#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.37916270f, 0.10693306f, 0.28674290f, -0.33764026f, -0.32182491f, -0.53404176f, -0.14023072f, -0.51419997f, 
    0.31362289f, 0.60847741f, 0.04053774f, 0.23849559f, -0.41091967f, 0.24878980f, 0.06720728f, 0.13307589f, 
    0.10481264f, 0.15609851f, -0.37747547f, -0.27538180f, -0.07442972f, -0.11943497f, -0.24076019f, -0.13199960f, 
    -0.09826082f, 1.02598751f, 0.38662988f, -0.36623684f, 0.84411728f, 0.96051776f, -0.00443380f, -0.23576710f, 
    0.07263172f, 0.55485314f, -0.00985359f, -0.30028734f, 0.15802754f, 0.21791150f, -0.14116102f, -0.23164882f, 
    -0.04255030f, -0.02970126f, -0.00319415f, -0.16942927f, -0.09940694f, 0.30174324f, 0.12739424f, 0.07494538f, 
    -0.01196096f, 0.09264011f, 0.19361740f, 0.56955397f, -0.35834906f, -0.39009920f, -0.31705174f, -0.64344674f, 
    0.40551779f, -0.02903193f, 0.30173644f, 0.51979476f, -0.69301921f, 0.18696238f, 0.41081801f, -0.29124260f, 
    -0.21485038f, -0.23520288f, -0.13744852f, 0.11383448f, 0.13069758f, -0.22004542f, 0.23147872f, 0.07194892f, 
    0.06754646f, -0.26882064f, 0.29534042f, 0.08115312f, 0.10576337f, 0.21377996f, 0.80469668f, 0.51945060f, 
    -0.03549637f, 0.43241838f, 0.43238986f, -0.07515609f, 0.21596195f, -0.24369116f, -0.41079089f, -0.63846028f, 
    -0.36891711f, -0.23530442f, -0.32590541f, -0.07879430f, -0.16830587f, -0.06949953f, -0.12077493f, 0.31132755f, 
    0.08469082f, -0.14964317f, -0.24550499f, 0.22474311f, 0.68133712f, 0.08917721f, 0.42286023f, 0.71027231f, 
    0.33722222f, -0.19155546f, -0.91419917f, -0.10210434f, -0.59213120f, -0.38979748f, 0.54439956f, 0.28923416f, 
    -0.13895899f, -0.02153411f, -0.13686250f, 0.20012651f, -0.18730660f, 0.00173759f, -0.13813108f, 0.37317026f, 
    0.15066870f, 0.08442912f, 0.39217493f, 0.03053163f, 0.12450575f, 0.80008608f, -0.28311899f, -0.61348838f, 
    -0.78477436f, 0.43119094f, 0.63839680f, -0.18519959f, -0.53331506f, -0.28874356f, -0.18551613f, -0.24870922f, 
    0.38906354f, 0.25624412f, 0.41222122f, 0.16504355f, -0.03555448f, -0.00209750f, -0.21505898f, 0.34923643f, 
    0.04054245f, 0.28470102f, 0.17920102f, -0.11837438f, -0.04374237f, -0.19634809f, -0.36524910f, -0.25596380f, 
    -0.87488067f, 0.26719788f, 0.68029094f, -0.15577386f, -0.07415590f, 0.21692510f, 0.19125219f, -0.37754452f, 
    0.18201463f, -0.35934579f, 0.00006057f, -0.17571060f, -0.38273165f, -0.09699539f, 0.26151335f, -0.43788099f, 
    -0.33861899f, -0.34009933f, 0.01750195f, -0.03272849f, 0.16561770f, -0.05827707f, -0.26174694f, -0.53123325f, 
    -0.94993871f, -0.23892289f, 0.39130396f, -0.44004729f, -0.32613063f, 0.17941053f, -0.01374296f, -0.73128909f, 
    0.30420393f, 0.26834282f, 0.04461540f, -0.11843923f, 0.29329678f, 0.43402919f, -0.38114101f, -0.43740886f, 
    0.26680392f, -0.14715056f, -0.43234828f, 0.35693005f, -0.44320762f, 0.10538378f, 0.10675895f, -0.10750372f, 
    0.50251967f, -0.82313448f, 0.25792563f, 0.19791342f, 0.11506479f, 0.12369806f, -0.77032477f, 0.19300711f, 
    0.19204178f, -0.35770327f, 0.10998182f, -0.40740979f, 0.26180571f, -0.38671824f, -0.46033639f, -0.25167120f, 
    0.11648386f, 0.54637569f, -0.24525797f, -0.14271301f, 0.17370577f, 0.27765745f, 0.26810077f, -0.00504549f, 
    -0.03537661f, -0.59215200f, 0.71812809f, 0.74072355f, 0.06858608f, 0.75618982f, 0.87139970f, -0.02628429f, 
    -0.83071315f, 0.03701264f, -0.64868563f, 0.09540538f, 0.10001150f, 0.07963049f, 0.21193767f, -0.30045712f, 
    -0.06152663f, 0.07833019f, 0.12478548f, -0.15358919f, 0.22956315f, -0.15954165f, -0.21248272f, -0.09512369f, 
    -0.07846273f, -0.11336579f, -1.06113410f, 0.61582619f, -0.28433123f, -0.61446106f, -0.82638210f, 0.75276756f, 
    0.42904779f, -0.58912754f, 0.33013284f, 0.55625969f, -0.34453222f, -0.17412996f, 0.14393221f, -0.24572869f, 
    0.04320045f, 0.21573786f, 0.10073370f, 0.14814755f, 0.08955625f, 0.05963309f, 0.00402492f, -0.24241215f, 
    0.18878089f, 0.15561438f, 0.14545016f, -0.65290457f, 0.64026845f, 0.55847633f, -0.70335686f, 0.18653046f, 
    -0.46245977f, -0.43247932f, -0.04904042f, -0.40981105f, 0.15554591f, 0.11743957f, 0.28344405f, 0.39816490f, 
    0.24112470f, -0.00229837f, -0.30430141f, -0.06986323f, -0.27851042f, -0.02199965f, 0.05191267f, -0.13267688f, 
    0.16481835f, 0.13512352f, -0.00055565f, 0.06070714f, 0.12881693f, -0.74056709f, 0.42318913f, -0.09606148f, 
    -0.13918240f, 0.58298200f, 0.51705372f, 0.18616651f, -0.53563350f, -0.22407889f, -0.10572415f, 0.40423137f, 
    -0.42805797f, 0.28782448f, 0.34346277f, 0.14112774f, -0.29418328f, -0.36229709f, -0.21380332f, 0.00514763f, 
    -0.06891524f, 0.29468292f, 0.45969713f, 0.19897562f, -0.15441005f, 0.34222028f, -0.46721661f, 0.46830425f, 
    -0.25804320f, 0.71093941f, 0.57349908f, -0.21767086f, -0.60085511f, -0.36900952f, -0.29863140f, 0.03398779f, 
    0.56907445f, 0.31652859f, 0.26430419f, 0.15678312f, 0.13555889f, 0.13274617f, 0.01048595f, 0.04822871f, 
    -0.11972430f, 0.15379314f, 0.04978167f, -0.03974845f, -0.06625950f, 0.37373653f, -0.09367888f, 0.69590420f, 
    -0.62502062f, -0.52604550f, 0.58344746f, 0.59478736f, -0.66033119f, 0.11177520f, -0.65208524f, 0.16782261f, 
    0.23506559f, 0.39114824f, 0.06938690f, 0.01850918f, 0.12380537f, -0.01174506f, -0.28482470f, 0.00796759f, 
    0.00570232f, 0.19276613f, 0.34221354f, -0.15625432f, 0.07162232f, -0.18469766f, -0.38359946f, -0.75505108f, 
    0.23867141f, 0.05594940f, 0.54153901f, 0.02802885f, -0.42907587f, 0.10333648f, -0.18094547f, 0.55219698f, 
    -0.20278876f, -0.16617441f, -0.05059511f, -0.38647270f, -0.05214084f, -0.15837041f, -0.13425989f, 0.38880441f, 
    0.52095723f, -0.33713838f, 0.23448306f, -0.31124231f, 0.10261892f, 0.10211904f, 0.35261884f, -0.23280559f, 
    -0.05952065f, -0.43179226f, -0.59362268f, 0.70684659f, 0.20339850f, 0.10426013f, -0.62278312f, -0.60630387f, 
    0.11682474f, -0.40804821f, 0.01329606f, 0.39354181f, 0.14356811f, 0.35899356f, 0.39270285f, 0.27813807f, 
    -0.07288761f, 0.04942368f, 0.22789480f, 0.31262285f, 0.12004305f, -0.17227653f, 0.35550857f, 0.08596063f, 
    -0.35342824f, -0.59335059f, -0.71039879f, -0.72628671f, -0.37675518f, -0.22405498f, -0.50441456f, -0.27185357f, 
    -0.33829600f, -0.06146608f, 0.55716521f, 0.25925216f, 0.19391195f, 0.36636361f, -0.00502439f, -0.00905454f, 
    0.03431667f, 0.14415918f, 0.07690284f, 0.08352032f, 0.48391083f, -0.38080004f, 0.04566085f, -0.32613793f, 
    0.19710974f, -0.14952226f, 0.50016439f, 0.76521444f, -0.58436894f, -0.01385279f, 0.86599213f, 0.04551469f, 
    0.22927694f, 0.51143062f, 0.39950043f, 0.42093530f, -0.10373911f, -0.04871808f, 0.18303873f, -0.17287906f, 
    0.06100881f, 0.26089805f, -0.03980204f, 0.17918524f, 0.13022621f, -0.18750113f, -0.05264848f, -0.14346793f, 
    0.26133603f, 0.10576525f, -0.06151045f, -0.54162872f, -0.09069887f, -0.51028502f, -0.64312005f, -0.23571193f, 
    0.17993549f, 0.42071685f, 0.25828239f, 0.45286366f, 0.56414759f, 0.14115697f, -0.28767633f, 0.28226376f, 
    -0.12751760f, -0.21773751f, 0.15699242f, 0.14939302f, 0.11044634f, 0.47270828f, -0.01863901f, -0.34609413f, 
    -0.27893198f, -0.27653655f, -0.27540991f, 0.24726157f, -0.68116236f, 0.30330887f, 0.40071243f, -0.17357668f, 
    0.45923108f, -0.60548782f, -0.19551130f, -0.21341695f, -0.15062933f, -0.50487202f, 0.42874569f, 0.45245132f, 
    -0.31745771f, 0.14348941f, 0.13693032f, -0.40704152f, -0.10145813f, -0.30232567f, -0.20065065f, 0.44204965f, 
    0.44808686f, 0.22100148f, 0.05182388f, 0.27714762f, -0.31660298f, 0.85127628f, 0.64096814f, -0.70882308f, 
    0.19314808f, 0.12662329f, 0.43217179f, 0.46797922f, 0.30809608f, 0.59565556f, 0.27557263f, -0.04449566f, 
    0.05464910f, -0.25966841f, 0.05487826f, -0.19347118f, 0.07202514f, 0.03214935f, -0.33094952f, -0.23426412f, 
    -0.13706575f, -0.26338923f, -0.15657048f, 0.12341525f, -0.03574185f, 0.17956741f, -0.06354014f, 0.53143638f, 
    0.91499424f, 0.47982731f, -0.03947962f, -0.40755084f, -0.05781605f, -0.36666715f, -0.12316770f, 0.18634439f, 
    -0.02602887f, 0.43781358f, 0.02974176f, 0.08879329f, 0.05536881f, 0.40604457f, 0.40638039f, 0.27516171f, 
    0.53729486f, 0.21701948f, -0.41980192f, -0.27258551f, 0.17284977f, -0.03891310f, 0.37684670f, -0.30553806f, 
    -0.50563258f, 0.45754993f, -0.46764162f, -0.81491143f, 0.71233910f, -0.19835870f, -0.22957005f, -0.17193952f, 
    -0.05428213f, -0.01122637f, 0.29888830f, 0.10804874f, 0.46128929f, 0.03794917f, 0.07328693f, 0.23695473f, 
    0.16950920f, -0.22257255f, 0.17056632f, -0.31376374f, -0.33880395f, -0.05015893f, -0.16732936f, -0.27859178f, 
    0.41845399f, -1.21462011f, 0.10333860f, -0.08824295f, -0.17782532f, 0.56063175f, 0.72284603f, 0.33169439f, 
    -0.35863408f, -0.19781196f, -0.33283883f, -0.25640577f, -0.44012305f, 0.00024729f, -0.01379055f, -0.19404046f, 
    -0.01799969f, -0.13500462f, 0.25884175f, -0.00793685f, -0.17836832f, -0.23896782f, -0.15226753f, -0.00141600f, 
    -0.06360503f, 0.47728306f, -0.46646735f, -0.05328873f, 0.88472390f, 0.00568841f, 0.01008120f, -0.52636170f, 
    0.49011660f, 0.42908055f, 0.11896217f, -0.16680211f, -0.42695478f, -0.24839909f, 0.23371163f, 0.00702658f, 
    -0.01116280f, 0.10769788f, -0.04468630f, -0.19739859f, 0.42742136f, -0.19135557f, 0.21860421f, 0.23930652f, 
    0.52784503f, -0.21794812f, 0.83313668f, 0.26193899f, -0.20983461f, -0.12630405f, -0.54059184f, 0.32860401f, 
    0.41008413f, -0.00268641f, 0.40080038f, 0.01534944f, 0.40817443f, 0.03040089f, 0.10890223f, -0.16452865f, 
    0.22482884f, 0.27095956f, -0.49062911f, 0.20056143f, -0.26266026f, 0.11711209f, -0.06628741f, -0.31879380f, 
    0.10348013f, 0.17113420f, -0.11861438f, 1.01929533f, -0.02729652f, -0.68216795f, -0.74731576f, 0.27601668f, 
    0.35183838f, -0.13350740f, 0.08690996f, 0.06637064f, 0.28026590f, -0.21899779f, -0.07950669f, 0.12402082f, 
    0.36064774f, 0.35713995f, -0.29618880f, -0.31146836f, -0.24660395f, -0.33252713f, -0.03099386f, 0.04671805f, 
    0.27155274f, 0.06592969f, 0.24575309f, -0.11157386f, 0.03135936f, -1.43034708f, -0.23980534f, 0.58340389f, 
    0.47812626f, -0.93636233f, 0.84696347f, 0.34508201f, -0.49907154f, 0.23976704f, 0.30374229f, 0.29457408f, 
    -0.00245699f, 0.04174303f, -0.02616675f, -0.46489552f, 0.03476647f, -0.23102297f, 0.16854876f, -0.24474575f, 
    -0.08981834f, 0.08307769f, -0.00647459f, -0.03361734f, 0.06787801f, 0.66815984f, 0.95030528f, 0.92982590f, 
    0.60655439f, 0.13450417f, -0.13807958f, 0.12068158f, -0.19531877f, -0.09254206f, 0.30467761f, 0.22190361f, 
    0.13697487f, -0.33421567f, 0.07885355f, -0.18292810f, 0.07466776f, -0.15533738f, 0.46248782f, -0.08813545f, 
    -0.36368328f, 0.21706933f, 0.03576376f, -0.35030517f, 0.32184720f, 0.25408486f, -0.04783853f, 0.14378616f, 
    0.04609949f, -0.30107087f, -0.44932458f, -0.62689751f, 0.22852112f, 0.35672739f, 0.64056921f, -0.93610168f, 
    -0.38112167f, 0.06777770f, 0.11723520f, -0.24717782f, -0.33127615f, -0.05541031f, -0.01624516f, 0.27719790f, 
    0.23854870f, -0.23176374f, 0.24803528f, -0.07161131f, -0.21925174f, -0.01008013f, -0.17892398f, -0.63585263f, 
    0.43303952f, -0.37066385f, -0.21658786f, -0.14933392f, -0.15219922f, -0.35747230f, -0.67582721f, -0.39353397f, 
    -0.24887298f, 0.41109437f, -0.35959721f, -0.43393201f, -0.47568604f, -0.40814966f, 0.17429067f, -0.33133328f, 
    -0.44842196f, -0.55546373f, -0.34253016f, 0.11050245f, 0.10584833f, -0.12726489f, 0.16666564f, -0.19330227f, 
    -0.00936863f, 0.08680206f, -0.00740239f, 0.17238358f, -0.07260004f, -0.34541824f, -0.85187054f, -0.68870735f, 
    -0.61653250f, -0.11481153f, -0.39284331f, -0.04753860f, 0.45096979f, 0.19662549f, -0.04553586f, 0.06954382f, 
    -0.04831018f, 0.31883174f, 0.19973043f, -0.06937730f, 0.17033432f, 0.04470321f, -0.03021169f, 0.10395539f, 
    0.25161910f, -0.27451792f, -0.80671775f, -0.75973147f, -0.54804283f, -0.07607511f, 0.12500271f, 0.22146687f, 
    -0.09696018f, -0.26134703f, 0.51981378f, 0.12757476f, -0.13070351f, -0.21390487f, -0.39283159f, -0.31887758f, 
    -0.05542968f, 0.22026028f, 0.48642853f, 0.14282683f, -0.44797996f, 0.07693008f, -0.31947500f, 0.12694594f, 
    0.18348616f, 0.21555167f, -0.04750498f, -0.54351079f, 0.21003811f, -0.48487756f, -0.25084203f, -0.31084830f, 
    -0.50132549f, -0.43095127f, 0.10953972f, 0.26278371f, 0.03483607f, -0.03098221f, -0.16691464f, -0.07927860f, 
    0.25851402f, -0.01863249f, 0.23026013f, 0.31065872f, 0.10566536f, -0.14802584f, 0.36718732f, -0.01049453f, 
    -0.04454420f, -0.01920036f, 0.05003428f, 0.22449118f, 0.69453835f, 0.24357586f, 0.15759343f, -0.02731750f, 
    0.44416559f, 0.29597804f, 0.60769993f, 0.39504620f, 0.33991829f, -0.47018141f, -0.28998581f, 0.07090771f, 
    -0.53121001f, -0.15424156f, 0.05868719f, 0.03701467f, 0.04819135f, -0.10932208f, -0.25599691f, -0.32207924f, 
    -0.18185169f, 0.18935521f, -0.22167091f, -0.21476288f, 0.41971332f, 0.43221921f, -0.45554355f, 0.85160834f, 
    -0.11452224f, 0.06122413f, -0.49352303f, -0.56032276f, -0.52594602f, 0.19802216f, 0.01234314f, 0.17587227f, 
    -0.10695956f, 0.18099914f, -0.38044021f, -0.00454415f, -0.05850970f, -0.10526293f, -0.13573785f, 0.23711446f, 
    -0.25535262f, 0.23166567f, 0.00122711f, 0.11414036f, -0.20892152f, -0.90952396f, 0.86514264f, 0.25425497f, 
    -0.67887914f, 0.27673757f, 0.19841726f, -0.49222368f, -0.49983454f, 0.22495776f, -0.36242980f, -0.16280968f, 
    -0.08926611f, -0.37451863f, 0.39282140f, -0.35801247f, -0.02544719f, 0.02869957f, 0.10910520f, -0.34887460f, 
    -0.22422916f, -0.06410217f, 0.22998951f, -0.02068639f, 0.12229771f, 0.10015915f, -0.64359146f, 0.47271362f, 
    -0.16460134f, -0.59717572f, -0.67609340f, 0.48496962f, 0.22309780f, -0.22073391f, 0.46223167f, 0.47240520f, 
    0.13334692f, -0.26402879f, -0.52323264f, 0.26544794f, 0.17998739f, 0.11130214f, -0.04745421f, -0.12324115f, 
    0.16015010f, 0.01038949f, -0.43003130f, 0.17854580f, -0.16426170f, -0.02234623f, -0.01569546f, 0.74379373f, 
    0.19286336f, 0.17687494f, 1.07830048f, 0.88412875f, 0.56057519f, 0.33619916f, -0.44299176f, -0.18248449f, 
    0.01989075f, -0.12155680f, -0.15744393f, -0.21610387f, -0.08096515f, -0.10119034f, -0.06857351f, 0.10095230f, 
    0.04539363f, -0.04018900f, 0.19519240f, 0.22274131f, 0.32617658f, 0.11863656f, -0.14101720f, 0.08641749f, 
    -0.66811830f, -0.89383227f, -0.53218931f, -0.33949557f, -0.35484809f, -0.73019803f, 0.30080771f, 0.42391416f, 
    0.45640180f, -0.32369009f, 0.12292824f, -0.06284264f, -0.01172467f, 0.12917052f, -0.05799876f, 0.21693382f, 
    -0.10342597f, -0.39537427f, 0.10893688f, -0.17320739f, 0.05264053f, -0.19965251f, 0.30554613f, -0.27085620f, 
    0.16610275f, -1.18157637f, 0.45727575f, -0.09946102f, -0.59045208f, -0.37090495f, 0.73244011f, 0.19689646f, 
    -0.16859424f, 0.59667546f, 0.28097984f, 0.28411430f, -0.07270685f, 0.25295621f, 0.29473457f, -0.12313499f, 
    -0.22949278f, -0.09522908f, -0.10774303f, -0.17937112f, -0.45634696f, 0.20644791f, 0.14927097f, 0.29851791f, 
    0.01154222f, -0.14467326f, -0.56761849f, -0.65279949f, -0.62946683f, -0.46302882f, -0.27330586f, -0.18976979f, 
    0.74834538f, 0.61276054f, 0.23882179f, 0.31507638f, 0.19701762f, -0.00334410f, 0.11354986f, -0.51071358f, 
    -0.22158413f, -0.10164989f, -0.07716984f, 0.24930476f, -0.22920376f, -0.14867903f, -0.04526684f, -0.01921461f, 
    0.07852754f, -0.14536631f, 0.14681603f, 0.82285130f, -0.29919100f, 0.59606040f, 0.36290991f, 0.19808297f, 
    0.07718451f, -0.39721787f, -0.50396204f, 0.18538116f, 0.46027648f, -0.10431906f, 0.34612340f, -0.06709250f, 
    0.26432127f, -0.25192505f, -0.26784837f, -0.28731400f, 0.13100962f, 0.13095494f, 0.02444242f, 0.08662869f, 
    0.55855751f, -0.11719815f, -0.31188622f, -0.17303433f, 0.46168503f, 0.38626930f, 0.47381309f, -0.07424828f, 
    -0.17204361f, 0.47509718f, 0.11356887f, -0.08039129f, 0.02475258f, 0.62154067f, 0.14750336f, 0.12012113f, 
    0.04401497f, -0.45353168f, 0.05270968f, -0.38183624f, -0.37763825f, 0.17255057f, 0.20211169f, -0.31236044f, 
    0.09033344f, 0.49245015f, 0.00145564f, 0.05631763f, 0.39086241f, 0.12009436f, 0.28160226f, -0.35499808f, 
    -0.53999913f, -0.25905615f, -0.51017576f, -0.52419841f, -0.59701705f, -0.43426016f, -0.37515423f, 0.29646936f, 
    0.09690493f, 0.13486935f, 0.01496109f, 0.02330160f, -0.26738018f, 0.24235831f, -0.37998199f, 0.22650154f, 
    0.35576859f, 0.02057609f, 0.23154491f, 0.61253494f, -0.21678169f, 0.29323491f, 0.70774806f, 0.14296785f, 
    0.34409672f, 0.81098664f, 0.76967943f, 0.04005237f, 0.15908924f, 0.33454880f, 0.28284875f, -0.12518968f, 
    0.10240627f, -0.05153401f, 0.11799547f, 0.34306005f, -0.23003563f, 0.32135597f, -0.17573909f, 0.12399412f, 
    -0.12762800f, 0.00678250f, 0.00365728f, -0.30053982f, 0.12352495f, -0.04499352f, 0.21602698f, -0.57637656f, 
    -1.05317140f, -0.48677960f, 0.09274984f, 0.31867018f, 0.50848228f, 0.74162543f, -0.16804633f, 0.24333447f, 
    0.31355667f, -0.16388990f, 0.16526972f, -0.29367745f, 0.54254305f, 0.35626233f, -0.03410352f, 0.33779806f, 
    -0.10478755f, 0.26600069f, -0.04505019f, 0.28187412f, 0.02291521f, -0.19035056f, -0.11432366f, 0.15012291f, 
    -0.18434429f, 0.41528517f, -0.60259885f, -0.69980550f, -0.65037048f, 0.66484362f, -0.20696709f, 0.26437792f, 
    0.38782233f, -0.00142181f, -0.62215096f, -0.39301273f, -0.44561428f, -0.28659716f, -0.38248155f, -0.14600140f, 
    -0.02716371f, 0.04159055f, -0.17104781f, -0.03255276f, 0.16231114f, -0.00202011f, -0.22587864f, -0.07548830f, 
    0.18283032f, -0.28375250f, 0.34215960f, -0.29463834f, 0.50134486f, 0.75490272f, 0.54148310f, 0.36894318f, 
    0.68923038f, 0.12839691f, -0.52551633f, -0.35635203f, -0.35300738f, -0.04280983f, -0.24422616f, 0.33429053f, 
    -0.48157009f, -0.24965274f, 0.07201011f, 0.07261920f, 0.04501443f, 0.14566480f, -0.35730472f, -0.01917496f, 
    0.04340710f, -0.03349579f, -0.44309115f, -0.11229333f, -0.09696618f, -0.41272771f, 0.69424772f, 0.55585629f, 
    -0.52928203f, -0.61618817f, -0.32206371f, -0.33335426f, -0.00173943f, 0.34160355f, 0.27551821f, -0.37630382f, 
    -0.22950253f, -0.28618851f, -0.32593617f, 0.26068678f, -0.53100246f, -0.01148956f, 0.26492769f, -0.18658598f, 
    -0.02311236f, -0.29203486f, -0.06026546f, -0.20026183f, -0.60387903f, 0.66984802f, 0.10451010f, -0.81935251f, 
    -0.32752225f, -0.62389684f, -0.07082450f, 0.11146978f, 0.11718867f, 0.32179344f, 0.31840494f, 0.09556878f, 
    -0.07993865f, 0.39677900f, -0.05170614f, -0.21955556f, -0.32077369f, 0.02304756f, -0.42366934f, 0.21252723f, 
    0.30507100f, 0.19386402f, -0.17140281f, 0.20743647f, 0.26876193f, 0.23270300f, 0.56139475f, 0.49340478f, 
    0.51134032f, -0.12867418f, 0.30722541f, 0.05753372f, 0.28160149f, -0.30787036f, 0.26005813f, -0.04687509f, 
    -0.01412359f, 0.33031282f, 0.20001617f, -0.36301523f, -0.28861913f, -0.40158060f, 0.02661183f, -0.24809849f, 
    -0.57610953f, -0.01971534f, -0.33879369f, 0.19325501f, 0.07697551f, 1.06653166f, 0.72688389f, -0.36831194f, 
    -0.03007531f, -0.47882077f, -0.66593003f, -0.24472989f, -0.47416914f, 0.27125716f, -0.43813688f, 0.18387954f, 
    -0.13095401f, -0.21387710f, -0.22661082f, -0.29506874f, -0.14885984f, -0.17379785f, -0.25101215f, -0.10161713f, 
    -0.18763050f, 0.21033363f, 0.39511773f, 0.01453904f, 0.14229262f, 0.13426751f, -0.09242384f, -0.50729674f, 
    -0.61828470f, -0.59656584f, 0.00820011f, 0.64546150f, 0.87019509f, -0.14039470f, 0.48059151f, 0.50263321f, 
    -0.14531508f, -0.16664344f, -0.48222485f, -0.18451624f, -0.23005456f, -0.00022328f, -0.05547896f, 0.12988627f, 
    -0.11375362f, 0.07217496f, 0.02120523f, 0.02677853f, 0.02848581f, -0.04721100f, 0.12563749f, 1.07368302f, 
    0.03822010f, 0.45210972f, 0.56385309f, 0.88105482f, -0.46268046f, 0.06653906f, 0.07574953f, 0.10219808f, 
    0.15613793f, 0.30239347f, 0.01789642f, 0.12943552f, 0.01318077f, 0.20211816f, -0.09798267f, -0.09791330f, 
    0.11794869f, 0.45088109f, 0.04312227f, 0.22880657f, -0.02290402f, 0.05432929f, 0.06369882f, -0.01349498f, 
    0.58041209f, 0.47835439f, -0.47583863f, -0.97354519f, -0.55077112f, 0.05727584f, 0.34232590f, 0.22205317f, 
    0.31283757f, -0.18761010f, -0.13421361f, -0.00746950f, -0.14317843f, 0.07082482f, 0.09655483f, 0.21176539f, 
    -0.12357521f, 0.36156401f, 0.27065158f, 0.31054923f, 0.37430152f, -0.50093824f, 0.20148620f, -0.10425013f, 
    0.26699221f, -0.28797948f, -0.87222749f, 0.07248808f, -0.18033087f, -0.40822858f, 0.46552968f, -0.58074862f, 
    0.55999815f, 0.47820666f, 0.15333451f, 0.43060300f, -0.42064878f, -0.05662147f, 0.32993197f, 0.14606792f, 
    0.10288855f, 0.14367847f, -0.26728168f, 0.25234425f, 0.13055284f, 0.16151424f, -0.05447344f, -0.08479562f, 
    -0.18509308f, -0.19940294f, 1.17965090f, 0.13861346f, -0.34028918f, 1.01547718f, -0.45971516f, -0.31348175f, 
    0.17431724f, 0.16138820f, -0.22394152f, 0.28273058f, -0.01798201f, -0.28405574f, 0.18211423f, -0.34136936f, 
    0.12255186f, 0.31045774f, -0.06384710f, 0.29811791f, 0.12583545f, 0.29904360f, 0.27572596f, -0.02148687f, 
    0.08517747f, -0.09684510f, 0.13305871f, 0.67267519f, 0.84604186f, -0.22324182f, -0.48655045f, -0.64198935f, 
    0.57035202f, -0.05212968f, -0.52779549f, 0.07595250f, -0.13705194f, 0.42622134f, 0.43527976f, 0.37386444f, 
    0.16105013f, 0.02085133f, -0.12824282f, -0.02606543f, -0.01998311f, 0.15412891f, 0.15301098f, 0.21831131f, 
    0.11412510f, 0.15051508f, -0.04035597f, 0.15472730f, 0.57054216f, 0.74191171f, 0.89807165f, -0.89861643f, 
    -0.17411995f, 0.29467002f, -0.16380221f, 0.42218834f, -0.07229839f, -0.16868614f, 0.30241469f, 0.37604609f, 
    0.05075664f, 0.04347235f, -0.15515319f, 0.40279022f, 0.00043914f, 0.21711516f, 0.12344483f, -0.00921081f, 
    0.05334501f, -0.03017930f, -0.09287889f, -0.30754164f, 0.34253892f, -0.92048687f, -0.79197907f, 0.48269165f, 
    0.81694835f, 0.27581078f, 0.02685956f, 1.05875897f, 0.24533117f, 0.25489452f, 0.33584365f, -0.19600730f, 
    -0.20861456f, 0.06327973f, -0.09398919f, 0.05971342f, -0.01310896f, -0.10169435f, -0.01183661f, -0.16596894f, 
    -0.25114080f, -0.08865542f, -0.00592199f, -0.25717726f, 0.26282042f, -0.50235897f, 0.05902173f, 0.87604290f, 
    0.64964885f, 0.26893717f, 0.59651369f, -0.94124031f, 0.06231755f, -0.56441170f, -0.09092227f, -0.23617613f, 
    0.07945468f, -0.00049383f, -0.06934690f, 0.02284440f, 0.42823750f, 0.18504266f, -0.12828700f, -0.19225438f, 
    0.13475615f, 0.16980594f, -0.09337982f, 0.12742820f, 0.24920645f, 0.02181618f, -0.01978994f, 0.63485461f, 
    0.76700169f, 0.48272628f, -0.19757825f, 0.91147089f, 0.28413484f, -0.55380255f, 0.04971087f, 0.00927504f, 
    0.36698812f, -0.23186445f, -0.21055603f, -0.15922301f, 0.32253003f, 0.14352188f, 0.05256896f, -0.03322937f, 
    -0.22076586f, -0.00741807f, -0.20265177f, 0.19765276f, 0.08619601f, -0.08305845f, -0.12401479f, 0.10900493f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19487628f, 0.02282602f, 0.07562624f, 0.01447137f, 0.04287771f, 0.16551130f, 0.07726576f, 0.09571068f, 
    0.03732326f, 0.09286904f, -0.06683579f, 0.07952698f, 0.20400277f, 0.15398982f, 0.06983498f, -0.01369735f, 
    0.12228753f, 0.28248468f, 0.23918274f, 0.13083194f, 0.08661288f, 0.09790380f, 0.08975779f, 0.11035635f, 
    0.28438243f, 0.04768167f, 0.25901863f, 0.09704168f, 0.26204515f, 0.14653693f, 0.17567454f, 0.04995010f, 
    0.15205629f, 0.08995337f, 0.16633233f, 0.08864302f, 0.05602355f, 0.03451188f, -0.08551267f, 0.17633814f, 
    0.10872200f, 0.04769509f, 0.01041937f, 0.23453403f, 0.02707279f, 0.07445172f, 0.31942591f, 0.02385458f, 
    -0.11923173f, 0.05591684f, 0.18093634f, 0.28298301f, -0.02126569f, 0.21349411f, 0.02200824f, 0.08647595f, 
    0.14558828f, 0.20901401f, 0.19735098f, -0.02325131f, 0.21452186f, 0.16180788f, 0.33542290f, 0.18846025f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12872194f, -0.15304512f, 0.01641282f, 0.05217712f, -0.01731113f, -0.07863451f, -0.03206334f, -0.01821750f, 
    0.02915556f, 0.08810631f, -0.04080347f, 0.01754941f, 0.16660294f, 0.05794577f, 0.12087183f, 0.24531169f, 
    -0.07064177f, 0.14168926f, -0.01769439f, 0.03388517f, -0.04868789f, 0.10124062f, 0.11287104f, 0.02111454f, 
    -0.08004208f, -0.08606455f, -0.10826427f, -0.23227751f, 0.04257524f, 0.03187146f, -0.06333055f, -0.06666075f, 
    0.06451017f, 0.05080970f, -0.00154954f, -0.01118935f, 0.04194188f, 0.09967288f, 0.06812293f, 0.08215491f, 
    -0.11141624f, 0.04821432f, -0.01064661f, -0.05651873f, -0.13424525f, -0.03286657f, -0.00613692f, 0.05738855f, 
    0.20758601f, -0.07933829f, -0.00711118f, 0.11058231f, -0.17606695f, -0.03439339f, -0.10414925f, 0.09765848f, 
    -0.00212738f, -0.06189584f, -0.08292788f, -0.09537786f, -0.10350696f, -0.15143184f, 0.19005316f, -0.43775594f, 
    0.01688704f, 0.02806848f, 0.07526974f, -0.13617663f, -0.01782058f, -0.00126976f, 0.02725213f, 0.03944576f, 
    -0.18368669f, 0.14687279f, 0.16171801f, 0.06171819f, -0.04446546f, 0.09540121f, -0.12542310f, -0.05322314f, 
    -0.01408021f, 0.06004453f, -0.04471665f, -0.19576775f, -0.21554369f, -0.08890706f, -0.20784029f, 0.14819717f, 
    0.06812578f, -0.00582600f, -0.00177420f, -0.01192781f, 0.07539542f, -0.03514942f, -0.09799184f, -0.07750744f, 
    0.17446564f, -0.07718561f, 0.03897731f, 0.15440616f, 0.04498231f, 0.15442978f, -0.00501887f, -0.02347855f, 
    -0.11392512f, 0.12853639f, -0.16394806f, -0.07823598f, -0.31049398f, -0.07167263f, -0.01580759f, -0.04888635f, 
    -0.09004941f, -0.09292081f, 0.07957590f, -0.00149143f, 0.04540964f, 0.01778710f, -0.07376412f, -0.01138520f, 
    0.67669117f, 0.05060127f, -0.03959944f, -0.15104324f, 0.08598259f, 0.05705016f, -0.01832243f, -0.01643873f, 
    0.01988507f, -0.03741787f, -0.00472571f, 0.03819022f, -0.50057447f, 0.06651771f, 0.08463159f, 0.00088191f, 
    0.06871479f, 0.00410655f, -0.04138316f, 0.09685006f, 0.11717037f, -0.11918392f, 0.04400428f, 0.05333541f, 
    -0.19975589f, -0.01087697f, 0.13226157f, -0.14887656f, 0.05052825f, 0.04246189f, -0.08214778f, -0.00987009f, 
    -0.00187495f, 0.03392230f, 0.22307633f, -0.06671628f, -0.08214528f, -0.21610625f, 0.12465619f, -0.19411799f, 
    -0.03458262f, 0.08083789f, 0.00557919f, -0.04577852f, -0.07414236f, 0.08496234f, 0.12704314f, -0.03843458f, 
    0.01223611f, -0.12421697f, 0.30337226f, -0.07723580f, -0.01170351f, 0.03590298f, 0.08828388f, -0.09468165f, 
    0.18762024f, -0.04929574f, 0.00748915f, 0.00329635f, -0.16521172f, 0.04843042f, -0.18005481f, 0.12511277f, 
    0.08343944f, -0.03927055f, 0.03014323f, 0.06301232f, 0.00963054f, 0.08288021f, 0.00623058f, 0.03378795f, 
    0.07219609f, -0.05947046f, 0.05169970f, 0.11296331f, 0.10884336f, 0.04653338f, 0.05784021f, -0.04091729f, 
    -0.03057609f, -0.21450616f, -0.01443856f, -0.10105454f, -0.16342044f, -0.23670849f, -0.11567529f, 0.01601384f, 
    -0.12553808f, -0.06745240f, 0.00257048f, 0.02281870f, -0.06612873f, -0.05958335f, -0.02352199f, -0.12982537f, 
    -0.01512004f, 0.07675278f, 0.15874253f, -0.03417452f, -0.12386812f, 0.01189659f, 0.03954707f, -0.00259550f, 
    -0.11034089f, 0.05840315f, -0.04641394f, -0.02577422f, 0.23466027f, 0.15656938f, -0.08033617f, -0.26621413f, 
    0.04634419f, -0.00716166f, 0.01341815f, 0.08366855f, 0.07717270f, 0.01045200f, -0.05963903f, 0.02972375f, 
    -0.18898462f, 0.03110943f, 0.10616502f, 0.00594279f, -0.00210885f, 0.04026378f, 0.02559103f, -0.01429687f, 
    0.07086249f, -0.17894053f, 0.09697167f, 0.04586819f, -0.01142807f, 0.03390640f, 0.05920483f, -0.06040294f, 
    -0.06212750f, 0.04467902f, -0.00917453f, 0.13247366f, -0.15702485f, 0.04997669f, 0.01930343f, -0.12830988f, 
    -0.15250060f, 0.09940562f, -0.11249217f, 0.03830303f, -0.08126920f, -0.02962456f, -0.02857563f, 0.05411410f, 
    0.05813889f, 0.05838801f, -0.07702211f, 0.04194775f, -0.11962546f, 0.04388186f, 0.06343264f, -0.03675610f, 
    0.03283411f, -0.11868393f, -0.01072385f, -0.03257389f, -0.19154148f, 0.07740229f, -0.07414234f, -0.05883686f, 
    -0.01244893f, 0.05983075f, 0.13282603f, -0.12491777f, 0.01279325f, -0.10635262f, 0.04899058f, 0.02100915f, 
    -0.01657729f, 0.02676707f, 0.06054083f, -0.01876709f, 0.13376112f, -0.06623405f, -0.02650354f, 0.35560516f, 
    -0.10180637f, 0.03719474f, -0.10570848f, -0.04721904f, -0.16217078f, -0.11576229f, -0.00526986f, 0.05150840f, 
    -0.05127366f, 0.04924317f, -0.07206320f, -0.12966646f, -0.13465466f, 0.04086482f, -0.07891309f, 0.03271020f, 
    -0.03150785f, 0.00761673f, 0.00344595f, -0.07791191f, 0.19366623f, -0.15064694f, 0.03491145f, -0.25470436f, 
    -0.04924913f, -0.09598962f, 0.06085009f, 0.06917743f, -0.08960550f, -0.01170535f, 0.05208337f, -0.02347466f, 
    -0.04289388f, -0.01447177f, -0.15839635f, 0.13270982f, -0.07742893f, -0.01406476f, -0.01852930f, -0.05722300f, 
    -0.04247371f, 0.06437492f, -0.07947964f, 0.07457698f, -0.02297222f, 0.02976628f, -0.09240489f, 0.10372086f, 
    -0.24719536f, -0.20431294f, 0.05098987f, 0.01680440f, -0.07597298f, 0.03050519f, -0.08625879f, -0.15923248f, 
    -0.12807937f, 0.22684717f, -0.07748482f, -0.01706352f, 0.04737467f, -0.02626954f, -0.10246661f, -0.10774664f, 
    0.05745387f, -0.00159120f, 0.07673454f, 0.04477685f, -0.13952468f, -0.18841918f, 0.07586613f, 0.09473948f, 
    -0.07991766f, 0.01907022f, -0.08445717f, 0.06532141f, 0.04670379f, 0.10341612f, 0.07234696f, -0.07511511f, 
    0.01362465f, 0.09080666f, 0.15850322f, 0.08874907f, -0.03151776f, 0.01423277f, 0.04610977f, 0.00233382f, 
    -0.11637163f, -0.00725010f, -0.12620823f, 0.07988918f, -0.08201151f, -0.10327183f, 0.00533651f, -0.27272144f, 
    0.08975609f, -0.02741369f, -0.00207721f, 0.19877334f, -0.11857322f, 0.05562413f, -0.06481647f, 0.00992600f, 
    -0.05352808f, -0.13776200f, -0.01729460f, -0.09698208f, -0.04497648f, -0.02322827f, -0.02120604f, 0.00785025f, 
    -0.07878715f, 0.01299623f, -0.14896081f, 0.03207018f, -0.00431650f, 0.03714683f, -0.00243097f, 0.05148616f, 
    -0.16653006f, 0.01292419f, 0.03343422f, 0.00167088f, 0.00691582f, -0.04286527f, 0.03775044f, -0.01533752f, 
    0.24248053f, 0.08024460f, 0.05047560f, 0.11335381f, -0.13748398f, 0.08593492f, -0.11853230f, 0.04767741f, 
    -0.09982707f, 0.01064917f, 0.00753078f, -0.04140573f, -0.36702508f, 0.03277351f, 0.12255764f, -0.12192322f, 
    0.06978176f, -0.00804380f, 0.00145510f, -0.05123071f, 0.13545604f, 0.02499889f, -0.11562056f, -0.02890594f, 
    0.45611978f, -0.08721104f, -0.06525827f, -0.18762770f, -0.04255291f, 0.08068972f, 0.15642449f, -0.05894279f, 
    0.08973026f, 0.07208370f, -0.02240959f, 0.02985445f, 0.09970587f, -0.13749914f, 0.02220987f, 0.31635687f, 
    -0.15672274f, -0.04256583f, -0.05208788f, 0.02867085f, -0.10023413f, 0.05425907f, -0.03879121f, -0.02070130f, 
    -0.11413077f, 0.09427511f, -0.12377978f, -0.09876892f, -0.08141103f, -0.08727799f, 0.05209463f, 0.03423394f, 
    0.13447239f, 0.02660510f, -0.10424909f, -0.04357915f, 0.39079514f, -0.11109181f, -0.05432848f, -0.09821090f, 
    0.14347741f, 0.01375895f, -0.04027123f, 0.02032038f, 0.03287318f, -0.06576198f, -0.00886868f, 0.00175314f, 
    -0.01143005f, 0.19921963f, 0.03438062f, -0.36633649f, 0.11253126f, -0.00386509f, 0.01529779f, 0.02155028f, 
    -0.03117958f, 0.03366461f, -0.01099439f, 0.07054703f, 0.18799701f, -0.11151241f, -0.07806472f, 0.14446618f, 
    -0.00624029f, -0.03022402f, -0.00080624f, -0.00631750f, -0.13570735f, 0.08986966f, -0.07793444f, 0.02251326f, 
    0.01862001f, 0.03092870f, 0.00374214f, 0.05847917f, 0.04547825f, 0.03462836f, 0.01908102f, -0.10528598f, 
    -0.09436686f, 0.02504595f, -0.14269765f, 0.03839984f, -0.21148741f, -0.11502405f, 0.03691073f, -0.01384755f, 
    -0.02326361f, -0.00562131f, 0.06417958f, 0.08948902f, -0.02760605f, -0.16771249f, -0.01841312f, -0.08491888f, 
    0.04301067f, 0.04843140f, -0.05043522f, 0.15941678f, -0.11721830f, 0.00152679f, -0.03827034f, 0.03278345f, 
    -0.01459974f, 0.05080196f, -0.02907530f, -0.05723099f, -0.18517730f, -0.00424644f, 0.15192084f, -0.00105569f, 
    0.09875783f, 0.06988696f, -0.00865561f, -0.01822095f, 0.12476215f, -0.01357473f, -0.02354222f, 0.17182976f, 
    0.32738298f, -0.02627423f, -0.04432203f, -0.20416364f, 0.08485703f, 0.05267704f, 0.03661299f, -0.01761587f, 
    -0.06305075f, 0.07579050f, -0.10260088f, 0.02238546f, -0.13264160f, 0.06346922f, 0.03477177f, -0.05355742f, 
    -0.10615093f, 0.01595091f, 0.01838163f, 0.00497496f, 0.00647539f, 0.00428563f, -0.02321595f, 0.01573740f, 
    -0.23447567f, -0.34963956f, 0.14860901f, -0.07695306f, -0.03957944f, 0.04001031f, 0.03791846f, -0.02572806f, 
    -0.02928293f, 0.03216165f, 0.01477939f, -0.05452104f, -0.09969909f, -0.15309912f, -0.05051237f, 0.24502642f, 
    0.05991589f, 0.00807958f, -0.00149463f, -0.06117349f, 0.01235001f, 0.03198687f, -0.01197219f, 0.04217094f, 
    0.09209599f, -0.01597995f, -0.03551883f, 0.02252140f, -0.16592580f, -0.13393432f, 0.05391927f, -0.00961755f, 
    0.07422895f, 0.01488531f, 0.02866107f, -0.02052750f, -0.08828297f, 0.06160669f, 0.01685765f, -0.08309713f, 
    0.01223123f, -0.04216073f, -0.05233479f, 0.02881552f, 0.06456500f, -0.15554486f, 0.01888401f, -0.02509596f, 
    0.07838506f, 0.20099941f, 0.12786469f, -0.14637055f, 0.07778423f, 0.04183049f, 0.10436895f, -0.04416892f, 
    0.00530018f, 0.08092409f, 0.02882449f, 0.13295572f, 0.26321003f, -0.00012612f, -0.09220824f, 0.11703667f, 
    -0.16812597f, -0.02097969f, -0.06115506f, 0.03663127f, -0.04293507f, -0.02316184f, 0.01446236f, 0.01360083f, 
    -0.02974169f, 0.16546525f, -0.11145325f, -0.44143713f, -0.05210178f, -0.06708370f, 0.02181454f, -0.06492876f, 
    -0.14783187f, 0.04710506f, 0.09503982f, 0.07329198f, 0.12213504f, -0.20754133f, -0.07051470f, 0.07117145f, 
    0.05437056f, -0.04313072f, -0.03108255f, -0.06471011f, -0.01268183f, -0.01360437f, 0.08139261f, -0.01187133f, 
    0.09411669f, 0.08023882f, -0.05486850f, 0.26606971f, -0.09846650f, 0.00766739f, -0.10357546f, 0.03717175f, 
    -0.02571066f, -0.00570188f, 0.03329518f, -0.01575905f, -0.22130135f, -0.00339659f, 0.02618603f, -0.10220616f, 
    -0.07295308f, 0.03591430f, 0.07327510f, 0.02257629f, 0.03659785f, -0.02335036f, 0.04747098f, 0.10859509f, 
    -0.20637888f, 0.12145088f, 0.13957217f, -0.34063607f, -0.01566704f, -0.01250938f, 0.01108488f, -0.01500695f, 
    0.00309211f, -0.02154712f, 0.00579115f, -0.04934584f, -0.12905748f, 0.15151422f, 0.03587586f, 0.21295175f, 
    -0.09700866f, 0.07010917f, 0.12243374f, -0.07829656f, 0.00372102f, -0.13613226f, -0.07677403f, -0.00825971f, 
    0.02978062f, 0.06057816f, -0.11025785f, -0.14282076f, -0.05320595f, -0.05636001f, -0.01707272f, 0.00753848f, 
    -0.06533433f, 0.04609855f, -0.20942403f, -0.06596158f, 0.17519492f, -0.03451949f, 0.16297419f, -0.22714710f, 
    -0.05378895f, -0.02039910f, 0.06966090f, 0.00377305f, 0.10093351f, -0.06665854f, 0.00966554f, -0.19239612f, 
    0.08084358f, 0.00321563f, -0.13567296f, -0.00805763f, 0.00984350f, -0.07799536f, -0.04005934f, -0.03872545f, 
    -0.02001829f, -0.09225189f, -0.02203885f, -0.06274661f, 0.19355355f, -0.12784749f, 0.00848451f, 0.31338415f, 
    -0.02576865f, -0.04485720f, -0.03698597f, 0.02472052f, 0.00281011f, -0.10268208f, -0.11207324f, -0.07917842f, 
    0.01635766f, 0.03245879f, 0.01285213f, -0.15638447f, 0.04692813f, -0.16222613f, -0.04283794f, 0.09288821f, 
    -0.12711012f, -0.18418960f, 0.06913862f, -0.01730288f, 0.15471296f, -0.00287317f, -0.10501502f, 0.27945435f, 
    0.02008449f, 0.10190884f, 0.04950990f, 0.02680888f, 0.05169600f, 0.13099983f, -0.08566306f, -0.12904713f, 
    -0.08389812f, -0.00822698f, 0.25090787f, 0.09127790f, 0.08698719f, -0.00521170f, 0.07631350f, 0.01997923f, 
    0.02774813f, 0.05534965f, 0.04519466f, 0.09721567f, 0.23884821f, -0.28933856f, 0.12534459f, -0.18007861f, 
    -0.08676866f, -0.03998545f, 0.06624400f, -0.02914714f, -0.12098255f, 0.06032915f, -0.02347261f, -0.04739886f, 
    0.13498005f, -0.08438949f, -0.11261497f, -0.08354541f, 0.06571409f, 0.05129472f, 0.04308864f, 0.09603615f, 
    -0.00012176f, -0.13094096f, -0.13206410f, -0.12360499f, -0.05392436f, 0.09258331f, -0.11799974f, 0.15262416f, 
    -0.14931025f, -0.01005557f, -0.15884733f, -0.01453357f, -0.08589971f, -0.12093082f, 0.06668404f, 0.07787362f, 
    -0.30974451f, -0.11904249f, 0.08354195f, -0.08520469f, -0.04669728f, 0.03624851f, 0.06561234f, -0.06993416f, 
    0.16880842f, -0.11221767f, 0.02974258f, 0.00791719f, 0.08661807f, -0.07831594f, 0.03148158f, 0.01745770f, 
    -0.02931171f, 0.07175510f, 0.00344715f, -0.12649107f, -0.02713683f, -0.00726272f, 0.11994860f, -0.04014217f, 
    -0.59468669f, -0.11744232f, 0.05690879f, -0.18561471f, 0.02907787f, -0.07834702f, -0.02468070f, 0.08834943f, 
    0.14272505f, -0.00684338f, 0.02567145f, 0.02438072f, -0.15514919f, -0.01356874f, 0.02608893f, -0.12587346f, 
    -0.04058335f, -0.05601446f, 0.08588365f, -0.00088264f, -0.00779245f, 0.19783165f, -0.02468562f, -0.07987051f, 
    0.13210553f, 0.01030585f, -0.11222228f, -0.00143505f, -0.02902195f, 0.03348954f, 0.03847820f, -0.13999952f, 
    -0.06674270f, 0.04262628f, -0.17203498f, 0.02402946f, -0.05477252f, -0.05168546f, 0.12789062f, -0.07617303f, 
    -0.08083421f, 0.00558415f, -0.07830002f, 0.07639751f, 0.07978544f, -0.05022587f, -0.06451812f, -0.03448450f, 
    0.07845528f, -0.01712318f, 0.07919107f, -0.22596078f, -0.11227138f, -0.19916087f, -0.03331608f, -0.00117773f, 
    0.11584943f, 0.07810597f, -0.07026292f, -0.03729718f, -0.00581668f, -0.11780345f, -0.37757388f, -0.07484550f, 
    0.05060574f, 0.07554480f, 0.06388058f, -0.07716481f, -0.01989339f, -0.13685346f, 0.09314211f, -0.00611467f, 
    -0.11457580f, -0.10159983f, -0.05720779f, -0.03035908f, -0.02690515f, -0.04688343f, 0.02703686f, 0.08001234f, 
    -0.04399196f, 0.20062417f, 0.03672492f, 0.17670561f, 0.14915079f, 0.05959463f, 0.04515431f, -0.03866057f, 
    0.06743106f, -0.09921530f, 0.12662981f, -0.02035712f, -0.04567054f, 0.03241771f, 0.12562370f, 0.06580754f, 
    0.13038513f, -0.03211891f, 0.06276572f, -0.01508742f, 0.07391946f, -0.04402680f, -0.07761957f, 0.03010794f, 
    0.06667741f, -0.00027634f, -0.03154808f, 0.02847207f, 0.06660549f, 0.02626365f, 0.02635169f, -0.14723343f, 
    0.10008387f, -0.00068421f, -0.01628420f, -0.05034996f, -0.04984441f, -0.01458449f, -0.02068526f, 0.05879925f, 
    -0.25236332f, -0.01719077f, -0.10174916f, -0.05631420f, 0.06284594f, -0.06339905f, -0.03696635f, 0.02436623f, 
    -0.05413489f, 0.02944532f, 0.01440960f, -0.12442988f, 0.29484266f, -0.09111236f, 0.12840146f, 0.10865083f, 
    -0.03629163f, -0.07430170f, -0.18187460f, 0.00530841f, -0.00593897f, -0.03541239f, 0.04649881f, 0.10490292f, 
    0.04173972f, 0.01499179f, -0.09093943f, 0.12132492f, -0.02499183f, 0.04541301f, 0.02134539f, -0.08161741f, 
    0.11113776f, -0.09037940f, 0.01034267f, -0.01707749f, -0.17972082f, 0.12957290f, -0.09108015f, 0.07026563f, 
    0.03543633f, 0.07315297f, 0.21041779f, -0.18250105f, 0.03378602f, -0.02342639f, 0.07758631f, 0.06058354f, 
    0.25520006f, -0.13999665f, 0.00036260f, 0.08684294f, 0.05883658f, 0.05785498f, -0.02704027f, -0.04365705f, 
    0.07486635f, 0.03155988f, -0.10035183f, -0.02846318f, 0.07891260f, 0.04714527f, 0.00352587f, 0.07019113f, 
    -0.07420172f, -0.02402825f, -0.02370921f, -0.01080993f, 0.16050687f, 0.08799261f, 0.05732752f, 0.13207239f, 
    0.24264613f, -0.19363998f, 0.08894050f, -0.01124933f, -0.10815406f, -0.03006375f, 0.02963079f, 0.04549777f, 
    -0.00482032f, 0.01551381f, 0.01370150f, 0.11538490f, 0.18089277f, -0.29537183f, 0.10058320f, -0.22421210f, 
    0.05045642f, -0.08340108f, 0.00501463f, -0.03074918f, -0.20274805f, -0.06239811f, -0.13654251f, 0.03715527f, 
    0.06446793f, -0.24271771f, 0.04995099f, 0.10624816f, -0.09186765f, -0.04039948f, -0.03293621f, 0.03777517f, 
    0.04341735f, -0.07984068f, -0.00698423f, -0.06293056f, 0.21428865f, 0.11148078f, 0.06155396f, 0.12589689f, 
    -0.17144591f, 0.02520143f, 0.01150679f, 0.01326897f, 0.03752764f, -0.02147326f, -0.01869924f, 0.07874905f, 
    -0.26550835f, -0.23544042f, -0.24327481f, -0.02659227f, -0.05612333f, 0.03414264f, 0.06007998f, 0.03159200f, 
    0.02611221f, -0.17935029f, -0.14719261f, 0.10829762f, -0.03105126f, -0.03698607f, -0.29580057f, -0.35884982f, 
    -0.11929443f, 0.04107562f, 0.04405677f, 0.03309279f, -0.09764118f, -0.22034721f, -0.19245736f, -0.04672867f, 
    -0.08921815f, -0.12242401f, -0.05907413f, -0.11718501f, -0.08795677f, 0.02001162f, 0.05419970f, 0.03408726f, 
    0.03395331f, 0.04581187f, 0.01851112f, -0.02820620f, 0.26874942f, 0.03476833f, -0.12329876f, -0.10566901f, 
    0.04043660f, 0.05530025f, 0.06081270f, 0.02935956f, 0.13669355f, -0.15257402f, 0.07755177f, -0.06758563f, 
    -0.13236554f, -0.00975389f, 0.09697551f, 0.10874085f, 0.02984395f, 0.04163010f, 0.06176752f, 0.09704652f, 
    0.11675903f, 0.01949297f, 0.09042750f, 0.05857993f, 0.08480471f, 0.05299499f, 0.11832672f, 0.05976469f, 
    -0.01650973f, 0.02289700f, -0.05773077f, -0.00864070f, 0.07576018f, -0.07986160f, 0.09712449f, -0.02965558f, 
    -0.05136133f, -0.28529024f, -0.09053870f, -0.07726644f, 0.18897362f, -0.11283784f, 0.03005710f, 0.01307096f, 
    0.10950657f, 0.02812422f, 0.01168048f, 0.01142131f, -0.15735359f, -0.09676281f, -0.28359282f, -0.22794162f, 
    0.02355001f, 0.04916132f, 0.09955164f, -0.04022328f, -0.05024101f, -0.02192989f, -0.04712708f, -0.05840196f, 
    -0.33890662f, -0.04161067f, -0.17793225f, -0.20746157f, 0.02581631f, -0.12203231f, -0.02389162f, -0.03668420f, 
    -0.02644305f, 0.13107179f, -0.08775253f, -0.00759734f, 0.22119595f, -0.09950043f, 0.03843407f, 0.06450495f, 
    -0.10641939f, 0.02938710f, -0.02366471f, 0.02447369f, -0.05107125f, 0.05955205f, 0.04617245f, -0.04064606f, 
    0.13485411f, -0.05382414f, -0.00013861f, 0.04390713f, -0.05544879f, 0.02793748f, -0.02865721f, 0.17720930f, 
    -0.02200643f, -0.06608424f, -0.06126738f, 0.06278507f, -0.41446683f, -0.03815154f, -0.02149415f, -0.07984854f, 
    0.00800920f, 0.02978691f, -0.03230486f, 0.02643173f, 0.03293445f, 0.00594515f, 0.00832287f, -0.08060239f, 
    0.25958943f, -0.09872489f, -0.14300573f, -0.11273845f, 0.07577869f, 0.01445898f, -0.06033200f, 0.00855587f, 
    0.12367546f, -0.15959372f, -0.00908427f, -0.01821876f, 0.08392372f, -0.05907389f, 0.14606799f, 0.01352002f, 
    -0.08452136f, 0.03119263f, 0.02411475f, -0.01280631f, 0.07213239f, -0.04153183f, 0.07403471f, -0.10384435f, 
    0.04231625f, 0.15326536f, 0.00114914f, 0.01296422f, -0.09264078f, -0.05497553f, 0.03312911f, 0.02355341f, 
    0.03393987f, 0.02070737f, 0.05651607f, -0.05284397f, -0.12659676f, -0.06664666f, -0.08658471f, -0.19503157f, 
    0.09567870f, 0.00398806f, -0.01788621f, 0.01100251f, -0.03883683f, 0.17853944f, 0.17764686f, 0.06435826f, 
    0.14901455f, 0.04040362f, 0.11665712f, 0.11405457f, -0.02619180f, 0.03648411f, -0.01952131f, -0.03575430f, 
    0.04519622f, -0.07224189f, 0.02109663f, 0.01019564f, 0.33564535f, 0.01507070f, -0.21632630f, -0.04905304f, 
    0.09029070f, 0.00654260f, -0.00170335f, 0.14041409f, -0.04490194f, 0.16807432f, -0.07493426f, -0.02088454f, 
    -0.37791649f, -0.16643873f, -0.02194671f, -0.16327561f, -0.08156725f, -0.12069950f, -0.01618229f, 0.04643835f, 
    0.11229743f, 0.01457074f, -0.01834082f, -0.06074661f, 0.08798168f, 0.13743371f, -0.12576517f, 0.18819603f, 
    0.00348251f, 0.05761831f, -0.03515954f, 0.04058019f, -0.03745334f, 0.06282605f, 0.05388672f, -0.05458201f, 
    0.10911658f, 0.01873224f, -0.05452948f, -0.18368168f, -0.02211948f, -0.09155540f, 0.00350442f, 0.04146404f, 
    -0.01884388f, -0.15734835f, -0.01375647f, -0.11173264f, -0.49214584f, 0.13293624f, -0.12697044f, -0.03506006f, 
    0.01875765f, 0.01973390f, -0.00137103f, 0.09457209f, -0.07871514f, -0.07466662f, -0.05745989f, -0.01606142f, 
    0.09681087f, 0.04691214f, 0.13020258f, 0.18127279f, -0.07685036f, 0.04875295f, -0.00807107f, 0.04194754f, 
    -0.04989125f, 0.01314208f, -0.12752920f, -0.03471036f, 0.25731948f, -0.18244827f, -0.11662649f, -0.03809761f, 
    -0.07026439f, 0.00269094f, 0.06653935f, 0.08592067f, -0.07224305f, 0.03154799f, -0.05626083f, 0.02008369f, 
    0.12984361f, -0.20133764f, -0.06177694f, -0.08278809f, 0.03704296f, -0.02917068f, -0.13524492f, -0.01259119f, 
    0.00887266f, 0.09665544f, -0.04325680f, 0.02080789f, 0.08271048f, -0.04164628f, -0.00003939f, 0.29179141f, 
    -0.07462014f, -0.02835228f, -0.06578083f, 0.04297225f, 0.13125309f, 0.07649310f, -0.01489738f, 0.06983896f, 
    0.18295325f, -0.11582823f, 0.04811999f, -0.28775021f, 0.04760237f, 0.04376089f, -0.02389118f, 0.19725175f, 
    -0.06359455f, 0.00077996f, -0.01346745f, 0.07546505f, -0.12098968f, 0.13681380f, 0.05571140f, -0.05318930f, 
    0.06377187f, 0.04480333f, 0.04389668f, -0.03798188f, -0.00096582f, 0.05726320f, 0.03613923f, 0.01100399f, 
    0.30179778f, -0.03246419f, -0.07032829f, 0.20875832f, -0.21287188f, -0.03655599f, 0.04452300f, -0.00747776f, 
    0.00858307f, 0.04723170f, -0.03859856f, 0.17637022f, 0.04278391f, -0.20763719f, 0.10332531f, -0.14992939f, 
    -0.03790126f, -0.01902118f, -0.00683887f, 0.06750707f, -0.06734422f, 0.06479146f, -0.04388859f, -0.07126239f, 
    0.04266170f, 0.09297992f, -0.09648851f, -0.07784604f, -0.02465173f, 0.04002666f, -0.09238822f, -0.06844781f, 
    0.03139352f, -0.02447537f, 0.03070905f, 0.03780345f, -0.01158813f, 0.07409013f, -0.12278432f, 0.09069693f, 
    0.00005278f, 0.09671598f, -0.06993384f, -0.07867467f, -0.06386535f, 0.05593151f, 0.05499805f, -0.01994999f, 
    0.05195709f, -0.00967048f, -0.02038243f, 0.09820002f, 0.00948210f, -0.06203146f, 0.08811897f, -0.04143685f, 
    0.07236926f, -0.00013686f, -0.06044431f, 0.09625348f, 0.21083444f, -0.06808569f, 0.01271257f, 0.02703547f, 
    -0.03144917f, -0.12663189f, 0.01285465f, 0.04237328f, -0.03843441f, -0.03538258f, -0.17636833f, 0.15931255f, 
    -0.08095174f, -0.14469075f, 0.09072553f, -0.08221453f, -0.05983694f, 0.02894814f, -0.02133677f, 0.02777074f, 
    0.05257641f, -0.01770775f, -0.07290702f, -0.10174893f, -0.02599834f, 0.02099524f, -0.03335990f, -0.10525437f, 
    0.09984360f, -0.08237574f, 0.04302717f, -0.05317867f, 0.00435656f, 0.12747298f, 0.00203256f, -0.11980902f, 
    0.04526404f, 0.21461762f, -0.08628318f, 0.05086779f, -0.05083516f, 0.09586380f, 0.05964275f, -0.09825631f, 
    0.06935523f, -0.01913902f, -0.00967815f, 0.08607490f, -0.11670179f, -0.02097892f, -0.12079357f, -0.11655074f, 
    0.12811038f, 0.01256730f, 0.05340672f, -0.07616535f, 0.08161131f, 0.05876995f, 0.04734749f, 0.00722888f, 
    -0.15332492f, 0.16340600f, -0.22591765f, 0.01180876f, 0.02228367f, 0.03128054f, -0.02972512f, -0.06704070f, 
    -0.02202016f, -0.00768096f, -0.01636286f, -0.17532495f, -0.53247279f, -0.12431207f, 0.06196822f, -0.25246888f, 
    -0.01503293f, -0.00369292f, 0.03192586f, -0.00591603f, -0.05771128f, -0.10522248f, -0.08522717f, -0.01939920f, 
    -0.15670866f, -0.23443513f, -0.07765240f, 0.00278467f, -0.05361913f, 0.10984957f, -0.10677422f, -0.07127851f, 
    0.07209830f, 0.07018695f, 0.02186593f, -0.07783196f, 0.41303897f, -0.10627148f, -0.06500939f, -0.02111628f, 
    -0.06407154f, -0.00603565f, -0.03641044f, 0.04697200f, 0.06780865f, -0.03171735f, 0.02754555f, -0.06249825f, 
    -0.51068330f, 0.00145712f, -0.16949821f, -0.08061696f, -0.01489541f, 0.03568737f, -0.09856717f, 0.00280935f, 
    0.07492641f, 0.05197428f, -0.04380807f, -0.05352768f, 0.26616880f, -0.07073072f, -0.14522704f, 0.17865898f, 
    0.06595165f, 0.05438396f, 0.10029561f, -0.10232321f, -0.10511631f, -0.02102453f, -0.05106245f, -0.00858675f, 
    0.35788032f, 0.12783505f, 0.00810820f, 0.03773502f, 0.10523792f, 0.00185872f, -0.02459460f, 0.03154369f, 
    -0.05720770f, 0.10240018f, 0.05173885f, 0.02900798f, 0.20247358f, 0.13782749f, -0.09259257f, -0.03009478f, 
    0.10405902f, 0.11317245f, -0.07424285f, -0.02930401f, 0.01683822f, -0.00133664f, -0.05421070f, -0.07864944f, 
    0.02615393f, -0.08705743f, 0.00854331f, -0.08918180f, -0.16277125f, -0.08535779f, -0.07882284f, -0.05599616f, 
    0.00854377f, -0.10570162f, -0.00088992f, 0.01063968f, 0.04243000f, -0.10191029f, -0.02570243f, -0.07318693f, 
    0.09665045f, 0.00302581f, -0.00438799f, -0.00427350f, -0.08115520f, -0.07892528f, -0.12102976f, -0.08319455f, 
    0.06431541f, -0.05953221f, 0.06989522f, -0.14990714f, -0.02799039f, -0.09568091f, 0.04296562f, 0.00914392f, 
    -0.05383001f, -0.04363577f, -0.05261551f, -0.10193238f, -0.00962650f, -0.15349263f, -0.23712288f, -0.03745206f, 
    -0.01207378f, -0.00006165f, -0.08530115f, -0.06871051f, -0.13763747f, -0.02839741f, -0.03515607f, -0.02582870f, 
    -0.01415809f, -0.24193196f, 0.01920023f, -0.14031900f, -0.03876883f, 0.03681390f, -0.13060127f, -0.00982568f, 
    -0.11963762f, -0.13617997f, -0.04103130f, -0.03240031f, 0.20155309f, -0.14542437f, 0.09527351f, -0.07928640f, 
    -0.05240151f, 0.00802106f, -0.01866308f, 0.05702065f, -0.10344916f, 0.04115103f, -0.07360932f, -0.08316287f, 
    0.08583389f, -0.11878482f, 0.01080112f, 0.06582674f, -0.03831614f, 0.03905709f, 0.05676163f, 0.02296763f, 
    0.01145224f, -0.03677008f, -0.03998471f, 0.05570210f, 0.06937102f, 0.06462727f, 0.07441802f, 0.16591156f, 
    -0.03781329f, -0.12333318f, 0.06440949f, 0.08508371f, -0.10297236f, 0.02580673f, -0.03950758f, -0.04793341f, 
    0.13380131f, 0.10095091f, -0.16497503f, 0.05715369f, 0.00607216f, 0.10716673f, -0.05083416f, -0.05013312f, 
    -0.02972282f, -0.05041214f, 0.03821027f, 0.00074256f, 0.19634086f, -0.04535693f, -0.02772249f, -0.00927212f, 
    0.05185421f, -0.07956959f, 0.06916211f, 0.13925217f, -0.03043121f, -0.01609882f, 0.11808375f, -0.04787942f, 
    0.21803352f, 0.00828148f, -0.08630266f, 0.05742425f, -0.01919742f, 0.10630976f, -0.01482113f, 0.03280699f, 
    -0.07568449f, -0.07438997f, -0.06225975f, -0.08211205f, 0.06703042f, 0.07363591f, 0.11134624f, -0.34930742f, 
    -0.02098058f, 0.02930094f, 0.02483899f, 0.03315053f, 0.02556761f, 0.07072601f, -0.05719747f, -0.12790222f, 
    -0.14438356f, -0.06213019f, 0.03967111f, -0.01893098f, -0.04623922f, -0.15237612f, -0.02336288f, 0.10021970f, 
    0.04746594f, 0.02941715f, 0.06318797f, -0.03656689f, -0.27311340f, 0.02201228f, -0.13434944f, 0.11575972f, 
    0.00591838f, 0.01439104f, -0.08286653f, 0.05330639f, -0.08053714f, 0.04639238f, 0.09132129f, -0.07323587f, 
    0.04706967f, -0.06954914f, 0.03903070f, -0.03898939f, -0.02441368f, -0.11295091f, 0.02548637f, 0.05551137f, 
    -0.02494871f, -0.06434789f, -0.00795789f, -0.07405274f, -0.25525674f, 0.04609662f, 0.01821750f, -0.00995394f, 
    0.00499780f, -0.09218110f, 0.07034294f, -0.06103284f, -0.03527980f, -0.02048817f, -0.07497961f, 0.04259919f, 
    0.52835518f, -0.10003193f, 0.07538623f, 0.03376628f, -0.02729674f, 0.05182325f, 0.00270068f, -0.03937747f, 
    -0.01802550f, 0.04323639f, -0.04416708f, 0.04174818f, 0.01598102f, 0.01972998f, -0.07504939f, 0.00648884f, 
    0.11631222f, 0.02276757f, 0.09878287f, -0.02730822f, 0.06370402f, 0.02912148f, -0.04353237f, -0.09358799f, 
    -0.16209972f, 0.16279447f, -0.30851722f, -0.03856359f, -0.09503967f, 0.02543042f, 0.07582437f, 0.03818583f, 
    -0.09761643f, 0.03706332f, 0.02818561f, -0.01564155f, -0.10410962f, -0.16504206f, -0.12670931f, -0.20807268f, 
    0.04371666f, 0.11844034f, -0.07853236f, -0.02898706f, 0.09060796f, 0.08345679f, 0.02062174f, -0.08165783f, 
    -0.31611660f, -0.04055334f, -0.14680865f, -0.25764945f, 0.02835331f, -0.01360633f, -0.06282341f, 0.00460752f, 
    -0.01103736f, 0.04506215f, -0.06427445f, 0.01587049f, 0.00177055f, -0.31154126f, 0.19686021f, 0.16894244f, 
    -0.08729094f, -0.00373502f, 0.00017185f, -0.06988418f, -0.13374439f, 0.07151457f, 0.02072840f, 0.06886621f, 
    -0.19823587f, -0.23855765f, 0.04088052f, -0.10750145f, -0.04866609f, 0.04706869f, -0.03630764f, -0.03244517f, 
    0.04924301f, -0.05725137f, -0.00121512f, -0.02398318f, 0.08691864f, -0.00061324f, -0.08362701f, 0.07911305f, 
    0.10688543f, 0.10869186f, 0.01577127f, 0.11780506f, -0.08658119f, 0.04390712f, 0.00915384f, -0.01577620f, 
    -0.18987234f, 0.01663263f, -0.11289097f, -0.15029800f, -0.03690748f, 0.07058970f, -0.00397420f, 0.01998986f, 
    -0.02606868f, 0.09778074f, -0.06612180f, -0.06039287f, 0.09015510f, 0.06296133f, -0.41746339f, -0.06870333f, 
    0.00701960f, 0.05451684f, 0.07105986f, -0.15276785f, -0.03613655f, -0.00329959f, -0.11114354f, 0.06147431f, 
    0.27058488f, 0.08963823f, 0.05542088f, 0.11696269f, 0.00982707f, -0.02542469f, 0.06016253f, 0.00154498f, 
    -0.14462455f, -0.03472959f, 0.03621570f, -0.00028485f, 0.01613803f, -0.15844987f, 0.08274440f, 0.04389678f, 
    0.08322367f, 0.02307484f, 0.01367936f, -0.08806890f, 0.08668010f, 0.05939519f, 0.02176915f, 0.02494098f, 
    0.16576797f, -0.01019636f, -0.16100419f, 0.12924482f, -0.12247813f, -0.06909303f, -0.12929693f, 0.06395193f, 
    0.04322229f, 0.04170970f, 0.07378214f, 0.00153630f, 0.29074377f, 0.17662624f, 0.03678878f, 0.04738888f, 
    -0.05772702f, -0.03774476f, -0.08145765f, -0.09983692f, -0.08884528f, 0.00454455f, -0.05070741f, -0.09803191f, 
    0.22053178f, 0.03869436f, 0.06292509f, 0.24157730f, -0.19392601f, -0.07598594f, 0.05568504f, 0.09567582f, 
    -0.04233385f, -0.01275748f, 0.00067745f, -0.02926767f, -0.21462364f, 0.05978230f, 0.08092000f, -0.01780134f, 
    -0.00526463f, 0.03971900f, -0.01306524f, 0.01151941f, 0.03782708f, 0.06552499f, 0.00137903f, -0.03942640f, 
    0.05760766f, 0.01459187f, 0.15767136f, -0.02010616f, -0.05155499f, 0.03204600f, 0.02376011f, -0.00098508f, 
    0.01948212f, 0.13745353f, -0.02010173f, 0.06921485f, -0.21829596f, 0.09031383f, 0.02062195f, -0.29262730f, 
    0.09420397f, -0.01929830f, 0.01243248f, -0.03514889f, -0.01710514f, -0.00878265f, 0.00724083f, -0.08739555f, 
    -0.03389074f, 0.01768069f, -0.07473332f, 0.06634772f, 0.10735112f, -0.02738651f, -0.04317917f, -0.00639307f, 
    -0.13109697f, 0.04057925f, -0.01777271f, -0.05562380f, 0.32657197f, -0.08131648f, 0.09666290f, 0.05659857f, 
    -0.08468258f, -0.05462512f, 0.06186588f, 0.03260827f, -0.01765370f, -0.04771406f, -0.01088987f, 0.00231371f, 
    -0.01401801f, 0.12308139f, -0.13314946f, 0.20488445f, -0.01436124f, -0.06070926f, 0.08108555f, -0.02976514f, 
    -0.05112693f, -0.02274821f, 0.04555993f, 0.02761785f, -0.08223279f, 0.05900159f, 0.07704325f, -0.12938072f, 
    0.01090171f, 0.07695585f, 0.02715177f, -0.00202423f, 0.04866375f, -0.05017769f, -0.02739074f, 0.15031019f, 
    -0.13216919f, -0.28663343f, -0.03974541f, -0.14276721f, 0.01764029f, -0.08553210f, 0.01615329f, -0.11489438f, 
    -0.12124214f, 0.16299097f, -0.06999534f, -0.06552522f, 0.04056118f, -0.14040302f, 0.02682691f, -0.21746105f, 
    -0.12927438f, 0.13085665f, -0.06335546f, -0.03624786f, 0.08872550f, -0.02340999f, -0.01299373f, -0.02183146f, 
    0.15426111f, 0.01745568f, -0.07028674f, -0.03927359f, 0.04611471f, 0.05338688f, 0.02250323f, -0.05937028f, 
    0.01125134f, 0.01144049f, 0.04084275f, -0.03438114f, -0.00848304f, 0.11896753f, -0.04120591f, -0.20832384f, 
    0.08576091f, -0.13745745f, 0.04463942f, 0.00882991f, -0.01375853f, 0.03378919f, 0.12214998f, 0.01051666f, 
    0.22433470f, -0.12010133f, 0.14596458f, 0.19531094f, -0.06128080f, 0.04261654f, 0.00776335f, 0.03992531f, 
    0.04500576f, 0.01384297f, -0.02418676f, 0.05728761f, 0.05393168f, 0.19448066f, -0.01254801f, -0.01646034f, 
    0.12441139f, -0.02473004f, -0.02698184f, -0.02252528f, 0.02149453f, -0.05905502f, 0.01250811f, -0.03459013f, 
    -0.13089798f, 0.04997065f, -0.09461347f, 0.06443168f, 0.01548773f, -0.03619669f, 0.08898643f, -0.04072355f, 
    -0.07101242f, -0.03083168f, 0.04147819f, 0.02667929f, -0.02530453f, 0.16444920f, 0.03856701f, 0.04746073f, 
    -0.05112776f, 0.03096065f, -0.03957938f, -0.00765338f, -0.04072875f, -0.04824686f, -0.00489290f, -0.01687263f, 
    0.09908359f, -0.01826578f, -0.03593180f, -0.03410358f, -0.07721956f, -0.01347873f, -0.06652566f, 0.03631583f, 
    -0.00201251f, -0.02604613f, 0.04787659f, -0.03010115f, -0.00781184f, -0.00912633f, 0.07035659f, -0.21685641f, 
    0.06944805f, -0.00564901f, 0.04092864f, -0.05779447f, 0.00948889f, -0.03024594f, 0.06385712f, -0.05080618f, 
    -0.18780236f, -0.05455464f, -0.01922305f, -0.01347607f, 0.06829227f, 0.01354688f, 0.05054106f, 0.00125560f, 
    -0.11726951f, -0.08896323f, -0.06866650f, -0.01127624f, 0.33677876f, -0.24360503f, -0.05895052f, -0.06833144f, 
    -0.10163213f, 0.05036349f, 0.06692028f, 0.00892708f, 0.12373087f, -0.02021060f, 0.03327982f, -0.06764983f, 
    0.17323698f, 0.03295570f, -0.18765046f, 0.01576967f, 0.03567519f, 0.05484558f, -0.03423951f, -0.02811469f, 
    -0.09675769f, -0.04773217f, 0.00288307f, -0.12579323f, -0.10600890f, -0.07627626f, 0.00640097f, 0.00311117f, 
    0.12378936f, 0.01748686f, 0.03111304f, -0.10534507f, 0.07827656f, 0.04342401f, -0.01462257f, -0.01965774f, 
    -0.16868760f, 0.16761442f, 0.02025895f, 0.09412050f, -0.02352010f, 0.01404819f, -0.04435348f, -0.04071774f, 
    0.01985561f, 0.01345312f, 0.04683533f, 0.05394056f, 0.12812012f, -0.15778995f, -0.20814870f, 0.00971561f, 
    -0.02655209f, -0.06379112f, -0.02958811f, -0.08421469f, 0.04146481f, -0.05915204f, -0.14964372f, -0.01009424f, 
    -0.02540664f, 0.02565924f, -0.02465048f, -0.00241041f, -0.05980410f, 0.01568088f, 0.05954694f, -0.12493990f, 
    -0.05119428f, 0.04774180f, -0.13433875f, 0.16709524f, -0.40889403f, -0.23079236f, 0.05247090f, -0.01008502f, 
    -0.01845223f, 0.01636319f, 0.05585122f, -0.03507580f, 0.01501630f, 0.05644864f, 0.13593273f, -0.06738185f, 
    0.22917254f, -0.36541262f, -0.04765704f, 0.23969886f, -0.02557370f, 0.02658686f, -0.06083514f, 0.06952423f, 
    0.00784914f, -0.00730721f, 0.06529984f, -0.15520756f, 0.09796379f, 0.04813395f, 0.04396975f, 0.10451191f, 
    -0.06872753f, 0.06627794f, -0.00258564f, -0.00451747f, -0.07451929f, -0.07568423f, 0.02438146f, 0.07486804f, 
    0.17281494f, 0.10913434f, 0.00288787f, 0.12152869f, -0.08984338f, 0.04561808f, 0.08818382f, -0.00690513f, 
    -0.09808066f, 0.07059079f, 0.02337013f, 0.00651911f, 0.07736955f, 0.07202483f, 0.14557366f, -0.15256985f, 
    -0.03777380f, -0.11156520f, -0.07694171f, -0.03428045f, 0.01871863f, 0.13220587f, -0.00629229f, -0.01185652f, 
    0.23150213f, -0.01355593f, 0.10964486f, 0.16351984f, -0.05169846f, 0.03108885f, -0.01564826f, 0.01091676f, 
    -0.01015085f, 0.11359469f, -0.16581821f, -0.00094335f, 0.62985736f, -0.16805957f, 0.15369713f, 0.23001617f, 
    0.07549080f, -0.02909136f, -0.04029310f, 0.05580244f, -0.01344009f, 0.04952686f, -0.07264064f, -0.07924146f, 
    -0.07418545f, 0.17543201f, 0.05035421f, -0.18980625f, -0.04408829f, 0.02475518f, -0.04985712f, 0.04563270f, 
    -0.02342795f, -0.10408867f, -0.04286088f, 0.03218663f, -0.00839990f, 0.03888299f, 0.12246609f, 0.02218572f, 
    0.14337711f, 0.06375783f, -0.01615418f, 0.05541670f, 0.01266172f, -0.00012531f, -0.03239822f, 0.04389097f, 
    0.10346980f, 0.02254847f, -0.01394720f, 0.14294177f, 0.01988667f, -0.00134081f, -0.03903059f, 0.08388495f, 
    -0.07221341f, -0.14336841f, 0.05729836f, -0.02891623f, -0.09675931f, -0.11951730f, 0.13857330f, 0.17721738f, 
    0.04021128f, 0.12221284f, 0.02297856f, -0.03165524f, 0.04072617f, -0.00727858f, -0.12501231f, -0.00568825f, 
    0.27853975f, 0.23417750f, -0.07354453f, 0.11358228f, -0.00109083f, 0.03232537f, -0.05903457f, 0.02516786f, 
    -0.03484541f, -0.04865931f, -0.01545671f, -0.00956067f, -0.00496448f, 0.23163323f, 0.06085106f, 0.05508229f, 
    -0.02806982f, 0.02032335f, -0.00579562f, 0.11033356f, -0.09115960f, 0.00535287f, 0.00824268f, -0.03592872f, 
    0.28981054f, 0.08176950f, 0.03666474f, 0.06476291f, 0.17888832f, 0.04972609f, -0.06384606f, 0.01835600f, 
    0.02363557f, -0.10456220f, 0.01073467f, -0.13548222f, -0.11314018f, 0.10791066f, -0.11602733f, -0.03424942f, 
    -0.10130037f, -0.04723101f, -0.08767937f, 0.02860289f, -0.04345017f, -0.20386067f, 0.02545764f, 0.04830558f, 
    -0.07046403f, 0.02550562f, -0.18149696f, -0.18028294f, -0.11317034f, 0.01279236f, -0.02571853f, 0.01616876f, 
    0.00338591f, -0.07812710f, 0.03289419f, 0.06808286f, -0.20273732f, 0.04838545f, -0.10027117f, -0.15966329f, 
    -0.04054774f, -0.07958642f, -0.01402132f, -0.03918992f, -0.03454559f, -0.05218658f, -0.01774831f, -0.05376086f, 
    0.02192440f, 0.20170929f, 0.14963695f, 0.06288266f, 0.11511618f, -0.00459354f, 0.06015708f, -0.08022736f, 
    -0.05493894f, 0.02854567f, 0.06468171f, -0.06784238f, 0.04148215f, -0.13856855f, -0.14100875f, -0.09298759f, 
    -0.14665775f, 0.00064581f, 0.00354515f, 0.05120654f, -0.06452669f, 0.01960646f, 0.02092487f, 0.00694079f, 
    -0.34436062f, -0.08915713f, -0.19514519f, 0.19403367f, 0.04131895f, -0.04097613f, 0.09041219f, 0.03189761f, 
    -0.05594285f, -0.09271604f, -0.09612688f, -0.01744667f, -0.00044404f, -0.17046672f, -0.02474896f, -0.11677132f, 
    -0.00552956f, 0.05367923f, 0.01941443f, 0.10227251f, -0.00706320f, 0.03386721f, -0.02659644f, -0.00105667f, 
    -0.05024991f, -0.18776993f, 0.07464689f, 0.03446163f, -0.02974875f, 0.03900288f, 0.02421775f, 0.00911417f, 
    -0.04548177f, -0.05135341f, 0.05026910f, 0.02863702f, 0.14709696f, 0.12641129f, 0.06944808f, 0.03410865f, 
    0.04531159f, -0.00988797f, 0.06294645f, -0.03886335f, -0.07640012f, -0.07457456f, 0.02071845f, -0.08716909f, 
    -0.05536555f, -0.05141807f, -0.18314107f, -0.04836930f, -0.04588391f, 0.04676930f, -0.04492781f, 0.12199584f, 
    -0.02270571f, 0.03075347f, 0.07078999f, -0.01604794f, -0.04723267f, 0.01986569f, 0.00201082f, 0.05127690f, 
    -0.02654023f, -0.02795522f, 0.04752873f, 0.05951764f, -0.04481336f, 0.03294203f, -0.00003950f, -0.11430567f, 
    -0.17776045f, 0.12307666f, 0.15500249f, 0.03145888f, -0.01880224f, 0.06975581f, 0.07539259f, -0.06621211f, 
    -0.06676883f, 0.06523934f, -0.01656353f, 0.04469006f, -0.60936695f, -0.53790450f, -0.24366790f, 0.19144888f, 
    -0.13993140f, 0.03418786f, 0.04250828f, -0.02916230f, -0.03068773f, -0.07330793f, 0.06190443f, -0.14119366f, 
    -0.00556630f, 0.20263369f, 0.13147447f, 0.01701323f, 0.12134501f, 0.03677256f, -0.01844750f, 0.05098073f, 
    -0.13312937f, 0.05631360f, 0.00443030f, 0.05785034f, 0.18686029f, 0.20026150f, 0.02995673f, 0.03346522f, 
    0.06721035f, -0.02819390f, -0.01856787f, -0.03120172f, 0.07160833f, 0.09517824f, 0.06002942f, 0.05307081f, 
    0.21112347f, -0.09125326f, 0.02251803f, 0.08490983f, 0.11995368f, 0.06978871f, -0.08506858f, -0.05014243f, 
    -0.00841418f, -0.07731216f, -0.12277543f, 0.09336445f, 0.01175540f, 0.03503682f, 0.00338936f, -0.06371985f, 
    -0.13387792f, -0.04867911f, -0.03698986f, 0.03040329f, 0.00413011f, 0.02171820f, -0.05196581f, 0.10058893f, 
    0.06218914f, 0.12554480f, 0.09129434f, 0.18301958f, 0.00639775f, -0.03383635f, -0.09318817f, -0.06361389f, 
    0.08346637f, 0.06697922f, -0.04303215f, 0.03874122f, -0.41451570f, -0.18490425f, -0.07958265f, -0.06425585f, 
    -0.04820927f, -0.03255508f, -0.05664354f, 0.05591350f, 0.01541878f, 0.08965238f, 0.00016541f, 0.01412857f, 
    0.24342439f, -0.11169331f, -0.05351456f, 0.29363832f, 0.04342494f, -0.00924880f, 0.04714192f, 0.16104648f, 
    0.01725559f, -0.04371272f, 0.10129665f, -0.08165465f, 0.49906382f, 0.20220375f, 0.09402242f, 0.02277197f, 
    0.06206375f, -0.07606050f, -0.06748110f, 0.04918317f, -0.03345265f, 0.04671421f, -0.00694650f, -0.08952408f, 
    -0.15225673f, 0.12391284f, 0.04698632f, -0.18673162f, -0.07300897f, 0.09011082f, -0.06276913f, 0.06611829f, 
    0.05958886f, -0.10408170f, -0.04001606f, 0.05128048f, -0.37602624f, -0.35400414f, -0.06821458f, 0.23422226f, 
    -0.04813901f, -0.00434816f, -0.04203514f, -0.04730352f, 0.01771925f, -0.11051419f, 0.02761853f, 0.02882605f, 
    0.04142682f, 0.04268927f, 0.00178957f, 0.04239270f, -0.12441621f, -0.17679948f, 0.01555552f, -0.00836436f, 
    -0.07731985f, 0.01900667f, 0.02021217f, -0.02887160f, -0.01670628f, 0.26147670f, 0.03246279f, -0.11320052f, 
    -0.05827006f, -0.08630651f, 0.04210797f, -0.02097194f, 0.05088696f, -0.09305553f, -0.00577907f, 0.02917500f, 
    -0.02360822f, -0.07121367f, -0.00838914f, -0.12689161f, -0.07007061f, -0.01852241f, -0.00539821f, -0.01409307f, 
    -0.09317391f, -0.00579497f, -0.06570406f, 0.02532941f, -0.07450601f, -0.03703400f, -0.07981275f, 0.21700402f, 
    -0.02592517f, 0.01456981f, -0.05949097f, -0.02543268f, 0.01270295f, -0.12083050f, -0.02417784f, 0.01882748f, 
    -0.29456446f, -0.03822742f, 0.03628839f, -0.14210463f, 0.05052913f, -0.03544001f, -0.10852575f, -0.02037700f, 
    0.02272895f, -0.01213075f, -0.05691189f, 0.06624126f, 0.04384774f, 0.07381880f, 0.12230384f, 0.02955434f, 
    -0.12563753f, -0.01077494f, -0.10382686f, 0.06075156f, 0.10193894f, -0.03066119f, -0.05884366f, -0.16476582f, 
    -0.21226174f, -0.12172496f, 0.10294947f, -0.08970629f, -0.08253874f, -0.02631311f, 0.04392510f, -0.02824483f, 
    0.01234273f, -0.02427633f, 0.03924530f, -0.01918634f, -0.01201053f, 0.05109722f, -0.10566477f, -0.03594077f, 
    -0.11983075f, -0.10754618f, -0.02401823f, -0.07891122f, -0.02374865f, -0.15096223f, 0.07992730f, -0.06753358f, 
    -0.12009306f, -0.04875164f, 0.05591976f, -0.03854384f, -0.09773117f, 0.04531535f, 0.06137314f, 0.09710270f, 
    -0.07156634f, 0.02284444f, -0.10395539f, 0.04092755f, -0.32270685f, -0.12563671f, 0.04496428f, -0.10201572f, 
    -0.06591359f, -0.02053754f, 0.04183339f, -0.03207996f, 0.02654703f, -0.09228457f, 0.03345153f, 0.07284367f, 
    0.25619617f, 0.18437725f, 0.07016287f, 0.06803539f, 0.03145417f, 0.00184959f, 0.04144530f, 0.08221899f, 
    0.04104424f, 0.03337290f, -0.08264785f, 0.00285294f, 0.09916797f, 0.01686307f, 0.07133354f, 0.01262670f, 
    -0.01703865f, 0.03191087f, -0.05057838f, -0.09906305f, 0.03138341f, -0.02718965f, 0.04785148f, -0.00802938f, 
    -0.27150422f, -0.13910738f, -0.00976912f, -0.03046175f, -0.05056566f, -0.03703816f, 0.06108727f, 0.01840146f, 
    0.07802149f, -0.00679132f, 0.11612554f, -0.02461778f, 0.09348044f, -0.20137031f, -0.08386161f, -0.11192136f, 
    0.01294130f, 0.01777715f, 0.00541452f, 0.01852077f, 0.01218361f, 0.04920635f, 0.01731226f, -0.03141700f, 
    -0.18902580f, 0.05205609f, -0.13529959f, -0.10506921f, -0.13312761f, -0.05208369f, 0.00973983f, -0.07566159f, 
    -0.09667960f, -0.10556270f, 0.00295512f, -0.02997090f, -0.45053318f, -0.20657530f, 0.06777385f, 0.02957678f, 
    0.01707058f, 0.15823954f, 0.08008210f, -0.00735046f, -0.03332864f, 0.01146820f, 0.00001693f, -0.00298755f, 
    -0.06219160f, -0.06353837f, 0.04233771f, -0.12968519f, -0.10952773f, 0.05894032f, 0.05271468f, 0.08798337f, 
    0.00933995f, 0.01757076f, 0.05863199f, -0.03080743f, 0.05302374f, -0.05280887f, -0.03348802f, -0.11979400f, 
    -0.06999367f, 0.09446836f, -0.04414337f, 0.04048495f, 0.02884827f, 0.01888488f, 0.03280124f, 0.06877124f, 
    0.23358971f, -0.50976616f, -0.13054332f, -0.16027708f, -0.04855368f, 0.09108058f, -0.03915133f, -0.00506654f, 
    -0.03027536f, -0.05568132f, 0.00684700f, -0.04819590f, 0.13584377f, -0.10942969f, -0.00775005f, 0.09508534f, 
    -0.13509549f, -0.01327630f, -0.06396449f, 0.07849895f, -0.04067279f, -0.04807114f, -0.07665931f, -0.00117205f, 
    -0.26634219f, -0.17744139f, 0.03089991f, 0.02480817f, -0.05128899f, -0.03337592f, 0.04592940f, 0.06459781f, 
    -0.00572262f, 0.09318189f, -0.03849236f, -0.09191482f, -0.26445362f, 0.09750506f, 0.06443223f, 0.08690314f, 
    0.07100254f, -0.08674785f, 0.00385570f, 0.05174604f, 0.04171141f, 0.01868619f, -0.02974169f, -0.00190744f, 
    -0.17002039f, 0.03019979f, 0.01679622f, 0.08139788f, 0.06877480f, 0.06736819f, 0.02212491f, 0.05164953f, 
    -0.06888254f, -0.07042344f, 0.03821534f, -0.11876830f, 0.00883184f, -0.33626211f, -0.36051330f, 0.01834469f, 
    -0.13462621f, 0.06807243f, -0.03639901f, -0.15700096f, -0.00912025f, -0.05525346f, -0.02045498f, 0.04611285f, 
    -0.03269199f, -0.09042491f, 0.12944630f, 0.03677246f, -0.04625355f, 0.01858704f, -0.00355796f, 0.00535928f, 
    0.04489297f, 0.14348507f, 0.01716697f, 0.12240545f, 0.36779371f, -0.05732139f, 0.00885821f, 0.19702542f, 
    -0.15028092f, 0.00730010f, 0.04252976f, 0.00901474f, 0.00881363f, -0.00627787f, -0.12727810f, -0.03331517f, 
    -0.07806092f, -0.14881057f, 0.17428699f, 0.06602798f, -0.07085568f, 0.02378816f, -0.00762960f, -0.09303898f, 
    -0.04778500f, 0.07943451f, -0.07977425f, -0.04505270f, 0.10077946f, 0.09764881f, 0.08127107f, 0.06657969f, 
    0.00779193f, 0.02023174f, 0.09197505f, 0.03484976f, -0.01357981f, 0.02330368f, 0.18441218f, 0.02069803f, 
    -0.38774163f, -0.00018163f, 0.13417745f, 0.12258241f, -0.04025421f, -0.01505969f, -0.11377996f, -0.14132755f, 
    0.01167370f, -0.04288179f, -0.01275026f, -0.10994675f, -0.12498016f, -0.07650118f, -0.08601610f, 0.08845157f, 
    0.02377309f, -0.05768534f, -0.03817909f, -0.01964157f, -0.02223872f, 0.00239529f, -0.07821027f, 0.08116273f, 
    0.12112527f, 0.01671320f, -0.18903805f, -0.06874069f, 0.08475953f, -0.00536554f, 0.02903918f, -0.01262222f, 
    0.05090722f, -0.08182082f, 0.09331865f, 0.04727942f, -0.40377203f, -0.05301356f, 0.06079009f, -0.17905955f, 
    0.10938491f, -0.01250121f, -0.03010959f, 0.03784956f, -0.07350881f, -0.04903293f, -0.04857830f, 0.08233970f, 
    -0.03280772f, 0.15607795f, -0.05346317f, -0.03135652f, -0.02664095f, -0.06932898f, -0.07261976f, 0.01126105f, 
    -0.14762735f, -0.03110304f, -0.06585846f, 0.07649527f, -0.15308823f, 0.30922180f, -0.11374529f, -0.30263305f, 
    -0.00802629f, 0.06052141f, 0.00758886f, 0.11992513f, -0.03243707f, 0.00734907f, 0.04699905f, 0.02404338f, 
    -0.07941553f, -0.13794364f, 0.04936088f, 0.13144965f, -0.00480766f, -0.09636650f, 0.03387772f, -0.02585618f, 
    -0.02902984f, 0.11493533f, -0.05283798f, 0.00108093f, 0.15514542f, -0.02837067f, 0.04656927f, 0.04512706f, 
    -0.09515565f, -0.10729144f, -0.00045965f, -0.09185321f, -0.02839942f, 0.05086854f, 0.01724288f, -0.00609470f, 
    -0.39876845f, 0.07882909f, -0.02868052f, -0.29405239f, 0.14138533f, -0.07942258f, -0.01648985f, 0.04863212f, 
    0.00587412f, 0.03950973f, 0.00781313f, 0.01317928f, -0.21255456f, -0.08106392f, 0.09712916f, -0.10656019f, 
    0.06329186f, -0.02731312f, -0.05267909f, -0.04911456f, 0.10195448f, -0.13270374f, -0.12193535f, -0.02919330f, 
    -0.06339543f, -0.13716938f, -0.35252193f, 0.19994308f, 0.03021562f, 0.07836334f, -0.01855766f, -0.15376079f, 
    -0.15739301f, -0.11240008f, 0.03677153f, 0.00576567f, 0.16116421f, 0.04734848f, 0.08137506f, -0.07412680f, 
    -0.11282824f, 0.13962144f, 0.01349556f, -0.08303122f, 0.11191086f, -0.14790788f, -0.04058263f, -0.02809905f, 
    -0.09808656f, 0.20449203f, 0.05389488f, 0.14629862f, 0.00372702f, 0.07952785f, -0.05481558f, -0.03920471f, 
    0.07564360f, -0.20765677f, -0.01153683f, -0.08340726f, 0.18986544f, -0.02818162f, 0.08840190f, 0.30328113f, 
    0.01567296f, 0.11937739f, -0.04461423f, 0.19624206f, 0.12242951f, 0.11246678f, 0.00586044f, -0.01711231f, 
    0.17923538f, -0.30877712f, -0.22162202f, 0.07976021f, -0.14608185f, -0.02246020f, 0.01057687f, -0.01421021f, 
    0.00587177f, -0.00601157f, -0.05557047f, -0.05340765f, -0.10668085f, -0.06633664f, 0.02001222f, 0.18714005f, 
    0.01189557f, -0.00688274f, 0.04155648f, 0.05188867f, -0.02278942f, 0.05391455f, 0.11793756f, 0.03660848f, 
    -0.13172770f, 0.07328977f, 0.09944523f, -0.04929098f, 0.01106947f, -0.07142056f, -0.01807035f, -0.11913977f, 
    -0.13234609f, -0.05590047f, 0.02829797f, 0.01922114f, 0.01286011f, -0.13405074f, -0.10825664f, 0.12932785f, 
    -0.06039895f, -0.04481003f, 0.04796856f, 0.09095182f, -0.02972900f, 0.00508412f, -0.04419498f, -0.03245002f, 
    -0.08688406f, -0.04817752f, -0.01834855f, -0.04301821f, -0.01906307f, 0.07749986f, 0.03733686f, 0.05313018f, 
    -0.10698388f, 0.05489561f, 0.08938889f, -0.00928959f, 0.12933770f, -0.01774429f, 0.12518683f, -0.10722505f, 
    -0.03752480f, -0.04716120f, -0.03208600f, 0.16461553f, 0.01782713f, 0.03084120f, -0.07317863f, 0.09091938f, 
    -0.54290593f, 0.17404501f, 0.09349775f, 0.03491382f, 0.02139158f, -0.05123772f, -0.02097926f, -0.09811658f, 
    0.08771866f, 0.02574511f, 0.01847991f, 0.01935974f, 0.08995673f, 0.07921983f, -0.05856168f, 0.08309943f, 
    0.03627975f, 0.07912606f, 0.01117868f, -0.01112254f, 0.03514648f, -0.01917985f, -0.03277627f, -0.07999240f, 
    -0.04841727f, 0.05059836f, 0.01611771f, -0.06594698f, 0.00884795f, 0.08987597f, -0.01887082f, -0.13968870f, 
    -0.14386958f, -0.04054445f, 0.05127633f, -0.02902555f, 0.16441610f, -0.29537511f, -0.21503367f, 0.04332570f, 
    0.05721560f, 0.05691494f, -0.05360751f, 0.07850610f, -0.03322461f, 0.13216048f, -0.02344228f, 0.00402884f, 
    -0.64938504f, 0.19166753f, -0.03859613f, -0.05589593f, 0.07686108f, -0.03516586f, 0.01321007f, -0.09360952f, 
    -0.02899975f, 0.03987863f, -0.01894808f, 0.08973408f, -0.23105320f, 0.00253341f, 0.11505073f, 0.04565759f, 
    -0.10730581f, 0.03356979f, 0.02536845f, 0.13743035f, 0.13762632f, -0.01975598f, -0.02475234f, 0.03242844f, 
    0.14795220f, 0.00652829f, 0.11776864f, -0.09422868f, -0.02495058f, 0.01350358f, 0.05623078f, -0.04938763f, 
    -0.04475356f, 0.00160577f, -0.01017234f, 0.08672857f, 0.09220194f, -0.00132378f, 0.12074379f, -0.06182662f, 
    -0.02046812f, 0.00472570f, 0.06956638f, -0.04794417f, 0.04056877f, 0.08139835f, 0.07937044f, 0.01431865f, 
    -0.11106914f, -0.14057326f, 0.16646320f, 0.11507107f, -0.04871223f, 0.00891090f, -0.08830851f, 0.04543100f, 
    0.17351203f, -0.03203629f, -0.02978735f, -0.02640989f, -0.36675465f, 0.00198877f, 0.01233955f, 0.19833508f, 
    0.10330495f, -0.12641823f, 0.05228159f, 0.14319669f, -0.03868786f, 0.12260379f, 0.00420711f, 0.05179143f, 
    0.13185196f, 0.01481558f, -0.01798919f, 0.01784171f, -0.03559743f, -0.02318697f, 0.02147525f, 0.08486100f, 
    0.00376390f, 0.07200634f, -0.06776465f, 0.00057563f, 0.00669785f, 0.02077515f, 0.13233878f, 0.10485102f, 
    -0.03492545f, -0.07688184f, 0.00225333f, 0.12635268f, -0.03252510f, 0.08057383f, 0.00597497f, 0.09454771f, 
    -0.18346159f, 0.02234966f, 0.06157651f, 0.02566167f, -0.13736831f, 0.17907937f, 0.06311496f, 0.00599319f, 
    -0.05216432f, -0.14953922f, 0.01455965f, 0.01288321f, 0.41410351f, 0.15622708f, 0.04996543f, -0.04336448f, 
    -0.07863913f, 0.01393321f, -0.10000086f, -0.03383634f, 0.07166372f, -0.03518483f, 0.03042438f, 0.07045318f, 
    0.22340959f, -0.02025585f, 0.10876872f, 0.08360764f, 0.02939343f, 0.01352225f, 0.06333090f, 0.11610609f, 
    -0.01612990f, -0.14440100f, 0.09830995f, 0.09805022f, 0.20310210f, 0.19396447f, -0.00069550f, -0.01488349f, 
    -0.00682755f, 0.11275626f, 0.08305359f, 0.01754969f, -0.01189366f, -0.09424178f, -0.01648455f, 0.04177941f, 
    -0.08936538f, -0.01895212f, -0.02945025f, 0.13206434f, -0.00746365f, -0.01597483f, 0.03834839f, 0.05882639f, 
    -0.06409597f, -0.05464973f, -0.02232996f, -0.06492517f, 0.19162473f, 0.14380129f, -0.01451909f, 0.00126981f, 
    0.07907066f, 0.05483295f, 0.09517499f, 0.00235472f, -0.03154609f, 0.01613628f, -0.02038474f, 0.02545607f, 
    -0.48091111f, 0.05515613f, 0.07362708f, 0.15117180f, 0.01685851f, -0.00405032f, 0.05052760f, 0.07849722f, 
    -0.10595355f, 0.03984364f, 0.09620509f, 0.06596734f, -0.22748122f, 0.08487001f, -0.03947757f, 0.04452053f, 
    0.12002973f, 0.09199570f, -0.09300110f, -0.03190800f, 0.05480830f, -0.12856494f, -0.01070511f, 0.09642850f, 
    -0.26695964f, 0.05136717f, 0.00527618f, -0.01581953f, 0.06484400f, -0.04290917f, -0.04484001f, -0.05762662f, 
    0.05800998f, -0.08848593f, -0.05858154f, -0.00730197f, -0.02804266f, -0.03252635f, 0.04971731f, 0.10696077f, 
    0.00809178f, -0.00903660f, 0.08562203f, 0.01528961f, 0.01956500f, 0.02145109f, 0.05964543f, 0.05059770f, 
    0.18834680f, 0.00999106f, -0.17124684f, 0.01165129f, -0.02044612f, -0.07343870f, 0.08903481f, 0.05003005f, 
    -0.05736835f, 0.07034025f, -0.03151115f, -0.03981677f, -0.39453930f, 0.16611607f, -0.06246550f, -0.03705965f, 
    -0.07068330f, -0.09910238f, 0.04360165f, -0.03123114f, -0.03331551f, 0.02251517f, -0.00029994f, -0.04245459f, 
    0.00383275f, -0.23112454f, 0.01179477f, 0.16875446f, 0.06237224f, -0.14743257f, 0.12096687f, 0.06067413f, 
    -0.08718301f, -0.02637787f, 0.10760707f, 0.07164171f, 0.34131479f, -0.15657374f, -0.23365809f, -0.04934671f, 
    0.08118720f, 0.03525800f, 0.11750671f, -0.02918037f, 0.01285366f, -0.05859842f, 0.07785317f, 0.01282482f, 
    -0.18547811f, 0.06403451f, -0.04311249f, -0.11500911f, 0.05202504f, -0.03384297f, 0.01744526f, 0.09981842f, 
    -0.03677306f, -0.00502123f, 0.01567185f, 0.09475429f, -0.00250699f, -0.17309670f, -0.02567669f, -0.09440050f, 
    0.00301758f, 0.00914401f, -0.06059831f, -0.02308299f, -0.07889254f, -0.03576781f, -0.06932348f, 0.01983610f, 
    0.01294350f, 0.12263063f, -0.05575160f, 0.03632997f, -0.04706918f, -0.04530243f, 0.07834490f, -0.00457140f, 
    0.00324686f, -0.02468837f, -0.01032012f, 0.08927340f, -0.02870633f, -0.21020809f, 0.01196931f, 0.11460052f, 
    -0.16907805f, -0.12046813f, 0.04820270f, -0.12634417f, -0.02742784f, 0.10179821f, -0.00032755f, -0.02107764f, 
    -0.50398970f, -0.03409094f, 0.14421794f, 0.20237145f, 0.08447670f, -0.01819899f, -0.04804469f, -0.00503018f, 
    -0.12847228f, -0.03551455f, 0.03944942f, 0.06335168f, 0.03308750f, -0.19570035f, 0.05365851f, -0.02895660f, 
    0.00235705f, -0.08055878f, 0.05163009f, -0.03509075f, 0.15108447f, 0.00260441f, 0.00316559f, -0.14605261f, 
    -0.01350990f, -0.12088405f, 0.05170690f, 0.07575949f, -0.08861180f, 0.01100079f, 0.01692700f, -0.17552893f, 
    0.12281526f, -0.11129163f, -0.11598515f, -0.03066358f, 0.03201807f, 0.04640302f, 0.04950448f, 0.06230415f, 
    0.01056278f, 0.10142913f, -0.10957374f, -0.02534053f, 0.02096110f, -0.09042773f, -0.04815859f, -0.02971525f, 
    0.08350954f, 0.11675045f, 0.07373209f, -0.13565861f, 0.01638620f, 0.08570542f, 0.04559200f, -0.16575596f, 
    0.05944601f, -0.05718756f, -0.03650655f, -0.19023718f, -0.23507771f, -0.19837373f, -0.09530022f, -0.00982604f, 
    -0.00812677f, 0.03965412f, -0.03759062f, -0.05041831f, 0.02269517f, -0.08114952f, 0.00428745f, -0.05404542f, 
    0.10909865f, -0.03940208f, -0.00205561f, -0.22971798f, -0.12244581f, -0.00665724f, 0.09914683f, -0.03438894f, 
    -0.02912798f, 0.05482504f, -0.02477979f, -0.07466830f, -0.47153029f, 0.13993734f, -0.19222274f, -0.12580302f, 
    -0.02720463f, 0.05898535f, 0.01866399f, 0.13059899f, 0.03851790f, 0.04161580f, 0.02714399f, 0.06334649f, 
    -0.30994508f, 0.06488278f, 0.17301671f, 0.18731417f, -0.06026691f, -0.02161678f, -0.02596223f, -0.10310578f, 
    0.04440938f, 0.01758714f, 0.05158271f, -0.03104892f, -0.00034379f, -0.12187385f, -0.13553606f, 0.19575571f, 
    -0.04694738f, -0.06386293f, -0.08621946f, 0.01057508f, 0.05238370f, 0.06079804f, -0.01815146f, -0.01132112f, 
    0.01321559f, 0.05341450f, -0.08779753f, -0.15264021f, 0.01331657f, 0.00803845f, 0.00119362f, 0.06312534f, 
    -0.07881659f, -0.01221292f, -0.02444342f, -0.07204887f, -0.06305342f, -0.01222596f, 0.05378016f, -0.51049036f, 
    -0.01173804f, -0.05541338f, -0.00581653f, 0.01133681f, 0.00172363f, -0.01535090f, 0.03565463f, 0.05956660f, 
    -0.01854456f, -0.16273086f, -0.10938212f, 0.04213131f, 0.01033249f, -0.05771752f, 0.02071062f, -0.07619082f, 
    0.13075852f, -0.13919449f, 0.09507979f, -0.08158825f, -0.10422051f, 0.10813160f, 0.14865138f, -0.12491482f, 
    -0.17112324f, -0.01001211f, -0.09087983f, 0.04268257f, 0.04720963f, -0.08649861f, -0.15097544f, -0.18413818f, 
    0.01888659f, -0.00200589f, 0.03158369f, 0.14257307f, -0.11799659f, 0.06531005f, -0.04444328f, -0.00523352f, 
    -0.01314574f, 0.00743985f, -0.02626422f, 0.20754556f, 0.01035105f, -0.01598296f, 0.04842273f, 0.08049000f, 
    0.10879215f, -0.03292632f, 0.01872976f, 0.10985293f, 0.20733103f, 0.05959729f, 0.11018903f, 0.01322815f, 
    -0.19702300f, -0.01703275f, -0.07924203f, -0.30728477f, 0.00745914f, 0.07327113f, -0.00193401f, -0.10004198f, 
    -0.05448068f, -0.07116744f, -0.13816315f, 0.09966256f, -0.09002399f, -0.02061732f, -0.16026463f, -0.10562319f, 
    0.16336337f, -0.05543039f, -0.01326552f, 0.14417082f, -0.00878780f, -0.03044656f, 0.13778524f, -0.16476394f, 
    0.00164126f, -0.26713103f, -0.06613155f, 0.02451851f, 0.03490868f, 0.01476058f, 0.02966948f, 0.04024887f, 
    -0.01755472f, -0.14046827f, 0.12534770f, -0.01714402f, -0.13270517f, -0.18548819f, 0.27926844f, 0.16292116f, 
    -0.07173137f, 0.02885026f, -0.05709131f, -0.03932181f, -0.03594518f, 0.08220397f, -0.07583492f, 0.07891611f, 
    -0.25609231f, -0.02516828f, -0.09126379f, -0.03497924f, 0.04634451f, -0.02224479f, 0.00207403f, -0.21879956f, 
    -0.00469644f, 0.00612222f, 0.06687760f, -0.08363611f, -0.09814676f, -0.04893941f, -0.00564403f, 0.18844226f, 
    -0.00075538f, -0.07806735f, 0.09569714f, 0.05262832f, -0.14214979f, -0.12614518f, 0.04790775f, 0.05567542f, 
    -0.31082606f, 0.05258415f, 0.20239279f, 0.15541118f, -0.11757375f, 0.01739222f, 0.08650377f, 0.12073291f, 
    0.09867656f, 0.03583745f, -0.13961637f, -0.01173905f, 0.06745035f, 0.10465691f, 0.07568177f, 0.15795346f, 
    -0.04129003f, 0.05599253f, 0.06593581f, 0.12617968f, -0.00387690f, 0.06612656f, 0.09266759f, 0.15858792f, 
    -0.49270263f, -0.20679633f, 0.03879612f, 0.06586009f, -0.04303886f, 0.01195066f, 0.02143517f, 0.00010473f, 
    -0.11040995f, 0.04615465f, -0.01934249f, 0.05945237f, 0.00709227f, 0.00566911f, 0.15235019f, 0.13976979f, 
    -0.02410192f, -0.08539979f, -0.01489842f, 0.00836039f, 0.10751516f, 0.10046075f, -0.02778391f, -0.01113073f, 
    -0.08340456f, -0.11321845f, -0.00346897f, -0.19760688f, 0.06453849f, -0.14364283f, -0.03653747f, 0.01179646f, 
    0.09635104f, 0.14423896f, 0.14591046f, 0.16713518f, -0.29398626f, -0.16653033f, -0.20437846f, 0.03752566f, 
    0.05358244f, 0.00954175f, -0.09267063f, -0.02702619f, 0.06443732f, -0.01231388f, 0.08116543f, 0.11647720f, 
    0.02030165f, 0.15060215f, 0.18403287f, -0.13756475f, 0.01012144f, 0.00797433f, -0.01455770f, -0.13055050f, 
    0.05862523f, -0.07533386f, 0.03369804f, 0.03709875f, -0.05894026f, -0.02830102f, -0.07676703f, -0.11574864f, 
    0.03860696f, 0.07295244f, -0.10957800f, -0.19256246f, 0.01580696f, -0.04944969f, 0.07317729f, 0.02762913f, 
    0.06948881f, -0.08247271f, 0.10140194f, 0.01322482f, -0.15157266f, -0.12026662f, 0.09872287f, 0.16979785f, 
    0.01602617f, 0.15261821f, -0.17251037f, 0.17746066f, 0.05689817f, 0.12315491f, 0.02500506f, -0.20150815f, 
    -0.05034028f, 0.11226714f, 0.04614200f, -0.23501800f, -0.00705050f, -0.12178804f, -0.15480338f, 0.05885935f, 
    0.09706676f, 0.03930380f, -0.00150639f, -0.24533904f, 0.03949374f, -0.00709393f, 0.02340972f, 0.04388095f, 
    -0.01691586f, -0.00308400f, 0.17341523f, 0.15911399f, -0.35708252f, -0.20239441f, 0.01721046f, 0.04248655f, 
    -0.11482239f, 0.03057112f, -0.14879715f, -0.17679513f, 0.10891375f, -0.05847720f, 0.13082056f, -0.05686757f, 
    -0.17169648f, 0.22819346f, -0.14404538f, 0.03844081f, -0.06013645f, 0.06210977f, -0.10314193f, -0.00160088f, 
    -0.13636953f, -0.02396334f, 0.03942316f, -0.13878395f, -0.12652586f, 0.02659317f, -0.07208588f, -0.17443477f, 
    0.11693651f, -0.02959030f, 0.07771758f, -0.13916889f, -0.02100524f, 0.09375326f, 0.07912835f, -0.06204013f, 
    0.13259391f, 0.05403452f, -0.09551930f, -0.01723611f, 0.08791146f, -0.07554428f, 0.04797413f, -0.15840366f, 
    0.04150283f, -0.03667037f, -0.08724464f, 0.00633034f, -0.08386628f, 0.02158783f, 0.05774806f, -0.06073226f, 
    -0.12188891f, -0.11592422f, 0.01459183f, -0.03276965f, 0.13695140f, 0.01257091f, 0.06134414f, -0.18380535f, 
    -0.32468933f, -0.00106905f, -0.00737805f, -0.26530874f, 0.12670989f, 0.00089197f, -0.05563109f, -0.03924855f, 
    0.02141894f, -0.06689104f, 0.10654481f, -0.08935002f, 0.10977735f, -0.01083527f, 0.04121992f, 0.09170730f, 
    0.04299435f, 0.16864935f, -0.04771269f, -0.02191498f, -0.03320956f, -0.05136403f, 0.07230732f, 0.04636051f, 
    0.08329688f, -0.06128762f, -0.02990603f, 0.27311885f, 0.08083376f, -0.04444706f, -0.15172271f, -0.01111445f, 
    0.05340775f, 0.04872170f, 0.11168863f, -0.08194755f, -0.02557560f, 0.00339269f, 0.16300996f, 0.27068695f, 
    0.09468172f, 0.08935681f, 0.15545341f, 0.05292789f, 0.02223163f, 0.14597222f, -0.28518125f, -0.01244775f, 
    0.08713187f, 0.02863452f, -0.04562477f, 0.09540381f, 0.02900082f, -0.11911930f, -0.03425245f, -0.04201676f, 
    -0.09093379f, -0.00752159f, 0.20432089f, 0.11985561f, -0.01678443f, -0.07131632f, -0.16238090f, -0.03711588f, 
    0.08698735f, 0.23786792f, -0.02540788f, 0.04395028f, 0.10947975f, -0.16887803f, 0.03882867f, -0.11116640f, 
    -0.00546580f, 0.01461658f, -0.08739705f, 0.07050700f, 0.09957447f, -0.03096965f, -0.08415021f, 0.01006566f, 
    0.07712799f, -0.00403682f, -0.00913409f, -0.00719165f, 0.18486033f, 0.08412465f, 0.11092594f, -0.03358919f, 
    0.06049987f, -0.11100236f, 0.08782294f, -0.12554264f, -0.11685165f, 0.00799787f, -0.03324781f, -0.05234300f, 
    0.06276747f, -0.01866670f, 0.12479619f, -0.04908739f, -0.04947348f, -0.09524128f, 0.07541011f, 0.00258123f, 
    -0.03272290f, -0.07580780f, 0.02905254f, 0.08633772f, -0.16670853f, 0.07318291f, 0.17583765f, 0.38237891f, 
    -0.10340662f, 0.02725908f, -0.03800119f, 0.01363905f, 0.02093260f, -0.01598421f, 0.00242032f, -0.04544574f, 
    0.06203189f, -0.16921027f, -0.03884776f, -0.06734178f, 0.09911067f, -0.07035606f, -0.05664509f, -0.14937595f, 
    0.04853320f, 0.01272161f, 0.01966495f, -0.02529901f, -0.09244528f, 0.02220965f, 0.23250790f, -0.12554199f, 
    -0.03007584f, -0.02266559f, 0.06059534f, -0.01461700f, 0.11070446f, 0.05860236f, -0.01881944f, 0.11957537f, 
    -0.32585597f, -0.23826471f, -0.27299392f, -0.00955983f, 0.17114682f, 0.12015306f, -0.00459879f, -0.11933948f, 
    0.04411046f, 0.04660036f, -0.10785155f, 0.12333153f, -0.29932770f, -0.21987404f, -0.08878847f, -0.02715787f, 
    -0.07092671f, -0.06023505f, 0.12372651f, 0.00363243f, 0.05805892f, -0.10710710f, 0.02567386f, -0.00094222f, 
    -0.33819485f, -0.15410820f, -0.21125180f, -0.06200667f, 0.09673443f, 0.03306947f, -0.04340123f, -0.17582725f, 
    0.11470810f, -0.00773308f, -0.03426833f, 0.02779785f, -0.03729242f, -0.02753576f, 0.00199562f, 0.03642287f, 
    0.00347842f, -0.18873402f, 0.00678374f, 0.05589024f, 0.03587557f, 0.03843170f, 0.02766252f, -0.03885464f, 
    0.11365753f, -0.31968966f, 0.04399505f, -0.00101042f, -0.02047170f, 0.01307968f, 0.08866081f, 0.17275506f, 
    0.09587950f, -0.14881773f, 0.12666304f, -0.09353277f, 0.02767101f, -0.03308773f, 0.08749884f, 0.22065978f, 
    -0.00036317f, -0.16666561f, 0.01700927f, 0.00158636f, -0.02952603f, -0.05125906f, -0.20859052f, 0.09691161f, 
    -0.10303869f, 0.09166120f, 0.04473237f, 0.01524888f, 0.06358420f, 0.04546684f, 0.00993056f, -0.11637596f, 
    0.01733293f, -0.09942736f, -0.01910861f, 0.13578284f, -0.57162493f, 0.06096047f, -0.17823353f, -0.03563676f, 
    0.15944695f, 0.15385143f, -0.05802526f, -0.14237888f, 0.05135762f, -0.01938148f, 0.00149427f, -0.11269253f, 
    0.32315102f, -0.06237030f, -0.05264943f, 0.02236190f, 0.10979955f, 0.17877042f, -0.13976943f, 0.03844587f, 
    0.08220670f, -0.06187601f, -0.08570196f, -0.09216934f, -0.17997767f, 0.17780197f, 0.34730077f, -0.18752472f, 
    -0.07421689f, 0.00127969f, -0.05404403f, -0.06073518f, 0.02223073f, -0.01138994f, -0.04457666f, -0.15801165f, 
    -0.04045187f, -0.26429603f, -0.03616750f, 0.12490726f, -0.05126558f, 0.14103785f, -0.03471584f, 0.02643049f, 
    -0.10130753f, 0.11236332f, 0.08352993f, -0.06505169f, 0.07111903f, -0.05275324f, 0.01814998f, 0.20631982f, 
    -0.07656001f, -0.06929038f, 0.07827649f, 0.08187476f, 0.01978740f, -0.07083699f, -0.04714001f, 0.07139129f, 
    -0.07258094f, 0.09639011f, 0.14121869f, 0.02768412f, -0.05883360f, 0.11985268f, 0.05471271f, 0.03529148f, 
    -0.21985841f, -0.07694082f, -0.01447670f, -0.07507581f, -0.07620602f, -0.03446719f, 0.00382140f, 0.15854330f, 
    0.03435277f, 0.06483385f, 0.07466847f, 0.04415987f, -0.06133934f, -0.13557242f, -0.11575829f, -0.08290893f, 
    0.13471840f, 0.04469174f, -0.14809659f, -0.12183471f, 0.00551951f, 0.02090634f, 0.05729839f, -0.06150319f, 
    0.18125659f, -0.07176260f, -0.04698231f, -0.10416553f, -0.11912812f, 0.04982208f, 0.15751995f, -0.17709467f, 
    0.00044383f, 0.02972668f, 0.06313665f, -0.00403397f, 0.00575337f, -0.06518205f, 0.04498212f, 0.05201992f, 
    0.20149590f, -0.04363871f, -0.09629509f, -0.00734304f, -0.04685077f, 0.06609832f, -0.00584323f, -0.08510387f, 
    0.11653463f, 0.10001181f, 0.03335522f, -0.02703936f, -0.09526225f, -0.21409239f, -0.25010672f, 0.01451375f, 
    0.04546791f, -0.02897816f, 0.02979703f, -0.03740934f, 0.16331811f, 0.14938647f, -0.11774332f, 0.10338508f, 
    0.04032205f, -0.02154847f, 0.09259298f, -0.08421426f, 0.00745599f, -0.10667308f, -0.05931827f, 0.10316518f, 
    -0.01162783f, 0.06696700f, 0.07241824f, -0.00648720f, 0.00536103f, 0.18455881f, -0.07319183f, 0.11491439f, 
    -0.07735155f, -0.06206367f, 0.01393936f, -0.01183476f, -0.01878816f, -0.07409421f, 0.05387931f, 0.04474682f, 
    -0.00795081f, -0.00809985f, 0.10810051f, 0.06530980f, -0.01563121f, -0.01128476f, 0.00837139f, 0.02225627f, 
    0.06635322f, -0.00651410f, 0.03779960f, 0.12414105f, -0.29088217f, 0.25318298f, 0.08018444f, -0.17113584f, 
    0.00389845f, -0.10461266f, 0.07037679f, 0.05714590f, 0.03360922f, -0.01863398f, -0.03039206f, -0.17177145f, 
    0.09861381f, 0.07749184f, -0.00839968f, 0.06941498f, -0.08546145f, -0.00243965f, -0.01723861f, 0.05813609f, 
    -0.07424308f, 0.04937704f, 0.05119621f, 0.12420578f, -0.06464633f, 0.09764438f, 0.17162542f, 0.11186927f, 
    0.03136919f, -0.03046220f, 0.04418520f, 0.03937592f, -0.08326976f, 0.02591777f, 0.02097822f, 0.01884997f, 
    -0.19725108f, 0.10816337f, -0.01633467f, 0.30196577f, 0.02133057f, 0.00861634f, -0.04662231f, 0.04857907f, 
    0.05657372f, 0.08138313f, 0.04452096f, 0.02736288f, -0.24703541f, 0.16332774f, 0.15573460f, -0.22451183f, 
    -0.12632117f, 0.08019524f, 0.03247193f, -0.01977624f, -0.07060392f, -0.00858961f, 0.09363671f, -0.09510064f, 
    -0.21077371f, 0.00894472f, 0.07842155f, 0.05280342f, 0.00527669f, 0.01545804f, 0.08981333f, 0.00656115f, 
    -0.01388536f, 0.05121124f, -0.00673841f, -0.05167761f, 0.14591354f, -0.00747059f, 0.04882111f, -0.14650920f, 
    0.09243841f, -0.03639411f, 0.06928419f, 0.08798823f, -0.06247604f, -0.05792587f, -0.00432690f, 0.17233811f, 
    0.15796483f, 0.08924884f, -0.02507156f, -0.40548441f, -0.00909816f, 0.08343294f, 0.02646803f, -0.02823718f, 
    -0.05953367f, -0.07082319f, 0.06024164f, -0.07162680f, 0.08792468f, -0.23368977f, -0.15558353f, -0.06508591f, 
    -0.02377178f, 0.07026298f, -0.08188209f, 0.05044184f, 0.06310785f, -0.13512632f, 0.03081589f, -0.10757323f, 
    -0.13062853f, 0.00638893f, 0.04586531f, 0.23191571f, 0.05869742f, -0.14399418f, 0.09947136f, -0.06807218f, 
    0.03436501f, 0.11368318f, 0.06585968f, -0.00804245f, 0.07310523f, 0.10658679f, 0.07529648f, -0.37488183f, 
    -0.09546750f, -0.12779084f, 0.08226639f, -0.02120533f, 0.05685906f, 0.15357262f, 0.06270003f, 0.08821721f, 
    0.11431265f, -0.01123414f, -0.06015481f, -0.05614804f, 0.08443829f, 0.01473972f, 0.10288055f, -0.06667715f, 
    -0.15074745f, 0.06523284f, -0.01627098f, 0.05540903f, 0.28114530f, 0.02358410f, -0.02043415f, -0.08313531f, 
    -0.01288107f, 0.05301569f, 0.09149173f, 0.06489886f, 0.15565643f, -0.03650570f, -0.01805319f, -0.00256266f, 
    0.23256856f, -0.02850476f, -0.17699841f, 0.16210198f, -0.11069996f, 0.11591022f, -0.04779489f, 0.04213220f, 
    -0.16044757f, 0.08260413f, -0.00247501f, 0.04620829f, -0.02321129f, 0.03759312f, 0.01211369f, 0.02764286f, 
    -0.06805769f, 0.05155220f, -0.01386674f, 0.00280199f, -0.00282202f, -0.10094392f, -0.08061223f, 0.06279736f, 
    0.24891067f, -0.13359478f, -0.01021505f, 0.11980124f, 0.05489147f, 0.08938330f, -0.09631132f, -0.12577611f, 
    -0.12000475f, -0.01941864f, 0.05399252f, -0.06509923f, 0.09489278f, -0.05877594f, -0.09846634f, 0.02104253f, 
    -0.03808818f, -0.04566374f, -0.02171570f, -0.06941658f, -0.08139388f, -0.00780598f, 0.09088090f, -0.16715427f, 
    0.08057845f, 0.04791516f, -0.03877194f, -0.01438337f, -0.01495533f, 0.10537653f, 0.01965629f, 0.03408843f, 
    0.05437864f, -0.16979952f, 0.09063224f, -0.02950858f, 0.17135540f, -0.02164929f, 0.18760160f, -0.23546959f, 
    0.04629938f, 0.05263923f, 0.00050879f, 0.04912574f, -0.15782243f, -0.08121672f, -0.06668745f, 0.04386030f, 
    -0.09138246f, -0.02693740f, 0.04880103f, -0.12486508f, -0.14848603f, 0.11029626f, 0.01804015f, -0.05623121f, 
    -0.03426779f, -0.21526168f, -0.09215090f, -0.09495668f, -0.37008342f, 0.00263430f, -0.11558754f, -0.10354044f, 
    -0.08514474f, -0.00451347f, 0.15209724f, 0.01180282f, -0.02594174f, -0.01738454f, -0.11235437f, -0.08948224f, 
    -0.48379302f, 0.05198441f, 0.08755628f, 0.00020072f, 0.05939386f, 0.02828642f, -0.00534323f, 0.08138586f, 
    -0.04137471f, 0.02380852f, -0.10962681f, 0.02883882f, -0.23119350f, -0.25076771f, -0.25807756f, 0.04192811f, 
    0.01551510f, -0.01372107f, 0.01396496f, -0.03226725f, 0.08965316f, 0.03922226f, -0.06464565f, -0.00582957f, 
    0.08222184f, 0.00363003f, -0.08338283f, 0.02372124f, 0.06695691f, 0.15875120f, -0.11249685f, -0.02303514f, 
    0.05761633f, -0.08387280f, 0.04363958f, 0.08887422f, -0.43580326f, -0.04446706f, -0.05008342f, 0.10043720f, 
    0.04864566f, -0.06459417f, -0.03783108f, 0.07425443f, 0.05645639f, -0.02006662f, 0.06940246f, 0.00908353f, 
    -0.01886532f, 0.12135788f, 0.06544317f, -0.04494017f, -0.10002455f, -0.06211546f, 0.07217064f, -0.14133073f, 
    0.05431260f, -0.00434871f, -0.16500027f, -0.31558830f, 0.02660096f, -0.18938197f, -0.01622343f, 0.17670742f, 
    -0.03578972f, 0.06689534f, 0.15605220f, 0.10438734f, -0.04550539f, 0.02020977f, -0.04967003f, 0.05541137f, 
    0.24982907f, -0.29735973f, -0.10324194f, -0.10249777f, -0.04963374f, 0.08687689f, 0.03158295f, 0.01556235f, 
    -0.01945008f, 0.07809500f, 0.01893463f, 0.19919965f, -0.09071886f, -0.07831001f, 0.10126075f, -0.28247696f, 
    0.09044389f, -0.03211246f, 0.16812193f, 0.04738910f, 0.01484033f, -0.09690312f, -0.22319521f, 0.01178522f, 
    -0.13937619f, 0.10181406f, 0.00948718f, 0.18838210f, 0.06219725f, 0.12671854f, 0.09827840f, 0.01662961f, 
    -0.03391865f, 0.08390260f, 0.03675483f, -0.03900336f, -0.15232518f, 0.10682023f, -0.04936002f, 0.08155822f, 
    -0.00948204f, 0.10575660f, -0.07365276f, -0.08366635f, -0.03719087f, -0.14012323f, 0.01424543f, 0.06599820f, 
    0.46815631f, 0.00433577f, 0.06298680f, 0.03066437f, -0.13179344f, 0.06570398f, 0.03184745f, 0.02727660f, 
    0.08207644f, -0.10493832f, 0.01920353f, 0.06191414f, -0.05615086f, 0.22730792f, 0.08303290f, -0.13211420f, 
    0.03850586f, -0.13116883f, 0.11045344f, 0.09654115f, 0.03356723f, 0.04616174f, 0.01946283f, 0.03556988f, 
    0.01582326f, -0.17909437f, 0.06110248f, 0.00447168f, 0.10846934f, -0.04012473f, 0.14353304f, -0.01147485f, 
    0.01515309f, -0.03841738f, 0.00550441f, 0.05021080f, 0.01478691f, 0.04297332f, -0.15155646f, -0.03233473f, 
    0.00674582f, -0.05271814f, -0.16518043f, -0.01899095f, -0.20238149f, -0.01495030f, 0.15629618f, 0.01395503f, 
    -0.00730870f, 0.03217344f, -0.09628273f, -0.01109742f, 0.04248042f, -0.00381612f, -0.13286345f, 0.03827437f, 
    -0.12331772f, -0.07192630f, -0.05786112f, 0.01503544f, -0.12957497f, -0.01788590f, -0.24210097f, -0.51205564f, 
    -0.08026155f, -0.04444003f, -0.11540387f, -0.04177427f, -0.06587630f, 0.10490080f, -0.11075944f, 0.19256285f, 
    -0.21923532f, 0.00546830f, 0.02679441f, 0.02594453f, -0.03627248f, -0.07624213f, 0.01325367f, -0.10949168f, 
    -0.06333911f, 0.07078609f, -0.02230385f, -0.04025025f, -0.19364008f, 0.08279216f, -0.04008892f, 0.05664188f, 
    -0.03190436f, 0.04196834f, 0.01858055f, 0.07155438f, 0.00926566f, 0.08169042f, -0.07634787f, 0.13459902f, 
    -0.04326544f, 0.20843549f, -0.09501554f, 0.03044461f, -0.10846523f, 0.09825038f, -0.11805369f, -0.00450298f, 
    0.06532414f, 0.01829202f, 0.00135774f, -0.07702015f, 0.03055928f, -0.06704479f, 0.10178200f, -0.14198977f, 
    0.00503652f, -0.03991088f, -0.01594220f, 0.02829357f, -0.06629429f, 0.12915614f, -0.05237503f, -0.03196255f, 
    -0.14062908f, -0.04822724f, -0.05379158f, 0.19415055f, -0.02927493f, 0.05469155f, 0.00449877f, 0.04043954f, 
    -0.06873563f, 0.02426786f, 0.01574253f, -0.01580397f, 0.03350498f, 0.00336855f, -0.03633420f, -0.31080735f, 
    -0.01534435f, -0.03201051f, -0.05536413f, 0.11578371f, -0.02737840f, -0.09957215f, 0.04459538f, -0.16606969f, 
    -0.16184653f, -0.04094049f, -0.00049955f, -0.32780045f, 0.03957392f, 0.00860417f, 0.03806363f, -0.05650276f, 
    -0.01152073f, -0.09184036f, 0.22484249f, 0.00052256f, 0.09483049f, -0.05703244f, 0.05065585f, 0.00607100f, 
    -0.09452222f, 0.04997443f, -0.09809574f, 0.02758500f, -0.18195032f, 0.12762007f, 0.05233236f, 0.05230784f, 
    -0.08768518f, -0.21075495f, -0.06154193f, -0.16135094f, 0.01938020f, -0.08601268f, -0.01491750f, -0.09608386f, 
    -0.02262696f, 0.02763899f, 0.04424436f, 0.17073373f, 0.04711313f, 0.12316571f, 0.03461951f, -0.07228291f, 
    -0.02558979f, 0.07587112f, 0.04759926f, -0.03701079f, -0.03084900f, 0.00824160f, -0.02134019f, -0.05814091f, 
    -0.01696863f, 0.18350491f, -0.11310921f, 0.16168469f, -0.03883402f, -0.04098900f, -0.04319016f, 0.00329395f, 
    -0.14239484f, 0.11897674f, 0.10765781f, -0.03825362f, -0.14471930f, -0.11686603f, -0.15989673f, -0.07378227f, 
    -0.13525449f, -0.03358614f, -0.08393985f, 0.06610011f, 0.03363922f, -0.12777743f, -0.00873374f, -0.06338792f, 
    0.08410240f, 0.10811768f, 0.18853371f, -0.13727580f, -0.08818628f, -0.02996617f, 0.01631197f, 0.08659692f, 
    -0.00805487f, 0.02828691f, 0.05721793f, -0.07403979f, -0.02342263f, -0.19029453f, 0.00915773f, -0.02882470f, 
    -0.03715963f, -0.00854972f, 0.02955987f, 0.03856564f, -0.00709443f, 0.03748875f, 0.06929981f, -0.01492616f, 
    -0.03252967f, 0.17815466f, -0.15739639f, 0.09791847f, -0.11467388f, -0.13040535f, 0.08122213f, -0.07068162f, 
    0.04738566f, 0.02113151f, 0.04256438f, 0.01779021f, -0.04424091f, -0.12652981f, -0.08026693f, 0.16863848f, 
    -0.05101110f, 0.00303077f, -0.08199335f, 0.00526996f, 0.08235224f, -0.04039185f, -0.10216138f, 0.15589844f, 
    0.12009291f, 0.05280200f, -0.15822606f, 0.02801096f, 0.07715861f, 0.02416418f, 0.05185928f, -0.06602321f, 
    0.06642614f, 0.02234459f, -0.11037120f, 0.14312416f, -0.18584709f, -0.00501289f, 0.05838744f, -0.06456091f, 
    0.05479275f, -0.02977529f, -0.05499133f, -0.01465678f, -0.02864936f, 0.02079304f, 0.10821397f, -0.12184963f, 
    0.15710878f, 0.19024649f, 0.04981672f, -0.13557969f, -0.08166493f, -0.00915512f, 0.00301363f, 0.04723585f, 
    0.14386402f, 0.09642950f, 0.08018664f, 0.11143246f, -0.34357181f, 0.03903054f, -0.15035638f, 0.16925706f, 
    0.13553292f, 0.03746860f, -0.04446847f, 0.01619408f, 0.02069095f, 0.01520731f, 0.07638106f, 0.02544283f, 
    -0.15002835f, -0.10576680f, -0.10643809f, -0.07982570f, -0.02327937f, -0.01109553f, -0.04828592f, -0.02753466f, 
    -0.02988058f, 0.11018810f, 0.01508080f, 0.08926310f, 0.25407082f, 0.18242632f, 0.13986914f, -0.26559648f, 
    -0.10599690f, 0.03193601f, 0.03019872f, 0.12198426f, -0.02023227f, 0.02988270f, 0.01241476f, 0.08850748f, 
    -0.10625673f, -0.03270540f, -0.21664096f, 0.28108639f, 0.14284262f, -0.12800737f, 0.06680683f, -0.04039248f, 
    0.01877249f, -0.07539961f, 0.03450997f, -0.11391453f, -0.37628174f, -0.09857295f, -0.02009555f, -0.09829400f, 
    0.00880597f, -0.02257784f, 0.08487564f, 0.06162658f, -0.10912277f, -0.10111764f, -0.00952195f, -0.00886445f, 
    -0.06843362f, 0.06552023f, 0.14457104f, -0.00944128f, -0.04197795f, 0.05816189f, -0.04521432f, 0.03993903f, 
    -0.01933927f, -0.00606562f, 0.00105119f, -0.07280658f, -0.05682569f, -0.12211694f, -0.14400871f, 0.30295867f, 
    0.06058707f, 0.05634226f, -0.05098481f, 0.07680961f, -0.05527220f, 0.02912728f, -0.14529271f, -0.07219815f, 
    -0.18356016f, 0.12817866f, -0.22562481f, 0.42066929f, -0.03155698f, -0.05828963f, 0.12007119f, 0.01472925f, 
    0.02758524f, -0.09188254f, -0.02638483f, -0.14061753f, 0.37561658f, -0.65817487f, 0.05852721f, 0.01057212f, 
    -0.02974265f, 0.10622153f, 0.01851496f, 0.01450620f, 0.02092632f, 0.02088026f, 0.07817184f, 0.14384240f, 
    -0.03396697f, 0.15587898f, 0.18205659f, -0.26594546f, 0.08267075f, 0.06873665f, 0.06187581f, -0.03017893f, 
    -0.07381546f, -0.01519403f, -0.09733196f, -0.09477043f, -0.23573288f, 0.21354949f, 0.10981533f, -0.10386675f, 
    -0.04635153f, -0.00463180f, 0.08519817f, 0.09593111f, 0.02059684f, 0.06898461f, 0.04308328f, -0.06326427f, 
    0.00708259f, 0.04152977f, -0.12342260f, -0.02401889f, -0.00959181f, -0.02569504f, 0.00120496f, 0.04258747f, 
    0.01628302f, 0.00373819f, 0.01878471f, -0.04881795f, -0.03736874f, 0.16483501f, 0.04474746f, -0.13827842f, 
    0.03219644f, 0.07717606f, -0.06598541f, -0.07563227f, -0.09771284f, -0.01339454f, 0.02712129f, -0.07843428f, 
    0.12040830f, -0.11497435f, -0.01662485f, -0.02218840f, 0.01906894f, 0.01478597f, -0.11974650f, -0.00944703f, 
    0.03833427f, 0.07845673f, -0.02720091f, -0.02173503f, 0.15275335f, -0.03820271f, 0.07469555f, -0.11713307f, 
    -0.06952963f, -0.00759026f, -0.05126808f, -0.08528490f, 0.03545151f, -0.02728262f, 0.02857169f, 0.04628333f, 
    -0.02773609f, 0.04414969f, -0.18759958f, 0.07362787f, -0.08001934f, -0.04665038f, -0.03966565f, -0.09204186f, 
    -0.02303433f, -0.02904801f, 0.01389877f, -0.00949480f, -0.02303649f, 0.14621566f, -0.12212150f, 0.07280301f, 
    -0.05241958f, -0.00841589f, -0.00731182f, -0.05473410f, -0.05624631f, -0.08555356f, 0.00545134f, -0.04840546f, 
    0.02796503f, 0.00793573f, 0.09206294f, -0.02517349f, 0.03632699f, 0.05090202f, -0.06677958f, 0.02780088f, 
    -0.04118282f, -0.01065212f, 0.02623782f, -0.03382601f, 0.21121219f, 0.08316056f, 0.13350290f, 0.06769527f, 
    -0.00597237f, -0.01009323f, 0.00577599f, -0.08576824f, -0.03963122f, 0.02079746f, -0.03391339f, -0.06783471f, 
    0.14067025f, 0.05523082f, -0.09246614f, 0.05196008f, 0.02249509f, -0.03239387f, -0.05825358f, -0.07986090f, 
    -0.06999832f, 0.04561491f, -0.00952205f, 0.00490919f, -0.32705173f, 0.13548164f, 0.05222591f, 0.01861607f, 
    -0.05055374f, -0.02522183f, 0.02408180f, -0.03269654f, -0.04595198f, -0.01162877f, 0.07936001f, -0.03020584f, 
    0.03455297f, 0.15415064f, 0.00346711f, 0.23731731f, 0.16826348f, -0.03380729f, 0.12415008f, 0.05156256f, 
    0.04651893f, -0.00716529f, 0.07297222f, 0.04804708f, 0.24747448f, -0.13997838f, 0.04722977f, 0.12843837f, 
    0.00648449f, -0.05492864f, -0.06976230f, -0.06734736f, -0.03112713f, 0.01855142f, -0.07933113f, -0.07413046f, 
    0.02035717f, -0.07203639f, 0.03174210f, -0.03400340f, -0.04170908f, 0.09573251f, -0.00177029f, 0.00903542f, 
    0.08256988f, -0.07704525f, -0.03459315f, 0.02727201f, -0.14397387f, -0.01016186f, -0.21306795f, 0.02867929f, 
    -0.07033760f, -0.10097432f, 0.00132134f, -0.00557538f, -0.03253939f, -0.02647440f, 0.00913799f, -0.01194813f, 
    -0.08306397f, 0.11027789f, -0.05314990f, 0.05630696f, -0.01345721f, -0.10128526f, -0.06414511f, 0.00663993f, 
    -0.03579346f, -0.02688635f, -0.03513630f, -0.04059856f, -0.01215814f, -0.09315268f, 0.08322018f, -0.13415131f, 
    0.09318255f, 0.04538428f, -0.03090712f, -0.02750054f, -0.05269958f, 0.02494403f, 0.02166518f, -0.05841770f, 
    -0.14509916f, 0.14627741f, -0.01096949f, -0.06612392f, -0.05764689f, -0.01889268f, 0.02402277f, -0.04726849f, 
    0.01675182f, 0.06884646f, -0.11338034f, -0.09408115f, 0.03315385f, 0.09626944f, 0.18841961f, 0.10683925f, 
    0.07306981f, 0.04034695f, -0.07988577f, -0.06012092f, 0.04983380f, 0.03480093f, -0.08371814f, -0.06980550f, 
    -0.09854698f, 0.12920159f, 0.03399487f, 0.06971690f, 0.02191849f, -0.02610308f, 0.02660923f, -0.03359159f, 
    0.03559744f, 0.03441929f, -0.06480723f, -0.01560836f, -0.04420273f, 0.11835971f, 0.06655084f, 0.10718835f, 
    0.12475061f, 0.02893714f, 0.00323868f, -0.00206731f, 0.07390717f, 0.02317086f, -0.01758968f, -0.02841063f, 
    -0.00243620f, -0.26124248f, 0.01615615f, -0.00598447f, -0.00185698f, -0.05561639f, -0.00255299f, -0.07924483f, 
    -0.06465263f, -0.01905801f, 0.04168352f, -0.08987793f, -0.18419883f, 0.06001621f, -0.01624562f, -0.04280922f, 
    -0.00496304f, -0.01965015f, -0.03324540f, -0.00012064f, 0.01085298f, 0.02148301f, -0.02206892f, -0.04567576f, 
    -0.14674893f, -0.19921093f, -0.06343239f, -0.01393292f, -0.00990156f, -0.07184412f, 0.00098916f, 0.04586785f, 
    -0.04042127f, 0.00320106f, 0.00965861f, -0.00991377f, 0.11597185f, 0.09147504f, -0.05144577f, 0.21297674f, 
    0.10100736f, -0.04719615f, -0.07512229f, 0.10318418f, 0.04234757f, -0.06056529f, -0.02055266f, -0.12664232f, 
    0.05054037f, 0.04961339f, 0.06082474f, -0.00533734f, -0.06660015f, 0.00710821f, 0.01695346f, 0.03347469f, 
    -0.03947620f, -0.02201886f, -0.05703898f, -0.03942051f, 0.17283319f, 0.06506188f, -0.06864586f, -0.14405151f, 
    0.02720342f, 0.06679793f, -0.03625759f, 0.00221729f, -0.01992478f, 0.01864788f, 0.00360157f, -0.04763987f, 
    -0.21329680f, 0.10441408f, -0.04833066f, -0.02441071f, -0.13355905f, -0.02035959f, -0.06087567f, 0.00363701f, 
    0.05090469f, -0.04434717f, -0.08693497f, -0.05759723f, -0.09657740f, -0.02674420f, -0.27732915f, -0.04291833f, 
    -0.04576347f, 0.04571595f, -0.07267073f, -0.03994065f, -0.10887848f, 0.01014376f, 0.02955656f, -0.04673294f, 
    0.31601593f, -0.20718582f, 0.05051172f, -0.18916954f, -0.07753327f, 0.06124281f, -0.04932093f, -0.07114547f, 
    -0.01265651f, 0.07269116f, -0.08379117f, 0.03080581f, -0.28361803f, -0.20557487f, -0.16213898f, -0.26643559f, 
    0.09237844f, -0.06606509f, 0.01502956f, -0.07355806f, -0.03659081f, -0.00730965f, -0.02361405f, -0.03028972f, 
    0.24864860f, -0.02258907f, 0.01223907f, -0.03682362f, -0.06125345f, -0.08374906f, -0.01424066f, -0.13861805f, 
    -0.06674208f, 0.03853829f, 0.00842773f, -0.10813107f, 0.03775633f, 0.06762230f, 0.11899863f, 0.18545131f, 
    0.09652499f, -0.08454696f, -0.06961784f, 0.00897246f, -0.04212781f, -0.07566896f, 0.04072002f, -0.04565931f, 
    0.03608957f, 0.02034167f, -0.00818255f, 0.17596006f, -0.05909073f, -0.11311983f, -0.12686075f, -0.06480832f, 
    0.04115602f, 0.02129301f, -0.03921471f, 0.02682428f, 0.04827924f, 0.14465794f, 0.20594339f, 0.22124618f, 
    0.08995562f, 0.04192317f, 0.10085046f, -0.09665954f, -0.07878970f, 0.04675422f, 0.01356946f, -0.10796563f, 
    0.08890463f, 0.07691861f, -0.01467826f, 0.06959616f, 0.05833805f, 0.00123066f, 0.04248503f, -0.08305808f, 
    -0.04127253f, -0.09692977f, -0.06070871f, 0.03509505f, 0.13680635f, 0.05140680f, -0.03854792f, -0.14397694f, 
    -0.04563662f, -0.03265711f, -0.03247249f, -0.06386620f, 0.01596678f, 0.03677214f, -0.03393081f, 0.03450494f, 
    -0.17287895f, 0.09690911f, 0.01000407f, 0.10595091f, -0.18966839f, -0.08149520f, -0.05601488f, -0.02758572f, 
    -0.08671996f, -0.02208218f, -0.04111653f, -0.03449063f, -0.02735401f, 0.03526136f, 0.05534624f, 0.15038769f, 
    0.07903939f, -0.00718441f, -0.05787303f, -0.05134307f, -0.00710310f, -0.03187824f, -0.01430704f, -0.03364949f, 
    -0.07221708f, 0.19902557f, 0.02502016f, 0.21948490f, 0.17403351f, 0.01375878f, -0.01950756f, 0.02023417f, 
    -0.01335052f, -0.05924746f, 0.07778465f, -0.02212927f, -0.42277098f, 0.11603372f, -0.05241213f, -0.06379799f, 
    -0.05383964f, 0.01633356f, -0.06364124f, -0.10942147f, -0.04323062f, -0.01955396f, -0.06017068f, -0.10906786f, 
    0.15439570f, 0.05810257f, 0.14640257f, 0.09530970f, 0.05038207f, 0.10641655f, 0.03256584f, -0.04816988f, 
    -0.04605103f, -0.00900426f, -0.01451888f, -0.04131239f, -0.04154873f, 0.12574078f, 0.07420522f, 0.12671413f, 
    0.06100265f, -0.02103205f, 0.03806036f, 0.00152658f, 0.00555589f, 0.05280019f, -0.00003257f, 0.01982204f, 
    0.18686470f, 0.10583164f, 0.18544978f, 0.14501505f, 0.10333426f, 0.01598694f, 0.07403164f, -0.08905294f, 
    -0.02306410f, 0.08364422f, 0.03802906f, -0.07767691f, -0.06447555f, -0.02504604f, -0.28819039f, -0.11745486f, 
    -0.02364686f, -0.00077914f, 0.00221763f, -0.08032281f, -0.14635968f, 0.04015586f, 0.00842793f, -0.02067866f, 
    -0.14745991f, -0.10384040f, -0.16288593f, -0.17461176f, 0.01369630f, 0.01126735f, 0.00065148f, -0.00533080f, 
    -0.07306740f, -0.02472037f, -0.02403193f, -0.01557185f, 0.04203794f, 0.08600170f, -0.01786942f, 0.15819278f, 
    -0.06269145f, -0.05999595f, -0.14192460f, -0.07424390f, -0.00006176f, -0.06174964f, -0.01688751f, -0.06691959f, 
    -0.15303522f, -0.01569979f, -0.11429916f, -0.06014418f, -0.08023649f, 0.00315657f, -0.04151874f, -0.09023715f, 
    -0.01289413f, -0.04624117f, 0.04413329f, -0.01672505f, -0.21564533f, 0.06509391f, 0.20029651f, -0.01906257f, 
    0.01909027f, 0.07282335f, 0.02051755f, 0.01339791f, -0.06963879f, -0.00028232f, 0.09012189f, -0.02639388f, 
    0.29445666f, 0.23322330f, -0.01030760f, 0.18378027f, 0.11039074f, 0.06862172f, 0.13461114f, 0.01910535f, 
    -0.01154782f, 0.03736681f, 0.00507496f, -0.00083347f, 0.02310712f, 0.03559870f, 0.03876174f, -0.07538594f, 
    -0.01582450f, -0.05722049f, -0.01609020f, -0.07140770f, 0.01617472f, 0.04132987f, -0.03224187f, -0.00039542f, 
    -0.04107792f, 0.10723127f, -0.00268379f, 0.09062844f, -0.06261390f, -0.01897690f, 0.01704943f, -0.03632123f, 
    -0.10811573f, -0.04022723f, -0.01732879f, -0.06860837f, 0.16866969f, 0.08539017f, 0.03935305f, 0.06832450f, 
    0.03294425f, -0.03958471f, 0.02530309f, -0.07905529f, -0.00396711f, 0.00822965f, -0.03128902f, -0.06562582f, 
    -0.21328115f, -0.03960550f, -0.05405793f, -0.14343235f, 0.04093545f, -0.01733363f, -0.00407709f, -0.08847705f, 
    -0.07257590f, -0.03930019f, -0.01810597f, -0.04778932f, -0.10730941f, 0.01910070f, -0.10261418f, 0.09049837f, 
    -0.07062329f, -0.03754282f, -0.06813535f, -0.08290195f, -0.12736264f, 0.01135338f, 0.08262038f, 0.02458969f, 
    -0.16523428f, 0.23322049f, 0.10696555f, 0.02466418f, 0.04137461f, 0.05522233f, 0.04819352f, -0.05979868f, 
    0.00493432f, 0.03827537f, 0.05413014f, -0.02551756f, -0.01917086f, 0.02216319f, -0.20443106f, -0.09729625f, 
    -0.04115390f, 0.02014000f, 0.04734422f, -0.05379239f, -0.06678046f, -0.08559926f, -0.00092795f, -0.10862687f, 
    -0.06743976f, 0.08559480f, -0.16007623f, 0.05612814f, 0.01374188f, -0.00557650f, 0.00548444f, -0.00880687f, 
    0.04163037f, -0.06933653f, 0.05034734f, -0.02739908f, -0.08832280f, 0.07885604f, -0.00016183f, 0.13037615f, 
    0.01733070f, -0.05128443f, -0.01860636f, 0.02207300f, -0.06034334f, -0.08549446f, -0.03884327f, -0.05959846f, 
    -0.11172789f, 0.20678620f, -0.02818101f, -0.20376703f, -0.02650267f, -0.03481991f, 0.04699155f, 0.00480910f, 
    -0.05070814f, -0.04561190f, 0.01268865f, -0.05983823f, -0.22621560f, 0.09112508f, -0.00989670f, 0.04690640f, 
    -0.09963430f, -0.08077162f, -0.02478280f, 0.01851220f, -0.01125205f, 0.05100643f, 0.05034082f, 0.00628642f, 
    -0.01225521f, -0.21511103f, -0.13008024f, -0.03134638f, 0.03447866f, -0.04136792f, -0.03783754f, 0.04431489f, 
    0.05476068f, -0.08372147f, -0.01767493f, -0.08027066f, -0.06022919f, 0.05345767f, 0.06129792f, -0.23620291f, 
    0.01939937f, -0.00026104f, 0.00412039f, -0.01230728f, -0.04054358f, 0.02529948f, -0.02769409f, 0.00917383f, 
    -0.17821585f, -0.29433039f, -0.00126423f, -0.00104853f, -0.02804051f, -0.04980484f, -0.05091064f, -0.01797346f, 
    -0.06581298f, -0.01247517f, 0.01087224f, -0.03992550f, 0.01255720f, 0.11181320f, -0.21872418f, -0.06398822f, 
    0.04611866f, 0.00366411f, 0.01655542f, -0.01650864f, -0.07600447f, 0.05552011f, 0.12095027f, -0.01427332f, 
    -0.03081889f, 0.05414800f, -0.21920250f, -0.23991688f, 0.05099681f, 0.02048416f, -0.07581960f, 0.04471359f, 
    0.07283431f, -0.07256044f, 0.07249098f, 0.04885175f, 0.06941465f, -0.28920287f, 0.09616692f, 0.12558883f, 
    0.03349059f, -0.06871650f, -0.03409946f, -0.01007052f, 0.07434548f, -0.06931829f, 0.03011953f, -0.08357971f, 
    0.09687948f, 0.14856118f, -0.15340015f, 0.06373865f, -0.01623975f, -0.00234168f, -0.07042401f, 0.02216940f, 
    0.02184392f, 0.09062245f, 0.05659470f, 0.04970812f, 0.15852098f, 0.13030095f, -0.02265923f, 0.05867971f, 
    -0.01709020f, -0.09510108f, -0.06939228f, 0.03902752f, 0.02836683f, 0.01846531f, -0.09719251f, -0.16428694f, 
    -0.26004836f, -0.09039324f, -0.14072353f, 0.03475624f, 0.13943224f, 0.07816362f, 0.04047105f, -0.04118088f, 
    0.03284124f, 0.13964893f, -0.13588403f, 0.04514753f, -0.15964724f, 0.20539752f, -0.18812728f, -0.09755432f, 
    -0.06315153f, -0.00825246f, -0.06884639f, 0.09370802f, 0.00963011f, -0.02210358f, 0.03055772f, -0.03248265f, 
    -0.20210706f, -0.00473492f, 0.13216396f, -0.07291570f, 0.04058003f, -0.10036631f, -0.02551671f, -0.10311100f, 
    -0.03886474f, -0.10697238f, -0.16901304f, 0.01869790f, -0.09432188f, -0.18354312f, 0.12520702f, -0.09549993f, 
    0.02382668f, -0.00432460f, 0.00819976f, -0.01892303f, -0.01475381f, 0.10493635f, 0.00667129f, -0.02682471f, 
    -0.20869322f, 0.12344057f, 0.17986336f, 0.00516089f, 0.06692349f, -0.06462026f, 0.01430343f, 0.09311664f, 
    0.13489048f, -0.04476230f, 0.10086242f, -0.05839955f, 0.04373812f, -0.18352915f, -0.05547294f, 0.14409113f, 
    0.09825041f, -0.08101436f, -0.12774901f, 0.02045609f, 0.05440159f, 0.04046347f, 0.01616850f, -0.03245047f, 
    -0.03305818f, 0.04764150f, -0.04769874f, -0.00066888f, 0.03004286f, -0.07292666f, 0.09632638f, -0.05091172f, 
    0.02371428f, -0.04396039f, -0.02869955f, 0.01852523f, 0.15677144f, 0.11002720f, -0.03977545f, -0.13631175f, 
    0.03790839f, 0.05242585f, 0.01421542f, -0.02609952f, 0.09068964f, -0.03623077f, 0.09067208f, -0.00267063f, 
    0.06539817f, -0.00752750f, -0.16741015f, -0.15471274f, 0.00332743f, -0.01508327f, 0.12312412f, -0.04157288f, 
    0.05249579f, 0.01042743f, -0.07510188f, -0.00556306f, 0.00837983f, 0.10691279f, -0.12252218f, 0.01708266f, 
    -0.05681367f, 0.03275668f, 0.02648813f, -0.15851431f, 0.05192797f, 0.06430133f, 0.07364442f, 0.07909213f, 
    0.02641468f, 0.13028470f, -0.15666147f, 0.02430605f, 0.04976579f, -0.04708919f, -0.16548605f, 0.01816595f, 
    0.01649287f, 0.05977753f, -0.01738053f, 0.04785832f, -0.12063602f, -0.07234506f, -0.05970039f, 0.02694895f, 
    0.00366295f, -0.07185548f, -0.06570093f, -0.02381948f, 0.00971605f, 0.04969993f, -0.03003894f, 0.11661685f, 
    -0.14897279f, -0.09609395f, -0.10704748f, -0.12451813f, -0.01938005f, -0.05673074f, 0.05705967f, -0.09052962f, 
    -0.02051913f, 0.06229310f, 0.01539874f, -0.00234040f, -0.21788947f, 0.10123270f, 0.11018796f, -0.07930283f, 
    -0.03188107f, -0.05852942f, -0.06857563f, -0.09402461f, -0.00201054f, -0.08615425f, -0.01302679f, 0.10563194f, 
    0.10400053f, 0.11909666f, -0.05547468f, 0.12202964f, 0.08074773f, -0.06653299f, -0.01417723f, -0.09950771f, 
    -0.07610902f, 0.04206047f, 0.06079827f, -0.06906120f, -0.07900839f, 0.07527088f, 0.05335722f, 0.12774663f, 
    -0.20786920f, 0.02660075f, -0.10885531f, -0.12251002f, -0.01212885f, -0.11152975f, 0.09084440f, -0.08088408f, 
    -0.02393228f, -0.09884272f, -0.00043269f, -0.08621220f, 0.08597741f, -0.03318742f, 0.01126592f, 0.00141034f, 
    0.13166018f, 0.07195411f, -0.11197393f, 0.04426126f, 0.13925853f, 0.02290418f, -0.07878366f, 0.10404494f, 
    0.06371123f, 0.00688823f, -0.05458719f, -0.07974171f, 0.00303179f, -0.06812043f, -0.03041048f, 0.05822708f, 
    0.09249356f, -0.09086727f, -0.10198417f, 0.02704392f, 0.12068775f, -0.01261290f, -0.02174677f, -0.07580930f, 
    -0.07632171f, -0.01890572f, 0.07511960f, 0.16244870f, 0.19505465f, -0.08177462f, 0.04899679f, -0.19788700f, 
    -0.08449861f, -0.04153602f, 0.04538633f, -0.19167474f, -0.08132727f, 0.02153043f, 0.08445968f, 0.04181087f, 
    -0.05978424f, 0.10495206f, -0.07082352f, -0.19214588f, -0.05446364f, -0.06262561f, 0.03762844f, 0.05088541f, 
    0.01019688f, -0.09234287f, 0.00542218f, -0.02853419f, -0.11177312f, -0.12456086f, 0.12898576f, -0.04698783f, 
    -0.01661981f, -0.05989224f, 0.06625108f, -0.03164855f, -0.10999175f, 0.10668010f, -0.02152518f, 0.01556910f, 
    0.04760372f, 0.19334146f, -0.08013347f, 0.07628535f, 0.09913702f, -0.00748152f, -0.04120567f, -0.02272310f, 
    -0.00322973f, -0.02390515f, -0.05344860f, -0.03994712f, -0.07575706f, 0.22798941f, -0.01831508f, -0.02368805f, 
    -0.04228414f, 0.04035793f, -0.06341039f, -0.01522554f, 0.11235551f, 0.14076871f, -0.15464370f, -0.10345495f, 
    -0.10288396f, 0.06985687f, -0.00147874f, -0.03268587f, 0.03180135f, -0.04689527f, -0.04098547f, 0.03655536f, 
    0.05068743f, -0.08482722f, 0.05988784f, -0.00380829f, 0.01986798f, -0.10782601f, -0.15075196f, 0.17192735f, 
    0.17040212f, -0.03531788f, -0.06829254f, -0.01780780f, -0.03324819f, -0.06964447f, 0.19850560f, -0.07879136f, 
    0.00450174f, -0.15231279f, 0.01733081f, -0.25071451f, -0.05319842f, -0.05781204f, -0.16200216f, 0.10697403f, 
    -0.12482717f, 0.02840168f, 0.09778264f, 0.00155679f, -0.13910629f, 0.00495545f, -0.26054728f, -0.31335601f, 
    0.04756001f, -0.08587528f, 0.04141248f, 0.00443790f, 0.00235574f, -0.04447194f, -0.16802153f, 0.04457905f, 
    -0.17587069f, -0.16082789f, -0.21440576f, -0.23807847f, -0.11994147f, -0.08035249f, 0.05232915f, 0.03667988f, 
    0.09780001f, 0.01921093f, 0.12904432f, -0.08706528f, -0.17402281f, -0.01014785f, 0.06639774f, 0.00344713f, 
    0.05880883f, 0.04959678f, -0.03688529f, -0.30107683f, -0.00361290f, -0.05940694f, -0.01828690f, -0.00660346f, 
    -0.17416081f, -0.05311154f, -0.07116385f, -0.13468570f, -0.04345506f, 0.06719237f, -0.04928325f, 0.01870906f, 
    -0.03150427f, -0.02171537f, 0.05745003f, -0.07285545f, 0.22225076f, 0.04357300f, 0.01676881f, -0.00184293f, 
    0.09068798f, -0.08178673f, -0.09487665f, -0.08200538f, 0.02065104f, 0.01276031f, -0.02432515f, -0.05450961f, 
    -0.09739041f, -0.11522864f, -0.16119893f, 0.07623505f, 0.00402744f, -0.11157831f, -0.04331965f, 0.01317158f, 
    -0.03398506f, 0.08667978f, 0.03262999f, -0.12181194f, -0.21966513f, -0.28840140f, -0.16329642f, -0.27892074f, 
    0.05621088f, 0.04675217f, -0.11579572f, 0.08078261f, 0.13957031f, 0.02313211f, 0.10337693f, -0.06468251f, 
    0.02068427f, 0.00893726f, -0.02731853f, 0.02880802f, -0.00158612f, -0.08181988f, -0.07474313f, 0.01509945f, 
    0.03291447f, 0.01584164f, -0.11559673f, -0.06924170f, 0.06297225f, 0.07982074f, 0.08513156f, 0.22280149f, 
    0.06997951f, -0.02900935f, -0.04701190f, -0.01666041f, 0.07770460f, 0.09276171f, 0.02494942f, 0.03568677f, 
    -0.22981767f, -0.16396984f, 0.21958180f, -0.14085709f, 0.01609612f, -0.04629087f, 0.05853488f, -0.13368681f, 
    -0.01410657f, -0.11524170f, 0.01148099f, 0.08526579f, 0.05475705f, -0.04192485f, 0.06028638f, 0.05199066f, 
    -0.03706594f, -0.07445277f, 0.13237253f, 0.01622983f, 0.08712396f, -0.03270084f, 0.12368351f, -0.04119079f, 
    -0.02762521f, -0.00968551f, 0.16148797f, 0.04764235f, -0.12238298f, -0.04235543f, -0.06749485f, 0.01924601f, 
    0.00978404f, -0.03507944f, 0.02006973f, -0.05177013f, 0.00295058f, -0.05830112f, 0.02833433f, 0.00065116f, 
    -0.02966539f, 0.00537226f, -0.04270593f, -0.01833207f, 0.03426493f, 0.01288246f, 0.08572186f, -0.10720601f, 
    0.11199468f, 0.04376944f, -0.12208386f, 0.09838534f, 0.01934758f, 0.05002900f, -0.02982396f, 0.06955311f, 
    -0.01370669f, -0.04624045f, 0.04489477f, -0.00880849f, -0.04739194f, 0.07210767f, -0.18234532f, -0.39905474f, 
    -0.06813736f, 0.00132719f, 0.04510291f, 0.01184570f, 0.05420290f, 0.04157063f, 0.00714481f, 0.11998966f, 
    0.08717895f, -0.11147476f, 0.08451611f, 0.11782020f, 0.10153712f, 0.03846278f, -0.00042864f, -0.05261760f, 
    -0.07917500f, -0.02835146f, 0.09981388f, -0.05003227f, -0.05033893f, -0.05052194f, 0.15963091f, 0.06891519f, 
    -0.07835940f, -0.02148421f, -0.09519906f, 0.04507303f, 0.01518484f, -0.03390149f, 0.00046653f, 0.05560627f, 
    -0.04359056f, 0.10660687f, -0.05740139f, -0.14379461f, -0.06377206f, 0.08157615f, -0.05983014f, 0.07766397f, 
    0.06102438f, -0.11804155f, -0.00864294f, -0.15511505f, 0.19488940f, -0.05601250f, -0.02168069f, 0.04080597f, 
    -0.03711100f, -0.12214837f, -0.05735071f, -0.04914707f, 0.00048882f, -0.03132586f, 0.01853864f, -0.08906361f, 
    -0.18775550f, -0.03173668f, -0.00245330f, -0.02911159f, 0.08891857f, 0.05890938f, -0.17286025f, 0.01143752f, 
    0.09018044f, -0.05845910f, -0.02454938f, -0.09313532f, 0.04467162f, -0.04000930f, 0.11588719f, -0.19347174f, 
    0.06924962f, -0.03760824f, 0.02232700f, 0.06443102f, 0.01741696f, 0.07578875f, 0.03933775f, 0.07497923f, 
    -0.03785950f, -0.12288341f, -0.05433753f, 0.20427756f, 0.13316453f, 0.01820083f, -0.05151000f, -0.09284510f, 
    0.02175651f, 0.09571435f, 0.02079921f, -0.04600265f, -0.03421259f, -0.00965926f, -0.05428429f, -0.14079295f, 
    0.02492134f, 0.00650624f, -0.09446217f, 0.09345368f, 0.11440783f, -0.03331871f, -0.11428581f, -0.03722754f, 
    0.08310768f, 0.08398107f, 0.08441224f, 0.12708561f, -0.13651951f, 0.02980834f, 0.00827723f, 0.00918737f, 
    -0.01603260f, -0.04214638f, 0.02068836f, 0.01901953f, -0.02966704f, -0.03700817f, 0.01118516f, 0.11482759f, 
    0.11106483f, 0.00528288f, -0.02291507f, -0.04918919f, -0.10200847f, 0.03664634f, 0.11619880f, -0.04424905f, 
    0.00209298f, 0.17292722f, -0.19700606f, -0.00253148f, -0.07431670f, 0.00582888f, -0.06973733f, -0.02586467f, 
    0.00497805f, 0.00389893f, -0.03229116f, -0.08342395f, -0.17488626f, 0.02189888f, 0.19252849f, 0.03170004f, 
    -0.09133310f, -0.04575334f, -0.04200953f, 0.07634114f, -0.06393519f, -0.04881230f, -0.00789907f, -0.01730861f, 
    0.08145124f, -0.05811337f, -0.11070953f, 0.06693949f, 0.07095031f, -0.12685768f, 0.04179968f, -0.04923013f, 
    0.04126700f, 0.08937304f, 0.00541369f, 0.08534528f, 0.23078659f, 0.21262722f, -0.20093486f, -0.04890647f, 
    -0.00271538f, -0.01896419f, 0.04084166f, -0.05382128f, 0.02794190f, 0.01048192f, 0.10808413f, 0.08169843f, 
    0.27249455f, 0.26839879f, -0.10379730f, 0.01684574f, 0.11490659f, 0.02177329f, -0.11700980f, 0.01453912f, 
    -0.03335471f, 0.02414928f, 0.00892743f, 0.08169884f, 0.04409213f, -0.18325953f, 0.10752826f, 0.10981983f, 
    -0.02800195f, -0.10718811f, -0.02897864f, -0.14094716f, 0.10480240f, 0.01702921f, -0.15190342f, -0.12707338f, 
    -0.20334139f, -0.10652185f, -0.08150941f, 0.07804384f, 0.05913964f, -0.00821381f, -0.02066398f, 0.01495326f, 
    0.12871458f, 0.06776582f, -0.07198006f, 0.06310789f, -0.15759879f, -0.03661664f, -0.05860688f, 0.08676124f, 
    -0.01081821f, 0.03701364f, -0.12550354f, 0.00769459f, 0.03680129f, 0.08914034f, 0.02106061f, -0.06540998f, 
    0.08709212f, -0.10354137f, 0.02610259f, -0.06914102f, -0.06600759f, 0.04380135f, 0.04338653f, 0.01180224f, 
    -0.01866103f, -0.06266833f, 0.00648347f, -0.04448314f, -0.48329949f, 0.23033272f, -0.20161028f, -0.07909250f, 
    0.04281518f, 0.01260960f, -0.07646894f, -0.03181979f, 0.02023168f, -0.08032132f, 0.01400109f, 0.09260929f, 
    0.34249398f, -0.14094657f, 0.08494947f, 0.03417991f, -0.10488594f, -0.01317887f, 0.07160735f, 0.10012942f, 
    -0.02525109f, 0.06214219f, -0.07830018f, 0.14279589f, -0.16782564f, -0.05199110f, -0.13409491f, 0.05135373f, 
    0.03624580f, -0.07242788f, 0.00256997f, -0.10220443f, -0.04323203f, 0.04076972f, 0.03769319f, 0.05091251f, 
    -0.01048960f, 0.16460900f, -0.10564867f, -0.35264245f, -0.06434514f, -0.06897777f, 0.00094356f, 0.14655834f, 
    -0.07025625f, -0.02694917f, -0.01148781f, -0.15993029f, -0.23576361f, 0.43461284f, -0.03329608f, 0.17315502f, 
    0.02777599f, 0.08618823f, -0.03841764f, -0.05660729f, -0.09739932f, 0.05253965f, -0.03242042f, -0.01655206f, 
    -0.03024797f, -0.03558627f, -0.02014783f, 0.18460436f, -0.21142888f, 0.02778353f, 0.02798654f, 0.12171609f, 
    -0.04419577f, 0.04536943f, 0.07805588f, 0.06161053f, -0.20100179f, -0.26268208f, -0.09314995f, 0.04631546f, 
    0.02531042f, 0.07909240f, 0.08331948f, -0.08737154f, 0.06814492f, 0.15142620f, -0.03567509f, -0.01167446f, 
    0.26964644f, 0.22561346f, -0.04234316f, -0.07847930f, -0.09771629f, 0.00630886f, -0.02093835f, -0.05990971f, 
    0.08310948f, 0.08887830f, 0.00798113f, 0.01294647f, -0.16461346f, 0.16919112f, -0.10964637f, -0.27207068f, 
    -0.01757442f, -0.16272178f, -0.00046061f, 0.11617595f, 0.00679390f, -0.05322918f, -0.01329845f, -0.02192389f, 
    -0.07306779f, -0.35874987f, 0.17471437f, -0.19933724f, 0.02507489f, 0.06200790f, 0.04933562f, 0.01291196f, 
    0.01939632f, -0.07427625f, 0.01866800f, 0.09187829f, 0.00650737f, -0.39918497f, 0.03307064f, -0.20325534f, 
    -0.02835744f, -0.01428704f, -0.04006478f, -0.04557897f, -0.04116081f, 0.01593172f, 0.04784752f, 0.04542549f, 
    0.24021272f, 0.09155102f, -0.13537866f, 0.04640768f, 0.04836177f, -0.07547770f, -0.10879888f, -0.01242836f, 
    0.05779884f, -0.05102894f, 0.00667359f, 0.09197089f, 0.12376243f, 0.47293648f, -0.26361471f, -0.21851878f, 
    0.09818514f, -0.02907165f, 0.03059711f, -0.01528062f, -0.02941961f, 0.03589714f, -0.06295492f, -0.00908894f, 
    -0.01962544f, -0.01273251f, 0.04589351f, -0.18474095f, -0.08479016f, -0.00508489f, -0.01809419f, 0.06279902f, 
    0.00191316f, -0.02957002f, 0.08891979f, 0.04789781f, -0.02092789f, -0.08096017f, 0.06804553f, 0.22274326f, 
    -0.05008336f, 0.09980743f, 0.06792824f, -0.03793399f, -0.00833483f, 0.00155594f, 0.10468313f, -0.10547189f, 
    -0.23912245f, 0.11416092f, -0.11479971f, 0.23229980f, -0.04987814f, -0.00531292f, 0.03440687f, -0.02663697f, 
    -0.06353095f, -0.03494765f, -0.09104663f, -0.09856810f, -0.23956232f, -0.31393582f, 0.01269114f, -0.07484036f, 
    0.11360813f, 0.06471039f, -0.04399341f, -0.04283531f, -0.07965302f, -0.00502998f, -0.10631089f, -0.02716564f, 
    0.12413700f, 0.01465841f, -0.12300159f, -0.00059060f, 0.07852019f, -0.02732168f, -0.01274440f, 0.07940017f, 
    -0.01651982f, 0.06802777f, 0.03578255f, -0.10340572f, -0.00419929f, -0.30172712f, 0.05417981f, -0.06361251f, 
    -0.03866109f, -0.07478078f, 0.03410139f, 0.18538745f, -0.02124824f, 0.05263630f, -0.04501389f, -0.01122367f, 
    0.04300980f, -0.34202835f, -0.10184204f, 0.01421164f, -0.11639211f, -0.04428712f, 0.01944683f, 0.00427122f, 
    0.04024414f, -0.05125770f, 0.09873736f, -0.13124850f, -0.21622264f, 0.25901154f, 0.19523603f, -0.03849248f, 
    0.05792087f, 0.03601550f, -0.05120809f, -0.01513796f, 0.16340314f, 0.08584419f, 0.09631074f, -0.01020872f, 
    0.06171161f, -0.06355884f, 0.26071051f, -0.05926372f, 0.05950210f, -0.03033429f, -0.10185369f, 0.07779663f, 
    0.02165338f, 0.02298619f, -0.02536884f, -0.11255041f, 0.21176545f, 0.13984421f, -0.01901897f, -0.12663461f, 
    0.09833402f, -0.01947352f, -0.08164211f, 0.13549069f, 0.03003545f, -0.00345115f, 0.04216845f, 0.05620610f, 
    0.30834746f, 0.04229767f, -0.09123574f, 0.04769732f, 0.14759865f, 0.02318509f, 0.04276893f, 0.09094581f, 
    -0.04892639f, -0.03402887f, -0.01501140f, 0.06158833f, 0.07724860f, 0.13354769f, 0.02854110f, -0.14410567f, 
    -0.02175389f, 0.03100920f, -0.05153136f, -0.04754353f, -0.05459991f, -0.06382988f, 0.04211628f, 0.02502248f, 
    -0.04299282f, 0.16234155f, 0.17959008f, 0.09532586f, 0.04078760f, -0.01820547f, -0.03755597f, 0.05343358f, 
    0.12963352f, 0.02937684f, 0.08686243f, -0.00257168f, -0.11950126f, 0.42587009f, 0.14394620f, 0.37947735f, 
    0.09490173f, 0.11984851f, -0.06910160f, -0.01830361f, 0.10850832f, -0.03290497f, 0.02194261f, 0.11978821f, 
    -0.16779381f, -0.08889321f, -0.03281166f, 0.03199574f, -0.00721532f, 0.01210858f, -0.04286518f, -0.00581805f, 
    -0.08503782f, 0.06123370f, 0.04349332f, 0.01276445f, -0.10173225f, -0.02383002f, 0.18860056f, -0.11452012f, 
    0.06736372f, 0.04715966f, -0.17922384f, -0.16288432f, -0.09687539f, 0.03435951f, -0.04415929f, -0.14812276f, 
    0.02268834f, -0.08821633f, 0.02519206f, 0.16290833f, -0.00756017f, -0.03324129f, -0.06856254f, 0.00986913f, 
    0.13144930f, 0.10058656f, -0.00728221f, 0.06265271f, -0.01510440f, -0.09449633f, -0.00030422f, 0.03165849f, 
    -0.02692875f, -0.01291154f, 0.09474716f, 0.05145681f, 0.05635991f, -0.05082457f, 0.10288002f, 0.01987329f, 
    -0.15687002f, 0.07422379f, 0.02873745f, -0.23125848f, 0.03353674f, 0.04277867f, 0.01229408f, -0.00747013f, 
    -0.06934720f, 0.00561212f, -0.15914458f, -0.09351168f, -0.13217315f, -0.28654841f, -0.03914025f, 0.08459566f, 
    -0.01840713f, 0.01232475f, 0.04804319f, 0.02984805f, -0.00573030f, 0.06830954f, 0.06859194f, 0.05512284f, 
    0.20827258f, -0.12595779f, -0.06729466f, -0.11005534f, -0.05744474f, -0.00473842f, 0.10654451f, -0.05414254f, 
    -0.09064442f, -0.03746262f, 0.03190474f, -0.02181841f, 0.16317441f, -0.04417806f, 0.00759148f, 0.03252433f, 
    0.00604740f, 0.06866045f, -0.01233217f, 0.03353481f, 0.10379565f, 0.08850002f, 0.00368609f, 0.03953817f, 
    -0.40297952f, 0.12209090f, 0.11726686f, -0.21210454f, 0.07923930f, -0.00649594f, 0.04430945f, -0.00501473f, 
    0.04314508f, 0.04152545f, -0.03530060f, -0.00807462f, -0.19732249f, -0.23073481f, -0.10069200f, -0.18453322f, 
    -0.01011741f, -0.03015613f, 0.03815324f, 0.02656436f, -0.16583647f, -0.02470283f, 0.05990508f, 0.11895077f, 
    -0.36268705f, -0.08938170f, 0.13048519f, -0.06642432f, 0.01958001f, -0.00703705f, -0.01547879f, 0.02827682f, 
    0.07542320f, -0.05380550f, 0.04030198f, -0.00502335f, -0.37509513f, 0.26877752f, -0.26791602f, -0.24719198f, 
    0.13655582f, -0.01232785f, 0.01493220f, -0.10884713f, -0.15282691f, -0.09451707f, -0.08017184f, -0.16157688f, 
    0.13659440f, -0.12835102f, -0.07874867f, 0.19860394f, 0.03000674f, -0.00033945f, -0.02137063f, 0.01784660f, 
    -0.02195120f, 0.05594653f, -0.09924404f, -0.04350452f, -0.29383221f, -0.29193547f, 0.05140289f, 0.05109931f, 
    0.03579370f, -0.08436498f, 0.00829136f, -0.06293250f, 0.08311389f, -0.04833703f, 0.02423888f, 0.06936348f, 
    -0.07871383f, -0.14109696f, -0.04608427f, 0.09764876f, 0.04231604f, 0.01768962f, -0.04599921f, 0.14037412f, 
    0.02513750f, 0.01780155f, -0.07483175f, -0.11749710f, 0.03412540f, 0.19423191f, 0.02620750f, -0.31630161f, 
    -0.15014969f, 0.07777939f, 0.09005636f, -0.04010222f, -0.22084704f, -0.00846556f, -0.08865614f, 0.04099195f, 
    0.02728219f, 0.09490806f, 0.14696631f, -0.14559411f, 0.06447531f, 0.09606208f, -0.00502106f, -0.16131595f, 
    -0.03470780f, -0.01975756f, -0.15430793f, 0.02718257f, 0.05316277f, -0.08647688f, 0.05882591f, 0.03364931f, 
    -0.04086249f, 0.09494665f, -0.12343501f, -0.12143642f, -0.01742243f, -0.03244888f, 0.00304095f, -0.05474733f, 
    -0.09683397f, 0.15593317f, -0.10323984f, -0.12156267f, 0.02605550f, -0.00169564f, -0.00403912f, 0.01342448f, 
    0.08926068f, 0.01992980f, -0.07201128f, 0.04757336f, 0.01664775f, -0.14864241f, 0.00219132f, -0.01097284f, 
    0.15215315f, -0.07442624f, -0.03968611f, -0.15855452f, 0.02808590f, -0.00087350f, 0.01026955f, 0.00804255f, 
    -0.19305895f, 0.02440945f, 0.29570195f, -0.03748929f, -0.01644091f, -0.02414045f, -0.07578171f, -0.03755745f, 
    -0.05354884f, 0.04959832f, 0.08267625f, 0.17358172f, 0.05640523f, 0.06561872f, -0.21838316f, 0.13745593f, 
    0.09082447f, 0.02887245f, 0.06181042f, 0.05520027f, -0.10544761f, -0.01010373f, -0.00175159f, 0.02750540f, 
    -0.16146863f, 0.09201723f, -0.03046757f, -0.01462333f, -0.06807156f, -0.00275800f, 0.04674877f, 0.05043343f, 
    0.09675156f, 0.01578200f, 0.07218491f, -0.05458042f, 0.09166996f, 0.02870818f, -0.11883391f, -0.06471045f, 
    0.00656631f, 0.00723894f, 0.05681390f, -0.11624737f, -0.00461662f, 0.08504088f, -0.01612874f, 0.00210692f, 
    -0.15254958f, -0.08305836f, -0.18600640f, -0.12567775f, 0.14667942f, 0.02816165f, -0.04665725f, 0.04372601f, 
    -0.01332767f, 0.04625146f, 0.03470120f, 0.12150960f, -0.10720283f, 0.09334301f, 0.28104219f, -0.12582713f, 
    -0.08521677f, -0.06332880f, -0.04287433f, -0.14900787f, 0.00933632f, -0.05812128f, -0.04296801f, 0.02211654f, 
    -0.31261379f, 0.06231750f, -0.02178411f, 0.02026244f, 0.16210487f, 0.01709791f, -0.06103633f, 0.01679755f, 
    0.04425769f, -0.00099367f, 0.05266859f, -0.06812771f, -0.22692153f, 0.04578460f, -0.09530161f, -0.06787799f, 
    0.02899215f, -0.02803333f, -0.01120721f, -0.16527876f, -0.12734103f, -0.13963304f, -0.10312681f, 0.03684789f, 
    -0.12427974f, 0.03546423f, 0.27913105f, 0.08249901f, 0.00830758f, 0.07645052f, -0.04561596f, 0.16402590f, 
    0.00985170f, -0.08461777f, 0.07574929f, 0.03862150f, 0.36411440f, -0.01835091f, 0.00497359f, -0.19283146f, 
    0.02398386f, -0.04921306f, 0.13339166f, 0.12186478f, -0.01086481f, -0.09575434f, 0.12326862f, -0.02286229f, 
    -0.45893753f, 0.13271689f, -0.07202357f, 0.01495943f, 0.09558076f, -0.00121685f, 0.11705733f, -0.00741771f, 
    -0.05871536f, -0.04199487f, 0.05060270f, 0.03666326f, -0.01507752f, 0.26907268f, 0.31558108f, -0.06320450f, 
    0.06281656f, 0.00021688f, -0.00179328f, -0.12328690f, -0.02330991f, -0.08959287f, -0.01066831f, -0.03796162f, 
    0.14787592f, -0.16634636f, 0.21671191f, -0.09457995f, 0.09876326f, 0.02073242f, -0.00240648f, 0.05974054f, 
    -0.00651603f, 0.09682165f, -0.03658645f, -0.07417819f, 0.29476321f, -0.11576832f, 0.15980241f, 0.01559615f, 
    0.04194214f, -0.00389773f, -0.04001174f, 0.03330648f, -0.00215676f, -0.00866038f, -0.05155925f, 0.08650606f, 
    0.08998712f, -0.23123842f, 0.00183659f, -0.24631247f, -0.00845901f, 0.02293321f, 0.04986856f, 0.03090288f, 
    -0.03792625f, 0.02619958f, 0.10202426f, -0.11736608f, -0.04163179f, 0.13494216f, 0.00363160f, -0.15698881f, 
    0.05451857f, 0.20711099f, -0.07982806f, -0.02178486f, -0.08800607f, -0.08153766f, 0.00722197f, 0.03299662f, 
    -0.04589681f, 0.01672637f, 0.03823851f, 0.11418062f, 0.09598536f, 0.02578108f, -0.01782736f, -0.02324420f, 
    -0.06288320f, -0.09595168f, -0.03676368f, 0.01195034f, -0.32310924f, -0.54269618f, -0.12436267f, -0.06980871f, 
    0.01560278f, -0.06391037f, -0.02316861f, 0.09763811f, 0.07208957f, 0.00833902f, 0.06112361f, 0.13369974f, 
    -0.32707217f, -0.00402426f, 0.04619662f, 0.12304157f, 0.05952315f, 0.03977648f, -0.02951298f, 0.05825565f, 
    0.04769110f, 0.01834995f, 0.09949642f, -0.09543371f, -0.03052194f, -0.04454056f, -0.17926973f, -0.16101807f, 
    -0.00701418f, -0.06779534f, -0.05322974f, 0.04334095f, 0.01247000f, -0.11619926f, -0.11792767f, -0.11651637f, 
    0.05261552f, 0.09858336f, 0.06800400f, -0.16934946f, 0.03154460f, -0.05755640f, 0.08721050f, -0.00051931f, 
    0.00422817f, 0.07589116f, -0.01824053f, 0.13237976f, 0.04906891f, -0.06607279f, -0.01677795f, 0.07012557f, 
    0.05158539f, -0.03486871f, 0.01817436f, 0.04843386f, -0.00962154f, 0.13833115f, 0.01308533f, 0.03094477f, 
    0.19466059f, -0.01980586f, 0.02075909f, 0.08681357f, 0.00480376f, -0.16378050f, -0.01255942f, 0.13562770f, 
    0.11809132f, -0.17171052f, -0.16035034f, 0.03650342f, 0.18732807f, -0.01111048f, -0.01357146f, 0.19014353f, 
    0.04545173f, 0.06896840f, 0.00980204f, -0.00089354f, -0.03676505f, -0.00783453f, -0.02146525f, 0.08348102f, 
    -0.14574730f, 0.08107449f, 0.17196643f, -0.08761337f, 0.01413594f, 0.06455872f, -0.01124001f, -0.00250185f, 
    -0.00059606f, 0.00856178f, 0.11324062f, -0.03401543f, -0.44299740f, 0.06901019f, -0.20890021f, -0.20655434f, 
    0.04512614f, 0.02785504f, -0.04630644f, -0.01345505f, 0.08124626f, -0.02153639f, 0.04912640f, 0.00094537f, 
    -0.09021161f, 0.06107339f, -0.17556095f, 0.07323244f, -0.06815898f, -0.05595460f, -0.02743778f, -0.15523531f, 
    -0.02253635f, -0.02582746f, 0.15515722f, -0.07017458f, 0.10075775f, 0.20156258f, -0.16929537f, -0.01647943f, 
    0.03663275f, 0.01901669f, -0.02282290f, -0.01842585f, 0.05121530f, 0.02239758f, -0.02192494f, -0.04567180f, 
    0.06434145f, -0.05629205f, 0.08004830f, 0.06957442f, -0.06970268f, -0.03721581f, 0.09320705f, -0.06027807f, 
    0.00863204f, 0.10730014f, 0.04310163f, -0.00793182f, 0.08199112f, 0.12611492f, -0.06780835f, -0.06556194f, 
    0.09337332f, -0.04951912f, 0.02097650f, 0.05642501f, -0.00403672f, 0.03315665f, 0.14135122f, 0.05389622f, 
    0.14040022f, -0.05506186f, -0.00472927f, -0.05021386f, 0.03743862f, -0.02009146f, 0.04208715f, 0.10605609f, 
    0.03177035f, 0.04620265f, 0.02458324f, 0.03695342f, -0.06366671f, 0.01000046f, -0.04566058f, 0.06013933f, 
    0.02523434f, -0.14049886f, 0.03272029f, 0.05606846f, 0.00764912f, 0.11415257f, -0.01704500f, 0.14193782f, 
    0.27226403f, -0.02623920f, -0.03311895f, 0.04646119f, 0.02702539f, -0.13189271f, 0.07849976f, 0.00889796f, 
    0.05713046f, 0.13174731f, 0.02914535f, 0.11331096f, 0.15757254f, 0.09593143f, -0.04590572f, -0.13906315f, 
    0.03776937f, -0.06707314f, 0.04850038f, -0.01029246f, 0.02079331f, -0.01364936f, 0.04128848f, 0.04967475f, 
    -0.13825338f, -0.24878962f, -0.03906919f, 0.04428677f, 0.00614907f, 0.01940884f, 0.00510094f, -0.07544208f, 
    -0.02669133f, 0.04253051f, 0.09871832f, 0.05817305f, 0.11766894f, 0.08275008f, 0.07688447f, -0.05265928f, 
    -0.14079136f, -0.01059068f, -0.04110115f, -0.00617897f, -0.05793965f, -0.06136605f, -0.03904655f, 0.04085067f, 
    0.16128114f, 0.23835866f, -0.05480192f, -0.06977166f, 0.11862608f, 0.01936049f, -0.02190560f, 0.14642130f, 
    0.07828043f, 0.06583583f, -0.02003495f, 0.12758371f, -0.29165766f, -0.14765082f, -0.15333940f, -0.05912462f, 
    -0.01614921f, 0.07044253f, 0.05286326f, -0.09444217f, 0.03388501f, -0.14895491f, -0.08096327f, 0.02660137f, 
    -0.23632307f, -0.02113764f, -0.01819146f, -0.00129375f, 0.03855050f, -0.04401921f, -0.06409237f, -0.06527644f, 
    -0.01291673f, 0.05499233f, 0.15286832f, 0.10409702f, -0.03610303f, 0.03420773f, -0.10356215f, 0.11703292f, 
    0.03691312f, -0.07865243f, 0.10142968f, -0.13372438f, -0.08350640f, -0.01640694f, 0.02958870f, -0.02109522f, 
    0.17067951f, 0.05916878f, -0.00529570f, 0.03818300f, -0.09383824f, 0.01200209f, -0.04079223f, -0.04230155f, 
    -0.04260338f, 0.01408671f, -0.04954262f, -0.21898071f, -0.30524936f, -0.28766236f, -0.06458586f, -0.02960325f, 
    -0.07779071f, -0.09800698f, 0.08013280f, 0.03913484f, 0.10298204f, 0.15639238f, 0.03627552f, 0.18374431f, 
    -0.18375708f, -0.12849955f, 0.13283512f, -0.05008670f, 0.08071245f, 0.09210321f, 0.03152673f, -0.03592294f, 
    0.08280788f, -0.05518731f, -0.02135429f, 0.06223365f, -0.25091204f, -0.30122671f, 0.09213867f, 0.06522912f, 
    0.00212044f, 0.10841355f, 0.06215434f, -0.03073682f, 0.13028657f, 0.02901909f, -0.10458031f, -0.04515923f, 
    0.21154897f, -0.01782486f, -0.06904390f, 0.03374268f, -0.00791170f, -0.02058963f, -0.06801651f, 0.08599890f, 
    0.01221861f, -0.02521750f, -0.08593956f, -0.05398310f, -0.60324806f, -0.06884323f, -0.13353868f, -0.19432825f, 
    0.06983623f, 0.08893003f, -0.14881955f, -0.06529884f, 0.01842527f, -0.00410720f, -0.03265988f, 0.15537408f, 
    -0.01258306f, -0.16026901f, 0.16572365f, -0.15710799f, -0.04475333f, 0.13094682f, 0.01245056f, 0.00097786f, 
    -0.06544465f, -0.11066353f, 0.02119927f, -0.01719035f, 0.00446696f, 0.06475098f, 0.11595592f, 0.07004081f, 
    -0.10207113f, -0.01618758f, -0.00842308f, -0.08901505f, 0.01921546f, -0.09490797f, -0.18895927f, -0.01682665f, 
    0.25534043f, 0.14173980f, 0.09725700f, 0.01028257f, 0.04604925f, 0.07067847f, 0.04233658f, -0.03735673f, 
    -0.01970355f, 0.08093640f, 0.13840464f, -0.00979406f, 0.08962600f, -0.00755610f, -0.05477616f, -0.01982483f, 
    -0.10806889f, -0.00505924f, -0.02869601f, -0.07342705f, 0.05237822f, -0.07589874f, -0.01456266f, -0.14259122f, 
    -0.03508650f, 0.05516528f, 0.01823422f, -0.02097034f, 0.10258824f, 0.04086370f, -0.02104061f, -0.05236303f, 
    -0.10571204f, 0.06412649f, 0.08851512f, -0.08403856f, -0.31061614f, -0.08117241f, -0.10928943f, -0.13233088f, 
    0.08664647f, 0.08638795f, -0.07442800f, -0.05366924f, -0.01138922f, -0.16642733f, -0.04729519f, -0.07023641f, 
    0.00540397f, -0.19778694f, 0.08536260f, -0.08713225f, 0.11030784f, -0.02358292f, 0.01293099f, -0.08272222f, 
    0.10523175f, 0.00876494f, -0.09558973f, 0.12923950f, -0.18558547f, 0.07918450f, -0.01774908f, -0.14631581f, 
    0.21001838f, 0.00244394f, 0.06043446f, -0.03254585f, 0.00027962f, -0.02856676f, -0.01347116f, -0.01681610f, 
    0.03711537f, -0.03326264f, -0.13265198f, 0.01724583f, -0.09845911f, -0.10215323f, 0.02880879f, -0.11474082f, 
    -0.07780588f, 0.07599013f, -0.12882055f, 0.02973821f, -0.17580424f, -0.07746197f, -0.15499303f, -0.24123433f, 
    -0.00740237f, -0.11627664f, 0.05021579f, 0.09296749f, -0.01310476f, 0.04614586f, 0.12439436f, 0.10983270f, 
    0.17410539f, -0.02019414f, 0.07035103f, -0.22389989f, -0.04146479f, 0.03826454f, 0.01865399f, -0.04088811f, 
    0.02289745f, 0.01889551f, -0.09926437f, -0.01382707f, 0.06641825f, 0.05089711f, -0.09832056f, -0.02851850f, 
    -0.12025738f, -0.10037195f, -0.01961806f, 0.02191238f, -0.04320583f, 0.08577829f, 0.04171186f, -0.10077395f, 
    0.17716819f, 0.06696001f, 0.00081197f, -0.09413380f, -0.18034630f, -0.13755777f, 0.01380484f, -0.07603455f, 
    -0.05601422f, -0.09205265f, -0.05089131f, -0.09821326f, -0.15806234f, -0.22120166f, 0.14264992f, -0.04869979f, 
    0.04360849f, -0.05022999f, 0.00102588f, 0.00104636f, 0.09297989f, 0.15556081f, 0.01897941f, -0.04479720f, 
    -0.12721935f, -0.08233912f, -0.06706343f, 0.05647490f, -0.00003193f, 0.04260495f, -0.01378407f, -0.02653361f, 
    0.07731634f, 0.08308669f, 0.02293900f, 0.08074269f, 0.22406015f, 0.13248384f, 0.04633889f, -0.01075906f, 
    0.17177065f, 0.13900830f, 0.12591380f, -0.04037185f, 0.00609023f, 0.14491728f, 0.03867821f, 0.09317413f, 
    -0.23162577f, -0.25837767f, -0.19713323f, -0.09917333f, -0.01453392f, 0.03018078f, -0.05197470f, 0.03290492f, 
    0.04917560f, 0.06053084f, -0.00788884f, 0.02942461f, 0.20298123f, 0.02019205f, -0.04353036f, 0.08362886f, 
    -0.06975984f, -0.05820477f, 0.07157148f, 0.12832005f, 0.00816908f, 0.09109790f, -0.07773608f, 0.07731190f, 
    -0.01273236f, -0.05577042f, 0.00377035f, -0.14268392f, -0.09938021f, 0.00679470f, -0.11068210f, -0.04583623f, 
    0.07298332f, -0.04964903f, -0.14465405f, -0.19281413f, 0.16049245f, -0.02206398f, -0.01035028f, -0.03447415f, 
    -0.02706669f, -0.06359711f, -0.05608587f, 0.05216577f, 0.04280235f, 0.09279013f, -0.14676197f, -0.13582762f, 
    0.27420729f, 0.11517369f, 0.00088077f, -0.07790309f, 0.11454953f, -0.09928104f, 0.01188996f, 0.03445106f, 
    -0.05631093f, -0.17138588f, 0.10613021f, -0.00030887f, 0.08609249f, 0.13514990f, -0.01909929f, 0.10635869f, 
    0.09502898f, 0.05308462f, 0.10064737f, 0.06347829f, -0.00999548f, 0.09900348f, 0.03628023f, -0.02945350f, 
    -0.19828188f, -0.16458738f, 0.00327146f, -0.02072146f, -0.04950095f, 0.02268482f, -0.10839783f, -0.02967820f, 
    -0.00832418f, -0.00219536f, -0.16337405f, -0.02807886f, -0.31366137f, -0.17141487f, 0.31766576f, 0.13698071f, 
    0.04821992f, 0.01756600f, 0.06171073f, 0.05080771f, 0.09211857f, 0.00470358f, -0.02207076f, 0.13291286f, 
    0.15058905f, 0.01331059f, -0.09743991f, 0.00927679f, -0.13174875f, -0.09574515f, 0.03964658f, 0.04268332f, 
    0.12266231f, 0.00873747f, -0.01695853f, -0.00986663f, -0.39881608f, -0.20953958f, -0.09427975f, -0.12195116f, 
    -0.00600074f, -0.09579182f, -0.01151565f, 0.00700020f, -0.04385457f, 0.08841979f, -0.02460035f, 0.08441475f, 
    -0.18692034f, -0.23060949f, 0.17618643f, -0.02258909f, 0.02337758f, 0.06723578f, -0.04611322f, 0.02466578f, 
    0.05005043f, 0.09349710f, -0.10115846f, 0.01800490f, 0.09573361f, -0.03392108f, 0.06545163f, -0.01271478f, 
    -0.08069112f, -0.11203761f, 0.04315171f, -0.09010392f, -0.03982552f, 0.05521801f, -0.01168256f, 0.02650247f, 
    -0.57237059f, -0.30508140f, 0.02143139f, 0.03311935f, 0.10624363f, 0.05626699f, 0.04543096f, -0.00484571f, 
    0.13833889f, 0.08337041f, 0.01823594f, 0.08920497f, -0.32433823f, -0.14202924f, -0.05129372f, -0.01552288f, 
    0.10678123f, -0.08721734f, -0.02570713f, 0.03280529f, 0.09458805f, 0.07924594f, 0.07349468f, 0.01154319f, 
    -0.37780121f, -0.14752866f, 0.04691919f, -0.00102288f, 0.05985994f, -0.02033574f, -0.13570182f, 0.01541603f, 
    -0.03505030f, -0.03184038f, 0.03019658f, 0.21539077f, 0.27853888f, 0.06407648f, -0.16217794f, 0.05347841f, 
    0.03356817f, -0.09649348f, -0.21889678f, -0.02489989f, -0.08541287f, 0.00431154f, -0.05966982f, 0.01159927f, 
    -0.17116156f, 0.13027382f, -0.01422594f, -0.11941147f, 0.10617826f, -0.03910528f, 0.05183361f, 0.09522343f, 
    0.03862963f, 0.09248459f, 0.03361493f, 0.20172088f, -0.43609932f, -0.12185989f, 0.04916463f, -0.13767499f, 
    0.12603129f, -0.12076298f, 0.01555857f, 0.03355975f, 0.03961007f, -0.03773549f, -0.10318746f, 0.02586163f, 
    0.24021541f, 0.01173307f, 0.01442054f, -0.16666117f, -0.01560805f, -0.04369372f, 0.01343728f, 0.01580993f, 
    0.04929653f, 0.03676982f, -0.01224892f, 0.04365520f, -0.19591551f, 0.16686964f, -0.14777927f, -0.12294774f, 
    0.17832474f, -0.01527326f, 0.01543646f, -0.03411547f, 0.11715629f, 0.07913779f, 0.05666934f, 0.05830082f, 
    -0.09455416f, 0.33430424f, -0.06895930f, 0.02935499f, 0.02861465f, 0.04044382f, 0.00373862f, 0.04648856f, 
    0.00503308f, 0.05122073f, -0.03692879f, -0.07767767f, -0.13276504f, -0.10993365f, -0.18257460f, -0.20143101f, 
    0.00570453f, -0.01266929f, -0.00707313f, -0.07499102f, -0.00563772f, -0.01221990f, -0.01403040f, 0.06035112f, 
    0.17790087f, -0.13098082f, -0.16273063f, -0.06404550f, 0.16730824f, -0.20872203f, 0.03747394f, 0.09980375f, 
    -0.03600181f, -0.03773602f, 0.02920210f, -0.04359708f, 0.16788763f, -0.03813844f, -0.14285198f, 0.24700952f, 
    -0.03494048f, -0.07271104f, 0.02418827f, 0.02824516f, 0.00952568f, 0.01886267f, -0.05945349f, 0.02806931f, 
    -0.02371508f, -0.01563357f, 0.07769980f, -0.12093959f, -0.10998045f, -0.15813141f, -0.00246383f, -0.07803930f, 
    0.03605477f, 0.08340450f, 0.10816325f, 0.03473707f, -0.02744312f, 0.14285907f, -0.05018184f, 0.12110098f, 
    0.00261582f, 0.10766620f, 0.00592967f, -0.12040810f, 0.07084030f, -0.13269758f, -0.00350664f, 0.03577575f, 
    -0.18278132f, -0.10304552f, -0.00096049f, -0.09573498f, 0.06921889f, -0.18935911f, -0.08124507f, 0.10785112f, 
    -0.06000815f, 0.03261521f, 0.05376116f, -0.06734433f, 0.01074126f, -0.05405303f, 0.03848134f, 0.19943964f, 
    -0.03210811f, -0.09093548f, -0.00253088f, -0.04981146f, -0.00771380f, -0.02590225f, 0.07955491f, -0.00053843f, 
    0.00397050f, -0.10670780f, -0.08759212f, 0.07108653f, -0.16080855f, 0.08258781f, -0.10579502f, 0.02533390f, 
    -0.02437342f, -0.04191642f, -0.13196191f, -0.03141529f, -0.10364921f, -0.09507447f, -0.05781849f, 0.11666180f, 
    -0.07671422f, 0.15363769f, 0.00030895f, 0.11368037f, 0.08304630f, -0.04856467f, -0.03345247f, 0.05402771f, 
    -0.05228191f, -0.12878132f, 0.05642970f, 0.06601661f, 0.00886779f, 0.02686103f, 0.04433969f, 0.06192821f, 
    0.05201499f, 0.04179444f, 0.07918009f, 0.00065781f, 0.08761705f, -0.30648842f, -0.06145304f, 0.30271003f, 
    -0.13381636f, -0.01714569f, 0.05438745f, 0.12946878f, 0.00232026f, 0.05562980f, -0.12762684f, 0.01959621f, 
    -0.00960369f, 0.03293689f, -0.04865082f, 0.23221527f, 0.15842721f, 0.10608409f, 0.00268377f, 0.06411842f, 
    0.04384861f, 0.08889951f, -0.04522983f, 0.02011644f, -0.10950213f, 0.06503011f, -0.02965672f, -0.18066683f, 
    0.02541296f, -0.09761258f, -0.02493250f, 0.00393896f, -0.09525660f, 0.06276604f, -0.12430192f, -0.05754041f, 
    -0.00337418f, -0.06190603f, 0.07777543f, -0.03615864f, 0.06073945f, 0.02378454f, -0.04369468f, 0.08049586f, 
    -0.09335435f, -0.06042165f, -0.01268157f, -0.02662969f, 0.13571961f, 0.12708966f, 0.01265250f, -0.07568712f, 
    -0.01978888f, 0.00799297f, 0.00742489f, -0.09786198f, 0.10926427f, -0.01386665f, -0.09990090f, -0.07313327f, 
    -0.14143467f, -0.00813219f, -0.14270367f, 0.15778859f, 0.05762444f, 0.00819477f, -0.00872651f, 0.04964256f, 
    0.01856325f, 0.02458526f, -0.02076488f, 0.00601228f, 0.05271520f, -0.02548520f, 0.03266397f, 0.06232338f, 
    -0.10331066f, -0.00497267f, 0.10597160f, 0.04325589f, 0.00960752f, -0.00672342f, -0.07276604f, -0.08722796f, 
    0.05698014f, 0.05571330f, -0.01236810f, 0.17008096f, -0.16598067f, 0.01430210f, 0.03028526f, 0.05971388f, 
    -0.00480250f, -0.08691023f, -0.07310004f, -0.07684230f, -0.24594669f, -0.14559022f, -0.05826335f, -0.09646964f, 
    0.09709495f, -0.02817471f, 0.08877847f, 0.07255788f, 0.04469714f, 0.03927860f, 0.07164454f, -0.07597882f, 
    0.15295202f, -0.00093492f, 0.05784763f, 0.04804069f, 0.02261025f, -0.02278581f, 0.00470699f, -0.03359138f, 
    -0.04639187f, -0.06287101f, -0.07563927f, 0.03185778f, -0.01610944f, -0.22164239f, -0.05120573f, 0.11041938f, 
    -0.04209250f, 0.12781660f, -0.11644512f, -0.08329796f, 0.06481922f, -0.12311819f, -0.04923692f, 0.08034064f, 
    -0.20569710f, -0.27369860f, -0.00024594f, 0.03719242f, 0.00274845f, 0.05359535f, 0.03136914f, 0.02556294f, 
    0.05354646f, 0.03702214f, 0.04544741f, 0.06175108f, -0.01330446f, -0.02956574f, 0.01989526f, -0.23812042f, 
    0.10117278f, -0.06804527f, -0.05646722f, 0.14789009f, -0.06604134f, -0.00727196f, -0.05343625f, -0.04047406f, 
    -0.06070431f, -0.25631201f, 0.01133499f, 0.09868270f, 0.04321392f, -0.05732756f, -0.06757272f, 0.02601762f, 
    0.03048421f, 0.07242914f, -0.08312587f, -0.04821339f, 0.15862411f, 0.08126718f, -0.06090340f, 0.06114707f, 
    0.02498348f, -0.07434682f, -0.01709092f, 0.05898034f, 0.02205341f, -0.01304955f, 0.11580654f, 0.09740221f, 
    -0.39648217f, 0.17236274f, -0.11291703f, 0.01915120f, 0.14812647f, -0.09292842f, 0.07353503f, 0.03609730f, 
    0.01296196f, -0.02870073f, 0.02215295f, 0.00971645f, 0.58081257f, -0.04865772f, -0.17581803f, -0.30870414f, 
    -0.02155261f, -0.13607983f, 0.04233745f, -0.00092887f, 0.00710596f, -0.02552872f, -0.03920831f, 0.07320639f, 
    -0.08700077f, 0.25152189f, 0.05674193f, -0.08942825f, -0.15362360f, 0.14765406f, 0.01486522f, -0.11410238f, 
    0.03228570f, 0.10640296f, -0.07181781f, -0.20307961f, -0.05336850f, -0.17233238f, -0.14398283f, -0.09528046f, 
    -0.06220590f, 0.03471535f, -0.10990616f, -0.08873604f, -0.01317571f, 0.02111124f, 0.04202919f, 0.00558944f, 
    -0.02732379f, -0.02352843f, -0.15902470f, 0.08250508f, 0.09806941f, -0.03383077f, 0.09251769f, 0.05293000f, 
    0.07747263f, 0.00865989f, -0.12106218f, -0.13079935f, 0.20676720f, 0.02151663f, -0.02595405f, -0.04428608f, 
    -0.10338323f, -0.10791639f, -0.06122604f, -0.09757490f, -0.03407354f, -0.00107730f, -0.03008383f, -0.02153657f, 
    0.14737019f, 0.04332259f, 0.04363891f, -0.11542027f, -0.08766756f, -0.01628217f, -0.03451949f, -0.07840967f, 
    -0.03486517f, -0.03444049f, -0.03471092f, 0.04948651f, -0.34735686f, -0.21902248f, -0.14093417f, -0.20391828f, 
    0.03798826f, -0.00382602f, 0.00462817f, 0.03919065f, -0.00127672f, -0.03866366f, 0.02482693f, -0.11205445f, 
    0.26097056f, -0.04377828f, 0.01180202f, -0.10876043f, 0.09404870f, -0.06618323f, 0.01743560f, -0.08257252f, 
    -0.03617971f, 0.03434905f, 0.00539515f, -0.01425097f, -0.05617011f, -0.09587615f, 0.04754792f, 0.23870450f, 
    -0.16837932f, 0.00280176f, 0.05619831f, -0.01012626f, 0.07670778f, -0.07606316f, -0.00849455f, 0.17541228f, 
    -0.06896444f, -0.09465785f, 0.04396114f, 0.06626190f, -0.12203631f, 0.05316107f, -0.08996410f, 0.00035552f, 
    -0.04017311f, 0.07245374f, 0.01437269f, 0.00796025f, 0.21116090f, -0.17542374f, -0.00892027f, -0.02324103f, 
    0.02044590f, -0.02905158f, 0.05158112f, -0.11116344f, -0.01588214f, -0.03087631f, -0.03408375f, -0.04361323f, 
    -0.19146582f, 0.28803056f, 0.08173286f, -0.16215280f, 0.03131574f, -0.04031247f, -0.11356259f, -0.09562676f, 
    0.05537352f, 0.15054154f, 0.03964677f, -0.09464864f, -0.11953131f, -0.22339268f, 0.04742054f, 0.03708904f, 
    0.03636672f, 0.17547378f, -0.13566677f, -0.02000589f, -0.04576294f, 0.00834269f, -0.02366943f, 0.05715123f, 
    -0.25327668f, 0.10693112f, 0.00771879f, 0.01328796f, -0.04474673f, 0.02202415f, -0.05650113f, -0.01244726f, 
    0.03620958f, 0.07478525f, 0.03748485f, -0.20189069f, 0.23747110f, -0.04666479f, -0.09465623f, 0.01283303f, 
    0.17288840f, 0.02208681f, 0.01159410f, 0.04353187f, 0.06505293f, -0.07873604f, -0.01655860f, 0.08255877f, 
    0.34469286f, -0.27814525f, -0.04754289f, -0.12927654f, -0.01916270f, -0.02304707f, -0.09358793f, 0.02234560f, 
    0.04980396f, 0.04671797f, -0.02929372f, -0.01850439f, 0.21706346f, 0.00594589f, -0.16337956f, 0.10052697f, 
    -0.01260227f, 0.13073963f, -0.05060253f, -0.03759544f, -0.01239729f, 0.09155890f, -0.00793218f, -0.06792776f, 
    -0.13332643f, -0.25069314f, -0.03058887f, -0.16608518f, 0.03200934f, 0.00961050f, -0.06266566f, 0.01151288f, 
    -0.03256664f, 0.01417140f, -0.03097320f, -0.07011136f, 0.05930592f, -0.02643349f, 0.13879305f, -0.02130108f, 
    -0.08157938f, 0.01607211f, 0.09556320f, -0.07795203f, -0.05203473f, -0.13933647f, 0.00907938f, -0.02787747f, 
    -0.07771681f, -0.07115281f, -0.05762063f, -0.01324238f, -0.01189186f, 0.05836438f, -0.05885530f, -0.16400002f, 
    -0.11908936f, -0.05698693f, 0.11179885f, 0.08813721f, -0.20838267f, -0.34545511f, 0.22634411f, -0.05288549f, 
    0.09323895f, 0.01874660f, 0.01360896f, 0.03532286f, 0.00804069f, -0.01400782f, 0.06683702f, 0.08223871f, 
    0.10075736f, -0.06567381f, 0.00473717f, 0.30039471f, 0.05161137f, 0.15126576f, 0.02104262f, -0.15345129f, 
    0.01936057f, 0.08815096f, 0.02335344f, 0.12517548f, 0.00505060f, 0.06788959f, 0.02068023f, -0.08870099f, 
    0.03541477f, -0.01477117f, -0.02204539f, -0.02477706f, 0.02080909f, -0.01591591f, -0.04203301f, 0.04685223f, 
    0.09146954f, -0.10528392f, -0.00355236f, -0.21421699f, 0.12715904f, -0.12517272f, -0.07688563f, 0.02629280f, 
    0.05694953f, 0.00743775f, -0.02119410f, 0.05209293f, 0.36571211f, 0.32383800f, -0.01972074f, -0.05538693f, 
    0.05004168f, 0.06761699f, -0.05791601f, -0.15116052f, 0.06037105f, 0.03963790f, 0.04354185f, 0.04389417f, 
    0.07684208f, -0.09453085f, -0.12610941f, -0.08636922f, -0.04117100f, 0.03990474f, 0.14493875f, 0.03127940f, 
    -0.22816275f, 0.01453043f, -0.04630957f, -0.07120312f, -0.03035937f, 0.07575775f, -0.25493872f, -0.00733780f, 
    0.08823119f, -0.00647012f, 0.05288235f, -0.04747098f, -0.05826881f, -0.06489152f, -0.01537656f, -0.03629418f, 
    -0.02284474f, 0.15862347f, -0.05053682f, 0.17725052f, 0.04523943f, -0.02497344f, -0.12657522f, -0.07494850f, 
    -0.05438169f, -0.02497370f, -0.09387925f, 0.01600100f, -0.02262984f, -0.02796600f, 0.01119897f, -0.00314089f, 
    -0.00978643f, 0.03880270f, -0.01635104f, 0.04354173f, -0.03914639f, -0.09016275f, 0.03076709f, -0.10941454f, 
    -0.19361380f, 0.06909321f, -0.01165327f, 0.02797419f, 0.18706496f, -0.07243489f, -0.00741728f, 0.02375880f, 
    0.00220972f, -0.06584094f, -0.06463710f, -0.03527305f, 0.25142005f, -0.18961510f, -0.13866954f, 0.03844802f, 
    0.05781754f, 0.02647536f, -0.09375624f, -0.07466307f, 0.04449103f, 0.06037764f, -0.03047516f, 0.05060767f, 
    0.24578539f, -0.07904571f, -0.07605010f, 0.13382830f, -0.03448019f, 0.03899589f, 0.05116190f, 0.00333548f, 
    0.02954703f, -0.00257611f, -0.02411549f, -0.00746010f, -0.41161448f, 0.07595331f, -0.03271084f, -0.20918170f, 
    0.00086050f, -0.02592996f, 0.01639202f, 0.02423702f, -0.05985958f, 0.09366830f, 0.08498178f, 0.10809310f, 
    0.26487780f, -0.05087397f, -0.18970799f, 0.08530290f, -0.06323934f, 0.00119553f, 0.00398580f, 0.03572639f, 
    0.01721055f, -0.12576731f, -0.01949160f, -0.04033114f, 0.26365370f, -0.01636483f, -0.18761371f, 0.10938390f, 
    -0.00935919f, -0.03469771f, 0.01161415f, 0.08144011f, -0.00922128f, 0.01527022f, 0.05595094f, 0.03256571f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03269246f, 0.03441361f, -0.02381880f, -0.03643849f, -0.01890323f, -0.01043349f, 0.04636737f, -0.05209970f, 
    -0.05847653f, -0.03103862f, 0.07674501f, 0.03933834f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
