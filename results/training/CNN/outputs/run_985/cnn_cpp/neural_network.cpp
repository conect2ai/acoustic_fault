#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28576598f, -1.05569565f, 0.86081171f, -0.19258119f, 0.12458727f, -0.46013802f, 0.08637270f, -0.43558493f, 
    -0.70901310f, -0.17717180f, -0.37110284f, -0.36154941f, 0.48006848f, 0.63070625f, 0.33547297f, -0.62458998f, 
    -0.19685334f, 0.25996682f, -0.97765207f, -0.48486629f, -0.13177457f, -0.80961275f, -0.62558740f, -0.76614028f, 
    0.05215891f, 0.41958177f, 0.64938939f, -1.28226101f, 0.31319463f, 0.90934020f, -0.47692192f, 0.48892644f, 
    0.15840831f, -0.52335131f, -0.08710204f, 0.46708012f, 1.48774874f, -1.43455756f, -0.56333703f, 0.28713962f, 
    0.40648517f, 0.52952605f, -0.16646925f, -0.11281722f, 0.21404631f, 1.09534025f, 0.31601086f, 0.66890979f, 
    0.16581352f, 0.27903822f, -0.00055541f, 0.15858257f, 0.17271478f, 0.07505922f, 0.65295023f, -1.00481045f, 
    0.55224460f, 0.47846222f, 0.56954777f, -0.49073023f, 0.59446681f, -0.48593533f, 0.36687747f, 0.81952959f, 
    -0.35187313f, 0.05408143f, -0.79414958f, -0.65185863f, 0.31458080f, 0.29795569f, 0.62250328f, 0.37800688f, 
    -0.82131809f, -0.82882619f, -0.71946132f, 0.46034580f, 0.52871907f, -0.56283224f, -0.06452086f, -0.48797217f, 
    -0.47406074f, -0.54628271f, 0.12631600f, -0.57498652f, 0.65054011f, 0.10469445f, -0.45513225f, 0.53038311f, 
    0.42968664f, 0.67526668f, -0.85984403f, 0.55987167f, -0.78951550f, 0.33009019f, 0.33631340f, 0.45606750f, 
    -0.02973385f, -0.35791576f, -0.34779537f, -0.43834767f, -0.95459068f, -0.39883396f, 0.62626106f, 0.10259645f, 
    0.67372608f, 0.39456081f, 0.33349305f, -0.08545318f, 0.21331367f, 1.00936306f, -0.71080077f, -0.47518584f, 
    0.20634909f, 0.79164964f, -0.07903127f, -0.38728476f, -0.36972466f, -0.13663216f, 1.00996375f, -0.54440880f, 
    -0.10633270f, 0.31991369f, 0.50093311f, 0.36694533f, -0.08650300f, 0.38916886f, -1.16597915f, -0.20151189f, 
    0.84851778f, 0.63900876f, 0.13792153f, -0.89846581f, -0.23740174f, -0.31285378f, -0.50203580f, -0.47340944f, 
    -0.90005136f, 0.62908727f, -0.95446295f, -0.84135574f, 0.38103557f, -0.28301477f, -0.41602367f, -0.22667718f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19702040f, 0.10388395f, -0.01201671f, 0.26605362f, 0.17954807f, 0.22948782f, 0.17680112f, 0.11394563f, 
    -0.26646462f, -0.13742569f, 0.20390005f, 0.00840396f, 0.04062445f, 0.04364429f, -0.09776805f, 0.46152028f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03407847f, -0.05685687f, -0.03686216f, -0.03884568f, 0.01470505f, 0.01196390f, 0.03281379f, -0.02847548f, 
    0.02358002f, 0.01096405f, -0.03084048f, 0.00062901f, -0.02822633f, -0.01243918f, 0.02668982f, -0.01721221f, 
    -0.00806879f, -0.02124550f, -0.05375695f, 0.02283968f, -0.01315345f, -0.02765311f, -0.01909822f, -0.02357842f, 
    -0.02436727f, -0.05698204f, -0.05686486f, -0.03745696f, 0.00650317f, -0.04008600f, -0.02362855f, -0.06379133f, 
    0.00196723f, 0.04361061f, -0.00976063f, -0.05044565f, -0.01882776f, 0.02883160f, 0.04556776f, -0.01379463f, 
    0.03577551f, 0.02088557f, -0.05319439f, -0.03869336f, 0.04038906f, -0.01177754f, 0.00509487f, -0.02665649f, 
    -0.01430228f, -0.03819492f, -0.01916661f, 0.04453235f, -0.04863116f, -0.01272458f, 0.02317512f, -0.02288671f, 
    -0.03719947f, -0.02883764f, 0.00517767f, -0.02963364f, -0.01492844f, -0.02779842f, -0.01935591f, 0.02227840f, 
    -0.05304505f, -0.03069414f, -0.04823631f, -0.03876767f, 0.00472514f, -0.01301170f, -0.02334935f, -0.03449088f, 
    0.03405396f, -0.00593548f, 0.01379624f, 0.04470047f, -0.04522234f, 0.03296547f, 0.02754898f, -0.04608970f, 
    -0.05441088f, 0.04325229f, 0.01310902f, -0.01291010f, -0.00245431f, -0.01943825f, -0.06131802f, 0.03789813f, 
    -0.04674639f, 0.03326051f, 0.00757635f, 0.03977815f, 0.01620508f, -0.04367945f, -0.00582060f, 0.01998125f, 
    0.05734076f, -0.00826824f, 0.03955961f, -0.01351494f, -0.05715885f, 0.04471243f, 0.00721600f, -0.00120332f, 
    0.01657480f, -0.02428104f, -0.06042422f, -0.00203820f, 0.01593372f, -0.02503688f, 0.00403981f, -0.04988232f, 
    -0.00786768f, 0.05669086f, -0.03648662f, -0.02580493f, 0.01534012f, 0.05363934f, 0.00581858f, 0.03959252f, 
    -0.03325855f, 0.00461235f, 0.04044434f, -0.04173538f, 0.02684062f, 0.00275512f, 0.00952156f, 0.02170999f, 
    -0.00504626f, -0.02676109f, -0.04957980f, -0.01872533f, 0.02215428f, -0.05372809f, 0.01367652f, 0.01720493f, 
    0.00362125f, -0.02477288f, 0.03063972f, -0.03481484f, 0.02965758f, 0.00147769f, -0.04116188f, -0.01233346f, 
    0.02998813f, -0.03936041f, -0.05139146f, -0.05343786f, 0.02637979f, -0.00630126f, -0.01617458f, 0.01999182f, 
    -0.04035949f, -0.00389058f, -0.03796789f, 0.00256013f, -0.00673900f, 0.03847681f, 0.01803107f, 0.03288030f, 
    -0.04183136f, -0.05578718f, 0.04679381f, -0.04934732f, 0.04036667f, -0.02031777f, 0.00129605f, 0.00372291f, 
    0.01205066f, -0.02277388f, 0.03092739f, 0.02666525f, -0.01386032f, -0.05317961f, 0.02933314f, 0.04476173f, 
    -0.05744698f, -0.01779619f, -0.00932977f, 0.03452449f, -0.05754267f, -0.02538648f, -0.01562846f, -0.03640337f, 
    -0.04454169f, 0.03047764f, -0.02677379f, -0.04220899f, 0.03765261f, -0.03275121f, 0.05205980f, 0.02692182f, 
    -0.03707261f, 0.04134485f, 0.01438499f, -0.04193600f, 0.01940375f, -0.03807372f, 0.00704755f, 0.01599009f, 
    0.01901616f, 0.00653497f, -0.04584628f, -0.05333472f, 0.03897255f, 0.04759334f, -0.02705201f, -0.00851684f, 
    -0.04419717f, -0.04650982f, 0.03866110f, -0.02817859f, 0.03073506f, -0.01509286f, 0.01680369f, -0.00006442f, 
    -0.00379342f, -0.04497093f, 0.01683741f, 0.04270781f, -0.04086002f, 0.02333599f, 0.01827008f, -0.02898563f, 
    -0.04759086f, 0.00755336f, 0.00403506f, -0.05932982f, 0.00903704f, -0.00584642f, 0.00876718f, -0.00338505f, 
    0.00950706f, 0.01487388f, -0.05135333f, 0.03252308f, -0.00308446f, -0.02294817f, -0.04614644f, -0.04275374f, 
    0.00426585f, 0.04862479f, 0.04419780f, -0.03201972f, 0.02831561f, 0.04885462f, 0.03253376f, 0.04593252f, 
    0.03606987f, -0.03600440f, -0.04218751f, -0.04208295f, 0.02865188f, -0.04526441f, 0.01463465f, -0.04126921f, 
    -0.03246983f, -0.00864134f, 0.03232967f, 0.00519446f, 0.01864376f, -0.03848848f, 0.03995974f, -0.01178409f, 
    0.03996921f, -0.01723086f, -0.04667418f, 0.03081172f, 0.02332234f, 0.01395809f, 0.02714955f, 0.02344744f, 
    0.01022818f, -0.02844929f, -0.00603664f, -0.02908375f, -0.04638270f, 0.02887372f, -0.05494852f, -0.01192494f, 
    -0.03817440f, -0.03811386f, 0.05148901f, 0.02439080f, -0.00173523f, 0.02079703f, -0.04540247f, 0.00172273f, 
    -0.02614769f, -0.02760267f, -0.00906968f, -0.05317526f, -0.05901438f, -0.03712051f, -0.06343064f, -0.05208600f, 
    -0.00005446f, -0.05460947f, -0.05034143f, -0.05145208f, -0.02276446f, 0.03772798f, -0.01591876f, -0.05553055f, 
    -0.03487886f, 0.04549361f, 0.02160997f, 0.05144118f, 0.00567401f, 0.04352905f, -0.03260285f, -0.06286848f, 
    -0.03798893f, 0.03756689f, -0.03047018f, -0.03657874f, -0.00566492f, -0.06251826f, 0.04478864f, 0.01081949f, 
    -0.05936592f, -0.05383440f, -0.00287626f, -0.04993713f, 0.00046543f, 0.02841000f, -0.01188017f, -0.00435762f, 
    -0.05071274f, -0.03157218f, -0.04004306f, -0.01718403f, -0.03068606f, -0.06125933f, 0.01764337f, -0.00335038f, 
    0.02140504f, -0.06159347f, -0.04248557f, -0.05321732f, -0.04949255f, -0.04443156f, 0.02257464f, 0.04070393f, 
    0.05179812f, -0.02175654f, -0.01618739f, 0.00392884f, 0.04630388f, -0.00884360f, -0.03741939f, 0.02212169f, 
    -0.01656789f, 0.03749100f, 0.03759427f, 0.01305198f, -0.02252418f, 0.00710023f, 0.02249160f, 0.04794492f, 
    0.01792289f, -0.03443205f, -0.00009334f, -0.05289325f, -0.01152153f, -0.06904123f, -0.01762320f, -0.06625583f, 
    -0.04191329f, -0.05428890f, -0.05170246f, 0.03091758f, 0.03416174f, -0.04621378f, -0.00449020f, -0.03241291f, 
    0.02480340f, 0.00852357f, -0.01679133f, -0.06345268f, -0.01806587f, -0.02209969f, -0.03379557f, -0.00935204f, 
    -0.01492306f, -0.02390161f, -0.02089179f, -0.04951610f, 0.03921610f, -0.02005362f, -0.04527086f, -0.00432764f, 
    0.01248217f, -0.06427588f, -0.03604368f, -0.04750832f, 0.02666549f, 0.02363921f, 0.00343899f, 0.04201830f, 
    -0.01373674f, 0.00578181f, 0.01926404f, -0.02612183f, -0.02727556f, -0.05514451f, 0.00867180f, 0.02113049f, 
    0.02769818f, 0.03667754f, 0.03015900f, 0.03511672f, 0.03905622f, 0.02110394f, 0.02136645f, -0.00675991f, 
    -0.05075895f, -0.01618042f, -0.01959196f, -0.01277433f, 0.00122501f, -0.02310714f, -0.01248036f, 0.01319276f, 
    -0.03136222f, 0.01400751f, 0.02425438f, -0.05656894f, -0.05529177f, 0.04001033f, -0.01024568f, 0.00501678f, 
    0.00018742f, 0.01234851f, -0.04244254f, -0.03413454f, 0.03009182f, 0.04786050f, 0.02122147f, 0.04347556f, 
    0.00105758f, 0.00174691f, -0.00004177f, 0.00754762f, -0.00196727f, 0.03346969f, 0.04809653f, -0.04855632f, 
    0.00018463f, -0.01560152f, -0.03784249f, -0.05889384f, -0.05681630f, -0.04474814f, 0.04993632f, -0.03780590f, 
    -0.05976757f, -0.00996277f, -0.00068110f, 0.03961169f, -0.03015267f, 0.02368640f, -0.02988749f, -0.04609450f, 
    -0.02117676f, 0.03492777f, 0.04241553f, 0.02812457f, 0.02470600f, 0.01846769f, 0.00217288f, -0.00733322f, 
    -0.05306843f, -0.00302141f, 0.02822530f, 0.01039318f, -0.03287997f, -0.02370444f, 0.01445627f, 0.03827574f, 
    0.02369399f, -0.00423167f, -0.05022580f, -0.02570262f, -0.00285164f, 0.00179755f, 0.01531913f, -0.06445653f, 
    -0.04117080f, 0.02047223f, 0.03329003f, -0.02319685f, 0.02828746f, -0.04279868f, 0.03680681f, -0.01387258f, 
    -0.01374944f, -0.02451618f, -0.05591486f, -0.02481948f, 0.00818963f, -0.04230912f, 0.02192655f, 0.00729003f, 
    0.01599629f, -0.01907243f, 0.04475612f, -0.02834863f, -0.03344693f, 0.05074391f, -0.04066118f, 0.01385065f, 
    -0.01150009f, -0.04651120f, 0.04527146f, -0.03617727f, -0.00907436f, -0.00676510f, -0.03835108f, -0.03942240f, 
    -0.00134911f, -0.05759056f, -0.00960265f, 0.00546083f, -0.05586764f, -0.02278075f, 0.03808935f, 0.04035455f, 
    -0.00354666f, 0.04029323f, 0.02106472f, 0.00937802f, -0.00302668f, -0.04806398f, -0.02490974f, 0.01715240f, 
    -0.04066279f, -0.01249282f, 0.01605475f, -0.02281798f, -0.03961872f, 0.00536961f, 0.02559287f, -0.01989315f, 
    -0.05496708f, 0.00885473f, 0.03135027f, 0.02560022f, -0.00055968f, -0.04639851f, -0.06123339f, -0.00192896f, 
    0.02827675f, 0.03964230f, 0.04335114f, -0.04903115f, 0.03099738f, -0.03492576f, 0.01163435f, 0.02484320f, 
    0.02312318f, 0.03413149f, 0.00538067f, 0.00615870f, 0.03195691f, -0.04499442f, -0.01773313f, -0.00122464f, 
    -0.03256548f, 0.04067359f, 0.03652833f, -0.02307612f, -0.03662930f, 0.01115355f, 0.00152999f, -0.06059300f, 
    -0.00096487f, -0.03606189f, -0.01251888f, -0.02082337f, -0.04487598f, -0.00235512f, -0.03144235f, 0.01525069f, 
    0.02651802f, 0.04194495f, -0.05523251f, 0.01329947f, -0.04736086f, -0.00301878f, -0.01226946f, -0.01419757f, 
    0.02816148f, -0.05242685f, -0.01280820f, -0.02848583f, 0.03642817f, 0.01524423f, -0.03208958f, 0.03416182f, 
    -0.01363631f, 0.03319575f, -0.05600215f, -0.04397589f, -0.01420181f, -0.02238112f, -0.05801905f, 0.02291121f, 
    0.03310002f, -0.02585600f, -0.01939655f, 0.00433495f, -0.00925644f, 0.00255092f, 0.03528694f, -0.04014822f, 
    -0.03814405f, -0.02634905f, -0.01769507f, 0.00904382f, 0.01379714f, 0.01654494f, -0.01964008f, 0.03121870f, 
    -0.06592426f, 0.02823058f, -0.00766847f, -0.03842129f, 0.00163424f, -0.06099072f, -0.00677313f, 0.02260208f, 
    0.00388033f, 0.01873381f, 0.03219626f, 0.02993684f, -0.06362437f, -0.04177411f, -0.01439747f, -0.04147185f, 
    -0.02261325f, -0.01623525f, -0.00068195f, -0.06472427f, -0.03130018f, -0.01588871f, -0.01343563f, -0.08486953f, 
    -0.00488755f, -0.04798350f, -0.06045236f, -0.02957744f, 0.01092956f, -0.05971641f, -0.04507713f, 0.01116487f, 
    -0.03612270f, 0.02116132f, 0.01272364f, -0.03736297f, 0.00925467f, -0.05967470f, -0.05056973f, 0.02162654f, 
    -0.05844560f, -0.04093608f, -0.02892656f, -0.09081554f, -0.05887830f, -0.07184278f, -0.00478488f, -0.02025189f, 
    0.01358875f, 0.04284086f, 0.02317275f, -0.07567111f, -0.08035363f, -0.01690664f, 0.00305886f, -0.09150892f, 
    -0.03734327f, -0.01845238f, -0.03073022f, 0.02251986f, 0.04415603f, 0.00927359f, 0.00886451f, -0.01247765f, 
    -0.06781092f, -0.02898138f, -0.08577289f, 0.00466110f, 0.00561235f, -0.00805196f, -0.01579240f, -0.00793532f, 
    0.01197167f, -0.08324035f, -0.08247612f, -0.02951936f, -0.02617936f, -0.05006735f, -0.00168365f, 0.02057177f, 
    -0.04584618f, -0.03323834f, 0.01598774f, 0.01131932f, 0.00954052f, -0.03006593f, -0.04858779f, 0.00817865f, 
    -0.06214758f, 0.01583066f, -0.01999522f, -0.08343457f, -0.06364404f, 0.01855588f, -0.04534890f, -0.06006605f, 
    -0.00524811f, -0.02763533f, -0.09024773f, -0.07598071f, -0.07339093f, -0.03664966f, -0.01256565f, -0.02366055f, 
    -0.06849815f, -0.08013582f, -0.06230644f, 0.04783517f, 0.03064643f, -0.00973409f, 0.03171206f, 0.02074774f, 
    -0.04471137f, 0.02094716f, 0.02007790f, 0.01331113f, -0.09774294f, 0.01897761f, 0.01988077f, -0.01046577f, 
    -0.01763313f, 0.01678037f, -0.05806381f, 0.03361489f, -0.03652084f, -0.02705315f, -0.05747658f, 0.02869688f, 
    -0.02772927f, -0.04205266f, -0.05035112f, 0.01346976f, 0.03203209f, 0.04313438f, 0.03033852f, -0.04987621f, 
    -0.07801583f, 0.00589677f, -0.06480557f, -0.02985937f, 0.01520225f, 0.00816273f, -0.01025340f, -0.02390740f, 
    0.01483193f, -0.02686006f, 0.02949608f, 0.00899076f, -0.05546217f, 0.03292084f, 0.00894635f, -0.05610147f, 
    0.01934526f, 0.02563679f, -0.05623359f, -0.07720819f, -0.00620480f, -0.07487825f, 0.02180369f, 0.00328539f, 
    -0.06761692f, 0.00129121f, -0.05643321f, -0.01567283f, -0.03890303f, -0.00171834f, -0.07939020f, -0.03376899f, 
    0.02961326f, -0.04552606f, 0.01074833f, -0.07225459f, -0.01667143f, -0.06368322f, 0.00443921f, -0.08755900f, 
    -0.02035782f, -0.02500010f, -0.03177324f, -0.06064489f, 0.00300986f, -0.01955471f, -0.01877669f, -0.03941756f, 
    -0.05513057f, -0.03848497f, -0.03247885f, -0.01985687f, -0.09515682f, 0.00175025f, -0.06187552f, 0.02568980f, 
    -0.06407180f, -0.05104232f, -0.06053045f, 0.01672655f, -0.05526213f, -0.03142938f, -0.00687600f, -0.03158054f, 
    -0.03396087f, -0.03554469f, 0.01568458f, -0.06217051f, 0.00540082f, -0.04481385f, -0.04945846f, 0.00732257f, 
    0.03681253f, -0.01315889f, -0.01494969f, -0.01015326f, 0.01139024f, -0.04300684f, 0.03801140f, -0.01166193f, 
    0.04157408f, -0.00075506f, -0.01273232f, -0.04234046f, 0.00181746f, -0.00069629f, -0.08556839f, -0.06500665f, 
    -0.03259388f, -0.04135831f, -0.05461870f, -0.08323295f, 0.00442735f, 0.00780277f, -0.03433344f, -0.06507900f, 
    -0.04330691f, -0.03525883f, -0.07246972f, -0.01886071f, -0.01221048f, -0.03410788f, 0.04719762f, -0.02105512f, 
    -0.08672377f, -0.03482652f, -0.06051796f, -0.07405825f, -0.04392177f, -0.04617639f, -0.08739072f, -0.05397190f, 
    -0.00250463f, -0.01547280f, -0.07629585f, -0.02051562f, 0.00873563f, -0.06932965f, -0.00699513f, -0.05772776f, 
    -0.02952030f, -0.05391582f, -0.02088111f, 0.00749207f, -0.04918122f, -0.05324073f, -0.09420154f, -0.03999770f, 
    -0.03612536f, -0.08115097f, -0.00069830f, 0.02618194f, -0.01947325f, -0.03820371f, -0.02199495f, -0.06738874f, 
    0.03142970f, -0.00639772f, -0.05158430f, -0.09537920f, -0.04992533f, 0.01909705f, -0.06288344f, 0.00293514f, 
    0.02358341f, -0.06878791f, -0.07119663f, -0.04410100f, -0.03983655f, 0.02273045f, 0.00202243f, 0.04783465f, 
    -0.05387562f, -0.03502256f, -0.01576975f, -0.03460210f, 0.01865704f, 0.03566767f, -0.04755154f, -0.05355258f, 
    0.00157443f, -0.03882411f, -0.02918855f, -0.05500662f, -0.07714272f, -0.04301240f, -0.05992256f, -0.06007073f, 
    -0.03226365f, -0.01929471f, 0.03702663f, -0.05893841f, -0.04395078f, 0.00105294f, -0.07525958f, -0.05542314f, 
    -0.06520895f, -0.02710412f, -0.00268285f, 0.01077354f, -0.04193439f, -0.03098061f, -0.03616966f, -0.06704575f, 
    -0.04932219f, -0.01629851f, 0.00021869f, 0.02579982f, -0.06589012f, -0.01431516f, 0.01340250f, -0.00238841f, 
    -0.06650256f, -0.02920800f, -0.02827803f, -0.02194969f, -0.01844213f, -0.01938675f, -0.04360577f, -0.04372847f, 
    0.05588357f, 0.01043344f, 0.07045171f, -0.46900165f, 0.08879808f, 0.02888178f, 0.03525816f, -0.13307633f, 
    0.03484686f, 0.04992722f, 0.07922664f, 0.06664921f, 0.08951688f, 0.04471243f, -0.04711785f, 0.04904972f, 
    -0.00417538f, 0.08424314f, -0.22552156f, -0.14386196f, -0.02365065f, -0.00844105f, -0.08551963f, -0.03843291f, 
    -0.14191799f, 0.07120448f, 0.06637341f, 0.06869150f, -0.05621931f, 0.00876059f, 0.13027261f, -0.05287890f, 
    -0.04620783f, 0.07372794f, -0.06287466f, 0.05157828f, 0.12798466f, -0.09129942f, 0.12449789f, -0.18133692f, 
    0.30307463f, 0.27259940f, -0.18319280f, -0.19554228f, 0.10884107f, 0.14180870f, -0.00853998f, 0.02994106f, 
    0.18117258f, 0.06060165f, 0.10215035f, -0.07932568f, 0.03021262f, 0.04958030f, 0.11176604f, 0.00598397f, 
    0.04877100f, 0.02312828f, -0.13207507f, 0.11992259f, 0.02116069f, 0.08805594f, 0.11977832f, -0.34796026f, 
    -0.06869726f, 0.11710630f, -0.05318344f, -0.01607014f, 0.08392870f, -0.02138228f, 0.04676843f, 0.11889824f, 
    -0.03214942f, -0.00631132f, 0.11743525f, 0.00888987f, 0.21068944f, -0.00162049f, 0.07186580f, 0.11230487f, 
    0.57076561f, 0.03153376f, -0.09620963f, 0.29167494f, 0.01378398f, -0.02557487f, 0.12084501f, -0.10060132f, 
    -0.25478771f, 0.14431646f, 0.12940259f, 0.06815029f, -0.08360724f, 0.03020391f, -0.00118191f, 0.06313002f, 
    0.15028568f, 0.02685162f, -0.05131635f, -0.04883213f, -0.23500945f, 0.11846718f, -0.00639285f, 0.02440587f, 
    -0.22807322f, -0.13150939f, 0.01081139f, -0.13457495f, -0.16026820f, -0.13981517f, -0.02311215f, 0.03504138f, 
    -0.02269433f, 0.09468681f, 0.09646181f, 0.05031666f, 0.07745354f, 0.00274943f, 0.02941915f, 0.03134751f, 
    -0.04677344f, 0.02679884f, -0.23531587f, -0.03602821f, -0.08382221f, -0.23731114f, -0.07180493f, 0.02129126f, 
    -0.08792861f, -0.05921032f, 0.03952309f, 0.04123706f, 0.21014014f, -0.00658862f, -0.03224005f, 0.05275267f, 
    0.22650163f, 0.16100466f, -0.04570707f, 0.09453034f, 0.18027867f, 0.00728821f, -0.01576762f, -0.07295268f, 
    -0.25475115f, 0.01365381f, -0.01192304f, -0.21785094f, -0.13842027f, 0.04955041f, 0.11656594f, 0.19046818f, 
    0.03726373f, 0.22049479f, -0.01542700f, -0.09516367f, 0.09571791f, 0.18825091f, 0.02452119f, 0.28481388f, 
    0.51069653f, 0.42579105f, -0.19047567f, -0.20077050f, 0.22294787f, 0.19478053f, 0.10728164f, 0.07381526f, 
    -0.08896412f, 0.04705324f, 0.05194687f, -0.07551319f, -0.09509648f, 0.02803317f, 0.23086201f, 0.17249906f, 
    -0.05134300f, -0.07071765f, 0.01928487f, 0.05187084f, -0.23885180f, -0.18489347f, -0.43445221f, -0.20075139f, 
    -0.05028175f, -0.01629493f, -0.03821674f, 0.05907129f, 0.02986658f, -0.03352569f, 0.00287883f, 0.01470276f, 
    -0.11462637f, 0.03485295f, -0.11084479f, -0.09847113f, 0.21636300f, 0.16305199f, 0.21025743f, 0.09649517f, 
    0.20665060f, 0.06715465f, -0.05702860f, -0.06701487f, 0.12399147f, 0.07986251f, 0.08617047f, 0.07922862f, 
    -0.10213045f, -0.09838780f, -0.06281611f, 0.02961662f, -0.00237033f, -0.00313821f, 0.11036602f, 0.15649185f, 
    0.03740581f, -0.13883822f, -0.17531621f, -0.12617770f, -0.34204677f, -0.37484035f, -0.62479335f, -0.34972191f, 
    0.02728349f, 0.06076558f, 0.12594227f, 0.28891790f, -0.08912898f, 0.00137313f, -0.14348550f, -0.02520750f, 
    0.12487849f, 0.21581262f, 0.06640083f, 0.00539475f, 0.06581418f, -0.06208162f, -0.07140274f, -0.13249236f, 
    -0.14407751f, 0.17646885f, 0.47350985f, 0.11016885f, -0.06503038f, -0.08923989f, -0.03392048f, -0.17400122f, 
    0.11847278f, 0.03212143f, 0.06224305f, -0.09818950f, 0.07459120f, -0.06580080f, -0.08930825f, -0.10669395f, 
    -0.07337724f, -0.14195719f, 0.02875049f, -0.20564948f, -0.37881118f, -0.07256673f, -0.06186513f, -0.05466310f, 
    -0.11476651f, -0.08096346f, 0.12967624f, -0.14139782f, -0.03543627f, -0.09751501f, -0.00117198f, 0.21245465f, 
    0.19859728f, 0.00781878f, 0.09572529f, -0.02181815f, -0.01574514f, -0.19683889f, 0.11936021f, -0.07061291f, 
    0.31069082f, 0.53778088f, 0.02379949f, -0.36912060f, 0.20999324f, 0.08440238f, 0.10190544f, -0.09728573f, 
    0.23452291f, 0.12277833f, 0.10803138f, -0.00554259f, 0.00196196f, -0.03445854f, 0.13730952f, -0.10633094f, 
    -0.02687638f, 0.09506293f, -0.03365184f, -0.12534606f, 0.16492237f, 0.22879669f, 0.20360288f, -0.37854719f, 
    0.18796435f, -0.02112121f, 0.00006294f, -0.07614131f, -0.08639984f, 0.09071153f, 0.10275914f, 0.04030156f, 
    -0.15386759f, -0.07928544f, -0.06013901f, 0.06277732f, -0.03890929f, 0.00307225f, -0.14579247f, -0.17787367f, 
    0.02255683f, -0.00227970f, -0.04181336f, 0.00505708f, 0.03898904f, 0.01311419f, 0.00669926f, 0.02372121f, 
    -0.03330762f, 0.04324979f, 0.01232585f, -0.00177579f, 0.03896561f, -0.04267280f, -0.00098667f, -0.01238524f, 
    -0.04405034f, -0.06187971f, 0.01909549f, -0.00999056f, 0.01150979f, -0.02762952f, 0.02117296f, -0.00201422f, 
    0.03538281f, -0.04063559f, 0.01913407f, -0.03383514f, -0.05879473f, -0.01094028f, -0.05259475f, 0.01622462f, 
    0.03911508f, -0.02239118f, -0.02034243f, 0.01410917f, -0.03470508f, 0.02856063f, -0.00696056f, 0.02906662f, 
    0.01309924f, -0.04473425f, 0.02355208f, 0.01455782f, -0.03088214f, 0.03014243f, 0.02517626f, -0.01613995f, 
    -0.00515709f, 0.00928181f, -0.04566850f, -0.06979639f, 0.04505238f, 0.02723192f, -0.00136726f, -0.01466972f, 
    0.03410517f, -0.00265822f, 0.00623995f, 0.03762049f, 0.03410806f, -0.03561140f, 0.02134998f, -0.03132094f, 
    0.00307101f, -0.03842033f, 0.04091122f, 0.01105772f, -0.01588434f, -0.00788187f, -0.04600220f, -0.00532331f, 
    0.04453870f, 0.00111601f, -0.06233944f, 0.04430539f, 0.03992481f, -0.03284477f, 0.02693679f, -0.04032000f, 
    -0.04955884f, 0.03242752f, -0.05296100f, 0.01256845f, -0.01464505f, -0.00571781f, -0.01149103f, -0.00886381f, 
    -0.06159811f, -0.00695338f, 0.02674128f, -0.03072287f, -0.02590683f, -0.00675200f, -0.03803862f, 0.00835696f, 
    0.01470000f, 0.02934267f, -0.02453967f, 0.00743043f, -0.00844767f, 0.02048241f, 0.02043079f, -0.04567747f, 
    -0.02466342f, 0.03904548f, -0.05950330f, -0.04105431f, -0.04346769f, -0.01216336f, 0.01817365f, 0.02248074f, 
    0.01411410f, -0.03211581f, 0.00993595f, -0.03189996f, -0.01768363f, 0.02059207f, 0.01024985f, -0.04647652f, 
    -0.02999822f, -0.01216962f, -0.02028880f, 0.00197905f, -0.01446147f, 0.02356948f, 0.04310215f, -0.05935160f, 
    0.03323103f, -0.04772100f, 0.02095724f, -0.04515874f, 0.01635317f, -0.03138828f, -0.04656085f, 0.03780376f, 
    0.01219176f, -0.03455914f, 0.01978415f, -0.03814562f, 0.00594142f, 0.01871014f, 0.02803353f, -0.01335476f, 
    0.02486207f, -0.02082532f, 0.00841261f, 0.04070556f, -0.01817930f, 0.04128864f, -0.05185673f, 0.00825020f, 
    0.00751931f, -0.05915112f, 0.03179133f, -0.04005177f, -0.01316855f, -0.06104619f, 0.00752546f, -0.01654691f, 
    -0.04856228f, 0.00233082f, -0.01458289f, 0.01420855f, -0.00750692f, -0.03124042f, 0.02652114f, 0.01581837f, 
    -0.06309062f, -0.05384182f, -0.01981001f, -0.01286513f, 0.02289779f, -0.05636714f, 0.02411574f, -0.01166347f, 
    -0.04774460f, 0.00624400f, -0.06415895f, -0.00385624f, 0.04984653f, -0.05248479f, -0.03750562f, 0.02083237f, 
    -0.00986750f, -0.06301755f, 0.01513648f, 0.00405883f, -0.06109883f, -0.05225503f, -0.00451517f, 0.03857587f, 
    -0.02739909f, 0.02015724f, 0.03849220f, 0.03938190f, 0.02081482f, -0.05224648f, 0.00547887f, -0.00387319f, 
    0.00019898f, 0.04626410f, -0.02759328f, 0.02740890f, -0.06185737f, 0.03312466f, -0.03637902f, -0.05546639f, 
    -0.01548441f, -0.03276106f, -0.05960511f, -0.05386692f, -0.03190415f, -0.00883574f, -0.06379008f, -0.03046229f, 
    0.04047257f, 0.00922648f, -0.01772450f, -0.00654708f, -0.04083993f, 0.04170743f, 0.04110168f, -0.05801242f, 
    0.04594779f, 0.03304069f, -0.03726348f, -0.01754177f, 0.02553530f, -0.04165500f, 0.05159208f, 0.02887421f, 
    -0.01909505f, 0.02730457f, -0.00676776f, 0.01612583f, -0.05449294f, -0.00741356f, -0.06260614f, -0.06699036f, 
    -0.04778836f, -0.04490033f, 0.02595448f, -0.01974326f, -0.02216774f, 0.01988389f, 0.03599117f, 0.00324667f, 
    0.03893206f, 0.02069713f, 0.00284874f, -0.02769254f, -0.00811506f, -0.02201871f, -0.05515261f, 0.03936956f, 
    0.02191055f, -0.04059684f, -0.00471419f, -0.02972507f, -0.04068502f, 0.04408091f, -0.04142183f, 0.00687747f, 
    0.02760504f, -0.05612045f, -0.03399427f, -0.05310999f, -0.02721944f, 0.04715841f, 0.05245388f, 0.04816739f, 
    0.04099997f, 0.01767561f, -0.00989812f, -0.00954777f, 0.02248614f, 0.01650307f, -0.01193797f, 0.01855849f, 
    0.01267667f, 0.03089201f, -0.03940602f, -0.04195552f, -0.06296410f, -0.03118577f, -0.01566935f, -0.04779148f, 
    -0.05807755f, 0.02057648f, -0.01014257f, -0.02594788f, -0.01261129f, -0.01767706f, -0.03616077f, -0.01874127f, 
    0.01367173f, -0.05468056f, -0.02885217f, 0.03722160f, -0.03655473f, 0.03621218f, -0.02363650f, -0.06298138f, 
    -0.02556807f, -0.04630808f, -0.03723578f, 0.03647019f, -0.01253715f, -0.00867091f, 0.00892760f, -0.06566231f, 
    0.00489461f, 0.02953280f, 0.03696565f, -0.01811201f, 0.00629771f, 0.00695161f, 0.03685395f, -0.00996609f, 
    -0.01487767f, -0.04956737f, -0.05643460f, -0.03794992f, -0.04709944f, -0.03638021f, -0.02817627f, -0.02398113f, 
    0.02814353f, -0.06667265f, -0.04961105f, -0.03611711f, -0.00552684f, -0.04899541f, 0.03372250f, -0.00330296f, 
    0.00744273f, 0.03019848f, 0.03668579f, 0.01046279f, -0.05239455f, -0.06304695f, -0.03495878f, 0.04161500f, 
    0.04475071f, -0.02107163f, 0.03880830f, 0.01773129f, -0.00574513f, -0.05455494f, -0.04865319f, 0.01379193f, 
    -0.01125518f, 0.02949706f, -0.00111126f, 0.04408570f, -0.06493869f, -0.05178359f, 0.02245433f, 0.00641797f, 
    0.02965950f, 0.02155547f, -0.01088900f, 0.02600813f, -0.00051438f, -0.03799260f, -0.04162653f, -0.04616475f, 
    -0.05708671f, -0.02068363f, 0.02088747f, 0.04222470f, 0.00236504f, -0.03086059f, -0.00570636f, 0.03102941f, 
    0.03658643f, 0.01443554f, 0.01762139f, -0.03508779f, 0.04415054f, -0.01197342f, 0.02204161f, 0.02911487f, 
    0.04132239f, 0.01705639f, 0.00212229f, -0.00841610f, 0.00571371f, -0.02366403f, -0.00732777f, -0.05102503f, 
    -0.05705762f, 0.02548598f, 0.02094916f, 0.03257447f, -0.02416290f, -0.04513850f, 0.01027954f, -0.05110270f, 
    0.04773998f, 0.03535185f, 0.03460696f, -0.05853829f, 0.01243779f, -0.02602480f, -0.03698770f, 0.04919058f, 
    -0.04396678f, 0.04457282f, 0.04512170f, -0.06092972f, -0.06487890f, 0.00806550f, -0.04517696f, 0.02685131f, 
    -0.00196886f, -0.00316810f, -0.02551369f, -0.04670430f, 0.00744780f, -0.05257624f, -0.04282752f, 0.02826925f, 
    -0.05257969f, -0.04875956f, -0.03686189f, 0.02673852f, -0.00811230f, -0.02729743f, 0.03918465f, -0.02257872f, 
    0.02577484f, -0.00186666f, -0.05767753f, -0.01394636f, -0.06316023f, -0.05879504f, 0.00988574f, -0.05884095f, 
    0.03824542f, 0.00874346f, -0.05195490f, -0.05416699f, -0.04202430f, -0.03273106f, -0.06230454f, 0.03071569f, 
    0.01073279f, -0.05254550f, 0.04959323f, -0.04861568f, -0.01667275f, -0.02099296f, -0.01010577f, -0.05214471f, 
    -0.00849060f, -0.02018911f, -0.02329506f, -0.06133185f, -0.04011735f, -0.03875816f, 0.02479656f, -0.00305032f, 
    0.02574970f, -0.01005072f, 0.02434622f, 0.00236640f, -0.05067012f, -0.02999293f, 0.03711277f, 0.03835754f, 
    0.02324269f, -0.03406153f, 0.00162164f, 0.01803313f, -0.02851212f, -0.00949603f, -0.01595771f, -0.02395855f, 
    -0.06323130f, -0.02761934f, 0.03947654f, 0.03626376f, -0.02507070f, 0.02534406f, 0.01443545f, 0.04593753f, 
    -0.03416054f, 0.03351995f, -0.02802002f, 0.00816120f, -0.05016020f, 0.00343006f, 0.02610681f, -0.04686692f, 
    -0.04845155f, 0.02725152f, -0.04405900f, -0.05334111f, -0.01082910f, -0.02093263f, -0.03933307f, 0.00957070f, 
    -0.01055808f, -0.02498426f, 0.04110423f, -0.01743256f, 0.01733472f, 0.03678348f, -0.00662622f, 0.04210857f, 
    -0.03416171f, -0.05961383f, 0.02788998f, 0.02180158f, 0.01826789f, -0.03215999f, -0.03025340f, -0.02882324f, 
    0.04090895f, 0.03577657f, 0.00709133f, 0.03850256f, -0.01247588f, -0.01442272f, -0.03369979f, -0.00835904f, 
    0.02506064f, -0.02362086f, -0.04578507f, -0.01050556f, 0.01731005f, -0.03836153f, 0.01312385f, -0.04569536f, 
    -0.05438228f, -0.00515330f, 0.04378508f, -0.02759210f, -0.01170650f, -0.00677500f, -0.02505705f, -0.00440492f, 
    -0.02851855f, 0.00171712f, -0.00140771f, -0.03588367f, -0.01938747f, -0.02947310f, -0.01887230f, -0.00530525f, 
    0.00585143f, 0.02035487f, -0.00409475f, 0.04137461f, -0.01523713f, 0.00996639f, 0.03626815f, -0.00914305f, 
    -0.02295211f, -0.05686136f, 0.03004009f, -0.00415416f, 0.03763638f, -0.03255432f, 0.02456091f, 0.02014324f, 
    -0.04430348f, -0.05893068f, -0.03701194f, 0.00923852f, 0.00256437f, 0.04118391f, 0.00048400f, -0.04092188f, 
    0.04403753f, 0.03159221f, 0.00572214f, 0.01965817f, -0.01978134f, 0.03067372f, -0.02486373f, 0.03488631f, 
    0.04738660f, 0.02970321f, -0.05179559f, -0.02749297f, -0.03867181f, 0.02075336f, 0.00977212f, 0.03283370f, 
    0.02569564f, -0.01148165f, 0.00494009f, -0.03980096f, 0.04529813f, 0.00975057f, -0.00268618f, 0.02880387f, 
    0.04044339f, 0.02125437f, 0.00128762f, -0.02543268f, 0.00827221f, 0.00558458f, 0.02867714f, 0.04034431f, 
    -0.06137659f, 0.03780438f, 0.02208500f, 0.03367892f, 0.02110219f, -0.03066195f, 0.00729870f, -0.06249144f, 
    -0.03837946f, -0.04344843f, -0.06571244f, -0.00916854f, -0.02395633f, -0.04388404f, 0.03674650f, 0.01281428f, 
    -0.01211881f, -0.01436042f, -0.04053473f, -0.00410573f, -0.04860388f, -0.02181536f, -0.02988398f, 0.00840156f, 
    -0.00235209f, -0.02887137f, -0.06177817f, 0.00045198f, -0.00927636f, 0.03295520f, -0.00536734f, 0.02359923f, 
    -0.05138597f, 0.03068289f, -0.03703345f, -0.00003050f, -0.03425232f, -0.04211166f, -0.03770757f, 0.00708718f, 
    -0.05844516f, -0.01388782f, -0.03110171f, 0.01848292f, 0.01797178f, 0.02862505f, 0.01042216f, -0.06063122f, 
    -0.05310146f, -0.01368301f, -0.04543072f, 0.04756752f, -0.00314338f, -0.04124124f, -0.00039096f, 0.01264297f, 
    0.01020202f, -0.01147648f, 0.02634396f, -0.03022741f, 0.00792143f, -0.03880927f, -0.05259426f, 0.00799778f, 
    -0.06128943f, -0.02489732f, -0.02634879f, -0.02821941f, -0.03285908f, 0.04320567f, -0.01213984f, 0.00363557f, 
    0.04759822f, 0.03608565f, 0.01098353f, -0.00959632f, -0.02851989f, -0.03944025f, 0.00712337f, -0.05323752f, 
    -0.02445654f, 0.01784582f, 0.00998922f, 0.00806604f, -0.00465689f, -0.00240357f, 0.01873448f, 0.02155660f, 
    -0.00047235f, 0.03515689f, 0.00742415f, -0.05143210f, 0.04489898f, 0.00389014f, -0.03532501f, -0.04411826f, 
    -0.01103713f, -0.02580544f, 0.00395361f, 0.00462627f, 0.02537365f, 0.01378711f, -0.03689900f, 0.03506942f, 
    0.01717561f, -0.02751741f, 0.01829910f, -0.04331146f, 0.02261174f, -0.02814209f, 0.01612773f, -0.04010676f, 
    0.00923542f, 0.00764288f, -0.00943794f, -0.00100933f, 0.00534497f, 0.03435253f, -0.03163948f, 0.00580107f, 
    -0.00707812f, 0.01102227f, -0.00520995f, -0.04646723f, -0.05548834f, 0.02082293f, -0.05242015f, 0.03016342f, 
    0.00113074f, 0.04633122f, 0.02006749f, -0.05391874f, 0.03844336f, 0.00482225f, -0.05002352f, -0.00118519f, 
    0.01579368f, -0.02324475f, 0.02236521f, -0.05268784f, 0.01083286f, 0.03842847f, -0.00297821f, -0.05530856f, 
    -0.04282727f, 0.01834061f, 0.04386281f, 0.00350490f, -0.03060882f, -0.05190463f, 0.02124669f, 0.01888650f, 
    -0.00497076f, -0.03308984f, 0.01605103f, -0.04996313f, -0.05418636f, -0.03511867f, 0.03653993f, -0.00140132f, 
    -0.03650346f, -0.01859716f, -0.01114917f, 0.03043726f, -0.05989363f, -0.04449635f, -0.02259866f, -0.02207177f, 
    0.00340657f, 0.01483621f, 0.04500007f, 0.04852025f, 0.00363142f, 0.03043314f, 0.04347064f, -0.00828873f, 
    -0.04936941f, 0.01829450f, 0.02702478f, -0.06099002f, -0.05455199f, -0.01569089f, 0.00615962f, 0.01230076f, 
    -0.03182576f, -0.03968202f, 0.01278995f, 0.02913384f, 0.03986732f, -0.02470232f, -0.05304111f, 0.02506514f, 
    -0.00059147f, -0.04669687f, -0.05413294f, 0.02408213f, -0.02466561f, -0.00157987f, 0.02836104f, -0.02864388f, 
    -0.00700629f, 0.02485321f, 0.03120422f, 0.02888545f, 0.02894047f, -0.01855752f, 0.03908578f, 0.01426908f, 
    0.04598409f, 0.00289040f, 0.03645232f, 0.01590664f, -0.04497701f, -0.04854601f, -0.03904377f, -0.06181430f, 
    0.03353233f, 0.02071953f, 0.04407356f, 0.00826143f, 0.01983169f, 0.04853211f, -0.03833862f, -0.02659466f, 
    0.00636870f, 0.04953258f, -0.04012623f, 0.04155835f, -0.05456232f, -0.01742452f, -0.04147348f, -0.04807959f, 
    0.01501596f, 0.02208150f, -0.00106191f, -0.04927544f, 0.01198401f, -0.05686254f, -0.05938849f, -0.02185355f, 
    -0.05570587f, 0.00442612f, -0.03585359f, 0.01121939f, -0.01937812f, -0.00969765f, -0.05870152f, 0.00259925f, 
    0.00571869f, -0.04605959f, -0.01649014f, -0.03027128f, 0.01615727f, 0.00065883f, -0.05088001f, -0.06058968f, 
    -0.06160411f, -0.04077919f, -0.00692425f, -0.02856763f, -0.05043853f, 0.04605896f, -0.05457306f, -0.03020416f, 
    0.04184311f, -0.02204618f, 0.03329024f, 0.00498317f, 0.00801678f, -0.00136269f, 0.00004517f, 0.02677025f, 
    -0.03817156f, -0.05296000f, -0.00475450f, -0.01908937f, -0.01753999f, -0.02492293f, -0.03781460f, 0.00534970f, 
    -0.05258823f, -0.05547185f, 0.04073093f, 0.02152748f, 0.02342193f, -0.01673309f, -0.02188191f, -0.02426798f, 
    -0.02858492f, -0.02232960f, -0.05033101f, -0.04073315f, -0.05103788f, 0.02779397f, -0.02263294f, -0.00990682f, 
    -0.02175911f, 0.03490215f, 0.02913083f, -0.03896604f, -0.03308028f, 0.04183627f, 0.02671445f, 0.03792198f, 
    -0.04274276f, 0.03712718f, -0.02331777f, 0.01143521f, 0.04494598f, -0.02063575f, 0.01401275f, 0.03867983f, 
    0.05548433f, 0.03863227f, 0.02462181f, -0.01006460f, -0.04103578f, -0.02889306f, 0.02084697f, -0.04165041f, 
    0.04007157f, -0.02082218f, 0.00392367f, 0.01105056f, -0.00870756f, -0.01364669f, -0.03784782f, 0.04070254f, 
    0.00553474f, 0.00922527f, -0.02260632f, -0.01378703f, 0.00689066f, 0.05137323f, 0.03975150f, -0.02567079f, 
    -0.02038585f, 0.01010861f, -0.05058870f, -0.02856673f, -0.00376258f, -0.02483996f, -0.03468770f, -0.04112248f, 
    -0.05538289f, -0.03376989f, -0.03613699f, 0.02910634f, 0.01642710f, -0.02589815f, -0.03907331f, 0.04276945f, 
    -0.02733384f, 0.03704137f, 0.01559616f, -0.05034890f, -0.00565487f, -0.04315327f, 0.02538524f, -0.05036617f, 
    -0.02949646f, -0.05113411f, -0.05116604f, -0.02862098f, 0.02784788f, 0.00056310f, -0.00299395f, -0.04901760f, 
    -0.05521694f, 0.03427136f, 0.04303038f, -0.00827500f, 0.03926633f, -0.03082884f, -0.04098177f, 0.02758954f, 
    0.01636843f, -0.05509645f, 0.01180988f, 0.03669625f, 0.01586417f, -0.01485310f, -0.00270260f, -0.03516381f, 
    -0.04274385f, -0.02149964f, -0.01034721f, -0.04008206f, 0.00327959f, 0.03415941f, -0.00823366f, 0.02167981f, 
    0.02896936f, 0.02423985f, 0.01890656f, 0.01259780f, -0.05541378f, 0.00412129f, -0.04702172f, -0.03324325f, 
    -0.03037201f, -0.00308443f, 0.00624955f, 0.04699668f, 0.01617856f, -0.04577141f, 0.02503036f, -0.01537315f, 
    0.03870920f, 0.00300803f, -0.00635248f, -0.05287887f, 0.03099464f, 0.02819825f, -0.05386500f, 0.02167664f, 
    0.04785906f, 0.02018484f, 0.01360626f, 0.04982068f, 0.02202036f, -0.00453144f, 0.01055340f, -0.03595189f, 
    -0.02307527f, 0.02578543f, -0.01947914f, 0.02554822f, 0.02519241f, -0.04984340f, 0.02188092f, -0.02874605f, 
    -0.00987374f, 0.04786149f, 0.03226690f, 0.00438456f, -0.02279803f, -0.00352410f, 0.00555415f, -0.03334627f, 
    -0.05763068f, -0.02966917f, 0.00106053f, -0.00431745f, 0.05130532f, -0.01447698f, -0.02951350f, -0.03117941f, 
    -0.03918443f, -0.05502330f, -0.00514604f, -0.01020468f, -0.05443329f, -0.05331763f, 0.02757423f, 0.02299179f, 
    -0.01678330f, -0.01682682f, 0.01353711f, -0.04929149f, 0.03482874f, -0.05389963f, 0.00501216f, -0.00225870f, 
    -0.01163252f, -0.00334267f, -0.04592843f, -0.05963085f, -0.03539661f, 0.02527451f, -0.05726493f, 0.00937123f, 
    -0.05712876f, -0.01262107f, 0.03957318f, 0.03291265f, 0.00815155f, 0.00139977f, 0.03999896f, -0.02506055f, 
    0.02320214f, 0.01306766f, 0.01200441f, -0.05709946f, -0.00447508f, -0.04121787f, 0.04202751f, 0.03705131f, 
    0.04365461f, -0.00490280f, 0.00873833f, -0.04851983f, 0.02438198f, 0.03039477f, -0.04148004f, 0.02847736f, 
    -0.02300224f, 0.04866969f, 0.04100563f, 0.02907211f, -0.03872262f, -0.00996354f, -0.00941622f, 0.01521179f, 
    -0.03028312f, 0.00133469f, -0.01691484f, 0.01845753f, 0.04978555f, -0.00584498f, -0.03121647f, -0.02346313f, 
    -0.03124734f, 0.02301356f, 0.01202293f, -0.00849585f, 0.02030160f, 0.03121820f, -0.00586531f, 0.03675834f, 
    -0.00868848f, 0.04674315f, -0.00114201f, -0.01903610f, -0.02154354f, 0.03047866f, 0.00194801f, 0.04465755f, 
    -0.00086092f, -0.05525985f, -0.05991564f, -0.04626822f, 0.01382568f, -0.04835105f, -0.04363124f, 0.04799752f, 
    0.02614029f, 0.00213391f, -0.00906889f, -0.03443215f, 0.01724693f, -0.01078809f, 0.00496943f, -0.03323950f, 
    0.00694388f, 0.03900240f, 0.03505307f, -0.00457407f, -0.04121674f, -0.02050106f, 0.04491008f, 0.04167666f, 
    -0.04210416f, -0.03618930f, -0.01952894f, -0.02944208f, -0.01058924f, 0.01008896f, -0.02380058f, 0.00164908f, 
    -0.00092925f, 0.01368284f, -0.00852504f, -0.05672286f, 0.03346779f, -0.01697887f, -0.05532590f, -0.03507947f, 
    -0.02965192f, 0.03865050f, -0.05131432f, -0.02980652f, -0.01378530f, -0.00458918f, -0.04987109f, -0.01970602f, 
    -0.00522362f, -0.05441046f, -0.02719220f, -0.02841880f, -0.04267557f, -0.01149416f, 0.02278950f, -0.02200126f, 
    -0.00216136f, 0.03764638f, 0.02107380f, 0.04141579f, 0.01622814f, -0.00558682f, 0.05075510f, -0.02582673f, 
    -0.04766697f, 0.01466610f, -0.05804462f, -0.01921874f, 0.00556369f, -0.02780499f, -0.03474424f, -0.00082801f, 
    -0.01147484f, 0.03134312f, 0.04373342f, 0.02585611f, 0.02780343f, 0.04040581f, 0.03262585f, 0.00345299f, 
    0.00331563f, 0.01253837f, 0.03934935f, -0.01307168f, -0.04566867f, -0.00880623f, 0.03197141f, -0.02821459f, 
    -0.03005149f, -0.04758139f, -0.04251888f, -0.01124939f, -0.02304041f, -0.05707103f, -0.04000264f, -0.02978299f, 
    -0.04210050f, -0.02493969f, -0.00155776f, 0.03602571f, -0.00228829f, -0.00118030f, -0.05501913f, -0.05288431f, 
    -0.02331279f, -0.05168169f, -0.03257888f, 0.04182001f, 0.03014307f, -0.04671687f, 0.03792152f, -0.04673979f, 
    0.02691827f, 0.00444356f, 0.04684417f, -0.02732613f, -0.01635496f, 0.00604189f, 0.04341129f, -0.00830069f, 
    -0.04875583f, -0.05442058f, 0.01537827f, -0.02751613f, -0.04835510f, -0.03560326f, -0.02313420f, -0.03328295f, 
    0.00261466f, -0.02160752f, 0.03662680f, 0.01701005f, 0.01139959f, -0.00607049f, -0.05243577f, 0.01892651f, 
    0.02094755f, -0.01770543f, -0.05928434f, -0.03174387f, -0.03453619f, -0.03834262f, -0.03741477f, 0.02593770f, 
    -0.16950986f, -0.02699607f, 0.09708344f, 0.05610657f, 0.05190873f, -0.11887535f, 0.01917575f, -0.08128099f, 
    0.19871901f, 0.09461217f, -0.05809801f, 0.09950865f, -0.08489138f, -0.17996208f, 0.00243920f, 0.05416324f, 
    -0.07220605f, 0.01489121f, 0.06370494f, 0.05937030f, 0.20274371f, -0.20407204f, 0.20196499f, 0.07234854f, 
    -0.22261719f, -0.16148123f, -0.10107692f, -0.17091835f, 0.05798443f, -0.15674317f, 0.06839705f, 0.09324376f, 
    0.13481985f, -0.06522862f, 0.19805764f, 0.07022464f, 0.11426695f, 0.04044743f, 0.07429790f, -0.02947896f, 
    0.08505505f, -0.05969120f, -0.06628305f, 0.64810127f, -0.23481445f, -0.02546425f, 0.07636604f, -0.05486070f, 
    0.17306498f, 0.07067009f, -0.13876541f, 0.01281531f, 0.02546819f, 0.07784409f, -0.04298372f, 0.15470821f, 
    0.04919598f, -0.12582208f, -0.20049298f, 0.13585880f, 0.45837486f, 0.33021873f, 0.00105049f, 0.40750334f, 
    -0.07568818f, 0.02709807f, -0.04492283f, -0.07486697f, 0.11070634f, 0.01526652f, -0.09311037f, 0.13985670f, 
    0.09653834f, -0.12096697f, 0.01900828f, 0.18576235f, 0.07025523f, 0.12116402f, -0.14427911f, 0.15992990f, 
    0.65291256f, 0.05879466f, 0.39420861f, -0.07880376f, -0.50660419f, -0.06332372f, -0.26952624f, 0.00253015f, 
    -0.32625166f, -0.03059451f, -0.17040020f, 0.15921849f, 0.15732054f, -0.04108022f, 0.05604640f, 0.03006666f, 
    -0.14338402f, 0.00405665f, 0.32295206f, 0.04716149f, -0.41833344f, -0.25633913f, -0.21879353f, -0.03024722f, 
    0.21945930f, -0.18517244f, -0.28155237f, -0.21023850f, 0.05183687f, -0.12863067f, 0.27913693f, 0.10769181f, 
    0.04661730f, 0.03396639f, -0.00169468f, 0.04483305f, 0.09632062f, 0.17005292f, 0.26189834f, -0.10730966f, 
    0.26171884f, 0.08706139f, 0.03194753f, -0.31779087f, 0.26942131f, -0.16854614f, -0.07685041f, -0.14731346f, 
    -0.04778703f, -0.27030247f, 0.02144625f, 0.11774580f, 0.18586178f, -0.03654908f, 0.12497111f, 0.03610841f, 
    0.06074268f, -0.00305636f, 0.37454182f, 0.07465456f, -1.04249680f, -0.26858148f, -0.01148530f, -0.02523600f, 
    -0.04019221f, 0.07664911f, 0.22982022f, 0.09716822f, -0.10775559f, 0.03437166f, 0.01374491f, -0.02187615f, 
    0.01012797f, 0.13685349f, -0.16237020f, 0.16874267f, 0.04619797f, 0.11518236f, -0.10408545f, 0.18972959f, 
    -0.13804628f, 0.15711327f, 0.93319064f, 0.32483336f, -0.05257575f, 0.03173802f, -0.13823952f, -0.14845322f, 
    0.08573078f, -0.06787180f, 0.14004722f, -0.05949595f, -0.05942203f, -0.18263593f, 0.00920363f, 0.11099244f, 
    0.06543732f, -0.02143724f, -0.06668284f, -0.06389221f, 0.56490517f, -0.43480602f, -0.22568889f, 0.01644932f, 
    0.13520128f, 0.08298450f, -0.10860720f, -0.16557699f, 0.17630243f, -0.22275148f, -0.10309625f, 0.10171846f, 
    0.12543669f, -0.07090412f, -0.11826473f, 0.06190079f, 0.11960058f, 0.03160947f, 0.07359210f, 0.02267436f, 
    -0.00115136f, 0.29118809f, 0.26911572f, 0.23855966f, -0.33576047f, -0.01521357f, 0.11211465f, 0.04801644f, 
    -0.08901556f, -0.03055671f, 0.12209205f, -0.07440286f, -0.26276797f, -0.01207637f, 0.08229907f, 0.08624169f, 
    -0.00106991f, 0.08391122f, 0.03774898f, 0.01785272f, 0.34824258f, -0.18060796f, 0.18022563f, -0.05004243f, 
    -0.05025764f, -0.15312484f, -0.11914296f, -0.24538235f, 0.01752950f, -0.29220322f, 0.08091319f, 0.08841737f, 
    0.01024402f, 0.10933954f, 0.12008268f, 0.00403792f, -0.00643095f, 0.23746121f, 0.07780825f, -0.05004583f, 
    0.37272394f, -0.04931220f, -0.07908618f, 0.24219906f, -0.27627259f, -0.14769635f, -0.11655004f, 0.13597380f, 
    -0.49077493f, 0.20314075f, -0.02364625f, -0.02204796f, -0.20650104f, 0.20934454f, 0.13715750f, 0.16699301f, 
    -0.06811239f, 0.07298680f, 0.03367149f, 0.17461218f, -0.02795756f, -0.08028799f, -0.15529536f, -0.02192281f, 
    -0.20354113f, -0.11200963f, -0.25980371f, 0.13101158f, -0.47432393f, -0.10439982f, 0.14246865f, -0.16506930f, 
    0.03051574f, 0.24553908f, 0.16485372f, 0.11493962f, 0.13393271f, 0.22354567f, -0.02443693f, 0.06678935f, 
    -0.08191349f, 0.19214107f, 0.46000999f, 0.45504504f, 0.25622776f, 0.17270406f, -0.06105367f, -0.00147057f, 
    0.34080458f, -0.13861687f, 0.14319855f, -0.06852853f, 0.04092581f, -0.16455007f, -0.08651052f, 0.09870538f, 
    -0.01475925f, -0.18707222f, -0.16078863f, 0.15806074f, -0.36647609f, 0.21737389f, 0.02916036f, 0.54795474f, 
    -0.25007576f, 0.12930721f, 0.06938004f, 0.00810724f, 0.19625781f, 0.28508967f, -0.01996335f, 0.13856074f, 
    -0.04246954f, -0.01921700f, 0.18832971f, -0.00772235f, 0.12547530f, 0.16726944f, -0.29294381f, 0.13520156f, 
    0.14522718f, 0.26855096f, 0.31138948f, 0.15631109f, 0.11273178f, 0.03123389f, -0.01180827f, 0.24615459f, 
    -0.22370964f, -0.11017044f, 0.13454057f, -0.02539254f, 0.15046747f, 0.07358360f, 0.10148689f, 0.04336489f, 
    0.08014654f, 0.25352669f, 0.01687739f, -0.18279770f, -0.09203253f, 0.14350434f, -0.11215486f, 0.07543727f, 
    -0.02963401f, 0.07813425f, -0.03083151f, -0.01660303f, -0.15470219f, 0.06484107f, 0.00800176f, 0.07832751f, 
    0.10098109f, 0.10268616f, 0.13240997f, -0.00657800f, -0.03051532f, -0.05466449f, -0.11999526f, 0.00824227f, 
    0.29778707f, -0.20876671f, -0.32453778f, -0.22503945f, -0.03478839f, 0.16521665f, 0.19910513f, 0.00259796f, 
    -0.01376467f, -0.11776631f, -0.02539751f, -0.10748764f, -0.09769289f, -0.00279628f, 0.03017981f, -0.03808627f, 
    0.06322770f, -0.09832053f, -0.00594067f, 0.12292325f, 0.67131448f, 0.34975076f, 0.34156045f, -0.17427160f, 
    0.02375517f, -0.06328986f, 0.07042218f, 0.18901511f, 0.12415845f, 0.07774927f, -0.01372900f, 0.12229037f, 
    0.07015234f, 0.09637256f, 0.15774703f, 0.01154076f, 0.15781574f, -0.00018451f, 0.22423598f, 0.18274823f, 
    -0.48393303f, 0.11832471f, -0.23247650f, 0.48817649f, 0.36364663f, 0.04682671f, 0.08823460f, 0.02687196f, 
    0.17476350f, 0.11765950f, 0.04746338f, 0.26089150f, 0.09359506f, -0.04107807f, 0.17761540f, 0.13548434f, 
    0.06702584f, -0.11109950f, 0.14719112f, -0.02224769f, -0.05604617f, 0.23634429f, 0.28075308f, 0.21366775f, 
    -0.37950429f, -0.16878253f, -0.23603667f, -0.37878713f, -0.00737061f, -0.14457417f, -0.15404274f, -0.03617683f, 
    -0.08849893f, -0.04235523f, 0.04007114f, -0.04927912f, -0.12826037f, -0.03118453f, -0.16233620f, 0.02833423f, 
    -0.21559955f, 0.26067045f, 0.02191096f, 0.32113490f, -0.26756310f, 0.14364807f, -0.10254866f, 0.20296723f, 
    -0.00355910f, 0.06109345f, 0.02762739f, 0.04136809f, 0.01637934f, 0.12154125f, 0.05019009f, 0.04212302f, 
    0.17575888f, -0.09764044f, 0.07765888f, 0.27692586f, 0.20303744f, -0.30695182f, -0.27370667f, 0.48230582f, 
    -0.41451946f, 0.03402706f, 0.13617176f, -0.13344663f, 0.13467187f, -0.19746275f, 0.04254056f, 0.02550935f, 
    0.12841029f, 0.12708896f, 0.23472685f, -0.05335896f, 0.14356981f, 0.09323713f, -0.09179862f, 0.00490686f, 
    0.03539032f, 0.14075431f, -0.36421251f, -0.20304315f, 0.14308977f, 0.03095759f, 0.09252355f, 0.19344555f, 
    -0.00223007f, 0.05220684f, -0.12523983f, -0.03369148f, -0.03584933f, -0.02523041f, -0.08926142f, 0.07862382f, 
    -0.10595157f, 0.08140752f, -0.03838006f, -0.11522138f, -0.12897837f, -0.25101095f, -0.41416404f, 0.04013251f, 
    -0.13210522f, -0.18407097f, -0.06173071f, 0.15419741f, -0.07603425f, 0.11901805f, 0.02392348f, -0.05786779f, 
    -0.13418275f, -0.22388805f, 0.07566160f, -0.14963239f, 0.08527780f, 0.00823540f, 0.06930426f, -0.01929303f, 
    0.44623917f, 0.07279445f, -0.12612051f, -0.11736911f, 0.31450996f, -0.08572178f, 0.12767647f, 0.04414158f, 
    0.16831446f, -0.06397859f, -0.01631489f, 0.13864639f, 0.16850922f, 0.10157401f, 0.02127587f, 0.03804583f, 
    -0.05364433f, -0.07499482f, 0.03713324f, -0.07268479f, -0.28288528f, -0.13017589f, -0.05021477f, -0.30780473f, 
    -0.05607954f, -0.03833149f, 0.07023809f, 0.00222234f, -0.09122844f, 0.18075955f, -0.03859104f, 0.04128268f, 
    0.07222820f, 0.02459764f, -0.06985117f, -0.11726801f, 0.07552040f, -0.13061301f, -0.15052474f, -0.05281498f, 
    0.34148207f, -0.06252952f, 0.69364554f, 0.32063285f, 0.23273803f, -0.05077986f, -0.03151175f, -0.24249406f, 
    0.28702810f, -0.12234323f, -0.01543628f, 0.00973448f, 0.08671290f, 0.06416584f, 0.14178963f, -0.05988760f, 
    -0.06766733f, -0.17065799f, 0.12140635f, -0.15827103f, 0.25536317f, -0.11503725f, 0.06467374f, -0.03369851f, 
    -0.13786304f, -0.17352630f, 0.06890108f, -0.00566633f, 0.17599870f, -0.06437732f, -0.12532818f, 0.15462862f, 
    0.09035220f, -0.01725082f, 0.02966899f, -0.15151490f, -0.10503129f, 0.09023655f, 0.00750579f, -0.00656177f, 
    0.32004568f, 0.58830535f, 0.05396305f, -0.08661167f, 0.14174342f, 0.11573435f, 0.06075785f, 0.17091507f, 
    0.03527947f, -0.04643982f, -0.00247947f, -0.00016803f, -0.00547373f, 0.11223000f, 0.12503894f, 0.07330969f, 
    0.01483703f, 0.02525437f, 0.05673321f, -0.02044005f, 0.47865584f, 0.02942578f, 0.17602296f, -0.04767540f, 
    0.18566704f, 0.01572768f, 0.07161840f, 0.18977918f, 0.00935178f, 0.04139451f, 0.04474161f, -0.07945779f, 
    -0.09616626f, 0.04151015f, -0.11653698f, 0.05436774f, 0.01323072f, 0.09910408f, 0.03919730f, -0.02570815f, 
    0.10922884f, -0.07962280f, 0.03072682f, -0.18324400f, 0.15203086f, -0.09585979f, 0.03097943f, -0.16885985f, 
    -0.32396728f, 0.10266525f, 0.10402584f, -0.01549936f, 0.12531041f, 0.18540531f, 0.01882990f, 0.15394384f, 
    0.05248237f, 0.07192488f, 0.00743950f, -0.06138459f, -0.04408292f, 0.16452557f, -0.10532403f, 0.12888920f, 
    0.07472233f, 0.14234462f, 0.02134825f, 0.10563339f, 0.08513862f, -0.09212414f, 0.11365444f, -0.01582201f, 
    0.00106070f, 0.08883993f, -0.09716246f, -0.02362606f, 0.11834995f, -0.06429267f, 0.10410706f, 0.08839413f, 
    0.14343958f, 0.10449465f, -0.09802672f, -0.22791274f, -0.06611057f, 0.13103239f, -0.01083023f, 0.08374953f, 
    -0.05892857f, -0.17820653f, 0.10425483f, -0.07511195f, -0.06977098f, -0.02903523f, -0.10285354f, -0.13848551f, 
    -0.12073353f, 0.22830379f, 0.01241664f, -0.13205476f, -0.40950340f, 0.13067383f, -0.23606101f, -0.10047530f, 
    0.01182771f, 0.21702595f, 0.17732638f, 0.09952573f, 0.00910821f, -0.13697460f, 0.12332451f, 0.22730978f, 
    0.00728382f, 0.15855315f, -0.13217893f, -0.04343547f, 0.16435103f, -0.14264616f, 0.09700741f, 0.14516103f, 
    0.27402478f, 0.12091178f, -0.15227552f, 0.19660582f, 0.03938254f, 0.01907218f, -0.11676688f, 0.21517853f, 
    -0.13760652f, -0.10956266f, -0.00270609f, 0.24074224f, 0.06406479f, -0.10966776f, 0.01159848f, 0.13211766f, 
    0.25258651f, 0.10591457f, -0.17992820f, 0.05618140f, 0.36278567f, 0.26052055f, 0.08367451f, 0.09500632f, 
    0.10262925f, -0.08200128f, -0.04816636f, -0.01968256f, -0.04995862f, -0.16365130f, -0.03473597f, -0.03293285f, 
    0.01677302f, 0.13718830f, -0.01435622f, 0.02577673f, -0.02189224f, 0.05744444f, -0.08138825f, -0.06139676f, 
    -0.10173891f, 0.05614513f, 0.01491549f, -0.20575574f, 0.04040213f, -0.20633110f, -0.10290978f, 0.02872551f, 
    -0.08433201f, -0.22363047f, 0.18670824f, 0.06342360f, 0.11924424f, 0.11178385f, 0.00837848f, -0.02562827f, 
    0.15664646f, 0.04990367f, -0.16241083f, -0.25131732f, 0.09377187f, -0.11626375f, -0.04470106f, 0.31880391f, 
    -0.05181813f, -0.03772742f, -0.00226248f, -0.07711250f, -0.07204609f, -0.16329396f, 0.15196460f, 0.12742354f, 
    0.01478092f, 0.25902829f, -0.04729227f, -0.16509718f, -0.08415980f, 0.09684375f, -0.18105954f, -0.09588907f, 
    0.53675330f, 0.10482229f, -0.28623354f, -0.17939208f, -0.20275775f, 0.17282054f, -0.01743523f, 0.07340366f, 
    0.09371936f, 0.14356436f, 0.13574605f, -0.07536063f, -0.01768898f, 0.04172516f, 0.14649972f, 0.11643526f, 
    -0.02762239f, -0.01642840f, 0.16106808f, 0.12807219f, -0.16767016f, -0.02454684f, 0.10567586f, 0.00171805f, 
    -0.08617669f, -0.05070069f, -0.04416605f, -0.07298336f, 0.03252495f, -0.19115655f, 0.17476118f, 0.02578966f, 
    -0.04374647f, 0.00921498f, -0.02130030f, -0.28243798f, -0.16233616f, 0.07214557f, 0.02390669f, -0.24801916f, 
    -0.01793547f, 0.02878560f, -0.09046459f, -0.13029990f, -0.01085808f, 0.07165445f, 0.02243158f, 0.10657670f, 
    -0.04977293f, -0.04523785f, 0.04470699f, 0.05119471f, 0.14579533f, 0.01749357f, 0.16318494f, 0.12597518f, 
    0.16328654f, -0.06376481f, 0.01909551f, 0.14349174f, -0.20282069f, 0.11686579f, -0.08061136f, -0.19660957f, 
    0.01612911f, 0.02535816f, 0.02695214f, 0.11054256f, 0.09327201f, -0.00581112f, -0.09084190f, -0.05488034f, 
    0.11467280f, 0.04217622f, 0.10011498f, 0.01941395f, 0.14117076f, -0.03288732f, -0.06189219f, -0.11240643f, 
    -0.03576097f, 0.09525674f, 0.56823921f, 0.10316381f, 0.01002526f, 0.02525343f, -0.12132385f, -0.13905568f, 
    0.12124614f, 0.00417245f, 0.08925644f, -0.04499776f, 0.17826648f, 0.00519083f, -0.16995199f, 0.02094797f, 
    0.07123608f, 0.11661790f, 0.33428031f, 0.11849105f, -0.00627934f, 0.14340197f, -0.07609224f, -0.11347494f, 
    0.06519599f, -0.06880276f, -0.28038684f, -0.20692641f, 0.17032504f, -0.11414766f, 0.11031779f, 0.25780073f, 
    0.17930388f, -0.04864198f, 0.07843569f, -0.00625174f, -0.13695665f, -0.17152287f, 0.12502782f, -0.13020004f, 
    0.25277111f, 0.36743844f, -0.23381394f, -0.39601332f, -0.07809974f, 0.01510010f, 0.17197761f, -0.06711684f, 
    0.23240963f, 0.31311396f, 0.03675863f, 0.07395899f, 0.11721425f, 0.02708521f, -0.03370660f, 0.04277397f, 
    0.13463423f, 0.16155641f, 0.22233315f, -0.06069002f, 0.17147915f, 0.09473512f, -0.03077326f, -0.31861684f, 
    0.12210845f, 0.12224954f, 0.05906870f, -0.09998363f, -0.25981987f, -0.08144721f, 0.09468191f, -0.08515565f, 
    0.04170431f, -0.03916462f, -0.11600067f, -0.02520115f, 0.00017635f, 0.18021315f, 0.03030164f, -0.08508353f, 
    -0.02406765f, 0.03209787f, 0.00722934f, -0.06102162f, -0.02527433f, -0.03932863f, 0.00354400f, -0.07044674f, 
    0.01170382f, -0.03062530f, -0.01882379f, -0.04930213f, -0.07489986f, -0.09142005f, -0.07157560f, 0.00960309f, 
    0.01980256f, 0.01330197f, -0.01738219f, 0.01012433f, -0.02463023f, -0.01408898f, -0.05168508f, -0.00554217f, 
    0.03958363f, -0.04446327f, 0.02461460f, -0.00821354f, -0.06784993f, 0.03492219f, -0.07509917f, -0.00904931f, 
    -0.05358484f, -0.03374732f, -0.02816808f, 0.00522494f, -0.01775103f, -0.02493655f, -0.02593836f, -0.06375422f, 
    -0.02620311f, -0.04016191f, 0.04573620f, 0.01641170f, 0.02440293f, -0.04260642f, -0.02226697f, 0.01596637f, 
    0.00991922f, -0.06154901f, -0.01142294f, 0.04367432f, 0.00820737f, -0.04122718f, 0.04001707f, 0.01750010f, 
    0.03671123f, -0.01450753f, 0.01789169f, -0.07545675f, -0.05187008f, -0.00854981f, -0.07180415f, 0.06027830f, 
    0.00469585f, -0.00383359f, 0.01115274f, -0.03689012f, -0.03141255f, -0.00657895f, -0.05675989f, 0.03638819f, 
    -0.01435475f, -0.05773337f, -0.06184801f, 0.00006591f, -0.06435054f, -0.01952581f, -0.05913081f, -0.06484895f, 
    0.00614022f, -0.02559708f, 0.00096514f, 0.01882960f, 0.03435227f, -0.04664436f, -0.03993728f, -0.01683189f, 
    -0.05501725f, 0.01751227f, -0.03800319f, -0.00292579f, -0.00174468f, 0.08530975f, -0.05974178f, -0.05372647f, 
    -0.00316933f, -0.05233825f, -0.00166097f, -0.01435114f, 0.02766114f, -0.03607970f, 0.03525301f, 0.04900750f, 
    -0.04032297f, 0.02880835f, -0.01070349f, -0.04143529f, 0.01131640f, -0.02393597f, -0.08358162f, -0.08582467f, 
    -0.01371409f, -0.01898821f, -0.08840386f, 0.06154792f, -0.06471092f, 0.00597674f, -0.01477206f, -0.02774091f, 
    0.03461979f, 0.02421319f, -0.00061339f, 0.03455646f, -0.02520300f, 0.01006376f, 0.02681062f, -0.03611981f, 
    -0.05208156f, -0.06659307f, -0.02394551f, -0.04503852f, -0.00742919f, -0.00668088f, 0.05524202f, -0.04663872f, 
    -0.04981373f, -0.07745733f, -0.02879329f, -0.02178971f, -0.00033354f, -0.05103573f, 0.00032624f, -0.09302212f, 
    -0.00665462f, -0.02027912f, -0.06847428f, -0.03815488f, 0.01679859f, -0.06944889f, -0.01420894f, 0.01106030f, 
    -0.01920974f, -0.05092588f, -0.05327586f, -0.03739323f, -0.02085128f, -0.07313509f, 0.00124652f, -0.01226054f, 
    0.01817072f, 0.00863842f, 0.04758523f, -0.03763486f, 0.02473707f, 0.05173816f, 0.00764509f, 0.02364341f, 
    -0.04404684f, 0.00916142f, -0.02036361f, 0.03117014f, -0.01180750f, 0.04128122f, -0.01459295f, -0.00867782f, 
    0.04802641f, 0.04026806f, -0.04456120f, -0.06169397f, -0.04711240f, -0.01499905f, 0.02612331f, 0.02715301f, 
    0.04823635f, -0.02390288f, 0.00324629f, 0.00639620f, -0.03331774f, -0.05483690f, 0.07735673f, -0.00759393f, 
    0.04540185f, 0.03130218f, 0.03966348f, 0.00138119f, 0.00816631f, -0.06673511f, -0.06036064f, -0.01534272f, 
    0.01895404f, -0.03989020f, -0.04050523f, -0.07882069f, 0.02818282f, -0.03330342f, -0.01794282f, -0.05198529f, 
    0.01892892f, -0.08285049f, -0.01969669f, -0.03119526f, -0.05500997f, -0.03182809f, -0.02521094f, -0.04354079f, 
    0.02552089f, -0.06148050f, -0.07155906f, -0.06710988f, -0.00265627f, 0.00800248f, -0.05677808f, 0.04368477f, 
    -0.00625353f, 0.00134308f, -0.08029355f, 0.04047986f, -0.05210405f, -0.04540829f, -0.03608046f, -0.06410796f, 
    -0.02743830f, 0.04904761f, 0.00861417f, 0.01017399f, -0.03365887f, -0.06810684f, -0.06002590f, 0.02802440f, 
    -0.00848553f, -0.01797446f, -0.05395037f, -0.04175894f, -0.00625485f, 0.02674410f, 0.02361976f, -0.01826259f, 
    0.00543122f, 0.01455259f, -0.00458520f, 0.02409406f, -0.03341884f, -0.06532368f, -0.00591019f, -0.05126341f, 
    0.03475465f, -0.05668018f, -0.04195351f, -0.06346791f, 0.04115395f, 0.03799516f, -0.04123329f, -0.00188817f, 
    -0.01324135f, -0.07370596f, -0.01602232f, 0.00622273f, 0.01128398f, -0.02869380f, 0.01046860f, -0.13956098f, 
    0.02729387f, -0.01087178f, -0.06175112f, -0.08192696f, -0.02844523f, -0.05491628f, -0.05330209f, 0.03181250f, 
    0.00995660f, -0.04846621f, -0.00820744f, 0.02498140f, -0.00383085f, -0.03415759f, -0.01082266f, -0.02491887f, 
    0.01355617f, -0.01523153f, 0.02148840f, -0.03863272f, -0.04975463f, -0.05425512f, 0.03176440f, -0.07560667f, 
    0.05212653f, -0.04234843f, -0.04942640f, -0.07079458f, -0.00049262f, 0.03446314f, -0.04010952f, -0.03303880f, 
    -0.08430532f, 0.02591208f, -0.00735867f, -0.00926531f, 0.02322784f, 0.00609531f, -0.07455158f, 0.01901145f, 
    0.00403783f, -0.04578845f, -0.06785469f, 0.01536879f, 0.01838669f, -0.02143499f, -0.00010668f, -0.10345316f, 
    0.26819339f, -0.01977886f, 0.12663071f, 0.08459201f, 0.26646227f, -0.23166595f, -0.10252139f, -0.33958754f, 
    0.03266563f, 0.08741952f, 0.00995084f, 0.00044162f, 0.11308615f, -0.01433235f, -0.08392172f, -0.14285809f, 
    0.05191369f, -0.23033744f, 0.08543646f, -0.07656006f, 0.19186294f, -0.11102533f, -0.01945220f, 0.28515282f, 
    0.12169708f, -0.08411209f, 0.06286875f, -0.00875833f, 0.15521930f, 0.04087785f, 0.04689323f, 0.02454439f, 
    0.15163700f, -0.03177736f, -0.06584409f, 0.03190510f, 0.01351616f, -0.12437946f, 0.07171207f, 0.07866411f, 
    0.02476248f, -0.51952660f, -0.48771971f, -0.01652093f, -0.35533455f, -0.19595197f, 0.02627482f, -0.04442261f, 
    -0.08755550f, -0.00380132f, 0.02757593f, -0.04120180f, 0.02136108f, 0.02554608f, -0.04219425f, 0.02231842f, 
    0.01882615f, 0.13996749f, 0.16891651f, 0.01311904f, 0.38448545f, 0.53652853f, -0.56516993f, 0.06341074f, 
    -0.44110513f, -0.05413907f, 0.07928964f, -0.00681493f, -0.03735102f, 0.16381697f, -0.03101803f, 0.10082306f, 
    0.13333446f, -0.03061801f, -0.13708691f, 0.08164342f, -0.16150969f, 0.03399697f, -0.16201860f, -0.09789832f, 
    0.14331269f, -0.08560891f, 0.33222204f, 0.02776304f, 0.17915547f, -0.05717266f, 0.02055281f, 0.22340015f, 
    -0.31446171f, 0.08052935f, 0.09997936f, 0.16483144f, -0.05839740f, 0.09944600f, -0.00688740f, 0.01764669f, 
    -0.00322437f, -0.06321377f, -0.07348167f, -0.07074685f, -0.07584077f, 0.17630170f, 0.04455911f, -0.02346001f, 
    -0.03058453f, -0.02801444f, -0.12616546f, -0.11037045f, -0.09887727f, 0.00124354f, 0.22150308f, 0.05009297f, 
    0.03331238f, 0.13670498f, 0.00879522f, -0.02561868f, -0.06454711f, 0.02423837f, 0.06879856f, 0.00693231f, 
    0.17727064f, -0.02817482f, 0.16894928f, -0.25162154f, 0.11567272f, -0.09685437f, 0.06661145f, -0.19647954f, 
    0.03234746f, -0.08795086f, 0.27319536f, -0.12411074f, -0.07820660f, -0.07411664f, 0.14675108f, 0.04371279f, 
    0.09094650f, -0.07327013f, -0.09928399f, -0.13242809f, -0.03574217f, -0.04554686f, -0.37078726f, 0.00261431f, 
    -0.01229311f, 0.11086451f, -0.12961955f, 0.06574026f, -0.00476928f, 0.10438113f, 0.26360476f, -0.04670392f, 
    0.25569090f, 0.05988950f, -0.14761016f, 0.06295967f, 0.10595974f, -0.04960060f, 0.10768674f, 0.15621655f, 
    0.41561770f, -0.57678974f, -0.09249804f, -0.04888622f, -0.23770581f, -0.23326124f, -0.06738461f, 0.00111055f, 
    0.44087920f, 0.08537805f, 0.06416171f, 0.00667496f, -0.02161347f, 0.00987139f, -0.04112549f, 0.00097531f, 
    -0.07784825f, -0.10425245f, 0.04020900f, -0.08268018f, 0.16217318f, -0.06512035f, 0.06419253f, -0.05763357f, 
    0.02494369f, 0.06086997f, 0.05151470f, -0.10376976f, -0.01393757f, -0.09510241f, 0.04379459f, 0.07911064f, 
    0.15041859f, 0.09980404f, 0.07000628f, -0.00915441f, 0.01392599f, 0.01946478f, 0.11908395f, 0.09228927f, 
    0.20987898f, -0.08553934f, -0.11090335f, 0.14300211f, 0.04731617f, -0.04348806f, -0.00231123f, 0.12218133f, 
    0.18284914f, 0.00302626f, 0.02198939f, 0.05656089f, -0.01900817f, 0.04497722f, 0.02904705f, 0.10335343f, 
    -0.00645432f, -0.21464923f, 0.03875040f, -0.01738243f, 0.31486762f, -0.04742301f, 0.06848594f, -0.05579693f, 
    0.01098141f, -0.17277959f, -0.06849299f, -0.01277487f, 0.09801965f, 0.09067757f, 0.21769001f, 0.05466658f, 
    0.02951697f, 0.11951555f, 0.20668805f, 0.01929508f, 0.08571214f, -0.13135283f, 0.07259499f, -0.06186152f, 
    -0.82143033f, 0.39319566f, 0.14494409f, 0.20725356f, -0.15917692f, -0.08141198f, 0.06287797f, 0.09352207f, 
    -0.09427691f, 0.06083880f, 0.06624462f, 0.06538467f, 0.06910560f, -0.01368960f, 0.12950402f, 0.07796671f, 
    0.14871494f, 0.00663701f, -0.07447039f, 0.11212153f, 0.02413802f, 0.24240731f, 0.02417291f, -0.10098089f, 
    -0.09635899f, 0.04320089f, -0.14098378f, 0.05231691f, -0.03886577f, -0.07503160f, 0.06095603f, -0.04177945f, 
    -0.09746014f, -0.08895145f, -0.05440504f, 0.08868387f, -0.04144902f, -0.02380899f, 0.10211975f, 0.07704529f, 
    0.26364776f, 0.02316733f, -0.19247706f, -0.10788763f, -0.12412032f, -0.28341022f, -0.00808410f, -0.13905492f, 
    0.35497898f, 0.16972066f, 0.06357878f, -0.00700364f, 0.00198293f, 0.02375386f, -0.14486487f, 0.12890941f, 
    -0.02598749f, 0.10705721f, -0.07402255f, -0.15698844f, 0.10796792f, 0.07527554f, -0.72502190f, 0.25793558f, 
    0.00095584f, 0.21650819f, -0.06994785f, -0.18486553f, 0.12833357f, 0.07247563f, 0.11120697f, 0.02991240f, 
    0.04172117f, 0.09432680f, 0.07116511f, -0.03873144f, 0.03934649f, 0.17576139f, 0.16101551f, -0.02321182f, 
    -0.11700492f, 0.01392997f, -0.08826126f, -0.09421857f, -0.05843386f, -0.04142608f, -0.09206140f, 0.07196701f, 
    0.15467530f, 0.09126480f, 0.00898366f, -0.00029875f, -0.16329847f, -0.11844410f, -0.04360754f, 0.24243699f, 
    0.13205899f, -0.09965083f, 0.13338782f, 0.36674660f, 0.11658602f, 0.00068304f, 0.30681109f, -0.01154635f, 
    -0.01465184f, 0.06213876f, 0.05600803f, 0.03942169f, 0.05409731f, 0.13463306f, 0.17524275f, 0.06149431f, 
    0.13381849f, 0.05009886f, 0.06416799f, -0.03872855f, 0.11304341f, 0.04916481f, -0.05789283f, -0.00457287f, 
    0.32313293f, 0.57564563f, 0.41617918f, 0.34017918f, 0.26844698f, -0.00948969f, -0.12529773f, 0.10858387f, 
    0.09572622f, 0.28151286f, -0.00033090f, 0.03674924f, -0.02629862f, -0.07788987f, -0.00059775f, -0.11650231f, 
    -0.15912651f, -0.07235047f, 0.01667001f, -0.00352360f, -0.32253826f, -0.25140435f, 0.03035193f, 0.04787910f, 
    -0.12695025f, 0.14951280f, -0.02558650f, -0.02496854f, -0.05910248f, 0.01470040f, 0.10507064f, -0.14544901f, 
    -0.06052718f, -0.16119725f, -0.00824266f, 0.01538109f, -0.06407268f, 0.02651341f, -0.16726987f, -0.07454967f, 
    -0.04325431f, -0.13244779f, 0.21290512f, -0.24819502f, -0.27002388f, 0.04284158f, -0.05474849f, -0.21943901f, 
    0.05451786f, -0.02267072f, 0.03090056f, -0.10950790f, -0.05836131f, 0.17871603f, -0.06384812f, -0.04348335f, 
    0.03744607f, -0.04944500f, 0.05176881f, -0.03998619f, -0.37625316f, -0.44776502f, -0.39515918f, -0.28109279f, 
    -0.03733125f, 0.17152587f, 0.22409731f, 0.23853661f, 0.01663951f, 0.03812747f, 0.06561527f, 0.21303967f, 
    0.07818449f, 0.09311861f, 0.02908475f, 0.02151183f, 0.04368037f, -0.01682639f, -0.03820448f, -0.11162857f, 
    -0.07932781f, -0.29304850f, -0.16548020f, -0.18491270f, 0.04468890f, -0.05600201f, 0.13473889f, -0.03864388f, 
    -0.04479317f, 0.02515762f, -0.07857472f, 0.09784270f, 0.07462149f, -0.00041801f, -0.09116267f, -0.09625538f, 
    -0.16026238f, -0.02316816f, -0.10223033f, -0.20387009f, -0.06885367f, 0.17332964f, 0.33979541f, -0.45306057f, 
    0.12157387f, 0.10732211f, -0.02126890f, 0.19451264f, -0.04766067f, 0.06763412f, -0.02662941f, 0.13210164f, 
    -0.01382866f, -0.17536007f, -0.03295284f, 0.14677869f, -0.08566037f, -0.09860825f, 0.01169463f, -0.10259944f, 
    0.10695233f, 0.16922405f, 0.42692831f, 0.34399077f, 0.24356815f, 0.21596421f, 0.21454531f, -0.05445531f, 
    -0.19464637f, 0.07810346f, -0.04918784f, 0.03320879f, 0.01681867f, 0.16086216f, 0.21558958f, -0.02988829f, 
    0.23306744f, 0.06537008f, -0.07220384f, 0.12811282f, 0.11090909f, 0.09293087f, 0.06078351f, 0.05462632f, 
    0.11759433f, 0.02351322f, 0.09745523f, -0.07119504f, -0.06465203f, 0.09494042f, -0.05994092f, 0.07401393f, 
    0.15729472f, 0.01245127f, -0.04309421f, 0.18501256f, -0.06704228f, -0.05675697f, -0.10243734f, -0.03401993f, 
    0.01387933f, 0.08165929f, 0.33468378f, 0.29615849f, -0.05986683f, 0.21684252f, 0.16703244f, 0.04036383f, 
    0.03653174f, 0.11877467f, 0.10746624f, -0.07023001f, -0.02806453f, 0.03683456f, 0.15556484f, -0.02139707f, 
    0.08547388f, 0.23417601f, 0.03487191f, 0.13574378f, 0.31458783f, 0.26254797f, 0.24383765f, 0.49473491f, 
    0.30177027f, 0.17161837f, 0.04881628f, 0.00165350f, -0.08970298f, 0.09335912f, 0.04462895f, 0.11229745f, 
    -0.02546390f, 0.06931636f, 0.04767153f, 0.07870787f, -0.10051191f, 0.08026550f, 0.05963366f, 0.10911366f, 
    -0.04578969f, 0.05885935f, -0.53513950f, -0.24181265f, -0.15574539f, 0.01636821f, -0.05068797f, -0.05751839f, 
    -0.05559400f, 0.06643485f, 0.01127506f, 0.04378962f, -0.06322602f, -0.10681494f, -0.01849421f, 0.07511597f, 
    0.17235869f, 0.20101105f, 0.03629100f, 0.31776842f, -0.29929367f, -0.09814081f, -0.11262485f, -0.01683654f, 
    -0.01628319f, 0.06134653f, 0.03943092f, -0.06255446f, -0.10509694f, 0.10912602f, 0.05824526f, -0.07399784f, 
    0.03670555f, -0.02874694f, 0.08887306f, 0.10272314f, 0.11067173f, -0.02687070f, -0.08297158f, -0.04833383f, 
    0.10794930f, -0.11787002f, 0.09046625f, 0.24391867f, 0.09893976f, 0.02570833f, -0.06688610f, 0.12731585f, 
    -0.16615976f, 0.08706383f, 0.04384570f, 0.08695264f, -0.03654234f, -0.02904633f, -0.06919467f, 0.05824554f, 
    0.08817287f, 0.07796376f, 0.00579864f, 0.33091879f, -0.14459510f, 0.11671892f, 0.25016201f, 0.04684319f, 
    -0.05438478f, -0.02127972f, 0.03129944f, 0.05716151f, -0.02253617f, 0.08662124f, -0.05345022f, -0.07065155f, 
    -0.01148893f, -0.00206199f, 0.09142703f, 0.01327054f, 0.14911379f, 0.00110220f, 0.07246999f, 0.23595847f, 
    -0.01497989f, -0.00312807f, -0.05045374f, -0.00194314f, 0.00012418f, 0.03306660f, -0.00945819f, 0.01880032f, 
    -0.03413645f, 0.03874034f, 0.02768115f, 0.00787389f, 0.04572263f, -0.03880108f, 0.01400441f, -0.04686765f, 
    -0.04946600f, -0.04057062f, -0.00929370f, -0.01939518f, -0.02773350f, -0.00563681f, -0.01434533f, 0.02999290f, 
    -0.06141956f, -0.04931492f, -0.03951949f, -0.02858715f, -0.04693384f, 0.04824086f, 0.00332580f, -0.01752656f, 
    0.02663696f, -0.03138547f, 0.03693029f, 0.00708870f, 0.00290662f, 0.01108098f, -0.04351011f, 0.04438624f, 
    0.04114677f, 0.00171279f, 0.00495093f, 0.02788450f, 0.01221430f, -0.05501529f, -0.05165645f, -0.04283002f, 
    -0.03551685f, -0.04728159f, -0.04009727f, -0.04484526f, 0.04173924f, 0.02662769f, -0.05408223f, -0.05249823f, 
    0.04544426f, -0.05951101f, 0.00280733f, 0.00083507f, -0.01705517f, 0.01186547f, -0.00185951f, -0.04240793f, 
    -0.02803458f, -0.01076740f, 0.01921463f, -0.03354524f, -0.04722381f, 0.00844545f, -0.00403064f, -0.01961902f, 
    0.01426987f, -0.00006105f, 0.00148311f, -0.05547465f, -0.04372578f, -0.02783624f, -0.00581658f, -0.02499810f, 
    0.01617414f, 0.02869018f, -0.00761627f, -0.04996257f, -0.02936873f, 0.01059700f, -0.03216183f, 0.00985275f, 
    0.02921853f, -0.04388222f, 0.03623590f, -0.02376842f, 0.01022019f, -0.01817990f, -0.02881637f, -0.02917651f, 
    -0.02914646f, 0.01965414f, -0.01750576f, 0.04068536f, -0.02067254f, -0.02606111f, 0.04657328f, -0.04898982f, 
    -0.02890026f, -0.02629327f, -0.02895992f, -0.05813789f, 0.04028454f, -0.02921943f, 0.01576304f, 0.00967661f, 
    -0.02343439f, 0.00754024f, 0.04675896f, -0.02035388f, 0.03719033f, -0.03226143f, 0.01778464f, 0.02208195f, 
    0.02681693f, -0.00790633f, -0.04415318f, -0.04159177f, 0.00829526f, 0.04720148f, -0.02979255f, 0.03450336f, 
    -0.05994259f, 0.00513365f, -0.01936776f, -0.01922589f, -0.01831443f, 0.03191435f, 0.04663648f, 0.04752952f, 
    0.03312568f, 0.01577790f, 0.04439148f, 0.03441046f, -0.02397733f, -0.00648471f, 0.02356913f, 0.03823976f, 
    -0.00280305f, -0.02396017f, 0.03581269f, 0.02244070f, -0.02434644f, 0.01914235f, -0.01541511f, -0.03609412f, 
    -0.04538098f, -0.03941664f, 0.03528922f, -0.00202627f, 0.02351698f, 0.03283132f, 0.03487220f, -0.00062536f, 
    0.01078959f, -0.02703842f, 0.02620844f, 0.02774410f, 0.01202392f, -0.03994649f, 0.01255112f, 0.02507228f, 
    0.01726644f, -0.05241669f, -0.00642380f, -0.01388132f, -0.01876995f, 0.03990988f, -0.03938504f, -0.05445664f, 
    0.01614824f, -0.05949773f, -0.01275188f, 0.02255298f, 0.01507067f, 0.03357134f, 0.04378044f, 0.01477876f, 
    0.03728994f, 0.01874474f, 0.04561142f, -0.00663045f, 0.01128178f, 0.01101466f, 0.02848011f, -0.06102114f, 
    -0.04095919f, -0.00237928f, 0.02445684f, -0.04394099f, 0.04202855f, 0.00166542f, -0.02767577f, -0.05679831f, 
    0.04086442f, 0.02022696f, 0.02828596f, -0.00154630f, -0.02350621f, -0.04928206f, -0.05940653f, -0.06189320f, 
    -0.01689001f, 0.00768421f, -0.01248624f, -0.05542358f, -0.05228890f, -0.02802379f, -0.04041748f, -0.03979957f, 
    0.02141269f, -0.03088514f, -0.01711097f, -0.03025711f, -0.05244318f, -0.02316332f, -0.00509926f, -0.04907490f, 
    -0.05396599f, 0.02071098f, -0.01751382f, -0.06177487f, 0.02211568f, 0.00627074f, -0.00754528f, -0.02933096f, 
    -0.04705190f, 0.03221640f, -0.03463265f, 0.00470535f, -0.02003844f, -0.03458619f, -0.04601431f, -0.03679336f, 
    -0.02976400f, 0.03797648f, -0.05139120f, 0.04399845f, 0.01325441f, 0.06054835f, -0.04652512f, -0.03867522f, 
    -0.01442413f, -0.00705953f, 0.03324039f, 0.04343558f, 0.00956015f, -0.01353696f, -0.00996864f, 0.02340925f, 
    -0.00958682f, -0.04573969f, 0.01791269f, 0.02724049f, 0.01571469f, -0.01699031f, -0.02180612f, -0.00283578f, 
    0.04403475f, -0.04011737f, -0.05016373f, -0.03940200f, -0.01830733f, -0.05022158f, -0.00840542f, -0.04428317f, 
    -0.00127673f, 0.00887070f, 0.00017885f, -0.04900653f, -0.04859023f, 0.03152639f, -0.04603826f, 0.01960058f, 
    -0.01871268f, -0.05136776f, 0.00765900f, -0.02687884f, 0.03966991f, -0.01447015f, -0.02179435f, 0.02184852f, 
    -0.04689100f, -0.05372449f, -0.00347687f, -0.04679196f, 0.03489024f, 0.05729260f, 0.03514757f, -0.04127533f, 
    -0.02622295f, -0.02406818f, 0.02713762f, -0.00652939f, -0.01334642f, 0.00232387f, 0.00162851f, -0.04949078f, 
    -0.04235724f, 0.02565103f, 0.02187589f, -0.03403807f, 0.01631398f, 0.04775906f, 0.04161371f, 0.03597067f, 
    0.00773144f, 0.02618854f, 0.04417973f, 0.03531122f, -0.04736259f, 0.01395724f, -0.02144046f, 0.03843618f, 
    -0.24774179f, -0.03429783f, -0.09126606f, -0.44942120f, 0.18216290f, 0.00656259f, -0.07624746f, -0.01508267f, 
    0.02658983f, 0.02666733f, 0.03791909f, 0.00366065f, 0.00223537f, -0.01085414f, -0.05111734f, 0.12395616f, 
    -0.06493542f, 0.05935739f, -0.18781501f, -0.13459566f, 0.14548180f, -0.08578400f, 0.19945174f, 0.09934890f, 
    -0.03975337f, 0.19916426f, 0.02105477f, 0.07007455f, 0.12487612f, 0.01112321f, 0.09646179f, -0.04032651f, 
    0.01739385f, -0.05756689f, -0.18479945f, 0.06604522f, -0.00377774f, -0.14462025f, -0.00489823f, -0.07405900f, 
    0.08362974f, 0.47160673f, -0.14921439f, -0.03444928f, 0.27619940f, 0.05964402f, 0.03319277f, -0.04641965f, 
    0.03271947f, 0.04510566f, -0.15019712f, -0.04492712f, 0.03189694f, 0.07959123f, 0.05693616f, -0.06321749f, 
    -0.10801490f, -0.11831279f, -0.03460742f, 0.15670718f, 0.13383918f, -0.23791622f, 0.40394753f, -0.34595498f, 
    0.42478609f, -0.03183916f, 0.06515291f, -0.02896250f, -0.01053361f, -0.04731551f, -0.04818884f, 0.11357014f, 
    -0.01816617f, -0.05680066f, 0.01442942f, -0.03094358f, 0.04455201f, -0.03642570f, -0.07972505f, -0.06344035f, 
    0.35859704f, 0.59381199f, -0.43720457f, 0.59486479f, -0.19346260f, 0.07614688f, -0.10344604f, -0.13947502f, 
    0.11980979f, -0.00709645f, 0.09016991f, -0.07893600f, -0.09873152f, 0.02270663f, -0.06498712f, -0.01344370f, 
    0.13303284f, 0.06329770f, 0.07807137f, -0.05931025f, -0.07625943f, -0.16114724f, -0.22617078f, -0.12896226f, 
    -0.26086590f, -0.14941090f, 0.00789310f, -0.06743302f, 0.04351758f, -0.13338172f, -0.07313886f, 0.21546702f, 
    0.04014469f, -0.11546744f, -0.01446315f, -0.09697514f, -0.00783216f, 0.05308442f, 0.13339575f, -0.06008426f, 
    -0.26948366f, 0.31909290f, -0.04543581f, 0.14932320f, -0.05822337f, -0.13592398f, 0.00147040f, 0.17209271f, 
    0.18286543f, -0.11823909f, -0.16184005f, 0.15010624f, 0.16919057f, -0.06513149f, -0.13912031f, -0.08360144f, 
    0.12921387f, 0.13158417f, 0.01659972f, 0.00422957f, -0.55876189f, -0.14617811f, 0.10709302f, -0.26870245f, 
    -0.14060763f, -0.01092120f, 0.12143818f, -0.00388474f, 0.03253704f, 0.04516978f, -0.13586517f, 0.18221800f, 
    0.01494196f, 0.23988807f, 0.07121506f, 0.04429244f, -0.06470758f, 0.04919128f, 0.21351418f, 0.22359970f, 
    0.46675351f, 0.34436285f, 0.29125229f, 0.06240271f, 0.09007570f, 0.31537515f, 0.07076126f, 0.12601689f, 
    -0.02008424f, 0.00981264f, 0.11486126f, 0.12730917f, -0.07799610f, -0.14277405f, 0.09762837f, 0.10251440f, 
    -0.07163496f, 0.01886928f, 0.02317722f, 0.05302262f, 0.04228329f, -0.11515657f, -0.32813609f, 0.07845829f, 
    -0.13689624f, 0.05762047f, 0.03311127f, 0.10134323f, 0.03362004f, -0.07963656f, -0.19118729f, 0.07869498f, 
    0.01798043f, -0.03055282f, -0.18286350f, -0.02462255f, 0.17804180f, 0.08426673f, 0.22116679f, 0.02202920f, 
    0.17337020f, 0.01488859f, 0.36061203f, 0.00405089f, -0.01732362f, 0.08242667f, 0.11407346f, 0.16229899f, 
    0.00076368f, -0.02240871f, -0.10058552f, -0.00041612f, -0.01385602f, -0.09778484f, -0.09706365f, 0.18018708f, 
    0.01693846f, -0.10039728f, -0.04133496f, 0.02226084f, -0.09012407f, -0.04499429f, -0.00630952f, -0.19317538f, 
    0.06343234f, 0.01360145f, 0.08347018f, 0.06011234f, -0.03024198f, -0.05719595f, -0.25291398f, 0.19056584f, 
    0.01744775f, 0.03859918f, 0.04702564f, 0.10773420f, -0.02971822f, 0.04582583f, -0.03866601f, -0.09511273f, 
    -0.21639386f, -0.23782547f, 0.41583803f, 0.00261689f, -0.21416339f, -0.01997918f, 0.07683002f, 0.16484694f, 
    -0.07782679f, 0.13031743f, 0.15270458f, 0.02126882f, 0.02508941f, 0.21297832f, -0.08419998f, -0.02689976f, 
    -0.21339363f, 0.06977762f, -0.08311614f, -0.03247458f, -0.16115852f, -0.34275794f, 0.01968520f, 0.07770858f, 
    -0.11151014f, -0.17487183f, 0.04593479f, 0.21778047f, -0.03600126f, -0.04726719f, -0.00716796f, -0.03058982f, 
    0.02787021f, 0.07108134f, 0.00728965f, -0.14533953f, -0.14326832f, -0.13665132f, -0.12676574f, -0.02012221f, 
    0.39293656f, 0.44364825f, 0.09700587f, -0.01173509f, 0.40153775f, 0.12030968f, -0.04616785f, -0.04108168f, 
    0.08930283f, -0.09283002f, 0.07889858f, 0.10164657f, 0.02974490f, -0.14196660f, 0.17961264f, -0.11743699f, 
    -0.11376514f, 0.01680677f, -0.01727897f, 0.01751407f, -0.20559657f, 0.30787042f, 0.12849593f, -0.24058063f, 
    0.32089630f, -0.18304472f, -0.08530395f, -0.00649436f, -0.06919730f, -0.04902570f, -0.21014990f, -0.01287283f, 
    -0.08598036f, -0.05138232f, -0.09601664f, 0.04994916f, -0.14089261f, -0.08045960f, -0.02709528f, -0.17097357f, 
    0.42151409f, -0.09947558f, 0.20127764f, 0.00135299f, -0.07974149f, -0.05882983f, 0.10163958f, -0.08476606f, 
    -0.08178584f, -0.03341912f, 0.03304518f, 0.05447035f, 0.06325968f, 0.07752675f, -0.00464442f, -0.05768235f, 
    -0.02034043f, -0.10805845f, 0.13119526f, -0.24469818f, -0.10754219f, 0.17021863f, -0.40154010f, 0.11109822f, 
    0.02288372f, 0.12445307f, 0.06244874f, -0.04321497f, -0.07449856f, 0.03157892f, -0.06376491f, 0.15496591f, 
    0.06192824f, 0.02794456f, 0.04080870f, 0.00319486f, 0.01005751f, 0.21623951f, 0.03608071f, 0.13269342f, 
    0.31941262f, 0.21194425f, 0.30288926f, 0.13393477f, -0.00139636f, 0.12729704f, 0.05899236f, 0.05536840f, 
    0.10751756f, -0.05445530f, -0.02609369f, -0.16855443f, -0.02743594f, -0.02387753f, 0.04220727f, -0.07483920f, 
    0.08703596f, 0.15689406f, -0.09589136f, 0.10923605f, -0.66352385f, 0.03156244f, -0.14119500f, 0.28843212f, 
    -0.11121507f, 0.17703174f, -0.12637390f, -0.10061353f, 0.30243415f, 0.12555568f, -0.04400507f, 0.06956351f, 
    0.02647049f, 0.04327526f, -0.04490102f, -0.04426193f, -0.02619950f, 0.01832593f, 0.04485961f, 0.35369411f, 
    0.21314454f, -0.56282502f, -0.31493551f, -0.07011224f, -0.03050632f, -0.07772332f, 0.06074218f, 0.08241586f, 
    -0.20425254f, 0.08573636f, 0.02858647f, 0.14884855f, 0.07397770f, -0.22733079f, 0.05763661f, 0.11089084f, 
    -0.11437482f, 0.16981614f, -0.06399026f, 0.14756778f, -0.44145653f, -0.59302413f, -0.69371825f, 0.12914048f, 
    0.09587631f, 0.05176606f, 0.15545826f, -0.06455652f, -0.11225030f, -0.06193370f, 0.07776454f, -0.17708224f, 
    -0.05150200f, 0.10934342f, 0.06186579f, -0.10594718f, -0.08072507f, 0.09093273f, -0.07888971f, -0.03667105f, 
    0.11520801f, -0.38632864f, -0.37680477f, -0.40742904f, 0.07405989f, -0.06825797f, -0.13624702f, -0.05352891f, 
    -0.23672552f, 0.04520161f, 0.19711560f, -0.03181721f, -0.11465083f, 0.10893553f, 0.12039412f, 0.12682529f, 
    -0.09296320f, 0.08804125f, -0.02663381f, 0.09114572f, 0.50190455f, -0.25243005f, -0.01008270f, 0.00695498f, 
    0.07881486f, -0.09603468f, 0.04829899f, -0.09601302f, -0.07582726f, -0.00060148f, -0.03029080f, 0.06741720f, 
    -0.03777618f, -0.09270957f, 0.03278163f, 0.02497981f, 0.08691147f, -0.01485198f, -0.18275927f, 0.17537627f, 
    0.29787791f, 0.32611150f, -0.06186500f, -0.10095108f, 0.03945433f, 0.12217671f, 0.05781280f, 0.13895120f, 
    0.05906490f, 0.11624031f, 0.08022210f, -0.02641844f, -0.10150575f, 0.11785620f, -0.02727013f, -0.06265069f, 
    -0.04264040f, -0.13414808f, 0.11545997f, -0.01686200f, -0.14819565f, 0.13267992f, -0.02819745f, -0.24117206f, 
    -0.00490714f, -0.05717221f, -0.07874242f, -0.07385127f, -0.00151229f, -0.02612843f, 0.02237474f, -0.16007890f, 
    0.06910343f, 0.02616634f, -0.08807950f, -0.00634479f, 0.11314855f, 0.14492477f, -0.13263956f, 0.09003012f, 
    -0.19861440f, 0.55869889f, -0.18740138f, 0.09733125f, 0.10976127f, -0.05841282f, 0.01125202f, 0.13355252f, 
    0.03064910f, 0.09220628f, 0.12399253f, -0.08345155f, -0.02436537f, 0.07322178f, 0.05061734f, -0.13406216f, 
    -0.02894736f, 0.02975809f, -0.09039658f, -0.21386597f, 0.00538215f, -0.02046332f, -0.44965908f, -0.06247886f, 
    -0.08981112f, 0.15995558f, 0.22433972f, 0.11013511f, 0.07898205f, -0.00170582f, 0.00040089f, -0.23344906f, 
    0.02756433f, 0.03511816f, -0.03646789f, 0.01295254f, 0.08451240f, -0.04044132f, 0.02944469f, -0.07401626f, 
    0.23489831f, 0.29679444f, -0.15902463f, 0.08124261f, 0.03607322f, -0.02960403f, -0.19804588f, -0.23175028f, 
    -0.14619525f, 0.09543885f, 0.11166157f, 0.02312694f, 0.16587627f, -0.00787162f, 0.07812501f, -0.11833595f, 
    -0.01190309f, -0.23230688f, 0.15843667f, 0.04107025f, -0.29688203f, 0.02385734f, -0.41030216f, -0.21734820f, 
    -0.04907679f, 0.24689114f, -0.15631178f, -0.17065863f, -0.12556501f, 0.08305676f, 0.00595432f, 0.11018371f, 
    0.10324936f, -0.07629686f, 0.04000100f, 0.07096875f, 0.12021319f, -0.01751128f, 0.02091533f, 0.10429938f, 
    -0.08167294f, 0.08662999f, 0.24398690f, -0.16318290f, -0.05452222f, -0.01697617f, 0.20160244f, -0.02207261f, 
    0.26374996f, 0.05134825f, -0.02354524f, -0.05051100f, -0.12833834f, 0.07646998f, -0.03302542f, -0.01919986f, 
    0.07646644f, -0.08868741f, 0.09010302f, -0.05983917f, 0.38063049f, 0.14079207f, 0.38726145f, -0.02698772f, 
    -0.19303551f, 0.28343388f, 0.20907584f, 0.02745469f, 0.08126298f, 0.09691148f, 0.11625873f, 0.05031352f, 
    -0.10535964f, -0.07119071f, 0.02424501f, -0.03154905f, -0.00804545f, -0.13861795f, -0.08028428f, -0.01863370f, 
    0.21311709f, -0.04824553f, 0.18770236f, -0.00560394f, 0.12990901f, 0.18046394f, -0.09242827f, 0.13823548f, 
    -0.07599299f, -0.02253716f, 0.00882093f, 0.08688289f, -0.09255110f, -0.05375949f, 0.07149237f, -0.03381832f, 
    -0.18646865f, 0.01725065f, -0.15674676f, -0.31492952f, 0.00956049f, -0.06584490f, -0.05256116f, 0.00835456f, 
    -0.05461409f, -0.01604924f, 0.04081509f, -0.00428820f, 0.10718098f, -0.09793460f, -0.02434561f, 0.00277177f, 
    0.02294201f, 0.03083615f, 0.04684589f, 0.03049101f, -0.03970276f, 0.00669081f, -0.03861571f, 0.02704198f, 
    -0.09899114f, 0.01728574f, -0.04631821f, -0.14808556f, -0.02502033f, -0.04925565f, 0.12349188f, -0.11684365f, 
    0.12146845f, -0.04158193f, 0.01251630f, 0.06663090f, 0.02664066f, -0.03193674f, 0.02993531f, 0.02447945f, 
    0.17730613f, 0.00420689f, 0.22948767f, 0.09555140f, 0.20039988f, -0.14631203f, 0.33154652f, 0.00018766f, 
    0.16997419f, -0.14147228f, 0.08508786f, 0.11195752f, -0.00292719f, -0.01856323f, -0.20438880f, 0.18009046f, 
    0.04687295f, 0.03608382f, 0.01081709f, 0.09973580f, 0.02184035f, 0.13074037f, 0.12215774f, -0.02282392f, 
    0.08102337f, -0.17198554f, -0.24201296f, 0.19380230f, -0.11423016f, 0.07484542f, 0.09474127f, -0.04473204f, 
    0.16365652f, 0.05353984f, 0.01609272f, 0.07924971f, 0.07370988f, 0.00465231f, 0.14514585f, -0.12591851f, 
    -0.00604893f, 0.01812831f, 0.11883261f, 0.01027177f, 0.00094286f, 0.06476315f, 0.11433447f, 0.08977218f, 
    -0.26751387f, -0.12923230f, -0.04291631f, -0.04101223f, 0.08832235f, -0.03487086f, -0.06942712f, -0.06260252f, 
    0.04103670f, 0.06674467f, 0.02409456f, -0.01208253f, 0.01268682f, -0.02847718f, 0.11129600f, 0.05929027f, 
    -0.05068643f, 0.09289365f, -0.03888818f, 0.29048908f, -0.09583256f, -0.16138206f, -0.07613325f, 0.05029812f, 
    0.21459195f, -0.02172721f, -0.05050568f, -0.06093434f, 0.07301753f, 0.13568270f, 0.02873466f, -0.05078471f, 
    -0.01622674f, 0.08951308f, 0.12949499f, 0.17935757f, 0.01260523f, 0.01852352f, 0.00620008f, 0.13065451f, 
    -0.04470371f, -0.00378861f, 0.02128159f, -0.22503346f, 0.19954993f, -0.13829648f, 0.00540910f, 0.00978384f, 
    0.06453222f, 0.07799746f, 0.05971242f, 0.05765534f, 0.24531636f, 0.06870342f, 0.30559415f, 0.14193457f, 
    0.05850099f, 0.14636676f, -0.27257532f, -0.28002444f, -0.23413879f, -0.05679459f, 0.02674892f, 0.06449796f, 
    0.19353594f, 0.08190595f, 0.04686705f, -0.05157077f, -0.02833850f, -0.24259405f, -0.09027404f, 0.02840385f, 
    -0.22951052f, -0.01623737f, -0.14551327f, -0.07015686f, -0.01612752f, -0.03957351f, -0.19534829f, 0.13893327f, 
    -0.06381036f, -0.08500123f, 0.11902013f, 0.22401741f, 0.16352648f, 0.01653349f, 0.01924179f, 0.06307383f, 
    -0.09360303f, -0.18562083f, 0.02523419f, -0.12230444f, 0.14799146f, 0.19598645f, 0.15225388f, 0.14466855f, 
    0.04016642f, 0.07758608f, 0.01267106f, -0.02142140f, 0.14541055f, -0.11461690f, 0.04045324f, 0.07224559f, 
    -0.06051605f, 0.02326845f, -0.08302046f, 0.00561768f, -0.10740085f, 0.07585771f, -0.02831432f, 0.05607837f, 
    -0.10239482f, -0.11920843f, -0.13763267f, -0.10698528f, 0.00550905f, -0.24506956f, -0.12492052f, -0.04644475f, 
    -0.24281974f, 0.05020728f, 0.19878776f, 0.10268759f, 0.20299828f, -0.04566315f, -0.00514579f, 0.01985780f, 
    0.04159018f, -0.17108698f, -0.18073784f, -0.17858666f, -0.08158946f, -0.04275026f, 0.01376679f, -0.01994934f, 
    0.04233802f, -0.17274146f, 0.28630522f, 0.07426854f, 0.23011640f, -0.07193682f, 0.12217878f, 0.12714264f, 
    -0.19692644f, -0.06077455f, 0.01297332f, 0.05622869f, -0.13346685f, 0.27746275f, 0.08565357f, 0.01486352f, 
    -0.25681013f, -0.13260235f, -0.21129867f, -0.18121809f, -0.09184087f, -0.14885481f, 0.16765516f, 0.05927229f, 
    -0.00846098f, -0.14430863f, 0.09732263f, 0.14141944f, 0.08015598f, 0.02275722f, -0.13818741f, 0.01230760f, 
    -0.03609191f, 0.18991163f, 0.00956901f, -0.15878972f, 0.02670028f, 0.15939835f, 0.00999320f, 0.10618354f, 
    -0.00822226f, 0.02455537f, -0.07202235f, -0.01671606f, 0.14017639f, -0.03175880f, -0.05812368f, 0.01540574f, 
    0.07323063f, -0.08174843f, 0.02309210f, 0.05921877f, -0.11579038f, -0.07730935f, 0.40857434f, 0.01037378f, 
    -0.12714309f, -0.18840604f, -0.01960869f, -0.17921615f, -0.00049478f, 0.06017363f, 0.08239330f, 0.00946135f, 
    0.10109424f, 0.03429805f, 0.08339336f, 0.13634185f, 0.22731806f, 0.04330099f, 0.08711243f, 0.11886580f, 
    0.12037561f, -0.01304486f, -0.15532875f, 0.15785614f, -0.06862994f, 0.00222302f, 0.04448945f, -0.18424246f, 
    0.01678015f, -0.03282299f, 0.01949580f, 0.00695514f, -0.00079284f, -0.04318659f, 0.02597546f, -0.04795375f, 
    -0.04948551f, 0.01676980f, -0.02588407f, -0.01141727f, 0.03923686f, 0.04458168f, -0.05413194f, 0.03400675f, 
    -0.04598753f, -0.02629453f, -0.02801649f, -0.05651061f, -0.00001115f, -0.03963640f, 0.02769766f, 0.03962533f, 
    0.03362533f, -0.03113587f, -0.02271668f, -0.04609530f, -0.01368005f, -0.03551192f, -0.01824505f, -0.03220581f, 
    0.03265036f, -0.02973957f, -0.00002652f, 0.01434833f, 0.03082936f, 0.01031570f, -0.04493760f, -0.00257470f, 
    0.04248658f, 0.03029285f, -0.01073414f, 0.01174380f, -0.01648443f, -0.04675720f, 0.03464853f, -0.05940830f, 
    -0.05449319f, -0.04817851f, -0.03855610f, -0.02678262f, 0.00627752f, -0.01238094f, -0.00454861f, -0.05822701f, 
    -0.01931762f, 0.00229525f, 0.00234744f, -0.03750445f, 0.00236327f, -0.04392060f, 0.01487486f, -0.01626713f, 
    0.00084658f, 0.01549275f, -0.00133434f, -0.01006495f, 0.00837169f, 0.02843791f, -0.03885914f, -0.03057309f, 
    0.01277240f, 0.00487468f, -0.06404237f, -0.02988843f, -0.01968007f, -0.03043396f, -0.06383348f, -0.06341854f, 
    -0.06086642f, -0.00482018f, -0.05739779f, -0.01170655f, -0.00589984f, -0.01115185f, -0.01158304f, 0.00960926f, 
    0.02446972f, -0.02287397f, -0.04124397f, -0.03596869f, -0.01376579f, -0.06584676f, 0.03489714f, -0.01157614f, 
    0.01637757f, -0.02855225f, 0.02220868f, 0.03764574f, -0.01957720f, -0.02096832f, 0.02523039f, -0.04291474f, 
    0.04191675f, -0.03649937f, 0.01248994f, -0.01072174f, -0.01118319f, -0.01921533f, 0.03662851f, -0.00428981f, 
    -0.02648292f, 0.00975361f, 0.03565198f, -0.00227438f, 0.00721849f, 0.02609856f, 0.02058353f, 0.00264450f, 
    -0.06211261f, 0.04564794f, -0.01886768f, -0.02800419f, -0.01091058f, 0.02837124f, -0.04209167f, -0.00991916f, 
    -0.05142838f, 0.04330652f, 0.01795696f, -0.02138611f, 0.00615285f, -0.01669337f, 0.01973272f, -0.01770784f, 
    0.01545532f, 0.01855359f, 0.03763145f, -0.03067468f, 0.00714745f, -0.05261274f, 0.00972848f, -0.05939781f, 
    0.03332094f, 0.02442878f, -0.01856471f, -0.03602484f, 0.01665363f, 0.02976560f, 0.02431552f, -0.00612941f, 
    0.01756539f, 0.00879088f, 0.02732941f, 0.02493224f, -0.02373854f, -0.04415490f, -0.03575883f, -0.02472513f, 
    0.01740090f, 0.01398961f, 0.01609448f, 0.01629477f, 0.01191622f, -0.03987810f, -0.04042766f, 0.02713800f, 
    0.00483445f, -0.04211895f, -0.04825019f, 0.02694361f, 0.02442196f, -0.01521472f, -0.03782423f, 0.04527064f, 
    0.03346460f, -0.02070128f, -0.01779117f, 0.03349242f, -0.03864265f, -0.03761852f, -0.05252210f, -0.00483895f, 
    -0.00177454f, 0.02030802f, 0.02854157f, -0.00440355f, 0.02525347f, -0.06192977f, 0.01058923f, -0.04219668f, 
    0.02656391f, -0.05208873f, 0.03571483f, 0.01747847f, -0.05379407f, -0.05691630f, -0.04165657f, -0.03196558f, 
    0.02247431f, 0.02730194f, -0.06572662f, 0.04466137f, -0.02255064f, -0.01675432f, 0.02919346f, -0.05477697f, 
    0.04566918f, -0.03664107f, 0.04745197f, -0.03389951f, 0.02242051f, -0.03903958f, -0.05734554f, 0.01398190f, 
    0.02448592f, -0.00166814f, -0.00447928f, -0.02732131f, -0.06056479f, -0.05959389f, 0.04106073f, 0.00212374f, 
    0.02959123f, -0.01773296f, 0.00020377f, -0.06414431f, -0.02460711f, 0.00348322f, 0.01460983f, 0.03172220f, 
    0.02186200f, -0.02979144f, 0.02638138f, -0.02423954f, 0.03999413f, -0.00513046f, 0.04984947f, 0.04104707f, 
    -0.05376967f, 0.01727592f, 0.01868389f, -0.02424239f, 0.03374799f, 0.00690073f, -0.01495283f, -0.02803021f, 
    0.03930464f, -0.00146509f, 0.00780497f, -0.00627834f, 0.01322517f, 0.00646878f, -0.03942449f, -0.05735147f, 
    0.03031576f, -0.00218966f, 0.01533511f, -0.06173496f, -0.01600730f, 0.01903104f, -0.03883025f, 0.04068079f, 
    -0.04417629f, -0.03205352f, -0.06119005f, -0.00439966f, 0.00816048f, 0.01239136f, -0.04604880f, -0.04194457f, 
    -0.04539711f, -0.04899757f, -0.04893866f, 0.01917579f, 0.02106026f, 0.02918848f, 0.03504135f, -0.01318851f, 
    -0.02368014f, 0.03597828f, -0.00918713f, -0.02595318f, 0.03197201f, -0.02930345f, -0.00268184f, 0.00135085f, 
    0.00931462f, -0.04643953f, -0.02221924f, -0.03629408f, -0.02822935f, -0.04998843f, 0.04763475f, 0.01771064f, 
    -0.01274163f, -0.02548322f, -0.02506297f, 0.00833738f, 0.01980907f, 0.00241474f, 0.03325744f, 0.03781362f, 
    0.03283847f, 0.00974793f, -0.05046216f, 0.01939654f, 0.00537768f, -0.04838303f, 0.02898981f, 0.00889845f, 
    0.03926535f, 0.04135083f, -0.05604159f, 0.03703693f, 0.00979633f, -0.00461658f, 0.01360022f, -0.00462042f, 
    0.25286669f, -0.23614182f, -0.27851665f, -0.35214686f, 0.13381642f, 0.05035184f, -0.15954660f, 0.01256505f, 
    0.30470720f, 0.00686333f, 0.07482198f, 0.00178847f, -0.13017227f, -0.04496652f, -0.15394741f, 0.16142532f, 
    -0.05615313f, -0.25938457f, -0.00820677f, 0.17990024f, 0.26082483f, -0.23519526f, 0.22210108f, 0.19051453f, 
    0.00536580f, -0.19147515f, -0.00327696f, -0.12156737f, 0.15880057f, -0.20936483f, 0.06791936f, -0.12401164f, 
    0.07510114f, -0.02540708f, 0.00445938f, 0.12639184f, 0.03272390f, -0.11089166f, -0.06961226f, -0.08050732f, 
    -0.05392040f, 0.56857699f, 0.36998513f, 0.21061550f, -0.02413765f, -0.20346294f, -0.02256297f, -0.04705520f, 
    0.03523849f, 0.15819980f, 0.02912986f, 0.04801845f, 0.03812949f, -0.05217206f, -0.06642661f, -0.00098662f, 
    -0.08783098f, 0.01709164f, 0.04982761f, -0.36885297f, -0.80251020f, -0.32024342f, 0.05791636f, 0.19672894f, 
    0.11235113f, -0.05913715f, 0.05535647f, 0.14338425f, 0.18476811f, -0.01888070f, 0.15225105f, -0.02544037f, 
    -0.06937576f, 0.10288308f, -0.04244518f, -0.06645278f, -0.02043873f, 0.04656360f, -0.07942032f, -0.11359999f, 
    0.93723243f, -0.28062454f, 0.10690700f, -0.02079972f, -0.39996815f, -0.02896939f, -0.09372927f, -0.13916595f, 
    0.09416522f, -0.25629249f, -0.00656216f, -0.17059337f, -0.04099546f, 0.21160749f, -0.01054283f, 0.03994957f, 
    -0.00431156f, -0.14683542f, 0.01630591f, -0.03543062f, 0.13442521f, -0.09584754f, 0.05466602f, 0.05716783f, 
    0.10951511f, -0.09666219f, 0.06250621f, 0.09700768f, 0.05806162f, 0.00978166f, 0.01716043f, 0.13177639f, 
    -0.04612380f, 0.04218725f, 0.00505394f, 0.04540522f, 0.05724793f, -0.10800709f, 0.00689171f, 0.06823952f, 
    0.21288452f, -0.20255025f, 0.12506296f, 0.15938424f, -0.04266527f, -0.13604404f, 0.09246102f, -0.13525453f, 
    0.02160631f, -0.17119193f, 0.06409892f, 0.15254323f, 0.04797552f, -0.08958759f, -0.07986853f, -0.09452455f, 
    -0.17335440f, -0.02000868f, -0.20553580f, -0.09602807f, -0.26341981f, 0.02511759f, 0.15434088f, -0.33769485f, 
    0.01086517f, -0.07719371f, 0.01240553f, 0.06364283f, 0.01900456f, -0.00373078f, 0.07417715f, -0.04490423f, 
    0.02583869f, -0.02339281f, -0.02591239f, 0.03195114f, -0.07997901f, -0.15169054f, 0.09371721f, -0.10105238f, 
    0.55198354f, -0.04665519f, 0.28691038f, 0.18123640f, -0.24149960f, 0.08545766f, 0.10174022f, -0.13951372f, 
    0.17103553f, -0.04285568f, 0.04140456f, -0.14003251f, 0.00136461f, -0.03437395f, -0.03116095f, 0.17814809f, 
    0.10642816f, 0.05773420f, -0.06671438f, -0.00258623f, 0.19951451f, -0.08818466f, 0.03151391f, 0.07593201f, 
    -0.07076728f, -0.07014096f, 0.02122385f, -0.07346854f, 0.05826914f, -0.08331392f, -0.10340115f, 0.05923966f, 
    0.05307463f, 0.10513975f, 0.03947746f, 0.02771053f, -0.00274339f, -0.08171456f, -0.06640599f, -0.02522021f, 
    -0.22239533f, -0.05219510f, 0.39933655f, 0.20562500f, -0.22715636f, 0.13026305f, 0.03829186f, 0.04635275f, 
    -0.08097328f, -0.06617324f, 0.01656879f, 0.03803754f, -0.08801645f, 0.04000636f, -0.02888568f, 0.17377760f, 
    0.11628422f, -0.04503522f, 0.00008468f, 0.09198241f, 0.67755061f, 0.17016467f, 0.10410542f, 0.36128098f, 
    -0.25839546f, -0.10900591f, -0.10680475f, -0.15258898f, -0.05530268f, -0.11595339f, 0.05233522f, -0.00736450f, 
    -0.03537372f, 0.02214664f, 0.07011146f, 0.03086069f, -0.00829687f, -0.18979819f, 0.02619130f, -0.00098187f, 
    -0.69249421f, 0.02993389f, -0.27390119f, -0.02179589f, -0.04248663f, 0.05166156f, -0.18952087f, 0.32058349f, 
    -0.09333377f, 0.03397754f, -0.04093735f, 0.10058797f, -0.00782473f, 0.16806960f, -0.05395139f, 0.20040753f, 
    0.09165986f, 0.14988844f, -0.12843682f, 0.26788741f, -0.22399297f, 0.08195759f, 0.29650018f, 0.05291917f, 
    -0.04542886f, -0.01609483f, -0.06807794f, 0.08964714f, -0.08244147f, -0.13380778f, 0.12337514f, 0.01968011f, 
    -0.17051236f, 0.02093697f, -0.02716031f, -0.02787396f, -0.10320966f, -0.21189234f, 0.00665977f, 0.06622338f, 
    0.20161980f, -0.39070740f, -0.37223375f, 0.11202647f, 0.00946788f, 0.01153868f, -0.00411672f, 0.08725339f, 
    0.14076443f, 0.03221839f, 0.14886980f, -0.02478297f, 0.09868884f, 0.22961648f, -0.07471956f, 0.06045626f, 
    0.12834767f, 0.08304451f, -0.01057537f, 0.02632751f, -0.17393897f, 0.24284999f, -0.05843211f, 0.00012769f, 
    -0.01377806f, -0.01034868f, -0.05162565f, -0.00615807f, 0.15598077f, -0.02543669f, 0.00525173f, -0.06254156f, 
    0.16201390f, 0.08398553f, -0.06782843f, -0.00858590f, 0.12659985f, -0.05610214f, 0.23571360f, 0.00763678f, 
    0.15035087f, -0.03424102f, -0.15765011f, 0.34500372f, 0.12235549f, 0.19287232f, 0.40417206f, -0.17435558f, 
    0.18486325f, 0.06813714f, -0.03464380f, 0.08738547f, 0.03777591f, 0.01371052f, 0.15002209f, -0.11533649f, 
    -0.00018366f, 0.02395133f, -0.00778744f, -0.02695932f, 0.08978785f, 0.21761657f, 0.01620536f, 0.26757523f, 
    0.07211478f, 0.02858419f, -0.10672218f, -0.14411414f, -0.18419053f, -0.15231004f, -0.04633643f, 0.00565395f, 
    -0.01762707f, 0.17710933f, 0.00637058f, 0.09995686f, -0.02700098f, 0.03141309f, 0.04283293f, 0.09092334f, 
    -0.49600846f, -0.35013163f, 0.05876054f, -0.11241414f, -0.30943295f, 0.06326400f, 0.01491308f, 0.03187863f, 
    0.04234426f, -0.17612743f, -0.05637123f, -0.05357958f, -0.05436959f, 0.00533971f, -0.04156584f, -0.02163034f, 
    0.01152840f, 0.14940457f, 0.03264336f, -0.04283994f, -0.46925792f, 0.47930875f, 0.10719085f, 0.60215998f, 
    -0.07234818f, 0.13896084f, 0.05223324f, -0.00502891f, 0.15986641f, -0.00174640f, 0.30666000f, 0.25183615f, 
    0.03034117f, 0.24173175f, 0.01755613f, 0.47515032f, 0.18524355f, 0.04365699f, 0.34180915f, 0.10854182f, 
    0.64618790f, 0.07574210f, 0.27039915f, -0.12088528f, 0.01358220f, 0.09485210f, -0.14313419f, -0.08675436f, 
    -0.15325141f, -0.02621239f, 0.14731668f, 0.34868792f, 0.22232422f, -0.10925110f, 0.21598572f, 0.17591591f, 
    -0.08341274f, 0.03858235f, 0.04115907f, 0.19178624f, 0.25394410f, 0.04591553f, 0.04624916f, 0.17590381f, 
    0.28462046f, -0.06572592f, -0.01236873f, -0.03011627f, -0.03211514f, -0.13856891f, 0.07657185f, -0.05328108f, 
    0.11369289f, 0.06003375f, -0.02142273f, -0.04318788f, 0.00045290f, 0.07336985f, -0.01225437f, -0.03405720f, 
    0.30959347f, -0.09084484f, 0.11337706f, -0.01046302f, 0.14351435f, -0.02706334f, 0.09598183f, -0.15420178f, 
    -0.14057331f, -0.14490539f, 0.35762614f, 0.31405175f, 0.14750496f, 0.19960772f, 0.21367702f, 0.01288927f, 
    0.16738518f, -0.03621263f, 0.01488962f, -0.00946670f, 0.08286542f, 0.03485543f, 0.01788499f, 0.03905138f, 
    -0.20161296f, -0.01758935f, -0.10549243f, 0.20323604f, -0.02232468f, 0.04943936f, 0.11081646f, -0.15381120f, 
    -0.07001055f, 0.05865284f, -0.02400173f, 0.02703209f, 0.08600012f, -0.10730551f, 0.07650765f, -0.00547761f, 
    -0.15963174f, 0.04714919f, -0.36130849f, -0.12099914f, -0.42790863f, -0.00958269f, -0.07383789f, -0.17038500f, 
    0.16492288f, 0.08062629f, 0.08100612f, -0.18504588f, -0.01045767f, -0.00698397f, -0.10598835f, 0.02755771f, 
    -0.06043516f, -0.07092185f, 0.17053717f, 0.19018890f, -0.09610882f, -0.02659563f, 0.27003419f, -0.11968569f, 
    -0.12603936f, -0.11753196f, -0.09146479f, -0.12641895f, -0.02380245f, -0.18156563f, 0.04279514f, 0.04180765f, 
    0.15424511f, 0.17028260f, -0.05235211f, -0.13385913f, -0.15529500f, -0.03747329f, -0.08516517f, -0.06763289f, 
    -0.19986930f, 0.31938770f, -0.17396766f, 0.20642543f, -0.10514925f, 0.00576890f, -0.00587260f, 0.11916154f, 
    -0.13416576f, 0.07472244f, 0.10132612f, -0.14147173f, 0.06509461f, 0.09452505f, 0.14768440f, 0.07390259f, 
    0.07250249f, 0.11534575f, 0.15194999f, 0.06993652f, -0.04089489f, 0.13462298f, 0.09539872f, -0.05130544f, 
    -0.37776956f, -0.03131164f, -0.19478545f, -0.21765879f, -0.12474982f, -0.29809615f, -0.04540781f, -0.02200544f, 
    0.30920687f, 0.07671605f, 0.13421768f, -0.10331586f, -0.06279990f, -0.14469387f, -0.05489726f, -0.00260109f, 
    0.42389026f, 0.21938953f, 0.03202436f, 0.25961170f, 0.54065150f, -0.20214167f, -0.15081698f, 0.10410330f, 
    -0.18782450f, -0.06521010f, -0.06287382f, 0.06138948f, 0.07370544f, 0.05110159f, 0.13181993f, 0.16483586f, 
    0.11605688f, 0.04902146f, 0.15939084f, -0.00076159f, 0.06275680f, 0.18050896f, 0.01765490f, 0.05693751f, 
    0.01233550f, 0.00039839f, -0.18684843f, -0.05913677f, -0.26735583f, -0.04234407f, 0.27129605f, 0.33322665f, 
    0.13215737f, 0.29184362f, 0.00664236f, -0.02532066f, 0.01204380f, -0.20336890f, -0.07006060f, -0.04941856f, 
    -0.57889217f, -0.03408326f, 0.01590032f, 0.01117965f, -0.06274096f, 0.14277811f, 0.29497144f, -0.00116582f, 
    0.24685684f, 0.18158327f, 0.18066275f, -0.14468279f, 0.06157222f, 0.16647300f, -0.00772409f, 0.07681949f, 
    0.02550263f, -0.16167811f, 0.13526841f, -0.04093277f, -0.11541334f, -0.02011116f, -0.16284186f, 0.19929595f, 
    -0.19983301f, 0.54197794f, 0.10402449f, 0.08812956f, 0.16770060f, 0.18983787f, 0.08876742f, 0.07598837f, 
    0.14243080f, -0.00475343f, 0.19772036f, 0.05360165f, 0.06328060f, 0.12456696f, 0.03988998f, 0.17310308f, 
    -0.31934214f, 0.22225019f, 0.08422774f, 0.56194079f, -0.22050570f, 0.14732233f, -0.07785720f, 0.19644943f, 
    -0.04399722f, 0.08199762f, 0.15043776f, -0.05211643f, 0.11347903f, 0.07466622f, 0.06580164f, 0.18126461f, 
    0.27398518f, 0.36245474f, 0.31528553f, 0.19626810f, -0.24941139f, 0.21835123f, 0.23607357f, -0.04977683f, 
    0.08032383f, -0.04322995f, 0.08369695f, 0.19237189f, -0.12837356f, -0.01769516f, 0.04546207f, 0.09439585f, 
    0.03893046f, 0.08919187f, 0.26324764f, -0.01184544f, 0.00392236f, 0.07504936f, -0.08024731f, 0.00821990f, 
    -0.07593388f, -0.31523091f, -0.01248918f, 0.30570972f, 0.11679237f, 0.05733562f, -0.01308501f, -0.01456954f, 
    -0.14725155f, -0.02117767f, 0.01245205f, 0.11396631f, -0.11378534f, -0.14298850f, -0.00464120f, -0.01414887f, 
    -0.02788119f, -0.06102367f, 0.00295120f, 0.03127571f, 0.47319481f, 0.06917617f, -0.18317801f, -0.16789304f, 
    0.37137517f, 0.23772293f, 0.34896114f, 0.22534539f, -0.21955918f, 0.18262456f, 0.19585122f, 0.20359558f, 
    0.19270100f, 0.20137593f, 0.36493862f, 0.06804083f, 0.25699478f, -0.02800994f, 0.15845275f, 0.02809023f, 
    -0.52989125f, 0.27373335f, 0.06752887f, -0.12018894f, 0.09052090f, -0.09240567f, 0.15571912f, 0.05300790f, 
    0.20239744f, -0.08829223f, -0.07549637f, -0.03863692f, 0.22673896f, 0.12142628f, 0.20815438f, 0.08650800f, 
    -0.05842885f, 0.13182478f, -0.10507286f, -0.14074628f, 0.08021148f, 0.17034052f, 0.12977871f, -0.13825002f, 
    -0.15752603f, 0.03403571f, 0.03448671f, 0.00468706f, -0.02549764f, 0.00791892f, -0.13753842f, 0.03724465f, 
    0.02137055f, 0.05851233f, 0.04066180f, 0.14175446f, 0.20462780f, 0.06460479f, -0.13542628f, -0.02868269f, 
    -0.37309098f, 0.06201267f, -0.06616604f, 0.09772935f, -0.12746777f, 0.07928687f, -0.07874293f, 0.13793115f, 
    0.05685906f, 0.07835037f, -0.07316005f, -0.01651107f, 0.18189880f, 0.21090093f, 0.21855745f, 0.05611259f, 
    -0.03287688f, -0.05327352f, 0.03933816f, -0.21207011f, 0.09722704f, 0.11633797f, -0.04859397f, 0.18278107f, 
    -0.05498173f, 0.09410569f, 0.11385260f, -0.03089451f, 0.03058311f, -0.20221855f, 0.07131851f, 0.03213204f, 
    0.08495843f, 0.00445622f, 0.23319812f, -0.08555720f, -0.14723121f, 0.07807959f, -0.11694717f, -0.24457431f, 
    -0.62861139f, -0.15723832f, 0.32596037f, 0.41565782f, 0.26010624f, -0.09408017f, 0.05504953f, 0.11421946f, 
    -0.10296537f, -0.12305050f, -0.12311365f, 0.02075568f, 0.13979800f, -0.02377156f, 0.13578241f, 0.03962002f, 
    0.17287527f, 0.26944059f, 0.14514774f, 0.07922729f, -0.30292699f, -0.07630713f, -0.01050053f, -0.05693181f, 
    -0.10468341f, -0.17813486f, -0.11480650f, -0.03840073f, -0.01782412f, 0.10910463f, 0.14544348f, 0.03834466f, 
    0.00049186f, -0.03929069f, 0.13766314f, 0.03513834f, -0.22220159f, -0.09225465f, -0.22005352f, -0.28074697f, 
    0.03074749f, 0.00951765f, 0.23089294f, 0.11903213f, 0.27362198f, 0.24042335f, 0.07026462f, -0.06536043f, 
    0.18624090f, 0.14671774f, -0.03310187f, 0.06016455f, 0.30324811f, 0.23003449f, 0.14618920f, 0.00864609f, 
    0.09397969f, 0.17597882f, 0.25951579f, 0.20270859f, -0.33420533f, 0.24731281f, 0.28502327f, 0.05243895f, 
    0.06224119f, -0.18027937f, -0.20365860f, 0.04496319f, 0.05765346f, 0.20766623f, 0.10441494f, 0.12193622f, 
    -0.00134545f, -0.02483767f, 0.03453894f, 0.01236472f, -0.02443735f, 0.11096191f, -0.09461515f, -0.05740995f, 
    0.43077707f, -0.33656055f, 0.09033456f, -0.09436324f, 0.25994265f, 0.07284825f, 0.13551691f, -0.28030449f, 
    0.15069503f, -0.07798441f, -0.09919345f, -0.00538598f, 0.01415316f, -0.15168084f, -0.07239815f, 0.09112433f, 
    0.17509310f, 0.04989661f, 0.21853743f, 0.09161918f, 0.08794542f, -0.17561346f, -0.06303731f, -0.19851886f, 
    0.01415044f, -0.08956077f, 0.13057159f, -0.16128924f, 0.14129972f, -0.06017099f, 0.02213923f, 0.08782800f, 
    0.25310940f, 0.19319566f, 0.22178054f, 0.03421380f, 0.06636379f, 0.07181197f, -0.10361407f, -0.13494119f, 
    -0.28493893f, -0.34355238f, 0.20128945f, 0.52380717f, 0.05524264f, 0.35423702f, 0.03946979f, 0.19339982f, 
    -0.23188311f, 0.10134991f, 0.05095461f, 0.07673062f, 0.05212155f, 0.06915319f, 0.12685911f, 0.26915523f, 
    0.23107493f, 0.25892875f, 0.20421484f, 0.15406694f, 0.18044063f, -0.27233285f, 0.01801572f, 0.38775405f, 
    0.18936953f, 0.01212181f, -0.00737290f, 0.19856572f, 0.09072403f, 0.16989005f, 0.09349574f, 0.01803807f, 
    0.04620006f, 0.17718524f, 0.10526809f, 0.18592151f, 0.22790802f, 0.08102449f, 0.17286122f, 0.33445260f, 
    -0.04073386f, 0.02226576f, 0.00418564f, -0.02520070f, 0.00637450f, -0.04390736f, -0.00511842f, 0.03737660f, 
    -0.03317945f, -0.05880203f, 0.03280281f, -0.06237274f, -0.02526753f, -0.04857640f, 0.04481217f, -0.03415266f, 
    -0.00622496f, 0.03924281f, 0.00478570f, -0.01251855f, 0.01977204f, -0.03081784f, 0.02409664f, -0.03477436f, 
    -0.04992642f, -0.02547656f, 0.00950240f, 0.02878004f, 0.01043265f, -0.04835756f, -0.01751708f, -0.01777767f, 
    0.04346896f, -0.01535321f, -0.01646137f, 0.02670931f, -0.00911048f, -0.05963330f, 0.04034576f, -0.02625546f, 
    0.00250741f, -0.01258856f, -0.00398051f, -0.05384762f, 0.02772239f, 0.01342078f, -0.03802150f, -0.04110738f, 
    0.02474523f, 0.04803792f, -0.04987955f, 0.03838647f, -0.01197722f, 0.00421525f, -0.03157000f, -0.05433916f, 
    -0.03199185f, 0.01746619f, 0.04666683f, -0.05277046f, 0.03194096f, 0.04947194f, 0.02762407f, 0.03866102f, 
    0.00283061f, -0.02982117f, -0.05896778f, -0.02353723f, -0.01562482f, -0.02252235f, 0.02406786f, -0.04708187f, 
    -0.06022643f, 0.01597446f, -0.04832909f, -0.05440114f, -0.05032461f, 0.04006871f, -0.00581727f, -0.04520006f, 
    0.01208596f, 0.06067052f, 0.02402085f, -0.01514159f, 0.02078302f, -0.00520961f, -0.04241364f, -0.01707165f, 
    -0.04030954f, -0.05447271f, 0.00305415f, -0.02805720f, -0.05912856f, -0.04020094f, -0.06208132f, 0.02273135f, 
    -0.04536346f, -0.01814052f, 0.01005590f, 0.03361756f, 0.04525185f, -0.00989350f, 0.03111119f, -0.02671471f, 
    -0.03118940f, -0.01067049f, -0.01482920f, -0.05000664f, -0.06266629f, -0.01859321f, 0.04123939f, 0.00148263f, 
    0.03588619f, -0.01516849f, -0.02032917f, 0.01583652f, -0.01317033f, -0.04180183f, -0.03381867f, 0.02696961f, 
    -0.01684234f, 0.06171985f, -0.01856578f, -0.00231374f, -0.02321251f, 0.04355817f, -0.05321916f, -0.03759343f, 
    -0.03785458f, 0.04511581f, 0.03127547f, -0.00377270f, -0.01849495f, 0.00642125f, -0.03621649f, 0.04500106f, 
    0.04480102f, 0.02398130f, -0.06193700f, 0.02377524f, -0.02180245f, -0.02375006f, 0.02720169f, 0.03456905f, 
    -0.02765026f, 0.01378903f, -0.03840972f, -0.03428344f, -0.00074587f, -0.05157140f, 0.03166110f, -0.01832818f, 
    -0.01335930f, -0.00609678f, -0.04177769f, 0.00894784f, -0.04773498f, -0.00388625f, 0.03726629f, -0.01613452f, 
    -0.03554367f, 0.00280834f, -0.02936061f, 0.03813257f, 0.03121214f, -0.00164288f, -0.03502895f, -0.05213616f, 
    0.05578348f, -0.04094196f, -0.00336697f, -0.05986933f, -0.04554967f, 0.00231065f, -0.02972460f, 0.02837111f, 
    -0.03674537f, -0.04124751f, 0.04375466f, 0.00888434f, 0.00072005f, 0.00511765f, 0.04396525f, -0.03385185f, 
    -0.02180627f, 0.01966570f, 0.02564698f, -0.06120423f, -0.05156330f, 0.04167198f, 0.03841752f, -0.03056352f, 
    -0.01725987f, -0.03686195f, 0.00714684f, -0.00251358f, -0.02590436f, 0.01550855f, -0.05512365f, -0.04548343f, 
    -0.02054680f, -0.01746509f, 0.02425898f, -0.04780209f, 0.01190372f, 0.01821867f, -0.00152921f, 0.04628713f, 
    -0.01876527f, -0.03786120f, -0.00828083f, 0.02847765f, -0.02368886f, -0.03232042f, -0.01288079f, 0.04060609f, 
    -0.04121110f, 0.00396862f, 0.02494796f, -0.00613876f, -0.03658722f, -0.03721669f, -0.03817919f, -0.01457018f, 
    -0.06326685f, 0.03460939f, 0.00712976f, 0.04581644f, 0.00447503f, 0.04798488f, 0.03057942f, -0.03637885f, 
    -0.01643677f, -0.02737180f, -0.05540299f, -0.04822982f, -0.00279942f, -0.05753612f, 0.03048797f, -0.02878967f, 
    0.04122737f, 0.03400610f, 0.00319885f, 0.00828026f, -0.03926494f, 0.03122421f, -0.01999263f, -0.02860925f, 
    0.02259032f, 0.01080460f, -0.04305159f, 0.04226707f, -0.00004441f, 0.03447971f, 0.03993347f, -0.04437692f, 
    0.03080712f, 0.03425918f, -0.00585959f, 0.01331108f, -0.00523893f, -0.02685234f, 0.00055487f, -0.03958874f, 
    -0.04973879f, -0.00450757f, 0.04829581f, 0.01438705f, 0.00942117f, -0.04416175f, 0.01299136f, -0.02568272f, 
    0.04480201f, -0.01095461f, 0.00164732f, -0.00843624f, -0.04097549f, -0.01715619f, 0.00515854f, 0.01194134f, 
    -0.00412416f, -0.04201695f, 0.03185841f, 0.00287230f, 0.01982222f, 0.04263727f, -0.06266978f, 0.02077741f, 
    0.00377670f, -0.02080722f, 0.04200071f, -0.05030083f, 0.00648636f, 0.04179415f, 0.03088442f, -0.00156816f, 
    0.04047460f, -0.01719544f, -0.02667665f, -0.01271535f, -0.04950448f, -0.04296307f, -0.05217078f, 0.01692235f, 
    -0.04073327f, -0.02734707f, 0.01266823f, -0.02386863f, -0.02730682f, -0.01808085f, -0.00087270f, -0.00238473f, 
    -0.03182936f, -0.05232277f, 0.02391510f, 0.02118291f, 0.02394834f, -0.04684543f, 0.01200172f, -0.00404155f, 
    -0.04358183f, -0.03249081f, -0.02562314f, 0.01529245f, -0.02201634f, -0.04815767f, 0.01269265f, -0.00716867f, 
    -0.04045566f, -0.05539011f, -0.01812629f, -0.05475289f, 0.04310568f, -0.00816022f, -0.04236678f, -0.00080764f, 
    0.01068889f, -0.04444112f, 0.00601867f, 0.02354051f, -0.06313762f, -0.03770733f, -0.02080157f, -0.01555257f, 
    0.01440220f, 0.01716649f, -0.00281863f, -0.02367136f, -0.03326340f, 0.01309730f, 0.02380567f, -0.02511408f, 
    0.03778012f, -0.01897308f, -0.01453000f, 0.04246343f, -0.04567434f, -0.01418987f, 0.00230751f, -0.03534821f, 
    0.01257126f, 0.03793579f, -0.05601093f, 0.04815407f, 0.04115208f, -0.03117242f, -0.02284756f, 0.02886616f, 
    -0.02527646f, -0.03942021f, 0.04145705f, 0.04573617f, -0.05461529f, 0.00015491f, 0.02457532f, 0.03068555f, 
    -0.02040721f, 0.03190013f, -0.00334304f, 0.02661147f, -0.02552781f, -0.00665376f, 0.03794665f, -0.03188419f, 
    0.00445847f, -0.03232301f, -0.04400520f, 0.03330008f, -0.00447767f, -0.04738950f, -0.04187760f, 0.02744547f, 
    0.02095179f, -0.00868394f, -0.01383031f, 0.00291002f, 0.00646760f, -0.00687992f, -0.03088982f, -0.03986958f, 
    0.02707331f, 0.00706963f, 0.02800369f, -0.05348631f, -0.01604291f, 0.00587396f, 0.04504636f, -0.04301718f, 
    -0.04942787f, -0.02043253f, 0.03610481f, -0.04912618f, 0.04948882f, -0.00525509f, 0.02613583f, 0.01088485f, 
    -0.03934468f, 0.02619606f, 0.01420560f, -0.04191525f, 0.04181102f, -0.03002623f, -0.03437819f, 0.00577943f, 
    0.00783048f, 0.01854072f, -0.05320105f, 0.03355576f, -0.06338972f, -0.05238556f, -0.00676770f, 0.04536045f, 
    0.03999761f, -0.02920112f, 0.00229199f, -0.06141810f, 0.01429317f, 0.00596609f, -0.03797731f, -0.05727586f, 
    0.02247985f, 0.00396076f, 0.04266613f, -0.06186786f, 0.03353321f, 0.01184824f, 0.04300102f, 0.01493904f, 
    0.01347464f, 0.03590241f, 0.03956166f, -0.04027526f, 0.02040814f, 0.03224818f, -0.04781969f, 0.02267827f, 
    0.01145610f, -0.01397160f, -0.00286496f, -0.05235834f, -0.00574863f, 0.02987593f, 0.01241481f, 0.01693028f, 
    0.01289617f, 0.00270684f, -0.02302346f, -0.00442021f, 0.04406361f, -0.05502176f, 0.04896215f, 0.04771928f, 
    0.01374121f, -0.03693404f, 0.02435839f, 0.03579175f, -0.06339409f, -0.00859481f, -0.00814203f, -0.01377988f, 
    0.00336397f, 0.04340781f, 0.01477830f, -0.01535176f, -0.02827207f, -0.03340563f, 0.02382823f, -0.00927325f, 
    -0.00179451f, -0.00400908f, 0.03947719f, 0.04026665f, -0.03225782f, 0.03192580f, -0.00337052f, -0.02505010f, 
    -0.04326926f, -0.04436942f, -0.00546577f, -0.05377383f, -0.02891677f, 0.02543617f, -0.01216489f, -0.04461236f, 
    -0.00729995f, -0.03004965f, -0.01810684f, -0.01942857f, 0.02453996f, -0.03032187f, 0.04256573f, -0.02531563f, 
    -0.01202781f, 0.04675217f, -0.02575686f, -0.05477446f, 0.04692860f, 0.00322726f, -0.00811212f, -0.00027200f, 
    -0.02462729f, -0.05900984f, -0.05411594f, -0.00777335f, -0.00681117f, -0.05817752f, -0.05071555f, 0.02897255f, 
    -0.04816252f, -0.06133381f, -0.05188729f, 0.01879673f, 0.03051523f, -0.01491620f, -0.03581083f, 0.04459433f, 
    -0.03789851f, -0.01254912f, 0.00294573f, 0.03039893f, -0.00084987f, -0.06233248f, -0.00119241f, 0.03066519f, 
    0.04103968f, -0.02237957f, 0.01663784f, 0.03825615f, -0.05156696f, -0.01679811f, -0.01639987f, 0.03582308f, 
    -0.04218866f, -0.05809027f, -0.01054486f, -0.05191466f, 0.03256297f, -0.04680131f, -0.04318585f, 0.02205618f, 
    0.02700186f, -0.02074638f, 0.00685771f, 0.00679754f, 0.03508056f, -0.05296803f, -0.02326700f, 0.01957339f, 
    0.01801405f, 0.02851675f, 0.04002267f, -0.03435524f, -0.03110310f, 0.03440446f, -0.05110963f, -0.02151112f, 
    0.04528919f, -0.03910756f, 0.00117617f, -0.00717609f, -0.03070642f, 0.02030271f, -0.03433383f, -0.01661298f, 
    -0.02447519f, -0.04392498f, 0.03342373f, -0.03593738f, 0.03765364f, -0.02607168f, -0.04151255f, 0.03475146f, 
    0.02009427f, -0.04364856f, -0.02288148f, 0.00240459f, -0.04622697f, -0.05739849f, -0.04539918f, -0.04165471f, 
    0.02365955f, -0.02799547f, 0.01795544f, -0.00040475f, -0.00851109f, -0.06280877f, -0.00693900f, 0.00453726f, 
    -0.02900672f, -0.06199966f, 0.02325632f, -0.01074183f, -0.04431282f, -0.04736860f, -0.06386098f, 0.02444991f, 
    0.01703967f, -0.06277344f, -0.04809637f, -0.01568221f, 0.00806992f, 0.03875605f, -0.02960077f, -0.01696106f, 
    -0.00014316f, 0.03262614f, 0.01521000f, -0.00889526f, -0.04384442f, -0.01985695f, -0.01707879f, -0.00435296f, 
    0.02969459f, 0.01641017f, 0.03040575f, -0.05163438f, 0.02042450f, -0.00983765f, -0.05609983f, 0.01068122f, 
    -0.00646435f, -0.01014784f, -0.05287438f, -0.04171471f, -0.03687524f, -0.05276116f, -0.02241232f, -0.00042250f, 
    0.01136058f, -0.05350234f, -0.05269848f, -0.05321593f, -0.03093276f, -0.03056639f, -0.01960170f, 0.02323990f, 
    -0.07201326f, -0.05693337f, -0.02294546f, -0.07199682f, -0.03941191f, -0.04309256f, 0.01001784f, -0.02930470f, 
    0.01211455f, -0.04363635f, 0.03504493f, -0.02494595f, -0.05933767f, 0.00225784f, -0.05466188f, 0.00820076f, 
    -0.03916084f, -0.03872197f, -0.04670221f, -0.05708711f, -0.02752158f, -0.03908852f, -0.06834183f, -0.05526513f, 
    -0.02002594f, 0.01815474f, -0.07446986f, -0.02324571f, -0.06438068f, -0.03984642f, 0.01602328f, -0.07351497f, 
    -0.06034174f, -0.01954748f, 0.03224342f, 0.03216477f, -0.06815144f, -0.02700931f, 0.02374873f, 0.00634068f, 
    0.03102677f, 0.04585319f, 0.03239425f, -0.01775495f, 0.03030705f, -0.06679731f, 0.01636580f, 0.00650521f, 
    -0.05455665f, -0.05269109f, -0.02720999f, -0.05366782f, -0.03429547f, -0.04475285f, 0.00699969f, 0.03081999f, 
    -0.04482409f, 0.00964521f, -0.00854844f, -0.05140599f, -0.01810040f, 0.00075986f, 0.00190125f, -0.05028868f, 
    0.02047676f, -0.02481888f, -0.05670361f, 0.00655828f, 0.04592654f, -0.05566480f, -0.01906244f, 0.00782797f, 
    -0.05253400f, 0.00043420f, -0.04021725f, -0.04706740f, -0.04486853f, -0.02799900f, -0.05398467f, -0.02822428f, 
    -0.06512021f, -0.07010689f, -0.04007012f, -0.04344214f, -0.03871444f, 0.02536538f, -0.07167915f, -0.02858728f, 
    -0.02650788f, -0.04124392f, -0.02819078f, 0.01467151f, 0.00817944f, 0.00200646f, 0.02272027f, -0.06414169f, 
    0.02347343f, 0.00759811f, -0.03298219f, 0.02467167f, 0.00119568f, 0.03040385f, -0.05550483f, -0.07397143f, 
    -0.05126626f, -0.07527318f, -0.02527514f, 0.02628785f, -0.00862429f, -0.03480742f, -0.03053350f, -0.03122606f, 
    -0.03708459f, 0.00240174f, -0.07131793f, -0.06707392f, 0.01180706f, -0.05738117f, -0.00343952f, 0.00867733f, 
    -0.00040869f, -0.00985482f, -0.01279202f, 0.00830561f, 0.00687284f, -0.07074168f, 0.02744340f, 0.01584637f, 
    -0.02512685f, -0.04004951f, 0.01512124f, -0.03614483f, 0.00740162f, -0.02252421f, -0.02835148f, -0.00248021f, 
    -0.07496457f, -0.06747109f, -0.05539257f, -0.07381075f, -0.04691863f, -0.02417435f, -0.04769133f, 0.01737052f, 
    0.00725942f, 0.02482213f, -0.07409731f, 0.00837417f, -0.00364809f, -0.06760558f, 0.00637145f, 0.02163828f, 
    -0.06825554f, -0.03993324f, 0.02747969f, -0.03574320f, 0.05242104f, -0.03743618f, -0.01134816f, -0.01470638f, 
    -0.05782361f, 0.01319364f, -0.03999680f, -0.01614820f, -0.01243180f, 0.01765805f, -0.06103581f, 0.01551471f, 
    -0.04408465f, -0.01040308f, -0.06587991f, -0.07139442f, -0.07432173f, 0.01845698f, -0.05441956f, -0.00077951f, 
    0.01764872f, -0.06057838f, 0.01193602f, 0.01792934f, -0.06639024f, -0.04393861f, 0.01459343f, -0.00467233f, 
    -0.07323215f, -0.03705737f, -0.05141005f, -0.07347495f, -0.00940238f, 0.00772825f, -0.06145307f, -0.06904197f, 
    0.01730714f, -0.04063023f, 0.00117263f, 0.03298447f, -0.05791092f, -0.01519390f, -0.03458395f, -0.01688872f, 
    -0.02535775f, -0.01198997f, -0.04069094f, -0.00283641f, 0.03355044f, -0.04301878f, -0.05217803f, -0.03989277f, 
    0.01082035f, 0.02914860f, -0.01123958f, -0.05478909f, -0.01053093f, -0.01164528f, 0.01520944f, -0.01308056f, 
    0.01569799f, -0.03923618f, -0.04201226f, -0.00835949f, -0.00590517f, -0.04788361f, -0.07212420f, -0.00385051f, 
    0.02568887f, 0.05463077f, 0.05530014f, -0.03602557f, -0.01386417f, -0.02459308f, -0.06755359f, -0.00744585f, 
    0.03954361f, 0.00756764f, 0.03287058f, -0.00157478f, 0.01220345f, -0.00901878f, -0.07088275f, -0.02995067f, 
    -0.01639734f, -0.05359793f, -0.02451115f, 0.01997765f, -0.01476598f, 0.02188739f, 0.02199252f, 0.02145134f, 
    -0.05512658f, -0.05066764f, -0.02767160f, -0.04736718f, 0.01045856f, 0.02782205f, -0.05201112f, -0.02194140f, 
    -0.01214983f, 0.03264524f, 0.01440465f, 0.03313112f, -0.04423577f, 0.02025333f, -0.06454656f, -0.04555675f, 
    0.01400252f, 0.02457788f, -0.02492665f, -0.01479768f, 0.02280913f, -0.04130138f, -0.05523529f, -0.01813382f, 
    -0.01690874f, 0.01204320f, -0.00781713f, -0.02410589f, 0.03547770f, -0.02592760f, -0.00316349f, -0.02068885f, 
    0.04511189f, 0.03396677f, -0.00772921f, -0.05169262f, 0.02807634f, 0.04406223f, -0.05067956f, -0.06935274f, 
    -0.06705111f, 0.00503053f, -0.06356667f, -0.03090035f, -0.02321632f, -0.02524539f, -0.00976083f, -0.03109251f, 
    -0.01578442f, 0.03172493f, -0.02379618f, -0.04538717f, 0.00691048f, -0.07023337f, -0.01111341f, -0.02047214f, 
    -0.05203321f, 0.00390123f, -0.03865018f, -0.05527255f, -0.04992860f, 0.03646939f, 0.02728034f, -0.05022854f, 
    0.03274814f, 0.02751371f, 0.02590666f, -0.02458221f, -0.04655275f, -0.05672954f, -0.04252936f, -0.03437109f, 
    0.01574753f, 0.03166692f, -0.02244767f, 0.00295770f, 0.00574632f, 0.00318775f, -0.02711691f, 0.01988493f, 
    0.00173048f, -0.00536562f, -0.01510034f, -0.00708903f, 0.04239590f, -0.03667545f, -0.02226323f, -0.05677795f, 
    -0.01837960f, -0.02026740f, 0.02122621f, -0.06271607f, -0.06537875f, 0.01736469f, -0.03967248f, -0.00989727f, 
    -0.00010897f, 0.03881858f, 0.00842675f, -0.00909117f, 0.01738974f, -0.01472653f, 0.03010017f, 0.02466358f, 
    0.03325473f, 0.01937143f, -0.06256977f, 0.04261031f, -0.04517895f, -0.05027144f, -0.03687181f, 0.04435741f, 
    0.00605810f, -0.03080650f, 0.03843279f, -0.00463004f, -0.01301921f, 0.03523034f, -0.00092402f, 0.04062055f, 
    -0.04123736f, 0.00582208f, -0.00405956f, 0.01433583f, 0.00217284f, 0.04189769f, -0.04153517f, -0.00292235f, 
    0.00757115f, -0.02369870f, -0.06581086f, -0.01193782f, 0.02707781f, -0.05786004f, -0.03306775f, -0.04152337f, 
    0.02081066f, 0.03102229f, -0.04740698f, -0.00498330f, 0.02142776f, 0.03696324f, 0.01984937f, -0.00295517f, 
    0.00587127f, 0.04896108f, -0.01123211f, -0.00501062f, 0.05281479f, 0.04057214f, -0.02452436f, -0.00758867f, 
    -0.03993239f, -0.02339560f, 0.01377132f, -0.02966138f, -0.02308314f, 0.00258247f, 0.01941985f, -0.05437656f, 
    0.00214833f, -0.03794371f, -0.00352425f, -0.05173409f, 0.03709426f, 0.01377823f, 0.01996509f, -0.05268576f, 
    -0.02395977f, -0.03540931f, -0.01245435f, -0.06209464f, 0.02422322f, -0.05317734f, 0.01578096f, -0.03141383f, 
    -0.05785002f, -0.02920826f, 0.04060209f, 0.04273314f, 0.02687797f, -0.01072715f, -0.01917769f, -0.04321494f, 
    0.03996849f, 0.03203745f, -0.04569812f, 0.01786719f, -0.01669878f, 0.02711316f, -0.04291982f, 0.00536920f, 
    0.02472553f, 0.03554137f, 0.03000837f, 0.02317543f, 0.00362696f, -0.05290969f, 0.01940131f, -0.02799177f, 
    0.03764283f, -0.00741691f, -0.04445206f, 0.02441211f, -0.01884180f, -0.05840405f, -0.04488784f, -0.00604081f, 
    0.00102038f, 0.03122598f, -0.03721022f, -0.01939751f, -0.00773161f, 0.02475853f, -0.01523553f, 0.00609694f, 
    0.03137752f, -0.00721106f, -0.05632200f, -0.04942285f, 0.04498184f, 0.02004646f, 0.04380841f, -0.04160659f, 
    0.03205869f, -0.00778872f, 0.02335981f, 0.01162065f, -0.05535024f, -0.00728515f, -0.04085868f, 0.01605556f, 
    0.04666721f, 0.04433470f, -0.03430932f, 0.01650313f, -0.04312396f, -0.01837687f, -0.02754028f, 0.03580446f, 
    -0.03063426f, 0.02305260f, 0.01037266f, -0.02001870f, -0.02412706f, 0.02525312f, -0.03184125f, 0.05496214f, 
    0.03900116f, -0.04093504f, 0.03005142f, 0.02867403f, -0.02156774f, -0.02063529f, -0.05187128f, -0.03936136f, 
    -0.02192275f, 0.01893521f, 0.00388424f, 0.03421354f, -0.01183144f, 0.01806108f, 0.01125412f, -0.04983910f, 
    -0.00619832f, 0.01930764f, 0.01263709f, 0.02103597f, -0.00802848f, 0.03679489f, -0.05271851f, -0.01266570f, 
    -0.06453996f, -0.00458640f, -0.05451832f, -0.01839647f, 0.01177143f, -0.04340004f, 0.03146911f, 0.02034440f, 
    -0.04220125f, -0.02284727f, -0.00784903f, 0.03312691f, -0.02751852f, -0.01404847f, 0.03740180f, 0.05055831f, 
    -0.05039214f, -0.04602728f, -0.01323482f, -0.04271437f, 0.00377579f, -0.02216376f, -0.02309566f, -0.02110096f, 
    -0.00618383f, 0.05382297f, -0.03907496f, -0.04839341f, 0.04903409f, -0.00078175f, 0.03902784f, 0.03041362f, 
    -0.04432399f, -0.06425700f, 0.03800712f, -0.05579240f, -0.04412678f, 0.01917713f, -0.05854722f, 0.04358252f, 
    -0.00804995f, -0.02973923f, -0.06042337f, -0.02817339f, -0.04159716f, -0.01392886f, -0.02726323f, -0.03501998f, 
    -0.02290601f, 0.01200540f, -0.01691876f, -0.05238426f, -0.06217420f, -0.03475638f, -0.01852416f, 0.01065215f, 
    0.02588489f, -0.04812066f, 0.03576297f, -0.01367812f, 0.04025860f, 0.01081171f, 0.03857282f, 0.02884962f, 
    -0.02417877f, -0.01092558f, -0.06003093f, 0.00015562f, 0.00306446f, -0.02312186f, 0.00890500f, 0.04641841f, 
    -0.03948597f, 0.04271086f, -0.03415348f, 0.03651385f, 0.02481928f, -0.04616202f, 0.03662921f, 0.04890871f, 
    -0.06252272f, -0.00586401f, -0.06229649f, -0.04522303f, -0.00796038f, 0.02610924f, -0.00370615f, -0.02993670f, 
    0.00078595f, -0.06200717f, -0.01336136f, 0.04141821f, -0.02223252f, 0.02709332f, 0.00599435f, -0.05065883f, 
    -0.04433411f, -0.05744779f, -0.06095939f, -0.01294200f, 0.03605423f, 0.00576187f, -0.02048485f, -0.01659601f, 
    -0.28158021f, 0.06937899f, 0.08122241f, -0.29820940f, 0.26835361f, -0.02831754f, -0.17380127f, 0.06745511f, 
    -0.18992241f, 0.01554080f, 0.14393830f, -0.06596260f, 0.04417399f, 0.14268826f, 0.03604979f, 0.18107638f, 
    0.09929765f, 0.11019567f, -0.02207783f, 0.27290937f, 0.10137323f, -0.01772348f, 0.02968678f, 0.12098900f, 
    -0.04570736f, 0.10119993f, 0.09656267f, 0.15639557f, 0.11999420f, -0.25739810f, 0.03611441f, -0.07591801f, 
    0.05871116f, 0.06117238f, 0.10706778f, -0.13393493f, 0.11657748f, -0.12035572f, 0.10345882f, -0.01834792f, 
    0.40001464f, 0.19600293f, -0.27941680f, -0.17468792f, 0.11997392f, -0.09614398f, -0.09482940f, 0.04233021f, 
    -0.00405529f, 0.16764759f, 0.03564335f, 0.12231549f, -0.19475156f, -0.10308836f, -0.15763484f, 0.04482035f, 
    -0.26110300f, -0.14348520f, -0.00982648f, -0.18259700f, 0.31169236f, 0.40278414f, -0.12770247f, -0.31171030f, 
    0.16316091f, -0.03241448f, 0.12376623f, 0.04792089f, -0.11962458f, -0.08425856f, 0.01537952f, 0.00345683f, 
    -0.08432756f, 0.03856269f, 0.16534536f, -0.01725733f, -0.00333409f, -0.30134740f, 0.07223459f, -0.02247185f, 
    -0.05367188f, 0.21125206f, -0.02151169f, 0.36383969f, 0.06995974f, 0.05037163f, 0.00396605f, 0.40329447f, 
    -0.26915234f, -0.18113723f, -0.05655431f, 0.00673395f, -0.02032608f, 0.05935307f, 0.14987275f, -0.01381174f, 
    0.13076991f, -0.03004025f, 0.04663457f, -0.10170768f, -0.21160008f, 0.06793990f, 0.13152322f, -0.00584633f, 
    0.07779140f, -0.10852670f, -0.33091190f, -0.21915601f, -0.11460099f, -0.25891072f, -0.02853002f, -0.03491015f, 
    -0.07682859f, 0.09534529f, 0.05478180f, 0.04922477f, 0.01481869f, -0.07421678f, -0.20906454f, -0.06881724f, 
    -0.08869906f, 0.26897755f, 0.30230692f, -0.30454338f, 0.04520030f, -0.30064571f, 0.03703056f, 0.01569794f, 
    -0.07827318f, -0.25230864f, -0.05015207f, 0.04553808f, 0.19188620f, -0.02426378f, 0.08584625f, -0.19953550f, 
    0.05777571f, -0.13727599f, -0.18171069f, -0.18782373f, -0.39909667f, -0.36720827f, -0.09323069f, 0.16578969f, 
    -0.04277908f, -0.14307985f, -0.14227010f, 0.08126577f, -0.08583820f, -0.14383465f, 0.04488593f, 0.21154174f, 
    -0.05233228f, 0.05935297f, -0.06926519f, -0.04104054f, -0.04775285f, -0.15422253f, -0.39891148f, -0.17333189f, 
    0.37996939f, -0.15296586f, -0.00050478f, -0.04048017f, 0.27052826f, 0.15839759f, 0.09068795f, 0.25173026f, 
    0.06291749f, 0.08354281f, 0.03263255f, -0.03373701f, 0.12431879f, 0.17718858f, 0.08126047f, -0.00588343f, 
    -0.01860549f, 0.10487427f, 0.07659066f, 0.29618528f, 0.52701730f, -0.12701112f, -0.00376586f, 0.10339168f, 
    0.17535339f, -0.01556912f, -0.09518537f, -0.03504887f, 0.01341575f, -0.12293661f, 0.02752211f, 0.12222124f, 
    -0.10115849f, -0.03377487f, 0.04789524f, -0.05785153f, -0.12084536f, -0.25401759f, 0.33409306f, -0.28304428f, 
    0.34959993f, -0.42623806f, 0.00127219f, -0.06284220f, -0.01513832f, 0.09890693f, 0.08036429f, 0.09759011f, 
    0.02502155f, -0.17274176f, -0.08192668f, -0.05695145f, 0.15664399f, 0.03665993f, 0.00325792f, 0.12020429f, 
    0.07673120f, -0.06383071f, 0.08426339f, 0.20781179f, 0.35294986f, -0.02765118f, 0.18625377f, -0.17430277f, 
    0.29033518f, -0.00931236f, 0.06101690f, 0.02919411f, 0.02335049f, -0.28421181f, -0.03877704f, 0.01363411f, 
    -0.01064060f, 0.10347322f, 0.19573508f, 0.12139585f, -0.19431482f, 0.01043027f, 0.05664271f, 0.00501887f, 
    -0.40793720f, -0.14202233f, 0.51793981f, 0.25187936f, -0.18502448f, 0.05486702f, -0.02451641f, 0.04089226f, 
    0.12094025f, -0.19128603f, 0.05439391f, -0.00778408f, 0.03687882f, 0.03078295f, 0.06931058f, 0.14561577f, 
    0.15627678f, 0.13755454f, 0.18901151f, 0.21791597f, 0.17601877f, 0.12149875f, -0.05676123f, -0.09625234f, 
    -0.12785101f, -0.04525380f, -0.37648079f, 0.16143434f, 0.08565959f, -0.31633097f, -0.01084848f, -0.02941420f, 
    -0.02628266f, -0.11635478f, 0.12591273f, -0.11617832f, -0.17059581f, -0.17865492f, -0.02595236f, -0.07974476f, 
    0.55257070f, 0.41383103f, -0.22784816f, -0.17301771f, 0.13637832f, -0.00865142f, -0.00359702f, -0.06463969f, 
    0.16277137f, 0.20934483f, -0.10683673f, 0.11674201f, 0.08522824f, 0.04440794f, 0.03004353f, 0.03156183f, 
    -0.03442886f, 0.11831809f, 0.18101308f, 0.17974807f, 0.10554916f, 0.19113387f, -0.13100907f, -0.24286579f, 
    0.23845236f, -0.11870962f, 0.01316002f, -0.00631867f, -0.07158605f, -0.02125479f, 0.00035025f, -0.08808617f, 
    -0.04546470f, 0.02599095f, -0.05366958f, 0.04734024f, -0.02728534f, 0.03569086f, 0.05332262f, 0.10241015f, 
    -0.22055659f, 0.11534517f, -0.02654758f, 0.30439126f, 0.11470281f, -0.05201200f, 0.03143248f, 0.04514720f, 
    -0.15171285f, 0.00158215f, 0.21638124f, 0.05895721f, -0.01007017f, 0.06301228f, -0.02701541f, 0.12335547f, 
    0.20042992f, 0.08673607f, 0.15907811f, 0.34919187f, 0.15101770f, 0.33970833f, -0.07027759f, 0.01579631f, 
    -0.06525559f, 0.00646611f, -0.04092850f, -0.08965220f, 0.03663681f, -0.06599254f, -0.01591366f, -0.08039664f, 
    0.10844372f, 0.09340946f, 0.12468542f, -0.02628236f, 0.01497143f, 0.01007060f, -0.03770048f, -0.01015203f, 
    0.29025999f, -0.12062067f, 0.08743048f, 0.05525564f, 0.22433025f, 0.09074670f, -0.08391473f, 0.27380103f, 
    -0.02426746f, 0.21308252f, 0.12230153f, 0.01460049f, -0.08983488f, -0.00043568f, -0.08708584f, -0.08183415f, 
    -0.05905449f, 0.09487465f, -0.04900874f, -0.20793483f, 0.07606412f, 0.43497863f, -0.20448226f, 0.01501460f, 
    -0.46308544f, 0.11847802f, -0.14171962f, 0.04173460f, -0.16557679f, -0.14180143f, 0.01346821f, -0.02601520f, 
    -0.00198466f, 0.07128489f, 0.04990281f, -0.09481583f, -0.08765722f, -0.02591070f, -0.06462536f, -0.02378839f, 
    -0.52969664f, -0.03376586f, 0.23741254f, -0.32264072f, 0.09446336f, -0.06625709f, -0.19416611f, 0.22778797f, 
    -0.06090147f, -0.25985190f, -0.13504933f, 0.10521124f, 0.11252338f, 0.05145828f, 0.08785444f, 0.00029102f, 
    -0.10740744f, 0.01704734f, -0.10323568f, -0.13836746f, -0.20454909f, -0.14975148f, -0.06729782f, -0.06511504f, 
    0.17083046f, 0.28868264f, -0.01816262f, 0.08853201f, -0.25647956f, -0.20704602f, 0.12896582f, 0.02458662f, 
    0.02310348f, 0.09044649f, 0.05606102f, 0.02813233f, -0.00218147f, -0.01181841f, -0.14722238f, -0.23026805f, 
    0.05994507f, -0.10596820f, 0.24166115f, -0.45865259f, -0.01884378f, 0.17907487f, 0.09020897f, -0.15814102f, 
    -0.10354294f, -0.10592482f, 0.05277489f, 0.03991925f, 0.02240214f, -0.01323598f, 0.01670613f, -0.12992655f, 
    0.02163002f, -0.18863748f, -0.13920647f, -0.22546256f, -0.12311056f, -0.10662683f, 0.19667470f, 0.00235040f, 
    0.10990816f, 0.01892238f, -0.25159314f, 0.19731487f, -0.23436049f, 0.03060711f, 0.13501032f, -0.00700507f, 
    -0.27091524f, -0.32537103f, -0.09581647f, -0.16052601f, -0.41265586f, -0.28071499f, -0.37673447f, -0.47475871f, 
    -0.06614094f, 0.08607899f, -0.09898389f, 0.25509238f, 0.28066093f, 0.13538165f, 0.18184249f, 0.00959937f, 
    0.03323722f, 0.20512968f, -0.00882984f, 0.15556817f, 0.02873140f, 0.28215933f, 0.14350107f, -0.05763832f, 
    0.25501952f, 0.07469808f, 0.10317124f, 0.25801349f, 0.29310146f, 0.24526294f, 0.46206445f, -0.19977422f, 
    0.02515477f, 0.00402910f, 0.00816382f, -0.17302079f, -0.11733305f, 0.09529377f, 0.08909480f, 0.04295815f, 
    0.11894769f, 0.16066936f, -0.04556131f, 0.11952049f, -0.43122211f, -0.22726512f, -0.33114421f, -0.28997612f, 
    0.33364135f, 0.00449406f, -0.22860651f, 0.17606582f, 0.00342986f, 0.04927700f, -0.08263271f, -0.04550222f, 
    0.08655754f, -0.03989735f, 0.08021390f, -0.12494287f, 0.09182794f, 0.03380055f, 0.10040580f, -0.18141432f, 
    0.13479139f, 0.09804723f, 0.08962894f, 0.10475770f, 0.10137388f, 0.33550346f, 0.34398100f, 0.16963209f, 
    0.34754544f, 0.17619234f, -0.08447395f, -0.18811345f, 0.08271956f, -0.31001499f, 0.07123431f, 0.00136993f, 
    0.04761682f, 0.10334972f, 0.19104841f, 0.02394945f, 0.00309122f, -0.00923158f, 0.07284588f, 0.14623898f, 
    0.20589356f, 0.13374273f, -0.13108306f, 0.10492010f, -0.13248610f, -0.05729335f, -0.23636721f, 0.19483422f, 
    0.15262696f, -0.04859320f, -0.03809261f, 0.13814104f, 0.04565494f, -0.22061868f, -0.01241861f, 0.02343627f, 
    0.27907822f, 0.20488781f, 0.10679640f, 0.16089690f, 0.12324882f, 0.32633775f, -0.30202582f, -0.09179271f, 
    -0.15145904f, 0.19909412f, -0.23152682f, 0.03635537f, -0.26984298f, -0.23768887f, 0.04442202f, 0.09679179f, 
    0.09130805f, -0.08757088f, 0.19276819f, 0.03282454f, -0.15930443f, -0.09917627f, -0.10877952f, -0.38848615f, 
    0.01370306f, 0.24487573f, 0.14992362f, 0.01417813f, 0.14804387f, -0.09712140f, 0.12571064f, 0.02641740f, 
    -0.05793366f, 0.12568939f, 0.02388877f, 0.10446616f, -0.06738067f, -0.00768496f, -0.19993249f, 0.03108836f, 
    0.15274906f, 0.06681632f, 0.13764879f, 0.30088076f, 0.00808374f, -0.00972230f, -0.06528620f, 0.13068014f, 
    0.05296031f, 0.12030174f, -0.13405065f, -0.01921656f, 0.01099669f, 0.00992847f, 0.09331525f, -0.01864264f, 
    0.03835478f, 0.08525100f, 0.01359382f, -0.02836466f, 0.15101685f, 0.18075247f, -0.03367847f, 0.22397833f, 
    0.72466886f, -0.22227970f, 0.23191023f, -0.02879082f, -0.01517867f, 0.15817568f, 0.05110722f, 0.17999384f, 
    0.17790693f, 0.02511111f, 0.01727879f, 0.13880925f, -0.00049580f, -0.00358555f, 0.10993363f, -0.03544824f, 
    -0.06388000f, 0.03314428f, -0.04416006f, 0.00112249f, 0.10960962f, 0.02430727f, -0.47272336f, -0.15440145f, 
    -0.11770031f, -0.12318843f, -0.13712336f, -0.18109429f, -0.19243252f, -0.08125852f, -0.02847763f, 0.15480869f, 
    -0.13079089f, 0.02300919f, -0.02180281f, -0.01912785f, 0.02140280f, 0.30734634f, -0.04727095f, -0.05687723f, 
    0.38156876f, 0.29949152f, 0.43611962f, -0.25048980f, -0.28650928f, 0.00289186f, 0.02868471f, 0.04725571f, 
    0.19701712f, 0.21171570f, 0.10750435f, -0.01761439f, 0.03717955f, 0.02771541f, -0.00082673f, 0.01658527f, 
    0.10128210f, -0.03229227f, 0.33161438f, 0.03736144f, -0.22287621f, 0.02900251f, 0.20481873f, 0.26550618f, 
    -0.52356327f, -0.04816763f, -0.24303304f, -0.08480733f, 0.35293257f, -0.20055203f, 0.09397085f, 0.04943478f, 
    -0.16175215f, -0.13701771f, 0.16812615f, 0.11244880f, 0.10608210f, 0.02289093f, 0.05553867f, 0.05409811f, 
    -0.29592288f, -0.82608366f, -0.26436350f, -0.14602518f, -0.03694661f, 0.06680132f, -0.07469395f, -0.00329106f, 
    -0.04464111f, -0.08359537f, 0.11106058f, 0.21712825f, -0.04465340f, -0.02487995f, 0.01230526f, -0.11176305f, 
    -0.03649448f, -0.05775902f, 0.14573105f, 0.02512672f, -0.34671307f, 0.06351680f, 0.03962163f, 0.24667630f, 
    -0.12353285f, 0.00946112f, 0.16182102f, 0.02830166f, 0.00610233f, -0.09771737f, 0.12578176f, -0.13479869f, 
    0.03612740f, -0.00450677f, 0.12268020f, -0.00849226f, -0.00244412f, 0.00535253f, -0.15281007f, 0.07101253f, 
    0.12658568f, -0.07023217f, -0.09770514f, 0.13875845f, -0.14410503f, -0.02073020f, -0.00309829f, 0.08343446f, 
    -0.00967994f, 0.01917588f, 0.13454124f, 0.04820564f, -0.14790507f, 0.05187679f, 0.13744365f, -0.05393576f, 
    0.02737587f, 0.02106137f, 0.18445309f, 0.29596415f, 0.26607022f, -0.05627828f, 0.33329770f, 0.06602714f, 
    -0.32687089f, -0.07441738f, -0.14281604f, -0.05949582f, -0.01304713f, -0.09607431f, -0.09865737f, -0.02815069f, 
    0.16499017f, -0.15912263f, -0.06045194f, 0.00117761f, 0.11787714f, -0.08452174f, 0.03692858f, 0.12730807f, 
    0.17590117f, 0.27296323f, -0.51383185f, -0.28438401f, -0.12352853f, -0.10930405f, 0.06780551f, -0.04774531f, 
    -0.07132795f, 0.10775529f, -0.02643286f, 0.07323325f, -0.10431655f, 0.08936173f, 0.02810334f, -0.01893396f, 
    0.01764799f, 0.12582633f, 0.07367498f, -0.07487381f, 0.04404714f, 0.11478210f, -0.13979961f, -0.13636792f, 
    -0.11281132f, -0.20625651f, 0.00053066f, 0.07297142f, -0.00370548f, 0.16336867f, 0.22987543f, -0.05008023f, 
    -0.08249825f, -0.14929315f, 0.00289179f, -0.12047905f, 0.12579130f, 0.14722811f, -0.12173080f, 0.12370491f, 
    0.24758208f, 0.28002173f, -0.37079328f, -0.00282281f, -0.04783420f, -0.31134877f, -0.02614239f, -0.05642302f, 
    0.02334040f, -0.04922417f, 0.06196625f, 0.12828945f, -0.17013320f, -0.00684741f, -0.07959961f, -0.12089933f, 
    0.03024109f, 0.17766982f, -0.15441169f, -0.12130065f, 0.18486710f, -0.36301222f, -0.52531469f, -0.13100556f, 
    -0.26970047f, -0.00735630f, -0.00271448f, -0.05577226f, -0.04415999f, -0.02917615f, 0.27571025f, 0.01142024f, 
    0.10593501f, -0.05973828f, -0.06528392f, -0.03531912f, 0.08683167f, -0.07918452f, 0.01280364f, -0.04253005f, 
    0.26858085f, 0.23815669f, 0.01650016f, 0.27461115f, 0.39062271f, -0.02945536f, 0.06893284f, 0.01740406f, 
    -0.01288649f, -0.09896859f, -0.05316579f, 0.02973205f, 0.08480565f, 0.15964209f, 0.15101925f, -0.16629495f, 
    0.11765136f, -0.12564285f, -0.24190390f, -0.06431416f, -0.17328461f, 0.09851526f, -0.00720187f, 0.10256191f, 
    -0.08145547f, 0.16495584f, 0.16955204f, 0.06612207f, -0.07084939f, -0.06638836f, 0.06579811f, 0.08571880f, 
    -0.05916261f, 0.24060063f, 0.14852595f, -0.05128910f, 0.14188513f, 0.23994397f, 0.03929278f, 0.02372532f, 
    0.02416358f, 0.12015770f, -0.02955102f, -0.31078359f, -0.18967628f, -0.00349051f, -0.03613992f, 0.06544223f, 
    0.02798492f, 0.13709524f, 0.01567996f, -0.11676151f, -0.02537655f, 0.14525013f, 0.04672379f, 0.06827703f, 
    0.06007369f, -0.09326225f, 0.09372196f, 0.16673923f, 0.56753194f, 0.12751922f, 0.43655393f, 0.04198608f, 
    -0.20102164f, 0.11803367f, 0.09416001f, 0.20598920f, 0.12609187f, 0.17993489f, 0.20154065f, 0.16636278f, 
    -0.05360801f, 0.11446152f, 0.01218871f, 0.11793239f, 0.04365213f, -0.04907391f, 0.00211415f, -0.04305008f, 
    -0.33898199f, 0.32919031f, -0.21607764f, 0.26852515f, -0.11343633f, 0.01422695f, 0.25005516f, -0.06954046f, 
    0.11936779f, 0.00325223f, -0.07703818f, -0.10873186f, 0.07232958f, 0.03012460f, -0.08179468f, 0.04820815f, 
    0.29575121f, 0.03787975f, 0.23348439f, 0.21647979f, -0.20722328f, 0.14787608f, 0.42827833f, -0.14448826f, 
    0.20546210f, -0.02945503f, -0.02149068f, 0.04677449f, 0.02768575f, 0.10713343f, 0.01776369f, 0.07291202f, 
    -0.07104251f, 0.14160417f, -0.02855065f, 0.05212191f, 0.04387711f, -0.00449986f, -0.03155564f, -0.06754599f, 
    -0.56446421f, -0.16306147f, -0.01694865f, -0.08524194f, 0.19463331f, 0.08997619f, 0.01659738f, 0.15049896f, 
    -0.05045572f, 0.04309777f, -0.05611051f, 0.08970435f, -0.04077296f, 0.07140713f, 0.01677893f, -0.00724988f, 
    -0.07382192f, 0.07193844f, 0.29720896f, 0.04364127f, -0.49016494f, -0.35109738f, 0.19515990f, -0.14429231f, 
    0.17395951f, -0.04542203f, 0.09115205f, -0.08772338f, -0.08651949f, 0.03122790f, 0.07851935f, -0.09836190f, 
    -0.19277668f, 0.25240478f, -0.00173456f, -0.03054975f, 0.14273511f, -0.04979710f, 0.20737663f, 0.05100285f, 
    -0.44716400f, 0.42092910f, 0.05962320f, -0.16402856f, 0.13048398f, -0.09749219f, 0.06569158f, -0.17998284f, 
    0.27432352f, 0.06921146f, 0.15386273f, -0.17627667f, 0.10336486f, 0.22871552f, 0.06448530f, 0.07603049f, 
    -0.01584219f, 0.15191789f, -0.06985331f, 0.06592906f, 0.17012617f, -0.20030659f, -0.10007748f, -0.20202848f, 
    -0.00522780f, 0.07571010f, 0.01602578f, 0.12599260f, 0.03947191f, 0.10567430f, -0.01982242f, -0.03751850f, 
    -0.15599370f, -0.04650423f, -0.07165013f, -0.00650648f, -0.05993269f, 0.03528285f, -0.06029636f, 0.01613846f, 
    -0.08165731f, -0.13678551f, -0.05756774f, 0.01702091f, 0.01180161f, 0.03895348f, -0.02406046f, -0.02328655f, 
    0.01496835f, 0.14875868f, -0.14153312f, -0.00625575f, 0.21538456f, -0.04651204f, -0.13455713f, 0.10863353f, 
    -0.05347787f, 0.00429071f, -0.16556060f, 0.01852136f, 0.07423083f, 0.19303770f, 0.04265282f, -0.28892291f, 
    0.10021991f, -0.01826688f, -0.17687161f, -0.07777010f, 0.12796222f, 0.03279143f, 0.05620297f, 0.15216552f, 
    -0.18904397f, -0.12575726f, 0.11376300f, 0.02030813f, -0.02529893f, 0.02386274f, 0.19693448f, -0.03600248f, 
    -0.31413093f, -0.12298052f, -0.03994768f, 0.28176859f, 0.31448299f, 0.09317637f, 0.11698126f, 0.01418225f, 
    -0.08029348f, 0.01338142f, 0.02696821f, 0.05195852f, 0.16421241f, 0.07133627f, -0.14051668f, 0.01701681f, 
    0.07542680f, 0.07706882f, 0.11482929f, -0.07434975f, -0.32785690f, 0.03808066f, 0.34344643f, 0.03387443f, 
    -0.08304431f, -0.04290247f, -0.16378096f, -0.24754684f, -0.19467105f, 0.03747395f, 0.06204944f, 0.07690890f, 
    0.05702872f, -0.00617528f, 0.10846718f, 0.12385242f, -0.03966208f, 0.00478757f, -0.12054580f, 0.09372354f, 
    -0.03701347f, 0.01048608f, 0.24184887f, 0.14008437f, 0.25399220f, 0.23120283f, -0.00762183f, -0.07628678f, 
    0.10656855f, 0.17357685f, 0.14716363f, 0.04024689f, 0.25604913f, 0.10194309f, 0.07928450f, -0.06428178f, 
    0.02782562f, 0.23973523f, 0.05356826f, -0.00624934f, -0.53584015f, 0.31402382f, 0.33417225f, 0.28881267f, 
    0.20530833f, 0.06449070f, 0.01701941f, -0.19432877f, -0.08172882f, -0.11568799f, -0.06990141f, 0.02922597f, 
    -0.04477478f, -0.04170471f, 0.15331268f, 0.09973504f, 0.02834486f, -0.04918359f, 0.03881653f, 0.11123271f, 
    -0.07600349f, 0.01730870f, -0.40606847f, -0.40321442f, 0.05814370f, 0.01626707f, -0.07797071f, 0.01907912f, 
    0.09418300f, -0.10551755f, -0.03980648f, 0.01777591f, 0.05035213f, -0.06414599f, -0.27084258f, 0.24153775f, 
    0.05506951f, 0.20962417f, 0.03573366f, 0.10668647f, -0.01570284f, -0.05344010f, 0.06788083f, 0.04206748f, 
    0.05911803f, -0.01333176f, -0.06871697f, -0.01625257f, 0.10159451f, 0.05341956f, 0.17109942f, 0.04309119f, 
    0.11746123f, -0.20301341f, 0.05522734f, 0.10641933f, 0.00593580f, -0.01661956f, -0.00532259f, 0.05350566f, 
    -0.08576631f, -0.26099163f, 0.09884721f, 0.17562920f, 0.00185981f, -0.03572899f, 0.15686803f, -0.08966130f, 
    -0.19509070f, -0.01328715f, -0.08099303f, 0.01450246f, 0.12676331f, 0.28060785f, -0.05391083f, 0.03535769f, 
    0.04553023f, 0.02378735f, 0.06136773f, 0.07532548f, -0.30351600f, -0.17252807f, -0.28343388f, 0.02745951f, 
    0.05223062f, 0.01542482f, 0.01944028f, 0.01853950f, 0.05540884f, -0.07094783f, -0.14897203f, -0.08493478f, 
    -0.01753023f, 0.16901365f, 0.09315868f, -0.03769881f, -0.04177136f, -0.13481995f, 0.27971023f, 0.05273087f, 
    0.60219675f, -0.26037729f, 0.03305213f, -0.02632670f, -0.09460287f, 0.07541013f, 0.01043794f, 0.21863519f, 
    0.19378512f, 0.03190975f, -0.13506089f, -0.02333054f, -0.09127018f, -0.11022193f, -0.03780635f, 0.06749833f, 
    -0.14249624f, 0.00494776f, 0.00981793f, 0.04164184f, -0.14597972f, -0.09697866f, -0.32562798f, -0.04543036f, 
    -0.06855553f, -0.03987810f, -0.13102813f, -0.02621858f, -0.03559040f, -0.07761452f, 0.10656504f, 0.04457609f, 
    -0.07052688f, 0.01684988f, 0.00711678f, 0.19435538f, -0.06746908f, 0.07284211f, -0.10958587f, -0.00492572f, 
    0.15837739f, 0.32722417f, 0.56297123f, 0.05351161f, -0.08281229f, -0.17850097f, -0.11601903f, -0.02508251f, 
    0.03209854f, 0.06921981f, 0.04294246f, 0.00742506f, -0.04356390f, -0.10905260f, 0.06088476f, -0.14049983f, 
    -0.09123582f, -0.05604369f, -0.06456355f, -0.12246712f, -0.43370989f, -0.47803897f, -0.05790102f, 0.12717699f, 
    0.02802050f, 0.03753346f, 0.06457227f, 0.18968514f, 0.15817343f, -0.11645377f, 0.23412797f, -0.10405102f, 
    -0.04180391f, -0.04692717f, 0.08597642f, -0.02578829f, 0.08589269f, -0.03402878f, -0.07185546f, 0.03276592f, 
    0.12206150f, -0.70271456f, -0.11789218f, -0.07672117f, -0.32098716f, -0.01241609f, 0.06510356f, -0.08273710f, 
    0.22818574f, -0.17564258f, 0.04323128f, -0.00557523f, -0.11828532f, 0.08135647f, -0.00665899f, 0.01183030f, 
    0.02371549f, 0.02698991f, -0.02130664f, -0.09285761f, 0.24197131f, 0.22837411f, 0.28634205f, 0.15761165f, 
    -0.07838470f, 0.04551556f, 0.19410306f, 0.08935102f, 0.15362397f, -0.03354591f, -0.01040439f, 0.03782348f, 
    0.01922975f, 0.02651165f, -0.03290401f, 0.12168077f, 0.20381053f, 0.00735756f, -0.04941267f, 0.08399031f, 
    0.02761094f, -0.04239723f, -0.17034763f, 0.32283580f, -0.23474433f, 0.03110900f, 0.01569415f, 0.15342671f, 
    -0.04130844f, -0.01889561f, 0.08863317f, 0.13239288f, -0.00858592f, 0.15994866f, -0.02392569f, -0.00439610f, 
    -0.12592639f, 0.07701650f, -0.02135771f, -0.09384927f, 0.29251030f, 0.05571176f, 0.36353207f, 0.10227820f, 
    0.02976475f, -0.02185845f, 0.04654124f, -0.10572676f, 0.02590423f, -0.25279796f, -0.05590583f, 0.06688976f, 
    0.18804279f, 0.00430121f, 0.11129852f, 0.01953005f, -0.01299769f, 0.02400844f, -0.07817187f, -0.04206330f, 
    0.10439501f, 0.07979039f, -0.31307432f, 0.01005064f, -0.26136205f, -0.12384180f, 0.13947281f, 0.01357652f, 
    -0.01680273f, 0.17249225f, -0.11580998f, -0.10096678f, 0.04434692f, 0.08391453f, 0.08475712f, 0.05296640f, 
    0.04808544f, 0.06426582f, 0.05192548f, 0.03358844f, -0.08947332f, 0.01955671f, -0.26110074f, 0.11640868f, 
    -0.08669629f, -0.15495077f, -0.11328331f, 0.00392075f, 0.03897421f, 0.09384731f, 0.02916268f, -0.07848332f, 
    0.00199019f, -0.08092945f, 0.11828659f, -0.00052991f, 0.01356426f, -0.01362475f, -0.16467854f, -0.14101343f, 
    -0.38799781f, 0.05041233f, -0.07027347f, 0.03328230f, -0.03981382f, -0.03854531f, -0.02189765f, -0.08982915f, 
    0.02258634f, 0.07882338f, -0.01581371f, 0.09353315f, -0.01743079f, 0.12320071f, 0.03100749f, 0.00243724f, 
    -0.08710671f, 0.07813973f, 0.02390737f, 0.02251315f, 0.09706213f, -0.25205895f, -0.56036049f, 0.11105062f, 
    -0.48529032f, -0.00388432f, -0.15093227f, 0.13728085f, 0.03026921f, 0.10441072f, 0.21529338f, -0.04905779f, 
    0.02361762f, 0.05152475f, -0.11606198f, -0.06260897f, -0.00413052f, 0.01656989f, -0.08258935f, -0.04908015f, 
    0.21161135f, 0.04469046f, 0.00428848f, -0.00690430f, 0.38283283f, 0.06784873f, -0.04133630f, -0.25710541f, 
    0.17345849f, -0.04481979f, -0.11587904f, -0.07661595f, -0.09305133f, -0.11453517f, -0.04381270f, -0.17169741f, 
    0.03128840f, -0.05501417f, 0.07488667f, 0.01304752f, -0.16941918f, -0.02483118f, 0.18040465f, 0.07046607f, 
    0.08330461f, -0.00382220f, 0.24880020f, -0.10923131f, 0.09141780f, 0.00295593f, -0.01348761f, 0.17158350f, 
    0.09179430f, 0.16717765f, 0.01140950f, -0.03748735f, 0.16945785f, -0.10809631f, 0.07145839f, -0.06448238f, 
    -0.28018996f, -0.55695945f, -0.23967633f, 0.05024319f, -0.15579501f, 0.08018562f, 0.07094119f, 0.26853991f, 
    -0.09956932f, 0.13037042f, 0.02161949f, -0.07375442f, 0.03559893f, 0.01460586f, 0.05447438f, 0.08813698f, 
    0.12327053f, 0.11661793f, 0.05817084f, 0.07818183f, 0.25993115f, -0.02857014f, 0.52240950f, -0.05875062f, 
    -0.08205459f, 0.01719335f, 0.01473162f, 0.15430465f, 0.12159612f, 0.11686374f, -0.00358910f, 0.02685147f, 
    0.07371294f, 0.07182989f, 0.04054493f, 0.04262411f, 0.07322042f, -0.00663244f, 0.05779992f, 0.12242920f, 
    0.54480851f, -0.25199857f, 0.05815322f, -0.32659364f, 0.01797263f, -0.06940830f, 0.03795918f, 0.03621593f, 
    0.16894291f, -0.02804405f, -0.03370288f, -0.00406725f, -0.00979533f, 0.01218390f, 0.08886605f, -0.09343949f, 
    -0.16849194f, -0.04526406f, -0.09124836f, -0.20346957f, 0.01611516f, -0.52075797f, -0.10696150f, 0.02391604f, 
    -0.02542734f, -0.11892062f, -0.05669846f, -0.01443074f, 0.05942670f, -0.06943528f, 0.02833598f, -0.08499514f, 
    -0.00766225f, -0.10213253f, -0.05175262f, 0.11875275f, -0.00246692f, -0.20081916f, 0.00255621f, -0.00021198f, 
    0.08316820f, 0.25201914f, 0.04995100f, 0.27843210f, -0.03949047f, -0.04606354f, 0.09705291f, -0.13041301f, 
    0.06933694f, -0.04592048f, -0.07997054f, -0.10197183f, 0.18295760f, 0.04876190f, 0.09568077f, -0.10557998f, 
    0.06444538f, -0.02767580f, -0.26931515f, 0.10163042f, -0.11782009f, -0.40905416f, 0.06467356f, 0.25157198f, 
    0.40875012f, 0.04261761f, 0.00790569f, 0.11391240f, 0.22180457f, 0.05396747f, 0.07741153f, 0.02604152f, 
    0.10318030f, 0.06947876f, 0.04285530f, -0.09166687f, -0.00534857f, 0.11897362f, 0.00154900f, 0.04819329f, 
    1.10819781f, -0.18991786f, 0.04741731f, 0.25992447f, -0.06785915f, -0.01584173f, 0.00726269f, -0.11813321f, 
    -0.20751196f, 0.00063210f, -0.02804069f, -0.04795993f, -0.06358588f, 0.01395366f, -0.03941470f, 0.01470192f, 
    -0.01491076f, -0.07510738f, -0.06665841f, -0.01997059f, 0.31168768f, 0.34200096f, 0.20112424f, 0.22943464f, 
    0.15015979f, 0.02032486f, 0.03087169f, -0.18129347f, -0.04695472f, -0.03163350f, 0.07140259f, 0.10026406f, 
    0.06984805f, 0.02661292f, 0.06402949f, 0.01143629f, -0.02035592f, -0.15425353f, -0.01640197f, 0.01342549f, 
    0.21887542f, -0.00512364f, -0.24842267f, 0.11012217f, 0.00971677f, -0.05951181f, -0.03695639f, 0.06654783f, 
    -0.07509663f, -0.04447897f, 0.08737970f, 0.08268845f, 0.12233381f, -0.06831549f, -0.16871670f, 0.03311880f, 
    -0.14201021f, 0.08658173f, 0.03163024f, -0.18342753f, 0.14120932f, -0.08109759f, 0.07930792f, 0.01690650f, 
    0.07243846f, -0.03779499f, 0.23860626f, -0.00400573f, -0.21376276f, 0.07268389f, -0.06884632f, -0.08030754f, 
    0.18977292f, 0.20280735f, 0.05413759f, -0.02839444f, 0.04530792f, 0.03654943f, -0.12613484f, 0.00494508f, 
    0.40576556f, 0.10441064f, 0.32839754f, -0.10710435f, -0.19382606f, 0.01710144f, -0.05303411f, 0.07148743f, 
    0.08413814f, -0.00778167f, 0.06727712f, -0.14401725f, 0.06035352f, -0.08633921f, -0.04995584f, 0.05604083f, 
    -0.16691616f, -0.11163427f, 0.10395589f, 0.01847031f, 0.01931355f, -0.09378011f, -0.41612548f, 0.02736743f, 
    0.01084913f, -0.00231650f, 0.11611214f, 0.15890174f, 0.20426084f, -0.06595993f, -0.05815473f, 0.04197113f, 
    -0.08799135f, 0.05912457f, -0.02684414f, -0.06712528f, 0.08429401f, -0.12170572f, 0.03076201f, -0.10690492f, 
    -0.65522730f, 0.05616496f, 0.16478680f, -0.08716040f, -0.07434770f, -0.05646902f, 0.05586365f, 0.10431448f, 
    -0.08179840f, -0.04797353f, -0.09337716f, 0.10737064f, -0.08389064f, 0.01079678f, 0.11019020f, 0.13490191f, 
    -0.14388299f, -0.15781389f, 0.00131021f, -0.02482672f, 0.05553589f, -0.40177676f, -0.59349090f, -0.14197668f, 
    -0.24585913f, -0.19350255f, -0.07771487f, 0.14053705f, -0.00334825f, 0.20867407f, 0.03932575f, 0.04482104f, 
    -0.14464223f, -0.02470504f, -0.17248178f, -0.02925599f, -0.03419136f, 0.02262760f, -0.04195238f, -0.08393487f, 
    0.00880717f, 0.38196662f, 0.42011589f, 0.07843912f, 0.10399112f, 0.04167393f, 0.05195646f, -0.13661280f, 
    0.00878599f, 0.07324179f, -0.04943074f, 0.02688913f, -0.00864785f, 0.09393327f, 0.08051240f, 0.02773646f, 
    -0.15549816f, -0.10379353f, 0.01113523f, -0.08149826f, -0.03231901f, -0.01255975f, 0.09570031f, 0.02283832f, 
    0.13770793f, -0.05232869f, 0.13164043f, -0.04301797f, 0.06082422f, 0.03120925f, 0.10504432f, 0.05708601f, 
    -0.03962849f, -0.08534569f, -0.12380119f, -0.07963996f, -0.09415079f, -0.22828078f, 0.04648122f, 0.01252704f, 
    -0.00557392f, -0.37919837f, 0.06422833f, -0.05922596f, 0.03699970f, 0.19631952f, -0.05931128f, 0.16910511f, 
    0.16546182f, -0.07270952f, 0.04459784f, 0.00730929f, 0.19988413f, 0.05383742f, 0.06061311f, -0.01863488f, 
    -0.14358917f, 0.04087009f, -0.10142162f, -0.15728056f, 0.02602841f, 0.18258491f, 0.33939666f, -0.13098897f, 
    0.03320672f, 0.03134168f, 0.13729733f, 0.02882785f, 0.15054649f, 0.17343493f, -0.06236552f, 0.02939505f, 
    0.10693177f, -0.03550239f, 0.10754269f, -0.03117069f, -0.01308956f, 0.14507473f, -0.02291702f, 0.02468607f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01052877f, -0.04729366f, -0.03565454f, -0.05610674f, 0.00000699f, 0.00487758f, 0.00525266f, -0.04001187f, 
    0.15535542f, 0.01703333f, 0.01292194f, 0.01157494f, 0.02142802f, 0.10186469f, -0.02882780f, -0.01619615f, 
    0.06343098f, 0.00447640f, -0.00172882f, 0.12743409f, 0.24779122f, 0.15789773f, -0.02870247f, 0.03760390f, 
    -0.06842742f, -0.01675027f, -0.12396244f, -0.04876732f, 0.07975456f, 0.06074307f, 0.16144291f, 0.16077316f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04908995f, -0.00874701f, -0.03568757f, 0.11896353f, 0.04296934f, -0.10573003f, -0.04862238f, -0.12141921f, 
    -0.04377513f, -0.10125978f, 0.11842908f, 0.01744458f, -0.09660394f, -0.09555934f, 0.12708881f, 0.12622899f, 
    -0.18955113f, -0.00502366f, 0.05285769f, -0.06943312f, -0.17511129f, -0.19090879f, -0.16199794f, 0.09068523f, 
    -0.14946488f, -0.07496407f, -0.01311048f, 0.10492550f, -0.04566687f, -0.08657017f, -0.08517516f, -0.06641724f, 
    -0.06131006f, 0.12479153f, 0.08012006f, -0.26159585f, 0.14385773f, -0.00528496f, -0.10405788f, -0.13130887f, 
    0.01057008f, 0.07943135f, 0.33212560f, -0.09245846f, 0.06672216f, -0.20378356f, 0.02741784f, -0.29517612f, 
    -0.09380928f, -0.08957350f, -0.15194570f, 0.09506800f, 0.31169379f, 0.11058418f, -0.04134860f, 0.13031571f, 
    0.07868532f, -0.17832176f, 0.10745794f, 0.23095194f, -0.21265048f, -0.09705398f, -0.21843983f, -0.45896864f, 
    0.02383099f, -0.09620637f, 0.00769298f, 0.33209348f, -0.13203152f, 0.01236981f, 0.02956780f, -0.14571796f, 
    -0.34014037f, 0.26128751f, 0.13755843f, 0.01268298f, -0.27079073f, 0.24145438f, 0.11256532f, 0.43394399f, 
    -0.24842373f, -0.12284598f, -0.08252613f, 0.35986227f, -0.08030396f, 0.15303376f, -0.12063951f, -0.10825595f, 
    0.18047825f, -0.08070228f, 0.13231149f, -0.30508327f, 0.18790270f, -0.01578406f, 0.38570312f, 0.05276455f, 
    -0.10736142f, 0.15490292f, 0.09614100f, -0.00233498f, 0.14821018f, 0.07575402f, 0.03930693f, 0.13217616f, 
    0.06748389f, -0.18022901f, -0.15987282f, -0.08658341f, -0.09483081f, 0.00645773f, -0.15186651f, -0.15248032f, 
    -0.05464494f, -0.13414189f, -0.15097633f, -0.09157498f, -0.09978206f, -0.10321870f, -0.07629513f, 0.00586832f, 
    0.07067695f, 0.05537616f, -0.12100586f, -0.11979952f, -0.26427260f, 0.06930131f, 0.12461377f, -0.14224340f, 
    -0.05208693f, 0.15019009f, 0.07725906f, -0.02102104f, -0.08634648f, -0.09804212f, -0.01249993f, -0.00843866f, 
    -0.09811445f, 0.10491900f, -0.27235883f, 0.09944804f, -0.11197415f, 0.01617194f, -0.15162601f, 0.30868244f, 
    -0.21794952f, -0.03560934f, 0.01485700f, -0.09953392f, 0.10881319f, 0.12251133f, 0.07602686f, -0.00529436f, 
    0.07362125f, -0.12054913f, 0.03898809f, 0.00600263f, 0.14683014f, 0.24367954f, -0.58760726f, -0.30988845f, 
    -0.11692747f, -0.12175609f, -0.06635104f, 0.04226141f, 0.02546706f, -0.15422393f, 0.15304494f, 0.11124606f, 
    0.10072567f, 0.28673422f, 0.13958313f, -0.08901450f, 0.10554408f, -0.22276431f, -0.05773889f, -0.00366843f, 
    -0.22680567f, -0.07707446f, 0.03171978f, -0.47792622f, 0.35452041f, 0.21962202f, 0.07115587f, -0.13847493f, 
    0.11995514f, 0.12104549f, 0.17132443f, 0.28505412f, -0.41618383f, 0.08657113f, -0.52200574f, -0.23910300f, 
    0.03973800f, 0.01616790f, -0.02381716f, -0.12755908f, 0.03689640f, -0.07268573f, 0.04652166f, 0.07093400f, 
    0.10485040f, -0.21120851f, 0.21177608f, -0.03779035f, -0.16199705f, 0.09552602f, -0.02218771f, -0.18133609f, 
    0.17182574f, -0.24833767f, -0.06809729f, 0.58145130f, 0.25284487f, 0.22500175f, 0.07769374f, -0.16361047f, 
    0.01461135f, -0.15255390f, -0.08622018f, -0.26865479f, -0.39148238f, 0.02498211f, 0.27296677f, 0.38102031f, 
    0.05249735f, 0.02671036f, 0.07938847f, 0.04536011f, 0.11700955f, 0.02372168f, 0.00213655f, 0.04414603f, 
    0.03075311f, -0.26483756f, 0.05782889f, -0.04508992f, -0.48119327f, 0.22724441f, 0.11289079f, -0.11589987f, 
    0.41803998f, -0.29189408f, -0.04890690f, -0.27360007f, 0.24913874f, 0.23945066f, 0.10373019f, 0.05149442f, 
    -0.09115873f, -0.14093694f, -0.49992594f, 0.19435744f, -0.16307509f, 0.33217743f, 0.09365217f, 0.00396507f, 
    -0.07444756f, 0.05834893f, -0.01903618f, 0.08301570f, 0.16289870f, -0.11823209f, -0.04094701f, 0.15823008f, 
    0.30140316f, 0.46926576f, -0.06973564f, -0.05310438f, 0.09674280f, -0.38085952f, -0.08635455f, 0.00961544f, 
    -0.03989859f, 0.12789266f, 0.09755003f, -0.65108734f, 0.18782184f, 0.09053513f, -0.09517878f, -0.05636778f, 
    -0.17212889f, -0.00747533f, -0.41280589f, -0.36309913f, 0.47417051f, -0.12793389f, -0.13144040f, 0.10129583f, 
    -0.11972091f, -0.02641777f, 0.10979896f, 0.12916963f, 0.15330185f, -0.13811927f, 0.12360813f, -0.02162887f, 
    0.48254323f, -0.05656872f, -0.09690779f, 0.03413287f, -0.04693629f, 0.32409224f, -0.13021901f, 0.17322510f, 
    0.35886359f, 0.02655966f, -0.02755878f, 0.35339901f, 0.24973586f, -0.25481290f, -0.18403886f, 0.05818523f, 
    0.18782216f, -0.14511566f, -0.01503349f, -0.16400106f, 0.60327119f, -0.11987983f, 0.06562984f, -0.09238830f, 
    -0.08356827f, -0.10179188f, -0.06425641f, -0.24949621f, -0.14454326f, 0.04273869f, 0.14349633f, -0.10606434f, 
    -0.32361352f, 0.23416539f, -0.07926136f, 0.17636384f, -0.32322782f, 0.17691487f, -0.02303146f, -0.26356953f, 
    0.33019483f, 0.02162459f, 0.06707203f, -0.47469345f, 0.09424141f, 0.21864094f, -0.11895089f, -0.05752320f, 
    0.07198145f, 0.03045652f, -0.13524877f, 0.67166138f, 0.38675472f, 0.09365916f, 0.29973581f, -0.45207497f, 
    0.03943858f, 0.02624719f, 0.07254059f, 0.35443100f, 0.15673210f, 0.03029633f, 0.08590048f, -0.05984117f, 
    -0.36692876f, 0.01572209f, -0.10441730f, 0.11919392f, 0.17270812f, -0.13609691f, -0.00718657f, -0.00305954f, 
    0.38964075f, 0.21307254f, 0.07662779f, -0.54398924f, 0.02009930f, -0.04288737f, 0.14898841f, 0.08678848f, 
    -0.14181632f, 0.09340601f, -0.11617874f, -0.33160329f, 0.32709765f, 0.04062032f, 0.02592017f, 0.13557673f, 
    -0.00771960f, 0.11199261f, -0.04328100f, 0.10806797f, -0.02740916f, 0.16667680f, 0.09954835f, 0.06044368f, 
    -0.32349637f, 0.27363834f, 0.36954904f, -0.05699701f, -0.13873811f, -0.20957635f, 0.17030999f, -0.19319446f, 
    0.35797006f, -0.02707966f, -0.16451094f, -0.32274887f, 0.23147041f, 0.30704993f, -0.05179757f, 0.08597435f, 
    -0.06239939f, -0.03471476f, -0.63431126f, -0.40173948f, 0.39242512f, -0.16819753f, 0.46243760f, 0.08889353f, 
    0.06623923f, -0.07572661f, 0.09616130f, 0.36178312f, -0.06596981f, 0.09454770f, 0.09242643f, -0.01408024f, 
    0.56372029f, -0.09296683f, -0.37587813f, 0.13734971f, -0.34677333f, 0.26259199f, 0.11239693f, -0.11312377f, 
    0.14202929f, -0.03598192f, 0.14455327f, -0.01327086f, 0.17828318f, 0.08747213f, 0.03634952f, -0.07617518f, 
    -0.02133838f, 0.07094492f, -0.57625365f, -0.21091001f, 0.50312614f, -0.18001233f, 0.34282917f, 0.12874974f, 
    0.15911709f, -0.07278457f, 0.01467601f, -0.28093696f, -0.09453660f, -0.12254821f, 0.08591772f, 0.05678606f, 
    0.40206984f, -0.20678391f, 0.00014227f, -0.04042498f, 0.31493795f, 0.29730400f, 0.14375900f, -0.35266909f, 
    -0.34853682f, -0.48657048f, 0.10265324f, 0.09118000f, 0.12660053f, 0.25131848f, 0.16641444f, 0.09619901f, 
    0.00321847f, 0.00207314f, -0.03605602f, 0.58249992f, -0.28645489f, 0.12222894f, -0.48634285f, -0.54016346f, 
    0.01314181f, -0.02881114f, 0.08459841f, -0.05488562f, -0.17094736f, -0.13840829f, 0.04229683f, 0.10211216f, 
    -0.62274760f, 0.26034558f, 0.16258442f, 0.09684753f, 0.16382104f, 0.07757040f, 0.09803829f, -0.03999848f, 
    0.44538379f, 0.19609727f, -0.03452514f, -0.07208277f, -0.19849981f, -0.17130795f, -0.17501017f, -0.14256856f, 
    0.01132218f, -0.08322616f, -0.35615143f, -0.02626269f, 0.03874219f, 0.10823543f, 0.10601728f, -0.00526842f, 
    -0.00569436f, -0.13827419f, -0.09457442f, 0.28564423f, -0.08397161f, 0.06274106f, -0.03122470f, -0.16341327f, 
    0.02044360f, 0.04340797f, -0.11362958f, 0.05466869f, -0.07075661f, 0.30112794f, 0.10018513f, 0.39757773f, 
    0.23317446f, 0.18111371f, 0.13477638f, -0.17805836f, -0.17463580f, -0.12702847f, -0.09440397f, 0.01773548f, 
    -0.12205186f, -0.03167643f, -0.10798609f, -0.05651630f, -0.18593627f, 0.15751891f, -0.29563335f, -0.16209987f, 
    -0.13290800f, 0.04698475f, 0.05626019f, -0.20784782f, 0.09836739f, -0.05220424f, 0.01747267f, -0.01677093f, 
    0.18373062f, -0.10962959f, 0.25137135f, -0.03767573f, 0.30495787f, -0.08276698f, -0.09019551f, -0.09377432f, 
    0.09032086f, 0.04127146f, -0.13233191f, 0.33485073f, 0.30515850f, -0.25429565f, 0.16000816f, -0.05688475f, 
    -0.09847634f, 0.14308284f, 0.30753088f, 0.33430609f, 0.05299325f, -0.02303021f, -0.19726549f, -0.04484710f, 
    0.04603041f, 0.16182959f, -0.09688767f, 0.14952318f, -0.00079305f, -0.04753732f, 0.05449643f, 0.14672454f, 
    0.17170605f, 0.03379716f, 0.12907393f, -0.15846831f, 0.11303038f, -0.07560876f, -0.16627513f, 0.37770990f, 
    -0.07503400f, 0.15519807f, 0.18182160f, 0.55845535f, -0.10004384f, 0.06121207f, 0.01410499f, -0.04605558f, 
    -0.13089195f, -0.09363031f, 0.64654106f, 0.08771228f, 0.04593239f, -0.33156314f, 0.49338704f, 0.39067024f, 
    0.16854486f, -0.00448579f, 0.10373400f, -0.11020035f, 0.15994312f, 0.01906425f, -0.11303104f, -0.04949600f, 
    0.05896183f, -0.04690490f, 0.09948428f, 0.12947808f, 0.05165705f, -0.09101292f, -0.07671338f, -0.17779705f, 
    -0.12765211f, -0.15695585f, 0.02159539f, -0.11845008f, -0.13601449f, 0.11296964f, -0.16462170f, -0.12246136f, 
    0.11748874f, -0.01171235f, 0.13631725f, -0.14227708f, -0.22109655f, -0.13118829f, -0.25618196f, -0.16263823f, 
    0.09115893f, -0.08337907f, -0.13848782f, -0.38406581f, -0.15105312f, -0.02532178f, -0.14638934f, -0.13991363f, 
    -0.06158277f, -0.14222097f, 0.07127097f, 0.11287516f, 0.25846428f, 0.14175035f, -0.10456045f, -0.29650956f, 
    0.12042028f, 0.00912813f, -0.15348352f, 0.59977883f, 0.33618426f, 0.02265946f, -0.04528318f, -0.07050989f, 
    0.03914182f, -0.00764089f, -0.14204916f, 0.07990301f, -0.10789745f, 0.29428449f, -0.10004350f, 0.11898745f, 
    0.12366671f, 0.00731100f, -0.14908712f, -0.10019241f, -0.09624541f, 0.02242554f, -0.13132869f, 0.14551350f, 
    0.01079647f, 0.51579410f, 0.09057243f, 0.02283068f, 0.06520376f, -0.25148201f, 0.01593638f, 0.24349165f, 
    -0.54035342f, 0.18912090f, 0.06213321f, -0.07870767f, 0.25223243f, 0.24980256f, -0.07277110f, 0.01653368f, 
    0.13034968f, -0.15900387f, 0.05467470f, -0.39175487f, 0.03382785f, 0.07002770f, -0.02527870f, -0.30123836f, 
    0.06213500f, 0.16309288f, 0.06452818f, 0.52320212f, -0.14913648f, -0.08925198f, 0.10761490f, -0.12396599f, 
    -0.28211537f, 0.26794222f, 0.45227882f, 0.12275746f, 0.23362631f, 0.10292942f, 0.16784693f, 0.12459141f, 
    0.50670195f, -0.33366981f, 0.14731716f, -0.17557602f, 0.02923998f, -0.15520541f, 0.05084086f, -0.04069157f, 
    -0.12724213f, -0.04737782f, 0.48359230f, 0.26957661f, 0.19363293f, 0.02982467f, -0.12909076f, -0.12909590f, 
    -0.05323165f, 0.04366725f, 0.14824316f, -0.04494598f, -0.16129595f, 0.13226566f, -0.08726354f, -0.07439844f, 
    0.40434954f, 0.09487416f, 0.11492515f, 0.05801868f, -0.45558593f, 0.21982996f, 0.06443574f, 0.42684874f, 
    -0.08623188f, -0.11997147f, -0.08096492f, -0.37141693f, 0.01311250f, 0.13859211f, -0.06349850f, -0.13728847f, 
    0.06613173f, -0.13789232f, 0.00353776f, -0.11061470f, -0.32843009f, -0.03390350f, -0.22139756f, 0.42935506f, 
    -0.10187911f, -0.08458309f, -0.16454902f, 0.32730529f, -0.14550911f, 0.12263936f, 0.01317559f, 0.11057510f, 
    0.03865157f, -0.06427453f, 0.08178186f, 0.14022167f, -0.21289997f, 0.27466995f, 0.12540011f, 0.48888275f, 
    -0.36126488f, -0.11596554f, -0.07732976f, -0.07091825f, -0.06184893f, 0.15504037f, -0.08766373f, -0.03217514f, 
    -0.02178700f, -0.06773449f, 0.64069676f, 0.10587585f, -0.38082796f, 0.25243834f, -0.33850902f, -0.23823173f, 
    0.09668158f, -0.03675639f, 0.00896013f, 0.01042503f, -0.08531746f, 0.02373765f, 0.02647357f, 0.08522436f, 
    0.20892230f, -0.20795260f, -0.03952297f, 0.13117354f, -0.10338501f, -0.12686855f, -0.10298300f, -0.01951308f, 
    0.12565319f, -0.07965467f, -0.02383765f, 0.05371770f, 0.14443842f, 0.16633910f, 0.15276104f, -0.17231855f, 
    0.09708663f, -0.12036192f, -0.31037557f, -0.13723393f, 0.02308714f, -0.04710365f, 0.07290969f, -0.21319006f, 
    -0.06729950f, 0.01079575f, -0.14154808f, 0.03662475f, -0.01845598f, 0.02451282f, -0.03519350f, 0.12189151f, 
    -0.12291288f, 0.02025797f, -0.08546365f, 0.16973105f, -0.09117912f, -0.10332347f, -0.08866483f, 0.12152471f, 
    0.16473159f, -0.17003509f, -0.06533252f, -0.11422550f, 0.13470820f, -0.01394863f, -0.14018059f, -0.11973321f, 
    -0.10707363f, -0.02521960f, -0.13600536f, -0.09476659f, -0.09003213f, -0.14327385f, 0.02502903f, -0.05593402f, 
    0.14369178f, 0.06844615f, -0.00100153f, 0.16568653f, -0.15350504f, -0.08797510f, 0.05933243f, -0.00123704f, 
    0.22657886f, 0.45122993f, 0.12664551f, -0.12128960f, 0.22157066f, -0.16366675f, 0.10052015f, 0.03604216f, 
    -0.18501046f, -0.05908477f, -0.16480707f, -0.41040894f, -0.08358393f, 0.19879742f, 0.13824156f, 0.07323013f, 
    0.14521980f, 0.02979873f, 0.62547904f, -0.08896305f, -0.20605616f, -0.41251543f, -0.54379243f, 0.03969706f, 
    0.08382700f, 0.03865239f, 0.01276223f, -0.02964727f, 0.08831381f, -0.16006720f, 0.06199098f, 0.14758398f, 
    -0.02007069f, -0.02260902f, -0.01364228f, -0.03626365f, -0.17831069f, -0.12990966f, -0.03612996f, 0.09580507f, 
    -0.01451074f, -0.18442087f, 0.06380386f, -0.10052449f, -0.11053875f, -0.05131195f, 0.06470420f, 0.06421542f, 
    -0.02067482f, 0.01264053f, -0.09977693f, 0.15322667f, -0.15694320f, -0.08635160f, 0.06506351f, 0.08976983f, 
    -0.17772098f, 0.14562230f, -0.09790374f, 0.00208218f, -0.04590362f, -0.10241506f, -0.08069566f, -0.02348361f, 
    0.39939985f, 0.15119265f, 0.13672566f, -0.08775839f, -0.27435058f, 0.24295275f, 0.02039952f, 0.09357636f, 
    0.00517760f, -0.39808145f, 0.11965013f, -0.28455165f, -0.18896839f, 0.11065529f, 0.10882775f, -0.08931658f, 
    -0.13260922f, 0.06566450f, 0.36375836f, 0.76879340f, 0.45177415f, -0.38650328f, -0.05055372f, -0.41890907f, 
    0.13712054f, 0.08206639f, 0.08915312f, -0.39990810f, -0.06495848f, -0.11165210f, 0.14407849f, -0.11589196f, 
    0.02623179f, 0.19540294f, -0.26218209f, 0.03857866f, -0.34573480f, 0.21772268f, -0.11862490f, -0.06697597f, 
    -0.57155126f, -0.05119404f, -0.15607882f, 0.17641112f, -0.08408595f, 0.37343782f, 0.04369161f, 0.00860675f, 
    -0.11787140f, -0.05485124f, 0.08853070f, 0.05288383f, -0.14979339f, 0.28657770f, -0.00341568f, -0.22192544f, 
    0.17063324f, 0.00791555f, -0.02301750f, 0.09579042f, -0.11138704f, -0.07977480f, -0.05329182f, -0.10270867f, 
    0.22410220f, 0.13878538f, 0.05244764f, 0.14415881f, -0.22540499f, -0.12567849f, -0.04327312f, 0.54946494f, 
    0.08181470f, 0.19130500f, -0.13980238f, 0.29171783f, 0.19528052f, -0.18742910f, 0.10023369f, -0.14195618f, 
    0.15773511f, -0.11359387f, -0.25457025f, -0.35085180f, 0.11644689f, -0.11998381f, -0.05682165f, 0.06172518f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01868511f, 0.12654595f, 0.17259315f, -0.07076088f, -0.02558536f, 0.23368829f, 0.26153356f, 0.22197294f, 
    0.20269400f, 0.09999368f, 0.00929945f, -0.00874448f, 0.20539722f, 0.25594142f, 0.21782058f, 0.02172831f, 
    -0.18105304f, -0.09959629f, -0.17390482f, -0.10869002f, 0.03284777f, 0.08956275f, -0.28069916f, 0.25945622f, 
    0.08632935f, -0.10590754f, -0.14265110f, 0.15198511f, -0.17143428f, -0.08785657f, 0.21084416f, 0.04192762f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.05436787f, -0.24212991f, 0.27914813f, -0.08802942f, -0.26501310f, -0.49833319f, -0.23492230f, -0.32224458f, 
    -0.38067463f, 0.22633415f, -0.10523529f, 0.00401305f, -0.08035588f, -0.14034368f, -0.49194682f, -0.04070741f, 
    0.14879653f, 0.10663196f, 0.17602584f, 0.02027345f, 0.01668012f, -0.19834557f, 0.33472967f, 0.03011993f, 
    0.12926559f, -0.16424772f, -0.04177925f, -0.11191818f, 0.02681204f, 0.28178492f, -0.43773440f, 0.09519549f, 
    -0.11686086f, -0.21421285f, 0.09261300f, -0.09999457f, -0.40007651f, -0.05194360f, 0.42188215f, 0.13687854f, 
    -0.00064934f, 0.11368779f, -0.93565309f, -0.18392320f, 0.11803382f, 0.17840536f, -0.73665881f, -0.12294886f, 
    0.14580008f, 0.05339321f, 0.24344364f, 0.05999636f, 0.12157624f, -0.02623803f, -0.08634214f, 0.30732653f, 
    0.08797009f, -0.03110331f, -0.00852088f, -0.12951073f, -0.07965538f, -0.28772104f, -0.28339741f, 0.34813523f, 
    0.16265334f, 0.06087037f, -0.41620350f, -0.14977665f, -0.15811642f, 0.27108467f, 0.17315581f, -0.25565431f, 
    -0.04512174f, -0.06654572f, -0.48739541f, 0.06084864f, -0.42555735f, -0.02466851f, 0.31845281f, 0.10421342f, 
    0.10986464f, -0.16255839f, -0.19400296f, 0.28481758f, -0.11079131f, 0.05515506f, -0.37414178f, 0.36922431f, 
    0.14205168f, -0.24441525f, -0.02847827f, 0.64314711f, 0.05253604f, 0.15158200f, 0.28974894f, -0.12647374f, 
    -0.20635176f, -0.11528702f, -0.13504769f, -0.23485291f, 0.13415691f, 0.35264733f, -0.36306748f, 0.17008731f, 
    -0.13848981f, -0.14027451f, 0.17016448f, 0.17129505f, -0.32535499f, -0.09679211f, 0.05373038f, -0.01608124f, 
    0.38427654f, -0.16659947f, -0.08965904f, -0.18915962f, -1.01547408f, -0.05624524f, 0.22514080f, 0.20827460f, 
    0.37008286f, -0.46194002f, 0.03439312f, 0.19548340f, 0.10210468f, 0.27341282f, -0.15271303f, -0.12077159f, 
    0.02959208f, -0.64433640f, 0.14919627f, 0.01957561f, 0.02045876f, -0.65245700f, 0.13943113f, 0.19364220f, 
    -0.24642842f, -0.05013086f, 0.19899103f, 0.35039070f, -0.22070554f, 0.12947369f, 0.23194279f, 0.03021609f, 
    -0.43159178f, -0.20273398f, 0.20168942f, 0.04773945f, -0.01422735f, -0.67813742f, -0.11220413f, 0.03876022f, 
    0.13433790f, -0.26972860f, -0.00829922f, -0.35465428f, 0.06516600f, 0.23691756f, 0.34033981f, -0.27286872f, 
    -0.06248778f, -0.15639797f, -0.21366607f, -0.15883616f, -0.35366580f, -0.07999112f, -0.04031617f, 0.36468554f, 
    0.29964897f, 0.23303366f, 0.26441556f, -0.02132610f, 0.29078385f, 0.33373240f, -0.17193340f, 0.18431850f, 
    -0.14957654f, -0.06151904f, -0.22732154f, -0.20325436f, -0.04858962f, -0.16573906f, -0.13529763f, 0.17028064f, 
    -0.52085268f, -0.04759124f, 0.05311494f, -0.38458991f, -0.14750279f, 0.14337765f, -0.43770868f, 0.09154440f, 
    -0.07640842f, 0.25628904f, -0.11845755f, 0.06349596f, 0.12396260f, 0.30486622f, 0.04737739f, 0.34581345f, 
    -0.16100775f, -0.79208648f, 0.14982779f, 0.00411502f, 0.11467876f, -0.60598671f, 0.13828808f, -0.09842145f, 
    -0.46548274f, -0.05805276f, -0.65964353f, 0.04704641f, 0.18292315f, 0.10206801f, 0.10817732f, -0.26549169f, 
    0.14291485f, -0.00811806f, 0.17718405f, -0.24480422f, -0.15469790f, -0.71734321f, 0.25346830f, -0.05624140f, 
    -0.04840644f, 0.33210638f, -0.73232800f, -0.18596798f, -0.56555992f, 0.31411278f, -0.18850231f, -0.66423279f, 
    0.03769726f, -0.19116238f, 0.07947516f, -0.22752436f, -0.20537844f, -0.29862681f, 0.09022349f, -0.19655986f, 
    -0.41603208f, 0.39163762f, 0.36383387f, -0.09929971f, -0.13305978f, 0.07924412f, 0.10592607f, -0.60639036f, 
    -0.79305112f, -0.01985902f, 0.10918179f, 0.47203279f, 0.04585929f, 0.15768583f, -0.24493904f, 0.08519939f, 
    -0.12007541f, -0.26043236f, 0.31187597f, -0.00496165f, -0.04130659f, 0.04059521f, -0.30003113f, -0.95280671f, 
    0.27147439f, 0.07829656f, -0.06911816f, 0.23125601f, 0.38718864f, 0.22756416f, -0.37593293f, -0.25522038f, 
    -0.55610931f, -0.29764429f, -0.00000633f, 0.12246685f, -0.33899114f, 0.25905606f, 0.41725430f, -0.79574758f, 
    -0.62437564f, -0.31684855f, -0.06394965f, 0.44917479f, -0.15318987f, -0.61232042f, -0.27528259f, -0.17879388f, 
    -0.03359425f, 0.20367861f, -0.12364507f, -0.35619888f, -0.33972242f, 0.00132915f, 0.20266907f, 0.14166614f, 
    -0.55614257f, 0.27098954f, 0.16343693f, -0.07591734f, -0.22272781f, 0.06520688f, 0.38981986f, -0.54950094f, 
    -0.75251061f, 0.34419385f, -0.03768754f, 0.00995464f, 0.29374716f, -0.16518959f, -0.16211942f, -0.59406495f, 
    -0.17133270f, 0.15556514f, -0.01852685f, -0.87587607f, 0.13397014f, -0.03701757f, 0.03488704f, -0.47061679f, 
    0.02521799f, -0.41171250f, 0.14203465f, -0.19409856f, 0.49723363f, 0.08179476f, -0.32499540f, -0.37317136f, 
    0.16379622f, 0.21424407f, -0.25914171f, -0.65500295f, -0.20739481f, 0.20215224f, -0.07157821f, -0.88742554f, 
    -0.07639468f, -0.55856872f, -0.05712859f, -0.13449144f, -0.23370750f, 0.43013865f, -0.74645925f, 0.18141529f, 
    0.12839966f, -0.20427369f, -0.07541099f, -0.06467877f, -0.06882361f, -0.21645473f, 0.46824956f, 0.40140426f, 
    -0.14928186f, 0.00348713f, 0.36926576f, 0.00298377f, -0.51747471f, 0.11806940f, 0.19875266f, 0.07124166f, 
    -0.02849489f, -0.58496422f, 0.42938328f, -0.37229040f, 0.43027005f, -0.13183364f, -0.46878463f, -0.60885626f, 
    -0.61317271f, -0.67319518f, 0.09979496f, -0.03847533f, -0.31212187f, 0.26876119f, -0.27726486f, 0.04612942f, 
    -0.22562593f, -0.09101913f, -0.12565543f, -0.21102093f, -0.14733779f, -0.14142832f, 0.33314875f, -0.23374830f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.24155864f, 0.17835103f, 0.23980096f, 0.00107882f, -0.02951987f, -0.07823550f, 0.11220244f, 0.04079182f, 
    0.03031362f, 0.18669020f, 0.15502240f, -0.18434374f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
