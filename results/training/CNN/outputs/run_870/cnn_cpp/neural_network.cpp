#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.60306710f, 0.59257084f, 0.00455593f, -0.52888423f, 0.76209778f, 0.75324732f, -0.39834398f, 0.11450073f, 
    -0.14345498f, -1.01235330f, 0.16651186f, -0.45401838f, 0.58617091f, 1.18592870f, 0.19255529f, 0.06547420f, 
    -0.46402523f, 0.10781609f, 0.48166248f, 0.56117857f, -0.33714414f, -0.31519780f, 0.30058962f, -1.03015113f, 
    0.14810324f, 0.35957289f, 0.21003866f, 0.43780828f, 0.91197008f, 0.10044853f, -0.36708131f, -0.93597567f, 
    0.13373062f, -0.12075057f, 0.00989068f, -0.36395374f, -0.59092432f, -0.30816767f, 0.76084322f, 0.91049081f, 
    -0.12877040f, 0.57557553f, 0.13437268f, -0.44695637f, -0.08265823f, -0.56397724f, -0.65624428f, -0.87450993f, 
    -0.07776283f, 0.27974322f, 0.86063981f, -0.36806789f, -0.06628838f, -0.18204188f, -1.14014566f, 0.96517897f, 
    -0.13444000f, -0.27479565f, 0.13247328f, -0.65270752f, -0.12865251f, 0.12188952f, -0.00686015f, 0.00801339f, 
    -0.52456790f, -0.67761731f, -0.00475021f, -0.91712475f, -0.73118204f, -0.57458580f, -0.20843229f, 0.62263578f, 
    0.15005620f, 0.39379421f, 0.22270377f, 0.31960431f, 0.24357496f, 0.18077376f, -0.70388168f, -0.65623748f, 
    0.24063352f, 0.63691741f, 1.07471776f, -0.70214182f, 0.27814767f, 0.26572374f, -0.16371396f, 0.32273874f, 
    -0.02253626f, 0.20605975f, -0.09375132f, 0.43593904f, -0.04083336f, 0.74362707f, -0.43665385f, -0.15185317f, 
    0.24686529f, 0.47116968f, 0.59497446f, -0.27500892f, -0.23914227f, 0.21934335f, 0.21966986f, 0.49094692f, 
    0.87578171f, -0.00231133f, 0.19295357f, 0.71845299f, -0.84760696f, -0.91243660f, -0.74052268f, -0.61075795f, 
    -0.05134273f, -0.24828970f, 0.29302934f, -0.09157792f, 0.01889914f, 0.84865248f, 0.50181872f, 0.88729274f, 
    0.56983846f, 0.15650399f, 0.36549219f, 0.09000587f, 0.59530699f, 0.04451161f, 0.91948032f, 0.72042155f, 
    0.54679680f, -1.14576805f, 0.43366641f, -0.41024828f, -0.08417067f, 0.28056389f, -0.05106429f, -0.87934464f, 
    0.34954131f, 0.49916208f, -0.06153112f, -0.46708292f, 0.61333150f, 0.43896806f, -0.13888890f, 0.64826614f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.29070228f, -0.08132914f, 0.18487029f, 0.05707705f, -0.07790883f, -0.03691897f, 0.14468673f, 0.28238654f, 
    0.09032998f, -0.27247462f, -0.47536105f, 0.45679456f, -0.03920185f, 0.69934893f, -0.11883835f, -0.21132477f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.02993578f, -0.08470240f, 0.06760877f, -0.00475184f, 0.00711652f, -0.02821066f, -0.03416960f, 0.04127101f, 
    0.05153272f, -0.08196753f, -0.01219707f, 0.06677163f, -0.04044961f, -0.08044284f, -0.01422411f, 0.05896744f, 
    -0.06788795f, -0.00870184f, -0.08337813f, -0.03937955f, -0.06936249f, 0.03561490f, -0.09020721f, 0.00901644f, 
    0.03649941f, -0.06887820f, 0.02421563f, -0.06395062f, 0.00431660f, 0.02950768f, -0.05436565f, -0.06201382f, 
    -0.03072567f, -0.08018752f, -0.04522575f, -0.08658548f, -0.05491620f, -0.00922936f, -0.08316495f, -0.03476281f, 
    -0.02407351f, -0.07848429f, -0.04803958f, -0.00190596f, -0.07658114f, 0.03532499f, -0.06996947f, -0.05209693f, 
    -0.00790277f, -0.05088048f, -0.06323316f, -0.04123037f, -0.09451421f, -0.04912097f, 0.01329929f, 0.07108861f, 
    -0.06567404f, 0.06976406f, 0.06399070f, -0.07340276f, 0.05848305f, -0.08987871f, 0.04644873f, -0.04280414f, 
    -0.05951210f, 0.05884153f, 0.00196702f, 0.04861432f, 0.05816463f, 0.05538558f, 0.01176013f, 0.02809925f, 
    0.05906225f, 0.04580025f, 0.05094823f, 0.01365467f, -0.00371845f, 0.05382887f, 0.06249344f, 0.02061316f, 
    -0.08834807f, -0.08522303f, -0.06394129f, -0.05817508f, 0.06771481f, -0.02255667f, 0.03734279f, -0.07333050f, 
    -0.04343006f, 0.04350533f, -0.02644720f, -0.06407075f, -0.01569608f, -0.00156417f, -0.07892785f, 0.03828591f, 
    0.06532765f, -0.06483678f, -0.06669537f, -0.02890413f, -0.02867039f, 0.01563350f, 0.00457757f, -0.03094299f, 
    -0.02877343f, -0.03664429f, 0.05129443f, 0.02453116f, -0.08038986f, -0.05797017f, -0.03419750f, -0.00151591f, 
    0.06817961f, -0.08021966f, 0.04049693f, 0.00700567f, 0.04046416f, 0.05018141f, -0.09025915f, -0.00387421f, 
    -0.06519120f, -0.06509223f, 0.00870393f, 0.06878739f, 0.05367352f, -0.01505385f, -0.07700147f, -0.06855425f, 
    0.02291215f, 0.06869850f, 0.02511859f, -0.07113727f, 0.01416198f, 0.03201240f, -0.02989189f, -0.05083896f, 
    -0.01230086f, 0.01926988f, 0.04886376f, 0.00546119f, 0.04829371f, 0.02228513f, -0.09080616f, -0.06017082f, 
    -0.36278951f, 0.01083697f, -0.11081694f, -0.22473076f, -0.24400206f, -0.26439992f, 0.18327110f, -0.05288316f, 
    -0.06771313f, 0.22392513f, 0.13417697f, -0.26804376f, -0.02570352f, 0.05484037f, 0.11722017f, 0.10044955f, 
    -0.00392398f, 0.09899139f, 0.06935870f, -0.09440627f, 0.23770626f, 0.09127577f, -0.04567614f, 0.00817484f, 
    -0.03076701f, 0.05439531f, 0.26229435f, 0.16730216f, -0.12832761f, 0.05786345f, 0.14011404f, 0.05400948f, 
    0.00944006f, -0.03482123f, -0.11685880f, -0.12964965f, 0.17974274f, -0.32195911f, -0.19922081f, -0.04110219f, 
    0.16155957f, 0.09676993f, -0.09636921f, 0.02380405f, -0.01878458f, 0.31995678f, -0.18314318f, 0.08067554f, 
    -0.08890612f, -0.08372618f, -0.01384715f, -0.15243155f, 0.10552344f, -0.14241375f, 0.36684957f, 0.12278456f, 
    -0.26174492f, 0.00191494f, 0.00730581f, -0.24994670f, -0.03360269f, 0.07627803f, 0.06435918f, 0.31795976f, 
    0.17098719f, 0.24064074f, -0.03720587f, -0.02810735f, -0.10043054f, 0.20355275f, 0.30314901f, 0.12571009f, 
    -0.19149449f, -0.12484290f, -0.33435225f, 0.03804045f, 0.18312320f, -0.01300351f, 0.07062404f, -0.09052317f, 
    -0.12792037f, -0.41693515f, -0.42739758f, -0.28105438f, 0.13306066f, -0.00156339f, -0.12601197f, -0.04721987f, 
    0.00740111f, -0.11234763f, 0.30929795f, -0.09099592f, -0.13106619f, -0.08263111f, -0.17721033f, 0.13502689f, 
    -0.06163166f, -0.06884495f, 0.14196777f, 0.31952590f, 0.05685314f, 0.14484450f, -0.08787844f, -0.01524424f, 
    0.24854468f, 0.02096036f, 0.18972123f, 0.10629006f, -0.26911575f, -0.12116327f, 0.13234341f, 0.05759342f, 
    -0.09214914f, 0.23159429f, -0.01571364f, -0.08409499f, 0.04487848f, -0.63871932f, -0.58841395f, 0.01966649f, 
    0.06882722f, 0.16666448f, 0.09893948f, 0.10682321f, 0.15617004f, -0.25227267f, -0.61148649f, 0.25054270f, 
    0.33090484f, 0.18735652f, 0.14393695f, -0.33031759f, 0.06674279f, -0.07560635f, 0.00982074f, -0.12263913f, 
    -0.06321031f, 0.10118677f, 0.03974114f, -0.13637657f, 0.09645175f, 0.22172961f, -0.08132184f, 0.10177950f, 
    -0.30095652f, -0.21800949f, -0.27744052f, -0.04319424f, 0.12827261f, -0.12743002f, -0.07903192f, 0.00402811f, 
    0.08248650f, 0.30566242f, -0.08001412f, -0.28409988f, -0.01233532f, -0.27859265f, -0.09090251f, 0.11828917f, 
    -0.16852379f, 0.01527903f, 0.30332592f, 0.14812699f, 0.07215280f, 0.33535299f, 0.09666372f, 0.22785467f, 
    0.14601338f, -0.10470977f, 0.20697084f, 0.41161409f, 0.22096330f, -0.10942882f, 0.14061594f, -0.00114435f, 
    -0.05307674f, 0.14433366f, 0.17053713f, -0.13188647f, -0.33650959f, 0.08761422f, 0.35285571f, 0.27558997f, 
    0.02693594f, 0.10875764f, -0.00933568f, -0.17904015f, 0.13323534f, -0.09039067f, 0.09575737f, -0.54530704f, 
    -0.07426386f, 0.09290443f, 0.17516041f, -0.01404574f, -0.21917945f, -0.19464576f, -0.22036883f, -0.20284845f, 
    0.01174742f, 0.24861458f, -0.00442094f, 0.12003344f, -0.06454283f, -0.09783980f, 0.03653987f, -0.22857147f, 
    0.09047653f, 0.08503611f, 0.00667281f, -0.04044068f, 0.13131632f, -0.14539744f, 0.23828503f, -0.17356563f, 
    -0.20543674f, -0.00773033f, -0.22475335f, -0.12497153f, 0.05902271f, -0.15317611f, -0.00241340f, 0.15735450f, 
    0.37412483f, 0.13781381f, 0.17139052f, 0.02712933f, -0.23002350f, 0.30884838f, -0.15863763f, -0.11284494f, 
    -0.00134701f, 0.04740398f, -0.28510952f, -0.15160127f, -0.33388561f, -0.12573270f, 0.24104144f, -0.05683002f, 
    0.12445356f, 0.24054226f, 0.00084936f, -0.16182320f, -0.00105445f, 0.16854405f, 0.01431328f, 0.17848222f, 
    -0.02714000f, 0.26096711f, 0.04936648f, 0.10233721f, -0.21467142f, -0.11000744f, -0.28355891f, -0.06906391f, 
    0.12956527f, 0.13721412f, 0.01770880f, 0.13509542f, -0.21493645f, 0.42892647f, 0.21120887f, 0.18624642f, 
    0.03367837f, -0.06994068f, -0.20440438f, 0.00324409f, 0.18124445f, 0.05118134f, 0.26832649f, 0.10082814f, 
    -0.09642254f, 0.12464689f, -0.03310909f, 0.17732556f, -0.08145837f, 0.02249639f, 0.08984316f, -0.41315246f, 
    -0.19156581f, 0.03397883f, -0.15321472f, 0.09947014f, -0.14707187f, 0.15307748f, 0.06263816f, 0.22479472f, 
    -0.28655055f, 0.08016164f, 0.09014463f, -0.16826005f, -0.22253683f, 0.24966143f, 0.07601535f, 0.03381465f, 
    -0.10940278f, -0.08744506f, -0.07739833f, 0.13124904f, -0.03229421f, 0.08551878f, 0.11557470f, -0.31481621f, 
    0.29574719f, 0.16052859f, 0.13207471f, -0.13620387f, 0.17097728f, -0.11545878f, 0.01092203f, -0.29444614f, 
    0.19805963f, 0.01804519f, -0.10391203f, 0.12552002f, 0.05667832f, -0.23141254f, 0.15737852f, -0.07436982f, 
    -0.02979176f, 0.27967495f, 0.06053981f, -0.00134864f, 0.02312562f, -0.28715912f, -0.11687771f, -0.09084678f, 
    0.11002279f, 0.11432462f, -0.12789415f, -0.25627089f, -0.06205527f, -0.04436938f, -0.19308941f, 0.39030278f, 
    0.06922419f, -0.18026094f, -0.18925862f, -0.17485601f, 0.12918292f, 0.12749864f, 0.09709247f, 0.17072889f, 
    0.24341629f, -0.08226950f, -0.28729877f, 0.08102390f, 0.07939327f, 0.04029613f, 0.02826285f, 0.31194797f, 
    -0.19225618f, 0.01205051f, 0.11070516f, -0.11305032f, 0.00829076f, 0.06214032f, 0.05843620f, 0.07054055f, 
    0.06851915f, -0.01697917f, -0.15823238f, 0.11094246f, 0.21352592f, 0.23864302f, -0.17179091f, 0.02011110f, 
    -0.17093915f, -0.01260579f, 0.09349184f, 0.22289900f, 0.17350285f, -0.02559064f, -0.03651133f, -0.10026974f, 
    -0.10116616f, -0.16582283f, -0.17471099f, 0.08659425f, 0.31290412f, 0.12890492f, -0.01527402f, 0.18480176f, 
    -0.04249170f, -0.26725861f, -0.00942798f, 0.16984153f, 0.07165179f, -0.20864785f, 0.00559661f, 0.06547391f, 
    0.05797027f, 0.07380860f, -0.27624390f, -0.11268133f, -0.01496531f, -0.01545948f, 0.29982668f, -0.04319543f, 
    0.19526169f, -0.04068778f, -0.03636707f, -0.04345188f, 0.26584896f, 0.10362171f, -0.12602884f, -0.45225677f, 
    0.17909634f, 0.09040991f, 0.27969894f, 0.05308705f, 0.06193110f, -0.01269423f, -0.02873863f, -0.00003153f, 
    -0.19828632f, -0.04341003f, 0.10903388f, -0.04660273f, 0.09508123f, -0.10229599f, 0.15487428f, 0.04298140f, 
    0.03720465f, -0.09525508f, -0.04499750f, -0.01766830f, 0.10662641f, 0.04306499f, -0.05027428f, -0.33325267f, 
    0.06393111f, -0.04699006f, -0.03799414f, 0.04163268f, -0.04593596f, -0.03286944f, -0.07562293f, -0.02542913f, 
    -0.02310877f, -0.02075068f, -0.07245305f, -0.08465495f, 0.07576074f, 0.07394090f, -0.00782008f, -0.05267853f, 
    -0.05078547f, -0.04646346f, 0.01589901f, -0.06955197f, -0.05960084f, -0.00766117f, -0.03922397f, -0.04567477f, 
    -0.01609568f, -0.06167744f, 0.06791089f, -0.01217664f, -0.03512327f, 0.04237488f, -0.05378852f, -0.02597988f, 
    -0.00631494f, -0.08879250f, -0.07709228f, -0.08816645f, -0.00719109f, -0.07730702f, 0.04583900f, 0.00480661f, 
    -0.06358264f, -0.01596025f, 0.00721572f, -0.01000519f, -0.06057803f, 0.06924951f, -0.07159090f, 0.06404451f, 
    0.02669385f, -0.06238401f, 0.02526133f, -0.02384126f, -0.07685085f, -0.07600853f, -0.07426749f, -0.07475643f, 
    0.03342016f, -0.01809248f, -0.01990066f, -0.08081947f, 0.02461731f, 0.06020915f, 0.05107687f, -0.06677517f, 
    -0.06862646f, -0.04593861f, -0.03207390f, -0.00928666f, 0.01510054f, -0.04974428f, 0.01108906f, 0.02754810f, 
    0.05947448f, 0.06606447f, 0.05230739f, -0.02811868f, -0.08398609f, 0.07496493f, -0.06645140f, -0.00932690f, 
    0.04262163f, 0.06687654f, 0.03094736f, -0.06831589f, -0.00975726f, 0.07693887f, -0.01625462f, -0.04077988f, 
    -0.03366417f, -0.05186826f, -0.04292603f, -0.00322304f, -0.00653313f, 0.05362006f, 0.07328530f, -0.07081321f, 
    -0.02562550f, 0.05215615f, -0.06068905f, -0.04412252f, 0.03300602f, -0.03253805f, 0.00354870f, -0.07424162f, 
    0.01335498f, 0.05807240f, 0.03897735f, 0.02338627f, -0.01871042f, -0.03255963f, -0.06424031f, 0.02024704f, 
    -0.05706466f, -0.02946487f, -0.06304450f, -0.00986153f, 0.06991637f, -0.08571806f, 0.01922937f, -0.08403571f, 
    0.06731230f, -0.05200887f, 0.01879151f, -0.05693449f, 0.02097409f, -0.02993867f, -0.04346100f, 0.01440421f, 
    0.01459160f, 0.01341324f, 0.00781747f, -0.00232035f, 0.00022080f, 0.07554419f, 0.04803605f, 0.02313041f, 
    0.00498883f, -0.03111094f, 0.00705304f, 0.01770346f, 0.07214355f, -0.01763216f, -0.06370130f, -0.02657237f, 
    -0.06187887f, -0.22543885f, -0.14016293f, -0.20741564f, 0.09082058f, 0.03613768f, -0.11602917f, -0.16369353f, 
    0.09846925f, -0.06971534f, -0.23254924f, -0.08385329f, 0.06175187f, 0.08281096f, 0.12084758f, 0.10595400f, 
    -0.06744472f, 0.03764591f, -0.07999533f, -0.04159760f, -0.05918177f, 0.06455945f, 0.04585721f, -0.02302024f, 
    -0.26942354f, 0.01764334f, -0.05371786f, -0.52289134f, 0.17801854f, 0.30556026f, -0.24709506f, 0.04891098f, 
    -0.08407219f, 0.09856617f, 0.13903253f, 0.16181888f, 0.16634969f, -0.44946045f, -0.40818885f, 0.05604535f, 
    0.12203017f, 0.10482148f, 0.19799042f, -0.12047289f, -0.07045272f, -0.16270834f, -0.38105819f, -0.11381733f, 
    -0.09255136f, 0.11907008f, 0.10630444f, 0.05940181f, -0.03882157f, 0.18821765f, -0.01318708f, -0.07846445f, 
    0.16558596f, 0.08538124f, 0.13166359f, -0.20365790f, 0.00991795f, -0.13490002f, 0.24730045f, 0.13420120f, 
    -0.24031787f, -0.11042918f, -0.10627604f, 0.11836131f, -0.08331770f, 0.18342316f, 0.00619913f, 0.05875403f, 
    0.07046027f, 0.05607689f, -0.00767705f, 0.25804642f, 0.15275727f, -0.01928325f, 0.07996092f, 0.04724177f, 
    -0.00778793f, -0.38269779f, -0.04298194f, -0.02588371f, -0.09251866f, -0.07837024f, -0.21002066f, -0.07382492f, 
    -0.18197736f, -0.06904551f, -0.12208927f, -0.29508781f, -0.28130069f, 0.09388272f, 0.01616227f, 0.01560614f, 
    -0.18499041f, 0.09179009f, -0.21166001f, 0.01063820f, -0.06550861f, 0.17964569f, 0.21704668f, 0.03369791f, 
    0.00573822f, -0.10287622f, 0.10808054f, -0.13366838f, -0.44239920f, 0.14674771f, -0.00447820f, 0.38298312f, 
    0.21204071f, 0.06547377f, 0.02741879f, 0.00627610f, -0.05739821f, -0.19063644f, 0.43012378f, 0.48440689f, 
    0.04943406f, 0.21647292f, 0.05599081f, 0.12322091f, -0.02454904f, -0.05710416f, 0.12244261f, 0.50117975f, 
    0.26159135f, 0.08680801f, -0.02702595f, -0.01847777f, -0.24633706f, -0.04955474f, -0.08444469f, -0.18543889f, 
    -0.25482976f, -0.21972857f, -0.01670566f, 0.05832255f, 0.01052701f, -0.07299690f, 0.04465779f, 0.00803474f, 
    0.12924479f, 0.20895351f, -0.30651051f, -0.37578860f, -0.08389015f, 0.25118843f, -0.12320134f, -0.03356617f, 
    0.06153312f, 0.54309952f, 0.06381244f, 0.01865733f, -0.10930923f, -0.19543622f, -0.00744139f, 0.10304596f, 
    0.01665460f, 0.09460738f, -0.19109526f, 0.12413350f, -0.01368543f, 0.14637212f, -0.03583221f, -0.05385699f, 
    0.04132982f, 0.01707524f, 0.20636927f, -0.50217640f, 0.04054396f, -0.02393815f, 0.15214355f, 0.25875765f, 
    0.17701600f, 0.16694370f, 0.14292029f, 0.04010751f, 0.16252670f, -0.21254332f, -0.02734479f, -0.08752132f, 
    0.31641719f, 0.21653180f, -0.08739216f, -0.08489696f, -0.26569635f, 0.18265422f, 0.07256105f, 0.21092974f, 
    -0.09051970f, -0.03635537f, -0.03749868f, -0.08990666f, 0.09906830f, 0.17066732f, 0.42687842f, 0.03905861f, 
    0.04958596f, 0.08614570f, 0.01536725f, -0.08815530f, -0.06667210f, 0.11347609f, 0.26653254f, -0.46775302f, 
    -0.03003987f, -0.04866746f, -0.00792677f, 0.33426237f, -0.06068066f, -0.02839153f, 0.00357275f, -0.01459331f, 
    -0.23907265f, -0.22662166f, 0.01919714f, 0.19867365f, 0.10797885f, 0.18736096f, 0.08015761f, 0.14555527f, 
    0.14463978f, 0.44071361f, -0.10487469f, -0.32116240f, -0.02311009f, -0.02560292f, -0.01803927f, -0.19628014f, 
    0.05897463f, -0.12369245f, -0.16818705f, 0.07691871f, -0.08002163f, 0.35100541f, 0.03388435f, 0.05495599f, 
    -0.43453079f, 0.09023266f, -0.38972196f, 0.11027332f, -0.14858326f, 0.22232725f, 0.00119725f, -0.05107902f, 
    0.05905647f, 0.18494983f, 0.01309267f, -0.31411284f, 0.03201906f, -0.59672827f, 0.12669593f, -0.23752484f, 
    0.04496853f, 0.05830590f, 0.05243280f, -0.09301583f, 0.03103680f, -0.46508652f, 0.01339453f, 0.34953198f, 
    -0.00195419f, 0.17225586f, 0.04365912f, -0.04234897f, 0.08120175f, -0.11168848f, 0.14488371f, 0.70328963f, 
    -0.08152395f, -0.07920761f, 0.01911130f, -0.12075932f, -0.13841461f, 0.01158321f, -0.17579606f, 0.16146262f, 
    0.54077244f, -0.28960845f, 0.03328389f, 0.03137945f, -0.33423954f, -0.15016894f, -0.04026693f, -0.05584833f, 
    -0.07670933f, 0.02347940f, 0.08528144f, -0.05551369f, 0.10007021f, -0.04469195f, 0.13300245f, 0.01398424f, 
    -0.07794783f, 0.01795197f, -0.14939503f, 0.11684231f, -0.10427218f, -0.20023692f, 0.17971197f, -0.08678164f, 
    -0.12645583f, 0.08970495f, 0.53856951f, -0.05465481f, -0.57605666f, 0.17295967f, 0.21219976f, -0.02320077f, 
    0.02464500f, 0.00802677f, -0.02808905f, -0.41718087f, 0.20037466f, 0.16903077f, -0.02249133f, 0.12663710f, 
    -0.02055102f, 0.12399376f, 0.27090999f, -0.08527716f, 0.24232444f, 0.23821948f, -0.12592681f, -0.03535657f, 
    -0.08891992f, -0.00688735f, 0.05309796f, 0.09167293f, -0.06373652f, -0.42153391f, -0.02525512f, 0.47366694f, 
    -0.08207627f, -0.08199186f, -0.14774168f, -0.07503693f, 0.21522067f, -0.00518376f, -0.71977812f, -0.16490337f, 
    -0.74369866f, 0.09792171f, 0.00283285f, -0.03163974f, 0.06831956f, 0.00331646f, 0.03623204f, -0.17112473f, 
    -0.06596588f, -0.20422159f, -0.05616426f, -0.10602748f, 0.14958735f, -0.02248745f, 0.04860887f, 0.20130216f, 
    -0.08418270f, -0.33285028f, -0.16749103f, 0.06262478f, 0.09337969f, -0.11182907f, 0.06005519f, 0.08259303f, 
    0.08479127f, -0.08101922f, 0.41128784f, -0.13953017f, -0.14247268f, -0.18392578f, -0.15672143f, -0.22138153f, 
    0.01136124f, 0.01710760f, 0.07096943f, -0.15282938f, -0.26249218f, 0.07865212f, -0.01124748f, 0.11763598f, 
    -0.01188105f, 0.00909449f, 0.14207789f, 0.11590815f, -0.09278595f, 0.24151854f, -0.11634121f, 0.08154998f, 
    0.13061009f, -0.13762027f, 0.12327747f, 0.07213277f, -0.39483476f, 0.14729816f, 0.58808583f, 0.33023223f, 
    0.18369409f, -0.15726657f, 0.00761612f, 0.10423434f, 0.11905715f, 0.25814003f, 0.22834446f, 0.10699420f, 
    -0.02887833f, 0.04109658f, -0.02381145f, 0.00942782f, 0.15373595f, -0.13692361f, 0.13090502f, -0.00162062f, 
    -0.45917943f, -0.00311307f, -0.07431196f, 0.14330949f, -0.02210910f, -0.15163635f, 0.00855329f, 0.29693472f, 
    0.00530452f, 0.04247838f, 0.11985756f, -0.12195022f, -0.10919182f, -0.01359380f, -0.03249902f, 0.15486798f, 
    -0.42349157f, 0.02599628f, -0.35614553f, 0.02551506f, -0.09921932f, -0.03434366f, -0.11316875f, -0.13592018f, 
    0.21358867f, -0.30780232f, -0.06084037f, -0.01888073f, -0.10252475f, 0.09669009f, 0.00207941f, -0.27729684f, 
    0.00803609f, -0.07443827f, 0.16581230f, 0.09862211f, -0.44476688f, 0.13853431f, 0.13425817f, 0.02166264f, 
    0.10198694f, 0.02815804f, -0.01122345f, 0.66534907f, 0.26331460f, -0.15159099f, 0.27503750f, 0.01115201f, 
    -0.01543286f, -0.05998573f, 0.02379479f, 0.09671764f, -0.36271363f, -0.45282316f, -0.04695190f, 0.07138491f, 
    0.10980535f, 0.09150773f, 0.00538972f, 0.07452907f, 0.20266020f, 0.39349139f, 0.07211339f, 0.07437908f, 
    -0.02346615f, -0.02228819f, -0.18805014f, 0.03240491f, -0.12470046f, -0.02879408f, -0.09920003f, -0.03831468f, 
    -0.03367789f, -0.02861284f, 0.02615967f, 0.11201020f, 0.03120824f, -0.27715155f, 0.01152231f, 0.15839842f, 
    -0.09363347f, -0.40050822f, -0.13105589f, -0.11016113f, 0.14107946f, 0.17434448f, 0.07217990f, -0.11759810f, 
    -0.06769013f, 0.14614853f, -0.09540647f, 0.06363118f, 0.03676964f, 0.15474358f, -0.00283301f, -0.08193599f, 
    0.01169296f, 0.36571535f, -0.05028561f, -0.09699237f, 0.10560717f, 0.02405942f, -0.13312626f, 0.06238088f, 
    -0.01641008f, -0.05660921f, -0.04196526f, -0.13206179f, 0.18587530f, 0.25865698f, 0.24942736f, -0.01418438f, 
    0.31361523f, -0.08195551f, 0.03703651f, -0.09411018f, -0.13027130f, 0.10402953f, -0.07562498f, -0.03953310f, 
    0.16334905f, 0.18186589f, 0.03306461f, 0.05430761f, -0.12210380f, 0.13597667f, -0.34058157f, 0.05343596f, 
    -0.01414424f, -0.01868599f, -0.13891970f, -0.03022517f, 0.10104514f, 0.28574207f, -0.08976588f, 0.07347880f, 
    -0.00064533f, -0.03816519f, -0.11047977f, 0.10407035f, 0.11209445f, -0.01719442f, 0.35798126f, 0.23559870f, 
    -0.01765725f, 0.17417139f, 0.06428804f, 0.14964333f, 0.00113755f, -0.09183315f, -0.04223506f, -0.19103099f, 
    -0.02269326f, 0.03207262f, -0.22580107f, 0.31430387f, -0.03412511f, -0.12212618f, 0.12673537f, -0.22636113f, 
    -0.09526402f, -0.08088445f, 0.05033007f, -0.04279650f, -0.05559874f, -0.07122316f, -0.07694326f, -0.08438060f, 
    -0.02863078f, -0.02279307f, 0.01197365f, -0.02512623f, -0.02173232f, -0.05362111f, 0.04956746f, -0.00027901f, 
    -0.05484761f, -0.00544438f, -0.00575690f, -0.08375409f, -0.06480493f, -0.07520174f, 0.00878325f, 0.01934560f, 
    0.01219250f, -0.08515240f, -0.04730124f, -0.00828685f, -0.06614245f, -0.01282045f, 0.01828128f, 0.03006728f, 
    0.02331488f, -0.00678833f, 0.04556170f, 0.03082325f, 0.01392349f, -0.07627717f, -0.02638362f, -0.03897734f, 
    -0.03935991f, -0.03633836f, 0.00801966f, -0.05788007f, -0.05891518f, -0.01861282f, -0.07839201f, -0.09547377f, 
    -0.09215350f, 0.00794957f, -0.09671074f, -0.02971205f, -0.06460019f, 0.06171985f, 0.00457073f, 0.03477427f, 
    -0.08167174f, -0.04947045f, -0.01763558f, 0.04170534f, -0.05820652f, -0.04881977f, 0.00160115f, -0.03738765f, 
    -0.03770712f, -0.08702830f, -0.01269760f, -0.08001571f, -0.08771603f, -0.07769250f, -0.08610578f, -0.01985029f, 
    -0.04069415f, -0.02698573f, -0.03644961f, 0.02245132f, -0.02970383f, -0.04157625f, -0.04965498f, 0.06700295f, 
    0.06241095f, -0.01461552f, -0.05116200f, -0.03621483f, 0.04272545f, 0.04461687f, 0.02929990f, 0.01915237f, 
    0.00651526f, 0.00280714f, -0.01389278f, -0.06325944f, -0.08037952f, 0.05852062f, 0.03980345f, -0.01801845f, 
    0.04750518f, 0.02722353f, -0.03433046f, -0.02766848f, -0.07470539f, 0.01276816f, -0.07675772f, -0.03792774f, 
    -0.07181371f, 0.00358639f, 0.04108469f, 0.04506714f, -0.07444066f, -0.00425583f, -0.07209968f, 0.03592926f, 
    0.05687517f, 0.03162773f, 0.06510799f, 0.03745573f, -0.05744119f, -0.00032237f, -0.06323417f, -0.08603252f, 
    -0.03520871f, -0.09594228f, 0.05313969f, -0.05235575f, -0.00377228f, -0.06873677f, -0.04254121f, -0.00326906f, 
    0.04833659f, 0.06820562f, -0.04553303f, -0.01800006f, -0.00388076f, -0.07061697f, -0.04961961f, -0.09515044f, 
    -0.02904742f, -0.01689940f, -0.00041543f, 0.00536782f, -0.04093825f, -0.05939859f, 0.06264075f, -0.07519595f, 
    0.00530205f, 0.10178234f, -0.37970462f, 0.05907567f, -0.22241068f, -0.21419269f, 0.08556698f, -0.08689886f, 
    0.03005190f, 0.35327214f, 0.32956719f, -0.03797515f, -0.00975323f, 0.06136170f, -0.10534272f, 0.01781221f, 
    0.00637212f, -0.18576749f, 0.07508501f, -0.20050301f, -0.09799706f, -0.13238288f, -0.11734021f, 0.02822206f, 
    -0.09325340f, 0.02775847f, 0.04622473f, -0.09176989f, 0.16653451f, 0.12223396f, 0.14287472f, -0.31415975f, 
    -0.03600093f, 0.11788755f, -0.08774081f, 0.04598733f, -0.36860001f, 0.31088865f, -0.16412365f, 0.19259243f, 
    0.15347318f, -0.05686506f, 0.04844602f, 0.15502685f, -0.12962452f, 0.11112576f, -0.03060247f, -0.44658500f, 
    0.16757354f, -0.03688769f, 0.12250388f, 0.05294936f, -0.10166351f, 0.17819606f, -0.09897618f, -0.37025148f, 
    -0.36980024f, 0.01342250f, 0.12657931f, 0.08631807f, -0.05774475f, 0.05532270f, 0.08298466f, -0.26788273f, 
    -0.28890073f, -0.12238397f, 0.06220602f, 0.08803355f, -0.01178060f, -0.12749146f, -0.05336065f, 0.24676849f, 
    0.11654846f, 0.24066003f, 0.23029107f, -0.34608218f, 0.09700677f, 0.03708835f, 0.10492214f, 0.22094442f, 
    0.04499837f, -0.09769412f, -0.55748367f, -0.06483903f, -0.07324383f, 0.13501887f, -0.19469640f, -0.04891892f, 
    -0.06589502f, -0.08467057f, -0.32750070f, -0.29088056f, 0.00754676f, 0.22548211f, 0.13442025f, -0.15998910f, 
    0.13579807f, -0.21311980f, -0.10437866f, -0.36601818f, 0.19541191f, 0.02886650f, -0.03444462f, 0.07592988f, 
    0.00416647f, 0.06374505f, -0.07226970f, 0.10116707f, 0.19016927f, 0.27329236f, 0.28853399f, 0.08272913f, 
    0.09057470f, 0.09093033f, 0.24378015f, -0.00477046f, -0.01452322f, 0.16018839f, 0.34054822f, 0.39517081f, 
    0.04841771f, -0.13019226f, -0.07518887f, -0.08406832f, -0.17892687f, 0.11582583f, 0.22981136f, -0.11287613f, 
    -0.30838743f, -0.18102863f, -0.12836742f, 0.08432543f, 0.02732345f, -0.01767611f, 0.06287380f, -0.26722142f, 
    -0.02286723f, -0.15086162f, 0.15717496f, 0.02371462f, -0.08790716f, -0.00893669f, -0.05338552f, -0.08153705f, 
    0.15659948f, -0.35648605f, 0.16606858f, -0.07538948f, -0.21440257f, 0.12094428f, -0.13360327f, 0.20173834f, 
    -0.01159088f, 0.72450411f, -0.07701815f, 0.12805417f, 0.07039922f, -0.04391740f, 0.20808157f, -0.10176700f, 
    -0.18714151f, 0.06301748f, -0.04245062f, 0.13371670f, -0.20399849f, 0.20514870f, 0.00571100f, -0.02764144f, 
    0.06212090f, 0.01133990f, 0.04668948f, 0.08529039f, 0.31206155f, 0.24247496f, -0.24333616f, -0.16198163f, 
    -0.03681903f, -0.10053314f, 0.29492602f, 0.22138412f, 0.01708523f, -0.26879239f, -0.22961350f, 0.10377820f, 
    0.15723266f, 0.19648148f, -0.16177458f, 0.17567213f, 0.05570374f, -0.13512753f, 0.31878966f, -0.54085505f, 
    0.22274725f, 0.06317177f, 0.13601497f, 0.12244879f, -0.02546480f, 0.05442326f, 0.36813822f, -0.19893000f, 
    -0.10515559f, -0.37074804f, -0.14923163f, -0.11675396f, -0.01862539f, 0.12644413f, -0.05234104f, -0.29731393f, 
    -0.08332654f, 0.00538044f, -0.04381227f, 0.19845508f, -0.05315709f, -0.20689452f, 0.16613905f, 0.18612079f, 
    -0.03966890f, 0.20329736f, -0.06520733f, -0.03939909f, 0.12764458f, -0.00854542f, 0.21426518f, 0.22632390f, 
    -0.10931996f, -0.06151181f, 0.17261243f, 0.34898800f, -0.24386044f, 0.04201545f, -0.11531772f, 0.03701540f, 
    0.11707848f, -0.23194371f, -0.20204626f, 0.09027570f, -0.22290863f, -0.03871853f, 0.00875425f, -0.01150174f, 
    0.14888541f, -0.02629497f, -0.12002853f, -0.28073248f, 0.05936202f, 0.20731036f, 0.08723788f, -0.00893695f, 
    -0.10963363f, 0.03476293f, 0.04904163f, -0.19228289f, -0.12824146f, 0.32665277f, -0.42796013f, 0.14494467f, 
    0.28921482f, -0.04892137f, -0.10029368f, 0.13888794f, -0.07005006f, -0.05737969f, 0.18771774f, 0.13762014f, 
    0.12747160f, 0.22395708f, 0.07896453f, -0.13112558f, -0.08522350f, -0.04416214f, 0.06611764f, 0.24658477f, 
    -0.13250090f, 0.00768416f, 0.05905430f, -0.18717805f, -0.32025257f, -0.06780057f, -0.19441503f, -0.13415366f, 
    -0.22598003f, 0.00998703f, -0.14663540f, 0.26772168f, 0.18334556f, 0.21190359f, 0.00321590f, 0.05034902f, 
    0.27510944f, -0.50810224f, 0.22138853f, -0.08324912f, -0.06532160f, -0.13329785f, -0.13373777f, 0.11806133f, 
    0.16813314f, 0.14379898f, 0.25075936f, 0.19669841f, 0.17101155f, 0.19994630f, 0.14350420f, 0.15455572f, 
    0.17613123f, 0.19711217f, -0.44424510f, -0.00503092f, 0.07562358f, -0.06066919f, -0.09770884f, -0.12599123f, 
    -0.08563390f, 0.12785454f, 0.08028387f, 0.20413330f, -0.05413294f, -0.32772055f, -0.37393066f, -0.13424608f, 
    -0.06242167f, -0.27123991f, 0.12392204f, -0.32068515f, 0.10415963f, 0.22454354f, -0.02369418f, 0.00226386f, 
    -0.06560483f, -0.20531218f, -0.00476590f, 0.06083284f, -0.11570174f, 0.62066370f, -0.12594420f, 0.59851098f, 
    0.22986010f, 0.18697327f, 0.20537600f, -0.00491627f, 0.24030384f, 0.08705456f, 0.15614869f, -0.07343826f, 
    -0.23697327f, -0.03504495f, -0.03826359f, 0.21919651f, -0.07995746f, 0.06919352f, 0.03293362f, 0.44035459f, 
    0.19288769f, 0.02919204f, -0.07503241f, -0.08059703f, -0.01035044f, -0.19508095f, -0.08223960f, -0.26874307f, 
    0.28680351f, 0.02480588f, -0.23028372f, -0.03489793f, 0.10751972f, 0.08787045f, 0.07656971f, 0.13755579f, 
    -0.03544657f, -0.43432873f, 0.50578284f, 0.36527526f, 0.00861930f, 0.00323690f, -0.05564380f, 0.18202171f, 
    0.04591953f, 0.07656666f, -0.04738432f, -0.02737277f, -0.02358434f, 0.01657438f, 0.11177860f, -0.07982675f, 
    -0.26882499f, 0.02995402f, -0.00308132f, 0.10566184f, -0.18524654f, -0.20361437f, -0.14073525f, -0.05780730f, 
    -0.22172907f, 0.33424318f, 0.17290343f, -0.00659064f, 0.11961683f, 0.17061548f, 0.51394695f, 0.11581718f, 
    -0.06003195f, 0.04020031f, 0.05954045f, -0.01691116f, 0.18686160f, -0.23867038f, -0.41847992f, 0.03636602f, 
    0.06536014f, -0.02609696f, 0.06099702f, -0.06984875f, 0.04803091f, -0.03671590f, -0.08071876f, -0.14749216f, 
    -0.41981158f, -0.20447139f, 0.00160320f, -0.14226660f, -0.14263037f, -0.30845582f, -0.04445900f, 0.21613322f, 
    -0.58222061f, -0.20205447f, -0.10690397f, -0.05807851f, 0.02606751f, 0.13009511f, 0.05579382f, -0.08353694f, 
    -0.05957381f, 0.07814397f, 0.17028183f, 0.11783326f, 0.01128815f, -0.04840599f, -0.25801453f, -0.16014087f, 
    0.04418436f, -0.05263508f, -0.05086878f, 0.17061585f, 0.28140029f, 0.06796398f, 0.14649184f, 0.14381745f, 
    -0.05228741f, -0.13318217f, -0.15299489f, -0.25872973f, 0.27666140f, -0.16333705f, -0.03891164f, 0.25949687f, 
    0.09394643f, -0.19180189f, -0.17589366f, -0.39829725f, -0.09557635f, 0.08926124f, -0.22456080f, 0.06111945f, 
    0.01517595f, -0.28359616f, -0.00539182f, 0.07719326f, 0.11236586f, 0.05954716f, 0.11088771f, 0.11989824f, 
    0.02279125f, 0.04349726f, 0.03242961f, -0.03865805f, -0.07995737f, 0.07832126f, 0.23058151f, 0.09665731f, 
    0.15533786f, 0.20218492f, -0.19189636f, 0.22853567f, 0.20380244f, 0.12752154f, -0.13586089f, 0.29820651f, 
    -0.24950297f, 0.18097204f, 0.15367630f, 0.06365305f, -0.21576351f, 0.15714639f, -0.22798966f, 0.28097388f, 
    0.22244816f, -0.00785857f, -0.11627075f, 0.18561092f, 0.25031704f, -0.09802876f, 0.16719969f, -0.13683647f, 
    -0.07098241f, 0.13424772f, 0.18151386f, -0.02970856f, 0.09886135f, 0.13525161f, 0.01860641f, 0.21430804f, 
    0.21832591f, -0.39378420f, -0.43547484f, -0.31032497f, -0.07326768f, -0.10284271f, -0.20131674f, -0.06283798f, 
    -0.02056045f, -0.31832227f, 0.09867536f, -0.05822974f, -0.18541837f, 0.16070361f, 0.09555665f, 0.11209755f, 
    0.15600634f, 0.36658061f, -0.11556515f, 0.15149561f, 0.23919407f, 0.16508330f, 0.17713206f, -0.20784371f, 
    0.07450233f, 0.25888097f, -0.03770320f, -0.03445878f, 0.22918856f, 0.08646002f, 0.27300376f, 0.15771210f, 
    -0.20839712f, 0.28016502f, 0.21498770f, 0.21720372f, 0.00373993f, 0.08822214f, 0.12877573f, 0.30988455f, 
    0.13294941f, -0.05526900f, -0.17539351f, 0.37667716f, 0.08718697f, 0.42296126f, -0.42362493f, -0.01933791f, 
    0.36694697f, -0.04073880f, 0.09000532f, -0.19123411f, -0.14440523f, -0.15891622f, 0.25488412f, 0.04248408f, 
    -0.13756922f, 0.07868857f, -0.09992973f, -0.15916726f, -0.02794235f, -0.00178898f, 0.08911917f, -0.06616424f, 
    -0.00757880f, 0.12010296f, -0.06221608f, -0.00345772f, -0.13264273f, -0.12290924f, 0.09366018f, 0.07765874f, 
    -0.04238790f, 0.35301983f, 0.09625648f, 0.00937811f, -0.03369565f, 0.05104572f, -0.05712493f, 0.11044237f, 
    0.06130047f, -0.12299562f, 0.21803731f, -0.03399537f, -0.09780224f, 0.01613865f, 0.10970104f, 0.13562800f, 
    -0.04775315f, -0.03724691f, 0.01848542f, -0.39288443f, -0.17582193f, -0.17457308f, 0.14990020f, -0.12006404f, 
    0.06549143f, -0.26117438f, 0.14247081f, -0.09927625f, -0.12118935f, 0.14284013f, 0.12248223f, -0.02544330f, 
    0.03661694f, 0.01983538f, -0.04768176f, 0.00324833f, -0.02611895f, 0.13808131f, 0.17672282f, 0.05242017f, 
    0.00496816f, 0.12565066f, -0.16668090f, 0.12804812f, 0.13456182f, 0.08661018f, -0.24251546f, -0.31528899f, 
    -0.74555266f, 0.04672782f, 0.01026203f, 0.14794227f, -0.13857861f, 0.10049296f, -0.04330105f, -0.33196568f, 
    -0.23346522f, -0.10958032f, 0.10784437f, 0.30520669f, 0.05613332f, -0.25975493f, 0.20631005f, -0.16391574f, 
    -0.02324335f, 0.02423853f, 0.06172217f, -0.00442086f, -0.09805460f, 0.09069543f, -0.09871828f, -0.00842254f, 
    0.39528251f, 0.11597945f, -0.61012113f, -0.15612751f, -0.06004701f, -0.07948852f, -0.09720476f, 0.03543358f, 
    -0.01460526f, 0.03166958f, 0.09803279f, 0.04117690f, 0.07865427f, -0.15109494f, -0.13415484f, -0.04775308f, 
    -0.00273680f, 0.04131296f, 0.11626619f, 0.31337953f, 0.42161521f, 0.07016316f, -0.18821684f, -0.11639636f, 
    0.09185215f, 0.03813936f, -0.07388516f, 0.11861368f, 0.44011521f, -0.00887696f, 0.09476453f, 0.00030377f, 
    -0.04114446f, 0.03612804f, -0.04615160f, 0.10439835f, -0.05077464f, -0.32867494f, 0.02072235f, 0.04022451f, 
    0.00720446f, 0.07741461f, -0.05105077f, -0.05452071f, -0.07996879f, 0.29547551f, 0.10556915f, -0.07809786f, 
    -0.13285650f, 0.04808499f, 0.01690500f, 0.23634805f, -0.00991885f, -0.01655014f, -0.01556337f, -0.04509486f, 
    0.33295107f, -0.27043083f, -0.02803598f, -0.18064068f, 0.12985757f, 0.05406883f, -0.09768622f, -0.03254258f, 
    -0.17636028f, 0.19319145f, 0.31475097f, -0.10193829f, -0.04366039f, -0.24479343f, 0.13949759f, 0.00102791f, 
    -0.00635817f, -0.40249732f, 0.16164868f, 0.09398582f, -0.08983073f, 0.11388791f, -0.00333943f, 0.08439136f, 
    0.10813607f, 0.09988622f, 0.11581699f, -0.22070688f, -0.24524443f, 0.02512497f, 0.06677714f, -0.08424120f, 
    -0.20913213f, 0.16633849f, -0.04570105f, 0.15556321f, -0.67902416f, 0.19603495f, -0.11485220f, 0.09560028f, 
    0.01634582f, 0.15178540f, -0.13776939f, 0.18472913f, -0.23320170f, 0.00563843f, -0.15661858f, 0.06786197f, 
    0.09538991f, 0.01444555f, -0.10100985f, -0.13767239f, 0.14806609f, 0.17711499f, 0.24148834f, 0.05189758f, 
    -0.02976314f, 0.03216729f, 0.13170262f, -0.10817792f, 0.09108924f, 0.12888089f, 0.40718582f, 0.01882294f, 
    0.20486844f, 0.07765145f, -0.05250237f, 0.10954881f, -0.12270864f, 0.03360873f, -0.07660254f, 0.27861893f, 
    -0.02615667f, 0.03611911f, 0.15791148f, 0.08324949f, -0.13443978f, 0.14977729f, -0.02310464f, 0.05571330f, 
    -0.48804244f, -0.35842916f, -0.05684011f, -0.01268175f, 0.14038531f, -0.07725123f, -0.01410327f, 0.11579082f, 
    -0.07623577f, 0.31901443f, -0.47669539f, 0.02166127f, -0.04964757f, 0.09315836f, 0.13009229f, 0.02397117f, 
    -0.01933713f, 0.03522362f, 0.24636059f, -0.03760418f, 0.18042190f, -0.07651041f, 0.05092267f, -0.00819554f, 
    -0.03563367f, 0.07148124f, -0.14769816f, 0.13571022f, -0.08693960f, -0.02623017f, 0.10221805f, -0.16722976f, 
    0.06484082f, 0.18355060f, 0.01201218f, -0.21735251f, -0.52225250f, 0.30967873f, -0.27817002f, -0.07930789f, 
    -0.07515031f, 0.02413216f, 0.06552044f, 0.00172337f, 0.21532820f, -0.36473912f, -0.42102897f, 0.17819341f, 
    -0.02078441f, -0.17187618f, 0.02227499f, -0.02483310f, 0.17107877f, 0.06473187f, 0.36079112f, -0.27286080f, 
    -0.04744166f, 0.08862858f, -0.13865891f, 0.06118468f, 0.09776565f, -0.09879905f, -0.04722555f, -0.33679315f, 
    -0.06582616f, 0.07607565f, 0.02700768f, 0.11827499f, -0.05320723f, -0.18913096f, -0.01258652f, 0.07541663f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06094226f, 0.21811070f, 0.18882290f, -0.03107006f, -0.03349876f, 0.29755944f, 0.22049718f, 0.01302853f, 
    -0.20672975f, 0.06470997f, 0.05362900f, 0.05226096f, -0.15425053f, 0.18401733f, 0.21662687f, -0.09343599f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11011391f, 0.48991555f, 0.18106817f, -0.30561754f, 0.11394840f, -0.55787402f, -0.11209115f, 0.48737046f, 
    0.57381654f, 0.10381278f, 0.31935608f, -0.39506394f, -0.34524202f, 0.08373873f, 0.58867413f, 0.66166133f, 
    0.03967194f, 0.54872829f, -0.08551493f, 0.23181500f, -0.04154667f, -0.15321416f, 0.26675698f, -0.14771740f, 
    0.46798921f, -0.13179266f, -0.47495121f, 0.47320390f, 0.24217364f, -0.18330240f, -0.19362520f, 0.36053815f, 
    0.13200937f, -0.38066939f, 0.26424697f, -0.38135180f, 0.25163776f, 0.02161465f, 0.08478694f, 0.29569983f, 
    -0.30268097f, 0.18187296f, 0.65559512f, 0.33739099f, -0.18133274f, 0.24831203f, 0.25788632f, -0.10902670f, 
    0.22856699f, 0.17935377f, -0.03000677f, 0.15669006f, -0.13332291f, 0.21497945f, 0.48758337f, 0.35282835f, 
    -0.11247701f, 0.16594791f, -0.03261645f, 0.40324718f, -0.03268220f, -0.34532535f, -0.42522481f, 0.35288647f, 
    0.13539241f, -0.05444727f, -0.06599879f, 0.01534588f, 0.18470523f, -0.13597922f, -0.07619030f, -0.24353173f, 
    0.18007231f, -0.03459418f, 0.13485423f, -0.00447257f, -0.18489099f, -0.26618984f, 0.08745261f, -0.03474642f, 
    -0.07705007f, 0.71201289f, 0.10650325f, -0.06901106f, 0.13388790f, 0.39942965f, 0.34195486f, -0.66487962f, 
    0.25816527f, -0.18129462f, -0.50714225f, -0.28695372f, -0.00725082f, 0.30387178f, -0.13957441f, -0.15784916f, 
    -0.12003717f, 0.33218160f, -0.25679472f, 0.24999240f, 0.20490456f, 0.32174861f, -0.14238107f, 0.70189327f, 
    -0.02312309f, 0.21925244f, -0.82685131f, 0.24107921f, 0.48108420f, 0.11434046f, -0.10659716f, -0.65427434f, 
    -0.19504052f, 0.18791726f, 0.50181884f, -0.41465783f, -0.19432935f, -0.16988564f, 0.14969786f, -0.13744378f, 
    0.61765903f, 0.00258973f, 0.30377102f, 0.04060432f, -0.47107989f, 0.19384608f, 0.39986524f, 0.05865367f, 
    0.08084234f, 0.09252436f, 0.33599019f, 0.04491376f, 0.10955110f, -0.13969132f, 0.44388995f, 0.13197973f, 
    -0.37658155f, -0.07016501f, 0.16860738f, -0.49282852f, 0.05322842f, 0.12638217f, 0.34129968f, -0.39627934f, 
    -0.19178934f, 0.10766572f, 0.39415291f, -0.11604518f, -0.13458815f, -0.14937986f, -0.40799770f, -0.07390610f, 
    -0.70210809f, 0.00481179f, 0.71491039f, 0.02459641f, 0.19846167f, 0.37683484f, 0.09620073f, -0.33487117f, 
    -0.02445474f, 0.43604395f, -0.40093604f, 0.54840505f, -0.17932574f, -0.60370022f, 0.32645214f, 0.00774922f, 
    0.18756594f, 0.22362617f, 0.37805417f, -0.38740364f, 0.17204356f, 0.04819842f, 0.27742693f, 0.11868848f, 
    0.24335429f, 0.14701590f, 0.04174481f, -0.20805150f, -0.09708402f, 0.09384383f, -0.10308102f, 0.12396737f, 
    0.15903722f, -0.02087283f, -0.02687856f, -0.15822601f, -0.23520985f, -0.31754577f, -0.07003362f, 0.10947502f, 
    -0.22725450f, -0.49173638f, 0.37897637f, -0.13787182f, 0.22226593f, 0.31968814f, 0.47595975f, -0.17199452f, 
    -0.26713938f, 0.19003612f, 0.53066283f, 0.36725590f, 0.16355260f, -0.25867033f, 0.08546282f, -0.33107585f, 
    0.19776197f, 0.24627256f, 0.16087556f, -0.22391349f, -0.20992878f, 0.11896820f, 0.09233718f, -0.01745418f, 
    0.16261239f, 0.17128047f, -0.12259968f, -0.12425429f, 0.02450629f, -0.03316116f, 0.16187501f, 0.05902452f, 
    -0.13758653f, -0.30169794f, 0.14285895f, 0.29950964f, -0.14916599f, -0.23460968f, 0.03173731f, 0.55616599f, 
    0.33631587f, -0.07111177f, -0.06369600f, -0.19660409f, -0.60541517f, 0.08851796f, -0.12028491f, -0.22410439f, 
    0.24029869f, 0.08943617f, 0.68745786f, 0.05585121f, -0.15431020f, 0.32264894f, -0.48751318f, 0.33462232f, 
    -0.40230691f, -0.01273894f, -0.06718002f, 0.37042359f, -0.29754469f, 0.35831651f, -0.35033152f, 0.17193070f, 
    -0.14622250f, -0.60265237f, 0.16652782f, 0.52371323f, -0.20342788f, 0.60200280f, -0.15517315f, -0.30194920f, 
    0.38141000f, 0.22640955f, 0.46215573f, -0.02309596f, -0.21864299f, 0.33508661f, -0.54787946f, -0.13910545f, 
    -0.10233354f, 0.63196123f, -0.02001389f, 0.36308202f, 0.08234057f, 0.02342192f, 0.33806708f, 0.31701827f, 
    0.11594270f, -0.12380135f, -0.55626070f, -0.06273074f, -0.24673983f, -0.05964799f, 0.01770543f, -0.23372062f, 
    -0.14001685f, 0.05510059f, 0.17056182f, -0.24523877f, 0.06942746f, 0.16220094f, 0.00096239f, -0.03871926f, 
    -0.24412996f, -0.11639458f, -0.04292722f, 0.03916236f, -0.01700051f, -0.22143282f, -0.12697309f, -0.15664722f, 
    0.16061682f, 0.01849965f, 0.11350217f, 0.35254684f, -0.09867138f, -0.37585613f, -0.03740844f, -0.39447358f, 
    -0.70740265f, 0.12536429f, 0.47816020f, 0.09082987f, 0.75623798f, 0.21529932f, -0.24357256f, 0.37947544f, 
    -0.09608336f, -0.05123477f, -0.02485236f, 0.06954031f, 0.10098114f, 0.43352318f, 0.31618640f, -0.42222917f, 
    -0.23677011f, -0.13123009f, 0.89066994f, 0.39121974f, -0.10275155f, 0.00557478f, -0.17566791f, 0.35302231f, 
    -0.16047919f, -0.52966028f, 0.39037690f, 0.26698416f, 0.17204186f, 0.05602272f, -0.36262622f, 0.42822921f, 
    0.39577934f, -0.14006603f, 0.12694350f, 0.27346107f, 0.27013949f, -0.13427274f, -0.31020913f, 0.42855695f, 
    0.00246312f, -0.16209075f, -0.06527285f, -0.19560364f, 0.03134335f, 0.62122315f, -0.05595278f, 0.58138925f, 
    0.00348238f, 0.12226620f, 0.41041341f, -0.48913002f, 0.30917549f, 0.05822433f, 0.00251032f, 0.36290959f, 
    -0.22616918f, -0.46702406f, -0.14681253f, 0.41736981f, 0.03092086f, -0.27197194f, 0.14823784f, 0.43643972f, 
    0.52171570f, -0.25677267f, 0.13332753f, 0.48444644f, 0.36339903f, -0.43369859f, 0.21033743f, -0.12199715f, 
    -0.00365186f, 0.34641629f, 0.14127573f, -0.06101661f, 0.01600617f, -0.72119766f, -0.00834988f, -0.13324542f, 
    0.12488848f, -0.17144345f, -0.05373847f, 0.04248653f, 0.67870581f, -0.04640376f, 0.58135819f, -0.21607126f, 
    0.03237246f, 0.47922838f, -0.34272945f, 0.48129380f, 0.19003946f, 0.41423476f, 0.53483242f, -0.44938365f, 
    0.06777572f, -0.21410586f, -0.35970935f, 0.14645207f, 0.18084475f, 0.20446594f, -0.32896265f, 0.41126907f, 
    0.23583175f, -0.60351020f, 0.07652468f, -0.04877285f, 0.09632602f, -0.49209663f, 0.29261699f, 0.72982883f, 
    -0.24889296f, -0.12685642f, -0.21090508f, 0.11712965f, 0.01933850f, 0.11645810f, 0.29763040f, -0.28193101f, 
    0.16508943f, -0.12879097f, -0.06584603f, -0.11942035f, -0.05230889f, 0.19897676f, -0.08793411f, 0.07942125f, 
    -0.10958675f, -0.02275923f, 0.10962898f, -0.10854891f, 0.10484761f, -0.22741288f, -0.15676704f, 0.19711486f, 
    0.20710227f, -0.20311348f, -0.50163150f, 0.59996760f, 0.18909682f, -0.16443917f, -0.04828240f, -0.03692441f, 
    0.68338233f, 0.05838218f, -0.19306332f, -0.25737330f, 0.55331904f, 0.13207366f, 0.38582864f, 0.12463692f, 
    0.13153408f, 0.05306610f, 0.04730332f, -0.19746645f, 0.15364431f, 0.43634304f, -0.25966793f, -0.43894249f, 
    0.40376320f, 0.18503235f, 0.42096722f, -0.29426733f, 0.29255700f, 0.29155558f, 0.34697923f, -0.58765614f, 
    0.11776466f, -0.15052754f, -0.22591232f, -0.14996372f, 0.05843194f, -0.41222623f, 0.20962924f, 0.43812564f, 
    0.33552843f, -0.21038744f, 0.36633760f, -0.29031432f, 0.00159263f, 0.07173877f, 0.47977573f, 0.73849952f, 
    -0.11307468f, -0.52631217f, -0.02591150f, -0.49545830f, -0.19412589f, 0.23455496f, 0.47036180f, 0.57524955f, 
    -0.10954921f, -0.01909652f, 0.48304465f, 0.11493135f, 0.18562429f, 0.09086213f, 0.22358644f, -0.48251674f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00667464f, 0.09380378f, 0.36253634f, 0.43305457f, -0.19748545f, 0.42785612f, 0.04412917f, 0.19723223f, 
    0.21836084f, -0.00090863f, 0.28408191f, -0.14799482f, -0.02956834f, -0.10929395f, 0.44745895f, 0.63268757f, 
    0.03168384f, 0.30615002f, -0.04280771f, 0.11857798f, 0.17589864f, -0.08564345f, 0.03214661f, -0.15883690f, 
    0.03016591f, 0.25714868f, -0.11794225f, -0.00133955f, -0.13445115f, 0.17072468f, -0.07079931f, 0.02079880f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.29476821f, -0.01397885f, 0.21830796f, 0.12158757f, -0.04958741f, -0.26502401f, -0.61592078f, -0.09436131f, 
    0.05533981f, 0.54198718f, -0.13104005f, -0.07835297f, 0.28112999f, -0.21138060f, -0.38491642f, 0.21717305f, 
    -0.27086195f, -0.25556648f, -0.13525678f, 0.60217458f, 0.33996224f, 0.11106507f, -0.74545908f, 0.17110956f, 
    0.26575628f, -0.10779741f, 0.22123897f, 0.03525908f, -0.77918243f, -0.40738162f, -0.13329655f, -0.13259216f, 
    0.24134709f, -0.76628900f, 0.11982215f, -0.17967644f, -0.13946310f, -0.25114906f, -0.53976184f, 0.16648826f, 
    0.34581131f, 0.41602227f, 0.22695252f, 0.01981235f, 0.21717818f, -0.11943447f, 0.15905398f, 0.02319556f, 
    0.04798072f, -0.45036694f, -0.17695718f, 0.15572545f, 0.01311416f, -0.09257546f, 0.21769103f, -0.32660937f, 
    -0.10408155f, -0.39441741f, -0.21389247f, -0.09205078f, -0.12569834f, 0.46414027f, 0.11885251f, 0.36709127f, 
    -0.21595305f, -0.03694963f, 0.08840202f, 0.36708847f, 0.11537423f, -0.26327917f, -0.10260340f, 0.11233128f, 
    0.31290266f, -0.79083818f, 0.03870204f, 0.11833964f, 0.56796777f, -0.03947862f, -0.37746298f, -0.57064718f, 
    -0.82388502f, 0.01492439f, -0.17366676f, -0.94309396f, 0.04571725f, -0.69749779f, -0.22645296f, 0.56664246f, 
    0.16800782f, -0.08218607f, 0.41012883f, 0.06813430f, -0.24486126f, -0.47119868f, 0.23859254f, 0.56137186f, 
    0.40349367f, 0.33639362f, -0.36789191f, 0.29347944f, -0.11483560f, 0.20403297f, -0.26601946f, -0.10563514f, 
    -0.28400499f, -0.47122195f, 0.21034271f, -0.05157481f, -0.95860827f, -0.04233676f, -0.69486570f, -0.18480562f, 
    -0.65755332f, 0.13227864f, 0.14534198f, 0.10910144f, 0.23028404f, -0.24917383f, 0.23230870f, -0.49339101f, 
    -0.24041745f, 0.37736058f, -1.35363185f, 0.00258360f, -0.03936234f, -0.57847327f, 0.46714526f, -1.33172762f, 
    -0.51936251f, -0.20102637f, -0.17566203f, 0.13926865f, -0.10923488f, 0.27622846f, 0.21636297f, -0.35191432f, 
    0.38505477f, -0.10097001f, 0.09200608f, 0.16446184f, -0.27545002f, -0.19406329f, 0.02245034f, 0.05432796f, 
    0.29360628f, 0.32005525f, -0.04152250f, -0.02961678f, 0.07893463f, -0.42677087f, 0.30832979f, -0.64603198f, 
    -0.69300616f, 0.31835049f, 0.20181867f, -0.11511638f, 0.21761447f, -0.03230386f, -0.20176342f, -0.08700635f, 
    -0.19642334f, -0.37995663f, 0.07281900f, -0.41897199f, 0.05585625f, 0.15662096f, -0.30041221f, 0.15666419f, 
    -0.26619506f, 0.32634541f, -0.51878369f, -0.14609179f, 0.02845583f, -0.04130537f, 0.56541800f, 0.27851287f, 
    0.43806592f, -0.64254570f, 0.10502902f, 0.27037305f, 0.32182607f, -0.03567944f, 0.02464728f, -0.62500960f, 
    -0.04937878f, -0.10732122f, -0.04686263f, 0.17496514f, -0.27334985f, 0.65648907f, -0.42416769f, -0.03570960f, 
    -0.33640882f, 0.19659193f, -0.08260366f, 0.21221794f, -0.12175079f, 0.37113529f, -0.31886601f, 0.19381018f, 
    -0.10367951f, -0.12254183f, -0.96423531f, -0.09673649f, 0.25379795f, 0.13489774f, -0.72167873f, 0.27497751f, 
    0.31051409f, -0.09715674f, -0.16648749f, -0.25466150f, 0.21614474f, 0.33925396f, -0.09547077f, -0.30810061f, 
    -0.78520924f, 0.22309060f, -1.02498865f, -0.01689052f, -0.71912360f, -0.06500933f, -0.52305603f, -0.03763055f, 
    -0.69832027f, 0.16618605f, -0.69620281f, -0.40451038f, 0.02960603f, -0.26807085f, 0.37615535f, -1.03693438f, 
    -0.16096054f, -0.22876669f, 0.23065972f, -0.08758008f, 0.05539914f, -0.15352695f, -0.14341250f, -0.75113827f, 
    -0.39802447f, -0.41631639f, -0.00851878f, 0.39558792f, -0.54015005f, 0.35146308f, 0.21933670f, 0.54922438f, 
    0.63475317f, 0.03832546f, 0.09901791f, -0.17229189f, 0.55968004f, 0.13465479f, 0.09097480f, 0.15351953f, 
    0.55800956f, -0.59758717f, 0.19671063f, -0.28220123f, -0.12247072f, -0.78858715f, -0.04386063f, 0.07494737f, 
    -0.04757521f, 0.10890634f, -0.36298046f, -0.10907178f, -0.47780210f, -0.02049412f, 0.09945472f, 0.29989600f, 
    0.02257315f, -0.33794627f, 0.14363413f, -0.63941580f, -0.67058784f, 0.43529895f, 0.67776549f, 0.13121259f, 
    -0.58479339f, -0.67220229f, 0.27930567f, 0.00684893f, 0.04110717f, 0.03466909f, 0.59467399f, 0.05215238f, 
    -0.72325796f, 0.08590125f, 0.07448239f, 0.50075448f, 0.13829535f, -0.16657956f, 0.76077271f, -0.36378726f, 
    -0.55563915f, -0.11684765f, -0.49877888f, -0.14040059f, -0.04627116f, -0.21325609f, 0.16801602f, 0.34368238f, 
    -0.02918585f, 0.19863276f, -0.06191495f, 0.10176908f, -0.03845367f, 0.28993893f, -0.10102218f, 0.33345896f, 
    -0.17973150f, -0.03793242f, -0.16973989f, -0.17074984f, -0.20778272f, -0.34974372f, -0.44299155f, -0.00216284f, 
    0.31645936f, -0.01781191f, -0.25030139f, -0.52111745f, -0.04201720f, 0.40701887f, 0.30099949f, 0.23778443f, 
    0.44275859f, 0.23949476f, 0.12883802f, 0.12538241f, -0.49499214f, 0.13768460f, -0.44889697f, 0.15355517f, 
    -0.87408626f, 0.53237492f, 0.14578307f, -0.27770075f, -0.86188644f, -0.72884327f, -0.78494668f, -0.76792270f, 
    0.57219255f, -0.10576361f, -0.54461002f, 0.00155151f, -0.15142357f, 0.37259969f, -0.15090151f, -0.24296714f, 
    0.25448993f, 0.30610546f, -0.16381055f, -0.00029127f, -0.12135302f, -0.11046049f, -0.47938442f, 0.28929326f, 
    -0.51834404f, -0.77101266f, 0.20604064f, -0.11513504f, -0.42946750f, -0.21433575f, 0.13841954f, -0.15831248f, 
    0.45823306f, 0.08768055f, 0.10044196f, -0.32288694f, -0.05586265f, 0.25854766f, -0.92036450f, 0.69103616f, 
    -0.17064248f, 0.05281055f, -0.51386702f, 0.13408236f, 0.32550514f, 0.08542023f, 0.25077465f, -0.93300617f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03778696f, 0.21125709f, -0.23238726f, -0.07875256f, 0.20867756f, -0.15568331f, -0.13987598f, -0.56378645f, 
    -0.26664913f, 0.26937339f, 0.23970997f, 0.34259284f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
