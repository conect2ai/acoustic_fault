#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.96045405f, 0.87621236f, 0.56249017f, -0.26804140f, -0.34151575f, 0.63271838f, 0.54701561f, -0.56272388f, 
    -0.00687479f, 0.45907581f, 0.49599785f, 0.61738896f, 0.33720157f, -0.20465039f, 0.37015170f, 0.20768987f, 
    -0.09896155f, -0.03797754f, 0.69579768f, 0.66064048f, 0.34909874f, 0.51034534f, 0.01452360f, -0.71441776f, 
    0.15488733f, -0.10403714f, -0.08248189f, -0.43515062f, 0.29301760f, 0.85241139f, -0.03813902f, -0.43217704f, 
    -0.32677534f, -0.52465910f, -0.70460564f, -0.65829188f, -0.07133096f, 0.44586888f, -0.19479540f, -0.18537284f, 
    0.24150725f, 0.59378606f, 0.67025554f, -0.62845111f, -0.34260604f, -1.13732350f, -0.57227951f, -0.74479908f, 
    0.67199689f, -0.60464150f, -0.34708500f, 0.02171853f, -0.22707769f, -0.23519689f, 0.91407382f, -0.11851341f, 
    0.94359303f, -0.51150149f, -0.72297722f, -0.49757579f, 0.37591290f, 0.54086512f, 0.25064656f, -1.36789334f, 
    -1.20202851f, 0.92373133f, 0.10860901f, 0.36562955f, -0.41035327f, -0.28206760f, -0.39827690f, -0.17266124f, 
    -0.64962620f, -0.48368382f, -1.11017907f, 0.55874389f, 0.44744709f, 0.35299519f, 0.65350741f, 0.55315489f, 
    0.49212313f, 0.63861293f, 0.04332332f, -0.71986151f, -0.37587187f, -0.12699731f, 0.30634013f, 0.47105315f, 
    0.13965079f, 0.63118351f, -0.80369449f, -0.79090416f, -1.19572258f, 0.98810768f, 0.24054490f, 0.40786514f, 
    -0.61792082f, -0.58832783f, -0.61228323f, -1.04163134f, 0.72520077f, 0.01217055f, 0.44665796f, -0.84783369f, 
    -0.55229872f, 0.55354285f, 0.54253453f, -0.07080339f, 0.52539051f, -0.07853379f, 0.19938098f, 0.53094083f, 
    0.89902157f, 0.67732030f, 0.13691525f, 0.51786917f, 0.08361323f, 0.31722727f, 0.22967251f, -0.18631497f, 
    0.01795261f, 0.23584446f, -0.24727879f, 0.42655349f, 0.36210150f, 0.50614840f, 0.73368973f, 0.28775427f, 
    0.82781291f, -0.52350909f, -0.08913344f, 0.41636598f, -0.26619768f, -0.03032852f, 0.21942773f, -0.15958472f, 
    -0.05876179f, 0.39588746f, 0.62236798f, 0.49835286f, -0.33371574f, 0.16047445f, 0.56531584f, -0.48752019f, 
    -0.49383476f, -0.36026391f, 0.00226143f, -0.59220207f, -0.17515053f, -1.15743697f, 0.02652607f, 0.55655962f, 
    0.80066687f, -0.27997926f, -0.64965075f, -0.10057400f, -0.77131754f, -0.53799540f, -0.36250845f, -0.03015819f, 
    -0.42633787f, -0.69737291f, 1.39994764f, -1.13158631f, -1.06438994f, 0.85547310f, -0.17140019f, 0.08446638f, 
    -0.28014618f, 0.28944731f, -0.02483158f, -1.00053298f, 0.40590504f, 0.79744047f, -0.93391740f, -0.15936081f, 
    0.91955560f, -0.62079144f, 0.28930593f, 0.58745950f, -0.94084537f, 0.03267111f, -0.11550057f, 0.45235494f, 
    1.28142285f, 0.40862125f, -0.26426759f, 0.12931244f, -0.03610634f, -0.18766221f, -0.49937814f, -0.47808680f, 
    -0.69215816f, -0.65913188f, -0.93742007f, -0.29830027f, -0.63779497f, 0.55559087f, -0.81712794f, -0.27033362f, 
    0.87265366f, 0.55922627f, 0.63624412f, 0.09898303f, -0.35699850f, -0.47536996f, -0.68618929f, 0.40353307f, 
    0.16508709f, -0.26242572f, -0.69427246f, -0.86350840f, -1.01798725f, -0.41616759f, -0.76057661f, -0.78149420f, 
    -0.57164764f, 0.62114543f, 0.36118671f, -0.81023026f, -1.03459287f, -0.88936466f, 0.02009953f, 0.09849590f, 
    0.11174762f, 0.17919919f, -0.59662545f, 1.29850972f, -0.53131312f, 0.51441455f, -0.43229529f, 0.72307748f, 
    -0.52333558f, -0.28971702f, -1.16187859f, 0.07569201f, 0.82258612f, 0.30532369f, -0.11532450f, 0.05419073f, 
    0.30734828f, 0.44652891f, 0.23538017f, 0.39526597f, 1.10690641f, -1.57911921f, 0.31544510f, -0.24276876f, 
    -0.46513903f, -0.37668413f, 0.52730078f, -0.25017816f, 1.18876362f, -0.34438038f, -0.46119070f, 0.49976611f, 
    0.08813111f, 0.27558488f, -0.23415174f, 0.46820191f, -0.82332164f, 0.53937024f, 0.61868453f, -0.03014424f, 
    0.09644842f, 0.03714992f, -0.38045156f, -0.49707407f, 0.46957183f, 0.24835409f, -1.52752602f, -0.21296991f, 
    0.41234043f, 0.30889335f, 0.31653616f, -0.58852559f, 0.63036126f, 0.62849540f, 0.06057122f, 0.48572406f, 
    0.14379255f, -0.84534526f, -0.67404103f, -0.09692058f, -0.64128369f, 0.37686306f, 0.59368128f, 0.93485260f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07906361f, 0.43161228f, 0.28398198f, 0.07582004f, 0.70454854f, -0.07143623f, 0.09547529f, 0.30433947f, 
    0.45112744f, 0.29695603f, 0.36464548f, 0.13369554f, -0.36324659f, -0.34646645f, 0.29438457f, 0.50075966f, 
    -0.11200888f, 0.34776828f, 0.29516092f, 0.38735950f, -0.22482206f, -0.44280696f, 0.10485056f, 0.08317897f, 
    0.61211783f, -0.06303049f, -0.19267149f, -0.10356122f, -0.19757311f, 0.69466758f, 0.16728316f, -0.08677175f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02516764f, 0.01155541f, 0.06318693f, 0.06720285f, -0.06058589f, 0.02822372f, 0.14425735f, 0.04833431f, 
    -0.24416605f, -0.10193862f, 0.08437136f, -0.01490922f, 0.04978081f, -0.02072646f, 0.03067240f, 0.04758498f, 
    -0.08497035f, -0.05156282f, -0.08083291f, 0.02557233f, -0.00254617f, 0.14728296f, -0.04755243f, 0.00850751f, 
    0.07041011f, -0.05125455f, -0.19335051f, 0.07029832f, 0.00919403f, -0.10430481f, -0.02610256f, -0.17001994f, 
    0.00467083f, -0.29472154f, -0.27470693f, -0.32562736f, 0.09970506f, 0.12594870f, 0.05863965f, 0.11123928f, 
    0.06781688f, 0.23164535f, -0.08618875f, 0.03085364f, -0.20013607f, -0.09626886f, -0.18495616f, -0.05575730f, 
    0.02732458f, -0.08806104f, -0.05157701f, -0.04960357f, -0.23557456f, -0.00255007f, 0.05828078f, 0.10685250f, 
    0.12210179f, 0.22196274f, 0.09792738f, -0.15160219f, 0.18166782f, 0.12771817f, 0.03188568f, -0.18533728f, 
    0.16819178f, 0.11240218f, -0.02290895f, -0.04974371f, 0.01512921f, -0.18561500f, -0.14219454f, -0.27867007f, 
    0.09442731f, 0.01812329f, 0.10135620f, 0.11376285f, 0.07193223f, -0.08985183f, 0.06083326f, -0.01090235f, 
    0.21844877f, 0.06929455f, -0.03708770f, 0.01253831f, -0.09721981f, 0.08048696f, -0.12568544f, 0.14452703f, 
    0.24109830f, 0.12927061f, -0.04612558f, 0.11710470f, -0.02282946f, 0.07808182f, -0.13183384f, 0.00593037f, 
    -0.31777284f, -0.40936890f, -0.43864018f, -0.07279136f, 0.33157122f, -0.03531885f, 0.13275087f, -0.09563429f, 
    0.08432332f, 0.17603628f, 0.18707643f, 0.07896132f, -0.11672922f, -0.14145654f, -0.11185618f, 0.21117708f, 
    0.23711365f, 0.00068695f, -0.07783496f, 0.10188116f, 0.07638034f, -0.01795059f, -0.15727429f, -0.07430071f, 
    0.19693010f, 0.07613637f, -0.08248398f, 0.07800294f, 0.16301849f, 0.12486838f, -0.11350527f, 0.13301840f, 
    0.21762449f, -0.01342015f, 0.00206158f, -0.04620174f, -0.03762784f, -0.01642373f, -0.05438811f, 0.10794055f, 
    0.06986044f, -0.08353882f, 0.17655995f, 0.29376772f, 0.18387640f, 0.09011718f, 0.04750870f, 0.15576139f, 
    0.05831922f, 0.01442796f, -0.19316238f, -0.01029831f, 0.05408197f, -0.02191586f, 0.35056239f, 0.12216181f, 
    0.25698331f, -0.02320833f, -0.16623414f, 0.00883440f, 0.13218729f, -0.14234287f, -0.07023031f, -0.05074492f, 
    -0.13926530f, -0.10636193f, -0.10944463f, 0.23154767f, 0.28366476f, 0.36189225f, 0.09353457f, -0.24287450f, 
    0.05627890f, -0.32223052f, 0.05116519f, 0.41566789f, -0.18816873f, 0.24606897f, 0.36853862f, -0.07451088f, 
    0.04102537f, 0.05543998f, 0.15734674f, 0.34804165f, 0.00849651f, -0.08861645f, 0.03516681f, 0.29391697f, 
    0.35455388f, 0.35486096f, -0.05284309f, 0.03522912f, 0.05763424f, 0.22300571f, -0.47659859f, -0.26008752f, 
    0.10612206f, 0.03175041f, 0.01473473f, 0.18509172f, 0.04516604f, 0.05530862f, 0.10475160f, -0.13620555f, 
    -0.03646210f, 0.03709983f, 0.01585583f, 0.19607653f, -0.34831148f, -0.10319885f, -0.60479152f, 0.00340390f, 
    -0.31638384f, -0.32397991f, 0.18090603f, -0.06190457f, -0.06409802f, -0.00692933f, -0.15776926f, -0.50169665f, 
    0.05481701f, 0.25772882f, -0.03282817f, 0.09565101f, -0.05453055f, -0.02014374f, 0.12906259f, 0.10830149f, 
    0.04392301f, 0.36387712f, 0.52166051f, 0.19829200f, 0.04324893f, -0.00027445f, 0.11125159f, -0.19374321f, 
    0.37534252f, -0.21064396f, -0.02115323f, 0.09839295f, -0.00843407f, 0.10396408f, -0.19144735f, -0.04825721f, 
    0.02647960f, 0.10928013f, 0.11895908f, 0.27143103f, 0.81977141f, 0.04744368f, 0.18240581f, 0.39765176f, 
    0.30675867f, 0.20773949f, 0.09754650f, 0.03801251f, -0.03939062f, -0.06220873f, 0.00101799f, 0.29138061f, 
    0.32478037f, -0.04463277f, -0.03893297f, -0.21586999f, -0.03312797f, 0.01650310f, 0.06723215f, 0.11602574f, 
    0.12803712f, 0.12814620f, 0.02691420f, 0.19768278f, 0.21456787f, 0.03316512f, -0.18092005f, 0.24440260f, 
    0.10842443f, -0.09545635f, -0.04959100f, -0.01166085f, 0.05160647f, 0.15413706f, 0.18208776f, 0.03238610f, 
    -0.16333413f, -0.21443295f, -0.21859585f, -0.14612989f, -0.09024423f, 0.24548814f, 0.25959840f, 0.14165272f, 
    -0.03201095f, 0.18724282f, 0.03170896f, -0.04843479f, -0.09488610f, -0.11585213f, 0.06839873f, -0.03644176f, 
    -0.08789168f, 0.06767811f, 0.09807447f, -0.00193535f, -0.14230886f, -0.02799767f, -0.09693596f, 0.08597229f, 
    -0.02287936f, 0.02865861f, -0.02043357f, 0.03484196f, -0.01354635f, 0.04352693f, -0.03040757f, -0.07998335f, 
    0.06833231f, 0.11623427f, -0.08312479f, 0.01845628f, 0.06000189f, -0.16312164f, -0.08423617f, -0.05952127f, 
    0.03032013f, -0.00252548f, -0.01539418f, 0.13160315f, 0.17397697f, 0.29502657f, 0.13427934f, 0.12383251f, 
    0.09809675f, -0.26249969f, -0.01927710f, -0.15441728f, -0.08737904f, 0.03304252f, 0.19961788f, 0.36714092f, 
    -0.15687224f, -0.08521903f, 0.02882963f, -0.10095260f, -0.02176975f, 0.06780872f, 0.07547397f, -0.22242458f, 
    -0.43451673f, -0.01352568f, -0.11441792f, -0.24530783f, -0.09593138f, 0.09549912f, 0.19591875f, 0.06797277f, 
    -0.13661075f, -0.33146271f, 0.08790426f, -0.12273670f, 0.01269988f, 0.18145049f, 0.03415770f, -0.14349988f, 
    -0.02736469f, -0.17335227f, -0.03109344f, 0.00323350f, 0.13724530f, 0.03252758f, -0.04416655f, -0.07065849f, 
    0.10109559f, -0.26000664f, -0.04613331f, -0.20584568f, 0.28053653f, 0.01943122f, 0.08906780f, 0.04148580f, 
    0.04855475f, 0.08216729f, -0.11519682f, -0.18731229f, 0.07620022f, -0.18981260f, -0.08313715f, 0.21023756f, 
    0.04553486f, 0.09412092f, -0.18150325f, 0.12251002f, -0.16689020f, -0.17138796f, 0.10621358f, 0.23853359f, 
    0.18991283f, -0.09056960f, -0.06049864f, 0.16446070f, 0.07005554f, 0.07559143f, 0.18124074f, -0.02303591f, 
    -0.07409267f, -0.26312095f, -0.05182758f, -0.06798890f, -0.10244936f, -0.16189106f, -0.06871726f, -0.10282295f, 
    0.06706054f, -0.02227956f, -0.14716670f, -0.09324535f, -0.01885596f, 0.00347438f, 0.06841335f, 0.01216447f, 
    -0.06868943f, 0.00742427f, -0.06243157f, -0.09927057f, 0.04925906f, 0.09374380f, -0.03384167f, 0.14080451f, 
    -0.02299696f, 0.18062122f, 0.11777674f, 0.08895439f, -0.00841609f, -0.13264808f, 0.09876674f, 0.03623033f, 
    0.25389153f, -0.01056043f, -0.07392076f, 0.26285183f, 0.14670253f, 0.04960766f, -0.10841747f, 0.01208158f, 
    0.18411084f, -0.06621220f, -0.22302094f, -0.09166440f, 0.05107411f, 0.01310605f, -0.00276458f, 0.04968350f, 
    0.15677273f, 0.16301043f, 0.63136441f, -0.09477571f, -0.22678405f, 0.22216412f, 0.18106641f, -0.02586710f, 
    0.03317928f, 0.03454422f, 0.09306279f, 0.24091111f, -0.11756390f, -0.25349003f, 0.20854394f, -0.22426897f, 
    0.00982147f, 0.09144812f, -0.19863528f, 0.15413716f, 0.03855072f, -0.18428828f, 0.06979770f, -0.20281918f, 
    0.07411084f, -0.17640704f, 0.03122085f, -0.09725237f, -0.11816961f, -0.10545807f, -0.18436548f, -0.04257144f, 
    0.05322928f, 0.00752816f, -0.14761662f, 0.07276955f, 0.05619034f, 0.15386145f, -0.00219698f, -0.02329738f, 
    0.17741685f, -0.06843401f, -0.17291537f, 0.03795979f, 0.08091985f, 0.11184106f, -0.18447033f, -0.04925464f, 
    -0.16543105f, -0.10473675f, -0.05242574f, -0.02068805f, -0.05311909f, -0.07427794f, 0.02825531f, 0.02567215f, 
    -0.07339074f, 0.05374797f, -0.13399026f, 0.08635261f, 0.13733751f, 0.15302773f, -0.03936980f, 0.06496282f, 
    0.13214900f, 0.36123863f, -0.22644907f, -0.31301615f, -0.03899023f, 0.01367537f, -0.27008438f, -0.18482125f, 
    0.17034680f, -0.10099167f, 0.27274722f, -0.09550595f, -0.12770483f, 0.01035538f, -0.02103387f, -0.15314034f, 
    -0.04293318f, -0.23983483f, 0.07829043f, -0.48350942f, -0.31534481f, -0.65682775f, 0.09287705f, -0.12736081f, 
    0.28439885f, -0.09322915f, -0.14434263f, 0.04073094f, 0.26268262f, 0.20745173f, -0.11041536f, -0.08365018f, 
    -0.18049701f, -0.12159941f, -0.11401539f, -0.03486120f, -0.03704531f, -0.06661365f, 0.16791630f, -0.06663282f, 
    -0.00502067f, -0.04473186f, 0.01416412f, 0.22109950f, 0.06653710f, 0.22904235f, 0.11488365f, -0.27634427f, 
    -0.02196222f, 0.00175439f, 0.03155216f, 0.04785048f, -0.10586480f, -0.08781392f, 0.00576321f, -0.70465261f, 
    -0.31843814f, -0.25159085f, 0.30050415f, 0.10805585f, 0.02621154f, -0.03927557f, 0.07508190f, 0.16301909f, 
    -0.15401621f, -0.15466666f, -0.08686342f, -0.06458038f, 0.09704431f, -0.16689040f, -0.21037994f, -0.12759607f, 
    -0.01870632f, -0.18830185f, -0.02536923f, -0.07635501f, 0.07919542f, 0.10237166f, -0.12685901f, -0.03523219f, 
    0.02056167f, -0.17005268f, -0.11359770f, -0.03787691f, -0.04362478f, 0.06425425f, 0.10577410f, -0.09723567f, 
    -0.08788301f, 0.06939328f, -0.14239028f, -0.19704439f, 0.32589391f, 0.22273280f, 0.07688568f, 0.19045213f, 
    0.07558578f, -0.11986699f, -0.00016631f, -0.13061495f, -0.04083343f, -0.19084209f, -0.01961240f, -0.01165823f, 
    0.06293909f, 0.17687468f, 0.07715081f, -0.18497810f, 0.15824448f, -0.17028205f, 0.13702086f, -0.05322591f, 
    0.08819108f, 0.22296719f, -0.01637202f, 0.06980833f, 0.05229986f, 0.15283205f, -0.08825181f, 0.02710708f, 
    0.02454489f, 0.20397015f, 0.03170893f, -0.02414029f, 0.06682745f, 0.10779388f, -0.00836500f, -0.12991336f, 
    0.33110109f, -0.13141531f, -0.15296602f, -0.01383351f, 0.25832558f, -0.12854068f, 0.17261755f, 0.11370719f, 
    0.08014377f, 0.18500397f, -0.17565186f, 0.01515782f, 0.04961751f, -0.09605073f, 0.00297013f, -0.30398485f, 
    -0.21628450f, 0.04801175f, -0.02739287f, -0.02752259f, -0.06971680f, 0.09621493f, -0.21028563f, 0.08166352f, 
    0.01175257f, -0.06833598f, 0.07191081f, 0.19060095f, -0.12404834f, -0.24154960f, -0.01864649f, 0.28322545f, 
    0.03942923f, 0.24701282f, 0.17750998f, 0.00374124f, 0.29223239f, 0.05927490f, 0.12749501f, 0.03552938f, 
    0.15236992f, 0.02729334f, -0.22270782f, 0.16449778f, 0.02811293f, -0.03784122f, -0.01969656f, 0.04899446f, 
    0.08372129f, 0.11963397f, 0.16917056f, 0.19068059f, -0.09036224f, 0.06639188f, -0.00996591f, 0.00748975f, 
    -0.07450446f, -0.04142245f, -0.02180490f, 0.21228607f, 0.02680155f, 0.01659077f, -0.33214527f, 0.04729431f, 
    -0.13306001f, -0.00561322f, 0.08287706f, -0.07009377f, -0.12995014f, -0.02525418f, -0.15136085f, 0.07934073f, 
    0.04462630f, -0.02117604f, 0.06218261f, 0.22184734f, 0.03353391f, 0.14537399f, 0.07886393f, 0.09454567f, 
    0.08034091f, 0.16958798f, -0.11811165f, -0.01073181f, 0.04134096f, -0.08716979f, 0.08253777f, -0.17428297f, 
    0.10881963f, -0.20414405f, 0.14992283f, 0.12152830f, 0.02475407f, 0.28572333f, -0.17305805f, -0.11045735f, 
    0.03018861f, 0.04693950f, -0.11546977f, 0.01367927f, 0.65007019f, 0.09375071f, -0.01762731f, 0.08563185f, 
    -0.12247013f, 0.32729861f, 0.21460888f, -0.02144219f, 0.14079578f, 0.01916830f, 0.08023898f, 0.05571514f, 
    -0.07803731f, 0.09426180f, -0.00988718f, -0.10188247f, 0.08936487f, -0.11982482f, -0.26127952f, 0.05223868f, 
    0.02453693f, 0.08879276f, 0.02776776f, 0.05883592f, 0.05289101f, 0.07497665f, 0.02972387f, 0.18794720f, 
    -0.03401591f, -0.01865157f, -0.31902349f, -0.01052667f, 0.11952697f, 0.09916403f, -0.04549693f, 0.26926485f, 
    -0.46940073f, -0.12508497f, -0.13246326f, 0.14044322f, -0.10852029f, 0.14431721f, 0.04230593f, -0.26437408f, 
    0.03594874f, 0.14063558f, 0.11389846f, 0.19551039f, -0.16581251f, -0.03989434f, 0.10917699f, 0.03247248f, 
    -0.26978266f, 0.06682035f, 0.04065711f, 0.09187771f, 0.03021189f, 0.13845728f, -0.05536690f, 0.02586058f, 
    0.25614551f, 0.03691863f, 0.50998217f, 0.15842620f, 0.16928133f, 0.08165783f, 0.15333079f, 0.03645984f, 
    -0.09583327f, -0.01366470f, -0.10753413f, 0.04497826f, -0.10574073f, -0.02523817f, 0.07635129f, -0.14712626f, 
    0.26705548f, -0.16179864f, -0.10387872f, 0.37260625f, 0.30772451f, 0.78898627f, 0.51193112f, -0.00365481f, 
    0.08604334f, -0.03981520f, 0.18172288f, 0.26581743f, -0.11756776f, -0.35030246f, 0.47077858f, 0.03355976f, 
    -0.04491165f, 0.37325335f, -0.06346069f, 0.10898340f, 0.27583227f, -0.17095116f, 0.08495147f, 0.21376088f, 
    0.07044341f, -0.02880600f, 0.20110092f, -0.00301955f, -0.03980962f, 0.14736542f, 0.18110138f, 0.10969446f, 
    -0.10389229f, -0.09822606f, 0.21609949f, -0.25925058f, 0.15797986f, -0.27724743f, -0.01459868f, 0.05132988f, 
    0.04817390f, 0.16763605f, -0.29030663f, -0.26184878f, -0.39396450f, 0.10660893f, -0.25353277f, 0.07999317f, 
    0.03548118f, 0.03461238f, -0.06377878f, 0.02481333f, 0.00575425f, -0.00206422f, -0.00568737f, 0.04110513f, 
    0.03959565f, -0.03770600f, 0.01066250f, -0.05253480f, 0.00427262f, -0.05575749f, -0.02527274f, -0.02084784f, 
    -0.05755735f, -0.03456168f, 0.00661721f, -0.03554991f, 0.01143409f, -0.04389470f, -0.05113943f, -0.02326094f, 
    -0.01503772f, -0.03743398f, 0.00403485f, 0.02010653f, -0.04272401f, -0.04539891f, -0.03651756f, 0.05563966f, 
    0.00807276f, -0.01468877f, 0.05143017f, -0.02117865f, -0.04798035f, -0.03600040f, -0.06906416f, 0.03325260f, 
    -0.06454656f, 0.02986677f, 0.01666056f, -0.03545414f, -0.01853202f, 0.04642051f, -0.01630912f, -0.02698742f, 
    0.01148987f, -0.05552363f, 0.01439863f, -0.04263104f, 0.01134420f, -0.03553783f, -0.00385759f, -0.02742844f, 
    0.00442598f, 0.05106265f, -0.05142934f, -0.04106250f, 0.03034526f, -0.04677067f, -0.05903871f, 0.05038082f, 
    -0.05437373f, -0.06073185f, 0.00294537f, 0.02342350f, -0.00956709f, -0.06417630f, -0.03600983f, -0.04467320f, 
    -0.03766929f, 0.03523547f, -0.06750205f, 0.04865076f, 0.02031671f, 0.05251035f, -0.00168164f, 0.00158529f, 
    -0.04137941f, -0.03602192f, -0.02130760f, -0.01458892f, 0.03643533f, -0.00555094f, 0.00588310f, -0.05078607f, 
    0.01954182f, 0.01381223f, 0.03552086f, -0.06389633f, 0.02933470f, -0.05408027f, -0.00281409f, 0.01208963f, 
    -0.05322785f, 0.02519037f, 0.01200228f, 0.01393001f, 0.04368634f, -0.00014854f, 0.03735887f, 0.00068302f, 
    -0.00771545f, -0.05643478f, -0.00139421f, 0.00201286f, 0.02920385f, 0.02032959f, -0.05062725f, -0.01924298f, 
    0.04337281f, 0.03040567f, 0.03777852f, 0.01867661f, -0.00525130f, -0.02988829f, -0.05402148f, -0.03508620f, 
    -0.05322322f, 0.00636087f, -0.06053213f, 0.04448427f, 0.02076792f, -0.03562163f, 0.04633230f, 0.01142189f, 
    -0.05361098f, 0.04687833f, -0.05759918f, 0.02395221f, -0.02321530f, -0.01252511f, -0.01541347f, 0.02091579f, 
    -0.03412129f, 0.02229637f, -0.03013341f, 0.03608245f, -0.03946280f, 0.01844183f, 0.03080756f, 0.02174105f, 
    -0.00500818f, 0.00097615f, -0.00973759f, 0.00663664f, 0.05320600f, -0.02560272f, -0.00676152f, -0.05977967f, 
    0.02732464f, -0.01797471f, 0.04574188f, -0.02811824f, -0.00891039f, -0.06168512f, -0.04954166f, -0.04618199f, 
    -0.00925811f, -0.04387325f, -0.00746381f, -0.05948862f, 0.04051038f, 0.04352328f, 0.04326478f, -0.00282477f, 
    -0.01126666f, -0.04518652f, -0.02330227f, 0.02214381f, 0.01353900f, -0.05221688f, 0.02995979f, -0.06499788f, 
    0.03963706f, -0.01747283f, -0.03603135f, 0.02503959f, -0.01842948f, 0.02467407f, -0.02745586f, -0.03191580f, 
    0.00270716f, -0.03536779f, -0.04301139f, 0.00703137f, -0.02397750f, 0.01132587f, 0.01976729f, -0.01632489f, 
    -0.02157313f, 0.01526783f, -0.05892236f, -0.04842910f, 0.03070808f, 0.02686910f, -0.04804724f, -0.03993316f, 
    0.04776519f, -0.01297252f, 0.04466214f, 0.00796448f, 0.01526532f, 0.00494246f, 0.02735789f, 0.02849956f, 
    -0.05736061f, -0.05530929f, -0.03106106f, 0.04104372f, -0.05489679f, 0.06107133f, -0.04770656f, -0.05123753f, 
    -0.03602750f, 0.04413510f, 0.02124026f, 0.03007499f, -0.01532591f, -0.03549391f, 0.00803065f, -0.00525379f, 
    -0.01703767f, 0.03303584f, 0.00595526f, -0.00539962f, -0.03341647f, -0.04704452f, -0.02307087f, 0.01017985f, 
    0.00455608f, -0.05069979f, -0.02386814f, -0.02756089f, 0.01450434f, -0.01474216f, -0.01455957f, 0.01195328f, 
    -0.04759412f, -0.04555019f, -0.01607249f, 0.02729584f, -0.01151911f, 0.05654978f, -0.01136418f, -0.04112764f, 
    0.01327453f, -0.06731633f, 0.05327059f, 0.01692220f, 0.03776385f, -0.00050116f, -0.04620346f, -0.03751364f, 
    -0.02771241f, -0.01919262f, 0.00707008f, -0.03791185f, -0.00176092f, -0.02232207f, -0.04171240f, 0.04669362f, 
    0.04108002f, 0.04289664f, -0.00006879f, -0.04548995f, 0.00767642f, 0.03262210f, -0.01454493f, -0.01313740f, 
    0.01163776f, 0.02720460f, 0.03263557f, -0.06343810f, 0.02544628f, -0.02049499f, -0.00917912f, -0.03528758f, 
    0.02595515f, 0.03271826f, 0.03649680f, -0.04817598f, 0.03741301f, 0.02444308f, 0.03271433f, 0.03770625f, 
    -0.82701534f, -0.42122057f, -0.38851485f, 0.02246008f, -0.04570539f, 0.11622561f, -0.11323934f, 0.10064997f, 
    0.01600572f, -0.48898923f, -0.24788779f, 0.11918990f, 0.04817189f, 0.07020327f, 0.14582480f, -0.01785228f, 
    0.10228547f, 0.07449906f, -0.27408335f, -0.38345358f, 0.32649559f, 0.13281202f, 0.11715499f, 0.01269706f, 
    0.04091092f, 0.10532004f, -0.01866392f, -0.05874001f, 0.13969322f, 0.11226331f, -0.00440820f, 0.19637312f, 
    0.04671964f, 0.04177591f, 0.01931948f, 0.02997341f, -0.11466070f, 0.05293938f, 0.07022893f, -0.02874761f, 
    0.04647527f, -0.00211620f, 0.00471985f, 0.24874446f, 0.05989530f, -0.26456606f, -0.60225594f, 0.32534903f, 
    -0.07747086f, 0.01894464f, -0.02125194f, 0.13355882f, -0.07775915f, 0.08187024f, 0.13218719f, 0.09894782f, 
    0.02295052f, 0.15306848f, 0.16554770f, 0.14806110f, 0.10125917f, -0.16422413f, -0.13324408f, -0.09130709f, 
    0.01206197f, -0.03501633f, -0.09100550f, 0.07062343f, -0.26327360f, 0.12709881f, 0.04451371f, -0.07001637f, 
    0.05703342f, -0.06469855f, 0.46359003f, -0.03401853f, -0.14485332f, -0.31295481f, 0.09059651f, 0.09897461f, 
    0.20443919f, -0.23400803f, 0.37400830f, 0.48966670f, 0.17605227f, -0.00910475f, 0.20092496f, -0.00156501f, 
    0.05027919f, 0.02994221f, 0.26508498f, -0.02248551f, 0.18113452f, -0.01646784f, 0.03984050f, -0.03117974f, 
    0.18705115f, -0.06012510f, -0.04706568f, 0.38676447f, -0.31465802f, -0.12763892f, -0.22069003f, 0.17492864f, 
    -0.05802636f, 0.13854185f, 0.08239568f, 0.11686674f, -0.08886219f, -0.01235892f, 0.23587170f, -0.07622584f, 
    -0.17410299f, -0.17988935f, 0.17081827f, 0.02822554f, 0.13024168f, -0.08051884f, 0.10386674f, 0.27773884f, 
    0.03302090f, -0.12574618f, -0.04810113f, 0.36659718f, -0.07126187f, 0.07247316f, -0.65691739f, -0.28239995f, 
    -0.30980429f, 0.15357195f, 0.10161640f, 0.12569971f, 0.06456332f, 0.01242929f, 0.09301247f, -0.16765794f, 
    -0.06456669f, 0.04552412f, -0.18108238f, 0.35703963f, -0.21555822f, 0.08163577f, 0.27424771f, 0.07470762f, 
    -0.07528801f, 0.07314191f, 0.30358401f, -0.23169143f, -0.00137233f, -0.11148189f, 0.13246150f, -0.07203824f, 
    0.01344262f, -0.03430085f, -0.24435636f, 0.23680487f, 0.17110011f, -0.19776531f, 0.02352080f, 0.11949847f, 
    0.02484660f, 0.03403503f, 0.08831365f, -0.23192525f, 0.26206225f, -0.13826820f, 0.13738975f, 0.18753903f, 
    -0.06975859f, -0.09178557f, 0.22434212f, -0.12454025f, 0.15757993f, -0.37884688f, -0.24105819f, -0.22550154f, 
    0.04622081f, -0.01813920f, 0.04696428f, -0.04529843f, 0.02194710f, 0.24963793f, 0.02769573f, -0.11818610f, 
    -0.11397914f, -0.46732578f, 0.03667478f, -0.15365610f, 0.00052469f, -0.22822586f, -0.13216010f, 0.28835255f, 
    -0.16722411f, -0.04338771f, -0.17197727f, 0.11276536f, 0.08286679f, -0.15316378f, 0.16298005f, 0.01465217f, 
    -0.10151347f, -0.18572365f, -0.01481959f, -0.20858692f, 0.06114145f, 0.03908965f, -0.02621275f, -0.08685686f, 
    -0.25865889f, 0.24178560f, 0.12058467f, -0.04284378f, 0.07683474f, 0.00082327f, 0.05991921f, 0.03778913f, 
    0.32976180f, 0.41702229f, 0.15096508f, 0.05808038f, 0.07026447f, -0.06812394f, -0.01047527f, 0.03875274f, 
    0.05285460f, -0.65022004f, -0.50234187f, 0.35218164f, 0.01032801f, 0.09058057f, 0.09388541f, 0.03773225f, 
    0.05767473f, -0.24402089f, 0.13636906f, -0.01839130f, -0.11607402f, -0.02045965f, -0.08510201f, -0.14161754f, 
    -0.06999114f, -0.02992322f, 0.06357440f, -0.12076873f, 0.51517218f, -0.09156325f, -0.13271001f, 0.25502303f, 
    -0.06697925f, -0.13890794f, 0.09257535f, -0.12481873f, -0.08536340f, -0.27876458f, -0.16335905f, -0.25895828f, 
    -0.20896238f, -0.30427358f, 0.03390491f, 0.03253052f, 0.32038468f, -0.16995256f, 0.00087859f, 0.09211670f, 
    0.13623647f, -0.03363759f, 0.10453335f, 0.23604472f, -0.02439257f, 0.17351970f, 0.12216273f, -0.39105546f, 
    -0.03326695f, -0.10661692f, 0.16932331f, -0.18197064f, 0.07570822f, 0.02462628f, 0.00456357f, 0.05226601f, 
    0.48882335f, 0.60596943f, 0.14073437f, -0.11596064f, 0.14173546f, -0.02225929f, 0.07964028f, -0.04782669f, 
    -0.04685488f, -0.02890538f, 0.05642710f, -0.04444375f, 0.02671927f, -0.04507315f, -0.02452565f, -0.01393383f, 
    -0.01953818f, -0.00572828f, 0.00259755f, -0.00614496f, 0.03741435f, -0.02820336f, -0.05293882f, -0.00537047f, 
    -0.00579350f, 0.01684622f, -0.02705631f, -0.03872173f, -0.03594944f, -0.03809796f, 0.02222070f, 0.03688904f, 
    -0.05227651f, 0.03960642f, -0.03121755f, -0.06405757f, 0.05195247f, 0.03949993f, -0.02073108f, -0.01988319f, 
    0.02712332f, 0.03553709f, 0.00536848f, 0.00639299f, -0.01985898f, -0.03671068f, -0.02064813f, -0.01661778f, 
    0.04226496f, -0.05520112f, 0.02097047f, 0.01998583f, -0.06018210f, -0.06199116f, 0.01371287f, -0.05298012f, 
    0.02824695f, 0.05094897f, 0.02734432f, 0.04747865f, -0.04382648f, 0.02136818f, -0.04628984f, 0.00878050f, 
    0.03405797f, -0.00654915f, -0.02142434f, -0.01382741f, -0.00709256f, 0.00164014f, -0.01535849f, 0.03089878f, 
    -0.02211391f, 0.01106469f, 0.05278919f, -0.02580983f, 0.03170764f, 0.03418578f, -0.05654233f, -0.03653690f, 
    -0.03669363f, 0.03791767f, 0.00418033f, -0.04049670f, -0.01962027f, -0.05189399f, 0.00058806f, -0.01784130f, 
    0.03963612f, 0.04170772f, 0.01094597f, 0.01374058f, 0.03915773f, 0.04525806f, -0.03499889f, 0.02090206f, 
    -0.03985504f, 0.04675398f, 0.04102230f, -0.04340638f, 0.03520139f, -0.04006928f, 0.00530958f, -0.04051959f, 
    -0.05922622f, 0.03395985f, -0.01923506f, -0.03016842f, 0.00393601f, -0.04901256f, 0.04269150f, -0.01536394f, 
    0.05295198f, -0.01578123f, -0.05581866f, 0.02194319f, -0.01495009f, -0.03783784f, 0.04315287f, 0.00109522f, 
    0.04623896f, 0.05602311f, 0.03045725f, 0.01693027f, -0.02164751f, 0.05759354f, 0.03133807f, -0.02945873f, 
    0.01010050f, -0.05437040f, -0.01114682f, 0.02999727f, 0.05662837f, 0.02096114f, 0.02162183f, 0.03001023f, 
    0.01296421f, -0.02433949f, 0.04774317f, -0.03405941f, 0.01048463f, -0.02135121f, 0.05245399f, 0.01385133f, 
    0.01262800f, 0.05272000f, -0.04516371f, -0.05105327f, -0.02299604f, -0.05633925f, -0.00846114f, -0.04840001f, 
    0.03857617f, 0.02201004f, -0.02160344f, -0.04580965f, -0.03271751f, -0.03018174f, 0.03498317f, -0.00864699f, 
    0.01580568f, 0.00885957f, -0.01103477f, -0.04850546f, -0.05784784f, -0.06342263f, 0.00279825f, 0.00464211f, 
    0.04374291f, 0.04542728f, -0.03608670f, -0.05900669f, -0.03939379f, -0.06444860f, 0.04664237f, -0.01767311f, 
    -0.01991245f, 0.01066924f, 0.01099954f, 0.00135079f, 0.03997312f, -0.05957000f, -0.05784344f, -0.02221469f, 
    0.01726352f, -0.01807527f, 0.03479110f, -0.05715730f, 0.05578239f, 0.04544316f, -0.00583254f, 0.00458904f, 
    -0.04399743f, 0.04542926f, -0.01041204f, -0.03252401f, -0.01825369f, 0.05218865f, -0.05627066f, 0.00317439f, 
    -0.03272971f, -0.05207795f, -0.01859078f, -0.04958913f, 0.00184043f, -0.04314703f, -0.02208355f, -0.06141900f, 
    0.00951051f, 0.00615757f, -0.05268726f, 0.02400996f, 0.00790942f, 0.00916018f, -0.04019124f, 0.01261612f, 
    0.01140220f, 0.04506465f, -0.00165725f, -0.04513448f, -0.06229541f, -0.05523328f, 0.00464631f, -0.03104535f, 
    -0.00167741f, 0.03188673f, 0.03950601f, -0.05761667f, 0.00470826f, -0.00865443f, 0.01963199f, -0.00770631f, 
    -0.06247137f, -0.03079168f, -0.01938184f, 0.02838995f, -0.02759892f, -0.01998723f, -0.03441252f, -0.06056447f, 
    -0.01321115f, -0.01971247f, 0.00576075f, -0.04822947f, 0.02723517f, 0.05155556f, 0.00456079f, -0.04974210f, 
    -0.03380375f, -0.01737039f, 0.00212270f, 0.04575492f, -0.05044755f, -0.05651495f, 0.03135065f, -0.00761625f, 
    -0.05788862f, -0.01142789f, -0.02490819f, 0.02879621f, 0.01927776f, -0.01905914f, -0.05647742f, -0.02975512f, 
    -0.04587034f, -0.00690594f, -0.00091575f, -0.02545585f, -0.02607800f, -0.02693095f, -0.02992442f, -0.05592280f, 
    0.03791365f, 0.02006775f, 0.01927526f, -0.02846848f, -0.06152036f, -0.02718859f, -0.02644282f, -0.04665869f, 
    -0.04388971f, -0.01678651f, -0.05447114f, 0.04976186f, 0.01636565f, -0.02090711f, 0.03492709f, -0.01666511f, 
    0.03518616f, -0.05877865f, 0.00641736f, -0.04731204f, -0.05336037f, -0.02177154f, 0.03574661f, 0.01418140f, 
    -0.02605712f, 0.01382547f, 0.00749403f, 0.02597775f, 0.04621318f, 0.03780343f, 0.00781640f, 0.04398534f, 
    -0.00389595f, -0.03298097f, -0.03261266f, -0.04126463f, -0.01469242f, 0.01245413f, -0.03186692f, -0.06823850f, 
    -0.04355456f, -0.01674130f, -0.03777870f, 0.04413728f, 0.03673289f, 0.01945637f, -0.01003103f, 0.05418269f, 
    -0.07082386f, -0.05192114f, 0.02287515f, -0.04342153f, 0.00486603f, 0.03040843f, 0.03934922f, 0.02228338f, 
    -0.05022129f, 0.04619449f, 0.03084558f, -0.04051953f, 0.05587067f, -0.06202791f, -0.02705351f, -0.01626914f, 
    0.01254871f, -0.01419669f, 0.00525128f, 0.00101756f, -0.03659643f, -0.04735473f, -0.03829767f, 0.01498195f, 
    0.03007131f, 0.00210869f, 0.02618147f, -0.06208183f, -0.03481709f, -0.04617224f, -0.00411322f, -0.06107306f, 
    -0.02952842f, 0.01347660f, 0.00928795f, -0.05453268f, -0.00131230f, -0.04475623f, -0.02015241f, -0.04959664f, 
    -0.03494436f, 0.02039318f, -0.01506747f, -0.00705993f, -0.05815798f, 0.04734704f, 0.04229579f, 0.04980280f, 
    -0.03783311f, -0.01901547f, 0.00140638f, -0.06476752f, -0.06351212f, -0.05871655f, 0.00196098f, 0.01654977f, 
    0.03980743f, 0.03001015f, -0.04769940f, 0.04938584f, -0.03985731f, -0.03450591f, -0.05840620f, -0.01387752f, 
    -0.04358876f, -0.03258761f, 0.00322021f, -0.04583366f, -0.01519217f, -0.04644633f, 0.03843050f, 0.04252471f, 
    0.04709847f, -0.04483733f, -0.05060229f, 0.03572818f, 0.03419800f, -0.04526464f, -0.02555954f, -0.02900362f, 
    0.00607722f, 0.02675008f, 0.04241540f, -0.01769406f, -0.04351163f, -0.01364447f, 0.02258962f, 0.04090156f, 
    -0.01298431f, -0.04870194f, -0.00631139f, -0.04963478f, 0.00172459f, 0.00012925f, 0.00910992f, 0.04958114f, 
    0.04256315f, 0.04146474f, 0.00226225f, 0.03160872f, -0.03557725f, 0.03969884f, 0.03728497f, -0.05841509f, 
    0.04736952f, 0.04639588f, -0.04882522f, 0.01949682f, -0.06061815f, -0.00422815f, -0.00366492f, 0.02452467f, 
    -0.01639846f, 0.02296069f, -0.03703224f, -0.03713655f, -0.03520315f, -0.02282600f, -0.05749964f, -0.05455891f, 
    -0.00193309f, 0.04651110f, 0.03190773f, -0.05887805f, -0.00699879f, 0.05433833f, -0.01073130f, 0.03293359f, 
    0.03209559f, 0.00026789f, 0.01441009f, -0.03940192f, -0.02744456f, 0.04181618f, -0.06181812f, -0.01276607f, 
    -0.00557910f, -0.03793837f, -0.05924511f, -0.03876146f, -0.02349400f, -0.01335289f, 0.01587589f, -0.01836013f, 
    0.00506954f, -0.02832619f, 0.01348335f, -0.05163509f, -0.04319027f, 0.04152803f, 0.00937198f, -0.04103386f, 
    0.04416927f, -0.07075497f, -0.06097244f, -0.02771795f, -0.00403519f, -0.04080932f, -0.04637717f, 0.01290127f, 
    0.01091366f, -0.03466066f, 0.05219793f, 0.01360278f, 0.00789001f, 0.03116578f, -0.03400575f, 0.01273286f, 
    -0.05202425f, -0.01198895f, 0.00723350f, 0.04561717f, -0.04370307f, -0.05248893f, 0.04869138f, -0.05072193f, 
    -0.02055474f, -0.02859071f, -0.04761310f, -0.04378473f, 0.02859037f, -0.04347508f, -0.02528733f, -0.01059661f, 
    0.04104955f, -0.03947997f, 0.01242218f, -0.00949768f, -0.04203516f, -0.01992343f, -0.04086982f, 0.02779675f, 
    -0.03187564f, 0.03875163f, 0.01297077f, -0.03890446f, 0.05196302f, 0.05403823f, -0.06172974f, 0.00420855f, 
    -0.03905495f, 0.03634399f, 0.02403509f, -0.04634428f, 0.00526922f, 0.03900578f, -0.02192106f, 0.02682866f, 
    0.02728471f, 0.00183371f, -0.02427783f, -0.03797842f, -0.00154082f, 0.00942229f, -0.01157163f, 0.03828657f, 
    0.00698005f, -0.00000012f, 0.00505221f, -0.03654685f, 0.01887508f, 0.04332941f, 0.01356050f, -0.06029334f, 
    -0.03746020f, -0.07763124f, 0.05404436f, -0.03179414f, -0.03692476f, -0.00051183f, 0.02549366f, 0.06044925f, 
    0.04374030f, 0.00697130f, 0.02523886f, -0.04931688f, -0.03717656f, 0.02941707f, -0.02004476f, 0.02922511f, 
    -0.03527307f, -0.04889300f, -0.04389266f, -0.02606675f, 0.00621543f, 0.04680005f, 0.02685782f, 0.03970233f, 
    -0.04656703f, -0.01318549f, -0.00105386f, -0.06289155f, 0.01722397f, 0.05699751f, -0.00316421f, -0.03771938f, 
    0.06457885f, 0.02527351f, -0.03743473f, -0.04395429f, 0.00744677f, 0.03986299f, -0.00521843f, 0.02957707f, 
    0.01646753f, 0.04231907f, -0.03584686f, 0.00999189f, 0.00166900f, -0.04278241f, 0.01010387f, 0.05049289f, 
    0.00070430f, -0.01477866f, 0.02352506f, -0.03490607f, -0.05909602f, 0.03732198f, 0.01146381f, 0.02842685f, 
    0.00613030f, -0.05984462f, 0.01097621f, 0.03911798f, -0.03997356f, -0.05953618f, -0.02975504f, 0.01468089f, 
    0.04433323f, -0.05946384f, 0.03790890f, -0.00473188f, -0.00160233f, 0.04355862f, -0.02105932f, -0.03040478f, 
    0.00314274f, -0.03840882f, -0.01742556f, 0.04528029f, 0.00709827f, -0.05037546f, -0.02632427f, -0.05967412f, 
    -0.01233035f, -0.04083337f, -0.06137802f, 0.01328039f, 0.02450797f, 0.03552137f, 0.02559460f, -0.00208956f, 
    -0.05624191f, 0.01463273f, 0.03629796f, -0.03415817f, 0.00017035f, -0.01124233f, 0.03668097f, -0.05893986f, 
    -0.05018746f, 0.03117462f, 0.02225026f, -0.06333102f, 0.00811631f, -0.04727839f, -0.00892132f, 0.02812587f, 
    0.01269114f, -0.03916816f, -0.04869889f, 0.00324782f, -0.01843455f, -0.04812070f, 0.01079449f, -0.00738547f, 
    -0.00072577f, -0.03604957f, 0.03472736f, 0.04484767f, -0.05649236f, 0.03839158f, -0.00179193f, 0.00220105f, 
    0.03514123f, -0.03786214f, -0.03939094f, -0.03386318f, -0.05792980f, -0.04922637f, -0.02530567f, -0.05401889f, 
    0.03918926f, 0.01589210f, -0.03462575f, -0.02123288f, 0.00909762f, -0.03263416f, -0.01576161f, 0.04614043f, 
    -0.05369233f, 0.01579836f, -0.05915244f, -0.00888840f, 0.03722439f, -0.04698001f, 0.01211083f, -0.05622709f, 
    0.01203093f, -0.02137348f, 0.04714058f, -0.05179180f, 0.01022620f, 0.00627607f, -0.01633282f, -0.02152829f, 
    -0.05719741f, 0.00369810f, 0.03150507f, -0.02540706f, -0.04786831f, -0.05746504f, -0.00804699f, -0.03161316f, 
    0.03732559f, -0.01775078f, -0.00353760f, 0.02245551f, -0.04685322f, -0.04381126f, -0.01506054f, 0.03242587f, 
    -0.06430729f, -0.00774704f, -0.02593447f, -0.05542422f, -0.03313566f, -0.01906508f, -0.03328771f, 0.00189779f, 
    0.02555263f, -0.05638624f, 0.04460699f, -0.00076539f, 0.04174726f, 0.04584186f, -0.00491749f, 0.04459098f, 
    -0.00514893f, -0.04600555f, -0.05750267f, 0.01882635f, 0.01981627f, 0.05319937f, -0.00793541f, -0.02495413f, 
    -0.06007970f, 0.00763757f, -0.02740196f, -0.05181900f, -0.06096739f, -0.00461579f, -0.00235906f, -0.02271740f, 
    -0.02421519f, -0.06643360f, 0.02898869f, -0.00422948f, -0.01939362f, 0.02061782f, -0.03750699f, 0.04981036f, 
    -0.02005103f, -0.00702681f, -0.03732936f, -0.03193471f, 0.02243759f, 0.01011169f, 0.00065858f, 0.04843357f, 
    0.04373889f, -0.03221863f, 0.02010950f, -0.05241183f, -0.00847597f, -0.06390960f, 0.04798871f, 0.04488781f, 
    -0.03132991f, -0.02517680f, -0.00452807f, -0.04840383f, -0.00414379f, 0.00490686f, 0.04681158f, 0.01141523f, 
    -0.05122555f, -0.04345536f, 0.00425687f, -0.00847215f, -0.00106888f, -0.05166968f, 0.01347017f, 0.00740294f, 
    0.04409036f, 0.03430432f, -0.01290164f, -0.05911871f, -0.03671988f, -0.06142259f, -0.00747310f, 0.03069395f, 
    -0.00111754f, -0.00742835f, -0.04021649f, 0.04389718f, -0.04955222f, -0.03746505f, -0.01080499f, -0.02567400f, 
    0.00400045f, -0.04996715f, 0.00549816f, -0.00416509f, -0.04593895f, 0.03014977f, 0.00437454f, 0.00201088f, 
    -0.00022138f, -0.03727673f, 0.00985855f, -0.04427230f, 0.01483318f, 0.03358193f, -0.00236058f, 0.02064494f, 
    -0.04600920f, 0.00959664f, -0.02191964f, 0.03256825f, 0.04823011f, 0.03734282f, -0.02582774f, 0.03312699f, 
    0.03394341f, -0.04601821f, -0.01349209f, 0.03838364f, 0.02397131f, 0.01447089f, -0.00308656f, -0.02067991f, 
    0.04605184f, 0.02808561f, -0.01921459f, -0.06313857f, 0.03867957f, 0.00677121f, 0.03487353f, 0.00552128f, 
    -0.00388298f, -0.02141053f, -0.02120790f, -0.01705659f, -0.00316776f, -0.04305243f, 0.04988028f, -0.04142191f, 
    -0.05004823f, -0.01187616f, -0.05917825f, -0.01572392f, -0.01614143f, -0.05941093f, -0.03363945f, -0.02576097f, 
    -0.04345131f, 0.02635486f, 0.04200150f, -0.01499750f, 0.01032377f, -0.02364422f, 0.02046796f, 0.01756094f, 
    -0.00573837f, 0.04672251f, -0.02810833f, -0.01438530f, -0.00028849f, -0.00228351f, -0.05035888f, 0.04331192f, 
    -0.22184591f, -0.13141721f, -0.05047818f, 0.08556503f, 0.03267131f, -0.11231396f, -0.17257281f, -0.06466882f, 
    -0.04183204f, -0.01074682f, 0.01884698f, 0.09963690f, 0.09385934f, 0.06967098f, -0.05583328f, -0.00857074f, 
    -0.16983396f, 0.05637474f, -0.24804355f, -0.03519032f, 0.19724374f, 0.03035610f, 0.01719244f, 0.06781082f, 
    -0.04543569f, -0.01346809f, -0.00269136f, 0.01067520f, 0.17506371f, 0.00853524f, -0.07728407f, -0.09446374f, 
    -0.08209353f, 0.20147353f, 0.23502640f, 0.29572093f, 0.14872153f, 0.04444018f, 0.03180980f, 0.25412551f, 
    0.19772945f, -0.17605807f, 0.22189111f, 0.11820918f, 0.13866912f, 0.20228401f, -0.30902767f, 0.06859359f, 
    -0.09672537f, 0.02526483f, 0.00800452f, -0.26152712f, 0.07592109f, -0.05485513f, 0.01088688f, -0.41284332f, 
    -0.44464833f, 0.00594954f, -0.10110550f, 0.09111866f, 0.10683394f, 0.01968418f, -0.20871365f, 0.48687291f, 
    0.07049973f, 0.08471280f, -0.07556098f, 0.03673596f, -0.01269326f, -0.03200906f, 0.16486065f, -0.02113174f, 
    -0.04516919f, 0.15398671f, 0.35037950f, -0.02870524f, -0.01314041f, 0.11093058f, 0.07797703f, -0.14887172f, 
    0.00513282f, 0.03763496f, 0.11963151f, -0.16500911f, -0.10666943f, 0.06404240f, 0.12652789f, 0.09774932f, 
    0.10759810f, 0.03932574f, 0.22367983f, -0.05215838f, 0.23001806f, 0.07438852f, 0.00221106f, 0.07155082f, 
    0.05970340f, 0.25279516f, 0.07428880f, 0.10765993f, -0.36571071f, -0.53957635f, 0.00379344f, 0.08150528f, 
    -0.06631832f, 0.13551240f, 0.08636181f, 0.01575556f, -0.11044081f, -0.08223317f, -0.00153763f, -0.12290633f, 
    -0.06422920f, -0.17159700f, 0.12305277f, -0.05084395f, 0.01106915f, -0.04576176f, -0.22059430f, -0.11745955f, 
    -0.21084179f, -0.57118934f, -0.27612254f, 0.04206407f, -0.10308198f, -0.18685402f, -0.04699991f, 0.01502506f, 
    0.12704796f, -0.06317256f, -0.07484569f, 0.05041401f, 0.05707107f, -0.04649422f, -0.05901706f, 0.00653863f, 
    0.02730484f, -0.00449309f, 0.17611934f, 0.06255908f, 0.04602382f, 0.15261729f, 0.04669901f, 0.23536111f, 
    -0.14115866f, -0.75018215f, -0.07777863f, 0.07627080f, 0.05954434f, -0.03251245f, 0.08550412f, -0.00812586f, 
    0.05007452f, 0.04575361f, -0.08558647f, -0.21385060f, 0.01316987f, 0.05210268f, -0.07306599f, -0.07527310f, 
    0.10094970f, -0.13698637f, 0.07777204f, 0.10622787f, 0.08722252f, 0.03254629f, 0.10231723f, 0.06363893f, 
    0.13129582f, 0.13569161f, -0.01507652f, 0.41952866f, -0.36426884f, -0.41442502f, -0.27153191f, -0.12335323f, 
    0.15884697f, 0.08313410f, 0.09445938f, 0.07414616f, -0.21346956f, -0.11310387f, 0.06490601f, -0.27452245f, 
    -0.01259928f, -0.08064561f, -0.00090266f, -0.08189318f, 0.10998417f, -0.06548377f, -0.43570051f, -0.57141775f, 
    -0.07099842f, -0.06355259f, -0.18914102f, -0.20149864f, 0.09751193f, -0.09341338f, 0.31218976f, 0.11423822f, 
    -0.06633998f, -0.37740710f, -0.05854325f, 0.06667501f, 0.12096324f, 0.23141412f, 0.27557775f, -0.25002429f, 
    -0.31962517f, -0.15487699f, -0.05602746f, -0.06828343f, -0.03131270f, 0.04106343f, -0.00827330f, 0.05365806f, 
    0.16950099f, -0.11635464f, -0.15665440f, 0.10854733f, 0.15725522f, 0.13494189f, 0.11441898f, -0.02037886f, 
    -0.00869391f, -0.00029780f, -0.28788123f, -0.57106769f, 0.07327092f, -0.05497792f, 0.09869586f, 0.27010286f, 
    0.14429116f, 0.08869304f, -0.03773340f, -0.16437259f, -0.18604267f, -0.17317992f, -0.24480869f, -0.08460666f, 
    0.10376465f, -0.12891215f, 0.07439063f, 0.08361983f, -0.50440800f, -0.18408191f, 0.08612043f, -0.27564099f, 
    -0.17630872f, 0.06732032f, 0.01884161f, -0.01353025f, -0.24987242f, -0.15622368f, -0.03720490f, -0.16276117f, 
    0.08687110f, -0.43377322f, 0.10336385f, 0.14240725f, -0.00907031f, -0.07742120f, 0.18167898f, 0.32729742f, 
    0.13580732f, -0.02308650f, -0.02611090f, 0.10998929f, 0.02265664f, -0.03321097f, 0.03725817f, -0.00595994f, 
    0.05905231f, -0.10516188f, -0.00610200f, -0.19270918f, 0.05530278f, 0.06365975f, -0.08148860f, -0.01737334f, 
    -0.51410228f, -0.65200043f, -0.23838255f, -0.27010384f, -0.05411737f, 0.08073934f, -0.01093923f, -0.02925390f, 
    -0.24666503f, -0.29877689f, -0.11727335f, -0.03110379f, -0.03259389f, -0.02666178f, -0.15281565f, 0.01750498f, 
    0.01472314f, -0.17421053f, -0.00625420f, 0.04300855f, 0.03581166f, 0.06925502f, 0.06362738f, -0.10133964f, 
    0.00442736f, 0.09676549f, -0.24554145f, -0.22846061f, 0.03964463f, 0.07896009f, 0.13103183f, 0.01609553f, 
    0.21201909f, 0.05376086f, 0.00762088f, -0.37730286f, -0.09831740f, 0.05055624f, 0.03591869f, 0.09775059f, 
    0.10592889f, -0.14450374f, 0.04369880f, 0.04209781f, 0.30262873f, 0.08247381f, -0.10165623f, 0.08218282f, 
    0.22115502f, 0.01886596f, 0.15429240f, 0.25175661f, 0.08456426f, -0.39305794f, -0.03074306f, 0.32225236f, 
    0.07433157f, 0.03434286f, -0.00352340f, -0.00812720f, -0.08342841f, 0.06191365f, -0.01934146f, -0.47390661f, 
    -0.66099697f, -0.05534547f, -0.07551796f, -0.05577744f, 0.16228673f, 0.05447495f, 0.03857492f, -0.10990443f, 
    -0.09691554f, 0.32029068f, 0.16664997f, -0.11471204f, -0.02465900f, -0.01211689f, -0.18082595f, 0.00959847f, 
    -0.19027971f, 0.21464421f, 0.30435532f, 0.01444195f, 0.11879164f, -0.05956725f, -0.02118290f, 0.15671402f, 
    0.21796021f, 0.26007342f, 0.13023554f, -0.15311693f, 0.20805055f, 0.08972113f, -0.05557195f, 0.20378490f, 
    0.22851364f, 0.06198986f, -0.15983388f, 0.20233363f, 0.22909902f, -0.05904893f, -0.22106946f, 0.08980962f, 
    0.03302821f, -0.03642551f, 0.02450195f, -0.34211656f, -0.02453149f, -0.08129933f, -0.04686132f, 0.11387438f, 
    -0.30739811f, 0.32750344f, 0.16637339f, 0.05190295f, -0.17498127f, -0.05330428f, -0.21131390f, -0.12280797f, 
    -0.17086813f, -0.19009179f, -0.03220101f, -0.06339472f, 0.08477954f, -0.09151301f, -0.14125912f, -0.20698252f, 
    -0.14903508f, -0.24733207f, -0.12064130f, -0.01437599f, 0.08898629f, -0.13948068f, -0.19557291f, -0.23836967f, 
    -0.08873549f, -0.01093567f, 0.09902996f, 0.09895740f, -0.01775894f, 0.06078385f, 0.00358002f, -0.00047595f, 
    0.12283663f, 0.06606062f, 0.08473819f, -0.00976685f, 0.03642669f, 0.20839004f, 0.26640311f, 0.27353278f, 
    -0.14352249f, -0.45481247f, 0.05976567f, -0.15405658f, 0.02870203f, -0.13489094f, 0.09737350f, 0.00157678f, 
    0.16332784f, -0.07780028f, -0.13889994f, 0.16628383f, 0.02923254f, 0.03426354f, 0.04483714f, 0.08175904f, 
    -0.08507961f, 0.14475419f, 0.38479164f, 0.30174586f, -0.04833386f, 0.28862804f, -0.10986643f, 0.12440538f, 
    0.05492250f, -0.04451220f, -0.03800616f, -0.07368638f, -0.31750154f, -0.42091104f, -0.01580849f, 0.18266256f, 
    0.08971390f, 0.31284130f, 0.05745227f, 0.22918758f, -0.36583671f, -0.00821453f, -0.07999878f, -0.28069198f, 
    -0.29346037f, -0.03335464f, -0.02706817f, -0.03011237f, 0.12751321f, -0.14842135f, -0.37532184f, -0.06249969f, 
    0.06067482f, -0.21002659f, -0.14502062f, 0.20654081f, 0.03583016f, 0.06374344f, 0.09387144f, 0.09300080f, 
    -0.11089037f, -0.13359629f, -0.27359769f, -0.05344100f, 0.03234746f, -0.10180277f, -0.24424979f, -0.17226495f, 
    -0.42305651f, 0.20282575f, 0.05465525f, 0.03190985f, 0.05362839f, 0.21442696f, 0.08203880f, -0.01684793f, 
    -0.18352328f, -0.33384743f, -0.06605001f, 0.09616084f, 0.20180126f, -0.03210978f, 0.32362619f, 0.05916696f, 
    0.02592800f, 0.35288298f, -0.57229275f, -0.84768659f, 0.00172016f, -0.10968592f, -0.00991355f, -0.05952260f, 
    -0.05002625f, 0.06554285f, -0.24864550f, -0.04036651f, -0.18772502f, -0.21283561f, -0.23991308f, -0.07527930f, 
    0.02594452f, -0.07442528f, 0.03605011f, 0.86699307f, -0.47562328f, -0.40185392f, -0.05894072f, -0.06283282f, 
    0.05929091f, -0.00705824f, 0.10095150f, 0.13023348f, 0.04071623f, -0.18356040f, -0.45229796f, -0.28672013f, 
    -0.29552725f, -0.00483189f, 0.02193941f, -0.40194112f, -0.03735993f, -0.03314237f, -0.00255285f, 0.11276226f, 
    0.11728413f, 0.09756984f, 0.12194148f, 0.08090486f, 0.31147662f, 0.25502762f, -0.27844471f, -0.01354250f, 
    0.27282694f, 0.09563032f, -0.09624643f, 0.00409738f, 0.01125792f, 0.11985780f, 0.13974532f, 0.14898296f, 
    -0.16730873f, -0.44002542f, -0.12858656f, -0.07900162f, -0.25223839f, -0.02508655f, 0.04836797f, -0.02982587f, 
    0.23948242f, -0.00854919f, 0.19209182f, -0.07941423f, -0.01758586f, -0.04667344f, 0.08891101f, -0.16069002f, 
    0.07842259f, 0.14570305f, 0.06567833f, 0.16369502f, 0.10031313f, 0.12035657f, -0.01389635f, 0.03374568f, 
    0.00388930f, 0.05856974f, 0.09888976f, -0.03329843f, 0.05653640f, -0.00947660f, 0.10826068f, 0.02091756f, 
    0.18905689f, -0.06861849f, 0.15418971f, 0.00471577f, -0.09918944f, -0.05915276f, 0.06510046f, 0.06309456f, 
    0.11072638f, 0.18046635f, -0.00154207f, 0.06726038f, 0.02749805f, 0.26254562f, 0.11729609f, -0.00515566f, 
    -0.09934343f, 0.06862127f, 0.24302177f, 0.12470163f, 0.31269565f, -0.35431466f, 0.15687315f, 0.02949727f, 
    -0.00994066f, 0.05308368f, -0.16790129f, -0.02863424f, -0.02080092f, -0.12746148f, 0.18155430f, 0.00844596f, 
    0.06308582f, -0.01585723f, 0.13293861f, 0.19720899f, 0.02994196f, -0.10942511f, 0.03528933f, -0.38697889f, 
    -0.14014827f, 0.27726325f, 0.05239308f, 0.00844146f, -0.12511271f, 0.05978922f, -0.04100219f, -0.12454771f, 
    -0.19083765f, 0.08897781f, 0.00537727f, -0.09056551f, 0.09091241f, 0.09991688f, 0.03325497f, 0.10967947f, 
    -0.09220944f, 0.17984949f, 0.04599345f, 0.09707171f, 0.02538189f, 0.05748759f, 0.15609160f, -0.05891158f, 
    0.06658199f, -0.04005018f, -0.40724280f, 0.02381611f, -0.13591039f, 0.02322935f, -0.04047647f, -0.33592227f, 
    -0.07406010f, -0.04564457f, 0.04148262f, -0.45800376f, -0.25166661f, 0.38728267f, -0.11607585f, 0.05125296f, 
    0.12356731f, 0.14013976f, 0.00397193f, 0.02936196f, 0.00573965f, -0.00463976f, 0.03348620f, 0.01438349f, 
    0.02904213f, -0.04503803f, -0.09644276f, -0.01243786f, -0.08614317f, 0.02489516f, -0.07050461f, -0.09114552f, 
    0.23392436f, -0.03816855f, 0.13192570f, -0.34836215f, -0.17991479f, -0.03214274f, 0.19050469f, -0.02494569f, 
    0.10457158f, -0.03916671f, 0.21617618f, -0.01365323f, 0.15495865f, 0.13978708f, -0.02512586f, 0.01798831f, 
    0.09996677f, 0.10049382f, 0.00103275f, 0.09986825f, -0.01136915f, 0.24187896f, 0.01077055f, 0.03361945f, 
    -0.03197330f, 0.10103945f, -0.29835668f, 0.01194169f, 0.07258720f, -0.00040722f, 0.12564309f, 0.03734068f, 
    -0.10337976f, -0.13717362f, -0.01409385f, -0.33685571f, -0.08579684f, 0.08576789f, -0.10331562f, -0.07276846f, 
    0.09579634f, -0.04019203f, 0.23346929f, 0.38622826f, -0.10513453f, -0.06476810f, 0.01979872f, -0.01621224f, 
    -0.02204842f, -0.05665651f, 0.05977430f, -0.14346480f, 0.06972502f, 0.30994451f, 0.08694097f, 0.32229307f, 
    0.18828258f, 0.27563208f, 0.17674612f, -0.03442154f, -0.25483632f, -0.21906133f, -0.04603335f, 0.07348302f, 
    0.04780034f, -0.08565674f, -0.01714658f, -0.10395800f, 0.01687847f, 0.12014424f, -0.02614726f, -0.37284780f, 
    -0.03657699f, -0.03730490f, -0.07181828f, 0.13267806f, 0.04610448f, -0.02540883f, -0.07193979f, -0.06701300f, 
    0.10896342f, 0.17502809f, 0.11345766f, -0.12536310f, 0.10385974f, -0.16180953f, 0.16231294f, -0.12746458f, 
    -0.31254849f, -0.50114334f, 0.04630680f, 0.02409554f, 0.17131177f, 0.09191178f, -0.02299798f, 0.01878753f, 
    -0.46867281f, -0.55084795f, -0.07500651f, 0.07915193f, 0.07809394f, 0.17060758f, 0.15606463f, 0.04463377f, 
    0.13691689f, -0.18368711f, 0.39877716f, -0.00066480f, -0.14053798f, 0.05345396f, -0.02178748f, -0.03355586f, 
    -0.15863487f, 0.10861610f, -0.07780731f, 0.12314887f, 0.21555212f, -0.01863448f, -0.03865875f, -0.05454450f, 
    0.02855421f, -0.03884130f, 0.02824668f, 0.11337361f, 0.06362076f, 0.24424726f, 0.08037937f, -0.05327049f, 
    0.01139588f, 0.18408376f, 0.05015869f, 0.11868711f, 0.03880170f, 0.08348475f, 0.18133019f, 0.04779395f, 
    -0.11099630f, 0.16119502f, -0.06799621f, 0.14009459f, 0.16591339f, 0.20367272f, -0.09289192f, 0.21175215f, 
    -0.02609519f, 0.20223606f, 0.04345710f, 0.12773748f, 0.24766694f, 0.00832717f, -0.35363147f, 0.03559957f, 
    0.34550911f, -0.20782970f, -0.01476848f, 0.11110944f, 0.18015160f, 0.07782614f, -0.02271227f, -0.01981553f, 
    -0.18250747f, -0.39970639f, 0.27927613f, 0.05775708f, 0.12948388f, 0.04775187f, -0.07748488f, 0.10346527f, 
    -0.06381994f, -0.04116593f, 0.19795558f, 0.01184869f, 0.07867092f, -0.00543589f, -0.00555134f, -0.11166229f, 
    0.03165215f, -0.06777098f, -0.03293318f, 0.18813978f, -0.03654455f, -0.03130069f, -0.09655863f, -0.04500647f, 
    0.07463901f, 0.03680204f, 0.01715110f, 0.01668258f, 0.09058006f, -0.01634439f, 0.07573666f, -0.00900810f, 
    -0.02726072f, -0.01228698f, -0.01689025f, -0.05119537f, 0.03579201f, -0.02085155f, -0.02515311f, 0.11546542f, 
    -0.03438217f, 0.12088250f, 0.05737371f, -0.01402937f, 0.06377134f, 0.03396472f, 0.08553501f, -0.06607507f, 
    -0.09059406f, -0.01314767f, -0.06132577f, -0.13558991f, -0.05105314f, 0.86342621f, -0.26828748f, 0.86992693f, 
    -0.09639992f, -0.06098993f, -0.19900012f, -0.08757432f, 0.03444761f, 0.17691091f, -0.39876029f, -0.20876412f, 
    0.21931043f, 0.02908075f, 0.05601154f, 0.05456911f, 0.18517998f, 0.04640754f, 0.21717487f, 1.01746202f, 
    -0.35413677f, 0.34534186f, 0.00294949f, -0.14790231f, -0.02870823f, -0.04817430f, 0.32643789f, -0.02467902f, 
    0.22809775f, 0.01337217f, 0.06408462f, -0.27184835f, -0.05179358f, -0.02362007f, 0.09251903f, -0.02516251f, 
    0.01956163f, -0.19811334f, -0.05544464f, -0.04846534f, 0.14740323f, -0.00634822f, -0.01160354f, -0.01832741f, 
    0.07013932f, 0.03023283f, 0.05373616f, -0.59523743f, 0.32259941f, -0.03099183f, -0.01313171f, 0.02361709f, 
    0.06366923f, 0.07290416f, 0.12356020f, 1.50149703f, -0.48195723f, 0.37269828f, 0.10128155f, 0.10731483f, 
    0.03772002f, 0.00748877f, 0.13744438f, 0.25514120f, 0.06255575f, 0.07881738f, 0.08325919f, -0.48458052f, 
    -0.31845471f, -0.04938589f, 0.10601203f, -0.03675218f, 0.03720190f, -0.08812382f, 0.07387141f, 0.14672545f, 
    -0.19198072f, -0.05694864f, 0.01250904f, 0.05961433f, -0.01085414f, 0.07380822f, -0.06455534f, -0.06219282f, 
    0.03418420f, -0.00607251f, 0.00575631f, 0.00032093f, 0.06159633f, 0.01632915f, 0.05406831f, 0.00743960f, 
    0.06731626f, 0.17743026f, -0.31932139f, -0.33557364f, -0.18024877f, -0.01060602f, -0.05822142f, -0.06588500f, 
    0.32175362f, -1.05016434f, -0.30579790f, -0.15057838f, 0.06515696f, -0.08214372f, -0.00631682f, -0.15116577f, 
    -0.23738129f, -0.11856838f, -0.13290225f, -0.45921680f, -0.09059338f, -0.01862890f, 0.05272428f, -0.10442730f, 
    -0.07210654f, -0.01332892f, -0.29609621f, -0.09699499f, 0.33849078f, -0.03900586f, -0.02422956f, 0.11798021f, 
    -0.03801388f, 0.05261973f, 0.22171843f, 0.31332400f, 0.37671131f, -0.60752696f, 0.04791059f, 0.05478134f, 
    0.12073425f, -0.24818286f, 0.06134097f, -0.11250921f, 0.14970160f, 0.08639125f, -0.02129427f, -0.32626331f, 
    -0.23433815f, -0.09208646f, 0.11455279f, 0.03371901f, -0.04953492f, -0.43611738f, -0.71608752f, -0.09044731f, 
    -0.12432982f, 0.07792615f, -0.06735307f, -0.06370460f, -0.10299810f, 0.04026785f, 0.04032105f, 0.06190184f, 
    0.06609266f, -0.04301666f, -0.17535463f, -0.38517302f, 0.04066129f, 0.01748516f, 0.03109429f, -0.65642959f, 
    -0.37264213f, 0.07519348f, -0.02530010f, 0.10143871f, -0.01596640f, -0.26555955f, -0.11088563f, 0.12441762f, 
    -0.41794229f, -0.29125464f, 0.33538312f, -0.02613532f, 0.10396558f, -0.15356456f, 0.00279535f, -0.08043710f, 
    0.27637431f, -0.21841571f, 0.10649748f, -0.08995863f, -0.06681756f, 0.00701246f, 0.05048218f, 0.04207689f, 
    0.12602815f, -0.17323358f, 0.40123889f, 0.18644023f, -0.00675534f, 0.32807973f, -0.08509207f, 0.07527011f, 
    0.00994467f, 0.08003916f, 0.06857786f, 0.18325444f, -0.32012168f, 0.20359802f, -0.06691277f, -0.20765845f, 
    0.14258952f, 0.09515382f, 0.20151706f, -0.09371428f, 0.01833285f, 0.09214137f, 0.16104202f, 0.16235927f, 
    -0.25635085f, 0.07163297f, -0.05644081f, -0.01906433f, 0.29350013f, -0.05702834f, -0.08461463f, -0.00940373f, 
    0.04159869f, 0.04744796f, 0.03741129f, -0.06301285f, 0.09978145f, -0.01343369f, 0.78940904f, 0.03116461f, 
    -0.08001019f, 0.20154034f, 0.02505421f, 0.04181196f, 0.16322298f, 0.12382194f, -0.00002053f, -0.33874643f, 
    -0.07969947f, 0.21790153f, 0.11771931f, 0.07205793f, -0.01147899f, 0.01257876f, -0.15201859f, -0.03479565f, 
    -0.29878339f, -0.35840976f, -0.05434607f, 0.07897418f, -0.03903205f, -0.16240455f, 0.10912552f, 0.09129362f, 
    -0.04325060f, -0.28659761f, -0.30283561f, -0.05797048f, 0.08511857f, 0.06224281f, -0.06578766f, 0.06113153f, 
    -0.02426094f, -0.09968048f, -0.48042956f, -0.35961378f, 0.02455134f, -0.00205389f, 0.07692552f, -0.06183132f, 
    -0.00736069f, 0.11270326f, -0.10780858f, -0.10442079f, 0.08074833f, 0.03949867f, -0.03417059f, -0.04641843f, 
    -0.10092033f, 0.14648283f, -0.01906856f, -0.20631415f, 0.11060794f, -0.25945711f, -0.10220675f, -0.06161516f, 
    -0.02586512f, -0.12437739f, -0.09396230f, 0.16090965f, 0.05099514f, 0.09626427f, 0.26279980f, -0.04828501f, 
    0.00822919f, -0.14098281f, -0.00847568f, 0.06570338f, -0.14784096f, 0.08509772f, -0.14179437f, -0.18021862f, 
    -0.06427416f, -0.03848843f, 0.05509776f, -0.03211084f, 0.27565414f, -0.00474496f, -0.04119584f, 0.52978611f, 
    0.07281052f, -0.39438623f, 0.04608953f, -0.18040082f, 0.16496518f, 0.02156767f, 0.07735003f, -0.11375910f, 
    0.02805353f, -0.04383110f, -0.22881782f, 0.14175785f, 0.02225984f, -0.08458490f, 0.09735936f, 0.01213032f, 
    0.15565459f, 0.12004916f, 0.00145990f, -0.13372992f, -0.02782719f, 0.00783219f, -0.24703160f, 0.00574372f, 
    0.27495718f, -0.12503187f, 0.33604515f, -0.25977674f, -0.26999712f, 0.03034830f, -0.13282846f, 0.25691894f, 
    0.07255913f, -0.15572262f, 0.09257824f, 0.16422042f, 0.27497053f, 0.06541587f, -0.06287350f, -0.14828588f, 
    0.08721488f, 0.20298782f, 0.02477851f, -0.02001153f, 0.00121603f, -0.08419981f, -0.27574530f, 0.04060217f, 
    -0.06187715f, -0.19819632f, 0.17459421f, -0.00806354f, 0.13512649f, -0.01930257f, 0.03505964f, -0.12014140f, 
    0.13523744f, 0.13229726f, -0.03651749f, 0.14832802f, 0.11375269f, 0.06370374f, -0.31567308f, -0.57903260f, 
    -0.09684394f, 0.03691131f, -0.00747394f, -0.18798064f, 0.17057133f, 0.05795692f, -0.06739216f, -0.28772095f, 
    0.08121862f, -0.30796137f, -0.00332903f, -0.00776860f, -0.19036867f, 0.06570413f, -0.00155134f, -0.05320753f, 
    0.31590942f, 0.50964397f, 0.47464463f, -0.32075050f, -0.02380773f, -0.14174621f, 0.05874022f, 0.10397869f, 
    0.14672540f, 0.13940990f, 0.14788322f, 0.22912680f, -0.02721242f, 0.03383405f, 0.09290816f, 0.14847355f, 
    -0.05685181f, 0.03113380f, -0.24747252f, -0.02676458f, -0.51362008f, 0.01645353f, -0.06116052f, -0.01688572f, 
    -0.02524927f, -0.07665776f, -0.08577532f, -0.25374418f, -0.30270207f, -0.02259448f, -0.12031414f, 0.11721379f, 
    -0.33053899f, 0.08404330f, 0.15792651f, -0.03743400f, 0.61312968f, 0.08145115f, -0.24804057f, 0.00090736f, 
    -0.15206233f, 0.06161710f, -0.05725502f, 0.06325835f, -0.03445074f, 0.49424186f, 0.45267996f, 0.28011876f, 
    0.00886855f, -0.11374155f, -0.03618105f, -0.03380121f, -0.02450471f, 0.08926494f, 0.30237430f, 0.08955020f, 
    -0.14370401f, 0.02963061f, -0.06563439f, 0.01831769f, -0.03574234f, -0.02495146f, -0.17984788f, 0.00072468f, 
    0.14643559f, 0.38823637f, 0.05555605f, 0.12347277f, 0.12176831f, 0.09086624f, -0.06124814f, -0.04431403f, 
    0.16679005f, 0.32731742f, 0.35857290f, -0.31542155f, -0.07207482f, 0.01780996f, 0.01823557f, 0.03616808f, 
    -0.13081576f, -0.27173769f, -0.31898654f, -0.09909846f, 0.06164158f, 0.03413778f, -0.27888307f, 0.03437666f, 
    0.07307484f, -0.26163948f, -0.18051670f, -0.04852026f, -0.15020955f, 0.03306807f, -0.05287049f, -0.09680578f, 
    0.10573162f, -0.00131949f, 0.03090503f, -0.25980425f, -0.32445657f, -1.16899264f, 0.05986043f, 0.17294019f, 
    0.09301777f, -0.07085247f, -0.08180868f, 0.05128612f, -0.54570013f, -0.20255965f, -0.08290642f, 0.03335881f, 
    0.07974091f, -0.03679883f, 0.17508602f, -0.06151262f, -0.18336605f, -0.22625183f, -0.49662843f, -0.06793470f, 
    -0.00797926f, 0.17734614f, 0.01988267f, 0.11661775f, 0.03255745f, -0.09769795f, -0.01825060f, 0.25358286f, 
    0.10268197f, 0.12624788f, 0.01080099f, -0.07915242f, 0.18037198f, 0.08702171f, 0.09383726f, 0.32140458f, 
    0.40606192f, 0.15130253f, -0.15355849f, 0.12717825f, -0.21021123f, 0.21138242f, 0.11221465f, -0.05823684f, 
    -0.61459470f, 0.31301180f, 0.18964154f, 0.18478969f, -0.01020434f, 0.08586724f, 0.06116842f, 0.07265747f, 
    -0.02896143f, -0.40900138f, 0.27481046f, 0.22899574f, 0.02357970f, -0.05148211f, 0.06294772f, 0.05395690f, 
    0.01223022f, -0.12483085f, -0.97610265f, -0.12165905f, 0.18024789f, -0.20394629f, -0.04928632f, 0.00004321f, 
    0.06884648f, 0.05056512f, -0.00028190f, -0.15001194f, 0.12788254f, 0.07694349f, -0.10364018f, -0.24926324f, 
    -0.00079125f, -0.04137170f, 0.02966533f, 0.10654183f, -0.27332631f, -0.02069472f, 0.46038297f, 0.03172552f, 
    0.11511139f, -0.04664101f, 0.19738001f, -0.11914431f, 0.05577661f, 0.19547243f, 0.16900343f, -0.09999297f, 
    0.02215551f, 0.05605195f, 0.08415876f, -0.02831797f, -0.00083079f, -0.07457349f, 0.29471880f, -0.11055295f, 
    -0.12957822f, -0.29003349f, -0.18794443f, 0.08761136f, -0.02351873f, 0.05023809f, 0.33470646f, 0.22233810f, 
    0.32711881f, -0.18643974f, 0.03748586f, 0.10491501f, 0.15123452f, 0.02826309f, 0.12334877f, -0.15566176f, 
    -0.58319855f, -0.67143863f, -0.62690753f, 0.08675150f, 0.03593379f, 0.21705984f, 0.15582480f, 0.23054884f, 
    0.18312730f, -0.13726512f, -0.12783374f, -0.15647599f, 0.08512675f, -0.01556794f, 0.08647480f, 0.04651029f, 
    -0.10067318f, 0.07985104f, 0.35683957f, 0.10142419f, -0.16476674f, 0.03403580f, 0.14155367f, -0.00625603f, 
    -0.01498721f, 0.00874676f, -0.20600714f, 0.16059424f, 0.04954477f, 0.15923227f, -0.03702246f, -0.10316014f, 
    0.16055994f, 0.10641690f, 0.05028399f, 0.04535015f, -0.23610237f, 0.16207235f, 0.17674327f, -0.42167819f, 
    0.00651070f, -0.13609540f, 0.08457305f, 0.10469644f, 0.04753749f, -0.08525226f, 0.09057955f, 0.09661038f, 
    -0.04478183f, -0.10634704f, -0.03046535f, 0.19822979f, 0.11071111f, -0.16145274f, -0.17040338f, 0.18681364f, 
    -0.15801896f, 0.03751247f, -0.00118336f, 0.01038550f, 0.03767763f, 0.03691782f, 0.10959937f, -0.06802386f, 
    0.09179854f, 0.08711378f, -0.17530560f, 0.08568297f, -0.11095764f, 0.06621353f, 0.03327449f, 0.06763705f, 
    0.05880586f, 0.33023152f, 0.04754677f, -0.28253067f, -0.09479593f, 0.04327100f, -0.01389237f, -0.03214400f, 
    0.25554985f, 0.18137889f, 0.13647185f, -0.08175081f, -0.05331900f, -0.07568783f, 0.15322627f, 0.02493000f, 
    -0.03056819f, -0.08044324f, 0.46096426f, -0.19818728f, -0.31720111f, -0.18569236f, 0.08821568f, 0.12485692f, 
    0.16925123f, 0.17511258f, 0.04333649f, 0.61435872f, -0.07580308f, 0.23547010f, -0.28051952f, -0.06892657f, 
    0.06237597f, -0.05000932f, 0.17688775f, 0.24327461f, -0.49736592f, -1.00434029f, -0.43737420f, -0.15161648f, 
    -0.09379627f, -0.27555886f, 0.25782886f, 0.04221296f, -0.00610568f, 0.18092093f, 0.23667821f, 0.02414934f, 
    -0.22343197f, -0.10389014f, -0.17583886f, -0.06822115f, 0.07685678f, 0.26875246f, 0.39788511f, 0.37865296f, 
    -0.10967460f, -0.01851133f, -0.15637113f, -0.15335298f, 0.04743572f, -0.09553969f, -0.28244314f, -0.02746930f, 
    -0.04777450f, -0.13356268f, -0.11247627f, -0.23743398f, -0.04219563f, 0.02687633f, 0.00923954f, 0.13779500f, 
    0.17901453f, 0.12751816f, 0.05298553f, -0.24261571f, -0.30258283f, 0.21038000f, -0.13422833f, 0.22119181f, 
    0.24803844f, -0.01876796f, 0.18885958f, -0.33341187f, 0.24380203f, 0.07888961f, 0.01051293f, -0.01438723f, 
    0.22889704f, 0.18554114f, 0.32760862f, -0.21641754f, -0.14422990f, -0.27198121f, -0.20008071f, -0.05791242f, 
    -0.04198790f, 0.00468169f, 0.03503838f, -0.10834185f, -0.40367377f, -0.34920168f, -0.24441695f, 0.11357763f, 
    -0.36093783f, 0.12219045f, -0.09986328f, -0.15110359f, -0.10480716f, -0.58286750f, 0.54967785f, -0.19684228f, 
    -0.10795230f, -0.08731595f, 0.00071002f, 0.11674522f, -0.18921103f, -0.49636742f, -0.04556764f, 0.43351203f, 
    -0.24684203f, 0.06376557f, -0.08953994f, 0.12703307f, 0.00300778f, 0.10169590f, 0.04267320f, 0.01826290f, 
    -0.44106591f, -0.08081896f, -0.04361429f, 0.06760868f, 0.04502374f, 0.05655020f, -0.00616250f, -0.10195500f, 
    -0.02964682f, -0.33328113f, -0.10444005f, -0.11128647f, -0.05598537f, -0.03843362f, -0.19073707f, 0.06318579f, 
    -0.16447143f, -0.53494543f, -0.03493699f, 0.02291739f, -0.30777004f, -0.06995732f, -0.07245684f, -0.00778886f, 
    0.06428505f, -0.08584390f, -0.24906473f, -0.13165340f, 0.05533359f, -0.04638448f, -0.10819956f, -0.03899096f, 
    0.04818910f, 0.20289800f, -0.28325024f, 0.12248890f, 0.14811881f, 0.12689084f, -0.03318859f, -0.10911434f, 
    -0.08568393f, 0.03574654f, 0.08574484f, -0.32726294f, 0.15078205f, -0.14871706f, 0.00423207f, 0.10890906f, 
    0.10832675f, 0.02122658f, -0.00893673f, -0.14125973f, -0.21337155f, -0.23399773f, -0.20103513f, 0.17892145f, 
    0.02234854f, 0.06757108f, -0.05528171f, 0.19289392f, 0.42488736f, 0.14701243f, 0.33386579f, 0.18917219f, 
    -0.04880863f, 0.11446615f, -0.05256958f, 0.10006696f, 0.09345456f, 0.10136364f, -0.34672728f, -0.28423065f, 
    -0.37316868f, -0.36036423f, 0.09165534f, -0.25064582f, -0.18390478f, -0.13021171f, 0.10386883f, 0.44455919f, 
    0.13885368f, 0.17551717f, 0.15475842f, 0.07305661f, 0.06714074f, 0.43399623f, 0.20893531f, 0.01558535f, 
    -0.36241645f, -0.09579679f, 0.01719361f, 0.17602853f, -0.06885985f, -0.00414317f, -0.11357057f, 0.09062742f, 
    0.22811748f, 0.22068870f, -0.06883223f, -0.22219670f, -0.30263445f, 0.06153394f, 0.01666385f, 0.06208450f, 
    -0.15378925f, -0.10471891f, 0.09674030f, 0.33880383f, 0.05865074f, 0.16843823f, 0.30960146f, 0.01727311f, 
    0.17852330f, 0.28198791f, 0.10596831f, -0.11725515f, 0.02511044f, 0.10822614f, -0.01498393f, 0.02027699f, 
    -0.00166932f, -0.14247328f, -0.08269024f, 0.06948426f, -0.26010591f, -0.63839936f, -0.07951817f, -0.12849386f, 
    -0.22256871f, -0.24810562f, 0.15977541f, 0.08003031f, 0.03504107f, -0.29768130f, -0.07248578f, -0.16367006f, 
    -0.13070972f, -0.40686923f, 0.18628535f, -0.09646314f, -0.22051583f, -0.19457775f, -0.16837715f, -0.43025187f, 
    -0.20183937f, 0.06198248f, -0.08933678f, -0.08027127f, 0.20547730f, 0.11135908f, 0.06413610f, -0.15764734f, 
    -0.18064383f, 0.09121879f, 0.18816970f, 0.20605089f, -0.14930427f, 0.07232887f, 0.05987087f, 0.14717661f, 
    -0.10158669f, 0.29636264f, 0.25583196f, -0.17163745f, 0.01780651f, -0.01942093f, -0.12675337f, -0.34059194f, 
    -0.19683017f, 0.13111433f, 0.30622029f, 0.22633901f, -0.05767644f, 0.09403069f, -0.11182741f, 0.15719250f, 
    -0.08848907f, -0.00852322f, 0.28864828f, -0.10194652f, -0.10153199f, -0.09483892f, 0.16648225f, -0.03169655f, 
    0.02564439f, 0.13452721f, 0.10205072f, -0.35643372f, -0.35948098f, 0.00054943f, 0.04035303f, 0.25028113f, 
    -0.00430242f, 0.08647252f, 0.23120059f, 0.01938078f, -0.50905043f, -0.25699630f, 0.20693487f, -0.01235589f, 
    -0.17598604f, -0.05244898f, 0.15059319f, 0.22281198f, 0.13227345f, -0.12175778f, 0.25789568f, 0.35417679f, 
    0.05562989f, 0.12004906f, -0.34990799f, 0.08851986f, -0.21761157f, -0.11330555f, -0.14103699f, 0.03853063f, 
    -0.15125526f, 0.07796911f, -0.07310522f, -0.26941261f, 0.22402182f, 0.09949089f, 0.16517310f, -0.08950040f, 
    0.34448028f, 0.39634895f, 0.06292627f, -0.00056357f, 0.04406106f, -0.09654999f, -0.01572153f, 0.06578677f, 
    -0.20320570f, 0.23967561f, 0.09056883f, 0.03007868f, -0.09298218f, -0.10508265f, -0.08991666f, -0.04624309f, 
    0.05205377f, -0.33872977f, -0.09296010f, -0.10903453f, 0.00535318f, -0.01340987f, -0.19991624f, -0.15694034f, 
    -0.31063899f, 0.30005330f, -0.11532009f, 0.02546368f, 0.03026463f, -0.04424416f, -0.03245969f, -0.15863928f, 
    -0.03070747f, 0.07721812f, 0.06662271f, -0.00242396f, -0.40723789f, -0.88826060f, 0.19833945f, -0.17648299f, 
    -0.06219118f, 0.07178387f, 0.09853899f, 0.04296910f, -0.00901807f, -0.49263459f, -0.12073125f, 0.21388893f, 
    -0.24832785f, -0.17745000f, 0.22229265f, 0.06298415f, 0.12266180f, -0.06448781f, -0.39795178f, -0.12592284f, 
    0.16528617f, 0.15589331f, 0.18681939f, 0.05297101f, 0.06678960f, 0.08418402f, 0.18037845f, -0.17756462f, 
    0.27303180f, -0.12074005f, 0.05278549f, 0.00774230f, 0.22660275f, 0.01256607f, -0.06432299f, 0.05197146f, 
    0.18851897f, -0.29988384f, -0.17761870f, -0.10903630f, 0.16960162f, -0.15732688f, -0.49901080f, -0.06394725f, 
    -0.19402273f, 0.13925190f, -0.02001308f, 0.01296283f, -0.18864633f, -0.14396384f, 0.07637453f, -0.02302026f, 
    0.01202665f, -0.20517027f, 0.06556652f, 0.01063090f, -0.01428500f, -0.08221404f, -0.15095365f, -0.03683241f, 
    -0.05956294f, -0.04615483f, -0.05916385f, -0.05168480f, -0.04313116f, 0.03443517f, -0.13381530f, -0.15624093f, 
    0.08811069f, 0.02827980f, -0.10724159f, 0.13198531f, 0.12154350f, -0.06374220f, -0.04202750f, -0.03804922f, 
    -0.04246439f, 0.10749760f, -0.01582964f, 0.04875771f, 0.06018451f, 0.14494963f, -0.13447869f, -0.07218074f, 
    0.19914891f, -0.15712625f, 0.10437108f, 0.06626559f, -0.09259886f, -0.33620527f, -0.27883771f, 0.12707210f, 
    0.09572802f, -0.30978212f, -0.01493600f, -0.13073961f, -0.11276925f, 0.23012608f, -0.27133417f, 0.24955063f, 
    0.18213685f, 0.09683771f, -0.01607484f, -0.11184086f, 0.10949031f, 0.03644251f, 0.22508441f, -0.04466455f, 
    0.07899195f, -0.24130453f, -0.10110905f, -0.19268665f, 0.02172834f, -0.00231224f, -0.01653825f, -0.02333325f, 
    -0.01323014f, -0.13310647f, 0.13906233f, 0.01729065f, -0.02196738f, -0.09863197f, 0.00289571f, 0.02580002f, 
    0.08006984f, -0.13258706f, -0.09756219f, 0.11075744f, -0.10454670f, -0.03544620f, 0.04174185f, 0.02656057f, 
    -0.00993469f, 0.09258351f, -0.03773892f, -0.26809973f, 0.11189146f, 0.04540778f, -0.14965002f, 0.03598182f, 
    -0.09488533f, 0.13276035f, 0.14070125f, 0.29002219f, 0.25491863f, -0.13350925f, 0.06904345f, 0.11292187f, 
    -0.05583375f, -0.00324636f, 0.06509459f, 0.13746668f, 0.05796829f, 0.05043192f, -0.00286398f, -0.71383029f, 
    -0.43259254f, -0.36102808f, -0.07442839f, -0.02444120f, 0.14855748f, 0.00936319f, -0.04997892f, -0.13909492f, 
    0.01707528f, -0.06247232f, -0.03888167f, -0.04972300f, 0.16725326f, 0.16910164f, -0.14867298f, -0.12610875f, 
    0.03120900f, 0.01870978f, -0.07334749f, -0.04878040f, 0.07741729f, -0.06535131f, -0.06579743f, 0.08988414f, 
    0.14606638f, -0.07774560f, 0.08388864f, 0.01798892f, -0.18813431f, 0.03068603f, 0.05176314f, 0.08322766f, 
    0.01887417f, -0.25008222f, 0.27341089f, -0.18051462f, 0.00845817f, -0.23082444f, -0.10080665f, 0.09895598f, 
    0.06361126f, -0.05530848f, -0.14659582f, 0.28661814f, -0.04220475f, -0.10839427f, -0.01956901f, 0.06726924f, 
    -0.00552060f, 0.16241616f, -0.47589061f, 0.40489286f, 0.23409532f, -0.01831190f, 0.18456569f, -0.10365210f, 
    0.01031484f, 0.03566976f, -0.10531667f, 0.63982981f, -0.13988149f, -0.43593648f, 0.09383488f, 0.00033381f, 
    -0.28921053f, 0.11642637f, 0.08242003f, -0.08065236f, 0.14203010f, -0.08951586f, -0.06652728f, -0.51190716f, 
    -0.39221418f, -0.48648137f, -0.02287733f, 0.14005420f, -0.03714931f, 0.03794058f, -0.13505968f, 0.47199422f, 
    -0.16367899f, -0.12297602f, -0.20691636f, -0.14310655f, -0.03357323f, -0.10403876f, 0.03534536f, -0.01044497f, 
    -0.17420894f, -0.09922364f, -0.21125254f, -0.15183745f, 0.14319329f, 0.02597889f, -0.04265460f, 0.12603764f, 
    0.08911837f, 0.51314628f, -0.03457817f, 0.00760864f, -0.10220690f, 0.18440586f, 0.17458220f, -0.02949794f, 
    0.14588274f, 0.46698466f, 0.55113101f, -0.03304962f, 0.06325073f, -0.27097574f, 0.06076867f, -0.12197665f, 
    -0.09368311f, -0.29134157f, 0.12605740f, -0.08950048f, 0.17343491f, -0.09227460f, -0.08522405f, -0.01231006f, 
    -0.06564347f, 0.08983888f, 0.26980338f, -0.07719276f, -0.30682954f, -0.25999200f, -0.12834671f, -0.15627041f, 
    -0.02858924f, 0.00300888f, -0.02577039f, 0.67121810f, 0.62053496f, 0.10219436f, -0.13929941f, 0.18522091f, 
    -0.01340046f, -0.01164216f, -0.00971563f, -0.26599589f, -0.23018733f, 0.20981833f, 0.07507816f, 0.01882359f, 
    0.13168885f, -0.39829645f, 0.09804161f, 0.20257072f, 0.07155847f, -0.06995899f, 0.19350395f, 0.05456981f, 
    -0.09573688f, 0.00128667f, -0.09912324f, 0.13023493f, 0.20186774f, 0.03489644f, 0.37424639f, -0.28564042f, 
    -0.27645773f, 0.22484498f, 0.14760567f, 0.04123937f, -0.14911714f, -0.01932642f, 0.12554811f, -0.12875496f, 
    0.27405697f, 0.38648516f, -0.08913002f, -0.04172129f, -0.06237091f, -0.04602708f, 0.07743855f, -0.02859756f, 
    0.19884691f, 0.24401847f, -0.09970075f, 0.00945718f, 0.01138714f, -0.03768612f, -0.09152345f, 0.01401459f, 
    -0.13145912f, 0.23468767f, 0.28175187f, 0.02759037f, 0.01267574f, 0.17371027f, -0.05188781f, 0.00927066f, 
    -0.00578107f, -0.04250552f, 0.10572219f, 0.27774557f, 0.01248813f, -0.06578732f, 0.16410735f, 0.07745448f, 
    -0.00555404f, 0.08500151f, -0.05930484f, 0.05608998f, 0.10658370f, 0.02605061f, -0.20798263f, 0.04077936f, 
    0.13120218f, 0.18233435f, 0.04380115f, 0.03266311f, 0.18814400f, 0.17062169f, 0.05827824f, 0.10714412f, 
    0.02809210f, -0.08603512f, 0.07130031f, -0.05300224f, 0.20427184f, -0.23308004f, -0.46289495f, -0.08262095f, 
    -0.24429095f, 0.01685013f, 0.50825471f, 0.08170085f, 0.07712290f, 0.20292717f, 0.46584252f, -0.04064460f, 
    -0.17249793f, 0.04576182f, -0.06228760f, -0.23581153f, -0.07248013f, -0.00159239f, -0.20664184f, 0.11670805f, 
    -0.18383856f, -0.17597829f, -0.03670834f, -0.21347736f, 0.46171671f, 0.06873219f, 0.07904123f, 0.19656575f, 
    -0.18832228f, 0.04984777f, 0.13037421f, -0.06243068f, 0.11591563f, -0.04153225f, 0.11445922f, -0.07525346f, 
    -0.10911202f, 0.05013917f, 0.16413628f, 0.07466266f, 0.03917575f, -0.02267305f, -0.18105888f, 0.08997400f, 
    -0.03645443f, 0.03573689f, 0.13298768f, -0.17793377f, 0.42143017f, 0.00187527f, 0.06303923f, 0.27601463f, 
    0.04383187f, 0.14578107f, 0.23974524f, -0.20049495f, -0.35921061f, -0.08081070f, -0.15946631f, -0.07886156f, 
    -0.22522382f, 0.03058660f, -0.09817667f, -0.16445749f, -0.15513384f, 0.00291479f, -0.05333034f, -0.03328477f, 
    0.03214071f, 0.04528271f, 0.17493542f, 0.02033874f, 0.14031485f, -0.08812732f, -0.02910266f, -0.03853654f, 
    -0.18673398f, -0.09033605f, -0.12657492f, 0.23961616f, 0.11085137f, 0.06628869f, 0.33251899f, 0.36823565f, 
    0.02598282f, 0.01021402f, 0.02107085f, 0.06667169f, -0.00814127f, -0.10560808f, -0.10585764f, 0.04811127f, 
    -0.06050441f, 0.07095515f, 0.00642143f, 0.13902061f, -0.00870278f, 0.20760429f, 0.16046186f, 0.17843258f, 
    -0.60397041f, -0.16221388f, -0.33087224f, -0.15286779f, -0.00016954f, 0.04341815f, -0.15205762f, -0.04211779f, 
    -0.22082713f, 0.05899356f, -0.05918165f, -0.14995572f, 0.18509099f, -0.14554887f, 0.15285118f, 0.17606863f, 
    0.12717097f, 0.27865368f, -0.41264880f, 0.21879038f, 0.05379545f, 0.04779669f, 0.16801293f, 0.26986217f, 
    0.13519889f, 0.22105409f, -0.08278192f, 0.19376066f, 0.39127803f, -0.35839483f, -0.00004101f, 0.23535085f, 
    0.04298469f, 0.09687153f, -0.38044032f, -0.01384369f, -0.34101897f, -0.26008850f, 0.03119321f, -0.08634585f, 
    -0.01033561f, 0.06937815f, 0.03695535f, -0.14875478f, 0.03411877f, -0.25745288f, -0.30354908f, 0.04770975f, 
    -0.03857236f, 0.01120233f, 0.00463991f, -0.02619641f, -0.01660043f, 0.01934469f, 0.07189285f, 0.10871869f, 
    -0.12270415f, -0.19628617f, 0.02392747f, -0.06888627f, 0.31495333f, -0.28101519f, 0.24928647f, -0.09951518f, 
    -0.04914329f, 0.07817460f, -0.01061049f, -0.02438501f, -0.19431087f, 0.15304533f, 0.19431750f, 0.09867063f, 
    0.32291752f, -0.01761832f, -0.31799319f, 0.08409116f, -0.10226148f, 0.17997910f, 0.10240849f, -0.00256838f, 
    0.02115564f, 0.34329486f, -0.42438516f, -0.43197975f, -0.01504382f, 0.20243718f, -0.04124301f, 0.22936437f, 
    0.01717855f, -0.07642011f, -0.20299622f, -0.11057772f, 0.03026352f, -0.08699368f, -0.04235043f, -0.08981589f, 
    -0.05032520f, 0.09376520f, -0.00597984f, -0.67052513f, -0.63088930f, 0.18217508f, -0.11272416f, 0.11927601f, 
    0.25082499f, 0.08643030f, 0.35279161f, 0.04177591f, -0.63244331f, 0.13701008f, 0.13264832f, -0.09436311f, 
    -0.00554177f, 0.10185075f, 0.19069187f, 0.10923526f, -0.00719772f, 0.05977921f, 0.11077829f, 0.19199498f, 
    -0.04339758f, 0.06653336f, 0.23565902f, 0.13642286f, 0.18677191f, -0.11128984f, -0.30640990f, -0.15665209f, 
    0.18341111f, -0.22674343f, 0.04772522f, -0.04849759f, -0.21899536f, -0.08210263f, -0.26627460f, -0.15919873f, 
    -0.04658692f, -0.24272513f, -0.00803403f, -0.22823922f, -0.40429780f, -0.25710976f, -0.27945390f, -0.24757820f, 
    -0.21159182f, 0.05496586f, -0.11212795f, 0.02642120f, -0.01823526f, 0.11052420f, 0.06703386f, 0.24542283f, 
    0.03209435f, 0.04935115f, -0.24815753f, -0.38291928f, 0.00812726f, -0.06011293f, -0.08409480f, 0.00202270f, 
    0.04270860f, 0.04864421f, -0.45388749f, -0.31531203f, -0.09451217f, -0.02135863f, -0.05867539f, -0.08385801f, 
    -0.08501156f, 0.06493886f, -0.03407260f, 0.11453825f, -0.07850625f, -0.27214220f, 0.13272034f, 0.06570498f, 
    0.10651499f, 0.15464388f, -0.05656697f, -0.09176604f, -0.50818795f, -0.40644801f, -0.34185183f, 0.00187940f, 
    -0.14395775f, -0.08834449f, 0.05371432f, -0.28067395f, -0.08657232f, 0.67676854f, 0.22502086f, 0.37296402f, 
    0.04132158f, 0.03629787f, 0.06507656f, -0.04316601f, 0.27103722f, 0.06834492f, 0.00219720f, -0.12377034f, 
    0.15391500f, -0.24405086f, -0.19777091f, -0.34098858f, 0.17392810f, -0.00523527f, -0.15324529f, 0.79214650f, 
    -0.02285203f, 0.08985678f, 0.16708276f, -0.16620171f, 0.18792713f, 0.07110756f, 0.16190737f, -0.05427800f, 
    -0.05563261f, -0.31728140f, -0.35540804f, 0.03035613f, 0.08566585f, 0.04469561f, -0.25496656f, -0.00815142f, 
    -0.02514577f, -0.12004390f, 0.05024849f, -0.34325412f, -0.02299846f, 0.04387284f, -0.10831019f, 0.07430380f, 
    0.10002214f, -0.23247507f, 0.32513934f, 0.06597632f, 0.48770645f, 0.05154677f, 0.17178218f, 0.18308163f, 
    0.19841646f, 0.19279227f, 0.10754603f, 0.11315091f, 0.26287618f, 0.19097123f, 0.08423623f, 0.06963825f, 
    -0.11277511f, -0.16251755f, 0.06846078f, 0.06339919f, -0.15431571f, 0.10887504f, -0.35104635f, -0.09937569f, 
    0.04833935f, 0.22300303f, -0.05413985f, 0.07046068f, 0.00630868f, 0.11393674f, 0.02512624f, -0.04537129f, 
    0.04083734f, 0.28545293f, -0.07375165f, 0.13586386f, 0.03263119f, -0.03989323f, 0.18837699f, -0.12787747f, 
    -0.48671281f, 0.00831530f, -0.10799688f, -0.01962433f, 0.02337654f, 0.12415815f, 0.01700325f, 0.19629546f, 
    -0.60402286f, -0.17274283f, -0.31545663f, -0.33009428f, -0.08239017f, -0.15471479f, -0.22784990f, -0.08103053f, 
    0.14356554f, 0.45732680f, 0.24663623f, 0.17122552f, -0.12961940f, 0.12159277f, 0.19766736f, 0.10781396f, 
    0.21820769f, 0.16654328f, 0.28666121f, 0.16407278f, 0.03840878f, -0.00810775f, 0.06768543f, -0.02430924f, 
    0.04663366f, 0.00066173f, 0.70853370f, 0.33043528f, -0.26374459f, -0.00513589f, -0.07043763f, -0.09269706f, 
    -0.04338361f, 0.03777133f, 0.12967196f, -0.29575309f, 0.14551046f, -0.53523499f, -0.08012273f, 0.05473614f, 
    -0.00332194f, 0.02619658f, 0.11580705f, -0.01136797f, 0.09346294f, -0.28436941f, 0.12670201f, 0.04868612f, 
    -0.17298211f, 0.08401523f, -0.14098325f, 0.15319486f, 0.23043644f, 0.46506363f, 0.19306137f, 0.28776622f, 
    -0.07832929f, 0.04494568f, -0.10448340f, 0.02119638f, 0.09912732f, 0.03966868f, 0.51469457f, -0.36596668f, 
    0.16011333f, 0.06236795f, 0.02124336f, 0.00600637f, 0.11812529f, 0.07846236f, 0.02968843f, -0.18409215f, 
    0.21327090f, 0.03607921f, 0.02196185f, 0.01785393f, 0.07132716f, -0.19838646f, -0.06679679f, 0.11244272f, 
    0.08091421f, 0.22408737f, 0.11296900f, -0.06804173f, -0.25994939f, -0.08970321f, -0.08684836f, -0.00151519f, 
    0.13077489f, -0.09951957f, -0.27232525f, -0.21848676f, -0.51251531f, 0.07364652f, -0.23310131f, -0.02434221f, 
    -0.16016428f, -0.09737013f, -0.21712397f, 0.18164393f, -0.27025867f, -0.11538491f, 0.13656048f, -0.08130993f, 
    0.15755840f, 0.11653990f, 0.04604876f, -0.57655859f, -0.13191356f, -0.40459687f, -0.09301148f, -0.51334310f, 
    0.00798345f, -0.04203801f, 0.12966616f, -0.36914027f, 0.90724415f, 0.54145181f, -0.12104539f, 0.05146813f, 
    -0.02021008f, 0.03393940f, -0.15993783f, 0.11312209f, 0.21478401f, -0.40431261f, -0.79060751f, -0.35330144f, 
    0.04770451f, -0.24231002f, -0.14517453f, -0.08561103f, 0.01386930f, -0.42520192f, 0.09636737f, 0.18708745f, 
    0.21663882f, -0.02107037f, 0.02790343f, -0.11776301f, -0.07239912f, -0.13074762f, -0.02107849f, 0.19552206f, 
    0.22780865f, 0.17814995f, 0.20096266f, 0.00795474f, 0.04374127f, 0.00080108f, 0.12571965f, -0.02316391f, 
    -0.03151214f, -0.17221427f, 0.21915220f, -0.19659227f, -0.21307757f, -0.11073253f, 0.03205295f, 0.07953592f, 
    0.05271092f, 0.00272361f, -0.09150098f, -0.05235164f, 0.07975455f, -0.11761632f, 0.04638297f, 0.13569511f, 
    0.09705696f, 0.07269993f, -0.21013536f, -0.04926082f, 0.04059273f, -0.02575641f, -0.01722123f, -0.10378210f, 
    -0.10299174f, 0.18370789f, 0.13675100f, -0.14700484f, -0.06966246f, -0.14857681f, 0.14547575f, -0.06925203f, 
    0.03169555f, 0.03739469f, -0.00285915f, -0.02974249f, -0.13975571f, -0.17410812f, 0.09003769f, -0.02772622f, 
    0.00199620f, 0.04232144f, 0.08883809f, -0.03342566f, 0.13134913f, -0.15829530f, 0.27639195f, 0.44495496f, 
    -0.10744902f, -0.22337301f, 0.20297460f, -0.15027791f, 0.26540560f, 0.10172411f, 0.00674030f, -0.04432835f, 
    -0.19251366f, -0.12519872f, -0.22166754f, -0.17107221f, -0.11987800f, 0.01902851f, 0.05474466f, 0.21340227f, 
    0.16875798f, 0.21777542f, -0.07249511f, -0.03648918f, 0.14487058f, 0.10900728f, 0.06275568f, 0.06316847f, 
    -0.24850999f, -0.07369231f, 0.01957220f, 0.08713968f, 0.24695666f, 0.24624562f, 0.10070451f, 0.10470317f, 
    0.04137949f, 0.02801146f, -0.05879192f, 0.17313509f, -0.00730354f, 0.13489047f, 0.04379736f, 0.17727499f, 
    -0.00405575f, 0.13217191f, 0.04002865f, 0.39573762f, 0.61269063f, 0.05070803f, 0.06965572f, 0.10712588f, 
    0.20140415f, 0.09222267f, 0.00988115f, -0.19773579f, -0.21922284f, -0.15325961f, -0.12569445f, -0.19571091f, 
    0.06237112f, -0.20156550f, -0.08181401f, 0.12627156f, -0.10460122f, 0.02069329f, -0.02453284f, -0.12287088f, 
    0.00227181f, -0.21989781f, 0.22035430f, -0.02335465f, 0.21146175f, -0.03828287f, -0.13529278f, -0.12945119f, 
    -0.12086985f, -0.03581136f, -0.18182781f, 0.19398507f, -0.01003887f, -0.01593184f, 0.02522143f, -0.07003005f, 
    0.08609018f, -0.12584113f, 0.13842151f, -0.11463057f, 0.07416900f, 0.06773665f, 0.02386301f, 0.05180312f, 
    0.11015725f, -0.09821816f, -0.10484896f, 0.12393706f, 0.09494287f, 0.03606235f, -0.10059004f, 0.06437994f, 
    -0.24254426f, -0.05347093f, -0.03602302f, -0.00564730f, -0.05435308f, -0.25137666f, -0.00238048f, -0.17484368f, 
    0.06799167f, -0.12640969f, 0.16573615f, -0.04870896f, 0.07647722f, -0.04696050f, -0.08615126f, 0.04857659f, 
    0.12338068f, -0.01875423f, 0.94976401f, 0.30093700f, -0.09443571f, 0.17124209f, -0.09355098f, 0.16511379f, 
    0.24070482f, 0.17229082f, -0.06807104f, 0.32757691f, -0.06200113f, -0.21693015f, -0.24180932f, 0.04506646f, 
    0.25376293f, 0.14743151f, 0.17847680f, 0.13251759f, -0.63646758f, -0.56718767f, -0.38626575f, -0.09897429f, 
    0.22790945f, -0.10824682f, -0.02340966f, -0.14968836f, 0.11164615f, -0.30523145f, -0.12468809f, 0.03820557f, 
    -0.25813001f, -0.43636218f, 0.04784927f, -0.01800917f, 0.07782356f, 0.04665691f, 0.14781141f, -0.03819894f, 
    -0.08713143f, 0.05969651f, 0.01257954f, -0.13853173f, 0.04507947f, -0.07202183f, 0.02557031f, -0.27508312f, 
    -0.07914693f, -0.17018692f, -0.04370255f, -0.25859120f, -0.10768995f, -0.11806951f, -0.03754199f, 0.09597112f, 
    -0.25854933f, -0.20590560f, 0.03534631f, -0.16587821f, -0.14051713f, -0.03310229f, -0.06707923f, 0.16927212f, 
    0.16901772f, -0.34241417f, -0.07159889f, -0.44925985f, -0.43795016f, 0.11195543f, -0.26713449f, -0.17098975f, 
    0.05136740f, 0.15183809f, 0.04541221f, 0.00827415f, -0.12181316f, -0.01445942f, -0.19384800f, 0.02487452f, 
    -0.14140581f, 0.16793510f, -0.09009200f, -0.22997881f, -0.28760773f, 0.13443589f, -0.17922103f, -0.37079844f, 
    -0.19080958f, -0.11534938f, -0.09590937f, -0.10933007f, 1.30993593f, 0.03824753f, -0.22376144f, -0.15057287f, 
    -0.07545033f, 0.09894091f, -0.47772229f, 0.22184084f, 0.08530149f, 0.05106314f, -0.04163158f, 0.03710673f, 
    0.08374270f, 0.05656707f, -0.08060030f, 0.05694147f, 0.06643464f, 0.10071490f, -0.16590759f, -0.01166240f, 
    -0.10179048f, -0.05346265f, 0.07374547f, 0.09012360f, 0.08293606f, 0.15527707f, 0.07092763f, -0.14928707f, 
    -0.43474305f, -0.38469949f, 0.04416104f, 0.13659821f, -0.12503015f, -0.06431024f, 0.01841437f, 0.12569694f, 
    0.36350134f, 0.25600013f, 0.26012829f, -0.03251335f, -0.14953862f, -0.18739872f, 0.01926995f, -0.06940351f, 
    0.06463251f, 0.24579792f, 0.22441261f, 0.22109729f, -0.01773424f, -0.07647288f, -0.09443990f, 0.04260234f, 
    -0.03008791f, 0.01817424f, 0.31450394f, 0.16648777f, 0.10216642f, 0.03671365f, -0.04232111f, -0.00653518f, 
    0.00439044f, 0.13502182f, 0.03982428f, 0.07094973f, 0.03494070f, 0.15238413f, 0.09535159f, -0.08977284f, 
    0.05956325f, -0.11842978f, -0.00222578f, 0.06320255f, 0.15490542f, 0.01331418f, 0.13627367f, -0.15270822f, 
    -0.00717236f, -0.04862946f, -0.07650205f, -0.00955349f, -0.01866848f, 0.06765234f, 0.32660720f, -0.32826051f, 
    0.07254577f, -0.08381905f, 0.04411649f, 0.08910874f, -0.04452243f, -0.08046905f, 0.41945428f, 0.29469252f, 
    0.21375507f, -0.11266353f, -0.20376590f, 0.05512970f, -0.04735621f, -0.12997279f, -0.07818899f, -0.25060585f, 
    -0.38184136f, -0.40417522f, 0.11528318f, 0.12757474f, 0.04390132f, 0.22273417f, 0.04119373f, 0.00432939f, 
    0.03471962f, -0.31964627f, -0.23813301f, -0.08655554f, -0.09080901f, 0.13867687f, -0.01856233f, 0.01340878f, 
    -0.18931782f, 0.00673809f, -0.08661615f, 0.08966669f, 0.17029682f, 0.03172792f, 0.02820599f, 0.05897615f, 
    -0.07660516f, -0.00835609f, -0.35571194f, -0.40763810f, -0.72364515f, -0.19765240f, -0.28772524f, 0.06250147f, 
    0.02883736f, 0.12292167f, 0.03808165f, -0.30903453f, 0.23659296f, 0.07105821f, 0.09925259f, -0.02945127f, 
    -0.12164296f, 0.02667994f, 0.07333665f, -0.06389987f, 0.19557154f, -0.04310280f, -0.02782258f, -0.12734552f, 
    -0.05217345f, -0.01591412f, -0.07670460f, -0.07790412f, -0.16948231f, 0.07146333f, 0.01673188f, -0.01813419f, 
    0.08821611f, 0.10809000f, 0.01266150f, -0.04975212f, -0.12293985f, -0.19339514f, 0.32554802f, 0.05870264f, 
    0.22042644f, -0.03106850f, 0.01307643f, -0.12499661f, 0.11165299f, 0.03236487f, -0.06986968f, 0.13397133f, 
    0.12569393f, -0.16772068f, 0.01555158f, 0.03132075f, 0.01839816f, 0.05138171f, -0.08395834f, -0.14720346f, 
    -0.27495253f, -0.17284939f, 0.13122162f, -0.19500373f, -0.09856091f, -0.01287828f, -0.11268384f, -0.20988452f, 
    -0.01300275f, -0.07146107f, -0.29526713f, -0.14234392f, 0.01702144f, -0.01943240f, 0.20543161f, 0.03336652f, 
    0.02706597f, 0.01033203f, 0.03710135f, 0.00481500f, -0.12946028f, -0.03057328f, -0.01428033f, 0.03740897f, 
    0.08591177f, -0.02321764f, -0.05812691f, 0.06493768f, -0.30477485f, 0.14983816f, -0.04248145f, 0.18540864f, 
    -0.15360530f, 0.02678459f, 0.11317098f, -0.14207490f, 0.22681750f, -0.17882374f, -0.29623330f, -0.08697024f, 
    -0.23284325f, -0.11640272f, -0.10832707f, -0.10911287f, -0.19256304f, 0.08184714f, -0.06633423f, -0.02820925f, 
    0.08834936f, 0.04762784f, 0.09211265f, 0.05072311f, -0.01408762f, 0.11989710f, -0.06882309f, -0.21381095f, 
    -0.16549641f, 0.13132156f, 0.01757598f, 0.13263111f, 0.09837870f, 0.06295004f, 0.20170507f, -0.15062164f, 
    -0.16829719f, 0.12752713f, 0.09507345f, -0.04818399f, 0.03725832f, 0.00791984f, 0.02571485f, -0.03070457f, 
    -0.37498030f, 0.18828411f, 0.18885149f, -0.08955769f, -0.06610639f, -0.01936748f, -0.08971981f, 0.00993094f, 
    -0.00467027f, 0.03249568f, 0.29461077f, 0.23568273f, -0.07896836f, -0.11511838f, 0.01146982f, 0.07188424f, 
    -0.00708885f, 0.02257119f, 0.10065472f, -0.07300878f, -0.14695325f, 0.00180872f, -0.00599148f, -0.04253785f, 
    0.01021427f, -0.05688076f, -0.21150732f, -0.20310509f, 0.45607436f, -0.08538488f, 0.17221017f, 0.19267794f, 
    0.06327233f, -0.03649694f, 0.03314800f, -0.02961465f, 0.20714521f, -0.19354852f, 0.08411281f, -0.12652971f, 
    0.12602803f, 0.09111544f, 0.13935852f, -0.03779118f, 0.02440992f, 0.37949145f, 0.18258336f, 0.14170624f, 
    0.05846924f, -0.06159978f, -0.13322988f, 0.01622248f, 0.13217440f, -0.07220356f, 0.04588438f, -0.18840860f, 
    -0.24430075f, 0.07163039f, -0.00681200f, -0.15229680f, 0.11039889f, 0.03860926f, -0.17718883f, -0.10251936f, 
    -0.11652107f, 0.31866863f, 0.18932383f, 0.09622283f, 0.22287749f, -0.08790684f, -0.10672725f, 0.08310611f, 
    -0.00407597f, -0.07194337f, -0.07561947f, -0.03714944f, -0.05975420f, 0.00695896f, -0.14883187f, -0.27784508f, 
    -0.07272305f, -0.00505619f, -0.03599152f, -0.00460022f, 0.02252080f, 0.01722247f, 0.01449159f, -0.11883763f, 
    -0.25750789f, -0.01252289f, 0.07115217f, -0.09130137f, -0.13730809f, 0.06148149f, -0.07636600f, 0.03661579f, 
    0.09295821f, 0.02558644f, -0.09851599f, -0.13000755f, -0.18646111f, -0.21458305f, 0.01654637f, -0.01203500f, 
    0.06449011f, 0.10458878f, -0.11306575f, -0.33460301f, -0.00777490f, -0.12749507f, 0.02231723f, 0.04188423f, 
    -0.22848880f, 0.02592087f, -0.23893407f, -0.07740466f, 0.05921121f, 0.26477024f, 0.30055884f, -0.13572730f, 
    0.07693051f, 0.03154359f, 0.08886853f, 0.01815426f, -0.01281183f, -0.14476317f, -0.33555806f, -0.28187892f, 
    -0.22016644f, 0.01081700f, 0.13480599f, 0.06548125f, -0.04643066f, 0.14869364f, 0.24017146f, -0.04749619f, 
    -0.08456012f, -0.27467877f, -0.12233563f, 0.00099147f, 0.20752169f, -0.21327536f, -0.11304523f, -0.16228162f, 
    0.15857334f, 0.06763590f, -0.12158228f, -0.08240359f, -0.21161921f, -0.04793521f, 0.05043153f, 0.09906783f, 
    0.09717590f, 0.06034407f, -0.05209086f, 0.02738235f, -0.03663743f, -0.01639709f, -0.00624576f, 0.07721214f, 
    -0.04277236f, 0.09259091f, -0.05688512f, -0.19855593f, -0.11396575f, 0.01098240f, 0.05696059f, -0.17580453f, 
    -0.12024033f, -0.18880889f, -0.17210881f, -0.02902263f, 0.28771582f, 0.29753685f, 0.14354864f, -0.17513876f, 
    0.14178412f, 0.07246318f, 0.20950869f, -0.14475602f, -0.05317100f, -0.03714834f, -0.04870247f, 0.11925200f, 
    -0.00621801f, -0.12221560f, -0.10532521f, -0.05832162f, -0.03585232f, 0.01080353f, 0.06653873f, -0.12220625f, 
    0.13335815f, 0.24423067f, -0.11660218f, 0.04092748f, 0.03322523f, 0.05681035f, 0.00542151f, -0.06490129f, 
    -0.05101394f, 0.03121132f, -0.07494503f, -0.03480202f, -0.00570351f, -0.08698322f, 0.10465576f, -0.17105523f, 
    -0.07382731f, -0.04752672f, 0.01517098f, -0.24841669f, -0.02070459f, -0.09111390f, -0.00301831f, -0.00358945f, 
    0.27581608f, 0.42591852f, 0.41878316f, 0.08877347f, 0.04542486f, 0.00296363f, 0.05454780f, 0.07766230f, 
    0.13902099f, 0.12182648f, 0.32216436f, 0.14766024f, 0.08898439f, 0.12681335f, 0.01916127f, 0.08871054f, 
    -0.10531563f, -0.09223609f, 0.37275109f, -0.11414214f, -0.12465806f, 0.03080712f, -0.08139808f, 0.07218403f, 
    0.12523434f, -0.05821665f, -0.34915203f, -0.53124362f, -0.45545995f, 0.35201216f, 0.23517844f, 0.22379674f, 
    -0.07163111f, -0.09876989f, 0.03635056f, 0.01482033f, 0.05722497f, 0.08266599f, 0.00660146f, 0.10170002f, 
    -0.07676779f, 0.04943374f, -0.03524318f, 0.06006187f, 0.05311394f, 0.20191216f, 0.45916399f, 0.51654404f, 
    0.02097066f, 0.10725789f, 0.11025906f, -0.01612355f, -0.00262224f, 0.01294620f, -0.16777745f, -0.13684727f, 
    -0.03547989f, 0.04894139f, 0.13602903f, 0.20803019f, -0.14421879f, -0.30773905f, -0.18773897f, 0.34370446f, 
    0.37394765f, -0.03569719f, 0.05446007f, 0.01352743f, 0.06866249f, 0.17275323f, -0.13664217f, -0.44708452f, 
    -0.23258664f, -0.04044735f, -0.04958150f, 0.09143320f, 0.15028860f, 0.10349042f, 0.07164803f, 0.11568547f, 
    0.02780473f, -0.12763676f, -0.04190600f, -0.01009792f, 0.11093349f, -0.04341400f, 0.23173912f, -0.29439384f, 
    0.34597445f, -0.42526522f, -0.00902720f, -0.04493319f, 0.06515745f, 0.02475034f, -0.19333144f, 0.01672710f, 
    -0.07022160f, 0.16268037f, -0.01034099f, -0.08310153f, 0.11837473f, -0.47833440f, 0.06048051f, -0.08036184f, 
    0.20447065f, -0.09970544f, 0.18214299f, 0.27544680f, 0.07238202f, -0.01302108f, -0.06661424f, 0.27227601f, 
    0.08574244f, -0.03915560f, -0.08113156f, -0.20110974f, -0.45989743f, -0.01875987f, -0.23964460f, -0.12364917f, 
    -0.01734935f, 0.01065660f, -0.08306541f, 0.11981179f, 0.12352090f, 0.16868056f, 0.08906902f, 0.32670817f, 
    0.15949923f, 0.00098288f, -0.26602745f, -0.04530139f, 0.00299395f, 0.21335937f, -0.02621048f, 0.17922579f, 
    0.12953091f, 0.11288076f, -0.01335720f, 0.17629060f, 0.02955388f, 0.13253361f, 0.03376005f, 0.22504210f, 
    -0.01151541f, 0.10366428f, 0.19375950f, 0.00374527f, 0.04045848f, -0.16744153f, -0.01121928f, 0.18744260f, 
    0.06745411f, 0.08374364f, 0.10707802f, 0.13556653f, 0.02241427f, -0.04748477f, 0.01901982f, 0.08030003f, 
    -0.02790185f, 0.02322681f, -0.09888045f, 0.04936611f, 0.14741538f, -0.04997805f, 0.01381159f, 0.02339600f, 
    0.03926408f, 0.04623825f, 0.14994928f, 0.00338313f, 0.12752596f, -0.08966441f, -0.09623966f, -0.08357049f, 
    0.00060175f, -0.13338742f, 0.06947105f, -0.06580943f, 0.02512869f, 0.00537784f, -0.02363707f, -0.14068189f, 
    0.09161016f, -0.15225013f, -0.11273412f, -0.03684270f, -0.08924649f, 0.29965690f, 0.05744183f, -0.31232476f, 
    -0.05301274f, -0.07111847f, 0.02608212f, -0.00398130f, 0.15397848f, -0.11208861f, 0.01937963f, -0.04016411f, 
    0.10662795f, -0.03545531f, -0.09882278f, 0.27999687f, -0.08594906f, 0.09366627f, 0.02457149f, 0.45504338f, 
    0.02582613f, -0.45977417f, 0.07701816f, -0.04405221f, -0.05937334f, 0.07716005f, -0.05810339f, -0.33512899f, 
    0.15342809f, -0.16299012f, -0.29401079f, 0.06359717f, 0.04608310f, 0.04396155f, 0.05022456f, -0.10333132f, 
    -0.05651865f, -0.24368156f, -0.07496366f, 0.00010670f, 0.27739584f, 0.14431818f, 0.27971041f, -0.09921382f, 
    0.01563093f, -0.04216661f, 0.14856651f, -0.22350368f, -0.53657681f, -0.07195352f, 0.06220113f, -0.24933811f, 
    -0.03992279f, 0.11217353f, 0.13755167f, 0.09209476f, -0.03869027f, 0.40494347f, 0.13537085f, 0.00611627f, 
    0.27130830f, 0.01264867f, -0.03751422f, 0.25281185f, 0.12320867f, 0.09182607f, 0.04550518f, -0.04634708f, 
    -0.09598233f, -0.12120782f, -0.16294633f, -0.36926562f, -0.16508003f, -0.06295884f, -0.05925731f, -0.02895214f, 
    0.08493575f, -0.02312703f, 0.10338897f, 0.08926827f, -0.23139295f, 0.17817761f, 0.10632849f, -0.01937305f, 
    -0.03508589f, -0.00474705f, 0.00731860f, 0.00858130f, 0.12850428f, 0.12140129f, 0.07040065f, 0.09374692f, 
    0.13690858f, 0.09581324f, -0.01851346f, 0.08759678f, -0.01136903f, -0.12478492f, -0.15510695f, 0.02112163f, 
    0.41640809f, 0.01211563f, 0.06342006f, -0.16675743f, -0.08505658f, -0.02052847f, 0.01457757f, -0.01536469f, 
    0.08390956f, 0.02733534f, -0.08056279f, -0.31144369f, -0.03904678f, -0.03108446f, -0.08431227f, 0.17632033f, 
    0.27533913f, -0.33660519f, 0.20072046f, -0.00183422f, -0.11080329f, -0.08425529f, -0.01214863f, 0.34013876f, 
    0.04465000f, 0.23212761f, -0.01496128f, 0.32043624f, 0.17121589f, -0.15410258f, 0.17420508f, 0.17240642f, 
    -0.03590897f, 0.28515676f, 0.13526124f, 0.07127637f, 0.20077835f, -0.08663345f, -0.29972318f, -0.10292134f, 
    -0.01988694f, -0.27459517f, -0.04749886f, -0.39948863f, -0.28826654f, 0.05897121f, 0.08634201f, -0.15469956f, 
    0.03394174f, 0.02281608f, -0.13993737f, 0.05065645f, 0.10555772f, -0.12470838f, 0.09487274f, -0.11710586f, 
    -0.14998791f, -0.10869484f, 0.12650344f, -0.12526155f, -0.07637939f, -0.01319118f, 0.04257725f, -0.11650644f, 
    -0.31451997f, 0.11332426f, 0.02132286f, -0.03922253f, 0.00065005f, 0.00666831f, 0.07470687f, -0.09439272f, 
    -0.21000208f, -0.05888493f, 0.31133667f, 0.07173695f, 0.01179127f, 0.14030351f, -0.11084282f, 0.00293584f, 
    0.01714891f, 0.06877509f, -0.03536738f, 0.04028890f, -0.02477626f, -0.00469912f, -0.15860634f, 0.24217737f, 
    0.50539947f, -0.13869256f, 0.18508428f, 0.04908880f, -0.01326566f, 0.09730355f, -0.04108542f, 0.00241017f, 
    0.08546909f, 0.02299637f, 0.02328607f, -0.11790957f, -0.12422331f, 0.11989845f, 0.04176846f, -0.24898526f, 
    0.25769535f, -0.09726974f, 0.30706832f, 0.09323226f, 0.10033359f, 0.08336584f, 0.14881530f, -0.07449865f, 
    0.00534401f, 0.03736763f, -0.22073723f, 0.18697405f, 0.14301571f, -0.12143739f, -0.04012270f, 0.15195952f, 
    -0.02808367f, -0.19851470f, 0.05958315f, 0.17724089f, -0.08435988f, 0.09101571f, 0.39835048f, -0.12431715f, 
    -0.13268901f, -0.04986384f, -0.00725268f, 0.07305241f, 0.11587852f, -0.02759678f, 0.04099162f, -0.17363401f, 
    -0.16549490f, 0.12869233f, 0.09779672f, 0.01679767f, 0.29474285f, 0.03359848f, 0.01700084f, 0.16881707f, 
    -0.06437291f, -0.15983681f, 0.01132095f, -0.00358918f, 0.11052635f, -0.05765738f, 0.10082199f, 0.02923100f, 
    0.07466186f, -0.04024463f, 0.02151707f, 0.10574943f, 0.14416403f, 0.14228395f, -0.13980737f, 0.07491304f, 
    0.12953196f, 0.01233128f, -0.06532772f, 0.03949242f, 0.13359106f, 0.03898109f, -0.01365264f, -0.19793861f, 
    0.23638691f, 0.00219379f, 0.07696617f, -0.15578441f, -0.33695325f, -0.18097676f, -0.03325594f, 0.13123395f, 
    -0.01992805f, -0.09594218f, 0.04224264f, -0.00786110f, 0.14667222f, 0.19599891f, -0.00129219f, 0.04727725f, 
    0.34115648f, 0.15716909f, 0.09768283f, 0.20128202f, 0.13818026f, -0.03749191f, 0.27635291f, -0.16002773f, 
    0.08186214f, 0.06329083f, -0.08921073f, 0.02222504f, 0.02758333f, 0.00284153f, -0.06344784f, -0.34354660f, 
    -0.16117585f, 0.12314750f, 0.02766179f, -0.18930659f, -0.09028826f, -0.03934963f, -0.17006315f, -0.20832241f, 
    -0.47250074f, 0.17852819f, 0.17832170f, 0.06136009f, 0.33236811f, -0.02764595f, 0.00891125f, 0.02043776f, 
    0.17894235f, 0.25430468f, -0.15051277f, 0.00797776f, -0.28458998f, -0.01227263f, 0.17532782f, 0.13959429f, 
    0.16026188f, 0.24204080f, 0.12456725f, -0.37699071f, -0.02146839f, -0.03510584f, -0.02787745f, 0.05104694f, 
    0.05120763f, -0.14474013f, -0.09150618f, -0.06152030f, 0.09716098f, 0.05363013f, -0.00813017f, 0.15000588f, 
    0.03847091f, 0.07165091f, 0.02725740f, -0.36420324f, -0.33089367f, 0.09002595f, -0.12930813f, 0.16427800f, 
    -0.17627236f, 0.03343647f, 0.16496597f, -0.00256053f, 0.07306428f, 0.10839953f, -0.13015307f, -0.21420260f, 
    -0.27969432f, -0.23866569f, 0.07261031f, 0.02390020f, 0.08309100f, 0.07941749f, 0.02292196f, -0.28920037f, 
    0.18805955f, -0.20489414f, 0.22045420f, 0.13149278f, 0.12376414f, 0.05013359f, -0.05223235f, -0.26415393f, 
    -0.13098934f, 0.01610033f, -0.04891558f, -0.01610984f, 0.00554230f, 0.04377200f, 0.07272959f, -0.13369820f, 
    0.15989000f, 0.14774196f, -0.03110797f, -0.39025119f, 0.01753136f, 0.30269584f, 0.09937109f, -0.11609466f, 
    -0.09259311f, 0.19090277f, 0.02374467f, -0.21124595f, -0.05187654f, -0.07252994f, -0.13166471f, -0.06694490f, 
    -0.19152953f, 0.00285709f, 0.09167411f, 0.07623775f, -0.10379332f, 0.08122800f, -0.01818543f, 0.17472538f, 
    0.13544434f, 0.08796343f, -0.08185681f, -0.01224784f, -0.82746583f, -0.15009753f, 0.16325603f, 0.05532173f, 
    0.03634750f, -0.04026574f, -0.07167829f, -0.03794874f, -0.66474104f, 0.37135452f, -0.03460690f, 0.09420522f, 
    0.09046235f, -0.02927756f, -0.07230583f, 0.19936338f, 0.12140702f, 0.20256574f, 0.36185914f, -0.31687522f, 
    -0.53157598f, -0.29481274f, 0.14415944f, 0.12239385f, 0.13505945f, 0.12810753f, 0.24585401f, -0.08201560f, 
    -0.18069033f, -0.00226246f, -0.01425858f, 0.02482687f, 0.05195061f, -0.06234017f, -0.12726609f, -0.11906902f, 
    0.27067104f, 0.11319135f, -0.30478111f, 0.27811041f, -0.21963610f, -0.01662238f, 0.00687236f, 0.26698697f, 
    -0.09204821f, -0.05907167f, -0.05301574f, 0.12837379f, -0.14354800f, 0.09360103f, 0.13738421f, -0.11729841f, 
    0.15782627f, -0.49927580f, 0.28280443f, 0.10803297f, 0.07230461f, -0.17640235f, 0.13161290f, 0.09548988f, 
    -0.09724914f, -0.78647959f, -0.36580643f, -0.24833518f, 0.04250296f, -0.05179775f, -0.10788428f, -0.19231558f, 
    0.01371309f, -0.33455858f, 0.01326620f, -0.39888176f, -0.13334565f, -0.04769652f, 0.07174357f, 0.00926091f, 
    -0.05809958f, -0.08959801f, 0.09255431f, -0.20254271f, 0.03400369f, -1.16242373f, -0.50496823f, 0.43092334f, 
    0.18835540f, -0.00125295f, -0.12262013f, 0.00374723f, -0.04705463f, 0.05591308f, -0.49095625f, -0.39615786f, 
    -0.10202391f, 0.27182859f, -0.03390858f, 0.04461902f, -0.15623502f, 0.08596791f, 0.08289158f, -0.08097249f, 
    -0.00162516f, -0.03020575f, 0.19543460f, 0.31416437f, 0.13429126f, 0.28578103f, -0.45648801f, -0.12057698f, 
    0.16243640f, 0.09183733f, 0.01895084f, -0.00747265f, 0.07793966f, 0.06577438f, 0.06987834f, 0.36632451f, 
    0.25523138f, -0.29511413f, -0.08258684f, -0.09946879f, 0.08298861f, 0.00962505f, -0.06341638f, -0.21513693f, 
    0.06679469f, -0.04896251f, -0.02491059f, 0.32630616f, 0.23651375f, 0.23435700f, 0.04589269f, 0.17457485f, 
    -0.01009807f, 0.11210737f, 0.01802805f, 0.03344491f, 0.10859009f, 0.14887398f, 0.14590240f, 0.02078478f, 
    0.14423090f, 0.01600374f, 0.04251802f, -0.03056820f, 0.06702880f, 0.06642449f, 0.05621463f, 0.19253421f, 
    0.05408803f, -0.01556893f, 0.17821828f, -0.03793307f, 0.05991736f, -0.17681485f, 0.12330318f, -0.03979717f, 
    -0.08835486f, 0.14815214f, -0.00413115f, 0.06550240f, 0.04680968f, -0.08526331f, -0.03741766f, 0.21016523f, 
    0.01754699f, 0.04683292f, 0.05675609f, -0.01036750f, 0.03264029f, 0.36625704f, -0.08625203f, 0.11160897f, 
    -0.03156586f, -0.17378274f, 0.01741295f, 0.08014915f, 0.00327517f, -0.12650713f, 0.09878480f, 0.11691624f, 
    0.08212795f, -0.10767744f, -0.20494699f, -0.19164331f, -0.02041559f, 0.04940580f, -0.05290022f, 0.00346056f, 
    0.05259959f, 0.18300453f, -0.34356776f, -0.07514310f, -0.55439633f, 0.13953820f, 0.02387516f, 0.11731704f, 
    0.20080784f, -0.00940054f, 0.29335487f, 0.13474506f, 0.18383065f, 0.07312173f, 0.21906662f, -0.11541181f, 
    -0.13336140f, 0.08623575f, 0.22115551f, 0.17887686f, 0.02488358f, -0.00224058f, -0.00685514f, -0.08740305f, 
    -0.21933191f, -0.16005109f, 0.00961339f, 0.10480751f, 0.31067380f, -0.19236301f, -0.03837138f, 0.03173190f, 
    0.16520518f, 0.10319362f, -0.00527914f, 0.21399313f, 0.06122948f, 0.06099252f, -0.19578555f, -0.22081333f, 
    -0.04502593f, -0.05144946f, 0.06424461f, -0.33042544f, 0.26163763f, 0.08308917f, 0.33396506f, 0.06820050f, 
    0.01765215f, 0.07016288f, 0.07025676f, 0.02384815f, -0.12252650f, 0.16205831f, 0.13084622f, 0.16124232f, 
    0.14759900f, 0.04801842f, -0.02139696f, 0.19116911f, -0.10470605f, -0.22156547f, -0.07538699f, -0.07497548f, 
    -0.05868698f, 0.28445354f, 0.07047310f, 0.11098688f, 0.05994084f, 0.13424443f, 0.00765650f, 0.20200379f, 
    -0.05756112f, 0.07779786f, -0.05890467f, -0.08520423f, 0.17918135f, -0.15851197f, -0.11537049f, -0.13625748f, 
    0.11429253f, 0.01494615f, 0.18351847f, -0.11369268f, -0.09660032f, 0.00557201f, 0.14856140f, -0.26534250f, 
    -0.09013064f, -0.00910479f, 0.15200950f, 0.03132134f, 0.37198836f, -0.00140292f, -0.21782608f, -0.01210279f, 
    0.02724715f, 0.04701893f, 0.26788324f, 0.02007312f, -0.24253556f, 0.10398930f, -0.28075132f, -0.01883161f, 
    0.10092541f, 0.00261364f, -0.07518137f, -0.31582206f, -0.02319422f, -0.21693635f, 0.10600633f, -0.11999867f, 
    -0.06577533f, 0.04771310f, -0.12973641f, -0.18257372f, 0.02959152f, 0.05076192f, 0.41931799f, -0.10624065f, 
    -0.03707953f, 0.05862163f, -0.03908937f, -0.09606262f, -0.17759176f, -0.01956260f, 0.06458555f, -0.17983337f, 
    0.25173238f, -0.11834235f, -0.09967218f, 0.07519890f, -0.09684082f, -0.05739033f, 0.23466524f, 0.20840852f, 
    0.46919724f, -0.20304100f, -0.12817550f, -0.10881498f, 0.12612593f, 0.09517813f, -0.00843026f, -0.29006690f, 
    0.19070102f, -0.01264755f, 0.25628620f, -0.15130101f, -0.19370827f, 0.07527448f, 0.06088176f, 0.06823755f, 
    -0.18202956f, 0.19097140f, -0.01476676f, -0.09832925f, -0.18069774f, -0.05271465f, 0.09109435f, -0.06628753f, 
    -0.05589318f, 0.23768094f, -0.69913054f, -0.33086866f, 0.27233750f, -0.22054450f, -0.25869739f, 0.17002684f, 
    0.19849606f, 0.14210142f, 0.25842047f, 0.02347400f, 0.05110142f, 0.10197438f, -0.00587317f, 0.09384308f, 
    -0.01573569f, -0.03934886f, -0.36219725f, -0.71359193f, -0.19074227f, -0.82682097f, -0.33397952f, -0.74670005f, 
    0.09845076f, 0.00989925f, 0.18464638f, 0.00695347f, 0.32982013f, 0.25817606f, 0.08074751f, 0.11172779f, 
    -0.15632841f, 0.01615449f, 0.18923794f, 0.25583774f, -0.07323017f, -0.04564846f, -0.01006031f, 0.03613732f, 
    0.12127984f, -0.01471172f, 0.08682926f, -0.02199754f, 0.03058155f, -0.02873863f, 0.22740795f, 0.01987577f, 
    0.04385270f, 0.00459259f, -0.05209113f, 0.06731630f, 0.15196148f, -0.12123425f, -0.20126697f, 0.13600881f, 
    0.26056713f, 0.13729358f, 0.05015843f, -0.21216731f, 0.08644269f, -0.09517836f, -0.46325064f, 0.00327558f, 
    -0.30775619f, -0.12692001f, 0.02480472f, 0.06169825f, -0.12053047f, 0.08770213f, 0.06298032f, -0.01614681f, 
    -0.10428355f, -0.29254559f, -0.08406556f, 0.09271772f, 0.03131258f, 0.05838965f, -0.04331170f, 0.10646046f, 
    0.08677675f, 0.02127884f, -0.27397984f, -0.11680390f, 0.15822256f, 0.12853484f, 0.03782545f, -0.05597028f, 
    0.02343992f, 0.00413178f, -0.02492678f, -0.20455194f, 0.20460829f, 0.37296551f, 0.11279754f, -0.00732475f, 
    -0.12490026f, 0.17507637f, 0.01366272f, -0.12311315f, -0.14954215f, 0.13170488f, -0.06233374f, 0.01180696f, 
    -0.09106598f, -0.04452359f, -0.07777545f, 0.06387221f, 0.12143956f, -0.16870911f, -0.14803489f, 0.30937800f, 
    0.08922424f, 0.20037216f, 0.03127179f, 0.17807293f, -0.00019940f, 0.00499646f, -0.02801043f, -0.04634508f, 
    0.15888542f, -0.26853460f, 0.26926953f, -0.11797006f, -0.01006387f, -0.02717389f, 0.13628492f, -0.17178689f, 
    0.24379711f, 0.15530287f, -0.13594815f, 0.07071874f, 0.00094262f, -0.03291395f, 0.09123035f, 0.02022332f, 
    0.02834798f, -0.03262252f, 0.05138640f, 0.09210279f, 0.04597382f, 0.06656142f, 0.09465784f, 0.09847200f, 
    -0.11251720f, -0.00223992f, 0.11713348f, 0.15127872f, 0.05372987f, -0.04811414f, 0.05699993f, -0.05263428f, 
    -0.07159066f, -0.02701983f, -0.14269182f, 0.08299826f, 0.08709245f, -0.03097883f, 0.09546836f, -0.09344537f, 
    -0.00687576f, -0.29472572f, -0.01752836f, 0.00274721f, -0.23545994f, -0.08145273f, -0.09545130f, 0.01589008f, 
    -0.07180832f, 0.19397172f, -0.01927784f, 0.03335170f, -0.10871275f, -0.10320717f, -0.12498996f, 0.07342433f, 
    0.05069351f, 0.06260948f, -0.13112487f, 0.35720581f, 0.21758766f, 0.01248348f, 0.06866825f, 0.00724673f, 
    -0.02240869f, 0.04851867f, 0.09728324f, 0.04046243f, 0.31699201f, 0.01871984f, -0.22734509f, 0.07590331f, 
    0.14649820f, 0.05482793f, 0.03510634f, -0.03589914f, -0.03612056f, 0.06365807f, 0.03895010f, -0.10582462f, 
    -0.03038018f, 0.18190852f, 0.03622514f, 0.03537411f, -0.10578880f, 0.00583598f, -0.05488991f, 0.07127225f, 
    0.02523476f, 0.02029011f, 0.00914105f, -0.29206792f, -0.20574640f, -0.28268179f, 0.13386327f, 0.12637942f, 
    0.03299425f, -0.14956568f, -0.11687326f, 0.07726818f, 0.11160649f, 0.12665643f, 0.13658425f, 0.01244708f, 
    -0.04230101f, 0.08299964f, -0.20535845f, -0.25972137f, 0.24677667f, 0.02247905f, 0.04143447f, 0.22365449f, 
    -0.09498451f, 0.00748410f, -0.03407044f, -0.05794821f, 0.31684795f, -0.15167536f, 0.16817036f, -0.03793165f, 
    -0.05670436f, -0.15379819f, 0.05941096f, 0.02318318f, -0.22350661f, 0.13625444f, -0.32187814f, 0.08734160f, 
    -0.12670618f, -0.10996607f, -0.19064525f, 0.00564673f, 0.14898141f, -0.25590855f, -0.12765305f, 0.02857479f, 
    -0.07124808f, 0.06025664f, 0.08027842f, -0.03261034f, 0.06755283f, -0.05916753f, -0.76273853f, 0.37579662f, 
    0.03975867f, 0.21538270f, -0.10364445f, -0.16710792f, -0.04892235f, -0.05077656f, -0.08929431f, 0.10603062f, 
    -0.28434530f, 0.20092134f, -0.10835555f, 0.00562322f, -0.09029279f, 0.04896621f, 0.09267174f, -0.09731172f, 
    0.08650552f, 0.03690637f, -0.00084346f, -0.22979857f, -0.06926232f, -0.01314417f, -0.00971114f, -0.13654068f, 
    0.11845671f, -0.46647719f, 0.32098150f, 0.73488730f, -0.12098999f, 0.07385589f, -0.01618413f, 0.14901260f, 
    -0.11693230f, -0.03640820f, 0.04648941f, 0.06206034f, -0.04413388f, -0.13772571f, 0.15841624f, -0.06891632f, 
    0.00340663f, 0.21911621f, -0.26212668f, -0.21132176f, 0.10446779f, 0.41377062f, 0.15109251f, 0.07823527f, 
    0.10995168f, -0.19232586f, 0.25728455f, -0.07699287f, -0.09783810f, -0.41740578f, 0.17403112f, 0.00899257f, 
    -0.11813402f, 0.14049302f, -0.21621351f, -0.03797574f, 0.05932882f, -0.05740805f, -0.01207113f, -0.07924308f, 
    0.07139191f, 0.13061228f, 0.00934201f, -0.04510777f, 0.10328261f, 0.06775095f, 0.07048938f, -0.09149069f, 
    0.01654143f, -0.02279019f, 0.10809998f, -0.03314655f, 0.15202245f, -0.10942517f, -0.04200071f, 0.02650168f, 
    0.07331781f, 0.02011207f, -0.19467708f, 0.07159797f, 0.07447227f, 0.02962128f, 0.12594737f, -0.12831151f, 
    0.00099731f, -0.10830208f, -0.02925814f, 0.02747895f, -0.00423753f, 0.03402592f, 0.18307647f, 0.27472481f, 
    -0.07655296f, 0.03704428f, -0.14356628f, -0.08792499f, 0.00573421f, 0.00903512f, 0.02987654f, 0.08390816f, 
    0.14253978f, -0.17638551f, -0.12887889f, -0.08296643f, -0.12837569f, 0.03245392f, 0.08962133f, 0.09882274f, 
    0.13156465f, 0.14601292f, -0.11741044f, 0.35130054f, 0.13541879f, 0.10409653f, 0.16253409f, 0.11727706f, 
    0.03131486f, 0.05432300f, 0.08938700f, -0.11732049f, -0.21222137f, -0.25319517f, 0.02406058f, 0.07921966f, 
    0.04875934f, -0.04892119f, -0.09965516f, -0.16237497f, -0.08080428f, 0.05878309f, 0.01410500f, -0.21875410f, 
    0.18519279f, 0.14344113f, -0.00610832f, -0.02495874f, 0.05851472f, 0.09395128f, 0.08099555f, 0.15398648f, 
    0.01709630f, -0.02392018f, -0.19344634f, 0.11192352f, 0.11137640f, 0.16326839f, -0.13210170f, 0.42684168f, 
    0.14235680f, -0.41626263f, -0.23001449f, 0.23621835f, 0.10737652f, 0.04153677f, 0.13850108f, 0.04544769f, 
    0.00013261f, 0.13164619f, 0.11716214f, 0.15236154f, -0.09887408f, -0.15697721f, -0.06163456f, -0.16482310f, 
    -0.04390116f, 0.04154849f, -0.03094846f, -0.05492755f, 0.20793548f, 0.14696991f, -0.18992414f, -0.01163225f, 
    -0.17112611f, -0.28032467f, -0.03364984f, -0.16642082f, -0.14410771f, 0.08063553f, 0.12166165f, 0.20247327f, 
    0.06341910f, 0.28931525f, 0.24840777f, 0.10313940f, -0.11395091f, -0.24575923f, 0.19996209f, 0.16331823f, 
    0.07775377f, -0.21141475f, -0.24237268f, -0.08621801f, 0.08889531f, 0.06952689f, 0.22300711f, 0.10808407f, 
    0.07137106f, 0.08203823f, -0.48173574f, -0.43839422f, -0.12561528f, 0.04935481f, -0.01332666f, 0.08018915f, 
    0.10661120f, 0.05300795f, 0.07131070f, -0.25813946f, -0.22482778f, -0.32541236f, 0.05713038f, 0.00773648f, 
    -0.10535499f, -0.01499038f, 0.03965649f, -0.13295075f, 0.17710933f, -0.00013608f, -0.11973289f, -0.08049461f, 
    0.09061144f, -0.06280906f, -0.03377731f, 0.09816479f, 0.10427044f, -0.26124462f, -0.22103778f, -0.08743596f, 
    0.08335208f, 0.05112663f, -0.30957076f, 0.23922853f, -0.06993359f, -0.01948768f, -0.10397517f, -0.15611735f, 
    -0.18868959f, 0.16704750f, 0.13996430f, -0.12603132f, 0.02713312f, 0.11900420f, -0.09684283f, 0.00585141f, 
    0.05534661f, -0.03222290f, -0.53015000f, 0.42348632f, 0.24419533f, -0.23997724f, -0.19858444f, -0.03324299f, 
    -0.01425131f, 0.26948676f, 0.33012238f, 0.20477383f, 0.02492188f, 0.04851656f, -0.15270071f, 0.00176296f, 
    -0.19281189f, 0.04368049f, -0.07444787f, -0.13333420f, 0.23776811f, 0.17840427f, 0.22724138f, 0.12366213f, 
    0.16497174f, 0.13947357f, -0.39081565f, -0.06253179f, 0.00083016f, 0.06258398f, 0.30300894f, -0.02038057f, 
    0.25149399f, 0.20757440f, 0.08575576f, -0.08761506f, -0.08760726f, -0.04755893f, 0.41489804f, -0.02460130f, 
    -0.48734206f, 0.20169176f, 0.19627918f, 0.08037080f, -0.01244597f, 0.06747805f, -0.20942377f, 0.10892268f, 
    0.19721082f, 0.35017288f, 0.01324023f, 0.15010913f, 0.13524836f, 0.03688896f, -0.03584645f, 0.10782524f, 
    0.08994853f, 0.18667507f, 0.02860780f, -0.04168475f, -0.12224826f, 0.14984581f, -0.05688526f, 0.02231138f, 
    -0.06844505f, -0.07338765f, 0.12112347f, -0.26953080f, 0.09335339f, -0.12190281f, 0.05329652f, 0.21689197f, 
    0.31890967f, -0.01558778f, 0.05882153f, -0.00491392f, 0.10151730f, 0.11900648f, 0.17682345f, 0.05127825f, 
    0.00704885f, -0.39466140f, -0.24550676f, 0.40044421f, -0.28370571f, 0.11601263f, -0.00241773f, 0.04045141f, 
    -0.26127201f, 0.11027820f, 0.17227334f, 0.09382656f, -0.35865834f, 0.23818526f, 0.04955919f, -0.03301688f, 
    0.10308974f, 0.28134996f, 0.16908537f, 0.08746631f, 0.15642023f, -0.05733861f, -0.05673653f, -0.01120071f, 
    -0.12014931f, 0.00315554f, -0.03658243f, 0.13293622f, -0.02372591f, -0.03363525f, 0.04992183f, -0.12128276f, 
    -0.06442739f, 0.19550066f, 0.18399674f, -0.11890657f, 0.03299504f, -0.18570779f, -0.21561791f, 0.17485172f, 
    0.15008631f, 0.11136394f, 0.35981259f, -0.00065446f, -0.43711641f, -0.12866335f, -0.38170210f, -0.12080657f, 
    0.52337939f, 0.16684936f, 0.17862049f, -0.07571389f, 0.01077414f, -0.13685350f, -0.10265251f, -0.12376694f, 
    0.13978168f, 0.35586026f, 0.21304394f, 0.06958124f, -0.04891285f, 0.02442008f, 0.03460902f, -0.07287871f, 
    0.01552804f, 0.08461562f, 0.40973875f, 0.16106938f, 0.12988122f, -0.05356824f, 0.00614209f, 0.00639321f, 
    0.05373646f, 0.07201174f, 0.04222992f, 0.25855246f, 0.14711064f, 0.39150938f, -0.08142891f, -0.26722121f, 
    0.05357287f, -0.01523271f, 0.20349178f, 0.03476802f, 0.20602728f, 0.05104676f, -0.00692415f, 0.05806017f, 
    0.08518658f, -0.07606828f, 0.07836557f, 0.05462746f, 0.07954890f, 0.05736796f, -0.18365483f, -0.25192922f, 
    -0.15929317f, -0.03198445f, 0.11413018f, 0.12147033f, -0.05691683f, -0.09406863f, 0.44221628f, 0.14557756f, 
    0.05283261f, -0.14347091f, -0.05631291f, -0.22762583f, 0.17152211f, 0.16189624f, 0.20605677f, -0.10965104f, 
    -0.49882188f, -0.30183595f, 0.06368666f, 0.13821910f, 0.11269493f, -0.04886357f, -0.06322984f, -0.08216217f, 
    -0.16967706f, -0.03811263f, -0.14172776f, 0.04579882f, 0.10877705f, 0.16986273f, 0.14539024f, -0.04520574f, 
    -0.00253385f, 0.12708163f, -0.03880683f, 0.08337781f, -0.02376868f, 0.14741251f, 0.18546787f, 0.00382640f, 
    0.21809301f, 0.00268589f, -0.10083043f, -0.20805356f, -0.02436001f, -0.09704958f, -0.00654988f, 0.01612138f, 
    0.00008016f, -0.27713934f, 0.13271774f, -0.31006435f, -0.22084370f, -0.29479235f, -0.05499896f, -0.18671271f, 
    -0.28078038f, 0.30372146f, 0.11471287f, -0.17959282f, -0.10817105f, 0.08504931f, -0.12180380f, -0.11449736f, 
    0.07181197f, 0.08605479f, 0.00653230f, 0.13548349f, 0.08687604f, 0.01057536f, 0.00488413f, 0.00270661f, 
    -0.16256598f, 0.09003993f, 0.00210768f, 0.00976023f, 0.27590182f, 0.03489334f, 0.57191366f, 0.18798605f, 
    0.16986741f, 0.06883366f, 0.09720767f, -0.02862984f, 0.01938196f, 0.09591176f, 0.08593743f, -0.24250263f, 
    0.00332642f, -0.04013021f, 0.07106552f, 0.06370834f, 0.06362857f, 0.24930209f, -0.03928502f, 0.02654028f, 
    -0.13635828f, -0.38721138f, -0.15364394f, -0.18047005f, -0.17065476f, -0.15353222f, -0.06582974f, -0.00283520f, 
    0.04288320f, 0.34090981f, -0.05727674f, -0.04681628f, -0.20347121f, -0.22839877f, 0.14698920f, 0.09112214f, 
    0.06676317f, 0.09030262f, -0.58835244f, -0.20463897f, -0.38447893f, -0.21977212f, 0.26703194f, -0.02162051f, 
    -0.14394267f, 0.05698749f, -0.04972320f, 0.56605780f, -0.34300131f, 0.03466053f, 0.23532112f, 0.19316293f, 
    -0.04270297f, 0.02889467f, 0.10943801f, 0.02200099f, -0.28923538f, -0.15292598f, -0.37912160f, -0.11579730f, 
    0.03731097f, -0.03063183f, 0.23154229f, -0.02049074f, 0.03543149f, 0.11286325f, 0.12817521f, -0.23882608f, 
    -0.15847242f, -0.04083209f, -0.14658746f, -0.02656637f, 0.05778150f, 0.10834520f, -0.28432965f, -0.29379037f, 
    -0.30301636f, -0.02696242f, 0.02865398f, 0.03983345f, -0.01029561f, -0.08365002f, 0.07503583f, 0.20865585f, 
    0.16936260f, 0.06901845f, -0.18072982f, -0.23298535f, -0.10401324f, -0.01646180f, 0.07502797f, 0.07757245f, 
    0.34073114f, -0.09665338f, 0.31247273f, 0.02515420f, -0.12555553f, -0.12520419f, 0.17572166f, 0.10385360f, 
    0.06215959f, 0.01668688f, -0.29802582f, -0.09730317f, -0.24063019f, -0.13310406f, 0.26813865f, 0.10573334f, 
    0.00968731f, 0.01612590f, -0.22761023f, -0.04133292f, -0.31875536f, 0.10560800f, -0.06200597f, -0.01356113f, 
    -0.01255907f, -0.16702119f, -0.09858777f, -0.27710485f, -0.55720496f, -0.77087975f, -0.23212321f, -0.09365702f, 
    -0.21887329f, 0.23233952f, 0.02605489f, -0.19840999f, -0.24014977f, -0.17912520f, -0.05912165f, -0.16269231f, 
    0.03784520f, -0.20143558f, -0.44982865f, -0.13547228f, 0.23946874f, 0.33607805f, 0.22573949f, 0.24415362f, 
    0.00681323f, 0.12914269f, 0.02265085f, 0.17335977f, 0.20096458f, 0.09638388f, -0.25187305f, -0.25666323f, 
    -0.15098143f, 0.00936590f, -0.08512193f, -0.02139131f, 0.08762252f, -0.19820078f, -0.02808741f, 0.00563361f, 
    -0.23472543f, -0.07174586f, -0.21215650f, -0.04852866f, -0.11622511f, -0.11564260f, 0.21693906f, 0.03247083f, 
    -0.20491047f, -0.02819201f, 0.13146147f, -0.18386330f, -0.02673517f, -0.15146419f, -0.09953732f, -0.08442905f, 
    -0.03351012f, -0.25433767f, -0.02735198f, 0.10603267f, -0.06959075f, -0.06935801f, -0.17222080f, 0.01439347f, 
    0.02816525f, -0.12502658f, -0.14895229f, -0.01267366f, 0.03175715f, -0.07868139f, -0.14351755f, -0.11719588f, 
    0.16258280f, 0.02817967f, -0.02820567f, -0.22665064f, -0.64986593f, 0.11630868f, 0.05770986f, 0.05898692f, 
    -0.17847018f, -0.03786006f, -0.06786255f, 0.09229839f, -0.05447012f, 0.22136678f, 0.00030780f, -0.09729206f, 
    -0.03176706f, 0.02521344f, -0.12752561f, -0.12817170f, 0.00824343f, -0.06309002f, -0.36380607f, 0.44942197f, 
    -0.16638848f, -0.07680303f, -0.09443485f, 0.06285053f, -0.00801104f, 0.06089168f, -0.19489881f, 0.05944237f, 
    -0.02588361f, -0.13456446f, 0.01752267f, 0.10882470f, -0.00668894f, 0.25838757f, -0.18285275f, -0.38729736f, 
    -0.05810041f, 0.00211433f, -0.06363732f, 0.14796783f, -0.36793295f, 0.09283933f, 0.11802523f, -0.01415016f, 
    0.00245290f, 0.07249261f, 0.02517483f, -0.13745764f, -0.10764226f, -0.09215130f, 0.22678126f, 0.06423607f, 
    0.05155312f, -0.47740349f, 0.11539278f, -0.02108894f, 0.10649712f, 0.14919309f, 0.02164746f, -0.05543182f, 
    -0.04671566f, 0.08764366f, -0.31183442f, 0.17604482f, 0.31804961f, 0.05027878f, -0.05784430f, -0.17556652f, 
    -0.00697004f, -0.19457577f, 0.03581665f, 0.63591379f, -0.08909784f, 0.17747772f, 0.12154043f, 0.09036439f, 
    0.18285763f, 0.11136240f, 0.15160725f, 0.04706687f, -0.11776628f, 0.01215675f, -0.05160191f, -0.23763187f, 
    -0.06455632f, -0.04097750f, 0.00103363f, -0.19848749f, -0.05564230f, -0.12023757f, -0.10344332f, -0.10589003f, 
    0.11406274f, 0.15895464f, 0.01983316f, -0.14144239f, 0.05943497f, 0.06656668f, -0.23325893f, -0.17584805f, 
    -0.15478693f, -0.09278131f, -0.02387912f, -0.07409080f, -0.12027133f, -0.09524337f, 0.01471384f, -0.32045764f, 
    0.03832407f, 0.00875007f, -0.26515755f, -0.05782235f, -0.01347285f, 0.02118143f, -0.10048656f, -0.18563507f, 
    0.25932825f, 0.56692743f, 0.18378502f, 0.14736786f, -0.10147232f, 0.00672436f, 0.06755885f, 0.16212358f, 
    -0.02809260f, 0.04450613f, -0.04916913f, 0.20603342f, 0.06170964f, -0.10265314f, 0.05054250f, 0.10448483f, 
    0.08965001f, 0.14373945f, -0.19317940f, 0.02403399f, 0.21411298f, -0.06955091f, -0.17845342f, 0.14053561f, 
    -0.15131864f, -0.14790535f, 0.26920122f, 0.00046485f, 0.14079235f, -0.23331028f, -0.07626353f, 0.18382239f, 
    0.02530677f, -0.15478654f, -0.04353436f, 0.13036372f, 0.01562885f, 0.56045300f, -0.09219840f, -0.05715450f, 
    -0.29203522f, -0.18886830f, 0.04181265f, -0.15525348f, -0.01579145f, -0.02269997f, 0.50707000f, 0.39178348f, 
    0.07974799f, 0.05192738f, 0.10574318f, 0.03674321f, -0.12946677f, 0.07386664f, -0.53647631f, 0.09013967f, 
    -0.14850721f, -0.10766185f, 0.08989861f, -0.35895154f, -0.16325898f, 0.04952109f, 0.02719138f, 0.18571141f, 
    -0.13499826f, 0.25555485f, 0.13583447f, -0.06349146f, 0.01204656f, 0.06222803f, 0.09048988f, 0.17349918f, 
    -0.01527616f, 0.01545143f, 0.47181180f, 0.15552314f, 0.06602325f, 0.02143966f, 0.11824667f, 0.10924795f, 
    0.04667552f, -0.23272406f, -0.12278219f, 0.36420602f, -0.30935797f, 0.07330881f, -0.15168627f, 0.16190796f, 
    0.03344847f, -0.08188538f, 0.11291730f, -0.06320956f, -0.14253236f, 0.06432507f, 0.35380936f, -0.13124630f, 
    0.12163956f, 0.10796431f, -0.00656643f, -0.03803208f, 0.39708877f, -0.04762230f, -0.16258332f, 0.26652184f, 
    0.10068963f, -0.03697407f, 0.29482388f, -0.05123058f, -0.15649791f, 0.16283603f, 0.02871376f, 0.09244382f, 
    -0.24555764f, 0.14672388f, -0.06797684f, 0.18607320f, 0.04954550f, -0.26186720f, -0.19888927f, -0.19204837f, 
    -0.09617025f, -0.12713878f, -0.18009119f, -0.02387249f, 0.09811293f, -0.03941958f, 0.38998422f, -0.20337950f, 
    0.06390427f, -0.08813821f, 0.17859733f, -0.07521544f, 0.12721191f, 0.18310466f, 0.06168270f, -0.27436185f, 
    0.28860930f, -0.00444585f, 0.15871912f, 0.08795983f, -0.03356173f, 0.00994746f, 0.04792392f, 0.05257066f, 
    0.29292476f, 0.09390131f, -0.07474776f, 0.07911164f, 0.01704264f, 0.11504133f, 0.15239573f, 0.00515175f, 
    -0.01198776f, 0.25761199f, 0.06047577f, -0.11838275f, 0.08509830f, 0.11386309f, 0.06164353f, -0.02710957f, 
    -0.04730426f, -0.02840228f, 0.38149261f, 0.04502446f, -0.05223771f, 0.13733488f, 0.02884875f, 0.13491352f, 
    0.00223746f, -0.11328053f, -0.11399472f, 0.16816503f, 0.03665679f, 0.09204488f, 0.08261860f, 0.06203808f, 
    -0.00862692f, 0.04483565f, 0.13672678f, 0.15447637f, 0.20934559f, 0.08615358f, -0.24632293f, 0.10466770f, 
    0.16834196f, -0.15307173f, 0.11920448f, 0.07989851f, 0.17563175f, -0.05086714f, -0.14954917f, 0.34541222f, 
    0.24819256f, -0.16506572f, 0.10170199f, -0.04421797f, 0.01243053f, 0.11086082f, 0.20873959f, -0.02575110f, 
    -0.16929764f, -0.01802347f, 0.02657830f, 0.05736085f, -0.06018983f, -0.06386264f, -0.09102735f, -0.38208106f, 
    -0.27080929f, 0.35614452f, 0.00126095f, 0.11260908f, -0.03260339f, 0.09907144f, -0.01496265f, 0.19993512f, 
    -0.03208729f, -0.10309748f, 0.12559904f, 0.05620436f, -0.01030792f, -0.05914808f, -0.24594118f, -0.22689766f, 
    -0.03459709f, -0.00243640f, 0.06826945f, -0.06205156f, -0.08957118f, -0.09663877f, -0.05630845f, -0.15055723f, 
    -0.28396937f, -0.32931548f, -0.30519190f, -0.17759296f, 0.05060608f, -0.05303879f, 0.20004010f, 0.10874452f, 
    -0.00711089f, 0.21190339f, 0.12184642f, 0.12748715f, -0.17162649f, -0.05843439f, 0.07907025f, 0.03872640f, 
    0.08220435f, 0.09371290f, -0.25457487f, 0.29005662f, 0.01758246f, 0.07251282f, 0.12893932f, 0.11756128f, 
    0.12965749f, 0.04673879f, -0.12490296f, 0.06086375f, 0.13307701f, 0.06320032f, 0.06860874f, 0.11770578f, 
    0.06709931f, -0.05790754f, 0.09245449f, -0.36106202f, -0.36561689f, -0.27455580f, 0.22682962f, -0.03294917f, 
    -0.34879386f, 0.09278452f, 0.01719655f, 0.05948121f, -0.01995372f, -0.01085598f, -0.00871862f, 0.01839517f, 
    -0.19160423f, -0.05199081f, 0.15123563f, 0.02696547f, -0.05244963f, -0.12318698f, -0.14082763f, 0.06628750f, 
    -0.13077198f, -0.13344266f, 0.02271249f, -0.01030297f, -0.16966769f, -0.00421015f, -0.09968831f, -0.00056052f, 
    -0.10995618f, -0.00665437f, 0.18609650f, 0.31671229f, 0.15960245f, 0.05980266f, 0.15471172f, -0.07188974f, 
    -0.02831170f, -0.00532076f, -0.13480793f, 0.14462610f, 0.10138141f, 0.02842133f, 0.12350851f, 0.06784684f, 
    0.02844850f, 0.20973511f, -0.02412765f, -0.12529920f, 0.23044401f, -0.37930954f, -0.14864504f, 0.02426475f, 
    -0.07021549f, -0.05196308f, -0.03868582f, -0.08696418f, -0.08484721f, -0.17393777f, 0.03153604f, -0.08077359f, 
    0.18720728f, 0.04097083f, -0.15366733f, 0.14745839f, 0.06146228f, 0.17806071f, 0.25063273f, 0.22972149f, 
    0.42143938f, 0.10810267f, 0.20749412f, -0.11078757f, -0.06716980f, -0.03350756f, -0.47441301f, -0.46743676f, 
    0.10913928f, 0.04558690f, 0.19501686f, -0.12952448f, -0.02411699f, -0.02722405f, 0.04391691f, 0.30577666f, 
    0.44732788f, 0.26043224f, 0.19114682f, -0.03714827f, 0.05249527f, 0.09088473f, 0.01746165f, 0.02321103f, 
    0.21002381f, -0.02273655f, -0.05218730f, -0.04405651f, -0.09028704f, -0.17836446f, -0.00830816f, 0.07109879f, 
    0.04631189f, 0.25558746f, -0.52789730f, -0.11890695f, 0.18659957f, -0.16738802f, -0.08185069f, 0.18464227f, 
    -0.21306124f, 0.06716239f, 0.01151988f, -0.09570800f, -0.02970942f, 0.13203350f, 0.13131899f, 0.04108649f, 
    -0.09570722f, -0.19603881f, -0.14334093f, 0.35949549f, 0.29786819f, -0.32549316f, 0.19199722f, 0.15307939f, 
    0.21630286f, 0.22892851f, -0.05979171f, -0.04737851f, -0.14100756f, 0.27522320f, -0.09229031f, 0.08109587f, 
    0.08673336f, 0.00954605f, 0.22615404f, 0.03474206f, 0.26377416f, 0.18922269f, -0.15489945f, -0.14748733f, 
    0.11636163f, 0.07678393f, 0.18341000f, -0.05061119f, -0.22121054f, -0.13644782f, 0.04505636f, -0.35662302f, 
    -0.04272746f, 0.33748844f, -0.03173118f, -0.08663064f, 0.20446502f, -0.00017729f, 0.11952212f, -0.11866160f, 
    0.03140143f, 0.05344545f, -0.18972659f, -0.03678005f, -0.21495888f, -0.27447069f, -0.34860593f, -0.32899007f, 
    -0.09887029f, -0.10034827f, -0.06698684f, -0.02933549f, -0.15938100f, 0.16159531f, -0.01298250f, 0.01711668f, 
    -0.12520494f, -0.14370659f, -0.11156534f, -0.02310325f, -0.12497095f, -0.10485838f, 0.11945725f, -0.06848324f, 
    0.01014738f, -0.09055830f, -0.17111351f, -0.06592960f, -0.02579052f, -0.02046248f, -0.01395262f, 0.03552200f, 
    -0.18374282f, -0.00285982f, -0.10610227f, -0.05086084f, 0.17306054f, 0.01810421f, 0.06158238f, 0.02136067f, 
    0.07676741f, -0.35848209f, -0.05407352f, -0.47849506f, -0.02650174f, -0.04872491f, 0.08258427f, 0.11371487f, 
    -0.34363112f, 0.32569966f, -0.24553560f, -0.05531589f, 0.02664262f, 0.20536447f, 0.21474314f, -0.02366454f, 
    0.03960834f, 0.00822146f, -0.00001717f, 0.07634006f, 0.12544639f, 0.11385917f, -0.68400484f, -0.09586327f, 
    -0.04422244f, 0.00864228f, 0.09221367f, 0.11487743f, -0.06298436f, 0.05365559f, 0.01291828f, 0.38276628f, 
    0.45298681f, 0.02717989f, 0.12385024f, -0.02923824f, 0.05438284f, -0.09061282f, -0.18268010f, 0.17446427f, 
    0.06572637f, 0.05588352f, 0.12155182f, -0.01908207f, -0.03656812f, -0.10031606f, -0.03452741f, 0.11358880f, 
    0.04979365f, -0.22313301f, 0.00374140f, 0.00737462f, -0.20049237f, -0.08399860f, -0.05646135f, -0.02764498f, 
    0.02805358f, 0.10765741f, 0.27631575f, 0.28460962f, -0.13997623f, -0.01003902f, 0.08264179f, -0.13071130f, 
    -0.16513160f, -0.13406724f, -0.12413310f, 0.44357798f, 0.11070238f, 0.13437502f, 0.02354372f, -0.04786747f, 
    0.15166649f, 0.01343882f, 0.04379825f, 0.04885560f, 0.09181067f, -0.11237438f, 0.10704702f, 0.03693407f, 
    -0.15258540f, -0.18176499f, -0.15766475f, -0.07446837f, -0.01436910f, -0.08980484f, 0.00492812f, -0.03395884f, 
    -0.00433205f, 0.10734128f, -0.20636778f, -0.11120904f, 0.02073004f, 0.03714798f, -0.16537462f, -0.07540134f, 
    0.08546571f, -0.01337077f, -0.06452071f, 0.09363873f, 0.01134881f, 0.15936027f, 0.00502340f, 0.05468436f, 
    -0.06987037f, 0.06016320f, 0.01607785f, 0.14895873f, 0.04426421f, -0.14380379f, -0.02092023f, 0.09396971f, 
    0.35315183f, 0.13387387f, 0.22699450f, 0.07904928f, 0.16878508f, 0.05071291f, 0.14998177f, -0.04313075f, 
    0.11653976f, 0.07189072f, 0.21054661f, 0.05444104f, 0.03085587f, 0.16211985f, 0.05272906f, 0.01153638f, 
    0.05023386f, -0.11892310f, 0.18261871f, 0.26660147f, -0.10848203f, -0.12136477f, 0.11205121f, -0.14318901f, 
    0.02414136f, -0.20369865f, 0.08489497f, 0.10514352f, 0.07048080f, 0.47139776f, -0.09625894f, -0.08661902f, 
    -0.09030484f, 0.03367927f, 0.08918872f, 0.02661331f, 0.13442864f, -0.03164452f, 0.16948789f, -0.21212918f, 
    -0.03278842f, -0.01347221f, -0.11278185f, -0.02668087f, -0.02630769f, 0.25424686f, 0.06893048f, -0.02429676f, 
    0.11596324f, -0.01403929f, 0.10857184f, 0.16204745f, 0.07150669f, -0.27923682f, 0.10084581f, 0.14108014f, 
    -0.02178781f, 0.09056272f, 0.28040636f, 0.06373671f, -0.34623754f, -0.42818612f, -0.32509077f, -0.08531825f, 
    0.14481837f, 0.12258253f, 0.08291300f, 0.10633699f, 0.10570040f, 0.12638612f, -0.15195879f, -0.41018638f, 
    0.09723857f, 0.27215651f, -0.08331513f, 0.01310276f, 0.10236069f, 0.07978887f, -0.07475597f, -0.04213722f, 
    -0.03276797f, -0.06217709f, 0.19337030f, 0.48823142f, 0.01974278f, -0.02781826f, 0.15043858f, -0.23579225f, 
    0.26495734f, 0.18979976f, 0.13114166f, 0.07103291f, 0.10359098f, -0.28496155f, -0.34547341f, -0.02439975f, 
    -0.09664232f, 0.13757129f, 0.04233982f, -0.08926567f, 0.14589456f, 0.33053252f, -0.06538888f, 0.26015738f, 
    0.04302111f, -0.24000485f, -0.41203246f, 0.28888065f, 0.04678340f, -0.05671226f, -0.02651866f, -0.05821226f, 
    0.23064522f, -0.06936464f, -0.25100714f, -0.32740793f, -0.03890360f, -0.13157965f, -0.12834069f, 0.02334266f, 
    -0.11153299f, 0.17012036f, 0.02149689f, -0.08005057f, 0.09029165f, 0.09458855f, 0.36866769f, 0.13970104f, 
    0.20221713f, -0.02340625f, -0.17533344f, 0.03626698f, -0.03916629f, 0.05789230f, 0.06787048f, -0.17141138f, 
    0.16292928f, -0.11693142f, -0.16757317f, 0.20001803f, 0.02859960f, 0.04843822f, 0.06461526f, 0.12312823f, 
    -0.14859131f, -0.05442879f, -0.10870412f, 0.08014895f, 0.02637467f, -0.00118356f, -0.04901088f, -0.20575935f, 
    0.05507880f, -0.03906462f, 0.01851032f, 0.06663873f, 0.08563849f, 0.04808304f, -0.09235340f, -0.13692811f, 
    0.10795915f, 0.12070251f, 0.02144029f, 0.02143927f, 0.03126879f, -0.08929563f, -0.04844518f, -0.08429980f, 
    -0.00621866f, -0.03134067f, 0.08001731f, 0.14153831f, 0.27186280f, -0.10262021f, -0.11128542f, 0.00749227f, 
    -0.00443535f, -0.03430961f, -0.10919469f, 0.22804356f, 0.03357950f, 0.22548489f, -0.00661028f, 0.08227104f, 
    -0.02995580f, 0.25520378f, 0.14396994f, -0.00597821f, -0.00862921f, -0.20794600f, -0.12278125f, -0.23816097f, 
    0.06233819f, 0.16745830f, -0.07038378f, 0.03725221f, -0.10068286f, -0.13521728f, -0.28046727f, -0.00451542f, 
    0.14371631f, -0.00548046f, 0.03183533f, 0.05521396f, -0.32969812f, -0.19159617f, 0.26409882f, -0.08719026f, 
    0.29297444f, -0.04786203f, 0.10346904f, 0.14274336f, 0.05995002f, -0.03581468f, 0.06861237f, -0.13750276f, 
    -0.04816119f, 0.10582659f, 0.10341804f, -0.17431331f, 0.01383137f, 0.00149827f, -0.03498382f, -0.08210385f, 
    -0.04208728f, 0.21881962f, 0.07055388f, 0.17834143f, -0.21103367f, 0.09274940f, 0.07142926f, -0.12943508f, 
    -0.13640304f, 0.05563404f, -0.10455132f, -0.02870202f, -0.00110050f, 0.06520126f, 0.04943738f, -0.12954392f, 
    0.12872924f, 0.18480229f, 0.14062895f, -0.23800837f, 0.12906356f, -0.11002780f, -0.14421271f, -0.02223604f, 
    0.26750973f, 0.03826780f, 0.00994489f, -0.20361839f, -0.14825843f, -0.11139577f, 0.03516706f, 0.08389442f, 
    0.07243832f, 0.04543961f, 0.05604872f, 0.03003721f, -0.04181134f, 0.00199685f, -0.06887541f, -0.11373366f, 
    -0.15540339f, -0.07925709f, -0.02866982f, -0.14414833f, -0.23043628f, 0.04351727f, -0.06394672f, -0.02700308f, 
    0.11756278f, -0.08762342f, 0.01661329f, 0.11337689f, -0.13704363f, -0.16920032f, 0.10163561f, -0.09436958f, 
    0.18292205f, -0.01140403f, -0.10163663f, -0.05042269f, -0.01422998f, 0.08150709f, 0.20895030f, -0.16382791f, 
    0.23901913f, 0.04708103f, -0.36802754f, -0.33503050f, 0.04470389f, -0.03873580f, 0.05495477f, -0.05055483f, 
    -0.22877803f, -0.00543499f, -0.06655662f, -0.35879752f, 0.05985534f, 0.11240499f, -0.10648762f, -0.04077913f, 
    0.03597128f, 0.10958030f, 0.15368028f, 0.12148190f, 0.25705621f, 0.05471689f, 0.06606801f, 0.17544986f, 
    0.10363159f, -0.12606651f, 0.04882709f, -0.20919329f, 0.25523347f, 0.22446071f, -0.18579465f, 0.14282680f, 
    0.14472444f, 0.08557124f, 0.06196323f, 0.19884498f, -0.08441827f, -0.06937302f, -0.08168228f, -0.07405262f, 
    -0.05954459f, -0.02923413f, 0.11138115f, -0.03406628f, -0.11771449f, -0.18157125f, -0.40351284f, -0.31896779f, 
    -0.00908653f, -0.00072291f, -0.16830115f, -0.02895181f, -0.15514594f, 0.01221866f, -0.06641455f, 0.11865420f, 
    0.02734795f, -0.06959450f, 0.04318665f, -0.08137392f, 0.13034508f, 0.17684962f, -0.10911053f, 0.00380569f, 
    -0.14762741f, -0.43887287f, 0.07393686f, 0.03078534f, -0.01639608f, -0.10559933f, -0.01822666f, -0.04407778f, 
    -0.04153050f, -0.07042185f, -0.19252947f, 0.10140880f, 0.14544903f, 0.14381059f, -0.09087928f, 0.03725946f, 
    0.06291594f, -0.35051489f, 0.35579723f, -0.20939089f, 0.04187676f, -0.16628398f, -0.09114161f, -0.11747222f, 
    0.11588556f, -0.08875036f, -0.21303095f, 0.20043902f, -0.11503438f, 0.01751991f, -0.10998268f, 0.27280146f, 
    -0.17995721f, 0.12157687f, 0.05196456f, 0.13486943f, 0.38606244f, -0.22977586f, 0.05870917f, -0.18864103f, 
    -0.21258247f, 0.17090690f, 0.47053719f, 0.07795884f, -0.03442985f, -0.05115150f, 0.04810202f, 0.01933119f, 
    0.10877569f, 0.09900989f, 0.10265624f, 0.15612368f, 0.05658186f, -0.10622966f, -0.03521906f, -0.01263904f, 
    0.00993142f, -0.00820349f, 0.00775511f, 0.03542156f, 0.03737381f, 0.11544246f, -0.22670622f, 0.33847585f, 
    -0.12373500f, 0.07179866f, -0.12061347f, 0.29552525f, -0.00321499f, 0.06177720f, -0.06732798f, 0.33400935f, 
    -0.01231350f, -0.16643299f, -0.37634560f, -0.02511840f, 0.08272986f, -0.09371591f, -0.11373475f, 0.08143882f, 
    0.01945757f, 0.00727664f, -0.02592028f, -0.09060912f, -0.00029251f, 0.02619272f, -0.00596940f, -0.01637089f, 
    0.03285581f, 0.00152113f, -0.06659388f, -0.02357544f, -0.08261410f, -0.02961185f, -0.00498968f, 0.01015289f, 
    -0.03347507f, 0.02160803f, -0.01025448f, 0.02104637f, -0.05366027f, -0.03380906f, -0.00909154f, -0.04756843f, 
    -0.01563836f, -0.01369213f, 0.00312447f, 0.03610243f, -0.07378073f, -0.01582101f, -0.05752400f, -0.04977636f, 
    -0.03993629f, -0.01872301f, 0.02000241f, -0.01436053f, -0.01251611f, 0.02862338f, 0.01273858f, 0.00634166f, 
    0.04045760f, -0.05737319f, -0.03026400f, -0.00674872f, 0.02854851f, -0.05593094f, 0.01847348f, -0.08385532f, 
    0.04078682f, -0.02598160f, -0.05293053f, -0.03179975f, 0.02648829f, -0.00684118f, -0.04674707f, -0.08434565f, 
    -0.02760936f, -0.03961948f, -0.06418798f, -0.03511814f, -0.00511829f, 0.03805923f, -0.00493129f, -0.00102464f, 
    -0.04428962f, 0.01382742f, -0.04525716f, -0.01337706f, -0.08041991f, 0.01393777f, -0.06539050f, -0.06905209f, 
    -0.01231069f, -0.04640485f, -0.07333215f, -0.02932151f, -0.03696304f, -0.06143168f, -0.00514726f, 0.00468501f, 
    0.03798668f, -0.01733698f, -0.05087661f, -0.03707946f, -0.01356103f, 0.01478103f, 0.02560445f, 0.01228998f, 
    -0.05201873f, -0.00788930f, -0.01678038f, -0.02537118f, -0.06647458f, -0.06346373f, 0.02518651f, -0.06257415f, 
    -0.08465911f, -0.02326163f, -0.02037742f, 0.03741350f, -0.02882390f, -0.04020261f, 0.01661489f, -0.03080356f, 
    -0.06677016f, -0.07684706f, 0.04133011f, -0.04482972f, -0.08072229f, -0.01707677f, -0.08573519f, -0.08845399f, 
    0.00137010f, 0.04108514f, 0.04458613f, -0.00753226f, 0.03550905f, -0.00172532f, -0.03262186f, -0.06116762f, 
    -0.05027687f, -0.02697920f, -0.03189059f, 0.06397168f, 0.08178358f, 0.06445704f, 0.02780456f, 0.01740107f, 
    0.02815194f, -0.06303065f, -0.05051115f, -0.00707867f, 0.01245216f, 0.00802870f, 0.00118083f, -0.06052749f, 
    -0.04556364f, -0.07615712f, -0.03081648f, 0.00161169f, -0.01385035f, -0.06697591f, -0.03345894f, -0.06300633f, 
    -0.02620822f, -0.07831771f, -0.04821420f, 0.00492857f, -0.04928295f, 0.00200832f, -0.01850992f, -0.00274359f, 
    -0.00316042f, 0.03160683f, -0.00771866f, -0.02762762f, -0.04360262f, -0.02600889f, -0.00451859f, -0.05196363f, 
    -0.00817575f, -0.06178603f, 0.00389537f, -0.00799144f, -0.00938411f, -0.05071329f, 0.00016908f, 0.00346206f, 
    0.03788823f, 0.00835294f, -0.01749145f, -0.06623130f, 0.01851059f, -0.03711209f, -0.05216568f, 0.05113142f, 
    0.02346785f, -0.03393646f, 0.00772105f, 0.05363900f, -0.07337498f, -0.01134064f, -0.06210088f, -0.04757917f, 
    0.03250852f, 0.06068165f, -0.06524288f, -0.06234025f, -0.07164077f, -0.01092397f, 0.05069099f, 0.01301313f, 
    0.02663209f, 0.01048498f, 0.03602879f, 0.03332921f, -0.06102863f, -0.03715466f, -0.02833069f, -0.06880151f, 
    0.00668755f, 0.00053897f, 0.00739410f, -0.08243684f, -0.08442897f, -0.01923788f, -0.05422757f, -0.02770084f, 
    -0.00317175f, 0.01802433f, -0.01946216f, 0.02950970f, -0.05768574f, 0.03339520f, 0.02687386f, -0.05395849f, 
    -0.05715659f, -0.06936655f, 0.01545583f, -0.05976512f, -0.05119496f, 0.01843541f, -0.09086698f, -0.05789105f, 
    -0.08263374f, -0.01063354f, 0.00359235f, 0.01046555f, -0.05940641f, -0.00103949f, -0.01697114f, 0.01481632f, 
    0.00020927f, -0.04279731f, -0.03865613f, -0.02849720f, -0.04722179f, -0.05774632f, 0.00429513f, -0.07890489f, 
    0.00976417f, -0.03217849f, -0.00203489f, -0.09042153f, -0.07688366f, -0.01391582f, -0.03131637f, -0.03099724f, 
    -0.01896198f, 0.04451531f, -0.06819497f, -0.02887065f, -0.09134706f, -0.06853395f, 0.05076895f, -0.02040564f, 
    -0.00567611f, 0.03268773f, 0.00931148f, -0.06219590f, -0.09365910f, -0.01507489f, -0.04316846f, -0.08413506f, 
    -0.07379344f, -0.07546051f, -0.06627989f, 0.01728017f, -0.02127522f, -0.00546942f, -0.01863359f, -0.08208460f, 
    -0.04708594f, 0.01326970f, -0.01394491f, 0.01990615f, -0.02249379f, 0.04775085f, -0.03360476f, -0.06258007f, 
    -0.00987503f, 0.02388036f, -0.00668289f, -0.05868453f, -0.02907224f, 0.04912553f, 0.01097902f, -0.00976975f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.16762185f, 0.23700997f, 0.01192522f, 0.01376561f, 0.13855007f, 0.00074888f, -0.01915691f, -0.04306462f, 
    0.27071485f, 0.51293224f, 0.10946515f, -0.11325838f, 0.07134383f, 0.13244854f, 0.16034585f, 0.07604536f, 
    0.31473699f, -0.21159878f, 0.20433192f, 0.08118570f, 0.06273945f, 0.09412765f, 0.35118273f, 0.04479524f, 
    0.01733363f, -0.27074555f, 0.20155968f, 0.05109880f, 0.05726619f, 0.08922596f, 0.07588547f, -0.06700784f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21443370f, -0.28847104f, -0.18703602f, 0.09244992f, -0.66348070f, -0.12674107f, 0.16862871f, 0.13930796f, 
    -0.00336707f, -1.06589401f, 0.17317933f, 0.22563672f, 0.45089141f, 0.35398495f, 0.28678155f, -0.80867565f, 
    -0.47539753f, 0.58838856f, -0.60822785f, -0.01791808f, 0.32620960f, -0.03716689f, -0.10879625f, 0.10309646f, 
    -0.11199202f, 0.19932678f, -0.28881490f, -0.32697833f, -0.13133006f, 0.14785765f, 0.13628428f, -0.08048682f, 
    -0.00092930f, 0.50697881f, -0.33235613f, 0.03966867f, -0.31613386f, -0.06700230f, -0.03953876f, -0.09455088f, 
    -0.34531823f, 0.01338210f, 0.27764854f, -0.01352875f, -0.21593273f, 0.33685222f, 0.23292339f, -0.59573293f, 
    -0.16914815f, 0.46979976f, 0.63307166f, 0.28336474f, 0.13475499f, 0.27287760f, -0.03369780f, 0.04539369f, 
    -0.11996774f, -0.36589211f, -0.12370681f, -0.17764732f, -0.11909171f, 0.08495910f, 0.14996386f, -0.05923397f, 
    -0.05707410f, 0.22538619f, -0.22394781f, 0.13953856f, -0.09376920f, -0.13129190f, 0.07494913f, -0.01031322f, 
    0.43895328f, 0.36218539f, -0.05218360f, 0.28590754f, -0.96537489f, -0.76666665f, 0.32454798f, 0.19086567f, 
    -0.00748851f, -0.44991556f, 0.63483095f, -0.49594659f, -0.39414036f, -0.17043161f, -0.18202804f, 0.21415070f, 
    0.00857211f, 0.14993957f, -0.40324956f, -0.14546092f, 0.08585097f, 0.05881473f, 0.04564535f, -0.00708610f, 
    -0.19984700f, 0.13560034f, 0.10773407f, -0.02394054f, 0.47063270f, 0.01875160f, 0.14969401f, 0.08989109f, 
    0.34786385f, -0.45653737f, -0.83113259f, -0.15656237f, 0.11982869f, 0.23487996f, -0.08162110f, 0.72895688f, 
    -0.06980007f, 0.05678248f, -0.21744905f, -0.61453199f, -0.40817043f, 0.57299715f, -1.06836021f, 0.34659004f, 
    -0.11906746f, 0.48274061f, -0.63722599f, -0.30509001f, -0.13336632f, 0.29820198f, -0.29372847f, -0.10629466f, 
    -0.14973551f, -0.33466673f, -0.34141400f, 0.15356417f, 0.31054652f, 0.04407265f, 0.15675063f, 0.07578965f, 
    -0.56199199f, -0.62877363f, -0.07075303f, 0.04106932f, 0.29952866f, -0.67305571f, 0.08551668f, 0.14582677f, 
    0.05631483f, 0.18971263f, -0.32628670f, 0.08887650f, 0.23323537f, -0.22284274f, 0.10456307f, 0.14928831f, 
    0.04191472f, 0.02323767f, 0.02569531f, 0.59643155f, 0.11531923f, -0.16857553f, -0.02531232f, -0.08325641f, 
    0.21427451f, -0.12842092f, 0.11217331f, -0.09359056f, -0.27103299f, -0.05367411f, -0.02328140f, -0.17378402f, 
    -0.38599974f, 0.46487069f, -0.06013977f, -0.26812288f, 0.30570304f, 0.22650543f, 0.27647713f, 0.22728604f, 
    -0.36652425f, -0.35076931f, -0.38268301f, 0.08842579f, 0.26065707f, -0.32316858f, 0.06827910f, -0.07800786f, 
    0.01946099f, -0.21409716f, 0.32394493f, -0.27959570f, 0.12918139f, 0.21845751f, -0.26579523f, -0.05094543f, 
    -0.07980251f, -0.24862717f, 0.27974001f, 0.04238025f, -0.90193605f, -0.11359089f, 0.11437712f, 0.04727287f, 
    0.51547682f, 0.76036000f, 0.28167975f, -0.35015503f, -1.03500581f, -0.52134526f, -1.06983340f, -0.37964544f, 
    0.43285924f, -0.45507580f, 0.15482287f, -0.34516892f, -0.02667086f, -0.25073218f, 0.11246382f, -0.08302294f, 
    -0.52600986f, 0.17854014f, -0.27177280f, -0.33261183f, 0.16915864f, -0.50734323f, 0.17768030f, -0.00255818f, 
    -0.20433375f, 0.06593062f, -0.23805848f, 0.11778197f, 0.10295060f, -0.12960316f, 0.06561484f, 0.00518237f, 
    -0.31284854f, -0.43858108f, -0.07718305f, 0.64318407f, -0.36735895f, -0.41605520f, -0.28228217f, 0.41784555f, 
    -0.30005914f, 0.61366802f, 0.07176853f, 0.35006288f, -0.16950926f, 0.27101943f, 0.12487041f, -0.17640391f, 
    -0.10136402f, 0.12357119f, 0.09514187f, 0.51661676f, 0.06622259f, -0.16099095f, -0.04583703f, -0.16453810f, 
    0.28472716f, 0.44872186f, -0.16204362f, 0.10551318f, -0.19326116f, 0.01467811f, 0.18724766f, 0.09730186f, 
    0.36439124f, 0.08990762f, -0.20664693f, -0.24086370f, -0.16323934f, 0.93382490f, -0.89192313f, -0.06559798f, 
    0.45076051f, -0.22137126f, -0.12785761f, -0.10247641f, 0.30752537f, 0.12106942f, -0.06946135f, -0.13505881f, 
    -0.07633667f, -0.31773210f, 0.44612730f, 0.23908636f, -0.52422130f, 0.12221545f, -0.27272391f, 0.09268175f, 
    -0.31269529f, -0.08294708f, -0.12327938f, -0.14163499f, 0.86643881f, -0.07041653f, 0.06629457f, -0.07215504f, 
    0.05811077f, 0.24409513f, -0.29173329f, -0.40501514f, -0.09540450f, -0.72836947f, -0.04844345f, -0.13010848f, 
    0.29532585f, 0.12935555f, -0.54270375f, 0.24801290f, -0.58058065f, -0.14693049f, 0.73487079f, 0.03608047f, 
    0.01023891f, -0.09121109f, -0.20874925f, -0.31042731f, 0.31524983f, -0.39023542f, 0.14434022f, -0.06397787f, 
    0.38542137f, -0.17381822f, 0.10444332f, -0.05678118f, 0.41195554f, 0.13515779f, 0.13927832f, -0.13485348f, 
    0.02811935f, -0.13116586f, -0.14631763f, -0.21034332f, -0.59855771f, -0.26763520f, -0.18054742f, 0.44387344f, 
    -0.26450258f, -0.57638013f, 0.05672885f, -0.18571623f, 0.28625423f, -0.03753291f, -0.20010132f, -0.39726225f, 
    0.36650470f, -0.30131751f, -0.94256264f, 0.47288808f, -0.58872324f, 0.39630935f, 0.41563919f, -0.06279617f, 
    -0.21489532f, -0.74120229f, 0.52977520f, -0.03774537f, -0.03832112f, 0.05209155f, -0.01001126f, -0.11718814f, 
    -0.15701306f, -0.34438914f, 0.16177174f, -0.30539912f, 0.12858252f, -0.59766698f, -0.13372526f, -0.33173472f, 
    0.34037897f, -0.36719647f, 0.32732263f, 0.19907725f, -0.46988639f, -0.11714348f, -0.63183349f, -0.41986763f, 
    0.40495664f, 0.02204799f, 0.87393552f, -0.14233677f, -0.31898344f, -0.14466459f, 0.12316938f, 0.03077427f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19618218f, 0.08422357f, 0.05114891f, 0.10793370f, 0.10045248f, -0.00319185f, 0.11093108f, -0.39412981f, 
    0.07033654f, 0.14279334f, 0.11523935f, 0.01284940f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
