#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.47018650f, -0.32604280f, -0.43065679f, 0.02416656f, -0.00332671f, -0.16059095f, 0.06031567f, 0.88084388f, 
    0.26543862f, -0.22098272f, 0.99605119f, -0.89252007f, -1.01737559f, -0.03010329f, -0.46493331f, 0.23698947f, 
    0.43690115f, -0.13705832f, -0.89395583f, -0.56571615f, 0.12571815f, 0.91434288f, -0.69479954f, -0.67898911f, 
    -0.21467441f, -0.18633321f, -0.23652793f, -0.54290944f, 0.56051445f, 0.74259657f, -0.10282723f, 0.40775591f, 
    -0.37162656f, -0.54055601f, -0.42057741f, -0.37972668f, -1.12460351f, -0.28342810f, -0.54095495f, 0.18169524f, 
    -0.06921624f, 0.23517427f, -0.08227348f, 0.59655231f, 0.25303498f, 0.98175532f, -0.24351729f, -0.33811033f, 
    0.66415513f, 0.35333791f, 0.56195837f, -0.53861421f, 0.39083439f, -0.63659614f, -0.27614155f, 0.72478747f, 
    -0.35198939f, 0.02908882f, 0.20897029f, 0.29209262f, -0.36649108f, 1.01419425f, -0.55927342f, 0.45804265f, 
    -0.22669505f, -0.42687482f, 0.16060776f, 0.39703310f, 0.18779524f, 0.81472749f, -0.45502201f, -0.42126068f, 
    0.36738232f, 0.49175066f, 0.05526604f, -0.03642555f, 0.96182764f, -1.13419330f, 0.14093459f, -0.11670996f, 
    0.15317246f, -0.40987104f, -0.44263372f, -0.22088712f, -0.59257805f, -0.14380445f, -0.70425314f, -0.20081022f, 
    -0.16565837f, 0.77725530f, -0.42281002f, -0.28576431f, 1.06912231f, -0.50995439f, -0.44996294f, -0.00879679f, 
    -0.04400381f, 0.47519284f, -0.31328115f, -0.45960060f, -0.65973294f, -0.87196594f, 0.28775579f, 0.63247228f, 
    0.23765290f, -0.47794658f, -0.32319856f, -0.71421826f, 0.53462541f, 0.49291506f, 0.70880020f, 0.41548219f, 
    0.77966392f, 0.67456698f, 0.19484159f, 0.06894933f, 0.06099521f, 0.66340715f, 0.78954130f, 0.56465966f, 
    0.17824689f, -0.68942934f, -0.40439594f, -0.16126385f, -0.08689857f, 0.34930086f, 0.68375283f, 0.14006467f, 
    -0.78096020f, 0.57733518f, -1.00725734f, -0.06475725f, -0.40740466f, -0.37002841f, -0.18128681f, 0.49432251f, 
    0.25302076f, 0.24036109f, -0.32200721f, -0.59261310f, -0.03386997f, 0.77797443f, 0.26777837f, -0.44520530f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00917847f, -0.10731060f, -0.12110966f, 0.21088529f, 0.31944412f, -0.05893394f, 0.36035341f, 0.48954403f, 
    0.21760498f, -0.28464791f, 0.39419231f, 0.36115253f, 0.03930168f, 0.30885783f, 0.07243712f, 0.02212556f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.33005133f, 0.16254625f, -0.06049836f, -0.05699884f, 0.19557357f, 0.00765490f, 0.06780900f, -0.12227818f, 
    0.15928535f, 0.21831568f, 0.25993583f, 0.09319042f, -0.09433071f, 0.01190325f, 0.15539208f, 0.00401151f, 
    -0.12159994f, -0.18984255f, 0.09488612f, 0.19779907f, 0.21510416f, 0.12417608f, -0.13524303f, 0.06745493f, 
    0.19625588f, -0.07660601f, -0.13577539f, -0.05156934f, -0.25070167f, 0.12965328f, 0.03918546f, 0.15686743f, 
    -0.01507555f, 0.01194960f, -0.05537329f, -0.14905521f, 0.10404069f, 0.12015422f, -0.08764306f, -0.02001167f, 
    -0.03551978f, 0.15785488f, 0.05214412f, 0.07878269f, 0.18199942f, -0.06444240f, -0.10627051f, -0.16680016f, 
    0.17072225f, 0.02034186f, 0.11817002f, 0.09587222f, -0.27452293f, -0.11178075f, -0.10290822f, -0.08107631f, 
    -0.10463095f, -0.03741380f, 0.13741919f, -0.04865682f, -0.29344341f, 0.10065521f, 0.14026701f, -0.16281684f, 
    -0.11396949f, -0.23709454f, -0.00840223f, 0.12433384f, -0.12567368f, -0.09035180f, 0.01392492f, 0.01084288f, 
    -0.36734584f, 0.04926638f, -0.01490518f, 0.04510611f, -0.00668925f, -0.03605916f, 0.23779537f, -0.08490244f, 
    -0.12051704f, 0.25449926f, 0.37405875f, 0.39039108f, 0.05131568f, 0.08427118f, 0.02829589f, 0.08707698f, 
    0.06857012f, 0.26408914f, -0.29304776f, 0.30134451f, -0.00002968f, 0.12405053f, 0.04038446f, -0.20450827f, 
    0.08200660f, 0.08464602f, -0.27525792f, 0.10114178f, 0.03773056f, -0.06604420f, -0.05963043f, -0.03781329f, 
    0.28668547f, -0.12684624f, -0.07595291f, 0.09842841f, 0.11445569f, 0.00698319f, -0.00153738f, -0.05951424f, 
    0.02777210f, -0.25521880f, 0.01512692f, -0.04361239f, 0.02124752f, -0.15209441f, -0.45632428f, -0.26250586f, 
    0.12129155f, 0.15365626f, 0.19052118f, 0.04741406f, -0.27724081f, -0.03467719f, -0.05914539f, -0.04388807f, 
    0.00597011f, 0.14664441f, 0.07246268f, 0.03680574f, -0.10892463f, -0.10605753f, -0.15679675f, -0.34153771f, 
    -0.15143219f, 0.22799404f, 0.30218661f, 0.08839764f, -0.00110197f, 0.01115007f, 0.23743090f, -0.09395824f, 
    -0.28583121f, -0.22423536f, 0.11954191f, 0.18867175f, -0.04943871f, 0.02590637f, 0.23237744f, -0.00765485f, 
    0.18711421f, 0.39275298f, 0.01116848f, 0.18690345f, 0.00465052f, 0.20529900f, 0.14002708f, -0.09147418f, 
    -0.32327235f, 0.00942242f, 0.61012417f, -0.20841761f, -0.20505553f, -0.05926179f, 0.05275729f, -0.22181992f, 
    0.07173484f, 0.25339720f, 0.07209381f, 0.15604244f, -0.03975349f, -0.22944716f, 0.08933128f, 0.09717023f, 
    -0.05810975f, -0.05883458f, -0.01951611f, -0.11359641f, 0.98816603f, -0.09046040f, -0.53278840f, -0.20367652f, 
    0.29855305f, -0.11581981f, 0.06367854f, -0.09409938f, -0.09597591f, 0.03938678f, 0.20038757f, 0.20809333f, 
    0.00734906f, 0.06332884f, 0.03190067f, 0.13852911f, -0.18762971f, 0.10853972f, -0.06616029f, 0.23834889f, 
    0.05969528f, -0.24505584f, -0.09907179f, -0.24328023f, -0.01710088f, -0.12825623f, -0.14131312f, -0.12313905f, 
    -0.10772312f, 0.26223868f, -0.23672581f, -0.07489319f, -0.21135435f, 0.00929691f, -0.01338184f, 0.05273337f, 
    -0.23548537f, 0.17927568f, 0.28874728f, -0.17378469f, 0.01095692f, -0.13066429f, -0.05959112f, -0.10763483f, 
    -0.00631261f, 0.44011462f, 0.24214716f, -0.07967988f, -0.00743104f, 0.17395055f, -0.10483365f, -0.05131608f, 
    -0.13461587f, 0.00278399f, 0.19539887f, 0.15078796f, -0.42160305f, -0.12412146f, -0.03101765f, -0.03321047f, 
    0.12669730f, 0.01110232f, -0.04897749f, 0.05809653f, -0.00827545f, -0.05993144f, 0.16869350f, 0.02582962f, 
    -0.00993016f, 0.00301460f, 0.22466920f, 0.10383271f, 0.12605962f, 0.22128661f, 0.21142854f, -0.25099576f, 
    0.09582325f, -0.13754503f, 0.03598927f, 0.01848213f, 0.11902851f, -0.44413662f, -0.07807472f, -0.05867478f, 
    -0.05885946f, -0.05698514f, 0.11091135f, 0.06393571f, 0.06065680f, 0.07424144f, -0.26018357f, -0.18860704f, 
    -0.17306173f, -0.02457089f, -0.16119727f, -0.07854740f, -0.20825577f, 0.10899682f, -0.05213489f, -0.33290160f, 
    0.24928847f, 0.04828449f, 0.04960012f, -0.04015648f, -0.02486716f, 0.32506368f, -0.12821557f, 0.10568149f, 
    0.14897056f, 0.15849409f, 0.04077922f, -0.02286784f, 0.03513472f, -0.15437229f, 0.06419413f, 0.10542970f, 
    0.09476560f, -0.22341098f, -0.30221784f, -0.24752447f, -0.01658743f, 0.11386801f, -0.16817334f, 0.01099064f, 
    0.01163589f, -0.12348896f, -0.05765034f, -0.12979162f, 0.16196097f, -0.09178627f, -0.11453268f, 0.07354198f, 
    0.03373228f, 0.04943091f, 0.05014824f, -0.74982327f, -0.42725769f, -0.09890956f, -0.00151651f, 0.00341365f, 
    -0.14375550f, 0.03653642f, 0.12751891f, 0.02219844f, -0.21803558f, 0.05755578f, -0.02088578f, -0.04623395f, 
    0.18612415f, -0.06815815f, -0.01797727f, 0.11829408f, -0.12153689f, 1.40501177f, -0.49973771f, -0.07390052f, 
    -0.08908403f, -0.02139156f, -0.15956508f, -0.13703668f, 0.05000134f, 0.05774504f, -0.18989435f, -0.25602552f, 
    0.12713400f, 0.14311844f, 0.14140169f, 0.02637525f, -0.11090893f, -0.00625765f, -0.11287772f, 0.01172613f, 
    -0.25163665f, 0.17203450f, 0.03360844f, 0.16146219f, 0.12502865f, 0.09274653f, -0.01024088f, 0.05205727f, 
    0.10423301f, -0.58452970f, 0.10120921f, -0.20083863f, -0.03967484f, -0.05862276f, -0.00014340f, -0.04623263f, 
    -0.00024409f, 0.06991271f, 0.01727938f, 0.25393039f, -0.11471672f, -0.02696949f, 0.06284562f, -0.02915250f, 
    -0.23745848f, 0.17955369f, -0.08983295f, -0.18438350f, -0.26118413f, -0.08616233f, -0.07891198f, 0.10249358f, 
    -0.03124560f, 0.02407801f, 0.13430959f, 0.03946634f, 0.17449176f, 0.30923200f, 0.06595939f, 0.12449191f, 
    0.06642889f, 0.21360642f, 0.08806683f, 0.06364786f, -0.97510278f, -0.08178709f, -0.02817825f, -0.34841678f, 
    0.02919532f, -0.31795827f, 0.13485025f, 0.05417994f, 0.26322252f, 0.19671805f, -0.50359958f, -0.46016002f, 
    0.00680762f, -0.22661333f, -0.05203085f, 0.01912509f, 0.01380649f, 0.14848991f, 0.26754892f, 0.10413153f, 
    -0.10847634f, -0.03050865f, 0.12155204f, -0.01019406f, 0.07247586f, 0.09208091f, -0.08582198f, 0.22716191f, 
    -0.23637003f, 0.14603090f, -0.00888358f, -0.19376676f, -0.24597025f, 0.02379117f, 0.00787740f, -0.02844157f, 
    0.11861582f, -0.12454418f, -0.19449654f, -0.01898404f, 0.02721656f, 0.04355418f, 0.17546415f, 0.14753062f, 
    0.43555468f, -0.33876991f, 0.08803750f, 0.08559326f, 0.12212278f, 0.03256388f, 0.10852167f, 0.05461539f, 
    0.26394147f, 0.15650949f, -0.00867982f, -0.33186087f, 0.15234305f, -0.00969920f, 0.01938345f, -0.10987581f, 
    -0.13825604f, -0.24914184f, -0.19969802f, -0.10871375f, 0.09517249f, 0.00752152f, 0.08318686f, -0.11519252f, 
    0.10908139f, -0.07090626f, 0.00623563f, -0.29822898f, 0.18719399f, 0.10176183f, 0.12216370f, -0.03299205f, 
    -0.01547676f, -0.13195059f, 0.10680258f, 0.06727715f, 0.14703467f, -0.34630039f, -0.21437281f, 0.18619789f, 
    0.01536311f, 0.02564824f, 0.01283473f, 0.05786484f, -0.05201660f, -0.01511117f, 0.09600931f, 0.44645807f, 
    0.31792128f, 0.27439395f, 0.08522661f, 0.01281763f, 0.00400583f, 0.17261262f, 0.00103497f, 0.06389771f, 
    0.11452462f, 0.40479887f, -0.25956979f, 0.28235838f, 0.06522062f, -0.06116700f, 0.13020240f, -0.14234322f, 
    -0.60288346f, 0.32343161f, -0.18663569f, 0.11912799f, 0.00729701f, 0.04566919f, -0.05559708f, 0.16774522f, 
    0.36702126f, -0.23608848f, -0.36002004f, -0.04697751f, -0.15276095f, -0.06579088f, 0.04703679f, 0.17511636f, 
    0.21187772f, -0.04381231f, 0.47010216f, 0.14807042f, 0.04401397f, 0.22150616f, 0.26085800f, 0.15250558f, 
    0.07286216f, 0.31644648f, 0.22401373f, 0.08374106f, 0.09654032f, 0.01602240f, -0.06754634f, 0.19205444f, 
    -0.28805348f, -0.03574536f, -0.26161426f, -0.29159167f, -0.41867074f, -0.17776442f, -0.02813303f, -0.06839143f, 
    -0.00675310f, -0.25492263f, -0.11198314f, -0.15090761f, -0.31719035f, -0.65645015f, -0.00279739f, 0.13402385f, 
    -0.08771655f, -0.01625875f, 0.10356690f, -0.09637183f, 0.04179888f, 0.04279417f, 0.18628888f, -0.16799803f, 
    -0.11614356f, 0.01264502f, 0.17983361f, 0.10222765f, 0.01130244f, 0.09045068f, -0.18707196f, -0.35003078f, 
    0.23981240f, 0.00335609f, 0.06624560f, -0.09122516f, 0.25675455f, -0.00578183f, 0.28572917f, 0.11607464f, 
    -0.36842522f, -0.21692556f, -0.33414963f, 0.06443416f, -0.02837834f, 0.00129335f, 0.08182272f, -0.02565289f, 
    0.17350426f, 0.19822280f, -0.19015789f, -0.43973315f, -0.24859989f, -0.47270221f, -0.10402662f, -0.04302622f, 
    -0.34389037f, 0.11620909f, 0.62085563f, 0.56591696f, 0.11027826f, -0.15989015f, -0.18008813f, 0.16717796f, 
    0.12680008f, 0.17957927f, -0.19781981f, 0.08239599f, 0.27077281f, 0.01721455f, -0.11787386f, -0.15762645f, 
    -0.15524855f, 0.07330136f, 0.10859306f, 0.20761204f, -0.06510711f, -0.18311822f, 0.02474013f, 0.14616227f, 
    -0.09603926f, 0.30408135f, -0.10749635f, -0.02719396f, 0.15403999f, -0.04874769f, -0.29877618f, 0.10346311f, 
    -0.00822655f, -0.04783922f, -0.20129383f, -0.16827305f, 0.08972035f, 0.10222921f, -0.18278308f, -0.31757733f, 
    0.05129239f, -0.02482205f, 0.15527271f, -0.14750437f, 0.32791722f, -0.00392791f, 0.09633181f, 0.14296640f, 
    -0.22494470f, 0.10106860f, 0.24731430f, 0.21781415f, 0.00087662f, 0.09207348f, 0.04749373f, 0.17931147f, 
    -0.44519347f, -0.12374183f, -0.27337638f, 0.07792550f, -0.07991654f, -0.00096477f, 0.14330019f, 0.16704735f, 
    0.01069043f, 0.20203780f, 0.19760047f, 0.09400170f, -0.06166302f, 0.00935236f, -0.06704154f, 0.11313795f, 
    0.00375625f, -0.01068846f, 0.47748625f, -0.19047205f, -0.20380421f, -0.15854996f, -0.06816827f, -0.08976927f, 
    0.20415211f, 0.19021259f, 0.07155363f, 0.36459622f, 0.19142948f, 0.04180200f, -0.04954557f, 0.20212258f, 
    0.22602102f, -0.01403925f, -0.18996149f, -0.18494105f, -0.69748449f, 0.44212258f, 0.14644538f, -0.16249967f, 
    -0.25592327f, 0.04109113f, 0.04482635f, 0.01499732f, 0.10244498f, -0.61696154f, -0.03624349f, -0.28330147f, 
    0.07587657f, -0.01245924f, -0.21947128f, 0.11047380f, -0.01591696f, 0.10823970f, -0.09502271f, -0.10214463f, 
    -0.24424271f, -0.06290770f, -0.09984011f, 0.23557201f, 0.03434008f, 0.14232758f, 0.02177197f, -0.11115869f, 
    0.17071137f, 0.12434027f, 0.03481587f, -0.07278299f, -0.01588649f, -0.11938960f, -0.01181448f, 0.21872841f, 
    -0.06834873f, 0.04274680f, 0.02899850f, -0.06120964f, -0.03054113f, -0.02608401f, -0.00081873f, 0.00918762f, 
    -0.00488600f, -0.01356737f, -0.02458127f, 0.06247381f, -0.08409320f, -0.00010103f, -0.06943814f, 0.05631002f, 
    -0.03780324f, -0.01635610f, 0.02377521f, 0.02778829f, 0.02690678f, 0.04810407f, 0.04021676f, -0.10322481f, 
    0.03654771f, -0.00948955f, 0.00807490f, 0.05673773f, 0.06610278f, -0.09731350f, -0.05348274f, -0.06768370f, 
    -0.03710495f, 0.00956752f, -0.10292742f, -0.06152746f, -0.04810972f, -0.00769335f, -0.02760165f, -0.01469862f, 
    -0.00359548f, -0.03010266f, 0.02924358f, -0.10881428f, -0.04491076f, -0.08342783f, -0.08122189f, -0.08267661f, 
    0.05283705f, -0.01523750f, -0.04893410f, -0.10415221f, -0.09972970f, -0.11434875f, -0.01148214f, -0.10425572f, 
    -0.00183904f, -0.00481194f, -0.04615608f, -0.08095958f, -0.02437149f, -0.02569476f, 0.02699343f, -0.01064633f, 
    -0.06681390f, 0.01689892f, -0.10895730f, -0.11575636f, 0.05465228f, -0.10202299f, 0.06666961f, 0.03205467f, 
    -0.05824760f, -0.02412286f, 0.04427074f, 0.00162996f, -0.06708997f, -0.04779330f, -0.07482789f, -0.08622965f, 
    -0.06667477f, 0.00443747f, 0.01887119f, -0.01007408f, -0.03692251f, -0.08023187f, -0.03846965f, 0.02781664f, 
    -0.10100073f, -0.06587617f, 0.00809447f, -0.06034245f, -0.05316541f, -0.03999995f, -0.04476583f, -0.03828289f, 
    0.01746822f, -0.08138774f, -0.04989008f, -0.01599033f, -0.09701994f, -0.01177159f, 0.03505633f, 0.01213736f, 
    -0.05203027f, 0.01515072f, -0.02571391f, -0.06086306f, 0.00996037f, -0.01690158f, 0.03959464f, -0.04366561f, 
    0.00278524f, 0.04708172f, -0.03446062f, -0.08240706f, -0.05937428f, 0.04548157f, -0.10730243f, -0.05001239f, 
    -0.08391678f, -0.00293484f, 0.02119396f, 0.03986591f, 0.01310287f, 0.04686327f, -0.08794595f, 0.04908472f, 
    0.04524818f, 0.04295482f, 0.03067694f, -0.08450475f, -0.10242223f, -0.10878208f, 0.00131114f, -0.04758164f, 
    -0.04025290f, 0.02678950f, -0.00933626f, -0.04358197f, 0.02263878f, -0.02416286f, 0.00189218f, -0.05318742f, 
    -0.20667595f, -0.44059998f, 0.33740261f, -0.04579345f, 0.18220173f, 0.33862662f, 0.21138339f, 0.15827541f, 
    0.00428906f, -0.40674493f, -0.16734476f, 0.19578880f, -0.28887153f, -0.06817460f, -0.11314041f, 0.06278871f, 
    0.16700406f, 0.09133375f, -0.29254588f, -0.21732691f, 0.40346095f, -0.09145546f, 0.02947267f, -0.09451785f, 
    0.03267970f, 0.05830822f, -0.07365084f, -0.20358425f, 0.02895344f, 0.13562611f, -0.04341462f, 0.04292474f, 
    -0.30171406f, 0.06091222f, -0.11671565f, 0.15874568f, -0.27162099f, -0.03917623f, -0.20075066f, -0.07364501f, 
    0.11019456f, -0.23026794f, 0.06234255f, -0.01642949f, -0.12079807f, -0.09954567f, -0.56909454f, 0.40540418f, 
    -0.21628995f, -0.19355682f, -0.14263080f, -0.04756141f, 0.07504643f, 0.23620388f, 0.08817464f, 0.01004223f, 
    0.30452496f, 0.12969184f, -0.00453252f, -0.05598545f, 0.01542532f, 0.05276750f, 0.19034629f, -0.13881287f, 
    -0.06168285f, 0.31451535f, 0.08134889f, 0.06400851f, -0.03936244f, -0.04182774f, 0.36204797f, 0.12442553f, 
    0.18836793f, 0.02870397f, -0.08883917f, 0.10784037f, -0.15728872f, -0.32850426f, 0.26328120f, 0.00997005f, 
    -0.03142258f, 0.22410022f, 0.13703403f, 0.25148767f, -0.22017865f, -0.18559043f, -0.22585309f, 0.16236138f, 
    0.12675767f, 0.12927219f, -0.19769622f, -0.04324171f, 0.35959777f, -0.23705789f, 0.42833418f, -0.23921755f, 
    0.07863703f, 0.08703939f, 0.17635636f, -0.06492899f, -0.17518385f, -0.38204584f, 0.18369508f, 0.17113635f, 
    0.07643322f, -0.12105318f, -0.30276650f, 0.01250159f, 0.19228199f, -0.03059926f, -0.04883784f, -0.05184771f, 
    -0.01996998f, -0.22119814f, 0.04968312f, 0.01431918f, 0.08406441f, 0.20939390f, 0.26819369f, -0.13932149f, 
    -0.11946190f, -0.02050740f, -0.12372944f, 0.12833518f, 0.16920097f, 0.13936642f, 0.16961731f, -0.09496520f, 
    0.20000878f, -0.04703718f, -0.00264601f, -0.00731456f, 0.23397969f, -0.14911833f, -0.22936292f, -0.01045029f, 
    0.20086429f, 0.16143033f, -0.17146373f, -0.22455108f, -0.11119875f, 0.20292217f, 0.16123262f, 0.06933802f, 
    -0.15464093f, 0.18596399f, -0.01231936f, -0.14016341f, 0.09251387f, 0.17972802f, 0.09159011f, -0.12299439f, 
    -0.07731239f, 0.58201265f, 0.33013308f, 0.02265778f, 0.02921877f, -0.05360533f, -0.08273137f, 0.01953965f, 
    0.10228862f, -0.05578451f, -0.44474649f, 0.09643692f, 0.29810527f, 0.19262055f, -0.18456396f, -0.00802403f, 
    -0.07148956f, -0.12300000f, -0.04306452f, 0.26184404f, 0.29648107f, 0.08808073f, -0.08868348f, 0.19433220f, 
    -0.07961331f, 0.22427265f, 0.33763897f, 0.29338536f, -0.20267946f, -0.22716609f, 0.28457093f, 0.31747776f, 
    -0.01903333f, 0.07524905f, 0.02289621f, 0.14036685f, 0.02141552f, -0.26798451f, -0.09397962f, 0.05817937f, 
    0.07227661f, 0.25707230f, 0.02437369f, 0.01602921f, 0.08013467f, 0.20361738f, 0.00484179f, -0.00918784f, 
    -0.32175359f, -0.12081829f, -0.12220372f, -0.11850903f, 0.24290395f, -0.06408099f, 0.24911824f, 0.00438342f, 
    0.07599690f, -0.07529366f, 0.07964778f, 0.05236417f, 0.06247234f, 0.34559342f, 0.08981571f, 0.01794341f, 
    -0.13093936f, 0.25084147f, -0.05726343f, -0.09000956f, -0.05601973f, -0.02083377f, 0.17062378f, -0.17817308f, 
    -0.18074611f, 0.02668265f, -0.06990961f, 0.22650102f, 0.21298769f, -0.04255317f, -0.11569688f, -0.03692450f, 
    -0.14757617f, -0.16455044f, 0.41748276f, -0.04302450f, -0.12704404f, 0.10660944f, 0.09457675f, -0.08626665f, 
    0.12679720f, 0.19211383f, 0.04176626f, -0.19858220f, -0.02626714f, 0.18486175f, -0.12165359f, 0.16108818f, 
    0.24521892f, -0.04975962f, 0.22378188f, 0.15289073f, 0.11247958f, 0.08626010f, -0.09519781f, -0.16890000f, 
    -0.13076614f, -0.09440111f, 0.04614390f, 0.01592875f, 0.17215884f, 0.05097226f, -0.07894696f, -0.02432708f, 
    0.02586687f, -0.10405813f, -0.25575849f, 0.15490192f, -0.05693491f, -0.11610387f, 0.49318081f, 0.09947854f, 
    0.07415392f, -0.05031018f, 0.23427831f, 0.03277605f, 0.34546992f, 0.20270975f, 0.01375125f, 0.05894052f, 
    -0.03859700f, -0.12323508f, 0.10865848f, -0.04242004f, -0.08524275f, -0.12010816f, 0.01022270f, -0.02529481f, 
    0.00976906f, 0.17537495f, 0.11340122f, -0.13611141f, -0.23475732f, 0.21904936f, -0.07590916f, 0.20588127f, 
    0.14139923f, -0.03101033f, 0.35108301f, 0.64445210f, -0.18714169f, 0.42576936f, 0.14676942f, -0.13606906f, 
    0.15902998f, -0.27753675f, -0.24366102f, -0.06691691f, 0.23044598f, -0.30770347f, -0.02668893f, -0.37893414f, 
    0.15146886f, -0.12948598f, 0.03106727f, 0.00114759f, 0.07466587f, -0.14564410f, 0.05830450f, 0.10547124f, 
    -0.18442598f, 0.10503942f, -0.04150854f, 0.19181658f, 0.28033632f, -0.02072681f, 0.24390371f, -0.02086320f, 
    0.04678008f, 0.12186393f, 0.10784331f, 0.11164828f, 0.08762655f, 0.04807431f, -0.19248419f, 0.12040693f, 
    0.05795642f, -0.26706058f, -0.01578858f, 0.18474676f, 0.08733744f, 0.20332554f, -0.15490966f, 0.46132633f, 
    -0.24892059f, 0.14396681f, -0.04394203f, 0.08350368f, -0.13018721f, 0.18886387f, -0.10982552f, 0.01283058f, 
    0.14886424f, 0.54864311f, 0.09322289f, -0.04623891f, 0.02844738f, 0.12451679f, -0.18234842f, 0.16823968f, 
    -0.39059889f, 0.07350613f, -0.26701009f, 0.11168654f, -0.12999098f, -0.05553091f, 0.01702900f, -0.17788588f, 
    0.04044391f, -0.08672470f, 0.27563596f, 0.35253868f, -0.00028501f, -0.27335262f, -0.18920851f, 0.03234933f, 
    0.18713310f, 0.16862249f, -0.12619638f, 0.11104624f, 0.02855494f, -0.27363122f, 0.15083426f, -0.02540558f, 
    0.14738874f, 0.12226632f, 0.23897663f, 0.08661448f, -0.00626309f, 0.38015184f, -0.09670020f, -0.11593444f, 
    0.11483572f, 0.08897826f, 0.00468319f, 0.10678044f, -0.04291463f, -0.00678115f, 0.12117442f, -0.28540784f, 
    -0.15336616f, -0.18938692f, 0.24039659f, 0.07844713f, 0.00786127f, -0.52146524f, 0.16256446f, 0.15624020f, 
    -0.11608157f, -0.12803425f, -0.02268361f, -0.03550802f, 0.17316994f, 0.03778618f, 0.03011339f, -0.52465445f, 
    0.41947699f, 0.02524650f, -0.10791191f, -0.20870492f, 0.07137157f, 0.07000022f, 0.01635116f, -0.49309734f, 
    -0.18430105f, -0.28603768f, -0.15330826f, 0.09053358f, -0.22019675f, 0.11937384f, -0.08503702f, 0.06372578f, 
    -0.11543873f, -0.22518142f, 0.33830097f, 0.09569886f, 0.08754124f, 0.02167993f, -0.30162585f, -0.14774659f, 
    -0.13742851f, -0.09804786f, -0.59452021f, 0.24553517f, -0.02556279f, 0.04385300f, 0.04580823f, -0.13349167f, 
    0.01985797f, -0.06189504f, 0.09598845f, 0.28237674f, 0.25389972f, -0.32200462f, 0.16123813f, -0.22666295f, 
    -0.03787239f, 0.24599627f, 0.13285828f, -0.02406001f, -0.12179816f, -0.13790767f, -0.12486946f, 0.19146952f, 
    0.00419925f, 0.11817915f, 0.06115563f, 0.12669346f, -0.21454574f, 0.12030523f, 0.04788325f, 0.08192477f, 
    -0.14764607f, -0.43764874f, -0.03247634f, -0.13935284f, 0.02576134f, -0.11489219f, -0.14055210f, 0.35205844f, 
    -0.14182205f, 0.09433772f, 0.21977486f, -0.04763495f, -0.09692376f, 0.19368976f, 0.11809513f, -0.09149834f, 
    0.19812900f, -0.13985470f, 0.09401138f, 0.11726539f, 0.00406294f, 0.08116078f, 0.25489110f, 0.00033244f, 
    -0.13932315f, 0.32320341f, -0.27968028f, 0.25809491f, 0.01986861f, -0.16510317f, 0.14356096f, 0.10752375f, 
    0.23864442f, 0.04507420f, 0.05456976f, -0.01548763f, -0.05232550f, -0.04037259f, 0.16168746f, 0.23253712f, 
    -0.11534690f, -0.00974517f, 0.35979319f, 0.08550492f, 0.20259833f, 0.02362835f, -0.01952039f, 0.09960117f, 
    -0.05732424f, 0.02211345f, -0.26472697f, -0.01166890f, -0.30105492f, -0.14258662f, 0.38675901f, -0.04869918f, 
    0.00543354f, -0.09344994f, -0.05439089f, 0.21702956f, -0.27316374f, 0.11935209f, 0.10159281f, 0.07126553f, 
    0.01220399f, -0.15443510f, 0.08712325f, 0.28732079f, 0.22976044f, -0.03618792f, -0.08029341f, -0.02778204f, 
    0.02366484f, -0.10421680f, 0.01285757f, -0.06505147f, -0.13992982f, 0.21758004f, 0.17912120f, -0.05320975f, 
    0.02237881f, -0.14474693f, -0.22705062f, 0.06507563f, -0.06372256f, -0.15841977f, -0.06119632f, -0.07360471f, 
    0.35336816f, -0.08474721f, -0.09540071f, 0.16111654f, 0.00211931f, 0.28483200f, 0.27061409f, 0.14265619f, 
    -0.00321740f, 0.01850152f, 0.16988683f, -0.06335524f, -0.03509918f, 0.09064452f, 0.19776616f, -0.23223080f, 
    -0.02139259f, 0.01875922f, 0.05196944f, 0.02776905f, 0.12510474f, 0.05359795f, 0.23505308f, -0.18657967f, 
    0.24033567f, -0.05207506f, -0.38348725f, -0.40560767f, -0.05606851f, 0.03676882f, -0.02870647f, -0.05225401f, 
    -0.09981042f, 0.00274948f, -0.06978712f, -0.15793182f, -0.21677867f, -0.03391399f, 0.01075844f, 0.04811815f, 
    0.24439934f, -0.31383801f, -0.14347985f, -0.10367980f, 0.13125771f, -0.05339518f, 0.04455000f, 0.04297701f, 
    0.14992769f, -0.00510661f, 0.01037282f, 0.25574151f, -0.02773595f, -0.30221242f, -0.37945610f, -0.07703296f, 
    0.07262655f, -0.01043547f, 0.03982775f, -0.09380796f, -0.01793289f, 0.41549170f, 0.02418716f, 0.22336751f, 
    -0.09074004f, -0.02940380f, -0.12937947f, 0.09778214f, -0.14637479f, 0.16397370f, -0.11890540f, 0.43723813f, 
    0.23231788f, 0.01631744f, 0.16567895f, 0.12136468f, -0.08394036f, -0.11187760f, -0.06825764f, 0.00547230f, 
    -0.06145456f, 0.02077118f, 0.10124018f, 0.07142600f, 0.00661308f, -0.10999183f, 0.03806093f, 0.00036537f, 
    0.20537466f, 0.25732908f, -0.01474942f, 0.05202293f, 0.27935129f, -0.11673128f, 0.27460510f, 0.09924047f, 
    0.03514595f, 0.35465032f, 0.24110568f, -0.09719813f, 0.03731485f, 0.04199580f, 0.08791097f, 0.15717986f, 
    -0.08127353f, 0.11349000f, -0.43808046f, 0.04690389f, 0.00336066f, 0.04573581f, -0.02442902f, 0.34649187f, 
    0.06126224f, -0.19824044f, 0.02646784f, 0.04820738f, -0.15885697f, -0.54814547f, -0.16423568f, -0.04698383f, 
    0.05826909f, 0.12851387f, -0.09682095f, 0.01366855f, 0.19232677f, 0.34298900f, 0.19494289f, -0.36137593f, 
    -0.05291778f, -0.03445570f, -0.00951791f, -0.14362681f, -0.19504425f, 0.30797544f, 0.08691037f, 0.20645168f, 
    0.09904744f, -0.04590886f, 0.08955751f, 0.22540940f, 0.15334827f, 0.20510632f, -0.07918095f, -0.64778680f, 
    -0.06419957f, -0.09303472f, -0.15217724f, 0.18482603f, 0.17244545f, -0.02672199f, -0.13467270f, 0.39903522f, 
    -0.22646348f, 0.07449687f, -0.30496800f, -0.05002493f, -0.12550680f, -0.22846469f, 0.24181333f, 0.28335905f, 
    0.16112483f, -0.07126221f, 0.11291996f, 0.05150250f, -0.06786072f, -0.04189344f, -0.00682362f, 0.05025832f, 
    0.00697300f, 0.08118372f, 0.01869279f, -0.24275376f, -0.01006767f, -0.23086125f, 0.18375316f, 0.00657402f, 
    0.01009125f, -0.10849514f, 0.44813862f, 0.16642979f, 0.23282714f, -0.00739295f, 0.00870390f, -0.00853091f, 
    -0.01398805f, -0.11069217f, 0.09713492f, -0.15994880f, -0.21622397f, 0.06957960f, 0.06524609f, 0.10794938f, 
    -0.26123843f, 0.34082115f, 0.13991317f, -0.15133619f, 0.19409285f, 0.21499249f, 0.20419867f, -0.10753674f, 
    0.21937251f, 0.33944151f, 0.05457884f, 0.09065980f, 0.11947335f, 0.18099743f, -0.37802306f, -0.41352484f, 
    0.07474253f, -0.26007739f, -0.18827379f, 0.06691147f, -0.00068213f, -0.07445197f, -0.47465482f, -0.56681913f, 
    -0.29267660f, -0.11877543f, 0.05246274f, 0.28234276f, 0.04371215f, 0.22705273f, 0.16205077f, -0.09625645f, 
    -0.40570977f, -0.35790578f, 0.04698054f, -0.00497606f, -0.03134256f, -0.06285583f, 0.16289438f, 0.12353329f, 
    -0.28679562f, -0.59121138f, 0.00352732f, 0.07310700f, -0.18483505f, -0.17039825f, 0.06196681f, -0.01160022f, 
    -0.14295681f, 0.43864805f, 0.16717081f, 0.43554994f, -0.08588898f, 0.12087170f, -0.02520051f, -0.04757940f, 
    0.09173562f, 0.04586031f, -0.08458062f, -0.11350347f, 0.40217522f, -0.07906087f, 0.00787497f, -0.06283044f, 
    -0.07843194f, 0.11958627f, 0.09250322f, 0.01599341f, -0.06038294f, 0.22426076f, 0.09603082f, 0.02271376f, 
    -0.02638930f, 0.32374972f, -0.08531830f, 0.06498542f, 0.21928631f, -0.40004826f, -0.30281463f, 0.05739897f, 
    0.06100355f, 0.09333609f, 0.13246159f, -0.16768625f, 0.19323023f, -0.20202963f, -0.47199336f, -0.04703891f, 
    -0.07499777f, 0.03709589f, 0.00917261f, -0.11734901f, 0.04344060f, 0.04537645f, -0.15629283f, 0.52496952f, 
    0.24401571f, -0.04898801f, -0.00745535f, 0.04709237f, 0.10164776f, 0.05006640f, -0.03424956f, -0.01860407f, 
    -0.29860887f, -0.01111734f, -0.10942787f, 0.17730770f, -0.03683389f, -0.18557228f, 0.10202139f, 0.02415396f, 
    0.23973736f, 0.40146631f, 0.29790255f, -0.12364754f, -0.17970534f, -0.07379420f, 0.22614381f, 0.18545984f, 
    0.21617909f, -0.67982084f, 0.14630874f, -0.36333758f, 0.00885203f, -0.15133293f, 0.05122371f, 0.00066389f, 
    0.20203061f, 0.04011727f, -0.43135139f, -0.48644152f, -0.23178972f, -0.40073329f, 0.05958167f, -0.34731671f, 
    0.25945702f, -0.11870029f, -0.04170447f, -0.06209209f, -0.22662123f, 0.06110849f, 0.01635293f, -0.13820037f, 
    0.09018782f, 0.10335674f, 0.01411085f, 0.04873892f, -0.50915009f, 0.07272870f, 0.38947448f, 0.04509179f, 
    0.03563816f, -0.20179242f, 0.11857120f, 0.04207007f, 0.25194019f, 0.20485464f, -0.11555296f, -0.09800394f, 
    -0.21369973f, -0.36608687f, -0.07123682f, -0.03841568f, 0.07377312f, 0.14464730f, -0.24762151f, 0.05118584f, 
    0.10476242f, 0.07535447f, 0.03380188f, -0.06397524f, 0.16241227f, 0.12030157f, -0.03847366f, 0.20634995f, 
    0.06873413f, 0.03449411f, 0.01120091f, -0.05250055f, -0.18469623f, 0.04134191f, 0.16658306f, -0.04498302f, 
    -0.06492827f, -0.33377773f, 0.18237688f, 0.29727340f, 0.20701610f, 0.11041749f, -0.05752489f, 0.24669977f, 
    0.02306624f, -0.33142418f, -0.14955969f, -0.07533475f, -0.15435238f, -0.24395952f, -0.22773367f, 0.12069292f, 
    -0.06747928f, 0.14865917f, 0.21399066f, -0.11500128f, -0.35105407f, -0.03169863f, -0.13524325f, -0.01109009f, 
    0.18055116f, 0.16812217f, 0.24517842f, 0.31455624f, 0.26460204f, 0.47540131f, -0.15408719f, -0.27084568f, 
    -0.17222682f, 0.09635603f, -0.07619289f, 0.08763098f, -0.09477040f, -0.03667131f, 0.08296186f, -0.05316519f, 
    0.07700065f, 0.11059205f, 0.02764850f, 0.15053710f, 0.07293089f, -0.08464528f, 0.07149363f, -0.03118120f, 
    0.22537902f, 0.17435759f, -0.00141166f, 0.08024515f, 0.05314296f, 0.02295113f, 0.02171747f, -0.67840153f, 
    -0.71132708f, -0.12849836f, 0.09255884f, -0.03457695f, 0.00611944f, 0.08151061f, -0.15949322f, -0.18422183f, 
    -0.00128600f, -0.51133072f, -0.18743174f, 0.03418593f, 0.20791893f, 0.17809586f, 0.18642208f, 0.11973423f, 
    -0.09512475f, -0.21999887f, -0.05947305f, 0.12605318f, 0.23721042f, 0.00618904f, 0.27211529f, 0.20173553f, 
    0.39133897f, -0.26003283f, 0.44824663f, 0.37740690f, 0.09381891f, 0.43151248f, -0.13501550f, 0.10528440f, 
    0.27119648f, -0.06849667f, -0.01092019f, 0.46285659f, -0.37926418f, -0.14101973f, -0.18505704f, 0.13284343f, 
    0.02461523f, -0.07611168f, 0.04146994f, -0.00940704f, -0.19760802f, 0.12176721f, 0.01441974f, -0.12186190f, 
    0.08285559f, -0.21372953f, -0.11686291f, -0.11478265f, -0.06168770f, -0.28002271f, -0.30265182f, -0.21117839f, 
    0.05164972f, 0.08242106f, 0.18320858f, 0.01662132f, 0.13615876f, -0.04354546f, 0.05133162f, 0.01971107f, 
    0.10170110f, 0.16393748f, 0.06630021f, -0.09274711f, 0.17140356f, -0.05936661f, 0.13545360f, 0.27134123f, 
    0.19205949f, 0.07596002f, 0.17703536f, -0.05605834f, -0.09964799f, -0.04659950f, -0.05051477f, -0.00592947f, 
    0.09262226f, -0.14873952f, 0.04802626f, 0.13229229f, -0.03569144f, -0.12985775f, -0.11610683f, 0.07130603f, 
    0.19664247f, 0.23509429f, -0.01668201f, 0.01360430f, -0.22962400f, -0.09069721f, 0.01650457f, 0.07676470f, 
    0.08172107f, 0.10348580f, 0.14436211f, 0.05503457f, -0.21321931f, -0.01310631f, 0.02693566f, 0.11784394f, 
    0.03700143f, 0.19385046f, -0.09322990f, 0.25148001f, 0.55453211f, 0.06652826f, 0.14455496f, -0.06751651f, 
    0.09074504f, 0.13097005f, -0.00925734f, 0.04121719f, -0.46236899f, -0.48161674f, -0.27996001f, 0.04527199f, 
    0.08983137f, -0.14835915f, -0.31859654f, -0.22787423f, 0.10332653f, 0.05417744f, 0.06844472f, -0.04586018f, 
    -0.04174593f, -0.12627232f, -0.04592215f, -0.07695955f, -0.12510645f, -0.18377818f, -0.05859075f, 0.02337946f, 
    -0.03680111f, -0.15507011f, 0.00669463f, 0.13703460f, -0.03458284f, 0.15147585f, -0.13788907f, 0.01621783f, 
    -0.23104797f, -0.00073647f, 0.02972283f, -0.06677947f, -0.19477095f, -0.13052160f, -0.15696719f, -0.04764850f, 
    0.03791089f, 0.20769446f, 0.13899668f, 0.26425248f, -0.25901192f, -0.04448558f, 0.04455183f, 0.13386329f, 
    -0.24106264f, 0.00770690f, -0.35315287f, 0.08703376f, -0.08747731f, 0.03693506f, 0.05558066f, -0.02021052f, 
    0.10907326f, -0.16992792f, -1.44742727f, -0.22940592f, -0.01325694f, 0.00534131f, -0.09447495f, 0.02151397f, 
    0.01447919f, -0.05873087f, 0.07054424f, -0.62193584f, -0.14383020f, -0.08657318f, -0.17041855f, -0.08586743f, 
    0.10016739f, 0.03246888f, -0.00550603f, -0.16598466f, 0.07135180f, 0.04398257f, 0.02340064f, -0.10499319f, 
    0.00614540f, -0.08099211f, -0.03650182f, 0.18224369f, -0.42448613f, 0.32076293f, 0.46488470f, 0.03259889f, 
    0.01503567f, -0.15151332f, 0.00846078f, -0.06706019f, -0.00005476f, -0.05611465f, 0.24825671f, 0.06599379f, 
    0.03797852f, 0.03655200f, 0.13071679f, -0.05418377f, 0.02914669f, 0.09766969f, 0.27901050f, 0.05180245f, 
    0.37014750f, 0.22262710f, -0.05392997f, 0.16529937f, 0.00614979f, 0.06314829f, 0.13826551f, 0.12410622f, 
    0.24936889f, 0.12945093f, 0.05666193f, -0.00424068f, -0.11571445f, 0.20501697f, 0.31659085f, 0.01674612f, 
    -0.14152764f, -0.24650750f, 0.26479605f, 0.05365418f, -0.04521780f, 0.06754386f, -0.08968162f, 0.14097287f, 
    -0.09381265f, -0.69179261f, -0.37191862f, -0.31102946f, 0.22115144f, 0.09823139f, -0.12160921f, 0.02837871f, 
    -0.01618317f, 0.17372186f, 0.18390363f, -0.25427899f, -0.28296173f, -0.14580376f, -0.14009029f, -0.01783641f, 
    0.04213531f, 0.09334517f, 0.08197074f, -0.21546496f, -0.02544546f, 0.13989264f, -0.02868163f, 0.05819226f, 
    -0.05644041f, 0.07748625f, 0.00379728f, 0.04831987f, 0.27660784f, 0.10916612f, 0.02342793f, -0.32835588f, 
    -0.30269814f, -0.13557087f, -0.00124031f, -0.19901213f, 0.17849368f, -0.04441255f, -0.00095829f, 0.00662003f, 
    0.00850187f, 0.09513874f, -0.10414539f, 0.09400324f, 0.11930674f, 0.23484647f, -0.26881644f, 0.42537105f, 
    0.31359079f, -0.23330608f, -0.17099823f, -0.27695450f, 0.16391046f, -0.27961546f, 0.15048382f, 0.28643760f, 
    -0.17883439f, -0.20541121f, -0.11753187f, -0.02205797f, -0.12708421f, 0.00378767f, 0.09412327f, 0.10689010f, 
    0.03267861f, 0.01246224f, -0.07777389f, -0.01651686f, -0.07597937f, -0.03213106f, 0.04921518f, 0.07611037f, 
    -0.09517319f, -0.07962877f, 0.02085480f, 0.02829171f, -0.03618525f, -0.05702901f, -0.09471500f, 0.01233047f, 
    -0.06260902f, -0.02099423f, -0.06375778f, 0.02319178f, 0.04487303f, -0.07575588f, -0.05579963f, -0.09149797f, 
    -0.03278292f, 0.05599174f, -0.05095547f, 0.07431498f, -0.06433320f, -0.05147785f, 0.03676996f, -0.06270589f, 
    -0.07965662f, -0.07293375f, -0.04245495f, -0.08823463f, -0.09708174f, 0.00251495f, -0.01846525f, -0.01071439f, 
    0.07219309f, 0.06567083f, -0.01512674f, -0.04687559f, -0.01377489f, -0.00144324f, -0.00555419f, 0.02734332f, 
    -0.01619080f, -0.10922853f, 0.02813337f, -0.02627678f, 0.02677880f, -0.02331389f, -0.03033271f, 0.00218771f, 
    -0.05875561f, 0.06162787f, -0.06205414f, -0.08920048f, -0.05433959f, -0.05863373f, -0.05592088f, 0.04451600f, 
    -0.05118420f, -0.09382120f, -0.01036897f, -0.02625179f, 0.02680576f, 0.01164397f, -0.07783620f, 0.01006206f, 
    -0.05682222f, 0.02363834f, -0.07959048f, -0.07741913f, 0.05569476f, 0.00521277f, -0.04648482f, 0.01966987f, 
    0.02559610f, 0.00664337f, -0.00852610f, -0.07101713f, 0.05710917f, 0.07837033f, 0.01775367f, -0.00431903f, 
    0.00631299f, -0.01145413f, -0.03119476f, 0.06111883f, -0.03486111f, 0.05438587f, 0.02177357f, -0.08627488f, 
    0.05756965f, -0.09842280f, -0.01502750f, -0.01863727f, -0.08165598f, 0.01611128f, -0.06454153f, 0.02798251f, 
    -0.08634491f, -0.01335810f, 0.05083989f, -0.02328399f, -0.05561430f, -0.01480975f, -0.05364350f, 0.04497199f, 
    0.07032476f, 0.00065876f, 0.03810196f, -0.02811269f, -0.02766442f, -0.03179668f, 0.01065319f, -0.08957516f, 
    0.05324237f, 0.04058146f, -0.04625935f, 0.05181267f, -0.03243445f, 0.04414620f, -0.05337670f, -0.06085408f, 
    -0.07162105f, 0.05976449f, 0.00232867f, -0.08537568f, -0.03671706f, 0.03010061f, 0.02153614f, -0.00629710f, 
    -0.01659736f, 0.01524739f, -0.06272881f, -0.06250603f, -0.07656959f, -0.00411628f, -0.07425616f, 0.05426190f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.08086126f, -0.43787289f, 0.28990391f, 0.31838670f, 0.21545812f, 0.01852426f, 0.10317091f, 0.23817058f, 
    0.15960062f, -0.20914187f, 0.09037674f, 0.05085810f, 0.42380008f, 0.19246314f, 0.34980783f, -0.04125895f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01320514f, 0.61199063f, -0.63401872f, 0.35250363f, 0.32578820f, 0.18264775f, 0.19710182f, -0.27280673f, 
    0.58296728f, -0.16999950f, -0.27784064f, 0.25882724f, -0.34234613f, 0.10399237f, 0.06631201f, -0.24290048f, 
    -0.14037544f, 0.16783923f, -0.00600976f, -0.12151787f, 0.33443797f, 0.02193813f, -0.24353038f, 0.41451472f, 
    0.01109316f, 0.09824481f, -0.28440854f, -0.39782247f, -0.05595164f, -0.02125973f, 0.24156123f, 0.18338484f, 
    0.39671052f, -0.69905132f, 1.00562298f, -0.02192043f, 0.09810334f, 0.03671432f, 0.04090783f, 0.00971209f, 
    0.15408863f, -0.16513661f, 0.08217595f, 0.45383805f, 0.35768443f, 0.13407473f, -0.68867052f, 0.00136402f, 
    -0.38706002f, -0.14263085f, 0.37830734f, -0.16027030f, -0.15786675f, 0.02914426f, 0.43304458f, 0.43664119f, 
    0.45740229f, 0.52534097f, 0.08585464f, -0.28435102f, -0.01663328f, 0.18449387f, -0.22845022f, 0.04100592f, 
    0.02638131f, 0.40753537f, 0.09577031f, 0.52955741f, 0.55462474f, 0.06233780f, -0.27265486f, -0.03230770f, 
    -0.13495047f, -0.40212297f, -0.07154801f, -0.14206345f, -0.11317604f, 0.15424430f, 0.56112987f, 0.04592064f, 
    0.17556079f, -0.07660714f, -0.00677908f, 0.19936135f, -0.13773794f, 0.16382162f, 0.19003266f, 0.29206407f, 
    0.08795910f, -0.20673008f, -0.31334424f, 0.07217409f, 0.16752644f, 0.26577505f, -0.62691665f, -0.12720345f, 
    0.52067405f, -0.31153753f, -0.28146997f, 0.09464849f, -0.08523928f, -0.16520697f, 0.05515699f, -0.16912353f, 
    0.21927711f, -0.36025563f, 0.27781373f, 0.40237996f, -0.07691944f, 0.51342714f, 0.05626699f, -0.14439638f, 
    0.19702429f, 0.38134325f, 0.28038183f, 0.56263798f, 0.40260345f, -0.06992331f, 0.01472802f, -0.23359668f, 
    -0.19160257f, -0.02040523f, 0.23635170f, 0.03353631f, -0.35798064f, 0.48964620f, -0.03689785f, -0.17105217f, 
    0.03134578f, 0.00157048f, -0.59489518f, 0.30091828f, 0.26238617f, -0.00981747f, -0.05711567f, 0.11303957f, 
    0.48876899f, -0.50345725f, -0.30337736f, 0.25649196f, 0.19631210f, 0.13337068f, -0.24792172f, 0.11771447f, 
    -0.02985056f, 0.03782097f, 0.83330888f, 0.25005284f, -0.37528354f, 0.00495158f, 0.35994780f, -0.27518812f, 
    0.36951977f, -0.08508342f, 0.40162608f, 0.36838266f, -0.30811146f, 0.12567607f, -0.07691853f, -0.23477133f, 
    0.31544673f, 0.23379272f, 0.14606787f, -0.06152063f, 0.51361525f, -0.22429033f, -0.12026224f, -0.26904899f, 
    0.17865844f, -0.18114652f, -0.32095760f, 0.48990756f, -0.10405971f, -0.10820842f, -0.64650142f, -0.16771272f, 
    -0.00409317f, 0.16598880f, -0.86673254f, 0.47030205f, 0.29123321f, 0.07901482f, -0.16070251f, 0.25066444f, 
    0.06512323f, -0.18783881f, -0.37879965f, -0.22870168f, -0.49812111f, 0.53796661f, 0.57768542f, 0.01837605f, 
    -0.21140224f, 0.42604783f, 0.01596739f, 0.19180447f, -0.00446777f, 0.08798498f, 0.35661262f, -0.12451503f, 
    0.03448460f, 0.04996762f, 0.04682935f, 0.50491595f, -0.14725377f, -0.06933820f, -0.12092675f, -0.10009222f, 
    -0.27269828f, 0.09923349f, 0.13736266f, -0.26070505f, -0.19373614f, -0.20118965f, -0.33803728f, 0.27094325f, 
    0.34899873f, 0.20036460f, -0.10077118f, 0.04288769f, 0.38855797f, -0.26059222f, -0.05034385f, 0.11728081f, 
    0.10319648f, 0.19318113f, -0.19403055f, -0.03843248f, -0.19092333f, -0.01200259f, 0.07198434f, -0.21540904f, 
    -0.13051648f, -0.28886729f, 0.07206334f, 0.28218913f, -0.22687326f, -0.19820461f, 0.09384882f, 0.16861027f, 
    0.26938272f, 0.22680832f, -0.17451966f, -0.40017450f, -0.04461146f, -0.17672314f, -0.07864580f, -0.16559803f, 
    -0.18729830f, 0.00099389f, 0.51106256f, 0.42168063f, 0.01384811f, 0.41130051f, 0.11949585f, 0.22995578f, 
    0.27879223f, -0.01026359f, 0.56301057f, 0.02314425f, -0.18372354f, 0.20458443f, -0.06944853f, -0.19849700f, 
    -0.08388677f, -0.11177526f, -0.14664435f, 0.54148155f, 0.09043492f, 0.12877581f, -0.11098929f, -0.03809521f, 
    -0.57089257f, -0.07350489f, 0.31872380f, -0.14528014f, -0.01160698f, 0.18595307f, 0.02181688f, 0.12118911f, 
    0.18636341f, -0.13583606f, 0.19241619f, -0.04667005f, -0.53442252f, 0.29797912f, 0.09787290f, -0.00748064f, 
    0.28056455f, 0.41824603f, -0.70899445f, -0.48987919f, 0.05744872f, 0.06192052f, -0.05345536f, 0.42789492f, 
    -0.11946247f, 0.31030843f, 0.06009169f, 0.44581136f, -0.06625052f, 0.22205311f, -0.44566050f, -0.07948526f, 
    -0.04478272f, -0.41659129f, -0.62933856f, -0.05564305f, -0.12982772f, 0.20108020f, 0.57931376f, 0.03190276f, 
    0.19531342f, 0.49169162f, -0.04633011f, 0.34890363f, -0.37777132f, -0.20981084f, -0.28843889f, -0.08911298f, 
    0.14705466f, -0.17810841f, 0.21506183f, -0.20075502f, 0.15725830f, 0.04463905f, 0.15590313f, -0.14799561f, 
    -0.19346139f, 0.11497784f, -0.21438059f, -0.09988911f, 0.03451265f, -0.01758538f, -0.10754773f, -0.22307134f, 
    0.38297588f, 0.15278716f, -0.30484268f, 0.58484966f, 0.36883652f, 0.03878363f, 0.48814335f, -0.25207862f, 
    0.01374676f, -0.16358048f, 0.02812735f, -0.23443511f, -0.23842975f, 0.46526659f, 0.19182281f, -0.12960084f, 
    0.18740518f, -0.19886218f, 0.23921590f, 0.11228486f, 0.58317691f, 0.24075805f, -0.43974882f, 0.23182707f, 
    -0.11898389f, -0.18760756f, 0.00319423f, 0.01716923f, 0.41241425f, -0.45116711f, 0.35941291f, 0.20205416f, 
    0.19721119f, -0.24720712f, 0.19062550f, -0.25238204f, -0.01397213f, -0.19078098f, 0.08341306f, -0.16793096f, 
    -0.24234129f, -0.09074647f, 0.04248618f, -0.00505875f, -0.20171604f, 0.08564830f, -0.10787864f, 0.02607126f, 
    0.02420045f, 0.17993034f, 0.13310665f, -0.26185229f, 0.04598872f, 0.05216736f, -0.22125842f, 0.03072903f, 
    -0.05712445f, -0.21104833f, -0.01073071f, -0.03140012f, -0.12108597f, 0.00331262f, -0.11324669f, 0.04430361f, 
    0.29949275f, -0.43101892f, -0.68627912f, 0.18489946f, 0.08128330f, -0.10543470f, 0.12155297f, 0.31412885f, 
    0.41343310f, 0.00237820f, -0.71542156f, 0.00167696f, 0.26978755f, -0.55070764f, -0.12849486f, -0.02295221f, 
    -0.57127512f, -0.37550873f, 0.29215160f, -0.01964699f, 0.15969625f, 0.13447681f, 0.47088596f, 0.41279161f, 
    -0.10281663f, 0.55570567f, 0.19154060f, -0.56142491f, 0.02161376f, -0.68820924f, -0.23132817f, 0.22308037f, 
    0.16376282f, 0.31048211f, -0.73955828f, -0.16710949f, -0.13473435f, 0.22850409f, 0.51789099f, 0.11731867f, 
    0.37625504f, 0.17524807f, -0.03196726f, 0.56546372f, -0.47870913f, -0.02849148f, -0.31132174f, 0.10624259f, 
    0.22154586f, -0.46682674f, 0.62722933f, 0.24352214f, 0.37910512f, 0.03571473f, 0.35206610f, 0.07539147f, 
    -0.49727029f, 0.02519726f, -0.01762886f, -0.25779587f, -0.02906647f, 0.31235072f, 0.17089371f, 0.08303013f, 
    0.16913089f, -0.04583967f, 0.32654822f, -0.24717191f, -0.53924823f, 0.12771441f, 0.18325406f, 0.20145991f, 
    -0.16658032f, 0.22981358f, 0.08967662f, 0.20497735f, -0.26552191f, 0.30162480f, 0.27488822f, 0.02972769f, 
    0.33366561f, 0.60990787f, -0.68192089f, -0.40669283f, 0.40160111f, 0.11158926f, -0.09287471f, 0.25496367f, 
    -0.21614596f, -0.09573386f, -0.15686905f, 0.44752276f, -0.54882580f, -0.52950001f, -0.14179873f, -0.08259983f, 
    0.19570492f, 0.02716712f, -0.58844090f, 0.14927953f, -0.54375869f, -0.14484158f, 0.68368435f, -0.33596519f, 
    0.55964470f, -0.01875435f, -0.14983262f, 0.39524439f, 0.06865583f, -0.09595334f, -0.13460286f, 0.06635198f, 
    -0.32784390f, 0.10953376f, -0.36877850f, -0.38501146f, -0.02197500f, -0.13370539f, -0.03696388f, 0.41703492f, 
    0.04743396f, 0.15710002f, 0.20848857f, -0.54966527f, -0.23104887f, 0.07048542f, 0.41875136f, 0.07756203f, 
    -0.32028207f, -0.32133305f, 0.36627230f, -0.18740781f, 0.06592841f, 0.15306915f, 0.25127232f, 0.20471863f, 
    0.17766204f, 0.23467852f, 0.15028046f, -0.58307838f, 0.48462471f, -0.43424246f, 0.25498214f, -0.19772966f, 
    -0.33927885f, -0.83963329f, 0.27748773f, 0.08131427f, -0.00726600f, -0.05671366f, -0.08384909f, 0.40549740f, 
    0.33885759f, 0.24641705f, -0.86873001f, -0.06123613f, 0.03335118f, -0.52190220f, 0.57618344f, -0.19546187f, 
    0.15295339f, -0.61102676f, -0.48181477f, 0.10906917f, -0.41229895f, 0.08519305f, 0.47825730f, 0.30986169f, 
    0.40426669f, 0.26203811f, -0.74278331f, -0.04074143f, -0.03484712f, -0.28275689f, -0.26025993f, 0.06588124f, 
    -0.30180329f, -0.53769606f, 0.99462450f, 0.29222801f, 0.44704622f, 0.18869092f, 0.21855104f, 0.08811688f, 
    -0.11335234f, -0.36097860f, 0.05769878f, -0.12850280f, -0.00223673f, -0.20810468f, 0.57162100f, 0.01543691f, 
    0.18539159f, 0.13480072f, -0.11678715f, 0.32972088f, 0.56327009f, 0.23619984f, 0.49300677f, -0.22690521f, 
    -0.26878795f, -0.48866093f, -0.44399917f, 0.37928191f, -0.06985168f, 0.71426427f, -0.15517443f, 0.14686577f, 
    -0.41552460f, 0.13839561f, 0.36960289f, -0.03542388f, 0.58759779f, 0.07207275f, -0.09671713f, 0.16942562f, 
    -0.26372004f, 0.22323121f, 0.21752100f, 0.13877203f, -0.53185445f, -0.17600828f, 0.17602393f, -0.14119552f, 
    0.35825336f, -0.60784638f, 0.65406561f, 0.15312694f, 0.22383749f, 0.10747612f, -0.24313219f, 0.09002670f, 
    0.01217325f, -0.16339174f, -0.61970901f, 0.45647988f, -0.05189648f, -0.14134304f, -0.52926689f, 0.06050402f, 
    0.02368794f, -0.04329420f, -0.34355989f, 0.06635982f, -0.03521865f, -0.19938323f, -0.35823926f, -0.10276244f, 
    0.06198524f, 0.13268736f, 0.34029666f, 0.49164265f, -0.08910011f, -0.55626130f, -0.65714848f, -0.02197108f, 
    0.00844574f, -0.21462874f, 0.59810972f, 0.43262586f, 0.19906525f, -0.14478277f, 0.63130450f, -0.13091120f, 
    -0.37965965f, -0.14236918f, 0.36184809f, 0.35463017f, -0.45252147f, 0.18578288f, 0.11479783f, -0.21146794f, 
    -0.24752539f, -0.53971481f, 0.80983317f, 0.42799920f, -0.01133966f, 0.24368101f, 0.52546513f, 0.14501508f, 
    0.38313422f, -0.13427360f, 0.34442469f, -0.24894831f, -0.26623264f, 0.18955480f, -0.33216101f, -0.16433863f, 
    0.35384452f, -0.36400434f, -0.29228020f, 0.27950305f, 0.28671864f, 0.13849898f, 0.30633822f, 0.20815103f, 
    -0.29157004f, 0.20618741f, -0.22346044f, 0.48436087f, 0.15035757f, -0.31057718f, -0.63449484f, -0.12340323f, 
    -0.23292509f, 0.03329805f, -0.09291469f, 0.07079504f, -0.24444671f, -0.22407547f, -0.18241939f, -0.02522575f, 
    -0.22384016f, 0.13727570f, -0.25271907f, 0.02804177f, 0.03837192f, -0.07450129f, 0.06864716f, 0.15324725f, 
    0.00138933f, -0.46403232f, 0.58379036f, 0.06365070f, 0.01517753f, -0.11543912f, -0.19018467f, 0.24635299f, 
    0.29988483f, -0.07951830f, -0.20482515f, -0.23545517f, 0.43410581f, 0.14929275f, 0.13472630f, 0.03270425f, 
    0.14129959f, 0.00725585f, 0.22043890f, 0.04461050f, -0.02291738f, 0.20774719f, -0.05829963f, -0.21673842f, 
    -0.01329868f, -0.04802700f, -0.13723971f, -0.20765129f, -0.18319383f, -0.08996926f, -0.09769408f, 0.14465734f, 
    0.29047358f, -0.10090137f, -0.09549887f, -0.00799677f, -0.19006586f, -0.19980162f, 0.09350450f, 0.20198271f, 
    0.37520561f, -0.45026648f, 0.29336187f, 0.40166986f, 0.09204209f, 0.24089797f, -0.52198261f, -0.12137854f, 
    0.16448224f, 0.43866915f, 0.03415800f, 0.15049270f, 0.31501532f, -0.06858587f, -0.45787445f, -0.10071616f, 
    0.29661435f, 0.07157315f, 0.09070155f, 0.14731601f, -0.07481905f, -0.21846481f, -0.48564473f, 0.25404790f, 
    0.30197436f, -0.01507267f, -0.00379629f, -0.03912335f, -0.34049681f, 0.08993952f, -0.39879769f, 0.19887105f, 
    -0.11785574f, -0.07669923f, -0.21166734f, 0.23788454f, 0.22674586f, 0.56143314f, 0.42601424f, 0.02433494f, 
    0.16115279f, 0.06602072f, -0.15851842f, 0.15423937f, 0.55417347f, 0.06793278f, 0.26783165f, 0.15154169f, 
    -0.39178205f, 0.00653189f, 0.17698640f, -0.30234379f, -0.29301247f, 0.11738198f, 0.06960623f, -0.13730049f, 
    0.36237377f, -0.32439655f, 0.43819207f, 0.19495900f, -0.20419002f, 0.04989997f, 0.52765006f, -0.27146778f, 
    0.18452974f, -0.11172582f, 0.20375519f, 0.13875094f, 0.14692956f, 0.05542209f, -0.06182860f, 0.19520523f, 
    0.43122011f, -0.11377383f, 0.53947532f, 0.21856019f, 0.24660346f, -0.17538014f, -0.40501571f, 0.18134829f, 
    0.05721639f, -0.40886602f, -0.07554612f, 0.22806151f, 0.37121633f, 0.08324882f, -0.08041881f, 0.03542988f, 
    -0.33184323f, 0.07123717f, -0.69690698f, -0.03177189f, 0.42316198f, -0.04982666f, -0.15563793f, 0.16555993f, 
    0.23346643f, 0.40101001f, -0.23686165f, -0.38599688f, 0.37876979f, -0.28301194f, 0.11274087f, -0.02127149f, 
    -0.20721458f, -0.39085501f, 0.59870237f, 0.23174970f, 0.24753048f, 0.16833180f, 0.04224475f, -0.03559663f, 
    -0.33766389f, 0.20122039f, -0.07812937f, 0.04046886f, 0.00122848f, 0.14480560f, 0.19525903f, -0.04047482f, 
    -0.17550938f, 0.01642053f, 0.26046684f, 0.63198894f, 0.09962872f, 0.09696438f, -0.24781109f, 0.01097002f, 
    0.46822703f, -0.57747680f, -0.89852905f, 0.40511176f, 0.04864348f, 0.00550179f, 0.15961187f, -0.16520424f, 
    0.06643337f, 0.07159680f, 0.06776386f, -0.21350297f, 0.09099656f, -0.07176492f, -0.16615415f, -0.15461904f, 
    -0.21713260f, -0.17951044f, -0.24426916f, 0.09985322f, 0.11807677f, 0.06120306f, 0.18743530f, -0.19074088f, 
    -0.07314084f, 0.06158290f, 0.72531116f, 0.15556251f, -0.06468608f, -0.22249971f, 0.17184572f, 0.25404969f, 
    0.23626842f, -0.36950004f, -0.14380357f, 0.05282764f, 0.13773842f, 0.24305764f, -0.42688039f, 0.02463510f, 
    -0.03910335f, -0.25514805f, 0.93219739f, 0.53569698f, -0.19892423f, -0.20700420f, 0.34840220f, -0.39943263f, 
    0.51705480f, 0.20341896f, 0.16263737f, 0.00369481f, -0.07265563f, 0.03401900f, 0.21004328f, -0.12631401f, 
    0.25844556f, -0.20002183f, 1.06285000f, 0.05698262f, -0.12460639f, -0.16793039f, 0.33386570f, -0.02030900f, 
    -0.29714355f, -0.02928664f, 0.05154910f, 0.26399028f, 0.00225881f, -0.12808324f, 0.22310944f, -0.10885014f, 
    -0.00718089f, -0.06812054f, -0.59257323f, 0.34225461f, 0.21673582f, -0.06556237f, 0.35852516f, 0.01493845f, 
    0.15683126f, 0.20790020f, 0.04742031f, -0.49720439f, 0.18299215f, -0.38691685f, 0.03032051f, -0.03656165f, 
    -0.16013473f, 0.05541664f, -0.55125368f, -0.05445961f, 0.37174973f, 0.14072128f, 0.14001742f, -0.31260011f, 
    0.23133001f, -0.16111849f, -0.03935723f, -0.37997288f, 0.44816729f, 0.17234139f, -0.12516880f, -0.16121025f, 
    -0.20194370f, -0.06373136f, 0.18079785f, 0.65361166f, 0.08878882f, -0.20842956f, 0.28006506f, -0.07063823f, 
    0.28408474f, 0.06709148f, -0.48536563f, -0.34085920f, -0.34715131f, 0.33316615f, 0.71850520f, -0.06503920f, 
    -0.23837362f, -0.08705842f, 0.34894043f, -0.03242424f, -0.19012009f, 0.04162772f, 0.04575032f, 0.41924605f, 
    0.27877665f, 0.58006454f, -0.03399047f, -0.25401115f, 0.05605491f, -0.16046917f, 0.06638990f, -0.05859074f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17540658f, 0.40866035f, 0.32995078f, 0.21146572f, -0.03220400f, 0.07030504f, 0.07790465f, -0.25470558f, 
    0.38603517f, 0.27636465f, 0.26357749f, -0.23823072f, 0.13862896f, -0.02376912f, -0.15493523f, -0.11221530f, 
    -0.26037297f, -0.03628996f, -0.26842791f, -0.37026486f, -0.23985544f, -0.32369608f, 0.75671452f, 0.02654489f, 
    -0.06154631f, 0.15781905f, 0.41642073f, -0.44873598f, -0.03724593f, -0.23315431f, 0.08946136f, -0.03884768f, 
    0.13838315f, -0.09133609f, 0.67503202f, 0.34758443f, 0.33998927f, -0.17724454f, 0.37439874f, 0.37913689f, 
    -0.19641766f, 0.23754157f, 0.14947003f, 0.01694349f, 0.08982285f, 0.64642668f, -0.01691558f, 0.14224389f, 
    -0.18493406f, -0.22098432f, 0.28167108f, -0.00746526f, 0.06097909f, -0.19094279f, 0.64849049f, 0.55915707f, 
    -0.15360343f, -0.18439387f, 0.06095320f, 0.12431967f, -0.01344939f, -0.07164515f, 0.35920542f, 0.31835878f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.21434468f, -0.27034381f, 0.03443933f, -0.62021977f, 0.40859583f, -0.08183764f, 0.02095962f, 0.27174404f, 
    0.00784998f, -0.17990036f, 0.20364715f, 0.02751756f, 0.19951728f, -0.05318438f, -0.07142362f, 0.12626395f, 
    0.29739207f, -0.30884317f, 0.19692022f, 0.08635791f, -0.04697703f, 0.15894030f, 0.05884219f, 0.01038064f, 
    -0.03177987f, -0.22855970f, 0.24044140f, 0.22723864f, -0.24349006f, -0.18814348f, 0.50745857f, -0.03923637f, 
    0.10426713f, -0.05175715f, -0.93432873f, -0.83614469f, -0.32231677f, 0.46994209f, 0.20148374f, 0.03890074f, 
    0.26725012f, 0.34741199f, -0.71075946f, 0.10704087f, 0.06779706f, -0.71767181f, -0.08840618f, -0.06437292f, 
    0.10540533f, -0.01040690f, 0.12489226f, -0.14737999f, 0.08594473f, -0.13773933f, -0.10487955f, 0.04133883f, 
    0.09253873f, -0.14705218f, -0.47835222f, 0.05762453f, -0.30554730f, -0.45145467f, -0.73634565f, -0.59610540f, 
    -0.06572438f, -0.11756951f, 0.18484986f, -0.06483185f, 0.11758574f, -0.11528645f, 0.11936410f, 0.16194443f, 
    0.06216111f, 0.22585274f, 0.33542731f, -0.56039804f, 0.03268079f, -0.23617640f, -0.05461766f, -0.03350317f, 
    0.08054063f, 0.01943131f, -0.20247981f, -0.95141822f, -0.11241262f, 0.01853522f, 0.17968175f, -0.02244553f, 
    -0.02348980f, -0.33738205f, 0.11285181f, -0.46332538f, 0.12367217f, 0.00605269f, -1.20187283f, -0.35567948f, 
    0.24697852f, -0.19930270f, -0.35322085f, -0.82355851f, 0.41514251f, 0.03769376f, 0.31242356f, 0.28295678f, 
    -0.42863232f, 0.36928651f, 0.35795602f, -0.23985602f, -0.00754292f, 0.04636338f, -0.06847482f, -0.05879262f, 
    0.22953483f, -0.20792811f, 0.11496937f, 0.08910510f, 0.10992570f, -0.30770105f, 0.15969254f, 0.14595699f, 
    -0.04709965f, 0.14867130f, 0.18831468f, 0.17205909f, -0.14067732f, -0.16317290f, -0.26122943f, -0.11989103f, 
    -0.25306138f, 0.10703372f, -0.92611790f, -0.20871720f, 0.30228069f, -0.15026133f, -0.14528184f, -0.51778388f, 
    0.31282440f, -0.40331084f, -0.74374622f, 0.34895644f, 0.05485246f, 0.15188301f, 0.00106434f, 0.33837831f, 
    -0.40675902f, -0.73874259f, -0.13997087f, -0.09301759f, -0.17037001f, -0.46795142f, 0.47285637f, 0.05335559f, 
    0.09822551f, 0.37933210f, -0.19709678f, -0.43220001f, -0.19215183f, -0.03235111f, -0.27939975f, -0.28506985f, 
    -0.24770126f, -0.10609645f, 0.67978519f, 0.32722455f, 0.27177909f, -0.83414745f, -0.01205675f, -0.15969037f, 
    -1.50258219f, -0.61306655f, -0.30723080f, 0.00906063f, -0.05615513f, 0.08313189f, -0.04591720f, -0.23500395f, 
    -0.29182431f, 0.05785618f, -0.09032314f, -0.21272402f, 0.12659736f, 0.11232617f, 0.21507649f, 0.79086161f, 
    -0.00447179f, -0.13955399f, -0.21879187f, -0.04670827f, 0.02796720f, 0.11584097f, 0.45988908f, 0.09274051f, 
    0.19755584f, 0.22464155f, -0.16131434f, -0.01673102f, 0.07758971f, 0.23121004f, -0.07177563f, -0.13432087f, 
    0.27268687f, -0.66462195f, 0.18769823f, 0.33546305f, -0.06567898f, -0.02018487f, 0.08485488f, 0.12390038f, 
    -0.48204812f, 0.43347767f, 0.23285486f, 0.11812950f, -0.08260702f, 0.16034047f, -0.00211758f, 0.05638733f, 
    -0.07816098f, 0.25009245f, -0.03011584f, 0.05474398f, -0.41406620f, -0.42334995f, 0.16737264f, -0.06379555f, 
    -0.80830431f, -0.32847443f, -0.05501474f, 0.19528818f, -0.92545193f, -0.03967564f, -0.01304932f, -0.05374895f, 
    -0.09121370f, -0.60439783f, -0.13448687f, 0.06493302f, 0.09832066f, -0.06380118f, -0.06023712f, 0.00395859f, 
    0.21201159f, -0.35245895f, 0.16532560f, -0.35935256f, 0.11056519f, 0.52220279f, -0.46336895f, 0.00219649f, 
    -0.07282411f, 0.07724324f, -0.46033543f, -0.82209897f, 0.19029473f, 0.81092733f, -0.22846560f, -0.07552988f, 
    -0.05826190f, -0.38957459f, 0.24805263f, -0.05984979f, -0.60984308f, 0.06049721f, 0.28862309f, -0.25254977f, 
    0.05524777f, 0.32343146f, 0.16634014f, -0.57287616f, 0.13248360f, -0.00395732f, 0.11576771f, 0.15169245f, 
    0.15450393f, -1.03808355f, 0.14881833f, 0.46652433f, -0.14371435f, -0.31320494f, -0.13061427f, -0.06684877f, 
    0.05675073f, 0.14284107f, -0.69569790f, 0.33182392f, -0.89469171f, 0.36272231f, -0.14990833f, 0.45669660f, 
    -0.10849028f, 0.05723492f, -0.09441078f, 0.34080294f, -0.68483210f, -0.23762175f, -0.38715160f, 0.19649543f, 
    0.42091817f, -0.15777202f, -0.20885579f, 0.10041026f, -0.11851070f, 0.00413583f, -0.05496917f, 0.16580360f, 
    -0.03143674f, 0.09240799f, -0.47946453f, 0.16108280f, 0.00810417f, -0.25982621f, -0.31084737f, -0.01074961f, 
    0.04833379f, -0.14736651f, 0.01745793f, -0.05023883f, -0.13714272f, -0.46915433f, -0.89882880f, -0.04803847f, 
    -0.33530891f, -0.12217200f, 0.23891215f, -0.09590485f, -0.11564413f, 0.33428359f, 0.33105290f, -0.20565018f, 
    0.05298399f, -0.05495439f, -0.09377030f, 0.08052514f, -0.21217211f, -0.20108469f, 0.03502881f, 0.12138901f, 
    -0.03522220f, -1.16901529f, -0.00913866f, -0.33955446f, -0.07500849f, 0.09232639f, -0.05727940f, -0.06033949f, 
    0.04510115f, 0.05335395f, -0.54860145f, -0.19306861f, 0.24657814f, 0.22067210f, -0.17785650f, 0.01389685f, 
    0.04402005f, -0.18371724f, -0.05803861f, 0.28298303f, 0.04219447f, 0.23434588f, -0.40637171f, 0.13807090f, 
    -0.38984123f, 0.07915252f, 0.13073772f, 0.07547913f, 0.00406894f, 0.21884800f, -0.05544027f, 0.21310608f, 
    -0.36140817f, 0.34998322f, 0.03320175f, 0.19100724f, 0.14073099f, -0.50727236f, -0.03333595f, 0.11132909f, 
    0.09696376f, 0.23379441f, -0.21367264f, 0.19117552f, -0.15119995f, -1.05602956f, -0.10879698f, -0.13642834f, 
    -1.05603194f, 0.29954711f, -2.07837391f, 0.14431459f, 0.25053918f, -0.72546035f, -0.34819147f, -0.49974412f, 
    -0.39252749f, -0.76051539f, -0.36082202f, 0.39227578f, -0.68623590f, 0.11102588f, -0.11138394f, -0.31620353f, 
    0.11538795f, -0.21910261f, -0.14466581f, -0.47743979f, 0.05836801f, -0.33107179f, 0.16364254f, 0.09508839f, 
    -0.00238152f, 0.15570234f, 0.17777741f, -1.15372562f, 0.32779124f, 0.03983652f, -0.09875590f, -0.52448773f, 
    0.33402067f, 0.22845702f, 0.73288369f, 0.21895090f, 0.27665395f, -0.65149570f, -0.07912210f, -0.63539344f, 
    -0.30912369f, -1.13536787f, -0.11478611f, -1.34630108f, -0.08362872f, 0.34291354f, -0.01711266f, -0.53722590f, 
    -0.89304501f, 0.41083202f, 0.02154639f, -0.25270578f, -0.38896549f, 0.34259379f, 0.27601513f, -1.25234330f, 
    0.01080169f, -0.36265469f, -0.04595622f, 0.02299675f, 0.04824613f, -0.23912868f, 0.50253588f, 0.27910367f, 
    0.40086892f, 0.10967146f, -0.35039392f, 0.14569701f, 0.29054329f, -0.10699542f, 0.07158306f, 0.25890270f, 
    -1.22647071f, 0.10945163f, -0.16096088f, 0.65016216f, 0.25162929f, -0.20250623f, 0.09194728f, -0.12156257f, 
    0.16284125f, -0.17846093f, 0.17254543f, 0.52859384f, -0.01034507f, 0.16854875f, -0.96159619f, 0.09809262f, 
    -0.03859380f, -0.95989251f, -0.27272594f, 0.64467031f, 0.00042092f, 0.18785402f, 0.50923675f, -0.08506135f, 
    0.14494246f, -0.37078071f, -0.18692192f, 0.08047349f, -0.84853363f, -0.51243114f, 0.22475699f, -0.28490725f, 
    -0.31004331f, -0.14326796f, 0.02482613f, -1.23573411f, -0.07455497f, -0.46792999f, -0.11544257f, 0.07181168f, 
    -0.63916993f, 0.14486687f, 0.10816243f, -0.21314593f, -0.98473442f, -0.33480823f, -0.12836175f, -0.85561514f, 
    -0.05929688f, 0.18958108f, -0.07173752f, -0.03226086f, -0.25028932f, 0.24124908f, 0.13034034f, 0.07519238f, 
    0.03472874f, 0.06933514f, -0.91143978f, -0.23125511f, 0.60432196f, -0.25995815f, 0.03828632f, 0.36641967f, 
    -0.04454487f, 0.02103293f, -0.74168319f, 0.49350891f, -0.09211511f, -0.57639235f, 0.03776650f, -0.32620713f, 
    -0.48023322f, 0.34723702f, -0.65759629f, -0.70532721f, 0.07388414f, 0.52175647f, 0.15702340f, 0.00037901f, 
    0.00177226f, 0.11238820f, -0.33579096f, -0.61667186f, 0.33156931f, -0.27254656f, 0.30487424f, -0.49325204f, 
    -0.19970647f, 0.00220166f, -0.47078314f, -0.50419426f, 0.13696307f, 0.28722632f, 0.11399557f, -1.34252167f, 
    -0.32503060f, 0.24356318f, 0.03362914f, -0.32572821f, 0.03162993f, 0.07129438f, -0.04269154f, -0.22843799f, 
    -0.05426015f, -0.05859836f, 0.26600716f, 0.05657195f, 0.01631159f, -0.06362191f, 0.14476135f, 0.15261476f, 
    0.08806692f, -0.27395144f, 0.14670222f, 0.12257052f, 0.17361405f, 0.19292933f, 0.45635003f, -0.23282446f, 
    -0.99195737f, 0.22802684f, 0.71091002f, 0.24046814f, -0.57476795f, 0.30841044f, -0.62076265f, -0.66038442f, 
    -0.07150652f, -0.17282853f, -1.01033497f, -0.86624575f, -0.08165745f, 0.42382309f, -0.01250748f, -0.32377601f, 
    -0.42093608f, -0.07142417f, 0.15583558f, -0.35640374f, 0.05099700f, -0.77331895f, 0.26818299f, 0.05646249f, 
    -0.02477176f, 0.18875366f, 0.33819079f, -0.55142468f, -0.18938001f, -0.18472068f, -1.34020770f, -0.71707678f, 
    -0.04170211f, 0.28568304f, 0.14147875f, 0.12913813f, -0.06662464f, -1.52577794f, 0.07893687f, 0.12726995f, 
    -0.25099975f, -0.55019283f, 0.02257224f, 0.27882782f, -0.03625042f, 0.33602452f, -0.02942719f, 0.12554206f, 
    0.13082463f, -0.17593026f, -0.16135679f, -0.17359839f, 0.26727539f, 0.18998200f, -0.03695216f, -0.34934983f, 
    -0.01559989f, 0.24552538f, -0.07806793f, 0.10011726f, -0.01092049f, -0.11490424f, -0.63818699f, 0.28230196f, 
    0.51305276f, -0.30599868f, -0.34513125f, -0.04530868f, 0.12910677f, 0.08814638f, 0.05810212f, 0.00763566f, 
    0.24753474f, 0.58158487f, -0.09039574f, 0.07821828f, 0.14213823f, 0.07746729f, 0.06743232f, -0.57352567f, 
    0.08468723f, 0.01170265f, -0.78785318f, 0.12389801f, -0.12500913f, 0.23202181f, -0.54342949f, 0.04971738f, 
    0.03154735f, 0.08665667f, -0.66925216f, 0.05240212f, -0.68854469f, -0.32003722f, -1.31625330f, 0.44538537f, 
    -0.25602520f, -0.22290041f, -0.03997607f, 0.18375951f, -0.18814956f, -0.06631291f, -0.67238146f, -0.56011230f, 
    -0.10493463f, -0.56293356f, 0.16995136f, -0.86981833f, 0.01279946f, 0.00784202f, -0.00355410f, 0.03484591f, 
    0.10374828f, -0.06322083f, -0.83918631f, 0.18844257f, -0.02213151f, -0.22611584f, -0.41750816f, 0.34272185f, 
    0.03005597f, 0.19301976f, 0.46924326f, -0.18815070f, -0.13874693f, -0.40837449f, 0.52419680f, -0.13843720f, 
    -0.17591053f, -0.14294116f, -0.29755196f, 0.17253974f, -0.86869586f, -0.17971070f, -0.51842749f, -0.43137139f, 
    -0.28236958f, 0.01979612f, -0.73263901f, -0.60115087f, 0.22353947f, -0.29600811f, -0.03077226f, -0.21313834f, 
    -0.47835252f, 0.12985615f, -0.14922771f, 0.54627925f, -0.03408334f, 0.12789775f, -0.54702663f, -0.01969034f, 
    -0.01008705f, -0.04489727f, 0.46565560f, -0.00254505f, 0.19106269f, 0.07087004f, -0.65171361f, 0.65833735f, 
    -0.06610023f, 0.16973817f, -0.25300381f, 0.27165544f, 0.14411628f, -0.49531296f, 0.05182059f, -0.01323936f, 
    -1.20359087f, 0.05714568f, 0.24097374f, 0.24019113f, 0.05137508f, -0.33340320f, -0.11325110f, -0.37791780f, 
    -0.31058356f, -0.94183701f, 0.19257845f, 0.15955114f, -0.73220801f, 0.07176188f, 0.03676163f, -0.50517428f, 
    -0.09679233f, -0.22754598f, 0.25484875f, 0.09412997f, 0.24124458f, 0.11787401f, 0.05261923f, 0.21800756f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26842350f, 0.13768025f, 0.10962666f, -0.09492715f, 0.02011632f, -0.09071634f, -0.11080767f, -0.28790891f, 
    -0.04344122f, 0.15121669f, -0.09198432f, -0.03913428f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
