#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.12782896f, 0.59126121f, -0.55887759f, 0.90550721f, 0.91333306f, 0.01925657f, -0.27467397f, -0.20630305f, 
    -0.32045126f, 0.16677980f, 1.22758198f, 0.31234801f, 0.25249112f, -0.64445668f, -0.08048423f, -0.76402324f, 
    -0.02536386f, -0.33320102f, 0.77612448f, -0.09515706f, -1.02397442f, -0.55923462f, -0.70026010f, -0.28741777f, 
    -0.70088261f, 0.14037164f, 0.20557198f, 1.01966238f, 0.83558643f, 0.79009682f, -0.02045181f, -1.02597833f, 
    -0.10768715f, 0.11617546f, 0.23437746f, 0.27843857f, 0.33788767f, -0.27154091f, -0.88813013f, 0.73072648f, 
    0.18874373f, -0.97166437f, 0.28340238f, -0.56903988f, 0.05009433f, 1.34138906f, -1.03668678f, 0.62075746f, 
    -0.47271168f, -0.61576879f, -0.83339441f, 0.10339385f, 0.07551562f, 0.02501901f, -0.38622338f, -1.31313264f, 
    -0.69967878f, -0.82754546f, 0.81520343f, 0.02062924f, -0.04227436f, -0.14489983f, -0.09450445f, -0.71358389f, 
    -0.94431317f, -0.49319655f, -0.10103179f, -0.88248348f, -0.43264589f, 0.41058847f, 0.26128706f, 0.01885776f, 
    -1.40770793f, 0.18001474f, 0.65211606f, 0.04877644f, 0.84089839f, -0.36334589f, -0.32146236f, -0.13543783f, 
    0.04335790f, -0.72922355f, -0.99080694f, -0.76382047f, 0.46209121f, 0.65356678f, 0.97828406f, -0.07221861f, 
    -0.07302227f, -0.16416104f, 0.87726051f, 0.80084878f, 0.51539761f, 0.27953148f, 0.48286149f, -0.39013284f, 
    0.04981083f, 0.03281944f, -0.47123694f, 0.37865332f, 1.18245268f, 0.70889688f, -0.83561701f, 0.93590260f, 
    0.27811965f, 0.10329882f, 0.38601780f, -0.08046453f, -0.09859242f, 0.75810063f, -0.34503305f, -0.74951375f, 
    -0.51557338f, -0.87053126f, 0.60088706f, 0.16723867f, 0.36934292f, 0.18853419f, -0.90883774f, -0.69491011f, 
    0.00473403f, -0.20310070f, -0.73513150f, -0.49998227f, 0.55139810f, -0.05739674f, 0.13823499f, 0.93122518f, 
    -0.88841319f, 0.30160493f, -0.43653989f, 0.75448406f, 0.42299265f, -0.21132345f, 0.48229146f, -0.44324443f, 
    -0.87482947f, -0.66994584f, 0.82176030f, 0.78943318f, -0.46411115f, -0.10671365f, 0.10917985f, -0.27457356f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20536871f, 0.01335823f, 0.24485192f, -0.10701784f, 0.22235480f, 0.18589060f, 0.13592447f, 0.11926164f, 
    0.10507666f, 0.08250054f, 0.24206997f, 0.12557900f, -0.02816484f, 0.41385368f, -0.12382352f, 0.19626993f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05776161f, -0.00236414f, 0.02922704f, -0.04150504f, -0.03979531f, 0.03142779f, -0.05869142f, -0.04933071f, 
    0.02686323f, -0.03872493f, -0.03384105f, 0.03489203f, 0.00553334f, -0.05846973f, 0.03021419f, -0.00080985f, 
    0.02500446f, 0.04655512f, 0.00690633f, 0.04319600f, -0.05437510f, 0.02966795f, 0.03204482f, -0.00833240f, 
    -0.03511478f, -0.01467101f, 0.01870240f, -0.04881718f, -0.02496750f, -0.04075524f, -0.00032605f, -0.03587992f, 
    0.03039013f, -0.00923896f, -0.03941295f, -0.04499135f, 0.03251365f, 0.03981261f, -0.04755262f, -0.00813853f, 
    -0.01183762f, 0.02232699f, -0.00376629f, -0.01257589f, 0.03375231f, 0.02929946f, 0.00360770f, 0.03941205f, 
    -0.05562015f, -0.01571949f, -0.05098169f, 0.00929850f, -0.01123034f, 0.03260083f, -0.05599711f, -0.01964822f, 
    -0.03162940f, -0.05801246f, 0.04853436f, -0.05275283f, 0.01807976f, 0.02395064f, 0.03647327f, 0.01099555f, 
    0.04097071f, 0.03104650f, -0.02109105f, 0.01572962f, -0.02428160f, 0.04132457f, 0.01262760f, -0.02940171f, 
    0.05217142f, 0.00376925f, -0.02311602f, -0.00516751f, -0.01896288f, -0.04987737f, -0.02429039f, 0.02764073f, 
    0.03334247f, -0.01196192f, 0.05671965f, -0.00877068f, 0.02029373f, 0.02588024f, 0.00114779f, 0.02910954f, 
    -0.05437027f, -0.00736091f, -0.04899031f, 0.03738791f, -0.05013125f, -0.00947278f, -0.01914654f, -0.03370276f, 
    0.02070658f, 0.01248393f, -0.03932022f, -0.02261630f, 0.01492781f, -0.01089617f, 0.03904170f, -0.03831278f, 
    -0.00642120f, 0.04634085f, 0.01223116f, -0.00879828f, 0.01678713f, -0.04553084f, -0.04475710f, -0.03611449f, 
    0.01741202f, -0.05899982f, -0.02119047f, 0.00995931f, 0.01052250f, 0.01947343f, -0.01336126f, -0.04512416f, 
    0.00431150f, -0.03856643f, 0.01477189f, 0.02381127f, -0.01840104f, -0.00299659f, -0.04793401f, -0.05035805f, 
    -0.00721912f, -0.00162613f, 0.00037620f, -0.05479757f, 0.01789262f, -0.00248505f, 0.01355894f, -0.04649338f, 
    -0.03758790f, 0.00065405f, -0.00470121f, -0.03635274f, -0.03185957f, -0.05919598f, 0.03097893f, -0.02622831f, 
    0.04246100f, -0.04523131f, -0.03009425f, 0.01007576f, -0.00174244f, 0.03003724f, 0.01545009f, -0.02372498f, 
    -0.01525621f, 0.01778404f, -0.00384277f, -0.04621573f, -0.02740306f, 0.02828636f, 0.03753398f, 0.04489985f, 
    -0.04709337f, -0.03202730f, -0.01372673f, -0.03450459f, 0.00549427f, 0.01979072f, 0.04618371f, -0.01297984f, 
    -0.02521512f, -0.04631466f, -0.03067857f, -0.05373593f, -0.06167259f, -0.02399066f, -0.03984132f, -0.04208795f, 
    -0.00275060f, 0.01618261f, -0.00221558f, 0.03854030f, -0.00909085f, -0.05611181f, 0.04546465f, -0.00670251f, 
    -0.05077539f, 0.02021518f, 0.01689136f, -0.05490673f, -0.03490280f, 0.00446553f, 0.01529611f, -0.00018600f, 
    -0.00624469f, 0.03256962f, 0.01080350f, -0.01255001f, 0.00675899f, 0.01356757f, -0.05343189f, 0.02480817f, 
    -0.00635158f, -0.00792041f, 0.04866951f, -0.03379629f, -0.03443680f, -0.02746919f, 0.03725882f, -0.00321141f, 
    -0.04861546f, 0.00036760f, -0.02136269f, -0.01563128f, 0.04657543f, -0.01486057f, -0.04450399f, 0.01274327f, 
    -0.04165186f, 0.00114551f, -0.01346217f, 0.02530667f, -0.01285599f, 0.04438895f, -0.02509084f, 0.04908294f, 
    -0.03908419f, -0.01464980f, 0.04427078f, -0.01364631f, 0.02018498f, -0.00086186f, 0.04975568f, 0.02791938f, 
    0.01045526f, 0.01108856f, 0.00445759f, 0.04244548f, -0.02239425f, 0.01878734f, 0.04140592f, -0.05619863f, 
    0.03456908f, -0.03294056f, -0.00912142f, -0.05204068f, -0.00905243f, -0.00029396f, -0.03043439f, 0.02160310f, 
    -0.03393464f, 0.02788484f, -0.02327510f, 0.00947892f, -0.04827241f, -0.01973011f, 0.04119790f, 0.01095432f, 
    -0.04467637f, -0.04245745f, 0.03431413f, 0.02888208f, -0.01308725f, -0.01185434f, -0.02329916f, 0.02103464f, 
    -0.04910562f, -0.03293302f, -0.03018153f, 0.04252995f, 0.02547663f, 0.04203443f, -0.03787737f, 0.04844929f, 
    0.03126681f, -0.01617191f, 0.03259217f, -0.01776406f, 0.04469376f, -0.00970176f, 0.01630685f, 0.02277665f, 
    -0.02749364f, 0.01975968f, 0.02858515f, -0.00059741f, 0.04241294f, 0.01828380f, 0.01619397f, -0.04914676f, 
    0.02967539f, -0.05153748f, -0.00616337f, 0.04711451f, -0.02234494f, -0.00903639f, -0.05208254f, 0.05655639f, 
    -0.05238238f, 0.03426883f, -0.04627347f, -0.01995184f, 0.00232121f, 0.04548767f, -0.03831450f, 0.02038711f, 
    -0.06050486f, -0.02033881f, -0.04561668f, 0.04594887f, -0.01113055f, 0.01241803f, -0.02776560f, -0.05072710f, 
    0.04524708f, 0.01638153f, 0.01446563f, -0.02594810f, 0.02245249f, 0.00273132f, 0.02081628f, -0.04737359f, 
    0.42062896f, 0.11458305f, 0.27204192f, -0.02570587f, 0.19473690f, -0.22647297f, -0.06991757f, -0.17638116f, 
    -0.07091185f, -0.03575521f, -0.04433014f, 0.04734342f, 0.00475186f, -0.01144956f, 0.04002869f, 0.08973645f, 
    -0.00214236f, 0.02955664f, 0.25998503f, -0.00468803f, -0.03440249f, -0.18398151f, -0.07191480f, 0.05120508f, 
    0.16341826f, -0.01435584f, -0.04717651f, 0.05586670f, -0.04885452f, 0.10239933f, -0.00094977f, -0.02915791f, 
    0.00332633f, 0.02198349f, 0.02880788f, 0.01340226f, -0.02935465f, -0.01011445f, 0.04420375f, -0.26068529f, 
    0.13658553f, -0.31288254f, 0.26331908f, -0.21844317f, -0.15238933f, -0.04062415f, -0.00735155f, 0.10574808f, 
    0.08676521f, 0.03353347f, -0.15667216f, -0.09076076f, 0.01881237f, 0.17326130f, 0.06185210f, 0.12846586f, 
    -0.18164395f, 0.01348921f, -0.11322754f, -0.05198404f, -0.17199324f, -0.01757807f, 0.11289015f, 0.26607192f, 
    0.17334394f, 0.05738646f, -0.07405048f, 0.17991214f, -0.02286584f, -0.05261032f, -0.02182636f, -0.12761888f, 
    0.07152392f, 0.13478222f, -0.06716105f, 0.03434076f, 0.05382564f, 0.02752013f, -0.04990250f, -0.12707166f, 
    -0.05803958f, -0.03655154f, -0.22295988f, -0.12440347f, -0.11513557f, 0.23355679f, -0.04336062f, 0.03512597f, 
    -0.03567401f, -0.05345241f, 0.05641354f, 0.10054233f, -0.05313400f, -0.08514719f, 0.06603865f, -0.06453310f, 
    0.13836910f, -0.26629817f, 0.09557277f, -0.04552359f, 0.05103114f, -0.06265201f, 0.14004152f, 0.04738345f, 
    -0.15925916f, 0.04032733f, 0.13509469f, 0.12740745f, 0.02889064f, -0.05276247f, 0.10761759f, 0.08801549f, 
    0.13408041f, 0.06273414f, 0.09190296f, -0.06388959f, 0.00135789f, -0.21696919f, -0.10496061f, -0.06859620f, 
    0.39644605f, -0.42641655f, -0.23202123f, 0.09280931f, -0.05320831f, -0.15799130f, 0.04826731f, 0.08760083f, 
    0.08952785f, 0.16103031f, 0.10579017f, 0.03039448f, -0.16767766f, 0.02197900f, 0.05344320f, 0.06018216f, 
    0.02332419f, -0.07722969f, -0.18556738f, 0.08112608f, -0.06663119f, 0.29025072f, 0.05565370f, 0.06166413f, 
    -0.10211287f, 0.04382949f, 0.08577299f, 0.02393556f, 0.10035210f, 0.11231960f, -0.07489083f, -0.02294751f, 
    0.22008088f, 0.17020936f, -0.21261725f, 0.05879432f, 0.25098476f, -0.21036839f, -0.04773774f, -0.11600860f, 
    -0.40529886f, -0.03583881f, -0.35758486f, -0.07961384f, 0.02923465f, 0.06962188f, 0.04846073f, -0.00225448f, 
    -0.03020691f, 0.04297580f, 0.08824640f, -0.01285405f, -0.00899979f, -0.21656546f, -0.14137901f, -0.07648603f, 
    -0.07413494f, -0.01240045f, 0.18095292f, -0.06445400f, 0.38011435f, 0.02378558f, -0.15396540f, -0.09224562f, 
    -0.27123499f, -0.07039256f, -0.02118009f, -0.03811432f, -0.06303715f, -0.04064178f, 0.02550432f, 0.02727449f, 
    -0.08492117f, -0.01310937f, 0.00257569f, 0.12820372f, 0.19173855f, 0.06846911f, 0.02538648f, 0.16126619f, 
    -0.06976351f, -0.07802750f, 0.10114434f, 0.16321215f, 0.35883442f, -0.01603780f, 0.00118072f, 0.03599022f, 
    -0.00598003f, 0.03110645f, -0.10966590f, -0.15604588f, 0.01906443f, 0.08697600f, -0.01101581f, -0.08258028f, 
    0.10565186f, 0.02284006f, 0.03376577f, 0.00550866f, -0.14301483f, 0.33541965f, -0.07210138f, 0.09266301f, 
    0.11751129f, 0.03815585f, 0.05558756f, 0.06852883f, 0.06343374f, -0.03646961f, 0.12594120f, 0.10402723f, 
    0.03028910f, 0.18317875f, -0.07220763f, 0.07381135f, -0.08167794f, 0.09852687f, -0.05695126f, 0.13470766f, 
    0.05238946f, 0.06393763f, -0.07330704f, 0.08031115f, 0.05145646f, 0.07268297f, -0.09032609f, 0.14772975f, 
    -0.01832119f, 0.17615955f, -0.09935217f, -0.03303272f, 0.06803248f, 0.03853498f, 0.04623038f, 0.16021162f, 
    0.11133884f, -0.21520098f, -0.07015893f, 0.13733867f, 0.03190804f, -0.04733343f, 0.05650429f, -0.07089631f, 
    0.03518718f, 0.03748327f, 0.12333286f, 0.07226494f, 0.06686584f, 0.18025063f, -0.07123470f, -0.07753199f, 
    0.21844165f, 0.04406568f, 0.01160218f, 0.06937850f, 0.11634897f, -0.11704733f, -0.00969611f, -0.11488058f, 
    0.03787721f, 0.22164941f, 0.06250318f, 0.02146185f, 0.05356897f, -0.06585432f, -0.10921964f, 0.04994395f, 
    -0.09291020f, -0.07511827f, 0.13509308f, -0.17127453f, -0.19954322f, 0.06279224f, -0.03982323f, -0.05190425f, 
    0.21758702f, 0.06567527f, 0.26153871f, 0.12931262f, 0.18744642f, -0.00834742f, -0.37598839f, 0.02042819f, 
    -0.17009601f, 0.13175173f, -0.01959784f, 0.01344383f, -0.03135183f, 0.13142538f, 0.03184053f, -0.03367477f, 
    -0.05666012f, -0.04236925f, -0.00856559f, 0.11261094f, 0.04902280f, -0.02680154f, 0.03150811f, 0.03291616f, 
    -0.12807254f, -0.22578759f, -0.02149087f, 0.09490428f, -0.13969897f, 0.14092395f, 0.11584838f, 0.07079284f, 
    0.02307381f, 0.01017633f, 0.04965346f, -0.02804737f, 0.07822723f, -0.14353096f, -0.00430865f, -0.09680246f, 
    0.06983085f, 0.11374248f, 0.12164298f, -0.00753463f, -0.19242615f, -0.17625390f, -0.04251578f, -0.14623518f, 
    -0.04684793f, 0.20477396f, 0.20200530f, -0.15700600f, 0.00069281f, 0.03301132f, 0.16592446f, -0.09769923f, 
    0.05848180f, -0.05397359f, 0.06366474f, -0.01105229f, 0.01618977f, -0.04724934f, -0.12177169f, 0.20054476f, 
    -0.30763048f, 0.20241281f, -0.17168078f, 0.00201944f, 0.01319104f, 0.04751529f, 0.03933297f, -0.00013758f, 
    0.05989408f, -0.02401971f, 0.10246763f, 0.15577328f, -0.08130950f, -0.00984121f, 0.04206393f, 0.02408049f, 
    0.18990181f, -0.10415644f, -0.02326475f, -0.09656104f, -0.08852170f, 0.10319244f, 0.14724708f, -0.34063450f, 
    -0.07202364f, 0.09985720f, 0.01682955f, -0.11644418f, -0.05154938f, 0.12122315f, 0.11207110f, 0.15306847f, 
    -0.01454464f, 0.03196901f, 0.01893261f, 0.04559705f, -0.02017190f, -0.13579293f, -0.05975014f, 0.06402350f, 
    0.22945277f, -0.44389153f, 0.18674843f, 0.10089587f, -0.24511878f, 0.10388819f, 0.00296459f, 0.07970250f, 
    -0.03631070f, 0.14879875f, -0.02678478f, 0.02296119f, 0.05552708f, 0.03809739f, 0.10125129f, -0.01407456f, 
    -0.06420892f, -0.11654905f, 0.08589922f, -0.06218636f, -0.15606688f, 0.04154659f, 0.01970308f, -0.39126310f, 
    -0.20331866f, 0.23882206f, -0.02698754f, -0.07691053f, -0.08474512f, -0.05410145f, 0.08219637f, 0.12461633f, 
    0.06150839f, -0.01594971f, 0.05625134f, 0.01652164f, 0.20180210f, -0.03820002f, -0.00284598f, 0.03127329f, 
    0.32507136f, -0.07550129f, -0.04497248f, 0.10564608f, -0.12345985f, -0.23145133f, -0.09662251f, -0.04228146f, 
    -0.07228632f, 0.05921476f, 0.02400372f, 0.02162729f, 0.12165030f, -0.00931869f, 0.05890997f, -0.04052188f, 
    0.04961516f, -0.00405627f, -0.03053237f, 0.03724837f, 0.34990546f, 0.00636082f, 0.13684347f, -0.27234128f, 
    -0.25234687f, -0.05303385f, -0.03484786f, 0.16257006f, -0.08115188f, -0.09728681f, -0.03787318f, -0.08870448f, 
    -0.14122154f, -0.02229365f, -0.09883973f, 0.06026198f, 0.07697406f, -0.11669575f, 0.14247522f, 0.07091034f, 
    0.16023956f, -0.28246930f, -0.16769393f, -0.09831427f, 0.35022047f, -0.12221363f, -0.09435071f, -0.02665335f, 
    0.03694000f, 0.14173761f, -0.02798319f, 0.06007633f, 0.05010168f, 0.05247927f, 0.11607401f, 0.06639957f, 
    0.00690562f, -0.06413553f, -0.08797704f, -0.02045540f, 0.22999957f, 0.05483619f, 0.16278574f, 0.28368831f, 
    0.01476371f, -0.04943330f, -0.16286410f, -0.17839305f, 0.10337789f, 0.08034518f, 0.06132469f, -0.07734363f, 
    -0.11261368f, 0.06750354f, 0.04572323f, -0.18491927f, 0.00426630f, -0.11928183f, -0.06794633f, 0.03385329f, 
    0.10886796f, -0.00075806f, 0.08171093f, -0.19277716f, -0.16743748f, 0.11817876f, 0.03138452f, 0.03536566f, 
    -0.08337501f, 0.18292727f, 0.08933914f, 0.03230078f, -0.04896170f, -0.02375978f, 0.01272970f, 0.01698512f, 
    -0.01188018f, 0.05728910f, -0.03261127f, -0.01764891f, 0.26238737f, 0.01343300f, -0.29137218f, 0.02984767f, 
    0.05775534f, 0.17050773f, -0.00637182f, -0.10846163f, 0.02196883f, 0.12608810f, -0.04078759f, 0.03151989f, 
    -0.09984947f, -0.06023974f, 0.13485429f, 0.09796031f, 0.00638310f, 0.13720822f, -0.03563976f, 0.06933231f, 
    0.09660094f, 0.12326347f, -0.25938022f, -0.28923833f, 0.05672879f, 0.11468674f, 0.05995602f, 0.13250946f, 
    0.06433368f, -0.00898810f, 0.10170629f, 0.10557610f, 0.10728414f, -0.09519837f, -0.00981208f, 0.09134001f, 
    0.00373698f, 0.14108187f, 0.01956054f, -0.02375861f, 0.19316553f, 0.01200541f, 0.04843968f, -0.17487440f, 
    -0.20286192f, -0.00458116f, -0.01923142f, 0.07374390f, 0.01823362f, -0.08300939f, 0.05392831f, -0.08404310f, 
    -0.01229746f, -0.01481574f, -0.03572741f, 0.09501917f, 0.01245327f, -0.07834762f, 0.01056372f, 0.17048042f, 
    0.04940781f, -0.37495777f, 0.01860780f, -0.07216984f, 0.30851802f, 0.13080873f, 0.05372549f, 0.03874614f, 
    0.04430051f, -0.15469807f, -0.00839361f, 0.12589693f, 0.16912535f, 0.11789509f, 0.14231458f, 0.04789089f, 
    0.06906512f, 0.15307598f, -0.00455833f, 0.06726042f, 0.45270640f, -0.19123498f, 0.18954861f, 0.16349936f, 
    -0.12687740f, -0.03763214f, -0.03922825f, 0.05045789f, 0.07779443f, 0.03074823f, 0.04984134f, -0.03154480f, 
    -0.14488184f, 0.14889745f, -0.04716001f, -0.08697146f, -0.06199473f, 0.07501754f, 0.06210545f, -0.04327256f, 
    0.10004458f, -0.09923228f, 0.16915216f, -0.15210731f, 0.09910034f, -0.07879944f, 0.17397602f, 0.01494113f, 
    -0.06865714f, 0.00135115f, 0.06354951f, 0.10710462f, -0.05775553f, -0.02932608f, 0.02522141f, -0.13455974f, 
    0.14856201f, -0.04621302f, 0.06447405f, -0.00699988f, 0.02366849f, 0.07013218f, 0.12369011f, -0.03484361f, 
    0.07659805f, 0.04084432f, -0.26241037f, -0.07503132f, -0.07361136f, -0.12132037f, 0.05485793f, -0.06307191f, 
    -0.10172753f, -0.01162744f, 0.08886140f, 0.05840417f, 0.00722243f, -0.10045531f, 0.10129672f, 0.05329200f, 
    0.00058361f, 0.00872905f, 0.11283094f, 0.04734493f, 0.38921052f, -0.00318967f, -0.06012698f, 0.07235266f, 
    -0.02850125f, -0.04562785f, -0.04366301f, 0.04947238f, 0.09764151f, 0.06593198f, 0.04535953f, -0.07386913f, 
    0.01658778f, -0.13654776f, -0.07953068f, -0.07121468f, 0.51598454f, 0.06850823f, -0.05781446f, -0.24245650f, 
    0.03671352f, -0.12018042f, -0.24701305f, -0.03273343f, 0.05844922f, 0.00693244f, 0.10800698f, -0.09182694f, 
    0.07159065f, 0.18261975f, -0.08536785f, 0.13140219f, 0.01273840f, 0.05680712f, 0.04466649f, 0.13224353f, 
    0.21783373f, -0.04592776f, 0.04692983f, 0.09695131f, 0.22292693f, 0.00049843f, -0.02063964f, 0.12576108f, 
    0.08978885f, 0.02576143f, 0.04727542f, 0.07056665f, 0.01665170f, -0.16031255f, -0.07749095f, -0.01383702f, 
    0.07440257f, -0.26161018f, -0.01972489f, -0.07390679f, 0.19993834f, -0.14177836f, -0.09291355f, 0.15418409f, 
    0.17742567f, 0.01159258f, -0.21356328f, -0.11812385f, 0.07072016f, -0.00226622f, -0.09037492f, 0.09606885f, 
    -0.00810613f, 0.07690030f, 0.09539063f, -0.05244073f, -0.11367203f, -0.17569217f, -0.03566260f, -0.10765513f, 
    -0.14637637f, 0.15632245f, 0.01931652f, -0.08264306f, -0.14865306f, 0.09190372f, 0.07306976f, -0.05712620f, 
    -0.02080959f, -0.11059829f, 0.05982034f, 0.20061052f, -0.09337418f, -0.08282150f, -0.10480142f, -0.10736508f, 
    -0.06269570f, -0.06476244f, -0.24926245f, 0.00346745f, 0.02702405f, -0.21497162f, 0.05955154f, 0.10787024f, 
    0.03827019f, -0.03620267f, -0.08401130f, 0.11079305f, 0.05694729f, -0.06423543f, 0.00426072f, -0.05332423f, 
    -0.03072888f, 0.14776500f, -0.00364567f, 0.18547592f, 0.05718916f, -0.00833147f, 0.04373845f, -0.10424557f, 
    -0.38474628f, 0.20254251f, 0.37915054f, 0.21456921f, -0.13227734f, -0.02208592f, 0.17658855f, 0.10094965f, 
    -0.02280213f, -0.05858590f, -0.10911076f, 0.18506533f, 0.05451417f, -0.06880319f, -0.10238321f, 0.04309997f, 
    -0.18078573f, 0.01287079f, -0.00561490f, 0.06179415f, 0.13882840f, 0.36955875f, 0.07117999f, -0.19292188f, 
    -0.34342867f, 0.24930929f, 0.18017803f, -0.01400385f, 0.05307723f, -0.16090152f, 0.07796830f, 0.03270948f, 
    -0.18527196f, 0.03925016f, -0.15901725f, 0.01353260f, 0.09712061f, -0.06180342f, -0.07293971f, -0.00241914f, 
    0.26160589f, -0.25570709f, -0.21849117f, -0.01303407f, -0.00827536f, -0.16906820f, 0.01411285f, 0.05774688f, 
    -0.10313823f, -0.06089700f, 0.07355849f, 0.12685892f, -0.09123784f, -0.00421471f, -0.02198992f, 0.03966267f, 
    0.01645806f, 0.04724776f, 0.00948081f, 0.01805172f, 0.49791920f, -0.07619488f, -0.25657156f, -0.21890323f, 
    0.00441163f, -0.07612078f, -0.02858695f, -0.12545119f, -0.01948669f, 0.15320593f, 0.06548814f, -0.00466768f, 
    -0.03430159f, -0.03575641f, 0.17197046f, -0.04301822f, 0.07813907f, 0.18015835f, 0.01016345f, 0.12481246f, 
    0.15767463f, 0.00732774f, -0.01766287f, 0.15075126f, 0.15962844f, -0.08577421f, -0.08302823f, 0.09024119f, 
    0.14347360f, 0.10190527f, 0.10731737f, 0.04405268f, 0.10366897f, 0.11039154f, 0.14013910f, -0.05075809f, 
    0.03855851f, -0.09191212f, -0.00187781f, -0.07264923f, 0.20152707f, -0.31995925f, -0.03022820f, 0.04470043f, 
    0.04899289f, 0.00134227f, -0.04154934f, 0.14687461f, 0.03733500f, 0.11631559f, 0.04839110f, 0.04947134f, 
    0.11771145f, -0.05564458f, 0.00766602f, -0.13599926f, 0.10479774f, -0.10060831f, -0.05444500f, -0.01699933f, 
    -0.29258791f, -0.15935653f, 0.14684941f, -0.13007291f, 0.20368965f, 0.07648659f, 0.19232354f, -0.21784602f, 
    -0.05199963f, 0.17384048f, 0.14238700f, -0.03137605f, -0.12393159f, 0.07232234f, -0.01858288f, 0.13763660f, 
    0.09950134f, 0.12826887f, -0.16613744f, 0.21198897f, 0.14952831f, 0.26671338f, 0.01970449f, 0.08560673f, 
    -0.12844387f, 0.09126403f, 0.10050060f, 0.09395812f, -0.08140555f, -0.09394792f, -0.06940333f, -0.07137242f, 
    0.00763939f, -0.06301957f, -0.06134782f, 0.00714739f, 0.05664177f, -0.06194281f, -0.00907667f, -0.01566507f, 
    -0.02273624f, 0.03526536f, -0.04255650f, 0.00079439f, 0.02031510f, -0.02997591f, -0.01484816f, -0.02843510f, 
    0.00919556f, 0.04473310f, -0.05484597f, 0.00186199f, 0.03964830f, -0.01052491f, -0.00109538f, -0.03495931f, 
    -0.05667899f, -0.01337891f, -0.05201639f, -0.01321743f, -0.02687646f, 0.01942415f, -0.03837500f, -0.02496232f, 
    0.01489304f, 0.01817164f, -0.01377854f, -0.02439344f, -0.03346549f, 0.01893848f, 0.02989406f, -0.02117841f, 
    0.05155068f, -0.04570877f, -0.00763337f, -0.01995703f, -0.05012931f, -0.03688744f, 0.04389204f, -0.02733096f, 
    -0.03769117f, -0.02804242f, -0.00351772f, 0.00824948f, -0.00268399f, 0.00075373f, 0.03101969f, 0.03977421f, 
    -0.03111086f, 0.01674884f, -0.02252353f, 0.03885612f, 0.03957134f, -0.00400690f, 0.03656559f, 0.03923934f, 
    -0.01759680f, 0.00580982f, 0.01158168f, 0.00989196f, -0.00329835f, -0.01154556f, -0.00164655f, -0.02582345f, 
    0.03233145f, 0.00756921f, -0.04115092f, -0.05045278f, 0.04836737f, -0.01297932f, -0.00037161f, -0.01914210f, 
    -0.02584162f, -0.01973769f, -0.04170914f, 0.02849622f, 0.01569751f, -0.03246250f, -0.04797132f, -0.04421018f, 
    0.06111315f, -0.04651130f, 0.03296892f, -0.03837685f, -0.03172171f, 0.05306772f, -0.02789847f, -0.02058198f, 
    -0.04880766f, -0.04521627f, 0.03481300f, -0.04151411f, 0.00554778f, 0.04286334f, -0.03002436f, -0.04844553f, 
    -0.04583702f, 0.04918548f, 0.03919424f, -0.03879197f, 0.00807143f, -0.03178202f, 0.02800275f, 0.03500465f, 
    -0.01176878f, -0.03907745f, 0.01434124f, -0.00629942f, -0.01099191f, -0.03085614f, -0.03530294f, -0.04690962f, 
    0.04128379f, 0.00671134f, -0.05340449f, 0.04212743f, 0.03298732f, -0.02724258f, 0.03744964f, 0.04761310f, 
    -0.05085494f, -0.04697119f, -0.05902582f, -0.05010948f, -0.03423384f, -0.00260132f, 0.04703755f, -0.03945407f, 
    -0.05762646f, -0.00567240f, 0.00151075f, 0.04803204f, -0.04257156f, -0.00435737f, 0.04258805f, -0.00275423f, 
    0.03128548f, -0.04870570f, 0.01574202f, -0.03662039f, 0.02564051f, 0.02167379f, 0.04504352f, -0.05450819f, 
    -0.00672053f, 0.03688949f, 0.03519822f, 0.02962298f, 0.05442834f, 0.01072249f, -0.02796756f, -0.05298413f, 
    -0.04919479f, -0.04530370f, -0.01087337f, -0.04779955f, 0.00975673f, -0.00282425f, 0.04150759f, -0.02393632f, 
    0.04644067f, -0.04648377f, 0.00128021f, 0.03387176f, 0.02173141f, -0.02096689f, -0.05736504f, -0.01514954f, 
    -0.03677159f, -0.03626203f, -0.01659473f, -0.05898036f, 0.00104496f, -0.04847382f, 0.05004712f, 0.01021835f, 
    0.02500116f, 0.02697404f, 0.04165613f, 0.00671428f, 0.03484598f, -0.04745359f, -0.01037672f, 0.00797650f, 
    0.01545558f, -0.00625986f, -0.01693299f, -0.01172266f, 0.00925802f, -0.03646032f, -0.04228357f, -0.00800430f, 
    -0.03902953f, 0.03167115f, 0.03874024f, 0.02504728f, 0.00530630f, 0.02161971f, 0.00037507f, 0.04211724f, 
    0.02617433f, 0.02922880f, -0.00317790f, -0.01163000f, -0.04897903f, -0.05845957f, 0.04864639f, -0.03812760f, 
    0.03257722f, -0.00752618f, 0.04318247f, -0.02774580f, 0.02328325f, 0.02989748f, -0.06325423f, 0.04970604f, 
    0.02488704f, -0.04775234f, 0.01704252f, 0.03820649f, 0.02091740f, 0.02307006f, -0.03055997f, 0.04507063f, 
    -0.02134853f, 0.03372826f, 0.04319946f, -0.04397273f, -0.03074536f, -0.04743467f, -0.01808032f, -0.00612187f, 
    -0.01100168f, -0.05679050f, -0.04639837f, 0.04554510f, -0.00531211f, -0.04602678f, -0.01895848f, -0.00200922f, 
    -0.03025990f, -0.01068385f, 0.01916214f, -0.00430512f, 0.02028075f, -0.00408375f, -0.00416872f, -0.03950605f, 
    -0.04236931f, -0.01197688f, -0.02617365f, 0.02038840f, -0.06184545f, -0.01385896f, -0.05287034f, 0.04789402f, 
    0.02807837f, 0.01826035f, 0.01685819f, -0.05915448f, -0.01865470f, -0.06095486f, -0.04073148f, -0.01398505f, 
    -0.02464547f, -0.01803455f, -0.04278580f, -0.04371171f, 0.01848675f, -0.01694452f, -0.01865767f, 0.01723499f, 
    -0.03023223f, 0.02596780f, -0.01235453f, 0.01764817f, -0.00718389f, 0.02078795f, 0.04959969f, -0.03490383f, 
    -0.05459839f, -0.00666032f, -0.04868310f, -0.03387277f, -0.05611530f, -0.01113141f, 0.01060593f, -0.00126081f, 
    0.02515887f, -0.04518185f, 0.03012021f, 0.01462816f, -0.04521885f, -0.01565248f, -0.00141327f, 0.00584245f, 
    0.00785078f, 0.02603992f, 0.03179304f, 0.03104955f, -0.01759440f, 0.01245839f, -0.01751809f, -0.03969869f, 
    0.02767657f, 0.02281779f, 0.04169188f, -0.03973529f, -0.03196182f, -0.04267527f, -0.02770096f, 0.01465599f, 
    -0.03908773f, 0.01641161f, -0.03669596f, -0.04608348f, 0.04398516f, 0.04038865f, -0.01903366f, -0.02905055f, 
    -0.39609239f, -0.17557238f, -0.26199809f, -0.08376716f, -0.25686526f, 0.03600224f, -0.09029462f, 0.00904299f, 
    -0.00062306f, 0.10434212f, -0.03499942f, -0.08644417f, 0.06610601f, 0.00407012f, 0.04105515f, 0.08448986f, 
    -0.04364595f, -0.00926477f, 0.02727634f, 0.12833442f, -0.33433294f, 0.10033786f, -0.24454424f, 0.01666399f, 
    -0.31314853f, 0.07447471f, 0.19089530f, 0.03282979f, -0.03538353f, -0.03281528f, 0.13426228f, 0.18646553f, 
    0.00378031f, 0.02264220f, -0.12010524f, -0.04345941f, -0.03503048f, 0.11584265f, -0.06883436f, 0.04925119f, 
    0.19024828f, 0.24152088f, 0.11153416f, -0.10172610f, 0.19168887f, 0.09513025f, 0.12778017f, -0.08202448f, 
    0.01207448f, 0.05609888f, 0.19479591f, 0.04097111f, 0.00298755f, -0.06000781f, -0.09695190f, 0.00680411f, 
    0.06026424f, 0.11927167f, -0.11585154f, 0.04388926f, -0.55264378f, 0.00050872f, -0.34719595f, -0.00281408f, 
    -0.10214240f, 0.21897735f, -0.03045700f, 0.10173052f, -0.08013049f, -0.14947049f, -0.18766040f, 0.13462698f, 
    -0.04184055f, -0.03956322f, -0.01122970f, -0.10103233f, -0.04715230f, -0.00565484f, -0.06250567f, -0.02559275f, 
    0.09685514f, 0.12966457f, 0.03910914f, -0.02349529f, 0.07719701f, -0.04561920f, 0.12994958f, -0.07476557f, 
    -0.00437470f, 0.11384052f, 0.03917681f, -0.08532971f, -0.01854576f, 0.03752877f, -0.03157208f, 0.17803419f, 
    -0.02063080f, 0.23405699f, 0.04382208f, 0.06142176f, -0.25396079f, 0.48837507f, 0.00142569f, -0.00114579f, 
    0.44887671f, -0.01385589f, 0.02270856f, 0.05642303f, 0.08950470f, 0.17009911f, 0.03073164f, 0.01556152f, 
    0.09491769f, -0.08950042f, -0.05782841f, 0.16098140f, 0.02573314f, 0.02179955f, 0.01953215f, 0.09022987f, 
    0.48275453f, -0.08057068f, 0.22639519f, -0.10860296f, 0.20361638f, -0.06727356f, 0.15815145f, 0.15874410f, 
    -0.02300134f, -0.09761994f, -0.02820696f, -0.09117565f, 0.04910649f, -0.01171923f, -0.11985601f, 0.18736596f, 
    0.14224845f, -0.01257746f, 0.06919715f, 0.07026685f, 0.21441928f, 0.23791653f, 0.00415316f, -0.15132405f, 
    0.01551921f, -0.04432967f, -0.00354410f, -0.04564241f, -0.18850718f, 0.05426395f, -0.16480912f, 0.12789492f, 
    0.01428014f, -0.14534429f, 0.10675813f, -0.01034233f, -0.03287056f, 0.13899139f, -0.08447845f, 0.07959032f, 
    0.36542878f, -0.00720049f, -0.21319188f, 0.15779497f, 0.15153684f, 0.05385701f, -0.03181265f, -0.02657556f, 
    0.10348120f, 0.09532584f, -0.01939057f, -0.05436645f, 0.14396186f, 0.02607325f, 0.11731909f, 0.04981462f, 
    0.06751405f, -0.00943372f, 0.12229807f, 0.04048466f, 0.29180309f, -0.20189127f, 0.27704868f, 0.04245801f, 
    0.24970444f, -0.24790546f, -0.10342647f, 0.13388416f, 0.07230236f, 0.01603191f, -0.06095717f, 0.01436015f, 
    0.09263010f, 0.03687098f, 0.00917703f, -0.07229754f, 0.00659621f, 0.03220516f, 0.00937421f, -0.08280537f, 
    -0.40014005f, -0.21280436f, -0.32744622f, -0.06778874f, -0.43044800f, 0.12175246f, -0.06944630f, 0.02950750f, 
    0.00117485f, -0.06830192f, -0.03343092f, -0.03859988f, 0.10321689f, 0.14300190f, -0.06923560f, 0.04188786f, 
    -0.08396254f, -0.01297325f, -0.05020981f, 0.00667554f, -0.45929754f, 0.01569257f, -0.19223851f, 0.08119612f, 
    -0.25070512f, 0.03591329f, -0.01473963f, 0.04500087f, 0.03567033f, -0.13440156f, -0.17160729f, 0.00340643f, 
    -0.05259316f, 0.13001673f, -0.06437153f, 0.10517112f, 0.04851915f, -0.03434929f, -0.00190024f, 0.13290834f, 
    0.30124155f, 0.37927982f, 0.06556701f, -0.04545691f, -0.06434480f, 0.15838483f, 0.09315915f, -0.09225670f, 
    0.03734068f, 0.06141935f, -0.10251290f, 0.07908543f, -0.05291957f, -0.08814473f, -0.10106342f, 0.08467952f, 
    0.10293556f, 0.06169442f, 0.04397902f, -0.02895197f, -0.02786099f, 0.09434110f, -0.05036930f, -0.18087645f, 
    0.07461964f, -0.04440422f, 0.03986280f, -0.13701624f, -0.03863807f, -0.01158342f, 0.09421038f, 0.07575575f, 
    -0.05979576f, -0.03737000f, 0.00445293f, 0.05638009f, 0.03515875f, 0.10939352f, 0.04385963f, -0.08347093f, 
    -0.34109503f, 0.13496423f, -0.11186060f, 0.23796391f, -0.08043515f, 0.01738473f, 0.10147525f, 0.11609685f, 
    -0.00313250f, 0.12413712f, 0.08623245f, -0.02534139f, -0.08279205f, -0.05779549f, 0.05886320f, -0.06045100f, 
    0.00818801f, 0.06948394f, 0.10949133f, -0.00254990f, 0.24240321f, 0.01482277f, 0.23886012f, -0.01018074f, 
    0.27844664f, -0.07123730f, -0.00267072f, 0.01048179f, 0.17996758f, 0.02648503f, -0.03482058f, 0.05431323f, 
    -0.06787142f, 0.04258476f, -0.00444181f, -0.01277814f, -0.10170656f, 0.03821328f, 0.06634333f, 0.05387908f, 
    -0.36779687f, -0.01779836f, -0.02587610f, -0.13605005f, -0.22794287f, 0.16560999f, -0.04918722f, 0.08811136f, 
    0.04903970f, 0.05728973f, 0.00840681f, 0.01544507f, 0.02864532f, 0.09962980f, -0.04846706f, 0.04787868f, 
    0.04024365f, 0.02790190f, -0.12015268f, 0.09074879f, 0.26278186f, -0.34036252f, -0.11522283f, -0.05819874f, 
    0.07084588f, -0.11252872f, 0.09490220f, 0.09386159f, -0.03996134f, 0.01528438f, -0.03928474f, -0.01865348f, 
    -0.04253529f, 0.14076568f, -0.01339886f, 0.09513476f, 0.05409157f, 0.09315827f, -0.00017755f, 0.03537502f, 
    0.05616169f, 0.08955815f, -0.09185892f, 0.28636330f, 0.05301771f, -0.01611659f, -0.04475944f, -0.01606139f, 
    -0.00547159f, 0.06220498f, 0.01067686f, 0.12930316f, 0.00512698f, -0.10054134f, 0.04448676f, 0.11452800f, 
    0.05655219f, 0.04070109f, 0.09305556f, 0.05424437f, -0.04987728f, -0.57302010f, -0.02961095f, -0.03139843f, 
    0.12227491f, -0.11681824f, 0.10697509f, 0.00065998f, -0.09312042f, 0.02377676f, 0.11107904f, 0.07029905f, 
    -0.18034604f, -0.05983693f, -0.08917942f, -0.09535565f, -0.09417419f, -0.03464743f, -0.04204530f, 0.12428597f, 
    0.11651019f, -0.00719383f, 0.11950754f, 0.08191213f, -0.02159238f, 0.04567034f, -0.08981500f, 0.15866145f, 
    -0.00862696f, 0.18898644f, -0.12829973f, -0.15218370f, 0.03826414f, 0.05166525f, 0.06342610f, -0.03124443f, 
    -0.06620294f, 0.11930336f, -0.13096987f, 0.06098662f, -0.14262724f, -0.05316763f, 0.20911217f, 0.14516100f, 
    -0.13242811f, -0.00744402f, 0.17530246f, -0.04171115f, 0.07535990f, 0.02784608f, 0.06840852f, -0.05892833f, 
    -0.10052425f, -0.04428308f, -0.10403895f, -0.04117868f, 0.07691928f, 0.16892619f, -0.06560016f, -0.00834032f, 
    -0.38991854f, 0.20183203f, 0.06408716f, 0.39672020f, -0.01370504f, -0.00851559f, -0.24004139f, -0.11175119f, 
    0.13627917f, 0.19042274f, -0.11464532f, 0.11765846f, -0.05740301f, 0.03682842f, 0.10820321f, -0.06735544f, 
    0.11811733f, 0.20804521f, 0.22304715f, -0.16217983f, 0.37553123f, -0.06341141f, -0.15740755f, 0.23611329f, 
    0.02051618f, 0.10503083f, 0.09619286f, -0.02643478f, 0.03879875f, 0.09813015f, 0.01590959f, -0.10518170f, 
    -0.05846018f, -0.10664067f, 0.03461073f, 0.00946646f, 0.10882168f, 0.12473524f, 0.04974111f, 0.05662194f, 
    -0.16750765f, 0.64274395f, 0.04910791f, -0.04770580f, -0.04778889f, -0.01948404f, -0.09499514f, 0.04506905f, 
    0.17859334f, -0.08230538f, 0.02304793f, 0.02717454f, 0.07760162f, 0.10711535f, -0.02030716f, -0.08633137f, 
    0.03902566f, -0.08459937f, 0.05657629f, -0.01485702f, -0.05585862f, 0.03533013f, -0.21022524f, 0.23421790f, 
    0.08968265f, 0.10684678f, -0.06564549f, 0.10962860f, 0.01023977f, 0.16481987f, -0.07860784f, 0.05959973f, 
    0.13221818f, -0.04433437f, 0.04921119f, 0.01113055f, -0.01273390f, 0.17799750f, 0.07272107f, -0.09131092f, 
    -0.13149296f, -0.17675984f, 0.04000456f, -0.31345618f, 0.01575150f, -0.06365067f, 0.06364502f, 0.03944954f, 
    -0.00972875f, 0.08818792f, 0.07945374f, 0.07170036f, -0.08756231f, -0.03306863f, 0.01591756f, 0.09614383f, 
    0.08474452f, -0.02521561f, -0.04967488f, 0.04393641f, -0.40705070f, -0.22087309f, 0.11963946f, -0.12102566f, 
    0.11174959f, -0.05201798f, 0.07836861f, 0.10391520f, -0.06197057f, 0.01301589f, 0.01250269f, 0.03096606f, 
    -0.01747405f, -0.04557253f, 0.06118732f, -0.03022576f, -0.07768566f, -0.08462521f, 0.00684575f, 0.02713693f, 
    0.17143185f, -0.16556010f, 0.12111131f, 0.14769612f, -0.03323032f, -0.10557520f, 0.11803893f, 0.08324439f, 
    -0.14770915f, 0.04234127f, -0.01789491f, 0.03111663f, -0.00969629f, -0.11761639f, 0.07674552f, -0.20114729f, 
    -0.00946799f, 0.14754516f, -0.03208816f, 0.04612406f, 0.11059500f, 0.23833764f, 0.00114304f, 0.43244359f, 
    -0.15911919f, 0.03082367f, 0.01873115f, -0.10827321f, -0.00113385f, 0.05600859f, 0.08918945f, 0.13456209f, 
    0.01612919f, -0.06762007f, -0.01078323f, 0.09903974f, -0.13242842f, 0.04731076f, -0.03270897f, 0.10418045f, 
    0.42853498f, -0.26352081f, -0.07497563f, -0.05262584f, -0.00106990f, -0.06276875f, 0.11557543f, 0.22428872f, 
    0.02262648f, -0.09700912f, -0.05779542f, 0.04021869f, 0.05864404f, -0.09277202f, 0.12574205f, 0.01645029f, 
    -0.09134772f, 0.02218892f, -0.00418425f, 0.03493242f, -0.24326566f, 0.07923590f, 0.01999845f, 0.04327012f, 
    0.14250530f, 0.06167075f, -0.15810813f, 0.01753792f, 0.11772861f, 0.11390802f, -0.09669767f, -0.01881589f, 
    0.08005827f, 0.01052633f, -0.05533288f, 0.00634817f, 0.02088685f, 0.07240906f, 0.08913375f, -0.03554068f, 
    -0.04773435f, -0.03456606f, -0.12462925f, -0.32375357f, -0.01016656f, 0.01196930f, -0.06684261f, 0.02303044f, 
    -0.14968775f, -0.16350588f, 0.10036001f, -0.02095033f, 0.02132932f, 0.12233089f, 0.06498295f, 0.01059144f, 
    0.05653626f, 0.04296382f, -0.08344849f, 0.00291603f, 0.21170953f, 0.03320139f, -0.14017807f, -0.12699021f, 
    0.31486151f, -0.11539350f, -0.08753297f, -0.33784488f, -0.11600628f, -0.10694647f, 0.04953645f, -0.02159672f, 
    -0.00722726f, 0.14191504f, 0.03019613f, 0.15603419f, 0.19624779f, 0.03557385f, -0.03793447f, 0.06956874f, 
    0.14436132f, 0.05759922f, -0.06965930f, 0.30122855f, 0.24710262f, 0.04620095f, 0.13719426f, -0.06828813f, 
    -0.10328262f, -0.03037079f, 0.00791169f, 0.20170316f, 0.14504190f, -0.08506361f, 0.06158885f, 0.02496294f, 
    0.12316529f, -0.01088335f, 0.09563014f, 0.02529691f, 0.28324270f, -0.48531568f, -0.17474236f, -0.09712487f, 
    0.18116646f, -0.15019561f, 0.00922380f, -0.11686615f, -0.19767815f, -0.23004848f, 0.11296395f, 0.01117412f, 
    -0.01462021f, -0.00382340f, 0.01694124f, 0.02067787f, -0.01296313f, 0.04580075f, -0.09479693f, 0.06943788f, 
    0.09781435f, 0.07928731f, 0.21504694f, 0.10440513f, 0.17396677f, -0.02085936f, -0.03087097f, 0.20993276f, 
    0.01840826f, 0.07675731f, 0.06299256f, -0.07578442f, -0.03089298f, 0.05569285f, 0.03148091f, 0.03092831f, 
    -0.04858552f, 0.20288393f, -0.02426016f, -0.08915792f, 0.08092588f, -0.24332415f, 0.04850787f, 0.24363811f, 
    -0.09182072f, 0.08250303f, 0.06575286f, -0.13976467f, -0.01818171f, -0.03293166f, 0.00293758f, 0.09682061f, 
    -0.07011472f, -0.01249588f, -0.05405792f, 0.03602930f, 0.11105397f, 0.02258157f, 0.00168606f, -0.00186523f, 
    -0.25780201f, 0.36249748f, 0.14694405f, 0.16499710f, -0.06351197f, 0.01229963f, -0.03176999f, -0.04960284f, 
    -0.00644069f, 0.06764764f, -0.04783431f, 0.08866829f, -0.00776831f, 0.02400044f, -0.07390337f, -0.13374619f, 
    0.05658391f, 0.09562366f, 0.14115617f, -0.07553899f, 0.08664054f, -0.17945693f, 0.09379026f, 0.11928452f, 
    0.07868355f, 0.12359065f, -0.14202239f, -0.10382277f, -0.04093322f, -0.02162579f, 0.06077233f, 0.03086993f, 
    -0.03232076f, -0.20656277f, 0.04614968f, 0.04109117f, 0.03231784f, 0.11642165f, 0.02417787f, 0.00566290f, 
    0.14077896f, 0.59317136f, 0.33471775f, 0.02453960f, -0.25090110f, 0.00652511f, 0.05725786f, 0.05860235f, 
    0.14987554f, -0.00227941f, -0.05035940f, 0.07048564f, 0.03704144f, 0.10853743f, 0.04396489f, 0.08320516f, 
    0.00940637f, 0.00886402f, -0.02417294f, 0.03280020f, -0.01792153f, 0.09986071f, 0.07671161f, -0.05322204f, 
    -0.17219798f, 0.06758229f, 0.03293563f, 0.21261407f, 0.14776228f, 0.08710550f, -0.15213600f, -0.00404052f, 
    0.15011002f, 0.12917960f, -0.02016573f, 0.10498822f, 0.07901815f, 0.04041716f, 0.00013466f, -0.07646168f, 
    0.16029729f, 0.02579607f, -0.18437098f, -0.35741389f, 0.09321144f, -0.18206525f, -0.17405474f, -0.03957668f, 
    -0.10517072f, -0.08375496f, 0.17368791f, 0.02481582f, 0.02279962f, 0.04511143f, -0.00417898f, 0.11780724f, 
    0.02240296f, -0.12125607f, -0.07022562f, -0.18884182f, -0.22057806f, -0.09936344f, -0.15452248f, -0.34276277f, 
    0.23846567f, -0.10508911f, -0.00396340f, -0.09064208f, -0.25708589f, -0.05842715f, -0.09168224f, -0.07837797f, 
    0.04238449f, -0.22742717f, 0.16569839f, -0.05166633f, 0.00045679f, -0.17999816f, -0.04754653f, -0.12100171f, 
    -0.05071497f, -0.02258396f, -0.00321495f, -0.20424117f, -0.05257520f, -0.00690397f, 0.00467957f, -0.01736465f, 
    0.05231064f, -0.03138496f, 0.10459892f, 0.04930220f, -0.04686294f, -0.17523517f, -0.04451612f, -0.08387152f, 
    -0.07332546f, 0.19682777f, -0.01513330f, 0.08509750f, 0.24130081f, 0.06069205f, 0.10187592f, 0.13308577f, 
    -0.01472734f, -0.00845774f, -0.07309121f, -0.08430527f, -0.02737655f, 0.01852643f, 0.05889742f, 0.13675334f, 
    0.06894595f, -0.06180824f, 0.03783379f, -0.00928603f, -0.01224906f, 0.03186120f, -0.14949505f, 0.29029104f, 
    0.28223166f, -0.11865843f, -0.34543785f, -0.19798227f, -0.04421139f, -0.07175139f, 0.16391611f, -0.10510647f, 
    0.01803183f, -0.15412967f, -0.01990727f, -0.09519280f, -0.09178908f, -0.09311237f, 0.05975797f, -0.02833353f, 
    -0.22396815f, -0.04302822f, -0.13954890f, -0.02624505f, -0.03804843f, 0.26046270f, 0.32258913f, -0.08112545f, 
    -0.10478288f, -0.00674379f, -0.08209063f, 0.04648362f, 0.17317668f, -0.05282370f, -0.07357959f, -0.04963785f, 
    -0.04173800f, 0.07478206f, -0.01516183f, -0.13623101f, 0.08392768f, 0.14498425f, 0.09531645f, -0.05326164f, 
    0.26233181f, -0.34909230f, -0.07789422f, -0.09545016f, -0.16155438f, -0.11610221f, 0.03598814f, -0.03071239f, 
    -0.04623058f, 0.13008572f, 0.09438935f, -0.01192569f, -0.01787852f, -0.05775087f, -0.04566609f, -0.11166894f, 
    0.12398989f, -0.13097212f, 0.20443285f, -0.10070945f, 0.00276393f, 0.10452543f, -0.05126104f, 0.09430163f, 
    -0.05475798f, 0.10524335f, -0.13679408f, -0.06237050f, 0.00015148f, -0.03323776f, 0.18911062f, -0.07629771f, 
    -0.00350887f, 0.02894376f, 0.09075411f, -0.03576953f, -0.05744338f, 0.07762762f, 0.23828255f, 0.08448303f, 
    0.23558533f, 0.00405058f, 0.09529933f, -0.01741944f, 0.29058656f, 0.01828913f, 0.06430496f, 0.05664335f, 
    0.02384575f, -0.02549034f, 0.05938634f, 0.09363049f, 0.11502490f, -0.02531268f, 0.01897375f, -0.03424516f, 
    0.01517548f, -0.05625022f, -0.13798247f, 0.08315351f, 0.29512745f, -0.17387265f, -0.29336396f, 0.14272453f, 
    0.26737100f, 0.03279650f, -0.13854212f, -0.00733454f, 0.10701391f, -0.08067975f, 0.01838850f, -0.06221998f, 
    0.00814214f, 0.30056822f, 0.12022527f, 0.17650510f, 0.03236928f, 0.24016243f, 0.06023542f, 0.05832030f, 
    0.34630486f, -0.08299296f, -0.07770371f, 0.13112283f, 0.06110809f, -0.04880290f, -0.10313575f, 0.13291657f, 
    -0.01843926f, -0.09098737f, 0.14955696f, 0.05360026f, -0.01776978f, 0.00081704f, -0.13626693f, -0.08918507f, 
    0.06092257f, -0.20414142f, 0.02602535f, 0.00656725f, -0.11901109f, -0.01845605f, 0.21195847f, 0.28903067f, 
    0.42352039f, -0.00799314f, -0.18060213f, 0.03296925f, 0.15015449f, 0.06712957f, 0.13163729f, 0.07666603f, 
    0.06249988f, 0.00170285f, 0.01876209f, 0.04458643f, -0.04980665f, -0.03149648f, -0.14530800f, -0.14192419f, 
    -0.29031435f, 0.20413698f, 0.00684006f, -0.21815787f, 0.00704880f, 0.02637622f, -0.08547707f, 0.13174364f, 
    -0.10504156f, -0.23301710f, 0.12270043f, 0.10113157f, -0.06631654f, -0.07268079f, -0.02894300f, -0.01460545f, 
    0.02800313f, -0.02924188f, -0.15535285f, -0.01866247f, 0.08678372f, 0.01141927f, -0.08944385f, -0.05185167f, 
    0.00071122f, -0.13190573f, -0.05716210f, 0.09625106f, 0.02365728f, 0.10268986f, -0.01241840f, 0.06828483f, 
    0.04496521f, 0.17420062f, 0.07746791f, 0.05306284f, 0.06305365f, 0.01590917f, -0.05556429f, -0.05114769f, 
    -0.62376308f, 0.36600116f, 0.12701006f, 0.24128956f, -0.33008316f, -0.03570504f, 0.02249127f, 0.00467917f, 
    0.07473604f, -0.09195556f, 0.03570589f, 0.09703409f, 0.09176020f, -0.21366587f, -0.10772333f, -0.04228947f, 
    -0.09824554f, 0.10027226f, 0.08891667f, 0.12119770f, -0.18319747f, 0.22753394f, 0.21358399f, -0.32344919f, 
    -0.23189145f, 0.02651068f, 0.03152995f, 0.16221154f, -0.05502389f, -0.09688584f, 0.01693697f, 0.10912539f, 
    -0.11274680f, -0.12988418f, -0.19596353f, 0.01333864f, 0.04066259f, -0.01038414f, 0.02174344f, -0.03259793f, 
    0.18025011f, -0.31927285f, -0.36007002f, 0.17869602f, -0.11245501f, -0.04923009f, -0.02554331f, 0.07017934f, 
    -0.13453931f, -0.05263237f, 0.12741263f, 0.05678008f, 0.09580848f, 0.03564089f, -0.05317538f, -0.02288526f, 
    -0.03725402f, -0.01784926f, 0.00478963f, -0.00708056f, -0.17794205f, 0.21664645f, -0.34551623f, -0.08423253f, 
    0.12846585f, -0.24071637f, -0.01416361f, -0.01184161f, 0.00619321f, 0.09648611f, 0.09708253f, 0.06662770f, 
    -0.03826819f, 0.01776489f, 0.06571848f, -0.01665177f, 0.04239629f, 0.06903077f, 0.17440240f, 0.17564738f, 
    0.45245263f, 0.36376715f, -0.03079605f, 0.13681005f, 0.04695537f, 0.04790531f, -0.04635706f, -0.05100288f, 
    0.02249444f, 0.04148260f, 0.04481198f, 0.05271456f, 0.06962221f, 0.20567767f, 0.27044544f, 0.15185001f, 
    0.00731523f, -0.17440169f, -0.03830374f, 0.10737013f, 0.11255226f, -0.06505249f, -0.09799556f, 0.09881869f, 
    0.03625242f, -0.03026202f, -0.03946932f, 0.00085319f, 0.02177285f, 0.09274060f, 0.05755170f, 0.09306448f, 
    0.21562724f, 0.01976158f, -0.05439705f, -0.15874048f, 0.13069135f, -0.03712324f, -0.08740719f, -0.16273281f, 
    -0.23517723f, 0.18490335f, -0.21032663f, 0.09062740f, 0.16366716f, 0.11859880f, 0.13972244f, -0.14247966f, 
    -0.03980710f, 0.25024259f, 0.11377322f, -0.11496833f, -0.17214808f, -0.05235425f, -0.05361617f, 0.11172567f, 
    0.05243373f, -0.00413120f, 0.06928235f, 0.05460428f, 0.24278575f, 0.15963757f, 0.06400678f, -0.18736319f, 
    -0.12287351f, -0.12320683f, 0.06609012f, 0.11389336f, -0.01330530f, -0.17808104f, 0.06164799f, -0.02849928f, 
    -0.01349718f, 0.02002606f, 0.11242989f, 0.00086020f, 0.07779699f, -0.01851853f, -0.05043119f, 0.05215423f, 
    0.02902921f, -0.00972415f, 0.01503272f, 0.01605128f, -0.02745674f, 0.03727455f, -0.06210037f, 0.00233145f, 
    -0.02966118f, 0.00721883f, 0.04294494f, 0.04191143f, 0.04328198f, -0.03858134f, 0.02805188f, 0.03072457f, 
    -0.06589729f, -0.01326693f, -0.00399095f, -0.06022316f, 0.00039327f, -0.00984013f, 0.04179991f, 0.03369570f, 
    -0.00867201f, 0.02324626f, -0.01357155f, 0.01166228f, 0.01465041f, -0.02317920f, -0.05598031f, -0.01304599f, 
    -0.03718656f, -0.02973240f, 0.04064241f, -0.00835916f, -0.01635483f, 0.03642324f, -0.03562962f, -0.03493018f, 
    -0.04392477f, -0.01716746f, 0.02658785f, 0.03871945f, -0.00666764f, -0.05591184f, -0.02489190f, 0.03030549f, 
    -0.02230245f, 0.04783006f, 0.01755421f, -0.00073935f, -0.03406603f, -0.05424536f, -0.01150809f, -0.04944678f, 
    -0.02418021f, 0.05318655f, 0.04465630f, -0.03276304f, -0.06075056f, 0.02027708f, -0.01751341f, -0.00471119f, 
    0.05952504f, -0.03964335f, -0.01098139f, -0.02483415f, -0.02586630f, -0.05567468f, 0.03171213f, 0.03297659f, 
    -0.00812348f, 0.03149990f, -0.03446798f, -0.04825412f, -0.01366261f, 0.00001151f, 0.01643473f, -0.00153946f, 
    -0.00425870f, -0.03382513f, 0.04834140f, -0.01525619f, -0.06024083f, -0.05841460f, -0.01170092f, -0.03993833f, 
    -0.05365396f, -0.02096146f, -0.05034552f, 0.02717913f, 0.02319416f, 0.01132887f, 0.03320194f, 0.03760867f, 
    0.02803076f, 0.00516206f, -0.00114025f, -0.03692333f, 0.04442741f, 0.04696548f, -0.05848796f, 0.01000039f, 
    0.01516606f, -0.02927276f, 0.04000099f, 0.02985999f, -0.05016318f, -0.01334461f, 0.02730650f, 0.00443014f, 
    -0.02446755f, -0.00956804f, 0.03744391f, 0.01387844f, -0.03489606f, -0.02986101f, 0.00031990f, 0.03480211f, 
    -0.03244449f, 0.05001533f, 0.00235179f, -0.02576446f, -0.03925675f, -0.00192686f, -0.01197104f, -0.03970553f, 
    0.04456513f, -0.05009084f, 0.00696899f, 0.01727918f, 0.03302135f, 0.04398147f, -0.02957079f, -0.03055065f, 
    -0.04425794f, -0.05404636f, 0.03750511f, -0.04460973f, -0.04964045f, -0.03641085f, 0.02772022f, 0.00633510f, 
    0.01601058f, -0.01554747f, 0.04345336f, -0.00229160f, -0.01678788f, -0.02672856f, 0.00785949f, 0.03791636f, 
    -0.02471047f, -0.00545043f, -0.01714585f, 0.02522139f, -0.05500268f, 0.04605757f, -0.01951777f, 0.01438744f, 
    -0.06018028f, 0.03255782f, 0.02182495f, -0.00048675f, -0.05154357f, -0.03545237f, -0.02226011f, 0.01974852f, 
    0.04268294f, 0.01017123f, 0.03363283f, 0.03713828f, 0.00597573f, -0.03353097f, -0.00517910f, 0.03129635f, 
    -0.04881049f, -0.01258953f, -0.03004153f, -0.04708145f, 0.03097718f, -0.04444385f, -0.03490667f, 0.02040350f, 
    0.04387531f, -0.01881908f, -0.02192606f, -0.02022937f, -0.02368143f, 0.01011719f, -0.04701644f, -0.00424962f, 
    0.03057372f, 0.03394638f, 0.02079398f, -0.03851731f, -0.05447577f, -0.03808238f, -0.04782041f, -0.04774441f, 
    -0.01536059f, 0.01630019f, -0.02774114f, 0.03528622f, 0.04434741f, 0.03744460f, -0.05794019f, -0.03366098f, 
    -0.04929303f, 0.01635224f, -0.01913280f, 0.03097077f, 0.02946899f, 0.02649216f, 0.02151818f, -0.00551395f, 
    0.03895400f, -0.00343077f, -0.04716910f, 0.03872252f, -0.01829005f, 0.01360435f, -0.03193484f, -0.04352346f, 
    -0.02985142f, -0.03853141f, 0.04397467f, -0.03944951f, 0.02291853f, -0.04351525f, -0.03336491f, -0.05682283f, 
    0.04255304f, -0.05828593f, 0.04506320f, -0.00122608f, -0.04148768f, 0.01253346f, -0.00788407f, -0.00837035f, 
    0.03265616f, 0.03367038f, 0.03050226f, -0.03320226f, -0.00638035f, 0.00428566f, 0.02229196f, 0.04054531f, 
    -0.01362095f, -0.02123617f, 0.01469738f, -0.00451877f, 0.03951531f, -0.02567339f, -0.02690163f, 0.03163939f, 
    -0.02161048f, -0.02680501f, -0.01882921f, 0.02022080f, 0.02743602f, -0.00365430f, -0.04849553f, -0.04549710f, 
    -0.02674516f, 0.00022258f, -0.05262893f, 0.01295006f, 0.00032647f, -0.02724135f, 0.04509668f, 0.00108336f, 
    0.01702518f, -0.05024410f, 0.00330650f, 0.03565492f, 0.03971333f, 0.01190637f, 0.00975678f, -0.03138534f, 
    -0.04459178f, 0.02388032f, -0.01277909f, -0.00886703f, 0.02662552f, 0.01512421f, -0.04854898f, 0.03098857f, 
    -0.04008825f, 0.05023395f, 0.02632682f, -0.02829711f, -0.02457092f, 0.04678246f, -0.00913660f, 0.00676028f, 
    0.00022359f, -0.00336051f, -0.05781647f, -0.03943994f, 0.00498297f, -0.03964182f, 0.01439025f, 0.01976260f, 
    -0.01107491f, 0.04081978f, 0.01349535f, -0.05604802f, 0.01363108f, -0.04523384f, -0.04556217f, -0.02560487f, 
    0.00325350f, -0.02906694f, 0.02907099f, -0.02852483f, -0.05975760f, 0.02568730f, -0.05818251f, 0.02449690f, 
    -0.05440310f, -0.03243584f, 0.03644763f, 0.00758930f, -0.05418604f, 0.01597245f, 0.04947434f, 0.00331515f, 
    0.04693108f, -0.06010564f, 0.02200717f, 0.02628134f, 0.04190772f, -0.01583305f, -0.05605311f, 0.02866214f, 
    -0.04612372f, -0.01082096f, -0.04286200f, -0.03856073f, 0.01509229f, 0.04252897f, -0.00616218f, -0.01680938f, 
    0.03568652f, 0.04306339f, -0.04830105f, 0.03700272f, 0.00378068f, 0.01265288f, -0.01210646f, -0.01513219f, 
    -0.03006461f, -0.01298106f, -0.02532064f, 0.00900641f, -0.03698739f, 0.04525463f, -0.04823304f, -0.02401004f, 
    -0.00372658f, -0.01760790f, 0.04372956f, -0.00986677f, 0.01786283f, 0.00028920f, 0.00108124f, -0.05574683f, 
    0.01866263f, -0.01100118f, -0.00868601f, -0.04607172f, -0.03939865f, 0.02975933f, 0.01851978f, 0.02273489f, 
    0.03552017f, 0.03982243f, -0.04555565f, -0.05025240f, -0.02599097f, -0.02218377f, -0.03973392f, -0.01757376f, 
    0.03714064f, -0.01495225f, -0.03026941f, 0.02201714f, 0.01956899f, -0.06028761f, 0.02602538f, 0.03453360f, 
    -0.01186295f, -0.04316138f, 0.00004980f, -0.04931758f, -0.01846527f, 0.01436989f, 0.02854224f, -0.01318588f, 
    -0.01085751f, 0.04426856f, -0.03909319f, -0.05854250f, -0.05799946f, -0.06094208f, -0.04433698f, 0.04588406f, 
    -0.01535998f, -0.00766911f, -0.01861030f, -0.05810666f, -0.00237913f, -0.03854432f, 0.03859989f, -0.04885019f, 
    0.01617280f, -0.05298342f, -0.00819996f, 0.03095984f, 0.03332622f, -0.03695365f, 0.04361952f, 0.02582218f, 
    -0.02837810f, 0.01044944f, -0.00733077f, 0.02143865f, -0.02717932f, -0.06038857f, 0.04806784f, -0.01520223f, 
    -0.00404087f, -0.04273636f, 0.03075212f, -0.01963741f, -0.05146984f, -0.02882685f, -0.01392466f, 0.00361149f, 
    0.03828511f, 0.02362331f, -0.03396924f, -0.05987874f, -0.05561953f, 0.03819105f, 0.00019020f, -0.05616427f, 
    -0.02128176f, 0.02135983f, -0.05446310f, 0.00081411f, -0.02782595f, -0.02071647f, 0.02660030f, 0.02509521f, 
    -0.05619764f, -0.05727872f, 0.05422750f, 0.01236604f, -0.00039841f, -0.05913847f, 0.02188283f, -0.03280614f, 
    -0.01007714f, -0.04539383f, 0.00096362f, 0.01798273f, 0.04485991f, -0.03452436f, 0.00666280f, 0.02398927f, 
    0.02930797f, -0.05129107f, -0.01142558f, -0.03735660f, -0.05972330f, 0.04743914f, 0.01252211f, -0.03984721f, 
    -0.04580962f, -0.01583070f, 0.03389003f, 0.03252661f, -0.00441043f, -0.06034162f, -0.01380784f, -0.01246950f, 
    0.04285995f, 0.01830304f, -0.06045736f, -0.06089726f, 0.03479232f, 0.00052914f, 0.01836492f, -0.04198410f, 
    0.03375463f, 0.02438757f, 0.01543980f, -0.05995550f, 0.01998043f, 0.04465448f, 0.02909817f, -0.00070066f, 
    -0.04162098f, -0.04633558f, -0.02519332f, 0.04704630f, -0.00027156f, 0.01529518f, -0.02389039f, 0.02549579f, 
    0.03978853f, -0.03577858f, 0.00161595f, -0.01459000f, 0.03700420f, 0.01886686f, -0.01039924f, -0.03551711f, 
    -0.00185478f, -0.00917867f, -0.00844119f, -0.00760067f, -0.03373487f, -0.04900641f, 0.02945916f, 0.04276520f, 
    0.01116057f, -0.03490267f, -0.05092014f, -0.00187477f, 0.00440840f, 0.03751018f, 0.04658838f, -0.03176969f, 
    -0.03917062f, 0.04450903f, 0.03632103f, -0.01359594f, -0.05947842f, 0.00206589f, 0.02209235f, 0.02139816f, 
    0.00425949f, 0.03408339f, -0.00416999f, -0.03010703f, -0.05280128f, 0.05026183f, 0.02492436f, -0.01916864f, 
    -0.05574767f, -0.00832301f, 0.01727553f, 0.03292296f, -0.03567873f, 0.02036527f, -0.05674559f, -0.04849985f, 
    -0.03263494f, -0.05243327f, 0.02184575f, -0.03473769f, -0.01587540f, 0.00542635f, -0.05159516f, 0.02692947f, 
    0.00248755f, -0.01077135f, -0.00173215f, -0.00214052f, 0.02574760f, -0.04593269f, 0.03100104f, -0.03534495f, 
    -0.05882978f, 0.02099835f, -0.00204125f, -0.01927543f, 0.03773002f, -0.03534272f, -0.04910447f, -0.04302514f, 
    -0.02164383f, 0.01863531f, 0.04493121f, -0.05167650f, -0.01708084f, -0.01797580f, -0.02619053f, 0.02946046f, 
    -0.03959281f, 0.03072202f, 0.03406545f, -0.02435129f, 0.04462174f, -0.01411360f, -0.04987616f, -0.01119581f, 
    0.02853454f, -0.03802442f, -0.01461786f, -0.03499543f, 0.01980115f, 0.04915866f, -0.04957417f, -0.00783289f, 
    0.01182566f, -0.02021697f, -0.04516217f, -0.05099631f, -0.04829878f, 0.03715084f, 0.04947205f, -0.01735880f, 
    -0.04928056f, 0.01458788f, -0.01285844f, -0.05300745f, -0.01964036f, -0.06113791f, -0.03602197f, 0.04032246f, 
    -0.01336694f, -0.00463911f, 0.00322670f, -0.04720606f, -0.02261991f, -0.00322926f, -0.04044123f, -0.00279369f, 
    -0.01228184f, -0.03158255f, 0.00109642f, 0.01838129f, 0.00141976f, -0.02017507f, -0.05274292f, -0.04740320f, 
    0.01748535f, -0.05887914f, 0.02348751f, 0.03539220f, -0.02258544f, -0.03445685f, -0.02639056f, 0.04387157f, 
    -0.04998447f, -0.04446933f, -0.05704964f, -0.05330582f, -0.01159816f, -0.04076630f, -0.00049922f, 0.02268271f, 
    0.02630576f, 0.02213045f, -0.01200484f, -0.06583895f, 0.00241279f, -0.02093712f, -0.05870112f, 0.02018684f, 
    -0.07118416f, -0.00927975f, -0.04280568f, -0.02849638f, 0.01656850f, 0.04139349f, 0.00278091f, 0.00810253f, 
    0.01771687f, 0.02233188f, 0.01086397f, 0.00822390f, 0.02962531f, -0.01094735f, 0.01416594f, 0.03752990f, 
    -0.02252477f, -0.00996584f, -0.02058888f, 0.03003810f, -0.01823221f, 0.03715502f, 0.01957385f, -0.04767833f, 
    -0.05770705f, -0.02537172f, 0.01573613f, -0.02311207f, 0.02056870f, -0.03218730f, -0.06364416f, -0.02867633f, 
    -0.04617524f, 0.03082116f, -0.02821445f, 0.02329654f, 0.01553976f, -0.03356842f, -0.01185509f, 0.04129260f, 
    -0.00965104f, 0.01006992f, -0.02573232f, 0.04534419f, 0.02326670f, 0.03095379f, -0.03192111f, 0.00190967f, 
    -0.00975705f, 0.03545232f, 0.03517212f, 0.02716401f, -0.04494061f, -0.03703143f, -0.04002056f, 0.02948962f, 
    0.05268740f, -0.08050150f, -0.01948220f, -0.01400854f, 0.01982501f, 0.03447599f, 0.03051140f, -0.05400261f, 
    0.03086557f, -0.03407096f, -0.03880131f, -0.02382156f, -0.00828855f, -0.02981984f, 0.04649155f, -0.07812571f, 
    0.02411129f, -0.00128567f, 0.03257345f, 0.02444172f, -0.04845174f, -0.01976674f, 0.00603244f, 0.01349201f, 
    -0.03084603f, -0.05488256f, 0.00402980f, -0.05549040f, 0.02333660f, 0.01411877f, -0.05065522f, -0.05910837f, 
    -0.01441469f, -0.00366865f, -0.04521007f, -0.01402074f, -0.07326581f, 0.03444370f, 0.01252593f, -0.02229974f, 
    -0.01864459f, -0.01532099f, -0.02978286f, 0.02483448f, -0.02410232f, -0.06397901f, -0.04735117f, -0.03357162f, 
    0.03830121f, 0.02708101f, 0.01541172f, 0.01516703f, -0.01266534f, 0.03767043f, -0.05200949f, -0.03090460f, 
    0.01594108f, -0.05013197f, -0.03579817f, -0.01406168f, 0.04716238f, 0.03737484f, 0.01440646f, -0.02961411f, 
    -0.04003765f, 0.03665886f, -0.04772717f, -0.04939499f, -0.01399140f, -0.06900257f, -0.03118289f, 0.00067386f, 
    0.03469841f, -0.06936736f, 0.04481444f, 0.01464528f, 0.00293589f, -0.03502322f, 0.00983245f, -0.03160363f, 
    0.02849066f, 0.02955751f, -0.00231461f, -0.03588433f, -0.06308123f, -0.05530920f, -0.02370610f, -0.00356082f, 
    -0.03325104f, 0.03152153f, 0.02652060f, 0.00625351f, -0.00855223f, -0.04479779f, -0.06745932f, 0.01687152f, 
    -0.06343970f, -0.05498932f, 0.04784759f, -0.01259115f, -0.02237999f, 0.01058118f, 0.02137605f, -0.04095551f, 
    0.00904832f, -0.03374321f, 0.03958942f, -0.01153540f, -0.03319390f, -0.05822299f, -0.02210324f, -0.05508569f, 
    -0.01475787f, -0.03636665f, 0.03271006f, 0.03617061f, 0.00055628f, -0.04067791f, 0.02564303f, -0.00678043f, 
    -0.01708809f, -0.03543973f, -0.02745411f, 0.01342559f, -0.04146601f, 0.03537337f, -0.00116711f, -0.03233012f, 
    -0.01180834f, -0.06340753f, 0.03801922f, -0.00436208f, 0.02039385f, -0.02904635f, -0.06245909f, -0.05071611f, 
    -0.00192735f, 0.02930879f, -0.00655410f, -0.05760060f, 0.00418305f, -0.00227556f, -0.00414352f, -0.01104092f, 
    0.02320986f, 0.04900284f, 0.03916601f, -0.03291640f, -0.05438377f, -0.00333301f, 0.00234149f, -0.05334987f, 
    0.03198243f, -0.06374591f, -0.00919201f, -0.04116036f, 0.02346556f, -0.03889093f, 0.03555878f, 0.01923436f, 
    -0.00784247f, 0.01188352f, -0.01981972f, 0.02910291f, 0.03645809f, 0.00222032f, -0.00943701f, 0.00147891f, 
    -0.03455238f, -0.00998892f, 0.00026263f, 0.00834043f, -0.06176350f, -0.04030144f, 0.03271970f, -0.06065090f, 
    0.00584703f, -0.06061874f, -0.04152826f, 0.00426194f, -0.02541503f, -0.05904796f, -0.02334493f, -0.03423568f, 
    -0.01008676f, -0.00771590f, -0.03855024f, -0.02678551f, -0.06859733f, 0.01079115f, 0.00293829f, 0.04921401f, 
    -0.01405090f, -0.05298234f, -0.05088783f, -0.06146128f, -0.06462006f, 0.02947661f, 0.03563265f, 0.00357563f, 
    -0.00435293f, 0.02383191f, 0.00027348f, 0.01330458f, 0.00079737f, -0.00459331f, -0.00533716f, 0.06190511f, 
    -0.05012398f, 0.03909828f, -0.05468176f, -0.00241604f, -0.00564778f, -0.05230675f, 0.00134308f, -0.01682764f, 
    0.02119263f, -0.03340492f, 0.02995370f, -0.02736397f, 0.02460404f, -0.04438653f, -0.04633830f, 0.02083864f, 
    -0.03071694f, -0.01304951f, 0.04230386f, 0.02724114f, -0.00966482f, -0.00389699f, -0.03317848f, -0.02817814f, 
    -0.02872175f, -0.00401109f, -0.01505940f, -0.02785347f, -0.03377464f, 0.00037981f, -0.05264416f, -0.05948468f, 
    -0.03724231f, 0.02256777f, -0.04704096f, -0.06051182f, -0.05470399f, 0.02613821f, -0.04741371f, -0.02184082f, 
    0.00974225f, -0.02474126f, -0.00375107f, -0.01432906f, -0.00308526f, -0.02520576f, 0.00738419f, 0.01524355f, 
    -0.00741720f, 0.00822335f, -0.04641423f, -0.05165395f, -0.03767149f, -0.01021988f, -0.04201564f, 0.00162492f, 
    -0.05543531f, 0.02121861f, -0.01679529f, -0.04473815f, -0.04022333f, -0.06024490f, 0.02675722f, 0.03042254f, 
    -0.00239681f, 0.02970259f, 0.04284402f, -0.01739464f, -0.00604174f, -0.00126753f, 0.03424404f, 0.00474321f, 
    0.04121189f, 0.01241137f, -0.05140471f, -0.00311434f, -0.03793358f, -0.06245967f, -0.05795334f, 0.00886546f, 
    -0.00085026f, -0.01628323f, 0.02549965f, -0.02085915f, -0.05835265f, 0.00801876f, -0.04274347f, 0.00829311f, 
    0.00487217f, -0.05091118f, 0.02434652f, -0.02441777f, 0.03872078f, -0.05702573f, 0.00901637f, -0.00715469f, 
    -0.00019884f, 0.01630289f, 0.01680186f, -0.03393594f, -0.04441361f, -0.05759558f, -0.04065707f, -0.01254826f, 
    -0.01860539f, -0.03990386f, -0.01694345f, -0.06226122f, 0.00287067f, -0.03408680f, -0.01940242f, 0.03949986f, 
    -0.01011136f, 0.04071812f, -0.05889025f, 0.01793574f, 0.02004190f, -0.00335374f, -0.01470592f, 0.00561277f, 
    0.04208961f, -0.01882755f, -0.06311802f, -0.00971751f, 0.03357432f, -0.02797331f, -0.00247227f, 0.01088519f, 
    0.01128381f, 0.03106353f, 0.03838924f, -0.01012281f, -0.03659981f, 0.04767366f, 0.01375363f, -0.01999307f, 
    0.01351119f, -0.01757398f, -0.03818439f, -0.05392218f, 0.04416791f, -0.02336337f, 0.00604948f, -0.04357382f, 
    0.03839779f, 0.02246077f, -0.04974540f, -0.02256799f, -0.01224172f, 0.01470006f, -0.00359248f, -0.04125909f, 
    -0.04095074f, -0.01992463f, -0.05849087f, 0.02931234f, -0.00428230f, 0.02482434f, -0.03791274f, -0.05482434f, 
    -0.04253113f, 0.00210874f, -0.01936435f, -0.04214988f, 0.04480130f, -0.05191118f, -0.00191378f, 0.00728264f, 
    -0.05736727f, -0.06098570f, 0.03385942f, -0.04009276f, -0.05165893f, 0.03311131f, -0.05017971f, 0.03154949f, 
    -0.05814887f, -0.05737869f, 0.02178540f, -0.03743027f, -0.05931627f, 0.00138801f, 0.03866913f, -0.03633560f, 
    -0.01556844f, -0.01989347f, -0.05805655f, 0.01646106f, 0.00984277f, 0.02127922f, -0.00134780f, -0.00561850f, 
    0.02619045f, 0.03790751f, -0.00720359f, -0.00604247f, 0.03860987f, -0.05323938f, -0.06224858f, -0.02408857f, 
    -0.04976358f, -0.04422065f, -0.00388799f, 0.04741706f, -0.03199051f, -0.00112043f, -0.03150894f, -0.03906830f, 
    -0.03868482f, 0.03774775f, -0.02907957f, 0.02839594f, 0.00835790f, -0.01817380f, -0.04241012f, 0.02224463f, 
    -0.01679829f, 0.03696984f, 0.00992100f, -0.03261854f, -0.00852494f, -0.00647611f, -0.00737551f, -0.01344099f, 
    0.01672317f, -0.03173769f, -0.01344605f, 0.03768573f, 0.03201630f, -0.03174378f, 0.00157424f, 0.03538465f, 
    -0.02044706f, 0.03118936f, -0.06016319f, 0.04770095f, 0.04128641f, 0.03738503f, 0.01965631f, 0.03397172f, 
    0.03808794f, 0.02505043f, 0.00417280f, 0.02526903f, 0.04207776f, 0.00966181f, -0.04747157f, 0.02970898f, 
    0.02264588f, 0.03407552f, 0.00550497f, -0.00993386f, -0.01529681f, -0.02859916f, 0.04710259f, 0.04410635f, 
    -0.00187533f, -0.00067727f, 0.04630160f, 0.04686018f, 0.01913855f, -0.01372130f, -0.05819568f, -0.05439059f, 
    -0.04588514f, 0.01925787f, 0.04435455f, 0.03418259f, 0.02595093f, -0.01553681f, -0.05845920f, 0.02831856f, 
    -0.01498910f, -0.04784717f, -0.05122535f, 0.03288575f, -0.02505610f, 0.03035938f, 0.04121131f, -0.05600335f, 
    -0.03582852f, -0.00777929f, -0.03789984f, 0.02767045f, -0.04550267f, -0.03286453f, -0.05773821f, 0.04616953f, 
    -0.00059213f, -0.02895988f, -0.03182551f, -0.03270205f, -0.01959185f, 0.03558997f, 0.02898552f, -0.02569933f, 
    0.02439418f, -0.03163721f, -0.03491512f, 0.01324413f, 0.01552402f, -0.06072091f, -0.03598337f, -0.04363573f, 
    -0.04330816f, -0.05336323f, 0.03282162f, -0.00131549f, 0.04225250f, -0.02558398f, 0.02719485f, -0.05439697f, 
    0.03711486f, -0.03058751f, 0.03111787f, 0.01047656f, -0.01519204f, -0.00264058f, -0.04457372f, -0.06106727f, 
    0.02198676f, 0.00932625f, -0.05850372f, -0.04318291f, -0.03824534f, -0.01397337f, 0.03407502f, -0.00775812f, 
    -0.05316311f, -0.00448569f, -0.03581341f, -0.03075336f, -0.03984326f, -0.03048019f, 0.02044730f, -0.01194540f, 
    0.04401805f, -0.04947934f, -0.06092895f, -0.06234197f, -0.04162392f, 0.01512355f, -0.05830543f, 0.03192842f, 
    0.01174826f, -0.04578475f, 0.01866672f, 0.02446851f, 0.03595238f, -0.00595050f, 0.02797098f, -0.04257691f, 
    0.20049264f, -0.13791028f, -0.26142862f, 0.23371589f, -0.24760193f, 0.00465311f, 0.08029936f, 0.01079153f, 
    0.03338415f, 0.15719490f, 0.01013523f, -0.05727360f, 0.01135014f, -0.04929288f, 0.07276242f, -0.09838546f, 
    -0.02047367f, -0.01229762f, -0.02383341f, -0.14406285f, -0.21170455f, 0.40104339f, 0.03931118f, 0.17972100f, 
    -0.35522497f, 0.04481274f, 0.06562405f, 0.09257147f, 0.05905230f, -0.05403952f, 0.16891046f, 0.03502271f, 
    0.09272233f, -0.04460328f, -0.00013737f, -0.16359627f, -0.05167696f, 0.16246308f, -0.01528789f, 0.10511550f, 
    0.06724845f, 0.16415299f, -0.23439336f, -0.10531215f, -0.10942719f, 0.05465073f, 0.16331646f, -0.03080110f, 
    0.02613366f, -0.08719566f, 0.15061572f, -0.02189984f, 0.01209927f, -0.03510202f, -0.00938203f, -0.07480286f, 
    0.18815087f, 0.07181999f, -0.02446814f, 0.04213679f, -0.20644416f, 0.42836764f, -0.04814836f, 0.12421682f, 
    0.02823353f, 0.11614556f, -0.00100614f, -0.03178108f, 0.09135222f, 0.03120243f, -0.10791486f, 0.16321966f, 
    0.14010967f, 0.16098794f, 0.13957646f, -0.06966726f, 0.02348758f, 0.08330071f, 0.07149795f, 0.03548082f, 
    0.05209301f, 0.01039093f, 0.03228631f, -0.00465970f, -0.18001924f, -0.11945172f, 0.01239347f, -0.03562740f, 
    0.02575676f, 0.01919884f, 0.03573974f, -0.03677671f, 0.03615864f, 0.17248201f, -0.10998333f, 0.00032006f, 
    -0.10553899f, 0.08683358f, 0.10601214f, 0.04916249f, -0.23802957f, 0.19287524f, -0.04872898f, -0.06009873f, 
    0.44006521f, -0.08445104f, -0.10698528f, 0.08054569f, -0.09414761f, -0.00737935f, 0.09247284f, -0.01089888f, 
    0.05069505f, -0.00635543f, -0.03668028f, 0.11280116f, 0.02864379f, 0.05169502f, 0.00584818f, 0.01551803f, 
    0.11937233f, 0.06108397f, 0.15889880f, -0.36743397f, 0.26783806f, 0.14137916f, 0.11411768f, 0.12375253f, 
    -0.01540990f, -0.13803186f, 0.11427342f, -0.22344898f, 0.13480356f, -0.05165551f, -0.07712051f, 0.05377737f, 
    0.11399075f, 0.02840660f, 0.00262284f, 0.11425035f, -0.06160953f, 0.19207795f, 0.11895778f, -0.36597180f, 
    0.09513988f, -0.00170519f, -0.00079163f, -0.03519823f, -0.04782736f, -0.00640977f, 0.03130200f, 0.09781492f, 
    -0.07213118f, 0.02081192f, 0.05836921f, -0.09521095f, -0.14083944f, 0.09005274f, -0.05191648f, 0.14040011f, 
    0.09062396f, -0.37900406f, -0.17864059f, -0.07298989f, -0.13509402f, 0.05244877f, 0.06399249f, 0.00887611f, 
    -0.07372133f, -0.04931420f, 0.02261559f, -0.04625822f, -0.02543193f, -0.06264444f, 0.17575771f, 0.01852917f, 
    0.02938335f, 0.09818958f, -0.00198867f, 0.06516234f, -0.55543828f, -0.21349815f, 0.23879954f, -0.08032861f, 
    0.46648428f, -0.03910172f, -0.02007825f, 0.01448368f, -0.01048496f, 0.05139173f, 0.03822965f, 0.04610367f, 
    -0.01002796f, 0.02085497f, -0.01951896f, -0.00885358f, -0.01436910f, -0.08806691f, 0.03845002f, -0.01643794f, 
    0.03609195f, 0.21551661f, -0.12336656f, 0.24408574f, -0.40391880f, 0.19151837f, 0.05143120f, 0.04239266f, 
    -0.03367012f, -0.00465052f, 0.05549968f, -0.06380926f, 0.17681178f, 0.07848259f, 0.06644993f, -0.05107804f, 
    -0.16751614f, -0.06219208f, 0.00044077f, 0.01366783f, 0.00134086f, 0.23746757f, -0.06653699f, 0.33786848f, 
    -0.12002912f, 0.05629825f, -0.05695918f, 0.14356714f, 0.04310507f, 0.00386697f, -0.07538834f, 0.03272003f, 
    -0.06073477f, 0.12413593f, -0.07857454f, 0.10836048f, 0.03786927f, 0.00073422f, 0.05276901f, -0.12667997f, 
    0.05885430f, 0.07180414f, -0.04867100f, -0.00012237f, -0.12198143f, 0.18597420f, 0.00966367f, -0.21424000f, 
    -0.00980907f, -0.04243802f, -0.06827228f, 0.11962149f, -0.06869509f, 0.11189006f, 0.00549141f, 0.10425198f, 
    -0.02003594f, -0.06947418f, -0.05601561f, -0.03876127f, -0.13271676f, 0.18197837f, -0.04277853f, -0.21058400f, 
    0.06510372f, -0.03248513f, -0.04546997f, -0.02725307f, 0.01568842f, -0.07196207f, 0.04176540f, -0.00918139f, 
    -0.10708666f, 0.01831235f, -0.05558401f, -0.09540548f, 0.11066388f, 0.03741251f, 0.06574634f, -0.08373825f, 
    -0.27973095f, 0.39500359f, -0.31078669f, 0.29891637f, -0.02858789f, 0.17718743f, -0.03426296f, -0.11124752f, 
    -0.11667143f, 0.18899143f, -0.04196631f, 0.07986495f, 0.02476333f, -0.07680576f, -0.12497338f, 0.07790094f, 
    -0.08044307f, -0.08247185f, 0.06261040f, -0.08704458f, 0.05201583f, -0.16680148f, 0.30673003f, -0.02908751f, 
    0.09078588f, -0.13026799f, 0.09188623f, 0.02938251f, 0.09989546f, -0.08113212f, 0.01820656f, 0.02772540f, 
    -0.12452611f, 0.03315748f, 0.10846546f, 0.03049560f, -0.00382555f, -0.04664921f, 0.00020314f, 0.15511513f, 
    -0.02896441f, 0.00163790f, 0.01673713f, 0.02734732f, 0.01901879f, 0.00120095f, -0.02325225f, -0.05439153f, 
    -0.06125806f, -0.00501881f, -0.04021694f, 0.04686395f, 0.01941014f, 0.02491476f, -0.02956975f, -0.02311810f, 
    0.04239617f, -0.05958445f, 0.01496035f, -0.02102927f, 0.00137015f, -0.03100770f, 0.04061931f, 0.01053592f, 
    -0.01331029f, 0.03307434f, 0.03115419f, 0.04134126f, 0.03001603f, -0.05006558f, -0.03485111f, -0.00933218f, 
    -0.01511608f, -0.00096512f, 0.03635227f, 0.04837309f, 0.04609805f, -0.05466693f, -0.05245057f, 0.04261268f, 
    -0.02239883f, 0.03739976f, 0.02051761f, -0.03351422f, -0.04533787f, 0.02258696f, -0.00916978f, -0.00974964f, 
    -0.03386604f, 0.00527372f, -0.02867481f, -0.05390167f, -0.03876068f, -0.04990175f, -0.01889315f, 0.03170508f, 
    -0.03208486f, -0.00024496f, 0.02372712f, -0.02525475f, -0.05028768f, -0.04811654f, -0.01793074f, 0.00585307f, 
    -0.02891709f, 0.01059935f, 0.03001508f, 0.03865609f, 0.02770594f, -0.00171435f, -0.05794971f, 0.02499450f, 
    -0.05719371f, -0.03734858f, -0.03489724f, -0.04015952f, 0.03690358f, -0.02740674f, 0.02208897f, -0.05154175f, 
    0.03680396f, -0.05899001f, -0.02817162f, 0.01220131f, -0.02016687f, -0.04483632f, -0.02736416f, -0.05033544f, 
    -0.02488101f, -0.00757442f, -0.01748281f, 0.01530454f, -0.01185590f, -0.01756733f, 0.01096040f, -0.05305571f, 
    -0.03295639f, 0.04470911f, -0.00491079f, -0.01192472f, 0.03883881f, -0.06030647f, 0.01521637f, -0.05905959f, 
    0.04769092f, 0.01344345f, -0.00180737f, 0.04770710f, -0.02437157f, 0.01648783f, -0.02700526f, 0.02663350f, 
    -0.04581608f, -0.02689234f, -0.03547441f, -0.04800083f, -0.04581191f, -0.03356080f, -0.05047746f, 0.01192923f, 
    0.02145658f, 0.01489817f, -0.04908827f, 0.01299018f, 0.03645694f, 0.02662663f, -0.02548140f, -0.05346784f, 
    0.03581716f, -0.03960250f, -0.05405978f, -0.04375274f, -0.01773300f, 0.01111365f, 0.01374068f, 0.01737217f, 
    0.00932312f, -0.05312566f, -0.03063433f, 0.03589201f, -0.04214262f, 0.02417626f, 0.03159723f, 0.00650687f, 
    0.03537534f, -0.05449082f, -0.02887774f, 0.00863836f, 0.04780963f, -0.03915328f, -0.02995918f, -0.06122842f, 
    0.01325611f, -0.05787810f, 0.00493478f, -0.02935063f, 0.02885295f, 0.04834455f, -0.05540231f, -0.01277499f, 
    0.01148681f, 0.03081848f, -0.02785089f, 0.00798292f, -0.04655297f, -0.00690300f, -0.05849040f, 0.04807866f, 
    -0.01726417f, -0.03932474f, -0.04271568f, 0.01294048f, -0.01039559f, 0.01470724f, -0.02086143f, -0.06061247f, 
    0.00494634f, 0.01976913f, -0.03113215f, -0.04452492f, -0.02341499f, -0.06049545f, -0.04267306f, 0.01769961f, 
    -0.04343875f, -0.01018696f, -0.03528791f, 0.03052070f, 0.04569552f, -0.06092163f, -0.02676167f, 0.04052601f, 
    -0.03820313f, -0.02759804f, -0.00488238f, 0.02454404f, -0.04145239f, 0.04547343f, 0.00194510f, 0.01515203f, 
    0.00286195f, -0.04602323f, -0.03537771f, -0.04001044f, 0.00885190f, 0.01809753f, 0.03756596f, -0.01285888f, 
    -0.00101604f, -0.03884419f, -0.01308711f, -0.01213166f, -0.03489708f, -0.04846036f, 0.03276255f, -0.00961200f, 
    0.03559015f, 0.04067421f, -0.04502313f, -0.05571765f, 0.02570596f, 0.04329512f, 0.02123346f, 0.03185777f, 
    -0.04915804f, 0.02222001f, -0.02146550f, -0.02387889f, 0.01604732f, -0.03950995f, 0.03522457f, 0.03396229f, 
    -0.03659885f, -0.04006439f, -0.06074787f, 0.03443447f, 0.03737307f, 0.03322716f, 0.00593304f, -0.00501113f, 
    0.01589496f, 0.04438794f, -0.01614537f, 0.00220273f, -0.01215733f, -0.05496790f, 0.00013607f, -0.02927943f, 
    -0.05272781f, -0.05722017f, -0.04792795f, 0.00372717f, -0.03911356f, -0.05650313f, 0.02644701f, 0.02874107f, 
    -0.01652407f, -0.01089322f, -0.00692257f, 0.02284793f, 0.01347902f, 0.04132877f, -0.01903707f, -0.00217077f, 
    -0.01897233f, -0.00850484f, 0.04193256f, -0.05550550f, 0.03887843f, 0.03361908f, -0.02088903f, -0.03318890f, 
    0.02812740f, 0.02187895f, -0.03258927f, 0.02021649f, 0.02527963f, -0.06125702f, 0.03351240f, 0.01297383f, 
    0.00559609f, 0.00975750f, 0.01133982f, 0.04067990f, -0.01522741f, -0.01085600f, 0.03507730f, -0.04070808f, 
    0.01676998f, -0.04629495f, -0.01512680f, 0.01387754f, 0.06153262f, 0.02410737f, 0.02699480f, 0.04899441f, 
    -0.03298777f, 0.03732408f, -0.04974783f, -0.00552369f, -0.03724070f, 0.01798188f, 0.02073695f, 0.05206462f, 
    -0.01084029f, -0.01957857f, -0.01640869f, 0.03871079f, -0.01268134f, 0.01584614f, 0.00431048f, -0.00408483f, 
    0.01796737f, 0.03383229f, -0.00699291f, -0.04181141f, -0.05102132f, 0.00937409f, 0.00083922f, 0.02944192f, 
    0.01552348f, 0.01213605f, -0.03123179f, 0.03327075f, -0.02250675f, -0.06093919f, -0.00077897f, -0.00742452f, 
    0.02990403f, -0.05363167f, 0.01265007f, -0.00395732f, 0.00359623f, -0.02727708f, -0.01004337f, -0.03681590f, 
    0.00868653f, 0.02932450f, -0.05112594f, -0.06385083f, 0.00313815f, 0.01247632f, -0.02966955f, -0.03751302f, 
    -0.00541365f, 0.03608306f, 0.00690868f, -0.01463179f, 0.00658889f, -0.03988113f, -0.03094690f, -0.00340112f, 
    -0.02944113f, -0.01822949f, -0.01855224f, -0.04005170f, -0.06218152f, -0.04630403f, -0.00353445f, 0.01281870f, 
    -0.03209196f, -0.01588610f, -0.04395888f, -0.01324402f, -0.05149150f, 0.04602146f, -0.00215402f, 0.04598537f, 
    -0.02544402f, -0.01675859f, 0.01844736f, 0.02233819f, -0.05038708f, -0.00541944f, 0.02560718f, -0.00511982f, 
    0.04540755f, 0.00944033f, 0.01605478f, 0.03050802f, -0.03145555f, -0.00509275f, -0.02511784f, -0.02561058f, 
    0.01167347f, -0.01951231f, 0.02105370f, -0.04752576f, -0.02558945f, -0.00649937f, 0.02054678f, 0.00365247f, 
    0.04164914f, 0.03260576f, -0.04290664f, -0.05064701f, 0.01269011f, -0.04230723f, -0.00888163f, -0.04632622f, 
    0.00924767f, 0.00116002f, -0.00072050f, -0.04269031f, -0.02199842f, 0.02392572f, 0.01880632f, -0.01562662f, 
    -0.02935148f, -0.00301388f, -0.01144102f, -0.02260050f, 0.02181260f, 0.02465550f, 0.01605436f, 0.02073788f, 
    -0.03021779f, -0.05409686f, -0.00178728f, 0.04277094f, -0.00187905f, 0.01532902f, 0.02479692f, 0.01865385f, 
    -0.02516675f, -0.04590084f, 0.00287483f, -0.04382794f, 0.00957401f, -0.03524554f, -0.01779525f, 0.03632941f, 
    0.03979448f, 0.03203203f, -0.01847230f, 0.02271441f, -0.02913187f, 0.02849651f, -0.03290592f, 0.02135344f, 
    -0.06303498f, 0.03257996f, 0.04958318f, -0.01278471f, 0.02825211f, 0.03132868f, -0.06025902f, -0.00839361f, 
    0.00167331f, -0.04636648f, -0.02792940f, -0.05093713f, -0.01160658f, -0.01964293f, -0.03834056f, -0.02915426f, 
    -0.02328646f, -0.05254614f, 0.04040616f, 0.00510164f, -0.02227131f, -0.00056395f, -0.04687413f, 0.03896446f, 
    -0.00860530f, -0.05020595f, -0.03850823f, 0.03787850f, -0.05770976f, 0.03724003f, 0.00739388f, -0.05944123f, 
    -0.06143941f, 0.00505883f, -0.03325225f, 0.01748873f, 0.01930506f, 0.00852704f, -0.03229584f, 0.01496242f, 
    -0.05197573f, 0.01365367f, 0.02518129f, 0.01298103f, -0.01870702f, -0.05733651f, 0.03444632f, -0.02357953f, 
    -0.00996623f, -0.01234016f, -0.02674115f, 0.00614302f, 0.04096267f, -0.03817752f, -0.05650371f, 0.03168993f, 
    -0.04600849f, -0.05433134f, -0.05496943f, -0.05625034f, -0.02924764f, -0.03443656f, -0.02489432f, -0.04063178f, 
    -0.03851381f, 0.03026075f, -0.04570498f, 0.03496033f, -0.00693410f, -0.03641548f, -0.05794139f, 0.00483751f, 
    0.00777012f, 0.00104511f, -0.02080978f, 0.00941718f, -0.01597978f, 0.00820466f, -0.03707461f, -0.05285323f, 
    -0.05035166f, -0.03867632f, -0.05458847f, 0.04730457f, 0.01632726f, -0.03986693f, 0.00082616f, 0.00419591f, 
    0.00887284f, -0.04165987f, -0.02670072f, 0.01456741f, 0.02651996f, -0.03136889f, -0.01940745f, -0.03706081f, 
    -0.03361774f, 0.01425819f, 0.00330804f, 0.03579002f, 0.00369993f, 0.04514774f, -0.05167207f, -0.00420069f, 
    -0.04453171f, -0.03134628f, -0.02206097f, 0.01468265f, -0.05282860f, -0.05314202f, -0.01459602f, -0.02332838f, 
    -0.03178605f, -0.02009551f, 0.00857894f, -0.03986042f, -0.00860874f, 0.03769455f, 0.00815682f, 0.04229361f, 
    -0.02808338f, -0.03698245f, -0.00192292f, 0.04378298f, 0.00626874f, -0.05987870f, -0.02711022f, -0.03631891f, 
    0.01840003f, 0.01326444f, 0.01716354f, -0.01125239f, 0.00925120f, 0.01430965f, -0.03293418f, -0.01356554f, 
    -0.04387790f, -0.01100878f, 0.02723285f, 0.01217440f, 0.03083825f, 0.02187132f, 0.04981699f, -0.01522482f, 
    0.02032422f, 0.01501741f, -0.00963460f, -0.01582748f, -0.02738563f, -0.03716619f, -0.01472402f, -0.03877199f, 
    0.03456903f, 0.01591404f, 0.04566616f, -0.00139097f, -0.02632516f, -0.02241705f, -0.00617391f, -0.00622369f, 
    -0.04730227f, 0.00788981f, -0.06165691f, 0.04204022f, 0.00983652f, 0.02335950f, 0.04286271f, 0.04597056f, 
    0.04672708f, 0.01044060f, 0.01034099f, 0.04588245f, 0.03890567f, -0.02235075f, -0.05389971f, -0.05483336f, 
    0.00791220f, -0.00352044f, -0.03927518f, 0.00004587f, 0.01991206f, 0.04130903f, -0.05824740f, 0.02051768f, 
    0.01512490f, -0.03471667f, -0.01404434f, -0.00574867f, 0.00649061f, -0.03578281f, 0.01235102f, -0.04190056f, 
    0.01545089f, 0.01460463f, -0.02340956f, -0.02849394f, 0.03221872f, -0.03256797f, -0.05960599f, -0.02040338f, 
    0.01554945f, 0.06245981f, 0.00008635f, -0.03696511f, -0.02504955f, 0.01518451f, -0.00450176f, -0.06513370f, 
    -0.05898792f, 0.00515041f, -0.05939323f, -0.00409342f, -0.02772655f, -0.03795239f, -0.07116611f, -0.06081788f, 
    0.03476492f, 0.01812574f, 0.01460344f, -0.04726512f, -0.01012199f, -0.02824876f, 0.02373348f, -0.05146405f, 
    -0.07430512f, -0.00380606f, 0.01508146f, -0.05432545f, -0.06842925f, 0.00685467f, -0.04662782f, -0.03354061f, 
    -0.02742323f, -0.04821586f, -0.02695194f, -0.00613686f, -0.03850283f, -0.03311846f, -0.01944882f, -0.00131170f, 
    -0.04166326f, 0.03393656f, -0.05102466f, 0.02826072f, 0.00250667f, -0.00292894f, -0.03837296f, -0.04557818f, 
    -0.06446666f, 0.06371805f, 0.04374995f, -0.05196235f, -0.07355636f, 0.01580129f, -0.02346182f, -0.01857475f, 
    0.02736684f, -0.03994849f, -0.00212284f, -0.01324326f, -0.01925798f, -0.02925978f, -0.03766658f, -0.00433873f, 
    0.01080858f, -0.09701880f, -0.09227777f, -0.05729134f, -0.02202144f, -0.05001871f, 0.02520581f, -0.06061882f, 
    -0.01172414f, -0.00615883f, -0.03882442f, -0.01363655f, -0.01252736f, -0.00398640f, -0.02323231f, -0.02759298f, 
    0.00175076f, -0.04645018f, -0.02692590f, -0.03551157f, 0.02011805f, -0.03016272f, 0.03939911f, 0.00014661f, 
    0.04417427f, 0.00905888f, 0.02409500f, -0.00021648f, 0.02404506f, 0.01875578f, -0.02189166f, -0.05464676f, 
    0.01843536f, 0.00653557f, 0.00097738f, -0.02898237f, -0.06392006f, 0.03134330f, -0.02791723f, 0.00495770f, 
    0.02563004f, 0.00195526f, -0.04918601f, -0.07313564f, -0.07877866f, -0.03667193f, 0.02886842f, -0.03743739f, 
    -0.06426610f, -0.00826786f, 0.00818058f, -0.05843182f, 0.01724655f, 0.04750292f, -0.04612534f, -0.02164440f, 
    0.00272408f, -0.05185167f, 0.00181255f, -0.05981385f, -0.04851113f, 0.00748024f, 0.03925554f, -0.04111427f, 
    -0.02909330f, -0.02100020f, -0.01821365f, 0.04390913f, 0.01206416f, -0.01208315f, 0.02887946f, 0.02714421f, 
    -0.03728481f, -0.01933772f, 0.01546187f, -0.00911027f, -0.09043115f, -0.08486643f, -0.06017756f, 0.01044201f, 
    -0.00604156f, -0.02580463f, 0.00314665f, -0.08955400f, -0.07294605f, -0.04925712f, 0.02162084f, -0.04376717f, 
    -0.00091495f, -0.04682484f, -0.06890655f, 0.00176124f, -0.01793169f, 0.01524134f, -0.04368142f, 0.04499690f, 
    -0.05094124f, -0.04241440f, 0.04565165f, -0.03673912f, -0.05365134f, 0.03647961f, 0.02933835f, 0.00324026f, 
    -0.05476888f, 0.02396021f, 0.01499672f, 0.01136377f, 0.01895157f, -0.03645582f, -0.03176815f, 0.01150589f, 
    -0.06017537f, -0.00896509f, 0.03250547f, -0.01349310f, -0.02833231f, -0.01110694f, -0.07177895f, -0.03298426f, 
    -0.04398256f, -0.05418120f, 0.02373403f, 0.00766097f, -0.04004992f, -0.06864520f, -0.06328716f, -0.00060284f, 
    -0.06805414f, -0.02072444f, 0.04140022f, -0.04193594f, -0.00293343f, 0.03584941f, -0.07193010f, 0.04135436f, 
    -0.04087108f, 0.00888954f, -0.05243998f, -0.02619155f, -0.04123900f, -0.06146497f, -0.06893636f, -0.08802111f, 
    0.03707436f, 0.02424847f, -0.00000855f, -0.04934198f, -0.03039168f, -0.04671615f, -0.00698397f, -0.05835194f, 
    -0.01914391f, -0.02764414f, 0.01667159f, -0.01327458f, -0.05973423f, -0.06817728f, 0.02033239f, -0.07968700f, 
    0.00988193f, -0.07023761f, -0.00878751f, -0.02533228f, -0.00210117f, 0.00273175f, -0.01199083f, -0.07400044f, 
    0.03713312f, -0.07249835f, 0.05103872f, 0.03963501f, -0.05617281f, -0.05832817f, -0.03445950f, -0.00937892f, 
    -0.08923991f, 0.01189349f, -0.05568326f, 0.02653413f, -0.07176841f, 0.04192075f, -0.00790462f, -0.05955756f, 
    -0.07798949f, -0.05016981f, 0.04209019f, 0.03226815f, -0.01529205f, -0.00235672f, -0.06409202f, -0.05438723f, 
    -0.05223943f, 0.05966181f, 0.07199383f, 0.03830040f, -0.07627580f, -0.06738642f, -0.06137541f, -0.02159974f, 
    -0.00178182f, -0.03979803f, 0.04955027f, -0.02917337f, -0.00723482f, 0.01729604f, -0.05241203f, -0.02768339f, 
    -0.07733862f, -0.04717665f, -0.00659132f, -0.05831154f, 0.04328387f, 0.05063256f, -0.03060634f, -0.04177138f, 
    -0.05831797f, 0.04024582f, 0.02775635f, -0.04823258f, -0.06378075f, -0.00931035f, 0.00766500f, -0.03929261f, 
    -0.05011333f, 0.02018701f, 0.04560199f, -0.01451152f, -0.06958607f, 0.00843427f, -0.03521333f, -0.05826655f, 
    -0.05124597f, -0.01008336f, 0.03431436f, -0.01060485f, -0.05188157f, -0.01147719f, 0.00822888f, -0.05507345f, 
    -0.01505131f, -0.02272462f, 0.04666681f, -0.07223861f, -0.04894156f, -0.00095256f, 0.03291457f, 0.01074047f, 
    -0.01050186f, 0.01079376f, -0.06333062f, -0.06992037f, -0.03715655f, 0.01500802f, -0.04289521f, -0.01757326f, 
    0.27116036f, -0.07540764f, 0.03965499f, -0.10655490f, -0.30140319f, 0.03563017f, 0.00621703f, 0.03936313f, 
    -0.09727298f, 0.02600252f, -0.08100948f, -0.02788900f, 0.11318141f, 0.05318535f, -0.04104846f, -0.16966845f, 
    0.04337117f, 0.01876878f, 0.17164594f, -0.13876471f, 0.13052396f, -0.31349280f, -0.01965487f, -0.11492620f, 
    -0.09653245f, 0.11121837f, 0.28093308f, -0.04288981f, -0.06674139f, 0.07792162f, 0.10986638f, -0.12127969f, 
    0.08804543f, 0.03070666f, 0.15480863f, 0.00402110f, 0.04471207f, 0.13379683f, 0.07178631f, 0.05851338f, 
    -0.17300916f, 0.18894242f, -0.16060662f, -0.03656874f, -0.17655133f, 0.07753187f, -0.01510803f, 0.10514458f, 
    0.01669260f, -0.06118910f, 0.02152930f, 0.04812758f, -0.16232538f, -0.03063756f, 0.07838680f, 0.18455127f, 
    0.01712425f, 0.03314561f, -0.05216710f, 0.06744733f, -0.06627954f, -0.15841262f, -0.00723205f, 0.08020022f, 
    0.34802413f, 0.11075289f, 0.11366720f, -0.01927338f, -0.05728694f, 0.01011103f, 0.16543268f, 0.15325032f, 
    0.07932236f, 0.24274199f, 0.15608510f, -0.11547342f, -0.03536311f, 0.00682712f, -0.11650334f, -0.04873943f, 
    0.27839550f, -0.36491680f, 0.23777142f, -0.00973832f, -0.47953176f, 0.18100408f, -0.17325908f, 0.13419825f, 
    0.00445414f, 0.16975485f, -0.14307725f, -0.15038911f, -0.06454419f, 0.00156079f, 0.01991180f, -0.22390339f, 
    -0.10549950f, -0.11161930f, 0.16582635f, 0.01925975f, -0.53135401f, 0.12700798f, 0.13081075f, -0.16374350f, 
    0.07124439f, 0.05906551f, -0.00115266f, 0.04892724f, -0.06142450f, -0.01976609f, 0.31702596f, 0.05853785f, 
    0.02106510f, -0.09014980f, -0.01181276f, 0.02831906f, 0.23056544f, -0.03727935f, -0.18414330f, 0.02869708f, 
    0.13333523f, -0.11118965f, -0.11217345f, 0.25500864f, -0.04540418f, -0.15100907f, -0.14254309f, -0.00837921f, 
    0.09442334f, 0.07465788f, 0.06915671f, 0.06373418f, -0.08425245f, -0.00184280f, -0.00414767f, 0.08700476f, 
    0.05733065f, 0.02377933f, 0.08843806f, -0.11978868f, 0.29911587f, 0.17323411f, 0.11139254f, -0.22212367f, 
    -0.21438290f, -0.05824020f, 0.01997976f, -0.03109694f, 0.12153387f, -0.03617172f, 0.00221396f, -0.03414766f, 
    0.13632682f, 0.09732752f, -0.10953659f, -0.07345042f, 0.03500022f, -0.15856929f, 0.12633362f, 0.01553177f, 
    -0.37400588f, 0.05159890f, -0.42039663f, -0.19221254f, -0.02964124f, -0.09505960f, -0.20229907f, -0.08792027f, 
    0.05728121f, 0.01341819f, 0.00402988f, 0.09358491f, 0.11288135f, 0.10556618f, 0.10733324f, -0.10990953f, 
    0.06112052f, -0.08908267f, -0.05436932f, -0.07230438f, 0.11040108f, 0.04637154f, 0.08079931f, 0.39832881f, 
    0.19282660f, -0.24254572f, -0.19626722f, 0.06928713f, 0.05207342f, 0.07685736f, 0.03478898f, -0.08743425f, 
    0.04764158f, -0.09549985f, 0.03141424f, -0.04247811f, -0.04308783f, 0.03655249f, 0.02393289f, -0.01362644f, 
    0.27143618f, -0.14734983f, -0.09412640f, -0.09054103f, 0.04557918f, 0.08362250f, 0.14702143f, -0.02479126f, 
    -0.10008875f, 0.07091103f, 0.05577327f, -0.09085732f, 0.17444481f, 0.10481768f, 0.00658412f, -0.01019943f, 
    0.17790280f, 0.01528744f, 0.00541623f, -0.01874281f, 0.08538342f, 0.24255462f, -0.38346979f, 0.00181808f, 
    0.14611238f, -0.01791825f, 0.15503158f, 0.11409185f, 0.04911363f, -0.01422513f, 0.09476057f, 0.11770457f, 
    -0.04575969f, 0.07925138f, -0.06400244f, 0.08778711f, -0.04478635f, 0.10270539f, -0.05847889f, 0.26004252f, 
    0.30803967f, 0.01095698f, -0.23229772f, -0.22841570f, -0.12322899f, 0.13230041f, 0.06369903f, 0.03694849f, 
    -0.06606043f, -0.05415712f, 0.02087942f, 0.08930355f, 0.08360646f, -0.03200003f, 0.13414443f, -0.02665359f, 
    -0.08651056f, -0.06160089f, -0.00229768f, 0.17115426f, 0.10578896f, 0.23674570f, 0.02947246f, 0.09849955f, 
    -0.16209479f, -0.00381205f, 0.09064858f, -0.16209070f, 0.14508772f, -0.06254904f, 0.10523991f, 0.02290902f, 
    0.00258937f, -0.06752238f, -0.14030546f, 0.02694331f, -0.03528141f, -0.00243847f, -0.01798654f, 0.00085063f, 
    0.14906758f, 0.12225290f, -0.09014317f, -0.05484254f, 0.17280433f, 0.18107916f, 0.01108633f, 0.03964356f, 
    -0.01822738f, 0.05269853f, -0.03260058f, -0.00437339f, 0.08361938f, 0.00161169f, -0.01881162f, -0.10323410f, 
    0.04398234f, 0.12958843f, 0.24748422f, 0.15045935f, 0.25274134f, -0.08827423f, 0.05324410f, 0.06794623f, 
    0.04120439f, -0.10645400f, -0.10730991f, 0.04940474f, 0.02883288f, 0.02969377f, -0.12119243f, -0.08991156f, 
    0.00582801f, 0.06296711f, -0.09074141f, -0.01095085f, -0.06246053f, 0.05751794f, 0.04025536f, 0.01615469f, 
    0.48352766f, 0.17040190f, 0.34218156f, -0.06615966f, -0.04180642f, -0.02124471f, -0.08856381f, -0.04679685f, 
    -0.01595530f, 0.00316453f, -0.13519149f, 0.09905832f, -0.05946345f, 0.01924133f, 0.01182901f, -0.01110792f, 
    0.00714534f, -0.06277842f, 0.01763822f, -0.13244154f, 0.36643600f, -0.17828228f, -0.02270965f, -0.07802957f, 
    0.16335985f, 0.00457853f, 0.06744349f, 0.01811592f, 0.03392050f, -0.05323566f, -0.04513946f, -0.09580939f, 
    0.05930628f, -0.00660423f, 0.00539878f, 0.00059766f, -0.01745152f, -0.04161463f, 0.05983601f, -0.16566341f, 
    -0.02940691f, 0.13555792f, -0.00693497f, -0.21428652f, -0.11005015f, -0.05945750f, -0.13278934f, 0.08421205f, 
    0.09129526f, -0.00032277f, -0.03671359f, -0.01613261f, -0.12637749f, 0.07024613f, 0.06973860f, 0.02712321f, 
    -0.09315189f, 0.05344762f, -0.05668627f, -0.08108635f, 0.27024180f, 0.22367394f, 0.06669535f, -0.02299785f, 
    0.19907516f, -0.08949284f, -0.07445975f, 0.12452150f, 0.04826313f, 0.03245201f, -0.02073303f, -0.06974579f, 
    0.16778505f, 0.06240641f, -0.01823970f, 0.04880039f, 0.04988364f, -0.09542230f, -0.09888789f, 0.01515086f, 
    -0.07002183f, -0.18698868f, 0.08147229f, -0.08738253f, -0.03335854f, 0.09470509f, -0.14291139f, -0.00934049f, 
    -0.08301628f, 0.01419024f, -0.14070737f, -0.02908046f, -0.09186095f, -0.07596814f, -0.08766656f, -0.10767536f, 
    0.02938995f, -0.27629724f, 0.02216914f, -0.03894360f, 0.14862524f, 0.08398634f, -0.29225498f, -0.24411707f, 
    0.04373954f, -0.04140050f, 0.06381467f, -0.09955119f, -0.02886731f, -0.18276617f, 0.00784606f, -0.03004022f, 
    0.00121779f, -0.06383713f, 0.06828606f, -0.07413104f, 0.04974629f, -0.08232387f, -0.09548286f, 0.07433806f, 
    0.55125535f, -0.03738663f, 0.14409907f, 0.04515164f, 0.08638095f, -0.07695220f, 0.04200794f, -0.07381753f, 
    -0.01470556f, 0.16814578f, 0.05118944f, 0.03175807f, 0.07456762f, 0.07246225f, -0.03067743f, 0.09216978f, 
    0.01947025f, -0.05613588f, 0.06582623f, -0.09155530f, -0.07301948f, 0.06484382f, 0.22720632f, 0.09334330f, 
    -0.01332610f, 0.07165407f, 0.04137241f, -0.08407601f, 0.11546923f, 0.06136945f, -0.12155382f, -0.03621560f, 
    0.07667423f, 0.15088744f, -0.09470263f, 0.02392726f, 0.08903743f, -0.09008656f, 0.05426230f, -0.22846000f, 
    -0.31338766f, -0.08205494f, -0.08445580f, -0.14349777f, 0.10623160f, -0.01198070f, -0.00649428f, 0.00434180f, 
    0.02923421f, 0.02942196f, -0.00993207f, 0.07611112f, 0.01052247f, -0.09061734f, -0.04659450f, -0.05001806f, 
    -0.03932712f, -0.02526063f, 0.01489001f, -0.12473164f, 0.34070292f, 0.12785624f, 0.17363948f, 0.41806406f, 
    -0.05947061f, 0.13445288f, 0.04856392f, -0.13039473f, -0.15088479f, 0.08435525f, 0.11459859f, 0.00304053f, 
    -0.05875732f, -0.04984045f, -0.09764441f, 0.00085982f, 0.10301962f, 0.07184692f, 0.01682331f, 0.02794345f, 
    0.58266157f, -0.00743082f, 0.13004889f, 0.06677452f, 0.37843713f, 0.00306461f, -0.00843736f, 0.14382793f, 
    0.03875249f, -0.00264748f, -0.09545824f, -0.06268704f, -0.05424973f, -0.03181781f, 0.03821785f, 0.00029298f, 
    0.02292090f, 0.04503708f, 0.00177618f, -0.06031549f, 0.80042279f, 0.21017730f, -0.09299403f, 0.04910625f, 
    -0.05131857f, 0.04647598f, 0.00851479f, 0.07042938f, 0.15486400f, -0.05436631f, 0.17337981f, -0.02040181f, 
    -0.02947418f, 0.08394307f, -0.15094216f, -0.05657052f, -0.04309975f, 0.03429341f, -0.14746445f, 0.04649616f, 
    -0.25545645f, -0.16512750f, -0.31485009f, -0.06186825f, 0.01509435f, 0.02610113f, -0.14447051f, 0.10001870f, 
    -0.01306282f, 0.03324344f, -0.01869585f, 0.03286407f, 0.03683611f, -0.04471188f, 0.06746650f, -0.03445479f, 
    -0.13681699f, -0.12045481f, 0.01528475f, 0.16717917f, 0.03948155f, -0.13808836f, 0.19533552f, -0.08507378f, 
    0.05890272f, -0.08896591f, 0.12101852f, -0.03864535f, 0.14372687f, 0.11492108f, -0.10724164f, -0.01023642f, 
    0.04031983f, 0.04233149f, -0.03923608f, 0.01141712f, 0.03009174f, -0.05256479f, -0.09209477f, -0.02989971f, 
    -0.17329422f, 0.21117230f, 0.31203970f, -0.01675241f, -0.03974573f, -0.01312922f, -0.10717279f, -0.08512916f, 
    0.03335841f, 0.02228251f, 0.00488142f, -0.10504135f, -0.05840490f, -0.08385985f, 0.00204914f, -0.00211907f, 
    -0.02219827f, -0.05826078f, -0.01711818f, 0.01218485f, 0.13997295f, -0.08234926f, 0.15122433f, 0.05104167f, 
    0.02511691f, 0.10307182f, 0.07787198f, -0.01478963f, -0.17719159f, 0.11210415f, -0.07888275f, -0.09449821f, 
    -0.02672544f, 0.06817497f, -0.08010136f, -0.00643444f, 0.02113003f, -0.02065460f, -0.05048301f, -0.02831705f, 
    0.27710259f, -0.37017196f, 0.03042627f, 0.06650598f, 0.14295344f, -0.15103544f, 0.00592791f, -0.04695970f, 
    0.08419591f, 0.00953878f, -0.09520514f, -0.03126606f, -0.00294891f, -0.07168317f, -0.03485412f, 0.00350511f, 
    -0.04234077f, 0.06356251f, 0.12770538f, 0.05066039f, -0.07474188f, 0.11352232f, -0.15471126f, -0.00321079f, 
    0.17757431f, 0.08825953f, 0.08979160f, 0.01196008f, 0.04549320f, 0.08265617f, 0.15351990f, -0.06313221f, 
    -0.00421300f, -0.01923646f, 0.01601160f, -0.03314098f, -0.00441730f, -0.06032056f, -0.01221814f, -0.00425923f, 
    0.03202029f, -0.28282979f, 0.09635694f, -0.20612489f, -0.12353328f, 0.02101720f, -0.03052808f, 0.04046462f, 
    0.10923175f, 0.01768252f, -0.01837775f, -0.01896751f, 0.00809177f, 0.12704961f, -0.00298582f, 0.04171620f, 
    0.02785765f, -0.02551106f, 0.01923779f, -0.07482053f, 0.00082179f, 0.26203305f, 0.07686511f, 0.01830493f, 
    0.12896977f, 0.11217052f, -0.01649596f, 0.10117968f, 0.05217601f, 0.02072380f, 0.00554795f, -0.05583613f, 
    0.01232730f, 0.10762729f, 0.00992336f, 0.15214941f, 0.02837586f, -0.03006837f, -0.04007267f, -0.04099119f, 
    0.27611676f, -0.30303448f, -0.09748168f, -0.05960977f, -0.01449256f, 0.05362248f, -0.10204694f, 0.05628257f, 
    0.00420647f, -0.05312078f, 0.10221393f, 0.15111832f, -0.01246748f, -0.06218701f, 0.06961402f, -0.06523215f, 
    -0.04716719f, -0.09956489f, 0.00842325f, -0.06440084f, 0.07322850f, -0.10405847f, 0.21536203f, -0.22700736f, 
    -0.09117492f, 0.11690673f, 0.04884999f, 0.05869403f, 0.01599605f, -0.04485034f, 0.08002890f, 0.10519969f, 
    0.10172404f, -0.04684341f, 0.11704767f, -0.03382427f, -0.00606961f, -0.07310175f, 0.07111264f, 0.02155502f, 
    0.41861007f, -0.28463951f, -0.16790630f, 0.09089649f, -0.07731231f, -0.16237873f, 0.02895359f, 0.05918503f, 
    -0.05596342f, -0.02164401f, 0.16710927f, -0.02806302f, 0.02257555f, 0.08544337f, 0.03202875f, 0.09889999f, 
    0.01692043f, -0.02319587f, -0.06938741f, 0.17625773f, -0.01190337f, 0.06317221f, 0.02738906f, -0.12157836f, 
    -0.20299867f, -0.04262673f, -0.07106572f, 0.08037374f, 0.04155646f, -0.00933493f, -0.00528299f, -0.01965289f, 
    -0.03545758f, 0.08030675f, -0.15716037f, 0.04659547f, 0.07309892f, -0.11643436f, -0.03866164f, -0.00095710f, 
    0.14858750f, -0.28911582f, -0.19837156f, -0.04491269f, 0.16120036f, -0.07289021f, -0.01693852f, 0.01270010f, 
    0.06329758f, 0.12275381f, -0.01675216f, 0.16345401f, 0.00640069f, -0.05694551f, 0.06787074f, 0.12758090f, 
    -0.10456552f, 0.06081097f, -0.02629733f, -0.02840860f, 0.32379872f, -0.08262189f, -0.05367852f, -0.11129352f, 
    -0.31705984f, -0.15555207f, -0.14144565f, -0.12670363f, 0.05699360f, 0.00970648f, 0.07224166f, -0.04445486f, 
    -0.07582941f, 0.03845289f, -0.06660332f, 0.00774401f, 0.05544071f, -0.12828033f, -0.04870018f, 0.03828220f, 
    0.18151671f, 0.12141448f, 0.13946460f, 0.00296386f, 0.20248669f, -0.02314007f, -0.04587295f, 0.10150713f, 
    -0.02092185f, 0.05541784f, -0.06227234f, -0.07964189f, 0.10600623f, -0.05823604f, -0.06756783f, -0.09103905f, 
    0.00022427f, 0.00474667f, -0.10285003f, -0.01798107f, -0.04315498f, 0.45459098f, -0.12593900f, -0.03120185f, 
    0.29302612f, 0.14416470f, -0.02604297f, -0.03588612f, 0.03620397f, 0.08724447f, -0.03915666f, -0.01963977f, 
    0.05569557f, 0.04326549f, 0.03572629f, 0.07925016f, 0.03991029f, 0.11752309f, -0.14468572f, 0.01126437f, 
    0.06571636f, 0.08461006f, -0.22523683f, -0.11406889f, 0.00488106f, 0.20152700f, 0.10400052f, 0.08466734f, 
    -0.02371230f, 0.08818951f, 0.02124075f, 0.11139848f, 0.04493347f, 0.04763636f, 0.00022701f, 0.18855061f, 
    0.02888272f, -0.05292537f, 0.10310643f, -0.03737311f, 0.15039858f, -0.28566617f, 0.10483970f, -0.25666374f, 
    -0.06432983f, -0.10909105f, 0.03557707f, 0.13667810f, -0.02320888f, 0.01617008f, -0.05422943f, -0.18511161f, 
    0.12458314f, 0.04038969f, -0.04908359f, 0.06462001f, 0.12504090f, 0.01180523f, -0.02999611f, 0.03084099f, 
    0.05111291f, -0.18771368f, 0.07493854f, 0.05238250f, 0.30351117f, -0.04066484f, -0.13127597f, 0.04421186f, 
    -0.09251308f, -0.00807486f, 0.12890603f, 0.00755511f, -0.07828575f, 0.01021796f, 0.04508384f, -0.07113282f, 
    0.01537669f, 0.04936797f, 0.06812501f, 0.15940918f, 0.58610356f, -0.19670881f, -0.16967483f, 0.07149883f, 
    -0.24769804f, -0.05099251f, 0.00500623f, 0.04792267f, 0.06509821f, 0.05105488f, 0.10551572f, -0.01030369f, 
    -0.10643892f, 0.08033559f, 0.09957664f, 0.06657480f, -0.01889879f, 0.02999490f, 0.00361112f, 0.00941666f, 
    -0.05158425f, 0.01826157f, -0.02323541f, -0.00720100f, 0.03727771f, -0.05311379f, -0.01886333f, -0.03029066f, 
    -0.01512718f, 0.03171294f, -0.00414826f, 0.04802654f, -0.04379274f, -0.01010883f, -0.02068479f, 0.05129709f, 
    0.03124282f, -0.01607038f, -0.04498352f, -0.02483345f, 0.03204767f, -0.05050571f, -0.04158622f, 0.04220219f, 
    -0.01789527f, 0.00048376f, 0.01802393f, -0.05193601f, 0.03463624f, 0.02479032f, 0.00606177f, 0.04919858f, 
    -0.03496459f, 0.00410179f, 0.01080521f, 0.01171291f, -0.04066375f, 0.02149537f, 0.02156277f, -0.04179169f, 
    -0.04497266f, 0.03823940f, -0.02797548f, 0.00474340f, -0.06243689f, 0.01612728f, -0.00238011f, -0.02200410f, 
    -0.03406225f, -0.01025619f, -0.00691761f, -0.00221157f, 0.03404907f, -0.02668670f, -0.00736451f, -0.03490929f, 
    -0.00752450f, -0.06182323f, -0.02266858f, 0.04561962f, 0.01711939f, 0.00394048f, 0.02741640f, -0.02140763f, 
    -0.04798582f, 0.04495625f, -0.03837907f, 0.00704815f, 0.03797188f, 0.01050280f, -0.00798928f, -0.00094419f, 
    -0.03047295f, -0.00302629f, -0.02943859f, -0.05276897f, -0.00052125f, -0.02417015f, 0.03936559f, -0.04978398f, 
    0.01316696f, -0.05633486f, -0.03250677f, 0.02017848f, 0.00201227f, 0.01420487f, -0.03523893f, -0.03911695f, 
    0.02752898f, -0.03687871f, -0.00885933f, -0.02910926f, -0.00033419f, -0.04880740f, -0.01031553f, -0.01943186f, 
    -0.06229074f, -0.01603942f, -0.04792650f, -0.04408457f, -0.03412595f, -0.03824229f, -0.02826481f, 0.01195514f, 
    -0.04785039f, 0.02108750f, 0.01186400f, 0.02539886f, -0.04061398f, -0.00487411f, 0.00455019f, -0.01443040f, 
    -0.03500091f, 0.04315038f, 0.00545031f, -0.00733235f, -0.03040577f, 0.02989519f, -0.05116475f, -0.01743869f, 
    0.03504364f, -0.00185319f, 0.03089484f, -0.02067668f, -0.03056070f, 0.03823747f, -0.04316003f, -0.00270854f, 
    0.00713962f, 0.01594259f, -0.03025774f, -0.04297344f, 0.00621238f, 0.00648680f, 0.03633494f, 0.01946379f, 
    0.02332996f, -0.03653436f, -0.02245043f, 0.00535745f, -0.04634989f, -0.04559708f, 0.04058341f, -0.04103524f, 
    -0.03869685f, -0.05675571f, 0.04388490f, -0.01024814f, -0.04553538f, -0.02809382f, -0.02780590f, -0.02145115f, 
    -0.01927518f, 0.01970826f, -0.03557247f, -0.05337065f, -0.02924009f, -0.01334243f, -0.04584334f, 0.02963935f, 
    0.01269286f, -0.05811237f, 0.03454901f, 0.03607780f, 0.03627121f, -0.04170769f, -0.04642730f, -0.06348848f, 
    -0.02289221f, 0.02905598f, -0.00595048f, -0.01957723f, 0.01524856f, -0.01362751f, 0.00463395f, -0.02361995f, 
    -0.01568457f, -0.04630483f, 0.00729998f, -0.01059280f, 0.03886731f, 0.02665279f, -0.00773772f, 0.04734196f, 
    -0.05283250f, 0.01541224f, 0.01632847f, -0.02997588f, 0.02998208f, 0.03649887f, -0.04667307f, 0.01184774f, 
    0.01588663f, 0.04387819f, 0.04376367f, -0.02220292f, 0.03647248f, -0.03163302f, -0.03902655f, -0.02725376f, 
    0.03792038f, -0.02883144f, 0.02457230f, -0.03720353f, -0.01253789f, -0.02232115f, -0.00339718f, -0.00699640f, 
    -0.04048488f, 0.00845471f, -0.03644384f, 0.03961642f, 0.03088993f, -0.06064468f, 0.00594139f, -0.02352165f, 
    -0.04282517f, 0.03675888f, -0.02407959f, -0.05044834f, 0.03814704f, 0.00933723f, 0.00520440f, 0.02771512f, 
    0.02591759f, 0.01466752f, -0.03060673f, -0.02563643f, -0.05689501f, -0.00089748f, 0.01637379f, -0.00866627f, 
    -0.04886266f, -0.01129568f, 0.02612575f, -0.01943256f, 0.02893660f, 0.02547491f, -0.02343598f, -0.05576796f, 
    -0.00755665f, -0.02247364f, 0.04018002f, 0.01593843f, -0.05832940f, -0.03171512f, -0.03371425f, -0.03175772f, 
    -0.04794967f, 0.00004278f, -0.01997570f, 0.02519980f, -0.05962556f, 0.02788791f, -0.03669746f, 0.04586259f, 
    -0.02678364f, 0.03753346f, 0.04305561f, 0.03191022f, -0.05508343f, -0.05158979f, -0.02891968f, 0.02952291f, 
    -0.04388177f, 0.02136162f, 0.02258199f, -0.01130163f, -0.04922451f, -0.05465888f, -0.02061436f, 0.01482436f, 
    -0.02995901f, -0.04433849f, -0.02535727f, 0.01231907f, -0.04813896f, -0.03665192f, -0.00712203f, 0.02824565f, 
    -0.01943658f, -0.01983949f, 0.03692706f, -0.04407466f, -0.05857206f, -0.03839981f, -0.03690668f, 0.00836768f, 
    -0.05277796f, 0.03400146f, -0.04352907f, -0.00839602f, -0.00335649f, 0.01238570f, -0.00628891f, 0.01575942f, 
    0.02943933f, 0.02608387f, -0.04383895f, -0.03025333f, -0.04196206f, -0.00030851f, -0.01489317f, -0.05634661f, 
    0.01147965f, -0.00788102f, 0.03033340f, -0.05568991f, 0.03028657f, 0.02482847f, -0.04234479f, -0.03632502f, 
    0.02164691f, 0.00696906f, 0.02272492f, 0.04454228f, -0.02683020f, -0.04930865f, -0.03338845f, 0.01643378f, 
    -0.03958434f, 0.03153967f, -0.06106706f, 0.04143827f, -0.02189668f, 0.02225915f, 0.02394940f, 0.02478453f, 
    0.00044899f, -0.05524365f, 0.04200846f, -0.00455192f, -0.01063606f, -0.00977219f, -0.04715363f, -0.05139396f, 
    0.01129393f, -0.03629768f, -0.04204630f, -0.03673472f, -0.01097185f, 0.03458011f, -0.01358887f, -0.03114461f, 
    -0.00466397f, -0.00418497f, 0.02387230f, 0.03336611f, -0.02452452f, 0.01160515f, -0.03161466f, -0.01900083f, 
    0.02530295f, 0.04707823f, 0.00836437f, -0.01719517f, -0.01141649f, -0.00033262f, -0.05753116f, -0.04091860f, 
    -0.02722518f, -0.04584745f, -0.02960674f, -0.03948881f, -0.01836203f, 0.04617911f, 0.00955473f, 0.02067780f, 
    0.00355392f, 0.02328009f, 0.04053641f, -0.01915616f, -0.00638381f, 0.00638843f, -0.01237614f, -0.02820354f, 
    0.01579380f, 0.04543649f, 0.01068246f, 0.04511603f, 0.01911632f, -0.02703873f, -0.06546254f, 0.04269392f, 
    0.05395282f, -0.01166675f, 0.01863896f, 0.01401438f, 0.00855754f, -0.02816487f, 0.00430439f, -0.03105615f, 
    -0.05129372f, 0.02667078f, -0.04662825f, 0.03616811f, 0.03403410f, -0.00156676f, -0.03096242f, 0.04046440f, 
    0.02874386f, 0.03915125f, 0.02478350f, -0.03433343f, -0.01483704f, 0.03700396f, -0.05437850f, 0.03961551f, 
    -0.01363368f, 0.00642235f, -0.02692118f, -0.05342098f, -0.05486609f, 0.01237286f, -0.02959466f, -0.03499537f, 
    -0.01891863f, 0.02985652f, -0.01501437f, -0.06367993f, -0.03013589f, 0.02226565f, 0.02096638f, 0.01504599f, 
    -0.05367250f, 0.03858335f, -0.00604527f, -0.05998577f, -0.06242885f, -0.03213717f, -0.02836501f, 0.03914690f, 
    -0.04956349f, 0.00019706f, -0.00599794f, 0.01372231f, 0.03134730f, -0.01404057f, 0.01431639f, -0.06090261f, 
    0.03608931f, -0.00202482f, 0.02222589f, 0.02787291f, 0.02128079f, -0.01875878f, 0.01060820f, 0.04601613f, 
    -0.00507885f, -0.03359175f, 0.02210116f, 0.01132375f, 0.01982412f, 0.03706702f, -0.02619240f, 0.03504007f, 
    -0.03316746f, -0.04078165f, 0.01143115f, -0.02969280f, 0.02388751f, -0.00171203f, -0.02045899f, 0.02204535f, 
    -0.00806253f, 0.01164208f, 0.03950152f, 0.00686740f, -0.00184221f, -0.01296133f, 0.00606187f, -0.00413988f, 
    0.00688560f, -0.01842808f, -0.00068403f, 0.03827956f, 0.02256588f, -0.02532872f, 0.01771483f, 0.02194282f, 
    -0.03826815f, -0.05825749f, -0.04767330f, 0.00831105f, -0.03370930f, 0.01320375f, 0.00860718f, -0.05112103f, 
    0.02735742f, 0.00294605f, -0.06092590f, 0.04712992f, -0.04579555f, -0.00858167f, -0.04120386f, -0.05950683f, 
    0.01801552f, -0.02033790f, 0.00797774f, -0.00023959f, -0.01486726f, -0.02188308f, 0.03348077f, 0.05175410f, 
    -0.01476735f, -0.01303566f, -0.02601990f, -0.03059681f, 0.04962132f, -0.04862289f, -0.01151167f, -0.02693906f, 
    -0.03284227f, 0.02310119f, -0.04319470f, 0.04782521f, -0.04348022f, -0.00465461f, 0.02478335f, 0.03552588f, 
    0.00925488f, -0.06058599f, 0.03516434f, -0.00567106f, 0.03572226f, 0.00908881f, 0.04335872f, -0.01950794f, 
    -0.03906852f, -0.06193924f, -0.06382459f, -0.03193119f, -0.05302453f, -0.03585866f, 0.03715904f, 0.04558673f, 
    -0.03610118f, -0.02809229f, 0.03783997f, 0.02585131f, 0.00710713f, -0.03449342f, 0.01924091f, 0.05906282f, 
    0.02156817f, -0.03396688f, 0.01899972f, 0.03749816f, -0.05338543f, -0.04236357f, 0.00270674f, 0.02458278f, 
    0.00183374f, 0.02914418f, -0.00190459f, -0.00027494f, 0.01943771f, 0.01592277f, -0.03487878f, 0.04514579f, 
    0.01632308f, 0.03965000f, -0.01388530f, 0.04319451f, -0.00905513f, 0.01128618f, -0.03223048f, 0.00846577f, 
    -0.03856749f, 0.04353547f, 0.05292940f, -0.04558354f, -0.03479213f, 0.01970203f, 0.03765253f, -0.02309228f, 
    0.02977924f, -0.03521292f, -0.02968193f, 0.04196095f, -0.06045885f, 0.03069056f, -0.04688060f, -0.05546263f, 
    0.02062366f, -0.02323670f, -0.05202300f, -0.03158813f, -0.06099057f, -0.01466885f, -0.03620512f, 0.00406171f, 
    -0.05034347f, -0.03208834f, -0.00258168f, -0.01327393f, -0.04129560f, 0.03169239f, 0.00284757f, -0.03905271f, 
    0.03911149f, -0.04203883f, 0.01151636f, -0.00893895f, -0.03066882f, -0.05388230f, -0.03107045f, -0.06272207f, 
    -0.05100606f, -0.04710997f, 0.02716145f, -0.06499872f, 0.01372425f, 0.00859411f, -0.01004773f, -0.01098431f, 
    -0.02511223f, -0.06079542f, 0.04177128f, -0.04016679f, 0.01432821f, 0.03150779f, 0.03555693f, 0.04074094f, 
    -0.03531362f, 0.00281286f, -0.06307878f, -0.02785782f, 0.04633309f, -0.03339796f, -0.01991527f, 0.05043349f, 
    0.02581982f, 0.03535489f, 0.00777475f, -0.01911457f, 0.04534100f, -0.06355932f, -0.04713571f, -0.06457768f, 
    0.05544761f, 0.40328956f, 0.07416487f, 0.02998218f, 0.20435724f, 0.03342736f, -0.01582593f, 0.03375353f, 
    0.01028276f, -0.03157474f, 0.01683747f, 0.03304139f, -0.05753122f, 0.07305165f, 0.03027451f, 0.08301602f, 
    0.03892653f, 0.18083607f, -0.27218238f, 0.03410528f, -0.09113213f, 0.45598838f, 0.23555295f, 0.05535141f, 
    -0.01435700f, -0.19663499f, -0.08746848f, 0.12692645f, -0.03246159f, 0.01255503f, -0.15246400f, 0.09079549f, 
    0.00370466f, -0.02778899f, -0.18129760f, -0.01866116f, -0.02049835f, 0.01504409f, -0.06864198f, -0.01201929f, 
    0.01404143f, -0.06940257f, -0.06435116f, 0.03494739f, 0.06548426f, -0.03343379f, 0.07508799f, 0.02338067f, 
    0.00313981f, 0.08611836f, -0.02552701f, -0.00464261f, 0.07498795f, 0.00071306f, 0.00274069f, -0.03144771f, 
    0.01533394f, 0.08531727f, 0.16811945f, -0.10255741f, -0.28543714f, 0.36788765f, 0.08958997f, -0.14078814f, 
    -0.18229142f, -0.17597060f, -0.00514521f, -0.04201966f, 0.08175247f, 0.02540851f, -0.18847032f, 0.07164074f, 
    0.11498757f, -0.13300063f, -0.08739702f, 0.03243993f, -0.02708791f, -0.08684056f, 0.04006843f, 0.07737204f, 
    -0.42471978f, 0.26750886f, 0.05775787f, -0.02542709f, 0.26014945f, -0.16385971f, 0.18364047f, -0.05355879f, 
    0.11362103f, -0.06689546f, -0.00693178f, 0.00334879f, 0.08471502f, 0.02834357f, 0.01158697f, 0.17989799f, 
    -0.01446542f, 0.20788753f, -0.02421917f, 0.12729670f, 0.23070274f, 0.09066945f, -0.12048738f, 0.04571229f, 
    -0.11181357f, -0.18162288f, 0.04948313f, -0.00768541f, -0.02171893f, 0.01758721f, -0.21216352f, -0.05880995f, 
    -0.02314772f, 0.06974695f, 0.05646318f, 0.08980002f, -0.15697339f, 0.08670793f, 0.13207427f, 0.06167493f, 
    0.02783161f, 0.06284466f, 0.10296114f, -0.09632325f, 0.22240721f, 0.24524237f, 0.23845291f, -0.06006568f, 
    0.10780811f, 0.02895176f, -0.12535694f, -0.12219141f, 0.07344753f, 0.03328815f, -0.09217148f, -0.02360077f, 
    -0.05554849f, 0.10991207f, 0.06154303f, 0.00484879f, -0.33378974f, -0.26215863f, 0.01777356f, 0.08647671f, 
    0.20123440f, 0.11359102f, 0.08356943f, -0.01311302f, -0.02138769f, 0.00489376f, 0.11217882f, 0.07593158f, 
    -0.10757332f, -0.10717658f, 0.08881166f, 0.01217244f, -0.08615312f, 0.18998595f, -0.00405962f, 0.05091844f, 
    0.71392936f, -0.13864256f, 0.12279375f, 0.03366749f, -0.05198601f, 0.14931254f, 0.23260561f, 0.00150059f, 
    -0.00536257f, -0.00468333f, 0.00162431f, -0.04983781f, -0.06335486f, 0.08300507f, -0.06762777f, 0.05997831f, 
    0.10545864f, 0.06914800f, -0.08098084f, 0.00979977f, -0.20719114f, 0.07311280f, -0.03213486f, 0.01279271f, 
    0.28805608f, 0.19993015f, 0.13600500f, 0.03892083f, 0.13012372f, 0.03949342f, 0.00402523f, -0.02243366f, 
    0.04619659f, 0.15120119f, 0.04679218f, 0.01281180f, -0.07043037f, -0.03905547f, 0.05776797f, 0.01580161f, 
    -0.22113556f, 0.34311792f, 0.35259917f, -0.04650077f, -0.04335035f, 0.06137366f, 0.00188649f, 0.00567841f, 
    0.10629190f, -0.07485723f, 0.00755864f, 0.02370836f, -0.09203622f, 0.05467251f, 0.08034077f, 0.12261695f, 
    -0.01033509f, -0.00977057f, -0.02613846f, -0.02596318f, 0.11522742f, -0.18588346f, 0.32867008f, 0.05245140f, 
    -0.22459744f, 0.10260464f, -0.00835216f, 0.04331868f, -0.08451252f, -0.04890368f, -0.05599859f, -0.02116702f, 
    0.11954181f, -0.02243125f, -0.00321878f, -0.01723585f, 0.15006456f, -0.04794126f, -0.06420867f, -0.21010980f, 
    -0.40522519f, -0.28523573f, 0.30396646f, 0.15464267f, 0.00404686f, -0.10415905f, -0.08225018f, -0.20136331f, 
    0.03065008f, -0.12775338f, -0.11493152f, -0.06554026f, -0.06342948f, 0.12478800f, -0.09552046f, -0.06367499f, 
    -0.06401145f, 0.11620153f, 0.06341317f, -0.16798797f, -0.13997549f, -0.02012599f, 0.02326554f, -0.09443272f, 
    0.23016874f, 0.03631654f, -0.02508035f, 0.12924968f, 0.03504925f, -0.04046197f, -0.01082736f, -0.02421046f, 
    -0.14944610f, -0.01817200f, 0.03313404f, -0.08228200f, -0.04608691f, -0.02437763f, 0.07755705f, 0.00365563f, 
    -0.24621677f, 0.06525591f, 0.02080942f, 0.02808261f, -0.17247741f, -0.03476179f, -0.02624495f, 0.00867163f, 
    -0.06422707f, 0.05522677f, -0.10248354f, 0.13631354f, 0.11178957f, -0.03706843f, 0.01085053f, 0.08132989f, 
    -0.11671384f, -0.01954053f, -0.16701466f, -0.08395749f, -0.30895749f, 0.05538582f, 0.17547503f, -0.07135149f, 
    0.14066851f, 0.15691467f, 0.16424984f, -0.07973539f, 0.09723185f, 0.02324280f, 0.04343165f, 0.16191058f, 
    0.06492131f, -0.07675239f, 0.07953528f, 0.01922963f, 0.07990447f, -0.03245265f, 0.03243873f, 0.09660114f, 
    -0.06055947f, 0.36857611f, 0.12132014f, 0.00122244f, 0.02231964f, -0.05260568f, -0.01042122f, -0.22943129f, 
    -0.15577073f, -0.09437737f, 0.05556779f, 0.02740197f, -0.11315113f, 0.06450733f, -0.01765727f, -0.05184622f, 
    -0.02276864f, 0.02253254f, 0.22619541f, 0.02347083f, 0.00949030f, -0.21074305f, -0.02922448f, 0.23291712f, 
    -0.06523822f, 0.15047380f, -0.03623195f, -0.09136458f, 0.02499262f, 0.03348809f, -0.01797750f, 0.02881791f, 
    0.00107275f, 0.02139290f, 0.07331710f, 0.05679037f, -0.01618199f, -0.08981373f, 0.17026785f, -0.09562439f, 
    -0.04552825f, -0.01821650f, 0.13928717f, -0.18293843f, 0.03215359f, 0.08397374f, -0.11760411f, -0.02763501f, 
    -0.02384862f, 0.04994652f, 0.03495997f, -0.09022208f, 0.02626122f, 0.16264403f, 0.10778306f, -0.03797542f, 
    -0.15661752f, 0.04097439f, -0.08343218f, 0.21825153f, 0.28315434f, -0.04485232f, -0.01148739f, 0.30919150f, 
    -0.00841790f, 0.18068689f, -0.01728853f, 0.04074317f, -0.04297940f, -0.05177973f, 0.06203682f, -0.12171473f, 
    0.07035437f, -0.05572731f, -0.02010512f, -0.02272031f, -0.01603932f, 0.02043106f, -0.00138632f, -0.18747720f, 
    -0.04914075f, 0.10771706f, -0.11930598f, 0.00316238f, -0.04691111f, 0.11794250f, 0.13447003f, -0.07163672f, 
    0.05028651f, -0.05533487f, 0.08850782f, 0.09976959f, -0.14236668f, 0.00494556f, 0.06204123f, -0.05469722f, 
    0.15763459f, -0.22269380f, 0.05599936f, -0.13673308f, 0.09876540f, 0.13192432f, -0.11768435f, 0.02890181f, 
    0.21079311f, 0.01201221f, -0.04565999f, 0.16507666f, 0.06220002f, -0.01091047f, 0.07903915f, 0.00877641f, 
    0.12053505f, 0.08595568f, 0.04567067f, -0.00405348f, 0.04500808f, -0.04024800f, -0.04253173f, -0.12970023f, 
    -0.07519630f, -0.23413652f, -0.15257429f, -0.05515569f, 0.03039442f, -0.03973538f, -0.05967394f, 0.15035024f, 
    -0.08087406f, -0.04871955f, 0.14470026f, 0.06648932f, -0.08290277f, 0.01055268f, 0.09158736f, 0.07364199f, 
    -0.00112652f, -0.15048184f, -0.11403821f, 0.11243656f, -0.08645125f, 0.36060795f, -0.10694175f, 0.00061785f, 
    0.07255904f, -0.07968395f, -0.00155918f, 0.12985903f, -0.01558542f, 0.08759604f, -0.15596807f, 0.01191057f, 
    0.12034886f, 0.26294917f, -0.11077052f, 0.03673776f, 0.15934032f, -0.13986699f, -0.16962956f, -0.04337904f, 
    -0.56703329f, -0.23648006f, -0.07376428f, 0.23318589f, 0.04331734f, 0.07276563f, 0.03265166f, -0.03803101f, 
    0.00636144f, 0.02544230f, 0.13007000f, -0.01790403f, 0.12512828f, -0.15002464f, -0.04744382f, -0.01794701f, 
    0.03127648f, 0.04643695f, 0.17084107f, -0.03109336f, 0.15805550f, -0.17347313f, -0.04396838f, -0.22082797f, 
    -0.27738076f, -0.08565278f, -0.03026648f, -0.06351383f, -0.13752551f, -0.08438741f, -0.07296895f, 0.11255696f, 
    -0.04320409f, -0.10938870f, -0.06834362f, 0.00266400f, 0.10316782f, 0.09106220f, -0.10039882f, 0.09646661f, 
    0.01728726f, -0.26316386f, -0.08594730f, 0.34784180f, 0.11973079f, 0.05951705f, 0.06596074f, -0.11264385f, 
    -0.09547933f, -0.08027644f, -0.14618017f, -0.05577287f, -0.03221167f, 0.03310258f, -0.05183225f, -0.11452343f, 
    0.02764564f, 0.08797628f, 0.10764389f, -0.04516991f, 0.19056745f, -0.05283102f, -0.02960831f, 0.17570095f, 
    -0.14346404f, -0.06787066f, -0.05263425f, -0.07086813f, 0.06773424f, 0.02169180f, 0.09723797f, 0.03027068f, 
    -0.00059322f, 0.05902240f, -0.00679436f, 0.03728701f, -0.04515859f, 0.11299570f, 0.14185974f, 0.15105999f, 
    0.21804890f, 0.20091674f, -0.08079719f, -0.03593164f, 0.08178261f, -0.02802775f, -0.01328509f, 0.15857330f, 
    0.15185015f, 0.16251633f, -0.04904822f, -0.01793888f, 0.09148309f, 0.07497741f, -0.07172749f, 0.17186111f, 
    0.12148313f, -0.35187870f, -0.07494386f, 0.20949118f, 0.04005941f, 0.09690729f, -0.19447157f, 0.03532344f, 
    0.07127241f, -0.02422338f, 0.06171741f, 0.06058406f, 0.02160672f, 0.12644222f, 0.03468059f, 0.11164542f, 
    0.08068846f, 0.12876670f, 0.07821273f, 0.02257501f, 0.05110744f, -0.09037586f, 0.13879240f, -0.17579418f, 
    -0.04341375f, 0.12598151f, 0.26784778f, 0.05073757f, -0.13219234f, 0.11192444f, 0.00007069f, 0.00667018f, 
    0.14928153f, 0.07346719f, 0.05226176f, -0.11617195f, -0.14308047f, 0.03848039f, -0.19425522f, -0.07514454f, 
    0.22107033f, -0.06908233f, 0.27483377f, 0.01750822f, 0.05638815f, -0.09296831f, -0.36328965f, -0.02787751f, 
    -0.03020602f, 0.08910871f, 0.03321769f, 0.01144963f, -0.12317056f, 0.10623028f, 0.02721240f, 0.03300427f, 
    0.12326621f, -0.00825439f, 0.04400351f, 0.07212804f, 0.02808579f, -0.15733045f, -0.01007208f, -0.05158492f, 
    -0.03996184f, 0.00448237f, -0.03902658f, 0.02318509f, -0.05404878f, -0.04316498f, 0.03679488f, 0.01259043f, 
    0.00646861f, 0.01107178f, 0.03138841f, -0.01186804f, -0.04579332f, -0.05021562f, -0.01264318f, -0.00856924f, 
    0.04513473f, -0.00424612f, 0.02116263f, -0.04581773f, -0.00816228f, -0.00031253f, 0.01601297f, 0.03812613f, 
    -0.03733772f, -0.01715703f, 0.01452526f, -0.00472111f, -0.03797935f, 0.04468523f, -0.01391770f, 0.01532237f, 
    -0.00764603f, -0.04046322f, -0.00176327f, 0.02208000f, -0.02250101f, 0.00146121f, -0.03595681f, -0.03708578f, 
    0.03037245f, -0.01994997f, 0.00369676f, -0.04869186f, -0.02136626f, 0.01287672f, 0.00589528f, 0.04139474f, 
    0.01662039f, -0.02950379f, 0.04049001f, 0.02236546f, -0.03507785f, -0.01097816f, -0.00618393f, 0.02191007f, 
    -0.01373670f, 0.02486865f, -0.01762976f, -0.05193774f, -0.02581223f, 0.00642837f, -0.03972613f, 0.02847734f, 
    -0.01805165f, 0.00513487f, 0.01068192f, 0.01230933f, -0.02875949f, 0.00170204f, 0.01239617f, 0.03170875f, 
    -0.01222319f, -0.02861407f, -0.04557763f, -0.03018365f, 0.03293289f, 0.03298109f, 0.04734982f, 0.02397739f, 
    -0.02941533f, 0.03748452f, 0.05294226f, -0.05516551f, 0.04799775f, -0.02525223f, 0.03044820f, -0.00073481f, 
    0.01324145f, -0.02861588f, -0.03685230f, -0.02971525f, -0.04024095f, -0.04630671f, -0.02992209f, 0.01724504f, 
    0.05436373f, -0.02605999f, -0.03160939f, -0.04468481f, 0.01365751f, -0.01428596f, 0.00254657f, -0.03380729f, 
    -0.02633188f, -0.01101258f, 0.04603089f, -0.03327370f, -0.00644746f, -0.04178144f, -0.05374482f, -0.05005479f, 
    -0.01263068f, -0.04862715f, -0.01405545f, 0.01200892f, -0.00985045f, -0.04102543f, -0.00939729f, -0.03535543f, 
    -0.04623634f, 0.01018787f, -0.00393955f, -0.03664880f, -0.02528773f, -0.03992955f, 0.05534255f, -0.04440856f, 
    0.04039693f, -0.04330255f, 0.02812792f, -0.03045901f, 0.03296555f, 0.01531763f, -0.05436942f, -0.02426882f, 
    0.03475807f, -0.00455273f, -0.03776938f, 0.00219896f, -0.03267080f, -0.03908236f, 0.01040678f, 0.03342852f, 
    0.04074557f, 0.04105401f, 0.03975230f, -0.00080936f, 0.01701006f, 0.05289866f, 0.00456374f, -0.01194484f, 
    -0.04137452f, 0.02660747f, 0.00582313f, -0.05558817f, -0.01789287f, -0.00101321f, 0.04415168f, -0.03236534f, 
    -0.04017845f, 0.00025409f, 0.02411698f, -0.01889202f, 0.02839270f, -0.01003843f, -0.01252350f, -0.04775142f, 
    -0.01707393f, -0.00756403f, -0.02182199f, -0.03046558f, 0.03974723f, 0.03432066f, -0.04777262f, 0.02914730f, 
    -0.02884454f, -0.01764398f, 0.01172855f, -0.05043674f, 0.01757980f, -0.01950319f, 0.00482004f, 0.01131647f, 
    -0.04923820f, 0.01883111f, -0.05224010f, -0.01818863f, 0.04145565f, 0.00046222f, -0.03251134f, -0.04331466f, 
    0.05308021f, 0.00857769f, 0.01459442f, -0.02706125f, 0.01160389f, -0.00339683f, -0.02920613f, -0.03833605f, 
    0.05307993f, -0.04077559f, 0.01669400f, -0.04905352f, 0.00344681f, 0.01138830f, -0.05075122f, 0.00018195f, 
    -0.05326277f, 0.03910752f, 0.05131691f, -0.05225364f, 0.03076403f, -0.03654838f, -0.01214193f, -0.04359577f, 
    -0.04342603f, 0.05443176f, -0.01468742f, -0.03254439f, -0.01535826f, -0.00927661f, -0.03390544f, 0.05212883f, 
    0.00602803f, -0.03170149f, 0.00310537f, -0.05060938f, -0.04409551f, -0.03549020f, -0.05388069f, 0.02588738f, 
    0.02653319f, -0.02161170f, 0.02048163f, 0.04359625f, 0.04973088f, 0.03971010f, 0.00686427f, -0.00747750f, 
    -0.01864033f, 0.02467936f, -0.01312639f, 0.02264266f, 0.02376129f, -0.00765730f, -0.05074174f, -0.01982498f, 
    0.02444311f, -0.04295588f, 0.02644661f, 0.05436387f, -0.05412924f, 0.03394389f, -0.03770095f, -0.00531136f, 
    -0.04624550f, -0.01094701f, -0.04971521f, -0.04300265f, 0.02942020f, 0.03157792f, 0.04291648f, 0.04879253f, 
    -0.00638352f, 0.03604372f, -0.01427480f, -0.01875566f, 0.03163308f, 0.03816569f, 0.05112083f, 0.04985875f, 
    -0.01961807f, -0.05575772f, -0.00703644f, 0.02330369f, 0.00725001f, -0.01063128f, -0.02399173f, -0.00780477f, 
    -0.01216520f, -0.01971526f, 0.03654674f, 0.05352481f, 0.02803008f, -0.05502224f, 0.03863075f, -0.02406472f, 
    -0.00068275f, -0.02027425f, 0.00939446f, -0.04890741f, -0.04941788f, 0.01871222f, 0.05313788f, -0.00633713f, 
    0.03906236f, -0.00405750f, 0.01255864f, 0.01072814f, 0.02928649f, -0.00470285f, 0.00802872f, 0.02969480f, 
    -0.03992407f, 0.02657474f, -0.01893592f, -0.04192227f, -0.01636186f, -0.04062961f, 0.00623974f, 0.04323493f, 
    0.05044154f, -0.01545637f, 0.00805369f, -0.01344678f, 0.04999795f, -0.05556374f, -0.03107764f, -0.05531513f, 
    0.03507728f, -0.02684274f, 0.02533979f, -0.02522737f, -0.03276452f, -0.02634216f, 0.05057013f, -0.04952513f, 
    0.02672519f, -0.03598285f, 0.02382865f, 0.04198937f, -0.01869613f, -0.00326809f, -0.04330422f, -0.02640901f, 
    0.03010155f, 0.01164337f, -0.05675851f, 0.01134211f, 0.04446153f, 0.00426104f, 0.03299349f, -0.01561251f, 
    0.02253517f, 0.01277317f, -0.03902968f, -0.05960044f, 0.00030699f, -0.03886028f, 0.04265367f, -0.05085203f, 
    0.04032816f, -0.02253785f, -0.04216728f, 0.03319931f, -0.03640603f, 0.03994045f, 0.03567022f, 0.03474783f, 
    -0.03442857f, -0.03923161f, 0.04344530f, -0.00324452f, 0.04349843f, 0.02510093f, 0.00453466f, -0.06317835f, 
    -0.03715331f, 0.03870675f, -0.03005783f, -0.05753939f, 0.01644990f, 0.01156788f, -0.04322474f, -0.05705816f, 
    0.00828072f, 0.00929747f, -0.00574249f, -0.04896873f, -0.02754881f, -0.01510857f, -0.01165182f, -0.03720734f, 
    -0.00934319f, 0.02053340f, -0.02937759f, 0.04600687f, -0.01412240f, 0.01904984f, 0.03982366f, 0.04044926f, 
    -0.04689487f, -0.03948770f, -0.03278199f, -0.03813482f, -0.02164940f, -0.05685673f, -0.03156186f, 0.01396172f, 
    -0.01922204f, -0.02543658f, 0.01572911f, -0.05395813f, 0.00413742f, -0.01419456f, -0.03063173f, 0.01502078f, 
    -0.03648287f, -0.01230153f, -0.05191432f, -0.02063831f, -0.00315407f, -0.03539848f, 0.01391399f, 0.03782992f, 
    0.03310719f, 0.02831837f, -0.01554975f, 0.03066712f, 0.02121486f, 0.00342785f, -0.00008447f, 0.01365211f, 
    -0.05635534f, -0.05182100f, 0.00267340f, -0.03850191f, -0.05414786f, -0.04839233f, 0.00817691f, -0.03181068f, 
    -0.03675614f, -0.01869135f, 0.01874414f, -0.01897435f, -0.06085686f, -0.06015316f, 0.00868029f, -0.04437359f, 
    -0.02780588f, -0.03556434f, 0.02583131f, -0.05253463f, 0.03100451f, -0.01456710f, 0.02819727f, -0.04755597f, 
    -0.04408873f, 0.04972326f, 0.04290162f, -0.04873536f, -0.05823046f, -0.03444275f, -0.01544990f, 0.02892143f, 
    0.01440786f, 0.05095816f, 0.00542581f, 0.04156727f, -0.01721977f, -0.02754852f, 0.00119842f, 0.00328376f, 
    -0.04128391f, 0.01198152f, -0.00732768f, 0.00017072f, -0.05063033f, -0.04828469f, 0.04505879f, 0.01261723f, 
    -0.01532694f, -0.00850129f, 0.03356168f, -0.02389417f, 0.04089754f, 0.01767887f, -0.02521757f, 0.04540173f, 
    -0.03040871f, -0.05491362f, 0.00064869f, 0.00632516f, -0.03928383f, -0.03738191f, -0.03218177f, 0.03826771f, 
    -0.01104695f, -0.05794369f, 0.02436009f, 0.00276073f, 0.03217057f, -0.01873706f, -0.01266125f, -0.01234301f, 
    0.03300788f, -0.04748357f, -0.04473983f, 0.01292580f, 0.03889489f, 0.04437915f, 0.00238181f, -0.00628030f, 
    -0.06129068f, -0.00418002f, -0.05441547f, 0.04030681f, 0.04374523f, 0.01647202f, -0.02463720f, -0.03788996f, 
    0.00468831f, -0.02509671f, 0.00000863f, 0.05031086f, -0.06102634f, 0.01492531f, 0.01413498f, -0.06114483f, 
    -0.00875084f, 0.00982141f, -0.02954221f, -0.00009363f, -0.01006753f, -0.05975996f, 0.02949318f, 0.03180742f, 
    -0.00406042f, 0.00755446f, 0.02272527f, 0.01752313f, 0.04042250f, -0.05904594f, 0.03469647f, -0.04516573f, 
    -0.04478363f, 0.01391109f, -0.01405259f, -0.03728970f, -0.01803290f, -0.04874445f, -0.04879175f, -0.01451938f, 
    0.00149139f, 0.01933334f, 0.01845610f, -0.04323500f, -0.04090263f, -0.03410712f, 0.01708230f, -0.03176912f, 
    0.01953206f, -0.05004599f, -0.00385315f, -0.05947243f, -0.00889390f, 0.03711138f, -0.00937044f, -0.00755659f, 
    -0.03841085f, 0.03120965f, 0.03957451f, -0.03003085f, 0.00413314f, -0.00407773f, -0.00817990f, 0.04314702f, 
    -0.03105193f, 0.00670523f, -0.01659107f, 0.01406220f, -0.01173238f, -0.02662354f, -0.05761224f, -0.05580510f, 
    0.02873056f, 0.01445261f, 0.04110998f, -0.04724521f, 0.03349992f, -0.02620067f, -0.02936061f, -0.05648233f, 
    0.05021151f, -0.00777084f, 0.01261818f, 0.02878606f, -0.04773732f, 0.01831559f, -0.01968484f, -0.06088367f, 
    -0.02502953f, -0.02740149f, -0.00262668f, -0.04229439f, 0.01815856f, -0.03991626f, -0.03667602f, -0.00295701f, 
    0.01046721f, 0.00604247f, 0.03109175f, -0.03779918f, -0.02817376f, 0.00060089f, -0.04570436f, 0.03850907f, 
    0.03115405f, -0.05352305f, 0.03654575f, 0.04123538f, 0.01434485f, -0.03907116f, -0.05720643f, -0.03445064f, 
    -0.04087708f, -0.02515147f, 0.00927899f, -0.05668968f, 0.02769657f, -0.03692959f, -0.04253700f, -0.04738154f, 
    -0.03666450f, 0.03639283f, -0.04684201f, 0.03331051f, 0.00875747f, 0.00779152f, -0.00531695f, -0.02020666f, 
    -0.04129459f, 0.00708099f, 0.05053518f, -0.00201925f, -0.05525034f, 0.00010537f, 0.00068455f, 0.04195019f, 
    -0.42699775f, -0.02093207f, 0.08962493f, -0.15838701f, 0.22442134f, 0.12270967f, 0.03366373f, 0.12574418f, 
    0.12669985f, -0.00826815f, 0.04089884f, 0.02166801f, 0.11184128f, -0.00731253f, -0.04549183f, 0.09576526f, 
    -0.00908892f, 0.09358246f, -0.15970668f, 0.26311281f, -0.20879300f, -0.01879095f, -0.01076628f, -0.18838465f, 
    0.03768950f, -0.01385596f, 0.10346438f, -0.03520607f, -0.01990896f, -0.02659332f, 0.02734518f, 0.09993485f, 
    -0.05527003f, 0.06574290f, -0.10309695f, 0.10290835f, 0.00795891f, -0.06241782f, -0.20736837f, 0.02726493f, 
    -0.15782008f, -0.02088585f, 0.12349135f, 0.08173794f, 0.21687828f, 0.04453893f, 0.07537033f, -0.00154124f, 
    -0.09548070f, 0.09053803f, 0.02834083f, 0.01708823f, 0.02879224f, 0.01033285f, 0.03995016f, -0.04033049f, 
    -0.02956867f, 0.12434862f, 0.11245967f, -0.04969984f, -0.39388263f, 0.10241806f, 0.09633062f, -0.28949288f, 
    -0.18625140f, 0.11831176f, 0.04594467f, -0.01939564f, -0.12084468f, -0.00453056f, -0.04651567f, 0.04651336f, 
    -0.09111343f, -0.10225993f, -0.09917872f, 0.12030783f, 0.03917009f, -0.17472038f, -0.15105656f, 0.00751436f, 
    -0.01300351f, -0.14031091f, -0.01665584f, -0.05718012f, 0.27906913f, 0.12458967f, 0.10690211f, -0.02654545f, 
    -0.00203197f, 0.02228995f, 0.00811441f, 0.14108896f, -0.01673213f, -0.06030260f, 0.14618793f, 0.14162800f, 
    -0.03390158f, 0.13427477f, -0.07302803f, 0.10622837f, 0.08103435f, 0.01652407f, -0.02221723f, -0.21862002f, 
    -0.38799840f, 0.10799431f, 0.10858965f, 0.00458183f, 0.06508426f, 0.03431273f, -0.12667026f, 0.01562556f, 
    -0.07653248f, 0.07274704f, 0.11089956f, -0.01428485f, -0.00629553f, -0.00195058f, 0.10828859f, 0.07339387f, 
    0.72446585f, -0.21623755f, -0.11259410f, 0.17874920f, -0.09097812f, -0.15783750f, 0.03096427f, -0.04038884f, 
    -0.04568998f, 0.07211956f, -0.11589080f, 0.04335847f, 0.05247888f, 0.01324508f, 0.05383500f, -0.07863646f, 
    -0.03235701f, 0.01462707f, -0.02079269f, 0.06486151f, 0.13763791f, -0.03609975f, 0.00232176f, 0.03146430f, 
    -0.24590026f, 0.02235124f, -0.16157192f, 0.00647555f, -0.11408909f, -0.18114197f, -0.03897003f, -0.07997419f, 
    -0.10445427f, -0.21774335f, -0.10983823f, 0.04438907f, -0.05680710f, 0.11268515f, 0.09755392f, -0.06989560f, 
    0.72533309f, -0.23686445f, 0.02655456f, 0.12870617f, 0.45754349f, -0.03452687f, -0.00071964f, -0.03642998f, 
    0.07515626f, 0.12155239f, 0.00904849f, 0.00504556f, 0.02567254f, 0.08580638f, 0.05864100f, 0.11746602f, 
    -0.01935708f, 0.02302316f, -0.02891958f, -0.01578657f, 0.73663139f, 0.00245827f, -0.00311821f, 0.15600111f, 
    -0.16529959f, -0.04524231f, -0.04579031f, -0.09122948f, 0.19893475f, 0.01175377f, 0.06747319f, -0.00893630f, 
    -0.00488696f, 0.13645583f, 0.08531354f, -0.15177138f, -0.05282407f, -0.08071808f, -0.03326559f, -0.00339376f, 
    -0.33208320f, -0.02529304f, 0.11700294f, -0.28213128f, -0.08079641f, 0.11814878f, -0.04046122f, -0.07004309f, 
    0.06909740f, 0.06010269f, -0.02278399f, 0.11371078f, -0.08261961f, -0.02713991f, -0.08022718f, 0.09484714f, 
    -0.02190996f, 0.06133126f, -0.13121057f, 0.02494324f, -0.03437772f, -0.08942993f, 0.01574698f, -0.25216082f, 
    0.03219368f, 0.23714903f, 0.06953284f, -0.13241518f, -0.08430283f, 0.00548089f, -0.07349224f, -0.10734914f, 
    -0.00005039f, -0.03424491f, 0.08411826f, 0.03255204f, 0.10408967f, 0.02979086f, -0.14968398f, -0.00609843f, 
    -0.01759728f, 0.13554403f, 0.06845258f, -0.17911732f, 0.16874592f, -0.05007174f, 0.07494806f, 0.07236771f, 
    0.12130680f, 0.04592431f, 0.01919609f, 0.09343135f, -0.04122619f, -0.18030176f, -0.11030269f, -0.01523524f, 
    0.03836402f, 0.22900996f, 0.21750936f, -0.11802587f, 0.10508250f, -0.19124322f, 0.10680836f, -0.09285738f, 
    0.06058126f, -0.01577408f, -0.01161403f, 0.12690501f, -0.09719022f, -0.00556518f, -0.09157202f, -0.08435191f, 
    -0.02341792f, -0.09239911f, -0.00453288f, 0.12916882f, -0.05379663f, 0.02273435f, -0.00326927f, 0.13006729f, 
    -0.11791103f, -0.38035676f, 0.18573396f, -0.11121782f, 0.25323722f, -0.07711498f, -0.03884235f, 0.29737461f, 
    0.11398545f, -0.16747686f, 0.00553344f, 0.05926757f, 0.10264408f, 0.05227218f, 0.23661795f, 0.09230462f, 
    0.04454474f, 0.21661307f, -0.10841789f, 0.09860322f, 0.43320593f, -0.00094960f, -0.00916320f, 0.15546302f, 
    0.06438121f, 0.14027116f, -0.06855536f, 0.02143754f, 0.06874569f, 0.13594732f, 0.04158525f, 0.00730151f, 
    0.03716229f, 0.03401468f, -0.08882703f, -0.02175917f, -0.07433631f, 0.09693800f, 0.08833750f, 0.00232302f, 
    -0.02933596f, 0.02097419f, 0.01140039f, -0.05552173f, -0.05011722f, 0.00441232f, 0.00254443f, 0.00871747f, 
    -0.01465452f, 0.01900382f, -0.02810244f, 0.01562277f, 0.02209920f, -0.02644716f, -0.05791302f, 0.02553570f, 
    -0.00746194f, -0.06375780f, -0.00282397f, 0.00139915f, -0.01293523f, -0.04993450f, 0.02051140f, 0.01814845f, 
    0.01238572f, -0.00210824f, -0.01600793f, 0.03861124f, 0.03102381f, 0.02806225f, -0.00898012f, 0.00027346f, 
    0.00816897f, -0.00316517f, -0.02676299f, -0.04589538f, -0.02779655f, 0.01259696f, -0.02709904f, 0.03205030f, 
    -0.00609377f, -0.01112535f, -0.04615808f, -0.02499440f, 0.03215720f, 0.02494693f, -0.05713333f, -0.04328457f, 
    0.04240641f, 0.00208763f, -0.05053204f, 0.01724761f, 0.03627292f, -0.01149216f, -0.03575464f, 0.02335475f, 
    0.03022484f, -0.01426973f, 0.03210925f, 0.01826132f, -0.05890090f, 0.00254110f, 0.01230089f, -0.03334769f, 
    -0.03610457f, 0.01705515f, -0.02070927f, 0.04747609f, -0.05042631f, -0.00632322f, -0.05955821f, 0.04293390f, 
    0.01971046f, 0.00249581f, -0.03298705f, 0.04418410f, -0.05042849f, 0.04164702f, 0.04275901f, 0.03284861f, 
    -0.03061322f, -0.00799993f, -0.02758799f, 0.04349920f, 0.00113259f, -0.05093657f, 0.03504989f, -0.04016221f, 
    0.01989495f, 0.02988624f, -0.01921849f, 0.01999214f, 0.01495487f, -0.04031864f, -0.02965420f, -0.04940744f, 
    0.02476668f, -0.03191888f, -0.00589953f, -0.04711223f, -0.03037673f, 0.03515545f, 0.03927757f, 0.03683163f, 
    -0.02757595f, -0.05672023f, -0.04580120f, 0.03250813f, 0.00515934f, -0.06223863f, -0.05921830f, 0.02423723f, 
    0.01077904f, -0.04200880f, 0.00358663f, -0.05727671f, -0.00514567f, -0.02832136f, 0.01244830f, -0.05422788f, 
    -0.06308797f, -0.00462094f, -0.03255032f, -0.02702313f, -0.03231687f, 0.02929804f, 0.04753658f, 0.03473127f, 
    -0.06146928f, -0.02293209f, -0.05122804f, -0.01094320f, -0.05430086f, -0.00699691f, 0.00715011f, -0.00992817f, 
    -0.06385472f, -0.02106840f, -0.03816668f, -0.00466926f, 0.03476696f, -0.03503881f, 0.00966866f, -0.03710215f, 
    -0.03554550f, 0.02405281f, -0.05711449f, 0.02845598f, -0.03925462f, 0.02948593f, -0.02311064f, 0.04125790f, 
    -0.05803768f, 0.03706497f, 0.01598546f, -0.01954102f, -0.05830641f, 0.04448949f, 0.02813119f, -0.04151382f, 
    -0.00199874f, -0.06191784f, -0.01179553f, -0.03609118f, 0.00413037f, 0.01988930f, -0.05342351f, -0.00398290f, 
    -0.06185248f, -0.00002794f, -0.01263596f, -0.02146096f, -0.04015899f, -0.03734428f, -0.06249712f, -0.03680788f, 
    -0.02851611f, -0.00103661f, -0.06168926f, 0.00258244f, 0.00759228f, -0.00313320f, -0.05178357f, 0.02340522f, 
    -0.04991853f, -0.02486381f, -0.03385301f, -0.00596565f, -0.06329512f, -0.03285583f, 0.00949498f, -0.03244933f, 
    0.02807299f, -0.00131911f, -0.03277004f, -0.05819137f, 0.03997396f, 0.03845308f, -0.00918486f, -0.00909666f, 
    -0.00497664f, -0.05205021f, -0.06036151f, 0.02785190f, 0.00466088f, -0.02604732f, -0.04810919f, -0.03016365f, 
    -0.04680104f, -0.01666084f, 0.00797075f, 0.01780995f, 0.03317671f, 0.02599336f, -0.05792632f, 0.04368482f, 
    0.00923807f, 0.04150390f, -0.06420156f, -0.05868890f, -0.00672975f, 0.03643044f, -0.05594301f, -0.00119002f, 
    0.00181249f, 0.03458609f, 0.00886212f, 0.02437313f, -0.02587936f, -0.04882917f, -0.02370926f, 0.04419491f, 
    -0.03118036f, -0.00918608f, 0.04367762f, -0.02734057f, 0.04164147f, -0.04803525f, -0.00132593f, -0.05278545f, 
    -0.05939889f, -0.05001051f, -0.01892333f, 0.04684340f, -0.04354040f, 0.03358919f, -0.05724220f, 0.01232015f, 
    -0.03304297f, -0.03346390f, -0.03228042f, 0.03373387f, 0.03935261f, 0.00525485f, 0.02264509f, 0.02115365f, 
    0.04558276f, 0.02693386f, -0.01023610f, 0.00813792f, -0.00570085f, -0.00150287f, 0.00876706f, -0.03037084f, 
    0.01997706f, 0.00975911f, -0.03307903f, -0.05397820f, 0.00589127f, -0.01167626f, -0.01381439f, 0.03657193f, 
    0.01199972f, 0.02742023f, 0.00843181f, 0.00003135f, -0.00253958f, 0.01653264f, -0.02837840f, -0.04151240f, 
    0.03470362f, 0.03955049f, 0.03219672f, 0.04722639f, -0.02745228f, 0.03951314f, 0.03268386f, -0.05064578f, 
    -0.02721395f, 0.02847844f, -0.01653322f, -0.01981270f, -0.00094123f, 0.01146659f, 0.03129730f, 0.04398550f, 
    -0.00553838f, 0.02209102f, -0.03091479f, 0.02524623f, 0.01584615f, 0.01289109f, -0.00635565f, 0.00922918f, 
    -0.03691325f, -0.04306358f, -0.04732376f, -0.06347329f, -0.00736812f, -0.02488695f, -0.05927471f, -0.05838913f, 
    0.03175552f, 0.03700317f, -0.03526970f, -0.00775811f, 0.03242813f, 0.03793759f, -0.05781913f, -0.02209733f, 
    0.23805097f, 0.17947848f, 0.28197926f, -0.11563846f, -0.12276176f, 0.07802218f, 0.03392788f, 0.05895464f, 
    -0.06768586f, 0.12007472f, 0.10423744f, 0.09819626f, 0.03876653f, 0.09575538f, 0.04159115f, -0.03268153f, 
    -0.02046808f, -0.05524505f, -0.01893807f, -0.12474792f, 0.11380373f, -0.12733075f, 0.16459219f, 0.02555916f, 
    -0.27234697f, 0.04443842f, 0.00399684f, 0.01164604f, -0.02853218f, -0.04965049f, -0.03148049f, -0.07202147f, 
    0.14855684f, -0.04436954f, 0.08651798f, 0.05811282f, 0.09692539f, -0.03375831f, 0.10091161f, -0.03254117f, 
    -0.13518819f, 0.21540689f, -0.04586067f, -0.14297462f, 0.01324193f, 0.10423723f, -0.08759884f, 0.08496782f, 
    -0.07339883f, 0.05855422f, -0.01545926f, -0.01431796f, -0.06408393f, -0.07838185f, 0.08344182f, 0.05059090f, 
    -0.06409228f, 0.10684087f, -0.16413073f, 0.04736177f, 0.28387469f, 0.39608917f, -0.07755639f, -0.09808708f, 
    -0.01422602f, -0.00494518f, -0.04985252f, 0.04115387f, 0.10489792f, -0.02009721f, 0.01746344f, -0.06613874f, 
    0.10767429f, 0.08343849f, 0.06454236f, -0.03899620f, 0.01208151f, 0.04390731f, -0.07840896f, 0.00563678f, 
    0.01699839f, -0.20578496f, 0.08448976f, -0.03620698f, -0.02521115f, 0.08765469f, -0.02902038f, -0.01654207f, 
    0.10764244f, 0.10392485f, -0.08186663f, -0.06169163f, -0.06214451f, -0.04085746f, -0.05275370f, -0.07001328f, 
    -0.04784970f, -0.28861067f, 0.01221180f, 0.07478286f, -0.00146369f, 0.16460192f, -0.32722214f, -0.13074616f, 
    0.33020619f, -0.07906768f, -0.13391966f, -0.01821468f, 0.03839201f, 0.00305560f, -0.05297615f, -0.08497425f, 
    0.05880768f, 0.00391103f, 0.08707953f, 0.04056701f, 0.00467181f, -0.04743860f, -0.11852654f, 0.00760780f, 
    0.21175477f, 0.11183412f, 0.03678780f, -0.12061876f, 0.11270660f, 0.04835471f, 0.15530957f, -0.06557506f, 
    -0.00017348f, -0.04123538f, 0.09034277f, 0.04751990f, 0.01724906f, -0.04240679f, -0.06560807f, 0.03902925f, 
    0.02113132f, -0.05483922f, -0.00662014f, -0.03811729f, 0.01516898f, -0.06894791f, 0.08843747f, 0.04588751f, 
    -0.00855627f, -0.02424568f, 0.05647661f, -0.08052330f, 0.04324822f, 0.07620861f, -0.02403307f, 0.05029974f, 
    0.09601247f, 0.17860055f, 0.03725214f, 0.02167653f, 0.03100521f, 0.02879108f, -0.02676453f, -0.16851321f, 
    -0.28090110f, -0.18676022f, 0.03049391f, -0.00961207f, 0.00727198f, 0.04955199f, -0.04695077f, -0.05495675f, 
    0.03143345f, 0.00198816f, -0.00170843f, 0.01693618f, 0.07698731f, -0.09283803f, 0.00930880f, 0.00069117f, 
    -0.01378427f, -0.01929608f, 0.01549249f, -0.10080551f, -0.07984038f, 0.28681341f, 0.13265763f, 0.18004301f, 
    0.04358200f, 0.08986227f, 0.06018937f, 0.04521999f, 0.01085514f, -0.02399630f, 0.12157817f, -0.00125432f, 
    -0.08360301f, -0.06806236f, -0.09863603f, -0.09663035f, 0.01812735f, 0.04657061f, -0.00263020f, 0.01092233f, 
    0.41322857f, -0.27128014f, -0.03412322f, 0.17269488f, 0.11905605f, 0.08905489f, 0.06114092f, 0.11929829f, 
    -0.04866196f, -0.01544809f, -0.06968542f, 0.04246690f, 0.02078623f, 0.05259336f, -0.00878751f, -0.09218739f, 
    -0.05353339f, 0.05755932f, 0.02218838f, -0.05379181f, 0.90094107f, -0.00172112f, -0.19509131f, 0.11683223f, 
    -0.30410078f, -0.17295456f, 0.03695046f, 0.05084775f, 0.02842704f, 0.03125679f, 0.15528357f, -0.06969009f, 
    -0.03464282f, 0.12186818f, -0.05337210f, -0.06076691f, -0.09879520f, 0.07885073f, -0.01703251f, 0.02953097f, 
    0.01009257f, 0.07647160f, -0.15731485f, -0.00276690f, -0.00161833f, -0.04586536f, -0.12875271f, 0.00411244f, 
    0.00126153f, 0.09565613f, 0.05555374f, 0.02555300f, 0.03423707f, -0.00767513f, 0.02693909f, 0.02025346f, 
    -0.06742261f, -0.08412261f, -0.05842652f, 0.10164537f, -0.08287822f, -0.08528732f, 0.02847582f, 0.00628163f, 
    0.12977344f, 0.02240873f, -0.01909819f, 0.00040919f, 0.02972012f, 0.03980499f, 0.06003433f, 0.17427585f, 
    0.03262831f, 0.02864376f, 0.04773334f, -0.08481400f, 0.12681766f, -0.05874527f, 0.09134175f, -0.26845697f, 
    -0.47165045f, 0.23931752f, 0.17341618f, -0.03374914f, -0.04916415f, 0.07153518f, 0.04965436f, -0.08290353f, 
    -0.01426059f, 0.28538597f, -0.07417262f, -0.06113430f, -0.11664449f, -0.09762812f, -0.14868970f, 0.11403475f, 
    0.04903657f, -0.05272306f, 0.01246810f, -0.01880684f, 0.00169897f, -0.08948807f, 0.14554912f, 0.03311783f, 
    0.19852681f, 0.10871956f, 0.09644669f, 0.12498982f, -0.12654901f, -0.00481373f, 0.00216175f, -0.17662954f, 
    -0.00596217f, 0.01841483f, -0.06478813f, 0.04007863f, 0.01711619f, -0.11899716f, -0.00806548f, -0.01886008f, 
    0.26067460f, -0.45778948f, 0.05169531f, 0.05562435f, -0.02749567f, 0.09962770f, 0.02399796f, 0.14710602f, 
    0.15590131f, 0.20638843f, -0.09414465f, -0.03392028f, -0.06314293f, 0.12047243f, -0.02707353f, -0.11849137f, 
    -0.02013917f, -0.08033741f, -0.24031729f, -0.07454363f, 0.35737875f, 0.21421057f, 0.06529752f, 0.06740791f, 
    0.02645031f, 0.01492088f, 0.04889246f, 0.26495841f, -0.00360605f, 0.05127740f, 0.02888784f, -0.08575378f, 
    0.08940422f, -0.05232323f, -0.05082772f, -0.02591894f, -0.00248781f, 0.16276948f, 0.05414026f, 0.13151641f, 
    0.13718340f, 0.01888124f, -0.06355488f, 0.07995874f, -0.14499326f, -0.00346200f, -0.01913300f, 0.10204129f, 
    0.03584301f, -0.02132622f, -0.02799627f, 0.14996584f, 0.01162448f, -0.15423146f, -0.05203373f, 0.00410572f, 
    -0.02773050f, 0.09474347f, 0.03431093f, 0.01467742f, 0.37867147f, 0.10142992f, -0.01140204f, 0.17017218f, 
    0.23287989f, -0.11066690f, 0.03552418f, 0.07202360f, 0.13188222f, 0.06397842f, 0.05222536f, 0.02636418f, 
    0.05563996f, 0.11067151f, 0.02986622f, 0.11130438f, 0.00286560f, -0.00140089f, 0.02015212f, 0.18020444f, 
    0.26637432f, -0.37143660f, 0.14598322f, -0.02891348f, -0.06215552f, -0.05897705f, -0.12478847f, 0.12505618f, 
    0.01267345f, -0.00466857f, -0.09974791f, -0.09917976f, 0.06226293f, 0.02468901f, -0.12721059f, -0.03304524f, 
    -0.13010368f, 0.01920882f, -0.20994034f, -0.02971819f, -0.04015867f, -0.17061719f, 0.09251864f, 0.00002593f, 
    0.27856597f, -0.09591782f, -0.02053785f, 0.02092766f, 0.05494424f, 0.01521241f, 0.10781144f, -0.10363244f, 
    -0.09144084f, -0.09856147f, -0.00131095f, 0.07608120f, -0.01670898f, 0.16069438f, 0.14817640f, 0.07810407f, 
    -0.26506314f, 0.26663586f, -0.10539229f, 0.01009915f, -0.13119835f, 0.03896447f, -0.04147656f, -0.05082610f, 
    0.11688231f, -0.08459956f, 0.08909713f, -0.08302312f, 0.12408668f, 0.03760748f, -0.04232341f, 0.01114936f, 
    0.07655690f, 0.08137350f, 0.08880360f, -0.09065218f, -0.01284358f, -0.30638367f, -0.23807046f, 0.05503564f, 
    -0.06739011f, 0.01474115f, 0.18529490f, -0.07538158f, 0.14811315f, 0.08622967f, 0.06301471f, 0.04171522f, 
    0.01354319f, -0.05262116f, 0.10939176f, -0.02901561f, -0.07693532f, 0.11818767f, 0.03641861f, 0.05511715f, 
    -0.14074801f, 0.27992678f, 0.11988783f, -0.17105260f, -0.25660855f, -0.15567239f, -0.06976955f, 0.03797593f, 
    0.08674005f, -0.14603609f, -0.07875453f, 0.08773863f, 0.02300852f, 0.02184240f, 0.00416895f, 0.00933979f, 
    -0.04033628f, 0.06426894f, -0.01287356f, 0.04214776f, -0.39166754f, 0.20245989f, -0.15676843f, 0.03710964f, 
    -0.04851280f, 0.13553768f, 0.17430666f, 0.09224600f, -0.04011936f, 0.08392925f, 0.05322130f, -0.06961081f, 
    0.10644639f, 0.06960280f, -0.05715000f, 0.12451709f, -0.04570551f, -0.07062121f, 0.04817688f, -0.08488448f, 
    0.54572266f, 0.05940549f, 0.02215517f, 0.00430074f, 0.08257600f, -0.06376521f, -0.05055619f, 0.18220426f, 
    0.04982771f, 0.15534469f, 0.17283499f, 0.09479681f, 0.03229746f, -0.15276748f, 0.05344145f, 0.03325139f, 
    0.01874948f, -0.00546094f, -0.10116160f, 0.07394438f, 0.01472770f, 0.44831151f, -0.02660886f, -0.04397310f, 
    0.19933291f, -0.14021285f, -0.04311597f, 0.10578866f, 0.08230743f, -0.04759028f, 0.08756542f, 0.00578917f, 
    0.03661592f, -0.12543024f, 0.06909327f, -0.10638904f, 0.01053545f, -0.10486564f, -0.07253554f, -0.10904877f, 
    0.00864778f, -0.11947865f, 0.00983447f, 0.14557131f, 0.00367038f, 0.03814201f, 0.03133629f, -0.05492483f, 
    -0.15028943f, 0.05401181f, 0.01308878f, 0.11015028f, -0.14078237f, 0.05259226f, 0.18079241f, -0.13323641f, 
    -0.07237551f, 0.12492403f, 0.06356352f, -0.00453017f, -0.00190048f, -0.20932688f, 0.07082502f, 0.07290392f, 
    -0.07866944f, -0.04254383f, -0.06001067f, -0.07870822f, 0.08311179f, 0.03713468f, 0.03039208f, 0.04871406f, 
    -0.01700041f, 0.04356666f, -0.11905704f, -0.02949847f, -0.01361573f, 0.11398682f, 0.02191625f, -0.03676398f, 
    0.06281899f, -0.02029895f, -0.05483378f, -0.00233594f, -0.02556585f, -0.00068703f, -0.00936212f, -0.02551682f, 
    -0.16501954f, 0.15128435f, -0.10371239f, 0.12399434f, -0.02119462f, -0.10131060f, -0.03114038f, 0.06805379f, 
    -0.13700943f, -0.14711943f, -0.17482235f, -0.00577728f, -0.02435156f, -0.12096462f, 0.10273745f, -0.08978792f, 
    0.03045039f, -0.00306761f, 0.03460917f, -0.00941235f, 0.04891441f, -0.21946280f, -0.10372878f, -0.03930557f, 
    -0.04907213f, 0.01986273f, 0.05523876f, 0.03564411f, 0.05325292f, 0.06236846f, -0.03556491f, 0.04194171f, 
    0.05618932f, 0.01359475f, -0.17168571f, 0.05588024f, -0.30649322f, 0.06797165f, 0.00153975f, -0.14233387f, 
    0.01116152f, 0.04212961f, -0.00704161f, -0.16848595f, -0.08032892f, -0.07674251f, 0.00465099f, -0.05531812f, 
    -0.01990032f, -0.04378049f, 0.07436930f, -0.08674619f, 0.03137956f, -0.20853998f, -0.18528050f, 0.00074908f, 
    -0.08463908f, -0.08380773f, 0.28157675f, 0.11745127f, 0.02528480f, 0.08418009f, 0.00137918f, -0.04247238f, 
    0.07818525f, -0.01750545f, -0.08740061f, 0.01296172f, -0.02392450f, 0.05443382f, -0.02877517f, 0.02846052f, 
    0.16682234f, 0.15835595f, -0.03096933f, -0.00015460f, -0.19056398f, -0.00888756f, 0.12387438f, 0.05569096f, 
    0.04332570f, -0.07957929f, -0.02615223f, 0.02506144f, -0.08630560f, 0.01572759f, 0.13625960f, 0.08824047f, 
    0.09487922f, -0.00176999f, -0.00229711f, -0.03171058f, -0.56461501f, -0.25735337f, -0.04188049f, 0.09081729f, 
    0.11456180f, 0.10813889f, 0.08489496f, -0.04754070f, -0.03273626f, -0.04293013f, 0.00684691f, 0.10974756f, 
    0.02170042f, 0.00500728f, 0.06553124f, -0.15722618f, 0.00827685f, -0.10052662f, -0.05826643f, -0.05557158f, 
    -0.07429729f, 0.11358330f, -0.00246364f, -0.06720178f, -0.40738544f, 0.02267392f, -0.00430546f, 0.04532858f, 
    -0.02311918f, 0.17002606f, -0.10509390f, -0.12352876f, -0.01931979f, 0.06565288f, 0.05011978f, -0.13845621f, 
    -0.01571793f, 0.07925993f, 0.18471637f, 0.02524828f, -0.45655528f, 0.23785882f, 0.08552993f, -0.00754099f, 
    -0.08948300f, -0.03745089f, 0.09952436f, 0.08156362f, -0.14042604f, -0.08244777f, 0.15354669f, -0.00098789f, 
    0.04684991f, -0.10755357f, -0.11806610f, 0.07115245f, 0.10639657f, 0.04392156f, -0.10764048f, 0.12285222f, 
    0.41529220f, -0.13608041f, 0.27890098f, 0.19059730f, 0.27749088f, -0.15433547f, -0.04432680f, 0.05411987f, 
    0.05271440f, 0.14489543f, -0.01714939f, -0.11348590f, 0.03852997f, -0.03542401f, 0.04216359f, 0.12495705f, 
    0.13933557f, 0.06642663f, 0.08943014f, -0.12340986f, 0.40026373f, 0.66294169f, 0.21345104f, -0.09728900f, 
    0.03500340f, 0.16725728f, 0.05217614f, 0.01575442f, 0.09894291f, 0.11560016f, -0.01145709f, 0.02001498f, 
    0.09333243f, 0.00359592f, -0.05788897f, -0.14085865f, 0.00835107f, -0.06139776f, -0.00060518f, 0.10679788f, 
    -0.25596958f, 0.21553938f, -0.45034555f, -0.27631897f, 0.03665093f, -0.04335781f, -0.17292580f, -0.02091649f, 
    0.07293443f, 0.08025542f, 0.00063311f, -0.04758108f, 0.07288719f, 0.05512225f, 0.04483403f, -0.06534382f, 
    0.10345101f, -0.06667999f, 0.04180257f, -0.00571215f, 0.19682507f, -0.31246746f, 0.17010444f, 0.44282079f, 
    0.39308915f, -0.16735177f, -0.17496094f, 0.08417230f, -0.05735305f, 0.25116178f, -0.03006281f, 0.06650765f, 
    0.12872878f, -0.02103643f, 0.11490721f, -0.02018576f, 0.03930733f, 0.13070366f, 0.10893438f, -0.01720034f, 
    -0.22539513f, 0.04424964f, 0.07312298f, -0.05234905f, -0.21875776f, 0.14631370f, 0.09741090f, -0.03293638f, 
    -0.00000481f, 0.04333568f, -0.02293584f, -0.23055047f, 0.00887309f, 0.15492450f, 0.00372271f, -0.04949836f, 
    0.08470336f, -0.05793020f, -0.03882861f, 0.03884888f, -0.41148224f, 0.04853761f, -0.01478211f, 0.11835343f, 
    0.00514872f, 0.03865445f, 0.05643264f, 0.23571619f, 0.00088985f, -0.06822626f, 0.10160876f, 0.04434233f, 
    -0.18845007f, 0.08930172f, -0.15582892f, 0.20222266f, 0.07612125f, -0.02978405f, -0.05642664f, 0.06379283f, 
    0.06107436f, -0.07911586f, -0.13583764f, -0.14518863f, -0.16289048f, 0.26553738f, -0.02495527f, -0.03341710f, 
    -0.13464907f, -0.08845989f, -0.08826963f, 0.04802984f, 0.05680013f, -0.06362553f, -0.03089975f, 0.02956085f, 
    0.02148616f, -0.07053541f, -0.07765142f, 0.19212139f, 0.28175402f, 0.54203773f, 0.02090458f, 0.07357465f, 
    0.04274660f, -0.06490048f, 0.13241486f, -0.15105070f, 0.13651176f, 0.01251838f, 0.06268798f, 0.01642977f, 
    -0.05263519f, 0.03893936f, -0.00510740f, 0.13443996f, -0.03379747f, -0.01204054f, 0.02455652f, 0.14152619f, 
    0.17813030f, 0.08808520f, -0.22050071f, 0.17162573f, 0.00981392f, 0.10016257f, -0.09781565f, 0.08208371f, 
    -0.06803180f, -0.14581805f, 0.03122589f, -0.11507194f, -0.06231666f, -0.05101668f, 0.06373988f, -0.15311909f, 
    -0.00243467f, 0.05336483f, 0.23623554f, -0.06032415f, 0.03759907f, 0.05405595f, 0.15801999f, 0.07284412f, 
    0.09196779f, -0.04590609f, -0.14250173f, -0.11027764f, 0.07612364f, 0.15953285f, -0.12499636f, 0.05279658f, 
    0.00554447f, 0.07268239f, -0.07315109f, -0.04125449f, 0.01253165f, 0.05965113f, -0.03231554f, 0.01557821f, 
    -0.45297313f, 0.03273996f, -0.18040025f, 0.03046526f, -0.32350799f, 0.14391752f, 0.11393775f, 0.03092577f, 
    -0.04315570f, 0.08313006f, 0.02414167f, -0.02848876f, 0.05875331f, -0.00730591f, 0.08618588f, 0.03146969f, 
    0.09421162f, -0.08256562f, -0.15195301f, 0.04423480f, 0.05594546f, -0.02873571f, -0.04640552f, 0.21003254f, 
    -0.21247531f, 0.05527403f, 0.07684767f, 0.00876272f, 0.13352296f, 0.01285520f, -0.02731958f, 0.07253608f, 
    0.06010202f, 0.03143304f, 0.07781067f, -0.03679296f, -0.00435482f, 0.06037738f, 0.04378387f, 0.03984610f, 
    0.07453353f, 0.25510070f, -0.10852594f, 0.17871520f, 0.12630473f, 0.12419594f, -0.04236585f, 0.01210555f, 
    -0.00580876f, 0.04815915f, 0.05196688f, -0.04144386f, -0.00055650f, -0.12219237f, 0.04853829f, 0.03860629f, 
    0.09373123f, 0.15002356f, -0.03925193f, 0.26455438f, 0.40239078f, -0.12850384f, -0.15787464f, 0.21709764f, 
    -0.10555018f, 0.03163106f, -0.00084671f, 0.09848972f, 0.03720566f, -0.09006841f, 0.03749948f, 0.05729519f, 
    -0.10559709f, 0.03311555f, 0.16582264f, -0.09281446f, -0.07054549f, 0.05644736f, 0.07047537f, -0.08255780f, 
    0.29532027f, 0.13128226f, 0.05847412f, 0.01785635f, -0.05758592f, -0.09885132f, 0.03570451f, 0.00491998f, 
    -0.05358275f, 0.01723196f, -0.02094324f, -0.04118180f, 0.09260564f, 0.12981950f, -0.03987672f, -0.05383682f, 
    0.05365463f, 0.07811264f, 0.02857498f, -0.08695305f, -0.08586773f, 0.18236397f, 0.01732153f, 0.13833858f, 
    0.44848993f, -0.00174531f, -0.11128721f, -0.00422129f, 0.02618250f, 0.15552947f, -0.01509234f, -0.05527927f, 
    0.06602640f, 0.01340855f, -0.00438686f, 0.07082745f, 0.03958593f, 0.16206779f, -0.10499086f, 0.00787054f, 
    -0.57042176f, 0.25878373f, -0.03655618f, -0.11142398f, 0.12436114f, 0.14861350f, -0.19840899f, 0.15516254f, 
    0.01034889f, -0.11743233f, -0.06378750f, -0.04700777f, 0.17317340f, -0.05792541f, 0.08116069f, 0.04039082f, 
    0.10341617f, -0.00671644f, 0.13659842f, -0.01999534f, 0.13810278f, 0.17807941f, -0.20821483f, 0.04845167f, 
    0.16565898f, 0.00199923f, 0.05061775f, 0.00508362f, 0.01460173f, 0.06176899f, 0.04273875f, -0.01221776f, 
    0.04597439f, -0.08716872f, 0.18927263f, -0.06729379f, -0.02834704f, 0.08314337f, 0.02170404f, 0.16043162f, 
    -0.40325025f, 0.18560481f, 0.05324459f, 0.24047688f, -0.07049978f, 0.05877960f, -0.00457047f, 0.01913952f, 
    -0.02629576f, -0.07702049f, -0.03199438f, -0.08735853f, 0.08037502f, 0.15919843f, 0.05341764f, -0.14938709f, 
    0.14996095f, -0.03174077f, -0.03925799f, 0.11905918f, -0.31648287f, -0.17546105f, -0.12637320f, -0.21769795f, 
    0.06851444f, 0.05037764f, 0.00420974f, 0.14132985f, -0.07851759f, 0.09377278f, -0.14388630f, 0.02944265f, 
    0.17490652f, -0.07954384f, 0.02849267f, -0.10307121f, -0.11532684f, -0.03101796f, -0.03812731f, 0.01078726f, 
    0.07860839f, -0.15938476f, -0.30081668f, 0.21080481f, -0.36105934f, -0.10546966f, 0.03008098f, -0.04761829f, 
    0.01906968f, -0.04083746f, 0.06076830f, 0.08321564f, 0.07804982f, -0.01660188f, 0.05771961f, 0.02603550f, 
    -0.06918718f, -0.01120845f, -0.00625844f, -0.02505801f, -0.10317412f, -0.10671169f, 0.11841632f, 0.12032754f, 
    -0.28739038f, -0.13974114f, -0.03462675f, 0.11890215f, 0.06400722f, -0.04115736f, 0.01036060f, 0.09435814f, 
    -0.02869828f, 0.03025318f, 0.03180769f, 0.03548594f, -0.07472394f, -0.05806144f, 0.09959226f, 0.00870216f, 
    0.23132254f, 0.16836767f, 0.06309077f, 0.08977069f, -0.04267310f, -0.06211706f, 0.07186384f, -0.05600088f, 
    0.01270866f, -0.00059245f, -0.06029856f, -0.05979037f, -0.13696428f, -0.08510032f, -0.02923369f, 0.01617422f, 
    0.04135609f, -0.06567055f, 0.01121355f, 0.07422419f, -0.00490324f, 0.28729934f, -0.13911836f, 0.23562834f, 
    0.05515831f, 0.09774224f, -0.01663262f, -0.04537896f, -0.03921935f, 0.06253518f, 0.11443582f, 0.14771827f, 
    -0.00737781f, 0.03966574f, 0.08947524f, -0.05122630f, -0.10701334f, 0.15230989f, 0.14369890f, -0.06483126f, 
    0.11999964f, 0.00029639f, -0.09886831f, 0.11911254f, -0.10784064f, 0.08816385f, 0.14654048f, -0.06872960f, 
    0.07622185f, 0.15520187f, 0.02127402f, 0.00224899f, -0.02698190f, -0.06433202f, -0.13172960f, -0.03883232f, 
    0.03190628f, -0.13426380f, 0.13038024f, -0.10421771f, -0.21298674f, 0.03621062f, -0.12554574f, -0.04491361f, 
    0.17239104f, -0.01567966f, 0.02950077f, -0.00082512f, -0.02143344f, -0.01094931f, -0.08806426f, -0.09122679f, 
    0.10764959f, -0.02215454f, 0.04360373f, -0.07537573f, -0.03882611f, -0.04205190f, -0.10333309f, 0.00785007f, 
    -0.00592794f, 0.01517407f, -0.03074912f, -0.00674913f, 0.00506212f, -0.03428956f, 0.02520915f, -0.02736846f, 
    0.05885149f, 0.03604762f, -0.01907945f, -0.05973077f, 0.02267166f, -0.02382329f, 0.00644901f, -0.03009677f, 
    -0.00388627f, -0.02006366f, 0.01036187f, -0.03017198f, -0.01897920f, -0.04227978f, -0.06216499f, -0.03896613f, 
    -0.01019295f, 0.01244298f, 0.02823368f, 0.01440450f, 0.04330634f, 0.03580578f, 0.00817727f, 0.02301659f, 
    0.03423719f, -0.03675961f, -0.01725356f, -0.01336113f, -0.05478409f, -0.02189208f, -0.05306768f, -0.02259673f, 
    0.01333259f, 0.02705882f, -0.03213175f, -0.03781539f, -0.03215171f, -0.05179229f, -0.00131977f, 0.00970126f, 
    -0.00859836f, 0.01576522f, -0.05317051f, -0.05590099f, 0.01433883f, -0.01205792f, -0.01281232f, -0.02431066f, 
    -0.01567804f, -0.03172089f, 0.03251487f, -0.05213275f, -0.00115309f, -0.03350943f, -0.03308356f, -0.00426681f, 
    -0.02189643f, 0.00835091f, 0.02835028f, 0.05372984f, -0.03787051f, -0.02673505f, 0.00674294f, -0.03348498f, 
    -0.05324460f, -0.00617582f, 0.01163591f, 0.04103028f, 0.02642703f, 0.02361564f, 0.01526910f, 0.02401664f, 
    0.03909135f, -0.00476118f, 0.00466911f, -0.05831501f, 0.00510836f, 0.00675034f, 0.02559835f, -0.03422511f, 
    -0.02748786f, 0.05121518f, 0.03467819f, -0.03194769f, 0.02948343f, 0.01160020f, 0.02687708f, 0.00852310f, 
    -0.06059798f, 0.03543578f, -0.00272512f, -0.00247640f, 0.03689476f, -0.03196342f, -0.04379059f, 0.01663877f, 
    -0.01263008f, -0.00928977f, 0.02827046f, 0.04817704f, 0.04434443f, -0.05166353f, -0.05178948f, -0.05103577f, 
    0.02915116f, 0.00320568f, 0.01372772f, -0.02474107f, -0.00824540f, -0.05586874f, -0.03678449f, -0.03160721f, 
    0.03697022f, 0.02055033f, 0.01821012f, 0.04173839f, 0.02281614f, 0.03362456f, 0.02830931f, 0.02207955f, 
    0.02100798f, 0.05340699f, -0.02807903f, 0.00884845f, 0.00222372f, -0.05653686f, -0.00908158f, 0.03099542f, 
    0.03020203f, 0.01830429f, -0.01901872f, -0.03214143f, 0.03292190f, -0.05560704f, 0.01108323f, -0.04848526f, 
    -0.02717664f, -0.02931055f, -0.01230414f, -0.05251344f, -0.01095551f, 0.04773405f, -0.01089337f, 0.03767562f, 
    -0.03099050f, 0.03325071f, 0.01592507f, 0.00217971f, -0.01177559f, 0.04562393f, -0.00722937f, 0.00654275f, 
    -0.05123760f, -0.01530822f, -0.05874728f, 0.02792594f, -0.05681117f, -0.05877449f, -0.00783019f, 0.01682512f, 
    0.00776708f, 0.00665989f, -0.05082890f, 0.02439447f, -0.01604708f, -0.02972871f, -0.04754300f, -0.02983579f, 
    -0.05414192f, -0.00563167f, -0.05928386f, -0.00560236f, -0.01521331f, 0.01935554f, -0.05676690f, -0.05240840f, 
    -0.01968312f, 0.03710262f, 0.01075259f, 0.00007699f, -0.02933965f, -0.03746262f, 0.03871693f, -0.02714875f, 
    -0.06264538f, -0.03007403f, 0.03703724f, 0.04679858f, 0.01437331f, -0.01714427f, 0.03256792f, 0.00676186f, 
    -0.05322146f, 0.00294444f, -0.04028490f, -0.01663141f, -0.05790238f, 0.01765793f, 0.04070121f, -0.04824436f, 
    0.01440887f, -0.03492821f, -0.03049119f, -0.00417661f, 0.00829809f, 0.02549858f, 0.02591331f, 0.01047588f, 
    0.03017225f, -0.00946041f, -0.04262605f, -0.01488817f, 0.00708711f, -0.04995733f, -0.06046068f, 0.03616842f, 
    -0.03519809f, -0.00949473f, 0.01747061f, -0.03989449f, -0.00498092f, 0.04548573f, -0.00572839f, -0.00324268f, 
    -0.05466178f, 0.02014696f, 0.02707181f, -0.03253903f, -0.01161056f, -0.02587815f, 0.03108398f, 0.00019920f, 
    0.04545486f, 0.00937353f, 0.01820978f, 0.03028380f, -0.04967681f, -0.05802117f, 0.04231481f, 0.03539412f, 
    -0.04410101f, 0.02952770f, -0.05230334f, 0.05277484f, -0.04033903f, 0.04997580f, -0.05528104f, -0.04017794f, 
    -0.06270057f, -0.02802471f, 0.03601686f, -0.01831842f, -0.02716229f, -0.01338845f, 0.01976771f, 0.03112639f, 
    -0.02389670f, -0.02139745f, 0.02786498f, 0.02693788f, -0.05804477f, 0.05090776f, 0.04178187f, -0.01445598f, 
    0.04455488f, 0.02295666f, -0.04664770f, -0.04850395f, 0.00832917f, 0.03760783f, 0.04526937f, -0.02647263f, 
    -0.03989556f, -0.04454303f, -0.04284601f, -0.04611361f, 0.05062125f, 0.03123080f, -0.02382017f, -0.03803109f, 
    -0.02516911f, 0.00571479f, 0.03970569f, 0.04546459f, 0.01782391f, 0.00276310f, 0.02307184f, -0.00444529f, 
    -0.03806702f, 0.03800498f, 0.02099317f, -0.03938847f, 0.02980694f, -0.03164519f, 0.01681479f, -0.04775301f, 
    -0.00012228f, -0.00905961f, 0.02734468f, -0.05117549f, -0.05110170f, -0.03407271f, -0.00825857f, -0.01956588f, 
    -0.00904261f, 0.01386399f, -0.04343864f, -0.02369243f, 0.03861498f, -0.04207338f, -0.01757505f, -0.04327370f, 
    -0.18813471f, -0.28739086f, -0.16319045f, 0.09562214f, 0.01456970f, -0.15995544f, -0.05215384f, -0.03340990f, 
    0.17870423f, 0.01530361f, -0.14669557f, -0.06172908f, -0.03214134f, -0.05977970f, -0.07543744f, 0.00668813f, 
    -0.03222923f, -0.04970107f, -0.05883409f, 0.10451834f, 0.01538088f, 0.40179837f, -0.27626592f, -0.07972203f, 
    0.23933867f, -0.02352318f, -0.00844144f, 0.03903889f, 0.11944394f, -0.03908888f, 0.12659031f, 0.02129742f, 
    -0.10818346f, -0.01204672f, -0.14958821f, 0.07252542f, -0.06237683f, 0.02921249f, -0.02627629f, -0.02522946f, 
    0.24510683f, -0.04765037f, 0.14685397f, -0.11293884f, 0.13860892f, 0.00869655f, 0.09419389f, -0.05862301f, 
    0.07081863f, 0.00820961f, -0.09756767f, -0.00646490f, 0.06077171f, 0.07587161f, -0.08575508f, 0.00319075f, 
    -0.01368365f, 0.12396574f, 0.02033829f, -0.08282067f, 0.05834520f, 0.19727474f, -0.20840824f, 0.02112664f, 
    -0.02869714f, 0.03050691f, -0.12361069f, 0.13568309f, 0.11367189f, -0.06182064f, -0.02319273f, 0.06242591f, 
    0.02917685f, -0.11981048f, -0.12577285f, 0.16649647f, 0.12477518f, -0.05762510f, 0.06681937f, -0.01441840f, 
    0.25193256f, -0.09813929f, -0.10603094f, -0.03968499f, 0.36566985f, -0.12645842f, -0.03313050f, -0.02109991f, 
    -0.10273010f, -0.17235003f, -0.00162546f, 0.13453817f, -0.06917174f, -0.05274985f, 0.00884381f, -0.02454301f, 
    -0.11413267f, 0.20058452f, 0.03799883f, -0.02881423f, 0.20286910f, -0.03917577f, 0.03331406f, -0.02473796f, 
    0.18837754f, 0.06500423f, 0.07966094f, 0.07008015f, 0.04894951f, 0.06498086f, -0.09362062f, 0.05489593f, 
    -0.06360149f, -0.01307991f, 0.03391133f, 0.04676400f, -0.12162267f, 0.04742537f, 0.20754446f, 0.09145345f, 
    0.46229497f, -0.17933080f, 0.15718466f, -0.17623940f, -0.05042002f, -0.09246245f, 0.01112567f, 0.09341688f, 
    -0.10368149f, 0.00839028f, 0.03024578f, -0.10063259f, 0.09397639f, -0.03151803f, -0.04505266f, 0.11277827f, 
    -0.03662315f, -0.00349483f, -0.01237836f, 0.19145758f, -0.11888409f, 0.26702628f, -0.10017072f, -0.08354828f, 
    -0.13147992f, -0.06207317f, -0.10840254f, 0.08875871f, 0.04082565f, -0.08027362f, 0.01113530f, -0.01159723f, 
    -0.18224056f, -0.04846094f, -0.00156138f, -0.05566137f, -0.10139900f, -0.01870047f, 0.00636313f, 0.10067831f, 
    0.32629439f, -0.10232107f, 0.06775893f, 0.21566077f, 0.14926602f, 0.04402267f, 0.07795554f, -0.01820840f, 
    0.05308365f, 0.05486999f, -0.11820433f, 0.09445959f, 0.11242472f, 0.01782494f, -0.00851883f, 0.18746604f, 
    -0.13166438f, 0.09601680f, -0.00633857f, 0.16062313f, 0.34285912f, -0.38363773f, 0.19426927f, -0.29586533f, 
    -0.37976757f, -0.07650267f, -0.02506310f, -0.06886079f, -0.03436032f, -0.02058976f, 0.00441832f, 0.00145893f, 
    0.11094417f, 0.11292789f, -0.05277780f, 0.01665729f, 0.01771459f, -0.18276325f, -0.07632100f, -0.05581265f, 
    0.15012640f, 0.14128487f, -0.08300760f, 0.09571104f, -0.10037431f, -0.25236076f, -0.33363628f, 0.17622310f, 
    0.04514503f, -0.10546596f, -0.02448886f, 0.01390707f, 0.05516871f, 0.01909998f, -0.08487450f, 0.02697991f, 
    -0.05951001f, -0.00413247f, -0.05003827f, -0.02026327f, -0.21186286f, 0.31092164f, -0.00189428f, -0.08146288f, 
    0.16006546f, 0.03238456f, -0.12598412f, 0.03252102f, 0.02944095f, -0.04776430f, -0.08215734f, -0.07550031f, 
    0.04849456f, -0.00865182f, -0.10371672f, 0.05321991f, 0.11748707f, 0.00312115f, -0.09024218f, -0.13339970f, 
    -0.10825387f, 0.03979664f, -0.14012896f, 0.03312462f, 0.22888611f, 0.06781021f, 0.05902055f, -0.00907834f, 
    0.07235819f, 0.08314243f, 0.01011677f, 0.13501520f, -0.07333321f, -0.05631229f, -0.16739391f, 0.00789039f, 
    -0.03093800f, 0.13743724f, 0.13910830f, -0.11112126f, 0.18496300f, -0.17707354f, 0.05839610f, -0.29477346f, 
    0.11299343f, -0.08588062f, 0.06848454f, 0.02294702f, 0.00419361f, -0.03645008f, -0.07963437f, -0.15997151f, 
    -0.08298050f, 0.03546852f, -0.07104601f, 0.01378395f, 0.05101364f, 0.16198219f, -0.04226892f, 0.05518391f, 
    -0.16035375f, -0.09772835f, -0.00664005f, 0.21400973f, 0.23842916f, -0.04846156f, 0.09168909f, -0.00897282f, 
    0.02695904f, 0.00330694f, 0.17470679f, 0.12372329f, 0.00429906f, 0.11823981f, 0.03324151f, -0.08361584f, 
    -0.07273918f, 0.04977986f, -0.06253405f, 0.04181192f, 0.57593054f, -0.02325038f, -0.03656556f, 0.02606053f, 
    -0.09411728f, -0.03914518f, 0.10766748f, 0.01708865f, 0.08127745f, -0.09467469f, 0.07133646f, 0.09348866f, 
    -0.06803396f, 0.02760377f, 0.03724356f, -0.06184632f, -0.05196077f, 0.11918712f, -0.02165445f, 0.07809982f, 
    -0.28790885f, 0.09832438f, 0.14150834f, -0.08267172f, 0.15227045f, -0.07147329f, 0.02823712f, 0.04030652f, 
    0.10926789f, -0.06510026f, -0.03242904f, 0.09671486f, -0.03993386f, 0.10837859f, 0.02319757f, 0.12620348f, 
    0.06694475f, -0.06228046f, -0.05232161f, 0.16637670f, 0.18696059f, -0.18197787f, -0.02229824f, 0.02815819f, 
    0.14953497f, -0.03852616f, -0.07800667f, 0.02378767f, 0.09780461f, 0.02646336f, -0.10673049f, -0.01423858f, 
    -0.06236379f, 0.06080954f, 0.02047448f, 0.16828266f, 0.01086512f, -0.10401803f, 0.12436563f, -0.09120131f, 
    0.09540754f, -0.16022795f, 0.28115872f, 0.09948944f, 0.25511292f, 0.05513767f, -0.14451987f, -0.00098621f, 
    0.00803153f, 0.07524217f, -0.08571140f, -0.11324466f, 0.04327319f, 0.09181739f, 0.03283363f, -0.01634167f, 
    -0.19009744f, 0.04520626f, 0.05516555f, 0.13418378f, 0.53794318f, -0.16731225f, -0.02354279f, 0.07953113f, 
    -0.13593869f, -0.11100671f, -0.07465406f, 0.15595289f, 0.07211774f, -0.07152330f, 0.05828252f, -0.11469863f, 
    -0.11965185f, -0.06122877f, -0.02089614f, 0.07071871f, 0.00356201f, -0.00655677f, -0.06026118f, -0.04491379f, 
    0.12490966f, -0.02796283f, -0.16315308f, -0.02041906f, 0.34543341f, 0.09694961f, -0.01400573f, -0.00753633f, 
    0.04818497f, -0.15147474f, 0.06172569f, 0.13695180f, -0.05975287f, -0.12046493f, 0.01839547f, -0.03154530f, 
    0.09153995f, -0.07249627f, -0.11573464f, -0.07778619f, 0.32642442f, -0.14845845f, 0.04225404f, 0.12460129f, 
    -0.01212534f, 0.02054798f, 0.10730154f, 0.09054786f, 0.11046880f, 0.09643539f, -0.03260843f, -0.02809135f, 
    -0.02827595f, 0.11426836f, 0.14699712f, -0.06302866f, -0.10650718f, -0.02965407f, 0.08812253f, -0.04710208f, 
    -0.23984359f, -0.03924890f, -0.20131382f, 0.09832931f, -0.17966338f, -0.05496208f, -0.03486174f, 0.05989508f, 
    0.04733293f, -0.01347615f, -0.07845096f, 0.09925216f, 0.02326604f, 0.04162739f, 0.07730669f, 0.08839373f, 
    0.00176788f, 0.01346899f, -0.04053015f, 0.11492570f, -0.01127722f, -0.02625209f, -0.17709427f, 0.24901631f, 
    -0.01292042f, -0.03040552f, 0.01359846f, -0.00589669f, 0.07602566f, -0.02428653f, -0.08438963f, -0.09568696f, 
    0.07646909f, 0.04051203f, 0.01308229f, 0.13778496f, 0.01593611f, 0.00031873f, 0.05130508f, -0.14696607f, 
    -0.22084975f, 0.09469324f, 0.26581916f, 0.16817148f, 0.11810305f, 0.01936083f, 0.04646496f, 0.04679164f, 
    0.07654141f, -0.01014933f, -0.01082555f, 0.05203959f, 0.03517547f, 0.02114987f, -0.07654750f, -0.03501483f, 
    -0.04094239f, 0.08781254f, 0.02552842f, 0.07436951f, 0.15899129f, -0.01542494f, -0.32398081f, -0.33914912f, 
    -0.56275898f, 0.16259591f, 0.10906798f, -0.05834812f, -0.10270677f, -0.01527874f, -0.09276342f, 0.02472444f, 
    0.02891111f, 0.07168192f, 0.00130707f, -0.00184306f, 0.00257222f, -0.00813270f, -0.11631694f, 0.00755930f, 
    0.11754826f, -0.07198874f, 0.02432657f, 0.03040989f, 0.11294068f, -0.22280774f, -0.14968236f, -0.00911864f, 
    0.07667901f, -0.08272292f, -0.05990989f, 0.08300176f, -0.06978168f, -0.06095091f, -0.03356127f, 0.01422880f, 
    -0.01252841f, 0.07570130f, 0.01751089f, 0.01661940f, -0.06321827f, -0.01056752f, 0.15435858f, -0.12207101f, 
    0.07963584f, -0.03016079f, -0.02495633f, -0.08241348f, 0.09536580f, 0.05063144f, 0.03213984f, 0.04594487f, 
    0.05173178f, -0.05412876f, 0.03519838f, -0.12670235f, -0.11107848f, 0.05104021f, 0.01300158f, -0.02959231f, 
    -0.04188865f, 0.05346388f, 0.03019102f, 0.17375197f, 0.20723176f, -0.23640053f, 0.03573765f, 0.19691959f, 
    0.06660652f, 0.15280987f, 0.04253356f, -0.05133282f, -0.05319929f, -0.05177629f, -0.07394597f, 0.03979375f, 
    0.00989289f, -0.06970672f, 0.04255695f, 0.01388182f, 0.03394854f, -0.08618528f, -0.04414377f, 0.13470252f, 
    0.09407856f, 0.05941885f, 0.02779454f, 0.10444698f, 0.02774823f, 0.09951530f, -0.08067178f, 0.02632941f, 
    0.17212191f, 0.02613994f, 0.04848631f, 0.12374086f, 0.02085186f, 0.12518907f, 0.08828406f, -0.01826725f, 
    0.11003450f, -0.24361044f, 0.31275076f, -0.14355668f, 0.09570833f, -0.12175073f, 0.08492655f, 0.11416365f, 
    0.01341252f, -0.05135849f, 0.12484601f, -0.02278343f, -0.12671877f, 0.03054007f, -0.10195699f, -0.09287323f, 
    0.06795482f, -0.09924828f, -0.03591544f, 0.06080016f, 0.00083630f, 0.10362666f, -0.49690244f, 0.00701045f, 
    0.00279295f, 0.10408490f, -0.04265258f, -0.00598118f, -0.08958587f, 0.06133488f, 0.00839701f, -0.05083224f, 
    0.11852002f, -0.09487971f, 0.00795447f, -0.01953769f, 0.00147103f, 0.04081792f, -0.06462586f, -0.01085836f, 
    0.02524184f, 0.02391014f, 0.00967844f, -0.03958677f, 0.01592983f, -0.06065119f, -0.03535344f, -0.05211980f, 
    -0.00481508f, 0.04067462f, 0.01281728f, -0.02591573f, -0.06040979f, -0.02539443f, 0.01353009f, 0.01776155f, 
    0.03134163f, -0.01856693f, 0.03474566f, 0.00153505f, -0.01459722f, -0.02778731f, -0.04261559f, -0.05791941f, 
    0.04245578f, -0.02543104f, 0.04560928f, 0.04361431f, -0.01249643f, 0.02827104f, -0.01960843f, -0.02243833f, 
    0.00638041f, -0.01961404f, -0.01512769f, 0.03594901f, -0.04945295f, -0.04677404f, 0.04654899f, 0.02982313f, 
    -0.00482118f, -0.06247854f, -0.05668017f, -0.00524477f, 0.04251507f, -0.02340516f, 0.03422220f, -0.05726799f, 
    0.01768548f, 0.03638236f, -0.04152303f, -0.02144323f, -0.00688201f, -0.03724856f, 0.03333908f, 0.00269474f, 
    -0.01071142f, 0.04478727f, -0.01039506f, -0.03162607f, 0.00700647f, 0.00863457f, -0.04508959f, 0.02120781f, 
    0.01736177f, 0.01332739f, 0.03451391f, 0.00149351f, 0.02758588f, 0.01145837f, -0.00184197f, -0.04659633f, 
    -0.02874013f, 0.02229018f, -0.01410215f, 0.03468227f, 0.01441100f, 0.00781329f, -0.02607882f, 0.01115810f, 
    0.01096207f, -0.05169945f, -0.03583506f, -0.00227882f, 0.03551130f, -0.05013187f, 0.01011784f, 0.03033899f, 
    0.05115079f, 0.00813936f, 0.01100229f, -0.02222737f, 0.02730289f, -0.05391522f, -0.02469970f, -0.00878963f, 
    -0.05673540f, -0.03383068f, 0.00187920f, -0.05439818f, 0.01669011f, 0.00098776f, 0.03772805f, 0.04157845f, 
    0.04397830f, -0.05356950f, -0.01960636f, 0.04537082f, 0.03800422f, 0.01766588f, 0.02657468f, -0.03085219f, 
    -0.01260909f, 0.02135618f, -0.03615388f, 0.01544454f, -0.02269056f, -0.04732652f, 0.01277550f, 0.02658599f, 
    -0.01421949f, 0.00131358f, -0.03901805f, -0.00024144f, -0.04562099f, -0.03701280f, 0.00596399f, -0.00275029f, 
    0.01648306f, -0.03390674f, -0.05600681f, -0.03310309f, -0.01470161f, 0.03900170f, 0.01811559f, 0.05251249f, 
    -0.00447017f, -0.03153824f, -0.05465354f, 0.01329249f, 0.02993853f, 0.00594415f, -0.04150921f, -0.05071372f, 
    -0.03268109f, 0.05611454f, -0.01544371f, -0.04198106f, 0.00195060f, 0.01788209f, -0.04745246f, -0.02923695f, 
    -0.03930604f, -0.05849339f, 0.00522346f, -0.02868423f, -0.02041106f, -0.03929932f, -0.05029807f, -0.01439448f, 
    0.04415904f, 0.05126072f, -0.05285794f, -0.03907155f, -0.04088277f, -0.00780106f, -0.02494886f, -0.02211890f, 
    -0.02265170f, -0.04196799f, -0.02391635f, -0.01366830f, -0.06041158f, -0.03068454f, -0.02943710f, -0.04945888f, 
    0.03652489f, 0.00801021f, 0.00578982f, -0.02492428f, 0.03811724f, 0.00115937f, 0.02878778f, 0.02885550f, 
    -0.01791496f, -0.01600981f, 0.00577254f, -0.00575129f, 0.00406798f, 0.01484426f, 0.00662971f, -0.01550585f, 
    -0.05772187f, 0.04111646f, -0.03924803f, -0.01135437f, -0.01109285f, 0.00513087f, -0.04394031f, 0.04879686f, 
    -0.02293821f, -0.01893275f, 0.06376848f, 0.03439451f, -0.02050316f, -0.01088794f, 0.02499059f, -0.01680808f, 
    -0.03882692f, -0.03738150f, 0.00097451f, -0.02268525f, -0.05345260f, -0.00762112f, -0.05130372f, 0.04013694f, 
    0.04168926f, 0.02523292f, -0.01557461f, 0.04698504f, -0.02610428f, -0.00211576f, -0.01791406f, -0.04618208f, 
    -0.04927021f, -0.04047891f, 0.03536243f, 0.01447825f, 0.02242363f, -0.06305770f, -0.04412960f, 0.00949776f, 
    -0.03883249f, -0.01831243f, 0.02920601f, -0.02825363f, -0.01166483f, 0.04155003f, 0.02527859f, -0.02574371f, 
    0.01677864f, -0.01618505f, 0.00259106f, -0.05876684f, 0.00311275f, -0.05707103f, -0.03128134f, -0.00364443f, 
    -0.02087198f, -0.01076155f, 0.03615703f, 0.01104842f, 0.01311605f, -0.05135599f, -0.05674200f, -0.04255713f, 
    0.02180368f, 0.03394988f, -0.01580056f, -0.00402213f, -0.00620685f, -0.05117312f, -0.00695653f, 0.02416367f, 
    -0.02500535f, 0.01790244f, 0.03839451f, 0.02116752f, -0.01098299f, 0.02346766f, 0.00047449f, 0.05110746f, 
    -0.03621866f, -0.02883401f, -0.01403796f, 0.03694154f, 0.04488780f, 0.02168797f, 0.04605620f, -0.06269240f, 
    -0.06146776f, 0.00360420f, -0.04580067f, 0.00444621f, 0.01408905f, -0.02681051f, -0.05993672f, 0.03707375f, 
    0.00886063f, 0.00347597f, -0.05589756f, 0.02976845f, -0.05432916f, 0.00088688f, -0.03714477f, -0.02859908f, 
    -0.03599829f, -0.03893750f, 0.01554000f, -0.00190155f, -0.05617310f, 0.01971792f, 0.01330487f, -0.05470607f, 
    0.02199188f, -0.01528785f, -0.01654736f, 0.02928912f, 0.01547049f, -0.05863016f, 0.02559836f, 0.01657523f, 
    0.02599242f, -0.02967520f, 0.02232550f, 0.04055935f, 0.03005719f, 0.02519945f, 0.04254437f, -0.02736341f, 
    -0.02676648f, -0.03990185f, 0.02910075f, -0.02544237f, -0.05848236f, -0.04624085f, 0.04713945f, 0.00539124f, 
    0.04982040f, -0.05607286f, 0.03158309f, 0.04176268f, 0.00059367f, 0.00023163f, -0.00152172f, -0.03450454f, 
    -0.02874598f, 0.03545304f, -0.01790036f, -0.04766184f, -0.05429526f, 0.00143753f, 0.02427732f, 0.01250931f, 
    -0.02897204f, 0.04486755f, 0.03785774f, -0.04932687f, -0.00255893f, -0.02265917f, -0.02077432f, -0.03801890f, 
    -0.04721883f, -0.03132574f, -0.04652884f, -0.03241536f, -0.02181489f, 0.00243456f, -0.03272947f, 0.03176564f, 
    -0.02248420f, -0.03021734f, -0.02146695f, 0.00164097f, -0.05466110f, 0.03623779f, -0.00142193f, -0.03331242f, 
    0.03283070f, -0.04265210f, 0.00522829f, 0.04141589f, -0.03998890f, -0.05046933f, 0.01542592f, -0.04768636f, 
    -0.00765253f, -0.05606895f, 0.04620328f, -0.00621242f, 0.02095448f, -0.03693764f, 0.04375573f, -0.02120002f, 
    0.04425676f, -0.00555911f, -0.04684730f, -0.00278762f, -0.06157969f, 0.01334099f, 0.04603156f, -0.01447568f, 
    -0.04452560f, -0.05945581f, 0.00972751f, -0.04361365f, -0.00862802f, 0.03027132f, -0.04314723f, -0.05620202f, 
    0.02717750f, -0.01983136f, 0.03320109f, 0.04208343f, -0.00963108f, -0.04853689f, -0.03069452f, -0.04061793f, 
    -0.02390815f, -0.01905575f, 0.01315887f, 0.00330331f, -0.01234555f, 0.01792732f, 0.03627196f, -0.04330987f, 
    -0.00551104f, -0.02472334f, 0.03176745f, 0.00567943f, -0.04564300f, 0.04518181f, -0.06117029f, -0.03106504f, 
    -0.00664337f, -0.04300963f, 0.01799245f, -0.02416690f, -0.04741637f, 0.00597164f, -0.01423291f, -0.00672655f, 
    -0.05268994f, 0.04799375f, 0.00133822f, -0.04250862f, 0.01714315f, -0.05752420f, -0.06147103f, -0.00654494f, 
    -0.01728308f, -0.01186422f, -0.01226959f, 0.00395545f, 0.03052612f, -0.03270257f, -0.01313483f, -0.00104194f, 
    0.01835988f, 0.01139677f, -0.00907257f, 0.01907659f, -0.00656833f, -0.03508878f, -0.00032144f, -0.03836821f, 
    0.01559061f, -0.05381110f, -0.02960945f, -0.05811009f, 0.02746308f, 0.01965609f, 0.04764611f, 0.01033067f, 
    0.00189215f, -0.03401506f, 0.00776791f, 0.03746543f, -0.05476172f, 0.01885685f, 0.02927661f, 0.03424505f, 
    -0.00693704f, -0.04832670f, 0.04009140f, -0.01346464f, -0.05815595f, -0.01828048f, -0.02530675f, -0.03799298f, 
    0.00435070f, 0.00221300f, -0.00803888f, -0.00236857f, -0.03176100f, -0.03758368f, 0.03743641f, 0.02488592f, 
    -0.03071966f, -0.01029734f, -0.02383714f, 0.00497147f, 0.00787601f, 0.02053162f, -0.00286955f, -0.02275795f, 
    0.03149862f, 0.01142123f, -0.03211512f, -0.03327284f, -0.00229636f, 0.02030097f, 0.01459486f, 0.03115899f, 
    0.03082814f, 0.01957749f, 0.01125458f, 0.02791030f, -0.01651128f, -0.00478094f, 0.03883967f, 0.04987852f, 
    -0.05873300f, -0.02366974f, 0.02228500f, 0.00987185f, 0.03985974f, -0.03414080f, 0.01287383f, -0.05278546f, 
    -0.04385931f, -0.01117455f, 0.03574790f, -0.05017565f, -0.03674730f, 0.04782219f, -0.05041280f, 0.01830946f, 
    0.03001256f, 0.01620670f, 0.00904297f, -0.00120419f, 0.04711164f, -0.02889304f, -0.06040350f, 0.00226042f, 
    -0.04551000f, -0.04657710f, 0.01543277f, -0.04092221f, 0.02194623f, -0.02892287f, 0.00094707f, -0.00715199f, 
    -0.01286409f, -0.01207884f, 0.02979090f, -0.04282185f, -0.03986363f, -0.00639754f, 0.03757652f, 0.01581399f, 
    0.03074270f, -0.01228793f, -0.01553648f, -0.03902339f, 0.04583170f, -0.05059272f, 0.01651538f, -0.00355495f, 
    0.03580371f, -0.04161151f, 0.04022837f, 0.00123788f, -0.03426331f, -0.00485576f, 0.00140922f, 0.00799893f, 
    -0.01533751f, 0.03715320f, 0.04978421f, 0.01053139f, 0.00112175f, -0.00437056f, 0.04254639f, 0.04962921f, 
    0.03330659f, 0.04030919f, -0.03739060f, 0.03725816f, -0.02955736f, 0.02080167f, -0.03559078f, 0.01502840f, 
    0.03725965f, -0.01336552f, -0.03883908f, -0.01153474f, -0.04818112f, 0.04683697f, -0.01100118f, -0.04913871f, 
    0.02224128f, -0.02634257f, 0.04076468f, -0.04068538f, -0.03591255f, -0.02467244f, -0.00555102f, -0.04378800f, 
    0.03187430f, 0.01960766f, 0.04074192f, -0.01774885f, -0.02714728f, -0.03451296f, 0.01258367f, 0.00926756f, 
    -0.05020852f, 0.02187090f, 0.02641380f, -0.02046493f, 0.03288404f, -0.04814903f, 0.03318204f, -0.00780427f, 
    0.01213642f, 0.00060992f, -0.00233905f, -0.03669156f, -0.00245080f, 0.04834303f, 0.02744549f, -0.04506237f, 
    -0.00219235f, -0.03937354f, -0.04661386f, 0.02555747f, 0.00664743f, 0.04275807f, -0.01256383f, 0.00463583f, 
    -0.05634068f, -0.05876829f, 0.03004941f, -0.01847677f, -0.04932559f, 0.01975976f, -0.05708217f, -0.05062592f, 
    0.03498799f, -0.05044100f, 0.03575656f, 0.00816813f, -0.00005924f, 0.03982073f, 0.01916225f, 0.00703285f, 
    0.01867311f, 0.01629404f, -0.04184588f, -0.01200305f, -0.04730621f, -0.03715441f, 0.03788790f, -0.03032785f, 
    -0.03301215f, -0.03570451f, -0.05445502f, -0.02905937f, 0.04085973f, 0.01412682f, -0.00596909f, -0.03240109f, 
    -0.00118559f, -0.04989519f, 0.03211589f, 0.00469570f, -0.04519487f, -0.05062299f, 0.04883486f, -0.01336454f, 
    -0.05380976f, -0.03723286f, -0.05219145f, 0.02953581f, -0.01725266f, 0.05026691f, -0.02194444f, -0.01066347f, 
    0.01948643f, 0.01364294f, -0.03692177f, -0.05250784f, -0.00958120f, 0.04606693f, 0.00425779f, 0.04440380f, 
    0.02425618f, 0.03023695f, -0.05717745f, -0.00929800f, 0.00285135f, -0.02418244f, -0.02292614f, -0.00948904f, 
    -0.02317084f, 0.04312056f, 0.02816627f, -0.02821754f, -0.03252194f, 0.01726833f, 0.04230169f, 0.04289561f, 
    0.00885461f, -0.02761573f, 0.01776619f, -0.01537258f, -0.02964814f, -0.01404375f, -0.04900405f, 0.05681486f, 
    0.02552954f, 0.04187951f, 0.03067330f, 0.03286812f, 0.04409421f, -0.00334648f, 0.02933575f, -0.00006895f, 
    0.03573859f, -0.00070903f, -0.01576534f, -0.02103473f, 0.03994907f, 0.00902629f, 0.01115670f, -0.01312216f, 
    -0.04468232f, -0.01196886f, 0.02829388f, 0.03396692f, -0.01167436f, -0.02269000f, 0.02797998f, 0.03047698f, 
    -0.04687385f, -0.05530922f, -0.00751504f, -0.03101815f, -0.02756598f, -0.02466223f, -0.02326087f, 0.03855427f, 
    -0.04643314f, 0.00330945f, -0.02813441f, 0.03211495f, 0.04722711f, -0.00256356f, -0.00446660f, 0.00901237f, 
    -0.02349159f, 0.02635493f, 0.03447443f, -0.05317510f, -0.03021724f, 0.01789347f, 0.00623387f, 0.04579961f, 
    -0.03483440f, 0.00764487f, 0.04786887f, -0.05092146f, 0.03331956f, -0.05562971f, -0.00935199f, 0.04159434f, 
    -0.05024217f, 0.00967298f, -0.01242976f, -0.01698954f, 0.02003309f, -0.03557081f, -0.05597901f, 0.04123948f, 
    0.03021137f, 0.00863178f, 0.01102135f, -0.05805007f, -0.01756035f, 0.02366296f, -0.04160826f, 0.05754963f, 
    0.03850312f, 0.02111429f, 0.00295555f, -0.05377051f, -0.04343393f, -0.04260518f, -0.05689269f, 0.01496857f, 
    0.05174233f, -0.03587015f, -0.05747933f, 0.04905366f, 0.04693254f, 0.04500371f, -0.04575318f, 0.03400661f, 
    0.04184458f, -0.01425533f, -0.01799168f, 0.02115516f, -0.06073037f, 0.04618441f, 0.01862366f, -0.02863888f, 
    0.00018077f, -0.03793717f, -0.01648344f, -0.02159441f, -0.01984602f, -0.02414867f, -0.05345475f, -0.01830730f, 
    -0.00552975f, -0.05574813f, -0.05292038f, -0.05588947f, 0.02227585f, 0.01115374f, 0.01533168f, -0.03501910f, 
    -0.01826283f, -0.04663241f, -0.02869746f, -0.05840188f, -0.05529943f, 0.03383597f, -0.06255514f, -0.02959484f, 
    0.04842092f, -0.01422035f, 0.02439627f, 0.03823265f, -0.02518210f, -0.04282544f, 0.04116594f, 0.04391448f, 
    -0.01809815f, 0.00486504f, -0.04242179f, -0.02841355f, 0.04396699f, -0.04863216f, 0.01455127f, -0.04888587f, 
    -0.04754171f, -0.01633053f, -0.03304804f, -0.00040636f, -0.02714031f, 0.01570562f, -0.05597660f, -0.03727608f, 
    0.03326524f, -0.02126279f, 0.00302361f, -0.01836327f, -0.06105220f, 0.02429313f, -0.00021427f, -0.02896288f, 
    0.03755613f, 0.00035738f, 0.00507235f, 0.00002708f, 0.03450427f, -0.01923725f, -0.02108753f, -0.01147321f, 
    0.02348589f, 0.04666198f, -0.04314229f, -0.04019422f, -0.03370930f, -0.05267565f, -0.04630120f, 0.02842846f, 
    -0.02369312f, 0.02531832f, 0.01422307f, -0.00174184f, 0.04306374f, -0.01128208f, -0.01520399f, 0.03431141f, 
    -0.05555469f, 0.00328675f, -0.04292175f, 0.01359348f, -0.03894440f, -0.04804940f, -0.05056368f, 0.00209620f, 
    -0.03948012f, 0.02229372f, 0.04467013f, 0.00167410f, -0.05525236f, 0.01376745f, -0.02831936f, -0.00292332f, 
    0.00014384f, 0.02194992f, 0.01265037f, -0.03239152f, -0.00824781f, -0.05451005f, 0.02297394f, -0.03021826f, 
    0.01694977f, -0.00165922f, 0.02035706f, -0.05795526f, -0.04079305f, -0.04387045f, -0.04297246f, -0.03948597f, 
    -0.05046977f, 0.04445247f, 0.02500463f, -0.01974073f, 0.02156369f, -0.05971384f, -0.00486194f, -0.04010718f, 
    -0.03083123f, 0.02834746f, 0.02503791f, -0.01367624f, -0.03142847f, 0.00130459f, -0.04041612f, -0.00173421f, 
    -0.06135500f, 0.02546807f, -0.02510275f, -0.01485496f, -0.00828328f, 0.02875802f, 0.02401654f, -0.04712347f, 
    0.00542504f, 0.04752795f, 0.02023690f, 0.00419189f, 0.02648083f, 0.00968088f, 0.01848888f, -0.05472213f, 
    0.04785078f, -0.04287546f, -0.03948996f, 0.00254362f, 0.00512910f, -0.01546290f, -0.04172705f, 0.02979437f, 
    0.09480852f, 0.53401065f, 0.18375154f, 0.03556449f, 0.37044883f, -0.03636599f, -0.06930915f, 0.00277975f, 
    -0.05871651f, -0.02815321f, 0.19914205f, 0.10101958f, 0.03518758f, 0.11666124f, 0.03614015f, 0.09869713f, 
    -0.01978640f, 0.07590942f, -0.08110627f, 0.04183789f, -0.14600068f, 0.14035745f, 0.25356817f, 0.20121701f, 
    -0.12936834f, 0.00316437f, -0.11629820f, -0.07281366f, -0.01032603f, -0.11556295f, -0.13966434f, 0.04574745f, 
    -0.00085751f, 0.09635039f, -0.00162139f, 0.04875184f, -0.01954659f, 0.00344817f, -0.02865740f, -0.04781793f, 
    -0.13311097f, -0.02067379f, -0.02152702f, -0.08904485f, -0.00405219f, 0.02741661f, -0.00369361f, 0.00586836f, 
    -0.08519041f, 0.06244193f, 0.13592762f, -0.13731071f, 0.04845992f, 0.01615178f, 0.02027978f, -0.10411821f, 
    -0.04949247f, 0.07345508f, 0.00174599f, 0.09982858f, -0.00682863f, 0.28560060f, 0.08905587f, -0.00455781f, 
    -0.18179999f, -0.03898327f, 0.11143713f, 0.04894406f, 0.05638781f, -0.00729599f, -0.14525528f, -0.04466611f, 
    0.00806232f, -0.12458993f, 0.00717539f, 0.02084816f, 0.09498084f, 0.14621340f, 0.02230012f, -0.01936607f, 
    -0.37536839f, 0.23110631f, 0.07864325f, -0.01655171f, 0.26481739f, -0.04124979f, 0.16224205f, -0.18997246f, 
    0.06606337f, 0.03074062f, 0.05730520f, 0.10618439f, 0.03858726f, 0.04818897f, 0.03199464f, 0.19718724f, 
    0.08133385f, 0.07392862f, -0.03882771f, 0.07266755f, 0.23574536f, 0.17733471f, -0.24138531f, 0.02077092f, 
    0.05505860f, -0.09729805f, -0.07529195f, -0.07384226f, 0.03957463f, -0.04949483f, -0.16811699f, -0.08230430f, 
    -0.03410349f, 0.07918331f, 0.09809565f, 0.10016321f, -0.05012891f, -0.00045202f, 0.11861515f, -0.00633079f, 
    -0.11321442f, 0.08708140f, -0.08252220f, -0.25937432f, 0.15655042f, 0.15454133f, 0.18028621f, -0.01196255f, 
    -0.00047197f, -0.11657685f, 0.00887909f, 0.02228983f, -0.02523132f, 0.05592077f, -0.04288810f, -0.11420923f, 
    -0.08510367f, 0.00357883f, -0.04392783f, 0.06236405f, -0.39545208f, -0.32857695f, 0.05445357f, 0.07250910f, 
    0.19757530f, -0.03370564f, -0.02078199f, -0.06590045f, -0.12228175f, 0.00980911f, 0.10649959f, 0.21795513f, 
    0.03417300f, 0.02413969f, 0.12376000f, 0.07992445f, -0.00623034f, 0.21575892f, -0.03214244f, 0.00341072f, 
    0.63835412f, -0.26975787f, 0.36502752f, 0.11643440f, -0.03671515f, 0.15090129f, 0.07778107f, 0.00311084f, 
    -0.02550904f, 0.05823144f, 0.09110975f, -0.08824746f, -0.06521420f, 0.01987551f, -0.05690416f, 0.05120572f, 
    0.05917763f, 0.05977552f, 0.13229096f, -0.03981565f, -0.14230666f, 0.18037564f, 0.06455383f, -0.04253790f, 
    0.18882200f, 0.03542356f, 0.16290866f, 0.00341046f, 0.03664568f, -0.07660995f, 0.00230077f, -0.02541732f, 
    -0.10466029f, -0.02325368f, 0.06045449f, 0.06348849f, -0.04971672f, 0.03567431f, 0.10252777f, 0.01766248f, 
    -0.21050157f, 0.07798298f, 0.08992860f, 0.11732806f, 0.17101356f, 0.12831478f, 0.11929747f, -0.03426193f, 
    0.01244048f, -0.13521971f, -0.15845904f, 0.10537913f, -0.06307930f, -0.07629769f, 0.00446160f, 0.08080194f, 
    -0.12847680f, 0.05154087f, 0.02329643f, -0.04303271f, 0.50067657f, -0.20393811f, 0.19280730f, 0.05881032f, 
    -0.25594771f, 0.08547208f, 0.00711042f, -0.14941312f, -0.11018963f, -0.10821794f, -0.13263211f, -0.02702112f, 
    0.14226112f, 0.04533324f, 0.06405191f, -0.13429612f, -0.02188025f, -0.00746322f, 0.17672767f, -0.11725905f, 
    -0.19369270f, 0.10236586f, 0.20737860f, 0.04115922f, -0.07677972f, -0.11758336f, -0.13898405f, -0.18121155f, 
    0.09432951f, -0.01564395f, 0.02714010f, -0.09303803f, -0.05716274f, 0.01542390f, -0.03445771f, 0.02535865f, 
    0.02040371f, 0.04227237f, -0.00351517f, -0.14681779f, -0.30763674f, -0.21023126f, 0.04611922f, -0.03574464f, 
    0.20761991f, 0.04117299f, -0.07847703f, 0.12198140f, -0.02028077f, 0.08819730f, 0.07671890f, 0.14121816f, 
    -0.00168567f, 0.00411109f, 0.07958322f, -0.07691126f, -0.05521103f, -0.08894627f, 0.07873052f, -0.17613998f, 
    -0.23165254f, 0.40119639f, 0.12796557f, -0.10458277f, -0.34150565f, -0.07208680f, -0.09591553f, 0.02432943f, 
    0.04980029f, 0.14102918f, -0.05706244f, -0.01858531f, 0.10202672f, 0.09843068f, -0.14583254f, 0.06891010f, 
    0.04860227f, -0.04962689f, -0.15300597f, -0.07495786f, -0.36950454f, -0.04173519f, 0.16084976f, -0.08792093f, 
    0.20966969f, 0.13899872f, 0.16766699f, 0.03341727f, -0.06859364f, 0.02696637f, 0.08548762f, 0.00441741f, 
    0.07477643f, -0.09963942f, 0.11669642f, 0.05746217f, -0.00206847f, -0.11934785f, 0.07269113f, 0.05339640f, 
    -0.49048367f, 0.09717428f, -0.25856808f, 0.17261288f, -0.35170278f, 0.23228681f, 0.16974825f, 0.07136577f, 
    0.02600074f, 0.08160929f, 0.02697563f, -0.01906787f, -0.02214024f, 0.02386916f, 0.06229911f, -0.03247731f, 
    0.01734373f, -0.00527124f, -0.29473031f, -0.05549710f, 0.14668725f, 0.27432874f, 0.05462407f, 0.03580269f, 
    -0.16027136f, -0.08583225f, 0.15789689f, 0.04106285f, 0.10280983f, -0.00650168f, 0.01478907f, 0.02318345f, 
    0.03124028f, 0.02228054f, 0.08198862f, -0.00583474f, 0.08488712f, 0.05869398f, -0.01167465f, 0.14416321f, 
    -0.00246275f, 0.29924810f, -0.21912347f, 0.25109357f, -0.01737685f, 0.04385568f, 0.04122778f, -0.00367378f, 
    0.02114849f, 0.01930434f, 0.09602005f, 0.04498517f, -0.04888460f, 0.00084664f, 0.01394541f, -0.01701535f, 
    0.18985596f, 0.11170422f, 0.05153610f, 0.13024916f, 0.16910334f, -0.07306784f, -0.00023815f, 0.04209266f, 
    -0.12816937f, -0.00808153f, 0.07461426f, -0.10213131f, -0.03252554f, 0.06170460f, 0.13094294f, 0.11358596f, 
    -0.13236803f, -0.18912320f, 0.05737125f, -0.10112278f, -0.09482233f, -0.12450984f, -0.00469378f, 0.05489233f, 
    -0.00023889f, 0.13783029f, 0.14116302f, 0.10705602f, -0.10543423f, -0.19845799f, 0.05001027f, 0.05598796f, 
    -0.01530685f, 0.00100193f, -0.14127095f, -0.03367235f, 0.14651610f, 0.07186156f, 0.07108574f, 0.09858939f, 
    -0.10468329f, 0.35447016f, -0.04433514f, 0.02976585f, -0.02185327f, 0.14372273f, -0.05612496f, 0.10315990f, 
    0.11446042f, -0.01162547f, -0.05097563f, -0.08077388f, -0.04009718f, 0.02935840f, -0.05659568f, -0.00822646f, 
    -0.04609297f, -0.06865551f, -0.03464510f, 0.09885129f, 0.09624111f, 0.17309678f, 0.00081894f, 0.14322826f, 
    -0.52059108f, 0.32165024f, 0.24206422f, -0.08260729f, 0.10188375f, 0.13096400f, -0.17165147f, 0.02947014f, 
    0.07763375f, -0.05191848f, -0.13342895f, -0.06789015f, 0.22201794f, 0.00249774f, 0.05377047f, 0.03131384f, 
    0.09652791f, 0.06266433f, 0.21976016f, -0.00846788f, 0.09409342f, 0.03079004f, -0.08489924f, -0.02234615f, 
    0.11941130f, 0.07582839f, 0.05586648f, -0.00493976f, -0.08379450f, -0.02398097f, 0.05075052f, 0.00243559f, 
    -0.15619533f, -0.15268661f, 0.11767540f, -0.10727900f, -0.17813984f, 0.20293044f, 0.06933566f, 0.14447667f, 
    0.19580664f, 0.06166722f, 0.05928484f, -0.03201926f, -0.02970521f, -0.04503037f, -0.03020906f, -0.00569639f, 
    0.03608335f, -0.05670475f, -0.11332060f, -0.00594873f, 0.01778176f, 0.24417292f, 0.17863229f, -0.00277094f, 
    0.14969823f, 0.02780249f, -0.06437406f, 0.09555968f, -0.48521078f, -0.33704820f, 0.01458633f, 0.07387688f, 
    0.35084027f, 0.07138015f, 0.05845458f, 0.09374062f, -0.00764210f, 0.12786138f, -0.11650614f, 0.02768629f, 
    0.17549233f, 0.05661056f, 0.03358695f, -0.02505490f, -0.16699389f, -0.04196820f, -0.00424387f, -0.02991544f, 
    0.00418179f, 0.27379504f, 0.02922540f, 0.05795412f, -0.35023856f, 0.00007040f, 0.00201290f, -0.10951288f, 
    0.03599630f, 0.09498277f, 0.13926052f, 0.02149304f, 0.03596707f, 0.03003859f, 0.03405177f, 0.09029411f, 
    -0.03406634f, -0.10416443f, -0.06516042f, 0.04114650f, -0.16093907f, -0.23701569f, 0.25179449f, 0.20098472f, 
    -0.15298706f, 0.03521173f, -0.10490186f, 0.09635360f, -0.01856122f, -0.01065752f, -0.00004283f, 0.01012687f, 
    -0.06982686f, -0.07051156f, 0.00686070f, 0.10302902f, 0.00270983f, -0.25446120f, -0.05539798f, -0.16365571f, 
    -0.08480666f, -0.08671601f, 0.08043496f, 0.02647911f, -0.06806226f, -0.01658952f, 0.15426570f, -0.10260247f, 
    -0.03631262f, -0.10098644f, -0.01047817f, 0.11755145f, -0.15468055f, -0.14069761f, -0.05384447f, -0.05620390f, 
    -0.01578282f, 0.09052492f, 0.02566540f, 0.01433871f, 0.05638617f, 0.30489987f, -0.07909151f, 0.07196131f, 
    0.00617464f, 0.08249327f, -0.03691812f, 0.00944783f, -0.03782278f, -0.18739320f, 0.11969045f, 0.02665807f, 
    -0.19198439f, -0.03616713f, 0.07554650f, 0.05783216f, -0.17257135f, 0.12590119f, 0.09844270f, 0.13416202f, 
    0.15902026f, -0.14186032f, -0.10275388f, 0.11808988f, -0.19349711f, 0.04814604f, 0.06705359f, -0.01655222f, 
    0.11650480f, -0.01794882f, -0.07461718f, 0.14392355f, 0.06317615f, -0.08860409f, 0.05429751f, -0.05639626f, 
    -0.16156709f, -0.15385656f, -0.10568153f, -0.18441349f, -0.28487808f, -0.03764822f, 0.27965584f, -0.00647592f, 
    0.10038140f, -0.02566027f, 0.02204565f, 0.04179712f, 0.05431678f, -0.07885729f, -0.04900282f, 0.07311288f, 
    0.08648320f, 0.06039764f, 0.02426247f, -0.11360995f, -0.02994899f, 0.07096779f, -0.01210497f, 0.06793343f, 
    -0.02178012f, 0.02893002f, -0.00054556f, -0.01119437f, -0.02470650f, -0.02809646f, -0.02396186f, -0.00688782f, 
    -0.04284768f, -0.01954073f, -0.04833459f, 0.02369775f, -0.05495831f, 0.00482457f, 0.03346477f, -0.03724729f, 
    -0.01463830f, 0.01831201f, -0.05237989f, 0.04517119f, -0.00148277f, 0.01405109f, 0.03448990f, -0.00199060f, 
    0.03826189f, 0.02405290f, 0.01415802f, -0.04026187f, -0.01978216f, 0.00294991f, 0.04212658f, -0.02201881f, 
    0.03199431f, 0.04033886f, -0.02589099f, 0.03760840f, 0.02112623f, -0.02135853f, 0.02947856f, -0.05691017f, 
    0.00003725f, 0.00071120f, 0.02823606f, -0.03894033f, 0.04634446f, -0.03531523f, -0.05805713f, -0.02076801f, 
    -0.02727559f, 0.04262238f, -0.04965901f, 0.03991123f, -0.05846768f, -0.03099021f, 0.00621394f, 0.03535178f, 
    -0.02980328f, -0.01279071f, -0.04323658f, -0.00380339f, -0.04074939f, 0.04592130f, -0.03871970f, -0.02490655f, 
    -0.04212178f, 0.01035683f, -0.03565152f, 0.02593277f, -0.00933354f, 0.00225908f, -0.02120780f, -0.00452190f, 
    0.03524428f, -0.04472855f, -0.06049854f, 0.04828780f, -0.03198906f, 0.02356327f, 0.02945348f, -0.05554823f, 
    0.03212591f, -0.02111829f, -0.05444371f, -0.04131347f, 0.01372725f, -0.01479804f, 0.02084024f, 0.01031710f, 
    0.00743023f, -0.01750337f, -0.05854403f, 0.00506513f, -0.05841553f, -0.02350646f, 0.01510773f, 0.03064965f, 
    -0.01774129f, 0.05056936f, -0.00221975f, -0.02079234f, -0.02242150f, 0.04667624f, -0.03542358f, 0.03589005f, 
    -0.03959186f, -0.04853243f, -0.01090916f, 0.04672535f, -0.03403050f, -0.01246280f, -0.03976349f, -0.00390444f, 
    0.03072826f, 0.01650801f, -0.04369371f, -0.01911635f, 0.04280974f, -0.02544807f, 0.02490168f, 0.00844477f, 
    0.03270287f, 0.04374933f, 0.04355799f, -0.04515199f, 0.01234942f, 0.03706804f, -0.02578758f, 0.00469634f, 
    -0.01113027f, 0.04611496f, 0.01701613f, 0.01427619f, 0.01658977f, 0.03716611f, -0.02725388f, 0.00095809f, 
    -0.01907828f, -0.03719281f, 0.02506038f, 0.06107362f, 0.00021293f, -0.03036006f, 0.03640740f, -0.04854559f, 
    0.01670878f, 0.00326805f, 0.02115544f, -0.04487860f, -0.00125020f, 0.02670189f, 0.04932362f, -0.04191358f, 
    -0.00719002f, 0.03438626f, -0.00194969f, -0.03542121f, -0.05473773f, -0.02463396f, 0.02325171f, -0.04082006f, 
    -0.03790375f, -0.04124292f, -0.02542088f, -0.05788450f, -0.01941717f, -0.00393706f, 0.00755110f, -0.00005106f, 
    0.03463503f, -0.00607770f, 0.03488583f, 0.03258308f, -0.05988926f, 0.03179558f, -0.01154790f, 0.00045931f, 
    0.01393390f, 0.04597996f, -0.04429388f, 0.02753789f, 0.02145273f, -0.03222924f, 0.00352006f, 0.01974910f, 
    0.03384595f, -0.02026027f, -0.02043602f, 0.04549780f, -0.00143780f, -0.01285075f, 0.04616841f, 0.00674033f, 
    -0.05566016f, -0.05153202f, -0.06109902f, 0.04152275f, -0.05111098f, 0.04256816f, -0.02059605f, -0.04436251f, 
    0.03737647f, 0.03857300f, 0.06161011f, -0.03182567f, -0.03200313f, -0.01182380f, 0.03914322f, 0.00135660f, 
    0.04128729f, -0.06162479f, 0.01560051f, 0.01411794f, 0.03247290f, -0.01284884f, 0.00197015f, 0.00733423f, 
    0.02492098f, 0.01509063f, 0.04455183f, 0.01167185f, -0.02214847f, 0.01683475f, -0.01560578f, 0.02980210f, 
    0.00723373f, -0.04615407f, 0.02427296f, -0.04981004f, -0.03294743f, -0.05243825f, -0.01792413f, -0.04273550f, 
    -0.05164866f, -0.02634032f, -0.03263144f, -0.01187309f, 0.00932651f, -0.04064514f, 0.00333721f, 0.00544864f, 
    -0.04681703f, -0.02321136f, 0.00430581f, -0.02501140f, -0.02104544f, -0.05852032f, -0.04423040f, -0.01774646f, 
    -0.02083354f, 0.03222456f, -0.03242090f, -0.04473523f, -0.05312961f, 0.00614813f, 0.00576390f, -0.01790288f, 
    0.01866048f, 0.04111280f, 0.04459812f, 0.05658583f, 0.03561736f, 0.00424732f, -0.02157061f, -0.03599109f, 
    0.04333879f, -0.06083178f, -0.05837589f, -0.05001830f, 0.00467009f, -0.00733507f, 0.00189154f, 0.01548770f, 
    0.01178857f, -0.00208373f, -0.05713284f, -0.01435182f, 0.04496631f, 0.04627664f, -0.01516255f, -0.04114185f, 
    -0.00777866f, 0.03594125f, -0.02422942f, -0.03862938f, -0.05811849f, 0.00188683f, 0.00387242f, -0.04760684f, 
    -0.00933533f, 0.02091252f, -0.02177440f, 0.02052583f, 0.04797860f, 0.01095351f, 0.00853936f, 0.01693016f, 
    0.02924558f, -0.01192746f, -0.01899387f, -0.04581127f, -0.06113610f, -0.00923636f, 0.03888234f, 0.01975397f, 
    -0.01277059f, -0.01909149f, 0.00467292f, -0.05908434f, 0.02385280f, 0.02375867f, -0.00639495f, -0.03653868f, 
    -0.05280415f, 0.04557929f, -0.00907641f, 0.00260597f, -0.01652013f, -0.01957063f, -0.01281781f, -0.04022590f, 
    0.03962384f, -0.06013394f, -0.01246345f, -0.04524365f, -0.00847069f, -0.02926573f, -0.04756992f, 0.03175925f, 
    -0.02324870f, 0.04778997f, 0.01919004f, -0.04571725f, 0.00732404f, -0.04351573f, 0.05012739f, -0.00323766f, 
    0.04179576f, 0.03492982f, -0.00406845f, 0.01681889f, -0.00796008f, -0.04902878f, -0.02529857f, 0.04548680f, 
    0.03427834f, 0.00705057f, -0.01985320f, -0.01573941f, -0.02599742f, 0.00323005f, -0.00750313f, 0.03704272f, 
    -0.00087590f, 0.00399589f, 0.04029698f, -0.03765954f, -0.04818660f, 0.02830496f, -0.06185140f, 0.03841104f, 
    -0.04995153f, 0.01514473f, -0.03819702f, 0.00054614f, 0.01005176f, 0.01140401f, 0.00855369f, 0.04106308f, 
    -0.04753191f, 0.02529980f, 0.03534931f, 0.02606575f, -0.04494035f, -0.01164745f, -0.05621625f, 0.04222960f, 
    -0.05574869f, 0.00816365f, -0.02463327f, 0.03136063f, 0.01367872f, -0.01428087f, -0.02048540f, 0.00600726f, 
    -0.02722381f, -0.02086174f, -0.06307784f, -0.00380714f, -0.03141321f, 0.01286009f, -0.02804244f, 0.01718571f, 
    -0.04561903f, -0.03607985f, 0.00480571f, -0.02324700f, -0.04294178f, 0.02346637f, 0.02798925f, 0.03810086f, 
    -0.05282227f, -0.04713899f, 0.05811341f, -0.03553927f, -0.05415962f, -0.05275442f, 0.04185590f, -0.02455716f, 
    0.00568590f, 0.04485737f, -0.06089269f, -0.02570622f, -0.00602256f, -0.01673311f, 0.00383351f, 0.03648675f, 
    -0.02576948f, -0.02329488f, -0.00868165f, 0.01147334f, 0.02695853f, 0.01077698f, -0.04658487f, 0.01989107f, 
    -0.02480642f, 0.03101706f, -0.03961264f, -0.04795405f, -0.00758749f, 0.03602819f, -0.00273837f, -0.04600142f, 
    -0.04628891f, 0.01640518f, -0.05884248f, -0.00503398f, 0.04133393f, 0.03310366f, -0.02057464f, 0.00857053f, 
    -0.01734144f, -0.00841565f, -0.05124785f, 0.02566521f, 0.03137735f, 0.01723218f, -0.02748132f, 0.05217316f, 
    0.04269200f, -0.02711625f, -0.02231707f, 0.02671068f, 0.02773929f, -0.02905394f, 0.00204060f, -0.04428480f, 
    -0.03614219f, -0.01804780f, 0.04739016f, -0.02446410f, -0.06239272f, 0.03380946f, 0.00221486f, 0.01804002f, 
    -0.05308660f, 0.04277457f, -0.04792386f, 0.04673805f, 0.04829704f, 0.03958684f, 0.02921331f, 0.03181401f, 
    -0.01411489f, -0.06707129f, -0.04626963f, 0.01419576f, 0.02213895f, -0.01453162f, -0.00424629f, 0.03489362f, 
    0.03809981f, -0.03177343f, -0.01210732f, -0.02445864f, -0.04973530f, -0.00944396f, -0.01172976f, -0.01319987f, 
    0.03214319f, -0.03610647f, 0.03662495f, -0.04822842f, -0.00019485f, -0.02491544f, 0.04869582f, 0.03644978f, 
    -0.03789246f, 0.02822567f, -0.06007240f, -0.01466349f, -0.01425976f, -0.01137995f, 0.01741567f, 0.03536654f, 
    0.04412439f, 0.01311305f, 0.01822810f, -0.01501169f, -0.00439773f, 0.00923719f, 0.02460023f, 0.02922725f, 
    -0.03905706f, -0.02417132f, -0.05815291f, -0.03414154f, -0.04255103f, 0.01135320f, 0.00047240f, -0.03609577f, 
    -0.02647374f, 0.01486758f, -0.03604589f, -0.04902709f, 0.02469580f, -0.06090916f, 0.00955053f, -0.00721768f, 
    -0.03671594f, 0.00196236f, 0.02676437f, -0.02244011f, -0.05246713f, -0.05467692f, -0.01792219f, 0.00546525f, 
    -0.03555455f, 0.05137234f, -0.00171992f, 0.02947408f, -0.03028697f, -0.03150731f, 0.00268374f, 0.00857860f, 
    0.01567418f, 0.04534220f, -0.04705777f, 0.02000804f, -0.02313165f, 0.02074607f, 0.04700219f, -0.00375984f, 
    0.03122640f, 0.03375542f, -0.02151119f, 0.03961573f, -0.00802332f, -0.00359018f, 0.00199041f, -0.05525461f, 
    -0.01865634f, -0.04745098f, 0.01247267f, 0.00871848f, 0.02092691f, 0.04428634f, 0.01281181f, -0.00413356f, 
    -0.05011909f, 0.03256581f, -0.00971409f, 0.04699172f, 0.01347655f, -0.02785879f, -0.05640206f, -0.02208786f, 
    0.03516503f, -0.03488378f, -0.01244833f, -0.01321390f, 0.02776386f, -0.01616742f, 0.05175893f, 0.01113816f, 
    -0.03529276f, 0.01568686f, -0.04774159f, 0.00024630f, -0.03624999f, -0.04222455f, -0.05315519f, -0.00991089f, 
    -0.01246816f, -0.01720648f, -0.05343443f, -0.00554174f, -0.01605277f, -0.02909016f, -0.01248541f, -0.05649284f, 
    0.04204593f, 0.00226643f, -0.04325970f, -0.00154987f, -0.03238023f, 0.00486314f, 0.04184575f, -0.00855549f, 
    -0.04637389f, -0.00337307f, -0.02146775f, -0.05593215f, -0.04422577f, -0.01912043f, 0.02729155f, 0.03803251f, 
    -0.05174800f, -0.03905652f, -0.02758110f, -0.00858129f, -0.05723711f, -0.05364420f, 0.00243810f, -0.06366837f, 
    0.01719775f, -0.02122463f, -0.00161263f, -0.00318440f, -0.05742983f, -0.05428332f, -0.00933690f, 0.00425262f, 
    -0.00269193f, -0.01212712f, 0.00952598f, -0.01112270f, -0.00340408f, -0.04457752f, -0.01671663f, 0.00283255f, 
    0.38370201f, -0.10496759f, 0.14059202f, 0.13663757f, 0.21483280f, -0.05956803f, -0.14309195f, -0.01815215f, 
    0.14241977f, -0.02223884f, -0.11686190f, -0.03483531f, -0.00571420f, 0.03621752f, -0.09305749f, 0.04265244f, 
    -0.17041199f, -0.01639121f, 0.03939767f, 0.02093986f, 0.41097015f, -0.17350498f, -0.15499073f, -0.02608914f, 
    0.43359321f, 0.00083030f, 0.05246869f, -0.08842181f, 0.11345617f, 0.01253390f, 0.09211107f, -0.10806596f, 
    0.04118664f, 0.04198884f, 0.08964475f, 0.05671731f, 0.19030711f, -0.06080225f, -0.07703310f, 0.04845994f, 
    -0.07452704f, -0.00920653f, 0.06106788f, -0.08174754f, -0.35533723f, 0.06043690f, -0.04231050f, 0.05433846f, 
    -0.01354954f, -0.04207475f, 0.07159312f, 0.01340659f, -0.02963313f, 0.06162732f, -0.01786982f, 0.10712431f, 
    -0.13652673f, 0.07914425f, 0.12785113f, 0.01454836f, 0.44989714f, 0.02288073f, 0.01341661f, 0.06393685f, 
    0.27394974f, 0.05691788f, 0.16990206f, 0.10954968f, 0.07308510f, -0.01107558f, 0.01051168f, -0.00391293f, 
    0.03444565f, -0.14866768f, -0.00462930f, 0.03462140f, 0.07997703f, 0.00985298f, -0.06771830f, -0.01051200f, 
    0.28299290f, -0.27403206f, 0.25407425f, -0.04294075f, -0.07540320f, 0.02916446f, -0.10993119f, -0.00524029f, 
    -0.15458758f, -0.10658793f, -0.03110702f, -0.03495368f, -0.01639854f, -0.06456268f, 0.05686035f, 0.01887598f, 
    -0.06368618f, 0.03149366f, -0.09634369f, -0.09642664f, 0.18922064f, -0.03771057f, -0.06495229f, -0.22040945f, 
    -0.19279648f, 0.11600007f, 0.19308528f, -0.07545775f, 0.02261387f, -0.13101242f, 0.06948105f, 0.07030741f, 
    -0.10142563f, -0.05303128f, 0.01690650f, -0.00284959f, 0.10258610f, 0.06723959f, 0.13176541f, 0.06211007f, 
    0.14040019f, 0.01735654f, 0.00425120f, 0.18908915f, -0.20059924f, -0.24640103f, -0.07786754f, 0.04350136f, 
    -0.14971356f, 0.16712023f, 0.07756262f, 0.04985495f, 0.00962889f, 0.09159918f, 0.15016469f, 0.08584736f, 
    -0.09049048f, 0.06824497f, 0.18677373f, 0.01713408f, -0.23197621f, -0.18009450f, 0.10913751f, 0.03149826f, 
    -0.25061998f, -0.17481937f, -0.00967042f, -0.12180655f, 0.07657413f, -0.05575075f, 0.03094738f, 0.02138484f, 
    -0.02176887f, 0.02420771f, -0.01581029f, -0.06264757f, -0.00171762f, 0.00335540f, 0.10814892f, -0.15280186f, 
    0.26683360f, -0.13434212f, 0.14886892f, -0.03043004f, 0.10445578f, -0.10889707f, -0.06975012f, -0.03042294f, 
    0.04915854f, 0.11082332f, 0.05857974f, -0.00986095f, 0.04032452f, 0.09423448f, 0.08391661f, 0.10094073f, 
    -0.03092018f, 0.02147859f, 0.09419362f, -0.08985632f, 0.11393281f, 0.11422782f, -0.00009265f, 0.25694335f, 
    -0.18215042f, -0.05731108f, -0.06857675f, -0.06219265f, -0.07775156f, 0.08243387f, 0.09356075f, -0.14848711f, 
    -0.02173392f, -0.02125305f, 0.07401968f, 0.09753699f, -0.08364495f, 0.00749492f, -0.01800997f, 0.03682064f, 
    0.52954680f, 0.12121029f, -0.01249428f, 0.03144849f, 0.52364784f, -0.01034912f, -0.02588680f, -0.00331429f, 
    0.13168508f, 0.01781935f, -0.09360165f, 0.00445562f, 0.02909880f, -0.16652635f, 0.02441913f, 0.03345713f, 
    0.04203047f, 0.02876104f, -0.00362590f, -0.00629946f, 0.31054053f, 0.34074184f, -0.03539710f, -0.11530251f, 
    0.42991734f, 0.15685971f, -0.01625714f, -0.08176666f, 0.06718002f, -0.03397318f, -0.03486930f, 0.02765215f, 
    0.07834318f, -0.19789113f, 0.04620660f, -0.01574653f, -0.12983058f, -0.00683736f, 0.05747040f, -0.04875323f, 
    -0.30778432f, 0.08008252f, -0.22525416f, -0.23255138f, -0.05644009f, 0.06063455f, 0.11312859f, 0.13699803f, 
    -0.01278244f, 0.08317519f, 0.09144229f, 0.00501232f, -0.07293119f, -0.11797349f, -0.05871971f, 0.08650032f, 
    -0.00386448f, 0.13252033f, 0.03866389f, -0.01211976f, -0.06118935f, -0.12864012f, 0.23093583f, -0.03770115f, 
    -0.14309116f, -0.18210708f, -0.04840667f, 0.04271327f, -0.02341035f, -0.05358911f, 0.02394406f, -0.06758029f, 
    0.04181703f, 0.03018213f, 0.09672571f, 0.13481478f, -0.03621208f, 0.02980447f, -0.10398454f, 0.07620267f, 
    0.31505403f, 0.10958842f, 0.11564970f, -0.06569247f, -0.11544421f, -0.10960962f, -0.02828678f, 0.04467432f, 
    0.18860033f, -0.08750395f, -0.01678342f, 0.03132784f, 0.12501933f, 0.02388171f, 0.05511146f, -0.12578294f, 
    -0.13496025f, -0.14420621f, -0.09467750f, -0.05320895f, 0.14224672f, -0.21907279f, 0.02869250f, 0.09382222f, 
    -0.07627242f, -0.05382274f, -0.10236392f, 0.04235031f, -0.05134698f, 0.03566778f, 0.01339331f, -0.07018171f, 
    -0.04461707f, 0.03262438f, 0.06301624f, 0.03974468f, -0.00839096f, 0.01928094f, 0.09306046f, 0.03948932f, 
    0.24254096f, 0.20150620f, 0.32095432f, -0.32929248f, 0.17504063f, -0.02005476f, -0.21929194f, 0.01132786f, 
    -0.18539715f, -0.04789437f, 0.10616866f, 0.06130639f, -0.00756157f, 0.03686503f, 0.00836080f, -0.00012260f, 
    0.03371876f, 0.13420388f, 0.19931099f, -0.02664905f, -0.00254677f, -0.21560332f, 0.28642514f, -0.06613904f, 
    0.06837846f, -0.01702667f, -0.15753692f, 0.01091658f, -0.19526328f, 0.01156520f, -0.17517857f, -0.12788172f, 
    -0.00272070f, 0.10548238f, 0.05366370f, -0.00504899f, 0.09220622f, 0.07479971f, 0.01861298f, -0.07132695f, 
    -0.01815362f, -0.27700615f, 0.03352880f, 0.09338381f, 0.06459320f, -0.01436416f, -0.02614323f, 0.13564594f, 
    -0.04251996f, 0.08078606f, 0.02892594f, 0.00763520f, 0.10349122f, -0.03813696f, 0.05198922f, -0.00031454f, 
    -0.11332560f, -0.14751153f, 0.07188958f, -0.03448093f, -0.15816680f, -0.13549030f, 0.23329188f, -0.16213447f, 
    0.12681732f, -0.22842842f, 0.00515517f, -0.00647235f, -0.08439934f, 0.02404507f, -0.04272325f, -0.16153668f, 
    0.03113591f, 0.21636038f, -0.07474139f, 0.00092964f, 0.03086455f, 0.00360959f, -0.07448921f, -0.00424561f, 
    -0.40965480f, 0.14366329f, -0.05291611f, 0.01134242f, -0.13455829f, 0.11763651f, -0.00754363f, 0.11078397f, 
    0.12800030f, 0.15896083f, -0.01336112f, -0.02540404f, -0.01108457f, 0.04971121f, -0.09423147f, 0.05054801f, 
    0.04530746f, -0.13239999f, 0.01514694f, 0.12740938f, -0.11326730f, -0.16154818f, 0.12349218f, 0.21635580f, 
    -0.28339157f, -0.01547510f, 0.04436357f, -0.00639972f, 0.10622477f, -0.06253269f, 0.01013806f, -0.05808204f, 
    -0.03594445f, 0.07107246f, -0.01814103f, -0.06346028f, -0.07724065f, -0.05473289f, -0.07355134f, -0.11177478f, 
    -0.36025718f, 0.00272748f, -0.22396153f, 0.25110489f, -0.09373151f, 0.16949114f, 0.08060486f, -0.08976950f, 
    0.21877781f, 0.13569380f, 0.00520755f, 0.19895113f, -0.18541232f, 0.06734528f, -0.00456657f, -0.11189750f, 
    -0.12488395f, -0.07038496f, -0.03261824f, -0.19892532f, 0.05684822f, -0.38006565f, 0.06223783f, 0.29841328f, 
    0.04496299f, 0.16183105f, -0.00286364f, -0.00620862f, 0.02745094f, 0.10116939f, 0.07720982f, 0.03115254f, 
    0.16693187f, 0.19712341f, 0.01574985f, 0.12638825f, 0.09384652f, 0.02046994f, -0.10246781f, -0.00572883f, 
    -0.21789245f, 0.49057695f, 0.16777800f, -0.07423431f, -0.23719543f, -0.00614996f, 0.02009916f, 0.03543251f, 
    -0.04015704f, -0.05883854f, 0.12743215f, 0.03893383f, 0.01216483f, -0.03402033f, -0.13459307f, -0.03786932f, 
    -0.00621939f, -0.09015614f, 0.04178840f, -0.11230398f, -0.04372595f, 0.59410924f, -0.17306975f, 0.13301393f, 
    0.03777441f, 0.16249797f, 0.10318766f, 0.04419158f, 0.13271450f, -0.04372305f, 0.09845937f, 0.07097920f, 
    -0.09425823f, -0.00353308f, 0.01679280f, -0.00047484f, 0.03766388f, 0.19802712f, 0.16143292f, 0.04746881f, 
    -0.30516219f, -0.24253640f, 0.19754776f, -0.24962543f, 0.35269693f, 0.03828416f, 0.17048050f, 0.03108204f, 
    -0.10215366f, 0.04529163f, -0.00534287f, -0.03026903f, -0.01692009f, 0.00174674f, 0.02374987f, -0.00208117f, 
    0.08204283f, 0.07703698f, 0.07153179f, -0.01870005f, -0.15741557f, -0.28181225f, -0.11399229f, -0.19879572f, 
    0.02444608f, -0.15144458f, 0.04321542f, 0.02874045f, -0.05870748f, -0.00831672f, 0.07192035f, -0.02464126f, 
    0.02141925f, 0.05377600f, 0.10266577f, -0.07007781f, 0.07034754f, 0.09112639f, 0.04450755f, 0.16145594f, 
    0.10664099f, -0.07629491f, 0.30783260f, 0.13089487f, -0.03092135f, -0.14214954f, -0.08006079f, 0.03448445f, 
    -0.05381397f, 0.01721157f, 0.03944903f, -0.11327504f, 0.11685370f, 0.07704797f, 0.16775046f, -0.05251232f, 
    0.03360707f, -0.03204842f, -0.10386460f, 0.03260178f, -0.11008636f, -0.12335005f, -0.04177213f, 0.34160334f, 
    -0.10113820f, 0.09598144f, -0.01404567f, 0.07281834f, 0.11168388f, 0.24939175f, 0.00350201f, 0.08412950f, 
    0.17258427f, -0.00576730f, 0.08586048f, -0.05258229f, -0.00822184f, -0.09519248f, -0.06158549f, -0.03774318f, 
    -0.10834324f, 0.02704352f, 0.03313730f, -0.25894338f, -0.08476592f, -0.15217067f, -0.09748929f, 0.07169934f, 
    -0.10005794f, 0.03829249f, -0.09168629f, -0.02061266f, 0.02985132f, 0.05432316f, 0.06343786f, 0.16233395f, 
    0.09022583f, 0.07710477f, 0.01404587f, 0.19560055f, -0.34995392f, 0.13368522f, -0.00343566f, -0.04462733f, 
    -0.07447734f, 0.11561864f, -0.00381916f, 0.01024314f, 0.01319542f, 0.06722390f, -0.04501086f, -0.08669696f, 
    0.07555272f, -0.03407254f, -0.05643622f, 0.08632609f, 0.07543466f, -0.06512506f, 0.12693994f, -0.05256435f, 
    -0.04279440f, 0.00307534f, -0.00014146f, -0.05291624f, 0.01281158f, 0.03704004f, -0.03730936f, -0.03604481f, 
    0.03200923f, -0.05203724f, 0.00569671f, -0.02720012f, -0.03135204f, -0.04411913f, 0.04053246f, 0.03161586f, 
    -0.01380869f, 0.01864901f, -0.05864465f, 0.00894324f, 0.00407997f, 0.00783067f, -0.03534765f, -0.03915577f, 
    -0.01195675f, -0.03975731f, 0.01046956f, -0.05927105f, 0.02287989f, -0.03440456f, 0.01468258f, 0.03179404f, 
    0.00687176f, -0.05164623f, -0.04088512f, 0.00597381f, 0.04678029f, -0.02158466f, 0.03108043f, 0.04143316f, 
    -0.03824005f, -0.03241247f, -0.01163987f, -0.03409977f, -0.01865195f, -0.01827598f, -0.01708451f, -0.03951110f, 
    -0.00571215f, 0.00110637f, -0.03111879f, -0.01089368f, 0.02966740f, -0.05590018f, 0.02547196f, -0.05434293f, 
    -0.04106716f, -0.02517304f, 0.04628685f, -0.02705982f, 0.01100467f, 0.04222447f, -0.04278728f, -0.00865370f, 
    0.04130005f, -0.02644196f, -0.01477131f, 0.02667176f, 0.03981281f, 0.05028252f, 0.00506774f, -0.03681798f, 
    -0.03060951f, -0.00841421f, 0.01835982f, -0.05416880f, -0.02263352f, -0.01788415f, -0.05494892f, 0.01532086f, 
    0.01943125f, -0.04786768f, -0.00743992f, 0.02754717f, 0.02865315f, -0.04468149f, 0.04618102f, -0.00620759f, 
    0.00629781f, 0.04343811f, -0.02543143f, -0.04468431f, 0.02024772f, 0.02035292f, -0.02993745f, 0.03685634f, 
    -0.00391732f, -0.00012911f, -0.00840557f, 0.03544446f, 0.03075139f, -0.03334595f, -0.04695817f, -0.02985018f, 
    0.03177499f, -0.04056850f, -0.02344371f, -0.04454879f, -0.06051717f, 0.04113719f, 0.00800051f, 0.04216628f, 
    -0.04829744f, -0.01317318f, -0.02189901f, 0.03267539f, 0.04223238f, 0.03365302f, -0.05387603f, 0.01039288f, 
    -0.00549465f, 0.02840579f, 0.04390999f, -0.01427474f, -0.03021076f, -0.05182451f, -0.03502047f, -0.04258521f, 
    0.01322620f, 0.00124084f, 0.03947164f, -0.04495768f, 0.00800635f, -0.03859657f, 0.02722323f, -0.05458816f, 
    -0.01722527f, 0.03721434f, 0.02719939f, -0.02921353f, -0.00767272f, -0.05853237f, -0.05659753f, -0.02424439f, 
    -0.01649284f, 0.00603637f, -0.02288632f, 0.04365203f, 0.04824881f, -0.01759604f, -0.05350624f, 0.01500997f, 
    -0.03761020f, -0.02887544f, -0.01692613f, 0.00268428f, 0.00741226f, -0.03732260f, 0.00141638f, -0.01451345f, 
    -0.00480230f, -0.00646862f, 0.04315980f, -0.01306390f, -0.04213823f, 0.03662018f, -0.01129425f, 0.00439320f, 
    -0.02062372f, -0.00479929f, 0.02336256f, -0.04565648f, -0.03421904f, 0.03831037f, 0.01938015f, 0.03633584f, 
    0.01497485f, -0.05325032f, -0.00583610f, 0.01047455f, 0.00232389f, -0.01531928f, 0.00892903f, 0.01585394f, 
    0.02536540f, 0.00528940f, -0.03909903f, 0.00430117f, -0.06018721f, 0.01937489f, -0.00282205f, 0.02825968f, 
    0.04339450f, 0.00184674f, 0.04770429f, -0.05656424f, -0.03434131f, -0.05227017f, -0.01429793f, -0.00163441f, 
    -0.02960661f, -0.04815032f, -0.03506163f, -0.00237539f, 0.02974601f, -0.03280605f, -0.02348264f, -0.04512152f, 
    -0.01867150f, -0.06014583f, -0.00001179f, -0.03663806f, 0.02682970f, 0.00780181f, -0.05942366f, -0.04125903f, 
    0.01405207f, -0.03695272f, -0.02177127f, 0.01936257f, -0.03705283f, 0.03805462f, 0.03675941f, 0.02273464f, 
    -0.05955565f, -0.04135058f, -0.03494272f, -0.02958494f, -0.04882189f, -0.02276447f, 0.03421339f, 0.00183223f, 
    0.01163053f, -0.02143908f, 0.03288505f, 0.04634834f, -0.00431285f, 0.03341163f, -0.05773525f, -0.03705511f, 
    0.02685027f, 0.03174513f, -0.01302361f, -0.05494777f, -0.01398881f, 0.04721439f, 0.00823625f, -0.05408166f, 
    -0.02902253f, 0.04322703f, -0.04979600f, -0.05852159f, 0.04062982f, 0.03514153f, 0.00957085f, 0.02200139f, 
    -0.02181961f, 0.04273077f, -0.01774793f, -0.05049558f, -0.02289101f, -0.04114697f, -0.03717162f, 0.04622745f, 
    -0.03076987f, -0.04657823f, 0.04236733f, 0.03996764f, -0.05704100f, -0.05167064f, 0.04488745f, 0.00084954f, 
    0.04613318f, -0.04187498f, -0.05240698f, -0.05416077f, -0.01412680f, 0.02008508f, -0.03979054f, 0.03263319f, 
    0.03803009f, 0.03269565f, 0.04273739f, -0.04271714f, -0.00549545f, 0.04081576f, -0.02143727f, 0.02036373f, 
    -0.03184868f, -0.04181635f, 0.04237115f, 0.02484155f, 0.02813044f, -0.00044102f, -0.05615658f, -0.03879059f, 
    0.02865678f, -0.05021432f, 0.04995231f, 0.04244943f, 0.04127152f, -0.04628829f, -0.04672370f, -0.01493186f, 
    0.00615911f, 0.00601832f, 0.00305058f, 0.03557167f, 0.00915127f, -0.02194129f, -0.02453207f, -0.05281408f, 
    0.02515736f, 0.02832776f, -0.03215746f, 0.04234137f, -0.03858435f, -0.04768167f, 0.03002441f, -0.05802520f, 
    -0.13573253f, -0.09652807f, -0.05304454f, 0.16367447f, -0.03338983f, 0.19968852f, 0.10853975f, 0.08380294f, 
    0.10654147f, 0.05064627f, -0.10919315f, -0.07788711f, -0.07386566f, 0.01424542f, -0.02976408f, -0.04103971f, 
    0.04688370f, -0.01054847f, -0.17386726f, 0.01755377f, 0.21721531f, 0.18887658f, 0.02328932f, -0.13974240f, 
    -0.13975383f, -0.15718180f, 0.20131394f, 0.17490743f, -0.01861068f, 0.13531436f, 0.05797619f, -0.02323043f, 
    0.15791859f, -0.09363578f, -0.07370915f, 0.02183834f, -0.07004928f, -0.08378103f, -0.05625008f, 0.06958853f, 
    -0.02414741f, -0.01699953f, -0.04636624f, 0.05145682f, -0.11899354f, 0.02832446f, -0.03461428f, 0.09975634f, 
    0.16975075f, 0.07438842f, -0.09230726f, -0.02497388f, -0.03057009f, 0.03849221f, -0.01448784f, 0.00958052f, 
    0.09065361f, 0.04982691f, 0.19800580f, -0.01635799f, 0.06953759f, 0.31882390f, 0.28755841f, -0.06491423f, 
    -0.20624311f, -0.16010424f, -0.05191962f, 0.00121862f, -0.04024412f, 0.17475802f, 0.05797277f, -0.00287115f, 
    0.03256902f, -0.02604956f, 0.04370735f, 0.03374473f, -0.00731065f, -0.29137844f, -0.06430077f, 0.02347725f, 
    0.07538809f, -0.20162986f, -0.10783333f, -0.13356800f, -0.00260875f, 0.03734700f, -0.02481269f, 0.01314909f, 
    0.00151063f, -0.02060094f, -0.03442846f, 0.01886973f, 0.01829600f, -0.04095770f, 0.09110061f, -0.01818269f, 
    -0.02825522f, 0.07576800f, -0.04982937f, 0.04686703f, 0.11548664f, -0.13708782f, -0.01118903f, -0.25519398f, 
    -0.19185689f, 0.08489233f, 0.19141909f, 0.11237919f, -0.11508080f, 0.03197182f, 0.07866408f, 0.01982252f, 
    0.14376812f, -0.02055879f, 0.10636884f, 0.01090785f, 0.04746729f, 0.00196246f, 0.05755568f, 0.12568641f, 
    0.10044502f, -0.16626085f, -0.17485984f, 0.18371786f, 0.06254655f, -0.10850655f, -0.03552296f, -0.03932180f, 
    0.10075733f, 0.16479869f, 0.00213122f, -0.09675952f, 0.21996874f, 0.04990456f, 0.02240818f, 0.15344784f, 
    0.06399938f, 0.01919057f, 0.10220075f, -0.01606175f, 0.11864628f, 0.11061023f, -0.07398394f, 0.03942031f, 
    0.06597877f, 0.16011629f, -0.01655798f, 0.06729314f, 0.07598660f, -0.05039413f, 0.07444795f, -0.12144019f, 
    -0.04337514f, -0.00866678f, -0.03765930f, -0.01546222f, -0.01690930f, -0.06009809f, 0.15317927f, -0.01205303f, 
    0.03286311f, -0.25772282f, -0.34718916f, -0.11822827f, 0.28458637f, -0.04326102f, 0.06025343f, -0.01454066f, 
    0.00752889f, 0.02860015f, -0.11883307f, 0.09537870f, -0.00397292f, 0.11003158f, 0.12188845f, 0.03660555f, 
    0.06615511f, 0.04432534f, -0.19011037f, 0.11899523f, 0.00496532f, -0.19283755f, -0.25945696f, 0.00835404f, 
    -0.03569291f, 0.18296747f, 0.01273090f, -0.10584618f, -0.09548911f, 0.17550798f, 0.09888536f, -0.03215022f, 
    0.23725596f, 0.19728281f, 0.02020048f, 0.05707051f, -0.06716251f, -0.12723085f, -0.03702146f, -0.06449312f, 
    0.21893360f, 0.37491074f, 0.41148818f, -0.01093990f, -0.13723870f, -0.05705969f, 0.02068924f, 0.07822022f, 
    0.10474893f, 0.16006637f, 0.04293120f, -0.02623549f, 0.03088591f, -0.03954061f, 0.02644819f, 0.04714449f, 
    0.02237531f, -0.02788284f, -0.03336781f, 0.09066669f, 0.10042281f, 0.15989080f, 0.25044173f, 0.02984126f, 
    -0.08593357f, 0.05692678f, -0.15455446f, 0.12490348f, 0.08051190f, 0.03997369f, 0.07667800f, -0.05925864f, 
    -0.00381698f, 0.07521921f, -0.00797042f, 0.05437597f, 0.00876099f, 0.00838852f, -0.27350226f, -0.12365476f, 
    -0.30543822f, -0.45179331f, -0.06285809f, 0.05671064f, 0.07160364f, 0.08538982f, 0.02310265f, 0.06092933f, 
    0.00671556f, 0.02732025f, -0.11315580f, 0.08121387f, -0.06657008f, -0.09213383f, -0.09019434f, -0.02906238f, 
    0.02526671f, 0.00527532f, 0.09358082f, 0.05343653f, 0.06132686f, 0.07968675f, -0.01142224f, 0.04632619f, 
    0.14619173f, 0.01060715f, 0.01354917f, 0.11066124f, 0.10881843f, 0.01236101f, -0.04866121f, -0.00466096f, 
    -0.11149596f, 0.11999906f, -0.05478223f, 0.11038111f, 0.05576831f, 0.06193487f, 0.05638054f, 0.24176748f, 
    0.15420289f, -0.61059588f, 0.16695929f, 0.06975698f, 0.24460346f, -0.07019220f, -0.04200232f, 0.03645490f, 
    -0.13703956f, -0.15445666f, 0.00802250f, 0.11399282f, 0.06528615f, -0.08546118f, 0.01311940f, -0.11647131f, 
    0.09252752f, 0.01140724f, -0.03653065f, -0.05113157f, 0.19415705f, -0.15128404f, -0.19322741f, 0.13668691f, 
    -0.06127220f, 0.05533297f, -0.02612472f, -0.11573865f, 0.06626263f, 0.08318901f, -0.04761541f, 0.08826961f, 
    -0.08550908f, 0.08397853f, -0.08521056f, 0.03112899f, 0.01126508f, 0.11355877f, -0.11002816f, -0.02436737f, 
    -0.49284321f, 0.13384831f, 0.06976885f, -0.25576928f, -0.06377684f, 0.10503588f, 0.07329179f, 0.17202131f, 
    -0.01832462f, 0.17542464f, 0.23120803f, 0.02298766f, 0.08279596f, 0.04796593f, 0.08763950f, 0.08636702f, 
    0.00289130f, 0.11200618f, -0.08089096f, 0.12237041f, -0.37977386f, -0.03224124f, 0.22696187f, 0.04341769f, 
    -0.60304290f, 0.18291569f, 0.18817401f, -0.03550690f, -0.01677418f, -0.00142212f, -0.04595385f, 0.15692465f, 
    0.00691439f, 0.01836731f, 0.05735844f, 0.01149449f, -0.02793431f, -0.00527191f, -0.10094909f, 0.02405219f, 
    -0.28370360f, 0.06640991f, -0.03038494f, 0.05341385f, 0.24627034f, 0.19749601f, -0.02738537f, 0.03784047f, 
    -0.06595229f, 0.13143113f, 0.05495751f, -0.02903817f, 0.02991457f, 0.03738716f, 0.03715772f, 0.00352450f, 
    0.04188531f, 0.04393055f, -0.10401510f, 0.11706594f, -0.13790050f, 0.25376719f, 0.03557137f, -0.16248783f, 
    -0.40301010f, 0.10780764f, 0.07868274f, 0.09574775f, -0.06786548f, -0.02891600f, 0.03327170f, -0.07884550f, 
    -0.12987712f, 0.03587200f, 0.04533499f, -0.01092366f, -0.08231463f, -0.00482421f, -0.15964153f, -0.11254960f, 
    0.03898476f, -0.03263808f, -0.08511522f, 0.02988033f, 0.16075918f, 0.20320277f, 0.08320533f, -0.04874199f, 
    0.10560739f, 0.14606696f, 0.13182354f, 0.07669123f, 0.02537384f, 0.02646992f, 0.07639095f, 0.19283389f, 
    0.08782615f, -0.11463159f, -0.00599348f, 0.13039827f, -0.14362656f, 0.17002489f, -0.03711475f, -0.04128962f, 
    0.25643775f, 0.07442836f, -0.05571489f, 0.11241645f, 0.18498819f, 0.21416709f, -0.11179288f, -0.06107533f, 
    0.02687667f, 0.11040380f, 0.15782800f, 0.12684833f, 0.02786991f, -0.02322488f, -0.00572757f, 0.01718459f, 
    0.14087649f, -0.22392869f, -0.51131338f, -0.03404685f, 0.13006601f, 0.04141508f, 0.06408565f, -0.02333167f, 
    -0.02849190f, -0.15610750f, -0.02156822f, 0.12042745f, 0.10821421f, -0.07302651f, -0.02236953f, -0.01506421f, 
    0.03399697f, -0.12638991f, -0.10643826f, -0.00316275f, 0.12261935f, -0.14187826f, -0.21200255f, -0.00212664f, 
    0.05787887f, -0.01357524f, -0.05806982f, -0.03635660f, -0.12812412f, 0.02653143f, -0.03390805f, 0.09140792f, 
    0.13271040f, 0.06007824f, 0.07804990f, 0.08851548f, 0.03199361f, 0.05452715f, 0.02663597f, 0.03221698f, 
    0.28217033f, -0.38496450f, -0.00949562f, 0.20043296f, 0.19347166f, 0.02987404f, -0.04508422f, -0.00973255f, 
    -0.07050861f, 0.04307366f, 0.09237609f, -0.06349721f, 0.10433309f, 0.00139087f, -0.00114737f, 0.00580597f, 
    0.08760566f, 0.02826966f, 0.03066658f, -0.02068438f, 0.15666690f, 0.10731920f, -0.21109551f, -0.16974927f, 
    0.12198902f, -0.10588699f, -0.01001390f, -0.04647877f, 0.05216243f, -0.15208095f, -0.04426594f, 0.06184025f, 
    -0.09785591f, -0.04027752f, 0.02281553f, -0.11446323f, -0.02710431f, -0.05165607f, -0.16228423f, 0.06683062f, 
    -0.36102590f, -0.30501449f, -0.07410071f, -0.17932729f, -0.44439015f, 0.17404200f, 0.20198733f, -0.10236622f, 
    -0.08560707f, 0.03449884f, 0.09038493f, 0.15532967f, -0.04468418f, 0.00571082f, 0.03861720f, -0.03538293f, 
    -0.07901289f, 0.04030617f, -0.01227419f, 0.07381533f, 0.16469108f, -0.20111592f, 0.01599682f, 0.02812504f, 
    -0.53510606f, 0.04686030f, 0.14509828f, -0.02956813f, -0.02431218f, 0.13392663f, 0.07736232f, -0.03655770f, 
    0.02192965f, 0.08760612f, 0.11841073f, -0.00896161f, -0.06876809f, 0.08106849f, 0.02720958f, 0.09006569f, 
    0.26664069f, 0.29759404f, 0.32331231f, 0.10010824f, 0.07278791f, -0.05274151f, 0.08747848f, -0.09380069f, 
    0.05571606f, 0.10439867f, -0.04325912f, -0.10171496f, -0.02618302f, 0.06858768f, -0.12318300f, 0.09249128f, 
    0.15643202f, -0.01456663f, 0.07953417f, -0.00923836f, -0.16299404f, -0.14815295f, -0.32698286f, 0.05270530f, 
    0.16894747f, 0.22865854f, -0.01276674f, 0.05666369f, -0.03027659f, 0.13261680f, 0.11820321f, 0.08733229f, 
    0.08347558f, 0.04772784f, 0.03966579f, -0.05284804f, 0.04184713f, -0.02727555f, 0.20582344f, -0.19084425f, 
    -0.36115226f, -0.07875571f, 0.14682783f, -0.04624050f, 0.00600141f, -0.03315896f, -0.04969531f, 0.17717712f, 
    0.01181712f, 0.12110534f, -0.01204277f, -0.07220963f, -0.04567071f, 0.04861069f, -0.02111404f, 0.11315196f, 
    0.35614860f, 0.06453323f, 0.04670147f, 0.09908664f, 0.05690295f, -0.14405377f, -0.20539135f, 0.06246632f, 
    0.26580435f, 0.10136756f, 0.03103080f, 0.07552470f, -0.07773858f, 0.08611380f, 0.05594664f, -0.01817383f, 
    0.01239752f, -0.11898413f, -0.07027281f, 0.06554449f, -0.07084162f, -0.04076182f, 0.01072241f, 0.06893120f, 
    0.61580598f, -0.20211861f, 0.11961799f, 0.04429821f, 0.28481573f, -0.09609642f, -0.03407351f, -0.09387875f, 
    0.00302095f, -0.03203229f, 0.00988387f, 0.05622653f, -0.04258830f, -0.00726183f, 0.11397240f, -0.02584419f, 
    0.06148200f, -0.00966147f, 0.11712618f, -0.08333024f, 0.13291118f, 0.07765441f, 0.09453154f, 0.06871356f, 
    0.15620136f, -0.07131772f, -0.11284228f, 0.10246506f, -0.00988164f, 0.05018008f, 0.01407668f, -0.02118444f, 
    0.00746095f, -0.07409061f, 0.05884020f, -0.01336562f, -0.13690190f, 0.00442567f, 0.09015308f, -0.10781869f, 
    0.17073569f, -0.45864996f, 0.06676705f, -0.02364404f, -0.09849636f, -0.03952635f, 0.03555979f, 0.07755390f, 
    0.08060441f, 0.01034622f, -0.10803100f, -0.01818458f, 0.09242699f, 0.02772699f, -0.03585304f, -0.04716499f, 
    -0.06710630f, -0.11082057f, -0.00270614f, -0.02946104f, 0.01514312f, 0.05206582f, 0.20707324f, 0.33138871f, 
    0.25277027f, -0.15851897f, -0.17081158f, 0.09866489f, 0.05015118f, 0.10727213f, -0.02552624f, -0.14280720f, 
    0.08545867f, 0.21639097f, 0.05024748f, 0.14553432f, 0.08483607f, 0.03446391f, -0.00164472f, -0.05477148f, 
    0.02047200f, -0.02857120f, -0.16279036f, -0.08670335f, -0.08131359f, 0.02653599f, -0.04243311f, 0.15153797f, 
    0.10035937f, -0.05644249f, 0.10247149f, 0.09801614f, 0.01696312f, 0.00190161f, -0.03998011f, -0.10319851f, 
    0.10795400f, -0.13524583f, 0.04467388f, 0.02184138f, 0.01554862f, -0.33910590f, 0.37909341f, 0.10608014f, 
    -0.06471637f, -0.04106045f, 0.00327195f, 0.08770343f, -0.03828270f, 0.04497579f, 0.14981954f, 0.01932597f, 
    0.07241277f, 0.02350328f, 0.07384983f, -0.12770741f, -0.07256762f, -0.09418104f, 0.03191702f, -0.11452859f, 
    -0.21189883f, -0.12848474f, -0.25210753f, 0.04618898f, -0.11625818f, 0.05802419f, 0.04813495f, 0.04844108f, 
    0.12093657f, -0.00100587f, 0.08237363f, -0.01862104f, -0.10777188f, 0.01296885f, -0.00671834f, -0.05700467f, 
    -0.03264846f, -0.01829846f, -0.10320695f, -0.02216594f, -0.06340382f, -0.03253701f, -0.03500599f, -0.00747944f, 
    -0.05567805f, 0.09119667f, 0.14619891f, 0.08286472f, 0.18145686f, 0.10744389f, 0.02411302f, -0.05993313f, 
    0.10690676f, 0.21645245f, -0.10274152f, 0.03738524f, 0.10555032f, -0.11805600f, -0.06833751f, 0.00798525f, 
    -0.47593445f, 0.11466709f, -0.07868544f, -0.11482278f, -0.27415630f, -0.01087573f, 0.09917931f, 0.07392944f, 
    0.03699226f, -0.04637862f, 0.03943425f, 0.06064509f, -0.07748026f, -0.20314674f, -0.11752643f, -0.01386648f, 
    -0.08052333f, 0.02890814f, -0.01633067f, 0.05914972f, -0.17709087f, 0.27438274f, -0.22408591f, -0.21924150f, 
    -0.21280539f, 0.12960793f, 0.12645143f, 0.08005750f, 0.00071123f, -0.00110684f, 0.10392407f, 0.00087593f, 
    -0.03028462f, -0.00329559f, 0.00444236f, 0.20933370f, 0.07555255f, -0.04313925f, 0.03217589f, -0.00184348f, 
    0.13936640f, 0.01174384f, 0.15106866f, 0.11758510f, 0.32921913f, -0.06736702f, 0.03817282f, 0.10541414f, 
    0.03797294f, 0.09979434f, 0.03303578f, -0.05182366f, 0.04889187f, -0.00819077f, 0.09788867f, -0.04364591f, 
    0.04108396f, 0.01618590f, -0.00863780f, 0.04568739f, -0.28665683f, 0.42073244f, -0.00420720f, 0.03812122f, 
    0.29166713f, -0.05838011f, 0.01357980f, 0.04805641f, 0.00466815f, 0.12165816f, 0.09619717f, 0.03240015f, 
    -0.00501294f, 0.04015060f, -0.00793776f, -0.06030540f, -0.04631985f, 0.05130776f, -0.09102426f, 0.00159763f, 
    0.07345267f, -0.22057477f, 0.04791737f, 0.18917406f, -0.00008022f, 0.07134091f, -0.05358876f, 0.15092719f, 
    -0.00812498f, 0.04758637f, 0.01065078f, -0.10776232f, 0.07432336f, 0.14334190f, 0.18311994f, 0.03012889f, 
    -0.02653229f, -0.19234341f, -0.10563756f, 0.02249136f, 0.00711789f, -0.16424543f, 0.05037951f, -0.02149659f, 
    -0.03300156f, 0.05895100f, 0.00882820f, 0.12107515f, 0.15237603f, 0.18409598f, -0.10190251f, -0.01575720f, 
    0.09805819f, 0.09538110f, 0.01660453f, -0.10969034f, 0.17352469f, -0.02673576f, -0.01447632f, -0.06137335f, 
    0.13191873f, 0.00230037f, -0.12724373f, -0.02490824f, 0.17574710f, -0.02211575f, -0.05760592f, -0.12786552f, 
    -0.21526831f, 0.09983880f, -0.00289854f, -0.02499141f, -0.13458292f, 0.00847568f, -0.07026245f, 0.02249403f, 
    0.04764885f, -0.06019521f, 0.09904229f, 0.22473572f, 0.07456049f, 0.03694826f, -0.25689003f, -0.15896778f, 
    -0.19306894f, 0.08498482f, 0.05123996f, 0.08093294f, 0.10546377f, -0.11683398f, 0.06189197f, -0.04473973f, 
    -0.00349720f, 0.01927191f, 0.14538941f, 0.17430665f, 0.08762845f, -0.06273378f, -0.01055193f, -0.01697423f, 
    -0.81803113f, 0.19764017f, -0.06581540f, 0.03208017f, -0.30356503f, 0.07371595f, 0.09683876f, 0.04371123f, 
    -0.00564657f, 0.00921770f, 0.03773648f, -0.01571667f, 0.03848047f, 0.03970137f, -0.01888661f, 0.04471344f, 
    -0.02157584f, 0.01509235f, -0.21709327f, 0.19123891f, 0.02514835f, -0.01983175f, -0.08022340f, 0.00762387f, 
    -0.27559310f, 0.02488016f, 0.11846734f, -0.13124022f, 0.13490728f, -0.08509503f, -0.01783924f, 0.08132390f, 
    -0.05084424f, 0.09593514f, 0.03826472f, 0.08731819f, 0.16143599f, -0.07146903f, -0.08305570f, 0.13185799f, 
    -0.07679710f, 0.36884713f, -0.05174301f, 0.10365294f, 0.27808270f, 0.09606763f, -0.01913595f, -0.06129608f, 
    -0.06917351f, 0.01490144f, 0.08895148f, 0.02774066f, -0.02245089f, -0.03018857f, 0.07302406f, 0.08899499f, 
    0.00850734f, 0.16757095f, 0.03776934f, 0.12008700f, 0.19622555f, 0.01194911f, -0.26345697f, -0.17706646f, 
    -0.35620186f, 0.11418477f, 0.05400410f, 0.02989083f, -0.02845294f, -0.08630461f, 0.02301638f, 0.04654093f, 
    -0.10561766f, -0.23854643f, 0.09065589f, -0.09067822f, -0.01671143f, 0.02726745f, 0.00565560f, -0.05401274f, 
    0.04678609f, 0.18137400f, 0.15761979f, 0.01132293f, 0.19766678f, 0.00461973f, 0.06667004f, -0.15561415f, 
    -0.04610343f, 0.08387383f, -0.00515969f, -0.01259351f, 0.00190720f, 0.01861180f, 0.07032774f, 0.16995846f, 
    0.00855109f, 0.18007709f, -0.02515781f, -0.07827208f, 0.07707509f, 0.28850645f, -0.36589876f, 0.01567787f, 
    0.32212448f, 0.03108867f, -0.04397672f, 0.02905093f, 0.03837383f, 0.09023133f, -0.14406769f, -0.02581293f, 
    0.06009818f, -0.00720376f, 0.02756955f, 0.07237182f, 0.02322823f, 0.10777000f, -0.02822113f, 0.03455922f, 
    0.10267684f, 0.12096299f, 0.18802334f, -0.11837665f, 0.06928216f, 0.03885974f, 0.02180773f, 0.02949974f, 
    -0.06804764f, -0.01339876f, -0.21275337f, 0.06848569f, 0.17520131f, -0.03707267f, -0.00164022f, 0.05096776f, 
    0.01851728f, -0.04242631f, 0.14366563f, 0.02544463f, 0.03442525f, 0.10851157f, 0.03122192f, 0.05784343f, 
    0.14092577f, -0.03536304f, -0.01152603f, -0.02226546f, -0.10818911f, -0.09983400f, 0.00014780f, -0.01684584f, 
    0.00363234f, -0.17202713f, 0.08358479f, 0.06270220f, -0.10839330f, 0.13466485f, 0.14553595f, 0.06960019f, 
    0.28103620f, -0.09473579f, 0.12865818f, 0.22180654f, 0.27425146f, 0.17042169f, 0.02194198f, -0.02647186f, 
    -0.02148688f, 0.13298200f, -0.13990808f, -0.07887518f, 0.10949563f, 0.16607462f, 0.16877654f, -0.01202145f, 
    0.15930551f, -0.03819030f, 0.02978221f, 0.01898047f, 0.15940037f, -0.33351496f, 0.16252376f, -0.03094627f, 
    0.08431484f, 0.03417468f, 0.07668361f, 0.03163338f, -0.01265750f, 0.01677938f, -0.09651331f, -0.00448791f, 
    0.12858243f, 0.00145686f, 0.01066571f, -0.12079239f, -0.14488567f, -0.03791278f, -0.09004705f, 0.05436602f, 
    0.00916466f, -0.05835600f, -0.15990806f, 0.07498689f, -0.35295820f, 0.00170689f, -0.08595367f, -0.00036096f, 
    -0.02393492f, -0.14355025f, -0.00250182f, -0.00970786f, 0.03240095f, -0.01872567f, -0.06502754f, 0.08113334f, 
    -0.08218617f, -0.01710501f, -0.00920678f, -0.02789609f, 0.26265252f, -0.39131373f, 0.10015590f, 0.00710460f, 
    -0.46206608f, -0.02992097f, -0.06016396f, -0.04789850f, 0.00484173f, -0.01652684f, -0.09987222f, -0.02901265f, 
    -0.04287486f, -0.03254259f, 0.03600054f, 0.06001832f, 0.03003936f, -0.01350550f, 0.10464919f, 0.04241488f, 
    0.00866327f, 0.24089672f, 0.06628779f, -0.05170917f, 0.10642170f, -0.08094990f, 0.03526228f, -0.11109363f, 
    0.11679990f, 0.04925240f, -0.02820147f, -0.00472936f, -0.01975284f, -0.12036186f, -0.22388072f, 0.02443171f, 
    0.04714874f, 0.08661124f, 0.13858487f, 0.02491256f, -0.01321516f, 0.11200831f, -0.09540527f, 0.07680241f, 
    0.08933955f, 0.03865085f, -0.01542951f, 0.00901430f, -0.03904880f, -0.01050764f, 0.10395069f, 0.12296388f, 
    -0.06418427f, 0.04769199f, 0.05601897f, 0.09155951f, -0.10449573f, 0.11099698f, 0.10679488f, -0.04663067f, 
    -0.12707335f, -0.06079496f, 0.19720002f, 0.08183557f, -0.09041642f, 0.01560694f, 0.08823608f, 0.17036973f, 
    0.20806056f, 0.03469618f, -0.00078907f, 0.07769030f, 0.02833643f, 0.01430449f, -0.00560669f, -0.01323545f, 
    0.06829489f, 0.03511315f, -0.03898147f, -0.18446927f, -0.06329700f, 0.05059579f, 0.04680509f, 0.03514268f, 
    0.27116817f, -0.01011231f, 0.09567808f, 0.05191773f, -0.02272655f, 0.12585813f, -0.02071877f, 0.04479606f, 
    0.12577030f, -0.04451304f, -0.12374958f, -0.07231072f, -0.12819220f, -0.01200685f, -0.02546136f, -0.04202972f, 
    0.02303501f, -0.03922986f, 0.04663866f, 0.01952653f, -0.04412296f, -0.01472460f, 0.01492012f, -0.05036588f, 
    -0.01750639f, -0.02037252f, 0.00013386f, 0.04121612f, 0.00567760f, -0.03904326f, 0.02451753f, 0.04725597f, 
    -0.02280657f, -0.04219444f, 0.02679796f, 0.01128326f, -0.05971602f, -0.04238210f, -0.00931884f, -0.02962004f, 
    0.00783959f, -0.01963884f, 0.03357730f, -0.00175596f, 0.03762570f, -0.01474840f, 0.00614489f, 0.04657742f, 
    -0.02823603f, -0.00308724f, -0.03231173f, 0.03038046f, 0.04590501f, 0.03259265f, 0.00567269f, -0.03676484f, 
    0.03059279f, 0.02602452f, 0.01577022f, -0.01803413f, 0.01781769f, 0.02484924f, -0.03467254f, -0.03128681f, 
    -0.02683811f, -0.04970291f, -0.01482167f, -0.02132560f, -0.03400515f, -0.01210220f, 0.02005764f, -0.00646519f, 
    0.00910343f, 0.00766584f, -0.04851796f, -0.02753657f, -0.04176176f, 0.00125692f, -0.05998605f, -0.00673232f, 
    -0.03436858f, -0.03488057f, -0.04414981f, 0.01291985f, 0.02149973f, -0.00994685f, 0.03291747f, -0.02054015f, 
    0.03373493f, 0.04377238f, -0.02543343f, -0.04003936f, 0.01963662f, 0.02983029f, 0.02680254f, 0.04524473f, 
    0.00462892f, -0.01581814f, 0.04286571f, -0.01042005f, 0.04912088f, 0.03813110f, 0.03233548f, -0.02428960f, 
    -0.03819940f, -0.02111931f, -0.00380047f, 0.03059861f, 0.04722235f, 0.02800232f, 0.01012819f, 0.01797475f, 
    0.01482426f, -0.05113696f, -0.01703875f, -0.02740253f, -0.05804748f, -0.02858956f, -0.03056788f, 0.04411305f, 
    -0.03913224f, 0.00863190f, 0.03927569f, -0.01573376f, -0.06171126f, -0.02327167f, -0.01645472f, 0.00100906f, 
    0.00820198f, -0.05789205f, -0.02943693f, 0.01316985f, -0.05335378f, -0.05142627f, 0.00207249f, -0.05901707f, 
    0.03104156f, 0.00827497f, -0.00271869f, 0.03165783f, -0.03548893f, 0.02153729f, 0.03462755f, 0.02122454f, 
    -0.00025287f, 0.04678238f, -0.02366574f, 0.04485334f, 0.03127002f, -0.02709260f, 0.04224988f, -0.02003265f, 
    -0.00769980f, 0.01136259f, -0.06102923f, -0.00884527f, -0.04828927f, -0.03908615f, 0.01673366f, 0.03527004f, 
    -0.01089917f, -0.04123469f, -0.00881136f, 0.04131965f, 0.02032593f, 0.03278409f, 0.02284328f, -0.01334900f, 
    -0.06295460f, 0.01911543f, -0.04041167f, -0.02739122f, -0.02565041f, -0.01955036f, -0.05003904f, -0.04819567f, 
    0.01523738f, 0.02203034f, -0.02339345f, -0.03316306f, 0.02017391f, -0.05814692f, 0.03510473f, 0.00261289f, 
    0.04135351f, -0.00218099f, -0.01170998f, 0.02654750f, -0.03154596f, 0.02198704f, 0.01720369f, -0.03583076f, 
    0.04395887f, -0.01505256f, -0.05957645f, -0.01333591f, -0.05155238f, 0.02919701f, -0.04765446f, -0.04855085f, 
    -0.02828959f, -0.05050766f, -0.06465569f, -0.05825173f, -0.04073073f, 0.04483500f, -0.01833734f, -0.02573612f, 
    -0.03762048f, -0.00424924f, 0.00308871f, -0.00523017f, -0.03276364f, 0.02256223f, -0.03735794f, -0.02923691f, 
    -0.04560059f, 0.03590416f, 0.02887261f, -0.05399464f, 0.00992975f, 0.04113385f, 0.02579426f, 0.03490875f, 
    0.00237952f, 0.01906147f, 0.04031484f, -0.02364581f, -0.01095373f, -0.05951327f, -0.04637594f, -0.04989884f, 
    0.01694084f, 0.01743176f, 0.02229434f, 0.01965456f, 0.04501502f, 0.01114891f, -0.03429906f, -0.04815120f, 
    0.03955194f, -0.03313730f, -0.03880664f, 0.04023227f, 0.02290869f, -0.01574992f, 0.04331329f, 0.02936850f, 
    -0.01714402f, -0.02017207f, -0.05743380f, -0.04570667f, -0.05249819f, -0.02824617f, 0.03699060f, 0.00112983f, 
    0.00098079f, 0.04402627f, 0.01648683f, 0.02487566f, -0.05128368f, -0.02376752f, -0.04080150f, -0.03412743f, 
    0.00367552f, -0.00573503f, 0.01675336f, 0.01760155f, -0.04612484f, -0.03042482f, 0.00799085f, 0.04060661f, 
    -0.03496381f, -0.06149611f, -0.00731836f, 0.01078165f, 0.00792551f, -0.02918299f, -0.04778309f, -0.02793880f, 
    -0.04901870f, 0.03187313f, -0.01869409f, -0.01866620f, 0.01926280f, -0.02170184f, -0.01328315f, 0.04808946f, 
    0.02829188f, -0.02102769f, 0.01634132f, 0.01196219f, 0.02109415f, 0.02363064f, -0.01991348f, -0.00955723f, 
    0.01561943f, -0.00716743f, -0.03796600f, 0.01251635f, 0.02721008f, -0.06512899f, -0.00127396f, 0.02816187f, 
    0.00851338f, -0.01030800f, -0.01991120f, 0.00359970f, -0.05307309f, 0.00330491f, 0.03521306f, -0.01242937f, 
    0.01858487f, 0.00568392f, -0.02911787f, -0.05125942f, 0.01967196f, -0.01965077f, -0.00736651f, 0.03053589f, 
    0.01223412f, -0.00435797f, 0.03316215f, 0.02733142f, -0.00141782f, 0.01746526f, 0.01638054f, -0.00290654f, 
    0.00956171f, -0.01380960f, -0.06216772f, -0.03402060f, -0.02594881f, -0.05032970f, -0.05855617f, 0.04404276f, 
    0.05945900f, 0.01638478f, 0.03913102f, -0.03421710f, 0.05348576f, 0.00360053f, 0.02481380f, -0.01532121f, 
    -0.04007453f, 0.04309449f, 0.04779524f, -0.02884577f, 0.00665524f, -0.02312628f, 0.04095871f, -0.02604132f, 
    0.02240645f, 0.02091062f, -0.01374624f, 0.01266631f, -0.02695953f, -0.04406460f, 0.02860646f, -0.03435978f, 
    0.00619111f, -0.05189864f, 0.01465832f, 0.01999019f, -0.02515376f, -0.03302296f, 0.04874227f, -0.01752822f, 
    0.04252541f, -0.00405043f, 0.04684174f, -0.02617226f, 0.02535321f, 0.02814059f, 0.00220019f, 0.04020518f, 
    0.00239393f, 0.01827127f, -0.03814036f, -0.00696096f, 0.01424758f, -0.01089072f, -0.03185013f, 0.03057547f, 
    0.00710239f, -0.04768570f, -0.05956611f, 0.02764346f, 0.03053651f, -0.03531739f, -0.05731795f, 0.04912740f, 
    -0.04561131f, 0.00976236f, -0.02475430f, 0.04157172f, 0.03391495f, -0.04475487f, 0.01066547f, -0.04699646f, 
    0.00389688f, -0.03413899f, 0.03632485f, -0.03672170f, 0.00856083f, -0.03212671f, -0.00858096f, -0.00745568f, 
    -0.05568692f, 0.02138394f, 0.02800819f, -0.01928636f, 0.01512740f, -0.01274763f, -0.01715003f, 0.01161945f, 
    -0.01622610f, -0.05178666f, -0.03299173f, 0.03288121f, -0.01007348f, -0.03055590f, -0.01656734f, 0.02760697f, 
    -0.01695825f, 0.02704711f, 0.03384129f, -0.02434676f, -0.04601273f, 0.01444132f, 0.04760455f, -0.01040742f, 
    0.04124823f, -0.03719972f, 0.01231723f, 0.03722217f, 0.01190805f, -0.00477966f, -0.04334697f, -0.03323417f, 
    -0.05245193f, -0.04183082f, -0.03677984f, 0.03982447f, -0.02899739f, 0.03375373f, -0.00889551f, -0.04547510f, 
    -0.05536370f, 0.01256422f, -0.02297607f, -0.02778437f, 0.04537514f, 0.04504871f, -0.04029364f, 0.03802996f, 
    -0.05303894f, 0.02713423f, 0.02749070f, -0.01397061f, -0.01404601f, 0.03265932f, -0.04394670f, 0.02331700f, 
    -0.03710716f, -0.04569967f, 0.02462105f, 0.03285725f, -0.01018074f, -0.00119489f, 0.03517233f, 0.01210752f, 
    -0.03324347f, 0.02307184f, 0.01585909f, 0.01599434f, -0.02146222f, 0.01857294f, -0.04416769f, -0.05733621f, 
    0.03476704f, 0.05591279f, -0.05763273f, 0.00649712f, -0.00929104f, -0.03824048f, -0.05082289f, -0.05472432f, 
    -0.04271022f, -0.04719838f, 0.01201854f, -0.01497727f, -0.05600148f, -0.03767997f, -0.02830349f, -0.01068254f, 
    -0.01715640f, 0.03489853f, -0.05994266f, 0.00515543f, -0.00317258f, 0.04549036f, -0.05542604f, 0.02909429f, 
    0.00251553f, 0.00871036f, 0.04548371f, -0.04638356f, 0.01209042f, -0.01191739f, -0.03234354f, 0.00658536f, 
    -0.02125129f, 0.03060716f, 0.02909937f, 0.02031958f, 0.00084274f, -0.04367827f, 0.00484008f, -0.00812664f, 
    0.02739246f, -0.05076192f, -0.05065719f, -0.03753856f, -0.02528504f, 0.03240828f, -0.01513736f, -0.02343183f, 
    0.03435349f, -0.03162780f, -0.00817303f, 0.03872379f, 0.02112597f, 0.01169828f, -0.06335694f, -0.05173973f, 
    0.04930342f, -0.03005741f, -0.00499367f, -0.04578448f, 0.05209221f, 0.04427947f, -0.00598799f, -0.00801545f, 
    0.00596071f, -0.04489662f, 0.01302824f, 0.00677005f, 0.02031741f, -0.00070586f, -0.00933502f, -0.02421446f, 
    0.00986602f, 0.01395727f, -0.05429019f, -0.01037569f, 0.02887948f, 0.01707488f, -0.02913908f, 0.03935366f, 
    -0.03889566f, -0.04686075f, 0.01320925f, 0.03485782f, -0.02357035f, 0.00910881f, 0.01435540f, 0.00700138f, 
    -0.00568357f, -0.04348321f, 0.04535330f, 0.04300504f, -0.01049076f, -0.02267463f, 0.03476853f, -0.03682070f, 
    0.03706486f, -0.04144452f, -0.04240294f, -0.00453375f, -0.04184051f, -0.04576189f, 0.00985198f, 0.00260823f, 
    -0.00505512f, 0.00702173f, -0.04318949f, -0.03418455f, 0.02574154f, -0.02383261f, 0.01590599f, 0.03359982f, 
    -0.01116734f, 0.03349843f, -0.03552193f, -0.00825515f, -0.02096503f, 0.04033946f, 0.04592938f, 0.03812056f, 
    -0.02229369f, -0.04674496f, -0.04908086f, -0.05049347f, -0.04011248f, -0.01276399f, 0.05023130f, -0.03261957f, 
    0.01555217f, -0.04582968f, 0.03785129f, -0.00789175f, -0.03835560f, 0.00348028f, -0.04215278f, -0.02229113f, 
    0.03754660f, -0.02529773f, -0.04916187f, -0.03285968f, -0.03548587f, 0.02153305f, 0.01330430f, -0.03907834f, 
    0.04237588f, 0.04649108f, -0.00243896f, -0.01165812f, -0.05103564f, -0.00578953f, -0.05412391f, 0.02348937f, 
    0.01724990f, -0.00323925f, -0.04828791f, 0.02649055f, 0.02382729f, -0.05361682f, -0.05659700f, -0.05774074f, 
    -0.04619581f, -0.04171151f, -0.02800540f, 0.03513543f, -0.03121893f, -0.02416244f, 0.02237568f, 0.01442490f, 
    -0.03091668f, -0.00483904f, 0.02922924f, -0.04710296f, 0.00018539f, 0.01622633f, -0.00697773f, -0.01202392f, 
    -0.07585375f, 0.31639197f, -0.00120772f, 0.03919227f, -0.06827781f, 0.09677576f, 0.23831911f, -0.12976934f, 
    -0.13246654f, -0.07466331f, 0.12865576f, -0.00900523f, 0.12244988f, -0.02384792f, 0.16885985f, -0.03653811f, 
    0.12010131f, 0.06676900f, 0.08339890f, -0.07184283f, 0.01421073f, -0.08000051f, 0.17864236f, 0.06247703f, 
    -0.13303109f, 0.02039582f, 0.14191197f, -0.05045553f, -0.08762318f, 0.01959316f, -0.01060795f, -0.01140857f, 
    0.20425865f, -0.11484440f, 0.14629288f, -0.08074524f, -0.01779398f, -0.00123488f, 0.07337117f, -0.00503202f, 
    -0.30478767f, -0.00045590f, -0.11990132f, 0.04817107f, 0.01001303f, -0.02321877f, -0.01578097f, 0.05548332f, 
    -0.01178433f, -0.02549344f, 0.09233548f, -0.12313136f, -0.07133062f, 0.17244805f, 0.05319869f, 0.01055707f, 
    0.09716864f, -0.04337725f, -0.02263032f, 0.16432405f, 0.06505909f, 0.11234403f, 0.22792944f, 0.07658216f, 
    -0.08722367f, -0.05488030f, 0.01949082f, -0.10860335f, -0.15250209f, 0.13975318f, 0.14673376f, 0.05926370f, 
    0.11932651f, 0.10366409f, 0.03145452f, -0.04746991f, 0.06780159f, -0.07876553f, 0.00691665f, -0.07417462f, 
    -0.21717009f, 0.11879952f, -0.13837990f, -0.04446288f, -0.33976391f, 0.15804738f, 0.04178832f, -0.01929789f, 
    0.19110483f, -0.09964955f, -0.05240458f, 0.01305277f, -0.05509412f, 0.01202239f, 0.03833336f, -0.09796586f, 
    0.21070741f, -0.04132975f, 0.05718260f, 0.04849423f, -0.22374283f, -0.03651151f, 0.03905876f, -0.05848736f, 
    -0.07547865f, 0.05287773f, -0.00989329f, 0.05845363f, -0.04252429f, -0.00521191f, 0.11695574f, 0.03591973f, 
    0.25604898f, 0.15132654f, -0.03840917f, -0.06738594f, 0.13512747f, -0.02493701f, -0.18575056f, 0.04194521f, 
    -0.57615411f, -0.20775828f, -0.09726733f, 0.00671176f, 0.09730694f, 0.18902604f, -0.05124849f, -0.02514056f, 
    0.01481664f, 0.16381900f, -0.06390475f, -0.11937527f, -0.06399912f, 0.00476758f, -0.03406153f, 0.04174112f, 
    0.04015711f, -0.07986005f, -0.03421383f, -0.09500587f, -0.06469406f, 0.25396031f, 0.07049676f, 0.02179077f, 
    0.14852062f, 0.06049680f, -0.02794973f, 0.07528411f, 0.08517729f, -0.14479929f, 0.15651879f, -0.06509377f, 
    -0.14240552f, 0.20149128f, -0.14242816f, 0.04518225f, 0.13989128f, -0.09837709f, -0.02509480f, 0.00421191f, 
    -0.70693851f, -0.17790586f, -0.38425139f, -0.07394822f, 0.06850056f, -0.02251837f, 0.11824244f, 0.07847065f, 
    -0.02094075f, -0.06639908f, -0.00676599f, 0.03793461f, -0.06641294f, -0.03967698f, 0.04229809f, -0.08034965f, 
    0.21101850f, -0.02167284f, -0.02050958f, 0.02193388f, -0.33821964f, -0.12703881f, -0.21156487f, -0.01394547f, 
    0.10269288f, 0.13313796f, 0.06736935f, -0.00845345f, -0.03652979f, 0.02008938f, 0.02673081f, 0.09307466f, 
    0.00929353f, 0.02582179f, 0.02967955f, 0.00681819f, 0.01404791f, 0.05519080f, -0.11867437f, 0.10054412f, 
    0.01371607f, 0.14123601f, 0.21428579f, 0.10245917f, -0.10436049f, 0.06732238f, 0.19278812f, -0.05557610f, 
    -0.07816274f, -0.07146730f, 0.00303661f, -0.19241756f, 0.02270839f, -0.00239448f, 0.07953316f, -0.05079695f, 
    0.14513668f, 0.08656146f, 0.07867419f, 0.01697757f, 0.23504083f, -0.16791448f, 0.14883113f, 0.32011917f, 
    -0.23687416f, 0.05079194f, 0.04666644f, 0.06834139f, -0.01978699f, 0.09947845f, 0.14277655f, 0.10310303f, 
    -0.05504940f, -0.00358425f, 0.00534631f, 0.06524677f, 0.02192855f, 0.20576605f, 0.00820963f, 0.11101707f, 
    -0.01100453f, -0.17415512f, -0.11696593f, -0.08813380f, -0.04270569f, -0.06415468f, -0.09728761f, 0.11745532f, 
    0.01144233f, -0.07128199f, -0.01092984f, -0.01777684f, 0.10793212f, 0.05367532f, -0.00626397f, 0.02136451f, 
    0.10347953f, -0.17873161f, -0.09764500f, 0.22576638f, -0.04139319f, 0.39724228f, -0.12323410f, 0.04486511f, 
    0.08320747f, 0.00812474f, -0.01884109f, 0.10523391f, 0.02354644f, 0.09040716f, 0.06576327f, -0.02086843f, 
    -0.09989857f, 0.19441731f, 0.04110778f, 0.09270301f, 0.03480466f, -0.12752999f, 0.09412538f, 0.17788768f, 
    0.16533059f, -0.17775719f, 0.07370273f, -0.12984326f, 0.14984052f, 0.10559539f, 0.06678336f, 0.04447527f, 
    -0.13677332f, -0.07907879f, -0.07768948f, 0.00421306f, -0.00751347f, -0.13085310f, -0.07734273f, -0.00492341f, 
    0.30896914f, 0.07402244f, 0.23033303f, 0.11858539f, -0.25891951f, -0.06748062f, -0.22602352f, 0.04894706f, 
    -0.13916804f, 0.10586209f, -0.06237142f, 0.01302312f, -0.06684410f, 0.00734910f, 0.03228285f, -0.05479918f, 
    -0.03444842f, -0.02738444f, -0.07782526f, 0.10592612f, 0.01205718f, -0.01077970f, -0.04293188f, -0.06420742f, 
    -0.11806419f, 0.03599897f, -0.17971221f, -0.04365573f, -0.27095541f, -0.00334309f, 0.04197085f, -0.08591708f, 
    0.00603662f, -0.01582493f, -0.00609425f, -0.03604430f, -0.07780788f, 0.07258631f, -0.02144457f, -0.01376930f, 
    0.07898897f, -0.11872546f, 0.06496236f, 0.04218094f, 0.18531698f, -0.03483516f, -0.01655372f, 0.00848294f, 
    0.05640886f, -0.20492221f, -0.04326289f, 0.13376379f, 0.10691544f, 0.13770674f, -0.09636775f, -0.00526349f, 
    -0.01987693f, 0.03572397f, -0.14789560f, 0.11789102f, 0.01480364f, 0.02487826f, 0.13575402f, -0.08310080f, 
    0.42084476f, -0.00696102f, 0.10099431f, 0.16191372f, 0.03860650f, -0.12848695f, 0.12888156f, -0.05226285f, 
    0.04052064f, -0.07729515f, -0.06617702f, -0.04054369f, 0.04452133f, -0.03624845f, 0.05493535f, -0.05131378f, 
    0.02035724f, -0.00295960f, 0.00573630f, -0.03179613f, -0.26650307f, -0.47358531f, -0.09563200f, 0.19737554f, 
    0.06525920f, -0.22057085f, -0.15133893f, -0.03546626f, 0.02481779f, 0.10473418f, 0.00360490f, -0.09531861f, 
    -0.12585472f, 0.06680185f, -0.00393791f, -0.00372331f, -0.07071430f, -0.03967719f, 0.08574844f, 0.04004644f, 
    -0.16976085f, 0.34162930f, -0.10334878f, 0.12163218f, -0.13991202f, -0.12591729f, 0.00552010f, -0.01933186f, 
    -0.04134199f, -0.04476932f, -0.03046633f, -0.05262240f, -0.02568271f, -0.01929725f, -0.13115393f, -0.06264123f, 
    -0.02109125f, 0.02724459f, -0.00735955f, 0.09512829f, 0.00707790f, 0.08168684f, 0.27325809f, 0.32210878f, 
    0.00297031f, -0.18237869f, 0.04859490f, 0.02230881f, 0.01885525f, 0.05681392f, 0.02601386f, -0.02745630f, 
    -0.01304130f, -0.07532157f, -0.13006906f, -0.06785857f, -0.09148826f, -0.01764122f, -0.17501314f, -0.00962902f, 
    -0.09730706f, 0.06730526f, 0.29502368f, 0.26631638f, 0.26989502f, 0.11200708f, 0.10462737f, -0.00963859f, 
    0.14100683f, 0.14846756f, -0.04885380f, 0.07758505f, -0.08897805f, -0.00018510f, 0.03633082f, 0.00245485f, 
    0.10659780f, 0.04302043f, 0.01893493f, -0.23837511f, 0.28873172f, 0.22833830f, 0.02064558f, 0.18378568f, 
    0.29282764f, 0.14348769f, 0.15284847f, -0.01642074f, 0.07940400f, 0.06584298f, 0.03350375f, -0.00889404f, 
    0.02302523f, -0.08863963f, 0.05402013f, -0.08256789f, 0.06515112f, -0.00893736f, -0.10032687f, -0.03447558f, 
    -0.28326285f, 0.64150083f, 0.01677606f, -0.13791808f, -0.10765330f, 0.11925349f, -0.03267667f, -0.00898135f, 
    0.07110341f, -0.02625036f, 0.07054198f, 0.06007394f, -0.01137392f, -0.05559199f, -0.12931469f, -0.14506374f, 
    -0.10576936f, -0.04215574f, 0.01207048f, -0.00792244f, -0.00581089f, -0.05575968f, 0.03803034f, 0.08753394f, 
    0.31899646f, 0.06407434f, 0.07222338f, 0.16022210f, -0.01096755f, 0.08904824f, -0.00753599f, 0.06890627f, 
    0.08424292f, -0.00164555f, -0.01077949f, -0.06458794f, 0.05042288f, 0.09915785f, 0.12639663f, -0.04416895f, 
    -0.29163215f, -0.09904921f, -0.09745213f, -0.07933805f, -0.10578134f, -0.05441577f, -0.00499675f, -0.11986092f, 
    -0.03688665f, 0.01513025f, -0.02404625f, -0.05354919f, 0.06191600f, 0.15243019f, 0.02591471f, 0.10775395f, 
    0.11258938f, -0.13662843f, 0.07740626f, 0.06139573f, -0.66396588f, -0.11531164f, 0.00371768f, -0.12443361f, 
    0.02992170f, -0.19416811f, 0.07581385f, 0.08309337f, -0.01349463f, 0.08024663f, 0.10720696f, 0.03678891f, 
    -0.05570817f, 0.08027378f, -0.11344188f, 0.12815094f, 0.14760782f, -0.25519300f, -0.00373973f, 0.10416150f, 
    0.17148706f, 0.04825822f, 0.12684026f, 0.17882204f, -0.00628593f, 0.03700266f, -0.07816519f, -0.09179908f, 
    -0.00332075f, 0.06714700f, -0.09403405f, -0.01646587f, 0.05525207f, 0.03154846f, 0.16999172f, -0.17070268f, 
    -0.02684423f, -0.10933506f, -0.16896729f, 0.06398770f, 0.27189660f, 0.28157926f, 0.01823760f, 0.30791426f, 
    0.07083881f, 0.00233202f, 0.13317354f, -0.15600061f, 0.08380775f, -0.04240175f, -0.02232909f, -0.00244207f, 
    -0.03140241f, -0.05539616f, 0.02093727f, -0.05584811f, -0.10697585f, 0.01652090f, -0.18804412f, -0.05511342f, 
    0.07237373f, 0.05661523f, -0.26974076f, 0.18364041f, -0.08916243f, -0.03768985f, 0.01942088f, 0.03025306f, 
    -0.04367856f, -0.00580555f, 0.06405647f, -0.09353922f, -0.11878224f, -0.12910853f, 0.03671729f, -0.07915893f, 
    -0.04930492f, -0.00383239f, 0.01233040f, 0.07281558f, -0.21594791f, 0.22578284f, -0.05095420f, 0.07341901f, 
    0.15726858f, -0.04451980f, -0.04444006f, -0.18026757f, 0.08460273f, -0.01044486f, -0.08024716f, 0.09817186f, 
    -0.02166229f, -0.10363597f, -0.08448495f, 0.05599723f, -0.03710488f, 0.03631395f, 0.08357443f, -0.06348401f, 
    0.03340980f, 0.02745304f, -0.03816955f, -0.05246901f, -0.02541668f, -0.03993478f, 0.02049902f, -0.00343716f, 
    -0.01158726f, -0.02715422f, 0.01412264f, -0.00306008f, -0.03052137f, 0.02816145f, -0.05651239f, -0.02370445f, 
    0.00494608f, -0.02396263f, -0.04088945f, 0.01386259f, -0.05328421f, -0.02228096f, -0.00517615f, -0.02559843f, 
    0.01168005f, 0.02117463f, -0.01562470f, 0.03456877f, 0.00251968f, -0.04351126f, -0.05124770f, -0.04653852f, 
    0.01305747f, -0.05138576f, -0.06096397f, -0.00455293f, -0.04510559f, -0.05320401f, 0.04518269f, -0.01747664f, 
    -0.02167992f, -0.01225585f, 0.03434465f, 0.03142637f, -0.01708301f, 0.04056207f, 0.01121821f, -0.00665885f, 
    -0.02532421f, -0.02658896f, 0.04919125f, -0.03396593f, 0.01057266f, 0.00294198f, 0.00657207f, 0.01814182f, 
    -0.04050590f, -0.04177317f, -0.02534554f, 0.03346664f, 0.01324917f, -0.00780319f, 0.06200577f, -0.00432668f, 
    -0.03509502f, -0.03949488f, 0.00992913f, 0.01846160f, -0.03354611f, -0.01471817f, -0.04319807f, -0.01285348f, 
    -0.05843676f, -0.05998553f, -0.00954959f, -0.01810219f, -0.05265422f, 0.01525284f, 0.00722796f, -0.03269275f, 
    -0.01440201f, 0.04001069f, -0.01582848f, -0.00405905f, -0.04175159f, -0.00902579f, 0.03042980f, 0.02882541f, 
    -0.00185180f, 0.01976090f, -0.01992126f, 0.02790623f, 0.05406817f, -0.00780788f, 0.03100434f, 0.02371200f, 
    -0.02913425f, -0.00134136f, -0.01653050f, 0.02288242f, -0.03564733f, -0.02608953f, -0.04880453f, -0.06030323f, 
    -0.04588274f, 0.03443517f, -0.05085269f, 0.02637337f, 0.02452010f, -0.01419554f, -0.03738653f, -0.02535781f, 
    0.01541083f, -0.02471871f, -0.00608102f, -0.04800251f, 0.01340214f, -0.03774852f, -0.03533180f, -0.00729318f, 
    0.06455193f, -0.02692241f, -0.02457261f, 0.02965974f, -0.03567710f, -0.04880856f, 0.00373275f, 0.02499551f, 
    0.02735447f, 0.01174839f, 0.03234367f, -0.00975849f, 0.03237333f, -0.02612731f, -0.06058209f, -0.06260490f, 
    0.03862160f, 0.03349727f, 0.00853732f, 0.00034219f, -0.00425419f, 0.00603602f, 0.03820461f, 0.05437995f, 
    -0.04291929f, -0.01055253f, 0.04062474f, -0.03471168f, 0.03760465f, -0.03637198f, 0.04148147f, 0.01126939f, 
    -0.03142503f, 0.02668319f, -0.01134226f, -0.06054718f, 0.01944730f, -0.01221743f, 0.04417505f, -0.02066638f, 
    -0.03897978f, -0.04366338f, -0.04061520f, -0.01398786f, -0.04697413f, -0.02678830f, 0.03180450f, 0.01176428f, 
    -0.01198660f, 0.02749256f, -0.03438129f, -0.06150324f, -0.03581112f, -0.01343657f, -0.01876695f, -0.03671377f, 
    -0.02709120f, 0.00328133f, -0.04001219f, 0.00589181f, 0.00030441f, -0.03059330f, -0.04802379f, -0.01063342f, 
    0.02188883f, 0.00419220f, -0.01424292f, -0.01218421f, 0.01809027f, -0.03532917f, 0.02195371f, -0.05186940f, 
    -0.03112970f, -0.02526037f, 0.04063886f, -0.00710736f, -0.01016674f, -0.02245291f, -0.03857538f, -0.05081582f, 
    0.02466498f, -0.03467475f, -0.01893947f, -0.00355097f, -0.03644865f, 0.00752014f, 0.01882999f, 0.05195388f, 
    0.00495404f, -0.01961711f, -0.01456015f, 0.01572423f, -0.00520313f, -0.03483253f, 0.03597513f, 0.04146248f, 
    -0.01274457f, 0.02910359f, 0.00977680f, -0.00580242f, 0.00369253f, -0.01910986f, -0.01010304f, -0.01097661f, 
    0.01205493f, 0.03428211f, 0.00639468f, -0.03852242f, -0.01612759f, -0.04956092f, -0.01366468f, -0.00987117f, 
    0.04566017f, 0.03564421f, -0.00915523f, -0.04982952f, -0.04036690f, 0.04133374f, 0.03706880f, -0.02630500f, 
    -0.04489145f, 0.01163867f, -0.01302564f, 0.01563077f, -0.05365751f, 0.02319149f, -0.02335402f, 0.03961214f, 
    0.02275060f, 0.03312551f, -0.03063004f, 0.03810279f, -0.04883318f, 0.02565213f, -0.01684593f, -0.05770559f, 
    -0.04624417f, -0.06009584f, -0.04862247f, -0.00566960f, 0.01172240f, -0.03771220f, -0.00309461f, -0.04820827f, 
    0.05316830f, 0.04055785f, -0.04251318f, -0.03738901f, -0.03275082f, 0.03937426f, 0.00810970f, -0.01669424f, 
    -0.00341942f, 0.03410613f, 0.01663841f, -0.05014572f, 0.01880479f, -0.03111011f, 0.04439474f, -0.05509269f, 
    0.01324744f, -0.02765711f, -0.00245506f, -0.03556487f, 0.00866747f, -0.04697223f, -0.03727601f, -0.03502971f, 
    0.02306959f, -0.03734666f, 0.00115773f, 0.02215213f, 0.03525381f, 0.03653248f, 0.01914060f, -0.00633867f, 
    -0.01795111f, 0.05248549f, -0.02635157f, 0.02935809f, -0.04742191f, 0.03775347f, 0.04512858f, -0.02725092f, 
    0.04266140f, 0.03542561f, -0.05137298f, 0.00224752f, 0.03148950f, 0.03307953f, -0.03027618f, -0.01832770f, 
    0.02642231f, -0.03891728f, 0.04136162f, 0.01536280f, 0.02815336f, 0.01605479f, 0.03477520f, 0.02546117f, 
    -0.20498587f, 0.18559751f, -0.06480247f, 0.12672131f, 0.20406058f, -0.00602070f, 0.09970853f, 0.10955317f, 
    -0.00101466f, 0.01900306f, 0.10910416f, 0.11646341f, 0.05666978f, 0.01262928f, 0.08233048f, 0.03166094f, 
    0.07832041f, 0.01201931f, -0.04897856f, 0.00801187f, 0.01892485f, 0.18670066f, 0.26084921f, 0.19180265f, 
    -0.05724202f, -0.02907426f, -0.13645211f, -0.01206066f, 0.01484835f, 0.06254295f, -0.05529300f, 0.00631680f, 
    0.01208163f, 0.01474042f, 0.19904873f, 0.03644113f, 0.03595418f, 0.00034198f, 0.09680375f, 0.07054280f, 
    -0.06201538f, -0.17276420f, -0.09188335f, 0.16675040f, -0.00972160f, 0.04883953f, -0.09415410f, 0.01353687f, 
    0.01854304f, 0.04965838f, -0.00413420f, -0.05236934f, 0.14887087f, -0.03464200f, -0.01220743f, -0.04960277f, 
    0.00531502f, -0.07047350f, 0.06642716f, 0.13500842f, 0.20093691f, 0.00546500f, 0.21294641f, 0.15384057f, 
    -0.06785911f, -0.20207652f, -0.06411146f, -0.03548680f, -0.02579985f, 0.10447948f, 0.09570939f, -0.05187829f, 
    -0.00976969f, 0.00334982f, 0.09681847f, 0.04611711f, -0.04284337f, 0.04793648f, 0.13512862f, -0.00815694f, 
    0.03750164f, 0.18231013f, 0.04411015f, 0.04113446f, 0.00870861f, -0.09955309f, 0.06714491f, -0.04088086f, 
    0.05911580f, -0.14403203f, 0.02883648f, 0.01224117f, 0.07837419f, 0.06440667f, 0.02540538f, 0.05543149f, 
    0.09437264f, 0.11112762f, -0.05440950f, 0.05663735f, 0.21027845f, -0.19640173f, 0.07665997f, 0.17376904f, 
    -0.09183325f, 0.03642634f, -0.03724615f, 0.01221900f, -0.01618965f, 0.01371371f, -0.03658074f, -0.09132144f, 
    0.04740781f, 0.10941818f, 0.12216329f, 0.00953240f, -0.07434241f, 0.13257731f, 0.16039324f, -0.00504897f, 
    -0.79420108f, 0.22724544f, -0.27624258f, -0.10795435f, -0.08811275f, 0.20583192f, -0.02368650f, -0.03563131f, 
    0.09275375f, -0.03332465f, -0.02860094f, 0.00763035f, -0.02275038f, 0.00550187f, -0.03446168f, -0.04766192f, 
    -0.02334400f, 0.03124061f, 0.00180501f, -0.03239503f, -0.18391784f, -0.30278239f, -0.19712538f, 0.12833552f, 
    0.09741195f, 0.03320330f, 0.07674238f, 0.02923363f, 0.06977673f, -0.04421925f, 0.10989124f, 0.15177809f, 
    -0.02367051f, 0.02533337f, 0.15221931f, 0.14951274f, -0.08257283f, 0.16043901f, -0.05595724f, 0.00861639f, 
    -0.02563303f, -0.07603832f, 0.22499634f, 0.15403144f, -0.16588938f, -0.04455414f, -0.00687915f, 0.12509175f, 
    -0.05293290f, -0.13110612f, 0.07626126f, -0.04058419f, -0.09930828f, 0.07746494f, 0.01147121f, 0.00338865f, 
    0.03536376f, 0.03090992f, -0.01948595f, 0.11051345f, -0.62500054f, 0.16781820f, -0.34427699f, -0.24831334f, 
    -0.01700007f, 0.07828845f, 0.07155489f, 0.04693422f, 0.01247548f, -0.08675411f, -0.06308621f, -0.03542175f, 
    0.07758638f, 0.00119386f, 0.02922956f, 0.06660973f, -0.02047371f, 0.05687681f, 0.00279213f, 0.03234914f, 
    -0.08870157f, 0.12998897f, 0.13149942f, 0.11208221f, -0.03253693f, -0.03167756f, 0.10324372f, -0.11396484f, 
    0.08521904f, 0.01469890f, 0.10006167f, 0.04711093f, -0.06685461f, -0.03795891f, 0.04910854f, 0.01972668f, 
    0.02023231f, 0.08303930f, 0.10827642f, 0.01044657f, -0.06939608f, -0.15228663f, 0.35079223f, 0.13244589f, 
    -0.02072841f, -0.09941438f, -0.13738337f, 0.02556544f, -0.00994300f, 0.07651892f, 0.06728522f, 0.00494645f, 
    0.16000250f, -0.00324192f, 0.11154544f, -0.14204705f, -0.00635203f, -0.02861662f, 0.13251700f, -0.09607786f, 
    -0.06238751f, -0.15087393f, 0.28255060f, 0.19845459f, -0.02546473f, -0.11999829f, 0.05261561f, -0.07029693f, 
    -0.03067148f, -0.01700963f, -0.01803873f, -0.09518285f, -0.10612733f, 0.07616060f, -0.02118444f, 0.03518006f, 
    0.04822491f, -0.02559635f, -0.06012318f, -0.08611358f, -0.17798182f, 0.09917876f, -0.11194073f, 0.11228105f, 
    0.00465264f, 0.19356513f, -0.11379236f, 0.13771148f, -0.02693074f, -0.03071727f, 0.07625804f, 0.14664482f, 
    0.03248274f, 0.02057308f, 0.11191027f, 0.00245601f, -0.09543763f, -0.02897854f, 0.14183578f, 0.01690724f, 
    0.18053596f, -0.17770286f, 0.02188613f, -0.13239545f, -0.10180613f, -0.10714841f, -0.01572237f, 0.02798836f, 
    -0.03577839f, 0.07092692f, -0.07898723f, 0.06315759f, 0.10425826f, -0.01773914f, -0.01292114f, 0.10857401f, 
    0.04320666f, -0.04472016f, -0.07442386f, -0.04260604f, -0.44244576f, 0.04108750f, -0.12380879f, -0.12959522f, 
    -0.01766556f, -0.00329880f, 0.04045663f, -0.01152082f, -0.07877535f, -0.10465346f, 0.05839518f, 0.05199642f, 
    0.04814127f, -0.07341479f, 0.05412778f, 0.02551522f, 0.10496245f, 0.02915545f, 0.00627479f, 0.01779164f, 
    -0.12248904f, 0.55396456f, -0.17836577f, 0.15062614f, 0.14972463f, 0.06395467f, 0.14172336f, -0.09740099f, 
    -0.06463732f, -0.10149443f, 0.05159491f, -0.05209764f, 0.04247119f, -0.07605092f, 0.11579539f, 0.00128311f, 
    0.02497283f, 0.03602142f, 0.10564743f, -0.00040155f, -0.15561377f, 0.02382807f, 0.17201835f, 0.05186771f, 
    -0.02026809f, 0.00289010f, -0.02080623f, -0.12401092f, -0.04494040f, 0.08492161f, -0.11340851f, 0.09182877f, 
    0.06697392f, 0.00901510f, 0.10507642f, 0.02852139f, 0.08894391f, -0.06530216f, 0.04951283f, 0.01444770f, 
    -0.13727048f, 0.05211255f, -0.04772604f, 0.00660832f, -0.27660143f, -0.04550605f, 0.04371086f, -0.07434238f, 
    0.00783128f, -0.00035926f, 0.10662995f, -0.14915606f, 0.02716533f, 0.12663935f, 0.07730304f, -0.01910281f, 
    0.07355434f, -0.03028765f, 0.09424616f, 0.15585917f, -0.10361925f, -0.01285053f, 0.18310632f, -0.01687361f, 
    -0.15006366f, 0.08281156f, 0.02129097f, -0.15842573f, -0.01238302f, 0.13440190f, 0.02164789f, 0.05481237f, 
    -0.04217945f, -0.05841373f, 0.08524660f, -0.08809927f, -0.05063246f, 0.02398412f, 0.11148091f, -0.09807961f, 
    -0.27714652f, 0.42050943f, -0.03892778f, 0.02668931f, -0.19833764f, -0.04763523f, 0.15475370f, -0.09520157f, 
    -0.01067866f, 0.03567462f, 0.02602944f, 0.06362400f, 0.01821493f, 0.11608154f, 0.14425693f, 0.07174201f, 
    0.16437957f, 0.10611780f, 0.09463519f, 0.06984838f, 0.08189360f, 0.05887719f, -0.03989474f, -0.02401198f, 
    -0.34627870f, 0.01410897f, -0.00572166f, -0.02227275f, -0.09776282f, -0.06134420f, -0.04640479f, -0.03609358f, 
    0.04296036f, 0.10910621f, 0.05487869f, -0.01252445f, 0.04310270f, -0.06041633f, -0.02010868f, -0.00555127f, 
    -0.48908421f, 0.06137902f, -0.08407243f, 0.02162668f, 0.09604669f, 0.14653288f, -0.00764931f, -0.00290306f, 
    -0.00700572f, 0.09982845f, -0.01388282f, 0.00186707f, 0.04788202f, 0.03206453f, 0.05562680f, 0.02538077f, 
    -0.00235439f, -0.04645513f, 0.06916863f, -0.04700981f, -0.16329882f, 0.08067777f, 0.15830255f, -0.00061788f, 
    0.20309797f, 0.08063503f, 0.04608435f, 0.08331073f, -0.11004946f, -0.09984704f, 0.14761315f, 0.15493210f, 
    0.00741177f, -0.05609514f, 0.03718979f, 0.02990636f, -0.05059802f, 0.01880657f, -0.05660240f, 0.03877394f, 
    0.16465735f, -0.22662598f, -0.10831135f, 0.05524981f, 0.08441848f, 0.00723138f, -0.04541200f, 0.00983604f, 
    -0.14423715f, 0.03452646f, 0.13762730f, -0.19256079f, -0.24309918f, 0.06213893f, 0.08678272f, -0.03745696f, 
    0.14462581f, -0.02325346f, 0.05184518f, 0.03059810f, -0.23045343f, -0.18886860f, -0.04361654f, -0.02913098f, 
    0.28340641f, -0.03854350f, 0.03318535f, 0.05471244f, 0.02418301f, 0.00982662f, -0.02165545f, 0.05514652f, 
    0.00518422f, -0.09349646f, 0.16391630f, -0.00008189f, -0.10683892f, 0.06567902f, 0.00041473f, 0.07566190f, 
    -0.26395524f, 0.18035969f, 0.16693869f, 0.05642064f, -0.06997795f, 0.08069980f, 0.19612299f, -0.22580369f, 
    0.03647478f, -0.07162197f, -0.02924097f, -0.09536751f, 0.02943438f, -0.00685694f, 0.14744584f, -0.00662958f, 
    -0.02440892f, 0.06922958f, 0.19108219f, -0.04591519f, -0.04537578f, -0.43393442f, 0.34714353f, 0.24679218f, 
    -0.09668397f, 0.18938769f, 0.00997041f, -0.02282653f, -0.07418320f, 0.05713977f, -0.07643572f, -0.00707918f, 
    0.05608829f, 0.09075473f, 0.01913207f, 0.01448679f, -0.03857249f, 0.03729331f, 0.10357564f, -0.04918636f, 
    -0.14673425f, -0.10371673f, 0.09827434f, -0.08320821f, -0.06596991f, -0.05582132f, -0.04229242f, 0.00678195f, 
    0.08575401f, -0.12163978f, -0.05174841f, -0.09698915f, 0.04789475f, 0.01417168f, -0.08822954f, 0.09167135f, 
    0.03859847f, -0.05693292f, -0.02449357f, -0.02711120f, -0.10349178f, 0.35066634f, -0.05586867f, 0.07455266f, 
    -0.02403001f, 0.06439409f, -0.01746034f, 0.06113565f, 0.01775487f, -0.08565771f, -0.01842248f, 0.11398087f, 
    -0.02687012f, 0.04381253f, 0.11640733f, 0.01048567f, -0.10708296f, -0.14224289f, 0.07089913f, 0.07902686f, 
    0.20484255f, 0.00416966f, -0.02310731f, -0.09025465f, -0.22127275f, 0.03318216f, -0.05704780f, 0.04412695f, 
    0.11284208f, -0.06850237f, -0.04696595f, -0.01766637f, 0.13637494f, 0.06891325f, 0.00938277f, -0.03259696f, 
    0.12482418f, -0.09155824f, 0.07781900f, -0.08466855f, -0.41224548f, 0.02888487f, -0.08655099f, 0.00425836f, 
    0.01859397f, 0.03178471f, -0.01141185f, -0.05833738f, -0.11760031f, 0.14761730f, 0.12600887f, 0.15043910f, 
    0.06134734f, -0.03237073f, 0.04556302f, 0.09840214f, 0.04376364f, 0.01401176f, 0.08935129f, -0.05007277f, 
    0.17877208f, -0.28160444f, 0.04192986f, -0.04081856f, 0.31253806f, 0.02475227f, 0.10932324f, 0.13756453f, 
    0.11026605f, 0.00667320f, 0.05010847f, 0.00067901f, 0.05730889f, 0.00230206f, 0.04097552f, -0.00396285f, 
    0.01688729f, 0.13483998f, -0.14022912f, 0.05915666f, -0.14835276f, 0.28235039f, 0.23421887f, 0.00110292f, 
    -0.05093251f, -0.07241873f, -0.06102499f, 0.13937055f, -0.02072951f, 0.12569882f, 0.03474686f, 0.03929429f, 
    -0.03436140f, -0.01914534f, 0.05254505f, -0.02222331f, -0.13819407f, 0.01405365f, -0.03018755f, -0.00950790f, 
    -0.05457078f, -0.29384905f, 0.07786086f, 0.01993220f, -0.06312869f, -0.01837519f, -0.02727947f, 0.11229450f, 
    0.02937211f, 0.07634626f, -0.10831921f, -0.05627472f, 0.09759504f, 0.02224241f, -0.11769579f, -0.03883465f, 
    0.01793034f, -0.09253942f, 0.15997332f, -0.15594269f, -0.11268904f, 0.32309887f, 0.35340273f, -0.00776006f, 
    -0.01887511f, -0.11400843f, -0.05069171f, 0.07176894f, 0.02161949f, 0.19011860f, 0.06866675f, -0.05655694f, 
    0.03627389f, 0.11541080f, 0.01816591f, 0.14641654f, -0.02679994f, -0.15464695f, -0.02033779f, -0.03019190f, 
    -0.02116013f, -0.13003956f, -0.19333600f, -0.02313674f, 0.05915476f, 0.06334813f, 0.02601197f, 0.07564004f, 
    0.06866953f, -0.05635747f, 0.03221569f, 0.10797346f, 0.10346672f, -0.08159778f, 0.03024970f, 0.04487919f, 
    0.08746880f, 0.03674228f, -0.09652514f, 0.13353994f, 0.14359492f, -0.27422121f, 0.33848125f, -0.07080610f, 
    -0.33939365f, 0.10333994f, 0.01466232f, 0.11028307f, -0.02828245f, 0.01832739f, -0.04551454f, 0.00443394f, 
    -0.00837429f, 0.01082108f, 0.10257307f, -0.01113469f, -0.15615202f, -0.01996054f, 0.13090596f, 0.00456707f, 
    -0.00646648f, -0.12175365f, -0.27823916f, 0.08627063f, -0.06979488f, 0.00740614f, 0.08000060f, -0.02632308f, 
    0.06763023f, 0.00997678f, 0.08537327f, -0.03832611f, 0.05416952f, 0.06849833f, -0.11021295f, -0.04489315f, 
    -0.03019433f, 0.00906586f, -0.15855156f, 0.19255999f, -0.09327409f, -0.19684137f, -0.10643248f, 0.00480234f, 
    -0.01137580f, 0.13644980f, -0.01993972f, 0.01467508f, 0.08926339f, -0.04349941f, 0.09559709f, -0.04935776f, 
    0.02921530f, 0.08271109f, -0.02914107f, 0.12071450f, 0.04055886f, -0.04668951f, 0.02903626f, -0.00344111f, 
    0.34457108f, -0.23925902f, -0.06187904f, -0.07998710f, 0.04753228f, -0.18452631f, 0.07093136f, 0.02850827f, 
    -0.04029145f, 0.02273784f, 0.08410294f, 0.06540874f, -0.06613459f, -0.07467703f, -0.05638639f, 0.05361573f, 
    -0.05700784f, 0.03413240f, -0.11093783f, 0.11033679f, -0.07075498f, 0.18965606f, -0.28923717f, -0.16415370f, 
    -0.13129044f, 0.08125180f, 0.02169853f, -0.13228981f, 0.18915896f, -0.05153301f, 0.12998772f, 0.00543344f, 
    -0.08182211f, 0.18646705f, 0.01833611f, 0.11973464f, -0.00333573f, -0.08452603f, -0.05414689f, -0.02074015f, 
    -0.09270301f, 0.22672708f, 0.39215565f, -0.18011941f, 0.10438447f, 0.08036516f, 0.01897088f, 0.03684433f, 
    0.02262208f, 0.10227409f, 0.08306488f, 0.11150067f, -0.00941575f, -0.09656964f, 0.08502536f, 0.02078446f, 
    -0.04334803f, 0.00711739f, -0.02912192f, 0.12578592f, -0.35601339f, 0.31158957f, 0.11892592f, -0.05984645f, 
    0.19394687f, 0.03725873f, 0.01897265f, 0.06348552f, 0.02883008f, 0.14325817f, -0.01625228f, -0.04479270f, 
    0.06540146f, 0.01386041f, 0.18864246f, -0.06868633f, 0.00501626f, 0.07835769f, -0.13061166f, -0.10866232f, 
    -0.05125160f, -0.15578382f, 0.17516613f, 0.18858719f, 0.04590064f, -0.00437593f, 0.05551995f, 0.10928527f, 
    -0.04271410f, 0.07178682f, -0.08576191f, -0.01131498f, -0.08383933f, 0.14323495f, 0.10232344f, 0.00027618f, 
    0.02379782f, 0.03642046f, 0.10717481f, -0.11212765f, -0.05231204f, -0.14013056f, 0.02732490f, -0.12974298f, 
    0.02730566f, 0.07085615f, -0.06014481f, 0.19480284f, 0.03966136f, 0.05107213f, -0.09058689f, -0.06597854f, 
    0.02869782f, -0.03428201f, -0.01841905f, -0.02653387f, 0.13006668f, -0.03807208f, 0.06825917f, 0.11711502f, 
    0.01757350f, -0.35802355f, 0.00661189f, -0.04319213f, 0.28669026f, -0.09344253f, -0.11662807f, 0.08429544f, 
    -0.21582569f, 0.01893601f, 0.12181916f, 0.14718829f, 0.06882861f, 0.10377024f, 0.08088696f, 0.11365975f, 
    0.09877428f, -0.00970563f, -0.07889231f, 0.20386727f, 0.18163449f, -0.06869841f, -0.12140489f, -0.06951927f, 
    -0.19567396f, 0.04816892f, 0.07838165f, -0.03980755f, 0.05420862f, -0.11809315f, 0.12495074f, 0.09527192f, 
    -0.03241950f, -0.07633714f, 0.11498757f, 0.05725591f, 0.11803684f, 0.01077666f, -0.03124622f, 0.07222482f, 
    0.04390780f, -0.02371951f, -0.00770533f, -0.03385476f, -0.02768908f, -0.04053145f, -0.01504119f, 0.00866557f, 
    -0.04533905f, -0.02468595f, 0.01654781f, -0.05519011f, 0.04895671f, 0.01894542f, -0.00935331f, 0.00808385f, 
    0.04042866f, -0.04249566f, 0.03285687f, -0.05524394f, 0.00605807f, -0.02241334f, -0.04228335f, -0.00176896f, 
    -0.04243380f, -0.02474055f, 0.04793543f, -0.02697133f, -0.03975850f, 0.02073574f, -0.00854873f, 0.02790421f, 
    -0.04209803f, -0.00253320f, 0.01964678f, 0.00213069f, -0.00432442f, -0.00250588f, -0.01228606f, -0.02654085f, 
    -0.01939942f, -0.03928111f, 0.03626736f, 0.00039225f, 0.01675108f, -0.02211040f, 0.01340313f, 0.02424759f, 
    0.01850665f, 0.01015531f, 0.02192397f, -0.03689084f, -0.05192304f, -0.00070042f, -0.03400372f, -0.02368332f, 
    0.00702125f, 0.04431259f, -0.04824399f, -0.04814072f, 0.01218835f, 0.04286752f, 0.03521427f, -0.01833748f, 
    0.01799028f, -0.02730334f, -0.00146375f, -0.03325561f, 0.04459019f, -0.02967575f, -0.01764626f, 0.00504342f, 
    0.00452049f, 0.01457358f, -0.04220935f, -0.01820359f, -0.01609201f, 0.00309047f, -0.03801920f, -0.00359131f, 
    0.00153619f, 0.03809970f, -0.03317917f, 0.02312201f, 0.05151609f, 0.01747150f, 0.02597957f, -0.03242751f, 
    0.04524359f, 0.05006614f, 0.01785176f, -0.05038647f, 0.05328745f, -0.02262842f, 0.05355770f, 0.00841606f, 
    0.00461766f, 0.03483160f, -0.04697416f, -0.01625227f, 0.02362248f, -0.05314911f, -0.03757054f, 0.03731218f, 
    0.03036071f, 0.01928759f, -0.02713497f, 0.01889739f, 0.02077447f, -0.00145409f, 0.00657784f, -0.02467719f, 
    -0.00632617f, -0.01689983f, 0.02934452f, 0.05079389f, -0.03908864f, 0.01730957f, -0.01678574f, -0.05276850f, 
    -0.01887848f, 0.04368468f, -0.05231807f, -0.02675655f, 0.01762115f, 0.01247750f, -0.01098383f, 0.05380666f, 
    0.02260610f, -0.01174963f, -0.00614091f, -0.02164632f, 0.05207600f, 0.01080166f, 0.02596059f, -0.00970343f, 
    0.03927290f, -0.02573156f, 0.04442198f, -0.03781292f, -0.03119845f, -0.04629399f, 0.02029121f, -0.00052806f, 
    -0.02470219f, 0.04348006f, 0.04914617f, 0.01763429f, -0.04182432f, -0.01555440f, -0.04878189f, 0.04140829f, 
    -0.01948367f, 0.03329302f, 0.05163364f, 0.02245171f, 0.01359716f, 0.00095315f, -0.05448032f, -0.04979960f, 
    -0.04077883f, -0.00113691f, -0.02970993f, -0.05144209f, -0.00075468f, 0.00440218f, 0.03907403f, -0.02265234f, 
    -0.04350241f, 0.04381805f, -0.00673491f, -0.05109152f, -0.00403595f, -0.04603671f, 0.03853732f, 0.03041122f, 
    0.00872270f, 0.01588002f, -0.00702682f, -0.03952870f, 0.00532618f, -0.01772243f, 0.03592151f, 0.02934294f, 
    -0.01513458f, 0.00688622f, -0.04892465f, -0.02691065f, 0.01323952f, 0.05394128f, -0.04492771f, -0.02501514f, 
    -0.05377579f, 0.02172353f, 0.00149609f, -0.02885933f, -0.05137311f, -0.04223895f, -0.00196525f, -0.04426565f, 
    -0.00511032f, -0.02872786f, -0.00518515f, 0.02461292f, 0.02341398f, 0.02793855f, 0.01917825f, 0.03030295f, 
    0.03197614f, -0.04535837f, -0.04470102f, 0.04239683f, -0.00175043f, -0.01731469f, -0.04848542f, -0.03186896f, 
    0.02813123f, 0.00669283f, -0.04619385f, -0.03912761f, -0.05344727f, 0.04398210f, -0.01462528f, -0.01166720f, 
    -0.00948161f, -0.00581038f, -0.04877955f, -0.03598037f, 0.03423239f, 0.01331552f, 0.03169743f, 0.03418767f, 
    -0.01033762f, -0.03516211f, -0.00658205f, -0.02060886f, 0.00642055f, -0.02170330f, 0.03561706f, 0.04625770f, 
    0.01732014f, -0.00436533f, 0.03055601f, -0.05195963f, -0.05327422f, -0.05317003f, -0.01807920f, 0.03071946f, 
    0.01363553f, 0.04130116f, -0.03604795f, 0.01260267f, -0.00051764f, -0.03364001f, 0.04083863f, 0.03742270f, 
    -0.05448474f, -0.04767762f, -0.05476481f, 0.03291048f, -0.01955737f, 0.05563757f, 0.02452855f, -0.05440433f, 
    -0.00681102f, 0.03770957f, -0.05052292f, 0.01976116f, -0.01500813f, -0.03678806f, -0.02161408f, 0.01066702f, 
    -0.05479972f, 0.00568778f, 0.04697815f, 0.02445036f, -0.03147953f, -0.04524941f, 0.02076648f, -0.01840181f, 
    0.00562302f, -0.01252918f, 0.00644269f, -0.00605088f, 0.01012239f, -0.04117271f, 0.03144065f, -0.04404277f, 
    -0.04291261f, -0.02773272f, 0.03117611f, 0.02514111f, -0.03338414f, -0.04228244f, 0.04002945f, 0.01367993f, 
    -0.04940675f, -0.04052303f, 0.05339582f, -0.00771768f, -0.01073648f, 0.00398958f, -0.02041528f, 0.02270799f, 
    0.04407323f, -0.04319207f, 0.02586462f, 0.02557748f, 0.00190844f, 0.00804816f, -0.04486009f, 0.03438947f, 
    -0.01368821f, -0.02581000f, -0.04546063f, -0.04743812f, -0.02895194f, -0.04767524f, 0.05074669f, -0.03480532f, 
    -0.20176455f, 0.22431050f, 0.01852678f, -0.01874403f, 0.08544541f, 0.11761415f, 0.01933973f, 0.05403643f, 
    -0.01339994f, -0.13694584f, 0.06136796f, 0.07346641f, -0.00833463f, 0.03654578f, -0.01097523f, -0.03211606f, 
    0.00938510f, 0.12846619f, -0.06963467f, 0.07357905f, 0.12896526f, -0.30086467f, -0.05164790f, -0.08790439f, 
    0.34781960f, -0.01326410f, -0.03441269f, -0.14638476f, 0.05410993f, -0.01485671f, -0.03415029f, -0.02430797f, 
    -0.09163200f, 0.06335382f, -0.03903348f, 0.05104950f, 0.21550301f, -0.08441661f, -0.05389330f, 0.09155578f, 
    -0.22341661f, 0.29034153f, -0.06219315f, 0.19545929f, 0.04671678f, -0.04519418f, 0.04597328f, -0.03736742f, 
    -0.05484438f, -0.03275422f, 0.14074588f, 0.10831869f, 0.05812365f, -0.03060378f, 0.06918287f, 0.08998732f, 
    -0.00617466f, 0.06738466f, 0.11386029f, 0.06459428f, 0.17535451f, -0.36412695f, -0.04442256f, -0.34054461f, 
    0.02768252f, 0.04504059f, 0.16572730f, -0.07285360f, 0.00929071f, 0.00245985f, 0.04017999f, 0.10824551f, 
    -0.07851134f, -0.19763549f, -0.10038072f, -0.12689865f, 0.04148185f, -0.08258630f, -0.01265087f, 0.05408580f, 
    -0.05657210f, 0.16130459f, 0.32477003f, 0.14222577f, -0.00928138f, 0.02154114f, 0.03142507f, 0.03257251f, 
    -0.07583177f, 0.12803228f, -0.08776058f, -0.00986529f, -0.01894511f, -0.04959081f, 0.08218445f, 0.07172570f, 
    -0.02626568f, 0.12184464f, -0.04145180f, -0.07891835f, 0.16249564f, 0.06145426f, -0.06137673f, 0.00010395f, 
    -0.38730651f, 0.04543306f, 0.07021832f, -0.14436424f, -0.01100104f, -0.03239492f, -0.02208263f, 0.03702658f, 
    -0.10969317f, -0.01203415f, -0.03200361f, -0.10173217f, 0.13592936f, 0.07569812f, 0.01627000f, 0.09050058f, 
    -0.17048247f, 0.29541099f, 0.31613216f, 0.26700211f, -0.16187641f, -0.10123730f, -0.18447599f, -0.09692856f, 
    -0.01024937f, 0.18904263f, -0.14580704f, 0.20821688f, 0.02725986f, 0.08651432f, 0.13385288f, -0.04442731f, 
    -0.07501569f, 0.06591865f, 0.15957688f, -0.10814209f, 0.01863372f, -0.11833359f, 0.20756081f, 0.13424028f, 
    -0.03574567f, -0.04744961f, 0.01678968f, -0.05462456f, -0.11675992f, -0.08125747f, -0.02173377f, 0.06013314f, 
    -0.13367245f, -0.16314560f, -0.01436351f, 0.04182245f, -0.03673669f, 0.16181745f, 0.09606138f, 0.00701770f, 
    0.25819770f, 0.27912256f, 0.36308530f, -0.00145728f, 0.15279467f, -0.03612886f, -0.07358439f, 0.03214690f, 
    0.05941283f, 0.01871505f, -0.00886297f, -0.06611513f, 0.02407721f, 0.28742194f, 0.07330311f, 0.00506353f, 
    0.06391443f, -0.03471456f, -0.02565797f, -0.04032925f, 0.16943191f, 0.02707162f, 0.19769898f, 0.35355100f, 
    0.04058670f, -0.02803729f, -0.04002245f, -0.05524430f, 0.08431277f, 0.07420284f, -0.04144781f, -0.07134806f, 
    0.05082031f, 0.09944310f, 0.13572986f, -0.01086882f, -0.03553604f, 0.14820012f, 0.00825065f, 0.07949448f, 
    0.02157594f, 0.01410845f, -0.10147163f, -0.17257413f, 0.11364642f, 0.05068183f, 0.03296850f, -0.05253335f, 
    -0.00801776f, 0.00947110f, -0.06410287f, 0.03730236f, -0.11219817f, -0.05235238f, 0.00591804f, 0.06266923f, 
    0.11479411f, 0.10616542f, 0.10787261f, -0.02564650f, 0.15136571f, -0.45123547f, 0.06215413f, -0.19508970f, 
    0.15357584f, 0.07070228f, 0.08269697f, -0.12951100f, -0.03861175f, -0.09638446f, -0.09558550f, -0.03777024f, 
    -0.00314212f, -0.18455531f, 0.09048208f, -0.05814790f, 0.00802184f, -0.00320134f, 0.16397436f, -0.01072464f, 
    -0.19261411f, -0.05725987f, 0.02524020f, -0.22320008f, 0.01426012f, -0.14538147f, 0.07498790f, 0.06219861f, 
    0.00536838f, -0.09726387f, 0.10298351f, -0.01889277f, 0.00459583f, -0.12518167f, -0.06831553f, -0.04617730f, 
    -0.06276546f, 0.25417033f, 0.04198715f, -0.01373323f, 0.08579946f, 0.22659884f, 0.11763160f, 0.19391249f, 
    -0.16676572f, -0.00308339f, -0.05638750f, 0.03569011f, -0.05054672f, -0.04670167f, -0.01668643f, 0.02031206f, 
    -0.08036336f, -0.13180314f, 0.07883849f, 0.16078979f, -0.11778446f, -0.03527222f, -0.09837583f, 0.16183922f, 
    0.39120448f, -0.09045572f, 0.07210408f, -0.20830020f, -0.17197427f, -0.01346619f, 0.10860034f, 0.10604491f, 
    0.22202562f, -0.23537791f, -0.04382618f, 0.03524603f, 0.16833781f, 0.06955275f, 0.14830226f, -0.00887476f, 
    -0.15817885f, 0.04821198f, -0.20218731f, -0.05997515f, -0.23411492f, 0.18095134f, 0.20800591f, 0.15106787f, 
    0.07741405f, 0.00764081f, -0.11225145f, -0.03107973f, -0.06673957f, 0.09598821f, -0.05128087f, -0.03319909f, 
    0.04049754f, 0.03114139f, -0.06452108f, -0.05477102f, 0.00997665f, 0.13099711f, 0.08234683f, -0.09652562f, 
    0.41188341f, -0.11959223f, 0.03654001f, -0.04954400f, 0.04556392f, -0.13085920f, -0.01104656f, -0.14809904f, 
    -0.03567546f, 0.00045360f, 0.02113518f, -0.06235473f, -0.10328974f, -0.08258971f, 0.05058979f, -0.05592566f, 
    0.02644529f, -0.05962686f, 0.17172003f, -0.09830802f, -0.04335165f, 0.31571525f, 0.05190617f, -0.08663217f, 
    0.15868954f, -0.06820109f, -0.14609194f, 0.15942141f, -0.08320870f, -0.03997237f, 0.04434910f, -0.02725339f, 
    -0.00386933f, -0.08309104f, -0.06491646f, -0.06164394f, -0.12385044f, 0.12978137f, 0.08995817f, -0.10236062f, 
    0.42664602f, -0.38500375f, 0.13688509f, 0.00176395f, 0.14717145f, -0.08953693f, 0.08496132f, 0.03274316f, 
    0.11808909f, -0.05945896f, -0.18400282f, -0.07934216f, 0.05237025f, -0.00168562f, 0.03159418f, -0.01898852f, 
    0.01350738f, -0.08748621f, -0.00955691f, -0.16808023f, -0.37559658f, 0.05331370f, 0.07526077f, 0.14076954f, 
    0.18883561f, -0.10211036f, -0.14679542f, -0.01115396f, 0.04318420f, -0.00286931f, -0.09675216f, -0.06672600f, 
    0.20656282f, 0.18869169f, -0.03519515f, 0.13779859f, 0.01663177f, -0.00159637f, 0.05233980f, 0.02319747f, 
    -0.22882697f, 0.03829902f, -0.19095248f, 0.00128017f, -0.00140328f, -0.01979591f, 0.01325288f, 0.06400618f, 
    0.05319811f, -0.13396667f, 0.04908236f, 0.08154076f, -0.00785614f, -0.02644037f, -0.14424567f, -0.05952260f, 
    0.00349755f, -0.04230012f, 0.15363419f, 0.08869383f, 0.00810029f, -0.10992111f, 0.22322376f, 0.25690901f, 
    0.05606051f, -0.08882403f, -0.01814348f, 0.07158097f, -0.07370519f, 0.08418509f, 0.07010735f, 0.05937198f, 
    0.01442469f, -0.08271556f, -0.05984112f, -0.08809059f, -0.13860472f, -0.11276364f, -0.02394482f, -0.03496853f, 
    0.17835747f, -0.21768226f, 0.03168293f, -0.10663648f, 0.13030477f, 0.13146797f, 0.12678850f, 0.08863301f, 
    0.06809224f, 0.07993979f, 0.04631619f, -0.00105418f, -0.15200013f, 0.04560840f, -0.06738010f, -0.00582380f, 
    0.00727624f, -0.01042573f, -0.18562621f, -0.01950381f, -0.01189302f, 0.19305043f, -0.02285698f, 0.03311471f, 
    0.13280208f, 0.08962927f, 0.01458652f, -0.00124998f, 0.20091249f, 0.06051214f, 0.07738354f, -0.04955384f, 
    0.03641055f, 0.15778022f, -0.08952413f, 0.02385105f, 0.02025787f, -0.15681899f, -0.09858812f, 0.07144435f, 
    -0.28670236f, 0.23243524f, -0.15205684f, -0.03694011f, -0.21641497f, 0.06390807f, 0.14393474f, 0.02641763f, 
    -0.03895777f, -0.04847621f, 0.03343402f, 0.17189330f, -0.02400352f, -0.21563876f, -0.16116466f, -0.05971243f, 
    -0.10889759f, 0.03400352f, -0.00098425f, 0.13073872f, 0.04022336f, 0.05782937f, 0.07920870f, -0.13338442f, 
    -0.00716074f, 0.10999358f, 0.10954588f, 0.04987263f, 0.06826839f, -0.09358196f, 0.09003575f, 0.15484756f, 
    -0.07136691f, 0.06747288f, -0.10543716f, 0.07527578f, 0.20112434f, -0.00425764f, 0.06015848f, -0.08621877f, 
    -0.20843600f, 0.08412576f, 0.14678912f, 0.06974005f, 0.03919302f, -0.11924472f, -0.03659458f, 0.09309901f, 
    -0.05048541f, 0.00386947f, 0.03960347f, -0.08344218f, 0.05057246f, 0.04537156f, 0.07887333f, -0.03772656f, 
    0.05257249f, -0.01244671f, -0.05908652f, 0.04504758f, -0.39052117f, 0.29934719f, -0.00819007f, -0.04339744f, 
    0.09734617f, -0.07058093f, -0.06091680f, 0.10775949f, 0.02488937f, 0.08331764f, 0.07841241f, 0.05535320f, 
    0.03423247f, 0.10008539f, -0.11086024f, 0.05841226f, 0.13218506f, 0.02776247f, -0.11099608f, -0.00570655f, 
    0.10268289f, -0.20104426f, 0.08919784f, 0.23990272f, 0.09212923f, 0.14477777f, -0.12071200f, -0.02787887f, 
    0.02478598f, 0.02222480f, -0.03390247f, 0.07311451f, 0.13814722f, 0.13104574f, 0.17125320f, -0.10018485f, 
    -0.02398537f, -0.09660681f, 0.05764014f, 0.07817078f, 0.14171562f, -0.10551500f, 0.02188975f, -0.02700052f, 
    0.14980780f, 0.00519328f, 0.10139008f, 0.08355813f, 0.14100771f, 0.09039354f, -0.09783844f, -0.07043220f, 
    0.01786695f, 0.00156921f, -0.05409034f, -0.12828861f, 0.13735782f, -0.01304765f, -0.05471363f, 0.05289000f, 
    -0.09648901f, 0.07642674f, -0.15352693f, 0.14103018f, 0.12618887f, 0.05461561f, -0.08284208f, -0.12660494f, 
    -0.23097843f, 0.01911450f, 0.02846599f, -0.07474952f, -0.18891093f, -0.02316720f, 0.05388353f, 0.04229825f, 
    0.03777179f, 0.12141641f, 0.04071396f, 0.19601905f, 0.10236061f, 0.18055484f, -0.00006891f, -0.01230368f, 
    -0.22092257f, 0.04627992f, 0.07921923f, -0.02423273f, 0.18937364f, -0.07715594f, 0.00102598f, 0.04938902f, 
    -0.00182549f, -0.01589545f, 0.03353352f, 0.13418676f, 0.10555871f, 0.06064504f, -0.01180186f, 0.00697738f, 
    -0.05748228f, -0.01040423f, -0.04690572f, -0.02314994f, 0.03914363f, -0.00718560f, -0.00827881f, 0.04310504f, 
    -0.00299942f, 0.03641807f, 0.03439675f, 0.01921361f, 0.02909408f, -0.04139087f, 0.04465095f, 0.00353924f, 
    -0.04377631f, -0.04703623f, -0.05811935f, -0.05078701f, -0.04845309f, 0.01960752f, -0.00712491f, 0.03979311f, 
    0.01311808f, 0.02551501f, -0.03447905f, -0.03833814f, -0.02165801f, -0.02040338f, -0.00254053f, -0.05737201f, 
    0.00110229f, -0.06003000f, -0.05411445f, -0.03360273f, -0.03767131f, -0.06250905f, 0.00714702f, 0.01502508f, 
    -0.00751941f, 0.00218978f, -0.03167610f, 0.02227358f, 0.01553086f, -0.04259272f, 0.04337865f, -0.04383876f, 
    0.01407834f, -0.04589728f, -0.03812096f, -0.04850931f, 0.00823076f, 0.00707510f, 0.00246625f, 0.04673466f, 
    0.00479950f, 0.00201251f, 0.02165630f, 0.00362543f, 0.03686821f, -0.02515383f, -0.04170172f, -0.00292498f, 
    0.02152470f, 0.03276278f, 0.03411159f, 0.00129156f, 0.03244590f, -0.03203421f, 0.04741040f, 0.05036065f, 
    0.03225076f, 0.02985331f, 0.04799541f, -0.01562904f, 0.04633449f, -0.01766302f, 0.01127368f, -0.02935160f, 
    -0.01248759f, 0.00724741f, -0.01153607f, -0.05327089f, 0.01836109f, 0.04409657f, -0.04601339f, -0.04867566f, 
    0.01058836f, 0.01064889f, 0.02206537f, 0.02006260f, 0.02966497f, 0.02131553f, -0.04985567f, 0.03854656f, 
    0.02329343f, -0.01659739f, -0.04567468f, -0.03776306f, 0.03944575f, 0.01276227f, -0.01432413f, 0.00170689f, 
    0.00774815f, 0.01059915f, -0.04189331f, 0.01761077f, -0.06031093f, 0.00592736f, 0.01943738f, -0.02843370f, 
    -0.02156282f, -0.02845440f, 0.00738267f, 0.00325744f, -0.04466212f, -0.01904987f, -0.05716729f, -0.03449929f, 
    0.00105860f, -0.00322463f, -0.01663437f, -0.01904659f, -0.02517510f, 0.02713379f, 0.00058628f, 0.00911550f, 
    0.04555701f, 0.00440390f, 0.02842672f, 0.00029817f, 0.04416693f, -0.05665128f, 0.04315361f, -0.00237492f, 
    -0.00735310f, -0.00401618f, 0.04287464f, -0.02807515f, -0.00797081f, -0.01050417f, -0.00485848f, -0.00529320f, 
    0.04253570f, 0.00054952f, -0.00830131f, -0.06000511f, -0.00924347f, -0.00801185f, -0.05264412f, -0.06037182f, 
    0.04172318f, 0.04751579f, -0.04481399f, 0.01814144f, -0.06203688f, -0.01927624f, -0.04018980f, -0.05028632f, 
    -0.03271456f, -0.00351911f, 0.01321704f, 0.01024531f, 0.03658812f, -0.02088780f, -0.00073658f, 0.01718135f, 
    0.01356621f, -0.01427030f, -0.01238669f, -0.00140651f, 0.03326612f, 0.02105748f, 0.01491619f, 0.00689707f, 
    -0.03554892f, -0.02115543f, 0.01088872f, -0.03968449f, 0.03563805f, 0.00504574f, 0.03750498f, -0.04034965f, 
    -0.03114008f, -0.03013794f, -0.05103860f, -0.06100664f, -0.01919461f, -0.04007129f, 0.02906733f, 0.01751410f, 
    0.02242673f, -0.02634251f, -0.04311410f, -0.05433149f, -0.04766899f, -0.04977558f, 0.01456226f, -0.04228601f, 
    0.04246393f, -0.04037478f, 0.00564152f, -0.03866762f, 0.03924346f, 0.04250813f, 0.02943625f, 0.00736099f, 
    0.02662018f, -0.06418848f, -0.02022547f, -0.01588937f, -0.02212702f, 0.03465921f, -0.04112884f, 0.02860685f, 
    0.01926656f, -0.06430599f, -0.00263804f, -0.03440743f, 0.04011825f, -0.00709248f, -0.05874517f, -0.01168659f, 
    -0.00589790f, 0.00322203f, -0.04286945f, -0.04024202f, -0.06083697f, -0.05947423f, 0.01819605f, -0.03040691f, 
    -0.01048601f, -0.02604248f, 0.01628380f, -0.02842814f, -0.03247958f, -0.03853966f, 0.00000677f, -0.01486550f, 
    -0.02991536f, -0.03660401f, 0.03592791f, -0.01001771f, -0.02881002f, -0.04862281f, -0.05862067f, -0.01568427f, 
    0.01431902f, 0.00345359f, -0.04221604f, -0.02429503f, 0.04338722f, 0.01815382f, 0.04094008f, -0.04653345f, 
    -0.00475833f, -0.00883488f, 0.03238701f, -0.00626387f, 0.02127145f, -0.00931910f, -0.00843449f, -0.03929437f, 
    -0.06117493f, 0.04422615f, -0.03306746f, -0.04449734f, -0.02207017f, -0.06044495f, -0.02783407f, 0.04174480f, 
    0.02497773f, -0.01692151f, -0.02863970f, 0.04082467f, -0.03538321f, 0.04012776f, -0.00286990f, -0.02769557f, 
    -0.00113926f, -0.02981080f, -0.02920527f, -0.01609498f, -0.00326884f, -0.05088080f, 0.00163668f, -0.03275955f, 
    -0.05710798f, -0.03711423f, -0.01385665f, -0.02040495f, 0.00230270f, 0.00299400f, -0.04244083f, -0.01598807f, 
    -0.04668231f, 0.04747267f, -0.03950893f, 0.03769178f, 0.03929151f, 0.04698382f, 0.00887611f, -0.00756339f, 
    -0.02283218f, 0.00750075f, 0.02399983f, 0.00935339f, 0.02679398f, -0.01270189f, -0.05232413f, -0.00518780f, 
    -0.02257019f, -0.01766454f, 0.00470940f, -0.01550426f, -0.01747414f, 0.01896545f, -0.04500344f, 0.02148832f, 
    -0.03655173f, -0.01289257f, -0.05584888f, -0.04237302f, 0.02432891f, -0.00960531f, 0.00917234f, -0.03820304f, 
    -0.02072229f, -0.04688548f, -0.05642217f, -0.03712587f, -0.03130018f, -0.04670187f, 0.02214842f, -0.00123222f, 
    -0.01658677f, -0.01711326f, -0.01629714f, -0.06324570f, 0.05110839f, -0.01826464f, -0.05189179f, -0.02190141f, 
    0.01516086f, -0.00289146f, -0.01974199f, -0.01430488f, -0.02134307f, 0.00322515f, -0.01246301f, -0.05507619f, 
    -0.02120628f, 0.01361086f, -0.05898459f, -0.06430522f, 0.03758406f, 0.00015002f, -0.05548323f, 0.02224046f, 
    0.00999383f, 0.01375873f, 0.00613370f, -0.00229081f, -0.00238531f, -0.05299834f, -0.00024614f, -0.06010003f, 
    0.00285434f, -0.01167188f, 0.03209247f, -0.05631670f, 0.02364660f, 0.00980957f, -0.04727428f, -0.04098528f, 
    -0.02426890f, -0.02019623f, 0.02804596f, 0.02705811f, 0.02338061f, -0.02495522f, 0.03478727f, 0.00389732f, 
    0.03025351f, 0.00363118f, -0.04655818f, -0.05605151f, 0.00588223f, 0.00412205f, -0.03986179f, -0.01998867f, 
    0.00537383f, 0.00823960f, 0.04607860f, -0.00156413f, 0.03823761f, -0.00450083f, 0.01508609f, 0.01379713f, 
    -0.01191191f, 0.03379623f, 0.01067775f, -0.05796055f, 0.01107402f, -0.00964278f, -0.05350874f, -0.05921862f, 
    0.03707289f, -0.04422967f, -0.00007176f, -0.04276247f, 0.03787704f, -0.00982060f, 0.01179926f, 0.04116362f, 
    -0.02200874f, -0.03255923f, -0.02322582f, -0.03336453f, -0.04568315f, 0.03942905f, -0.04625181f, -0.00926765f, 
    -0.05999572f, -0.04194114f, -0.06534912f, -0.01403206f, -0.00607354f, -0.01482809f, 0.02490018f, 0.03532523f, 
    0.03092869f, -0.05945583f, -0.05053947f, -0.02234695f, 0.03966922f, 0.03537836f, -0.04269746f, -0.01960354f, 
    0.04046966f, 0.00448634f, -0.04173279f, 0.04221756f, -0.00094259f, 0.02280779f, -0.00316584f, -0.02757288f, 
    0.02758922f, -0.04076302f, 0.00480468f, -0.01279722f, -0.05986953f, 0.01599767f, 0.02560443f, -0.05850775f, 
    -0.01210595f, 0.03362158f, -0.05362593f, -0.03171195f, 0.00185634f, 0.04460702f, -0.04174298f, -0.04258407f, 
    0.00276799f, -0.02925871f, 0.00234831f, 0.04123907f, -0.02149779f, 0.01779736f, 0.03791159f, -0.02977885f, 
    0.04464922f, -0.03683383f, 0.00634437f, -0.05446396f, -0.02892025f, 0.02803466f, 0.00490970f, -0.00956867f, 
    0.02571680f, 0.02058251f, -0.05742557f, -0.03198384f, 0.03527108f, 0.01712877f, -0.04538875f, -0.03100308f, 
    -0.04792317f, -0.04424625f, 0.02287583f, -0.02613804f, 0.00429891f, 0.00076561f, -0.02848860f, -0.05902986f, 
    0.02153893f, 0.02994828f, -0.05201287f, -0.01363240f, -0.01728583f, -0.02255278f, -0.04849445f, 0.02002221f, 
    -0.03655913f, -0.04415521f, 0.04562221f, 0.03372188f, 0.05001829f, -0.04149993f, -0.04859395f, -0.02619438f, 
    0.03725031f, 0.01472585f, -0.03164895f, 0.00500079f, -0.04188542f, 0.04371149f, -0.03357789f, 0.04635445f, 
    0.01621569f, 0.02382528f, 0.03231066f, 0.03404606f, -0.03224519f, 0.01342774f, -0.05149300f, 0.02586318f, 
    0.01104980f, 0.04317768f, 0.04604011f, -0.05143424f, 0.03363002f, -0.02345366f, 0.02617048f, -0.00524833f, 
    -0.02655504f, 0.00344292f, -0.02095236f, -0.05941608f, -0.02439351f, 0.00322565f, 0.03194689f, 0.00892288f, 
    -0.01447852f, 0.03276066f, -0.03598042f, 0.02315672f, -0.02948034f, -0.02627095f, 0.00894473f, -0.04573502f, 
    -0.00186275f, -0.03865024f, -0.00442909f, -0.00154779f, 0.02805376f, 0.02269399f, -0.04921818f, -0.03294211f, 
    -0.00930335f, -0.05924643f, 0.04092358f, -0.04414973f, -0.05803477f, -0.05514465f, -0.01283027f, -0.03843283f, 
    0.01114682f, 0.01740638f, -0.04200481f, -0.04543421f, 0.02946139f, 0.04247252f, -0.00652554f, 0.03153242f, 
    0.00353871f, -0.02362206f, -0.03534385f, -0.02766090f, 0.00398501f, -0.01841716f, 0.02503937f, -0.01750344f, 
    -0.03453398f, -0.05338722f, -0.04854686f, 0.00038695f, 0.00436561f, -0.01114390f, -0.00795272f, -0.04336074f, 
    0.00658166f, 0.04459096f, -0.06514212f, 0.01237915f, 0.00482906f, -0.02154465f, 0.01508696f, 0.02623574f, 
    0.02103356f, 0.04694099f, -0.05283064f, 0.03206486f, -0.03364300f, 0.01888279f, -0.02966050f, -0.05358963f, 
    -0.04657955f, -0.04665737f, 0.02758259f, -0.03200888f, -0.03222630f, 0.04342292f, -0.06252518f, -0.02137664f, 
    -0.00145543f, 0.03111091f, -0.04163242f, -0.05564463f, 0.04858444f, -0.00564852f, 0.01290630f, -0.00041891f, 
    -0.02523547f, -0.05079267f, 0.03743082f, -0.03235228f, 0.02219335f, -0.04961651f, 0.03809208f, -0.02954733f, 
    -0.03906663f, 0.02239120f, -0.04119058f, 0.04566148f, 0.03036651f, -0.01082772f, -0.02731373f, 0.04171804f, 
    0.36532319f, -0.00660724f, -0.20464262f, 0.18929683f, 0.07581856f, -0.03057203f, -0.10646302f, 0.01170574f, 
    0.03883059f, 0.03844605f, 0.02616196f, -0.05240079f, 0.09166372f, -0.00953309f, -0.01280775f, 0.05210566f, 
    -0.08867644f, -0.05883247f, 0.02567682f, -0.07413390f, 0.06580430f, 0.14634143f, -0.05806583f, 0.19894175f, 
    0.01835860f, -0.03223276f, 0.01096831f, 0.12338945f, 0.09992087f, 0.06030779f, -0.02770137f, 0.06971760f, 
    0.07769596f, 0.04925824f, 0.06293927f, -0.11086974f, 0.02377415f, 0.16031109f, 0.01725147f, 0.02901559f, 
    0.20306109f, -0.03426816f, -0.01530732f, -0.02678280f, -0.33183384f, -0.02402564f, 0.04242728f, 0.03042538f, 
    -0.02875206f, -0.03254410f, 0.12740299f, -0.05116373f, 0.01663745f, -0.03089693f, -0.00458516f, 0.00072604f, 
    -0.00313519f, 0.09387216f, 0.02433093f, 0.14361976f, -0.10188817f, 0.00336033f, -0.02914469f, 0.31055707f, 
    0.23968729f, 0.07000843f, 0.17669225f, 0.06778719f, 0.05059534f, -0.09605958f, 0.00031966f, 0.07650366f, 
    -0.04102669f, -0.06241482f, 0.13894895f, -0.02482955f, 0.02233738f, 0.17899115f, 0.09167442f, -0.05238434f, 
    0.03507701f, 0.07561997f, 0.07878309f, -0.01992354f, -0.07190230f, -0.10790049f, -0.04105092f, -0.02142452f, 
    -0.00603697f, -0.06742981f, 0.12886238f, -0.03929472f, 0.08064383f, 0.18394187f, -0.02526712f, 0.04066807f, 
    0.01765594f, 0.19665590f, 0.01943893f, 0.09175608f, -0.16193736f, 0.06282918f, 0.16712381f, 0.11824141f, 
    0.20354298f, -0.04769088f, 0.01275373f, 0.08034524f, -0.02831730f, -0.00307821f, 0.16697392f, -0.02337850f, 
    -0.09897735f, 0.00439561f, -0.08809202f, 0.06482863f, 0.04516818f, 0.15882279f, 0.14691384f, 0.00408368f, 
    -0.39181772f, 0.12062612f, -0.08485060f, -0.06309124f, 0.03475178f, 0.12141929f, 0.00409624f, 0.13554934f, 
    -0.02908142f, -0.10642144f, 0.09309381f, -0.06174047f, -0.04804484f, 0.05887932f, 0.03956813f, 0.07429020f, 
    0.07797781f, 0.13643649f, 0.14768012f, 0.04069609f, -0.29531214f, -0.03797044f, -0.11227292f, -0.15050839f, 
    0.01887604f, -0.00773443f, 0.07039197f, -0.14894882f, -0.00851459f, 0.11022055f, 0.09894465f, 0.21326871f, 
    0.08600406f, -0.05231990f, 0.16650227f, -0.13890795f, -0.05412152f, 0.12181701f, -0.06024488f, 0.15730330f, 
    0.15365431f, 0.06460047f, -0.06934944f, -0.06287105f, -0.33478394f, -0.03205826f, -0.08597545f, 0.02859787f, 
    0.07351705f, -0.08097762f, 0.15215105f, -0.16077049f, -0.09922293f, 0.00304588f, 0.05838372f, 0.00077920f, 
    0.04122045f, 0.07354628f, 0.18907359f, 0.05897201f, -0.54356378f, -0.06712075f, -0.08858343f, -0.07272557f, 
    0.32274243f, -0.17277423f, -0.11220619f, 0.17311910f, -0.13551092f, 0.06549194f, -0.05243542f, 0.08175159f, 
    0.13365977f, -0.03794502f, 0.07403149f, 0.14755645f, -0.02501117f, 0.01197506f, 0.13559413f, 0.05581848f, 
    -0.08957932f, 0.07576457f, 0.02029061f, 0.17376430f, 0.18061948f, 0.06937249f, 0.02538868f, 0.00002295f, 
    0.05957977f, -0.03673301f, 0.04516369f, -0.00824439f, 0.14112319f, -0.01198496f, 0.07771793f, -0.00601549f, 
    -0.09982797f, 0.01054078f, 0.04961513f, 0.02896188f, -0.46344987f, 0.30106765f, 0.08307227f, 0.18393718f, 
    0.14934106f, -0.04777398f, 0.01027613f, 0.06611364f, -0.00103981f, -0.08902127f, -0.13477045f, 0.02550624f, 
    0.05338695f, -0.06599969f, -0.00297528f, -0.01240162f, -0.02557683f, -0.20535429f, 0.11589632f, -0.11420294f, 
    -0.00907301f, 0.18494275f, 0.14764836f, 0.08938047f, -0.21496245f, 0.11077993f, 0.06810362f, -0.09808497f, 
    -0.06590048f, -0.00431164f, -0.00951069f, -0.03318293f, -0.16015434f, 0.03676981f, 0.05796395f, 0.04996986f, 
    -0.00466780f, -0.01523979f, -0.03735355f, 0.01126785f, -0.17071013f, 0.13549010f, -0.03822745f, 0.01045316f, 
    -0.11039419f, -0.03958335f, -0.04891066f, -0.05289354f, -0.03468907f, -0.06250790f, 0.12957659f, 0.04462563f, 
    0.03654978f, -0.02818427f, 0.10429613f, -0.03544949f, -0.09882212f, 0.10315350f, 0.05205231f, -0.01988198f, 
    0.24454369f, 0.48189083f, -0.33852521f, 0.14431982f, -0.30937782f, -0.05112607f, -0.03825209f, -0.01330512f, 
    -0.01248055f, 0.15068114f, -0.00133888f, -0.01521932f, 0.09310280f, -0.08993543f, -0.12955230f, -0.05235361f, 
    -0.15206696f, -0.19728048f, -0.00930470f, -0.13916670f, -0.31073174f, -0.15796819f, 0.06208082f, -0.24540463f, 
    0.09359983f, -0.15610975f, 0.02636491f, -0.01554626f, 0.00015671f, -0.08409055f, 0.06265308f, 0.09073324f, 
    0.09942216f, 0.04121754f, 0.15011418f, 0.09198984f, 0.02700946f, -0.00358009f, 0.00364286f, 0.04945773f, 
    -0.02746647f, -0.02325708f, 0.02008850f, -0.03658294f, -0.01746739f, -0.04316333f, -0.00697293f, -0.06697499f, 
    -0.04472654f, 0.03087867f, -0.01042205f, -0.04013985f, 0.04460358f, -0.04141442f, 0.00692208f, 0.00401316f, 
    -0.01806388f, 0.02670846f, 0.04916964f, 0.00103398f, 0.01757971f, -0.02230461f, -0.05288445f, -0.02092976f, 
    -0.02938216f, -0.01892860f, -0.04200286f, 0.02805883f, 0.01538159f, 0.03522540f, -0.00099164f, -0.01151862f, 
    0.00201128f, -0.05220665f, -0.02013879f, 0.00071483f, 0.01653719f, -0.05043393f, -0.00307756f, 0.04294298f, 
    -0.05361472f, -0.04173404f, 0.04433400f, 0.03799201f, -0.04579588f, 0.02855161f, 0.03743259f, -0.03670919f, 
    0.02832689f, 0.00987230f, -0.01755817f, -0.05469792f, -0.04907475f, 0.02502363f, -0.04512514f, 0.00514853f, 
    0.04340830f, -0.00483207f, -0.01126186f, 0.00696043f, -0.02387156f, 0.02241994f, 0.03449707f, -0.00291360f, 
    -0.01789390f, -0.04215884f, -0.04833940f, 0.04845204f, 0.04339780f, 0.04060592f, 0.02008936f, 0.00084622f, 
    0.02556381f, 0.03359229f, 0.03546800f, 0.01117974f, 0.01047646f, 0.00605466f, -0.02317519f, 0.02558660f, 
    -0.01031357f, -0.04148741f, -0.05144658f, -0.04943882f, 0.03746765f, -0.00416484f, 0.03733372f, 0.00210298f, 
    0.00521709f, -0.01778602f, -0.01812991f, 0.02239690f, 0.04362100f, 0.01527653f, -0.03302444f, 0.00087748f, 
    0.04110941f, -0.06335831f, 0.04646701f, 0.01520882f, -0.04946571f, 0.04147825f, -0.05297966f, -0.03215770f, 
    0.01015097f, -0.02542982f, -0.03607054f, -0.01799850f, -0.02332071f, -0.04131587f, -0.03849634f, 0.03052775f, 
    -0.05289761f, 0.02337215f, -0.06210546f, -0.05734371f, 0.00681777f, -0.02619604f, -0.03272055f, 0.03634272f, 
    0.00824164f, -0.00154923f, -0.03839420f, -0.02936935f, 0.02746207f, 0.04021082f, 0.02086755f, -0.03733687f, 
    -0.01029144f, -0.00830339f, -0.00934009f, 0.03121696f, 0.05012661f, 0.03361797f, 0.00743555f, 0.00903448f, 
    0.00725245f, 0.03091769f, -0.06041111f, 0.04542224f, 0.03845675f, -0.02750272f, -0.02975706f, 0.00744233f, 
    0.04744711f, -0.02003099f, 0.01691800f, -0.02026924f, 0.01644210f, 0.02811085f, -0.02564341f, -0.01890220f, 
    -0.01599501f, 0.04494973f, -0.02006744f, -0.01394388f, -0.00791982f, 0.03308401f, 0.02499621f, -0.04006656f, 
    -0.05664726f, 0.04602281f, 0.03047200f, 0.00626933f, -0.00758227f, 0.00109776f, -0.01327566f, 0.00341513f, 
    -0.01703237f, 0.02537078f, -0.02171139f, -0.04101108f, -0.04761557f, 0.04706816f, 0.02173224f, 0.04389454f, 
    0.02027542f, -0.01655792f, -0.00264415f, -0.00128823f, -0.00400296f, 0.02939227f, -0.00315109f, 0.01578126f, 
    -0.06150500f, -0.05182684f, 0.00511895f, -0.06448138f, 0.00853390f, 0.03773190f, -0.03165956f, -0.01688133f, 
    -0.03315419f, -0.05245021f, 0.02656315f, 0.03378705f, 0.04019477f, 0.02254446f, -0.06592347f, -0.02034379f, 
    -0.04319214f, -0.02280188f, -0.02633631f, 0.01074016f, -0.04934141f, 0.03354777f, 0.01702682f, -0.00876080f, 
    -0.01448038f, 0.03288640f, -0.04123786f, 0.03098417f, -0.06382129f, 0.01523329f, -0.02307329f, -0.01658610f, 
    0.03602509f, 0.00918778f, -0.02068717f, 0.02311943f, -0.03425914f, -0.00851482f, 0.04421607f, -0.01749079f, 
    0.00364091f, -0.06694172f, 0.04032116f, 0.02066892f, -0.04761572f, -0.03256598f, 0.02734430f, -0.03116293f, 
    -0.03149084f, 0.01249410f, 0.01141428f, -0.04283267f, -0.03053588f, 0.00850499f, 0.00197719f, -0.04672325f, 
    0.03495913f, -0.07202693f, -0.03044032f, -0.00862197f, -0.02552637f, -0.02443230f, -0.01557274f, -0.00128997f, 
    0.02173963f, 0.04175400f, -0.04324475f, 0.03014684f, -0.01622837f, 0.03864524f, -0.06115319f, 0.00344819f, 
    -0.02623370f, -0.00842579f, -0.02205187f, -0.02166277f, 0.01812916f, -0.04551002f, -0.01442823f, 0.00215790f, 
    0.03209732f, 0.01890954f, 0.01627000f, -0.04263562f, -0.05516002f, 0.01634152f, -0.00365755f, -0.06016650f, 
    0.00059533f, 0.03860972f, -0.01582640f, -0.04953577f, -0.00988104f, 0.01661422f, -0.01346320f, 0.03674372f, 
    -0.05418636f, -0.02369386f, 0.03717414f, 0.00128686f, 0.04890976f, 0.04610369f, -0.00325424f, -0.03062767f, 
    -0.03649094f, 0.04536210f, -0.00060510f, 0.02968348f, 0.01050681f, 0.05634226f, 0.00366442f, 0.04528156f, 
    -0.01831367f, 0.03377334f, 0.00492534f, -0.03555381f, -0.03530194f, 0.03503115f, -0.02972133f, -0.04470965f, 
    -0.04739937f, -0.04577614f, 0.05574454f, 0.01290337f, 0.00371283f, 0.04127046f, 0.01986795f, 0.03977653f, 
    -0.02187213f, -0.06210665f, 0.03310814f, -0.01583178f, -0.02898993f, -0.02766021f, -0.04284337f, -0.03874815f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.05991792f, 0.00687849f, 0.03644224f, -0.04021551f, -0.02057510f, -0.00053982f, 0.00654122f, -0.02694159f, 
    0.04765578f, 0.03266181f, 0.03744146f, -0.03187009f, 0.01308259f, 0.03112881f, 0.02791882f, 0.00218893f, 
    -0.06632616f, 0.00827249f, -0.07120646f, 0.03782043f, 0.04159112f, 0.00270702f, -0.07359829f, 0.10260330f, 
    -0.01627020f, 0.01414737f, -0.03474737f, 0.03657999f, 0.01355819f, -0.04485922f, 0.03074937f, 0.10692605f, 
    -0.05831040f, -0.03282985f, 0.04692385f, 0.01910041f, -0.01074169f, -0.01872688f, -0.00257702f, 0.06130260f, 
    -0.03737536f, 0.04821602f, -0.11632322f, 0.03429527f, -0.02663304f, 0.03191233f, 0.15969630f, -0.00265488f, 
    0.07992175f, 0.01032712f, -0.00142966f, 0.10159858f, 0.00708362f, 0.00304405f, 0.04023558f, 0.04875556f, 
    0.08789222f, -0.05172402f, -0.08958498f, -0.01241725f, -0.05143131f, -0.01313397f, -0.06016001f, -0.04907769f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09534097f, -0.15996303f, -0.04864020f, 0.41735151f, 0.03981569f, -0.63825142f, -0.04034911f, 0.38809216f, 
    0.10228479f, 0.01599552f, -0.01848161f, 0.03936002f, 0.10448693f, -0.35886526f, 0.02602446f, 0.10237239f, 
    -0.02797277f, -0.56333238f, -0.11726684f, 0.12634966f, -0.06973784f, -0.09687623f, 0.16142370f, -0.43266779f, 
    -0.11760458f, -0.07077543f, 0.12891640f, -0.00050563f, -0.27468127f, 0.24928860f, -0.59227395f, -0.40898293f, 
    0.00058315f, 0.20888454f, 0.17028914f, 0.10323317f, 0.05675388f, -0.01095318f, 0.12655260f, -0.27950394f, 
    0.08084767f, 0.11465050f, 0.14233808f, 0.25874484f, 0.10062622f, -0.10512771f, -0.19377764f, 0.24864936f, 
    -0.39445984f, -0.06070838f, 0.10031484f, -0.33475646f, -0.24205670f, 0.07915728f, 0.24212754f, -0.12550911f, 
    0.28948087f, -0.03976078f, 0.15452991f, 0.13733180f, 0.07217649f, 0.10155334f, -0.04535186f, 0.11176245f, 
    -0.09304564f, 0.41267774f, -0.01826403f, 0.02877926f, 0.09238058f, -0.32482630f, -0.15148598f, -0.31777373f, 
    -0.06395955f, -0.07144306f, 0.10426056f, -0.07398459f, -0.03630457f, -0.23022278f, 0.11146761f, 0.10812309f, 
    -0.12612970f, 0.07098688f, 0.36728314f, 0.26279774f, -0.01958968f, -0.11671174f, -0.07823548f, 0.20671478f, 
    -0.00045104f, -0.06145626f, -0.01681302f, -0.03024033f, -0.00723643f, 0.01738407f, 0.09821916f, -0.38266632f, 
    -0.03688449f, 0.14252840f, 0.13421288f, -0.05049346f, 0.08037729f, -0.06412930f, -0.21560411f, -0.55812079f, 
    0.00010773f, -0.00650790f, 0.06796139f, -0.00063718f, -0.12599483f, 0.24438967f, -0.21464086f, 0.30157438f, 
    -0.40956527f, 0.02366360f, 0.04403993f, 0.22743547f, -0.04506098f, 0.02234850f, -0.12144055f, -0.09215923f, 
    0.11060553f, 0.10644914f, -0.21588226f, 0.22519504f, 0.03207798f, -0.08213732f, -0.19594842f, 0.11748839f, 
    0.07775546f, -0.04539349f, 0.22100052f, -0.56783885f, -0.05435272f, 0.30012602f, -0.09411024f, -0.33655417f, 
    -0.32112408f, 0.10464303f, 0.10789929f, 0.01174066f, -0.02565228f, 0.22654702f, -0.01763361f, 0.01058119f, 
    -0.03640868f, 0.28178439f, 0.25770429f, 0.22137752f, 0.03709530f, -0.10465907f, 0.08436588f, -0.53246260f, 
    0.11891831f, 0.02553643f, 0.34896690f, 0.06332490f, 0.21955463f, 0.25550038f, 0.07976313f, -0.57624924f, 
    0.04235448f, -0.02178363f, -0.51316088f, -0.10511065f, -0.10459340f, -0.12162483f, 0.13051367f, -0.34496936f, 
    0.01230507f, 0.04693095f, 0.24352959f, -0.01370053f, -0.07266480f, -0.06128957f, 0.19879384f, -0.15317880f, 
    -0.21770054f, 0.05963293f, 0.07173341f, -0.58651012f, -0.61712909f, 0.09445083f, -0.42604661f, -0.27962548f, 
    0.07962537f, 0.11819045f, -0.11772590f, -0.20105976f, -0.05603293f, -0.03177381f, 0.16837077f, 0.03721189f, 
    -0.08853973f, 0.06422175f, -0.24370493f, -0.25223574f, 0.11288659f, 0.22808355f, 0.36794344f, 0.29265755f, 
    0.27146283f, 0.05543229f, -0.00458208f, 0.03588978f, -0.11403331f, -0.32116443f, -0.09292080f, -0.09300361f, 
    -0.17172529f, 0.08670428f, -0.34142524f, -0.03426623f, 0.10418802f, 0.02733380f, -0.44691315f, 0.23682444f, 
    0.10695183f, -0.08732358f, -0.12218535f, -0.06325740f, -0.50084984f, 0.02030575f, 0.20258525f, 0.32847589f, 
    0.03225779f, 0.23151983f, 0.25926474f, -0.09657419f, 0.10495562f, 0.07967550f, -0.45063633f, 0.03664162f, 
    -0.06095680f, 0.00201697f, 0.06788678f, -0.14538687f, -0.05363100f, -0.34390336f, -0.17641786f, -0.06280284f, 
    0.12214097f, -0.05617440f, -0.08298709f, -0.43670744f, 0.28662559f, -0.03539446f, -0.11761300f, -0.19563034f, 
    -0.31422436f, 0.11296156f, 0.09340406f, -0.02675568f, -0.01909112f, 0.01785427f, 0.27903631f, -0.06457968f, 
    0.10187571f, -0.23903336f, -0.13405061f, -0.33448225f, -0.04718243f, -0.17180441f, 0.28073058f, 0.14318354f, 
    -0.17787588f, 0.09489023f, -0.09699521f, -0.08819298f, -0.00324056f, 0.10359374f, 0.02838628f, 0.02113145f, 
    0.05837820f, 0.07935442f, -0.13388227f, -0.22457242f, -0.09557427f, 0.04701189f, 0.15806884f, -0.41736311f, 
    0.06300445f, -0.01647255f, -0.33058202f, -0.07860799f, -0.25454974f, 0.20127471f, 0.24043655f, 0.07211144f, 
    -0.10855485f, -0.45202556f, -0.19354849f, 0.00661217f, -0.09232402f, -0.03274456f, -0.08430500f, 0.32327884f, 
    0.05156479f, 0.01426711f, -0.10278749f, 0.19596051f, -0.00232998f, 0.16004582f, -0.20857790f, 0.12977487f, 
    -0.24777038f, -0.10666882f, -0.11939238f, 0.26052567f, 0.34147450f, -0.10661819f, 0.24015456f, 0.16270526f, 
    0.05545616f, -0.10637836f, 0.03794624f, 0.09743067f, 0.05150345f, 0.00412766f, 0.23661622f, -0.08727598f, 
    0.09912728f, 0.06987607f, -0.41033444f, 0.19034477f, 0.08156253f, -0.17101647f, -0.16451104f, -0.41249582f, 
    0.24634922f, -0.10456047f, -0.00994621f, 0.01934158f, 0.00089614f, 0.03164175f, -0.01426106f, -0.09941849f, 
    -0.10077967f, -0.11490192f, -0.04572159f, -0.17412281f, -0.10319479f, 0.10114694f, 0.06760284f, 0.37470272f, 
    -0.08912244f, 0.09296548f, -0.44981363f, -0.06929348f, 0.27035278f, 0.08889540f, -0.33668378f, 0.16699570f, 
    -0.06354974f, -0.43384832f, 0.11380250f, 0.07370571f, 0.00435888f, 0.09667317f, 0.27447301f, -0.24289167f, 
    -0.01748214f, -0.02600413f, -0.19877458f, 0.34737936f, 0.06738475f, -0.25552949f, 0.30166596f, 0.22427072f, 
    -0.15516940f, -0.07891268f, -0.02709772f, 0.16012916f, 0.05758144f, 0.04554091f, 0.27903584f, 0.04050726f, 
    0.02079459f, 0.09428722f, -0.43952885f, 0.07369313f, 0.05585449f, 0.02100620f, 0.15479462f, 0.07687760f, 
    -0.11595082f, -0.16682714f, -0.06268644f, -0.35040563f, -0.06629815f, 0.28466254f, -0.43129128f, -0.57585371f, 
    -0.13086921f, 0.05296444f, -0.07754818f, 0.05813219f, 0.00515965f, 0.48004591f, -0.06584891f, 0.09160697f, 
    -0.11219421f, -0.62795597f, -0.29693195f, 0.15682569f, 0.09879207f, 0.08409683f, 0.23809066f, -0.04330652f, 
    -0.04416890f, 0.08447634f, 0.06499998f, -0.09206332f, -0.22570999f, -0.02551720f, 0.00448762f, 0.04814529f, 
    -0.00118201f, 0.50598204f, -0.07648878f, -0.08945281f, 0.00002247f, 0.06373075f, 0.11727320f, 0.20762721f, 
    0.01867739f, 0.07552762f, -0.11171558f, -0.80209202f, -0.06837664f, 0.21661714f, 0.13372469f, -0.04466328f, 
    0.12649591f, 0.03877593f, 0.00421641f, 0.00887267f, -0.32814065f, 0.06331474f, 0.12073079f, 0.10486482f, 
    0.16947402f, 0.00525293f, -0.43825740f, 0.05385026f, -0.05192907f, -0.11694164f, 0.21443234f, -0.01077722f, 
    -0.05359890f, -0.25555924f, -0.19027293f, 0.17095859f, 0.11267002f, 0.25309622f, -0.05359124f, 0.23769273f, 
    0.02528337f, -0.05369934f, 0.03466772f, -0.03279580f, 0.01162038f, 0.11057521f, 0.05242620f, -0.09606904f, 
    -0.12691176f, -0.25605112f, 0.28136998f, -0.36455458f, 0.06075065f, -0.09730943f, 0.27352658f, -0.12075806f, 
    0.08162694f, 0.06517861f, 0.01778423f, 0.03719967f, 0.24850993f, -0.33214232f, 0.18801564f, -0.12400699f, 
    -0.11850213f, 0.15751587f, -0.26752558f, -0.08308397f, -0.11348488f, 0.12185849f, 0.18604879f, 0.05556057f, 
    -0.08947396f, 0.03368254f, -0.30660483f, 0.05202954f, 0.00767269f, -0.44592807f, -0.18904595f, -0.47330761f, 
    0.32056266f, -0.06233108f, -0.12896283f, -0.29075244f, 0.25425047f, 0.05504199f, -0.44970864f, -0.09501036f, 
    -0.59974682f, 0.05690657f, 0.15702017f, 0.20066427f, -0.05904539f, -0.08389979f, -0.32317033f, 0.03220905f, 
    -0.02834481f, 0.15092401f, 0.24260172f, -0.16031367f, -0.12090877f, -0.07861942f, -0.44474325f, -0.14574577f, 
    0.08512526f, 0.04575752f, 0.05513212f, -0.00825353f, -0.04781590f, 0.32326454f, -0.08125534f, -0.00019261f, 
    0.06144101f, 0.30994347f, 0.24837311f, 0.15109247f, -0.02993004f, 0.13049392f, -0.21484999f, 0.34004119f, 
    0.02713235f, -0.06374792f, -0.44459045f, -0.11181582f, 0.14068289f, -0.32932034f, 0.18385616f, -0.20693140f, 
    0.08894258f, -0.31222093f, -0.54999024f, -0.07384691f, 0.02973907f, 0.08994085f, 0.12748556f, -0.15889220f, 
    -0.10504890f, 0.00446381f, 0.27893162f, -0.08206200f, 0.02974074f, -0.59406811f, -0.39502132f, -0.02109783f, 
    -0.20538512f, -0.08017612f, -0.07349166f, 0.15388542f, -0.22705105f, -0.09882571f, -0.17327489f, 0.24005498f, 
    -0.26582694f, -0.10785069f, 0.17236950f, -0.15831663f, 0.09542951f, -0.04205324f, 0.25040671f, -0.12435160f, 
    -0.01889494f, -0.20060866f, 0.12384395f, -0.18560113f, 0.12344515f, -0.15253840f, 0.12071680f, -0.15207285f, 
    -0.72029632f, -0.07431625f, 0.03556444f, 0.04101681f, 0.09852333f, -0.47741860f, -0.01077386f, -0.06209689f, 
    0.03106846f, -0.24778025f, 0.03923766f, -0.12543750f, -0.00713061f, -0.08760011f, 0.13933659f, 0.14961176f, 
    -0.00318608f, -0.04253995f, 0.41065887f, -0.01460457f, 0.00734885f, -0.30545548f, -0.10192642f, -0.02617753f, 
    -0.03551576f, -0.26964453f, 0.20636737f, -0.11630115f, -0.05160123f, -0.07292023f, 0.20188613f, 0.10097659f, 
    0.02256584f, -0.04772205f, 0.06011936f, 0.06996448f, -0.01454485f, 0.21719262f, 0.29477736f, -0.36863494f, 
    0.34168559f, 0.03255892f, 0.11105110f, 0.23424760f, -0.26511091f, -0.03875027f, 0.18471038f, 0.23726641f, 
    0.00598807f, 0.01135613f, 0.37308323f, -0.57147044f, 0.09649344f, 0.11089940f, -0.31150490f, -0.00370804f, 
    -0.08130001f, 0.08983959f, 0.39380229f, 0.10314420f, -0.02451502f, 0.33491695f, 0.05992891f, -0.00452746f, 
    0.22583720f, 0.02209358f, -0.08188668f, 0.03423786f, -0.00024236f, -0.02456783f, -0.09759309f, 0.09752335f, 
    0.05234567f, 0.29270077f, -0.65867484f, 0.13592845f, -0.06064609f, -0.04994515f, -0.24115729f, -0.01291721f, 
    0.00724036f, 0.02916043f, 0.40423712f, 0.07267352f, -0.47663221f, -0.75310570f, 0.24013571f, -0.12657252f, 
    -0.10206284f, -0.05994843f, -0.24624106f, -0.03739014f, 0.01540778f, -0.05125151f, -0.48230082f, -0.28183526f, 
    -0.11380737f, -0.01389279f, -0.59073246f, 0.28771013f, -0.11607189f, -0.16207404f, 0.45968255f, -0.06105411f, 
    -0.07270072f, 0.07681967f, 0.08789725f, 0.18193623f, 0.09926891f, -0.07247222f, -0.25305164f, 0.00457118f, 
    0.11663084f, 0.08515298f, -0.12283779f, 0.23434953f, -0.02894262f, -0.00918647f, -0.47075009f, -0.09804129f, 
    0.06119426f, -0.62748158f, 0.23157927f, 0.35033852f, -0.08358628f, -0.01712997f, -0.02356338f, -0.00509243f, 
    0.32582200f, -0.07082259f, 0.11906454f, 0.10570227f, -0.03641019f, 0.21157169f, 0.07115065f, 0.05553237f, 
    -0.07906967f, 0.20761454f, 0.11132488f, -0.06003749f, 0.02720111f, -0.03916646f, -0.30380803f, -0.01501655f, 
    0.03286916f, 0.06653183f, -0.30358380f, 0.02549354f, 0.38606718f, 0.34430692f, -0.10823689f, 0.38903770f, 
    0.00301329f, 0.10244671f, -0.01165644f, -0.07493047f, -0.11410233f, 0.10372375f, -0.31288412f, 0.24112144f, 
    -0.05457264f, -0.06605054f, -0.08744505f, -0.42241034f, 0.03724988f, 0.10284276f, 0.08356448f, -0.23255192f, 
    0.28325057f, 0.01078117f, -0.01436508f, 0.11047570f, -0.23337367f, -0.11132444f, -0.01592429f, -0.26597649f, 
    -0.22796912f, -0.06088839f, -0.08218112f, -0.28519055f, -0.00246233f, -0.09134118f, -0.23179935f, 0.07900763f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00319835f, 0.09239830f, -0.02105412f, 0.08224105f, -0.08303890f, -0.10754076f, 0.01300080f, -0.05519828f, 
    0.04918147f, -0.04787187f, 0.04023172f, -0.04227854f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
