#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.42990229f, 0.07227733f, 0.15801422f, -0.87575370f, -0.62471569f, 0.16852191f, 0.06639276f, -0.08672973f, 
    0.11536212f, 0.50880343f, 0.08296052f, -0.20779195f, -0.47603306f, -0.61427915f, 0.28521937f, 0.08322103f, 
    0.23827869f, 0.38576838f, 0.35061181f, -0.21204814f, -0.14339742f, 0.02014379f, -0.27575725f, -0.47580341f, 
    -0.45154130f, 0.58092153f, -0.52824861f, -0.88868368f, -0.75535733f, -0.77345598f, 0.28845233f, 0.04306882f, 
    0.24134682f, 0.48328093f, 0.41281781f, 0.17267919f, 0.02869509f, 0.16763385f, -0.15572448f, 0.14344053f, 
    0.03978387f, -0.01900367f, 0.18820262f, -0.27488393f, -0.07037983f, -0.06541507f, -0.18727753f, -0.23921074f, 
    -0.12416372f, 0.31660584f, -0.48500115f, -0.65388411f, -0.34825829f, 0.03699738f, -0.11154108f, -0.71830779f, 
    -0.74849302f, -0.62118202f, -0.17252950f, -0.73781759f, 0.30760100f, 0.21686092f, 0.29544866f, 0.33374566f, 
    -0.13943453f, 0.02342968f, -0.09043879f, -0.25481713f, 0.02301284f, 0.11736851f, 0.15148754f, 0.06747162f, 
    -0.09702921f, -0.17710719f, 0.43535116f, 0.49896708f, -0.46741503f, -0.37229604f, 0.24258649f, 0.72978783f, 
    0.02548768f, 0.67874098f, -0.02438275f, -0.57975703f, -0.55471784f, -0.06622299f, 0.00896241f, 0.13992697f, 
    -0.38375077f, -0.12477384f, 0.05364842f, -0.05224324f, 0.06175855f, 0.13136452f, -0.18350542f, 0.14281066f, 
    -0.15032141f, -0.07942437f, 0.12085963f, -0.00948135f, -0.78260326f, -0.76921588f, -0.16169666f, 0.12700416f, 
    0.31659168f, 0.88696289f, -0.49249047f, -0.14720280f, 0.52153832f, 0.74689651f, 0.17215513f, -0.13547963f, 
    -0.20092022f, -0.03095825f, -0.19478956f, -0.23812275f, -0.02917167f, 0.03052654f, 0.04620925f, -0.14071392f, 
    0.08815403f, 0.17864062f, 0.19930428f, -0.00228152f, 0.14028126f, 0.21767204f, 0.25938672f, -0.59933531f, 
    -0.36287189f, 0.55508208f, 0.02586473f, -0.14018846f, -0.03523602f, -0.05370706f, -0.56037545f, 0.20435528f, 
    0.03060176f, 0.27051625f, -0.39770198f, -0.07748974f, 0.14931150f, 0.21181293f, -0.03158154f, -0.35296011f, 
    -0.29818049f, -0.15153262f, 0.21941800f, 0.41778257f, 0.22951250f, 0.35848099f, -1.18457448f, -0.01654913f, 
    0.00248758f, -0.18102889f, -0.04479893f, 0.29492992f, 0.14356194f, 0.40725651f, 0.16457985f, 0.06458224f, 
    -0.01059625f, 0.38064504f, -0.27847460f, 0.67157608f, -0.18702021f, -0.25525436f, -0.37053144f, -0.13927327f, 
    -0.05056473f, 0.12870875f, 0.12589699f, 0.39806640f, -0.00508942f, 0.14071245f, -0.07115223f, -0.48532152f, 
    -0.19946410f, 0.32895437f, 0.12405738f, 0.42751110f, 0.30234194f, 0.57540590f, -0.05143868f, 0.01853228f, 
    0.13394034f, -0.18144947f, 0.31878844f, 0.39881140f, -0.37558946f, -0.11236735f, 0.05635770f, -0.04512222f, 
    -0.02804567f, -0.16399677f, -0.20179725f, 0.01675595f, 0.12434613f, 0.04192937f, -0.31076264f, 0.13543831f, 
    0.60213256f, -0.95920169f, -0.94939423f, -0.38628772f, -0.80600035f, 0.61651081f, 0.35092717f, 0.52261388f, 
    -0.28510830f, 0.12416889f, -0.46566045f, -0.28285930f, -0.09973478f, 0.04500890f, 0.21112739f, -0.53042138f, 
    -0.18149754f, 0.05683623f, 0.01333435f, -0.22154203f, 0.14946696f, -0.03910792f, 0.00921285f, 0.16748922f, 
    -0.23649280f, -0.24376115f, 0.41073656f, 0.22175887f, -0.09654883f, 0.12931566f, -0.66018558f, -0.40047723f, 
    0.64966947f, 0.26255262f, 0.03219249f, -0.30387542f, 0.17103721f, 0.05317955f, 0.47293496f, -0.23814540f, 
    -0.02419835f, -0.04873999f, -0.53360218f, 0.15500273f, 0.09355615f, 0.20422517f, -0.33444121f, -0.00317824f, 
    0.28751636f, -0.20590352f, 0.15373501f, 0.19047543f, -0.23099560f, -0.38618088f, -0.45959765f, -0.57212025f, 
    0.00798780f, -0.14134233f, -0.02009174f, -0.39405045f, 0.42956835f, 0.52720922f, 0.32837445f, -0.26412186f, 
    -0.02137121f, -0.18843119f, -0.00516486f, -0.25871947f, -0.03973042f, -0.07129242f, -0.29593623f, 0.05384320f, 
    -0.20795448f, -0.37351182f, -0.34897482f, 0.66485804f, 0.50502443f, 0.37431848f, 0.13475692f, -0.09670081f, 
    0.05567234f, 0.25305489f, 0.11777826f, -0.06257585f, 0.08972509f, 0.34717727f, -0.09958094f, -0.03901290f, 
    0.26812246f, -0.38169762f, -0.10661835f, -0.01739148f, -0.01061864f, -0.01572941f, -0.10689171f, 0.01992290f, 
    0.05296855f, 0.09058883f, 0.03704382f, 0.03935032f, 0.50054348f, 0.21950716f, 0.49521679f, -0.56738025f, 
    0.21921377f, -0.55153292f, 0.00265107f, -0.24282099f, -0.27173907f, 0.49792916f, -0.14025813f, -0.03505178f, 
    0.07922883f, 0.10577690f, 0.01614775f, -0.12420564f, -0.37511885f, 0.22312191f, 0.22245340f, 0.12015624f, 
    -0.24238543f, 0.28312835f, -0.06431258f, 0.00009687f, -0.00680679f, 0.84523320f, -0.37297705f, -0.10106926f, 
    0.26270339f, 0.20009504f, -0.07787166f, 0.31607807f, -0.02539020f, 0.22595502f, 0.29264319f, -0.31152913f, 
    0.26745841f, -0.24117267f, -0.17220835f, -0.07030620f, -0.02528532f, -0.13091457f, -0.01322174f, 0.00932967f, 
    -0.26160395f, -0.36498052f, -0.20961417f, -0.35104781f, -0.32864267f, -0.28052145f, 0.95244026f, 1.16057372f, 
    0.06429154f, -0.38449797f, -0.90453774f, -0.43324703f, 0.10860928f, 0.29017124f, -0.23344386f, -0.51132941f, 
    -0.09100709f, -0.02547959f, 0.27042249f, -0.08853115f, -0.08680675f, 0.32899830f, 0.11878318f, 0.25938317f, 
    0.02751545f, -0.57313418f, -0.11032847f, -0.05375403f, -0.39256054f, -0.15433545f, -0.00058929f, -0.08999123f, 
    -0.43621567f, 0.00329308f, -0.11890694f, -0.82495904f, -0.05529137f, -0.49674547f, -0.51892948f, -0.59322536f, 
    -0.46736330f, -0.27180457f, -0.26478142f, -0.22195211f, -0.38652813f, -0.32624152f, -0.14966281f, -0.28616560f, 
    -0.11146621f, -0.04566845f, -0.25620219f, -0.27304661f, 0.03922838f, -0.19251460f, -0.08685926f, 0.05731829f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.17425323f, 0.18681361f, 0.09027758f, 0.24428970f, 0.09311023f, 0.40253991f, 0.09634633f, 0.35974810f, 
    0.25417191f, 0.43934131f, 0.05011452f, -0.13195585f, 0.22637133f, 0.12963817f, 0.46968931f, 0.10008127f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05769381f, -0.11639608f, 0.11543600f, 0.24745204f, 0.18038943f, 0.25758198f, -0.14416870f, -0.15554729f, 
    0.03602660f, 0.07987665f, 0.11744239f, -0.10093307f, 0.07900953f, 0.41909608f, 0.01583760f, 0.29506728f, 
    -0.00394345f, 0.03954541f, 0.05725431f, -0.16912723f, 0.13726996f, 0.04478539f, -0.08088982f, 0.12133861f, 
    -0.22147270f, -0.19949740f, -0.24243306f, 0.11060179f, -0.22369683f, -0.05429525f, -0.07755878f, 0.13252127f, 
    -0.03806804f, 0.01720301f, 0.07409078f, -0.00801736f, 0.25995103f, 0.24299061f, -0.07298721f, 0.47743991f, 
    -0.14640386f, -0.08041496f, -0.03981855f, -0.23879986f, 0.14216839f, -0.11218884f, 0.12872559f, -0.04585376f, 
    -0.08542519f, 0.06189169f, -0.36523128f, -0.24824584f, -0.14244860f, -0.05722527f, -0.09898230f, 0.09046927f, 
    0.01464168f, 0.04878549f, 0.01850317f, 0.00223137f, -0.01445023f, -0.22696193f, 0.10895722f, 0.03221311f, 
    0.02556652f, 0.06917229f, 0.10314527f, 0.01331964f, 0.02903561f, 0.08129688f, 0.10158630f, -0.05953123f, 
    -0.17377293f, -0.07871106f, -0.05470299f, -0.01671513f, -0.14572875f, -0.16879314f, -0.02788711f, -0.02370068f, 
    -0.14011280f, -0.10630058f, 0.07947298f, 0.12960073f, 0.18760991f, 0.00792694f, -0.00841250f, -0.13434157f, 
    -0.10770017f, -0.09553690f, -0.03052860f, 0.04282796f, 0.13860552f, 0.09400713f, -0.10398066f, -0.02135870f, 
    -0.13483970f, 0.17649937f, 0.53588551f, 0.36389193f, -0.11684266f, 0.15579094f, 0.14621978f, 0.05709836f, 
    0.08799312f, -0.10360166f, 0.11900349f, 0.14991267f, 0.17389713f, 0.00579008f, -0.06835227f, -0.24794415f, 
    -0.04486438f, 0.09307240f, -0.07340285f, 0.15346892f, -0.09370875f, 0.01010446f, 0.11142769f, 0.10284305f, 
    -0.04357752f, -0.16923419f, -0.10626686f, 0.00312872f, 0.05922095f, 0.13330919f, -0.01977178f, 0.12388269f, 
    0.07340556f, 0.15346155f, -0.11401352f, 0.09095499f, -0.02125924f, 0.15593652f, 0.01710908f, -0.23153794f, 
    -0.10678811f, -0.13739677f, -0.10848785f, -0.11242954f, -0.19783284f, -0.14039466f, 0.15983544f, -0.11089293f, 
    0.51196611f, -0.14372414f, 0.41046399f, -0.16043463f, -0.01314502f, 0.05510692f, -0.22374412f, 0.07366114f, 
    -0.03236951f, -0.04019544f, 0.06742298f, -0.10809958f, 0.13443708f, 0.19148637f, -0.07861393f, -0.08386397f, 
    0.00359545f, 0.01523097f, -0.09016547f, -0.14413960f, -0.04670712f, 0.26327336f, 0.21126746f, 0.19210020f, 
    -0.04143519f, -0.11981689f, 0.21470858f, -0.25616151f, 0.11738215f, 0.06470577f, -0.04153461f, -0.02289605f, 
    -0.11466493f, -0.14753748f, -0.05025905f, 0.22926933f, -0.25614437f, -0.09223718f, -0.01178014f, 0.24719580f, 
    0.09273414f, 0.17958355f, -0.06041273f, -0.04441623f, -0.05726291f, -0.05791619f, 0.03850310f, 0.01820588f, 
    -0.04263359f, -0.05251137f, 0.05458165f, -0.20716946f, -0.01428785f, 0.07691320f, -0.01464152f, 0.07430610f, 
    -0.16063239f, -0.01718387f, -0.16594528f, -0.32810530f, 0.15346515f, 0.38475850f, -0.09809507f, -0.04358110f, 
    0.11181094f, 0.02440617f, 0.06978595f, -0.07142457f, 0.19185358f, 0.09844062f, 0.10403254f, -0.03156570f, 
    -0.52577573f, -0.28138056f, -0.37003040f, -0.22661711f, -0.16140652f, 0.02944477f, -0.14407746f, -0.08999054f, 
    -0.10528192f, 0.02433590f, 0.06133500f, -0.00069823f, 0.21049491f, 0.17986749f, 0.18665537f, 0.41724759f, 
    -0.20144419f, 0.02061374f, 0.03553716f, 0.04632278f, -0.04199376f, 0.03654260f, 0.05697272f, 0.04205808f, 
    -0.43504497f, 0.21850161f, -0.16705222f, 0.46885723f, -0.01602992f, -0.10842113f, -0.23214336f, -0.03835538f, 
    -0.11578771f, 0.09618469f, 0.18630676f, 0.04202092f, -0.14783676f, -0.13533701f, -0.10195497f, -0.04738244f, 
    -0.06644766f, 0.21191105f, 0.23349708f, 0.14470537f, -0.04246614f, 0.14542161f, 0.16019791f, 0.11771785f, 
    -0.32273003f, -0.09329361f, 0.16262855f, 0.00959194f, -0.08002786f, -0.10932026f, 0.10002384f, 0.11446437f, 
    -0.06336313f, 0.00793817f, 0.15160166f, -0.04276498f, 0.02349527f, -0.11976276f, 0.09224934f, 0.12981275f, 
    -0.08477879f, 0.00606383f, -0.01322347f, 0.03293781f, 0.19260168f, 0.34778059f, 0.19583839f, 0.20700751f, 
    0.31097722f, 0.24072912f, 0.28768927f, 0.06381081f, -0.07585119f, 0.08412658f, 0.08551176f, 0.14867263f, 
    -0.03972001f, -0.05101331f, 0.05244962f, -0.11710271f, 0.19029750f, 0.09581823f, 0.35901791f, 0.21378195f, 
    0.03013264f, 0.22238299f, 0.07707142f, 0.10311135f, 0.09163950f, 0.04052200f, 0.27677342f, 0.21044119f, 
    -0.15982760f, -0.11443812f, 0.06473038f, -0.08868703f, -0.05581731f, -0.03038845f, -0.03015727f, 0.10775258f, 
    -0.07295774f, 0.12981658f, -0.07729776f, -0.01761856f, 0.15189168f, 0.06909718f, 0.08953561f, -0.03089545f, 
    -0.10686120f, -0.13331793f, 0.01199068f, -0.08679394f, -0.11524230f, 0.06058698f, 0.12814119f, 0.09493378f, 
    0.46000907f, 0.12188778f, 0.34890109f, -0.01951723f, -0.01868646f, 0.04240868f, -0.00147195f, 0.19484967f, 
    0.01649299f, 0.13693428f, 0.06036616f, -0.05577642f, 0.00529938f, 0.28096160f, 0.02549327f, -0.03209798f, 
    -0.08649896f, -0.01339940f, -0.15526427f, -0.01040231f, -0.07492963f, 0.09921117f, -0.05428169f, -0.17718066f, 
    0.05837573f, -0.37318978f, 0.24336942f, -0.30348730f, 0.09235732f, 0.05701948f, 0.28156811f, 0.11166521f, 
    0.04029638f, -0.00741320f, -0.02836926f, 0.13721243f, -0.08471427f, -0.13713922f, -0.19193868f, 0.01164346f, 
    0.01349453f, 0.16465656f, -0.02905972f, -0.06055990f, 0.06466061f, 0.11250167f, -0.03858173f, -0.04504699f, 
    0.05136235f, -0.04177215f, 0.10209318f, -0.05903292f, -0.07964114f, 0.16866511f, 0.16219302f, -0.12535997f, 
    0.29185215f, 0.15112393f, 0.22569010f, 0.16568911f, 0.08181545f, 0.29299337f, 0.25195181f, -0.09079266f, 
    -0.06610680f, -0.02688975f, -0.06987847f, -0.07725797f, 0.00497113f, 0.17635636f, 0.01268725f, -0.09349041f, 
    -0.49868280f, -0.20088398f, -0.18296635f, -0.24680963f, 0.00382190f, -0.36519963f, -0.15006492f, -0.12865949f, 
    0.04589055f, -0.11980442f, 0.01497228f, -0.04550246f, -0.11656162f, -0.02269317f, 0.23530918f, 0.07713260f, 
    0.18614125f, -0.07103869f, 0.03528853f, 0.03911462f, -0.07862397f, 0.16873004f, -0.05448493f, 0.13598087f, 
    -0.03938939f, -0.02533756f, 0.02718973f, 0.44889086f, 0.14616062f, -0.05790364f, -0.16904473f, 0.06945415f, 
    -0.06339631f, -0.05725893f, 0.00193985f, -0.18323767f, -0.06796774f, -0.03052920f, 0.14583059f, -0.10816795f, 
    -0.12490521f, -0.27566835f, 0.10074899f, 0.11686715f, -0.15825267f, 0.03116931f, -0.23216876f, -0.18174031f, 
    -0.18842392f, 0.03922442f, 0.13398601f, 0.22824627f, -0.01996611f, -0.14591004f, -0.11473085f, -0.14880942f, 
    -0.10681750f, -0.30492005f, -0.19065563f, 0.12424757f, 0.04453451f, 0.05171932f, 0.02855176f, 0.19493659f, 
    0.00705703f, 0.11666114f, 0.00630572f, 0.01490295f, 0.12817293f, 0.21738118f, -0.01563088f, -0.02032222f, 
    -0.04042394f, -0.12412035f, 0.01078711f, -0.24257760f, -0.16682754f, -0.19624734f, -0.03899133f, 0.02239111f, 
    -0.17965935f, 0.01332347f, 0.08753449f, 0.22661541f, 0.02074098f, 0.14753273f, 0.04837060f, 0.03748159f, 
    -0.03341122f, 0.10556602f, 0.01615400f, -0.00017404f, 0.07847067f, -0.12947990f, 0.09838321f, 0.09526645f, 
    -0.14875367f, 0.00094295f, 0.12622134f, -0.20054990f, 0.05165220f, 0.01816583f, 0.04525658f, 0.10968571f, 
    0.03629155f, 0.14326164f, 0.09276123f, 0.28071287f, 0.11014831f, -0.10411916f, 0.06778826f, -0.03379481f, 
    -0.04054952f, 0.03887012f, 0.12137062f, 0.04388715f, 0.03902258f, -0.01555238f, -0.02912953f, -0.15711641f, 
    0.34029466f, 0.14171614f, 0.01560571f, -0.09400082f, 0.01484210f, 0.08236569f, 0.04982327f, -0.04008666f, 
    -0.07599994f, -0.03613736f, -0.02396505f, 0.02104501f, 0.00851538f, 0.09587225f, 0.06273918f, 0.06822408f, 
    0.06274554f, 0.01252789f, 0.07390866f, -0.00571127f, 0.13888024f, 0.25821936f, 0.29690570f, 0.16853821f, 
    0.21198194f, 0.02420003f, 0.12153358f, -0.30657431f, 0.00329564f, -0.09924985f, 0.33560434f, 0.08151171f, 
    0.13787837f, 0.18256466f, 0.03848472f, 0.14346370f, -0.03949855f, -0.14756936f, 0.04558692f, 0.00310202f, 
    -0.06641230f, 0.01090041f, 0.15792637f, 0.04013720f, 0.05279438f, 0.05416001f, -0.00219622f, -0.05660211f, 
    -0.26230401f, -0.19147374f, 0.02101063f, -0.04231483f, 0.02685112f, 0.23047382f, -0.04419549f, 0.16450506f, 
    -0.08320708f, -0.05609609f, 0.11177532f, -0.29676810f, 0.08163313f, -0.12948832f, 0.02188615f, 0.20054476f, 
    0.11405282f, -0.05069567f, 0.21539271f, 0.07353832f, 0.14339824f, 0.08485335f, -0.02903553f, 0.22182594f, 
    0.08551403f, -0.24915658f, 0.06619664f, -0.02474437f, 0.00209922f, 0.17856389f, 0.16860311f, -0.22775666f, 
    -0.02934340f, -0.01998294f, 0.05998053f, 0.05443166f, -0.10781839f, -0.20498919f, 0.19415522f, -0.20247854f, 
    0.01357550f, -0.00286477f, -0.02612568f, 0.04129722f, 0.01744554f, 0.11141040f, -0.05375642f, -0.04549447f, 
    -0.03356079f, -0.27176356f, 0.16745387f, 0.09212531f, -0.15124789f, -0.17104326f, 0.02960095f, 0.11459012f, 
    0.03564008f, 0.15895407f, 0.05005291f, 0.17516394f, -0.22479576f, -0.09139185f, -0.04027995f, -0.10590424f, 
    0.15951370f, 0.00376698f, 0.01035981f, 0.01649078f, 0.16886958f, 0.00666430f, -0.04082283f, 0.00869411f, 
    -0.28269833f, -0.16555604f, 0.06173624f, 0.06664351f, -0.04607276f, 0.07807571f, -0.04009779f, -0.03313724f, 
    0.20922719f, 0.12066857f, 0.07231935f, 0.08627476f, 0.17069566f, 0.02509890f, 0.15266846f, 0.00351490f, 
    -0.01722786f, -0.10025387f, -0.04555549f, 0.00610963f, 0.23671053f, 0.18055575f, 0.15015979f, 0.13388720f, 
    -0.09398680f, -0.32127082f, -0.11416261f, -0.02575285f, 0.16139318f, 0.11568912f, -0.04866895f, 0.04001169f, 
    0.14883095f, 0.01989015f, -0.02560074f, 0.05323803f, 0.21414950f, 0.20186198f, -0.27275184f, 0.21461084f, 
    0.17026941f, -0.13699684f, 0.14458703f, 0.06616516f, -0.08178241f, -0.08602303f, 0.01561880f, -0.09981358f, 
    0.10966446f, 0.28378883f, -0.09459674f, -0.00991744f, -0.08743750f, 0.00468707f, 0.04498966f, -0.05916495f, 
    -0.11289791f, -0.09784518f, 0.01534608f, -0.14511348f, -0.12054918f, 0.07889024f, -0.06863667f, -0.15692177f, 
    0.07337090f, 0.02515287f, -0.05285234f, -0.05586840f, 0.04886850f, 0.00622560f, -0.03605851f, 0.05957675f, 
    -0.10837548f, -0.33951771f, -0.04887485f, 0.18556008f, 0.26187378f, -0.00671374f, 0.01066144f, 0.10821304f, 
    -0.02374200f, -0.02046969f, -0.17081043f, 0.32423773f, 0.12584491f, -0.05570291f, -0.00036036f, -0.09597489f, 
    -0.08411415f, -0.04042457f, 0.07678390f, -0.15848893f, 0.15290970f, 0.01304077f, 0.12135453f, -0.05129505f, 
    -0.08052594f, 0.29300570f, -0.46476832f, 0.01592893f, 0.08197531f, 0.16835018f, 0.10189430f, 0.08757672f, 
    -0.14945795f, 0.02291539f, -0.06860033f, -0.04608388f, 0.11543737f, -0.03556123f, 0.11909761f, -0.15703276f, 
    0.04887962f, -0.04937842f, 0.07710092f, -0.21505424f, 0.02608353f, 0.07761982f, 0.09253178f, 0.08709402f, 
    -0.16904895f, 0.24209933f, -0.05503422f, -0.00097421f, 0.08570667f, 0.03162456f, 0.06004218f, 0.07633336f, 
    -0.00746024f, 0.01079406f, 0.12770793f, -0.06320789f, 0.18454090f, -0.03636687f, 0.00562667f, -0.13459638f, 
    0.02555283f, -0.08402257f, 0.08244316f, 0.03248378f, 0.06951131f, -0.02705797f, 0.11736743f, -0.05724703f, 
    0.09146120f, 0.38088283f, 0.20663160f, 0.04282165f, -0.01144892f, -0.11844884f, 0.02226215f, -0.09914520f, 
    0.03445719f, -0.02840584f, 0.04885478f, 0.09708484f, -0.18527545f, -0.69496942f, 0.28363159f, -0.09150242f, 
    -0.02709274f, 0.05232623f, 0.01086638f, -0.02191735f, 0.01966239f, -0.01697854f, 0.01510629f, 0.04404168f, 
    0.12928143f, 0.00021258f, 0.05962070f, 0.06263088f, -0.28216231f, -0.06737126f, 0.03619055f, 0.02351378f, 
    -0.06320892f, -0.03100042f, 0.05311812f, 0.00869275f, 0.12418590f, 0.16771659f, -0.11047626f, -0.03557204f, 
    0.13828665f, -0.00772029f, -0.08173479f, 0.06217192f, -0.03730522f, -0.14259145f, 0.01771201f, 0.06969115f, 
    -0.40164584f, 0.22352287f, 0.36092764f, -0.05421588f, 0.00577263f, -0.06683805f, -0.08897991f, -0.09290932f, 
    0.06080761f, -0.01030848f, -0.05621973f, 0.02030994f, 0.21208620f, -0.05675662f, 0.30426091f, -0.01670705f, 
    0.00644372f, -0.11254402f, 0.06431031f, 0.01586629f, -0.01487905f, -0.03518998f, 0.15387034f, 0.06189664f, 
    0.07961807f, -0.00020117f, -0.34734544f, -0.03304432f, 0.04304798f, 0.06217163f, -0.16237211f, 0.13100190f, 
    0.04244579f, -0.06659616f, -0.10931718f, 0.00675207f, -0.28378236f, -0.00131033f, 0.09888232f, 0.05674018f, 
    0.12779497f, -0.03646808f, -0.06828780f, 0.15026602f, 0.11512666f, -0.03746311f, 0.01707658f, -0.07029690f, 
    0.15986905f, 0.12603872f, 0.04468584f, -0.05578898f, 0.06927576f, 0.06172205f, 0.04735859f, -0.09104393f, 
    0.03942898f, -0.05055578f, 0.03047758f, -0.00805923f, 0.24398781f, -0.12107890f, -0.15073998f, 0.07550380f, 
    0.02898150f, 0.11811230f, 0.06402443f, -0.02923220f, 0.04048495f, 0.08759262f, -0.09990765f, -0.04720809f, 
    -0.06265566f, 0.07791613f, -0.45813808f, 0.16021839f, 0.01140952f, 0.04665810f, 0.06116891f, 0.00492375f, 
    -0.04654836f, 0.13030154f, -0.03975687f, 0.15500210f, -0.03951150f, -0.01092558f, 0.04544017f, 0.03151098f, 
    0.04557229f, -0.04919255f, -0.03174626f, 0.00264025f, 0.00354679f, -0.15069611f, 0.03753472f, 0.11391982f, 
    0.23235227f, -0.14643705f, -0.20431970f, 0.14262481f, -0.02555512f, 0.08369998f, 0.24299705f, 0.00319527f, 
    -0.10445985f, 0.15584786f, -0.09527757f, -0.03984058f, 0.22740532f, 0.13570026f, -0.09503632f, -0.15426390f, 
    0.09549216f, 0.01299624f, -0.05667838f, -0.06816979f, 0.02522627f, -0.04907708f, -0.06569804f, 0.09726604f, 
    0.05921833f, -0.02841618f, -0.27889007f, -0.01210039f, 0.03237420f, 0.07860664f, 0.08829238f, -0.03501822f, 
    0.37955403f, 0.11032477f, 0.23572093f, 0.41234389f, 0.00362137f, -0.38300568f, 0.16301870f, -0.08887699f, 
    0.07640268f, -0.07187115f, -0.15928876f, -0.12901215f, -0.06213757f, 0.12267048f, 0.01231062f, -0.06669739f, 
    0.36783457f, 0.26501065f, 0.36256593f, 0.12326106f, 0.26359981f, -0.03292878f, 0.06610154f, 0.10623384f, 
    0.06679574f, 0.06896202f, 0.02568324f, -0.07184425f, -0.06487832f, -0.12979671f, 0.12985343f, -0.40026420f, 
    0.31336975f, -0.07905791f, -0.15236041f, 0.11824659f, -0.21381785f, 0.03485480f, -0.22942942f, 0.00279432f, 
    0.32733166f, 0.04410586f, 0.35928097f, 0.11529045f, -0.16320224f, 0.06274288f, 0.00472266f, -0.36948276f, 
    0.00649839f, -0.00621302f, -0.08027188f, 0.05004085f, 0.19841690f, -0.04410236f, 0.00426381f, 0.09304892f, 
    0.26603228f, -0.04980678f, -0.20108476f, 0.01580586f, -0.25861105f, -0.40624529f, -0.30940482f, -0.38674504f, 
    0.03578733f, 0.19087636f, 0.12955543f, 0.09475765f, -0.02761129f, 0.01000283f, -0.16123608f, -0.25150156f, 
    0.21773016f, 0.07942817f, -0.21774279f, -0.21240091f, -0.11789744f, 0.22866665f, -0.01852993f, 0.23318529f, 
    0.10978276f, -0.16123970f, -0.15864593f, -0.32556409f, 0.00492318f, 0.00378402f, 0.10483517f, 0.03990182f, 
    -0.03446411f, -0.15997797f, -0.19346902f, 0.03564646f, 0.20149532f, 0.01818751f, -0.10758612f, 0.04959495f, 
    -0.02887994f, 0.01560497f, 0.02833510f, 0.20943365f, -0.23206714f, 0.12382261f, -0.24899237f, -0.15292807f, 
    -0.12490265f, -0.17313991f, -0.02288096f, -0.12696855f, -0.02696226f, -0.13894600f, -0.08614241f, -0.24555480f, 
    0.17908910f, 0.37271053f, 0.33427611f, 0.18578771f, 0.10445823f, -0.03003289f, 0.09804654f, 0.11679814f, 
    0.26870790f, 0.06571207f, 0.22494054f, 0.17742091f, -0.11536928f, -0.20873156f, -0.25028825f, 0.33533481f, 
    0.32100514f, 0.30819273f, 0.13491598f, -0.03697638f, 0.13682634f, -0.12452552f, -0.12526232f, -0.00089309f, 
    -0.52998966f, 0.06934330f, -0.45597231f, 0.03579011f, 0.20102987f, -0.03329080f, 0.07132859f, -0.42038032f, 
    -0.11818607f, -0.30031759f, -0.09826669f, -0.05134628f, -0.00813178f, -0.43374169f, -0.03115786f, 0.04663631f, 
    -0.06172971f, 0.00710852f, 0.09448303f, 0.04856667f, 0.23087357f, 0.18107201f, 0.12835343f, 0.30150193f, 
    -0.35186884f, 0.51916009f, -0.38102502f, 0.47324619f, -0.02179881f, -0.11824387f, -0.19051631f, 0.09231228f, 
    0.03825316f, 0.15853316f, 0.07702695f, -0.00612950f, 0.16912052f, 0.13023582f, 0.16223969f, 0.09742855f, 
    0.16123368f, 0.03019987f, 0.15069102f, 0.31817955f, -0.00240405f, 0.09003823f, 0.07203852f, 0.03529653f, 
    -0.05241294f, -0.10215659f, -0.08093416f, 0.02395740f, 0.05038188f, -0.07699510f, 0.04261520f, 0.03165480f, 
    -0.04341796f, -0.04407231f, -0.05327343f, 0.04198959f, 0.05589306f, -0.01112338f, -0.08889049f, -0.06683896f, 
    0.02543883f, -0.04495835f, -0.00861857f, -0.00537860f, -0.03768557f, 0.06504753f, -0.03048075f, -0.02559664f, 
    -0.06386222f, 0.05905605f, -0.01357980f, -0.00360453f, 0.05392311f, 0.04431335f, -0.07406738f, 0.00586763f, 
    -0.03095554f, 0.01795571f, -0.06792513f, 0.04171091f, -0.00148624f, 0.00343146f, -0.03100999f, 0.01389441f, 
    -0.00758240f, 0.02835974f, 0.02945132f, -0.08848462f, -0.02446944f, 0.02604927f, -0.08621874f, -0.03595044f, 
    -0.00695127f, 0.03144844f, 0.02433348f, -0.07808754f, -0.00611653f, 0.05116215f, -0.07016402f, -0.02452046f, 
    -0.06018906f, 0.04431899f, -0.05995992f, -0.01572327f, 0.03069730f, -0.06613287f, -0.08315661f, -0.08165789f, 
    -0.03193143f, 0.02288762f, 0.01437704f, -0.04394178f, 0.04091331f, -0.03266051f, -0.07805455f, -0.08101092f, 
    -0.06127696f, -0.07014274f, -0.06793464f, -0.08243820f, -0.04285243f, 0.00713433f, 0.04544278f, -0.05005346f, 
    -0.04964142f, 0.03826473f, 0.05876178f, -0.01628527f, 0.04223867f, -0.03418961f, -0.08554929f, -0.04345772f, 
    0.05955492f, 0.00332868f, -0.04078792f, -0.02724308f, -0.05828021f, 0.04968594f, 0.05605752f, -0.01364263f, 
    -0.02684747f, -0.06655262f, -0.06074869f, 0.00289440f, 0.01336170f, 0.00723241f, -0.05884727f, 0.05850871f, 
    -0.00372836f, -0.08444344f, 0.04123333f, 0.03256042f, -0.07279339f, -0.05802057f, -0.05842974f, -0.00794849f, 
    -0.02224348f, -0.00230834f, 0.01043790f, -0.07350781f, 0.03055275f, -0.00167455f, -0.05381965f, -0.00226755f, 
    -0.05063594f, -0.09739881f, -0.06444831f, -0.01638520f, -0.07678073f, -0.01400872f, -0.04877142f, -0.10212778f, 
    -0.05531714f, -0.03716201f, 0.02670767f, 0.03291859f, -0.04946431f, 0.02964715f, -0.07911890f, -0.02300929f, 
    -0.05446805f, -0.00422837f, -0.04728176f, -0.02158361f, -0.04456288f, 0.01538935f, -0.01694052f, 0.04379340f, 
    0.04430719f, 0.04576460f, -0.08307562f, -0.07165632f, -0.06670154f, -0.02454170f, -0.06342780f, 0.03194387f, 
    -0.03848965f, -0.01653258f, -0.05008992f, -0.08627682f, -0.08007938f, -0.06507738f, 0.01936078f, -0.03903214f, 
    0.04819711f, -0.03594092f, 0.02746030f, -0.03689295f, 0.00274155f, 0.00246901f, -0.05572740f, 0.01952703f, 
    -0.01918697f, -0.02586778f, 0.04179182f, -0.08978531f, -0.07268029f, -0.05536571f, -0.06049563f, 0.04258872f, 
    -0.04571398f, 0.07634870f, 0.03271706f, 0.05396908f, -0.04843993f, -0.01998044f, -0.06393667f, 0.00538868f, 
    -0.04502966f, -0.07422858f, -0.04324745f, -0.04719248f, -0.04593985f, -0.07290351f, -0.05106910f, 0.04614911f, 
    -0.21144199f, 0.27957794f, 0.15068606f, -0.35958895f, 0.05772469f, -0.08641147f, 0.00932440f, 0.13038553f, 
    -0.14834921f, -0.00088602f, -0.33323738f, -0.30641174f, 0.04115073f, 0.02440086f, -0.20216186f, -0.38378662f, 
    -0.00111790f, 0.01765854f, -0.08606219f, 0.16424567f, 0.15515612f, -0.01080186f, 0.16160026f, 0.14517298f, 
    -0.24718358f, 0.07686313f, -0.05271665f, 0.09559049f, 0.12403063f, 0.28744105f, -0.09658036f, 0.06393276f, 
    0.04527936f, 0.05381127f, -0.06884384f, 0.17177084f, 0.27738321f, 0.10034624f, -0.01019315f, 0.08012155f, 
    -0.22262441f, 0.08376946f, 0.04825371f, 0.14212947f, 0.07744581f, -0.15505332f, 0.05357828f, -0.09734098f, 
    -0.47317845f, -0.09448189f, -0.27388892f, 0.28483045f, -0.03010544f, -0.04684374f, -0.22217430f, -0.11384612f, 
    -0.04288994f, 0.09788081f, 0.19628350f, -0.08601706f, -0.03077081f, 0.14140074f, 0.01737468f, -0.02144616f, 
    -0.05470348f, 0.34103167f, 0.42411697f, 0.08378141f, -0.01101091f, 0.13272381f, 0.19905317f, 0.31311432f, 
    -0.20905377f, -0.27364036f, -0.15617764f, -0.11612988f, -0.01736684f, -0.06600771f, 0.13234381f, -0.06969491f, 
    0.03113691f, 0.14566240f, 0.18575376f, -0.09738293f, -0.07877979f, -0.20429535f, -0.05323997f, 0.18224852f, 
    0.06209382f, -0.13664414f, 0.03667197f, -0.06494755f, 0.12140506f, 0.13047317f, 0.19067977f, 0.29019630f, 
    0.41495541f, 0.32884607f, 0.26154342f, 0.01049073f, -0.07657621f, 0.12236524f, 0.06657840f, 0.22387694f, 
    -0.03390911f, 0.09231321f, -0.02949652f, -0.16111673f, -0.03635943f, -0.18044834f, 0.20749778f, 0.32152042f, 
    0.14484675f, 0.09963528f, 0.04424855f, -0.08749265f, 0.06223537f, 0.20323937f, 0.02136175f, 0.07862934f, 
    -0.03289220f, -0.07542162f, 0.10510150f, 0.07301565f, 0.02036496f, 0.01589845f, -0.11748885f, 0.05362593f, 
    -0.13737780f, -0.26645744f, -0.14976871f, -0.02386757f, 0.12398361f, -0.05731610f, 0.07308292f, -0.00073055f, 
    -0.19336928f, -0.29592803f, -0.21979451f, -0.18928686f, 0.06641194f, 0.15351646f, 0.08737469f, 0.02926815f, 
    0.13772081f, 0.13973947f, 0.17730170f, 0.11572896f, -0.16130425f, -0.19974639f, 0.03428485f, 0.04748989f, 
    0.05868763f, 0.22823016f, -0.16731396f, -0.05551861f, -0.06222228f, 0.06892064f, 0.08323707f, 0.12883966f, 
    -0.01277834f, -0.05458347f, -0.18334469f, -0.05065117f, -0.00296866f, -0.39481431f, -0.24948457f, -0.37477407f, 
    0.13224356f, -0.28424335f, 0.10152917f, -0.21700913f, -0.05742228f, 0.01588258f, 0.06331592f, -0.16320600f, 
    0.14433126f, -0.01187973f, 0.03507864f, -0.02511108f, 0.05855386f, 0.05092173f, 0.03870218f, -0.04396092f, 
    -0.02402004f, 0.07967770f, 0.03573774f, -0.05696040f, 0.05046889f, 0.06171353f, -0.10172594f, -0.07499033f, 
    0.00577422f, 0.01071080f, 0.03652586f, -0.01211359f, 0.01850367f, -0.06560730f, 0.04624815f, 0.01411654f, 
    -0.05592662f, 0.09107757f, -0.04955429f, -0.04607529f, -0.02416047f, -0.00401417f, 0.07274125f, -0.02352618f, 
    0.01215247f, -0.06970005f, 0.01095922f, -0.02956889f, -0.05081213f, -0.03007318f, -0.05955450f, -0.06657108f, 
    -0.03667869f, -0.00817668f, -0.09767839f, 0.00667616f, 0.07940735f, 0.00187671f, -0.02807893f, -0.00938786f, 
    -0.06346654f, 0.07429103f, 0.02466506f, 0.04545768f, -0.08190923f, -0.03477853f, 0.06330200f, 0.05314561f, 
    -0.02120184f, 0.04081161f, -0.01428277f, 0.00704762f, -0.00942720f, 0.01700752f, -0.02451575f, -0.07028709f, 
    0.02105167f, 0.02323103f, 0.03153813f, 0.05863760f, -0.04958775f, -0.05666304f, -0.10602049f, 0.00096245f, 
    -0.06733379f, -0.04850517f, -0.09058236f, 0.03181215f, -0.00924893f, 0.01034731f, 0.03371851f, -0.00418806f, 
    -0.03718739f, -0.06454979f, 0.03109506f, -0.03626484f, 0.03190172f, -0.08297127f, -0.05626358f, -0.07614054f, 
    -0.00167934f, 0.00283896f, -0.06304058f, -0.05528358f, -0.03873865f, -0.01846715f, -0.06311573f, 0.04335602f, 
    0.04417206f, -0.01556312f, 0.01842478f, -0.01328198f, -0.01384698f, -0.04031593f, 0.04050077f, -0.07559786f, 
    -0.05755203f, -0.06276676f, 0.01644004f, 0.01548944f, -0.01876290f, -0.01461101f, -0.07210579f, -0.08487062f, 
    -0.05450414f, -0.08149847f, 0.04564910f, -0.03907608f, -0.09095111f, -0.02261903f, 0.00382920f, -0.05695377f, 
    -0.04382277f, -0.05429717f, -0.03963682f, 0.04653491f, -0.04326160f, 0.04788210f, -0.00804649f, -0.08182305f, 
    -0.03235825f, -0.08941455f, -0.01520846f, 0.03383425f, 0.02296919f, -0.01240796f, 0.02019057f, -0.05774356f, 
    0.01156015f, 0.03100018f, -0.02745350f, -0.02105343f, -0.00237351f, -0.05680619f, -0.01808042f, 0.00691719f, 
    0.01678702f, 0.04780770f, 0.05562082f, 0.02206995f, -0.10764012f, -0.04091623f, 0.03528121f, 0.02993798f, 
    -0.04662595f, -0.07038020f, -0.09667797f, -0.08861778f, -0.08142632f, -0.02203066f, 0.00770703f, -0.05817925f, 
    -0.09903243f, -0.00957554f, 0.01440283f, -0.09796811f, -0.05714693f, -0.09844609f, 0.03801781f, -0.03982664f, 
    -0.05108247f, -0.00282455f, -0.06304763f, -0.07700406f, 0.00619361f, 0.02322210f, -0.03339224f, 0.04648253f, 
    -0.04889314f, -0.02680341f, -0.06257859f, -0.02219671f, 0.01991476f, -0.01279029f, -0.06405394f, 0.03325543f, 
    -0.01372560f, -0.04051959f, -0.03129692f, 0.03538255f, 0.03643477f, 0.04576234f, 0.06843677f, -0.04248270f, 
    0.02725928f, -0.10142611f, 0.02724372f, 0.04300990f, -0.06420489f, -0.07459229f, -0.07072397f, 0.03863470f, 
    -0.09178717f, -0.03462997f, -0.01210458f, -0.01696701f, -0.05908114f, -0.07755233f, -0.04004141f, 0.03321441f, 
    0.22979635f, -0.05223510f, -0.00003905f, -0.02442832f, -0.15816227f, -0.16848865f, 0.37676322f, 0.07449737f, 
    0.09105889f, 0.07098026f, 0.11173926f, 0.18315829f, -0.10214864f, 0.26917240f, 0.19994061f, -0.00611717f, 
    -0.12134288f, -0.11183570f, -0.07654784f, 0.14516343f, -0.08216036f, 0.11279033f, 0.06928083f, 0.03905941f, 
    -0.25849503f, -0.04228960f, 0.06562251f, -0.00456187f, 0.10408741f, -0.15572095f, -0.10995193f, -0.04472867f, 
    0.03103286f, 0.03032738f, -0.03174021f, -0.02008048f, -0.33176547f, 0.11352039f, 0.09377307f, 0.01823531f, 
    0.21613576f, 0.04915226f, -0.02117120f, 0.15335877f, 0.05346262f, -0.06097208f, 0.02701867f, -0.07642928f, 
    -0.16142125f, -0.11470198f, 0.06759101f, 0.28523502f, 0.23329644f, -0.01933302f, 0.09774145f, -0.08595417f, 
    0.07689283f, 0.09352285f, -0.02813505f, 0.14510266f, 0.00274147f, 0.13763538f, 0.11868139f, 0.01204494f, 
    -0.01054054f, -0.13727228f, -0.06485052f, -0.01734447f, 0.01643636f, -0.05982050f, 0.03974061f, -0.17422169f, 
    0.09774213f, 0.40973043f, 0.14813413f, 0.10617056f, 0.14900778f, -0.02586924f, -0.05252137f, -0.15928595f, 
    0.05117060f, 0.14212349f, -0.03050264f, 0.04086551f, -0.11861061f, -0.04092010f, 0.14791426f, -0.02343648f, 
    0.14534642f, 0.05830529f, -0.04262597f, 0.00495471f, 0.07002607f, 0.03264407f, 0.02323434f, 0.10427307f, 
    -0.38049671f, 0.20137687f, -0.00132144f, 0.02741622f, -0.14616738f, -0.00105106f, 0.04271208f, 0.12793617f, 
    0.07749411f, 0.06220772f, 0.01163186f, -0.04775098f, -0.11275855f, 0.15375482f, -0.06668657f, -0.13152595f, 
    -0.06049797f, 0.08790235f, -0.10198610f, -0.03024616f, -0.02002674f, 0.04647906f, -0.08064283f, -0.00701777f, 
    -0.05188901f, 0.06581310f, 0.12061780f, -0.15123910f, -0.05466677f, -0.05085647f, 0.19237359f, -0.01186556f, 
    0.14026198f, 0.12815157f, 0.12496428f, 0.06366233f, 0.15889579f, -0.10832972f, -0.06214182f, 0.01285282f, 
    -0.04909598f, -0.05485730f, 0.07558267f, -0.05597981f, 0.01050706f, 0.09287407f, -0.17536932f, -0.15207691f, 
    -0.02655934f, -0.02446948f, -0.01981478f, 0.02673504f, -0.11232802f, 0.07584056f, 0.24948613f, 0.02727433f, 
    0.05425778f, 0.04091463f, -0.10035793f, 0.01621532f, 0.02033298f, 0.22385181f, 0.11854811f, 0.04125144f, 
    0.03206766f, 0.00593645f, -0.00484506f, 0.06496079f, 0.20068790f, 0.08808034f, 0.13360490f, -0.09485113f, 
    0.22191572f, 0.06153067f, -0.10654096f, -0.13364248f, -0.09828084f, -0.03625546f, 0.17422083f, 0.02253095f, 
    0.24442339f, 0.15987357f, -0.05509846f, -0.02364065f, -0.25666761f, -0.27281606f, 0.04612185f, 0.18204631f, 
    -0.09910916f, -0.00673234f, 0.09499581f, 0.10950811f, -0.07859325f, 0.03100009f, -0.01141222f, 0.01686798f, 
    -0.15905538f, 0.29625347f, 0.06308747f, -0.12701336f, 0.01269239f, 0.08863137f, -0.08868758f, 0.03525351f, 
    0.09513475f, -0.12317009f, -0.01848958f, 0.00552560f, 0.28530437f, -0.20931388f, 0.18947721f, -0.41438699f, 
    -0.01912275f, 0.01108811f, 0.16086486f, -0.14216340f, -0.00996982f, -0.03598563f, -0.00421412f, -0.04241562f, 
    0.14968109f, 0.24216448f, 0.17876090f, -0.01169639f, 0.00190947f, -0.12938465f, 0.21710999f, 0.15918086f, 
    0.05894445f, -0.00690056f, 0.05599500f, -0.01822806f, 0.18772933f, -0.36717880f, 0.12137226f, -0.33029240f, 
    -0.18243091f, 0.05303236f, 0.10633206f, 0.05702578f, -0.09592552f, -0.01975505f, -0.06115888f, 0.14612477f, 
    0.17857772f, 0.07760090f, 0.17889583f, 0.13293634f, -0.11995664f, -0.03479207f, -0.04531213f, -0.01946257f, 
    0.00759511f, 0.00369985f, 0.03441081f, -0.01601094f, 0.07294666f, 0.03554150f, -0.13295530f, -0.08369080f, 
    0.13008909f, 0.14276867f, -0.09530436f, 0.00394002f, -0.06979739f, 0.04355511f, -0.05839256f, -0.04972146f, 
    -0.25372404f, -0.28594148f, -0.08281775f, 0.05021483f, 0.02101536f, 0.08418400f, -0.00335144f, 0.01741938f, 
    0.06913108f, -0.07748958f, -0.05009040f, -0.05849823f, -0.14691104f, 0.04499843f, -0.09281819f, 0.22246145f, 
    0.00379541f, -0.02425570f, -0.08122049f, -0.07844307f, 0.05389910f, 0.21290128f, 0.14011313f, 0.07087498f, 
    0.55117327f, -0.35483384f, -0.05032065f, -0.31744486f, 0.09903032f, 0.07597200f, 0.10789908f, 0.10272954f, 
    -0.04379631f, -0.04658413f, 0.07944246f, 0.02557024f, 0.03601537f, -0.20552190f, -0.03720947f, 0.25273469f, 
    0.15849741f, -0.01137628f, 0.05088875f, -0.12113222f, 0.04566317f, -0.07624159f, 0.07898923f, 0.15415142f, 
    0.06848241f, 0.09634019f, -0.02058228f, -0.10694351f, -0.02542945f, 0.00919311f, -0.04481820f, 0.07851158f, 
    0.02133825f, -0.09142873f, 0.07056638f, -0.03417094f, 0.00248202f, 0.02640409f, 0.07482291f, 0.13348435f, 
    0.06871371f, 0.09511404f, 0.03488313f, -0.00766891f, 0.00249371f, 0.03510250f, 0.04034685f, 0.12892660f, 
    0.17707714f, -0.03163147f, -0.01633174f, 0.05889548f, 0.18132202f, -0.09335256f, -0.17202196f, -0.04509478f, 
    -0.11704178f, 0.05517763f, -0.10523563f, -0.04662268f, 0.13090748f, -0.38264406f, 0.05537803f, 0.02117192f, 
    -0.03779698f, -0.03177065f, -0.04464928f, -0.02151648f, -0.05665703f, -0.14581068f, 0.02906395f, 0.08365009f, 
    -0.13235790f, -0.00603407f, -0.11208843f, 0.03578515f, 0.12700503f, 0.08547532f, 0.00181061f, 0.02979089f, 
    -0.00422670f, 0.08653297f, 0.00560176f, 0.06219434f, 0.30502251f, 0.37921494f, 0.05598507f, -0.16740310f, 
    -0.08825922f, 0.00021538f, 0.00799097f, 0.12922116f, 0.04443959f, 0.12216967f, 0.13652125f, 0.05634808f, 
    -0.31991318f, -0.07132436f, 0.07644437f, -0.13714415f, 0.07845867f, -0.14825067f, 0.05082251f, -0.06232864f, 
    0.00581316f, 0.01724489f, -0.10855474f, -0.14756890f, -0.15776584f, -0.34769437f, -0.12275932f, -0.23538899f, 
    -0.13565043f, -0.04639310f, -0.00080014f, 0.05203145f, 0.07366334f, -0.08427148f, -0.05359998f, 0.04357401f, 
    -0.05255256f, -0.00127546f, 0.17402075f, 0.35193470f, -0.00948556f, 0.25150695f, 0.10302883f, 0.20322385f, 
    -0.11021400f, 0.06787745f, -0.07571147f, 0.04112783f, 0.12182477f, 0.01116884f, 0.42521405f, -0.25993514f, 
    -0.16863531f, 0.01067529f, -0.03692231f, 0.07259831f, 0.06903221f, -0.08482826f, -0.03958874f, 0.07270393f, 
    -0.00311448f, -0.14636123f, -0.23548819f, 0.09191261f, -0.19454402f, -0.04172509f, -0.05255030f, -0.06143206f, 
    0.06457156f, 0.07507143f, 0.13818862f, 0.03755452f, -0.04403012f, 0.11321820f, -0.01187305f, 0.19462183f, 
    0.28636587f, 0.07078508f, 0.12863870f, 0.00303578f, 0.09489265f, 0.01722830f, 0.24284844f, 0.21497932f, 
    0.40231284f, 0.06439266f, -0.12675427f, -0.20621851f, -0.21073143f, -0.13500562f, 0.10109393f, -0.01501602f, 
    0.14999466f, 0.01505922f, 0.08495472f, 0.06855857f, 0.14308259f, 0.11052381f, 0.00754651f, 0.06164069f, 
    -0.06363413f, -0.04277412f, -0.03888573f, -0.15556699f, 0.17703101f, -0.05808702f, -0.02193374f, 0.14578329f, 
    -0.03606618f, -0.20244618f, 0.16504246f, 0.01737393f, -0.05853351f, -0.00854698f, 0.19620275f, 0.13061136f, 
    -0.01190977f, 0.11323898f, 0.00230181f, -0.00337318f, 0.12401063f, 0.12440574f, -0.08382195f, 0.16312158f, 
    0.08655673f, -0.03775761f, 0.16246600f, -0.15540302f, 0.13408160f, 0.16164577f, 0.09996566f, 0.10853557f, 
    -0.12900417f, 0.06580835f, 0.02484210f, 0.17457736f, 0.10185681f, 0.00331373f, -0.07032152f, 0.01352394f, 
    -0.00897910f, -0.24119282f, -0.19236872f, -0.31318256f, -0.11769907f, 0.12882586f, 0.00968014f, 0.08995152f, 
    -0.19026139f, -0.07696874f, -0.16398506f, 0.00023008f, 0.14410342f, 0.17630053f, -0.03089252f, 0.18334973f, 
    -0.16698325f, 0.21442908f, 0.03224218f, 0.05118233f, -0.04151227f, -0.21294168f, 0.01809517f, 0.04600054f, 
    0.16629243f, 0.09233566f, 0.01414729f, 0.09129287f, 0.06497935f, -0.00479480f, 0.15701237f, -0.14951800f, 
    0.00741203f, -0.10145061f, -0.05476573f, -0.10835958f, 0.16188981f, -0.17394602f, 0.02594953f, -0.08972566f, 
    -0.38241178f, 0.14977942f, -0.23828566f, 0.32291859f, 0.09893102f, 0.08571205f, -0.10988492f, 0.22836193f, 
    -0.05909931f, -0.12984778f, -0.06277779f, -0.06966440f, 0.07080040f, 0.00160316f, 0.23211730f, 0.19990115f, 
    -0.00896609f, 0.19217946f, -0.02653246f, 0.10617975f, 0.10065056f, -0.04231436f, 0.02283392f, -0.00219096f, 
    0.26134118f, 0.31862244f, 0.20045629f, 0.13381857f, 0.13659827f, 0.03630264f, -0.03692327f, -0.05114505f, 
    -0.00248648f, -0.03193051f, -0.12379495f, 0.26140195f, 0.33433616f, 0.21942993f, 0.02996649f, 0.11068519f, 
    0.04823073f, 0.17365544f, 0.04558100f, -0.10807138f, 0.12724032f, 0.06031601f, 0.12006820f, -0.05891035f, 
    0.18391973f, 0.38519564f, 0.05988317f, 0.12492636f, 0.01098663f, 0.04664326f, 0.04230187f, 0.32003096f, 
    0.06247754f, -0.07437112f, -0.01413228f, -0.01151672f, 0.16291991f, 0.08842570f, -0.07025883f, 0.16635695f, 
    -0.08912334f, -0.13842574f, 0.11146431f, -0.02905891f, 0.07646593f, 0.05561814f, 0.07517669f, 0.06794307f, 
    0.08669774f, 0.24725902f, 0.23073031f, -0.44689497f, 0.09837791f, 0.18594287f, 0.00731230f, 0.00317170f, 
    -0.02011084f, 0.00152613f, 0.02573802f, 0.02375248f, 0.27689391f, 0.17040922f, -0.01674760f, 0.25656983f, 
    -0.01878816f, 0.03862005f, 0.11129589f, -0.10340435f, -0.14256687f, 0.05858561f, 0.07410939f, 0.11033297f, 
    0.04854621f, 0.16450408f, -0.00448164f, 0.15168725f, 0.03614581f, 0.07621380f, 0.14986196f, 0.14655834f, 
    -0.15111578f, 0.12140986f, 0.16972184f, -0.05253482f, -0.29752010f, -0.31281140f, -0.29453489f, -0.10840774f, 
    0.02393891f, -0.00032244f, -0.02038878f, 0.05062752f, -0.06054643f, 0.03041716f, -0.03116945f, -0.04077948f, 
    0.53512257f, 0.39979500f, 0.35190406f, 0.27780539f, 0.12533763f, 0.11670797f, 0.03471098f, -0.11038804f, 
    -0.00089476f, 0.03803133f, 0.14696234f, -0.08966810f, -0.39943734f, -0.30246833f, -0.04154488f, -0.10349169f, 
    -0.08532654f, -0.08310191f, -0.13494521f, -0.00909570f, 0.23939559f, -0.06819381f, -0.06393336f, 0.06293964f, 
    0.21596682f, 0.01973532f, -0.05202650f, 0.10913648f, 0.03473378f, -0.10533520f, -0.03657816f, -0.08701769f, 
    0.08313520f, 0.00583771f, 0.00480573f, 0.02709548f, -0.35084513f, -0.47213733f, -0.39673868f, -0.05239433f, 
    0.05372968f, 0.01796113f, -0.01325702f, 0.00674856f, 0.11739420f, 0.09731009f, 0.19046876f, 0.17177023f, 
    -0.38644069f, -0.13389367f, -0.22210762f, -0.14245018f, -0.10033772f, -0.03245040f, -0.20218943f, -0.01951952f, 
    0.02319152f, 0.03926240f, 0.19112146f, -0.13088515f, -0.19726835f, -0.18313590f, -0.11128659f, -0.24144237f, 
    -0.08078283f, 0.02933291f, -0.04592839f, -0.12423299f, -0.11536508f, 0.08760185f, -0.02566992f, 0.06236930f, 
    -0.17859994f, -0.34849158f, 0.19839783f, 0.04297200f, -0.17075899f, -0.05622656f, -0.19599997f, -0.12333670f, 
    0.00240099f, 0.07091910f, 0.04438044f, 0.16139707f, 0.16341355f, 0.33587947f, 0.16032442f, 0.24636704f, 
    0.01413418f, 0.07442022f, 0.04933869f, 0.31594950f, -0.02377817f, -0.04435021f, -0.10808760f, -0.14957945f, 
    -0.06797980f, 0.11107016f, -0.09153835f, -0.07052592f, -0.03038642f, -0.03712497f, 0.08748664f, 0.03271780f, 
    0.16090745f, 0.17177090f, 0.18153992f, 0.23728877f, 0.26201507f, 0.35441241f, 0.13112532f, -0.14263596f, 
    -0.25009370f, -0.12264580f, 0.11400190f, 0.08654594f, 0.04687007f, 0.00554341f, 0.00845480f, 0.07987320f, 
    0.08307290f, 0.26455125f, 0.18563585f, 0.07762879f, -0.04738102f, 0.02467689f, 0.02521728f, 0.15502805f, 
    0.08522591f, -0.00590811f, -0.03135800f, 0.04718007f, -0.22064708f, -0.51386040f, 0.44260293f, -0.34482738f, 
    0.15156895f, -0.08093286f, -0.12070542f, -0.02772564f, 0.01665006f, -0.07128290f, -0.07342475f, 0.09656601f, 
    0.27785262f, 0.14801465f, 0.34896922f, 0.29649752f, -0.13373588f, -0.04985911f, 0.05400585f, -0.28257766f, 
    0.09798893f, -0.06275915f, -0.01086829f, 0.08438564f, 0.10528945f, 0.08367441f, -0.02206974f, 0.14701961f, 
    0.13987756f, -0.12976399f, -0.07230202f, -0.05909495f, -0.14271373f, -0.21999288f, -0.03155990f, -0.15249369f, 
    0.21702461f, 0.62030786f, 0.33304641f, 0.22737022f, -0.26371828f, -0.10560625f, -0.09524217f, -0.04852902f, 
    0.03580124f, -0.01216052f, -0.18475682f, 0.05013908f, 0.29203999f, 0.10627118f, 0.49897978f, 0.18551818f, 
    -0.19741175f, -0.03201280f, -0.06629422f, -0.12168508f, 0.16776893f, -0.02790506f, 0.05926055f, 0.12873745f, 
    -0.11458459f, 0.08094615f, 0.10653570f, 0.01014889f, -0.08282796f, 0.03480997f, 0.01602358f, 0.18633308f, 
    0.12108509f, -0.02381896f, -0.00983047f, 0.05690168f, -0.43514234f, 0.27738893f, -0.26820055f, 0.02540048f, 
    -0.04674046f, 0.02980121f, 0.00970343f, -0.03970735f, 0.07588621f, -0.07275898f, -0.04650185f, -0.05006580f, 
    0.11773472f, 0.29788288f, 0.21813907f, 0.05597194f, 0.01534753f, -0.00785393f, 0.15116513f, -0.02787795f, 
    0.30156332f, 0.12408029f, 0.13080820f, 0.18948756f, 0.06210721f, -0.39569634f, -0.35505739f, 0.02691483f, 
    0.07240639f, 0.34681112f, 0.18045290f, -0.01299811f, -0.01081508f, -0.07409153f, -0.28373578f, 0.15253213f, 
    -0.37840641f, -0.07581709f, -0.48425341f, 0.01118794f, 0.01070115f, -0.02708124f, -0.02836897f, -0.08684719f, 
    0.02815505f, -0.05128885f, -0.13439885f, -0.05012799f, 0.01647588f, -0.02615429f, 0.14103805f, -0.26224300f, 
    -0.17697334f, -0.08078431f, -0.03933727f, -0.01522533f, 0.26736066f, 0.11629251f, 0.30018798f, 0.37526703f, 
    -0.11610267f, 0.14698702f, -0.32571673f, -0.09560271f, -0.05637988f, 0.07066607f, 0.08044370f, 0.11631300f, 
    0.07756875f, 0.04260720f, -0.07498539f, 0.00129716f, -0.02920718f, 0.03710546f, -0.02670327f, -0.10146381f, 
    0.02015630f, 0.08333193f, 0.01380140f, 0.13523951f, 0.06686413f, 0.03237413f, 0.00265658f, 0.13993913f, 
    -0.05161604f, -0.01671175f, -0.14867133f, -0.10084523f, 0.06460162f, 0.28986666f, 0.39226311f, 0.43372729f, 
    0.15935150f, 0.24189357f, 0.25175506f, 0.39258966f, 0.04147601f, -0.18292405f, -0.11352222f, 0.03450247f, 
    -0.09626465f, 0.09632334f, 0.20598473f, 0.40850025f, -0.19098264f, 0.07156173f, 0.11343699f, -0.00725721f, 
    0.26965681f, 0.03346829f, 0.13753797f, -0.10824063f, 0.39430583f, 0.03019316f, 0.04326975f, -0.13636211f, 
    0.12094717f, -0.10679514f, -0.09811579f, -0.17182057f, -0.03839904f, 0.13716136f, -0.15202908f, 0.18325363f, 
    0.42986071f, -0.19747822f, 0.07923502f, 0.13305658f, -0.09192893f, 0.24099731f, -0.01488704f, -0.00716070f, 
    -0.10454688f, -0.46701950f, 0.59325027f, -0.06854817f, -0.00161482f, -0.03710492f, -0.15369424f, -0.13747442f, 
    0.01683250f, -0.04217831f, 0.10739822f, -0.06867345f, -0.13289371f, 0.11797366f, -0.09850798f, -0.13735361f, 
    0.08134282f, 0.05899221f, -0.11613876f, -0.04676920f, -0.09486133f, -0.29380950f, -0.28174368f, -0.34037167f, 
    -0.04371858f, 0.09034552f, 0.09156246f, 0.05041438f, 0.11017930f, 0.03891054f, -0.20686908f, -0.17353068f, 
    0.12034435f, -0.05738097f, -0.02355458f, -0.05204694f, -0.00215033f, 0.19981691f, 0.05464055f, -0.07245231f, 
    0.12904638f, -0.07873207f, 0.02716789f, -0.07654061f, 0.06614581f, 0.05756499f, 0.22451675f, 0.11985720f, 
    0.02123491f, 0.09795766f, -0.37939343f, -0.21247844f, 0.09745379f, 0.06843755f, 0.01579975f, 0.09595279f, 
    -0.06276787f, 0.07204346f, -0.03988884f, 0.04315052f, 0.12474883f, 0.11384642f, -0.08250495f, 0.00208113f, 
    -0.11884861f, 0.02286340f, 0.12913936f, -0.08205452f, -0.08327831f, -0.02710252f, -0.03024036f, -0.12918280f, 
    0.11749088f, 0.23720321f, -0.18239059f, 0.09758500f, -0.07822279f, -0.07140194f, 0.10567877f, 0.11945885f, 
    0.05752764f, 0.19505440f, 0.28297645f, 0.15601255f, 0.00458761f, -0.14931348f, -0.04399263f, -0.13498780f, 
    0.16441281f, 0.11866272f, 0.03084082f, -0.05797950f, -0.13451765f, -0.18348220f, -0.30647811f, -0.07805152f, 
    -0.31520346f, -0.15940481f, -0.26924318f, 0.18716596f, 0.00520853f, 0.03781281f, 0.13587271f, -0.07741696f, 
    -0.11453349f, -0.15504983f, -0.08891495f, 0.16441463f, -0.07151421f, -0.16143823f, -0.21536468f, 0.16646412f, 
    -0.06106418f, -0.13415661f, 0.27749649f, 0.22742493f, 0.31519297f, 0.10958291f, 0.13804060f, 0.10365238f, 
    0.21811597f, -0.04031399f, -0.24990423f, 0.07805488f, -0.08176661f, 0.03021652f, 0.11090817f, 0.02482000f, 
    0.26122165f, 0.21482022f, 0.11614636f, -0.02969901f, 0.16717039f, 0.01127896f, 0.08636968f, -0.09150685f, 
    0.09788675f, -0.11175960f, 0.14788331f, -0.01841982f, -0.05148155f, 0.01134726f, -0.01671940f, -0.02170739f, 
    -0.00892278f, 0.06387004f, -0.09567598f, 0.04186147f, 0.17996594f, -0.09423278f, -0.11653158f, -0.14423224f, 
    -0.07880013f, 0.01400077f, -0.11468206f, -0.16192792f, 0.01671238f, -0.12733783f, -0.10260286f, 0.05660991f, 
    0.14405495f, 0.08303346f, 0.06099751f, -0.10202808f, -0.02459969f, -0.03391267f, 0.04301336f, -0.00373157f, 
    0.24670172f, 0.27993789f, 0.03071963f, 0.32011864f, -0.01300256f, 0.34084237f, 0.23001699f, 0.31574112f, 
    -0.04210153f, 0.06471220f, 0.03597802f, -0.03038784f, 0.27596101f, 0.23333926f, 0.06087044f, 0.10507384f, 
    -0.27858871f, 0.06310016f, 0.06794305f, -0.02728378f, -0.02478385f, -0.03214313f, 0.09906203f, 0.02531018f, 
    -0.19434379f, 0.23815143f, -0.45596933f, 0.09661604f, -0.07609125f, -0.03309585f, 0.00308734f, -0.13525847f, 
    -0.04212786f, 0.06400816f, 0.05660122f, 0.19122550f, -0.00326341f, 0.02493809f, -0.01365744f, 0.07455529f, 
    0.11442145f, 0.25193760f, 0.12300728f, -0.00179694f, -0.01461380f, 0.11890879f, 0.17952296f, 0.19537377f, 
    0.01149069f, -0.28255987f, -0.09928131f, -0.18597189f, -0.06143286f, -0.00237975f, 0.15613884f, 0.03671459f, 
    -0.00263076f, -0.09520280f, 0.17797944f, -0.02302096f, -0.25332087f, -0.18355989f, -0.14247859f, -0.09149022f, 
    -0.04025061f, -0.03980542f, -0.05606161f, -0.01360048f, -0.09238431f, 0.08848813f, -0.17886072f, 0.10111281f, 
    0.36325741f, 0.12477227f, 0.27983829f, 0.37075606f, 0.26539809f, 0.20742008f, -0.04086303f, 0.05168493f, 
    0.07617833f, 0.02861811f, 0.14348896f, 0.06877202f, 0.07256727f, -0.11608341f, 0.37811938f, -0.17920394f, 
    0.06377207f, 0.00227611f, -0.07180361f, 0.04980669f, 0.22595398f, 0.02648289f, 0.14445874f, 0.16811843f, 
    0.13585630f, -0.17232262f, 0.14461875f, 0.17133230f, 0.07956728f, 0.12477910f, -0.06152415f, 0.12626936f, 
    -0.15543096f, -0.03816751f, -0.19018655f, -0.08559779f, -0.15457621f, -0.09262360f, 0.04381871f, 0.00893092f, 
    -0.08833559f, -0.16730531f, -0.11058160f, -0.04336885f, -0.06068878f, 0.14048746f, 0.02405377f, 0.04862719f, 
    -0.00244285f, 0.19507407f, 0.03747824f, -0.05134061f, 0.02662920f, -0.05579336f, 0.04175912f, -0.06869800f, 
    0.01176518f, -0.05611249f, 0.07923026f, 0.02357902f, -0.17487645f, -0.05120089f, -0.01778704f, -0.06005676f, 
    -0.08584544f, 0.03081756f, -0.15621702f, 0.03314431f, -0.16876550f, -0.06910314f, -0.11497398f, -0.00239066f, 
    -0.20891021f, -0.23996229f, 0.32804468f, 0.11233997f, 0.09585711f, 0.06768361f, -0.19173479f, 0.09016871f, 
    -0.16632821f, -0.01935329f, 0.06379255f, 0.06744002f, 0.12555969f, 0.07262138f, 0.08547487f, 0.21458687f, 
    0.01237969f, 0.03454441f, 0.01705326f, 0.22073512f, 0.12815480f, 0.08973050f, 0.08462641f, 0.00913341f, 
    -0.22595784f, 0.14530107f, 0.03009691f, -0.04712866f, -0.00229939f, -0.10296052f, 0.04882306f, -0.01477594f, 
    -0.05649231f, 0.04657973f, 0.11842213f, 0.10525233f, -0.00522202f, -0.02453486f, -0.00105318f, 0.09115901f, 
    -0.12096678f, -0.01457210f, 0.10451449f, 0.22250977f, -0.06159256f, -0.03598254f, 0.00208754f, 0.21305285f, 
    0.19281247f, 0.20376177f, 0.42215383f, 0.08864927f, 0.00613763f, 0.10251772f, -0.03257644f, -0.08612838f, 
    0.11320116f, 0.06043632f, 0.03148830f, 0.15299580f, -0.08980603f, -0.48932716f, -0.06299627f, -0.37385693f, 
    0.15939702f, 0.14527024f, -0.02994064f, 0.20891072f, 0.03526653f, 0.04404552f, -0.01452645f, -0.04237390f, 
    0.02930001f, -0.26543608f, 0.14876416f, 0.03826486f, -0.08792816f, 0.01978491f, 0.01025127f, -0.01152929f, 
    0.01746058f, 0.05024398f, -0.02480745f, 0.00054551f, 0.12776016f, 0.15604953f, 0.06974185f, -0.04950729f, 
    0.02962486f, 0.13189931f, -0.09530943f, -0.07688131f, 0.13639648f, -0.15821399f, 0.10042305f, 0.02710382f, 
    0.05007627f, -0.04938941f, -0.04823954f, 0.01742774f, 0.01236586f, 0.03631542f, 0.00832470f, -0.12936811f, 
    0.14193885f, 0.13789842f, -0.13528945f, -0.03259744f, 0.25334659f, -0.03462476f, 0.08381358f, 0.01316262f, 
    0.00652324f, -0.01116883f, 0.09173676f, 0.06617805f, 0.01402978f, -0.16848166f, 0.14644520f, 0.01829483f, 
    -0.29134223f, 0.17731871f, 0.06685942f, -0.13624594f, -0.00854216f, -0.00148047f, -0.04953972f, 0.05376239f, 
    0.10750338f, 0.06431834f, -0.11538050f, -0.16253996f, -0.24032614f, -0.11874960f, -0.17585468f, 0.16306002f, 
    0.06002188f, -0.00567770f, -0.03911795f, -0.02081260f, -0.13662581f, 0.06452510f, -0.26710013f, -0.10146762f, 
    0.15917014f, 0.24688037f, -0.03461394f, 0.06435958f, -0.04332596f, -0.03991805f, 0.09777030f, -0.24251118f, 
    0.09121995f, -0.07525935f, 0.09562524f, 0.07556167f, 0.09016220f, -0.01514415f, -0.09691790f, 0.09967516f, 
    0.18353741f, 0.01752608f, 0.02475742f, -0.02377922f, 0.07943410f, 0.02309597f, -0.09813643f, -0.01393559f, 
    -0.28901026f, -0.21918958f, -0.17854545f, 0.31683037f, 0.03375453f, 0.01124202f, 0.12968107f, 0.07012995f, 
    0.08865482f, 0.03205137f, -0.21918276f, 0.08843224f, 0.18152127f, -0.09836306f, 0.01119370f, 0.14514196f, 
    0.01774794f, 0.06476443f, 0.15193330f, 0.11709301f, 0.09119591f, -0.27294904f, -0.05769212f, 0.11474288f, 
    0.25261322f, 0.23076025f, -0.35518932f, 0.00668829f, -0.04024821f, 0.13289933f, -0.05963783f, -0.25382617f, 
    0.20759279f, 0.05486366f, 0.04673932f, -0.00794250f, 0.08957633f, 0.22513355f, 0.10541230f, -0.09497647f, 
    0.00084757f, 0.04601292f, 0.04326189f, 0.05766406f, -0.03340862f, -0.13488035f, 0.01205326f, 0.17552324f, 
    0.00797141f, -0.18146208f, -0.01429836f, 0.16043249f, 0.13125576f, 0.25517243f, -0.03960703f, 0.02604506f, 
    -0.04120355f, 0.07436892f, 0.06512754f, -0.15228796f, 0.04368762f, -0.06999142f, -0.28715268f, 0.39712694f, 
    0.18079707f, 0.11060004f, 0.05963952f, 0.02895084f, 0.11348815f, 0.04164160f, 0.08899870f, 0.02432788f, 
    0.07165841f, -0.36465770f, -0.31111130f, -0.11463645f, 0.13646077f, 0.04428924f, -0.03340758f, -0.10952605f, 
    -0.00729772f, -0.05087623f, 0.09083338f, -0.01954031f, 0.16468492f, 0.42947316f, -0.15983632f, 0.50597352f, 
    0.04607373f, -0.08812851f, 0.01907035f, -0.16359416f, -0.00469545f, 0.08224381f, 0.15803395f, 0.05130199f, 
    -0.11419267f, 0.02867382f, -0.15262371f, -0.34026325f, 0.08136097f, 0.03134216f, -0.09512924f, 0.21302734f, 
    0.01192820f, 0.06696064f, 0.09523974f, 0.09185584f, -0.24481817f, -0.19259626f, -0.11677065f, -0.12110278f, 
    -0.01663234f, 0.10694949f, -0.02661858f, 0.03706788f, 0.00269002f, 0.17770374f, -0.03684077f, 0.11759371f, 
    -0.25140831f, -0.27893844f, -0.11547332f, 0.01484712f, 0.00164269f, -0.00817023f, 0.05233410f, 0.02279895f, 
    0.04271903f, 0.08545714f, 0.00859636f, -0.01703435f, 0.07157671f, 0.02562746f, -0.02982330f, -0.26540965f, 
    -0.14211200f, 0.00071839f, 0.01144476f, 0.12106197f, 0.08914999f, 0.11059217f, 0.04649207f, -0.05258156f, 
    0.05375132f, 0.04687932f, -0.10991307f, 0.28130004f, 0.18202148f, 0.13794291f, 0.12332164f, 0.01676300f, 
    0.02051452f, 0.02330110f, 0.10835180f, 0.19775873f, 0.34934804f, 0.05198248f, 0.17196344f, -0.17844933f, 
    0.06093392f, -0.09643346f, -0.00771969f, 0.19353750f, -0.02141210f, 0.05086920f, 0.06189438f, -0.00984482f, 
    0.03408480f, -0.13323510f, -0.27143750f, -0.00003418f, 0.03526480f, 0.18028040f, -0.10899446f, 0.17311290f, 
    -0.17413445f, 0.04877503f, -0.08766487f, 0.00243584f, -0.11959506f, 0.28166163f, -0.00199088f, -0.11099155f, 
    -0.12693118f, -0.10059261f, -0.12629136f, -0.16431852f, -0.08996620f, -0.01568785f, 0.01042360f, -0.09441669f, 
    0.07036051f, -0.21662048f, 0.16627221f, 0.05642281f, 0.13944383f, -0.03799176f, -0.05194929f, 0.05720828f, 
    -0.10976806f, -0.13565905f, -0.04096737f, 0.09261526f, 0.09387425f, 0.21220605f, -0.12832394f, -0.01414505f, 
    -0.00957407f, 0.00791752f, -0.03118051f, -0.07429371f, 0.02479056f, 0.20521326f, 0.03041063f, -0.11965466f, 
    0.00097247f, -0.06792533f, 0.21188444f, -0.06728032f, -0.07811536f, 0.20640418f, 0.09386424f, 0.02500832f, 
    -0.10530770f, -0.01726473f, 0.07145746f, 0.09326170f, -0.03239075f, -0.18895052f, 0.01672474f, 0.00902871f, 
    0.18092340f, 0.00517931f, -0.01181319f, -0.20874666f, 0.06095020f, 0.00520066f, 0.05055045f, 0.09868840f, 
    -0.23721941f, -0.17289314f, 0.01727949f, -0.14853261f, -0.06417545f, -0.03956879f, 0.09818650f, 0.20482367f, 
    -0.06046088f, 0.10714958f, 0.06321529f, -0.17261989f, -0.01775505f, 0.00616009f, -0.05754381f, 0.13163024f, 
    -0.01800240f, -0.05409702f, 0.21590051f, 0.19462314f, 0.12760390f, -0.00628232f, 0.09484066f, -0.04324175f, 
    -0.28543037f, -0.19244854f, 0.05441047f, 0.14631879f, 0.04662718f, 0.17087457f, 0.08120202f, -0.12934649f, 
    -0.05182738f, 0.06899857f, 0.05068564f, 0.08920594f, -0.19279492f, -0.06220635f, 0.30160785f, -0.26509163f, 
    0.09298225f, 0.10082176f, -0.02086493f, 0.06067578f, 0.00779097f, 0.05413094f, 0.02014716f, 0.00051636f, 
    -0.27455777f, -0.52770859f, -0.04805815f, 0.12597550f, -0.06006158f, -0.17057206f, -0.05677756f, -0.06241676f, 
    -0.01590182f, 0.03349838f, 0.07469228f, 0.20959079f, -0.20986372f, -0.05960289f, 0.06953856f, -0.08990300f, 
    0.12321029f, 0.00411385f, -0.05535809f, -0.05744340f, 0.06897620f, -0.07280228f, 0.12190702f, 0.10485875f, 
    -0.04231803f, 0.26919937f, 0.18217818f, -0.00556184f, -0.03809007f, 0.00495312f, 0.02641757f, -0.18800558f, 
    0.11654875f, 0.12625438f, 0.07410438f, 0.08834514f, 0.11274242f, 0.02613251f, 0.33742183f, -0.12349840f, 
    0.01945521f, -0.10845025f, -0.04955305f, -0.01067471f, 0.21323344f, 0.04525789f, 0.06594925f, 0.16973020f, 
    -0.29323837f, -0.02312887f, -0.11957901f, -0.07459973f, 0.14902152f, 0.05325031f, 0.12311281f, 0.20109935f, 
    0.01220338f, 0.06219796f, 0.00711190f, 0.12643901f, 0.01094251f, 0.30553555f, -0.19130120f, 0.11800740f, 
    0.17053746f, -0.06929382f, 0.17967971f, -0.03415128f, 0.05374613f, 0.08743170f, 0.07005090f, -0.13600825f, 
    -0.06605422f, 0.25747594f, -0.00378590f, 0.05690942f, -0.03670817f, -0.00445506f, 0.14253944f, -0.03125064f, 
    0.04739181f, -0.04093354f, -0.01034224f, -0.19690190f, -0.22190969f, -0.08077219f, -0.31131649f, -0.25426334f, 
    -0.15919863f, 0.00820627f, -0.02899037f, -0.11725214f, 0.08744099f, 0.04352409f, -0.21434903f, 0.01400049f, 
    -0.27155796f, -0.13213187f, -0.33285522f, 0.12288602f, 0.17854558f, -0.13640322f, 0.21071464f, 0.05922649f, 
    0.08247405f, -0.02186347f, -0.15755484f, 0.27681094f, 0.03796135f, -0.01390531f, 0.03267388f, -0.08431242f, 
    -0.08088852f, -0.08983253f, -0.01332693f, -0.01732226f, 0.21029589f, -0.15165357f, 0.21053249f, -0.15135120f, 
    0.10214915f, 0.21605849f, -0.51956290f, 0.09296274f, -0.05116839f, 0.08493117f, 0.22756878f, 0.10237246f, 
    -0.15743047f, 0.08068073f, -0.09187263f, -0.16596156f, -0.03174005f, -0.03395003f, 0.11678545f, 0.09894932f, 
    0.01390933f, 0.08555592f, 0.10043988f, -0.12523714f, 0.10311476f, 0.10583723f, -0.01262361f, 0.14693940f, 
    0.04782150f, -0.03844533f, -0.07652046f, -0.05445123f, 0.00762251f, 0.00031275f, -0.02190727f, -0.04613208f, 
    -0.07144269f, 0.00643224f, -0.05083698f, -0.05786667f, 0.02270598f, -0.02029814f, 0.01688653f, 0.04100113f, 
    0.05394989f, -0.05511419f, 0.02538885f, -0.00451447f, -0.06121985f, -0.01704109f, 0.03280867f, -0.02266372f, 
    0.06478461f, 0.04069336f, 0.05943731f, -0.03097716f, -0.00784477f, 0.00384104f, 0.05577830f, -0.00842681f, 
    0.02006516f, 0.03833749f, 0.01280416f, 0.00488898f, 0.00280815f, 0.02142188f, 0.01317499f, -0.02212224f, 
    -0.07153356f, 0.03961905f, 0.04588386f, 0.01695959f, 0.02767243f, -0.02113547f, -0.03731468f, -0.07315319f, 
    0.05097653f, -0.06023155f, -0.02609665f, 0.00660743f, -0.06152357f, 0.00974335f, 0.05407019f, -0.07953107f, 
    -0.04528856f, -0.02258695f, -0.04043231f, -0.01077998f, 0.01147887f, -0.04911184f, -0.02520981f, -0.02617707f, 
    0.02822252f, 0.04914454f, 0.05362657f, -0.03341322f, -0.02764109f, 0.05473589f, 0.05825115f, 0.03286797f, 
    -0.03396902f, 0.03366616f, -0.07742544f, -0.02193229f, 0.03579334f, 0.01575176f, 0.01110871f, -0.05885750f, 
    -0.02498901f, -0.08024170f, 0.03046155f, -0.05874702f, 0.04741926f, 0.05730245f, -0.00693190f, -0.01669329f, 
    0.04633797f, -0.00241744f, 0.05735315f, -0.04447572f, -0.05368799f, 0.00073127f, 0.03682684f, 0.01376640f, 
    -0.08111393f, -0.08457379f, -0.05836462f, -0.04008074f, -0.00971438f, -0.05973716f, -0.07092705f, -0.06728611f, 
    -0.06192310f, -0.00777917f, -0.00943386f, 0.01910345f, 0.03121346f, -0.07548714f, 0.02260484f, -0.01845079f, 
    0.03324851f, 0.00914177f, 0.00701309f, 0.01568967f, 0.04605250f, -0.04532942f, -0.06167446f, 0.02577952f, 
    -0.02939162f, 0.00961753f, -0.05221665f, 0.02500729f, -0.03946584f, 0.03619839f, -0.00089965f, -0.04027974f, 
    -0.05994195f, 0.04607978f, 0.01279784f, -0.05019990f, 0.02334215f, -0.07224039f, -0.01751833f, 0.04752782f, 
    -0.01371048f, -0.06456228f, -0.00016748f, 0.01890123f, 0.04298253f, 0.03041124f, -0.00064086f, 0.00115774f, 
    -0.08604933f, -0.03553608f, -0.04139995f, -0.06897182f, -0.06947197f, -0.05012174f, -0.05385938f, -0.06042056f, 
    -0.01920633f, -0.03749138f, 0.02308735f, -0.06176363f, -0.05542256f, -0.00611820f, -0.07183325f, 0.05359849f, 
    -0.06386194f, -0.02212668f, 0.04336679f, -0.05629092f, 0.05715849f, -0.04261523f, -0.07274383f, -0.00182607f, 
    -0.00446009f, 0.00782915f, 0.03889914f, 0.02671444f, 0.03387509f, -0.00070159f, -0.06582046f, 0.03240050f, 
    0.04077108f, 0.03241114f, -0.07934258f, 0.01675802f, 0.01001398f, -0.07333132f, 0.06954399f, 0.01618471f, 
    -0.05049485f, -0.01398622f, -0.01385748f, 0.01373492f, -0.00992293f, -0.00286485f, -0.02330793f, -0.05438405f, 
    -0.29216811f, 0.10863232f, -0.00294173f, -0.12564676f, -0.10235485f, 0.13957307f, -0.13368148f, -0.01340300f, 
    0.10300089f, -0.04282736f, 0.12516803f, -0.22537896f, 0.38148513f, -0.00198944f, 0.15863639f, -0.26614931f, 
    -0.00885672f, -0.16831383f, 0.13722119f, 0.05842963f, 0.21235135f, 0.03680901f, -0.02596380f, 0.04686166f, 
    -0.04541115f, -0.19981878f, 0.25300485f, 0.11681681f, -0.06896901f, -0.06211750f, 0.03348645f, -0.20999540f, 
    0.10075611f, -0.07627917f, 0.01655745f, 0.07292520f, 0.12400687f, -0.27446550f, 0.25011399f, -0.27241570f, 
    -0.03128272f, -0.02603890f, 0.08081995f, 0.04813462f, -0.00192080f, 0.02849812f, -0.11687218f, 0.08659481f, 
    -0.24361539f, -0.08161137f, -0.10919228f, 0.26992911f, -0.19204038f, -0.07692075f, -0.11356866f, 0.01006366f, 
    0.05221266f, -0.17551121f, -0.00507441f, 0.00289049f, -0.12629162f, -0.02318428f, 0.05009511f, -0.17288463f, 
    0.07793119f, 0.19170909f, -0.02539425f, 0.33460167f, -0.04361611f, 0.04718842f, -0.04320548f, -0.12544352f, 
    -0.51720488f, -0.34741911f, -0.06310377f, -0.00988219f, -0.09778585f, -0.05586332f, -0.13690044f, -0.02408555f, 
    0.22881390f, -0.06266633f, 0.08693303f, 0.19635688f, 0.01848906f, -0.06171487f, 0.01283763f, 0.12952815f, 
    -0.06862815f, -0.09316714f, -0.07806568f, 0.01698761f, 0.16636835f, 0.25143763f, 0.12914355f, 0.17832360f, 
    0.10201307f, -0.09933024f, 0.04214570f, -0.31838274f, 0.02397224f, 0.04037461f, 0.00213578f, 0.15914766f, 
    0.01244535f, -0.00861237f, 0.03630329f, 0.07216753f, 0.16035703f, -0.11405329f, -0.02582109f, 0.17239930f, 
    0.37636620f, 0.13208078f, 0.11064573f, -0.05139928f, 0.11743112f, -0.03300566f, 0.19862552f, 0.11405223f, 
    -0.00503850f, 0.13604166f, -0.03337499f, -0.17774376f, 0.01751881f, 0.11249229f, 0.01391431f, 0.02601488f, 
    -0.03198647f, -0.12378727f, 0.12240718f, 0.00143646f, 0.18470006f, 0.06614824f, 0.09810131f, -0.00869393f, 
    -0.04402822f, -0.03713385f, -0.08750515f, -0.10436098f, -0.12001048f, -0.01699080f, -0.01598067f, -0.04240732f, 
    0.50640374f, -0.07277099f, 0.10482485f, 0.08880902f, 0.24106570f, 0.05371328f, 0.06022770f, 0.13763340f, 
    -0.00396712f, 0.08499344f, -0.02410984f, 0.06415123f, 0.31715053f, -0.13080741f, 0.05547487f, 0.09082394f, 
    0.01331684f, 0.01396937f, -0.05607626f, -0.02975560f, 0.07710279f, -0.12998734f, 0.11346439f, 0.09113660f, 
    0.21806869f, 0.24531981f, -0.28969979f, -0.13644430f, 0.22042906f, 0.08538108f, 0.14212154f, 0.18961580f, 
    0.03622255f, 0.05130266f, 0.10801238f, 0.05068807f, 0.15644512f, 0.16819872f, 0.11553375f, -0.06636170f, 
    -0.02597813f, -0.10076494f, -0.12076369f, -0.13110350f, 0.04306965f, 0.13484573f, 0.04446580f, -0.00661474f, 
    0.29082924f, 0.03624986f, -0.30309907f, 0.17181695f, -0.00414484f, -0.00284720f, 0.12824653f, 0.12091210f, 
    -0.11226740f, -0.03489577f, 0.25420526f, -0.01140826f, -0.13060483f, -0.16726761f, -0.05967799f, 0.19507463f, 
    0.13514464f, -0.03190928f, -0.04880041f, 0.20589770f, -0.07533474f, -0.00732081f, 0.03500371f, -0.17057541f, 
    0.43291894f, -0.00591396f, 0.06937061f, 0.06569805f, 0.05787043f, -0.02382724f, 0.10060006f, 0.01752087f, 
    0.04219965f, -0.01133091f, 0.02334206f, -0.14588346f, -0.19125789f, 0.49377620f, -0.12411159f, 0.30501282f, 
    0.03144779f, 0.04605275f, -0.10010498f, -0.03850410f, -0.11315711f, -0.01108432f, -0.06403178f, -0.03147296f, 
    -0.03864088f, 0.17296885f, -0.15081528f, -0.04420988f, -0.01956186f, 0.04790469f, 0.12413823f, -0.00887237f, 
    0.03222021f, 0.03129668f, 0.11268153f, 0.25305003f, 0.12023772f, 0.08457816f, 0.08141078f, -0.03635463f, 
    0.07863092f, 0.05634955f, -0.34116468f, 0.09204552f, 0.05347936f, -0.04786636f, -0.12203763f, -0.15679434f, 
    0.00145286f, 0.03655068f, 0.21714328f, 0.11849603f, 0.02685566f, 0.05634095f, 0.00743604f, -0.12755080f, 
    0.16473830f, 0.11427546f, -0.05656731f, -0.08621552f, -0.19665542f, -0.00951209f, -0.11708476f, -0.31272548f, 
    0.04021781f, -0.01632369f, 0.02863083f, -0.03476835f, 0.09819486f, 0.11470091f, 0.08493122f, 0.18196729f, 
    -0.19609502f, 0.09465747f, -0.20925248f, 0.24582435f, 0.12454819f, 0.08406851f, -0.09567042f, 0.00180321f, 
    0.03230548f, 0.06591277f, -0.00551422f, 0.21641900f, 0.22302756f, -0.08527844f, 0.14701752f, -0.36795324f, 
    -0.05617487f, -0.04597546f, -0.16726331f, 0.05630954f, -0.14822850f, -0.07678363f, 0.05952933f, 0.04883641f, 
    0.05450650f, 0.04252021f, -0.00821430f, 0.07015222f, 0.22886446f, 0.13506731f, 0.13676581f, 0.00590782f, 
    -0.13641325f, 0.02305921f, 0.13263470f, -0.00058077f, -0.05648838f, -0.00850831f, 0.06088529f, 0.07799614f, 
    0.01526451f, 0.09237903f, -0.05306416f, -0.06667481f, -0.00890199f, 0.13407299f, 0.01144066f, -0.04190947f, 
    0.01494233f, -0.07710833f, -0.16414957f, 0.12459619f, -0.06149603f, 0.08736239f, 0.15096517f, -0.12433110f, 
    0.00130013f, -0.10531812f, 0.03117468f, 0.05300863f, -0.11779136f, 0.04048407f, -0.23771027f, -0.14144233f, 
    -0.07042085f, 0.05174796f, 0.00964275f, 0.16230540f, 0.06972819f, 0.19831638f, 0.03276201f, 0.00941481f, 
    0.09990325f, -0.08916505f, 0.16616561f, 0.11949743f, -0.14182900f, 0.06017756f, 0.03131591f, 0.00276978f, 
    -0.02321532f, 0.06739909f, 0.02917240f, -0.16330200f, 0.02519742f, -0.25006759f, -0.09372423f, 0.16648275f, 
    0.04909420f, -0.04443379f, 0.00771146f, -0.04258440f, -0.01861191f, 0.03367567f, 0.08967707f, 0.03167332f, 
    0.02791278f, -0.23642589f, 0.19275172f, -0.02401569f, -0.06653405f, -0.07660811f, -0.26167512f, -0.14240521f, 
    0.06896484f, -0.08210919f, -0.00695549f, 0.16772489f, 0.38871115f, 0.39236075f, 0.08064735f, 0.09990735f, 
    -0.02384623f, -0.06951904f, -0.00020069f, 0.00685343f, 0.05400136f, -0.01844376f, 0.05764417f, 0.28025261f, 
    -0.33238137f, -0.05467092f, -0.11570254f, 0.05553153f, 0.19148690f, 0.11761189f, 0.09790730f, 0.13775012f, 
    0.06377418f, 0.05319542f, -0.01574696f, 0.01312822f, -0.02169810f, 0.02306671f, 0.08818150f, -0.12423395f, 
    0.14232896f, -0.15480210f, 0.01355142f, 0.12670527f, -0.04921107f, 0.00522059f, 0.03136392f, -0.05308289f, 
    0.09444491f, -0.33752364f, 0.44979462f, -0.16580203f, 0.08384494f, -0.02410414f, -0.09875575f, 0.15695946f, 
    0.20431410f, 0.04435435f, 0.02671739f, 0.12261138f, 0.04240536f, -0.05584380f, -0.06982929f, 0.02101738f, 
    0.11832833f, -0.24641454f, 0.14039093f, -0.21475823f, 0.10939367f, -0.01967844f, -0.02724645f, -0.05882262f, 
    0.08271506f, 0.17938671f, -0.12145489f, 0.25559717f, -0.00171520f, -0.05936343f, -0.12156232f, -0.01228998f, 
    -0.04157250f, 0.03483075f, 0.02719619f, 0.17824523f, 0.32845840f, -0.03421614f, 0.17206687f, 0.13876516f, 
    0.04696438f, -0.00998051f, -0.15664223f, 0.08030671f, 0.10123647f, 0.01669729f, 0.00180653f, 0.11388297f, 
    -0.13317363f, 0.02907575f, 0.21422374f, -0.05230400f, -0.09867398f, -0.07239258f, -0.01537469f, -0.06791220f, 
    0.07470555f, -0.01770427f, 0.08182419f, -0.08230408f, -0.27392027f, 0.28245541f, -0.46898982f, 0.13057286f, 
    -0.03712627f, -0.06249659f, -0.01682431f, -0.08327775f, 0.01363163f, -0.01285245f, 0.01014100f, -0.03400699f, 
    -0.14588830f, 0.17818181f, 0.05098293f, 0.06122984f, -0.03548276f, 0.02663247f, 0.13894467f, -0.07469695f, 
    0.19080403f, -0.10434516f, 0.08249822f, 0.07592364f, -0.04282028f, -0.09457171f, -0.27731085f, -0.04252117f, 
    0.07808169f, 0.03395113f, -0.02315939f, -0.11793615f, 0.12558529f, -0.05927319f, -0.05321606f, 0.01420450f, 
    -0.21570851f, -0.28361610f, -0.10630146f, -0.03118165f, 0.13562268f, -0.04397075f, -0.18600179f, -0.02573492f, 
    0.05254336f, -0.01635789f, -0.02374495f, -0.00285668f, 0.27401346f, 0.05960923f, 0.14031890f, -0.07782030f, 
    -0.01675949f, -0.04135701f, 0.12451892f, -0.10520939f, 0.20517017f, 0.04804155f, 0.17998812f, 0.12302787f, 
    -0.04046123f, 0.37317604f, -0.23009454f, -0.11804586f, -0.01255258f, 0.05511838f, 0.06851249f, -0.15900789f, 
    0.22769326f, 0.09109829f, 0.00137396f, 0.08318116f, -0.21527408f, 0.02587388f, 0.19484293f, 0.09565881f, 
    -0.03899880f, 0.04355172f, 0.04837764f, 0.08663559f, -0.01581650f, 0.01651651f, 0.02424062f, -0.04622098f, 
    -0.02148160f, -0.06493325f, 0.03492941f, -0.05628515f, -0.02715020f, 0.03583068f, -0.03582953f, 0.05676634f, 
    0.00932193f, -0.04100673f, -0.00075937f, 0.00961049f, -0.06670746f, -0.07546014f, -0.06475502f, 0.05243202f, 
    0.06228046f, 0.00303035f, -0.06197409f, 0.03509010f, -0.03782535f, -0.04158177f, -0.04244661f, 0.00746713f, 
    0.01065645f, 0.02944888f, -0.02064656f, -0.00171053f, 0.03146005f, -0.02154224f, -0.07580833f, 0.01458925f, 
    -0.07517788f, 0.02690288f, -0.03284777f, -0.01518810f, 0.02105722f, 0.04584540f, -0.02094991f, 0.05377012f, 
    -0.08003096f, 0.06202009f, 0.02571478f, -0.03407558f, -0.06373814f, -0.00824634f, -0.05798846f, -0.03147114f, 
    0.01326817f, 0.04138463f, 0.03255777f, -0.07033477f, 0.01723339f, -0.01175372f, -0.06758937f, -0.01228892f, 
    -0.00667519f, -0.02740610f, -0.04533897f, -0.03384855f, -0.05038385f, 0.06349644f, -0.02194891f, -0.04732179f, 
    0.01893583f, 0.00404877f, 0.01945777f, -0.06613339f, 0.03469225f, 0.00775026f, 0.02582536f, -0.06805278f, 
    -0.01832838f, 0.04795775f, 0.05684035f, 0.01864873f, 0.03025656f, -0.07735685f, -0.00300464f, 0.01009681f, 
    -0.05165913f, -0.05208661f, -0.01314559f, -0.02080424f, -0.06139614f, -0.00242644f, 0.05449311f, 0.01757380f, 
    -0.06164008f, 0.01645131f, 0.03191480f, 0.05641156f, -0.02913334f, 0.03238520f, 0.01982195f, 0.01786962f, 
    -0.03973557f, -0.01416160f, 0.05883925f, -0.03821367f, -0.01585871f, 0.00938947f, -0.04076143f, -0.05840045f, 
    0.04314767f, -0.01747901f, -0.06976968f, 0.02415141f, 0.01662203f, 0.04596867f, 0.00867813f, 0.00091577f, 
    -0.07032334f, -0.03485744f, -0.07416831f, -0.01335293f, -0.02931131f, -0.07433140f, -0.01623186f, -0.00602230f, 
    0.02021035f, -0.00030012f, -0.01454775f, -0.00268392f, -0.01858852f, -0.02188948f, -0.01664975f, -0.02142266f, 
    -0.00216407f, -0.05651183f, -0.05758248f, 0.02306779f, -0.06353348f, 0.06126873f, 0.04661151f, 0.02376167f, 
    0.02502910f, 0.00914271f, -0.03133565f, 0.02936771f, -0.00001960f, 0.05299225f, -0.03336293f, -0.07528187f, 
    -0.02451073f, -0.01476445f, -0.06780759f, -0.02832442f, 0.03562475f, -0.05318327f, 0.00949509f, -0.05317943f, 
    0.01417348f, -0.00346473f, -0.02619116f, -0.06654688f, -0.00517653f, 0.01825686f, 0.01829931f, 0.01929416f, 
    -0.05851966f, -0.02558423f, -0.01791746f, -0.03635447f, -0.07390494f, -0.05586388f, -0.03869027f, -0.03498816f, 
    -0.01827416f, -0.04276809f, -0.05728930f, -0.03027760f, -0.05124676f, 0.02910620f, -0.01055042f, -0.04285782f, 
    0.06360212f, -0.01863505f, -0.01480637f, 0.03565969f, 0.04526807f, 0.05831515f, -0.04062141f, -0.06051138f, 
    -0.06805112f, 0.00239206f, 0.05584620f, 0.06067604f, 0.00054757f, 0.00495965f, 0.01062928f, 0.05298987f, 
    -0.34097558f, 0.03670866f, -0.16531324f, -0.08018583f, -0.07631841f, 0.06818185f, 0.19792141f, 0.42314342f, 
    -0.04961382f, 0.05097418f, 0.01611376f, -0.16321173f, -0.50263000f, -0.22629295f, 0.00045219f, 0.01812118f, 
    0.03256616f, 0.10937335f, 0.16723236f, 0.00818213f, -0.12270519f, -0.07600625f, -0.06015790f, 0.18136828f, 
    0.31915042f, -0.41904217f, -0.05671450f, -0.16668370f, -0.05019982f, 0.08614204f, 0.15403591f, -0.05903317f, 
    0.09198035f, 0.11669150f, 0.03277563f, 0.02043235f, 0.16976805f, 0.35827813f, -0.12942719f, 0.00737163f, 
    -0.14982423f, 0.13313724f, 0.09639426f, 0.10349888f, -0.04703495f, -0.00148662f, 0.03428933f, -0.10391649f, 
    -0.02341752f, -0.04440859f, -0.14063230f, 0.30203384f, 0.03650459f, 0.00784748f, 0.15496561f, -0.19760998f, 
    0.22114724f, 0.15283176f, -0.03333496f, -0.01058877f, -0.11975158f, -0.03170955f, 0.10676590f, -0.15449065f, 
    -0.00569790f, 0.21268575f, -0.10638063f, -0.00619148f, 0.11245164f, -0.01359901f, -0.02924172f, 0.02859105f, 
    0.18389954f, -0.29526624f, -0.24510053f, -0.12717919f, 0.01219674f, 0.09535389f, 0.06330557f, 0.05629545f, 
    0.12847966f, 0.13351353f, -0.04870753f, -0.15395607f, -0.20370188f, 0.08863238f, -0.22376919f, -0.00678226f, 
    0.02625135f, 0.06566140f, 0.10351539f, -0.02623599f, 0.04354106f, 0.06455579f, 0.17066702f, 0.05000978f, 
    -0.12868014f, -0.33146900f, 0.08669459f, 0.10473538f, 0.06703809f, -0.01783426f, 0.15438652f, 0.05111029f, 
    0.14559497f, -0.07033919f, -0.10399417f, -0.04713599f, 0.62325317f, 0.07616191f, 0.06988751f, 0.18253486f, 
    0.16986151f, 0.07817868f, 0.16120166f, -0.03182248f, -0.12494495f, 0.15596572f, 0.02221659f, 0.10011456f, 
    -0.01608907f, 0.00285032f, -0.21083783f, 0.01234942f, 0.06521149f, 0.06425524f, -0.05695068f, 0.00685200f, 
    -0.02615155f, 0.03511461f, 0.00075894f, -0.21469323f, -0.32206109f, 0.01000014f, 0.27302381f, -0.08544198f, 
    -0.04013926f, 0.00737819f, -0.08894394f, 0.04319644f, -0.12555042f, 0.03243749f, 0.08307691f, 0.00810127f, 
    0.12757668f, 0.03182084f, 0.34280568f, 0.06572276f, 0.04928015f, 0.10723552f, 0.08407893f, 0.08247361f, 
    -0.02277876f, 0.04288285f, -0.08446659f, 0.05400179f, -0.01168801f, -0.15357174f, -0.13558000f, 0.16316180f, 
    -0.02813599f, -0.06515245f, 0.03678983f, -0.00221919f, 0.24719410f, -0.08391247f, -0.22332375f, -0.10380725f, 
    -0.37577593f, 0.10357349f, 0.14323097f, 0.18672083f, 0.14750524f, 0.10901795f, -0.19342193f, 0.29201311f, 
    0.02778232f, -0.14317961f, 0.24373299f, 0.00407668f, 0.02822586f, -0.19205454f, -0.03859298f, -0.27392021f, 
    -0.01128160f, -0.15625747f, 0.04113423f, -0.02149083f, 0.06687517f, -0.01438070f, 0.15526254f, 0.03913388f, 
    0.27344763f, -0.03961780f, 0.07422628f, -0.01452469f, 0.11355618f, 0.16228922f, -0.03575408f, 0.08882869f, 
    -0.10741051f, -0.02640866f, -0.07092427f, -0.07550111f, 0.07339910f, -0.03893671f, -0.08195992f, -0.03816693f, 
    0.13976344f, 0.00555066f, -0.05415298f, -0.17248358f, 0.11972258f, 0.13372502f, 0.05275935f, -0.06614962f, 
    0.05478466f, -0.08418579f, -0.28120747f, -0.03504939f, 0.05107662f, -0.00074876f, -0.00292655f, 0.05098092f, 
    -0.07525816f, -0.06558489f, 0.05001976f, -0.01164609f, 0.37748948f, 0.56664264f, -0.21663356f, 0.65941823f, 
    -0.19198260f, -0.00586548f, 0.12721759f, -0.17077610f, 0.04424342f, -0.02464507f, 0.12824360f, 0.01836640f, 
    -0.02841071f, 0.17327684f, -0.19770426f, -0.13930112f, 0.08474728f, -0.00404637f, -0.10793208f, -0.00836891f, 
    -0.05711022f, 0.12549224f, 0.07282927f, 0.09022756f, -0.06229524f, -0.09358909f, -0.11328801f, 0.02716201f, 
    -0.09535567f, 0.07699272f, 0.25085980f, 0.01354785f, -0.10058211f, 0.20558769f, 0.05268509f, 0.06771128f, 
    -0.09607185f, -0.38417637f, -0.30724704f, -0.17455898f, 0.02749429f, -0.07276990f, -0.02342460f, 0.08438440f, 
    -0.12272948f, -0.06291379f, 0.07615989f, 0.00337066f, -0.03705881f, 0.06478833f, -0.20259000f, -0.05721081f, 
    -0.15763240f, 0.01512192f, -0.13932814f, -0.03282558f, -0.13371903f, 0.15098664f, -0.04525416f, -0.03545322f, 
    0.37865865f, 0.07697271f, 0.11849942f, 0.13698658f, 0.06141495f, -0.01151767f, 0.12183455f, -0.08624110f, 
    -0.04258775f, -0.06166154f, 0.12137394f, -0.05235235f, 0.30447394f, -0.07183315f, 0.32597813f, -0.01143095f, 
    -0.01309657f, 0.01759568f, -0.09434245f, 0.12031219f, 0.04982045f, -0.08256599f, 0.13396071f, 0.15170918f, 
    -0.03803534f, -0.17522152f, -0.07253096f, -0.01318294f, 0.01989345f, 0.13420337f, -0.09629249f, 0.26679191f, 
    -0.09190839f, 0.13529177f, -0.04112912f, 0.01686510f, 0.10301841f, 0.31264096f, 0.22251010f, 0.01275345f, 
    -0.10971174f, -0.11946052f, -0.08639194f, -0.06124520f, -0.12545596f, -0.01927450f, 0.04776235f, -0.04760542f, 
    0.48633915f, 0.14791965f, 0.50850570f, -0.21170178f, -0.12945352f, -0.01790376f, -0.19413018f, 0.05716303f, 
    -0.09088998f, 0.03306422f, 0.07393413f, -0.09833147f, -0.00059720f, 0.23462629f, -0.01415849f, 0.06825588f, 
    0.02558580f, -0.00803698f, -0.03223606f, -0.15291978f, -0.19328342f, 0.16842006f, -0.07095687f, -0.04519833f, 
    -0.14132239f, -0.21584721f, 0.56144345f, -0.09446053f, 0.00750590f, 0.10302967f, 0.11275885f, 0.00505256f, 
    0.07743352f, 0.04941759f, -0.01522083f, 0.09610029f, -0.00462845f, 0.01915687f, -0.00759085f, 0.13787675f, 
    0.02967208f, 0.07267384f, 0.08553729f, -0.03292717f, -0.03609709f, -0.01521543f, 0.04213071f, -0.01221906f, 
    0.16581468f, -0.26107457f, 0.27288249f, 0.00745703f, 0.01737759f, 0.18815489f, -0.01251015f, 0.14212357f, 
    0.00250560f, -0.06663882f, -0.04740920f, 0.11035775f, 0.07744526f, -0.37696141f, -0.07781666f, 0.03142063f, 
    0.04701423f, 0.04165214f, 0.00845325f, -0.01659952f, -0.02240835f, -0.00112086f, 0.03380401f, -0.03364430f, 
    0.05523558f, -0.07115262f, -0.16829826f, 0.01011308f, 0.24351911f, 0.07282213f, 0.22883804f, 0.21742430f, 
    0.03405488f, 0.00820406f, 0.05408372f, -0.15178627f, 0.12243565f, 0.34460822f, -0.03806295f, 0.15407491f, 
    0.00555355f, -0.13545483f, 0.16379917f, -0.00771510f, -0.07194326f, 0.09738947f, -0.01314980f, -0.02559231f, 
    0.41397592f, -0.35122445f, 0.39120379f, -0.50357568f, 0.05899522f, 0.12558158f, -0.02677618f, -0.04234826f, 
    0.17659096f, 0.11357449f, 0.15516637f, 0.07958943f, -0.11047963f, -0.05282011f, -0.23196240f, 0.14397205f, 
    0.17242202f, -0.10533046f, 0.14064297f, -0.06546128f, 0.12305392f, 0.07458720f, -0.03803918f, 0.06824158f, 
    0.13571693f, 0.12978454f, -0.23699673f, -0.11684077f, -0.04322053f, 0.03794677f, -0.00808255f, -0.06246187f, 
    -0.09155829f, 0.09289902f, 0.13193746f, 0.12426690f, 0.01924647f, 0.16448148f, 0.00336196f, -0.08960594f, 
    -0.01278183f, 0.05376543f, -0.11207835f, -0.15286367f, 0.03703438f, -0.11977541f, -0.03665873f, -0.04358290f, 
    0.28726733f, -0.26099607f, -0.25332722f, 0.09488562f, 0.21775933f, 0.04102580f, 0.09355059f, 0.00232549f, 
    -0.00943291f, -0.03754928f, 0.07801815f, 0.02617380f, 0.01816772f, 0.20201692f, -0.17903860f, 0.06303127f, 
    0.02346051f, -0.28135404f, 0.05188632f, -0.17127858f, 0.11237890f, 0.04908958f, -0.07502507f, 0.00716880f, 
    -0.07579573f, 0.02412213f, -0.09133209f, 0.15765615f, 0.09917897f, 0.00220977f, -0.02483425f, 0.13608402f, 
    0.01410833f, 0.01766746f, 0.09045929f, -0.03447642f, -0.23735689f, 0.02587813f, -0.13797089f, 0.01232335f, 
    -0.05948072f, -0.11947604f, -0.03388177f, -0.02922169f, 0.09563622f, 0.03154885f, -0.08987618f, 0.06102797f, 
    -0.28164411f, 0.03343032f, -0.03740230f, -0.27479866f, 0.05181946f, -0.18404354f, -0.18813123f, -0.10018712f, 
    0.04732051f, -0.10540520f, 0.12471375f, 0.04141257f, 0.02263775f, -0.05367378f, 0.08642725f, -0.03789248f, 
    0.00269630f, -0.03755431f, 0.05362936f, -0.12215927f, 0.05763738f, 0.03423291f, 0.03096834f, -0.09607638f, 
    -0.39801988f, 0.09646244f, 0.01037784f, 0.30720621f, -0.11655542f, 0.03491427f, 0.03588838f, 0.14769499f, 
    -0.05708636f, 0.01468272f, -0.01395222f, 0.14382493f, 0.05902492f, -0.02489701f, 0.10318438f, 0.09755812f, 
    0.09473553f, 0.03120029f, 0.14978239f, 0.04511366f, -0.03494495f, 0.08300693f, 0.06536463f, -0.01361852f, 
    0.25158951f, 0.22315912f, 0.05685549f, 0.08554271f, 0.00126607f, -0.09467985f, -0.12922738f, -0.00657413f, 
    0.09296104f, 0.16617677f, -0.08477705f, 0.32649952f, 0.13678955f, 0.27274635f, 0.06804205f, 0.06277154f, 
    0.08978083f, 0.16682974f, 0.02869488f, -0.18703359f, -0.00749133f, 0.10963308f, 0.02516318f, -0.13876662f, 
    0.02650980f, 0.29685342f, -0.03565549f, -0.21951814f, 0.11299029f, -0.00589985f, 0.07067470f, 0.18100196f, 
    -0.04822284f, 0.02649190f, 0.04465984f, -0.09489463f, 0.15288740f, -0.00464300f, -0.19292973f, 0.36727569f, 
    -0.04684051f, -0.00323760f, 0.10760223f, -0.05437940f, -0.03222661f, -0.02803304f, 0.06342661f, 0.09581734f, 
    -0.17651683f, 0.34770918f, -0.09322377f, 0.10202362f, 0.02298029f, 0.09916753f, 0.05791648f, -0.05479337f, 
    -0.03323983f, 0.04999450f, 0.04142359f, 0.01728117f, 0.25475800f, 0.03698467f, 0.07335125f, 0.14159773f, 
    -0.06892232f, 0.10044789f, 0.09969713f, -0.10132348f, -0.19382498f, 0.12286492f, 0.00171042f, -0.00351682f, 
    -0.22127062f, 0.00132277f, 0.16585757f, 0.18847750f, -0.03327426f, -0.02434492f, 0.04903738f, 0.13483375f, 
    -0.09063380f, -0.05513325f, -0.07149138f, -0.10392261f, -0.20676053f, -0.16701472f, -0.06345148f, 0.10219028f, 
    -0.01130229f, 0.01332720f, 0.14403881f, 0.04686089f, 0.00469707f, 0.16433184f, -0.04682301f, 0.03893491f, 
    0.34432644f, 0.38763326f, 0.22803117f, 0.17651688f, -0.00383602f, 0.01781672f, -0.06603558f, -0.17310297f, 
    0.04084174f, -0.04038902f, 0.04461703f, -0.07406197f, -0.31985119f, -0.04624116f, 0.34750906f, 0.02766715f, 
    -0.06929523f, 0.05263470f, 0.00654820f, 0.18452375f, 0.08979008f, -0.09648216f, 0.10628347f, 0.07718338f, 
    0.11166814f, -0.11877991f, 0.15231551f, -0.13709909f, 0.05906194f, -0.03087734f, -0.09903557f, 0.00492640f, 
    0.12918463f, 0.17519797f, 0.03702324f, 0.12361757f, 0.02081053f, -0.19380277f, -0.06209347f, 0.08796135f, 
    0.04542891f, -0.07412007f, 0.08436129f, 0.13627917f, -0.04682923f, -0.03507442f, 0.07026679f, 0.09298466f, 
    0.12959670f, 0.16020988f, 0.07250327f, -0.02480047f, -0.00669788f, -0.03733679f, -0.01278857f, 0.02137125f, 
    -0.06573631f, -0.01240886f, 0.08654360f, -0.16810580f, -0.26601636f, -0.03959541f, -0.16035208f, 0.06244657f, 
    -0.07426438f, 0.09265964f, 0.00401504f, 0.12612832f, -0.23591517f, 0.20630018f, -0.02173243f, 0.19231609f, 
    0.02452508f, -0.36901844f, 0.44905445f, -0.10721805f, -0.11808864f, -0.04093315f, -0.10604183f, -0.25134137f, 
    0.04751784f, 0.18202700f, -0.05688028f, 0.11587308f, 0.16367948f, 0.07184670f, -0.07113958f, -0.06382498f, 
    0.02082076f, 0.04653760f, 0.09414283f, 0.22220905f, -0.07556234f, -0.07411569f, 0.01367207f, -0.17748146f, 
    -0.07556003f, 0.05563506f, -0.17780173f, -0.06912327f, -0.02248923f, -0.02606737f, 0.17894271f, 0.11014958f, 
    -0.00851153f, 0.16861674f, 0.17036588f, 0.12666324f, -0.22056481f, 0.36329311f, 0.11476541f, 0.28767422f, 
    -0.18957667f, -0.03443422f, 0.04545306f, 0.35931346f, 0.00344959f, 0.10131131f, 0.04163797f, 0.07891127f, 
    -0.16789547f, -0.19156753f, 0.10873181f, 0.21186759f, 0.00567222f, 0.19146398f, -0.19644538f, -0.10758188f, 
    0.07837587f, 0.06081676f, -0.07085387f, 0.04910096f, 0.02051403f, 0.38148588f, -0.02593039f, -0.04860236f, 
    -0.07897954f, 0.07621715f, -0.11046646f, 0.15229096f, -0.00552993f, 0.12875868f, -0.05111265f, -0.07252575f, 
    -0.54610771f, -0.06293031f, -0.12361875f, 0.36090109f, -0.04590407f, -0.13750218f, -0.04166352f, 0.13863470f, 
    -0.14111407f, -0.11835081f, 0.03097947f, 0.05319681f, 0.07600874f, -0.02077567f, 0.31425640f, -0.06392924f, 
    -0.03831427f, 0.17524934f, -0.13364489f, 0.08526247f, 0.01990206f, -0.05710869f, -0.09806935f, -0.05930331f, 
    0.30784279f, -0.01576373f, -0.02817185f, 0.14892593f, -0.09775110f, -0.14784743f, -0.00644679f, -0.15089233f, 
    0.08264349f, 0.04331321f, -0.00046747f, -0.07441737f, 0.09795170f, -0.06268990f, -0.22329603f, -0.26986030f, 
    0.01657320f, -0.09740170f, -0.05217816f, 0.04993945f, -0.02190257f, 0.10214622f, -0.00258911f, -0.01656161f, 
    -0.44123358f, 0.26223060f, 0.45306253f, -0.01287145f, -0.13041767f, 0.01419522f, 0.10230609f, 0.02755965f, 
    -0.07940149f, 0.08833326f, -0.01381265f, -0.03327210f, 0.40515068f, -0.00138808f, -0.15084931f, 0.09834772f, 
    -0.00591580f, 0.18668844f, 0.05858284f, -0.09766395f, -0.11635207f, 0.06027632f, -0.00238133f, -0.10356971f, 
    0.04705587f, 0.02032740f, 0.01494958f, 0.10609479f, 0.09545086f, 0.08927658f, 0.04324841f, -0.18584682f, 
    0.23231004f, 0.12955961f, 0.17481999f, 0.04569595f, -0.29889131f, -0.10560696f, 0.14540458f, -0.27343112f, 
    0.00138161f, -0.06572863f, -0.20225757f, -0.06685100f, -0.13235934f, -0.11780383f, 0.02710906f, -0.03018579f, 
    -0.10394684f, -0.25813717f, 0.31696290f, 0.16928488f, 0.07904073f, 0.13882725f, -0.05964287f, -0.00046430f, 
    0.03495822f, -0.01616958f, 0.00374609f, 0.03941814f, 0.02782162f, 0.00409178f, -0.24992213f, 0.04758748f, 
    -0.01474370f, -0.01371618f, 0.05295943f, 0.14938906f, 0.18363975f, 0.07491860f, 0.05536323f, 0.18802413f, 
    0.10827535f, 0.32485685f, -0.08220203f, -0.10121132f, 0.12026987f, 0.20081851f, -0.05724211f, -0.14162205f, 
    0.02054895f, -0.00782930f, 0.11156709f, -0.21423081f, -0.34140456f, -0.11708678f, 0.05951702f, -0.01045279f, 
    -0.01221735f, 0.03704721f, -0.09145091f, -0.11135428f, 0.02292951f, 0.02574798f, 0.01669320f, -0.04644164f, 
    -0.23768416f, 0.19666702f, -0.04149343f, -0.20665132f, 0.01424727f, 0.07240841f, 0.00205864f, 0.22124501f, 
    0.08654822f, 0.10800375f, 0.02483357f, 0.03874358f, 0.27923423f, -0.42805353f, -0.22440401f, -0.30711970f, 
    -0.07062696f, -0.02180609f, -0.05425306f, 0.09784260f, 0.18138298f, 0.03362853f, 0.14830682f, 0.01731089f, 
    0.20823853f, 0.23367971f, 0.23916806f, -0.08862517f, 0.01175017f, 0.04835595f, 0.17996663f, -0.05627991f, 
    0.06157553f, -0.09219424f, -0.04899608f, 0.14999160f, -0.00714236f, -0.35803521f, -0.19352332f, -0.07192229f, 
    0.11918978f, -0.03497580f, 0.01794131f, -0.01251398f, 0.01732203f, 0.09171535f, -0.01526699f, 0.08277349f, 
    -0.22888984f, 0.10996940f, 0.18952133f, 0.19013883f, -0.18176228f, 0.05302651f, -0.05702716f, -0.01956118f, 
    0.00075309f, -0.03852265f, 0.06594180f, -0.01476390f, 0.00511680f, 0.12286249f, -0.14016178f, -0.15281570f, 
    0.05833092f, 0.22110297f, 0.09393982f, -0.00785419f, -0.05443012f, 0.03674290f, -0.00529900f, 0.05489821f, 
    -0.42952952f, -0.20220479f, 0.15928829f, -0.04314899f, -0.10589917f, -0.03516201f, -0.08406438f, -0.09182829f, 
    0.03794792f, 0.06606700f, 0.00389836f, 0.00061975f, 0.14445907f, -0.08589204f, 0.15806843f, 0.18900174f, 
    -0.06168575f, -0.11483171f, 0.00161386f, -0.13201967f, 0.02433367f, 0.00228437f, 0.21776205f, 0.20149361f, 
    0.20111725f, -0.04508846f, -0.35979104f, -0.16623768f, 0.11664357f, 0.12231329f, -0.09779529f, 0.13011383f, 
    0.03079498f, 0.04201021f, -0.06848452f, -0.06204094f, -0.23581469f, -0.18034534f, 0.22628899f, 0.22003365f, 
    0.10321114f, 0.11555987f, -0.05337740f, 0.08453723f, 0.01912340f, 0.13603567f, -0.07809781f, -0.00394446f, 
    0.17123805f, 0.02177891f, -0.03963796f, -0.19275077f, -0.06020857f, 0.02985979f, 0.02003486f, 0.17011838f, 
    -0.02501181f, -0.06051448f, 0.12807062f, -0.03853285f, 0.30179653f, 0.19933470f, 0.19850093f, 0.29600045f, 
    -0.02613115f, -0.10688413f, 0.03428616f, -0.10449814f, -0.04998434f, -0.08125304f, -0.12686791f, 0.00201667f, 
    0.19334388f, -0.04524592f, -0.23269144f, 0.37442487f, -0.01853475f, -0.01628065f, 0.05019610f, -0.07058807f, 
    -0.13106303f, -0.00773902f, -0.14691198f, 0.01621597f, 0.16647555f, -0.13593678f, 0.04525946f, 0.19280957f, 
    -0.05324351f, 0.06496976f, 0.03121427f, 0.08424786f, 0.08952306f, -0.18778569f, -0.04278705f, 0.05214766f, 
    0.47770113f, -0.31796244f, -0.16780455f, -0.02412039f, 0.18122816f, 0.00993520f, 0.21623433f, 0.02587046f, 
    0.16451007f, 0.08761376f, 0.13318621f, -0.03056338f, 0.18174231f, 0.21471649f, -0.07489148f, -0.21772262f, 
    -0.01730843f, 0.03038817f, 0.04151094f, -0.02650931f, 0.03344372f, 0.00934298f, 0.06664741f, 0.16528401f, 
    0.20134735f, 0.07119706f, -0.05336474f, -0.14931023f, -0.03232568f, 0.10142131f, 0.17504707f, 0.13769524f, 
    -0.10094254f, -0.09582299f, 0.02690599f, -0.07497975f, -0.12884067f, -0.42242613f, -0.07713205f, 0.00694788f, 
    0.19630907f, 0.03741834f, 0.06139755f, 0.08388615f, 0.06094429f, -0.01482018f, -0.04248047f, 0.00127480f, 
    0.29103181f, -0.18540996f, 0.05912348f, 0.21937679f, 0.23367260f, 0.13984728f, 0.05881458f, -0.03563424f, 
    0.06488671f, 0.04976226f, -0.01524139f, -0.04342844f, 0.24366885f, 0.77809656f, -0.15311426f, 0.10978463f, 
    -0.04428893f, 0.09284495f, 0.02994842f, 0.02614671f, -0.08072472f, 0.10449884f, -0.02330262f, -0.02909601f, 
    -0.31993335f, -0.28703326f, -0.02641241f, -0.07891179f, -0.00539037f, 0.13409418f, 0.03995147f, -0.05002245f, 
    0.06050672f, -0.01180141f, 0.14871639f, 0.22667626f, -0.05584688f, 0.02820468f, 0.10418999f, 0.00781080f, 
    0.13375071f, 0.24397047f, -0.04827689f, 0.02288023f, 0.02516382f, -0.04751490f, -0.01977567f, -0.09338804f, 
    -0.10936182f, -0.47743350f, -0.29125667f, -0.10200486f, 0.11249085f, 0.06468990f, -0.02952948f, -0.08541013f, 
    0.18203783f, 0.13343276f, 0.20113425f, -0.06393825f, -0.37961420f, 0.15995868f, -0.41371578f, -0.11994412f, 
    0.02156831f, -0.01155418f, -0.03446037f, -0.10212834f, 0.17455505f, 0.02032319f, 0.07696892f, 0.10529281f, 
    0.00083740f, -0.24797970f, -0.22265190f, -0.05128064f, 0.25575155f, 0.13149256f, 0.11703930f, -0.02389348f, 
    -0.05434706f, -0.00792657f, 0.07419809f, 0.05047163f, 0.42802685f, -0.18151841f, 0.06714786f, 0.00028198f, 
    0.11029174f, -0.08115001f, 0.13140422f, -0.19042356f, -0.13968210f, 0.01098133f, 0.09404343f, 0.04428032f, 
    0.01788120f, -0.08070643f, -0.13058028f, 0.10797989f, 0.15897651f, 0.13201708f, -0.08386081f, 0.19939969f, 
    -0.19518171f, -0.13061085f, 0.07658020f, -0.00687740f, -0.11596047f, 0.11624454f, 0.23341765f, 0.11861471f, 
    -0.00340570f, -0.00126235f, -0.07781424f, -0.15081689f, 0.04148874f, -0.02339719f, -0.00064667f, -0.06329481f, 
    0.07356946f, 0.03086407f, 0.31061628f, 0.05416957f, 0.13322611f, -0.16839363f, -0.10116784f, -0.04197945f, 
    0.04434551f, -0.10505320f, -0.00007837f, 0.12645860f, 0.07825786f, -0.18067408f, -0.18369175f, 0.10093181f, 
    0.01552437f, -0.01190965f, -0.09358875f, 0.06204306f, 0.08635461f, -0.12100698f, -0.05217728f, -0.31813118f, 
    -0.03354247f, 0.16497400f, -0.06640706f, 0.14628914f, -0.00775190f, 0.08595325f, -0.12999587f, 0.14168316f, 
    -0.01610605f, -0.06879205f, 0.10971935f, -0.05912579f, 0.14537938f, -0.05674794f, 0.19786097f, 0.21762721f, 
    -0.03090615f, -0.15868294f, 0.07535034f, -0.09545245f, 0.04029880f, 0.08639041f, -0.02439854f, -0.01574193f, 
    -0.23013395f, 0.29325807f, 0.10923117f, -0.16889079f, -0.00955996f, 0.11028063f, -0.10890056f, -0.01441024f, 
    -0.04535509f, -0.06832318f, -0.06673247f, 0.19647413f, 0.04302016f, -0.26345158f, 0.04720958f, -0.14470498f, 
    -0.08044913f, 0.09872737f, 0.19513807f, 0.08960173f, -0.00135182f, -0.06322328f, 0.01747351f, 0.10577264f, 
    0.29479134f, 0.22348718f, 0.38291219f, 0.24623650f, 0.07386498f, 0.08033543f, 0.09107754f, 0.02766543f, 
    0.18137199f, -0.03212298f, -0.07503312f, 0.02070967f, 0.24119240f, -0.05006281f, -0.17486224f, -0.34033668f, 
    -0.09050053f, -0.06542475f, 0.21225190f, 0.09583491f, 0.00590599f, 0.05295942f, 0.01266978f, 0.02784554f, 
    0.30338049f, -0.23326910f, 0.18824250f, -0.20087928f, -0.11927797f, 0.12666875f, 0.01846354f, 0.20302668f, 
    0.22272620f, -0.10688082f, -0.17025575f, -0.03388054f, 0.07228882f, 0.13269056f, 0.06135157f, 0.07009989f, 
    0.01452162f, 0.17478956f, -0.02730291f, -0.15217046f, 0.05809863f, -0.09764944f, -0.02783350f, -0.00175669f, 
    0.27699932f, -0.42960042f, -0.44450966f, -0.08475143f, 0.09970688f, 0.09738849f, -0.02890540f, 0.01179541f, 
    0.08039464f, -0.01737182f, 0.03150678f, 0.00707440f, 0.19290955f, 0.13220346f, -0.17895217f, 0.13074031f, 
    -0.01735877f, -0.04303227f, -0.01347923f, 0.02078920f, -0.11332598f, -0.11252491f, 0.07827774f, -0.20701405f, 
    0.07103590f, -0.08790639f, 0.07720051f, -0.29016402f, -0.00977328f, 0.05242219f, 0.16932613f, -0.03495605f, 
    -0.02692744f, 0.02229726f, 0.07158772f, -0.08555341f, 0.10120656f, -0.26439083f, -0.17829768f, 0.24428965f, 
    0.16360034f, -0.04799462f, 0.07267839f, -0.07600883f, -0.04499009f, 0.15740454f, -0.19297746f, 0.07627138f, 
    0.10759471f, 0.07394338f, -0.15567267f, 0.00206589f, 0.00523835f, 0.11743698f, 0.00583842f, 0.00818370f, 
    0.19197619f, -0.16416721f, 0.16187444f, 0.00838790f, 0.01438269f, 0.04725324f, 0.13205712f, 0.15509014f, 
    0.07569281f, -0.00971811f, 0.03031679f, -0.00361973f, 0.11010370f, -0.04675366f, 0.13011084f, 0.04173391f, 
    -0.17907199f, -0.25419632f, 0.13142163f, 0.15545170f, 0.12625387f, -0.06255397f, -0.19011314f, 0.00411604f, 
    0.11743809f, -0.01673195f, -0.04286281f, -0.01390354f, 0.17523852f, -0.24443285f, -0.09447004f, 0.11684273f, 
    -0.00099427f, 0.10370618f, 0.13301188f, 0.04481094f, -0.00098047f, -0.26190645f, -0.04655719f, 0.14250663f, 
    -0.04206314f, 0.18709524f, -0.21343409f, 0.12691687f, 0.19303270f, 0.05509050f, -0.16743061f, -0.18845323f, 
    0.03331047f, -0.06353725f, 0.24136244f, 0.07794394f, 0.17414421f, 0.37919724f, 0.28892758f, -0.09862898f, 
    -0.01107050f, 0.02529023f, 0.05986823f, 0.14746360f, 0.00213095f, -0.08582488f, 0.05108710f, 0.03563730f, 
    -0.10010856f, 0.00481654f, 0.10516203f, 0.07933833f, 0.16252206f, 0.11753000f, -0.08072651f, -0.02282993f, 
    0.02025626f, -0.04435703f, -0.13179164f, -0.14036217f, -0.00909616f, 0.20169270f, -0.26256227f, 0.03917124f, 
    0.00387155f, 0.10751675f, -0.06087808f, -0.11258103f, 0.27439159f, 0.12069411f, 0.14072005f, -0.11009502f, 
    -0.26072952f, 0.06869374f, -0.21637361f, -0.17481405f, -0.05652291f, 0.05618318f, -0.07722278f, -0.03609947f, 
    -0.07480461f, -0.02633832f, 0.07165368f, 0.08070517f, 0.13707058f, -0.07435236f, 0.13120666f, 0.55635011f, 
    0.02911298f, -0.13438986f, 0.02061644f, -0.19270310f, 0.07315545f, 0.03723120f, 0.05982539f, 0.11735919f, 
    -0.07508115f, 0.38506156f, -0.10150883f, -0.22660750f, -0.01633573f, 0.02470993f, -0.15504357f, 0.11805774f, 
    -0.16605510f, 0.00771586f, 0.10121347f, -0.19145338f, -0.11422013f, 0.06247179f, -0.00962079f, 0.08884536f, 
    -0.15020125f, 0.05716737f, 0.21172734f, 0.09396941f, -0.12284011f, 0.10657442f, 0.07204749f, 0.13402835f, 
    -0.06319822f, 0.23595504f, 0.32179755f, -0.09528310f, -0.08553001f, 0.06923905f, 0.02005640f, 0.05585871f, 
    -0.21194072f, 0.06349476f, 0.08235707f, -0.01031016f, 0.24611053f, -0.06598216f, 0.24491541f, -0.02648764f, 
    -0.11760549f, -0.01171862f, 0.00208066f, 0.03349930f, 0.07488474f, 0.00357227f, 0.01554620f, -0.00259077f, 
    0.11782030f, 0.33603290f, -0.01134677f, 0.16765133f, 0.08453016f, 0.06958435f, 0.05333015f, 0.06896587f, 
    0.02990042f, -0.01651250f, -0.05701424f, -0.01700079f, -0.21029246f, 0.09467974f, 0.30060050f, -0.05346907f, 
    -0.02876041f, 0.06458342f, -0.00200969f, 0.11642193f, 0.13046168f, -0.03390123f, 0.18210073f, -0.04025894f, 
    0.04300027f, -0.19697608f, -0.04024732f, 0.02505988f, -0.11242700f, 0.02453526f, -0.02380031f, 0.02723164f, 
    0.00470279f, 0.03561786f, -0.11637512f, 0.10110975f, 0.12022898f, 0.01622319f, -0.07973468f, -0.01045115f, 
    -0.19707875f, -0.08548853f, 0.04828222f, 0.00939019f, -0.11534819f, 0.02306100f, -0.00294390f, 0.07840873f, 
    0.14094108f, 0.27455708f, -0.07806044f, -0.06200991f, -0.14074495f, 0.05883798f, -0.01623114f, -0.00920083f, 
    -0.04315828f, 0.09830870f, 0.12186377f, -0.10039742f, -0.17192419f, 0.33224717f, 0.15974578f, -0.03055012f, 
    -0.05419989f, -0.03078699f, -0.08132429f, -0.06652856f, -0.13173236f, 0.11232010f, 0.11578967f, -0.17559183f, 
    0.22106384f, -0.46290660f, 0.16106082f, -0.18365358f, 0.03815321f, -0.02588096f, 0.28436360f, 0.03843831f, 
    -0.13410653f, 0.04253299f, -0.06341612f, 0.13347167f, 0.06039419f, 0.04775082f, -0.16316037f, -0.03694938f, 
    0.04736759f, 0.14910817f, -0.01994074f, -0.06509452f, 0.00374378f, -0.04685465f, -0.05984439f, -0.07066345f, 
    0.06036619f, 0.10971872f, -0.06956654f, 0.08004688f, 0.01919977f, 0.19119328f, 0.18410365f, -0.00120148f, 
    0.19770004f, 0.29683399f, 0.14208466f, 0.55065024f, -0.43556651f, -0.11454377f, 0.10162730f, 0.00848513f, 
    -0.25819594f, 0.06864029f, 0.09397561f, -0.09086689f, 0.02708466f, 0.10896672f, 0.08317027f, -0.00392471f, 
    0.29382181f, 0.11641770f, 0.06865229f, 0.01542009f, 0.14607075f, -0.01450784f, -0.00541209f, 0.14603406f, 
    0.05091659f, 0.12729903f, 0.07745074f, -0.25941926f, 0.17000411f, -0.00293384f, 0.12136915f, -0.10014253f, 
    0.16856581f, -0.15563665f, -0.09288710f, -0.03118928f, -0.16050087f, 0.11523881f, -0.25850591f, -0.21312734f, 
    0.28901079f, 0.04043718f, 0.34694257f, -0.19172214f, -0.09772898f, 0.22338741f, -0.03818320f, -0.13105704f, 
    0.17530596f, 0.05302958f, 0.08588780f, -0.04908541f, 0.04929116f, 0.06634971f, 0.21040055f, 0.03037352f, 
    0.13748892f, -0.02881798f, -0.13584097f, -0.09700084f, -0.24442284f, -0.31597459f, -0.35238096f, -0.61975843f, 
    0.55182654f, 0.47335041f, -0.11091533f, -0.16468041f, -0.01547398f, -0.03164018f, -0.05860221f, 0.07112312f, 
    0.22791384f, 0.03440254f, -0.14916421f, -0.03481612f, 0.05463130f, 0.26188800f, -0.15355563f, -0.14557174f, 
    -0.21942206f, 0.00228007f, 0.02816661f, -0.39913368f, -0.06469780f, 0.03144791f, 0.09237918f, -0.11242899f, 
    -0.19058959f, 0.08408416f, 0.10573755f, 0.05312366f, -0.03087325f, 0.02125181f, 0.17268391f, -0.03918151f, 
    0.06527789f, 0.06055867f, -0.02160548f, 0.08518244f, 0.00867371f, 0.24991618f, -0.08345820f, -0.01072529f, 
    -0.21388221f, -0.00696972f, 0.14643428f, -0.30886638f, -0.05339280f, -0.23760016f, -0.22143942f, -0.00348800f, 
    0.09869343f, 0.13668855f, -0.02896078f, 0.16384029f, -0.01754349f, -0.11251605f, 0.12288287f, -0.03101692f, 
    0.31874090f, 0.29535568f, 0.27585295f, 0.25339481f, -0.24324195f, -0.01818592f, 0.02495013f, -0.10897912f, 
    0.01534256f, 0.09614387f, -0.29540208f, -0.06803098f, -0.12908655f, -0.35990030f, -0.08109590f, 0.12554118f, 
    -0.39360738f, 0.05069355f, 0.01907324f, 0.01857465f, -0.01059932f, 0.08053425f, -0.21642585f, -0.30900535f, 
    -0.08445018f, -0.22506963f, -0.01857044f, -0.19800404f, -0.15107895f, -0.23707646f, 0.03074350f, -0.05697024f, 
    -0.18974864f, -0.13659990f, -0.04331823f, -0.03813955f, 0.04121338f, 0.35219896f, 0.18471053f, 0.34879982f, 
    -0.55684012f, 0.34834677f, 0.03108238f, 0.40679768f, 0.11251312f, -0.03302772f, -0.09044280f, 0.15294817f, 
    0.00124224f, 0.15898414f, 0.19208400f, 0.09835285f, 0.03965868f, 0.05865892f, -0.01525150f, 0.03920957f, 
    0.16919696f, -0.00346668f, 0.11453864f, 0.25132135f, 0.05242058f, -0.02589522f, 0.09242789f, -0.02922895f, 
    0.08322243f, -0.11754116f, -0.09920581f, 0.04403131f, -0.02138136f, -0.06373207f, 0.24346107f, 0.07636377f, 
    -0.07403602f, -0.05599969f, -0.06161452f, -0.20597972f, -0.40607977f, -0.29647803f, -0.22004507f, 0.12005699f, 
    -0.00769067f, -0.01501354f, -0.05562322f, 0.09551268f, 0.02244633f, -0.03873881f, -0.04135395f, -0.14201868f, 
    0.07992864f, -0.18040338f, -0.09918603f, 0.16262108f, -0.00696386f, 0.16747180f, 0.00723156f, 0.02961909f, 
    -0.06121720f, 0.12493661f, -0.05421216f, 0.00110250f, 0.09053911f, 0.75206679f, 0.06444506f, 0.02717340f, 
    -0.11017738f, 0.16065618f, -0.00511194f, 0.09843734f, -0.03164636f, -0.03912198f, 0.00374692f, 0.00424435f, 
    -0.13049291f, -0.05133956f, -0.22568251f, 0.14204063f, 0.12188981f, 0.01823564f, 0.08101925f, -0.16915558f, 
    -0.01946145f, 0.05460551f, 0.11154565f, 0.10797989f, -0.05321108f, 0.07052049f, 0.17621441f, 0.01576605f, 
    -0.03288471f, 0.08776690f, -0.05178477f, 0.15521604f, 0.00066021f, 0.04210293f, 0.09827459f, 0.05090766f, 
    0.35630646f, 0.07958132f, -0.06655163f, -0.18032810f, -0.04397342f, -0.00075598f, 0.03940172f, -0.00761528f, 
    0.16274413f, 0.18921837f, 0.11664402f, -0.11855596f, -0.11459678f, 0.17358662f, -0.10882219f, -0.25137708f, 
    0.07670470f, 0.00262029f, 0.09974260f, -0.08030295f, 0.13684128f, 0.03866290f, 0.10438453f, 0.14542419f, 
    -0.28326154f, 0.02208131f, -0.02926418f, 0.17807057f, 0.12464824f, 0.08173099f, 0.16476849f, 0.07335874f, 
    -0.00331669f, 0.06585648f, -0.03331479f, 0.08165315f, 0.49358633f, 0.03680216f, 0.19192691f, -0.11412620f, 
    0.08391408f, 0.04475910f, -0.02710690f, -0.08776179f, -0.04121470f, 0.15914789f, 0.12774169f, 0.06818843f, 
    -0.19135982f, -0.12738892f, -0.05125241f, 0.07512785f, 0.10603252f, 0.04910842f, 0.06650119f, 0.03688198f, 
    -0.20356169f, 0.07414258f, -0.06712727f, -0.18287116f, -0.07598601f, 0.17618161f, 0.19619180f, -0.03213855f, 
    -0.07347320f, -0.09760647f, -0.04808271f, -0.05858959f, 0.03879319f, 0.06124232f, -0.00770052f, 0.03488312f, 
    -0.03466064f, 0.16347094f, 0.29857382f, -0.04474592f, -0.05343850f, 0.04285498f, 0.13896099f, 0.01382475f, 
    0.08045577f, -0.01363290f, -0.00608661f, 0.09005880f, -0.10724880f, 0.18349136f, -0.13568315f, 0.03140324f, 
    -0.01240428f, -0.13112156f, -0.15784891f, -0.04773893f, 0.05078259f, -0.00400233f, -0.10301200f, -0.31826377f, 
    -0.12959521f, 0.05056800f, 0.06086114f, 0.24037200f, -0.13527848f, 0.07004713f, 0.01569642f, 0.13518323f, 
    -0.09664509f, -0.09022827f, 0.00003294f, -0.12519969f, -0.06766896f, -0.20279685f, 0.05061591f, 0.26266143f, 
    0.06529989f, -0.04979601f, -0.06107453f, -0.00488823f, 0.02358065f, 0.08913865f, 0.07389161f, 0.03028413f, 
    -0.18388832f, -0.19523257f, 0.27565378f, -0.07871062f, 0.18124181f, 0.10109130f, -0.05541715f, 0.15141381f, 
    0.05507386f, -0.01442500f, -0.11765225f, -0.21602060f, 0.18235889f, 0.08957721f, -0.06425596f, 0.02649667f, 
    -0.03167936f, -0.02560045f, 0.02469670f, -0.01656242f, 0.22272187f, -0.01445858f, 0.10475547f, -0.01474005f, 
    -0.25802693f, 0.13269188f, -0.20425449f, -0.23093933f, 0.02400585f, 0.05848473f, 0.09361681f, -0.00384012f, 
    -0.01669614f, 0.06032924f, 0.07867142f, 0.09666545f, -0.09826690f, -0.53538090f, 0.30267784f, -0.05865889f, 
    0.02051343f, -0.03525382f, -0.09747145f, -0.10001617f, 0.13502501f, -0.08321623f, 0.09809145f, 0.08094085f, 
    0.02956589f, -0.14567074f, 0.10444625f, 0.05217003f, -0.06861839f, -0.16994318f, -0.13639161f, 0.02822057f, 
    -0.06110860f, 0.10760324f, 0.06152318f, 0.04050680f, -0.17715462f, 0.06478767f, -0.19426495f, 0.07976763f, 
    0.19382580f, -0.08378326f, 0.27680403f, 0.02977486f, 0.05978362f, 0.09667306f, 0.18935819f, 0.20553026f, 
    -0.17068249f, 0.31197175f, 0.34955779f, -0.02784006f, -0.16324176f, 0.07354698f, -0.04680976f, 0.01239356f, 
    -0.06454741f, 0.10405331f, 0.14989838f, 0.13234334f, 0.16717139f, -0.05616940f, 0.42772579f, 0.16211191f, 
    -0.13738625f, -0.08298978f, -0.00361791f, 0.00684019f, 0.06474266f, -0.02296672f, 0.05571197f, 0.07519534f, 
    0.27284142f, -0.25039455f, -0.18961969f, -0.02657809f, 0.20370455f, 0.23685376f, 0.01368286f, 0.22226825f, 
    0.07825230f, 0.04110570f, -0.03610330f, -0.03626376f, -0.28851071f, 0.23924752f, -0.03419226f, 0.35482559f, 
    0.03376269f, 0.04105879f, 0.17027658f, -0.00880842f, 0.13724758f, 0.04240846f, 0.21127023f, -0.11700889f, 
    -0.05977052f, 0.28226846f, 0.06270698f, -0.05554573f, -0.08295523f, -0.11840774f, 0.02899293f, 0.00420600f, 
    -0.08627301f, -0.06742796f, -0.15614060f, -0.11395278f, -0.15578133f, -0.02957832f, -0.21592547f, -0.11930928f, 
    -0.07475068f, -0.00807916f, 0.02592300f, -0.02838690f, 0.02640367f, 0.03725524f, -0.20601952f, 0.06438635f, 
    -0.22618212f, 0.05311220f, -0.32883772f, -0.02165299f, 0.01319798f, -0.08011035f, -0.02382920f, 0.09687635f, 
    0.01738016f, 0.05634715f, -0.12159411f, 0.25320768f, 0.02443900f, 0.19138157f, 0.26537722f, -0.05983680f, 
    0.04334088f, -0.04748467f, -0.05985707f, -0.13422021f, 0.11771064f, -0.14935070f, 0.16297032f, -0.15807183f, 
    -0.00196834f, -0.06149302f, -0.37399849f, -0.11448416f, 0.11830892f, 0.15696943f, 0.30461913f, 0.08996716f, 
    -0.15681227f, 0.00005949f, -0.12039910f, 0.10239312f, 0.19663824f, 0.05537589f, -0.13180090f, -0.11989971f, 
    0.06816220f, 0.24395172f, 0.11792939f, -0.06169916f, -0.06382482f, -0.04740085f, -0.00942133f, 0.09365866f, 
    0.03720927f, 0.02074686f, 0.07168855f, -0.27944252f, 0.10448857f, -0.09728627f, 0.08279725f, 0.23858711f, 
    -0.00502788f, -0.06754685f, -0.07427912f, 0.06343389f, 0.05450913f, 0.28872743f, -0.08365402f, 0.10848002f, 
    -0.01159292f, 0.01781254f, -0.02997244f, 0.15070584f, 0.03214408f, -0.08387361f, 0.00524377f, 0.22898677f, 
    -0.20266171f, -0.13181672f, -0.01754138f, 0.09578728f, 0.25905141f, 0.31789050f, -0.04598548f, -0.10354249f, 
    0.03199271f, -0.08656219f, -0.11896823f, -0.02131856f, 0.12726966f, 0.56356555f, -0.19412673f, -0.05431405f, 
    -0.17116062f, -0.02411289f, 0.20506123f, 0.36047897f, 0.05154678f, 0.04800232f, 0.08194552f, -0.06784163f, 
    -0.76807678f, -0.37703505f, 0.25925580f, 0.13651158f, 0.01624819f, 0.14661372f, -0.04570904f, 0.12151558f, 
    -0.01636392f, -0.04273241f, -0.05188289f, -0.07522615f, -0.06542150f, 0.14663722f, 0.03413130f, -0.01495431f, 
    0.00167807f, 0.04662928f, 0.23739488f, -0.02685026f, 0.09314048f, -0.13287114f, 0.04043199f, 0.14763615f, 
    0.19377078f, 0.01709170f, -0.17227827f, 0.21871719f, 0.06627341f, -0.16475981f, -0.11564202f, -0.11310538f, 
    0.07384971f, 0.08894940f, 0.06465969f, -0.15417062f, 0.08426140f, -0.17301825f, -0.05462683f, -0.00977563f, 
    0.22655317f, -0.09095339f, -0.07568017f, 0.08453280f, 0.17121315f, 0.02728268f, 0.17655423f, 0.14155987f, 
    -0.08226074f, 0.32052493f, 0.24331433f, -0.18168087f, -0.01774835f, -0.04315577f, 0.08911205f, -0.02061635f, 
    -0.08677901f, 0.02695478f, 0.04498077f, -0.18139587f, -0.00301248f, -0.07199749f, -0.14409105f, 0.38012326f, 
    0.06404177f, 0.00702549f, 0.21683167f, -0.18705265f, -0.16548245f, 0.19561562f, -0.10328091f, -0.08553311f, 
    -0.14236498f, -0.02004430f, -0.11811534f, 0.14932324f, -0.05574479f, 0.03863176f, -0.04615757f, -0.04456411f, 
    0.04120445f, -0.14481638f, -0.05838514f, 0.06632634f, -0.32152295f, -0.41277480f, -0.21447304f, -0.21372579f, 
    -0.00510129f, -0.33546430f, -0.19673811f, -0.14756441f, 0.20710693f, -0.15908699f, -0.02971037f, -0.04203056f, 
    -0.45348042f, -0.17219666f, 0.29262495f, 0.06085237f, 0.00918536f, -0.03088663f, -0.11967834f, 0.01243304f, 
    0.17744099f, 0.07226257f, -0.25665161f, 0.08156668f, 0.06248159f, -0.06324597f, -0.10120952f, 0.13429949f, 
    0.01340497f, 0.04478795f, -0.08885826f, 0.04837853f, 0.25618881f, -0.02439460f, -0.06906126f, -0.12581286f, 
    0.16509195f, 0.20971103f, -0.08856951f, 0.05475244f, -0.01502171f, 0.13946755f, 0.05478153f, -0.11318185f, 
    0.19245209f, -0.00272056f, 0.10654917f, -0.04950993f, -0.13851087f, -0.02142555f, 0.19680879f, 0.04652779f, 
    0.10234083f, 0.13600543f, 0.04963900f, -0.00218381f, 0.14461479f, 0.12409342f, -0.06075685f, -0.08022600f, 
    0.33753455f, -0.25542468f, 0.01393171f, 0.05364097f, -0.03272394f, -0.25068969f, 0.10834676f, -0.04326995f, 
    0.16636255f, 0.08569640f, 0.11175827f, -0.09841842f, -0.12203746f, 0.22274192f, 0.18497112f, 0.11308568f, 
    -0.07879958f, -0.10701038f, -0.06093929f, -0.11900589f, 0.01744972f, 0.01969857f, 0.03110653f, -0.05390040f, 
    -0.27167812f, -0.18204582f, 0.03474920f, 0.13156383f, -0.04235941f, -0.10847016f, -0.02505420f, 0.08745604f, 
    0.02268472f, 0.21524680f, 0.05221481f, -0.07751409f, -0.19089693f, 0.57749712f, 0.32661870f, 0.00529642f, 
    0.05082406f, 0.16468537f, -0.13848196f, 0.07745712f, 0.01687855f, -0.00213874f, 0.13373384f, 0.05171501f, 
    -0.30125213f, -0.03361121f, -0.21791622f, 0.29383507f, 0.13929333f, -0.11639497f, -0.02032098f, -0.29615209f, 
    -0.15295969f, 0.01559415f, -0.07009352f, 0.15527421f, 0.01978892f, -0.04888112f, 0.23169969f, 0.03963987f, 
    -0.02305604f, -0.15009242f, -0.06556053f, -0.01844321f, 0.11951362f, 0.02600753f, 0.02004927f, 0.05321700f, 
    0.18655887f, 0.41892543f, 0.03961945f, 0.14270315f, -0.00186373f, -0.15797304f, -0.05588489f, -0.11106842f, 
    -0.08448298f, 0.01126276f, -0.01111524f, -0.00025896f, -0.36221898f, 0.15139715f, 0.16450098f, -0.13698223f, 
    0.06023008f, 0.04153257f, 0.01478688f, -0.11280930f, 0.01353023f, -0.10388482f, -0.10962421f, 0.05543863f, 
    -0.27724195f, 0.10744503f, 0.11931157f, 0.16712312f, -0.09778856f, -0.00308330f, 0.10551795f, 0.13659270f, 
    -0.00286448f, 0.16381724f, 0.03289717f, 0.12438432f, 0.15347102f, 0.27890417f, -0.14227585f, -0.15482071f, 
    -0.03266721f, -0.00754712f, -0.03392630f, 0.01028191f, -0.02389344f, 0.00461486f, 0.04933827f, -0.01117529f, 
    -0.01016180f, 0.06259795f, 0.26319593f, 0.02559585f, 0.12893461f, 0.05824492f, 0.22656077f, 0.06043516f, 
    0.00532809f, -0.00769665f, 0.02589794f, -0.12675048f, -0.02683097f, -0.26373532f, -0.04360345f, -0.01837195f, 
    -0.10788229f, -0.02150949f, 0.03532496f, -0.10904578f, -0.06313232f, 0.10222020f, -0.09840000f, -0.14553520f, 
    0.03379131f, 0.17306690f, 0.07346980f, -0.20487279f, -0.00649268f, 0.05088400f, 0.16336179f, 0.05703083f, 
    0.02319060f, 0.01755602f, 0.01501003f, 0.01492618f, -0.04405077f, 0.24375185f, 0.02847631f, -0.10633983f, 
    0.01680608f, -0.04002289f, -0.03312095f, 0.10584854f, -0.03969043f, 0.14256725f, 0.01070572f, 0.04253403f, 
    -0.06402595f, 0.24009936f, 0.11738990f, -0.02282308f, -0.10994980f, -0.00548416f, 0.16963930f, 0.03948872f, 
    0.00375849f, 0.02741112f, -0.12624142f, -0.00937369f, -0.25379086f, -0.29561105f, 0.06334855f, 0.26007703f, 
    -0.09143627f, 0.05213982f, 0.03948420f, 0.00620813f, 0.10992724f, 0.23738529f, 0.09028104f, 0.02281128f, 
    0.19893146f, -0.17425616f, -0.19566952f, 0.27685380f, -0.00450550f, 0.11914099f, 0.16649543f, -0.07234845f, 
    -0.00837928f, 0.09897348f, 0.20481554f, -0.03638692f, -0.27597567f, -0.20461704f, -0.06809056f, 0.22030771f, 
    0.05721026f, -0.03118883f, -0.02011707f, 0.13134761f, 0.11883979f, 0.05927289f, 0.01604566f, -0.08735439f, 
    -0.06260318f, -0.25649819f, 0.07271583f, 0.26201370f, -0.08683334f, -0.14793111f, -0.13241327f, -0.10563199f, 
    -0.13565406f, 0.05045440f, 0.01042182f, 0.01181786f, -0.05531330f, 0.40175766f, 0.00581431f, 0.25392815f, 
    0.03223459f, 0.03643028f, -0.08305390f, -0.14733784f, 0.00842369f, 0.08002643f, 0.03116251f, 0.04209704f, 
    0.27043885f, 0.22665195f, -0.35775059f, -0.31611726f, 0.10775464f, -0.02286411f, 0.03143334f, 0.13667281f, 
    -0.09891363f, 0.07616449f, 0.05261369f, 0.08086581f, -0.04592088f, -0.03232446f, 0.19467176f, 0.06326521f, 
    -0.02333698f, -0.06495168f, -0.05334047f, 0.24642055f, -0.00788460f, 0.05659399f, 0.01572417f, -0.15164801f, 
    0.36223152f, 0.20485088f, 0.00758875f, -0.19841756f, 0.02174247f, -0.09910724f, -0.05671180f, 0.01116582f, 
    0.08403347f, 0.14148678f, 0.02885941f, 0.12266160f, 0.07814840f, 0.07352883f, 0.11049424f, -0.21103597f, 
    -0.05220044f, 0.12107210f, -0.00017606f, -0.05202566f, -0.01243715f, 0.06493094f, -0.15475950f, 0.04006941f, 
    -0.31822696f, 0.13164242f, -0.06623261f, 0.13362212f, 0.01736579f, -0.03938660f, 0.06441744f, 0.09604320f, 
    0.00514310f, -0.01764891f, 0.01038043f, 0.19797496f, 0.24197040f, -0.11094165f, 0.09249225f, -0.49262601f, 
    0.09501933f, 0.00186720f, -0.19782785f, 0.06143899f, 0.02124313f, 0.02377394f, -0.02628451f, -0.09693174f, 
    -0.07130935f, -0.27828965f, 0.06243672f, 0.08721525f, 0.07277428f, 0.04585749f, 0.11705659f, 0.14469633f, 
    0.07528403f, 0.12708877f, 0.00408111f, 0.21712896f, 0.09558595f, 0.27479628f, 0.08822531f, 0.04079184f, 
    -0.03872974f, -0.02985768f, -0.02707356f, -0.09345428f, 0.02457295f, 0.14352246f, 0.00661010f, -0.16572258f, 
    0.36193377f, 0.04206068f, 0.02888961f, -0.06024861f, -0.05512565f, 0.09373027f, -0.01618334f, -0.01318612f, 
    0.03124581f, -0.03470335f, 0.18186335f, -0.05433004f, -0.02547028f, 0.23290597f, -0.08909540f, -0.11952046f, 
    0.00065299f, -0.10114850f, -0.02898734f, 0.05426899f, -0.10285129f, 0.23552087f, 0.07009371f, -0.01339679f, 
    0.22015911f, 0.08128940f, 0.19785032f, 0.07719534f, -0.10184190f, -0.11097668f, 0.21223402f, 0.10318019f, 
    -0.02783446f, 0.07858114f, 0.12539959f, 0.13056143f, -0.18300532f, -0.30415210f, 0.08255547f, 0.30890134f, 
    0.03491037f, -0.06790836f, -0.13397710f, -0.13363861f, 0.06191776f, 0.01539563f, -0.09730342f, 0.09521078f, 
    0.00896432f, 0.30616435f, 0.07522632f, -0.00106483f, 0.19067004f, -0.03495054f, -0.09278151f, -0.02446735f, 
    0.02256698f, 0.14733620f, 0.09241986f, 0.04494467f, -0.04999170f, -0.00641729f, -0.18944645f, 0.18268132f, 
    -0.04922446f, 0.26540115f, -0.02551851f, 0.11978558f, 0.10536055f, 0.12657246f, 0.14256944f, 0.18288881f, 
    0.37906173f, 0.23066701f, -0.01344608f, -0.24579780f, 0.14306767f, 0.31953523f, 0.11737369f, 0.07154723f, 
    0.01082317f, -0.05097760f, 0.00703682f, 0.14193895f, 0.26701069f, 0.03470460f, -0.35688582f, 0.14879018f, 
    -0.17716525f, -0.01191188f, -0.12146762f, 0.00890536f, 0.02503296f, -0.01183510f, 0.09905890f, -0.09078360f, 
    -0.20158955f, 0.19380157f, 0.02666535f, 0.00951075f, 0.06066776f, 0.20001368f, 0.03260426f, 0.00780910f, 
    -0.02700358f, -0.02109556f, 0.06494471f, -0.13962997f, 0.06479869f, 0.00817474f, -0.07671310f, -0.05866676f, 
    0.06906091f, 0.19634733f, 0.12956248f, -0.09437133f, -0.06450818f, 0.04148516f, 0.12171787f, 0.19393401f, 
    0.20557924f, -0.09195177f, -0.03457646f, 0.00515038f, -0.08760756f, 0.08080377f, 0.15752429f, 0.04651337f, 
    -0.03821281f, 0.05028527f, -0.02386260f, -0.20627746f, 0.09627017f, -0.08549658f, -0.16414420f, -0.00424534f, 
    0.03187560f, -0.24205361f, 0.14300896f, -0.08546455f, -0.06212316f, -0.08589392f, 0.12584057f, 0.05855871f, 
    0.29635015f, 0.10539938f, 0.08124284f, 0.10840886f, 0.09264864f, 0.09812662f, -0.02050646f, -0.12047774f, 
    0.16785228f, 0.12871899f, -0.03762113f, -0.01000744f, 0.06758930f, -0.13808861f, 0.27640903f, 0.19350797f, 
    -0.27642649f, 0.04263052f, 0.00248702f, 0.03238094f, -0.05046779f, 0.08136907f, -0.21996517f, 0.06694280f, 
    0.04733390f, 0.01468403f, 0.01805241f, 0.17394206f, 0.05224955f, 0.06741282f, -0.04559528f, -0.02052229f, 
    -0.04796347f, 0.06434757f, 0.06777518f, 0.18066797f, -0.19318444f, -0.01892295f, -0.14227329f, 0.12571585f, 
    -0.00931678f, -0.22302505f, -0.19146143f, -0.12750839f, 0.02092198f, 0.00956444f, -0.06474523f, 0.14194925f, 
    -0.54540360f, 0.07610964f, -0.07104977f, 0.18459034f, -0.20168681f, -0.16300125f, -0.11374074f, -0.12975322f, 
    -0.00592062f, -0.06623754f, -0.02166998f, 0.09955417f, -0.11468643f, -0.05394806f, -0.00008591f, 0.11741470f, 
    -0.04037627f, 0.04924625f, -0.05437726f, -0.05203935f, 0.11316704f, -0.08760364f, -0.07335478f, 0.04422240f, 
    -0.28304601f, -0.30114880f, 0.22301181f, 0.23133618f, 0.04646134f, 0.14795360f, -0.08367335f, -0.24623314f, 
    0.15765162f, 0.01742965f, 0.08482185f, 0.08536012f, 0.16191176f, 0.19744217f, 0.00615462f, -0.18300514f, 
    0.15867531f, 0.13238454f, 0.02065804f, 0.07921444f, 0.02312327f, -0.02695891f, 0.00047814f, -0.00035248f, 
    0.25642037f, 0.09852620f, 0.00312248f, 0.12073057f, 0.04886375f, 0.09326473f, -0.08152707f, -0.14137198f, 
    0.02664839f, 0.01278393f, 0.11679813f, 0.18497032f, 0.18171507f, -0.14402615f, -0.04442428f, -0.04872081f, 
    0.05706142f, 0.01119767f, -0.08990468f, -0.18999690f, 0.18843545f, 0.10477295f, -0.05468627f, -0.11745689f, 
    0.16276732f, 0.14237118f, 0.17803933f, 0.15174188f, -0.00307580f, -0.12386975f, -0.02415944f, 0.04273029f, 
    -0.04594247f, 0.00617499f, -0.01627400f, -0.01000207f, 0.12526931f, 0.11852951f, 0.07968544f, 0.41990229f, 
    0.06034619f, -0.10344300f, -0.06857329f, -0.22218713f, 0.08228028f, -0.05541883f, 0.04127412f, 0.11248800f, 
    0.19979616f, 0.33236158f, -0.04784765f, -0.34534118f, -0.07356508f, -0.03593995f, 0.03887197f, 0.06076371f, 
    -0.03285889f, -0.00833227f, -0.09318774f, -0.05315914f, 0.09969296f, 0.08796278f, -0.01789008f, 0.12069987f, 
    -0.00575575f, -0.15946576f, -0.08559487f, 0.06198232f, -0.12753472f, 0.03674318f, -0.00914680f, -0.21767065f, 
    -0.06239731f, 0.08086155f, 0.13452353f, -0.16823506f, -0.08065832f, -0.14366786f, -0.14083727f, -0.01609845f, 
    -0.20983414f, -0.12973842f, -0.13646257f, 0.04264882f, 0.00980815f, 0.09231608f, 0.02102587f, 0.07575791f, 
    -0.01475906f, -0.00003699f, -0.10547973f, -0.02701892f, -0.11749516f, -0.00244287f, -0.12390205f, -0.02973934f, 
    0.13913037f, 0.22208627f, -0.05489862f, 0.14456247f, 0.00818076f, -0.04110778f, 0.06366598f, -0.06495418f, 
    0.08651712f, -0.15008706f, 0.12388185f, 0.16890247f, -0.16315030f, -0.10296503f, 0.13911740f, -0.35529652f, 
    -0.00125115f, -0.00197787f, -0.21468282f, 0.03408848f, -0.00659328f, -0.14646286f, 0.08220827f, 0.14337398f, 
    0.19652842f, -0.14384466f, 0.09873586f, -0.13890837f, 0.13469952f, 0.04238857f, 0.16078787f, 0.18604986f, 
    0.12713306f, 0.17035355f, 0.02361836f, 0.16534831f, 0.39417708f, 0.05943681f, 0.04771530f, 0.12505417f, 
    -0.00898652f, -0.02969804f, -0.01402741f, -0.06349218f, -0.11098661f, -0.05469848f, -0.04134681f, -0.05208634f, 
    0.50697720f, 0.12784371f, -0.10043950f, 0.02167451f, 0.00542959f, 0.05780280f, -0.07769097f, -0.06520040f, 
    -0.00818480f, -0.12385458f, 0.02816566f, -0.16823253f, 0.12280842f, 0.14152764f, -0.04979230f, -0.01164525f, 
    -0.03672519f, -0.02051948f, -0.04979209f, 0.04799766f, -0.09414943f, 0.27522758f, 0.19722238f, 0.14429717f, 
    0.25015819f, -0.09904363f, 0.28012478f, -0.13625203f, -0.01974792f, -0.15698615f, 0.15220667f, -0.01888763f, 
    0.08368069f, 0.11198556f, 0.04286200f, 0.17180756f, -0.00731769f, 0.04855796f, -0.09941027f, 0.17927650f, 
    0.02796554f, 0.01614784f, 0.01115839f, 0.14957534f, 0.02398344f, -0.01479236f, -0.04791403f, -0.00188036f, 
    0.13973692f, -0.21788435f, 0.20680077f, 0.06453513f, 0.07506442f, 0.12540431f, -0.00566623f, -0.04752920f, 
    -0.02590642f, 0.00577061f, -0.11463047f, 0.02852380f, -0.07504973f, -0.04783251f, -0.06314100f, 0.00318243f, 
    0.09715839f, 0.12268310f, -0.02793402f, -0.08145692f, 0.04187001f, 0.08540611f, -0.02849159f, -0.02190047f, 
    -0.05522599f, -0.17152427f, -0.31382647f, -0.03811315f, 0.20015088f, 0.13579483f, 0.00899667f, 0.17939645f, 
    0.01926751f, -0.04084221f, 0.05177970f, -0.04780043f, 0.29743215f, 0.52787703f, -0.06235219f, 0.31499696f, 
    -0.12779745f, -0.22513393f, 0.06630805f, -0.13843811f, 0.01751599f, 0.14865352f, 0.11864282f, 0.09976100f, 
    0.31076324f, 0.00615100f, 0.16866919f, -0.39092493f, 0.17883793f, 0.12539889f, 0.03097489f, 0.10433376f, 
    0.00982674f, 0.09548852f, 0.10733153f, 0.08255243f, -0.10718152f, 0.00294898f, 0.00714586f, 0.15685184f, 
    0.04699706f, -0.11495785f, 0.28611630f, -0.03034274f, 0.04846924f, 0.08025571f, 0.00083292f, 0.13494907f, 
    0.31557336f, 0.15417999f, -0.23861028f, -0.15069835f, -0.00611796f, 0.06042173f, 0.00612709f, 0.09325435f, 
    -0.26708612f, 0.05034938f, 0.19211277f, -0.01229637f, 0.05111990f, 0.19795911f, -0.04388201f, -0.07967713f, 
    -0.06064072f, 0.06633945f, -0.07680079f, -0.08277529f, 0.01799187f, -0.05717557f, -0.04279650f, -0.08336341f, 
    0.20335798f, -0.03123505f, 0.00003477f, 0.12498669f, 0.07741902f, 0.00110335f, 0.15884143f, -0.12043028f, 
    0.06151950f, 0.03540609f, 0.03848568f, 0.08161992f, 0.28953010f, 0.12036983f, 0.00920556f, -0.07454271f, 
    -0.07910371f, -0.10525805f, -0.03104182f, -0.14372522f, 0.08555555f, -0.01810098f, 0.12896279f, 0.08590612f, 
    -0.12041490f, -0.11966359f, -0.17289408f, 0.16705418f, 0.02605301f, 0.00086613f, 0.02602305f, 0.14883260f, 
    -0.07217465f, 0.12731707f, -0.10354616f, 0.03732505f, -0.20068410f, 0.12444282f, 0.01966181f, -0.01530514f, 
    -0.15269533f, -0.04818648f, -0.01532107f, -0.01172316f, -0.01840356f, -0.02542388f, 0.10022665f, 0.06266686f, 
    -0.09781171f, 0.00293191f, 0.22239286f, -0.17139228f, -0.01825052f, -0.10882564f, -0.14535722f, -0.00019553f, 
    0.13435377f, 0.01955365f, 0.17157534f, -0.08637317f, -0.00373996f, 0.04012014f, 0.03590944f, -0.03131893f, 
    0.01671914f, -0.04491483f, -0.08042510f, -0.17066173f, -0.03843646f, 0.12630002f, -0.04776639f, -0.17110315f, 
    -0.25268170f, -0.10269370f, 0.25598928f, 0.10876902f, -0.06292573f, -0.02811328f, -0.00597192f, 0.08780194f, 
    -0.00791846f, -0.08225546f, 0.10435406f, 0.17464826f, -0.10331473f, -0.04550585f, 0.13113335f, 0.25799048f, 
    0.02194519f, 0.08181307f, 0.07063881f, 0.01302566f, 0.07931523f, -0.04339821f, -0.01055544f, -0.01190339f, 
    -0.03267557f, -0.01838548f, -0.06738092f, 0.02297737f, 0.06845397f, 0.02609415f, -0.03245272f, -0.03286410f, 
    -0.01715073f, 0.02274625f, 0.03477099f, -0.02641980f, 0.04984042f, -0.02216963f, -0.01965737f, 0.02148482f, 
    -0.06933542f, -0.02784002f, 0.06411041f, -0.01885370f, 0.00520371f, 0.02221010f, -0.01012018f, -0.04225115f, 
    -0.06495370f, 0.03330430f, -0.04678401f, -0.04675580f, -0.00711029f, -0.02878409f, -0.05449676f, -0.02714459f, 
    0.01749144f, -0.00418084f, 0.05150053f, 0.04243245f, -0.07839848f, 0.01650319f, -0.05400378f, -0.07230256f, 
    -0.01593569f, -0.07544393f, -0.02949414f, -0.04235611f, 0.04138019f, -0.00976652f, 0.02749118f, -0.02385301f, 
    -0.04691457f, -0.03706450f, 0.06865779f, -0.06815578f, -0.01151605f, -0.04553808f, 0.06919882f, -0.00715829f, 
    -0.04114735f, -0.07031295f, 0.05148061f, 0.00785955f, 0.05107526f, -0.06082047f, 0.00117096f, 0.01153504f, 
    0.03627770f, 0.02715782f, -0.05885155f, -0.07143696f, -0.04847912f, -0.06658921f, -0.08710629f, -0.06451964f, 
    0.04239303f, 0.00693316f, 0.04047287f, 0.05837043f, -0.05021992f, 0.01859857f, 0.06521748f, 0.04555146f, 
    0.02772571f, -0.08212771f, 0.00463223f, -0.06234888f, 0.05583676f, -0.01030874f, 0.03065794f, -0.05431505f, 
    0.06259600f, -0.06380185f, 0.00090720f, -0.00142550f, -0.06789672f, -0.02257708f, -0.00941801f, 0.00015374f, 
    0.06508356f, -0.00310124f, -0.00006991f, -0.08144056f, -0.06211902f, 0.05573460f, 0.00050063f, 0.00254328f, 
    -0.06890606f, 0.02954191f, 0.04986228f, 0.05163533f, -0.04677867f, 0.00597325f, 0.02105616f, -0.03542376f, 
    -0.03439655f, -0.00154605f, 0.02051297f, -0.01030892f, -0.06004904f, -0.01069536f, 0.00314028f, -0.07259780f, 
    0.03208083f, 0.03915740f, 0.02025807f, -0.07922430f, 0.03963153f, 0.03590498f, -0.00443033f, -0.02748111f, 
    0.01520355f, -0.07072642f, -0.06196554f, 0.00497233f, 0.01725539f, -0.03266604f, 0.06477951f, -0.00186490f, 
    -0.01457497f, -0.04398550f, -0.05925250f, 0.05632901f, 0.05903954f, -0.01033849f, -0.05461195f, -0.01599380f, 
    0.02197436f, -0.01686441f, 0.03348302f, -0.06647149f, 0.01907799f, 0.02320432f, 0.05885763f, 0.03862841f, 
    -0.02128814f, 0.02170861f, -0.07344778f, -0.03263195f, 0.03844317f, -0.05668668f, -0.04810689f, -0.07075936f, 
    -0.05285031f, -0.07443115f, 0.05674817f, -0.05555676f, 0.03114079f, -0.06726623f, 0.01076427f, -0.01581639f, 
    0.02827444f, -0.08331288f, 0.05293903f, 0.04773898f, 0.01443517f, 0.03283342f, -0.05716687f, 0.00043885f, 
    0.03062178f, -0.04905748f, -0.02225773f, -0.07282650f, 0.05858064f, -0.04364600f, -0.03825632f, 0.05062298f, 
    0.05466806f, 0.00408641f, -0.01619129f, -0.02249027f, -0.03322747f, -0.02412466f, 0.05557455f, -0.07866791f, 
    -0.23919132f, 0.29009837f, -0.06652011f, -0.12836550f, 0.21905988f, 0.09754277f, -0.05092988f, 0.10047792f, 
    -0.16232149f, 0.01947282f, -0.16942415f, -0.03748530f, -0.08734855f, -0.09246787f, -0.18725491f, -0.04694568f, 
    0.12069477f, 0.18575536f, 0.12344243f, 0.02482266f, 0.23351522f, -0.01662916f, -0.09584484f, -0.06115574f, 
    0.23950408f, 0.29907647f, 0.03997968f, 0.07482949f, 0.12854572f, 0.34076551f, 0.10132263f, 0.09473079f, 
    0.07867390f, 0.03120756f, 0.06592283f, 0.13327043f, 0.39506811f, -0.08794068f, -0.21086790f, 0.23501703f, 
    -0.26396444f, -0.00455494f, 0.03006942f, -0.07002319f, 0.10489768f, -0.01463124f, 0.06328140f, 0.04930015f, 
    -0.29599649f, 0.17961173f, -0.09468718f, -0.07922921f, -0.17584200f, 0.05961185f, -0.09333728f, 0.11070967f, 
    -0.11144476f, 0.05313659f, 0.15758194f, -0.12921299f, 0.04511568f, 0.03567590f, 0.01751686f, 0.04149348f, 
    0.00523935f, 0.26253125f, 0.16304472f, -0.01870853f, -0.06197569f, 0.03334692f, 0.11794993f, 0.15167814f, 
    -0.07911118f, -0.26306486f, 0.07665206f, -0.15756045f, -0.09232487f, 0.00420757f, 0.15484419f, 0.03316198f, 
    0.01381019f, 0.05373274f, 0.05297056f, -0.27237850f, 0.00269611f, -0.19296540f, -0.09904280f, 0.02467157f, 
    -0.09879341f, -0.08485295f, 0.10493078f, 0.03012508f, 0.01063891f, 0.04040277f, 0.05949989f, 0.08132488f, 
    0.41107440f, 0.25425690f, 0.20612836f, 0.10533212f, 0.14335638f, 0.24994880f, 0.02342254f, 0.00979533f, 
    0.05782826f, -0.07869650f, -0.05555891f, -0.06719899f, -0.13652666f, -0.19590983f, 0.35239109f, 0.12616192f, 
    -0.03189659f, 0.13086908f, 0.00997070f, -0.00382085f, 0.00713957f, 0.01504790f, 0.10607366f, 0.06415234f, 
    0.16412586f, -0.00430820f, -0.07487099f, 0.11519440f, 0.03882618f, 0.01222262f, -0.12158514f, 0.05140479f, 
    0.05650750f, 0.00013194f, -0.07118700f, 0.02988664f, -0.02140364f, -0.10156457f, -0.07966337f, 0.06748217f, 
    -0.10052317f, -0.17717142f, -0.06801422f, -0.01221611f, -0.07958590f, -0.00407651f, 0.12723140f, 0.20509464f, 
    -0.07695103f, 0.12477816f, 0.08171343f, 0.19548763f, -0.12057331f, -0.00778804f, -0.03846174f, 0.12083729f, 
    -0.06380574f, 0.05986052f, -0.00283009f, 0.00700992f, -0.14422186f, -0.13731162f, -0.09610570f, 0.10476720f, 
    -0.06789070f, 0.00538477f, -0.03624270f, -0.03564008f, -0.03501119f, -0.12184152f, -0.14750499f, -0.02412139f, 
    0.04430036f, -0.33901194f, 0.13987078f, 0.03852957f, 0.13376322f, 0.07415801f, -0.16798696f, -0.15782475f, 
    -0.03743704f, 0.01276513f, 0.03824876f, 0.13221227f, 0.25099850f, 0.31290665f, 0.09543751f, -0.08720842f, 
    0.05480249f, 0.15401375f, -0.06165951f, 0.03041203f, 0.06104587f, 0.00365665f, 0.00702556f, 0.01554624f, 
    -0.19696240f, 0.17278819f, -0.12183783f, -0.09429199f, -0.05765367f, -0.21762894f, 0.05047686f, -0.06639810f, 
    -0.04354264f, 0.00632239f, -0.05228805f, 0.10956188f, 0.08736312f, -0.04628747f, 0.19371706f, -0.30566356f, 
    -0.21388704f, -0.11153874f, -0.02966394f, -0.07851309f, 0.03208587f, -0.05899709f, -0.00171031f, -0.00401837f, 
    -0.13740072f, 0.23755789f, 0.34038913f, 0.23893890f, -0.19065969f, -0.01933347f, 0.01434124f, 0.09683269f, 
    0.02746998f, -0.00160201f, 0.06703784f, 0.08028393f, 0.05998907f, -0.42744389f, 0.37788957f, -0.25529879f, 
    -0.15325451f, 0.18722787f, -0.09306449f, 0.15241791f, 0.03756184f, -0.04882714f, 0.02737022f, 0.03382976f, 
    0.10013181f, 0.15968166f, -0.32499447f, 0.17377050f, -0.20936958f, -0.02941602f, -0.09930675f, -0.07720141f, 
    0.00169675f, -0.11917994f, -0.13761786f, -0.13263279f, 0.15351649f, 0.12120962f, 0.21269366f, -0.01709939f, 
    0.06672610f, 0.06169337f, 0.03514490f, 0.16492014f, -0.13304411f, -0.05701208f, 0.12564336f, 0.00959491f, 
    0.03916838f, 0.08342744f, 0.06605674f, -0.07423516f, -0.12427759f, -0.17084719f, 0.00849003f, -0.00313464f, 
    0.06347222f, 0.06899049f, -0.00310488f, 0.01783776f, 0.13581577f, -0.02458332f, 0.03702176f, 0.13543050f, 
    -0.02258473f, 0.03815255f, 0.01368365f, -0.12925166f, 0.00827670f, 0.00859948f, 0.05265041f, 0.01708748f, 
    -0.06732488f, 0.06416106f, 0.13804144f, -0.15841012f, -0.12951115f, -0.13876812f, 0.01750688f, 0.10884356f, 
    -0.04548068f, 0.02994307f, 0.03309883f, -0.11946163f, -0.17216758f, -0.18663776f, 0.08429181f, -0.02487236f, 
    0.09806479f, 0.01984561f, -0.01087098f, 0.01697982f, 0.12613100f, 0.02763350f, -0.08246002f, 0.00470282f, 
    -0.05449225f, -0.12086488f, 0.24866325f, -0.07947728f, 0.08474906f, -0.04618051f, 0.17116441f, -0.00876184f, 
    0.06096201f, -0.03117755f, 0.06840497f, 0.00502250f, 0.31417358f, -0.02809348f, 0.17374262f, 0.16611266f, 
    0.00080489f, 0.07005787f, -0.03443370f, -0.06809501f, 0.07824051f, 0.07986472f, -0.00187729f, 0.02891534f, 
    0.29147243f, 0.15512840f, -0.12058135f, -0.03218456f, -0.04447026f, -0.08735935f, 0.07324840f, -0.09809325f, 
    -0.02092203f, 0.13826017f, -0.05819039f, -0.09175494f, 0.23991039f, -0.09994937f, 0.11574157f, -0.03032680f, 
    0.07310855f, 0.03861961f, -0.11766779f, 0.08456848f, -0.01695471f, -0.11885420f, -0.01356575f, 0.12398770f, 
    0.22385058f, -0.01962748f, -0.10329258f, -0.02103732f, 0.07618368f, -0.05363214f, 0.04883514f, -0.00339020f, 
    0.05138600f, 0.12272888f, 0.10125279f, 0.11310153f, 0.08521291f, 0.09784859f, 0.06543425f, 0.02297581f, 
    0.00508397f, 0.05483771f, -0.03559627f, 0.06226324f, 0.08103808f, 0.06423903f, -0.00551483f, -0.00881991f, 
    0.01429790f, 0.01869533f, 0.03961705f, -0.06895317f, 0.04089469f, -0.02803391f, 0.02006149f, 0.07135560f, 
    0.01969578f, -0.05116564f, -0.06996129f, 0.02956568f, 0.04887233f, 0.02918338f, 0.02979604f, 0.03645355f, 
    0.01257989f, -0.04982707f, 0.00115591f, 0.05197281f, 0.03812215f, -0.05323052f, -0.05205079f, 0.00508640f, 
    -0.02348665f, -0.07578993f, -0.00900150f, -0.03576360f, 0.00374670f, -0.02899316f, -0.05559513f, -0.06903385f, 
    -0.07151213f, 0.00210803f, 0.03435200f, 0.01860504f, -0.04436390f, -0.01159084f, -0.03544978f, 0.02085535f, 
    0.06196547f, -0.07970348f, 0.05204074f, -0.06894580f, 0.04833241f, -0.00560155f, -0.06229160f, -0.05333146f, 
    -0.05909237f, 0.00092492f, 0.05681031f, 0.01174452f, -0.07566462f, 0.01576991f, -0.08362467f, 0.03912279f, 
    0.03533193f, 0.00893316f, 0.01135099f, -0.03965784f, -0.05373710f, -0.00217132f, -0.01451409f, 0.04332577f, 
    0.04199646f, -0.04655798f, -0.06432466f, -0.05531802f, 0.04376597f, -0.01243167f, 0.00872586f, 0.00509154f, 
    -0.08155790f, -0.05705296f, -0.06345961f, -0.02887873f, -0.03086878f, -0.05603290f, -0.03754426f, -0.00382120f, 
    -0.03980191f, -0.07319286f, -0.06455085f, -0.05413208f, 0.04316360f, -0.07820706f, -0.04866240f, -0.01369013f, 
    0.05076193f, -0.03884488f, 0.00949670f, -0.03498130f, 0.05176804f, 0.03772219f, 0.02896015f, 0.03992772f, 
    -0.02114637f, 0.05478952f, -0.02451206f, -0.06194605f, 0.00654890f, 0.04711597f, -0.00425256f, -0.01314479f, 
    -0.07420836f, 0.06524709f, -0.01498591f, 0.01481621f, 0.03056850f, -0.07752746f, -0.04394661f, -0.01752623f, 
    0.04029176f, 0.01275319f, 0.00403126f, 0.04113037f, -0.00112787f, -0.04616290f, -0.01113252f, 0.02876336f, 
    -0.08586890f, 0.02371107f, -0.01752972f, 0.03936839f, -0.01849484f, 0.03159277f, 0.05203701f, 0.03289097f, 
    0.01964512f, -0.05407620f, 0.00565075f, -0.04046851f, -0.05864765f, -0.02896657f, 0.02343152f, -0.07056973f, 
    -0.07735316f, -0.01578229f, -0.00544287f, 0.04945841f, -0.05942902f, -0.02603596f, 0.03106389f, 0.03621093f, 
    -0.08709043f, -0.06871743f, -0.02973229f, 0.02946785f, -0.01080953f, 0.00462413f, -0.02404909f, -0.06477144f, 
    0.02550965f, -0.06900012f, -0.07859120f, -0.05449195f, 0.02381856f, 0.00250283f, 0.01358620f, -0.06154616f, 
    0.00017742f, 0.03436401f, -0.00155478f, -0.03677223f, -0.07150827f, -0.05853210f, -0.05649650f, -0.04055231f, 
    -0.04328525f, -0.01222979f, 0.01608429f, -0.03949797f, -0.03738927f, 0.03759316f, 0.01745089f, 0.00237909f, 
    0.00615138f, -0.05752977f, 0.02338539f, 0.03184129f, -0.00845263f, -0.03885323f, -0.01581637f, -0.04068422f, 
    0.01078649f, -0.01883235f, -0.03921994f, 0.02918099f, 0.04295848f, 0.02922952f, -0.00665401f, 0.03002266f, 
    0.33668000f, -0.16937250f, -0.19880883f, 0.05719082f, -0.04421914f, 0.07144221f, 0.11955366f, 0.02135190f, 
    0.10641128f, 0.00924581f, 0.20718049f, 0.22924289f, 0.04044499f, 0.38062844f, 0.25644931f, 0.09449958f, 
    0.00186522f, -0.07931052f, 0.03194998f, -0.02749665f, -0.08856238f, 0.09373977f, -0.04140744f, -0.01488716f, 
    -0.08112255f, -0.12722857f, -0.03972188f, -0.11722717f, -0.03716581f, -0.11181719f, -0.10577638f, -0.07189952f, 
    -0.05066097f, -0.00372263f, -0.05465366f, -0.23687853f, -0.10675921f, 0.31831557f, -0.03954570f, 0.15341395f, 
    0.12938887f, 0.04236742f, 0.01068158f, -0.02144573f, -0.06491742f, 0.02432402f, -0.13291557f, 0.02706663f, 
    -0.18692665f, 0.14391413f, 0.02316984f, 0.22051939f, 0.15353844f, -0.05397179f, 0.07149149f, -0.16984725f, 
    0.04102882f, -0.12724417f, 0.00173973f, -0.02821361f, 0.14025450f, -0.14235674f, 0.15116337f, -0.06917655f, 
    -0.04674628f, 0.02830859f, -0.33766246f, 0.00770184f, -0.07985308f, -0.08732399f, -0.20886326f, -0.43073231f, 
    -0.15547328f, 0.01313731f, 0.10666860f, 0.27292043f, 0.02154297f, -0.13077365f, -0.18160102f, -0.15318283f, 
    -0.02159060f, -0.06185043f, -0.08252248f, 0.05874682f, -0.30916771f, -0.04259877f, -0.18460925f, -0.15638745f, 
    0.06364115f, 0.12113550f, -0.07079999f, -0.08954662f, -0.00058572f, 0.18696567f, 0.05335749f, -0.01616485f, 
    -0.30102822f, 0.19227807f, 0.21012539f, 0.06296532f, 0.02855237f, -0.05119275f, -0.00166017f, -0.08946629f, 
    -0.08945990f, -0.02011693f, 0.12567326f, 0.21056654f, 0.27328315f, -0.06430047f, -0.05877363f, -0.27318147f, 
    0.02523760f, 0.06905301f, -0.14431873f, 0.05115278f, -0.10947146f, -0.10707153f, 0.08279449f, 0.10647999f, 
    -0.06235548f, -0.12176606f, 0.05779410f, -0.18910199f, 0.00263770f, 0.05213797f, 0.15289080f, -0.02688779f, 
    0.15854688f, 0.31203413f, 0.29298612f, 0.22520460f, 0.18954293f, -0.03769809f, 0.26717016f, 0.05222877f, 
    0.01440206f, 0.06172801f, 0.07430143f, 0.02612415f, -0.17449126f, -0.21379443f, 0.10568705f, -0.16009673f, 
    0.43518680f, -0.05526401f, 0.14983040f, 0.00699730f, 0.15452163f, 0.22110222f, 0.00795572f, -0.11796401f, 
    -0.11284786f, -0.22781876f, 0.05376128f, -0.16817775f, 0.04336943f, -0.00848780f, -0.22304010f, 0.06550232f, 
    -0.01247150f, 0.06871546f, -0.01609067f, 0.14790553f, 0.13937774f, 0.44571838f, 0.08055487f, 0.27505457f, 
    0.29050031f, 0.18388128f, 0.18982962f, -0.22012857f, -0.00607754f, -0.07033961f, 0.01807738f, 0.12371835f, 
    0.13876289f, 0.08955705f, 0.16748157f, 0.02380453f, -0.12679623f, -0.23117766f, 0.03461201f, 0.12626050f, 
    -0.03542126f, -0.00372987f, 0.17250361f, 0.10665288f, 0.00121062f, 0.05301556f, 0.00947948f, 0.07029841f, 
    -0.20309649f, -0.03159908f, 0.03247960f, -0.16607650f, -0.04498521f, 0.06086916f, 0.06884523f, -0.01864496f, 
    0.18785717f, 0.03275537f, -0.03062507f, 0.05867427f, -0.02851966f, 0.13880868f, 0.35697365f, -0.14370729f, 
    -0.26031357f, -0.10935265f, -0.00153010f, 0.06142852f, 0.08014511f, -0.00038172f, 0.07827798f, 0.05764364f, 
    -0.30091953f, -0.05539450f, 0.29915959f, 0.26601759f, -0.15408380f, -0.15596007f, -0.16018119f, -0.00196894f, 
    -0.04862404f, 0.06375356f, -0.08392311f, 0.05533710f, -0.07861511f, -0.31851196f, 0.32471716f, -0.52526051f, 
    -0.01730846f, 0.14281966f, 0.05820883f, 0.14316376f, 0.01042005f, 0.05692701f, 0.00813853f, -0.05389431f, 
    0.17539400f, -0.20370877f, -0.10916104f, 0.20500703f, -0.08170090f, -0.05418153f, 0.05092052f, 0.04976101f, 
    0.08115304f, -0.00679771f, -0.18065326f, -0.02400184f, -0.05112202f, 0.09339821f, 0.31800255f, 0.01993102f, 
    -0.02427863f, 0.02504679f, -0.04797673f, 0.24381278f, 0.00780994f, -0.06414157f, 0.04255738f, -0.06871650f, 
    0.13155968f, 0.22269630f, -0.07737351f, -0.00984509f, 0.01239596f, -0.06463842f, 0.00229178f, 0.01264561f, 
    -0.00872233f, -0.05047528f, 0.21951394f, 0.26319692f, 0.07121735f, 0.01610462f, -0.03683861f, 0.01408030f, 
    -0.06124960f, 0.05579034f, -0.05265489f, -0.00484134f, 0.04926912f, 0.06232884f, 0.00783928f, -0.12694938f, 
    -0.23048598f, 0.05307505f, 0.20895331f, -0.26607382f, -0.02578628f, -0.04750661f, 0.17815238f, 0.06204095f, 
    -0.12276224f, 0.03083260f, -0.03771392f, 0.00187585f, 0.09034057f, -0.06720672f, -0.29363164f, 0.03905629f, 
    0.25964543f, 0.11036678f, -0.06259477f, -0.06007406f, 0.12025988f, 0.02442474f, 0.02242090f, -0.03178560f, 
    -0.06619804f, 0.09079480f, 0.11206626f, -0.05317289f, -0.02516973f, 0.07298296f, 0.14944512f, 0.03000763f, 
    0.23507611f, -0.04811688f, 0.10731626f, 0.08157273f, 0.04854011f, -0.05420223f, -0.02275754f, -0.10823666f, 
    -0.03858523f, 0.04940882f, 0.07201936f, -0.05661532f, 0.06351212f, -0.01981247f, 0.00684754f, -0.10661717f, 
    0.19809417f, 0.02692402f, 0.03351084f, -0.16094536f, -0.05284766f, 0.13736668f, -0.04593866f, -0.01974185f, 
    0.15771474f, 0.11496098f, -0.05542604f, -0.01912108f, 0.22270662f, -0.10554446f, 0.08735538f, -0.05065839f, 
    -0.01945657f, -0.09673041f, -0.11916520f, -0.08397315f, 0.06687326f, -0.01364539f, 0.11777108f, 0.07533888f, 
    0.21187903f, 0.29629847f, -0.18952356f, -0.23198986f, 0.04512098f, -0.10639828f, 0.11217056f, 0.06508495f, 
    0.03013639f, 0.03705027f, 0.04137648f, 0.04392441f, -0.19981487f, 0.05492860f, 0.15949988f, 0.08240564f, 
    -0.04208707f, 0.08016696f, -0.10183065f, 0.03017068f, 0.08889413f, 0.07902376f, -0.02894038f, 0.15829022f, 
    -0.01573413f, -0.01667976f, -0.15535104f, 0.09383292f, -0.06320534f, -0.00609263f, -0.11424343f, -0.12670620f, 
    -0.06630006f, -0.15999158f, 0.18597133f, 0.23044096f, 0.19197893f, 0.38554460f, 0.14676249f, 0.06440488f, 
    0.02855849f, 0.05513348f, 0.12296154f, -0.05338064f, 0.09135818f, 0.11431702f, 0.00576876f, 0.08975442f, 
    -0.18379667f, -0.06610231f, 0.12244809f, 0.20693131f, -0.21966051f, -0.03118248f, -0.14392203f, -0.00409431f, 
    -0.10699633f, -0.13350706f, -0.12031540f, -0.14034593f, 0.17151733f, 0.05527265f, 0.03907816f, 0.24780820f, 
    0.07976066f, -0.06411651f, 0.02024825f, -0.05243212f, 0.02671198f, -0.02852636f, 0.09132698f, 0.00144657f, 
    0.01117288f, 0.11835998f, -0.09428029f, 0.12360343f, 0.07390710f, 0.00122796f, 0.07978951f, 0.10272156f, 
    0.03099620f, -0.02505890f, -0.14994763f, 0.09259573f, 0.14938201f, -0.15947397f, 0.22359094f, -0.03119392f, 
    -0.08738096f, 0.04249698f, -0.25481746f, -0.01654362f, -0.17621136f, 0.01597485f, -0.10989024f, -0.19554107f, 
    -0.19548260f, -0.15061800f, -0.02429176f, 0.16043898f, 0.03309356f, -0.05145725f, -0.05123917f, 0.02119270f, 
    -0.00588963f, -0.10795389f, -0.02592964f, 0.10589194f, 0.02189518f, -0.11571195f, -0.07405251f, 0.02322847f, 
    0.01029053f, 0.04434271f, -0.01459160f, 0.11320524f, -0.02746427f, 0.17761576f, -0.09998549f, 0.03894658f, 
    -0.25762287f, 0.31741971f, 0.53961784f, -0.06248772f, -0.19176126f, -0.13569307f, 0.04946474f, -0.03364484f, 
    -0.01515257f, -0.14400889f, 0.03498501f, 0.08107411f, 0.04393131f, -0.16341975f, -0.14460464f, -0.18373536f, 
    -0.04134811f, 0.16361745f, -0.13659507f, 0.09620512f, 0.08164059f, -0.01202459f, 0.01078491f, 0.15829886f, 
    0.00809211f, -0.21131459f, 0.00701571f, -0.07531720f, 0.03609282f, 0.05676988f, 0.01149795f, -0.04873630f, 
    0.28268263f, 0.22374144f, 0.15301120f, 0.09630521f, 0.21239851f, 0.06326866f, 0.21358357f, -0.09282938f, 
    0.06001839f, 0.05285133f, 0.03955007f, 0.04562545f, -0.05929135f, -0.06321126f, 0.11023743f, -0.07200691f, 
    0.58788884f, -0.11022127f, 0.24215694f, 0.03681767f, 0.07729658f, 0.23746972f, -0.09280097f, 0.11507230f, 
    0.00031537f, -0.06072694f, -0.02565441f, -0.18529615f, 0.18609551f, -0.02248254f, -0.11304675f, -0.05536655f, 
    0.00020130f, -0.02881192f, -0.02411866f, -0.02415532f, -0.02913035f, 0.25719485f, 0.11628532f, 0.36034912f, 
    0.31817126f, 0.02601316f, 0.24887508f, -0.34476620f, 0.03549365f, 0.00711497f, -0.00601339f, -0.19931747f, 
    0.16069797f, 0.04202886f, 0.13277327f, 0.07349052f, -0.24535275f, -0.02530637f, 0.06097887f, 0.08172983f, 
    -0.03305221f, 0.08950335f, -0.00612633f, 0.07140099f, -0.09161114f, -0.04763724f, 0.10098355f, 0.10857131f, 
    -0.14880027f, 0.07915607f, 0.25963601f, -0.41324931f, 0.02315316f, -0.01014323f, 0.13261671f, 0.13249035f, 
    0.07089362f, -0.03169096f, -0.16093807f, -0.01736320f, 0.13589473f, -0.48602930f, -0.00474036f, -0.57987827f, 
    -0.09308381f, -0.10237321f, -0.05330162f, -0.06246042f, -0.01012313f, -0.04885774f, 0.16314006f, 0.12586826f, 
    -0.03232963f, 0.15906948f, 0.26316470f, 0.23444995f, 0.15677354f, 0.15175897f, 0.16196841f, 0.16815922f, 
    -0.00141540f, 0.05497646f, -0.06289731f, 0.03553461f, 0.25455993f, 0.13380763f, 0.09794198f, -0.40111884f, 
    -0.04952323f, -0.04346671f, 0.10006168f, 0.14159188f, 0.02163486f, 0.07595749f, -0.06501037f, 0.01764876f, 
    0.21075085f, -0.34267527f, 0.12633528f, 0.01366000f, -0.10515006f, 0.12368220f, -0.05507376f, 0.00858588f, 
    0.07347631f, -0.03010569f, 0.02884830f, -0.00755863f, 0.00790257f, 0.17159425f, 0.10691319f, 0.04830223f, 
    0.10440476f, 0.15746649f, 0.26638365f, 0.01785081f, -0.01159225f, -0.05553031f, 0.11091750f, 0.00657048f, 
    0.09887510f, -0.10990116f, -0.33437237f, -0.13675360f, -0.05109251f, -0.04240461f, -0.08066497f, -0.15274976f, 
    -0.02201885f, 0.01805335f, 0.11645591f, 0.01972050f, -0.07640754f, 0.11342381f, -0.00946284f, 0.28244719f, 
    -0.06006045f, -0.06753182f, -0.06776264f, -0.16175956f, 0.06991909f, -0.00293803f, 0.07560033f, 0.03325345f, 
    0.32510370f, -0.32059768f, -0.31093422f, -0.40997908f, 0.02749188f, -0.06641150f, 0.17381874f, 0.09574753f, 
    -0.07074879f, 0.14844236f, 0.08355679f, -0.09431625f, 0.08280842f, -0.07129445f, -0.12786117f, 0.14324142f, 
    0.21084398f, 0.01666194f, 0.19738561f, -0.26999182f, 0.11363193f, 0.19656299f, -0.11219975f, 0.09465100f, 
    -0.10894157f, 0.01318859f, -0.05577036f, 0.04001953f, 0.06069412f, 0.04023764f, 0.02663933f, 0.22414617f, 
    -0.04663324f, -0.23764142f, 0.12293503f, -0.05091041f, 0.05953865f, 0.12571098f, 0.14223893f, 0.14106520f, 
    -0.02248732f, -0.09321298f, -0.10992365f, -0.10604479f, 0.00458108f, -0.01020077f, -0.06070650f, 0.01777893f, 
    0.04234909f, 0.08444851f, 0.05205702f, -0.03591720f, -0.06881595f, -0.18869200f, -0.05588212f, -0.10052068f, 
    0.04911529f, 0.11191273f, -0.08342458f, -0.02055542f, 0.26777461f, -0.20036249f, 0.08159084f, 0.18248752f, 
    0.07169814f, 0.04304965f, 0.05677265f, -0.11430542f, 0.11920557f, -0.23802866f, -0.12254388f, -0.21993136f, 
    0.07209381f, 0.11528951f, -0.18152782f, 0.03517619f, 0.09617201f, -0.08496133f, 0.02965485f, 0.11968298f, 
    0.01869723f, 0.01102146f, 0.04355026f, 0.07072034f, 0.24677974f, 0.38998470f, 0.34954360f, 0.09655673f, 
    0.01119395f, 0.05383059f, 0.11428984f, 0.10935618f, -0.00670341f, 0.03227635f, 0.00036389f, 0.09019221f, 
    0.06210917f, 0.05619047f, -0.01510928f, 0.04359746f, 0.00259319f, -0.05114965f, -0.06346940f, 0.06500865f, 
    -0.00803498f, 0.08096486f, 0.06135476f, -0.00424735f, 0.05010226f, -0.06310979f, -0.02735877f, 0.01026271f, 
    0.05493850f, -0.08551094f, -0.01532535f, -0.01801246f, -0.00333085f, 0.06128743f, -0.05365617f, 0.01683388f, 
    0.01484361f, -0.02387797f, -0.03244948f, 0.05563023f, -0.06018270f, -0.02068562f, -0.02890238f, -0.05252999f, 
    -0.01213240f, -0.06618239f, -0.00769154f, -0.03793252f, -0.05426052f, 0.04657329f, 0.02275103f, 0.05133645f, 
    0.04531158f, 0.05095187f, 0.02247396f, 0.05295156f, -0.06354485f, -0.06091194f, -0.03040516f, -0.05164500f, 
    -0.06555840f, -0.08333936f, -0.04912964f, 0.00626223f, -0.01474699f, -0.05281225f, -0.05844595f, 0.00958575f, 
    -0.01965969f, 0.06516676f, -0.05007263f, 0.06525073f, -0.00028179f, -0.01445592f, -0.06366652f, 0.03294799f, 
    0.00173148f, -0.05024801f, -0.04535361f, 0.06818844f, 0.02868214f, -0.07173023f, -0.02005947f, 0.04618618f, 
    0.02379234f, -0.07143482f, 0.02623148f, -0.03445860f, -0.03180851f, 0.01341081f, 0.04923489f, 0.01086081f, 
    -0.01630569f, -0.08310039f, -0.04300006f, -0.01978157f, -0.03599142f, -0.05376417f, 0.01508530f, 0.03941308f, 
    -0.02883393f, -0.08505974f, 0.02719969f, -0.08260309f, 0.02336705f, -0.02771570f, -0.08066861f, -0.08127626f, 
    0.01748123f, -0.01768276f, -0.02200238f, 0.00112234f, 0.04509762f, 0.06139513f, -0.00380987f, 0.04177311f, 
    0.00217411f, -0.00832229f, 0.02684580f, -0.02169956f, -0.02850370f, 0.02284091f, 0.03471722f, -0.02466321f, 
    0.03504186f, -0.00448417f, -0.05966930f, -0.00448329f, 0.03871241f, -0.07873050f, 0.03097411f, 0.01540540f, 
    0.02837808f, -0.00730820f, -0.00961186f, -0.07102095f, -0.05574650f, -0.03716819f, -0.03331586f, -0.04366049f, 
    0.05933095f, -0.06615787f, -0.06204995f, -0.01800600f, 0.04616526f, 0.03092246f, 0.04563205f, 0.05470473f, 
    -0.05190232f, -0.03102171f, -0.03257347f, -0.08972082f, 0.04551049f, -0.01005899f, 0.04584555f, -0.04426286f, 
    -0.06304436f, 0.02785194f, 0.04953278f, 0.04039187f, -0.01468750f, 0.02575540f, 0.02455175f, -0.06630173f, 
    0.03705631f, -0.06299176f, -0.05870985f, -0.02049278f, 0.02264102f, 0.02702741f, 0.00607267f, 0.02891787f, 
    -0.03741003f, 0.01914429f, -0.08620817f, 0.00943736f, 0.02494464f, -0.08176357f, 0.00156755f, 0.05096770f, 
    -0.06663425f, -0.03396707f, -0.06048420f, 0.03373257f, -0.00990933f, -0.04332237f, -0.02207281f, 0.00458952f, 
    0.01127485f, 0.00056968f, -0.05154309f, -0.05862240f, -0.00035599f, -0.06196875f, 0.05028086f, -0.04717920f, 
    0.05325355f, 0.00628500f, -0.00578453f, -0.05276265f, -0.06648186f, -0.06777654f, -0.06953875f, -0.02220582f, 
    0.15432857f, -0.24318977f, -0.01755277f, -0.00992540f, 0.04154486f, -0.04313808f, 0.21093567f, 0.15366974f, 
    -0.09788264f, -0.03507580f, -0.07313898f, -0.10439596f, -0.03352023f, 0.22397088f, -0.23879403f, 0.37322423f, 
    0.13043964f, 0.08022605f, 0.12295900f, 0.18576489f, -0.02686217f, 0.01995254f, 0.06384087f, -0.04366326f, 
    -0.20472704f, -0.29181051f, -0.24164678f, -0.03652487f, 0.11792026f, 0.22818442f, -0.00498382f, 0.02571611f, 
    -0.05018437f, -0.04757844f, 0.03083325f, -0.02455891f, 0.02919370f, 0.49561965f, -0.01922487f, 0.32532728f, 
    0.00752544f, -0.02594651f, -0.02776671f, 0.12919556f, -0.01041092f, 0.13241887f, 0.23236175f, -0.00363578f, 
    -0.40356547f, -0.31983951f, 0.04105580f, -0.16608624f, 0.08256602f, -0.02215515f, -0.04408236f, 0.02770797f, 
    -0.12787588f, 0.12912269f, 0.13942058f, 0.10954111f, -0.10829370f, 0.05272922f, -0.01055611f, 0.00130541f, 
    0.01697979f, -0.08600955f, 0.00532792f, -0.09360755f, 0.04751757f, 0.00819229f, 0.09777807f, 0.14317358f, 
    0.27315888f, 0.29157114f, 0.11003809f, 0.01292663f, 0.02480760f, 0.01895500f, 0.05558393f, -0.09129220f, 
    -0.06625448f, 0.09801891f, 0.26429909f, -0.05551752f, 0.07770332f, 0.14715423f, 0.09894686f, -0.34730479f, 
    0.15487774f, -0.04022999f, -0.08287500f, 0.03324582f, 0.15170737f, -0.03938350f, 0.03571816f, 0.11940962f, 
    -0.15195489f, 0.06764919f, 0.03405675f, 0.16319717f, 0.16302863f, 0.08513945f, 0.12412450f, 0.11687046f, 
    -0.08288562f, 0.03561303f, 0.05077469f, 0.03529069f, 0.28217545f, 0.28722820f, 0.07126029f, 0.07153565f, 
    -0.06847003f, -0.09897389f, 0.17826270f, 0.05981155f, -0.00441923f, 0.05991921f, 0.10174114f, -0.11833675f, 
    -0.14056249f, -0.14330256f, -0.20858425f, 0.09295372f, 0.03429233f, 0.03098549f, -0.07463987f, -0.07403705f, 
    -0.14913143f, 0.06872374f, -0.15412320f, -0.12492258f, -0.28511074f, -0.07773209f, -0.10483633f, -0.34982547f, 
    -0.18731906f, -0.24527237f, -0.31070539f, -0.22466840f, 0.06640306f, 0.06526151f, -0.09907712f, -0.07038657f, 
    -0.31487611f, 0.05469507f, 0.08388209f, 0.01069217f, -0.01095539f, -0.18786828f, 0.09860444f, 0.12855266f, 
    0.04346370f, -0.08233897f, -0.05103750f, 0.20294444f, -0.21592808f, 0.22051933f, -0.12089843f, -0.04317234f, 
    -0.02210222f, -0.08851843f, 0.08991374f, 0.03720280f, 0.16090019f, 0.06721438f, 0.02805307f, -0.25199348f, 
    0.06719583f, -0.10322411f, -0.00595814f, 0.08425061f, -0.14406486f, 0.19754392f, 0.14552325f, 0.00783851f, 
    0.03843919f, 0.14293587f, -0.00490531f, -0.04434901f, -0.13425164f, -0.17200068f, 0.06531203f, 0.18659574f, 
    0.01884248f, 0.06961952f, -0.02262159f, -0.09590269f, 0.08803382f, 0.05622832f, -0.12803361f, -0.05417438f, 
    -0.18943596f, -0.22566406f, 0.18697797f, 0.18387300f, -0.10577072f, 0.14582634f, 0.12970045f, -0.00375146f, 
    0.17542994f, 0.21221472f, -0.05460677f, -0.12071303f, -0.11470515f, 0.42984858f, 0.21907656f, 0.28956488f, 
    -0.04895464f, 0.09612241f, 0.03788687f, 0.13086055f, 0.02379656f, 0.22277699f, 0.06478466f, 0.24614938f, 
    -0.36603260f, -0.64231408f, -0.54384726f, -0.38378698f, -0.13899176f, -0.08057790f, -0.13777821f, -0.06513710f, 
    -0.02740040f, 0.02959282f, -0.04602544f, -0.05025988f, -0.25169855f, -0.08889428f, 0.17272533f, 0.04640446f, 
    0.05991258f, -0.01779177f, 0.13480587f, 0.06272472f, 0.05519174f, 0.00335915f, 0.11131012f, -0.04631444f, 
    0.07589789f, -0.24405766f, -0.00002142f, 0.05938363f, 0.18935667f, -0.03115916f, -0.04769433f, 0.11686106f, 
    0.18541464f, 0.15756235f, -0.02731184f, -0.04197061f, -0.10479066f, -0.08581220f, 0.06946617f, 0.07037175f, 
    -0.03575231f, -0.14318070f, 0.15850708f, 0.00931078f, 0.15492052f, 0.04420232f, 0.03600014f, -0.00472450f, 
    0.07798224f, 0.03767597f, -0.19889987f, 0.02150660f, 0.00937455f, 0.02161753f, 0.07204732f, 0.10582981f, 
    -0.03786669f, -0.12507737f, 0.00380808f, 0.17746224f, 0.11392490f, 0.09050785f, 0.02679005f, 0.04404606f, 
    -0.04127357f, 0.05857624f, 0.01206265f, 0.12108768f, 0.10478459f, 0.09941624f, -0.04156423f, -0.05081889f, 
    -0.12346958f, 0.12021197f, 0.42061427f, 0.09420993f, -0.23470807f, -0.07587983f, 0.22976182f, 0.06604827f, 
    -0.05413416f, 0.04588846f, 0.06322484f, 0.17877339f, 0.18514122f, 0.30799809f, -0.21579511f, -0.03991953f, 
    -0.04271276f, 0.05046475f, 0.06261110f, 0.08123499f, 0.04185509f, 0.05480205f, -0.05258505f, 0.07277596f, 
    -0.14681353f, -0.07358436f, -0.05425161f, 0.00818282f, -0.06627055f, -0.10309870f, -0.03706427f, -0.04986227f, 
    0.07205569f, 0.11296444f, -0.04407768f, -0.07146379f, -0.22755341f, 0.03954760f, -0.06527864f, -0.21603031f, 
    -0.06068273f, -0.00353647f, -0.02498888f, 0.05730036f, 0.06536018f, 0.05736485f, 0.08650862f, -0.06244962f, 
    -0.00628919f, -0.04269613f, 0.05720955f, -0.12388139f, 0.03879507f, 0.06790544f, -0.01276698f, 0.06788555f, 
    -0.03261281f, 0.12715070f, 0.07993307f, -0.00309747f, -0.02597078f, 0.01114576f, 0.05954499f, 0.04991097f, 
    -0.06928559f, -0.07491372f, 0.01290935f, -0.00182912f, 0.13983534f, 0.20520948f, 0.13717303f, 0.08864369f, 
    -0.23119058f, 0.01734592f, 0.04993003f, -0.06867296f, 0.06116777f, -0.01546579f, 0.16495381f, 0.10746161f, 
    -0.01962800f, -0.08978685f, 0.09056317f, 0.10423633f, -0.22180815f, -0.09059986f, 0.04297806f, -0.10260566f, 
    0.04869528f, -0.09119041f, 0.00330146f, -0.17114192f, -0.11966804f, -0.00760011f, -0.02715139f, 0.10289171f, 
    0.26790887f, 0.06879702f, 0.22189194f, 0.03409171f, 0.00962111f, -0.23672862f, 0.02626137f, 0.04770293f, 
    0.19689608f, -0.02967767f, -0.03135195f, 0.21060264f, 0.32141489f, 0.35548845f, 0.24689953f, -0.12507048f, 
    -0.03405031f, 0.06986304f, 0.04190590f, -0.12806222f, 0.05596534f, -0.02200100f, 0.06960075f, 0.16455652f, 
    -0.12624560f, 0.41460559f, 0.18159632f, 0.22883958f, 0.00441779f, -0.05934706f, 0.07217929f, 0.30478033f, 
    0.03716375f, 0.10168476f, -0.10721041f, -0.01757168f, -0.03290461f, -0.22600292f, 0.28087419f, -0.33209500f, 
    -0.00642578f, 0.08241702f, 0.02224847f, 0.15571551f, 0.10513366f, -0.06963321f, -0.03116112f, 0.00283360f, 
    0.06033288f, 0.02116432f, 0.05735958f, 0.08711685f, 0.08611017f, 0.00220794f, 0.07163587f, -0.20876740f, 
    0.10837324f, -0.03303408f, -0.08739796f, 0.07416854f, 0.27583873f, -0.00069908f, 0.02792831f, 0.14916396f, 
    -0.04091474f, -0.05177228f, 0.17022750f, -0.12476591f, -0.09733066f, -0.02830146f, 0.11340588f, 0.04883821f, 
    0.02275867f, 0.28151301f, 0.02234590f, 0.12516044f, 0.04966463f, -0.12416115f, 0.03036015f, 0.13367909f, 
    -0.06623986f, -0.05171126f, -0.01079872f, 0.03624389f, -0.35327226f, -0.16887517f, 0.03115090f, -0.04226422f, 
    0.05244665f, 0.05909797f, -0.11275520f, -0.12035272f, -0.03982892f, -0.01646921f, 0.03614003f, 0.16088039f, 
    0.16131313f, 0.07123010f, 0.54621404f, 0.20105922f, 0.00508235f, 0.04458523f, 0.02974218f, 0.02530210f, 
    -0.02706210f, 0.02647392f, 0.02325333f, -0.14316970f, -0.38489535f, 0.07277489f, -0.21093096f, 0.11309978f, 
    -0.01167673f, -0.03107048f, -0.01627034f, -0.05541554f, 0.19172943f, 0.05083083f, -0.07796731f, -0.10107720f, 
    0.04905437f, 0.24705017f, 0.28239852f, 0.04986333f, 0.08839124f, -0.06456330f, 0.04348073f, -0.06445748f, 
    0.08872613f, 0.03056967f, -0.02627576f, 0.14973916f, -0.40678439f, -0.55492675f, -0.42330343f, -0.01815274f, 
    0.01638932f, 0.05129188f, 0.02786494f, -0.01800506f, 0.06993095f, 0.01262078f, -0.05819865f, 0.10419957f, 
    -0.27874324f, 0.00300397f, -0.25485650f, -0.22516060f, -0.02365032f, 0.02648275f, -0.08546956f, -0.04404388f, 
    0.09747539f, -0.01382120f, 0.03833219f, -0.19417660f, -0.00143099f, -0.22993438f, 0.10251518f, -0.21794538f, 
    -0.05622914f, 0.07575634f, -0.07691056f, 0.02089353f, 0.02962777f, 0.08528049f, 0.17301428f, 0.17665491f, 
    -0.30538437f, 0.10651716f, -0.03575278f, -0.13038892f, 0.03357751f, 0.02723752f, -0.06691498f, 0.10542032f, 
    -0.08221589f, 0.03420866f, -0.00751438f, -0.00327847f, -0.17328928f, 0.14181526f, 0.06903384f, 0.20475739f, 
    -0.12550712f, -0.00003843f, 0.01663226f, 0.29519224f, 0.05563603f, 0.06240965f, -0.00594684f, -0.06695601f, 
    -0.42192176f, -0.15934531f, -0.08164037f, -0.07299335f, -0.10916948f, 0.16504967f, 0.17487554f, -0.01560464f, 
    -0.03514421f, 0.06578090f, 0.09892592f, 0.24450420f, 0.07604246f, 0.20433944f, -0.00152595f, 0.07344840f, 
    -0.08599361f, -0.09297962f, 0.09500340f, 0.11761829f, 0.06926659f, 0.16013947f, 0.14683154f, -0.08572291f, 
    -0.52484715f, -0.35235751f, -0.38830546f, -0.19505575f, 0.19646084f, 0.01607301f, -0.16806269f, -0.22099866f, 
    -0.04756245f, -0.07710019f, -0.12041069f, -0.10727000f, 0.09875652f, 0.00755358f, 0.14288794f, 0.23891707f, 
    0.24878271f, -0.18270932f, 0.03972344f, -0.03393837f, 0.03434958f, 0.24041879f, 0.09963493f, 0.01016931f, 
    0.15303396f, -0.19911502f, 0.17961141f, 0.00546245f, 0.12046404f, -0.03846892f, -0.07309125f, 0.02852122f, 
    -0.18142302f, -0.02717643f, 0.12466855f, 0.01888037f, -0.08489355f, -0.00710752f, -0.00274075f, 0.03942864f, 
    -0.03052217f, -0.07530363f, -0.12395111f, -0.09274148f, -0.04245640f, -0.15017962f, -0.11211490f, -0.20003375f, 
    -0.04119676f, 0.03255153f, 0.14759539f, 0.07853252f, -0.00814352f, -0.09192908f, -0.15151580f, -0.10829577f, 
    -0.08163588f, 0.11420088f, -0.04597156f, 0.13800384f, 0.13169526f, 0.08380671f, 0.09319391f, 0.08451430f, 
    -0.03618028f, -0.01263729f, -0.02932354f, -0.01071881f, 0.20910974f, 0.09943969f, 0.01639607f, 0.06245311f, 
    -0.38684675f, -0.12873346f, -0.19715156f, -0.13893577f, -0.21253353f, -0.29009184f, -0.06462400f, -0.11526735f, 
    -0.03593350f, -0.13602941f, -0.05266219f, 0.17735419f, -0.06017315f, 0.16725859f, -0.08588964f, 0.02655380f, 
    0.03874233f, 0.03934228f, 0.11327740f, -0.02889896f, -0.04177134f, -0.16661216f, -0.00790040f, 0.21167220f, 
    -0.27170691f, -0.17585787f, -0.21598843f, -0.25504258f, -0.04069668f, 0.09191392f, 0.07451991f, 0.00250023f, 
    0.18921517f, 0.09050241f, 0.08873123f, 0.07987361f, 0.19122916f, 0.09552157f, 0.08909096f, -0.10223170f, 
    -0.00474868f, -0.04270941f, -0.01359337f, 0.00766325f, 0.03405369f, -0.13936296f, -0.07906368f, -0.02328632f, 
    0.22764771f, -0.06601698f, 0.03316493f, 0.07684612f, -0.06397028f, 0.02492931f, 0.04827208f, 0.00761352f, 
    -0.09002879f, -0.01110059f, 0.01348818f, 0.05112761f, 0.07058875f, 0.07567463f, 0.03937263f, -0.11302432f, 
    0.02040339f, -0.09908977f, 0.11086258f, 0.06972524f, 0.10353989f, 0.30238196f, 0.28965947f, 0.08278893f, 
    0.24463697f, -0.03075842f, -0.10796643f, -0.15336086f, 0.14237097f, 0.06553680f, 0.34211943f, -0.01794734f, 
    0.29018134f, 0.29179001f, 0.07485515f, 0.11665530f, -0.02702276f, -0.38334283f, -0.08859109f, -0.12195210f, 
    0.09499344f, 0.10973348f, 0.13949171f, -0.09982478f, -0.05744944f, 0.07210889f, 0.10486022f, 0.13227165f, 
    0.09166677f, 0.12052834f, -0.19737686f, 0.01504691f, -0.02843442f, -0.20859285f, 0.33154109f, 0.11653314f, 
    -0.02514719f, 0.09294317f, 0.09384187f, 0.19643864f, -0.33039829f, 0.23648195f, -0.05933872f, 0.20688199f, 
    -0.08676022f, -0.07518897f, -0.08525823f, 0.26645759f, -0.06490878f, 0.01166085f, 0.03268855f, 0.00538611f, 
    0.23155461f, -0.07150029f, 0.03175434f, 0.00069933f, 0.02232622f, 0.09441777f, -0.07640311f, 0.04276268f, 
    0.02160204f, 0.02455516f, -0.06054752f, -0.12331239f, 0.00423241f, 0.42759514f, -0.07770793f, 0.03841767f, 
    -0.04432554f, 0.14763775f, -0.07114454f, 0.12750313f, -0.03000697f, -0.03331066f, 0.00432670f, -0.04207872f, 
    -0.26944375f, 0.23569369f, -0.07425255f, 0.38907593f, 0.09653129f, 0.02804533f, 0.14500119f, 0.03000062f, 
    -0.08433430f, -0.01222173f, -0.03019495f, 0.02615417f, 0.08374041f, 0.05847423f, 0.18259670f, 0.00549887f, 
    -0.11361031f, 0.25297314f, -0.15880562f, 0.00047180f, 0.02560127f, -0.16698556f, 0.01219862f, -0.09500355f, 
    0.39761159f, 0.22029997f, 0.03496657f, 0.12723958f, 0.03325137f, -0.12318249f, 0.01365519f, 0.06731559f, 
    0.13660312f, 0.04910151f, -0.09714424f, -0.17533088f, -0.04263579f, 0.08442514f, -0.22661144f, -0.22027469f, 
    0.09177641f, 0.01216453f, 0.06575577f, -0.06678740f, -0.06639362f, 0.05859778f, 0.09925800f, 0.01427527f, 
    -0.38155502f, 0.29236630f, 0.30555043f, 0.09229832f, -0.03122569f, 0.06790974f, 0.01332039f, 0.17466767f, 
    0.06704961f, 0.04698237f, -0.14717087f, -0.06130232f, 0.37246251f, 0.00344819f, 0.27019668f, 0.01712051f, 
    -0.11615063f, 0.13560644f, 0.01422877f, 0.02502757f, -0.18533839f, 0.04398048f, -0.00750571f, -0.00480578f, 
    0.05191387f, -0.01409592f, -0.00284856f, 0.03386657f, 0.01267697f, 0.01089467f, -0.03089010f, -0.14400502f, 
    0.06046800f, 0.21631992f, 0.05175836f, 0.05641364f, -0.22287254f, -0.07060028f, 0.13752659f, -0.06432342f, 
    -0.00328068f, -0.09039644f, -0.07304115f, -0.00523845f, -0.03110016f, -0.11032692f, 0.01228003f, 0.01307271f, 
    -0.06573991f, 0.11668814f, 0.23292054f, 0.09543719f, -0.05527275f, 0.12323564f, 0.14418580f, -0.04538661f, 
    -0.06846794f, -0.11803368f, -0.05037189f, -0.10648486f, -0.15299863f, -0.04516491f, -0.18308237f, 0.04227985f, 
    -0.06640919f, 0.00707340f, -0.03811126f, 0.21118101f, 0.06969082f, 0.16239294f, -0.12061484f, 0.09652179f, 
    -0.04962346f, 0.04217061f, 0.17842108f, 0.16470830f, 0.02431882f, 0.10152590f, -0.05553637f, 0.02019711f, 
    0.07768212f, 0.05945903f, 0.11618589f, -0.21246110f, -0.25334707f, -0.33709431f, 0.05344953f, -0.02686824f, 
    0.05833485f, -0.09238500f, 0.06259979f, 0.01355067f, -0.04451676f, 0.05438851f, -0.02512125f, -0.18823636f, 
    0.00469934f, -0.04048678f, 0.02331089f, 0.02490584f, 0.05897300f, 0.00614659f, -0.00925435f, -0.04465906f, 
    0.06417637f, 0.05179225f, -0.05060247f, 0.03236961f, 0.01548540f, -0.04367780f, -0.02894748f, -0.05604317f, 
    0.02537567f, 0.04655185f, 0.00363296f, -0.04231749f, 0.03915347f, -0.06615155f, -0.05676855f, -0.04804720f, 
    -0.06586469f, 0.02993743f, 0.01904817f, -0.02955104f, 0.01103896f, 0.02455773f, -0.06793497f, 0.00887724f, 
    -0.01459795f, -0.02019319f, 0.06605061f, -0.05776880f, 0.00465804f, 0.01671633f, -0.05997788f, 0.01996440f, 
    -0.06378778f, -0.03249561f, -0.01191224f, 0.02192630f, -0.04040864f, -0.08233649f, 0.02572246f, 0.04647393f, 
    -0.08064247f, -0.05676771f, -0.02942455f, 0.04848313f, 0.02485918f, -0.06913905f, 0.01074065f, 0.05009431f, 
    -0.04576055f, -0.00717327f, -0.08159216f, 0.06299579f, -0.08214174f, -0.05586855f, -0.03470675f, -0.05460649f, 
    0.02890596f, -0.04048301f, -0.04518312f, 0.01385704f, -0.00680845f, -0.00219295f, -0.07071795f, -0.03634252f, 
    -0.08111254f, -0.04147143f, -0.00413842f, -0.06730958f, 0.01946904f, 0.05664188f, 0.03597752f, 0.00563731f, 
    0.03566725f, -0.07907499f, 0.04984704f, 0.00720566f, 0.02984265f, -0.04800790f, 0.03578306f, -0.03311562f, 
    0.04943711f, 0.02757970f, -0.03959223f, 0.04539569f, 0.01059892f, -0.04352145f, 0.05602736f, -0.00983457f, 
    -0.05396494f, 0.04892181f, 0.04353150f, -0.03473366f, 0.00219889f, -0.04480053f, -0.01102373f, -0.01700973f, 
    0.00219069f, 0.06025083f, 0.01914355f, 0.01507035f, -0.01538517f, -0.03461715f, 0.05434496f, -0.02579615f, 
    0.00586892f, -0.07581818f, 0.01260144f, 0.04441530f, -0.06661378f, -0.04364802f, -0.06782925f, -0.03716604f, 
    0.00133838f, 0.03849791f, 0.02792584f, 0.04102262f, -0.04507492f, 0.02643458f, -0.00843687f, -0.04806451f, 
    -0.01260064f, 0.06111596f, -0.06766824f, -0.03157242f, -0.02600450f, 0.00722676f, -0.04726142f, -0.02895727f, 
    -0.07642413f, 0.03509477f, -0.08795699f, -0.00523333f, -0.01030975f, 0.01079455f, 0.00127850f, 0.01670449f, 
    -0.04987867f, -0.03958539f, -0.03134619f, 0.02252965f, -0.02837811f, 0.03817383f, 0.03819488f, 0.05643104f, 
    0.05967965f, 0.02560637f, 0.04812436f, 0.01951932f, -0.06239744f, 0.02134059f, 0.01109218f, -0.06680354f, 
    0.00943132f, -0.05319155f, 0.05963422f, -0.05719877f, 0.05313265f, 0.00275197f, 0.02273066f, -0.08111929f, 
    -0.01991596f, -0.00378517f, 0.04813038f, 0.02648776f, 0.03053720f, 0.05634417f, 0.03470986f, 0.01567471f, 
    -0.01851607f, -0.06028235f, 0.05802930f, -0.04564234f, -0.04325172f, -0.07077748f, -0.06035483f, -0.01972732f, 
    -0.05432948f, -0.04668505f, -0.06834138f, -0.07997016f, -0.05498250f, -0.06605848f, -0.02981060f, -0.01821691f, 
    0.01074164f, 0.09806549f, 0.01821695f, -0.07696548f, -0.10815321f, -0.01883548f, -0.16060455f, -0.03252154f, 
    0.12895752f, 0.04336016f, -0.05164026f, -0.01973389f, 0.37428114f, 0.29505283f, 0.37354055f, -0.26940334f, 
    0.00118814f, -0.19932814f, 0.03055872f, -0.11639097f, 0.02273582f, 0.11617903f, -0.00092562f, 0.05685131f, 
    -0.32439369f, -0.14292021f, 0.15240766f, -0.00082813f, -0.12578294f, -0.15972842f, -0.03808006f, -0.01000730f, 
    0.12682909f, 0.08069103f, 0.00744065f, -0.01705979f, -0.05398030f, -0.20140961f, 0.21854971f, -0.16366383f, 
    0.07405427f, 0.09514862f, -0.02963645f, -0.00085639f, 0.00739322f, -0.02980424f, -0.09298796f, -0.00113539f, 
    -0.18902284f, 0.08144403f, -0.14402243f, 0.59520566f, -0.07891106f, -0.16898489f, -0.14893599f, -0.12100136f, 
    -0.04660763f, -0.07858366f, 0.03339114f, 0.11405335f, -0.06729346f, -0.08776306f, 0.06060333f, -0.06171005f, 
    0.02578868f, 0.11674140f, 0.12017717f, 0.25709468f, -0.00314503f, 0.14981271f, -0.04818819f, -0.04360238f, 
    -0.33527073f, -0.08027786f, 0.05306589f, 0.21465096f, 0.02743134f, -0.17830361f, -0.05831328f, -0.05754955f, 
    0.12097313f, -0.26348424f, 0.07108536f, 0.04831680f, -0.16236298f, -0.12184891f, 0.04490122f, 0.26559463f, 
    -0.05701224f, 0.02286345f, -0.12589498f, -0.05125673f, 0.07229572f, 0.21123779f, 0.12662919f, 0.21382500f, 
    0.13109316f, 0.09262215f, 0.36119011f, -0.15804595f, -0.10919483f, -0.01375145f, 0.06059444f, 0.02150629f, 
    0.02044125f, 0.00588327f, 0.09979479f, 0.01216421f, 0.12352703f, -0.01918565f, 0.00682568f, 0.14604074f, 
    0.21705101f, 0.10952973f, 0.05639910f, 0.01387091f, 0.09208566f, -0.09555592f, 0.23416841f, 0.03514915f, 
    -0.00147410f, 0.15911740f, 0.24132261f, -0.24743603f, 0.07418738f, 0.09291933f, 0.00766499f, 0.13330653f, 
    0.03228471f, 0.02996611f, 0.01719392f, 0.03570021f, 0.12284879f, -0.07211176f, 0.03518149f, 0.07630230f, 
    -0.06927209f, 0.03951208f, 0.05049246f, 0.00516812f, -0.03507388f, -0.10220463f, -0.00133687f, -0.08937459f, 
    0.36248970f, -0.05293181f, 0.17026143f, 0.04695646f, 0.17661574f, 0.05987830f, 0.06463374f, 0.05164418f, 
    -0.06618528f, -0.03294727f, -0.11531512f, -0.10056427f, 0.30269113f, -0.03629120f, -0.00521200f, 0.01166957f, 
    0.06759130f, -0.00299807f, -0.07749793f, 0.09082646f, 0.02862839f, 0.10249672f, 0.04514471f, 0.25329465f, 
    0.23394202f, 0.08764635f, 0.03785169f, -0.36478388f, 0.20796408f, -0.03849955f, 0.07742842f, 0.11207703f, 
    0.08580657f, -0.04128643f, -0.13496397f, 0.06565396f, -0.10533619f, -0.01038143f, -0.06849653f, -0.01883224f, 
    -0.23998263f, -0.00636191f, -0.06868965f, 0.03706503f, 0.15111773f, 0.15964249f, 0.12118751f, -0.01889072f, 
    0.02627178f, -0.21453327f, -0.16332518f, -0.01795172f, -0.08521198f, -0.02130106f, 0.35677898f, 0.16285126f, 
    0.04423891f, 0.02076338f, 0.20658949f, -0.03104701f, -0.08002780f, 0.05200315f, 0.11075042f, 0.23391716f, 
    0.06977779f, -0.02123295f, 0.09528348f, 0.29569337f, -0.09557819f, -0.02049035f, -0.05943666f, -0.05508000f, 
    -0.06513968f, -0.16837671f, 0.14343904f, 0.24526846f, 0.06522629f, 0.05098242f, 0.00070883f, -0.01989823f, 
    -0.03223692f, 0.00959141f, -0.10638160f, -0.01722732f, -0.21602300f, 0.44054624f, 0.19420876f, -0.06142717f, 
    0.16768070f, 0.05905630f, -0.07260906f, 0.10263716f, -0.02274382f, 0.04362466f, -0.14232227f, -0.08652699f, 
    -0.25415412f, -0.26107931f, -0.05711395f, 0.26609451f, -0.01337175f, 0.00769490f, 0.06164005f, 0.02415994f, 
    0.02958141f, -0.05206025f, 0.03300309f, 0.23557666f, -0.02789867f, 0.06207157f, 0.22937514f, 0.00303524f, 
    -0.05992689f, -0.06472882f, -0.21431048f, -0.05930731f, 0.13234012f, -0.07461001f, -0.05321489f, -0.06640218f, 
    0.10502920f, 0.30038899f, 0.10924293f, 0.26762661f, -0.04263932f, -0.02779738f, -0.08181550f, -0.12919316f, 
    0.08347831f, 0.11309910f, 0.09562422f, -0.06519346f, -0.10876284f, -0.02804517f, 0.11691884f, -0.14306605f, 
    0.11562651f, -0.07478367f, 0.03105564f, 0.05104398f, 0.18805441f, 0.01785446f, 0.11561598f, 0.09891974f, 
    -0.46924603f, 0.00610638f, -0.03637083f, 0.02302658f, 0.04721607f, 0.04952447f, 0.03318770f, 0.15685135f, 
    -0.03111672f, 0.04076120f, -0.01084138f, 0.02584372f, 0.20892790f, 0.18536977f, -0.14590828f, -0.06771332f, 
    0.04922358f, -0.12133489f, 0.06845655f, -0.02381455f, -0.14584057f, 0.01769072f, 0.03252625f, -0.16809580f, 
    0.02601643f, 0.20552526f, 0.08456624f, 0.11424059f, 0.04844686f, -0.00100984f, 0.07655531f, -0.09116270f, 
    -0.06294900f, -0.02406139f, 0.08507504f, -0.15301278f, -0.24282125f, -0.15055874f, -0.11845703f, -0.10633510f, 
    0.04108227f, 0.07821658f, -0.04994766f, -0.10709498f, 0.07644413f, 0.10047004f, -0.13112359f, -0.02988090f, 
    -0.24963626f, -0.07300236f, -0.20862918f, 0.17883232f, 0.00886254f, 0.08716895f, 0.22230837f, -0.04627163f, 
    -0.02590225f, -0.06710637f, -0.13191341f, 0.23390147f, -0.04180121f, -0.02847277f, -0.15442581f, -0.07031846f, 
    0.03950325f, -0.03920696f, -0.01319747f, 0.08190211f, 0.22377799f, 0.06385857f, 0.10880124f, 0.01795100f, 
    0.12227435f, 0.25394750f, -0.34046674f, 0.03036201f, -0.14313240f, 0.19159196f, 0.09379350f, 0.11377106f, 
    0.03228875f, 0.09161008f, 0.11309364f, -0.29392236f, -0.15575618f, -0.27704588f, 0.08089814f, 0.10788762f, 
    0.07633534f, -0.01869529f, 0.06842750f, 0.02871204f, 0.05327388f, 0.10255215f, 0.06421152f, 0.04856408f, 
    0.10291241f, -0.26921842f, 0.11936364f, -0.01544230f, -0.13136929f, -0.00095553f, -0.07704719f, 0.24890754f, 
    0.08886297f, -0.02074362f, -0.00861178f, -0.02189278f, 0.17475760f, 0.02159605f, 0.20998399f, -0.12966496f, 
    0.02073754f, -0.08758325f, 0.00743499f, -0.00239604f, -0.30166635f, 0.06537036f, 0.15259469f, 0.04941116f, 
    -0.15957123f, -0.41725481f, -0.37911394f, -0.34186962f, 0.04495023f, 0.00099894f, 0.15058567f, 0.14143054f, 
    -0.04590671f, -0.01544437f, 0.10409901f, 0.03365988f, -0.06854393f, -0.03816221f, 0.11960783f, -0.28391591f, 
    -0.05602993f, 0.12354353f, -0.02124781f, 0.14142361f, -0.02424644f, 0.11713641f, 0.13713339f, -0.01546003f, 
    0.07673695f, -0.42798015f, 0.23939128f, 0.01789010f, -0.11168915f, -0.07009615f, -0.12786153f, -0.15515015f, 
    0.19382554f, 0.09108503f, 0.06017429f, 0.16604725f, -0.09268326f, -0.26438966f, -0.06937630f, -0.03044674f, 
    0.16680017f, 0.05736294f, 0.08945098f, 0.00754795f, 0.11354896f, -0.03616196f, -0.01909009f, 0.14404117f, 
    0.05211160f, 0.12886840f, -0.11801175f, 0.23377277f, 0.04376495f, -0.00947310f, -0.10432419f, -0.02703158f, 
    0.22237800f, -0.06510533f, 0.08275537f, 0.19050652f, -0.20606397f, 0.15256107f, 0.09560408f, 0.16952623f, 
    -0.04191065f, 0.07828833f, -0.15013276f, 0.01047488f, 0.20879352f, 0.23088239f, 0.17326976f, -0.00078388f, 
    -0.03616212f, -0.27862129f, -0.01471633f, -0.10062023f, 0.04912641f, -0.01841234f, 0.01596915f, 0.10734658f, 
    0.00605502f, -0.01835876f, 0.17531312f, 0.04210657f, 0.20729563f, 0.35267758f, -0.21390282f, 0.21917114f, 
    0.11729094f, -0.02323392f, 0.18842435f, -0.00519268f, 0.18276589f, 0.12314446f, 0.09248898f, -0.11657014f, 
    -0.19974642f, 0.10699414f, 0.02279459f, -0.09925877f, -0.00140445f, 0.06813569f, -0.04975079f, 0.12699659f, 
    0.04375327f, 0.27490944f, 0.11397931f, -0.08232157f, -0.42077640f, -0.01758840f, -0.05922664f, -0.20917457f, 
    -0.13669588f, -0.07182779f, -0.08629142f, -0.08043334f, -0.13892497f, -0.01873066f, -0.00236223f, -0.02168826f, 
    -0.19939640f, -0.27996871f, 0.19872069f, -0.12269875f, 0.32639524f, -0.00349341f, -0.06809308f, -0.08680101f, 
    -0.10055795f, -0.01310891f, 0.03059374f, 0.16876873f, 0.14967790f, -0.09134807f, 0.15454961f, 0.03503644f, 
    0.04946468f, -0.02256634f, -0.00582101f, -0.07388451f, 0.25012290f, 0.09419066f, 0.04660700f, -0.06067619f, 
    -0.44492462f, 0.25756881f, -0.09443707f, 0.10244893f, 0.10676587f, 0.11132888f, -0.06844509f, 0.30642182f, 
    -0.01479775f, -0.04253735f, 0.08119494f, 0.08634526f, -0.21596743f, -0.14591114f, -0.01539093f, -0.16913745f, 
    -0.05923406f, 0.08052604f, 0.19033135f, 0.17647657f, 0.04326582f, 0.13335299f, 0.12963569f, 0.05768947f, 
    -0.01116389f, -0.04380660f, 0.03590186f, 0.00730007f, 0.06047874f, -0.02762245f, -0.03976961f, -0.06798152f, 
    0.00817368f, 0.03926066f, 0.02602156f, -0.00487657f, -0.00768829f, -0.03571016f, 0.02069657f, 0.04613319f, 
    0.01298527f, 0.04705713f, 0.05595474f, 0.04704052f, -0.04718041f, 0.03842502f, -0.07004549f, 0.04501690f, 
    0.03434707f, -0.04468007f, 0.05307688f, 0.00217995f, 0.02642630f, -0.01240051f, 0.00950557f, -0.00719275f, 
    -0.05329600f, 0.00439762f, -0.04107096f, 0.05351209f, -0.01491463f, 0.00265070f, -0.03077565f, 0.01355898f, 
    -0.05416266f, -0.02440159f, 0.03509774f, 0.04944009f, -0.03248096f, -0.00531901f, 0.04210167f, -0.07709855f, 
    0.00326789f, -0.06216798f, 0.05787109f, 0.03432437f, 0.07072198f, -0.01186824f, -0.06622889f, 0.01541036f, 
    0.05932502f, -0.00434623f, 0.00693660f, 0.03819010f, -0.00018560f, 0.00458482f, -0.06941139f, 0.03165378f, 
    -0.05529863f, -0.01182516f, 0.03802257f, 0.02188473f, -0.00990967f, -0.05324534f, 0.05478391f, 0.01048627f, 
    -0.02592096f, -0.04248307f, -0.04239105f, -0.07567807f, -0.01375222f, -0.05217416f, -0.02890315f, 0.00760299f, 
    0.04128388f, -0.06449042f, -0.07436402f, 0.02265397f, 0.02059785f, -0.03902357f, 0.00638857f, 0.00267085f, 
    -0.02916025f, -0.06726487f, 0.03850023f, -0.01273443f, 0.01822975f, -0.03450641f, -0.00468434f, -0.05323578f, 
    -0.01452605f, 0.04102893f, -0.00570101f, -0.03968242f, 0.03495605f, -0.00337078f, -0.03129082f, 0.01506732f, 
    0.01710824f, -0.02448087f, -0.04754888f, -0.07145491f, 0.02400722f, 0.03758539f, -0.03487751f, -0.06113817f, 
    0.03656887f, -0.00972044f, -0.05195383f, -0.06665259f, -0.03555967f, -0.06288786f, -0.07025531f, 0.04902100f, 
    0.04278473f, 0.00448927f, -0.04282954f, -0.05803814f, -0.06007071f, -0.06867318f, -0.04887852f, 0.06207688f, 
    0.00355685f, -0.00185456f, 0.00198329f, 0.02576781f, -0.05488313f, -0.04678603f, 0.05953583f, -0.03735305f, 
    -0.07001135f, -0.07268859f, 0.04175809f, 0.05560600f, -0.07658897f, 0.02805910f, -0.03622470f, 0.02807876f, 
    -0.03083136f, -0.02337836f, -0.05997200f, 0.04781921f, -0.01046765f, 0.05625132f, -0.05186397f, -0.03839533f, 
    0.03622299f, -0.02880383f, -0.04962643f, -0.00091231f, 0.03467250f, -0.01455407f, 0.03956443f, -0.03869173f, 
    -0.07167598f, -0.04989591f, 0.03728499f, -0.06672677f, -0.05158391f, -0.06802037f, 0.01492354f, 0.04528959f, 
    -0.04389192f, -0.04476002f, 0.03676085f, -0.03497762f, -0.00419288f, -0.01275273f, 0.03907180f, -0.02548332f, 
    0.01119506f, 0.05092439f, -0.01086927f, -0.00177048f, -0.03800796f, 0.03744775f, 0.03378774f, 0.02620778f, 
    -0.03481242f, 0.04741543f, 0.00710466f, -0.07643183f, 0.00338442f, 0.02480259f, -0.02069963f, -0.00648345f, 
    -0.35867059f, -0.02001022f, -0.12583315f, -0.12416491f, 0.02822843f, -0.05548241f, -0.04553320f, -0.03245275f, 
    -0.20393209f, -0.22185473f, -0.10997911f, -0.13201927f, -0.03730199f, -0.26426101f, -0.20025225f, -0.22474602f, 
    -0.07832361f, -0.11292485f, 0.03663329f, 0.01455985f, 0.12497870f, -0.10093234f, -0.12734443f, -0.02630249f, 
    -0.02211189f, -0.00761816f, 0.34699082f, 0.44148013f, -0.04569046f, 0.24497265f, 0.13371700f, 0.02210871f, 
    -0.06839249f, 0.04631317f, 0.05292355f, 0.14225964f, 0.07276721f, -0.03653885f, 0.44371158f, -0.22895117f, 
    -0.09728393f, 0.02013453f, -0.04656434f, 0.05309916f, 0.09167338f, -0.01839069f, 0.01061857f, 0.10510860f, 
    0.04737839f, -0.00635617f, -0.24133322f, 0.05823461f, -0.20907426f, -0.08787682f, -0.07695135f, 0.00752438f, 
    -0.01348712f, 0.07050380f, -0.00003820f, -0.08908758f, 0.03081198f, 0.19561018f, 0.13250510f, 0.08752903f, 
    0.05817037f, 0.04756631f, 0.17551716f, 0.12510981f, 0.04290064f, 0.05158620f, 0.16189307f, 0.23417719f, 
    0.37487426f, 0.16040786f, -0.00252813f, -0.19242765f, -0.14737138f, -0.09792969f, 0.01346037f, -0.08995076f, 
    0.14826412f, 0.15293342f, 0.17970006f, -0.06060046f, 0.32909670f, -0.00040576f, 0.10300784f, 0.05684047f, 
    -0.12548494f, -0.00905016f, -0.08032204f, -0.00536348f, 0.12105680f, -0.12502503f, 0.03864148f, 0.10503390f, 
    -0.11293296f, 0.02943264f, 0.09939177f, -0.02693206f, -0.08191412f, -0.02286339f, 0.17787173f, 0.15769520f, 
    -0.03008150f, -0.07355931f, -0.17260027f, -0.05622574f, -0.08226641f, 0.03862816f, -0.08490642f, 0.19735089f, 
    0.18727662f, 0.04720329f, 0.08705060f, -0.07448532f, 0.09245962f, 0.10258380f, 0.02438090f, 0.03113975f, 
    -0.09238759f, -0.02404123f, -0.01712846f, 0.14961411f, 0.01857260f, 0.09915706f, 0.07290301f, 0.01170831f, 
    0.06163834f, -0.24417681f, -0.14971776f, -0.20059887f, 0.16771777f, 0.18613331f, 0.00573172f, 0.10061026f, 
    -0.05857956f, -0.00029594f, -0.08395384f, -0.00918089f, 0.18032415f, 0.08953586f, -0.02043382f, 0.14183427f, 
    -0.00634329f, 0.12025061f, -0.11509147f, 0.22120413f, -0.01209105f, -0.11319776f, -0.05099564f, 0.09259902f, 
    0.18435764f, 0.09103257f, 0.00548843f, 0.01357052f, 0.13644785f, -0.02361644f, 0.09663100f, -0.09197028f, 
    -0.03450640f, -0.09141397f, -0.11032660f, -0.07296544f, 0.02254377f, -0.30883032f, -0.08724249f, -0.10877530f, 
    0.10030893f, 0.12814331f, -0.32432559f, 0.17023286f, 0.13733695f, 0.04857362f, 0.01334635f, 0.13137130f, 
    0.01483431f, -0.10652611f, 0.01342148f, 0.04200473f, -0.01558151f, 0.07284544f, 0.23577641f, 0.17511317f, 
    0.02203459f, 0.15518989f, -0.02107964f, 0.13520756f, 0.00400401f, -0.07779434f, -0.04828810f, -0.03709624f, 
    -0.15188017f, -0.23819858f, -0.27563730f, -0.29217261f, 0.04393048f, -0.24231994f, -0.13297908f, -0.16675833f, 
    -0.18948342f, -0.16524705f, -0.09485175f, 0.20291974f, -0.03164317f, -0.51560795f, -0.25030014f, -0.23246741f, 
    -0.02435423f, -0.06946026f, 0.03826883f, 0.04025900f, 0.05564468f, -0.00666982f, 0.13130370f, -0.15445904f, 
    -0.27940819f, -0.12142227f, -0.23922014f, -0.09165520f, 0.34603190f, 0.24059053f, -0.11862762f, 0.04883621f, 
    -0.09674051f, 0.03500615f, 0.03057836f, -0.07043660f, 0.66576040f, 0.14519118f, 0.37209585f, 0.34574857f, 
    0.07371431f, 0.10257254f, 0.02791472f, 0.07835165f, 0.06386179f, 0.00847752f, 0.05345703f, -0.00416662f, 
    0.07924744f, 0.14343898f, -0.00370891f, -0.08480689f, -0.01353495f, 0.06654269f, -0.01102707f, 0.00122710f, 
    -0.08002838f, -0.00955352f, 0.12932137f, 0.11752412f, 0.04987681f, -0.02904577f, -0.06386684f, -0.00180648f, 
    0.07503753f, 0.05592324f, 0.09068096f, 0.00794310f, -0.02355102f, -0.01688484f, -0.04346918f, 0.11363194f, 
    0.09292323f, -0.02735958f, -0.08383015f, -0.09194920f, -0.09654956f, -0.06059353f, 0.03617363f, -0.00738251f, 
    0.11769130f, 0.04316711f, -0.02330364f, -0.09864985f, 0.23019762f, 0.02010509f, 0.17203097f, 0.10860713f, 
    0.00058049f, 0.10939334f, -0.02371080f, -0.02787936f, 0.03836332f, 0.05484557f, -0.04270182f, 0.06683393f, 
    0.06756178f, -0.64895028f, -0.68406868f, -0.67773199f, -0.28825170f, -0.19037472f, 0.02013634f, 0.08008067f, 
    -0.08329219f, -0.07601161f, -0.05684799f, -0.10894168f, -0.03256343f, 0.24390401f, 0.34540027f, 0.16082998f, 
    -0.03765275f, 0.15183879f, 0.15741590f, -0.09047769f, 0.23401386f, -0.05410579f, -0.02161357f, 0.07437248f, 
    -0.48978463f, -0.43731031f, -0.00690851f, -0.04846505f, 0.01488118f, -0.01491820f, -0.22388177f, 0.02395632f, 
    0.21922512f, -0.10739177f, -0.22564581f, -0.04409571f, 0.15025266f, 0.17982350f, 0.06042168f, 0.23714373f, 
    0.03938384f, -0.07931662f, 0.03848271f, 0.05512993f, -0.00690499f, -0.02273513f, -0.08482005f, 0.08330444f, 
    0.22607222f, 0.19459546f, 0.09470254f, 0.12465442f, -0.09873407f, -0.09346819f, -0.01900141f, -0.07880418f, 
    -0.00139036f, 0.04653230f, 0.07282548f, 0.02015512f, 0.08781147f, 0.04784152f, 0.10676446f, 0.05348229f, 
    0.06727391f, 0.09891023f, -0.03270088f, -0.01012263f, 0.06484497f, -0.21834126f, -0.22466792f, 0.04294404f, 
    0.03725521f, 0.04073372f, 0.15774156f, 0.06173597f, 0.03342354f, -0.11492598f, 0.16342337f, 0.00508124f, 
    0.20450111f, 0.34847513f, -0.05695033f, 0.11513581f, 0.04334336f, -0.71176845f, -0.59297061f, -0.20677650f, 
    0.14392005f, 0.22658753f, 0.04389405f, 0.19261968f, -0.04071331f, -0.03146319f, -0.05446693f, -0.15625745f, 
    -0.10505303f, 0.15671061f, -0.11620327f, -0.30682290f, -0.12478018f, -0.02321712f, 0.27532747f, 0.25778979f, 
    -0.06095593f, 0.11676279f, 0.03376428f, -0.15655862f, -0.09364708f, -0.17439058f, 0.08193491f, -0.29400751f, 
    -0.03919281f, -0.14265817f, 0.05475089f, 0.10241473f, -0.09147324f, -0.03067287f, 0.12979582f, -0.05734421f, 
    0.04963038f, -0.00212140f, 0.07566895f, -0.12567233f, 0.14675921f, -0.03254752f, 0.06400015f, -0.13272110f, 
    -0.04369501f, 0.01387438f, -0.10766795f, 0.03900205f, -0.13196044f, 0.02117268f, 0.07997527f, -0.17379682f, 
    -0.01323225f, 0.14758012f, -0.05258314f, 0.09783681f, -0.04734322f, 0.02920308f, -0.08165994f, 0.05924182f, 
    -0.48265192f, -0.02751171f, -0.02034602f, 0.61017030f, -0.00167268f, -0.16786009f, -0.02005160f, -0.28949368f, 
    -0.01129313f, 0.03228075f, 0.13050592f, -0.01853005f, 0.00828703f, 0.17817473f, 0.06414764f, -0.12402295f, 
    0.06638724f, 0.15134348f, -0.04969623f, 0.15809301f, 0.02883253f, -0.02125594f, -0.04266329f, 0.00447198f, 
    -0.29986566f, -0.03927829f, 0.17060260f, 0.02057436f, -0.02404273f, 0.03548831f, 0.03228354f, -0.15154189f, 
    0.15663975f, 0.08254682f, 0.15901893f, -0.11493499f, -0.22854610f, 0.08021283f, -0.04634304f, 0.21055765f, 
    0.06460348f, -0.05651449f, -0.03885552f, -0.09528218f, 0.14741172f, 0.20605519f, 0.24177745f, 0.19207548f, 
    0.23753721f, -0.05704024f, -0.29189521f, -0.08850955f, 0.07318468f, 0.07140245f, -0.08571366f, 0.30949000f, 
    -0.04067402f, 0.09358880f, -0.05572284f, -0.04891383f, 0.33167157f, -0.04649598f, 0.24579155f, 0.16672492f, 
    0.14628135f, 0.11395172f, 0.09408700f, -0.06344434f, -0.02020060f, 0.12380027f, 0.22353317f, 0.08051099f, 
    0.01055684f, 0.12059610f, 0.12717228f, -0.19250700f, 0.05031902f, -0.00598659f, 0.03597000f, 0.02356032f, 
    -0.22509910f, -0.08583084f, 0.03757627f, -0.21351802f, 0.07963081f, 0.03108017f, 0.25015581f, 0.17977330f, 
    -0.10082212f, -0.02155411f, -0.07204006f, -0.10669413f, 0.05398457f, 0.07262504f, -0.13597535f, 0.00073598f, 
    0.11334670f, 0.23801838f, 0.02258289f, 0.22285469f, 0.01690914f, -0.02288857f, 0.35896924f, -0.01064840f, 
    -0.08070155f, 0.06008651f, -0.09622647f, 0.22262101f, -0.15337168f, -0.10519642f, 0.04681003f, 0.20943855f, 
    -0.04709127f, -0.04158704f, 0.00017271f, 0.14928314f, 0.08764245f, -0.17731492f, -0.07041849f, -0.19347380f, 
    0.14418305f, -0.11555195f, -0.08776511f, 0.07607351f, 0.04055661f, 0.10396551f, 0.12813462f, 0.09135850f, 
    0.04781292f, -0.04301428f, 0.04025551f, -0.19951177f, 0.18731272f, 0.05140861f, -0.01234602f, -0.12252645f, 
    -0.02412237f, -0.00540146f, 0.00210803f, -0.01012876f, 0.00576654f, 0.10344330f, -0.02260462f, -0.06295275f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08550427f, 0.32937044f, -0.01288749f, 0.09816593f, 0.03568806f, -0.08845500f, 0.05022358f, 0.26246589f, 
    -0.01154473f, 0.01507437f, 0.11793772f, 0.25961781f, 0.00304838f, 0.02675430f, -0.04521944f, 0.21029413f, 
    -0.04058985f, 0.08363967f, 0.15890580f, -0.08428450f, 0.23016448f, -0.03432848f, 0.09499062f, -0.05378911f, 
    0.07608259f, 0.08949902f, -0.03620535f, -0.00983730f, 0.14892234f, 0.02970706f, 0.00472372f, -0.06417184f, 
    0.01988956f, -0.02398781f, 0.03537541f, 0.11520259f, 0.11123462f, 0.09186168f, -0.11127373f, -0.01930165f, 
    -0.09668636f, 0.01175057f, -0.03785304f, 0.14491864f, 0.06263766f, -0.05598381f, -0.03882699f, 0.08593423f, 
    0.12805979f, 0.04923422f, 0.03437819f, 0.15714002f, 0.08863584f, -0.03029063f, -0.00218056f, 0.03266895f, 
    0.02794933f, 0.15237778f, -0.01602727f, 0.21794479f, -0.06683099f, 0.16045369f, 0.30792803f, 0.15814024f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.41958570f, -0.19116054f, -0.06071116f, -0.20043600f, 0.18135418f, 0.21356061f, 0.06761684f, -0.17353556f, 
    0.00891714f, -0.24849169f, 0.21051450f, -0.22508729f, 0.28658432f, 0.17036971f, 0.27422690f, 0.02335896f, 
    0.08388364f, -0.06915554f, -0.70023870f, -0.08468795f, -0.28675827f, 0.01986209f, -0.18218881f, -0.04090539f, 
    0.01606037f, 0.03200890f, 0.09674088f, 0.24479151f, -0.67612922f, 0.33300078f, -0.23768948f, 0.14367577f, 
    0.10901789f, 0.31135869f, -0.41293067f, 0.01498975f, -0.46971682f, -0.62254483f, -0.32036301f, 0.27360049f, 
    0.14872283f, -0.06209594f, 0.13073575f, 0.20404294f, -0.13205601f, -0.03179356f, -0.17543970f, -0.59057838f, 
    -0.32338631f, -0.05848240f, -0.00935139f, -0.61557806f, 0.09130175f, 0.02643280f, -0.08587905f, -0.06261404f, 
    0.08659377f, -0.32651234f, -0.46433815f, -0.26648042f, 0.01703807f, -0.36669120f, -0.34347263f, -0.04891465f, 
    0.33568776f, 0.18085635f, 0.11714339f, -0.12365741f, 0.02069717f, -0.62557453f, -0.00002832f, 0.31624737f, 
    0.02506462f, -0.15609244f, 0.11539514f, 0.07732187f, 0.25039375f, -0.20964058f, -0.59454435f, 0.14436200f, 
    -0.02972377f, 0.01238763f, -0.17010425f, -0.10822029f, 0.17403395f, -0.13279204f, 0.00358186f, -0.06693798f, 
    -0.20982993f, 0.25408739f, -0.09805509f, 0.09395203f, -0.42126691f, 0.22247972f, -0.05640882f, 0.06884651f, 
    0.15464939f, -0.99294257f, -0.13150425f, 0.02609321f, -0.06402107f, -0.21856564f, -0.06223658f, 0.05077020f, 
    0.24424911f, 0.01884049f, -0.05479141f, 0.16720845f, 0.13808286f, -0.09725184f, -0.20556211f, -0.04310374f, 
    0.22089183f, 0.21713375f, -0.07364155f, -0.31039393f, -0.17200497f, 0.11854955f, 0.23410310f, -0.48206297f, 
    -0.10897356f, 0.11920784f, -0.55558115f, -0.33961114f, -0.07742888f, 0.17551972f, 0.29337344f, -0.07892150f, 
    0.28278267f, 0.17822361f, 0.12408222f, -0.09943635f, -0.23258756f, -0.54273766f, -0.08667467f, 0.18237473f, 
    0.05270148f, 0.03786009f, -0.22205497f, -0.19700927f, -0.02459216f, 0.03603559f, -0.12785919f, -0.10781395f, 
    0.04050680f, -0.01405235f, -0.13494976f, -0.00917133f, -0.14251001f, -0.25651613f, 0.18521294f, 0.04721542f, 
    0.07064252f, 0.05417414f, -0.19266649f, 0.10834302f, 0.53210801f, -0.62432814f, -0.32408428f, 0.00196357f, 
    -0.02235909f, 0.20981157f, -0.15072766f, -0.01086348f, 0.58709252f, -0.03687128f, -0.30072337f, 0.10674322f, 
    -0.30242342f, 0.04898325f, 0.04866229f, -0.00831774f, -0.16657664f, 0.07203545f, 0.08182167f, -0.05281132f, 
    0.30280855f, -0.32482275f, -0.04280776f, 0.15914109f, 0.24945986f, 0.10958132f, -0.09187086f, 0.29718485f, 
    -0.00171127f, 0.07781685f, -0.14146186f, 0.09052052f, -0.11118685f, -0.24228513f, 0.02543727f, -0.33664379f, 
    0.14150120f, -0.14603439f, -0.22062968f, -0.35026592f, -0.35478482f, 0.10971315f, -0.11731888f, -0.27220121f, 
    0.01745363f, 0.07163397f, -0.33823353f, -0.12221593f, 0.23311591f, -0.13728516f, 0.00403909f, 0.11925597f, 
    -0.19301949f, 0.23533796f, -0.23760638f, -0.04018179f, -0.56679517f, 0.26090112f, 0.15374807f, -0.10518213f, 
    -0.35476875f, 0.18124129f, 0.37069839f, 0.06053321f, -0.03376010f, -0.40690735f, 0.23522504f, -0.12489407f, 
    -0.06226017f, 0.04332719f, 0.27103809f, -0.39122277f, 0.06321242f, 0.21841323f, 0.38038531f, 0.05825441f, 
    0.23643498f, 0.39903641f, 0.04675263f, -0.10873777f, -0.44780260f, -0.00010003f, 0.25283465f, -0.49829504f, 
    0.03042299f, -0.19742398f, -0.04565154f, 0.31069621f, -0.25687230f, 0.09631649f, -0.51920533f, 0.15471065f, 
    -0.09646168f, -0.35360986f, 0.18769222f, 0.04763085f, 0.03331374f, -0.24916570f, -0.08493949f, -0.42127988f, 
    -0.09304948f, -0.43031317f, -0.11561386f, -0.07041403f, 0.09455389f, 0.28824463f, -0.02218364f, -0.28851813f, 
    -0.08289222f, 0.01066214f, -0.03940660f, 0.02389539f, 0.01258116f, 0.33782855f, -0.08112889f, -0.01525180f, 
    0.30087993f, -0.24430189f, -0.03517939f, 0.02073307f, -0.01585319f, 0.09762105f, 0.04559771f, 0.10008448f, 
    -0.07305074f, -0.46021542f, -0.21683863f, -0.03170727f, 0.25803617f, 0.01724952f, -0.12977357f, 0.18456063f, 
    -0.20974189f, 0.26459202f, -0.12445457f, -0.25089136f, -0.17955919f, -0.02985854f, 0.13277300f, 0.04067225f, 
    0.11099599f, -0.35582551f, -0.05235057f, -0.02363886f, 0.26304394f, -0.11793416f, 0.07066277f, 0.09045312f, 
    0.25020659f, -0.11790319f, 0.03892260f, -0.46783835f, -0.15860479f, 0.12773865f, -0.38174391f, 0.15586658f, 
    -0.03787500f, -0.05158671f, 0.24620274f, -0.76531303f, 0.00072277f, 0.15509710f, 0.18782173f, -0.22483817f, 
    -0.63815767f, -0.15628220f, -0.31465968f, 0.20654906f, 0.09720869f, 0.03000841f, -0.11333831f, 0.23914900f, 
    -0.10143185f, -0.07794307f, 0.11654132f, 0.16455466f, -0.04978955f, -0.07841788f, 0.20572959f, -0.03371889f, 
    0.24250677f, -0.06359463f, 0.31520131f, -0.04144121f, 0.15710469f, -0.02880143f, 0.06918384f, -0.09753268f, 
    0.19243924f, -0.28565353f, 0.06247047f, -0.20854406f, 0.02171994f, 0.32167917f, 0.27387220f, 0.22150856f, 
    -0.23062012f, -0.42075822f, -0.01225435f, 0.09780272f, 0.36997402f, -0.22060202f, -0.35375154f, 0.11514516f, 
    -0.35655889f, -0.19218425f, 0.00796359f, 0.09131485f, 0.00152494f, 0.09633734f, -0.46938404f, -0.11821566f, 
    -0.51977932f, 0.37539580f, -0.00954986f, 0.07752736f, -0.25682658f, -0.05594135f, -0.19621764f, -0.06792507f, 
    0.02806634f, -0.07436077f, 0.19344755f, 0.06363772f, -0.06981713f, 0.16854273f, -0.32860091f, 0.26591718f, 
    0.19623609f, 0.12134656f, 0.24756435f, 0.15844455f, 0.19501998f, -0.55144161f, -0.02401249f, -0.23373979f, 
    -0.05462680f, 0.22218367f, -0.31172010f, -0.65595376f, -0.71912062f, 0.08378018f, 0.32949087f, -0.53852963f, 
    0.06362134f, 0.17676337f, 0.24474642f, -0.05650328f, 0.18756323f, 0.07268851f, 0.13676766f, -0.11506217f, 
    -0.36373025f, -0.14731218f, -0.31497791f, -0.08927836f, 0.10056676f, 0.11280335f, -0.27830222f, -0.32571641f, 
    0.16132097f, -0.45994368f, -0.26023915f, 0.19320159f, -0.15963246f, -0.02481939f, 0.15834281f, -0.30746686f, 
    0.11086759f, -0.22142601f, 0.01974967f, -0.25668010f, -0.11367827f, 0.01659127f, 0.23777911f, -0.01936888f, 
    0.24778859f, -0.51603848f, 0.05493264f, 0.25675815f, 0.14491028f, -0.32350591f, 0.29007632f, -0.09962965f, 
    -0.07306296f, 0.09207951f, 0.23480336f, -0.03292430f, -0.00581355f, -0.32184532f, -0.24006583f, -0.00747187f, 
    -0.05235673f, -0.22545113f, 0.02947508f, -0.06552427f, -0.04457344f, 0.03707018f, -0.09709144f, -0.16866475f, 
    0.01585267f, -0.00796435f, -0.14434469f, 0.22099538f, -0.40220872f, -0.09479169f, 0.25558352f, -0.43114159f, 
    0.05206585f, -0.06849310f, 0.10646150f, -0.11902340f, -0.07170338f, -0.32077840f, 0.12762724f, 0.11717457f, 
    -0.00272550f, -0.12834625f, 0.39001262f, -0.53936964f, -0.06163946f, -0.36333168f, 0.07067009f, 0.23717721f, 
    0.02115858f, 0.66054624f, 0.05691993f, 0.05613860f, 0.04767322f, -0.22138190f, 0.25673038f, -0.28492513f, 
    0.00523531f, 0.32332703f, 0.01584696f, -0.21588939f, 0.09725656f, 0.01701987f, -0.37421849f, 0.25631976f, 
    -0.20106047f, 0.34271732f, 0.12259971f, 0.13598892f, 0.20465459f, -0.54346472f, 0.13069506f, -0.24437802f, 
    -0.00393265f, -0.44412923f, -0.06957932f, -0.02075601f, -0.02153740f, 0.23457086f, -0.01250396f, -0.41948417f, 
    0.24352869f, 0.09450102f, -0.24253142f, 0.32514068f, -0.14898457f, -0.61602402f, -0.09031245f, -0.13020299f, 
    0.07055050f, -0.50820887f, 0.10289263f, 0.38001373f, -0.50783771f, -0.71615154f, -0.72399616f, 0.27621925f, 
    -0.26759097f, 0.34046981f, 0.13553414f, -0.04561474f, 0.14249434f, 0.07839452f, -0.20569463f, 0.09322924f, 
    0.48705548f, 0.19112866f, 0.16991001f, -0.31445548f, 0.01341820f, -0.51627862f, 0.23053317f, -0.04771497f, 
    -0.11806020f, -0.09899023f, 0.35847020f, 0.07836203f, -0.51515388f, -0.02842808f, 0.14075238f, 0.06863787f, 
    -0.42886260f, 0.21352422f, 0.10079748f, -0.00427053f, -0.30002716f, -0.02752260f, -0.41386825f, -0.15088420f, 
    -0.23347664f, -0.14524136f, 0.10555559f, 0.22511443f, 0.23096798f, -0.38501278f, -0.16252533f, 0.08356446f, 
    0.11074962f, -0.09953235f, 0.05347363f, 0.43710870f, 0.04663557f, 0.14272361f, -0.09937219f, 0.03563382f, 
    -0.29864806f, -0.04910352f, 0.24986787f, 0.00057034f, 0.08912560f, 0.33991829f, -0.05175838f, -0.27185991f, 
    0.13794170f, 0.16348727f, 0.44273779f, 0.02980499f, -0.08780346f, 0.35464537f, -0.04497987f, -0.22327887f, 
    -0.09417294f, -0.50356919f, 0.10479397f, -0.09367896f, 0.16902818f, -0.22801960f, 0.23547366f, -0.01349652f, 
    -0.33122340f, -0.29489693f, 0.12745777f, -0.10530858f, -0.33062750f, -0.17929459f, -0.33093643f, -0.15541179f, 
    -0.30579665f, 0.09255724f, -0.37725288f, 0.18793352f, -0.27593800f, 0.13680148f, -0.35040858f, -0.41773820f, 
    -0.07010844f, -0.14358003f, 0.05231279f, -0.48092598f, 0.21733907f, -0.09529852f, 0.14582931f, 0.20216639f, 
    -0.06420238f, 0.18095502f, 0.09510034f, -0.38606921f, -0.02116674f, 0.34850141f, -0.02290991f, -0.31593049f, 
    0.02266890f, 0.29218450f, 0.04673561f, 0.42403126f, -0.06277468f, -0.11136686f, -0.09891129f, 0.13894923f, 
    -0.02273412f, 0.22934012f, -0.27531633f, -0.36445391f, 0.22176377f, -0.74061036f, 0.03705358f, 0.30365950f, 
    -0.08276986f, 0.26847410f, -0.58640361f, 0.34810391f, 0.02930663f, 0.14057267f, -0.46434230f, 0.19954455f, 
    -0.11222854f, -0.17604215f, 0.28391454f, -0.05756200f, -0.38531470f, -0.00125411f, -0.29949731f, 0.11499120f, 
    -0.16980495f, -0.07432944f, -0.16987529f, 0.03423530f, -0.09969202f, -0.21385767f, -0.44606230f, -0.69401854f, 
    0.43803734f, -0.39429376f, 0.40060261f, 0.39551950f, -0.02383166f, 0.37688643f, 0.19123320f, 0.10949312f, 
    0.00557555f, -0.03610018f, -0.00090979f, 0.10478812f, 0.25210994f, 0.01083833f, -0.52268291f, -0.07367706f, 
    -0.54723626f, -0.27451459f, 0.03010666f, 0.38990897f, -0.14863491f, 0.12086716f, -0.45196968f, 0.18107542f, 
    0.01801505f, -0.19547421f, 0.08323228f, -0.32947373f, -0.04387797f, 0.34180179f, -0.57590377f, 0.20922619f, 
    0.00603166f, 0.10616736f, 0.20575033f, -0.32564673f, -0.19595794f, -0.47266892f, -0.02124298f, 0.15495476f, 
    -0.07563803f, 0.16456594f, 0.01270324f, -0.39375076f, -0.15988782f, -0.60226583f, 0.07035392f, -0.02977345f, 
    -0.23389418f, -0.02017755f, -0.34008360f, 0.03590483f, 0.17741805f, 0.24619247f, -0.54827940f, 0.00441637f, 
    0.34160331f, 0.22657998f, -0.42487484f, 0.08639047f, 0.36760992f, 0.08379695f, 0.32877019f, -0.11920021f, 
    -0.15402025f, -0.07415937f, 0.31429604f, -0.69508862f, -0.18441674f, 0.11006840f, 0.29547840f, -0.20514964f, 
    0.18672121f, -0.17368953f, 0.07297909f, -0.10128690f, 0.16780725f, -0.10623817f, 0.44818491f, 0.06661583f, 
    0.29077297f, 0.07594008f, -0.07492835f, -0.13950920f, -0.14906397f, -0.36136493f, -0.02294535f, 0.38952014f, 
    -0.05074731f, 0.22371371f, 0.04192236f, -0.14363813f, -0.06807731f, -0.25800017f, -0.34354430f, 0.38135394f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09059687f, 0.00562141f, 0.16145276f, 0.00219108f, 0.10497456f, 0.13469581f, -0.06213334f, -0.21968715f, 
    0.00116866f, -0.03744959f, -0.07293767f, -0.04792196f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
