#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.26008233f, -0.16938649f, -0.10403417f, -0.61128807f, -0.71229559f, -0.47459382f, 0.38110000f, 0.14441504f, 
    0.31765369f, 0.64143980f, 0.00818155f, -0.02997262f, 0.51578510f, 0.28055450f, 0.02242318f, -0.00109479f, 
    0.01131548f, -0.39660183f, 0.07447618f, 0.69866037f, 0.36163720f, -0.66898084f, -0.30638441f, 0.00690450f, 
    -0.11121618f, 0.08955391f, 0.10012919f, -0.18027775f, -0.11665476f, -0.32777658f, -0.42198268f, -0.33238193f, 
    -0.10440771f, -0.51342458f, -0.38599530f, 0.24760015f, -0.49432456f, -0.19656181f, -0.14251021f, 0.27899653f, 
    -0.14268225f, -0.78186488f, -0.47465941f, 0.18727981f, -0.15634409f, -0.67956269f, -0.57773250f, 0.62430251f, 
    0.64701480f, 0.47183520f, 0.01477638f, -0.32951710f, -0.33978942f, -0.23680583f, -0.65716261f, 0.42676166f, 
    0.61680621f, -0.12903269f, 0.45321992f, -0.41828239f, -0.05612394f, -0.33390105f, -0.03325108f, -0.21234000f, 
    -0.74372697f, -0.81530392f, 0.23920524f, -0.16177016f, 0.47519988f, -0.00377278f, 0.15731826f, 0.40254635f, 
    0.41647935f, 0.31060293f, -0.19151211f, 0.47888228f, 0.05858645f, 0.04805230f, -0.41808441f, 0.32693163f, 
    0.22391705f, -0.85906816f, -0.22959015f, -0.24209900f, 0.45349380f, 0.44470820f, 0.34041563f, -0.06241504f, 
    0.31089360f, 0.36866814f, 0.59776270f, -0.39582837f, -0.18308355f, -0.64160180f, -0.33231556f, 0.96191674f, 
    -0.10271432f, 0.21925925f, -0.18834609f, -0.48742378f, -0.32499704f, -0.26198578f, -0.18220271f, -0.37158114f, 
    -0.52733672f, 0.15057874f, 0.03018922f, -0.02364414f, -0.30277166f, -0.25440252f, 0.40266034f, -0.26491395f, 
    0.14093708f, -0.63616663f, 0.10320500f, 0.39615160f, 0.55821002f, -0.15066411f, -0.27081618f, -0.48473129f, 
    0.53357911f, -0.48460737f, -0.33954349f, 0.18130478f, 0.03011083f, 0.16464545f, -0.56385463f, -0.80518162f, 
    -0.51557642f, 0.75899476f, 0.57458955f, 0.12441064f, 0.19885673f, -0.48816067f, -0.28154737f, 0.30472773f, 
    0.42093006f, 0.31185177f, -0.00898766f, 0.22486237f, 0.10707748f, -0.19143397f, -0.59338719f, 0.03624962f, 
    -0.03088953f, -0.22320458f, 0.55097449f, 0.32699090f, -0.58405417f, -0.50428748f, 0.14539127f, 0.67822754f, 
    -0.43004027f, 0.24711339f, -0.12643072f, 0.34962776f, -0.28545842f, 0.09147377f, 0.12861755f, -0.02917258f, 
    0.25657809f, -0.53919262f, -0.67269266f, -0.17435966f, 0.03233820f, -0.27185741f, -0.17271671f, 0.11103833f, 
    0.46124855f, -0.65091878f, 0.51820487f, 0.49403653f, -0.30070341f, 0.00579766f, -0.05639699f, 0.26309121f, 
    -0.19327472f, -0.54100525f, 0.87609851f, -0.37915617f, 0.25724426f, -0.11440989f, 0.11690501f, 0.39372575f, 
    -0.20227399f, -0.01831418f, 0.00644786f, 0.26268536f, 0.29821211f, 0.49915341f, 0.18124528f, 0.46069250f, 
    0.23867406f, -0.59340113f, -0.70126611f, 0.16481605f, 0.01848479f, 0.15762462f, -0.62829030f, 0.24638450f, 
    0.14245190f, 0.48137629f, 0.47695708f, 0.50298744f, 0.40751934f, -0.09159679f, -0.06117491f, 0.09267998f, 
    -0.50491095f, 0.30239040f, 1.05449617f, -0.78295714f, 0.01420250f, -0.11489030f, 0.17238958f, -0.49550930f, 
    0.19652563f, 0.08590799f, 0.11792493f, -0.09684828f, -0.26301229f, 0.18218908f, 0.13948369f, 0.40494460f, 
    0.17444944f, 0.38088188f, 0.30816048f, 0.55070585f, -0.20048000f, 0.14916196f, -0.14682142f, 0.07179978f, 
    -0.02938090f, -0.11560106f, 0.45090097f, -0.84705603f, -0.68499190f, 0.18696710f, 0.21365820f, 0.06657496f, 
    -0.24175493f, -0.17353787f, -0.52550012f, 0.32937348f, 0.16702114f, -0.57586342f, -0.43996122f, -0.37201026f, 
    0.12765665f, 0.23258969f, 0.47503862f, 0.47238162f, -0.04855753f, -0.10362919f, 0.54363972f, -0.51692194f, 
    -0.00508275f, 0.21219069f, 0.39641351f, -0.55272710f, 0.38609925f, 0.01871147f, 0.26351425f, 0.00300172f, 
    0.01163227f, -0.55082184f, 0.43230900f, -0.08714480f, 0.28464350f, -0.44371355f, 0.66593790f, 0.75060999f, 
    -0.78018594f, -0.41962835f, 0.17031719f, -0.11003420f, 0.22429943f, 0.04219939f, -0.13176601f, -0.45684758f, 
    0.02224626f, -0.25142014f, -0.27552670f, 0.57361293f, 0.25606102f, 0.03093076f, 0.34278458f, 0.29433617f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10180101f, 0.13828638f, -0.15191184f, 0.20334744f, -0.01728983f, 0.05398535f, 0.07475366f, 0.28678676f, 
    -0.16024855f, 0.07241470f, -0.06741309f, -0.10634470f, -0.24608700f, -0.15565459f, -0.09336907f, -0.13847286f, 
    0.01313340f, 0.39575529f, -0.04486621f, -0.27178827f, -0.28601500f, 0.05068706f, -0.22663558f, -0.28183192f, 
    0.41890344f, -0.17862998f, -0.10996272f, -0.11477523f, 0.17372899f, -0.01803732f, 0.09601325f, 0.39624593f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.21103454f, -0.02858370f, -0.11049345f, 0.01869858f, -0.08448108f, 0.07914595f, 0.01348057f, 0.16385059f, 
    0.10944675f, -0.09768470f, -0.11670836f, -0.00171147f, -0.13790068f, 0.00970956f, -0.00493665f, -0.04073986f, 
    -0.04903866f, 0.00071133f, 0.08344731f, -0.08604266f, -0.01861062f, 0.03792842f, -0.00244264f, 0.09252361f, 
    0.09383050f, -0.07425290f, -0.13203417f, 0.00096335f, -0.05387950f, -0.08564109f, 0.00031983f, 0.12076935f, 
    0.06175346f, 0.13474733f, 0.05404392f, 0.01715332f, -0.02294380f, -0.06302767f, -0.04106425f, -0.02744515f, 
    0.01720273f, 0.06775071f, 0.01076280f, -0.01145029f, -0.17788486f, -0.12875931f, -0.23093636f, 0.18258949f, 
    0.01499586f, 0.00401755f, -0.02896712f, -0.05190670f, -0.17823499f, -0.12247801f, -0.15750287f, -0.29885095f, 
    0.28978428f, 0.09659389f, 0.09334443f, 0.12949921f, -0.05428149f, 0.15607400f, 0.02039278f, -0.06250248f, 
    0.02157684f, -0.13123959f, -0.06951637f, -0.00375390f, -0.08120444f, 0.10264798f, 0.05863088f, -0.03984628f, 
    -0.01131989f, -0.09628299f, 0.02738092f, -0.08761391f, 0.10306913f, 0.04830146f, 0.00717116f, 0.09858663f, 
    -0.05498811f, -0.07781745f, -0.03907405f, -0.14358170f, -0.04938481f, 0.02043584f, -0.06903882f, 0.03832951f, 
    0.07521254f, 0.02687726f, 0.21857031f, -0.05943889f, 0.15025932f, 0.00027384f, 0.15450601f, 0.10914581f, 
    0.20207101f, 0.00303110f, 0.21294867f, -0.20581079f, -0.04449568f, -0.14606422f, -0.15377012f, -0.05864819f, 
    0.02328934f, 0.01157450f, 0.13789047f, -0.06594826f, 0.03835009f, -0.05587675f, 0.10530283f, -0.01213532f, 
    0.00586418f, -0.08656853f, -0.06603643f, 0.15747735f, 0.04304500f, -0.09183245f, 0.23127005f, 0.02809287f, 
    -0.24138021f, -0.06503338f, 0.06884195f, -0.04876189f, 0.12052485f, -0.03467017f, -0.24591498f, -0.09535461f, 
    -0.07865009f, 0.09893746f, 0.01531044f, 0.07484808f, -0.16167727f, -0.14115252f, -0.09827136f, -0.08663359f, 
    -0.08248822f, -0.08508427f, -0.22122516f, -0.07489114f, -0.05124364f, 0.06409346f, -0.06505215f, -0.10242345f, 
    -0.07217869f, -0.00544177f, 0.33359468f, 0.10174525f, 0.13625804f, 0.03325867f, -0.20238528f, 0.10593996f, 
    0.11486421f, 0.10830169f, -0.05877260f, 0.19251423f, -0.04814541f, 0.04568312f, 0.04473132f, -0.05502693f, 
    0.08315394f, 0.07592925f, -0.29306585f, 0.02073470f, -0.01685919f, -0.07135317f, -0.04241960f, -0.13090158f, 
    -0.04015343f, 0.03311617f, 0.09153558f, 0.07200946f, -0.24922393f, 0.18421146f, 0.14932925f, 0.19563505f, 
    0.10215259f, -0.13727826f, -0.15509911f, 0.10388836f, -0.09040482f, -0.01834965f, -0.07931580f, -0.07169841f, 
    0.07554641f, -0.04168843f, 0.00481066f, 0.12410415f, 0.09056353f, -0.05869836f, 0.13255203f, -0.08084331f, 
    0.00559500f, 0.06352261f, 0.07069486f, 0.00883912f, 0.07315243f, 0.13663872f, -0.22911941f, -0.13043916f, 
    -0.11512936f, 0.09993548f, -0.00806078f, -0.00607173f, -0.05370670f, 0.01605527f, 0.05164200f, -0.11191873f, 
    -0.31637764f, 0.31566772f, -0.07588408f, -0.08196507f, 0.11719739f, -0.15591948f, 0.02828691f, 0.05493329f, 
    0.04751486f, 0.04158499f, 0.11919526f, 0.05297539f, 0.10478083f, 0.03837051f, 0.02484180f, 0.15584275f, 
    0.04467999f, -0.10567619f, 0.03858457f, 0.00507145f, -0.10302974f, -0.00855764f, -0.06078389f, -0.05120821f, 
    0.03056179f, -0.08670587f, -0.13640183f, -0.07157306f, 0.02783895f, -0.00334688f, -0.04469669f, 0.06936256f, 
    -0.10927912f, -0.11756997f, 0.02313912f, -0.07778588f, 0.04949563f, -0.05220186f, 0.05048612f, 0.02437127f, 
    0.18254220f, 0.09536506f, 0.11618242f, 0.04838765f, 0.05871891f, 0.15050675f, 0.14339858f, 0.10216175f, 
    0.19399112f, 0.13833153f, 0.15914145f, 0.01641008f, 0.02286834f, 0.11223181f, -0.04820621f, 0.08926632f, 
    -0.05403486f, -0.07871283f, -0.07471120f, -0.03437507f, 0.05005289f, 0.02082643f, 0.07957665f, -0.07365853f, 
    0.08120903f, 0.08917638f, 0.07127284f, 0.02333075f, 0.02476032f, 0.15667242f, 0.04647733f, -0.00437282f, 
    -0.00498507f, -0.01402369f, 0.14215448f, 0.03775451f, 0.11179637f, 0.08475498f, 0.13715233f, -0.00525500f, 
    -0.05516668f, -0.07567991f, 0.04031000f, 0.15108496f, -0.13516180f, -0.01837581f, 0.09075708f, 0.10496525f, 
    0.07897455f, -0.00688517f, 0.12449768f, 0.04421631f, 0.09448099f, -0.06789961f, 0.06986475f, -0.05897708f, 
    -0.05911968f, -0.14886144f, -0.20254925f, -0.01055417f, 0.14145334f, -0.01727933f, 0.00847805f, -0.07745124f, 
    0.05589368f, -0.02473018f, 0.06764422f, 0.02158310f, -0.16298361f, -0.00560689f, 0.12884094f, 0.09265636f, 
    0.04221023f, 0.18733801f, 0.03346663f, 0.04504034f, -0.16950059f, 0.23851453f, -0.02435221f, -0.04893945f, 
    -0.09604340f, 0.04158510f, 0.05768528f, -0.03105546f, 0.11023413f, -0.01321593f, -0.17108206f, -0.10825069f, 
    -0.00579032f, 0.02419800f, 0.10214821f, -0.08740180f, -0.22653830f, -0.24610473f, 0.07539909f, 0.05477633f, 
    0.17131960f, 0.01343139f, 0.01655087f, -0.10515418f, -0.10162512f, -0.11002065f, -0.13239808f, -0.08140599f, 
    -0.30439371f, -0.24877471f, -0.09482647f, -0.03251780f, 0.03979664f, 0.18900615f, -0.05546960f, 0.04170761f, 
    -0.08286791f, 0.08032767f, 0.06733765f, 0.25972039f, -0.06482553f, -0.00428439f, -0.14473823f, -0.07351708f, 
    -0.12874599f, -0.02142388f, -0.06569375f, -0.25118533f, -0.03134657f, -0.03627716f, -0.08337306f, 0.11734234f, 
    0.03897645f, 0.03800314f, 0.13479850f, -0.16766579f, 0.04276177f, -0.10714240f, 0.11810022f, -0.00214257f, 
    0.17307194f, 0.04586493f, 0.14399645f, 0.05205694f, 0.01828059f, -0.05003983f, 0.06209474f, -0.04029064f, 
    0.13931188f, 0.11603054f, -0.01330398f, 0.11326455f, -0.03969455f, 0.05418090f, -0.10633527f, -0.07939091f, 
    -0.12660508f, -0.17261459f, 0.05124794f, 0.13451989f, 0.06824365f, 0.00831157f, 0.18096443f, -0.15282466f, 
    0.01774695f, -0.15283763f, 0.01540383f, 0.06558840f, 0.09776566f, 0.01029137f, 0.02989955f, -0.21071243f, 
    -0.20387803f, -0.21633257f, -0.05756824f, 0.12926583f, -0.16020845f, -0.26126564f, -0.02064768f, -0.04846495f, 
    0.08745649f, 0.07775985f, 0.10949422f, -0.14814544f, -0.02807094f, -0.04424195f, -0.06910267f, -0.09419500f, 
    0.22765322f, 0.49266848f, 0.01902773f, 0.10514433f, -0.01010670f, -0.07024744f, 0.22931565f, 0.11802404f, 
    0.05836618f, 0.04108607f, 0.10825983f, 0.12072659f, 0.05953961f, -0.00625792f, 0.03757782f, 0.05910161f, 
    0.04576023f, 0.08541548f, 0.27241245f, -0.15137929f, -0.22444588f, 0.02295731f, -0.04417413f, 0.01782732f, 
    0.15153043f, -0.01893195f, 0.05913328f, -0.06030430f, 0.14508598f, -0.08371106f, 0.21260372f, 0.14789683f, 
    -0.06410401f, 0.12722015f, 0.08632203f, 0.10588069f, 0.03123609f, 0.04510451f, -0.11192497f, -0.05945218f, 
    -0.02447680f, -0.04119902f, 0.00882667f, 0.15591869f, -0.08583195f, 0.08752365f, 0.10598067f, 0.09709990f, 
    0.10198795f, -0.09389830f, -0.12206732f, 0.12713937f, -0.04822297f, -0.12610801f, 0.11587228f, 0.04516891f, 
    -0.05661257f, -0.00719230f, 0.01608377f, -0.08093137f, -0.04627867f, -0.08724426f, -0.08391641f, 0.08572638f, 
    0.15560697f, -0.10547511f, 0.08991698f, -0.17128377f, 0.04576848f, 0.16572317f, -0.15887411f, -0.19246346f, 
    0.05610115f, 0.03406361f, 0.10892301f, 0.05615184f, 0.17090575f, 0.03721395f, -0.00704607f, 0.17874520f, 
    0.01995585f, -0.02426473f, 0.00589624f, 0.04407086f, -0.03706095f, -0.07265592f, -0.08228742f, -0.02467419f, 
    -0.00808169f, 0.02294783f, -0.13882813f, -0.16622607f, -0.34944406f, 0.04010376f, 0.09923568f, 0.18345840f, 
    -0.01812831f, -0.30466411f, -0.01527258f, 0.00578286f, -0.04937300f, -0.17561735f, -0.08482251f, 0.13094944f, 
    -0.05596363f, -0.07928170f, 0.13535301f, -0.00250832f, 0.20925131f, 0.07100718f, 0.05728032f, 0.16442080f, 
    -0.01935246f, -0.02512359f, 0.04167596f, 0.14171548f, 0.07990228f, 0.06512013f, 0.14163218f, 0.00678227f, 
    -0.07616063f, 0.01606867f, 0.08449417f, -0.12062133f, -0.02198950f, 0.06664363f, -0.12814528f, 0.11572404f, 
    -0.16099204f, -0.09170429f, 0.03073863f, 0.02836489f, 0.12116031f, 0.03906913f, 0.02686690f, 0.04423167f, 
    -0.13205121f, -0.09384163f, 0.01330318f, 0.08623923f, -0.05225084f, 0.14019334f, -0.01429079f, 0.04267516f, 
    0.26894298f, 0.33251005f, 0.25483844f, -0.01604120f, -0.23275870f, -0.09451231f, -0.04502205f, -0.05347174f, 
    0.00863113f, 0.19495738f, -0.02854185f, 0.01805332f, -0.12015308f, -0.01448051f, -0.06867191f, 0.01091773f, 
    0.10944252f, 0.07291314f, -0.46764404f, 0.55081296f, -0.26279217f, -0.02885786f, -0.11803859f, 0.10539295f, 
    -0.03421001f, -0.05167459f, 0.03377716f, -0.22751278f, -0.02659021f, -0.03677895f, 0.05135462f, 0.15375623f, 
    0.06033232f, 0.03798164f, 0.06077220f, 0.11722954f, -0.14641929f, -0.10572457f, -0.01721677f, -0.20954901f, 
    0.00504832f, -0.02499000f, 0.11859349f, 0.02059847f, 0.07591998f, -0.05425726f, 0.13798265f, 0.04498593f, 
    -0.32615903f, 0.02635539f, -0.31587029f, 0.00898218f, 0.01348390f, 0.10140330f, -0.12256911f, -0.13423316f, 
    -0.11575814f, -0.06985285f, 0.06834315f, -0.14282954f, 0.11157670f, -0.01914055f, 0.09213182f, 0.01593417f, 
    0.03060529f, 0.28641763f, 0.08691589f, -0.11230252f, -0.05030429f, 0.04161771f, 0.10390036f, -0.00068978f, 
    0.04213404f, -0.02885276f, 0.07700377f, 0.10923274f, -0.20555444f, 0.09342074f, 0.12972300f, -0.04847488f, 
    0.04775910f, 0.04935255f, 0.06658959f, 0.06499431f, -0.09890758f, -0.03661893f, -0.15571679f, 0.09005890f, 
    0.02849380f, -0.03334522f, -0.64830995f, -0.22083037f, 0.00384162f, 0.08010762f, -0.02738753f, -0.08027221f, 
    -0.07993174f, 0.01544929f, -0.00918069f, 0.00008669f, -0.12428015f, 0.22039056f, -0.02223554f, -0.12060963f, 
    -0.10372967f, 0.04248367f, -0.05915489f, 0.09916677f, 0.12526478f, 0.05720689f, 0.07141848f, 0.03590469f, 
    0.15258268f, 0.05750943f, -0.07177929f, -0.15982667f, -0.19261378f, 0.10238571f, -0.18935154f, 0.12745918f, 
    -0.24062261f, -0.08923594f, -0.15255803f, 0.03210522f, 0.05348625f, -0.05397372f, 0.10088797f, 0.08001256f, 
    0.22281328f, -0.09215005f, 0.04731742f, -0.38113832f, -0.20974088f, -0.04112055f, 0.01715323f, -0.05936554f, 
    -0.00166662f, -0.06034365f, 0.01767027f, -0.00607235f, -0.00769577f, 0.01823194f, 0.05170062f, 0.18496704f, 
    0.07245503f, -0.19424792f, 0.19204485f, -0.08801234f, 0.11286254f, -0.09937946f, -0.04676124f, -0.06008957f, 
    0.03781972f, -0.03251336f, 0.12121326f, 0.00886695f, 0.03512320f, 0.08966725f, 0.03257407f, 0.08350059f, 
    0.06966721f, 0.16994098f, -0.07315949f, 0.07957847f, 0.09698454f, 0.09560753f, -0.04543733f, -0.05463742f, 
    -0.01020832f, -0.07430085f, -0.02065798f, 0.03323754f, -0.24881655f, 0.11535264f, -0.00480631f, -0.05661882f, 
    -0.06369761f, 0.11428489f, 0.03192620f, -0.05509805f, 0.01202270f, -0.07217237f, 0.06345460f, 0.10669494f, 
    0.01086200f, 0.02887391f, 0.12079305f, -0.00034442f, -0.07256289f, 0.24146101f, 0.13285078f, 0.02272363f, 
    0.19383419f, 0.15444154f, -0.02149091f, -0.05956108f, -0.17445144f, -0.07425522f, 0.07379219f, 0.11057509f, 
    0.04584645f, -0.23630227f, -0.05899683f, -0.12765302f, -0.00933868f, -0.07241319f, -0.02896957f, -0.24253477f, 
    -0.00161334f, -0.14009519f, -0.28460884f, -0.12755422f, -0.06120025f, 0.10062014f, -0.02486092f, 0.10446642f, 
    -0.03680084f, -0.04497888f, 0.01609876f, 0.17989820f, 0.08687405f, 0.11971612f, 0.07844459f, -0.02163788f, 
    0.00173231f, -0.09206614f, -0.08800618f, -0.13435915f, 0.02179425f, 0.12272494f, 0.03883483f, 0.11118823f, 
    -0.00971822f, 0.05125268f, 0.11678462f, -0.21013944f, 0.07202930f, 0.08658184f, -0.12085082f, 0.02779583f, 
    -0.10750610f, 0.01979615f, 0.12014528f, -0.19912152f, 0.17286792f, 0.17507459f, 0.12357103f, 0.12381707f, 
    0.05556285f, 0.03861453f, -0.07093844f, -0.22145976f, -0.05612505f, -0.02383167f, -0.04694740f, 0.07202930f, 
    0.10695834f, 0.04433356f, -0.01838448f, 0.05602271f, -0.02567662f, -0.21243642f, 0.09538522f, -0.17259820f, 
    -0.01341489f, 0.10113284f, 0.03176762f, 0.09388988f, 0.10936704f, 0.07254064f, -0.19698113f, -0.01531442f, 
    0.01749813f, -0.17140892f, 0.01092811f, 0.04542902f, -0.00533682f, 0.07966391f, -0.08834951f, -0.01802118f, 
    0.07066638f, 0.15568513f, -0.00420581f, -0.08544526f, -0.02021696f, 0.07094049f, 0.01983597f, -0.07416365f, 
    0.27332482f, 0.23524994f, 0.34564999f, -0.10347981f, -0.11473726f, -0.14686115f, -0.14467914f, -0.02950012f, 
    0.02029414f, -0.03777039f, -0.02420112f, -0.05205627f, 0.00247253f, -0.02956015f, -0.03153082f, 0.07321825f, 
    0.05044545f, -0.01396048f, -0.32777658f, -0.49535501f, 0.06272501f, -0.00772526f, -0.21914347f, -0.26304165f, 
    0.14864978f, 0.11682231f, 0.05182046f, 0.21137467f, 0.09708910f, 0.14715922f, 0.12452018f, 0.04742985f, 
    -0.01052471f, -0.01682238f, 0.00970991f, -0.13213935f, 0.12269423f, 0.17403422f, 0.00772799f, 0.04680671f, 
    0.08260714f, 0.16567592f, 0.00254405f, -0.06287417f, -0.00281714f, 0.27559403f, 0.14812520f, -0.27469027f, 
    0.06596593f, -0.12692331f, 0.10228661f, 0.01300532f, 0.10885815f, 0.04671720f, -0.29562899f, 0.10218188f, 
    0.01072838f, -0.03872231f, 0.00586714f, -0.01191696f, -0.05932758f, 0.02578941f, 0.00440742f, 0.09621839f, 
    -0.04875283f, -0.14809805f, 0.12223200f, 0.17329174f, 0.06320362f, 0.07402998f, 0.00673505f, 0.10125529f, 
    0.06440600f, -0.19257681f, -0.27134266f, 0.06455696f, 0.17143473f, 0.15659925f, 0.13874035f, -0.02924678f, 
    0.02236718f, -0.29600018f, -0.34824094f, -0.48895976f, 0.16531418f, -0.07308000f, 0.04398216f, 0.07779787f, 
    -0.06113902f, 0.12354004f, 0.22178061f, -0.28882572f, 0.03438678f, 0.07759119f, -0.04434773f, -0.17497686f, 
    -0.11958692f, 0.13424763f, -0.19543377f, 0.22829947f, 0.17450063f, 0.19553816f, 0.07194563f, 0.07181080f, 
    0.18709789f, 0.01455968f, -0.01025707f, 0.00874575f, 0.07677253f, 0.36600444f, 0.06894633f, 0.02255159f, 
    -0.05852944f, 0.03903255f, -0.05989057f, 0.08663495f, -0.01875862f, 0.15285100f, 0.19583236f, -0.04508471f, 
    0.08840448f, 0.04318344f, 0.07702474f, -0.05683008f, -0.03863510f, 0.17101055f, 0.32862872f, -0.02311521f, 
    -0.38632149f, 0.07577463f, -0.15783463f, 0.16768926f, 0.03794050f, -0.00363873f, 0.09913757f, -0.07315072f, 
    -0.21151209f, 0.03179693f, 0.24089396f, -0.10058137f, -0.05340775f, 0.02169396f, 0.06728465f, -0.00560739f, 
    0.08257339f, -0.05125675f, -0.13269335f, -0.08089020f, 0.12525930f, 0.01824395f, 0.11806422f, 0.02263918f, 
    0.03167161f, -0.15634504f, -0.01411045f, 0.19380605f, 0.13113150f, -0.11588589f, -0.13975638f, -0.05571293f, 
    -0.09157321f, 0.02053452f, 0.15929800f, 0.08518743f, 0.17839842f, 0.02393660f, -0.04404853f, -0.00832744f, 
    -0.05810844f, 0.02098895f, 0.14235415f, -0.33114976f, -0.27420300f, -0.30618143f, -0.08326732f, 0.19302461f, 
    0.14544389f, 0.06790961f, 0.04895585f, 0.08662482f, 0.08465673f, -0.01660713f, -0.20743118f, -0.03293618f, 
    0.13760509f, -0.08579130f, 0.02846109f, -0.08409379f, 0.04479965f, -0.21982580f, -0.22723953f, -0.06109972f, 
    -0.22073597f, -0.15821950f, -0.12988174f, 0.01881347f, -0.00259801f, 0.08102261f, -0.17556281f, -0.03544239f, 
    -0.19482674f, 0.05346470f, -0.09267543f, -0.03404420f, 0.09030627f, 0.02427505f, 0.08924304f, -0.32699999f, 
    0.17405431f, -0.34295195f, -0.04838584f, -0.00130512f, 0.20712303f, 0.04001140f, 0.06395602f, 0.11839306f, 
    0.11351687f, -0.01853724f, -0.02913662f, 0.03219878f, 0.12419728f, -0.03350494f, -0.02880821f, 0.11760633f, 
    0.14806788f, -0.02982382f, -0.36083853f, 0.07038768f, 0.22465307f, -0.04720888f, -0.00911073f, 0.01425890f, 
    -0.12616330f, 0.07273538f, 0.29936621f, 0.02459899f, 0.02689636f, -0.01059781f, -0.00332625f, 0.03517320f, 
    0.02664482f, 0.05282383f, -0.10847866f, 0.24280298f, 0.06492681f, -0.08944365f, -0.09401198f, -0.01574081f, 
    0.04040693f, -0.07836401f, 0.14573802f, -0.09110443f, 0.13019864f, -0.04941047f, 0.14055252f, 0.05526773f, 
    0.11088037f, -0.02902907f, 0.02927945f, 0.23188464f, 0.06525440f, -0.16091634f, -0.07454434f, 0.20388773f, 
    0.02255594f, -0.11601126f, -0.25857735f, -0.01872861f, 0.09821833f, -0.04184432f, -0.23996961f, -0.16669656f, 
    -0.33599374f, -0.07360336f, -0.16622789f, -0.16250922f, 0.07009173f, 0.02150005f, 0.01489926f, -0.27881268f, 
    -0.24954642f, -0.11597535f, 0.06637283f, -0.14281476f, 0.09773729f, 0.06122640f, 0.03492520f, 0.14757852f, 
    -0.40131658f, -0.32069245f, -0.18957274f, -0.11100791f, -0.15116154f, -0.10715450f, -0.06893391f, -0.01102937f, 
    0.05888099f, 0.26136908f, -0.04873180f, -0.01478360f, -0.05728045f, -0.04083920f, 0.01901842f, -0.04062971f, 
    0.21711922f, 0.18457136f, -0.50447524f, -0.48353636f, -0.42287356f, -0.14873523f, -0.33457944f, -0.09272989f, 
    -0.14500992f, -0.04591298f, -0.04202989f, -0.14744844f, 0.07625552f, 0.09715754f, -0.00557606f, 0.09436937f, 
    -0.08806467f, 0.15293851f, 0.04515854f, -0.00462639f, -0.17898071f, 0.09190176f, 0.29057574f, -0.08295543f, 
    -0.21452035f, -0.04459189f, 0.21505693f, 0.03318100f, 0.00801152f, 0.13506104f, 0.28248233f, 0.21255395f, 
    0.03480124f, -0.03023975f, -0.07379200f, 0.09094664f, 0.03643192f, -0.05067325f, 0.01080243f, -0.07734710f, 
    -0.12203721f, -0.02585779f, -0.29095581f, -0.02188142f, 0.07721408f, 0.05945019f, 0.16825657f, 0.08592321f, 
    0.15044528f, 0.16306752f, 0.07974142f, 0.21459661f, 0.01314938f, 0.16960086f, 0.13212627f, 0.02468820f, 
    -0.04166101f, -0.03427304f, -0.20771267f, -0.08427434f, -0.00039955f, 0.19504863f, 0.03108988f, 0.08645955f, 
    -0.08688238f, -0.19426703f, -0.01472371f, 0.05052743f, -0.18687457f, 0.08860750f, 0.22481579f, -0.03307255f, 
    0.10199396f, -0.05078448f, 0.48125944f, 0.26204884f, 0.17689098f, 0.17022364f, 0.01783556f, -0.20082545f, 
    -0.01491286f, 0.02860747f, 0.10363537f, -0.04950518f, 0.03282005f, -0.01440476f, -0.06295813f, -0.06580003f, 
    -0.18109363f, 0.04780225f, 0.05408753f, -0.07735893f, -0.35271198f, 0.10473365f, 0.05934360f, -0.07804321f, 
    -0.05998430f, -0.00541390f, -0.12583682f, -0.02820493f, 0.03684860f, -0.11105153f, 0.13706173f, 0.11787719f, 
    -0.06692988f, 0.04479342f, -0.03527967f, 0.13757420f, 0.01519030f, 0.02933646f, -0.05606437f, 0.43405399f, 
    0.22610445f, 0.02581252f, -0.04124406f, 0.16231377f, 0.13179852f, -0.02653935f, 0.01079368f, -0.12175884f, 
    -0.01356535f, -0.13528332f, -0.09252730f, -0.08667245f, -0.14052400f, -0.03945990f, -0.01394034f, -0.12126952f, 
    -0.06782003f, -0.17769809f, -0.33810353f, -0.34310982f, -0.04116646f, 0.08061239f, -0.02066487f, -0.05817814f, 
    0.10399311f, 0.04676418f, 0.07685445f, 0.08135402f, 0.13105558f, 0.05791248f, -0.08648123f, 0.12762064f, 
    -0.02262842f, 0.10122609f, -0.39039046f, 0.02034928f, 0.00864429f, -0.01749060f, -0.01659139f, -0.04463049f, 
    0.01494564f, 0.19123574f, 0.15440191f, 0.07154698f, -0.09130351f, -0.23124050f, -0.08729795f, -0.09056591f, 
    -0.03278763f, -0.07207826f, -0.15739553f, 0.06987761f, -0.17902419f, -0.13127267f, -0.19631518f, -0.14582741f, 
    -0.14422126f, -0.08073799f, 0.02952237f, -0.03408350f, -0.10780694f, -0.26293722f, 0.17438537f, -0.28247368f, 
    -0.14652897f, -0.33705056f, 0.01298517f, 0.00531017f, 0.15222345f, 0.14949568f, -0.27403674f, -0.00269179f, 
    -0.20489484f, -0.40851548f, -0.35464713f, -0.04485779f, -0.10413459f, -0.08613890f, 0.05046890f, -0.06702189f, 
    -0.41682121f, -0.27903134f, -0.05344986f, 0.00226009f, 0.00373794f, 0.31225553f, -0.09682297f, -0.01400553f, 
    0.11618856f, 0.05077192f, 0.06293873f, 0.06579392f, 0.01996893f, 0.06833532f, 0.20491430f, 0.07336587f, 
    0.11275751f, -0.24146779f, 0.15463389f, 0.12489646f, -0.25998381f, -0.19651298f, -0.17300111f, 0.01003942f, 
    -0.04859379f, -0.03635177f, 0.16342154f, 0.29325974f, -0.06382708f, -0.17039110f, -0.09566686f, -0.10050354f, 
    0.09342889f, -0.11060230f, -0.07105695f, -0.06228883f, -0.46524957f, -0.09299120f, 0.12040858f, -0.05343187f, 
    -0.17051728f, -0.05806316f, -0.05411952f, 0.12565728f, 0.10909069f, 0.10701699f, -0.06081946f, -0.01921231f, 
    0.10262387f, 0.05956052f, 0.15446588f, 0.16399477f, 0.08635134f, -0.19936572f, 0.10830074f, 0.08172350f, 
    0.11707582f, 0.08309437f, -0.14592099f, 0.22048861f, -0.02739515f, 0.21366461f, -0.08307829f, -0.12536481f, 
    0.15924047f, 0.01584112f, -0.17387182f, 0.05971404f, -0.03993214f, 0.11875883f, 0.13740803f, -0.11341773f, 
    -0.00040610f, 0.09026020f, 0.07582596f, 0.23365061f, 0.02252542f, 0.16344106f, 0.08569328f, 0.11710665f, 
    0.09800476f, 0.03931028f, 0.00686588f, 0.19744694f, 0.10984570f, 0.02232112f, -0.03690100f, -0.09868973f, 
    -0.23414342f, 0.03082465f, 0.13644548f, -0.14805919f, 0.01536859f, 0.02493576f, 0.10964264f, -0.05605333f, 
    0.05935055f, -0.01677420f, 0.08452124f, 0.19691376f, -0.25314310f, -0.05657520f, -0.19809027f, -0.09088708f, 
    0.05007773f, 0.00115203f, 0.07813188f, 0.00301843f, 0.08336118f, 0.19142359f, 0.04644176f, 0.00923881f, 
    -0.05328804f, -0.06885910f, 0.05039011f, -0.09294322f, 0.03710345f, -0.13113715f, 0.22491467f, 0.01896739f, 
    0.10716215f, 0.08007182f, -0.03277701f, -0.04417823f, 0.03770907f, 0.04250828f, -0.21198088f, -0.03600596f, 
    0.01367999f, 0.06827156f, 0.02453603f, 0.14377576f, 0.03240553f, 0.17523365f, 0.33377627f, 0.06699318f, 
    0.05424298f, -0.00536030f, -0.03984970f, 0.13060039f, 0.01555663f, 0.06372869f, -0.08092634f, 0.05503773f, 
    -0.00645119f, 0.20015879f, 0.06063548f, 0.15024500f, 0.03612445f, 0.00509990f, 0.22310096f, -0.08382673f, 
    0.02312218f, -0.06084277f, -0.26540405f, -0.01717100f, 0.00018967f, 0.13519041f, -0.08272249f, -0.19117962f, 
    -0.22205536f, -0.04372215f, -0.14438073f, 0.02562265f, 0.05143930f, 0.03706953f, 0.14181226f, -0.08867364f, 
    -0.09010263f, -0.13450749f, -0.14868222f, 0.19397058f, -0.19248554f, 0.12925343f, 0.16316468f, -0.03372355f, 
    0.07580591f, 0.04932850f, -0.10472953f, 0.17091997f, -0.00148511f, 0.19045372f, 0.09219690f, 0.13992611f, 
    0.10741356f, -0.14217843f, -0.04749081f, 0.03170829f, 0.06979544f, -0.08071858f, 0.08295177f, -0.06233327f, 
    0.05770655f, -0.02915836f, -0.06789353f, -0.04721880f, -0.36256552f, 0.04278667f, -0.04135534f, 0.12065309f, 
    0.03755808f, 0.03196732f, 0.07939185f, 0.05786200f, 0.07694711f, -0.04406141f, -0.10989677f, -0.09860548f, 
    0.01636442f, 0.03841573f, 0.14698218f, 0.11493717f, 0.16868098f, 0.04909131f, 0.24007630f, -0.05082706f, 
    0.06438953f, -0.16025774f, 0.06577695f, 0.15412509f, 0.06222491f, 0.04008275f, 0.03277616f, 0.07441445f, 
    0.21701172f, -0.07516962f, -0.08920045f, 0.07171790f, 0.17121139f, -0.02824595f, -0.06399662f, -0.02433285f, 
    0.05254176f, 0.10424042f, 0.08151279f, -0.09512262f, 0.06079546f, 0.03177634f, -0.01073877f, 0.06885457f, 
    0.03690059f, 0.01533348f, 0.05306677f, 0.01753123f, -0.02699138f, 0.14964794f, 0.09890029f, 0.03665718f, 
    0.11881267f, 0.06741917f, -0.12919028f, -0.15254480f, -0.06262331f, -0.12381461f, 0.09695717f, -0.09344375f, 
    0.08396938f, 0.19044730f, -0.00173098f, -0.07658538f, -0.03952984f, 0.04330599f, -0.14357100f, -0.10533362f, 
    -0.01615510f, 0.06343506f, -0.10764971f, -0.15736236f, -0.38858092f, 0.28216818f, 0.28999183f, -0.07683706f, 
    -0.05447356f, -0.13995066f, -0.17477824f, -0.06104815f, 0.06724663f, 0.03139087f, -0.09527891f, -0.07235774f, 
    -0.09092213f, 0.01272414f, 0.09323688f, 0.02844174f, 0.02933484f, -0.18773504f, -0.09802308f, 0.04543723f, 
    0.34355098f, -0.29149446f, 0.06860937f, 0.13384648f, 0.08395447f, -0.09377395f, 0.12494981f, 0.07636047f, 
    -0.03007272f, -0.01164450f, -0.13587968f, -0.08264358f, -0.05513553f, -0.07612091f, -0.03121869f, -0.17033327f, 
    -0.20262048f, 0.24861389f, 0.09628860f, -0.12267976f, 0.01658391f, -0.04991714f, -0.02470292f, -0.04065909f, 
    -0.03948927f, 0.06587868f, -0.22195908f, 0.18968825f, 0.24692985f, -0.02185886f, 0.12366939f, 0.15868334f, 
    0.14892662f, 0.16119416f, 0.24110268f, -0.04962483f, 0.05833042f, -0.04676505f, -0.01508202f, -0.10126957f, 
    -0.16373958f, -0.04484048f, -0.21762507f, -0.38004866f, 0.11513451f, -0.02676108f, -0.16978231f, 0.11549130f, 
    -0.00328176f, -0.07496750f, 0.02400668f, 0.13739695f, -0.15284432f, 0.14643140f, 0.27022254f, -0.33422783f, 
    -0.00712487f, -0.05565870f, -0.04400929f, 0.07984656f, -0.01959315f, 0.08313783f, -0.00018988f, 0.22229426f, 
    -0.06442568f, 0.13144648f, -0.14324041f, -0.01647391f, 0.13923942f, 0.05051377f, 0.02412011f, 0.00064193f, 
    -0.08648263f, 0.03396563f, -0.01414990f, 0.11348552f, 0.07826198f, -0.18458423f, -0.10557588f, -0.22158058f, 
    -0.18376380f, -0.16954681f, 0.11876784f, -0.10917936f, -0.08655792f, -0.12985651f, -0.13699417f, 0.02872127f, 
    -0.11081355f, 0.02188675f, -0.09852908f, -0.03678005f, -0.05890983f, -0.08064388f, -0.15121932f, 0.20419900f, 
    0.05126853f, 0.18068545f, -0.18769290f, -0.08277421f, -0.29578689f, -0.23780416f, 0.02130266f, -0.12975387f, 
    -0.24107811f, -0.02201536f, -0.26223108f, -0.15229400f, 0.16269174f, 0.25084692f, -0.05154705f, 0.00798301f, 
    -0.04905583f, 0.14521728f, 0.04386772f, 0.10275131f, -0.34949028f, 0.10325769f, 0.32393214f, -0.01244819f, 
    -0.06142705f, 0.07222631f, 0.11455335f, 0.04400627f, 0.15360066f, -0.12597144f, -0.00332370f, 0.09171369f, 
    0.02801532f, 0.23479718f, -0.19257057f, 0.11248747f, 0.01968554f, -0.01959885f, -0.14146236f, 0.03830687f, 
    0.51118726f, 0.07478271f, -0.01292529f, -0.12588383f, -0.00274604f, 0.00621968f, 0.07553311f, -0.21336597f, 
    0.13733201f, 0.18644807f, 0.03085246f, 0.10043073f, 0.06871182f, 0.13355267f, 0.05093898f, -0.02679789f, 
    0.12754469f, -0.16988821f, -0.04506818f, -0.18157801f, 0.02078489f, -0.05908585f, 0.11681177f, 0.14448039f, 
    0.06456659f, -0.18740101f, 0.02394264f, -0.04441821f, -0.08195710f, 0.05648005f, 0.06513035f, 0.01905296f, 
    -0.04548017f, 0.06101788f, 0.03503346f, -0.30123112f, 0.15599896f, -0.00554217f, -0.07831272f, -0.25103989f, 
    -0.00616349f, -0.00462195f, 0.14964329f, -0.13681222f, -0.00549490f, 0.12896664f, -0.07380912f, -0.05945216f, 
    -0.05594561f, -0.00365908f, -0.03953833f, -0.08905824f, -0.23727268f, -0.36392495f, -0.02173028f, -0.10192467f, 
    -0.01145445f, -0.11334599f, -0.03824769f, -0.15115333f, -0.03472191f, -0.24421549f, -0.06771046f, 0.12893881f, 
    -0.02985091f, -0.02735342f, -0.01594163f, 0.11610901f, -0.16249515f, -0.00538478f, -0.50426084f, 0.31746992f, 
    -0.06566535f, -0.03405722f, 0.16406664f, 0.01856774f, 0.01492295f, 0.13317844f, 0.05193070f, 0.06390826f, 
    -0.26886421f, 0.05425279f, -0.20152044f, -0.06769448f, -0.18934803f, -0.08840487f, 0.05009120f, -0.24207164f, 
    -0.21769659f, 0.09545447f, 0.34134349f, -0.04618060f, 0.06386055f, -0.14682569f, -0.00653004f, 0.08292447f, 
    0.36975229f, 0.06536224f, 0.05916286f, 0.25152516f, 0.01091393f, 0.02666306f, 0.18916921f, 0.02304279f, 
    0.06180165f, 0.33199090f, -0.06901109f, 0.02125625f, 0.36962664f, -0.15228552f, -0.06381702f, -0.00743527f, 
    -0.03433644f, -0.11817779f, 0.09077798f, -0.04214127f, 0.01078430f, 0.28369975f, -0.15081246f, -0.16157518f, 
    -0.04768497f, -0.11175274f, -0.19998592f, 0.32093486f, 0.02614561f, -0.02676899f, -0.11086135f, -0.12345476f, 
    0.11322622f, -0.03531551f, 0.05540740f, 0.08459171f, -0.03795013f, -0.05048957f, 0.05360993f, -0.09705252f, 
    -0.10586013f, -0.08729815f, -0.18325838f, -0.02261439f, 0.11913291f, 0.05347737f, -0.04128012f, -0.23752043f, 
    0.08256117f, -0.02850099f, -0.10108662f, -0.10162572f, 0.02262946f, 0.07181934f, 0.07930943f, -0.21047752f, 
    -0.22507480f, 0.17278969f, 0.07100829f, 0.08017273f, -0.25295776f, -0.01942079f, -0.14930010f, 0.16204923f, 
    -0.06082962f, -0.11660428f, -0.13236474f, 0.03142777f, 0.09954932f, 0.04023463f, 0.06561062f, 0.08341867f, 
    0.09672185f, 0.04075907f, 0.14917956f, 0.25779900f, -0.26402691f, -0.09530882f, 0.09096907f, -0.14415349f, 
    -0.00570304f, 0.11045875f, -0.01678487f, 0.28339353f, -0.05361430f, -0.00478984f, -0.05911976f, 0.04423226f, 
    -0.02469825f, 0.13435633f, 0.09757237f, -0.01908148f, -0.20402779f, 0.02485970f, -0.05513261f, 0.06054628f, 
    0.04126599f, -0.03962865f, 0.02456388f, -0.06165210f, -0.02935094f, -0.08674089f, 0.26728046f, -0.09312009f, 
    -0.12000366f, 0.02207270f, -0.05311745f, 0.08542641f, 0.03365876f, -0.04740195f, 0.00785096f, 0.12420619f, 
    -0.05888886f, -0.15593500f, -0.20642832f, 0.02085956f, 0.05085293f, 0.31958431f, 0.77420282f, -0.16735002f, 
    -0.01875011f, -0.07041296f, 0.04864131f, 0.08804123f, 0.04788420f, 0.03114231f, 0.08343256f, -0.07622228f, 
    0.12994169f, 0.21556672f, 0.04000188f, 0.25249940f, 0.08169411f, 0.02578853f, 0.04378942f, 0.00356095f, 
    -0.12522091f, -0.18217178f, 0.08129452f, -0.03203781f, 0.01229203f, 0.10247038f, -0.05382208f, -0.02328513f, 
    0.01011135f, 0.02803081f, -0.08725817f, 0.09059443f, 0.00065488f, 0.02327243f, 0.04451533f, -0.03167974f, 
    -0.04839683f, -0.07659607f, 0.21270609f, 0.01607643f, 0.06736880f, 0.06043226f, 0.05249913f, 0.00576796f, 
    -0.10706898f, -0.06615631f, 0.03871645f, 0.05464838f, 0.02480616f, 0.00055587f, 0.01711700f, 0.11063074f, 
    -0.09343847f, 0.04061791f, 0.03176443f, 0.02697308f, -0.09249373f, -0.10703951f, 0.02933280f, 0.13540114f, 
    0.03832183f, 0.10070604f, 0.00261495f, -0.08215172f, -0.03511742f, -0.17715068f, -0.02973322f, -0.03755343f, 
    0.05803301f, 0.07722485f, -0.01589058f, -0.15338737f, -0.10692088f, -0.19598135f, -0.04398606f, 0.14346105f, 
    0.04521294f, 0.15028311f, 0.04374463f, 0.02691967f, 0.09859640f, 0.14646433f, -0.01658204f, -0.00681867f, 
    0.06491259f, -0.07734860f, -0.07644294f, 0.01580980f, -0.01264470f, 0.03235631f, -0.03352146f, -0.15718201f, 
    0.06370348f, 0.10638423f, 0.06250800f, 0.02777818f, -0.00290299f, 0.06053152f, 0.10690784f, -0.01897429f, 
    0.02121614f, -0.02113445f, 0.05871800f, 0.03254053f, -0.02361662f, -0.01701049f, -0.12468753f, 0.06901477f, 
    -0.09875149f, -0.08322503f, 0.23914641f, -0.06729714f, 0.16368176f, -0.18288137f, 0.05576798f, 0.10318766f, 
    0.14952958f, -0.02415361f, -0.17916542f, -0.22650906f, -0.07187163f, 0.00448197f, -0.06868047f, 0.05658025f, 
    0.00680878f, -0.03004499f, -0.02494305f, -0.08642548f, 0.06063019f, 0.05051043f, -0.21583785f, -0.03825623f, 
    -0.06416003f, 0.03538591f, 0.13111416f, 0.00164061f, 0.04249052f, -0.05445490f, 0.16887309f, 0.10067790f, 
    -0.08635637f, 0.02523241f, 0.13605595f, 0.00378383f, -0.09527075f, 0.01332134f, -0.08281819f, -0.14902487f, 
    0.03449703f, 0.14350706f, -0.10884581f, -0.06083130f, -0.27006871f, -0.12923618f, -0.12019650f, 0.04429349f, 
    0.06224477f, 0.05546470f, -0.03159648f, 0.01184070f, -0.06956728f, 0.05019598f, -0.14920543f, -0.05012745f, 
    -0.22919382f, 0.09104349f, 0.12509564f, -0.10917379f, 0.19856954f, 0.05481804f, -0.13580380f, 0.03111824f, 
    -0.00086569f, 0.10349274f, 0.16234781f, 0.15344033f, 0.00936147f, 0.09132577f, -0.03116336f, -0.04397193f, 
    -0.04136770f, -0.00793597f, -0.18105771f, 0.02020621f, 0.14864737f, -0.12193687f, 0.15400076f, -0.00975230f, 
    -0.04338955f, 0.06941838f, -0.02253130f, 0.06007631f, -0.15848166f, -0.00025059f, 0.14664708f, 0.01590750f, 
    0.11298949f, -0.03366436f, 0.13764364f, -0.16663210f, 0.02024401f, 0.07541921f, 0.08357976f, -0.02938531f, 
    0.03300664f, -0.02404699f, -0.03112528f, -0.04262060f, 0.06692743f, -0.13990034f, 0.09521135f, 0.15638064f, 
    -0.00353723f, 0.11866526f, 0.15817077f, -0.05958860f, 0.02989815f, 0.16256854f, -0.13670678f, 0.11988503f, 
    -0.01127783f, -0.01838087f, -0.00260286f, 0.00520837f, -0.02234351f, -0.16673397f, -0.26724422f, -0.28897351f, 
    -0.21712838f, 0.15303697f, -0.03779314f, -0.01831996f, -0.07134905f, 0.15374196f, -0.07953200f, 0.01954629f, 
    0.15448728f, 0.03276331f, 0.11751471f, 0.10291851f, 0.09159531f, -0.00218942f, 0.05157812f, 0.06121718f, 
    0.05679221f, 0.01761697f, 0.19794713f, 0.18445794f, 0.00835605f, 0.02800731f, -0.00910471f, -0.03475238f, 
    -0.03360058f, -0.10068627f, -0.00245150f, 0.03385741f, 0.01951714f, 0.09843519f, -0.03957982f, -0.17127086f, 
    -0.08471241f, -0.01735422f, -0.16977598f, 0.16235805f, -0.11242680f, -0.04816488f, 0.14889356f, 0.07122920f, 
    0.04391444f, 0.00522687f, -0.06530489f, 0.16028042f, 0.04831188f, 0.22652033f, 0.18772499f, 0.08830608f, 
    -0.06208446f, 0.06817766f, -0.24912141f, 0.29838693f, 0.06240020f, 0.12612309f, -0.05208863f, 0.19509834f, 
    -0.00539022f, 0.18365052f, -0.03449342f, 0.11012895f, -0.02387016f, 0.01970234f, 0.09573474f, 0.13222054f, 
    0.13755666f, 0.13347150f, 0.15645733f, 0.04112998f, -0.18362527f, 0.19425659f, 0.00706959f, 0.11022467f, 
    0.04421886f, 0.06077209f, 0.03992607f, 0.06359821f, -0.04941385f, 0.06484293f, -0.03627928f, -0.07203538f, 
    -0.27468953f, 0.03289182f, 0.19474815f, -0.11276560f, -0.12611601f, -0.24093232f, 0.00436032f, 0.04633212f, 
    0.14261833f, -0.00249382f, -0.13155790f, 0.24989428f, 0.06383567f, -0.04392415f, 0.02024347f, -0.03684593f, 
    -0.02813074f, 0.08313903f, -0.31158271f, 0.25088558f, -0.11733333f, -0.16278426f, -0.09961717f, -0.11047425f, 
    0.10207740f, -0.05863785f, 0.00048398f, 0.06097586f, 0.17908604f, -0.01501856f, -0.14914486f, 0.01958446f, 
    0.05677250f, 0.08150564f, -0.02901530f, -0.08367748f, 0.10835255f, 0.04317809f, 0.30181113f, 0.01578044f, 
    0.04306378f, -0.26030511f, 0.03965248f, 0.06735174f, -0.09042020f, -0.13385786f, -0.17917839f, -0.15985368f, 
    0.07646506f, 0.18406224f, -0.28125939f, -0.08490479f, -0.06982432f, 0.02973990f, -0.20347218f, 0.28053492f, 
    0.24729708f, -0.00000318f, 0.14118800f, -0.16408153f, 0.06546031f, -0.01051306f, 0.08003592f, -0.11122947f, 
    -0.02311667f, -0.32428908f, 0.02837603f, 0.00274763f, 0.03930222f, 0.09682636f, -0.05530325f, -0.08678746f, 
    0.07214771f, 0.02146562f, 0.12017647f, -0.08693805f, -0.10371580f, -0.02858017f, -0.05034117f, -0.11504221f, 
    -0.03248860f, -0.04949304f, -0.14371516f, -0.17076200f, 0.00381157f, 0.07047919f, -0.02864193f, 0.00144390f, 
    -0.08633833f, -0.05593035f, -0.72408456f, 0.31500909f, 0.19514255f, -0.04943189f, -0.39874122f, 0.15048558f, 
    0.05971774f, 0.01846015f, 0.22148079f, 0.05598222f, -0.17539838f, 0.02977385f, -0.05784710f, -0.04231428f, 
    -0.18974882f, -0.02389486f, -0.01619129f, 0.08345573f, -0.31315136f, -0.08885568f, -0.07112841f, 0.03135645f, 
    -0.05544309f, -0.15658142f, 0.17249490f, 0.06818508f, 0.02648394f, -0.09387662f, -0.42706198f, 0.16791722f, 
    -0.14855121f, 0.11870153f, 0.03945553f, -0.01032182f, 0.04754265f, -0.04143810f, 0.14613850f, -0.39184099f, 
    -0.16266635f, -0.02093623f, 0.10969513f, -0.07943006f, 0.02082767f, 0.06984676f, 0.12038999f, -0.11161458f, 
    0.03878817f, 0.02178857f, -0.04991288f, -0.09689087f, -0.07820702f, -0.00926634f, -0.00295870f, 0.08195893f, 
    0.01012689f, 0.05543773f, 0.22587490f, -0.06782522f, 0.26204714f, -0.20240507f, 0.02604890f, 0.14005859f, 
    -0.07024396f, 0.00689062f, 0.25978199f, 0.27365708f, -0.10996693f, 0.04452839f, -0.11161614f, -0.06842307f, 
    0.21383747f, 0.12696421f, 0.10394844f, 0.15928444f, 0.18073393f, 0.03240768f, -0.07018974f, -0.11519825f, 
    0.09641381f, 0.10063373f, 0.17212687f, 0.02653973f, -0.05983090f, 0.51380730f, -0.02744936f, -0.00917914f, 
    0.01865525f, -0.06705883f, 0.08279014f, 0.02486678f, 0.06155945f, 0.05286137f, 0.05173516f, -0.10553136f, 
    0.02104687f, 0.01682466f, 0.17757607f, -0.05684922f, -0.06678426f, -0.00688837f, 0.20530160f, 0.14039706f, 
    -0.13896033f, 0.04642082f, -0.07315288f, 0.08862958f, 0.09157315f, 0.02162960f, -0.08059029f, -0.01584329f, 
    0.00406988f, -0.04118109f, -0.02825229f, -0.07119573f, 0.02873322f, -0.05502632f, -0.03214892f, -0.13367340f, 
    -0.33598998f, 0.53734165f, -0.20969853f, 0.04578757f, -0.21999943f, -0.09069197f, 0.02326071f, 0.01132367f, 
    -0.02214833f, 0.05773733f, 0.12809068f, -0.01429852f, -0.01684538f, 0.00727536f, 0.03870917f, 0.08005918f, 
    0.03452010f, 0.16236016f, 0.25704721f, -0.03338916f, -0.11271522f, 0.04335092f, -0.14812145f, -0.06057386f, 
    0.08300040f, -0.01069491f, 0.33161753f, -0.40384471f, -0.41450745f, 0.07485474f, -0.00218095f, 0.20396444f, 
    -0.02321670f, -0.11865084f, -0.06458507f, -0.18919833f, -0.00823791f, -0.05391768f, 0.06404521f, 0.04178406f, 
    0.04736720f, 0.05656442f, 0.06479601f, 0.12238316f, -0.39457744f, 0.26204017f, 0.31122726f, 0.03911924f, 
    0.07391423f, -0.00870542f, 0.02122851f, 0.00835750f, -0.00441222f, -0.25511265f, 0.29375976f, 0.34165302f, 
    -0.05776705f, -0.20828249f, -0.16102335f, -0.03879447f, 0.10732362f, 0.13942091f, -0.25914094f, -0.10869849f, 
    0.28502893f, 0.13381590f, 0.11661875f, 0.02445691f, -0.00545182f, 0.00323680f, -0.01015763f, -0.08033503f, 
    -0.06130843f, -0.07298654f, 0.08406164f, 0.04404433f, 0.09036547f, 0.06452725f, 0.05589511f, 0.01982628f, 
    0.05566825f, 0.01382257f, -0.01298641f, -0.01927525f, -0.02029929f, 0.03416485f, 0.02903828f, -0.01558069f, 
    -0.06114924f, 0.04446965f, 0.04371922f, -0.03942768f, -0.03084299f, -0.03997016f, -0.04029963f, -0.04618493f, 
    -0.02518753f, -0.03404751f, 0.04863592f, -0.00011814f, 0.01769807f, 0.01596387f, -0.00555496f, 0.00843220f, 
    -0.01970646f, 0.04701585f, 0.04158328f, -0.01341582f, -0.01692392f, -0.01555492f, -0.04248662f, -0.04689685f, 
    -0.00067402f, -0.05607416f, -0.03391929f, 0.00464406f, -0.04778146f, -0.02262846f, -0.03206080f, 0.01099166f, 
    -0.06433851f, -0.00714691f, 0.01148504f, 0.01597133f, 0.04311067f, 0.00726536f, 0.03876361f, -0.04385135f, 
    0.04791835f, -0.02567117f, 0.01612964f, -0.06830126f, -0.05636382f, -0.03671678f, -0.06146015f, 0.04197589f, 
    -0.03533592f, 0.03102332f, -0.03162355f, 0.01818013f, -0.01243613f, -0.04435340f, -0.00333782f, -0.04338027f, 
    0.04154331f, -0.06122702f, -0.06597235f, 0.00646416f, 0.00108755f, -0.02498470f, -0.05683784f, -0.04630063f, 
    -0.01547260f, 0.00397873f, -0.00596498f, 0.02666087f, 0.02955709f, 0.02481172f, -0.05758826f, -0.01631807f, 
    -0.03393137f, 0.00617578f, -0.00263358f, -0.04154878f, 0.00937777f, -0.03297498f, 0.02676118f, 0.01620702f, 
    -0.04458954f, -0.01032969f, 0.04874692f, -0.06311935f, 0.02535019f, -0.05208895f, -0.04691034f, -0.00765823f, 
    -0.00775441f, -0.05653943f, 0.03415349f, 0.01786098f, 0.04743615f, -0.00913394f, 0.01550182f, -0.06027896f, 
    -0.04989768f, -0.00248162f, -0.05443861f, 0.00637463f, 0.00200736f, 0.01293634f, 0.01879517f, 0.02389559f, 
    -0.03369587f, -0.04293192f, 0.04351379f, -0.00847318f, 0.01175097f, 0.03509662f, 0.04120645f, -0.04341000f, 
    0.03097387f, 0.03614100f, -0.01148114f, -0.01501899f, 0.04312003f, -0.02575623f, -0.03165122f, 0.00168580f, 
    0.01472925f, 0.02273012f, 0.01091005f, -0.03898625f, 0.00357624f, -0.05843842f, 0.02457253f, 0.03031482f, 
    0.04972309f, 0.01952837f, 0.02342921f, -0.04426348f, -0.05624180f, 0.00959370f, 0.03617873f, 0.00323707f, 
    -0.01800959f, 0.03914663f, 0.01595112f, 0.01024365f, 0.03809048f, 0.02024777f, 0.01813310f, -0.06455614f, 
    -0.06012729f, 0.03364570f, -0.02508200f, -0.00257042f, -0.02030116f, -0.04314304f, -0.04511484f, -0.04453119f, 
    -0.05392684f, 0.00240059f, -0.04812294f, 0.03670396f, -0.03073507f, -0.04516272f, -0.01616639f, 0.02257944f, 
    -0.00669435f, -0.03770187f, 0.01019352f, 0.02136930f, 0.01069222f, 0.03404594f, 0.01995633f, -0.04200101f, 
    -0.01021386f, -0.05277837f, 0.04217840f, 0.00202946f, 0.02691677f, -0.03761398f, -0.01666338f, -0.02548591f, 
    0.03885263f, 0.03437416f, 0.04839491f, 0.05718456f, -0.05050062f, -0.00066453f, -0.00915803f, -0.06036749f, 
    0.04412119f, 0.04589576f, -0.01429774f, 0.02112318f, -0.04327661f, 0.02414776f, -0.02916223f, -0.03297370f, 
    -0.02369314f, -0.06477035f, 0.04911273f, -0.02956538f, 0.00033820f, 0.01464857f, 0.00767946f, 0.05328326f, 
    0.00732487f, 0.00262198f, -0.05428238f, 0.01043030f, 0.01235867f, 0.03703139f, 0.01142338f, 0.02124622f, 
    0.05055858f, -0.03300905f, 0.01173444f, 0.00513157f, 0.01368250f, -0.03013452f, 0.02682144f, -0.06026275f, 
    -0.03574904f, 0.00259949f, -0.06134982f, -0.03204452f, 0.04767051f, 0.00117295f, -0.01427092f, 0.01908113f, 
    0.03578565f, -0.01432440f, 0.05114146f, -0.01351415f, 0.00417441f, -0.01077471f, -0.03574786f, -0.01731340f, 
    0.01272922f, 0.02703752f, -0.04759460f, 0.00477962f, -0.04418397f, -0.05357311f, 0.04224864f, -0.01607684f, 
    0.01463832f, 0.01111913f, 0.03784647f, -0.04651928f, -0.05684270f, 0.04752231f, -0.03201651f, -0.03555417f, 
    -0.04643421f, -0.02371559f, 0.03824123f, -0.05666768f, 0.01322504f, -0.02985048f, 0.00626789f, 0.04220068f, 
    0.00812876f, 0.00007089f, 0.01305510f, -0.01617998f, 0.03568999f, 0.04945881f, 0.03770457f, -0.03878843f, 
    -0.01519425f, 0.00282247f, 0.04250731f, -0.02312760f, 0.00992722f, -0.02089739f, -0.05790387f, -0.01339363f, 
    0.02813041f, -0.06701099f, -0.03805051f, -0.00595948f, -0.06265099f, 0.00179002f, -0.01409544f, -0.00434541f, 
    0.23473662f, -0.07445147f, -0.10631797f, -0.00885890f, 0.13313590f, 0.14057568f, -0.03828540f, -0.00977051f, 
    -0.33613089f, -0.14452508f, -0.04460344f, 0.01293518f, 0.00926967f, -0.01882583f, 0.07160503f, 0.11063808f, 
    -0.04479653f, 0.02943805f, -0.01834745f, 0.00014972f, 0.13443568f, -0.43548054f, 0.21809581f, 0.05906913f, 
    0.00005929f, 0.01930492f, -0.08504380f, 0.07085125f, 0.00701566f, -0.02527495f, -0.06428968f, -0.02750964f, 
    -0.20177202f, 0.00064558f, 0.02879225f, 0.01421102f, 0.12190579f, -0.01188299f, -0.09876733f, 0.05613474f, 
    -0.10005762f, 0.02481255f, 0.02785522f, 0.13104071f, 0.07551499f, -0.03312450f, 0.23165940f, -0.27075246f, 
    0.00632439f, 0.16394381f, 0.02917841f, -0.06368245f, 0.05351282f, 0.03052516f, 0.40498465f, 0.24096230f, 
    0.10082442f, 0.00408145f, 0.16639674f, -0.10036136f, 0.07668771f, 0.00191058f, 0.18027490f, 0.09137539f, 
    -0.13592784f, 0.11329620f, 0.11962438f, 0.08514690f, 0.01254191f, -0.02820296f, 0.16593610f, -0.10567063f, 
    -0.03850540f, 0.13847339f, 0.00207715f, 0.05807675f, -0.18322591f, -0.04683391f, -0.07225421f, 0.04797626f, 
    0.03525091f, -0.02714804f, -0.10715090f, 0.18452531f, 0.08626244f, 0.08804121f, 0.07863224f, -0.05721907f, 
    -0.08182669f, -0.12824522f, -0.12956238f, -0.19872835f, 0.08509661f, -0.05626634f, -0.15131295f, 0.02233674f, 
    0.03961426f, 0.07645162f, -0.00167465f, 0.08627855f, -0.11103862f, -0.00672324f, 0.08713626f, 0.05873381f, 
    0.01421865f, -0.01889667f, 0.03001259f, -0.06026111f, -0.08684812f, -0.10481913f, 0.02576792f, 0.00015770f, 
    0.03821904f, 0.03545889f, 0.05030907f, -0.15667564f, -0.23471446f, 0.04122961f, -0.13571925f, -0.08401436f, 
    0.12253803f, 0.05934948f, -0.03081540f, 0.03316289f, 0.18471801f, -0.01958271f, -0.35125205f, 0.01619316f, 
    -0.00607243f, 0.08841594f, 0.13052070f, 0.10188949f, -0.00966320f, 0.11146656f, 0.05319898f, -0.14622232f, 
    -0.19365150f, -0.15848608f, -0.06135175f, 0.03630635f, -0.05562083f, 0.12334390f, 0.02743228f, 0.08157869f, 
    0.15382607f, -0.06227700f, 0.02688324f, -0.02446929f, 0.17751297f, 0.20807526f, -0.00711714f, 0.25770569f, 
    -0.15900539f, -0.07188293f, -0.07981801f, -0.07598396f, 0.00358741f, -0.03317646f, 0.13315889f, 0.00618583f, 
    0.22599097f, 0.17355031f, 0.22146176f, 0.00820626f, -0.06251832f, 0.13266221f, 0.14685684f, 0.09798069f, 
    0.00083379f, -0.00789862f, -0.03099415f, -0.41515064f, 0.17762432f, -0.04889286f, 0.03279159f, -0.18346816f, 
    0.27961501f, -0.03825563f, 0.22468445f, 0.20606633f, -0.02905813f, 0.04866469f, 0.00911632f, -0.03215944f, 
    -0.01955153f, -0.17302765f, -0.00865802f, 0.03118037f, 0.01199483f, -0.12276318f, -0.05842097f, 0.16332337f, 
    -0.08232018f, 0.13043594f, 0.00329439f, 0.06907407f, 0.10042372f, -0.09251384f, -0.11425284f, 0.06917283f, 
    0.02250109f, 0.01800377f, 0.11935883f, 0.04576753f, 0.05583848f, -0.04886404f, -0.01296211f, 0.08941590f, 
    0.29887360f, -0.03876171f, 0.03640795f, -0.05691542f, 0.15843970f, 0.19144334f, 0.49452755f, 0.16924484f, 
    -0.20971423f, -0.00069884f, -0.00990253f, -0.05887115f, -0.04269480f, -0.08740459f, -0.07398468f, -0.02210528f, 
    -0.16456488f, -0.25292781f, -0.18393473f, -0.04271428f, -0.13572441f, -0.07208405f, 0.02705066f, -0.09189545f, 
    0.04412381f, -0.00638857f, 0.00153667f, 0.05553954f, 0.08586626f, -0.14224769f, 0.14836276f, 0.12380958f, 
    0.01526790f, 0.25646365f, 0.11451620f, -0.15849639f, 0.09530469f, 0.05569861f, -0.05437350f, 0.04156481f, 
    -0.19974808f, -0.08721996f, 0.00182302f, -0.25744593f, 0.10546212f, -0.07394207f, -0.04730781f, 0.04769776f, 
    0.11478344f, -0.05894691f, 0.06064583f, -0.00271578f, -0.03331568f, 0.22158913f, -0.17996205f, 0.14138493f, 
    -0.18960197f, -0.00244808f, 0.04325699f, -0.02664027f, 0.09697869f, 0.13753238f, -0.16357534f, 0.06944660f, 
    -0.06363426f, 0.02973870f, -0.13164181f, 0.03676919f, 0.01068523f, 0.15473612f, 0.06823897f, -0.07099137f, 
    -0.01426603f, 0.20092689f, 0.06042973f, 0.12009080f, -0.05783339f, 0.01743550f, -0.15835044f, -0.03242043f, 
    0.14156713f, 0.23153289f, 0.46081206f, -0.03582462f, 0.04186168f, -0.02629281f, 0.10037094f, 0.02489492f, 
    -0.03145067f, -0.11189094f, -0.16327038f, -0.10298197f, -0.04322060f, -0.07909957f, -0.05981885f, -0.00623906f, 
    0.05931591f, 0.00523258f, -0.02820987f, -0.29569271f, 0.12210178f, 0.18918197f, 0.00701105f, -0.22189616f, 
    -0.01745851f, 0.10770206f, 0.00314482f, -0.13530906f, 0.25052240f, 0.19208165f, 0.04399801f, 0.04846809f, 
    0.04767476f, 0.16363347f, 0.01500612f, 0.01724077f, -0.05024871f, 0.30547172f, 0.31112334f, -0.09273450f, 
    0.04862055f, -0.00769916f, 0.04810210f, 0.05859762f, -0.04967674f, -0.42278373f, -0.01622713f, 0.01176283f, 
    -0.10992190f, 0.09645881f, -0.14428888f, -0.05353593f, -0.05431144f, -0.03804281f, -0.21850404f, -0.05073299f, 
    -0.06226359f, -0.09268095f, 0.04404350f, -0.23756188f, -0.10741550f, -0.05892054f, -0.01527495f, -0.06449816f, 
    0.19906096f, 0.30236086f, -0.07335316f, -0.08955087f, -0.04282843f, 0.10133857f, 0.11659086f, 0.05968869f, 
    0.02677312f, -0.02600617f, 0.05311610f, -0.08658197f, -0.21948706f, -0.08470817f, 0.09729828f, 0.04480962f, 
    0.00299244f, -0.10338625f, 0.08161728f, 0.07609022f, -0.14777112f, 0.01039874f, -0.04183050f, 0.04189616f, 
    0.09825611f, 0.01762008f, -0.18488942f, 0.19250201f, -0.41254035f, 0.18033066f, -0.02558244f, -0.00038781f, 
    -0.09689511f, 0.10332278f, 0.02170812f, -0.03789167f, 0.06724566f, 0.25754863f, -0.21010037f, -0.09797408f, 
    -0.00207666f, 0.11895084f, 0.08403812f, 0.04831602f, 0.09462020f, 0.15653501f, -0.09489553f, 0.17720713f, 
    0.14557131f, -0.09507176f, -0.08908439f, 0.16416174f, 0.11931703f, 0.23453915f, 0.08209316f, 0.41994071f, 
    -0.19672489f, -0.07106379f, 0.06119862f, 0.03079045f, 0.08639147f, 0.05484051f, -0.17079969f, 0.07025268f, 
    0.29784319f, 0.07712142f, -0.03288445f, -0.01440147f, 0.04732608f, -0.15715168f, -0.06338596f, -0.24599732f, 
    -0.16699821f, -0.07467286f, 0.02336542f, -0.04614020f, 0.00446324f, -0.05055868f, -0.16204906f, 0.11481091f, 
    0.19516574f, 0.24950744f, 0.27314568f, 0.02882764f, 0.17219947f, -0.02918950f, 0.13110848f, 0.03774285f, 
    -0.04974836f, -0.09416837f, 0.00611287f, -0.05072610f, -0.09142879f, 0.01809330f, 0.02240160f, 0.03715644f, 
    0.16492607f, -0.14280748f, 0.09942543f, 0.23269045f, 0.22694257f, -0.01583949f, -0.02929582f, -0.07994920f, 
    0.03822139f, -0.02026816f, 0.14824073f, 0.16726668f, 0.30131119f, -0.14354515f, -0.10590860f, 0.10131600f, 
    -0.02766126f, 0.19351612f, 0.14274324f, -0.33123574f, 0.01776088f, -0.04877087f, -0.07735915f, 0.01128483f, 
    -0.00149739f, -0.00828428f, 0.05832120f, 0.01088744f, 0.07345695f, -0.19197653f, -0.12213621f, -0.06238907f, 
    0.10766217f, 0.08886483f, -0.04946167f, 0.02947583f, -0.02624881f, 0.10395157f, -0.03260744f, 0.11208750f, 
    0.00111940f, -0.06027127f, -0.09098119f, -0.09838264f, -0.05693685f, -0.04082119f, -0.07318527f, -0.62758678f, 
    -0.38019150f, 0.43028253f, 0.14284350f, 0.20757051f, -0.22856428f, -0.18527624f, -0.07334620f, -0.08482697f, 
    -0.10816507f, -0.00806046f, -0.16855796f, -0.08654843f, 0.05089473f, -0.13790520f, 0.00156871f, 0.06374662f, 
    -0.01461817f, -0.25598103f, -0.07575012f, -0.14758939f, 0.06480205f, 0.09075635f, 0.00865932f, 0.07784294f, 
    0.11151618f, -0.07951214f, -0.03170997f, 0.15844248f, -0.00205222f, 0.09717554f, -0.07676241f, 0.06510022f, 
    -0.03105744f, -0.13241233f, -0.04600319f, -0.11013898f, 0.07116628f, 0.05978807f, 0.03310961f, -0.03384253f, 
    0.07558887f, -0.04566699f, 0.13071994f, -0.07516818f, -0.12668332f, 0.02289399f, 0.19555384f, -0.00095678f, 
    0.07477165f, -0.13942102f, -0.12832029f, 0.03134280f, 0.18443227f, -0.00879606f, -0.01185797f, -0.15217617f, 
    -0.05115295f, 0.12941733f, -0.06436288f, -0.08073884f, 0.17638326f, -0.06756186f, -0.18422371f, -0.09841407f, 
    0.05271259f, 0.02650154f, 0.20709442f, -0.04238231f, -0.13972993f, 0.04784590f, 0.13841072f, -0.15170722f, 
    0.13619991f, -0.00965711f, -0.03827830f, -0.10389703f, -0.03352660f, -0.02353989f, 0.03322180f, 0.08333635f, 
    0.09308260f, -0.16446640f, 0.09736931f, -0.08326498f, 0.02759379f, -0.09100447f, 0.03597917f, 0.07294033f, 
    0.04623501f, -0.42380401f, 0.13533436f, 0.25554451f, 0.06174712f, 0.12058843f, -0.07584663f, 0.12984079f, 
    0.00333485f, 0.13414299f, 0.24414496f, -0.13312799f, 0.20837532f, -0.05091889f, -0.02637193f, -0.17361479f, 
    -0.12476188f, -0.19942945f, -0.09992396f, 0.13240601f, -0.03844180f, 0.07894874f, 0.12765394f, 0.01074085f, 
    0.06524061f, -0.00093644f, 0.11940305f, 0.11330608f, -0.04932640f, 0.07769620f, 0.06818282f, 0.07937881f, 
    -0.09968325f, 0.11702491f, 0.02368069f, 0.05406249f, 0.10925239f, -0.19113547f, -0.19650111f, -0.48080915f, 
    0.20225710f, 0.05705115f, 0.12781492f, 0.11079855f, -0.05472717f, 0.09037016f, 0.32724547f, 0.15091111f, 
    0.00800647f, -0.04772075f, -0.06467009f, 0.00343411f, 0.24299401f, -0.10017083f, 0.15409581f, 0.01770155f, 
    -0.26837754f, 0.12415537f, 0.09981684f, -0.01839983f, 0.11623282f, 0.04009791f, -0.06428110f, -0.02277006f, 
    -0.14991808f, 0.13641357f, 0.14025185f, -0.12429792f, 0.06138571f, -0.07113208f, 0.02606278f, 0.05310876f, 
    -0.23102036f, 0.17246020f, -0.26158044f, -0.13176700f, 0.00612246f, 0.01138154f, 0.13142462f, -0.06541070f, 
    0.11578260f, -0.09224802f, -0.07905290f, -0.28135794f, 0.03964721f, -0.13152996f, -0.07815891f, -0.04112693f, 
    0.03154232f, -0.16164519f, -0.02861230f, -0.02007813f, -0.09058543f, 0.06450494f, 0.05869365f, 0.08351068f, 
    -0.06252195f, -0.03715185f, 0.04264284f, 0.04853346f, 0.02831199f, -0.48290235f, -0.49490848f, -0.15090871f, 
    -0.04166988f, -0.04717675f, 0.10794976f, 0.01903756f, -0.15075788f, -0.16961928f, -0.07762079f, 0.13275799f, 
    -0.00806032f, 0.05775519f, -0.00260241f, 0.00104966f, 0.07045466f, -0.07215919f, -0.30436677f, -0.07517556f, 
    0.10961033f, 0.09339133f, 0.14442158f, 0.14266144f, 0.10215247f, -0.01849871f, 0.17218927f, -0.09280401f, 
    0.24650082f, 0.15995657f, -0.15541629f, 0.05871362f, -0.38792959f, -0.06630448f, -0.05398635f, 0.15713155f, 
    -0.11459107f, -0.10645782f, -0.14303282f, -0.04939387f, -0.03844699f, 0.04485892f, 0.15815037f, -0.02431087f, 
    0.14617760f, 0.20606874f, 0.04148664f, -0.03968219f, 0.13624911f, -0.04491708f, -0.00426756f, 0.14835213f, 
    0.13192661f, 0.09996647f, 0.29697630f, -0.05162167f, -0.08150727f, -0.01054738f, -0.01376620f, -0.10122880f, 
    0.03342810f, -0.05360308f, 0.02302436f, -0.25123328f, -0.22907823f, 0.06941589f, -0.14845884f, -0.08774424f, 
    -0.09038321f, -0.03092518f, -0.01717743f, 0.08639304f, -0.03736290f, 0.04092600f, -0.11944784f, -0.08326383f, 
    -0.09002558f, -0.13855472f, -0.04090464f, 0.00654417f, -0.11351793f, -0.10647997f, -0.02864143f, 0.10993603f, 
    0.07754030f, 0.02248911f, -0.18347424f, 0.16261984f, -0.09861512f, -0.10013559f, -0.02093385f, 0.04798128f, 
    -0.20424461f, -0.01845518f, 0.05440023f, -0.15668331f, 0.06765689f, 0.00216269f, -0.01097448f, -0.64589751f, 
    -0.04296005f, -0.34733176f, -0.04856902f, -0.34579226f, 0.16812922f, 0.07667779f, 0.10470346f, 0.04360396f, 
    0.04169649f, 0.14249165f, -0.04173779f, -0.00192369f, 0.03910869f, 0.08395451f, 0.10741858f, 0.11264531f, 
    0.05580982f, -0.06475440f, 0.30435514f, -0.03498591f, -0.07363045f, -0.06366538f, -0.04681975f, -0.12758829f, 
    -0.15191218f, 0.08216904f, -0.06992767f, -0.03829311f, -0.01596097f, -0.04286742f, 0.19530803f, 0.10846454f, 
    0.02472422f, 0.13308573f, 0.11679364f, -0.07423430f, -0.26591963f, -0.03188589f, -0.15683395f, -0.01589934f, 
    -0.06408318f, 0.10938279f, 0.12028699f, -0.17631777f, 0.37916461f, -0.00788202f, -0.39966205f, 0.08545008f, 
    -0.04706612f, -0.01940334f, 0.01601313f, -0.01541906f, 0.11723997f, 0.10530234f, -0.07633989f, 0.05421579f, 
    0.00165137f, -0.07339349f, -0.05183323f, 0.01054286f, -0.17530453f, 0.10078524f, -0.17228884f, -0.19098744f, 
    0.02099207f, 0.05999085f, 0.00702748f, -0.03361567f, -0.14450145f, 0.10216530f, 0.17374557f, 0.27021575f, 
    -0.09472580f, 0.04137408f, 0.16055769f, 0.17950499f, 0.02307191f, 0.02521887f, 0.04684039f, 0.06851663f, 
    0.17039424f, 0.22480617f, 0.11214332f, 0.03242942f, 0.00672073f, 0.11487488f, -0.01506923f, -0.07279773f, 
    0.00331806f, -0.03375073f, -0.01107860f, -0.15971917f, -0.07858413f, 0.00888326f, 0.00532565f, -0.00744348f, 
    -0.02339725f, -0.11102404f, -0.06153996f, -0.19236667f, 0.12577890f, 0.19080538f, 0.06403404f, 0.16303596f, 
    -0.05896691f, -0.07651590f, -0.02495311f, 0.16638716f, -0.05216642f, 0.10238835f, 0.02589819f, -0.05513685f, 
    -0.04414677f, 0.04527111f, -0.02911595f, -0.11305313f, 0.07014839f, 0.19402221f, 0.05643786f, 0.04682039f, 
    -0.08665580f, -0.04741142f, -0.04579309f, -0.07779098f, 0.00609086f, 0.07129854f, -0.07411566f, -0.13672842f, 
    0.20340642f, -0.00901715f, 0.17331062f, -0.05171917f, -0.06456345f, -0.05743632f, 0.07654493f, -0.18049817f, 
    0.14162721f, 0.10190453f, 0.10096049f, 0.19249965f, -0.00692281f, -0.01861134f, -0.17671660f, 0.09361828f, 
    0.12438842f, 0.22182111f, 0.01758280f, -0.08361413f, -0.10124929f, -0.04286419f, -0.05502630f, 0.12717445f, 
    0.07927266f, 0.04089118f, -0.04355266f, 0.06834163f, -0.07750968f, -0.06352323f, 0.14547178f, 0.03514904f, 
    -0.03248274f, -0.10270065f, -0.06019444f, -0.03463318f, 0.19832236f, 0.00562234f, 0.07417957f, 0.07350650f, 
    0.08891927f, -0.01104974f, 0.05392489f, -0.26290429f, 0.07219590f, 0.17913702f, -0.11139251f, 0.02618646f, 
    -0.02930757f, 0.14321901f, -0.28899559f, 0.06673001f, 0.17503810f, 0.06527910f, 0.07628281f, -0.08850868f, 
    -0.07152754f, 0.03915574f, -0.07386082f, -0.00063123f, 0.01618434f, 0.09004791f, 0.05143796f, -0.08274981f, 
    -0.01420011f, -0.14348562f, 0.02098781f, 0.02945564f, -0.00702777f, 0.10019200f, 0.23631756f, 0.22212179f, 
    -0.00417712f, -0.13363871f, -0.10889215f, 0.04799688f, 0.12839094f, 0.13395403f, -0.07749319f, 0.21999967f, 
    -0.04917718f, -0.02160360f, 0.03820204f, 0.04515027f, -0.07387406f, 0.02367184f, 0.02245609f, 0.01625397f, 
    -0.11288822f, -0.08744429f, 0.10060681f, -0.04016290f, 0.06148645f, -0.05560533f, -0.11135334f, -0.12807477f, 
    0.14015412f, 0.11196409f, -0.11162378f, 0.03221979f, 0.01089783f, 0.04551980f, 0.01399341f, -0.08091255f, 
    -0.03161234f, -0.08017386f, -0.12614851f, 0.01054148f, 0.11714532f, -0.04276068f, 0.04327988f, -0.07953440f, 
    -0.00442057f, -0.06470566f, 0.16997249f, 0.14930055f, 0.10615758f, 0.17613484f, -0.10327741f, -0.08397910f, 
    0.05673138f, -0.04796679f, 0.06897770f, 0.32453680f, 0.04742837f, -0.02387024f, 0.04084974f, 0.09397612f, 
    -0.14159997f, 0.15207420f, 0.00295537f, -0.14979737f, 0.04945262f, 0.01526961f, 0.00421260f, 0.15505365f, 
    0.02226776f, -0.11782803f, 0.09247933f, 0.11467353f, -0.03291630f, -0.19708870f, 0.00476396f, 0.01595988f, 
    0.01769444f, 0.12424873f, 0.17385748f, -0.01095570f, -0.12191173f, -0.08587314f, -0.06144574f, -0.03713249f, 
    -0.13554758f, 0.18882777f, 0.13942878f, 0.04776442f, 0.03448259f, 0.06005808f, -0.13594650f, -0.01854956f, 
    0.12650758f, -0.01011690f, -0.13269453f, 0.12493140f, 0.12648883f, 0.04981991f, -0.02075473f, -0.18385938f, 
    0.02105328f, -0.00824718f, -0.01486882f, 0.04086897f, -0.02434185f, -0.05932037f, 0.05366484f, 0.04226142f, 
    0.04157986f, -0.08958446f, -0.03244932f, -0.08166461f, 0.06200464f, 0.06405871f, 0.03880309f, 0.01334527f, 
    0.04340689f, -0.11524308f, 0.00737585f, 0.03558238f, -0.11599112f, -0.12020997f, 0.00818724f, -0.00642606f, 
    -0.06883840f, -0.00947188f, -0.24125776f, 0.08157483f, 0.08071996f, 0.12655079f, -0.09968586f, -0.03353080f, 
    -0.12470374f, 0.04931485f, 0.10461540f, -0.05412388f, 0.01946494f, -0.07556787f, 0.05249435f, 0.11242607f, 
    0.05359500f, -0.00448732f, -0.04883118f, 0.06047617f, 0.00908103f, 0.02783666f, -0.20781806f, 0.02954775f, 
    -0.09023587f, 0.03571718f, 0.09733824f, -0.03917202f, -0.07398275f, -0.24808834f, 0.12892137f, 0.01270837f, 
    -0.00998263f, 0.08855554f, 0.02602030f, 0.00789013f, -0.11189117f, 0.06055309f, -0.13511221f, 0.09393109f, 
    0.00878336f, 0.09420285f, 0.11564451f, -0.02544479f, 0.12288418f, 0.03364908f, 0.02740911f, -0.00738337f, 
    0.08842058f, 0.36250889f, 0.26768184f, -0.01729904f, -0.08183961f, -0.20916885f, 0.06092289f, -0.05541339f, 
    -0.02264223f, 0.24939503f, -0.22805543f, -0.09190554f, -0.02525825f, -0.06883060f, -0.19146413f, 0.03930777f, 
    -0.00361484f, 0.09382106f, -0.27097520f, -0.22563876f, -0.12309793f, 0.00523716f, -0.08724485f, 0.00601777f, 
    -0.09161142f, 0.01282890f, 0.00516480f, -0.01387823f, 0.12425125f, 0.15041140f, -0.02957119f, 0.11463948f, 
    0.02175203f, 0.21619214f, -0.04690351f, -0.11882156f, 0.11294582f, 0.14944856f, 0.15246789f, -0.02166399f, 
    -0.01533384f, 0.05489990f, 0.05771570f, 0.07473962f, 0.03270854f, 0.18662605f, -0.03405800f, 0.05089652f, 
    -0.13955168f, 0.10589638f, 0.03715395f, 0.09480251f, 0.08483085f, 0.09166653f, -0.43851319f, 0.00571682f, 
    0.05423287f, 0.05131191f, -0.06369851f, 0.17966680f, -0.00323053f, 0.04395324f, -0.03421206f, 0.13289037f, 
    0.11340859f, -0.00318387f, 0.10135334f, 0.08307404f, 0.07979715f, -0.01424289f, 0.06239024f, -0.01350386f, 
    0.00810399f, -0.37221757f, -0.23938404f, 0.05192938f, 0.04786908f, 0.02894868f, 0.00351020f, 0.14591742f, 
    -0.00263297f, -0.18451837f, -0.25459588f, -0.13211972f, -0.11272588f, 0.00702776f, 0.05087268f, -0.04997954f, 
    0.09021115f, -0.00936422f, 0.00429098f, 0.04517058f, 0.20192249f, 0.00725352f, -0.08683880f, -0.10871396f, 
    -0.01652012f, 0.21280839f, -0.04327260f, 0.20472552f, 0.23162359f, 0.07083501f, -0.11803176f, 0.03165277f, 
    -0.00504942f, 0.17008360f, 0.00570784f, -0.01615190f, 0.13213150f, 0.26708099f, 0.17188309f, -0.12962861f, 
    0.02093060f, -0.06546117f, -0.15130919f, -0.00370559f, -0.10787801f, 0.08920082f, 0.18805468f, -0.03631047f, 
    0.00483335f, 0.06204809f, 0.12804402f, -0.01300240f, -0.09349417f, 0.05511288f, 0.25694779f, -0.05559084f, 
    -0.15604466f, 0.02855787f, 0.18777335f, 0.05429592f, 0.09376924f, 0.18017606f, -0.05593025f, -0.03613839f, 
    -0.23862337f, -0.13638267f, 0.13034880f, -0.16481189f, -0.11563020f, -0.02193324f, 0.06186049f, -0.06126754f, 
    -0.12595546f, 0.12518494f, 0.18714991f, -0.06081105f, 0.20312946f, 0.05481121f, -0.05476154f, 0.06935124f, 
    0.26583168f, -0.00621308f, 0.05177796f, 0.18471625f, -0.02561906f, -0.04477462f, -0.00132605f, -0.05629325f, 
    0.02736380f, 0.08062409f, -0.03552488f, 0.28721619f, 0.17210786f, -0.07933162f, 0.04218744f, -0.02911284f, 
    0.10959186f, 0.11262900f, 0.07398468f, -0.06448031f, -0.21961269f, 0.28303203f, 0.02049927f, 0.14169401f, 
    -0.12069320f, -0.01006972f, 0.10474105f, 0.12176944f, -0.11212805f, -0.17261000f, -0.03923565f, -0.11046202f, 
    -0.01087537f, -0.00954753f, -0.07659962f, -0.18716170f, -0.02332232f, -0.33375823f, 0.06651567f, -0.31209797f, 
    -0.09772402f, 0.01480924f, 0.08956879f, -0.06947669f, -0.00267339f, 0.00963860f, -0.20447499f, -0.25659478f, 
    -0.17833802f, -0.12045115f, -0.15156105f, -0.06589362f, -0.01294928f, -0.03490568f, 0.09530419f, -0.28555954f, 
    -0.18939339f, 0.15034083f, -0.03251568f, 0.19942051f, -0.13254029f, -0.05797578f, 0.06748197f, 0.09751612f, 
    -0.08115969f, -0.09000283f, 0.03075571f, -0.06206965f, 0.06814966f, 0.01429958f, 0.04294135f, -0.06693565f, 
    0.14478913f, 0.06386922f, -0.26831472f, 0.24748842f, -0.01606620f, 0.04131356f, 0.04363851f, -0.10751065f, 
    -0.13618025f, -0.05353523f, 0.25103539f, -0.07873515f, 0.01970402f, 0.08634473f, 0.11824294f, -0.05878729f, 
    0.10309173f, -0.07020253f, -0.09643468f, 0.01591484f, -0.01194825f, 0.01402050f, -0.10063964f, 0.06771158f, 
    0.07306226f, -0.08313787f, -0.19752862f, -0.06778435f, -0.27364206f, 0.11420812f, 0.18290202f, 0.07911617f, 
    0.09804560f, -0.13322607f, -0.07418739f, 0.11583035f, -0.07695496f, -0.27382025f, 0.09365804f, 0.04944060f, 
    0.02023504f, -0.25658500f, -0.09841936f, -0.04414133f, 0.00594996f, 0.17104062f, 0.01316137f, -0.30231982f, 
    -0.09442254f, 0.04083503f, -0.08843720f, 0.01354460f, -0.02275980f, 0.12482269f, -0.04596503f, -0.25761038f, 
    -0.15693307f, -0.10630593f, 0.04144188f, 0.05647561f, 0.13925840f, 0.02281035f, 0.15818331f, 0.03023468f, 
    -0.01557991f, 0.01208404f, -0.00176550f, 0.03756498f, -0.02608984f, -0.05824126f, -0.03122232f, 0.03281577f, 
    -0.05780016f, 0.03034273f, -0.05175915f, -0.04225659f, -0.01522805f, -0.03812413f, -0.03707438f, -0.01943447f, 
    0.00383747f, 0.04726709f, -0.01566190f, 0.04369475f, -0.01951421f, 0.00066159f, -0.03023923f, 0.00541582f, 
    0.03195009f, 0.03034910f, -0.05831002f, -0.04786875f, 0.00900938f, -0.00409294f, -0.03555631f, -0.04676959f, 
    -0.02966245f, 0.03477300f, 0.01507120f, 0.00572381f, -0.06104703f, -0.01255856f, 0.02726819f, -0.03251222f, 
    -0.05252966f, 0.04497414f, 0.00079245f, -0.00012320f, 0.02646687f, 0.00388307f, 0.04148433f, -0.04413118f, 
    -0.01935382f, -0.03862168f, -0.01579772f, -0.02197051f, -0.01318803f, -0.04274597f, -0.00274992f, -0.05121234f, 
    0.02955053f, 0.02029302f, -0.04669913f, 0.00023686f, -0.04108289f, 0.05276931f, -0.00308884f, -0.01825319f, 
    0.00093981f, -0.01794610f, -0.04374263f, -0.04510273f, -0.02975264f, 0.05354808f, -0.04473522f, 0.00217206f, 
    -0.04644230f, -0.04337430f, 0.03655627f, 0.03863486f, 0.04377067f, 0.02691298f, -0.02844011f, 0.04121726f, 
    -0.04472193f, -0.00112069f, 0.02027777f, 0.01477213f, 0.04657153f, -0.02892536f, -0.00545801f, 0.03324350f, 
    -0.02642367f, -0.01461189f, -0.00109826f, -0.05960295f, -0.02675265f, 0.04812628f, -0.01087372f, -0.02090213f, 
    0.03922674f, -0.05157886f, 0.03349842f, -0.00723658f, -0.01596438f, -0.02241294f, -0.03128097f, -0.04423209f, 
    0.02534022f, -0.03762264f, 0.02259072f, -0.00038115f, -0.00200720f, -0.01206933f, -0.00797556f, -0.02445798f, 
    -0.00280025f, -0.06258269f, 0.01303932f, 0.01254691f, 0.03932107f, -0.01390270f, 0.00588241f, 0.04359798f, 
    0.01025717f, -0.01068888f, -0.01828627f, -0.00082719f, 0.01541841f, -0.05032797f, 0.02718082f, -0.03901282f, 
    -0.03063397f, 0.04717282f, -0.02417849f, -0.06175163f, 0.02648951f, -0.02610073f, 0.02143390f, 0.02253893f, 
    -0.01313716f, -0.02865806f, 0.04430509f, 0.02439169f, -0.06034638f, 0.00005787f, -0.04309990f, -0.03417040f, 
    0.01721028f, -0.01077661f, -0.01920008f, -0.00607216f, 0.01444230f, 0.04724672f, -0.05848664f, 0.03829839f, 
    -0.04993163f, 0.02081893f, 0.02572493f, -0.02665342f, -0.04937772f, -0.02300105f, 0.02145321f, 0.03898627f, 
    0.04299108f, 0.02562603f, -0.01579463f, 0.01650877f, 0.01668845f, -0.01827757f, -0.01229368f, -0.03896789f, 
    0.05117989f, 0.02549466f, -0.02144405f, 0.02225390f, -0.00771897f, 0.02897829f, -0.01719810f, -0.01804489f, 
    -0.02571141f, -0.01840673f, -0.04172619f, -0.04840756f, 0.02204219f, -0.04347485f, 0.01091134f, -0.00245861f, 
    -0.02769005f, -0.03215216f, -0.02972951f, 0.03094928f, 0.00207094f, -0.01208133f, -0.03198075f, -0.05498784f, 
    0.00054448f, -0.01251595f, -0.00451416f, -0.00163470f, 0.00857347f, -0.03381528f, -0.03997817f, -0.03739285f, 
    -0.03142495f, -0.00206512f, 0.02240224f, 0.04435384f, -0.01405225f, 0.00231388f, -0.02327231f, -0.03588293f, 
    -0.03366169f, 0.01614527f, -0.05140888f, -0.02744641f, 0.04657175f, 0.05383052f, 0.01673425f, -0.00760418f, 
    0.02275373f, -0.04121901f, 0.05013233f, -0.03791294f, 0.01409280f, -0.05099292f, -0.04112119f, 0.04987650f, 
    -0.05007746f, -0.01016582f, 0.01197492f, -0.02525536f, 0.03550073f, 0.02763193f, 0.03275625f, 0.01279108f, 
    0.00138092f, 0.01875951f, 0.04955169f, -0.05995079f, -0.03873457f, -0.02797714f, 0.02998467f, -0.04164070f, 
    -0.01601762f, 0.04737209f, -0.05411684f, 0.02685544f, -0.00657549f, -0.01668869f, 0.02942648f, 0.01993079f, 
    -0.03684790f, -0.04184202f, -0.04810863f, 0.00773939f, 0.01364066f, -0.05393811f, -0.05052024f, -0.04593349f, 
    -0.06609404f, 0.01534419f, -0.03588964f, 0.00821210f, 0.00729635f, -0.05129543f, -0.01163936f, -0.00104220f, 
    0.04069091f, -0.04875895f, 0.04673561f, -0.00893373f, -0.00763167f, 0.00701217f, -0.05136663f, -0.00145030f, 
    0.04380353f, -0.04161093f, 0.03211430f, -0.00584222f, -0.04253251f, -0.02270442f, 0.03424905f, 0.02527758f, 
    0.01886281f, -0.03803274f, -0.06540921f, -0.03596634f, -0.01297199f, 0.01947367f, -0.05755956f, -0.03101677f, 
    -0.18650010f, 0.07331952f, 0.04695340f, -0.02581765f, 0.03920812f, 0.02643564f, 0.07524492f, 0.24014932f, 
    0.04591704f, 0.04334263f, -0.03328098f, -0.05440722f, -0.01816436f, -0.09449418f, 0.08635215f, -0.03346301f, 
    -0.03336640f, -0.16315043f, -0.04813827f, -0.19669244f, 0.05408583f, 0.20477688f, 0.02426726f, 0.05390503f, 
    -0.06984496f, 0.06943121f, 0.02460742f, -0.12994295f, 0.05191891f, -0.02635769f, -0.06229863f, 0.04681862f, 
    0.06473585f, 0.01075363f, 0.00099062f, 0.01764419f, -0.05826205f, -0.03774241f, 0.03203041f, -0.06296632f, 
    0.04855373f, 0.03987338f, 0.07043363f, -0.07175466f, -0.06330711f, -0.04151030f, -0.15613744f, 0.17879391f, 
    0.04800279f, -0.05174798f, -0.12412360f, -0.12711056f, -0.10544375f, -0.27936175f, -0.08315349f, -0.25989920f, 
    0.08024336f, 0.01882170f, -0.06317940f, -0.01047661f, -0.03919820f, -0.03795110f, -0.16245568f, -0.10920294f, 
    -0.03065760f, -0.03278861f, -0.09127565f, -0.05542751f, -0.08698111f, 0.03563840f, 0.00757203f, 0.07571605f, 
    -0.15496176f, -0.05664488f, 0.08364423f, 0.12531437f, -0.18815307f, -0.02925351f, -0.08609341f, -0.09955309f, 
    0.13913018f, 0.03975572f, 0.07294747f, 0.04000669f, 0.24688955f, 0.04215938f, 0.04048739f, 0.04420051f, 
    0.13349828f, 0.14308091f, 0.24446854f, 0.08626997f, -0.10689417f, 0.00293859f, 0.14818482f, 0.13802631f, 
    -0.05780997f, 0.02595965f, 0.07294066f, -0.20930269f, 0.08911072f, -0.11684632f, -0.07538765f, -0.06726648f, 
    0.09847429f, 0.08194374f, 0.15238389f, 0.00506213f, 0.04442129f, -0.03625589f, -0.00221008f, 0.07869560f, 
    -0.08500984f, 0.12705509f, 0.09058041f, 0.08293332f, 0.25872698f, -0.02349335f, 0.22569591f, -0.06232776f, 
    -0.05724277f, -0.01975311f, 0.10253166f, 0.06966814f, 0.09823005f, 0.02891951f, -0.05781510f, 0.03734857f, 
    0.07470651f, -0.04638460f, -0.03279161f, -0.20074995f, -0.17466651f, -0.16118117f, -0.26804692f, 0.05154934f, 
    0.00577063f, -0.04065510f, -0.11553974f, -0.10731775f, -0.07419144f, -0.11021291f, -0.02032699f, -0.28051084f, 
    -0.08192399f, 0.20611510f, 0.07462998f, 0.05517252f, -0.08696754f, 0.19030595f, 0.10336759f, -0.03066923f, 
    0.22512546f, 0.05466228f, -0.06630420f, -0.08389473f, 0.03330041f, 0.02288355f, 0.06329960f, -0.09695777f, 
    -0.10725319f, -0.06466611f, -0.27700496f, 0.00619732f, 0.08359736f, 0.00764982f, -0.03186835f, -0.04276148f, 
    0.03335492f, 0.03556594f, -0.03576115f, 0.05372580f, 0.07187468f, -0.02425579f, 0.23329349f, -0.06990750f, 
    0.08496718f, 0.18942621f, -0.49059832f, 0.16838771f, -0.14415884f, -0.08777916f, -0.02007846f, 0.18900542f, 
    0.03323276f, 0.03113009f, 0.14257531f, 0.07659243f, 0.12959866f, -0.13702706f, -0.07528728f, -0.29645234f, 
    0.15188716f, 0.00239853f, 0.05662660f, 0.16370001f, 0.09693418f, 0.13703130f, 0.00650867f, -0.16098154f, 
    -0.11871859f, 0.35251167f, 0.03874049f, -0.02853311f, -0.00096378f, -0.00369995f, -0.08229060f, 0.18224417f, 
    0.03532444f, -0.08019391f, 0.03228758f, -0.10002865f, 0.01548120f, 0.05452136f, -0.20508376f, -0.45390648f, 
    -0.01100356f, -0.01436506f, 0.04735647f, 0.00325858f, 0.08201119f, 0.09486349f, 0.15710276f, 0.07080997f, 
    0.17733477f, 0.00422557f, -0.04029590f, -0.05549818f, -0.08190368f, -0.09688732f, 0.02763419f, 0.03570153f, 
    0.06351579f, 0.06009501f, -0.19861759f, 0.04555926f, -0.10637489f, 0.10333867f, -0.02072470f, 0.07624343f, 
    -0.23123252f, -0.09108840f, -0.03069728f, 0.04859823f, -0.11774969f, 0.03607540f, 0.04881537f, 0.01598305f, 
    0.01280781f, 0.11416463f, 0.11328898f, 0.10464127f, 0.02423939f, -0.10222599f, -0.11234462f, 0.11121566f, 
    0.19556625f, 0.14167708f, -0.12377169f, 0.11502670f, 0.04618076f, 0.06307384f, 0.15178569f, -0.08910564f, 
    -0.03613784f, 0.06056952f, 0.08343969f, -0.17102611f, -0.10971300f, -0.11207052f, 0.09370546f, -0.02225171f, 
    0.07025971f, 0.07521894f, 0.06868523f, 0.07469897f, -0.07031889f, 0.05075856f, 0.08857620f, 0.11754206f, 
    -0.05564841f, -0.00476232f, 0.14911292f, -0.01581518f, 0.03033519f, 0.11778595f, 0.13125606f, 0.07254116f, 
    -0.21893448f, -0.07324335f, -0.28373778f, 0.03093026f, -0.03997933f, -0.10729714f, -0.02684779f, -0.16638656f, 
    -0.06813055f, 0.16132760f, 0.08122386f, -0.00606815f, 0.01975695f, 0.11486585f, 0.00355825f, 0.11394547f, 
    0.03374828f, -0.09913366f, 0.22094163f, -0.09181672f, -0.17124957f, 0.02031133f, 0.03224034f, 0.19525589f, 
    0.08492579f, 0.03142473f, 0.00249148f, -0.03026162f, 0.02077618f, -0.35086972f, 0.05752125f, -0.04906527f, 
    -0.13379917f, -0.05056748f, 0.00504856f, 0.05518740f, -0.13106127f, -0.22704297f, -0.40512401f, 0.15778619f, 
    -0.10766353f, -0.01574402f, -0.07903671f, 0.10380719f, 0.04789478f, -0.22128056f, -0.04151121f, 0.13615800f, 
    -0.07007851f, 0.22975880f, -0.03539184f, 0.00772344f, 0.06875965f, 0.09642509f, -0.14055167f, -0.12132996f, 
    0.13900945f, -0.05060320f, 0.06935453f, 0.06019545f, 0.11832395f, -0.11169898f, 0.09349931f, -0.13164999f, 
    0.33589849f, 0.09314784f, 0.12310538f, 0.04131526f, -0.22353379f, 0.13016646f, 0.11323947f, -0.00136505f, 
    -0.01288824f, -0.06256068f, 0.02885193f, 0.06201395f, -0.08763754f, -0.00496961f, 0.03731265f, 0.05125049f, 
    0.03971235f, -0.21997663f, 0.12451291f, 0.12356620f, 0.10805511f, 0.00119983f, 0.02411364f, 0.02764709f, 
    -0.09153408f, -0.15824099f, -0.15560120f, -0.08931545f, -0.02118305f, -0.17307185f, -0.13690022f, 0.13756604f, 
    0.08887386f, -0.06597759f, 0.00065728f, -0.11451229f, 0.04532632f, -0.05822824f, 0.09779307f, -0.16921601f, 
    -0.09115110f, -0.04077009f, -0.05306164f, -0.03745668f, -0.00465605f, -0.02469720f, -0.05644661f, -0.04835112f, 
    -0.02603532f, -0.04704269f, -0.15647165f, -0.22060195f, -0.19780076f, -0.22345281f, -0.08052843f, 0.01660998f, 
    -0.04418650f, -0.17339192f, -0.10610052f, 0.17727058f, 0.06809524f, -0.01582880f, -0.09746374f, 0.07104205f, 
    0.08437173f, -0.06838541f, 0.08614232f, -0.07703860f, 0.04896069f, 0.13280176f, 0.13507721f, 0.08021915f, 
    0.07328976f, 0.12252491f, -0.00696928f, 0.03838216f, -0.00025919f, 0.05102700f, 0.01424492f, -0.06358255f, 
    -0.02018612f, -0.32504079f, -0.19297922f, 0.00224383f, 0.03357856f, -0.10136792f, 0.01123906f, -0.07410279f, 
    -0.12485881f, 0.07142796f, 0.05012799f, -0.04656472f, 0.11813499f, 0.11940249f, 0.01748025f, 0.06254652f, 
    0.06055415f, 0.06579325f, -0.20917822f, 0.00159529f, -0.05616839f, 0.23003654f, 0.02415988f, 0.15890957f, 
    -0.17587420f, -0.14477293f, 0.01357891f, 0.05569306f, -0.29186991f, -0.05972679f, 0.15950868f, 0.00191557f, 
    -0.03830743f, 0.20698453f, -0.00396902f, -0.02914038f, 0.16280693f, 0.01573958f, 0.01683465f, 0.09936229f, 
    0.00342563f, -0.00385520f, -0.13464084f, -0.04464720f, -0.12765110f, 0.41793835f, -0.05044899f, -0.21288440f, 
    0.01607385f, 0.15465693f, 0.02125416f, 0.09477901f, -0.00691937f, -0.15215541f, -0.04565547f, -0.07467896f, 
    0.17561197f, 0.06656080f, 0.10795024f, -0.01493606f, 0.11357838f, -0.03452436f, -0.10638829f, -0.11595673f, 
    -0.14640109f, -0.27304795f, -0.09437805f, 0.11286721f, 0.11372682f, 0.07882921f, 0.14912742f, 0.00370374f, 
    0.18594109f, 0.11968148f, 0.11904728f, 0.09035134f, 0.04707913f, 0.00471952f, -0.02609714f, 0.02907150f, 
    -0.09338875f, 0.28331384f, 0.04145760f, -0.04960454f, 0.06439037f, 0.14663675f, 0.02352217f, 0.11329613f, 
    -0.03549644f, -0.12585419f, 0.20429364f, -0.14800349f, -0.32046598f, -0.13009319f, -0.10807946f, -0.02748616f, 
    0.13052192f, 0.07320940f, 0.22183803f, 0.15696225f, 0.05847566f, 0.02795864f, 0.06232772f, 0.01569414f, 
    -0.17004953f, -0.01536362f, -0.28400317f, -0.13829798f, 0.06103843f, 0.10609969f, -0.05762570f, 0.05599381f, 
    -0.17925878f, 0.09652467f, 0.00969819f, -0.10244349f, 0.02106078f, -0.16183925f, -0.09270755f, -0.09594413f, 
    0.05473473f, -0.04647610f, 0.12091033f, 0.07014024f, 0.11547733f, -0.02976169f, 0.30368906f, -0.07153305f, 
    -0.11215781f, -0.06608938f, -0.11235058f, 0.11519820f, 0.04624224f, 0.01803916f, -0.09839144f, -0.09793691f, 
    0.08880525f, 0.13400681f, -0.05571597f, 0.01547758f, -0.02382801f, 0.04175289f, -0.05565408f, -0.07021358f, 
    -0.12641491f, -0.03649672f, -0.00752036f, 0.06849273f, 0.07391152f, -0.35291073f, -0.04741829f, -0.03478447f, 
    -0.02167501f, 0.14210960f, 0.16317692f, -0.06134073f, -0.09991185f, -0.09549228f, 0.05643613f, -0.10376000f, 
    0.02417482f, -0.02946081f, 0.62082726f, 0.46473584f, 0.13763227f, -0.02482147f, -0.13230692f, 0.11471497f, 
    -0.08527953f, -0.00511479f, 0.00428180f, -0.01750584f, 0.05160050f, 0.09697746f, -0.03516587f, -0.00473107f, 
    0.04057451f, 0.03822424f, 0.01085527f, -0.02146656f, -0.01244576f, -0.06196920f, 0.06129019f, -0.10101031f, 
    -0.00359960f, -0.15581134f, 0.17991824f, 0.03720718f, 0.17445207f, -0.26227075f, -0.33257505f, -0.01571896f, 
    -0.07466773f, 0.02463717f, 0.07843289f, -0.02852495f, 0.10196925f, 0.16297282f, 0.00304893f, -0.03487228f, 
    0.03926412f, -0.22011681f, -0.19355887f, 0.24875930f, -0.00830863f, 0.12998852f, 0.03505516f, -0.05466314f, 
    -0.05940599f, 0.00844457f, 0.05267426f, 0.00231697f, 0.10694321f, 0.01858381f, -0.04470302f, -0.05917447f, 
    -0.08154697f, 0.10850371f, -0.02997492f, -0.02461675f, 0.01318943f, 0.07278810f, 0.12990843f, 0.08295982f, 
    -0.21371455f, -0.19425620f, 0.00127095f, -0.00382631f, -0.01738837f, 0.05053180f, 0.01281585f, -0.02214987f, 
    -0.10562140f, -0.22593686f, 0.37983656f, -0.29302517f, 0.06834713f, 0.04330369f, 0.02885620f, 0.08830963f, 
    -0.05696521f, -0.03656777f, 0.06903597f, -0.01504426f, -0.05788518f, 0.03904271f, -0.02847336f, -0.07648951f, 
    -0.11753739f, -0.02349938f, -0.05004377f, 0.07167121f, -0.09724857f, -0.11701768f, 0.05127453f, -0.09170024f, 
    -0.07557025f, -0.08232983f, 0.10750177f, -0.14986497f, -0.27339283f, -0.01613633f, -0.12338050f, 0.07332803f, 
    -0.07850033f, -0.05760809f, 0.02195141f, -0.01052675f, -0.02109964f, -0.20996368f, -0.13517950f, -0.02289930f, 
    0.10573748f, -0.09206191f, 0.14909691f, 0.09234301f, -0.15463854f, 0.04179003f, 0.17494495f, 0.36816755f, 
    0.33574638f, 0.05476020f, -0.02902960f, -0.23084633f, 0.06677248f, 0.02319218f, 0.11385151f, 0.00749159f, 
    0.05822780f, -0.21473262f, -0.04238225f, 0.11360032f, 0.03992007f, -0.12655506f, 0.12657963f, -0.05561483f, 
    0.02531295f, 0.34910730f, 0.06503793f, 0.18042547f, -0.02160310f, 0.00625531f, -0.09135097f, 0.07289842f, 
    0.02088737f, 0.10093524f, 0.11859637f, 0.05762691f, -0.11337946f, 0.03061114f, -0.21411525f, -0.08768900f, 
    -0.12709707f, 0.02390642f, -0.15361497f, 0.20844308f, 0.00437038f, -0.01279642f, 0.07545589f, -0.00924553f, 
    -0.13605615f, -0.08572215f, -0.18275505f, -0.19422786f, 0.03725159f, 0.02825744f, 0.11412627f, -0.00617980f, 
    -0.06068210f, 0.09857992f, 0.19284083f, -0.06037007f, -0.10958155f, 0.35357705f, 0.46032450f, 0.05414372f, 
    0.11948600f, 0.08631170f, -0.12749824f, 0.03088243f, -0.03044921f, -0.04618019f, -0.12549265f, -0.03008198f, 
    -0.07758490f, 0.01833992f, 0.05107744f, -0.01090360f, 0.08583399f, 0.08153410f, 0.04107546f, 0.18924369f, 
    -0.21540818f, -0.22353017f, -0.00672730f, 0.06988207f, -0.20955372f, -0.04626161f, -0.07959343f, -0.22093169f, 
    0.10835949f, 0.15912929f, 0.09210423f, 0.04207385f, 0.01451833f, 0.08513104f, 0.07403179f, 0.11185101f, 
    0.03922815f, 0.46036470f, 0.30164674f, 0.12571208f, -0.01756416f, 0.03596812f, 0.05907935f, -0.08967870f, 
    -0.03422331f, -0.05520125f, -0.11391939f, -0.13789105f, -0.08563659f, 0.05487371f, 0.05458255f, 0.20162223f, 
    -0.01451501f, 0.08188020f, 0.23792300f, -0.08897043f, 0.03854225f, 0.00997637f, -0.10017134f, -0.06274415f, 
    -0.09863593f, -0.05572261f, -0.00382799f, -0.17458887f, 0.02667231f, 0.00236802f, 0.11564895f, 0.03242907f, 
    -0.00506402f, -0.03956920f, 0.26701394f, 0.11712591f, 0.01367051f, 0.20968536f, 0.09810430f, 0.04542032f, 
    -0.04588904f, -0.19569398f, -0.11308642f, 0.04291062f, 0.01013951f, 0.01010296f, 0.30480248f, 0.13611645f, 
    -0.10166811f, -0.04004456f, -0.08062860f, 0.06920733f, -0.07623214f, 0.03127600f, -0.12364230f, -0.14092726f, 
    -0.01119968f, 0.04586631f, 0.15503894f, 0.02415323f, 0.16717355f, -0.13876630f, 0.05354934f, -0.13356327f, 
    -0.25584245f, 0.00069855f, -0.09306189f, 0.05974230f, 0.18027067f, -0.02070281f, -0.04670535f, 0.03250627f, 
    0.11268777f, 0.20575413f, -0.00778391f, 0.11897769f, 0.15469068f, -0.04892327f, -0.08040587f, 0.09197552f, 
    -0.02910325f, -0.05725719f, -0.50643092f, -0.15061119f, 0.10755401f, 0.07106500f, 0.01986891f, -0.05519744f, 
    0.17134513f, 0.00774536f, 0.01718868f, -0.17117190f, 0.10432039f, -0.02207422f, -0.11334683f, 0.07916859f, 
    -0.04578329f, -0.10851189f, -0.10930103f, 0.00086483f, -0.25680679f, -0.06448810f, 0.06086098f, 0.12844855f, 
    0.08254221f, 0.07173409f, -0.05482940f, -0.10495940f, 0.10746782f, -0.03727516f, 0.17977607f, 0.09813697f, 
    -0.02878574f, -0.12523310f, -0.07769931f, -0.07471813f, 0.10045990f, -0.01645737f, -0.08061112f, 0.20104997f, 
    0.10159844f, 0.13894859f, 0.00252937f, -0.16525289f, 0.00693538f, 0.10455161f, 0.04656034f, 0.06880706f, 
    -0.04546192f, -0.22652414f, 0.01388605f, 0.01706295f, 0.04983850f, 0.00382256f, 0.03803318f, -0.05402241f, 
    0.22635812f, 0.07401816f, 0.05867887f, -0.05225932f, 0.00628156f, -0.21940875f, -0.03653250f, -0.03782695f, 
    -0.02355476f, 0.11412721f, 0.12492209f, -0.10369310f, 0.01418853f, -0.10201473f, -0.08287152f, -0.10796273f, 
    0.04237659f, -0.12543505f, 0.22797424f, -0.04035642f, -0.08398553f, -0.12990554f, 0.05121730f, 0.17906195f, 
    -0.10117712f, 0.11269341f, -0.12733714f, -0.12444036f, 0.05995108f, 0.05254047f, 0.10435563f, 0.05089331f, 
    -0.10099838f, -0.03775195f, 0.00583453f, 0.14669922f, 0.13525091f, 0.11258820f, -0.16807497f, 0.06425352f, 
    0.00871632f, 0.01573851f, -0.04141276f, -0.01751599f, -0.08569630f, -0.10337904f, 0.02147941f, 0.21448149f, 
    -0.00199283f, 0.07277546f, 0.03693899f, 0.04454848f, -0.07356711f, 0.05238516f, -0.07957389f, 0.05748395f, 
    0.04761339f, 0.02526177f, -0.05941309f, -0.00161390f, 0.06498262f, 0.06460964f, 0.05134315f, 0.04443833f, 
    0.04086692f, 0.05102259f, 0.14516386f, 0.09473889f, -0.09188548f, 0.23121516f, 0.08210711f, 0.08893231f, 
    -0.11557468f, -0.03830943f, 0.15091334f, -0.07910110f, 0.03726310f, -0.02918939f, -0.00426226f, -0.01133579f, 
    -0.03126345f, 0.11399928f, -0.00234433f, 0.07313000f, 0.03824057f, 0.09351490f, -0.06379586f, -0.08556535f, 
    0.03787279f, -0.04211511f, -0.32712457f, -0.03013362f, 0.02176012f, -0.11518998f, 0.17294815f, -0.07438987f, 
    -0.00771921f, -0.04895532f, -0.03824877f, 0.16998266f, -0.03179958f, 0.07555193f, -0.00719485f, 0.13730486f, 
    0.01170105f, 0.10946725f, 0.09030690f, -0.09608728f, 0.20204034f, 0.10676791f, 0.06210730f, -0.04394104f, 
    0.09305552f, 0.02940981f, -0.11077195f, 0.00409435f, -0.10682213f, 0.10680927f, 0.06062898f, 0.18130539f, 
    0.03203135f, 0.05055231f, -0.08149199f, 0.11717419f, -0.19067447f, 0.03530264f, 0.14959009f, 0.21504056f, 
    0.08544496f, -0.06899719f, -0.12332864f, -0.07398417f, -0.05878722f, -0.03725626f, -0.03716331f, 0.10282818f, 
    0.10713322f, 0.11721136f, 0.01944284f, 0.08792568f, -0.08605064f, -0.12944719f, 0.18872294f, 0.06043395f, 
    0.05021610f, -0.02968105f, -0.01180654f, -0.02630686f, 0.05150650f, 0.00201277f, -0.02053901f, -0.06919795f, 
    -0.12091813f, 0.09910662f, 0.04781194f, 0.07788070f, 0.09579558f, -0.00685008f, -0.09704128f, 0.09562167f, 
    0.02893051f, 0.02746769f, 0.06624471f, 0.03956459f, 0.08348822f, 0.13232087f, -0.07558852f, 0.03820253f, 
    -0.02804637f, 0.05381651f, 0.06141581f, -0.01832991f, 0.07859630f, -0.19706757f, 0.09195723f, 0.07878873f, 
    0.04349566f, -0.01943061f, -0.09206061f, 0.00826486f, -0.19458802f, 0.12767746f, 0.07575620f, -0.14985082f, 
    0.05028211f, -0.20202988f, -0.21351229f, -0.14195926f, -0.21759580f, 0.02062019f, -0.10652327f, 0.11477083f, 
    -0.00080812f, -0.04141729f, 0.16832790f, -0.00487041f, -0.06977681f, 0.03972247f, 0.21283944f, -0.11497350f, 
    -0.04233800f, 0.14693126f, -0.19225670f, 0.12572111f, 0.01966794f, -0.01324105f, 0.00666300f, 0.04219157f, 
    0.03741421f, -0.16698071f, -0.00776810f, 0.02709067f, 0.00853372f, -0.07511514f, 0.08282008f, -0.10727363f, 
    -0.00092712f, 0.01993292f, 0.00860752f, -0.06000251f, 0.01912360f, -0.03578255f, 0.00037428f, 0.01686759f, 
    0.04962018f, 0.03213570f, -0.00175499f, -0.05141663f, 0.05034925f, 0.03343368f, -0.01305613f, -0.03527174f, 
    -0.00602735f, -0.00769757f, 0.05589911f, 0.03056200f, 0.03638742f, -0.03569926f, 0.02177473f, -0.06320328f, 
    -0.04118749f, -0.02566678f, -0.02800988f, 0.04595770f, 0.00057061f, 0.02422985f, -0.01750784f, -0.04361189f, 
    0.04423796f, -0.06421749f, -0.00581188f, -0.01075700f, -0.06353226f, 0.02813648f, -0.03861652f, 0.05144559f, 
    0.05113747f, -0.03935637f, 0.04102282f, -0.06283537f, -0.01126119f, 0.00493157f, -0.02134416f, -0.06370208f, 
    0.00424261f, -0.04737984f, -0.04575949f, 0.05047558f, -0.05369264f, -0.03386763f, -0.01359264f, 0.02128593f, 
    0.03094874f, 0.00382219f, -0.03935048f, 0.02601826f, 0.03469605f, -0.00751402f, 0.00852945f, 0.03966886f, 
    -0.05128571f, -0.00337081f, -0.04762454f, 0.04696041f, -0.01948925f, 0.01532988f, 0.00411584f, -0.02244836f, 
    0.03736779f, -0.00585135f, -0.03239903f, -0.01928384f, 0.02231987f, 0.02044372f, 0.05894514f, 0.02386857f, 
    -0.05813587f, -0.04985312f, -0.02236471f, 0.05086766f, -0.04884872f, 0.05286722f, -0.01470128f, -0.02338620f, 
    0.02607372f, 0.00488406f, 0.02518702f, 0.00674431f, 0.02968180f, -0.00660537f, 0.06089120f, -0.03432387f, 
    0.01885446f, -0.01489800f, -0.01728888f, 0.02480641f, -0.05357612f, 0.01598938f, -0.02251228f, -0.00246249f, 
    0.02064297f, -0.02687300f, 0.01213458f, -0.00473167f, -0.05851837f, -0.02375762f, -0.03875223f, -0.00671771f, 
    -0.00113866f, -0.03930635f, 0.02981808f, 0.00152944f, 0.01343271f, -0.02878218f, 0.04378767f, -0.03260176f, 
    -0.04377884f, -0.03100892f, 0.04511432f, 0.01146622f, -0.04761949f, 0.01520360f, -0.05599183f, 0.02966274f, 
    0.01629209f, -0.03909048f, -0.01728357f, -0.00235021f, -0.03163895f, 0.01427797f, -0.05227617f, 0.04071629f, 
    -0.05771834f, -0.01781594f, 0.05888761f, -0.05026970f, -0.05967309f, 0.00435932f, 0.03909884f, 0.01917799f, 
    -0.02001583f, -0.03005720f, 0.03731205f, -0.01412114f, 0.00263991f, -0.01111235f, -0.05678727f, -0.06452125f, 
    0.01453881f, -0.01060993f, -0.03997230f, -0.05697232f, -0.05878866f, 0.00077987f, 0.03873939f, -0.01454073f, 
    -0.01303907f, 0.01226588f, -0.02251116f, 0.04085384f, -0.05887911f, 0.03496676f, 0.01890861f, 0.03553759f, 
    -0.03770540f, -0.03226548f, -0.03656620f, 0.00595175f, -0.03268272f, -0.03310483f, 0.03811399f, 0.01984027f, 
    0.03289979f, -0.00193358f, -0.01340833f, 0.01456423f, -0.01427777f, 0.05760050f, 0.03623283f, -0.01705917f, 
    0.03814980f, -0.02312792f, -0.00660038f, -0.03195258f, -0.00185736f, -0.05561487f, -0.05232736f, -0.00528682f, 
    0.00651986f, -0.05975093f, -0.03914734f, -0.04216104f, -0.04764584f, 0.03621781f, 0.03599454f, 0.04449814f, 
    -0.00686363f, 0.05349662f, -0.01808811f, -0.04801098f, -0.00169260f, -0.04267087f, -0.04232458f, -0.01247524f, 
    -0.03250744f, 0.05094247f, -0.02887141f, -0.03828038f, -0.03785121f, -0.06358423f, 0.06475314f, 0.04171212f, 
    0.01677863f, 0.02621503f, -0.02804560f, -0.03250986f, 0.01007098f, -0.02146214f, -0.02329675f, -0.00507303f, 
    -0.05384972f, -0.03981432f, -0.04679370f, -0.00499279f, -0.05702200f, -0.04333547f, -0.03131793f, -0.03093744f, 
    0.02354844f, -0.02900269f, 0.03546990f, 0.01232659f, 0.02205050f, -0.04122186f, 0.03228260f, -0.00806964f, 
    -0.03600012f, -0.03683454f, -0.02124532f, 0.03835123f, 0.01856425f, -0.06421157f, 0.00247885f, 0.01820215f, 
    -0.00117801f, -0.04335539f, 0.03722510f, -0.04053505f, -0.04025048f, -0.02858070f, 0.01958014f, -0.00246752f, 
    0.04982464f, -0.04888225f, -0.04571331f, -0.06145125f, -0.00636294f, 0.00313676f, -0.05799034f, -0.03713545f, 
    -0.02114896f, 0.03591398f, 0.03030154f, -0.04304111f, -0.05769970f, -0.02717005f, 0.00688404f, 0.00757041f, 
    -0.05899529f, -0.02305271f, 0.01036396f, 0.00579652f, -0.04226179f, 0.01235959f, -0.04723372f, 0.02835752f, 
    0.02929003f, 0.00638759f, 0.05010442f, -0.01562348f, -0.06289545f, 0.04874825f, -0.04270786f, 0.03890858f, 
    0.12451480f, 0.21389006f, 0.10640448f, 0.04484365f, -0.07971343f, -0.04447444f, -0.07872015f, 0.06278407f, 
    -0.06043031f, 0.09983166f, -0.09620395f, 0.00330460f, 0.01778578f, -0.07887063f, -0.14749976f, 0.12714702f, 
    0.05345028f, 0.11328185f, -0.44230190f, -0.28726754f, -0.45953655f, -0.20779867f, -0.12968077f, -0.10368569f, 
    -0.09410792f, 0.00472419f, -0.08348749f, -0.07171308f, 0.09074613f, 0.27654517f, 0.00063112f, 0.07208191f, 
    0.08436639f, 0.13786054f, 0.09981374f, 0.06274870f, -0.19550279f, -0.04780392f, 0.34559685f, -0.01122850f, 
    0.00986262f, -0.04292980f, 0.27848986f, 0.06709286f, 0.04940192f, -0.23461716f, -0.05845399f, -0.14986542f, 
    -0.11764425f, -0.01452776f, -0.10483796f, 0.17873335f, 0.09082290f, -0.03413402f, -0.64278901f, -0.30803955f, 
    0.20110121f, -0.16994739f, 0.13135217f, -0.06957468f, 0.14082488f, 0.00117049f, -0.14085373f, 0.09593884f, 
    0.12737916f, 0.20813259f, 0.09878974f, 0.11798566f, -0.09324031f, -0.01583892f, 0.08565611f, -0.01798257f, 
    -0.05446584f, -0.13172841f, 0.00523861f, -0.13239278f, -0.02536912f, 0.06817171f, 0.12615909f, 0.16435002f, 
    0.00691465f, 0.08680999f, -0.05726120f, -0.05852894f, -0.09643696f, -0.05551467f, -0.13222605f, 0.06385954f, 
    0.00851838f, 0.02900763f, -0.70443338f, -0.46257785f, -0.03147149f, 0.01175408f, -0.09108584f, -0.10736840f, 
    0.07820409f, 0.10114398f, 0.05424833f, -0.03649243f, 0.13168818f, 0.22959094f, 0.01209487f, -0.05335040f, 
    0.03361975f, 0.09238192f, -0.04968958f, 0.09774923f, 0.04912958f, -0.10022330f, 0.14001904f, -0.06830774f, 
    -0.03106345f, -0.09177935f, -0.05737343f, -0.07413434f, 0.08761538f, -0.04659124f, 0.11792896f, -0.00456329f, 
    -0.08252794f, 0.12409239f, 0.00237247f, 0.14668019f, -0.09419059f, -0.01522557f, -0.04792499f, -0.21727486f, 
    -0.08350822f, -0.07192774f, -0.04144200f, -0.04464575f, 0.06509820f, -0.03282030f, 0.10481006f, -0.11553010f, 
    -0.45662367f, 0.06545570f, -0.06193306f, -0.00894147f, -0.07300281f, 0.10429277f, -0.06971010f, 0.11103509f, 
    -0.07441042f, -0.29388970f, 0.27234700f, -0.19358751f, 0.00951561f, 0.10045978f, 0.16949730f, 0.01144210f, 
    0.19378881f, -0.04915207f, -0.02553977f, 0.17369218f, 0.08048862f, 0.01519123f, -0.03276360f, 0.13737985f, 
    0.13818651f, 0.07504723f, 0.08203113f, 0.18431705f, 0.16447304f, -0.01979144f, 0.06204141f, -0.01791297f, 
    -0.01935295f, -0.02047361f, -0.06239171f, -0.46901944f, 0.06888163f, 0.10899930f, 0.02676375f, -0.05069934f, 
    0.08162788f, -0.02531817f, 0.28460473f, 0.00160095f, 0.04024957f, -0.09394705f, -0.01575244f, 0.05181488f, 
    -0.06889355f, -0.01233706f, 0.14001484f, 0.04940370f, 0.06054687f, 0.03896216f, -0.47858968f, -0.28891397f, 
    0.11939394f, 0.05026218f, 0.01142601f, -0.04620404f, -0.10074967f, 0.04835280f, 0.17353398f, 0.08759242f, 
    0.15479992f, -0.09566942f, -0.17103508f, -0.11742065f, 0.12816656f, 0.04743325f, 0.06818078f, -0.52832699f, 
    -0.53963298f, -0.08265794f, -0.09136104f, 0.04924443f, -0.13676535f, 0.15618117f, -0.05168973f, 0.07989007f, 
    0.00588702f, -0.03883280f, -0.03915073f, 0.06679105f, 0.00524030f, 0.09315420f, 0.02457138f, -0.01290389f, 
    0.09015519f, -0.36738724f, -0.54167390f, -0.20649424f, 0.03726686f, 0.08805204f, 0.05661171f, 0.01432546f, 
    -0.06938738f, -0.01186633f, -0.00350845f, -0.10010876f, -0.03745282f, 0.02517703f, -0.03299756f, 0.08191442f, 
    0.20318337f, -0.02980510f, -0.01531032f, -0.01467309f, 0.13352658f, 0.02991317f, -0.11666242f, 0.01197284f, 
    0.03087111f, -0.04178524f, 0.12962127f, -0.03068651f, -0.10513099f, -0.20118967f, 0.05560050f, 0.00832381f, 
    0.10490850f, -0.07993659f, -0.02708110f, 0.03187756f, -0.04820494f, -0.19135521f, -0.28380504f, -0.08467260f, 
    -0.07392761f, 0.01428131f, -0.05507566f, 0.07308041f, 0.11941870f, 0.12167327f, 0.09619177f, -0.05578774f, 
    -0.38288519f, 0.07346328f, -0.07335585f, 0.19825685f, 0.07543167f, -0.04624517f, -0.07792827f, -0.00129479f, 
    -0.01058106f, 0.06135672f, -0.09034183f, 0.11863837f, -0.02088573f, -0.03667454f, 0.05659116f, 0.09584372f, 
    0.14853698f, 0.03646732f, -0.25449648f, -0.03517539f, 0.12478339f, 0.18534295f, 0.08867934f, 0.08938366f, 
    0.12546499f, -0.25196066f, -0.25314113f, 0.06415799f, 0.01161179f, 0.11255753f, 0.01896517f, -0.08992087f, 
    -0.04884093f, -0.15412693f, -0.05328486f, -0.16023819f, -0.00446712f, 0.03008723f, 0.00421536f, -0.06707997f, 
    -0.08052845f, -0.02815002f, 0.00609815f, 0.15912533f, 0.06870393f, -0.05774361f, -0.03151003f, 0.03154451f, 
    0.00223271f, 0.04593068f, -0.00918444f, -0.12564474f, 0.14158204f, -0.04451200f, 0.03239968f, -0.01273909f, 
    0.11084152f, 0.01798442f, 0.03965882f, -0.13054800f, 0.02634833f, 0.02364302f, 0.10049127f, 0.03902261f, 
    0.08041339f, 0.12041239f, 0.08747078f, -0.08412226f, -0.08014841f, -0.12577491f, -0.22804873f, -0.10049072f, 
    0.12923983f, 0.09678790f, 0.03399495f, 0.14081414f, -0.09924008f, 0.21332428f, -0.06355733f, 0.10591444f, 
    0.15946627f, 0.10964663f, -0.05948205f, -0.03076906f, -0.07599022f, -0.02882042f, 0.11462136f, -0.02050743f, 
    -0.11212791f, -0.16100836f, -0.02272210f, 0.06370394f, 0.08690435f, 0.14828245f, 0.09300959f, -0.07683019f, 
    0.09808272f, -0.08185062f, 0.02865117f, 0.14563878f, 0.00766142f, -0.01151568f, -0.05675685f, -0.00128297f, 
    0.08834653f, 0.13678823f, 0.17345372f, 0.20197234f, 0.15363583f, 0.08606070f, -0.02689471f, 0.06813622f, 
    0.10060365f, -0.01615993f, 0.03818067f, 0.00836345f, -0.00079370f, -0.23298416f, -0.08269636f, 0.02474708f, 
    0.04238801f, 0.06659222f, 0.00068346f, 0.00239513f, 0.04627524f, 0.01103172f, -0.07720623f, -0.18185151f, 
    0.19303277f, -0.02519881f, 0.15215628f, 0.22940484f, 0.09322740f, 0.15898550f, -0.01755434f, -0.13627635f, 
    -0.14627233f, 0.10354627f, -0.06380253f, -0.00492018f, 0.06111610f, 0.07532225f, 0.05181810f, 0.10555838f, 
    0.01020272f, 0.06100316f, -0.06914376f, -0.20789425f, -0.14730409f, -0.04249432f, -0.15377294f, -0.32524875f, 
    -0.30106166f, -0.10076286f, -0.08752722f, -0.00117046f, -0.09963856f, -0.10448898f, -0.24568635f, -0.09379870f, 
    0.07919651f, 0.06506005f, -0.02701353f, 0.01999089f, 0.29449365f, 0.02728135f, 0.02833987f, 0.29492351f, 
    0.05007489f, -0.06956538f, -0.07005151f, 0.13422897f, 0.10802766f, 0.02231674f, 0.08622535f, -0.11422237f, 
    -0.04170603f, -0.02864506f, -0.07074796f, 0.07706726f, -0.16570981f, 0.08668370f, 0.16080262f, 0.01611843f, 
    0.10184491f, 0.13236958f, -0.01935760f, -0.08379304f, -0.13689560f, -0.22252853f, 0.12216882f, 0.09570069f, 
    0.02607463f, 0.01960550f, -0.05415419f, 0.04180438f, -0.09756218f, -0.12920368f, -0.11700354f, -0.06912500f, 
    0.01866934f, -0.02961477f, 0.03583593f, 0.00006446f, 0.12073776f, -0.33762044f, 0.06127964f, -0.24882109f, 
    -0.05724225f, 0.08223585f, 0.08529003f, -0.05525488f, 0.19347036f, 0.12932374f, -0.11792024f, -0.04484008f, 
    0.09483956f, 0.06321647f, 0.02265298f, 0.03319963f, -0.20628101f, -0.03210186f, -0.00135807f, -0.10476784f, 
    -0.13309358f, -0.06370950f, 0.00829479f, 0.19360493f, 0.01345459f, 0.08812442f, -0.02874038f, -0.25328201f, 
    -0.04457360f, 0.03717817f, -0.05782525f, -0.02388943f, -0.01158056f, 0.12084874f, 0.18806334f, 0.02928571f, 
    0.20135523f, -0.28290817f, -0.20449278f, 0.00091089f, -0.02425852f, 0.02243684f, 0.04724271f, -0.15968014f, 
    -0.04233545f, -0.02070640f, 0.19500718f, -0.08115362f, -0.18360545f, -0.13937093f, 0.13643669f, -0.19302830f, 
    -0.01320588f, 0.12385380f, -0.23100749f, 0.06190545f, -0.03275731f, -0.02689055f, -0.19808351f, 0.01436183f, 
    0.10272711f, 0.13471930f, -0.01364963f, 0.21974914f, 0.11744504f, 0.13098417f, 0.03746913f, 0.14071368f, 
    0.16878261f, 0.22793309f, 0.08999925f, 0.29510528f, 0.27665508f, -0.06508036f, 0.06181283f, 0.03222416f, 
    0.07490893f, 0.00102843f, 0.06700394f, -0.07449207f, 0.10923106f, 0.09100902f, -0.33257154f, 0.02985587f, 
    0.22084306f, 0.04994139f, -0.01745124f, 0.11044674f, 0.04098035f, 0.01623843f, 0.06008347f, -0.04958513f, 
    -0.00755152f, 0.08596073f, 0.04765954f, -0.02148187f, -0.06490028f, 0.10289820f, 0.14323862f, 0.04711333f, 
    -0.23827049f, -0.24152747f, -0.03367939f, 0.00914849f, -0.03874911f, -0.03654435f, -0.06501804f, -0.10075173f, 
    -0.09536842f, 0.15734802f, 0.08716263f, 0.11122487f, -0.03233547f, -0.02368297f, -0.05287908f, -0.00040680f, 
    -0.09672796f, -0.00017744f, -0.63081092f, -0.51870674f, -0.14834826f, -0.01630513f, 0.02192731f, -0.09162026f, 
    0.12687922f, 0.05656177f, -0.07041425f, -0.00170409f, -0.14666544f, -0.21144913f, 0.06155565f, 0.03034353f, 
    -0.14571954f, -0.07627030f, 0.06432630f, 0.03861473f, 0.03699352f, -0.10546032f, -0.01518929f, -0.00768179f, 
    -0.06846803f, -0.18666881f, -0.00752406f, -0.04126516f, 0.09946579f, 0.08058662f, 0.04181422f, 0.05322647f, 
    -0.02292722f, 0.08093698f, -0.11490296f, 0.07967795f, 0.02180943f, -0.05096158f, -0.00230557f, 0.02856726f, 
    0.11563089f, -0.07568900f, -0.08710986f, 0.06380457f, 0.02545214f, 0.06190030f, 0.00855733f, 0.56372637f, 
    -0.07004011f, -0.42658803f, -0.01616132f, 0.16703093f, 0.03154996f, 0.08137745f, -0.10054430f, 0.00259538f, 
    -0.00059931f, 0.09515049f, -0.02262901f, -0.12597719f, -0.05540904f, 0.05055970f, 0.06152880f, -0.01086660f, 
    -0.01256503f, 0.24244735f, 0.21991014f, -0.04770910f, -0.11707081f, 0.06233573f, 0.01390390f, 0.13977140f, 
    0.07749902f, -0.02855117f, -0.00601218f, -0.29819062f, -0.65721089f, -0.02064485f, 0.07573581f, 0.17924315f, 
    0.04902489f, 0.17776415f, -0.15368411f, 0.24571034f, -0.08378074f, -0.24601163f, -0.13918075f, 0.00296897f, 
    -0.09752274f, -0.00231670f, -0.04238942f, 0.01357596f, 0.01314638f, 0.08630145f, 0.20439452f, 0.17245924f, 
    -0.13408305f, 0.05653941f, 0.08819781f, 0.06175675f, 0.04949258f, 0.23000748f, 0.08939867f, -0.15402435f, 
    -0.15517445f, 0.00118153f, 0.04131807f, 0.02703417f, -0.16933101f, 0.04819422f, 0.18338273f, -0.08137767f, 
    -0.28578186f, -0.15225543f, -0.03953449f, -0.04123339f, 0.01862429f, 0.06261349f, -0.01326956f, 0.02519235f, 
    0.03131733f, -0.05941354f, -0.00631007f, -0.01514135f, -0.07855463f, -0.01322684f, -0.09155642f, -0.04677622f, 
    -0.38122347f, -0.21625975f, 0.31336558f, 0.08873709f, 0.01881213f, 0.10307735f, -0.09744235f, 0.07773993f, 
    0.07584994f, 0.05226758f, 0.01165191f, 0.09200279f, 0.02563357f, 0.00678959f, 0.04282890f, -0.01387942f, 
    0.00095515f, 0.03860544f, 0.44993019f, 0.40733722f, 0.23153616f, -0.04393655f, 0.02157668f, -0.10212552f, 
    -0.08024779f, 0.00253123f, -0.09354719f, 0.03417376f, 0.01744775f, 0.19054992f, -0.04667907f, -0.09510282f, 
    -0.20284903f, -0.03037905f, -0.03694506f, 0.03722208f, 0.00381332f, -0.08137804f, 0.01176317f, -0.14122172f, 
    -0.08876663f, -0.12489023f, 0.08484112f, 0.03290744f, 0.15067168f, -0.50407284f, -0.09279232f, 0.13869578f, 
    0.01414180f, -0.03057091f, -0.00920759f, 0.04504806f, 0.00602953f, 0.14577676f, 0.17206748f, 0.03110156f, 
    0.04423289f, -0.43581703f, -0.25824228f, -0.26557231f, -0.01333102f, -0.04962207f, -0.10654389f, 0.02826902f, 
    0.03554659f, 0.20301118f, 0.00463533f, 0.20442306f, -0.09928882f, 0.04789770f, -0.04279630f, 0.01608372f, 
    -0.07097623f, -0.05516668f, 0.12498980f, 0.07943217f, -0.01463814f, 0.03024225f, 0.04870508f, 0.00736668f, 
    0.14475432f, 0.03191540f, -0.13047619f, 0.00934531f, -0.00395426f, -0.15389293f, -0.02018527f, -0.07086155f, 
    -0.03668666f, 0.00235171f, -0.13079074f, -0.20883125f, -0.01851508f, -0.01284757f, -0.26638550f, 0.11694937f, 
    -0.02703179f, 0.12445156f, -0.07568216f, -0.20817132f, -0.29865718f, -0.26833180f, 0.15305777f, 0.08660725f, 
    0.08954156f, 0.01947247f, 0.00334292f, 0.08375387f, 0.01149167f, 0.11422098f, 0.16118824f, -0.04748609f, 
    0.04640403f, 0.16919319f, -0.10752413f, 0.16522206f, 0.05157382f, 0.00129269f, 0.07284064f, 0.11061502f, 
    0.07828017f, 0.01162727f, 0.12927461f, 0.05156131f, 0.10293490f, -0.09517118f, -0.07069342f, 0.07425544f, 
    0.08621610f, 0.07716537f, -0.05239958f, 0.15833291f, -0.00635154f, 0.06909313f, 0.01348468f, 0.28999531f, 
    0.14689477f, -0.15876266f, 0.02168777f, 0.04251371f, -0.01092237f, 0.15477216f, -0.05341596f, -0.02075419f, 
    0.00265598f, 0.02731391f, -0.03894033f, -0.05479841f, -0.03901141f, 0.00027628f, -0.02937636f, 0.03652151f, 
    -0.04789707f, 0.03271336f, 0.03945814f, 0.04958981f, -0.06070710f, -0.04689872f, -0.06364219f, -0.02540812f, 
    0.03675869f, 0.00177054f, -0.01862353f, -0.00725208f, -0.03550030f, -0.04488359f, -0.00032192f, 0.01079814f, 
    0.02118201f, -0.00253131f, -0.03641570f, 0.01050038f, 0.00866158f, -0.00815248f, 0.00946279f, -0.00258812f, 
    -0.06635152f, 0.01171168f, -0.01877345f, -0.03891664f, -0.06419043f, 0.03751516f, -0.02439960f, -0.04992811f, 
    -0.00201212f, 0.01771731f, -0.01638474f, 0.02894093f, -0.04700303f, -0.02499194f, -0.06076366f, -0.04164379f, 
    -0.05754036f, -0.03627564f, 0.03830073f, -0.03418443f, 0.02142465f, 0.00155947f, -0.01929660f, -0.06297086f, 
    0.04660081f, -0.05000675f, 0.00140671f, 0.01752015f, -0.01231925f, 0.03951254f, -0.03662679f, -0.03422852f, 
    0.04481164f, -0.01034418f, -0.00678585f, 0.00913263f, 0.03772495f, 0.00477229f, -0.05268311f, -0.06595244f, 
    -0.04350920f, -0.02378410f, -0.00192483f, 0.00537092f, 0.02857553f, -0.04593697f, 0.01204485f, -0.03012882f, 
    0.04874411f, 0.03579155f, -0.03560814f, -0.02270039f, 0.03518594f, -0.02569073f, -0.01547178f, -0.03935143f, 
    0.02118568f, 0.00051190f, 0.00938852f, -0.05124711f, 0.00420538f, -0.03455998f, -0.02269226f, -0.02575284f, 
    0.03199675f, -0.03959538f, -0.00791080f, 0.00050969f, -0.00491725f, 0.01991320f, -0.02604183f, 0.04895913f, 
    0.02605579f, 0.02399592f, -0.06195525f, 0.05152047f, 0.02798502f, 0.03420985f, 0.01294354f, 0.02244949f, 
    -0.00505561f, -0.05370295f, -0.02169507f, -0.05095930f, -0.00749652f, -0.06867974f, -0.04320593f, -0.00379390f, 
    0.01399600f, -0.01422011f, -0.02699905f, -0.06174877f, -0.02768605f, -0.02928252f, -0.03059254f, 0.00852562f, 
    0.02645074f, -0.01882275f, -0.01028743f, 0.03453479f, 0.02264475f, -0.04836584f, -0.01570033f, -0.02821427f, 
    -0.00077241f, -0.04596734f, 0.04319010f, 0.03937282f, -0.02548646f, -0.03530173f, -0.02099955f, 0.04900096f, 
    -0.06402553f, 0.03444162f, -0.02429797f, -0.06832905f, -0.03497091f, -0.05486434f, -0.05827032f, 0.01608042f, 
    0.04224880f, -0.02755397f, 0.02785823f, -0.02521152f, 0.02839826f, 0.01935704f, 0.01634066f, -0.04168025f, 
    -0.01221587f, 0.00743772f, 0.01462698f, -0.03920518f, -0.00076317f, 0.02402693f, 0.02715747f, 0.03798692f, 
    -0.01463427f, 0.02584518f, -0.05392170f, -0.05583122f, -0.02585931f, 0.01686349f, 0.04163533f, -0.02124469f, 
    -0.05410745f, -0.03108658f, -0.02253434f, 0.03169261f, -0.00688666f, -0.02441308f, -0.02698076f, 0.02362427f, 
    0.05764651f, -0.04034653f, 0.01519999f, -0.03135945f, -0.02155543f, 0.03144224f, -0.03175760f, -0.05298142f, 
    -0.05718045f, -0.05296014f, -0.05985708f, -0.00951238f, -0.00376081f, 0.02960926f, -0.02000299f, -0.05552168f, 
    -0.01645934f, 0.04387280f, -0.05804206f, -0.02002974f, 0.00777822f, -0.00253813f, 0.04910199f, 0.04524990f, 
    0.05164505f, -0.01699653f, 0.03424779f, 0.04534458f, -0.04414748f, 0.03223264f, -0.03865583f, 0.05437889f, 
    0.01478583f, -0.06308838f, -0.01952665f, 0.03818354f, 0.03426434f, -0.05002915f, -0.06774522f, -0.06243669f, 
    -0.05791596f, -0.01263481f, -0.05058096f, 0.00981798f, -0.02339854f, -0.03268542f, -0.06517020f, 0.04286731f, 
    0.03389360f, -0.04114345f, -0.05767987f, -0.02831663f, -0.05352838f, 0.04787794f, -0.05018868f, -0.00907665f, 
    -0.03438947f, 0.03962254f, 0.04604195f, -0.03763438f, 0.04800943f, 0.04757288f, 0.01363258f, -0.01453740f, 
    -0.02026469f, -0.00375330f, -0.03204762f, -0.00319714f, -0.04620789f, -0.03631108f, -0.05678551f, 0.04665494f, 
    -0.03198766f, -0.01585241f, 0.00870971f, 0.01157471f, -0.04511490f, 0.00795066f, -0.03922346f, -0.03044333f, 
    0.02257630f, -0.06043215f, -0.00700260f, -0.05725438f, -0.04903539f, 0.04122930f, 0.02666894f, 0.02813579f, 
    -0.05131961f, 0.02690679f, -0.01790258f, 0.02066451f, -0.01821954f, -0.06010233f, -0.05024805f, -0.03916714f, 
    0.01050879f, -0.01063718f, 0.03037549f, 0.00667784f, -0.02636054f, -0.00231169f, -0.07240395f, 0.01669023f, 
    -0.50667959f, -0.28633252f, -0.46766502f, -0.21869716f, 0.08119462f, -0.27907389f, -0.10423313f, -0.08563532f, 
    -0.05282637f, -0.00609955f, 0.04030494f, 0.04211688f, 0.04466426f, -0.04494358f, -0.01928269f, -0.02394063f, 
    -0.05895662f, 0.10681338f, 0.00849033f, -0.58684987f, -0.53688133f, -0.19215450f, 0.08669166f, 0.16564715f, 
    -0.00855589f, -0.07356579f, -0.10826679f, -0.18836790f, -0.14361227f, -0.20340511f, -0.06458509f, 0.04950234f, 
    0.02181308f, 0.00413822f, 0.08313043f, 0.09631687f, -0.33703476f, -0.13608615f, -0.13507591f, 0.07852726f, 
    -0.07382409f, -0.05269055f, -0.01642463f, 0.13915867f, 0.02681557f, -0.08222891f, 0.17705785f, 0.05334667f, 
    0.08510717f, 0.11065420f, -0.06040173f, 0.01818786f, 0.04827338f, 0.16841801f, -0.13945797f, -0.10288298f, 
    0.15202561f, 0.00535499f, 0.15786633f, 0.05267448f, 0.01422017f, 0.01202251f, 0.10174207f, -0.18445715f, 
    0.26744187f, 0.27835578f, -0.14346832f, -0.00892185f, -0.01607538f, -0.08129472f, 0.01135028f, 0.00083234f, 
    -0.05615311f, -0.03130678f, 0.02596821f, 0.07700267f, -0.08144776f, -0.05273613f, -0.00120560f, 0.12127047f, 
    0.08265404f, -0.18557234f, 0.10576564f, 0.15180600f, -0.11696905f, -0.10045573f, -0.03951719f, -0.04340230f, 
    0.01443636f, 0.07663744f, 0.14797190f, 0.16248833f, 0.18138407f, -0.13729542f, 0.01407712f, -0.05265314f, 
    0.12962729f, 0.01858516f, -0.02345102f, -0.25111610f, -0.00158391f, -0.06718063f, -0.16202432f, 0.06555247f, 
    -0.20188618f, -0.05608479f, 0.05489116f, 0.03879972f, -0.26629764f, -0.14720383f, -0.00579584f, -0.09882261f, 
    -0.11994348f, -0.10684871f, -0.04370329f, -0.24306092f, -0.16853939f, -0.38417509f, 0.00708656f, 0.05477579f, 
    -0.16639145f, -0.18786763f, -0.20048361f, 0.06180773f, 0.04116921f, -0.06774637f, -0.18090813f, -0.14912054f, 
    0.35367981f, -0.07099232f, 0.01423447f, -0.12819479f, -0.01552510f, 0.06197402f, 0.18364725f, -0.16274072f, 
    0.09049250f, -0.01356758f, -0.03834615f, -0.07006959f, -0.02855623f, 0.06443758f, 0.03803894f, 0.12065788f, 
    -0.23879308f, -0.25271025f, 0.05300937f, -0.00338755f, 0.05964437f, 0.02114305f, 0.10199085f, -0.17438163f, 
    0.03036807f, 0.01634392f, 0.03059832f, 0.05987782f, -0.01938397f, 0.03647602f, 0.07564124f, 0.01276124f, 
    0.05759192f, 0.12244302f, -0.45097175f, 0.02745717f, 0.52672094f, -0.15937458f, -0.09894191f, -0.02077444f, 
    -0.00981556f, 0.01267068f, -0.07750973f, -0.20457119f, -0.11597105f, 0.11106241f, 0.13888703f, -0.11854501f, 
    0.05840068f, -0.04044206f, -0.07339907f, -0.08497186f, -0.04807714f, -0.03815070f, 0.02198496f, 0.03281453f, 
    -0.04313277f, -0.08078890f, -0.16921970f, 0.00406849f, 0.03959745f, 0.32370824f, -0.43069130f, -0.26733848f, 
    0.01918522f, 0.13791563f, 0.02197998f, 0.04328254f, -0.01613476f, 0.03064540f, -0.15510319f, -0.01690605f, 
    0.06089196f, -0.00930822f, -0.08587921f, -0.05286940f, 0.09816016f, -0.00567842f, 0.18785156f, -0.24513756f, 
    -0.12963551f, 0.19605014f, 0.13056044f, 0.10580189f, -0.03425871f, 0.08880496f, 0.13253707f, 0.09348450f, 
    0.13124558f, -0.01174246f, 0.08041137f, 0.10424314f, 0.09516262f, 0.00319339f, -0.05317119f, 0.01947979f, 
    -0.04195396f, 0.14221856f, -0.22599459f, -0.16215083f, 0.02377695f, 0.04340772f, 0.08672999f, 0.03815294f, 
    0.00849557f, 0.00533878f, -0.16338377f, -0.01863701f, 0.11194827f, -0.04353759f, 0.11616993f, 0.03023901f, 
    0.14615999f, 0.03782114f, 0.25722849f, 0.17446253f, 0.04847112f, -0.19150813f, -0.01886595f, -0.00345187f, 
    0.02909089f, -0.13079871f, -0.19200070f, -0.08844922f, 0.12448393f, -0.01710135f, 0.08866620f, -0.02134487f, 
    0.04143977f, 0.00265922f, -0.05130875f, 0.12034307f, -0.03505393f, 0.11583697f, -0.02241366f, 0.20283075f, 
    0.02791104f, -0.02929704f, 0.01630253f, 0.20367737f, -0.01312755f, 0.02382468f, 0.29441366f, 0.03200371f, 
    -0.13784467f, 0.19581164f, 0.04182842f, 0.30179575f, 0.17185691f, 0.03443025f, 0.01034663f, -0.12083525f, 
    0.11064467f, 0.29397449f, -0.09820092f, 0.01057803f, -0.08096776f, 0.05084365f, 0.06860640f, 0.06851977f, 
    -0.19111222f, -0.08475125f, 0.33882222f, -0.03256275f, -0.06779146f, -0.13968293f, -0.06294796f, -0.16109167f, 
    -0.03321016f, 0.11513944f, 0.16928281f, 0.13296813f, -0.03777072f, 0.04121447f, -0.15593882f, 0.12837107f, 
    0.13293575f, 0.03379797f, -0.21654582f, -0.28371486f, 0.06474962f, -0.19477278f, -0.09984772f, -0.05618665f, 
    -0.03721593f, 0.09584465f, 0.07636412f, -0.25093031f, -0.16780695f, -0.08308107f, 0.06709030f, 0.10505442f, 
    -0.02957364f, 0.03560768f, -0.03549776f, 0.10937777f, -0.30568865f, -0.06617332f, -0.24403571f, -0.06582686f, 
    -0.14074485f, -0.05127157f, 0.03585503f, 0.08567803f, 0.07571853f, 0.05466099f, 0.01745010f, -0.04714765f, 
    -0.10050369f, 0.09067411f, 0.01482184f, 0.01992983f, -0.02956322f, 0.03229673f, 0.03034687f, 0.04811287f, 
    -0.05740207f, -0.10893469f, -0.02447183f, 0.06332994f, -0.02594701f, -0.02486549f, 0.07444140f, -0.10121325f, 
    -0.40272045f, -0.56119382f, -0.00080979f, 0.12141360f, 0.17261013f, 0.05089334f, -0.16599901f, 0.07110121f, 
    0.11427912f, 0.19035988f, 0.03497778f, -0.12753700f, -0.08348411f, 0.05303478f, 0.17880253f, -0.11186170f, 
    -0.01495530f, 0.06960173f, -0.11579458f, -0.22582404f, -0.17492937f, 0.06597184f, -0.01503961f, 0.11630569f, 
    -0.03213134f, 0.09516589f, -0.03139803f, -0.33038726f, 0.07626706f, -0.18930669f, 0.21038425f, -0.18474896f, 
    0.18731165f, 0.03167872f, 0.04077710f, -0.08076509f, -0.09598581f, -0.19732445f, -0.09342101f, -0.06489778f, 
    -0.02363231f, -0.07260837f, -0.03668963f, -0.06169649f, -0.07573892f, -0.05361761f, -0.02245495f, 0.02526997f, 
    0.05391573f, -0.00268743f, -0.04205417f, 0.10419408f, 0.10347567f, -0.33600467f, 0.15420420f, -0.23446368f, 
    0.07024238f, 0.04915240f, -0.02061187f, 0.09806082f, -0.02743855f, -0.06386565f, -0.35256681f, -0.30594358f, 
    -0.65916997f, -0.11541091f, 0.02855230f, 0.05755476f, 0.02157911f, -0.05114637f, -0.12208629f, 0.07576733f, 
    0.12419718f, 0.05780973f, -0.02468292f, -0.09434023f, -0.11576168f, -0.01361425f, -0.07104003f, 0.00012830f, 
    -0.46501806f, 0.31695446f, 0.00225829f, 0.18681911f, 0.16717997f, 0.07185614f, -0.10376483f, 0.20289735f, 
    0.06456113f, 0.21025200f, 0.12185872f, 0.07712446f, -0.11297462f, 0.10815358f, -0.07448951f, -0.02638646f, 
    0.12965073f, 0.14296407f, -0.61975026f, 0.09841788f, -0.18037374f, -0.19356477f, 0.18524458f, -0.05499091f, 
    -0.09301728f, 0.04806615f, -0.04549161f, -0.05335549f, 0.37960872f, 0.24021004f, -0.14711910f, -0.00581834f, 
    -0.08602034f, 0.08534520f, 0.21854970f, -0.04955104f, 0.03317892f, -0.05923107f, -0.12246791f, -0.07451902f, 
    -0.03751053f, 0.06048652f, 0.05700592f, 0.06490753f, 0.00708054f, -0.01378269f, 0.09085711f, 0.02242652f, 
    0.04859442f, -0.00422166f, -0.04355269f, 0.03525598f, 0.02153120f, 0.07429382f, 0.16549198f, 0.07187657f, 
    -0.19580914f, -0.10942185f, -0.12340187f, -0.09848864f, -0.08649443f, -0.09337269f, 0.02092071f, -0.29817200f, 
    0.20154302f, -0.31244659f, -0.02908940f, 0.20525537f, -0.06480610f, 0.17701885f, 0.28341490f, -0.14503846f, 
    0.03765105f, 0.02916116f, 0.05523739f, 0.01665114f, 0.10658285f, 0.06384965f, 0.00579451f, 0.04721832f, 
    0.11763380f, 0.12418607f, 0.06461236f, -0.02261628f, -0.11293930f, -0.11746422f, -0.08251705f, 0.05330837f, 
    0.09288978f, 0.03842807f, 0.00895696f, -0.30117509f, -0.69593579f, -0.11599757f, 0.27523091f, 0.01277233f, 
    -0.01772093f, 0.05714748f, -0.14830692f, -0.22767650f, -0.24575520f, -0.04696522f, -0.03544509f, 0.02217537f, 
    0.08450374f, 0.03770648f, -0.00815484f, 0.15451114f, -0.00784138f, 0.22737862f, 0.05261835f, -0.03533647f, 
    -0.01196380f, -0.06660014f, 0.07176645f, 0.05575714f, 0.14957121f, 0.19712710f, -0.03488318f, -0.06498623f, 
    -0.13463427f, 0.12397160f, -0.06290727f, -0.04266438f, 0.11678130f, 0.00435656f, 0.14041303f, 0.19805951f, 
    0.02810891f, -0.10761830f, 0.11981963f, -0.06132741f, 0.15053232f, 0.15708421f, -0.10801548f, -0.01283375f, 
    -0.11144581f, -0.19449255f, -0.18004912f, 0.09077447f, 0.04939429f, 0.15895456f, 0.01943596f, 0.06356052f, 
    -0.02269183f, 0.04796826f, -0.02617726f, 0.05201722f, -0.05396357f, 0.05037955f, -0.02888436f, 0.00374230f, 
    -0.00115646f, 0.00528472f, -0.04354598f, -0.02076936f, -0.05564285f, 0.00598927f, 0.03574037f, -0.00975278f, 
    0.00806409f, 0.03698738f, 0.05659581f, 0.01196720f, -0.04389008f, -0.00785075f, 0.02003092f, 0.03294526f, 
    0.03358014f, 0.03745451f, 0.05700951f, -0.00561242f, 0.00384745f, 0.01660324f, 0.01093173f, -0.02346887f, 
    -0.05569727f, -0.04948129f, 0.05273792f, -0.05832357f, -0.02406969f, -0.02525739f, 0.03509066f, -0.04177080f, 
    -0.04963894f, 0.02722312f, -0.02992572f, -0.00901526f, -0.04894770f, 0.04994017f, -0.00444251f, -0.00475572f, 
    -0.00084317f, 0.04629434f, 0.04235461f, -0.03735941f, -0.05428901f, -0.04598941f, -0.04485207f, -0.01066046f, 
    -0.03711403f, -0.00687498f, 0.02433586f, 0.00613175f, 0.02470971f, 0.00666033f, 0.03835577f, 0.02257535f, 
    0.04246456f, -0.04370648f, -0.01951332f, 0.04473241f, -0.05039458f, 0.04723394f, -0.00157887f, -0.05249828f, 
    -0.02757174f, 0.05337531f, -0.00695227f, -0.03340594f, 0.00637927f, -0.00060847f, -0.03265094f, -0.03336904f, 
    -0.01392226f, -0.01799879f, 0.01097566f, -0.05063053f, -0.00807989f, -0.01226892f, -0.05011565f, -0.04275506f, 
    0.02536837f, 0.03550784f, 0.01235623f, 0.03966643f, 0.00052640f, -0.03606721f, -0.04229537f, -0.01734147f, 
    -0.01518619f, 0.03690974f, -0.05041856f, -0.03745246f, -0.03080727f, -0.05436479f, -0.01064282f, 0.01271585f, 
    0.02998528f, -0.06291158f, 0.02881064f, 0.04544278f, 0.06326897f, 0.03954425f, -0.00456115f, -0.04563380f, 
    0.05242141f, 0.01025085f, -0.04377355f, 0.00128952f, 0.00327583f, 0.04344871f, 0.03633688f, 0.00276334f, 
    -0.06009582f, -0.04260150f, -0.01389110f, -0.05314702f, 0.02050260f, 0.02280983f, 0.02135341f, -0.03202921f, 
    0.03275620f, 0.05192937f, -0.00624208f, -0.05305736f, 0.00791198f, -0.00929720f, 0.00156787f, 0.02566680f, 
    -0.03739289f, 0.03683391f, -0.05311778f, 0.01184579f, -0.02857872f, 0.05556901f, 0.03460056f, 0.00049113f, 
    -0.05381487f, -0.02009009f, -0.00239211f, -0.02875405f, -0.05255819f, 0.03791080f, 0.04538020f, 0.06081869f, 
    -0.01909191f, -0.05968075f, 0.04947887f, -0.00121269f, -0.00740772f, -0.06041593f, 0.04930007f, -0.02702422f, 
    -0.05940169f, -0.05990504f, -0.04441644f, 0.04523868f, -0.01370904f, -0.02183216f, 0.01665477f, 0.00834689f, 
    0.04787968f, 0.03895808f, -0.01840266f, 0.00741559f, 0.02308692f, 0.03549210f, -0.00900866f, -0.00697495f, 
    -0.02645137f, 0.03577188f, -0.03026428f, -0.00926174f, -0.01456436f, -0.04011785f, 0.05780305f, -0.02599091f, 
    0.01559757f, -0.05301429f, 0.00050225f, -0.02846668f, -0.02705688f, -0.02320651f, -0.05480582f, 0.00550477f, 
    -0.04810804f, -0.02798237f, -0.02728816f, 0.00385864f, -0.00145122f, -0.02770069f, -0.04324157f, -0.02473620f, 
    -0.03476911f, 0.01112113f, -0.03618082f, -0.02273378f, -0.02981957f, 0.00404187f, -0.03832427f, -0.01335826f, 
    -0.05703391f, -0.05168481f, 0.05428870f, -0.00993760f, -0.01665925f, -0.00458150f, 0.06371114f, -0.04002370f, 
    -0.02431353f, -0.03113087f, -0.05520545f, -0.05074706f, -0.04989776f, -0.00086968f, -0.01484409f, 0.03226382f, 
    -0.02593207f, -0.05060517f, 0.04358119f, -0.03018023f, 0.04813221f, -0.05788174f, -0.06197048f, -0.03102166f, 
    0.03522094f, 0.02888102f, 0.03916512f, 0.02612909f, -0.01912168f, 0.04390042f, 0.03606446f, -0.04099248f, 
    0.02942284f, -0.00673605f, -0.00524879f, 0.02540427f, -0.01449823f, 0.02224282f, 0.02052697f, -0.01610044f, 
    -0.04737200f, -0.04702897f, -0.01030364f, -0.04793885f, 0.03227090f, 0.03868156f, 0.04988239f, 0.04513263f, 
    -0.00891583f, -0.05482816f, 0.05131622f, -0.06249132f, 0.02486435f, -0.00125514f, -0.01045130f, 0.00373022f, 
    0.00807086f, 0.03204231f, -0.02067137f, 0.01022331f, -0.00776013f, 0.04655788f, -0.01548428f, 0.06165001f, 
    -0.01688854f, -0.02716946f, -0.03223968f, -0.03009543f, 0.03063907f, 0.00470433f, 0.04539844f, -0.04812092f, 
    -0.04043931f, 0.01022368f, -0.00595220f, 0.00959912f, -0.05956386f, -0.06362292f, -0.06098968f, 0.03312249f, 
    -0.04172084f, -0.15043260f, -0.03645209f, 0.19557831f, 0.13498686f, -0.09825163f, -0.16188397f, -0.10613479f, 
    -0.18948765f, -0.09241632f, 0.03265101f, 0.07659975f, -0.00932938f, -0.06528576f, 0.08293160f, 0.02367825f, 
    0.10017454f, 0.13343847f, -0.18500152f, 0.22343780f, -0.12939209f, -0.17213960f, 0.04484630f, -0.05575521f, 
    -0.20160687f, -0.07525055f, -0.08614458f, 0.08569067f, 0.04802644f, -0.00643595f, 0.05799647f, 0.09142425f, 
    0.00427198f, 0.01804426f, -0.00678752f, -0.00444233f, 0.20424645f, -0.08976058f, 0.09776016f, 0.05665100f, 
    -0.04170910f, 0.08685718f, -0.06837474f, -0.03209505f, 0.06065561f, 0.15981685f, 0.02217531f, -0.20518167f, 
    -0.08723322f, 0.02943739f, -0.08476166f, -0.08234310f, 0.09780090f, 0.13527957f, -0.07155259f, 0.23702927f, 
    -0.16975239f, -0.01926944f, 0.14060263f, -0.01160838f, 0.08762737f, -0.00682693f, 0.07050145f, 0.12328908f, 
    -0.08004010f, -0.00064005f, -0.06357852f, -0.02305557f, -0.08698500f, -0.11679911f, -0.07060834f, -0.04065574f, 
    -0.02729009f, 0.14974308f, 0.06287013f, 0.06785031f, -0.04325494f, 0.06036587f, -0.08253490f, -0.04547980f, 
    -0.00610246f, 0.18427384f, 0.18643022f, -0.04646914f, -0.00278071f, -0.09193867f, 0.00299940f, -0.19400343f, 
    -0.14885499f, -0.11996212f, -0.03290594f, 0.17973223f, 0.00538329f, 0.02094298f, 0.06938607f, 0.29217696f, 
    0.08285172f, 0.11829612f, -0.00916252f, 0.12892292f, -0.23678735f, -0.08087862f, 0.11201754f, 0.12917756f, 
    0.01986399f, -0.07705493f, -0.07129164f, -0.10439930f, -0.10403875f, 0.00413305f, 0.06208826f, 0.08212682f, 
    0.00424133f, -0.03650609f, -0.18594757f, -0.09174369f, -0.10058336f, -0.02056785f, -0.21870074f, 0.20472667f, 
    -0.03148256f, -0.11494797f, 0.17382039f, -0.08950647f, -0.01371279f, -0.06683897f, 0.20100763f, -0.23867184f, 
    -0.02949709f, -0.02361375f, -0.00442110f, 0.09051055f, 0.01492890f, 0.02427782f, 0.21182102f, -0.21729603f, 
    -0.04027099f, -0.06439014f, 0.01101298f, 0.10177454f, -0.04388196f, 0.11816716f, 0.04982939f, -0.01706486f, 
    0.02536134f, 0.11541179f, 0.22629833f, 0.07530090f, 0.08486778f, 0.02847732f, 0.04904712f, -0.03134311f, 
    -0.14836086f, -0.03663510f, 0.05865297f, 0.01921986f, -0.02085616f, 0.02729028f, -0.00861236f, 0.01347414f, 
    0.06009717f, 0.07457312f, 0.21333702f, -0.04329179f, -0.00569091f, 0.16136473f, 0.05833640f, -0.01761828f, 
    0.09374718f, -0.06699754f, 0.07602903f, -0.37052736f, 0.21238673f, 0.16149369f, 0.00304411f, -0.02838793f, 
    0.14407274f, 0.01846836f, 0.03702757f, -0.00831687f, -0.07242081f, 0.06106156f, 0.13667792f, -0.01224129f, 
    -0.10775112f, 0.00832691f, -0.09330928f, -0.06503830f, -0.05588109f, 0.08704565f, 0.17711808f, 0.07425446f, 
    0.12170997f, -0.03406674f, -0.06723586f, -0.08925122f, -0.04654866f, -0.07837966f, 0.05736764f, 0.10236808f, 
    -0.02772442f, 0.01500941f, 0.02076160f, 0.08540056f, -0.01735086f, -0.20901513f, -0.02057416f, 0.16500206f, 
    0.08968732f, 0.26824406f, -0.09963316f, 0.14958771f, -0.05213742f, -0.04547882f, 0.30981877f, 0.04220473f, 
    -0.12271720f, 0.03336510f, 0.01399068f, -0.03054528f, 0.01183404f, -0.00877591f, -0.12368315f, -0.03606169f, 
    -0.06234076f, -0.02881559f, 0.04135229f, 0.02133587f, -0.02436776f, 0.02208158f, -0.05799270f, 0.09771494f, 
    -0.07773983f, -0.01122984f, -0.04205798f, -0.22367720f, 0.11708993f, 0.00791736f, -0.06541786f, 0.45566949f, 
    0.03358207f, 0.12076019f, 0.32369876f, -0.11773098f, -0.12263618f, -0.05933358f, 0.06143271f, 0.08684204f, 
    -0.02588267f, -0.22077598f, -0.15161863f, -0.03952856f, -0.11724839f, -0.01280885f, 0.02936468f, 0.02236037f, 
    0.12232389f, 0.01133261f, -0.08291496f, -0.03821182f, -0.11776479f, 0.10440843f, 0.21108279f, 0.15287562f, 
    -0.16578452f, -0.10933250f, -0.02318702f, 0.22703589f, 0.07777254f, 0.01798269f, -0.03338150f, 0.09142646f, 
    0.20748268f, 0.07081626f, 0.14642377f, 0.02616120f, -0.06137335f, 0.15006810f, 0.02449735f, 0.16738248f, 
    0.08399878f, -0.05933399f, 0.05473446f, -0.05178167f, -0.02174119f, -0.15966137f, -0.04958609f, -0.09498037f, 
    0.05972479f, 0.25901690f, 0.33044007f, -0.14170319f, 0.08709169f, -0.09172164f, 0.03732095f, 0.12665753f, 
    -0.00310841f, 0.25580072f, -0.15328175f, -0.19820182f, -0.11424977f, -0.35041714f, -0.06647638f, -0.00981397f, 
    -0.03552201f, -0.05372262f, 0.27084753f, -0.30217046f, -0.16811223f, 0.13206317f, -0.02757780f, -0.08386031f, 
    -0.00027404f, -0.00974010f, 0.18200861f, 0.01450927f, 0.07794596f, 0.24229439f, -0.09736190f, 0.10202637f, 
    0.09770864f, -0.00615201f, -0.10307348f, -0.02900405f, 0.16510968f, 0.17983699f, 0.04881934f, 0.04730076f, 
    0.07931563f, 0.00580379f, -0.00625229f, 0.07212498f, 0.09479593f, 0.10007184f, -0.41921651f, -0.03146054f, 
    -0.20679107f, -0.13028404f, 0.15556327f, 0.09361287f, 0.12245572f, -0.04310201f, -0.43037358f, -0.45219418f, 
    -0.00096026f, -0.03047180f, -0.05635141f, -0.14687584f, 0.07014853f, 0.03071243f, -0.20176125f, 0.31013083f, 
    0.04892839f, 0.01591474f, -0.05088035f, 0.03107824f, 0.05456306f, 0.01766908f, 0.00813428f, -0.10208459f, 
    -0.18873771f, -0.11094741f, -0.18854152f, -0.12053279f, -0.00933361f, 0.13851285f, 0.04205821f, 0.17420356f, 
    -0.24895161f, -0.02416783f, 0.02012546f, -0.17877261f, -0.23858242f, -0.07517548f, 0.01025632f, 0.01190701f, 
    -0.04733548f, -0.00791212f, -0.04660496f, -0.13335180f, 0.07293266f, 0.00252243f, 0.08391016f, -0.02019445f, 
    0.01655800f, 0.07385993f, -0.00319838f, 0.18102035f, 0.23063233f, 0.20210110f, -0.06138647f, 0.11604222f, 
    0.02101182f, 0.03100603f, 0.04172805f, 0.05328132f, 0.13152012f, 0.18808220f, 0.22810119f, 0.01535857f, 
    0.04835410f, 0.08756465f, 0.08415596f, 0.17220743f, 0.05010500f, 0.22314523f, 0.32465073f, 0.04197055f, 
    -0.13133365f, 0.03619393f, 0.02376409f, 0.02170504f, 0.02594293f, -0.00349625f, 0.25077862f, -0.26914260f, 
    -0.09118752f, -0.09274200f, 0.08340444f, 0.08071622f, 0.01284826f, 0.04060053f, 0.03218921f, 0.36507902f, 
    -0.04275357f, 0.12615426f, -0.02847387f, -0.07611575f, -0.05645771f, 0.12853888f, 0.02472040f, -0.21206510f, 
    0.11565573f, -0.04260862f, 0.09662924f, 0.01528234f, 0.05146044f, 0.01438447f, 0.04474035f, 0.08555948f, 
    0.17448919f, -0.07263483f, 0.01805777f, -0.00764612f, -0.05302007f, -0.07982910f, -0.04808854f, -0.08740382f, 
    -0.15086514f, -0.01928671f, 0.04676391f, 0.20574346f, 0.21475191f, -0.06742723f, 0.01305052f, -0.00858428f, 
    -0.15894713f, -0.05588169f, 0.02249716f, 0.03203255f, -0.49440733f, 0.19827287f, 0.25785321f, 0.18525144f, 
    -0.08247998f, -0.06732656f, -0.07910491f, -0.14882185f, -0.04890337f, -0.14527592f, -0.08195146f, -0.00245224f, 
    -0.06912660f, 0.05693226f, 0.14723398f, 0.13026781f, 0.06818192f, 0.10068492f, -0.23419447f, -0.40960145f, 
    -0.04490137f, 0.06324246f, -0.31684807f, -0.02798110f, -0.00374278f, 0.13812560f, 0.13504131f, 0.23440364f, 
    -0.00997264f, -0.33728734f, 0.04520244f, -0.05733149f, 0.05579874f, 0.00635379f, 0.00707896f, -0.03691264f, 
    -0.80182868f, -0.17529723f, -0.03258455f, 0.14274706f, -0.09484176f, -0.04629901f, 0.01200711f, -0.10373659f, 
    -0.27375793f, -0.30733982f, 0.08865320f, -0.16048233f, 0.03740884f, -0.15971282f, -0.07875670f, 0.12831117f, 
    0.12709938f, 0.08647206f, -0.10957298f, 0.32245031f, 0.09400333f, 0.12854701f, -0.26424828f, -0.01483684f, 
    -0.05807963f, 0.16645071f, 0.28079021f, -0.19542022f, 0.01092257f, 0.12457745f, -0.01762664f, 0.05020425f, 
    0.08132558f, 0.05365725f, -0.08823951f, 0.02124839f, -0.09993349f, -0.21351434f, -0.14681117f, 0.03301375f, 
    -0.01224795f, 0.08464613f, 0.13954291f, -0.00441372f, -0.57236439f, -0.33619297f, 0.29281694f, -0.14495188f, 
    0.03179093f, -0.06610928f, -0.05276198f, -0.13117003f, -0.12283692f, -0.09011143f, -0.18250996f, -0.08903190f, 
    -0.27227604f, -0.03637096f, -0.16648670f, -0.01566838f, -0.12247613f, 0.05940660f, -0.19853809f, -0.12458472f, 
    -0.83707607f, 0.04742850f, 0.00891530f, 0.03532362f, -0.04232418f, -0.00963633f, 0.11221252f, -0.14406455f, 
    -0.17277575f, -0.10845382f, -0.14090513f, -0.05267387f, 0.03190530f, 0.07647256f, 0.05230184f, 0.00842948f, 
    -0.06098200f, -0.16641824f, -0.21717152f, -0.11352174f, -0.10106986f, -0.13585570f, 0.14300217f, -0.13401654f, 
    -0.07658961f, -0.30655321f, 0.06378108f, 0.02612599f, -0.04548691f, -0.03068992f, 0.02623130f, 0.07776912f, 
    0.00311056f, 0.08977423f, -0.19786766f, -0.38665882f, -0.58914751f, -0.06687696f, -0.04360642f, -0.18328713f, 
    -0.08096491f, -0.11033168f, -0.14027458f, -0.03684814f, -0.10728651f, -0.02088786f, 0.01867063f, 0.13746831f, 
    0.04797454f, -0.04392017f, -0.04289537f, 0.14563867f, -0.17544279f, -0.22958073f, -0.01891863f, -0.07334276f, 
    0.10341039f, -0.16228667f, 0.14385332f, 0.03036119f, 0.11426979f, -0.01540131f, 0.04780604f, -0.08790629f, 
    -0.09162318f, -0.05401614f, 0.05061810f, 0.01498327f, 0.12708963f, 0.08913086f, -0.28428587f, 0.12078895f, 
    0.26777527f, 0.07803098f, -0.17885658f, -0.07089924f, 0.06283958f, 0.00900435f, 0.11548389f, -0.01803809f, 
    0.07646064f, 0.19038223f, 0.09000514f, 0.17004098f, 0.02555579f, -0.04258189f, 0.01358921f, 0.00286475f, 
    -0.13584176f, 0.06106440f, -0.10360288f, -0.06504070f, -0.09986190f, 0.08784215f, 0.06986111f, -0.02699361f, 
    0.07680175f, -0.10774525f, 0.06655917f, -0.05934553f, -0.03801718f, 0.09591845f, -0.08177149f, 0.02277123f, 
    -0.04230167f, 0.05960598f, 0.13912672f, -0.44405702f, -0.08417221f, 0.02528602f, -0.01093083f, -0.09374804f, 
    0.13058150f, 0.01098948f, 0.06242311f, -0.11827079f, -0.14086345f, -0.11873378f, 0.09342355f, -0.03452944f, 
    -0.07747430f, 0.04180789f, -0.12155189f, 0.09860473f, -0.21109800f, -0.34773412f, -0.20049813f, -0.12227058f, 
    -0.03411618f, -0.25011519f, 0.13723011f, -0.10165060f, 0.04669989f, -0.19849864f, -0.10273989f, 0.00136317f, 
    -0.14823228f, -0.06352204f, -0.19611673f, -0.00580028f, -0.02331348f, 0.09717026f, -0.28241137f, -0.05268721f, 
    0.24513118f, -0.15428276f, 0.01139531f, 0.07734147f, -0.18507756f, -0.04878872f, 0.07988549f, -0.15218899f, 
    0.00504683f, -0.00770859f, -0.05072460f, -0.05997277f, -0.12719350f, 0.01471321f, -0.02019315f, 0.09672061f, 
    -0.14462461f, -0.21243103f, 0.23416074f, -0.01251427f, 0.18259248f, -0.09553304f, 0.26611617f, 0.08593038f, 
    0.04734525f, 0.11371849f, -0.12845339f, 0.08168660f, 0.14362994f, 0.15967734f, 0.11953738f, 0.06528618f, 
    0.12032106f, 0.15846774f, -0.01690778f, 0.04745712f, 0.30488345f, 0.07166187f, -0.00983133f, -0.00183237f, 
    -0.09827187f, -0.15250747f, 0.09819515f, -0.21805869f, -0.35458407f, 0.27877587f, 0.05017514f, -0.02900369f, 
    0.18469217f, -0.05017723f, -0.03941052f, 0.11094642f, -0.00623911f, -0.13732359f, -0.14152831f, -0.15619515f, 
    -0.10329748f, 0.00823261f, 0.16581939f, -0.06846589f, 0.18804039f, 0.02655812f, -0.24673061f, 0.14190935f, 
    0.01997049f, 0.04822716f, -0.31408677f, 0.13426994f, -0.02756210f, -0.03981289f, -0.10439876f, 0.01634923f, 
    0.00942744f, -0.15775844f, -0.09965354f, -0.08201895f, 0.17103806f, 0.01243703f, 0.06130112f, -0.15854178f, 
    -0.07395083f, 0.34115022f, -0.17593247f, 0.10774013f, -0.08425535f, 0.01658759f, -0.01316694f, 0.17276421f, 
    0.09057749f, 0.04267353f, -0.07736926f, 0.03849218f, 0.07208580f, 0.04293301f, 0.12794290f, 0.09238115f, 
    0.04142138f, -0.06100061f, -0.09560537f, -0.13221166f, -0.08529657f, 0.04835716f, -0.17313874f, -0.12094909f, 
    -0.17580485f, 0.00549267f, -0.31615755f, -0.07046438f, 0.06922612f, 0.03496407f, -0.00420828f, 0.18876292f, 
    -0.05163231f, 0.13208926f, 0.14923346f, 0.21231744f, 0.00604277f, -0.32822052f, -0.15679938f, -0.08159028f, 
    -0.02152015f, 0.11542451f, -0.01009747f, -0.22051451f, 0.04746868f, 0.02249456f, 0.14813218f, 0.10689361f, 
    0.10009396f, 0.03418130f, 0.01340638f, 0.08259879f, 0.04489539f, 0.07100514f, -0.30201668f, -0.08140063f, 
    0.00169613f, 0.13425265f, -0.26161936f, 0.07577368f, 0.03495399f, 0.14489599f, 0.74329615f, 0.09566645f, 
    -0.30655199f, 0.21387519f, 0.00875158f, 0.03786071f, 0.12150989f, 0.20213808f, -0.15318605f, 0.02660248f, 
    0.12289093f, 0.08815408f, 0.04323821f, 0.11381168f, 0.07585410f, -0.03993321f, 0.06408411f, 0.09432746f, 
    0.01449804f, 0.01580436f, -0.06683341f, -0.00761224f, 0.01408351f, 0.00636770f, -0.04982438f, 0.02183472f, 
    -0.00116455f, 0.00699618f, -0.03831938f, 0.03314843f, -0.00377717f, -0.03982623f, -0.00479698f, -0.00183671f, 
    0.02035991f, 0.05704430f, -0.02254030f, -0.04536127f, -0.00383487f, -0.01958256f, 0.03298594f, -0.04168388f, 
    -0.03981656f, -0.01447250f, 0.02670394f, -0.03931218f, -0.02948784f, 0.01462107f, 0.00284933f, -0.05234158f, 
    -0.03614247f, 0.02699097f, -0.05930455f, -0.03684906f, -0.01744379f, 0.02667813f, 0.03224388f, -0.05473872f, 
    -0.01485172f, -0.04088588f, 0.04849134f, 0.03467079f, -0.02310530f, 0.04296325f, -0.01192576f, 0.03780432f, 
    0.02601922f, 0.04158882f, -0.02546742f, -0.01719657f, -0.01895415f, -0.03272742f, -0.02507028f, 0.02174858f, 
    0.04751097f, 0.03734628f, 0.03049628f, -0.04844338f, -0.01926660f, -0.05578389f, 0.01238848f, -0.05947446f, 
    0.01184913f, -0.01553105f, 0.02190766f, 0.01382530f, -0.03478019f, -0.05239473f, -0.03744396f, -0.06585214f, 
    0.00468968f, -0.03466311f, -0.01769784f, 0.00087581f, 0.02137019f, 0.01728662f, -0.01574524f, -0.00666435f, 
    0.03463667f, -0.03358326f, -0.00442171f, -0.03756924f, 0.00472181f, -0.01260525f, -0.00219917f, -0.00396629f, 
    0.03679248f, -0.00538824f, -0.03192583f, -0.02824450f, -0.03710527f, 0.04708260f, 0.02908737f, -0.05980895f, 
    0.05471524f, 0.02252289f, -0.03627648f, -0.02046844f, 0.01898532f, -0.03803087f, -0.02691567f, 0.03955001f, 
    0.00203113f, -0.04258871f, 0.04618195f, 0.04144055f, 0.02567640f, -0.01757924f, -0.04648278f, -0.00575743f, 
    0.02934354f, 0.01593255f, 0.00745346f, 0.04069171f, -0.03651902f, -0.02022171f, -0.02210769f, 0.01943979f, 
    -0.02067149f, -0.03106108f, 0.02631261f, -0.06558414f, 0.04719901f, -0.00549929f, 0.00233320f, 0.01953077f, 
    -0.05196781f, 0.00160513f, -0.05164758f, 0.01719319f, -0.04390214f, -0.03251935f, 0.01809444f, -0.03008575f, 
    0.03086182f, 0.00355694f, -0.03375230f, 0.00936909f, 0.04283472f, 0.04374941f, 0.03640982f, 0.05093820f, 
    0.01706743f, -0.00531704f, -0.03676186f, 0.01870592f, -0.05187668f, 0.04969911f, 0.04841255f, -0.04225438f, 
    -0.04868681f, 0.04583717f, -0.04204434f, 0.01889921f, 0.04142132f, 0.00829070f, 0.00940271f, -0.04273880f, 
    -0.04589121f, -0.01011543f, 0.01370242f, 0.04021405f, 0.00191326f, -0.01825513f, 0.03364851f, 0.04488299f, 
    -0.04746838f, -0.00220425f, -0.00755254f, -0.01959980f, 0.02725951f, -0.01035287f, 0.01397125f, 0.00219903f, 
    -0.06528510f, -0.04669278f, -0.00297989f, 0.03209317f, -0.04952487f, -0.03544730f, -0.06464515f, -0.01225956f, 
    0.01937457f, -0.01059492f, 0.00940040f, -0.03447242f, 0.00008533f, 0.00253522f, -0.00339971f, -0.01666837f, 
    -0.05129570f, 0.01876603f, -0.04188723f, 0.03254936f, 0.04858157f, 0.01447707f, -0.04190445f, 0.03012742f, 
    0.03273896f, 0.00107375f, 0.00441164f, 0.01133735f, 0.01564415f, -0.01151682f, -0.02144152f, -0.03051282f, 
    0.00761983f, 0.04968613f, -0.01306007f, 0.02938097f, 0.05931088f, 0.01737045f, 0.01665364f, -0.01196824f, 
    -0.06701906f, 0.03573658f, -0.01300974f, 0.03735108f, -0.05206639f, -0.00867665f, -0.04861791f, -0.05182608f, 
    0.01007687f, -0.00612800f, 0.01233299f, -0.03513107f, -0.03125107f, 0.03774126f, 0.05170254f, -0.01752398f, 
    0.01707196f, 0.03720119f, -0.04353105f, -0.06409145f, 0.03406400f, -0.01203073f, -0.00312308f, -0.05081099f, 
    0.01823388f, 0.03961637f, -0.04868947f, 0.02584725f, 0.04005839f, -0.04314077f, 0.00266504f, -0.03371054f, 
    -0.05367107f, 0.03229516f, 0.00176319f, 0.03085238f, 0.03553452f, 0.00041106f, -0.02505279f, 0.04114588f, 
    -0.01587621f, -0.03910777f, -0.00484374f, -0.05531977f, -0.01331451f, -0.02300193f, 0.01554584f, -0.04716811f, 
    -0.03858218f, 0.02033581f, 0.00253728f, -0.05992559f, 0.01669822f, -0.02523004f, 0.03160198f, 0.03988580f, 
    -0.02234299f, -0.00522050f, 0.03143800f, 0.01401309f, 0.03892245f, -0.04788991f, 0.01884854f, -0.06743950f, 
    -0.01456697f, -0.02469293f, -0.05175702f, -0.04095517f, 0.04841550f, -0.00066985f, -0.04655036f, -0.01108493f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.16842341f, 0.15957330f, 0.11551070f, 0.08848324f, 0.18650986f, 0.01735207f, 0.19415392f, 0.05764688f, 
    0.12760319f, 0.00791775f, -0.00661026f, 0.00146413f, 0.18360530f, -0.02928093f, 0.08802535f, 0.03432149f, 
    0.03637653f, 0.05406938f, 0.22269794f, -0.08383379f, -0.02522160f, 0.12718455f, 0.07960747f, 0.06724487f, 
    -0.00777689f, 0.18635443f, 0.21620682f, -0.01108566f, -0.05866740f, -0.04748574f, 0.27069962f, -0.03771143f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21402913f, 0.10349827f, -0.00553832f, -0.20352766f, -0.33129254f, 0.08962769f, -0.02882562f, -0.09572883f, 
    0.24931422f, 0.12034820f, 0.04325813f, -0.30840689f, 0.24827841f, -0.12196802f, -0.07467037f, -0.01146888f, 
    0.08493479f, -0.10820296f, 0.18219185f, 0.22675440f, -0.07631050f, -0.23343240f, -0.21604320f, -0.08837780f, 
    -0.07509894f, 0.19029839f, 0.29306814f, 0.01510762f, 0.27134788f, -0.08618736f, -0.06996984f, 0.03093210f, 
    -0.24410826f, -0.10257927f, -0.08851768f, 0.04978931f, 0.07544047f, 0.18440311f, -0.03425645f, 0.10351510f, 
    0.06950469f, 0.11073687f, -0.04728340f, -0.19986632f, 0.00314149f, 0.01064729f, -0.13881396f, -0.00535554f, 
    -0.08633319f, 0.17320982f, 0.14401792f, 0.18845829f, -0.04523752f, -0.38624135f, 0.01766054f, -0.07977302f, 
    0.05158748f, -0.07891250f, -0.02046087f, -0.12046930f, -0.12681915f, -0.07368664f, -0.18289556f, -0.04895438f, 
    -0.07502553f, 0.00041053f, 0.32771364f, 0.43767405f, 0.32413241f, 0.32929054f, 0.11735382f, -0.20866418f, 
    -0.37937054f, -0.05461926f, 0.03870522f, -0.24224041f, 0.08122128f, 0.18186398f, 0.20274615f, -0.04828980f, 
    -0.43971452f, -0.15287602f, -0.18471542f, 0.04729355f, 0.04306250f, -0.10417586f, 0.17995717f, -0.20291172f, 
    0.00806977f, -0.24060750f, -0.00971473f, -0.00548493f, 0.09373940f, 0.05998696f, 0.16001005f, -0.12347936f, 
    -0.10845006f, 0.18830025f, 0.15374215f, 0.07894801f, -0.11613069f, 0.16311370f, 0.11646894f, 0.01463954f, 
    0.16071139f, -0.12944736f, -0.03205315f, -0.32398263f, 0.33184290f, -0.40059674f, 0.19667958f, -0.00337146f, 
    -0.16917923f, -0.13380623f, 0.25432259f, -0.05205689f, 0.06111899f, -0.49631789f, -0.21851788f, 0.16362280f, 
    0.04487031f, 0.05204319f, 0.49113825f, 0.02608649f, 0.28239605f, 0.01180927f, -0.06387077f, -0.12600860f, 
    -0.17536157f, -0.34602496f, 0.00013215f, 0.16351135f, 0.30503801f, -0.12316098f, -0.29688898f, 0.11391716f, 
    0.04281928f, -0.01941696f, -0.02466721f, 0.19013157f, -0.04054328f, -0.06244643f, 0.29082412f, 0.13180916f, 
    0.05243469f, 0.11338633f, 0.03131811f, -0.01696308f, 0.00170844f, 0.02733683f, 0.13754408f, -0.30807498f, 
    -0.16430451f, -0.11257110f, 0.13289450f, -0.14313115f, 0.04714135f, 0.32948595f, -0.34095669f, 0.14136519f, 
    -0.20677352f, -0.17294987f, -0.18847577f, -0.18742287f, 0.08605284f, -0.14950128f, -0.00301245f, -0.00457050f, 
    -0.22359422f, -0.16544686f, 0.03808674f, -0.14370888f, -0.13263378f, -0.07383488f, 0.04874877f, 0.14995980f, 
    0.00750174f, 0.06392594f, -0.26312861f, 0.02661133f, -0.10186021f, -0.14714396f, -0.07245940f, -0.10407566f, 
    -0.17183290f, 0.05383643f, -0.14245577f, -0.06441252f, 0.11586212f, -0.08467911f, 0.02077324f, -0.11930982f, 
    -0.04494747f, 0.05002677f, 0.12191521f, -0.13482642f, -0.24101083f, 0.18819088f, -0.02102951f, -0.01436583f, 
    -0.13180482f, 0.01102855f, -0.10741309f, 0.01134256f, 0.17064984f, 0.17522182f, -0.24773306f, 0.00166517f, 
    0.13569838f, 0.19254325f, 0.10673025f, 0.00050734f, -0.13333730f, 0.25005651f, 0.05045720f, -0.05879694f, 
    0.17931111f, 0.01875190f, 0.19117363f, 0.05837372f, 0.08570120f, 0.58542818f, 0.22655460f, 0.15714394f, 
    0.12791952f, 0.27219120f, -0.35243934f, 0.00417848f, 0.03062337f, -0.18013535f, -0.04229641f, 0.05177378f, 
    0.31733137f, 0.00004053f, 0.17520133f, 0.15047757f, 0.25381064f, 0.08276300f, -0.01518105f, -0.02900791f, 
    0.25152561f, -0.35578394f, 0.03870839f, -0.24426101f, 0.10841511f, -0.10722417f, -0.06099802f, -0.05908100f, 
    -0.00273615f, -0.46942323f, 0.09073884f, 0.04429393f, 0.15102601f, -0.24449655f, 0.14257382f, -0.14449665f, 
    0.01994519f, 0.26846886f, -0.16199598f, 0.00401813f, 0.18266028f, -0.29022115f, 0.06262879f, 0.27829462f, 
    0.08926058f, -0.02623092f, -0.19974470f, 0.25983456f, 0.01805412f, 0.07720363f, 0.03779358f, -0.03923857f, 
    0.17333329f, -0.17128907f, 0.30639827f, -0.14305103f, -0.13509017f, 0.04595825f, -0.03436914f, 0.10356697f, 
    0.01906018f, 0.04052648f, 0.20667775f, -0.10609173f, 0.02047265f, -0.10349853f, -0.04628446f, -0.16041327f, 
    -0.17351846f, 0.06130013f, 0.34247923f, 0.08488404f, 0.04018567f, -0.00070422f, -0.11156858f, 0.12418521f, 
    0.12912516f, -0.08297101f, 0.10261157f, 0.08470159f, 0.53720289f, -0.05720049f, -0.18266869f, 0.09847795f, 
    0.11910889f, 0.03825599f, 0.33271724f, -0.35597777f, -0.09784905f, -0.02784741f, -0.11101469f, -0.31495714f, 
    0.06628850f, -0.10368012f, 0.24549507f, -0.09880477f, 0.21821690f, -0.06854892f, -0.25778562f, -0.08294125f, 
    -0.11235351f, 0.13879417f, 0.20584014f, -0.20286703f, -0.26489022f, 0.21814664f, -0.14451557f, 0.15985657f, 
    -0.09418920f, 0.14778145f, 0.04093114f, 0.20668788f, 0.02416632f, 0.11259449f, -0.16993473f, -0.13907959f, 
    -0.02349474f, -0.12600546f, 0.20351166f, 0.21445131f, 0.12870851f, 0.11322700f, -0.21962669f, 0.10158008f, 
    -0.10748096f, -0.21240340f, 0.05995121f, -0.10587431f, 0.11010476f, 0.15825310f, -0.28239000f, -0.01149342f, 
    -0.06710679f, -0.03748411f, 0.10857332f, -0.06487031f, 0.17497575f, 0.07327951f, -0.09278462f, -0.09603022f, 
    0.01243511f, 0.17524362f, -0.11986600f, 0.07273983f, 0.09242117f, 0.04137276f, -0.17012025f, -0.10314289f, 
    -0.02356686f, -0.13885370f, -0.01141572f, -0.07682227f, -0.15169491f, -0.12435514f, -0.17325380f, -0.07462607f, 
    0.07050391f, -0.09586731f, 0.06735318f, 0.12908621f, 0.06569892f, -0.09920248f, -0.15986012f, -0.16463695f, 
    -0.08317661f, 0.27313054f, 0.13832211f, 0.21395609f, 0.00937728f, -0.06289390f, 0.16059346f, -0.12878865f, 
    0.10177325f, 0.00302728f, 0.29736584f, 0.07482501f, 0.05102487f, 0.19809853f, -0.16174173f, 0.11390542f, 
    0.23124547f, -0.10416707f, -0.09992458f, -0.19772837f, 0.02416317f, -0.23919724f, -0.05475570f, 0.07737436f, 
    -0.09461483f, -0.24068771f, -0.29141206f, 0.09183389f, -0.15504582f, -0.36750504f, 0.00190202f, 0.07860244f, 
    -0.06544384f, 0.15899822f, 0.17474002f, -0.06084530f, -0.37085101f, -0.13635929f, 0.37986672f, -0.13636307f, 
    0.25803775f, 0.01936151f, 0.13053058f, 0.30406445f, -0.09158748f, 0.18038119f, -0.02470693f, -0.01232904f, 
    0.17180359f, 0.12050280f, 0.16645877f, -0.05308820f, -0.06144876f, 0.06687010f, -0.11459452f, -0.00428549f, 
    0.13788918f, -0.00833827f, -0.41264290f, -0.02973472f, -0.16955476f, 0.01298448f, 0.04690602f, -0.03406918f, 
    0.06281456f, -0.04452433f, 0.24221985f, 0.28409135f, -0.23789535f, 0.22230226f, 0.35108399f, 0.14469633f, 
    0.16509549f, -0.13308494f, 0.25136620f, -0.11493362f, -0.14902915f, -0.00836751f, 0.08511954f, -0.10813762f, 
    0.06963865f, -0.13373987f, -0.19078003f, 0.04862862f, -0.11872210f, 0.18391429f, 0.20189160f, -0.08153651f, 
    -0.08957428f, -0.23679696f, -0.22957779f, -0.03057806f, -0.20168933f, -0.17077683f, -0.17728329f, -0.15473810f, 
    -0.02458493f, 0.08566207f, 0.15314138f, 0.06123121f, 0.05135979f, 0.06910005f, 0.04594298f, -0.07381868f, 
    -0.45740801f, 0.09896710f, 0.14958861f, 0.20756005f, 0.37809747f, 0.19510296f, -0.28578648f, 0.00626804f, 
    0.03795815f, -0.09685080f, -0.05032274f, -0.38456649f, -0.10340697f, 0.07892702f, 0.28846070f, 0.01568584f, 
    0.14863138f, 0.02607529f, -0.16662082f, 0.03773512f, -0.15498753f, -0.55406159f, 0.22343025f, -0.06503332f, 
    -0.02219456f, -0.03443827f, -0.18075943f, -0.01206639f, 0.12451465f, -0.17290513f, 0.35646576f, -0.07237120f, 
    0.15930526f, -0.14519182f, 0.13665996f, 0.34393954f, 0.09905256f, 0.18950143f, -0.16333848f, -0.11016638f, 
    0.10171694f, 0.02148512f, 0.07581256f, -0.13828233f, -0.03340454f, -0.23316099f, 0.03874960f, -0.01717212f, 
    0.09075816f, -0.12542717f, 0.10949532f, 0.09098215f, -0.03584160f, -0.25389221f, 0.05126755f, -0.16464782f, 
    0.23166683f, 0.07819567f, 0.04422887f, 0.15185563f, 0.17734006f, -0.04829547f, 0.22541697f, -0.14804803f, 
    -0.54837441f, -0.10118288f, 0.12974079f, 0.09075025f, 0.40607631f, -0.04359847f, -0.07876340f, 0.10932930f, 
    0.18648358f, -0.23575500f, -0.27217290f, -0.07261896f, 0.11319330f, -0.06540009f, 0.10213464f, 0.01062293f, 
    -0.12772425f, -0.07463924f, -0.26494202f, 0.11557531f, 0.06378261f, -0.45561609f, 0.12514861f, -0.02970443f, 
    0.22759199f, -0.11456437f, -0.12779978f, 0.37525737f, 0.16915493f, 0.10173077f, 0.22030510f, 0.02762419f, 
    0.21378298f, -0.06388409f, 0.09860159f, 0.00470867f, -0.23631437f, 0.17163719f, 0.40568611f, -0.05961300f, 
    -0.13482232f, -0.32278877f, -0.37928095f, -0.27495539f, -0.15954374f, -0.00007266f, 0.26103196f, 0.12112273f, 
    -0.01145850f, -0.24685967f, 0.31442711f, -0.17594998f, -0.01330519f, -0.23618358f, -0.38460359f, -0.04093892f, 
    0.14438495f, -0.01962009f, -0.01785666f, 0.34270748f, 0.39131704f, -0.06540401f, 0.08625210f, -0.08140147f, 
    -0.37757212f, -0.01703968f, -0.20357423f, -0.10608620f, -0.29171079f, 0.20392276f, 0.11501238f, -0.16492519f, 
    0.13995524f, -0.16300730f, -0.18959276f, -0.21414265f, 0.08502080f, 0.32265863f, 0.15957253f, -0.13483316f, 
    -0.16613561f, -0.04362017f, 0.25370485f, -0.16978218f, -0.40354383f, 0.17255430f, 0.00065819f, -0.14964658f, 
    0.03478271f, -0.21335678f, 0.33502319f, -0.34686348f, 0.34324023f, -0.00287234f, 0.15042605f, 0.15120925f, 
    0.01425235f, -0.05683650f, 0.14151073f, 0.07816365f, 0.07532201f, -0.05245075f, -0.22916842f, -0.15119906f, 
    -0.08961808f, 0.12174053f, -0.03566251f, -0.18601860f, 0.11849358f, 0.05952379f, 0.28214213f, 0.09533156f, 
    -0.06689677f, 0.47437054f, -0.21946110f, 0.14301454f, 0.20197424f, -0.31682196f, 0.15770206f, 0.14831781f, 
    0.12451658f, -0.17931743f, 0.07520638f, 0.18694429f, 0.00947367f, 0.03610539f, 0.10165937f, -0.00170827f, 
    0.43388173f, -0.12729914f, 0.22632417f, -0.20109513f, -0.11745772f, 0.01141085f, 0.24278273f, -0.14434344f, 
    -0.12394848f, 0.10005055f, -0.03276309f, 0.25675428f, 0.01620121f, -0.32726744f, -0.09721158f, 0.10566621f, 
    -0.13047840f, -0.06015856f, -0.04784593f, -0.07586641f, 0.04906624f, 0.22211687f, -0.26126304f, -0.09192783f, 
    0.11745291f, -0.11029001f, -0.23435034f, -0.32106608f, 0.06885228f, -0.06274455f, 0.39724034f, 0.22031981f, 
    -0.01114718f, 0.01221908f, -0.18223281f, 0.14968280f, -0.07604993f, 0.03660690f, -0.02883292f, 0.06261647f, 
    0.03659771f, -0.06941381f, 0.19534607f, 0.08866030f, -0.06237278f, 0.33347276f, -0.00858069f, 0.11514419f, 
    0.13883856f, 0.24756345f, 0.32782719f, 0.16916454f, 0.04983731f, 0.38946357f, 0.32462814f, 0.06308074f, 
    0.11002511f, -0.03485541f, 0.03205468f, -0.20439984f, -0.03941640f, -0.13270640f, -0.17882754f, -0.12827407f, 
    0.14740478f, 0.09887508f, -0.12043627f, -0.18502885f, 0.01832666f, 0.11403630f, -0.20464450f, -0.13717537f, 
    0.02922260f, -0.08937976f, 0.00253112f, -0.19600131f, -0.12010033f, -0.14108534f, 0.10535872f, -0.15481718f, 
    0.06724017f, -0.00720338f, -0.18416063f, -0.00683245f, 0.04232775f, -0.17087840f, 0.10979813f, 0.09689969f, 
    0.21027726f, 0.19649391f, 0.13645048f, -0.24345775f, -0.21288708f, 0.09159999f, 0.20429438f, 0.14876992f, 
    0.12358537f, -0.06412640f, 0.15893295f, 0.30996478f, 0.10695263f, -0.03539476f, -0.18637942f, 0.15541923f, 
    -0.05030594f, 0.20592800f, 0.10913695f, -0.02223957f, 0.05109075f, 0.20507419f, -0.24550311f, -0.25058964f, 
    0.10218315f, 0.20304146f, -0.47531071f, 0.00010722f, 0.09850939f, 0.07141555f, 0.43770608f, 0.06236129f, 
    0.03592576f, -0.27326226f, -0.07017049f, -0.01062271f, 0.39745489f, 0.03239123f, -0.07934283f, 0.25097680f, 
    -0.03213313f, -0.14202484f, -0.17404555f, 0.25212944f, -0.37814629f, 0.17591543f, 0.26227987f, -0.09244839f, 
    -0.08048455f, -0.04594785f, -0.59522372f, -0.09305399f, 0.05732245f, 0.07171611f, 0.30421939f, -0.09488266f, 
    0.05405471f, 0.01167349f, 0.03369198f, -0.11294626f, -0.32504517f, 0.26180878f, -0.33423275f, -0.06877849f, 
    0.11667188f, 0.25509128f, 0.01238341f, 0.27949956f, 0.30980563f, -0.04688905f, -0.07784761f, -0.07359359f, 
    0.20641163f, -0.09349921f, -0.19218193f, -0.09523668f, 0.09974290f, 0.22225329f, -0.05331246f, 0.09456350f, 
    0.18106502f, 0.02498509f, 0.05891871f, 0.07251845f, -0.06053929f, -0.24026150f, 0.06719244f, -0.17384119f, 
    0.08893698f, -0.04323670f, 0.30962226f, -0.15798268f, -0.00979524f, -0.06465060f, -0.20020047f, 0.10736797f, 
    0.01724464f, -0.33630192f, 0.25220719f, -0.21124545f, -0.30284077f, 0.11638220f, 0.17954533f, 0.06747521f, 
    0.42675743f, 0.08951594f, 0.08089171f, -0.13195917f, -0.19484560f, -0.21633132f, 0.07962382f, 0.08650445f, 
    -0.09876046f, 0.07881202f, 0.03245144f, -0.01250530f, 0.14261802f, 0.18026748f, 0.04479378f, -0.05820263f, 
    -0.15467282f, 0.32598138f, -0.08080786f, -0.04399359f, 0.26879224f, -0.14280620f, 0.28669435f, 0.09619366f, 
    0.10910278f, 0.03523674f, 0.00390531f, -0.20567895f, 0.39108932f, 0.16893132f, -0.02200021f, -0.03536978f, 
    -0.24862736f, -0.13384035f, -0.00348576f, 0.08709184f, 0.30426520f, -0.19217570f, -0.01997308f, 0.10011394f, 
    0.00615788f, 0.18834284f, 0.13009451f, -0.05144204f, 0.14622167f, -0.00744373f, 0.03534395f, 0.09050825f, 
    -0.05088216f, 0.29518771f, 0.46218222f, 0.13124344f, -0.01568913f, -0.03032177f, 0.18716635f, -0.08233910f, 
    0.06993958f, -0.24968371f, -0.02934867f, 0.21160105f, 0.22122937f, -0.17997114f, -0.02413875f, 0.25406900f, 
    -0.20821233f, -0.09078743f, -0.12881978f, -0.00049309f, -0.19239326f, 0.15183920f, 0.26142642f, 0.05971032f, 
    0.18252657f, -0.31836376f, -0.32578409f, -0.28087759f, -0.06650817f, 0.18414965f, 0.27716178f, -0.03245593f, 
    -0.08942413f, 0.02585609f, 0.07149479f, -0.16106193f, -0.14113440f, 0.10463420f, -0.00525882f, -0.06732668f, 
    -0.05192430f, 0.19131978f, 0.26749694f, -0.14321944f, -0.17729090f, 0.27691343f, -0.03475727f, -0.16579695f, 
    0.00349382f, 0.10654527f, -0.09080926f, -0.06390109f, 0.15922892f, -0.12884845f, -0.27997711f, 0.03998990f, 
    0.03719808f, -0.12379675f, -0.07973694f, 0.03612407f, 0.08048794f, -0.03797952f, -0.00177641f, 0.23128654f, 
    0.11744858f, 0.30598441f, 0.00283097f, -0.07940125f, 0.08886390f, 0.01991197f, 0.29027903f, -0.12194872f, 
    0.06096861f, 0.02751977f, -0.12776861f, 0.03900013f, -0.21208961f, 0.02682601f, 0.03622794f, -0.08981500f, 
    0.17140520f, -0.13554458f, 0.00233603f, 0.39999333f, 0.45050111f, -0.02149850f, -0.10891395f, 0.07878061f, 
    -0.01129956f, -0.19529390f, -0.03849627f, -0.45126748f, 0.05746567f, 0.13956445f, -0.07896527f, -0.01364915f, 
    -0.02879179f, -0.19226143f, 0.22592542f, -0.04372889f, 0.04976630f, -0.24726453f, 0.43508735f, -0.03835033f, 
    0.08489491f, -0.12516217f, -0.17803057f, 0.07264346f, 0.13007951f, -0.05222551f, -0.05138526f, 0.00017638f, 
    -0.09466947f, 0.13097815f, 0.03077629f, 0.07985496f, 0.25291952f, 0.11587483f, -0.03649073f, 0.16292717f, 
    0.01026629f, -0.02140732f, 0.22398001f, -0.00616107f, -0.12764499f, 0.02407630f, -0.03958378f, 0.09364261f, 
    0.09755159f, -0.40487260f, 0.20968391f, 0.01428634f, -0.11169034f, -0.11073064f, -0.04981480f, 0.02142865f, 
    0.04155073f, 0.26149529f, 0.11165842f, 0.14607035f, -0.17031381f, 0.05862820f, 0.20563851f, 0.05959387f, 
    -0.00343192f, -0.10797916f, -0.23217170f, -0.11786044f, -0.16890542f, 0.05787298f, -0.10614578f, -0.12570137f, 
    -0.13784836f, 0.07301622f, 0.08351719f, 0.09130984f, 0.16859679f, 0.26240987f, 0.00330326f, 0.05165353f, 
    -0.14348857f, 0.02119911f, 0.14126359f, 0.03954055f, 0.05588976f, -0.24895725f, 0.06005774f, -0.10484497f, 
    0.20693520f, 0.19564521f, -0.38004807f, 0.30740377f, -0.02463649f, -0.17467634f, 0.30185482f, -0.10031766f, 
    0.39025754f, -0.16413681f, -0.02369361f, -0.33457622f, 0.13912408f, 0.09183075f, 0.22872652f, 0.05055165f, 
    0.02803867f, 0.05905981f, 0.28198427f, -0.06040272f, -0.02522303f, -0.17762639f, 0.00423756f, -0.46655670f, 
    -0.10897862f, -0.03180549f, -0.02968862f, 0.07186054f, -0.24924567f, 0.24971558f, 0.16449349f, 0.14327127f, 
    0.24845476f, -0.03945431f, 0.09362695f, -0.12165486f, 0.11952037f, -0.13110231f, 0.38804346f, 0.10174383f, 
    -0.01980549f, -0.10727676f, -0.09509429f, 0.09828786f, -0.29366744f, -0.19969876f, 0.13562283f, 0.15045916f, 
    0.21320750f, 0.24484362f, 0.20833987f, 0.16746029f, -0.12251406f, 0.15208074f, 0.09168011f, -0.17046623f, 
    -0.11914102f, 0.11776821f, -0.21597624f, -0.17609528f, -0.09365693f, 0.29230550f, 0.45353016f, 0.14528777f, 
    0.31587467f, 0.34191138f, -0.24632367f, 0.41872528f, 0.24807391f, -0.00658878f, 0.22922772f, -0.09002111f, 
    0.06020163f, 0.07273840f, 0.15581763f, -0.06917373f, 0.16561829f, 0.17658897f, 0.16233431f, -0.01681688f, 
    -0.11838545f, -0.52500606f, -0.14648460f, -0.37906402f, -0.13468589f, -0.16992053f, 0.12999947f, 0.24723184f, 
    0.07995853f, -0.33600003f, 0.43888831f, 0.10290512f, -0.17703128f, 0.11046985f, -0.23707893f, 0.12573370f, 
    -0.06522290f, 0.00085152f, -0.06447376f, -0.29657379f, 0.09555347f, 0.18822397f, 0.09550884f, 0.01872147f, 
    0.20925635f, -0.05320811f, 0.17855367f, -0.21422167f, 0.34253898f, -0.06394266f, -0.20594886f, -0.09180134f, 
    -0.19389573f, 0.16275537f, 0.02431191f, -0.00558735f, -0.01455548f, -0.57579178f, -0.00430850f, -0.01365788f, 
    -0.14758082f, 0.39105180f, 0.07602788f, 0.10048199f, 0.07274310f, 0.01163433f, 0.36567852f, -0.15004893f, 
    -0.10717563f, 0.00761022f, 0.17877744f, 0.09848937f, -0.48346493f, -0.08613127f, 0.02891622f, 0.11807728f, 
    0.08263769f, 0.05156848f, -0.07651719f, -0.06637134f, -0.11816756f, 0.00839470f, -0.03913201f, -0.15464748f, 
    0.10097352f, 0.08807217f, 0.04426837f, 0.07668913f, 0.11258297f, -0.07543898f, 0.11361901f, 0.13302295f, 
    0.01575449f, -0.12988670f, -0.06309723f, -0.00863005f, 0.15362114f, -0.21523787f, -0.19617306f, -0.06514376f, 
    -0.17397194f, -0.17130275f, 0.01041522f, 0.09055096f, -0.17609823f, -0.06903671f, 0.02441249f, 0.02316254f, 
    -0.12506677f, 0.06533533f, 0.01905658f, -0.01908641f, -0.07227930f, -0.00932784f, -0.20105954f, -0.00234960f, 
    -0.08639380f, -0.03866972f, 0.01133637f, -0.06212949f, -0.00481269f, 0.01493721f, -0.01661797f, -0.00111884f, 
    -0.11910249f, 0.11492613f, 0.01155593f, -0.14258049f, -0.13715068f, -0.07759353f, -0.06846806f, -0.02650830f, 
    0.09980205f, 0.10791064f, 0.39032540f, 0.15785372f, -0.10785581f, 0.24444927f, 0.36910748f, 0.07804043f, 
    0.05778436f, -0.10029350f, 0.09100740f, 0.00553990f, -0.11991793f, 0.08893277f, 0.18212755f, -0.06901529f, 
    0.07406703f, -0.19089217f, 0.12087738f, 0.09007786f, -0.14806470f, 0.18732686f, -0.11466302f, -0.30928132f, 
    -0.07985290f, -0.50341904f, -0.31679580f, -0.18071401f, -0.10871467f, -0.47783360f, -0.12017688f, -0.00915519f, 
    0.01568950f, -0.15609208f, -0.07631718f, -0.33219805f, 0.38816056f, 0.11389674f, 0.38132107f, 0.10827307f, 
    -0.07337558f, -0.02190686f, 0.21879137f, -0.20909429f, 0.24838197f, 0.07453760f, -0.23875721f, 0.14445676f, 
    -0.04699667f, 0.18247448f, 0.20115677f, 0.01445312f, 0.00824804f, -0.17406961f, 0.11707470f, -0.32188886f, 
    -0.15795171f, 0.19132861f, -0.03774369f, -0.06316803f, 0.00842160f, -0.32479411f, 0.30846322f, -0.05592291f, 
    0.03219237f, -0.28974396f, 0.23666839f, -0.18867372f, 0.32328722f, 0.40100953f, 0.14057134f, -0.02291147f, 
    -0.20186965f, -0.17455602f, 0.19607639f, -0.27788803f, 0.06059391f, -0.11490864f, -0.21075614f, 0.16630375f, 
    -0.27057150f, 0.29164961f, 0.21206762f, -0.17341460f, -0.06517033f, -0.02024432f, -0.19899939f, -0.24816550f, 
    -0.06220936f, 0.54936171f, -0.35587287f, -0.14791724f, 0.39088237f, -0.17948249f, 0.35284528f, 0.06213666f, 
    0.23679237f, -0.22113821f, -0.10161369f, 0.18625200f, 0.39907697f, -0.15618588f, 0.04152944f, 0.21790034f, 
    0.04061048f, -0.10831773f, -0.21360764f, -0.08504865f, -0.02643458f, -0.20172954f, 0.21394959f, 0.00059797f, 
    -0.06450666f, 0.11393968f, -0.10053393f, 0.15802014f, 0.02254451f, 0.09635324f, 0.22477597f, -0.07224613f, 
    0.10485603f, 0.17659420f, 0.14327428f, 0.01609592f, -0.15300642f, 0.10815550f, -0.22119865f, 0.08239033f, 
    0.05067794f, 0.24668127f, -0.09870491f, 0.07994602f, -0.02992018f, 0.14046486f, 0.34079045f, -0.25721031f, 
    -0.31146625f, -0.01090378f, 0.13498783f, -0.09681200f, 0.11732261f, 0.13802998f, -0.16188942f, 0.13430391f, 
    -0.00943949f, -0.48415375f, -0.13853537f, -0.31745985f, -0.05476724f, 0.07213886f, -0.10834895f, 0.17990664f, 
    -0.03933281f, -0.00102237f, 0.23210303f, -0.07225233f, 0.08921885f, -0.15412056f, 0.54562551f, 0.07368027f, 
    0.16885085f, 0.34652543f, -0.35241115f, -0.03254815f, -0.08111462f, -0.20262051f, 0.29603845f, -0.08094442f, 
    0.16844481f, -0.10494595f, 0.07829266f, 0.17827450f, -0.25634536f, 0.19190232f, 0.03308127f, 0.02600263f, 
    -0.10243790f, -0.21032910f, 0.13387191f, 0.10332487f, 0.14847086f, 0.16310988f, -0.20461047f, 0.16595054f, 
    0.05063030f, -0.18588673f, -0.02410888f, -0.08660844f, -0.09143803f, 0.36642328f, 0.32060245f, 0.16458939f, 
    0.01329325f, -0.26680195f, 0.18660435f, -0.01313469f, -0.22739111f, -0.07583513f, -0.10789809f, 0.16139536f, 
    -0.08583692f, -0.06128737f, -0.05765919f, -0.04883730f, -0.00014387f, 0.03646530f, -0.36672214f, 0.11604766f, 
    0.18867844f, 0.17299154f, -0.00340051f, -0.09082484f, 0.11531293f, 0.16362005f, -0.03968748f, -0.28949606f, 
    0.11940400f, 0.17317323f, -0.25027177f, -0.06710138f, -0.21470402f, -0.39680678f, -0.12850031f, 0.04946710f, 
    0.18668810f, 0.13974856f, 0.10267594f, 0.15311807f, -0.01896161f, 0.05346433f, 0.02799246f, -0.01316099f, 
    0.13936324f, 0.14313821f, -0.26447544f, -0.13940346f, 0.22859915f, 0.21433087f, 0.02973034f, -0.12400166f, 
    0.11571193f, 0.03344192f, 0.47700167f, -0.03602307f, 0.08208270f, 0.23458695f, -0.21573791f, -0.57629114f, 
    0.12315095f, 0.04690146f, -0.11397982f, 0.02097222f, -0.09020337f, 0.06115765f, 0.22728184f, 0.13490480f, 
    -0.12125099f, -0.25403678f, 0.30645660f, -0.14297038f, 0.16798985f, 0.20913716f, 0.39635858f, 0.16265267f, 
    0.09628222f, 0.13449141f, 0.27724513f, 0.14569366f, -0.32221851f, -0.07705811f, 0.17911781f, -0.16099313f, 
    -0.23811232f, 0.09585615f, -0.12228449f, 0.15696797f, 0.09769361f, 0.02097255f, 0.07646565f, 0.00806937f, 
    0.07212753f, 0.19681805f, -0.19098438f, -0.07111130f, -0.04875198f, 0.12698559f, 0.05952215f, 0.05837859f, 
    0.05181432f, -0.08301555f, 0.10649521f, 0.26597521f, 0.01792458f, 0.10353093f, -0.22716753f, -0.17319374f, 
    -0.05656837f, -0.01742242f, 0.05837299f, -0.14071243f, -0.11154771f, -0.14306159f, 0.02954842f, 0.16160645f, 
    0.13262428f, 0.09675093f, 0.14524956f, -0.09274951f, -0.11393011f, 0.04177761f, 0.03576032f, 0.18357784f, 
    0.03551403f, 0.23046075f, 0.42517096f, 0.02442947f, -0.09094707f, 0.69155145f, -0.02111517f, -0.12814958f, 
    -0.00831489f, 0.01837199f, 0.09512953f, -0.20525269f, -0.12491215f, -0.08013771f, 0.14719152f, 0.18694481f, 
    0.50933903f, -0.06966864f, -0.17336380f, 0.32479846f, 0.33212715f, 0.22231165f, -0.12600344f, -0.07564528f, 
    0.05036679f, -0.23750164f, 0.12442517f, -0.09907743f, -0.05375036f, 0.10903841f, 0.05897751f, -0.46312669f, 
    -0.10976809f, -0.22579139f, -0.16412884f, 0.15208618f, 0.08805044f, 0.03203018f, 0.15577407f, -0.13984618f, 
    0.04272849f, 0.17439538f, -0.51702982f, -0.11679214f, -0.17463110f, -0.01511897f, 0.04607417f, 0.02091629f, 
    0.50592393f, -0.08178235f, 0.08897983f, -0.01086122f, -0.02197089f, -0.04899468f, 0.09923508f, 0.09945513f, 
    0.08007352f, -0.25785935f, 0.07515395f, -0.04947748f, -0.05798731f, -0.19340745f, -0.16404195f, 0.05819825f, 
    -0.00147585f, 0.31086493f, 0.39127213f, -0.07461624f, 0.18990777f, -0.12471376f, 0.13087347f, -0.11624347f, 
    -0.22368877f, -0.07009677f, 0.36912164f, -0.05143126f, -0.42405188f, 0.00638712f, 0.20917259f, -0.01957749f, 
    0.48688981f, -0.11625504f, 0.08314257f, 0.22061302f, 0.01995163f, 0.04089995f, 0.21520899f, 0.03865057f, 
    -0.12142953f, -0.10144851f, -0.07196651f, 0.27193892f, -0.14979251f, 0.34904751f, -0.04080432f, -0.31262085f, 
    -0.01231234f, 0.04657943f, -0.21525823f, -0.06445591f, 0.08847448f, 0.34783059f, 0.17750628f, -0.05410881f, 
    0.24902460f, 0.17072679f, -0.42732286f, -0.00647083f, 0.14823526f, -0.29867196f, 0.41081607f, -0.06588322f, 
    -0.00412405f, -0.04310415f, -0.00164386f, -0.09702834f, 0.15513767f, 0.08622590f, 0.20845446f, 0.13324413f, 
    0.11717995f, 0.03763295f, 0.25375754f, -0.19368197f, -0.09978592f, -0.29397795f, 0.07239278f, -0.01787589f, 
    0.13938214f, -0.02515321f, -0.22708298f, 0.03978797f, -0.20257516f, -0.09494204f, 0.09053982f, 0.16764107f, 
    0.15758134f, -0.10804687f, 0.06670064f, 0.11078607f, -0.33352205f, -0.10606031f, 0.22602129f, 0.00043840f, 
    0.38756734f, -0.06942426f, 0.10741185f, -0.45429996f, 0.15105489f, 0.01544438f, 0.20169954f, -0.08663902f, 
    -0.33348101f, 0.07600302f, 0.19220452f, 0.08264519f, -0.16752021f, -0.67910749f, -0.19866577f, -0.10193092f, 
    0.11776670f, 0.44613254f, 0.24530168f, -0.13681135f, 0.16130176f, 0.20777370f, 0.18685836f, 0.05565265f, 
    -0.16194434f, 0.19247094f, 0.19861613f, -0.05184056f, -0.21229337f, 0.11862601f, 0.11672550f, -0.35315371f, 
    -0.18475495f, -0.09859709f, -0.01822421f, 0.24895622f, 0.16476305f, 0.02676367f, 0.03421108f, -0.12810554f, 
    -0.02490048f, -0.27647176f, 0.02218461f, 0.12771633f, -0.12564747f, 0.19054565f, -0.27688771f, 0.15281616f, 
    -0.14277586f, -0.10320822f, 0.02396110f, 0.16453107f, 0.36044100f, 0.20485830f, 0.16415092f, -0.09196433f, 
    0.26286092f, -0.16906826f, 0.25150782f, 0.01069132f, 0.18390235f, -0.19983958f, -0.04793856f, 0.12015010f, 
    0.15706934f, -0.08576395f, 0.02690772f, 0.06717514f, 0.22143117f, -0.04019289f, 0.03901718f, 0.09657702f, 
    -0.02260324f, -0.00853613f, -0.07732039f, -0.22556783f, 0.08677090f, -0.43291116f, 0.17889823f, 0.08199368f, 
    0.14199293f, -0.17646971f, -0.10409458f, 0.12879471f, 0.02588523f, 0.05711518f, -0.12224744f, 0.05296896f, 
    -0.12197142f, 0.20986453f, 0.06461608f, 0.03297352f, 0.39602846f, 0.28392231f, 0.06773662f, -0.33317906f, 
    -0.54778790f, 0.11535776f, 0.05258574f, 0.25680622f, 0.38596082f, -0.08821214f, -0.15213332f, -0.07221477f, 
    0.19626473f, -0.13805059f, -0.07213089f, -0.07435720f, -0.11788312f, 0.04671240f, -0.05122832f, 0.01544284f, 
    0.01820330f, 0.13560142f, 0.30767682f, 0.07299751f, 0.05603126f, -0.35534242f, -0.01398662f, -0.09114642f, 
    -0.13133636f, 0.02905895f, 0.33795729f, 0.12431821f, 0.50071120f, 0.38805765f, -0.02709134f, -0.33196026f, 
    -0.50078064f, 0.08807392f, 0.12922390f, 0.14812241f, 0.08046207f, 0.03925770f, -0.01760145f, -0.14341933f, 
    -0.32840955f, -0.25365007f, 0.01199343f, -0.04950844f, 0.09350801f, 0.21959054f, -0.08305170f, -0.15921043f, 
    -0.06848196f, -0.22998722f, -0.44355121f, -0.08352698f, 0.14299920f, 0.11377480f, 0.17120607f, 0.09358316f, 
    -0.04036899f, -0.00319566f, 0.54791713f, 0.12876408f, -0.02533647f, -0.09467950f, -0.06304338f, -0.00507875f, 
    -0.06058255f, -0.15232195f, -0.00088002f, 0.19240662f, 0.08629718f, 0.17597151f, -0.14893985f, -0.04797713f, 
    0.18081076f, -0.14366874f, -0.24484518f, -0.03638950f, 0.16631323f, -0.18497984f, 0.10917106f, -0.07201697f, 
    0.16661434f, -0.14909683f, 0.36730015f, 0.16177252f, 0.12363888f, -0.05924605f, -0.24847201f, 0.17045791f, 
    0.02361626f, 0.07066913f, 0.00197067f, -0.23878597f, -0.22794883f, 0.11452252f, -0.20467108f, 0.09008200f, 
    0.19901355f, -0.11131968f, 0.01546471f, -0.05819871f, -0.00970496f, -0.06481367f, 0.00610454f, -0.00036966f, 
    -0.17549589f, -0.08290676f, 0.13982813f, 0.03123176f, 0.10269531f, 0.03485537f, -0.05002080f, -0.01660662f, 
    0.09070531f, 0.42234245f, 0.23075391f, 0.03587456f, 0.06806914f, 0.09961779f, 0.39227259f, 0.15375470f, 
    -0.04440376f, -0.15080093f, -0.18439271f, -0.01576327f, -0.20324580f, -0.25426543f, -0.13859606f, -0.10577400f, 
    0.07536653f, 0.14748374f, -0.17745987f, -0.24952929f, 0.15653807f, 0.01361815f, -0.10838147f, -0.03566389f, 
    0.00797655f, 0.01172348f, -0.06789625f, 0.10393198f, -0.01239087f, 0.03178629f, -0.30768162f, -0.02634434f, 
    -0.00384158f, -0.18275143f, 0.07553647f, 0.03125510f, 0.01400305f, 0.00773254f, -0.07964104f, 0.14265774f, 
    -0.13988140f, 0.16630682f, -0.11490884f, -0.08514561f, -0.41625148f, -0.11098193f, 0.24765290f, -0.03220279f, 
    0.32451764f, -0.01049040f, 0.13286494f, 0.26586241f, -0.26423234f, 0.14155181f, -0.05816929f, 0.10306674f, 
    -0.10565000f, 0.01929482f, -0.02262506f, 0.05654279f, -0.03423481f, 0.24182729f, 0.00794695f, 0.18397175f, 
    -0.14035034f, -0.07330362f, -0.03756488f, 0.08737414f, 0.10614160f, 0.20709814f, 0.27823251f, -0.16717398f, 
    0.07418385f, 0.14171103f, 0.20318617f, 0.11628857f, -0.12693107f, 0.03833566f, -0.25506526f, 0.07570118f, 
    -0.15184513f, 0.04387603f, 0.02032163f, 0.01968515f, 0.20538659f, -0.24427502f, 0.06733176f, -0.08176093f, 
    -0.00597447f, -0.03140532f, -0.17958716f, -0.03782989f, 0.00821675f, 0.03821334f, 0.18388572f, 0.06890482f, 
    -0.15222813f, 0.08829580f, 0.34900334f, -0.16803604f, 0.25503024f, -0.05270183f, 0.04568998f, -0.13316014f, 
    -0.30441880f, -0.14278945f, -0.24383742f, -0.14715010f, 0.20348506f, -0.07060805f, 0.18182226f, -0.04484944f, 
    0.32729948f, 0.13447952f, 0.31296235f, 0.23501867f, 0.06603234f, -0.04387034f, 0.13461344f, -0.01509970f, 
    -0.39416414f, -0.08893084f, -0.22943158f, -0.10381080f, -0.16316326f, -0.14554775f, -0.24126895f, 0.31641462f, 
    -0.04778069f, 0.33400044f, -0.03361749f, 0.09912280f, 0.44406897f, 0.15030722f, 0.16893956f, 0.02020227f, 
    0.12345125f, -0.12111474f, -0.00660543f, -0.00283269f, 0.23306854f, -0.15399094f, 0.29720652f, 0.26612931f, 
    0.32440600f, 0.06761539f, 0.20862791f, 0.02084420f, 0.19718924f, -0.08961297f, -0.02424070f, -0.11968353f, 
    -0.01417244f, -0.25879201f, -0.19725168f, -0.30393890f, -0.07577045f, -0.10627396f, 0.18768251f, -0.16415721f, 
    -0.17444614f, -0.10062429f, -0.00093868f, 0.17832626f, -0.06088642f, -0.41214201f, 0.15797220f, -0.01470021f, 
    -0.19343758f, 0.00940213f, -0.15526117f, -0.11239543f, -0.04665032f, -0.15563779f, 0.00461583f, 0.00155785f, 
    -0.06345031f, 0.08850054f, 0.10897507f, -0.10464420f, 0.07137262f, -0.00983104f, -0.20281942f, -0.17580169f, 
    -0.20849343f, 0.10432754f, -0.22036399f, -0.16480413f, -0.13443047f, 0.07855219f, 0.09877496f, -0.15643957f, 
    -0.09726907f, -0.07972688f, -0.14478989f, 0.03278388f, 0.14757961f, -0.14568923f, 0.00862509f, 0.13659188f, 
    -0.02019688f, 0.20387097f, -0.15243976f, 0.11974675f, -0.24219720f, 0.02157609f, 0.23947202f, -0.04773159f, 
    0.39595217f, -0.08275350f, 0.11878860f, -0.12087263f, -0.14192763f, 0.01507807f, -0.06312023f, -0.14947979f, 
    0.03678102f, -0.10129076f, -0.31689021f, 0.05710487f, -0.17702462f, 0.22671187f, -0.11946083f, 0.01270074f, 
    0.17538714f, 0.15588711f, 0.15884498f, 0.05147826f, 0.13182253f, -0.00762994f, 0.18243115f, -0.02531951f, 
    0.06741499f, -0.14782126f, -0.05863545f, 0.01482452f, 0.31661695f, 0.03307278f, -0.24031928f, 0.16136388f, 
    -0.39953533f, 0.02140242f, -0.18785767f, 0.24235670f, 0.19637698f, 0.06903452f, -0.01270727f, 0.04866172f, 
    0.13699310f, 0.08469184f, 0.33349189f, -0.01439384f, 0.05503738f, 0.13868085f, -0.01959999f, -0.20277980f, 
    0.01270219f, 0.26709935f, 0.07032029f, -0.09898876f, 0.03836729f, 0.34218958f, 0.14352354f, -0.00657694f, 
    -0.17760290f, -0.17194566f, 0.30563954f, -0.00446017f, 0.08808093f, 0.17030698f, 0.14717849f, -0.15417877f, 
    -0.28340486f, -0.06074140f, 0.25325251f, 0.00337054f, 0.37841633f, 0.10618741f, -0.00716851f, -0.05977197f, 
    -0.11069040f, 0.14990284f, 0.28456545f, -0.02265533f, -0.16707857f, 0.09471099f, -0.20123778f, -0.26518711f, 
    0.10177467f, -0.11306768f, -0.47296154f, -0.13350932f, 0.05801364f, -0.29477805f, 0.31139672f, -0.04910922f, 
    0.41947183f, -0.02191963f, -0.17422745f, 0.19063397f, 0.45419151f, -0.07557642f, 0.17917801f, -0.00377431f, 
    -0.67426038f, 0.05242117f, -0.08708581f, -0.12120823f, -0.22123718f, 0.16171882f, 0.26015159f, -0.12788914f, 
    0.10267381f, -0.39345336f, 0.19983986f, -0.09375244f, 0.09137814f, 0.22945856f, 0.09530022f, -0.32285833f, 
    -0.03098763f, -0.08546882f, 0.06076435f, 0.13187777f, -0.20917645f, 0.12931484f, 0.21444274f, 0.14546815f, 
    0.13235606f, 0.09863744f, 0.23322685f, -0.21196404f, -0.12136093f, -0.07193107f, 0.02062454f, -0.08498741f, 
    -0.01013685f, 0.00901099f, 0.33942753f, 0.12428775f, 0.56897521f, -0.12692077f, -0.14014202f, 0.03191786f, 
    0.01533862f, -0.18947212f, -0.04564325f, -0.11255950f, -0.06992697f, -0.01588369f, 0.16867797f, -0.26615381f, 
    -0.01409752f, 0.16865624f, -0.16885509f, 0.10923234f, 0.30668765f, -0.30289766f, 0.03971162f, -0.06900698f, 
    -0.08133998f, -0.16872059f, -0.02186238f, -0.06868144f, -0.10425723f, -0.19334055f, 0.13882421f, -0.17492671f, 
    0.07751217f, -0.09056669f, -0.18645436f, -0.12153579f, -0.10403703f, 0.13520956f, -0.11447410f, -0.04527593f, 
    0.07109933f, -0.19830947f, 0.14623901f, -0.01787968f, -0.02255562f, -0.10377023f, -0.06920309f, -0.09805081f, 
    0.03239160f, 0.05408518f, -0.09775620f, -0.00084686f, 0.07634985f, 0.10893632f, 0.13080049f, 0.06929663f, 
    0.07841472f, -0.07954755f, -0.10596415f, -0.00678940f, -0.19356574f, -0.11808375f, 0.10497103f, -0.17027180f, 
    -0.18047088f, -0.05619281f, 0.05027102f, -0.05075789f, 0.01088788f, -0.19920257f, 0.04728365f, -0.02369458f, 
    0.14906545f, -0.04486167f, 0.06362595f, -0.07799173f, 0.02049631f, -0.13506538f, -0.14176905f, -0.05060028f, 
    0.11898780f, -0.01853374f, -0.06779560f, -0.13030863f, -0.17316732f, 0.02284680f, -0.02916813f, 0.07521320f, 
    -0.17875575f, -0.20853198f, 0.15483727f, 0.05718208f, -0.11182147f, 0.12855873f, 0.11838933f, -0.14236906f, 
    0.02227832f, -0.11936811f, -0.08965893f, -0.21572460f, 0.05088177f, -0.15187117f, 0.18088517f, 0.05794189f, 
    -0.04947088f, 0.02572056f, 0.08617296f, 0.10732892f, -0.02301840f, -0.23675454f, -0.18094146f, 0.07905520f, 
    0.06804888f, -0.13882305f, -0.19882156f, 0.16686726f, 0.15737054f, 0.08744168f, 0.05873491f, 0.01478427f, 
    -0.15416886f, 0.28153351f, -0.10359021f, 0.17638160f, 0.14857267f, 0.09530690f, -0.21332942f, -0.21886443f, 
    -0.10291590f, 0.04875567f, 0.27341041f, -0.01461646f, -0.07711697f, 0.06981120f, 0.00377715f, -0.12708537f, 
    -0.22397724f, -0.02569837f, -0.07333966f, -0.18344855f, -0.08947548f, -0.13158241f, 0.24667905f, 0.34685680f, 
    -0.07929443f, 0.01591714f, 0.25555578f, 0.13722703f, 0.10491206f, 0.23400998f, 0.08175043f, -0.10155801f, 
    0.22664556f, 0.04975969f, 0.13422431f, -0.08263746f, 0.40625355f, -0.07663250f, 0.25766256f, 0.25643417f, 
    -0.00707554f, -0.03659645f, -0.14836919f, -0.13141507f, -0.34588817f, -0.28368640f, 0.35645640f, -0.07293271f, 
    0.06520838f, -0.28726968f, -0.19398981f, 0.02537129f, 0.06078372f, 0.23158613f, 0.08640801f, 0.11033953f, 
    -0.09349830f, -0.06756572f, 0.18974118f, -0.02214924f, 0.05947658f, 0.13650168f, 0.21783356f, 0.14121671f, 
    0.21414919f, 0.30790746f, 0.17025471f, 0.06636010f, 0.12916933f, -0.05944840f, 0.35116914f, 0.15946639f, 
    -0.22014101f, -0.17567231f, -0.22909921f, 0.19725464f, 0.18604171f, -0.10044813f, 0.21645026f, 0.16824602f, 
    0.13200203f, -0.28907350f, 0.25560817f, -0.14258216f, 0.08680034f, 0.30237913f, 0.05398626f, -0.24990907f, 
    0.15222420f, -0.30222800f, -0.07294389f, 0.02225670f, -0.27668455f, -0.09190078f, 0.06907935f, -0.04537000f, 
    0.08512161f, 0.17338333f, 0.01842806f, -0.17540181f, 0.00041500f, 0.03148751f, -0.04907624f, -0.11521817f, 
    0.23999088f, -0.01496965f, 0.01413409f, -0.29911166f, 0.09657602f, 0.10548691f, 0.04134058f, -0.02544888f, 
    -0.17935812f, 0.19936100f, 0.20781630f, 0.12946472f, 0.15580541f, -0.55626482f, -0.09994512f, -0.25905466f, 
    0.11024851f, 0.36078873f, 0.10629642f, -0.07827190f, 0.23370130f, 0.06006104f, 0.29904851f, -0.08948159f, 
    -0.01746510f, -0.24883036f, -0.16780663f, 0.14056119f, -0.06385832f, -0.09271348f, -0.13882250f, 0.02583815f, 
    -0.20812155f, 0.09492992f, -0.01276398f, 0.02491045f, -0.08228336f, -0.12174855f, 0.12676316f, -0.01084390f, 
    -0.13492772f, 0.11766712f, -0.16468464f, -0.10361792f, -0.13526793f, -0.08897483f, -0.14289652f, -0.03257795f, 
    -0.08155777f, 0.05733923f, 0.07991945f, -0.17318432f, -0.09033484f, 0.05210880f, 0.16631398f, 0.03432882f, 
    -0.07100888f, 0.08724249f, 0.31974462f, 0.10519687f, -0.43169123f, 0.14198154f, -0.12156492f, 0.02975901f, 
    0.52560765f, 0.11460993f, 0.19754817f, -0.04671360f, 0.33575392f, 0.10862312f, -0.15963390f, 0.12359636f, 
    -0.15769082f, -0.38544050f, 0.12045172f, -0.26637441f, -0.15301071f, 0.39621568f, 0.12552010f, -0.39912221f, 
    -0.13026348f, -0.02401519f, -0.23493484f, 0.02921858f, 0.30980024f, -0.19050907f, 0.17807202f, -0.10434252f, 
    -0.04170465f, -0.09150188f, -0.19191353f, -0.17962259f, -0.02042043f, 0.18320501f, -0.17976555f, -0.16548294f, 
    -0.13435377f, -0.09025156f, 0.16584803f, -0.07148963f, 0.45732835f, 0.13184519f, -0.12626925f, 0.14445356f, 
    0.09798382f, -0.09381449f, 0.14797851f, -0.01197424f, 0.07005310f, -0.18539923f, 0.20970301f, 0.02861767f, 
    -0.01113534f, -0.00743451f, -0.02085395f, 0.05928270f, 0.10471296f, -0.40636688f, 0.19857909f, -0.15234198f, 
    0.08377901f, 0.04190369f, -0.25097576f, -0.23831955f, 0.26741555f, -0.17875396f, 0.23185436f, 0.02148606f, 
    -0.03439603f, 0.01977959f, -0.24018551f, 0.32868883f, 0.14873755f, -0.09870070f, 0.04178037f, -0.11535738f, 
    0.32529885f, -0.22507556f, 0.31910664f, -0.23648807f, -0.14676405f, 0.02067319f, 0.06333042f, -0.22133987f, 
    0.02334089f, -0.07554701f, 0.11913925f, 0.17300898f, 0.02258555f, 0.40256256f, 0.03635199f, 0.02870866f, 
    -0.01472199f, -0.02575376f, 0.22501495f, -0.26501846f, 0.17099698f, -0.10574538f, 0.51809174f, -0.17640607f, 
    0.17609546f, -0.09312178f, 0.26178715f, 0.25607190f, 0.32973930f, -0.00869236f, 0.03688211f, 0.01054770f, 
    0.19242153f, -0.22726272f, -0.03908726f, -0.29098418f, 0.04200285f, 0.07097752f, -0.07682552f, -0.29222080f, 
    -0.07865627f, -0.18972267f, -0.37086532f, 0.15131149f, -0.02724994f, -0.41842949f, 0.38863495f, 0.14240319f, 
    0.01051430f, 0.20804635f, 0.12254204f, 0.07394039f, -0.32342577f, 0.14663833f, -0.19221158f, -0.04904464f, 
    0.24642731f, -0.00156037f, -0.15580858f, 0.07301521f, 0.44144157f, -0.12634724f, -0.17190208f, 0.01264392f, 
    -0.06827795f, 0.02207957f, 0.18615323f, -0.16062675f, -0.07080068f, -0.09843364f, -0.15577489f, 0.07014320f, 
    0.01750553f, 0.09460792f, 0.58825898f, 0.02001659f, 0.20737891f, 0.51429546f, 0.12789541f, 0.08888103f, 
    -0.04032318f, 0.10962304f, 0.34047943f, 0.47220582f, -0.20025343f, 0.32536438f, -0.04188084f, -0.16524276f, 
    0.16802572f, 0.13072969f, 0.27114528f, 0.00739189f, 0.15730289f, 0.33375171f, 0.18138163f, 0.02777663f, 
    -0.20533341f, -0.01411010f, 0.01909610f, -0.10276060f, -0.10951365f, 0.19018304f, 0.03283685f, -0.34435877f, 
    0.01596545f, -0.53081465f, -0.13934411f, 0.04407858f, -0.04183282f, 0.18483284f, -0.19896957f, 0.15040213f, 
    -0.16072993f, 0.21068197f, 0.38762450f, 0.33492634f, -0.33338591f, 0.28446788f, -0.00687977f, 0.05980825f, 
    0.33472320f, -0.03843711f, -0.12000588f, 0.00626717f, -0.07738766f, 0.08992917f, 0.26283443f, 0.13632207f, 
    -0.15714628f, 0.00000403f, 0.21796401f, -0.10650682f, -0.16817527f, 0.55528283f, -0.08749225f, -0.38324964f, 
    0.06048464f, -0.32146582f, -0.36728692f, -0.17624193f, 0.07020393f, 0.22403936f, 0.05226225f, 0.13505335f, 
    0.23921064f, -0.24905208f, -0.03696206f, -0.29277542f, 0.46888211f, 0.07220777f, 0.33108562f, 0.17959204f, 
    0.06607752f, -0.12034287f, -0.12344263f, -0.09530361f, 0.05603893f, 0.10115577f, 0.07680646f, 0.16334862f, 
    -0.10984212f, 0.07138641f, -0.14410152f, -0.06268346f, -0.15765132f, -0.21923517f, 0.10220448f, -0.00810208f, 
    0.13213632f, 0.44924173f, -0.10889383f, 0.11411634f, -0.04599494f, -0.12929638f, 0.20909336f, -0.14008385f, 
    0.04559955f, 0.13759005f, -0.08575871f, -0.07321575f, 0.02711949f, 0.08291870f, 0.17503156f, -0.08145525f, 
    -0.24392302f, 0.02707821f, 0.19327608f, -0.04377421f, 0.03014186f, 0.21417595f, -0.16589057f, -0.05865217f, 
    0.05697166f, 0.13711077f, 0.25259763f, -0.23358984f, 0.13167244f, -0.13979669f, 0.22419873f, -0.13154422f, 
    0.12418435f, 0.21097612f, -0.25644174f, -0.11081555f, -0.18618849f, -0.06749520f, 0.48696145f, 0.11195280f, 
    0.09395895f, 0.09525243f, -0.11248645f, -0.38149554f, -0.10118135f, -0.36606154f, -0.33761042f, 0.05627375f, 
    -0.05186478f, -0.10744619f, -0.19804415f, 0.13608493f, 0.06731163f, -0.12881598f, -0.38761711f, -0.16797976f, 
    0.15742341f, 0.13670067f, -0.22088300f, -0.06532837f, 0.08503678f, 0.20974547f, 0.06582446f, -0.02961102f, 
    -0.00979984f, 0.28765410f, 0.31435445f, 0.15633503f, -0.24145067f, -0.06825814f, 0.22537547f, 0.00664421f, 
    0.17376778f, 0.32358810f, -0.38913295f, 0.16367942f, 0.42657679f, 0.21008795f, 0.23781638f, -0.20146950f, 
    -0.56530654f, -0.16591251f, 0.03748034f, -0.24690215f, -0.11560094f, 0.02346653f, -0.04426037f, 0.04894344f, 
    0.23535886f, 0.05411354f, 0.01398519f, -0.22167046f, -0.06927375f, -0.09545155f, 0.18164513f, 0.04230170f, 
    -0.12723041f, 0.09561393f, -0.13621984f, 0.03795760f, -0.17351304f, -0.19510953f, 0.40617406f, -0.13225576f, 
    -0.12490576f, 0.19896890f, 0.12104917f, 0.19064733f, -0.04549305f, -0.22344401f, -0.01536834f, 0.13811140f, 
    0.41066030f, -0.13354631f, 0.00900504f, 0.24958663f, -0.17260776f, -0.04562152f, 0.36843902f, 0.11166847f, 
    0.13857758f, -0.05699372f, 0.09313761f, -0.07918540f, -0.09945291f, 0.07235140f, 0.11376991f, 0.14547297f, 
    0.06276689f, -0.05425470f, 0.13389944f, 0.17157601f, 0.00485333f, 0.49371621f, -0.38187978f, -0.09895962f, 
    0.23590344f, 0.13296443f, 0.00867529f, -0.24332358f, -0.16261630f, -0.03971562f, -0.08841271f, 0.00470872f, 
    0.13384427f, 0.04519740f, 0.13561603f, -0.01862946f, 0.51588172f, 0.00016890f, -0.30239451f, -0.04287249f, 
    0.07350384f, -0.06199702f, 0.10312788f, -0.03948166f, -0.10103136f, -0.00629241f, -0.11863846f, -0.09822794f, 
    0.09727397f, 0.05967242f, 0.34649915f, 0.09183676f, 0.19006683f, -0.06159180f, 0.12161369f, 0.07199986f, 
    0.07143245f, 0.05450127f, 0.33530423f, 0.03244343f, -0.11988690f, 0.07841796f, -0.10297233f, -0.09411751f, 
    0.09577174f, 0.16379023f, -0.20182571f, 0.20538981f, -0.17777923f, 0.13704194f, 0.23177993f, -0.16952588f, 
    0.11349148f, 0.16695994f, 0.17953670f, -0.04531720f, 0.06208152f, 0.43004572f, -0.11273635f, 0.15518939f, 
    0.06373730f, 0.14564079f, -0.06155854f, -0.07407091f, -0.14743207f, 0.29137659f, -0.09663273f, -0.09751438f, 
    0.32522714f, 0.38136443f, -0.04855457f, 0.12551017f, -0.27415568f, -0.14996779f, 0.01690046f, -0.04024233f, 
    0.33203539f, -0.14331916f, -0.04096723f, -0.02675527f, 0.35057735f, 0.24490069f, 0.00250988f, 0.16884959f, 
    0.06435826f, -0.39196461f, 0.12470190f, -0.33173665f, -0.13975435f, 0.00354240f, 0.21030934f, -0.19584818f, 
    -0.02378026f, -0.12686150f, 0.12872621f, -0.16197860f, -0.00865606f, -0.36288944f, -0.01425375f, -0.00437037f, 
    0.08641493f, -0.07378565f, 0.27510598f, 0.01069505f, 0.22498623f, -0.19188830f, 0.37146690f, 0.21967982f, 
    0.24290332f, 0.16117460f, -0.24489821f, 0.13047892f, 0.19561836f, -0.02466504f, 0.05984648f, 0.09633642f, 
    0.17016520f, -0.11643686f, 0.17488021f, -0.05674972f, -0.05616041f, 0.22981229f, 0.12829897f, -0.37124196f, 
    -0.17877761f, -0.14546195f, 0.02345768f, 0.08481882f, -0.12549815f, -0.43271646f, 0.07104231f, -0.08025041f, 
    0.11573365f, 0.09847795f, -0.12669764f, 0.17496280f, 0.40127203f, -0.09940872f, 0.21060567f, -0.17172018f, 
    -0.12624294f, -0.02104405f, -0.07135578f, -0.02812741f, -0.22907752f, -0.08090571f, 0.18069433f, -0.06579355f, 
    -0.01566759f, 0.10127108f, 0.22574411f, 0.16690780f, 0.06459405f, -0.03453739f, -0.15105079f, 0.31550997f, 
    0.10470334f, 0.34747124f, 0.40178809f, 0.03692739f, 0.03468654f, 0.34177190f, 0.26190144f, -0.00661312f, 
    -0.14837533f, -0.24638328f, 0.30907324f, -0.19379145f, 0.19336860f, 0.30790386f, 0.32555160f, 0.07094383f, 
    0.17144339f, 0.17758581f, 0.10614324f, 0.18965162f, 0.27825224f, 0.02096366f, -0.06209574f, 0.09819044f, 
    -0.35688382f, -0.01584727f, 0.13099326f, -0.01023129f, 0.04194747f, -0.03506325f, -0.27759609f, -0.46353057f, 
    -0.16310924f, 0.09960879f, -0.41213775f, 0.02870427f, 0.31396216f, -0.27130499f, 0.02051756f, 0.02523457f, 
    0.01459588f, -0.12661189f, 0.20933570f, 0.23510674f, 0.30404016f, -0.14223705f, -0.03895668f, -0.02225359f, 
    -0.21723403f, 0.05864835f, -0.13590036f, 0.39884964f, -0.38554692f, 0.21221331f, 0.41026869f, -0.09404180f, 
    0.08365151f, -0.11155573f, -0.15503553f, 0.21396118f, -0.03815205f, 0.32693791f, 0.06838741f, -0.24571893f, 
    0.04055421f, -0.33167920f, -0.02843039f, -0.08314019f, -0.24343899f, 0.26944128f, -0.33914307f, -0.03470099f, 
    0.41285568f, -0.19052842f, -0.33292288f, 0.22931135f, 0.35780162f, -0.03418467f, 0.30635160f, 0.13727087f, 
    0.10495417f, 0.04486035f, 0.20892590f, -0.25254279f, 0.13414052f, 0.05383953f, 0.31170255f, 0.17520848f, 
    -0.11760136f, -0.20103998f, -0.26385769f, 0.06719279f, -0.09599959f, -0.24632792f, -0.07705675f, -0.12130622f, 
    -0.05587066f, 0.13482410f, 0.29002044f, -0.04052091f, -0.02481518f, -0.32989946f, -0.15342382f, -0.03769859f, 
    -0.02819503f, -0.15409915f, 0.15797633f, -0.03176682f, 0.13515447f, -0.35172066f, -0.17782040f, 0.19906197f, 
    0.14185341f, -0.07590206f, -0.15839046f, 0.11396175f, -0.05660193f, 0.09805540f, -0.02602323f, 0.01546112f, 
    0.06033347f, -0.12484670f, -0.11203492f, 0.02655339f, -0.11007121f, 0.03953192f, 0.37521014f, 0.10614341f, 
    0.11856905f, -0.00216904f, 0.27695075f, 0.04787245f, -0.07150280f, 0.12947510f, -0.18488024f, -0.05063818f, 
    -0.00510132f, -0.05430607f, -0.10124456f, 0.21920498f, 0.02198245f, -0.12653975f, -0.01950838f, 0.09869077f, 
    -0.02777076f, -0.10505504f, -0.05077037f, -0.06169857f, -0.17827983f, 0.06905048f, 0.20107982f, 0.04345328f, 
    0.04052423f, 0.15096955f, 0.28751391f, 0.08481271f, -0.16325729f, 0.00324401f, -0.19549461f, 0.18466957f, 
    -0.04730414f, -0.10570619f, 0.14845169f, -0.00728300f, -0.06144616f, 0.04220470f, -0.02963481f, 0.05476640f, 
    -0.24154986f, -0.19381358f, 0.17043908f, -0.15242635f, 0.19839644f, 0.26706982f, -0.11976569f, -0.20076130f, 
    0.01998683f, -0.05497834f, 0.14190124f, 0.23163135f, 0.53482103f, -0.02160317f, -0.09752284f, -0.11085302f, 
    -0.33046070f, -0.08158639f, 0.21794885f, -0.07358862f, -0.03507156f, 0.06123155f, -0.34872741f, -0.08798131f, 
    0.07210852f, 0.39792088f, -0.08940058f, 0.03571692f, 0.45198655f, 0.22114760f, 0.14592753f, 0.02072517f, 
    0.19625597f, 0.18996285f, -0.23075250f, 0.22303544f, -0.14652708f, -0.10505561f, 0.04500654f, -0.33466437f, 
    0.23313960f, 0.04294370f, -0.17603467f, 0.06047393f, -0.20556614f, 0.19240975f, 0.00220018f, 0.08776738f, 
    -0.07579896f, -0.02235870f, 0.43235523f, -0.19939581f, -0.10739850f, 0.22333214f, 0.00062113f, -0.24167359f, 
    -0.12970337f, -0.11364592f, 0.00441989f, -0.06561288f, -0.09575401f, 0.13492469f, 0.17867766f, -0.07215150f, 
    0.28819314f, 0.13141689f, -0.11816756f, -0.08743007f, 0.52957028f, 0.00515969f, 0.15215398f, 0.11052707f, 
    -0.03102442f, 0.10811494f, 0.10780554f, 0.07331774f, 0.38102657f, -0.15071936f, -0.17928962f, -0.04856623f, 
    -0.01161796f, -0.27937996f, -0.09814040f, -0.06195790f, -0.09881245f, -0.12968758f, 0.17901383f, 0.09531901f, 
    0.12672448f, 0.00246100f, 0.16105568f, 0.09476764f, 0.03200990f, -0.35566214f, -0.12931350f, -0.15226054f, 
    0.20234412f, -0.07894500f, 0.05789119f, -0.15365861f, -0.33496246f, 0.13482010f, 0.40958655f, 0.02293612f, 
    0.55842805f, 0.08281929f, -0.12741135f, -0.09372126f, -0.06048054f, -0.09305014f, 0.10354432f, 0.02724987f, 
    0.05923079f, -0.01461990f, 0.15667984f, -0.05084664f, -0.06623071f, 0.41660812f, 0.05442176f, -0.51328605f, 
    0.08527479f, 0.00746116f, -0.38889900f, 0.05650082f, 0.20618150f, 0.13909101f, 0.37145796f, 0.15665083f, 
    -0.17438456f, 0.08657746f, 0.24985720f, -0.01161890f, 0.00597842f, 0.14257626f, -0.03283041f, -0.23239443f, 
    -0.20901462f, -0.04891490f, 0.22420372f, 0.29485264f, 0.16637619f, 0.07931818f, -0.18994522f, -0.06503823f, 
    0.10415739f, 0.06738149f, -0.01413234f, -0.11505976f, 0.02692295f, 0.34273362f, -0.08468292f, -0.21634506f, 
    0.14322580f, 0.41853321f, -0.15252604f, 0.02203421f, 0.02424811f, 0.06708305f, 0.23422758f, 0.14789645f, 
    -0.07271894f, 0.04403833f, 0.05350776f, 0.05603329f, 0.01026357f, 0.14561151f, 0.35638505f, -0.54028636f, 
    0.02202207f, -0.05105539f, 0.26638126f, 0.05130198f, 0.18967335f, 0.10316645f, 0.23480304f, 0.08302369f, 
    -0.35845393f, -0.18851011f, 0.24701321f, -0.02595918f, -0.00169134f, 0.23762576f, -0.20517151f, -0.31426048f, 
    0.07737321f, -0.23829779f, -0.28940520f, 0.02939433f, 0.03533125f, 0.07709830f, 0.12082656f, -0.12157470f, 
    -0.32376203f, -0.08008122f, 0.41222185f, 0.14298274f, -0.12434021f, 0.46351549f, -0.27936915f, -0.22208849f, 
    -0.12323802f, 0.11177520f, 0.16592242f, -0.08819381f, 0.29662538f, -0.16275327f, 0.11958265f, 0.04835797f, 
    -0.51361465f, -0.17486830f, 0.04400586f, -0.00310651f, 0.09559670f, 0.33450350f, -0.10634588f, 0.18968047f, 
    -0.05317879f, 0.07908775f, -0.06349637f, -0.17116693f, 0.45328394f, 0.13706267f, 0.11204953f, -0.13764715f, 
    -0.18047382f, -0.33917058f, 0.41539842f, -0.12876485f, 0.42608428f, 0.39082146f, 0.29336289f, -0.00061540f, 
    -0.29398671f, -0.06714429f, 0.04504215f, 0.07533212f, 0.23410979f, -0.10974158f, 0.06257696f, 0.02476970f, 
    -0.27454546f, 0.09822553f, -0.01053205f, 0.05303612f, 0.12458608f, 0.06599963f, -0.06714609f, -0.02675121f, 
    -0.00244272f, 0.17122498f, -0.28029281f, -0.07892370f, 0.25057036f, -0.35061881f, -0.00301426f, 0.15524435f, 
    0.04457084f, 0.07290510f, 0.31084394f, -0.34831589f, -0.27714616f, -0.33726275f, -0.19266947f, -0.04572418f, 
    0.03633092f, -0.15160428f, -0.35222208f, -0.03888487f, 0.06705731f, -0.07786317f, -0.06958521f, -0.12325606f, 
    -0.16377477f, 0.07860400f, 0.20977969f, 0.04273370f, 0.13317731f, -0.15352803f, -0.06146008f, -0.11061184f, 
    -0.01925889f, 0.16779450f, 0.14094722f, 0.09787868f, 0.13340335f, -0.23282166f, -0.22945942f, -0.17014819f, 
    -0.05204313f, -0.15464412f, 0.30850053f, 0.21902302f, -0.08545510f, 0.38150212f, 0.03114777f, -0.15845717f, 
    -0.23426285f, -0.11203163f, 0.08636036f, -0.18247008f, -0.00758404f, -0.18304284f, 0.14125776f, 0.08857372f, 
    -0.01409032f, 0.13409442f, -0.06706011f, 0.16648565f, -0.09540656f, 0.24764156f, -0.08984385f, 0.01441191f, 
    -0.01438714f, 0.21756093f, 0.17137606f, -0.06766355f, 0.15384129f, 0.33037394f, 0.16536120f, 0.02737935f, 
    -0.03724056f, -0.04962380f, -0.00682312f, -0.13857047f, -0.15990126f, -0.15274663f, 0.09156613f, 0.01852467f, 
    -0.09563323f, -0.17527474f, -0.13767736f, -0.02816921f, 0.05058303f, -0.16139990f, -0.13181043f, -0.03556582f, 
    -0.02215830f, -0.07745563f, 0.09975757f, -0.21994507f, 0.04381812f, 0.11358526f, 0.04072661f, -0.18858677f, 
    0.01969358f, 0.05717069f, 0.02247990f, -0.04949635f, -0.09450600f, 0.11794847f, -0.18399741f, 0.03375212f, 
    -0.15400133f, 0.27101994f, 0.10858907f, 0.15850119f, -0.10706944f, 0.04954999f, -0.19370349f, -0.07176320f, 
    0.13318598f, 0.07675894f, -0.17477408f, -0.13902815f, -0.01001655f, 0.09840509f, 0.21450146f, 0.15437336f, 
    -0.09920990f, 0.02785443f, 0.00779101f, 0.23853472f, -0.03662087f, 0.22324318f, 0.02232119f, 0.38293406f, 
    -0.15560082f, -0.25463828f, 0.19140413f, -0.07522791f, 0.13290963f, 0.50493574f, -0.25227162f, -0.04745448f, 
    -0.04414370f, -0.05882825f, -0.14306077f, -0.00862550f, 0.11945777f, -0.08566517f, -0.00057936f, 0.00859991f, 
    0.30498263f, 0.14075898f, -0.01278182f, -0.17307071f, 0.16612026f, 0.14475064f, -0.05917393f, 0.13585021f, 
    0.13985479f, -0.11077547f, -0.08401255f, -0.03794110f, 0.00274439f, -0.53125125f, 0.15708719f, 0.16557431f, 
    -0.10761928f, 0.04950370f, -0.07331555f, -0.08662988f, -0.01624535f, 0.05482277f, 0.12924980f, -0.09245177f, 
    0.02030751f, 0.12783574f, -0.30827880f, -0.06955042f, 0.25056154f, -0.06239856f, 0.10321495f, 0.20444019f, 
    -0.01231880f, 0.03577826f, 0.03209796f, 0.26362857f, -0.21989648f, 0.09914716f, 0.12761572f, -0.07450012f, 
    0.08939832f, 0.04958632f, -0.03457556f, 0.02771180f, -0.09601396f, -0.02330345f, -0.18834345f, 0.25416917f, 
    0.09574439f, -0.03022215f, 0.38945901f, 0.16504958f, 0.15714931f, 0.42711946f, -0.22392131f, -0.08547162f, 
    0.28534845f, 0.25025982f, -0.14890905f, 0.20242952f, -0.10633726f, -0.30708399f, 0.25459045f, -0.02798062f, 
    0.12769191f, 0.07316165f, -0.10543203f, -0.03460403f, -0.19721434f, -0.04204360f, 0.21712294f, 0.04498672f, 
    0.05535826f, -0.42461544f, -0.16327205f, -0.24536929f, -0.15338258f, 0.09689108f, 0.26053891f, 0.14378457f, 
    0.12551080f, -0.15204808f, -0.15263332f, -0.05634781f, -0.29613253f, 0.03265643f, 0.38660359f, 0.16052857f, 
    -0.20164318f, -0.09216085f, 0.40848175f, 0.21698889f, 0.06235797f, 0.00623386f, -0.23990771f, 0.21380825f, 
    0.05303491f, -0.12264828f, 0.15164275f, 0.08388476f, 0.19129427f, 0.02966040f, 0.17516957f, -0.04285477f, 
    -0.02073463f, -0.13684042f, -0.25354457f, 0.08372136f, 0.06981830f, 0.21909818f, 0.09167069f, 0.21366239f, 
    -0.10843522f, -0.03886623f, 0.20224960f, 0.16428220f, 0.02669837f, 0.20741074f, -0.38290715f, -0.04838292f, 
    -0.04550892f, 0.01932623f, -0.05518435f, 0.17323352f, 0.21322501f, -0.05087040f, 0.13793132f, 0.02139558f, 
    -0.12877983f, -0.08966525f, 0.16724296f, 0.24286525f, -0.21902746f, 0.09665367f, 0.20548338f, -0.07656536f, 
    0.06310754f, -0.16774528f, -0.38409728f, -0.10463858f, -0.08121441f, 0.08681794f, 0.27177516f, 0.13809739f, 
    -0.09802006f, -0.18612799f, -0.26736033f, 0.08032729f, -0.02677153f, -0.06043949f, -0.26648709f, -0.01441466f, 
    0.15292758f, 0.14165238f, 0.34370109f, 0.20498200f, -0.24527426f, -0.09074719f, 0.18473990f, 0.16154467f, 
    0.49368232f, -0.13394699f, 0.11809121f, 0.14287701f, 0.25873923f, 0.23539013f, 0.13790745f, -0.08226036f, 
    -0.08820149f, -0.09643199f, 0.11274644f, -0.23866479f, 0.04036393f, -0.08967882f, 0.07918494f, -0.36572370f, 
    -0.02773666f, -0.33512414f, -0.21628863f, -0.04896836f, -0.18433748f, -0.26692951f, -0.07064259f, 0.11987321f, 
    -0.09084772f, 0.11670266f, 0.12544233f, 0.02218400f, -0.15242818f, -0.01785680f, -0.17089029f, -0.01048276f, 
    0.09347452f, -0.13625564f, -0.17553738f, -0.05270940f, -0.11382779f, -0.00608797f, -0.13465516f, -0.01007956f, 
    -0.17856447f, -0.03698673f, -0.00643434f, -0.17491652f, -0.16677341f, 0.03602612f, 0.03246656f, -0.15036458f, 
    0.16756681f, -0.16087840f, -0.07527744f, 0.12888414f, 0.09902211f, -0.11518466f, 0.13474889f, -0.06255018f, 
    -0.08704747f, 0.14211777f, 0.05863847f, -0.31138447f, -0.07847812f, 0.07965631f, -0.10019281f, 0.01952283f, 
    -0.00808479f, 0.04743097f, 0.00870895f, 0.25798243f, 0.02774714f, 0.03030130f, 0.10686007f, -0.01325742f, 
    0.13407011f, -0.06168554f, -0.13489528f, 0.01369640f, 0.10595138f, -0.01315623f, 0.00764476f, 0.16969207f, 
    0.15291595f, 0.04152247f, 0.15624084f, 0.10487270f, 0.11494571f, -0.11843594f, 0.35583940f, -0.06921786f, 
    -0.09071741f, 0.07177034f, -0.07467838f, 0.08265230f, 0.06161639f, 0.28061569f, 0.26933947f, -0.11557225f, 
    -0.54557329f, -0.16569389f, -0.00820399f, -0.12804151f, 0.22365198f, -0.01230449f, -0.24337459f, 0.15363811f, 
    0.17910750f, 0.21329854f, 0.30882040f, -0.06963069f, 0.00721936f, 0.27324307f, -0.00922168f, -0.16233684f, 
    -0.00458677f, 0.24881281f, 0.00972471f, 0.13084078f, -0.01947705f, -0.15761499f, 0.46198031f, 0.03059901f, 
    0.07764380f, 0.18162595f, 0.32708237f, 0.12399438f, -0.25890595f, -0.01215626f, -0.30771723f, 0.14786386f, 
    0.29432318f, -0.13593373f, -0.10719378f, 0.16632126f, -0.03635333f, 0.14550535f, 0.12227762f, 0.04008419f, 
    -0.02594703f, -0.17712459f, -0.04695751f, 0.17868355f, -0.12005107f, 0.12180445f, 0.07963172f, -0.02329871f, 
    0.06117491f, -0.16084939f, 0.04181124f, 0.04630878f, 0.27417752f, 0.42135641f, -0.04851765f, 0.09647696f, 
    -0.07582942f, -0.26084539f, -0.00672711f, -0.19299603f, 0.47914690f, -0.12337457f, 0.21084809f, 0.11759013f, 
    -0.17109214f, 0.03462584f, 0.07249515f, 0.37738228f, -0.22029844f, -0.00433779f, -0.00595501f, 0.04956365f, 
    0.23903838f, -0.07294469f, -0.23541655f, -0.04879460f, 0.15992108f, 0.28234029f, 0.13317518f, -0.04243402f, 
    -0.14974599f, 0.02817013f, -0.19796824f, 0.11190197f, -0.05757748f, 0.02548321f, -0.08763471f, -0.09333196f, 
    -0.16931333f, 0.09880745f, 0.18781738f, 0.37792757f, -0.13331917f, 0.04509666f, -0.17365375f, -0.24911016f, 
    0.03018712f, 0.10776799f, -0.01273411f, 0.11900879f, -0.27969536f, 0.09362053f, 0.35201409f, -0.15248802f, 
    -0.15517195f, 0.04376285f, 0.05009673f, -0.16975948f, -0.10730594f, 0.22442295f, -0.05012621f, 0.00951896f, 
    0.09886344f, 0.16983491f, -0.23129115f, -0.14474592f, 0.12453541f, 0.50320226f, -0.00840349f, -0.08028722f, 
    0.24344157f, -0.14765185f, -0.25460202f, -0.02218161f, 0.31419575f, -0.17662309f, 0.10971704f, -0.12062001f, 
    0.13152185f, -0.00521626f, 0.02274953f, 0.05561934f, 0.35361275f, 0.37346992f, -0.19837661f, -0.02490533f, 
    0.04952779f, -0.16377732f, 0.04591266f, -0.18034686f, 0.12471066f, -0.59138888f, 0.08434449f, -0.14214224f, 
    -0.11582287f, 0.10980669f, -0.10659847f, -0.09998667f, 0.27549070f, -0.52786803f, 0.16347928f, 0.02838308f, 
    0.02339165f, 0.24940415f, -0.34058046f, 0.00136210f, 0.30225977f, -0.00029229f, 0.08631843f, -0.24351507f, 
    -0.30881032f, 0.10766578f, 0.25090516f, -0.17400928f, 0.00860728f, 0.16315000f, 0.02010393f, -0.12171976f, 
    0.10847802f, -0.03998379f, -0.03829953f, -0.19363028f, -0.01530683f, -0.17007269f, 0.19910449f, 0.19559471f, 
    0.16770503f, 0.00592454f, 0.28528234f, 0.14647768f, -0.09247034f, -0.11771256f, 0.12042432f, -0.04002534f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.16355364f, -0.02596077f, 0.02783727f, 0.22991556f, 0.07380541f, -0.23239735f, -0.16492619f, 0.16802669f, 
    0.13574308f, 0.29425207f, 0.06278872f, 0.07182992f, 0.07988327f, 0.13964790f, 0.16349597f, 0.36256686f, 
    0.07717661f, 0.25598925f, 0.04976087f, -0.09583084f, 0.44880423f, -0.32221720f, 0.09345618f, -0.13006286f, 
    0.16872539f, 0.01216139f, -0.12273557f, 0.26438880f, 0.18683024f, -0.08183176f, 0.28257465f, 0.12744287f, 
    -0.03604887f, 0.14301588f, -0.03764696f, 0.10682673f, 0.13429128f, -0.02400459f, -0.08307058f, -0.06301064f, 
    0.22525023f, -0.01729776f, 0.22081624f, 0.26291713f, 0.25966245f, -0.04929968f, -0.22202955f, 0.13805243f, 
    -0.06959147f, 0.15696555f, -0.01271038f, -0.11044665f, 0.12667759f, 0.30794808f, 0.25883695f, 0.06261338f, 
    0.00208612f, 0.16755420f, 0.25474524f, -0.12576985f, 0.16339549f, -0.08713631f, -0.12514015f, -0.14795288f, 
    -0.03050520f, 0.22716959f, -0.20234093f, -0.21276726f, 0.01933546f, 0.12045084f, 0.27043656f, 0.18967420f, 
    0.04446166f, -0.06433769f, 0.22881861f, 0.14286728f, -0.04464230f, 0.35222906f, 0.00834469f, -0.13381770f, 
    -0.19472815f, 0.12210146f, 0.10582183f, 0.29678974f, 0.34249157f, 0.16521825f, 0.04682655f, 0.15009704f, 
    0.03307715f, 0.09431254f, 0.23564690f, -0.18084249f, -0.01135990f, 0.15410416f, 0.05544803f, 0.22096244f, 
    -0.07848597f, 0.06443188f, 0.13839863f, 0.03965408f, 0.09629671f, -0.03094237f, 0.04279297f, 0.02370354f, 
    0.32347310f, -0.00417302f, -0.09882630f, 0.03912179f, 0.18129610f, 0.00540004f, 0.14967762f, -0.10072806f, 
    -0.08594365f, 0.04510009f, -0.11785243f, -0.20599602f, 0.12237879f, 0.24761339f, 0.01997386f, 0.15005624f, 
    -0.05734030f, -0.12119539f, 0.33909944f, -0.10474943f, 0.04840229f, 0.06266388f, 0.16014297f, 0.07691331f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.08396787f, 0.00458722f, 0.16307725f, -0.12262163f, 0.20857365f, -0.14836711f, 0.04959179f, -0.39061105f, 
    -0.40656534f, -0.34441325f, -0.12906277f, -0.06475382f, -0.18928209f, -0.14426537f, 0.07059835f, -0.35894829f, 
    -0.35443875f, -0.58781856f, 0.09422228f, 0.00114840f, 0.00414044f, 0.18105122f, -0.12587869f, -0.02983357f, 
    -0.38112426f, 0.21498182f, -0.04610904f, -0.05509585f, -0.15095904f, 0.03739214f, 0.00658742f, -0.56567007f, 
    -0.04935876f, -0.12293578f, 0.12459832f, -0.06944664f, 0.14426047f, -0.06248331f, -0.04032323f, 0.04967120f, 
    -0.12208812f, -0.18847306f, 0.25381428f, 0.05373725f, -0.41527602f, 0.07357644f, -0.11480609f, -0.23444287f, 
    0.06150689f, 0.19012909f, -0.27186438f, -0.09551308f, 0.13749862f, -0.26488066f, -0.26160857f, -0.05102677f, 
    -0.01418417f, -0.42744640f, 0.09623907f, -0.12085132f, -0.05942915f, -0.01649440f, 0.00989869f, -0.00953850f, 
    0.14649831f, -0.45123461f, -0.03865298f, -0.00690756f, -0.02807102f, -0.28595987f, -0.01776109f, -0.57027572f, 
    -0.05383236f, -0.09080577f, -0.04023335f, 0.21350689f, 0.00783763f, -0.14585742f, -0.44546127f, 0.09841693f, 
    0.06011784f, -0.04188720f, -0.15634859f, -0.72341990f, 0.20158149f, 0.19546437f, 0.19169256f, 0.03229167f, 
    -0.11917938f, -0.29803991f, -0.17624556f, 0.17347661f, -0.06316941f, 0.09186604f, -0.18010172f, -0.38563538f, 
    0.18283695f, -0.54286963f, 0.06935067f, -0.16353218f, -0.02259804f, 0.06531124f, -0.13635670f, 0.13319458f, 
    -0.12236416f, -0.12044678f, -0.08902533f, 0.06244372f, 0.17176288f, -0.15622559f, 0.05757315f, 0.15280883f, 
    -0.05836686f, 0.23653142f, 0.11897207f, 0.08765968f, 0.00786445f, 0.15217045f, 0.03918650f, -0.01252867f, 
    0.05354730f, -0.09243891f, -0.33440465f, 0.13290437f, -0.07756764f, 0.27217481f, -0.05075677f, -0.03379220f, 
    0.13203914f, -0.01107222f, 0.03232783f, 0.46449324f, 0.26841167f, -0.03652759f, -0.09008688f, -0.05342409f, 
    0.11444864f, 0.12260286f, -0.10024776f, -0.02903059f, -0.11704440f, -0.11520682f, 0.08831540f, -0.09342317f, 
    -0.03397561f, 0.08783727f, 0.22960590f, 0.31115502f, -0.03479235f, -0.01118718f, -0.05586141f, -0.02579127f, 
    -0.25846818f, 0.53941232f, 0.06948286f, 0.01093211f, 0.06020551f, 0.38223085f, 0.06668954f, -0.33251369f, 
    -0.04344079f, 0.02387532f, 0.06692614f, 0.05575506f, 0.21767627f, 0.06396727f, -0.02383501f, -0.06600089f, 
    0.01364844f, -0.04539373f, -0.27149272f, 0.20097287f, -0.25231725f, -0.15891561f, -0.09113672f, 0.01644556f, 
    -0.04487434f, 0.05113075f, -0.21996120f, 0.08330094f, -0.27744749f, 0.08294054f, 0.35267484f, -0.41072485f, 
    -0.08855250f, -0.00375680f, -0.15674454f, -0.05219199f, 0.11474575f, 0.09870078f, -0.13768166f, -0.00515217f, 
    -0.35748768f, -0.01860982f, -0.07169628f, -0.19521128f, 0.08900305f, -0.22062805f, 0.18990907f, -0.31532389f, 
    0.05934213f, 0.00865399f, -0.15175308f, 0.01532311f, 0.17499334f, 0.11046024f, 0.16198859f, -0.02018196f, 
    -0.83670384f, -0.09825434f, -0.02478319f, -0.26498607f, 0.23110135f, -0.05397450f, -0.13840362f, 0.07369692f, 
    -0.06647973f, -0.10646917f, 0.10935545f, 0.10173302f, 0.00192957f, 0.01146388f, -0.03592920f, 0.08963010f, 
    0.16642350f, -0.38691860f, 0.27801192f, 0.23654066f, 0.01072556f, -0.00709316f, -0.67668319f, -0.35124871f, 
    0.10472145f, -0.44465524f, -0.27699816f, -0.34043339f, -0.51912600f, -0.06675162f, 0.32930568f, -0.06026268f, 
    -0.02266214f, -0.01424854f, -0.07666288f, 0.04505563f, 0.00664294f, 0.08493899f, 0.16388197f, -0.05015141f, 
    -0.08001032f, -0.04846442f, -0.02883950f, -0.02945874f, 0.22337180f, -0.09164878f, -0.24101789f, 0.04948792f, 
    -0.32464004f, 0.03969735f, 0.12789273f, -0.24191444f, -0.28759354f, -0.08830991f, -0.07119502f, -0.14016177f, 
    -0.05057553f, -0.26685140f, -0.14190707f, -0.00664397f, -0.03807287f, -0.10592726f, -0.04233688f, 0.08971801f, 
    0.09044205f, 0.28119519f, -0.25855058f, -0.58982193f, 0.11869561f, -0.03255338f, 0.05325240f, 0.06929692f, 
    -0.11459114f, -0.57886171f, -0.04378437f, -0.07355828f, 0.10098261f, -0.72005320f, -0.21597265f, -0.51159549f, 
    0.06727859f, 0.00864387f, -0.10755393f, 0.05594648f, -0.23585698f, 0.03400325f, 0.08735581f, 0.03805055f, 
    -0.06986406f, 0.22710742f, 0.22102982f, 0.10617398f, 0.14611095f, -0.05506521f, -0.10525499f, -0.21041386f, 
    0.14531095f, -0.01921087f, -0.33579743f, -0.21037315f, -0.34224814f, 0.02223822f, -0.36893904f, -0.05735069f, 
    -0.00166583f, 0.30168396f, 0.33465844f, -0.07206599f, -0.27524102f, -0.05053709f, -0.12412661f, -0.10743628f, 
    0.20217088f, 0.17467996f, -0.06134997f, -0.17071004f, 0.12315305f, 0.12831230f, 0.24226442f, -0.02116815f, 
    -0.09223408f, -0.02091122f, -0.09504533f, 0.00698683f, 0.09961534f, 0.08216926f, -0.18343438f, -0.08693172f, 
    -0.54556304f, 0.07546318f, 0.15834725f, 0.21859773f, -0.62110680f, -0.34380674f, -0.48493496f, 0.09992135f, 
    0.12497174f, -0.15834862f, 0.16429421f, -0.17285924f, -0.15265754f, -0.10013272f, -0.41619551f, 0.04832307f, 
    0.10898717f, 0.20702825f, -0.40639874f, 0.18501331f, 0.06149486f, 0.10520070f, 0.10304762f, -0.36880833f, 
    0.12595658f, -0.15207103f, 0.09238376f, 0.18160798f, -0.13497265f, 0.28711611f, -0.13085169f, 0.05896528f, 
    -0.03436629f, 0.05566341f, -0.12979513f, -0.00572772f, -0.25283900f, -0.00181363f, -0.16145928f, -0.26325786f, 
    -0.02598503f, -0.06520061f, 0.12389492f, -0.19611530f, 0.15374246f, -0.51540101f, 0.20853877f, 0.10978483f, 
    -0.16826409f, -0.13435811f, 0.23633118f, -0.02208078f, -0.13579448f, -0.01291987f, -0.25686005f, 0.09144992f, 
    -0.34946498f, 0.13462938f, -0.03003450f, 0.09389837f, 0.29709485f, -0.05256653f, 0.18728927f, 0.23760147f, 
    0.04724095f, 0.17475526f, 0.15800615f, -0.25623971f, -0.10548208f, 0.10410989f, -0.71136153f, -0.03645835f, 
    -0.17749406f, -0.22274750f, -0.12325686f, -0.05958629f, -0.19686177f, -0.17028540f, -0.27833772f, 0.12921461f, 
    -0.01157924f, -0.04688621f, -0.31431627f, -0.49179196f, 0.15425651f, -0.24949796f, 0.23519634f, -0.07815452f, 
    0.17282754f, -0.10016630f, -0.06145158f, -0.34656841f, 0.13087009f, -0.19290376f, 0.03562510f, -0.36110520f, 
    0.01657092f, -0.13579878f, -0.13288616f, 0.04326645f, 0.03136245f, -0.23273905f, -0.30490687f, 0.04789983f, 
    0.26527533f, 0.09025055f, 0.13704844f, 0.34772286f, -0.18898349f, -0.01793361f, 0.00879562f, 0.06302762f, 
    0.20963186f, 0.10579286f, -0.03475403f, 0.10391273f, -0.52901083f, 0.19592641f, -0.15969224f, 0.17191432f, 
    -0.10057963f, -0.10631067f, -0.12992501f, 0.19969738f, -0.31993440f, -0.06162837f, -0.54255211f, 0.10784700f, 
    0.37195039f, 0.20005432f, -0.51635855f, 0.11659008f, -0.22551724f, 0.21419258f, 0.07740067f, -0.24386978f, 
    -0.01629028f, -0.23187196f, -0.09697752f, -0.09835245f, -0.06502461f, -0.16509987f, 0.09602369f, -0.12916464f, 
    -0.61972034f, 0.30166161f, -0.03434473f, 0.03897414f, 0.22962412f, -0.57069165f, 0.00552627f, -0.47641075f, 
    -0.05230887f, -0.34195057f, -0.00782476f, 0.13496293f, 0.25598416f, 0.16078007f, -0.01465036f, 0.01548561f, 
    0.04471312f, -0.06531712f, 0.19437471f, -0.27684391f, -0.14743111f, 0.13032649f, 0.04644951f, 0.10251870f, 
    -0.03777967f, -0.05692149f, -0.14965774f, 0.00578405f, -0.06953658f, -0.05746345f, 0.04262795f, 0.05225514f, 
    -0.03077690f, -0.03307668f, -0.13976608f, -0.20157978f, 0.07802625f, -0.06336842f, 0.07457685f, -0.23396012f, 
    0.03609023f, 0.15267585f, 0.15868264f, 0.06372696f, -0.02005707f, 0.18555242f, -0.05748073f, -0.05283679f, 
    0.07970503f, -0.26825380f, -0.10165422f, -0.27651098f, -0.28121850f, -0.01305944f, 0.00276955f, 0.05565707f, 
    0.18893668f, -0.11196458f, 0.06581830f, -0.16679750f, -0.06242914f, -0.30310351f, -0.18293792f, 0.10372849f, 
    0.01746521f, 0.04977390f, -0.37417960f, 0.10583832f, -0.14135288f, -0.18294476f, 0.07190674f, 0.01949446f, 
    0.08187733f, -0.37886596f, -0.32194185f, -0.14485103f, -0.38278037f, 0.07610618f, -0.35405177f, -0.01624062f, 
    0.05725259f, 0.02426822f, 0.22491416f, -0.13876851f, 0.20626196f, -0.15701999f, -0.05126359f, 0.23086199f, 
    0.05361846f, 0.05144904f, 0.05644096f, 0.05919708f, -0.22337697f, -0.03759168f, 0.19201088f, -0.15207870f, 
    0.08552697f, -0.40215376f, -0.03651657f, -0.04737855f, 0.15569620f, 0.12254596f, -0.09339294f, -0.10701516f, 
    -0.09433866f, -0.01964701f, -0.08176301f, -0.05700250f, -0.22149988f, 0.04974841f, -0.18086207f, -0.05000133f, 
    -0.07974817f, -0.25726539f, 0.25898877f, 0.09455088f, 0.11101022f, 0.12267277f, 0.16603121f, -0.24902436f, 
    -0.07900095f, -0.07598738f, -0.31827044f, 0.12351746f, -0.31498924f, 0.23574784f, -0.35479751f, -0.03193946f, 
    0.05851956f, 0.29861102f, 0.15166107f, -0.61657280f, -0.12451542f, 0.09377888f, 0.19947936f, -0.03747267f, 
    -0.33372381f, 0.02708429f, 0.16769275f, 0.09186583f, -0.03724178f, 0.14629555f, -0.23205832f, 0.04092650f, 
    0.01743965f, 0.08104559f, 0.04691641f, 0.16721392f, -0.41202205f, 0.02983344f, -0.01073486f, 0.04635911f, 
    -0.06706497f, 0.06110036f, -0.03848940f, 0.08389557f, 0.13986510f, 0.09623679f, -0.67593259f, -0.18931635f, 
    0.09566794f, 0.15130372f, -0.01575838f, -0.21564689f, -0.26380682f, -0.14588875f, 0.03460539f, 0.08721193f, 
    -0.02441873f, -0.26528952f, 0.18435951f, 0.05720137f, 0.07351371f, 0.08603688f, 0.12824912f, -0.02645298f, 
    -0.05165032f, -0.00948970f, 0.00284222f, 0.15052947f, -0.29700568f, -0.06132924f, -0.02514547f, -0.09820391f, 
    0.02044841f, -0.34670094f, 0.02006686f, -0.23430622f, -0.12324926f, 0.03167192f, 0.01827600f, 0.10657544f, 
    -0.02387653f, 0.12600757f, 0.35833615f, 0.12321343f, 0.11443275f, -0.13626084f, 0.06219628f, 0.05888983f, 
    0.20776281f, -0.03848356f, -0.72152650f, -0.07201235f, 0.28527036f, 0.28782704f, -0.08752982f, 0.19960694f, 
    -0.16450614f, -0.00496333f, 0.03857933f, -0.07182670f, -0.01083369f, 0.09107703f, -0.31946898f, 0.12290129f, 
    -0.43624890f, -0.10012933f, -0.04684903f, -0.34398481f, -0.08001173f, -0.12838347f, 0.08011289f, -0.14578566f, 
    -0.21638903f, -0.05939244f, -0.10566293f, 0.15815528f, -0.10044055f, -0.06843054f, 0.25185353f, -0.20044355f, 
    0.04548795f, -0.01926961f, -0.10984511f, -0.04455913f, 0.10665668f, 0.22737695f, 0.03269103f, 0.02516010f, 
    -0.06430760f, 0.00163051f, 0.04042163f, 0.07007535f, -0.14822134f, 0.09166946f, 0.15227313f, -0.11762322f, 
    0.10204966f, -0.15423529f, 0.21904261f, 0.00328885f, -0.17126074f, 0.06462491f, 0.12269357f, 0.07209402f, 
    0.07808887f, -0.41512102f, 0.01549721f, -0.09847875f, -0.76724517f, 0.08999768f, -0.51678663f, 0.53805971f, 
    -0.09981593f, 0.20908102f, -0.11984758f, 0.10978616f, -0.21442194f, -0.23753987f, -0.18727247f, -0.02354892f, 
    0.03584554f, 0.02077425f, -0.06874881f, -0.04991949f, 0.26879355f, -0.14924173f, -0.03657524f, 0.06745696f, 
    0.01128504f, -0.04909028f, 0.09393448f, -0.06158320f, -0.04519795f, 0.01781138f, -0.11354429f, 0.04533489f, 
    -0.03319538f, -0.08496392f, -0.19767249f, -0.07612668f, 0.10876498f, -0.09357566f, 0.09845483f, -0.31336141f, 
    -0.22821355f, -0.36059964f, -0.34818929f, 0.00587584f, -0.03874843f, -0.09933250f, -0.32789537f, 0.07187678f, 
    0.02209232f, -0.04089355f, -0.73546529f, -0.47403675f, 0.13680011f, -0.03916386f, 0.13716176f, 0.04436405f, 
    0.10547965f, -0.23441528f, -0.19507173f, 0.20778981f, 0.18181793f, -0.11586907f, 0.16873850f, 0.00205174f, 
    -0.16702721f, -0.00991232f, -0.14209676f, 0.11066804f, -0.91916853f, 0.19618177f, -0.10300053f, -0.05814810f, 
    -0.76332748f, 0.16313908f, 0.38528541f, -0.08342322f, 0.19580378f, 0.05164314f, -0.10049810f, -0.05400550f, 
    0.08815055f, 0.07623073f, -0.74743932f, 0.04680220f, -0.25349197f, -0.05184567f, 0.12290750f, -0.04161703f, 
    -0.11814420f, 0.07561751f, -0.27522314f, -0.23979017f, 0.18311973f, -0.06352106f, 0.06966778f, -0.03001122f, 
    0.32505262f, -0.12810796f, -0.03619215f, 0.12704389f, 0.06026244f, 0.09671296f, -0.71680540f, -0.02614484f, 
    -0.05870482f, -0.08700016f, -0.26911804f, 0.12761483f, -0.26682657f, -0.71539605f, 0.13427779f, 0.02277476f, 
    -0.26948303f, 0.13523841f, -0.40831110f, 0.00180064f, 0.01853144f, -0.86778992f, -0.56643867f, 0.18063048f, 
    0.20394714f, -0.09946318f, 0.24915986f, -0.35307685f, -0.03830989f, -0.08409487f, -0.30718231f, -0.41276285f, 
    0.24779463f, 0.08411785f, -0.09567860f, -0.04901793f, -0.25225630f, -0.14075474f, 0.13694179f, -0.00705367f, 
    -0.06489383f, -0.02157623f, 0.10186043f, -0.26959801f, 0.05654488f, 0.14210682f, 0.17925911f, 0.17433819f, 
    0.03550597f, -0.34354523f, 0.00486276f, -0.08168054f, -0.26230726f, -0.29941121f, -0.35101429f, -0.78696620f, 
    0.07841954f, 0.11172529f, 0.24828467f, -0.28423762f, -0.38667333f, -0.03260154f, -0.02037020f, 0.13531151f, 
    0.16495827f, -0.08431907f, -0.38030753f, 0.16014118f, 0.15653041f, -0.07290082f, 0.08063617f, 0.28046432f, 
    0.11676095f, -0.04742675f, 0.06167425f, 0.02566510f, -0.21433872f, -0.29230994f, -0.37815124f, -0.17215034f, 
    0.00409713f, -0.50483644f, -0.15029606f, -0.21720293f, -0.41754082f, 0.02045426f, 0.13247931f, 0.05421851f, 
    -0.14857057f, -0.09835795f, 0.08279578f, -0.22581494f, 0.11329439f, 0.13064007f, -0.02685086f, 0.40173689f, 
    0.07732891f, 0.06990164f, -0.64604235f, -0.11196856f, 0.06602618f, -0.00829450f, -0.04377341f, -0.02438923f, 
    -0.46171075f, -0.18424873f, -0.11158226f, 0.06807899f, 0.22978598f, 0.13727351f, -0.07043146f, -0.23351628f, 
    -0.36159924f, 0.04262503f, -0.09327063f, 0.16215390f, -0.20390385f, -0.20103021f, -0.19361621f, 0.51163077f, 
    0.14215870f, 0.26643467f, -0.05395600f, 0.27741608f, 0.02569161f, -0.08577745f, 0.07663174f, 0.12518902f, 
    0.41912860f, -0.48877621f, -0.06493077f, 0.19372295f, 0.07400645f, -0.16164312f, -0.35350275f, 0.04770571f, 
    0.04905723f, 0.04518795f, -0.12453733f, 0.08262090f, 0.19188291f, -0.30892184f, -0.15474857f, -0.01040322f, 
    0.03231322f, 0.06047967f, 0.12580815f, -0.19577479f, 0.24228680f, -0.29050544f, -0.38967511f, -0.11810098f, 
    -0.46624374f, 0.01949146f, -0.23814729f, 0.03663405f, 0.18000700f, -0.07630314f, 0.08343521f, -0.09628787f, 
    0.11835067f, -0.02606718f, -0.06653447f, -0.07323250f, 0.13823272f, -0.01533222f, 0.38365650f, -0.39864650f, 
    0.05558272f, -0.85352015f, 0.04543810f, 0.06312795f, 0.42086682f, -0.09168690f, -0.27344504f, 0.00189470f, 
    0.04461741f, 0.04898490f, -0.02805778f, 0.23947811f, 0.00857600f, 0.04823929f, -0.18265894f, -0.39687082f, 
    0.02553845f, 0.09340329f, -0.17012379f, 0.16749665f, -0.16842350f, -0.06989667f, -0.08183518f, 0.04425521f, 
    -0.05560107f, -0.03410222f, -0.41316780f, -0.09741925f, 0.09732728f, -0.01179609f, 0.03900476f, 0.35821971f, 
    0.15289268f, 0.36781454f, 0.03625785f, 0.02876504f, 0.17202532f, -0.02322185f, -0.18907966f, 0.29563811f, 
    0.06469309f, 0.22536817f, -0.10624188f, -0.33368853f, 0.03842365f, -0.38696313f, -0.12868634f, -0.04888491f, 
    -0.06395010f, -0.46241948f, 0.09251806f, -0.28421932f, 0.01539253f, -0.07068728f, -0.00240561f, 0.33061340f, 
    0.05338087f, -0.16640030f, 0.15155064f, -0.08821032f, 0.14985849f, 0.00478727f, -0.22276662f, -0.08466449f, 
    -0.33376670f, 0.01986963f, -0.29163054f, -0.21028747f, 0.10480669f, -0.04881827f, 0.18785369f, 0.11163925f, 
    -0.55477375f, -0.04879783f, 0.27236184f, -0.00590191f, -0.63852626f, 0.12576425f, -0.19124287f, -0.18844733f, 
    0.12491959f, 0.03714716f, -0.18010005f, -0.06000011f, -0.01482742f, 0.00514586f, -0.08252141f, -0.03879078f, 
    -0.35953152f, 0.18284018f, 0.06265066f, -0.13158235f, 0.23139583f, -0.22129959f, 0.02746340f, 0.27627191f, 
    -0.03698391f, 0.06419908f, -0.15687659f, 0.16649069f, -0.46078849f, 0.14783576f, -0.01663944f, 0.06589449f, 
    0.17278761f, 0.25981066f, 0.27788609f, 0.12880784f, 0.19494773f, -0.13024379f, -0.38495407f, -0.01484125f, 
    0.21503671f, -0.06203435f, 0.05193286f, -0.03645529f, 0.17193359f, -0.14369515f, 0.28966773f, 0.11761937f, 
    -0.33406907f, -0.39051357f, -0.39792201f, -0.23015369f, -0.04901014f, -0.14088395f, -0.18914495f, 0.01002603f, 
    0.17687851f, -0.21082631f, -0.03242168f, -0.50087827f, -0.33565891f, -0.56534815f, 0.06146532f, -0.40191469f, 
    -0.03162969f, -0.16677031f, 0.06688420f, -0.07162511f, 0.11668686f, -0.10930520f, 0.00905414f, 0.12625107f, 
    0.02346605f, 0.01121852f, 0.00468729f, -0.00967524f, -0.18482836f, -0.17400593f, 0.40319920f, 0.12957741f, 
    0.07101373f, -0.09301972f, 0.13600045f, -0.03649229f, -0.42279238f, -0.07046036f, 0.16644999f, -0.34009042f, 
    -0.11035054f, 0.15681542f, -0.06427092f, -0.06017340f, -0.30224642f, -0.08005253f, 0.01472844f, 0.18108493f, 
    -0.26350847f, 0.02169416f, -0.41869462f, -0.21594916f, 0.14588553f, -0.28065518f, -0.00683161f, -0.09303608f, 
    0.15677482f, -0.37639743f, -0.17569193f, 0.16038649f, 0.08888452f, -0.29307556f, 0.17851703f, -0.09640506f, 
    -0.08325610f, 0.15346356f, -0.43538687f, 0.04880186f, -0.60780567f, -0.05314174f, -0.09534074f, 0.05451514f, 
    0.09690356f, -0.00923623f, 0.20834617f, 0.07775512f, -0.07140607f, -0.41493005f, 0.09229790f, 0.16400363f, 
    -0.08986102f, 0.02535705f, -0.04990328f, -0.30926454f, 0.07498308f, -0.38843027f, -0.24596503f, 0.05788873f, 
    -0.22230397f, 0.05040083f, 0.17809889f, -0.38893813f, 0.05754187f, -0.01864282f, -0.07638685f, 0.09942254f, 
    -0.50593245f, -0.17707521f, -0.14527707f, -0.06510534f, 0.20506580f, 0.22071512f, 0.01752584f, 0.14751966f, 
    0.07682197f, -0.06857868f, 0.14616999f, -0.09197661f, -0.07254978f, 0.01986631f, -0.23503104f, 0.00355115f, 
    0.46294335f, 0.03339599f, -0.26492706f, 0.02551137f, 0.12765306f, -0.07246886f, 0.32723537f, -0.06872294f, 
    0.05907348f, 0.34956267f, -0.05563678f, -0.22761188f, 0.12016399f, 0.14882651f, -0.10617551f, 0.14149566f, 
    -0.30201608f, 0.16493328f, -0.47482353f, -0.55434865f, 0.07170641f, -0.13422452f, 0.08122413f, -0.09148511f, 
    -0.05097798f, 0.28903344f, 0.09149632f, -0.01376714f, 0.38995603f, 0.19700707f, 0.00844338f, 0.19682910f, 
    -0.04690577f, -0.10767154f, -0.24549982f, -0.39649108f, -0.12544569f, 0.10967015f, -0.25567710f, -0.09749528f, 
    -0.00548529f, -0.00482539f, 0.17312570f, 0.05244437f, -0.16099240f, -0.03720678f, -0.60464281f, -0.22602208f, 
    -0.37787944f, -0.30704537f, -0.67039746f, -0.35256407f, -0.17273889f, -0.04785825f, -0.20982924f, 0.09585306f, 
    0.12361361f, -0.40221247f, 0.13160624f, -0.03118045f, 0.02164576f, 0.14098880f, 0.16169646f, -0.00775553f, 
    0.13354170f, -0.01753879f, 0.07055239f, -0.66799062f, 0.20604967f, -0.07862328f, 0.21899043f, -0.05975937f, 
    0.17281300f, 0.06924532f, -0.35044464f, 0.31216565f, -0.09334464f, 0.06295271f, -0.10482503f, 0.03226455f, 
    -0.18358634f, -0.01754301f, -0.22624770f, 0.22200780f, -0.07097299f, -0.18077043f, 0.10708961f, -0.03518907f, 
    0.00145005f, -0.04782968f, -0.31921726f, 0.00000160f, -0.12160870f, 0.11060491f, -0.22889513f, -0.43667457f, 
    0.18742160f, -0.47181511f, 0.26100212f, 0.20231345f, 0.25214487f, 0.00757858f, -0.48231572f, -0.08827002f, 
    0.05305254f, -0.30123460f, -0.56932759f, -0.00655818f, -0.05287063f, -0.09971970f, 0.30096897f, 0.00382911f, 
    0.33445022f, 0.25002033f, -0.01411451f, 0.19367120f, -0.41701958f, -0.53757691f, -0.16076314f, 0.13012786f, 
    -0.05862004f, 0.02886056f, -0.06061279f, -0.08326669f, 0.22858050f, 0.07528166f, -0.82557952f, -0.00969297f, 
    -0.00866531f, -0.10714453f, 0.07878600f, 0.23639585f, -0.41430560f, -0.29120725f, -0.07591793f, 0.11092649f, 
    -0.03970363f, -0.46994668f, -0.15471864f, 0.19509119f, -0.14796920f, 0.02154935f, 0.05801977f, 0.16884355f, 
    -0.25784990f, -0.13787907f, -0.06308097f, -0.11930761f, 0.20584023f, -0.38297060f, -0.43766069f, -0.11095634f, 
    0.02999612f, 0.30082306f, -0.07180811f, -0.20625642f, -0.31044975f, -0.12877899f, -0.01415289f, -0.22958355f, 
    -0.03251860f, -0.18897118f, -0.07625519f, 0.14073655f, 0.24786352f, 0.01616023f, 0.09697539f, 0.03596497f, 
    -0.08879309f, 0.15643565f, -0.33559635f, 0.06847920f, 0.24140018f, -0.18239911f, -0.16148376f, -0.10351537f, 
    0.11981774f, 0.04561215f, -0.29615042f, -0.15216878f, -0.04490979f, -0.09938826f, -0.05502773f, 0.10809457f, 
    -0.08754043f, 0.05014787f, -0.26346165f, -0.05824848f, -0.09497524f, 0.02887381f, -0.00356242f, -0.21875970f, 
    0.09139441f, -0.20207065f, -0.32900006f, -0.62003779f, -0.08849509f, 0.20757076f, -0.04186855f, 0.04469233f, 
    0.11460604f, -0.40542579f, -0.00119168f, 0.12612936f, -0.06739444f, -0.42158636f, -0.31229305f, 0.02128770f, 
    -0.04408203f, -0.04317551f, 0.48255104f, 0.07698967f, -0.40221438f, 0.14971758f, -0.02650691f, -0.10355891f, 
    0.08317339f, 0.20799571f, 0.12941089f, 0.11454041f, -0.21900524f, -0.08892792f, 0.04573015f, 0.19837701f, 
    -0.05788616f, -0.18782841f, 0.27075425f, 0.12887380f, 0.09979033f, 0.06238488f, 0.17768626f, -0.46644208f, 
    0.13307923f, -0.36586416f, -0.33185491f, 0.09959738f, 0.01545945f, -0.01410254f, -0.02856943f, -0.22685251f, 
    -0.01779486f, 0.24218738f, -0.06997869f, 0.06461972f, -0.13330486f, 0.11047664f, -0.37117645f, 0.05723688f, 
    -0.02541617f, 0.06897502f, -0.22424118f, -0.54362726f, -0.35418895f, -0.21103200f, 0.17104644f, -0.04268406f, 
    0.27918008f, -0.01629210f, -0.09777867f, 0.12077653f, -0.10561763f, -0.01184036f, 0.01727146f, 0.12595735f, 
    -0.02812846f, -0.42092001f, -0.19924881f, -0.12765509f, 0.09514198f, -0.23266502f, 0.10718255f, 0.18229862f, 
    -0.27145207f, 0.29473421f, -0.39831486f, 0.20988727f, 0.21772699f, -0.13891988f, 0.07924337f, -0.01230351f, 
    -0.00411891f, 0.42158112f, -0.20706053f, 0.11029050f, -0.34803772f, -0.18258581f, -0.05135295f, -0.11078838f, 
    0.02984877f, -0.35017958f, 0.02630631f, -0.27786428f, -0.21788052f, -0.27425125f, -0.48075047f, 0.15247793f, 
    -0.00658614f, -0.13294442f, -0.09592405f, -0.03311301f, -0.45939705f, -0.48335269f, 0.23643707f, -0.37005544f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07112976f, 0.20973040f, 0.07381696f, -0.07440852f, -0.05149034f, -0.07316970f, 0.05959537f, -0.08325153f, 
    0.09895995f, 0.11378902f, -0.03414141f, -0.01849139f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
