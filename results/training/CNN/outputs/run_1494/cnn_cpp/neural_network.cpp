#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.62795627f, -0.02064277f, 0.17430955f, 0.12867230f, 0.37746575f, -0.59164715f, 0.13109635f, 0.28844181f, 
    0.32337192f, 0.26959917f, 0.14543252f, 0.10574563f, -0.00710685f, -0.15880060f, -0.00008443f, 0.14548697f, 
    0.00595560f, -0.16666459f, -0.29866818f, -0.02470906f, 0.01317933f, 0.14867695f, 0.23890583f, 0.17255986f, 
    -0.31610802f, -1.06307447f, -0.60318685f, 0.34410048f, 0.36130479f, -0.20589745f, 0.82609665f, 0.73024672f, 
    -0.43865436f, -0.45414603f, 0.32170898f, 0.08177532f, -0.00335389f, -0.21666256f, 0.12785482f, -0.35465851f, 
    0.11008937f, 0.07785144f, -0.18082984f, 0.03274196f, -0.01708024f, 0.04207288f, -0.20077871f, 0.14375792f, 
    0.23762257f, -0.12398314f, 0.31384876f, 0.28268075f, -0.18094172f, 0.24797156f, 0.29314750f, -0.26103824f, 
    -0.09505987f, 0.16100381f, 0.18549938f, -0.22549656f, 0.16329870f, 0.20757516f, -0.19000763f, -0.23329981f, 
    -0.04306426f, -0.12626722f, 0.00910312f, -0.14022197f, -0.07110248f, 0.03743668f, -0.07371391f, -0.08874612f, 
    -0.13618606f, -0.19469602f, -0.23494238f, -0.30150545f, 0.42574611f, -0.13480140f, -0.22929786f, 0.29585284f, 
    0.15025711f, 0.11838563f, -0.35840645f, 0.45399541f, -0.08611277f, 0.10621726f, -0.18891360f, 0.02678357f, 
    -0.34452677f, -0.16193813f, -0.22340736f, 0.37602895f, 0.28321442f, -0.06073297f, 0.05972205f, -0.03728785f, 
    -0.14524963f, -0.28489792f, -0.14644381f, 0.23395242f, 0.41666698f, 0.65724510f, -0.51232064f, -0.42335716f, 
    -0.89673793f, -0.25560781f, -0.09835757f, 0.25791061f, 0.06521165f, 0.13907219f, -0.10100599f, 0.21280353f, 
    0.10330170f, 0.17699504f, -0.15608138f, -0.21776970f, 0.34115097f, -0.43104029f, -0.45600918f, 0.31462383f, 
    -0.10946645f, 0.24354097f, -0.21053258f, -0.19240038f, 0.28855008f, -0.29427019f, -0.25385761f, -0.15872179f, 
    0.25630352f, 0.29812846f, 0.18119700f, -0.30463541f, 0.00314350f, 0.27592725f, 0.31512418f, 0.04466500f, 
    -0.09722612f, -0.10615230f, 0.33041456f, -0.18863147f, -0.30741984f, -0.02779260f, 0.21895444f, -0.32123494f, 
    0.10872085f, -0.11878479f, -0.01622899f, 0.33527842f, 0.28775600f, -0.21683016f, -0.60713720f, 0.05514803f, 
    0.38949633f, 0.48409373f, -0.27155709f, -0.21878065f, -0.02820570f, 0.19577223f, -0.20151345f, -0.31945384f, 
    0.09591602f, -0.21250595f, -0.48174754f, 0.56160593f, -0.14385411f, -0.28350815f, -0.08446757f, 0.10011115f, 
    -0.06162923f, -0.22514966f, -0.11713482f, -0.02211871f, 0.36397883f, -0.17735167f, 0.20183173f, -0.21822837f, 
    -0.69573802f, -0.15436800f, 0.18668276f, 0.02388004f, -0.66976488f, -0.81233281f, -0.50031585f, 0.18709500f, 
    0.27481326f, -0.08542738f, -0.29785293f, -0.18471359f, 0.12320674f, 0.30494437f, -0.43496364f, -0.14169820f, 
    -0.15102890f, -0.35554016f, -0.62809628f, 0.00916884f, -0.11927722f, 0.14893261f, 0.10914290f, 0.04803387f, 
    -1.05454624f, -0.18815100f, -0.36977991f, 0.26545396f, 0.25473997f, 0.27226862f, -0.12990981f, 0.05701083f, 
    0.18156783f, 0.02067151f, 0.69743598f, 0.02379616f, -0.09501423f, -0.02687642f, -0.36926436f, -0.27577406f, 
    -0.09717540f, -0.27896431f, -0.33009356f, -0.16885489f, -0.21275188f, -0.10171399f, 0.24298996f, -0.17023955f, 
    -0.43131334f, 0.14166161f, 0.62961316f, 0.46346679f, 0.01851474f, 0.09906057f, -0.30434147f, -0.48008922f, 
    -0.25632069f, 0.16719408f, -0.15106642f, 0.32043526f, -0.30449557f, -0.15637474f, -0.14644015f, 0.06240706f, 
    0.07899389f, 0.36811373f, 0.23901863f, -0.06707967f, 0.10611475f, -0.19649073f, -0.12429961f, -0.15247343f, 
    0.09784492f, -0.33652684f, -0.11744449f, -0.38713104f, -0.90252250f, -0.86286288f, -0.78725821f, 0.70984691f, 
    0.20881143f, 0.46811154f, 0.34472084f, 0.35576758f, 0.31902340f, 0.22074841f, -0.07468175f, -0.04725615f, 
    -0.00921783f, -0.53615540f, -0.27668646f, 0.12760229f, -0.44952983f, -0.31142357f, 0.19926977f, -0.07659124f, 
    0.18249303f, 0.12586942f, 0.45073915f, -1.02663875f, -0.55553097f, -0.54098809f, -0.70877719f, -0.62040937f, 
    0.60489279f, -0.16489151f, -0.50356239f, 0.01985592f, 0.68193144f, -0.34925732f, -0.45893914f, 0.08894081f, 
    -0.10596538f, -0.28465900f, 0.15656134f, 0.12834042f, -0.20179452f, -0.15001291f, -0.13381423f, -0.00328906f, 
    0.02824294f, 0.03598739f, -0.06116076f, 0.24983037f, -0.09314106f, 0.13205984f, 0.28986335f, 0.32489833f, 
    -0.28714672f, -0.17244364f, -0.28362057f, 0.26936415f, -0.24177139f, 0.21580946f, -0.19972447f, -0.09578010f, 
    0.01652792f, 0.02483096f, -0.29299206f, 0.15956768f, 0.39705002f, 0.14999466f, 0.10112473f, -0.36441484f, 
    -0.04505458f, -0.18452592f, -0.04146038f, -0.29664347f, 0.22181453f, 0.77472496f, 0.24691504f, -0.74686855f, 
    -0.37477425f, -0.54931986f, -0.05765121f, -0.12127854f, 0.23429519f, 0.30094066f, 0.42574453f, 0.17725809f, 
    0.15714738f, 0.17525592f, -0.31808180f, -0.23509152f, 0.21007904f, -0.10249227f, 0.06901781f, -0.15413408f, 
    -0.27783576f, -0.22014675f, -0.07710356f, -0.10021423f, -0.06826772f, -0.24818580f, -0.52726674f, -0.07980271f, 
    -0.07808413f, 0.12833397f, 0.47029737f, 0.29509372f, -0.17583448f, -0.42235702f, -0.07380020f, 0.17547168f, 
    0.08107914f, -0.06289156f, -0.03148856f, 0.42225802f, -0.56161803f, -0.05273617f, -0.19098528f, -0.36048338f, 
    -0.32491192f, -0.36604342f, -0.33277664f, -0.27487960f, -0.48680517f, -0.25009802f, -0.44055775f, 0.50350112f, 
    0.13065444f, -0.07004433f, -0.08784166f, 0.11506475f, -0.13743299f, 0.55562311f, -0.16377480f, -0.54139423f, 
    -0.68372571f, -0.36010215f, -0.20320049f, -0.22425364f, 0.10098342f, -0.02378774f, -0.01310541f, -0.35167170f, 
    0.14379078f, 0.31124407f, -0.12180904f, 0.14310130f, -0.15013923f, -0.13716124f, 0.38441074f, -0.19925871f, 
    -0.76180559f, -0.12539382f, -0.38401929f, 0.16710505f, -0.39513126f, -0.00233725f, -0.16736232f, -0.41996133f, 
    -0.22396655f, 0.35544699f, -0.25710160f, -0.08939958f, -0.05410951f, 0.20211400f, -0.11866660f, -0.12097913f, 
    -0.17268789f, -0.05200756f, 0.05453651f, 0.18514897f, -0.26289347f, -0.27245235f, -0.24956325f, -0.18061899f, 
    -0.32594562f, 0.81303358f, -0.24999367f, -0.55112529f, -0.69738078f, -0.69418192f, -0.26383519f, 0.03498806f, 
    -0.08542468f, 0.25348040f, 0.22868074f, 0.15432638f, 0.14954330f, 0.38589889f, 0.06294955f, 0.11244422f, 
    -0.13076779f, -0.11011330f, 0.10639011f, -0.20278147f, -0.33669758f, -0.06483214f, -0.15464149f, -0.25734946f, 
    0.01825929f, -0.46418554f, 0.22326292f, -0.86280012f, -0.28626353f, 0.87702376f, 0.11903860f, 0.21645759f, 
    0.54143375f, -0.73532712f, -0.76866859f, -0.37162739f, 0.04237357f, -0.09394217f, -0.18803506f, -0.29805592f, 
    -0.03488865f, -0.12236164f, -0.01371174f, 0.16621950f, -0.16346884f, 0.19506204f, 0.08679258f, 0.09926161f, 
    0.07702661f, 0.02055956f, -0.32779971f, -0.64277595f, 0.56936198f, 0.14786409f, -0.19898206f, 0.05931601f, 
    -0.27408707f, 0.02488090f, 0.40126127f, 0.24354908f, -0.00286276f, -0.13928781f, 0.02335417f, 0.46830696f, 
    -0.43767077f, -0.24211363f, -0.13018638f, 0.12416165f, -0.45223501f, -0.07480756f, 0.36959019f, 0.20050605f, 
    0.14994317f, 0.21559145f, -0.26077873f, -0.00369100f, 0.92156792f, -0.56398469f, -0.66068381f, -0.46921745f, 
    -0.45809308f, 0.34967101f, 0.08627691f, 0.45064065f, 0.09165370f, 0.02756981f, 0.01094777f, -0.06652295f, 
    0.09558846f, -0.04557789f, 0.25505507f, 0.10983090f, -0.05702609f, 0.02122177f, -0.25231224f, 0.04724261f, 
    0.23963271f, -0.18135688f, 0.02418111f, 0.09131348f, -0.01768574f, 0.30546197f, -0.57847136f, -0.41984239f, 
    -0.45047963f, -0.71155864f, 0.01467434f, 0.28462604f, 0.33633283f, -0.27996752f, -0.19795804f, -0.20260507f, 
    -0.14583430f, -0.27345300f, -0.27088055f, -0.15071681f, -0.40953824f, 0.24087408f, 0.07217544f, -0.33555037f, 
    0.00888096f, -0.13623160f, 0.26614022f, 0.21974385f, -0.02874487f, -0.02824304f, 0.71067202f, 0.87235403f, 
    0.19994390f, -0.18929905f, -0.62331456f, -0.48748708f, -0.04526693f, 0.07978865f, -0.07145582f, -0.10978255f, 
    0.02245011f, 0.13724524f, -0.00241531f, 0.05971079f, -0.28242692f, -0.03334136f, -0.09871003f, 0.16248597f, 
    0.29459822f, -0.22837961f, -0.06615379f, 0.16958937f, -0.29004511f, 0.03960366f, 0.02991815f, -0.41411939f, 
    0.27004698f, 0.46321052f, -0.33518091f, -0.15728042f, -0.17040637f, -0.19408087f, 0.21828574f, -0.08972731f, 
    0.34994373f, 0.15762511f, 0.14295773f, -0.22052702f, 0.16967201f, -0.08143292f, -0.15844777f, -0.16263111f, 
    0.11128215f, -0.12066865f, -0.36208579f, 0.15113299f, 0.36643204f, 0.28446192f, -0.16282751f, 0.09844255f, 
    -1.01757884f, -0.79161072f, -0.05879167f, 0.46791208f, 0.78034294f, 0.15647298f, 0.16496080f, 0.37035635f, 
    -0.29001120f, -0.26057211f, -0.30240658f, -0.13929324f, -0.16561440f, 0.57376516f, -0.39700142f, -0.08059791f, 
    0.05666245f, -0.31619093f, 0.31885678f, 0.19209532f, 0.01622734f, 0.03900934f, -0.00896536f, 0.05249750f, 
    0.07640913f, 0.29511794f, -0.26277599f, 0.06782199f, -0.22703730f, 0.01455220f, 0.38778636f, 0.10649569f, 
    -0.06449459f, 0.38506854f, 0.08053941f, 0.10300972f, -0.09959998f, -0.01903232f, 0.01717549f, 0.15077448f, 
    -0.00712943f, 0.17854638f, -0.00638808f, -0.23165832f, 0.00586902f, 0.02301260f, 0.36668953f, -0.12642469f, 
    -0.00284558f, -0.11366207f, 0.14878100f, -0.32827067f, 0.26641685f, 0.55914086f, -0.21769117f, -0.29973054f, 
    -0.57025295f, 0.01671045f, 0.33358502f, 0.13272779f, 0.01727625f, -0.08065431f, -0.20594732f, -0.00132019f, 
    0.10027965f, 0.01320131f, 0.43780759f, 0.02261991f, -0.26499757f, -0.22033136f, 0.17871340f, 0.17239645f, 
    0.02169045f, -0.08612634f, -0.21794358f, 0.19140334f, -0.43266952f, 0.08516834f, 0.35557336f, -0.06025556f, 
    -0.47301567f, -0.04016349f, -0.11741903f, 0.21037832f, 0.35216522f, 0.34245807f, -0.33054629f, -0.24772078f, 
    0.31482759f, -0.13434537f, -0.01443780f, -0.17536090f, 0.08151499f, -0.09159258f, 0.12246606f, -0.24154346f, 
    0.03426034f, -0.19468382f, 0.24005863f, 0.24428670f, 0.48751968f, 0.17319900f, 0.38904658f, -0.16332780f, 
    -0.16869637f, -0.11334038f, -0.41464081f, -0.15976301f, 0.07176953f, -0.08409181f, -0.21645556f, -0.12158945f, 
    0.18803920f, 0.15971372f, -0.01425948f, 0.24096425f, -0.01472846f, -0.29860580f, 0.30067161f, -0.27512455f, 
    -0.12730283f, -0.25660011f, -0.04673265f, -0.05466923f, -0.21634312f, -0.45173675f, -0.37636548f, 0.33690345f, 
    0.18185471f, 0.45042554f, 0.42340654f, -0.31390268f, -0.37607089f, -0.23195547f, 0.28364468f, 0.15481998f, 
    0.42398921f, 0.11706150f, -0.09158053f, -0.21232712f, -0.40138847f, -0.04079479f, -0.06097486f, -0.05393821f, 
    0.25677705f, 0.11499102f, 0.19721860f, 0.20092520f, -0.09701901f, -0.11860847f, -0.25002885f, -0.54160142f, 
    -0.30467492f, -0.37523481f, -0.14735529f, -0.29625240f, -0.11270907f, -0.52153856f, -0.64036441f, -0.74468577f, 
    0.28902781f, 0.27512977f, -0.10872668f, 0.36225036f, -0.06868486f, -0.00193455f, -0.17168014f, 0.01468883f, 
    0.27531180f, 0.16130678f, -0.13489895f, -0.20632693f, -0.02505176f, 0.27283853f, 0.02430795f, -0.30208763f, 
    -0.32170150f, -0.88884383f, -0.48602656f, 0.18250008f, 0.31490600f, -0.14318551f, -0.50726092f, -0.46951026f, 
    -0.39304987f, -0.52745706f, -0.45188621f, 0.02586640f, 0.61191636f, -0.00538453f, 0.00820133f, 0.08166885f, 
    -0.19353297f, -0.22305879f, -0.31953374f, -0.16926998f, 0.03207558f, 0.20739768f, 0.02382629f, -0.26774088f, 
    0.10152584f, 0.14939246f, 0.37058133f, 0.01307347f, -0.57361740f, -0.19068834f, -0.24225484f, 0.20025828f, 
    -0.05987548f, 0.15605821f, 0.13535863f, 0.05899629f, -0.37023067f, 0.49120438f, -0.46282446f, -0.05140200f, 
    0.00327840f, -0.08484170f, 0.10656554f, 0.14499605f, 0.21056311f, -0.29736054f, -0.26540732f, -0.15280914f, 
    0.44377583f, 0.58514374f, -0.23664197f, -0.69013911f, -0.51832497f, -0.50342631f, 0.37839121f, 0.48639205f, 
    0.30710974f, 0.24145028f, -0.13096462f, -0.24863380f, -0.01754970f, 0.03391310f, -0.02681773f, -0.06517547f, 
    -0.01691560f, -0.25914428f, 0.08611124f, 0.32714817f, 0.00754416f, -0.13066562f, -0.03311612f, 0.29212642f, 
    -0.09461501f, -0.02371650f, -0.13436109f, 0.00556590f, -0.03942525f, -0.25131124f, -0.07741942f, 0.42766148f, 
    -0.09768905f, -0.18115002f, -0.22090183f, -0.37430212f, 0.43093741f, -0.28005075f, 0.05181746f, 0.12652642f, 
    -0.00668188f, 0.20083192f, -0.16648293f, 0.20904066f, -0.10354770f, -0.07172850f, -0.05946950f, 0.30675593f, 
    -0.07373708f, -0.19075955f, 0.37391013f, 0.02712454f, -0.35882255f, 0.26599288f, 0.35899135f, 0.34298962f, 
    -0.04987566f, 0.33819556f, 0.18647105f, -0.09622293f, -0.37967259f, -0.09049897f, -0.21559298f, -0.16326296f, 
    0.03538096f, 0.22557132f, -0.08216393f, -0.07265073f, -0.08343085f, 0.11860363f, -0.03049221f, 0.33065957f, 
    -0.17510825f, -0.28017345f, 0.04738732f, -0.04827543f, -0.45205519f, 0.11716750f, -0.36366025f, 0.02734383f, 
    0.05285266f, 0.30359128f, 0.25542283f, 0.14478272f, -0.40444914f, -0.33079308f, 0.32842773f, -0.19982983f, 
    -0.09466264f, 0.04510464f, 0.22643492f, -0.11980100f, -0.07361613f, -0.00589117f, 0.19251460f, -0.30186152f, 
    -0.02472415f, -0.32295772f, 0.37371603f, -0.20808791f, -0.04258116f, -0.53975689f, 0.08559195f, -0.25738817f, 
    -0.14576674f, 0.35138911f, 0.42513144f, -0.22120197f, -0.60368145f, -0.48865321f, -0.47900724f, 0.04234421f, 
    0.72478604f, -0.14677651f, -0.24450436f, 0.12786441f, -0.44339687f, 0.11048264f, -0.16551231f, -0.15643680f, 
    -0.05834581f, 0.35100347f, -0.24881056f, -0.31026578f, -0.05911765f, -0.27594209f, 0.63304746f, 0.05603800f, 
    0.03237440f, -0.12001982f, -0.41012496f, -0.44914633f, -0.47220105f, -0.09954214f, -0.05631668f, -0.08292990f, 
    0.06710915f, 0.12224424f, 0.39919704f, 0.10845952f, -0.18452333f, -0.10189883f, 0.04102412f, 0.00632033f, 
    0.20078465f, -0.13508165f, 0.02034332f, -0.02868543f, 0.03015115f, -0.20563094f, -0.11251640f, -0.62720561f, 
    0.50191259f, 0.77099818f, -0.30228657f, -0.18870109f, -0.82758719f, -0.37074578f, -0.17243959f, -0.19855471f, 
    -0.04000271f, -0.10189898f, -0.23708697f, -0.34767571f, 0.28798950f, -0.30308321f, 0.00199571f, -0.38553548f, 
    -0.03979232f, -0.05795934f, -0.32569984f, 0.23632564f, -0.24539222f, -0.02017786f, -0.30391198f, -0.34307802f, 
    -0.61404115f, -0.26604784f, -0.16452077f, -0.13270539f, 0.09774004f, 0.16381641f, 0.01067561f, 0.16971324f, 
    0.32594717f, 0.13634354f, 0.00549783f, 0.06494374f, 0.12576614f, 0.01682974f, 0.12292188f, -0.34670213f, 
    0.01082977f, -0.00866854f, -0.09574541f, 0.06256124f, -0.12704012f, 0.26038358f, 0.35677510f, 0.12003729f, 
    0.07021028f, 0.25737008f, 0.25264397f, 0.24318683f, -0.00234457f, -0.29439732f, -0.01875378f, 0.03444984f, 
    -0.39118651f, -0.07992121f, 0.16290694f, 0.12986310f, 0.15261665f, 0.25651401f, -0.05317377f, 0.20371667f, 
    -0.05911437f, -0.07595967f, 0.05027147f, -0.35842666f, -0.26587215f, 0.12644355f, -0.07213391f, 0.26803988f, 
    0.20320252f, 0.21200985f, 0.66288167f, 0.32182050f, -0.01978943f, -0.25671369f, -0.44819853f, 0.00965460f, 
    0.13075751f, 0.24533373f, 0.15130293f, -0.18592145f, -0.15311424f, 0.31241560f, -0.27372655f, -0.33204597f, 
    0.12587170f, -0.25101477f, 0.26325908f, 0.05505517f, -0.06214689f, -0.22997202f, 0.17770150f, -0.09603435f, 
    0.02646865f, 0.03671080f, -0.08895868f, -0.43464348f, -0.75431907f, -0.49513471f, 0.71177757f, 0.69180536f, 
    -0.57271725f, -0.40548682f, -0.58545208f, -0.18432826f, 0.34147853f, 0.38354278f, -0.08185660f, 0.02817896f, 
    0.01662907f, -0.20399788f, 0.25100121f, -0.39127716f, 0.16459647f, -0.26392153f, -0.44267735f, -0.34561476f, 
    -0.11792678f, -0.23144859f, -0.15732403f, -0.16453505f, -0.00644474f, -0.04148589f, 0.19962607f, 0.26417607f, 
    0.08588094f, 0.25128227f, -0.05840917f, 0.07134740f, 0.20577863f, 0.09182964f, 0.21737681f, -0.02374799f, 
    0.06259158f, 0.12985861f, 0.15343972f, 0.04293368f, 0.03299226f, 0.10177066f, 0.01147700f, -0.15698642f, 
    -0.12878230f, 0.38165858f, 0.00955304f, -0.05416424f, -0.21167202f, -0.09565037f, -0.26746216f, -0.40246364f, 
    -0.38787243f, 0.14662535f, -0.40375972f, 0.15083519f, 0.30448851f, 0.14981195f, 0.27798459f, -0.05251868f, 
    0.15418477f, 0.11847761f, -0.34767801f, 0.22010456f, -0.39621666f, 0.07682627f, 0.06590834f, 0.00078149f, 
    -0.32141230f, -0.08760440f, 0.02134239f, -0.00383419f, 0.15090878f, 0.25279373f, -0.50171602f, -0.35768726f, 
    -0.15859671f, -0.39838973f, -0.54557425f, -0.48916602f, -0.70251060f, -0.64659083f, -0.52921325f, -0.89697295f, 
    0.18196702f, 0.10705172f, 0.49894509f, 0.49744672f, 0.04567046f, -0.07071427f, -0.17077444f, -0.00898054f, 
    -0.36958978f, -0.16634862f, 0.16424815f, 0.13103831f, 0.05385366f, 0.26284102f, 0.14990184f, 0.77145839f, 
    -0.37714362f, -0.59733278f, -0.12914681f, 0.22944452f, 0.47798434f, 0.54143000f, 0.33612499f, -0.19738944f, 
    0.08602418f, -0.19902791f, 0.09913727f, -0.03201228f, -0.32603112f, 0.12063941f, -0.10438998f, -0.02966743f, 
    0.26124048f, -0.07885727f, -0.17171495f, 0.13208753f, -0.25359449f, -0.38520113f, -0.01845712f, 0.14810631f, 
    0.15937111f, -0.42530879f, 0.25355458f, 0.06874508f, 0.20669192f, -0.36291513f, -0.26795036f, 0.43662789f, 
    0.16583955f, -0.30386856f, -0.11297859f, 0.17318878f, 0.02502500f, 0.41272610f, -0.50653988f, -0.11127549f, 
    0.14780502f, 0.28258482f, -0.17077957f, -0.14967507f, 0.00565308f, 0.21881223f, 0.05188239f, 0.18055193f, 
    -0.06241881f, 0.14638364f, -0.12584864f, 0.15585998f, 0.03383246f, 0.39036047f, -0.52573776f, -0.22727630f, 
    0.09122698f, 0.33215815f, 0.13772707f, 0.10769607f, -0.06806933f, -0.17687345f, -0.00801037f, 0.00750807f, 
    0.13545905f, 0.22135714f, -0.16472083f, -0.35310152f, 0.12700118f, -0.13424222f, 0.02484567f, -0.08578435f, 
    -0.07556038f, -0.07991050f, 0.15287526f, 0.39661369f, 0.18274660f, 0.02675255f, 0.27048326f, -0.43241414f, 
    -0.35009864f, 0.16767827f, 0.53493708f, -0.31578997f, 0.25022620f, 0.03138160f, -0.09931280f, -0.26353788f, 
    0.14532137f, 0.09382544f, -0.08562272f, -0.11194086f, -0.02790930f, -0.03441654f, 0.21037537f, -0.06492116f, 
    -0.30549577f, 0.27296957f, -0.08307273f, -0.01786798f, -0.37155533f, -0.08266491f, -0.00210315f, -0.30392939f, 
    -0.28266346f, -0.32180354f, -0.24987532f, 0.16447203f, -0.27122369f, -0.13742287f, 0.04680662f, 0.07234996f, 
    0.26663253f, -0.28342968f, 0.08448607f, -0.03366361f, 0.20552494f, 0.12667298f, 0.27556804f, 0.21369582f, 
    -0.11119815f, -0.27588248f, -0.28506961f, 0.08417994f, -1.09240043f, -0.77402478f, -0.21984752f, 0.56926697f, 
    0.59648871f, -0.28634897f, -0.19953524f, 0.39816472f, 0.37670964f, 0.45082211f, 0.01158733f, -0.01392241f, 
    -0.06378192f, 0.08325084f, -0.24765567f, 0.16360149f, -0.12432404f, -0.00985786f, 0.16453280f, 0.16884127f, 
    0.11641153f, -0.28707334f, -0.02946992f, 0.01303601f, -0.03669092f, -0.11475883f, 0.51635855f, 0.24814305f, 
    0.05214706f, 0.37922046f, -0.39954665f, -0.37845144f, 0.21408117f, -0.38796204f, -0.33258513f, 0.17224847f, 
    -0.54492164f, 0.45934942f, -0.21557832f, -0.15113302f, -0.04033523f, 0.28134131f, -0.15800013f, -0.11164819f, 
    0.31160256f, -0.04486865f, -0.05119086f, -0.15520248f, 0.15738709f, 0.38373971f, -0.00804097f, -0.29207304f, 
    -1.06239808f, -0.53775328f, -0.04763411f, -0.03599364f, 0.49263611f, 0.89700514f, -0.40809876f, -0.53788656f, 
    -0.26570445f, -0.20183656f, -0.04962591f, -0.21998289f, -0.31639576f, -0.00502745f, -0.20887758f, 0.35962754f, 
    -0.24648863f, -0.01794766f, 0.04967796f, -0.11387773f, -0.16468425f, 0.31095287f, 0.08385000f, -0.72132635f, 
    -0.16939451f, -0.09897385f, -0.84742880f, -0.50294411f, -0.05562470f, 0.19875930f, 0.45937273f, 0.38130707f, 
    0.46189654f, -0.32393739f, -0.30858126f, -0.33171502f, -0.21328403f, 0.24227034f, 0.08969061f, 0.19292802f, 
    0.26510754f, 0.19208650f, 0.00911849f, -0.20082127f, -0.04867893f, -0.30075327f, -0.33875859f, -0.39475048f, 
    -0.78968453f, -0.51456219f, 0.02294216f, -0.42330420f, -0.42145419f, 0.09523987f, -0.27565476f, -0.37601063f, 
    -0.25173441f, 0.00792788f, -0.19620557f, -0.17665842f, -0.27399084f, -0.13188457f, -0.01631672f, -0.25199252f, 
    -0.28336370f, -0.24880014f, -0.37584549f, -0.34936568f, -0.06328671f, 0.14100672f, -0.05059859f, -0.00169354f, 
    -0.11990638f, -0.51745754f, -0.32109573f, -0.56629276f, -0.42792940f, 0.26854956f, 0.01312995f, -0.13041066f, 
    -0.29229099f, -0.30576715f, -0.02865631f, -0.41927961f, -0.36605999f, 0.04983285f, -0.39539114f, 0.09754522f, 
    0.30387011f, 0.01659805f, -0.06714606f, 0.02583745f, 0.06734216f, 0.08832421f, -0.13898905f, -0.29773742f, 
    -0.31000963f, -0.41008162f, -1.08178258f, 0.74389434f, 0.02379671f, -0.81611520f, -0.11167240f, -0.26096767f, 
    0.26548415f, 0.52057695f, 0.26084185f, -0.46186629f, -0.26834163f, 0.00558862f, -0.08716070f, -0.22259343f, 
    0.17466249f, 0.01122034f, -0.25017935f, -0.31146580f, -0.40766835f, -0.52737999f, -0.05877527f, 0.18890980f, 
    -0.04865744f, -0.34032637f, -0.47758731f, 1.15018249f, -0.61839092f, -0.85600334f, -0.66039455f, -0.38256863f, 
    0.52180350f, -0.04470437f, 0.00755969f, 0.22252662f, -0.55360782f, 0.01524079f, -0.15562862f, 0.27513054f, 
    -0.22929253f, 0.32494408f, -0.09556513f, 0.34027541f, 0.02400578f, -0.22653767f, 0.21464796f, -0.30929023f, 
    -0.29990101f, 0.12666032f, 0.12388467f, -0.17081682f, 0.59757125f, 0.30171487f, 0.42941803f, -0.01302221f, 
    -0.15555191f, -0.35891744f, 0.07279392f, 0.20446581f, -0.35808912f, 0.10814852f, 0.03791301f, -0.01023468f, 
    0.18067944f, -0.34301260f, -0.15952472f, 0.03689745f, 0.14878842f, -0.30062810f, 0.17833021f, -0.02735038f, 
    -0.34230798f, 0.10014498f, 0.07955568f, -0.04229407f, 0.13612631f, -0.62112683f, 0.33348000f, 0.35991982f, 
    -0.07475396f, -0.27161124f, 0.10255929f, 0.38652977f, 0.35065940f, 0.01176918f, -0.30491543f, 0.35133180f, 
    -0.05089077f, -0.12110399f, 0.30835727f, -0.31500939f, 0.19599998f, -0.08779424f, -0.18853036f, -0.11209189f, 
    -0.12226327f, 0.11287814f, -0.03666238f, 0.20887657f, 0.08527675f, -0.12660392f, -0.73289001f, -0.09444268f, 
    0.16362324f, 0.60729295f, 0.11563349f, -0.46028960f, -0.56443709f, -0.23410426f, 0.08486296f, 0.21883994f, 
    0.37695566f, -0.11770152f, -0.06806406f, 0.33656952f, 0.06009328f, -0.12001969f, 0.33625320f, -0.18155505f, 
    -0.35705522f, -0.21201774f, 0.29994336f, 0.10413433f, -0.01735218f, 0.11700921f, 0.26589060f, -0.27788663f, 
    -0.57249272f, -0.52056807f, -0.10099882f, -0.29612282f, -0.22711328f, -0.22694585f, 0.23183402f, 0.05164824f, 
    -0.61777800f, 0.14009400f, 0.59761453f, -0.04264007f, -0.14741926f, -0.06010281f, 0.20810977f, -0.10248036f, 
    0.19355235f, -0.09963205f, -0.21388403f, 0.08222574f, 0.47378320f, 0.17781262f, -0.16139667f, -0.01822774f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.39979592f, 0.27641729f, 0.08838941f, -0.09824559f, 0.36768377f, 0.34772271f, 0.06577271f, 0.09589547f, 
    -0.03482876f, 0.20054069f, 0.15302202f, -0.11412257f, 0.16017404f, -0.02350258f, 0.00512916f, -0.03866091f, 
    -0.16979741f, -0.00015458f, 0.21102117f, 0.23382789f, 0.15975592f, -0.12831374f, 0.43417931f, 0.12528919f, 
    -0.10241037f, -0.00004678f, 0.26735440f, 0.35748535f, 0.00224334f, 0.23039310f, -0.13350609f, -0.54620093f, 
    0.24897859f, 0.22375453f, 0.21851815f, 0.09689426f, 0.07261874f, 0.20516053f, 0.11463988f, 0.24920514f, 
    0.02891395f, -0.03885191f, 0.25537732f, -0.12378001f, -0.17037033f, 0.35188270f, -0.13064606f, 0.30899811f, 
    0.11907487f, 0.28472596f, 0.16910163f, 0.20317550f, 0.05249710f, 0.00856004f, -0.09327072f, -0.15544234f, 
    0.00120472f, -0.35786614f, 0.10611650f, -0.03213027f, 0.23488742f, 0.04757664f, 0.25818750f, 0.01937518f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.56022012f, -0.04083258f, 0.21777739f, -0.16087490f, -0.00986928f, 0.00428117f, 0.06635117f, 0.00050858f, 
    -0.02831265f, -0.07731737f, -0.08446652f, 0.01263151f, 0.39801657f, -0.21722499f, -0.14983675f, -0.23273663f, 
    -0.10197291f, -0.02108403f, 0.00705384f, 0.06865041f, -0.08879326f, -0.04812219f, -0.06001056f, -0.07849887f, 
    -0.30711350f, -0.15641156f, -0.12441844f, -0.01263807f, -0.03067209f, 0.02579901f, -0.03698629f, 0.03489473f, 
    -0.00300961f, -0.02627566f, 0.07415266f, 0.05368421f, -0.22667019f, 0.14479195f, -0.17983435f, 0.03948746f, 
    -0.03987897f, 0.08340085f, 0.01714446f, 0.15056336f, 0.10487760f, -0.00414335f, 0.05347238f, -0.03320358f, 
    0.10184358f, -0.09314793f, -0.08437084f, -0.05108349f, -0.10762706f, 0.05071099f, -0.07620126f, -0.13915685f, 
    -0.06423547f, -0.09440219f, 0.03938928f, -0.17450735f, 0.00031152f, 0.01043867f, 0.06673860f, -0.04953207f, 
    -0.04112808f, 0.00866723f, -0.02513062f, -0.02042671f, 0.10872811f, -0.09510191f, -0.19095540f, -0.12677121f, 
    -0.11214627f, -0.27792889f, 0.10080132f, -0.39215973f, -0.05644473f, -0.13216078f, -0.07810353f, 0.04602228f, 
    -0.04169762f, -0.05184563f, -0.07176179f, 0.07875315f, 0.14674979f, 0.18636619f, 0.15110925f, -0.31675175f, 
    0.09307478f, 0.11260275f, -0.07158985f, -0.21570435f, -0.06478027f, -0.11822741f, -0.07262298f, -0.15090427f, 
    0.28530189f, 0.05922051f, 0.03586970f, -0.08637322f, -0.00108623f, 0.09806600f, 0.03775136f, 0.02901126f, 
    -0.02227166f, 0.10797510f, -0.03715461f, -0.12940250f, -0.15143792f, 0.14187975f, 0.07887489f, -0.07901709f, 
    0.02935249f, -0.11642736f, -0.28338167f, -0.16591322f, -0.00889772f, -0.03829038f, -0.00023895f, 0.06299180f, 
    0.17835888f, -0.27583513f, -0.22101802f, -0.00336741f, 0.11627452f, 0.09876449f, -0.06402754f, -0.18290032f, 
    -0.03434357f, -0.01608503f, -0.16656564f, 0.00574885f, 0.24193116f, 0.14640535f, 0.05245068f, -0.14600053f, 
    0.05855967f, 0.09566835f, 0.13238107f, 0.02986403f, -0.01356674f, 0.04468692f, -0.03294532f, 0.01033948f, 
    -0.05840031f, 0.02647946f, 0.12110798f, -0.22614634f, -0.03127125f, -0.03680018f, 0.00292213f, 0.08355309f, 
    -0.06831816f, -0.05412130f, -0.03829716f, 0.03180666f, -0.17780355f, -0.05577020f, -0.07079009f, 0.11047620f, 
    0.04785491f, 0.04037754f, 0.06007301f, 0.03259763f, -0.16521673f, 0.01809620f, 0.06824462f, 0.12259985f, 
    0.14904296f, 0.11436710f, -0.09713370f, -0.03559274f, -0.06333111f, 0.05881830f, 0.03615060f, 0.03378230f, 
    0.04892348f, 0.07511891f, 0.05499684f, 0.02225909f, 0.15723886f, -0.18467276f, -0.12800716f, -0.07220461f, 
    0.08085573f, -0.07291124f, -0.07502287f, -0.20499773f, 0.04154599f, 0.04042983f, 0.04250573f, 0.02972154f, 
    0.22782391f, 0.13398598f, -0.02906666f, -0.08222832f, 0.05376602f, 0.09821241f, 0.01677388f, -0.04397197f, 
    -0.01824981f, -0.05915879f, -0.01513433f, 0.00126199f, 0.06746650f, -0.00190719f, -0.08157549f, 0.12490249f, 
    0.03260607f, 0.01417853f, 0.00294932f, -0.06980846f, 0.00049596f, -0.00089483f, -0.04041322f, 0.15275368f, 
    0.31396270f, -0.02675589f, -0.07516692f, -0.15779012f, 0.00199621f, -0.08581453f, 0.14829554f, -0.10046674f, 
    -0.01451358f, 0.00937051f, -0.00462266f, 0.02606843f, -0.63376904f, -0.24637423f, 0.20550551f, -0.18448842f, 
    -0.04780040f, -0.04332171f, -0.02793146f, 0.06265134f, -0.04195935f, -0.08557683f, 0.03554093f, -0.14605524f, 
    0.04051727f, -0.04357994f, -0.16980518f, 0.05489414f, 0.08949047f, 0.02492926f, -0.01010935f, 0.01033706f, 
    -0.01764033f, -0.04486611f, -0.00664273f, 0.03544728f, 0.26622969f, -0.04176459f, -0.14667130f, -0.01943911f, 
    0.12419842f, 0.07365882f, -0.04262844f, 0.06707502f, 0.06033071f, 0.01048176f, -0.05035623f, -0.01664639f, 
    -0.29356638f, -0.32237437f, -0.18101826f, -0.02603059f, 0.06281723f, 0.02369472f, -0.09094184f, -0.14360608f, 
    -0.06086114f, -0.00505792f, -0.06906278f, 0.04852618f, -0.09197436f, -0.17747450f, 0.07884414f, -0.07714440f, 
    -0.04760670f, 0.14598799f, -0.08954285f, -0.05621541f, -0.04035192f, -0.04989854f, -0.11588252f, -0.16188523f, 
    0.49127764f, -0.01060188f, 0.02541179f, -0.10132222f, 0.07196999f, 0.00875564f, 0.14682359f, 0.01100641f, 
    -0.06439846f, -0.06704856f, -0.10438034f, -0.14175780f, -0.01187454f, -0.01018593f, 0.02745375f, 0.05624938f, 
    -0.02838396f, 0.03097334f, -0.04267327f, 0.02898991f, -0.15213983f, 0.01688025f, -0.09407112f, -0.13176067f, 
    -0.51150101f, -0.08798943f, 0.42269182f, -0.60505956f, 0.07766227f, -0.10688431f, -0.11446299f, 0.04213125f, 
    0.01064831f, -0.03555807f, -0.07404529f, -0.02310424f, -0.22610600f, 0.03323467f, 0.05579027f, -0.24415097f, 
    -0.10123671f, 0.08120644f, 0.02173469f, -0.05221744f, -0.09394749f, -0.08010765f, -0.14071976f, -0.04185377f, 
    -0.12933607f, -0.08177738f, 0.03196884f, -0.04719194f, -0.01017101f, 0.01657015f, -0.09950525f, 0.02054733f, 
    0.01262828f, -0.09923301f, -0.04652370f, 0.11128481f, 0.05899669f, 0.12727444f, 0.14204744f, -0.00990362f, 
    -0.20974141f, 0.02772516f, -0.03593240f, -0.03789800f, 0.05073536f, -0.02252888f, 0.01223069f, -0.05434192f, 
    0.33215246f, 0.18201539f, -0.32503310f, -0.17762849f, 0.05441782f, -0.09495959f, -0.05715905f, 0.03953280f, 
    -0.00720246f, 0.03601135f, 0.00350061f, -0.02410845f, 0.36204919f, 0.07025845f, -0.08031579f, -0.09076438f, 
    0.07013833f, 0.14484394f, 0.08225378f, 0.00828614f, -0.08516054f, -0.00663899f, 0.04676697f, -0.00683361f, 
    -0.11755121f, -0.12297935f, 0.03181190f, -0.07677244f, -0.01921207f, -0.09693688f, -0.05690400f, 0.04070770f, 
    -0.01420806f, -0.04036513f, -0.12820418f, -0.02219794f, 0.04523629f, -0.32974413f, -0.32781568f, 0.03992900f, 
    0.11868909f, 0.01760105f, -0.05031972f, 0.03849041f, 0.04426919f, -0.09510476f, -0.09863779f, 0.07998335f, 
    0.10938019f, 0.00738147f, -0.13651951f, -0.00644240f, -0.12260144f, 0.08932453f, 0.03226008f, -0.11363038f, 
    0.00645748f, 0.00695907f, 0.01100038f, -0.02024647f, -0.10562107f, -0.48487613f, -0.10714447f, -0.09676734f, 
    0.01877704f, 0.02516343f, 0.01876904f, 0.04206400f, -0.04024353f, 0.02708927f, 0.06458875f, 0.08785318f, 
    0.03959162f, -0.04747147f, -0.27077687f, 0.06969829f, 0.06753471f, 0.04112016f, 0.00300351f, 0.00363647f, 
    -0.20144831f, -0.19156699f, -0.07561596f, 0.13859710f, 0.12495708f, 0.21901357f, -0.24473809f, -0.05666225f, 
    -0.00437604f, -0.08922954f, -0.00915469f, -0.01820721f, -0.16671763f, -0.04074787f, -0.09170245f, -0.17451559f, 
    0.09399842f, -0.00531237f, -0.05090783f, -0.19291505f, -0.06244602f, -0.22127557f, -0.03588893f, 0.11122529f, 
    0.04091186f, 0.03422927f, -0.00285435f, 0.03332794f, 0.03306552f, 0.17313091f, -0.01739773f, -0.03816644f, 
    -0.20651187f, 0.03025701f, -0.05833193f, 0.09993625f, -0.01588698f, -0.07805131f, -0.03995002f, -0.00009780f, 
    -0.01619006f, 0.01634835f, 0.07574917f, 0.05429324f, -0.00831618f, 0.04036596f, 0.01695444f, 0.00757290f, 
    -0.13565452f, -0.13070427f, -0.02637213f, -0.03357091f, 0.00243634f, -0.17050830f, 0.04153721f, 0.03868926f, 
    -0.02858336f, 0.05906126f, -0.02241132f, 0.00289695f, -0.04355969f, 0.01909528f, 0.00952982f, 0.01619054f, 
    -0.14122076f, -0.36085865f, -0.20582105f, 0.04491988f, 0.00362573f, 0.07228433f, -0.01699520f, 0.00138497f, 
    -0.06121147f, 0.00517860f, -0.04098143f, -0.09695178f, 0.24032484f, 0.25703949f, 0.13508409f, -0.15553996f, 
    -0.12025013f, -0.01802580f, -0.07353882f, -0.08029309f, -0.08956921f, -0.13380721f, -0.06425793f, -0.03394255f, 
    0.04316518f, 0.00006847f, 0.04142444f, 0.00623988f, -0.00652980f, 0.05796105f, 0.02439165f, 0.00579288f, 
    -0.11167260f, -0.24753386f, -0.25742260f, -0.23348254f, -0.13404071f, 0.02814452f, -0.07922912f, -0.01823219f, 
    0.00039791f, 0.02031418f, -0.01123880f, -0.12312973f, -0.09320545f, -0.15497524f, -0.08443292f, -0.10100625f, 
    0.26088393f, 0.12734051f, -0.15357982f, -0.26427785f, -0.00494877f, 0.04316511f, 0.00919766f, 0.11403762f, 
    0.03119697f, -0.05453905f, -0.01571437f, 0.00531477f, -0.37580299f, -0.31233624f, -0.62881494f, 0.11586993f, 
    0.03071528f, 0.03057699f, -0.01174404f, 0.01669352f, -0.04526556f, -0.07597923f, -0.21252768f, -0.01934256f, 
    -0.06947526f, 0.06510482f, 0.04665644f, -0.05990910f, -0.16463333f, -0.08758973f, -0.18562131f, -0.03811179f, 
    -0.00188157f, -0.05453651f, -0.01990569f, 0.03370455f, -0.17297272f, 0.04687700f, 0.07834163f, -0.01371680f, 
    0.01402672f, 0.02895157f, -0.02437647f, -0.03921140f, -0.05092506f, -0.01874254f, -0.06919159f, 0.01891534f, 
    -0.32345134f, -0.13165763f, -0.01581933f, -0.00349934f, -0.03201340f, 0.05736491f, -0.10596586f, 0.01001177f, 
    -0.01320981f, 0.03223283f, 0.09170651f, 0.02867748f, 0.18357334f, 0.08687475f, 0.04404163f, -0.20130789f, 
    -0.02665955f, -0.01546445f, 0.07240204f, 0.06187058f, 0.03608847f, -0.03034358f, 0.03250044f, -0.05120033f, 
    0.42029646f, 0.28336275f, 0.23358983f, -0.16117351f, 0.05105982f, 0.07482909f, 0.11221471f, -0.03829582f, 
    0.01396961f, -0.04858564f, 0.00914160f, 0.02447402f, 0.02670039f, -0.03874956f, 0.05832512f, -0.10783515f, 
    0.08412069f, -0.09748910f, -0.07989594f, 0.12118587f, 0.02223737f, 0.00069110f, 0.00649074f, -0.02896613f, 
    0.26599258f, 0.00767666f, -0.12448359f, 0.04136541f, 0.17177662f, 0.05128164f, 0.08250627f, 0.10688320f, 
    -0.00141217f, -0.01118251f, 0.02499875f, -0.02356491f, -0.07200225f, 0.15578242f, 0.16922483f, 0.01841733f, 
    0.06924726f, 0.22774872f, 0.05078569f, 0.17149687f, 0.02246608f, 0.11015615f, 0.08473238f, 0.13743161f, 
    0.18208383f, 0.14187412f, 0.04402361f, -0.17081027f, 0.06681956f, 0.05713717f, 0.01000937f, -0.11060267f, 
    -0.08993556f, -0.16616346f, -0.19033298f, -0.05749362f, 0.25644636f, 0.22850229f, 0.02815083f, 0.09731912f, 
    0.06512999f, 0.26079369f, 0.23642686f, -0.02059704f, -0.04461152f, 0.01959861f, 0.05687387f, -0.08379707f, 
    -0.03633609f, -0.01854030f, -0.02365862f, -0.03125257f, -0.01517542f, 0.08331114f, -0.13829671f, -0.00389641f, 
    -0.07187288f, -0.05090708f, -0.07355089f, 0.11857117f, 0.24300228f, -0.03793459f, -0.19142418f, -0.02724011f, 
    0.05932998f, 0.05172364f, -0.11488669f, 0.04646762f, -0.01170482f, 0.06010240f, 0.01476424f, 0.10449108f, 
    -0.41339338f, -0.16750035f, -0.18250419f, 0.05380061f, -0.01037412f, 0.03355683f, 0.01830132f, 0.01281027f, 
    -0.01090391f, 0.02459427f, -0.00795372f, 0.04198536f, -0.12832467f, -0.11110120f, -0.00702512f, -0.00563553f, 
    -0.02122599f, 0.03937161f, 0.04367596f, 0.08254968f, -0.16957018f, -0.09399037f, -0.22954381f, -0.01489662f, 
    -0.06853962f, 0.23999371f, 0.38520131f, -0.41670910f, -0.02499964f, 0.18064325f, 0.11624907f, 0.02768210f, 
    -0.00986590f, -0.01545615f, -0.14812823f, -0.16853756f, 0.21294934f, 0.06515559f, -0.09103023f, -0.11923292f, 
    0.05711538f, 0.07712646f, 0.00458682f, -0.02807737f, -0.02132360f, -0.02121726f, 0.01112640f, -0.00017646f, 
    -0.05643675f, -0.02369429f, 0.09810663f, 0.03689024f, 0.08716734f, -0.00897982f, -0.00873843f, 0.04250202f, 
    0.05117062f, 0.12328877f, 0.04201367f, 0.17630123f, 0.46747079f, -0.12642851f, 0.05265762f, -0.09481005f, 
    -0.05314640f, 0.01012668f, 0.02158186f, 0.01770881f, 0.10337807f, -0.13535440f, 0.07116167f, 0.04787343f, 
    0.01889513f, 0.06331212f, 0.18177439f, 0.09775288f, 0.00147877f, -0.00588351f, -0.04543902f, 0.00041542f, 
    0.05212120f, 0.00075844f, -0.00037515f, 0.10895517f, -0.11362381f, -0.04023230f, 0.04461181f, 0.09480305f, 
    -0.05274332f, -0.05305039f, -0.16239353f, 0.01036940f, 0.08606555f, 0.05709450f, -0.04984910f, -0.02951295f, 
    -0.04200663f, -0.19225551f, -0.11364049f, -0.17316769f, 0.15831129f, 0.08516015f, -0.02949910f, 0.03516203f, 
    0.03727549f, -0.01827597f, -0.09743428f, 0.01766678f, -0.05522672f, 0.09218873f, -0.00338294f, -0.01368750f, 
    -0.08068067f, 0.06648704f, 0.03935480f, 0.02355791f, -0.02199386f, 0.12565763f, -0.00560987f, -0.04886651f, 
    -0.39521500f, -0.46571809f, -0.15955661f, -0.25182807f, -0.00381926f, -0.15266933f, 0.13697116f, -0.06077263f, 
    0.00596463f, 0.01916129f, 0.01642752f, -0.11135696f, -0.22233886f, 0.17388941f, 0.02339373f, -0.09738399f, 
    -0.00171097f, 0.08070561f, 0.09825742f, 0.10183564f, 0.02816042f, 0.01140210f, 0.13299976f, -0.06915930f, 
    -0.17734317f, -0.14196241f, -0.61398089f, -0.11681392f, -0.08973698f, -0.01994399f, 0.03790036f, 0.06344630f, 
    -0.23947531f, -0.17611970f, -0.34745198f, 0.01407028f, -0.04500780f, -0.02786401f, 0.08977059f, 0.04071693f, 
    -0.05414699f, -0.03655444f, 0.07737023f, -0.03942826f, -0.02925934f, 0.01186241f, -0.01945849f, 0.03746962f, 
    -0.01482338f, -0.24347550f, -0.17547223f, -0.47468951f, -0.07289745f, -0.00113385f, -0.00103001f, 0.16286312f, 
    0.10564834f, 0.12041479f, -0.02243073f, -0.11311836f, 0.34088489f, 0.26825228f, 0.09296419f, 0.07900974f, 
    0.12095331f, 0.08337179f, -0.08170773f, -0.02078841f, -0.04161396f, 0.03705273f, 0.03217003f, -0.20764022f, 
    0.00992220f, 0.01370707f, 0.13869412f, -0.10228541f, 0.05165186f, 0.01082915f, -0.02643764f, -0.10764746f, 
    0.12595809f, 0.11405249f, -0.14516595f, 0.04060186f, 0.07149198f, -0.11785242f, 0.12635624f, -0.13958979f, 
    -0.00404109f, -0.03557689f, -0.02988049f, -0.00698386f, 0.07422570f, -0.09647583f, -0.01502342f, 0.07530751f, 
    0.11733217f, -0.10428832f, -0.28331935f, 0.16047400f, 0.04680137f, 0.03480108f, 0.02860193f, 0.01058526f, 
    -0.22650848f, -0.20076466f, -0.39084610f, -0.42226952f, 0.23332070f, -0.23104918f, 0.27408651f, -0.08428822f, 
    -0.15167959f, -0.10712710f, -0.07730486f, -0.21567096f, -0.06398586f, -0.00754723f, -0.00974274f, -0.00283785f, 
    0.06803304f, 0.17490016f, 0.04360665f, 0.14034510f, -0.01254948f, -0.02877526f, -0.10441457f, -0.17546308f, 
    0.08279863f, -0.06084711f, 0.11158355f, 0.00696834f, 0.09382610f, -0.26569030f, -0.06809719f, -0.16359179f, 
    -0.00565614f, 0.04323562f, 0.01764145f, -0.00062605f, 0.16409436f, -0.06395567f, -0.09600005f, 0.07090653f, 
    0.06009513f, -0.15228719f, -0.10546050f, -0.34819567f, 0.06776780f, 0.05611534f, -0.01211035f, 0.13627890f, 
    -0.01062099f, -0.03837484f, 0.01197809f, 0.05111264f, -0.14669913f, 0.04756818f, -0.05819980f, 0.13242638f, 
    -0.00224354f, 0.03257401f, 0.05374079f, -0.08260338f, -0.02756176f, -0.00843345f, -0.09213579f, 0.05861055f, 
    0.52754992f, -0.18063129f, -0.03053719f, -0.03841066f, -0.01679263f, 0.03897763f, 0.00430970f, -0.11240923f, 
    0.05411077f, -0.07341903f, 0.06753533f, -0.04518330f, 0.29821649f, 0.15914330f, 0.03046082f, -0.10582501f, 
    0.06714510f, -0.06301574f, 0.13334826f, 0.14594528f, -0.05614627f, 0.02510261f, -0.04211549f, -0.02375036f, 
    0.18955059f, -0.11699366f, 0.25690478f, -0.12224526f, 0.00298288f, -0.07864158f, -0.00496174f, -0.00839751f, 
    -0.00160522f, -0.13243650f, 0.04496668f, 0.05543294f, -0.00262376f, -0.19047698f, 0.04736270f, -0.08810145f, 
    -0.00016027f, 0.09820051f, -0.08421563f, 0.08659770f, -0.04516124f, -0.01514990f, 0.04231889f, -0.07004472f, 
    -0.26180926f, -0.31012675f, 0.22986595f, 0.01422879f, 0.06533638f, -0.02362289f, 0.20874795f, -0.17401135f, 
    0.08776365f, -0.04693893f, 0.09528899f, -0.01104550f, 0.09715784f, 0.02238617f, 0.01988494f, 0.06500281f, 
    -0.06538496f, 0.02047376f, -0.01856797f, -0.02887677f, -0.06590486f, 0.10101601f, 0.05655426f, -0.05682075f, 
    -0.28073010f, 0.39915791f, 0.06737956f, -0.02751172f, 0.04583267f, 0.01579168f, -0.01056994f, 0.11192886f, 
    -0.04588072f, -0.03040418f, -0.06163306f, 0.04867031f, -0.05582239f, 0.31932807f, -0.05591572f, -0.03311341f, 
    -0.06294692f, 0.07855061f, 0.00721444f, -0.08232994f, 0.05915569f, 0.04962406f, -0.03158793f, -0.00795465f, 
    -0.03980434f, 0.01018008f, 0.09959013f, 0.01188610f, 0.07112426f, 0.04582628f, -0.08868351f, -0.09353615f, 
    0.04120057f, 0.08149317f, 0.03232529f, -0.05580001f, 0.03565066f, 0.11163991f, -0.14720742f, 0.08826587f, 
    0.07312355f, -0.09832481f, 0.05080781f, 0.08275814f, -0.05952261f, 0.01832546f, -0.08602184f, 0.06922723f, 
    0.07989941f, -0.05715073f, 0.08229251f, 0.01011388f, -0.05809695f, 0.11373837f, 0.11658115f, -0.04364223f, 
    -0.02304087f, -0.05092482f, -0.01386227f, 0.02420945f, 0.06589425f, 0.00241743f, 0.36487991f, 0.29648027f, 
    0.23122931f, -0.21195376f, 0.12430145f, 0.01665654f, 0.00212885f, 0.02058342f, 0.07276540f, -0.14413330f, 
    0.03919389f, 0.03774055f, 0.13941114f, -0.21362841f, 0.16687469f, -0.00077412f, 0.05097380f, -0.02361514f, 
    0.12186237f, -0.10274208f, 0.03773894f, -0.05397188f, 0.46958232f, 0.07127710f, -0.21226633f, -0.05829097f, 
    0.03012919f, -0.04705219f, 0.02149715f, -0.08746167f, -0.00028486f, -0.11897124f, -0.00704856f, -0.11754716f, 
    -0.04047483f, -0.11236713f, -0.00102817f, 0.01043727f, 0.03404636f, 0.03555724f, 0.03048833f, 0.05355972f, 
    -0.03706110f, 0.05711549f, 0.02665413f, -0.02372998f, 0.12005367f, 0.08598217f, 0.15146761f, 0.11372577f, 
    -0.04224391f, -0.00314042f, -0.04060648f, -0.10145965f, 0.08111764f, -0.03329164f, 0.06905382f, -0.05506667f, 
    -0.08701818f, -0.28882322f, 0.09602948f, -0.09600504f, 0.07026665f, -0.04485927f, -0.02244714f, 0.02047877f, 
    0.05199382f, 0.10873517f, 0.12879093f, 0.02912079f, -0.08725457f, -0.30821311f, -0.25695646f, 0.07208688f, 
    0.07238431f, 0.04421385f, 0.06117481f, 0.21283843f, 0.09008676f, -0.03673536f, -0.09648844f, 0.08432475f, 
    -0.07405415f, -0.08666215f, 0.06026397f, -0.22094074f, -0.04136674f, -0.00167993f, -0.14196695f, -0.07943366f, 
    -0.07361599f, -0.12668416f, 0.09190404f, 0.09727681f, -0.07433274f, -0.27690676f, -0.06721742f, -0.32789156f, 
    0.14449307f, -0.08950311f, -0.08704869f, 0.18437679f, 0.06044570f, 0.03410994f, 0.03829126f, -0.12597361f, 
    -0.05394675f, 0.04861172f, 0.02680354f, -0.03629530f, 0.01806367f, -0.01440428f, 0.03730737f, 0.01318028f, 
    -0.10503531f, -0.02357112f, 0.01326248f, -0.03621997f, 0.10530347f, 0.00734520f, -0.01507562f, 0.00398568f, 
    -0.01098995f, -0.01101553f, -0.00462658f, 0.02836703f, -0.00305045f, -0.06420530f, 0.00082022f, -0.00544359f, 
    0.50237799f, 0.07884907f, 0.23524620f, 0.00237857f, -0.00166817f, -0.05366505f, 0.05567856f, -0.03277011f, 
    0.00417283f, 0.11130865f, -0.09750931f, 0.04302576f, -0.43788537f, 0.01407269f, -0.34324920f, -0.10649922f, 
    -0.02267873f, -0.05088154f, 0.05991380f, -0.05710242f, 0.00183592f, -0.03854452f, -0.09295482f, -0.09848920f, 
    0.02476890f, 0.07439913f, 0.04863114f, 0.08311790f, -0.07628378f, -0.04427490f, 0.01063302f, 0.03202073f, 
    -0.06678956f, 0.11076656f, 0.07663728f, 0.04043759f, -0.34970456f, -0.01119292f, -0.12313545f, -0.22812209f, 
    0.02044955f, 0.07282209f, 0.07291888f, -0.00624037f, 0.11677736f, 0.20581527f, -0.13696024f, 0.00590999f, 
    -0.22450766f, -0.01094778f, 0.13723405f, 0.17859687f, 0.04665921f, 0.00882749f, 0.04849270f, 0.10236224f, 
    -0.08031189f, -0.02584181f, 0.06845683f, 0.00817112f, 0.77500480f, -0.02795053f, 0.09943882f, 0.03403899f, 
    0.01934461f, -0.00581742f, -0.00088273f, -0.09260918f, 0.21122834f, -0.10167359f, -0.07060827f, 0.02001736f, 
    -0.08308309f, 0.03194062f, -0.03077555f, -0.00607687f, 0.06129067f, 0.17015035f, 0.02111328f, -0.06354498f, 
    -0.15084299f, 0.01258275f, -0.03175471f, 0.10503221f, -0.02298511f, 0.05644434f, 0.11716529f, 0.11958440f, 
    0.04470685f, -0.06668073f, 0.00848655f, 0.02158798f, 0.07468069f, 0.09734651f, -0.07741576f, 0.11486229f, 
    0.12599932f, 0.15690961f, 0.19157997f, 0.14292456f, 0.02488156f, -0.00602482f, -0.00124693f, -0.05227734f, 
    -0.02179346f, -0.02332596f, -0.00532190f, 0.03392650f, -0.06428888f, 0.02935450f, -0.02167049f, -0.12504408f, 
    -0.05324636f, -0.05130270f, -0.08585466f, -0.09151684f, -0.09923806f, -0.07441035f, 0.02869647f, -0.00103784f, 
    -0.36894095f, 0.04997472f, -0.16496643f, 0.03034725f, -0.09543502f, 0.10290742f, 0.11518780f, -0.02363046f, 
    0.00053373f, -0.17844348f, -0.04821444f, 0.13252138f, 0.01349698f, 0.06844047f, -0.18023592f, -0.05311689f, 
    -0.12655763f, -0.01829167f, 0.14460370f, -0.30391812f, -0.03936801f, 0.02952261f, -0.03775819f, 0.03191552f, 
    0.24887396f, 0.04056033f, 0.24179381f, 0.03151003f, 0.05301975f, 0.11588967f, 0.10467716f, -0.28439081f, 
    0.02718566f, -0.02744975f, -0.07677634f, -0.04787805f, -0.23124637f, 0.10174314f, 0.03311648f, -0.06717033f, 
    0.06462453f, 0.04203334f, -0.58677810f, -0.42226997f, -0.07398600f, -0.00517752f, -0.15319960f, -0.26898602f, 
    0.09574473f, 0.12291937f, 0.10853129f, 0.15263660f, 0.04402100f, 0.11158758f, -0.00791122f, 0.25216526f, 
    -0.03974188f, 0.03899555f, 0.10477669f, 0.02312688f, 0.14745522f, -0.05982885f, 0.02730605f, 0.14519562f, 
    0.04816900f, -0.03070472f, -0.19901484f, -0.11474297f, 0.01368315f, -0.02725261f, -0.08933793f, 0.03235842f, 
    -0.46559381f, -0.27710116f, 0.07669713f, -0.17739199f, 0.03268088f, 0.12113488f, -0.05663790f, 0.05971444f, 
    -0.15929547f, -0.04933468f, -0.01307318f, -0.10900625f, 0.44935668f, -0.06019102f, 0.05330368f, 0.03262553f, 
    0.04172580f, 0.00260947f, 0.18370070f, -0.25975868f, 0.08946999f, 0.07331342f, 0.01011468f, -0.10601595f, 
    0.33799198f, 0.07692637f, 0.25648233f, 0.03480963f, -0.07735317f, -0.01880872f, 0.04092713f, -0.02067031f, 
    -0.06071334f, 0.00315714f, -0.01973605f, 0.04966672f, 0.01619659f, -0.22856730f, 0.00760689f, 0.00540374f, 
    -0.04884486f, -0.08419959f, 0.08201037f, 0.00819795f, 0.10056490f, -0.04127258f, 0.09990093f, 0.10682057f, 
    -0.68668228f, 0.20045085f, -0.12380802f, -0.09701447f, 0.09697998f, -0.16872539f, 0.22871824f, 0.08744579f, 
    -0.03099260f, -0.12026811f, 0.10785054f, 0.02988385f, -0.13844219f, 0.16720410f, -0.16619702f, 0.08847245f, 
    -0.23221070f, 0.12285177f, -0.14633676f, 0.08117109f, -0.10902000f, -0.01407190f, -0.07412782f, -0.00259115f, 
    0.08743586f, -0.13063218f, -0.21855034f, 0.11324086f, 0.01284370f, 0.01712849f, 0.07341588f, 0.03836203f, 
    -0.03510415f, -0.05188039f, -0.18936944f, 0.07679246f, 0.20091884f, -0.19279276f, 0.37070289f, 0.06308373f, 
    0.11182499f, -0.12463535f, 0.03538475f, 0.06813057f, 0.10699659f, -0.04248041f, 0.06309792f, 0.07235946f, 
    -0.06110124f, -0.09967645f, -0.03808758f, 0.04434251f, -0.05943058f, -0.05946774f, -0.03545373f, 0.06890501f, 
    0.05904044f, -0.03103250f, -0.12783059f, 0.16012813f, 0.13634485f, -0.20230225f, -0.06562625f, -0.01196094f, 
    0.06149818f, 0.01274250f, 0.01656803f, -0.11580727f, 0.01449241f, 0.15790978f, -0.04868968f, 0.03487150f, 
    0.08356595f, 0.19354744f, -0.25452676f, 0.15876588f, -0.05822327f, 0.05602990f, -0.00652947f, -0.06952650f, 
    0.09886380f, -0.03058772f, -0.19393161f, 0.12447950f, -0.14141421f, 0.00865328f, -0.06843892f, 0.12519006f, 
    -0.00907810f, -0.00646512f, 0.07980096f, 0.05825508f, -0.02954253f, -0.02566872f, 0.06927127f, -0.14139843f, 
    0.05519185f, 0.24116193f, -0.17467107f, 0.03642063f, 0.09196549f, -0.03230753f, 0.04202279f, -0.03662988f, 
    -0.05790330f, 0.01456949f, 0.02900578f, -0.00147466f, -0.18808952f, -0.21525331f, -0.14201562f, -0.00917687f, 
    -0.04627192f, 0.01765774f, -0.04330343f, -0.14791025f, -0.00907412f, -0.03226328f, -0.03031001f, 0.00781747f, 
    -0.03226544f, 0.07635604f, -0.12092002f, -0.01666584f, 0.04515323f, -0.01294158f, -0.00642388f, -0.04428751f, 
    -0.00142820f, 0.07873637f, -0.07521207f, 0.06998660f, -0.16054429f, -0.03087405f, -0.00891301f, -0.13005765f, 
    0.05202549f, -0.02238899f, 0.22385263f, 0.01029602f, -0.00612050f, 0.01855702f, 0.00100824f, 0.07043273f, 
    -0.08932641f, 0.49555126f, 0.33286238f, 0.07796033f, -0.01315534f, 0.02228844f, 0.04145640f, -0.05559435f, 
    -0.07994279f, -0.06388041f, -0.12595350f, 0.04939870f, 0.07315367f, 0.05457126f, 0.42114964f, 0.59314471f, 
    -0.16412823f, 0.08948101f, -0.01999556f, 0.02284706f, 0.04476549f, -0.05108946f, -0.04445828f, 0.01558369f, 
    -0.04887243f, -0.02167302f, -0.15323107f, -0.03245777f, -0.03121747f, 0.02299824f, 0.01241530f, 0.03180065f, 
    0.04255467f, -0.12635662f, -0.00235838f, 0.00105311f, -0.03293226f, 0.28412250f, 0.00231510f, 0.08062439f, 
    0.02039754f, 0.05784757f, 0.02241222f, -0.18497629f, 0.02778824f, 0.05451059f, 0.03146430f, 0.14066592f, 
    -0.00092604f, -0.05952707f, 0.08903388f, 0.05334520f, 0.02348383f, -0.02313309f, 0.00143151f, -0.00482412f, 
    0.02760017f, 0.03521268f, 0.22493342f, 0.07423989f, -0.32580039f, -0.08488741f, -0.19509108f, -0.34357524f, 
    -0.18057123f, -0.01456225f, 0.10778134f, -0.06983206f, -0.04729932f, -0.01348988f, 0.00244092f, -0.07275727f, 
    -0.01577588f, -0.12701550f, 0.25428078f, 0.19881770f, 0.00247193f, 0.02719420f, -0.03983930f, 0.00206549f, 
    -0.02204268f, 0.09376129f, 0.04855769f, 0.05768123f, -0.06933904f, 0.23763029f, 0.10086001f, 0.06800880f, 
    -0.04352459f, -0.00815280f, 0.00474932f, -0.16929220f, 0.05205834f, 0.18428649f, 0.12257332f, 0.15816028f, 
    0.08318389f, 0.16845235f, -0.10885027f, -0.05416174f, -0.11833615f, -0.15569879f, 0.06049407f, 0.04040168f, 
    0.02122184f, -0.02587207f, -0.06151503f, 0.01271837f, 0.18812066f, -0.13236114f, -0.31790331f, 0.08148535f, 
    0.09962096f, 0.05350734f, 0.04073957f, 0.03571805f, -0.00994452f, -0.05368808f, -0.08269580f, 0.01088152f, 
    -0.22763726f, 0.35751224f, 0.18427576f, 0.11933678f, -0.07773318f, -0.01160964f, 0.06082823f, -0.12911382f, 
    0.05450947f, 0.10854904f, -0.05158997f, 0.05614824f, -0.29152328f, 0.24843507f, 0.35096714f, -0.23011747f, 
    -0.21651405f, 0.21537602f, 0.01696352f, -0.13720487f, 0.05324021f, -0.08135773f, -0.04674912f, -0.15979174f, 
    -0.35371143f, -0.17911519f, 0.23974068f, -0.17034566f, 0.02206356f, 0.08588646f, -0.10541245f, 0.03794398f, 
    0.01072176f, -0.16426209f, 0.06433804f, -0.03944285f, 0.08490229f, -0.13933362f, -0.21033862f, -0.01558636f, 
    0.20275591f, 0.01496915f, -0.04532283f, 0.02904331f, 0.03891731f, -0.12270869f, -0.01282350f, 0.11071040f, 
    -0.01610146f, 0.01267557f, 0.01959628f, 0.16505058f, -0.01355510f, -0.07236531f, 0.11432461f, 0.06880244f, 
    0.04193533f, 0.05165885f, 0.02367744f, -0.19586721f, -0.09460232f, -0.04790901f, 0.03295796f, 0.07599463f, 
    -0.00031799f, 0.03749288f, -0.03260929f, 0.04181163f, -0.00179600f, -0.02015886f, 0.00952461f, 0.16015972f, 
    -0.48375025f, 0.09344885f, -0.29144144f, 0.10131927f, -0.03297789f, -0.03390981f, 0.02660878f, -0.01105146f, 
    0.04040658f, -0.01017005f, -0.12331655f, 0.08822222f, -0.21741328f, 0.06021095f, -0.08642602f, 0.03569121f, 
    -0.01774609f, -0.01593202f, 0.02201461f, 0.04979937f, 0.00969233f, -0.04220105f, 0.08629680f, 0.03590817f, 
    -0.16523634f, -0.01398009f, 0.08019540f, -0.04619245f, -0.04898686f, 0.01305522f, -0.05674845f, -0.14492580f, 
    -0.03758306f, 0.02127700f, 0.07780050f, -0.00563702f, 0.10076020f, 0.11563746f, -0.12704928f, -0.11118864f, 
    0.12190259f, -0.19564809f, 0.04442857f, 0.09487335f, 0.02402336f, -0.00366419f, 0.02542927f, -0.14470586f, 
    -0.45683447f, -0.39388722f, -0.21022823f, -0.47674865f, -0.03836359f, -0.12897320f, -0.01944894f, 0.00764562f, 
    -0.01183638f, -0.02010783f, 0.00671232f, -0.01625568f, -0.51723570f, -0.62535572f, 0.09236442f, -0.20962708f, 
    0.06272380f, -0.06086044f, 0.05744556f, -0.11911583f, 0.04204379f, -0.05070196f, -0.02173973f, -0.10010739f, 
    0.02645242f, 0.01957942f, -0.02588928f, -0.11561220f, -0.08279318f, 0.06327684f, -0.12293895f, 0.13227524f, 
    0.04683975f, -0.07002591f, 0.07756814f, 0.00674139f, -0.25854501f, 0.33749643f, 0.25745425f, 0.06458107f, 
    -0.03380700f, -0.01183682f, 0.04523639f, -0.03983032f, 0.07274844f, 0.00723094f, 0.01146192f, -0.12159203f, 
    -0.08095107f, -0.00784385f, 0.02372589f, -0.02082042f, 0.04683465f, 0.08501110f, -0.12260062f, 0.05280340f, 
    0.00490076f, 0.01162817f, 0.01781032f, 0.02167701f, 0.03735606f, 0.09677249f, -0.36533868f, 0.07668158f, 
    0.01926084f, -0.01595389f, 0.00946682f, 0.09039830f, -0.02201437f, 0.05275279f, -0.04406200f, 0.00443893f, 
    -0.00253715f, -0.09337766f, 0.35192961f, -0.13011625f, -0.06250500f, -0.04004778f, 0.11154108f, -0.00192565f, 
    -0.12027794f, 0.01712884f, -0.01308845f, -0.03086425f, 0.24781953f, -0.06364673f, -0.02157963f, -0.14681104f, 
    0.18790984f, -0.04355139f, -0.06416415f, 0.20882067f, 0.07957904f, 0.00279710f, -0.06433767f, 0.00684953f, 
    -0.27029669f, 0.06102536f, 0.01175846f, -0.00371103f, 0.01944106f, 0.16659641f, -0.12883234f, -0.31258735f, 
    0.10267024f, -0.04841998f, 0.00738098f, 0.06289434f, 0.23153596f, -0.04598593f, 0.16218229f, -0.21864364f, 
    0.12204062f, 0.00436179f, -0.15151756f, -0.04921988f, -0.00706794f, -0.03495852f, 0.05540077f, -0.03664806f, 
    -0.06550428f, 0.02793020f, -0.02035131f, 0.07296441f, -0.01851860f, 0.01692904f, 0.02074384f, 0.04147124f, 
    -0.01797261f, 0.00303696f, 0.02399895f, -0.02064375f, -0.30473775f, -0.26599824f, 0.11085774f, 0.00593097f, 
    0.04150937f, -0.01750374f, -0.01296036f, -0.00481085f, -0.04636015f, -0.05255722f, -0.01908771f, -0.00050117f, 
    -0.17302150f, 0.10453866f, 0.03620790f, -0.12069255f, 0.03919711f, 0.01136922f, -0.00000669f, 0.00183610f, 
    0.02916195f, -0.04216932f, -0.08197484f, 0.09834127f, -0.12608397f, -0.27940074f, -0.14658086f, 0.02529276f, 
    -0.00475667f, 0.00309553f, -0.11992328f, 0.06400339f, -0.14164935f, -0.08629140f, -0.01514075f, 0.00646810f, 
    -0.10017022f, -0.02927875f, -0.04194763f, 0.01890617f, -0.01331529f, -0.03468983f, 0.00405918f, 0.00620201f, 
    -0.23613581f, -0.07948609f, 0.05218658f, 0.06731619f, 0.06581826f, 0.20024294f, 0.10099374f, -0.00434463f, 
    -0.00991944f, 0.12939720f, -0.06616390f, -0.14001586f, -0.15797651f, 0.03651534f, -0.06131280f, 0.01566474f, 
    -0.51131707f, -0.61226809f, -0.47021541f, -0.31453460f, 0.03149325f, -0.10844410f, -0.03713953f, -0.28877011f, 
    0.01333083f, -0.07717955f, -0.02443696f, -0.02239457f, -0.00157029f, -0.08300768f, 0.31013221f, 0.01060011f, 
    -0.03709658f, -0.01373869f, 0.00457229f, 0.00616217f, 0.01267848f, 0.07369639f, 0.07791180f, 0.04033664f, 
    -0.01030118f, -0.09838907f, -0.10227825f, 0.05798263f, -0.28345948f, -0.03376606f, 0.19064558f, 0.00958568f, 
    0.01458585f, -0.09110315f, 0.06279896f, -0.03407630f, -0.09417988f, -0.02820227f, -0.04769302f, 0.12921567f, 
    -0.01894337f, -0.01946421f, 0.00118997f, 0.02004445f, 0.01563068f, 0.03404285f, -0.13520364f, 0.10458216f, 
    -0.03013480f, -0.18589348f, 0.01749023f, 0.04051615f, -0.05357350f, -0.03219640f, 0.11222697f, 0.12182689f, 
    0.03706385f, 0.04039996f, -0.07714432f, 0.12136257f, -0.08588949f, 0.01560994f, -0.13709480f, 0.04196355f, 
    0.07679249f, 0.09437682f, -0.06845605f, -0.02624997f, 0.03696664f, 0.03288075f, 0.03235830f, -0.03410039f, 
    0.01889068f, -0.00491762f, -0.07864307f, 0.18728730f, -0.01895098f, 0.04016352f, -0.01069038f, 0.12836328f, 
    0.03853880f, 0.01844699f, 0.00958807f, -0.04907519f, -0.05917608f, -0.03005129f, -0.17709774f, -0.28512046f, 
    -0.10174182f, 0.05167276f, 0.12062486f, -0.02804955f, -0.04129621f, 0.04445569f, -0.00736484f, -0.01330024f, 
    -0.04292389f, 0.29070672f, 0.54887557f, -0.07091252f, -0.14198075f, -0.11880998f, 0.13008656f, 0.02021790f, 
    0.04753691f, -0.06998925f, 0.07107631f, -0.13508996f, 0.03843431f, 0.19444956f, 0.17446944f, 0.15782546f, 
    -0.02228451f, 0.02208914f, 0.01870432f, 0.06571454f, 0.04984785f, 0.05755497f, 0.00142854f, 0.01466169f, 
    0.12120219f, 0.03579665f, 0.23206830f, 0.22114372f, -0.00360610f, 0.01242028f, -0.03491386f, 0.09784466f, 
    -0.01300577f, -0.04598565f, -0.05467593f, -0.05062183f, -0.35862637f, -0.40192807f, -0.08218108f, 0.11611667f, 
    -0.01989057f, -0.19473881f, -0.00416960f, -0.00405991f, 0.03086804f, 0.02248136f, -0.00777597f, -0.13690634f, 
    0.21346843f, 0.24125563f, 0.01622804f, 0.11921842f, -0.05089381f, 0.01235398f, 0.07552691f, -0.09526122f, 
    -0.06117962f, 0.07359120f, -0.04192157f, 0.04003103f, -0.41669342f, 0.27744907f, 0.14857309f, -0.01127269f, 
    -0.19504829f, 0.04230525f, 0.05021397f, -0.26550192f, 0.00514637f, 0.08579142f, -0.03032910f, -0.07154698f, 
    -0.29645368f, -0.14448763f, 0.07149244f, -0.07648259f, 0.03326239f, -0.01582520f, 0.02065066f, 0.06514873f, 
    0.01439727f, -0.05663143f, -0.01182276f, 0.05861429f, 0.13044886f, -0.15167899f, -0.20800464f, -0.00764631f, 
    0.00192306f, -0.07228829f, 0.09323788f, 0.05038217f, -0.18012279f, -0.13134386f, -0.03301439f, 0.11804012f, 
    -0.09839842f, -0.28496724f, -0.29764962f, 0.09897284f, -0.02072055f, -0.16789223f, -0.14027923f, -0.01982256f, 
    0.02935228f, -0.00809619f, 0.01657788f, 0.06219408f, -0.21764271f, 0.10010632f, -0.03772594f, -0.13987786f, 
    -0.11693699f, -0.09899828f, 0.02684695f, 0.08403996f, 0.05806622f, -0.04105444f, -0.03807803f, 0.02133163f, 
    0.37687203f, -0.02490588f, -0.09674319f, -0.50476456f, 0.06212084f, -0.04380610f, 0.00987198f, -0.02187596f, 
    -0.02944061f, 0.03590146f, -0.12799461f, -0.08521965f, -0.58030725f, 0.63170397f, -0.15047094f, -0.17687289f, 
    0.18106720f, 0.19208606f, -0.05861656f, -0.13480669f, -0.39477274f, -0.11605932f, -0.06795502f, -0.09402087f, 
    -0.00402675f, -0.13221306f, 0.11971617f, 0.15155309f, -0.01985844f, 0.00501698f, -0.19851020f, 0.08587115f, 
    0.04249837f, 0.13833511f, -0.09423473f, 0.06777727f, 0.46195614f, -0.24646625f, 0.05669215f, -0.04392986f, 
    -0.01948227f, 0.08363420f, -0.24338073f, 0.08996740f, -0.12246680f, 0.14604220f, -0.05840029f, -0.04163902f, 
    -0.13118735f, -0.11077896f, -0.02371664f, 0.16433463f, -0.07660136f, -0.07104747f, -0.15245752f, 0.04582772f, 
    -0.05498097f, 0.02971144f, -0.09954704f, 0.00372890f, 0.03618074f, -0.17613500f, 0.03479679f, -0.49927491f, 
    0.16046144f, 0.09487350f, -0.09203278f, -0.03659152f, -0.07176579f, -0.05756374f, -0.04267750f, 0.02689415f, 
    0.17794511f, 0.33785856f, 0.03666777f, -0.01309835f, 0.10365863f, 0.04193316f, -0.05292793f, -0.09245776f, 
    -0.13546939f, -0.09801939f, 0.11839782f, 0.07583076f, 0.06479646f, -0.05214824f, -0.03241448f, 0.11396821f, 
    -0.07883786f, -0.06423474f, -0.02961475f, -0.02968394f, -0.09016105f, 0.00116770f, 0.01115888f, -0.11126651f, 
    0.09827077f, -0.08396718f, 0.02043397f, -0.23499049f, 0.07674832f, 0.14412506f, 0.00411570f, 0.05141900f, 
    -0.07557173f, -0.06516528f, -0.09911822f, 0.07889643f, 0.17699365f, -0.13346440f, 0.31043702f, 0.00753156f, 
    -0.22466558f, -0.04190211f, 0.05780093f, 0.03618369f, -0.00386978f, 0.11259005f, -0.03673749f, 0.13876301f, 
    -0.01813516f, 0.00157725f, 0.00583486f, 0.27471182f, 0.22867249f, 0.02215964f, 0.00170763f, 0.08354919f, 
    -0.02626331f, 0.04498838f, 0.04185197f, 0.03872903f, 0.09492179f, -0.14666390f, -0.05322842f, 0.14765418f, 
    0.05895234f, -0.00678894f, -0.09797328f, -0.12474356f, -0.05303290f, 0.10130872f, -0.04145537f, 0.11540368f, 
    0.04467272f, 0.02484991f, 0.02594219f, 0.05413113f, -0.16348669f, -0.04239932f, 0.01093722f, -0.09899558f, 
    -0.10232750f, 0.01645384f, 0.05403155f, -0.02735841f, -0.36538780f, 0.10981026f, -0.02022310f, 0.27256343f, 
    -0.05279525f, 0.13759686f, -0.08547597f, 0.03424438f, -0.07478247f, 0.10372101f, 0.03273804f, 0.05462129f, 
    0.00034828f, 0.06143913f, -0.06316191f, -0.02090079f, 0.00334333f, 0.03079014f, -0.10322402f, 0.02360471f, 
    0.01913426f, -0.01056364f, 0.07176247f, 0.01654412f, -0.03821880f, 0.07322390f, 0.15905161f, 0.53218019f, 
    -0.04717957f, -0.02734802f, 0.14102429f, 0.01307179f, 0.01029778f, -0.01969113f, 0.01070155f, 0.04600975f, 
    -0.02834976f, 0.02479674f, -0.05316220f, 0.08304042f, 0.13061520f, 0.04499079f, 0.00734719f, -0.02736995f, 
    -0.08616194f, 0.00085249f, 0.08199777f, 0.04142504f, -0.26183778f, -0.00432667f, -0.00658804f, 0.27068508f, 
    -0.06461175f, 0.07107881f, 0.05130168f, 0.06596554f, 0.08308929f, -0.03671227f, 0.02367030f, 0.03839346f, 
    -0.22439383f, 0.38139382f, -0.43410438f, 0.33609879f, -0.02777538f, -0.01042773f, -0.07426140f, -0.13206121f, 
    -0.02743554f, 0.11122543f, -0.00867039f, 0.01016708f, 0.54142010f, -0.17551738f, -0.09883589f, -0.19049171f, 
    -0.10127946f, -0.00192919f, -0.16894227f, 0.00071294f, 0.03148174f, 0.21224442f, -0.02219138f, -0.05691336f, 
    -0.46803728f, 0.03451126f, 0.12570354f, 0.23483630f, 0.05359428f, -0.00676344f, 0.09230126f, -0.12520194f, 
    -0.07200202f, -0.06652448f, 0.06256374f, -0.07801511f, -0.15170789f, 0.02294338f, 0.02233703f, 0.25437969f, 
    -0.02598055f, -0.10194968f, 0.02556361f, -0.03346204f, -0.00350770f, 0.06240567f, -0.09869368f, 0.08653380f, 
    -0.30829072f, -0.08936501f, 0.34049830f, -0.04513028f, -0.09545460f, -0.21461937f, -0.06685391f, -0.00884857f, 
    -0.04264461f, -0.00307123f, 0.02359756f, -0.06491334f, 0.26939335f, 0.03517137f, -0.08265842f, 0.18915021f, 
    0.05202753f, 0.02134734f, -0.04499242f, -0.23971912f, 0.08643238f, 0.03126207f, -0.00580562f, -0.00429833f, 
    -0.14081252f, 0.48515505f, -0.44203544f, -0.33008796f, 0.05373443f, 0.09254399f, -0.00967072f, 0.07403336f, 
    -0.12982038f, -0.20104040f, 0.10685345f, 0.05810802f, -0.16432458f, -0.07883330f, -0.29853237f, -0.29241207f, 
    0.13833642f, 0.10328818f, -0.01415284f, 0.01671509f, -0.09063147f, -0.07025227f, -0.22505236f, 0.02093443f, 
    0.00642218f, -0.21850698f, 0.03638126f, -0.10758214f, -0.09425279f, -0.10532143f, -0.00836879f, -0.07398389f, 
    -0.07477368f, 0.10833981f, -0.16676079f, -0.00357279f, -0.28433427f, -0.21003175f, -0.09892314f, -0.14821790f, 
    -0.03485686f, -0.15919323f, -0.07788323f, -0.15019739f, -0.01363904f, 0.00779836f, 0.16662230f, -0.10697725f, 
    -0.23316100f, -0.13194336f, 0.25068748f, 0.02904009f, -0.21244912f, 0.03876707f, 0.11307858f, 0.02449265f, 
    0.02590647f, 0.13933177f, 0.11956462f, -0.10998376f, -0.33571467f, 0.15647858f, -0.30509388f, -0.48082283f, 
    0.03934911f, -0.03511769f, -0.05045487f, 0.03760846f, -0.07166678f, 0.03856206f, -0.09078953f, 0.01544744f, 
    -0.20767398f, -0.16971645f, -0.16794857f, 0.12443557f, 0.03480418f, 0.16528599f, 0.12332085f, 0.00656944f, 
    -0.01355232f, -0.10041271f, 0.11163011f, -0.05136688f, 0.04639573f, -0.20594235f, -0.25365126f, 0.22524212f, 
    -0.07041419f, -0.03810125f, -0.07617114f, 0.09027010f, 0.06904760f, -0.06928357f, -0.09701338f, 0.04328753f, 
    -0.15328439f, -0.01835757f, -0.06450238f, -0.00724939f, -0.14428791f, 0.03487333f, -0.03627038f, -0.23643236f, 
    -0.04559002f, 0.07525859f, -0.01357679f, -0.17941362f, 0.01271248f, 0.09467690f, -0.08764796f, 0.22160502f, 
    0.07824399f, 0.08300298f, -0.01731879f, 0.11186132f, 0.09984361f, -0.08269524f, 0.15664175f, 0.04029840f, 
    -0.08893254f, -0.15294555f, 0.04016670f, 0.11708445f, 0.01025415f, 0.08957797f, -0.14835072f, -0.01842725f, 
    -0.02712719f, 0.05750783f, 0.01646518f, -0.05110784f, -0.22034852f, 0.48739779f, -0.28717077f, 0.12401117f, 
    -0.05870928f, 0.02337343f, 0.02575042f, 0.05581044f, 0.03889885f, -0.05278264f, 0.10737863f, 0.09313832f, 
    0.10821889f, -0.02049735f, -0.25133690f, -0.06054666f, 0.14337462f, 0.16139901f, 0.10759911f, -0.30511418f, 
    -0.08365020f, -0.09396861f, 0.21912420f, 0.01217448f, -0.08369937f, -0.02503170f, -0.07745706f, 0.02688402f, 
    0.02206779f, 0.11752900f, -0.02016570f, -0.01440107f, -0.07185499f, -0.03739285f, -0.04400240f, 0.10445138f, 
    -0.13434349f, -0.04125446f, 0.01616763f, 0.10009114f, 0.00427387f, 0.04504235f, 0.06005175f, -0.00249629f, 
    -0.01740581f, -0.07369133f, -0.04232700f, -0.01074355f, 0.11853610f, -0.03226858f, 0.09135618f, -0.09203120f, 
    -0.12322925f, 0.06520325f, 0.06980226f, -0.08035620f, -0.07372763f, -0.02504619f, 0.06018132f, -0.01609038f, 
    0.13953805f, -0.10081779f, 0.07169981f, -0.05814209f, 0.16212015f, 0.08487538f, -0.03775623f, 0.04368451f, 
    0.03373692f, 0.05222899f, -0.06973784f, 0.08131026f, 0.03458567f, 0.08513124f, -0.09133882f, 0.13950457f, 
    0.04431706f, -0.02679503f, 0.07821635f, 0.02601534f, -0.04566049f, 0.07739983f, -0.15202221f, -0.05374510f, 
    -0.34610251f, 0.06202426f, 0.06219798f, -0.02607754f, -0.11973089f, -0.05352379f, -0.08505770f, 0.06729644f, 
    -0.09282829f, -0.03841849f, -0.20437676f, 0.00007359f, 0.00812595f, 0.08366761f, -0.31105641f, 0.13772370f, 
    0.01525409f, 0.02331393f, -0.01175768f, 0.04069408f, 0.00852463f, 0.08665530f, 0.02438551f, 0.09361601f, 
    -0.25782025f, -0.32468611f, -0.08749799f, -0.00376113f, -0.13567166f, 0.08850034f, -0.10459051f, 0.12072235f, 
    -0.02068189f, -0.11548549f, -0.06456201f, 0.09346648f, 0.01037934f, 0.08593275f, -0.06875528f, 0.04305335f, 
    0.03707164f, -0.10936925f, 0.13796538f, -0.12193660f, 0.01706464f, 0.14905128f, -0.07833129f, 0.10525453f, 
    0.05843379f, -0.15112495f, -0.01052794f, 0.18334681f, 0.09045485f, 0.01309478f, 0.05105728f, 0.22775249f, 
    -0.07523369f, 0.02684379f, -0.10064766f, -0.11133138f, 0.06688798f, 0.72931015f, -0.23890451f, 0.16929634f, 
    0.23233885f, -0.14760754f, 0.23311312f, -0.01306027f, -0.12179977f, -0.06965858f, 0.04745683f, -0.12631817f, 
    0.12809688f, -0.43284634f, 0.02330825f, -0.02465455f, -0.09549610f, -0.15892124f, -0.22393276f, -0.20260209f, 
    0.01970456f, 0.14635535f, -0.15851299f, -0.06620508f, -0.04080916f, -0.13787271f, -0.02253478f, -0.25071070f, 
    -0.13039076f, -0.07110064f, -0.11995176f, -0.00406756f, 0.02658788f, 0.08185578f, -0.00390242f, -0.13281910f, 
    -0.08711860f, -0.47297713f, 0.14761175f, -0.23531832f, -0.16058911f, -0.18341450f, -0.05397601f, 0.16346961f, 
    0.05979673f, 0.05540651f, -0.12817094f, -0.05283033f, -0.04590983f, -0.14903094f, -0.03888987f, 0.11577646f, 
    -0.02167982f, -0.04214820f, -0.05187681f, -0.00229476f, -0.11238476f, 0.04273202f, -0.00425544f, -0.07218955f, 
    -0.12674512f, 0.30594006f, -0.24475901f, -0.55934602f, 0.15509050f, 0.05819608f, 0.02773266f, -0.06656305f, 
    -0.09495912f, -0.03453719f, -0.05656638f, -0.10074095f, 0.10743987f, 0.08027378f, 0.12102408f, 0.11004456f, 
    -0.12159538f, 0.04676326f, -0.09415341f, -0.08564741f, 0.18398680f, 0.09605860f, 0.10406569f, -0.02913627f, 
    0.16432023f, 0.12109642f, -0.12466076f, 0.15310089f, 0.01541497f, 0.04360878f, -0.02107628f, 0.04580972f, 
    -0.06401024f, 0.02908471f, 0.02704466f, -0.05867504f, 0.73364961f, -0.27404082f, 0.03301573f, 0.18404466f, 
    0.10523580f, 0.00304889f, 0.10061858f, 0.06648880f, -0.00813626f, -0.00865498f, 0.11653300f, 0.13972846f, 
    0.01402218f, -0.06052142f, 0.01007428f, 0.10658409f, 0.04671541f, -0.02282113f, 0.03721550f, 0.00484598f, 
    -0.10882903f, -0.03206081f, -0.09578583f, 0.05460088f, 0.06921624f, 0.01575184f, -0.13369162f, 0.04582038f, 
    0.08782367f, -0.05899923f, 0.03319232f, -0.00176931f, 0.09197953f, 0.10336444f, 0.00586206f, 0.06812681f, 
    0.47616288f, -0.07181242f, 0.03298530f, 0.11651464f, 0.04081761f, -0.07581036f, -0.02991444f, -0.00461836f, 
    -0.10295485f, -0.08851416f, 0.05430022f, 0.12691666f, -0.34170523f, -0.07932665f, -0.12223996f, 0.24037246f, 
    0.00881976f, -0.11332641f, 0.18470801f, -0.17627883f, -0.01012581f, -0.02776769f, -0.15488072f, -0.00135300f, 
    -0.49145928f, 0.10591768f, -0.01151023f, 0.12621360f, -0.01263824f, -0.06075741f, -0.22774561f, 0.02204558f, 
    -0.10698472f, -0.03198629f, 0.00094560f, 0.08532733f, 0.22933504f, -0.01302779f, 0.09673834f, 0.02978457f, 
    0.09075559f, -0.04266562f, -0.08853104f, -0.07965922f, -0.03976022f, 0.09182157f, 0.04937422f, -0.15656969f, 
    0.24976714f, 0.02302817f, -0.08073901f, -0.18148497f, -0.00039900f, -0.20035838f, -0.16031057f, -0.02326709f, 
    -0.02892545f, -0.05376669f, -0.04580306f, -0.04523790f, 0.01495640f, -0.16449226f, -0.07290812f, 0.09026603f, 
    0.05821954f, -0.01717568f, 0.04956641f, 0.05388185f, 0.06667165f, -0.01165529f, 0.18518735f, 0.00756445f, 
    -0.12137856f, 0.01043206f, -0.06727466f, -0.16267048f, 0.03180785f, 0.00204770f, -0.01215358f, -0.02560036f, 
    -0.02589690f, -0.06435517f, -0.00529720f, -0.05004431f, 0.18961306f, -0.27058357f, -0.20063250f, 0.06233140f, 
    -0.13947313f, -0.03204038f, 0.05606709f, -0.17780671f, -0.09369633f, 0.04524663f, -0.01909108f, -0.07437062f, 
    -0.03392559f, -0.09013101f, -0.02318713f, -0.02217932f, 0.03255341f, 0.00071634f, 0.06547349f, -0.02039078f, 
    0.06944636f, -0.00934774f, 0.20526966f, 0.04306670f, 0.26420626f, -0.00743988f, -0.14550263f, 0.11570485f, 
    0.14429712f, 0.07262282f, 0.00695631f, -0.00216138f, 0.04016410f, -0.11199064f, 0.14443430f, -0.09673832f, 
    -0.05616152f, 0.01932406f, 0.18252593f, -0.04899396f, -0.00999969f, -0.06888822f, -0.23785403f, -0.08995286f, 
    -0.10498976f, -0.13884652f, 0.05109645f, -0.20441148f, 0.07212647f, 0.03530164f, -0.05047668f, 0.06094478f, 
    -0.03563428f, -0.05676155f, 0.03050005f, -0.00277314f, -0.11307637f, -0.17203470f, -0.25695020f, -0.14562675f, 
    -0.05442177f, -0.37981713f, -0.09916947f, 0.13484584f, -0.14202458f, -0.07814547f, 0.09788334f, -0.01421421f, 
    -0.06677210f, -0.12707731f, -0.08335315f, -0.03372041f, -0.02729370f, 0.11011425f, 0.08325305f, 0.15366022f, 
    -0.04907029f, 0.03233207f, -0.06376255f, 0.01528386f, -0.18173364f, -0.03420857f, -0.00417717f, 0.06681188f, 
    0.05253118f, 0.07290034f, 0.08955267f, 0.16706181f, -0.04724164f, -0.10799292f, 0.01625472f, -0.04786773f, 
    0.10871975f, -0.02735057f, 0.08658625f, 0.04326557f, 0.21437815f, 0.14942221f, -0.13625427f, 0.27989325f, 
    -0.03599200f, 0.02594470f, -0.06381753f, -0.01558774f, 0.07390791f, -0.10564330f, 0.08199106f, -0.00901644f, 
    0.17944977f, 0.26358387f, 0.14549588f, 0.19374838f, -0.00266227f, -0.04137852f, -0.00256416f, -0.02015683f, 
    -0.03752290f, -0.24539603f, -0.11038145f, 0.05508623f, -0.03127991f, 0.03452220f, -0.03347514f, 0.10518703f, 
    -0.19498459f, -0.05373426f, 0.01798116f, -0.07534613f, 0.05577814f, -0.06072984f, 0.07286782f, -0.03433712f, 
    0.05867671f, -0.23603304f, -0.16338302f, 0.11035562f, -0.07621215f, 0.01102779f, 0.06916575f, 0.02975013f, 
    0.06776456f, -0.21612200f, -0.04322505f, -0.01932453f, -0.06750490f, -0.14046039f, -0.06618626f, -0.00746159f, 
    0.03686890f, -0.00235384f, 0.02651244f, 0.04983320f, 0.07113310f, -0.06945289f, 0.04103744f, 0.05067739f, 
    0.05043181f, -0.00289822f, 0.14956513f, 0.10830849f, -0.03335002f, -0.11862241f, -0.07259046f, -0.03307776f, 
    0.08923250f, 0.12497293f, 0.11773088f, 0.26047015f, -0.05685707f, 0.20387010f, -0.19548376f, 0.05186794f, 
    0.15614629f, 0.15441564f, -0.10499756f, 0.07345331f, 0.03971380f, 0.04139368f, -0.07936942f, -0.03476290f, 
    0.01311323f, -0.01000621f, 0.07313602f, 0.08430161f, -0.00998287f, -0.04873781f, 0.11509546f, -0.03598609f, 
    0.01587597f, 0.13912763f, -0.11699301f, 0.17608890f, -0.04319352f, 0.05145311f, 0.09622772f, 0.08471490f, 
    0.07381464f, -0.03573846f, 0.04598136f, -0.10597618f, 0.11886419f, 0.00781255f, 0.01151296f, 0.09497219f, 
    -0.07299619f, -0.18222928f, 0.30991524f, -0.05113446f, 0.10192260f, -0.05295435f, -0.07252763f, -0.09905568f, 
    0.01595930f, -0.09076044f, 0.01026773f, -0.06860537f, 0.10519771f, 0.09637138f, -0.16969599f, -0.34133238f, 
    0.12123217f, -0.09285911f, 0.00116405f, 0.09783601f, 0.03726356f, -0.09624766f, -0.12773152f, -0.23641475f, 
    0.03184016f, -0.08933246f, 0.03488648f, 0.02515106f, -0.04824823f, -0.05849857f, 0.01573446f, -0.04227381f, 
    -0.11043544f, -0.00380427f, -0.09196557f, 0.15445615f, -0.17202884f, -0.04365450f, 0.09358426f, -0.00044632f, 
    -0.02858380f, -0.07739298f, -0.06248649f, -0.14450048f, -0.01487471f, -0.04524687f, 0.01793131f, -0.06208836f, 
    0.11364091f, 0.00415436f, -0.30522454f, 0.12791923f, 0.00144995f, 0.08406272f, 0.04920113f, -0.02304173f, 
    0.06083145f, 0.04820201f, -0.00893289f, -0.05260738f, -0.07968838f, 0.15158416f, 0.01437103f, 0.00080944f, 
    0.00390247f, -0.04778860f, 0.11404102f, -0.09559423f, 0.03056119f, -0.31781095f, -0.06694462f, -0.06266068f, 
    -0.14922862f, -0.35023373f, 0.42952228f, -0.02404741f, -0.23699507f, 0.03000543f, -0.29049072f, -0.12776747f, 
    -0.03606472f, 0.10032670f, -0.08864265f, -0.00348388f, 0.10555220f, 0.03585681f, 0.06694212f, -0.01997211f, 
    0.02815403f, 0.04433244f, 0.04936772f, 0.05944809f, 0.08572019f, 0.07778537f, 0.01814644f, -0.07341959f, 
    -0.13327856f, -0.31116650f, -0.07455616f, -0.16876106f, -0.11734540f, -0.00610326f, 0.05983872f, -0.09349319f, 
    0.06257780f, -0.04000099f, 0.09374131f, -0.00374609f, -0.07572800f, -0.20842324f, 0.01208954f, -0.19831905f, 
    -0.03929603f, -0.08002523f, -0.03644305f, 0.14711386f, -0.15418218f, -0.01924982f, -0.12888029f, -0.12511860f, 
    0.17958368f, 0.12742008f, -0.00057280f, 0.07874647f, 0.00591963f, -0.10030850f, -0.05032662f, -0.06388978f, 
    0.00251695f, 0.08076383f, -0.15189418f, 0.09108692f, 0.02021559f, 0.08991373f, -0.12129473f, 0.08408657f, 
    0.10287977f, -0.01328251f, 0.00688162f, -0.19420883f, -0.15757322f, 0.01544103f, -0.08627710f, 0.13027704f, 
    0.17005798f, 0.22672902f, 0.26036534f, 0.19856299f, -0.07133929f, -0.15090294f, -0.02359886f, 0.11222953f, 
    0.01364933f, 0.09646134f, -0.07872833f, 0.08470803f, -0.02501643f, 0.16933258f, 0.25189593f, -0.04018183f, 
    -0.07826027f, 0.11395141f, -0.09098659f, 0.24887407f, 0.03387277f, 0.01994343f, 0.05136235f, 0.04061038f, 
    -0.05107332f, -0.16668811f, -0.04569472f, -0.03013605f, -0.10966279f, -0.04513904f, -0.20934738f, 0.12728240f, 
    -0.01753522f, -0.00869776f, -0.18180059f, 0.04013759f, -0.44936791f, -0.06360486f, 0.08623120f, -0.01407358f, 
    -0.10050994f, -0.07006419f, -0.13445739f, -0.06701289f, -0.13165247f, -0.16374461f, -0.01651628f, 0.06469954f, 
    0.08370712f, 0.06044943f, 0.06206404f, 0.03796014f, 0.05855966f, -0.21533357f, -0.14301401f, 0.04362056f, 
    0.02001902f, 0.01842759f, 0.01780090f, -0.07593783f, -0.13472244f, -0.25874758f, 0.13785082f, -0.04429409f, 
    0.11253910f, 0.03558145f, -0.00777244f, 0.02518363f, -0.01816073f, 0.00546674f, -0.05703160f, 0.00177007f, 
    0.02130657f, -0.01561974f, 0.01727695f, -0.05971465f, 0.01175908f, -0.10731765f, -0.03215421f, -0.01693463f, 
    -0.07600992f, -0.01296936f, -0.25190026f, -0.11523397f, 0.18054421f, -0.05960835f, 0.04441093f, 0.12636323f, 
    0.08255446f, -0.16809686f, -0.11131677f, -0.01761505f, -0.00130641f, 0.08178604f, 0.09592079f, 0.02134936f, 
    0.00427113f, 0.01889941f, 0.11090929f, 0.14686081f, -0.06784128f, 0.04485433f, 0.10851135f, -0.11128459f, 
    0.05735291f, 0.10492143f, -0.00289115f, -0.03523518f, 0.13509037f, -0.06125418f, -0.06135802f, 0.21497066f, 
    0.08186689f, -0.05127173f, 0.04043791f, -0.22815788f, 0.02310814f, -0.05782893f, 0.02214885f, 0.09954378f, 
    0.10535638f, 0.07897100f, -0.01241626f, 0.04378260f, 0.02898117f, -0.02477827f, -0.03504476f, 0.04184733f, 
    0.12572725f, -0.11192660f, -0.02479125f, 0.02622577f, 0.03788316f, 0.16165659f, 0.01378842f, 0.13496996f, 
    0.11343668f, 0.03365855f, 0.00275745f, 0.05216610f, -0.01172840f, 0.01632218f, -0.09600634f, -0.13313143f, 
    -0.02885433f, 0.04423570f, -0.20554824f, -0.24209346f, 0.10696253f, -0.00365569f, 0.05735625f, -0.01011468f, 
    -0.02948356f, 0.04484539f, 0.01036197f, -0.11912737f, 0.13653600f, 0.01056627f, 0.28340581f, 0.01123949f, 
    0.05720666f, 0.00380555f, -0.17168106f, -0.08730001f, -0.20174839f, 0.20741123f, 0.10495400f, -0.00935488f, 
    0.03853874f, 0.06148645f, 0.04756027f, -0.00550081f, 0.14520536f, 0.05825876f, 0.00941190f, 0.01509376f, 
    0.12722780f, 0.01531979f, -0.08251386f, 0.01227348f, -0.02262406f, -0.01227014f, 0.00788561f, -0.01779275f, 
    0.02227117f, -0.03412997f, -0.07866329f, -0.01284349f, -0.02823613f, -0.06562610f, -0.05499361f, -0.19763120f, 
    0.12074211f, 0.21419950f, 0.21980900f, 0.25240949f, -0.12048182f, -0.04674512f, -0.01908777f, 0.11670694f, 
    0.07839237f, -0.00120563f, 0.02199887f, 0.02705755f, -0.14667387f, -0.27012891f, -0.14486535f, -0.10596994f, 
    0.01131090f, 0.12688634f, -0.02634427f, 0.00403094f, -0.02633575f, 0.02824239f, 0.12335143f, -0.04139681f, 
    -0.05817479f, -0.02270618f, 0.02453618f, -0.00562097f, -0.06916916f, -0.04518079f, 0.16477560f, 0.03976322f, 
    0.02155851f, -0.18530415f, 0.04780412f, -0.07824330f, -0.01455612f, -0.08512636f, -0.00914236f, -0.03035588f, 
    -0.08424839f, 0.04702401f, 0.07045759f, 0.06484636f, 0.02972789f, -0.08903751f, 0.10094187f, 0.00403535f, 
    -0.04123144f, 0.05587500f, -0.00908109f, -0.11208122f, 0.02606944f, 0.00015157f, 0.04907233f, 0.02149003f, 
    0.02564454f, -0.02976774f, 0.01564199f, -0.01947927f, -0.01026753f, 0.05835564f, 0.18506262f, 0.05002192f, 
    -0.07702204f, 0.00602306f, -0.03769791f, -0.03966537f, 0.06357189f, -0.01586693f, -0.09186070f, 0.01064061f, 
    -0.09050892f, -0.37498987f, 0.04778327f, 0.05113048f, -0.27862468f, -0.03880953f, -0.02028944f, 0.06423433f, 
    -0.03220678f, 0.19759703f, -0.06104476f, 0.00339874f, -0.00948509f, 0.12185715f, 0.17128000f, 0.26646268f, 
    -0.16555072f, 0.02394045f, -0.09927114f, 0.25686607f, 0.01024170f, -0.04846182f, -0.03848509f, -0.09795347f, 
    -0.29217485f, -0.11636828f, 0.10468101f, -0.03470835f, -0.07924742f, 0.00426953f, -0.07713573f, -0.12066656f, 
    -0.02017402f, 0.05725426f, -0.04826835f, -0.10879374f, -0.38719150f, 0.02962769f, -0.11547732f, -0.02969909f, 
    -0.11061381f, -0.09655184f, 0.08879393f, -0.04840709f, 0.00727982f, -0.01747862f, 0.02013640f, 0.20849444f, 
    -0.07168879f, -0.02110292f, -0.07038056f, 0.08922794f, -0.03653825f, 0.01886907f, -0.03523676f, -0.18608762f, 
    0.02263371f, -0.00777485f, 0.07268223f, 0.05689535f, -0.08605747f, -0.03936892f, 0.09697565f, -0.01801103f, 
    -0.10458141f, 0.04717403f, -0.10738743f, 0.08864070f, 0.02032720f, -0.03010693f, -0.00937222f, 0.13254258f, 
    -0.02913271f, -0.15901342f, -0.01509870f, 0.03478263f, -0.06930512f, -0.05093232f, 0.00447477f, -0.06101535f, 
    0.10358368f, -0.13712485f, 0.05275893f, 0.10887919f, 0.07081168f, 0.08280297f, 0.31252477f, 0.00943977f, 
    0.01708712f, 0.02528341f, -0.14532900f, 0.00619118f, -0.03521924f, -0.04700299f, 0.11458963f, 0.09908420f, 
    0.10978977f, -0.13240156f, -0.09526050f, -0.09115340f, 0.00781834f, 0.03162746f, 0.04032214f, 0.08891357f, 
    0.12948616f, 0.01925202f, -0.02063055f, -0.03786888f, 0.12328421f, 0.02076519f, -0.01702936f, -0.05397397f, 
    0.08592975f, 0.05819300f, 0.02733220f, -0.03705108f, -0.03693645f, -0.19018494f, -0.09399224f, -0.08696955f, 
    -0.05977841f, -0.04946137f, -0.02731724f, 0.24129283f, -0.03962222f, -0.06534360f, -0.14575318f, -0.07183429f, 
    -0.04797950f, -0.01567157f, -0.16492121f, -0.07625411f, 0.08819130f, 0.00848626f, 0.25009608f, 0.05604860f, 
    -0.10100356f, -0.11949152f, -0.08790796f, -0.08616303f, 0.14484584f, 0.06221203f, -0.02673805f, -0.01604360f, 
    -0.21271388f, -0.08061930f, -0.04463972f, 0.36037907f, -0.09606059f, -0.17423578f, 0.04743796f, 0.00771218f, 
    0.02250907f, -0.00740523f, 0.14044698f, -0.02311571f, -0.70009619f, -0.00984063f, -0.08225545f, 0.02530511f, 
    0.01316189f, -0.06280099f, -0.07052048f, 0.12053295f, 0.11062564f, 0.10789371f, -0.05451772f, 0.02505902f, 
    0.11420865f, -0.02925896f, -0.11325855f, 0.01197389f, 0.07915326f, 0.01789148f, 0.00294383f, -0.01239982f, 
    -0.07278793f, -0.03418852f, 0.01986520f, -0.13364853f, -0.26366910f, 0.05982601f, -0.03011961f, -0.07303293f, 
    -0.04442501f, -0.16124254f, -0.00090646f, 0.10491988f, -0.15874277f, -0.32491854f, -0.01338453f, 0.25044006f, 
    0.22185947f, 0.07128561f, -0.04335395f, 0.19832052f, -0.00259699f, -0.00355978f, 0.05509025f, 0.03033915f, 
    0.10570458f, -0.03859456f, 0.00313165f, 0.11798128f, 0.00133517f, -0.27005649f, -0.04087627f, 0.14757831f, 
    -0.01395540f, -0.01282320f, 0.01678104f, -0.06063556f, 0.12507746f, 0.06207398f, 0.26278064f, 0.17095247f, 
    0.26492009f, 0.10837417f, 0.15451954f, 0.16653067f, 0.07505772f, 0.11451795f, -0.12967446f, -0.00958042f, 
    0.10440455f, 0.05107528f, 0.00650453f, 0.06879257f, 0.10374420f, -0.17705320f, 0.14511354f, 0.06792364f, 
    0.07551285f, -0.04625710f, -0.06663630f, 0.04714137f, 0.11767443f, 0.09360918f, -0.14145608f, 0.05180880f, 
    -0.35716611f, 0.01375628f, 0.13427597f, 0.00388188f, 0.04732843f, -0.00198693f, 0.00992220f, -0.01900810f, 
    0.05084000f, 0.05092633f, 0.07674561f, 0.05572003f, -0.12245832f, -0.03977272f, -0.08571733f, -0.00990252f, 
    0.13902432f, -0.03263760f, -0.07955571f, -0.01474219f, -0.03521773f, 0.02871471f, 0.10136192f, -0.13390991f, 
    -0.31662968f, -0.34817266f, -0.35666549f, -0.31470183f, -0.06440184f, -0.01893049f, -0.05248675f, -0.12782456f, 
    0.12176906f, -0.00089669f, 0.08796313f, -0.03131796f, -0.32405555f, -0.12258884f, 0.06430656f, -0.22947554f, 
    0.12795022f, -0.05771964f, -0.07622566f, 0.05892159f, 0.00709493f, -0.08437246f, -0.03626898f, 0.15133499f, 
    0.04319698f, -0.09751629f, -0.07300428f, 0.12259091f, 0.04071201f, -0.10821369f, -0.15270945f, 0.14525619f, 
    -0.17062859f, -0.00877155f, 0.31045061f, -0.05205777f, 0.40743884f, -0.17463610f, -0.12835881f, -0.05979425f, 
    -0.04106450f, 0.02520702f, -0.01900348f, 0.05085521f, 0.06891670f, -0.27753296f, -0.15708514f, -0.14981371f, 
    -0.25787029f, 0.05088240f, 0.15509346f, -0.12789939f, 0.03794443f, 0.02106314f, 0.04399469f, -0.03040789f, 
    -0.02114247f, -0.29603878f, -0.14239916f, -0.14969890f, 0.06043386f, 0.11701582f, -0.38725346f, -0.38488948f, 
    0.05389210f, 0.05272095f, 0.02632583f, 0.17656542f, 0.01458915f, 0.06487920f, -0.01522681f, -0.00440440f, 
    -0.25188476f, -0.05073631f, 0.09387457f, -0.02738973f, -0.07592967f, -0.09511704f, -0.11282215f, 0.07139117f, 
    -0.07136258f, -0.03034955f, -0.07579898f, -0.29983661f, 0.15191667f, -0.16636182f, -0.10332242f, -0.17104946f, 
    -0.02309239f, -0.00184845f, 0.02704446f, 0.02610274f, -0.21543685f, -0.17782772f, 0.12777996f, -0.42785248f, 
    0.17419668f, 0.08800837f, -0.01925145f, -0.07813989f, 0.03250000f, 0.00323025f, 0.08546638f, 0.13626216f, 
    0.06269435f, 0.08166727f, -0.08877972f, -0.07129043f, -0.32472235f, -0.09526251f, 0.00752976f, 0.35486174f, 
    0.02017141f, -0.13545351f, 0.05760530f, -0.05009567f, 0.04754080f, -0.00010876f, 0.04741325f, 0.21015750f, 
    -0.24266212f, -0.31516981f, -0.16157466f, -0.18358354f, 0.09755111f, -0.00985101f, -0.05753042f, 0.25108686f, 
    0.07253585f, -0.02056378f, -0.03540062f, -0.09087784f, 0.16867997f, 0.06108673f, -0.10634647f, 0.03291937f, 
    0.06222934f, 0.07330042f, -0.08417714f, 0.03815220f, 0.04632168f, 0.04997429f, 0.16748962f, 0.01022725f, 
    0.11427990f, 0.04159717f, -0.54991657f, 0.32355538f, 0.06998380f, 0.00411104f, -0.05451542f, 0.03217701f, 
    0.04588142f, 0.06446268f, -0.07017583f, -0.00082528f, -0.21716167f, 0.03404079f, 0.09024984f, -0.04380223f, 
    -0.12763287f, -0.24555705f, 0.07782856f, 0.06392152f, 0.01130757f, 0.15763578f, 0.04154112f, 0.01150029f, 
    -0.10403048f, 0.08369776f, -0.06807828f, 0.10529110f, 0.04455438f, -0.12472020f, 0.07369719f, -0.08313812f, 
    0.00866985f, 0.14645326f, -0.04691428f, -0.03114164f, -0.03358962f, -0.10285208f, -0.09565153f, -0.07898132f, 
    0.11166898f, -0.05242981f, 0.02250956f, -0.06481320f, 0.12170476f, -0.09163076f, 0.05150342f, 0.09511570f, 
    0.48234063f, -0.37753981f, 0.08474858f, 0.16795532f, 0.03607322f, 0.12415290f, -0.13758908f, 0.07194385f, 
    0.09605767f, 0.02074626f, 0.19457337f, -0.16996415f, 0.13449790f, -0.36166617f, 0.18298611f, 0.27394140f, 
    0.11517918f, -0.01813071f, 0.05511926f, -0.03075131f, 0.11137882f, 0.02332126f, 0.10190060f, 0.27910537f, 
    0.03592185f, -0.05572902f, -0.13187972f, 0.00988774f, -0.03207776f, 0.01731682f, 0.03068365f, 0.00690586f, 
    -0.02936744f, -0.05565055f, -0.02440659f, -0.19761971f, 0.09477673f, -0.40509999f, 0.34221068f, 0.04321670f, 
    -0.19799042f, 0.12710473f, -0.05736148f, 0.04936290f, 0.18727261f, -0.04116387f, 0.08085554f, -0.00650083f, 
    0.03308929f, 0.19297363f, 0.06187355f, -0.01411572f, 0.16544770f, 0.14559595f, -0.02157859f, -0.12752627f, 
    0.04906749f, 0.06884978f, 0.01862736f, 0.03778838f, -0.17060736f, 0.27344230f, -0.07457757f, -0.21027964f, 
    0.09287801f, -0.11769771f, -0.08200928f, -0.18746312f, -0.04438569f, 0.05610448f, -0.08478047f, 0.01595491f, 
    0.12362696f, -0.00045499f, -0.20256200f, 0.36195925f, -0.01366734f, 0.04503563f, -0.02888186f, 0.00535563f, 
    -0.11129151f, 0.13047791f, -0.02933772f, 0.13070717f, 0.11633845f, -0.26057845f, -0.41508585f, -0.20499730f, 
    0.07994138f, 0.04255427f, -0.05926751f, 0.05046008f, 0.09640919f, 0.16104963f, -0.03344248f, -0.12199220f, 
    0.06586557f, 0.13793591f, -0.11504467f, -0.11432249f, 0.08963562f, 0.14617664f, 0.29800805f, -0.02120432f, 
    0.09843921f, -0.10305644f, -0.04475917f, 0.12091499f, -0.01853447f, -0.20548923f, 0.05781436f, -0.04497657f, 
    -0.04963241f, -0.01523430f, -0.03412138f, 0.07415248f, -0.14868988f, 0.03478577f, -0.07899145f, -0.07475945f, 
    0.01698072f, 0.38895735f, -0.26026064f, -0.03125214f, -0.04463343f, 0.02567943f, -0.02231917f, 0.02977509f, 
    0.10700260f, -0.10383736f, -0.13838723f, -0.13632263f, 0.11692628f, 0.31006804f, 0.22952086f, -0.28046605f, 
    -0.10857989f, -0.05634375f, -0.12562056f, -0.14820126f, 0.00325884f, -0.09503765f, 0.11705548f, -0.09215222f, 
    0.17741923f, 0.00506886f, -0.07222001f, 0.06395019f, -0.06023937f, -0.01852599f, -0.09294252f, 0.10135761f, 
    0.06318369f, 0.14556307f, -0.05984159f, -0.16666752f, -0.17043525f, 0.21449329f, 0.28812829f, 0.16942573f, 
    0.11353051f, -0.05358930f, 0.11792557f, 0.11104902f, -0.01950193f, 0.05094557f, -0.07652169f, -0.00217799f, 
    -0.03712447f, -0.19932054f, -0.04995729f, 0.01162459f, -0.12185494f, -0.03333331f, 0.00491868f, -0.07764760f, 
    0.12867174f, 0.07417570f, -0.03458276f, -0.02332162f, -0.12020537f, -0.03033324f, -0.16540240f, -0.06628222f, 
    -0.10602950f, -0.02054749f, -0.10273788f, -0.00468547f, 0.02890657f, 0.05127418f, 0.08365586f, -0.00667445f, 
    0.02431366f, -0.11237919f, -0.31610605f, 0.04375951f, 0.03168105f, -0.00432076f, -0.07136232f, 0.01689654f, 
    0.06685589f, -0.16159071f, 0.15817426f, 0.01539065f, 0.08435645f, 0.02593137f, 0.36551338f, -0.07062694f, 
    -0.10594305f, -0.10793536f, 0.07815346f, -0.02011932f, 0.10141131f, -0.37676978f, -0.22664212f, 0.13272482f, 
    -0.00599661f, -0.09821492f, 0.02392398f, 0.00536195f, 0.02170828f, -0.04720999f, 0.02973936f, -0.03360969f, 
    0.09861792f, 0.06330919f, 0.01372375f, -0.04445815f, 0.08876092f, -0.22048856f, 0.03029882f, 0.07922594f, 
    -0.08363633f, -0.00537096f, 0.01844030f, 0.02621029f, 0.08820430f, -0.11636258f, 0.07897271f, 0.12293278f, 
    0.11135181f, 0.11557856f, 0.00838878f, -0.17517425f, 0.20635217f, 0.17772536f, 0.00707425f, -0.21713260f, 
    0.08789203f, 0.03593813f, -0.02910979f, -0.01680610f, -0.46334481f, -0.06897032f, -0.26914454f, -0.12800360f, 
    -0.06141734f, -0.03879889f, 0.02501989f, 0.12623781f, 0.04931295f, -0.16638353f, -0.10143778f, -0.04001252f, 
    0.18461406f, -0.16920972f, -0.10817540f, -0.04526234f, -0.00965438f, -0.01487829f, 0.01292529f, -0.07155386f, 
    0.12968998f, 0.09886588f, 0.05529775f, -0.07107582f, -0.03480691f, -0.15489693f, 0.05103420f, 0.04229690f, 
    0.09119219f, -0.03064460f, -0.03082750f, -0.02546529f, -0.06442361f, -0.04623371f, 0.11203135f, 0.00887129f, 
    -0.18091254f, -0.12340900f, -0.17200908f, 0.02407059f, 0.01434793f, 0.02602228f, -0.06091145f, 0.02244630f, 
    -0.03615514f, 0.01533498f, 0.06370641f, 0.02929139f, 0.15744029f, 0.01912299f, -0.00513536f, 0.06210873f, 
    0.06531993f, 0.07949411f, 0.07929710f, 0.08766259f, 0.01863291f, 0.08657210f, 0.08398296f, 0.05597528f, 
    -0.23912555f, -0.34945413f, 0.11334385f, 0.06527077f, 0.09946945f, -0.15528037f, 0.02202249f, 0.03296974f, 
    -0.06051741f, -0.10904337f, -0.02192057f, -0.10971979f, -0.04313115f, -0.04892048f, -0.04036696f, 0.15070012f, 
    0.25520542f, -0.01334704f, -0.16548415f, 0.00623354f, 0.05894875f, -0.06515196f, 0.06043656f, 0.12365950f, 
    -0.01792169f, 0.17451364f, -0.24726155f, -0.13921042f, 0.12461588f, -0.01622589f, -0.12446292f, 0.02292795f, 
    -0.04229722f, -0.04218699f, 0.03520272f, 0.20811310f, -0.29618904f, -0.09338596f, -0.10142083f, -0.11550198f, 
    -0.10525097f, -0.20259315f, 0.04413046f, 0.18532656f, -0.11472571f, -0.17387611f, -0.09547076f, -0.22685917f, 
    -0.05637750f, 0.03730238f, 0.08417478f, -0.20247105f, 0.01355984f, -0.03291636f, 0.14398731f, 0.00563084f, 
    0.08372496f, 0.06441838f, -0.01384252f, -0.18759441f, -0.09197439f, 0.17255448f, 0.21060562f, -0.05509761f, 
    0.10101065f, -0.15679975f, -0.06372915f, 0.07045624f, 0.00283222f, -0.02682951f, -0.00868391f, -0.04820556f, 
    -0.17629468f, 0.40482482f, -0.08997250f, 0.02114616f, 0.01213133f, -0.03495176f, 0.04798589f, 0.09824381f, 
    0.18988565f, 0.07424960f, -0.06324714f, -0.36264732f, -0.05151905f, 0.03124847f, -0.21719827f, -0.26875833f, 
    0.01958283f, 0.14719725f, -0.16891021f, 0.06354695f, -0.03606021f, -0.10898799f, 0.03757351f, 0.03716566f, 
    0.02201788f, -0.16883169f, -0.34936592f, 0.19622077f, 0.05781267f, -0.02899344f, 0.02513756f, 0.01680635f, 
    0.09973509f, -0.01351077f, 0.02266483f, 0.06780953f, -0.18715173f, 0.21232365f, -0.22405885f, 0.22385514f, 
    0.07073424f, 0.01646428f, -0.26735950f, -0.01570665f, 0.13990165f, 0.08644944f, -0.03818997f, -0.04628527f, 
    0.23336548f, -0.11723318f, 0.15858723f, -0.03892793f, -0.04946503f, 0.30816531f, -0.09391764f, 0.11644717f, 
    0.02601279f, 0.02303282f, 0.00840348f, -0.01054415f, 0.05503350f, 0.02531260f, -0.01337382f, -0.01904207f, 
    0.26259518f, 0.07847914f, 0.35199589f, -0.09173132f, 0.05586160f, -0.02030244f, 0.05273577f, -0.02653501f, 
    0.08372962f, -0.09415563f, -0.04022229f, -0.01288254f, -0.07093098f, 0.02037820f, -0.08060779f, 0.06508379f, 
    -0.03979862f, -0.00542820f, 0.08072138f, -0.12272838f, -0.08372750f, -0.07736790f, 0.23531015f, 0.05634931f, 
    -0.03841006f, 0.04329558f, 0.03193923f, -0.05384762f, -0.11961354f, 0.12019584f, 0.04600413f, -0.04408751f, 
    -0.00747853f, 0.07131941f, -0.05464706f, -0.13374089f, 0.07502790f, -0.01714065f, 0.05300392f, 0.02351530f, 
    -0.04423542f, -0.00174302f, 0.06690377f, -0.14499857f, -0.20672487f, -0.00374728f, 0.13303192f, 0.02019800f, 
    0.12209722f, -0.04645961f, 0.06552251f, 0.08772381f, -0.10386915f, 0.10349388f, 0.07557861f, 0.14650613f, 
    0.59054494f, 0.35444659f, 0.09910085f, 0.20650190f, 0.02672085f, -0.04257794f, 0.06411546f, 0.03183559f, 
    0.11923853f, 0.02244075f, 0.05030352f, -0.06385016f, -0.07437756f, -0.06740078f, 0.06594155f, 0.13584360f, 
    -0.04117623f, -0.00144604f, -0.20108660f, 0.18488696f, 0.00361018f, 0.03540082f, -0.04859795f, -0.02923608f, 
    -0.23903050f, 0.02365345f, -0.08404429f, -0.22697519f, -0.01328933f, 0.07470587f, 0.02417147f, 0.01170101f, 
    -0.00275457f, 0.03010027f, 0.08150169f, 0.04389146f, -0.25033161f, -0.54227871f, -0.71125722f, -0.20898993f, 
    -0.07147254f, -0.05810462f, -0.00735317f, 0.15869892f, -0.02659405f, -0.02376654f, -0.01187544f, 0.00285550f, 
    -0.29494503f, 0.03358886f, 0.26451603f, -0.07861473f, 0.00612638f, 0.07672334f, -0.04139857f, 0.01253570f, 
    0.12924138f, 0.01264953f, 0.13331953f, -0.14192952f, -0.00639268f, -0.12225761f, -0.16678566f, -0.03102903f, 
    -0.03398494f, 0.13677040f, 0.07279766f, 0.06315199f, 0.02877822f, 0.03914522f, 0.01584133f, -0.02092069f, 
    -0.18479492f, 0.39235765f, 0.28648376f, 0.47562122f, 0.03646863f, -0.12300386f, -0.04385238f, -0.02183131f, 
    -0.05226293f, 0.12436911f, 0.06290129f, 0.08908720f, -0.53013831f, -0.49190116f, 0.06166875f, -0.12130069f, 
    0.06933235f, -0.23526956f, 0.08320373f, 0.00923084f, -0.03048902f, 0.02941683f, -0.00636922f, 0.04135403f, 
    0.00676471f, 0.13684134f, -0.16452748f, -0.09987504f, -0.11182629f, 0.05816378f, 0.10623743f, -0.03256761f, 
    -0.02801489f, 0.15247959f, -0.19431971f, 0.05730214f, 0.32802176f, 0.24535061f, -0.11361159f, 0.09633070f, 
    0.01462920f, 0.05117178f, -0.06735712f, 0.10423300f, 0.08895901f, 0.26320189f, 0.09291047f, -0.13627046f, 
    -0.14690319f, -0.08626811f, 0.19750260f, -0.18739608f, -0.03851819f, 0.02165328f, 0.00936648f, 0.03813778f, 
    0.07085752f, 0.10393589f, 0.07980765f, 0.19588272f, -0.49786583f, -0.54457045f, 0.13272911f, 0.32147643f, 
    0.14045988f, -0.06378707f, 0.08558933f, -0.20760050f, 0.01134558f, -0.02852067f, -0.03176251f, 0.07714445f, 
    -0.23940477f, -0.29111266f, -0.18490678f, 0.09420884f, -0.09020099f, 0.11365312f, 0.15660745f, 0.06785948f, 
    -0.00149371f, 0.02849604f, -0.02536529f, 0.09044825f, 0.43197080f, 0.33548942f, -0.17900078f, -0.11073521f, 
    0.00046667f, -0.02334664f, -0.01742855f, 0.04459885f, 0.07394530f, 0.08630162f, -0.00794341f, 0.03760189f, 
    -0.32938528f, -0.56005466f, -0.02088663f, 0.43921039f, 0.14968564f, 0.10618641f, -0.08913997f, -0.27254122f, 
    0.02937824f, -0.03750043f, -0.00301212f, -0.03102152f, -0.02004722f, 0.00600579f, 0.02603104f, 0.09769004f, 
    -0.06735843f, 0.14072372f, -0.07794692f, -0.09481227f, 0.11076306f, -0.03885220f, 0.23859468f, -0.09260362f, 
    0.30396596f, 0.49998289f, -0.14891927f, 0.10573732f, -0.00648388f, -0.02664380f, -0.09804235f, 0.15734358f, 
    0.10821259f, -0.04295584f, 0.10974459f, 0.02947576f, -0.45615071f, -0.20336175f, 0.00071809f, -0.04780867f, 
    -0.08013733f, -0.06050562f, 0.06324810f, -0.07503270f, 0.05568436f, -0.03734160f, 0.04832377f, -0.07426492f, 
    0.34676960f, -0.12108894f, -0.15523435f, -0.32685280f, 0.01370982f, -0.03142477f, 0.22368178f, -0.08359197f, 
    0.01887035f, 0.08962838f, -0.05619836f, -0.01973314f, -0.00604005f, -0.08277229f, -0.10768148f, 0.00659640f, 
    -0.11036060f, -0.07670780f, -0.09013407f, 0.01951643f, 0.02424280f, 0.06225252f, 0.05224301f, -0.15126348f, 
    -0.12989646f, -0.31404212f, 0.03425978f, -0.10954673f, -0.07422249f, -0.20499825f, 0.02591891f, 0.01700777f, 
    -0.09718297f, 0.02731861f, -0.02509429f, 0.08102784f, 0.00947354f, 0.10724013f, -0.06471244f, -0.01933479f, 
    0.03741309f, 0.00182220f, 0.01774395f, 0.05763143f, -0.03545401f, -0.03636001f, -0.00951313f, 0.02642418f, 
    -0.01551106f, 0.01604451f, -0.36285788f, -0.13389404f, -0.13664186f, 0.13187711f, -0.02267291f, -0.20927139f, 
    -0.01516913f, -0.00866670f, -0.04161519f, -0.06453501f, 0.08227503f, 0.08961576f, -0.08800274f, 0.08052646f, 
    0.04508922f, -0.05818701f, 0.03585523f, 0.11611330f, 0.13327557f, -0.05847396f, 0.04488192f, 0.02607307f, 
    0.15194097f, 0.03231670f, -0.17456666f, -0.18369800f, -0.00811879f, 0.10656751f, 0.10147735f, 0.19086443f, 
    -0.01593767f, -0.03984366f, -0.10305227f, -0.02198354f, -0.23863353f, -0.22569261f, 0.15249941f, 0.20156333f, 
    0.01349747f, 0.14407404f, -0.01423726f, 0.01047020f, 0.09241301f, -0.02764431f, 0.06965890f, 0.05283715f, 
    -0.51827985f, -0.61558223f, 0.08319286f, 0.10000203f, -0.25037539f, -0.19837159f, -0.22232935f, -0.25978938f, 
    -0.03197906f, -0.05111340f, -0.04131967f, 0.00066472f, -0.42517281f, -0.27704564f, -0.29784313f, -0.08780939f, 
    0.07229521f, -0.08134437f, -0.22206360f, -0.10708517f, -0.03509272f, -0.00105895f, -0.01741933f, 0.10394600f, 
    0.19044830f, 0.01568314f, -0.07282346f, 0.11573436f, 0.11982697f, -0.03180430f, 0.20073712f, -0.08343857f, 
    0.04184416f, 0.03479269f, -0.03717416f, 0.02291275f, 0.09242091f, 0.24159560f, 0.09959050f, 0.11581040f, 
    -0.03921599f, 0.05608094f, -0.02795870f, 0.15952276f, 0.07723503f, 0.07946678f, 0.03211547f, 0.20640752f, 
    -0.13871445f, -0.12835285f, 0.16940148f, -0.10663408f, 0.04145604f, -0.34068471f, 0.05333223f, -0.20071502f, 
    -0.06174354f, -0.01883294f, -0.00997863f, -0.02191882f, -0.17104758f, -0.06117690f, -0.10803793f, 0.04327257f, 
    0.10501764f, 0.01358214f, -0.00217415f, -0.07450019f, -0.02900684f, -0.07368789f, -0.00784115f, 0.04973141f, 
    -0.29020593f, -0.09846471f, 0.14505386f, -0.00850391f, -0.03403447f, -0.00809046f, 0.02949982f, 0.00639084f, 
    -0.13385201f, 0.05612701f, 0.08239197f, -0.04696625f, -0.44297740f, -0.52286100f, 0.17933798f, 0.31185335f, 
    0.09234942f, 0.16242731f, 0.08322884f, -0.27792892f, 0.07464391f, -0.05477580f, 0.04699193f, 0.09979108f, 
    0.25320953f, 0.02965999f, -0.25092608f, -0.42579567f, 0.01260314f, 0.12916109f, 0.11734477f, 0.06203927f, 
    0.06683578f, 0.05075037f, -0.09908433f, 0.03417347f, -0.43877044f, -0.53315252f, -0.58622122f, -0.42110181f, 
    -0.05152003f, 0.20844430f, 0.08698372f, -0.18086879f, -0.00029233f, 0.03320411f, 0.03382057f, 0.09124290f, 
    -0.11805996f, 0.05121637f, 0.09180593f, 0.08350518f, -0.08444390f, -0.06770797f, -0.11915083f, 0.06360354f, 
    -0.19237429f, 0.03405337f, 0.00933482f, 0.05266280f, 0.16927558f, -0.11259010f, -0.04934416f, -0.02669550f, 
    -0.06253650f, -0.07427704f, 0.07317344f, -0.02813932f, -0.05722063f, 0.02913631f, -0.19829148f, -0.13769627f, 
    0.15906715f, -0.06153281f, -0.01552623f, -0.14601196f, 0.01629377f, -0.01359441f, 0.06794845f, -0.11659005f, 
    0.00984338f, 0.07985885f, -0.05954840f, -0.00292941f, 0.03325181f, -0.38196418f, -0.19268498f, -0.11153704f, 
    -0.04606986f, -0.03889883f, 0.06911278f, 0.10609982f, 0.16155422f, 0.12714344f, 0.11132538f, -0.01963338f, 
    -0.01560596f, -0.03738796f, -0.06360950f, -0.03762880f, 0.00128731f, 0.04326433f, -0.00290747f, 0.00478077f, 
    -0.05059855f, -0.15625997f, -0.23862536f, -0.09628610f, -0.00389363f, 0.21791451f, 0.03260573f, 0.06603627f, 
    -0.01657936f, -0.07035633f, 0.01224569f, 0.20774086f, 0.10840416f, 0.02775239f, 0.08558374f, -0.03385242f, 
    -0.65539354f, -0.52541274f, -0.27003434f, -0.28969905f, -0.10540871f, -0.36977771f, -0.26139104f, -0.34887421f, 
    -0.10071822f, -0.02026928f, -0.05563701f, -0.00478311f, -0.07700270f, 0.14856224f, 0.09429533f, -0.05823381f, 
    0.03378912f, 0.00387276f, 0.06524022f, 0.03998633f, -0.07785267f, 0.07346231f, 0.09165452f, 0.17026392f, 
    -0.03001634f, -0.01754121f, -0.08558472f, -0.17191055f, 0.08633419f, -0.03905563f, -0.17747599f, 0.10307454f, 
    -0.02104942f, 0.00629714f, -0.10422201f, 0.01863189f, 0.00272099f, 0.01294149f, -0.15456486f, -0.02297390f, 
    -0.01472530f, 0.00625681f, 0.02443142f, 0.09320874f, -0.02555985f, -0.09096838f, 0.05787118f, -0.10063334f, 
    0.02406564f, -0.00900475f, -0.16271673f, -0.16166475f, 0.02438346f, -0.01855844f, 0.07920483f, -0.03019680f, 
    -0.05711772f, 0.00988385f, 0.02584874f, -0.16971022f, -0.17212996f, -0.07939883f, -0.30766430f, -0.10479521f, 
    -0.10252054f, 0.09720749f, 0.10285289f, -0.10105589f, 0.05202746f, 0.03134227f, -0.03239137f, 0.07874177f, 
    -0.05002897f, 0.01108775f, 0.12664427f, 0.10312920f, -0.24182449f, -0.08048731f, 0.01067609f, 0.10890666f, 
    0.02424682f, 0.06026759f, 0.09702837f, -0.05123120f, -0.32394749f, -0.28394094f, 0.03367169f, -0.12213191f, 
    0.01002369f, 0.11468021f, 0.11953697f, 0.02923292f, -0.00802224f, -0.02437385f, 0.02645652f, -0.00360676f, 
    -0.34097391f, -0.22747485f, -0.10973771f, -0.22349474f, -0.20227206f, -0.08427916f, -0.01878647f, -0.08740675f, 
    -0.02179809f, 0.00740017f, 0.00057610f, -0.04564176f, -0.06211685f, -0.04981282f, -0.09566487f, 0.21201813f, 
    -0.21757552f, 0.17793866f, 0.12939404f, 0.15337434f, 0.07582343f, 0.03634193f, 0.15369177f, 0.00793102f, 
    -0.48913950f, -0.55825990f, -0.12601465f, -0.11481023f, -0.10415415f, -0.06197640f, -0.01637986f, -0.15323564f, 
    -0.03092903f, -0.04525250f, 0.03050582f, -0.03615395f, -0.21735340f, -0.35402545f, -0.30771646f, -0.00852835f, 
    -0.17671411f, -0.05402908f, 0.08887518f, -0.03987131f, 0.01958982f, 0.04189014f, 0.05865309f, -0.02097376f, 
    -0.10424288f, 0.01189581f, 0.15342344f, -0.42779040f, -0.04649116f, 0.04474276f, 0.05748741f, -0.06393723f, 
    0.02439771f, 0.05656198f, 0.21889649f, 0.10112267f, -0.20458397f, 0.36639488f, -0.15475753f, -0.16134687f, 
    -0.00327962f, 0.06749293f, -0.02301617f, -0.01416759f, 0.08025248f, -0.04284325f, 0.03577883f, -0.00747431f, 
    0.01444168f, -0.01602765f, -0.16613303f, -0.18227054f, 0.01093583f, 0.02703952f, 0.07086512f, -0.00483325f, 
    -0.00904541f, 0.01442280f, -0.01402211f, -0.01975283f, -0.05301636f, -0.06630478f, 0.23522583f, -0.22167961f, 
    0.02044175f, 0.03714438f, -0.06676647f, -0.08356399f, 0.09603387f, 0.05210463f, 0.06596071f, -0.02111249f, 
    -0.15716475f, -0.39684489f, -0.09462222f, 0.03165647f, -0.14000550f, -0.11151228f, -0.12341827f, 0.02355413f, 
    0.06923908f, 0.01301233f, 0.04548958f, -0.06480912f, -0.46632552f, -0.12749836f, 0.06190931f, -0.28590637f, 
    -0.36002344f, -0.06553837f, -0.04972608f, -0.19721091f, -0.00742672f, 0.04325191f, 0.01055290f, -0.02864538f, 
    0.20344934f, 0.03200180f, -0.07077713f, -0.04416774f, 0.01722504f, -0.03572068f, 0.01117248f, 0.00800177f, 
    -0.04533144f, 0.02062815f, -0.22906807f, -0.23609982f, 0.23000164f, 0.10494898f, 0.03545934f, -0.08128934f, 
    -0.03609442f, 0.04755169f, 0.01618377f, 0.08422296f, -0.07482906f, 0.06552198f, -0.08525306f, -0.07814686f, 
    0.08291348f, 0.02419479f, -0.03303836f, -0.06791847f, -0.04404172f, -0.03137852f, 0.02430598f, -0.01370439f, 
    0.04697433f, -0.00327152f, -0.03355399f, -0.07216241f, 0.11877081f, 0.02325329f, 0.10109797f, -0.12427579f, 
    -0.08047260f, 0.06153899f, -0.03530944f, -0.15554042f, -0.00875446f, -0.14333238f, -0.01136311f, 0.02086770f, 
    -0.38541755f, -0.23704730f, -0.40113524f, 0.14143755f, -0.09079425f, -0.08100399f, 0.17798030f, -0.00969299f, 
    -0.05313955f, -0.03509199f, 0.09569123f, -0.07252177f, 0.19012921f, 0.02658527f, -0.00784070f, -0.14294045f, 
    -0.00282064f, -0.00497389f, -0.03700743f, -0.04251061f, -0.00899552f, -0.04659944f, 0.00800390f, -0.18836983f, 
    -0.03621620f, 0.10627764f, -0.05436584f, 0.14304523f, -0.18772627f, 0.07941224f, -0.00778513f, -0.06729010f, 
    0.02017254f, 0.00461394f, -0.04819692f, -0.16796668f, -0.04627735f, -0.52480972f, 0.26750845f, 0.40233400f, 
    -0.08289495f, 0.04644764f, -0.05252487f, -0.05931514f, -0.06470715f, -0.09822880f, -0.07399738f, -0.05071530f, 
    0.60955793f, -0.11139837f, 0.03992003f, -0.09657609f, 0.05457991f, -0.03664545f, -0.06575647f, -0.00873514f, 
    0.18939066f, 0.10388418f, 0.02922679f, -0.15994576f, 0.04555119f, 0.01909216f, 0.11094170f, -0.03038294f, 
    -0.12385807f, -0.04976615f, -0.07935866f, 0.04539692f, -0.01074448f, -0.03103246f, 0.03527800f, 0.04514337f, 
    0.09415096f, -0.58028060f, -0.54644495f, -0.41498989f, -0.10443468f, 0.00631983f, 0.03587421f, 0.01467732f, 
    0.02491431f, -0.00410007f, 0.00974970f, 0.09325762f, 0.11200198f, -0.43703023f, -0.14334455f, -0.37083611f, 
    -0.06325227f, 0.05439303f, -0.05818994f, 0.13632289f, 0.06669838f, 0.02807695f, -0.07897946f, 0.01932967f, 
    0.05079579f, 0.03425014f, -0.00438147f, 0.01368888f, 0.02721728f, 0.06772172f, -0.08145878f, -0.09087794f, 
    -0.09850872f, -0.11986741f, 0.02050298f, 0.06410534f, -0.16440921f, -0.05054044f, 0.00030776f, 0.01071662f, 
    -0.03132801f, -0.03201104f, 0.01011938f, -0.04772599f, -0.03878490f, 0.07219502f, 0.11147394f, -0.10947930f, 
    0.22678548f, -0.08444241f, 0.03388505f, -0.16797613f, -0.06642311f, -0.08586764f, -0.02806548f, -0.00784956f, 
    0.08172794f, 0.12824447f, 0.05840028f, 0.04010660f, -0.18613610f, 0.43474588f, 0.18141244f, 0.08409419f, 
    0.07314669f, -0.03948029f, -0.00606955f, 0.03776100f, 0.04144749f, 0.08328946f, 0.05921900f, 0.02675899f, 
    0.31263408f, -0.44669288f, -0.03192218f, -0.49186122f, 0.05870791f, -0.00157859f, 0.03968317f, 0.18803275f, 
    -0.05329888f, -0.07704493f, 0.01178419f, 0.09075649f, -0.36337155f, -0.34974641f, 0.04276174f, -0.11115464f, 
    -0.06129149f, 0.06738044f, -0.02013853f, -0.00992065f, -0.02952072f, 0.03186863f, 0.05117658f, -0.09422660f, 
    -0.17061923f, -0.19838287f, 0.27991080f, -0.41446847f, -0.06200324f, -0.03726588f, 0.17177317f, 0.07648362f, 
    0.00664663f, -0.00324657f, 0.02083955f, -0.02636377f, 0.26278204f, 0.09929679f, -0.19972438f, 0.04963973f, 
    0.03274848f, 0.01581196f, 0.06214741f, -0.02909641f, -0.11380339f, 0.04728572f, -0.07726557f, -0.10006097f, 
    -0.07727353f, -0.06950502f, -0.07336259f, -0.02288762f, -0.03863321f, -0.03925423f, 0.05432939f, 0.01221760f, 
    -0.07856160f, 0.07034494f, -0.01742015f, 0.04476846f, -0.58840847f, -0.06286924f, -0.17994305f, -0.08273672f, 
    -0.00041975f, -0.02633004f, 0.30532908f, -0.00055920f, 0.03459434f, -0.00929810f, -0.09928947f, -0.04817256f, 
    -0.11677837f, 0.14296937f, -0.08530680f, 0.01790750f, -0.09310708f, 0.00560647f, -0.07901252f, -0.07532465f, 
    0.01506704f, 0.09139176f, 0.04020684f, 0.00987643f, 0.00955227f, 0.01322658f, -0.13207789f, 0.18846163f, 
    -0.06374028f, 0.06439764f, 0.01288983f, 0.04636870f, -0.07469516f, -0.00866416f, -0.05024876f, -0.04413150f, 
    0.53461051f, 0.09221617f, -0.57221949f, -0.40151197f, -0.07190980f, 0.07049789f, -0.03933557f, 0.13687749f, 
    -0.03495452f, 0.06473986f, -0.11463597f, -0.03168215f, 0.01425879f, 0.01439525f, 0.07200729f, -0.07103545f, 
    -0.05903558f, 0.02451524f, 0.00395313f, -0.01881260f, -0.08211061f, -0.07098991f, -0.14351824f, -0.14721194f, 
    0.16928707f, -0.33631048f, 0.16450365f, -0.00464597f, -0.00403640f, -0.04529523f, 0.05546213f, -0.07269856f, 
    0.01975741f, 0.02480731f, -0.02057648f, 0.05843943f, 0.09114438f, -0.06374600f, 0.02582349f, -0.19078486f, 
    -0.02167187f, 0.04622857f, -0.04113902f, -0.10863859f, -0.04939708f, -0.08833976f, -0.08220792f, -0.09424483f, 
    -0.04003441f, 0.09963194f, -0.04256758f, 0.05206517f, -0.04747429f, -0.04397013f, -0.13377681f, 0.07202829f, 
    0.04682028f, 0.03787841f, 0.05621737f, -0.02478889f, 0.09899022f, 0.00169696f, 0.04785594f, -0.06960408f, 
    -0.00553320f, 0.13822684f, -0.01604474f, 0.07754491f, 0.04359264f, 0.06399161f, 0.01207136f, -0.09332539f, 
    -0.41922843f, -0.04848843f, -0.18847640f, -0.00709068f, 0.07650359f, -0.11239878f, 0.07337239f, 0.22572003f, 
    -0.00768126f, -0.01417698f, -0.04155049f, 0.00643881f, -0.35751957f, -0.34225875f, 0.27000132f, -0.04527981f, 
    -0.09916166f, 0.08058538f, 0.13627712f, 0.10060709f, -0.07513057f, 0.02551201f, -0.00253789f, -0.02134306f, 
    0.01428794f, 0.03399124f, -0.11284449f, -0.07916366f, -0.13177469f, 0.07813541f, -0.03789016f, -0.02663790f, 
    -0.02703052f, 0.04913631f, -0.06794030f, 0.05494007f, -0.30858421f, 0.07242040f, -0.00858947f, 0.10587491f, 
    0.01334629f, -0.02212003f, 0.18351851f, 0.02054680f, -0.00547561f, -0.08605897f, 0.03641234f, 0.01098707f, 
    -0.12718794f, 0.04708090f, 0.06378602f, -0.03629184f, -0.19336076f, -0.12464552f, -0.02538685f, 0.01937500f, 
    -0.00103253f, 0.03007932f, 0.00107356f, 0.06985597f, 0.07921375f, 0.01293661f, -0.04757116f, -0.01268330f, 
    -0.01316359f, 0.01443535f, -0.03918954f, -0.05038774f, -0.03011657f, 0.08345646f, -0.06343465f, 0.01229289f, 
    0.13670075f, 0.10341983f, -0.00070084f, 0.00070895f, -0.00796576f, 0.02343484f, 0.02183012f, -0.04805204f, 
    0.14859284f, -0.04527070f, 0.05014306f, 0.10043073f, -0.17838900f, -0.17316069f, 0.18973973f, -0.03874845f, 
    0.11222474f, 0.05344287f, 0.00818795f, 0.09292441f, -0.13977636f, -0.01217323f, 0.13588256f, -0.05573725f, 
    -0.22846767f, -0.02132615f, -0.17474334f, 0.08149233f, -0.00772649f, -0.05196020f, -0.06118280f, 0.01980017f, 
    -0.02068857f, 0.04940224f, 0.02071809f, -0.02618098f, -0.39737043f, 0.05577470f, -0.41956103f, 0.36111870f, 
    -0.12062647f, 0.10346961f, -0.07049901f, 0.06478798f, -0.07946584f, -0.04306412f, -0.12129748f, 0.02951851f, 
    0.19506012f, 0.00163710f, -0.07627844f, -0.06002262f, -0.04694167f, -0.03267488f, -0.00233057f, 0.00485035f, 
    -0.02154829f, 0.03676928f, 0.08895367f, -0.00586881f, -0.04011651f, 0.03706145f, 0.09495126f, 0.04938990f, 
    -0.01094758f, 0.03725002f, 0.01197658f, -0.01972184f, 0.05620357f, -0.07527968f, 0.06214301f, -0.03493973f, 
    -0.07489973f, -0.00096822f, -0.00448810f, 0.01977315f, -0.01351765f, 0.05947675f, 0.06849702f, 0.03043793f, 
    -0.00375443f, -0.05727749f, 0.07063821f, -0.02615188f, 0.13121542f, -0.61682618f, 0.26785022f, 0.15247707f, 
    -0.06103238f, 0.16059661f, 0.07171910f, -0.09744883f, 0.09837762f, 0.04936278f, 0.01554640f, -0.04711687f, 
    0.07210853f, 0.00927139f, 0.05416349f, -0.11748024f, 0.02481211f, 0.00935499f, 0.04257330f, -0.02634938f, 
    -0.05531047f, -0.10860106f, -0.06662937f, -0.03691958f, 0.08390103f, -0.41323155f, -0.52111638f, -0.09867774f, 
    -0.06379234f, -0.07898236f, -0.04322163f, -0.05704346f, -0.03901458f, 0.07670169f, 0.00492008f, -0.10224735f, 
    -0.48046809f, -0.48539361f, 0.03365914f, 0.45935246f, 0.13128015f, 0.07595487f, -0.00046088f, 0.09647371f, 
    0.02911151f, 0.05759643f, -0.00136652f, 0.05168878f, -0.09584775f, 0.07660937f, 0.16714022f, 0.02455810f, 
    0.05593537f, -0.00733005f, 0.03464211f, -0.05519627f, -0.16735911f, 0.00889323f, -0.05410272f, -0.19120526f, 
    0.05560219f, 0.03056324f, -0.03532548f, 0.06075245f, -0.09874810f, -0.05157470f, -0.10105371f, -0.10144713f, 
    0.04039405f, -0.01731769f, -0.01635273f, -0.05474995f, 0.07146413f, -0.02209149f, 0.05626111f, -0.03912859f, 
    0.00806343f, -0.02263282f, -0.05200421f, -0.10657328f, -0.03828675f, 0.05422479f, 0.00974450f, -0.02760644f, 
    0.04236424f, 0.03422698f, 0.01021682f, -0.04523948f, -0.03743093f, -0.00991714f, -0.08914164f, -0.04530992f, 
    0.02474732f, 0.07544027f, -0.00164131f, -0.03603374f, -0.33315572f, -0.28579062f, -0.03032576f, 0.00248968f, 
    -0.00214742f, -0.02683269f, 0.06096206f, 0.04223763f, 0.01543433f, 0.02101567f, -0.03636513f, -0.01829881f, 
    0.54820269f, 0.04137050f, -0.19484401f, -0.22231130f, 0.07328058f, -0.07340229f, -0.18577352f, -0.08125111f, 
    -0.06634768f, 0.08191239f, -0.08244976f, -0.12473468f, -0.16208668f, 0.14842175f, -0.24012864f, -0.04149689f, 
    0.00948184f, -0.24346693f, 0.01083908f, -0.05941775f, 0.06105096f, 0.05404260f, 0.00214898f, 0.00373365f, 
    -0.53837317f, 0.30828220f, -0.28634456f, -0.08303729f, 0.05826151f, -0.31662792f, 0.23323815f, 0.14750887f, 
    0.01497721f, -0.00766236f, -0.08978546f, -0.04283487f, 0.03752000f, -0.08205465f, -0.11958672f, -0.16857742f, 
    0.06771363f, 0.17315516f, 0.20428316f, -0.06995183f, 0.12040482f, 0.04057778f, -0.09949682f, 0.21226050f, 
    -0.01423539f, -0.42584199f, 0.11417866f, 0.07856093f, -0.02354617f, -0.03580627f, -0.10384815f, 0.06712971f, 
    -0.00718203f, 0.00707283f, -0.06059353f, 0.08185966f, -0.30307204f, -0.31984559f, -0.06406802f, -0.28699133f, 
    0.01422793f, 0.05559413f, 0.08958260f, 0.14360431f, -0.01079278f, -0.09644375f, -0.06959023f, -0.02076722f, 
    -0.01731738f, 0.25263640f, -0.45286354f, 0.44456178f, -0.06937478f, -0.06609967f, 0.05794958f, -0.14902715f, 
    0.13202722f, 0.01107934f, 0.04754945f, 0.04847589f, -0.16901946f, -0.04762265f, 0.11614224f, 0.00331520f, 
    -0.15449402f, 0.01120173f, 0.05673669f, 0.08493744f, -0.03120101f, 0.04694526f, -0.07390655f, 0.00699033f, 
    -0.04107691f, 0.16554743f, -0.09822236f, 0.01791822f, 0.08326260f, 0.03494688f, -0.05211907f, -0.09020458f, 
    0.01344627f, 0.04047551f, 0.01315129f, 0.01687592f, 0.08699627f, 0.17919695f, -0.06279089f, 0.04692322f, 
    -0.03425366f, -0.00103469f, 0.04230571f, 0.04232490f, -0.08671966f, -0.01788758f, -0.07064851f, 0.02276290f, 
    0.30412567f, -0.38451904f, 0.16801502f, 0.21988158f, -0.13879970f, 0.04926183f, 0.11316625f, -0.10495339f, 
    0.00312511f, 0.05127933f, -0.03968718f, -0.00240718f, -0.46971577f, -0.24665231f, -0.30951390f, -0.00769969f, 
    0.06031786f, -0.05639884f, 0.09883380f, -0.05891420f, 0.05019422f, 0.00080863f, -0.00496065f, -0.01487997f, 
    0.25598234f, 0.07910872f, -0.18128802f, -0.21238288f, -0.04914625f, 0.07642983f, -0.04693673f, -0.06719214f, 
    0.08229787f, 0.08389229f, 0.11571482f, 0.17216380f, -0.11482804f, -0.09472039f, 0.04516319f, -0.02650725f, 
    -0.16123456f, 0.00083213f, 0.01878048f, 0.10331582f, 0.15423302f, 0.02833535f, 0.02739112f, 0.02900555f, 
    -0.17650482f, 0.01490487f, -0.00135784f, -0.13999751f, -0.05067479f, -0.03482144f, -0.02580994f, -0.13443603f, 
    -0.18459728f, -0.10913742f, -0.09828636f, -0.20063379f, -0.20155877f, 0.19124947f, -0.20421380f, -0.15075316f, 
    0.00235205f, -0.12326306f, 0.17405528f, -0.08318229f, 0.02611260f, 0.13841508f, -0.04794284f, -0.06978188f, 
    -0.51256567f, 0.15650858f, 0.07631864f, 0.19925182f, 0.10618050f, 0.09864640f, -0.07622248f, 0.11141939f, 
    -0.13103446f, 0.16178034f, 0.11165805f, 0.12911886f, -0.02408406f, 0.02854515f, -0.11209502f, -0.12840766f, 
    0.03959111f, -0.01334116f, -0.02617441f, 0.01438759f, 0.08378030f, 0.07044477f, -0.03914551f, 0.19708979f, 
    0.33594921f, 0.38299346f, -0.04942134f, -0.06336845f, 0.04892752f, -0.10695731f, -0.06159682f, 0.13201052f, 
    -0.01169677f, 0.10097579f, 0.04769616f, 0.23353773f, 0.37825793f, -0.30725402f, -0.38717583f, -0.31002051f, 
    0.17868833f, -0.04274288f, 0.03975318f, 0.11391854f, 0.07578178f, 0.02712804f, 0.06776944f, 0.15402541f, 
    -0.06815345f, -0.15586936f, -0.27617201f, -0.59810686f, -0.01937732f, 0.02952214f, 0.09437112f, -0.00218998f, 
    -0.06377005f, 0.00171180f, -0.13567628f, -0.21673773f, -0.07677736f, 0.01596540f, -0.02169345f, -0.11907078f, 
    0.15121365f, -0.04057937f, -0.08233697f, -0.02983612f, -0.07255029f, -0.09084434f, -0.13081139f, -0.10994300f, 
    -0.61797488f, -0.19892935f, 0.02488873f, 0.32414562f, 0.04875905f, 0.06793750f, 0.07989544f, 0.01334070f, 
    0.06775890f, 0.02936187f, 0.15864475f, 0.07068497f, -0.25829566f, -0.38988525f, -0.36747718f, -0.02844985f, 
    0.10817691f, 0.05477069f, 0.13922796f, 0.04619981f, -0.05647340f, -0.01917925f, 0.01639886f, -0.00733839f, 
    -0.16017413f, 0.07657601f, 0.05664007f, 0.12741438f, 0.04171386f, -0.04443974f, -0.00482047f, 0.01889146f, 
    0.01668542f, 0.05525241f, -0.17238182f, -0.00257132f, -0.43657166f, -0.05532184f, -0.06978516f, 0.07105544f, 
    0.04683143f, 0.01483046f, 0.04606850f, -0.03658040f, -0.02877643f, -0.02452140f, -0.19993661f, -0.09016508f, 
    0.01617990f, -0.11742269f, -0.15769835f, -0.22003795f, -0.01102379f, 0.00399484f, 0.04205584f, 0.01775345f, 
    -0.07003158f, -0.03605475f, -0.05563585f, -0.38574591f, -0.26971310f, 0.06730285f, 0.21762539f, 0.09095863f, 
    -0.06382108f, -0.08569382f, -0.05232619f, -0.01866951f, -0.00172852f, -0.05573127f, 0.05728232f, 0.02034820f, 
    0.00623305f, -0.00989075f, -0.13190928f, -0.00058059f, 0.15425082f, 0.03579058f, -0.10339010f, -0.05154242f, 
    -0.02372392f, -0.15449630f, -0.19374555f, -0.24595535f, -0.15792058f, -0.15002953f, -0.11505061f, 0.01752265f, 
    0.09137910f, 0.02310005f, 0.00775994f, 0.05090124f, -0.13942537f, -0.21765909f, -0.22942381f, -0.19781318f, 
    0.06976371f, 0.08179504f, 0.16259940f, 0.08272881f, -0.08586635f, -0.07162014f, 0.01988476f, -0.24358307f, 
    0.00024045f, 0.02160156f, 0.04456466f, 0.12581517f, 0.10925530f, 0.11846639f, -0.02518826f, -0.00808950f, 
    -0.08651722f, -0.03563920f, 0.06888103f, -0.05508152f, -0.05599422f, 0.03808525f, 0.04440374f, 0.05494387f, 
    -0.29860890f, -0.18194595f, 0.08670745f, 0.02866907f, 0.10520710f, 0.09294911f, 0.06540952f, 0.00230476f, 
    -0.01792261f, 0.01851772f, -0.00503588f, 0.01664996f, -0.23710081f, -0.38231668f, -0.00843279f, 0.11317360f, 
    0.02092929f, 0.05547739f, -0.06658912f, -0.05094065f, 0.00527767f, 0.07864086f, -0.06302078f, 0.18005618f, 
    -0.39213979f, 0.16235560f, 0.06256152f, 0.15445870f, -0.01958785f, 0.01422510f, -0.07146341f, 0.06304201f, 
    -0.07853377f, -0.05338712f, 0.04678147f, -0.00920603f, -0.10997490f, -0.01485900f, -0.16572006f, 0.02422555f, 
    0.19546407f, 0.02151489f, -0.02275851f, 0.07322252f, 0.01803609f, 0.19008636f, 0.16046251f, 0.18892704f, 
    0.32076201f, 0.03903103f, -0.52026612f, -0.27465424f, -0.08374216f, -0.21572703f, 0.04106483f, 0.03699860f, 
    0.02925785f, -0.06979088f, 0.07983439f, 0.14943346f, -0.17083709f, -0.01788626f, -0.05839506f, -0.07602193f, 
    0.00519001f, 0.01670713f, -0.01369514f, -0.03909626f, 0.07847187f, 0.11092491f, 0.01861401f, 0.10943518f, 
    0.11451735f, 0.29742566f, -0.05857201f, -0.07233183f, 0.09763931f, -0.05487683f, 0.06262053f, -0.08630709f, 
    -0.00942632f, 0.06325740f, -0.03138341f, 0.03506189f, 0.31042561f, 0.22779541f, -0.08355699f, -0.08368409f, 
    0.09626667f, 0.00670534f, 0.04994285f, -0.04376878f, 0.18343067f, 0.05724273f, 0.08513419f, 0.03361393f, 
    -0.16148099f, -0.10566123f, 0.01807115f, 0.04975566f, 0.10842901f, -0.02876092f, -0.09097119f, 0.00608630f, 
    -0.15511195f, -0.23570864f, -0.13364235f, -0.06952103f, 0.05650173f, -0.03484709f, -0.04714763f, -0.14135520f, 
    -0.17230672f, -0.10264886f, -0.04746587f, -0.06480161f, 0.00862919f, 0.07174106f, 0.12676886f, 0.08465832f, 
    0.02584463f, -0.07865298f, -0.07530748f, -0.08331096f, -0.20547809f, -0.09516529f, 0.06180351f, -0.04605909f, 
    0.01928035f, -0.08370650f, 0.00178771f, -0.00959294f, 0.19165568f, -0.43593550f, -0.37210593f, -0.31810409f, 
    -0.10160069f, -0.03880312f, -0.01081669f, -0.00922104f, -0.00758228f, -0.00955338f, 0.01016475f, 0.01569811f, 
    -0.13195691f, 0.05901455f, 0.06752574f, 0.13188496f, 0.05392666f, 0.04231248f, 0.03349890f, 0.10178953f, 
    -0.05376855f, -0.10588517f, 0.10007106f, -0.01474632f, -0.09900068f, -0.28468952f, 0.28662142f, 0.06840991f, 
    -0.10040847f, 0.12504995f, 0.00425340f, -0.01546929f, -0.15107390f, 0.03625827f, -0.00786061f, 0.03202507f, 
    -0.08150611f, -0.06375291f, 0.04642473f, -0.00421816f, 0.07155205f, -0.09672504f, 0.01163786f, 0.11226156f, 
    -0.04104476f, 0.07953618f, -0.04534129f, -0.00960805f, 0.06938305f, 0.01220295f, 0.10337400f, -0.06197665f, 
    -0.01798995f, -0.02936606f, -0.05002185f, -0.03309572f, -0.02095563f, -0.00529718f, -0.01788765f, -0.12504411f, 
    0.03775607f, -0.03254217f, -0.01078074f, -0.18621704f, -0.09295689f, 0.02732429f, -0.07898698f, 0.05884204f, 
    0.05790728f, 0.12344043f, 0.04205071f, 0.05146512f, 0.23573934f, 0.23705737f, -0.09399002f, -0.36292636f, 
    -0.06762017f, 0.00862495f, 0.20173094f, -0.11552758f, 0.04056602f, 0.05238788f, 0.03881526f, 0.00454821f, 
    -0.05145745f, -0.03133991f, -0.04060053f, 0.22045003f, 0.17873763f, 0.14637987f, -0.12237778f, 0.00349491f, 
    -0.10594203f, -0.00423689f, 0.08209579f, -0.04381857f, 0.28794214f, -0.11321124f, -0.20072120f, -0.08740545f, 
    0.07387035f, -0.06470943f, -0.09671281f, 0.04117630f, 0.03722708f, 0.08698346f, 0.01871659f, 0.01823250f, 
    -0.06465666f, -0.08176921f, -0.05616485f, -0.07964700f, 0.00931710f, 0.00526033f, 0.01959660f, 0.02570889f, 
    0.02677307f, 0.02190586f, -0.00970728f, 0.11077978f, -0.10161299f, -0.05948028f, 0.01340795f, -0.01461292f, 
    -0.01887540f, -0.01059806f, -0.00620264f, -0.03157216f, 0.07060397f, 0.07257500f, 0.07081327f, 0.03488775f, 
    -0.41909227f, 0.11507089f, 0.14684263f, 0.18525146f, -0.04316119f, 0.00475166f, -0.11251878f, -0.02756456f, 
    -0.01482914f, -0.01976790f, -0.02475476f, 0.06751191f, 0.38722813f, 0.03247747f, -0.16952077f, -0.31333858f, 
    0.05888528f, -0.04093466f, 0.06501257f, -0.00774973f, 0.09411012f, 0.05436484f, 0.02455635f, -0.15689586f, 
    -0.11373220f, -0.03165160f, -0.04120835f, -0.16479771f, -0.06315095f, -0.01700914f, -0.06272393f, -0.04371256f, 
    -0.01692278f, 0.01701887f, -0.01520540f, 0.04431729f, 0.01817158f, -0.06623642f, -0.14014225f, 0.05390958f, 
    0.12320478f, 0.08300474f, 0.02972555f, 0.12975140f, 0.15327920f, -0.18166332f, 0.10749848f, 0.05594278f, 
    -0.39661530f, -0.58041489f, -0.31388569f, -0.16780961f, -0.05496796f, 0.16653335f, 0.06002004f, 0.01014566f, 
    -0.02517922f, 0.07916020f, 0.01477869f, 0.01606649f, -0.31975093f, -0.33284819f, 0.02536514f, -0.04473981f, 
    -0.14445946f, 0.00089800f, -0.02789598f, -0.06298334f, 0.00100585f, -0.00173623f, 0.00539309f, 0.08511508f, 
    0.07523757f, 0.09424372f, -0.02930605f, -0.03072214f, 0.09581569f, -0.00254195f, -0.00661560f, -0.00022901f, 
    0.07037517f, 0.03836166f, 0.00745738f, 0.03404052f, 0.12834054f, 0.08979639f, -0.07103762f, -0.15691823f, 
    0.00728807f, -0.04103041f, -0.00442533f, -0.05518850f, 0.03152447f, -0.02796460f, 0.05333620f, 0.00212991f, 
    0.08247432f, 0.01063725f, 0.18939508f, 0.00364659f, 0.00399055f, -0.08693318f, -0.04728889f, -0.06672627f, 
    -0.00247626f, 0.00821866f, 0.00357720f, 0.02269467f, 0.13511884f, -0.02162611f, 0.01381176f, 0.16027606f, 
    0.05700913f, 0.14510301f, 0.07949982f, 0.06305319f, -0.04037863f, -0.08589281f, 0.00468536f, -0.02250886f, 
    0.18191582f, -0.05866786f, -0.42853934f, -0.36918908f, -0.00384522f, -0.07922106f, 0.03475855f, -0.05826584f, 
    0.19592731f, 0.09669998f, 0.20150229f, -0.01283317f, 0.11602751f, 0.18970850f, -0.01312712f, 0.06053986f, 
    -0.00459950f, -0.18625988f, 0.05777331f, -0.07429391f, 0.08768178f, -0.04176710f, 0.03931020f, -0.02371057f, 
    0.06869126f, -0.38965935f, -0.17616060f, 0.07396435f, -0.19076793f, 0.16482830f, 0.17733647f, -0.00856378f, 
    -0.00272341f, 0.00151648f, 0.02968617f, 0.12001725f, -0.18204576f, -0.28785080f, -0.13770218f, 0.09922940f, 
    0.13124365f, 0.25557983f, 0.11641825f, 0.17923176f, -0.12968811f, -0.04078020f, -0.09173787f, -0.49017289f, 
    -0.25772968f, -0.29008740f, -0.44320977f, -0.33912107f, 0.05339510f, -0.10576195f, 0.00790034f, 0.10949866f, 
    0.02312734f, 0.04893662f, 0.02845591f, 0.01388584f, 0.18554413f, -0.09831727f, -0.13048351f, -0.13382088f, 
    -0.14019749f, -0.01057944f, 0.08809690f, -0.13653113f, -0.02391107f, -0.10813119f, -0.10716680f, -0.20199768f, 
    -0.14484136f, -0.08876597f, -0.18136300f, -0.19225627f, 0.07291209f, 0.14461274f, 0.04192415f, 0.12477087f, 
    -0.05429589f, 0.11748220f, -0.19022654f, -0.36942881f, -0.35497120f, -0.55065435f, -0.12105758f, 0.13667277f, 
    0.18397918f, 0.05216018f, 0.08846044f, 0.05880733f, 0.01747736f, -0.01764277f, 0.02792719f, 0.06844711f, 
    -0.28633434f, 0.12003995f, 0.11177894f, 0.14593877f, -0.03811765f, -0.03631303f, -0.08362585f, -0.11911567f, 
    0.00146092f, 0.02363119f, -0.06230651f, 0.01096346f, 0.00610002f, -0.04849866f, -0.12895516f, -0.13573320f, 
    -0.12833875f, 0.09245276f, -0.05004554f, 0.04685051f, 0.05252366f, 0.09676767f, 0.07989907f, 0.01508126f, 
    0.36896551f, -0.08236278f, -0.23505975f, -0.28150499f, 0.15061408f, -0.06779955f, -0.07821327f, -0.10769338f, 
    0.03897946f, 0.14500862f, 0.20901813f, 0.14851069f, 0.04112622f, -0.58080029f, -0.30567157f, 0.21939911f, 
    0.07851399f, 0.06614449f, -0.16381790f, 0.06472396f, -0.05679315f, 0.05088987f, -0.05962614f, 0.07466449f, 
    -0.24480475f, 0.17527284f, 0.16574971f, 0.29269665f, 0.17016827f, -0.03451094f, -0.07903515f, -0.13234884f, 
    0.06038494f, -0.00845888f, 0.03023639f, -0.13683119f, -0.12018356f, -0.18054219f, -0.04823409f, 0.10234781f, 
    -0.20037837f, 0.21806371f, -0.27056292f, -0.05253933f, 0.11304220f, -0.08697172f, -0.08407743f, -0.05714731f, 
    -0.07186513f, -0.12552221f, -0.05629885f, 0.07846193f, 0.02732480f, 0.10314976f, 0.06250250f, 0.05961620f, 
    0.11466984f, 0.07482590f, 0.01457093f, -0.03523161f, 0.01737993f, -0.08866700f, -0.16643497f, 0.04701834f, 
    -0.02206710f, -0.03115609f, 0.14552137f, -0.32286361f, 0.05701405f, 0.09158342f, -0.05279449f, -0.09637413f, 
    -0.47339913f, 0.38352105f, -0.12116659f, -0.65452623f, -0.09165230f, -0.20436463f, 0.09496187f, 0.06532779f, 
    -0.01376224f, 0.08097448f, 0.06277242f, 0.02588360f, 0.11682779f, -0.10259701f, 0.14133978f, 0.14724267f, 
    0.11403541f, -0.09320537f, -0.03692575f, -0.12741822f, -0.05424774f, -0.22433551f, -0.07409599f, 0.03217795f, 
    -0.27598962f, -0.25927061f, -0.19491284f, 0.07912346f, -0.00152036f, 0.14369956f, -0.12808552f, 0.03932073f, 
    -0.12792160f, -0.11567576f, 0.04189552f, -0.12484358f, 0.19981582f, -0.09642719f, 0.14610080f, 0.13699557f, 
    -0.07576954f, -0.14523754f, 0.03199914f, 0.01129053f, 0.07739399f, 0.09593089f, 0.07966604f, 0.00722528f, 
    -0.18668529f, 0.01423962f, 0.26900145f, 0.33012864f, 0.01009418f, 0.01590903f, -0.08709652f, -0.14472751f, 
    -0.02159237f, 0.04389805f, 0.11498918f, 0.06627631f, 0.08917602f, -0.06443955f, -0.41535598f, -0.01796483f, 
    0.11994217f, 0.13452569f, 0.05254897f, 0.09037805f, -0.05889322f, -0.06795184f, -0.00420229f, 0.00475616f, 
    0.40362445f, 0.11791220f, 0.29958645f, -0.36666340f, -0.01585774f, -0.24123105f, -0.09089299f, -0.09040963f, 
    -0.11607312f, -0.00982562f, 0.01929363f, 0.07489257f, 0.06233889f, 0.03443821f, -0.24424534f, -0.27116576f, 
    -0.29056495f, -0.00342089f, 0.00213054f, -0.00677679f, 0.12505908f, 0.07176659f, 0.00954627f, -0.06416325f, 
    -0.00327304f, -0.00917172f, -0.29869747f, 0.17711866f, 0.16720128f, -0.02227433f, 0.07301913f, 0.00590903f, 
    0.11257081f, -0.00063367f, 0.01697508f, -0.12858245f, -0.01025170f, 0.14108340f, 0.48392129f, -0.24562442f, 
    -0.00372045f, -0.13017164f, 0.04018895f, -0.01690217f, -0.05882581f, 0.13851979f, 0.01429275f, 0.01927727f, 
    0.00721963f, -0.09148967f, 0.07456092f, 0.18127201f, 0.02895667f, 0.02302536f, -0.02323247f, -0.01193991f, 
    0.00040475f, 0.12340593f, 0.07360820f, 0.09478396f, -0.18528292f, -0.45941764f, -0.05356314f, -0.43129462f, 
    0.15098716f, 0.01698855f, 0.05709526f, 0.20933130f, 0.02252592f, -0.00746423f, -0.10734610f, -0.02306607f, 
    -0.12221824f, -0.08929405f, 0.05681349f, -0.17372938f, -0.17216899f, -0.07378548f, -0.08896235f, 0.04679359f, 
    0.17223269f, 0.00954346f, 0.06190795f, 0.00042495f, 0.05307846f, 0.27303943f, 0.44296348f, -0.25722641f, 
    -0.04413023f, -0.09810254f, 0.00834461f, -0.11525354f, 0.02456718f, -0.02065000f, 0.06885593f, 0.09574105f, 
    0.00021760f, -0.59883630f, 0.17229435f, -0.40458924f, -0.03765978f, -0.01808561f, -0.33915776f, 0.19429217f, 
    0.02855148f, -0.13051727f, 0.04133359f, -0.01026876f, -0.58219594f, 0.13811083f, -0.23015213f, 0.14707643f, 
    0.00530678f, -0.03764818f, -0.10574293f, 0.03358470f, 0.02553887f, -0.04107983f, -0.10135370f, 0.02657991f, 
    0.02290129f, -0.09439835f, 0.31469265f, -0.24880101f, 0.06599896f, -0.15679586f, -0.12499147f, -0.21040110f, 
    -0.02500184f, 0.05707329f, 0.02630319f, -0.03709545f, -0.07579380f, -0.06462813f, -0.18916643f, -0.23265930f, 
    0.03976804f, -0.05511038f, -0.00768486f, 0.04736962f, 0.02164983f, -0.06544945f, -0.00060073f, 0.00100213f, 
    -0.24049811f, 0.24907561f, -0.31463900f, 0.04780534f, 0.04103085f, 0.11316030f, 0.16834193f, 0.05803413f, 
    0.04943229f, 0.01604683f, -0.10229272f, 0.04610595f, 0.00276437f, 0.16644971f, -0.13850647f, 0.01459646f, 
    -0.10808253f, -0.01229711f, 0.05324959f, -0.15030694f, 0.06598582f, 0.04507012f, -0.22310238f, -0.05093132f, 
    -0.55883759f, -0.15406640f, -0.19871379f, 0.40530542f, 0.08011705f, 0.07702886f, -0.24407063f, 0.22050980f, 
    0.07427406f, -0.10440962f, 0.03240623f, 0.08407616f, 0.11471543f, 0.03071017f, 0.02049259f, 0.01756354f, 
    -0.09202440f, 0.07385707f, -0.08074563f, -0.08070315f, 0.05704644f, -0.06896328f, 0.14011803f, -0.02488890f, 
    0.25709713f, -0.08504320f, -0.36376315f, 0.15054771f, 0.09434700f, 0.04120534f, 0.01036473f, 0.07519609f, 
    0.06021004f, -0.03936692f, 0.01591252f, 0.01757774f, 0.00473847f, -0.16833986f, 0.04531695f, 0.01748884f, 
    -0.01039482f, -0.00044919f, -0.11976717f, 0.00387073f, -0.08085986f, 0.01181292f, -0.05367915f, -0.03961473f, 
    0.13173544f, 0.12679487f, -0.25523305f, 0.00674055f, 0.09418590f, -0.07321183f, 0.10452001f, 0.12472869f, 
    0.03169852f, -0.03083971f, 0.07814322f, 0.07419698f, 0.00800133f, -0.47899070f, 0.23871639f, 0.01347850f, 
    0.12740931f, 0.07492243f, -0.20797713f, -0.10233698f, -0.05316095f, -0.00965777f, -0.07673029f, -0.04897370f, 
    -0.27577111f, -0.02102705f, 0.11336555f, -0.27390850f, 0.01266224f, 0.02763598f, 0.01823504f, 0.17133050f, 
    0.02356536f, -0.05947805f, -0.03738999f, -0.02639484f, -0.07137500f, -0.10294740f, -0.07950454f, 0.19186787f, 
    -0.25384298f, 0.16136213f, -0.01231356f, 0.08312829f, 0.04324822f, 0.04285720f, 0.04293307f, 0.03769652f, 
    -0.18314868f, 0.11356799f, -0.30532524f, -0.05186644f, -0.10386565f, 0.01679323f, 0.11033831f, -0.14424171f, 
    -0.04277076f, -0.01459479f, -0.08197987f, 0.07106916f, 0.05525645f, -0.05871381f, 0.18954262f, -0.27849659f, 
    0.03051427f, -0.22338021f, -0.01096514f, -0.07627532f, -0.07338913f, 0.04043087f, 0.09516492f, 0.09478575f, 
    0.15767805f, 0.09941452f, -0.09048028f, -0.08158433f, -0.10634985f, 0.05175379f, 0.05925823f, 0.02979762f, 
    0.02547789f, -0.04328803f, -0.05159348f, -0.06625609f, -0.08806909f, -0.20101047f, 0.13345520f, -0.05969517f, 
    0.04214981f, 0.06911329f, 0.00790997f, 0.09853781f, 0.01488445f, -0.00994707f, 0.03342811f, -0.01291198f, 
    0.14679222f, -0.02351323f, 0.17379451f, 0.08280779f, 0.12553176f, 0.08873514f, -0.14856605f, -0.10850161f, 
    0.04454723f, 0.00164764f, -0.02071000f, 0.00884738f, -0.22923650f, -0.12629865f, -0.01519178f, -0.17631094f, 
    -0.01741502f, 0.04762122f, -0.00135016f, 0.04094402f, 0.03764689f, 0.10553501f, -0.02969777f, -0.00668261f, 
    0.15798344f, 0.28550813f, 0.02324696f, -0.09616291f, -0.08421036f, -0.02814709f, 0.20389043f, 0.01302845f, 
    -0.05667849f, 0.08446473f, 0.09390113f, -0.02552941f, -0.43474182f, 0.15860736f, -0.52930355f, 0.14111669f, 
    -0.04568668f, -0.04736365f, 0.01171802f, 0.04254437f, 0.05366075f, 0.07244189f, 0.02331192f, 0.06189515f, 
    0.14767313f, 0.11492275f, 0.12077166f, 0.12147091f, 0.13140278f, -0.10443185f, -0.02721253f, -0.08913398f, 
    -0.00020964f, -0.08182964f, 0.03144053f, 0.06387533f, 0.10627081f, 0.11552452f, -0.04690939f, 0.05321670f, 
    0.00355166f, 0.06541147f, -0.00757491f, -0.00077344f, 0.04715663f, 0.02393085f, -0.16395135f, 0.01619132f, 
    -0.10599285f, 0.00940416f, -0.10938186f, -0.21929707f, -0.06517909f, 0.05035434f, 0.08849628f, -0.01810474f, 
    0.08817786f, 0.01142888f, -0.04940822f, -0.10380606f, -0.19289622f, -0.26344219f, 0.20695233f, 0.11777195f, 
    0.09756241f, -0.01147704f, 0.06454337f, 0.03183695f, -0.01375316f, 0.12013135f, -0.01802947f, -0.03381348f, 
    0.17193322f, -0.00669728f, 0.02424140f, 0.11843171f, 0.05741112f, 0.10424210f, 0.03456661f, -0.03003445f, 
    0.15781599f, 0.12626243f, 0.13156466f, -0.14586802f, 0.20228718f, -0.02086798f, 0.22389223f, -0.06339104f, 
    0.10854910f, -0.25422084f, -0.02809205f, -0.09004697f, -0.17286317f, -0.07645629f, -0.08786872f, 0.06460559f, 
    -0.03014688f, 0.33786362f, -0.08957087f, -0.19912571f, -0.25825271f, -0.05551653f, 0.12413967f, 0.14617464f, 
    0.00715006f, 0.02125763f, 0.00670621f, -0.08509810f, 0.19299726f, -0.23886293f, 0.19992054f, -0.16682349f, 
    0.02452021f, -0.08295047f, 0.13059869f, -0.04810562f, 0.01470677f, 0.11311643f, 0.02668369f, 0.09941385f, 
    -0.16204321f, -0.08918343f, -0.20553146f, 0.23566586f, 0.13288586f, -0.05135223f, 0.04923299f, 0.12605684f, 
    0.04542471f, -0.08886219f, -0.07358375f, -0.10557275f, -0.04886526f, -0.04916160f, -0.06732303f, 0.01070568f, 
    0.11805855f, 0.03771169f, 0.09416614f, -0.10642052f, 0.06119857f, 0.04364027f, 0.05075699f, -0.00463828f, 
    -0.28537577f, -0.16942807f, -0.34655982f, 0.20696777f, 0.06562949f, 0.07916524f, 0.09459473f, -0.08823698f, 
    0.13849545f, -0.07790057f, -0.08230489f, -0.11356843f, -0.09828489f, 0.20810895f, 0.01877779f, -0.09656978f, 
    -0.02917130f, -0.14287660f, 0.10612148f, -0.00195093f, -0.01416593f, 0.02472503f, -0.00718106f, -0.01010388f, 
    -0.13575472f, 0.06548894f, 0.34352139f, 0.44274542f, 0.08524913f, -0.13118078f, -0.23649757f, -0.08439010f, 
    0.12175203f, 0.01100608f, -0.02507872f, 0.01083552f, -0.38762799f, -0.06795136f, -0.55566263f, -0.01363132f, 
    0.10465907f, -0.00982311f, 0.15551679f, 0.06603150f, -0.15272607f, -0.06542280f, -0.14718394f, -0.09617192f, 
    -0.23996562f, -0.23617713f, -0.19064334f, -0.16922455f, 0.11588112f, -0.05430949f, -0.04396432f, 0.13112740f, 
    -0.03289234f, 0.05547115f, -0.03314235f, 0.06081491f, 0.15230839f, -0.08591931f, 0.10906806f, -0.00389906f, 
    -0.06588142f, -0.20464765f, -0.03668009f, -0.26302299f, 0.14191221f, 0.03127036f, 0.07615335f, 0.07033277f, 
    -0.07879899f, 0.08518781f, -0.11244091f, 0.04283883f, -0.13843291f, -0.00740063f, 0.01060576f, 0.03093550f, 
    0.06897014f, 0.09024377f, 0.10605815f, 0.03215694f, -0.03823443f, -0.01883251f, 0.04385905f, 0.01287411f, 
    0.04711752f, 0.07535509f, 0.00895304f, 0.05398956f, 0.08707751f, 0.11923368f, 0.05158504f, 0.14251257f, 
    -0.47395897f, 0.10378012f, -0.08697284f, 0.20014885f, 0.01982720f, -0.05403761f, -0.05589767f, -0.03479232f, 
    0.00286495f, -0.02355324f, 0.04254190f, 0.12805539f, 0.16658586f, -0.28017771f, 0.11401159f, -0.45194456f, 
    -0.05765995f, -0.19649981f, 0.07034013f, 0.05690986f, -0.08986498f, 0.00736868f, -0.00027792f, 0.03074039f, 
    -0.26913485f, -0.23886378f, -0.35363376f, -0.02352603f, 0.16067024f, 0.11931966f, 0.12686525f, 0.07590126f, 
    -0.05390740f, -0.07127741f, 0.01064823f, 0.00162565f, -0.23399177f, 0.22871508f, -0.13490182f, 0.34377369f, 
    0.03557174f, -0.03612067f, 0.00051104f, -0.05408391f, 0.01260476f, -0.02039171f, 0.07987665f, -0.09472435f, 
    -0.06328748f, -0.03474583f, 0.01185655f, 0.09125414f, 0.00582446f, 0.04211516f, -0.10377529f, -0.11778946f, 
    -0.02902685f, -0.00661954f, -0.13102706f, -0.05687233f, -0.10240823f, 0.04667193f, 0.07384188f, 0.03418288f, 
    0.17807198f, -0.14197567f, -0.13822426f, 0.10930990f, -0.02110465f, -0.00549593f, -0.01836294f, -0.00782637f, 
    -0.03671055f, 0.02050806f, 0.12513311f, -0.16848163f, -0.20102306f, 0.02603852f, 0.01492905f, -0.04542140f, 
    0.04031499f, -0.08022914f, 0.02397862f, 0.05055425f, 0.07704207f, 0.20236352f, 0.19031754f, -0.01685712f, 
    0.12407406f, -0.05823598f, -0.03586125f, -0.03091874f, -0.04224709f, 0.07245636f, 0.04643404f, 0.06022346f, 
    -0.16243026f, 0.08727434f, 0.00812694f, -0.02257487f, -0.06780667f, -0.08021862f, -0.00400887f, -0.03528448f, 
    -0.07389006f, -0.09947630f, -0.14279723f, -0.09509158f, 0.14512792f, 0.28847262f, 0.06820989f, 0.03979174f, 
    -0.09928522f, 0.05390887f, 0.04528872f, -0.11040594f, -0.06306718f, -0.18368682f, -0.06265382f, -0.09869350f, 
    0.02205953f, -0.28134400f, 0.17476036f, 0.06475433f, 0.00287046f, 0.14032367f, 0.27518061f, -0.07338920f, 
    0.02341868f, 0.10215010f, 0.05307314f, 0.00011813f, -0.20122610f, 0.27960974f, -0.04328708f, 0.00330644f, 
    0.02204423f, -0.06540966f, 0.13595200f, -0.02286140f, -0.04219255f, 0.12914483f, 0.09584352f, 0.16150875f, 
    0.13926110f, 0.36014113f, 0.04454044f, -0.04085410f, -0.11076199f, 0.04333619f, 0.02764430f, 0.15983701f, 
    0.02315850f, 0.09055921f, -0.08438562f, 0.03541209f, -0.44525015f, 0.13194613f, -0.30118212f, -0.09156147f, 
    -0.03827529f, 0.04366929f, 0.12330723f, -0.00416508f, -0.04793577f, 0.07551429f, 0.01337082f, -0.05930263f, 
    -0.04444004f, 0.30528724f, -0.17582715f, 0.12915403f, 0.05792734f, 0.02755881f, 0.04390110f, 0.04852352f, 
    -0.04488978f, -0.10640992f, -0.48074138f, -0.19726728f, -0.02449077f, -0.11771733f, -0.30648592f, -0.10089909f, 
    -0.07895417f, -0.01233348f, -0.02488754f, -0.07710925f, -0.17204884f, 0.03978420f, -0.17878778f, -0.05334832f, 
    0.29102036f, -0.00287439f, -0.04739397f, 0.13999811f, -0.09464395f, -0.14637160f, 0.06169304f, 0.00892304f, 
    0.04088564f, -0.04805276f, 0.07590243f, -0.07774362f, -0.10338825f, -0.01428546f, 0.02875889f, -0.03084571f, 
    0.01977762f, -0.02999013f, 0.10955681f, 0.05570395f, 0.01691342f, 0.08033141f, 0.06094759f, -0.14643152f, 
    -0.03760874f, 0.07345247f, 0.14824089f, 0.01366846f, -0.18545182f, 0.01520786f, 0.01170818f, 0.06848653f, 
    -0.03285691f, -0.09483030f, -0.00146911f, -0.03155924f, -0.24055967f, 0.08115292f, -0.20100924f, 0.00651715f, 
    -0.05625264f, -0.05302770f, 0.00050552f, -0.04448966f, -0.01411746f, -0.35254100f, -0.14341813f, -0.03639536f, 
    -0.01352153f, 0.34341976f, -0.16555208f, -0.02632738f, 0.01346089f, 0.04220373f, 0.03115796f, 0.01167515f, 
    -0.03497377f, -0.23691523f, -0.31681502f, -0.35062489f, -0.06273707f, -0.27227414f, 0.25755197f, 0.10354031f, 
    -0.11601509f, 0.12020875f, -0.26718321f, 0.09756195f, 0.04269615f, -0.03811226f, -0.11106908f, 0.04393129f, 
    -0.16155608f, 0.08816621f, -0.22563334f, -0.18806414f, 0.07783416f, 0.18139343f, 0.17758130f, 0.09106249f, 
    -0.02073569f, -0.05147959f, -0.12173027f, -0.19577859f, -0.20519511f, 0.07515015f, -0.04972501f, 0.06212141f, 
    0.00991689f, -0.05540486f, 0.02457510f, 0.12707818f, -0.15054016f, -0.23080224f, -0.32473958f, -0.20533955f, 
    -0.24659528f, 0.11347501f, 0.03868696f, 0.22434787f, -0.00131255f, 0.16803670f, -0.13281089f, 0.06677493f, 
    -0.05604728f, -0.05594822f, 0.02622215f, 0.08256497f, 0.20859769f, -0.11695784f, 0.42813006f, -0.13309284f, 
    -0.21458700f, -0.06751110f, 0.00317640f, 0.14443663f, -0.07121605f, -0.03580131f, -0.01511638f, 0.06627721f, 
    -0.22607268f, 0.21414556f, 0.03832347f, 0.16001078f, 0.00390199f, -0.07478775f, -0.10841990f, 0.13825838f, 
    0.03245604f, 0.00504901f, -0.07162592f, -0.10559740f, -0.17634362f, -0.07633356f, -0.03194567f, 0.10624493f, 
    -0.05331584f, 0.05597704f, -0.14227630f, 0.15104593f, 0.03066717f, 0.10336794f, -0.09159208f, 0.00965515f, 
    0.00856061f, -0.16565871f, 0.03199410f, -0.05525531f, -0.01267741f, -0.03587398f, 0.08133893f, -0.02037009f, 
    -0.04324537f, 0.15219525f, -0.04052937f, -0.01061895f, 0.16921175f, 0.14796038f, 0.05662988f, -0.08952148f, 
    -0.10141257f, -0.05589737f, 0.04795378f, -0.06523135f, -0.02035867f, 0.07087934f, 0.05838527f, 0.22220658f, 
    -0.34937727f, 0.40693262f, 0.08996557f, 0.23321636f, -0.06282473f, 0.08184750f, -0.09260244f, 0.01522971f, 
    0.08027069f, 0.02984816f, 0.13094176f, 0.05027735f, -0.04130882f, 0.14011635f, -0.17027996f, -0.01911384f, 
    -0.02297156f, -0.19762577f, 0.09242367f, 0.01111003f, -0.26640475f, 0.07157738f, 0.07386234f, -0.02549102f, 
    -0.22600301f, 0.11225113f, -0.25737619f, -0.21252537f, -0.09349855f, 0.11413357f, 0.02346140f, -0.01416246f, 
    -0.17294472f, -0.22704868f, 0.07048168f, -0.06829666f, 0.04154864f, 0.15323345f, 0.01148931f, -0.02369729f, 
    0.02508018f, -0.02753730f, -0.05417885f, 0.03196426f, -0.09499052f, 0.09771916f, -0.05637938f, -0.08285768f, 
    -0.06963379f, -0.03047986f, -0.06072621f, -0.10305113f, -0.10184617f, -0.14724010f, 0.06260119f, 0.10194315f, 
    -0.12964973f, -0.04264665f, -0.31763813f, -0.12446153f, -0.35848823f, 0.09670535f, -0.05969656f, 0.05250829f, 
    0.07496853f, 0.00674575f, 0.16556597f, 0.15348832f, -0.08626609f, 0.03026129f, -0.03884128f, 0.12250140f, 
    -0.24478608f, -0.11628399f, 0.15781416f, 0.04250855f, 0.02677426f, -0.01384439f, -0.11316144f, -0.02271513f, 
    -0.00014936f, 0.05762190f, 0.03848714f, -0.08898184f, -0.14463922f, 0.10213420f, -0.58585930f, 0.03669954f, 
    -0.04997813f, -0.14750461f, 0.05117055f, 0.06984165f, 0.03055837f, 0.04350439f, -0.11399522f, -0.01912962f, 
    0.09779119f, 0.15455742f, 0.15784511f, -0.03005478f, 0.03672004f, -0.08664506f, -0.08504882f, 0.05099385f, 
    0.11947682f, 0.10798813f, 0.14103605f, 0.03555622f, 0.00098642f, 0.05069392f, 0.20283532f, -0.04512265f, 
    -0.03994300f, -0.05464151f, 0.07922082f, -0.13878858f, 0.10274193f, 0.10773480f, -0.14756814f, -0.07382383f, 
    0.04403883f, 0.05041352f, -0.14073940f, 0.16490458f, -0.09134829f, 0.04986897f, 0.03942661f, 0.01505091f, 
    -0.02255489f, 0.07731340f, 0.05897176f, 0.13043171f, -0.17213584f, 0.09288909f, 0.05545831f, -0.17415980f, 
    -0.08444133f, 0.01244928f, -0.04132305f, 0.02446761f, 0.09819195f, -0.09280211f, 0.01467616f, -0.06730139f, 
    0.05785582f, -0.02202752f, -0.14555836f, 0.42449212f, -0.05866941f, 0.01336221f, 0.11648330f, 0.09286202f, 
    0.00182790f, 0.08676714f, -0.12923332f, 0.13544454f, -0.07954159f, -0.07093994f, 0.12510543f, -0.01025610f, 
    -0.04117654f, 0.10010252f, 0.03577279f, 0.16396895f, -0.00827542f, 0.03690036f, 0.01595874f, -0.06315347f, 
    -0.15446839f, -0.15440768f, -0.17659239f, 0.09380735f, 0.13249588f, -0.21011317f, 0.03284443f, 0.21423408f, 
    -0.14593208f, -0.07979506f, -0.11487654f, -0.04515532f, 0.08742076f, 0.03910501f, -0.01448783f, -0.05236286f, 
    -0.14373919f, -0.11615238f, -0.04652691f, 0.09496945f, 0.02033323f, 0.04585626f, -0.16293767f, -0.00375393f, 
    0.01407782f, 0.07071923f, 0.00106009f, -0.07914779f, -0.05082842f, -0.06387630f, 0.05645340f, 0.00305969f, 
    0.00743295f, 0.21631807f, 0.09303932f, 0.11180799f, -0.09524729f, -0.01780872f, 0.06290006f, -0.15689160f, 
    0.02139851f, 0.00239190f, -0.00723527f, -0.07588211f, 0.00714215f, 0.08702350f, 0.19299349f, 0.17314406f, 
    -0.05983645f, 0.04581217f, 0.15420264f, 0.02277215f, -0.08483995f, 0.00184887f, -0.09589753f, -0.01203877f, 
    -0.05646667f, 0.00536760f, 0.10591864f, 0.14478667f, -0.43859023f, 0.13105468f, -0.30377743f, 0.04941508f, 
    0.16037747f, 0.11054945f, 0.05710277f, 0.05480918f, -0.07882094f, -0.09573210f, -0.15222268f, -0.11374591f, 
    -0.19244209f, -0.19326244f, -0.32754222f, -0.17209923f, -0.14179786f, -0.07799964f, 0.05858180f, -0.07332595f, 
    -0.10343847f, 0.14086662f, 0.06700598f, 0.09468477f, -0.03552692f, 0.11620849f, 0.16477427f, 0.09211885f, 
    -0.04664955f, 0.05400599f, 0.01857892f, 0.04098148f, 0.10760196f, 0.01103571f, 0.10492977f, 0.09894388f, 
    -0.10882708f, 0.01254841f, 0.10132519f, -0.03653445f, -0.01823164f, 0.06178908f, -0.04589701f, -0.13514398f, 
    0.02636553f, 0.13351433f, 0.06367046f, 0.04668729f, -0.17097710f, 0.29937577f, -0.05998687f, 0.05706989f, 
    0.10212541f, -0.02588021f, -0.09349055f, 0.09160855f, 0.03151871f, -0.16584691f, 0.04565945f, -0.02460640f, 
    -0.32400471f, 0.21958396f, 0.11514481f, 0.12106168f, -0.12269776f, 0.06601480f, 0.06902574f, 0.19136415f, 
    -0.00666931f, 0.13353170f, 0.14229532f, 0.07181159f, -0.13254045f, 0.01271197f, -0.07974195f, -0.14546207f, 
    -0.15792090f, -0.01833680f, -0.00497928f, 0.03635393f, -0.15643238f, -0.02920594f, -0.00137129f, -0.12956624f, 
    -0.19197339f, 0.23833773f, -0.21762928f, -0.26349661f, -0.07865288f, -0.05566511f, -0.01261026f, -0.10816324f, 
    0.04511151f, -0.04394849f, 0.02740153f, -0.00019017f, -0.09234700f, 0.18313588f, -0.10750036f, 0.06401835f, 
    0.04831960f, -0.10988884f, -0.18844311f, -0.05641221f, -0.02746280f, -0.03331187f, -0.08585962f, 0.00623401f, 
    -0.46158093f, 0.14276578f, 0.26476645f, -0.27861059f, -0.09171496f, 0.07810704f, -0.29955912f, 0.10516801f, 
    -0.10580149f, -0.13377404f, -0.09230804f, -0.10379790f, -0.03648682f, -0.46308398f, 0.18077677f, 0.12161596f, 
    -0.16751710f, 0.14191754f, 0.05681073f, -0.04861099f, 0.00981346f, 0.04402053f, 0.09352792f, 0.05835893f, 
    -0.04898959f, -0.36805525f, 0.02758448f, 0.11618575f, 0.00978395f, 0.17324863f, -0.10252325f, 0.02890734f, 
    0.05334108f, -0.00610923f, 0.01858845f, 0.12639366f, 0.01661752f, -0.02145504f, 0.03701408f, -0.08698756f, 
    0.01750590f, -0.15213831f, -0.03236333f, 0.07397196f, -0.05417642f, 0.03614879f, -0.21485211f, -0.49241662f, 
    -0.05860189f, -0.07752838f, -0.28199765f, -0.02153865f, 0.01750363f, 0.07815879f, 0.08495270f, -0.06050818f, 
    -0.01982238f, 0.12186263f, 0.01246749f, -0.05892589f, -0.06942835f, -0.01624852f, -0.25347668f, -0.15554896f, 
    -0.07631822f, 0.03827869f, -0.15155444f, -0.11462568f, -0.01681783f, -0.02568503f, 0.00565578f, -0.17707235f, 
    0.47646573f, -0.32086152f, 0.16850172f, -0.08407052f, 0.00083159f, -0.01017827f, 0.06008227f, 0.07443546f, 
    -0.08878056f, -0.12367180f, -0.23813786f, -0.25905606f, -0.25358546f, 0.28411889f, -0.26617342f, 0.20328747f, 
    0.08691774f, -0.17025843f, -0.30430514f, 0.32362139f, -0.08537988f, 0.04962657f, -0.02580801f, 0.01342908f, 
    -0.00625311f, -0.07689835f, 0.11728305f, -0.11766437f, -0.14085016f, -0.13766088f, 0.00548990f, 0.06958010f, 
    -0.10339592f, 0.01700729f, 0.06948904f, -0.03409273f, 0.36784810f, 0.22463338f, 0.12893099f, -0.21775927f, 
    -0.07387383f, -0.10366186f, -0.01778529f, 0.14521946f, 0.04965276f, 0.07294475f, 0.04368057f, 0.19372781f, 
    -0.28242359f, 0.18838707f, -0.24670628f, -0.16628502f, -0.01012665f, 0.14782099f, 0.15745316f, 0.02374451f, 
    -0.04341770f, 0.16031605f, 0.05334149f, 0.12464537f, -0.09903188f, 0.10441944f, 0.08606026f, 0.09765919f, 
    -0.15891333f, -0.00977927f, -0.05652446f, 0.08261976f, -0.05768505f, 0.03535211f, 0.05584656f, 0.04975786f, 
    -0.16734573f, -0.04809828f, -0.04136300f, -0.07346448f, 0.03618971f, 0.13828827f, -0.02027081f, -0.05032142f, 
    -0.10325801f, 0.00850497f, -0.00313813f, -0.10912279f, -0.66909534f, 0.28904703f, -0.33897305f, 0.23970054f, 
    0.12711480f, -0.16085081f, 0.04546336f, -0.14775364f, -0.07972500f, -0.03117748f, 0.01695041f, 0.12994045f, 
    0.22269049f, 0.12314716f, -0.06793905f, 0.14772587f, -0.01991897f, 0.08996108f, -0.01942975f, 0.05568766f, 
    -0.00184451f, 0.02087156f, 0.01650357f, -0.00997656f, 0.05710715f, -0.18015137f, 0.19713256f, 0.01124744f, 
    -0.18295446f, 0.08157256f, -0.22260630f, 0.10745605f, -0.02368911f, 0.03255274f, 0.00368465f, -0.09849817f, 
    0.00907712f, -0.43971774f, 0.30316225f, -0.31738025f, 0.02054653f, 0.03013588f, 0.07041135f, 0.04101499f, 
    0.04315092f, 0.01752858f, 0.03980526f, 0.05235171f, -0.09472337f, -0.12168310f, -0.06003954f, 0.12139801f, 
    0.07899441f, 0.00281495f, -0.00528927f, 0.01330155f, 0.01221802f, 0.00246847f, 0.04774481f, -0.06758209f, 
    0.02870742f, -0.12271311f, 0.26977223f, 0.34789664f, 0.15097059f, 0.04973114f, 0.06451380f, -0.07041539f, 
    0.04716847f, 0.08030012f, 0.01893477f, 0.03399099f, -0.16322513f, -0.36206570f, -0.22017896f, -0.03371348f, 
    0.08600055f, -0.28844571f, 0.08597623f, -0.11862582f, 0.02286065f, 0.07826595f, 0.09917480f, 0.05051155f, 
    -0.34570447f, -0.32565144f, -0.24178287f, 0.19346476f, 0.07295495f, -0.04059860f, -0.02255087f, -0.03229253f, 
    -0.03189069f, 0.01890406f, 0.19993867f, 0.13502973f, 0.31559652f, 0.05881911f, 0.05212600f, -0.03636897f, 
    -0.07128134f, -0.03300779f, -0.02858327f, 0.05145445f, 0.01979486f, 0.01704092f, -0.03390193f, -0.14532697f, 
    -0.28269327f, -0.17683570f, -0.17474358f, -0.12817085f, -0.07910499f, -0.03339740f, -0.01057377f, 0.04532826f, 
    -0.22019194f, -0.03185176f, -0.13073300f, -0.00011579f, -0.15193214f, 0.35367206f, -0.10616089f, -0.28905988f, 
    -0.03908210f, -0.09095912f, 0.14961666f, -0.04880493f, 0.01127775f, 0.02181203f, 0.04724631f, -0.04188507f, 
    0.11186977f, -0.03351334f, 0.18656264f, -0.12205701f, 0.07661094f, -0.09477834f, 0.16158125f, -0.01358317f, 
    0.02206586f, 0.00528822f, 0.14713943f, -0.06153451f, -0.06499828f, -0.04378542f, 0.05721672f, -0.04418341f, 
    -0.01773936f, 0.03167660f, -0.03473661f, 0.01527586f, -0.05075417f, 0.17370486f, 0.12696400f, -0.07922015f, 
    -0.32206008f, -0.11534197f, -0.18027419f, -0.03481067f, 0.06650307f, -0.02158625f, 0.01233913f, 0.00119831f, 
    0.02357706f, -0.02703625f, 0.05973734f, 0.06438158f, 0.39885345f, 0.14104995f, -0.22514224f, -0.05648222f, 
    -0.07673767f, 0.13687009f, -0.10181788f, -0.05540037f, 0.01332039f, 0.00689540f, 0.00686049f, -0.01527737f, 
    0.05982628f, -0.02451937f, -0.39858422f, -0.06414980f, -0.03072717f, -0.22151706f, 0.08175538f, -0.05126101f, 
    0.08958736f, 0.05773396f, 0.03208260f, 0.03144735f, -0.27162084f, -0.19113313f, 0.01147684f, 0.06105620f, 
    -0.06285599f, 0.07170175f, -0.02467601f, 0.06973020f, 0.01923435f, 0.12085379f, -0.04567962f, -0.03438055f, 
    -0.54175538f, 0.39118576f, -0.27335477f, 0.25203550f, -0.14256550f, -0.05588544f, 0.16076496f, 0.00260362f, 
    -0.04808326f, -0.03354685f, 0.06518712f, -0.08879483f, 0.14163381f, -0.20285197f, 0.36551565f, -0.64672089f, 
    -0.02177625f, 0.20601816f, -0.14839756f, 0.07628423f, 0.02334597f, 0.10466149f, 0.15519525f, -0.13884723f, 
    -0.37785494f, -0.25410765f, 0.18587367f, -0.01301344f, -0.08908954f, 0.01221764f, 0.06920774f, 0.12253500f, 
    -0.07049990f, -0.07229143f, -0.16194363f, -0.12877867f, -0.09836694f, 0.17222001f, 0.00861714f, -0.15059699f, 
    -0.04142387f, 0.08457392f, -0.06888678f, -0.01703550f, -0.01652213f, 0.03711621f, -0.01161146f, -0.00978136f, 
    0.25732192f, 0.04552596f, 0.32631296f, 0.10606294f, 0.02904930f, 0.04181714f, -0.09291106f, 0.06899031f, 
    -0.23225430f, 0.06243065f, 0.07221580f, -0.02854716f, -0.09139931f, -0.12882121f, 0.22063595f, -0.11491661f, 
    0.02565401f, 0.08211277f, 0.14530736f, -0.05188660f, -0.21118426f, -0.03470858f, -0.06188884f, -0.07522590f, 
    -0.30214646f, -0.12347648f, 0.08711264f, 0.04007537f, 0.18614632f, 0.15331380f, -0.00608485f, -0.03129606f, 
    0.00754217f, -0.06484209f, 0.04944000f, 0.10852136f, -0.21907286f, -0.15567368f, 0.00498682f, 0.10233423f, 
    0.01999317f, 0.02103578f, 0.04719933f, -0.02506084f, 0.01568908f, 0.00031659f, -0.07624939f, -0.02696028f, 
    0.18823270f, 0.21453759f, 0.12756695f, 0.33606464f, 0.11864014f, -0.08222511f, 0.15565132f, 0.08965755f, 
    0.03847952f, 0.06506003f, 0.06785700f, -0.02369918f, 0.09260847f, -0.09176163f, 0.13059334f, 0.32022256f, 
    0.04357816f, -0.12753575f, 0.01271536f, 0.15007602f, 0.03078719f, 0.07419864f, -0.04304064f, -0.06017201f, 
    0.39054143f, -0.09374975f, 0.25392571f, 0.00096914f, 0.01867259f, 0.09426191f, 0.06312262f, 0.01916001f, 
    -0.06328135f, 0.07886694f, 0.18675745f, 0.14708641f, -0.10331815f, 0.22477180f, -0.25644341f, -0.02537409f, 
    -0.04604826f, -0.01278566f, 0.09870742f, -0.14173889f, -0.07055423f, -0.06512923f, -0.13060145f, -0.17632049f, 
    0.03942826f, -0.14672542f, -0.02411334f, -0.10057320f, -0.12511185f, -0.07869470f, -0.23605014f, -0.07080458f, 
    -0.06492115f, -0.06308784f, -0.12395314f, -0.05969594f, -0.17590491f, -0.15427098f, 0.00618588f, -0.13189839f, 
    -0.14204079f, 0.04863588f, -0.07414701f, -0.21158010f, 0.02367114f, 0.03195743f, 0.04776045f, 0.08300800f, 
    0.05658722f, -0.20163256f, 0.34180120f, 0.08132139f, 0.05361715f, -0.15697399f, 0.22192326f, -0.00283035f, 
    -0.12613806f, -0.02720919f, -0.01420404f, 0.01379673f, -0.12804249f, -0.02632571f, 0.00692780f, -0.08914447f, 
    0.04334391f, 0.17229828f, -0.04473945f, 0.00850220f, -0.15076184f, 0.05410388f, 0.01235733f, -0.00548008f, 
    -0.11317972f, -0.01975558f, 0.12554505f, 0.12546389f, -0.09377050f, 0.03053700f, -0.19932123f, -0.05845794f, 
    -0.05741521f, -0.15119328f, -0.05798562f, -0.17313518f, 0.05744823f, 0.16347235f, -0.19181569f, -0.09800021f, 
    0.03604357f, -0.04857802f, 0.06463830f, -0.02017584f, 0.10599858f, 0.02541114f, -0.07825392f, 0.07382479f, 
    -0.27029675f, 0.12743069f, -0.04084860f, 0.07826592f, -0.11053843f, 0.06532478f, -0.02831891f, 0.06762292f, 
    -0.00998343f, 0.01682035f, 0.08980516f, 0.13740893f, -0.44886890f, 0.06648079f, -0.15045376f, 0.24078375f, 
    -0.25323242f, -0.01028606f, 0.04229756f, -0.17565671f, 0.01649079f, 0.05072916f, -0.09707721f, 0.04924453f, 
    0.24399737f, -0.12869439f, 0.40702611f, 0.03754080f, 0.06030340f, 0.00036430f, 0.02528218f, -0.00363888f, 
    -0.06534556f, 0.02537332f, 0.09423839f, 0.08050812f, 0.08168770f, -0.36620769f, 0.31488857f, -0.09839740f, 
    0.08306601f, 0.02520294f, 0.09913289f, -0.09191216f, 0.02428924f, 0.05968385f, 0.07588931f, 0.01911386f, 
    -0.13656783f, -0.05816273f, -0.02244839f, -0.02412584f, 0.04607718f, 0.01761061f, -0.01077734f, -0.01256953f, 
    0.04706533f, 0.03905218f, -0.10203249f, -0.25489911f, 0.07807383f, 0.14971222f, 0.03813917f, -0.01384992f, 
    0.12316763f, 0.09504014f, 0.18249300f, -0.02551056f, -0.18891343f, 0.06131876f, -0.01650815f, -0.00528293f, 
    0.09868790f, -0.02936946f, -0.03867577f, 0.17475298f, -0.04397900f, 0.03005193f, -0.09202638f, 0.02240951f, 
    -0.22434980f, -0.05771001f, 0.02013668f, -0.02477636f, -0.29485860f, -0.16520607f, -0.28235373f, 0.20324743f, 
    0.04898670f, 0.06853345f, -0.01009135f, 0.06605082f, 0.07378988f, 0.11227568f, 0.21364428f, 0.04804454f, 
    -0.09065644f, 0.08778968f, -0.10342211f, 0.07599190f, 0.00139029f, 0.04336358f, -0.01804187f, -0.04132173f, 
    0.05366113f, 0.04806218f, 0.02827071f, -0.05801839f, -0.06040861f, -0.02656735f, 0.05666320f, 0.04498447f, 
    0.01665515f, 0.02627068f, -0.07859184f, 0.03205562f, -0.16928521f, 0.01481445f, -0.00712777f, -0.11532851f, 
    -0.17002566f, -0.23719051f, 0.05415469f, -0.18633060f, -0.13251723f, -0.25355652f, -0.10642793f, -0.13284256f, 
    0.03762387f, -0.02745272f, -0.11956499f, -0.04493647f, -0.49089992f, 0.19802901f, -0.20508635f, 0.19219816f, 
    -0.07350567f, 0.03139513f, -0.01952570f, 0.07656465f, -0.23294336f, 0.05787483f, 0.12697290f, 0.06757198f, 
    0.22264916f, 0.03727529f, 0.21246074f, -0.01077155f, 0.09943080f, 0.02903324f, 0.05668324f, 0.19842826f, 
    -0.01326450f, -0.03191579f, -0.02500258f, -0.09439649f, 0.25760171f, -0.00738345f, -0.04017225f, -0.02590410f, 
    -0.03114491f, 0.13611610f, -0.03901475f, 0.03616769f, -0.06420569f, 0.02798840f, -0.05085752f, -0.10536010f, 
    0.38501212f, 0.07261990f, 0.04385089f, 0.01281171f, -0.00728255f, 0.07364058f, -0.06924473f, 0.10411892f, 
    -0.12745155f, -0.01542380f, -0.07099243f, 0.02677345f, 0.07298929f, -0.19356313f, 0.12424147f, -0.05375082f, 
    0.04661129f, -0.16945767f, 0.00793923f, -0.02536142f, -0.03623824f, -0.06324269f, 0.00015237f, -0.02356712f, 
    -0.27981937f, -0.33510265f, -0.23200729f, -0.03294399f, 0.30399644f, 0.07352789f, 0.02265268f, -0.00105886f, 
    0.05627587f, 0.17074068f, 0.17214492f, 0.16199447f, 0.54934871f, 0.05364330f, 0.44492504f, -0.36464301f, 
    0.01748135f, 0.07508159f, -0.42644399f, 0.20340386f, -0.13841927f, 0.00861709f, -0.10025746f, -0.09635442f, 
    -0.13836524f, 0.18104604f, 0.24883500f, 0.12466507f, -0.10332318f, -0.03018519f, -0.30781993f, 0.13856770f, 
    -0.03555176f, 0.05176720f, 0.05635643f, -0.04194617f, 0.35660380f, 0.13787828f, -0.13445905f, -0.32103339f, 
    -0.13300295f, -0.06998391f, 0.19347385f, 0.03285413f, -0.05453450f, 0.09198730f, 0.11388793f, 0.05972034f, 
    -0.14609024f, -0.22514673f, -0.25575608f, -0.10347979f, -0.02955667f, -0.15105157f, 0.02687893f, -0.21068017f, 
    0.02624621f, 0.00718351f, 0.03824279f, 0.07928896f, -0.07144439f, -0.08754759f, 0.03928093f, -0.08131505f, 
    -0.04977057f, 0.01892436f, 0.24078104f, 0.01439593f, 0.04404531f, 0.09263226f, 0.01825298f, 0.03051016f, 
    -0.10372530f, -0.26371226f, 0.11324745f, -0.41231158f, -0.01665319f, 0.04389742f, -0.07956950f, 0.07269078f, 
    -0.04817880f, 0.05043856f, 0.12319361f, 0.12916356f, -0.29667330f, -0.25617358f, 0.27680001f, 0.13718031f, 
    -0.08226409f, -0.03911657f, -0.03827725f, 0.05939461f, -0.04752531f, 0.08498557f, -0.14416055f, -0.08615763f, 
    0.28284347f, 0.15951642f, 0.30740219f, -0.10034623f, -0.08653815f, -0.02522570f, -0.10023344f, 0.00283232f, 
    -0.15966918f, -0.03367103f, 0.08274473f, -0.09026214f, -0.16231808f, -0.09318508f, 0.13192049f, 0.11359380f, 
    0.05618127f, 0.00652385f, 0.09726909f, 0.08738890f, -0.14729406f, 0.07634238f, -0.03696145f, -0.00849907f, 
    -0.01837539f, 0.12791727f, 0.06105661f, 0.16839394f, 0.16840456f, -0.16389152f, 0.10853501f, 0.05300466f, 
    0.06255671f, -0.03735662f, 0.03934598f, -0.21937218f, 0.12443092f, -0.07728513f, 0.24590844f, -0.00957324f, 
    -0.06802965f, 0.11560261f, -0.08577748f, 0.05896941f, 0.01292778f, -0.02510122f, 0.03363309f, -0.12306318f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.09366439f, 0.06717249f, 0.07403634f, -0.06665725f, -0.09154249f, 0.04201916f, 0.04912798f, -0.09187065f, 
    0.04805695f, 0.04292133f, -0.00513415f, -0.02320514f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
