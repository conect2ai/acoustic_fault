#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.63003886f, 0.75513548f, 0.58627564f, -0.25633273f, 0.14288089f, -0.83455181f, -0.42206505f, 0.31148574f, 
    0.19712618f, 0.12662327f, -0.09844463f, 0.31178954f, -0.13538545f, 0.34340462f, -0.14119832f, 0.19783866f, 
    -0.03048128f, 0.00641281f, -0.23508449f, -0.20494513f, 0.07412186f, 0.08406051f, -0.23954146f, 0.16022421f, 
    0.10832057f, 0.53768051f, -0.02192670f, 0.10375108f, 0.25009447f, -0.31259328f, 0.38878921f, 0.17501333f, 
    0.04902339f, 0.06721935f, 0.35634473f, -0.28294167f, 0.20098114f, -0.02836271f, -0.37181044f, -0.25333416f, 
    0.16674353f, -0.26511946f, -0.20383878f, 0.14127082f, 0.03239736f, -0.25054595f, 0.19837712f, 0.19409771f, 
    0.02233469f, -0.27930012f, -0.58985871f, 0.23740974f, 0.61740136f, -0.35332248f, -0.16665278f, -0.10040014f, 
    0.18043761f, -0.35375857f, -0.03469461f, 0.16445734f, 0.13819039f, 0.11827079f, -0.02615807f, -0.42059255f, 
    0.17425455f, 0.15176909f, 0.03683073f, -0.01125814f, -0.16112538f, 0.11893994f, -0.07615376f, 0.18114196f, 
    0.29903468f, 0.14776565f, 0.22743209f, 0.57316750f, 0.75809884f, 0.28834027f, 0.28424799f, -0.05763707f, 
    -0.32740244f, -0.42247856f, -0.02469349f, 0.15658344f, -0.32138985f, -0.10668347f, 0.14119926f, 0.15770760f, 
    0.30419359f, -0.27536002f, -0.33192635f, 0.06753405f, -0.26764363f, 0.29203674f, 0.11558475f, -0.14651819f, 
    0.11421035f, 0.16121262f, -0.19981568f, -0.12958553f, -0.21142898f, 0.33333495f, -0.00904213f, 0.40799853f, 
    0.46251628f, -0.09141083f, 0.00367685f, 0.16810597f, 0.10485574f, 0.38521180f, 0.10853627f, -0.30585748f, 
    0.05678608f, 0.06460902f, -0.06517781f, 0.23679283f, -0.03220163f, -0.04720997f, 0.32881036f, -0.38251460f, 
    -0.15833253f, 0.13900307f, -0.22251850f, -0.18215728f, -0.31372321f, -0.87601227f, -0.42673066f, 0.70780098f, 
    -0.00966452f, 0.16111298f, 0.00501405f, 0.45075855f, -0.54078013f, -0.24402359f, 0.20448738f, -0.35623267f, 
    -0.07149132f, -0.09242729f, 0.56257284f, -0.28456905f, 0.03075680f, 0.06072643f, -0.15069139f, 0.17290093f, 
    0.22000204f, 0.13562395f, 0.07836171f, -0.09065918f, 0.07883944f, 0.01233654f, -0.14413662f, -0.36546284f, 
    -0.02086162f, 0.45058119f, 0.62741351f, -0.28654486f, -0.10392974f, -0.00486811f, 0.20818385f, 0.28959048f, 
    0.07381663f, -0.30342418f, 0.19930719f, 0.59260392f, -0.25669315f, -0.42782718f, 0.34577310f, -0.11998399f, 
    -0.12470064f, -0.69891626f, 0.04007614f, 0.14404349f, 0.26244301f, 0.25526789f, 0.14385447f, -0.21650001f, 
    0.26013631f, -0.47825208f, -0.34132558f, -0.30578491f, -0.53068900f, 0.42334974f, -0.47122633f, -0.39054811f, 
    -0.27367428f, 0.36312395f, 0.47856686f, 0.16255660f, -0.40152591f, -0.30198276f, -0.10320795f, -0.06570406f, 
    0.20274466f, 0.00124386f, 0.19933809f, -0.19642544f, 0.05550300f, -0.36807436f, -0.34405017f, -0.00746665f, 
    0.26147738f, -0.79485971f, -0.38819811f, -0.27735475f, 0.09475489f, 0.41272479f, 0.49626327f, 0.64094323f, 
    -0.65268594f, -0.39914724f, -0.07349177f, -0.30098057f, -0.37009254f, -0.08767183f, -0.23600870f, -0.05661401f, 
    -0.31764561f, -0.04907351f, -0.15940060f, -0.19092225f, 0.10862326f, -0.17002662f, -0.12492845f, 0.10691512f, 
    -0.36830926f, -0.90776449f, -0.46633774f, -0.44061020f, -0.54098505f, -0.59917086f, 0.50459743f, 0.38458800f, 
    -0.05545505f, -0.11583151f, 0.24472576f, -0.29121813f, -0.24512915f, -0.27957043f, -0.37466270f, -0.42153645f, 
    0.26968494f, 0.40191302f, -0.21388258f, 0.25933516f, 0.26924440f, 0.03315488f, -0.04493656f, -0.23374794f, 
    -0.25966153f, -0.32664159f, -0.07882148f, 0.87740111f, 0.55205798f, -0.09719498f, -0.33755621f, -0.40962428f, 
    -0.37593067f, 0.07910968f, 0.57207143f, -0.00411470f, -0.34742582f, -0.47777307f, -0.11750491f, -0.06142615f, 
    -0.16236977f, 0.60486394f, 0.23429096f, -0.12187648f, -0.35833511f, 0.23900121f, -0.10523266f, 0.05097917f, 
    -0.19304045f, 0.00343640f, -0.20062533f, -0.16995199f, -0.22600152f, -0.65142781f, -0.28928846f, 0.14019173f, 
    -0.55359536f, -0.62398577f, -0.20697272f, -0.36628777f, -0.24897963f, 0.00461365f, 0.56450564f, 0.01762893f, 
    -0.08025543f, -0.00931215f, -0.01215604f, -0.10180550f, -0.05179522f, 0.14889957f, 0.08549893f, 0.34624764f, 
    0.20099138f, 0.11949167f, 0.16112313f, 0.15285462f, 0.12897515f, 0.22994286f, 0.32861748f, -0.66877091f, 
    -0.62891281f, 0.19543803f, -0.12369294f, -0.11082959f, 0.09884597f, 0.56381929f, 0.06574744f, -0.29668409f, 
    -0.39455429f, -0.40342596f, 0.49369740f, 0.02887926f, 0.05513893f, 0.18722245f, 0.29621717f, -0.08796926f, 
    0.00368894f, -0.15539472f, 0.00738520f, -0.38395864f, -0.19101302f, 1.08968294f, -0.71401364f, -0.52677870f, 
    -0.43707177f, 0.12199444f, -0.39658982f, 0.23601647f, 0.87359899f, -0.11945001f, -0.03046269f, -0.01499560f, 
    0.34173483f, 0.25427279f, -0.31026167f, -0.11277151f, 0.16817117f, -0.08958255f, 0.10406534f, -0.18701291f, 
    -0.08872259f, 0.11844297f, -0.08248165f, -0.35930315f, 0.21432880f, 0.02216647f, 0.34075159f, 0.49074122f, 
    -0.33640742f, -0.01737895f, 0.35537302f, -0.02021053f, 0.02611658f, -0.17736317f, 0.00069476f, -0.02513388f, 
    -0.03901182f, -0.05486660f, -0.14354958f, 0.06636142f, -0.27716750f, 0.09722017f, -0.35208669f, 0.30317500f, 
    0.08398702f, -0.39580849f, -0.01516419f, 0.38134128f, 0.33728719f, 0.30544311f, 0.20432732f, -0.66277373f, 
    -0.14666136f, -0.39229128f, -0.43534103f, 0.16891278f, -0.38291806f, -0.29925647f, 0.40492278f, 0.31895387f, 
    -0.11543522f, -0.27884939f, -0.39693749f, -0.18762834f, -0.04939433f, -0.24022363f, 0.04747747f, -0.40038943f, 
    0.40369508f, 0.19838564f, -0.41894197f, -0.13157260f, 0.41847029f, 0.07209421f, -0.19511303f, 0.28794888f, 
    0.73898715f, 0.00936381f, -0.27213153f, 0.05528187f, 0.41995871f, 0.13158070f, 0.00854519f, -0.24055845f, 
    -0.13042790f, 0.20823736f, -0.00738397f, 0.12786430f, -0.22963443f, -0.29643193f, 0.20211211f, -0.02898736f, 
    0.47538221f, 0.07695319f, -0.05686129f, -0.36284393f, -0.03733594f, -0.17345883f, -0.18238585f, -0.33134729f, 
    -0.46245706f, -0.10847395f, 0.52058184f, -0.22580671f, 0.30429351f, -0.24411866f, -0.36715850f, -0.37892810f, 
    -0.15629131f, 0.34386283f, 0.42034450f, 0.46247348f, -0.29647645f, 0.22148830f, -0.26774514f, -0.41382116f, 
    0.06674518f, -0.05806913f, 0.44039121f, -0.13164793f, -0.34856203f, -0.04130927f, -0.34546030f, -0.05125648f, 
    -0.18380645f, 0.42178169f, 0.22891934f, -0.03944378f, 0.42774796f, -0.00891259f, 0.35689974f, -0.17215404f, 
    -0.26637027f, -0.31815898f, -0.14057466f, -0.01674914f, 0.04137827f, 0.08128425f, -0.04924817f, -0.11343957f, 
    0.20029618f, 0.17334814f, 0.32831815f, -0.47316617f, 0.09178931f, 0.26122701f, -0.16480036f, 0.28729182f, 
    -0.06733735f, -0.07564656f, 0.37282246f, -0.71842462f, -0.65252644f, -0.57970065f, 0.10586474f, 0.52161312f, 
    0.18996248f, -0.13556209f, 0.34498367f, 0.43874916f, 0.27160698f, 0.14341766f, 0.12499955f, 0.09308010f, 
    0.10720781f, 0.11044268f, 0.12551084f, -0.08353470f, -0.16414708f, -0.13397893f, -0.18434793f, -0.17967995f, 
    0.07865870f, -0.03373946f, -0.00485507f, 0.12776561f, -0.60344797f, -0.36197942f, 0.20444587f, 0.17365535f, 
    -0.03494327f, 0.31168446f, -0.06008578f, -0.25753880f, 0.33637241f, 0.42513004f, 0.20544264f, -0.26437643f, 
    -0.12587954f, 0.05280137f, -0.35073450f, -0.34264758f, 0.20211503f, 0.32179371f, 0.14699413f, -0.10978967f, 
    0.18663299f, -0.02995259f, -0.14545186f, -0.12362614f, -0.39984003f, 0.46697754f, 0.04583463f, 0.13103007f, 
    -0.03975740f, -0.53965634f, -0.59695727f, -0.25872871f, -0.04128177f, -0.51851904f, -0.84482193f, 0.11144468f, 
    0.47388938f, -0.30032897f, 0.20309384f, 0.02107387f, 0.08390001f, -0.00526999f, 0.21288064f, 0.03589853f, 
    -0.25062463f, -0.28294086f, -0.21542425f, -0.04698344f, 0.19598819f, 0.17283429f, 0.22689579f, 0.75194734f, 
    0.37733957f, -0.55667019f, -0.68297660f, -0.37751418f, -0.13047341f, 0.42974928f, -0.44214994f, -0.38441908f, 
    -0.37418219f, -0.22251590f, 0.64361155f, 0.23713839f, 0.22886579f, -0.01659583f, -0.22659186f, -0.13091333f, 
    -0.20257138f, -0.14751898f, 0.04520777f, -0.02176177f, 0.41948184f, -0.05530624f, -0.14756045f, -0.98314553f, 
    0.35480192f, 0.18455981f, -0.53952682f, -0.37673512f, 0.32113582f, 0.44070727f, -0.05951515f, 0.04050108f, 
    0.04820967f, 0.19859749f, 0.46291700f, -0.19195071f, 0.30977896f, -0.16875304f, -0.11409251f, -0.32713485f, 
    -0.29599041f, -0.46667242f, -0.19300336f, 0.30530831f, 0.26572755f, 0.13898970f, 0.47807935f, -0.03584421f, 
    -0.50656021f, -0.22993405f, -0.25881508f, 0.05856373f, 0.08603472f, -0.10319202f, -0.48143524f, -0.76345259f, 
    -0.30952215f, -0.11237411f, 0.06997462f, 0.13753702f, -0.02311607f, 0.48289683f, -0.29850900f, 0.07728532f, 
    -0.27526355f, -0.29641679f, -0.00937018f, 0.26798403f, -0.28968018f, -0.09700592f, 0.09301478f, -0.01986200f, 
    -0.49599957f, -0.12173685f, -0.57180238f, -0.08197344f, -0.06126849f, -0.47813514f, 0.29862764f, -0.32135952f, 
    -0.43230042f, -0.21134891f, 0.13857746f, -0.10508125f, -0.13310347f, -0.41596985f, -0.40092432f, 0.43892682f, 
    -0.39704669f, 0.27795991f, -0.36885887f, -0.30178800f, -0.30385870f, -0.09400612f, -0.24629873f, 0.22523955f, 
    -0.01391528f, -0.00395136f, -0.92103416f, -0.72091675f, -0.59070897f, -0.18423444f, -0.28616649f, 0.52288967f, 
    0.24725723f, 0.24144754f, 0.35246676f, 0.74174899f, 0.05608911f, 0.33345577f, -0.28142565f, 0.32638770f, 
    -0.07564843f, -0.02262408f, -0.18334617f, 0.09389970f, 0.29818505f, -0.12228851f, -0.00588652f, -0.07115272f, 
    0.20289120f, -0.26013294f, 0.24882084f, 0.82368642f, 0.39371878f, 0.32414293f, 0.05086904f, -0.10585182f, 
    0.33612472f, 0.25366619f, 0.09765974f, 0.05760603f, -0.16461006f, 0.21949665f, 0.10863718f, 0.14142592f, 
    -0.05022619f, -0.14611772f, 0.12383809f, -0.09090903f, 0.04642180f, -0.00776454f, -0.35766932f, 0.19941385f, 
    0.23568505f, -0.10056536f, -0.20167889f, -0.01854573f, -0.98349577f, 0.42118973f, -0.23150189f, -0.37980211f, 
    0.37302011f, -0.07742269f, 0.00535654f, 0.65270305f, 0.18079261f, 0.06892737f, 0.12153666f, -0.04261601f, 
    0.15598111f, -0.40684351f, -0.12876789f, 0.28327960f, 0.20849152f, 0.05469916f, 0.26373312f, 0.00693298f, 
    0.10777625f, -0.03810840f, 0.41973320f, -0.28871825f, -0.53505236f, 0.04999859f, 0.65550119f, 0.16197449f, 
    -0.32137898f, 0.30191740f, 0.00576659f, 0.01262098f, -0.17147559f, 0.12765633f, -0.16393028f, -0.35196224f, 
    0.02990240f, 0.36842442f, -0.24595849f, 0.03546147f, -0.04010032f, 0.02750604f, 0.08286099f, -0.08248480f, 
    -0.32585707f, 0.02640239f, 0.04484718f, -0.10388410f, 0.12348790f, 0.38054776f, -0.40013692f, -0.55542713f, 
    -0.22921771f, 0.36788797f, -0.24547210f, -0.55992848f, -0.16166657f, -0.25025061f, -0.36868688f, -0.13934042f, 
    0.17357393f, 0.08496216f, 0.38756943f, -0.29702517f, -0.13840491f, 0.03802438f, -0.07910463f, -0.10635654f, 
    -0.38203317f, -0.45063353f, 0.26533428f, 0.02572244f, -0.03447526f, 0.23190406f, 0.27857903f, -0.32444549f, 
    -0.31374869f, -0.41915235f, 0.20805928f, 0.57155520f, -0.22111666f, 0.09412254f, 0.06039045f, 0.10468812f, 
    0.20556185f, -0.35957700f, -0.09065805f, -0.22749078f, -0.39806154f, 0.63274419f, 0.03375924f, 0.05327640f, 
    -0.16837409f, -0.03237193f, 0.13012747f, -0.00793893f, -0.46048757f, 0.01810955f, -0.26205406f, -0.25368500f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16582438f, -0.03823543f, 0.13320307f, -0.06825669f, -0.16692632f, -0.01592303f, 0.24561158f, -0.17729174f, 
    -0.28454888f, 0.00532998f, 0.15256743f, -0.21249656f, 0.25805339f, 0.36172396f, -0.07252181f, -0.33697838f, 
    -0.00561548f, 0.47932327f, 0.25864726f, 0.02436279f, -0.03323089f, 0.23855442f, 0.05191690f, -0.09611049f, 
    0.00410054f, -0.23394150f, 0.18739741f, 0.01888333f, -0.01666518f, 0.08964480f, -0.11468625f, 0.22904745f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.35291940f, -0.11998921f, 0.41280672f, -0.20774685f, 0.21688099f, -0.34773165f, 0.02007470f, 0.17306395f, 
    -0.02086166f, 0.09817658f, -0.03063925f, 0.07155390f, -0.40973058f, 0.08552249f, -0.07187645f, -0.09913910f, 
    0.03364056f, -0.02818290f, 0.06705699f, -0.06881814f, -0.13205165f, 0.04462384f, 0.02554739f, 0.05554832f, 
    0.26268777f, 0.16206917f, 0.07249121f, -0.10167435f, 0.22911078f, -0.03447388f, -0.18913423f, -0.05544701f, 
    0.00437926f, 0.04507475f, -0.07367913f, -0.09467051f, -0.00720353f, 0.01368030f, 0.24512441f, 0.09004483f, 
    0.07372233f, 0.10158020f, -0.18118362f, -0.01394562f, -0.07135148f, 0.14072274f, -0.02377100f, -0.11913988f, 
    0.01598998f, 0.02961691f, 0.02220556f, -0.09198100f, 0.10066113f, -0.06320991f, -0.04284519f, -0.00607313f, 
    -0.08121319f, -0.07148586f, -0.20690665f, 0.03419102f, 0.45780149f, 0.26408476f, -0.06876668f, -0.02173488f, 
    0.08566256f, -0.08417752f, 0.00525857f, 0.17809077f, 0.03066260f, 0.10262565f, -0.06527974f, -0.20263290f, 
    0.00812239f, 0.15255153f, -0.09389025f, -0.14954212f, 0.09384972f, -0.00105507f, 0.11811627f, -0.14422192f, 
    0.10921812f, -0.17443171f, 0.06639320f, 0.02428601f, 0.39915368f, 0.07392128f, -0.35333478f, 0.17619801f, 
    0.14289743f, -0.00400564f, -0.06626593f, 0.06007228f, -0.09152175f, -0.03770426f, 0.24801506f, -0.01166809f, 
    0.28329593f, 0.14925867f, 0.13679764f, 0.13836432f, -0.16237421f, 0.00448595f, 0.03955469f, -0.01646272f, 
    -0.03632874f, 0.02144243f, 0.01630050f, -0.03415281f, 0.43623093f, 0.33743736f, 0.08680011f, 0.09152372f, 
    0.25291824f, 0.19013469f, 0.14339627f, 0.15848152f, -0.04145833f, -0.05444152f, 0.01208867f, 0.07585427f, 
    -0.07958660f, -0.18173331f, 0.50519478f, -0.08054607f, 0.17371085f, -0.03841172f, -0.21117602f, 0.12706687f, 
    -0.08508149f, 0.16193213f, 0.10120132f, 0.00104142f, 0.36582848f, 0.26867393f, -0.07999697f, 0.15594648f, 
    -0.00369077f, 0.11883297f, 0.00799163f, 0.03070421f, 0.04082740f, -0.02020460f, 0.08104106f, -0.06452373f, 
    -0.26401779f, 0.13101959f, 0.20454755f, 0.03671131f, 0.25105819f, 0.09415077f, -0.03677493f, -0.08001955f, 
    0.13675396f, -0.03145616f, 0.00733131f, -0.05900046f, -0.05364053f, 0.25969869f, -0.23462717f, 0.16942339f, 
    -0.08859562f, -0.04029346f, -0.03734539f, -0.13404070f, -0.21918201f, 0.01453142f, 0.05795607f, 0.09818358f, 
    -0.04406841f, 0.03401631f, -0.02611467f, -0.11077507f, -0.04466915f, 0.10344560f, -0.17684394f, -0.08862281f, 
    0.02755612f, -0.01513108f, 0.02029990f, 0.03189518f, 0.31659290f, 0.30493212f, 0.16918586f, -0.11878134f, 
    -0.04465572f, 0.20335332f, 0.17438790f, 0.09028351f, 0.03906879f, -0.04193503f, -0.02730337f, 0.00994397f, 
    -0.25693214f, 0.22040294f, -0.12193803f, 0.14947298f, -0.06618401f, -0.03841674f, -0.02608555f, -0.07398530f, 
    -0.09264782f, -0.09066562f, -0.09896790f, 0.03836171f, -0.23648851f, -0.01426159f, 0.16186444f, -0.17099978f, 
    0.05182495f, -0.11897364f, -0.32838494f, -0.10350453f, -0.11582725f, -0.19180997f, 0.11159683f, 0.00959801f, 
    -0.05116252f, 0.16317579f, 0.01939755f, 0.02512584f, -0.15881252f, -0.10628553f, -0.20465660f, -0.15376148f, 
    0.11752094f, 0.02720351f, -0.04574743f, -0.03869073f, -0.00857843f, -0.13668089f, -0.39278623f, -0.06564149f, 
    0.13567767f, 0.09694137f, 0.09048633f, -0.09139388f, -0.02719767f, 0.11243208f, -0.03211020f, 0.09092689f, 
    -0.06007471f, 0.12916774f, -0.01577275f, -0.09072098f, 0.19330828f, -0.08025780f, 0.03003358f, 0.07102174f, 
    -0.04117486f, 0.00522624f, -0.02417991f, 0.09867584f, 0.02968682f, 0.05972919f, 0.09600709f, 0.04576080f, 
    -0.05279559f, 0.01846987f, -0.04227668f, 0.04883847f, 0.05320217f, 0.04299068f, -0.01283040f, -0.06079401f, 
    0.03936005f, -0.16602650f, 0.22210218f, 0.05769630f, 0.05990743f, 0.15069671f, -0.03408450f, 0.14620227f, 
    -0.05878200f, -0.01506572f, 0.01929750f, -0.14758267f, 0.22406121f, -0.07287279f, 0.03482369f, 0.05636869f, 
    0.18652110f, 0.15761441f, 0.09311619f, 0.13277018f, -0.36175713f, -0.03363532f, -0.00592783f, -0.05123525f, 
    0.15140729f, 0.06346820f, -0.21599913f, 0.01451115f, 0.18949899f, -0.04549933f, 0.11205401f, 0.06069119f, 
    -0.02216907f, -0.00870313f, -0.03564761f, 0.02112827f, 0.24540775f, 0.13456412f, 0.21285248f, -0.03811277f, 
    0.00425120f, 0.12922683f, -0.04653838f, -0.02520731f, -0.06961253f, -0.00859654f, -0.09998170f, 0.05699228f, 
    0.06314763f, 0.05743990f, -0.15981357f, -0.05865799f, 0.14847489f, 0.12573712f, 0.07562548f, -0.05037665f, 
    0.16663602f, 0.12304880f, -0.06751613f, 0.03850384f, -0.07015249f, 0.15925799f, 0.07417980f, -0.08380176f, 
    -0.00424262f, 0.15664929f, -0.01380668f, -0.00488237f, -0.21361998f, 0.09080292f, 0.14924532f, -0.02227512f, 
    0.08552183f, 0.01386131f, -0.11110371f, -0.03234158f, 0.01286187f, 0.14179517f, 0.01669704f, -0.12397762f, 
    -0.13123719f, 0.15236278f, 0.07395132f, 0.10224315f, 0.14282466f, -0.11731541f, -0.01337085f, 0.00170730f, 
    0.19642842f, 0.03325629f, -0.17318811f, -0.00564206f, -0.02625295f, 0.02838718f, 0.08354161f, -0.11387272f, 
    0.22935775f, 0.23190750f, 0.01487776f, 0.07549930f, 0.13329108f, -0.04248066f, 0.18878943f, 0.00737413f, 
    0.03730530f, 0.08774439f, 0.06061319f, 0.03909495f, -0.02780007f, 0.02021948f, -0.13289325f, 0.04374403f, 
    -0.09305556f, -0.18692443f, 0.02344554f, -0.08432247f, 0.08229002f, 0.11818229f, -0.08699479f, -0.00325902f, 
    -0.14959858f, 0.26354381f, -0.13009444f, 0.57848370f, 0.36165908f, 0.08925099f, 0.01761420f, -0.05903541f, 
    -0.13233867f, 0.00981320f, -0.16406429f, -0.01152210f, 0.05510791f, -0.17211297f, 0.00433501f, 0.02180816f, 
    -0.06087554f, 0.02219523f, -0.15798184f, -0.03913888f, 0.12668911f, -0.21553206f, -0.06083142f, 0.18745817f, 
    -0.30526540f, 0.12989977f, -0.03344405f, -0.03274905f, 0.16131964f, 0.18429881f, 0.16156676f, 0.06386213f, 
    0.05379228f, 0.05258159f, 0.00365552f, 0.03156548f, 0.07238294f, -0.22596882f, 0.06828205f, 0.31150600f, 
    0.11908361f, 0.14370859f, 0.10272604f, -0.11410077f, 0.12617894f, -0.07801959f, -0.02391009f, -0.07353665f, 
    -0.20739959f, -0.24996233f, 0.02629086f, 0.06872038f, -0.10597075f, -0.11493694f, -0.03121260f, 0.00358599f, 
    0.24580655f, 0.03605243f, 0.11306179f, 0.02496569f, -0.32563922f, -0.00339914f, 0.27809763f, 0.13643798f, 
    0.08041663f, 0.06566407f, 0.01489943f, 0.22290419f, -0.06816290f, 0.05278450f, -0.14922190f, -0.00315188f, 
    0.36357856f, -0.27931476f, 0.19301230f, 0.26309711f, -0.07388987f, -0.02807961f, -0.16105278f, 0.00255151f, 
    -0.07149201f, 0.11815667f, 0.14443456f, 0.13338536f, -0.08761244f, 0.24691071f, 0.23865071f, 0.06115485f, 
    0.01476605f, -0.02361100f, 0.21814573f, 0.23437823f, 0.07143573f, -0.04657990f, 0.03238768f, 0.08753488f, 
    -0.13895494f, 0.28364196f, -0.01469303f, -0.06236753f, 0.10439482f, -0.06902080f, 0.00761876f, 0.18929526f, 
    0.05722349f, 0.09274406f, 0.01860811f, -0.10994997f, -0.37123206f, -0.05889163f, 0.10338888f, -0.05257021f, 
    0.01010511f, -0.08742979f, 0.08426060f, 0.11251604f, -0.13477911f, 0.00065778f, 0.08307766f, 0.22949560f, 
    0.43599209f, -0.07050893f, -0.42685691f, 0.36612260f, 0.09760445f, 0.02404392f, -0.00370052f, -0.02963713f, 
    0.15890172f, -0.03878929f, 0.13887124f, 0.04640423f, -0.02741861f, 0.07601774f, 0.41314518f, 0.14429605f, 
    0.04850027f, 0.04968024f, 0.24100073f, 0.23485440f, 0.02201205f, 0.01885608f, -0.19925381f, -0.14223945f, 
    -0.05800758f, -0.03427614f, -0.17738205f, -0.25825003f, -0.13816245f, -0.04434199f, 0.07671548f, 0.09815051f, 
    -0.02471193f, -0.07056205f, 0.04829177f, 0.22881594f, 0.01959170f, -0.28546900f, 0.17433113f, 0.05015684f, 
    0.23142941f, 0.00030281f, 0.12251598f, 0.03636894f, 0.02435509f, -0.01992509f, 0.21604700f, 0.04608602f, 
    0.17625886f, -0.21449263f, -0.05851467f, -0.10531085f, 0.18928623f, 0.14872096f, -0.01017422f, -0.05866807f, 
    0.11768001f, -0.01758066f, -0.10021941f, -0.12923999f, -0.14978294f, -0.24278668f, 0.00511036f, 0.18441679f, 
    0.14703149f, -0.05423240f, -0.11825069f, 0.12314224f, 0.06641915f, -0.08891549f, 0.12265766f, -0.02339453f, 
    -0.06454808f, -0.18847232f, 0.04478376f, -0.34708720f, -0.06950963f, 0.03279962f, -0.12699221f, 0.03744627f, 
    0.14121832f, -0.10319082f, 0.14998680f, -0.09560389f, 0.44985902f, 0.03035541f, -0.09984586f, 0.39284420f, 
    -0.04893375f, -0.10974488f, 0.04234021f, 0.11749736f, 0.07749861f, 0.16190650f, 0.08261248f, 0.10019772f, 
    -0.14699169f, -0.12477043f, 0.25256208f, 0.02177098f, 0.40920475f, 0.06967109f, 0.17860706f, 0.25853330f, 
    0.15472622f, -0.01477610f, -0.07779762f, 0.08188621f, 0.07420307f, -0.56362730f, 0.32138157f, 0.36046121f, 
    -0.01206299f, -0.13911298f, -0.11880676f, 0.13654779f, 0.15231046f, 0.01667277f, 0.14963111f, -0.00182142f, 
    -0.30958617f, -0.21336845f, 0.07762103f, 0.24622856f, -0.05250704f, 0.04222406f, 0.09263588f, 0.02658191f, 
    0.07412852f, 0.06562078f, 0.15330879f, 0.05589278f, 0.03568061f, 0.37673262f, 0.11123394f, 0.32895738f, 
    0.17405018f, 0.19514722f, 0.11599342f, 0.12115160f, -0.02264585f, -0.01701319f, 0.08291008f, 0.02706252f, 
    -0.00705764f, 0.37783417f, -0.00327128f, 0.38516435f, 0.13715577f, 0.04764640f, 0.06968737f, 0.08292669f, 
    -0.04923400f, 0.05484899f, -0.11822899f, -0.13349235f, -0.25846928f, 0.37934783f, -0.27987170f, -0.00728122f, 
    0.00376264f, 0.03762300f, -0.03878335f, -0.25182432f, 0.26725942f, 0.14102504f, -0.08503623f, -0.14991297f, 
    -0.12356923f, 0.14172046f, 0.43730807f, 0.08055008f, 0.05386728f, -0.05002916f, 0.08356440f, 0.09061931f, 
    0.13451877f, 0.13738136f, -0.03426288f, 0.02845730f, -0.00468225f, 0.01012668f, 0.12815112f, 0.26230717f, 
    -0.01275156f, 0.07991164f, 0.14347020f, 0.09315342f, 0.17353050f, 0.06182833f, -0.08119004f, 0.11327688f, 
    -0.19289649f, -0.27046922f, 0.16195822f, 0.02298568f, 0.06413341f, -0.02046783f, 0.07488719f, 0.26721150f, 
    0.14233762f, -0.08882393f, 0.18325078f, 0.00236104f, -0.20822057f, -0.14188661f, -0.09120966f, 0.13154323f, 
    0.01825455f, -0.04327809f, -0.04104970f, -0.03448002f, 0.23927425f, -0.01117024f, 0.05364034f, 0.08678008f, 
    -0.05823397f, 0.08118184f, -0.17949440f, 0.06528816f, 0.20794450f, -0.25338042f, 0.08677114f, 0.27621889f, 
    0.20798832f, 0.00878509f, 0.29134500f, 0.02698994f, 0.02659257f, 0.14768356f, 0.07224514f, 0.09542473f, 
    0.13695416f, 0.05319327f, -0.14443253f, 0.04044887f, -0.02494661f, -0.06613336f, -0.06038021f, 0.01040668f, 
    0.10035333f, 0.01914658f, 0.11733466f, 0.17744516f, 0.01620525f, 0.15306054f, -0.01184205f, 0.26803839f, 
    0.12022218f, -0.01678012f, -0.06424949f, -0.02347851f, -0.06122207f, -0.07900888f, 0.26644918f, 0.13326208f, 
    -0.00205976f, -0.16970570f, 0.01368469f, 0.13349681f, -0.04496313f, 0.13766660f, -0.01008882f, 0.18314798f, 
    0.03993583f, -0.00254620f, -0.03622704f, 0.03058446f, -0.01742662f, -0.00113221f, -0.03846666f, -0.02028466f, 
    0.01722343f, 0.02432370f, -0.00220700f, -0.04591281f, -0.05533751f, -0.00933956f, -0.02869998f, 0.01605144f, 
    -0.01399034f, -0.03706937f, 0.03119832f, -0.02461458f, -0.04771107f, -0.04452277f, 0.03450254f, 0.01067392f, 
    -0.00538139f, 0.02349864f, 0.04752376f, 0.03218539f, -0.02568315f, -0.03710252f, -0.03047102f, 0.00121841f, 
    0.02821374f, -0.02353578f, 0.04979724f, 0.01751786f, -0.01270318f, 0.00272597f, 0.00453767f, -0.01545584f, 
    -0.05263516f, -0.03894957f, -0.02973859f, 0.01073428f, -0.02037168f, -0.00524087f, 0.03307511f, 0.01685958f, 
    -0.02118271f, 0.00273931f, 0.01975220f, -0.03698264f, -0.04812356f, 0.01425675f, 0.01724850f, -0.04762882f, 
    -0.02267741f, -0.04331884f, -0.04025165f, -0.01411672f, 0.00074158f, -0.00259653f, 0.03683841f, 0.03143485f, 
    -0.04571801f, -0.03431982f, 0.01421717f, -0.01521102f, 0.02399650f, 0.04340003f, -0.01235813f, -0.03752333f, 
    -0.01428312f, 0.02953724f, -0.02116991f, 0.00257373f, -0.04706455f, -0.00503609f, 0.04051777f, 0.04730203f, 
    -0.01531730f, -0.00507976f, -0.05068116f, -0.02592184f, -0.01982988f, -0.02253042f, 0.04119208f, 0.00702256f, 
    -0.02593768f, -0.04695462f, 0.00553016f, -0.00448631f, 0.00592895f, -0.00150719f, 0.03516101f, -0.04157948f, 
    -0.02015325f, -0.03182692f, -0.05446561f, -0.04052906f, 0.03889924f, -0.04955904f, 0.03082720f, 0.03159483f, 
    -0.00559248f, -0.00523214f, -0.02240853f, -0.03774751f, 0.02255673f, -0.01358754f, -0.02503330f, -0.01349995f, 
    -0.00534081f, -0.03729643f, -0.02107458f, 0.04642410f, 0.00380661f, 0.00089846f, 0.01598676f, -0.00894217f, 
    0.00307712f, -0.05084755f, 0.02670738f, -0.03794349f, 0.01229711f, -0.03397079f, 0.00025246f, -0.03169149f, 
    0.03849609f, 0.01308615f, -0.01847743f, 0.02006696f, 0.02673208f, -0.02027025f, 0.02421928f, -0.00481284f, 
    0.03003244f, -0.00823840f, -0.04587248f, -0.02211299f, -0.03230706f, -0.00838347f, 0.01895088f, -0.03895031f, 
    -0.03167553f, -0.01353492f, -0.02818660f, -0.00821740f, 0.00002647f, 0.02204267f, 0.04642795f, -0.03729246f, 
    0.00941455f, 0.02629882f, -0.01061753f, 0.03165620f, -0.04518229f, -0.02401106f, -0.04591800f, -0.05508344f, 
    -0.00669042f, 0.03517526f, 0.02238223f, -0.03866924f, -0.00404091f, 0.03684249f, 0.04374484f, -0.04750622f, 
    0.00374827f, 0.02595610f, 0.02611600f, -0.03259386f, -0.00846942f, 0.02845273f, 0.03999031f, 0.04915226f, 
    -0.02740312f, -0.04552291f, 0.02731551f, 0.04962048f, 0.01717677f, -0.02258322f, -0.01431811f, -0.03740249f, 
    -0.03679509f, 0.02385519f, 0.03833780f, -0.01025009f, 0.02407425f, 0.03093999f, -0.02076681f, 0.03651620f, 
    0.01874853f, -0.04326217f, -0.02466149f, 0.03332821f, 0.02068016f, 0.01691976f, -0.02945435f, 0.02345905f, 
    0.00027152f, -0.04690510f, 0.02888760f, 0.03870880f, -0.01591481f, 0.02507426f, -0.00134704f, -0.00535845f, 
    -0.05674957f, -0.03157054f, -0.02312299f, 0.03968444f, -0.01865514f, -0.01063589f, 0.02128702f, -0.02917941f, 
    -0.02643832f, -0.05803774f, -0.02867483f, -0.03949504f, -0.02360342f, -0.05020903f, 0.01112745f, -0.00524319f, 
    -0.01025191f, -0.01963823f, 0.03922336f, -0.04257282f, -0.05164189f, 0.03042018f, 0.02666730f, -0.02172892f, 
    -0.02875616f, 0.03048782f, -0.03936239f, -0.00992190f, 0.03164852f, -0.02290957f, -0.05948776f, -0.05023469f, 
    0.01827456f, 0.00610912f, -0.00458466f, 0.00714360f, 0.01607219f, 0.02877341f, -0.04925754f, -0.01309207f, 
    -0.00356649f, -0.05096045f, 0.03382910f, 0.03387025f, -0.03473014f, 0.04006397f, -0.04225373f, -0.04071447f, 
    -0.02958933f, -0.05880648f, -0.02713008f, -0.00509258f, 0.03820717f, 0.00155736f, 0.03124194f, -0.01199606f, 
    -0.01737608f, 0.00081729f, 0.01073822f, -0.05108320f, 0.03324174f, -0.03735029f, -0.00951549f, -0.02528418f, 
    -0.01707700f, -0.02745507f, -0.05381889f, -0.02602714f, 0.04390598f, -0.00738275f, -0.01114232f, 0.03500508f, 
    0.00442972f, 0.00334352f, 0.03086340f, -0.01153600f, -0.00365783f, -0.03209037f, -0.02343906f, -0.04011859f, 
    0.02029765f, 0.01378927f, -0.04011892f, 0.00480590f, -0.04622987f, 0.00592150f, -0.05331845f, -0.01253660f, 
    -0.04863112f, 0.02161484f, -0.05544483f, 0.00152553f, -0.03811494f, 0.02363329f, 0.04135924f, -0.03585075f, 
    0.02281018f, -0.02041283f, -0.01929902f, 0.03461762f, 0.00296142f, 0.04303005f, 0.04726255f, 0.00971694f, 
    -0.05695090f, 0.01447803f, 0.00743663f, 0.01510749f, 0.01452089f, -0.04227421f, -0.03807651f, 0.01067527f, 
    0.02049451f, -0.01148408f, 0.00751497f, -0.05649699f, -0.05140683f, -0.04213402f, 0.00611574f, 0.03446714f, 
    -0.01474646f, -0.03769147f, -0.04381457f, 0.03647658f, -0.05004245f, -0.03709646f, 0.01465242f, -0.05001633f, 
    -0.02545395f, -0.05950352f, -0.04948508f, 0.03224526f, 0.04617677f, -0.02052359f, -0.04101019f, -0.00890468f, 
    -0.01172073f, -0.03712231f, 0.04736212f, 0.01484687f, -0.03455873f, -0.02783888f, -0.00257447f, 0.02377899f, 
    0.04557429f, -0.01303856f, -0.02676828f, -0.04982346f, 0.00899592f, 0.04445694f, -0.00907313f, -0.04649255f, 
    -0.02304845f, 0.00740400f, -0.05280884f, -0.05005842f, 0.03472520f, 0.01453981f, -0.04227124f, -0.03677687f, 
    0.03656002f, -0.04776727f, 0.01652088f, -0.04259498f, 0.01716759f, -0.02058657f, 0.01992743f, 0.03117801f, 
    -0.00659827f, 0.01060486f, -0.04476437f, 0.00970579f, 0.01636485f, 0.01400145f, 0.03832697f, 0.03529980f, 
    0.02167312f, -0.04123057f, 0.04338353f, 0.01701056f, -0.02577855f, -0.02292869f, 0.02016506f, -0.00953838f, 
    0.03806804f, 0.03836739f, -0.02668800f, -0.03093796f, -0.00382983f, 0.00603029f, 0.00399162f, 0.02041820f, 
    -0.00499365f, 0.01818875f, -0.04025051f, -0.03956748f, -0.04187139f, 0.00302312f, -0.01248324f, -0.01988486f, 
    0.02505026f, -0.02537454f, 0.02953795f, -0.04310872f, 0.00831551f, -0.01232184f, -0.03169939f, -0.03798375f, 
    -0.03347567f, 0.03184222f, -0.03328365f, 0.03145283f, 0.02403453f, 0.02819526f, 0.01555930f, -0.00169931f, 
    0.03627674f, -0.01028958f, -0.02887710f, 0.00572594f, -0.02811536f, -0.00275982f, 0.00656293f, -0.03239398f, 
    -0.02160038f, -0.01312867f, 0.01045320f, 0.02999384f, -0.02188595f, -0.00907674f, 0.01362164f, -0.02383195f, 
    -0.04474022f, -0.02702546f, -0.05425074f, 0.03224054f, -0.05573785f, -0.05092705f, -0.05201828f, 0.03960377f, 
    0.03021038f, -0.03859240f, 0.01874919f, 0.02418042f, 0.03498731f, -0.02496310f, -0.03492455f, 0.00479275f, 
    0.00530041f, -0.02558957f, 0.01564498f, -0.01423150f, 0.02762826f, -0.00400917f, -0.04359414f, -0.05508545f, 
    -0.01738807f, 0.00431156f, 0.01459420f, 0.02469484f, -0.04998590f, -0.00466848f, -0.01765774f, -0.04881261f, 
    -0.04030705f, 0.05081024f, 0.02372140f, 0.02728318f, -0.02481377f, 0.01972474f, -0.02507552f, 0.00064598f, 
    -0.00423504f, 0.00214023f, -0.01441028f, 0.00631345f, -0.03052397f, -0.02009829f, -0.02480474f, -0.00091655f, 
    -0.02399896f, 0.02188599f, -0.04023342f, -0.03403874f, 0.01417913f, 0.01561062f, -0.03637193f, 0.02290688f, 
    0.03550163f, 0.03763474f, -0.04318365f, 0.00210029f, -0.01765592f, 0.01023387f, -0.04749091f, 0.04142585f, 
    0.01525963f, 0.03921654f, 0.02435936f, -0.01892773f, 0.01965609f, 0.00715436f, 0.04308695f, -0.03086318f, 
    -0.04182411f, -0.02055747f, -0.00118404f, -0.02670043f, 0.00050224f, 0.01285522f, -0.04063266f, 0.04043133f, 
    0.04370677f, -0.00831216f, -0.01829397f, -0.00604948f, -0.01351264f, -0.00350976f, -0.05187151f, 0.03047816f, 
    0.01936631f, -0.03794847f, 0.01595249f, -0.00948589f, 0.01732098f, -0.00337583f, -0.03127557f, -0.03385241f, 
    -0.04264889f, 0.04013570f, -0.05476626f, 0.01112985f, -0.00855326f, -0.02879738f, -0.03244922f, -0.00863058f, 
    -0.00869404f, -0.05104729f, -0.04236070f, 0.03843288f, 0.04507280f, -0.05079067f, 0.03645442f, -0.02280365f, 
    0.00851252f, -0.05119305f, 0.00247984f, 0.04467033f, -0.04954320f, 0.03365643f, -0.02452108f, -0.04828050f, 
    -0.04655812f, 0.00112230f, -0.03963938f, 0.03718809f, 0.03128803f, -0.00035801f, 0.04580952f, -0.01746120f, 
    -0.04698245f, 0.02376920f, -0.05656388f, -0.05607468f, 0.01991643f, 0.04488023f, 0.00990298f, -0.04099197f, 
    -0.00718123f, 0.00209037f, -0.02244547f, 0.02627377f, 0.03065273f, 0.00335296f, 0.00659761f, 0.00468313f, 
    -0.03668372f, -0.02076815f, -0.02724971f, 0.00869340f, -0.01506176f, -0.04762907f, 0.02340358f, -0.01074906f, 
    0.00776469f, -0.02258229f, -0.01086560f, 0.01456146f, 0.04386940f, -0.04655372f, -0.00132325f, -0.00552879f, 
    -0.03767755f, -0.01512606f, 0.02512334f, -0.03789220f, -0.02138337f, -0.01713680f, 0.01258082f, -0.05056465f, 
    0.00413129f, -0.03815522f, 0.03183255f, 0.00087172f, 0.00682708f, 0.01153712f, -0.00647822f, -0.02295289f, 
    -0.04241184f, -0.04887256f, -0.01046045f, -0.02709395f, 0.00462558f, -0.05006409f, 0.02602116f, -0.01865173f, 
    0.02925281f, 0.02942591f, -0.04591280f, -0.03095845f, -0.04293357f, 0.02556035f, -0.00808644f, -0.04488495f, 
    -0.01615890f, 0.02423887f, 0.03283375f, -0.03809119f, -0.01019512f, 0.00599969f, 0.02566637f, 0.00106592f, 
    -0.00160959f, 0.00844398f, -0.04826660f, -0.01547674f, 0.02249719f, 0.01041181f, 0.03489678f, -0.00876289f, 
    -0.01040585f, 0.02687640f, -0.01696529f, 0.01523402f, -0.04702262f, -0.03931523f, 0.04289995f, 0.01862472f, 
    -0.01436680f, -0.04653895f, -0.03559314f, -0.03379484f, 0.00010638f, -0.02714701f, 0.03687352f, 0.00690660f, 
    -0.01530665f, -0.05412366f, -0.03995177f, 0.01463584f, 0.04504813f, -0.05443054f, -0.05556663f, 0.00572436f, 
    -0.01063178f, -0.04496991f, -0.03135376f, 0.01408207f, 0.01850761f, -0.01665060f, 0.04951148f, 0.02884653f, 
    0.03543410f, 0.00222779f, -0.00714878f, 0.03116029f, -0.02576432f, 0.04402167f, -0.04030810f, -0.04600424f, 
    -0.00164875f, 0.01874934f, -0.04136657f, 0.00607377f, -0.00128626f, -0.03518657f, 0.00650585f, -0.01712702f, 
    0.01965723f, -0.02474173f, -0.01781099f, 0.01200843f, -0.03535709f, -0.04396842f, 0.03625284f, -0.05519306f, 
    0.04320468f, 0.01603477f, -0.02451003f, -0.04459462f, 0.04170672f, 0.00008403f, 0.00343117f, -0.02748010f, 
    0.00695624f, -0.01657725f, -0.01003709f, -0.03839678f, -0.04507623f, 0.00123102f, -0.04481957f, -0.00845798f, 
    -0.00976529f, 0.01932187f, -0.01847012f, -0.00747594f, 0.04022421f, 0.03444317f, 0.02137246f, 0.03051487f, 
    0.02912867f, -0.00763725f, -0.02822501f, 0.00778245f, 0.01770543f, 0.03744632f, 0.01725286f, -0.00103742f, 
    -0.04034222f, 0.01631157f, -0.02321490f, -0.02326716f, 0.00631101f, 0.03153441f, 0.00741726f, -0.03348123f, 
    -0.03004997f, -0.01520876f, -0.01181740f, 0.04777674f, -0.03012888f, 0.01518294f, 0.03772237f, 0.03705956f, 
    0.03284244f, -0.04710301f, -0.03433277f, -0.00645487f, -0.04193137f, -0.03518000f, -0.01306114f, -0.03511582f, 
    -0.01633664f, -0.04260346f, -0.03062869f, -0.02138456f, -0.01732103f, -0.04377965f, -0.05571777f, 0.04408254f, 
    0.31273261f, -0.47661284f, -0.05798019f, -0.00631994f, 0.26939434f, 0.02319707f, -0.02938635f, 0.28784272f, 
    0.10575625f, -0.03577282f, 0.08589234f, 0.18229693f, 0.02817242f, -0.01604595f, -0.24996093f, 0.02599831f, 
    -0.07218654f, -0.17938864f, -0.06180413f, -0.03207793f, 0.07786524f, 0.01057780f, 0.02377971f, -0.02772367f, 
    -0.15159667f, 0.12608197f, 0.12665097f, 0.04343921f, 0.32491887f, 0.03530394f, 0.07188390f, 0.40242651f, 
    0.14168362f, 0.15954366f, 0.05598906f, 0.02954370f, -0.00089851f, 0.02210858f, 0.28721294f, -0.13483943f, 
    -0.18041688f, -0.12336115f, -0.23992811f, 0.04962642f, -0.15404001f, -0.06596734f, 0.04050105f, 0.05918581f, 
    0.10253644f, 0.00352333f, -0.13275564f, -0.12878612f, -0.04470507f, -0.07608348f, -0.13167296f, 0.03004792f, 
    -0.04852759f, 0.03051291f, 0.17927289f, -0.17830925f, 0.16204029f, -0.42130402f, 0.16520892f, 0.31652287f, 
    0.13296393f, -0.18229631f, 0.05739987f, 0.14067365f, 0.20061283f, -0.02655219f, 0.07377727f, 0.10037673f, 
    -0.07659926f, -0.10919397f, -0.19385728f, -0.10970912f, -0.10353021f, -0.21326606f, 0.03463925f, 0.16481674f, 
    0.01696186f, 0.11423912f, 0.10285940f, 0.15745249f, -0.03018107f, -0.04476560f, -0.31305155f, -0.18350795f, 
    -0.06380973f, 0.18769155f, 0.00965367f, -0.04814254f, 0.04884747f, 0.00342564f, -0.21225582f, -0.02479345f, 
    -0.07146733f, -0.05821705f, 0.41381577f, -0.30416405f, -0.05142159f, -0.11451250f, 0.05737294f, -0.08625839f, 
    0.06098593f, -0.07671963f, 0.09950648f, -0.27109465f, -0.21779487f, 0.01879984f, 0.38735121f, 0.16822068f, 
    -0.12441514f, -0.20920086f, 0.15976055f, -0.00584900f, 0.07103738f, -0.04054225f, -0.09614822f, -0.12067992f, 
    0.06375419f, -0.03929001f, 0.27158436f, 0.03386404f, 0.05557822f, -0.02189822f, -0.12035243f, -0.05221272f, 
    -0.15530849f, -0.02935996f, 0.05114281f, 0.10963555f, 0.00460715f, -0.19665739f, -0.28466448f, -0.07737454f, 
    0.11651466f, 0.05999722f, 0.08515415f, -0.08746532f, 0.02319462f, 0.04820638f, -0.06581850f, -0.03940127f, 
    0.02412226f, 0.00865596f, 0.06891527f, 0.13893069f, 0.10394195f, 0.13024780f, 0.01109450f, 0.22925021f, 
    0.09341657f, 0.19572251f, 0.20029011f, 0.01607401f, 0.30119020f, 0.28625095f, -0.09776341f, 0.05050400f, 
    -0.10734145f, 0.03504985f, 0.02187540f, 0.12192363f, 0.24119768f, 0.11529654f, 0.14786953f, 0.18627235f, 
    -0.07267591f, -0.10358740f, 0.11019085f, -0.19877346f, -0.04529104f, -0.13592438f, -0.03504306f, 0.14699875f, 
    0.06539278f, 0.07455120f, 0.08937182f, 0.03324070f, -0.64265025f, 0.07123893f, -0.05200538f, -0.07626260f, 
    0.11708885f, 0.00537234f, 0.11918138f, -0.00531589f, 0.05900704f, 0.06453823f, 0.11247932f, -0.08850044f, 
    0.00306169f, -0.10963164f, -0.06715618f, -0.03794393f, -0.02064316f, -0.05691858f, -0.02589883f, -0.01206771f, 
    -0.00589977f, 0.08332162f, -0.08422454f, 0.02094701f, 0.22217222f, -0.08405071f, 0.09459042f, -0.05215206f, 
    0.32834744f, -0.02998018f, 0.00969099f, 0.17085075f, 0.05715971f, -0.01903369f, 0.10371748f, 0.09948114f, 
    0.05855300f, 0.12443864f, 0.06718533f, 0.16329713f, 0.03765081f, 0.10601997f, -0.06754707f, 0.09207109f, 
    0.09887456f, 0.05919913f, 0.02335068f, 0.19105843f, -0.48162752f, -0.25861707f, 0.13267364f, 0.12273127f, 
    -0.11043771f, -0.14076300f, 0.02748536f, 0.10823935f, 0.10837282f, 0.00062830f, 0.01708435f, 0.00924688f, 
    -0.14214359f, 0.04192766f, 0.07557449f, 0.22721998f, -0.00386279f, -0.07410873f, -0.12439193f, 0.09404023f, 
    -0.03020244f, -0.06030838f, 0.14911881f, 0.04199441f, -0.21026659f, -0.08278854f, -0.11183305f, -0.33013535f, 
    -0.03030950f, 0.08969034f, 0.07830887f, -0.30232155f, 0.11209144f, -0.02853377f, -0.04445619f, 0.15392441f, 
    -0.07962207f, -0.19544742f, 0.06324323f, -0.51351267f, 0.20185387f, 0.06941946f, 0.02736710f, -0.16032760f, 
    0.11695858f, 0.00485177f, 0.00399587f, -0.03248467f, -0.17563678f, -0.32140249f, -0.21419518f, 0.05483404f, 
    -0.09034126f, -0.17109822f, -0.05778003f, 0.11361215f, 0.51198626f, -0.02323774f, -0.09089456f, 0.00510817f, 
    -0.17778982f, -0.63838404f, -0.13663673f, 0.13995205f, 0.06601124f, -0.10581912f, 0.01532159f, -0.05332842f, 
    -0.10934692f, -0.17936403f, 0.02125408f, -0.05916186f, -0.15949175f, -0.28136966f, 0.40322483f, 0.01216862f, 
    -0.05107589f, 0.11178378f, 0.02913889f, -0.00332814f, 0.12021682f, -0.00101633f, -0.05426271f, -0.01263346f, 
    -0.56201661f, 0.04717333f, 0.37691477f, 0.38522473f, -0.19377178f, 0.10140998f, -0.03752470f, -0.03270188f, 
    0.05791277f, 0.03322510f, 0.07017025f, 0.08140408f, 0.09741372f, 0.07381997f, 0.02110969f, -0.09404051f, 
    -0.10450440f, -0.01120393f, -0.06923884f, 0.05122108f, -0.05686010f, -0.00161088f, 0.02015496f, -0.06277074f, 
    -0.40809008f, -0.10688913f, -0.17615518f, 0.03417196f, -0.00124980f, 0.00624356f, -0.01090485f, 0.06871417f, 
    0.19103619f, 0.00265940f, 0.16581158f, 0.01357034f, 0.04926752f, -0.19075513f, 0.10435240f, -0.17992167f, 
    -0.08504905f, 0.05487759f, -0.07994148f, 0.09219515f, 0.03029316f, 0.15106915f, 0.03861661f, 0.10472423f, 
    0.08841520f, -0.24379463f, -0.18312018f, -0.23799829f, 0.02701900f, 0.03687689f, 0.11859589f, 0.00531477f, 
    0.04681316f, 0.00025901f, -0.01514567f, -0.13093826f, 0.11120646f, -0.12966675f, 0.10687790f, 0.32849914f, 
    0.05941472f, 0.09136654f, 0.14233655f, 0.17724711f, 0.20417014f, 0.10675617f, 0.06951699f, 0.02417280f, 
    0.02962311f, 0.03232204f, 0.03718983f, -0.00630956f, 0.01907071f, -0.03907132f, 0.03254114f, -0.03436725f, 
    -0.04479451f, -0.05306135f, -0.02502057f, -0.02741783f, -0.00110664f, -0.00715276f, 0.00799440f, -0.02497813f, 
    -0.05630042f, 0.04428613f, -0.02607932f, 0.03235248f, -0.05181971f, -0.02854548f, -0.05394916f, -0.00568466f, 
    0.02292863f, 0.04300136f, 0.01827754f, -0.02633289f, 0.01843052f, 0.02554406f, 0.01469455f, 0.03661200f, 
    -0.02066169f, -0.01566969f, -0.04508936f, 0.00388288f, -0.04277072f, -0.00967194f, 0.02844520f, 0.01719113f, 
    -0.03439785f, 0.01030200f, -0.05028313f, -0.02316869f, 0.02738732f, -0.04063363f, -0.03767252f, -0.03428129f, 
    -0.04209986f, -0.04714499f, -0.01103931f, -0.05018746f, -0.00789467f, -0.02702225f, 0.03511075f, 0.00720435f, 
    0.02276687f, 0.01097086f, 0.02213922f, 0.02464837f, -0.05130883f, -0.03818734f, 0.00689603f, -0.04843475f, 
    0.02562345f, 0.02180598f, -0.01437716f, 0.04319559f, -0.01514213f, -0.02943214f, -0.04262713f, -0.01763308f, 
    -0.00554771f, -0.04206992f, 0.00911245f, -0.03107727f, -0.01884721f, -0.03528229f, 0.00844979f, 0.04935865f, 
    -0.01727341f, -0.04690120f, -0.03276579f, -0.00597720f, -0.01113997f, 0.03595792f, -0.01277803f, -0.05255216f, 
    0.03313561f, 0.00604516f, 0.02464904f, -0.04460781f, -0.03115943f, 0.03322536f, -0.02295507f, 0.04638324f, 
    0.01023339f, 0.01133703f, -0.02299734f, 0.02316846f, 0.03397274f, -0.03808215f, -0.03719918f, -0.01351421f, 
    0.00532197f, 0.02816552f, -0.04520638f, 0.00597737f, -0.02074726f, 0.03251409f, 0.00028152f, 0.01783483f, 
    0.03847773f, -0.02042424f, -0.04367957f, -0.00755025f, -0.02053809f, -0.01635983f, -0.04662240f, 0.01906569f, 
    -0.04197869f, 0.00853946f, 0.01386738f, -0.03537794f, 0.01767175f, 0.00105828f, 0.03296565f, -0.00343784f, 
    0.03096731f, 0.00404250f, -0.00823654f, -0.00098353f, -0.01026619f, 0.01372018f, -0.03774048f, 0.03707059f, 
    0.00064269f, 0.01395539f, 0.01591163f, 0.01434506f, -0.04598401f, -0.01597695f, 0.01467461f, 0.01401045f, 
    -0.00690295f, 0.01404482f, 0.01473950f, 0.02282964f, -0.02532301f, 0.01608853f, 0.03473463f, 0.03885390f, 
    -0.01573989f, 0.02763115f, -0.04055073f, 0.00069330f, 0.02788827f, 0.00060232f, 0.00960057f, 0.00417727f, 
    0.04287615f, -0.04436320f, 0.00073565f, -0.04708087f, 0.00457951f, -0.01741247f, 0.01068503f, -0.01319011f, 
    0.04424324f, -0.03537987f, -0.02195224f, 0.01514468f, -0.04881942f, -0.03674342f, -0.01615701f, -0.00813550f, 
    -0.02258207f, -0.00841014f, 0.00996257f, -0.00939439f, 0.01006547f, -0.00404654f, -0.00901555f, 0.03841217f, 
    -0.01957261f, -0.00118595f, -0.02528992f, -0.04893630f, -0.02180154f, -0.01905038f, -0.01761084f, 0.03702825f, 
    -0.05258466f, 0.04748574f, -0.03676715f, 0.03164776f, 0.02823322f, -0.04206752f, -0.05416192f, 0.03397396f, 
    -0.03437918f, 0.04851677f, -0.00953106f, -0.01381024f, -0.02335123f, -0.03528657f, -0.00268902f, -0.02097063f, 
    0.00476441f, 0.03722654f, 0.04006943f, 0.04376717f, 0.00761398f, -0.05430314f, -0.02484125f, -0.01624956f, 
    0.02086044f, -0.04858912f, -0.04761812f, -0.03355826f, 0.04086933f, -0.01380030f, -0.03394971f, 0.04448434f, 
    -0.00157046f, 0.03407840f, -0.01070821f, 0.01680660f, -0.01859577f, 0.02271792f, 0.02438860f, -0.01814979f, 
    0.02616752f, -0.01644306f, -0.03100973f, 0.02585641f, -0.02337930f, -0.03934574f, 0.00724148f, -0.02609031f, 
    -0.01159421f, -0.04031328f, 0.03314593f, -0.00858138f, 0.03269006f, -0.02265089f, -0.00315413f, -0.00179051f, 
    0.03875982f, 0.02867319f, 0.01939812f, -0.04003375f, 0.03453968f, -0.02387708f, -0.01513214f, 0.02281300f, 
    0.02043398f, -0.04962826f, -0.04528500f, 0.02872881f, -0.02036591f, -0.02766600f, 0.01392516f, 0.02259696f, 
    -0.03890228f, -0.03462537f, -0.02324115f, 0.00451503f, -0.03260249f, 0.00580351f, -0.01231367f, -0.01652290f, 
    0.04176812f, 0.02043560f, 0.02510457f, -0.03719219f, -0.03120407f, 0.02011492f, 0.00753026f, 0.02111379f, 
    -0.04076254f, -0.03862588f, 0.02922429f, -0.04622442f, -0.04608719f, 0.03024562f, -0.01448702f, 0.03298874f, 
    -0.02116620f, -0.00641393f, -0.04480435f, -0.03151276f, -0.02442772f, -0.03975999f, 0.02339090f, -0.01578711f, 
    0.04034513f, -0.03592873f, -0.04805977f, -0.01951166f, -0.01420276f, -0.02312357f, -0.04522397f, -0.05248587f, 
    0.02899555f, 0.02307903f, -0.01838596f, -0.04408973f, -0.05130937f, -0.00854179f, 0.02769041f, 0.04109216f, 
    0.02749554f, 0.01820511f, -0.03624688f, 0.03421666f, 0.01996431f, -0.00366079f, 0.02902828f, 0.02969888f, 
    -0.01696533f, 0.01562675f, -0.05038690f, 0.01179611f, -0.01205700f, -0.03296134f, -0.01994575f, 0.00599219f, 
    -0.03977571f, -0.04252002f, 0.01325843f, -0.01949720f, -0.00971055f, 0.00786411f, -0.03260732f, -0.04261615f, 
    -0.03394261f, 0.00093616f, 0.00423278f, 0.03171242f, -0.00467528f, 0.04359422f, -0.04520581f, -0.01517626f, 
    0.04690293f, -0.02101535f, 0.03147096f, -0.03304401f, 0.00760042f, -0.03629195f, -0.05093045f, 0.03476341f, 
    0.00742441f, 0.03728326f, 0.02686197f, -0.00670577f, 0.02548126f, -0.03366204f, 0.00952554f, -0.02501827f, 
    -0.02777109f, -0.04845110f, 0.00989718f, 0.02710815f, 0.03818070f, 0.01155858f, -0.01155024f, 0.04344802f, 
    -0.03270984f, 0.03355294f, 0.02978897f, 0.03739559f, 0.00633434f, 0.01008669f, -0.00925204f, 0.04195117f, 
    0.03405444f, -0.00726511f, -0.05399093f, 0.00098761f, 0.03873809f, -0.00011319f, 0.01510372f, 0.03874120f, 
    0.04601639f, -0.05510305f, 0.00731776f, 0.02485067f, -0.00749033f, 0.04409232f, 0.04075813f, 0.04342983f, 
    -0.01790644f, -0.04852855f, -0.04565394f, -0.00335247f, 0.01344276f, -0.05097269f, 0.03849716f, -0.00057157f, 
    -0.02308028f, -0.03034877f, -0.05110472f, -0.00272852f, 0.02652099f, -0.03009344f, -0.03437794f, -0.01245871f, 
    0.03779864f, -0.05304948f, 0.00678254f, 0.01802228f, 0.01162011f, -0.01387580f, 0.00619937f, -0.04575931f, 
    0.01359923f, 0.03716567f, -0.01580428f, -0.03443664f, 0.03353198f, -0.00615579f, -0.00560335f, -0.03588540f, 
    0.00030485f, 0.03501116f, 0.03044530f, 0.00498282f, -0.03293890f, -0.00077198f, -0.02555802f, 0.01237996f, 
    -0.02296026f, -0.02066751f, 0.03479596f, -0.03820244f, -0.01244960f, 0.00138272f, 0.00580963f, 0.04916485f, 
    -0.04351906f, 0.02218314f, 0.01940920f, 0.02953206f, 0.00413954f, -0.03082959f, 0.03769292f, 0.02689593f, 
    -0.04991617f, -0.01033591f, -0.03097979f, 0.00100515f, 0.00901026f, -0.02069714f, -0.01886590f, -0.02252673f, 
    0.04111490f, -0.04152846f, -0.00963548f, 0.02665971f, -0.03479555f, 0.04343839f, 0.00897506f, -0.01769819f, 
    -0.05455984f, 0.03889454f, -0.01620485f, -0.03997713f, -0.05104354f, -0.04197247f, -0.05121657f, -0.04535570f, 
    0.00208570f, 0.03470483f, 0.02929516f, -0.02477807f, -0.00992579f, -0.03669872f, -0.05302471f, -0.01137967f, 
    -0.03925075f, -0.02695301f, 0.02931175f, 0.02813482f, -0.01810125f, -0.00361986f, -0.00026209f, -0.05267234f, 
    0.01629972f, -0.00752750f, -0.01300789f, 0.01610110f, -0.03181996f, -0.04383402f, 0.02910216f, -0.05370151f, 
    -0.03395242f, -0.00499266f, -0.00064170f, -0.02952738f, -0.05668323f, -0.01554553f, 0.03311505f, 0.01361251f, 
    0.00988795f, -0.00187872f, 0.00285929f, -0.02437173f, 0.01708686f, -0.00103925f, -0.01323515f, -0.04463901f, 
    0.03623248f, -0.00632094f, 0.02304134f, -0.01558916f, -0.00813721f, -0.02537443f, 0.04252709f, -0.00648376f, 
    0.01028169f, -0.04711979f, -0.02636196f, -0.05685394f, 0.00659930f, 0.02086253f, -0.04579620f, 0.04431453f, 
    -0.01248401f, 0.02762412f, 0.00967563f, 0.00272998f, -0.03625639f, -0.04054702f, -0.01261511f, 0.03547111f, 
    -0.03318469f, -0.03809190f, -0.00719365f, -0.02667803f, 0.03484763f, 0.01505928f, 0.01223815f, -0.02576716f, 
    0.03058652f, -0.00201701f, 0.02418197f, -0.02294771f, -0.05463000f, -0.02558571f, 0.00460499f, -0.04011028f, 
    -0.01080449f, -0.02690586f, 0.01919783f, -0.00213402f, 0.02539321f, 0.00814187f, -0.04928762f, -0.00155423f, 
    -0.00828623f, 0.01402272f, -0.01464273f, -0.02604714f, 0.03769643f, -0.03279187f, -0.02541155f, -0.03197943f, 
    -0.02455139f, -0.01238721f, -0.04489223f, -0.04028003f, -0.01085314f, -0.04949191f, -0.03264157f, -0.04338720f, 
    -0.03814618f, 0.02508132f, -0.03213116f, -0.03434145f, -0.01333712f, 0.04161900f, -0.04328244f, -0.05156966f, 
    -0.05132343f, -0.04291281f, -0.02839425f, -0.02038741f, 0.02060689f, -0.01897649f, 0.01675419f, 0.04375727f, 
    -0.03001538f, 0.02024039f, -0.03535946f, 0.02267389f, 0.03275479f, -0.03774087f, 0.02906227f, -0.01324644f, 
    0.00997260f, -0.00536982f, -0.01166314f, 0.01762799f, -0.02936605f, -0.03738299f, 0.03309817f, 0.03645498f, 
    -0.01533878f, 0.01212660f, 0.02031749f, 0.00861605f, -0.00532735f, 0.00764268f, -0.04993995f, 0.02500102f, 
    -0.03724833f, 0.03529146f, 0.04539519f, -0.00921753f, -0.05568963f, -0.00879708f, -0.02399968f, 0.03346371f, 
    0.02186544f, -0.02211427f, 0.00975738f, -0.03586208f, 0.00415539f, -0.02093172f, 0.00257561f, -0.02618285f, 
    0.03448762f, -0.04636618f, 0.04150667f, -0.01901267f, 0.01806614f, 0.03381063f, -0.01587767f, -0.03226002f, 
    -0.01877913f, 0.00227216f, 0.00095685f, 0.00114599f, -0.05087066f, 0.03065170f, -0.01983665f, -0.01053604f, 
    -0.01827641f, -0.01936997f, -0.00408172f, 0.01363250f, 0.01879315f, -0.00443741f, -0.02835989f, 0.03168243f, 
    -0.04023726f, 0.00378046f, 0.03951630f, 0.02261216f, -0.01360064f, -0.00891458f, 0.02903987f, -0.00614760f, 
    0.00108829f, 0.03225616f, 0.04286641f, 0.02570572f, 0.00624411f, -0.03123740f, -0.01057498f, -0.04174458f, 
    -0.01380760f, 0.00955112f, 0.01326389f, 0.01506991f, -0.05629548f, -0.04842481f, 0.02022175f, 0.03828512f, 
    -0.02342511f, -0.04818520f, 0.01451272f, 0.01914414f, 0.02693082f, -0.01439084f, 0.02697847f, -0.05558863f, 
    0.01354434f, 0.03657551f, -0.03526032f, 0.02324144f, -0.03331261f, -0.02596626f, 0.04468954f, -0.03690416f, 
    0.01639994f, 0.03281833f, -0.03829196f, 0.00524068f, -0.05275752f, -0.01503880f, 0.00361351f, -0.02356000f, 
    -0.00196801f, -0.02358600f, -0.02428850f, -0.01513185f, 0.01520705f, 0.02065698f, 0.00597122f, -0.03640425f, 
    0.02846225f, 0.03270227f, -0.04129653f, -0.04849279f, 0.00597087f, 0.04508263f, -0.03353083f, 0.03217703f, 
    -0.04461217f, 0.00753242f, -0.03364320f, -0.02553731f, -0.01548634f, 0.01665694f, 0.03879980f, -0.02971287f, 
    -0.05153956f, -0.05373348f, 0.00559053f, -0.00348438f, -0.00425125f, 0.00993373f, 0.04553683f, 0.03679031f, 
    -0.01929288f, 0.01403979f, -0.04083597f, 0.01206470f, -0.01318436f, -0.03392326f, 0.03897630f, 0.01941584f, 
    0.01346733f, -0.04601805f, -0.01400266f, 0.00869344f, 0.02051572f, 0.02513528f, -0.03810079f, -0.03194110f, 
    -0.02808979f, 0.03204265f, 0.00753590f, -0.04351033f, 0.02448178f, -0.01492713f, 0.01203481f, 0.02595969f, 
    -0.02234472f, 0.02464946f, -0.01114700f, 0.04194498f, 0.03983415f, 0.00013343f, -0.00429611f, 0.03869987f, 
    0.07588273f, 0.08479143f, -0.28395069f, -0.04671286f, -0.05109979f, 0.02252375f, 0.14325355f, 0.07092647f, 
    -0.07411646f, 0.10809655f, 0.03677586f, -0.09655562f, 0.08433962f, 0.18018064f, 0.26492271f, 0.22025207f, 
    -0.00134785f, 0.03389364f, -0.03374983f, -0.08028252f, 0.06191045f, 0.04362980f, 0.10164046f, -0.06312361f, 
    -0.20270669f, -0.17363045f, -0.10587768f, 0.01067058f, -0.20001225f, 0.21219997f, 0.04059307f, 0.15179858f, 
    0.02020368f, -0.10312290f, 0.07057080f, -0.03891775f, 0.19920422f, 0.05061013f, -0.08239468f, 0.04665545f, 
    -0.02660453f, 0.02911568f, 0.08956175f, 0.05607850f, 0.10198542f, -0.05330822f, 0.00778024f, 0.06563183f, 
    0.22618145f, 0.16176282f, 0.10442749f, -0.03982380f, -0.07817379f, -0.00990946f, 0.05829331f, -0.03076995f, 
    0.03404855f, 0.10760319f, 0.29897168f, -0.01379624f, -0.16392472f, -0.15468322f, -0.12106617f, -0.14163913f, 
    0.15622328f, 0.02471875f, 0.13343720f, -0.01493183f, 0.00255640f, 0.07183482f, -0.04337822f, 0.05561613f, 
    0.27851534f, 0.03567850f, 0.04419148f, -0.04528202f, 0.11103349f, 0.05471956f, -0.06694657f, -0.00879813f, 
    -0.03255599f, 0.06023828f, -0.11016957f, -0.02967814f, -0.32443866f, 0.00749060f, 0.14813060f, -0.01141149f, 
    -0.14345275f, -0.05652456f, -0.02968589f, -0.14288926f, 0.01397030f, 0.13858822f, -0.10399188f, 0.08063351f, 
    -0.29575336f, -0.04786232f, -0.13591817f, -0.12104948f, 0.08521543f, 0.07435349f, 0.08233938f, 0.02055646f, 
    0.00100257f, 0.02731904f, 0.04343242f, 0.12033858f, -0.09919894f, -0.28693980f, -0.37429526f, -0.27789167f, 
    -0.08304904f, 0.08111398f, 0.09506267f, 0.05157763f, 0.08727909f, 0.03772896f, 0.04449535f, 0.05532490f, 
    -0.01516522f, 0.30251241f, 0.15069661f, 0.11589269f, -0.00190460f, 0.14315519f, 0.00265349f, -0.11912580f, 
    -0.06448831f, 0.06772725f, 0.11435886f, 0.10283341f, -0.14323454f, -0.32286555f, -0.19101873f, -0.23492123f, 
    0.07792345f, -0.02819262f, 0.07976738f, 0.06888786f, 0.04351167f, -0.02351024f, -0.01546036f, -0.01875119f, 
    0.16966397f, -0.31859741f, -0.02090054f, -0.00731446f, -0.08062194f, 0.07501852f, 0.18228027f, 0.02603360f, 
    0.10169183f, -0.07344933f, 0.07988730f, -0.02389245f, -0.19531158f, 0.02813211f, -0.20121978f, -0.05718729f, 
    0.09462337f, 0.02447795f, 0.12630953f, 0.05150021f, 0.04169289f, 0.09820040f, 0.11843827f, -0.06086642f, 
    0.04046582f, 0.05994480f, -0.02557557f, -0.03378400f, 0.11275739f, -0.04520282f, 0.01975083f, 0.06055420f, 
    -0.06274935f, -0.03797464f, -0.04231033f, -0.06119471f, 0.32077429f, -0.43461201f, -0.00328921f, -0.05269716f, 
    0.11307885f, -0.22736543f, -0.05329645f, 0.20590720f, -0.04590487f, 0.05131584f, -0.09492087f, 0.10572565f, 
    0.21130818f, 0.09619684f, 0.12530135f, 0.05803622f, 0.01078697f, 0.01802365f, 0.13174576f, -0.10531022f, 
    0.04231234f, 0.25102356f, 0.39684957f, 0.06118365f, 0.22067428f, 0.00551007f, 0.01738269f, 0.05837313f, 
    -0.03675376f, 0.05227529f, 0.15725625f, 0.11688008f, -0.03765557f, 0.09532927f, -0.02169555f, -0.11722430f, 
    0.20257926f, 0.00106266f, 0.05857750f, -0.15951724f, 0.08024757f, 0.22875232f, 0.18000790f, 0.03004518f, 
    -0.00132400f, -0.08960788f, -0.02934645f, -0.06655449f, 0.27017429f, 0.16059555f, 0.02052155f, -0.40594327f, 
    0.01109326f, -0.14588611f, -0.00849404f, 0.03711581f, 0.13363066f, 0.00785076f, 0.07863133f, -0.05063708f, 
    0.18464273f, 0.00338557f, 0.06116986f, -0.15568440f, -0.06770131f, 0.08399993f, -0.05047624f, -0.07063916f, 
    0.06927747f, 0.11791883f, 0.06673571f, 0.00690100f, 0.11278913f, -0.03169549f, -0.13273020f, -0.07614683f, 
    0.02390901f, -0.03755154f, 0.11891404f, -0.03074554f, 0.10614610f, -0.04644770f, 0.06777665f, -0.04877488f, 
    0.03747172f, 0.27936521f, -0.02133279f, 0.10393252f, 0.04302328f, 0.09009377f, 0.04291324f, 0.04063742f, 
    0.09608179f, 0.12103581f, -0.03441406f, 0.21194221f, -0.19789773f, -0.00812293f, 0.01278059f, 0.08773270f, 
    -0.06691518f, -0.06479545f, 0.04343019f, -0.03688664f, 0.16560520f, 0.34866750f, 0.21244571f, 0.26460174f, 
    -0.00202663f, -0.24476993f, -0.06808457f, -0.02189928f, -0.17737669f, -0.00859089f, -0.07277436f, -0.13163130f, 
    0.02619557f, -0.06646502f, 0.23712021f, 0.11864042f, -0.06301559f, -0.08699594f, -0.29861054f, -0.12634997f, 
    0.11725067f, -0.10971524f, 0.01144254f, 0.00855107f, 0.07009058f, -0.03713219f, 0.30004555f, -0.03328917f, 
    0.30770946f, -0.22180295f, -0.16695039f, -0.19838178f, 0.00760632f, -0.13109942f, -0.01668098f, 0.05461178f, 
    0.02802855f, 0.16162609f, 0.04502743f, 0.14451988f, 0.16760682f, 0.13725670f, 0.13009763f, -0.01665407f, 
    -0.00069727f, -0.00854628f, 0.01767239f, -0.00862301f, -0.00863742f, -0.05226035f, -0.11227757f, -0.12994511f, 
    0.17835017f, 0.05474256f, -0.12133157f, -0.12371374f, -0.06942852f, 0.09127233f, -0.13498582f, -0.04202818f, 
    0.07093966f, 0.15240367f, -0.06524415f, -0.14072853f, -0.05874354f, 0.23509920f, 0.00873638f, -0.10070532f, 
    -0.07603130f, -0.01452033f, -0.00921135f, 0.01546238f, 0.00032189f, -0.02619032f, -0.21626748f, 0.07721035f, 
    -0.14088805f, -0.13349502f, -0.13563266f, -0.14683276f, -0.19663303f, -0.01837589f, -0.17139986f, -0.04247732f, 
    -0.01775277f, 0.09627593f, -0.01993014f, -0.08118022f, 0.22855292f, 0.07354110f, -0.10246687f, -0.00220715f, 
    0.16398247f, 0.05244545f, 0.11868373f, -0.00021996f, 0.00365026f, 0.01517339f, 0.18758596f, -0.09102463f, 
    0.00221874f, 0.05462398f, 0.11235518f, -0.29828268f, -0.03586770f, -0.07402905f, -0.04156218f, 0.02426371f, 
    0.11640880f, -0.08298890f, -0.02240346f, 0.15781358f, 0.13269860f, 0.11373807f, -0.02241127f, -0.04566564f, 
    0.09912889f, 0.15395673f, 0.08716391f, 0.11058053f, -0.08858870f, -0.06819454f, -0.20721248f, -0.15916276f, 
    0.19528386f, 0.08259351f, -0.07175711f, -0.03373632f, 0.04637429f, -0.11960962f, 0.24228317f, 0.02119945f, 
    -0.00990997f, 0.12781674f, -0.12460086f, 0.02569270f, 0.35494140f, 0.10112988f, 0.11812688f, -0.08685701f, 
    -0.05901464f, -0.13921501f, 0.04131224f, 0.05799118f, 0.12295857f, 0.12533674f, 0.05390627f, 0.04685167f, 
    -0.05593050f, 0.20864749f, 0.03843018f, 0.12929414f, -0.00517505f, -0.02694172f, -0.11686578f, -0.07528887f, 
    0.24879728f, 0.15592495f, -0.12755099f, -0.00586448f, -0.41891161f, 0.25024378f, -0.03810579f, 0.29581994f, 
    -0.16996415f, 0.20631529f, 0.09984028f, -0.31594691f, -0.02408053f, -0.08133075f, 0.02328338f, 0.18783329f, 
    -0.06856243f, 0.01427991f, -0.01469803f, 0.40952682f, 0.04816715f, -0.08525420f, 0.11236851f, 0.04628621f, 
    0.07491177f, -0.18596438f, 0.08840947f, -0.07032351f, 0.04017786f, -0.10116357f, 0.09141224f, 0.19639222f, 
    -0.10371419f, -0.04514255f, -0.16107978f, -0.14142191f, -0.00537100f, -0.01578350f, 0.01465294f, -0.06674083f, 
    -0.10671318f, 0.03792212f, 0.39981773f, 0.19882423f, 0.02983346f, 0.14040771f, -0.10868185f, -0.17757615f, 
    -0.08218122f, -0.14685200f, -0.10657046f, 0.11151967f, 0.10400121f, 0.11036124f, 0.22315739f, 0.32189965f, 
    -0.05454302f, -0.14965968f, -0.13084467f, -0.15305783f, -0.01576210f, -0.13394897f, -0.15031536f, -0.10847958f, 
    0.60063952f, -0.16884108f, 0.03780660f, -0.34650642f, 0.03277743f, -0.21059383f, -0.04433432f, 0.02955496f, 
    0.00306032f, 0.07452662f, -0.19679283f, -0.03097116f, -0.01586157f, 0.03367697f, 0.43845239f, 0.37583765f, 
    -0.18869732f, -0.01740149f, -0.03340705f, 0.06935702f, 0.03323222f, -0.01235871f, -0.06184495f, -0.02322961f, 
    0.25008360f, 0.20811267f, 0.13201299f, -0.10198227f, -0.13762146f, -0.16371922f, -0.00958076f, -0.16371024f, 
    -0.18008600f, -0.00070535f, -0.23930152f, -0.22211087f, 0.26346511f, -0.27193379f, 0.34149069f, 0.02720173f, 
    -0.08472184f, 0.31673247f, 0.01555410f, -0.00863565f, -0.05341033f, -0.03545907f, 0.03559560f, 0.02902527f, 
    0.33420694f, 0.12067592f, 0.00004224f, 0.11443196f, -0.03337212f, 0.09916594f, 0.12874179f, 0.00643306f, 
    -0.05084307f, -0.07159488f, 0.00939617f, -0.08181714f, -0.08449926f, 0.02221361f, 0.02428360f, 0.32656857f, 
    -0.06331870f, -0.06434692f, -0.04075503f, -0.00063228f, -0.04660466f, 0.04439282f, -0.04998827f, -0.30633438f, 
    0.29505876f, 0.32393292f, -0.06395372f, 0.00925241f, -0.08877002f, -0.00524810f, -0.10899970f, 0.06558921f, 
    -0.11209857f, -0.07005379f, -0.06408130f, 0.01789203f, -0.24450907f, 0.04921956f, -0.02347890f, -0.06710021f, 
    -0.14794338f, 0.05602036f, 0.00079140f, -0.21771649f, 0.08287801f, 0.04123785f, -0.03214404f, 0.10647735f, 
    0.21726838f, 0.10494684f, -0.05904035f, 0.09978717f, -0.11875191f, -0.07545224f, 0.02896659f, 0.16513517f, 
    -0.08084377f, 0.05638524f, -0.02535170f, -0.00120344f, -0.02896214f, -0.17747606f, -0.31877536f, 0.13859494f, 
    0.02561694f, -0.05593544f, -0.00089562f, -0.12127266f, -0.23813051f, 0.03461996f, -0.00034185f, 0.10712080f, 
    0.00319002f, 0.04995780f, -0.40816566f, 0.12120339f, -0.02919991f, 0.03467554f, 0.04616312f, -0.12152760f, 
    -0.13878495f, -0.12503733f, -0.17248507f, 0.04784655f, 0.00607587f, -0.01582674f, 0.32837394f, 0.14021684f, 
    -0.10333051f, 0.13088588f, 0.08406267f, 0.02386174f, -0.02653525f, -0.10059648f, -0.07082294f, -0.12831762f, 
    -0.02605958f, -0.00085485f, 0.35414758f, 0.05423881f, -0.28636038f, 0.10874654f, -0.00643836f, 0.07386156f, 
    0.04698212f, 0.03048596f, 0.16795394f, -0.06006118f, 0.30640414f, 0.20828970f, 0.01864164f, -0.01416489f, 
    0.11864024f, -0.00911850f, 0.20730941f, 0.17459044f, 0.03065532f, -0.09294041f, 0.22278996f, 0.16651972f, 
    -0.18333803f, 0.08937006f, -0.04673367f, 0.25041920f, -0.08016256f, 0.02520634f, 0.03653118f, -0.03486058f, 
    -0.04465730f, 0.11387620f, -0.10197152f, 0.11885289f, -0.08704118f, 0.13705526f, 0.09095390f, 0.20206527f, 
    -0.10625736f, 0.08027682f, 0.10044318f, 0.02009244f, -0.03410009f, 0.11252224f, -0.11832937f, -0.06023620f, 
    0.33038995f, 0.19614638f, -0.38639301f, 0.01919281f, -0.06770169f, -0.05415113f, -0.09205047f, -0.03522655f, 
    -0.05789818f, -0.03174149f, -0.05514083f, -0.11439805f, 0.26608247f, 0.12860973f, 0.05749698f, 0.02421306f, 
    0.02222163f, 0.05335302f, -0.05083603f, 0.01164248f, 0.08279387f, 0.18525733f, 0.11225282f, 0.00235131f, 
    0.05174531f, -0.08096194f, 0.12247082f, -0.03624389f, -0.01269751f, -0.03343016f, -0.15940696f, 0.01850707f, 
    -0.09597824f, -0.03833832f, -0.26756898f, 0.15169939f, 0.29452538f, 0.09675146f, 0.18982835f, 0.03398306f, 
    0.00653659f, -0.01545247f, 0.00438815f, 0.03942265f, 0.06286839f, -0.01859481f, 0.03650124f, 0.05514322f, 
    -0.20577483f, 0.04007228f, 0.31123632f, 0.40309525f, -0.08436235f, 0.00822777f, 0.02550765f, 0.02883448f, 
    -0.03337867f, 0.05534659f, 0.13107549f, 0.00844892f, -0.23999773f, 0.13954756f, -0.05948064f, -0.00083310f, 
    -0.05614885f, -0.01797628f, -0.09761025f, -0.11899014f, -0.01853292f, 0.03010011f, -0.25141427f, -0.03244848f, 
    0.53300101f, -0.18019238f, 0.32828382f, -0.30990016f, 0.04658588f, -0.05114946f, 0.14579551f, 0.21493667f, 
    0.02723317f, 0.13049431f, 0.21972530f, 0.12838410f, -0.23257922f, 0.37288588f, 0.07657602f, 0.10509838f, 
    -0.21644403f, -0.09470277f, -0.10239406f, -0.13877554f, -0.11313872f, 0.14852233f, -0.00419027f, 0.07216030f, 
    0.29475948f, -0.06780302f, 0.05444863f, 0.09886263f, 0.10909016f, -0.02526052f, -0.10808705f, -0.01523216f, 
    -0.07319634f, 0.10420619f, -0.00785876f, 0.07979289f, 0.01860061f, 0.08898488f, 0.34196106f, -0.09112743f, 
    -0.07075325f, -0.01792064f, -0.16405347f, 0.06476751f, -0.07556357f, 0.06402550f, -0.05130721f, -0.04776517f, 
    0.14569277f, 0.26235291f, 0.01950163f, -0.40660512f, -0.08415809f, 0.02178900f, -0.03206485f, -0.12845409f, 
    -0.13506420f, -0.01442808f, -0.03187835f, -0.02406836f, 0.06467085f, 0.40007678f, -0.02343462f, 0.12430813f, 
    0.15329477f, -0.11685604f, 0.12131889f, 0.22702639f, -0.10222714f, -0.02950111f, 0.06753416f, 0.02321401f, 
    0.06928586f, 0.28319237f, -0.34367734f, -0.38748378f, 0.04258276f, -0.00407863f, 0.12986150f, -0.06099791f, 
    0.03785905f, 0.10954052f, 0.23309261f, 0.35669383f, 0.01641217f, -0.26961285f, 0.01718239f, 0.15006620f, 
    -0.03748425f, 0.10818326f, -0.02375255f, -0.05053934f, -0.11562624f, -0.12031825f, -0.07565349f, -0.10360740f, 
    0.11185335f, 0.02084783f, 0.10715898f, -0.08183380f, -0.20594673f, 0.02100633f, 0.00102345f, 0.00850720f, 
    0.02904744f, -0.06362290f, 0.04729224f, -0.03457443f, 0.25847450f, -0.07556919f, -0.01952241f, 0.08745619f, 
    0.04492376f, 0.00234117f, -0.01559640f, -0.01429383f, -0.17279257f, -0.03571592f, 0.03044956f, -0.16737078f, 
    0.10595655f, -0.09269176f, 0.53076434f, -0.22584859f, -0.07330958f, -0.09888335f, -0.06523072f, 0.06972782f, 
    -0.05626289f, 0.10729571f, -0.04118991f, -0.01060150f, 0.00479731f, -0.28673309f, -0.20122571f, 0.11215337f, 
    0.00597269f, 0.02235236f, -0.02148557f, -0.06649346f, -0.24788171f, -0.16676424f, -0.05328929f, -0.21904998f, 
    0.05987901f, -0.07353565f, 0.10939049f, 0.23065527f, 0.14953035f, -0.11158922f, 0.09500477f, 0.11836701f, 
    -0.01565043f, 0.00997287f, 0.09158109f, -0.06638644f, 0.14526008f, 0.16923125f, -0.12154821f, 0.29991978f, 
    -0.01967424f, 0.10746650f, 0.04476763f, 0.11898819f, 0.13312130f, 0.09803201f, 0.11985031f, 0.18834145f, 
    -0.12501949f, 0.17625406f, -0.03068271f, -0.10323437f, -0.05638535f, -0.04164788f, -0.23633510f, -0.04490142f, 
    -0.04557250f, 0.14747518f, 0.13227305f, 0.06008528f, 0.19160777f, 0.02567478f, -0.09564136f, -0.03877426f, 
    0.06182411f, 0.04403331f, 0.03510316f, 0.10873751f, -0.15578049f, 0.05860257f, -0.01861090f, 0.06209292f, 
    -0.25431174f, 0.30512363f, -0.20109588f, 0.00124019f, -0.12851390f, -0.05603019f, -0.05997311f, -0.04604129f, 
    -0.10028929f, 0.00941041f, -0.10418705f, -0.02409798f, 0.15313622f, 0.06532696f, 0.03491911f, 0.08583547f, 
    0.21633621f, -0.05179480f, 0.14667033f, 0.12354235f, 0.07433666f, 0.06518424f, 0.20861347f, 0.14704990f, 
    0.13487534f, 0.17255296f, 0.18828918f, 0.13478808f, -0.04419323f, 0.01441124f, -0.05356170f, 0.00798997f, 
    0.07528690f, 0.20154156f, -0.03534079f, 0.04994418f, -0.20236818f, -0.07583377f, -0.39266199f, -0.43121338f, 
    -0.06321608f, 0.09555351f, 0.13036442f, 0.02479021f, 0.06416857f, 0.12255164f, -0.03443035f, -0.01262870f, 
    -0.13539284f, 0.03373592f, -0.15087011f, -0.08471096f, 0.10392966f, -0.13610798f, 0.00765838f, 0.02937515f, 
    -0.03793877f, 0.05544086f, 0.10404653f, -0.12677099f, -0.09833542f, -0.23548044f, 0.08460978f, -0.01564125f, 
    -0.00568469f, 0.06602465f, -0.05550865f, -0.07152703f, 0.08035364f, -0.11320378f, 0.04851052f, 0.11219512f, 
    0.01651393f, -0.37191105f, 0.34435871f, -0.11299305f, 0.09983439f, 0.10500924f, 0.05021408f, 0.04199363f, 
    -0.09647568f, -0.02834902f, -0.05062024f, 0.15016979f, 0.01079080f, -0.31945136f, -0.05663399f, -0.00410859f, 
    -0.04698888f, 0.02314794f, 0.02241617f, 0.08386950f, 0.08571003f, 0.20109208f, -0.03490192f, -0.20872258f, 
    0.01667274f, -0.15081917f, -0.14815903f, 0.00794104f, 0.05828298f, -0.09458228f, 0.03964771f, 0.01950687f, 
    -0.05186052f, -0.01847348f, 0.02576026f, -0.00840064f, -0.21543556f, 0.03145373f, 0.07410911f, 0.00306809f, 
    -0.08189439f, -0.03800021f, -0.02031116f, 0.10046417f, 0.10199130f, 0.00624677f, 0.00654209f, 0.13636950f, 
    -0.25057903f, -0.00926726f, -0.10563163f, 0.14796250f, -0.03906938f, 0.10258400f, -0.08903488f, -0.05524547f, 
    0.06828620f, 0.19387944f, 0.10940514f, -0.11617886f, -0.00851682f, 0.21212317f, 0.09956399f, -0.00865120f, 
    -0.17896432f, 0.05643154f, -0.14905742f, -0.02603072f, -0.12668140f, 0.07307164f, 0.02474585f, -0.02792897f, 
    0.12825850f, -0.26233506f, -0.15889074f, -0.36890641f, 0.01683712f, 0.12432026f, -0.06052927f, -0.04550496f, 
    -0.08675478f, 0.11003386f, 0.02890483f, 0.06189671f, 0.01954349f, -0.06441753f, 0.24894625f, -0.02434700f, 
    0.04375992f, 0.06639838f, 0.01222740f, -0.05731344f, 0.04416314f, 0.04581053f, 0.12789343f, 0.11085318f, 
    -0.19248502f, -0.31212953f, -0.08167708f, -0.05644726f, -0.03470752f, -0.02946192f, -0.01991763f, 0.02687608f, 
    -0.00454894f, 0.08917584f, -0.05855840f, -0.04780946f, 0.10850678f, 0.32340571f, -0.28366804f, -0.00625333f, 
    -0.01779171f, 0.09286696f, 0.15741773f, 0.10991166f, 0.15953022f, 0.07838714f, 0.04805398f, -0.02851781f, 
    0.00604695f, 0.16322865f, -0.25713727f, -0.11944188f, -0.00189267f, 0.01826465f, -0.00163896f, -0.18086542f, 
    -0.07372911f, -0.15777080f, 0.08973362f, -0.14876428f, -0.15980898f, -0.00432826f, 0.07129061f, -0.18275188f, 
    0.18929285f, 0.10069007f, 0.03112019f, 0.02892080f, -0.06295937f, 0.01734002f, 0.11465796f, 0.13923641f, 
    0.01382944f, -0.03605234f, -0.09528010f, 0.12637037f, 0.03104024f, 0.16970819f, -0.10855666f, -0.16203848f, 
    -0.10797115f, -0.20827974f, -0.13017030f, -0.46295318f, 0.17745519f, -0.03485909f, -0.02566788f, -0.14285785f, 
    0.13409984f, 0.03094899f, -0.00737796f, 0.00904601f, 0.05521513f, -0.09000479f, -0.00208767f, 0.18271072f, 
    0.00113971f, -0.06123125f, -0.10981902f, -0.19094104f, 0.04030562f, 0.01292329f, 0.06702160f, -0.04426145f, 
    0.21469550f, 0.09222306f, 0.26263165f, 0.09761205f, -0.32169658f, 0.19164209f, -0.12351100f, -0.09202618f, 
    0.05380709f, 0.09992258f, -0.11414741f, -0.29903853f, -0.21270268f, -0.18129176f, -0.15798241f, -0.01591329f, 
    0.14667544f, -0.24012268f, -0.08121569f, 0.00998630f, 0.12317075f, -0.01598348f, -0.18638653f, -0.09248099f, 
    -0.22245884f, -0.16372301f, -0.00404606f, -0.20235977f, 0.01516775f, 0.06738100f, 0.14901364f, 0.16877259f, 
    0.06307364f, 0.00150332f, 0.01800002f, 0.04302249f, 0.25138265f, 0.24753839f, 0.17576277f, 0.08249161f, 
    -0.33153641f, 0.23077308f, -0.03868876f, 0.10677567f, 0.09460995f, 0.12833586f, 0.13998714f, 0.00567874f, 
    0.01741885f, 0.05314068f, 0.14369196f, 0.31787831f, -0.04837403f, -0.13163179f, 0.04257842f, 0.16153929f, 
    -0.07609994f, -0.04337458f, 0.11565093f, 0.07295977f, 0.03791700f, 0.08347221f, 0.12084012f, 0.35116938f, 
    0.15919372f, -0.07269289f, 0.08960877f, 0.07018405f, -0.15366527f, 0.03218569f, -0.02125127f, -0.03733297f, 
    0.01814536f, 0.02905122f, 0.18566182f, 0.09246476f, -0.03617833f, 0.04159770f, 0.08617441f, -0.01496259f, 
    0.02296180f, -0.13171983f, 0.04369095f, 0.13204901f, 0.09099918f, -0.09664582f, -0.03974751f, -0.23530981f, 
    0.21269324f, -0.22735018f, -0.00536776f, 0.05622966f, -0.15158600f, 0.08702145f, 0.09648616f, -0.19164933f, 
    -0.02371781f, 0.06231388f, 0.07427830f, 0.09976992f, -0.40042624f, 0.02326663f, 0.01405632f, -0.09371646f, 
    0.09816947f, -0.08814203f, 0.18584023f, 0.00534751f, -0.07971379f, 0.15341164f, -0.04065575f, -0.02637416f, 
    0.04042054f, -0.13016117f, 0.02374134f, 0.27412543f, 0.11574356f, -0.02462617f, -0.06107031f, 0.03139263f, 
    -0.49509707f, -0.50346053f, -0.07166892f, -0.37658852f, 0.33065960f, -0.34467542f, -0.08209810f, 0.13360937f, 
    0.16322421f, -0.12147266f, -0.15661164f, 0.01147758f, 0.07956308f, 0.02692251f, -0.03651772f, 0.03301491f, 
    0.07108868f, -0.05569754f, 0.02825823f, 0.10133743f, -0.02501815f, 0.06814686f, 0.02533679f, -0.11015590f, 
    0.14688817f, 0.42700225f, 0.12422986f, 0.29381415f, 0.00921265f, 0.02154546f, -0.07684473f, -0.04056292f, 
    -0.22178619f, 0.14981708f, -0.08829702f, -0.01568284f, -0.01237040f, 0.11308555f, -0.10793506f, -0.35132489f, 
    -0.08885308f, 0.03507870f, 0.07774181f, -0.07553828f, -0.08267093f, 0.02484124f, 0.03092621f, -0.05430826f, 
    -0.17302971f, -0.30507502f, -0.09193352f, -0.53297192f, 0.22254102f, 0.21450230f, 0.14750661f, 0.10275179f, 
    -0.06221955f, -0.00508102f, -0.02051302f, 0.07618029f, 0.16910785f, 0.02029183f, 0.03529073f, 0.01836985f, 
    0.15277465f, 0.09913275f, 0.18569832f, -0.04089784f, 0.03083250f, 0.16167578f, 0.00826728f, -0.14297681f, 
    0.19712354f, 0.11790603f, 0.01279646f, 0.30966789f, -0.00363408f, 0.02872526f, 0.12305612f, 0.31907251f, 
    0.00616355f, 0.01015795f, 0.15184252f, 0.12846535f, 0.02295698f, 0.05517170f, 0.01514333f, -0.15044677f, 
    0.13118000f, 0.35200992f, -0.07327041f, 0.18235172f, -0.02148492f, 0.06636262f, -0.02402548f, 0.08547108f, 
    -0.00759988f, -0.08210517f, -0.07514657f, 0.06049674f, 0.08006743f, 0.13637592f, -0.04544560f, 0.26942828f, 
    -0.02019374f, -0.11390492f, 0.11398417f, -0.16296692f, -0.06885076f, 0.01853389f, -0.02509777f, 0.10183990f, 
    0.01502950f, 0.00301797f, 0.04473304f, 0.19062574f, -0.08143351f, 0.16806860f, -0.12932049f, 0.09092339f, 
    0.15958560f, 0.10217969f, 0.11586265f, 0.16519766f, -0.06705087f, -0.11154211f, -0.10077816f, 0.27380010f, 
    0.07126419f, -0.05255206f, 0.02507606f, 0.01889002f, -0.01161323f, 0.01744464f, 0.05895458f, 0.08092632f, 
    0.38347068f, 0.10482164f, 0.14228901f, 0.20510927f, -0.02290641f, -0.06476852f, 0.18198462f, -0.06509321f, 
    -0.00252875f, -0.10523787f, -0.01505319f, 0.01394686f, 0.03586850f, -0.07566722f, -0.01371678f, -0.15266100f, 
    0.19508497f, -0.07124196f, -0.01859552f, -0.02524645f, -0.06213993f, -0.08603241f, 0.09398548f, -0.00159373f, 
    0.50699019f, 0.27783737f, -0.06934009f, -0.02626508f, 0.02440603f, -0.04758977f, 0.09636379f, 0.05736115f, 
    0.15810129f, 0.01307822f, -0.02028438f, 0.10111075f, -0.02434632f, 0.22693536f, 0.10414626f, -0.20753971f, 
    -0.00408504f, -0.10817955f, -0.15963839f, -0.06682596f, -0.32908702f, -0.02747607f, -0.30402225f, -0.40899450f, 
    0.04941478f, 0.02842633f, -0.08891730f, 0.21157441f, -0.04088470f, -0.03311114f, 0.07175604f, 0.01748276f, 
    -0.03041925f, 0.15553026f, -0.12892237f, -0.09631247f, 0.21194467f, -0.14612587f, -0.22149047f, 0.03554012f, 
    0.11315058f, 0.04522956f, 0.04603347f, -0.01564107f, 0.13723937f, 0.08205411f, 0.16202492f, 0.25568330f, 
    0.01377387f, -0.03319795f, 0.03511896f, 0.03660794f, 0.00833082f, 0.03352364f, -0.02285597f, 0.04048244f, 
    0.02555449f, 0.04177183f, 0.01990026f, 0.02136153f, -0.01225266f, -0.00310450f, 0.03137079f, 0.01105189f, 
    0.00959653f, 0.01819874f, 0.02223463f, 0.01537607f, 0.01007244f, -0.01567887f, 0.01419406f, -0.03722743f, 
    0.03880160f, 0.03522625f, -0.05224982f, -0.04357321f, -0.02444087f, -0.01623035f, -0.02445560f, 0.03882460f, 
    -0.04044267f, 0.00945288f, -0.03261948f, -0.02744244f, -0.04582145f, -0.01528130f, -0.04616760f, -0.02809486f, 
    -0.00144365f, -0.01954894f, 0.01928543f, -0.04235285f, -0.03657871f, -0.00768554f, -0.05068316f, 0.03540961f, 
    0.01975189f, 0.00681668f, 0.01681061f, -0.04659014f, -0.05112999f, -0.00478983f, -0.03377074f, -0.01491036f, 
    -0.01752050f, 0.03097015f, 0.01830969f, -0.05235229f, 0.02649906f, -0.02977610f, 0.02519314f, -0.00462519f, 
    -0.05439203f, 0.04502659f, 0.03707978f, -0.02412056f, -0.03718236f, -0.01741625f, -0.00533691f, -0.05082934f, 
    0.01164746f, -0.03552680f, -0.04145737f, -0.00125164f, 0.00586581f, 0.02704851f, 0.03769551f, -0.03468934f, 
    0.00317371f, 0.01797377f, 0.00724397f, -0.02058230f, -0.03569064f, -0.03851146f, -0.02635849f, -0.00624245f, 
    -0.01809979f, -0.03714620f, -0.01654292f, -0.01608095f, -0.01868570f, 0.01239138f, -0.02464605f, 0.00100677f, 
    -0.04705567f, 0.01669294f, -0.02065549f, 0.02873413f, 0.03471160f, 0.05206849f, -0.00244334f, -0.03421180f, 
    -0.03998698f, -0.04055861f, -0.01516690f, 0.00534538f, -0.01647392f, 0.00366574f, -0.02239792f, 0.04434237f, 
    0.01914579f, -0.02263460f, -0.03994205f, -0.04027760f, -0.01737944f, 0.00747042f, -0.03253979f, 0.02608690f, 
    -0.02409475f, -0.00359682f, -0.01405983f, 0.00111708f, 0.04250300f, -0.02797822f, 0.01678677f, 0.05151713f, 
    0.02451548f, 0.04048673f, -0.04373587f, -0.03847336f, 0.03806252f, -0.01010249f, 0.00094386f, 0.02566180f, 
    -0.00846818f, 0.00813914f, -0.04743209f, -0.05506318f, 0.00864799f, -0.01669470f, -0.02707914f, -0.00251430f, 
    -0.02121664f, -0.02175806f, -0.02766369f, 0.03637413f, 0.02808909f, 0.01660903f, 0.03608233f, -0.00547296f, 
    0.02315335f, -0.04866244f, -0.03680345f, -0.02692201f, 0.02348052f, -0.03511474f, 0.03642510f, -0.04794974f, 
    -0.05162623f, -0.04307937f, -0.01185286f, -0.02715749f, -0.04732944f, -0.02985469f, 0.02677020f, 0.03562178f, 
    0.00787167f, -0.02673613f, -0.04010515f, -0.05385080f, -0.03231062f, 0.00601298f, 0.03715518f, -0.00696875f, 
    -0.04275971f, 0.01294822f, -0.04979182f, 0.01159905f, -0.05326796f, 0.01585643f, -0.02950832f, 0.01185759f, 
    0.01032354f, -0.03005594f, 0.02008290f, -0.01719927f, 0.02180511f, 0.03528818f, -0.02139044f, -0.01614036f, 
    0.02395367f, 0.00309077f, -0.02369783f, -0.03949082f, -0.03661019f, -0.01805708f, -0.04022938f, 0.01976064f, 
    -0.05213737f, -0.02325740f, 0.00465167f, -0.04452670f, -0.01388175f, 0.03430746f, -0.04670191f, -0.01559752f, 
    -0.03154179f, 0.02346495f, -0.01087456f, -0.03676188f, -0.04137082f, 0.02116406f, -0.03016812f, -0.05580198f, 
    -0.04222009f, -0.04482989f, 0.03268769f, 0.01477359f, 0.02796720f, -0.04733189f, -0.01564908f, -0.05461267f, 
    0.03902987f, -0.04041397f, 0.03791331f, -0.00232043f, -0.04496079f, -0.03075051f, -0.04815599f, 0.03810813f, 
    -0.00544575f, 0.02947088f, -0.04305362f, 0.02355564f, -0.01542389f, -0.01934447f, -0.00889750f, -0.03824343f, 
    0.02357830f, 0.01535372f, 0.02392782f, -0.03891186f, -0.04770376f, -0.04242972f, 0.03108747f, -0.00761756f, 
    -0.01218440f, -0.00362236f, -0.05083814f, -0.04214663f, 0.03243321f, -0.01185091f, -0.04657038f, 0.02120399f, 
    -0.00380485f, 0.00827736f, 0.03566211f, -0.00279044f, -0.04225779f, -0.04858236f, 0.04162024f, -0.01820187f, 
    0.01574179f, 0.00363543f, 0.03562853f, -0.03404832f, -0.01116713f, -0.03574776f, -0.05706039f, 0.04257125f, 
    0.02917045f, -0.03291269f, -0.02521149f, -0.00419655f, -0.02361286f, -0.03358181f, 0.02917292f, -0.05803083f, 
    -0.04996814f, -0.01185681f, -0.00877191f, -0.02848356f, 0.00771322f, 0.02932860f, 0.04276761f, -0.03356858f, 
    -0.00047298f, -0.03629841f, -0.01495131f, 0.00413843f, 0.03967185f, -0.01984281f, 0.04425130f, 0.04111963f, 
    0.01575339f, -0.00148524f, -0.04129849f, 0.04420304f, -0.02849311f, 0.04282453f, 0.01404474f, 0.03633734f, 
    -0.00295497f, 0.00717133f, -0.03718390f, 0.00828279f, -0.02642655f, -0.00081410f, 0.00527473f, 0.01241224f, 
    -0.01247044f, 0.04423396f, 0.01680082f, 0.00694271f, -0.00110933f, -0.00996880f, -0.04032980f, -0.04643421f, 
    0.01262299f, 0.01143114f, -0.03839336f, -0.02740687f, -0.00203643f, 0.02378828f, 0.02522813f, -0.05725673f, 
    -0.03869390f, -0.05054358f, -0.01920739f, -0.00705699f, -0.02651302f, 0.00014642f, -0.03355778f, -0.01815729f, 
    0.01959956f, -0.04600604f, -0.02352532f, -0.04859214f, 0.02793072f, -0.05914998f, 0.01599173f, -0.04420072f, 
    0.03565068f, -0.00115343f, -0.03471158f, 0.02296983f, 0.03770433f, -0.00813127f, 0.04239426f, -0.04243183f, 
    -0.02439495f, 0.02131583f, 0.05753217f, -0.00524453f, -0.04418908f, 0.00255631f, 0.02976664f, -0.00927961f, 
    0.02024260f, -0.00522893f, 0.01821120f, -0.00068838f, 0.00104038f, 0.03298638f, -0.02580541f, 0.00813245f, 
    -0.01047798f, 0.02915973f, -0.02760262f, 0.02156046f, 0.04100919f, -0.03156587f, -0.01304720f, 0.03650288f, 
    0.02335344f, 0.03137115f, 0.05118196f, 0.03621615f, -0.00617215f, -0.02400357f, 0.03325929f, -0.03321046f, 
    -0.01467766f, 0.03190709f, 0.03583017f, 0.03749759f, 0.01339582f, 0.04034333f, -0.03040868f, 0.03397579f, 
    -0.04887840f, 0.01588511f, -0.01142899f, -0.02887709f, -0.03582503f, -0.02639646f, 0.02124544f, -0.05343403f, 
    0.02544363f, -0.00540083f, 0.02589225f, -0.04441803f, 0.01782725f, -0.01999208f, 0.01558838f, -0.02473607f, 
    0.01274228f, 0.03516911f, -0.02825686f, -0.01100520f, -0.01273960f, -0.01935705f, -0.01050542f, 0.01559913f, 
    0.01644327f, -0.05476265f, -0.04791532f, -0.01519503f, 0.01313320f, 0.01378878f, 0.01783385f, -0.01786401f, 
    0.04263109f, -0.03773075f, 0.03112261f, -0.00165242f, -0.02097622f, -0.01612458f, -0.01555214f, -0.05486500f, 
    0.01084262f, 0.05293140f, -0.02404355f, 0.03321352f, -0.03559112f, -0.05484118f, 0.02643137f, -0.01872526f, 
    0.04185620f, 0.03822559f, -0.02098095f, -0.03044615f, -0.03792704f, 0.02021290f, 0.04133181f, -0.03725000f, 
    -0.01650522f, -0.05558413f, 0.00922104f, -0.02483997f, 0.03527321f, -0.05005010f, -0.03903316f, -0.03550990f, 
    -0.05076831f, -0.00881951f, 0.00507830f, -0.01329052f, 0.04786627f, -0.03272491f, 0.04884843f, 0.00601434f, 
    0.01978322f, -0.03534182f, -0.04290788f, 0.03851630f, -0.02368361f, 0.04104770f, 0.04297212f, 0.02881751f, 
    0.02265174f, -0.01665163f, 0.03114132f, 0.00611603f, 0.03874568f, -0.01216604f, -0.01103412f, 0.01935440f, 
    -0.01496637f, -0.01643870f, 0.00565837f, 0.04269730f, -0.05355545f, -0.01736795f, 0.02186566f, -0.04914232f, 
    0.01869693f, 0.02964917f, -0.03563975f, -0.03617960f, -0.01100130f, -0.03910638f, -0.02403187f, -0.00840340f, 
    -0.00560777f, -0.01172088f, -0.04948184f, 0.01345338f, -0.05020089f, 0.00146101f, -0.00188696f, 0.03990203f, 
    -0.00143810f, 0.03687370f, -0.01940193f, -0.01794344f, 0.01761601f, 0.03483396f, 0.02476938f, -0.00906266f, 
    0.01792737f, 0.02705011f, -0.01124306f, -0.05566043f, -0.02256492f, 0.02275592f, -0.01652728f, 0.00012515f, 
    -0.03515550f, -0.04511333f, -0.04994044f, -0.05154662f, 0.02865678f, -0.04494221f, -0.03441558f, -0.00308547f, 
    -0.03487602f, 0.03635500f, -0.03742365f, 0.02670385f, -0.04950981f, -0.04701166f, 0.01628989f, -0.01403560f, 
    0.03239622f, 0.01369156f, 0.00565502f, -0.02272210f, -0.02482111f, -0.05239744f, 0.04302447f, 0.00393357f, 
    -0.03219049f, -0.00636552f, 0.02920902f, -0.04038566f, -0.02646140f, 0.04435818f, 0.01005408f, 0.03414408f, 
    0.00644757f, 0.01885090f, -0.04232465f, -0.01326913f, -0.02446251f, 0.00641555f, 0.02694385f, -0.03091195f, 
    -0.01292486f, -0.01599831f, 0.01450337f, -0.04820418f, 0.01237922f, 0.00353627f, 0.00508086f, -0.00530677f, 
    -0.01795195f, -0.00949188f, -0.01716788f, 0.04090945f, 0.01462988f, -0.04826137f, -0.00641039f, 0.03673309f, 
    0.01483596f, -0.00785746f, -0.00866945f, 0.00127856f, -0.00383645f, -0.05491859f, 0.03948954f, -0.02356604f, 
    -0.05659473f, -0.01496346f, -0.03653110f, 0.03790087f, 0.02613926f, 0.01682455f, 0.00077360f, 0.03001873f, 
    -0.01508638f, 0.03481774f, -0.01543291f, 0.02629158f, -0.04231193f, 0.02394986f, 0.00625867f, 0.00128204f, 
    -0.03860993f, -0.01182786f, -0.05568729f, -0.04850816f, -0.02395894f, -0.00914516f, 0.01614491f, -0.00758799f, 
    0.04025437f, -0.03336568f, 0.01904595f, 0.03442398f, 0.03927344f, -0.05497306f, -0.03102608f, -0.03829814f, 
    -0.02134037f, 0.03303796f, 0.03298198f, 0.02560104f, -0.03388479f, 0.02968988f, -0.01268168f, 0.04267845f, 
    -0.04266055f, 0.01574476f, -0.00881206f, 0.02237861f, -0.02181613f, -0.05636505f, -0.00158020f, 0.02392854f, 
    -0.01115702f, 0.03916590f, -0.01348046f, 0.03702391f, 0.03944373f, -0.05332070f, 0.04258558f, -0.00063312f, 
    0.03640277f, 0.01071182f, -0.05378399f, -0.02427810f, 0.04379557f, 0.03851961f, -0.04337122f, 0.02312122f, 
    -0.05514050f, -0.04546288f, -0.04719403f, -0.01536146f, -0.02659605f, -0.02146938f, 0.02257441f, -0.02627226f, 
    0.01272508f, -0.03546073f, -0.01633562f, -0.00068491f, 0.03723076f, -0.00606183f, -0.05333563f, -0.00069950f, 
    -0.03325902f, -0.02219536f, -0.04790467f, -0.02375287f, 0.02549398f, -0.02749450f, 0.01599039f, 0.04440095f, 
    0.02654839f, -0.04153998f, 0.03969002f, -0.02484398f, -0.02976238f, -0.00231077f, 0.02583781f, -0.05398212f, 
    -0.05676973f, 0.03222770f, 0.01490549f, -0.03662062f, -0.03232941f, 0.03794196f, 0.01891650f, -0.05484176f, 
    0.02226757f, -0.03163400f, -0.01683336f, -0.01363585f, -0.04509603f, 0.00022999f, 0.00158707f, 0.01585383f, 
    -0.00269811f, -0.02579184f, -0.05612451f, 0.02165811f, 0.01212835f, -0.02188042f, -0.02546155f, 0.01721177f, 
    0.04481249f, 0.00621923f, 0.03631986f, -0.00224911f, -0.03584222f, -0.04177028f, -0.00986833f, -0.00389245f, 
    0.01692430f, -0.01290846f, -0.03352726f, -0.02048003f, -0.00778139f, 0.00514144f, -0.01323810f, -0.05587097f, 
    0.00360239f, -0.03156313f, 0.01993451f, 0.04347973f, -0.03442981f, -0.03928817f, -0.04778014f, -0.01588666f, 
    0.00479820f, 0.03940998f, -0.05136332f, 0.04186689f, -0.03906019f, 0.02614414f, -0.00014665f, -0.00558104f, 
    0.01417436f, 0.03156362f, -0.04398405f, 0.01641597f, -0.02177873f, -0.02960190f, -0.02318002f, -0.05531632f, 
    0.03115636f, -0.04625845f, -0.04683687f, -0.04733914f, -0.03314802f, 0.02743451f, 0.03633151f, -0.01129309f, 
    -0.02656733f, 0.00561448f, 0.01474840f, 0.01272022f, -0.02925660f, -0.04145493f, 0.00906339f, -0.00526485f, 
    -0.01169159f, -0.04381749f, 0.01887430f, 0.00419723f, -0.00861680f, -0.00491533f, -0.05682497f, -0.02268182f, 
    -0.02891535f, 0.01742360f, 0.00570728f, 0.03241038f, -0.03153639f, 0.04939063f, 0.04926539f, -0.00641775f, 
    0.04911946f, -0.00698901f, 0.04023958f, -0.02031533f, -0.01494627f, -0.01260018f, -0.03512765f, 0.04732686f, 
    -0.03550915f, 0.01789403f, -0.03658579f, -0.03229629f, -0.01870403f, -0.03691886f, -0.03102434f, -0.04253579f, 
    0.04011767f, 0.04083544f, -0.04415679f, -0.01499529f, -0.04923228f, -0.02764011f, 0.00750485f, 0.03175250f, 
    -0.05043644f, -0.03944832f, 0.01196577f, 0.02607067f, -0.00230575f, 0.01185029f, 0.01290077f, -0.03055395f, 
    -0.00117508f, -0.02589007f, -0.01487799f, 0.01930020f, 0.01982396f, 0.00419177f, 0.03121091f, -0.04984310f, 
    0.03420221f, -0.01335050f, 0.04119954f, 0.00087840f, -0.04438426f, 0.03567781f, -0.01909096f, 0.03047326f, 
    0.02661231f, -0.01047467f, 0.00447650f, 0.02421002f, 0.01323862f, -0.01413656f, 0.00302116f, 0.03557817f, 
    -0.04594992f, 0.03395872f, 0.02030738f, 0.01327671f, 0.04784650f, 0.01284529f, -0.04662740f, 0.00302817f, 
    -0.04010915f, 0.00167260f, 0.01020032f, 0.02390899f, -0.03552801f, 0.02185216f, 0.04153247f, -0.03527853f, 
    -0.00743786f, 0.04034862f, 0.02480113f, -0.01417709f, -0.03699734f, -0.05567219f, 0.04040076f, -0.02509756f, 
    -0.00885306f, -0.00360718f, 0.01677005f, 0.00606794f, -0.01428735f, 0.03541448f, -0.04622469f, 0.01101345f, 
    0.03675656f, -0.05166003f, 0.02626496f, 0.00339280f, 0.02609650f, -0.01212003f, -0.02813951f, 0.02708619f, 
    -0.00728020f, -0.03297596f, 0.00275664f, -0.05039974f, 0.03693384f, 0.02763887f, 0.01466098f, -0.04134440f, 
    0.00398102f, -0.04125790f, -0.00660521f, -0.00296244f, 0.01937275f, 0.04736057f, -0.04844764f, 0.01678917f, 
    0.03682662f, 0.02235975f, -0.01804258f, -0.01171977f, -0.03709840f, -0.02356861f, -0.01133486f, 0.01819348f, 
    -0.05064503f, -0.01313452f, 0.02423092f, -0.02301437f, 0.01051800f, 0.01287462f, 0.04246346f, -0.02867106f, 
    0.03771115f, 0.01057880f, 0.02735014f, -0.05006311f, 0.01559898f, -0.05172827f, 0.03613128f, -0.03070887f, 
    0.00634128f, -0.03132207f, 0.02700226f, 0.02728047f, 0.03907821f, 0.00020277f, -0.04284499f, -0.01795148f, 
    -0.00674428f, 0.04993717f, -0.03774909f, -0.04654206f, 0.02848661f, -0.02121067f, -0.03763681f, -0.00447134f, 
    -0.01695790f, -0.01204027f, -0.04024527f, 0.02087968f, 0.03463189f, -0.04480787f, -0.01713535f, 0.01376182f, 
    -0.03896114f, -0.04333445f, -0.03570869f, 0.01199000f, 0.03004541f, 0.03256711f, -0.03605487f, -0.03815378f, 
    0.02388191f, -0.05085963f, -0.02340586f, -0.02267092f, 0.04192017f, -0.00939026f, -0.00472726f, -0.00929241f, 
    -0.01744406f, -0.02557643f, 0.03538402f, 0.02610428f, 0.04282625f, -0.04705093f, 0.02258568f, -0.00981048f, 
    0.03850029f, 0.02573421f, 0.03937903f, -0.03437173f, -0.02402162f, 0.00433253f, 0.02234727f, 0.04627696f, 
    0.02963950f, -0.04341897f, -0.00917753f, 0.03030136f, 0.01257795f, -0.01691089f, 0.02738435f, 0.01618342f, 
    -0.05279752f, 0.02268363f, 0.05039757f, -0.01472982f, -0.01978757f, -0.04781562f, -0.02446599f, -0.02438738f, 
    -0.02947834f, -0.03765146f, 0.05044553f, -0.01266332f, -0.01997531f, -0.03119387f, 0.00010322f, 0.02053772f, 
    0.04209018f, -0.03809533f, 0.03341572f, 0.01304625f, -0.01418267f, 0.03918793f, -0.02542700f, -0.03610156f, 
    -0.05274893f, -0.04872809f, 0.03314527f, -0.04082289f, -0.01064811f, -0.03910818f, -0.04936027f, -0.02093337f, 
    -0.04129184f, 0.05030402f, -0.02245216f, -0.03186468f, 0.02988086f, 0.01202020f, 0.04246576f, -0.00429888f, 
    0.01560932f, -0.05802518f, 0.01580635f, -0.03702964f, -0.01377574f, -0.00810905f, 0.03797836f, 0.02980481f, 
    -0.01924837f, -0.03672116f, -0.03610650f, -0.05105071f, 0.00698926f, -0.00806679f, -0.03124220f, 0.00499707f, 
    0.03039610f, -0.02391941f, -0.01293375f, 0.01071605f, -0.02326155f, -0.03372703f, -0.03731003f, -0.04073105f, 
    -0.00693810f, -0.00475912f, -0.01370114f, 0.00420843f, 0.03321943f, -0.03603474f, 0.00809713f, -0.04869333f, 
    -0.03113619f, 0.02343490f, 0.04107248f, 0.03269451f, 0.02677680f, 0.00694031f, -0.04720671f, 0.00894456f, 
    0.03551168f, -0.04510127f, 0.03752695f, -0.03821911f, 0.03585168f, 0.02393335f, -0.01600702f, 0.03445393f, 
    -0.01546724f, 0.00418264f, -0.02928445f, -0.04153004f, -0.04927579f, -0.03552816f, -0.02173684f, 0.05124264f, 
    0.04664030f, -0.05835386f, 0.04175901f, -0.03695448f, -0.02889709f, 0.04145131f, -0.00869549f, 0.03048132f, 
    -0.00778046f, -0.05529717f, -0.04816876f, 0.02096868f, -0.03446211f, 0.00115490f, -0.03029266f, -0.02909195f, 
    -0.02448152f, -0.04328043f, 0.02913865f, -0.04492237f, 0.00261404f, -0.04308510f, -0.04285130f, 0.03712487f, 
    -0.05775146f, -0.01926267f, -0.01479401f, 0.03249440f, 0.01438429f, 0.01294932f, -0.03089478f, -0.03632553f, 
    -0.05596320f, 0.02080274f, -0.01888670f, 0.03620648f, -0.03628972f, 0.03671633f, 0.01064479f, -0.01264858f, 
    -0.03026719f, -0.02756478f, -0.03968158f, -0.05095237f, -0.03818214f, -0.02200702f, 0.04082296f, -0.00187879f, 
    0.05221672f, 0.02043206f, -0.04221096f, 0.03487413f, -0.01130439f, -0.01171993f, -0.03284341f, -0.02097135f, 
    0.02802185f, 0.01254889f, 0.02413773f, 0.00730564f, 0.01649060f, 0.01911856f, 0.05204949f, -0.04425881f, 
    -0.02145670f, 0.02914242f, 0.01083512f, -0.04358375f, -0.05695021f, 0.03235175f, -0.04108333f, -0.01551526f, 
    0.00426809f, -0.00182664f, 0.01159610f, 0.01913774f, -0.01185454f, -0.04038835f, 0.03082262f, 0.01046381f, 
    0.35033107f, 0.09989900f, -0.24881057f, -0.06429366f, 0.00007921f, -0.11214484f, -0.00423509f, -0.11441613f, 
    -0.01488954f, 0.00094834f, -0.05413714f, -0.09751090f, -0.24836563f, -0.00372903f, -0.01890819f, -0.14567924f, 
    0.00658108f, 0.08529034f, -0.05930570f, 0.21142891f, 0.04590693f, -0.04516285f, -0.03746000f, 0.04783812f, 
    0.10859057f, -0.07912178f, -0.00193764f, 0.19290535f, 0.07646392f, 0.12855153f, -0.13590612f, -0.08511648f, 
    0.09965198f, 0.07851996f, -0.01455652f, -0.04190663f, -0.09207860f, -0.18493308f, 0.25518158f, 0.03052983f, 
    -0.10239530f, -0.09346887f, -0.30057871f, 0.00055678f, 0.06328081f, 0.01446982f, 0.07081012f, 0.06321584f, 
    0.09014495f, -0.02194146f, 0.01294157f, -0.38194957f, -0.11213958f, -0.03102224f, 0.03097730f, 0.12911974f, 
    0.10295530f, -0.08031433f, 0.20570490f, -0.04108860f, -0.28245813f, 0.24434489f, -0.03606755f, -0.10989396f, 
    0.06957053f, -0.03542900f, -0.08326533f, -0.12752242f, -0.08514133f, 0.10449721f, -0.13760068f, 0.06963199f, 
    0.53848177f, -0.27496246f, -0.09946278f, -0.37509680f, -0.02250284f, -0.00004209f, -0.11126598f, -0.01521321f, 
    -0.22201289f, 0.01868912f, 0.03182001f, 0.02866357f, -0.03000072f, 0.06672046f, -0.01956103f, 0.23817389f, 
    0.14326766f, -0.02457040f, 0.03754816f, -0.04165477f, 0.02874425f, 0.04849827f, 0.12941550f, 0.15259032f, 
    -0.24937069f, 0.60767657f, -0.17009656f, -0.07399541f, 0.03270840f, 0.07228730f, 0.09659963f, -0.01989820f, 
    -0.05317059f, -0.03143306f, 0.10787256f, -0.02859580f, -0.15603878f, -0.15789758f, 0.13663469f, 0.21555218f, 
    0.03332041f, -0.10696185f, 0.21194337f, 0.05962113f, -0.01255076f, 0.02339833f, 0.17323323f, 0.39962450f, 
    0.58882558f, -0.22704202f, 0.27432069f, -0.00042013f, -0.16026068f, 0.16370621f, -0.01165945f, 0.00235716f, 
    -0.00195439f, 0.05643360f, 0.24191767f, -0.02065831f, -0.03084026f, -0.10894390f, 0.00033080f, 0.14919817f, 
    0.12890774f, 0.07393216f, 0.17483251f, 0.07179644f, 0.15197684f, 0.04017792f, 0.03281834f, -0.00934043f, 
    0.22636022f, -0.33530283f, -0.11786569f, 0.14089175f, 0.03459836f, -0.02037715f, 0.02798751f, 0.08076845f, 
    -0.05434161f, -0.12157038f, -0.00816812f, 0.07879726f, -0.40356600f, -0.05766695f, -0.18153927f, -0.04763675f, 
    0.07114929f, -0.14004007f, 0.22613990f, -0.02303494f, -0.05328688f, 0.03531589f, 0.11093395f, 0.00828688f, 
    0.07674469f, -0.00758663f, -0.00517635f, 0.07392640f, 0.09985454f, -0.08494089f, -0.26668063f, -0.02427685f, 
    -0.01368263f, -0.12388656f, 0.12578362f, -0.06578867f, 0.32604244f, -0.38340881f, -0.02887885f, 0.06350055f, 
    0.11121526f, -0.04068518f, -0.21340799f, 0.01570618f, 0.08075975f, -0.01633711f, 0.13546826f, 0.06194107f, 
    0.01458722f, -0.05132634f, -0.05230556f, 0.08421312f, -0.07688584f, 0.04179555f, -0.06016003f, -0.09004872f, 
    0.13845067f, 0.24253443f, 0.16093428f, 0.10632902f, 0.37393656f, -0.04179794f, -0.31150091f, -0.05681685f, 
    -0.15131035f, -0.02149104f, -0.02818285f, 0.06113672f, -0.18621118f, 0.06641871f, 0.01745907f, -0.27962345f, 
    -0.22282746f, 0.05128046f, 0.47196823f, 0.24522868f, 0.00588806f, -0.09368494f, -0.04531043f, -0.06675957f, 
    0.07571068f, -0.15187964f, -0.02652251f, 0.08065318f, -0.03409703f, -0.42411694f, 0.01690143f, -0.11157770f, 
    0.03955325f, 0.01815310f, -0.06624210f, 0.14919640f, 0.00710885f, 0.05115360f, 0.01472959f, -0.00057291f, 
    -0.26200297f, -0.15676449f, 0.16477802f, -0.05556129f, 0.18929976f, 0.11230683f, 0.11160383f, -0.13430649f, 
    0.02739450f, 0.05690882f, 0.12615877f, 0.05174854f, -0.07439829f, 0.01837686f, 0.12262847f, 0.39146218f, 
    0.05126221f, 0.02654824f, 0.06767218f, -0.05116352f, 0.03598278f, 0.02112138f, 0.12150511f, -0.07158860f, 
    0.08646075f, 0.23383515f, -0.00746457f, 0.23002303f, 0.16511320f, -0.01487687f, -0.12152030f, -0.00091309f, 
    0.07041968f, 0.01304814f, 0.01353006f, -0.09379029f, 0.00340963f, 0.14440636f, -0.24823070f, 0.50541550f, 
    0.06237253f, -0.15397307f, 0.06357650f, -0.21166113f, 0.10905857f, 0.25845033f, -0.13644311f, 0.00184387f, 
    -0.07180517f, -0.11003879f, 0.09528512f, 0.15927805f, 0.07148505f, 0.03433766f, -0.07298106f, 0.00473962f, 
    0.05790849f, -0.10918797f, 0.11871465f, 0.08133223f, -0.08584880f, -0.22933125f, 0.03537813f, 0.29576674f, 
    0.12009127f, 0.00549103f, 0.05370564f, -0.03049469f, 0.06752723f, 0.08046911f, -0.12188074f, 0.02302989f, 
    -0.18099512f, -0.34807655f, 0.09732557f, 0.20286782f, 0.10336276f, 0.06959526f, 0.08428495f, 0.01742077f, 
    -0.00258514f, -0.13412611f, 0.12233432f, 0.01882578f, -0.22146384f, -0.01661925f, 0.05872501f, -0.09913632f, 
    0.00498355f, -0.13892686f, -0.15100352f, -0.10592927f, 0.01304038f, -0.06284640f, 0.01884530f, -0.22313699f, 
    0.67002106f, 0.13793488f, -0.33872363f, -0.11577423f, 0.14174831f, -0.06149600f, 0.20381618f, -0.04265358f, 
    0.01370485f, -0.02040591f, 0.10496455f, 0.11680055f, -0.01699006f, 0.44957295f, 0.33851629f, -0.22050172f, 
    0.00093929f, -0.01930264f, -0.22011110f, -0.03670618f, -0.21050383f, 0.05089965f, -0.21238884f, 0.05464166f, 
    0.11637109f, -0.07302074f, -0.03199774f, 0.22249569f, 0.05561764f, 0.01992448f, -0.03517984f, 0.06764300f, 
    0.08252773f, 0.22676106f, -0.08347076f, -0.05747311f, 0.22815885f, -0.09747523f, -0.22419430f, -0.05704280f, 
    0.17493375f, -0.11304042f, 0.10633471f, 0.02471287f, -0.08216347f, 0.08870076f, -0.02006814f, 0.12252154f, 
    0.07255374f, 0.01549402f, 0.23922385f, 0.24557276f, 0.12114149f, 0.28447440f, 0.01627699f, 0.09406078f, 
    -0.22124949f, 0.13310368f, -0.11300197f, 0.04850908f, -0.13672766f, -0.12504560f, -0.20847376f, 0.05956265f, 
    -0.15394148f, -0.10517388f, -0.05449579f, -0.02115284f, 0.09143607f, -0.06246469f, -0.14838102f, 0.08454179f, 
    -0.06178753f, -0.00444515f, -0.00363888f, 0.15963495f, 0.04026405f, -0.01531462f, 0.18142912f, 0.10667893f, 
    0.05327260f, 0.08689947f, 0.18892251f, 0.13906987f, -0.22796698f, -0.23266701f, 0.02518113f, -0.00553373f, 
    -0.05116581f, 0.06105476f, 0.11184614f, -0.09960378f, -0.11107164f, 0.00724463f, -0.07002603f, -0.06842645f, 
    -0.26061019f, -0.18927215f, 0.11355104f, -0.22852479f, -0.11560359f, -0.16418508f, 0.05334419f, 0.03986529f, 
    0.00531782f, 0.05754678f, -0.08737028f, 0.01595322f, 0.14483592f, 0.14682046f, 0.23987977f, 0.03691804f, 
    0.07289853f, -0.22513963f, 0.07812445f, 0.17124191f, 0.09025525f, 0.13056283f, -0.03318332f, 0.07294049f, 
    0.08687099f, 0.04276799f, 0.11784368f, -0.12747021f, -0.13901986f, 0.11640506f, -0.04615827f, 0.08079808f, 
    0.17537777f, 0.16995846f, -0.07692666f, 0.23534022f, 0.12558883f, 0.19632584f, 0.10822997f, 0.12512463f, 
    0.02603782f, 0.02762054f, 0.17965561f, 0.04143782f, -0.12302420f, -0.26127261f, 0.00670626f, -0.02580879f, 
    0.26448175f, 0.05559982f, -0.23177974f, -0.02957860f, -0.01717225f, -0.01774755f, -0.10666525f, 0.12591483f, 
    0.03503528f, 0.05803089f, 0.03927495f, -0.16137643f, 0.02906552f, 0.22931041f, 0.10366829f, -0.10167140f, 
    0.12157904f, 0.03700985f, 0.11479791f, 0.04095455f, -0.15366529f, -0.01278706f, 0.05474683f, -0.15997323f, 
    -0.00876559f, -0.18817891f, -0.21079090f, 0.08947255f, -0.05009654f, 0.08187839f, -0.16513436f, 0.00307858f, 
    0.07479329f, -0.10385091f, -0.11304947f, -0.15955560f, 0.16771862f, 0.09137476f, 0.29593003f, 0.11314564f, 
    -0.03248239f, 0.11680103f, 0.11880336f, 0.14707400f, -0.09195959f, -0.05241746f, -0.00214818f, 0.09917272f, 
    -0.20979732f, 0.11251553f, -0.21996050f, -0.06898521f, 0.15088713f, -0.05179428f, 0.06712065f, 0.20568487f, 
    0.05193250f, 0.01035346f, -0.01787018f, -0.07464425f, 0.09350988f, -0.30225244f, -0.11382777f, -0.09151415f, 
    -0.00386169f, 0.00967674f, -0.18099143f, 0.04790257f, 0.05304766f, -0.08596958f, 0.12588747f, 0.10893480f, 
    -0.17559855f, -0.15772246f, -0.19858149f, -0.12920211f, -0.14081921f, -0.09812137f, -0.12868929f, 0.02961849f, 
    0.20939459f, 0.20922905f, -0.02327706f, 0.06947341f, 0.03284084f, 0.11685961f, 0.15783368f, 0.10285922f, 
    -0.15883920f, 0.06782107f, 0.02356407f, 0.10962311f, -0.01757613f, -0.04462789f, 0.07553454f, 0.06214198f, 
    -0.36635870f, -0.15038671f, -0.36278999f, -0.13994154f, 0.05443925f, -0.01881997f, -0.02648445f, -0.03112598f, 
    -0.03925662f, -0.25140804f, 0.04564643f, -0.32310009f, 0.22330460f, 0.00299063f, -0.15456884f, 0.14815676f, 
    -0.18391876f, 0.00605570f, 0.16894715f, 0.14758107f, -0.03378466f, -0.07427409f, -0.07173816f, 0.19538511f, 
    -0.22265501f, -0.18744929f, -0.08922406f, -0.02342990f, 0.15294099f, -0.02428323f, 0.06058859f, 0.08383644f, 
    0.15626904f, 0.04887257f, 0.13801283f, 0.25637007f, 0.08418256f, -0.18873367f, -0.13266057f, -0.25271523f, 
    -0.08721498f, -0.02031194f, -0.13186900f, 0.06744488f, 0.08161214f, -0.05213230f, -0.00891060f, 0.03886387f, 
    -0.24190958f, 0.06132593f, 0.03505192f, -0.00317003f, 0.11481423f, -0.09189118f, 0.16306494f, 0.02296023f, 
    -0.03173532f, 0.06351406f, -0.07644327f, -0.16844861f, 0.11536446f, 0.27763492f, 0.16402213f, 0.18186143f, 
    0.13056077f, 0.08540573f, 0.05693397f, -0.02674902f, -0.13952346f, 0.01399255f, 0.00734831f, -0.02483330f, 
    -0.01894663f, 0.03976566f, 0.16537185f, 0.27309737f, 0.09535700f, 0.08095164f, 0.04671149f, 0.16858302f, 
    -0.12430694f, 0.12713028f, 0.06820850f, -0.02860106f, -0.00990371f, 0.06243740f, -0.02576372f, -0.03621491f, 
    0.04376150f, -0.08962155f, -0.02692052f, -0.12342300f, 0.02422062f, 0.09938857f, -0.08135015f, -0.27269793f, 
    0.10051115f, 0.31436762f, 0.33452243f, -0.17564826f, 0.11328936f, -0.07895955f, 0.13083915f, 0.01271929f, 
    -0.12611866f, -0.02264155f, -0.08653588f, 0.00472498f, 0.21537229f, 0.24689035f, 0.03289825f, 0.13870142f, 
    -0.07045892f, -0.03949077f, 0.01220707f, 0.07318719f, -0.00732229f, 0.06429041f, -0.05520913f, 0.13162614f, 
    -0.02109527f, 0.08675638f, -0.07309569f, -0.26363388f, -0.07510804f, -0.09327891f, -0.07434898f, 0.13658309f, 
    0.08859891f, -0.06586808f, -0.01646372f, -0.03182277f, -0.47930950f, -0.14443392f, -0.21960780f, -0.03907495f, 
    -0.01824670f, -0.10192896f, -0.02978603f, -0.03276470f, 0.17525114f, 0.03737819f, 0.01417642f, -0.03757428f, 
    -0.04962410f, 0.04066175f, -0.17488778f, -0.21084258f, 0.00432149f, -0.04237996f, 0.03033508f, 0.12762049f, 
    0.04145379f, 0.06071736f, -0.08161727f, -0.22884871f, -0.08320891f, -0.00945140f, -0.21463825f, 0.04184595f, 
    -0.03421390f, 0.20464829f, 0.04226778f, 0.11767919f, 0.19808660f, -0.00677776f, 0.12495935f, 0.17547907f, 
    0.23140112f, 0.14757198f, 0.30366901f, 0.19038114f, 0.07657582f, 0.10756649f, 0.11271440f, 0.09305111f, 
    0.12656654f, -0.14187075f, -0.05922064f, 0.05072404f, -0.04653179f, 0.22284713f, 0.12073392f, 0.01657331f, 
    -0.07343166f, -0.10780984f, 0.03915817f, 0.13515826f, -0.15654770f, 0.06169229f, 0.04271483f, 0.03695622f, 
    0.11713590f, -0.11166704f, 0.32709351f, -0.18886803f, 0.10592860f, -0.00793607f, 0.10980326f, 0.18223609f, 
    -0.03010477f, 0.07230545f, 0.06278146f, 0.04366582f, 0.11266550f, 0.18834743f, 0.00639463f, 0.12267154f, 
    -0.16539021f, -0.14049260f, -0.06694295f, -0.06087478f, -0.06716637f, 0.14298727f, -0.03866929f, -0.11274677f, 
    0.26856598f, 0.01762492f, 0.13180043f, -0.11275672f, 0.09679309f, -0.05639398f, 0.06100769f, 0.19325139f, 
    -0.01504617f, 0.15383428f, 0.04289585f, 0.12795860f, -0.27313045f, 0.09687015f, 0.09141585f, -0.08630200f, 
    -0.03238997f, -0.01130912f, -0.20192817f, -0.14726324f, -0.18163417f, -0.03527243f, -0.08056068f, -0.14155483f, 
    -0.12068481f, 0.04346488f, 0.06892686f, 0.04185256f, -0.04425761f, -0.05182054f, -0.19802350f, -0.26267096f, 
    -0.19500245f, -0.03531970f, -0.19094257f, 0.05233498f, 0.38523120f, 0.17772780f, 0.05994414f, -0.05079485f, 
    0.07520814f, 0.04716372f, 0.08003853f, 0.31443989f, 0.04816465f, 0.06075414f, 0.13906632f, -0.06235518f, 
    -0.15924403f, 0.30323300f, -0.08190186f, -0.08435640f, -0.12554213f, -0.00311534f, 0.18910328f, -0.04589648f, 
    0.05027090f, 0.02120446f, 0.07513376f, 0.15155391f, 0.19452100f, -0.09097107f, -0.09767392f, -0.06202315f, 
    0.06447908f, 0.03829892f, -0.01718311f, 0.02019669f, -0.04518638f, -0.13679625f, 0.00711993f, 0.01472782f, 
    0.43854040f, -0.19898075f, 0.11702830f, 0.09879725f, -0.06289629f, -0.04176060f, 0.06192118f, 0.01750704f, 
    0.10308989f, 0.00677725f, -0.02448972f, -0.11510172f, 0.35193682f, 0.23227800f, 0.03402422f, 0.01946722f, 
    0.16625275f, 0.09596621f, -0.07231740f, -0.04077598f, -0.01905340f, 0.01588898f, -0.01590872f, -0.14890352f, 
    -0.24675426f, 0.11446965f, 0.38294965f, -0.03619470f, -0.00710085f, -0.10417078f, -0.00668816f, 0.04563512f, 
    -0.04733805f, -0.03013978f, -0.16696133f, 0.01611373f, 0.10926784f, 0.02591889f, -0.15337923f, 0.10958757f, 
    0.09096680f, 0.17395772f, 0.01724003f, -0.01918596f, -0.14061889f, -0.00776284f, 0.12147308f, 0.06353207f, 
    -0.04139080f, 0.12391952f, 0.17433865f, -0.00521078f, 0.17795669f, -0.00508661f, -0.10849443f, 0.02113542f, 
    0.07893380f, 0.07667529f, 0.16437526f, 0.00228014f, 0.32246926f, 0.21273081f, -0.12178347f, 0.25845614f, 
    -0.04974439f, 0.02457687f, -0.07807307f, -0.04393147f, 0.15507613f, 0.07156409f, 0.10845909f, 0.18527041f, 
    -0.24362452f, 0.03031257f, -0.02619088f, -0.11734790f, -0.07134602f, -0.05168340f, 0.08102027f, -0.12686923f, 
    -0.07225709f, 0.11552170f, -0.06124877f, 0.11442193f, -0.09018859f, 0.40029377f, -0.01014764f, -0.05249322f, 
    -0.07924038f, 0.20276733f, 0.22295319f, 0.05073119f, -0.03879745f, 0.03884186f, -0.11955093f, 0.04050774f, 
    -0.10960811f, 0.13372952f, 0.05929495f, 0.14058624f, -0.01724649f, -0.06316704f, -0.01252595f, -0.00002261f, 
    -0.08649667f, -0.14040384f, -0.15506367f, -0.02648788f, -0.20832562f, 0.07746261f, 0.25795591f, -0.03542968f, 
    0.22259632f, 0.05480566f, -0.13425626f, -0.08109600f, 0.13411945f, -0.05656421f, 0.20373937f, 0.30740890f, 
    -0.01841727f, -0.03287763f, -0.22509879f, -0.01751254f, -0.01609612f, 0.01444596f, -0.07120721f, -0.02897250f, 
    0.01739178f, 0.08316154f, -0.08397724f, 0.01955126f, -0.13545586f, 0.09100444f, -0.38403758f, -0.16963898f, 
    -0.07304945f, 0.05420731f, 0.05163705f, -0.16425978f, -0.10013911f, 0.04133635f, -0.03007192f, 0.11654897f, 
    0.12076134f, 0.10364094f, -0.04365637f, -0.05688253f, 0.03182021f, -0.03340385f, -0.11010727f, 0.17898455f, 
    -0.07078002f, -0.01892737f, 0.05206319f, -0.06157769f, -0.00609078f, -0.06485061f, 0.00311711f, -0.14162061f, 
    -0.02811310f, 0.00975822f, -0.04374228f, 0.01785059f, 0.05845822f, 0.02802903f, 0.01597946f, 0.12111235f, 
    0.12260053f, -0.30438158f, 0.17089576f, -0.01791948f, 0.04673561f, 0.11752394f, 0.08696476f, 0.06961423f, 
    0.07693523f, 0.03526208f, 0.11331687f, 0.03445473f, 0.17984702f, -0.25862128f, 0.11480077f, -0.16682208f, 
    -0.01414871f, 0.04980625f, -0.05935866f, 0.20721532f, -0.01162155f, 0.01374854f, 0.06497926f, 0.04918704f, 
    0.08355727f, 0.12844704f, -0.12928922f, 0.03087894f, 0.12165039f, -0.01221022f, 0.14352757f, 0.05881242f, 
    -0.08690104f, 0.07035848f, -0.02316027f, -0.10052882f, 0.09407443f, 0.12508330f, 0.18155734f, -0.14514001f, 
    0.05462470f, 0.05292518f, -0.10049798f, 0.07437596f, -0.00138270f, 0.02115200f, -0.00954684f, 0.00564678f, 
    -0.06619973f, 0.05632684f, -0.16421303f, -0.13011229f, 0.09133812f, 0.12351147f, -0.08504304f, -0.08162870f, 
    0.02347185f, 0.11196042f, 0.04981291f, 0.02561725f, -0.03612958f, 0.12894791f, -0.00063106f, 0.00224234f, 
    -0.31087074f, -0.14756912f, -0.15861017f, -0.14138816f, -0.09601798f, 0.03164072f, -0.00176577f, 0.10903483f, 
    -0.16039003f, -0.33260301f, -0.05995891f, 0.01649335f, -0.05015234f, 0.11322155f, -0.07104337f, -0.11489278f, 
    -0.16152686f, 0.09650495f, -0.02318380f, 0.03162017f, -0.05186928f, -0.29209790f, -0.10250384f, 0.29263183f, 
    0.01692570f, 0.11353052f, 0.15895995f, -0.15809143f, 0.02582978f, -0.02956169f, 0.12028012f, 0.00437811f, 
    0.00519936f, 0.02330860f, 0.05659471f, -0.00347664f, 0.06585181f, 0.06654833f, 0.07749867f, 0.06786754f, 
    -0.04472254f, -0.09418195f, 0.14998206f, 0.16595992f, 0.05027488f, 0.19815680f, 0.04509873f, 0.01986000f, 
    -0.04119909f, -0.00449011f, -0.07567912f, -0.10160744f, 0.02250335f, 0.01632049f, -0.01823794f, -0.02353907f, 
    -0.01640648f, 0.04012707f, -0.04275480f, -0.02365419f, 0.01389743f, 0.00550093f, -0.00888958f, 0.02429148f, 
    -0.01149092f, 0.00391112f, 0.01524817f, 0.03945039f, -0.01859388f, -0.04790938f, 0.02717613f, 0.04061843f, 
    0.04974720f, -0.00807501f, -0.00658911f, 0.02307246f, -0.03737023f, -0.03451877f, -0.00677077f, -0.03877438f, 
    0.00523836f, -0.05698042f, 0.03035965f, 0.02882806f, -0.01288824f, -0.00857922f, -0.00249955f, 0.03508576f, 
    -0.02694887f, -0.05225025f, -0.01054450f, -0.03876702f, 0.00255052f, 0.03901009f, -0.04947119f, -0.04298631f, 
    -0.00386348f, -0.05593847f, -0.01493152f, 0.03535481f, -0.05025158f, 0.00453990f, 0.04555989f, 0.03208161f, 
    -0.02130434f, 0.00379035f, -0.05045745f, -0.00581425f, -0.04219129f, 0.00456622f, -0.04910006f, 0.03047985f, 
    -0.04208785f, 0.00621729f, 0.03960357f, -0.01499751f, 0.04987213f, -0.02805325f, -0.00774360f, -0.00813207f, 
    -0.04932353f, -0.04314763f, -0.02122937f, -0.04986243f, -0.01632126f, -0.06244697f, 0.02234993f, -0.05266096f, 
    -0.04303558f, -0.01058199f, -0.05229948f, 0.02783149f, 0.02793315f, -0.04078766f, 0.00217026f, 0.02918200f, 
    -0.00213877f, -0.02399655f, -0.01635585f, -0.04087971f, -0.01932804f, 0.03619258f, -0.00472614f, -0.04791268f, 
    -0.01191577f, 0.01930663f, 0.03817977f, -0.02860061f, -0.04744100f, -0.02799637f, -0.00109300f, 0.02149481f, 
    0.05364788f, -0.01213907f, 0.01295155f, -0.00543052f, -0.04169386f, -0.00690669f, -0.00638696f, 0.01956982f, 
    -0.00477472f, -0.00994660f, 0.02506896f, -0.03548107f, -0.03073493f, -0.03329457f, -0.02646419f, -0.01666761f, 
    0.01684387f, -0.00729525f, 0.00213964f, 0.00036023f, 0.00562673f, 0.03734154f, 0.00802006f, -0.00301437f, 
    0.03283766f, -0.00701091f, 0.00461034f, 0.03700848f, -0.05445316f, -0.03946139f, 0.04349788f, -0.02965141f, 
    0.02912069f, -0.03220738f, -0.05987965f, -0.05437739f, 0.01649198f, -0.03161770f, -0.05697317f, -0.00133973f, 
    -0.01190273f, -0.02568890f, 0.00186753f, -0.00574564f, 0.02558750f, -0.04099793f, 0.03592611f, -0.02862263f, 
    0.02735434f, -0.05913381f, -0.01972690f, 0.03041789f, 0.01226049f, -0.04260549f, 0.01343867f, -0.05496608f, 
    -0.01834170f, -0.05220566f, 0.04380299f, 0.02549825f, -0.05110365f, -0.02889842f, -0.05712951f, -0.02090510f, 
    -0.02325810f, -0.05869488f, -0.00380581f, -0.00439064f, 0.02248365f, -0.00932648f, -0.03570311f, -0.02243601f, 
    -0.04896967f, -0.06059878f, -0.01630455f, -0.01988043f, 0.03931132f, -0.02068533f, 0.00864365f, 0.01843433f, 
    0.00345493f, -0.03194865f, -0.02224323f, -0.00410827f, 0.01404414f, 0.02156372f, -0.02177502f, 0.02131037f, 
    0.02092209f, -0.00422520f, 0.04077144f, -0.05368551f, -0.02131015f, -0.03562883f, 0.02462861f, -0.05395931f, 
    0.00487074f, 0.02739406f, -0.00526161f, 0.03465037f, 0.00234732f, 0.00754713f, -0.00668583f, 0.01289408f, 
    -0.04215511f, -0.04578336f, 0.03500440f, -0.02645119f, 0.02779820f, -0.03965745f, -0.05610813f, -0.02009561f, 
    0.03099201f, 0.03577052f, -0.03797603f, 0.01047854f, -0.01778273f, 0.01699069f, -0.05366487f, 0.02793769f, 
    0.04245616f, -0.00239385f, 0.02101375f, 0.03692749f, -0.02162459f, -0.01569040f, -0.01090076f, -0.01899260f, 
    -0.00449151f, 0.03856208f, -0.04137642f, 0.01432445f, -0.01451016f, 0.00476523f, 0.03038735f, -0.01957382f, 
    0.01334944f, -0.05708568f, -0.01170767f, -0.00578161f, 0.02364216f, 0.02814820f, 0.01154260f, -0.03459036f, 
    0.00728989f, 0.02019123f, 0.01685469f, -0.03273151f, -0.01923812f, -0.04282715f, 0.01479579f, -0.00220058f, 
    -0.00601019f, 0.01205370f, -0.03372290f, 0.04605986f, 0.02650847f, 0.01538417f, 0.01023371f, 0.00826023f, 
    -0.04230956f, -0.02163758f, 0.00365104f, -0.05251265f, -0.00575232f, 0.02329412f, 0.00560182f, 0.04140262f, 
    0.01076797f, -0.03324317f, -0.02222657f, -0.03038724f, 0.03496975f, -0.04255138f, -0.02979204f, 0.03358974f, 
    -0.02650371f, -0.04514199f, -0.05504324f, -0.00892001f, 0.00303561f, -0.00593456f, -0.02726805f, 0.04263748f, 
    -0.04423674f, -0.00478917f, 0.02534076f, -0.03842932f, -0.01433497f, 0.01515904f, 0.01204560f, 0.02115412f, 
    0.04409606f, -0.03905560f, -0.01983190f, 0.04046363f, 0.04399807f, 0.01063431f, -0.03133472f, -0.03665384f, 
    0.03812929f, -0.00921843f, -0.00090142f, -0.00147703f, -0.03697868f, -0.00647602f, 0.00611694f, 0.01925347f, 
    0.00019028f, -0.01881221f, -0.00075242f, -0.01079966f, -0.05388774f, -0.01400337f, 0.02904367f, 0.00939402f, 
    -0.00508938f, -0.04042626f, 0.02248859f, -0.05881518f, 0.03604871f, -0.04498547f, -0.05103175f, -0.04555208f, 
    0.02769807f, -0.02610753f, 0.00816621f, 0.03908544f, -0.04697595f, -0.00786333f, -0.04726152f, -0.05881795f, 
    -0.06238151f, -0.02222133f, 0.01338784f, 0.00273848f, 0.03590792f, -0.04922917f, -0.01485283f, 0.00016482f, 
    0.04653461f, 0.00967114f, -0.02252522f, -0.03033405f, 0.01662460f, 0.00769371f, 0.04323441f, -0.03681893f, 
    -0.05303039f, 0.03020415f, -0.00764712f, -0.02517370f, -0.01090077f, 0.03108353f, -0.05335681f, 0.00049503f, 
    -0.03582614f, 0.01807515f, 0.01973422f, -0.04577499f, -0.01530921f, -0.05177308f, -0.01660186f, -0.00848387f, 
    -0.03475220f, -0.00227323f, -0.01659092f, -0.05343834f, -0.00519098f, -0.04107170f, -0.00572697f, 0.01691636f, 
    -0.02768188f, 0.00127859f, -0.01797171f, 0.00827861f, 0.03693222f, -0.03850396f, -0.06463990f, 0.03981674f, 
    0.02027551f, 0.01255723f, -0.02139478f, -0.02099272f, 0.02721408f, -0.01067222f, 0.02889360f, -0.00084059f, 
    0.27515364f, 0.03374769f, 0.18263610f, -0.23118597f, 0.01147848f, -0.06392866f, 0.17493489f, 0.02679499f, 
    0.05808888f, 0.07671714f, 0.18037777f, 0.09134689f, 0.03379785f, 0.42957023f, 0.28524724f, 0.11192422f, 
    -0.12270664f, -0.08800468f, -0.05638888f, -0.06336823f, 0.02598410f, 0.30616024f, 0.05378785f, 0.00055286f, 
    0.41086444f, -0.10080890f, 0.13901392f, 0.08611725f, -0.05497900f, -0.04367502f, 0.06474307f, 0.08308695f, 
    -0.07791489f, 0.09912248f, 0.16781564f, 0.14383918f, -0.23825188f, 0.15149893f, 0.09606016f, -0.04690408f, 
    -0.21400116f, -0.19293928f, -0.03177750f, -0.14574839f, 0.04697458f, 0.17455609f, -0.02999610f, -0.18511753f, 
    0.08445541f, 0.12860499f, 0.19489743f, -0.12389890f, -0.22516651f, 0.08421363f, -0.10611339f, -0.18126450f, 
    -0.05430377f, 0.04095827f, -0.02464833f, 0.04642252f, -0.14634238f, 0.50621027f, 0.05039080f, -0.01656411f, 
    -0.02002866f, 0.04902134f, -0.07434817f, 0.34055516f, -0.16741757f, 0.11738160f, 0.08715796f, 0.03742121f, 
    0.12657207f, 0.21617010f, -0.20901945f, -0.16994059f, -0.17275718f, 0.12704740f, 0.10810775f, -0.04001554f, 
    0.03631533f, 0.16377677f, 0.17984685f, 0.13703655f, -0.22553127f, -0.30504340f, 0.17272228f, 0.16586401f, 
    0.01500847f, -0.01947350f, -0.06169406f, 0.00100355f, -0.18334533f, -0.27009267f, -0.13096274f, 0.18799965f, 
    0.13481106f, 0.26847148f, 0.17867784f, 0.22481070f, -0.10126746f, -0.06621106f, -0.06420818f, 0.00643828f, 
    -0.00400567f, -0.01198347f, -0.03076328f, -0.13961127f, 0.15981884f, -0.16318600f, -0.03172992f, 0.24562135f, 
    0.01479687f, -0.16713479f, -0.24742380f, -0.13069539f, -0.13080762f, -0.14843108f, -0.21243934f, -0.11355022f, 
    0.39288011f, 0.10167345f, 0.28110608f, -0.08465298f, -0.20557094f, -0.07484328f, -0.04296570f, -0.04705416f, 
    -0.04220044f, 0.08965395f, -0.02276564f, 0.03782449f, -0.22809908f, -0.30646420f, -0.09060092f, 0.29400635f, 
    0.02046495f, 0.11694605f, 0.10243269f, 0.02712013f, -0.06827167f, -0.08652167f, 0.07862524f, 0.11563835f, 
    0.06014326f, -0.26125920f, 0.16173017f, 0.01851032f, 0.03126407f, -0.04176048f, -0.02395992f, -0.10429474f, 
    -0.08835702f, -0.07778095f, -0.09263157f, -0.03909693f, 0.12709537f, -0.10108479f, 0.11004508f, 0.14711931f, 
    -0.03486374f, 0.08710723f, 0.11961656f, -0.09435499f, 0.21699201f, 0.13113238f, 0.05969946f, 0.25109962f, 
    0.04014103f, 0.16328424f, -0.00463501f, 0.00714252f, -0.16733867f, -0.02369433f, 0.04287805f, -0.08749806f, 
    -0.04183029f, 0.13505320f, 0.07769047f, 0.12194271f, -0.04163738f, 0.00580541f, -0.27769679f, 0.21183091f, 
    0.04315708f, -0.02135002f, -0.00119168f, 0.12708072f, -0.04533218f, 0.13693346f, -0.11755382f, -0.06191797f, 
    -0.05372871f, 0.21083951f, 0.04554093f, -0.03649805f, -0.11676181f, -0.11291304f, -0.09250648f, 0.04428219f, 
    0.03140560f, 0.03488996f, -0.02051095f, -0.04459464f, -0.04834665f, 0.23762596f, 0.03748131f, -0.04306125f, 
    -0.11737775f, 0.28621146f, -0.02245398f, -0.06696900f, 0.19897585f, 0.14126737f, 0.21295093f, 0.22257479f, 
    -0.06172864f, -0.00980911f, 0.09527231f, 0.03488776f, -0.05002184f, -0.15956604f, 0.03595004f, -0.01295127f, 
    -0.07560424f, 0.14317438f, 0.01140395f, 0.08898155f, 0.22742161f, -0.17934674f, -0.46410313f, -0.41061503f, 
    -0.08989096f, 0.10641058f, -0.00274624f, -0.03948714f, -0.15234803f, 0.14482823f, 0.03790388f, -0.01021627f, 
    0.10050987f, -0.10164107f, -0.12860030f, -0.28909832f, 0.00536000f, 0.04677493f, -0.07197648f, 0.06942249f, 
    -0.10553984f, 0.00340196f, 0.03727551f, -0.20405114f, -0.24827097f, -0.20053107f, 0.09266757f, 0.21672457f, 
    -0.00631750f, 0.08718987f, 0.02268824f, 0.06232421f, 0.01666041f, 0.09150244f, 0.03274647f, 0.08759114f, 
    0.01050938f, -0.14666420f, 0.17449135f, 0.26652202f, -0.12622593f, 0.23265369f, 0.04943563f, 0.12623368f, 
    -0.01684120f, -0.13451968f, 0.19538437f, 0.16273905f, 0.49029699f, -0.03010502f, 0.03784914f, 0.01713920f, 
    -0.20221220f, -0.08597770f, 0.09745285f, 0.22699846f, 0.10241873f, 0.15875627f, 0.16104096f, 0.09275485f, 
    -0.22495471f, 0.05353794f, -0.09379638f, 0.25080055f, 0.06873650f, 0.08762553f, 0.14911655f, 0.21763498f, 
    -0.14197403f, -0.10602614f, -0.08163977f, -0.08706893f, -0.33338648f, 0.02857385f, 0.21180427f, 0.19427890f, 
    0.05002332f, 0.05263558f, -0.00199045f, 0.26068884f, -0.00956686f, 0.08805981f, -0.06352020f, 0.07705985f, 
    0.33170494f, -0.10461017f, -0.31991872f, -0.16323689f, 0.00151363f, 0.01154063f, -0.12642987f, -0.01213522f, 
    0.04060636f, 0.02708338f, -0.01302034f, -0.16089982f, -0.06256197f, 0.16408648f, 0.11038028f, 0.14965439f, 
    -0.14808406f, -0.18751054f, -0.14915715f, -0.11498094f, 0.11404810f, 0.09883559f, 0.07896334f, 0.12040386f, 
    0.42237902f, -0.25397786f, -0.12349634f, -0.11087099f, 0.06080483f, -0.01468022f, -0.04319607f, -0.10029495f, 
    -0.19376074f, -0.12002074f, -0.18606283f, 0.11423303f, 0.04297123f, 0.09290314f, 0.14779353f, 0.07044087f, 
    -0.17183256f, 0.00204456f, 0.16531147f, -0.12214561f, 0.10706336f, -0.03182130f, 0.14506188f, 0.10375524f, 
    -0.23937756f, -0.25603995f, 0.04903493f, 0.22379780f, -0.00077407f, 0.07572122f, -0.06568651f, 0.22540534f, 
    -0.02270201f, 0.07602889f, 0.07490531f, 0.18100998f, 0.11641166f, 0.19394757f, -0.31662357f, -0.23208375f, 
    0.02838006f, 0.07539415f, -0.10239944f, -0.09038197f, -0.03206536f, 0.11739262f, -0.11520219f, -0.22748300f, 
    0.23143519f, -0.01597544f, 0.06287264f, 0.25078008f, 0.18141846f, -0.27013403f, -0.05032814f, 0.10654885f, 
    -0.08774041f, 0.23088497f, -0.01838530f, 0.02004664f, -0.06042581f, 0.11028823f, 0.15098937f, 0.12157067f, 
    0.02942142f, -0.03135835f, 0.00422225f, 0.00766071f, 0.09323830f, -0.00346740f, 0.01758877f, 0.09972292f, 
    -0.07483992f, 0.14433099f, -0.00937658f, 0.02024598f, 0.07163358f, 0.06977426f, -0.13329311f, 0.10576012f, 
    0.03611737f, 0.15970074f, 0.09224170f, 0.08649634f, -0.12595659f, 0.11311889f, 0.08726162f, 0.19465168f, 
    0.11912706f, 0.03252617f, -0.14184572f, -0.00998279f, -0.00524671f, -0.01251916f, -0.02768608f, 0.02392337f, 
    0.01928541f, 0.01389814f, 0.18152077f, -0.00006073f, -0.00656452f, -0.02226264f, 0.00660759f, -0.00456653f, 
    -0.32316145f, -0.06680043f, -0.01237824f, -0.10134130f, 0.37886238f, -0.02964200f, 0.11075800f, -0.18313150f, 
    0.05962407f, -0.03819278f, -0.10563780f, 0.53232569f, -0.00335231f, -0.01988938f, -0.00752316f, -0.07371358f, 
    0.23721813f, -0.04600793f, 0.15801600f, -0.25063959f, -0.03766264f, -0.10280228f, 0.11767533f, -0.00443235f, 
    0.06279982f, 0.07474118f, 0.08252050f, 0.26996058f, 0.03722682f, 0.25896069f, -0.22343341f, -0.16573785f, 
    -0.02592151f, 0.00393677f, -0.11596300f, 0.01145720f, -0.16183917f, -0.27093637f, -0.16558687f, 0.12649651f, 
    0.36538115f, 0.23403469f, -0.16173080f, -0.14501794f, -0.17330258f, -0.09243288f, 0.03250103f, 0.07922056f, 
    -0.05993798f, -0.01643194f, 0.00354813f, -0.41629702f, 0.06973708f, 0.14282472f, -0.08566275f, -0.17073028f, 
    0.08357131f, 0.01359028f, 0.04719193f, 0.02353590f, -0.09564397f, -0.12674268f, -0.12700482f, 0.00970581f, 
    -0.19163232f, 0.22303191f, 0.24244621f, 0.28844252f, 0.24815945f, 0.08321229f, -0.05791401f, 0.07696584f, 
    -0.12717435f, 0.08898240f, 0.05445125f, -0.04093308f, 0.26648709f, 0.07071330f, -0.00149990f, 0.19605188f, 
    0.17415644f, 0.21182470f, 0.16230856f, 0.00376362f, -0.04881351f, -0.03204564f, -0.04546222f, 0.07362583f, 
    -0.31071109f, -0.03443890f, 0.06503164f, -0.02049546f, 0.02545526f, 0.13209926f, -0.09936780f, 0.07458600f, 
    -0.00947407f, -0.08830750f, -0.04154937f, -0.11073664f, 0.24668026f, -0.19448128f, -0.27850920f, 0.17436646f, 
    0.07175934f, -0.04609594f, 0.09922613f, -0.15350820f, 0.14567390f, -0.07218842f, 0.16512795f, 0.20369177f, 
    -0.02630484f, 0.09583778f, 0.12560436f, 0.00098046f, 0.01800767f, -0.01936356f, -0.05582302f, -0.15222691f, 
    0.11826012f, 0.14145502f, 0.07006011f, 0.12513854f, -0.08446791f, 0.07997942f, 0.03191163f, -0.08932742f, 
    0.20326617f, -0.00693077f, 0.14249764f, 0.00793022f, 0.03437371f, 0.07347349f, -0.03508563f, 0.10043933f, 
    -0.29930848f, -0.01339019f, 0.08720764f, -0.07529787f, -0.00666232f, -0.02514565f, -0.10223041f, -0.06840651f, 
    0.00878371f, -0.24449885f, -0.09583864f, -0.10004754f, 0.10709387f, 0.08573063f, 0.16674539f, 0.00296334f, 
    0.19399263f, -0.12626387f, -0.20589039f, 0.03158164f, -0.05118719f, -0.06950520f, 0.08934367f, 0.15323170f, 
    -0.01212434f, 0.10970163f, 0.19648308f, 0.04498537f, 0.21619788f, -0.11249135f, -0.10976852f, -0.11841162f, 
    0.09026033f, 0.09848106f, 0.00158413f, 0.18412130f, 0.24735436f, -0.50214040f, -0.18308352f, -0.30322826f, 
    0.04691661f, 0.00777999f, 0.04023584f, -0.04118169f, 0.00739477f, -0.14428079f, 0.06216291f, -0.10277749f, 
    -0.13774432f, -0.10712598f, 0.05849759f, -0.30555665f, -0.06958411f, -0.10656343f, -0.02748142f, 0.10071952f, 
    -0.03982149f, -0.05569021f, 0.03912708f, -0.21556880f, 0.12779859f, 0.18405217f, -0.10731752f, 0.14840600f, 
    0.09395525f, 0.09003767f, 0.06496649f, 0.03097798f, 0.02563581f, -0.00303663f, -0.04502280f, 0.12130959f, 
    -0.22996780f, 0.10096134f, -0.06517286f, 0.25947648f, 0.09543111f, 0.04603059f, 0.05820758f, 0.04691280f, 
    -0.20096812f, 0.03228102f, 0.09325568f, -0.06845216f, -0.39428413f, -0.22698864f, -0.30551204f, 0.13434672f, 
    0.08771138f, 0.17142783f, -0.22439031f, -0.04116363f, 0.10421862f, 0.16799873f, 0.13035975f, -0.01734998f, 
    0.09696154f, 0.05876086f, 0.02077059f, -0.13814227f, 0.05846769f, -0.18692261f, 0.11374570f, 0.07566527f, 
    -0.12952234f, -0.15232329f, -0.04654649f, -0.16618626f, 0.12380653f, -0.06927995f, 0.27481240f, 0.01182199f, 
    0.00140490f, -0.09344693f, -0.09656929f, 0.13889961f, 0.17772189f, 0.09709207f, 0.00253472f, -0.03614940f, 
    0.07432017f, -0.45542830f, -0.24457383f, -0.12454858f, 0.17747296f, 0.24695702f, 0.10806467f, -0.05788030f, 
    0.13039307f, -0.21931893f, 0.11899206f, -0.12503965f, -0.20437486f, 0.11677498f, -0.03880534f, 0.22983453f, 
    -0.03138314f, 0.02731302f, -0.05510354f, -0.03914754f, 0.03241838f, 0.07376172f, -0.02011612f, 0.11855632f, 
    0.01873265f, -0.07881815f, -0.12607704f, -0.03987202f, 0.14932147f, -0.01169032f, 0.13666393f, 0.05713766f, 
    -0.05213396f, 0.02357144f, 0.06045923f, 0.03821672f, 0.06231912f, 0.17975958f, -0.08149780f, 0.25495744f, 
    0.10559180f, 0.01569702f, -0.06609458f, -0.02594177f, 0.08159783f, 0.05059979f, 0.08073600f, 0.15124784f, 
    0.14758503f, -0.01743986f, -0.02968989f, 0.03403161f, 0.24675252f, 0.23534457f, 0.00543772f, 0.20597909f, 
    0.19938378f, 0.05770144f, 0.01369620f, 0.03407310f, 0.14927703f, -0.10212776f, 0.02287766f, -0.04430227f, 
    -0.04184201f, -0.21398965f, -0.04779636f, -0.07610591f, -0.15407141f, -0.00869248f, -0.08590605f, -0.24336046f, 
    0.21405920f, 0.12665750f, -0.19511630f, 0.04180000f, -0.12673981f, 0.26810864f, 0.19740157f, -0.01524924f, 
    -0.01982280f, 0.02098082f, -0.09229710f, -0.01656584f, -0.08064950f, 0.07366022f, -0.00647442f, 0.04534662f, 
    -0.09921681f, -0.06617139f, -0.07850016f, -0.04966318f, 0.16171084f, -0.12306459f, -0.11465129f, 0.11871029f, 
    -0.05049849f, -0.25464478f, 0.02725059f, 0.00480437f, -0.16283675f, -0.08030504f, 0.14242239f, -0.00285083f, 
    -0.01386760f, -0.11072069f, 0.18226317f, 0.09953183f, -0.15841487f, -0.14282994f, -0.15307088f, 0.01760728f, 
    -0.08173865f, 0.14773065f, 0.27032796f, 0.08825949f, 0.02077560f, -0.00761365f, -0.15179846f, -0.14356850f, 
    0.15067787f, -0.12499961f, -0.19947600f, -0.16476911f, -0.09876856f, 0.02437289f, 0.07349078f, -0.03469206f, 
    0.02304655f, 0.01455173f, 0.05588422f, -0.02988542f, -0.04500008f, 0.12795179f, 0.12332832f, 0.14011164f, 
    -0.03819228f, -0.15532769f, -0.08454140f, 0.04269105f, -0.07344010f, 0.09561190f, -0.06673569f, 0.06301164f, 
    0.12344174f, 0.07850682f, -0.30310383f, 0.03935778f, -0.11561161f, 0.06148186f, -0.11568540f, -0.02540855f, 
    -0.11343013f, 0.23258357f, -0.02894347f, 0.10521200f, -0.17368184f, -0.26674208f, 0.31109220f, -0.02674782f, 
    0.09796271f, 0.07345324f, 0.32150045f, 0.07681679f, 0.00256601f, 0.01237115f, 0.10958617f, -0.11068255f, 
    -0.28879353f, 0.02043063f, -0.00595793f, -0.25303647f, 0.04454125f, -0.03381690f, -0.06153653f, 0.24972400f, 
    0.09452900f, -0.07940611f, 0.05386285f, 0.03181086f, -0.36684662f, -0.38454735f, 0.22921783f, 0.08455180f, 
    -0.06190471f, -0.05527933f, 0.16395082f, 0.13862032f, -0.00145567f, 0.09115563f, 0.21296784f, 0.06417403f, 
    0.13680972f, 0.07853244f, -0.40238321f, 0.09096952f, -0.18891849f, 0.15172644f, 0.08022936f, 0.09864932f, 
    0.02580831f, -0.16191092f, -0.17163001f, 0.02136423f, -0.30764616f, -0.34973952f, 0.06046465f, -0.26842433f, 
    0.01741238f, -0.11073229f, 0.08085541f, -0.00226817f, -0.04794849f, -0.05845337f, -0.01896883f, -0.00535948f, 
    0.08014364f, -0.02027166f, -0.08518659f, 0.23196849f, 0.11098430f, -0.14829238f, 0.23496339f, 0.38174435f, 
    0.20861146f, 0.16710337f, 0.01251303f, 0.24135335f, -0.40198320f, 0.33207208f, 0.24837214f, 0.01654388f, 
    0.08888692f, -0.01436685f, -0.14891881f, 0.41790214f, 0.12523098f, -0.01480452f, 0.07883421f, -0.02290493f, 
    -0.24597594f, -0.27203086f, -0.13328893f, -0.13322993f, 0.08152010f, 0.00429043f, 0.04137540f, 0.00492183f, 
    0.03524983f, 0.05234601f, 0.02383391f, 0.03614509f, 0.04917529f, -0.31960815f, -0.22620691f, 0.04857774f, 
    -0.15691754f, -0.12901664f, -0.13528335f, 0.07096633f, -0.03555384f, -0.09328378f, 0.10009985f, 0.24390078f, 
    0.00647036f, -0.08033165f, -0.07488351f, -0.05963767f, 0.04698589f, -0.03952708f, 0.15035750f, 0.02586904f, 
    0.12298040f, 0.14743344f, 0.17840961f, 0.04306438f, 0.46905473f, 0.06053544f, -0.36336935f, 0.30773744f, 
    0.00661764f, 0.01510858f, 0.42272145f, 0.14977996f, -0.07051774f, 0.02571387f, 0.04950933f, -0.04652261f, 
    -0.10498112f, -0.16427006f, 0.06318511f, 0.11218009f, 0.05728553f, 0.33529902f, 0.27606887f, 0.16592906f, 
    0.09875252f, 0.01880015f, 0.10637189f, -0.04134935f, -0.15409611f, 0.42654368f, 0.57786143f, 0.17459749f, 
    0.02531081f, -0.00535045f, -0.00061715f, 0.09318434f, -0.03961929f, 0.04185971f, 0.00455443f, 0.08132633f, 
    -0.08033194f, 0.05684418f, 0.12843442f, 0.22048162f, 0.06296740f, 0.02370627f, 0.09084154f, -0.03033830f, 
    0.03813244f, 0.09698789f, -0.09008237f, 0.15448844f, -0.20320420f, -0.17574626f, -0.13921730f, -0.06619465f, 
    0.17314745f, -0.00667629f, -0.11277830f, -0.07726332f, 0.02235557f, -0.08192623f, 0.08564667f, -0.04186293f, 
    0.08645226f, -0.09352884f, -0.04570222f, -0.18416508f, 0.16211221f, -0.07860219f, -0.05198000f, -0.05191540f, 
    0.14463316f, 0.07970732f, -0.13099730f, -0.03054755f, 0.31175333f, 0.32492974f, 0.43479288f, 0.10001900f, 
    -0.12201649f, -0.07034335f, -0.00587454f, -0.08946372f, 0.12954685f, 0.01587788f, -0.04306126f, 0.11887264f, 
    -0.21126121f, -0.10176752f, 0.12594581f, -0.07406727f, 0.02590689f, 0.07594302f, -0.04373487f, 0.00853964f, 
    0.03728266f, -0.06568731f, 0.07089156f, -0.03924336f, -0.26882628f, -0.04069606f, -0.28735930f, 0.08608516f, 
    0.02626322f, -0.00424015f, 0.22826482f, -0.09860855f, -0.08717199f, -0.12185691f, 0.00934475f, 0.05713692f, 
    -0.23624572f, 0.29569897f, 0.76455384f, 0.41956323f, 0.05159474f, -0.03126284f, 0.03338202f, 0.10521450f, 
    -0.05103824f, 0.23826173f, 0.13814007f, 0.20486073f, -0.07012554f, 0.02656676f, 0.03742559f, -0.16079259f, 
    0.05412949f, -0.07570451f, 0.07553861f, 0.07378078f, -0.02859082f, -0.13449982f, -0.07892561f, -0.20097761f, 
    0.13844769f, 0.03838702f, 0.13417527f, 0.06025241f, -0.02341518f, -0.06509140f, 0.08752236f, 0.14695652f, 
    0.20438056f, 0.06692961f, 0.06953220f, 0.00510223f, -0.35497594f, -0.18450780f, 0.13732709f, -0.41873664f, 
    -0.03997649f, 0.06988601f, 0.07638489f, -0.00635088f, -0.06698772f, -0.06784721f, -0.00699214f, -0.02004453f, 
    0.04235606f, -0.26598841f, -0.05955528f, -0.12425958f, -0.22025569f, -0.02041168f, -0.16097297f, -0.05787577f, 
    -0.12473650f, -0.13549650f, -0.09529253f, 0.07614891f, -0.05716415f, 0.20164649f, 0.21764068f, 0.03642153f, 
    -0.04497262f, 0.03143044f, 0.12555644f, 0.23334044f, 0.12133169f, 0.00275081f, 0.09609706f, 0.04105882f, 
    -0.03075697f, -0.02591451f, -0.00101419f, 0.00457851f, -0.01101112f, 0.01445300f, 0.00279161f, -0.04069394f, 
    0.02739410f, -0.03751723f, -0.00742690f, 0.00402564f, -0.00699628f, -0.02239165f, -0.04019080f, -0.03258091f, 
    0.03922455f, -0.01033746f, 0.02384808f, -0.03578966f, 0.04154222f, 0.01131076f, -0.03354121f, 0.01265873f, 
    -0.01356829f, -0.06090328f, -0.02845157f, 0.01727123f, 0.01924316f, 0.02473870f, -0.02624203f, -0.00763973f, 
    0.00901775f, -0.00378417f, 0.04207180f, -0.03825551f, 0.00454058f, 0.00907166f, -0.04740395f, -0.05320230f, 
    -0.00869043f, -0.00699776f, -0.01741099f, -0.03222134f, -0.04760198f, -0.00767036f, 0.00726734f, -0.03552881f, 
    -0.02952178f, 0.03667695f, -0.02778841f, -0.01970719f, 0.04186922f, -0.01351758f, -0.01580112f, -0.02317864f, 
    0.02595599f, -0.04760781f, -0.02934793f, 0.00042497f, -0.04775430f, 0.03962003f, -0.02849562f, -0.04444187f, 
    0.02924508f, 0.02482587f, -0.05359237f, -0.02415054f, -0.01900304f, 0.02421356f, 0.02399145f, -0.02468653f, 
    -0.05192880f, 0.03982681f, -0.05726797f, -0.05736798f, 0.02687790f, 0.00737327f, 0.01893109f, -0.05287073f, 
    -0.02979575f, 0.03814897f, -0.02564648f, 0.01874037f, 0.03099650f, -0.04251594f, -0.01560821f, -0.02497914f, 
    -0.02982444f, 0.01863533f, -0.04637596f, 0.00674506f, -0.03132534f, 0.00424405f, 0.03174420f, -0.01679999f, 
    -0.01786706f, -0.02499936f, -0.04736475f, -0.01693680f, 0.02760627f, -0.01456886f, 0.02418534f, 0.03541311f, 
    -0.05259595f, -0.04201669f, -0.03284943f, 0.04133096f, -0.02037253f, 0.01583775f, -0.01417717f, -0.02902990f, 
    0.01971697f, 0.03151739f, -0.03567689f, -0.04371168f, -0.02330194f, 0.02978800f, -0.00527302f, -0.02952200f, 
    0.01801920f, -0.05901976f, 0.03449479f, -0.04320766f, -0.00810584f, -0.02456339f, -0.01520515f, 0.02983534f, 
    0.01128995f, -0.01350523f, -0.01222030f, 0.04280378f, -0.01064157f, -0.00162027f, 0.04103647f, 0.01228464f, 
    -0.05342889f, 0.01155270f, -0.01804429f, 0.02553868f, -0.01406236f, 0.02821673f, -0.00735831f, -0.01099647f, 
    -0.02851087f, -0.04494348f, -0.02701613f, 0.00796643f, -0.03578988f, -0.02116279f, -0.02477909f, -0.01941575f, 
    0.01185634f, 0.02361113f, -0.00118357f, -0.03595381f, 0.01173960f, -0.05893828f, -0.04929303f, -0.00739348f, 
    -0.03003730f, 0.01349828f, 0.01024752f, -0.03940601f, 0.02043233f, 0.02068251f, -0.04223783f, 0.03787579f, 
    -0.04473913f, 0.01192434f, 0.03963818f, -0.01301339f, 0.00656843f, -0.01265119f, 0.03350033f, 0.04468348f, 
    -0.01647221f, 0.02501515f, -0.00523906f, 0.01002031f, -0.04584012f, -0.01871788f, -0.03479621f, 0.04227325f, 
    0.02187850f, -0.03721976f, 0.00361368f, 0.01346183f, -0.02216346f, -0.04363284f, 0.01887504f, -0.03433716f, 
    0.03399839f, -0.03164251f, 0.02063732f, 0.02191754f, 0.00854483f, -0.04296105f, -0.01013390f, 0.00526007f, 
    0.02343148f, -0.00164548f, 0.01482777f, -0.02691003f, 0.03449580f, -0.02536419f, -0.00390514f, -0.03159453f, 
    -0.02905143f, 0.00226664f, -0.05724520f, 0.03579206f, -0.00267007f, 0.01403397f, -0.02774587f, -0.02006152f, 
    0.00781076f, -0.00768012f, 0.01793417f, -0.04950755f, 0.04209375f, -0.01419850f, -0.00383948f, -0.00222061f, 
    -0.03902416f, -0.05276795f, -0.05139450f, -0.01816025f, -0.03485987f, 0.00473423f, 0.00198224f, -0.02780162f, 
    -0.05392843f, -0.02625676f, 0.02388469f, -0.00004146f, -0.02924416f, 0.04379725f, -0.02882995f, -0.06270096f, 
    0.00780419f, -0.00771621f, -0.02820208f, 0.01363385f, -0.00301877f, 0.01317840f, 0.00532475f, -0.02561014f, 
    0.02020631f, -0.03190076f, 0.02455074f, 0.00082225f, -0.05112664f, -0.01900130f, 0.01137911f, 0.03227297f, 
    0.01426496f, -0.05007979f, -0.05217304f, -0.03810716f, -0.01349965f, 0.02873907f, -0.03413202f, 0.01523149f, 
    -0.03030654f, -0.04189127f, -0.00924939f, 0.01855320f, -0.02392127f, -0.04559212f, 0.01841757f, -0.04934827f, 
    0.02955748f, -0.00273153f, 0.01932281f, -0.05077380f, -0.02543417f, -0.04941645f, -0.02765161f, -0.03687945f, 
    0.01710070f, -0.05136706f, -0.04152923f, 0.00615046f, 0.03600829f, 0.00693174f, -0.04214092f, -0.02368362f, 
    -0.00194976f, -0.02481360f, -0.03390412f, -0.05279621f, 0.01106908f, 0.01665321f, -0.04537321f, 0.02768501f, 
    -0.03552641f, -0.05075006f, 0.02783934f, 0.01788439f, -0.02832940f, 0.01819156f, -0.03435040f, -0.00684418f, 
    -0.03308304f, -0.03741623f, -0.04800327f, -0.01594714f, -0.03872545f, -0.05613304f, -0.05286399f, -0.03913178f, 
    -0.04571544f, -0.00981610f, -0.03247324f, -0.05844323f, -0.02615481f, 0.00439491f, -0.00132745f, -0.05136411f, 
    0.02772480f, -0.01912784f, 0.01798727f, -0.01854132f, 0.01236463f, 0.00072591f, 0.03884647f, -0.01049166f, 
    -0.02923516f, -0.03843878f, 0.01692968f, 0.01245189f, 0.03220538f, 0.00184454f, 0.00213250f, -0.02043485f, 
    -0.01596846f, 0.04244301f, -0.00823340f, -0.03332989f, -0.02553079f, -0.01844472f, 0.00661788f, 0.02818073f, 
    -0.04331679f, 0.04375195f, 0.01716191f, -0.01879361f, 0.03699428f, 0.02701733f, -0.03256620f, -0.01980100f, 
    -0.05100592f, -0.03878894f, 0.01637252f, 0.04326776f, -0.01388871f, 0.02229977f, 0.03617753f, 0.00062779f, 
    0.00072194f, 0.03705948f, 0.01681845f, 0.02828613f, 0.02130490f, 0.03491936f, 0.01046736f, 0.01187262f, 
    -0.01926410f, -0.05202262f, 0.02064254f, 0.02084589f, 0.03674302f, -0.01420069f, -0.04224512f, -0.03646969f, 
    0.02832990f, 0.01801734f, -0.02538094f, -0.04052698f, -0.01478177f, -0.05280971f, -0.01885687f, -0.02095444f, 
    0.48976329f, -0.00753996f, 0.07956265f, -0.27645975f, 0.14226712f, 0.09079792f, 0.18799102f, 0.08192588f, 
    -0.11112063f, 0.15057383f, 0.02621828f, -0.05826520f, -0.01461033f, 0.37017158f, 0.00944696f, 0.22230288f, 
    -0.14411908f, -0.07828593f, -0.08152986f, -0.04818047f, 0.14818470f, 0.16666183f, 0.01048603f, 0.18960644f, 
    -0.08210818f, -0.15244658f, 0.11666216f, -0.01196616f, -0.10554182f, -0.00664736f, 0.09887204f, -0.03196450f, 
    -0.10886275f, -0.03295047f, 0.14775881f, 0.09925269f, 0.18683550f, 0.11541910f, 0.21786000f, -0.06202527f, 
    -0.16239786f, 0.07684362f, 0.02904244f, 0.02369964f, -0.07293202f, 0.01740729f, -0.02434251f, -0.05192256f, 
    0.18801647f, 0.16834836f, -0.05576556f, -0.25346133f, -0.15490256f, -0.10409152f, 0.01478323f, -0.08806204f, 
    -0.13128328f, 0.09099410f, 0.08079292f, -0.11578080f, -0.11884944f, 0.32282841f, 0.10502852f, 0.19774918f, 
    0.09726255f, -0.16251014f, 0.25242558f, 0.15874425f, -0.11492682f, 0.11284661f, -0.00077196f, 0.09846678f, 
    0.24546716f, 0.26802149f, -0.23258494f, -0.19362548f, -0.15412496f, 0.07529020f, -0.00791278f, 0.04161883f, 
    0.01941428f, 0.37043631f, 0.11448320f, 0.32997808f, -0.23701718f, -0.26424205f, 0.17369118f, 0.08803502f, 
    -0.07150596f, 0.10540387f, 0.07580725f, -0.05633808f, 0.05387890f, 0.00282144f, -0.12453905f, 0.04360204f, 
    -0.08609387f, 0.06887851f, -0.00091298f, -0.23834601f, -0.04053995f, 0.04135164f, 0.03492036f, 0.20547371f, 
    0.15161754f, -0.11613701f, 0.02062698f, -0.18723419f, 0.00183117f, -0.28536445f, -0.02497402f, -0.03277466f, 
    0.01831524f, -0.03018567f, 0.05858584f, -0.08327218f, -0.09077767f, 0.03299120f, 0.01077741f, -0.16467458f, 
    0.31657892f, -0.02739368f, 0.37419146f, 0.12227142f, -0.08338671f, -0.00661298f, -0.00748120f, 0.01091834f, 
    -0.06227344f, 0.02915845f, -0.06519945f, 0.06810360f, -0.14940505f, -0.38443261f, 0.04483766f, 0.03015260f, 
    0.08663534f, 0.05404318f, 0.04179712f, 0.07708506f, -0.12131561f, -0.05837452f, -0.02867851f, 0.03436842f, 
    0.01754687f, -0.02927742f, -0.07322692f, 0.20998235f, 0.14866336f, 0.07629190f, 0.23723835f, 0.22955166f, 
    0.06193626f, 0.02431576f, 0.04860748f, 0.06838850f, 0.02225958f, 0.00698857f, 0.00835171f, 0.20915139f, 
    0.14829132f, 0.11361188f, -0.06177212f, 0.22315758f, 0.22120395f, 0.08710726f, 0.18572199f, -0.04137704f, 
    -0.11358959f, 0.06503826f, 0.01361255f, -0.15131301f, -0.23237783f, -0.16822319f, -0.18326434f, -0.12884885f, 
    -0.03893636f, 0.11289388f, -0.00882222f, 0.09584695f, 0.08842491f, -0.29385257f, -0.09782734f, 0.04597684f, 
    0.05914334f, -0.09811228f, -0.09140778f, 0.07195537f, 0.00104023f, 0.14035653f, 0.05966986f, 0.20446755f, 
    -0.13947272f, 0.21460183f, -0.03980678f, 0.03799159f, -0.01439245f, 0.12058164f, 0.11051514f, 0.08428876f, 
    -0.02864692f, 0.07006749f, 0.01940657f, -0.07470707f, 0.48356384f, 0.14904231f, -0.10232573f, 0.29237267f, 
    0.07358713f, -0.01164956f, 0.35667974f, 0.23768193f, 0.02799329f, 0.08281307f, 0.06752257f, 0.09710620f, 
    -0.02390881f, 0.01662145f, 0.07191580f, 0.10852040f, 0.08810352f, 0.05598843f, 0.00289148f, -0.06074541f, 
    -0.05085193f, -0.01033602f, -0.00913314f, 0.13671148f, -0.32295358f, -0.11824264f, -0.17432435f, -0.47142076f, 
    -0.08109055f, 0.05400493f, -0.01036127f, 0.10539521f, -0.09355716f, 0.03382328f, -0.07447670f, -0.21255378f, 
    -0.16848025f, -0.01075866f, -0.12421212f, 0.00179070f, 0.03078756f, -0.05241694f, 0.04325132f, 0.07866833f, 
    -0.07494188f, 0.12824093f, 0.07430875f, -0.02393910f, -0.10820171f, -0.22839580f, 0.01361191f, 0.03257365f, 
    0.16614079f, 0.12217896f, -0.06908471f, -0.05358419f, 0.14564432f, 0.03191508f, 0.11946804f, 0.21586663f, 
    0.04875932f, -0.27116108f, 0.33995858f, -0.17862046f, 0.17231707f, 0.01661994f, 0.02811059f, 0.08040392f, 
    0.01640174f, 0.02632117f, -0.12215956f, 0.21986414f, -0.14429656f, -0.13929226f, 0.02872561f, -0.00836816f, 
    -0.30226654f, -0.11143167f, -0.12141050f, -0.03040776f, 0.18986624f, 0.26737669f, -0.05002454f, -0.18394172f, 
    -0.18988903f, -0.21021090f, -0.03754803f, -0.01393585f, 0.03196666f, -0.02009648f, -0.01798415f, -0.05624316f, 
    0.12022228f, 0.02561180f, 0.08517062f, -0.03539471f, -0.26195320f, 0.07535000f, -0.16305752f, 0.03476469f, 
    -0.00061147f, -0.10950018f, 0.07182340f, 0.05987027f, 0.15801473f, 0.10501095f, 0.08791244f, 0.19004960f, 
    -0.31561917f, 0.01635866f, 0.04066277f, 0.04429732f, 0.03542285f, 0.04790111f, -0.01388041f, 0.07439567f, 
    -0.04600532f, 0.03075195f, 0.03532075f, -0.20534529f, 0.05249474f, 0.09224090f, 0.11577301f, 0.00712985f, 
    -0.15520893f, -0.13810740f, -0.17259562f, 0.02798342f, -0.20033513f, -0.14753415f, -0.09734336f, -0.08742776f, 
    0.02951087f, -0.15203384f, -0.06320340f, -0.28105676f, -0.05096041f, -0.07098071f, 0.07530016f, 0.15948391f, 
    -0.08056116f, -0.08420569f, 0.04966860f, -0.30861992f, -0.02445022f, 0.01161737f, 0.30338508f, -0.11010785f, 
    -0.07087729f, 0.08104490f, -0.02786192f, -0.00424095f, -0.00492585f, -0.00794056f, 0.12942931f, 0.16889904f, 
    -0.14056931f, -0.39133424f, -0.01355674f, -0.05948006f, -0.04454481f, 0.07257405f, -0.16147442f, 0.07824816f, 
    0.04332244f, 0.15274140f, 0.05540669f, 0.05748607f, 0.05227521f, 0.35268787f, -0.10233510f, -0.03924626f, 
    0.10768437f, 0.15994851f, 0.22059456f, 0.24647520f, 0.04750966f, 0.16038840f, 0.12257402f, -0.12610993f, 
    -0.25154862f, -0.03203400f, -0.00788573f, -0.14626861f, -0.12582055f, 0.36160284f, 0.23665734f, 0.10880006f, 
    0.13082083f, -0.05988743f, 0.21772672f, 0.04199693f, 0.51494968f, 0.10562169f, 0.08023039f, 0.00989669f, 
    -0.13700497f, -0.05031022f, 0.00087082f, 0.05726326f, -0.04192274f, 0.17091009f, 0.38605124f, 0.02917442f, 
    0.10084884f, 0.05592106f, 0.07955458f, 0.03143769f, 0.04677262f, -0.00783254f, 0.00331608f, 0.00857728f, 
    -0.13188921f, -0.18912444f, -0.17759164f, -0.13800657f, 0.08970152f, 0.12501627f, -0.11989576f, -0.12785710f, 
    -0.03764169f, -0.19211762f, -0.10154735f, -0.01434566f, 0.03682374f, -0.04590990f, 0.14014621f, 0.31283316f, 
    0.02082580f, -0.01486127f, -0.19395509f, 0.15383555f, -0.01514653f, 0.05330498f, 0.02364518f, 0.00049734f, 
    0.35307199f, 0.11356149f, 0.26007453f, 0.30026296f, -0.07838559f, -0.20540549f, -0.11412824f, 0.15651344f, 
    -0.04247075f, 0.20759110f, 0.09429451f, -0.28004768f, -0.06701976f, -0.22408827f, 0.06889623f, 0.07213684f, 
    -0.25139120f, 0.09173062f, 0.11883964f, 0.22359119f, 0.04129239f, 0.10758040f, -0.01358544f, 0.09688424f, 
    0.00544058f, -0.04017405f, -0.02253946f, -0.03724509f, 0.01861453f, -0.13629912f, 0.08447938f, 0.04590929f, 
    0.03070957f, 0.16780113f, -0.00309242f, 0.04751836f, 0.25579065f, 0.33791688f, -0.01683498f, 0.02663379f, 
    -0.08216626f, -0.33905309f, 0.27232230f, 0.21037674f, 0.03521888f, 0.01095075f, 0.04661406f, -0.07436498f, 
    0.16382904f, 0.23196915f, 0.09735217f, 0.32331899f, 0.10811613f, -0.13322757f, -0.00931549f, 0.28435454f, 
    0.05827392f, 0.03126543f, -0.14964209f, -0.05904780f, -0.00218834f, -0.05735697f, 0.03647608f, 0.04243988f, 
    -0.09385115f, 0.30422768f, 0.16242565f, -0.02797448f, -0.15391894f, -0.03640835f, 0.11690959f, -0.01646774f, 
    0.18989968f, 0.14883535f, 0.18543673f, 0.16886465f, -0.09914662f, -0.00254908f, -0.23974079f, -0.10795271f, 
    0.08015534f, -0.14646965f, -0.19357994f, -0.09146875f, -0.14114611f, -0.08655991f, -0.11233681f, -0.11580803f, 
    0.22016503f, -0.01733486f, 0.06155965f, -0.04479190f, 0.08500057f, 0.16579607f, 0.08154295f, 0.01897060f, 
    -0.01007039f, 0.09286531f, 0.36431825f, 0.27688918f, 0.19147667f, 0.44990528f, 0.19002008f, -0.00589488f, 
    -0.06945184f, 0.07265110f, 0.17348716f, 0.15028715f, 0.27588534f, 0.45597807f, -0.10761345f, 0.04200380f, 
    0.07613392f, -0.01399036f, 0.08990532f, 0.08693339f, 0.07104053f, -0.12502182f, -0.03826768f, 0.00468351f, 
    -0.35379204f, -0.27133992f, -0.13173479f, -0.24843386f, -0.13347803f, 0.13354754f, -0.13877098f, -0.14716154f, 
    0.03200075f, 0.04548176f, -0.05584157f, -0.14981787f, -0.18068653f, -0.10574876f, -0.20729887f, -0.20516792f, 
    0.22457479f, -0.06329327f, 0.04939650f, 0.05326648f, 0.01323449f, 0.06894045f, 0.07887433f, 0.00888127f, 
    0.39133576f, 0.47278005f, -0.03158283f, 0.49915150f, -0.21233290f, 0.13214394f, 0.24772258f, -0.12071159f, 
    0.10669429f, 0.28050813f, 0.09493931f, 0.11515216f, 0.38306853f, 0.32699159f, 0.14302078f, 0.02651911f, 
    0.08283945f, 0.09944585f, -0.20756923f, -0.04208031f, -0.07999060f, 0.09909474f, -0.03860106f, 0.13561098f, 
    -0.16883932f, -0.06644695f, -0.03347100f, -0.16437435f, -0.06432146f, 0.62102211f, 0.25653580f, 0.30073017f, 
    -0.19230475f, -0.02883576f, -0.03905950f, 0.01762442f, -0.02302195f, 0.14895597f, -0.02650047f, 0.13161072f, 
    0.41381338f, 0.19376843f, 0.01721605f, 0.09551342f, -0.11396440f, 0.20747821f, -0.00618786f, 0.08994195f, 
    0.25828484f, 0.09293824f, 0.06661122f, 0.19003071f, 0.00556718f, -0.07794037f, 0.00882577f, -0.22778788f, 
    0.02353607f, -0.00132952f, 0.08130287f, 0.05194075f, -0.08237247f, 0.00183935f, -0.03806471f, 0.00749626f, 
    0.27795517f, -0.13368210f, -0.05114962f, -0.12205318f, 0.09890946f, 0.04926588f, 0.19429213f, 0.03342195f, 
    0.05428867f, -0.07706834f, 0.01434255f, 0.18980591f, 0.27377063f, -0.04220648f, 0.23265781f, 0.01690661f, 
    -0.14629312f, -0.07108593f, 0.10326534f, 0.24851531f, -0.12368526f, -0.21241181f, -0.16641693f, 0.13475771f, 
    0.04257843f, -0.18854812f, -0.21453975f, 0.20795561f, 0.15525264f, 0.32691190f, -0.01389752f, 0.06997852f, 
    0.21626788f, 0.06740227f, 0.06077141f, 0.10230278f, -0.02322020f, -0.07043758f, -0.15190688f, -0.20542403f, 
    0.19626153f, 0.18068373f, 0.10871002f, 0.03761616f, -0.12618323f, -0.23202981f, 0.12664372f, -0.04554242f, 
    0.16663176f, 0.45399031f, 0.21847562f, 0.23459442f, -0.17787230f, -0.06832977f, 0.03893135f, -0.00955747f, 
    -0.19456577f, 0.15422165f, -0.01107308f, 0.05422422f, 0.38682768f, 0.05565191f, 0.03245632f, -0.06310661f, 
    -0.05889660f, -0.09241945f, -0.01295727f, -0.02404981f, 0.00744489f, 0.09027989f, 0.17555772f, 0.19569534f, 
    -0.18324262f, 0.01820203f, 0.14824434f, 0.17897418f, -0.12458782f, 0.11485505f, -0.04645646f, 0.01604019f, 
    -0.00866640f, -0.08218312f, -0.07222421f, 0.11456648f, 0.03655548f, -0.04581743f, 0.08714739f, 0.00089796f, 
    -0.03917114f, -0.11185879f, 0.09680275f, -0.10885801f, -0.17149876f, 0.11609676f, -0.20486721f, -0.13540852f, 
    -0.14175673f, -0.06573691f, -0.13717262f, -0.19609626f, 0.01921379f, -0.00532349f, 0.11821883f, -0.15342273f, 
    -0.32625127f, -0.10770415f, -0.15021907f, -0.16805519f, -0.01267523f, -0.03316519f, -0.04157692f, 0.14734678f, 
    0.24418479f, 0.26669747f, 0.06032570f, -0.05982805f, 0.32207176f, 0.04814065f, 0.13239107f, 0.27432692f, 
    0.38966858f, -0.09363534f, 0.29188386f, -0.18751162f, 0.18200874f, -0.20813133f, 0.12596765f, 0.28992751f, 
    0.03609792f, 0.09812512f, -0.03096879f, 0.10085759f, -0.21834995f, 0.12042152f, 0.00406287f, 0.12255172f, 
    -0.15572160f, -0.19476753f, -0.11584846f, -0.03415456f, -0.05563588f, 0.15880239f, 0.13717549f, 0.02492351f, 
    0.09346663f, 0.06343099f, -0.01225915f, -0.08057494f, 0.10719589f, 0.04899768f, -0.27091375f, 0.14937297f, 
    0.06438922f, 0.19113551f, -0.06225212f, 0.08096477f, -0.06204368f, 0.04389252f, 0.51667744f, -0.16676173f, 
    -0.07270621f, -0.17785025f, -0.35334727f, 0.14073274f, -0.15927187f, -0.13280694f, -0.05240451f, -0.05885390f, 
    -0.05703236f, -0.07138581f, 0.00149754f, -0.04032638f, 0.01610276f, 0.06281661f, -0.09068837f, -0.13465200f, 
    -0.14320689f, -0.15609610f, -0.00460997f, -0.00046243f, 0.37970471f, 0.07832469f, -0.01543499f, -0.19056259f, 
    0.25385499f, 0.01569809f, 0.04417977f, 0.33267376f, 0.12533288f, -0.07583025f, -0.07712904f, -0.02929287f, 
    0.12164002f, 0.02965685f, 0.10450544f, -0.25848094f, 0.09756282f, -0.06196941f, 0.20121808f, -0.13073893f, 
    0.03756752f, -0.14547285f, 0.14767958f, 0.04624683f, 0.06113956f, 0.01044832f, -0.22782411f, -0.07065266f, 
    0.10052081f, 0.19027884f, -0.15845215f, 0.01076424f, -0.18610863f, -0.09431227f, -0.08660010f, 0.03233363f, 
    0.25087032f, 0.11155625f, -0.01408169f, -0.05221630f, -0.16744208f, -0.02631184f, 0.18973424f, -0.03786359f, 
    -0.10616444f, 0.02754109f, 0.05534174f, -0.12154813f, 0.37584642f, 0.23847623f, -0.08081632f, -0.01834225f, 
    0.13205649f, 0.15284754f, 0.11311550f, 0.09542342f, -0.04662527f, -0.02419387f, 0.04177799f, 0.08494101f, 
    -0.27428648f, -0.00125577f, 0.65722251f, 0.00028795f, 0.07878711f, -0.09150025f, 0.01771406f, 0.08520013f, 
    0.08070630f, 0.09022553f, 0.12392257f, 0.13763602f, 0.17128450f, 0.06293824f, -0.32655472f, -0.11621623f, 
    0.02522944f, -0.00251913f, 0.02261313f, -0.15131988f, -0.06904411f, -0.00152761f, -0.01452523f, 0.00936164f, 
    -0.07567132f, -0.21658802f, 0.19793062f, 0.01519074f, 0.07827130f, 0.20753741f, 0.05006715f, 0.11394161f, 
    0.17335656f, 0.08139864f, 0.15255524f, 0.05521121f, 0.15891056f, 0.22106406f, -0.18553184f, 0.25205010f, 
    0.04706406f, -0.08520434f, 0.25546080f, 0.06329823f, -0.03201675f, 0.23830119f, 0.15223587f, 0.16838776f, 
    -0.22777089f, 0.01314404f, 0.02117953f, -0.17732884f, -0.18804945f, -0.19020791f, -0.06320777f, -0.06359943f, 
    -0.15011303f, -0.03890736f, 0.07633001f, 0.02084906f, 0.27686712f, 0.15406002f, 0.08256717f, -0.11999801f, 
    0.15124552f, -0.00479141f, 0.11320457f, -0.00186908f, 0.00777344f, -0.08667710f, -0.01609025f, 0.08898313f, 
    -0.38130122f, -0.06632573f, 0.08799611f, 0.34949183f, -0.02579566f, 0.08694067f, -0.06501202f, 0.01552000f, 
    0.01099878f, 0.13679278f, -0.04712544f, 0.03883865f, -0.05259866f, -0.11753812f, 0.32208565f, -0.17948046f, 
    0.26448268f, 0.00700609f, -0.17814565f, 0.04797814f, 0.01980111f, -0.01533554f, 0.21947967f, 0.04713272f, 
    0.08585858f, 0.27897340f, 0.15127312f, -0.09126514f, 0.00353502f, -0.02303864f, -0.15654394f, -0.15157282f, 
    0.00890715f, 0.02610467f, -0.14528374f, 0.09771560f, -0.04320935f, -0.03456889f, -0.09587752f, -0.16986316f, 
    0.00667698f, 0.03429795f, 0.02751633f, -0.15568125f, -0.01483037f, -0.03968933f, 0.04233763f, 0.11490344f, 
    0.00272371f, 0.06247903f, 0.07216160f, -0.06688620f, -0.04635728f, 0.14633921f, -0.01283860f, 0.18416087f, 
    0.23047161f, 0.04998796f, 0.26577011f, -0.03252353f, 0.06260917f, -0.07099310f, -0.08283076f, -0.05141389f, 
    0.00749187f, 0.01440154f, -0.03124116f, 0.00504142f, 0.11967806f, -0.03970523f, -0.06853380f, 0.17542151f, 
    0.03629314f, -0.01174413f, 0.01688145f, -0.11797267f, 0.23423310f, 0.16576198f, 0.03337892f, 0.01736948f, 
    0.16329752f, 0.11353177f, -0.01316160f, 0.02860915f, -0.21084189f, -0.40829131f, -0.14562154f, 0.10247193f, 
    -0.07284153f, 0.07079735f, -0.03338002f, 0.11805231f, 0.01308533f, 0.06987936f, -0.13524117f, 0.10547749f, 
    0.12469704f, -0.09273571f, -0.24910240f, -0.04999204f, 0.10806087f, -0.11650104f, 0.05198879f, 0.06351910f, 
    -0.11967228f, -0.19398999f, 0.06599496f, -0.10331232f, 0.06890561f, -0.14341639f, 0.16615283f, -0.18472005f, 
    0.07415812f, 0.04238742f, -0.13387924f, -0.06342364f, 0.08014196f, -0.11667110f, -0.05709628f, -0.00588657f, 
    -0.14441901f, -0.22955993f, -0.04895733f, -0.02198898f, 0.18769439f, 0.18190920f, 0.03305152f, -0.09191427f, 
    0.09246588f, -0.06906455f, 0.11261469f, 0.08108340f, -0.14009625f, 0.16713494f, 0.04437950f, 0.14354229f, 
    -0.36653584f, -0.06499983f, -0.24585590f, -0.13468336f, -0.10537651f, 0.04835233f, 0.01837251f, 0.02208922f, 
    -0.17138994f, -0.17768994f, -0.33269176f, -0.11270037f, 0.12992883f, 0.27343810f, 0.09278302f, -0.18979619f, 
    -0.05758343f, 0.01331016f, 0.17287670f, 0.20028731f, 0.07978486f, -0.08230258f, -0.01542250f, 0.11448894f, 
    -0.07285059f, 0.01617560f, -0.10611594f, -0.01442765f, -0.10442616f, 0.07741225f, -0.07831363f, 0.03960275f, 
    0.07000993f, 0.03161957f, -0.19313386f, -0.18208480f, 0.08096144f, -0.06103465f, 0.04276496f, 0.04780876f, 
    0.01168058f, -0.06788927f, -0.01100213f, -0.11456176f, 0.36142206f, -0.08617511f, -0.02683575f, 0.11799534f, 
    0.23630463f, -0.00824973f, 0.13143082f, -0.06715003f, 0.20077880f, 0.04483012f, 0.03621828f, -0.04768142f, 
    -0.39750546f, 0.34577480f, -0.28659514f, 0.22940281f, 0.03802085f, 0.27051538f, -0.02478847f, -0.13723642f, 
    -0.09362489f, -0.09556416f, -0.13761450f, -0.05404754f, 0.44652084f, -0.05985530f, 0.17620315f, 0.26496992f, 
    -0.06369198f, -0.02795968f, 0.01310228f, 0.02525468f, 0.12707052f, -0.05545140f, -0.04844785f, 0.06791448f, 
    -0.37531212f, -0.07277524f, -0.19728385f, -0.03564095f, -0.03868579f, 0.06920323f, 0.20674576f, -0.09208743f, 
    0.01749846f, -0.14616399f, -0.05571279f, 0.01591961f, 0.29903620f, -0.00715406f, -0.25972366f, 0.14922436f, 
    0.18006246f, -0.00633065f, 0.14470792f, -0.16620795f, 0.10869511f, -0.05477753f, -0.12264391f, 0.07412532f, 
    -0.06414627f, 0.03931668f, 0.12448093f, 0.27555692f, -0.14022721f, -0.03586554f, 0.00565731f, -0.15245782f, 
    0.22296788f, 0.00971082f, 0.13166688f, -0.00713161f, -0.40444568f, -0.27917823f, 0.05422970f, 0.01968214f, 
    -0.01647976f, 0.17230332f, 0.08119263f, -0.08649661f, -0.08733857f, -0.10334957f, -0.18252218f, 0.13542430f, 
    0.19351499f, -0.10160062f, 0.35161564f, 0.32787353f, 0.07260333f, -0.00162687f, -0.16727227f, 0.02695801f, 
    0.04977595f, 0.11097030f, -0.13819629f, -0.04608423f, -0.22251052f, 0.15009633f, 0.32259944f, 0.01215893f, 
    0.03592670f, -0.10103653f, 0.16454609f, 0.07587782f, 0.06054325f, 0.02757116f, 0.03380302f, 0.12666607f, 
    -0.17910624f, -0.04457029f, -0.14422166f, -0.07683250f, 0.11385813f, -0.01904921f, -0.07833132f, 0.16455545f, 
    -0.00382061f, 0.05078310f, -0.02680159f, -0.00961149f, -0.39595214f, -0.18411468f, -0.24018247f, -0.18588045f, 
    -0.02203193f, -0.06133379f, -0.06530621f, -0.04058223f, 0.01257711f, 0.02188597f, 0.09048773f, 0.15921567f, 
    0.27120659f, 0.17909800f, -0.41384247f, 0.30209196f, 0.00667395f, 0.09673707f, 0.18872663f, -0.08812558f, 
    0.16291973f, -0.01148391f, 0.07320073f, 0.01838128f, -0.10627465f, 0.00712106f, 0.26836339f, -0.08276008f, 
    0.00518940f, -0.02692335f, 0.14627481f, 0.11283625f, 0.03515479f, -0.00003491f, -0.12736201f, 0.06582040f, 
    -0.04662785f, -0.04641037f, -0.31580222f, -0.25118697f, -0.14178634f, -0.02192736f, 0.08502039f, 0.11272225f, 
    -0.02060004f, 0.01029937f, 0.01537276f, 0.17131500f, -0.01045498f, -0.30001608f, 0.24587345f, -0.22827223f, 
    0.19160488f, -0.00849619f, -0.02712510f, 0.11555646f, 0.07678651f, 0.04411397f, 0.01363185f, -0.03549428f, 
    0.14598367f, -0.04669397f, -0.03916757f, 0.09610095f, 0.11767013f, 0.00034734f, -0.00414777f, -0.13142195f, 
    -0.00941621f, -0.06512727f, -0.14634822f, -0.13829604f, -0.08293445f, -0.25565791f, -0.00871453f, 0.05574323f, 
    0.15574089f, -0.13598391f, -0.13187535f, 0.03933643f, -0.03118069f, -0.07576478f, 0.10415258f, 0.08608113f, 
    0.15008394f, -0.15246387f, 0.17024063f, -0.13539539f, 0.00106276f, 0.11549189f, 0.05311156f, 0.07253806f, 
    0.19707306f, 0.06499158f, 0.13052467f, 0.01963071f, 0.23895447f, 0.18470596f, -0.09988692f, 0.34955221f, 
    -0.13170041f, 0.06203767f, 0.18580483f, 0.06786273f, 0.11376130f, 0.22764073f, -0.03214499f, 0.05571916f, 
    0.08901522f, -0.11988153f, -0.06024373f, -0.18217182f, 0.25250950f, 0.07227144f, 0.05196208f, 0.10978812f, 
    -0.05985845f, -0.13098615f, -0.00571833f, 0.03177225f, 0.12465807f, -0.01055295f, 0.37870684f, 0.16106492f, 
    0.01313085f, -0.08385968f, -0.21257135f, -0.01533172f, 0.02343795f, -0.07735313f, 0.12689784f, -0.00676351f, 
    -0.04349223f, -0.00398390f, 0.03860103f, 0.16063315f, -0.02254098f, 0.03673646f, 0.13487558f, -0.22516252f, 
    0.12135736f, 0.00428134f, 0.13959815f, 0.06842430f, 0.11133922f, 0.23562199f, 0.04336688f, 0.20315477f, 
    0.13696212f, 0.11436804f, 0.15688469f, 0.09384395f, -0.14347805f, 0.04107632f, 0.06966818f, 0.05784721f, 
    -0.04307191f, 0.25178218f, -0.16222893f, 0.18891513f, 0.07255994f, -0.10887247f, 0.10438903f, 0.07552954f, 
    0.00798281f, 0.07850682f, 0.03606243f, -0.02673208f, -0.36442044f, 0.26686430f, -0.06011419f, -0.02580546f, 
    -0.21296462f, -0.09260961f, -0.09028128f, -0.20480701f, 0.17505585f, 0.17077295f, 0.00894752f, -0.11738188f, 
    -0.00179814f, 0.12035886f, 0.30661523f, -0.06447036f, -0.03696189f, 0.01931881f, 0.02143804f, -0.04151822f, 
    0.11394541f, 0.01304015f, -0.02410777f, 0.02812582f, 0.04184559f, -0.01761550f, -0.18277043f, 0.06255352f, 
    0.02338267f, -0.06840412f, 0.12277442f, 0.18879618f, 0.08226017f, 0.02800757f, 0.09329370f, 0.07980849f, 
    0.07828290f, -0.13413373f, -0.02073088f, -0.13579997f, 0.06224902f, -0.18518850f, -0.14253937f, 0.02631929f, 
    0.04701976f, -0.14153641f, 0.04955627f, 0.04723182f, 0.17899072f, -0.02327918f, 0.06482866f, 0.29184389f, 
    0.11924407f, -0.06710522f, 0.07194940f, -0.06199120f, 0.15618277f, 0.07532056f, -0.00576989f, 0.05829200f, 
    -0.26928723f, 0.05924618f, 0.12758788f, -0.06709217f, 0.03792742f, -0.12551349f, -0.07169952f, 0.06131181f, 
    0.09563252f, -0.13912977f, -0.00017826f, -0.07067625f, 0.08656376f, 0.21252964f, 0.02329897f, 0.08260483f, 
    0.02792392f, -0.06732577f, -0.01970607f, -0.13048977f, 0.00413383f, -0.10351660f, -0.10855985f, 0.09111585f, 
    -0.01577828f, -0.03391121f, 0.07903598f, 0.10102552f, 0.05200268f, 0.04988337f, -0.07010202f, 0.12361574f, 
    0.03774762f, -0.13007350f, -0.01928183f, 0.02084969f, -0.05963673f, 0.03536060f, 0.23560789f, 0.05079502f, 
    0.03243103f, 0.10038357f, -0.10913390f, 0.09385268f, -0.05240171f, -0.06707980f, -0.00836597f, 0.10629939f, 
    0.11473710f, -0.03077002f, 0.35641930f, -0.31853101f, -0.01632607f, -0.01431365f, -0.02122909f, 0.09430676f, 
    -0.01032835f, 0.08258478f, 0.05239145f, 0.01810332f, 0.22262205f, -0.02053947f, -0.22218429f, 0.16733660f, 
    0.05628382f, 0.04640185f, 0.10275956f, 0.06848342f, -0.13883299f, 0.00385949f, 0.08379313f, -0.01829608f, 
    -0.12986058f, 0.06347357f, -0.03906609f, 0.00840191f, 0.11487360f, -0.10289492f, 0.02892753f, -0.25160399f, 
    0.07031216f, -0.08307125f, -0.23097788f, -0.18633850f, 0.65031296f, 0.00195015f, 0.22983085f, 0.00242004f, 
    0.02658034f, 0.02362475f, -0.03393132f, 0.16536102f, -0.06211434f, 0.03695006f, 0.01503066f, 0.04338993f, 
    0.00629174f, 0.15464866f, -0.07711025f, 0.17253184f, 0.08373730f, -0.00248437f, 0.03977555f, 0.09369659f, 
    0.12853199f, 0.10285910f, 0.10329936f, 0.00785252f, -0.48011789f, -0.20528880f, -0.14938429f, 0.38146621f, 
    0.23720586f, 0.04675629f, 0.45737156f, -0.57152414f, 0.03895670f, -0.06690392f, -0.01002830f, 0.13728516f, 
    -0.12504098f, 0.01108658f, 0.13135630f, 0.18534975f, 0.24576291f, -0.04198791f, -0.09090319f, 0.00155739f, 
    0.01438869f, 0.05448226f, 0.11662099f, -0.06317665f, -0.20339526f, -0.24220385f, -0.06223937f, 0.17005709f, 
    -0.07251367f, -0.03716016f, -0.06723515f, -0.11949234f, 0.09481615f, 0.11946235f, -0.07703707f, -0.21665719f, 
    -0.11866816f, -0.25405267f, 0.06634896f, -0.22562699f, 0.02070904f, 0.08991223f, 0.05063148f, -0.05090966f, 
    -0.22747238f, -0.00727347f, 0.05280472f, 0.34501040f, -0.04348354f, 0.21403384f, -0.13817033f, -0.18825577f, 
    0.06571931f, 0.07881807f, 0.17408311f, 0.01345134f, -0.03965291f, 0.01008237f, 0.18474500f, 0.10712021f, 
    0.50537592f, -0.22388361f, 0.24326505f, -0.07150564f, -0.05320130f, -0.11758745f, 0.08694409f, 0.09178593f, 
    -0.02922537f, -0.01054473f, 0.12158483f, 0.00416310f, 0.14122684f, 0.08606231f, 0.15694375f, -0.17381769f, 
    -0.08505452f, 0.07243457f, -0.12771386f, -0.06012176f, 0.11018191f, -0.00354140f, -0.13206221f, -0.02859351f, 
    0.21690547f, 0.06855793f, -0.21371868f, 0.06729859f, -0.04108370f, -0.04642030f, 0.26281989f, 0.08300018f, 
    -0.02613165f, 0.04426913f, 0.10674574f, -0.08977906f, 0.21454923f, -0.27895975f, -0.15984820f, -0.06722099f, 
    -0.01192230f, 0.18959524f, -0.10569225f, 0.15537730f, -0.03545003f, 0.07094852f, 0.18053283f, -0.10263023f, 
    0.27647439f, 0.09004701f, -0.01459344f, 0.01057978f, -0.05419249f, 0.07560998f, -0.19798315f, 0.09723973f, 
    -0.06686380f, -0.08953852f, 0.00630035f, -0.13827717f, 0.27094856f, -0.27674422f, 0.31731710f, -0.41951254f, 
    0.09320813f, 0.06903659f, 0.01490092f, -0.05645975f, -0.01680215f, 0.03872690f, 0.06522718f, -0.13653116f, 
    0.14999673f, 0.21877015f, -0.26141098f, 0.22233137f, -0.12144323f, 0.17812878f, 0.15151343f, 0.09245846f, 
    0.00573068f, 0.20558216f, 0.07427158f, 0.16266675f, -0.11282864f, -0.15969878f, 0.15535167f, 0.22533205f, 
    0.08383100f, -0.06322887f, 0.07618981f, 0.05949831f, -0.02449147f, 0.16107540f, -0.08467073f, -0.13055624f, 
    0.36608064f, 0.20408346f, 0.01117153f, 0.14858092f, 0.02577139f, -0.02352186f, 0.06621971f, 0.08336693f, 
    -0.03168771f, -0.11922616f, -0.03748566f, -0.07290254f, -0.61591113f, 0.06410805f, -0.21078432f, 0.00098190f, 
    0.07627679f, 0.01055761f, 0.00532373f, 0.00435993f, -0.03572723f, -0.04453507f, 0.03457287f, -0.03790276f, 
    -0.17356624f, -0.02942088f, -0.43215084f, 0.27561930f, -0.00831503f, 0.05873894f, 0.29710346f, -0.08518145f, 
    0.03108187f, 0.18989366f, 0.17089809f, 0.28450692f, 0.38103488f, -0.18194136f, 0.21531796f, -0.09816021f, 
    -0.10806881f, -0.03168024f, 0.11105731f, -0.00747948f, -0.06408170f, -0.00964432f, -0.07083556f, 0.10310190f, 
    0.24756093f, -0.35054922f, 0.44428512f, -0.49096334f, -0.02296755f, -0.04077619f, -0.00096592f, 0.06768316f, 
    0.05092436f, 0.02396269f, -0.15950289f, 0.15059237f, -0.52109390f, -0.33765396f, -0.08637454f, -0.11239506f, 
    0.09612249f, -0.05030462f, 0.22483042f, -0.02211342f, -0.00239873f, 0.06032019f, -0.11491240f, -0.19170375f, 
    -0.15389588f, -0.42136723f, -0.28974223f, 0.04970768f, -0.00925914f, -0.03055451f, -0.13115622f, -0.26703343f, 
    0.03862111f, 0.00246288f, -0.09487612f, 0.11692975f, -0.09907583f, -0.01431621f, -0.33291292f, -0.22827743f, 
    -0.02458537f, 0.07781212f, 0.02813425f, -0.05931928f, -0.10507145f, -0.15486012f, 0.07922553f, 0.13534746f, 
    -0.71435630f, 0.06681544f, -0.35867599f, -0.04428174f, 0.13978940f, 0.06345435f, 0.07223534f, -0.07122000f, 
    -0.08051000f, 0.09541654f, 0.03006628f, -0.02272182f, 0.31602606f, 0.03468044f, 0.08211000f, 0.01702181f, 
    -0.05425948f, 0.18860087f, 0.07444952f, 0.08251353f, -0.08889867f, 0.14908260f, 0.03591235f, -0.06244154f, 
    -0.30840772f, -0.00881196f, 0.06077409f, -0.10017204f, 0.06941337f, 0.36970383f, 0.13681699f, 0.08153580f, 
    0.03212409f, 0.10183815f, -0.04468170f, -0.11507673f, 0.31816417f, 0.16647728f, 0.15341990f, -0.08006126f, 
    -0.02258819f, 0.07910275f, -0.09324922f, 0.08136459f, 0.04539917f, 0.10793576f, -0.08896004f, -0.00761473f, 
    -0.37876162f, -0.01603801f, -0.16890042f, -0.14014313f, 0.14294393f, -0.18741699f, 0.08360247f, -0.22702834f, 
    -0.01091073f, -0.01041520f, 0.14693445f, -0.06268301f, -0.29153553f, 0.20218140f, -0.27478695f, 0.09141973f, 
    -0.03603052f, 0.11714635f, 0.12822171f, 0.16919306f, 0.16459545f, 0.04050444f, 0.10489456f, 0.20380475f, 
    -0.13874938f, -0.33450991f, -0.35183465f, 0.14799148f, -0.03831029f, 0.19774674f, -0.05698982f, -0.04129880f, 
    0.07578654f, -0.03921756f, -0.01046191f, 0.01270999f, 0.23610981f, -0.10369637f, -0.15748796f, -0.17747776f, 
    -0.03854982f, -0.09859460f, 0.05606216f, -0.05662607f, 0.05562007f, 0.01355831f, 0.26235527f, 0.13476340f, 
    -0.19651708f, 0.13232616f, -0.01566377f, 0.14925426f, 0.05985438f, 0.05416459f, -0.05454892f, 0.02507047f, 
    -0.11452194f, -0.08811296f, -0.13863356f, -0.31120443f, -0.03252083f, -0.16834216f, -0.14647190f, -0.06293109f, 
    -0.02236892f, 0.08572122f, 0.04605494f, -0.01040541f, 0.04119844f, -0.18280700f, 0.11177617f, 0.05754550f, 
    -0.02021023f, -0.25549287f, -0.28064001f, -0.19190551f, 0.14092742f, -0.07999983f, -0.14769393f, 0.09639436f, 
    0.12718299f, 0.04136725f, 0.30487996f, 0.01586082f, 0.28628060f, -0.61488891f, 0.00776965f, 0.16665889f, 
    -0.06009650f, -0.05227729f, -0.08328494f, -0.17004396f, -0.03037986f, -0.12531941f, -0.13571495f, -0.07225179f, 
    -0.14544430f, -0.23057787f, 0.02967171f, -0.02490697f, -0.08629231f, -0.02032077f, -0.11639660f, 0.02068692f, 
    -0.07630032f, 0.02392154f, -0.04059118f, -0.11589536f, 0.06572988f, 0.17340341f, -0.19469054f, 0.01161850f, 
    0.14718460f, 0.22630559f, 0.08084574f, 0.13057685f, 0.16234998f, 0.25726047f, 0.14918382f, 0.06898007f, 
    -0.18731646f, -0.09354310f, 0.16575497f, -0.02486156f, -0.02683709f, -0.14257027f, -0.00186071f, 0.02205999f, 
    0.16594149f, 0.05575047f, 0.12340463f, 0.13903302f, -0.24515517f, 0.08324331f, 0.33987352f, 0.14457443f, 
    -0.03557188f, 0.10233932f, 0.30572075f, 0.19614643f, -0.12820598f, -0.11120402f, -0.00975711f, 0.05085356f, 
    -0.10149420f, 0.04552144f, -0.14399883f, 0.06052224f, -0.11949599f, 0.11814608f, -0.02382059f, 0.08244552f, 
    0.08222464f, 0.06651641f, 0.11745872f, 0.15841039f, -0.03213682f, 0.17913786f, -0.19624285f, -0.11347528f, 
    0.16508922f, -0.00068433f, 0.03622160f, -0.03781047f, -0.05420885f, -0.06510006f, -0.07741062f, -0.17184004f, 
    0.13012041f, 0.02371644f, -0.16211180f, 0.13072626f, 0.19729912f, 0.16934085f, 0.08799943f, 0.16394578f, 
    -0.01479147f, 0.08494205f, 0.22281200f, 0.07300989f, 0.03939227f, 0.44696867f, -0.26916605f, -0.10523801f, 
    0.01942986f, -0.08665678f, 0.10313235f, 0.13154075f, 0.11191993f, 0.09976279f, 0.11066890f, 0.05519662f, 
    -0.15852459f, -0.16900040f, 0.09317522f, -0.06176290f, 0.12891620f, -0.08990069f, -0.05165940f, 0.13841769f, 
    -0.13883659f, -0.30978462f, -0.04798100f, -0.19021082f, -0.21254405f, 0.06921188f, 0.14497383f, -0.10979630f, 
    -0.09053148f, 0.02718826f, 0.09855592f, -0.16389866f, -0.15683986f, -0.26945916f, -0.03795005f, -0.07723068f, 
    0.09240647f, -0.31042567f, -0.12392498f, -0.10770040f, 0.16655791f, 0.03526803f, 0.02962446f, -0.10579802f, 
    0.32520580f, 0.18049645f, 0.31108233f, 0.23983674f, 0.09542817f, -0.07175905f, 0.06177466f, -0.07418105f, 
    0.19462349f, -0.09912959f, 0.01399860f, 0.12252125f, 0.08505070f, 0.11825882f, -0.06589332f, 0.00975601f, 
    -0.05147841f, 0.06474464f, -0.10190772f, 0.19449963f, 0.05360161f, 0.25137663f, 0.02794400f, -0.01406368f, 
    0.07481983f, -0.26390019f, -0.04765488f, -0.23853739f, -0.26730102f, 0.25424159f, 0.32987401f, 0.04788075f, 
    -0.10031225f, -0.12524492f, 0.06613975f, 0.20343134f, 0.03455567f, 0.08439088f, 0.03105753f, 0.00034272f, 
    -0.12003791f, 0.13863336f, 0.34250593f, -0.09735982f, -0.05449441f, 0.10769664f, -0.07692083f, 0.04435888f, 
    0.09572513f, 0.11633513f, 0.03605073f, 0.22229671f, 0.11316814f, 0.21140286f, -0.09278669f, -0.19218697f, 
    0.12679672f, -0.05778449f, 0.10233516f, -0.17975599f, 0.01490311f, 0.04113127f, 0.00915562f, -0.01360732f, 
    0.18577492f, 0.16223390f, -0.14764927f, -0.25144142f, 0.18440403f, -0.03343218f, 0.08108348f, -0.12178732f, 
    -0.04214070f, 0.05414674f, -0.15254560f, -0.13614227f, 0.02898594f, -0.08917204f, 0.12066974f, 0.04623991f, 
    0.07135164f, -0.16483532f, -0.07392658f, -0.02502085f, 0.17436281f, -0.04314775f, 0.13059063f, 0.09387019f, 
    -0.05712754f, -0.16659515f, 0.14832762f, 0.26009527f, 0.17037050f, 0.14100882f, -0.11247412f, 0.01588926f, 
    0.01908429f, -0.13317171f, 0.10345399f, 0.00891936f, 0.15407373f, -0.14390080f, 0.18924670f, 0.00593533f, 
    0.12440664f, 0.04397292f, -0.03046128f, 0.02965222f, -0.07020531f, -0.17055219f, 0.05480143f, 0.00998548f, 
    -0.30683687f, 0.21204475f, 0.57629222f, 0.21605608f, -0.07223799f, 0.04764842f, 0.29685715f, 0.34211934f, 
    -0.08427721f, 0.00603998f, -0.11640246f, 0.11773118f, 0.29413944f, -0.11852408f, -0.04304175f, -0.19496326f, 
    0.11770649f, 0.08514056f, 0.10636134f, -0.03940469f, 0.04877792f, -0.09112488f, 0.12429540f, -0.01718672f, 
    -0.20584826f, 0.24339308f, 0.00183293f, 0.19629568f, 0.02521182f, 0.08400274f, 0.04412438f, 0.18317190f, 
    0.16613354f, 0.05680892f, 0.10482205f, -0.13019295f, -0.07307496f, -0.14546539f, -0.12057274f, -0.20417383f, 
    0.09806215f, 0.05963307f, -0.15269054f, -0.05124753f, -0.20621783f, 0.10362596f, -0.24477966f, -0.16327833f, 
    0.12292340f, 0.10144554f, -0.13608612f, -0.12956321f, -0.06939127f, 0.01304663f, 0.18990065f, -0.10793613f, 
    -0.25195354f, -0.10341390f, -0.13729323f, -0.11540927f, -0.07280741f, -0.26257944f, 0.01264128f, 0.18012440f, 
    0.09131263f, 0.01814531f, 0.08648672f, 0.25053394f, 0.24252208f, -0.06294532f, 0.24173479f, 0.26338920f, 
    0.40839723f, 0.04382334f, 0.24455470f, -0.22210069f, -0.14800349f, -0.02272245f, -0.05234938f, -0.08043291f, 
    -0.15643597f, -0.21169773f, -0.24539503f, -0.13509202f, -0.25247157f, 0.07981504f, -0.04218042f, -0.14553235f, 
    0.10081168f, 0.03168612f, -0.08710527f, 0.09693248f, -0.02110826f, -0.05559436f, 0.07627534f, 0.17712013f, 
    0.29730552f, -0.03483509f, 0.09010891f, -0.16646226f, 0.06303316f, 0.07380262f, -0.09514250f, 0.01471929f, 
    -0.10750862f, -0.07471962f, -0.35925287f, -0.08573779f, -0.25749272f, -0.01878532f, 0.34859976f, 0.01119874f, 
    -0.10979349f, -0.13998383f, -0.56405181f, 0.00770266f, -0.04964165f, -0.16773197f, -0.03015273f, 0.03007711f, 
    0.13235956f, -0.13971201f, -0.10400852f, 0.05865427f, 0.07930652f, -0.08497367f, -0.02634195f, 0.04667997f, 
    0.00721874f, -0.00034166f, 0.09124184f, 0.15814362f, 0.54204732f, 0.37799934f, -0.19583100f, -0.33752650f, 
    0.18058233f, 0.05360844f, -0.05449524f, 0.12868743f, -0.18961687f, -0.01262795f, -0.13625021f, -0.10314688f, 
    0.20236285f, 0.18280479f, 0.04678064f, -0.13739520f, -0.10163289f, -0.09976929f, 0.00839304f, -0.11546618f, 
    -0.24964663f, -0.24253303f, -0.19656610f, -0.15664479f, 0.23453900f, -0.08317462f, -0.19775689f, 0.02747312f, 
    0.24728562f, -0.02284304f, -0.03194610f, 0.05709432f, 0.16579683f, 0.17459096f, 0.16985516f, 0.11151742f, 
    0.10656365f, 0.23753291f, -0.22541565f, 0.10696618f, -0.09702151f, 0.06417606f, 0.06666707f, -0.14683983f, 
    -0.01063376f, -0.08539432f, 0.01392495f, 0.10873879f, 0.29173309f, 0.05257705f, -0.05390400f, 0.07143185f, 
    0.15401171f, 0.08849505f, 0.08417303f, 0.04301097f, 0.04623418f, 0.12068944f, 0.12477054f, 0.29160127f, 
    -0.19152294f, -0.09731776f, 0.50262642f, 0.11571153f, -0.08893827f, -0.02558330f, -0.09973060f, 0.04407198f, 
    0.08874725f, 0.00484185f, 0.06834240f, 0.00635739f, 0.11299007f, 0.01236822f, -0.32442090f, -0.26583475f, 
    0.13457070f, 0.03066139f, 0.10692569f, -0.00216092f, -0.09194227f, 0.01086312f, -0.02675216f, -0.13796991f, 
    0.09896277f, -0.20402922f, 0.12817635f, 0.21497178f, -0.04859316f, 0.10217296f, 0.01591532f, -0.14805235f, 
    0.17316067f, 0.11045609f, -0.00290232f, 0.19983037f, -0.41393799f, 0.57612032f, -0.31079057f, 0.29890123f, 
    0.05090651f, -0.32511809f, 0.19221675f, -0.06377695f, -0.19205746f, 0.12272446f, -0.05645002f, -0.05093029f, 
    -0.22932266f, -0.00334729f, 0.04457795f, 0.17632362f, 0.02672721f, -0.04612356f, -0.03818779f, -0.00589055f, 
    -0.46121711f, -0.42064548f, -0.02304702f, -0.18615662f, 0.49743435f, -0.04805476f, -0.00085674f, -0.15729208f, 
    0.10607175f, 0.19619891f, -0.01477072f, 0.10842086f, -0.13801542f, -0.15854345f, 0.09279988f, -0.07634570f, 
    -0.28450990f, -0.05818728f, -0.02267596f, 0.39928299f, 0.09207825f, -0.19213511f, 0.01653779f, -0.12668741f, 
    0.20161940f, 0.42274994f, 0.03410877f, 0.13833563f, 0.14632858f, 0.05250690f, 0.10928198f, -0.19211848f, 
    0.05098595f, 0.07485929f, -0.08604869f, 0.06778905f, -0.14045183f, -0.04612407f, 0.08788691f, -0.22161703f, 
    -0.46173269f, 0.15516320f, 0.19388549f, 0.07197509f, -0.14635500f, 0.00241783f, -0.15123184f, -0.15296221f, 
    -0.14840327f, -0.22342569f, -0.17526105f, -0.43243143f, 0.15897347f, 0.20928566f, 0.21966882f, -0.03496664f, 
    0.04222837f, 0.00491535f, 0.09885619f, -0.14589797f, 0.02402183f, 0.08793487f, -0.01117781f, 0.03953805f, 
    0.11360450f, 0.18107615f, 0.24225657f, 0.03433992f, 0.06611142f, 0.17339362f, 0.04671234f, 0.13498570f, 
    0.20540982f, 0.12998271f, 0.05517343f, 0.17439099f, -0.00475618f, -0.08850639f, -0.08301163f, -0.00111442f, 
    0.03426662f, 0.06312004f, -0.03640353f, -0.04619354f, -0.00501249f, 0.01957835f, 0.00425974f, -0.04764407f, 
    0.12625490f, 0.04758826f, -0.10046180f, 0.05831958f, 0.02656063f, 0.07908032f, -0.08395880f, -0.06466135f, 
    0.06120954f, -0.10393981f, -0.25344801f, -0.04729984f, 0.29760432f, -0.04578667f, -0.00713838f, 0.12979649f, 
    0.01244104f, -0.10882179f, -0.01009364f, 0.09024344f, -0.21776019f, -0.09941760f, -0.33008346f, 0.03122243f, 
    0.28281555f, 0.04367311f, -0.20827766f, -0.09658509f, 0.10718846f, 0.04245719f, 0.02498662f, 0.12492984f, 
    0.06428305f, -0.05360606f, 0.08298599f, 0.08965967f, 0.08257680f, -0.09703656f, -0.05232900f, -0.05100560f, 
    0.07864902f, 0.03148896f, -0.09299845f, -0.21082744f, -0.11592090f, -0.06360149f, -0.14418326f, 0.04665030f, 
    0.06918092f, -0.09835584f, 0.30695987f, 0.18302193f, 0.18281052f, 0.18903919f, 0.08735327f, -0.19804522f, 
    -0.02398342f, -0.06110265f, 0.03525398f, 0.07949959f, 0.09864557f, 0.17245376f, 0.00268896f, -0.04259478f, 
    0.16853648f, -0.11087318f, -0.34958386f, -0.17701598f, -0.06276470f, -0.00993109f, 0.08409937f, -0.11700471f, 
    0.59750956f, 0.17165056f, -0.21370208f, 0.15022324f, 0.09096493f, 0.02262099f, 0.19342764f, -0.07831574f, 
    -0.06514829f, 0.04884518f, 0.12763926f, 0.22064288f, -0.10084740f, 0.21906517f, 0.13218012f, 0.03126602f, 
    0.07196011f, 0.03260900f, -0.11013919f, 0.01392660f, -0.48779690f, -0.09026457f, -0.37529266f, -0.40403539f, 
    0.28244495f, 0.11761496f, -0.30484739f, -0.15937474f, 0.09128726f, -0.07823624f, 0.19739833f, -0.12453867f, 
    -0.20598635f, -0.08140555f, -0.27184287f, 0.01515116f, 0.39292955f, -0.04603947f, -0.11963756f, 0.05285600f, 
    0.07283458f, -0.10099710f, 0.12139064f, -0.12827237f, 0.03697070f, 0.16239393f, -0.00763386f, 0.16172691f, 
    -0.04089602f, 0.07293884f, 0.28471047f, -0.19115962f, 0.22233319f, 0.18750155f, -0.08306687f, -0.04524380f, 
    0.12074994f, -0.10620710f, 0.01886559f, 0.12990631f, -0.10172433f, -0.15105388f, -0.25829452f, -0.12594889f, 
    0.02030190f, -0.00233704f, 0.09732638f, 0.02206822f, -0.03412385f, 0.07294103f, -0.00783973f, 0.01584089f, 
    0.18072675f, 0.23062055f, 0.04250303f, 0.01598866f, 0.22842030f, -0.05722723f, 0.20674641f, -0.09031107f, 
    -0.01026837f, 0.05436166f, -0.14768952f, 0.03492355f, 0.05756087f, -0.03829598f, 0.17913537f, -0.20279157f, 
    -0.05193286f, -0.01141901f, -0.00637779f, -0.07623961f, -0.03135876f, 0.06726450f, 0.02348812f, 0.01873241f, 
    -0.26757035f, -0.10452019f, -0.20370151f, 0.07353525f, 0.03631751f, 0.07832831f, -0.06581175f, -0.01502109f, 
    0.23674273f, 0.05885058f, -0.07965224f, 0.20059492f, -0.00545685f, 0.18373258f, 0.15166858f, 0.45365524f, 
    -0.10781155f, 0.16377027f, 0.27006626f, -0.24312627f, 0.12937902f, -0.20114432f, 0.13256469f, -0.11696390f, 
    -0.22814623f, -0.01951099f, -0.24581197f, 0.33275366f, 0.16777664f, 0.03940824f, 0.01549234f, -0.07613739f, 
    0.17164399f, -0.10916904f, 0.27460569f, 0.01524059f, 0.22874370f, 0.00804622f, 0.06129686f, 0.35142520f, 
    -0.01653287f, 0.13662148f, 0.03042432f, 0.18504944f, 0.12261571f, 0.20280139f, 0.17335346f, -0.17263046f, 
    -0.00064726f, -0.27278048f, 0.38863775f, 0.16910297f, 0.13720654f, 0.12315518f, -0.06425902f, -0.06617008f, 
    -0.07004739f, 0.06536815f, 0.02471243f, 0.18173072f, 0.18156140f, 0.31451637f, 0.33005434f, 0.34610537f, 
    -0.01294996f, -0.02563487f, -0.07856380f, 0.03910933f, 0.03942754f, -0.12949947f, 0.05219965f, -0.02184232f, 
    0.08519594f, -0.28137457f, -0.08507766f, -0.16088748f, 0.04539164f, -0.27381966f, -0.04353780f, 0.03797101f, 
    0.16627528f, 0.12010382f, -0.06108029f, 0.07650032f, 0.26650658f, 0.30330324f, 0.37252158f, 0.21442163f, 
    -0.12812595f, -0.17628717f, -0.07237080f, 0.20511530f, 0.02834035f, 0.06366538f, 0.02426678f, -0.02648981f, 
    -0.09779031f, 0.34608728f, -0.03826549f, -0.12900627f, 0.00633795f, -0.15921374f, -0.04302981f, -0.13598338f, 
    -0.03712827f, 0.26951978f, -0.00788027f, 0.13352434f, 0.04230499f, -0.14885074f, 0.48278096f, -0.00672827f, 
    -0.10397071f, 0.16618013f, -0.09306504f, 0.19670622f, -0.09265772f, -0.05232790f, -0.03139009f, 0.04850666f, 
    0.02542489f, -0.05149221f, -0.01956537f, -0.03922689f, -0.00778956f, 0.13329583f, -0.08482005f, 0.05453721f, 
    -0.05887993f, -0.09465110f, -0.01516302f, -0.10099003f, 0.07234664f, 0.22893232f, 0.25902939f, 0.02061603f, 
    0.00303508f, 0.17593209f, -0.16419475f, 0.02776721f, -0.02480439f, -0.11071742f, 0.07186614f, -0.20470314f, 
    -0.06695952f, 0.01840954f, -0.27965525f, 0.06269425f, -0.10388786f, 0.01249827f, -0.15367274f, 0.05294207f, 
    -0.05249297f, -0.08214491f, -0.12917040f, 0.02580449f, -0.15993884f, -0.06874766f, -0.07174659f, -0.09206102f, 
    -0.01507091f, 0.06828652f, -0.00730624f, -0.04124833f, 0.21411134f, -0.09620618f, 0.15212207f, -0.03493828f, 
    0.05142599f, 0.10748415f, -0.16346334f, -0.01801311f, -0.12346881f, -0.04941620f, 0.04551629f, 0.23223545f, 
    -0.05421341f, 0.08531621f, -0.07310207f, -0.07904226f, -0.10569690f, -0.00906456f, -0.11860448f, 0.54017478f, 
    -0.00873591f, 0.05133411f, -0.09811940f, -0.08090062f, 0.09015585f, 0.10499950f, 0.01779030f, 0.12923916f, 
    -0.02936960f, 0.19783913f, -0.39864784f, 0.46430734f, 0.08079588f, -0.01748016f, 0.13510741f, -0.04437498f, 
    0.12555568f, -0.08535429f, -0.01066875f, 0.21371715f, 0.05723768f, 0.20616658f, 0.41892883f, 0.08270973f, 
    -0.06813595f, -0.01968878f, 0.09259941f, 0.23814481f, -0.06331432f, 0.14800465f, -0.09595179f, -0.04323130f, 
    -0.06969177f, -0.17753369f, 0.39432114f, -0.17343798f, -0.08595246f, 0.05053547f, -0.04077584f, 0.02336131f, 
    0.10645672f, 0.01536130f, 0.01853733f, -0.03094555f, 0.08700384f, 0.09729991f, -0.07003473f, -0.15027745f, 
    0.04251095f, -0.03807613f, 0.16818586f, 0.05607000f, -0.06101228f, -0.39607581f, -0.32942423f, 0.01160980f, 
    0.20713951f, 0.16907424f, 0.04095889f, 0.16223888f, -0.04437422f, 0.04139465f, 0.04651854f, 0.09431233f, 
    0.15554394f, 0.12151656f, -0.17687307f, 0.13614523f, 0.07416634f, 0.20567320f, 0.01066724f, 0.11804645f, 
    -0.12044946f, 0.10912999f, 0.05118540f, -0.20026639f, -0.15284376f, -0.00522396f, -0.13983120f, 0.12086172f, 
    0.14917426f, 0.61516994f, -0.00010685f, 0.12532127f, 0.00889982f, 0.01842054f, 0.06026906f, 0.13745609f, 
    -0.01961459f, -0.06927801f, -0.12301934f, -0.04830534f, -0.21317008f, -0.01787066f, 0.03787161f, -0.13838115f, 
    -0.05251360f, 0.06236955f, 0.00264150f, -0.00653415f, -0.00958545f, 0.11993685f, 0.25196320f, 0.08967480f, 
    -0.31722322f, -0.13024448f, 0.08595408f, 0.11940733f, 0.04847173f, -0.03943831f, 0.00580637f, 0.00249571f, 
    0.03582461f, -0.03589808f, 0.06373186f, 0.12263450f, 0.06191835f, -0.16982706f, 0.01936248f, -0.09074919f, 
    0.09554993f, 0.07332949f, -0.01163606f, 0.10545285f, 0.08454934f, 0.12783754f, 0.13013841f, -0.25749296f, 
    0.01273837f, 0.24868965f, 0.14233933f, 0.23322284f, 0.07668369f, -0.07144410f, 0.15883669f, -0.10831398f, 
    -0.02765984f, -0.16664954f, 0.05867388f, 0.02641867f, -0.21159312f, 0.14669991f, 0.02025452f, 0.15819323f, 
    0.05425398f, 0.12847340f, 0.07125121f, -0.00305626f, 0.12759876f, 0.06829239f, -0.06387961f, 0.37461311f, 
    -0.01485176f, -0.02612327f, -0.00498447f, 0.01941555f, 0.01053253f, -0.02163482f, -0.05553448f, -0.04980841f, 
    0.03616934f, -0.00100266f, 0.00665481f, -0.03114823f, 0.02771037f, 0.01088048f, -0.03575211f, -0.05366120f, 
    -0.00090880f, 0.01547014f, -0.04914987f, -0.04601446f, 0.01148555f, -0.04780575f, -0.03794803f, -0.04065297f, 
    -0.04897764f, -0.01773623f, 0.03970855f, -0.04779146f, 0.01932205f, -0.00352895f, -0.02689166f, -0.00865468f, 
    -0.03118160f, 0.01530794f, -0.03692046f, 0.04153768f, 0.01801363f, 0.00425343f, 0.00979095f, 0.03726671f, 
    0.03856866f, -0.04277424f, -0.02736853f, -0.04586228f, -0.05673942f, 0.03529594f, -0.01981856f, 0.01698279f, 
    0.02761918f, 0.00295546f, -0.00477092f, -0.02990148f, -0.05196085f, -0.03356524f, -0.04567540f, 0.01877766f, 
    -0.00033579f, 0.02612894f, -0.04086398f, -0.05230400f, -0.00009135f, -0.04266432f, 0.01344248f, -0.03875455f, 
    0.02394714f, 0.04061154f, -0.02219817f, -0.03351748f, -0.01727983f, -0.03002660f, -0.03020084f, -0.00173108f, 
    0.03442715f, -0.02164613f, 0.04267756f, -0.02642632f, -0.00702338f, -0.00107700f, -0.03975273f, -0.03292234f, 
    -0.02956049f, -0.03648409f, -0.02137799f, 0.01282316f, 0.00271391f, -0.01845108f, -0.01221028f, 0.00811463f, 
    -0.04313410f, -0.00937113f, -0.04795687f, -0.00663083f, -0.05233122f, 0.00640630f, -0.03185275f, -0.04334245f, 
    -0.01510826f, -0.00849121f, 0.01448136f, -0.03404459f, 0.01357771f, -0.05343186f, -0.01684605f, 0.01409395f, 
    -0.01765759f, -0.03384921f, 0.00901313f, 0.03424785f, -0.02706257f, -0.00224397f, 0.01729682f, 0.02819328f, 
    0.03018379f, -0.02925438f, 0.03622044f, -0.04000441f, -0.05193865f, 0.02420609f, -0.04767161f, -0.01319594f, 
    -0.00349006f, 0.02958908f, -0.04677265f, -0.00769786f, -0.04970196f, -0.03377771f, 0.00412150f, -0.05299154f, 
    0.01709420f, -0.00852954f, -0.05023402f, -0.05199482f, -0.04073172f, -0.00217842f, -0.01220687f, -0.00498665f, 
    0.01061299f, 0.02082368f, -0.02909944f, 0.00355061f, 0.00086620f, -0.02102884f, 0.02980137f, 0.00857310f, 
    -0.00438994f, -0.05531384f, -0.02801189f, -0.04610973f, -0.01499506f, 0.01926105f, -0.03573022f, 0.03120168f, 
    0.02025701f, 0.01054059f, -0.02192208f, 0.01228229f, -0.01863981f, 0.04002142f, 0.00267097f, 0.00905512f, 
    -0.03153575f, 0.02308411f, -0.00006014f, -0.02494186f, 0.01376248f, -0.00074993f, -0.04073462f, -0.03787674f, 
    0.00631791f, -0.00949136f, -0.04981325f, -0.04961349f, -0.01216105f, -0.04645463f, 0.00838814f, 0.01963592f, 
    -0.01399307f, 0.03103246f, 0.01935388f, -0.05663959f, -0.02540252f, 0.02079125f, -0.00707387f, -0.02481272f, 
    0.02023163f, 0.03740160f, -0.02299754f, -0.02432446f, 0.01780742f, 0.00636040f, 0.02210657f, -0.01265230f, 
    0.01100551f, -0.04611545f, -0.04499957f, -0.01409545f, -0.01707212f, -0.02157445f, 0.02247540f, 0.00150357f, 
    0.02690833f, 0.02631427f, 0.00233887f, 0.02562631f, -0.04128593f, 0.03889814f, -0.04641859f, -0.00015815f, 
    0.01933741f, -0.02183997f, -0.02290213f, 0.04310658f, -0.02142602f, -0.05432812f, 0.00613250f, -0.00980579f, 
    -0.01926402f, -0.00564249f, -0.05434621f, 0.01397235f, -0.04817008f, -0.01146081f, -0.01372600f, 0.02135830f, 
    0.03606464f, -0.04852143f, 0.01172277f, -0.03827594f, 0.01601809f, 0.00390436f, -0.02880239f, -0.04545210f, 
    -0.01537456f, -0.02247634f, -0.03374981f, 0.02835098f, -0.00389692f, -0.01338729f, -0.01041714f, -0.03318319f, 
    0.01997848f, -0.00544549f, -0.04427730f, 0.02270303f, 0.01822788f, -0.03420598f, -0.01415210f, 0.01746037f, 
    -0.01033311f, 0.02514570f, 0.04087858f, 0.02790754f, -0.00188321f, -0.01801453f, 0.02677241f, -0.04889335f, 
    0.01613118f, -0.05725507f, -0.04166168f, -0.02531731f, 0.00495030f, -0.05655403f, 0.02257971f, -0.03153286f, 
    0.00310368f, 0.01874766f, -0.02179986f, -0.03933009f, 0.03195656f, 0.01421823f, -0.01496282f, 0.02009359f, 
    -0.01821367f, 0.02998241f, 0.01398265f, -0.05425183f, 0.01226975f, 0.00918107f, 0.04030002f, 0.00677626f, 
    0.01222096f, -0.04513712f, -0.00124048f, 0.03450838f, 0.00095788f, 0.02234453f, -0.05789442f, -0.00462015f, 
    0.00839755f, 0.00975231f, 0.01143358f, 0.03422729f, -0.00043315f, -0.02766739f, 0.02772283f, 0.02977330f, 
    0.03929057f, -0.03482680f, -0.01677811f, 0.04142034f, -0.00515433f, 0.01038794f, 0.01604329f, -0.02366260f, 
    0.01972288f, -0.05457444f, 0.01650364f, -0.05718791f, 0.01184660f, -0.02363305f, 0.01100799f, -0.03537259f, 
    0.02818799f, -0.00945732f, 0.00908013f, -0.00766489f, 0.01057037f, 0.02412025f, -0.01708490f, -0.03955646f, 
    0.03974661f, 0.00197059f, 0.03063462f, -0.05527624f, 0.04253153f, -0.01282166f, -0.02868442f, 0.03460052f, 
    -0.04308234f, 0.00108752f, 0.03200097f, 0.00203654f, 0.04029967f, -0.01858955f, 0.02955707f, -0.03052262f, 
    -0.00608845f, -0.04445134f, 0.03924979f, 0.04434504f, -0.04934492f, -0.02451264f, 0.01259902f, -0.03494475f, 
    0.00001221f, 0.01422096f, -0.01769129f, -0.03013409f, -0.04107460f, 0.02937927f, -0.04270318f, -0.00724443f, 
    0.04251869f, 0.03229745f, 0.03213546f, -0.00864970f, -0.01635423f, 0.02727006f, -0.02232518f, 0.01132131f, 
    -0.02226496f, 0.01120135f, -0.00040813f, -0.04376715f, 0.02319839f, -0.03845890f, -0.02599578f, -0.04451751f, 
    0.00915870f, -0.04741072f, -0.02627661f, -0.05284445f, 0.00610952f, -0.01433918f, -0.04592350f, 0.02316708f, 
    0.02249135f, 0.01157370f, -0.05464680f, 0.01645522f, 0.00226102f, 0.00038936f, 0.01293801f, -0.00184544f, 
    -0.65185034f, 0.13876256f, -0.01762115f, 0.46463430f, 0.10167722f, 0.15415174f, -0.10473649f, 0.02826010f, 
    -0.03344710f, 0.00459975f, -0.09667005f, 0.06749266f, 0.19694786f, -0.28884971f, 0.05037684f, 0.03025588f, 
    -0.06388881f, -0.00514506f, 0.00290611f, -0.04819990f, 0.01082841f, -0.14717610f, -0.02797136f, -0.02993035f, 
    -0.25148520f, 0.09339404f, -0.02220743f, -0.13275875f, 0.07423500f, 0.03364430f, 0.14196140f, 0.05328239f, 
    -0.00252012f, 0.05663193f, 0.04561620f, 0.10055847f, -0.25984013f, -0.03649906f, -0.36579531f, 0.15931138f, 
    0.19728473f, 0.05816464f, 0.15171283f, -0.08122887f, -0.02845194f, -0.09829681f, -0.02720625f, -0.05075405f, 
    -0.33653861f, -0.28794184f, 0.08918849f, 0.24845043f, -0.05589216f, -0.04654090f, 0.00693880f, -0.08377636f, 
    -0.01067557f, 0.01932413f, -0.06967084f, -0.00203717f, 0.01323390f, -0.13118827f, 0.10765496f, -0.07566270f, 
    -0.00543659f, 0.22476436f, 0.10521607f, 0.31969738f, 0.09823216f, 0.06872919f, 0.06881219f, -0.02777090f, 
    -0.20622262f, -0.01135706f, 0.35241702f, 0.29700813f, -0.16627726f, -0.01077595f, 0.03353920f, 0.00079347f, 
    0.11614429f, -0.03067311f, -0.01438995f, -0.00829114f, 0.20955166f, 0.28494206f, 0.09808735f, -0.12185524f, 
    0.04788912f, -0.07317099f, 0.04927400f, 0.10471487f, 0.06881680f, -0.07021333f, -0.01818575f, 0.11999375f, 
    0.42133030f, -0.27978012f, -0.09054483f, 0.13582046f, 0.12490851f, -0.02853470f, 0.02932307f, 0.13362250f, 
    0.13700470f, 0.09955169f, -0.00206106f, 0.05259245f, 0.12471163f, 0.35226995f, -0.16083364f, -0.20523190f, 
    0.12280384f, 0.05919195f, -0.15398701f, 0.02709882f, 0.04948873f, 0.03045999f, -0.06286541f, -0.12206408f, 
    -0.40364546f, 0.12403538f, -0.39217350f, 0.17067751f, 0.12756273f, 0.00349021f, 0.02558068f, -0.04533769f, 
    0.15615778f, -0.05737022f, -0.05449552f, -0.04413226f, 0.05685662f, 0.30438811f, 0.19759487f, 0.09797842f, 
    -0.06196623f, 0.13315138f, 0.10162390f, 0.07160795f, 0.01191916f, 0.07145187f, 0.07946510f, 0.05651839f, 
    -0.20513402f, 0.18706679f, -0.03245286f, -0.35034662f, -0.05519898f, 0.03772661f, -0.10825251f, -0.00561626f, 
    0.07079916f, -0.05328815f, 0.11341372f, 0.08008485f, 0.36731049f, -0.22036400f, 0.08449162f, -0.02203331f, 
    0.05743474f, -0.07880528f, -0.04597705f, -0.11114340f, 0.07296233f, -0.03337272f, 0.05419912f, 0.12668873f, 
    -0.10499274f, -0.14534564f, -0.14283945f, -0.04501085f, 0.13302110f, 0.08812579f, 0.12663125f, -0.06679235f, 
    0.07386272f, 0.02853197f, -0.10209001f, 0.08337177f, -0.34351826f, 0.43225729f, 0.12449250f, 0.00466763f, 
    -0.08070710f, 0.16145739f, 0.15503298f, -0.03267952f, 0.07330785f, 0.04307432f, 0.01402600f, -0.02778750f, 
    0.06430396f, -0.17868131f, 0.06576177f, -0.16227038f, -0.02900838f, 0.05222186f, -0.04150327f, 0.03803270f, 
    -0.02359253f, -0.35106704f, -0.00756914f, -0.12208818f, -0.24823990f, 0.03454917f, 0.19821748f, -0.01094356f, 
    -0.05119748f, -0.06144226f, -0.08063246f, 0.00067227f, 0.18166862f, 0.03547378f, -0.02392554f, 0.29403147f, 
    -0.05321660f, -0.30194771f, -0.26715779f, -0.22028421f, 0.25182709f, 0.05299560f, 0.04420326f, 0.01748819f, 
    -0.09240780f, -0.01207696f, 0.07461087f, 0.00906939f, 0.22869872f, 0.13095063f, 0.04366476f, 0.28069845f, 
    -0.03261940f, 0.01623075f, -0.02320593f, -0.08054680f, 0.14347214f, 0.03244523f, 0.10015194f, 0.09515419f, 
    0.08678087f, 0.01061491f, 0.08402998f, -0.00824006f, -0.13941827f, 0.07591883f, -0.01586218f, 0.12982804f, 
    0.05306925f, -0.06081140f, 0.02396893f, -0.09070356f, 0.21045518f, 0.33072263f, -0.06396069f, -0.16459550f, 
    0.14074680f, 0.04303125f, 0.09834471f, 0.19998980f, -0.13948226f, 0.00572059f, -0.04553532f, 0.14599138f, 
    -0.00752194f, 0.14664441f, -0.06834660f, 0.26777926f, 0.02450988f, 0.03544291f, 0.19767913f, 0.13510084f, 
    -0.01558230f, 0.05895751f, 0.03158019f, 0.01631382f, -0.07867590f, 0.11890936f, 0.11858114f, -0.36585972f, 
    0.01763125f, 0.07220955f, -0.08929617f, -0.02244019f, 0.02730480f, -0.03138683f, 0.20064054f, -0.02574530f, 
    0.24015121f, 0.39437672f, 0.16419007f, -0.09621939f, -0.00510676f, 0.04690690f, 0.14673002f, 0.08556081f, 
    0.12091251f, 0.15960550f, -0.05093553f, 0.00003411f, 0.29820806f, 0.30434430f, 0.13274249f, -0.20076323f, 
    0.03721584f, 0.04936825f, 0.01371073f, 0.12770216f, 0.05540842f, 0.05020560f, 0.08539174f, -0.05503931f, 
    0.28709710f, -0.02812099f, -0.18783253f, -0.30481663f, 0.01751560f, 0.06153420f, -0.02128292f, 0.05704393f, 
    0.08023088f, -0.01338948f, 0.04367905f, -0.01480487f, -0.17725350f, -0.29095379f, -0.26610079f, 0.13221708f, 
    -0.07006664f, -0.15584858f, -0.00516249f, -0.09692284f, 0.03419619f, 0.04328166f, 0.00064049f, 0.22376847f, 
    -0.42963970f, -0.11466444f, 0.05466477f, 0.13483898f, -0.05532626f, -0.08788134f, -0.04424477f, 0.09131363f, 
    0.06316471f, -0.00316531f, 0.06032503f, -0.00726027f, -0.11781525f, -0.19259664f, -0.43781981f, 0.30110914f, 
    0.13819979f, 0.08905306f, 0.12641414f, -0.02425537f, 0.09314326f, -0.11280583f, 0.15138489f, 0.05972583f, 
    0.08015309f, 0.24827856f, 0.27364767f, -0.07876738f, 0.09143447f, 0.13447259f, 0.12937462f, 0.15145898f, 
    0.11315577f, -0.08552443f, 0.06712205f, 0.15556796f, -0.08299708f, 0.10817713f, 0.33891940f, 0.13578568f, 
    -0.05745354f, -0.03602143f, -0.09884912f, -0.07329816f, 0.06094227f, -0.05438387f, 0.00958188f, 0.02906641f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14399251f, 0.19129980f, 0.01790801f, -0.01513585f, 0.23520666f, -0.03677090f, -0.00500089f, 0.00735265f, 
    -0.05552263f, 0.07317179f, -0.03849763f, 0.01618221f, -0.00989508f, -0.00474785f, -0.01707113f, 0.04017420f, 
    0.12899290f, -0.04036890f, 0.08636665f, 0.05315127f, 0.20260262f, 0.01556113f, 0.13153838f, 0.24259222f, 
    0.09704905f, 0.17105098f, 0.03634839f, 0.08627062f, -0.03429609f, 0.06904049f, -0.01416078f, 0.11537466f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.11372190f, 0.02364875f, 0.01855684f, 0.01158764f, -0.19225292f, -0.07164235f, -0.15004306f, -0.04039729f, 
    -0.16793019f, -0.19925705f, -0.07856852f, 0.11061021f, 0.10193241f, -0.12611294f, 0.01457101f, 0.01199194f, 
    -0.20409113f, -0.08537727f, -0.20565908f, -0.14093046f, -0.00332496f, -0.01221133f, 0.17390648f, -0.10802756f, 
    -0.06447317f, -0.09613586f, -0.14548175f, -0.10214394f, 0.00091985f, -0.07012568f, -0.02144246f, -0.01990902f, 
    0.09370788f, -0.29897985f, -0.04635978f, 0.04483668f, 0.10355944f, -0.16937284f, -0.02957319f, -0.01216432f, 
    0.21003379f, -0.26432967f, -0.07723637f, -0.04861253f, 0.02578728f, -0.09298319f, -0.15789045f, -0.27532506f, 
    -0.01031501f, -0.07724859f, 0.14854640f, 0.16763258f, -0.05970537f, 0.06621277f, 0.09774308f, 0.16300769f, 
    -0.15498148f, 0.10902566f, 0.07554466f, 0.07278886f, 0.31782764f, 0.00838772f, 0.00504759f, -0.19540924f, 
    0.02931398f, -0.06917336f, 0.15908165f, -0.02608932f, -0.05573811f, 0.02905570f, -0.12872404f, -0.15413681f, 
    0.05696432f, -0.14732294f, -0.04625956f, 0.07576724f, -0.14119262f, -0.04108414f, -0.08716761f, 0.01738263f, 
    -0.00171285f, -0.07836369f, -0.10922001f, -0.09799404f, -0.03204875f, 0.02031949f, 0.06213715f, -0.09455007f, 
    -0.18758011f, -0.02503030f, 0.11332938f, -0.39404070f, 0.05686565f, 0.09360557f, -0.15260708f, -0.44130301f, 
    0.19540638f, -0.15231675f, 0.12465473f, 0.01091662f, -0.40488401f, 0.06492442f, -0.08043553f, -0.14029898f, 
    -0.15020153f, -0.16154467f, 0.28231579f, 0.07892251f, 0.08451943f, 0.03476855f, -0.25935432f, 0.06483866f, 
    0.28300494f, 0.00174000f, -0.17031780f, -0.00902346f, -0.34878674f, -0.03943082f, -0.40956149f, 0.20626915f, 
    0.26277465f, -0.12622693f, -0.05689843f, 0.11652802f, 0.27690509f, 0.02511429f, 0.08923970f, 0.30072716f, 
    -0.23875263f, 0.22142188f, -0.04796416f, -0.14079443f, 0.34001589f, 0.04869147f, 0.11858933f, 0.24130140f, 
    -0.10527609f, -0.29566997f, -0.12522790f, -0.12207181f, -0.11116321f, -0.04648918f, -0.16137221f, -0.18529688f, 
    -0.10676210f, 0.15940693f, -0.24414504f, 0.09718015f, 0.06334427f, 0.10437879f, 0.19635640f, 0.13712737f, 
    0.34369707f, 0.27002618f, -0.18539865f, 0.14199227f, -0.18343914f, -0.19963355f, -0.11815528f, 0.13007018f, 
    0.14711259f, -0.12039723f, -0.14806940f, 0.06247463f, -0.09087260f, 0.11937024f, 0.11057554f, 0.20064741f, 
    0.22273439f, -0.09328328f, -0.18381761f, -0.00561173f, -0.00177860f, -0.12884033f, -0.21668465f, -0.13183409f, 
    -0.04446616f, 0.06390950f, 0.14411642f, 0.15894534f, -0.25775000f, 0.11166719f, -0.21972749f, -0.46091461f, 
    -0.21500313f, -0.20789072f, 0.02587611f, -0.12085500f, -0.17006117f, -0.30266297f, 0.02054492f, -0.35260496f, 
    0.23379213f, -0.22054818f, -0.08258294f, -0.04193728f, 0.01530013f, 0.09586110f, -0.08222644f, -0.08014091f, 
    0.22251067f, -0.05886293f, -0.05068500f, 0.05747008f, 0.04543700f, -0.13562874f, 0.26895332f, -0.01765845f, 
    -0.00677517f, 0.15114552f, 0.04623284f, 0.25621444f, -0.07681777f, -0.02778918f, -0.15116468f, -0.02491601f, 
    0.18600076f, -0.41220745f, 0.09747420f, -0.06213764f, 0.23485389f, 0.04576446f, 0.15019993f, -0.00603062f, 
    -0.30860913f, 0.06071770f, -0.14307500f, -0.14322506f, -0.44696915f, 0.10468721f, 0.01052791f, 0.31973109f, 
    -0.06961816f, -0.11258108f, 0.39628917f, 0.11087266f, -0.17022143f, -0.07613230f, 0.21192652f, -0.27780625f, 
    -0.12450004f, 0.13001579f, 0.41540009f, -0.03286200f, -0.31432319f, 0.02502197f, -0.02397873f, 0.16608302f, 
    0.15861474f, 0.46789494f, 0.01339069f, -0.32520166f, -0.01000725f, -0.17630355f, -0.04325989f, 0.16916902f, 
    0.01131097f, 0.30687022f, -0.12007475f, -0.14786088f, -0.01411419f, 0.08703779f, -0.00412514f, 0.22153968f, 
    -0.10350739f, -0.23029728f, -0.24990149f, -0.09265386f, -0.05521222f, 0.16054051f, 0.04333957f, 0.12537342f, 
    -0.14865579f, 0.04957118f, -0.11164719f, -0.00377827f, 0.02020873f, 0.01643984f, -0.04524645f, -0.29222685f, 
    -0.30086488f, 0.05103663f, 0.23451956f, 0.22163901f, -0.22057521f, -0.13345841f, 0.16153298f, 0.30498880f, 
    0.12534711f, 0.32739154f, 0.04559500f, -0.17450355f, -0.03445276f, 0.14175765f, 0.09694494f, -0.01045925f, 
    -0.01411181f, 0.56834984f, -0.04071869f, 0.07547677f, -0.03435506f, 0.01668986f, 0.30671000f, 0.23412830f, 
    0.14983781f, -0.06983358f, 0.54402357f, 0.09371007f, -0.35181475f, -0.02669717f, 0.20693359f, 0.00971709f, 
    0.24485306f, -0.04184549f, 0.14028113f, -0.32679906f, -0.38749442f, 0.28567767f, -0.01491614f, -0.14448817f, 
    0.11600597f, 0.08243366f, 0.04964666f, -0.08246646f, -0.10808237f, -0.06889694f, -0.07693109f, 0.00278947f, 
    0.11134424f, 0.26188147f, 0.26344424f, -0.06333485f, 0.11738209f, -0.01262582f, 0.51776224f, -0.19898127f, 
    0.08567759f, 0.13934763f, 0.55204952f, -0.05946064f, 0.08864149f, -0.14704666f, 0.10756880f, 0.02850758f, 
    0.03024791f, -0.35404992f, -0.48716661f, 0.05395751f, 0.27378461f, -0.11521310f, 0.03941974f, -0.27558920f, 
    0.06940084f, -0.10086922f, -0.07234595f, -0.04364441f, 0.13921504f, 0.08806006f, 0.03565026f, 0.14115848f, 
    -0.01863113f, -0.16873115f, -0.09297179f, 0.04148468f, -0.12913172f, 0.13217102f, -0.01026588f, -0.03616988f, 
    0.02908405f, 0.00488311f, 0.17800882f, -0.29432616f, 0.23232694f, -0.16979374f, -0.01099100f, -0.09445646f, 
    -0.09030449f, -0.07496740f, -0.28835922f, -0.27633709f, -0.02711434f, 0.16226357f, -0.02827380f, -0.02770010f, 
    -0.23426355f, -0.10363869f, 0.12870936f, 0.10584389f, 0.30625042f, -0.14763673f, 0.12255709f, 0.16215999f, 
    -0.10488597f, 0.34573665f, 0.05248383f, -0.10932284f, -0.11080080f, -0.07948988f, -0.04965104f, -0.45253664f, 
    -0.16506414f, 0.06442551f, -0.06629764f, 0.12600046f, 0.08229435f, -0.10973437f, 0.18692617f, 0.18420106f, 
    0.23998152f, -0.04154322f, 0.05821490f, -0.11063819f, 0.13252385f, 0.06887184f, -0.17708664f, -0.28880468f, 
    0.22118217f, 0.33693975f, -0.09484037f, 0.01546112f, -0.04110887f, 0.01152913f, 0.05037438f, -0.37923354f, 
    -0.31162748f, -0.39926639f, 0.06049725f, 0.17377317f, 0.11237021f, -0.13618675f, -0.04510565f, 0.26294205f, 
    0.20696840f, -0.10858093f, -0.14768571f, 0.06333855f, -0.38047585f, 0.00613036f, -0.32638207f, 0.05140032f, 
    0.18220465f, 0.01034430f, 0.07998309f, 0.30308214f, 0.23728922f, 0.26599094f, 0.12367280f, 0.40013465f, 
    -0.51067716f, -0.08914237f, 0.16701697f, 0.08486149f, -0.03056108f, 0.07340014f, 0.13341576f, 0.11924626f, 
    -0.61590230f, 0.16164072f, 0.23809861f, 0.02476836f, 0.15090907f, 0.15989354f, 0.17642570f, -0.25428465f, 
    0.10903089f, 0.10926015f, 0.10534748f, -0.02638950f, 0.29735005f, 0.03913098f, 0.12799978f, 0.15130562f, 
    0.02189864f, -0.12848462f, -0.23014498f, 0.43034834f, -0.12219117f, -0.27605915f, 0.10300907f, -0.04191488f, 
    0.02988539f, -0.07618883f, -0.05203358f, 0.09754578f, -0.07372589f, 0.00467187f, -0.02456225f, -0.20996596f, 
    -0.13339932f, -0.01791621f, -0.02118584f, 0.14977925f, 0.16436714f, 0.16557626f, -0.15938032f, 0.01126722f, 
    -0.13125387f, -0.12051472f, 0.04118526f, -0.02761248f, -0.16581249f, -0.07256740f, -0.04863024f, 0.00604331f, 
    0.00289024f, 0.15606067f, 0.08175374f, -0.06491854f, 0.15992269f, -0.00611693f, -0.17626537f, -0.00036663f, 
    0.05933667f, 0.01631892f, 0.00514207f, 0.06906549f, -0.16170426f, -0.11058749f, 0.00831345f, 0.07829775f, 
    -0.19851747f, 0.08552234f, -0.05945494f, 0.13265882f, -0.15992329f, 0.13984998f, 0.08386132f, 0.07183654f, 
    -0.08135039f, 0.07425037f, -0.11274876f, -0.06621358f, 0.07543404f, 0.03100125f, 0.01750423f, -0.14652652f, 
    -0.16279840f, -0.15127023f, -0.07750191f, -0.20009218f, 0.12244612f, -0.15436149f, -0.10106895f, -0.00286563f, 
    0.20561749f, 0.06957633f, -0.07370718f, -0.14053419f, 0.06596506f, -0.06114680f, 0.01145276f, 0.01322512f, 
    -0.23194587f, 0.17150646f, 0.02753211f, -0.15932003f, -0.10857802f, 0.11736986f, 0.39155579f, 0.13082577f, 
    0.02660325f, 0.02582687f, -0.20107614f, 0.28882855f, -0.01723611f, -0.15960121f, 0.11845279f, -0.13185808f, 
    0.50757277f, -0.09424177f, 0.06285834f, 0.09504746f, 0.39384237f, -0.09988955f, 0.15303880f, -0.23440345f, 
    0.09812185f, -0.04330107f, -0.16071030f, -0.07179771f, 0.08249541f, 0.13845663f, 0.03945294f, -0.23621665f, 
    -0.06212000f, -0.18375741f, 0.25335193f, 0.16227491f, 0.00687069f, -0.06215239f, -0.01246800f, -0.24821000f, 
    0.08325523f, 0.02523524f, -0.26774472f, -0.32275864f, 0.08325267f, -0.09580830f, -0.17154346f, 0.44720984f, 
    0.09698559f, 0.05330331f, 0.32591620f, 0.25553662f, 0.28105336f, 0.34614041f, -0.07833312f, 0.06252354f, 
    -0.12207977f, 0.29536077f, -0.17103192f, -0.11669055f, -0.63863093f, 0.02737695f, -0.02277641f, 0.14732379f, 
    0.19872655f, -0.37020057f, 0.04610094f, 0.14979585f, -0.15079314f, 0.01758434f, -0.03929549f, 0.08929583f, 
    -0.21549226f, -0.04638790f, 0.09259614f, -0.06264754f, 0.15071777f, -0.09549692f, 0.03774163f, 0.10394480f, 
    -0.21260697f, 0.34247217f, -0.36223808f, -0.08917445f, -0.27400473f, -0.03325937f, -0.08281801f, 0.21702220f, 
    -0.14951436f, 0.11434596f, 0.02349835f, 0.08191444f, 0.03346742f, 0.04956143f, 0.07991685f, 0.16981098f, 
    -0.07540718f, -0.04347831f, 0.59149694f, 0.07660152f, -0.11425292f, -0.04419183f, 0.38278931f, -0.26549059f, 
    -0.22158578f, -0.08918159f, 0.09982977f, -0.47227010f, 0.25131434f, 0.03973189f, 0.09347226f, 0.20175456f, 
    -0.02119733f, 0.00549597f, -0.40976360f, 0.32424596f, 0.22045730f, 0.07813617f, -0.03727526f, -0.33257961f, 
    0.11808702f, -0.16620313f, -0.01512012f, -0.04088113f, -0.14036350f, 0.14895588f, 0.10459482f, -0.18447581f, 
    -0.11883800f, -0.01409997f, -0.17841998f, 0.02533571f, 0.01746169f, -0.07153045f, -0.16962914f, -0.01500707f, 
    -0.01940566f, -0.00857560f, -0.05567993f, -0.16587399f, 0.06989239f, 0.07833198f, -0.07800435f, 0.12646265f, 
    -0.18754157f, 0.08397847f, 0.13230592f, -0.17191190f, -0.15120567f, 0.01854808f, 0.15961355f, -0.12956749f, 
    -0.24113774f, 0.36386937f, -0.03568253f, -0.06704457f, -0.07609300f, 0.05249375f, 0.05864854f, -0.27638200f, 
    0.16357268f, -0.07278296f, -0.05810490f, 0.06530816f, 0.12969491f, -0.05380249f, 0.05716843f, 0.22112201f, 
    0.05768310f, 0.05881567f, -0.12744361f, -0.36360988f, 0.37279466f, -0.11204531f, 0.03398455f, 0.12136509f, 
    -0.16780788f, 0.34832957f, 0.00316283f, 0.02478366f, -0.27395269f, 0.31772110f, 0.02255634f, 0.18455352f, 
    0.23877947f, -0.05953112f, -0.15550475f, -0.14351770f, 0.24273868f, -0.08174974f, -0.08388735f, -0.22093958f, 
    -0.48090652f, -0.09276817f, -0.09794755f, -0.04806764f, 0.08307066f, -0.02155875f, -0.06046798f, -0.12555277f, 
    0.27641341f, 0.05069422f, -0.04462676f, -0.26415023f, -0.16479531f, -0.13108769f, -0.37949881f, 0.25044543f, 
    0.33679816f, -0.47370577f, -0.37458459f, 0.20632166f, 0.50810611f, -0.01035334f, -0.08164272f, 0.20149074f, 
    -0.17287540f, 0.00818251f, -0.08760398f, 0.03394608f, -0.08896706f, -0.17626330f, 0.05114522f, 0.08715387f, 
    -0.13153015f, -0.11193822f, 0.04837539f, 0.04200901f, 0.06480158f, -0.07371827f, -0.00219629f, -0.05195401f, 
    0.01275018f, 0.03508665f, 0.00031228f, -0.16938271f, -0.03657128f, 0.13924760f, -0.05886733f, -0.00114660f, 
    0.03507572f, -0.18732221f, -0.02827649f, 0.04945486f, 0.13421804f, -0.05179752f, -0.10950352f, -0.01817438f, 
    0.12779953f, 0.12453554f, 0.07798059f, 0.07467058f, 0.04937338f, -0.10339225f, -0.01940742f, -0.21148254f, 
    -0.03954653f, 0.02697729f, -0.56011575f, -0.16718534f, -0.15616159f, 0.01146512f, 0.13448887f, 0.27802023f, 
    0.35730445f, 0.13585050f, 0.47304174f, 0.24716584f, -0.30221191f, 0.04073637f, -0.00706424f, -0.04390314f, 
    0.03143309f, 0.21953821f, -0.06489519f, -0.33178332f, -0.56090492f, -0.17697772f, -0.04281535f, 0.31975871f, 
    0.01266072f, 0.02728304f, 0.13083045f, 0.16275050f, -0.01554045f, 0.13418648f, 0.08673302f, -0.08984579f, 
    0.12998450f, -0.24303107f, -0.31700179f, 0.15127425f, 0.16771919f, 0.01902327f, 0.07882469f, 0.03946767f, 
    -0.24621652f, -0.08186246f, 0.19576144f, 0.18591130f, -0.16265851f, 0.03590864f, -0.17050780f, -0.12042984f, 
    -0.15863135f, 0.10721654f, 0.13192756f, -0.43280250f, -0.06229974f, 0.09956900f, -0.01174648f, -0.00924506f, 
    0.17004251f, -0.18665552f, 0.09109824f, -0.17022462f, -0.25773817f, 0.09047585f, -0.01425665f, -0.03087083f, 
    -0.29526415f, 0.56934386f, -0.33141708f, 0.05909586f, -0.05150400f, -0.11178156f, -0.20423244f, 0.20724267f, 
    0.35943499f, 0.02644352f, 0.38766366f, -0.14460024f, 0.29773331f, 0.06080849f, 0.46863750f, 0.03499619f, 
    0.12095114f, -0.20059752f, -0.13209139f, -0.38304171f, 0.26057225f, 0.14274171f, 0.16556896f, -0.02484094f, 
    -0.06864737f, 0.35144582f, -0.17985769f, -0.02659207f, -0.17118944f, 0.07512791f, -0.14017688f, 0.00823636f, 
    -0.60356498f, -0.21637504f, 0.43978170f, 0.05385304f, -0.01752227f, -0.17999747f, 0.54416806f, 0.18227771f, 
    -0.19578786f, 0.04153293f, -0.23902552f, 0.00857217f, 0.36059394f, 0.09445915f, -0.09141643f, 0.04128430f, 
    -0.04509203f, 0.36401492f, -0.63198465f, 0.00270752f, 0.55739540f, 0.01924787f, -0.07930914f, -0.00723699f, 
    -0.26074675f, -0.02473157f, -0.07339300f, 0.06831710f, 0.13629608f, 0.07939705f, -0.10027369f, 0.22298227f, 
    0.03817984f, 0.26943541f, 0.08892269f, 0.05893099f, 0.14336176f, 0.05035254f, 0.10750463f, -0.30107233f, 
    -0.02689650f, 0.13369223f, -0.14462422f, -0.15405390f, -0.12260328f, -0.04934466f, 0.29614088f, 0.19891998f, 
    -0.14638028f, 0.30728489f, 0.37507769f, 0.15148312f, 0.00062271f, -0.35467049f, 0.03932172f, -0.31931087f, 
    -0.06510345f, 0.05016626f, 0.10639273f, 0.00989604f, 0.00195989f, 0.12766919f, 0.09584548f, 0.12092026f, 
    -0.35761350f, 0.32456660f, -0.27781662f, -0.13987409f, -0.08952154f, 0.12356185f, -0.00192268f, -0.10897459f, 
    -0.05368646f, 0.00632619f, 0.00575650f, -0.34517109f, 0.42372563f, 0.07327097f, 0.29597825f, 0.13946135f, 
    0.07589494f, 0.01992549f, 0.17502464f, 0.28653076f, -0.26663846f, -0.13968039f, -0.16637547f, -0.09355406f, 
    -0.11564003f, 0.22304688f, 0.02929850f, 0.17117001f, 0.28871813f, -0.02695514f, -0.10085943f, -0.24387094f, 
    -0.43978754f, 0.10785467f, -0.49299073f, -0.16063848f, -0.10093972f, 0.11979429f, -0.35877410f, 0.06869496f, 
    0.38331348f, 0.01469281f, 0.21628030f, 0.34308386f, 0.08159439f, 0.00043389f, 0.07390756f, 0.08786717f, 
    0.19939657f, 0.16870996f, -0.59777927f, 0.12348324f, -0.29015997f, -0.09643566f, -0.03816584f, 0.32707313f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07410527f, 0.00131118f, -0.22504118f, -0.17181687f, 0.21883811f, -0.20387158f, -0.05386742f, 0.12039146f, 
    -0.03113410f, 0.06776101f, -0.09738503f, 0.15553783f, 0.10529306f, 0.10932166f, 0.08012828f, -0.02569951f, 
    -0.07514570f, -0.08023133f, 0.17238343f, -0.15965091f, -0.13779981f, -0.18938529f, 0.07137968f, -0.02237387f, 
    0.01574855f, 0.12057674f, 0.23356588f, 0.20840561f, 0.00031453f, -0.02351038f, 0.09546023f, 0.31963193f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.07170624f, 0.14094035f, 0.25828111f, 0.32979560f, -0.38343588f, -0.16609395f, 0.15677936f, -0.43487561f, 
    -0.47611552f, -0.23177953f, -0.60870200f, -0.11201472f, 0.06387136f, 0.20864639f, -0.19970305f, 0.01048909f, 
    0.13916133f, 0.07184750f, 0.25867462f, -0.25833401f, -0.48893315f, -0.07694919f, -0.18117222f, 0.39256972f, 
    -0.08067717f, -0.02349629f, 0.01015655f, 0.12786102f, 0.04572367f, -0.18507268f, 0.01302377f, -0.08532043f, 
    0.00187145f, 0.12608112f, -0.10792835f, 0.25652081f, 0.01248147f, -0.26367709f, 0.03723392f, 0.45546687f, 
    -0.29434797f, 0.09954893f, -0.23148410f, -0.03100590f, 0.05900076f, 0.12548965f, -0.06802945f, -0.02481650f, 
    -0.18035085f, -0.30525666f, 0.09246844f, -0.20657197f, -0.32490188f, 0.08743709f, 0.01149555f, 0.22647852f, 
    0.13641059f, 0.28842857f, -0.07686119f, -0.06309905f, -0.95789921f, 0.24438494f, -0.22821447f, 0.33416435f, 
    0.13683560f, 0.13420796f, 0.26126853f, -1.05237210f, 0.09270553f, -0.44091535f, 0.03613281f, -0.75441337f, 
    -0.12201508f, -0.24820091f, 0.43418300f, -0.24371497f, 0.09561453f, -0.13114260f, -0.10029601f, -0.05095723f, 
    -0.20827481f, -0.06211285f, 0.27042884f, -0.46814045f, 0.21405612f, 0.08442329f, 0.10843349f, 0.36270496f, 
    -0.08875106f, -0.24830665f, 0.02786868f, -0.04342674f, 0.20840591f, -0.17212169f, -0.19653273f, 0.32326451f, 
    -0.04326208f, -0.63759589f, -0.34364876f, -0.13371962f, -0.35796949f, -0.45249757f, 0.32324308f, 0.26514605f, 
    -0.65604466f, 0.10591187f, 0.61131334f, -0.32535160f, -0.37609458f, -0.03894824f, -0.32080024f, -0.14844540f, 
    0.05332214f, 0.19226366f, -0.02861563f, -0.15455376f, 0.10783077f, -0.17721632f, 0.00868583f, 0.06087644f, 
    0.06481248f, 0.06874684f, -0.21936910f, -0.08391458f, 0.20635378f, -0.44037095f, -0.27438736f, -0.48533398f, 
    0.11165988f, -0.03581751f, -0.02716892f, -0.11755294f, -0.40261686f, 0.29250216f, -0.02460350f, -0.34620285f, 
    -0.03389938f, 0.04827603f, -0.29731163f, -0.16243194f, -0.05932723f, 0.14080863f, -1.02979302f, 0.00331410f, 
    -0.08048277f, -0.31777033f, 0.15310612f, 0.33772686f, 0.11048631f, -0.15985924f, 0.23960824f, 0.01211451f, 
    -0.16366586f, 0.01090590f, -0.00547926f, -0.49888769f, 0.28036046f, 0.15542048f, -0.97356439f, -0.24520609f, 
    -0.10866698f, 0.18643528f, 0.02375635f, -0.34949157f, 0.09559024f, -0.10757324f, -0.16517308f, -0.22813371f, 
    0.13082248f, -0.01668064f, -0.34720367f, -0.34015763f, -0.23770639f, 0.19441271f, -0.22629862f, -0.15461768f, 
    -0.01067925f, 0.28546226f, -0.30584848f, 0.22036271f, -0.76705712f, 0.00196241f, 0.17005104f, -0.10025674f, 
    -0.02470563f, 0.24309711f, -0.11733469f, -0.16575147f, 0.23469158f, 0.13306101f, 0.08237226f, 0.31407449f, 
    -0.00295345f, -0.00839628f, -0.00553891f, -0.16253747f, 0.06772807f, -0.01802865f, 0.10873921f, -0.40568450f, 
    0.07122102f, -0.50506341f, -0.03504265f, -0.14557058f, 0.03499150f, -0.86795282f, 0.56938189f, 0.01177879f, 
    -0.07812919f, -0.11463645f, 0.24015303f, -0.34573942f, 0.30078673f, 0.01531317f, -0.16237986f, -0.38144290f, 
    0.04073505f, -0.18649390f, -0.07995123f, -0.10749453f, -0.04015485f, 0.28388652f, 0.40796691f, -0.27401361f, 
    -0.10818991f, 0.12509406f, -0.05109043f, 0.11705465f, -0.10359179f, 0.19106694f, 0.02096673f, 0.44188070f, 
    -0.17079838f, -0.19905345f, 0.41093841f, 0.22211148f, -0.11438071f, -0.26751441f, 0.24948744f, 0.08766223f, 
    -0.08153960f, 0.12803362f, -0.64398158f, 0.16530366f, 0.20574659f, 0.14980267f, -0.62210792f, -0.19859359f, 
    0.08507898f, 0.07762623f, -0.03117598f, -0.23913461f, 0.44566339f, -0.08321700f, -0.10584336f, 0.00950962f, 
    -0.04164732f, -0.34699157f, -0.14686309f, -0.42841339f, -0.07328489f, -0.21419263f, -0.10175045f, -0.17964910f, 
    0.21959682f, 0.14568515f, 0.03170840f, 0.03997562f, 0.23715121f, -0.66431105f, 0.31808943f, -0.12896499f, 
    -0.12888443f, 0.23058626f, -0.86286318f, -0.55612993f, -0.01334256f, -0.11025007f, -0.36134762f, -0.11738472f, 
    0.10657609f, 0.22695711f, -0.27141586f, 0.34623253f, 0.01022168f, -0.18007724f, 0.00253373f, 0.26349899f, 
    0.19160387f, 0.18485342f, -0.09377111f, -0.11446396f, 0.23394072f, -0.38707998f, 0.03548041f, 0.22279574f, 
    -0.13307144f, -0.45277342f, -0.44109631f, 0.21766067f, -0.11829038f, -0.05446312f, -0.26974314f, -0.09951498f, 
    -0.11767364f, -0.43473971f, 0.21115009f, 0.37779808f, 0.17100754f, 0.13564840f, 0.11201282f, -0.11492322f, 
    -0.14422381f, -0.50918865f, -0.54807723f, -0.59912604f, 0.30492803f, -0.19351965f, -0.17272592f, -0.05837601f, 
    0.09167851f, 0.01571122f, -0.00929513f, -0.15917985f, -0.38107979f, -0.33182296f, -0.33050093f, -0.53076500f, 
    -0.55122870f, 0.11731774f, 0.11545938f, 0.23942645f, -0.36537647f, -0.29460964f, -0.24281342f, 0.13150899f, 
    0.14058074f, -0.60087979f, -0.22588785f, 0.48743939f, -0.16193531f, 0.04879582f, 0.30206403f, -0.25434610f, 
    0.11472448f, 0.15825377f, -0.46816617f, 0.57542247f, -0.46588787f, -0.54083824f, 0.20011903f, 0.15189070f, 
    0.04283833f, -0.28472325f, 0.07591696f, -0.03931959f, -0.07574655f, -0.82683611f, -0.51307106f, -0.14436051f, 
    -0.08182430f, 0.35821569f, 0.00059050f, -0.45933095f, 0.22270297f, 0.07726296f, -0.66444409f, 0.01129990f, 
    0.00246602f, 0.23689073f, 0.20326768f, -0.59533614f, -0.00904054f, 0.02466429f, 0.11036302f, -0.33225849f, 
    0.04078326f, -0.36301342f, -0.75020158f, -0.11670478f, -0.37464532f, 0.30458346f, 0.10692441f, -0.78642392f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.46928057f, 0.24240777f, 0.15468457f, -0.05422535f, -0.12660019f, -0.00019486f, 0.04533672f, -0.08548693f, 
    -0.03146742f, 0.17089549f, 0.17083529f, -0.08295392f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
