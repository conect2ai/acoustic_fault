#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.04435182f, -0.58963549f, -0.63900447f, -0.40418738f, -0.41484806f, -0.61825520f, -0.44773313f, -0.35064107f, 
    -0.50912440f, -0.03273255f, -0.14571229f, -0.75613922f, 0.59814382f, 0.38779742f, 0.41633856f, -0.46726581f, 
    -0.30000314f, 0.08095973f, 1.26277947f, -0.76041240f, -0.64997971f, 0.22193189f, 0.01843671f, 0.17013964f, 
    -0.16526613f, 0.18158363f, -0.35262755f, 1.14483714f, -1.15275013f, -0.65977693f, -0.06115041f, -0.05919826f, 
    0.38883242f, 0.03588342f, -0.12292152f, 0.19042242f, -0.16531917f, 0.13643798f, 0.30974758f, -0.67879689f, 
    0.18850575f, 0.52885932f, 0.34732574f, -0.35456732f, 0.01318935f, 0.50087476f, 0.30934107f, -0.10892122f, 
    -0.93169653f, -0.99239129f, -0.51824045f, -0.48510617f, -0.74186075f, -0.17281257f, -0.53915727f, -1.20961654f, 
    0.93966174f, 0.63055629f, 0.68038112f, -0.26469111f, -0.28442222f, -0.22450073f, -0.35566071f, 0.63680965f, 
    -1.11573672f, -0.88190669f, 0.02532341f, 0.50166285f, 0.38980567f, 0.08555362f, -0.04696478f, 0.08812378f, 
    -1.46278870f, 0.41191468f, -0.44568565f, -0.06793280f, 0.76878464f, 0.61772490f, -0.32757106f, 0.09554603f, 
    -0.16960363f, 0.19316870f, 0.36976475f, 0.24119273f, -0.73271543f, -0.56124353f, -0.63255060f, 0.21738669f, 
    0.20430434f, 0.60015607f, -0.08779974f, -0.18731490f, -0.47257796f, 0.35917935f, -0.81251913f, -0.63800913f, 
    -0.33659384f, 0.48251718f, -0.41437292f, 0.27523196f, 0.36491191f, 0.05235253f, -0.05759676f, 0.02423809f, 
    -0.62898302f, 0.32914710f, 0.32098150f, 0.31305480f, -0.76832938f, -0.55139703f, -0.69573039f, -0.08013473f, 
    -0.10159897f, -0.33035472f, 0.54056799f, 0.68490320f, 0.44250894f, 0.35448050f, -0.16046798f, 0.06106138f, 
    -0.29611722f, 1.03785717f, -0.64334852f, -0.16331986f, -0.43004403f, 0.00038617f, -0.52250105f, -1.22553849f, 
    -0.71556747f, 1.00895929f, 0.83333653f, -0.42508855f, -0.20148478f, 0.28984439f, 0.22736253f, -0.02313834f, 
    -0.30935240f, 0.02757281f, -0.33378741f, -0.39506790f, 0.22290939f, 0.20119628f, -0.48845267f, 0.64944601f, 
    0.41392049f, -1.38867879f, 0.37888947f, -0.70237398f, -0.50363517f, 0.53363472f, -0.01187208f, 0.55529070f, 
    -0.56162375f, -1.11532938f, -0.26652479f, 0.74298292f, -0.67947912f, -0.75501674f, -0.58911419f, 0.56553268f, 
    -0.08728367f, -0.29983869f, -0.12082397f, -0.67187774f, 0.50858450f, -0.63130790f, -0.14375538f, 0.77251464f, 
    0.16652834f, -0.11964875f, 0.21444942f, 0.37970167f, -0.09132890f, 0.57842588f, -0.10231428f, 0.33162695f, 
    0.32781795f, 0.09029344f, -0.06605507f, 0.14378363f, -0.48792443f, -0.64343458f, 0.71900535f, 0.24748491f, 
    0.46177742f, 0.33530465f, -0.49623811f, -0.31031597f, 0.07501804f, -1.31345093f, 0.59127855f, -0.19347048f, 
    0.38488191f, 0.59131366f, -0.15458322f, -0.25729829f, -0.47196871f, -0.61654085f, 0.16527335f, -0.12976176f, 
    0.37154850f, 0.58324522f, 0.26853091f, 0.19252858f, 0.23414133f, 0.07985277f, -0.11322497f, 0.98930538f, 
    -0.86026442f, 0.21569537f, 0.27275378f, -0.28535414f, -0.33212006f, 0.40266958f, -0.31555924f, 0.18370706f, 
    0.94627398f, -0.83269221f, 0.67381167f, -0.30511120f, -0.21924303f, 0.03749831f, -0.48566917f, 0.54449564f, 
    -0.45174116f, -0.96006703f, 0.92032945f, 0.41052037f, -0.84652489f, 0.49095544f, 0.20955573f, -0.32026494f, 
    -0.41818675f, -0.54748529f, 0.42344335f, 0.59933931f, -0.77871662f, -0.09759495f, 0.63863289f, -0.47086915f, 
    -0.21849012f, 0.63544554f, -0.14642230f, 1.22714889f, -0.09996767f, -0.49481583f, 0.64001626f, 0.21723554f, 
    -0.20938818f, 0.14102156f, -0.52101147f, -0.39850229f, -0.77031863f, -0.27269375f, -0.34911975f, 0.72500682f, 
    0.36445257f, 0.18342091f, 0.41148332f, 0.28081319f, -0.50244313f, -0.13516049f, 0.89783537f, 0.95420212f, 
    -0.94272631f, -0.86348706f, 0.12984098f, 0.17721623f, -0.19774906f, 0.13757722f, -0.36090395f, -0.56474876f, 
    -0.40195513f, -0.47914958f, -0.82002288f, -0.91570145f, 0.09257826f, 0.22794224f, 0.42923591f, 0.15474105f, 
    -0.20410697f, -0.71729451f, -0.96212459f, -0.59277713f, -0.43441087f, -0.18779543f, -0.69147021f, -0.44534263f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.40361020f, 0.11169819f, 0.06604884f, 0.26125845f, 0.38814241f, -0.11303541f, -0.06645495f, 0.34624574f, 
    -0.03035598f, 0.15094404f, 0.33074430f, -0.14334069f, 0.39475751f, -0.06297457f, 0.26232177f, 0.30799180f, 
    0.17785169f, 0.34683919f, 0.08112650f, -0.05513383f, 0.22630790f, -0.16078094f, -0.06944839f, 0.11619869f, 
    0.13235718f, 0.07097507f, -0.00770245f, 0.24489127f, -0.01180866f, 0.23804609f, 0.03389489f, -0.27997422f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.42734754f, 0.31123844f, 0.15228347f, -0.16092832f, -0.04246937f, 0.16530742f, 0.25947908f, 0.24621007f, 
    0.01582927f, 0.04069381f, -0.02865293f, -0.04007257f, -0.01346877f, -0.05749783f, -0.02113752f, -0.05546487f, 
    -0.11553117f, -0.16441695f, -0.03927171f, -0.04466251f, 0.06898872f, -0.24001479f, -0.32159710f, 0.07668103f, 
    -0.02288522f, 0.01114431f, 0.02930111f, -0.02217712f, -0.01190486f, 0.03084805f, 0.00680593f, 0.06115763f, 
    0.02797669f, -0.03118997f, -0.00993972f, 0.00677434f, 0.05592976f, 0.02007511f, 0.02439471f, -0.03928727f, 
    -0.04012737f, -0.17041183f, -0.32146698f, 0.06312662f, -0.10304425f, -0.09471968f, -0.06113053f, -0.01983333f, 
    -0.15837122f, 0.05298994f, -0.09105010f, -0.08841244f, -0.31516457f, -0.18036772f, -0.12685093f, -0.01101664f, 
    -0.00472904f, 0.07327931f, 0.06739905f, 0.09999530f, 0.20024636f, 0.17875372f, -0.28488171f, 0.03652625f, 
    0.02920850f, 0.01957028f, -0.10924456f, -0.00170443f, -0.01648211f, -0.17601326f, -0.09893825f, -0.17134680f, 
    -0.20615476f, 0.04939192f, -0.09758203f, 0.04507138f, 0.00813187f, -0.04580816f, -0.01788040f, 0.03830934f, 
    -0.57242841f, -0.38863936f, 0.21658365f, 0.00855921f, -0.09637371f, -0.09328353f, -0.05489234f, -0.08158367f, 
    0.01866793f, -0.05227879f, -0.13015738f, -0.04105731f, -0.15332568f, -0.04200573f, 0.05254135f, -0.09076749f, 
    -0.09514880f, -0.09499959f, -0.09395678f, -0.10034468f, 0.03001685f, 0.40236464f, 0.27102748f, -0.34819224f, 
    -0.14339368f, -0.07134294f, 0.01633498f, -0.02921545f, -0.11285356f, -0.05872419f, -0.01325350f, -0.11453184f, 
    0.00117660f, 0.03583413f, 0.01084253f, -0.03630211f, -0.02936671f, 0.14539550f, 0.11385190f, 0.02020903f, 
    0.84358650f, -0.09016549f, -0.36349523f, -0.41452694f, -0.20992056f, -0.05320459f, -0.15846074f, 0.24878973f, 
    0.05960517f, 0.10088768f, 0.01539336f, 0.11911070f, -0.05350247f, 0.03294898f, -0.04479992f, -0.02577514f, 
    0.13173540f, 0.09808483f, -0.00772593f, 0.05935278f, 0.26112688f, 0.12448213f, -0.33677244f, 0.07325101f, 
    -0.02039208f, 0.14199835f, 0.03408534f, 0.11277451f, -0.07281315f, 0.00426653f, -0.10289335f, -0.08614287f, 
    -0.24077043f, -0.02660525f, -0.01852403f, 0.06304166f, 0.08562684f, -0.04892163f, -0.02450078f, 0.00201944f, 
    0.10615995f, -0.00727224f, 0.06544455f, -0.01660652f, 0.00786265f, 0.09030879f, 0.12145300f, 0.13195784f, 
    0.09090035f, -0.25095746f, -0.03558701f, 0.01288437f, 0.10591968f, 0.08426687f, -0.06637796f, 0.02702144f, 
    0.10645878f, 0.01978151f, -0.05003805f, -0.00805908f, 0.17858186f, 0.11797435f, -0.05098857f, -0.10914849f, 
    -0.07584978f, -0.02493919f, -0.14550546f, -0.14403944f, -0.03445423f, 0.04617989f, 0.03532096f, -0.06276884f, 
    0.00544986f, -0.03654069f, -0.07788264f, -0.02906512f, -0.04676620f, -0.02146965f, -0.04503612f, -0.09779024f, 
    0.20176917f, 0.23950951f, -0.10171196f, -0.20982394f, -0.16428487f, -0.00888986f, 0.07258558f, -0.01060062f, 
    -0.08901045f, -0.00621148f, 0.03312700f, 0.01894451f, 0.00569427f, -0.07148337f, -0.07695243f, -0.01402278f, 
    -0.02696946f, -0.12677909f, -0.00920091f, 0.03273846f, 0.01073356f, -0.00388026f, -0.02371794f, 0.01560276f, 
    0.01492940f, -0.01147209f, -0.00220501f, 0.00554653f, 0.12280796f, 0.09531938f, -0.06105688f, 0.00066987f, 
    0.00486146f, -0.02057665f, -0.10317017f, -0.01630361f, -0.04833477f, -0.22240943f, -0.06079144f, -0.10094637f, 
    0.34729213f, 0.29866526f, 0.01974102f, -0.13519880f, 0.03010618f, 0.06998941f, 0.11291079f, 0.09142132f, 
    -0.07084563f, -0.16322064f, 0.03313364f, -0.16726823f, -0.04519619f, 0.03023719f, 0.09161282f, 0.02325115f, 
    -0.07218122f, -0.01565209f, -0.02597088f, 0.01594995f, 0.17827679f, -0.25598603f, 0.23073207f, 0.08663520f, 
    -0.16935994f, -0.05603737f, -0.08778690f, -0.02850370f, -0.00879349f, 0.07063962f, -0.05199348f, 0.01818765f, 
    -0.02753213f, 0.09540147f, -0.04592621f, -0.24055411f, -0.07448488f, -0.02621995f, -0.20123513f, 0.22360045f, 
    0.27811560f, 0.15066203f, -0.62689239f, 0.00966628f, 0.06908046f, 0.18327713f, 0.11189054f, 0.09514273f, 
    -0.36637297f, 0.04855119f, -0.02103825f, -0.02894115f, -0.04818005f, -0.03774160f, 0.00868565f, -0.04877254f, 
    0.08081225f, 0.01191599f, -0.03769464f, 0.00377226f, 0.13427311f, 0.16567130f, 0.17197107f, -0.34526134f, 
    -0.03773118f, -0.07290953f, -0.04815045f, -0.01225169f, -0.11910070f, -0.02963145f, -0.04152246f, -0.04854026f, 
    -0.02351182f, -0.02419746f, -0.09384148f, -0.01754942f, -0.13443276f, -0.01069462f, -0.07279802f, -0.21146695f, 
    0.19505538f, 0.14420241f, 0.07901413f, -0.51453072f, -0.06317297f, 0.01376962f, -0.02631751f, 0.16113731f, 
    -0.22805595f, -0.02719493f, -0.07192464f, -0.02225738f, -0.09677796f, -0.02497279f, -0.11278137f, 0.00692891f, 
    -0.13134456f, -0.10153501f, -0.09325818f, 0.02876577f, 0.33708128f, 0.29699501f, 0.17364284f, -0.45075426f, 
    -0.02862587f, 0.04605968f, 0.13508733f, -0.16164464f, 0.07554965f, 0.02208416f, 0.10041596f, -0.03384390f, 
    -0.04200360f, -0.09263326f, -0.01936246f, 0.01354713f, -0.00565875f, -0.00166589f, -0.02293121f, 0.02867089f, 
    -0.03714639f, 0.20946825f, 0.22577451f, -0.11058549f, 0.10627187f, -0.06901568f, -0.07470256f, 0.13962564f, 
    -0.04691575f, -0.06809582f, -0.16404019f, -0.15511325f, -0.05324612f, -0.01185946f, 0.07169152f, 0.03676992f, 
    -0.13033138f, -0.05010728f, -0.00991066f, -0.13212761f, -0.10203499f, -0.08443599f, -0.02796249f, -0.00103072f, 
    0.04478478f, 0.04244971f, 0.06402654f, 0.03295996f, 0.00683302f, 0.04050701f, 0.05110991f, 0.00727693f, 
    0.09248418f, 0.00904155f, 0.00040315f, -0.00938632f, -0.10620110f, -0.00244545f, -0.05042847f, -0.05628810f, 
    0.17014037f, -0.25268972f, -0.10630437f, -0.11214039f, -0.07136694f, -0.01647059f, -0.04401505f, 0.06912118f, 
    0.05630468f, 0.05971265f, -0.06125753f, 0.03634479f, 0.02263355f, -0.04370940f, -0.11888424f, -0.09419489f, 
    0.03239351f, 0.06487232f, 0.02380555f, 0.03632837f, 0.14952375f, 0.27223632f, -0.00712142f, -0.19808517f, 
    -0.05829760f, -0.02879045f, 0.04676021f, 0.06953504f, 0.12419373f, -0.01313225f, 0.03341880f, 0.07168598f, 
    0.09359972f, 0.00639234f, 0.06142662f, -0.07171559f, 0.01936807f, 0.10928071f, -0.16138971f, -0.12977481f, 
    -0.00749349f, 0.01288460f, -0.05127347f, 0.06208708f, 0.05794666f, -0.02400094f, 0.04252928f, 0.03815341f, 
    0.00759538f, 0.06331578f, -0.13852334f, -0.24034147f, -0.12713869f, -0.19503248f, -0.22534025f, -0.05491329f, 
    -0.03122767f, -0.03165910f, -0.01488522f, 0.03366970f, -0.15707663f, -0.02153953f, -0.08073408f, -0.12392393f, 
    0.06816320f, -0.29755574f, -0.08673632f, -0.01085880f, 0.01718039f, 0.01052606f, -0.04450725f, 0.07704221f, 
    0.08238573f, -0.02724425f, -0.12066619f, -0.22661155f, 0.05470068f, -0.21591873f, -0.23627913f, -0.03137309f, 
    -0.92010719f, -0.12999152f, 0.32706442f, -0.67263508f, 0.20892930f, -0.05242185f, 0.01533557f, 0.07099592f, 
    -0.07759562f, 0.11369003f, 0.01175422f, -0.00040851f, -0.00112808f, -0.03164819f, 0.04833984f, 0.01714589f, 
    -0.04351918f, -0.09564473f, -0.18214710f, -0.06108451f, -0.42874008f, -0.04056709f, 0.39677429f, 0.09670856f, 
    0.07710796f, -0.01183740f, -0.04961392f, -0.04565094f, 0.10939993f, -0.01734502f, 0.03621912f, -0.02163044f, 
    0.03499093f, 0.06270190f, 0.05081402f, 0.09290835f, 0.07877503f, -0.05754612f, -0.15413822f, -0.13727768f, 
    -0.16493657f, -0.07856277f, -0.30953640f, 0.05208394f, 0.02308214f, 0.05962399f, 0.01462953f, -0.03319676f, 
    0.09263284f, 0.04053623f, -0.23850800f, 0.05841885f, -0.15572977f, -0.22779509f, -0.11281032f, -0.14694308f, 
    0.06043793f, -0.13664822f, -0.07492972f, -0.00088859f, -0.17152290f, -0.57895672f, -0.36004803f, 0.03880153f, 
    -0.25762859f, -0.01657309f, 0.01949377f, 0.02190900f, 0.04454640f, 0.09976111f, -0.05108868f, 0.05099988f, 
    -0.05077719f, 0.01401002f, 0.03872125f, -0.12679912f, -0.18951547f, 0.16907139f, -0.11599120f, 0.01629237f, 
    -0.01764159f, -0.04767961f, -0.18510735f, 0.05175448f, 0.09771866f, 0.07054377f, 0.08999418f, 0.04480241f, 
    0.00696493f, 0.17648461f, -0.06877143f, -0.02482450f, -0.10586353f, 0.11680759f, -0.03741090f, 0.02624846f, 
    0.01778448f, 0.05115883f, -0.03879201f, 0.03312192f, -0.72088373f, 0.13198887f, 0.43224868f, -0.47495207f, 
    0.00464847f, -0.24157274f, -0.30435342f, -0.32999048f, -0.13687378f, -0.20452546f, 0.02900906f, 0.03243368f, 
    -0.02944611f, 0.04498791f, 0.07641141f, -0.08179788f, 0.10352587f, 0.03463785f, -0.15114191f, -0.03299572f, 
    0.34440216f, 0.33786714f, -0.02227764f, -0.39445877f, -0.16824734f, 0.09434001f, 0.09485295f, 0.04818368f, 
    -0.07174816f, 0.04783831f, 0.05499046f, -0.01121348f, 0.03327642f, -0.00712625f, 0.05118502f, -0.03379602f, 
    -0.05546150f, 0.02697862f, 0.05326645f, -0.07589164f, 0.28083888f, 0.27484262f, 0.36204875f, -0.31218413f, 
    -0.15505366f, 0.15208003f, 0.15415719f, 0.09553515f, 0.01928854f, 0.05883474f, -0.01562852f, -0.03191105f, 
    -0.00706520f, -0.11544841f, -0.07507776f, -0.09777814f, -0.09620654f, 0.01352137f, 0.09512911f, 0.13804282f, 
    0.26936731f, 0.38368684f, 0.27997690f, 0.29363737f, 0.19710869f, 0.15080942f, -0.02984549f, -0.02463681f, 
    -0.01682092f, -0.06914868f, 0.03402028f, 0.04906372f, 0.03479615f, -0.07349408f, 0.06127464f, -0.01013481f, 
    -0.01079503f, 0.01031081f, -0.11242546f, 0.08018540f, 0.33505580f, -0.05470300f, 0.31271183f, 0.06637904f, 
    -0.10833745f, -0.03041795f, -0.03677278f, 0.02594305f, 0.07930683f, -0.07076976f, 0.11056339f, -0.11832716f, 
    -0.06934386f, -0.14111425f, -0.10823429f, 0.09617647f, 0.03506771f, -0.10933187f, -0.00767190f, -0.01571797f, 
    1.17572880f, 0.37671724f, -0.18145780f, 0.12626038f, -0.40419558f, -0.00759701f, 0.01669044f, -0.08187396f, 
    -0.12436319f, -0.02472441f, 0.03149457f, 0.01916851f, -0.11923908f, 0.00172265f, -0.04919106f, -0.01942312f, 
    -0.09137192f, -0.09460732f, -0.05538070f, 0.00955348f, 0.63538349f, -0.03864270f, -0.17559262f, 0.02505844f, 
    -0.18424615f, -0.19652194f, 0.14592430f, 0.09028941f, -0.32982677f, 0.20312132f, 0.19619462f, -0.17495556f, 
    0.15052132f, -0.05458950f, -0.01569252f, -0.09765866f, 0.09950041f, 0.02850497f, -0.08522002f, 0.06131651f, 
    0.11519617f, 0.00605499f, 0.07518888f, 0.11404241f, 0.16500609f, 0.04193464f, 0.02341988f, 0.09907131f, 
    -0.07439137f, 0.01559047f, 0.07911874f, 0.10883705f, 0.06478425f, -0.03783852f, 0.11163134f, -0.00320301f, 
    0.08907031f, 0.16034161f, 0.07423066f, -0.03798798f, -0.31606326f, 0.07198439f, -0.40012676f, -0.35973975f, 
    -0.62013167f, -0.15392713f, -0.17965241f, -0.01979747f, -0.13272148f, -0.05690393f, -0.05547284f, 0.07105111f, 
    0.02613121f, -0.02422279f, 0.00590450f, -0.07191654f, -0.13410866f, -0.17280987f, -0.34228310f, -0.33158144f, 
    0.31003463f, -0.39441541f, 0.19315958f, 0.09061407f, 0.06218436f, -0.12705949f, 0.02397946f, 0.01059642f, 
    0.06177486f, 0.01844246f, 0.21992216f, -0.11854077f, 0.10423119f, -0.10417620f, -0.19978212f, 0.16156484f, 
    -0.04737103f, -0.13157937f, -0.06587739f, -0.28414276f, 0.55290878f, -0.15940677f, -0.18021536f, 0.00644430f, 
    -0.22334637f, -0.06621983f, 0.10474481f, 0.11248251f, -0.19729830f, 0.05595589f, 0.07042371f, -0.14918306f, 
    0.08408944f, -0.08643638f, -0.03850813f, -0.04687956f, 0.01320822f, -0.03666489f, -0.03629072f, 0.00456483f, 
    -0.81703693f, -0.45998064f, 0.00529256f, -0.08935533f, -0.12779313f, 0.06887516f, 0.04822253f, -0.06409506f, 
    -0.15402862f, -0.16990468f, -0.00160597f, 0.05600380f, -0.17247432f, -0.05782143f, 0.08448652f, 0.08249831f, 
    0.05039727f, -0.18668412f, 0.05631373f, -0.04148731f, -0.01460241f, -0.01620249f, -0.06575488f, -0.12244459f, 
    -0.02356265f, 0.02666039f, -0.12008160f, -0.09841072f, 0.02164246f, 0.09727231f, -0.04188989f, -0.05477325f, 
    0.07927115f, 0.14637819f, 0.09923464f, -0.02204154f, 0.00886598f, -0.00660713f, 0.14665708f, 0.17481171f, 
    0.00380911f, 0.15327927f, -0.24736714f, 0.17924815f, -0.14463015f, 0.02561264f, 0.10461454f, -0.05980126f, 
    0.23184024f, -0.02032654f, -0.03082072f, -0.03325089f, -0.02304642f, -0.03063238f, 0.09978344f, -0.07837963f, 
    0.01201670f, 0.03983833f, 0.06729613f, 0.02518020f, -0.00458921f, -0.00733686f, -0.01276167f, -0.00263987f, 
    -0.01615182f, -0.00117957f, -0.00456156f, -0.01638359f, 0.02337578f, -0.02849435f, 0.01922636f, -0.02903167f, 
    -0.01297432f, 0.12573335f, 0.06970964f, -0.05799949f, -0.06766383f, -0.08269783f, 0.03440617f, -0.09536666f, 
    -0.27839774f, -0.07217648f, -0.13066177f, 0.10674375f, 0.05543140f, 0.06032268f, 0.24949780f, 0.16006002f, 
    0.04961807f, -0.01090197f, -0.06678667f, -0.01582604f, -0.03875206f, 0.03863302f, 0.05240187f, 0.02975349f, 
    0.01848450f, -0.01606638f, -0.01181164f, 0.06641530f, 0.49153870f, -0.29993257f, 0.03870871f, -0.00838512f, 
    0.17297912f, -0.10996848f, -0.05823604f, 0.04404867f, -0.00927014f, -0.07207947f, -0.14129709f, 0.06884825f, 
    0.00296137f, -0.02139788f, -0.06065767f, -0.01820214f, -0.23340613f, -0.02268562f, -0.06474848f, -0.25149810f, 
    0.45033535f, -0.24618950f, -0.18027905f, -0.04593477f, -0.14266078f, 0.00706915f, -0.00624099f, 0.13762727f, 
    0.05177713f, -0.30384022f, 0.09492423f, -0.18023351f, 0.02425554f, -0.00877505f, -0.08020566f, 0.00939320f, 
    0.02318066f, -0.03423319f, 0.03291990f, 0.03600744f, -0.31841534f, 0.09342216f, -0.14802726f, 0.02873167f, 
    0.06066013f, -0.05276864f, -0.09474429f, 0.25504017f, -0.05524131f, 0.02395581f, 0.10136914f, 0.00658565f, 
    0.04728905f, 0.01543586f, -0.02634236f, 0.04060501f, -0.00038609f, 0.06946585f, -0.09534134f, 0.02909815f, 
    -0.76649493f, 0.35441166f, -0.40594769f, -0.15199816f, 0.37982196f, -0.17204587f, 0.19668898f, -0.26862377f, 
    0.12094151f, 0.05127906f, -0.15596561f, 0.03723431f, -0.03716808f, 0.05256076f, -0.03791798f, -0.01243620f, 
    0.10884497f, -0.00485282f, -0.21896055f, 0.21092834f, -0.48250929f, 0.08265669f, -0.23233730f, -0.09182665f, 
    0.28021821f, 0.04001249f, -0.04835471f, -0.20726417f, 0.21549483f, -0.06752136f, -0.02472503f, 0.07260979f, 
    0.08790652f, 0.04633180f, 0.04478298f, 0.01303110f, -0.00353986f, 0.11403348f, -0.11420435f, -0.20645531f, 
    -0.45241463f, -0.02655112f, -0.10462081f, 0.07139976f, -0.01980569f, -0.15265396f, 0.05864700f, 0.18601874f, 
    -0.07189910f, 0.16071495f, 0.02213132f, 0.03197041f, 0.07558589f, -0.05288841f, -0.18606646f, -0.02261886f, 
    0.06763104f, 0.06136215f, -0.00251588f, 0.06214728f, 0.17366746f, 0.05249505f, 0.16064574f, 0.08150224f, 
    0.16841942f, -0.03001725f, -0.01189813f, -0.02091806f, -0.05489813f, 0.02392630f, -0.02520076f, -0.01388157f, 
    0.02482626f, 0.07091419f, 0.02992246f, -0.16140752f, -0.04023433f, 0.03454776f, -0.01931277f, -0.05688423f, 
    -0.04730004f, -0.18896440f, 0.28889707f, 0.20758195f, 0.05826022f, -0.07626209f, -0.03085262f, 0.08038789f, 
    -0.00797541f, -0.02986016f, 0.13569069f, -0.07888141f, 0.00798253f, -0.02929318f, -0.05214041f, 0.14097635f, 
    -0.02213665f, -0.05738281f, -0.03559466f, -0.14416990f, -0.37649432f, -0.17787679f, 0.24980260f, -0.00572753f, 
    -0.11276423f, 0.01094902f, -0.00902463f, -0.01401819f, -0.03096743f, -0.03147582f, 0.12869535f, 0.01344688f, 
    -0.19539835f, 0.02349304f, 0.14964016f, 0.27968150f, -0.07152612f, -0.26100564f, 0.08054628f, -0.12793420f, 
    0.19551858f, 0.10782208f, 0.10974927f, 0.13578507f, 0.05826649f, -0.00807830f, -0.05416657f, -0.04349861f, 
    -0.03052732f, -0.03448715f, -0.00971154f, 0.18438822f, 0.10312914f, 0.04703683f, 0.10213675f, -0.12460725f, 
    -0.07807588f, -0.02269532f, 0.01497660f, -0.06358355f, -0.01312939f, 0.16389632f, -0.06873971f, -0.17812243f, 
    0.02830222f, -0.09593444f, 0.02797499f, -0.06035453f, 0.01791471f, -0.01783385f, -0.06430179f, 0.01747594f, 
    0.05210721f, 0.13748944f, 0.00581969f, -0.00521057f, -0.06946231f, 0.12500319f, 0.15910512f, -0.09264237f, 
    0.46703976f, 0.52920467f, -0.20344909f, -0.27432463f, 0.36461684f, -0.03725522f, 0.08670069f, -0.14402615f, 
    -0.02956614f, -0.00442206f, -0.10504796f, -0.02018161f, 0.02569851f, 0.01923149f, -0.02170381f, -0.03308325f, 
    0.04485253f, 0.11767282f, 0.00539148f, -0.08140785f, -0.25319517f, -0.67993146f, 0.04932876f, -0.29036501f, 
    0.14660925f, -0.03611685f, -0.02070490f, 0.02657873f, -0.13646929f, -0.01524694f, 0.02468395f, 0.11457977f, 
    -0.00421822f, -0.07357731f, 0.02530766f, 0.01276053f, -0.18779519f, -0.13769665f, -0.06739327f, 0.00236009f, 
    0.02113913f, 0.08472470f, -0.04503128f, 0.02001309f, -0.07077011f, -0.05171260f, -0.01811960f, -0.09105042f, 
    0.02545428f, -0.06193434f, 0.06270363f, 0.15884674f, -0.14046198f, 0.05873224f, -0.00158276f, -0.18511610f, 
    0.00103734f, -0.12982635f, 0.12966985f, 0.05472441f, 0.91817909f, 0.17360489f, -0.04528676f, 0.16869497f, 
    -0.11334530f, -0.03650182f, -0.04351544f, 0.00915204f, -0.00473820f, -0.02979239f, -0.03451189f, 0.02989565f, 
    0.02943452f, -0.08236244f, 0.07608926f, 0.19899188f, -0.11131021f, 0.04342771f, 0.23213051f, 0.19616883f, 
    0.14246078f, 0.01971995f, -0.12104406f, -0.01134587f, -0.16275848f, -0.06656849f, -0.01691812f, -0.02428593f, 
    0.12469763f, -0.05801861f, -0.02497032f, 0.06410922f, 0.09487202f, -0.10631838f, 0.01773765f, -0.04470689f, 
    -0.06154648f, -0.07811724f, 0.00260174f, -0.00671579f, 0.07657126f, -0.21910053f, 0.29486614f, -0.22554147f, 
    0.00070021f, 0.12190158f, -0.14337498f, -0.21795318f, 0.03219602f, 0.04830569f, -0.04827902f, -0.02193617f, 
    0.03386565f, 0.03598619f, 0.01012974f, 0.01391688f, 0.04516943f, -0.01147612f, 0.10275345f, 0.03646646f, 
    -0.15580319f, 0.07126536f, -0.07917121f, 0.29757699f, 0.07356005f, -0.00743945f, 0.04965917f, -0.09692471f, 
    0.00609814f, -0.16599426f, 0.02974142f, 0.01681502f, 0.01305561f, 0.01435046f, 0.06039597f, -0.04936584f, 
    0.00224483f, 0.05677390f, -0.25297266f, 0.03818863f, -0.13914475f, 0.27419102f, 0.09181415f, 0.05405508f, 
    -0.09095393f, 0.09806982f, -0.07853229f, -0.00283882f, -0.18890755f, 0.07042057f, 0.02075938f, 0.01552813f, 
    0.04334914f, 0.01934040f, 0.02680455f, -0.08470991f, -0.06106992f, 0.11940715f, -0.23853263f, -0.37670642f, 
    -0.43628830f, -0.60680777f, -0.02820377f, 0.39447230f, -0.30723733f, -0.14228672f, -0.00872143f, -0.00925704f, 
    0.11202957f, -0.00121384f, -0.01881568f, -0.04049199f, -0.04014619f, 0.00888053f, -0.05961006f, -0.01649194f, 
    0.00392660f, 0.00428884f, -0.15896384f, 0.10280620f, -0.20060748f, -0.05290623f, 0.33847776f, 0.12315333f, 
    0.08651347f, 0.02243216f, -0.02534439f, 0.05461841f, -0.08899407f, -0.03276714f, 0.12880196f, 0.05026757f, 
    0.04340974f, -0.11067589f, 0.17758808f, -0.03187993f, 0.03692394f, 0.10526004f, 0.08180904f, -0.08359773f, 
    -0.59142607f, 0.61891168f, 0.33472285f, 0.29234901f, -0.31198415f, -0.05184769f, -0.11873676f, -0.15225677f, 
    -0.16684763f, 0.31706405f, 0.02038983f, -0.01366443f, -0.06028850f, -0.05219808f, -0.03242118f, 0.16887429f, 
    0.03806604f, 0.02469377f, 0.07076393f, 0.05089194f, -0.11781676f, 0.37259719f, 0.14677487f, 0.18449077f, 
    0.18405131f, -0.10435292f, 0.04454096f, -0.08353738f, -0.24389182f, -0.03069546f, 0.08002291f, 0.12885925f, 
    0.17220409f, -0.04208868f, 0.08556516f, -0.06516413f, -0.05134153f, -0.04142195f, 0.01748875f, -0.09584216f, 
    0.04996159f, -0.11315213f, -0.32136625f, -0.04497703f, 0.15211181f, 0.09071327f, -0.01768150f, -0.00308272f, 
    -0.01471165f, 0.08083694f, 0.06169315f, 0.12177268f, -0.02297488f, 0.12649019f, -0.13762417f, 0.01363764f, 
    0.03405410f, 0.10688500f, 0.06177667f, 0.00719490f, -0.65197986f, -0.53612715f, 0.38321173f, 0.02321592f, 
    -0.20694302f, -0.10189286f, -0.08997310f, -0.25020012f, -0.16005388f, -0.07155561f, -0.03630253f, 0.01673925f, 
    0.01373423f, -0.00585489f, -0.06239220f, -0.15464680f, -0.09261064f, 0.10298601f, 0.09482936f, 0.15439272f, 
    0.09219243f, 0.07703671f, 0.43318900f, 0.18359923f, 0.37129286f, 0.06668703f, -0.05063573f, -0.17887947f, 
    0.04584817f, -0.07793990f, 0.00674523f, 0.02312320f, -0.01150027f, -0.12063510f, 0.13868727f, 0.04113850f, 
    0.04264285f, 0.05192548f, -0.09685902f, 0.00086251f, 0.05811576f, 0.18341418f, 0.51765394f, 0.02727081f, 
    0.21372578f, -0.00425589f, 0.00151207f, 0.07961752f, -0.01095315f, -0.03316706f, 0.01789505f, 0.07823790f, 
    0.14857531f, -0.01106020f, 0.07185534f, 0.01305741f, 0.00317111f, -0.06710049f, 0.07733312f, -0.04156541f, 
    -0.11339534f, -0.30102995f, 0.53488874f, 0.15099572f, 0.25701413f, -0.11049899f, -0.00936795f, 0.00693503f, 
    -0.07276635f, -0.11600997f, -0.02864723f, -0.09561461f, -0.06194209f, -0.04865201f, 0.00854819f, 0.03472117f, 
    0.01300887f, -0.03338778f, 0.03467207f, 0.04663758f, -0.27106962f, -0.16189636f, 0.14401904f, -0.04650239f, 
    0.00736793f, 0.21185800f, 0.00339765f, -0.29812175f, -0.22982959f, -0.01219191f, 0.04238232f, -0.00058287f, 
    0.07136978f, -0.02067786f, -0.03957159f, 0.05333537f, 0.01939695f, -0.03911649f, -0.15679811f, -0.05910561f, 
    0.02383150f, -0.18359673f, -0.00305428f, 0.19395927f, -0.24537525f, 0.14588435f, 0.02201115f, 0.05602959f, 
    0.15158127f, -0.11285833f, -0.02976426f, 0.04293585f, -0.06990638f, 0.01865946f, -0.05975594f, -0.01757953f, 
    0.04464863f, 0.05880855f, 0.12837228f, 0.02554724f, -0.10039462f, -0.14834651f, 0.09302934f, -0.13526076f, 
    0.04860825f, 0.04645425f, -0.14795700f, -0.13305835f, 0.01328929f, 0.07833906f, 0.07999759f, -0.04974036f, 
    0.04173692f, 0.01483858f, -0.15919530f, 0.03123975f, -0.10919234f, -0.22272590f, -0.09908703f, -0.01178579f, 
    0.12834151f, -0.04780692f, 0.02975873f, 0.10314666f, 0.10792367f, -0.05476749f, -0.19107665f, -0.14316067f, 
    0.16411728f, -0.25544554f, 0.04758890f, 0.09667796f, 0.01800296f, 0.01240293f, 0.00761883f, -0.01057557f, 
    -0.00455974f, -0.01995413f, 0.01234883f, 0.02409145f, -0.33325541f, -0.31629312f, -0.15602006f, -0.02069918f, 
    -0.15021557f, 0.08746655f, -0.02172954f, -0.05899787f, -0.05319639f, 0.04709022f, 0.00730318f, -0.01860285f, 
    0.01477383f, -0.01854712f, 0.07866411f, 0.25087792f, 0.02072497f, -0.44869226f, 0.42861003f, -0.05384449f, 
    0.05273626f, -0.40130833f, 0.67335862f, 0.14491838f, 0.12941843f, 0.03295365f, -0.11883130f, 0.11845803f, 
    0.31734997f, -0.14410049f, 0.03122013f, 0.10262819f, 0.09671558f, 0.03489568f, 0.06306463f, 0.01528363f, 
    -0.05245627f, 0.00399733f, 0.06441249f, -0.06858576f, -0.10102604f, -0.07371321f, -0.23571722f, 0.13316171f, 
    0.05462498f, -0.06539314f, -0.00789262f, 0.18296406f, -0.19536689f, 0.06525719f, -0.00092492f, -0.04213583f, 
    0.12392122f, 0.00614820f, -0.00205789f, 0.03956723f, -0.00972682f, 0.04328419f, -0.06496927f, 0.01609016f, 
    0.20433229f, 0.35988209f, -0.46473384f, 0.19364941f, 0.07040780f, -0.01058721f, 0.14021450f, -0.10638854f, 
    0.07061305f, 0.19355911f, -0.01647281f, 0.15263592f, -0.23651412f, 0.06637900f, -0.04311070f, -0.02560639f, 
    -0.00357932f, -0.04555881f, -0.08040281f, 0.12195323f, 0.31594217f, -0.03616147f, -0.55212212f, -0.04033794f, 
    -0.15865590f, 0.13061215f, 0.15320085f, -0.03449925f, 0.26330543f, 0.06770527f, -0.02202544f, 0.01227454f, 
    0.02449617f, 0.02226347f, -0.08830123f, 0.05776361f, 0.02165427f, 0.02510531f, -0.12605430f, -0.00290674f, 
    0.23813473f, 0.18109986f, -0.22715816f, 0.02957957f, 0.24827981f, -0.11816988f, 0.11504781f, -0.07441997f, 
    -0.11160559f, -0.01752744f, -0.01291201f, 0.08579194f, 0.11896572f, -0.03291562f, -0.04694751f, -0.03887003f, 
    -0.01055545f, 0.05233007f, -0.09288541f, 0.09608558f, -0.08069353f, -0.07210001f, -0.14114867f, -0.00641030f, 
    0.06749442f, -0.03517610f, -0.06401885f, -0.00357929f, 0.01066148f, 0.11160383f, -0.02802016f, -0.06431442f, 
    0.00262873f, -0.01669250f, -0.08432706f, -0.08673508f, -0.05425131f, 0.03202371f, -0.00626519f, 0.00254261f, 
    0.08581620f, -0.01173330f, 0.06456118f, 0.07997049f, 0.18353699f, -0.00688948f, 0.00736940f, -0.13210168f, 
    0.04171415f, -0.07666937f, 0.00098942f, -0.03370980f, 0.05938396f, -0.11018827f, 0.06852389f, 0.02738671f, 
    0.04475163f, 0.09028772f, -0.06794721f, -0.02604052f, -0.09123660f, -0.37081957f, -0.01697801f, 0.32112691f, 
    0.18482995f, 0.05255640f, -0.01482066f, -0.03680790f, -0.03614571f, -0.07779486f, -0.01044836f, 0.01452291f, 
    0.00457489f, -0.07701206f, -0.03375147f, 0.11446918f, 0.06870738f, -0.05705975f, -0.13962828f, 0.13441078f, 
    -0.04314142f, -0.11739539f, -0.11086207f, -0.10764110f, 0.11519992f, 0.04867268f, -0.04934203f, 0.06965120f, 
    0.11121094f, 0.05047454f, -0.14760423f, -0.18882567f, 0.08176877f, -0.11282648f, -0.03749145f, 0.02535902f, 
    0.00524650f, 0.02801568f, 0.01565169f, -0.03635954f, -0.31485343f, 0.30250782f, -0.12756293f, -0.05360240f, 
    -0.10740270f, -0.10515776f, -0.20861956f, -0.27049032f, -0.12816191f, 0.05927783f, -0.03777732f, -0.02073059f, 
    0.10404812f, -0.03200342f, -0.11149777f, -0.01695657f, 0.06793626f, -0.05764158f, -0.02694143f, 0.05359769f, 
    -0.51383984f, 0.13148373f, -0.56524605f, -0.00409224f, -0.43495712f, -0.18603821f, -0.02421535f, -0.11776701f, 
    0.01230197f, 0.05263673f, 0.07128300f, -0.00494167f, -0.02962215f, 0.06682236f, 0.01855172f, 0.23658891f, 
    0.07653832f, 0.05855387f, 0.00912367f, -0.00515372f, 0.19504857f, -0.06130637f, -0.12992902f, -0.13642591f, 
    0.11411829f, 0.02744013f, 0.05107491f, 0.02629867f, 0.02558463f, 0.02051806f, -0.00026362f, 0.06789155f, 
    0.02153577f, 0.00317970f, -0.00911356f, 0.08582247f, 0.16779226f, -0.03207498f, 0.24205965f, 0.05529380f, 
    0.10051840f, -0.23369083f, 0.04539654f, -0.23864692f, 0.00589618f, 0.03711247f, -0.15509284f, -0.22379808f, 
    -0.03050520f, 0.03722087f, -0.00989599f, -0.22615053f, -0.17845646f, -0.03948633f, 0.09227844f, 0.09624765f, 
    -0.20772986f, -0.35703412f, 0.14295147f, 0.02265718f, -0.58968705f, 0.27361643f, 0.11668600f, -0.46719798f, 
    -0.45454231f, -0.00667161f, 0.02909302f, -0.00397340f, -0.03643934f, 0.10183415f, -0.04870155f, 0.06464219f, 
    -0.07991953f, 0.02985229f, -0.02057544f, 0.21919464f, -0.05015534f, -0.02095503f, 0.29246944f, -0.09352375f, 
    -0.09501120f, -0.25415695f, 0.39757454f, 0.01873381f, 0.26052082f, 0.03112421f, -0.05825710f, 0.05585593f, 
    0.15828408f, -0.14699075f, -0.13453592f, -0.02842932f, -0.16839652f, -0.00086515f, -0.03403895f, 0.03859877f, 
    -0.05005482f, 0.00270690f, 0.03015136f, -0.01818867f, -0.63274026f, -0.13929240f, 0.07196943f, -0.31497037f, 
    -0.13416238f, -0.20637687f, 0.01413388f, -0.15497172f, -0.18932478f, 0.01773050f, -0.00119491f, 0.00414046f, 
    0.01534906f, -0.00725833f, -0.04935303f, -0.00849425f, -0.11914222f, 0.04323666f, -0.04193532f, -0.10671640f, 
    -0.13036495f, -0.66409278f, -0.35123551f, 0.21633910f, -0.47210187f, 0.10948482f, -0.00226446f, 0.01448932f, 
    0.05737016f, -0.16952343f, -0.00419003f, 0.02489502f, 0.01257729f, 0.00948050f, -0.00851900f, -0.02510617f, 
    0.00953271f, -0.00194317f, -0.07977322f, 0.02407568f, -0.66401958f, -0.85791832f, -0.36711377f, 0.12310366f, 
    -0.62367809f, 0.13452351f, 0.12570028f, 0.08748982f, -0.06995520f, -0.04818973f, -0.01593474f, -0.04194756f, 
    -0.01502611f, -0.01785935f, -0.07307593f, -0.07168113f, 0.02564138f, -0.08250064f, 0.06273454f, 0.16737591f, 
    0.06705853f, -0.08972070f, -0.25343990f, -0.06605103f, 0.25163496f, 0.05126823f, 0.03468531f, -0.03104447f, 
    -0.00147235f, 0.11287326f, -0.11433794f, 0.04161689f, 0.01010294f, 0.02371379f, -0.00038926f, 0.06482445f, 
    0.08108543f, 0.16075283f, 0.00424799f, -0.04218536f, 0.42812786f, -0.01476497f, -0.02898979f, -0.00736045f, 
    -0.05645730f, 0.18662931f, 0.08605388f, -0.04049056f, 0.08557446f, 0.06792457f, 0.05089080f, 0.00929469f, 
    0.02109972f, -0.03545433f, 0.03626857f, -0.13066314f, 0.01569632f, -0.08637773f, -0.00752378f, -0.16961166f, 
    -0.35011312f, 0.14149415f, 0.27894506f, 0.39172933f, 0.41868749f, -0.08518842f, 0.01771970f, 0.12132227f, 
    -0.08286016f, -0.14448401f, -0.09019496f, 0.05959726f, 0.08641635f, 0.02717553f, -0.06160752f, 0.00734446f, 
    0.17797010f, -0.03219767f, -0.00535591f, -0.01408420f, -0.64051658f, 0.21966097f, 0.13386427f, 0.17858151f, 
    0.40816829f, -0.05375339f, -0.07740913f, 0.06967628f, -0.15583050f, -0.01665066f, -0.15137112f, 0.01410536f, 
    -0.11569001f, -0.05902491f, 0.02071704f, 0.09904231f, 0.08621670f, 0.03251006f, -0.05750013f, -0.14885923f, 
    0.30683619f, 0.05109551f, -0.14097165f, -0.44276771f, -0.66398418f, 0.01003706f, -0.04930008f, -0.08432198f, 
    -0.05300502f, -0.19921789f, -0.07250900f, -0.01665616f, -0.11739182f, -0.15801904f, -0.12987126f, -0.25278565f, 
    -0.05157412f, -0.09403519f, -0.00105093f, 0.01628942f, 0.08132017f, -0.28271765f, -0.04947771f, 0.11214980f, 
    0.38521013f, -0.17376381f, 0.07120359f, 0.04622986f, 0.16488546f, 0.03579776f, 0.04596891f, 0.07314624f, 
    0.01357130f, -0.04693733f, 0.07401357f, -0.04476525f, 0.04006959f, -0.01894031f, -0.03838003f, -0.10521873f, 
    -1.23831666f, 1.10615766f, -0.08159330f, -0.20925598f, -0.00396873f, 0.17697516f, 0.13107517f, 0.03574032f, 
    -0.03753088f, 0.18604675f, -0.24843988f, 0.00746993f, -0.09260066f, -0.12678269f, 0.05359254f, -0.12144139f, 
    0.10374956f, 0.03215760f, 0.09707260f, -0.08892820f, -0.23036964f, 0.37899217f, 0.03301782f, 0.10126737f, 
    0.24524599f, 0.01115961f, -0.13439079f, 0.04192856f, -0.25972492f, 0.01902441f, -0.06211692f, -0.01946700f, 
    -0.02984204f, -0.07238489f, 0.04162326f, -0.02455644f, -0.03177891f, 0.04188912f, 0.01557919f, 0.00607506f, 
    0.92534995f, 0.16592064f, -0.15505297f, -0.07044904f, 0.18238541f, 0.20246267f, 0.01539940f, 0.20649123f, 
    -0.03621012f, -0.07238541f, -0.32794437f, -0.07647819f, 0.04557704f, 0.24479672f, 0.05623377f, -0.11851700f, 
    0.16157316f, -0.03114703f, 0.00121833f, 0.14497726f, -0.00484452f, -0.22192112f, 0.17478988f, -0.00594648f, 
    0.20911831f, -0.13765804f, -0.01233255f, 0.06853081f, 0.09932144f, 0.08622219f, 0.09362739f, -0.01813706f, 
    -0.05264694f, -0.01636324f, 0.09469657f, -0.06818087f, -0.01163950f, -0.02943029f, -0.01327656f, -0.04367808f, 
    0.03341909f, -0.13290705f, -0.21203116f, -0.06158955f, 0.22556506f, 0.00521905f, -0.02654607f, 0.04608635f, 
    0.06511658f, 0.00855559f, -0.07985338f, -0.02931568f, -0.04202781f, 0.00407960f, -0.06187847f, 0.05672821f, 
    -0.12100361f, 0.03530087f, -0.08622399f, 0.11796118f, -0.18701105f, -0.14704238f, 0.06087793f, -0.03364367f, 
    0.07813749f, 0.02513736f, 0.08897921f, 0.11443809f, 0.05386786f, -0.03364237f, 0.02141883f, -0.04814392f, 
    -0.06582469f, -0.15217751f, -0.02870790f, 0.07137536f, -0.01171187f, 0.08677822f, 0.03605575f, -0.10707951f, 
    -0.08757200f, -0.13843773f, -0.26549909f, -0.07744672f, 0.31630796f, 0.14964743f, 0.01673691f, 0.12952837f, 
    0.05301122f, 0.11371341f, -0.04855840f, 0.04508810f, 0.04247444f, 0.02741454f, -0.01936999f, 0.05287204f, 
    -0.00092666f, 0.10746669f, 0.05700445f, 0.06178333f, -0.40776944f, 0.38385335f, -0.18545884f, 0.14284824f, 
    -0.51749331f, 0.03255504f, 0.02102420f, 0.13977394f, 0.13356496f, 0.06799933f, 0.17308173f, -0.11881234f, 
    0.14566699f, -0.15346564f, -0.03339706f, 0.07072871f, 0.07812122f, 0.06589510f, 0.21643153f, -0.04486350f, 
    -0.40444484f, 0.28340548f, -0.06982619f, 0.02217763f, 0.30594772f, 0.22375315f, -0.00100337f, -0.05947934f, 
    -0.06830222f, -0.00085811f, -0.16196331f, 0.08739851f, -0.06926435f, 0.07208525f, -0.00319492f, -0.00422489f, 
    0.01031562f, -0.01940303f, 0.12743802f, -0.04359851f, 0.08635134f, -0.10133485f, -0.24965936f, -0.08449552f, 
    -0.03811102f, -0.01548000f, -0.02404464f, -0.07747758f, -0.00779761f, -0.08402939f, -0.00199237f, 0.06027817f, 
    -0.06972093f, -0.06367834f, -0.09637265f, 0.12841785f, 0.02480609f, -0.08319329f, -0.01066173f, -0.34304789f, 
    -0.27804330f, 0.05910411f, -0.05804008f, -0.04644430f, 0.02870533f, -0.06971022f, 0.08886185f, 0.00843019f, 
    -0.13496765f, 0.02228237f, 0.01047548f, 0.02299308f, -0.13802819f, -0.09356557f, 0.02212405f, -0.04892191f, 
    -0.04208228f, 0.34046474f, -0.13345627f, -0.01437399f, 0.14256144f, 0.09355509f, -0.06405456f, -0.13816078f, 
    0.25216413f, 0.07684577f, 0.07286589f, 0.02737212f, 0.02129590f, -0.03371653f, -0.02790802f, -0.03558265f, 
    -0.08279677f, -0.12583102f, -0.06874612f, -0.13310976f, -0.06419998f, 0.00291879f, -0.06276965f, 0.00557546f, 
    0.10262487f, 0.34368646f, -0.30046850f, -0.52928442f, -0.08815797f, 0.05511672f, 0.11959793f, -0.38954487f, 
    0.15172574f, -0.39633608f, -0.03691525f, 0.05286674f, -0.20666471f, -0.11791937f, 0.03818101f, 0.07350621f, 
    0.05577086f, 0.03966585f, -0.15009053f, -0.06062633f, -0.71378452f, -0.59781516f, -0.27455699f, -0.04033338f, 
    -0.54604137f, 0.20210688f, -0.18599816f, -0.11686885f, -0.12831831f, -0.26325163f, 0.02175769f, 0.02618393f, 
    0.06153587f, -0.12221540f, -0.01915845f, -0.04997819f, 0.09797885f, -0.07942836f, -0.18138346f, -0.28817669f, 
    -0.21296078f, 0.71901602f, -0.00625144f, -0.24787420f, -0.14806880f, 0.19061348f, 0.03480592f, -0.05238124f, 
    0.09084827f, 0.05064075f, -0.11716158f, -0.09312311f, 0.03436793f, -0.09008428f, -0.00923870f, -0.06792317f, 
    0.00594250f, -0.19825627f, -0.02472070f, -0.13080250f, 0.71929491f, 0.36829919f, -0.30998111f, -0.02645419f, 
    -0.06160755f, 0.13662252f, 0.22651060f, -0.00769570f, -0.05710124f, 0.27626452f, -0.17645861f, -0.16527998f, 
    0.12381405f, -0.14546239f, 0.05334745f, -0.14023088f, -0.04630875f, -0.02683731f, 0.10020063f, 0.13264163f, 
    -0.35758057f, -0.38508978f, -0.34388480f, -0.35667935f, -0.33127341f, 0.24099098f, 0.14294632f, -0.04287366f, 
    -0.09982792f, -0.04485353f, -0.21378461f, -0.06599178f, -0.04809679f, -0.16368654f, -0.14541164f, -0.12610458f, 
    0.10664009f, -0.20442794f, -0.08147100f, -0.14176905f, -0.99842060f, -0.09638254f, -0.11031578f, 0.36603963f, 
    -0.27693474f, 0.12664485f, -0.04320812f, -0.07166561f, -0.21328300f, -0.15109603f, -0.10466686f, 0.09963572f, 
    -0.03548846f, 0.00895084f, -0.00360023f, 0.07899436f, 0.17777734f, 0.21281040f, -0.03698659f, -0.24128626f, 
    -0.98695385f, 0.11881056f, 0.27488920f, 0.15526086f, -0.43926883f, -0.07850806f, -0.03072460f, -0.01260533f, 
    -0.21150619f, -0.12897180f, 0.08713754f, 0.15869220f, -0.09224838f, 0.08255608f, -0.10610566f, 0.00412892f, 
    -0.14281496f, 0.30675644f, 0.04862378f, -0.05627908f, 0.60492420f, 0.18512824f, 0.11668848f, -0.68923354f, 
    -0.08441482f, 0.02101179f, 0.08645915f, 0.18366304f, 0.03497187f, 0.18184042f, -0.09752304f, -0.06864870f, 
    0.15541686f, 0.08186979f, 0.06526899f, -0.04324592f, -0.00796509f, -0.15391089f, 0.14433402f, 0.09657909f, 
    -0.22484438f, 0.24088344f, -0.07992076f, 0.16025582f, 0.07499181f, 0.03034516f, -0.20835997f, -0.23913690f, 
    -0.15689816f, -0.17136315f, -0.17021254f, -0.20259109f, 0.05249374f, 0.10800894f, 0.09742409f, -0.02408998f, 
    0.10408076f, 0.09658186f, 0.00173555f, -0.19244076f, -0.68631577f, 0.07890032f, -0.32632804f, 0.35536563f, 
    0.00132055f, 0.06850303f, -0.11564631f, 0.00353322f, -0.00124524f, 0.03312399f, -0.02885953f, 0.03004939f, 
    0.09984583f, -0.00019113f, -0.05657038f, -0.06970972f, 0.03866713f, -0.11610632f, -0.06873603f, -0.03496720f, 
    -0.11845240f, 0.01643277f, -0.29690391f, -0.00312677f, 0.17985879f, 0.37789422f, -0.03657661f, 0.12192859f, 
    -0.03755350f, -0.16059092f, -0.20712897f, -0.00910350f, 0.07911311f, -0.02837864f, 0.11593405f, -0.02110061f, 
    0.05853007f, -0.21914412f, 0.08870539f, 0.17247093f, 0.13682029f, -0.01851119f, 0.65568805f, -0.34455067f, 
    0.31689718f, -0.30379936f, 0.00960542f, -0.08537301f, -0.00311717f, -0.23479901f, 0.25695750f, -0.01553063f, 
    0.05143302f, -0.00698394f, 0.19456498f, 0.09502072f, -0.12815924f, 0.11283680f, -0.10486060f, -0.17241839f, 
    -0.00041382f, -0.14904378f, -0.34681615f, -0.01419520f, 0.20389938f, 0.14277832f, -0.05814875f, 0.04112024f, 
    0.05732631f, 0.12670648f, -0.07603034f, -0.03200744f, -0.10243933f, -0.02692041f, -0.09884910f, -0.01234865f, 
    -0.03544455f, 0.11918629f, -0.14439720f, -0.00463864f, 0.02674673f, -0.16005051f, -0.29928577f, 0.14891899f, 
    0.37700534f, -0.08167078f, 0.08732900f, 0.08644563f, 0.09260773f, 0.06406114f, -0.12163223f, -0.01111529f, 
    -0.09134817f, -0.10455509f, -0.00158955f, 0.02341670f, 0.08805125f, -0.04433127f, 0.01116412f, -0.08816492f, 
    -0.12930290f, -0.05218761f, 0.09846979f, 0.15126057f, 0.11906333f, -0.20495822f, 0.02316701f, -0.08414987f, 
    -0.09832480f, -0.06743801f, -0.03495928f, 0.05204063f, 0.01897493f, 0.02680954f, 0.01749468f, 0.09679728f, 
    0.05158317f, 0.06877096f, 0.04804126f, 0.08618207f, -0.28501469f, -0.25977805f, 0.09647344f, -0.19630952f, 
    -0.11802164f, 0.01241932f, 0.03914291f, -0.09500661f, 0.04923242f, 0.12759447f, -0.07350235f, -0.04219265f, 
    0.00529810f, 0.03370507f, 0.06750856f, -0.03158499f, 0.06161785f, -0.12052445f, -0.04635098f, 0.06802785f, 
    -0.13525566f, -0.18798392f, -0.05411079f, -0.42412060f, -0.21568096f, -0.03746063f, 0.11395663f, 0.00989043f, 
    0.05069652f, -0.16777796f, 0.01936575f, 0.03406478f, 0.00197250f, 0.09486522f, -0.01636027f, -0.01259253f, 
    0.03119127f, -0.20402502f, -0.07444006f, -0.09698161f, 0.14714445f, -0.47421539f, 0.13897391f, -0.13564108f, 
    0.11748317f, -0.07329118f, 0.06271646f, -0.03022177f, -0.16428012f, -0.41140905f, -0.11442170f, -0.17541751f, 
    -0.07807045f, 0.07886165f, -0.07637785f, -0.04605156f, -0.05938682f, -0.07456362f, -0.03502485f, -0.19213560f, 
    -0.15905882f, 0.03550120f, -0.08356207f, -0.18035038f, -0.14844058f, 0.02957683f, -0.06570778f, -0.10055340f, 
    0.03667092f, 0.01634690f, 0.08100776f, -0.14594713f, 0.01202960f, 0.02971501f, -0.08876956f, 0.06336978f, 
    -0.18295592f, -0.11733718f, -0.17828277f, 0.00053544f, 0.08034144f, 0.15760797f, 0.16331819f, 0.16484730f, 
    0.18704969f, 0.11245385f, 0.31489602f, 0.00498630f, 0.19835781f, 0.10772610f, 0.00109202f, -0.08580897f, 
    -0.03205640f, 0.00484482f, 0.01869570f, 0.00389599f, 0.10466670f, -0.01696572f, 0.22313400f, 0.30860823f, 
    -0.22498293f, -0.64775145f, 0.07280757f, -0.04724703f, 0.13221607f, -0.01413376f, 0.06178576f, 0.06497025f, 
    -0.15311927f, 0.16215713f, -0.17081596f, 0.12746665f, 0.01605291f, -0.00564018f, -0.17572369f, -0.17037970f, 
    -0.03372638f, 0.06485160f, -0.06843504f, 0.22767898f, -0.22757563f, -0.33178613f, 0.14419425f, -0.01987040f, 
    0.07069813f, -0.13036567f, -0.00764080f, -0.13155346f, -0.05233715f, -0.22535999f, -0.00661084f, -0.04009634f, 
    -0.08717919f, 0.05198113f, -0.07087473f, -0.02292220f, -0.01042643f, 0.01232151f, -0.00812104f, -0.13577120f, 
    -0.13918114f, -0.40303412f, 0.21027599f, -0.13940324f, -0.03424208f, -0.17650896f, -0.20768408f, -0.12439378f, 
    0.19577788f, 0.22175959f, 0.01228073f, 0.02727354f, -0.02219833f, -0.24513230f, 0.13348702f, -0.03642905f, 
    -0.04126356f, 0.05327943f, -0.05363564f, 0.06150576f, -0.14869638f, 0.13803074f, 0.01214585f, 0.16861005f, 
    0.17273800f, -0.03755324f, 0.12760869f, 0.08451262f, 0.10620858f, 0.19589217f, 0.01211679f, 0.02066625f, 
    -0.07147468f, -0.07637473f, 0.01326643f, -0.03830311f, -0.06032318f, -0.14451016f, -0.00683290f, -0.31028083f, 
    0.02605017f, 0.07171623f, 0.29645500f, 0.14739394f, -0.01669970f, -0.19296582f, -0.10501850f, -0.03434727f, 
    -0.08446011f, 0.09999969f, -0.03213682f, 0.00301691f, -0.03576946f, 0.01153573f, 0.00348252f, -0.04468350f, 
    0.00256170f, -0.03019254f, -0.09164473f, -0.08871080f, 0.07445344f, 0.10716272f, 0.02646725f, 0.00317338f, 
    0.06237805f, 0.16205090f, 0.20608766f, 0.07270898f, -0.03315881f, 0.13742536f, 0.05508123f, 0.07380460f, 
    0.08373359f, -0.03442876f, 0.09300944f, 0.01246832f, -0.10768539f, -0.08091109f, -0.05450277f, -0.08230478f, 
    0.14226906f, 0.12529732f, 0.18914910f, 0.20522580f, -0.03198587f, -0.07030719f, -0.09101590f, -0.17842101f, 
    -0.08094729f, 0.15884478f, 0.08155195f, 0.08671673f, 0.05077372f, 0.05533872f, 0.03464679f, 0.03743654f, 
    -0.05373469f, -0.01788910f, -0.06287672f, -0.07295419f, -0.11428560f, 0.33448878f, -0.08404928f, -0.04877432f, 
    -0.15036891f, 0.07755493f, 0.06317983f, 0.04981759f, 0.09658753f, -0.02471724f, 0.10036398f, 0.02720783f, 
    -0.05717931f, 0.03206116f, 0.00490176f, -0.16454108f, 0.25860012f, 0.05249284f, -0.10052663f, -0.09017828f, 
    0.24787481f, -0.13308260f, 0.26018116f, 0.12408911f, 0.02625316f, -0.23451321f, -0.12130108f, -0.13556044f, 
    -0.11942407f, 0.04698550f, 0.04553590f, -0.04795450f, 0.01728926f, -0.03354598f, 0.07716405f, 0.03032202f, 
    0.01486181f, 0.07183184f, -0.09921467f, -0.06483302f, -0.09834873f, 0.02784752f, 0.15406771f, 0.07822891f, 
    0.03784954f, -0.11752819f, 0.07627068f, -0.14179166f, 0.10783567f, 0.00820765f, -0.07529861f, -0.19007955f, 
    -0.05627751f, 0.01787378f, -0.01022995f, -0.08019495f, -0.12238310f, -0.06697675f, -0.09150829f, -0.07941204f, 
    -0.07393564f, -0.14283854f, 0.35337088f, -0.18826221f, 0.03578388f, -0.17044556f, -0.14574945f, -0.01800565f, 
    -0.05936322f, -0.26317987f, 0.06218106f, -0.07209550f, 0.06096484f, -0.07500824f, -0.02397276f, 0.01200174f, 
    -0.08440093f, -0.08236092f, -0.11962830f, -0.10093780f, -0.03053387f, 0.16008395f, 0.11108544f, 0.33687291f, 
    -0.00556172f, -0.08997612f, -0.06143525f, -0.06182399f, -0.25192043f, 0.01421337f, -0.02797118f, 0.01084330f, 
    -0.00779698f, 0.04351102f, 0.00705664f, -0.03463325f, 0.02985136f, -0.15307176f, -0.16111717f, -0.00042181f, 
    -0.18512230f, -0.11448696f, 0.13683832f, -0.09652267f, 0.03630374f, -0.01625488f, -0.02304119f, -0.07140115f, 
    0.03149983f, 0.06112206f, -0.12519555f, -0.06976362f, -0.11834378f, 0.07075582f, -0.04285879f, 0.04673646f, 
    -0.15166017f, -0.09276605f, -0.09939443f, -0.04950193f, 0.00983022f, -0.00049207f, -0.08788488f, -0.05457418f, 
    -0.01296351f, 0.05675058f, 0.05109446f, -0.00804602f, 0.01638019f, 0.00837499f, 0.13888581f, 0.07480121f, 
    -0.05043295f, -0.00824581f, 0.06707212f, 0.08468512f, -0.12664025f, -0.12636344f, 0.02091973f, 0.03712334f, 
    -0.10170336f, -0.44653317f, 0.01936716f, -0.33510715f, -0.10425513f, 0.03472457f, 0.02474439f, 0.05702065f, 
    -0.08023722f, 0.10998578f, -0.05763142f, -0.04901500f, -0.02155953f, -0.05295835f, -0.08486819f, -0.14207594f, 
    -0.08460197f, 0.03551204f, 0.01711511f, 0.00571459f, 0.14294626f, -0.74590755f, 0.10925677f, -0.00214486f, 
    -0.00827097f, 0.15461847f, -0.02722287f, 0.02403682f, 0.05094454f, 0.11163264f, -0.05609584f, 0.03529021f, 
    0.00799390f, -0.08542910f, -0.14096920f, -0.14451270f, -0.03886570f, 0.14617158f, 0.02245817f, 0.20732814f, 
    0.04675301f, 0.01891483f, 0.00908467f, -0.04554805f, -0.05238291f, 0.10886668f, -0.00548886f, 0.04846061f, 
    -0.00700370f, 0.06547771f, 0.09015422f, 0.02008625f, -0.06581604f, -0.00710089f, -0.06850655f, 0.18477534f, 
    0.00810281f, -0.02851896f, -0.01439485f, 0.02895269f, 0.26025623f, -0.11295256f, 0.04730987f, -0.08712994f, 
    0.14308757f, 0.21591288f, 0.09089690f, 0.11746386f, -0.00871085f, -0.16400644f, 0.00155607f, 0.02503666f, 
    -0.08477758f, -0.13813342f, 0.06141829f, -0.02292490f, -0.17752445f, -0.31794742f, -0.14350943f, -0.17255554f, 
    0.28260037f, -0.56745392f, -0.01724842f, -0.15081449f, 0.24218760f, 0.00914460f, 0.01140009f, 0.19080788f, 
    0.17749503f, -0.02591785f, 0.01382076f, 0.04507203f, 0.06680867f, -0.03188770f, 0.04919231f, 0.05688007f, 
    0.20753093f, -0.11705318f, -0.05372572f, 0.07565004f, 0.28010213f, -0.04753558f, -0.47385699f, 0.28139424f, 
    -0.25540870f, 0.13372727f, -0.04174088f, 0.02536921f, 0.00333739f, 0.01602694f, 0.14636005f, -0.05635070f, 
    0.01600887f, -0.00989979f, 0.04592048f, 0.03094756f, 0.11565550f, 0.28133282f, -0.00243756f, 0.28297335f, 
    0.03169640f, -0.03807017f, -0.02513467f, -0.02133609f, -0.08629837f, 0.19217061f, 0.00010595f, 0.13696837f, 
    -0.11425344f, 0.01601454f, -0.04343065f, 0.08456652f, 0.25346830f, -0.20182055f, -0.01223257f, 0.15417482f, 
    -0.09733468f, -0.05183087f, -0.20004672f, -0.03707745f, -0.09423589f, 0.27739853f, -0.05714602f, -0.45106405f, 
    -0.31742480f, 0.14452013f, 0.04485808f, -0.03744989f, 0.11862453f, 0.04774910f, 0.07083131f, 0.07980403f, 
    -0.01715703f, 0.10984081f, -0.12683135f, -0.13781388f, 0.02891023f, -0.15623723f, -0.12614857f, 0.02191201f, 
    0.26013386f, -0.03733612f, 0.05264048f, 0.05375369f, -0.00554977f, -0.01957680f, -0.02658374f, -0.00347027f, 
    0.00499066f, 0.20618236f, 0.16231033f, -0.02125503f, -0.09120453f, -0.17282097f, -0.13400145f, 0.13319010f, 
    0.06842894f, 0.02434790f, -0.05031582f, -0.06449156f, 0.07070974f, -0.02047390f, -0.35500306f, 0.51679265f, 
    0.25499973f, -0.05432197f, 0.08354910f, -0.17252007f, 0.03087623f, -0.02705157f, 0.05358846f, -0.05275629f, 
    0.04376386f, 0.05104571f, 0.03974075f, -0.06498615f, 0.10205509f, -0.14068715f, -0.04159439f, -0.13704577f, 
    0.09008478f, 0.19195202f, 0.34859121f, 0.24680263f, 0.28616071f, -0.22928789f, -0.08025758f, -0.00826911f, 
    0.04273210f, 0.19216679f, -0.02544986f, -0.01655974f, 0.03927380f, -0.01087164f, 0.03724672f, 0.01851068f, 
    -0.04401046f, -0.12590763f, -0.07635240f, -0.22343884f, -0.03773368f, 0.06720109f, 0.23698728f, 0.04386195f, 
    0.15293632f, -0.12362575f, 0.14761959f, -0.04902856f, 0.01212228f, 0.05713205f, 0.03253916f, -0.02438164f, 
    -0.00219557f, 0.02195251f, -0.01948050f, 0.11042920f, 0.16626520f, -0.06419501f, -0.03198255f, 0.25792119f, 
    -0.24874458f, -0.07428655f, 0.16963243f, -0.04586895f, -0.19565609f, 0.16170652f, -0.08402766f, 0.13727240f, 
    0.01823315f, -0.14391935f, 0.07968954f, -0.04672492f, -0.02360448f, 0.10684353f, 0.08102566f, 0.04676272f, 
    0.01804539f, -0.06242465f, -0.20849672f, -0.23319972f, -0.25471228f, 0.23580346f, -0.49995869f, -0.27123332f, 
    0.05500390f, 0.01231121f, -0.03906487f, -0.01076799f, -0.14222787f, 0.09550165f, -0.07527152f, 0.01803502f, 
    -0.05735616f, -0.01007933f, 0.06614134f, -0.09646928f, -0.08213161f, 0.15095189f, -0.03224981f, 0.02075624f, 
    -0.27062264f, 0.00345125f, 0.05614736f, -0.49664575f, 0.20499791f, -0.06963105f, 0.02763275f, -0.11847720f, 
    0.01463222f, -0.05346080f, 0.11337543f, -0.05976910f, 0.14123924f, -0.19836627f, -0.00962863f, -0.13241597f, 
    -0.16456777f, 0.04337998f, 0.15504703f, -0.11800097f, -0.10774736f, -0.14622453f, -0.00291257f, -0.23033823f, 
    -0.15937558f, 0.11608929f, -0.12008882f, -0.11308131f, 0.13421951f, 0.20506379f, -0.00602777f, 0.17001435f, 
    -0.01329033f, -0.01834055f, -0.04886150f, 0.11228261f, 0.02002266f, 0.04232277f, 0.01381969f, 0.20691156f, 
    -0.13485864f, -0.23983264f, -0.11437727f, 0.16069652f, 0.12836619f, 0.10145539f, -0.29415891f, -0.05230270f, 
    -0.02234101f, 0.14645855f, 0.02398729f, 0.06765738f, 0.01575277f, 0.07065766f, -0.02354083f, 0.16443954f, 
    0.07734904f, 0.07263969f, -0.02448384f, 0.13078013f, 0.23260637f, 0.05754328f, 0.16624445f, 0.26826271f, 
    -0.13804908f, 0.08015191f, -0.06567248f, -0.07416704f, 0.12413945f, 0.19505998f, 0.06940713f, 0.10097187f, 
    0.03866885f, -0.00597022f, -0.02652180f, -0.01241537f, 0.02205250f, 0.00361554f, -0.30661362f, -0.23735601f, 
    -0.10336007f, -0.02465249f, -0.07639360f, -0.14240877f, -0.37160370f, 0.07691253f, -0.08905258f, -0.00813711f, 
    -0.01938867f, -0.06262673f, -0.09964522f, -0.02296703f, -0.31924126f, 0.01682011f, 0.21859516f, -0.02118299f, 
    -0.09581855f, 0.00474993f, 0.09057669f, 0.04396149f, -0.10544871f, -0.16183065f, -0.27229831f, -0.13359906f, 
    -0.03716604f, 0.11764129f, 0.00383515f, -0.07765179f, 0.09387393f, 0.10190013f, -0.01977326f, 0.19211358f, 
    -0.00716689f, 0.03118813f, -0.01311477f, -0.02395569f, -0.03862475f, 0.08793269f, 0.01790459f, 0.12971225f, 
    -0.93096483f, 0.69498998f, -0.70219171f, 0.10888387f, -0.16435295f, 0.11181860f, -0.21089289f, 0.02076853f, 
    0.09674652f, 0.07215729f, 0.11000082f, -0.07982626f, 0.03283320f, 0.14145090f, -0.06084120f, -0.05163760f, 
    -0.08547684f, 0.18449222f, -0.11234998f, -0.07708855f, 0.07268221f, 0.03481045f, 0.06140671f, 0.02567144f, 
    -0.00222504f, -0.02098740f, 0.06836156f, 0.17487112f, -0.03537005f, -0.17914809f, -0.05898316f, 0.00081500f, 
    -0.03942326f, -0.09370119f, 0.02288308f, 0.03799405f, 0.10647503f, 0.08890162f, -0.17215416f, 0.12280429f, 
    0.02620034f, 0.17038561f, 0.22085944f, -0.17319019f, 0.07154176f, 0.14440307f, 0.03068400f, 0.09240438f, 
    -0.20782952f, -0.13483788f, 0.06634419f, 0.02457275f, 0.06480710f, 0.05899632f, 0.01673253f, 0.06443705f, 
    -0.05105738f, -0.13389845f, 0.04333378f, 0.00540025f, 0.00070884f, 0.04331895f, -0.06184409f, 0.00484671f, 
    0.12505612f, -0.04066807f, -0.02553854f, 0.01478793f, -0.02975595f, -0.07649095f, -0.08397944f, -0.16487725f, 
    -0.06862853f, -0.17086902f, 0.01820933f, 0.04338338f, 0.10235380f, 0.15270695f, -0.13290010f, 0.07724933f, 
    0.00931397f, -0.01149329f, 0.17344566f, -0.16596463f, -0.18197422f, -0.01057145f, -0.00222203f, 0.13675010f, 
    -0.03338561f, -0.04020596f, 0.08441560f, -0.04205219f, -0.04830717f, -0.07077339f, -0.01569721f, -0.00160713f, 
    0.07431721f, 0.03065560f, 0.03712554f, 0.07181942f, 0.19168188f, 0.23533645f, -0.40990227f, -0.30913770f, 
    0.33737859f, 0.02369025f, -0.01664528f, -0.11693780f, -0.07604074f, 0.00377356f, 0.18954743f, -0.03715598f, 
    0.01861816f, 0.07495908f, 0.06068745f, -0.07371724f, -0.07527022f, 0.14314301f, 0.11082091f, 0.28423351f, 
    -0.52296448f, 0.05175288f, -0.05260023f, -0.54088473f, -0.22946778f, 0.05256779f, 0.08340917f, -0.05575171f, 
    -0.09496439f, 0.21684223f, 0.01024581f, 0.14920992f, -0.15107754f, -0.09185960f, -0.07720797f, -0.03102466f, 
    -0.09007762f, 0.02725555f, 0.00824592f, 0.08719920f, 0.28123313f, -0.04754464f, 0.14822303f, -0.01205718f, 
    -0.11835784f, 0.05641042f, 0.05288109f, -0.10230388f, -0.05407364f, 0.16678244f, 0.06383767f, 0.12257424f, 
    0.02100743f, 0.13025407f, 0.08686502f, 0.04795228f, 0.08314438f, -0.09462585f, 0.12322601f, 0.33794770f, 
    0.72500336f, -0.29594460f, 0.19198026f, 0.24055751f, -0.23085587f, 0.19414254f, 0.04168497f, 0.03352327f, 
    -0.07545251f, 0.00648141f, 0.15623108f, -0.08454141f, 0.11463787f, 0.00295689f, 0.03081448f, -0.07065774f, 
    -0.02833728f, 0.00636025f, 0.25670719f, -0.27755383f, 0.09424359f, -0.12037512f, 0.45942262f, 0.10321108f, 
    -0.44243297f, 0.03640068f, -0.08657297f, 0.24047598f, -0.03846900f, -0.10058554f, 0.03895854f, -0.02322268f, 
    0.03415218f, 0.00386669f, 0.07404204f, -0.02221645f, -0.01539900f, -0.00526530f, -0.01637790f, 0.18113843f, 
    0.32872865f, -0.42133862f, -0.09039294f, 0.12900025f, -0.20689420f, 0.31125453f, -0.25957125f, -0.07168981f, 
    0.16974401f, 0.13489081f, 0.05338365f, 0.03423368f, -0.01438258f, -0.00995611f, 0.13423426f, -0.02268428f, 
    0.12924138f, -0.03043910f, -0.07412779f, 0.18120216f, -0.08240050f, -0.17372420f, -0.17204104f, 0.05809719f, 
    0.08927490f, 0.04201753f, -0.06205323f, -0.03345790f, -0.00537356f, -0.00854246f, -0.10893042f, -0.05273178f, 
    -0.03961827f, 0.11787330f, 0.11557910f, 0.05149852f, 0.08981727f, 0.04100173f, -0.01099479f, 0.07859002f, 
    0.05681359f, -0.05240063f, -0.13994291f, 0.07945859f, -0.00825682f, 0.06433462f, -0.08724839f, -0.00955919f, 
    -0.04642234f, -0.02986997f, -0.11963987f, 0.06236311f, -0.22392915f, 0.01194844f, 0.16437285f, -0.05173761f, 
    -0.04561678f, 0.07657367f, 0.01780352f, 0.13508287f, -0.86908746f, 0.63475782f, -0.16543071f, -0.24620473f, 
    0.05832836f, -0.14603062f, -0.13510765f, 0.02080848f, 0.01580037f, -0.10860192f, -0.14154510f, -0.11148541f, 
    -0.13694519f, -0.03275630f, -0.12475421f, -0.34998253f, -0.16195054f, -0.04709746f, -0.11546510f, -0.39035302f, 
    -0.06868850f, -0.10600417f, -0.20975937f, -0.01527810f, 0.08586353f, 0.06037754f, 0.04226382f, -0.10555396f, 
    -0.00151061f, -0.02097442f, 0.14963502f, -0.03800695f, -0.00471434f, 0.15699857f, 0.07083056f, -0.04069351f, 
    0.09472460f, 0.12720247f, 0.05419194f, 0.00270938f, 0.10223164f, -0.17151609f, 0.01354739f, -0.06011232f, 
    0.10833909f, -0.04974361f, 0.12459632f, 0.21170577f, -0.19380912f, 0.14531887f, 0.05334436f, -0.11293058f, 
    -0.13089871f, 0.01992355f, -0.00430597f, 0.01542250f, 0.01206677f, -0.03991738f, 0.13793816f, 0.20529221f, 
    0.21908568f, -0.70548415f, 0.19548754f, 0.35507134f, -0.13904072f, 0.12109853f, 0.11076413f, -0.18294904f, 
    -0.01619783f, 0.05163790f, 0.12975384f, -0.00304227f, 0.05242371f, -0.05101920f, 0.13707951f, -0.18618712f, 
    -0.08124732f, -0.02159763f, 0.26643124f, -0.09743477f, -0.40552363f, 0.41845399f, 0.05539784f, 0.34951824f, 
    -0.09476291f, 0.01596783f, -0.12472338f, -0.05261895f, 0.12843031f, -0.03596095f, 0.01475457f, -0.00936688f, 
    -0.09183578f, 0.00192405f, 0.03818999f, -0.18015786f, -0.15387830f, 0.08746704f, -0.12299927f, -0.40033576f, 
    0.36903390f, 0.00908735f, -0.33018032f, -0.14571047f, 0.19326203f, 0.05138567f, 0.11065470f, 0.11548264f, 
    -0.10380417f, -0.01794236f, 0.11719380f, -0.29082155f, -0.02637095f, 0.06993181f, -0.08541276f, 0.13555934f, 
    -0.04832051f, 0.13070166f, -0.01812549f, -0.15308145f, 0.10231583f, 0.12638786f, -0.31758916f, -0.52563554f, 
    0.31276450f, -0.00592207f, 0.07176037f, -0.00454924f, -0.04360427f, -0.08889671f, 0.07408914f, -0.08046409f, 
    -0.08637055f, -0.00352795f, 0.02215915f, -0.09224146f, 0.08800232f, -0.04555203f, 0.03564817f, -0.22196727f, 
    -0.41193628f, 0.15857041f, -0.31131896f, -0.28029650f, 0.03556229f, 0.05450182f, 0.08573386f, -0.02344150f, 
    -0.15437564f, -0.08315092f, 0.20007607f, 0.00689961f, -0.02813437f, 0.17158575f, 0.01266783f, -0.06612986f, 
    0.00935226f, 0.16073282f, -0.03615094f, -0.07952202f, -0.67471421f, -0.34698966f, -0.27994442f, 0.37653539f, 
    -0.35681653f, 0.28764114f, -0.11243410f, 0.03701444f, -0.05396549f, 0.34908879f, -0.03762386f, 0.09378690f, 
    -0.03634566f, -0.04472567f, 0.05175316f, 0.00805617f, -0.15497109f, 0.17773740f, -0.14242299f, -0.05709475f, 
    0.04142891f, -0.03249201f, 0.33300930f, -0.13474049f, -0.19440639f, 0.26425388f, 0.07160027f, 0.10673851f, 
    -0.02142208f, -0.04959854f, 0.02702256f, -0.03134140f, 0.02614452f, 0.01252706f, 0.04343738f, -0.01929577f, 
    0.00618557f, -0.10411006f, 0.19980854f, 0.21866654f, 0.16953291f, 0.02163648f, 0.18175678f, 0.24183546f, 
    -0.21993002f, 0.04722488f, -0.19429894f, -0.03750119f, 0.14663489f, 0.00896806f, 0.09639598f, 0.03983880f, 
    0.02172623f, 0.05544334f, -0.03734964f, -0.01895691f, -0.03855118f, -0.15863128f, -0.16867588f, -0.16212325f, 
    -0.52468139f, -0.52022320f, -0.83584225f, -0.40579903f, 0.06526420f, -0.05923227f, -0.10794108f, -0.20110890f, 
    -0.13829871f, -0.10272387f, 0.00269476f, 0.01121831f, -0.03156756f, 0.02276943f, -0.04100480f, 0.00789454f, 
    -0.08182167f, 0.04436345f, 0.19802213f, -0.06370720f, -0.07298701f, 0.18482357f, 0.15818809f, -0.03942120f, 
    0.21804492f, -0.02078794f, -0.07696811f, -0.09975425f, -0.02193666f, 0.02093831f, 0.06814717f, 0.21816367f, 
    0.04227401f, 0.11787585f, 0.02046986f, -0.00856512f, -0.02806950f, 0.08516438f, -0.03208154f, 0.09636819f, 
    -0.08426091f, 0.26336864f, -0.15781479f, -0.16909154f, 0.07395578f, 0.10224078f, 0.06252185f, 0.19397439f, 
    0.09998327f, -0.14693098f, 0.10125667f, -0.04305984f, 0.20096742f, 0.08704805f, 0.08942977f, 0.04219121f, 
    -0.00239034f, 0.14360897f, 0.05743473f, -0.08996668f, -0.15064690f, 0.61549395f, -0.18978739f, -0.16670917f, 
    0.21442179f, -0.11540923f, 0.04241142f, -0.14805265f, 0.20428017f, 0.08652713f, 0.10597578f, 0.05023716f, 
    0.07248327f, -0.04063275f, 0.05208500f, 0.10594072f, -0.07954462f, 0.06966474f, -0.00615287f, -0.03372797f, 
    0.09449858f, 0.22074783f, -0.10378376f, 0.10624908f, 0.08032415f, -0.04207242f, -0.00264104f, -0.02746565f, 
    -0.01464492f, 0.17172156f, -0.08388571f, 0.03038402f, 0.12896453f, -0.07426986f, 0.05171826f, -0.20131378f, 
    0.10365219f, -0.18710363f, 0.03751858f, 0.03398188f, -0.61052364f, -0.56428653f, -0.99906886f, -0.34288731f, 
    0.07330200f, -0.18236016f, 0.12721093f, 0.14165322f, -0.05324045f, -0.41841638f, -0.02978802f, -0.00093386f, 
    0.01390855f, 0.07207349f, 0.03365258f, 0.02427656f, -0.01539032f, 0.04269925f, 0.15105669f, 0.02035043f, 
    -0.00931727f, -0.05434310f, 0.06827237f, -0.01622257f, 0.10320148f, 0.00017207f, 0.10458185f, -0.15715465f, 
    -0.02920978f, 0.07370907f, -0.10327358f, 0.10199849f, 0.08101393f, 0.12154761f, -0.21018814f, 0.04618909f, 
    0.07121745f, -0.01794588f, 0.02486148f, 0.12275596f, -0.39931491f, 0.67586362f, 0.08153501f, -0.05292755f, 
    0.23841214f, -0.16602640f, 0.03894952f, -0.16003159f, 0.08919952f, 0.12468608f, 0.14564843f, 0.06882644f, 
    0.08021077f, 0.04453755f, 0.02544974f, 0.06417941f, -0.02370533f, -0.01306620f, 0.00817115f, -0.03814851f, 
    -0.70163649f, -0.27989632f, 0.29565820f, -0.05736626f, 0.43429667f, -0.24726757f, -0.00428942f, 0.02831665f, 
    -0.12542741f, 0.45073727f, -0.00184196f, 0.08026136f, 0.16762391f, 0.05912946f, 0.10299017f, -0.02797578f, 
    0.03010113f, 0.00547749f, 0.05227594f, 0.02977402f, 0.09189863f, -0.33905274f, -0.40567225f, -0.06541358f, 
    0.19381830f, -0.10022130f, 0.08029397f, 0.10437428f, -0.00965817f, -0.32468307f, 0.04132955f, -0.02558815f, 
    -0.11461832f, -0.00320795f, 0.05555690f, -0.02090853f, 0.02564096f, 0.13010174f, 0.14534111f, -0.09001281f, 
    -0.64431727f, -0.81420177f, -0.61520213f, 0.16360292f, -0.35533690f, 0.03674028f, 0.03322636f, -0.17996992f, 
    -0.05007719f, -0.26078591f, -0.00730238f, -0.02211928f, -0.04369280f, -0.04228792f, 0.00349267f, -0.01964155f, 
    0.04769762f, 0.09332702f, 0.06593633f, 0.07121483f, 0.04405046f, -0.14474495f, -0.11266781f, 0.01023186f, 
    0.05622740f, 0.01892144f, -0.12497819f, -0.03388758f, -0.07719681f, -0.11589631f, -0.06578837f, -0.04411251f, 
    -0.25546411f, -0.02346613f, 0.04801032f, -0.07215136f, -0.10086289f, 0.02230779f, -0.07738494f, -0.12724186f, 
    -0.56824291f, 0.19393402f, 0.29083830f, -0.06276064f, -0.22092889f, -0.25752002f, -0.15608317f, -0.31965420f, 
    -0.07433487f, -0.05847257f, -0.18819188f, 0.04677120f, -0.00599787f, -0.01343318f, 0.04327377f, 0.00751702f, 
    -0.05783203f, 0.02682713f, -0.02384284f, -0.11107063f, -0.47835749f, -0.50947714f, -0.06975448f, 0.31449026f, 
    -0.18007214f, 0.00192609f, 0.05798017f, 0.08759104f, 0.00937470f, -0.11215578f, 0.04916670f, -0.06838071f, 
    -0.00803632f, 0.08193251f, -0.00571919f, 0.21488708f, 0.15017568f, 0.11425027f, -0.16447909f, 0.07056754f, 
    -0.58501267f, 0.51318729f, 0.40282762f, 0.12939316f, 0.22156093f, 0.00764819f, -0.13945998f, -0.06371243f, 
    -0.10694449f, -0.00927880f, 0.02052631f, 0.17675404f, 0.05876279f, 0.16391136f, -0.02842582f, -0.01116987f, 
    -0.00837825f, 0.01780444f, -0.09679694f, 0.03143846f, -0.08240665f, 0.20559409f, -0.15145542f, 0.12324960f, 
    0.11557358f, -0.07744432f, -0.00350767f, 0.00207576f, 0.15749036f, 0.05335825f, -0.02055881f, 0.05003929f, 
    -0.07858463f, 0.02837221f, 0.06977897f, 0.03236293f, 0.02942753f, -0.05241287f, 0.08639033f, -0.06218041f, 
    -0.14810887f, -0.01215008f, -0.46240216f, 0.10907545f, -0.14388932f, -0.16743861f, -0.03094551f, 0.07628955f, 
    0.04421913f, -0.00499151f, 0.02819013f, -0.06021366f, 0.10812171f, -0.04748534f, -0.03359840f, 0.01212592f, 
    0.01183862f, 0.06082804f, 0.23123313f, -0.07326084f, -1.15267217f, -1.09079683f, -0.42043504f, -0.10950154f, 
    0.36729953f, -0.18223222f, -0.01085754f, -0.11140973f, -0.19535291f, -0.22985065f, 0.04261946f, -0.06436422f, 
    -0.00585385f, -0.07677983f, 0.02106751f, 0.00667697f, 0.03621500f, -0.01457675f, 0.24782273f, 0.04602207f, 
    -0.21710567f, 0.27939761f, -0.11906995f, 0.09523660f, -0.01849173f, -0.20312797f, 0.04012614f, -0.23119093f, 
    -0.03176775f, 0.37434536f, -0.08469248f, 0.01075766f, 0.09773158f, -0.05292041f, 0.12215973f, -0.06554502f, 
    0.03503274f, -0.10383721f, 0.13848568f, -0.17990391f, 0.14661522f, 0.04082624f, -0.05843729f, -0.05280318f, 
    0.00539912f, -0.03977152f, -0.03596119f, 0.01154343f, -0.02955032f, 0.13413827f, -0.00065730f, -0.13049938f, 
    -0.17877361f, -0.16635637f, -0.19034770f, -0.02788976f, -0.01590324f, -0.08918019f, -0.04739963f, 0.01783495f, 
    -0.10376213f, 0.07021008f, 0.01537397f, -0.07391261f, 0.09898193f, -0.03306428f, 0.03297370f, -0.07156832f, 
    -0.07255817f, 0.10031745f, -0.17507568f, 0.17571117f, 0.06763818f, 0.15631922f, -0.02861878f, 0.01834291f, 
    0.03027069f, 0.01304779f, 0.03099811f, 0.08176029f, 0.03399453f, -0.11700185f, 0.35903481f, -0.14618024f, 
    0.10973471f, -0.05145256f, 0.00874117f, -0.06827976f, 0.03136245f, 0.08469885f, -0.02923269f, 0.02951592f, 
    0.14841500f, 0.21900636f, -0.02483699f, -0.00810583f, 0.13159767f, 0.03432224f, 0.02808764f, 0.10194737f, 
    0.03351176f, 0.00815797f, 0.07406046f, 0.01098466f, -0.01322844f, 0.01464012f, 0.02391967f, -0.05561931f, 
    -0.01296448f, 0.07951429f, -0.07472789f, -0.03936449f, 0.06477955f, 0.09091941f, -0.02248959f, -0.00300414f, 
    0.00580572f, -0.06974237f, -0.05267659f, 0.00813198f, 0.17168097f, 0.08711465f, -0.02243736f, 0.00150599f, 
    0.06122570f, 0.16166833f, 0.03705927f, 0.13007346f, 0.19849832f, 0.07699153f, 0.01196321f, 0.07374389f, 
    -0.03410151f, -0.05709829f, 0.13159175f, -0.02260640f, -0.01831869f, 0.10238031f, -0.17657305f, -0.04098649f, 
    -0.19655317f, -0.00381168f, -0.39169690f, -0.33580664f, -0.05727788f, -0.01957796f, 0.11591759f, 0.20274183f, 
    -0.01751008f, 0.05555802f, -0.03796741f, -0.08155546f, 0.00401073f, 0.03907405f, 0.02502106f, 0.04736537f, 
    0.03030120f, 0.00207812f, 0.14979488f, 0.09023091f, -0.37991452f, 0.08042901f, 0.02192572f, -0.32686943f, 
    0.09734330f, -0.05261517f, 0.06004626f, 0.05731247f, -0.04581402f, 0.04271252f, -0.01182847f, -0.03511651f, 
    0.05808235f, 0.02062812f, -0.05434969f, 0.05699427f, 0.01387677f, -0.02547874f, 0.05040088f, -0.05372592f, 
    0.21168347f, 0.05857695f, 0.21655251f, 0.06191035f, -0.14300492f, 0.07341272f, -0.01826479f, 0.07761836f, 
    0.00952631f, -0.14896208f, -0.02223956f, 0.04224631f, -0.00579769f, -0.17095551f, -0.01317913f, 0.06771921f, 
    -0.28914833f, 0.02452185f, -0.25543007f, -0.02271922f, -0.05969013f, 0.00990452f, 0.10882924f, -0.10305009f, 
    -0.15098485f, 0.03323491f, 0.02703844f, 0.02451020f, -0.04899905f, -0.08257940f, 0.01705432f, -0.05243717f, 
    0.05849259f, -0.00069562f, 0.05751679f, 0.04845120f, 0.12503093f, 0.00590318f, -0.30600512f, 0.06862861f, 
    -0.32824174f, -0.09271436f, 0.37270346f, 0.12478507f, 0.04263170f, -0.05699508f, -0.10393303f, -0.03339041f, 
    -0.11662859f, 0.06888592f, -0.09031198f, -0.05363229f, -0.02892549f, -0.01734350f, 0.04654150f, 0.00470601f, 
    0.01178804f, -0.03459225f, -0.06032306f, -0.04047897f, 0.09566206f, -0.65598804f, -0.93189758f, -0.36483762f, 
    0.30998906f, -0.15292817f, 0.27628204f, 0.30953971f, 0.09868777f, 0.06766654f, -0.06573937f, -0.00561515f, 
    -0.05001478f, -0.03751113f, 0.05650657f, -0.00360864f, -0.01624257f, -0.25267914f, 0.32889301f, 0.10835008f, 
    -0.99940515f, -0.84977853f, -0.45294818f, -0.43287659f, -0.14113741f, -0.17554353f, -0.03568050f, -0.22204757f, 
    -0.05529547f, -0.37490740f, -0.04563416f, -0.04780199f, -0.06416935f, 0.01880769f, 0.03321846f, 0.00930525f, 
    0.01631305f, 0.11776947f, 0.05651959f, -0.03617105f, -0.59192592f, -0.49467790f, -0.83058184f, -0.34759426f, 
    0.01082633f, -0.20963037f, -0.02399177f, -0.02601131f, -0.10135211f, -0.37253660f, 0.07123762f, -0.02429244f, 
    -0.02779661f, 0.02687392f, 0.06760120f, -0.01213664f, -0.01920306f, 0.09446950f, 0.17645180f, 0.05838636f, 
    0.29956368f, -0.37406492f, -0.34788060f, -0.41823876f, -0.14334379f, -0.04206293f, 0.01328886f, -0.20298684f, 
    0.10982645f, 0.15776604f, 0.01029382f, 0.01987542f, -0.05282021f, -0.13597089f, -0.03844528f, -0.05394093f, 
    -0.02404556f, -0.02282582f, 0.15024665f, -0.07309423f, 0.11558476f, -0.07009004f, -0.39634350f, 0.03053357f, 
    -0.08538607f, 0.03402394f, -0.00752239f, 0.11619353f, 0.04724278f, -0.05672557f, 0.02082954f, -0.01280933f, 
    -0.05608244f, 0.01867672f, 0.07295275f, 0.02511119f, 0.00067453f, -0.01303562f, 0.08268061f, 0.06912498f, 
    -0.33047166f, -0.41255045f, 0.29590172f, -0.09265380f, 0.43268314f, 0.01900579f, 0.05708239f, 0.32325044f, 
    -0.15382236f, -0.00988225f, -0.03842305f, 0.03997396f, -0.04457583f, 0.11376379f, -0.04807024f, 0.14448474f, 
    -0.00047810f, -0.07168974f, -0.09911353f, -0.01312960f, -0.31643268f, -0.36636499f, -0.11719318f, -0.17582540f, 
    0.09561275f, 0.04242478f, 0.01577627f, 0.13943812f, -0.06118770f, -0.00641631f, -0.28605407f, 0.16467313f, 
    -0.06449377f, 0.11705319f, -0.00494447f, -0.03890546f, -0.01995252f, 0.00740501f, -0.05900769f, -0.04338541f, 
    0.03904651f, 0.18751289f, -0.02221876f, -0.02355570f, -0.27831146f, -0.01528357f, 0.06319698f, 0.02352100f, 
    -0.11139853f, -0.13830160f, -0.09151321f, 0.04368594f, -0.02197662f, -0.08626860f, -0.08555707f, -0.13451090f, 
    -0.06541833f, -0.04225035f, -0.02754414f, -0.06133873f, -0.71469462f, -0.21583906f, -0.11908684f, 0.42676815f, 
    0.04804859f, 0.25554967f, 0.07639050f, 0.00875556f, -0.06501408f, 0.18644880f, 0.04152886f, -0.03487164f, 
    -0.04401492f, 0.04348700f, -0.00069778f, 0.12399420f, 0.17268345f, -0.07027069f, 0.05255398f, 0.01590940f, 
    0.31514060f, -0.30116358f, -0.17694502f, -0.22360022f, 0.00425242f, 0.02913050f, -0.06000329f, -0.01748219f, 
    0.13474867f, 0.01759806f, 0.04148822f, 0.08129620f, 0.02736892f, -0.04289156f, -0.08344837f, -0.07852823f, 
    0.10321385f, -0.09881574f, 0.03846467f, 0.11706735f, -0.10880855f, -0.45161158f, -0.25221649f, -0.23051399f, 
    -0.16209966f, -0.06142838f, -0.13039158f, 0.11390228f, 0.02717253f, -0.14332969f, -0.08700209f, 0.06678969f, 
    -0.00843116f, 0.06549273f, -0.00730900f, -0.00220719f, -0.02516354f, 0.05959628f, 0.01134559f, -0.03027777f, 
    0.97206658f, 0.40419772f, -0.42466283f, 0.02516074f, -0.59773815f, 0.08341976f, 0.05078286f, -0.03561347f, 
    -0.17691498f, 0.00909642f, 0.00309888f, -0.00735832f, 0.05220520f, 0.15856083f, -0.04204232f, 0.02745726f, 
    0.00256957f, 0.07077408f, -0.00658133f, 0.01931874f, -0.29950267f, -0.22947343f, -0.05101803f, 0.22516038f, 
    -0.21376577f, 0.01416322f, -0.06348513f, -0.05746884f, 0.10552365f, 0.19341485f, 0.04454998f, -0.00151052f, 
    -0.02233410f, 0.01527639f, -0.08135682f, 0.06781571f, 0.00868182f, -0.09006706f, -0.05896750f, -0.03228169f, 
    -0.55220956f, -0.56931090f, 0.56798053f, -0.14246693f, 0.12092867f, -0.17554022f, 0.11562526f, -0.17765337f, 
    0.00241497f, 0.12472863f, -0.02958758f, -0.01478542f, -0.04856360f, -0.07696798f, -0.04431469f, 0.00903217f, 
    -0.01884784f, -0.10323258f, -0.03693332f, -0.15270521f, -0.07381492f, 0.04782990f, 0.03582757f, 0.02412201f, 
    -0.05247257f, 0.02756578f, 0.01209236f, 0.07048684f, 0.08345781f, 0.00602976f, -0.00737490f, 0.00642905f, 
    0.04117614f, 0.01364980f, -0.02136565f, 0.04941661f, -0.04725465f, 0.02562157f, 0.02741254f, 0.07511197f, 
    0.51317465f, -0.41107917f, -0.28600982f, -0.12110852f, -0.03999722f, 0.07816016f, -0.01987228f, 0.04560633f, 
    0.04196144f, -0.04339871f, -0.01558981f, 0.04171281f, 0.05186684f, 0.07326906f, 0.03713627f, 0.02054654f, 
    -0.00827267f, -0.03045880f, -0.00284056f, -0.07353812f, 0.10102718f, 0.08872017f, 0.21415254f, 0.00245688f, 
    -0.20462783f, 0.08496542f, 0.12482446f, 0.03150069f, -0.12005044f, 0.02123558f, 0.05081155f, -0.01617126f, 
    -0.02635206f, 0.07236656f, -0.02223899f, 0.08324859f, 0.11447809f, -0.01015447f, -0.15706593f, -0.02343286f, 
    0.39275709f, -0.60594505f, 0.00637007f, -0.06672024f, 0.02026956f, -0.17748560f, 0.01483537f, 0.01334708f, 
    0.21163520f, -0.17569911f, 0.02406902f, 0.00069248f, 0.04791607f, 0.00539752f, 0.10623502f, -0.05321265f, 
    0.02701072f, -0.04427821f, 0.07044042f, 0.08885115f, -0.12367072f, -0.54697031f, -0.30793613f, 0.13748756f, 
    -0.12856492f, 0.13375418f, 0.15498282f, -0.05779244f, -0.04714747f, -0.13269684f, -0.12312707f, -0.03165610f, 
    0.02144285f, -0.01549616f, -0.03346681f, 0.03339599f, 0.00102493f, 0.07871509f, -0.15496731f, -0.06551142f, 
    -0.49294865f, -0.85673648f, -0.27636224f, 0.13539661f, 0.34076658f, -0.11331557f, -0.01797957f, 0.22696595f, 
    -0.24555063f, -0.10777029f, 0.01842106f, -0.00840262f, 0.03063734f, -0.08050957f, -0.04040393f, 0.02704014f, 
    0.01608559f, 0.00305235f, 0.06154432f, -0.05160633f, 0.10099567f, -0.91438472f, 0.01562191f, 0.85196823f, 
    0.01230367f, -0.14221734f, 0.09011885f, 0.07231652f, 0.10329998f, 0.14337021f, 0.02512068f, 0.04294246f, 
    -0.13892251f, -0.11471111f, -0.00929020f, -0.09566285f, 0.13131158f, -0.10038164f, 0.08232076f, -0.10592490f, 
    0.44136974f, 0.01263062f, -0.10084278f, 0.11837628f, -0.17150499f, 0.14724532f, 0.06642033f, -0.07844919f, 
    -0.05692649f, -0.05528465f, -0.09620613f, 0.08985505f, 0.01842810f, 0.03592561f, -0.07028028f, 0.03179960f, 
    -0.08134223f, 0.09149197f, -0.06406308f, -0.08137937f, 0.01885003f, 0.10696930f, -0.01249520f, 0.02690000f, 
    -0.19265366f, -0.06110996f, 0.01573136f, -0.06543954f, -0.03722342f, -0.06671526f, 0.00009927f, 0.00130463f, 
    -0.06303295f, -0.05273050f, -0.09177258f, 0.00509088f, -0.04800069f, 0.06190237f, 0.07456041f, 0.01915505f, 
    0.17326908f, 0.09254797f, -0.44832358f, -0.03072572f, -0.25962043f, 0.03456095f, -0.01853560f, -0.06156084f, 
    0.04284965f, -0.05246257f, -0.03214973f, -0.05263975f, -0.02919620f, 0.03260688f, -0.07398490f, -0.04392298f, 
    -0.03126132f, -0.02199929f, 0.00732440f, 0.05402469f, 0.37319213f, -0.24339631f, -0.43102977f, -0.15496239f, 
    -0.40044823f, -0.03003781f, -0.00076983f, 0.03248798f, 0.13680379f, 0.04390040f, -0.07450756f, -0.08503535f, 
    -0.05545212f, -0.01079199f, -0.00430407f, -0.11660849f, -0.12928297f, -0.07616114f, -0.03198819f, 0.17013463f, 
    0.05140389f, 0.04759070f, 0.07893384f, -0.09778892f, -0.06244107f, -0.04520091f, 0.03022772f, -0.01294014f, 
    0.01059787f, -0.07827444f, -0.05968412f, -0.28098157f, -0.30564404f, -0.29729536f, -0.20323403f, 0.01091463f, 
    -0.01185773f, 0.00667720f, 0.06866477f, -0.02928614f, -0.02136113f, -0.11400222f, 0.19660540f, -0.14933394f, 
    0.16618685f, -0.01945226f, 0.01932852f, -0.04162863f, 0.02743717f, 0.01885857f, 0.04318748f, -0.05532354f, 
    -0.08816200f, -0.00152340f, -0.02345839f, -0.00100390f, -0.06281499f, -0.12304495f, 0.10690396f, -0.05519199f, 
    -0.03624826f, -0.13870144f, 0.03844101f, -0.17060845f, 0.01227085f, 0.02863700f, -0.06095602f, -0.04113943f, 
    -0.17382048f, 0.01139046f, 0.04992593f, 0.09366240f, 0.04206696f, 0.03203941f, -0.06324637f, 0.01834601f, 
    0.01370343f, -0.15231611f, -0.02913004f, -0.05472778f, -0.08193629f, 0.34576699f, -0.03921031f, 0.18481448f, 
    -0.51376283f, -0.01747133f, 0.19106263f, -0.04687355f, -0.06965242f, -0.00004709f, -0.10256204f, 0.06817419f, 
    0.08151415f, -0.02324820f, -0.01558205f, -0.05771001f, -0.01675002f, -0.03978155f, -0.08524150f, 0.08263819f, 
    -0.12067658f, 0.09069271f, 0.10192639f, 0.06289455f, 0.03915047f, -0.08643561f, -0.02092054f, 0.04119967f, 
    -0.00162648f, -0.00537228f, 0.15607814f, -0.06783704f, 0.10490997f, -0.04281294f, -0.12785158f, -0.04702723f, 
    -0.08804598f, 0.05871198f, -0.11194243f, 0.08131273f, -0.16989729f, -0.03615265f, 0.23242135f, 0.01135018f, 
    0.19523466f, 0.00539942f, 0.12031282f, 0.12571670f, -0.05674858f, 0.01711497f, 0.12008663f, -0.00023746f, 
    0.14571913f, 0.00034050f, -0.08181933f, -0.06219408f, -0.17087452f, -0.04649015f, 0.00189560f, -0.07600436f, 
    0.29592201f, 0.11106217f, 0.02168124f, -0.22057456f, -0.05530905f, 0.01312156f, 0.03241295f, 0.04303698f, 
    0.02157358f, -0.03390319f, 0.11724440f, -0.11883788f, -0.03720589f, 0.03834990f, 0.03166072f, 0.05229949f, 
    0.02824105f, -0.02063275f, 0.10642709f, -0.02017450f, -0.14422007f, 0.27354059f, -0.22045939f, 0.17625517f, 
    -0.37787032f, -0.08908471f, 0.06981468f, -0.15483786f, -0.00676836f, -0.04960277f, 0.06658664f, 0.07442982f, 
    0.06168592f, 0.03347479f, -0.00231228f, -0.12100544f, -0.02475844f, 0.00978988f, -0.07746004f, -0.01545129f, 
    -0.22029695f, -0.52913755f, 0.27503330f, 0.08040595f, 0.08361784f, -0.14260311f, 0.19490667f, -0.03020008f, 
    0.07234459f, 0.10244471f, 0.00875368f, 0.03222794f, -0.01313837f, -0.06955095f, -0.00528806f, 0.03413750f, 
    0.00315205f, -0.03404352f, 0.15021567f, 0.05116456f, -0.45053974f, -0.48459864f, -0.51811820f, 0.33326727f, 
    0.17657652f, 0.14984494f, 0.02531417f, 0.01589344f, -0.03448265f, 0.14412244f, 0.00680296f, 0.03581418f, 
    -0.08686030f, -0.07367877f, -0.03065300f, 0.07345778f, 0.14685978f, 0.02002021f, 0.10306714f, 0.07127777f, 
    -0.09280783f, -0.26630136f, -0.64209783f, -0.60370833f, -0.22251277f, -0.00971656f, -0.11186906f, 0.05517105f, 
    -0.01537990f, -0.34904018f, 0.01596069f, 0.00200702f, -0.03466963f, 0.04636013f, 0.07374715f, 0.04120106f, 
    0.05258168f, 0.05154993f, 0.00887408f, -0.06334087f, -0.12062502f, -0.24584329f, 0.09699074f, 0.08887957f, 
    0.10595073f, -0.13577463f, 0.03422055f, 0.02608334f, 0.00772239f, 0.01724374f, 0.07796501f, -0.06146872f, 
    -0.07432158f, 0.00503196f, -0.04007414f, -0.00935211f, -0.00339354f, 0.04284523f, 0.03789559f, -0.10806083f, 
    0.00275909f, -0.79725039f, 0.11365678f, 0.15348881f, 0.37466469f, 0.10755352f, -0.03151396f, 0.01727830f, 
    -0.08700868f, 0.14327547f, 0.05793121f, 0.05202934f, 0.00500244f, 0.11558078f, 0.07525569f, -0.11503272f, 
    -0.04154643f, -0.10423385f, -0.24577841f, -0.07505105f, 0.17675798f, -0.59712040f, -0.36806342f, -0.03419745f, 
    0.29690364f, 0.16342831f, 0.09576155f, 0.13041833f, 0.01082579f, 0.13733785f, 0.09370477f, 0.13805807f, 
    0.03816275f, 0.15030070f, 0.01167197f, -0.07823800f, -0.01413864f, 0.03163300f, 0.10534116f, -0.00010288f, 
    0.18841979f, 0.29444346f, 0.03278926f, -0.12891835f, -0.06892728f, -0.06016091f, 0.19909069f, -0.00199630f, 
    0.02517790f, -0.01580446f, 0.03823329f, -0.03133463f, 0.06030452f, 0.03310667f, 0.12605697f, 0.07336148f, 
    0.00339275f, 0.03014174f, 0.10384324f, -0.06028430f, 0.00433355f, -0.21409746f, 0.07380743f, -0.02612463f, 
    -0.17962126f, 0.21337163f, -0.21174026f, -0.05730750f, 0.03205730f, -0.15592821f, 0.02998769f, -0.04167573f, 
    0.02753353f, 0.01942213f, 0.00226950f, 0.12146844f, -0.01739203f, -0.02489618f, -0.25752664f, -0.45911834f, 
    0.16033128f, 0.20513551f, -0.27171299f, 0.00000359f, -0.01237894f, -0.09840627f, -0.09205738f, -0.09735058f, 
    0.03687177f, -0.04138036f, 0.09118056f, -0.05043064f, -0.03541296f, -0.00777394f, -0.02108502f, -0.04786080f, 
    0.00542638f, -0.01272765f, -0.04363289f, -0.15654907f, -0.14163920f, -0.72925681f, -0.12419549f, -0.11693025f, 
    0.17797774f, 0.00749343f, 0.12647580f, 0.14609209f, 0.06976007f, 0.10297658f, 0.09950868f, 0.00820493f, 
    -0.07414488f, 0.03447139f, -0.04922777f, -0.02016396f, 0.01390131f, -0.02907296f, 0.07851735f, -0.02288850f, 
    0.04766903f, -0.71649921f, -0.60001135f, -0.31697890f, -0.06509072f, -0.19088984f, 0.22289827f, 0.10928553f, 
    0.23212734f, -0.02103158f, 0.04340584f, 0.05469693f, -0.04275249f, -0.23860157f, 0.01982987f, -0.00650278f, 
    -0.03261477f, -0.12089349f, -0.01735366f, -0.16766794f, 0.13664813f, 0.00528220f, 0.04569082f, 0.03272329f, 
    -0.20170443f, 0.00469782f, -0.05729042f, -0.02630964f, -0.09461454f, -0.14956677f, -0.00335095f, 0.09266908f, 
    0.07604102f, -0.02761669f, -0.05805282f, 0.02282434f, 0.12528990f, 0.17178127f, 0.17664583f, 0.24608193f, 
    0.20794049f, -0.22262938f, -0.16171715f, -0.14451501f, 0.05954154f, 0.03159034f, -0.06887141f, 0.13380221f, 
    0.07885849f, -0.07874343f, 0.02762615f, 0.04655611f, -0.01047004f, 0.06109194f, 0.08455335f, 0.01981641f, 
    0.09494777f, 0.10413256f, -0.06194104f, -0.19395974f, -0.15308186f, -0.11085474f, -0.06090231f, 0.03157733f, 
    -0.11599585f, -0.11125604f, -0.12583682f, -0.13615026f, -0.03547144f, -0.13462389f, 0.02397044f, 0.15600564f, 
    0.05203810f, -0.00594984f, 0.00885762f, -0.03431114f, 0.18391708f, 0.15554848f, 0.13978842f, 0.17499015f, 
    0.04683275f, -0.31264591f, -0.42485321f, -0.10562006f, 0.03918061f, -0.12558119f, -0.04114231f, -0.00443856f, 
    0.12268496f, 0.16994816f, -0.03393960f, -0.12065008f, -0.07906882f, -0.08797752f, -0.02786943f, -0.05253118f, 
    0.05899126f, 0.10507937f, 0.02980630f, 0.08180277f, -0.36522985f, -0.10509802f, 0.28846726f, 0.16874334f, 
    -0.10265612f, -0.08367571f, -0.01876155f, -0.21266161f, -0.10073734f, -0.02513662f, -0.10831179f, 0.02357297f, 
    0.02157960f, -0.08621445f, 0.00155217f, -0.00349470f, -0.34682977f, -0.30613524f, -0.15339646f, -0.22448647f, 
    0.00291500f, -0.47723499f, -0.66607952f, 0.06840998f, 0.19361131f, -0.12546371f, 0.02875953f, 0.25422820f, 
    0.22750613f, 0.24018089f, 0.03263875f, -0.25534233f, -0.02057933f, -0.00784943f, -0.01226081f, -0.05502537f, 
    0.02021328f, 0.01669437f, -0.01224774f, -0.08678491f, 0.28744775f, -0.07969585f, -0.12117710f, -0.03480690f, 
    0.06651674f, 0.06551178f, 0.08423403f, 0.06815552f, -0.06637917f, 0.00989840f, -0.09155659f, 0.13418734f, 
    -0.04465660f, -0.01233858f, -0.04309341f, 0.05453872f, 0.02724704f, 0.10944512f, 0.15449817f, 0.11865067f, 
    1.08077312f, -0.02992900f, -0.59091324f, 0.12764867f, 0.01166979f, 0.11484237f, -0.06399504f, 0.05239668f, 
    0.18111992f, 0.23401518f, 0.09825376f, -0.00006664f, 0.08972518f, 0.08964275f, 0.10797530f, -0.09626225f, 
    0.05273647f, -0.06572315f, -0.08579960f, 0.02781188f, 0.36196652f, -0.08982509f, -0.27274773f, -0.29610559f, 
    0.06167360f, 0.16604325f, -0.04527878f, 0.01564463f, 0.06344458f, -0.03600565f, 0.03491036f, 0.06150469f, 
    0.16025092f, 0.08129648f, 0.11223810f, 0.04680391f, 0.02591323f, 0.07041944f, 0.01162057f, -0.06191039f, 
    0.39950311f, -0.00787304f, -0.26301011f, -0.15862633f, -0.06275330f, 0.00052178f, 0.03935409f, -0.01845904f, 
    0.00955608f, -0.09063957f, 0.11457197f, -0.01919664f, -0.00954376f, 0.00655696f, 0.00193505f, 0.02087835f, 
    -0.05457632f, 0.04535227f, 0.17063889f, -0.02456520f, -0.16185609f, 0.10790383f, 0.08503392f, -0.06921412f, 
    -0.24467213f, -0.06403734f, -0.03248654f, -0.04963828f, -0.00977014f, -0.04216043f, -0.03228209f, 0.02616317f, 
    -0.02696177f, 0.03268042f, 0.03983447f, 0.08697828f, 0.08912694f, -0.01804235f, 0.03179127f, 0.02737498f, 
    0.04955048f, 0.03880169f, -0.00587763f, -0.10756417f, -0.15059301f, -0.02614853f, 0.02072662f, -0.05720816f, 
    0.02928608f, -0.03443398f, 0.10687065f, -0.03587260f, 0.08939337f, 0.07628560f, -0.00659881f, -0.00390292f, 
    -0.02694830f, 0.00369466f, 0.04233650f, -0.07182983f, 0.20351940f, 0.04872405f, -0.16296315f, -0.00843026f, 
    -0.17274901f, -0.17603177f, -0.07840879f, -0.06641180f, -0.00731952f, -0.11177240f, 0.03066207f, 0.10381573f, 
    -0.00107354f, 0.11743759f, 0.09001212f, 0.00679481f, -0.10459226f, 0.00032198f, -0.19511136f, -0.12647244f, 
    -0.20561704f, -0.03786491f, -0.00688910f, -0.11870633f, -0.18759133f, -0.06803895f, -0.05877481f, -0.00100681f, 
    0.04357056f, -0.03475519f, 0.11796764f, 0.01911169f, 0.11870124f, 0.05344167f, 0.17257281f, -0.00940036f, 
    0.06807980f, 0.02282046f, 0.02537396f, 0.08842310f, 0.34367302f, -0.12422488f, 0.00579628f, 0.11162613f, 
    -0.01087758f, 0.11090921f, -0.11099440f, -0.20304316f, 0.01831273f, 0.07011710f, 0.09029981f, 0.05648323f, 
    0.04548560f, 0.02490075f, 0.04261852f, 0.03314009f, 0.08983429f, 0.13124235f, -0.10294666f, 0.15559100f, 
    0.60971016f, 0.22322923f, 0.16932094f, 0.19580780f, -0.24704753f, 0.08493215f, -0.10640702f, -0.21287397f, 
    -0.04162556f, 0.07765038f, -0.01602332f, -0.03151637f, -0.06069983f, -0.10717405f, -0.03568533f, -0.29973787f, 
    0.01662474f, -0.15933385f, -0.29105985f, -0.12036075f, 0.30361947f, 0.41115937f, 0.11485855f, -0.04462923f, 
    -0.21011651f, -0.06626855f, -0.04962819f, -0.18817061f, 0.07294205f, -0.09159319f, -0.04137523f, -0.00358529f, 
    -0.03213589f, -0.05474769f, 0.06987263f, -0.13614798f, -0.15094554f, -0.32139692f, 0.00360942f, -0.11338268f, 
    -0.49257281f, -0.13309272f, 0.05629261f, 0.01968740f, -0.16137986f, -0.08429198f, 0.01219401f, -0.00637538f, 
    0.06854001f, -0.05212712f, -0.07089851f, 0.15308499f, 0.04983488f, 0.08842015f, 0.12233356f, -0.07892075f, 
    0.17362557f, 0.05994529f, 0.17592028f, 0.11615886f, -0.87666589f, -0.28692046f, 0.40058786f, 0.19180451f, 
    0.20152614f, -0.05120566f, -0.08524194f, -0.05524067f, -0.06449522f, -0.08699059f, -0.09243010f, -0.18546142f, 
    0.00494634f, 0.00192524f, -0.00553176f, -0.21914868f, -0.06938952f, 0.01505868f, -0.31862855f, 0.08846109f, 
    -0.22683592f, -0.32145450f, -0.16536577f, -0.08635680f, -0.08132175f, -0.15035608f, 0.03920208f, 0.16118170f, 
    0.06751157f, 0.10614004f, 0.08835915f, 0.06217826f, 0.08632480f, 0.08696337f, 0.09526993f, -0.02170814f, 
    0.03803872f, 0.01859731f, 0.01668363f, 0.02558997f, 0.43104613f, 0.43554041f, 0.12397061f, 0.04626476f, 
    -0.20302783f, 0.27515566f, -0.17566021f, 0.05663449f, 0.02343641f, -0.43337479f, -0.00577347f, 0.02137284f, 
    0.02337607f, -0.06587926f, -0.00111726f, -0.06357392f, 0.07523867f, 0.03777479f, 0.15206467f, 0.02101148f, 
    0.08176348f, -0.69978660f, -0.68973547f, -0.22998779f, -0.07818519f, 0.03595361f, -0.06113354f, -0.00303105f, 
    0.07257656f, 0.02976232f, -0.06199817f, 0.01754511f, 0.03644824f, -0.02813525f, 0.07340067f, 0.03761832f, 
    0.02023259f, 0.05712192f, 0.05914913f, 0.10364901f, 0.04984671f, -0.46987754f, -0.37710887f, -0.31421831f, 
    -0.16430514f, -0.07137350f, -0.09770994f, -0.02340750f, -0.12247078f, -0.38707218f, -0.01354395f, -0.00756228f, 
    0.03295074f, 0.04589702f, 0.03535023f, 0.12020306f, 0.02158453f, 0.10304428f, -0.23957346f, -0.30881014f, 
    -0.26804295f, -0.14703055f, 0.17030841f, 0.17002486f, -0.52175742f, -0.06664147f, -0.07341040f, -0.02705937f, 
    0.15345988f, 0.18199290f, 0.06530433f, 0.02020955f, 0.05219575f, 0.06600792f, -0.02908297f, -0.03991731f, 
    0.03876062f, 0.13243161f, 0.18429656f, 0.06890172f, 0.04672681f, 0.19178437f, -0.03525507f, 0.16183387f, 
    -0.04725199f, 0.02536103f, -0.13193387f, -0.09185802f, 0.02248352f, -0.10062908f, -0.00062607f, 0.03669508f, 
    0.03164977f, 0.05287027f, -0.05555502f, 0.08756257f, 0.06220207f, 0.04280352f, -0.04559623f, 0.10335471f, 
    0.00730105f, -0.80392683f, 0.14800692f, -0.64557838f, -0.39127558f, -0.00359939f, -0.26839727f, 0.04219033f, 
    0.13620637f, -0.12171348f, -0.14666551f, 0.03115174f, 0.02662763f, -0.08545895f, 0.13324578f, 0.06831861f, 
    0.08853856f, -0.02062157f, -0.06827888f, 0.05597911f, -0.18980500f, -0.08997344f, 0.66878086f, -0.16754515f, 
    -0.78893119f, 0.15803756f, -0.31012362f, -0.01188384f, -0.06534740f, -0.13292985f, -0.01611204f, 0.08519837f, 
    -0.03839011f, 0.09312998f, 0.08240663f, -0.04285688f, -0.08473053f, -0.06064791f, -0.11685220f, 0.01094380f, 
    -0.27623129f, 0.01853957f, -0.19214289f, 0.05720869f, 0.20610985f, -0.01689024f, 0.10735739f, 0.14845733f, 
    0.08748580f, -0.27669388f, 0.01692089f, 0.04889840f, 0.00686221f, -0.09029722f, -0.01593048f, -0.04036414f, 
    0.05825192f, -0.10630875f, 0.01980835f, 0.11573843f, 0.06876089f, -0.22410978f, -0.89495414f, 0.12891588f, 
    0.01175135f, 0.13337454f, -0.09302077f, 0.20835602f, -0.02581539f, 0.16088507f, 0.03080834f, 0.00624868f, 
    -0.01574077f, -0.00545640f, 0.02280721f, -0.07222738f, 0.11065873f, 0.16605899f, 0.13596681f, 0.17807110f, 
    -0.36282495f, 0.02928244f, -0.02096204f, 0.35590565f, 0.02951501f, -0.06858865f, 0.23864147f, -0.40898788f, 
    0.17168480f, -0.14669850f, 0.07677051f, -0.07243357f, 0.14756905f, 0.00641914f, 0.01750795f, 0.15181638f, 
    0.11786760f, -0.01541142f, 0.05366648f, 0.13128665f, 0.02590198f, -0.05508937f, 0.42819607f, 0.15168174f, 
    -0.56703991f, 0.11016753f, -0.19016814f, -0.06419898f, -0.01792813f, -0.19540566f, -0.01667040f, 0.09837747f, 
    0.03958319f, 0.16730037f, -0.00387545f, 0.01686205f, -0.05476204f, 0.03020032f, -0.02290072f, 0.04386814f, 
    -0.34251076f, 0.39797562f, -0.01599028f, 0.54049581f, -0.21624704f, 0.05002597f, -0.34400660f, -0.25547066f, 
    -0.19208550f, -0.19872613f, 0.15598729f, -0.08536608f, 0.13117951f, -0.01451679f, 0.00522749f, 0.10189155f, 
    0.02918898f, 0.01763248f, -0.01706980f, 0.05999975f, 0.10689856f, 0.34167233f, -0.39816329f, 0.06176611f, 
    -0.11912770f, 0.11400279f, 0.10900246f, 0.23412164f, -0.00156595f, 0.03580988f, 0.02643403f, 0.00766231f, 
    -0.06336833f, -0.16168112f, -0.07388175f, -0.02651034f, -0.05993964f, -0.04412159f, 0.04494435f, -0.22079568f, 
    0.09209509f, -0.36533719f, 0.09434804f, -0.15825944f, -0.13787337f, -0.16024007f, -0.05086751f, 0.14447750f, 
    0.07741264f, 0.17291740f, -0.03927262f, 0.01141198f, 0.00309474f, -0.04170742f, -0.03011794f, -0.00597884f, 
    0.09225089f, 0.06706222f, -0.07454553f, -0.00517654f, 0.15909505f, 0.18539222f, -0.07959529f, 0.02190696f, 
    -0.07962885f, 0.02566451f, 0.17615254f, 0.16472173f, 0.05213884f, 0.02053718f, 0.02304925f, -0.06904283f, 
    -0.18837625f, -0.05115570f, 0.01370444f, 0.07138623f, -0.02565754f, -0.09744845f, 0.00244870f, -0.01076032f, 
    -0.09482010f, 0.00850214f, 0.39152041f, 0.13211840f, -0.18656577f, 0.04424017f, -0.10933963f, -0.15588248f, 
    -0.04501842f, 0.02671335f, 0.05586558f, 0.01088346f, 0.07209352f, -0.01431278f, -0.00599823f, -0.03972178f, 
    -0.07838332f, -0.04458993f, -0.03518155f, -0.06182049f, -0.08118001f, -0.48015645f, -0.10992695f, -0.69991612f, 
    0.20450105f, 0.11593175f, 0.13788083f, 0.10918202f, 0.15475249f, 0.07998277f, 0.03000079f, 0.07360138f, 
    -0.04374236f, -0.03543193f, -0.06563877f, -0.14761147f, 0.07017402f, 0.08309291f, -0.12276699f, 0.03190263f, 
    0.03670571f, -0.04033990f, 0.01238429f, -0.03165112f, -0.39439166f, -0.20359948f, 0.07416821f, -0.47691596f, 
    0.02019742f, -0.17651357f, -0.00000883f, -0.01714437f, 0.00775732f, 0.16236970f, 0.06756338f, -0.00733877f, 
    0.02808706f, 0.00784245f, -0.01227749f, -0.00339735f, 0.08553918f, 0.11726121f, -0.01981803f, -0.09205692f, 
    -0.12615804f, -0.00020881f, -0.13092268f, -0.02203439f, 0.04154633f, -0.00744743f, 0.04664572f, 0.02714321f, 
    -0.11871740f, -0.07720648f, 0.03315173f, -0.05244177f, -0.05004099f, 0.04791697f, -0.03991371f, -0.08062328f, 
    -0.60303378f, -0.24149650f, 0.20952399f, 0.16048761f, -0.44081917f, 0.12683478f, -0.29972741f, -0.03956555f, 
    -0.08608983f, -0.01095489f, 0.05656187f, -0.03282803f, -0.09118540f, -0.04706159f, 0.01439462f, 0.10601301f, 
    0.05835922f, -0.18515308f, -0.05178044f, -0.00532899f, -0.18782367f, -0.22255106f, 0.00043374f, 0.12377104f, 
    -0.49367091f, 0.03114415f, -0.12385746f, -0.04181491f, -0.11058419f, 0.13629837f, 0.00655037f, 0.01982449f, 
    0.01333890f, 0.01384051f, -0.00419694f, 0.05639669f, -0.01039988f, 0.03262774f, 0.12105395f, -0.10731851f, 
    -0.44966483f, 0.04876521f, 0.02093837f, 0.33837026f, -0.10940970f, 0.07393642f, -0.17489395f, 0.07084490f, 
    -0.24246635f, -0.42362949f, 0.01330091f, -0.08556098f, 0.05520513f, -0.01081300f, 0.10159516f, -0.06325719f, 
    -0.04192211f, -0.16028863f, -0.03805365f, -0.02575320f, -0.21016186f, -0.09690388f, -0.00975682f, -0.11604743f, 
    0.16111529f, 0.06428478f, 0.11904977f, 0.11087393f, 0.03555596f, -0.15165903f, 0.04956492f, 0.15240675f, 
    0.01788244f, -0.01795179f, -0.03836119f, 0.05208039f, -0.00687523f, 0.05470610f, -0.09660179f, -0.01235216f, 
    -0.08873120f, 0.17876290f, -0.05107486f, 0.35647306f, 0.13056028f, -0.02414510f, 0.06315082f, -0.13542108f, 
    0.10885075f, -0.13473183f, 0.12065670f, -0.05010441f, 0.10883275f, -0.04419032f, -0.08878322f, 0.09459152f, 
    0.08497111f, 0.02711728f, 0.03984994f, 0.12392945f, -0.37503135f, -0.01144926f, 0.02412109f, 0.36673462f, 
    0.03222836f, 0.02342416f, 0.09561033f, -0.06408917f, -0.14566991f, 0.09466570f, 0.11278316f, -0.15919985f, 
    0.06901278f, -0.00944052f, -0.02251112f, 0.20891684f, 0.10938714f, 0.07639694f, 0.10866194f, 0.03555924f, 
    -0.01760084f, -0.06086277f, 0.10627011f, 0.08296376f, 0.25566587f, -0.02061401f, 0.02820345f, -0.04928500f, 
    -0.02876935f, -0.19814304f, 0.09209828f, 0.07545058f, 0.17941523f, -0.03625463f, -0.03913173f, 0.09779543f, 
    -0.00323387f, -0.04403977f, -0.08715127f, 0.01246033f, 0.15443501f, -0.26737532f, -0.03506706f, -0.20411627f, 
    -0.23362501f, 0.07862886f, 0.00143738f, -0.02914475f, 0.05881500f, 0.03575074f, 0.07476547f, -0.09562912f, 
    -0.06743488f, -0.04574032f, -0.01284213f, 0.14874233f, 0.04028488f, -0.03532489f, -0.15510358f, -0.04732323f, 
    -0.19998270f, -0.31934118f, -0.42194921f, -0.27664155f, 0.00676929f, 0.27250928f, 0.05576445f, -0.06572340f, 
    -0.09997702f, -0.19039199f, 0.10714450f, -0.14615287f, 0.00071495f, 0.01689007f, -0.17106330f, 0.12409024f, 
    -0.04856122f, -0.21647680f, -0.09725343f, 0.15283349f, -0.53735489f, -0.06995137f, -0.56973797f, 0.09388424f, 
    0.08897663f, 0.03851968f, 0.07056472f, 0.19613227f, -0.00183902f, 0.08069205f, -0.04720051f, -0.06337319f, 
    0.07069875f, -0.00986016f, -0.02917021f, 0.09096222f, 0.10283335f, 0.11211292f, 0.04837858f, 0.21800919f, 
    -0.18727820f, 0.16903393f, -0.03331501f, -0.65748239f, 0.00843945f, -0.08488005f, -0.02597926f, -0.04030224f, 
    0.07438172f, 0.16277066f, 0.05204144f, 0.09391198f, -0.07483247f, 0.07573931f, 0.09866728f, 0.09315892f, 
    0.30071312f, -0.11804665f, -0.07496689f, 0.03109793f, 0.26265532f, -0.61224288f, -0.17176583f, -0.45486587f, 
    0.22424272f, -0.14692035f, -0.00501313f, 0.13729575f, 0.14501941f, 0.06037939f, -0.14533176f, 0.01710375f, 
    0.05961961f, -0.17630824f, -0.09463813f, 0.03876952f, 0.07551231f, 0.21246922f, -0.08524428f, 0.02885948f, 
    0.10990246f, 0.29045022f, 0.31758109f, 0.28830928f, -0.00186549f, 0.07027900f, 0.03069572f, -0.26615018f, 
    -0.21964425f, -0.17920452f, 0.02540210f, 0.04777550f, 0.01186732f, 0.06098464f, 0.01114493f, 0.06620266f, 
    0.02467761f, -0.11866546f, 0.04050231f, 0.02358668f, -0.11120468f, 0.35414004f, -1.61675668f, 0.23549265f, 
    -0.15127592f, 0.01921381f, 0.13902853f, 0.39995942f, -0.06591328f, 0.00223935f, 0.04397923f, -0.09963252f, 
    -0.05716491f, -0.03552445f, -0.03058975f, -0.05341484f, 0.14758395f, -0.13434102f, 0.02794804f, -0.05492867f, 
    -0.28847072f, -0.04316478f, 0.15939057f, 0.11485908f, -0.19644934f, -0.23829296f, -0.07960957f, 0.23858215f, 
    0.08142368f, 0.18039405f, -0.06167189f, 0.05428033f, 0.04721194f, -0.05813985f, -0.00061269f, -0.03620952f, 
    -0.00154968f, 0.03739819f, -0.05295627f, -0.20160571f, -0.14503355f, -0.33503434f, -0.04189869f, -0.04090898f, 
    -0.03581446f, -0.01800280f, -0.33582830f, -0.03572429f, 0.07013506f, 0.11463393f, -0.03424029f, 0.10152820f, 
    0.04864660f, 0.06356415f, 0.00476478f, -0.02402237f, 0.08112303f, 0.18044734f, 0.09720732f, 0.22774346f, 
    -0.27463356f, 0.10579023f, -0.54323059f, 0.03173303f, 0.09997223f, -0.10535974f, -0.07461566f, -0.23469307f, 
    0.00852627f, 0.00943368f, 0.00068933f, 0.10755196f, 0.06176154f, -0.06643456f, -0.00905908f, 0.00596400f, 
    -0.02727034f, -0.07546367f, 0.00906297f, -0.13186131f, 0.01359585f, -0.11065564f, 0.02102807f, 0.08014444f, 
    -0.08371817f, 0.01768893f, -0.00738665f, 0.04615488f, -0.05256336f, 0.03081560f, -0.03404646f, 0.08673996f, 
    -0.10131140f, -0.01345794f, -0.07978729f, -0.00575144f, -0.07128488f, 0.05619559f, 0.03724861f, -0.12174546f, 
    -0.43303701f, 0.33981633f, -0.19819675f, 0.22389746f, 0.04875144f, 0.12229228f, -0.05185049f, -0.18267968f, 
    0.16948469f, 0.15175734f, -0.03696026f, 0.09165731f, 0.00755730f, 0.02089201f, 0.07798875f, -0.11711878f, 
    -0.09255233f, -0.26592675f, -0.09769345f, 0.04703704f, -0.59531599f, 0.22111236f, -0.11640745f, 0.35688955f, 
    0.00025302f, 0.05709231f, 0.01544042f, -0.15977712f, 0.30688632f, 0.12862079f, 0.06245277f, -0.13587366f, 
    -0.01535973f, -0.08491215f, 0.13653533f, 0.07992687f, 0.04112766f, -0.08973100f, 0.20763959f, 0.10910005f, 
    -0.00223806f, -0.32732716f, 0.19396481f, 0.00287232f, -0.00823433f, -0.08249128f, -0.05610520f, -0.01796025f, 
    0.04570007f, -0.04208469f, -0.03371789f, -0.01807534f, -0.12576242f, 0.23621443f, 0.12275586f, 0.01020591f, 
    -0.02579353f, 0.10239248f, -0.03892888f, -0.00364143f, -0.13739949f, -0.03449860f, -0.26166925f, -0.04970246f, 
    0.05375109f, -0.11130395f, 0.02134258f, 0.04521515f, -0.06508538f, -0.20770739f, 0.03630790f, 0.09438564f, 
    -0.01988986f, 0.04204112f, -0.10858281f, 0.17888008f, -0.18065132f, -0.09981493f, -0.34850165f, -0.29636419f, 
    0.00095845f, 0.16358146f, 0.06445958f, 0.14427848f, -0.13897726f, 0.12492027f, -0.07632121f, 0.10046761f, 
    -0.01133309f, -0.19006144f, -0.02877030f, 0.09521120f, 0.00198127f, 0.03809181f, 0.03937610f, -0.13547921f, 
    -0.10822820f, -0.03068775f, -0.02785261f, -0.23301414f, -0.24165341f, 0.21610220f, -0.04752909f, 0.14566867f, 
    0.00716011f, 0.06411012f, -0.03488505f, -0.12565491f, 0.10854205f, 0.02043259f, 0.13778575f, -0.01808662f, 
    0.03089157f, -0.03083664f, 0.06346828f, 0.00041627f, -0.01964487f, -0.00267357f, 0.08916602f, 0.01022274f, 
    0.57996607f, -0.30096990f, 0.21746491f, -0.40102994f, -0.14509413f, -0.00205983f, 0.05411327f, -0.08471033f, 
    0.10020678f, -0.06490580f, -0.10332561f, 0.15555519f, -0.19278419f, -0.22653447f, -0.35162750f, -0.02714544f, 
    -0.05794456f, 0.07837630f, 0.03362920f, -0.15375748f, -0.37190589f, -0.24214932f, 0.03585980f, -0.06036942f, 
    -0.02700741f, 0.06071540f, 0.08083729f, 0.03544909f, -0.01213526f, 0.06432758f, -0.04563847f, 0.02714283f, 
    -0.02142609f, 0.05007254f, -0.02771166f, 0.00525056f, 0.04969952f, 0.03490952f, 0.16174558f, 0.23137622f, 
    -0.17018451f, 0.14167173f, 0.06286792f, 0.04024598f, 0.17642550f, 0.00150328f, -0.08041016f, 0.06919586f, 
    -0.11054292f, -0.03781522f, 0.02098458f, 0.01641822f, 0.09650856f, 0.01584950f, -0.07385668f, -0.07042200f, 
    -0.03487217f, -0.17185766f, -0.13296700f, 0.05599361f, -0.23488081f, -0.32331255f, -0.21019264f, -0.10266375f, 
    -0.20603606f, -0.08921404f, -0.01216496f, 0.02735496f, -0.07208051f, -0.07552574f, 0.00439297f, -0.04696521f, 
    0.08299739f, 0.05454846f, -0.09389931f, 0.03949758f, 0.02680896f, 0.23163280f, 0.09875110f, 0.19072928f, 
    -0.19188343f, 0.03954777f, -0.06515911f, 0.01002478f, 0.10815022f, -0.04585398f, 0.07187899f, 0.01513208f, 
    0.08283330f, 0.05188826f, -0.00996223f, -0.03503940f, -0.06146581f, -0.04661082f, -0.00342298f, 0.04959353f, 
    0.04205720f, 0.00018305f, 0.15408128f, 0.18156987f, -0.04036447f, 0.12851186f, 0.47659653f, 0.19952314f, 
    0.02104177f, 0.03948971f, 0.03179093f, -0.10656897f, 0.05929815f, -0.30488712f, -0.13632633f, 0.00194128f, 
    -0.05515603f, 0.04374139f, 0.08395471f, -0.04726130f, -0.14010091f, 0.14908852f, -0.28322804f, -0.09164073f, 
    -0.08712432f, 0.28439158f, 0.03881399f, 0.10611480f, 0.13182367f, 0.13554271f, -0.00894275f, -0.07470778f, 
    -0.02395886f, 0.07558685f, -0.16045283f, 0.12190712f, -0.03021290f, -0.12564144f, -0.09284845f, 0.02260160f, 
    -0.03982968f, -0.05813996f, 0.01499519f, -0.04334238f, -0.23095638f, -0.08607836f, 0.23170505f, 0.28985232f, 
    0.13921307f, 0.00741009f, 0.01100666f, -0.03678031f, 0.10581398f, 0.00396810f, -0.01096954f, -0.03374121f, 
    0.02819237f, 0.08240380f, 0.07673340f, 0.08559746f, 0.06010249f, -0.13293426f, 0.21676838f, 0.19903579f, 
    -0.72372222f, 0.18002616f, 0.20790017f, 0.08009579f, 0.03824897f, 0.13028212f, 0.06280506f, -0.02367803f, 
    0.21766917f, -0.02731236f, -0.20791274f, 0.00050854f, 0.19999783f, -0.05492340f, 0.17042160f, 0.02669452f, 
    0.03884703f, -0.03624922f, 0.00822513f, 0.07395748f, -0.19514942f, 0.20063794f, -0.42247969f, -0.17874837f, 
    0.15579957f, -0.05067744f, -0.02981421f, 0.02472887f, -0.07004957f, 0.12450279f, -0.16071041f, 0.10056058f, 
    -0.11126324f, 0.12490713f, 0.05440523f, 0.11742694f, -0.11482225f, -0.07331245f, -0.09778508f, -0.00307225f, 
    -0.57758248f, -0.43554127f, 0.33787322f, -0.21704464f, -0.10438639f, -0.06469303f, -0.03035689f, -0.09759152f, 
    0.30625370f, 0.02509564f, 0.08410711f, -0.13328074f, -0.11577942f, 0.10199528f, -0.04842926f, 0.06710851f, 
    -0.02852594f, 0.12130580f, 0.16071001f, -0.02401399f, -0.25839424f, -0.33996579f, -0.07482030f, -0.31997454f, 
    -0.20910399f, -0.09237649f, -0.19152553f, -0.01763056f, 0.15464056f, -0.09620287f, -0.09482556f, -0.02928898f, 
    -0.02039750f, -0.05122865f, 0.01362843f, 0.16727048f, 0.06160071f, 0.03441526f, 0.17917463f, -0.06002747f, 
    0.07376964f, -0.02638795f, 0.11687241f, -0.04721554f, -0.12305663f, 0.00275581f, -0.09900861f, -0.03773958f, 
    0.00826475f, -0.06243574f, 0.01633981f, 0.11596370f, -0.12259725f, -0.01184275f, -0.00290431f, -0.08971250f, 
    -0.01789497f, 0.02602139f, 0.01532226f, -0.15334763f, 0.44469136f, -0.32180083f, 0.37520364f, -0.10464033f, 
    -0.04268672f, 0.10844234f, 0.00013054f, 0.16004692f, 0.00466847f, -0.13344526f, 0.15111612f, 0.02186125f, 
    -0.07714833f, -0.04218132f, -0.04458543f, -0.00459396f, -0.09249187f, 0.09276193f, -0.13448063f, -0.16049902f, 
    -0.06368175f, -0.27080232f, -0.17007990f, 0.04333870f, -0.28044909f, -0.04184701f, -0.09701908f, -0.01922711f, 
    -0.08790328f, -0.01295066f, -0.11698828f, 0.03181221f, -0.10586558f, -0.08522759f, 0.09201751f, -0.04461724f, 
    -0.01544217f, -0.00009322f, 0.01275385f, 0.04962002f, -0.30307636f, 0.21071705f, -0.40924719f, 0.31553039f, 
    0.05064189f, -0.04569221f, -0.05538317f, 0.03310371f, 0.34091571f, 0.20694672f, -0.28250459f, 0.04364801f, 
    -0.01797347f, -0.04356003f, -0.00741251f, -0.01637910f, -0.03490713f, -0.05239491f, 0.28848627f, 0.27710596f, 
    -0.44961080f, 0.10321080f, 0.29595819f, 0.39044839f, 0.21591881f, -0.04469289f, -0.14588481f, 0.13215686f, 
    0.23640262f, 0.03846187f, -0.33768541f, 0.06001034f, 0.14791498f, -0.06069899f, 0.03177740f, -0.06587306f, 
    -0.06484152f, -0.05566547f, -0.02273872f, 0.23235376f, 0.14896543f, -0.33105016f, 0.21029057f, 0.01020202f, 
    0.10309103f, -0.17259195f, 0.08102964f, 0.01119241f, 0.01735545f, -0.17706253f, -0.04631677f, -0.03240391f, 
    -0.03308817f, 0.03489209f, 0.01302272f, 0.02160830f, -0.10096011f, -0.02597863f, -0.15858401f, -0.37143910f, 
    0.04676744f, -0.20973727f, 0.32324636f, 0.05305046f, -0.30627093f, 0.07274778f, 0.03238061f, 0.17009741f, 
    -0.01147877f, -0.06196297f, 0.06881797f, -0.13023998f, 0.05354121f, -0.04699629f, 0.01820178f, -0.02910633f, 
    0.04486861f, 0.28455409f, 0.09880680f, 0.05392015f, 0.02583824f, 0.11530308f, -0.31012034f, 0.36686915f, 
    -0.02706584f, 0.03466596f, -0.11096899f, -0.14928420f, -0.08199877f, 0.03603729f, -0.04454559f, 0.09085800f, 
    -0.20441729f, 0.05739239f, 0.05752787f, -0.03866942f, 0.02881532f, -0.14715490f, -0.08877008f, 0.06317902f, 
    0.19625415f, -0.10633717f, -0.02636787f, 0.08024399f, -0.12655057f, 0.04135631f, -0.04320020f, -0.19047229f, 
    0.05124721f, -0.04660425f, -0.13502805f, 0.07873219f, -0.01188549f, -0.14180160f, -0.04090250f, -0.03420303f, 
    -0.03699623f, 0.00622904f, 0.06355939f, -0.02330167f, -0.48579249f, -0.72463101f, 0.02261837f, -0.18224326f, 
    -0.03775043f, -0.29102734f, -0.11167989f, 0.14352924f, -0.20019761f, -0.08085810f, -0.16720358f, 0.14942068f, 
    -0.10309402f, 0.10320450f, 0.09015559f, 0.17763384f, -0.21772672f, 0.03203921f, 0.04869476f, 0.06289569f, 
    -0.38318992f, 0.12231363f, -0.21247685f, 0.01734368f, 0.17135274f, -0.08473830f, -0.08687456f, -0.01801681f, 
    -0.02051903f, -0.02124622f, 0.03668667f, 0.05910242f, 0.03127633f, 0.02407615f, -0.03193806f, 0.02547928f, 
    0.02474150f, -0.12758113f, 0.07424325f, 0.06465617f, -0.09796142f, -0.06094747f, -0.76991695f, -0.05189633f, 
    0.03514662f, 0.00075790f, -0.02705765f, 0.03180339f, -0.18694994f, -0.12865631f, 0.04013221f, 0.08347711f, 
    0.05542448f, 0.04774648f, 0.00538456f, 0.07241824f, -0.06616268f, -0.11936686f, -0.20327801f, -0.30568412f, 
    -0.05518533f, -0.24948524f, -0.19912070f, -0.44572520f, -0.17082432f, -0.10543232f, -0.13926163f, 0.17456026f, 
    -0.06098133f, -0.04685364f, 0.09293163f, 0.10210247f, 0.07596366f, -0.01761223f, -0.08066996f, 0.04422543f, 
    -0.00120606f, -0.03830125f, 0.06763171f, 0.11612571f, -0.20705929f, 0.17817862f, -0.14603195f, -0.15232407f, 
    -0.04724075f, 0.03312288f, 0.09634242f, -0.04388054f, -0.01042933f, 0.03435151f, -0.14591281f, -0.09426344f, 
    0.08483491f, 0.05458503f, 0.11938011f, 0.03692648f, -0.17097878f, -0.05165999f, -0.01082406f, 0.04650596f, 
    -0.57113296f, -0.23533210f, -0.36760277f, 0.67660069f, -0.17409320f, 0.01747732f, 0.14799161f, -0.04174848f, 
    0.17857380f, -0.10245362f, -0.26144424f, -0.03519153f, 0.00222362f, 0.14230719f, 0.09081698f, 0.07465570f, 
    0.02752841f, 0.21845366f, 0.09547979f, -0.00130037f, -0.48650569f, -0.40754092f, 0.08395424f, 0.22010972f, 
    -0.30692482f, -0.01422607f, 0.06560130f, -0.05614623f, 0.20836478f, -0.15933560f, -0.09036207f, -0.03336418f, 
    -0.01728133f, -0.10391250f, 0.16649835f, 0.04680618f, 0.01089313f, 0.08700751f, 0.08733461f, 0.04112405f, 
    0.14979492f, -0.07614043f, 0.15097950f, 0.04438678f, 0.22298475f, -0.00945676f, 0.10844266f, 0.03124489f, 
    0.07088913f, -0.09696972f, -0.06393241f, -0.06834600f, -0.07480090f, -0.06856240f, -0.14826657f, 0.01886437f, 
    0.02484744f, 0.04126706f, 0.02618161f, -0.04263867f, 0.44051558f, -0.49288219f, 0.23702553f, -0.12050834f, 
    0.11857364f, -0.04510946f, -0.28273079f, -0.18851037f, 0.04309753f, -0.29519522f, -0.05496898f, 0.06309862f, 
    0.04210816f, -0.01213256f, -0.04116007f, 0.11101957f, -0.00331038f, -0.03268630f, 0.25640661f, 0.01636000f, 
    -0.76429683f, 0.00162888f, -0.42231089f, 0.06082910f, -0.10835797f, 0.20474304f, 0.07712233f, 0.21821392f, 
    -0.30593038f, -0.02528027f, 0.02264961f, -0.15750083f, 0.02629566f, 0.29718107f, 0.19215383f, 0.01534087f, 
    -0.00840812f, 0.05985516f, 0.13229917f, 0.04542002f, -0.48875451f, -0.13350810f, -0.15374473f, 0.19396508f, 
    -0.29601419f, -0.00636522f, 0.07848200f, -0.04245093f, 0.23200177f, -0.02838945f, -0.12005996f, 0.01652937f, 
    0.00102232f, -0.10155584f, 0.05242918f, 0.01642206f, -0.06289842f, 0.02592946f, -0.02719543f, 0.10604092f, 
    -0.24326068f, -0.09879661f, -0.09017805f, 0.05531552f, -0.18795213f, 0.03651408f, 0.19960698f, 0.05052035f, 
    -0.02757548f, 0.04241179f, -0.04724653f, 0.03260504f, 0.08335542f, 0.10893690f, -0.01070181f, -0.15230030f, 
    -0.02108114f, 0.08512656f, -0.04016124f, 0.17787112f, 0.43742225f, 0.07576419f, 0.37847060f, 0.03902827f, 
    -0.08268968f, 0.05282884f, -0.03096221f, -0.09775572f, -0.06145843f, -0.11773524f, -0.14901972f, 0.10529730f, 
    0.04836964f, 0.09794251f, -0.00325010f, -0.09439456f, -0.07770733f, -0.02699333f, -0.00811104f, -0.02158348f, 
    -0.22139005f, -0.25087863f, -0.15243691f, 0.15475100f, 0.07998966f, -0.05188822f, -0.20814352f, -0.05202624f, 
    -0.12021010f, 0.03435009f, 0.06896975f, 0.06850640f, -0.09791861f, 0.08724470f, 0.08637536f, 0.15974161f, 
    -0.01238300f, 0.21241738f, 0.12488195f, -0.00121751f, 0.18442386f, 0.13713120f, 0.05405831f, 0.08646949f, 
    -0.15143944f, -0.22962901f, 0.13673550f, -0.03835682f, -0.14874473f, 0.00544403f, -0.10201222f, 0.07119852f, 
    -0.01811533f, 0.08597820f, 0.09286079f, -0.10275197f, -0.13092965f, 0.06456126f, -0.17906158f, -0.11454403f, 
    -0.17657284f, -0.31287071f, -0.22574681f, 0.21616557f, 0.13869931f, -0.06779064f, -0.14092299f, -0.01770444f, 
    -0.12614599f, -0.04748871f, 0.06636898f, 0.11392841f, -0.08359175f, -0.15069462f, -0.08442052f, 0.00578688f, 
    -0.13612977f, -0.03477901f, -0.14829907f, -0.25713849f, -0.20926365f, 0.35855016f, -0.38965279f, 0.37685329f, 
    0.17538525f, 0.16536190f, -0.01107477f, 0.11298371f, 0.01394337f, -0.10831745f, -0.12518676f, -0.06709051f, 
    -0.05825964f, -0.15038514f, -0.05569626f, 0.21501423f, -0.03597593f, -0.04643970f, 0.20131572f, -0.03564498f, 
    -0.73074263f, 0.24674764f, -0.34371474f, 0.35152158f, -0.45374173f, -0.02958857f, -0.06924161f, -0.06822483f, 
    0.07500460f, 0.07174329f, -0.10687810f, -0.19677283f, -0.09350834f, -0.00943583f, -0.00031341f, 0.05832110f, 
    0.01180969f, 0.03030502f, -0.07706064f, -0.01353735f, 0.17486852f, -0.28314078f, 0.27485889f, -0.08310893f, 
    0.01418720f, 0.04704911f, -0.06825712f, -0.09152346f, -0.01040377f, -0.04266836f, 0.19304131f, 0.02143589f, 
    -0.00784647f, -0.03699259f, 0.08022358f, -0.00056643f, 0.04665826f, -0.03722258f, 0.02390714f, -0.20006266f, 
    0.05450168f, -0.37309134f, 0.10844065f, 0.28463763f, -0.07577768f, 0.21889806f, 0.01156370f, 0.01082772f, 
    0.15250033f, -0.21996395f, 0.01031266f, 0.01005539f, -0.09081567f, 0.00374431f, 0.01663529f, 0.00024412f, 
    0.02459130f, 0.15860651f, 0.19031155f, -0.06525964f, -0.04632805f, -0.49328116f, -0.15085346f, 0.22054724f, 
    0.11942583f, -0.24979715f, -0.34824425f, 0.04023830f, -0.09919778f, 0.02180712f, 0.08361015f, 0.00631171f, 
    0.05359523f, -0.04373462f, -0.08487553f, 0.05605414f, -0.02776651f, 0.04497488f, 0.01868008f, -0.05220298f, 
    0.17145500f, -0.31882456f, 0.47771844f, -0.04214959f, 0.24541718f, 0.14857411f, 0.26597971f, 0.01129781f, 
    0.08023766f, -0.18673895f, 0.07019725f, 0.08598126f, 0.02634395f, 0.02721474f, 0.02756131f, 0.00034482f, 
    0.07464348f, -0.06763401f, 0.01905635f, -0.11955357f, 0.15685752f, 0.14157650f, 0.13685934f, -0.04353369f, 
    -0.03287872f, 0.02256932f, 0.05293844f, 0.11374685f, 0.10539378f, -0.06392272f, -0.09797616f, -0.00650681f, 
    0.04771391f, -0.14015356f, -0.12853651f, 0.10858252f, 0.03476205f, -0.07328998f, -0.10105369f, -0.04675218f, 
    -0.23612759f, -0.04442474f, -0.23993643f, -0.16788466f, 0.08916763f, 0.06794224f, 0.14210412f, 0.16320276f, 
    -0.06441353f, -0.07046814f, -0.05423516f, -0.16037370f, 0.02167822f, 0.18533248f, 0.21001488f, 0.04300343f, 
    0.02181465f, -0.01477589f, -0.00948586f, 0.01272918f, -0.55718118f, -0.19216548f, -0.40030560f, 0.03577552f, 
    0.29116905f, -0.03164817f, 0.24430767f, 0.00296080f, -0.12277261f, 0.00698017f, -0.03471320f, 0.16527762f, 
    0.18940268f, 0.11928135f, 0.14147860f, 0.06941316f, 0.11993257f, 0.04984979f, 0.23531453f, 0.15655933f, 
    -0.33892360f, -0.05484147f, -0.09289830f, 0.11844813f, -0.18609384f, -0.04688030f, 0.00918746f, 0.15330178f, 
    0.04499119f, 0.04763188f, -0.10718527f, 0.10673129f, -0.01447365f, 0.04026326f, -0.08420733f, 0.02068312f, 
    0.06278490f, -0.02514366f, -0.09041399f, -0.14384949f, -0.18588524f, 0.09952649f, 0.18670715f, 0.35057673f, 
    -0.34715635f, -0.03380004f, -0.08929989f, 0.14265618f, -0.05663199f, -0.08255240f, -0.04800842f, -0.03651059f, 
    0.01740837f, 0.08630309f, 0.02957641f, 0.06113257f, -0.05641769f, 0.02553630f, 0.01931235f, -0.22524050f, 
    0.09595155f, 0.15812732f, -0.02497137f, 0.50798911f, -0.24084044f, 0.02586117f, -0.13022844f, 0.06722434f, 
    0.20409775f, -0.20371738f, -0.10379209f, -0.13234465f, -0.23824388f, 0.03704350f, -0.09096373f, 0.15934500f, 
    -0.05834964f, 0.08547696f, -0.01822789f, 0.09987576f, 0.15903477f, -0.41190720f, 0.01649833f, 0.04814407f, 
    0.38329995f, -0.04317486f, 0.03411220f, 0.00171760f, 0.04238473f, -0.08216692f, -0.06535778f, 0.09277433f, 
    -0.09219115f, -0.07597148f, -0.12742910f, -0.02940685f, 0.10974578f, 0.07105301f, -0.06393860f, -0.02488656f, 
    0.21003306f, -0.09322295f, -0.27781036f, 0.38917798f, 0.46538255f, -0.18141513f, 0.39608619f, -0.14301659f, 
    0.14153224f, 0.20176552f, -0.00273134f, 0.18614745f, 0.05049603f, 0.19273089f, 0.09259693f, 0.00983836f, 
    0.05066299f, -0.07713338f, -0.11327220f, -0.10653661f, -0.18115585f, 0.01109185f, -0.21538706f, 0.37077615f, 
    -0.18174240f, -0.03814676f, 0.09214938f, 0.02456554f, -0.01201317f, 0.09750199f, -0.24753626f, -0.04653299f, 
    0.10871234f, 0.01177234f, -0.05584303f, 0.11355077f, 0.08412982f, 0.06683743f, -0.06535900f, -0.22040869f, 
    -0.43536943f, 0.15964602f, -0.38257125f, 0.14446871f, -0.27164435f, 0.06350997f, 0.00767830f, -0.02946437f, 
    -0.06420214f, 0.11554381f, -0.15518622f, -0.03628640f, 0.06691911f, 0.08585933f, -0.13550353f, -0.02007516f, 
    -0.07069736f, -0.04789895f, 0.01742024f, 0.00065295f, 0.78639865f, 0.11286923f, 0.68021429f, -0.32712975f, 
    0.04314661f, 0.17536339f, -0.03315668f, -0.05634182f, 0.23703240f, -0.10363404f, -0.13097003f, -0.04177949f, 
    -0.01033352f, -0.02773137f, -0.18688203f, 0.02982072f, 0.11971867f, -0.05807944f, -0.12386034f, 0.19319567f, 
    -0.09011821f, -0.24884193f, -0.18082936f, -0.08694773f, -0.14612326f, 0.00722709f, -0.38045862f, -0.06758861f, 
    -0.16579409f, -0.08711951f, 0.04567007f, 0.07473268f, 0.02450922f, 0.00218729f, -0.03443673f, 0.05320191f, 
    -0.01862567f, -0.00848803f, 0.07306536f, -0.11791178f, 0.10332386f, -0.56598562f, -0.43344560f, -0.31342325f, 
    0.14312188f, -0.13133001f, -0.23299284f, 0.04641910f, 0.03711811f, -0.15740407f, -0.09253640f, 0.00982853f, 
    0.12388926f, -0.09240419f, 0.00119330f, 0.12959136f, -0.00337524f, -0.05902919f, 0.25265306f, -0.02896022f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18533847f, 0.09102027f, 0.07968739f, -0.13851659f, -0.04510751f, 0.06906318f, 0.00688956f, -0.15629028f, 
    0.09231625f, 0.06013853f, 0.05907807f, 0.01915967f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
