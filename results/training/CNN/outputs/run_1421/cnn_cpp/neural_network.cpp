#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.04010442f, 0.20606136f, 0.02297143f, -0.35993201f, 0.07746240f, 0.46153468f, -0.11369600f, -0.14841290f, 
    0.68980080f, -0.33749443f, -0.40310383f, 0.03526971f, 0.83391988f, 0.00335590f, 0.04933265f, -0.23267040f, 
    -0.22776856f, -0.07613525f, -0.00225452f, 0.04015126f, 0.01519867f, -0.47312981f, -0.54947650f, -0.63535070f, 
    0.03031122f, -0.42892152f, 0.47854823f, 0.36173853f, 0.53450900f, 0.17641221f, -0.24454808f, -0.41793630f, 
    -0.39681944f, 0.39210805f, 0.25349966f, 0.00663291f, 0.03540090f, 0.02002554f, 0.00811177f, 0.66468257f, 
    -0.27772769f, -0.41796538f, 0.30759951f, 0.17141807f, 0.21330905f, -0.53246492f, -0.26582620f, -0.34870470f, 
    -0.22021925f, -0.30673954f, -0.26489389f, -0.04443813f, -0.24988893f, -0.27508584f, 0.14502797f, 0.26362285f, 
    0.04728700f, 0.12017732f, 0.22684895f, 0.48097649f, 0.36331573f, 0.41563711f, -0.62337065f, 0.59099907f, 
    0.55573887f, 0.43635580f, 0.26892713f, 0.27687117f, 0.16005388f, 0.02695090f, -0.25401783f, -0.16348413f, 
    0.59855807f, -0.66394413f, -0.02658192f, 0.41990674f, -0.42043945f, -0.44805336f, -0.17643975f, -0.13949654f, 
    -0.15206142f, 0.07054488f, -0.28463891f, -0.67335546f, -0.40134463f, 0.55079681f, -0.28853258f, 0.31929550f, 
    -0.00463730f, 0.26865366f, -0.07102265f, -0.12730654f, 0.28420153f, 0.79820782f, -0.26345494f, 0.46497375f, 
    -0.10629286f, 0.12888998f, -0.03988044f, 0.48360571f, -0.52862024f, -0.09132615f, 0.05593829f, 0.26341790f, 
    0.49447230f, -0.19520465f, -0.22080180f, -0.35180223f, -0.32773906f, 0.80392349f, -0.31359640f, 0.01762385f, 
    0.17643125f, 0.22185841f, -0.10571657f, 0.37825477f, 0.01993583f, -0.61845660f, 0.25087810f, -0.05142005f, 
    -0.14223550f, -0.50087690f, -0.31116414f, 0.30571812f, 0.42655817f, 0.44032827f, 0.80838716f, 0.28740472f, 
    -0.30580169f, -0.12883863f, -0.00307707f, -0.17610490f, -0.21003015f, 0.31660193f, 0.00747735f, -0.64763409f, 
    0.02742414f, -0.40420091f, -0.07235266f, 0.39235935f, 0.61037242f, 0.15301691f, 0.34344050f, 0.31196624f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00080963f, -0.07075373f, 0.20940904f, 0.00941589f, -0.09921724f, -0.42612872f, -0.06830437f, -0.13576947f, 
    -0.21643588f, 0.27270821f, -0.09271488f, 0.15472886f, 0.04463408f, -0.02283153f, 0.25956184f, 0.14475267f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03391589f, -0.00898078f, -0.30491120f, -0.05599699f, 0.00040891f, 0.09958874f, -0.00204885f, -0.02605379f, 
    -0.22854950f, 0.03594375f, 0.26274747f, -0.00282813f, 0.15955728f, 0.11542338f, 0.06094356f, 0.10514677f, 
    0.29783532f, 0.23592378f, -0.19372249f, -0.15447287f, -0.14320968f, -0.09125761f, -0.13408904f, -0.03270128f, 
    0.14082485f, 0.02222563f, -0.04117716f, -0.06850182f, -0.14025208f, 0.03335354f, -0.07402002f, -0.22679715f, 
    0.03095505f, -0.05033392f, 0.08646895f, 0.14863785f, 0.01056806f, 0.01600303f, 0.01133914f, -0.06887865f, 
    -0.19874814f, 0.17331479f, -0.12877598f, -0.22090681f, 0.09640104f, 0.35003847f, 0.17184587f, -0.15234169f, 
    -0.13419758f, 0.00167616f, -0.25902700f, 0.11513591f, 0.11516608f, 0.04791363f, 0.15842338f, -0.07024005f, 
    0.14813796f, -0.15919203f, -0.00288073f, 0.13547418f, 0.07590996f, -0.05898323f, -0.11236109f, 0.06044874f, 
    -0.28976485f, -0.21465418f, 0.03391398f, 0.03690751f, -0.05969700f, 0.08054191f, -0.11994849f, 0.07600579f, 
    -0.12989707f, -0.15995161f, 0.16320682f, -0.16498759f, -0.05862327f, -0.26818278f, 0.03816726f, 0.18003161f, 
    0.10205241f, 0.00015873f, 0.03672052f, 0.04506121f, 0.04924256f, 0.06103608f, 0.01958690f, 0.00531944f, 
    -0.01655218f, 0.04891535f, 0.03710880f, 0.01501494f, 0.26436570f, 0.06072013f, -0.04545519f, 0.01384026f, 
    0.00282886f, 0.06662883f, 0.01861496f, -0.00744503f, -0.02354522f, -0.07998386f, 0.20260938f, -0.00573319f, 
    0.07563294f, -0.12539175f, 0.11827847f, 0.10717842f, 0.14660740f, -0.06074926f, -0.00324948f, -0.08104558f, 
    0.03255242f, 0.06803682f, 0.01502468f, -0.18055157f, 0.08204775f, 0.01486458f, 0.07368269f, 0.11488321f, 
    -0.15286185f, -0.18425316f, 0.22775966f, 0.11664290f, -0.05175281f, 0.03379685f, -0.10112628f, 0.01696061f, 
    -0.08633695f, -0.02720827f, 0.01506284f, 0.10045777f, -0.04396477f, 0.04683606f, -0.04200025f, 0.20185414f, 
    0.04639553f, -0.11392523f, 0.09354731f, 0.06821226f, -0.20096280f, 0.10277890f, -0.05249041f, 0.05558309f, 
    -0.02528781f, -0.11624014f, 0.22342858f, 0.01284776f, 0.04454391f, -0.14812559f, -0.01679623f, -0.15753010f, 
    0.11311743f, 0.08080288f, 0.00892900f, 0.27010387f, -0.29769725f, -0.04748325f, -0.03897351f, 0.03093019f, 
    0.03664926f, 0.10602859f, -0.00362265f, 0.13998143f, 0.01777457f, -0.04587143f, -0.08083282f, -0.04882238f, 
    -0.09189801f, -0.03109385f, -0.02162828f, -0.00049883f, -0.14713357f, -0.22060814f, 0.04364173f, 0.10248446f, 
    -0.02882163f, 0.02044347f, 0.07387588f, 0.04181273f, -0.01832834f, -0.20318227f, 0.04794247f, -0.01005761f, 
    -0.17905678f, -0.05018071f, 0.09291542f, 0.06800503f, 0.09568755f, 0.09518252f, 0.23616014f, 0.22153015f, 
    -0.10181271f, 0.04967699f, 0.16065376f, 0.01131215f, -0.05157997f, -0.06324507f, -0.06535079f, -0.15898886f, 
    0.19645125f, 0.11671861f, -0.10546380f, 0.01099740f, 0.10112323f, 0.00433482f, 0.06562014f, 0.32034588f, 
    -0.37855011f, -0.00820829f, 0.30189762f, 0.02446324f, -0.04197572f, 0.01865503f, 0.03699714f, 0.06956767f, 
    0.36934906f, -0.16991547f, -0.19814743f, -0.13685194f, -0.03638319f, -0.04198492f, 0.13889769f, -0.03851286f, 
    0.05800753f, -0.05516572f, -0.03566733f, -0.06817479f, -0.08743498f, 0.03370361f, 0.07359213f, -0.01231675f, 
    0.02894618f, 0.02690252f, -0.34920031f, -0.11708168f, -0.18332733f, -0.17938399f, 0.10839895f, 0.03904979f, 
    -0.04646459f, -0.11577688f, -0.02960570f, 0.36237144f, -0.45935938f, -0.00194522f, -0.00802610f, -0.13620967f, 
    0.04374762f, 0.15292822f, 0.09859791f, -0.13707514f, -0.12252797f, -0.66682619f, -0.40433273f, 0.10071088f, 
    -0.05672051f, 0.12754655f, 0.04786656f, 0.00762578f, -0.07401813f, -0.03117310f, 0.19409253f, 0.27235079f, 
    -0.18559586f, 0.03653710f, -0.04704160f, -0.00216011f, 0.03094476f, 0.11792672f, 0.21733531f, -0.34767368f, 
    -0.77314472f, 0.12971941f, 0.17791018f, 0.11996149f, -0.05617671f, 0.00172079f, -0.03989328f, -0.14518377f, 
    -0.41893196f, -0.10242210f, -0.09269204f, 0.07017440f, 0.06224237f, 0.06438806f, 0.04830314f, 0.09121051f, 
    -0.05054750f, 0.38996777f, -0.30923358f, 0.06110238f, -0.15100576f, -0.01333690f, -0.04931229f, 0.11316599f, 
    -0.04425023f, -0.46473590f, -0.30393016f, 0.11913757f, -0.06843983f, 0.00438964f, -0.19826040f, -0.01253435f, 
    -0.11226774f, 0.02987324f, -0.12795344f, 0.24772200f, 0.22780570f, -0.10570578f, -0.09575518f, -0.10423484f, 
    0.08432202f, 0.08354677f, -0.03011289f, 0.15864348f, 0.34462240f, -0.29762480f, 0.08838799f, 0.14387602f, 
    -0.07295484f, 0.05890736f, 0.19064869f, 0.00939598f, -0.01904489f, -0.11776359f, 0.24449320f, 0.04582213f, 
    -0.10167357f, -0.27704278f, 0.08936340f, 0.10752481f, -0.06607053f, -0.27159476f, 0.00949457f, 0.09944310f, 
    -0.07607880f, -0.13343392f, 0.10245962f, 0.11219857f, 0.11173283f, 0.09923794f, -0.05416204f, -0.02281719f, 
    0.22832617f, 0.06594326f, -0.25600395f, 0.02612905f, 0.01053216f, 0.11528304f, 0.04629865f, 0.02193955f, 
    0.19810645f, 0.14849105f, 0.06466747f, -0.31949329f, -0.22509065f, 0.06876189f, 0.05529322f, 0.06758611f, 
    0.16634667f, 0.10248499f, 0.08645741f, -0.05106048f, -0.01019470f, 0.15978041f, -0.13915773f, -0.04051704f, 
    -0.16333234f, -0.36885113f, -0.12950960f, 0.30901891f, 0.05005873f, 0.04158808f, -0.04457826f, -0.01045582f, 
    0.06761722f, -0.02698523f, -0.35359523f, -0.09188628f, 0.34434554f, -0.02538098f, 0.05484303f, -0.28964537f, 
    0.03765457f, -0.02096952f, 0.00670245f, 0.12161049f, -0.36292705f, -0.22532845f, -0.02897841f, -0.04418841f, 
    0.04681138f, -0.17335974f, -0.05037401f, 0.15181465f, -0.15739298f, -0.21333115f, -0.08688421f, 0.11186822f, 
    0.02299983f, 0.17116885f, 0.08366956f, 0.02865241f, -0.01470306f, -0.31186029f, 0.19720998f, 0.19310088f, 
    -0.22174132f, -0.11048678f, 0.02012797f, 0.08339674f, 0.03454073f, 0.00047074f, 0.27261049f, -0.30641189f, 
    0.24849303f, 0.07303067f, 0.04749216f, 0.34070766f, 0.03721061f, 0.02152673f, 0.12016395f, -0.04560497f, 
    -0.04756701f, -0.25683981f, -0.03385612f, -0.04358470f, 0.11858071f, 0.12589283f, 0.00314762f, -0.08176634f, 
    -0.09856577f, 0.07111955f, 0.03936352f, 0.09849664f, 0.09869439f, 0.17209767f, 0.03398592f, -0.06578416f, 
    -0.16714625f, -0.15985903f, 0.20311989f, -0.07144763f, -0.10588472f, 0.01974216f, -0.00317305f, 0.12287820f, 
    -0.07668781f, 0.05060355f, 0.03482599f, 0.02269524f, -0.41071153f, -0.08271802f, -0.02829039f, -0.13512209f, 
    0.11793146f, -0.09963412f, 0.16699301f, 0.21827418f, -0.12745972f, -0.32793984f, 0.09013817f, 0.01846087f, 
    -0.04304134f, -0.04714118f, 0.02545049f, -0.02501083f, 0.17790633f, -0.32345206f, -0.11223058f, -0.07341376f, 
    0.03269618f, -0.13180411f, -0.08001114f, 0.09650532f, -0.18001917f, -0.22158657f, -0.14768805f, 0.17958708f, 
    -0.21937089f, -0.07455808f, 0.06529637f, 0.05919966f, 0.26514801f, 0.18954080f, -0.01056027f, 0.15652265f, 
    0.13557355f, -0.06335580f, -0.04378587f, -0.05069873f, 0.07586045f, 0.05296961f, 0.06165928f, -0.01076912f, 
    -0.05409973f, 0.05970702f, 0.06657241f, 0.02089828f, -0.07105506f, 0.02965205f, -0.07681981f, 0.17284830f, 
    0.09547070f, -0.66925907f, -0.08042984f, -0.12327781f, -0.18573307f, 0.15485053f, 0.07208344f, -0.20871317f, 
    -0.02935253f, 0.08554384f, 0.02574621f, 0.11654431f, 0.12082691f, 0.01758581f, 0.19257571f, 0.11203358f, 
    -0.03030406f, 0.04160010f, -0.00796387f, 0.13358919f, 0.31607527f, -0.14004859f, -0.03102624f, -0.03352359f, 
    -0.14437801f, -0.05703733f, 0.14142926f, 0.07593891f, -0.01456016f, -0.11488564f, -0.06223638f, -0.04415233f, 
    0.08181588f, 0.13669245f, -0.00469878f, 0.05083904f, -0.04719073f, 0.05510784f, 0.11037753f, 0.09911620f, 
    0.03012963f, 0.00381990f, -0.04254410f, -0.06033504f, -0.03876591f, -0.36815083f, 0.16657636f, -0.17482379f, 
    -0.23100129f, 0.02723761f, -0.03708193f, -0.15814012f, -0.22289552f, -0.07315981f, 0.54635900f, -0.25847599f, 
    -0.22515257f, 0.25412208f, 0.23241584f, 0.11098068f, 0.06609138f, 0.09179213f, -0.05432490f, -0.36334637f, 
    0.20484060f, 0.11339823f, 0.07712898f, -0.14341682f, -0.08732697f, 0.00879342f, 0.08646610f, 0.06260588f, 
    -0.00217155f, -0.17895687f, -0.34880599f, -0.07573597f, 0.00665011f, -0.03324265f, 0.01131502f, 0.02044598f, 
    -0.08828264f, -0.64630568f, -0.18983881f, -0.08978916f, -0.03165583f, -0.05335037f, 0.02042986f, -0.04638021f, 
    -0.03311798f, 0.07731345f, 0.11416208f, -0.10151453f, 0.22013232f, 0.00007154f, 0.02778260f, -0.04576543f, 
    -0.03151373f, -0.02858367f, 0.05234203f, 0.19527182f, -0.06377967f, -0.06137826f, -0.11735124f, 0.00385432f, 
    -0.04752310f, -0.10303576f, -0.07141051f, -0.01203007f, -0.13652590f, 0.13981196f, 0.07676271f, 0.01223805f, 
    0.28295109f, -0.19676326f, 0.27838024f, -0.01430370f, -0.02898083f, -0.24199899f, -0.11345981f, 0.22477876f, 
    -0.08458950f, -0.02711832f, -0.07140800f, 0.20704646f, 0.05592160f, 0.16084838f, -0.00395835f, -0.04839732f, 
    -0.03482082f, 0.12427069f, -0.31479096f, -0.18949367f, -0.00554393f, 0.07338671f, 0.00638203f, -0.12350425f, 
    -0.08344005f, 0.02415390f, 0.03931005f, -0.01572325f, 0.03615894f, -0.06990252f, 0.01442468f, 0.00703498f, 
    -0.14173751f, 0.10135739f, 0.26328418f, -0.11461838f, 0.17952089f, 0.03329761f, 0.18248650f, -0.24622209f, 
    0.06075666f, -0.01167075f, -0.04632693f, 0.29902884f, 0.01987242f, 0.26353416f, 0.06717202f, -0.02496063f, 
    0.13916592f, 0.08329668f, 0.00627260f, -0.04418036f, -0.14085272f, -0.00615853f, -0.15561616f, -0.07357896f, 
    -0.03362904f, -0.14802496f, -0.00004131f, -0.05992666f, 0.02068344f, -0.25056079f, 0.05894150f, -0.06083735f, 
    0.05006663f, 0.12589677f, 0.20992583f, 0.19817926f, 0.20572159f, -0.27452835f, -0.37722915f, -0.31816947f, 
    -0.00654886f, -0.14743778f, 0.16234940f, 0.06155575f, 0.18242712f, 0.09246967f, -0.17115942f, 0.01627422f, 
    0.07351705f, -0.02874925f, -0.00023039f, -0.02630370f, -0.19911209f, -0.13219059f, 0.30070910f, 0.16555850f, 
    -0.01983544f, -0.01733479f, -0.02139369f, -0.04354344f, 0.06795431f, 0.05983568f, 0.01597992f, 0.01892758f, 
    0.11268657f, 0.09331877f, -0.07700464f, 0.21076535f, -0.27947539f, 0.00506939f, 0.02857577f, 0.05145238f, 
    0.14014889f, -0.06522891f, 0.05762914f, -0.02238913f, 0.02409763f, 0.11538927f, 0.09246189f, -0.04992446f, 
    0.00908831f, 0.00397135f, 0.02817837f, 0.01049385f, 0.02111113f, 0.03797400f, -0.07857620f, -0.20570499f, 
    -0.35293993f, -0.23838146f, 0.09873163f, 0.16276675f, -0.22184068f, 0.03732335f, 0.19769983f, -0.02079028f, 
    0.08585763f, 0.16860828f, 0.05305161f, -0.06832295f, 0.11704452f, 0.07588173f, 0.15651472f, -0.02984244f, 
    0.13771690f, 0.17429762f, 0.14567655f, 0.09770607f, -0.06393220f, 0.23425433f, -0.02960778f, 0.10603341f, 
    0.06509931f, -0.08993706f, 0.03765528f, 0.25182515f, 0.17136930f, -0.38239270f, -0.11131222f, -0.26650375f, 
    -0.05624813f, 0.05938476f, -0.08101428f, -0.02197699f, 0.05498122f, -0.10123889f, -0.08643396f, -0.18008770f, 
    0.00537659f, 0.10694262f, 0.10313565f, -0.03021600f, -0.11229093f, 0.07924993f, 0.02588822f, -0.13923040f, 
    -0.11419456f, -0.08067302f, 0.07789801f, -0.02145024f, 0.08519880f, -0.07560404f, 0.11375289f, -0.15211435f, 
    -0.06041230f, 0.02681127f, -0.24089363f, -0.08249152f, 0.05977250f, 0.12315512f, -0.06274097f, -0.21041761f, 
    0.02418132f, 0.07212208f, 0.13316412f, 0.17109171f, -0.07475221f, -0.14214674f, 0.22230098f, -0.12398361f, 
    0.25543112f, 0.01564676f, -0.13956034f, -0.10806111f, -0.19006558f, 0.19456182f, 0.13633008f, 0.03033358f, 
    0.19115745f, 0.06576117f, 0.08616112f, 0.07517421f, -0.00581948f, -0.19111697f, 0.02931397f, -0.04251825f, 
    0.01368468f, -0.09472703f, -0.05187273f, -0.20396611f, 0.04738794f, 0.01870014f, -0.05323644f, 0.09905326f, 
    0.07698657f, -0.04922588f, -0.01958714f, 0.07970040f, 0.05354068f, -0.18035187f, -0.03504568f, 0.08027586f, 
    -0.09303369f, -0.06813286f, 0.05279610f, 0.17875636f, 0.16972843f, -0.01579432f, -0.00591445f, -0.21178871f, 
    0.10847975f, 0.13216491f, 0.13971220f, 0.01777065f, 0.00493375f, -0.01639139f, -0.00964618f, 0.09205922f, 
    -0.11954162f, 0.00940573f, 0.18186387f, -0.09278255f, -0.03155114f, 0.06278604f, -0.05385995f, -0.00195111f, 
    -0.00120391f, -0.04498762f, -0.14781432f, 0.02031357f, -0.00634699f, 0.17351329f, -0.08932193f, -0.04157311f, 
    0.14861670f, -0.16635004f, -0.21862715f, 0.13261814f, -0.16055599f, 0.07826799f, -0.06461374f, -0.07557553f, 
    -0.04292848f, -0.01803839f, -0.25768512f, -0.34443316f, -0.05820566f, 0.03191521f, 0.05748132f, 0.04628480f, 
    0.04407446f, 0.07428218f, 0.07401556f, 0.05598221f, -0.42950258f, -0.19328041f, 0.11977343f, 0.18964273f, 
    -0.14363950f, -0.01592216f, 0.10369664f, 0.01876655f, -0.28087264f, -0.19638415f, -0.06363938f, 0.04875268f, 
    -0.10871854f, -0.01580017f, 0.14523697f, 0.17056312f, -0.02237039f, -0.62482733f, -0.03636537f, -0.11068489f, 
    -0.16608809f, -0.05661694f, -0.12785682f, -0.07775173f, 0.03707856f, -0.07648121f, 0.16568922f, 0.17585804f, 
    0.11110777f, -0.10665640f, 0.10140588f, -0.08756161f, 0.03876096f, 0.07778808f, 0.21452491f, 0.08811524f, 
    0.12431680f, 0.07954719f, -0.12276156f, -0.11032202f, -0.20425673f, 0.01420330f, 0.01996172f, 0.04952328f, 
    -0.34628674f, 0.18864955f, -0.10494575f, -0.10732332f, -0.11101617f, -0.00943413f, 0.10926768f, -0.02562045f, 
    0.07770620f, -0.14878361f, -0.03242536f, 0.18483661f, -0.05419532f, 0.13341449f, 0.02990854f, 0.08927285f, 
    0.02326830f, -0.10513495f, -0.14373469f, -0.17984873f, 0.03930776f, -0.04342217f, 0.08671892f, 0.20354004f, 
    -0.06311318f, -0.06881590f, -0.05392264f, -0.16522497f, 0.08300198f, 0.10139394f, -0.10131612f, -0.02882785f, 
    0.11265887f, 0.10219175f, 0.10371994f, 0.02008286f, 0.16209181f, 0.02159428f, 0.04037988f, 0.11370519f, 
    0.00289609f, 0.10949938f, 0.11928030f, -0.07751600f, -0.07307281f, -0.49704081f, -0.23821187f, -0.17841727f, 
    -0.02039434f, -0.05425014f, -0.16466706f, 0.10126890f, 0.00395415f, -0.07813033f, 0.24054626f, 0.14030929f, 
    0.13062881f, 0.16374917f, 0.11290675f, -0.09042728f, -0.08786940f, -0.04048428f, -0.04565646f, -0.22173992f, 
    0.33569506f, 0.27113038f, -0.03124813f, -0.05383621f, 0.06307440f, -0.14118318f, 0.17835803f, 0.02485953f, 
    0.02236875f, 0.07171394f, 0.09469178f, 0.00243136f, -0.02156578f, 0.01734421f, -0.05623633f, 0.21950318f, 
    -0.01209194f, -0.17075925f, -0.61694777f, -0.41283900f, -0.05535934f, -0.08373810f, -0.09504884f, -0.02297122f, 
    -0.17937708f, -0.00690436f, -0.36339250f, 0.04947682f, 0.09704622f, -0.01549755f, 0.14379030f, -0.08397364f, 
    -0.04870181f, 0.06743275f, 0.03864131f, -0.06723315f, -0.04775172f, -0.03782337f, -0.00294257f, -0.05578201f, 
    0.01824873f, 0.02716044f, 0.00093582f, -0.05882633f, 0.10395632f, 0.01355248f, 0.01792773f, 0.04936795f, 
    -0.08593630f, -0.06894688f, 0.21698324f, 0.10935287f, -0.09977121f, 0.07578676f, -0.49422124f, -0.37509894f, 
    -0.26731718f, -0.11806678f, -0.15251297f, 0.04051520f, -0.11107258f, 0.01522177f, 0.30207255f, 0.15915219f, 
    0.01767095f, -0.12183312f, -0.16308047f, -0.06995571f, -0.07448646f, -0.05555472f, 0.04350821f, 0.27742580f, 
    0.12641762f, 0.26809162f, -0.06751427f, -0.01745646f, 0.13496950f, -0.08465938f, 0.03889257f, 0.03606063f, 
    -0.41270453f, -0.38094240f, 0.06042453f, 0.02402069f, 0.10550243f, 0.22802085f, 0.04834491f, 0.09612000f, 
    -0.00828523f, -0.37111813f, -0.09466303f, -0.17046590f, 0.02644056f, -0.07122494f, 0.25358623f, 0.03595029f, 
    0.03809878f, -0.01984601f, 0.13281277f, 0.07339796f, 0.10927519f, -0.16589491f, 0.06797532f, -0.06998858f, 
    -0.02496906f, 0.05956226f, -0.12836730f, 0.17448777f, 0.06488999f, -0.03737314f, 0.05703202f, -0.03736543f, 
    0.08841870f, -0.12006845f, 0.07241396f, 0.05225635f, 0.18187478f, 0.17781185f, -0.02538685f, -0.22040410f, 
    0.00886771f, 0.09379635f, 0.06913687f, -0.17793000f, 0.04428050f, -0.15410617f, -0.11706758f, -0.00068399f, 
    0.01913064f, -0.05240849f, 0.11407601f, 0.02993750f, -0.12642911f, 0.13446802f, 0.26628646f, 0.00588705f, 
    0.00903912f, 0.01174019f, -0.07865913f, 0.17271598f, 0.08363961f, 0.03235435f, 0.01150010f, 0.07485419f, 
    -0.16911019f, -0.37016106f, 0.05905221f, 0.10585114f, -0.03174676f, 0.12637533f, -0.00170860f, -0.14004362f, 
    0.01459279f, -0.12514395f, -0.04366491f, -0.14488713f, -0.03270340f, -0.19162253f, -0.06759872f, 0.12044067f, 
    -0.14797576f, -0.12171777f, -0.03651711f, -0.19008046f, 0.12654129f, -0.00393811f, 0.04348508f, 0.16773389f, 
    0.11735760f, -0.03492410f, 0.05496227f, 0.11507447f, 0.19042367f, -0.03832747f, -0.11210441f, 0.01715712f, 
    -0.16599296f, 0.13169593f, 0.07302846f, 0.00807536f, 0.03473223f, 0.02304478f, -0.08428553f, -0.09987645f, 
    0.02281374f, -0.07814620f, -0.12847587f, -0.07856186f, -0.04171181f, -0.03488233f, -0.06588081f, -0.08519106f, 
    -0.14673717f, 0.00726408f, 0.10588713f, 0.04468013f, 0.04451735f, -0.06883746f, -0.09241471f, 0.03931136f, 
    0.15901540f, -0.10638814f, -0.13139132f, -0.15828237f, -0.07760575f, 0.14880095f, -0.02768902f, 0.01739965f, 
    -0.08349898f, 0.12885019f, -0.14715618f, -0.14154080f, 0.06859170f, 0.07083903f, 0.07185891f, -0.07908966f, 
    -0.15407768f, -0.04865501f, -0.09724884f, -0.11125084f, 0.17751658f, -0.04756310f, 0.11313817f, 0.01231062f, 
    -0.09531431f, 0.13837281f, 0.34164089f, -0.05361475f, -0.05677005f, -0.01847818f, -0.03117329f, 0.05471680f, 
    0.03121893f, 0.07207277f, 0.23775567f, 0.34619623f, 0.04198615f, 0.17096956f, 0.08225143f, 0.02419820f, 
    0.08152330f, 0.10157917f, 0.21206918f, -0.08838765f, -0.00648463f, -0.13533764f, -0.04821890f, -0.18137616f, 
    0.05398738f, -0.08285341f, 0.08499780f, -0.01969766f, 0.09207253f, -0.12916027f, -0.13760523f, 0.14053448f, 
    0.11425172f, 0.16230954f, 0.09965739f, 0.01254561f, 0.12402701f, -0.17142752f, -0.18421032f, -0.09932269f, 
    0.06458383f, -0.11008619f, -0.09320776f, -0.03709853f, 0.23410228f, -0.12836137f, -0.21822433f, 0.06414893f, 
    0.03234459f, -0.05382014f, 0.04746520f, -0.00526419f, -0.18553454f, -0.18109253f, 0.04447513f, 0.41885224f, 
    0.08515660f, -0.10808843f, 0.05686229f, 0.07052671f, 0.06425192f, -0.15193602f, 0.08404041f, 0.06858664f, 
    -0.13980214f, 0.22503917f, -0.19435762f, 0.17269334f, 0.01435548f, 0.09306908f, 0.02453849f, 0.02337198f, 
    0.43261054f, 0.06531613f, 0.23335138f, 0.07713573f, 0.14526278f, -0.09759678f, 0.21786614f, -0.05208097f, 
    0.19699493f, 0.11201901f, 0.30254757f, 0.05351019f, 0.19786038f, -0.08675011f, 0.07030668f, 0.02615549f, 
    -0.04609773f, -0.20530745f, -0.02882720f, 0.08061875f, 0.02580094f, 0.06369200f, -0.00056132f, 0.19928172f, 
    -0.01220940f, -0.01560055f, -0.08015826f, -0.41681978f, -0.09042078f, -0.07977546f, -0.14706025f, -0.12728529f, 
    -0.04631801f, -0.15988536f, 0.06695256f, -0.00528134f, -0.12533003f, 0.24436305f, -0.08274940f, -0.03613668f, 
    -0.10137791f, -0.05208693f, -0.06227431f, -0.01564828f, -0.04687279f, -0.00389942f, 0.05403285f, -0.20981954f, 
    0.00815949f, 0.03708176f, 0.01799988f, -0.18961643f, -0.04001859f, -0.02173935f, -0.02350419f, -0.26733786f, 
    0.12558118f, -0.14720950f, 0.16005701f, 0.15965928f, 0.16372684f, 0.00791832f, -0.07295589f, -0.11297112f, 
    -0.44940248f, -0.38982108f, -0.26434866f, -0.17056882f, -0.15587096f, -0.02048312f, -0.04625189f, -0.22813384f, 
    0.29098544f, -0.01843857f, 0.03648271f, 0.16086681f, 0.14067549f, 0.00623611f, 0.10296922f, -0.04395369f, 
    -0.08126970f, 0.04219655f, 0.15629403f, 0.15253797f, 0.10895720f, 0.07260333f, -0.03774196f, 0.12537117f, 
    -0.00242647f, 0.09365134f, -0.12374978f, -0.16231455f, 0.05863279f, -0.04445717f, -0.03621856f, 0.11435449f, 
    0.04708913f, -0.05286874f, 0.11242992f, 0.12104265f, 0.09708674f, 0.03075460f, 0.13773499f, 0.04429726f, 
    0.04398264f, -0.01032861f, -0.00054376f, -0.10911562f, -0.00706461f, -0.06065392f, 0.25745779f, 0.05420183f, 
    -0.00369824f, 0.12964445f, 0.16680370f, -0.00130930f, -0.10969938f, 0.11320741f, 0.09332693f, 0.05728471f, 
    -0.08212007f, -0.10739556f, 0.01261603f, 0.06975131f, -0.04388755f, 0.10184933f, 0.13067132f, -0.12431791f, 
    0.14734337f, -0.01868402f, -0.00510231f, 0.06468908f, -0.12772286f, 0.00128553f, 0.06771383f, 0.04981578f, 
    0.03922577f, 0.01396543f, 0.09828394f, 0.06197159f, -0.06564031f, 0.07461108f, 0.01602335f, 0.03439057f, 
    -0.29686755f, 0.02222781f, -0.13186894f, 0.04252934f, -0.00797047f, -0.14658767f, -0.12797366f, -0.07396787f, 
    0.06991421f, -0.27440000f, -0.15257254f, 0.11474500f, -0.15961726f, 0.05115002f, -0.29893628f, 0.02070474f, 
    -0.09253602f, 0.06133347f, 0.03093106f, 0.27407375f, 0.33531061f, 0.09953906f, 0.14138165f, -0.13859279f, 
    -0.06339653f, -0.02670833f, -0.02562523f, 0.12904245f, -0.19301708f, -0.03935170f, -0.05816271f, 0.11817363f, 
    0.02216686f, 0.00862466f, 0.07843675f, -0.09741424f, 0.05180234f, -0.44379088f, 0.16474320f, -0.02209791f, 
    0.03145307f, -0.02404384f, 0.10408192f, 0.05319123f, 0.01050060f, 0.07800634f, 0.02045545f, 0.16496859f, 
    -0.08250435f, -0.17488967f, -0.00476722f, 0.23577259f, -0.01860693f, 0.01815714f, -0.07293228f, 0.27426225f, 
    0.03531506f, -0.28946301f, -0.08043138f, -0.09155650f, 0.06141955f, -0.03353558f, -0.06115615f, -0.23819822f, 
    -0.06577171f, 0.31388560f, 0.14251822f, -0.03187667f, 0.07552091f, 0.09911245f, -0.10153311f, 0.08445331f, 
    -0.03045010f, 0.10249195f, 0.08725846f, -0.00145248f, -0.14664352f, 0.01313122f, -0.02262820f, -0.02891467f, 
    -0.03224720f, 0.04011654f, 0.09083780f, 0.32343242f, -0.17428304f, -0.06354935f, -0.14868809f, -0.14148661f, 
    0.09319260f, 0.02674709f, 0.16190343f, 0.34523258f, 0.44297603f, -0.20215619f, -0.10883275f, -0.28613570f, 
    0.04663110f, 0.04256517f, -0.10201952f, -0.17082067f, -0.10223637f, -0.23049305f, 0.13425010f, -0.02693105f, 
    0.10056613f, -0.06516737f, -0.10133274f, 0.17038843f, -0.02043014f, 0.12302558f, -0.22473064f, 0.07384399f, 
    0.14903007f, 0.06364910f, 0.03401488f, 0.01673870f, -0.01326004f, 0.31965962f, 0.14565104f, 0.14232248f, 
    0.01504140f, 0.14570500f, 0.08513536f, -0.00583192f, 0.08675157f, -0.12376722f, -0.19740987f, -0.06045771f, 
    -0.17389517f, 0.14057778f, -0.22328483f, 0.03591524f, 0.08896615f, 0.11350725f, -0.06447344f, 0.07452170f, 
    0.22062072f, -0.18447527f, -0.12340403f, 0.02423179f, -0.02153430f, 0.04666352f, -0.00812786f, 0.00166753f, 
    -0.13018535f, -0.02772380f, 0.00612177f, 0.11967543f, 0.11949688f, 0.16147731f, 0.04684292f, -0.05663809f, 
    -0.14488053f, 0.11579818f, 0.23592590f, -0.00066857f, -0.13552842f, -0.01060213f, -0.06187703f, -0.10725726f, 
    0.18091096f, 0.37127757f, 0.05469879f, 0.02786865f, -0.01037760f, 0.08043298f, 0.09886967f, 0.00621418f, 
    -0.15618597f, -0.01366835f, -0.04733112f, 0.19019040f, 0.20491333f, -0.05712976f, 0.14999823f, 0.06995711f, 
    0.04377571f, 0.02031766f, -0.06925417f, -0.14917071f, 0.08695047f, -0.13614988f, 0.11973943f, 0.04760463f, 
    0.11211915f, 0.13344403f, -0.12478507f, -0.04612061f, -0.11166451f, 0.13565266f, -0.09456706f, -0.13086081f, 
    0.06290359f, 0.03115192f, -0.01107365f, -0.01875352f, -0.05777514f, 0.13273460f, 0.06867769f, -0.12056994f, 
    0.02681307f, 0.14561608f, 0.11135178f, 0.14085132f, -0.09844221f, -0.11796118f, -0.26711106f, 0.07010828f, 
    0.02605420f, 0.01480019f, 0.10099579f, 0.05613058f, 0.04838417f, 0.01760775f, 0.20891653f, 0.01771387f, 
    -0.26422292f, 0.08542462f, -0.11665662f, 0.20995285f, 0.09740980f, -0.12120798f, 0.07485639f, 0.26759508f, 
    -0.01973281f, 0.01785230f, -0.01148675f, -0.05970169f, -0.09006198f, -0.05095708f, -0.05004814f, -0.00242429f, 
    0.00660904f, 0.01628313f, 0.09851590f, 0.02619868f, 0.16088179f, 0.02557346f, 0.07958969f, 0.12339169f, 
    0.00748238f, -0.01880628f, 0.11619651f, -0.11906602f, 0.01017896f, 0.08684018f, 0.08006866f, -0.02238317f, 
    0.02895850f, -0.07736707f, 0.20865645f, 0.10153643f, 0.10711518f, -0.31093282f, -0.10336975f, 0.12303167f, 
    -0.05101340f, 0.05768236f, 0.08625247f, 0.01355549f, -0.11346136f, 0.01077754f, -0.12188483f, -0.10313604f, 
    0.16370493f, 0.01821137f, 0.01132196f, -0.11589671f, -0.14015029f, -0.26544875f, 0.03544230f, -0.03898544f, 
    0.11119522f, 0.01079089f, 0.01083473f, 0.00635349f, 0.17780732f, -0.05902272f, -0.03750354f, -0.23880555f, 
    0.30147591f, 0.06048302f, 0.09573449f, 0.10439069f, -0.06641444f, -0.09240723f, -0.11208741f, -0.24390410f, 
    -0.14139055f, 0.01598271f, -0.12777340f, -0.03678348f, 0.15391082f, -0.16967143f, 0.20228383f, -0.09066896f, 
    0.19462661f, -0.13890024f, -0.08119071f, 0.11912528f, 0.01315801f, -0.19023532f, -0.11518320f, 0.02356657f, 
    -0.20097584f, -0.18517365f, -0.10275340f, 0.17654112f, 0.08937432f, 0.10349090f, 0.22034471f, -0.02202285f, 
    0.10314743f, 0.02217952f, -0.00190794f, -0.31617323f, -0.07952610f, 0.13089564f, -0.04785367f, -0.17075965f, 
    -0.05530715f, -0.07185744f, 0.13191786f, 0.21199855f, -0.02056303f, 0.03006252f, -0.10106725f, 0.16595072f, 
    -0.16517098f, -0.03835673f, 0.14948955f, 0.26276404f, 0.31397155f, -0.14748643f, 0.05777586f, -0.12814271f, 
    -0.12614016f, 0.07257140f, -0.03010133f, 0.17057672f, 0.01494258f, -0.22711642f, -0.12057496f, 0.16884731f, 
    0.09656589f, 0.05477938f, -0.00123151f, -0.23759633f, -0.08329888f, -0.05273048f, -0.01246451f, -0.29616913f, 
    -0.05850086f, 0.09053159f, -0.07537431f, -0.05844159f, 0.06633002f, 0.02174202f, -0.13318676f, -0.01650580f, 
    0.09737803f, 0.08579803f, -0.25666919f, -0.15853620f, 0.23513106f, -0.10696547f, -0.00601425f, -0.15442878f, 
    -0.11641250f, 0.14865264f, -0.00282176f, 0.06161765f, -0.20350802f, 0.15062134f, 0.08249425f, 0.02160159f, 
    0.07799297f, 0.02493696f, -0.13206583f, -0.17042704f, 0.04711865f, 0.01717313f, 0.05085201f, -0.13304907f, 
    -0.06505167f, 0.04493150f, 0.02565846f, 0.01829545f, -0.05653976f, 0.01561345f, -0.00290163f, 0.08728714f, 
    -0.09559220f, -0.01151153f, 0.02482470f, -0.17054138f, -0.06366039f, 0.02603511f, 0.11709556f, 0.03153342f, 
    -0.11927601f, -0.16626668f, 0.14367187f, 0.05687840f, 0.01415952f, 0.15207441f, -0.08603119f, 0.26291725f, 
    0.10512690f, -0.01389640f, 0.11499985f, 0.12033734f, 0.00943101f, 0.00520787f, -0.09329039f, -0.24533378f, 
    -0.09581508f, 0.19675146f, -0.00496384f, 0.02048917f, 0.06836576f, -0.10268094f, 0.22799629f, -0.04025722f, 
    -0.14465742f, -0.18132909f, -0.10141438f, 0.02718564f, -0.07263552f, 0.01213895f, 0.04435605f, 0.10445119f, 
    0.31091926f, -0.29152846f, 0.23267980f, -0.01084030f, -0.07581824f, 0.14566398f, 0.03840179f, 0.01585127f, 
    -0.28161371f, -0.06298373f, -0.12924087f, -0.34747958f, -0.02108927f, -0.01763494f, 0.26606944f, 0.06540404f, 
    0.17180739f, 0.19840844f, 0.08724325f, 0.24568291f, -0.09070552f, 0.03456552f, 0.09435245f, -0.12000337f, 
    0.06979288f, 0.06024069f, -0.00051394f, 0.21889088f, 0.29919612f, 0.00069560f, -0.16852432f, -0.06810184f, 
    0.07997268f, -0.10429965f, -0.04625057f, -0.00330406f, -0.16299154f, 0.20488080f, -0.24970455f, -0.00371527f, 
    -0.05773209f, 0.05737771f, -0.09616850f, 0.00510633f, -0.23085664f, 0.14934559f, -0.12056305f, -0.19554271f, 
    -0.00973822f, -0.03507277f, 0.11724273f, 0.09545533f, -0.27623883f, 0.24174824f, 0.03973443f, 0.41862714f, 
    -0.05386983f, -0.05153475f, 0.12641463f, 0.03959420f, -0.11547647f, -0.00474409f, 0.05523964f, 0.08593876f, 
    0.45937860f, 0.06968116f, -0.18326870f, -0.10388453f, 0.00009167f, -0.08742559f, 0.09253519f, -0.00389186f, 
    0.05711548f, 0.35673907f, -0.19838178f, 0.09461268f, 0.05148052f, 0.16320620f, 0.00400435f, -0.13143586f, 
    0.10747030f, -0.00073407f, -0.06613145f, -0.00839278f, 0.22530864f, 0.12400296f, -0.08177978f, 0.02857716f, 
    0.07928916f, -0.06974061f, -0.14283486f, 0.15761147f, -0.24446762f, 0.16043471f, 0.12184997f, 0.05219536f, 
    0.07529823f, -0.07020694f, -0.25297526f, -0.37803033f, -0.19061393f, 0.04304906f, 0.02221232f, 0.11419543f, 
    -0.00626745f, 0.08048371f, -0.03622086f, 0.15983002f, 0.16033708f, 0.07016952f, -0.02593235f, -0.13215867f, 
    0.06178360f, 0.02776233f, 0.05047673f, -0.08471147f, -0.22184747f, -0.19128437f, -0.04547221f, -0.13293706f, 
    0.14499922f, -0.04192558f, -0.14588901f, 0.07128052f, -0.01575945f, -0.16009195f, -0.10870243f, 0.09282029f, 
    0.31913772f, 0.03522820f, -0.08659087f, 0.04911097f, -0.01110679f, 0.00097327f, -0.00921331f, 0.05709297f, 
    -0.23241661f, -0.16951685f, -0.02429751f, -0.07106759f, 0.16144508f, -0.08033123f, -0.04645117f, -0.16344222f, 
    -0.04249233f, 0.08216573f, 0.07793417f, -0.03831918f, -0.05122466f, -0.01188025f, -0.00920102f, -0.02702190f, 
    0.02150688f, 0.04568468f, 0.06032754f, -0.04517653f, -0.04317344f, -0.01852809f, -0.06445782f, -0.00403105f, 
    0.06023761f, 0.04366869f, 0.02767928f, 0.03082489f, 0.01158834f, -0.07640563f, -0.08501513f, -0.06393044f, 
    -0.05249078f, -0.08269799f, -0.01875849f, -0.03748849f, 0.03205465f, -0.01771158f, -0.02542046f, -0.03715087f, 
    -0.08057863f, -0.07514112f, -0.04740264f, -0.04584169f, 0.04304161f, 0.04183479f, -0.01294179f, -0.05588482f, 
    0.00648177f, 0.00696555f, -0.08423737f, -0.06978917f, 0.05846864f, -0.00448632f, 0.04121467f, 0.06984105f, 
    -0.07976609f, -0.05161699f, 0.03645691f, 0.06296009f, 0.04795801f, -0.07746177f, 0.03721307f, -0.05091006f, 
    -0.03971048f, 0.07305141f, 0.01613575f, -0.03605286f, 0.04200419f, 0.02029315f, 0.04849921f, 0.04390868f, 
    -0.00354941f, -0.04003076f, 0.00770340f, -0.03342163f, 0.05112182f, 0.06772756f, 0.07954317f, -0.00236741f, 
    0.04639751f, -0.08144286f, -0.08505143f, 0.04632290f, -0.06645970f, -0.01380262f, 0.02766160f, 0.00837233f, 
    -0.03114964f, 0.02158402f, 0.05556400f, -0.05340178f, -0.08324571f, 0.05979392f, -0.02449787f, 0.01736733f, 
    -0.01267935f, -0.06178676f, 0.05799532f, -0.02367589f, 0.02161304f, -0.03236068f, -0.01765983f, 0.02119343f, 
    -0.04858208f, -0.07649104f, -0.01052780f, -0.06182332f, -0.04042745f, -0.07814436f, -0.03550334f, 0.03033585f, 
    0.05870889f, 0.02014709f, -0.00189543f, 0.04860493f, -0.05875611f, -0.00534951f, 0.00718670f, -0.02731815f, 
    -0.01362142f, 0.03130803f, -0.03452166f, -0.01812410f, -0.06711221f, -0.08320011f, -0.00670260f, 0.00744516f, 
    0.00214354f, -0.06682601f, 0.00786768f, -0.01711866f, -0.03114348f, -0.01105599f, -0.06397994f, 0.05904418f, 
    0.06531969f, -0.07107896f, -0.04830715f, -0.05268847f, 0.06951871f, -0.07831687f, 0.07594403f, 0.03646756f, 
    -0.08182803f, 0.00792127f, 0.00139949f, -0.06298485f, -0.04135990f, -0.02716712f, 0.03257847f, -0.03497651f, 
    0.01723443f, -0.17044657f, -0.14624502f, 0.10120416f, 0.07912970f, 0.01693112f, 0.08593444f, 0.02053181f, 
    -0.05597455f, 0.23134229f, 0.06250300f, 0.01440051f, -0.01107346f, -0.02202302f, 0.12998292f, -0.27235252f, 
    0.13468967f, -0.00797488f, 0.31134784f, 0.19380270f, 0.11250061f, -0.11839257f, -0.05345169f, -0.05721379f, 
    -0.00727204f, -0.05781100f, -0.02591096f, 0.09472222f, -0.27803484f, 0.02412236f, -0.16974843f, -0.00262206f, 
    -0.03040708f, 0.03883037f, -0.04243315f, -0.09101355f, 0.21092780f, -0.03711645f, -0.17993428f, 0.16361670f, 
    -0.03716150f, -0.03222548f, 0.05757362f, -0.11750624f, 0.07686814f, 0.27195695f, 0.11928035f, 0.22517473f, 
    0.16364971f, 0.01808682f, 0.09143759f, 0.09642280f, -0.15233018f, 0.16374640f, 0.01804812f, -0.00996194f, 
    -0.22693312f, -0.10329404f, -0.05799226f, -0.06480601f, -0.03870317f, -0.08262987f, 0.08145683f, 0.11622841f, 
    -0.20826231f, -0.24236996f, 0.31499320f, -0.01497785f, -0.04951410f, -0.07411071f, 0.02370369f, 0.00527869f, 
    0.11848295f, 0.23087031f, -0.04069405f, -0.02528858f, -0.01267503f, 0.01923497f, -0.09827115f, -0.15842436f, 
    0.07589394f, -0.08421925f, 0.22182553f, -0.01058913f, -0.04998882f, -0.05720668f, 0.03420807f, 0.14295940f, 
    0.07834172f, -0.01348514f, -0.22549999f, -0.03799624f, -0.33935183f, 0.09090231f, -0.15270308f, 0.04782987f, 
    0.03312167f, 0.06391800f, -0.03310198f, 0.21283521f, -0.05580435f, -0.19700474f, 0.09573880f, -0.00363365f, 
    0.07477684f, -0.00726783f, 0.00690195f, 0.02169732f, -0.05406881f, 0.06627310f, -0.58439779f, -0.07156732f, 
    -0.00055653f, 0.18776764f, -0.00167305f, 0.07499794f, -0.01268646f, 0.19086647f, 0.28520909f, 0.21662249f, 
    0.07830980f, -0.08498253f, -0.07037468f, -0.01061067f, 0.02864928f, -0.00097067f, -0.22721829f, 0.23371615f, 
    -0.08313090f, 0.09611361f, -0.00513774f, 0.06878883f, -0.03073571f, 0.07248694f, -0.16302758f, -0.22914185f, 
    -0.38189760f, -0.18977492f, 0.07808123f, 0.04715401f, 0.11989073f, -0.08860205f, 0.03534889f, 0.07633491f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.14138353f, -0.01559830f, 0.02985954f, 0.37887511f, 0.22522356f, 0.06289507f, 0.16712895f, 0.06716608f, 
    0.23208341f, 0.18483019f, -0.07087324f, -0.11538431f, 0.21734984f, 0.08661486f, -0.06672033f, -0.09990345f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15562503f, 0.18924105f, 0.14967129f, -0.38744286f, 0.17361639f, -0.18308277f, -0.12115264f, 0.23996790f, 
    0.14230336f, 0.08755425f, 0.00800694f, 0.23028746f, -0.14424177f, 0.16358192f, -0.05454785f, 0.25784367f, 
    0.06097230f, 0.21822482f, 0.02347348f, -0.38072237f, -0.07601289f, -0.39709553f, -0.61295825f, 0.05291960f, 
    0.40286013f, -0.14508967f, 0.19613782f, 0.15253447f, 0.03259728f, 0.29382697f, 0.09299666f, 0.00800269f, 
    -0.08893759f, 0.20158641f, 0.00630198f, 0.46327695f, -0.03193228f, -0.02218937f, 0.10499106f, 0.16622990f, 
    -0.06898922f, -0.27355281f, -0.02606994f, 0.05600845f, -0.13609610f, -0.18680242f, 0.08299721f, 0.23140298f, 
    0.00836498f, 0.31560552f, -0.10249306f, -0.03015129f, -0.40655032f, -0.31953672f, 0.00948975f, 0.26478812f, 
    0.16140005f, 0.29537004f, -0.09316414f, -0.09216297f, 0.43702656f, -0.18975297f, -0.06317621f, -0.09931535f, 
    0.23674978f, -0.52873999f, -0.48242921f, -0.09689330f, -0.61735451f, -0.16731606f, -0.01420617f, 0.06606507f, 
    -0.38353333f, -0.29468679f, -0.07933399f, 0.26763722f, -0.41191804f, 0.38968846f, 0.12637433f, -0.28503904f, 
    0.14960550f, -0.16448630f, 0.48288521f, 0.08960660f, 0.13343422f, -0.20743683f, -0.18961591f, -0.14527275f, 
    0.12790419f, 0.17956045f, -0.12600978f, -0.08377359f, -0.32969019f, 0.12654781f, 0.17587072f, 0.00146700f, 
    -0.03127154f, -0.12414236f, 0.07865045f, -0.07663271f, 0.17333421f, 0.02941572f, -0.18298085f, -0.23242472f, 
    -0.24391890f, -0.26071128f, 0.15723148f, -0.07428857f, -0.08296221f, -0.24296017f, 0.17671841f, -0.06642158f, 
    -0.14766368f, 0.14800510f, 0.39256734f, -0.15662380f, 0.04790196f, 0.31132561f, 0.01833801f, 0.15696937f, 
    0.13959697f, 0.23403183f, -0.39520147f, -0.38007063f, -0.07168449f, -0.25708234f, -0.07529104f, 0.10134733f, 
    0.04996482f, -0.41971275f, -0.00028374f, -0.25184461f, 0.08676250f, -0.02916596f, -0.08617116f, -0.11194548f, 
    0.31522676f, 0.18584530f, -0.32224751f, 0.26989484f, -0.30638212f, -0.02776929f, 0.10147880f, 0.01578234f, 
    -0.03334004f, -0.19268718f, -0.00398640f, 0.12781011f, -0.13490526f, 0.07336009f, -0.47333315f, 0.09031889f, 
    0.09960250f, 0.31532425f, -0.43739328f, 0.29376253f, -0.00011580f, -0.29763719f, -0.16666651f, -0.02662777f, 
    0.11149527f, 0.37086430f, -0.09489711f, -0.11749425f, 0.34890887f, 0.19108887f, 0.10455910f, -0.06078747f, 
    0.15664116f, -0.10391343f, 0.09501635f, -0.23802403f, 0.33836207f, -0.26805979f, -0.04059926f, 0.33019054f, 
    0.08926952f, -0.41744983f, 0.03391873f, 0.25635281f, 0.34269696f, -0.28378609f, -0.08251386f, -0.19008897f, 
    0.37831530f, -0.08543029f, -0.13969746f, -0.00352444f, -0.36119199f, 0.36449254f, -0.11688982f, 0.15301743f, 
    0.19447407f, 0.33033654f, -0.01357862f, -0.06032417f, -0.12584029f, -0.14680023f, 0.00991412f, 0.29051787f, 
    0.00072187f, 0.24477388f, -0.08865590f, 0.02564951f, -0.05014704f, 0.11268463f, -0.20095362f, -0.05199653f, 
    0.33169258f, 0.38650897f, -0.14173821f, 0.08231390f, -0.08441459f, -0.08117382f, -0.60107738f, -0.20885392f, 
    0.14803319f, 0.02832780f, 0.04297000f, -0.22756101f, 0.09088808f, -0.13360928f, 0.19338159f, 0.33655083f, 
    0.25341418f, 0.38446847f, -0.28735092f, 0.02887714f, 0.03845620f, 0.09733785f, -0.10525052f, 0.27912626f, 
    0.00928705f, -0.18228127f, 0.15194751f, -0.17312877f, -0.13970339f, 0.15513939f, 0.14335711f, 0.41842723f, 
    0.10197010f, 0.48818851f, 0.22361988f, 0.04020997f, -0.03975160f, 0.20586155f, -0.02801898f, -0.23127377f, 
    -0.03181530f, 0.27319011f, 0.01891616f, -0.41425067f, 0.21418798f, -0.51754522f, -0.03691454f, -0.13861279f, 
    -0.12772004f, 0.21786858f, -0.22302800f, -0.40138143f, -0.05179900f, -0.41551059f, -0.62782508f, 0.02235767f, 
    0.23882042f, 0.32586825f, 0.08698647f, 0.01077448f, 0.25358403f, 0.21277699f, -0.22585875f, 0.05780126f, 
    0.30031142f, 0.37188008f, 0.00834301f, 0.17388673f, -0.46627676f, -0.05103665f, 0.07212734f, -0.26991355f, 
    0.27378687f, 0.11857586f, -0.08924815f, -0.01344271f, 0.13341817f, -0.57808977f, -0.09740013f, -0.13791156f, 
    -0.26998639f, 0.01160778f, -0.15015757f, 0.21688521f, -0.15131824f, 0.16748771f, -0.06248401f, 0.42603230f, 
    0.18771404f, 0.15280898f, 0.30875576f, -0.32575822f, 0.27099895f, -0.25288674f, -0.05075175f, -0.17281687f, 
    -0.04169971f, 0.13514529f, 0.25176075f, 0.17115138f, -0.14632741f, 0.17300853f, -0.32731447f, -0.18846855f, 
    -0.03808777f, -0.29932642f, 0.34402198f, 0.16778065f, -0.07022851f, -0.00487437f, -0.22320855f, 0.31010363f, 
    -0.16251455f, 0.33814245f, -0.25190145f, -0.13664484f, -0.06455234f, 0.26039794f, -0.38583934f, 0.17074907f, 
    0.30052844f, 0.23326832f, -0.02965643f, 0.00314064f, 0.28094131f, 0.10837997f, 0.13123736f, 0.10552669f, 
    -0.16971743f, -0.56876546f, 0.05714973f, -0.22779565f, -0.28463563f, 0.35018224f, 0.11152302f, -0.39488533f, 
    0.03018568f, 0.35510752f, 0.19957516f, -0.36396679f, 0.25990823f, 0.18313852f, -0.18979388f, -0.15681578f, 
    0.10477803f, 0.42479432f, 0.05355398f, -0.14813147f, 0.18264575f, 0.32540280f, -0.19302356f, 0.06952910f, 
    -0.07837398f, 0.25196469f, 0.14651537f, -0.39391169f, -0.03821716f, 0.05399667f, -0.14592043f, 0.39912808f, 
    0.27579832f, -0.76407921f, 0.18590276f, 0.08443111f, -0.31630132f, 0.17809889f, 0.08686343f, -0.16184667f, 
    -0.01265570f, 0.26528323f, 0.20986117f, -0.06498815f, -0.31524229f, 0.22627002f, 0.17365065f, -0.04667639f, 
    -0.16467068f, -0.04136255f, -0.19120803f, -0.03589094f, -0.06176975f, 0.07540718f, -0.24770981f, 0.00050169f, 
    -0.23934421f, -0.11050910f, -0.17971650f, -0.11179048f, -0.09977603f, -0.01971644f, -0.11593318f, -0.20028102f, 
    -0.14203079f, -0.20823389f, 0.12204689f, 0.04506882f, -0.01347101f, 0.07484069f, -0.29883495f, -0.42750549f, 
    -0.23346113f, 0.14600819f, 0.17237604f, 0.08360666f, -0.35038921f, 0.35951132f, -0.16755694f, 0.19711839f, 
    -0.33396438f, -0.06840862f, -0.23018673f, 0.29148057f, -0.62029666f, -0.37695149f, -0.23821133f, 0.26509196f, 
    -0.51644927f, -0.31206381f, 0.00463722f, 0.27140599f, 0.28702316f, 0.16863438f, -0.16930833f, -0.21307305f, 
    -0.14245781f, -0.15328287f, 0.30682307f, -0.16639945f, 0.41846126f, 0.00693635f, -0.22102016f, -0.23190832f, 
    0.25898969f, 0.14089638f, 0.02405722f, 0.05642384f, -0.16579618f, 0.25683710f, -0.05874678f, -0.32736224f, 
    0.27366146f, -0.08077630f, -0.27261570f, -0.09854034f, 0.15614948f, 0.09557506f, -0.21948931f, 0.09607456f, 
    0.14068502f, -0.29336584f, 0.43268305f, -0.25261691f, -0.16978595f, 0.35124418f, 0.22644100f, -0.14079720f, 
    0.04008446f, -0.12164015f, 0.21977584f, 0.17589918f, 0.31996104f, 0.26320139f, -0.28198597f, -0.21606481f, 
    -0.28866613f, -0.22821715f, 0.17976233f, -0.20197958f, 0.17340912f, 0.02511574f, 0.11296047f, 0.24062505f, 
    -0.09847085f, -0.15669201f, -0.01259608f, 0.15151270f, 0.13744190f, 0.20775114f, -0.05497029f, -0.39641502f, 
    -0.07543664f, -0.06896682f, 0.20658579f, -0.01167222f, 0.19767159f, 0.23879184f, 0.06837592f, -0.26472926f, 
    -0.11548976f, 0.29943401f, 0.01342968f, -0.05287578f, -0.03946190f, -0.02607755f, 0.03189763f, 0.39014456f, 
    -0.03898863f, 0.29129723f, -0.41335720f, 0.03095675f, 0.15562409f, 0.07344805f, -0.00705239f, -0.08769905f, 
    0.12788263f, 0.10087860f, 0.23038152f, -0.24466799f, -0.24024777f, 0.32122114f, -0.21930848f, -0.19209249f, 
    0.29492998f, 0.26842660f, 0.25571719f, -0.28882578f, 0.32614401f, -0.40196437f, 0.13533838f, -0.20600049f, 
    0.13098502f, 0.23109083f, -0.05321767f, -0.06793515f, 0.27933431f, 0.27122641f, -0.34113646f, -0.14425148f, 
    -0.15049870f, 0.10199206f, -0.12607615f, -0.02222482f, 0.33963224f, 0.15816765f, -0.08095923f, 0.12103147f, 
    -0.26710939f, 0.11795208f, -0.05915518f, -0.15532151f, 0.35385966f, -0.07365751f, -0.24750827f, 0.31284836f, 
    -0.14273471f, -0.24016683f, 0.10373627f, 0.07368024f, 0.28734025f, 0.49437863f, -0.07284757f, 0.26295173f, 
    -0.13186647f, 0.63771164f, -0.24965583f, 0.22094198f, 0.06118466f, -0.16948222f, -0.09438626f, 0.21229137f, 
    -0.19073446f, 0.34262830f, 0.10141910f, -0.26908815f, 0.25790638f, 0.23989594f, 0.17930612f, -0.03859738f, 
    0.11467265f, 0.42955649f, 0.40503180f, 0.36739427f, 0.15888663f, 0.06838053f, -0.02975434f, -0.16271026f, 
    0.18680423f, -0.17479695f, 0.23067977f, -0.14712422f, -0.23428382f, -0.10484518f, 0.15193626f, 0.17310561f, 
    -0.08212314f, 0.09499663f, 0.08090369f, -0.32665980f, -0.12396813f, 0.17364167f, 0.21214396f, 0.12074739f, 
    -0.18028367f, -0.03190164f, 0.49699825f, 0.05227312f, -0.16169076f, 0.06700218f, 0.15945393f, 0.33126256f, 
    -0.11143480f, 0.04899839f, 0.43629852f, 0.15005025f, -0.18615359f, 0.27380189f, -0.09133298f, -0.09788536f, 
    -0.00531644f, 0.01801844f, 0.01492441f, -0.16354258f, 0.14420302f, -0.19591141f, -0.05298689f, 0.13043846f, 
    0.01881647f, -0.21378854f, -0.01358018f, 0.19853146f, 0.07569911f, 0.01124103f, 0.30143324f, -0.06209894f, 
    0.17106932f, -0.22770374f, 0.60892385f, -0.15983652f, 0.12478924f, -0.04095254f, 0.13237792f, -0.07900026f, 
    0.41591427f, -0.21667819f, -0.56570268f, -0.21118145f, -0.12754408f, 0.22512200f, -0.20412239f, 0.06442060f, 
    -0.22338259f, -0.20582625f, -0.01168045f, -0.23460397f, 0.27679789f, -0.40335271f, -0.20091796f, 0.27752480f, 
    0.04921755f, 0.24992138f, -0.46324536f, -0.04038169f, -0.19974281f, 0.25274429f, -0.04520890f, 0.09833828f, 
    -0.18510272f, -0.00279718f, 0.06350124f, 0.22633506f, -0.32991305f, 0.08357090f, 0.22875994f, 0.23496148f, 
    0.20538062f, -0.28971839f, 0.37106583f, 0.29448131f, 0.19619243f, 0.26385844f, -0.17535752f, 0.02257974f, 
    0.23197438f, 0.14409164f, -0.31438494f, -0.19592763f, -0.06747789f, 0.05873445f, 0.09826109f, -0.05945013f, 
    -0.05955939f, 0.03613415f, 0.17816807f, 0.17176366f, 0.05635075f, 0.11509538f, -0.62749863f, -0.45013380f, 
    -0.11210614f, -0.28753561f, -0.05176417f, 0.15223458f, -0.02249164f, 0.31768295f, -0.13610677f, 0.05940353f, 
    -0.43561012f, 0.30424690f, 0.16725068f, 0.32608813f, -0.11096539f, 0.13988279f, -0.29972503f, 0.17869338f, 
    0.19682285f, -0.27545798f, 0.20101263f, -0.14521332f, -0.17245542f, 0.31417999f, -0.21025974f, 0.10555845f, 
    -0.28587642f, -0.00425915f, 0.29794624f, -0.13333003f, 0.31754926f, 0.05528742f, 0.02037831f, -0.15696669f, 
    0.20583670f, 0.07520273f, -0.17726757f, 0.05776051f, -0.05486744f, 0.37297630f, 0.23180930f, -0.24711870f, 
    -0.65041906f, 0.29355022f, 0.08357901f, -0.32289183f, 0.02617217f, 0.00157416f, -0.05463921f, 0.04597805f, 
    0.01006985f, 0.02235562f, 0.23505531f, 0.31933686f, 0.20261593f, 0.11112366f, -0.18272713f, -0.22473852f, 
    0.31191424f, 0.00092819f, -0.16331217f, -0.23618402f, -0.12425939f, -0.22142497f, 0.05317966f, 0.29443190f, 
    0.27080622f, -0.21617337f, -0.16550954f, 0.20018794f, 0.12018284f, -0.17614673f, 0.08227313f, 0.30993870f, 
    0.10310623f, 0.55874455f, 0.20361166f, 0.28842998f, 0.22677428f, 0.11850367f, 0.09332627f, 0.00560157f, 
    0.10027157f, -0.15089788f, 0.12198330f, -0.37198487f, 0.03866124f, 0.03151767f, 0.11537147f, -0.13155609f, 
    -0.15347226f, 0.26165956f, 0.31916341f, -0.11763537f, -0.19326709f, -0.03044729f, -0.37984943f, 0.24245685f, 
    -0.09175795f, 0.21173415f, 0.12458472f, 0.01966190f, -0.15534246f, 0.33819380f, 0.24177989f, 0.03030906f, 
    -0.29486415f, 0.05093981f, 0.31951690f, 0.16076945f, 0.11195795f, -0.00574528f, 0.21827073f, 0.08423552f, 
    0.10811182f, 0.03324688f, 0.03873722f, -0.06740604f, 0.22240692f, 0.04331832f, 0.14792670f, -0.23998754f, 
    -0.22859719f, -0.31011146f, 0.01910940f, -0.37074989f, 0.48074007f, -0.09754069f, -0.28852051f, 0.14807384f, 
    0.23477179f, -0.01924480f, 0.42042261f, -0.19868027f, 0.10676167f, 0.19297585f, -0.14075410f, 0.33224866f, 
    -0.13925405f, 0.04285115f, -0.21403611f, -0.12351891f, 0.05560485f, -0.10821078f, 0.13448247f, -0.13642296f, 
    0.05792543f, -0.18773192f, -0.15455192f, -0.06231949f, -0.06277013f, 0.06134448f, -0.12347189f, -0.19673252f, 
    -0.11778715f, -0.17731684f, 0.27612346f, 0.00546767f, 0.21771364f, -0.13048889f, -0.35660851f, -0.49506956f, 
    0.38247189f, -0.09161470f, 0.31705928f, -0.09531107f, 0.17484522f, 0.32619056f, 0.21087220f, -0.06676708f, 
    0.10074710f, 0.23984542f, 0.49693558f, 0.21296561f, -0.10459565f, 0.25171798f, -0.14902157f, 0.07287209f, 
    -0.08504949f, 0.03887548f, 0.02282757f, -0.30547196f, 0.00699361f, 0.06040139f, 0.15871969f, -0.09549115f, 
    -0.26075965f, 0.07404061f, -0.13277498f, 0.22792490f, -0.79511327f, -0.08805802f, 0.10403428f, 0.29707175f, 
    -0.44547251f, -0.30049801f, -0.20656763f, -0.12049477f, -0.14357451f, 0.12508349f, -0.06907484f, -0.44782162f, 
    0.22163107f, -0.05848246f, -0.20705557f, -0.12423321f, 0.26674545f, -0.19568217f, 0.28094348f, -0.55749023f, 
    0.06144820f, 0.22034664f, 0.15124637f, 0.26188576f, 0.00683160f, -0.25391525f, -0.15174934f, 0.00228056f, 
    -0.23418391f, 0.08955168f, -0.46640334f, 0.17272791f, 0.35744137f, 0.04257844f, 0.09815037f, -0.24978061f, 
    0.33336854f, -0.21305554f, -0.24773113f, -0.02419392f, 0.08759844f, 0.15724318f, 0.08766009f, -0.09523855f, 
    0.25159571f, -0.23534049f, 0.34899098f, 0.36385790f, 0.26842421f, -0.29195482f, 0.07500489f, -0.32166055f, 
    0.20872326f, -0.03995504f, 0.19614282f, 0.23162392f, -0.32045642f, 0.08017337f, 0.15241212f, -0.06956340f, 
    -0.11967477f, -0.12485206f, -0.09656374f, 0.41734833f, 0.29122853f, 0.02276278f, 0.08831950f, 0.08977082f, 
    0.08912366f, 0.13102342f, 0.21249694f, -0.54983824f, 0.15315694f, -0.22161600f, 0.08663678f, 0.02624529f, 
    -0.11110112f, 0.39913073f, 0.33942416f, -0.34618372f, 0.02903190f, 0.27714896f, 0.13297127f, 0.13613819f, 
    0.04690285f, 0.20505086f, -0.15133877f, -0.34850734f, 0.09578599f, 0.26477402f, -0.12601924f, -0.08665910f, 
    -0.14360490f, -0.09018331f, 0.26753515f, -0.35989809f, 0.15899120f, -0.11864057f, 0.24550760f, 0.33410171f, 
    -0.10904178f, 0.28844291f, 0.08944362f, -0.25018346f, 0.11978496f, 0.37496710f, -0.08116186f, -0.16384946f, 
    -0.18244053f, 0.12675402f, -0.29100627f, -0.46154869f, 0.03536763f, 0.06860973f, 0.03340839f, 0.17930159f, 
    0.21644247f, 0.29728630f, 0.22552259f, -0.12098695f, 0.25782123f, -0.12173156f, 0.10417533f, -0.10531421f, 
    -0.18214983f, 0.21114996f, -0.22991402f, 0.49837077f, -0.10329582f, -0.21570335f, 0.16902909f, -0.23195985f, 
    0.13701904f, 0.02046542f, -0.31933278f, 0.17985362f, 0.22990349f, 0.15100351f, 0.21235418f, -0.22893639f, 
    0.12795450f, -0.17447287f, 0.16918877f, 0.05807494f, 0.27742240f, -0.04005631f, 0.11704937f, 0.24981490f, 
    0.17125839f, 0.03763507f, 0.37648395f, -0.41066578f, -0.27041882f, -0.15693858f, -0.01481837f, -0.30279681f, 
    -0.10176386f, 0.11053925f, -0.21096250f, -0.10291006f, 0.39138517f, -0.06555367f, 0.39575419f, -0.56342596f, 
    0.20564187f, 0.40974021f, -0.11698914f, -0.27222827f, 0.19164494f, -0.22340369f, 0.00925562f, 0.05324074f, 
    0.04546804f, -0.27511790f, -0.06362039f, 0.23547994f, -0.28817856f, -0.16623363f, -0.35139510f, -0.26795605f, 
    0.26976305f, 0.27900624f, 0.17409474f, 0.19005197f, 0.02167075f, -0.08811553f, -0.11110929f, 0.26001799f, 
    -0.24341957f, -0.18042727f, 0.16000953f, 0.17160922f, 0.27236241f, 0.20617934f, 0.31383789f, 0.05440221f, 
    -0.10458338f, 0.28188106f, -0.05046966f, -0.16070308f, 0.03766157f, 0.16612355f, -0.05880626f, -0.13961805f, 
    -0.10543936f, -0.10508772f, -0.24920335f, 0.46721378f, -0.08121912f, -0.11885227f, 0.34226596f, -0.05531596f, 
    0.23415494f, -0.10662639f, 0.12213146f, -0.12214255f, 0.35727194f, 0.33019698f, 0.20146760f, -0.39948454f, 
    -0.54695952f, -0.00604874f, 0.14132062f, 0.29213208f, -0.09339560f, -0.33262828f, -0.03388202f, 0.29043162f, 
    0.35279289f, -0.09874722f, -0.33197191f, -0.01936408f, -0.48223934f, -0.01945269f, 0.03181407f, -0.19845881f, 
    -0.19273926f, 0.22650312f, -0.25265902f, -0.16621996f, 0.04021047f, -0.13929310f, -0.20243096f, 0.18596579f, 
    -0.21050361f, -0.15383069f, 0.07162005f, -0.03016164f, -0.00182536f, -0.03881250f, -0.10429356f, 0.25680262f, 
    0.06162646f, -0.24969435f, -0.25352976f, -0.22808406f, -0.17263669f, -0.07644686f, -0.03755283f, 0.17269920f, 
    -0.12903884f, -0.27527589f, -0.22129661f, -0.06847258f, 0.12255881f, 0.09708467f, -0.05674270f, -0.07495795f, 
    0.03917519f, -0.05885474f, 0.24728236f, -0.20614822f, -0.14243606f, 0.00546330f, 0.18193838f, -0.08822609f, 
    -0.00243583f, 0.07912708f, -0.03548057f, -0.07586800f, 0.28639954f, -0.19570091f, -0.05231100f, -0.03211913f, 
    -0.01108160f, -0.24538803f, 0.29811516f, -0.10617742f, 0.38043624f, 0.12156848f, -0.02032677f, -0.53418821f, 
    -0.04537712f, 0.00426876f, 0.38282466f, -0.24978293f, 0.38365269f, -0.09620062f, -0.22861499f, -0.10588175f, 
    0.27765632f, 0.21012108f, -0.15376233f, -0.67784989f, 0.18285075f, -0.26926503f, -0.80766952f, -0.35380840f, 
    -0.17696957f, 0.26045167f, -0.08801550f, 0.00991008f, 0.06495246f, 0.18298724f, -0.24036950f, 0.30352935f, 
    0.05561866f, -0.34785387f, -0.38688916f, -0.08222037f, 0.36370695f, -0.16254224f, 0.16270830f, -0.05973994f, 
    0.38393480f, 0.23209552f, -0.36709169f, -0.08815985f, -0.25824064f, -0.03990515f, -0.21144733f, 0.13547441f, 
    0.07532243f, 0.44368511f, -0.26861936f, -0.07176210f, 0.22563030f, 0.02858734f, 0.06482092f, 0.18353465f, 
    -0.18659604f, -0.08403538f, 0.27668265f, 0.03405360f, 0.06980567f, 0.26100561f, -0.11118870f, -0.12287550f, 
    -0.09547079f, -0.05545458f, -0.11216795f, -0.16554886f, 0.13714421f, -0.15545830f, 0.22320887f, -0.11298174f, 
    -0.12007269f, -0.18999892f, 0.14714789f, 0.04185006f, -0.12015700f, -0.01224971f, 0.13555053f, -0.07025188f, 
    0.23562582f, -0.47740519f, -0.25658897f, -0.18480480f, 0.06393193f, -0.18176748f, 0.24792829f, -0.51240146f, 
    0.13077876f, 0.13598567f, 0.37534043f, 0.12569478f, 0.30681819f, 0.08488742f, 0.22212887f, -0.27787051f, 
    0.10257493f, -0.32646450f, -0.29409286f, 0.01740476f, 0.25944185f, 0.02160825f, 0.16866702f, -0.33733916f, 
    0.04147583f, 0.08482487f, -0.45645398f, 0.12364616f, 0.16460402f, -0.19931398f, 0.22079948f, 0.12957115f, 
    -0.33958924f, -0.37099513f, 0.29957283f, -0.12392730f, 0.11091463f, 0.26152274f, 0.00922117f, -0.14602184f, 
    0.24028870f, 0.35086030f, -0.33483273f, -0.20660488f, 0.27343589f, 0.05209034f, -0.21064252f, -0.03789174f, 
    -0.28598645f, 0.53300220f, -0.00221506f, 0.12959129f, -0.10188925f, -0.14154278f, -0.20858444f, 0.27859309f, 
    -0.22523229f, 0.20169935f, 0.38355497f, -0.25377631f, 0.19553356f, 0.13853824f, 0.08157763f, -0.08454869f, 
    -0.23051529f, 0.17459005f, 0.37616462f, -0.41396528f, 0.27885756f, -0.01956339f, -0.04990205f, 0.34125626f, 
    -0.22976547f, 0.38277197f, 0.34359154f, -0.25556746f, 0.15526378f, 0.04972427f, 0.14575815f, 0.22247365f, 
    0.24179648f, -0.25163382f, 0.18516538f, -0.37171450f, -0.21242276f, -0.29938430f, -0.04730550f, 0.32024217f, 
    0.00092421f, 0.22733939f, 0.09466132f, 0.17408365f, -0.22249071f, -0.10048328f, -0.13873424f, 0.22000274f, 
    -0.01268674f, -0.35908338f, 0.06011245f, -0.02833264f, -0.05825528f, -0.12207179f, 0.23039505f, -0.01009741f, 
    -0.14121123f, -0.06890187f, 0.25851232f, -0.04026879f, -0.04679038f, -0.02324163f, -0.16588123f, -0.03522770f, 
    0.23944393f, -0.24607651f, 0.18982774f, -0.07642193f, -0.04871260f, -0.10530541f, 0.31731099f, -0.35171178f, 
    0.21018000f, 0.07389524f, 0.17155674f, 0.15837154f, -0.14431936f, -0.21755792f, -0.02665414f, -0.22345871f, 
    -0.18274540f, 0.13963379f, -0.18649320f, -0.18307132f, 0.03761487f, -0.09023305f, -0.00605607f, 0.16932094f, 
    -0.17160325f, -0.14126073f, 0.30441073f, -0.00703583f, 0.01018344f, 0.01277674f, -0.18249100f, 0.28238940f, 
    0.17142145f, 0.21918786f, -0.12454853f, -0.12687223f, 0.14633033f, 0.19021136f, 0.30789647f, -0.11087672f, 
    0.08341665f, 0.04968167f, -0.34632361f, -0.16586921f, -0.07725787f, -0.60723025f, -0.03690167f, 0.21280010f, 
    -0.23535730f, 0.37698951f, 0.33633164f, 0.04123604f, 0.45085832f, -0.28113231f, 0.26767588f, -0.13589372f, 
    -0.05352243f, -0.15443881f, 0.03479854f, 0.26370746f, -0.37971184f, 0.03943467f, -0.19864519f, 0.40522793f, 
    0.04859779f, 0.25350279f, -0.32960632f, -0.49020287f, -0.50031400f, 0.14052585f, -0.03772139f, -0.15955113f, 
    -0.24907362f, 0.27799052f, 0.02229562f, -0.05081463f, -0.00045202f, 0.05284950f, 0.14700437f, 0.32152471f, 
    0.23795779f, -0.13219321f, -0.09491739f, -0.10455717f, -0.16528308f, 0.18539149f, -0.11167333f, 0.05142666f, 
    -0.01733529f, 0.00429564f, -0.23452792f, 0.21466804f, -0.24849154f, -0.26737431f, -0.14965750f, 0.45650205f, 
    0.10665701f, 0.30564848f, -0.23302589f, 0.07007629f, -0.28309062f, -0.10340740f, 0.17085330f, 0.19956450f, 
    -0.66126508f, -0.32256058f, -0.21172807f, 0.17410897f, -0.07449218f, 0.07633653f, 0.14441380f, 0.34378761f, 
    0.04327647f, -0.33584034f, 0.00751441f, -0.06499160f, 0.18417986f, 0.24447860f, -0.19301710f, -0.15779980f, 
    -0.02840949f, -0.03217317f, -0.24439536f, -0.05967103f, -0.28756937f, 0.61443591f, 0.03761069f, 0.07143505f, 
    -0.48158225f, -0.11405694f, 0.32390857f, -0.15164931f, 0.12628278f, 0.01198119f, 0.25553307f, 0.09944215f, 
    0.03780548f, 0.13431737f, -0.00300054f, 0.07881773f, 0.05551258f, 0.28351557f, -0.11344759f, -0.11948564f, 
    0.06027912f, -0.27729836f, -0.29498553f, -0.54125690f, 0.36311939f, -0.05525052f, 0.47627723f, -0.62495172f, 
    0.30540666f, -0.16635530f, -0.29742068f, -0.03673230f, 0.30575353f, -0.14918289f, 0.18376052f, 0.24836709f, 
    -0.20653453f, 0.12613311f, 0.04153312f, 0.14428680f, 0.30499807f, 0.04325247f, -0.27732092f, 0.24874252f, 
    0.00119519f, -0.13522342f, -0.23906584f, 0.11243320f, 0.48115319f, -0.21542405f, -0.08288303f, -0.42538738f, 
    0.37545711f, -0.12366275f, 0.12606031f, -0.37351853f, 0.25810724f, -0.06614564f, -0.18388610f, 0.30855617f, 
    0.29380238f, -0.12313529f, -0.36444053f, -0.21681727f, -0.02447208f, -0.03042134f, -0.18038692f, 0.41552699f, 
    -0.03501885f, 0.04741144f, 0.42604402f, 0.29867136f, -0.04512691f, -0.19810340f, -0.19944824f, 0.16534066f, 
    -0.10681808f, -0.06851371f, 0.04380921f, -0.12558736f, -0.13546953f, 0.48309702f, 0.09193879f, 0.30345693f, 
    -0.41991314f, -0.05770035f, -0.19370365f, -0.17535637f, -0.52652460f, -0.08123425f, -0.01971687f, 0.25801536f, 
    -0.37912604f, -0.24013591f, -0.10841849f, -0.04129982f, -0.07693642f, 0.23484422f, -0.20542699f, -0.45361349f, 
    0.13236056f, -0.48783466f, 0.18695273f, 0.20180188f, 0.29762891f, -0.11961804f, 0.00983658f, -0.44889012f, 
    0.28071713f, -0.06601920f, 0.04273362f, -0.22771718f, -0.24233837f, 0.21569653f, -0.02723306f, -0.00073811f, 
    -0.16116683f, 0.03829485f, -0.34109440f, 0.47040418f, 0.04160262f, -0.30678350f, 0.33294603f, -0.22901545f, 
    0.16014135f, 0.13803323f, 0.27324709f, -0.07819629f, 0.14454962f, 0.11841345f, -0.00716596f, 0.06449632f, 
    -0.08841992f, 0.03536841f, -0.23022515f, -0.13683191f, -0.05400840f, 0.08506234f, -0.25648186f, -0.24234542f, 
    0.06542803f, -0.22873685f, -0.05185758f, 0.06290424f, 0.08036388f, -0.06232557f, 0.14359030f, -0.28981739f, 
    -0.12541518f, 0.28178236f, 0.27771360f, 0.06583014f, -0.11698565f, 0.26527908f, 0.08547834f, 0.21295762f, 
    -0.11462091f, -0.13652118f, -0.46308395f, -0.25967610f, 0.20413706f, 0.24360442f, -0.20549008f, 0.25691155f, 
    -0.03015394f, -0.20969515f, 0.50661999f, -0.50057524f, 0.39252573f, -0.02896230f, -0.43163395f, -0.02475948f, 
    0.30074129f, 0.19037142f, 0.36894158f, 0.00787118f, -0.16595194f, -0.09777433f, -0.20611140f, -0.19643760f, 
    0.11328384f, -0.36706647f, 0.09176295f, -0.07800481f, 0.22726789f, 0.30884200f, -0.24652019f, -0.37189579f, 
    0.13948283f, 0.21366610f, 0.21257491f, -0.10718445f, 0.29890564f, -0.09668745f, 0.02562228f, -0.24933071f, 
    0.04504746f, -0.34228614f, -0.20331439f, 0.23434286f, -0.31418020f, 0.15205793f, 0.02189892f, -0.21871017f, 
    -0.13742459f, 0.25293371f, -0.40165079f, 0.01845825f, 0.28626522f, 0.17922382f, -0.05681506f, 0.16128223f, 
    -0.10587385f, -0.06794087f, 0.00608182f, -0.41476774f, -0.25419131f, 0.32691112f, 0.09032533f, 0.26054287f, 
    -0.27387002f, 0.15460226f, 0.12331428f, -0.15351152f, 0.27975583f, 0.32825607f, -0.21297342f, 0.35408756f, 
    0.30041975f, 0.33780527f, 0.05625467f, 0.25781158f, -0.09441955f, -0.26773000f, -0.23440595f, -0.43790761f, 
    -0.01890762f, 0.35942480f, 0.04222595f, 0.12582587f, 0.27980226f, -0.34669548f, -0.18579908f, 0.18485609f, 
    0.21061875f, -0.26388532f, 0.03928445f, 0.28315520f, 0.15943974f, -0.34770370f, -0.16069628f, -0.44879198f, 
    -0.01156185f, -0.07211550f, 0.22321597f, 0.28347251f, 0.01361153f, 0.12815005f, -0.05878215f, -0.13440026f, 
    -0.09022523f, 0.39081204f, 0.29546857f, 0.09474114f, -0.15800527f, 0.13821860f, 0.13956891f, 0.05724660f, 
    -0.04623782f, 0.22626621f, 0.04891600f, -0.39802727f, 0.00094037f, 0.10856175f, 0.18355568f, -0.06076910f, 
    0.14149550f, -0.16330446f, -0.32023874f, -0.19213688f, 0.14720671f, -0.20290893f, 0.03691660f, -0.21252495f, 
    -0.06764376f, -0.23636246f, 0.09511932f, 0.31450176f, 0.23689881f, 0.36078346f, 0.03144052f, 0.29066792f, 
    -0.21208604f, 0.12975053f, -0.07598747f, -0.13134399f, -0.36455509f, -0.04044202f, 0.14044222f, 0.05119638f, 
    -0.13757725f, 0.23618641f, 0.42954201f, -0.21279900f, 0.23367898f, 0.12485404f, 0.06765759f, -0.07444122f, 
    0.03349635f, 0.01964222f, -0.24874777f, -0.18933097f, -0.02244174f, -0.14827797f, -0.17627093f, 0.20584242f, 
    0.18306032f, -0.00849033f, -0.01310203f, 0.20534603f, -0.16806220f, 0.17387635f, 0.19789466f, 0.34400418f, 
    0.09350107f, -0.00987898f, -0.03924732f, 0.11641216f, 0.13617323f, 0.23718488f, 0.39388904f, -0.01936568f, 
    -0.17841750f, 0.10235029f, -0.27510104f, 0.02166823f, -0.10015238f, -0.19097270f, 0.04165440f, -0.02773337f, 
    -0.13489664f, -0.18152502f, -0.02820519f, -0.04330127f, 0.06407078f, -0.00664099f, -0.26725134f, 0.08955129f, 
    -0.07826707f, -0.05723938f, -0.20488559f, -0.01609607f, 0.02712221f, -0.11195444f, -0.10499951f, -0.02957361f, 
    0.11639033f, -0.00062953f, 0.44887573f, -0.02885601f, 0.35414249f, -0.25541633f, 0.06123171f, 0.29422149f, 
    -0.06660996f, -0.17053631f, 0.27800262f, -0.00665068f, -0.22915690f, -0.09748960f, 0.09132491f, -0.14555258f, 
    -0.02270326f, 0.28053400f, -0.33361909f, -0.24379867f, -0.03411226f, 0.33431509f, 0.18393497f, -0.06217710f, 
    -0.01932191f, 0.17309465f, -0.42730999f, 0.08943416f, 0.33638713f, -0.07214445f, -0.19055007f, -0.09161472f, 
    0.37457761f, -0.39618298f, -0.28338736f, 0.23399568f, -0.19529909f, 0.22839507f, 0.36459407f, -0.15971154f, 
    -0.24734692f, -0.33398291f, 0.05870308f, -0.14269972f, 0.37046206f, -0.51784539f, 0.20159101f, -0.92914152f, 
    0.03720405f, -0.10949200f, -0.08444630f, 0.11939029f, 0.02629587f, -0.13019069f, 0.05877712f, -0.21749486f, 
    -0.16426018f, -0.17493416f, -0.09072284f, -0.09789485f, 0.05711038f, -0.19391464f, -0.08277848f, 0.04204339f, 
    -0.07634725f, -0.22578181f, 0.20908329f, 0.23183720f, 0.27356818f, -0.32071730f, -0.38343665f, -0.11662772f, 
    0.27800271f, -0.24629405f, -0.13498713f, 0.15607803f, 0.25317913f, 0.05604308f, 0.12545317f, 0.20408046f, 
    0.14218165f, 0.26625800f, -0.25938073f, -0.25877732f, 0.08014339f, 0.01197627f, -0.19754317f, 0.18898128f, 
    0.21471807f, -0.21114968f, 0.31584007f, -0.09781467f, -0.06355508f, 0.33106652f, 0.09531794f, 0.45547777f, 
    0.01215224f, 0.13900590f, -0.26688311f, -0.10606650f, 0.02651393f, -0.18566099f, -0.19044115f, -0.00127125f, 
    -0.00539857f, -0.07018635f, -0.15409204f, 0.11171870f, -0.01123929f, -0.13736881f, -0.10104993f, -0.20226476f, 
    0.31265157f, -0.17535792f, -0.16181484f, 0.31163591f, -0.48980021f, -0.18435074f, -0.24141313f, -0.27925470f, 
    0.05629868f, 0.10783240f, 0.03241722f, 0.04695875f, 0.25220963f, -0.24667601f, -0.21417192f, 0.23310541f, 
    -0.13402696f, 0.12160540f, 0.02765754f, -0.22949789f, 0.11599135f, 0.00848575f, -0.20611681f, -0.08509508f, 
    0.32342181f, 0.14430861f, -0.35278094f, 0.30551124f, -0.15741460f, 0.10221726f, -0.14820631f, -0.25610584f, 
    -0.17685422f, -0.03932227f, 0.24564229f, -0.04492829f, 0.49550775f, -0.18059438f, -0.14793032f, -0.61316592f, 
    0.14534312f, 0.06658333f, 0.11486928f, 0.32440266f, -0.00647562f, 0.18722464f, -0.18496533f, -0.22503813f, 
    -0.09899294f, 0.06394362f, 0.23231946f, -0.16002172f, -0.01204093f, 0.11822537f, -0.13903956f, -0.45596936f, 
    -0.05240734f, -0.21709701f, 0.46040803f, 0.12474551f, 0.14549927f, 0.29121587f, -0.18077201f, -0.16808267f, 
    -0.18195933f, 0.11059432f, 0.05813664f, 0.08386964f, -0.44336417f, 0.00305828f, 0.12110422f, -0.26376399f, 
    -0.05243428f, -0.10660068f, 0.29010421f, 0.15093321f, 0.07896114f, -0.09417363f, -0.21775837f, 0.34282196f, 
    0.16882382f, -0.00126151f, -0.10408293f, 0.28441486f, -0.00823209f, -0.18532979f, -0.03943516f, -0.31980982f, 
    -0.23470148f, -0.29648608f, 0.47700459f, 0.31972533f, 0.22492799f, -0.03308708f, 0.07905981f, 0.01711570f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.24252583f, 0.11600346f, 0.27989301f, 0.05981982f, 0.12898189f, 0.15028532f, 0.00446642f, 0.25795305f, 
    0.22740626f, 0.08407294f, 0.20829220f, 0.39387548f, -0.33320028f, -0.03230711f, -0.11439829f, 0.04536122f, 
    -0.01726252f, -0.11702135f, 0.25183919f, 0.13335967f, -0.15882967f, 0.13317412f, -0.03683449f, -0.39155281f, 
    0.07833183f, 0.29338345f, 0.07171321f, 0.25552991f, 0.04196529f, 0.00573386f, 0.48111871f, -0.07373197f, 
    0.14051540f, -0.12121816f, 0.16919228f, 0.07795038f, -0.13593331f, -0.41606364f, 0.02961870f, -0.15173428f, 
    0.36667898f, -0.38434538f, -0.04395584f, 0.07782721f, 0.04583657f, 0.38538080f, -0.09249648f, 0.10541385f, 
    -0.16873407f, -0.03157267f, 0.06103551f, -0.02290577f, -0.04344827f, 0.10263375f, 0.34304717f, 0.14936855f, 
    0.34932563f, 0.55966479f, -0.20702949f, 0.22485028f, -0.33150259f, -0.17872390f, 0.23559175f, 0.47758180f, 
    -0.03116596f, 0.24811549f, -0.02237588f, 0.24160160f, 0.35036635f, 0.05113528f, 0.12042020f, -0.11762026f, 
    0.01428900f, 0.42473653f, -0.30522302f, 0.36211154f, -0.35703424f, -0.11527899f, 0.37303677f, 0.27658001f, 
    0.14104940f, 0.19122033f, -0.12285434f, 0.12020370f, 0.31337553f, 0.38196445f, 0.27877599f, -0.00787412f, 
    -0.04915158f, -0.26036522f, -0.22949292f, -0.07127862f, 0.24725598f, -0.07249150f, 0.29730201f, 0.03423893f, 
    0.24092580f, -0.13193206f, -0.05570122f, 0.46875316f, 0.10036355f, -0.03802802f, -0.15131634f, -0.29065531f, 
    -0.12255011f, 0.01184132f, -0.26871237f, 0.00093073f, 0.35430580f, -0.20457098f, 0.37471673f, 0.17741446f, 
    -0.15554671f, 0.37629911f, 0.17271253f, -0.09431230f, 0.22838446f, 0.07375211f, -0.05070356f, 0.15848173f, 
    0.20043713f, -0.09844067f, -0.02268147f, 0.48615471f, 0.18189797f, 0.07301705f, -0.00666593f, -0.12943073f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.09322659f, -0.05728208f, -0.07234698f, 0.27122438f, -0.04129834f, -0.21817009f, 0.00252000f, 0.16749690f, 
    0.00206786f, -0.16631982f, 0.18708761f, -0.22683781f, -0.05903145f, -0.00961166f, 0.13876370f, 0.25906545f, 
    0.02033475f, 0.18777712f, 0.29650497f, 0.17642088f, 0.02112814f, -0.15905622f, 0.24594447f, -0.06820047f, 
    -0.08833521f, 0.05456863f, 0.10743866f, -0.05296697f, 0.26553595f, 0.06292283f, 0.05394397f, -0.07690995f, 
    0.08402194f, 0.10597648f, 0.11418737f, 0.45260495f, 0.05727374f, 0.00000975f, 0.15201868f, 0.27509281f, 
    0.28459549f, 0.01080360f, -0.08684237f, 0.19645301f, 0.15291163f, -0.04361610f, 0.10013355f, 0.09925457f, 
    0.13419728f, -0.07570574f, 0.04844391f, 0.09823490f, -0.03991147f, 0.14457808f, 0.06542582f, 0.15148515f, 
    -0.05712309f, 0.13417657f, -0.05219611f, 0.42838240f, 0.04926512f, 0.18290837f, 0.05968316f, -0.10961186f, 
    0.20535780f, 0.11156035f, -0.02004291f, -0.00657038f, 0.06062936f, -0.29292905f, -0.00296978f, -0.02576389f, 
    -0.04499186f, 0.09521459f, -0.06854606f, 0.00345327f, 0.07411607f, -0.02458850f, -0.14491354f, -0.01677365f, 
    -0.14029935f, 0.34211633f, 0.25821006f, 0.01129230f, -0.02566710f, 0.03272371f, 0.20220469f, 0.05292886f, 
    -0.09017271f, 0.19502461f, -0.12802187f, -0.04823527f, -0.07773013f, 0.00328972f, -0.49668729f, -0.15039550f, 
    -0.18046449f, -0.04384984f, 0.05652463f, -0.10989675f, 0.12315357f, -0.06078841f, -0.17394756f, -0.15182158f, 
    -0.00019742f, 0.04254161f, 0.04190209f, 0.13469273f, -0.21099058f, 0.06957346f, 0.00375911f, 0.20994921f, 
    0.09808262f, 0.03913218f, 0.03066089f, 0.06167787f, -0.04578790f, 0.00688257f, -0.04060736f, -0.01760318f, 
    0.22755067f, -0.08250999f, -0.15955025f, -0.00016742f, -0.13175586f, 0.08186232f, -0.04467704f, 0.14591891f, 
    0.02557550f, -0.05692039f, 0.01078425f, 0.27000201f, 0.20321342f, -0.40308827f, -0.03796148f, 0.15422964f, 
    -0.14011317f, -0.14413431f, 0.24084009f, -0.27216178f, -0.04210588f, 0.04985180f, -0.10225490f, 0.29554945f, 
    -0.03724839f, 0.07389804f, 0.20916936f, 0.05125483f, 0.16953145f, 0.02209277f, 0.20646270f, -0.33121479f, 
    0.04385289f, -0.00564655f, 0.41075757f, -0.05510814f, -0.20052047f, 0.14163655f, 0.12341087f, -0.00764050f, 
    0.07340537f, 0.15104125f, 0.05018640f, 0.41159549f, 0.02920974f, -0.06215615f, 0.13767408f, -0.12276085f, 
    -0.28405443f, -0.24761216f, 0.04483634f, -0.02738559f, 0.14492399f, 0.07963026f, 0.26754162f, -0.23346798f, 
    0.12528108f, 0.01277720f, 0.00149134f, -0.03840043f, 0.00266588f, -0.01508264f, 0.04945049f, 0.37058321f, 
    -0.13089061f, 0.21127470f, -0.19288611f, 0.20814712f, 0.08963300f, 0.05287770f, 0.15711939f, -0.01411489f, 
    -0.16696906f, 0.20377797f, -0.02237694f, 0.08328258f, 0.17411560f, 0.05146905f, 0.17772560f, -0.02128210f, 
    -0.01883722f, 0.13441281f, -0.12835190f, 0.00126176f, -0.05237224f, -0.04176924f, -0.09640332f, 0.05961680f, 
    0.10987429f, 0.44615451f, 0.25383985f, -0.07838144f, -0.01394893f, -0.12155575f, 0.04392892f, 0.15367009f, 
    0.02346906f, -0.16439803f, -0.31414536f, 0.02534059f, -0.04981551f, 0.06558530f, -0.27960560f, -0.08920796f, 
    -0.11482891f, -0.06544499f, 0.18960927f, -0.23125896f, 0.11119656f, -0.03643537f, 0.10501772f, 0.04526133f, 
    0.12970638f, 0.00685503f, -0.07740986f, 0.02364988f, -0.23295905f, 0.13240075f, -0.09095642f, 0.18345755f, 
    -0.01646684f, -0.06670580f, -0.02892062f, -0.18648502f, 0.03366721f, -0.40716806f, -0.02907825f, -0.11608090f, 
    -0.05067273f, 0.05634539f, -0.28413248f, 0.02292410f, -0.05756181f, 0.03769804f, -0.03526789f, -0.19861501f, 
    -0.03251142f, 0.27536130f, -0.10000836f, -0.06481547f, -0.33960202f, 0.18207334f, 0.01713474f, -0.11033134f, 
    -0.06236444f, 0.01279012f, 0.07414886f, 0.17251572f, -0.41521212f, -0.03017308f, -0.25353634f, -0.14346020f, 
    -0.00222972f, -0.07539379f, -0.15682614f, 0.08529487f, -0.00768583f, -0.15464543f, 0.11787120f, -0.19333439f, 
    -0.01287584f, 0.15493649f, -0.19203153f, 0.23995599f, 0.12094149f, 0.27121577f, 0.12131536f, -0.30458996f, 
    0.01847062f, 0.23180333f, 0.12374590f, -0.32425654f, 0.03180171f, -0.14866322f, -0.10140844f, -0.18552934f, 
    0.00393245f, -0.30879191f, 0.01059809f, 0.20228519f, -0.03771270f, 0.09530179f, 0.56764752f, -0.14158872f, 
    -0.00132792f, -0.16884537f, 0.01602653f, 0.18749344f, -0.01573621f, 0.44835928f, -0.00306064f, -0.14538024f, 
    0.15190545f, 0.01853074f, 0.09220939f, -0.19876486f, -0.18066184f, -0.39417690f, 0.12254249f, -0.02661041f, 
    -0.23238470f, 0.15851887f, 0.01445469f, -0.07444762f, -0.26735228f, -0.22634020f, 0.07026321f, -0.03034113f, 
    -0.02602541f, 0.23710890f, -0.06133897f, -0.13659625f, -0.19595675f, 0.06786063f, 0.22467694f, 0.06725659f, 
    0.08982422f, -0.28091845f, -0.01882215f, -0.20395133f, -0.06506059f, -0.00255495f, 0.07404269f, -0.11895553f, 
    0.06911696f, -0.47699070f, -0.32165039f, -0.21297072f, 0.01596756f, -0.03686455f, 0.15681301f, 0.25277570f, 
    0.12605523f, -0.10584398f, -0.01445016f, 0.17718287f, -0.15329085f, 0.07138752f, -0.23965530f, 0.14718765f, 
    0.15586703f, -0.05102830f, -0.23332053f, 0.02945826f, 0.21377406f, -0.08850836f, 0.07044566f, -0.07701239f, 
    0.01273130f, -0.12714486f, 0.01976205f, -0.20401300f, -0.01092623f, -0.13072093f, -0.09349578f, 0.23323889f, 
    0.06580278f, -0.00642293f, -0.22163288f, 0.18340613f, 0.39762288f, 0.36697072f, 0.03923837f, 0.07768076f, 
    0.02964878f, -0.19318685f, -0.02194532f, 0.16944292f, -0.01062339f, 0.03263208f, 0.03841875f, 0.35500395f, 
    0.01181040f, 0.17164853f, 0.04393027f, -0.05579054f, -0.04020503f, -0.08331067f, -0.07106612f, 0.23379508f, 
    -0.29984492f, 0.07953916f, 0.23047183f, 0.03032004f, 0.10821814f, 0.20822513f, 0.20106448f, -0.05795502f, 
    -0.04348313f, -0.01404036f, -0.07906259f, 0.04019634f, -0.19783646f, 0.16831031f, 0.03209643f, 0.17314039f, 
    0.18448824f, 0.15373905f, 0.05229312f, 0.13186313f, 0.01587956f, -0.14965464f, 0.36404303f, -0.27080444f, 
    -0.03630528f, -0.34489051f, 0.20549311f, 0.05296040f, 0.04669002f, 0.18836659f, -0.20504628f, -0.17910595f, 
    -0.03784670f, -0.00801043f, 0.10498958f, 0.00333933f, 0.01398641f, -0.14928262f, 0.19963768f, 0.41622898f, 
    -0.11721742f, 0.01904920f, -0.09545137f, 0.04931200f, 0.20374912f, 0.26676738f, 0.08641100f, -0.15662955f, 
    -0.05054449f, -0.06733714f, -0.13515882f, 0.15687080f, -0.06583615f, 0.25795996f, 0.09502734f, 0.12025429f, 
    0.12807144f, 0.16401769f, -0.26218286f, -0.04130253f, -0.11630196f, -0.04478066f, -0.24669997f, 0.11436862f, 
    0.32350850f, 0.05948143f, 0.20216681f, -0.07434240f, -0.01456804f, 0.01338596f, 0.02301666f, 0.07720529f, 
    -0.05188502f, -0.42465675f, 0.04654022f, -0.25851196f, 0.06120335f, 0.13378982f, -0.27995169f, -0.01132460f, 
    -0.00554277f, 0.10243732f, 0.27781028f, -0.09866738f, -0.22171712f, 0.00031471f, 0.19249459f, 0.03336889f, 
    0.24207257f, 0.10854511f, -0.01028153f, -0.07832310f, -0.20244901f, 0.12376910f, -0.28332785f, 0.00406330f, 
    -0.07691352f, 0.03658310f, 0.05633509f, 0.05195765f, -0.02345477f, -0.00449665f, -0.04669899f, 0.04345196f, 
    -0.10960950f, -0.07566883f, -0.03384276f, 0.11099138f, -0.13169800f, -0.10848247f, -0.06955712f, -0.34253073f, 
    0.05736708f, 0.20639212f, -0.01996024f, 0.01348049f, 0.33403385f, 0.09642481f, -0.02022684f, 0.14476377f, 
    -0.10968777f, -0.42256939f, -0.05953050f, -0.24332409f, 0.04172162f, 0.00780595f, -0.01604689f, 0.15272599f, 
    0.13415878f, -0.09860128f, -0.23314808f, 0.04513733f, 0.02102304f, 0.08043932f, 0.06955260f, 0.20415553f, 
    0.03749871f, 0.09970914f, 0.11120871f, 0.03250415f, 0.03422407f, 0.06621453f, 0.03732517f, 0.07263395f, 
    0.08152507f, -0.08384957f, -0.09188230f, 0.15672678f, 0.11647110f, 0.13177840f, 0.03379506f, -0.09852049f, 
    -0.21059874f, 0.12730037f, 0.02748419f, -0.09232017f, 0.09189538f, 0.01206059f, 0.10093635f, -0.01172398f, 
    -0.02311491f, 0.06097052f, -0.07067022f, -0.09169926f, 0.05430396f, 0.07388987f, 0.06946608f, 0.04767123f, 
    -0.01643408f, -0.05943421f, 0.13740480f, 0.00577752f, 0.22762626f, 0.04061535f, 0.04042060f, 0.05645958f, 
    -0.17080201f, 0.07466280f, -0.05545818f, -0.03082785f, -0.03321528f, 0.46048051f, 0.10414135f, 0.03028805f, 
    0.00238016f, 0.16447249f, -0.07508006f, -0.30616051f, 0.07453938f, -0.01072234f, -0.12900354f, -0.01881870f, 
    0.07843959f, 0.16952197f, 0.08623645f, -0.05809773f, 0.08286610f, 0.12043062f, 0.03336073f, 0.08475453f, 
    0.08018383f, 0.09872717f, 0.04201904f, 0.11138824f, 0.04507331f, -0.04256991f, -0.18468469f, -0.26685005f, 
    -0.30962300f, 0.16508494f, 0.10335012f, -0.01291607f, 0.14214914f, -0.06604190f, -0.04275614f, 0.02991792f, 
    -0.13484004f, 0.04130138f, 0.01092019f, -0.12643582f, 0.03319841f, 0.14362499f, 0.01290505f, 0.18123229f, 
    0.03745691f, 0.03908882f, 0.06593348f, -0.07548428f, 0.00824638f, -0.05688666f, 0.07017783f, -0.02221271f, 
    -0.01856493f, -0.11091488f, -0.24172673f, -0.14542364f, -0.05428720f, 0.05568304f, 0.14537132f, 0.05835696f, 
    -0.09912017f, -0.45618761f, -0.07903580f, 0.14923526f, 0.19742347f, -0.52941483f, -0.03131687f, 0.36493275f, 
    0.02227948f, 0.05288936f, 0.22762328f, -0.27483013f, -0.07600094f, 0.11264302f, -0.11910978f, 0.38354167f, 
    -0.41340303f, 0.05493384f, 0.19825931f, -0.00465686f, 0.09654645f, -0.00477467f, 0.18085736f, -0.37005442f, 
    0.06374452f, -0.07070237f, 0.46328631f, 0.11353271f, -0.11806029f, 0.16759896f, 0.08481161f, 0.15072288f, 
    0.19111618f, 0.13136886f, 0.05115374f, 0.21833426f, 0.03410799f, -0.28224078f, 0.16950192f, -0.23524296f, 
    -0.04115357f, -0.44311816f, 0.02067732f, -0.00737471f, 0.01531417f, 0.20974100f, 0.27581149f, -0.00408821f, 
    0.08366559f, -0.11751956f, 0.02804452f, -0.05954226f, -0.06123747f, -0.24765314f, 0.09224293f, 0.40521279f, 
    -0.07647792f, 0.24670292f, -0.37683994f, 0.20590928f, 0.02821363f, -0.11795519f, 0.16624703f, 0.06546285f, 
    -0.13585407f, 0.11590647f, -0.17048688f, 0.08647646f, 0.18875614f, 0.02039452f, 0.07576054f, 0.06508863f, 
    0.12049415f, 0.07679483f, -0.15412283f, 0.17875370f, -0.19193344f, -0.08029911f, -0.16103804f, 0.17828448f, 
    0.21713790f, 0.14559115f, 0.03628341f, -0.18954057f, 0.03324855f, -0.04459360f, -0.03208382f, 0.34571150f, 
    -0.01122538f, -0.32145512f, -0.15604167f, -0.09508700f, 0.10545298f, -0.00866679f, 0.04468348f, 0.08005230f, 
    0.12293892f, -0.13381651f, 0.21738301f, -0.32244521f, -0.00627997f, 0.07670849f, 0.16535652f, -0.15683842f, 
    0.16489282f, -0.03299951f, -0.11984132f, 0.06602625f, -0.35269323f, 0.06523189f, -0.10774923f, -0.07094733f, 
    -0.11588235f, 0.05190061f, -0.05767590f, -0.29691175f, 0.13979070f, -0.40807050f, -0.02345092f, -0.01326709f, 
    -0.07133701f, 0.04759493f, -0.21466723f, 0.17384109f, -0.18833055f, -0.02879215f, -0.17874804f, -0.34109178f, 
    -0.02790643f, 0.06884079f, -0.08550119f, 0.37261176f, -0.49498758f, 0.15837024f, -0.02666689f, 0.02961856f, 
    0.23406966f, 0.28892767f, 0.04790961f, -0.06937923f, -0.28440616f, 0.28180468f, -0.12005793f, 0.18225464f, 
    0.14044441f, 0.32417405f, 0.27696556f, 0.03660611f, 0.11911310f, 0.02524978f, 0.09645168f, -0.10646609f, 
    0.08181939f, 0.03402591f, 0.15245502f, -0.12294300f, 0.20568763f, -0.01384866f, 0.01137938f, -0.08020424f, 
    0.23953021f, -0.02294933f, -0.33761162f, -0.07112690f, 0.02029032f, -0.29588881f, 0.07394683f, 0.11354461f, 
    0.16219418f, 0.12434130f, -0.08054913f, -0.00573651f, -0.27331960f, -0.09258357f, -0.39362043f, 0.02583561f, 
    -0.09877667f, -0.24723633f, -0.11126093f, 0.11320301f, -0.07136379f, 0.18729775f, -0.02388248f, -0.07499396f, 
    0.18405102f, -0.03494680f, -0.10944099f, -0.00337446f, -0.18990056f, -0.20600510f, 0.19977421f, 0.21242526f, 
    0.04259365f, 0.09576240f, 0.46510383f, -0.12325366f, -0.09547535f, -0.21140009f, -0.02795512f, 0.02244676f, 
    0.15888913f, 0.09202883f, 0.22843446f, 0.15940429f, -0.71340823f, 0.06021189f, 0.20630720f, 0.00815759f, 
    0.15658152f, 0.00916398f, -0.20862703f, 0.15788648f, 0.14489497f, 0.25087738f, -0.04157510f, 0.05998083f, 
    -0.26478076f, 0.51859331f, -0.03443734f, -0.58844215f, -0.30174881f, -0.18641801f, 0.41550955f, 0.01819015f, 
    0.17097929f, -0.45663726f, -0.03567950f, 0.09829062f, 0.08562240f, 0.02561739f, -0.22159445f, -0.02849555f, 
    0.06198404f, 0.07273626f, -0.22209068f, 0.25651476f, -0.05039728f, -0.11267478f, 0.00402055f, 0.15350749f, 
    0.04009245f, 0.01879267f, 0.08461291f, -0.27855447f, 0.09095301f, -0.22744416f, -0.04844467f, 0.15181051f, 
    0.11337408f, -0.08345503f, 0.41876495f, 0.08144700f, -0.01118559f, 0.01774940f, 0.19094813f, -0.07343283f, 
    0.05859241f, -0.07666725f, -0.24295047f, 0.06259424f, 0.07359286f, -0.03478578f, -0.06258907f, 0.27832413f, 
    0.19504052f, -0.10132422f, 0.13579932f, 0.03256345f, -0.09611423f, 0.06089706f, -0.13750076f, 0.06117894f, 
    -0.09266356f, 0.18619080f, -0.12813216f, -0.13217562f, 0.09932907f, -0.00602275f, 0.04793775f, -0.52772862f, 
    -0.08583563f, -0.14396781f, -0.06539854f, 0.07855063f, 0.16741779f, 0.03654786f, -0.17018509f, 0.03029519f, 
    0.07899850f, -0.01096237f, -0.17766528f, -0.14474978f, -0.05603620f, -0.02155093f, 0.11972983f, -0.17384018f, 
    -0.00379358f, -0.31081527f, -0.03207909f, -0.32876164f, -0.51063186f, -0.06878467f, 0.08229380f, 0.00236476f, 
    -0.03635671f, -0.43488616f, -0.11784498f, 0.17403203f, -0.02071590f, 0.08018703f, -0.27128711f, 0.05192792f, 
    0.22059959f, 0.15632969f, -0.20209710f, -0.02618597f, 0.04121017f, -0.44095063f, 0.03024998f, -0.05196109f, 
    -0.05873341f, 0.27391642f, -0.09604000f, -0.12213659f, -0.07095182f, -0.32385963f, -0.19181533f, 0.03388737f, 
    0.09279525f, 0.17089985f, -0.10796161f, 0.25921509f, -0.33008444f, -0.06411939f, 0.07102701f, 0.29899812f, 
    0.19790050f, -0.32523337f, 0.04314929f, -0.00839039f, -0.21900189f, 0.00551134f, -0.04280177f, 0.28226253f, 
    -0.14940259f, -0.26180637f, 0.03471570f, 0.01669401f, -0.09959266f, -0.01956445f, 0.70393115f, 0.57679129f, 
    0.17821553f, -0.42758453f, -0.04644578f, 0.07570163f, -0.13631289f, -0.06415971f, -0.19220972f, 0.20309088f, 
    0.17061879f, -0.08243994f, -0.07396810f, 0.04171983f, -0.10281843f, -0.03828824f, -0.08884182f, -0.05491498f, 
    -0.05014718f, 0.06839930f, -0.03662443f, -0.33561477f, 0.21836887f, 0.15703516f, 0.04003039f, -0.00883605f, 
    0.07725270f, -0.03642436f, -0.13758224f, 0.14281783f, 0.15920095f, 0.03328253f, 0.13959436f, -0.13837087f, 
    -0.20559877f, -0.62068969f, 0.00229716f, -0.19326733f, -0.11023132f, -0.83994830f, -0.02700545f, -0.29772860f, 
    -0.13769406f, 0.02023469f, -0.02904654f, -0.38724676f, -0.18538459f, -0.01377982f, -0.07106247f, -0.15613794f, 
    -0.25855121f, -0.07181533f, 0.24896017f, 0.07818238f, 0.21328342f, 0.24282330f, 0.11321476f, 0.14128555f, 
    -0.02944271f, 0.12449922f, 0.07725786f, -0.35523686f, 0.33354530f, 0.22174214f, 0.39718154f, -0.13482952f, 
    0.15523352f, 0.12357901f, -0.11906510f, 0.18845610f, -0.12624729f, -0.12163673f, 0.17640723f, 0.17848624f, 
    0.26854277f, -0.00822156f, -0.16864882f, 0.09907406f, 0.06700454f, -0.21379803f, -0.00284387f, -0.32925504f, 
    -0.10001943f, 0.05122385f, -0.09292418f, -0.27506265f, 0.05691451f, -0.49736810f, 0.03974187f, 0.03348266f, 
    -0.04114133f, -0.20097037f, -0.15034631f, 0.05521714f, 0.04291183f, 0.19061686f, 0.04768918f, 0.08937805f, 
    -0.13647537f, -0.15404233f, 0.18682098f, 0.07884447f, 0.41930681f, 0.20187351f, 0.03621421f, -0.00638698f, 
    -0.04775818f, -0.00960248f, -0.17053545f, -0.35339072f, 0.05453955f, 0.02817160f, 0.29307032f, 0.06246389f, 
    -0.04381415f, 0.18710370f, -0.10483613f, -0.21903649f, 0.14685485f, -0.04741051f, 0.21692999f, -0.15984349f, 
    -0.58899850f, 0.05287946f, -0.16912487f, -0.36427078f, 0.06955101f, -0.12369977f, -0.18014401f, -0.07294427f, 
    -0.38367155f, -0.13191995f, -0.05596131f, -0.19314481f, 0.15802175f, 0.00829912f, -0.07988658f, -0.35996333f, 
    0.23884948f, 0.19449453f, 0.19157961f, 0.01857917f, 0.04321213f, 0.03297038f, 0.10214584f, 0.36987224f, 
    -0.10061819f, -0.11384302f, -0.02348648f, -0.24343054f, 0.08346988f, -0.06954730f, -0.00320287f, -0.34349996f, 
    -0.02636039f, -0.04994595f, 0.19792351f, -0.20697875f, -0.31375110f, 0.23239356f, 0.23155558f, 0.24791837f, 
    0.15066776f, -0.07187257f, 0.00782411f, -0.12925255f, 0.03784897f, 0.05904643f, -0.07154382f, 0.38043320f, 
    -0.01818790f, -0.26690325f, 0.07703629f, -0.17716578f, 0.05026776f, -0.04001912f, -0.10666890f, 0.26155719f, 
    -0.23785432f, -0.02609064f, 0.06315546f, -0.11788645f, 0.18613581f, 0.03539623f, 0.07556787f, 0.00019610f, 
    0.07407176f, -0.05381540f, -0.25367388f, 0.06964788f, -0.21145807f, 0.08766010f, -0.07513013f, 0.26558784f, 
    0.15628193f, 0.11230899f, -0.01995623f, 0.17342311f, -0.02024371f, -0.10681309f, 0.14980273f, -0.41453204f, 
    -0.37878579f, -0.11242440f, 0.17044611f, -0.14010809f, 0.16554724f, 0.20132168f, -0.13077378f, -0.01130780f, 
    0.06384166f, 0.13155617f, 0.14475466f, 0.10790851f, 0.03083107f, -0.22841883f, 0.15033683f, -0.00285379f, 
    -0.00984989f, -0.06683187f, -0.14772096f, -0.26357454f, 0.29744026f, 0.34568116f, 0.03532127f, -0.06818699f, 
    -0.11234606f, 0.02603564f, -0.17363526f, 0.13487341f, -0.08049725f, -0.07107896f, -0.06259163f, 0.11507468f, 
    0.10225429f, 0.07220359f, -0.04538822f, -0.06953927f, -0.05258087f, 0.03829239f, -0.14197077f, -0.12931964f, 
    0.21878225f, 0.09293757f, 0.25829104f, -0.09109686f, -0.11772037f, -0.20702796f, -0.10551002f, 0.04280396f, 
    0.02525739f, -0.20357160f, -0.08174125f, 0.03934206f, 0.30352980f, 0.07802876f, -0.07506903f, -0.19949277f, 
    0.15434636f, 0.09950208f, -0.14379261f, -0.23226291f, -0.25426897f, -0.08795884f, 0.38151824f, 0.17196006f, 
    -0.02121363f, 0.00785665f, 0.27579916f, -0.01952469f, -0.37185571f, 0.10737602f, -0.07084692f, 0.02490699f, 
    0.03417070f, -0.01087318f, 0.05925798f, -0.11440803f, 0.20156024f, 0.04517161f, 0.04589545f, -0.11952265f, 
    0.00115338f, -0.01996654f, -0.31231919f, 0.15747753f, 0.00083856f, -0.06002308f, -0.14015739f, -0.27526954f, 
    0.09403890f, -0.01104486f, -0.02554891f, 0.04428830f, -0.27500045f, -0.01847070f, 0.06079635f, -0.01463916f, 
    -0.01501534f, -0.06886072f, 0.11815634f, -0.13318278f, 0.07809056f, 0.17341258f, 0.15200408f, -0.02386920f, 
    0.16395046f, 0.07994924f, -0.17615733f, 0.07755441f, 0.01474894f, -0.09164728f, 0.14148726f, 0.10930931f, 
    -0.01221960f, 0.04989914f, 0.07597707f, -0.63337785f, -0.33511743f, -0.11127802f, -0.57241046f, 0.03671507f, 
    0.03123879f, 0.08255440f, 0.08863714f, 0.00319221f, 0.07094284f, 0.15637158f, -0.03914245f, -0.14898808f, 
    -0.31749895f, 0.22209910f, -0.39742780f, 0.09363998f, -0.08016147f, -0.50661296f, -0.25385368f, 0.07589231f, 
    -0.18322103f, 0.13629691f, -0.41953576f, 0.06490073f, -0.08427887f, -0.09671898f, -0.31785846f, 0.02569042f, 
    0.01465584f, -0.19469160f, -0.25545475f, -0.35243815f, -0.07927717f, -0.13551189f, -0.01237874f, 0.13374232f, 
    -0.46855414f, -0.07311091f, 0.11666916f, -0.29572704f, 0.23647918f, 0.07942475f, 0.24703635f, 0.04399292f, 
    -0.08882394f, -0.22933784f, 0.33395112f, -0.06146757f, -0.15478680f, -0.04430418f, -0.18579130f, 0.05466707f, 
    -0.27894655f, -0.04802158f, 0.02693575f, 0.21469764f, -0.00281001f, -0.30306610f, 0.13355152f, 0.01284144f, 
    0.13973336f, 0.71303976f, 0.11706018f, -0.48256752f, 0.00295211f, -0.31651577f, 0.17992377f, 0.02327330f, 
    0.14118613f, 0.29663587f, 0.05784970f, -0.30067396f, 0.12804985f, 0.01508940f, 0.22631606f, -0.03646747f, 
    -0.12179497f, 0.01623359f, 0.13775076f, 0.15139408f, -0.23774537f, -0.02347408f, 0.13634665f, 0.01042964f, 
    0.17085803f, -0.25836655f, -0.00515107f, -0.24409884f, -0.11522144f, -0.29505327f, 0.03969645f, 0.05441450f, 
    0.11534207f, 0.08603254f, 0.27068266f, -0.13046123f, -0.30560437f, -0.04000222f, 0.19096351f, 0.00228072f, 
    -0.05369340f, 0.04488563f, -0.04803139f, -0.01873445f, 0.05512444f, -0.01784213f, -0.06369357f, -0.08854830f, 
    -0.03369278f, 0.07444549f, 0.04126745f, -0.10557533f, -0.07461589f, -0.03609642f, -0.03159168f, 0.05325154f, 
    0.03127998f, 0.00925273f, -0.03596145f, 0.08760887f, 0.09017591f, -0.06385615f, -0.03064207f, 0.03287628f, 
    -0.01276112f, -0.00190552f, -0.10870156f, 0.05568187f, -0.01329602f, -0.07929639f, -0.04622025f, -0.01861860f, 
    -0.01262477f, -0.08527964f, 0.03998111f, 0.05487869f, -0.08620229f, 0.01995199f, 0.04058345f, 0.03862741f, 
    -0.00432263f, -0.07646291f, -0.08464648f, 0.04513980f, -0.09505932f, -0.02889434f, -0.02328733f, -0.01141913f, 
    -0.00229047f, -0.13405478f, -0.09851172f, -0.03548225f, -0.02705549f, -0.07096808f, -0.03081269f, -0.03194796f, 
    -0.05972999f, 0.05511488f, 0.03346737f, 0.03127271f, -0.07760547f, -0.01307133f, -0.06448001f, 0.01185994f, 
    -0.09687473f, -0.07184532f, -0.05057171f, -0.10208556f, 0.01167704f, -0.08835175f, -0.07020401f, -0.01864864f, 
    -0.13044038f, 0.05013498f, -0.01678235f, -0.09230481f, 0.02804534f, -0.02332337f, -0.01578739f, -0.01793136f, 
    -0.00665189f, 0.02163355f, -0.10812614f, 0.03614390f, 0.01554111f, -0.00071116f, -0.05242241f, 0.04959335f, 
    0.01860371f, 0.09909969f, 0.01423617f, -0.05400226f, 0.00068304f, -0.03139907f, 0.05544767f, -0.09617029f, 
    0.02087223f, -0.03922402f, 0.05232511f, -0.03381413f, 0.07032168f, 0.07948804f, -0.04513506f, 0.04255269f, 
    0.04984635f, -0.10278681f, 0.03099756f, -0.04933378f, 0.00758303f, -0.00841953f, -0.00047871f, 0.05691416f, 
    0.05266263f, -0.02524936f, 0.02508445f, -0.03662604f, -0.04054938f, 0.06952456f, 0.03920528f, -0.04173683f, 
    0.07487120f, -0.04546998f, -0.01921688f, -0.07579003f, -0.08017628f, -0.03670194f, 0.02901624f, 0.01128972f, 
    -0.01405529f, 0.02797528f, -0.15612853f, 0.04468301f, 0.05582831f, -0.06441113f, -0.08394700f, 0.22572419f, 
    0.26891211f, 0.33796793f, 0.01934000f, 0.10980439f, -0.11201473f, 0.00578246f, -0.04688329f, -0.10055058f, 
    -0.02663399f, -0.01970033f, 0.21228392f, 0.05580340f, 0.20033208f, 0.18192951f, -0.03024614f, 0.09624266f, 
    0.00691011f, -0.00261031f, 0.07858609f, -0.08359682f, 0.38717258f, 0.02851323f, 0.08569522f, -0.15441595f, 
    0.06483629f, -0.03705384f, 0.16955502f, -0.34123829f, -0.13461089f, -0.10275359f, 0.12160565f, 0.03709633f, 
    0.06020815f, -0.13796718f, 0.05797482f, 0.10659641f, 0.13313684f, 0.00767934f, -0.15588912f, 0.01875040f, 
    -0.18767975f, -0.03669290f, -0.14377551f, 0.22322099f, -0.08880208f, -0.02124710f, -0.04268041f, -0.09521753f, 
    -0.07620502f, 0.04170525f, 0.00866400f, -0.01081314f, -0.10898571f, -0.12504601f, -0.02938892f, -0.15465474f, 
    0.01389923f, -0.06042619f, 0.10488039f, -0.02437394f, 0.07232335f, -0.14213642f, -0.19814116f, 0.12771189f, 
    -0.04877028f, -0.04771266f, 0.17415808f, 0.10993829f, -0.08720005f, 0.04264069f, -0.01501903f, 0.10672142f, 
    0.17905200f, -0.43560264f, 0.06611881f, 0.10650922f, -0.05244100f, -0.09485631f, 0.08173805f, 0.09573632f, 
    -0.13416728f, -0.20053270f, -0.06762323f, -0.15448423f, 0.01486240f, 0.00777493f, 0.18272284f, 0.08912219f, 
    0.36215854f, 0.03392785f, -0.01462226f, -0.03168816f, -0.01914448f, 0.01726176f, -0.08892769f, 0.01868319f, 
    0.12085283f, 0.03404715f, 0.07853893f, -0.03726102f, 0.00010727f, -0.20180203f, 0.00711043f, -0.09980065f, 
    0.16199905f, -0.14513482f, -0.00343792f, -0.08763917f, -0.03631935f, -0.00521669f, -0.02788918f, -0.00828776f, 
    0.15419069f, -0.04689702f, 0.16038683f, -0.06296786f, -0.16590962f, -0.06073333f, -0.05354621f, 0.03560040f, 
    -0.09051529f, -0.06932394f, -0.01285813f, -0.01098013f, -0.06986022f, -0.05289975f, 0.08022863f, 0.02685630f, 
    -0.05217900f, -0.06647243f, 0.00782818f, 0.02144378f, -0.08091763f, -0.10844807f, -0.01326654f, 0.00580151f, 
    -0.00094166f, 0.03447485f, -0.06299774f, 0.04819403f, -0.06180596f, -0.02123342f, 0.01659927f, -0.06770699f, 
    0.06818144f, 0.02536263f, 0.03382283f, -0.01068390f, -0.08161473f, 0.00732450f, -0.04116107f, -0.10802667f, 
    -0.04850815f, -0.00955869f, -0.07295310f, -0.08314013f, -0.07909892f, -0.05375199f, 0.05145012f, 0.09342723f, 
    -0.03471248f, -0.06976029f, -0.03649176f, 0.09329459f, -0.08920563f, 0.05441559f, -0.09365188f, -0.11404117f, 
    0.01907879f, -0.06796987f, -0.00316967f, -0.12164199f, 0.07410674f, 0.06088970f, 0.04074609f, 0.00382572f, 
    -0.04635809f, -0.03760104f, 0.04854646f, -0.09863479f, 0.04965757f, -0.10438771f, 0.05530118f, 0.01027264f, 
    -0.00480537f, -0.11559246f, -0.10299119f, -0.04098513f, -0.03225602f, -0.08266239f, 0.08096237f, 0.07761139f, 
    -0.02788603f, 0.01835891f, -0.02834024f, -0.11390968f, -0.11963145f, -0.01957820f, -0.08194695f, -0.04253856f, 
    -0.07116629f, -0.11383250f, -0.09505161f, -0.05630310f, -0.02437793f, -0.04389678f, -0.13674341f, -0.07138557f, 
    0.04970510f, -0.06438114f, -0.03766908f, -0.08591095f, -0.01507634f, -0.06379680f, -0.04720102f, 0.02484644f, 
    -0.05265940f, 0.03785963f, -0.00658406f, -0.06359187f, -0.07064714f, -0.02293371f, 0.00779316f, -0.04920451f, 
    -0.02268123f, 0.01016305f, -0.12294003f, -0.03122351f, 0.01249519f, -0.02033005f, -0.04595012f, 0.04168857f, 
    0.04136119f, 0.01472668f, 0.03375818f, 0.04058044f, -0.07460136f, -0.10810781f, -0.08541929f, 0.01653980f, 
    0.04238109f, 0.03492622f, 0.05342840f, -0.01005642f, 0.09891289f, -0.03536368f, -0.09665743f, 0.07000557f, 
    0.13135871f, -0.10417339f, 0.12449893f, -0.52398384f, -0.06140614f, 0.21956649f, -0.07736754f, -0.03671430f, 
    0.16614772f, 0.40274239f, -0.22119536f, 0.39899340f, 0.04907723f, -0.07783267f, 0.22287765f, -0.21328132f, 
    -0.29107207f, -0.01685520f, -0.45422268f, 0.26152557f, -0.01550236f, -0.33409017f, -0.03834704f, 0.18249045f, 
    0.06274641f, 0.11101664f, -0.09710409f, 0.04957066f, -0.05645274f, 0.13253668f, 0.13519098f, -0.02775121f, 
    -0.31413049f, -0.08153509f, 0.30306572f, -0.23250157f, 0.27496892f, -0.08619024f, 0.15055890f, -0.23704739f, 
    0.12404999f, -0.03937173f, 0.21429764f, 0.34963608f, 0.32846224f, 0.18206106f, 0.03985604f, 0.07787684f, 
    0.13911735f, 0.17398818f, -0.01816070f, -0.04915588f, -0.09979329f, 0.05980339f, 0.25850475f, -0.30214563f, 
    -0.30281061f, 0.17184122f, 0.30885074f, 0.10678220f, 0.00740334f, -0.04783016f, -0.47321036f, 0.12631261f, 
    -0.23597862f, -0.38692728f, 0.05479712f, 0.12358343f, -0.04419537f, -0.49307984f, -0.07390299f, 0.01942891f, 
    -0.09583188f, -0.35529378f, -0.31246731f, -0.06007396f, 0.03394841f, -0.06084157f, -0.43430373f, 0.13353769f, 
    -0.03189762f, -0.14927882f, -0.21144725f, -0.09669948f, 0.01311808f, -0.00196172f, -0.12553863f, 0.04347533f, 
    0.21643154f, 0.28101906f, 0.17636763f, -0.14109415f, 0.28328007f, 0.01559466f, -1.01607740f, -0.11059374f, 
    -0.05049814f, 0.47569016f, 0.02647628f, 0.27368623f, 0.02210641f, -0.00426398f, 0.32590547f, -0.00790216f, 
    -0.25204626f, 0.21230012f, -0.01919652f, -0.20751043f, 0.23091811f, -0.02031992f, 0.18959501f, -0.37744597f, 
    0.17390729f, 0.07120681f, 0.09068922f, 0.03927816f, -0.06381021f, -0.13851370f, -0.01088931f, 0.18316923f, 
    0.20473248f, 0.07638698f, 0.00081792f, 0.06368320f, 0.05934239f, -0.04322134f, 0.13945861f, -0.03339976f, 
    -0.01337650f, 0.11593458f, -0.18840964f, 0.12533538f, -0.09998108f, -0.11626214f, 0.00426077f, -0.02247522f, 
    0.10467685f, 0.27614981f, 0.17360774f, -0.19202310f, 0.07877115f, 0.19870861f, 0.00259601f, 0.22571515f, 
    0.02896939f, 0.13639857f, -0.21128418f, 0.13095894f, 0.08090455f, -0.16468616f, 0.16132098f, -0.56442004f, 
    -0.06767919f, 0.13285030f, -0.02180762f, -0.08971440f, 0.09486899f, 0.14409682f, 0.04395260f, 0.12925389f, 
    0.07752766f, 0.12605399f, -0.08979791f, 0.30539322f, 0.14832251f, -0.14674972f, -0.07981642f, -0.20921506f, 
    -0.07080046f, 0.14474422f, -0.10411952f, 0.19424722f, -0.27375826f, -0.06349401f, 0.05117916f, -0.17619716f, 
    0.10922127f, 0.01522970f, -0.08782297f, -0.05779014f, -0.04445793f, 0.08967040f, -0.11183237f, 0.08664447f, 
    0.21907322f, -0.01750522f, -0.15977669f, -0.12317194f, 0.01419010f, -0.00228070f, 0.12471256f, -0.00126260f, 
    -0.07627592f, 0.19330409f, 0.02671968f, -0.08194980f, -0.49964398f, -0.15696360f, 0.01168520f, 0.05666609f, 
    -0.02483344f, 0.13357846f, 0.13329475f, -0.09189445f, 0.14287423f, -0.04815134f, -0.05438704f, 0.03340480f, 
    -0.02740151f, 0.18061569f, 0.09470711f, -0.14813937f, -0.15143590f, -0.08214822f, 0.01016872f, 0.05226969f, 
    -0.08420123f, 0.20614722f, 0.11485624f, 0.12034815f, -0.19467755f, -0.21904114f, -0.26229185f, 0.04468074f, 
    -0.04882851f, -0.41405207f, 0.05473126f, -0.19777489f, -0.09922134f, -0.00263502f, -0.09348248f, 0.05418073f, 
    0.05527643f, -0.05855986f, -0.05896839f, 0.18050076f, 0.02845964f, -0.06084878f, -0.06945937f, -0.00644352f, 
    -0.01866743f, -0.04222953f, -0.03083874f, -0.19046077f, 0.21608241f, -0.16151525f, 0.03123005f, 0.10720062f, 
    -0.03221957f, -0.06245189f, -0.15094307f, 0.08743960f, 0.16613454f, 0.11463001f, -0.01764695f, -0.00772412f, 
    0.12806909f, 0.53326547f, -0.20245667f, 0.12212459f, -0.58463180f, 0.28957182f, 0.06398789f, -0.32662171f, 
    -0.02211109f, 0.21903886f, -0.03197453f, 0.17826413f, 0.00824013f, 0.14627136f, 0.01121078f, -0.14838645f, 
    0.51354074f, -0.09200158f, -0.27220529f, 0.17721854f, 0.13854937f, -0.13175923f, 0.01372310f, 0.05975814f, 
    -0.06458534f, 0.03192084f, -0.42044854f, 0.06708142f, 0.02490553f, -0.07425540f, -0.03607767f, -0.04927928f, 
    0.03957244f, -0.00256382f, 0.20383720f, 0.03886077f, 0.08144453f, 0.04101286f, -0.32707366f, 0.02398061f, 
    -0.24914354f, 0.05507006f, -0.19303273f, 0.15250261f, 0.27451986f, -0.07934386f, 0.27594733f, -0.00701049f, 
    -0.08128402f, 0.15108280f, -0.02886541f, 0.07240663f, 0.02799203f, 0.16012824f, -0.21204163f, -0.33296961f, 
    0.12090408f, 0.09949023f, 0.25271094f, -0.40715191f, -0.10438059f, 0.09549984f, -0.02616179f, 0.04452043f, 
    0.05383222f, -0.07264159f, 0.19962859f, -0.06921396f, -0.06189070f, -0.10473375f, -0.03481326f, -0.17066735f, 
    -0.08555976f, -0.05566417f, 0.27481446f, -0.04241595f, -0.02830437f, -0.07196182f, 0.10222711f, -0.13197131f, 
    -0.15304948f, 0.00891416f, 0.00914066f, 0.11853397f, -0.07195710f, -0.01251262f, 0.09873296f, -0.20358434f, 
    0.14889579f, 0.21811029f, -0.18359058f, -0.47724363f, 0.06238749f, -0.07929907f, -0.26163402f, -0.46162203f, 
    0.03446759f, 0.30064318f, -0.31242406f, 0.08170153f, 0.09021261f, 0.04586258f, -0.26499227f, 0.22391516f, 
    -0.00172878f, 0.00811263f, 0.04229757f, 0.13156033f, 0.20285515f, -0.02397330f, 0.16772270f, 0.12187090f, 
    0.12352384f, -0.36508885f, -0.01295866f, 0.13389465f, -0.24325696f, -0.27423877f, 0.00630000f, 0.08574200f, 
    0.23792171f, -0.07608055f, -0.01700852f, 0.08516307f, 0.26653624f, 0.14988700f, 0.02402601f, 0.04838878f, 
    0.24653235f, 0.32626152f, -0.14193991f, 0.08786549f, -0.05219419f, 0.21393132f, -0.08118348f, -0.11778596f, 
    0.02206267f, -0.12065113f, -0.02304670f, -0.01886847f, 0.16463833f, -0.00718444f, 0.05292829f, -0.14913692f, 
    0.27267492f, -0.22759327f, -0.17466362f, -0.13673727f, 0.09578301f, 0.02419700f, 0.12213849f, 0.17355935f, 
    -0.08627807f, 0.13464224f, -0.19288476f, 0.10393035f, 0.12634020f, -0.04068119f, -0.24101909f, 0.05680118f, 
    0.04103445f, -0.04633211f, 0.21003006f, 0.03200210f, -0.10072304f, 0.16594513f, -0.00044165f, -0.21171051f, 
    -0.63871604f, 0.05535516f, -0.12049969f, -0.01099948f, 0.02360221f, 0.11359181f, 0.06769840f, -0.04653363f, 
    -0.12408666f, 0.18512146f, 0.02420518f, 0.39041564f, 0.03493289f, 0.29616430f, -0.06087007f, -0.12627907f, 
    0.00224100f, -0.02888370f, -0.05701248f, -0.44472033f, 0.38376403f, 0.24630560f, -0.02558034f, -0.26592416f, 
    0.02273252f, -0.14479266f, 0.13798532f, -0.04239148f, -0.33658046f, -0.35176358f, -0.07280592f, 0.05477267f, 
    -0.02011630f, 0.05506703f, 0.11089589f, -0.04547900f, 0.07882409f, 0.03234433f, 0.10155895f, -0.26846257f, 
    -0.07327117f, 0.07377477f, 0.36889765f, -0.00545732f, 0.02582279f, -0.38765472f, 0.15481906f, -0.38428646f, 
    -0.02903059f, 0.04617038f, 0.02286362f, -0.10899563f, 0.27237466f, 0.14545746f, -0.15018705f, -0.12037393f, 
    -0.04520775f, 0.08214874f, -0.14520414f, 0.11906927f, -0.04205980f, 0.01458013f, 0.17256744f, 0.36126789f, 
    -0.08058532f, -0.01805053f, 0.24128310f, 0.06995598f, -0.32189310f, -0.00314614f, -0.06437463f, 0.04458198f, 
    0.19084872f, -0.11008002f, 0.06251072f, 0.04847385f, 0.00429727f, -0.34938467f, -0.05829252f, 0.02536929f, 
    0.29485306f, -0.10131361f, -0.17363974f, 0.06700074f, 0.32833886f, 0.10166565f, -0.05240417f, -0.30981088f, 
    0.04693818f, 0.43419623f, -0.16761996f, 0.08380299f, -0.25454503f, -0.11620616f, 0.00951632f, -0.04585525f, 
    -0.13615672f, -0.31747895f, 0.12359710f, -0.03488105f, -0.09754597f, 0.01725645f, 0.11431111f, 0.09735733f, 
    0.15314922f, -0.02535222f, 0.08740679f, 0.27051297f, 0.25567421f, 0.00376712f, 0.35987630f, 0.04118120f, 
    0.01192585f, 0.11870842f, -0.26302925f, 0.00360769f, 0.58743608f, 0.41933230f, 0.21310711f, -0.02057963f, 
    0.12121255f, 0.23780186f, 0.23055995f, -0.01809427f, 0.07790475f, 0.03833524f, 0.12746215f, 0.21777807f, 
    -0.02741491f, -0.14355908f, -0.03827765f, 0.28748709f, 0.02075776f, 0.01813031f, 0.29066053f, -0.17106952f, 
    0.00075930f, 0.18190424f, -0.09083901f, 0.33014750f, -0.07821302f, 0.24782123f, 0.11116342f, -0.37971398f, 
    0.06692028f, -0.01997262f, -0.13535801f, -0.03525126f, 0.15459235f, 0.13318004f, 0.21896325f, -0.19508617f, 
    -0.02581313f, 0.16845810f, 0.08418731f, 0.06686648f, 0.00554219f, -0.47204223f, 0.06226671f, -0.00923944f, 
    0.02516256f, 0.02427038f, 0.07898412f, 0.02389779f, 0.09967147f, -0.00958143f, 0.14846063f, 0.03572923f, 
    -0.03686199f, 0.19238818f, 0.35823101f, 0.00361540f, 0.00571249f, -0.11383550f, 0.27122039f, -0.01238473f, 
    -0.17003900f, 0.38640094f, -0.18073434f, -0.30579016f, 0.17725809f, -0.01173081f, -0.24275944f, -0.05480084f, 
    -0.00952915f, 0.01186533f, -0.26723421f, -0.03377720f, 0.01216818f, 0.09454085f, 0.12596700f, 0.07521639f, 
    0.10299333f, 0.01213543f, 0.18922342f, 0.03258220f, -0.12586530f, 0.00743507f, 0.10871987f, 0.16425438f, 
    0.01112009f, -0.20071943f, 0.05042253f, -0.21811521f, 0.07246037f, -0.08745431f, 0.04141380f, -0.00612506f, 
    0.36402664f, -0.08745953f, -0.12424888f, -0.15360083f, -0.05206452f, 0.16066627f, 0.04123178f, 0.02606390f, 
    0.02388111f, 0.32660729f, -0.11443086f, 0.24381711f, -0.36866665f, 0.26567495f, -0.05255799f, -0.11165639f, 
    -0.03570271f, 0.18929684f, -0.01954566f, 0.12787746f, -0.13319910f, -0.02467577f, -0.15527397f, 0.05872475f, 
    0.32498699f, 0.04325226f, 0.03905145f, 0.22617160f, -0.03491439f, 0.10824011f, 0.13297169f, 0.18794665f, 
    -0.00320116f, 0.13817757f, -0.46449363f, 0.02245419f, 0.12092610f, 0.24635923f, -0.01096583f, -0.32067561f, 
    0.15721147f, 0.01773810f, -0.06655060f, -0.06920531f, 0.02242414f, 0.09432643f, 0.17379452f, 0.21881583f, 
    0.14311939f, 0.34922352f, -0.05841291f, 0.41424000f, 0.11549713f, -0.01592292f, -0.05592720f, -0.20257919f, 
    0.12109528f, 0.03961965f, -0.10838255f, 0.13978942f, 0.04052739f, 0.32874289f, 0.05040561f, 0.23165844f, 
    0.01891856f, -0.17386703f, 0.20401238f, 0.15665415f, -0.00923170f, 0.27120438f, -0.00943988f, -0.32319775f, 
    0.24471410f, 0.02801265f, 0.10729903f, -0.12601286f, -0.50008923f, -0.48991498f, 0.02694794f, -0.05749923f, 
    0.02855510f, 0.22678885f, 0.07423639f, -0.19375736f, -0.10579409f, -0.04013011f, 0.14512642f, -0.17479309f, 
    -0.02210802f, 0.00117250f, 0.21694273f, 0.02472137f, 0.08947722f, 0.08626012f, -0.17311396f, -0.17472784f, 
    -0.22800297f, -0.04285637f, 0.06893024f, -0.40689155f, -0.15304042f, -0.05618534f, -0.45924473f, -0.27999637f, 
    -0.16099861f, 0.17171648f, 0.05161056f, 0.20798413f, 0.04152530f, 0.01302966f, -0.32534036f, 0.16361150f, 
    0.21967873f, -0.06004130f, -0.13257028f, 0.17049040f, 0.10385235f, 0.06789035f, -0.01365465f, 0.13693599f, 
    -0.09668072f, -0.22232653f, 0.00278254f, 0.21524805f, -0.28085166f, 0.48850709f, -0.02869034f, 0.10261066f, 
    0.08838668f, 0.05350084f, 0.09843987f, -0.08227203f, 0.08938923f, 0.22198401f, 0.05413751f, 0.13703586f, 
    0.12125362f, 0.05829077f, 0.06571043f, 0.17729923f, 0.05501627f, -0.35315257f, 0.08934030f, 0.12945242f, 
    -0.17034149f, 0.06310480f, 0.04712708f, -0.34846422f, -0.03654224f, 0.10622398f, -0.03914893f, 0.19159430f, 
    -0.13989598f, 0.03877839f, 0.21186836f, 0.20901670f, 0.07600687f, 0.02090846f, 0.16624217f, -0.04413832f, 
    -0.02581984f, -0.03140157f, 0.33590287f, -0.10555693f, 0.17755383f, 0.28787664f, 0.02423067f, -0.03420195f, 
    -0.00406691f, 0.12514625f, 0.14516324f, 0.17691559f, 0.08753721f, -0.00450434f, 0.28039777f, 0.08178902f, 
    0.11121497f, -0.05725632f, -0.07491173f, 0.53281671f, 0.20384300f, -0.04303833f, 0.28727090f, -0.02929848f, 
    -0.01182908f, 0.15066783f, 0.07279472f, -0.02265482f, 0.01835288f, 0.00647504f, -0.01825295f, 0.29941729f, 
    -0.22862300f, 0.07243773f, -0.01300795f, 0.16672337f, -0.00090839f, 0.19260344f, 0.09266132f, 0.09413338f, 
    -0.15085833f, -0.07701654f, 0.01520156f, 0.00282472f, 0.20308159f, 0.09791150f, 0.01632416f, -0.05362608f, 
    -0.13454910f, 0.10074335f, -0.13987847f, -0.19418576f, 0.08768796f, 0.06250646f, -0.09034847f, 0.11215246f, 
    0.08849603f, 0.18527436f, 0.18517298f, -0.14696985f, 0.03169031f, -0.02264677f, 0.13163535f, -0.13834058f, 
    0.05998056f, -0.58571315f, -0.11734384f, 0.08548106f, -0.11029103f, 0.12648790f, -0.54648066f, -0.17026977f, 
    -0.09672607f, 0.14884929f, 0.15797558f, -0.19362043f, -0.00465064f, 0.07414506f, -0.03392906f, -0.12789665f, 
    0.15072988f, 0.05092094f, -0.04188303f, 0.04423163f, -0.04015033f, -0.00960565f, 0.13578109f, 0.14380804f, 
    -0.03739526f, 0.05340135f, -0.07309919f, -0.10045119f, 0.01067114f, -0.01651813f, 0.01059459f, -0.02317973f, 
    0.07767815f, -0.02132745f, -0.01634247f, -0.06100869f, -0.12270855f, 0.29779941f, 0.20995815f, 0.10109705f, 
    0.11199206f, 0.08396829f, -0.05335221f, -0.17127986f, -0.05746875f, 0.28501895f, 0.01747258f, -0.01231174f, 
    -0.03226320f, -0.11257762f, -0.05442880f, 0.15046464f, 0.04897868f, 0.09759275f, 0.17747426f, -0.13996418f, 
    0.12580502f, -0.14322932f, -0.21091637f, 0.00988870f, 0.06485925f, -0.07644916f, 0.07314377f, 0.14398322f, 
    -0.02578352f, 0.05410784f, -0.17653939f, 0.15797678f, -0.04380082f, 0.05387741f, -0.14192148f, -0.04311390f, 
    -0.13420261f, -0.10193599f, 0.00834986f, 0.03996990f, 0.19730686f, 0.16037743f, -0.07171386f, -0.04197992f, 
    -0.27315599f, 0.07307453f, -0.02134317f, -0.18370163f, 0.17032403f, -0.01095030f, 0.20483561f, 0.04372772f, 
    0.17259178f, 0.16760384f, 0.10989256f, 0.16687389f, 0.03894595f, 0.11229566f, -0.03493540f, -0.18284619f, 
    -0.09783044f, -0.05705911f, 0.11395326f, -0.05603961f, 0.21721382f, 0.10095876f, -0.07395890f, -0.30629370f, 
    0.14014794f, -0.22635233f, 0.00962030f, 0.05579278f, -0.35704666f, -0.36223724f, 0.04385863f, 0.02252642f, 
    -0.09455565f, -0.03299495f, 0.08459520f, -0.17528008f, 0.05830766f, 0.05607357f, -0.17233291f, -0.30719984f, 
    -0.22393133f, 0.01543799f, 0.17747115f, 0.05029669f, -0.04729075f, -0.04537714f, -0.01098811f, -0.09785827f, 
    0.09447638f, -0.12450785f, 0.21360527f, -0.00972202f, 0.05194600f, 0.13422444f, -0.47321898f, -0.10361948f, 
    -0.00386125f, 0.03868505f, -0.16926406f, 0.10989578f, -0.05174391f, -0.05951284f, 0.09286422f, 0.22393160f, 
    -0.20325832f, -0.08000631f, 0.09943399f, 0.00116803f, -0.03266958f, 0.06262738f, -0.05154641f, 0.05079794f, 
    0.13644685f, -0.10028952f, -0.05103376f, 0.17022847f, -0.16296348f, -0.35094032f, 0.07931868f, 0.03389006f, 
    0.14444596f, 0.00574116f, -0.09552399f, 0.02026647f, 0.19163686f, 0.04011716f, -0.06942251f, -0.12013836f, 
    -0.02164937f, -0.27976748f, -0.18484676f, -0.33320931f, 0.40104589f, 0.38276333f, 0.07218892f, 0.19850139f, 
    0.02550017f, -0.26544490f, 0.05560821f, 0.12784828f, -0.15207492f, -0.28611416f, -0.44087070f, 0.08991652f, 
    -0.31544152f, 0.01547377f, -0.12063750f, -0.11089601f, -0.19255120f, 0.19934082f, 0.05559642f, -0.01245320f, 
    -0.06369654f, 0.02912980f, -0.12330882f, 0.24316910f, -0.52349198f, -0.06552533f, 0.13955687f, -0.12099317f, 
    0.10946795f, 0.00349248f, -0.34358549f, 0.07361478f, -0.01453106f, -0.02713164f, 0.02824686f, 0.00532931f, 
    -0.25849351f, -0.33563209f, 0.00659781f, -0.58662945f, -0.34523365f, 0.20069821f, 0.05921023f, -0.33773029f, 
    0.05218949f, -0.15545799f, 0.13572745f, 0.08744850f, -0.01115944f, -0.00924891f, 0.11923270f, 0.01682524f, 
    0.24051647f, -0.02792581f, 0.17892259f, 0.12046303f, 0.12588885f, 0.03796444f, 0.05769027f, -0.05606451f, 
    0.28401592f, 0.34587592f, -0.12799077f, 0.18185052f, -0.21012472f, -0.23604137f, -0.00041442f, -0.03587475f, 
    0.10428262f, 0.32290360f, -0.30147776f, 0.14856422f, -0.17558321f, 0.06350222f, 0.30337220f, 0.07398754f, 
    0.17901433f, 0.12163180f, 0.10038820f, -0.11277843f, 0.18325156f, 0.43136787f, -0.11476909f, 0.07170781f, 
    -0.03756429f, -0.38088933f, -0.13261883f, -0.02803138f, 0.07576107f, 0.05936983f, 0.59561968f, -0.17916866f, 
    -0.17305219f, -0.11982466f, -0.07940590f, 0.19441159f, 0.03425967f, 0.00326303f, -0.16757123f, 0.14315842f, 
    0.16567607f, -0.15393785f, -0.15282917f, -0.09136183f, 0.03250297f, 0.17558663f, -0.18095079f, 0.04400989f, 
    -0.31119773f, 0.02309408f, 0.09257049f, 0.07077170f, -0.03814422f, 0.15530466f, -0.01230217f, -0.12486364f, 
    -0.43219283f, 0.05655491f, -0.40254703f, 0.05955819f, 0.25766581f, 0.09295411f, -0.07571834f, -0.28502393f, 
    0.18070418f, 0.37437874f, -0.14595905f, -0.03007052f, 0.11845327f, 0.26089287f, -0.07412881f, -0.04758271f, 
    0.04450681f, 0.14349122f, -0.08391140f, 0.04373333f, 0.11534657f, -0.04343750f, -0.10921354f, -0.13868341f, 
    0.41828468f, -0.11296441f, -0.22926998f, -0.06529286f, 0.05481175f, 0.23648915f, 0.11983292f, 0.24687743f, 
    -0.00990256f, 0.08904786f, -0.11892322f, 0.25423676f, 0.29604861f, 0.04748307f, -0.13845162f, 0.08902506f, 
    0.04399123f, -0.01411277f, 0.18140559f, -0.32753181f, 0.02758884f, 0.16387476f, 0.13552393f, -0.09931355f, 
    0.04791529f, 0.18285629f, 0.02714006f, 0.05556192f, -0.04294937f, -0.07415947f, -0.12294892f, 0.06732323f, 
    -0.13661025f, 0.26646540f, 0.03024188f, 0.33115572f, 0.00048638f, 0.36667976f, -0.10206336f, -0.12632219f, 
    -0.07074069f, -0.15387462f, -0.01668315f, -0.25243747f, 0.17804146f, 0.49058276f, 0.07281451f, -0.42826173f, 
    0.10608557f, -0.13609874f, 0.20329274f, -0.10083774f, -0.46940911f, -0.42571029f, -0.09508425f, -0.01871726f, 
    0.07451348f, 0.21324822f, 0.16718630f, -0.11415778f, 0.10032348f, 0.01289331f, 0.12602198f, -0.29982078f, 
    0.11666201f, -0.25444117f, 0.30495730f, 0.14948668f, -0.14745003f, -0.03791637f, -0.09474434f, -0.32572052f, 
    -0.13043043f, -0.08333822f, 0.04141211f, 0.05709593f, 0.02492215f, 0.08481827f, -0.07231072f, -0.05200022f, 
    0.06059752f, 0.06622539f, 0.04759697f, 0.17362079f, -0.24715298f, 0.06635328f, 0.03287643f, 0.40393937f, 
    0.11723584f, -0.18338734f, 0.17600872f, -0.00760342f, -0.18297219f, -0.07145678f, -0.13261427f, -0.04618035f, 
    0.17522758f, -0.12915403f, -0.00565514f, 0.03616391f, -0.05501794f, -0.23216185f, -0.09182531f, 0.07712264f, 
    0.15748711f, 0.05590539f, -0.05095974f, 0.08743935f, 0.13428779f, 0.15549116f, -0.10264657f, -0.23448388f, 
    -0.14856249f, -0.06654561f, -0.00023721f, -0.24608286f, -0.13936128f, -0.05484249f, -0.03348227f, -0.05083242f, 
    -0.05502688f, -0.00585462f, 0.15252528f, -0.02216791f, -0.06151456f, -0.00607577f, 0.04962339f, -0.07343019f, 
    -0.03201950f, 0.05219531f, -0.04649018f, -0.04637855f, -0.07730795f, -0.08541588f, 0.15296309f, 0.05314500f, 
    0.05529947f, -0.09394950f, -0.09648983f, -0.15271428f, -0.08515950f, 0.12734839f, 0.05883338f, 0.02045963f, 
    0.04958806f, 0.13304727f, -0.09737293f, -0.11578920f, 0.02473495f, -0.04087585f, 0.00472488f, 0.06223140f, 
    0.09299547f, -0.06920572f, -0.05962658f, -0.03707834f, -0.03347139f, 0.00239676f, -0.08368163f, 0.05398616f, 
    -0.12792484f, -0.10249954f, -0.12792778f, -0.09955221f, -0.05852973f, -0.15389971f, 0.05646315f, -0.08877223f, 
    0.10422967f, -0.18042584f, -0.17886335f, -0.13147549f, -0.00864887f, -0.10121328f, -0.10669271f, -0.20271684f, 
    -0.09111658f, -0.17351392f, 0.00157366f, -0.08699720f, -0.00710311f, -0.01310672f, -0.10810027f, -0.02860485f, 
    0.06936169f, -0.07582016f, 0.01554424f, -0.11767864f, -0.10208662f, 0.00398033f, 0.10902394f, 0.13704883f, 
    -0.14006996f, -0.09411173f, -0.03714242f, -0.07147202f, -0.09173702f, 0.05115709f, -0.03470895f, 0.02866207f, 
    -0.11330009f, -0.01397614f, 0.07849665f, -0.02389931f, 0.15601248f, -0.02675089f, 0.01460343f, -0.14501990f, 
    0.15897749f, -0.04144186f, -0.01719061f, -0.06148005f, -0.21056341f, -0.05897069f, 0.01823468f, -0.03355674f, 
    -0.06065177f, 0.05898087f, 0.08507054f, 0.01401486f, -0.04310966f, 0.06476634f, 0.14998560f, -0.19457343f, 
    -0.15439251f, -0.04647366f, -0.07442120f, -0.17418331f, -0.02346767f, 0.00005458f, 0.04192995f, -0.11030712f, 
    0.11825228f, -0.02042659f, 0.17744902f, -0.27343902f, -0.15735468f, -0.12925781f, -0.09153926f, 0.02262707f, 
    -0.17791288f, -0.10243388f, -0.03149276f, -0.17317611f, -0.12698273f, 0.10460098f, -0.07329094f, -0.02301795f, 
    0.03083168f, -0.17318347f, -0.13554861f, 0.20317577f, 0.02920892f, -0.23113938f, -0.04930900f, -0.00489600f, 
    -0.14285997f, 0.09332736f, 0.06761748f, -0.32571131f, -0.27877766f, 0.42014295f, -0.16995329f, 0.09314435f, 
    -0.00837482f, 0.21320382f, -0.31782478f, 0.41129437f, 0.09939085f, -0.07886571f, 0.41513580f, 0.02867308f, 
    -0.05716181f, 0.01039449f, -0.07945795f, 0.24477983f, -0.19994840f, -0.15025738f, -0.37032038f, 0.16741434f, 
    0.24504867f, -0.12169304f, 0.16618526f, 0.40358859f, 0.09991080f, 0.24454030f, 0.04151642f, -0.07542547f, 
    0.05332791f, -0.09310462f, 0.19408739f, -0.23350941f, 0.03548820f, 0.01575169f, 0.15551762f, 0.13723955f, 
    -0.02456896f, 0.30441138f, 0.18018515f, -0.02244031f, -0.02970285f, 0.01582924f, 0.02400268f, 0.33510613f, 
    0.15306503f, 0.13047066f, -0.17048058f, 0.22546348f, 0.37361896f, 0.39557752f, -0.06926592f, 0.08254575f, 
    -0.00978731f, 0.16742271f, -0.30412728f, 0.10487927f, 0.00025059f, 0.08537693f, 0.46559560f, 0.10602549f, 
    0.33501557f, 0.09937896f, -0.12609567f, -0.02982727f, 0.08806539f, 0.12930791f, -0.08248714f, -0.07447125f, 
    0.00954308f, -0.03265825f, -0.17916004f, 0.07961022f, 0.36543769f, 0.16783001f, 0.20187724f, 0.09051093f, 
    -0.31242141f, 0.04599859f, -0.07336771f, 0.29204947f, 0.29269013f, 0.04743960f, -0.01447605f, -0.11250976f, 
    0.07645564f, 0.10099808f, -0.00609805f, -0.17765868f, 0.43871742f, 0.01309896f, 0.09372083f, 0.03675881f, 
    -0.20303093f, 0.17944454f, -0.05985370f, 0.15782706f, 0.18966804f, 0.38942260f, 0.07754502f, 0.07829781f, 
    -0.29398176f, 0.07323577f, 0.04841454f, 0.15815324f, 0.16812350f, -0.00462594f, -0.26486561f, 0.09789930f, 
    -0.09692952f, 0.01452153f, -0.08518024f, -0.01341873f, 0.01720130f, -0.05118389f, 0.00179106f, -0.00050047f, 
    0.04411783f, -0.04781518f, 0.02352761f, 0.00020020f, -0.05961923f, -0.03606120f, -0.03546844f, -0.07927296f, 
    -0.05590287f, 0.02080052f, 0.07804088f, -0.07545011f, -0.11243340f, -0.01181808f, -0.09139326f, -0.03841742f, 
    0.06027490f, 0.00842714f, 0.07783232f, -0.01280439f, 0.00636901f, -0.10786995f, -0.01960886f, -0.04887726f, 
    -0.08677446f, 0.00684150f, -0.04651533f, 0.07049882f, 0.01093192f, -0.06819793f, -0.07934273f, -0.08714165f, 
    -0.02565463f, 0.03236504f, -0.03164577f, -0.00824630f, -0.06363655f, -0.10130553f, -0.05955165f, 0.04408998f, 
    0.00471320f, 0.00739359f, 0.05634054f, 0.00111382f, -0.01583767f, 0.05827849f, -0.09512582f, -0.08104212f, 
    0.04873300f, -0.01102646f, 0.02323392f, -0.07873963f, 0.03692159f, -0.05206881f, -0.02949868f, -0.01304957f, 
    -0.07335007f, -0.03615887f, -0.08377945f, -0.03326953f, 0.02999441f, 0.00445480f, -0.08340114f, -0.07392839f, 
    0.03735427f, -0.02491844f, 0.01086275f, -0.09380259f, -0.06162362f, 0.01868984f, -0.10494263f, -0.00359987f, 
    -0.12190655f, -0.06588245f, 0.03390996f, -0.08250525f, 0.02686369f, -0.11312804f, -0.04233051f, 0.00086592f, 
    0.04683263f, 0.05899087f, 0.00804779f, -0.05773611f, -0.10288868f, 0.06947989f, 0.00304820f, -0.07887978f, 
    -0.10778220f, -0.00683587f, 0.06426684f, -0.00906830f, -0.04911759f, 0.07342572f, -0.06499083f, -0.02531492f, 
    -0.01833325f, -0.08283310f, 0.06447360f, 0.08199082f, -0.01002950f, 0.03101545f, -0.10864149f, 0.02904293f, 
    -0.11039066f, -0.04495103f, 0.04512146f, 0.02052741f, -0.02312981f, -0.03604404f, 0.06541298f, -0.06406862f, 
    0.04369049f, 0.02585659f, 0.03374360f, 0.01745331f, 0.04595013f, -0.02038921f, 0.06916109f, -0.06239457f, 
    0.07099891f, 0.08170693f, 0.10691640f, 0.11989281f, 0.03649749f, -0.32878596f, 0.03881440f, 0.09985460f, 
    -0.05061187f, -0.25073665f, 0.13258445f, -0.22397394f, 0.09478913f, 0.01794318f, 0.24757735f, 0.13728416f, 
    0.04043771f, 0.14612317f, 0.11175336f, 0.08067200f, 0.03300862f, -0.38209203f, 0.16845961f, -0.18944721f, 
    0.04926091f, -0.08222077f, 0.13489474f, -0.05322508f, 0.17382124f, 0.14357316f, -0.15091562f, -0.04436714f, 
    -0.12496422f, 0.12326900f, 0.14842613f, 0.29744804f, 0.17627828f, 0.21550176f, -0.09254584f, -0.00105968f, 
    0.10544232f, -0.02839079f, -0.13532601f, 0.16470656f, 0.15757029f, 0.00288456f, 0.19882526f, 0.06133644f, 
    0.10350773f, -0.03254904f, -0.00464336f, 0.00796917f, 0.05777418f, -0.00559087f, 0.00435997f, 0.01284915f, 
    0.10866816f, 0.18303075f, -0.07365897f, 0.06592971f, 0.12383740f, 0.04997180f, 0.14253165f, -0.06022596f, 
    0.07385130f, 0.08197416f, -0.10229096f, 0.01854671f, -0.03388586f, -0.12197588f, 0.10536262f, -0.01391827f, 
    -0.11241318f, -0.07324248f, -0.04948241f, -0.05970138f, 0.14331689f, -0.01764813f, -0.24167517f, -0.04869507f, 
    -0.15700755f, 0.32195634f, 0.10637272f, 0.04950197f, -0.02566238f, -0.13451566f, 0.12387614f, 0.19740459f, 
    0.19236758f, 0.14181823f, 0.07223570f, 0.01740697f, -0.03223608f, -0.11250196f, -0.25224704f, 0.05734991f, 
    0.02263942f, 0.00856631f, 0.16703266f, -0.12588076f, 0.08731367f, 0.02190866f, 0.04193192f, -0.17623557f, 
    -0.13789782f, -0.20429434f, 0.05670887f, 0.20826966f, -0.10958532f, -0.00910240f, 0.13701682f, -0.03892384f, 
    0.13299716f, 0.08182579f, -0.00302401f, 0.15091540f, -0.02309470f, 0.07036041f, 0.03384722f, 0.04244578f, 
    0.26299152f, 0.00294192f, -0.30727619f, -0.00913193f, 0.07345814f, 0.22324121f, 0.10014266f, 0.02282942f, 
    -0.00285461f, -0.04926319f, 0.01778569f, 0.16830073f, 0.01894778f, -0.27599707f, -0.08534090f, 0.19050622f, 
    -0.00188801f, 0.19652332f, 0.09514872f, -0.29103863f, -0.08619089f, 0.04584017f, 0.05780041f, 0.16449158f, 
    -0.17595518f, -0.05142768f, 0.17425604f, 0.06798028f, 0.18802443f, -0.10245426f, 0.14971110f, -0.10824791f, 
    0.02335261f, -0.12304763f, 0.07843012f, -0.01932099f, 0.18867706f, 0.12253930f, 0.12041130f, 0.15746936f, 
    0.09108480f, 0.02331238f, 0.34282210f, 0.22689325f, 0.02266368f, 0.07515761f, 0.21947980f, -0.10910930f, 
    0.02247863f, -0.20357136f, 0.07713087f, 0.22040299f, 0.19332963f, 0.02129714f, 0.23586568f, 0.10212635f, 
    -0.08342920f, 0.04786876f, 0.11564793f, 0.14217103f, -0.00679443f, -0.04170871f, -0.03533691f, 0.29887116f, 
    -0.22686006f, 0.06713077f, -0.09895332f, 0.09256610f, 0.14821839f, 0.31260338f, 0.02249141f, -0.05169887f, 
    -0.17634077f, 0.01547222f, -0.03705585f, 0.13585752f, 0.16016287f, -0.11447955f, -0.06317279f, 0.10626100f, 
    0.04989846f, 0.00608608f, -0.25030705f, 0.07676734f, -0.01927397f, -0.04484602f, -0.11423800f, -0.08374187f, 
    0.02991214f, 0.07250108f, 0.23705935f, -0.02365479f, 0.11687057f, -0.22268683f, 0.07046728f, -0.23767570f, 
    0.00473227f, -0.52813476f, -0.21732429f, 0.00350658f, -0.02020714f, 0.05267501f, -0.54765165f, -0.09147094f, 
    0.09913236f, 0.13861009f, 0.01618784f, -0.25364569f, -0.11911147f, 0.01103152f, 0.09483632f, -0.01464671f, 
    0.17521992f, -0.01659095f, 0.23920669f, 0.06124715f, -0.17798688f, 0.04991535f, 0.02503308f, 0.02313746f, 
    0.07199517f, -0.07122874f, 0.00615002f, -0.01813813f, -0.02758830f, -0.12635365f, 0.06399029f, -0.00616860f, 
    0.11099832f, 0.08601980f, -0.22903061f, 0.06824930f, -0.05800916f, 0.19002302f, 0.05838627f, -0.00619192f, 
    -0.01850148f, -0.00811990f, -0.00309469f, 0.28510195f, 0.18551055f, -0.02113093f, -0.02428293f, 0.25499111f, 
    -0.21127920f, -0.18508916f, 0.01533477f, -0.28356284f, 0.07773823f, 0.00397636f, -0.11495651f, 0.24386528f, 
    0.02143253f, -0.00117416f, 0.32063177f, -0.01499987f, -0.03837557f, 0.06957392f, -0.00876142f, -0.14179318f, 
    -0.07022311f, -0.07473539f, 0.35872942f, 0.02418425f, -0.68909371f, 0.02258652f, 0.05179042f, 0.11187074f, 
    0.19683297f, 0.00455294f, -0.07668068f, 0.44746149f, 0.01366633f, 0.07804053f, 0.23201682f, -0.15076832f, 
    -0.24807777f, -0.03548701f, -0.01251836f, -0.25639829f, 0.03188516f, 0.12169334f, 0.09766150f, -0.10789352f, 
    0.11298586f, 0.24448803f, 0.10429684f, -0.00889976f, -0.05878705f, -0.00390846f, 0.23505630f, 0.51159263f, 
    -0.01180803f, -0.08634555f, -0.08184873f, 0.08211000f, 0.20118067f, 0.33002016f, 0.12020927f, -0.00579028f, 
    -0.03192735f, 0.09836449f, -0.14786619f, 0.14211607f, -0.11089008f, -0.05571018f, 0.07606535f, 0.09003461f, 
    0.11086208f, 0.15774606f, 0.03895612f, -0.11421248f, -0.06955043f, 0.03307951f, -0.01653498f, -0.13430630f, 
    0.10235979f, 0.44598186f, 0.25286332f, -0.02063777f, -0.06001220f, 0.03956186f, 0.09745392f, -0.00804796f, 
    -0.02370015f, -0.40878952f, -0.19492871f, -0.02069912f, -0.26598796f, 0.12545563f, -0.36872414f, -0.07867002f, 
    -0.17951782f, 0.03643903f, 0.08200922f, -0.15557329f, 0.02134163f, 0.04836312f, 0.05028639f, 0.12206917f, 
    -0.01583417f, -0.12778042f, 0.03393317f, 0.07163348f, -0.03573712f, 0.12764300f, -0.25106943f, 0.23678851f, 
    -0.17489779f, 0.08760984f, 0.04529820f, 0.03367873f, 0.03492691f, 0.08829382f, 0.01091457f, 0.02253016f, 
    -0.02994829f, -0.03531718f, -0.09426613f, 0.08769439f, 0.06400952f, 0.04765350f, 0.05679016f, -0.06487086f, 
    -0.02231737f, 0.00931650f, -0.06916717f, -0.02091533f, 0.01935904f, 0.04543928f, 0.00827065f, -0.08216368f, 
    -0.10450142f, -0.06573574f, -0.08661129f, -0.02928832f, 0.02352426f, -0.06338767f, -0.01268387f, 0.01124537f, 
    0.06267281f, -0.00131157f, 0.01629959f, -0.10356859f, -0.03411544f, -0.08798704f, 0.03523306f, -0.08062251f, 
    0.02562893f, -0.09419283f, -0.01513962f, 0.04096124f, -0.06877323f, 0.04522290f, -0.05201905f, -0.08387078f, 
    0.01040263f, 0.00199880f, 0.08528341f, -0.05079414f, -0.02537739f, 0.01448570f, 0.06032195f, -0.04992704f, 
    -0.04995806f, -0.03953457f, -0.03569557f, -0.00326711f, 0.04290297f, -0.09270596f, -0.04900262f, -0.04437264f, 
    0.04057117f, 0.05991359f, -0.03137364f, -0.02277902f, -0.03294445f, 0.06551587f, -0.05969549f, 0.04054489f, 
    -0.03301819f, -0.01255536f, 0.06112209f, -0.05731741f, -0.01030210f, -0.05519601f, -0.05338157f, 0.05126541f, 
    0.03529421f, -0.02909875f, 0.07400882f, -0.06036313f, -0.07347231f, -0.02870863f, 0.08135802f, 0.02588487f, 
    0.00010285f, 0.04088931f, -0.02210871f, -0.09329701f, 0.06249907f, -0.00737570f, -0.06941836f, -0.09126478f, 
    -0.07138660f, -0.08077600f, 0.02033557f, -0.06464009f, -0.00083308f, 0.04962192f, -0.07839164f, -0.02565784f, 
    -0.00419526f, -0.07348806f, -0.08564954f, -0.05736804f, -0.06125605f, -0.06351916f, 0.01670106f, -0.03039244f, 
    0.02863410f, 0.00062146f, 0.07807192f, -0.07028355f, -0.03174485f, 0.01712159f, -0.08349238f, 0.05614558f, 
    -0.08800939f, 0.06249265f, -0.09105100f, -0.00721537f, -0.05700752f, -0.05047971f, -0.08833785f, -0.04267903f, 
    0.00279530f, 0.04854542f, -0.01026619f, 0.01656373f, -0.08628710f, 0.08314835f, 0.03883632f, 0.02992349f, 
    -0.03353893f, 0.08094235f, -0.01824860f, 0.02680768f, 0.02327953f, -0.06315189f, -0.10501107f, -0.04917849f, 
    -0.04141037f, -0.03225216f, -0.04913956f, -0.03676877f, 0.02199166f, 0.04205234f, 0.04919364f, -0.03393793f, 
    -0.04260924f, -0.01916493f, -0.08432852f, -0.08398081f, -0.00661660f, 0.04144266f, -0.06860179f, -0.07567088f, 
    0.04945951f, 0.01176210f, 0.00013353f, 0.02476383f, 0.02532670f, 0.05120466f, -0.04031509f, 0.07241594f, 
    -0.03013744f, -0.02095394f, -0.09326149f, -0.01621147f, -0.05249938f, 0.03745438f, -0.02701244f, 0.00587497f, 
    -0.02414613f, 0.07615879f, -0.03859448f, 0.01568688f, 0.00583404f, 0.02022789f, 0.04163943f, -0.10702302f, 
    0.07494318f, -0.01189192f, 0.05709933f, -0.08947454f, -0.11852905f, -0.09332936f, 0.00894560f, 0.02917920f, 
    -0.04244329f, 0.03778065f, 0.02550814f, 0.03699639f, -0.08707423f, 0.07917859f, -0.07086302f, -0.05157166f, 
    -0.02583404f, -0.07612558f, -0.09271424f, -0.10289980f, -0.02880836f, 0.06424592f, 0.07760128f, -0.08945464f, 
    0.03712631f, -0.07846282f, -0.10174263f, 0.00442119f, -0.00341104f, 0.04672866f, -0.06989687f, -0.02314276f, 
    0.03772974f, -0.03074010f, 0.02544428f, 0.06686847f, -0.02729123f, 0.03065577f, 0.05208673f, -0.05410760f, 
    -0.02880901f, -0.08591948f, 0.01497081f, -0.10614260f, -0.02544829f, 0.06345890f, 0.03868449f, 0.00126046f, 
    0.02452337f, -0.08279529f, 0.02164421f, -0.02382534f, -0.05785019f, -0.06822345f, 0.00392825f, -0.03629287f, 
    -0.01186723f, -0.03933256f, -0.00067419f, -0.01139265f, -0.06927171f, -0.01483777f, -0.01720551f, 0.06091532f, 
    0.00768295f, 0.01459435f, -0.00640014f, -0.01150012f, -0.08597483f, -0.10182767f, -0.01946276f, -0.03876638f, 
    -0.05044391f, 0.01065304f, 0.08583096f, -0.06344780f, -0.01248791f, -0.03398100f, 0.02573556f, -0.06527214f, 
    -0.08417003f, -0.01837476f, -0.04079291f, 0.02143420f, -0.07159321f, 0.01847517f, -0.06149450f, 0.02132592f, 
    -0.04077458f, -0.15558562f, -0.13868737f, 0.30900133f, -0.14266786f, -0.05541951f, 0.00630219f, 0.08423429f, 
    -0.08642416f, 0.20563054f, 0.15990931f, -0.23268145f, -0.24522473f, 0.20541510f, 0.01962429f, 0.21284357f, 
    0.16205129f, 0.00450552f, 0.21237734f, 0.38650352f, 0.15188371f, 0.08896627f, 0.18055850f, 0.08377789f, 
    -0.00360185f, 0.14671864f, -0.19220003f, -0.12912591f, -0.02988531f, 0.31198126f, -0.08304164f, -0.31279612f, 
    0.15553345f, 0.10395772f, -0.42085332f, 0.02627150f, 0.26589286f, 0.16469723f, 0.33138099f, 0.22645870f, 
    -0.02497003f, 0.12331716f, 0.07286464f, 0.06693575f, 0.17340298f, -0.16414195f, 0.16030261f, -0.18113790f, 
    -0.01176892f, 0.00009306f, -0.09615783f, 0.01932850f, 0.04305318f, 0.05584271f, -0.02306198f, -0.07166176f, 
    0.04834666f, -0.10714997f, 0.03204006f, 0.35818043f, 0.08546010f, -0.01762739f, 0.05607061f, -0.35961640f, 
    0.13378289f, 0.15686864f, 0.32099307f, -0.08160508f, -0.39580306f, 0.18128507f, -0.01948348f, -0.02563419f, 
    0.09760015f, 0.11022286f, 0.12061900f, -0.10896349f, -0.06626349f, 0.07386260f, -0.05237802f, -0.09257910f, 
    0.05346464f, 0.01084461f, 0.09140482f, -0.00625597f, -0.01034378f, -0.04255424f, -0.00374585f, 0.00744588f, 
    -0.18795930f, -0.36791655f, 0.15897492f, -0.16336618f, -0.09938787f, -0.01213103f, -0.34023294f, -0.43579584f, 
    -0.11375062f, -0.04462845f, -0.05951876f, -0.01957281f, 0.21795700f, 0.09577578f, -0.02925307f, 0.05734725f, 
    0.27961224f, 0.05939419f, 0.02622616f, 0.25483143f, 0.01551878f, 0.00542758f, -0.11446615f, 0.14221330f, 
    -0.08937486f, -0.09179127f, 0.04390760f, -0.11720046f, -0.03930817f, -0.28152344f, 0.08745430f, 0.08782552f, 
    0.03163241f, 0.03010090f, 0.15463740f, -0.11289608f, -0.15536454f, 0.14931573f, 0.19170243f, 0.04365407f, 
    -0.17569318f, 0.11020203f, -0.02398156f, 0.15336156f, -0.11266830f, 0.14442785f, -0.05219746f, -0.13998178f, 
    -0.00010000f, -0.04601433f, -0.41808906f, 0.12933303f, 0.04242675f, -0.25981444f, -0.26551890f, -0.05292277f, 
    0.14560233f, 0.05471792f, 0.16795045f, 0.02471721f, -0.06665628f, 0.50127137f, -0.11393488f, 0.43374407f, 
    -0.08378649f, 0.17081828f, -0.26357704f, 0.14149986f, 0.11364959f, 0.06589011f, 0.35029241f, -0.05155434f, 
    -0.06444608f, 0.00186981f, 0.03857816f, 0.15567216f, -0.04940268f, -0.15080701f, -0.16490784f, 0.29962298f, 
    0.12108573f, -0.14293478f, 0.19328275f, 0.24624929f, 0.25945017f, 0.21423911f, 0.16374616f, -0.25605893f, 
    0.09495415f, 0.22170511f, 0.24493127f, -0.17685904f, 0.09326459f, -0.01294964f, 0.17737627f, -0.05889144f, 
    -0.44496810f, -0.12736015f, 0.25809410f, 0.12940951f, -0.09599746f, 0.10570079f, -0.09401427f, 0.26480344f, 
    0.16225486f, -0.14346446f, -0.04220776f, 0.23397355f, 0.40909907f, 0.41410396f, 0.00271063f, -0.07314411f, 
    0.02030094f, 0.00399530f, -0.23434247f, -0.07511824f, 0.04051639f, 0.02440803f, 0.27749464f, -0.22330633f, 
    0.19909982f, 0.25344306f, -0.07665525f, -0.14645310f, 0.10014275f, 0.06800325f, -0.19311294f, -0.34893268f, 
    -0.20474835f, -0.19115558f, -0.08261608f, -0.11188453f, 0.37632483f, 0.17614989f, -0.51558018f, 0.05547594f, 
    -0.47341669f, 0.22741403f, -0.24506155f, 0.11376943f, 0.26393971f, 0.01630988f, 0.06124868f, -0.07099573f, 
    0.15175317f, 0.13743992f, -0.01010024f, -0.10354457f, 0.19808158f, 0.02867887f, -0.07115615f, 0.18232577f, 
    -0.16810049f, 0.09565664f, -0.10153289f, 0.15360732f, -0.06680483f, 0.20616964f, 0.04944349f, -0.17913684f, 
    -0.29571441f, 0.09966431f, 0.31838071f, -0.12154815f, 0.01150780f, 0.15852058f, -0.13221951f, 0.20081069f, 
    -0.10710757f, 0.10527075f, -0.30123919f, 0.31568408f, -0.11104576f, 0.13473585f, 0.05071300f, 0.06713309f, 
    0.08004390f, 0.20963661f, 0.12979215f, 0.05535337f, -0.28866553f, 0.11648548f, -0.12035712f, -0.00481532f, 
    0.12323301f, 0.16188866f, 0.05426854f, 0.00096286f, 0.06537896f, 0.14025265f, 0.11292462f, 0.09940361f, 
    0.06919226f, 0.14176445f, 0.05908702f, 0.01405863f, 0.41484666f, -0.10794262f, 0.04007847f, -0.22060518f, 
    0.08536635f, -0.02663649f, -0.20067795f, -0.01703845f, -0.14261724f, -0.18321861f, 0.05218274f, -0.01655244f, 
    0.10744958f, 0.32732883f, -0.13902707f, 0.14573795f, -0.29018551f, -0.17927742f, -0.33346739f, 0.00568345f, 
    -0.16317636f, -0.06638250f, -0.04805489f, 0.15244040f, 0.00489883f, 0.18064071f, -0.03017870f, -0.05490946f, 
    0.17089947f, 0.06770162f, 0.02822897f, 0.13420747f, -0.22713415f, -0.19001645f, 0.11348234f, -0.07053000f, 
    0.15041918f, 0.11171426f, 0.38775116f, -0.18698986f, -0.22502851f, -0.36617997f, 0.02986207f, -0.05354544f, 
    0.07046709f, 0.21591112f, 0.12597431f, 0.10854404f, -0.56175005f, 0.07347601f, 0.17349418f, -0.04936304f, 
    0.10500510f, -0.02869030f, -0.00600937f, 0.14662802f, 0.02242582f, 0.24012977f, 0.05453122f, -0.10063357f, 
    -0.26381293f, 0.49769381f, -0.05528037f, -0.50092703f, -0.00129802f, -0.22356474f, 0.48934641f, 0.02798284f, 
    0.11110120f, -0.28190675f, 0.00650256f, 0.18213774f, 0.01802432f, 0.05051764f, -0.25929663f, 0.04459649f, 
    0.09721053f, 0.05004782f, -0.11099318f, 0.15082566f, -0.02508101f, -0.05530754f, -0.00999183f, 0.15039331f, 
    0.10261606f, -0.11261862f, -0.01205791f, -0.15057226f, 0.00473368f, -0.04133864f, 0.01308201f, 0.09740347f, 
    -0.01085092f, 0.03675523f, 0.36134613f, 0.11659295f, 0.02150160f, 0.05578282f, 0.20471692f, -0.11321691f, 
    0.08816806f, -0.27678815f, 0.02522846f, -0.16245238f, 0.21964288f, 0.47670287f, -0.06475352f, 0.58662659f, 
    0.29210618f, 0.43348306f, -0.15956862f, 0.24237901f, -0.01223107f, -0.47694972f, -0.29522288f, -0.18850973f, 
    -0.18513368f, -0.12649605f, 0.05160503f, 0.08361273f, -0.22574781f, 0.02652110f, -0.14851959f, 0.10901144f, 
    -0.08479185f, 0.11317513f, 0.67666847f, 0.11216502f, -0.33642936f, -0.22397681f, 0.13031511f, 0.10476872f, 
    -0.04019157f, -0.13927694f, -0.07081832f, -0.06203581f, 0.08091573f, -0.23367772f, 0.31656519f, -0.28782442f, 
    0.34511712f, -0.18649563f, 0.10554960f, 0.13197955f, 0.12826820f, 0.20516230f, -0.14289504f, -0.18267831f, 
    -0.01800555f, 0.22019012f, 0.13985266f, -0.12070012f, 0.07152165f, -0.30266494f, 0.14243855f, 0.34908438f, 
    -0.17100789f, -0.04111400f, 0.23838952f, -0.02753241f, 0.06023476f, 0.18362184f, -0.14007594f, 0.16791299f, 
    0.10878394f, -0.47102419f, -0.14370430f, 0.21223174f, 0.08814768f, 0.09412718f, -0.08246472f, 0.10265555f, 
    -0.01083391f, -0.05681963f, -0.45516157f, 0.11026569f, -0.25002810f, 0.04161771f, -0.10359865f, -0.06890612f, 
    0.37305954f, 0.02692020f, 0.11274844f, 0.11391885f, -0.02260433f, 0.32948256f, -0.22281541f, 0.01550521f, 
    0.31469724f, -0.43061724f, -0.07960339f, -0.16666348f, 0.18849705f, 0.16580823f, -0.17840452f, -0.28708026f, 
    0.13298889f, 0.11627968f, 0.28537029f, 0.13373898f, -0.05732231f, 0.07860741f, 0.05943607f, 0.20812455f, 
    -0.02651088f, 0.10925814f, -0.24056891f, -0.69438428f, 0.19666459f, -0.01445454f, -0.04544459f, 0.01507415f, 
    0.07241028f, 0.09617380f, -0.01929678f, 0.07695283f, 0.04501805f, -0.01659686f, 0.04681317f, 0.05424464f, 
    -0.32313085f, -0.02369134f, -0.03050162f, 0.31270036f, -0.05811392f, -0.07448839f, -0.06945357f, -0.24607195f, 
    -0.06663607f, -0.17201068f, -0.17397711f, 0.28627041f, -0.43524492f, -0.08966120f, 0.00551039f, -0.01678253f, 
    -0.00024486f, -0.12257726f, 0.01311955f, -0.00366114f, -0.25933111f, -0.01785041f, -0.04502827f, 0.18919916f, 
    -0.01623090f, 0.08018939f, 0.32543701f, 0.00319976f, -0.04830414f, 0.21674490f, 0.12179328f, 0.14408810f, 
    -0.00106770f, 0.06311654f, -0.28467646f, -0.01759556f, 0.31434187f, 0.11980459f, 0.06656082f, -0.45928836f, 
    0.17716692f, -0.13247296f, -0.17523035f, -0.13395643f, 0.13057183f, -0.05641324f, 0.04951889f, 0.32425264f, 
    0.06889636f, -0.05297334f, -0.01379974f, 0.04340165f, -0.07409218f, -0.14998060f, -0.17673664f, -0.05674317f, 
    -0.10182340f, -0.16707434f, -0.04141483f, 0.04143351f, -0.02474851f, 0.10820816f, 0.00181804f, 0.04574930f, 
    0.15739007f, 0.03548630f, -0.07251699f, 0.12270121f, 0.01404159f, 0.02063338f, 0.06097673f, -0.19663940f, 
    0.00952571f, 0.12449856f, 0.06161151f, -0.03662639f, 0.10732984f, -0.18390784f, -0.02555476f, -0.08503591f, 
    0.09146847f, 0.10239531f, -0.08003800f, -0.06787806f, -0.20963809f, 0.01246305f, 0.26445416f, -0.01451792f, 
    0.00083885f, 0.02478520f, -0.11215091f, 0.08560833f, -0.07334183f, 0.18631753f, -0.10661905f, -0.01442017f, 
    -0.41702154f, -0.08562356f, -0.07797404f, -0.58639216f, 0.03256673f, -0.19114812f, 0.11298988f, -0.51272368f, 
    0.06677849f, -0.16052759f, 0.01223421f, 0.17877889f, 0.10783766f, 0.04360099f, -0.15742466f, -0.08157028f, 
    0.07109890f, -0.03224859f, -0.17509598f, -0.01178990f, 0.04321893f, -0.08853918f, -0.05579317f, 0.07180616f, 
    0.01397446f, -0.14298862f, 0.00523662f, -0.23378657f, -0.07870762f, -0.06581954f, -0.05815320f, 0.03458091f, 
    0.09828364f, 0.03547559f, 0.14048825f, -0.05266751f, -0.06909392f, 0.10293862f, 0.18960823f, 0.08350078f, 
    -0.00181530f, -0.03684456f, 0.02446471f, -0.05087749f, 0.03662851f, -0.02459278f, -0.02082891f, -0.08575215f, 
    -0.08103874f, -0.00809729f, -0.01102179f, -0.04282078f, 0.04706262f, -0.05120406f, 0.04069646f, -0.01838280f, 
    -0.02313306f, -0.01232559f, -0.05309701f, -0.10061361f, -0.07418055f, -0.04224224f, 0.04369203f, 0.04694227f, 
    0.02741715f, -0.06892799f, 0.06551777f, 0.03938932f, -0.07767401f, 0.06273662f, -0.02900377f, 0.05034189f, 
    0.05985182f, -0.08394945f, -0.01833135f, -0.05598051f, -0.09047926f, 0.06185852f, -0.00304903f, 0.00765084f, 
    0.03914117f, 0.00810978f, 0.03325639f, -0.08382286f, 0.05560909f, -0.03812810f, 0.04872036f, -0.05553827f, 
    -0.10300039f, -0.07280959f, -0.05810371f, -0.05594071f, -0.06761937f, -0.05747884f, -0.07870649f, -0.02523655f, 
    -0.00006263f, 0.01882538f, 0.03848069f, 0.02971477f, -0.04824658f, 0.05497308f, -0.00692713f, 0.03274225f, 
    -0.08487646f, -0.06697505f, 0.00712522f, 0.00809813f, -0.05630187f, -0.09875177f, -0.06773480f, -0.03922818f, 
    0.03425926f, -0.01886288f, -0.00667380f, -0.06617779f, -0.07670443f, -0.05131532f, 0.00003537f, -0.05447206f, 
    -0.07373817f, 0.06384853f, 0.03792512f, -0.08670886f, 0.05504571f, -0.02227077f, -0.07819887f, 0.05887496f, 
    0.06072307f, -0.02127947f, -0.08383596f, -0.04935597f, -0.03238020f, 0.01296128f, -0.01254501f, -0.02807665f, 
    -0.09355128f, 0.05044451f, 0.01025577f, -0.07164077f, 0.02468730f, -0.02262138f, -0.05553613f, -0.03039185f, 
    -0.03165637f, -0.03913344f, -0.07593100f, -0.08440386f, 0.01041928f, 0.05763102f, -0.05362836f, -0.03548134f, 
    0.02739307f, -0.07368138f, -0.05963090f, 0.04033369f, -0.10151976f, 0.03776109f, 0.04944449f, 0.06439935f, 
    0.04693485f, 0.07998359f, 0.06568209f, -0.00598208f, -0.01703637f, -0.03859951f, 0.01118771f, -0.08159596f, 
    0.06324010f, 0.18310308f, -0.29571626f, 0.15073527f, -0.06464759f, 0.40876329f, -0.01307339f, 0.02316020f, 
    -0.31689224f, -0.29793414f, 0.08360338f, -0.04711581f, -0.14419609f, -0.06848721f, -0.14983858f, 0.04644212f, 
    0.18363349f, 0.11348642f, -0.01917313f, 0.07878517f, -0.13780341f, -0.00647674f, -0.04896482f, 0.11886411f, 
    -0.06049085f, -0.05553223f, -0.43906468f, 0.08600393f, 0.08646239f, 0.07880251f, 0.14498492f, -0.34498128f, 
    0.16960838f, -0.03232953f, -0.11476956f, 0.07342251f, 0.18861222f, 0.04749680f, 0.13615051f, 0.07573871f, 
    -0.49355602f, -0.09564018f, 0.01716087f, 0.00079831f, -0.02254741f, -0.01344643f, 0.07480552f, -0.24394028f, 
    0.12704603f, 0.04124990f, 0.00654017f, 0.30152705f, 0.02688872f, 0.32262185f, 0.09331608f, -0.07301975f, 
    0.04739652f, -0.18467280f, 0.25592834f, 0.10145628f, 0.07810388f, 0.31853169f, 0.04401675f, -0.40647501f, 
    0.24325813f, -0.02004518f, 0.06719941f, -0.10206962f, -0.43790498f, -0.17650878f, 0.06351116f, -0.08209585f, 
    0.17175941f, 0.29312065f, -0.02202769f, -0.34329566f, -0.07149532f, 0.04699352f, 0.11085407f, -0.32338712f, 
    -0.10262590f, 0.21665123f, 0.28591779f, -0.01589709f, 0.14871444f, 0.11254476f, -0.00188456f, -0.10542508f, 
    0.01296342f, -0.34116250f, -0.17246483f, -0.28202119f, -0.12787415f, -0.00670762f, -0.28678435f, -0.38695055f, 
    -0.26288792f, 0.10633173f, -0.17455783f, 0.25808015f, 0.01013226f, 0.06959153f, -0.21903707f, 0.37961435f, 
    0.13293806f, -0.27211967f, -0.14636582f, 0.07668957f, 0.16825573f, 0.05661234f, -0.08555776f, 0.10956072f, 
    -0.12327624f, -0.24910043f, 0.02020329f, 0.26738101f, -0.31575644f, 0.51853871f, 0.00960515f, 0.06333973f, 
    -0.14220712f, 0.04826584f, -0.06113178f, -0.13411415f, 0.30740622f, 0.25348598f, 0.06328008f, 0.00360120f, 
    0.02648606f, -0.21142483f, -0.12781341f, -0.11310601f, 0.08743790f, -0.38923964f, -0.02675311f, 0.25808698f, 
    0.00696452f, -0.54976392f, 0.25674891f, -0.18771683f, 0.06896470f, 0.01817085f, -0.10094052f, 0.14148596f, 
    -0.11888397f, -0.03148315f, -0.02620972f, -0.44641933f, -0.02417668f, 0.10584207f, 0.07058486f, -0.03175686f, 
    0.01726805f, -0.04523066f, -0.11817257f, 0.05656898f, 0.01859692f, 0.03466214f, 0.18162847f, 0.16254345f, 
    0.07591356f, 0.13477932f, -0.26798537f, 0.10793718f, -0.15009661f, -0.02898605f, -0.16942279f, -0.07976633f, 
    0.13391106f, -0.07412153f, -0.00302053f, -0.50346678f, -0.35416257f, 0.16401370f, 0.04900611f, -0.00017873f, 
    0.05705678f, -0.14832214f, 0.02716327f, -0.15407799f, -0.01541661f, -0.26527008f, -0.01252734f, 0.19042675f, 
    0.03150477f, 0.28875098f, -0.18063746f, -0.09574240f, 0.21978633f, -0.00992552f, 0.20379408f, 0.16011952f, 
    -0.12256753f, 0.31837046f, -0.30355150f, 0.12497601f, 0.27037326f, -0.11748605f, -0.03465129f, 0.01412637f, 
    0.11457342f, 0.15048927f, 0.01157971f, 0.21248621f, -0.02718540f, 0.01625035f, 0.39049610f, 0.20898566f, 
    0.25660509f, 0.13097787f, 0.27958372f, 0.10415712f, 0.04877728f, 0.07337154f, -0.05428921f, 0.08597538f, 
    -0.01251945f, -0.13671437f, -0.14711103f, -0.07626745f, 0.06436449f, 0.14490719f, 0.83532560f, -0.09733897f, 
    -0.00262747f, -0.25630558f, -0.17243323f, -0.11707851f, 0.18788078f, 0.02629576f, 0.05693445f, 0.08234370f, 
    -0.07550637f, 0.10918282f, 0.22866157f, -0.02535871f, 0.00893593f, 0.16647205f, 0.05030088f, 0.18742576f, 
    -0.10342409f, 0.05652257f, 0.10005911f, -0.26460332f, 0.29774660f, -0.13351969f, 0.06248296f, -0.23749493f, 
    -0.10927518f, 0.06418698f, -0.13925365f, 0.20909460f, -0.08873661f, -0.06672929f, -0.22035229f, -0.18072981f, 
    -0.02637424f, -0.08834244f, 0.04515751f, 0.09829943f, -0.08310913f, 0.00163600f, -0.06293308f, -0.11707733f, 
    -0.08261193f, -0.02159326f, 0.01284219f, 0.07008233f, 0.09157343f, -0.03243766f, 0.04671894f, -0.07242499f, 
    0.03167674f, 0.05767104f, -0.02306341f, -0.07099552f, -0.13984445f, 0.01042125f, 0.02816452f, -0.02345042f, 
    0.06389229f, -0.12618876f, -0.15572453f, -0.03652872f, -0.09307990f, -0.02597559f, -0.10483572f, -0.08715596f, 
    -0.08025661f, -0.11532380f, -0.03669171f, -0.09152329f, 0.00902438f, 0.05216787f, -0.10165103f, 0.03953857f, 
    0.05456743f, -0.09734759f, 0.03547472f, -0.07593354f, -0.08149249f, 0.02563294f, -0.02075434f, 0.02421114f, 
    -0.06502082f, -0.16038813f, -0.05944813f, 0.02461469f, -0.00524749f, -0.03645729f, -0.06453413f, -0.13530962f, 
    0.02271280f, -0.05414551f, 0.01212420f, -0.03788412f, -0.06463241f, -0.09071720f, -0.04879994f, 0.03259820f, 
    -0.01800719f, -0.08199027f, -0.08369689f, -0.11542679f, -0.01016578f, 0.05747795f, -0.06014508f, 0.07870410f, 
    0.02863574f, 0.00625327f, 0.00974739f, -0.07680565f, -0.03005906f, 0.06227355f, 0.03565546f, -0.06611630f, 
    -0.11316976f, -0.03431257f, 0.02399666f, 0.07990547f, 0.00917950f, -0.01941401f, -0.04016446f, -0.06595627f, 
    0.03838374f, -0.00657209f, 0.00263489f, 0.09267507f, -0.06400575f, -0.10280558f, 0.00104355f, 0.03081017f, 
    0.05533694f, -0.09147260f, -0.11094757f, -0.01994569f, 0.00743071f, -0.04548120f, -0.05165891f, 0.01079310f, 
    0.01224288f, -0.01391895f, -0.10793296f, 0.00576507f, -0.07456974f, -0.12578797f, -0.14356551f, -0.08879364f, 
    0.00635385f, 0.00689011f, 0.04347269f, -0.00912292f, -0.09603395f, -0.04618660f, 0.02697035f, -0.04903496f, 
    -0.13096258f, 0.09607222f, 0.10657303f, -0.04484372f, -0.03717304f, -0.09489274f, 0.01827750f, 0.05976334f, 
    -0.00464528f, -0.02938711f, -0.05973379f, 0.05931491f, 0.03853004f, 0.10733637f, -0.01383216f, -0.11951728f, 
    0.00181993f, 0.05928110f, -0.02539614f, 0.00232404f, -0.01497281f, 0.03595538f, -0.13443017f, -0.11304200f, 
    0.02492289f, -0.03219993f, -0.09479180f, 0.00311979f, 0.04502613f, -0.00750961f, -0.04117662f, -0.02963533f, 
    -0.02277643f, -0.01228860f, -0.06194910f, 0.03513813f, 0.09973259f, -0.00696353f, -0.06869683f, -0.00090212f, 
    0.02952329f, 0.05666940f, -0.00018919f, -0.01068411f, -0.02807535f, -0.08497843f, 0.07571097f, 0.02093835f, 
    -0.03338749f, -0.00808150f, 0.02649516f, -0.07428840f, 0.01921376f, -0.02479979f, 0.09753413f, -0.10954261f, 
    -0.06702773f, 0.00007036f, -0.07267544f, -0.05701203f, 0.05565620f, 0.03309651f, 0.06857730f, -0.04437316f, 
    0.04493602f, -0.01200975f, 0.05017978f, 0.01783263f, -0.03492017f, -0.10546713f, -0.04414951f, 0.04837351f, 
    -0.04788496f, -0.09103367f, -0.07464724f, -0.12121365f, 0.02596739f, -0.06674877f, -0.07092114f, 0.07106278f, 
    -0.00730207f, 0.06495152f, -0.07648525f, -0.05244592f, -0.05297831f, 0.08697619f, 0.06362432f, 0.03626200f, 
    -0.09767847f, 0.04426084f, -0.07021180f, -0.06136214f, 0.00755392f, 0.00159155f, -0.02822178f, -0.04529465f, 
    -0.09885097f, -0.04179324f, 0.01546920f, -0.05089165f, -0.03521872f, -0.06188397f, -0.03528014f, 0.06851304f, 
    -0.02536159f, -0.01550582f, -0.08130194f, 0.03566276f, -0.08642653f, 0.02186798f, -0.02682539f, 0.04204925f, 
    -0.00386966f, -0.01284276f, -0.03654097f, -0.00043095f, -0.03709078f, -0.00415547f, 0.01723677f, -0.10101636f, 
    -0.03601664f, -0.11486085f, -0.01664756f, 0.06318026f, -0.11590926f, -0.04437982f, -0.06587433f, 0.02929878f, 
    -0.08062693f, 0.02608541f, -0.00800948f, -0.02537050f, 0.02625730f, -0.01290562f, -0.08005892f, -0.04749994f, 
    -0.13139275f, -0.10845952f, -0.00331946f, -0.02242952f, 0.00536462f, -0.08298934f, 0.04816145f, -0.02576084f, 
    -0.10324098f, -0.03018438f, -0.12568250f, -0.00671406f, -0.10060591f, 0.01159496f, -0.06395648f, 0.08851899f, 
    -0.06221516f, 0.07121691f, -0.01559863f, 0.00029013f, -0.06083202f, -0.10614876f, -0.09964801f, 0.00727296f, 
    0.02507253f, -0.10466170f, -0.06154864f, -0.06811532f, -0.04356810f, -0.12370574f, -0.13553305f, -0.05550470f, 
    -0.06580906f, -0.08796882f, -0.05267572f, -0.09981017f, 0.01102832f, 0.07165480f, -0.07268659f, -0.05940984f, 
    -0.04854136f, -0.03251394f, 0.00987326f, 0.02845916f, -0.01028988f, -0.06826362f, 0.00078255f, 0.08030172f, 
    -0.09173908f, 0.01415953f, -0.10478550f, -0.06841572f, -0.06718395f, 0.02468267f, -0.13383129f, 0.04533013f, 
    -0.11474945f, -0.08286096f, -0.08583318f, 0.07593713f, -0.05029550f, 0.03544291f, -0.03547747f, -0.06945664f, 
    0.09815382f, -0.02636203f, 0.01832075f, -0.13697366f, -0.08217985f, -0.12153986f, -0.02013525f, 0.05176281f, 
    0.00178182f, -0.02919723f, -0.06942204f, -0.02383175f, -0.00666119f, 0.07490923f, 0.05858213f, 0.02439928f, 
    0.07667187f, -0.06565606f, 0.00077183f, 0.05370457f, 0.02432605f, 0.01436499f, 0.06345281f, 0.03877493f, 
    -0.07528667f, 0.07373304f, 0.03745941f, -0.04476132f, -0.14151472f, -0.01883832f, -0.10036416f, 0.04383726f, 
    -0.01693301f, 0.00513114f, -0.03702728f, 0.00876996f, 0.01856939f, -0.05657604f, -0.08858959f, -0.09254847f, 
    -0.14568636f, -0.10287759f, 0.03944768f, 0.05621328f, -0.00760207f, -0.02293898f, 0.02352354f, 0.04598969f, 
    -0.02114985f, -0.05958496f, -0.07420494f, -0.00787507f, -0.00589113f, 0.03993287f, 0.00006432f, 0.04916317f, 
    0.08222265f, -0.03089191f, -0.16143183f, 0.00864773f, -0.04056711f, -0.14134727f, -0.03589356f, 0.03863263f, 
    -0.05365224f, -0.06922849f, 0.13685480f, 0.23426948f, -0.06034873f, 0.11160232f, -0.06205449f, -0.15047896f, 
    -0.25664121f, -0.14298154f, -0.00197393f, 0.03337737f, -0.04431501f, 0.05810541f, -0.09787242f, 0.19592698f, 
    -0.02972360f, 0.07774060f, 0.19603069f, 0.13023347f, -0.09772667f, -0.28596917f, 0.06380331f, -0.11525296f, 
    -0.06383532f, 0.05907636f, 0.18897396f, 0.04823669f, -0.02396973f, 0.14116713f, 0.12268448f, -0.17225051f, 
    0.08594630f, 0.12030017f, 0.22053093f, 0.33743674f, 0.24502328f, -0.04695660f, 0.17080818f, 0.19667025f, 
    -0.26217046f, -0.13876796f, -0.02157747f, 0.57346553f, 0.31766546f, 0.02616144f, 0.33440718f, -0.14184792f, 
    0.19975922f, 0.17246804f, 0.19685566f, -0.03337974f, -0.11273909f, 0.08024737f, 0.23081288f, 0.18433888f, 
    -0.17029800f, 0.03789047f, 0.12959851f, 0.27247626f, -0.00909545f, 0.29597637f, -0.09419370f, 0.14536849f, 
    -0.02213696f, -0.10297071f, -0.09917368f, 0.11061843f, 0.25372797f, 0.16719568f, 0.04913926f, 0.00892247f, 
    -0.05676545f, 0.10703778f, -0.18535076f, -0.17774217f, 0.06494166f, -0.07882648f, -0.16854160f, -0.09116887f, 
    -0.14680517f, 0.35313061f, 0.01571916f, -0.23943545f, 0.08435092f, 0.14674067f, -0.06427974f, -0.13150419f, 
    0.13743097f, -0.52262270f, -0.17922696f, -0.02302054f, 0.02725988f, 0.06698924f, -0.79260582f, -0.22932968f, 
    -0.28910574f, 0.34534061f, 0.36402774f, 0.10865838f, 0.07241063f, -0.06001924f, -0.00313275f, 0.01205290f, 
    0.03857479f, -0.11192875f, -0.13833924f, 0.01951724f, 0.14317185f, 0.08868547f, -0.06814206f, 0.01048133f, 
    -0.08737810f, -0.10810510f, -0.10986707f, 0.14229472f, -0.28116819f, 0.05158477f, -0.05212926f, -0.01834944f, 
    -0.07144411f, 0.04282995f, 0.03938324f, 0.01403280f, 0.15125807f, 0.29342455f, 0.13973871f, 0.15365313f, 
    0.00964719f, -0.51820612f, -0.05606873f, -0.31103614f, 0.01306218f, 0.34109372f, -0.05326043f, 0.19532508f, 
    0.27246293f, 0.35501784f, -0.21175431f, 0.29690331f, -0.01217207f, -0.10347924f, -0.05150696f, -0.25084555f, 
    -0.38162163f, 0.15471832f, 0.03471172f, -0.06654371f, -0.25618654f, -0.29941213f, 0.01030946f, -0.07060218f, 
    0.03708983f, 0.35414430f, 0.21478541f, 0.14204253f, -0.20978758f, -0.26621017f, 0.14970616f, -0.03366810f, 
    -0.32848248f, -0.16302031f, -0.07608141f, 0.15847142f, 0.10763898f, -0.07951073f, 0.00010474f, -0.05875125f, 
    0.32353222f, -0.13027790f, 0.03934027f, 0.34114406f, 0.07478981f, 0.09495606f, 0.12523770f, 0.07927659f, 
    0.06523410f, 0.14468822f, -0.07168650f, -0.18578330f, 0.01059001f, -0.18827900f, 0.13475657f, -0.26131839f, 
    0.14015780f, 0.22054100f, 0.07342838f, 0.11206151f, -0.10551360f, -0.09618805f, -0.32923076f, 0.02071734f, 
    0.26809639f, -0.03408010f, 0.07308186f, 0.09775285f, -0.17759906f, -0.43354833f, -0.03545847f, -0.02410810f, 
    -0.04786058f, -0.27559400f, -0.13635772f, 0.23769753f, -0.01398538f, 0.03176360f, 0.00579528f, 0.18566225f, 
    0.08075040f, 0.13386776f, 0.00519295f, 0.18367533f, 0.02598388f, 0.12953861f, 0.11480493f, 0.23843472f, 
    0.29287970f, 0.07950521f, 0.09580257f, -0.19405979f, 0.11246631f, -0.01374662f, -0.09774599f, -0.03481096f, 
    0.00195316f, -0.01981961f, -0.06994824f, 0.28446949f, 0.09013136f, -0.02702371f, -0.16286741f, -0.09130386f, 
    -0.39089108f, -0.06951196f, -0.06583899f, -0.01741093f, 0.24826530f, -0.02870603f, -0.11724078f, -0.33250260f, 
    -0.08829454f, 0.08337176f, -0.06557532f, 0.18319076f, 0.11393251f, 0.16329247f, -0.05101290f, 0.08474725f, 
    -0.07678089f, -0.02870126f, -0.08616975f, 0.30146632f, 0.22702792f, -0.18196908f, -0.14817239f, -0.12277635f, 
    0.05120387f, 0.05737984f, 0.13887039f, -0.13963945f, 0.03704134f, 0.33305195f, -0.01104305f, 0.12290905f, 
    0.00721413f, 0.29700005f, -0.22002341f, 0.22084709f, -0.13725828f, 0.04448467f, -0.00964731f, -0.09944399f, 
    -0.10875156f, -0.12657987f, 0.04810208f, 0.39857143f, 0.02930396f, -0.20836101f, 0.11342063f, 0.07928191f, 
    0.07996446f, 0.16845773f, -0.07091006f, 0.13461255f, 0.25316885f, 0.24860889f, 0.14894384f, 0.01288731f, 
    -0.08376262f, -0.09064264f, 0.22255738f, 0.08426101f, 0.25210282f, -0.14883818f, 0.22392583f, -0.12916012f, 
    -0.41182396f, -0.16545455f, 0.27236715f, 0.60151166f, 0.52125990f, 0.11363076f, -0.21584278f, -0.08119352f, 
    0.17045975f, 0.17504275f, 0.10200205f, -0.01184151f, -0.00657376f, -0.05948329f, 0.22167270f, -0.18687753f, 
    -0.36538357f, 0.01004198f, 0.27519554f, 0.14241090f, -0.00256518f, 0.07033977f, -0.33490875f, 0.21254939f, 
    0.02286319f, -0.47110978f, 0.04631570f, 0.04738791f, 0.14078976f, -0.35692224f, -0.08569098f, -0.02257138f, 
    0.00262196f, -0.17980696f, -0.19952075f, -0.05106392f, -0.01951647f, 0.00325247f, -0.41204736f, -0.05717633f, 
    0.06709305f, -0.04646815f, -0.03020148f, -0.06652146f, 0.00439794f, 0.02287284f, -0.08296096f, -0.10390522f, 
    0.12845719f, -0.04761272f, -0.06958385f, -0.11957169f, 0.29546335f, 0.05882745f, -0.86956370f, -0.00184645f, 
    0.17602803f, 0.42380807f, -0.17912050f, 0.13424961f, -0.15081368f, -0.06849669f, 0.23541427f, -0.03220854f, 
    -0.10587805f, -0.00248664f, -0.18607165f, -0.11512402f, -0.01083565f, 0.10309980f, -0.01975288f, -0.27706307f, 
    0.11479938f, -0.02119420f, -0.01141542f, -0.01289721f, -0.16720536f, -0.05092502f, -0.06117395f, 0.20918387f, 
    0.16711643f, 0.01794240f, -0.12140652f, 0.16770293f, 0.05777064f, 0.08317249f, 0.10062821f, 0.00255095f, 
    0.12847340f, 0.06682995f, -0.09724353f, 0.17831594f, 0.12524581f, 0.24721868f, -0.06313519f, 0.46735889f, 
    0.12679468f, -0.08162950f, 0.01201851f, -0.17251374f, 0.10539078f, -0.01608408f, -0.28029495f, 0.14398605f, 
    -0.07079379f, -0.02640423f, -0.07916870f, -0.04551916f, 0.02828657f, 0.24402437f, 0.09871116f, 0.21423890f, 
    -0.08105595f, 0.01560258f, -0.11378055f, 0.21315265f, -0.26516458f, -0.03119867f, -0.01774303f, 0.19926785f, 
    0.18566951f, 0.04904335f, 0.14088188f, 0.08823987f, 0.07063608f, -0.15343730f, 0.21695146f, -0.48638010f, 
    -0.14012949f, -0.13640775f, 0.19225292f, -0.08777648f, 0.09739290f, 0.08871150f, -0.34626019f, 0.01245175f, 
    0.02211748f, 0.42220360f, 0.06884911f, 0.11707947f, -0.06783744f, -0.05098550f, 0.25237587f, -0.17973642f, 
    -0.12834193f, -0.16356346f, -0.06588752f, -0.19088022f, 0.36873737f, 0.51629782f, 0.02354853f, -0.29660049f, 
    0.01513063f, -0.11439914f, -0.09734686f, 0.08038780f, -0.34698460f, 0.12668695f, 0.04726497f, 0.03088420f, 
    0.06942701f, 0.05655839f, -0.08593722f, -0.20404027f, -0.21817733f, -0.02993694f, -0.30564570f, -0.12812053f, 
    0.29486451f, 0.16269977f, 0.48942050f, 0.15162814f, -0.05617999f, 0.04485737f, -0.13303719f, 0.07090872f, 
    -0.07076956f, 0.16684194f, 0.13337862f, -0.40921482f, 0.09306108f, 0.09022786f, -0.30620039f, 0.05589931f, 
    0.28234234f, 0.29983237f, -0.28977317f, -0.03214815f, -0.43849993f, -0.02113817f, 0.30932620f, 0.37155646f, 
    0.13382840f, -0.11916288f, 0.12604703f, -0.15010938f, -0.24771962f, 0.03970755f, -0.27493560f, 0.04501893f, 
    -0.09247704f, -0.06523119f, -0.08184649f, 0.15773498f, -0.15093572f, -0.37802732f, 0.01570621f, -0.01142045f, 
    -0.13236238f, 0.00072494f, -0.36991584f, 0.14524426f, 0.01011553f, 0.04368868f, -0.08187234f, -0.39585504f, 
    0.11406363f, -0.03214782f, 0.03424988f, 0.00324746f, -0.00454228f, 0.19015411f, 0.00651596f, -0.00227559f, 
    0.15514493f, 0.19489387f, 0.03858326f, 0.11987753f, -0.14554954f, -0.07144568f, -0.14069545f, -0.01724815f, 
    -0.06718764f, 0.05882925f, -0.15602520f, 0.07608839f, -0.11599943f, 0.12132788f, 0.00720611f, 0.07811682f, 
    -0.08596859f, 0.18649279f, -0.04153897f, 0.33132237f, -0.17885479f, 0.01885093f, 0.12817049f, -0.12603763f, 
    0.04790217f, 0.15138695f, -0.04226673f, -0.07785272f, 0.01315118f, -0.16765548f, -0.06637422f, -0.03248369f, 
    0.17565615f, -0.10295437f, 0.09253818f, 0.04312408f, 0.13310215f, 0.17668222f, 0.10311095f, -0.11894824f, 
    -0.03321388f, 0.08291125f, 0.04047475f, -0.12414467f, 0.09156571f, 0.01426530f, 0.10092735f, 0.05012904f, 
    -0.01751415f, -0.07829078f, 0.20222242f, -0.16552365f, -0.00846935f, -0.05144375f, 0.06277201f, 0.12980321f, 
    -0.20972377f, -0.04644101f, 0.10872990f, -0.00125830f, 0.05958658f, 0.41305098f, 0.07877871f, 0.04620945f, 
    0.13711879f, 0.15220705f, 0.05680363f, 0.13188219f, -0.17676714f, 0.07249466f, 0.27771130f, 0.02364230f, 
    0.26786762f, -0.09744373f, -0.17055698f, -0.09416601f, 0.04345373f, 0.17687537f, -0.05403759f, 0.15805037f, 
    0.06505944f, -0.32213372f, 0.02047409f, 0.01529188f, 0.15475571f, 0.08948254f, 0.46121258f, -0.05245626f, 
    0.04052471f, -0.04366287f, -0.09525018f, 0.04690013f, -0.01725547f, 0.01045327f, 0.02842002f, 0.14304148f, 
    0.12764755f, 0.08696812f, -0.05356986f, -0.02478942f, 0.27737325f, 0.01347874f, -0.00186585f, 0.02512281f, 
    -0.03053938f, 0.13967741f, 0.01432235f, -0.11711317f, 0.12103339f, 0.25990880f, 0.02205486f, 0.16964504f, 
    -0.13585119f, 0.11291403f, 0.32071739f, 0.15777218f, 0.13692306f, 0.09065317f, 0.00016367f, 0.13573328f, 
    0.14679864f, 0.02715500f, -0.04839303f, -0.19599874f, -0.13029253f, -0.00163177f, 0.02161451f, -0.05851993f, 
    0.12189870f, 0.34594899f, 0.11320332f, 0.17246947f, 0.03468439f, 0.26384181f, 0.12174001f, -0.06825335f, 
    0.08894564f, -0.08903243f, -0.10117097f, 0.06065214f, 0.23368397f, -0.21986151f, 0.12293267f, -0.17988469f, 
    0.05172671f, 0.11296969f, 0.47239771f, -0.06879031f, 0.12297682f, -0.00580256f, -0.04496862f, 0.12343519f, 
    -0.03615389f, 0.15401629f, 0.23308468f, -0.05559497f, 0.13028018f, -0.03430636f, -0.11740904f, -0.04358743f, 
    0.28288230f, -0.09264658f, -0.00668382f, -0.05170868f, 0.04433931f, 0.04822065f, 0.19342566f, 0.12053237f, 
    -0.08721088f, 0.11700735f, -0.05714428f, 0.12218384f, -0.01620011f, -0.02475550f, -0.06041340f, 0.05593708f, 
    0.19660985f, 0.05878510f, -0.10104594f, -0.00348977f, -0.03067395f, -0.04963092f, -0.07595611f, -0.03708592f, 
    0.02586756f, -0.08173728f, 0.06129847f, 0.07215264f, -0.19093727f, -0.32439855f, -0.01019073f, 0.00448642f, 
    0.00718858f, -0.18993057f, 0.23129782f, 0.12137199f, -0.03033182f, -0.01837741f, 0.01520553f, 0.17916098f, 
    -0.18015812f, -0.18558866f, -0.08883532f, 0.17223489f, 0.02088398f, 0.03518940f, 0.22803895f, 0.05417612f, 
    0.07668281f, -0.37380522f, 0.03884307f, -0.03332211f, -0.08096422f, 0.02176239f, -0.04467112f, 0.17873900f, 
    0.30496037f, 0.00592318f, 0.14487983f, 0.15624827f, 0.00157426f, 0.08702314f, 0.05352761f, -0.01591573f, 
    0.03158165f, -0.01717413f, 0.13646264f, 0.19005851f, 0.08764562f, -0.00195632f, 0.27789730f, -0.18689547f, 
    0.11967950f, 0.03337869f, -0.11698391f, 0.12673938f, 0.12408452f, -0.25315097f, 0.11898813f, 0.10531985f, 
    0.36935028f, 0.13265038f, -0.10866448f, 0.07544659f, 0.14136195f, -0.01692385f, -0.06816289f, 0.05248466f, 
    -0.05695542f, 0.05784662f, -0.05599286f, 0.00392634f, 0.03055033f, -0.08129670f, -0.05746535f, -0.04042064f, 
    0.03802571f, -0.05067123f, -0.05201685f, -0.01079928f, -0.04210767f, 0.06902439f, -0.05502399f, 0.06603535f, 
    -0.07947865f, -0.12005976f, 0.02852005f, -0.02484341f, -0.11494746f, -0.09116704f, 0.06549498f, -0.02382333f, 
    0.02590622f, -0.04421896f, -0.05248135f, 0.02888029f, -0.11840902f, -0.08289684f, -0.05030737f, 0.00418815f, 
    -0.07880553f, -0.08049091f, -0.04448671f, 0.03505924f, 0.02002372f, 0.02774172f, 0.05805535f, 0.01450348f, 
    -0.04343496f, 0.02538055f, -0.07379559f, -0.06836440f, -0.03896667f, 0.02920861f, -0.05471074f, -0.03086909f, 
    -0.05480632f, -0.10432526f, -0.06824647f, -0.06484412f, -0.03932535f, -0.03334954f, 0.00367401f, 0.08177961f, 
    -0.09065287f, -0.07114307f, 0.02738502f, -0.01900022f, -0.05529321f, -0.05649751f, 0.04986662f, -0.12390625f, 
    -0.09953491f, 0.07626451f, 0.06036727f, -0.11972901f, -0.11561380f, -0.02413303f, -0.05153546f, 0.02665797f, 
    0.03017200f, -0.01252344f, -0.08600842f, -0.07864708f, 0.00790379f, -0.07031640f, 0.01551166f, 0.00527148f, 
    -0.02997912f, 0.07499561f, -0.07224451f, -0.07881025f, -0.05976627f, -0.04593740f, -0.08541797f, -0.08283259f, 
    -0.02360735f, 0.07665587f, 0.00434693f, 0.02556779f, -0.05006030f, 0.02626007f, 0.06875180f, -0.00291240f, 
    -0.08319635f, 0.00454455f, 0.06484360f, -0.02903133f, 0.07004885f, -0.07919357f, -0.04809862f, 0.02414106f, 
    0.08465545f, 0.03355277f, -0.10066551f, 0.04235299f, -0.07447710f, -0.10719585f, 0.01327612f, 0.04963497f, 
    -0.02516002f, -0.11839546f, 0.05634062f, -0.10685503f, -0.06072812f, -0.04424609f, 0.07259370f, 0.01315834f, 
    -0.05222640f, 0.02022567f, -0.04803450f, 0.03808155f, -0.00998998f, 0.04313248f, -0.06375011f, 0.00742636f, 
    0.16832785f, 0.33305717f, -0.17750788f, 0.17763445f, -0.43894577f, 0.22777173f, -0.06655356f, -0.18137760f, 
    -0.43557614f, -0.11829747f, 0.01534189f, -0.01068895f, -0.01504276f, 0.19575340f, 0.12354848f, 0.02289785f, 
    0.32250595f, -0.01228243f, -0.01414310f, 0.07711175f, 0.10797614f, -0.07847530f, 0.08518350f, -0.13928902f, 
    -0.05248647f, -0.03492474f, -0.50919402f, -0.02114654f, 0.40653038f, -0.03624430f, -0.25023314f, 0.10263605f, 
    0.00052588f, 0.03846782f, 0.12681505f, 0.36311862f, 0.00240195f, 0.04250046f, -0.13967800f, -0.07323126f, 
    -0.55067343f, 0.10384443f, -0.36630616f, 0.07877217f, 0.18350868f, -0.03604685f, 0.54267412f, -0.07481699f, 
    0.07812710f, 0.17831172f, -0.09692839f, 0.16577725f, -0.02800900f, 0.20016655f, -0.20417334f, -0.27606955f, 
    0.14718351f, 0.13137244f, -0.06552416f, -0.09003761f, 0.03781424f, 0.26337439f, 0.12045455f, -0.10011221f, 
    0.24411349f, 0.05710480f, 0.08863961f, -0.30080491f, -0.21316466f, 0.05319623f, 0.03507847f, -0.04218121f, 
    -0.07279246f, -0.00654090f, 0.19638653f, -0.25565764f, 0.25613174f, 0.00785074f, -0.05824580f, -0.40584913f, 
    -0.22186068f, 0.32776287f, 0.15484329f, -0.09687102f, 0.03781435f, -0.31495348f, 0.05018289f, -0.04950218f, 
    0.08457351f, 0.16416621f, -0.47280553f, -0.37834615f, -0.05711024f, 0.01508355f, -0.22081162f, -0.39315581f, 
    -0.19346423f, 0.19572057f, -0.48624042f, -0.09342447f, 0.17073539f, 0.00956177f, -0.19483346f, 0.07424068f, 
    -0.15495120f, -0.39261210f, -0.14151224f, 0.10810935f, 0.01048374f, -0.05228375f, 0.10417981f, 0.14516172f, 
    0.11781967f, -0.63477409f, -0.02567775f, 0.01118035f, -0.15181586f, -0.16210322f, -0.07958242f, 0.12649959f, 
    0.19780552f, 0.01715162f, -0.10128222f, 0.12370262f, 0.10015261f, 0.15689129f, 0.04676104f, 0.11913694f, 
    -0.08693206f, -0.03535692f, -0.01780042f, -0.08865131f, 0.10578735f, -0.30241340f, -0.05757531f, 0.06560906f, 
    0.15883432f, 0.06337880f, 0.11870202f, 0.11758694f, -0.08446442f, 0.08280051f, -0.16968721f, 0.01247153f, 
    -0.08716105f, -0.10208581f, 0.14918865f, 0.05278379f, -0.01466868f, 0.05999207f, -0.18632880f, -0.18671219f, 
    0.08434927f, 0.06806786f, 0.46924752f, 0.05820888f, -0.27014622f, -0.02329088f, 0.18468362f, 0.16016011f, 
    -0.06123293f, 0.13807413f, 0.07018696f, -0.00834932f, 0.01269672f, -0.15320960f, -0.04877976f, -0.25504988f, 
    0.11338805f, -0.31377631f, -0.06374149f, 0.05576506f, 0.19386894f, 0.18661739f, 0.31648132f, -0.00184064f, 
    -0.20652178f, -0.00851137f, 0.12329714f, -0.17014098f, -0.05399195f, -0.14592759f, -0.09405363f, 0.36365765f, 
    0.02091128f, 0.16107842f, -0.04919928f, 0.11129189f, -0.09236301f, -0.20786454f, 0.00234434f, 0.38190299f, 
    -0.28006423f, 0.06985209f, -0.05801583f, 0.00140241f, 0.41594267f, 0.44778240f, -0.05717260f, 0.07931882f, 
    0.02910913f, -0.00134832f, -0.15014394f, 0.09452412f, -0.07089851f, 0.07749277f, 0.04715772f, 0.16504449f, 
    0.28621250f, 0.05806272f, -0.22488971f, -0.03725597f, 0.01492755f, 0.00661908f, 0.02064320f, 0.14438185f, 
    0.00883866f, -0.30143481f, -0.25328293f, -0.00947851f, -0.00554153f, 0.10025495f, 0.46211794f, 0.12224240f, 
    0.03667221f, 0.10118018f, 0.14097612f, 0.01478437f, 0.17454307f, 0.03571238f, 0.11287824f, -0.35115924f, 
    0.05557116f, 0.12582947f, -0.17480417f, -0.10654429f, 0.16335773f, -0.01660006f, 0.11447489f, 0.05230931f, 
    -0.01661302f, -0.03050444f, -0.04511360f, -0.14643191f, 0.10568643f, -0.45182526f, 0.04311566f, 0.17735009f, 
    -0.02754161f, -0.06131683f, 0.13119061f, 0.24346401f, -0.05078409f, 0.00142546f, -0.10440876f, -0.11219902f, 
    -0.01953726f, 0.04216867f, -0.01266346f, -0.02327509f, 0.05168518f, 0.03836578f, -0.08774744f, 0.03570066f, 
    0.05648889f, -0.04448330f, -0.07352035f, -0.01429719f, -0.06770839f, -0.02433114f, -0.12598264f, -0.08571693f, 
    0.01447569f, -0.14177631f, -0.09027998f, -0.08398519f, -0.05669167f, -0.06445809f, 0.03876723f, -0.01183606f, 
    -0.02648957f, -0.07259008f, 0.06899877f, -0.04527645f, 0.09547038f, -0.12429748f, -0.06705969f, -0.10478500f, 
    -0.06939758f, -0.06268714f, -0.11256778f, -0.03471322f, -0.06284191f, -0.07618790f, 0.01564021f, -0.07221667f, 
    -0.00394436f, -0.08698013f, 0.01986062f, 0.01881883f, -0.00149557f, -0.06141223f, 0.00117769f, -0.12505923f, 
    -0.11658082f, -0.06175095f, -0.04199291f, 0.08471685f, 0.05325685f, -0.06265332f, -0.03117339f, 0.14577498f, 
    -0.00524439f, -0.06131513f, 0.01477105f, 0.00696621f, -0.14012319f, 0.00219308f, -0.04381425f, 0.01399786f, 
    -0.09432463f, 0.05865715f, -0.09731047f, -0.07111493f, -0.03501285f, -0.06602695f, -0.07568654f, 0.01552181f, 
    0.03221308f, -0.04908218f, 0.02035170f, 0.03374369f, -0.04784820f, 0.00021385f, -0.07383792f, -0.02039075f, 
    0.09480712f, -0.18159679f, -0.03834989f, -0.00195272f, -0.04955833f, -0.06503636f, -0.12218841f, 0.01969342f, 
    0.04900811f, -0.14508672f, -0.00969148f, -0.05844577f, 0.02984396f, -0.11829956f, 0.18844765f, -0.11103272f, 
    0.10256577f, -0.02701007f, 0.07500704f, 0.08900797f, -0.08175055f, 0.07221657f, -0.07159252f, 0.04143532f, 
    -0.08100189f, -0.12806766f, -0.00517263f, -0.10845791f, 0.00352810f, -0.01931396f, -0.02492295f, -0.09045501f, 
    -0.08214293f, -0.01524522f, -0.03754063f, -0.09083614f, -0.11270929f, 0.05750434f, 0.04690272f, 0.04876129f, 
    0.04219890f, 0.06169056f, -0.08756588f, 0.00492067f, 0.06216848f, 0.03413349f, -0.14913268f, -0.11364982f, 
    0.11541367f, 0.11671107f, -0.08799561f, -0.16859519f, -0.22079340f, 0.37021279f, 0.01108206f, 0.01858303f, 
    0.12402327f, 0.04462799f, -0.13354130f, 0.47717127f, 0.08294711f, 0.04056836f, -0.01885408f, -0.27442586f, 
    0.12974742f, -0.30291015f, -0.26125744f, -0.07033210f, -0.04085111f, 0.00679818f, -0.12070489f, 0.16141550f, 
    0.08207935f, 0.15220977f, -0.29354465f, 0.34265858f, 0.21145633f, -0.11466061f, -0.06874048f, -0.09852616f, 
    -0.03246019f, -0.09386321f, -0.02404087f, -0.22239195f, 0.03452591f, 0.00187633f, -0.23911710f, -0.08626703f, 
    -0.07481296f, -0.00735950f, 0.18186781f, -0.18206935f, 0.01053220f, 0.12600598f, -0.35283351f, 0.10887138f, 
    -0.07222281f, 0.05829326f, 0.00679390f, 0.28151637f, 0.10832739f, 0.17190893f, -0.08349477f, -0.37788537f, 
    0.01187010f, 0.01369218f, 0.13376659f, -0.14462523f, 0.13106063f, -0.01076690f, -0.01867013f, -0.22228408f, 
    0.13821615f, -0.18782535f, 0.12847675f, -0.04865545f, -0.17167540f, -0.24706972f, -0.01053005f, 0.01161769f, 
    -0.08723383f, -0.07038238f, 0.15785621f, 0.31374428f, -0.05958951f, 0.05851535f, 0.18652834f, -0.03083030f, 
    0.01080928f, -0.40896502f, -0.01983147f, 0.11207151f, 0.02443811f, 0.03503493f, -0.00350855f, -0.20623095f, 
    0.12853441f, -0.42589828f, -0.00564479f, -0.05547797f, 0.18426441f, 0.07510769f, 0.19909358f, -0.06116154f, 
    0.33466956f, 0.01786857f, -0.17315459f, 0.21551128f, -0.05560644f, -0.01396618f, -0.12092218f, 0.40174401f, 
    -0.00776595f, -0.01103701f, -0.07331547f, -0.03392789f, 0.15213554f, 0.02488184f, -0.03665879f, -0.15851367f, 
    0.10223589f, -0.06615496f, 0.01311267f, 0.14213240f, -0.31236219f, -0.09026006f, 0.07578804f, 0.11198740f, 
    0.16493651f, 0.03125338f, -0.04199456f, 0.08673980f, 0.33335570f, 0.02010291f, -0.22389521f, -0.09658386f, 
    -0.08788823f, -0.02335623f, -0.23260921f, -0.58852500f, 0.20133838f, 0.02913081f, -0.02579836f, -0.04504776f, 
    0.25129402f, -0.37808025f, -0.05896716f, 0.29622704f, -0.36518505f, -0.28738794f, -0.24428673f, -0.01318816f, 
    -0.30985999f, -0.34813026f, -0.08213779f, -0.15075833f, -0.03615049f, 0.40741187f, -0.11875568f, 0.18635714f, 
    0.00085544f, 0.23749387f, -0.19908550f, 0.37843469f, 0.28090599f, 0.07752229f, 0.31375328f, -0.26802900f, 
    0.07683726f, 0.02326910f, 0.00566604f, -0.16322632f, -0.07149097f, -0.03275834f, -0.09803019f, 0.13503820f, 
    -0.06031331f, -0.11349422f, -0.01959517f, -0.13781048f, -0.18878525f, 0.34031948f, 0.28685576f, -0.37000412f, 
    -0.06047470f, -0.17626853f, -0.01137987f, 0.11818973f, -0.00637443f, 0.07270207f, -0.10839923f, 0.22688064f, 
    0.12533462f, 0.43397856f, 0.05160341f, -0.02040475f, -0.00804960f, -0.25530902f, 0.14135259f, 0.22062534f, 
    0.07103533f, 0.30592275f, -0.07359398f, 0.15976207f, 0.11845110f, 0.31720787f, 0.04705887f, -0.01470001f, 
    -0.10302883f, 0.22583337f, -0.19628590f, 0.30260265f, -0.15113278f, -0.05618478f, 0.39534917f, 0.28610677f, 
    0.24942896f, -0.09075712f, -0.03872980f, -0.13834253f, 0.15833227f, 0.19949393f, 0.00952782f, 0.05855443f, 
    0.01953289f, -0.38071617f, -0.30146661f, -0.20391513f, 0.25349760f, 0.21262668f, 0.55574256f, -0.17522332f, 
    -0.04941792f, -0.21246441f, 0.22158612f, 0.36777195f, 0.11262627f, 0.01855430f, -0.19408596f, 0.06854068f, 
    0.15477240f, -0.07130931f, -0.01133784f, -0.20676696f, 0.28713152f, -0.10373081f, 0.14508855f, 0.12281730f, 
    -0.04703158f, 0.12238961f, -0.09151983f, -0.12400457f, 0.01935253f, -0.20286834f, 0.05036978f, -0.02788692f, 
    -0.16578394f, -0.06311131f, -0.36827308f, 0.21209554f, 0.23682310f, 0.24737088f, -0.05894745f, -0.08645374f, 
    0.07438161f, -0.14273922f, 0.04533394f, 0.05441153f, -0.56183583f, -0.26459780f, -0.03658819f, 0.05052098f, 
    0.10268630f, 0.02524306f, 0.08065476f, 0.25472760f, -0.03355924f, 0.12952740f, 0.23418182f, 0.07003267f, 
    -0.24991852f, 0.03974525f, 0.19468346f, 0.04143740f, 0.17894763f, -0.25050145f, 0.02478015f, -0.35933155f, 
    -0.03854648f, -0.13565741f, -0.51869684f, -0.13822775f, 0.12193849f, -0.08553544f, -0.01465958f, -0.10727606f, 
    -0.13637394f, -0.05546656f, 0.19475520f, -0.02120744f, 0.17506872f, -0.09750673f, 0.04272981f, -0.00922367f, 
    -0.19921947f, -0.07583421f, 0.01293198f, 0.07563880f, 0.12512001f, -0.03002759f, 0.51093698f, 0.21767254f, 
    0.10839014f, -0.20134754f, 0.10304535f, -0.05057967f, 0.02894987f, -0.03076790f, -0.03270024f, -0.47808781f, 
    0.01401979f, 0.34548864f, -0.04895963f, 0.42808312f, -0.11958668f, -0.28413236f, 0.08395858f, 0.03502684f, 
    0.07051948f, 0.10709350f, 0.09694309f, 0.01920656f, 0.13497283f, -0.32406810f, -0.10704134f, -0.00512075f, 
    0.00627217f, -0.04079908f, -0.01994360f, 0.20982409f, -0.06220715f, -0.01627466f, -0.19625334f, 0.23013271f, 
    0.00981044f, -0.09738444f, -0.21254742f, -0.11017054f, 0.05869745f, 0.02652442f, 0.09386296f, 0.06522413f, 
    0.12334450f, 0.29647532f, 0.09070764f, -0.21154383f, 0.07637553f, -0.09473071f, -0.15950690f, 0.31041318f, 
    0.01287490f, -0.00765642f, -0.32010522f, -0.00922150f, 0.26686141f, -0.00300400f, -0.02247703f, -0.30759624f, 
    -0.03325610f, -0.08850962f, -0.09001917f, 0.23662721f, 0.01623892f, 0.01696592f, 0.15582937f, -0.09249673f, 
    0.09887333f, 0.04666682f, -0.00740073f, 0.05463461f, -0.03107495f, -0.15673451f, 0.05684644f, 0.23472621f, 
    0.19970539f, 0.03168242f, -0.38269064f, 0.07476898f, 0.08820738f, -0.00442356f, 0.07500208f, -0.00277762f, 
    0.07458576f, 0.04669777f, -0.05850199f, 0.17869546f, -0.04108882f, 0.33790603f, 0.06335077f, 0.21825077f, 
    -0.03155021f, 0.00451593f, 0.06175565f, -0.09864777f, 0.01183563f, -0.08328994f, -0.06612913f, 0.17508663f, 
    -0.13532165f, 0.12257651f, -0.02524069f, 0.07735474f, 0.00864334f, -0.10820942f, 0.18214136f, -0.00319871f, 
    -0.02990011f, -0.03453771f, -0.20943332f, 0.27108106f, -0.31378773f, 0.04747000f, -0.17579955f, 0.10949166f, 
    0.15942287f, -0.04007601f, 0.10023190f, 0.14586896f, 0.11559371f, -0.19614257f, 0.19515872f, -0.17778872f, 
    -0.17677578f, -0.07743321f, 0.12744310f, 0.01624610f, 0.15704210f, 0.13210368f, -0.12727860f, -0.09090068f, 
    0.08925440f, 0.31034139f, 0.03387025f, 0.10866420f, 0.05404380f, 0.09027888f, 0.16159737f, 0.17511286f, 
    -0.05274037f, -0.26519972f, 0.07370885f, 0.01194192f, 0.28495732f, 0.38140309f, 0.07211054f, -0.40617889f, 
    0.09770989f, -0.11126305f, -0.13546012f, -0.04668345f, -0.39400750f, 0.09915280f, 0.03953745f, 0.05801355f, 
    -0.01480239f, 0.28365305f, -0.13291898f, -0.15593213f, -0.08650577f, -0.05488241f, -0.23983581f, -0.29000998f, 
    0.15763213f, 0.25565228f, 0.35823455f, 0.09647006f, -0.13925816f, -0.06042041f, -0.03353990f, -0.18487824f, 
    -0.01619293f, -0.44765848f, -0.01155974f, -0.18509088f, 0.13971776f, 0.08508441f, -0.49324363f, -0.09402584f, 
    -0.02747612f, 0.30769747f, -0.05574875f, -0.01917686f, -0.32064173f, 0.06617336f, 0.00743295f, 0.42722240f, 
    0.13892455f, -0.27061355f, -0.12676138f, -0.12214771f, -0.03466122f, 0.03648278f, -0.25967038f, 0.02950639f, 
    -0.02994706f, -0.07023900f, 0.04744511f, 0.08394050f, -0.34779337f, -0.21455824f, 0.05101499f, 0.16584636f, 
    -0.21849886f, -0.03473220f, -0.12131096f, 0.04488141f, 0.04935652f, 0.06946678f, -0.04307513f, -0.29169860f, 
    0.12389891f, -0.09448792f, -0.15386502f, -0.12821195f, 0.10913998f, 0.27162039f, 0.04474722f, 0.36291903f, 
    0.10481644f, -0.35436043f, 0.05416447f, -0.11011580f, 0.20926350f, -0.08930495f, -0.14408562f, 0.25875723f, 
    -0.19364987f, -0.10676564f, 0.00065860f, -0.22670639f, 0.08536746f, 0.23589511f, 0.02221135f, 0.14181536f, 
    -0.05546918f, 0.05906845f, -0.45835221f, 0.19514035f, -0.28519139f, -0.05998097f, -0.09700891f, 0.14887016f, 
    0.04516121f, 0.08412046f, 0.13222811f, -0.05717243f, -0.08932699f, 0.02995386f, 0.21125214f, -0.29548404f, 
    -0.53354532f, 0.01132177f, -0.02393204f, -0.20548473f, 0.05019855f, 0.18418516f, -0.04574469f, 0.00838838f, 
    0.11580522f, 0.28150877f, 0.10260773f, 0.08443148f, 0.01010938f, -0.00786349f, 0.17506118f, -0.25858277f, 
    0.01899113f, -0.09227701f, -0.16802965f, -0.30765414f, 0.43134952f, 0.46756241f, 0.09255941f, -0.38121140f, 
    -0.06146712f, 0.06409123f, -0.14760667f, 0.04720379f, -0.15441753f, 0.09819804f, 0.06234520f, -0.13677609f, 
    0.19967328f, 0.13045162f, -0.20432562f, -0.10526938f, 0.04587839f, 0.01065275f, -0.11423913f, -0.07544994f, 
    0.22231412f, 0.01081914f, 0.38794306f, 0.14526984f, -0.09494644f, -0.01167918f, -0.10810138f, 0.06815117f, 
    -0.04988999f, -0.29138342f, -0.16989779f, -0.07772906f, 0.21139166f, 0.09993876f, -0.00883945f, -0.04056241f, 
    0.02949193f, 0.22406511f, -0.41971326f, -0.05734738f, -0.23068473f, 0.05811266f, 0.17525783f, 0.26671091f, 
    0.11651712f, -0.12804981f, 0.32673743f, -0.07676645f, -0.25785148f, 0.21049923f, -0.26448280f, 0.07798126f, 
    -0.05312598f, -0.01000509f, 0.05082992f, 0.08526133f, -0.03506149f, -0.11832947f, -0.05758364f, -0.08669890f, 
    -0.08893672f, -0.00726633f, -0.53317624f, 0.14947455f, 0.09207134f, 0.10137730f, -0.25473303f, -0.38167876f, 
    -0.13876109f, -0.08706030f, -0.05977217f, 0.16551095f, 0.11310765f, -0.03895377f, 0.07500572f, -0.20941189f, 
    0.13561687f, 0.04215356f, -0.14890657f, 0.00193480f, -0.08842159f, 0.09698840f, -0.16375157f, -0.15518071f, 
    0.10119028f, 0.09851797f, -0.12258894f, -0.18312754f, 0.06102084f, -0.01825686f, -0.16335800f, 0.12899941f, 
    0.07256664f, 0.01925977f, -0.18409744f, 0.05636469f, 0.00461148f, -0.26307729f, 0.07404629f, 0.00761041f, 
    -0.12572081f, 0.00180760f, -0.08395269f, 0.17336263f, -0.03245657f, -0.20076828f, -0.26148739f, -0.11319487f, 
    0.05332936f, 0.07472576f, 0.02273086f, -0.24263240f, -0.04774914f, 0.04794899f, -0.32011640f, -0.10995518f, 
    -0.01998928f, -0.09847464f, -0.05332542f, -0.24240923f, -0.01652702f, -0.14715084f, -0.04041418f, -0.19941205f, 
    0.04497840f, 0.19969526f, 0.08332574f, 0.03075314f, -0.00587291f, -0.00849298f, -0.02472435f, 0.13171412f, 
    -0.08185173f, 0.15920019f, 0.05303243f, -0.00197035f, 0.15673707f, -0.03923860f, -0.06905331f, 0.01506566f, 
    -0.07379615f, -0.13654752f, 0.11024323f, 0.13916050f, -0.13914298f, 0.07547031f, 0.12509902f, 0.09099849f, 
    0.05632148f, -0.01657687f, -0.24191503f, -0.08294846f, -0.05351705f, 0.06981292f, -0.10972133f, -0.25572115f, 
    -0.10296117f, 0.08365223f, -0.08028834f, -0.07297831f, 0.07118722f, -0.09033820f, 0.17071591f, -0.12025560f, 
    -0.18793005f, -0.11692147f, 0.00109902f, 0.12509076f, 0.20741896f, -0.05276751f, -0.16400057f, -0.20756489f, 
    -0.00170720f, 0.20451406f, -0.22618520f, 0.22646113f, 0.08656806f, -0.08706038f, 0.09914387f, 0.03814000f, 
    -0.12461085f, 0.08516188f, 0.06254777f, -0.18431230f, 0.17076784f, 0.11348207f, 0.01823852f, -0.09276852f, 
    -0.03742974f, 0.10890103f, 0.30879840f, 0.01377494f, 0.03461517f, -0.25633445f, -0.15047698f, -0.10760092f, 
    -0.02161994f, -0.22010727f, -0.05488842f, 0.48806897f, -0.25504971f, 0.12032811f, 0.02450963f, 0.06242104f, 
    0.02061128f, 0.37984934f, 0.09824751f, -0.03216757f, -0.06177605f, 0.22335331f, -0.17134254f, 0.25442171f, 
    -0.10190049f, 0.34681860f, 0.19911335f, 0.06183487f, 0.15964977f, -0.04164347f, 0.08788720f, -0.30713773f, 
    -0.08102477f, 0.06253799f, 0.13572535f, 0.02759392f, -0.20399924f, -0.10046042f, -0.03967407f, 0.04580303f, 
    0.09491860f, 0.07315679f, -0.14518534f, 0.18027355f, 0.00149670f, -0.24321336f, 0.07298566f, -0.12884434f, 
    0.06949970f, 0.17430136f, -0.12744738f, 0.26405141f, -0.01565013f, -0.11170230f, 0.15191486f, -0.02599516f, 
    -0.03332586f, -0.21012546f, 0.00375068f, -0.09893827f, 0.04278903f, 0.05757708f, 0.02024567f, -0.02958526f, 
    0.25367582f, -0.02865198f, 0.00303146f, 0.15936142f, -0.07839758f, -0.17911887f, 0.11038157f, 0.24488217f, 
    0.12356915f, 0.13684958f, 0.16236424f, -0.09367964f, -0.01995019f, -0.11310468f, 0.04255614f, -0.03825450f, 
    0.11405956f, 0.07713304f, 0.05617610f, 0.01058564f, -0.33718240f, 0.04503585f, 0.01364931f, 0.09845805f, 
    -0.07591703f, 0.03687223f, -0.19870190f, -0.04591615f, -0.08944386f, 0.07639184f, -0.10148389f, 0.07131444f, 
    -0.06090202f, 0.33586070f, -0.12477809f, -0.15589155f, -0.23675391f, -0.00789489f, -0.23426047f, -0.00828063f, 
    -0.05852637f, -0.22387145f, 0.03154443f, 0.02351026f, 0.18221587f, 0.02757635f, -0.18309094f, -0.08145165f, 
    0.04747539f, 0.02229573f, -0.32029691f, 0.29875565f, 0.00123363f, -0.08613301f, 0.00807315f, 0.09965094f, 
    0.04689249f, -0.08187461f, -0.02894722f, -0.27415285f, 0.11535425f, -0.08240176f, -0.04633171f, 0.10980184f, 
    0.06218312f, -0.05810723f, 0.08449998f, 0.17439693f, 0.06591439f, 0.02447521f, 0.10013133f, -0.11376768f, 
    0.11626954f, -0.00791573f, -0.20493653f, -0.15219884f, -0.31966153f, -0.10516790f, -0.01539561f, 0.17785771f, 
    0.14462198f, 0.00959914f, 0.19461639f, -0.01036960f, -0.26126054f, 0.06004240f, -0.07465077f, -0.05957984f, 
    -0.07650869f, -0.08792870f, -0.00736222f, 0.10849594f, 0.09161308f, 0.28500983f, 0.10868215f, -0.23549627f, 
    -0.03522217f, 0.11250799f, -0.00362834f, 0.08036268f, 0.10708530f, 0.29078734f, 0.16943122f, 0.08390265f, 
    0.04051686f, 0.18828084f, 0.28310364f, 0.11600426f, -0.16738307f, -0.07544080f, 0.08572888f, -0.35847908f, 
    -0.11170293f, -0.71784657f, -0.03511108f, 0.29942864f, -0.08197248f, 0.10666449f, 0.05888325f, -0.16868599f, 
    -0.16582771f, 0.05394271f, 0.02933889f, 0.09613094f, 0.06660486f, -0.09138438f, 0.04057155f, 0.07710279f, 
    -0.03849876f, 0.07175980f, -0.15713984f, -0.01442543f, 0.12350601f, -0.05178914f, 0.04081056f, -0.07040456f, 
    -0.23888220f, 0.11438669f, 0.02808931f, 0.11349348f, -0.09626586f, 0.15566367f, -0.14657286f, -0.13828376f, 
    0.14244439f, 0.13288862f, -0.03913508f, -0.00157434f, -0.16821845f, -0.04917403f, -0.05752171f, 0.21138313f, 
    0.33834484f, -0.12534000f, 0.06223612f, -0.06835097f, 0.08684024f, -0.16536331f, 0.10675663f, 0.06619691f, 
    0.02467943f, -0.08963889f, -0.21306513f, -0.43682748f, 0.12203503f, 0.12977317f, 0.33967063f, 0.28863794f, 
    0.21817125f, 0.08909708f, -0.09125683f, 0.06785461f, 0.00520036f, 0.05798171f, 0.13273421f, -0.02211629f, 
    0.23878990f, 0.11893495f, 0.18045257f, -0.10505893f, -0.08459133f, -0.07644639f, 0.09811510f, 0.05702161f, 
    -0.06547484f, 0.05866922f, 0.07136120f, -0.20800889f, 0.00340504f, -0.38491958f, 0.04012392f, 0.10190463f, 
    -0.00369871f, -0.00202231f, -0.23829018f, 0.08246449f, 0.17162968f, 0.18446773f, -0.03106785f, -0.14809781f, 
    0.03358848f, -0.11921512f, -0.05756972f, 0.36132568f, -0.32945257f, 0.09567963f, 0.04413021f, 0.26658529f, 
    -0.14105669f, 0.22089584f, 0.07782193f, -0.07860753f, -0.25088641f, 0.27163461f, 0.18294160f, 0.36217839f, 
    0.04499671f, 0.23474370f, 0.24492837f, 0.22729565f, 0.17475788f, 0.01161170f, 0.19741814f, -0.11112209f, 
    -0.07574523f, 0.12455868f, -0.10677768f, -0.09330290f, 0.11797965f, 0.19639257f, -0.08330332f, -0.08918761f, 
    0.19997650f, 0.03066881f, -0.16726199f, 0.24304104f, 0.18062176f, -0.21527016f, 0.29097301f, -0.00602076f, 
    -0.37308371f, 0.00980358f, 0.04647098f, 0.40093169f, 0.22374400f, -0.20986885f, 0.04644303f, -0.22700861f, 
    0.11607966f, 0.12544414f, -0.01234948f, 0.09010571f, 0.04197966f, 0.02046008f, 0.09284121f, -0.05471521f, 
    -0.05075577f, -0.01733081f, -0.10042913f, 0.37505955f, -0.02703493f, -0.14477865f, 0.01260496f, -0.23232311f, 
    0.24466546f, 0.04423782f, 0.27363449f, -0.11626742f, -0.16156502f, 0.22598647f, 0.05046237f, -0.10005751f, 
    -0.06541020f, 0.07717771f, 0.08647975f, -0.06004156f, -0.21520554f, 0.02072491f, -0.17757195f, -0.00039155f, 
    -0.02348160f, 0.18363148f, 0.14320789f, -0.15290138f, -0.12644093f, -0.05257770f, 0.04089211f, 0.27019757f, 
    -0.12258819f, 0.48201618f, 0.12308694f, -0.38019544f, -0.11156137f, -0.14100756f, -0.35155991f, 0.01380485f, 
    -0.06859536f, 0.02173765f, -0.14878169f, -0.06940778f, 0.14493492f, 0.06052954f, 0.14006700f, 0.06375465f, 
    0.12384028f, -0.06515764f, -0.00994035f, 0.30566078f, -0.18900414f, 0.12107401f, -0.17605186f, 0.18229930f, 
    -0.05315480f, -0.06457461f, 0.02429987f, -0.06030751f, -0.09836528f, -0.07119678f, -0.01981614f, 0.18581776f, 
    0.12646909f, 0.05644615f, 0.16993797f, -0.16954735f, -0.18192723f, 0.00635965f, 0.13331869f, -0.07061486f, 
    0.05433978f, -0.07892193f, 0.04980794f, 0.07113813f, -0.00763362f, 0.06212224f, 0.06113218f, -0.06859799f, 
    0.06063181f, 0.07726960f, -0.03511690f, -0.02946323f, -0.05408139f, 0.05202841f, -0.07684831f, -0.05688170f, 
    -0.03311722f, 0.06890681f, -0.06219350f, 0.05756599f, -0.02098542f, -0.04351413f, 0.00217468f, 0.00335321f, 
    0.02590863f, 0.00605668f, 0.07336643f, -0.04479229f, 0.03575115f, -0.01275877f, 0.00215466f, 0.03322448f, 
    -0.08816638f, -0.07052359f, -0.01934832f, -0.07774580f, -0.06912516f, -0.02560063f, -0.01752238f, -0.05097257f, 
    -0.05112274f, 0.01568154f, 0.03056595f, 0.04225037f, 0.03646643f, 0.05083186f, 0.02172792f, -0.00971836f, 
    -0.10044459f, 0.02434457f, -0.08842635f, -0.06046224f, 0.08279730f, -0.02267744f, -0.04382809f, 0.03524724f, 
    -0.06177788f, -0.08129258f, -0.04081312f, 0.01357881f, 0.04562916f, 0.04002983f, 0.05697368f, 0.05579472f, 
    -0.05030669f, -0.06284367f, -0.06966774f, -0.04354592f, -0.01391552f, -0.00164314f, -0.00026704f, -0.07183706f, 
    -0.09206166f, 0.01649076f, 0.04789648f, -0.09524964f, -0.08961056f, -0.01715693f, 0.01319040f, 0.02462722f, 
    0.00611246f, -0.03373230f, -0.05475830f, 0.01743682f, 0.04104804f, 0.03348989f, -0.02920601f, -0.10322846f, 
    -0.06150363f, 0.03579210f, -0.03263238f, -0.05615678f, -0.02736586f, -0.03773913f, 0.05403381f, -0.00993330f, 
    -0.10482050f, -0.09964018f, -0.04616665f, 0.00867358f, -0.07027818f, -0.03301778f, 0.00293057f, -0.00950975f, 
    -0.01613689f, -0.08854810f, 0.02191411f, 0.00981174f, 0.01765175f, -0.08479263f, 0.02317279f, 0.05852989f, 
    0.01397981f, -0.00501758f, -0.05656919f, 0.05369715f, -0.07710190f, -0.03353002f, -0.03475994f, -0.02310094f, 
    0.06043386f, -0.06073817f, 0.01667442f, 0.04641014f, -0.08452109f, -0.08673088f, -0.09609952f, -0.09256971f, 
    -0.06934740f, -0.07063897f, -0.01609746f, -0.22353491f, 0.07369378f, 0.08299894f, -0.08450740f, 0.18432863f, 
    -0.10842194f, 0.20154393f, 0.08001577f, -0.02210694f, 0.03132800f, -0.26886269f, 0.08226072f, -0.09258344f, 
    -0.47675252f, -0.04206706f, 0.32476816f, 0.27114537f, 0.03209256f, -0.04455375f, 0.03945500f, 0.06539912f, 
    0.00514947f, -0.50707084f, 0.18931499f, -0.09844590f, 0.11065233f, -0.05601529f, 0.12354850f, 0.07696310f, 
    -0.07791564f, -0.24775858f, 0.19438514f, 0.12779409f, 0.19529848f, -0.06387744f, 0.15987925f, 0.01100935f, 
    -0.00463426f, 0.04526324f, 0.13047679f, -0.56144208f, 0.04931073f, 0.07705843f, -0.06833573f, 0.00219924f, 
    0.10441170f, 0.00208182f, 0.07139783f, 0.11188820f, -0.05587417f, -0.21301892f, 0.13554884f, -0.03167037f, 
    -1.12689567f, -0.08306103f, 0.21034022f, 0.44842061f, -0.02941887f, 0.00277152f, -0.22895189f, 0.18171467f, 
    0.19277693f, -0.45964840f, -0.26257160f, 0.06608863f, 0.13131973f, 0.04184470f, -0.01951442f, -0.09062292f, 
    -0.03806169f, 0.05281646f, -0.36942631f, -0.05120151f, 0.04980749f, -0.06640676f, -0.47508550f, 0.00470877f, 
    0.11120383f, 0.02968390f, 0.03389131f, -0.13802512f, -0.06526602f, 0.03809059f, 0.03266987f, -0.04848577f, 
    0.11241435f, -0.14379516f, 0.02403546f, -0.07125438f, -0.07066924f, 0.09346047f, -0.84034592f, 0.11312221f, 
    0.29124627f, 0.22075363f, 0.00196698f, -0.09082219f, -0.01608285f, -0.11373320f, 0.03340327f, 0.09998170f, 
    -0.11088582f, 0.07976318f, -0.08094700f, -0.97003752f, -0.00885091f, 0.06154818f, -0.02815937f, -0.16546030f, 
    0.04013101f, 0.01818368f, 0.05187385f, -0.02621741f, -0.08940756f, 0.04055053f, -0.05849906f, 0.09810720f, 
    -0.16122849f, -0.00710740f, -0.26931790f, 0.00403238f, -0.21889083f, -0.29369596f, 0.19593385f, 0.05222730f, 
    -0.03309876f, -0.27430829f, 0.03395459f, 0.17135184f, 0.22217126f, 0.21540208f, 0.10294057f, 0.23250401f, 
    0.09253428f, 0.11022673f, 0.11959919f, 0.14889304f, -0.07889748f, 0.03068598f, -0.19688533f, 0.06113756f, 
    -0.09188800f, 0.15350728f, 0.05287791f, 0.01978126f, -0.08283920f, 0.14874233f, -0.04000548f, -0.16866909f, 
    -0.08755777f, -0.07628895f, 0.28468534f, 0.12829231f, -0.61108637f, -0.00588711f, 0.03820629f, 0.06087982f, 
    0.11201335f, -0.01814840f, -0.02558836f, 0.04408366f, -0.00461375f, -0.19821723f, 0.12667908f, -0.41021067f, 
    0.10456144f, -0.28567299f, 0.15004490f, -0.30043766f, 0.16452123f, 0.19076744f, -0.20586422f, 0.02313454f, 
    -0.08299045f, 0.04114129f, 0.03806826f, -0.12878799f, 0.04788735f, 0.01056214f, 0.10198539f, 0.26534656f, 
    -0.00649972f, 0.05927627f, 0.09850842f, 0.12635006f, -0.04357890f, 0.04543452f, -0.05236534f, 0.41861293f, 
    -0.10207818f, -0.01789802f, 0.07684556f, 0.02186299f, 0.28624907f, 0.54784727f, -0.03767150f, 0.00610636f, 
    0.05578467f, 0.20137863f, -0.01119136f, 0.00131777f, -0.20894726f, 0.03605052f, 0.06591505f, 0.04369853f, 
    0.31331083f, -0.05357248f, -0.04879965f, -0.10158744f, 0.08775014f, 0.16734290f, -0.15954633f, 0.23317167f, 
    0.15048288f, -0.16527896f, -0.02201356f, -0.03745939f, 0.01048082f, 0.09040067f, 0.25157714f, 0.07287849f, 
    0.12916401f, 0.16034414f, 0.33629838f, 0.09538154f, 0.14862636f, -0.04543903f, 0.07287250f, -0.00324777f, 
    0.01192121f, -0.01497386f, -0.24357717f, 0.02905870f, 0.04025466f, 0.01779654f, 0.00836877f, 0.06960788f, 
    -0.02428344f, 0.04323533f, -0.01239245f, 0.03792260f, -0.03176703f, -0.07755657f, 0.03299659f, 0.15239190f, 
    -0.24414963f, 0.02241294f, 0.06882431f, 0.13515678f, 0.09296570f, 0.00629382f, -0.05171170f, -0.22205541f, 
    0.03505528f, 0.08296728f, 0.11848404f, 0.01132307f, -0.21043089f, 0.48145533f, 0.04898755f, -0.11985616f, 
    0.22251810f, 0.26632586f, -0.05479774f, 0.42309552f, 0.00950894f, 0.01871440f, -0.00342536f, -0.18146278f, 
    0.09004901f, -0.01636330f, -0.17629787f, 0.08353585f, -0.04516080f, -0.02940291f, -0.18424395f, 0.04378528f, 
    0.03865097f, -0.03538243f, -0.09039924f, 0.15988472f, -0.30044988f, -0.14930677f, -0.03791833f, -0.00013715f, 
    0.00766036f, -0.16097692f, -0.16795005f, -0.14646702f, 0.13001114f, 0.01273447f, -0.02188264f, -0.22195573f, 
    -0.09253122f, -0.05325948f, 0.21444194f, -0.46145663f, -0.05863077f, 0.06202748f, -0.14417285f, 0.05078176f, 
    0.06701518f, -0.05033667f, 0.04678594f, -0.16360196f, -0.01784367f, 0.07738708f, 0.12427071f, -0.33388278f, 
    0.22481962f, 0.09463125f, 0.26193947f, 0.00399250f, -0.19953953f, -0.39364344f, -0.04027671f, 0.09598675f, 
    -0.02933681f, 0.00481254f, 0.22929022f, 0.05269228f, -0.01627056f, -0.02143876f, -0.11086832f, -0.16144502f, 
    0.00772215f, 0.02461962f, 0.15756263f, 0.02869458f, -0.08233803f, 0.03399940f, 0.07058587f, 0.11996384f, 
    -0.05235771f, -0.28818297f, -0.31632099f, 0.17316638f, -0.09749494f, 0.19399653f, -0.24927485f, 0.00052604f, 
    0.04353663f, -0.23902194f, 0.16555060f, -0.02260011f, 0.01084413f, -0.03035819f, 0.49215904f, 0.16810670f, 
    0.16088377f, 0.12187371f, -0.18530238f, 0.31534877f, 0.09773152f, 0.02564147f, -0.05441464f, 0.02987978f, 
    -0.14788797f, 0.06018120f, -0.13672841f, 0.10212529f, 0.32508498f, -0.05934507f, -0.13001913f, -0.16310678f, 
    0.09352415f, 0.10918532f, -0.04625135f, 0.09980533f, -0.10090920f, -0.15931338f, 0.10531934f, 0.25760484f, 
    -0.03469597f, 0.04547059f, 0.09534517f, 0.15022877f, 0.19928057f, -0.08472653f, 0.12417003f, -0.11734413f, 
    0.07510842f, 0.32893318f, -0.08473539f, 0.09244683f, -0.17993473f, 0.33534345f, 0.09348395f, -0.20850389f, 
    -0.34634948f, 0.22824636f, 0.07828059f, 0.03982622f, 0.06864368f, 0.17174797f, -0.10685457f, 0.01972909f, 
    0.41113552f, 0.08632507f, -0.24100961f, 0.10952453f, 0.03020659f, -0.02282876f, -0.07359006f, 0.06744281f, 
    -0.01070968f, 0.13488963f, -0.11006616f, 0.05010042f, -0.22243233f, 0.12563854f, -0.17307320f, -0.05373537f, 
    0.10482301f, 0.00405545f, 0.20037755f, 0.23917697f, 0.17861506f, -0.23289214f, -0.08600144f, 0.07806342f, 
    -0.24415877f, 0.09224840f, -0.19308403f, 0.06686757f, 0.18101996f, -0.13933016f, 0.14306855f, -0.12916306f, 
    0.02482693f, 0.21699156f, 0.01559678f, 0.03878759f, 0.05823866f, 0.16139825f, -0.12173395f, -0.45166111f, 
    0.15976992f, -0.11199956f, 0.29346222f, -0.11362712f, -0.13411447f, 0.36508512f, -0.00560668f, 0.03703176f, 
    0.17179598f, -0.04970035f, 0.23430465f, -0.21877927f, -0.33682045f, 0.57834822f, 0.13278612f, -0.15647049f, 
    -0.06842067f, 0.05347234f, 0.27036881f, -0.29708010f, 0.09022571f, -0.00871153f, 0.13429436f, -0.34416193f, 
    -0.30408826f, 0.22850461f, 0.06112251f, 0.08877781f, -0.17526190f, -0.12250650f, 0.07019546f, -0.34055528f, 
    0.11680096f, 0.23113509f, -0.18344194f, -0.12847237f, -0.30020049f, -0.01624428f, -0.35484615f, 0.23901117f, 
    -0.16555133f, 0.42343351f, -0.52677506f, -0.06238538f, 0.17063667f, 0.04652495f, -0.28825286f, 0.20879170f, 
    0.07672199f, -0.24022436f, -0.26881501f, 0.24387369f, 0.27228931f, -0.08679375f, 0.04770352f, 0.04551248f, 
    -0.01901365f, -0.52408212f, 0.06486762f, 0.31024760f, -0.20875527f, 0.45712608f, 0.01254606f, 0.21204203f, 
    0.04152741f, -0.00614633f, 0.09252357f, 0.00557667f, 0.13040918f, 0.10360509f, 0.04388253f, 0.26536393f, 
    0.01305100f, -0.02442107f, 0.01311370f, 0.01107723f, -0.06387142f, -0.08109905f, 0.05382674f, -0.07748780f, 
    0.05067233f, 0.01336523f, 0.03519480f, -0.07881583f, -0.05430448f, -0.08189907f, 0.01825608f, 0.03803379f, 
    0.02074330f, -0.12507787f, -0.00377706f, 0.03148334f, -0.09394717f, -0.04417470f, -0.03110061f, -0.00746393f, 
    -0.00792190f, 0.03617487f, 0.06123982f, -0.04489405f, 0.01067732f, -0.00119646f, 0.05341677f, -0.07141324f, 
    -0.01574581f, -0.01704396f, -0.06144306f, -0.06038081f, -0.10248252f, -0.00546118f, -0.04740455f, -0.10290048f, 
    -0.06372844f, -0.01529224f, -0.07102862f, -0.00064301f, -0.04660964f, -0.08904605f, 0.03575036f, -0.07199004f, 
    -0.05163062f, -0.04842363f, -0.09747117f, -0.05481182f, 0.02636808f, 0.01671480f, -0.07770026f, -0.02864641f, 
    0.01935510f, -0.04714166f, -0.08705638f, -0.03393967f, -0.00310732f, -0.07031226f, -0.06331236f, -0.11845122f, 
    0.00976046f, -0.10225047f, -0.08354799f, 0.00501448f, -0.03160091f, -0.07077210f, 0.07171009f, 0.02286757f, 
    -0.03672618f, -0.11653028f, 0.07586238f, 0.04094442f, -0.03272418f, -0.05983027f, -0.06313416f, 0.01608313f, 
    0.01142763f, -0.00860644f, -0.08570354f, -0.07440736f, -0.08150186f, 0.04143285f, -0.07723140f, -0.05539573f, 
    -0.03888328f, 0.07495840f, -0.07022204f, -0.00684104f, -0.12228748f, 0.05312362f, 0.04602452f, -0.06950521f, 
    0.03021893f, -0.04653604f, 0.05453230f, 0.02645886f, -0.04055636f, -0.08465503f, 0.05954430f, -0.04775102f, 
    0.04444960f, -0.08002480f, -0.04775853f, 0.01839713f, -0.11153032f, -0.09774718f, 0.03158711f, 0.03726681f, 
    -0.09528888f, -0.06901830f, 0.02584894f, -0.09102073f, -0.05671205f, 0.07591482f, 0.02531213f, -0.06852210f, 
    -0.10163782f, 0.04936311f, 0.00548168f, 0.01093788f, -0.00206755f, -0.08365042f, -0.08936372f, 0.00441247f, 
    0.18007511f, -0.07803659f, 0.05407263f, -0.04653570f, 0.03158933f, 0.28168571f, -0.09193408f, -0.07418986f, 
    0.12532328f, 0.35708436f, -0.02508644f, 0.40199700f, -0.02818500f, -0.06765522f, -0.09280053f, -0.25533998f, 
    0.09112059f, -0.29186592f, -0.00264445f, 0.06138381f, -0.13316822f, -0.23327535f, -0.07139800f, -0.21991865f, 
    0.06940150f, -0.10862216f, 0.39596802f, 0.20546448f, 0.03988148f, 0.06477507f, 0.03356532f, -0.14711766f, 
    -0.12138703f, -0.14798526f, 0.26582721f, -0.05133704f, 0.11666462f, -0.15202425f, 0.00866246f, -0.04853181f, 
    -0.01254217f, -0.37436584f, 0.18178564f, 0.06528750f, 0.06802668f, 0.16898535f, -0.20206766f, 0.18205221f, 
    0.12438880f, -0.00647785f, 0.02988631f, 0.27327830f, -0.05523864f, 0.19455048f, 0.04310822f, 0.36698434f, 
    -0.21787980f, 0.01335587f, 0.25895700f, 0.25962216f, -0.09693052f, 0.06257052f, -0.10111599f, -0.00420496f, 
    0.06241927f, -0.21642745f, -0.02544851f, 0.03184691f, 0.03862260f, -0.10232131f, -0.10145448f, 0.07126284f, 
    0.02774255f, -0.07268974f, -0.04625722f, 0.13745613f, -0.16165751f, -0.05614955f, -0.13481596f, 0.00743281f, 
    0.02760899f, -0.05750707f, 0.11883610f, 0.03644891f, -0.08959571f, -0.00829305f, -0.08906570f, -0.17254029f, 
    0.19373596f, -0.34392950f, -0.13560483f, 0.10059356f, 0.11942229f, 0.11211954f, -0.32690185f, 0.14594625f, 
    0.29308331f, 0.36293906f, 0.24192366f, 0.17041433f, -0.03243962f, 0.03465524f, 0.01392987f, 0.18675323f, 
    -0.08250313f, -0.16868998f, -0.14305261f, -0.05459160f, 0.23980060f, -0.06820733f, 0.13644572f, -0.20993412f, 
    0.02572943f, -0.19034974f, 0.02438182f, 0.23773694f, -0.44005856f, -0.27209613f, 0.01762737f, 0.23327394f, 
    0.08422914f, 0.07584258f, -0.27883002f, -0.10422233f, 0.20612191f, 0.01342282f, 0.00238531f, -0.11283141f, 
    -0.00945478f, -0.08508088f, -0.06608503f, 0.03574952f, -0.03822256f, 0.00071701f, -0.08675089f, -0.02496571f, 
    0.04489757f, -0.05580745f, 0.07984189f, -0.07042944f, -0.05808530f, 0.08478762f, 0.00769834f, 0.02582150f, 
    0.03217100f, -0.03732717f, 0.04676311f, -0.03545618f, -0.03824244f, -0.10650561f, -0.00493011f, 0.04299930f, 
    0.04402968f, -0.04691594f, -0.02324817f, 0.01965862f, -0.04400137f, 0.00440262f, -0.03827000f, 0.03903329f, 
    -0.03841735f, 0.03480307f, -0.00755352f, -0.04877251f, -0.01300590f, -0.08277620f, -0.10726386f, -0.00525756f, 
    -0.06834879f, 0.04794505f, 0.06053223f, -0.06652946f, -0.01002068f, 0.01998540f, -0.02282214f, -0.02553410f, 
    -0.04173837f, -0.00725050f, 0.00160717f, -0.04968691f, 0.04608152f, -0.07709372f, 0.02437516f, 0.08063087f, 
    -0.06950584f, -0.06202448f, -0.00582276f, -0.05711893f, 0.01442366f, -0.06214521f, 0.07904658f, 0.00804004f, 
    0.06856629f, -0.00720602f, -0.00616817f, -0.01076449f, 0.06822149f, 0.01696961f, 0.04666520f, 0.06477379f, 
    -0.10670457f, -0.05308756f, -0.08412794f, -0.09107956f, -0.02019553f, -0.05142424f, 0.03261285f, -0.02964072f, 
    0.04239958f, -0.07606912f, -0.01465167f, -0.10625134f, 0.04535845f, 0.02940690f, -0.10237259f, 0.01587913f, 
    0.01353012f, -0.02413034f, -0.05900009f, -0.00424247f, -0.10007535f, -0.09904081f, 0.08221443f, -0.00955757f, 
    -0.09896459f, -0.03373571f, 0.02604464f, -0.02174472f, -0.04206371f, 0.02395192f, 0.00639976f, -0.04985223f, 
    -0.01980645f, -0.04577278f, -0.05876889f, 0.06532672f, -0.06328532f, -0.09408953f, 0.05807351f, -0.08333910f, 
    0.04168554f, -0.05291874f, -0.06072567f, -0.09151941f, -0.03142664f, -0.08782337f, 0.02229404f, -0.00555365f, 
    -0.08588687f, -0.07413807f, -0.07239927f, -0.07907731f, -0.09730858f, 0.01418671f, 0.02870004f, -0.00089477f, 
    0.23911604f, 0.42439640f, -0.34042367f, -0.02795806f, -0.49290997f, 0.16010894f, 0.00085724f, -0.28725225f, 
    0.27161416f, 0.07601230f, -0.09808522f, 0.16516954f, 0.24934477f, 0.10758331f, 0.06250910f, -0.16254593f, 
    0.34801918f, -0.18243191f, -0.18318358f, -0.11501644f, 0.11398677f, 0.19246829f, 0.04831315f, -0.03866633f, 
    0.05133582f, 0.08637366f, -0.41558611f, 0.03329886f, 0.33169207f, -0.05671931f, -0.09648772f, 0.05461977f, 
    0.01651391f, -0.06862094f, 0.25814208f, 0.12586793f, -0.18773580f, -0.13291979f, -0.33241189f, -0.11450280f, 
    -0.18985622f, 0.14402607f, -0.12960939f, -0.09342961f, -0.14385512f, 0.06595709f, -0.14061683f, 0.21320027f, 
    -0.18505777f, 0.13171242f, -0.14539510f, 0.17487259f, -0.00411862f, 0.06381822f, -0.47525829f, -0.40425876f, 
    0.23898336f, 0.07781410f, 0.06336690f, -0.61167717f, -0.01565038f, 0.44304755f, 0.06537372f, 0.04175735f, 
    0.10486269f, -0.03244781f, 0.05318923f, -0.11016308f, -0.20499755f, 0.09043819f, 0.11000884f, 0.15086320f, 
    -0.04036576f, -0.08458479f, 0.36928716f, 0.08170009f, 0.10867709f, -0.05889327f, 0.32450196f, -0.06287761f, 
    -0.17474853f, 0.11974357f, 0.07616293f, 0.19480146f, -0.00951051f, 0.02346427f, 0.14437489f, -0.32478455f, 
    -0.00969583f, 0.26091588f, -0.31869611f, -0.26201907f, 0.15593217f, -0.02695685f, 0.17768480f, -0.52321315f, 
    0.15709554f, 0.11776185f, -0.33905214f, -0.00868745f, -0.04878956f, -0.02995496f, -0.26640558f, 0.20289581f, 
    0.02239522f, -0.12033352f, 0.03973471f, 0.12259939f, 0.02216865f, -0.13665693f, 0.20852292f, 0.02659030f, 
    0.14349109f, -0.20897520f, 0.01677542f, 0.18948190f, -0.08030299f, 0.24220443f, 0.00553840f, 0.05248353f, 
    0.16937385f, -0.06755758f, 0.06072954f, 0.26091394f, 0.13701227f, 0.19324516f, 0.04788579f, -0.08506600f, 
    0.00717562f, -0.51862419f, 0.10597312f, 0.25620645f, 0.10411751f, 0.26653686f, -0.02244874f, 0.17702803f, 
    0.05731443f, 0.41428250f, -0.05332298f, -0.01391648f, -0.00517426f, 0.08717542f, -0.18779279f, 0.26687190f, 
    -0.19488499f, 0.26158044f, 0.32521999f, 0.11275496f, -0.03251240f, -0.01579094f, 0.06284484f, 0.04499159f, 
    0.03415382f, -0.05429455f, 0.35329083f, 0.05790359f, -0.40382871f, -0.05115517f, -0.01559363f, -0.01931784f, 
    0.17240994f, -0.13391607f, -0.10309987f, 0.21240029f, 0.16693856f, -0.16272373f, 0.07617769f, 0.11537094f, 
    0.12160397f, -0.04282121f, 0.10703553f, 0.17911254f, 0.25206086f, 0.09719466f, -0.16278878f, -0.08643253f, 
    -0.02062355f, -0.04361852f, 0.13223559f, -0.20578232f, -0.03510187f, -0.18823963f, 0.23844551f, 0.29393938f, 
    -0.11394041f, -0.11811494f, 0.08568780f, 0.14037643f, -0.08500958f, -0.10043108f, -0.08205319f, 0.16367669f, 
    -0.04158835f, -0.02647280f, 0.04491071f, 0.02851287f, 0.20881476f, 0.20941746f, 0.05578037f, -0.05197144f, 
    0.02368922f, -0.06776901f, -0.03193669f, 0.11421625f, -0.15821816f, -0.01255117f, -0.01884809f, 0.06324804f, 
    0.17368062f, 0.11852735f, -0.07836466f, 0.02294934f, -0.01116979f, 0.19322202f, -0.20518790f, 0.04171157f, 
    -0.12551817f, -0.06671811f, -0.11543898f, -0.00748261f, -0.21844688f, 0.04149613f, -0.31604996f, -0.10013229f, 
    0.10296749f, 0.02156916f, 0.12302179f, 0.09766298f, 0.11085245f, 0.06454984f, -0.15529235f, 0.02256404f, 
    0.00935192f, 0.01105080f, -0.16325766f, 0.13247235f, 0.04544387f, 0.06576720f, -0.32680383f, 0.12896064f, 
    -0.14333543f, 0.01867939f, -0.03096084f, 0.04288773f, -0.05105315f, 0.09645921f, -0.05875043f, 0.15372980f, 
    -0.31242529f, -0.01258937f, 0.25746119f, 0.09153779f, -0.24873503f, -0.12277947f, -0.07536494f, -0.09476997f, 
    0.01012447f, -0.26038969f, -0.16042930f, 0.21788760f, 0.60650629f, 0.16891316f, 0.06096736f, 0.20431390f, 
    -0.37739715f, -0.15308870f, 0.21253628f, -0.21081097f, 0.00241032f, 0.02617064f, -0.02660834f, 0.37721556f, 
    -0.15328006f, -0.00339769f, 0.39519680f, -0.04694445f, 0.10244010f, -0.09735930f, 0.22731048f, -0.45707655f, 
    0.02470081f, -0.05519624f, 0.28846252f, 0.09384718f, -0.31364843f, 0.13896319f, -0.11583288f, 0.01570427f, 
    0.08273329f, 0.04069745f, 0.08773236f, 0.45514685f, 0.11815448f, -0.11558328f, -0.05125459f, 0.03398552f, 
    -0.04342481f, -0.18122664f, 0.00935709f, -0.38078150f, 0.11390865f, -0.13050571f, 0.18923610f, -0.03455349f, 
    0.29179561f, 0.02171035f, 0.02512757f, 0.10889394f, -0.00177206f, 0.08512793f, 0.14136812f, 0.60983139f, 
    -0.03873684f, -0.00835134f, -0.10064822f, 0.49335328f, 0.18000768f, 0.30267853f, 0.14893125f, -0.47386068f, 
    0.24800035f, 0.24837655f, -0.11168092f, -0.00676690f, -0.04177747f, -0.08008263f, 0.19354117f, 0.00593278f, 
    -0.21319605f, 0.05813316f, -0.22656469f, -0.02253139f, 0.00534253f, -0.08186170f, -0.00812483f, -0.25938642f, 
    -0.09800749f, 0.35778627f, 0.26996440f, -0.06134940f, -0.14595328f, -0.22268848f, 0.10274644f, 0.01382228f, 
    -0.01332762f, -0.44134417f, -0.39326197f, 0.14342116f, -0.25464237f, -0.11020896f, -0.42089158f, 0.09674430f, 
    0.02932299f, 0.06647830f, 0.43427473f, 0.11237946f, 0.09535997f, 0.03155162f, -0.00314816f, 0.15826084f, 
    0.16546595f, -0.24913013f, -0.09564192f, 0.10242678f, -0.10840683f, 0.05391068f, -0.17860314f, 0.12950100f, 
    -0.05385251f, -0.28573558f, 0.02957253f, 0.12047608f, -0.29437056f, -0.45920140f, -0.03031897f, -0.00318310f, 
    -0.04921923f, -0.03388533f, -0.24508074f, -0.07724118f, -0.10204890f, 0.07050348f, -0.11313227f, -0.22005343f, 
    0.02208752f, -0.10365573f, -0.01478869f, 0.07463109f, -0.06636324f, -0.03230916f, -0.06128703f, 0.26692790f, 
    0.02467100f, 0.15621053f, 0.01539750f, -0.17834502f, -0.07271044f, 0.17492437f, -0.02579242f, 0.11148977f, 
    -0.12572186f, -0.03940343f, 0.02889604f, -0.02675109f, 0.20073707f, 0.16916612f, 0.13091993f, -0.08922029f, 
    0.00314414f, 0.09455322f, 0.13763793f, 0.12149165f, -0.36154062f, 0.14947103f, 0.11759436f, 0.17248295f, 
    0.17398629f, 0.31071350f, 0.04356352f, 0.28123748f, 0.08660555f, -0.11997505f, 0.09660996f, -0.44174346f, 
    0.00209555f, -0.23510839f, 0.07936429f, 0.36692569f, 0.18608774f, 0.13971329f, -0.18928675f, -0.10895637f, 
    -0.01611986f, 0.15444033f, -0.01070660f, -0.22063427f, -0.07256988f, -0.25491941f, 0.07628136f, 0.40595081f, 
    -0.10511255f, 0.00068296f, -0.00087569f, 0.07448837f, 0.17962444f, 0.10995869f, 0.09177101f, 0.17303196f, 
    -0.24968472f, -0.04489000f, 0.05152860f, 0.05076966f, 0.10925625f, 0.39986166f, 0.20533015f, -0.05952320f, 
    -0.03077402f, -0.08104716f, 0.01693559f, 0.03058744f, -0.09508282f, 0.02649168f, -0.11795317f, -0.04141759f, 
    0.23920701f, 0.31074217f, 0.13007280f, -0.02442151f, -0.12725437f, -0.10521363f, 0.02411147f, 0.13063693f, 
    0.05593940f, 0.09788053f, -0.13728784f, -0.07836734f, 0.20574500f, 0.07661271f, -0.18209985f, -0.24403812f, 
    -0.01398141f, 0.07241549f, 0.29391330f, -0.22286785f, -0.09563404f, -0.00852067f, 0.12987465f, -0.16963151f, 
    0.12704462f, 0.05309607f, 0.01813786f, 0.18729503f, -0.10975774f, -0.04487360f, -0.08270776f, 0.09694486f, 
    -0.04242668f, -0.04327222f, 0.03196548f, -0.13142544f, -0.02887497f, -0.07061637f, 0.05889742f, -0.05198024f, 
    -0.10309582f, -0.05391351f, 0.18795982f, 0.17284705f, -0.19833836f, -0.05777860f, -0.05510447f, -0.33871436f, 
    -0.08702368f, 0.18192534f, 0.01734887f, 0.26227796f, -0.04463613f, 0.27539882f, -0.05293111f, 0.03506204f, 
    -0.05020565f, -0.08933000f, -0.05963390f, -0.07257812f, 0.01762944f, -0.14320222f, -0.36070529f, -0.02722093f, 
    0.24351367f, 0.01720025f, 0.04728210f, 0.01459125f, -0.10876414f, 0.33785933f, 0.01474248f, 0.33106792f, 
    -0.01506229f, 0.01223719f, -0.36384422f, 0.11552051f, 0.17057252f, -0.01294223f, 0.21415788f, -0.02503808f, 
    0.16350628f, -0.09282223f, -0.36809194f, -0.04304976f, -0.09517962f, 0.07999821f, 0.24241444f, 0.15390554f, 
    -0.14802530f, -0.02595079f, 0.01020128f, 0.21319267f, -0.02029721f, 0.04068613f, -0.07241644f, -0.23176064f, 
    -0.04106493f, 0.06025013f, 0.10951405f, -0.25503698f, -0.02235387f, -0.04814086f, 0.18006319f, 0.07559088f, 
    -0.10946212f, -0.32746959f, 0.04155584f, -0.21223792f, 0.07184200f, 0.30791405f, 0.01734828f, -0.03159436f, 
    0.16181232f, -0.25160879f, -0.12037314f, 0.16334094f, 0.06955443f, 0.24417359f, -0.03762865f, -0.10366572f, 
    0.15355127f, 0.15770076f, 0.10184986f, -0.29877695f, 0.10247407f, 0.00122038f, 0.23722115f, -0.09785575f, 
    0.15434679f, -0.06022405f, 0.20380193f, -0.08824518f, 0.05125361f, 0.18613096f, -0.21708369f, -0.16545670f, 
    -0.06975888f, 0.12794988f, -0.16346245f, -0.03159758f, 0.11145464f, 0.17302302f, -0.44524604f, -0.12401895f, 
    -0.32737002f, 0.02033069f, -0.13070744f, -0.00939724f, -0.20528781f, -0.01755076f, -0.03802275f, 0.31389353f, 
    0.14575474f, 0.12267705f, 0.11726256f, -0.19301663f, 0.18019974f, 0.19921142f, -0.18273067f, 0.15518543f, 
    -0.27749786f, 0.02069194f, 0.04080258f, 0.12931332f, -0.03489133f, 0.09012296f, -0.10434022f, -0.31451273f, 
    -0.25582913f, -0.06935558f, 0.21072957f, 0.07067253f, -0.10989290f, 0.18941405f, 0.13385098f, 0.10296074f, 
    0.05305620f, -0.55993575f, 0.00062873f, 0.24881727f, 0.16264769f, -0.09335960f, 0.06586435f, 0.04614411f, 
    -0.19902225f, -0.31073859f, 0.35192564f, -0.00681591f, 0.03622258f, 0.00823554f, -0.03095922f, -0.12540883f, 
    -0.19126822f, -0.12993783f, 0.17719981f, 0.06538341f, -0.09797579f, -0.21482684f, 0.10998594f, -0.30674520f, 
    0.03199737f, -0.31442645f, 0.36612684f, -0.31895369f, -0.55428755f, -0.02709531f, -0.17555080f, 0.03956955f, 
    -0.06042738f, -0.24794903f, 0.20192409f, 0.30780405f, 0.00468568f, -0.12947464f, -0.22940809f, -0.12626322f, 
    0.28918752f, -0.16100243f, -0.14105341f, -0.50701177f, 0.00163884f, -0.09849678f, 0.05931058f, 0.01856596f, 
    0.01591919f, -0.04441879f, 0.01463712f, 0.15538393f, 0.08392446f, -0.37801903f, -0.02384875f, 0.30828112f, 
    -0.26997760f, 0.08997352f, -0.01870063f, 0.50858611f, -0.19082537f, 0.17353134f, 0.04636377f, 0.00577841f, 
    0.20845932f, 0.11213890f, -0.21243326f, 0.02275336f, 0.19425589f, 0.00731721f, 0.04845607f, -0.06402469f, 
    -0.28568140f, -0.23040758f, -0.30129740f, 0.18708123f, -0.00010688f, -0.02074836f, -0.20186637f, -0.10432193f, 
    0.03350078f, 0.30910689f, 0.27346665f, -0.00990825f, 0.04446191f, -0.13821149f, 0.32503551f, -0.16024582f, 
    0.13372828f, -0.06591828f, -0.11846219f, 0.04339087f, -0.29265663f, 0.02428952f, -0.23298939f, 0.03937076f, 
    0.14071134f, 0.17819346f, 0.38973528f, -0.19488750f, 0.26958284f, -0.05052311f, -0.01315563f, -0.21613395f, 
    -0.28012210f, -0.17945199f, -0.17418255f, -0.12009808f, -0.16521801f, -0.07947151f, 0.15456705f, 0.04907861f, 
    0.04315534f, -0.10776667f, -0.05425975f, 0.10528801f, -0.31622648f, -0.19375154f, 0.07273576f, 0.05258680f, 
    0.07936837f, -0.04829528f, -0.11156829f, -0.35091850f, -0.48143655f, -0.23275842f, -0.16519402f, -0.10846317f, 
    0.09836207f, 0.15902863f, -0.05364189f, 0.24090974f, -0.12231246f, 0.06119508f, 0.06442828f, 0.23692691f, 
    -0.12272868f, 0.10957442f, 0.20832039f, -0.17619249f, -0.01794041f, 0.27984530f, 0.09376941f, 0.28480017f, 
    0.05720965f, -0.04084021f, 0.21315430f, 0.30436784f, 0.33327273f, -0.05668559f, 0.24551393f, -0.03556216f, 
    0.05597040f, 0.14137183f, -0.00141043f, -0.13580140f, 0.28729635f, 0.37721315f, 0.17060064f, 0.00156100f, 
    0.04142314f, 0.18974693f, 0.15275715f, 0.30254164f, 0.20116055f, 0.10573018f, 0.31375080f, -0.05083226f, 
    -0.25187191f, -0.12427694f, -0.02338630f, 0.08150470f, 0.15606445f, -0.11333640f, 0.12872899f, -0.11067545f, 
    0.17578250f, 0.06244471f, -0.07408302f, 0.29101989f, 0.00234738f, 0.21300399f, 0.06211961f, 0.00955319f, 
    -0.03450971f, 0.11259640f, -0.20651740f, 0.21726921f, 0.19077420f, 0.08396734f, 0.07681718f, -0.19630513f, 
    0.07526032f, 0.11339429f, 0.17342483f, -0.05034991f, -0.04341731f, -0.45880464f, -0.04300502f, 0.07300666f, 
    -0.05869197f, -0.01848196f, 0.10367040f, 0.06057435f, 0.03019352f, -0.04641690f, -0.06668321f, -0.06071932f, 
    -0.09938474f, 0.17025223f, 0.37607288f, 0.03655725f, -0.12739187f, -0.17552930f, 0.11900973f, 0.14639044f, 
    -0.16775683f, 0.27149913f, 0.01959318f, -0.10224245f, -0.01662774f, -0.07664288f, -0.47800925f, 0.00353508f, 
    0.04775815f, 0.26574576f, -0.07112767f, -0.00072099f, 0.07114773f, 0.06466082f, 0.15055586f, 0.05613030f, 
    -0.00383488f, 0.11092887f, 0.20977367f, 0.16257337f, -0.14256917f, 0.10190497f, 0.05583615f, 0.08805488f, 
    0.05017729f, -0.11102487f, 0.06853333f, -0.09618300f, 0.05990968f, -0.26016930f, 0.04310313f, 0.06605717f, 
    0.32484344f, -0.02927236f, -0.21822694f, -0.07094493f, 0.04632694f, 0.10657212f, 0.11002388f, -0.02586706f, 
    -0.11010325f, -0.30965206f, 0.06186801f, 0.13162372f, -0.09703721f, 0.37781882f, -0.02831096f, 0.06860790f, 
    0.16358538f, 0.06214235f, -0.11379758f, 0.34566364f, 0.02730571f, -0.07718773f, -0.03746570f, 0.18260284f, 
    -0.37290171f, 0.13058954f, 0.19680923f, -0.19845381f, -0.13504294f, -0.13895957f, -0.19215222f, -0.06997259f, 
    -0.06344154f, 0.01124355f, -0.28356189f, 0.24610013f, 0.03425522f, -0.28281426f, 0.23769037f, -0.09816863f, 
    0.02387645f, 0.01711447f, -0.04427816f, 0.06341322f, -0.06517488f, -0.17831087f, -0.35881484f, 0.11433648f, 
    0.18975700f, 0.04414749f, 0.03261545f, 0.15630849f, 0.04022832f, 0.31274179f, -0.14825737f, 0.08294096f, 
    0.21237838f, -0.13914591f, 0.03582627f, -0.03356347f, -0.04991896f, -0.10132749f, 0.11070477f, -0.22793931f, 
    0.12338725f, 0.33887213f, 0.10441556f, 0.13289362f, -0.08993623f, -0.26432005f, -0.07043145f, 0.19328600f, 
    0.38671818f, 0.06801187f, -0.02471538f, 0.11526317f, 0.13906582f, 0.01244843f, -0.23062070f, -0.08004163f, 
    0.10587319f, 0.16014811f, -0.20004383f, 0.27433440f, 0.00744469f, -0.03837920f, 0.13746844f, 0.22298725f, 
    0.21813351f, 0.02512273f, -0.15168720f, 0.01046094f, 0.12100326f, 0.29941782f, -0.08744631f, 0.02154919f, 
    0.00802778f, -0.16738743f, 0.00963733f, -0.01442533f, 0.18978150f, -0.08756547f, 0.20449579f, 0.03702146f, 
    0.05372771f, -0.04160910f, -0.15062718f, 0.35969123f, 0.10980190f, 0.04441172f, -0.23507911f, -0.08958612f, 
    0.02833848f, -0.07877649f, -0.14273855f, 0.04616000f, 0.30857566f, 0.00085148f, -0.15682404f, -0.20010318f, 
    0.02787093f, 0.13669932f, -0.08264899f, 0.15469350f, 0.08165921f, 0.30928457f, 0.09216080f, 0.19750401f, 
    -0.16153373f, -0.02160167f, -0.18886167f, 0.31417048f, 0.32677960f, -0.02854693f, -0.28671673f, 0.01964211f, 
    0.03615815f, 0.11528010f, -0.10875864f, -0.01799234f, -0.37948227f, 0.29351857f, -0.01466447f, 0.09106698f, 
    -0.08249807f, 0.06503136f, 0.10524012f, 0.11365592f, -0.05446884f, -0.12666701f, 0.06571425f, 0.08792201f, 
    -0.06236084f, -0.02083271f, -0.04228513f, 0.14861915f, 0.03353371f, -0.10617825f, 0.23758303f, 0.05042608f, 
    0.07671987f, 0.07142683f, -0.55446631f, 0.07020797f, 0.03808559f, 0.25737092f, -0.06286631f, -0.01274017f, 
    0.05257467f, -0.02530136f, 0.14598148f, -0.01338404f, 0.15580767f, 0.07817295f, 0.20591788f, 0.08594204f, 
    -0.69859457f, -0.13784808f, 0.16358149f, 0.26465866f, 0.16410586f, 0.10577928f, -0.09915948f, 0.00461007f, 
    0.04629088f, -0.00001777f, -0.01254927f, 0.35254306f, 0.04913473f, 0.17178641f, 0.09164255f, -0.46151686f, 
    -0.12623584f, -0.03863405f, 0.04070827f, 0.10118321f, 0.12524195f, 0.25949159f, -0.06914899f, -0.40448269f, 
    0.09759717f, -0.16144967f, -0.02929833f, 0.07168392f, -0.17952338f, -0.40488622f, -0.03835924f, -0.04887421f, 
    0.15012424f, 0.04529304f, -0.36904263f, -0.01141073f, -0.01513020f, 0.04377512f, -0.25981724f, -0.22823836f, 
    0.04002338f, 0.05251560f, 0.27984729f, -0.00954902f, 0.09777837f, 0.01129651f, 0.12245078f, -0.06780487f, 
    0.09218132f, -0.65868735f, 0.03551097f, -0.32884625f, 0.21789563f, 0.06180847f, -0.53965783f, -0.20591892f, 
    -0.00211118f, 0.11803105f, -0.32679898f, 0.08240078f, -0.18760955f, 0.00168581f, 0.11202920f, 0.37781063f, 
    0.21592739f, -0.00017017f, -0.03752445f, 0.06269272f, -0.20712468f, 0.07448473f, -0.20003375f, -0.10943232f, 
    -0.09051604f, -0.05180206f, -0.00259988f, 0.07700576f, -0.22412694f, -0.11624392f, -0.04506623f, 0.13285026f, 
    0.08625332f, 0.08618375f, -0.46403462f, -0.10250157f, 0.14965454f, 0.05190086f, -0.04965066f, -0.12252598f, 
    0.00391574f, -0.46457714f, -0.00187638f, 0.11766682f, 0.33204463f, -0.32545832f, 0.05251699f, 0.40937087f, 
    -0.04408386f, -0.12091415f, 0.22701392f, -0.34090382f, -0.10532859f, 0.10981641f, 0.09580132f, 0.32925782f, 
    -0.31834391f, 0.13573241f, 0.08508728f, -0.11940066f, 0.04664315f, -0.22562426f, 0.15616928f, -0.13783067f, 
    0.03900157f, -0.20182146f, 0.06518660f, 0.00265062f, 0.06500281f, -0.01411936f, 0.03801010f, 0.14686359f, 
    0.15149230f, 0.14980568f, -0.08711848f, 0.19969819f, 0.10046139f, -0.25582963f, 0.08972555f, -0.45378363f, 
    -0.17843191f, -0.19025433f, 0.05944744f, -0.37284619f, -0.01578347f, 0.09172879f, 0.14403459f, 0.01020461f, 
    0.16718572f, -0.15604784f, -0.03379771f, -0.04770703f, 0.02454622f, -0.15007575f, 0.10043250f, 0.21118793f, 
    0.03557685f, 0.08924135f, -0.14483175f, 0.12457695f, 0.14878289f, -0.17860025f, 0.18368968f, 0.23924044f, 
    -0.09073538f, 0.20682466f, -0.16039500f, 0.06919321f, 0.21714588f, -0.18267867f, -0.00283966f, 0.04733812f, 
    0.05475417f, 0.06645548f, -0.12285171f, -0.01855225f, -0.00677258f, 0.08647646f, -0.17695263f, 0.16179265f, 
    0.20375842f, 0.08474667f, 0.08008618f, -0.07552974f, -0.13138467f, -0.01009289f, -0.03339455f, 0.32327035f, 
    -0.06948603f, -0.31724000f, -0.05138621f, -0.08019128f, 0.18900840f, -0.07441807f, -0.03409681f, -0.07934873f, 
    0.12739529f, -0.14029011f, 0.06263549f, -0.27520069f, -0.11050118f, 0.02220372f, 0.26642287f, -0.08014264f, 
    -0.03342738f, 0.01988130f, 0.00504012f, 0.04486635f, -0.24390718f, 0.07854996f, -0.13992105f, 0.01490401f, 
    -0.08456682f, 0.06266201f, 0.01287292f, -0.21931227f, 0.12127350f, -0.35040978f, 0.04164494f, -0.10677513f, 
    -0.06863576f, 0.07589255f, -0.55533445f, 0.19735010f, -0.06304537f, -0.04791783f, -0.14411138f, -0.24502088f, 
    -0.03942297f, 0.01056206f, 0.05272757f, 0.03059192f, 0.04286458f, 0.02920573f, -0.02772943f, -0.04397213f, 
    -0.04491485f, -0.06916708f, -0.05857105f, 0.05344968f, 0.05820503f, -0.07835608f, -0.09097752f, 0.02123731f, 
    0.04641196f, -0.00439901f, 0.00377018f, -0.00074553f, -0.00336367f, 0.08068074f, -0.00361011f, -0.05907667f, 
    0.01416271f, -0.00798032f, 0.04546599f, -0.00195384f, 0.02394270f, -0.04555423f, -0.03227116f, -0.03553237f, 
    -0.04634381f, 0.03796686f, -0.05386271f, 0.05741086f, -0.06382821f, -0.02239429f, -0.06826456f, -0.00216412f, 
    0.07198551f, -0.06579364f, 0.00588880f, -0.06380171f, -0.08683660f, 0.03975489f, 0.01049610f, -0.01739918f, 
    0.05242974f, 0.07070566f, -0.06320201f, -0.05955322f, 0.01980576f, 0.00233299f, -0.00434859f, -0.06273845f, 
    0.03135268f, -0.01006688f, -0.04325329f, 0.01748385f, 0.07752497f, 0.06749441f, -0.06997161f, -0.09128886f, 
    0.05843160f, -0.04588862f, 0.00723950f, -0.08855256f, -0.08291064f, -0.07779866f, 0.05223176f, 0.02680725f, 
    0.08486614f, -0.07914789f, -0.05990912f, -0.06609142f, 0.05774131f, -0.03996088f, -0.04302350f, -0.01222913f, 
    0.07929557f, 0.02885480f, 0.04728297f, -0.09209283f, -0.03512653f, -0.06745017f, -0.01567889f, 0.04218553f, 
    -0.08194236f, 0.04059409f, -0.05718870f, -0.04984257f, -0.04803092f, -0.00072332f, -0.01503745f, -0.09287176f, 
    0.03433882f, -0.07826545f, -0.00401733f, -0.03310356f, 0.03154247f, 0.06840456f, 0.02585536f, 0.01737808f, 
    0.03566251f, 0.03693726f, 0.03693401f, 0.01152424f, 0.03495142f, -0.08684880f, 0.01010437f, 0.01556703f, 
    0.07624138f, -0.07774302f, -0.00902241f, -0.05056746f, -0.03369907f, 0.07923087f, 0.01494477f, 0.01300202f, 
    -0.07332518f, 0.02550404f, 0.00975818f, -0.05410047f, -0.04006931f, -0.03785577f, 0.05671723f, 0.02099752f, 
    -0.05794157f, 0.00198577f, -0.17246917f, 0.03514979f, -0.07365862f, 0.28927916f, 0.09269182f, 0.18059333f, 
    0.18669526f, -0.05622166f, 0.04006184f, -0.05206611f, -0.23519374f, 0.00361335f, -0.33851409f, 0.04510990f, 
    -0.01338823f, -0.03101668f, -0.14553392f, -0.00304157f, 0.06068491f, 0.17335741f, 0.06019383f, -0.07587790f, 
    -0.03011690f, -0.00524693f, 0.02161417f, 0.35274404f, -0.32060841f, 0.07267178f, 0.06069536f, -0.16048655f, 
    0.18607001f, 0.16629498f, -0.09809196f, -0.26638237f, 0.05249776f, 0.00373783f, 0.11396730f, -0.24943410f, 
    0.03912639f, -0.50209594f, 0.07546245f, -0.15262623f, -0.17175968f, 0.13580620f, -0.19971731f, -0.11969519f, 
    -0.08176935f, -0.06134915f, -0.02741302f, 0.11504620f, 0.06812257f, 0.14640905f, -0.00526646f, -0.00454189f, 
    0.01646356f, -0.12133736f, -0.06432626f, -0.23115833f, 0.15637912f, -0.04869149f, 0.14713937f, -0.38191625f, 
    -0.11836762f, 0.02815205f, -0.06737856f, 0.01830261f, -0.52734619f, 0.08228018f, 0.01554643f, -0.06805763f, 
    0.16649824f, 0.22124098f, -0.04508718f, 0.09058241f, -0.31647393f, -0.02583027f, 0.02456578f, -0.01776419f, 
    0.37485498f, -0.06521818f, 0.14628936f, -0.07635748f, 0.07904214f, 0.13648134f, -0.04734750f, 0.14947897f, 
    -0.01686138f, -0.22326915f, -0.11096522f, -0.02377340f, 0.14764406f, 0.12032897f, 0.47438180f, -0.11951505f, 
    0.10444212f, 0.00164299f, 0.00846545f, 0.18790908f, -0.16297023f, -0.01716755f, 0.00768656f, 0.24856482f, 
    0.24644715f, -0.06531492f, 0.06624401f, -0.04835144f, -0.14511241f, -0.03383303f, -0.00600677f, -0.06632306f, 
    -0.14048198f, 0.05803443f, 0.04088757f, 0.00173102f, 0.05698008f, -0.35709554f, -0.08142869f, 0.00468712f, 
    -0.08031455f, 0.01713460f, 0.00925396f, 0.11910290f, 0.23196246f, 0.04953499f, -0.08470644f, -0.18847692f, 
    0.01756353f, 0.00483946f, -0.18774039f, -0.36940181f, 0.12427616f, -0.24081270f, -0.00324137f, 0.07489359f, 
    -0.14400919f, -0.29823300f, 0.12397154f, 0.05073947f, -0.41131493f, -0.11461673f, -0.08748960f, 0.00286612f, 
    -0.19505836f, -0.22956429f, -0.10454541f, 0.09676810f, 0.08569157f, 0.17866203f, 0.08118205f, -0.20914046f, 
    0.07166474f, 0.20989317f, -0.14622326f, 0.20804286f, 0.29047775f, 0.26682758f, 0.26489994f, -0.19045469f, 
    0.07355235f, 0.22361463f, 0.18794072f, -0.15409397f, -0.06787847f, 0.07805946f, -0.03540066f, -0.02575501f, 
    -0.67659044f, -0.16442145f, -0.12955289f, 0.28874671f, -0.06285963f, 0.02785793f, 0.72864348f, -0.26176265f, 
    0.01910513f, -0.07602788f, -0.01096449f, 0.21097369f, -0.05577967f, 0.25184265f, -0.00969403f, -0.02140035f, 
    0.20999825f, 0.29195610f, -0.07755446f, -0.01912408f, 0.13118583f, -0.29930189f, 0.07984390f, -0.14094245f, 
    -0.16616072f, 0.24840751f, -0.13723023f, 0.05513986f, -0.01046419f, -0.02615405f, -0.10639561f, 0.05053862f, 
    0.04690931f, 0.32839668f, -0.26596922f, -0.07500209f, -0.01512277f, -0.01565669f, 0.15025716f, 0.08957420f, 
    0.23186731f, -0.07582163f, 0.04777936f, -0.30332449f, -0.14207859f, 0.05248588f, 0.15268579f, 0.05007024f, 
    -0.14040473f, -0.63198119f, -0.28519529f, 0.00174967f, 0.21835028f, 0.09693429f, 0.14538215f, 0.32899177f, 
    -0.03031575f, -0.14498414f, -0.06721231f, 0.03869857f, 0.01963908f, -0.12313852f, 0.11099779f, -0.14225967f, 
    0.16242641f, -0.07831805f, 0.13089524f, -0.06930246f, 0.07580507f, -0.01773388f, 0.19682236f, 0.04521184f, 
    -0.02866876f, -0.02037430f, -0.05854443f, -0.32144663f, 0.13935047f, -0.48361713f, 0.01876971f, 0.05426469f, 
    0.17489842f, -0.07634484f, -0.65277910f, 0.09035497f, 0.31030318f, 0.31325385f, 0.02021524f, 0.08777978f, 
    0.22976565f, 0.01627608f, -0.01930061f, -0.13339134f, 0.12075761f, -0.15704253f, -0.02473151f, 0.04912550f, 
    0.12708451f, 0.04677163f, -0.01038688f, -0.04297448f, -0.03709764f, 0.06828629f, 0.17002709f, -0.05142787f, 
    -0.06361435f, -0.05303372f, -0.27422369f, 0.12754290f, 0.13981934f, -0.18825166f, 0.14919487f, -0.17851807f, 
    0.02438615f, 0.12703358f, 0.37569764f, 0.00985112f, 0.23834559f, 0.02223959f, -0.00020790f, 0.06038192f, 
    -0.02664590f, 0.17147835f, 0.41869763f, 0.11734582f, 0.15488872f, 0.10737592f, -0.00411424f, -0.05631457f, 
    0.14950678f, -0.02935043f, -0.05008024f, 0.02896363f, 0.19190109f, 0.11366636f, 0.41248009f, 0.11930329f, 
    0.00109843f, 0.20099784f, 0.09566109f, -0.03931442f, 0.09266002f, -0.05401591f, 0.00263024f, -0.12548079f, 
    -0.03068959f, 0.10015459f, 0.07056293f, -0.15678157f, 0.18881795f, 0.09103835f, -0.01229125f, 0.11227743f, 
    -0.05963096f, -0.10522222f, -0.12882474f, -0.03386895f, -0.12517238f, -0.42630208f, 0.08366389f, 0.07581569f, 
    0.07421257f, -0.17439251f, -0.07044721f, 0.09736669f, -0.00213214f, 0.05744880f, 0.01399020f, 0.01571718f, 
    -0.14941581f, 0.16784477f, 0.00379422f, 0.08878037f, -0.04020236f, -0.08448982f, 0.18223135f, 0.05933968f, 
    0.21942860f, -0.32153410f, -0.02794564f, -0.08029538f, 0.03979100f, 0.15873021f, -0.38611743f, -0.05324083f, 
    0.09015813f, 0.12374828f, 0.17315726f, -0.03141350f, 0.07288005f, -0.02843541f, -0.02150595f, 0.06139684f, 
    -0.08348610f, 0.13112958f, 0.05041179f, 0.15417075f, -0.04450421f, -0.03894101f, 0.20379233f, 0.05627963f, 
    0.19633086f, 0.08019742f, 0.07782784f, -0.07124452f, 0.14616819f, -0.17094168f, 0.09390699f, 0.15913504f, 
    0.34041008f, -0.03443361f, -0.30214006f, 0.08725490f, 0.03542165f, 0.06683249f, -0.03448141f, 0.06741577f, 
    -0.10649678f, 0.02287958f, 0.03839318f, 0.24002752f, -0.01617842f, -0.01279558f, -0.06704920f, 0.34056550f, 
    -0.09395203f, 0.19701004f, 0.27537784f, -0.11704756f, -0.18854719f, 0.19701478f, -0.00656704f, 0.14763756f, 
    -0.18713906f, 0.07767900f, 0.07522832f, 0.25211865f, 0.06682111f, 0.18619360f, 0.27943164f, 0.01048754f, 
    0.03895856f, 0.07406086f, -0.09792840f, 0.10618423f, 0.50670701f, 0.30039784f, 0.12065300f, -0.13201848f, 
    0.20423630f, 0.07580305f, -0.09902535f, -0.06099722f, 0.08440900f, -0.08589641f, 0.31667256f, 0.09423501f, 
    0.01464069f, 0.10572363f, 0.07097327f, 0.53235507f, 0.02830361f, 0.00898076f, -0.31567049f, -0.17854615f, 
    0.00581711f, -0.02629737f, -0.11665355f, 0.07807042f, 0.07730915f, 0.37561432f, 0.12730980f, -0.13085909f, 
    -0.07072303f, -0.02515063f, -0.12400296f, 0.01796582f, -0.01069319f, -0.15216310f, 0.20569514f, -0.30972037f, 
    0.01906016f, -0.00222684f, 0.07300158f, -0.00514287f, -0.18407625f, 0.00667139f, -0.04310220f, -0.11410367f, 
    0.14657328f, 0.43455616f, -0.13313003f, -0.15656649f, -0.14430985f, 0.04079686f, 0.03038554f, -0.03909458f, 
    0.31042969f, -0.13146599f, -0.06312913f, -0.17533076f, -0.02613406f, 0.02055810f, -0.04121212f, 0.32665220f, 
    -0.19756174f, -0.51052082f, 0.17141335f, -0.03164466f, 0.15518378f, -0.08017563f, -0.22650498f, 0.05434545f, 
    0.12771823f, 0.08038875f, -0.12631485f, 0.20066430f, -0.12218035f, 0.01969972f, 0.10261782f, 0.07532822f, 
    0.36480907f, -0.03315225f, -0.00224405f, -0.06947791f, -0.12596597f, 0.00978565f, -0.11533374f, 0.04315154f, 
    -0.15671670f, 0.07612003f, 0.04522668f, -0.13009733f, -0.00355865f, -0.03873583f, 0.03956478f, 0.09875941f, 
    0.04141506f, 0.07508489f, -0.07614889f, -0.00111621f, 0.02005667f, 0.23189153f, 0.09801751f, -0.05122323f, 
    0.05566532f, 0.32639864f, -0.11268307f, -0.23261571f, -0.10256030f, -0.13603283f, -0.01385393f, -0.00075846f, 
    -0.06427804f, -0.08036806f, 0.15164521f, 0.05138903f, -0.17600155f, 0.11240132f, 0.08747254f, -0.08384726f, 
    0.02158527f, -0.21792471f, -0.07078546f, 0.15049458f, 0.17215189f, 0.08096649f, 0.07886863f, 0.07584335f, 
    -0.00571485f, 0.11126330f, -0.42658263f, 0.02461457f, 0.36977279f, 0.20039739f, 0.17293496f, -0.06996395f, 
    -0.03915897f, 0.22374314f, 0.08663396f, -0.17515135f, -0.02668582f, 0.12927625f, 0.02456439f, -0.07813490f, 
    -0.54460162f, -0.03799001f, 0.04548595f, 0.30043373f, 0.22648308f, -0.07814143f, 0.35995367f, -0.15741001f, 
    -0.02570913f, -0.01538728f, -0.08377817f, 0.09765643f, -0.06686448f, 0.09035936f, 0.06062111f, 0.05704821f, 
    0.11631268f, 0.05146978f, -0.01655170f, -0.02571036f, -0.03069913f, -0.46052334f, 0.12699901f, -0.00510037f, 
    -0.22200574f, 0.04069663f, 0.05695561f, -0.03275236f, -0.07928259f, 0.03248077f, -0.01029137f, -0.03545498f, 
    -0.08774445f, 0.06169687f, 0.09318920f, -0.16910091f, -0.05531197f, -0.02289140f, -0.08401977f, 0.00277970f, 
    0.14983498f, -0.23559920f, 0.02397287f, -0.17307049f, -0.15306468f, -0.04257154f, 0.14001553f, 0.18921737f, 
    -0.09828134f, 0.13927566f, -0.06445650f, -0.08248691f, 0.17072506f, -0.10185825f, 0.11752828f, 0.08651266f, 
    0.16364887f, -0.00205940f, -0.23359734f, 0.01163279f, 0.04280166f, 0.05401188f, 0.21532364f, -0.08278703f, 
    0.07571311f, 0.03613966f, 0.17171164f, -0.02996192f, 0.00959810f, -0.07871881f, 0.12849474f, -0.07042893f, 
    0.03501689f, -0.02214033f, -0.04701492f, -0.19595005f, 0.02917506f, -0.59390944f, 0.05769677f, 0.05587364f, 
    0.08237018f, 0.00307365f, -0.49819121f, 0.03020720f, 0.03868733f, 0.34209728f, 0.20155004f, 0.02580825f, 
    -0.17103298f, 0.03509193f, 0.04466363f, 0.13127644f, 0.06031108f, -0.30508053f, 0.10002733f, 0.05944737f, 
    -0.23784627f, -0.00245208f, 0.10920182f, -0.24196938f, -0.03507674f, 0.08636326f, -0.03651156f, 0.04618253f, 
    -0.05029342f, 0.03645969f, 0.12922840f, 0.15711412f, 0.05854755f, 0.11173984f, 0.08815443f, 0.04888574f, 
    0.06159386f, -0.08225449f, 0.26739454f, -0.13559674f, 0.21512361f, 0.00459689f, -0.01982628f, -0.01633060f, 
    0.10571253f, 0.07094873f, 0.02805636f, 0.20125259f, 0.04566863f, 0.08328424f, 0.12604663f, 0.10781652f, 
    0.12938067f, 0.06562160f, -0.00211550f, 0.26639980f, 0.13419119f, 0.02726634f, -0.00305824f, -0.00703104f, 
    -0.11215042f, 0.14493375f, -0.05710626f, -0.19031340f, 0.04568483f, 0.07519258f, -0.08993453f, 0.20641182f, 
    -0.02652602f, -0.04102891f, -0.00050390f, 0.04682057f, -0.01745886f, -0.00380124f, -0.01002710f, 0.09607012f, 
    -0.11931407f, -0.03282959f, -0.01404744f, -0.11053880f, 0.23019610f, 0.19061580f, 0.06676760f, -0.09776254f, 
    -0.05566733f, 0.10666136f, -0.03262295f, -0.34313300f, 0.03850948f, -0.04449510f, 0.03446678f, -0.04603140f, 
    0.01937505f, 0.13738337f, 0.04675146f, -0.04599879f, -0.06371190f, 0.13917337f, 0.04457742f, 0.03434583f, 
    -0.16623434f, -0.19048741f, -0.03767508f, -0.03107382f, -0.03156740f, 0.05002998f, -0.21852750f, -0.11259998f, 
    -0.16159783f, 0.01496860f, 0.21608485f, -0.19707577f, -0.01159942f, 0.00594027f, -0.17633371f, -0.12144276f, 
    0.04147892f, 0.05006635f, -0.10247056f, 0.05340900f, 0.04611480f, -0.09981156f, 0.10124271f, 0.10160463f, 
    0.02531902f, -0.01402786f, -0.06245228f, -0.07596186f, 0.02084730f, 0.00595948f, -0.11780523f, -0.06358890f, 
    0.02679580f, 0.07432985f, -0.00924948f, -0.13668789f, -0.17099816f, 0.18272136f, 0.19457678f, 0.14742506f, 
    -0.05112351f, -0.09923746f, -0.04787489f, -0.09035764f, -0.05784838f, -0.04023657f, -0.06528717f, 0.02781121f, 
    -0.05724657f, 0.05966185f, -0.06156866f, -0.07772239f, -0.07078098f, 0.03479568f, -0.08837995f, 0.03648876f, 
    -0.08156481f, -0.04886260f, 0.06437229f, -0.01119998f, -0.05738352f, -0.00107860f, -0.02792978f, 0.00078724f, 
    -0.08564604f, 0.03412551f, 0.01738499f, -0.02884196f, -0.03724868f, -0.06068185f, 0.04258741f, -0.04812484f, 
    -0.06246921f, -0.02029857f, -0.06125483f, -0.02666178f, 0.01775301f, -0.02065077f, -0.00115061f, 0.00912188f, 
    0.05156543f, -0.13131389f, -0.04345613f, 0.02930820f, -0.03935631f, -0.00795416f, 0.01825087f, -0.07260881f, 
    -0.02326785f, 0.00054193f, 0.00193888f, 0.05691263f, 0.01005530f, -0.06219793f, -0.03624625f, -0.03934630f, 
    0.06031917f, -0.03431948f, 0.03702379f, 0.02684148f, -0.02001166f, -0.01909506f, -0.07810405f, -0.01411307f, 
    0.05845783f, -0.04798996f, -0.04576543f, -0.05351390f, -0.11442851f, -0.02552887f, 0.04623212f, -0.03946727f, 
    -0.08122645f, 0.01908473f, -0.05954975f, -0.01805425f, 0.02889813f, -0.03770943f, 0.00972050f, -0.06912282f, 
    -0.00488473f, -0.05974066f, -0.09528154f, -0.04709531f, -0.07547021f, -0.04483805f, -0.04317370f, -0.10819171f, 
    0.04006031f, -0.10815687f, -0.02295821f, -0.03477101f, 0.06423192f, -0.04135152f, -0.00025999f, 0.01440633f, 
    -0.03356868f, -0.04583471f, -0.03553550f, -0.00131891f, -0.07427612f, -0.06793970f, -0.10490993f, 0.04438733f, 
    -0.08132320f, 0.03246737f, -0.04552265f, -0.01059824f, 0.05167459f, -0.00567711f, 0.00369199f, -0.03767268f, 
    -0.03579327f, 0.01876073f, -0.02855372f, -0.09599980f, -0.10787808f, -0.02659833f, 0.00145794f, -0.06598715f, 
    0.03432041f, -0.00806217f, -0.05972512f, 0.04567071f, -0.00147629f, 0.02445878f, -0.09541806f, -0.09467832f, 
    0.07203491f, 0.36056989f, -0.25332859f, 0.17557888f, -0.03206386f, 0.20099959f, 0.01670338f, -0.03186858f, 
    0.05386833f, 0.06445450f, 0.05357792f, 0.13317715f, -0.26115909f, -0.07930148f, -0.34092036f, -0.00248339f, 
    0.05049334f, 0.00286825f, -0.03676323f, 0.21447232f, -0.02777437f, 0.08565512f, -0.00142074f, -0.10851245f, 
    -0.02000992f, 0.05603614f, 0.02631844f, 0.15763502f, 0.26814970f, 0.07693020f, 0.10693616f, -0.36914182f, 
    0.18436216f, 0.04810545f, -0.10774244f, -0.29727402f, -0.04280907f, -0.25679803f, -0.05095767f, 0.12659772f, 
    -0.02034485f, -0.07115804f, -0.07316501f, 0.00170412f, -0.07681523f, 0.07873797f, 0.38949591f, -0.16956352f, 
    -0.09909026f, -0.10672747f, 0.01797663f, 0.23718974f, -0.08299607f, 0.37778911f, -0.05306033f, 0.00614495f, 
    0.23337150f, 0.00045376f, 0.07282634f, 0.07063004f, -0.07866598f, -0.18578786f, 0.02616817f, -0.02871418f, 
    0.03081456f, 0.23259422f, 0.23000398f, -0.16640259f, -0.10890975f, -0.02085406f, 0.04616316f, -0.07073296f, 
    0.06322282f, 0.25687832f, -0.02791606f, 0.00570521f, -0.43508941f, -0.02020785f, 0.16627243f, 0.08221088f, 
    0.07827471f, -0.20470406f, 0.11188887f, -0.06505596f, -0.03631594f, 0.15360309f, -0.00202849f, -0.17824683f, 
    -0.15190598f, -0.19746682f, -0.33730981f, -0.16148916f, -0.10621777f, -0.11107091f, 0.25920436f, 0.19835339f, 
    0.09346197f, -0.05365604f, 0.03902337f, 0.25480330f, 0.02355655f, -0.04233154f, -0.31653577f, 0.09150898f, 
    0.25127211f, -0.15893811f, -0.28263724f, 0.07044456f, 0.19980183f, -0.04880681f, 0.11691876f, 0.11255921f, 
    -0.06906421f, -0.24672318f, 0.01461304f, -0.05989869f, -0.19876178f, 0.01253111f, 0.00616861f, 0.24556774f, 
    0.10150187f, 0.01524646f, -0.08480385f, -0.01278419f, 0.31068367f, 0.27573392f, 0.15775955f, 0.11878908f, 
    0.12749475f, -0.00941886f, 0.03237537f, -0.44259477f, -0.12265819f, 0.07944280f, -0.05388873f, -0.07045058f, 
    -0.05237864f, -0.20355266f, 0.00712588f, 0.25057673f, 0.09695708f, -0.17520660f, -0.06686363f, -0.05807263f, 
    -0.35346162f, -0.19134443f, -0.43841383f, -0.03780893f, -0.10687978f, 0.02955889f, -0.08109941f, 0.05143318f, 
    -0.06859627f, 0.06775325f, -0.40098837f, 0.33454052f, 0.02641826f, 0.19626743f, 0.10935656f, 0.16839360f, 
    -0.09686436f, 0.16609946f, 0.09978329f, -0.22616886f, -0.01477286f, -0.01561609f, -0.14429340f, -0.21573474f, 
    0.06885632f, -0.10313962f, 0.15168843f, -0.00211992f, 0.01171757f, 0.11491652f, 0.04808696f, -0.07880243f, 
    0.00835684f, 0.05127235f, 0.01194623f, -0.01685320f, 0.00227117f, -0.06240124f, 0.04792198f, -0.11829258f, 
    -0.05757558f, 0.00207712f, -0.07712711f, -0.39926818f, 0.28217921f, 0.08012378f, -0.08557492f, 0.12439768f, 
    -0.23690906f, 0.05248897f, -0.21122186f, 0.11116083f, -0.05685174f, 0.06179490f, 0.04296584f, 0.02956974f, 
    -0.01592843f, -0.07415699f, -0.28345218f, 0.09661496f, -0.03209975f, 0.05318733f, 0.08933054f, 0.00836687f, 
    0.07372733f, -0.24977556f, 0.04290836f, -0.06253611f, -0.08020425f, -0.21459486f, -0.15253632f, 0.05253085f, 
    0.18646125f, -0.45489621f, -0.06099122f, 0.10046601f, 0.49458072f, 0.09205148f, 0.23509739f, 0.13892719f, 
    0.01910568f, 0.00179043f, -0.14221792f, 0.05139400f, -0.14949292f, 0.05759756f, 0.27780089f, -0.10513964f, 
    -0.03234046f, 0.13575050f, 0.17280044f, -0.29288843f, 0.06810723f, 0.10174475f, 0.16976346f, -0.21372047f, 
    0.10752089f, 0.11068439f, 0.06278566f, -0.03388684f, 0.02057697f, 0.00654108f, 0.09771175f, -0.01047796f, 
    0.06279894f, -0.10869353f, -0.05144082f, 0.08468559f, 0.33813161f, 0.08850013f, -0.05340537f, -0.10624386f, 
    -0.07377937f, -0.02617073f, -0.10283864f, -0.10594793f, -0.19063984f, 0.11693081f, 0.02436790f, -0.23368067f, 
    0.14377479f, -0.05746515f, -0.01142688f, 0.30365670f, -0.07639371f, 0.02989438f, -0.27136177f, -0.19978638f, 
    0.07469195f, 0.03579034f, -0.29977298f, -0.05914510f, -0.03015719f, -0.11523551f, -0.19316655f, -0.04621783f, 
    -0.06462862f, 0.12709756f, -0.17061990f, 0.24239963f, -0.22696695f, -0.14019135f, 0.21652538f, -0.26483440f, 
    -0.15246129f, -0.07801706f, -0.07683542f, -0.06395751f, 0.08142450f, -0.55031478f, -0.44489083f, -0.06705840f, 
    0.28770325f, -0.14356826f, 0.07931335f, -0.22970714f, -0.25343084f, 0.17055042f, -0.11633319f, -0.06520519f, 
    -0.03569108f, -0.29530078f, 0.06640883f, -0.16872904f, 0.09042894f, 0.05745934f, -0.07375538f, 0.11730983f, 
    0.32659629f, 0.36137530f, 0.16634861f, -0.05563467f, -0.17932387f, -0.60376066f, -0.02750770f, 0.49059254f, 
    -0.03850678f, 0.24590990f, 0.03920268f, 0.01519206f, 0.19203232f, -0.52565897f, 0.06795776f, 0.02740990f, 
    -0.18819396f, 0.03951579f, 0.03062811f, 0.23896851f, -0.11664723f, -0.06762902f, 0.31962451f, 0.30679506f, 
    -0.02122776f, 0.06088145f, -0.35709193f, -0.17472306f, -0.25055167f, 0.28760383f, -0.02578046f, -0.07219126f, 
    0.08221301f, -0.25255111f, 0.02571439f, -0.10441055f, 0.04134113f, -0.03947577f, 0.50127357f, -0.28294271f, 
    -0.12705481f, -0.29251197f, -0.05698595f, 0.25557017f, 0.24599372f, -0.00623706f, -0.35971773f, -0.02640368f, 
    -0.12723537f, 0.12898651f, -0.59164864f, 0.06833750f, 0.28200150f, -0.13107367f, 0.14112779f, -0.05423712f, 
    -0.10762331f, 0.09390308f, 0.02082008f, -0.20829931f, 0.13348308f, 0.20341501f, 0.06748703f, 0.14426206f, 
    -0.01105110f, -0.05528111f, 0.10766815f, 0.22786482f, 0.37475067f, -0.14390342f, -0.18067645f, 0.09773777f, 
    -0.10628730f, -0.01396629f, -0.10300433f, 0.03391088f, -0.01592109f, -0.02266910f, -0.03990600f, -0.03251806f, 
    -0.02680552f, -0.07788559f, 0.04457318f, 0.05633137f, -0.00808011f, 0.01792746f, 0.02113383f, 0.03536891f, 
    -0.02514689f, -0.09643015f, -0.00127710f, 0.04682722f, 0.04884483f, -0.04465772f, -0.01627705f, -0.06437069f, 
    -0.03228637f, -0.03145207f, 0.07519440f, -0.06978079f, 0.03552186f, -0.06739274f, 0.07742366f, -0.11255044f, 
    -0.02958523f, 0.00144595f, -0.11718003f, 0.03867700f, -0.09914750f, -0.05886191f, 0.05858255f, 0.02974146f, 
    -0.04423613f, 0.01468261f, -0.08290669f, 0.04192849f, 0.01241934f, 0.06806338f, -0.05479129f, 0.02887660f, 
    -0.03753275f, 0.02178265f, -0.07053784f, 0.06367576f, -0.01598669f, -0.05217154f, 0.00292297f, 0.01764624f, 
    0.06248296f, -0.05290441f, -0.07853857f, -0.03699559f, 0.01524268f, -0.01977211f, -0.00469704f, -0.04970620f, 
    -0.03202552f, -0.09951681f, -0.07362220f, -0.00219459f, 0.03634685f, 0.01211456f, 0.00925063f, -0.02723669f, 
    -0.05421666f, 0.03158249f, -0.06903038f, -0.04719128f, 0.03381640f, 0.04654785f, 0.03630679f, 0.03301556f, 
    -0.04297918f, 0.02778724f, -0.03189337f, 0.02907990f, 0.03329190f, -0.04293279f, -0.11647092f, -0.06282201f, 
    -0.06396148f, -0.07287683f, -0.02499587f, -0.05735135f, -0.02774387f, -0.10027640f, -0.07644854f, -0.00520860f, 
    -0.07160843f, 0.03552530f, -0.08787615f, -0.01971721f, 0.02865030f, 0.04774469f, -0.10716894f, -0.01539311f, 
    0.02884673f, -0.05834197f, -0.02510856f, 0.02835381f, -0.07967909f, -0.09453867f, -0.11176270f, -0.01173743f, 
    -0.00087328f, -0.11039003f, -0.03165485f, -0.02724382f, 0.03265467f, 0.03744933f, 0.00668455f, 0.07092424f, 
    -0.04742879f, 0.04997295f, 0.08494943f, -0.07209942f, 0.06845383f, 0.06745953f, 0.00643385f, -0.11199398f, 
    0.02104060f, 0.34696746f, -0.05426810f, 0.11498153f, -0.26525828f, 0.11293620f, -0.06673976f, 0.01002056f, 
    0.02267519f, 0.32394779f, 0.13321751f, 0.06149829f, -0.35575336f, 0.01511326f, -0.16598618f, -0.10339245f, 
    -0.01630534f, -0.01228649f, 0.10650761f, 0.24241120f, 0.14890586f, 0.01181893f, 0.15240727f, -0.05293880f, 
    -0.08551811f, 0.07641593f, -0.13447753f, 0.19277237f, 0.35990801f, 0.29206368f, 0.04687814f, -0.13219059f, 
    0.10276391f, 0.19253419f, 0.12472863f, -0.46410832f, 0.04330777f, -0.38897607f, -0.00049636f, -0.15598065f, 
    0.24892861f, -0.03982612f, 0.04156809f, 0.51984054f, 0.16553698f, 0.02879573f, -0.03397674f, -0.09080546f, 
    -0.07412782f, -0.06587930f, -0.00886130f, 0.05519582f, 0.06804067f, 0.37919328f, -0.05892609f, -0.03907940f, 
    0.13679272f, 0.13440849f, -0.04065402f, -0.12871483f, -0.22086370f, -0.31814790f, -0.04257486f, -0.00885805f, 
    0.03345724f, 0.05399779f, 0.14808744f, -0.06611199f, -0.19228342f, -0.06038662f, -0.20366378f, 0.03876916f, 
    -0.02458249f, 0.23935245f, 0.17426199f, -0.07188363f, -0.37050053f, -0.01770172f, 0.01112638f, 0.06384401f, 
    0.09715635f, -0.30264264f, -0.03307134f, -0.16830902f, -0.05423611f, -0.04213065f, -0.04617103f, 0.01283818f, 
    -0.16523865f, 0.25616661f, -0.14058910f, -0.37881151f, 0.12086695f, -0.11878037f, -0.06496962f, 0.18672146f, 
    0.16527598f, -0.15317908f, 0.02865299f, 0.17149642f, -0.06787199f, 0.02115791f, -0.20533882f, 0.08729656f, 
    0.28504786f, -0.05860195f, -0.41217798f, 0.10923305f, 0.07219468f, -0.11106048f, 0.15207019f, -0.01823197f, 
    0.03751413f, -0.13943508f, 0.05411949f, -0.14244062f, -0.09668916f, -0.07383753f, 0.08619922f, 0.15689990f, 
    0.14364439f, 0.05373431f, -0.01751078f, 0.06523224f, 0.23411381f, 0.22695079f, -0.05451734f, -0.02325313f, 
    0.07128934f, -0.36010274f, -0.08527479f, -0.09171824f, 0.00155688f, -0.14529985f, 0.06511346f, 0.23396125f, 
    0.03818376f, -0.22898760f, 0.06501755f, -0.19416919f, 0.01155005f, -0.08404441f, -0.00154831f, 0.27051279f, 
    -0.33544284f, 0.03368360f, 0.07414999f, -0.02100682f, 0.05202747f, 0.04191163f, 0.19793089f, -0.17668886f, 
    -0.01928380f, -0.07668766f, -0.03994350f, 0.00761362f, -0.17437060f, 0.11505265f, -0.03320010f, 0.10040540f, 
    0.08052886f, 0.12163860f, -0.07311399f, -0.00335675f, 0.07884321f, -0.01783969f, 0.02240659f, -0.01351436f, 
    -0.37738690f, -0.16067976f, -0.00824448f, -0.58470911f, -0.19737099f, -0.06389540f, 0.29859647f, -0.10706185f, 
    0.15926957f, -0.17520694f, 0.10898124f, 0.12714665f, -0.06360412f, 0.03152435f, -0.07377993f, 0.13439295f, 
    0.06512659f, 0.04238747f, -0.13428973f, 0.28244057f, 0.15538307f, -0.01358084f, 0.07010586f, -0.09706306f, 
    0.11956044f, 0.17283151f, -0.14293838f, 0.03739513f, -0.02572340f, 0.05066905f, -0.07975473f, -0.01084759f, 
    0.00351946f, 0.15662341f, -0.29508555f, 0.09289724f, 0.02221054f, -0.08319889f, 0.00747841f, 0.09340014f, 
    0.21405455f, -0.07942408f, 0.17215270f, -0.03086032f, 0.03493679f, -0.13019998f, -0.00986875f, 0.33690655f, 
    0.07498100f, -0.44799101f, -0.02070519f, -0.11490010f, 0.02135165f, 0.11873925f, 0.15348981f, 0.21048768f, 
    0.09817699f, -0.12646344f, 0.02417267f, -0.04596487f, -0.03007441f, 0.06330327f, 0.12989235f, 0.05105253f, 
    0.11193601f, -0.14911652f, -0.07375412f, 0.04523222f, -0.22304921f, -0.02380246f, -0.15833358f, 0.01048180f, 
    -0.06768645f, 0.13880050f, 0.00987062f, -0.24186574f, 0.07763511f, -0.05844107f, 0.00494439f, -0.03953940f, 
    -0.09769401f, 0.06833179f, -0.44011205f, -0.09040704f, -0.06191384f, -0.03221139f, -0.02353434f, -0.30930084f, 
    -0.03170192f, 0.17443530f, -0.11044241f, -0.23959373f, -0.15996726f, 0.33805782f, -0.08780994f, -0.09376448f, 
    -0.10184608f, -0.15108426f, -0.00550380f, 0.36456519f, -0.16996884f, -0.11390822f, -0.07423855f, 0.15862010f, 
    -0.15082423f, 0.03896121f, -0.25085858f, 0.10505196f, -0.10306084f, 0.07276359f, 0.06159582f, -0.03220687f, 
    -0.08019990f, 0.02077325f, -0.49719861f, 0.26376453f, -0.21708995f, 0.20932253f, 0.05884573f, -0.15358812f, 
    -0.06816593f, -0.06569185f, -0.00984527f, -0.16296266f, 0.19487289f, -0.12581639f, 0.04493700f, -0.00587319f, 
    -0.27008808f, -0.25749138f, -0.03392367f, -0.00479518f, 0.18879594f, 0.10802175f, 0.31037492f, -0.21935195f, 
    0.11145873f, -0.11041702f, -0.05322655f, 0.18891278f, -0.06868364f, 0.34371582f, -0.13001154f, -0.20211142f, 
    0.04521434f, 0.03489869f, 0.30205631f, 0.24915953f, 0.00346761f, -0.18607214f, -0.10399666f, 0.02103270f, 
    -0.02414968f, 0.20380938f, -0.00570888f, 0.04250079f, 0.04845844f, 0.40242082f, -0.05743363f, -0.03412101f, 
    -0.00535481f, 0.26010182f, -0.03101903f, 0.06181336f, -0.01608380f, 0.00303465f, -0.02755713f, -0.08865118f, 
    -0.02255565f, -0.13332883f, 0.02434367f, -0.02689339f, -0.01473478f, 0.10739269f, 0.06801049f, 0.15136310f, 
    0.28795451f, -0.36245894f, -0.17449702f, 0.07105843f, 0.21559276f, 0.08210289f, -0.04658536f, 0.29284480f, 
    -0.07180022f, 0.24354197f, -0.18590841f, 0.30146211f, 0.14562912f, 0.08306169f, -0.01100404f, 0.17295428f, 
    0.11670022f, -0.16894186f, -0.17276922f, -0.01231716f, 0.10765310f, -0.04328319f, 0.00849669f, -0.08907691f, 
    -0.10284525f, -0.06441200f, 0.07492203f, 0.02289853f, -0.18230504f, -0.07968906f, -0.06002910f, 0.20078576f, 
    0.02740001f, 0.07222065f, -0.33494586f, 0.00970089f, 0.34772804f, 0.11508703f, 0.06538451f, 0.07622281f, 
    -0.05507908f, -0.32747814f, 0.03859743f, -0.17466410f, -0.12406638f, -0.43031102f, -0.06680141f, -0.41904324f, 
    0.01374174f, 0.08647671f, 0.13188630f, -0.30588248f, 0.00108663f, -0.11374369f, 0.08215427f, -0.29091370f, 
    -0.18429998f, 0.01548554f, 0.01657375f, 0.35008067f, 0.12089408f, 0.08301672f, 0.08210048f, 0.13878761f, 
    -0.07795043f, 0.09597547f, -0.12795001f, -0.53079575f, 0.12584068f, 0.21396779f, 0.19416469f, 0.04713338f, 
    0.02188786f, 0.01085157f, -0.04688179f, -0.46531308f, 0.01682019f, 0.16808529f, 0.31794286f, -0.01449566f, 
    -0.09501622f, 0.17275986f, -0.00846592f, -0.22603247f, -0.19728969f, -0.24276121f, 0.11906363f, -0.06975769f, 
    -0.13096434f, 0.00132086f, -0.07381342f, -0.16851093f, 0.01001053f, -0.39187512f, -0.00980601f, 0.06400442f, 
    0.14331515f, -0.44332927f, 0.08967054f, -0.44938478f, -0.04035569f, 0.13437806f, 0.02626685f, 0.06989396f, 
    0.02861647f, -0.20756775f, 0.32485786f, 0.14046726f, 0.04158266f, -0.35442674f, -0.48873860f, -0.00421600f, 
    0.00085908f, -0.08094700f, -0.02036365f, -0.54165304f, 0.09320581f, 0.07004677f, 0.11541943f, 0.11704111f, 
    -0.25669059f, -0.35080320f, -0.24625082f, 0.08574066f, 0.15083338f, 0.13802722f, 0.23499084f, 0.12157184f, 
    -0.02240906f, 0.12308732f, 0.04970257f, 0.02928721f, -0.22404264f, 0.14405438f, 0.01811698f, -0.09116273f, 
    -0.08806100f, 0.08716679f, 0.21717918f, -0.12465489f, 0.04211535f, -0.02207896f, 0.08974633f, -0.29393718f, 
    0.19161835f, 0.11995953f, 0.25544602f, 0.09040172f, 0.02587875f, 0.00908036f, -0.04189871f, 0.05544110f, 
    0.14822906f, 0.01542831f, 0.04796275f, 0.07944394f, 0.12047514f, -0.30620971f, -0.01411384f, -0.26822263f, 
    0.08601825f, -0.10365544f, 0.14722429f, -0.21133715f, -0.51446277f, 0.19079737f, 0.41017887f, 0.05516614f, 
    -0.02692357f, -0.29626727f, 0.04263338f, 0.00148756f, 0.01684320f, -0.03817822f, -0.00697814f, 0.25474432f, 
    0.01039694f, 0.14818951f, 0.12694299f, -0.06286763f, -0.05210790f, 0.04439121f, 0.03083737f, 0.30605674f, 
    -0.37608632f, 0.01232369f, -0.09649050f, 0.04299917f, 0.20188427f, -0.00645748f, 0.05024032f, -0.17176805f, 
    -0.02246467f, -0.07546055f, -0.17508887f, 0.17419703f, -0.34413612f, 0.14217792f, 0.08897018f, 0.20267069f, 
    0.02315569f, 0.18181933f, 0.11402742f, 0.11191708f, 0.04088692f, -0.17849025f, 0.18540365f, -0.50188988f, 
    -0.17367269f, -0.06674806f, 0.06147441f, 0.07470730f, 0.18005714f, 0.26393554f, -0.03065517f, -0.16347323f, 
    0.08795201f, 0.07155227f, 0.10991557f, -0.10135048f, 0.04062486f, -0.21557453f, 0.08920874f, 0.18773904f, 
    -0.00825298f, 0.06563864f, -0.21797112f, 0.05987914f, 0.25242573f, 0.12651175f, 0.11799894f, 0.03842273f, 
    -0.17527777f, 0.08379939f, -0.18469359f, 0.11929208f, 0.15660676f, 0.21620953f, 0.18314819f, -0.00770561f, 
    -0.05336082f, 0.09260306f, -0.15554750f, 0.06516442f, -0.03731233f, 0.01091357f, -0.34986338f, 0.19480048f, 
    0.16614845f, 0.05495301f, 0.16973345f, -0.17954989f, -0.21753815f, -0.26956642f, -0.09195867f, 0.17594121f, 
    0.07866208f, -0.26331109f, -0.04381831f, -0.15899044f, 0.27550063f, 0.03798489f, -0.03826055f, 0.16693014f, 
    0.24902344f, 0.07260823f, 0.02912864f, -0.26666415f, -0.11900294f, 0.01470646f, 0.35344937f, 0.04790588f, 
    0.07444138f, 0.12691896f, 0.00203295f, -0.06331935f, -0.38186881f, 0.01196798f, -0.15564971f, -0.05843706f, 
    -0.07814331f, -0.00883445f, 0.00299354f, -0.18227248f, 0.21533421f, -0.01136302f, 0.08566399f, 0.07827777f, 
    0.01878270f, 0.00048681f, -0.48074603f, 0.25569358f, -0.02357198f, -0.11034003f, -0.07624877f, -0.28321806f, 
    0.04756629f, -0.07902759f, -0.18063676f, -0.51456416f, -0.34305045f, 0.20207027f, -0.03786108f, -0.05480842f, 
    0.27314687f, -0.26736993f, -0.08564442f, 0.43097720f, -0.19382888f, -0.17472140f, -0.24200277f, -0.11148946f, 
    -0.21595061f, -0.15846735f, -0.26513714f, -0.11696590f, -0.13446605f, 0.22196184f, -0.16888887f, -0.14114246f, 
    -0.07895465f, 0.16254787f, 0.08311860f, 0.29845920f, 0.15229923f, -0.05033286f, 0.35918081f, -0.01431061f, 
    -0.12769867f, 0.06333242f, 0.04167965f, -0.24241903f, 0.01054320f, -0.34753621f, -0.39065981f, -0.20632072f, 
    0.15569249f, -0.12904540f, 0.13512215f, 0.08919779f, -0.01167390f, 0.32873383f, -0.03419355f, -0.11828711f, 
    -0.01755621f, -0.02129124f, 0.10561544f, -0.10263642f, 0.09449615f, 0.09327152f, 0.04272186f, -0.03900477f, 
    0.15381984f, 0.33565280f, 0.09843624f, -0.03384612f, -0.17368120f, -0.18532507f, 0.02360297f, 0.34873214f, 
    0.03684381f, 0.18663068f, -0.00443247f, 0.06485582f, 0.29425573f, 0.54822034f, 0.07858241f, 0.01907653f, 
    -0.29538289f, 0.14864366f, -0.17113480f, 0.45310161f, -0.13337177f, -0.00207120f, 0.33166277f, 0.22794662f, 
    0.13178381f, -0.23718503f, -0.27089986f, -0.00680638f, 0.01137841f, 0.16444103f, -0.09971435f, 0.12102509f, 
    0.07250193f, -0.32560304f, -0.31095210f, -0.23815903f, 0.36666256f, 0.17351590f, 0.39969462f, 0.01936132f, 
    0.04234560f, 0.04678386f, 0.00701215f, 0.42608556f, 0.08953494f, 0.05077629f, -0.05413845f, -0.08218621f, 
    0.12259112f, -0.11718029f, -0.24602297f, -0.17663853f, 0.30455312f, -0.16019732f, 0.07321688f, -0.22066654f, 
    -0.06209561f, -0.05918435f, -0.00843338f, -0.02048270f, 0.00840936f, -0.43442747f, 0.01250480f, 0.18430223f, 
    -0.00713350f, -0.08207024f, -0.29809010f, 0.35856420f, 0.34554499f, -0.03051903f, -0.33258486f, -0.14156091f, 
    -0.05236488f, -0.02077359f, 0.04336515f, -0.18501395f, -0.21257877f, 0.10383724f, 0.03392941f, 0.04272252f, 
    0.00911747f, -0.29231390f, 0.12427772f, 0.23094255f, -0.22278558f, -0.14671068f, -0.13075101f, 0.08834425f, 
    -0.10725105f, -0.04219329f, -0.02376926f, -0.04702426f, -0.13856909f, 0.07832518f, -0.06134348f, -0.04838245f, 
    0.05988168f, 0.09001007f, -0.20423041f, 0.08002460f, -0.24715836f, 0.08668785f, 0.07521100f, -0.35166267f, 
    -0.01783630f, -0.09674937f, -0.10651003f, -0.17079072f, 0.13131849f, 0.00860351f, -0.04230688f, 0.25084588f, 
    -0.37033573f, -0.44509751f, -0.06835882f, -0.10130333f, 0.00791887f, 0.07103547f, 0.35331252f, -0.01258302f, 
    0.04516120f, -0.16799577f, 0.09984688f, 0.09502084f, 0.03714480f, 0.19364363f, 0.00999427f, 0.10132233f, 
    0.17413902f, 0.08220767f, 0.11545950f, 0.05439336f, -0.04646058f, -0.12901312f, 0.12177151f, 0.01986918f, 
    0.10006008f, 0.19303876f, 0.03326869f, 0.00555398f, 0.17931338f, 0.20557560f, 0.03391855f, 0.05228379f, 
    0.03609331f, 0.22228812f, -0.15158507f, 0.20687772f, -0.21033022f, 0.04919123f, 0.12666754f, 0.02872487f, 
    0.08179663f, -0.02033579f, -0.10760653f, -0.04743633f, 0.15607624f, 0.25072438f, 0.02540238f, 0.05670102f, 
    0.17942297f, -0.33459592f, -0.24743390f, -0.12785195f, 0.08348177f, 0.06301764f, 0.26750097f, -0.07425874f, 
    -0.08936276f, 0.01191167f, -0.09486427f, 0.26321378f, 0.17681086f, 0.03073870f, -0.18312910f, 0.14264885f, 
    0.02753991f, -0.13465889f, -0.33485413f, 0.02021088f, 0.17652182f, 0.05812748f, 0.03712765f, 0.06801038f, 
    -0.04519774f, -0.05540967f, 0.03995676f, 0.00673366f, -0.19051081f, 0.30075201f, 0.06608620f, 0.03423350f, 
    -0.04095421f, 0.01764302f, -0.09372447f, -0.00203440f, 0.29917163f, 0.14532471f, -0.01379259f, 0.11506967f, 
    0.10453480f, -0.02666514f, -0.26618201f, -0.14804102f, -0.11135858f, 0.22943020f, -0.07801401f, 0.15678503f, 
    0.23639333f, -0.00353958f, 0.08286878f, 0.00292319f, -0.10443958f, -0.08211572f, -0.19982420f, -0.03445316f, 
    -0.05262095f, -0.17703317f, -0.16613227f, -0.03029466f, 0.03660605f, 0.41406697f, 0.01087001f, -0.01299460f, 
    -0.04066405f, 0.02841410f, 0.19307944f, 0.28848809f, -0.23570319f, 0.23539512f, 0.10512350f, 0.01983296f, 
    0.19119275f, 0.15340781f, 0.01958774f, -0.26460931f, 0.02337562f, -0.09255850f, 0.17639214f, -0.27781519f, 
    0.18937288f, -0.48588043f, 0.04760534f, 0.16194263f, -0.07668489f, 0.18148659f, -0.30498475f, -0.18363427f, 
    -0.23386210f, 0.02439542f, 0.02639536f, -0.01130571f, -0.08441046f, 0.16874886f, -0.05023734f, 0.21658856f, 
    0.03585502f, -0.13966021f, -0.06844576f, -0.21610703f, 0.16751854f, 0.04101804f, 0.05737716f, -0.28197131f, 
    -0.18707687f, 0.00629123f, 0.08949415f, -0.06408548f, -0.35872090f, 0.25236738f, -0.03122100f, 0.03065212f, 
    0.16616732f, 0.17158906f, 0.01992571f, 0.02259170f, -0.35305211f, -0.06157864f, 0.09341761f, -0.04771033f, 
    0.38048482f, -0.13960351f, 0.17121948f, 0.03873466f, 0.06423420f, 0.11196321f, -0.02906198f, 0.07928962f, 
    -0.05981528f, -0.21535902f, -0.04956354f, -0.20956822f, 0.09640002f, 0.16965270f, 0.43984154f, -0.22213769f, 
    0.03315560f, 0.00012822f, -0.03627860f, 0.20626549f, -0.15730931f, -0.05077480f, 0.13565464f, 0.20427459f, 
    0.32836679f, 0.01286769f, 0.20971277f, -0.10554969f, -0.12040120f, -0.11234249f, 0.03563164f, -0.00471447f, 
    -0.13495106f, -0.03362038f, 0.09788199f, -0.00095923f, 0.06472285f, -0.21895623f, 0.05960460f, 0.11224561f, 
    -0.15564744f, -0.08740390f, 0.09052718f, 0.10263491f, 0.17346589f, 0.11492868f, -0.02904737f, -0.23538731f, 
    0.17974512f, -0.02789900f, 0.10314348f, 0.28762072f, -0.16469069f, 0.27921313f, -0.04858096f, -0.16919631f, 
    0.15230449f, 0.09994149f, -0.26052040f, 0.35327545f, 0.01303433f, -0.08721146f, -0.08718643f, -0.57105416f, 
    0.31221855f, -0.21894716f, -0.02088563f, -0.12865704f, -0.11035602f, -0.19633344f, -0.24380024f, 0.05152278f, 
    0.01656527f, -0.08638667f, 0.16866368f, 0.25991467f, -0.04816334f, -0.34476250f, -0.04088377f, 0.12539200f, 
    -0.10778708f, -0.20032446f, 0.05531068f, -0.08103749f, -0.10985173f, 0.05352160f, -0.25331980f, 0.17317361f, 
    -0.06631128f, -0.01631420f, 0.00007420f, -0.17831552f, -0.05971170f, 0.10490312f, 0.17204392f, 0.17202599f, 
    0.00740173f, 0.15713896f, 0.14591543f, 0.13809580f, 0.06503797f, -0.08266832f, 0.00280130f, -0.04232598f, 
    0.08605579f, -0.00378445f, 0.12465931f, -0.13139606f, -0.05046806f, 0.27058256f, 0.01213626f, -0.10027964f, 
    0.35944054f, -0.09834180f, -0.01831708f, 0.11033346f, -0.03234094f, -0.26656097f, -0.05515448f, 0.09223999f, 
    0.04349084f, -0.14275292f, 0.22376963f, 0.42498744f, -0.07083095f, 0.08052242f, 0.22037862f, -0.13515720f, 
    0.03842313f, -0.25291607f, 0.00473521f, 0.18119334f, 0.17643563f, 0.12415962f, -0.04162205f, -0.20232651f, 
    0.18631917f, -0.04604798f, -0.04053858f, -0.01958468f, -0.04748328f, 0.24677233f, 0.52370495f, 0.12944622f, 
    0.24507962f, -0.08370946f, -0.01868468f, 0.23305961f, -0.10389133f, -0.05788542f, -0.08635003f, 0.14468360f, 
    -0.09761497f, -0.18583006f, 0.03523518f, -0.08683106f, 0.03669678f, 0.06787926f, -0.03532805f, -0.15347019f, 
    0.10007968f, 0.11339474f, -0.03429785f, 0.20197156f, -0.05755877f, -0.11188889f, -0.09242488f, 0.15776478f, 
    0.06025815f, -0.05455871f, -0.20417853f, 0.08245094f, 0.25212896f, 0.03250985f, -0.15887585f, -0.12325314f, 
    0.01713160f, 0.13682832f, -0.00517477f, -0.02783997f, 0.01714262f, -0.09389311f, 0.05374997f, 0.07213156f, 
    -0.15265453f, -0.37829027f, 0.18654479f, -0.12141090f, -0.16800024f, -0.18664688f, -0.00738834f, -0.04128261f, 
    -0.10936133f, -0.12604985f, -0.16452949f, 0.15228318f, -0.14138122f, 0.20971760f, 0.16521931f, 0.23470765f, 
    0.03881911f, 0.06560866f, -0.41617462f, 0.03819218f, -0.21779928f, 0.08686723f, 0.05917757f, -0.03686792f, 
    0.05415231f, 0.09143294f, -0.22804110f, -0.11695407f, 0.13687401f, 0.07924647f, 0.08106717f, 0.00094383f, 
    -0.09817154f, 0.18819964f, 0.07435351f, -0.20574453f, -0.10500483f, 0.05558970f, 0.05635389f, -0.00047893f, 
    0.05575189f, -0.12152630f, 0.06078424f, 0.06555469f, -0.05599945f, 0.12034852f, 0.03293071f, -0.04715079f, 
    -0.01808465f, -0.09161727f, -0.02526231f, -0.08006829f, 0.22849721f, -0.01352689f, 0.08714185f, -0.16074930f, 
    -0.23168252f, 0.03264048f, -0.12647039f, 0.14448112f, -0.24050911f, 0.05876187f, 0.00440856f, -0.09090777f, 
    0.13678588f, 0.16720398f, -0.18731076f, -0.18452665f, 0.06580140f, -0.01412335f, 0.12800421f, 0.01652781f, 
    0.10075554f, -0.07182958f, 0.06980627f, -0.22349167f, 0.02474890f, 0.12796715f, 0.03715003f, 0.14618625f, 
    0.03639251f, -0.57598549f, -0.01090988f, 0.03964285f, 0.12895221f, 0.04666608f, 0.22764920f, -0.40399688f, 
    -0.23967680f, 0.05690615f, -0.25072750f, 0.07417236f, -0.06416956f, -0.09170486f, 0.22837588f, 0.24910769f, 
    0.13562667f, 0.17423572f, 0.06872283f, -0.10640882f, 0.06600937f, 0.03565989f, 0.08806669f, 0.10679061f, 
    -0.16932219f, 0.14330165f, 0.03400837f, -0.31219104f, 0.01794740f, -0.22676504f, -0.07034700f, -0.12119613f, 
    -0.14879937f, -0.03430414f, -0.13128087f, -0.14122613f, 0.02191932f, 0.23817301f, 0.15562788f, 0.14923784f, 
    0.04713592f, -0.05197053f, 0.01890927f, -0.05265689f, -0.03614858f, -0.06340339f, -0.06834259f, -0.02309188f, 
    -0.05523915f, -0.07757656f, -0.04790727f, -0.07143884f, 0.01998446f, -0.03877820f, -0.08241452f, 0.02127304f, 
    -0.04894719f, -0.03865312f, 0.05897618f, -0.06718149f, 0.05538003f, -0.01790354f, -0.07293262f, -0.02272668f, 
    -0.01549065f, -0.02805035f, 0.07044048f, -0.08386195f, 0.01014456f, -0.08388705f, 0.04228514f, 0.05300675f, 
    0.03112580f, 0.00552252f, 0.04970063f, 0.04658605f, -0.07980567f, -0.01546657f, 0.01534010f, 0.04872437f, 
    -0.09282497f, -0.04846412f, -0.03003401f, 0.05835334f, -0.03636108f, -0.10063306f, 0.01086238f, -0.07653215f, 
    0.05280734f, 0.05998667f, 0.02430739f, 0.03124028f, -0.06785779f, -0.04142513f, -0.01462060f, -0.02921537f, 
    0.02809777f, -0.04365247f, -0.00416786f, -0.06840715f, 0.05765840f, -0.02302070f, 0.08933049f, 0.08034881f, 
    -0.04822737f, -0.03603802f, -0.01791720f, -0.02824475f, -0.09108421f, -0.02760295f, -0.02428811f, -0.07596569f, 
    0.07681347f, -0.01076313f, -0.03831474f, -0.07057288f, -0.02700119f, -0.07717554f, -0.02028773f, 0.07736783f, 
    -0.08684419f, 0.06682070f, 0.00640795f, 0.05704505f, 0.01907486f, 0.07648223f, 0.05009175f, 0.01383320f, 
    -0.09997074f, 0.01541492f, -0.05509258f, 0.07118176f, -0.08905052f, -0.09292198f, 0.00575701f, -0.06871904f, 
    0.00490155f, -0.03378571f, 0.00053475f, -0.02917063f, -0.03452258f, -0.07548765f, -0.02102263f, -0.01249707f, 
    -0.02982029f, 0.00565962f, -0.06334802f, 0.03877135f, -0.01831714f, 0.00405694f, -0.07412913f, 0.07746109f, 
    -0.04686821f, -0.08784890f, 0.03297975f, -0.08616278f, 0.06320119f, -0.08987582f, 0.04627427f, -0.06510184f, 
    0.00554666f, -0.00174340f, 0.02816999f, -0.07136505f, 0.01468689f, -0.07010502f, -0.03588372f, -0.03797504f, 
    -0.02431351f, -0.12147375f, -0.00360147f, 0.00578649f, 0.06122884f, 0.04426723f, -0.07386188f, 0.06869885f, 
    -0.16489698f, -0.16769546f, 0.10259821f, -0.06428000f, -0.00668200f, 0.04951505f, 0.07632709f, 0.14216232f, 
    -0.05939034f, 0.04983481f, -0.16648667f, 0.06311087f, -0.02376891f, -0.16536234f, 0.08648977f, -0.21946749f, 
    -0.03706459f, 0.06225466f, 0.20162910f, 0.11089443f, -0.22895196f, 0.09480224f, 0.05527817f, 0.02318038f, 
    0.04446661f, 0.05355056f, 0.02091815f, 0.50653028f, 0.16058759f, -0.08570030f, -0.05942314f, -0.29334861f, 
    -0.26286456f, -0.16658036f, 0.00335008f, 0.29092279f, 0.31755894f, 0.22801262f, 0.17339954f, -0.22460842f, 
    0.23372708f, 0.15193945f, 0.14882980f, -0.22070453f, 0.04556686f, -0.06392165f, 0.23481344f, 0.18160525f, 
    0.01616721f, 0.10635713f, 0.08663289f, 0.08742847f, 0.09782761f, -0.01748180f, -0.07474007f, 0.32905161f, 
    -0.24605317f, 0.06995232f, -0.03064595f, -0.03249502f, 0.41338453f, 0.43023610f, 0.19165893f, 0.06927831f, 
    -0.04967682f, 0.09730270f, -0.17123623f, -0.18359381f, -0.03627332f, 0.02670583f, -0.05345558f, -0.00612907f, 
    0.02511583f, 0.39919069f, 0.09385446f, -0.15583873f, -0.08468222f, 0.01185040f, 0.07231374f, 0.09626013f, 
    0.34855917f, -0.25810465f, -0.30131766f, -0.01544610f, 0.14490926f, -0.00553642f, -0.40844369f, -0.35385242f, 
    -0.27669892f, 0.19045819f, 0.16663824f, -0.11718002f, 0.06049403f, 0.03980021f, 0.15160047f, -0.07348739f, 
    -0.01368556f, -0.02381416f, -0.25233588f, -0.01950356f, 0.08046801f, 0.19544314f, -0.00093789f, -0.03402280f, 
    -0.06992291f, 0.03016648f, -0.08715573f, -0.03699857f, -0.01382418f, 0.03042155f, 0.08440062f, -0.04661880f, 
    0.01552091f, 0.10678623f, -0.13636295f, 0.08427862f, 0.18706818f, 0.20620102f, -0.03843761f, 0.13135266f, 
    0.03850084f, -0.04652089f, -0.18197741f, -0.19255872f, -0.07379054f, 0.07399549f, 0.00674137f, -0.01521311f, 
    0.15870725f, -0.36087877f, 0.15138730f, 0.18658908f, -0.11671347f, -0.03772596f, -0.24078862f, -0.07934458f, 
    -0.03785777f, -0.11131644f, -0.11673541f, -0.02061300f, -0.14625640f, 0.23404962f, -0.05879154f, 0.13352448f, 
    -0.03433441f, 0.00344814f, -0.11617130f, 0.14357257f, -0.32248542f, 0.05946614f, 0.18422951f, -0.31101599f, 
    0.02697436f, -0.06350149f, -0.33791852f, -0.32037017f, 0.05388503f, 0.04784363f, 0.00038619f, 0.27470398f, 
    0.14827450f, -0.28045598f, -0.04596468f, -0.62692523f, -0.34408092f, 0.09370335f, -0.04281560f, -0.00730730f, 
    -0.15819684f, -0.28926089f, -0.02514233f, 0.10887663f, 0.06838997f, 0.20701006f, -0.15524554f, 0.13008396f, 
    0.14326793f, 0.02517997f, 0.15636812f, -0.03048563f, 0.02601404f, -0.17040949f, 0.02382732f, -0.01122955f, 
    0.00420885f, 0.17915969f, 0.01406934f, -0.07566410f, 0.07841127f, -0.37010464f, -0.12640308f, 0.03821047f, 
    0.05566978f, 0.19469658f, -0.09251638f, 0.06017450f, -0.17048790f, -0.02061044f, 0.38666621f, 0.20247062f, 
    0.20436348f, -0.11446515f, 0.05227351f, 0.03093983f, 0.09646112f, 0.38223052f, 0.00384451f, 0.09435850f, 
    0.00107980f, -0.29638866f, -0.07086393f, -0.09486035f, -0.17227075f, 0.10478265f, 0.54402518f, -0.16667600f, 
    0.02700167f, -0.18730502f, -0.09381246f, 0.32477167f, 0.05502459f, 0.06916125f, -0.13458639f, 0.15657413f, 
    0.06310146f, 0.09802456f, -0.10402344f, -0.04882269f, 0.30417201f, -0.03777145f, 0.14599921f, 0.07505208f, 
    -0.12917092f, -0.00809220f, 0.01655859f, -0.28030208f, -0.04916712f, 0.12009773f, -0.00579782f, 0.02715551f, 
    -0.14007114f, 0.01532971f, 0.18699028f, -0.06643291f, 0.20922999f, 0.02799562f, 0.00795584f, 0.16691045f, 
    0.09157784f, -0.00248548f, 0.03840581f, 0.34157312f, 0.03107376f, -0.27415183f, -0.00572751f, 0.22310881f, 
    -0.12236947f, -0.28204998f, 0.22755298f, -0.22065060f, -0.04893698f, -0.08836368f, 0.05453419f, 0.03559589f, 
    -0.08107259f, 0.00062145f, 0.42519736f, -0.08836644f, 0.04106609f, 0.20167117f, 0.19492067f, -0.12034938f, 
    -0.08275706f, -0.02696979f, 0.78481531f, -0.14313696f, 0.04298879f, 0.00789538f, -0.12045550f, 0.02948759f, 
    0.11513269f, 0.12480866f, 0.20973723f, 0.17660996f, -0.14603078f, 0.18652336f, 0.01667978f, 0.34029374f, 
    0.25637230f, -0.04124059f, -0.14017944f, -0.21263838f, -0.03055120f, -0.02325270f, 0.14518510f, -0.02830632f, 
    -0.05514945f, 0.04922839f, 0.00651750f, 0.28788128f, -0.03944866f, 0.11358038f, -0.09062539f, 0.62961245f, 
    0.07789271f, 0.08597608f, -0.13137454f, -0.07428713f, 0.08423875f, 0.20469306f, 0.29990134f, -0.15442392f, 
    0.02147288f, 0.17446359f, 0.01775914f, 0.05338810f, 0.03580195f, -0.15230416f, 0.01575798f, -0.00036477f, 
    0.09421246f, 0.10901249f, -0.32154283f, 0.11000971f, 0.03676230f, -0.05221650f, 0.27151045f, 0.04034461f, 
    0.00592126f, 0.21320370f, 0.42690331f, 0.09553854f, 0.10384790f, -0.04000508f, 0.26183143f, -0.11467697f, 
    -0.16754946f, -0.53106308f, -0.14281313f, 0.05528229f, -0.28153947f, 0.01815943f, 0.33769777f, -0.10161166f, 
    0.02944154f, -0.05172368f, 0.30658236f, -0.12035562f, 0.01240213f, -0.03782431f, -0.17864886f, 0.19462223f, 
    0.15009329f, -0.05132951f, 0.21433614f, -0.10164096f, -0.11383709f, -0.00196977f, 0.17380434f, 0.27080575f, 
    -0.01020804f, -0.05268908f, 0.07366715f, 0.02970320f, 0.12404727f, -0.08012877f, 0.03774637f, -0.05599361f, 
    0.11120414f, 0.08846945f, 0.15692189f, -0.07282031f, -0.12395740f, 0.06868663f, 0.11184210f, 0.08626721f, 
    -0.05057083f, -0.24662220f, -0.22807810f, 0.16496010f, -0.22313356f, -0.15874040f, 0.00841506f, 0.01213358f, 
    0.09964043f, 0.45431995f, -0.01594109f, -0.28281441f, 0.03673795f, 0.10115145f, -0.05051150f, 0.19238412f, 
    -0.01887306f, 0.14211449f, -0.11514159f, 0.00869568f, 0.16490911f, -0.12338080f, 0.14296246f, -0.35398072f, 
    0.08443118f, 0.18391246f, -0.22993648f, -0.10460041f, 0.14846171f, -0.01774482f, 0.00777892f, 0.07877384f, 
    0.16449693f, 0.20538135f, -0.21370600f, 0.27400440f, -0.06730104f, -0.28507808f, -0.04542863f, -0.19945934f, 
    0.00395354f, 0.10262696f, 0.01318231f, 0.47033203f, -0.14606389f, -0.19599697f, -0.15456761f, -0.15332808f, 
    0.05561620f, -0.05289094f, -0.24012701f, -0.08396418f, 0.07568249f, -0.02118715f, -0.12008347f, 0.06162798f, 
    0.16756873f, 0.01114357f, -0.12983489f, -0.14329427f, 0.07242569f, 0.11967328f, 0.09140041f, -0.11699004f, 
    -0.28130996f, 0.06706385f, 0.09017374f, -0.24809682f, -0.57622749f, 0.09339581f, 0.07454602f, -0.03128812f, 
    0.06160054f, 0.05954637f, 0.01233340f, -0.04812272f, 0.03811871f, -0.03754728f, 0.04200685f, -0.01615271f, 
    -0.11087722f, 0.07781971f, -0.15073520f, 0.00925642f, -0.33857802f, -0.04888966f, -0.06063331f, 0.00782883f, 
    -0.29799515f, -0.02201831f, 0.11885139f, -0.08142959f, -0.24662440f, -0.28016549f, -0.13402665f, 0.04932652f, 
    -0.11345600f, -0.44787341f, -0.07326183f, -0.12506452f, -0.13281389f, 0.08823425f, -0.07849199f, 0.02002785f, 
    0.03640352f, 0.08319981f, -0.09830035f, 0.23032117f, -0.08523281f, -0.07156482f, 0.05927387f, 0.00971198f, 
    0.01376659f, -0.06524085f, -0.08843177f, -0.18613774f, 0.11755561f, -0.07380065f, -0.07912762f, 0.08711050f, 
    -0.05804808f, -0.02257115f, -0.00262754f, 0.14982338f, 0.12773350f, -0.01492839f, -0.00957442f, 0.03503175f, 
    0.06662825f, -0.13584280f, 0.12680696f, 0.14676949f, -0.53167051f, 0.32047158f, -0.07794861f, -0.25323072f, 
    0.02101925f, -0.19935435f, -0.03148826f, 0.31893152f, -0.06073236f, -0.08354349f, -0.09988523f, -0.06872721f, 
    0.07574814f, 0.04180823f, 0.01634918f, 0.02835286f, -0.19332561f, -0.00200586f, -0.16426297f, 0.05487419f, 
    -0.07140157f, 0.09504168f, -0.17813730f, 0.10625564f, -0.31251335f, 0.01414991f, 0.04873830f, -0.33649218f, 
    0.10282788f, -0.25326800f, -0.17839931f, -0.05490033f, 0.15603346f, -0.17937368f, -0.03634317f, 0.31712076f, 
    -0.11416854f, -0.48346245f, -0.00440285f, -0.24318182f, -0.04388380f, 0.08161218f, -0.15261629f, 0.01876053f, 
    0.17038102f, -0.17970531f, 0.05079060f, 0.05252963f, 0.06399797f, 0.10999659f, 0.05492078f, 0.04455562f, 
    0.17228083f, 0.23451647f, 0.42829552f, 0.28880697f, -0.08955424f, -0.00801150f, -0.06463398f, 0.17492163f, 
    0.27831113f, 0.08568701f, 0.00458273f, 0.10391558f, 0.27444631f, -0.15388967f, -0.09434082f, -0.03757204f, 
    0.00470746f, 0.13286702f, 0.01305802f, 0.16564748f, -0.17839415f, -0.03603873f, 0.18809830f, 0.09183847f, 
    -0.00242017f, -0.00429638f, -0.05189252f, -0.09503739f, 0.20324668f, 0.32392836f, 0.03309987f, -0.17949268f, 
    0.30010411f, -0.37132803f, -0.26919943f, -0.00576014f, -0.12687017f, 0.00105592f, 0.18380399f, -0.43996575f, 
    0.02831153f, -0.00024916f, 0.01092117f, 0.35130244f, 0.23258263f, 0.06401804f, -0.23506503f, 0.09598586f, 
    0.06551735f, -0.11550739f, -0.38407600f, 0.06651866f, 0.26180908f, 0.09993303f, 0.01759909f, 0.06332143f, 
    -0.05984165f, 0.09453195f, 0.01601746f, 0.21985863f, -0.38807559f, 0.13834938f, -0.01596963f, 0.07540190f, 
    -0.11108150f, -0.04220657f, 0.09528069f, -0.05940127f, 0.29836810f, 0.01405326f, -0.14721714f, -0.00473490f, 
    -0.07506886f, -0.05386495f, 0.02087504f, 0.33133388f, -0.09660312f, -0.30032688f, 0.04020638f, 0.09929658f, 
    -0.18342236f, -0.12045182f, -0.04349652f, -0.46545717f, 0.17479414f, 0.08266409f, 0.01420102f, 0.27122712f, 
    0.00390175f, 0.10964976f, 0.30703887f, 0.02059631f, 0.03375326f, 0.20975828f, 0.11895370f, 0.10126147f, 
    0.02980535f, -0.02319476f, 0.14249402f, -0.15914313f, -0.35633925f, -0.06970792f, -0.03213267f, 0.07469986f, 
    0.23324844f, -0.04890410f, -0.11066087f, 0.35065192f, -0.01064020f, -0.08349875f, 0.08439489f, 0.18004066f, 
    0.00585189f, -0.28300187f, 0.07879815f, -0.48056743f, 0.05794483f, -0.07502986f, -0.25155568f, -0.11607450f, 
    0.06374972f, 0.20851386f, -0.00253614f, -0.05968966f, -0.03318534f, -0.11830819f, 0.16865319f, 0.04471531f, 
    -0.21052429f, -0.23260716f, -0.25138149f, 0.20623069f, 0.08023629f, 0.35853332f, 0.07163363f, 0.08405837f, 
    -0.02984787f, 0.04178273f, 0.01503524f, 0.02520671f, 0.22015782f, 0.38674638f, 0.04676809f, 0.11061195f, 
    0.07266528f, 0.09245205f, -0.01943902f, -0.10158338f, -0.11433788f, -0.06222016f, 0.02307421f, -0.11931448f, 
    0.01132649f, 0.34116870f, 0.18319356f, 0.01360364f, 0.05203852f, 0.01670938f, 0.10231830f, -0.01575146f, 
    -0.29716411f, 0.28427118f, -0.34464306f, -0.01990774f, -0.14181231f, -0.00773197f, -0.26447213f, -0.39078090f, 
    -0.13882148f, 0.06389500f, 0.14258911f, -0.23125197f, 0.18333958f, 0.02536198f, 0.05868335f, -0.05618954f, 
    0.01631683f, 0.09757076f, 0.08299092f, 0.10003130f, -0.18404286f, 0.24291037f, -0.17041810f, 0.37489977f, 
    -0.15272602f, -0.02991348f, 0.06936160f, -0.09738131f, -0.06734080f, 0.04298024f, -0.03602417f, -0.05808377f, 
    0.03828031f, -0.03498166f, 0.36395064f, -0.17614280f, -0.44719383f, -0.11671975f, 0.11234450f, -0.06795082f, 
    0.08070832f, 0.01946303f, -0.03976089f, 0.24710873f, -0.04418748f, -0.19062246f, 0.06561539f, 0.18709116f, 
    0.18936361f, 0.05806019f, 0.20062163f, 0.08548988f, -0.06873115f, 0.31673494f, 0.16721223f, 0.00966903f, 
    0.01730492f, -0.00801400f, 0.03134460f, -0.05446978f, 0.16739269f, -0.25835752f, 0.19549052f, -0.31540519f, 
    0.05138096f, 0.05927434f, 0.20619285f, -0.16664477f, 0.30855384f, -0.05762969f, -0.08166917f, 0.04066790f, 
    -0.01569974f, -0.00840687f, 0.21956581f, 0.19435889f, 0.01060653f, -0.18331307f, -0.14410669f, -0.20476368f, 
    -0.21287540f, -0.15510216f, -0.01335210f, -0.04137248f, -0.08179048f, -0.04581177f, -0.40321961f, 0.08300322f, 
    -0.00666302f, -0.03389228f, -0.00484761f, 0.24094300f, 0.02000849f, 0.03320254f, -0.08404506f, 0.19889523f, 
    -0.00895871f, 0.20667472f, -0.19453372f, 0.11237657f, -0.02561529f, 0.07964391f, 0.09188136f, 0.07641954f, 
    0.04359705f, 0.02817497f, 0.16383609f, -0.11296330f, 0.17204036f, -0.28550813f, 0.09899884f, 0.05306269f, 
    -0.12711701f, -0.09406325f, 0.18135059f, 0.16774417f, 0.05423582f, -0.04386137f, -0.15378121f, 0.06548978f, 
    -0.05894009f, 0.00123611f, 0.11263815f, -0.00439447f, 0.05635330f, -0.15572815f, 0.22081167f, 0.09120737f, 
    -0.11231305f, 0.40051970f, -0.05503055f, -0.05631756f, 0.25697833f, -0.10447475f, 0.16750725f, 0.16593064f, 
    0.41893992f, 0.03228954f, 0.11287039f, 0.02064818f, 0.01332212f, 0.04197956f, 0.18409838f, -0.11223009f, 
    -0.17057088f, -0.00533844f, 0.06342252f, 0.28590038f, -0.11528112f, -0.09120302f, 0.15486555f, -0.11826280f, 
    0.18560565f, -0.03846574f, 0.10842480f, -0.06874016f, 0.05097951f, -0.11744221f, -0.04535924f, 0.10872123f, 
    0.38209057f, 0.06929702f, -0.07776655f, 0.12941512f, -0.14102033f, -0.23987198f, 0.08158730f, -0.29071125f, 
    -0.05535140f, -0.40092474f, 0.11316883f, -0.22602148f, -0.16773973f, -0.11555772f, -0.04199503f, -0.04698301f, 
    0.22495684f, -0.17839858f, 0.15711716f, 0.19678934f, 0.02359655f, -0.32376620f, 0.05663178f, 0.05733652f, 
    -0.59432977f, 0.06754080f, -0.24171300f, -0.15858305f, -0.20254642f, 0.05941527f, 0.05074336f, -0.07373560f, 
    0.05209548f, 0.07465137f, 0.08771392f, 0.04525748f, -0.40425840f, 0.08737846f, -0.07625387f, 0.02405419f, 
    -0.23815601f, -0.05612582f, -0.24743918f, -0.10889225f, 0.09686182f, 0.14529999f, -0.11440860f, -0.11733308f, 
    0.00997321f, 0.02608379f, 0.14075202f, -0.14927505f, -0.10567548f, -0.02884409f, 0.04508485f, 0.24470252f, 
    0.03389646f, -0.21397255f, 0.05151553f, -0.44785804f, 0.03831416f, -0.08406672f, 0.06915959f, 0.04673791f, 
    0.34864053f, 0.33176696f, 0.12022685f, 0.13127598f, 0.06503854f, -0.40933815f, -0.24341440f, 0.13118985f, 
    0.00086494f, 0.40015948f, -0.04802486f, 0.12631762f, -0.03034179f, 0.07072417f, -0.04772541f, -0.04853184f, 
    0.12022932f, -0.10206071f, -0.78803426f, 0.14024091f, -0.00903597f, 0.06239187f, 0.20692989f, 0.29026073f, 
    -0.06450146f, -0.22860752f, -0.42427647f, 0.17205031f, -0.02538383f, 0.22281626f, -0.05845210f, 0.41015711f, 
    0.04201198f, -0.07274253f, 0.15040082f, 0.20226933f, -0.02279786f, -0.00721717f, 0.32309252f, -0.00302529f, 
    -0.12646113f, -0.09099061f, 0.11176615f, 0.16009079f, 0.39598486f, -0.06453194f, 0.18838213f, -0.37122339f, 
    -0.17915884f, 0.08102002f, 0.00718688f, -0.07227381f, 0.06592045f, 0.10619665f, 0.12121306f, -0.15868101f, 
    0.03440759f, 0.21007319f, 0.00800796f, 0.06122060f, 0.10530715f, -0.05147498f, -0.05524128f, 0.01793979f, 
    -0.00449650f, 0.07372776f, 0.25437999f, 0.02782397f, -0.02074898f, -0.33721751f, 0.06166520f, -0.08219475f, 
    0.10369469f, 0.17293279f, 0.13713178f, 0.17792627f, -0.15647395f, 0.09993013f, 0.05477628f, 0.03283897f, 
    0.07889727f, 0.01717864f, 0.06101580f, -0.10363749f, 0.07116942f, 0.20103125f, 0.15593326f, -0.05457531f, 
    0.12179396f, 0.07015712f, -0.19432707f, 0.03282330f, 0.02387392f, -0.29425284f, 0.02848694f, 0.17689435f, 
    -0.07024967f, 0.15445893f, -0.09075013f, -0.42682061f, -0.26704794f, -0.01767503f, -0.55984855f, 0.03972133f, 
    -0.02742492f, -0.08085501f, 0.06299753f, 0.03602863f, -0.01203996f, 0.18438719f, -0.03644561f, -0.32326964f, 
    -0.37774995f, 0.13976334f, -0.45812464f, 0.15911157f, 0.01650183f, -0.50764132f, -0.24210314f, 0.08941069f, 
    -0.04546244f, 0.06874043f, -0.31882682f, -0.06181915f, 0.01815194f, -0.08477667f, -0.31485033f, -0.02341986f, 
    -0.01322010f, -0.22731163f, -0.23587190f, -0.35073671f, -0.07235889f, -0.35621598f, 0.04274617f, 0.21795134f, 
    -0.26620686f, 0.08733866f, 0.09085722f, -0.43017030f, 0.07756610f, 0.28782612f, 0.03536780f, -0.02187251f, 
    -0.04268575f, -0.08759399f, 0.30581933f, -0.05031437f, -0.12700517f, -0.08282253f, -0.18445967f, -0.06268586f, 
    -0.24820572f, 0.02854538f, 0.01138842f, 0.06898408f, -0.02183320f, -0.31030238f, 0.19401544f, 0.18109725f, 
    0.18118960f, 0.67662048f, 0.17241810f, -0.11072060f, 0.16708264f, -0.37975636f, 0.12610011f, 0.14916697f, 
    0.19784482f, 0.32776690f, -0.00681373f, -0.28982583f, 0.00271374f, 0.03293014f, 0.23462173f, -0.01359518f, 
    -0.15548483f, -0.03793904f, 0.14500275f, 0.12071508f, -0.26871264f, -0.06934062f, 0.14460362f, -0.01631516f, 
    0.17902288f, -0.13199823f, -0.04172270f, -0.31034565f, -0.13345087f, -0.26888579f, 0.05768751f, 0.07194291f, 
    0.09616973f, 0.06379172f, 0.27022815f, -0.06421021f, -0.22496289f, 0.01211145f, 0.09796438f, -0.11175151f, 
    0.01972232f, -0.25250649f, -0.01056628f, 0.30213290f, 0.06833101f, -0.47786427f, 0.02498255f, 0.31421411f, 
    0.03203900f, 0.09741991f, 0.18951710f, -0.43277609f, -0.07300643f, 0.19276521f, -0.18273234f, 0.09096271f, 
    -0.13946447f, -0.01930183f, 0.15091318f, -0.08387289f, 0.07552081f, 0.22040159f, 0.11850857f, -0.08215113f, 
    -0.04460998f, -0.08783228f, 0.38746500f, -0.10007661f, -0.28558105f, 0.07442607f, 0.08477049f, 0.14308655f, 
    0.16628601f, 0.08447713f, 0.04752099f, 0.24980707f, -0.01596344f, -0.18700990f, 0.10300634f, -0.20579104f, 
    0.16312934f, -0.22665980f, 0.05016949f, 0.19069488f, 0.05582825f, -0.00125847f, -0.07948503f, -0.01650519f, 
    -0.17857783f, 0.02920400f, -0.00215138f, 0.01192482f, 0.03726521f, -0.28755182f, 0.09946471f, 0.34140787f, 
    -0.12593266f, 0.05759479f, -0.26280010f, 0.07069980f, 0.10934521f, 0.07101209f, 0.09147064f, 0.02405473f, 
    -0.08100165f, -0.00596072f, 0.07505645f, 0.05060530f, 0.18639334f, 0.15492475f, 0.10312320f, -0.04008608f, 
    -0.00343625f, 0.02157112f, 0.05176346f, -0.00728944f, -0.18946685f, -0.08099826f, -0.15614754f, 0.11208127f, 
    0.22935663f, 0.21148677f, 0.15463768f, 0.00645161f, 0.03903630f, -0.00602380f, 0.02381108f, 0.00554398f, 
    -0.16778815f, 0.34484315f, -0.19196357f, -0.10148481f, 0.00771361f, -0.00878784f, -0.14831346f, -0.13606408f, 
    0.22812144f, -0.00094757f, 0.22986668f, -0.38285267f, 0.04139282f, -0.05912764f, 0.13099447f, -0.09342386f, 
    0.04668150f, 0.06122188f, 0.19942701f, 0.02798910f, -0.37263268f, 0.09583375f, -0.05199614f, 0.18640353f, 
    -0.12583463f, -0.02165457f, -0.10764554f, -0.14806624f, 0.14255345f, -0.32071799f, 0.04810272f, -0.16914955f, 
    0.04197138f, 0.05341039f, 0.07059105f, 0.09219848f, -0.36036634f, -0.11270630f, -0.02740431f, -0.40224808f, 
    0.06818784f, 0.22401896f, -0.20507263f, 0.04757241f, -0.25499177f, 0.25494629f, 0.08789960f, 0.04617732f, 
    0.26530358f, 0.55962479f, 0.11050717f, 0.16684271f, 0.07546204f, 0.24558300f, 0.00172461f, -0.05143435f, 
    0.11749842f, 0.03481285f, -0.26112744f, 0.03485403f, 0.24805568f, -0.15717112f, 0.15493415f, -0.24180321f, 
    0.02326824f, 0.08609327f, -0.04760906f, 0.16222350f, 0.45016068f, 0.01628257f, -0.21488221f, -0.04946413f, 
    0.15953414f, 0.18643181f, -0.07706050f, -0.27107897f, -0.06509378f, -0.29565132f, -0.09057021f, -0.32453829f, 
    0.20491491f, -0.02440663f, 0.01246629f, 0.15987748f, -0.24130712f, -0.13249914f, -0.30416164f, 0.17045169f, 
    -0.05699126f, -0.02016082f, -0.11668649f, 0.11276321f, 0.01907004f, 0.14015928f, -0.21608207f, 0.05689532f, 
    0.24230802f, 0.12848818f, 0.09075040f, -0.26903766f, -0.20737413f, -0.23197708f, 0.04564776f, -0.01505279f, 
    -0.12044212f, 0.07211789f, 0.35908845f, -0.22414705f, -0.53146058f, -0.20553045f, -0.09501097f, -0.05797329f, 
    0.05292058f, 0.04174741f, 0.22560884f, 0.22705761f, -0.40421236f, 0.04778969f, 0.10025762f, 0.06523066f, 
    0.00057577f, -0.20486683f, -0.04733168f, 0.12643957f, -0.18894272f, -0.03704575f, 0.00923588f, 0.04247616f, 
    -0.17659089f, -0.15948677f, 0.15431608f, -0.27924153f, -0.00832413f, -0.13541012f, 0.32797483f, 0.15385593f, 
    0.39400071f, -0.10005511f, -0.05250870f, 0.20086458f, -0.00589182f, 0.01214955f, -0.28295505f, 0.11517405f, 
    0.11702703f, -0.05969530f, -0.20411314f, 0.11977132f, 0.02743990f, -0.16901271f, 0.05086569f, -0.06145856f, 
    0.16743310f, -0.20874915f, -0.06547077f, 0.05858543f, -0.03868989f, -0.34283653f, -0.00909738f, 0.26447907f, 
    0.21414430f, 0.00154499f, 0.25178251f, 0.18099870f, 0.14086771f, 0.09174278f, 0.07085655f, -0.04824325f, 
    0.05321568f, 0.10093739f, -0.24459316f, 0.14052638f, -0.01788932f, 0.41316235f, -0.07692600f, -0.04190159f, 
    0.01523944f, -0.17825694f, 0.05451040f, -0.01320896f, -0.30599210f, -0.14232074f, -0.30939862f, 0.21986648f, 
    0.06378607f, 0.08844120f, -0.01480561f, 0.01794057f, 0.04923140f, 0.02045023f, 0.01012916f, -0.10747766f, 
    -0.04097461f, 0.06989291f, -0.12822695f, 0.09150893f, 0.06805220f, 0.09931824f, -0.03808055f, -0.19672716f, 
    0.15762071f, -0.10472908f, -0.30098036f, -0.16114306f, 0.13824254f, -0.14497359f, 0.09029237f, 0.10482501f, 
    -0.59150326f, -0.43113482f, -0.04525986f, -0.22282749f, -0.39941347f, -0.11540776f, 0.21305153f, -0.07051516f, 
    0.03241474f, -0.17774719f, -0.04337256f, 0.19630004f, -0.03983872f, 0.31370980f, -0.12749426f, -0.03877807f, 
    0.20614956f, 0.03790436f, 0.12185264f, 0.28491876f, -0.00454677f, -0.08565278f, 0.09305895f, 0.00889092f, 
    0.28765285f, 0.19856575f, 0.23233867f, -0.00408420f, -0.24335913f, -0.11031056f, -0.07326218f, -0.06300417f, 
    0.00788742f, 0.20442471f, -0.08022228f, -0.01430400f, -0.45296684f, 0.08145249f, 0.21348432f, -0.05683962f, 
    -0.00905250f, 0.03385299f, 0.19729631f, -0.05990562f, -0.03382440f, 0.11566743f, 0.08191339f, 0.06962035f, 
    -0.16797954f, -0.44929636f, -0.42060885f, -0.05346464f, -0.13571976f, -0.08544029f, 0.51761395f, 0.38637564f, 
    0.05505903f, -0.21074030f, 0.05278601f, 0.20122772f, 0.11174855f, 0.05038037f, -0.33653343f, 0.25883257f, 
    0.09514291f, -0.03682786f, -0.33590293f, 0.14511788f, 0.14184009f, -0.01288114f, -0.07608851f, 0.10469557f, 
    -0.11271144f, -0.22108310f, 0.07058092f, -0.22857925f, -0.19817726f, -0.12186898f, 0.05093015f, 0.16579983f, 
    -0.15896538f, -0.04228074f, -0.04698783f, 0.06271916f, 0.33594915f, 0.14218184f, 0.21742032f, -0.01574340f, 
    -0.03081520f, -0.03009915f, 0.06810078f, 0.01790207f, 0.00458993f, 0.04787496f, -0.00627222f, -0.05654702f, 
    -0.05173022f, -0.00169266f, -0.00916131f, -0.07007375f, 0.01462003f, -0.03194854f, -0.07143021f, 0.04031941f, 
    -0.05280437f, -0.01427398f, 0.00502549f, 0.06526588f, -0.03510449f, -0.07624996f, 0.08412046f, 0.03058185f, 
    -0.04706953f, -0.06433458f, 0.06481175f, -0.07198148f, 0.05987303f, -0.04148775f, 0.01331838f, -0.02116315f, 
    -0.03298946f, -0.03828946f, -0.01910138f, -0.03520112f, -0.06101842f, -0.05780274f, 0.00960931f, -0.02855655f, 
    -0.03822536f, -0.04515978f, -0.07511074f, -0.08394931f, 0.05509376f, -0.03725480f, 0.03825782f, 0.01685646f, 
    -0.00801196f, -0.06538468f, -0.04437371f, 0.00147209f, 0.01311832f, 0.05237997f, -0.03931816f, -0.01320497f, 
    -0.06989949f, 0.02582622f, -0.05283931f, -0.04087152f, -0.00388428f, -0.06882010f, 0.06176532f, -0.08040591f, 
    0.07203142f, 0.07354499f, 0.07548582f, -0.08496509f, -0.09937619f, 0.04068276f, -0.05887533f, -0.03091941f, 
    -0.07626553f, 0.06895167f, -0.02903823f, -0.00433802f, 0.06374162f, -0.05588930f, -0.02836286f, -0.03727574f, 
    0.06804270f, -0.00718160f, -0.10582712f, -0.00299133f, -0.05280008f, -0.01715411f, -0.04380707f, 0.03595816f, 
    0.03352166f, 0.07487999f, -0.05356094f, 0.00686864f, -0.01972305f, 0.06272846f, -0.07551128f, -0.07788687f, 
    -0.01737703f, 0.03572362f, 0.01527057f, 0.07181789f, 0.05390935f, 0.07993706f, 0.06762750f, 0.07401681f, 
    -0.04545353f, -0.06988776f, -0.02026554f, 0.01389251f, -0.05493772f, 0.05080151f, 0.00485359f, 0.01637677f, 
    -0.10742970f, 0.05071481f, 0.00964103f, -0.02106950f, 0.00127673f, 0.01272080f, 0.00876748f, 0.06744511f, 
    0.02479292f, 0.00780293f, -0.06059621f, -0.01070823f, -0.06274497f, -0.08380974f, -0.06541370f, -0.03596990f, 
    0.01447620f, 0.34005263f, -0.11955824f, -0.17527688f, -0.53000593f, 0.11855656f, -0.05559400f, -0.09738177f, 
    0.17204849f, 0.33663839f, 0.22795351f, 0.12056153f, -0.14715661f, 0.03160993f, 0.03171280f, -0.14025249f, 
    0.08134040f, 0.01505518f, -0.22911488f, 0.12679206f, 0.21993725f, -0.27478799f, 0.08158419f, -0.14991377f, 
    -0.02222241f, 0.08890162f, -0.63310963f, 0.09935233f, 0.18497677f, 0.26941001f, 0.01401671f, -0.15792248f, 
    0.04062464f, 0.23265907f, 0.09035671f, -0.29696831f, 0.06874850f, -0.02132822f, -0.04702658f, -0.27533057f, 
    0.43337318f, -0.03650873f, -0.10340530f, 0.12114669f, 0.06571340f, 0.07460225f, 0.56714785f, 0.05020788f, 
    -0.01015760f, -0.02668912f, -0.04889969f, 0.17680699f, -0.04180634f, 0.20671792f, -0.18731219f, -0.12931941f, 
    0.23088278f, 0.17529169f, 0.07120053f, -0.14164667f, -0.09471959f, -0.36928415f, -0.07118027f, -0.03743185f, 
    -0.15671666f, 0.17115736f, 0.19072445f, -0.07122414f, -0.12408695f, -0.09613110f, -0.09920051f, -0.04149069f, 
    -0.06345335f, 0.07312775f, 0.19355883f, 0.00795648f, -0.01524607f, -0.07714850f, 0.04243871f, 0.22141315f, 
    0.05047575f, -0.35707232f, -0.20022200f, 0.00625699f, -0.20608154f, 0.04368148f, 0.05355218f, 0.00399476f, 
    0.10552794f, -0.18536329f, 0.12909430f, -0.36042970f, 0.03195088f, -0.06450038f, 0.00653433f, 0.55958736f, 
    0.23229833f, -0.15570493f, -0.05731281f, 0.07401685f, -0.12336592f, 0.00629514f, -0.07365663f, -0.05954870f, 
    0.11669476f, 0.06686972f, -0.15585370f, 0.04874444f, 0.08709635f, -0.20965183f, 0.23316501f, -0.12738557f, 
    -0.02784664f, -0.10641125f, -0.02801347f, -0.18339449f, 0.01572454f, -0.30083242f, 0.05235025f, 0.19931117f, 
    0.21452717f, 0.01633844f, -0.12787543f, 0.22059891f, 0.20814538f, 0.17910206f, 0.06467237f, 0.03995090f, 
    0.03438238f, -0.33482620f, 0.11939099f, 0.38796422f, -0.06325802f, -0.21179095f, 0.07098506f, 0.09975741f, 
    -0.07576670f, 0.21328248f, 0.04238364f, -0.17917822f, 0.07063087f, 0.22545023f, 0.06887022f, 0.05576404f, 
    0.08787549f, 0.24738893f, 0.45738527f, 0.00897309f, -0.00117632f, 0.06876308f, -0.04165030f, -0.19820327f, 
    -0.06871144f, -0.04887920f, 0.15718377f, -0.33838519f, 0.14987351f, -0.17399703f, -0.14161712f, 0.07625478f, 
    0.00798151f, 0.05426184f, 0.11759245f, 0.49897835f, 0.01821127f, -0.00268024f, 0.09361781f, 0.36710694f, 
    0.29456308f, -0.03210941f, -0.09358770f, -0.08823732f, 0.30541092f, -0.06518973f, -0.30226377f, -0.08786384f, 
    0.06316705f, 0.10827545f, 0.06368185f, -0.06554718f, -0.02649544f, -0.20686717f, 0.17099631f, 0.16955815f, 
    -0.17242931f, 0.06336290f, -0.11826774f, 0.18255159f, 0.09114189f, 0.30857304f, -0.02639261f, 0.02412480f, 
    0.40072599f, 0.05770969f, 0.16065431f, 0.04286270f, 0.21212201f, 0.09611230f, -0.00200438f, -0.06225261f, 
    0.04808269f, -0.14968835f, 0.04095337f, 0.25056943f, 0.05631649f, -0.01206600f, -0.17597079f, -0.20218812f, 
    0.02609906f, 0.27756584f, 0.15038387f, 0.05187073f, 0.15204805f, -0.02053562f, 0.23730642f, -0.05610972f, 
    0.10112564f, 0.47046611f, -0.14144798f, -0.16811976f, -0.38902313f, 0.09098376f, -0.10599142f, 0.16418923f, 
    0.15376276f, 0.05319568f, 0.05719619f, -0.24187541f, 0.11086690f, 0.06786482f, -0.09543863f, -0.32522660f, 
    0.00612804f, -0.09456546f, 0.00610032f, 0.17816392f, -0.45054901f, 0.15010263f, -0.27401882f, 0.08866386f, 
    -0.03171518f, 0.02774015f, 0.05915692f, 0.24237478f, -0.10446858f, 0.10734966f, 0.06016885f, -0.09400216f, 
    0.05207059f, 0.04381530f, 0.16336495f, 0.01715543f, -0.43323734f, -0.06927297f, 0.12347529f, -0.01037493f, 
    0.03293745f, -0.16718163f, -0.01762516f, -0.14471352f, -0.34878361f, -0.48660827f, 0.06995075f, -0.06828190f, 
    0.00883092f, 0.00281383f, 0.02837299f, 0.06487563f, -0.11714048f, -0.26341510f, 0.02002797f, -0.04278230f, 
    -0.35688913f, -0.05007785f, 0.12573877f, -0.05091168f, 0.02248546f, 0.08211718f, -0.03491194f, -0.21831881f, 
    0.00136831f, 0.16138907f, -0.26071686f, 0.07784662f, 0.18783994f, 0.12959810f, 0.16855457f, 0.11332302f, 
    -0.13465610f, 0.16063525f, 0.22258250f, -0.05433588f, -0.24319497f, -0.03890954f, -0.05370576f, 0.07400257f, 
    0.35805207f, -0.22845255f, 0.04658806f, 0.63812208f, 0.15285809f, 0.15497054f, 0.11970598f, 0.03235320f, 
    0.03854673f, -0.01147941f, -0.01956774f, 0.06618369f, 0.03032952f, -0.30631939f, 0.09532388f, -0.04554667f, 
    -0.32758465f, 0.27055565f, -0.28852451f, -0.27794710f, 0.08092805f, -0.01114144f, -0.05876227f, 0.01160591f, 
    -0.09924667f, -0.12926249f, -0.08175125f, 0.07423127f, 0.23615564f, -0.07008471f, -0.22997947f, 0.02487873f, 
    0.02144975f, -0.20616852f, -0.20527023f, 0.24219725f, -0.02755234f, 0.05008463f, 0.03241582f, 0.01588556f, 
    0.03970686f, -0.10606203f, 0.01703439f, -0.10765383f, 0.05393361f, -0.21844426f, 0.02742829f, -0.13507417f, 
    0.11740411f, -0.44086617f, -0.22359425f, -0.13745677f, 0.30628946f, 0.16087860f, 0.05495932f, 0.16607620f, 
    0.06140630f, -0.02926765f, -0.20916200f, -0.08456898f, 0.05382795f, -0.05510272f, 0.20657592f, -0.17481072f, 
    -0.05418622f, 0.07898264f, 0.12273458f, -0.11369817f, -0.14251035f, 0.10069186f, 0.23692845f, 0.02338327f, 
    -0.08048536f, 0.03786018f, -0.03875380f, 0.00810980f, 0.06373353f, 0.34038958f, -0.06040455f, -0.03760564f, 
    0.19580030f, 0.01816226f, 0.23038204f, 0.04848228f, 0.02546441f, 0.10027885f, -0.22843581f, 0.00452118f, 
    0.12362475f, 0.49585274f, -0.01866362f, 0.17802857f, -0.53629768f, 0.23637576f, -0.02557640f, -0.29932478f, 
    -0.18104017f, 0.17342427f, -0.10971662f, 0.21767457f, 0.05478330f, 0.11046027f, 0.00229798f, -0.00986976f, 
    0.41479951f, -0.10315779f, -0.19519028f, 0.21039437f, 0.09509093f, 0.07576606f, 0.01639064f, 0.22831748f, 
    0.07496211f, 0.18589191f, -0.48593616f, 0.02585283f, 0.11912400f, 0.01418812f, -0.07470353f, -0.18796904f, 
    0.01093914f, 0.06915160f, 0.20426965f, 0.00159276f, 0.11324512f, -0.07297776f, -0.12265690f, -0.00790953f, 
    -0.46073583f, 0.05705621f, -0.14658530f, 0.29734468f, 0.34146574f, -0.07733975f, 0.32019132f, -0.08422615f, 
    -0.09674435f, 0.17266506f, -0.08247041f, 0.07898695f, 0.08091448f, 0.21167214f, -0.21514036f, -0.34705916f, 
    -0.04781773f, -0.02494665f, 0.14830682f, -0.25347009f, -0.00336226f, 0.07740665f, -0.09362745f, 0.07306404f, 
    -0.03046272f, -0.04112663f, 0.19301206f, -0.19309410f, -0.06585354f, 0.14214811f, -0.02777872f, 0.00579065f, 
    -0.06228484f, 0.04405108f, 0.39718649f, -0.07502326f, 0.05786109f, -0.06406383f, 0.02361896f, -0.19508114f, 
    -0.18927120f, 0.07905465f, 0.04771296f, -0.10906265f, -0.03133353f, -0.27057177f, 0.08355583f, -0.21584624f, 
    0.16249159f, -0.02876906f, -0.14906360f, -0.51141894f, 0.07021105f, 0.03147090f, -0.29167378f, -0.38357788f, 
    -0.06538024f, 0.30443752f, -0.33250353f, 0.00581762f, 0.11099520f, 0.01763866f, -0.15769081f, 0.18205656f, 
    0.11034075f, -0.07714000f, -0.06941495f, 0.10962850f, 0.20388766f, -0.00109492f, 0.08293047f, 0.03331357f, 
    0.07004834f, -0.43938079f, -0.01669801f, -0.01892465f, -0.22551160f, 0.08629376f, -0.05252064f, 0.11639252f, 
    0.21527512f, -0.07222021f, 0.00363833f, 0.03573622f, 0.12947051f, 0.22938330f, 0.13280140f, 0.08486988f, 
    -0.07086802f, -0.07598554f, -0.07357641f, -0.02157866f, -0.08036926f, -0.09034085f, -0.00219393f, -0.07280260f, 
    -0.02372349f, 0.10120783f, 0.07699793f, -0.08008512f, -0.06580482f, -0.05802446f, 0.03570782f, 0.02796871f, 
    -0.04406302f, -0.04279525f, 0.02001801f, 0.03827165f, -0.10061396f, 0.04588843f, -0.01650034f, -0.04413553f, 
    -0.07180031f, 0.02920793f, 0.06017979f, -0.09152820f, 0.02463399f, -0.02332407f, 0.05527417f, 0.04237973f, 
    -0.07059100f, -0.04197290f, -0.01634421f, -0.05197771f, 0.00083569f, 0.01635224f, -0.04894697f, 0.06851064f, 
    -0.02423975f, 0.04249221f, 0.06084388f, -0.05356335f, -0.09349778f, 0.03292465f, 0.05255926f, -0.12266010f, 
    -0.05234341f, -0.07039872f, 0.03175053f, -0.06099318f, -0.05526836f, -0.01228817f, -0.09438062f, -0.01553168f, 
    -0.08396589f, 0.07443508f, -0.05843130f, -0.05583244f, 0.06992029f, -0.08410814f, -0.04944943f, 0.05012035f, 
    0.03371538f, -0.05259334f, -0.07561693f, 0.05343193f, -0.04997600f, 0.07388240f, -0.02411409f, -0.00549179f, 
    0.01120234f, 0.06020177f, 0.00157815f, 0.02830818f, -0.04980366f, -0.06684775f, -0.07623864f, -0.06308829f, 
    -0.03644414f, -0.06581197f, -0.05221381f, 0.03521899f, -0.07187980f, -0.07060443f, -0.01391256f, 0.03737928f, 
    -0.00433720f, 0.04053738f, -0.10043296f, -0.07472802f, -0.05866348f, 0.06381948f, -0.06575917f, -0.06769063f, 
    0.03381350f, 0.02318413f, -0.02934235f, -0.00601794f, 0.06918352f, 0.06219916f, -0.09153254f, -0.01163518f, 
    0.06083323f, -0.10167575f, 0.02068534f, -0.06656155f, 0.00465678f, -0.07338446f, -0.10057396f, -0.02877217f, 
    -0.06101386f, -0.03507783f, 0.08226932f, 0.02462696f, -0.08673921f, -0.08252189f, 0.06069348f, -0.10451217f, 
    -0.02100501f, -0.03112623f, -0.00633829f, 0.01992252f, -0.02987122f, -0.06673905f, -0.03305526f, -0.03685060f, 
    0.06388313f, -0.02053607f, -0.06092879f, 0.09725209f, -0.03177452f, 0.04036975f, -0.06724626f, -0.08376557f, 
    0.02909005f, -0.00557834f, -0.08210776f, -0.05620769f, -0.01127022f, -0.02104871f, 0.01632799f, -0.02731811f, 
    -0.06137355f, -0.04008018f, 0.04225697f, -0.06677900f, 0.05544924f, 0.04394122f, -0.02235395f, -0.11208046f, 
    -0.02522052f, -0.10307154f, -0.01013437f, -0.11376222f, 0.04674644f, -0.08773009f, -0.10895883f, -0.05562823f, 
    -0.08837491f, -0.04250101f, -0.01557324f, 0.05640674f, -0.05953634f, -0.01176021f, 0.05637450f, -0.03077685f, 
    0.09471770f, -0.04038508f, -0.03011654f, 0.02717532f, -0.04749221f, -0.01137159f, 0.10412978f, 0.00157149f, 
    -0.05468523f, 0.01670404f, -0.00792956f, -0.05595909f, 0.02994973f, -0.07411610f, -0.08478801f, 0.01167606f, 
    0.05318027f, 0.02206350f, -0.12818119f, -0.10564741f, -0.06785046f, -0.07698774f, 0.02440274f, 0.01380301f, 
    -0.06702064f, -0.00571204f, 0.05979149f, 0.02777964f, -0.06741372f, 0.01506989f, 0.03263663f, 0.07443216f, 
    0.00579758f, -0.03000009f, 0.10906873f, -0.00295777f, -0.03368256f, -0.04382568f, 0.04271401f, -0.09305716f, 
    0.03905051f, -0.06906369f, 0.06535560f, -0.05184976f, -0.07002263f, 0.00629477f, -0.01208513f, 0.03107017f, 
    0.03362220f, 0.09365276f, -0.10802072f, 0.05121022f, -0.01598829f, -0.09983937f, 0.06483516f, -0.05063153f, 
    -0.10535221f, -0.05715503f, 0.04924395f, 0.03160667f, 0.03982845f, 0.00306345f, -0.01200971f, 0.00961182f, 
    -0.07786699f, -0.11412115f, -0.01736566f, 0.03084548f, -0.11344038f, -0.05189374f, 0.01984838f, 0.05731085f, 
    0.00268099f, -0.08503171f, 0.05407460f, 0.06003581f, -0.03559065f, 0.00799056f, -0.02789426f, -0.05446516f, 
    -0.10683930f, -0.04080878f, -0.03613590f, -0.07234140f, 0.03911176f, 0.04545521f, 0.06966065f, -0.03477081f, 
    0.08221693f, 0.06191510f, -0.07007376f, 0.03259368f, 0.36164650f, 0.16111296f, -0.00468745f, 0.24947512f, 
    0.25691348f, -0.05141361f, 0.05679656f, 0.17697161f, 0.11642619f, -0.01140438f, -0.00086648f, 0.05412289f, 
    0.09238135f, 0.04192274f, -0.10898115f, -0.14441201f, 0.12321120f, -0.11421984f, -0.06884924f, 0.23503426f, 
    0.03845372f, -0.07200033f, -0.01315647f, 0.07786281f, 0.32779765f, -0.19341458f, -0.11639971f, 0.07860296f, 
    0.01342743f, -0.10642228f, -0.12289976f, -0.18831241f, -0.07753923f, -0.15175214f, -0.17251112f, -0.24486607f, 
    0.01073239f, 0.17206445f, 0.12268350f, -0.31965768f, -0.09504469f, 0.11079624f, -0.39140114f, 0.20792808f, 
    -0.03126182f, 0.06058026f, -0.09083635f, 0.07510250f, -0.05096004f, -0.11709601f, 0.01929171f, -0.24097604f, 
    0.16698495f, 0.13075453f, -0.03390583f, -0.24085219f, 0.16904987f, 0.01233378f, -0.02868466f, 0.16296488f, 
    0.12399135f, 0.05987883f, 0.08803692f, -0.02572612f, -0.11844894f, -0.15856588f, -0.06134552f, 0.04833851f, 
    -0.02605057f, -0.12114582f, 0.13407315f, 0.21855165f, -0.02270130f, 0.07431377f, 0.08930805f, 0.10401317f, 
    0.05899986f, -0.05880354f, -0.00779079f, 0.13780898f, -0.15361933f, 0.05097944f, -0.09013086f, 0.07154300f, 
    -0.17649445f, 0.44158760f, 0.11980399f, 0.03788385f, 0.13273233f, 0.01665796f, 0.63244110f, 0.08041463f, 
    0.44266841f, -0.06779774f, -0.36333612f, -0.05384181f, -0.18052682f, -0.05710107f, 0.07205775f, 0.25933078f, 
    -0.11634841f, -0.03538967f, 0.05598423f, 0.01504287f, 0.03672890f, -0.02978245f, 0.04410700f, -0.12014282f, 
    0.14120041f, -0.04263808f, -0.01257016f, -0.03891592f, 0.21707165f, 0.07494747f, 0.05119160f, 0.12867182f, 
    0.10567728f, -0.05169820f, -0.23675917f, 0.20787136f, -0.02762572f, -0.28229254f, -0.10786934f, -0.16307507f, 
    0.13301125f, 0.10784543f, -0.13380514f, -0.06406686f, -0.37610310f, 0.13579881f, -0.05892339f, 0.05688320f, 
    0.26056597f, 0.44497824f, 0.05673094f, 0.17034689f, -0.20545703f, 0.15734711f, -0.20234708f, -0.06146080f, 
    -0.01551327f, 0.02859861f, -0.20333529f, -0.02868309f, 0.15722346f, -0.15700541f, 0.05994155f, -0.23673820f, 
    -0.07241071f, 0.04503074f, 0.21344611f, 0.11034628f, -0.13337155f, -0.00792501f, 0.04421253f, -0.09498981f, 
    0.02758945f, 0.16236985f, -0.00978833f, -0.32541525f, -0.08145154f, -0.53289557f, -0.20934840f, -0.49580497f, 
    0.23117088f, -0.34036094f, -0.05104353f, 0.20174146f, -0.27293825f, 0.01984357f, -0.12783846f, -0.01940268f, 
    -0.20122971f, -0.29835799f, -0.15038311f, 0.09699235f, 0.05326024f, 0.23052941f, -0.13703850f, 0.00385165f, 
    0.24046487f, 0.07083367f, -0.07436474f, -0.22231056f, -0.26402736f, -0.33471236f, 0.04122381f, 0.19072857f, 
    -0.14617985f, 0.19685963f, 0.20780544f, -0.16129999f, -0.12860499f, -0.18965726f, -0.06472126f, 0.00940537f, 
    -0.10627521f, 0.14044054f, 0.18352179f, 0.16908240f, -0.51835817f, -0.07616939f, 0.05612263f, 0.17993262f, 
    0.07084197f, -0.39622003f, -0.22425255f, -0.10462055f, -0.15078428f, 0.07121756f, -0.14555007f, 0.09701382f, 
    -0.00258134f, 0.12962338f, -0.03644890f, -0.26890227f, -0.01848556f, -0.06799794f, 0.44762236f, 0.24534534f, 
    0.32081735f, -0.28800601f, -0.04367877f, 0.07767088f, -0.02436164f, -0.09708603f, -0.22028646f, 0.01227673f, 
    0.16236041f, 0.12566654f, -0.35167333f, 0.03476902f, 0.11809208f, -0.20371237f, 0.18064921f, -0.21557903f, 
    0.12381144f, -0.13676068f, 0.08748765f, -0.25643012f, 0.14895780f, -0.40722609f, -0.08600522f, 0.19627799f, 
    0.14897342f, -0.08346040f, 0.24668832f, 0.32729816f, 0.23339622f, 0.06943464f, -0.09584172f, -0.04537911f, 
    0.06212859f, 0.15292491f, 0.00641547f, -0.32640317f, -0.31903213f, -0.06446855f, 0.01624034f, -0.16648810f, 
    0.16241239f, -0.28224495f, -0.06105396f, 0.31284630f, -0.10240220f, -0.06738767f, -0.03851123f, -0.03377974f, 
    0.02763970f, -0.16838098f, -0.04319335f, -0.06713151f, 0.01329591f, 0.11594001f, -0.01062342f, -0.09794885f, 
    0.05812914f, 0.12822592f, -0.03036794f, 0.13889846f, 0.10183938f, -0.12832370f, 0.19111082f, -0.19694389f, 
    0.03476566f, 0.00564514f, 0.04047289f, -0.10866860f, 0.04805956f, 0.02373493f, -0.34931335f, 0.09983812f, 
    -0.15428312f, -0.03356206f, -0.06494138f, -0.23845778f, 0.05446239f, 0.21141718f, 0.76758188f, -0.09187365f, 
    0.03524038f, 0.01122927f, 0.06231673f, 0.02547746f, 0.04150822f, 0.20790797f, -0.26988998f, -0.07407437f, 
    0.29396924f, 0.39938474f, 0.11344637f, 0.00027878f, -0.03122136f, -0.27673766f, 0.05882505f, 0.30365005f, 
    -0.04047236f, 0.23987894f, 0.00555013f, 0.06613890f, 0.29279384f, 0.34191275f, 0.01363737f, 0.01137616f, 
    -0.27107990f, 0.05153721f, 0.02929467f, 0.32602951f, -0.02634130f, -0.04063225f, 0.26066464f, 0.12089382f, 
    0.00093954f, 0.06587920f, -0.11677909f, -0.17691889f, 0.00371007f, 0.03661996f, 0.06042156f, -0.03623518f, 
    0.18303643f, -0.39805844f, -0.35485306f, -0.08436524f, 0.11695272f, 0.09997786f, 0.57420921f, -0.08032238f, 
    -0.13003707f, -0.23107174f, -0.03294192f, 0.22517568f, 0.30105349f, 0.05022364f, -0.28322953f, 0.08985503f, 
    0.03484610f, -0.13085276f, -0.22743061f, -0.11064687f, 0.11379287f, -0.08608063f, 0.21297540f, 0.09861322f, 
    0.08528599f, -0.08208846f, 0.00917767f, -0.18426195f, 0.07273141f, -0.60717624f, 0.06085321f, -0.08027425f, 
    0.18397322f, -0.02472740f, -0.49748489f, 0.25321957f, 0.38183236f, 0.15627109f, 0.07978670f, -0.03329438f, 
    0.04416991f, -0.01848651f, 0.06268502f, 0.01025683f, -0.19117555f, -0.15265502f, -0.07104971f, 0.07487725f, 
    0.06331305f, 0.23820986f, -0.00492561f, 0.24131738f, 0.04853746f, -0.14401503f, -0.07523485f, -0.08581402f, 
    -0.28764397f, 0.12372760f, 0.06884310f, -0.00883177f, -0.05873691f, 0.07428765f, -0.04776553f, -0.16679400f, 
    0.02920159f, 0.12773646f, -0.09088683f, 0.14694358f, -0.16318507f, 0.11357911f, 0.12334099f, 0.08639324f, 
    -0.04586164f, 0.13420217f, 0.27915999f, -0.36048850f, -0.09498344f, -0.08625731f, -0.07764748f, -0.05687449f, 
    0.05580414f, -0.22842056f, 0.21467823f, 0.26263759f, 0.31217292f, 0.14163148f, -0.05766736f, 0.09381801f, 
    0.09471028f, -0.01958031f, 0.17897117f, 0.02153552f, -0.00186055f, -0.20117770f, 0.18201753f, -0.05405090f, 
    -0.27549380f, 0.18982740f, 0.02844904f, -0.20797528f, 0.00481240f, -0.25254086f, -0.12364607f, 0.12450488f, 
    -0.19235016f, -0.15660235f, -0.09550712f, 0.11639407f, 0.40637890f, 0.09777311f, 0.01359694f, 0.12534541f, 
    0.14905339f, -0.25196549f, -0.09007356f, 0.28760186f, 0.01875676f, -0.01532581f, -0.12853126f, 0.07778271f, 
    0.03851751f, -0.31513476f, -0.10511351f, 0.00210543f, -0.01448018f, -0.21371903f, -0.01714273f, -0.06049272f, 
    0.13140303f, -0.31827378f, -0.06988153f, 0.04744692f, 0.40094694f, 0.22817262f, 0.02456680f, 0.11275028f, 
    0.15881094f, 0.18855202f, -0.23292853f, 0.08496335f, 0.07635611f, 0.06093777f, 0.40858728f, -0.14360122f, 
    -0.08553983f, 0.13032077f, -0.06769327f, -0.22485363f, -0.04576875f, 0.07700349f, 0.05601090f, -0.11880328f, 
    0.03054629f, 0.11485699f, 0.07229247f, 0.10316160f, 0.10459061f, 0.08593069f, 0.06284688f, -0.01009178f, 
    -0.01955037f, 0.11361568f, 0.21796282f, 0.12568574f, -0.00404584f, 0.02305678f, -0.15060574f, 0.04955430f, 
    -0.01878776f, -0.07305951f, -0.09653021f, 0.00871883f, 0.31379575f, -0.14241441f, -0.07537769f, 0.20418137f, 
    0.17247342f, 0.06162460f, 0.10713627f, -0.08605421f, 0.17303570f, 0.17514119f, 0.07262205f, 0.29002681f, 
    -0.05192740f, 0.14980122f, -0.19554347f, -0.14848530f, 0.26611298f, -0.19672996f, 0.01608998f, -0.11430456f, 
    -0.02765409f, 0.01035899f, 0.33538926f, -0.03646200f, 0.42751205f, -0.09118004f, 0.02095183f, 0.22899827f, 
    -0.07011630f, 0.10413843f, 0.11095909f, 0.18749082f, -0.06345981f, -0.20039667f, -0.23295133f, -0.34265241f, 
    0.01734820f, -0.04839518f, 0.05357909f, -0.24475637f, -0.08828009f, 0.16640757f, -0.26024321f, 0.21232334f, 
    0.06493144f, -0.02110910f, 0.01297244f, -0.07449082f, -0.04980914f, -0.38279983f, -0.02216882f, -0.07016858f, 
    -0.02639276f, 0.13914280f, -0.14585790f, -0.41950038f, 0.13505325f, -0.04302529f, 0.09150297f, 0.20443636f, 
    -0.13332388f, 0.09193453f, -0.15411131f, -0.01565376f, 0.12220944f, -0.08626457f, -0.01349944f, 0.00724817f, 
    -0.10325005f, -0.17795862f, 0.03704596f, 0.07264403f, -0.00143558f, 0.04713041f, -0.08424468f, 0.08440260f, 
    0.08038381f, 0.00185227f, -0.03453285f, 0.08906680f, -0.08144206f, 0.06790607f, -0.00377006f, 0.21270686f, 
    -0.18980934f, 0.34629753f, 0.02244014f, 0.02550757f, 0.30843940f, -0.08512977f, 0.42392588f, 0.04100462f, 
    0.32104272f, -0.08927196f, -0.20498444f, -0.22694457f, -0.19317009f, 0.02877190f, 0.07653290f, -0.11198739f, 
    -0.14682025f, 0.02835781f, 0.01872026f, 0.14043087f, -0.04436032f, 0.00860165f, 0.09553230f, -0.07152329f, 
    0.13252737f, 0.07522248f, -0.07502837f, -0.02716298f, 0.29764512f, 0.10350224f, -0.03807608f, 0.00833992f, 
    0.02557272f, 0.04198755f, -0.35676077f, 0.20223947f, -0.14265074f, -0.23857771f, -0.10719559f, -0.09786916f, 
    0.13649520f, 0.13224334f, 0.04776247f, -0.06989533f, -0.18038471f, -0.27386603f, 0.04586799f, 0.04371431f, 
    0.00117236f, -0.15880330f, 0.12129652f, 0.23938195f, -0.06930391f, 0.07502136f, 0.13011478f, 0.00342479f, 
    0.03092040f, 0.09488335f, 0.26629001f, -0.05676596f, 0.16343951f, -0.07139035f, 0.01468350f, -0.36091089f, 
    0.01899844f, -0.11310481f, 0.13372707f, -0.01420034f, 0.17775658f, -0.12034411f, -0.12755732f, -0.00622057f, 
    -0.09320813f, 0.03333230f, 0.05432032f, -0.12947345f, 0.04638857f, -0.09820884f, -0.22625309f, 0.15311050f, 
    -0.16895464f, -0.19194897f, -0.08910001f, -0.31602338f, 0.07633314f, -0.07292098f, 0.28243327f, 0.20179063f, 
    -0.01551285f, -0.29268390f, 0.02914290f, 0.24116765f, 0.04387230f, 0.15115318f, -0.09343200f, 0.18271303f, 
    0.25984070f, 0.33271995f, -0.04248146f, 0.30515763f, -0.22844818f, -0.34860724f, 0.14510110f, 0.32689586f, 
    0.10247950f, 0.20538418f, 0.12292957f, 0.04596246f, 0.41489840f, -0.20138329f, -0.04480305f, 0.02098267f, 
    -0.13320920f, -0.08734530f, 0.08743053f, 0.26091474f, -0.12149274f, -0.06024897f, 0.02390274f, 0.24995743f, 
    -0.02154845f, -0.03682409f, -0.21047260f, 0.04973765f, 0.09341364f, 0.07002012f, 0.22264171f, 0.16394772f, 
    0.04538264f, -0.39206678f, -0.13244827f, -0.02593821f, -0.08838076f, 0.00522832f, 0.54991162f, 0.52212369f, 
    0.24583066f, -0.16226359f, 0.05418044f, 0.17554799f, 0.21323813f, -0.00286775f, -0.02165661f, -0.15926799f, 
    -0.07320497f, -0.04466510f, -0.18145357f, 0.13566068f, 0.06699654f, -0.00100593f, 0.22090769f, -0.09804151f, 
    0.11848963f, -0.03028622f, 0.11720090f, -0.15404806f, 0.08658523f, -0.55988795f, -0.10707740f, 0.15744025f, 
    0.23694694f, 0.01949942f, -0.15734451f, 0.12252609f, 0.06794456f, -0.04189687f, 0.15739161f, -0.04281343f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.07127525f, 0.11955326f, 0.10989535f, 0.02184126f, -0.14149402f, 0.25033879f, 0.20172206f, 0.00931563f, 
    0.20959523f, -0.01567691f, -0.16912524f, -0.08390275f, -0.05007057f, -0.08373850f, 0.06939392f, -0.01573038f, 
    -0.06798069f, -0.29492983f, -0.01225025f, -0.06504670f, 0.01189533f, -0.12250219f, 0.15791485f, -0.14652203f, 
    -0.09056567f, 0.18431348f, -0.09110337f, 0.15971896f, 0.14698134f, 0.03146792f, -0.05234448f, -0.01303426f, 
    -0.01120272f, 0.08496077f, 0.19702792f, 0.17076668f, 0.11043999f, -0.07816675f, -0.17052852f, 0.15896319f, 
    -0.01392963f, -0.11160255f, -0.05066077f, 0.13327537f, 0.25096083f, 0.06708625f, -0.11480321f, 0.13637485f, 
    0.10424192f, -0.08310948f, -0.12175972f, 0.35039979f, -0.12831329f, -0.05401577f, 0.30820134f, 0.21398017f, 
    -0.10974982f, -0.12216657f, 0.10812886f, 0.22854920f, 0.19488549f, -0.05001003f, -0.05542410f, 0.05249209f, 
    0.25678581f, 0.15517034f, -0.14643237f, 0.01837205f, -0.03534719f, 0.02885504f, 0.09540027f, 0.32298657f, 
    -0.04234667f, 0.09106233f, -0.00189111f, 0.11297271f, 0.16902393f, 0.16297236f, -0.10329652f, 0.16044746f, 
    0.03886170f, 0.05932707f, 0.10420611f, 0.05103321f, 0.07688396f, 0.07118308f, 0.05607066f, -0.10348042f, 
    0.06418283f, -0.09348901f, 0.27190304f, -0.10093752f, 0.01673086f, 0.02074981f, -0.06416238f, -0.13294081f, 
    0.02792261f, 0.34104463f, 0.18392467f, 0.08757815f, 0.10378987f, 0.02733420f, -0.01338740f, 0.17288114f, 
    0.07115295f, -0.02081531f, -0.00511213f, 0.18606845f, 0.10199546f, 0.28908426f, 0.03062550f, -0.08142213f, 
    0.15795919f, -0.03483404f, 0.11839031f, -0.07077619f, -0.07323772f, 0.08785530f, 0.05190159f, -0.04655239f, 
    -0.09296299f, 0.05275062f, -0.03888217f, 0.17040993f, 0.15782832f, 0.09123783f, 0.12584385f, 0.16191041f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.13050655f, -0.00737147f, -0.06862504f, -0.26410395f, 0.10965407f, -0.29191628f, 0.03930191f, -0.19136660f, 
    0.01073198f, -0.21001150f, 0.40817332f, 0.04949382f, -0.20115112f, -0.00635456f, -0.21690774f, 0.13739975f, 
    0.12814671f, 0.01899642f, 0.10073128f, 0.03926843f, -0.08336065f, 0.05673449f, 0.40441287f, 0.03432904f, 
    -0.18469331f, 0.08988907f, -0.07733925f, 0.14467376f, -0.10843889f, -0.10130576f, -0.07153134f, 0.02591408f, 
    -0.00364486f, -0.55454481f, 0.00903069f, -0.61075431f, -0.15584090f, -0.01984818f, 0.02060349f, -0.15050879f, 
    0.02186887f, 0.00048808f, 0.00134805f, 0.06885245f, 0.24515495f, -0.18452053f, 0.01194203f, -0.32806027f, 
    0.00040625f, -0.01523854f, 0.19975694f, -0.01948076f, -0.04951292f, -0.16076082f, 0.60630763f, 0.05086506f, 
    -0.05430843f, -0.03481284f, 0.18134700f, 0.10766584f, -0.05744531f, 0.10462110f, -0.05770779f, -0.11358026f, 
    -0.23218830f, -0.13281280f, 0.18272854f, -0.05331224f, -0.14974868f, 0.03715950f, 0.12569800f, -0.26339912f, 
    -0.05054238f, -0.04737666f, -0.18516399f, 0.02569841f, 0.11254320f, 0.18509924f, -0.08579247f, -0.15162605f, 
    -0.07341766f, -0.28708169f, -0.08353359f, 0.04078206f, -0.09411193f, 0.05544611f, 0.01522922f, 0.01745839f, 
    -0.00291558f, -0.23166689f, 0.46819699f, -0.04440936f, 0.01148310f, -0.16651186f, -0.24442419f, 0.05682764f, 
    -0.28063414f, 0.54105139f, -0.23851593f, -0.35615858f, -0.03956834f, -0.23396033f, 0.02655064f, 0.11207404f, 
    -0.34788069f, -0.03211240f, 0.01419755f, -0.09603442f, 0.07322084f, 0.12816755f, 0.08410089f, 0.38280913f, 
    -0.04403563f, -0.01661159f, -0.01841776f, -0.08062260f, 0.01703731f, 0.12745357f, -0.31567159f, 0.06645165f, 
    -0.01369017f, 0.06912792f, 0.11223260f, 0.01792053f, -0.00785800f, -0.45329005f, 0.02281277f, 0.02099066f, 
    0.13210706f, 0.19047107f, -0.16635704f, 0.13378620f, -0.05261932f, 0.27511379f, 0.20497714f, 0.03580468f, 
    -0.34985909f, 0.01744692f, -0.46554136f, -0.04849595f, 0.10874301f, -0.04931548f, 0.03722928f, 0.16272767f, 
    -0.71411049f, -0.44124019f, -0.01186329f, 0.00968740f, 0.09137723f, -0.17182985f, -0.51665026f, -0.21088909f, 
    -0.09746256f, -0.07427382f, -0.05077343f, 0.09922912f, 0.15368496f, 0.11723150f, 0.04016943f, -0.05439447f, 
    0.14892246f, -0.05689458f, 0.07469772f, 0.24543653f, 0.09058920f, -0.06232766f, -0.11310472f, -0.05962322f, 
    -0.02694029f, -0.02163626f, -0.06298218f, 0.15312925f, 0.10205845f, 0.21961305f, 0.04446208f, -0.02700007f, 
    0.05168286f, -0.02110829f, -0.52342272f, 0.13219178f, 0.01231444f, -0.16988517f, -0.64502430f, 0.04528492f, 
    0.01940377f, -0.12444779f, -0.16148248f, 0.20156039f, 0.04661938f, 0.25164396f, -0.08722266f, 0.14801651f, 
    0.04967321f, -0.09187485f, -0.36089277f, 0.02107331f, 0.24921326f, -0.09628791f, -0.43854538f, 0.19463159f, 
    0.21646100f, 0.13304672f, -0.15797584f, 0.28978121f, 0.11045908f, 0.01039362f, 0.00603229f, 0.19641215f, 
    -0.01404665f, -0.09648956f, -0.18486165f, 0.07593407f, 0.11654456f, -0.07535095f, 0.07639051f, -0.02297611f, 
    -0.10754460f, -0.20415594f, -0.50290209f, -0.07434994f, 0.03231270f, 0.02838390f, -0.42701787f, -0.12840509f, 
    0.08244297f, -0.34710750f, -0.34014300f, -0.10268345f, -0.04296266f, -0.17097397f, -0.05531802f, 0.07671452f, 
    -0.26409927f, 0.05896379f, 0.24330148f, -0.34568819f, 0.20502806f, 0.22262275f, -0.15229422f, -0.35129532f, 
    0.21618450f, 0.10976110f, -0.09961713f, -0.06020137f, -0.05788709f, 0.22592306f, -0.07259881f, -0.67868453f, 
    -0.05697761f, -0.00908380f, 0.05559834f, 0.07407450f, -0.65418291f, -0.00759201f, 0.11383303f, 0.05026996f, 
    -0.01526932f, -0.15948360f, 0.12907791f, -0.23746428f, -0.11589607f, 0.04092120f, 0.21664935f, 0.22866942f, 
    -0.07724829f, -0.17253120f, -0.28620383f, -0.13132995f, -0.03998566f, 0.01429775f, -0.46705872f, -0.63785219f, 
    -0.28069571f, -0.00913426f, -0.28576818f, -0.46027592f, -0.20394310f, -0.14405015f, 0.25774756f, -0.40464380f, 
    -0.01980078f, 0.11568697f, -0.00184211f, 0.11913799f, -0.24002188f, 0.15855782f, 0.04681377f, 0.07635517f, 
    -0.40938175f, -0.15960796f, 0.16722378f, -0.25746125f, 0.21936701f, -0.07082141f, -0.13365376f, 0.14880855f, 
    0.06757410f, 0.01818030f, -0.09740388f, -0.54651403f, -0.04843511f, -0.73115742f, -0.40182552f, 0.10197648f, 
    -0.11581345f, -0.10539213f, -0.24679957f, 0.18623818f, -0.01497650f, -0.08842751f, 0.28521657f, -0.00064661f, 
    -0.37735286f, 0.00016905f, 0.09037072f, 0.08090293f, -0.00444083f, -0.69353342f, -0.08786576f, 0.06004864f, 
    0.09492283f, 0.11076006f, -0.66304392f, -0.06337186f, -0.16649230f, -0.09033495f, -0.06879219f, -0.01805360f, 
    -0.14617358f, -0.32081592f, -0.03771853f, -0.18355137f, -0.61679250f, 0.09202886f, -0.49926153f, -0.02456954f, 
    0.03146382f, 0.04404804f, 0.19359711f, -0.19987343f, -0.08944082f, -0.10626608f, -0.03327159f, 0.01873468f, 
    0.19131331f, 0.00458682f, 0.21974516f, 0.01198496f, -0.10542210f, 0.01464947f, -0.04605493f, 0.01491975f, 
    -0.11763150f, 0.17831230f, 0.19742535f, 0.00977687f, 0.14084846f, -0.07808860f, -0.07071558f, -0.11502980f, 
    0.26089516f, 0.08248593f, -0.52603632f, 0.15499367f, -0.51169270f, -0.01608202f, 0.07356364f, -0.25211740f, 
    -0.20543997f, -0.10265563f, 0.26626441f, -0.00514708f, -0.07004710f, 0.21880908f, 0.10648987f, -0.50424886f, 
    0.05399136f, -0.04324064f, 0.06423045f, 0.20955136f, 0.23423831f, 0.00085687f, 0.00534692f, 0.15422298f, 
    -0.10202842f, -0.33215013f, 0.12160286f, -0.08511468f, -0.15829109f, -0.10081086f, 0.15886225f, 0.16810369f, 
    0.57238001f, -0.13279535f, 0.19156083f, -0.13598822f, 0.25719717f, 0.00284329f, -0.58556288f, -0.01660273f, 
    0.08469068f, -0.01641712f, 0.07357831f, 0.07741160f, -0.08844359f, -0.05633185f, -0.03112738f, 0.17433520f, 
    -0.12259106f, -0.19137451f, 0.04781467f, -0.11170849f, -0.09301024f, -0.61810106f, 0.04071826f, 0.03776874f, 
    0.05212152f, 0.14782402f, 0.10903207f, -0.39881301f, 0.03518080f, 0.04701205f, -0.05864356f, 0.00986490f, 
    0.02176118f, 0.02417933f, -0.00664401f, -0.49387196f, -0.59061283f, -0.31568930f, -0.09118160f, -0.03689493f, 
    0.09479707f, 0.02835438f, -0.20218605f, 0.00907079f, 0.04168734f, 0.21530101f, 0.06985410f, 0.00795789f, 
    -0.17693578f, -0.15797865f, -0.39676034f, -0.01522409f, 0.09466119f, -0.02127397f, 0.05808746f, -0.47303700f, 
    -0.18608190f, 0.08297658f, -0.00927531f, -0.05456960f, 0.11810157f, 0.05208725f, 0.12071709f, -0.31939796f, 
    -0.52224952f, -0.16610664f, 0.15736409f, -0.48474142f, 0.00126850f, -0.27950582f, -0.04946253f, -0.19128445f, 
    -0.02643893f, 0.03498401f, 0.00212800f, -0.01479303f, 0.05816821f, 0.14363845f, -0.02424942f, 0.00176638f, 
    0.16093646f, -0.03817901f, -0.09106246f, -0.01717061f, 0.14389682f, -0.07471950f, -0.05037820f, 0.57178986f, 
    -0.14496787f, -0.03861873f, -0.08675311f, 0.08940105f, 0.18822691f, -0.01808193f, 0.05197557f, -0.53699070f, 
    0.09820209f, 0.00450424f, -0.05153310f, 0.01309002f, -0.38766950f, 0.11498541f, -0.58266008f, 0.15601566f, 
    -0.00683249f, 0.19250485f, 0.12940106f, -0.03109645f, 0.15865114f, -0.21955331f, -0.04293421f, -0.02651276f, 
    0.06455443f, -0.07433691f, 0.13823289f, 0.17763123f, 0.09035315f, -0.08987977f, 0.01264633f, 0.15216371f, 
    0.04630268f, -0.02286852f, 0.15402173f, -0.09284071f, 0.08771206f, -0.48666328f, -0.01635098f, -0.19667032f, 
    -0.35427123f, -0.16782963f, -0.61459422f, 0.02954282f, -0.15392388f, 0.03399600f, 0.13582243f, 0.08027543f, 
    0.16068535f, 0.08227342f, 0.02589840f, 0.16583367f, 0.12979683f, 0.14280210f, -0.35155305f, 0.15265554f, 
    0.07040716f, -0.68368101f, -0.05565612f, 0.08058414f, 0.06346859f, 0.05270798f, 0.05757010f, 0.00208825f, 
    0.13869788f, -0.82529891f, -0.05576749f, -0.17669983f, -0.04752098f, -0.03476781f, 0.19983360f, -0.41345462f, 
    -0.04965303f, -0.08239819f, -0.08280394f, 0.17956898f, -0.01363327f, -0.14566135f, -0.07872809f, -0.03868965f, 
    0.09653183f, -0.05628714f, 0.17470853f, -0.13707231f, 0.03608385f, -0.05229185f, -0.48591805f, -0.00210854f, 
    0.08128975f, -0.06288774f, 0.01477680f, 0.02541078f, -0.07019753f, -0.01725441f, 0.02209640f, 0.03037328f, 
    -0.18464041f, 0.02294722f, 0.20180745f, -0.02361364f, -0.00604873f, 0.01242914f, 0.04985217f, -0.13104805f, 
    0.07183426f, -0.11189582f, -0.11149423f, 0.26614383f, 0.04343692f, -0.39757434f, 0.10312167f, -0.45998132f, 
    -0.06012603f, -0.03966000f, 0.06113079f, 0.14406903f, 0.06675467f, 0.01601813f, 0.04173550f, -0.06685201f, 
    0.13798559f, -0.08773809f, -0.26282632f, 0.02713747f, 0.03580800f, -0.13809904f, 0.08777671f, 0.24538249f, 
    -0.48689863f, -0.61323440f, -0.04000284f, -0.07737043f, -0.04313454f, 0.19255841f, -0.03814270f, 0.01690095f, 
    0.00558635f, 0.07351085f, 0.02218627f, 0.13779151f, -0.22820465f, -0.05652845f, 0.23695560f, -0.55607885f, 
    -0.21313129f, 0.05808803f, 0.12055617f, -0.06623545f, 0.10342860f, -0.04994293f, -0.26289526f, 0.14460649f, 
    -0.05865289f, -0.06758138f, -0.12707567f, -0.02021054f, 0.10276803f, -0.12485708f, -0.15575865f, 0.06314808f, 
    0.03978924f, 0.11147836f, 0.01676627f, 0.08735457f, 0.09428924f, 0.18782856f, -0.06713870f, 0.20146392f, 
    -0.37700644f, 0.18771447f, -0.08445583f, -0.08515938f, -0.02398022f, 0.04543986f, 0.25859559f, 0.05560704f, 
    -0.02180180f, 0.05861350f, 0.09358931f, -0.08250237f, 0.01350398f, 0.09109224f, 0.15082179f, -0.08474252f, 
    -0.01104242f, -0.00302428f, -0.01499263f, 0.07828436f, 0.06001820f, 0.02740796f, -0.10322347f, -0.00247929f, 
    0.02266895f, -0.10841976f, -0.07740553f, -0.42944092f, -0.00361793f, -0.05683848f, -0.00799603f, 0.14843336f, 
    -0.03301346f, -0.08599932f, -0.06327042f, -0.03028966f, -0.37533176f, 0.08377314f, 0.07349158f, -0.07997824f, 
    -0.00077545f, -0.06810421f, 0.13269703f, 0.02374309f, 0.01920735f, -0.11164539f, -0.00154027f, 0.05662103f, 
    0.03605253f, 0.16729927f, -0.19942053f, 0.00938292f, 0.09653459f, 0.11108975f, -0.02765146f, 0.04923569f, 
    -0.08817251f, -0.02378683f, -0.01072994f, -0.08607242f, -0.12123921f, 0.00135530f, -0.12855895f, -0.17450611f, 
    0.18042792f, 0.02974001f, -0.37866247f, -0.54235071f, 0.09359985f, -0.07280616f, 0.10641053f, 0.24402063f, 
    -0.00083516f, 0.01501636f, 0.14340405f, 0.08142126f, 0.03123193f, 0.10124695f, 0.00366955f, -0.05162798f, 
    -0.00043527f, 0.08939064f, -0.35990179f, -0.05872890f, -0.01438194f, 0.22518200f, 0.17539164f, -0.04496579f, 
    0.22214817f, -0.02036049f, -0.05973521f, -0.05854189f, -0.43442333f, 0.09586694f, 0.06433036f, 0.08602221f, 
    -0.05666391f, -0.01088834f, -0.02881968f, -0.36094317f, -0.14311334f, 0.05990369f, 0.10394544f, 0.10361897f, 
    0.02502315f, -0.06649031f, 0.12474664f, -0.00739958f, -0.00218969f, -0.43663287f, 0.00402569f, 0.07114597f, 
    -0.05720521f, -0.08035874f, 0.08259461f, -0.05321020f, -0.07964312f, 0.02533332f, 0.14047174f, 0.07826209f, 
    -0.44144204f, -0.30095711f, -0.53943336f, -0.38387430f, -0.14031483f, -0.20991600f, -0.66113913f, -0.31651282f, 
    -0.10388732f, -0.09142885f, -0.00965070f, 0.01700287f, 0.11302801f, -0.06355162f, 0.14883465f, -0.12261092f, 
    0.05924446f, -0.49513468f, -0.93773615f, -0.29237652f, -0.38382116f, -0.00583828f, 0.18828271f, -0.37131527f, 
    -0.06629203f, 0.19771446f, -0.04726264f, -0.18122107f, -0.44143370f, -0.14725737f, 0.00052363f, -0.04230931f, 
    -0.41320410f, 0.15111241f, -0.82219571f, 0.18619680f, -0.39008388f, -0.05235970f, -0.18283749f, 0.26959157f, 
    0.08823778f, 0.00701171f, -0.03850135f, -0.09000916f, 0.15822348f, -0.02611311f, -0.35122296f, 0.15799454f, 
    0.02861698f, 0.00805426f, -0.45414668f, 0.20139745f, -0.06469519f, 0.10641804f, 0.19467820f, 0.08530235f, 
    -0.34506038f, -0.20123437f, 0.21412997f, -0.43530044f, -0.70196670f, 0.08468346f, -0.00882045f, -0.17817503f, 
    0.14622742f, 0.31808630f, 0.30258229f, 0.04787390f, 0.13382074f, 0.03998359f, -0.45222315f, 0.16790922f, 
    0.00275882f, -0.10079965f, -0.21779419f, -0.14499928f, -0.79360819f, 0.15628287f, -0.43915039f, -0.06393771f, 
    -0.05645067f, -0.36722326f, -0.60100460f, -0.00774386f, -0.92365396f, -0.51529264f, -0.36053586f, 0.01606155f, 
    -0.47921139f, 0.13096097f, 0.45423260f, 0.02329655f, -0.92329812f, -0.38145566f, 0.08085609f, -0.16583179f, 
    -0.09956097f, 0.30185580f, 0.09024424f, -0.37809256f, 0.18486199f, -0.19875656f, -0.02418751f, 0.08819685f, 
    0.27174199f, -0.27938220f, -0.15785931f, 0.28963438f, -0.14892018f, -0.34759921f, 0.17769720f, -0.00818746f, 
    -0.06446216f, -0.91703707f, -0.10438290f, 0.02866402f, -0.27753747f, -0.22749357f, -0.01102317f, 0.08571528f, 
    -0.03247441f, 0.01889532f, 0.04482384f, -0.62029839f, 0.26156077f, 0.15543744f, 0.07135175f, 0.03080193f, 
    0.07608425f, -0.26586723f, -0.00776483f, -0.01694732f, -0.13661954f, -0.32394415f, -0.38775265f, -0.32274833f, 
    0.30502599f, 0.18452233f, -0.36452073f, -0.01129551f, 0.29089200f, -0.02643785f, 0.01745063f, -0.31824610f, 
    0.06688049f, 0.32671356f, 0.47405457f, -0.04568888f, -0.04450265f, 0.19145544f, -0.33718738f, 0.27923310f, 
    -0.04669693f, -0.14299612f, -0.03207838f, -0.00084162f, 0.17337185f, 0.10583793f, 0.06589650f, -0.06496910f, 
    -0.19505945f, -0.14111194f, -0.60707337f, -0.06917120f, -0.42607185f, 0.01688597f, -0.01725639f, 0.09807873f, 
    -0.06766210f, -0.00314654f, -0.09306768f, -0.12194871f, -0.01702788f, 0.07319257f, 0.08991739f, -0.23804064f, 
    0.11147932f, -0.00891602f, 0.02489079f, -0.58209509f, -0.00452665f, 0.18409206f, -0.11905184f, -0.02976297f, 
    0.03116683f, 0.28315124f, -0.02282786f, -0.48567140f, -0.28253168f, -0.33752587f, -0.02482256f, -0.10275631f, 
    -0.63808823f, -0.35403344f, -0.23660925f, -0.00623186f, -0.00737113f, 0.00122846f, 0.26661071f, -0.07240610f, 
    -0.10052124f, -0.24562204f, -0.01116944f, -0.31917268f, 0.24272342f, -0.16176546f, 0.24613778f, -0.32624382f, 
    -0.06162126f, -0.06060661f, -0.55163354f, 0.14764409f, -0.24183020f, -0.49392590f, -0.06812070f, -0.00778304f, 
    -0.20109184f, 0.08858100f, -0.17830934f, -0.11132020f, -0.28647187f, -0.28747615f, -0.26567543f, -0.06597091f, 
    -0.00779288f, -0.24589752f, -0.21838482f, -0.16729106f, 0.12471241f, -0.27863050f, -0.08424708f, -0.12098954f, 
    -0.33023506f, 0.14022838f, -0.22494830f, -0.16004203f, -0.07372192f, 0.18637772f, -0.20772795f, -0.13921191f, 
    -0.09207228f, 0.14882746f, -0.36366826f, 0.05404688f, -0.21142875f, -0.01633045f, 0.18862762f, -0.05714059f, 
    -0.04782334f, -0.00242074f, 0.06282751f, -0.22731969f, -0.07984445f, 0.06237006f, 0.02525270f, -0.14365862f, 
    -0.07661918f, 0.22610754f, -0.39084169f, 0.17795005f, 0.17397006f, 0.21758850f, -0.62392592f, -0.02911781f, 
    0.22852854f, 0.26248547f, -0.02209175f, -0.07418806f, 0.04183157f, -0.05500174f, -0.39919960f, -0.40111077f, 
    -0.01987534f, -0.23380503f, 0.05961852f, -0.43659627f, 0.16020942f, -0.50507617f, -0.08017215f, -0.19262286f, 
    -0.13726713f, 0.21355775f, 0.00417541f, -0.14475521f, 0.11995322f, 0.12110257f, 0.03022260f, 0.05305740f, 
    -0.07980907f, 0.21223922f, -0.48626840f, 0.10623895f, -0.10472279f, 0.00438595f, -0.66085052f, 0.33635128f, 
    -0.00346414f, -0.00971001f, -0.08598164f, 0.10205673f, -0.27271414f, -0.09109578f, 0.13703918f, 0.16106389f, 
    -0.25191438f, 0.06476659f, -0.10761821f, 0.18071954f, -0.07310700f, -0.22269015f, 0.18835628f, -0.40930399f, 
    -0.04258573f, 0.27417707f, -0.00783764f, -0.56548971f, 0.30125809f, -0.20061255f, -0.00960779f, -0.23771845f, 
    0.00008391f, -0.45861596f, 0.32651812f, -0.01068589f, -0.41979671f, 0.04695717f, 0.28834108f, -0.00909218f, 
    -0.47759005f, 0.27933493f, 0.18629318f, -0.22202118f, -0.15159795f, -0.09440063f, -0.09722649f, 0.02591386f, 
    -0.02303578f, 0.24505828f, 0.25584975f, -0.03556442f, -0.03055794f, 0.12606722f, 0.08756424f, 0.03949993f, 
    -0.54438537f, 0.15280873f, -0.14162537f, 0.02158600f, -0.22475666f, 0.00335527f, -0.25996891f, -0.20228077f, 
    0.18890180f, 0.08186956f, -0.20061198f, 0.32173410f, -0.05262186f, 0.13936333f, 0.01407712f, 0.20367700f, 
    -0.01019111f, 0.06258966f, -0.25348482f, -0.45918798f, 0.15744999f, -0.33936748f, -0.10423794f, -0.14328253f, 
    0.20717543f, -0.55659080f, -0.65108538f, -0.07425588f, -0.56562841f, -0.03714883f, 0.18253104f, 0.13961908f, 
    0.04502818f, -0.02473741f, -0.17363511f, -0.26887175f, 0.21648324f, 0.09626924f, -0.03599035f, -0.24535953f, 
    0.11336915f, -0.06699584f, 0.26320985f, -0.12033231f, -0.25494757f, 0.03866607f, -0.16319746f, -0.41860253f, 
    -0.39099687f, -0.22523281f, -0.56277996f, 0.04470992f, -0.07256950f, -0.06137491f, 0.16428332f, -0.05439829f, 
    0.00260379f, -0.38887689f, -0.08854408f, -0.06703316f, 0.03476517f, -0.11247737f, -0.21789183f, -0.20308818f, 
    -0.08445367f, 0.12028214f, -0.04976498f, -0.00399208f, 0.04686455f, -0.34846118f, 0.06580608f, -0.05159552f, 
    -0.22181360f, 0.13025305f, -0.22827360f, -0.21695772f, -0.03226103f, 0.07407836f, -0.25367972f, -0.76488686f, 
    -0.05214793f, 0.04598180f, -0.03271958f, 0.24631353f, 0.02705909f, 0.11292405f, -0.74712628f, 0.04100180f, 
    0.00349125f, 0.02416822f, -0.56311983f, 0.07133893f, -0.06965461f, 0.02910448f, 0.07766433f, 0.27957505f, 
    -0.58525282f, -0.61803657f, -0.08864044f, 0.16497952f, 0.02402321f, -0.17093015f, 0.05043857f, -0.03205185f, 
    -0.02327945f, 0.03437469f, -0.31761363f, -0.04485019f, 0.14360900f, 0.00153479f, -0.38642225f, 0.01439389f, 
    -0.42746058f, 0.02484857f, -0.07062127f, 0.23670328f, -0.22150776f, 0.08334786f, -0.02337898f, -0.25525817f, 
    0.04098579f, -0.03906502f, 0.16020809f, 0.02707852f, -0.04547250f, 0.08441944f, -0.08182748f, 0.02143801f, 
    0.05258115f, 0.10746892f, 0.09443669f, -0.00945161f, 0.08954452f, -0.27164784f, 0.18011013f, -0.11445156f, 
    0.05015076f, 0.09785312f, 0.11653876f, 0.01287028f, 0.05083354f, -0.16486321f, 0.00866471f, 0.12106055f, 
    -0.08545280f, -0.31864843f, -0.14341055f, 0.18471144f, 0.29795524f, -0.17061360f, 0.04440589f, -0.30219537f, 
    -0.43144295f, -0.12493505f, -0.13563587f, -0.00963780f, 0.21525574f, 0.28563082f, 0.16511339f, 0.01349261f, 
    -0.11409141f, 0.00409324f, -0.57661170f, 0.19468243f, 0.16020714f, 0.15436779f, -0.59076154f, 0.03020919f, 
    0.10149913f, 0.02437083f, -0.19775040f, 0.06791264f, 0.19184899f, -0.06706279f, -0.01062767f, -0.19082887f, 
    -0.05457581f, -0.15484798f, -0.09417602f, 0.02995959f, -0.16343018f, -0.03693160f, -0.19320840f, -0.35466462f, 
    -0.21839327f, -0.14012025f, 0.07553890f, 0.28213328f, 0.02030272f, -0.12217662f, 0.16857217f, 0.15519862f, 
    -0.01013523f, 0.07126402f, 0.00585072f, -0.57481354f, -0.05564275f, 0.17556851f, -0.04045299f, 0.06615379f, 
    0.10379405f, 0.14258961f, 0.08383112f, -0.26181379f, 0.22516659f, -0.08941478f, 0.27572450f, 0.04884756f, 
    -0.07416391f, 0.03745462f, 0.05314554f, 0.15802462f, -0.31649762f, -0.31428343f, 0.16472529f, -0.00844430f, 
    -0.62638736f, -0.02919591f, -0.00573335f, -0.17168403f, -0.03573649f, -0.48386216f, 0.10795285f, -0.35956731f, 
    0.27311209f, 0.14047760f, -0.03659800f, -0.00698528f, -0.13250619f, 0.10876085f, -0.08655809f, -0.70961940f, 
    -0.00897747f, -0.09848247f, 0.10652692f, -0.05420386f, -0.29111612f, 0.05659263f, -0.28846949f, 0.17203231f, 
    0.15757971f, -0.06331143f, 0.24743898f, -0.01750467f, -0.06620487f, 0.00034576f, 0.13766986f, -0.07927000f, 
    -0.06947161f, 0.11412186f, -0.11992911f, -0.58734739f, 0.06540132f, -0.18186830f, 0.02824094f, 0.03185536f, 
    0.07328486f, -0.22286469f, -0.06332257f, -0.07768473f, -0.05986193f, -0.02195782f, 0.00412749f, -0.02822967f, 
    -0.24431400f, -0.16635083f, 0.09774216f, 0.06482801f, -0.41067818f, 0.16339169f, 0.01531730f, -0.03621503f, 
    0.10478599f, 0.12261688f, -0.15912925f, 0.20718506f, 0.32645828f, -0.34635857f, 0.20660080f, -0.02081781f, 
    0.10173549f, -0.42231753f, 0.13002387f, -0.04096558f, -0.50952345f, -0.41690689f, -0.39468187f, -0.01581443f, 
    0.05464490f, -0.10559978f, -0.33993676f, -0.49464023f, -0.27285206f, -0.14828482f, -0.49567980f, -0.26334471f, 
    -0.41588634f, -0.31348526f, 0.17270760f, 0.09580176f, 0.07101344f, -0.30861896f, -0.21980253f, -0.28868231f, 
    0.24960563f, 0.07837047f, -0.17974731f, -0.01539504f, 0.01714047f, 0.00753119f, 0.18462592f, 0.03543575f, 
    -0.31745747f, -0.06042814f, -0.43017483f, -0.07092114f, -0.18553920f, 0.01760151f, 0.27819237f, 0.12515070f, 
    -0.11785927f, 0.15409744f, -0.08970989f, -0.34192690f, -0.14270809f, 0.05369012f, 0.04978390f, 0.01648619f, 
    -0.59407657f, 0.19863842f, -0.04959985f, 0.28504080f, -0.29095480f, 0.03365371f, 0.08527718f, -0.36992064f, 
    -0.10799460f, -0.08366519f, -0.10951158f, 0.07315348f, -0.01836712f, 0.21565455f, 0.22538580f, 0.15568876f, 
    -0.21721865f, -0.03270423f, -0.67167521f, -0.21438813f, -0.00990032f, 0.16469695f, 0.01181779f, -0.36466780f, 
    0.32156813f, 0.19720198f, -0.13884574f, -0.27348256f, -0.08407959f, -0.27487788f, -0.01776887f, 0.24168617f, 
    0.11625993f, 0.13741611f, -0.38422635f, -0.05940188f, 0.15833220f, -0.07491231f, -0.11909884f, 0.10377533f, 
    -0.02603507f, 0.02152810f, 0.25599557f, 0.06334906f, -0.45746633f, 0.09706350f, 0.14418460f, -0.20908846f, 
    0.00142882f, 0.35651848f, -0.19960538f, -0.09918094f, -0.02834314f, -0.33814821f, -0.12039242f, 0.07460561f, 
    -0.06158293f, 0.15852632f, -0.14980455f, 0.02340520f, 0.10426879f, -0.35772377f, 0.09567340f, 0.15086444f, 
    0.10509508f, 0.00714076f, -0.06709528f, 0.30894259f, 0.08772268f, 0.08964875f, 0.00527439f, 0.07773384f, 
    -0.00136287f, -0.53000945f, 0.37570858f, 0.00234040f, 0.00970091f, -0.53689629f, -0.26343188f, -0.13215058f, 
    -0.32476473f, 0.19435720f, -0.08043500f, 0.02072872f, -0.09251471f, -0.11328559f, -0.13283037f, -0.24325365f, 
    -0.00137575f, 0.01433034f, 0.07514027f, 0.15041794f, -0.34914112f, 0.03270391f, -0.12888384f, -0.58333617f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.05343018f, 0.24025472f, 0.04926522f, -0.04819509f, -0.02425896f, -0.10835056f, 0.14253671f, -0.15053347f, 
    -0.04470992f, 0.03516272f, -0.03176980f, -0.09772446f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
