#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.50535750f, 0.41300002f, 0.65861416f, 0.28267699f, 0.13408105f, 0.50409484f, -0.11283787f, 0.20440175f, 
    0.04486850f, 0.39663705f, -0.53276831f, -0.21072233f, -0.42989802f, -0.30900237f, -0.32570562f, -0.24187529f, 
    -0.15733069f, -0.41749313f, -0.42148986f, -0.44225529f, -0.25026366f, -0.24472623f, -0.03065285f, 0.17097463f, 
    -0.09387334f, -0.74330389f, -0.79905403f, 0.66429740f, 0.21146044f, -0.23726362f, 0.47089607f, 0.39940876f, 
    0.82905108f, -0.02848005f, -0.16061935f, -0.04481371f, -0.15398426f, 0.20656681f, 0.17830142f, -0.17730202f, 
    -0.12243050f, 0.16322260f, -0.18865107f, 0.01184174f, 0.16292733f, -0.25771329f, 0.33717287f, 0.28672135f, 
    0.22273812f, -0.13050434f, 0.00907442f, -0.87549740f, -0.79930550f, -0.07224422f, -0.10559721f, -0.96832025f, 
    0.78276807f, 0.66875303f, -0.56508100f, 0.24126089f, 0.08392230f, -0.26873261f, 0.16385545f, -0.12259393f, 
    0.35726219f, -0.17942397f, 0.07997242f, -0.21154989f, -0.24320386f, -0.20670547f, 0.26080132f, -0.01774092f, 
    0.15472835f, 0.26199052f, 0.01056029f, 0.48112673f, 0.72487628f, 0.67688155f, 0.38722080f, 0.02380337f, 
    -0.51832747f, 0.40164971f, -0.03243799f, -0.13264658f, 0.27162296f, 0.47676140f, 0.19559668f, -0.46513167f, 
    -0.20047230f, -0.18285693f, -0.20489886f, -0.49740562f, 0.21002193f, -0.21109068f, -0.30774567f, 0.46160242f, 
    0.01727970f, -0.05734365f, -0.05696933f, -0.16860175f, 0.27362916f, 0.00522364f, 0.33713034f, 0.57155722f, 
    0.34745631f, -0.72384870f, -0.50418609f, 0.18529850f, -0.21351545f, -0.25531259f, -0.07869288f, -0.34378436f, 
    -0.48022279f, -0.24997115f, -0.25608185f, 0.44926399f, -0.36205012f, -0.18265383f, -0.05099551f, 0.38796347f, 
    -0.03933466f, -0.26577443f, 0.01860264f, -0.50181371f, -0.15232940f, -0.38965186f, 0.08886880f, 0.58728099f, 
    0.64719921f, -0.16636215f, -0.95508742f, 0.33758506f, 0.07269017f, -0.14830375f, 0.17680159f, 0.16528226f, 
    0.41391212f, -0.21722960f, 0.28086871f, -0.19100897f, 0.41622314f, 0.26066774f, -0.32007468f, 0.11047697f, 
    0.10087379f, -0.10625075f, -0.25446907f, 0.34114438f, -0.31493145f, 0.02465265f, -1.09769487f, 0.15476128f, 
    -0.21360762f, 0.39376882f, -0.05539491f, 0.10960901f, 1.02723479f, -0.48016781f, -0.03163939f, -0.36266273f, 
    0.02120344f, 0.29073364f, 0.18755756f, 0.05758322f, 0.03736722f, 0.04723290f, 0.18284792f, -0.05794972f, 
    -0.08521080f, -0.25236523f, 0.26318806f, 0.01466241f, 0.06365910f, 0.09019799f, 0.18201996f, -0.59346074f, 
    -0.45547295f, -0.09966958f, -0.49189124f, -0.21496861f, -0.08281386f, 0.29000738f, -0.13046825f, -0.06097308f, 
    -0.45853266f, -0.28239396f, -0.17257050f, -0.43489495f, -0.21483500f, -0.28520820f, 0.21288921f, -0.08482178f, 
    0.43774247f, 0.22512104f, 0.10980934f, -0.09761690f, -0.18595061f, 0.33322588f, 0.31780446f, 0.28642935f, 
    0.13756090f, 0.53608555f, 0.10827279f, 0.16562198f, 0.67426533f, -0.84297109f, -0.24663849f, -0.56216532f, 
    0.02786598f, -0.33765879f, -0.23661111f, -0.06252588f, -0.09644385f, 0.28409579f, 0.02537528f, 0.08996513f, 
    0.11645584f, -0.22537941f, -0.23993224f, -0.37109426f, -0.20488460f, 0.02350917f, 0.00546497f, 0.38080540f, 
    0.07379557f, 0.82721168f, -0.34605953f, -0.24844462f, 0.84825397f, -0.14879376f, 0.61397707f, 0.25045088f, 
    -0.14298789f, 0.55299181f, 0.35115406f, -0.09946081f, 0.38533619f, 0.00500358f, 0.10438724f, -0.00065357f, 
    0.02418231f, -0.10861189f, -0.23886162f, 0.04689533f, 0.16018164f, -0.24553049f, -0.23632155f, 0.12413520f, 
    0.01540357f, -0.13048409f, -0.98349780f, 1.00974154f, 0.42556745f, -0.70312142f, 0.54468095f, -0.80391008f, 
    0.46565968f, 0.27685869f, -0.63855082f, -0.55916584f, -0.15609258f, -0.18820193f, 0.31649780f, 0.13665400f, 
    -0.18408747f, 0.14859883f, -0.21430378f, -0.02828801f, -0.11566419f, -0.17169167f, -0.16863807f, 0.08162865f, 
    -0.02482522f, 0.27349085f, 0.23446807f, -0.77067739f, -0.08308867f, 0.68330842f, 0.27302015f, 0.50137889f, 
    0.83760786f, 0.25818428f, -0.54675066f, 0.50537395f, -0.45122075f, 0.20867765f, 0.17966127f, -0.12999128f, 
    -0.14066993f, -0.27170396f, -0.40371022f, -0.03523688f, 0.22933629f, -0.52128041f, -0.10529755f, 0.13433215f, 
    0.04297582f, -0.44463393f, 0.09781866f, -0.13095900f, 0.57932544f, 0.47410092f, 0.37947488f, 0.59189868f, 
    0.10528232f, -0.05436977f, 0.12110215f, 0.18581150f, 0.31101343f, 0.31273779f, -0.29651731f, -0.00700858f, 
    0.19557740f, -0.14128239f, -0.05224968f, 0.49072921f, -0.26778018f, -0.17483872f, 0.14399667f, 0.40600130f, 
    0.02724700f, -0.57579768f, 0.33291242f, -0.19145578f, -0.18828361f, 0.63484615f, -0.14567800f, -0.57846880f, 
    1.00033343f, 0.62319452f, 0.67993748f, -0.31319693f, -0.05506727f, 0.30752459f, 0.07426413f, 0.10565652f, 
    -0.19837695f, -0.52997750f, -0.07464207f, -0.14658588f, 0.28686792f, 0.01577699f, 0.31362137f, -0.05054833f, 
    0.24192716f, -0.04894231f, 0.02246646f, 0.29482558f, -0.26206616f, -0.18823321f, 0.81177992f, 0.37059036f, 
    0.56072295f, 0.52619559f, 0.37015381f, 0.52694511f, 0.12510887f, -0.18316469f, -0.15235487f, -0.63824278f, 
    0.07928131f, -0.02518610f, -0.21784578f, 0.06798545f, 0.11549568f, 0.42064160f, 0.15399526f, -0.16520821f, 
    0.19134857f, -0.03413609f, 0.22566241f, -0.05762412f, -0.02220956f, -0.20166680f, 0.36708871f, -0.21198118f, 
    -0.30416402f, -0.44637102f, -0.24553974f, -0.03221175f, 0.13514797f, -0.49521637f, 0.32394499f, 0.41965762f, 
    -0.48360330f, -0.45084411f, -0.06170514f, -0.07830348f, 0.13247553f, -0.38088292f, 0.08243527f, 0.29416782f, 
    0.05796743f, -0.24724419f, -0.22548680f, 0.15525912f, 0.16861528f, 0.16192493f, 0.10764162f, 0.11892737f, 
    0.75574321f, 0.51569319f, 0.05740900f, 0.52272153f, 0.78751129f, -0.12122294f, 0.26079977f, -0.24623118f, 
    0.40556398f, 0.15636444f, 0.43500939f, 0.32504192f, 0.30320624f, -0.42664000f, -0.08355974f, -0.20399193f, 
    -0.18383470f, -0.13132527f, 0.14038859f, -0.10520238f, -0.25329426f, 0.04341448f, 0.29159147f, 0.09183570f, 
    -0.06687909f, 0.67335647f, -0.56799841f, -0.24185979f, -0.38368788f, 0.34844595f, 0.22177605f, 0.25617653f, 
    0.36599147f, 0.19913551f, 0.01984661f, -0.47874054f, -0.13597690f, -0.71513176f, -0.15403041f, -0.11277202f, 
    0.11469340f, -0.40232629f, -0.34981582f, -0.10794035f, -0.19946289f, -0.09321352f, -0.11960415f, -0.25212809f, 
    -0.34788024f, -0.41091189f, 0.10384762f, 0.52386969f, 0.65623957f, 0.64960223f, 0.19333425f, -0.26810429f, 
    0.24996500f, 0.23393671f, -0.56490076f, -0.15224031f, 0.12604673f, 0.13271652f, 0.23743203f, 0.41374344f, 
    0.30478874f, -0.31538960f, 0.17107131f, 0.28713354f, 0.00862728f, 0.36365739f, 0.01990850f, -0.03731766f, 
    -0.22831653f, 0.39863652f, -0.12690033f, 0.09510916f, 0.48875397f, 0.44598994f, 0.13680358f, 0.53301281f, 
    -0.35864079f, -0.27636439f, -0.59128702f, -0.64605123f, -0.24931583f, -0.17955641f, 0.25567839f, 0.25743622f, 
    0.28395620f, 0.23442048f, 0.21537825f, 0.32382956f, 0.19813547f, -0.01985413f, 0.24027847f, 0.14386694f, 
    0.02344956f, 0.24298039f, -0.06568518f, 0.13017608f, -0.25065291f, 0.18696971f, -0.45177203f, -0.40238237f, 
    0.09976542f, 0.24079639f, 0.34487519f, -0.65257597f, 0.49260631f, 0.19059576f, 0.25964710f, -0.32862738f, 
    -0.35806966f, 0.46343687f, 0.26194125f, -0.32878479f, -0.18355758f, -0.35506323f, -0.43863493f, -0.37317544f, 
    0.02953066f, -0.15493920f, 0.09362952f, 0.32908553f, -0.06490610f, 0.61206204f, 0.22214825f, -0.51311010f, 
    -0.43864402f, 0.10548364f, 0.55183661f, 0.20081170f, 0.67228961f, 0.57625002f, -0.02115641f, -0.51061940f, 
    -0.18970712f, -0.25362289f, -0.21294886f, 0.31430081f, -0.26572961f, -0.19335616f, -0.32975680f, 0.03465634f, 
    0.16265899f, -0.06775607f, 0.00771797f, -0.15824607f, -0.27977309f, -0.05803342f, 0.89316452f, 0.21937309f, 
    0.01462636f, 0.42755640f, -0.68412203f, -0.16805644f, -0.87418991f, -0.52197492f, -0.31740132f, -0.35780811f, 
    -0.22472455f, -0.17816174f, 0.40765974f, -0.15780674f, 0.24839298f, -0.15334059f, -0.44553298f, -0.05906975f, 
    0.10499135f, -0.14996657f, -0.09531324f, 0.20783569f, 0.32706693f, -0.08360956f, -0.02081260f, 0.43989414f, 
    -0.28097311f, 0.16158140f, -0.46699280f, 0.46948195f, 0.35127422f, -0.49168456f, 0.38579118f, 0.47008017f, 
    -0.21992609f, -0.31638610f, 0.29950488f, 0.19220461f, 0.08361715f, -0.24615955f, 0.00233803f, 0.22394001f, 
    -0.30863461f, -0.19755581f, -0.35157660f, -0.27999288f, -0.03325960f, -0.16151865f, 0.52990901f, 0.20825000f, 
    0.62057501f, 0.49793682f, 0.21536238f, -0.06730210f, -0.51652700f, 0.18888672f, -0.06019312f, 0.19030516f, 
    -0.08056735f, 0.48249254f, 0.40154427f, -0.00563308f, 0.12286236f, -0.41988078f, -0.31010032f, -0.17565094f, 
    0.17036414f, 0.09308654f, 0.33720496f, -0.26425326f, 0.30099159f, 0.15000090f, 0.20962165f, 0.44813457f, 
    -0.02600499f, -0.54457539f, -0.59041625f, -0.61801124f, -0.52064824f, -0.39378923f, -0.46399814f, -0.08957169f, 
    0.27691278f, -0.37014550f, 0.04204223f, 0.01209099f, 0.00861758f, 0.20220309f, -0.01619281f, 0.23043390f, 
    0.17582034f, -0.15124269f, -0.20115358f, 0.06313705f, 0.00046881f, -0.14996733f, -0.20016114f, 0.03886504f, 
    -0.23749357f, 0.00698327f, -0.58972406f, 1.06997514f, -0.13403837f, 0.03558281f, 0.28899455f, 0.29351386f, 
    0.27962121f, 0.35754189f, -0.24784879f, 0.58809972f, -0.17114705f, -0.13919546f, -0.18716979f, -0.32291961f, 
    0.25283742f, 0.17330627f, -0.22377655f, -0.04781063f, -0.00935707f, 0.24695370f, -0.00199937f, 0.26958251f, 
    0.07520783f, 0.08048432f, 0.08401658f, -0.78166127f, -0.07976022f, -0.37945062f, -0.53244030f, -0.59155315f, 
    0.67731166f, 0.83021069f, -0.10980439f, 0.38507381f, 0.58154976f, -0.18923973f, -0.19208409f, -0.14863800f, 
    -0.35760209f, 0.15754648f, -0.03751297f, 0.10182992f, -0.05690265f, 0.20503087f, 0.08921319f, 0.12784551f, 
    -0.12661739f, 0.07292230f, -0.21827251f, 0.00582470f, -0.70658219f, -0.69915026f, -0.22456509f, 0.11901216f, 
    0.13244116f, -0.15996298f, -0.17235674f, 0.58040583f, 0.38749021f, -0.48473904f, 0.10368977f, -0.11572813f, 
    -0.30268192f, 0.14099684f, 0.21040748f, 0.16568883f, 0.17760393f, 0.37353617f, 0.43817171f, 0.17517513f, 
    -0.10216990f, -0.48904562f, -0.24556907f, -0.36916575f, -0.18547672f, 0.37372079f, -0.16478561f, 0.44085127f, 
    1.02693367f, 0.67445105f, 0.19987546f, 0.07558996f, 0.33221173f, 0.17292477f, 0.24865726f, -0.26042101f, 
    -0.38990933f, -0.02295719f, -0.22438775f, -0.16418295f, -0.36618048f, -0.09641514f, 0.03902376f, -0.10152604f, 
    -0.04012874f, 0.13078721f, -0.11804320f, -0.45823848f, -0.06504554f, -0.11499614f, -0.53313327f, -0.43276629f, 
    -0.43029526f, -0.32171342f, -0.61383283f, 0.14462288f, -0.14274321f, -0.29810169f, -0.36122784f, 0.16735418f, 
    -0.02271586f, -0.20470595f, -0.04447736f, -0.14693862f, 0.03355199f, 0.16493310f, 0.02470807f, 0.00382375f, 
    0.15435024f, -0.02582707f, 0.35446641f, 0.24159904f, -0.24342367f, -0.31541830f, 0.33186007f, 0.17395039f, 
    -0.42159951f, -0.55020225f, 0.02513874f, 0.09705906f, 0.48894268f, -0.24838234f, -0.05928965f, -0.42142484f, 
    -0.37710077f, -0.38550428f, -0.06943256f, 0.02414870f, -0.18958305f, -0.34759134f, -0.15756607f, -0.26401740f, 
    -0.15818773f, -0.19054483f, -0.32937595f, -0.05935683f, -0.25469697f, 0.02452491f, -0.02467432f, 0.19522768f, 
    -0.86778611f, 0.05921958f, 0.15656200f, 0.26255319f, -0.32118431f, -0.46042383f, -0.24238700f, -0.20753357f, 
    0.25418007f, 0.30161333f, -0.34342816f, 0.43495438f, -0.55558801f, 0.18883349f, -0.36428511f, 0.25880525f, 
    0.33237469f, 0.16146964f, -0.38603795f, -0.30192268f, -0.10730410f, 0.19555119f, -0.00020166f, -0.16514191f, 
    0.04017843f, 0.45937338f, -0.92314112f, 0.71630132f, 0.81724501f, -0.25652218f, -0.60335743f, -0.37661338f, 
    -0.15792286f, -0.07213515f, -0.14776036f, 0.25006512f, -0.02277520f, -0.05534081f, 0.08389556f, -0.18655938f, 
    -0.45787540f, -0.37206244f, -0.36017317f, -0.16711415f, 0.00342582f, 0.01962977f, 0.23338804f, 0.07192682f, 
    -0.06443630f, 0.16047674f, -0.89857882f, 0.38196483f, -0.06650905f, -0.37937516f, -0.32214186f, 0.13849734f, 
    0.95385140f, 0.03840935f, -0.01817635f, 0.64830583f, -0.27958801f, 0.00639865f, -0.04070634f, -0.37654448f, 
    -0.28345600f, 0.23603892f, 0.03489513f, -0.10326764f, -0.00262154f, -0.31712404f, -0.05622499f, 0.05783957f, 
    0.14910866f, -0.05913965f, 0.35242158f, 0.01929695f, -0.45728192f, -0.18364133f, -0.62212062f, 0.02577122f, 
    0.23906070f, -0.31611156f, -0.05330320f, -0.11153606f, -0.00477660f, -0.21498974f, -0.41360363f, 0.30984744f, 
    -0.08483306f, 0.39865750f, -0.43594652f, -0.01278550f, 0.00791559f, -0.05972443f, -0.05951250f, 0.63527942f, 
    -0.09207048f, 0.39531076f, 0.27292201f, -0.33590147f, -0.45320502f, -0.17545867f, 0.17016155f, -0.38272583f, 
    0.28670955f, 0.39099953f, 0.62023330f, -0.68213767f, -0.32162955f, -0.11430100f, -0.17558591f, 0.75861925f, 
    -0.02768932f, 0.20316158f, 0.32498097f, 0.20831108f, -0.14193241f, -0.17304727f, -0.17166378f, 0.26221639f, 
    -0.28900298f, -0.02186644f, 0.19583586f, 0.30544490f, 0.12210739f, 0.73171002f, 0.33528116f, 0.25511512f, 
    -0.28553289f, 0.13819081f, -0.17664149f, -0.53795159f, 0.73215461f, 0.60255027f, 0.13419211f, -0.40770707f, 
    -0.00725151f, -0.17846280f, 0.29820612f, -0.00501090f, 0.52089322f, -0.14973547f, -0.18981846f, -0.02889999f, 
    0.04101440f, 0.07257586f, 0.05101326f, 0.14055263f, -0.15409762f, 0.33022904f, -0.36035857f, 0.39602178f, 
    0.58633524f, -0.81730533f, -0.59790379f, 0.50692594f, 0.10926692f, -0.36570364f, -0.20310093f, 0.10649485f, 
    0.24194644f, 0.53437233f, 0.12476016f, 0.24619950f, 0.31078467f, -0.21107934f, 0.07754342f, 0.00983218f, 
    0.22151542f, 0.09729279f, 0.27658030f, 0.12297848f, -0.01260654f, -0.07113592f, 0.43290377f, 0.80119061f, 
    0.43317699f, -0.82806730f, -0.56843603f, -0.63234693f, -0.04601458f, -0.06921450f, -0.11333934f, 0.05576768f, 
    -0.12949231f, -0.27782238f, -0.03285902f, 0.13979432f, 0.17659186f, 0.22117727f, -0.25050876f, -0.16317272f, 
    -0.27135956f, -0.09297843f, 0.07796018f, 0.19382705f, 0.30463627f, -0.19969168f, 0.08758409f, -0.14375469f, 
    -0.67161977f, -0.06390144f, -0.21253163f, -0.20944546f, -0.13155901f, -0.41736883f, -0.53822815f, -0.13292719f, 
    -0.31594321f, -0.47557566f, -0.49671209f, -0.13400431f, 0.26059490f, -0.05869600f, -0.10587738f, -0.28599906f, 
    -0.22225952f, -0.39167079f, 0.05125976f, 0.00104533f, 0.15474147f, 0.25913814f, 0.33919093f, 0.15493898f, 
    0.05810953f, 0.36059636f, -0.20472121f, -0.70947129f, -0.54964662f, 0.14868656f, -0.01702033f, 0.59740341f, 
    0.12397268f, 0.01045766f, 0.56845665f, 0.45178595f, -0.19520722f, -0.19551679f, -0.03402404f, 0.13271970f, 
    -0.10101294f, -0.06507552f, 0.34023845f, -0.08176377f, 0.15587603f, 0.13098183f, -0.30693558f, 0.27242017f, 
    0.24304989f, 0.11152898f, -0.59019518f, -0.07768503f, 0.54347408f, 0.64966953f, 0.38398230f, -0.89739907f, 
    -0.01771908f, -0.50989944f, -0.24112789f, 0.01913463f, 0.43713066f, 0.42900652f, 0.20676187f, -0.15619385f, 
    -0.11550663f, 0.07324686f, 0.25024840f, 0.47235706f, 0.19913548f, 0.11561790f, -0.34411153f, -0.27035430f, 
    0.13345549f, 0.07598807f, -0.35166138f, -0.53386253f, 0.45144531f, 0.73277992f, 0.06055553f, 0.59965104f, 
    0.52627069f, -0.05009655f, 0.19140144f, -0.33018920f, -0.32466263f, 0.26244918f, -0.21304677f, 0.23261923f, 
    0.20161380f, -0.00075488f, -0.02784050f, 0.08290976f, 0.10914429f, -0.16965494f, 0.31281391f, -0.11547408f, 
    0.49925363f, 0.05204062f, 0.11301807f, 0.17235269f, 0.10347828f, 0.65759838f, -0.61388087f, -0.40298808f, 
    -0.11004651f, 0.39543715f, -0.81669658f, -0.73959863f, -0.62868112f, 0.07243134f, -0.30809036f, 0.09610405f, 
    0.39601579f, 0.06324369f, 0.05729619f, 0.03205910f, -0.05293357f, 0.14942470f, 0.23118062f, 0.19255467f, 
    0.03118118f, 0.11117683f, 0.07712582f, -0.28923944f, -0.08342730f, -0.16298255f, 0.14998654f, -0.24955454f, 
    -0.69876206f, -0.45433170f, 0.31812429f, -0.30686530f, 0.03096693f, -0.44048762f, -0.75190765f, 0.32805654f, 
    0.50310230f, 0.17254443f, 0.16658427f, -0.14860320f, 0.00146964f, -0.13190520f, -0.31041899f, -0.41699541f, 
    0.31863523f, -0.08964307f, -0.03123128f, 0.23920348f, 0.41566738f, -0.17577505f, 0.81422204f, -0.02119227f, 
    -0.78433037f, -0.63705677f, -0.31806821f, -0.29387543f, 0.67794281f, 0.01991760f, -0.08037891f, 0.49940816f, 
    0.06887271f, -0.07442833f, 0.31382731f, -0.36068514f, 0.01229215f, 0.00721167f, 0.27239680f, -0.16460507f, 
    -0.05272952f, 0.10526923f, -0.26109916f, -0.12364158f, -0.13392204f, 0.04617038f, 0.03910792f, 0.77513570f, 
    0.64083874f, 0.41735387f, 0.11427434f, 0.70810825f, 0.22041407f, -0.44439435f, 0.08013585f, 0.24579093f, 
    0.51883447f, -0.37716413f, -0.25122735f, 0.01984055f, 0.17600463f, 0.03303408f, -0.16447541f, 0.16592011f, 
    0.18380265f, -0.02645099f, -0.12034574f, 0.32130554f, 0.07955024f, -0.13488993f, -0.02428593f, 0.20873746f, 
    0.16815554f, -0.29767898f, -0.64853841f, -0.57991546f, 0.15753010f, 0.26874900f, -0.58199281f, 0.30160561f, 
    0.84392571f, -0.01174174f, -0.66313207f, 0.02787814f, 0.01943334f, -0.18171047f, -0.14565107f, -0.18926559f, 
    -0.14999017f, -0.07709052f, 0.26578712f, 0.00585147f, -0.39787984f, 0.11113091f, -0.09229918f, 0.27154025f, 
    -0.44918004f, -0.71525788f, -0.26710740f, -0.56335026f, -0.23561348f, -0.17138480f, -0.04153568f, -0.45331684f, 
    -0.12698360f, 0.35087323f, 0.06535986f, 0.13290772f, 0.28142637f, -0.43578178f, -0.02763400f, -0.28540689f, 
    0.03408873f, 0.16375647f, -0.24367307f, -0.07945441f, -0.25037855f, 0.26337281f, 0.10289560f, 0.46309033f, 
    -0.15035982f, 0.14559440f, 0.80938625f, 0.92472118f, 0.28425679f, 0.18693385f, -0.45727006f, -0.59521216f, 
    0.44527817f, -0.65921247f, 0.14982107f, 0.21152739f, 0.44894511f, -0.11435521f, -0.31804028f, 0.04353946f, 
    -0.11964148f, 0.02277146f, -0.19838104f, 0.34819749f, 0.38766199f, -0.13434525f, -0.37491721f, -0.03873472f, 
    -0.01109968f, -0.11091687f, 0.26759443f, 0.20136595f, 0.11122902f, -0.74624455f, 0.65445411f, -0.42599916f, 
    0.05877551f, -0.14955364f, 0.15805350f, 0.29448393f, -0.01829566f, 0.34685513f, -0.39871144f, 0.12052730f, 
    -0.19261213f, 0.65123141f, 0.22971278f, -0.35464779f, 0.24298957f, -0.14144780f, 0.53569078f, -0.07011434f, 
    0.00876258f, -0.21431608f, 0.31696039f, -0.50197637f, -0.40834516f, -1.02324975f, -0.73634946f, -0.23343746f, 
    -0.04982305f, -0.00478226f, 0.64172095f, 0.33924693f, 0.54872715f, 0.39802945f, -0.24130538f, -0.09362379f, 
    -0.23672733f, -0.14843927f, -0.21933056f, -0.10968065f, 0.28791606f, 0.16233028f, 0.05402075f, -0.18146916f, 
    -0.03666934f, -0.14910112f, -0.16368032f, -0.09941482f, 0.33680567f, 0.53898150f, -0.42760545f, -0.99622744f, 
    0.19521803f, 0.17680845f, -0.39495966f, 0.58758366f, -0.04876813f, 0.42097265f, -0.35684639f, 0.04624268f, 
    0.04840278f, 0.01236887f, -0.05628915f, 0.05067828f, 0.06340493f, -0.24397688f, 0.13609675f, 0.07774369f, 
    0.16320539f, 0.26888269f, 0.37186867f, -0.18030263f, -0.00537329f, 0.20044193f, 0.61689013f, 0.61161911f, 
    -0.17821053f, 0.60080004f, 0.25372809f, 0.43751147f, 0.42113605f, 0.46457687f, 0.43475568f, 0.41539848f, 
    -0.26400372f, 0.00400478f, -0.01348377f, -0.10267996f, -0.37873930f, -0.09944905f, -0.04494206f, 0.02035777f, 
    -0.09494568f, 0.13378346f, -0.10706941f, -0.02133352f, -0.18116407f, 0.00177116f, 0.30186328f, -0.66213727f, 
    0.01979114f, -0.03488423f, -0.50511843f, 0.86485207f, 0.12965292f, -0.47373223f, -0.56493419f, -0.34428710f, 
    -0.56012219f, -0.17604710f, 0.16878305f, 0.40381104f, 0.00671978f, 0.21205041f, 0.36935228f, -0.23697802f, 
    -0.12288147f, 0.06152807f, 0.24624933f, -0.04361576f, 0.02496107f, 0.15758586f, 0.08671812f, -0.12249161f, 
    0.57743829f, 0.51120728f, 0.61698616f, 0.43137181f, 0.50294447f, 0.30287620f, 0.21520936f, 0.04099301f, 
    -0.59143382f, -0.31002077f, 0.12547037f, 0.16608872f, 0.20037007f, -0.16926585f, 0.09653743f, -0.16593271f, 
    0.06812420f, 0.26261085f, -0.08385714f, -0.24607664f, -0.21339983f, -0.14494024f, 0.19124912f, -0.08760332f, 
    0.04516017f, 0.03222194f, 0.28619835f, -0.25729290f, -0.33280987f, -0.17024101f, 0.41259852f, -0.36390036f, 
    -0.56034487f, -0.54176599f, 0.18931223f, 0.05540755f, 0.42267218f, -0.06999137f, 0.32057151f, 0.27264869f, 
    -0.41987854f, -0.47280881f, -0.06430298f, -0.34915879f, -0.20287329f, 0.30062038f, -0.01145964f, -0.49080148f, 
    -0.16587690f, -0.24096902f, -0.73079360f, -0.68205827f, -0.61214602f, -0.44356096f, -0.04356595f, -0.19129762f, 
    0.39471501f, 0.54238313f, 0.53057349f, 0.44857621f, 0.32032368f, -0.16874747f, 0.27715933f, 0.01348843f, 
    0.16303757f, -0.03435234f, -0.11501852f, 0.08783749f, 0.00059671f, 0.04784245f, 0.04730868f, 0.19089408f, 
    -0.02213202f, -0.07596667f, -0.10539699f, 0.80454683f, 0.40392432f, 0.10011584f, -1.18535018f, -0.08491509f, 
    0.19238742f, -0.01077392f, -0.13635735f, -0.37947956f, -0.58563185f, -0.20047101f, 0.09385639f, -0.02903704f, 
    0.25171185f, -0.07844117f, -0.06730830f, 0.33278349f, -0.14211574f, 0.07200654f, 0.42835206f, -0.22769536f, 
    -0.04964110f, -0.02548600f, -0.21751268f, 0.24132006f, 0.92018056f, 0.31344292f, -0.05256757f, 0.87939477f, 
    0.85466021f, -0.01335888f, -0.17921397f, -0.08229357f, -0.09572699f, 0.02384007f, -0.18130031f, 0.18306908f, 
    -0.00437146f, 0.08169226f, 0.13271040f, -0.01956762f, 0.03132854f, 0.24845296f, 0.09124272f, 0.14411187f, 
    0.13539268f, 0.20996572f, 0.07257388f, -0.18305458f, 0.14084587f, 0.57251334f, 0.80174625f, 0.17852324f, 
    -0.07870337f, -0.26588336f, -0.30047262f, -0.98691928f, -0.17680846f, -0.09013856f, 0.08976379f, 0.39519638f, 
    -0.24958861f, 0.19436844f, 0.24818040f, -0.35097995f, -0.27817881f, 0.05058230f, -0.09498741f, -0.06285757f, 
    0.17808735f, 0.04892823f, 0.16273850f, 0.36479181f, 0.07653216f, -0.18342526f, 1.00643051f, 0.39708942f, 
    -0.00628100f, -0.16626398f, -0.44603902f, -0.13236143f, 0.26216397f, -0.61710489f, 0.33975461f, 0.44883969f, 
    0.25827876f, 0.32059816f, 0.01574429f, 0.08167201f, -0.06686054f, -0.11028109f, -0.21482758f, -0.14786090f, 
    -0.24305679f, 0.01264890f, -0.08735426f, 0.32947385f, -0.11951513f, 0.08252627f, 0.00027997f, 0.19486000f, 
    0.85056359f, -0.59889865f, -0.10334541f, 0.81951523f, -0.30702990f, -0.35709861f, 0.49622932f, 0.03719532f, 
    0.41768667f, -0.37736997f, 0.24397847f, -0.26553309f, -0.32974687f, -0.09417351f, 0.15608783f, -0.30521083f, 
    0.00972379f, -0.36671305f, 0.10688978f, -0.32929146f, -0.00859665f, 0.06659292f, -0.12721775f, -0.18604808f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17824836f, 0.25096151f, -0.02670785f, 0.33134785f, -0.00794556f, 0.28814501f, 0.26455748f, -0.00781953f, 
    0.19864446f, 0.08699270f, 0.34520936f, 0.19264998f, 0.14205924f, -0.03073026f, 0.07654815f, 0.17016670f, 
    -0.00746488f, -0.04042274f, -0.06196870f, -0.01853189f, -0.07644466f, 0.18672504f, 0.12859438f, -0.05471238f, 
    0.14766619f, 0.11535997f, -0.00978294f, -0.04579395f, 0.10099914f, 0.15952969f, 0.03595763f, 0.07691670f, 
    0.08837081f, 0.19161052f, 0.05384755f, 0.31722137f, 0.17506403f, 0.05354519f, 0.05507105f, 0.05246650f, 
    0.18494236f, 0.38852671f, 0.17315564f, 0.23349755f, 0.24101806f, 0.03437217f, 0.12164654f, 0.20153111f, 
    0.19434376f, 0.06043510f, 0.00643560f, 0.24224502f, 0.03942825f, 0.33204368f, -0.00650202f, 0.12205181f, 
    0.01941526f, -0.05163225f, 0.05283757f, 0.31781203f, -0.01054584f, 0.05641558f, 0.00438711f, 0.01576575f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10360151f, 0.13992541f, 0.01778160f, 0.08526668f, 0.01186324f, 0.05777417f, 0.01564098f, -0.07677482f, 
    -0.06077681f, -0.11740891f, -0.22159532f, -0.18892737f, -0.19252577f, -0.01689505f, -0.01997510f, -0.00288358f, 
    -0.13612823f, 0.03279520f, 0.09804192f, -0.01284821f, 0.05832674f, 0.06351154f, 0.00491643f, -0.03368350f, 
    0.29813960f, 0.06546818f, 0.17231677f, -0.05948652f, -0.11734653f, 0.02927565f, -0.05980136f, 0.15113539f, 
    0.09779330f, 0.02072210f, -0.02179650f, -0.03655693f, -0.10261369f, 0.02100066f, -0.08000699f, 0.00435881f, 
    0.08752960f, 0.06768650f, 0.00569647f, 0.04365336f, 0.05787110f, -0.02408665f, -0.05072279f, 0.02730742f, 
    -0.17252606f, -0.01132435f, -0.07817420f, 0.02824409f, 0.01487469f, -0.08503395f, -0.00457388f, 0.04284033f, 
    -0.08156007f, 0.00272068f, -0.10915295f, 0.07896584f, 0.25349289f, -0.13913797f, -0.21526723f, 0.01630852f, 
    0.07267940f, -0.04892052f, -0.05962731f, -0.08314032f, -0.03123188f, -0.01883518f, -0.04029404f, 0.22457740f, 
    -0.08946151f, -0.13160728f, -0.18860915f, -0.23263417f, -0.05528752f, -0.01094003f, -0.03150758f, 0.02076114f, 
    0.13325243f, -0.06726751f, 0.10512896f, -0.08586901f, 0.09994598f, -0.00281986f, 0.19246961f, -0.08135726f, 
    0.04002091f, 0.06088309f, 0.11634335f, -0.09293492f, 0.14014292f, 0.07922757f, -0.13220933f, 0.09992123f, 
    -0.15324175f, -0.01320780f, 0.02289979f, 0.13990697f, 0.01586174f, 0.02013446f, 0.10155524f, 0.01644537f, 
    0.06986197f, -0.07683086f, -0.12263173f, 0.01142146f, 0.13003516f, 0.00386847f, 0.12306855f, 0.32667929f, 
    0.01462588f, -0.01732467f, -0.04130410f, -0.04429894f, -0.07905056f, 0.02334162f, -0.01917748f, -0.01032678f, 
    -0.00866689f, 0.18157957f, -0.06993249f, -0.04386961f, 0.05554700f, 0.09533639f, -0.04919497f, -0.07150958f, 
    -0.01498383f, 0.03624471f, -0.03633321f, -0.03371643f, 0.01858004f, 0.10841843f, 0.10103969f, -0.04599946f, 
    0.08458561f, -0.01124846f, -0.00148635f, 0.04883621f, -0.05897088f, -0.18185814f, 0.00224524f, -0.14000507f, 
    0.10677604f, -0.07322590f, 0.00511720f, 0.08648384f, 0.04227935f, -0.02505257f, -0.01186393f, 0.01470840f, 
    -0.06152163f, 0.04026653f, 0.06809402f, 0.08651638f, -0.18893731f, -0.19329588f, 0.03524585f, 0.07285148f, 
    -0.06605916f, -0.20840791f, -0.08656017f, 0.02918041f, 0.03036584f, 0.16758548f, -0.03107183f, 0.09262399f, 
    -0.11818650f, -0.00241438f, 0.10904035f, 0.09314764f, 0.04819181f, 0.04539024f, -0.10208998f, -0.03303867f, 
    0.14666635f, 0.09307019f, 0.03659905f, 0.10372154f, -0.09241039f, -0.09195968f, 0.05830420f, -0.13680315f, 
    0.07637059f, 0.10944042f, 0.13618229f, 0.12807444f, 0.08572825f, -0.05487746f, 0.00162900f, 0.05376241f, 
    0.21570492f, -0.15844393f, 0.06031489f, 0.30549279f, 0.05501071f, -0.08024758f, -0.02204334f, -0.06650198f, 
    0.02420005f, -0.09062529f, -0.03603121f, -0.01717707f, 0.07708976f, -0.04145597f, 0.31478626f, -0.07129024f, 
    -0.07321516f, 0.05682826f, -0.08109292f, -0.06467322f, 0.01432170f, 0.00262146f, -0.27616391f, -0.20415255f, 
    -0.12181909f, 0.05788164f, -0.02049153f, 0.23776363f, 0.12598744f, -0.05299138f, -0.05577426f, -0.02831841f, 
    0.04494153f, 0.10805129f, 0.18667564f, 0.03761702f, -0.04152066f, 0.06735636f, -0.12463571f, 0.02125964f, 
    0.02958989f, -0.14374179f, 0.06095809f, -0.06835673f, 0.03200828f, 0.21486947f, 0.23298125f, 0.08275542f, 
    -0.15363643f, -0.08844192f, -0.15081547f, -0.06266300f, 0.03426225f, 0.06470512f, 0.04500487f, 0.10517637f, 
    0.04814680f, -0.03853355f, -0.25849760f, -0.02123686f, 0.37213743f, -0.21850380f, 0.03065659f, -0.00478725f, 
    -0.19846922f, 0.12944363f, -0.05324032f, -0.03168460f, 0.06220662f, 0.08439536f, -0.12333407f, -0.07190480f, 
    -0.43834659f, -0.01275027f, 0.10764584f, 0.11395768f, -0.00860442f, -0.07814867f, 0.06119981f, -0.04043737f, 
    0.09155356f, 0.10138296f, 0.00445452f, -0.01914161f, -0.14096482f, -0.22383252f, 0.06511883f, -0.03040732f, 
    0.00848418f, 0.06676675f, 0.03769823f, 0.00473389f, 0.02549260f, -0.13950446f, 0.16979316f, 0.04249638f, 
    -0.05967698f, 0.06458849f, 0.14790787f, 0.07536614f, 0.06351317f, -0.06401292f, 0.12925273f, 0.04120667f, 
    0.13465817f, -0.03532218f, 0.04413949f, 0.06682465f, 0.16440336f, 0.20353259f, 0.31267205f, 0.02547120f, 
    0.08225484f, 0.09979288f, -0.04585163f, 0.01589582f, -0.02253516f, -0.02725709f, -0.04386820f, 0.05966816f, 
    0.02534838f, 0.19459616f, -0.01219428f, 0.10477199f, 0.11583078f, -0.01098363f, -0.06445180f, -0.08745764f, 
    0.10772412f, 0.19274771f, -0.15557730f, 0.05837467f, 0.32327920f, 0.18254763f, 0.02641093f, 0.21377972f, 
    -0.03510825f, -0.19234665f, 0.08956864f, -0.00215597f, 0.04730652f, 0.17777488f, -0.03049113f, -0.00616258f, 
    -0.09252074f, 0.04762357f, 0.06011286f, -0.19922788f, 0.11885443f, -0.04204456f, -0.12226665f, 0.06591355f, 
    -0.15322581f, 0.19365117f, -0.02296845f, 0.10014547f, 0.09512368f, 0.10164609f, -0.00402863f, 0.13707429f, 
    -0.03770242f, 0.00683069f, -0.05003344f, 0.03289859f, 0.06852791f, -0.05409714f, 0.09509935f, -0.06849265f, 
    0.07988562f, 0.16425785f, 0.11435661f, 0.21311371f, 0.03228329f, 0.00338963f, -0.00795391f, 0.12415940f, 
    0.03877011f, 0.03530372f, 0.04134468f, 0.05049737f, -0.01135792f, 0.06605706f, 0.18529911f, -0.19101289f, 
    -0.12527868f, 0.02805705f, 0.03191012f, -0.01100893f, 0.01825832f, -0.13604040f, -0.09527176f, -0.21066940f, 
    0.05998938f, -0.02137693f, -0.22869752f, -0.04518583f, 0.12080836f, -0.14335135f, -0.03562776f, -0.12729666f, 
    0.12188059f, -0.14603674f, -0.02764422f, -0.09473839f, -0.16628461f, -0.01886383f, 0.16915795f, 0.21281925f, 
    0.10931376f, 0.03952606f, -0.04800199f, -0.02963055f, -0.00670266f, 0.07306980f, -0.04925660f, -0.10574378f, 
    0.10692752f, 0.14535631f, -0.07765513f, 0.08386989f, -0.09683280f, 0.00043651f, -0.02238556f, 0.00447220f, 
    0.11167685f, 0.00873524f, 0.02554002f, 0.01668012f, 0.01096018f, 0.03463922f, 0.08283979f, -0.03163389f, 
    0.06048425f, -0.02925653f, 0.10765323f, 0.00929572f, 0.06140600f, 0.07235645f, -0.01754886f, -0.09667505f, 
    -0.08501721f, -0.02256982f, 0.01417007f, -0.21873829f, -0.07738025f, 0.10195280f, 0.12142451f, -0.13472734f, 
    0.06994109f, 0.13233548f, 0.06990993f, 0.04997922f, -0.09047107f, -0.15504317f, 0.00780502f, 0.02389053f, 
    0.05318924f, -0.00002547f, -0.01510250f, 0.05287806f, 0.03636098f, -0.10914156f, -0.01381266f, 0.06620100f, 
    0.02858413f, 0.08484716f, -0.21934029f, 0.02430334f, 0.00166939f, 0.04637910f, -0.00901978f, 0.10689681f, 
    0.17466316f, 0.13377061f, 0.14718585f, 0.01043471f, -0.02552431f, -0.08403422f, -0.15911476f, -0.24210322f, 
    -0.06279234f, 0.01587570f, -0.04218516f, 0.01915339f, -0.02159637f, 0.06487937f, -0.10445980f, -0.14245240f, 
    0.09244260f, -0.04653132f, 0.05619800f, -0.11898781f, 0.10486020f, 0.11830038f, 0.04308402f, 0.00953935f, 
    -0.05242573f, 0.04880618f, 0.01448411f, -0.08156410f, 0.14859533f, -0.10102363f, -0.00792983f, 0.02848697f, 
    -0.01347403f, 0.06953675f, 0.04197716f, 0.01229352f, 0.04290103f, -0.02727531f, 0.01935201f, 0.09867168f, 
    0.25002560f, -0.13535477f, -0.15779868f, -0.08493458f, -0.01741385f, -0.05590495f, 0.01580378f, -0.03651828f, 
    -0.02131123f, -0.07758720f, 0.15312000f, 0.19378030f, -0.10609033f, 0.31951022f, 0.05178838f, -0.08273306f, 
    0.08501624f, 0.02677118f, 0.05058433f, 0.02958767f, 0.01115384f, 0.15167439f, 0.07103818f, 0.00856704f, 
    -0.24042545f, -0.02623831f, -0.09155121f, -0.13420905f, -0.02250585f, -0.09529693f, 0.05866174f, -0.01701527f, 
    0.06675400f, 0.04987580f, 0.22240424f, -0.07964095f, 0.09241985f, 0.09419849f, -0.04416291f, -0.13460313f, 
    0.04793421f, -0.00995324f, 0.14942640f, -0.10714314f, -0.06021893f, 0.15824640f, -0.02861427f, 0.09693999f, 
    0.13911638f, 0.00664228f, -0.04168063f, -0.18140933f, -0.03329055f, 0.06577625f, -0.00011077f, -0.07659055f, 
    0.08176959f, -0.10657547f, -0.02023723f, -0.03121163f, 0.02578110f, -0.22402436f, 0.11501854f, 0.04464082f, 
    0.10649168f, -0.09253855f, -0.03895038f, 0.16928227f, 0.09668549f, -0.01765384f, 0.06374810f, 0.03637844f, 
    0.02283538f, -0.13983609f, -0.08352429f, -0.01282012f, 0.11559390f, 0.08105845f, -0.02739620f, -0.10547696f, 
    -0.06287813f, -0.03541819f, -0.01476408f, -0.08330964f, 0.09870927f, 0.06442166f, 0.18444626f, -0.05874300f, 
    0.20622426f, -0.06450507f, 0.07188419f, 0.01350059f, 0.01921983f, -0.17363924f, -0.12110955f, 0.03261368f, 
    -0.12606314f, -0.13385262f, -0.09256621f, -0.00922442f, 0.12829868f, -0.02352690f, 0.04435436f, -0.06716606f, 
    0.04227641f, -0.06445332f, -0.06694228f, 0.12532921f, 0.01011476f, -0.16498719f, -0.01372566f, 0.29523972f, 
    0.02573562f, -0.00336611f, -0.05728542f, 0.04695084f, 0.03880728f, 0.13992183f, -0.17840789f, 0.22753367f, 
    0.15655033f, 0.11772443f, 0.17082806f, 0.14964807f, 0.01493086f, 0.09297637f, -0.11055578f, 0.04145247f, 
    0.13622734f, -0.10919606f, -0.00339006f, -0.03300332f, 0.09190542f, -0.18521225f, 0.01044651f, 0.05626201f, 
    -0.06642188f, 0.07387253f, -0.06155597f, 0.20857875f, 0.13038325f, 0.03259445f, 0.08498325f, -0.01375856f, 
    0.52462542f, -0.08146241f, -0.00978530f, 0.21204199f, 0.06094310f, 0.09042133f, -0.03499039f, -0.01072763f, 
    0.01289949f, -0.14412749f, 0.08818398f, 0.02527468f, -0.05320487f, 0.08983910f, -0.02337796f, -0.28833413f, 
    0.03776451f, 0.00059172f, 0.07725154f, -0.08656232f, -0.02245840f, 0.12280334f, -0.01369199f, 0.13939801f, 
    -0.02851531f, 0.21515787f, -0.01374248f, 0.21049634f, 0.03472152f, 0.05598715f, -0.01312187f, -0.01918572f, 
    -0.08115008f, -0.06179894f, 0.18043728f, -0.01337335f, -0.24447733f, -0.05623061f, -0.12550345f, 0.01119280f, 
    0.02172650f, 0.00487843f, -0.03153362f, 0.09700654f, -0.05496031f, -0.00543936f, -0.19701260f, -0.10385092f, 
    0.19154526f, 0.14964393f, 0.14470564f, 0.05176729f, 0.13194849f, 0.02873362f, 0.11173048f, 0.07946011f, 
    -0.03865381f, 0.08039161f, -0.00931206f, 0.00214169f, -0.10020409f, 0.05028244f, 0.04823128f, -0.16634701f, 
    0.14882885f, 0.14030620f, 0.00431921f, -0.08422988f, 0.02312367f, 0.11761633f, 0.10907998f, 0.01166789f, 
    -0.01251402f, -0.15599585f, 0.04044952f, 0.23251131f, -0.09054667f, -0.06789905f, -0.13028696f, 0.03680199f, 
    0.05103996f, 0.20334001f, 0.11637469f, 0.03583185f, -0.49996555f, 0.03595641f, 0.06368516f, -0.08435540f, 
    0.06900904f, 0.03893472f, 0.12602267f, -0.02109673f, 0.04705146f, 0.09666787f, 0.11764932f, 0.02689019f, 
    -0.12845266f, -0.22746877f, 0.04210509f, 0.03204806f, 0.06802789f, -0.04555877f, -0.01203023f, -0.07501965f, 
    0.00505442f, -0.10955822f, -0.03816311f, -0.03933930f, 0.08465847f, -0.09703533f, -0.02655420f, 0.01918445f, 
    0.12908287f, -0.04892309f, 0.00195004f, -0.13717346f, -0.06139846f, -0.07046107f, -0.17824396f, -0.02285383f, 
    0.23431571f, 0.08507861f, 0.09065764f, 0.19104354f, -0.07296537f, 0.13078451f, 0.07680842f, 0.04957388f, 
    -0.08274995f, 0.06898401f, 0.05876298f, 0.02524202f, -0.22560044f, 0.03653655f, -0.09855191f, 0.10721949f, 
    0.08780219f, 0.04101830f, 0.01342200f, -0.03172146f, 0.04522069f, 0.04558096f, -0.05352168f, -0.01580102f, 
    0.05700111f, -0.01165964f, -0.08868367f, 0.00311745f, -0.03377263f, -0.03161953f, -0.09673688f, -0.02472224f, 
    0.00835778f, -0.01574106f, 0.06026964f, -0.08318205f, 0.15759368f, 0.13495567f, 0.23510429f, 0.13711043f, 
    -0.04268989f, -0.14643241f, 0.13323915f, 0.02202631f, 0.06717997f, 0.06273887f, 0.04732274f, 0.00916485f, 
    -0.00053116f, 0.12458437f, -0.05177980f, 0.09814832f, -0.11767961f, 0.00562589f, 0.01000338f, 0.00513864f, 
    0.10058823f, -0.07000171f, 0.02973366f, 0.03894603f, 0.27830592f, -0.13120311f, -0.11437901f, 0.07764096f, 
    -0.06471800f, -0.01397798f, 0.03992635f, -0.10971894f, 0.10947937f, -0.01953684f, -0.01205892f, -0.01067389f, 
    0.03151172f, -0.03752308f, -0.06049880f, -0.07154971f, -0.01292569f, 0.06050330f, -0.05999982f, -0.01435500f, 
    0.02000215f, -0.01601617f, -0.02556109f, -0.05525099f, -0.05731811f, -0.05758014f, -0.05248674f, -0.00514691f, 
    0.14531501f, -0.00567133f, 0.00278194f, 0.09232999f, 0.06720145f, 0.01820551f, -0.04448009f, 0.06052032f, 
    0.04034860f, 0.02942053f, 0.01967137f, -0.10442730f, 0.02388046f, -0.03871568f, 0.00034958f, -0.04145908f, 
    -0.08043291f, -0.04761746f, 0.06277616f, -0.03452296f, 0.32167092f, 0.02647799f, 0.01491749f, 0.14358106f, 
    -0.06104322f, 0.08643212f, 0.00820828f, 0.08576768f, -0.01923838f, 0.02611468f, 0.10593301f, 0.02912856f, 
    0.23445894f, -0.05169368f, -0.29309502f, -0.00660847f, 0.00283897f, 0.04003912f, 0.02532086f, -0.05190940f, 
    -0.02477675f, 0.00072068f, 0.07772786f, -0.02182456f, -0.25220186f, 0.02864134f, 0.07952221f, 0.11652731f, 
    -0.03940255f, 0.02591397f, 0.03140282f, -0.01442888f, -0.08691149f, 0.07741419f, 0.04185373f, -0.06945322f, 
    0.25763029f, 0.18390435f, 0.11255580f, 0.15295386f, -0.14132531f, 0.05382857f, 0.07158656f, 0.02558360f, 
    0.08635715f, -0.03620935f, 0.09639860f, -0.04280310f, 0.08378284f, 0.02539748f, 0.15252256f, 0.17452711f, 
    0.01694890f, 0.09646609f, -0.14363568f, 0.03238149f, 0.01307680f, 0.04933947f, -0.09884539f, -0.00441020f, 
    0.29694018f, 0.26503700f, 0.17811245f, 0.03679197f, 0.01911315f, -0.04971113f, 0.02412490f, 0.06862741f, 
    0.06966878f, 0.15416272f, -0.03026063f, -0.03429232f, -0.21003325f, -0.10269774f, -0.07363643f, 0.03238057f, 
    0.11899415f, -0.05091533f, 0.03303056f, 0.00651398f, 0.16813423f, -0.06134669f, -0.02662535f, 0.07788359f, 
    0.33787525f, 0.20649509f, 0.18991336f, 0.10863704f, -0.03960359f, -0.09483998f, 0.09225037f, 0.05511963f, 
    0.04102700f, 0.07298599f, 0.02396756f, -0.03910139f, 0.20047660f, 0.10477441f, 0.07442466f, -0.09072905f, 
    0.11773007f, 0.00994517f, -0.00045975f, 0.03859736f, 0.03388942f, 0.04471754f, -0.01537676f, 0.03399793f, 
    0.30926555f, 0.33838037f, -0.18405157f, 0.09642619f, -0.03155501f, 0.12087563f, 0.04429076f, 0.00787125f, 
    -0.04483414f, -0.06223563f, -0.02880037f, 0.02234061f, 0.04414552f, 0.28810418f, -0.02050395f, -0.13338231f, 
    0.01420389f, 0.03894106f, 0.02775056f, -0.02611770f, -0.05268180f, -0.07854988f, -0.07493895f, 0.06901950f, 
    -0.02697551f, -0.13733749f, -0.00609255f, -0.18607971f, -0.02507971f, 0.13774897f, 0.08423750f, 0.00796539f, 
    -0.02558880f, -0.02253209f, -0.05967479f, 0.01157353f, 0.25434497f, 0.11814539f, 0.06065474f, 0.06033246f, 
    0.04168129f, -0.06514535f, 0.05179283f, 0.11383633f, -0.00862976f, 0.09456532f, 0.01008239f, 0.12888999f, 
    -0.27544904f, 0.17155835f, -0.00846090f, -0.09440492f, -0.06893464f, -0.03510216f, 0.08983997f, 0.04690087f, 
    -0.11434213f, 0.02648347f, -0.03632462f, -0.00025609f, 0.10314517f, 0.04817004f, 0.14642127f, -0.03361326f, 
    0.13373584f, 0.00265134f, -0.07744501f, -0.13768990f, 0.04321054f, -0.03402479f, 0.02066566f, -0.12627672f, 
    0.18056628f, 0.21717256f, 0.19530568f, 0.06644271f, -0.02316155f, -0.03530452f, 0.03140378f, 0.03845373f, 
    -0.01042938f, -0.00218737f, 0.00170178f, -0.02920872f, -0.05335563f, 0.01404104f, -0.11626555f, 0.10367739f, 
    0.03884102f, 0.04849594f, 0.02427305f, 0.10748863f, 0.01530898f, 0.06284779f, 0.01046626f, -0.01651232f, 
    0.41312370f, -0.01320337f, 0.11874463f, -0.02463014f, -0.04033864f, -0.02261810f, 0.23690863f, -0.15381192f, 
    0.03663997f, 0.05082806f, 0.04256580f, 0.00930070f, 0.35787529f, -0.07542260f, -0.00227870f, -0.09417163f, 
    0.15232584f, 0.01154364f, -0.00387593f, 0.03207774f, 0.08724976f, 0.11116426f, -0.01329295f, 0.11508469f, 
    0.08172478f, 0.07317083f, -0.22102426f, 0.09950792f, 0.15598026f, 0.05282741f, 0.01100184f, 0.18178037f, 
    0.04765591f, -0.00134088f, -0.04946119f, -0.02918563f, 0.02971536f, 0.21285151f, 0.05743015f, 0.31260633f, 
    -0.03624176f, 0.10412630f, 0.02308344f, 0.04497845f, 0.06487872f, 0.05874169f, 0.02574583f, 0.08414507f, 
    -0.04899270f, -0.02376521f, 0.04890042f, 0.05218402f, 0.04857173f, -0.00336141f, 0.05209785f, 0.03005752f, 
    0.09968095f, 0.01582246f, 0.00471697f, 0.07553171f, -0.21425149f, -0.10188341f, 0.00117142f, -0.17227599f, 
    0.00600075f, 0.05442306f, 0.02289158f, -0.00831831f, -0.00758750f, 0.14385134f, 0.07758584f, -0.02080878f, 
    0.16208576f, -0.19754620f, -0.28006151f, 0.14242409f, 0.00140012f, -0.01112509f, -0.03276006f, -0.02420621f, 
    0.14081433f, 0.11544554f, 0.00784271f, -0.08579127f, -0.22549860f, -0.03737148f, -0.19210131f, 0.09161731f, 
    -0.11379278f, 0.11557298f, 0.00391777f, -0.06560446f, -0.05916615f, 0.02163750f, 0.02052695f, 0.05607986f, 
    0.41089192f, -0.08832868f, 0.06445701f, -0.06126434f, 0.03047641f, 0.01503162f, -0.05715871f, 0.00922349f, 
    0.06194580f, 0.04159234f, 0.07410313f, 0.04114265f, -0.12304538f, -0.14055957f, 0.03898719f, -0.15757962f, 
    0.05633238f, 0.01529005f, -0.05360648f, 0.09054877f, 0.10630306f, -0.12381648f, -0.05843253f, 0.16746311f, 
    -0.23303656f, -0.19287266f, 0.20520650f, -0.30215433f, -0.00250635f, 0.06865535f, -0.02021728f, 0.01802837f, 
    0.01889525f, 0.00234947f, 0.02605886f, -0.07087846f, 0.32859945f, 0.11416786f, 0.11386676f, 0.04469619f, 
    0.07980443f, -0.10660313f, 0.03767233f, 0.08724199f, 0.00756003f, -0.06101319f, 0.18439178f, -0.06299083f, 
    -0.21418197f, 0.07350581f, 0.09418338f, -0.11327207f, 0.02643026f, 0.01296322f, 0.04132807f, 0.03149093f, 
    -0.04303129f, -0.01482218f, 0.02288624f, 0.00941666f, -0.02529282f, -0.12877692f, -0.00249175f, -0.28587493f, 
    0.06823576f, -0.07143581f, 0.08019989f, -0.00722949f, -0.08783146f, -0.02222759f, 0.04028685f, 0.08433560f, 
    -0.22294450f, -0.17546806f, -0.13224846f, -0.05695163f, 0.05532908f, 0.03945698f, 0.07817572f, 0.03541612f, 
    -0.01357415f, 0.00799664f, -0.00555718f, 0.06546274f, 0.08019049f, -0.09644370f, 0.09556571f, -0.21516223f, 
    -0.01349678f, 0.00276335f, -0.08417922f, 0.04944428f, -0.04561452f, -0.08471083f, 0.00147032f, -0.00801830f, 
    0.23854505f, -0.17053403f, -0.14871311f, -0.02033893f, -0.04512805f, 0.03499569f, -0.00760228f, -0.05234567f, 
    0.11607595f, -0.01423094f, 0.07530942f, 0.00066188f, -0.00392967f, 0.26697597f, 0.08356889f, 0.02508024f, 
    -0.11679705f, 0.03777119f, 0.05125488f, -0.10046069f, 0.01564065f, -0.04577669f, -0.06367312f, 0.10112592f, 
    -0.35696274f, -0.09628583f, 0.17415838f, -0.38501418f, -0.03074782f, -0.09667745f, 0.15165006f, -0.01171841f, 
    -0.02617448f, -0.02143109f, 0.03384042f, -0.01729330f, -0.30253679f, -0.04542143f, 0.08230382f, -0.03684451f, 
    -0.01576231f, 0.07884128f, 0.02407388f, -0.03217464f, -0.00044584f, 0.00395284f, -0.03130787f, -0.01078818f, 
    0.12841748f, -0.15800577f, 0.07024519f, -0.17254904f, 0.04065686f, -0.10427044f, -0.00723499f, 0.13064979f, 
    -0.02649953f, 0.02827070f, 0.04512310f, 0.01883101f, 0.26435381f, 0.08083773f, 0.36618540f, -0.02045284f, 
    -0.01592341f, -0.06050328f, 0.10435653f, 0.04206436f, -0.01469213f, 0.04584963f, 0.01614399f, -0.07976587f, 
    0.04348495f, -0.09667179f, -0.01754464f, -0.20616679f, 0.06954855f, 0.03607788f, 0.08026412f, -0.02838165f, 
    -0.01704237f, 0.00523106f, 0.00439699f, 0.11754076f, -0.11103047f, -0.22874294f, -0.13584575f, 0.06944793f, 
    0.16021214f, -0.03061248f, 0.00515747f, 0.02612625f, 0.00066218f, -0.07831588f, -0.07538576f, -0.03073938f, 
    0.20660540f, 0.08708570f, 0.18702406f, -0.00025973f, -0.12971108f, -0.05770524f, -0.00080268f, 0.06676590f, 
    -0.09921753f, -0.08999908f, 0.02860273f, -0.01355264f, -0.08601423f, 0.02487371f, 0.00320231f, 0.22816250f, 
    -0.06187245f, 0.08497635f, -0.02120328f, 0.00549622f, 0.01898243f, -0.00495233f, -0.07216983f, 0.11660789f, 
    0.15233782f, 0.06539868f, -0.16564199f, 0.08750645f, 0.25486121f, 0.07644144f, 0.03996486f, 0.11419100f, 
    0.12597173f, -0.01982229f, 0.01458509f, 0.17990047f, -0.06516622f, -0.11328478f, -0.18413787f, -0.01737902f, 
    -0.02156007f, -0.01747089f, 0.06996013f, 0.00116724f, 0.05193084f, 0.00955592f, -0.00764790f, 0.07716630f, 
    0.29499051f, 0.11488126f, 0.18530734f, 0.17568733f, 0.08536985f, 0.00931721f, 0.08987880f, 0.02960942f, 
    0.03022746f, 0.10202524f, 0.03993636f, 0.05922684f, -0.30573401f, -0.12028495f, 0.00222588f, -0.25996631f, 
    0.01529657f, 0.06746295f, 0.11687072f, -0.10060286f, -0.03418845f, 0.00499456f, 0.00232291f, 0.06081636f, 
    0.34910434f, 0.31972945f, 0.05041956f, 0.10296857f, -0.03412286f, 0.00577298f, 0.10081550f, 0.04944550f, 
    -0.07849253f, 0.13100447f, -0.01921922f, 0.08665688f, -0.41910008f, -0.09941360f, 0.12064028f, -0.17487480f, 
    0.10577270f, 0.05513573f, 0.11611804f, 0.03778620f, 0.00891301f, 0.04016265f, -0.06895194f, -0.14738655f, 
    0.10965904f, 0.09733006f, -0.15673739f, 0.01443561f, 0.13887227f, 0.01244493f, 0.01726937f, 0.16345310f, 
    -0.02059904f, 0.04575532f, -0.08478311f, 0.06416265f, -0.04288084f, 0.21395160f, 0.11611712f, -0.21372285f, 
    0.05775327f, 0.03205451f, 0.09330308f, -0.02662408f, -0.12647641f, 0.01796917f, 0.05129813f, 0.03352601f, 
    0.30499089f, 0.10311837f, 0.16564086f, -0.06211373f, -0.01343601f, -0.08999591f, 0.02973851f, 0.01558757f, 
    -0.05223762f, 0.09767251f, 0.01438002f, 0.00947955f, -0.23614711f, 0.09306677f, 0.29450542f, -0.03132593f, 
    -0.05008736f, -0.01406456f, 0.18872580f, -0.07770457f, -0.12127879f, -0.09045491f, 0.02851256f, 0.00393848f, 
    0.36327407f, 0.21849903f, 0.20620468f, -0.09626442f, -0.11889253f, -0.04046085f, 0.08771494f, 0.01562786f, 
    -0.07022651f, 0.08365068f, 0.01743401f, -0.03910616f, 0.14270185f, -0.17186311f, 0.23485233f, -0.23087306f, 
    -0.05992471f, -0.01556955f, 0.13795176f, 0.02453658f, 0.07590079f, -0.01954484f, 0.00678888f, 0.04095273f, 
    -0.09457104f, -0.12857305f, 0.11029775f, -0.01789434f, 0.10613363f, -0.10830491f, 0.03010782f, -0.11611100f, 
    0.06469470f, -0.02783747f, -0.04098758f, -0.05436553f, 0.10470813f, 0.19399276f, 0.15787989f, -0.00445336f, 
    0.18874441f, -0.02141862f, 0.05667965f, 0.07868242f, -0.10848635f, -0.00440070f, 0.07666586f, -0.04019858f, 
    -0.39840156f, 0.19208127f, -0.03231783f, 0.07932742f, 0.05615275f, 0.10725099f, -0.00685796f, 0.06835190f, 
    -0.03557866f, 0.19994098f, 0.03617468f, 0.04225338f, -0.01012894f, -0.24922772f, 0.01237106f, 0.10080244f, 
    0.03548722f, -0.13229471f, -0.01592574f, -0.10072291f, -0.09438454f, 0.08391640f, -0.07274849f, -0.19087358f, 
    0.07918789f, -0.24281067f, -0.01938345f, 0.29477921f, -0.04409237f, -0.07159113f, 0.00938703f, -0.07341240f, 
    0.25885919f, 0.10435152f, 0.08687575f, 0.08840199f, -0.06400654f, -0.16217978f, 0.08547225f, 0.03914724f, 
    0.00551129f, -0.05012637f, -0.07877570f, 0.03622425f, 0.11119656f, 0.02313362f, -0.04306865f, 0.07736145f, 
    0.08613143f, 0.14623860f, 0.14096636f, -0.04344453f, -0.07901994f, -0.04936703f, -0.05189312f, -0.04550179f, 
    0.00996682f, 0.10043405f, -0.00577081f, 0.12893310f, 0.02295652f, 0.09237267f, 0.28694266f, 0.19331293f, 
    0.21628879f, -0.00407840f, 0.03786066f, 0.09310121f, 0.03105243f, 0.00324821f, 0.16876931f, -0.02509741f, 
    -0.05433203f, -0.27201384f, 0.00594191f, 0.00435215f, -0.08703386f, -0.12807436f, -0.16463493f, -0.09506712f, 
    -0.11173871f, -0.11487725f, 0.14249557f, -0.02149977f, 0.04303421f, 0.27733469f, -0.27939728f, 0.03787483f, 
    0.11009561f, 0.02056831f, 0.07621728f, 0.05077834f, -0.04467012f, 0.05138942f, 0.04095797f, -0.02495873f, 
    0.21741745f, -0.34944752f, 0.11017777f, 0.33671823f, -0.08456731f, -0.05789950f, -0.09814719f, 0.02903653f, 
    0.01757914f, 0.03870521f, 0.14372222f, -0.00141878f, -0.55957514f, 0.03639305f, 0.12733130f, -0.00983747f, 
    -0.00494498f, -0.13199280f, 0.05143818f, -0.11672109f, 0.02597725f, 0.07141113f, 0.00247950f, -0.08148311f, 
    0.09456444f, -0.08722710f, -0.18880157f, 0.08826256f, 0.11285643f, 0.06346069f, 0.01653106f, -0.05866947f, 
    0.11223590f, -0.00030853f, -0.08385755f, -0.01403726f, 0.05767156f, 0.42253208f, 0.01726526f, 0.33482090f, 
    0.03462537f, 0.08076321f, 0.05025001f, -0.06463782f, 0.06202962f, 0.04743044f, 0.02929249f, 0.00240500f, 
    0.07327146f, 0.14259346f, -0.01523253f, 0.14096645f, 0.09737390f, 0.02850893f, 0.03326413f, -0.01997284f, 
    -0.05601590f, -0.04578340f, 0.02092806f, 0.05801838f, 0.18505971f, 0.06644100f, 0.05387402f, 0.26994082f, 
    0.07584652f, 0.18234749f, -0.10389267f, 0.06296048f, -0.03830088f, -0.01229781f, 0.07536080f, 0.05561703f, 
    -0.02800252f, 0.00521448f, -0.07737419f, -0.15074307f, 0.09936750f, -0.00787277f, 0.05964226f, 0.01446838f, 
    0.00854422f, -0.05713386f, -0.01970105f, -0.06653754f, 0.09405212f, 0.38472435f, -0.19873998f, 0.00735750f, 
    -0.03508756f, 0.06315594f, 0.05804792f, 0.00271448f, -0.06121907f, -0.01833676f, 0.14321885f, -0.08391999f, 
    0.17319760f, -0.10461621f, -0.17029130f, 0.02288680f, 0.05793256f, 0.06029660f, 0.09490056f, 0.07136625f, 
    -0.06324172f, 0.00430814f, -0.00810527f, 0.02464122f, -0.05854085f, -0.06995729f, 0.01167201f, -0.16067834f, 
    -0.08712474f, -0.09328051f, -0.13592657f, 0.04138283f, 0.01675157f, 0.03773431f, -0.09014470f, 0.08046667f, 
    -0.10753337f, 0.02518655f, 0.09893236f, -0.11702922f, 0.03772623f, -0.05213713f, 0.17068203f, 0.04941564f, 
    0.16920288f, 0.02551570f, 0.00956455f, -0.00587530f, 0.30712652f, 0.30487615f, -0.02405204f, -0.05339846f, 
    0.03551054f, 0.02292710f, -0.03638291f, 0.04658399f, 0.01565624f, 0.03299065f, -0.02422584f, -0.01971374f, 
    0.14449921f, 0.06573150f, -0.03705569f, -0.06027038f, -0.11018454f, 0.00925829f, 0.01196256f, -0.04512491f, 
    -0.09780017f, -0.08883579f, 0.04147490f, -0.14111353f, 0.39477193f, 0.20175010f, -0.03915881f, -0.02591926f, 
    0.12656486f, -0.01209310f, -0.04380224f, -0.04904132f, -0.09263784f, -0.12493711f, 0.08369566f, -0.00259952f, 
    0.04961805f, 0.07647245f, -0.08701310f, -0.17125225f, 0.04538109f, 0.14158460f, -0.05026610f, -0.03242153f, 
    -0.01432728f, -0.09127900f, 0.00324610f, -0.07864225f, -0.09310652f, -0.16214029f, 0.03386945f, 0.14350055f, 
    0.13001332f, 0.02128414f, -0.01685727f, 0.10393372f, 0.01366021f, 0.02196665f, -0.06782465f, -0.00347997f, 
    0.23446760f, -0.11989720f, 0.15078858f, -0.08282371f, -0.03743225f, -0.05599247f, 0.09883149f, 0.00758513f, 
    0.04917643f, 0.02843444f, -0.11950971f, 0.05154258f, 0.14952974f, 0.07356123f, 0.29136264f, -0.06362184f, 
    0.22593138f, 0.11210705f, 0.02371492f, 0.02858940f, 0.11312099f, -0.08890709f, 0.09504237f, 0.06084314f, 
    0.19421121f, 0.00599560f, -0.00893038f, 0.20664778f, -0.00624154f, 0.00972744f, 0.02940006f, -0.07813960f, 
    0.20442748f, 0.04364790f, 0.12708506f, -0.00608041f, -0.10675181f, 0.08532483f, -0.00544023f, 0.17577024f, 
    0.06790822f, 0.01905829f, -0.03489332f, -0.11168757f, -0.07560974f, 0.04900247f, -0.10866395f, -0.09364777f, 
    -0.02972799f, -0.08069582f, 0.14614986f, -0.01365122f, 0.11334670f, 0.08843022f, 0.04706608f, -0.03672775f, 
    0.04428631f, -0.06887927f, 0.07782684f, 0.07053369f, -0.05523226f, 0.18219157f, 0.18291631f, 0.11881916f, 
    0.10489693f, 0.23326164f, 0.03569923f, 0.06345741f, -0.00348763f, 0.10080646f, 0.10114817f, -0.09813183f, 
    -0.02727054f, -0.08330483f, 0.14830016f, 0.18129180f, 0.07518610f, -0.04351681f, -0.04349915f, 0.07090427f, 
    0.07061715f, 0.01642808f, -0.19064948f, 0.06102710f, 0.06279596f, -0.10905752f, -0.03979516f, 0.14800787f, 
    -0.19892359f, -0.04808732f, -0.00230377f, -0.00215444f, -0.02697422f, -0.03049560f, -0.01124754f, 0.09337441f, 
    0.38752031f, 0.05482769f, 0.16457334f, -0.12437005f, 0.19466956f, 0.01691401f, -0.01042621f, -0.01910685f, 
    0.03150479f, 0.03009585f, 0.02616613f, 0.03230747f, -0.15290381f, 0.02354508f, -0.05565432f, 0.06774034f, 
    -0.01372301f, 0.06148527f, 0.06273360f, 0.05891336f, -0.00580081f, -0.00151774f, -0.03029600f, -0.04074419f, 
    -0.17169388f, 0.00257886f, 0.11014866f, 0.04953996f, 0.11761284f, -0.15347235f, -0.01048264f, 0.12365085f, 
    0.05594146f, 0.07953729f, 0.04568620f, 0.04365115f, 0.52323884f, -0.10545786f, -0.03392977f, -0.15317944f, 
    0.01983942f, 0.11425669f, -0.00595448f, -0.03769390f, 0.11964237f, 0.06970167f, 0.16535103f, 0.00787567f, 
    0.20785296f, 0.13373770f, 0.20921965f, -0.19185580f, 0.06073309f, -0.02866386f, 0.08931113f, -0.14129606f, 
    -0.03397560f, -0.06448403f, 0.08428767f, 0.15951991f, -0.16828878f, 0.11999623f, 0.15169905f, -0.03136852f, 
    -0.06028201f, 0.01761377f, 0.05633841f, -0.10050368f, 0.04436806f, 0.06776017f, 0.04662143f, 0.03476158f, 
    -0.09434155f, -0.03974741f, 0.09248815f, 0.35995856f, -0.06713238f, -0.00784990f, 0.06362837f, 0.05189114f, 
    0.01247501f, 0.01877627f, -0.03462233f, 0.07007144f, -0.28330806f, 0.27424437f, 0.00780424f, 0.08980770f, 
    -0.09159137f, -0.04605780f, 0.00522934f, -0.07039152f, 0.01977212f, -0.02468702f, -0.06249585f, -0.04733562f, 
    -0.20545490f, -0.07908945f, -0.07247096f, -0.01415496f, -0.03619831f, 0.04068027f, -0.04647888f, 0.06771658f, 
    0.12421440f, 0.04025487f, 0.09212292f, -0.00246640f, -0.19154869f, -0.00566975f, 0.04415728f, -0.01093565f, 
    -0.07782038f, 0.04260538f, -0.06826884f, 0.03199472f, 0.06184996f, -0.06090350f, -0.12686160f, 0.20810518f, 
    -0.22675946f, 0.10431179f, 0.10433703f, -0.20812424f, -0.13528180f, -0.12375420f, 0.01785887f, -0.04715366f, 
    0.05487403f, 0.07332364f, -0.04904892f, 0.09493759f, -0.08444717f, 0.06814606f, 0.16985863f, 0.14436172f, 
    0.04130851f, 0.01916087f, -0.05235215f, 0.04445038f, 0.18054193f, -0.04753821f, 0.08036384f, 0.07228607f, 
    -0.29682305f, 0.21977180f, 0.06639199f, 0.06028286f, -0.05809141f, 0.01028606f, -0.05501208f, 0.06505115f, 
    0.01454672f, 0.15885985f, -0.04173255f, 0.12239625f, 0.08669070f, -0.11985495f, -0.05176715f, 0.04182499f, 
    0.09423640f, 0.04980185f, -0.11775499f, -0.01152562f, -0.01683140f, -0.01298124f, -0.04730711f, -0.08860942f, 
    0.31217909f, 0.07188310f, 0.05812910f, 0.02494074f, -0.08690432f, -0.09506822f, -0.09573098f, -0.01979829f, 
    -0.11182395f, -0.10649905f, 0.07779404f, -0.01012011f, -0.12343283f, -0.07224660f, -0.03048540f, 0.25601250f, 
    0.02541035f, 0.05094475f, 0.10554077f, 0.09367692f, -0.03778020f, 0.02421143f, -0.09962031f, -0.02823526f, 
    -0.14812297f, -0.08046769f, -0.04022228f, 0.03214967f, -0.08993821f, 0.08226492f, -0.13179842f, 0.01911084f, 
    -0.11111727f, -0.08086391f, 0.13717212f, -0.01796492f, -0.07729851f, 0.14126679f, -0.02648274f, -0.27496594f, 
    -0.09112443f, 0.01706013f, -0.00371550f, -0.03524604f, -0.07900983f, -0.05281837f, 0.04132938f, -0.18416128f, 
    -0.08798754f, 0.30439872f, 0.09752781f, 0.16139537f, 0.10506091f, 0.17109196f, -0.01768689f, 0.02053469f, 
    -0.01991596f, -0.00534990f, -0.08730163f, 0.06714084f, -0.25111964f, 0.37411693f, -0.01265621f, -0.02920403f, 
    -0.05848785f, -0.13185430f, -0.05826311f, -0.12081690f, 0.03721799f, 0.03176957f, -0.10736851f, 0.01548821f, 
    0.15021729f, 0.08896053f, 0.00070861f, 0.04240847f, 0.01294496f, 0.01514623f, -0.06261647f, -0.05303109f, 
    -0.03321216f, 0.10644715f, -0.01578687f, 0.01157386f, -0.14440894f, -0.17469943f, -0.02126355f, 0.08526351f, 
    0.04245878f, -0.01236166f, -0.01203922f, 0.06033176f, -0.01361709f, 0.05559617f, 0.17068712f, -0.05699808f, 
    -0.02918138f, -0.12698938f, -0.06000002f, 0.05199348f, 0.04245689f, 0.03016432f, 0.01557683f, -0.05250371f, 
    -0.03615979f, -0.02286099f, -0.01025363f, -0.00037572f, -0.18624523f, -0.08562950f, 0.07117201f, 0.04654291f, 
    0.01427791f, 0.04393804f, 0.14187184f, -0.13569170f, 0.03156852f, 0.15625700f, 0.16313033f, 0.00789365f, 
    -0.15528619f, 0.05274250f, 0.08993589f, 0.12535678f, 0.01332138f, -0.10108236f, -0.09203733f, -0.06702973f, 
    -0.08092297f, 0.01745207f, -0.04074214f, -0.05841862f, -0.10245892f, 0.17727682f, 0.13864633f, -0.19407721f, 
    0.01418038f, -0.02561990f, -0.04070914f, 0.13576093f, 0.00894012f, 0.00397555f, -0.06154845f, -0.00729722f, 
    -0.14334768f, 0.09010249f, -0.13456030f, 0.02907767f, -0.01518309f, -0.03421456f, 0.00978840f, -0.07412431f, 
    -0.07881477f, 0.04092121f, 0.03159441f, -0.02014556f, 0.10487567f, 0.03478920f, 0.15830083f, -0.04052842f, 
    -0.07346091f, -0.06317119f, 0.01142366f, -0.01335274f, 0.13273250f, -0.13261345f, -0.00412944f, -0.04497965f, 
    0.18463792f, 0.14187340f, -0.14024106f, -0.11235726f, -0.06590323f, 0.03252647f, 0.08746748f, -0.01098607f, 
    0.07303920f, -0.01823311f, 0.01285436f, 0.00458637f, 0.33580020f, -0.13866256f, 0.15324293f, 0.07114201f, 
    -0.11602171f, -0.03875710f, -0.06294812f, -0.00678060f, -0.13328242f, -0.00095980f, 0.01258356f, -0.11537921f, 
    -0.01298314f, 0.00388826f, 0.02468754f, -0.00358166f, 0.01937746f, -0.00028267f, -0.02000463f, 0.01334123f, 
    -0.01215007f, -0.03597973f, 0.01266699f, -0.00406949f, -0.02694334f, -0.04299524f, -0.01034954f, -0.01552376f, 
    0.02374809f, 0.02547397f, -0.02512125f, -0.01364287f, -0.01965597f, -0.02436729f, -0.01204287f, -0.03268443f, 
    -0.00307596f, 0.00819509f, -0.00965933f, -0.01799474f, 0.00039615f, -0.02705192f, -0.03779934f, -0.03784069f, 
    0.03011533f, 0.04008106f, -0.00150798f, -0.02147666f, -0.04160570f, -0.00975402f, -0.00253661f, 0.02525838f, 
    -0.00191309f, -0.00131903f, 0.02148764f, -0.03569048f, 0.01525084f, -0.02872246f, 0.00445207f, 0.02827070f, 
    0.02409993f, -0.02506121f, -0.00230226f, 0.01153810f, -0.00105761f, 0.02376788f, -0.00763628f, -0.02882248f, 
    -0.03394940f, 0.00777674f, 0.00430806f, -0.02515252f, 0.00658060f, 0.02843785f, -0.02118507f, -0.03631800f, 
    -0.01456153f, -0.03424434f, -0.03758406f, 0.01122243f, -0.02996216f, -0.00553530f, 0.00988160f, 0.02380670f, 
    -0.03954560f, -0.00905595f, 0.01988337f, -0.03499153f, -0.02853136f, -0.01998076f, -0.03608926f, -0.02023207f, 
    0.01456999f, 0.00564566f, 0.01943277f, 0.01935977f, -0.02709586f, 0.01363953f, -0.04201022f, 0.00911866f, 
    -0.00361276f, -0.01611822f, 0.01245051f, 0.02215644f, -0.03564494f, -0.02362345f, -0.00292019f, -0.02007113f, 
    -0.00813184f, 0.03204086f, -0.02211560f, 0.02804653f, -0.04282012f, -0.02582704f, 0.02054202f, 0.01118496f, 
    0.02190913f, -0.02329704f, -0.04229010f, -0.00003019f, -0.04291203f, 0.00301377f, 0.00642829f, 0.00380511f, 
    -0.02006028f, 0.02266601f, -0.03826612f, 0.01079978f, -0.02064368f, 0.02013859f, -0.03912704f, -0.03981221f, 
    0.02810358f, 0.02176565f, -0.02954252f, 0.01388275f, 0.02298038f, 0.00928678f, -0.02783709f, -0.02539840f, 
    0.01273141f, 0.01605139f, -0.03453584f, -0.00499461f, 0.01382440f, -0.02628250f, -0.01461455f, 0.01696067f, 
    -0.00186974f, -0.00285414f, -0.01481000f, -0.03236925f, 0.00358340f, 0.00538295f, -0.01610695f, 0.01886625f, 
    0.02870612f, 0.01379444f, 0.00640368f, 0.02258501f, -0.04086493f, -0.00979933f, -0.03579898f, 0.01429128f, 
    0.00393966f, -0.01964821f, 0.01932696f, 0.01333169f, -0.01363102f, -0.01936607f, -0.02308491f, -0.00286096f, 
    0.01463025f, -0.00083366f, -0.02584714f, 0.01925715f, -0.01925251f, 0.02704281f, 0.01158422f, -0.02127368f, 
    -0.03953129f, -0.01077051f, -0.00896571f, 0.00530457f, -0.00533739f, -0.02402414f, -0.02049752f, -0.00461441f, 
    -0.02075753f, -0.01109162f, -0.02691287f, -0.02070319f, -0.00666719f, -0.03208771f, 0.02754463f, 0.01350651f, 
    0.01832731f, -0.03046928f, 0.01039186f, 0.01484494f, -0.00432360f, -0.00119096f, 0.02821925f, -0.00210480f, 
    0.02235292f, 0.02737775f, -0.01210658f, 0.01202650f, 0.02492583f, -0.00422493f, 0.02347733f, -0.02614994f, 
    -0.01929077f, -0.01560224f, 0.00782963f, 0.00958336f, 0.02901789f, 0.00348738f, -0.02339039f, 0.02065066f, 
    0.01117275f, -0.00509878f, 0.02048011f, 0.02504247f, 0.01195650f, -0.02702158f, -0.02275533f, 0.03227460f, 
    -0.03682499f, -0.00657238f, 0.03476327f, -0.04077583f, 0.02732941f, -0.00920099f, 0.00184020f, -0.02788488f, 
    0.01836682f, 0.00996430f, -0.00154643f, -0.03104443f, 0.02648495f, -0.02688451f, -0.01849530f, 0.01808676f, 
    -0.03988725f, -0.03574648f, 0.02663969f, -0.02609781f, -0.00536017f, -0.01210412f, -0.03987913f, -0.00922456f, 
    -0.00443532f, 0.01658844f, -0.04217871f, -0.02494285f, -0.02907369f, -0.00110379f, -0.00858979f, -0.02938430f, 
    -0.00926416f, -0.01758586f, -0.01125104f, -0.01720572f, -0.02099547f, 0.00514026f, -0.03677968f, -0.03791986f, 
    -0.02235840f, -0.02022479f, 0.01148912f, -0.04178933f, -0.01575154f, -0.01630866f, -0.03535031f, -0.00305745f, 
    0.01363980f, -0.01614094f, 0.01940886f, -0.02607615f, -0.01132467f, 0.01631120f, -0.04064494f, -0.00793058f, 
    0.01172279f, -0.00563068f, 0.00452244f, -0.01323698f, -0.02301531f, -0.01709563f, -0.02885105f, -0.00967513f, 
    -0.03477168f, -0.02610449f, -0.01931346f, -0.02899357f, 0.00722770f, -0.01286148f, -0.00207872f, -0.00402747f, 
    -0.03305689f, -0.03679090f, 0.01637078f, -0.00955994f, -0.02016469f, 0.02104007f, -0.02441210f, -0.02035070f, 
    0.00310917f, -0.03008174f, -0.02145072f, -0.01950377f, -0.02024690f, 0.00733406f, -0.00774105f, -0.04281692f, 
    0.01373224f, 0.02526076f, -0.02747193f, -0.03142494f, 0.02000348f, -0.00670257f, 0.01754660f, -0.01406694f, 
    -0.01791488f, -0.03924260f, -0.00221875f, 0.00172661f, -0.02980791f, 0.01879921f, -0.00664984f, -0.02159056f, 
    0.00470374f, -0.03079652f, 0.02198715f, -0.01201793f, -0.02762533f, -0.04046251f, 0.00566759f, 0.00834849f, 
    0.03062433f, -0.00522678f, 0.01625427f, 0.01897489f, -0.02372805f, 0.03008313f, 0.01656113f, 0.02189463f, 
    0.02043158f, -0.00096909f, -0.00716950f, 0.00268783f, -0.03920819f, 0.01258404f, 0.01631464f, 0.00875129f, 
    0.00436850f, -0.00858777f, 0.00360920f, -0.03257970f, 0.03003205f, 0.01294249f, -0.00970368f, 0.02410047f, 
    0.02218771f, 0.00048144f, -0.00058663f, 0.01603492f, -0.01873952f, 0.02759414f, -0.01784051f, 0.01504104f, 
    -0.01518388f, 0.00831712f, 0.01978277f, 0.00419579f, -0.01426477f, 0.01510751f, -0.03486836f, -0.03508849f, 
    0.01069444f, 0.00912599f, 0.03183676f, 0.02360769f, 0.02600054f, -0.02066181f, -0.03808187f, -0.01076398f, 
    0.00753830f, -0.01067884f, 0.03176488f, 0.01657250f, 0.00901830f, -0.00015015f, -0.02562430f, -0.01970049f, 
    0.01036512f, 0.01117693f, -0.03174213f, -0.01415000f, 0.00539632f, -0.00688084f, 0.03718351f, 0.02344112f, 
    0.00610545f, -0.01018132f, 0.02512734f, -0.00809700f, -0.01684024f, -0.01892714f, -0.03580519f, -0.00889794f, 
    -0.01082168f, -0.01151588f, -0.02134610f, -0.01986937f, 0.00449190f, 0.00363393f, -0.03289310f, -0.01864997f, 
    0.02212755f, -0.04142433f, 0.02066585f, 0.01710791f, -0.02201318f, -0.01230098f, -0.02271587f, 0.00421440f, 
    0.01854403f, 0.01078515f, -0.03393205f, -0.01488958f, -0.03256373f, -0.02877063f, 0.01968721f, -0.01879233f, 
    -0.04206603f, -0.04052275f, 0.02914896f, 0.01021222f, -0.03189530f, -0.00041973f, 0.00798282f, 0.01985163f, 
    -0.01744510f, 0.01809033f, -0.02271007f, -0.03233046f, 0.00763577f, 0.00485852f, -0.01537224f, -0.04106050f, 
    -0.00524239f, 0.00489079f, -0.02503665f, 0.01218546f, -0.03409577f, -0.04186588f, 0.02811603f, 0.00620601f, 
    -0.02145964f, 0.02526536f, -0.01642699f, 0.02014750f, 0.01509255f, -0.03922684f, -0.01437042f, -0.01247067f, 
    -0.00192928f, -0.03387574f, -0.02015165f, 0.02199669f, -0.01209631f, -0.00151011f, 0.00583305f, -0.00513651f, 
    0.01924723f, 0.01872136f, 0.00669305f, -0.00675294f, 0.02640473f, 0.01090312f, 0.02405213f, 0.01687543f, 
    -0.01908588f, -0.00112170f, -0.01641293f, 0.01147471f, 0.02859833f, -0.01882351f, 0.02133892f, 0.02308488f, 
    0.00729876f, 0.00129152f, 0.02577596f, -0.02121958f, 0.02168964f, 0.00238865f, 0.02920020f, -0.01178551f, 
    -0.02478222f, -0.02688288f, 0.00536038f, -0.00272194f, 0.02480540f, -0.00665850f, -0.01161930f, -0.01430937f, 
    0.02277111f, -0.00906675f, 0.02416836f, 0.02465102f, -0.00330030f, -0.04140341f, -0.04106541f, -0.03860610f, 
    -0.02823270f, -0.00758265f, -0.03401612f, -0.01935547f, 0.01346952f, 0.00995398f, -0.02102916f, 0.01922439f, 
    0.01013544f, 0.01805277f, 0.02238061f, -0.03049559f, -0.00935142f, -0.01607835f, 0.02755461f, -0.00996826f, 
    -0.04053432f, -0.01578023f, -0.01911128f, -0.03054495f, -0.02471245f, 0.02499211f, -0.00987497f, -0.03494516f, 
    -0.02837639f, -0.00484435f, 0.01194834f, 0.01931043f, -0.01606097f, 0.02373157f, 0.01098487f, 0.00064819f, 
    -0.00918678f, -0.04022836f, -0.03481282f, 0.01858752f, -0.03075794f, -0.01755263f, -0.03744766f, 0.00930299f, 
    0.01204753f, -0.03481165f, 0.00428593f, 0.02853473f, 0.00200598f, 0.00125934f, -0.01917826f, -0.00270413f, 
    -0.01908950f, -0.04064325f, 0.01877138f, 0.00923828f, -0.00046260f, -0.01752803f, -0.03377465f, -0.03106900f, 
    -0.00389411f, 0.01308960f, -0.00129631f, 0.02415198f, 0.01289065f, 0.03357689f, -0.02379593f, 0.02275096f, 
    -0.01556916f, -0.02426734f, -0.04204613f, -0.01239329f, 0.00867277f, -0.01286068f, -0.01847264f, -0.02053576f, 
    -0.02666601f, -0.02719672f, 0.01423811f, -0.01481654f, 0.01009125f, -0.02887980f, -0.02793877f, -0.01315707f, 
    -0.00877833f, 0.02118017f, 0.00642657f, 0.00968874f, 0.00044398f, 0.02414513f, -0.02178446f, -0.02114189f, 
    0.00844391f, -0.02359956f, 0.01591488f, 0.01953121f, 0.00975910f, -0.02562177f, 0.00175448f, 0.02080478f, 
    -0.02448761f, 0.00255173f, 0.00132734f, -0.04084271f, -0.02718276f, 0.02626020f, -0.02293539f, -0.03701220f, 
    -0.00652488f, -0.03878365f, -0.03148052f, 0.01697138f, 0.02587981f, -0.03217323f, -0.01156373f, -0.02299103f, 
    -0.00534191f, 0.01580729f, -0.03175313f, 0.02739907f, 0.02745625f, -0.03051272f, 0.00142359f, -0.02190308f, 
    0.02087674f, 0.02052445f, 0.01456929f, -0.04072867f, 0.01619674f, -0.00869896f, 0.02981194f, 0.00279784f, 
    -0.02571053f, 0.02896310f, 0.00569701f, -0.02078809f, -0.03283924f, -0.00885053f, 0.01162655f, 0.02888796f, 
    0.00003435f, 0.02814293f, 0.00605006f, 0.01449394f, -0.00143908f, -0.00982095f, -0.03675788f, 0.01244475f, 
    -0.02017121f, 0.00709998f, -0.01686008f, 0.02052036f, -0.04057354f, -0.01344282f, -0.02411442f, -0.03635342f, 
    -0.00828022f, -0.03419733f, -0.02849619f, 0.00491300f, 0.00800109f, -0.02932991f, 0.02793783f, -0.00953381f, 
    -0.01752470f, -0.00945361f, -0.03863891f, -0.03086374f, -0.02285027f, 0.00066265f, -0.00477724f, 0.00628880f, 
    0.02644584f, -0.01014689f, -0.00205649f, 0.00843571f, 0.02731974f, 0.00745663f, 0.00406159f, 0.01718650f, 
    0.02729262f, 0.02490062f, -0.00023651f, -0.01294042f, 0.00481433f, 0.00068500f, 0.00887065f, -0.01258022f, 
    -0.01636202f, -0.00120235f, 0.00055268f, -0.02945175f, -0.00602812f, -0.02014579f, 0.01820316f, -0.03450329f, 
    0.01774806f, 0.01094952f, 0.01723631f, -0.00983836f, 0.00850151f, 0.00052459f, 0.03292730f, -0.00372668f, 
    -0.00938965f, 0.01721362f, 0.01924944f, 0.01221601f, -0.01364346f, -0.04080018f, 0.00515528f, -0.00741404f, 
    -0.00604206f, 0.02032213f, -0.01904701f, 0.02606382f, -0.02237556f, 0.00473396f, 0.02264435f, -0.03226563f, 
    -0.03191602f, 0.02441494f, 0.00496402f, 0.02455997f, -0.01822708f, 0.01696261f, -0.00035481f, -0.02445285f, 
    0.01442397f, 0.00486382f, -0.00076503f, -0.00299804f, 0.01470928f, 0.00008158f, -0.00593511f, -0.03666377f, 
    0.01520764f, -0.02183877f, -0.00957116f, -0.02649815f, 0.02636181f, 0.02871103f, 0.02420639f, -0.00752381f, 
    0.00396371f, 0.00289028f, 0.01903046f, 0.02709941f, -0.00612019f, 0.00806948f, 0.00185639f, 0.01106240f, 
    -0.03144450f, 0.00692487f, 0.02592721f, -0.00789072f, -0.02382418f, -0.03815218f, -0.00187451f, -0.01369151f, 
    0.01137112f, -0.01193528f, -0.03658754f, -0.03066427f, -0.02327478f, -0.03931689f, 0.01937267f, -0.01542211f, 
    -0.19562337f, 0.05828359f, 0.05620116f, -0.05464314f, 0.09990798f, -0.05734987f, 0.04252815f, 0.11847772f, 
    0.08034464f, -0.10154487f, -0.22283258f, 0.00994534f, -0.23104833f, 0.04276695f, -0.11979441f, -0.10713332f, 
    0.19890393f, 0.12267698f, 0.13274449f, 0.09042543f, 0.03459942f, 0.05690657f, 0.01582471f, -0.10506764f, 
    -0.51546228f, 0.01520324f, 0.06015396f, -0.09605741f, 0.15154399f, 0.04373976f, 0.10316220f, 0.17144762f, 
    0.00984124f, -0.11680595f, 0.01344360f, 0.07729158f, -0.18744840f, -0.16879542f, -0.00712622f, 0.01158198f, 
    -0.07999647f, 0.08420156f, -0.06726142f, 0.03677859f, 0.01492901f, 0.04703465f, -0.01079660f, -0.06763599f, 
    0.16649926f, -0.04652870f, 0.08873763f, 0.11562096f, -0.02200575f, -0.02661834f, 0.05926281f, -0.12185114f, 
    0.13142973f, 0.03786952f, 0.00168583f, -0.01782832f, -0.09165760f, -0.04039692f, 0.00568556f, -0.06077112f, 
    0.07429449f, 0.09547030f, -0.00787788f, 0.10527756f, -0.01044820f, 0.17751430f, 0.03962240f, 0.03391284f, 
    -0.42795229f, 0.11936668f, 0.31877029f, -0.05232356f, -0.01487716f, 0.01112563f, 0.05023888f, 0.02104226f, 
    0.07625324f, 0.16697350f, 0.11809094f, 0.08843257f, 0.19846970f, 0.28670973f, 0.23073137f, 0.19076817f, 
    0.10854167f, 0.08212835f, 0.04509926f, 0.11492915f, 0.08870032f, 0.00608437f, 0.02950011f, -0.04537573f, 
    0.07953311f, 0.12047001f, 0.32940707f, 0.35138467f, -0.17427076f, -0.02555704f, -0.04094384f, 0.05369993f, 
    -0.02096651f, 0.05026805f, 0.03929949f, 0.09348922f, -0.30636588f, 0.17095132f, -0.14248912f, -0.03671938f, 
    0.15195826f, -0.01780516f, 0.06266558f, -0.01194176f, 0.02752479f, -0.07544261f, -0.10449067f, 0.01027202f, 
    -0.08824313f, 0.15383707f, 0.34149766f, 0.40665129f, -0.08394027f, -0.14188823f, 0.02501144f, 0.01849342f, 
    0.12342941f, -0.03594412f, 0.03694217f, -0.08301175f, -0.13328560f, 0.31304222f, 0.00741217f, -0.35265344f, 
    0.05992225f, -0.04663315f, 0.04309748f, -0.07204121f, 0.04350258f, -0.00864986f, 0.03345679f, 0.04212284f, 
    -0.10119033f, -0.03430482f, -0.07947644f, -0.20634070f, 0.07801196f, 0.00166472f, -0.01348774f, -0.00152818f, 
    0.06357007f, 0.00886136f, -0.02953160f, -0.00469516f, 0.01284658f, 0.18851788f, -0.23029481f, -0.17972404f, 
    0.05913703f, 0.01860515f, 0.07395700f, 0.05102606f, 0.15101735f, 0.01122872f, 0.08668497f, 0.06297222f, 
    -0.06428418f, 0.09360123f, 0.07082513f, 0.01696148f, -0.04282333f, 0.01453962f, -0.00307081f, -0.00925824f, 
    0.04965322f, 0.05740381f, 0.01250308f, 0.01450918f, 0.31782085f, 0.00544047f, -0.08588261f, 0.07428879f, 
    0.16819471f, 0.26961809f, 0.13026133f, 0.01006382f, -0.08339195f, -0.02396808f, 0.08299546f, -0.01972223f, 
    -0.23863836f, -0.17084275f, -0.03789706f, -0.26759264f, -0.03602660f, -0.07287358f, 0.05329162f, 0.06361227f, 
    0.09194040f, -0.16103242f, -0.00650692f, 0.03153944f, -0.16846903f, -0.11778362f, 0.01859381f, 0.05402656f, 
    -0.04682096f, 0.10111854f, 0.07616554f, -0.06368528f, -0.07591441f, -0.12687117f, -0.09330150f, -0.00902462f, 
    -0.25709563f, -0.20365028f, 0.13859692f, -0.08065078f, -0.03447270f, -0.01152045f, 0.09094028f, 0.07449876f, 
    -0.11075559f, 0.07697547f, 0.11586096f, 0.08476713f, -0.10949454f, -0.14741266f, 0.34599704f, 0.30781594f, 
    -0.16060029f, -0.10645097f, 0.03455311f, -0.03728109f, -0.06261030f, 0.09274082f, 0.15247811f, 0.21869895f, 
    -0.02715826f, 0.00619791f, -0.19884154f, 0.00684479f, -0.04162171f, -0.02672023f, 0.15543473f, 0.24477954f, 
    0.17041321f, 0.02540081f, -0.05692782f, -0.06814621f, 0.21358383f, -0.17238119f, -0.05276760f, -0.07586463f, 
    0.03853741f, 0.17413522f, -0.02037575f, -0.10988794f, 0.07667898f, -0.00723578f, 0.00640848f, 0.01923105f, 
    0.15640135f, 0.17934535f, 0.20166121f, 0.36615661f, 0.03369450f, -0.07214602f, 0.00492468f, -0.04292276f, 
    0.00996197f, -0.08370032f, 0.08908512f, 0.08404351f, 0.20299427f, -0.08257146f, -0.09257159f, 0.05164370f, 
    0.04845431f, 0.08845588f, 0.01869298f, 0.04178246f, 0.02946736f, -0.11228474f, 0.04254656f, -0.08694687f, 
    -0.29659852f, -0.16578571f, 0.06287619f, -0.05849716f, 0.03683098f, -0.03642995f, -0.01996430f, 0.05648024f, 
    0.18946630f, -0.08264162f, 0.03809015f, -0.10494543f, 0.04827122f, 0.02464228f, 0.11128205f, 0.14587928f, 
    0.11308789f, 0.10338951f, 0.06734871f, 0.05554597f, 0.04303773f, -0.01455338f, -0.06116318f, 0.10341781f, 
    -0.24602121f, -0.04940077f, 0.09274930f, 0.04135576f, 0.02781345f, 0.09289414f, 0.08178533f, 0.12072884f, 
    0.04084273f, 0.04892934f, -0.03310877f, 0.00700255f, -0.30481729f, 0.08253251f, -0.06616462f, 0.09135146f, 
    0.04238847f, 0.07366755f, 0.08867875f, -0.01624725f, 0.05731512f, 0.04916731f, 0.03772132f, 0.04609486f, 
    -0.00776476f, 0.09126228f, -0.03163555f, -0.09957644f, 0.06651624f, -0.05343048f, -0.04545547f, -0.06117068f, 
    0.16746046f, 0.09798524f, -0.06465992f, -0.02163737f, -0.03411927f, 0.00064864f, -0.03133990f, -0.25393167f, 
    0.02538066f, 0.01921295f, -0.00705652f, 0.00636988f, -0.02652410f, 0.03276479f, 0.02788967f, 0.00882548f, 
    0.19865687f, 0.04933300f, 0.02713342f, 0.19958907f, 0.13944164f, 0.03587960f, -0.01095574f, 0.09889116f, 
    0.03456964f, -0.00297176f, 0.07252465f, -0.03209899f, 0.15257768f, 0.37874240f, 0.17096817f, 0.20932999f, 
    -0.00541591f, -0.02757705f, 0.14297879f, 0.04428290f, -0.00640870f, -0.11011749f, 0.04953827f, 0.10535727f, 
    0.18281588f, 0.18979318f, 0.21544354f, 0.17344001f, 0.14232093f, 0.13031356f, -0.05889069f, 0.11042435f, 
    -0.04071943f, 0.05712845f, 0.04150342f, 0.10322078f, 0.05489598f, -0.00401055f, 0.33101150f, 0.31120330f, 
    -0.02181058f, -0.11239199f, -0.05839560f, -0.06294593f, 0.04771383f, -0.12071563f, -0.06220073f, 0.07025455f, 
    -0.26222649f, 0.05706698f, -0.03132958f, -0.08138950f, 0.06689817f, 0.03888626f, 0.07517190f, 0.02148833f, 
    0.05463670f, 0.00781944f, -0.06992424f, 0.07387345f, 0.17353936f, -0.10346786f, -0.21839780f, 0.20765741f, 
    0.08281057f, -0.00885305f, 0.04036795f, -0.01391746f, -0.10621770f, 0.00969922f, 0.06759547f, -0.07866883f, 
    -0.23922719f, 0.17512697f, 0.08202226f, 0.13225302f, -0.05074438f, -0.00072150f, -0.01132253f, 0.13223332f, 
    0.03018876f, 0.07339558f, 0.01283348f, 0.06969554f, 0.14403053f, -0.10537039f, 0.00767286f, -0.02564325f, 
    -0.02960820f, 0.02076514f, 0.05653588f, -0.17634761f, 0.05127128f, 0.09146756f, 0.08759373f, 0.15421478f, 
    -0.03413437f, -0.08579148f, -0.05355577f, 0.09397208f, 0.06038607f, 0.05987055f, -0.08184723f, -0.06262030f, 
    -0.05464258f, -0.01667937f, -0.02694474f, 0.09411237f, 0.02503157f, -0.12802623f, -0.03153807f, 0.19720910f, 
    -0.02534736f, 0.11298656f, 0.00820523f, -0.00256602f, -0.03154793f, 0.07589497f, 0.21625116f, -0.14052853f, 
    0.16606402f, -0.01234913f, 0.13899474f, 0.38513017f, 0.01563284f, 0.07690530f, -0.03729188f, 0.04020056f, 
    0.03527872f, -0.02438984f, 0.03187587f, -0.01206565f, -0.12036839f, 0.02874269f, -0.12511533f, 0.02379445f, 
    0.07865575f, 0.04688848f, 0.03852005f, 0.12041454f, 0.01857031f, 0.03923380f, -0.02048527f, -0.03698046f, 
    -0.18336581f, 0.06748904f, 0.05682818f, -0.11894643f, 0.02086206f, 0.00289376f, 0.03293476f, 0.14135113f, 
    0.10288832f, 0.11268381f, 0.02870778f, 0.09766866f, -0.19973929f, -0.02886414f, 0.07729184f, -0.01862279f, 
    0.12570202f, 0.03111189f, 0.06297664f, 0.09643839f, 0.05892492f, 0.07200791f, 0.07602736f, 0.05699153f, 
    0.14158586f, 0.04929542f, 0.06243371f, 0.54509181f, -0.01284404f, 0.14066973f, 0.02779334f, -0.01540775f, 
    -0.03830616f, -0.00550078f, 0.05321028f, 0.10574657f, 0.06808674f, -0.13337907f, 0.09701629f, 0.23178107f, 
    0.05992323f, -0.01160161f, 0.02625470f, -0.02452345f, -0.06252209f, 0.02508862f, -0.02031746f, 0.10600530f, 
    -0.17242850f, -0.10988631f, -0.03604012f, 0.08265623f, 0.02216413f, 0.10062351f, -0.01290083f, -0.02555155f, 
    0.06847029f, 0.04095733f, -0.00186424f, -0.10549027f, -0.01824457f, -0.13148458f, -0.11788314f, -0.01051836f, 
    0.00119042f, 0.01090226f, -0.02272252f, 0.02986746f, 0.10453368f, 0.09630454f, 0.04289095f, 0.05916669f, 
    0.33227116f, -0.07010156f, -0.13911079f, 0.18674156f, 0.16235681f, 0.07163223f, -0.06572702f, -0.23056501f, 
    -0.02663689f, -0.07857055f, 0.08944064f, -0.07518987f, 0.39350849f, 0.17006291f, -0.08517201f, -0.04683347f, 
    -0.01955051f, 0.10978454f, 0.07859645f, -0.00586819f, -0.14146681f, 0.15448956f, -0.01297552f, -0.06586678f, 
    -0.39119202f, -0.12457816f, 0.03426902f, -0.04055845f, -0.07281797f, 0.12761930f, 0.01851655f, -0.07462599f, 
    0.09933313f, 0.02613522f, 0.03917127f, -0.01090707f, 0.26450804f, 0.07077748f, 0.04181253f, -0.11323127f, 
    0.09876215f, 0.13390653f, -0.12752028f, -0.07901393f, 0.01266178f, -0.10364399f, 0.06761272f, -0.15274605f, 
    -0.31655794f, 0.19044012f, -0.06284478f, -0.02998090f, 0.04999460f, 0.07646608f, -0.07621632f, -0.07018682f, 
    -0.02195969f, 0.02993252f, 0.05277647f, -0.07279170f, 0.03001039f, 0.11433013f, 0.06399213f, -0.12753980f, 
    0.07291184f, 0.03538428f, -0.01950315f, -0.09152097f, -0.01522732f, 0.06405415f, 0.09277277f, -0.07288025f, 
    -0.23266812f, -0.03304247f, -0.04741003f, -0.08395045f, -0.05396772f, 0.10496260f, 0.04972033f, -0.01026816f, 
    -0.09011880f, -0.03963003f, -0.01323027f, 0.01838157f, 0.05004122f, 0.20104191f, 0.06348196f, 0.28796777f, 
    0.00122455f, -0.00374166f, -0.05706777f, 0.12822294f, -0.09678297f, -0.03166676f, 0.16984524f, 0.19059220f, 
    -0.15306884f, -0.10974751f, 0.07802753f, -0.05711192f, -0.00656998f, -0.03876141f, -0.00506361f, 0.01616413f, 
    -0.04459688f, 0.00234552f, 0.16935872f, -0.06370991f, 0.00617359f, -0.09929322f, -0.05902352f, 0.31329337f, 
    0.16106470f, 0.05215603f, -0.08944776f, -0.01443369f, -0.03927410f, 0.00784104f, 0.08978269f, 0.13993251f, 
    -0.12959994f, 0.04457965f, -0.14179666f, -0.01758533f, 0.16008137f, 0.11535140f, 0.09162794f, -0.13555519f, 
    0.00928630f, -0.02871782f, 0.04500672f, -0.03424377f, 0.04882158f, -0.14794776f, 0.29825166f, 0.25526574f, 
    0.00532816f, 0.00093699f, 0.01770242f, -0.00623395f, 0.14812681f, -0.02059489f, 0.02682269f, -0.08511018f, 
    -0.10747536f, -0.06559981f, -0.00385321f, 0.01947713f, -0.09784123f, 0.07120119f, 0.05395545f, 0.04862127f, 
    0.04696360f, 0.04468716f, 0.07111147f, 0.17177655f, 0.02548898f, -0.12713858f, -0.02368022f, 0.21265632f, 
    -0.03656476f, -0.00141304f, -0.15671097f, -0.10061894f, 0.18009199f, 0.00026515f, -0.10935392f, 0.03182608f, 
    -0.36154515f, -0.28351420f, -0.13793258f, 0.07335802f, 0.01245882f, -0.00902744f, 0.04246422f, 0.08171354f, 
    0.04763860f, -0.06630581f, -0.04956675f, 0.02673058f, 0.23688497f, -0.10136921f, 0.03252184f, 0.19572617f, 
    -0.12115085f, 0.03504692f, 0.09377018f, -0.02322775f, -0.16094831f, -0.12911455f, -0.04151160f, -0.09322289f, 
    0.02493321f, -0.02803005f, -0.02478476f, -0.00388553f, 0.01237465f, -0.00192649f, -0.03911268f, 0.03433463f, 
    -0.03721267f, -0.01201747f, -0.01806007f, -0.00287095f, -0.00896402f, 0.00085583f, -0.01746641f, -0.02973002f, 
    0.01418176f, -0.02162519f, 0.02225298f, -0.02603703f, 0.02917302f, -0.03986254f, -0.03418259f, -0.02084433f, 
    -0.00350564f, -0.02414243f, 0.02156795f, -0.01303901f, -0.01409780f, -0.01045268f, -0.04086770f, 0.02857605f, 
    0.01049445f, -0.02426821f, 0.01423594f, -0.01144082f, -0.02272359f, -0.01086765f, 0.00980918f, -0.01431369f, 
    0.00880394f, -0.02232469f, -0.00149844f, 0.00999829f, -0.00617473f, -0.00929379f, -0.01562554f, -0.02797466f, 
    -0.03149993f, 0.00598078f, -0.01876192f, -0.03034673f, -0.04141350f, 0.02798577f, 0.00326651f, 0.02175169f, 
    -0.00952429f, 0.02002919f, -0.00704303f, -0.02104116f, -0.02394868f, 0.00714678f, 0.00850439f, 0.01066596f, 
    0.01058797f, -0.00477241f, -0.02794900f, -0.02539297f, -0.03997450f, -0.00939866f, 0.01327287f, -0.02090237f, 
    -0.02374313f, 0.00870515f, 0.01170066f, -0.02716852f, -0.02358948f, -0.02905810f, -0.01657320f, -0.03606419f, 
    0.01149964f, 0.01400813f, -0.00215175f, -0.00098024f, -0.01937502f, -0.03329580f, -0.03090219f, -0.01046178f, 
    0.01491361f, 0.01810624f, 0.02551118f, -0.03543855f, 0.02369467f, -0.00923430f, -0.02637524f, 0.02133550f, 
    -0.01508888f, -0.03275186f, 0.02494068f, -0.02331479f, -0.01161703f, 0.00495062f, -0.03681940f, -0.02945383f, 
    0.01747925f, -0.02782661f, 0.01641763f, 0.00484815f, 0.02518124f, 0.02598350f, -0.00479296f, 0.01810213f, 
    -0.00139945f, -0.01554652f, 0.02002893f, -0.00969442f, 0.00070824f, 0.00772787f, 0.00409708f, -0.03335316f, 
    0.02461613f, -0.04022354f, -0.00157488f, -0.03521065f, -0.00559717f, 0.00893439f, -0.02759347f, 0.02533910f, 
    -0.01462729f, -0.01168148f, 0.01085456f, -0.01563819f, 0.00380843f, 0.02330578f, 0.00925322f, 0.00484219f, 
    0.01661312f, -0.02763576f, 0.00476028f, -0.00109203f, -0.00522629f, 0.00406112f, 0.02316143f, 0.02601982f, 
    -0.02475353f, 0.02084502f, -0.04312302f, 0.01925208f, -0.02126069f, -0.01644680f, 0.02515230f, -0.02797483f, 
    -0.01769723f, -0.00891156f, -0.03961705f, 0.00293496f, -0.01952181f, -0.02733858f, -0.01878046f, -0.02544408f, 
    -0.00579041f, 0.02515517f, -0.04287441f, -0.00276127f, -0.00351272f, 0.02846162f, 0.00035054f, -0.03244297f, 
    0.02659959f, -0.02767581f, 0.01347537f, -0.01510135f, -0.01404512f, 0.01997052f, -0.02654801f, -0.01292408f, 
    0.02717480f, 0.02122084f, -0.00743525f, -0.00785335f, -0.00499172f, 0.00207376f, -0.04299689f, -0.03155572f, 
    -0.03534337f, -0.02984340f, -0.03055352f, -0.01765190f, -0.02123827f, -0.04173060f, 0.00737612f, 0.00870144f, 
    -0.00335152f, 0.00138487f, 0.02472554f, -0.01891707f, -0.00446956f, 0.01459117f, -0.01319185f, 0.00425352f, 
    -0.03056465f, 0.01816619f, -0.01853399f, -0.01341549f, -0.03564526f, 0.02087532f, -0.01062994f, 0.02821349f, 
    0.01337906f, -0.04214240f, -0.03042994f, -0.01229885f, -0.02496167f, 0.01554705f, -0.00789509f, -0.04081267f, 
    -0.03134983f, -0.01703732f, -0.00973396f, 0.02472107f, -0.01014873f, -0.01034931f, 0.00943315f, -0.01517441f, 
    0.00327150f, 0.02181322f, -0.01600641f, 0.01473923f, -0.01169377f, 0.02383238f, 0.00942173f, 0.01376262f, 
    0.02154257f, -0.03470656f, 0.01816576f, 0.00461063f, 0.00550604f, -0.00382201f, 0.01074214f, 0.01904593f, 
    0.01681639f, -0.03173793f, -0.02994802f, -0.01084480f, -0.00035535f, -0.00226545f, 0.01471998f, -0.00094769f, 
    -0.00257909f, -0.03597302f, -0.01842737f, 0.02242176f, -0.02471188f, -0.02752742f, -0.03241647f, 0.00852547f, 
    0.02411231f, -0.00049795f, -0.04185960f, 0.02077668f, 0.00517089f, 0.01057461f, 0.01961781f, 0.01139751f, 
    0.01097673f, 0.01824183f, -0.03805345f, -0.03556500f, 0.02262242f, -0.02927798f, -0.02941450f, 0.02595227f, 
    -0.04152456f, -0.01015448f, -0.01417072f, -0.00338960f, -0.04170911f, -0.01607175f, -0.02825532f, 0.00419528f, 
    0.02945662f, -0.01872182f, -0.03161339f, 0.02432449f, -0.03853600f, 0.00453857f, -0.00117669f, -0.00066388f, 
    -0.03934585f, -0.03644916f, -0.01170321f, 0.02195065f, -0.00099946f, -0.03892980f, -0.02637186f, -0.03353675f, 
    0.02472947f, -0.02419972f, 0.00806184f, -0.00859107f, 0.00949953f, 0.01195009f, -0.00585279f, 0.01286040f, 
    0.01523462f, 0.01767858f, -0.01513199f, -0.04260764f, -0.02400714f, 0.02401281f, -0.00581172f, -0.02729038f, 
    -0.00161313f, 0.01092475f, 0.00809550f, 0.01512907f, -0.01655428f, -0.04041516f, 0.01387484f, 0.02759388f, 
    0.00990123f, 0.01164602f, 0.00362545f, -0.01283477f, 0.02564189f, -0.00685050f, -0.01977626f, 0.00355864f, 
    0.00032116f, 0.00919428f, -0.01774256f, -0.02676433f, 0.00065410f, -0.00027538f, -0.00571375f, 0.00922458f, 
    -0.00421155f, -0.00921600f, 0.02546340f, 0.01977234f, -0.03076285f, -0.04337851f, -0.02964748f, -0.00324587f, 
    -0.01312206f, -0.00937692f, 0.00851437f, 0.00159642f, -0.03439981f, -0.01921007f, -0.00122560f, 0.01760367f, 
    -0.01426209f, -0.03037717f, 0.02768667f, 0.01057638f, -0.02148351f, -0.02651543f, 0.01039525f, -0.02647429f, 
    0.00919662f, -0.01190742f, -0.01912307f, -0.00733739f, -0.02456724f, -0.03098106f, 0.03612915f, 0.02701165f, 
    0.01376415f, 0.02259188f, -0.01543104f, 0.02857693f, -0.02977623f, -0.01729405f, 0.01629896f, 0.03159699f, 
    -0.01321366f, -0.02449764f, -0.00578118f, -0.03081261f, -0.01406687f, -0.02936487f, 0.00803798f, -0.00846134f, 
    -0.03154372f, -0.00334647f, 0.00574374f, -0.00483782f, -0.02373556f, 0.00464267f, -0.01899638f, -0.01765459f, 
    0.00142431f, 0.00899239f, -0.02864110f, -0.00531416f, -0.00357743f, -0.02757524f, -0.01982990f, 0.02861219f, 
    -0.02606699f, -0.01911623f, -0.03681290f, -0.00761514f, 0.01911663f, -0.02431375f, 0.01202319f, -0.01678486f, 
    -0.02260203f, -0.03612829f, -0.01468785f, -0.03112389f, -0.04220039f, -0.01896391f, -0.02675220f, 0.00321662f, 
    -0.01639196f, -0.03146778f, 0.00841529f, 0.00753706f, 0.01926612f, -0.02859326f, -0.00201185f, -0.01481532f, 
    -0.01800864f, 0.02113475f, 0.00222520f, 0.02719525f, -0.00442206f, -0.00232736f, -0.00758035f, -0.02362261f, 
    0.00896221f, 0.02265655f, -0.03283231f, 0.00813627f, -0.02055174f, -0.03577080f, -0.02258015f, -0.02844925f, 
    0.00876166f, 0.01409811f, 0.00851718f, -0.02806264f, -0.00808601f, 0.01202206f, 0.00381021f, -0.01668277f, 
    0.02714525f, 0.02541403f, -0.00536972f, -0.02686962f, 0.01308537f, -0.00470086f, -0.01451816f, -0.03207746f, 
    0.02769073f, -0.03475520f, 0.02347871f, -0.02342625f, -0.01810499f, 0.00836993f, -0.00347340f, -0.02983372f, 
    0.02104772f, 0.01719681f, -0.01107796f, -0.03225242f, -0.03380354f, 0.00299420f, -0.02830810f, 0.01986015f, 
    0.02520400f, -0.02367986f, -0.04003330f, -0.03775370f, -0.03813280f, -0.01773951f, -0.02244326f, 0.00759397f, 
    0.02046292f, 0.02139739f, 0.00457169f, 0.00125615f, -0.01524200f, -0.01407451f, 0.00296172f, 0.01288732f, 
    -0.03531125f, -0.03871370f, 0.01551765f, -0.03466835f, -0.00560428f, 0.00040242f, 0.00656053f, -0.03802684f, 
    -0.02608468f, -0.02480647f, -0.01383740f, -0.02643860f, -0.03539688f, 0.02018715f, -0.01813269f, 0.00797978f, 
    -0.03617370f, -0.01341356f, -0.01047641f, 0.02786166f, -0.02059443f, -0.02158197f, -0.01400969f, 0.00788547f, 
    -0.03182215f, 0.01873012f, 0.02150755f, -0.01832659f, -0.04099549f, -0.03092583f, -0.00111234f, 0.01855960f, 
    -0.03253057f, 0.02474119f, -0.00839384f, -0.02892251f, -0.02563326f, 0.00157047f, -0.03653047f, -0.02952177f, 
    -0.01233093f, 0.00894958f, 0.02590744f, 0.02947431f, 0.01155409f, -0.00365807f, -0.00572859f, 0.00710046f, 
    0.01378694f, -0.02492806f, 0.00207385f, -0.00433450f, 0.00359657f, 0.00657158f, -0.03082113f, 0.00057737f, 
    -0.03677716f, 0.02353154f, 0.02337165f, -0.03250521f, 0.02517151f, 0.00330831f, -0.00170749f, -0.01320817f, 
    0.01819591f, -0.00193740f, -0.01486860f, -0.01305664f, -0.03175369f, -0.03895472f, -0.00501186f, -0.00167919f, 
    0.01239934f, -0.02771088f, -0.02083855f, -0.01449046f, -0.01128308f, -0.03665892f, 0.01004110f, -0.03246772f, 
    0.00523308f, 0.01020611f, -0.00212858f, -0.02958317f, 0.00517219f, -0.02192715f, -0.00399577f, 0.02666380f, 
    -0.01355380f, -0.01466247f, 0.02645601f, 0.02601374f, -0.01603865f, 0.02414079f, -0.03633602f, -0.00945560f, 
    0.00289709f, -0.00602219f, -0.01138107f, -0.03721991f, -0.02999841f, -0.04250012f, 0.01087211f, -0.02611018f, 
    -0.01855031f, -0.02574100f, 0.03165726f, -0.00447024f, 0.01440919f, -0.04161488f, -0.03012116f, 0.00961974f, 
    -0.00593386f, 0.00956961f, -0.03316953f, 0.02031421f, 0.01986534f, 0.00650330f, -0.01657177f, -0.02002334f, 
    0.00535039f, -0.01799453f, -0.03092137f, 0.00286955f, -0.00182929f, 0.01607450f, -0.01112033f, -0.00000450f, 
    -0.04154536f, -0.00556417f, 0.01498097f, -0.00701017f, 0.00997570f, -0.03408933f, -0.03571232f, -0.00303197f, 
    -0.02646019f, 0.00233432f, 0.00820178f, -0.03992284f, 0.02004309f, 0.00412537f, 0.02244489f, -0.03469809f, 
    0.00889849f, -0.03461148f, -0.01102505f, 0.03271237f, 0.00634883f, 0.01743506f, -0.03748772f, -0.00660406f, 
    0.00194942f, 0.02403004f, -0.03656569f, -0.00697281f, 0.02793107f, 0.00131489f, 0.01226521f, 0.01724519f, 
    -0.01293265f, 0.01931425f, -0.03102404f, 0.00821878f, -0.03802998f, -0.02879410f, -0.03316403f, -0.02528687f, 
    -0.03958516f, -0.00543628f, -0.02660412f, -0.00516381f, 0.02436180f, -0.00917784f, -0.02718215f, 0.02679611f, 
    -0.02257796f, -0.01888134f, 0.02728394f, -0.01387973f, 0.00371535f, 0.01269864f, -0.03609120f, 0.01898368f, 
    0.01310264f, -0.03715043f, 0.01134561f, -0.00821641f, 0.00902734f, 0.01961214f, 0.00014292f, 0.00904510f, 
    0.02634927f, -0.04158729f, 0.02025647f, 0.02792976f, -0.01159566f, 0.02711082f, -0.01751170f, 0.01917714f, 
    -0.02888047f, 0.01730799f, 0.01469293f, -0.01739492f, 0.00716108f, 0.00167372f, -0.01311631f, -0.01891561f, 
    -0.03722665f, 0.00781748f, 0.01312458f, -0.00202081f, -0.00978412f, -0.03433274f, -0.03568654f, -0.03558722f, 
    0.00604932f, -0.01848629f, 0.00631301f, 0.00172171f, 0.00104052f, -0.01182304f, 0.02107299f, -0.04085035f, 
    -0.03291453f, -0.01951551f, -0.02863642f, -0.00605277f, 0.01920629f, -0.02507169f, -0.00339552f, 0.02623633f, 
    -0.03628754f, -0.01553481f, -0.01212735f, 0.01743956f, 0.01746866f, 0.02953245f, 0.00352618f, -0.03529051f, 
    -0.04231867f, 0.01782956f, 0.01121261f, -0.01489127f, 0.02093582f, -0.02155144f, -0.00991800f, 0.01696293f, 
    -0.03484943f, 0.00311480f, 0.01530514f, -0.03203669f, 0.02714319f, 0.02431131f, -0.04205059f, -0.03525734f, 
    -0.01458325f, -0.00707175f, 0.01798247f, 0.02294275f, 0.02959663f, 0.01117487f, -0.03849337f, 0.00966099f, 
    0.00044078f, -0.02116409f, -0.03222859f, -0.03551617f, 0.00368380f, 0.01674272f, 0.00241970f, -0.02091023f, 
    -0.02732908f, 0.02767827f, -0.03163031f, -0.00320241f, -0.00895721f, -0.00622546f, -0.02042506f, -0.01180301f, 
    0.16519524f, 0.02225530f, -0.01738412f, 0.10480651f, 0.02966555f, -0.05496993f, 0.04977744f, 0.01609183f, 
    -0.02326505f, 0.01323561f, 0.05230295f, 0.13329299f, 0.26351753f, -0.45600575f, 0.02273479f, 0.07786857f, 
    0.08477668f, 0.00788220f, 0.06993379f, -0.01830656f, 0.03707168f, -0.02617812f, 0.01023531f, 0.04840948f, 
    -0.11794030f, -0.02999412f, 0.15142980f, -0.35937387f, -0.02149723f, -0.03702929f, 0.05623136f, 0.00495625f, 
    0.02235186f, 0.02092231f, 0.06114770f, -0.03618771f, -0.12240925f, 0.01622702f, 0.04409136f, 0.02809774f, 
    0.05078143f, -0.07266957f, -0.02353604f, 0.07446212f, -0.01859676f, -0.02613398f, 0.00385028f, 0.08801449f, 
    0.13214201f, 0.15331875f, 0.05046367f, -0.23221925f, -0.02200395f, 0.11815627f, 0.11574691f, 0.02141263f, 
    -0.14834107f, 0.11180940f, 0.09690631f, -0.01286966f, 0.17068370f, -0.10841659f, 0.13442743f, -0.06693397f, 
    0.12409773f, 0.00848713f, 0.12773508f, 0.02194766f, 0.01725883f, 0.06630751f, 0.02571374f, -0.20304370f, 
    0.00116725f, -0.14715897f, 0.18606608f, 0.18193933f, 0.08593312f, -0.02233269f, 0.07349534f, 0.01892442f, 
    -0.06760515f, -0.11055628f, -0.07458170f, -0.02768004f, 0.11528616f, 0.03393598f, -0.05736102f, -0.15156607f, 
    0.05688423f, 0.04281481f, 0.02281435f, 0.02784519f, 0.01846441f, -0.01394996f, -0.04056025f, 0.05738198f, 
    -0.14872381f, 0.13846549f, 0.00738354f, -0.04103971f, 0.10943464f, 0.02858516f, -0.02752215f, 0.00040815f, 
    -0.05967338f, 0.15916310f, 0.04803554f, 0.09584280f, -0.07551041f, 0.16319931f, 0.29959491f, -0.06479169f, 
    -0.25287110f, 0.00198744f, 0.02542390f, -0.14348887f, 0.02863576f, -0.08441273f, -0.00445661f, -0.10343698f, 
    0.22922380f, -0.28360811f, 0.20280595f, 0.27258050f, -0.00111619f, -0.07341303f, 0.02957692f, -0.07580408f, 
    -0.03984196f, -0.04214553f, -0.11666689f, -0.06463682f, 0.21799879f, -0.21677606f, 0.07769778f, -0.03718343f, 
    -0.07577608f, 0.02358129f, -0.10125819f, 0.04589400f, 0.10457718f, 0.06667418f, 0.06366932f, 0.04986442f, 
    -0.11750526f, 0.25303355f, 0.29065946f, 0.01412026f, -0.01348729f, 0.03005438f, 0.10304339f, 0.03135378f, 
    -0.01910568f, 0.05452408f, -0.02331684f, -0.08356811f, -0.16814305f, 0.18474297f, 0.05725442f, -0.41054267f, 
    -0.05957057f, 0.15306720f, -0.02699753f, -0.03625062f, 0.08748426f, -0.11849409f, -0.00724548f, 0.04293706f, 
    -0.12123877f, 0.32878301f, 0.09122109f, 0.17301364f, -0.06666370f, 0.09312244f, 0.05091238f, -0.02444391f, 
    0.03142338f, -0.02583398f, 0.12271850f, 0.00782709f, -0.04380204f, 0.06024306f, 0.08225448f, 0.04185487f, 
    0.08650614f, -0.04353819f, 0.12404093f, -0.09092014f, -0.11395557f, 0.06202153f, -0.02833992f, 0.00167954f, 
    -0.18004504f, 0.26438338f, 0.20072280f, -0.23196912f, 0.00459273f, 0.04201433f, 0.08363858f, 0.03145112f, 
    -0.06907082f, -0.05234686f, 0.01736740f, 0.01526516f, 0.09531628f, -0.03049349f, 0.07248397f, 0.07955375f, 
    0.02795687f, -0.01046056f, -0.01541109f, 0.01677562f, 0.02199672f, -0.04774602f, -0.02145942f, 0.14262368f, 
    0.27020311f, -0.05225231f, 0.26050529f, -0.10544097f, 0.09810417f, 0.04794166f, 0.07915790f, 0.05043921f, 
    0.09073178f, 0.01310924f, -0.02660213f, -0.02486669f, -0.03350675f, 0.04224211f, 0.08463489f, -0.20364773f, 
    0.02228146f, 0.08731647f, 0.00670421f, 0.02052799f, -0.01649801f, -0.06129039f, 0.03866763f, 0.08937757f, 
    -0.08490738f, 0.16838920f, -0.01579865f, 0.10106473f, 0.10498603f, -0.05534761f, -0.03103428f, -0.06467977f, 
    -0.08957251f, 0.09674749f, 0.21793295f, -0.02741760f, 0.07535566f, 0.06746658f, -0.07701391f, -0.10537567f, 
    -0.01767417f, 0.01134390f, -0.12432759f, -0.01845364f, -0.02818180f, 0.02900485f, -0.04395863f, -0.04289550f, 
    -0.18686135f, 0.04903768f, -0.04804646f, 0.16899037f, 0.00765621f, -0.02360572f, 0.03554905f, 0.15581548f, 
    -0.12092177f, -0.01593613f, -0.02223876f, 0.04258135f, 0.14730632f, 0.06108807f, -0.00893792f, 0.12040675f, 
    -0.15291023f, 0.00757302f, 0.06121084f, -0.14185315f, 0.04873692f, 0.22969759f, -0.03913689f, 0.07839338f, 
    -0.09137909f, 0.07694551f, 0.04765844f, 0.11726017f, 0.00280160f, 0.02036798f, 0.02883576f, 0.06290133f, 
    0.03875528f, -0.00631650f, -0.02058569f, -0.08851002f, -0.13950588f, -0.09770803f, 0.02233092f, -0.03584220f, 
    -0.00269511f, 0.05726146f, -0.00923450f, -0.03988063f, 0.07965695f, 0.05007456f, 0.14471123f, 0.06570303f, 
    -0.06727165f, 0.16122591f, 0.07306910f, 0.19249530f, 0.03966190f, -0.02627689f, 0.08784271f, -0.00798081f, 
    -0.09734694f, -0.06200280f, 0.06526628f, -0.08028154f, -0.07355370f, 0.02627299f, -0.14449775f, 0.08253842f, 
    0.05334469f, 0.08628840f, 0.02560746f, -0.02658995f, 0.04254004f, -0.02056202f, 0.04934960f, 0.03940265f, 
    -0.22342671f, -0.29710671f, 0.06550971f, -0.01415471f, 0.06039641f, -0.04905401f, 0.01448286f, 0.07139017f, 
    0.08524106f, 0.09337440f, 0.02204528f, 0.02921421f, 0.31823650f, 0.01817351f, 0.28282887f, -0.12733206f, 
    -0.08978266f, -0.00024085f, 0.00399501f, 0.01139066f, -0.04871193f, -0.04829765f, 0.04275819f, -0.02703587f, 
    -0.04500427f, 0.07582075f, -0.05144633f, -0.00734576f, 0.10429201f, 0.08236791f, -0.03596086f, 0.07813078f, 
    -0.08602628f, 0.00927427f, 0.07159415f, -0.02765549f, 0.02529080f, 0.16635808f, 0.05985643f, -0.03426181f, 
    -0.07945926f, 0.07140910f, 0.07581095f, 0.00748123f, 0.07393691f, 0.04756838f, 0.06567545f, 0.02362220f, 
    0.00755590f, -0.03405724f, 0.05089537f, 0.11833688f, 0.10840904f, 0.02295831f, 0.05695751f, -0.05068931f, 
    -0.01379406f, 0.09335251f, 0.17676246f, 0.05081210f, 0.29243523f, -0.13479485f, 0.08203032f, -0.08643334f, 
    0.03627279f, -0.10365778f, 0.05291424f, -0.00490346f, -0.04264464f, -0.10574974f, 0.05018149f, -0.02426729f, 
    -0.02767992f, -0.04458136f, -0.06652209f, 0.19951893f, 0.05293154f, 0.06562451f, 0.16594642f, -0.11491508f, 
    -0.00596622f, -0.12451095f, -0.00658418f, 0.14801490f, -0.19125977f, 0.06038634f, -0.07910264f, -0.03740153f, 
    0.01288045f, -0.01538574f, -0.01845633f, 0.05893875f, -0.05098559f, 0.09553754f, 0.10267834f, -0.11831524f, 
    0.12105218f, -0.11981225f, 0.04553596f, 0.09603345f, -0.08067219f, 0.14349718f, -0.01794317f, -0.05482828f, 
    -0.06183703f, -0.05327301f, -0.08403596f, 0.06515317f, -0.21960923f, 0.22026725f, 0.05463069f, 0.13789594f, 
    0.03722265f, 0.11021420f, 0.01755264f, -0.00411963f, -0.01108591f, 0.08213490f, 0.04944688f, 0.01204703f, 
    0.20350356f, 0.08210952f, -0.09511089f, 0.21240224f, 0.02157700f, -0.08265566f, -0.00918321f, -0.05803588f, 
    -0.20231751f, -0.02414675f, -0.09130640f, 0.01627208f, 0.09467205f, 0.11565962f, -0.17994168f, 0.33492059f, 
    0.05159761f, 0.07843672f, -0.04932836f, 0.09085294f, 0.07047581f, -0.01704448f, 0.01353780f, -0.09803940f, 
    0.04274455f, -0.02477865f, -0.04051595f, 0.08763552f, 0.05289574f, 0.00065553f, 0.05710743f, -0.01577127f, 
    -0.03194906f, 0.08738150f, 0.11916484f, 0.00299724f, -0.18523443f, 0.17783514f, 0.02401111f, -0.00754117f, 
    -0.00521122f, -0.05932713f, -0.08548000f, -0.03212533f, -0.01051476f, 0.05362861f, 0.03330105f, -0.01680901f, 
    0.14443296f, -0.07226440f, 0.18985754f, -0.21724172f, 0.09843857f, 0.03617688f, 0.06976300f, -0.05560809f, 
    0.02400173f, 0.02434715f, -0.09285365f, 0.00157130f, 0.24370271f, -0.17353332f, 0.07304949f, 0.12783304f, 
    0.11980645f, -0.00512712f, 0.01134558f, 0.03487014f, 0.06852145f, 0.00533454f, -0.08077458f, -0.19245885f, 
    -0.12423149f, 0.06530258f, -0.01433961f, 0.26135880f, 0.01607925f, 0.01351669f, -0.01230438f, 0.12750806f, 
    -0.02262308f, -0.01266784f, -0.00023274f, 0.02793905f, 0.25979030f, 0.13154455f, -0.11709215f, 0.22424234f, 
    -0.08178435f, 0.00760265f, -0.06893241f, 0.01452340f, 0.01748077f, -0.11364775f, 0.01984911f, 0.16539763f, 
    -0.16521715f, 0.02276291f, -0.13152467f, 0.11682694f, -0.06377526f, 0.12998496f, -0.14271441f, 0.06126102f, 
    0.10467365f, -0.00324741f, 0.01184404f, -0.00825358f, -0.18854584f, 0.29961911f, 0.27014670f, -0.04233297f, 
    0.01855725f, 0.04508080f, 0.03371789f, -0.02026469f, -0.05211315f, 0.08159640f, 0.16019917f, -0.06921805f, 
    0.11531971f, 0.05178313f, -0.04695174f, -0.09008557f, 0.05633233f, 0.08402131f, 0.02095026f, 0.04472186f, 
    0.03530086f, 0.06293654f, 0.00722072f, -0.01539960f, -0.23433292f, 0.06401601f, 0.03090159f, 0.08264003f, 
    0.13595048f, -0.05916984f, -0.06709415f, -0.01083638f, 0.02189180f, 0.05746757f, -0.01066468f, 0.10291320f, 
    -0.34709042f, 0.18933623f, 0.05724951f, 0.09259111f, 0.13904957f, 0.11274508f, 0.04112742f, -0.05338986f, 
    0.06702307f, -0.02847064f, -0.02036545f, -0.03998663f, -0.15620145f, 0.16304265f, 0.07607831f, -0.07152475f, 
    0.01604672f, -0.00494143f, -0.05453011f, 0.04367672f, 0.08247715f, -0.03721884f, 0.06107153f, -0.12128909f, 
    -0.18810330f, -0.09690052f, 0.11220896f, -0.29967561f, 0.00490655f, 0.16156033f, 0.03462046f, -0.12855689f, 
    -0.04713060f, 0.02968936f, 0.06337532f, 0.15054108f, 0.05659556f, 0.10183109f, -0.01277814f, -0.16098183f, 
    0.04385352f, 0.00193824f, 0.10227753f, 0.02066844f, -0.00948220f, -0.11204165f, -0.00315823f, -0.14006123f, 
    -0.10665805f, 0.23304012f, 0.18029839f, -0.03252503f, -0.14155240f, -0.05605425f, 0.01119915f, -0.05828346f, 
    -0.03719822f, -0.01482182f, 0.04419683f, 0.04564245f, -0.09337103f, -0.05267224f, 0.15559223f, -0.09168286f, 
    -0.02016276f, -0.02409917f, -0.15111829f, -0.10453215f, -0.01676214f, -0.00616986f, 0.02538314f, 0.03530610f, 
    0.07878733f, 0.05057761f, 0.20806141f, 0.10095852f, -0.01939854f, 0.03941390f, 0.02166713f, 0.05852898f, 
    0.06399412f, 0.07041911f, -0.06930181f, -0.01636028f, -0.09534509f, 0.26051229f, -0.03118183f, 0.10976498f, 
    -0.01236613f, 0.05090223f, -0.12471186f, 0.05425328f, -0.11211962f, -0.01056964f, 0.12311896f, 0.08283810f, 
    -0.42677924f, -0.23786917f, 0.03728575f, -0.07081516f, 0.03498697f, 0.00373513f, 0.07336771f, -0.09575900f, 
    -0.01726833f, 0.02015694f, 0.07654757f, 0.03154377f, 0.16489272f, -0.12939960f, -0.16364710f, 0.23702823f, 
    -0.03418166f, -0.02024658f, -0.08091813f, 0.01764803f, 0.11547349f, -0.04302938f, -0.05857123f, -0.05578605f, 
    -0.01043277f, 0.26647922f, 0.21006501f, -0.36677465f, -0.13116790f, 0.06612656f, 0.03071586f, 0.01589077f, 
    0.03764780f, -0.03579982f, -0.04272594f, -0.04308208f, -0.40430623f, -0.12168351f, -0.08255179f, 0.18103936f, 
    -0.00706599f, -0.02962817f, -0.09565084f, 0.00902814f, -0.08340836f, -0.01403537f, -0.03842786f, 0.04788558f, 
    -0.31546542f, 0.19605570f, -0.12391204f, 0.26956922f, 0.00661016f, 0.05856745f, -0.02261227f, 0.04976414f, 
    -0.13150381f, -0.03316664f, 0.09692886f, -0.02100197f, -0.32622206f, 0.06840735f, 0.12227239f, -0.04136964f, 
    -0.08441220f, 0.03373605f, 0.01364790f, -0.00335483f, -0.14371119f, -0.07047069f, 0.02676298f, 0.12530169f, 
    -0.00009112f, -0.03530547f, 0.00032023f, 0.01802237f, -0.02879418f, 0.01385854f, 0.02799186f, -0.03449486f, 
    -0.02001161f, 0.02341249f, 0.00425673f, -0.03698974f, -0.00255429f, -0.02900054f, -0.00996285f, 0.00868910f, 
    -0.02553459f, 0.02369903f, 0.02688072f, 0.02435172f, -0.04048444f, -0.01184472f, -0.01141200f, 0.01569796f, 
    0.03440828f, 0.00153569f, -0.00221030f, 0.03291065f, 0.01563044f, -0.01517457f, -0.03585655f, 0.02139814f, 
    -0.01421899f, -0.02793768f, 0.01898941f, -0.01624928f, 0.01574096f, -0.01654826f, 0.01961912f, -0.03410744f, 
    0.00634750f, 0.02547892f, 0.01063412f, -0.00553276f, -0.03024509f, 0.01295525f, 0.02780383f, -0.00923607f, 
    -0.00669409f, -0.01844783f, -0.00012193f, -0.02222815f, -0.03234956f, 0.02221207f, -0.00540623f, -0.00531111f, 
    -0.02848304f, 0.01015749f, 0.01847311f, -0.02647438f, 0.01882563f, 0.00156459f, -0.03054387f, -0.01670201f, 
    0.00410877f, -0.01480217f, -0.03424587f, -0.01807803f, -0.01048901f, 0.00131743f, -0.02675842f, -0.03055163f, 
    0.02230089f, 0.02639754f, -0.04258041f, -0.02707978f, -0.04172335f, -0.03073339f, -0.01981733f, 0.01421114f, 
    -0.03536307f, -0.02634686f, -0.00255312f, 0.01066291f, -0.02350109f, 0.04016163f, -0.00416867f, 0.01299740f, 
    0.03502262f, 0.02695282f, -0.00157446f, -0.02317972f, -0.02440053f, 0.02377291f, 0.01064978f, -0.03603204f, 
    -0.01748230f, 0.02054185f, -0.02186904f, 0.02938102f, 0.01541472f, -0.03680878f, -0.02087201f, -0.02334886f, 
    -0.01331209f, 0.04592436f, 0.01547732f, -0.00272630f, 0.00564386f, -0.02246314f, -0.01659194f, 0.01433419f, 
    -0.02538072f, 0.00074134f, 0.02473766f, -0.03739901f, 0.00891535f, -0.02173596f, 0.01879234f, -0.01136857f, 
    0.03046107f, -0.01289388f, -0.03352785f, 0.02366455f, -0.02993064f, -0.00037364f, 0.03370525f, -0.02061604f, 
    -0.00819391f, 0.00769332f, 0.00956110f, 0.01459330f, -0.03474962f, 0.01961294f, -0.01671164f, -0.03498597f, 
    -0.02334297f, 0.03244634f, -0.03115673f, 0.00244960f, 0.00642267f, 0.02194753f, -0.01571759f, -0.01513797f, 
    -0.01815785f, -0.01052764f, -0.00332548f, 0.00937796f, 0.02455519f, -0.03945084f, -0.03630490f, -0.01216519f, 
    0.02868750f, 0.01811166f, -0.02350335f, 0.01003190f, 0.00470987f, 0.01630716f, -0.00978758f, -0.01766763f, 
    -0.03160179f, 0.02956248f, 0.02285768f, -0.00753598f, 0.00468822f, 0.01043691f, -0.02509760f, -0.01052989f, 
    -0.00134589f, -0.01247638f, 0.00136983f, -0.02073761f, -0.00774818f, 0.00514214f, -0.03001409f, -0.04530971f, 
    -0.03970328f, -0.00911433f, 0.01165821f, 0.01150552f, -0.02052344f, -0.00774023f, -0.02220101f, -0.01675640f, 
    0.02954493f, 0.03671100f, -0.01850308f, 0.00540947f, 0.02112107f, 0.01931086f, 0.01750468f, -0.03347448f, 
    0.01519693f, -0.01412584f, -0.02327621f, 0.02601639f, -0.02287689f, 0.02085020f, -0.00816509f, -0.00741640f, 
    -0.02611193f, 0.02314385f, -0.01238838f, -0.04203068f, 0.02877401f, 0.01499826f, -0.00827150f, -0.00578945f, 
    0.02623035f, 0.02754619f, 0.00967683f, -0.00117346f, -0.01131416f, -0.02556351f, 0.02551678f, -0.00607523f, 
    0.02023761f, 0.00880667f, -0.01575310f, 0.01643998f, 0.02181591f, -0.01133369f, 0.00671646f, 0.00423656f, 
    0.02173921f, 0.01777858f, -0.04332270f, -0.00420094f, -0.00328525f, -0.01206231f, 0.01052968f, 0.02956318f, 
    -0.03776165f, -0.02663613f, -0.00944419f, -0.01603300f, -0.02102428f, 0.02558303f, -0.04052950f, -0.00264527f, 
    -0.00448703f, 0.02602688f, -0.03623227f, 0.03983770f, -0.02195515f, -0.02334900f, -0.02976815f, -0.00637192f, 
    -0.03243841f, -0.01311081f, 0.01841099f, -0.03599736f, 0.02761029f, -0.03091754f, 0.00939762f, 0.00932538f, 
    -0.00694445f, -0.01040377f, -0.03242912f, -0.00644509f, -0.02980708f, -0.01212523f, 0.00482658f, -0.00085519f, 
    -0.01499547f, -0.02013830f, 0.01995532f, -0.01474304f, 0.01012892f, -0.00465321f, 0.00561111f, -0.01278166f, 
    -0.02657199f, 0.00846227f, 0.03526522f, -0.01001911f, 0.03206887f, 0.01912799f, -0.01024173f, -0.03224019f, 
    -0.03130509f, -0.00992036f, -0.02408414f, 0.01536681f, -0.00092887f, -0.01839662f, -0.01785325f, -0.03233450f, 
    -0.02164353f, 0.02667371f, -0.00567613f, -0.01855114f, 0.00698080f, -0.03362331f, -0.01075522f, 0.00566204f, 
    0.01210781f, -0.01754891f, -0.04181173f, -0.04188542f, 0.01446493f, -0.01002263f, 0.00837358f, 0.03627391f, 
    0.00211862f, -0.01978019f, -0.02461217f, -0.00859830f, -0.00618898f, -0.01018871f, 0.01950967f, -0.01969170f, 
    0.01619816f, -0.00417903f, -0.02417795f, 0.00727332f, -0.01103015f, 0.01138317f, -0.02042332f, 0.02672052f, 
    -0.04404332f, -0.01875959f, -0.02649601f, 0.03437391f, 0.02267106f, -0.00100976f, 0.02762446f, 0.02128663f, 
    -0.03462178f, -0.01470399f, -0.00730696f, -0.01490365f, -0.04082625f, -0.03428056f, 0.01872650f, -0.02567897f, 
    0.01577336f, -0.00751022f, 0.02329108f, 0.02059808f, -0.02075461f, 0.02850956f, -0.00633403f, -0.00422476f, 
    -0.01227302f, 0.01017240f, 0.02770776f, -0.01545247f, 0.00227607f, -0.02591854f, -0.03110485f, -0.00339131f, 
    0.02251303f, -0.03018398f, 0.02338466f, 0.02292700f, -0.02505948f, 0.01105812f, -0.01349655f, -0.00150395f, 
    0.03372001f, 0.03709206f, -0.01648239f, 0.00471633f, -0.03204530f, 0.04081650f, -0.01241303f, -0.03269748f, 
    0.02353308f, -0.04124024f, -0.00764319f, -0.00223868f, 0.02420393f, 0.00136080f, 0.01866813f, -0.00326296f, 
    -0.00688521f, -0.00398144f, -0.02524535f, -0.03460143f, -0.01891761f, -0.00342970f, 0.02127772f, -0.02055254f, 
    0.03663287f, 0.03146511f, 0.02682466f, 0.00602494f, -0.01144954f, -0.01612963f, -0.01174076f, 0.00992144f, 
    0.00473759f, -0.02775651f, 0.02121841f, -0.02639634f, -0.03169814f, -0.02793754f, -0.03169016f, 0.02943996f, 
    -0.02829502f, 0.03558552f, 0.01861516f, -0.03944501f, -0.00772464f, -0.00159738f, -0.00478146f, -0.03486132f, 
    -0.01741832f, -0.02835092f, -0.03209901f, -0.03546765f, 0.00252497f, -0.03676937f, 0.01879129f, 0.01899629f, 
    -0.00947448f, 0.01472338f, 0.00151910f, -0.00430009f, 0.01491740f, -0.00846671f, -0.01879263f, -0.01023739f, 
    -0.00639617f, 0.00210537f, -0.01277082f, -0.00424157f, -0.03702103f, -0.01791704f, 0.01701794f, 0.01589233f, 
    -0.02605821f, -0.00766326f, -0.00770237f, 0.01834353f, -0.00720395f, 0.03731918f, -0.00662137f, 0.03110538f, 
    0.02203074f, -0.01736312f, -0.01073766f, -0.03612841f, 0.03159517f, -0.00147833f, -0.00336799f, 0.04031713f, 
    0.00913905f, -0.03810646f, 0.01685447f, 0.00491940f, -0.02713753f, 0.01542638f, 0.01626209f, -0.03294575f, 
    -0.03742966f, 0.01938988f, 0.03235879f, -0.00012266f, -0.00429817f, -0.01467362f, -0.03143841f, -0.00172905f, 
    -0.03128880f, 0.01605736f, -0.02935882f, -0.01511932f, -0.02093056f, 0.02864860f, -0.02265213f, -0.03665296f, 
    0.01159923f, 0.02559082f, 0.00567242f, -0.02850348f, -0.03526995f, 0.00624398f, -0.03005780f, -0.04147112f, 
    0.00742815f, 0.00170518f, -0.00250813f, -0.00879854f, 0.02241118f, -0.01604567f, -0.00349614f, 0.00934117f, 
    0.00075757f, 0.00826089f, -0.00489897f, 0.00708546f, -0.03530566f, 0.02522903f, -0.03526258f, -0.00309510f, 
    -0.00671564f, 0.02696286f, 0.00238228f, -0.02381722f, 0.00714376f, 0.01332099f, -0.03897059f, 0.00445648f, 
    -0.00422233f, 0.00063581f, -0.04273721f, -0.00521600f, -0.02249363f, 0.02427938f, -0.02409645f, 0.00761930f, 
    0.02689326f, -0.00082729f, -0.03201756f, 0.01865389f, 0.02562287f, 0.00459977f, -0.01948005f, -0.02605535f, 
    0.02036394f, 0.02473500f, -0.00202002f, 0.00127276f, 0.02006285f, 0.01905954f, 0.02090333f, -0.00948094f, 
    -0.01563412f, -0.00849730f, 0.03447986f, 0.00532136f, -0.03816521f, 0.00169655f, -0.04286316f, -0.01236875f, 
    -0.00015490f, 0.01719214f, -0.03419860f, -0.03527715f, 0.01911521f, 0.02351350f, 0.01761505f, 0.02511609f, 
    -0.02745472f, 0.01888906f, 0.01816667f, 0.02023722f, -0.04012150f, 0.01437409f, 0.02773620f, -0.04038243f, 
    0.03121288f, -0.00931292f, 0.02602959f, -0.02960732f, -0.00294544f, -0.00046392f, -0.01587016f, -0.03782503f, 
    -0.02723288f, -0.02293102f, 0.03450631f, -0.00379949f, 0.02499391f, 0.01795969f, -0.03061733f, 0.01627930f, 
    0.02409199f, 0.02588820f, 0.01557485f, -0.04204470f, -0.00470367f, -0.02197730f, 0.03072999f, -0.02823999f, 
    -0.01768566f, 0.00053874f, 0.03142156f, -0.01512543f, -0.00261902f, -0.02397685f, 0.02265737f, -0.00163762f, 
    0.02751572f, 0.01741027f, -0.00232549f, 0.02990563f, -0.02844941f, 0.03242950f, 0.02400226f, -0.00933328f, 
    -0.00699811f, 0.00448883f, 0.01078968f, -0.02340305f, 0.02572177f, 0.00487882f, 0.03266748f, 0.02327266f, 
    0.00537194f, -0.01601837f, 0.00135806f, 0.01616660f, -0.03099292f, -0.00972767f, -0.01093633f, -0.00111332f, 
    0.03248554f, -0.00057070f, -0.02572664f, 0.01643400f, -0.02317645f, -0.03594472f, 0.01061949f, -0.03694927f, 
    -0.02777387f, 0.00898989f, -0.02720750f, 0.00085778f, -0.03811936f, -0.04023279f, -0.00206657f, -0.04327974f, 
    -0.02700220f, -0.02307485f, -0.01898138f, -0.02455272f, -0.03896883f, -0.02105337f, 0.01662275f, -0.03505710f, 
    -0.02686801f, -0.03194002f, 0.02426352f, 0.00027799f, -0.03714016f, 0.02492442f, 0.02423885f, 0.00556687f, 
    0.02132290f, 0.00270588f, 0.02773958f, 0.02439726f, 0.02409095f, -0.01220758f, -0.01457132f, 0.02455741f, 
    0.01597907f, -0.03081643f, 0.02083275f, 0.01433771f, -0.00757198f, -0.02855797f, 0.00881577f, -0.03303539f, 
    0.01234297f, -0.00818208f, -0.00179322f, -0.00107775f, -0.04351255f, 0.02659229f, -0.01799808f, 0.02986228f, 
    -0.02969236f, -0.00321285f, -0.00673872f, -0.03555085f, -0.00417605f, -0.00009765f, -0.00245983f, -0.02562923f, 
    -0.04319017f, -0.03429390f, 0.02439338f, 0.00713723f, -0.02468629f, -0.02697642f, 0.00645946f, 0.00449975f, 
    0.00167499f, 0.02086017f, -0.02303115f, -0.03161137f, -0.01933689f, 0.01171167f, 0.00287497f, -0.01071817f, 
    -0.01069719f, 0.00594609f, 0.02651739f, -0.01642608f, 0.00781059f, 0.01284641f, 0.00761532f, -0.02689743f, 
    0.01448598f, 0.01406707f, 0.01492393f, 0.02764492f, 0.02814512f, -0.01155716f, 0.02232056f, -0.03411508f, 
    0.02051263f, -0.00796088f, -0.01001106f, 0.00417395f, 0.00728867f, -0.00510173f, 0.00966631f, -0.00343308f, 
    0.01526688f, -0.02184721f, -0.00920791f, 0.00989910f, -0.01436900f, 0.01846190f, -0.00293612f, 0.02683255f, 
    -0.01768426f, 0.01073751f, -0.02054112f, 0.03279632f, -0.01434962f, -0.01109899f, 0.02460546f, -0.02689980f, 
    -0.03851297f, -0.00052031f, 0.01796046f, 0.01730167f, -0.01452113f, -0.00606466f, -0.04114464f, -0.03177656f, 
    -0.00928563f, -0.01038054f, 0.01685067f, 0.02010378f, 0.01677430f, -0.04309138f, -0.00220814f, 0.00002271f, 
    -0.00893365f, -0.00832149f, -0.00301996f, -0.01008979f, -0.00294107f, 0.02343915f, -0.00707467f, -0.03306010f, 
    -0.00988077f, 0.00562021f, 0.02286496f, 0.01047519f, 0.02541822f, 0.02051919f, 0.01277985f, -0.00109603f, 
    0.00502917f, 0.03408888f, 0.01796320f, 0.01049489f, -0.04304342f, -0.01444742f, -0.01235299f, -0.03138044f, 
    -0.03519962f, 0.00500184f, -0.03682730f, 0.02239495f, -0.03384766f, 0.01349752f, 0.00502382f, -0.02807737f, 
    0.01534218f, 0.00522633f, 0.01250819f, -0.02109644f, -0.01556714f, 0.03291322f, 0.01528970f, -0.01177095f, 
    -0.03679064f, -0.00491578f, -0.01042158f, -0.00751272f, 0.02647345f, -0.01350509f, 0.00373523f, -0.04296305f, 
    0.02248436f, 0.01207623f, -0.02746295f, 0.01221692f, 0.02148597f, -0.02731890f, 0.02588057f, -0.00653534f, 
    -0.00160422f, -0.02583770f, 0.01909248f, -0.02122140f, 0.01093800f, -0.02058156f, -0.04272650f, 0.02017320f, 
    0.00913267f, -0.00359608f, 0.00441855f, -0.03383060f, -0.01474659f, 0.02706550f, -0.00281197f, 0.01407464f, 
    -0.03859610f, 0.01783681f, 0.02630887f, -0.02911503f, 0.02819050f, -0.02521119f, -0.01581952f, -0.00524188f, 
    -0.01112355f, 0.02137640f, -0.01759331f, -0.00701318f, -0.02588068f, -0.02192767f, -0.03962057f, 0.02426304f, 
    -0.02791251f, -0.03171191f, 0.01787289f, 0.01237170f, -0.02626594f, 0.01888191f, -0.01696521f, -0.03835801f, 
    0.00405599f, -0.01582703f, -0.03300190f, -0.01313453f, -0.02105832f, -0.03819625f, 0.00103999f, -0.00477429f, 
    -0.00305563f, -0.02413973f, -0.04072146f, 0.02331779f, -0.01759347f, -0.01716582f, -0.01560719f, -0.02970513f, 
    -0.03367171f, -0.00343382f, 0.02330290f, 0.02780549f, -0.00166810f, 0.02244822f, -0.02883428f, -0.01710920f, 
    0.02788965f, -0.03344062f, 0.02288637f, -0.02100751f, -0.03739588f, 0.02680571f, 0.00123085f, 0.00558935f, 
    -0.00722010f, -0.03298469f, -0.00770623f, -0.01727356f, -0.03582104f, -0.03077316f, -0.00096027f, -0.00923957f, 
    0.02120446f, 0.02085110f, -0.01067157f, -0.03188327f, 0.00905979f, 0.00866673f, -0.04272180f, -0.03966699f, 
    -0.04351182f, -0.00973368f, -0.01164583f, 0.01740854f, -0.04128973f, -0.03445272f, 0.00104845f, 0.02104767f, 
    -0.04078821f, -0.00595373f, -0.00837989f, 0.00441914f, -0.04170538f, -0.03841707f, 0.02056618f, 0.02112161f, 
    -0.02661595f, 0.00885111f, 0.00796739f, -0.03238090f, 0.02205171f, -0.01760835f, -0.00375888f, 0.00277970f, 
    -0.01026250f, -0.01170677f, -0.03675118f, 0.01255612f, 0.02505361f, 0.02334417f, -0.02617422f, 0.00881829f, 
    -0.03314623f, -0.02322038f, -0.03442138f, 0.02429312f, 0.01777991f, -0.00846846f, -0.04410106f, -0.00399965f, 
    0.00035413f, -0.00341593f, -0.03345915f, 0.00360286f, -0.01439576f, 0.02690220f, -0.01228832f, -0.03293980f, 
    -0.02740932f, -0.02894475f, -0.01638684f, 0.02274226f, 0.01428451f, -0.03360346f, -0.01652351f, -0.00935592f, 
    -0.04254276f, 0.01055381f, 0.01214727f, -0.03252084f, -0.01412708f, -0.00293895f, -0.01013713f, -0.01132745f, 
    -0.00424904f, 0.01058359f, -0.01635858f, 0.02770520f, -0.02439760f, -0.03319386f, -0.01204441f, -0.01196746f, 
    -0.03583628f, -0.00348523f, 0.02002639f, 0.01502561f, -0.03714918f, -0.03298177f, 0.02522135f, 0.01420981f, 
    0.01210943f, -0.01172693f, -0.00098186f, 0.00154823f, -0.00505443f, 0.02833612f, -0.03787024f, -0.00519897f, 
    0.02017010f, 0.00656391f, -0.00348271f, -0.00668528f, 0.02876008f, -0.02850177f, 0.01331653f, 0.00329014f, 
    0.00955190f, 0.02627826f, -0.02697595f, -0.01225895f, -0.02625193f, -0.00396246f, 0.01659773f, -0.04203292f, 
    0.02783947f, 0.02048615f, -0.00795151f, 0.02949847f, -0.00977661f, -0.02229728f, -0.03579172f, -0.02807637f, 
    0.01537614f, -0.00176074f, 0.01041960f, -0.03870462f, -0.01382487f, -0.01560355f, -0.02113358f, -0.01434650f, 
    0.00887015f, 0.00749018f, 0.01314702f, -0.02657733f, -0.01944885f, -0.03999778f, -0.04007031f, 0.02846446f, 
    -0.03680960f, -0.02333960f, 0.00305583f, 0.02503412f, -0.02092472f, -0.00212668f, 0.00677057f, 0.02272888f, 
    0.02569748f, -0.02391208f, -0.03272492f, -0.01516868f, 0.02430093f, -0.01078896f, -0.01458423f, -0.02735963f, 
    0.02271862f, 0.00616015f, 0.00393691f, -0.00236920f, -0.02458445f, -0.01385233f, -0.01252814f, 0.02554380f, 
    -0.02447469f, -0.00582206f, -0.00961635f, 0.01306927f, 0.02663071f, 0.02587339f, -0.02326676f, -0.02859276f, 
    0.01617556f, 0.03853017f, 0.02018532f, -0.00721634f, -0.01454832f, -0.03062789f, 0.02879681f, 0.01108123f, 
    -0.03656306f, 0.01678506f, 0.01926330f, -0.01187353f, -0.00237213f, 0.01361795f, -0.02179902f, -0.01667491f, 
    -0.04326132f, 0.01645188f, 0.02173391f, 0.02644719f, -0.02107535f, 0.01474529f, 0.01936160f, -0.02266410f, 
    -0.01942318f, 0.00847030f, -0.03908241f, -0.02887116f, 0.00240990f, -0.03189811f, -0.00619849f, -0.03192083f, 
    0.02012725f, 0.01490252f, 0.00715374f, -0.03616585f, -0.01288562f, -0.01519375f, 0.02560847f, -0.00832313f, 
    -0.02561861f, -0.01188269f, 0.00116365f, -0.00064096f, -0.00191380f, 0.00391590f, -0.02885709f, -0.02496846f, 
    0.02362415f, 0.02740578f, 0.02229845f, 0.00920998f, 0.00867664f, 0.02839886f, -0.02550518f, 0.00874791f, 
    -0.04040815f, 0.00547425f, 0.00405856f, -0.01124325f, -0.01480122f, 0.02361828f, -0.04217819f, 0.02991391f, 
    0.01019571f, 0.01509268f, -0.03579393f, -0.04190959f, -0.03390093f, 0.00198281f, -0.02176686f, 0.01363345f, 
    -0.04226030f, 0.00347362f, -0.03097014f, 0.00557405f, 0.02402434f, -0.02835530f, -0.02406418f, 0.00268033f, 
    -0.00956818f, -0.04219325f, -0.02094116f, 0.03555715f, 0.02325371f, 0.01226194f, 0.01247465f, 0.00312175f, 
    -0.03047030f, 0.02405283f, -0.02825352f, 0.00579077f, -0.01308163f, -0.01662199f, -0.00042233f, -0.00168854f, 
    0.01211083f, -0.02199351f, -0.02332260f, -0.03309554f, 0.00228922f, -0.01505564f, -0.01152769f, -0.01234719f, 
    -0.03721070f, 0.01326654f, -0.01382225f, 0.02587156f, -0.02796952f, -0.03847318f, -0.00201294f, -0.03912253f, 
    0.00135024f, -0.02758340f, -0.02664983f, 0.02080597f, 0.00479650f, -0.02688831f, 0.01577011f, -0.03794054f, 
    -0.00610276f, 0.00785836f, -0.01375568f, -0.03181103f, 0.02642239f, 0.01606968f, 0.00090740f, -0.00456386f, 
    0.01659915f, -0.02877293f, -0.00141251f, -0.04107909f, -0.01098839f, -0.01668549f, -0.01424250f, -0.04002857f, 
    -0.04253215f, 0.01147031f, 0.00087688f, -0.02864908f, -0.01448789f, -0.01204514f, -0.03809264f, -0.00691578f, 
    -0.02552759f, -0.01837148f, -0.01913856f, 0.00647173f, -0.02711840f, 0.02551146f, -0.01088436f, -0.03622263f, 
    -0.02043479f, -0.00285199f, -0.02462016f, 0.02052943f, -0.03876064f, -0.02472392f, 0.00035681f, 0.01139608f, 
    -0.03364180f, -0.03463145f, -0.00993768f, 0.00281286f, 0.00511671f, -0.01090956f, 0.01114430f, -0.04213981f, 
    -0.03058594f, 0.02058112f, 0.01360484f, -0.02934548f, -0.00219332f, -0.03707488f, -0.03849955f, 0.01262069f, 
    -0.03421353f, -0.00776742f, -0.02648675f, 0.00291894f, -0.02796896f, -0.02929658f, 0.01555771f, -0.02046461f, 
    -0.02011340f, 0.02592844f, 0.01027438f, 0.00821464f, -0.00832547f, -0.02787241f, 0.00883070f, 0.01557098f, 
    -0.03468877f, -0.01118412f, -0.03753053f, -0.04219038f, -0.04043778f, -0.02529368f, -0.00709302f, 0.02839004f, 
    0.00069481f, -0.03688787f, 0.01591729f, -0.02909779f, -0.01959944f, -0.02349117f, -0.00200854f, 0.01698805f, 
    -0.02568057f, -0.03845180f, -0.00490093f, -0.01396794f, -0.00484247f, -0.03328821f, 0.02578962f, -0.00796844f, 
    0.00438198f, 0.02315632f, 0.00472825f, 0.02705229f, 0.00527390f, -0.02516725f, -0.04194584f, 0.01808711f, 
    0.00650992f, 0.01080533f, 0.02748950f, -0.04293805f, 0.01290069f, -0.02170570f, -0.03286662f, 0.00978217f, 
    -0.02619999f, -0.01152081f, 0.01793719f, -0.03123365f, 0.01616661f, -0.01449457f, -0.00935225f, 0.02506460f, 
    0.02348373f, 0.01144014f, 0.02236624f, -0.00293161f, -0.04107175f, 0.01135651f, 0.01943222f, 0.00093142f, 
    -0.00097055f, 0.02664050f, -0.01406145f, -0.04131885f, -0.01154733f, -0.02680049f, -0.03892978f, -0.00951086f, 
    -0.04040126f, -0.04299565f, 0.02682213f, -0.01991418f, -0.02179501f, -0.03257479f, -0.03496814f, -0.03876212f, 
    -0.03495281f, -0.01359355f, 0.00747520f, 0.02640121f, -0.01402499f, 0.02658211f, -0.01986219f, 0.01842005f, 
    -0.03773922f, -0.00868287f, -0.02431083f, -0.02623642f, -0.02726373f, -0.00606149f, -0.02724376f, -0.00736588f, 
    0.02557131f, -0.02983481f, 0.02749939f, 0.01998214f, -0.02733673f, 0.02323259f, -0.01710336f, 0.00205363f, 
    0.02235587f, 0.01542410f, -0.00507271f, -0.02609334f, -0.01235189f, 0.02430205f, 0.00161086f, -0.00216610f, 
    0.01878280f, -0.02520978f, -0.00838547f, -0.03178218f, -0.02859503f, -0.04112360f, -0.01906853f, -0.03556632f, 
    -0.02504907f, 0.02634215f, -0.01347457f, -0.01043680f, 0.01860895f, -0.02904077f, -0.03421573f, 0.02537534f, 
    0.01784736f, 0.02097606f, -0.02372744f, -0.00336440f, -0.03635420f, -0.03563914f, -0.01205183f, -0.01474850f, 
    -0.02507920f, -0.01972324f, 0.02490601f, -0.02276981f, -0.02541824f, 0.00550522f, -0.02626836f, 0.00174796f, 
    -0.01404709f, -0.01032894f, -0.01352768f, 0.00033233f, -0.03696406f, -0.03810007f, 0.02307172f, -0.02737104f, 
    0.02707616f, 0.01107191f, 0.01903480f, -0.01238307f, -0.01545787f, -0.03023442f, -0.01251709f, -0.00227610f, 
    0.02371675f, 0.02805323f, 0.00663281f, -0.02675513f, -0.03476601f, 0.00665200f, -0.00269791f, 0.00993355f, 
    0.02016877f, -0.00033199f, 0.02013824f, -0.03714082f, -0.04054594f, 0.00763557f, -0.01861370f, 0.02753616f, 
    -0.04017617f, -0.02524338f, -0.01674665f, -0.01482177f, -0.00797345f, 0.01666152f, -0.03116424f, -0.03297921f, 
    0.02729482f, -0.03486221f, 0.00245887f, -0.02461157f, 0.02969325f, 0.00597833f, -0.03423266f, -0.02490647f, 
    -0.01291951f, -0.01488631f, 0.02661752f, -0.03983809f, 0.02785572f, -0.02378061f, 0.02330072f, 0.02918716f, 
    -0.01511533f, -0.01904904f, 0.00364585f, 0.00809386f, 0.00944404f, 0.01289326f, 0.01253004f, -0.03655854f, 
    0.00756136f, -0.03706237f, -0.03699113f, -0.01022766f, -0.03413016f, -0.00063616f, -0.03591564f, -0.03097222f, 
    -0.03921130f, -0.00272406f, -0.03484300f, 0.02352898f, 0.00525171f, 0.00014166f, 0.00346184f, -0.02215572f, 
    -0.01158122f, -0.02507824f, 0.00408980f, -0.04221094f, -0.01135257f, 0.00070102f, 0.01063009f, -0.00787540f, 
    -0.03268211f, -0.02394931f, 0.01211323f, 0.02201164f, 0.02598173f, 0.01744247f, -0.02817029f, -0.04294138f, 
    -0.02767622f, -0.00276919f, 0.00997170f, 0.00295957f, 0.01037737f, 0.00864045f, -0.00440136f, -0.02610962f, 
    0.02690902f, -0.00341291f, -0.03103770f, -0.01265491f, 0.01710796f, 0.00870506f, -0.02351607f, -0.01893327f, 
    -0.02703344f, 0.02891204f, 0.00157583f, 0.01196853f, -0.02698991f, 0.01762653f, 0.00801819f, -0.01076885f, 
    0.01797859f, -0.02038462f, 0.02425484f, -0.01158860f, 0.01916680f, -0.03017800f, 0.00931799f, 0.00495694f, 
    -0.02484475f, 0.01135630f, -0.01143672f, -0.02316377f, -0.02706090f, 0.02140587f, -0.02600405f, -0.03710796f, 
    0.01578762f, 0.01401231f, -0.01494354f, 0.00261610f, 0.01800127f, -0.02748521f, -0.02506119f, 0.01517013f, 
    0.00485570f, -0.03509514f, 0.00665249f, -0.03944728f, -0.01953138f, -0.04282256f, -0.02845627f, -0.00255451f, 
    -0.01528911f, -0.04394237f, 0.02289631f, 0.02454505f, 0.00667394f, -0.01536258f, -0.00362522f, -0.03142916f, 
    -0.02067261f, 0.00529929f, 0.00822253f, -0.00080850f, 0.00448908f, 0.02551662f, -0.02370387f, -0.03682492f, 
    -0.00128805f, 0.01536764f, -0.02961181f, -0.01617057f, -0.01287938f, -0.01837911f, -0.00303523f, -0.03932937f, 
    -0.01177209f, -0.02622185f, -0.01792091f, -0.03171608f, -0.00494832f, 0.00382541f, 0.01832945f, 0.00007460f, 
    -0.01899752f, -0.02062648f, 0.00413979f, -0.02703465f, -0.02113472f, -0.00152906f, -0.01698101f, -0.03818053f, 
    0.00388996f, -0.01333354f, -0.04010558f, -0.02826659f, -0.02036762f, 0.00337335f, -0.01894936f, -0.02794269f, 
    -0.00134343f, 0.02819569f, -0.00902885f, 0.00330057f, -0.00683476f, 0.01116921f, 0.01674460f, 0.00011281f, 
    0.00619746f, -0.03719557f, -0.03139557f, -0.03528432f, -0.00924181f, -0.01101830f, -0.02212121f, -0.01544366f, 
    -0.02425193f, 0.02711850f, 0.01454224f, 0.00418658f, 0.00848634f, -0.03313220f, -0.01792982f, -0.01688414f, 
    -0.03869574f, -0.00261563f, 0.01902279f, -0.01180707f, -0.02231198f, -0.01977026f, 0.02078412f, -0.02899614f, 
    -0.03306063f, 0.02192005f, 0.00368004f, -0.01200697f, 0.00613604f, -0.03809609f, -0.01402869f, 0.02827718f, 
    -0.03263671f, 0.03944734f, 0.00391288f, -0.02464872f, 0.00638978f, -0.03229197f, 0.02654328f, -0.01756347f, 
    -0.02368230f, -0.00769371f, 0.02582673f, -0.00475354f, 0.00014230f, -0.03640646f, -0.01310383f, -0.03456984f, 
    0.00205927f, 0.01642564f, -0.01286577f, 0.02006590f, 0.02466832f, -0.03924596f, -0.02441866f, 0.02938892f, 
    -0.03687393f, 0.02804988f, 0.02386550f, 0.01941514f, -0.00204243f, -0.01956222f, -0.00845442f, 0.02624751f, 
    0.02954772f, -0.01078640f, -0.03776946f, -0.00192425f, -0.01688812f, -0.01823042f, -0.02094292f, 0.02606785f, 
    -0.03486873f, -0.01675319f, -0.03285927f, -0.02444251f, -0.01690593f, 0.00904750f, -0.01261838f, -0.00893714f, 
    0.02337673f, -0.00321219f, -0.03838252f, 0.01974314f, -0.03694106f, -0.01932463f, 0.00034951f, -0.00476293f, 
    -0.01552445f, -0.00433531f, -0.01371668f, -0.00644905f, -0.03614166f, 0.02208824f, 0.01906477f, -0.03980744f, 
    -0.02102140f, -0.01095160f, 0.02512958f, -0.02722766f, -0.01135694f, -0.01856916f, -0.02868812f, -0.03939035f, 
    -0.02815070f, -0.01437680f, -0.00927265f, -0.03450562f, 0.01092250f, 0.01439015f, 0.01401090f, -0.03993975f, 
    -0.02308475f, -0.01870397f, -0.03387844f, -0.03744998f, 0.02469553f, -0.01412832f, 0.02469685f, -0.00679425f, 
    0.02665388f, -0.00653202f, 0.00211996f, -0.00883150f, -0.01155105f, -0.02709237f, -0.01156102f, 0.01201205f, 
    -0.01014586f, -0.03827080f, -0.02257917f, 0.01356899f, 0.01277490f, -0.03477588f, -0.00833898f, 0.01196050f, 
    0.02292891f, -0.03803847f, -0.00891179f, -0.00175660f, -0.02640941f, -0.03451944f, 0.02904455f, 0.02835947f, 
    0.02288406f, 0.00526384f, -0.00292480f, 0.02330396f, 0.00624604f, 0.02952168f, -0.00889358f, -0.02607202f, 
    -0.03163835f, 0.02656231f, 0.02750108f, -0.02530053f, -0.03976504f, 0.01345219f, -0.02511888f, 0.02863726f, 
    0.02972762f, -0.01808863f, -0.01148997f, 0.01768516f, 0.00443554f, 0.00823563f, -0.03620819f, -0.04205629f, 
    0.02687715f, -0.00870334f, -0.00082050f, -0.00913532f, -0.03894570f, 0.02278313f, 0.00901651f, 0.00463634f, 
    -0.02662370f, 0.02398873f, -0.03520236f, -0.03067282f, -0.03940843f, -0.02227199f, 0.01404136f, 0.00790095f, 
    -0.00730972f, -0.03132569f, -0.03622337f, 0.01036502f, 0.00158416f, 0.01741921f, 0.01752532f, -0.01966029f, 
    -0.00883031f, -0.00362541f, 0.00590639f, -0.02692450f, -0.00849023f, -0.01908585f, 0.03006071f, -0.01206048f, 
    0.02069397f, 0.01683487f, -0.02663741f, 0.01404112f, 0.01095039f, -0.02510627f, -0.01263555f, 0.00040570f, 
    -0.01811214f, 0.00010561f, -0.03678488f, 0.02562162f, 0.00094425f, 0.00664205f, -0.02929982f, -0.02201004f, 
    -0.03678904f, -0.03606972f, -0.02809902f, -0.03999474f, -0.00059931f, 0.02852286f, -0.03900146f, -0.01905052f, 
    -0.00172232f, 0.00279144f, 0.01754374f, 0.00299802f, -0.03454207f, -0.00630152f, -0.01500791f, -0.00788114f, 
    -0.03236848f, -0.01801288f, 0.01394751f, 0.00858989f, -0.03963804f, 0.02210347f, -0.00804299f, -0.01614355f, 
    0.01192030f, -0.03118083f, -0.03671000f, 0.03002812f, -0.01757862f, 0.01693300f, 0.00560014f, -0.00923431f, 
    -0.03137578f, -0.00686910f, 0.01607554f, -0.03400876f, -0.00841318f, 0.01966117f, 0.02911336f, 0.03007321f, 
    -0.04036047f, 0.02916154f, -0.00089297f, 0.01918719f, 0.02626608f, -0.03315856f, -0.00939449f, -0.00100404f, 
    0.02177367f, 0.01605960f, -0.01502649f, 0.01440636f, -0.02172539f, -0.02299821f, 0.00208793f, 0.02186015f, 
    0.00716630f, 0.02994744f, 0.00158017f, 0.01501074f, -0.00088560f, -0.02398184f, 0.02503538f, -0.03802814f, 
    0.01301673f, -0.03312573f, -0.00782051f, -0.00172443f, 0.02254535f, -0.00825575f, -0.01782004f, 0.02095080f, 
    0.02936093f, -0.01692531f, 0.02009249f, -0.01220349f, 0.02537077f, 0.01627915f, 0.00803167f, -0.01126983f, 
    0.00371380f, -0.02709992f, 0.01773534f, -0.01095467f, -0.01939300f, -0.00417741f, -0.03301197f, -0.02146724f, 
    0.02107414f, -0.00308038f, 0.02012759f, -0.00550398f, -0.02429283f, 0.02783010f, -0.00687042f, 0.02962914f, 
    -0.02314745f, -0.02350499f, -0.00153672f, -0.01905124f, 0.00889038f, 0.02032169f, -0.01533286f, 0.01360098f, 
    -0.03182222f, 0.02293666f, -0.03120081f, -0.01903085f, 0.02271799f, 0.02894745f, -0.02245841f, -0.00355038f, 
    -0.03629652f, 0.02459833f, 0.00966849f, 0.01212380f, -0.00488035f, -0.02852664f, 0.00577190f, -0.03143823f, 
    0.02293780f, -0.00324654f, 0.00953319f, -0.03609065f, 0.02033012f, -0.01216594f, -0.02050142f, 0.00668852f, 
    0.02351018f, 0.02770938f, -0.03197525f, -0.02127041f, 0.01644567f, -0.01679957f, -0.03801104f, -0.00542514f, 
    0.02159391f, -0.00998153f, 0.00954098f, -0.02704894f, -0.01054488f, -0.02216541f, -0.02977606f, -0.01410726f, 
    -0.01849691f, -0.00128394f, -0.01399501f, 0.00870020f, 0.00914797f, -0.00015112f, 0.01602800f, -0.02027586f, 
    -0.03631405f, 0.00989575f, 0.01041001f, -0.03521293f, -0.02627992f, 0.02119929f, 0.00540510f, 0.00095168f, 
    -0.01482264f, 0.01035940f, 0.02208415f, 0.01425049f, 0.02683444f, 0.00264755f, 0.02639253f, -0.00282100f, 
    0.00673676f, 0.00871271f, -0.04080518f, -0.00893525f, 0.01841606f, -0.01833187f, 0.01073042f, 0.00189932f, 
    0.00881603f, 0.02912366f, 0.00479746f, -0.02318456f, 0.00561420f, 0.01598756f, -0.02294949f, -0.03708451f, 
    -0.03388782f, -0.03058914f, -0.02581900f, -0.02601848f, 0.01602449f, -0.02509008f, -0.01889996f, 0.02791344f, 
    0.02652503f, 0.00966443f, -0.02336617f, 0.02811686f, -0.03455790f, 0.01523043f, -0.01448603f, 0.00746511f, 
    0.00610942f, -0.03858440f, 0.00393576f, -0.01615453f, -0.03539486f, 0.00395362f, 0.00416566f, -0.01214615f, 
    0.00071056f, -0.02225366f, 0.01213287f, -0.01111552f, 0.01100046f, -0.03710956f, -0.03342540f, 0.01589206f, 
    0.01041892f, 0.00533064f, -0.01599189f, -0.01888460f, -0.01003657f, 0.00432387f, -0.02561290f, 0.01263492f, 
    -0.03406132f, -0.00031460f, 0.01198435f, -0.01691599f, -0.02167428f, 0.00106638f, -0.00145378f, -0.00703500f, 
    0.01514334f, 0.00641230f, -0.03601424f, -0.02883448f, 0.01655446f, 0.02204327f, 0.00935771f, 0.01088805f, 
    0.01056367f, -0.02108856f, 0.02012761f, -0.01558495f, -0.01908375f, -0.03026265f, 0.02180705f, 0.02332615f, 
    -0.02877018f, -0.01189663f, -0.02171326f, -0.02256425f, -0.04190983f, 0.01617116f, -0.02319455f, 0.02215198f, 
    -0.02828601f, -0.00419985f, -0.03928547f, -0.02974258f, 0.00261222f, -0.02908084f, -0.03491367f, 0.02873251f, 
    -0.03800247f, -0.02837531f, -0.01001301f, 0.01645971f, 0.00939360f, 0.00564186f, -0.00630981f, -0.02112836f, 
    -0.03439014f, -0.01801185f, -0.02230347f, 0.02839310f, -0.04128918f, -0.01516546f, 0.00646221f, -0.03648481f, 
    -0.03547376f, -0.02988637f, 0.01558746f, -0.03148337f, -0.01776909f, -0.02846871f, -0.03101728f, -0.00227802f, 
    0.01976726f, -0.03712557f, 0.00491526f, 0.01742432f, -0.00433739f, 0.01307032f, -0.01230540f, -0.02342315f, 
    0.00194851f, 0.01331403f, 0.02194378f, -0.01933018f, -0.01587444f, 0.01907458f, -0.02927534f, -0.01162596f, 
    0.02842618f, 0.01993495f, 0.00505588f, 0.01227811f, -0.02431959f, 0.01891987f, -0.00721537f, -0.03495657f, 
    0.00353928f, 0.01649070f, -0.01658598f, -0.00423194f, -0.01844102f, 0.02637474f, -0.00428451f, 0.01994601f, 
    -0.01146405f, 0.00219922f, 0.02701311f, -0.02065797f, -0.00839156f, 0.02968790f, 0.01887956f, -0.01978930f, 
    -0.03555165f, 0.01382391f, 0.00175322f, -0.03088244f, -0.01649568f, 0.02488459f, 0.00321667f, 0.01877519f, 
    -0.00785068f, -0.01900354f, 0.00055020f, 0.01727853f, 0.01428400f, 0.01879040f, -0.01890058f, -0.03477749f, 
    -0.00953179f, 0.01291387f, -0.02344952f, 0.02409511f, -0.03485763f, -0.02411859f, 0.02433407f, 0.02866269f, 
    -0.04043198f, -0.03076547f, -0.01935277f, -0.01876434f, -0.03844278f, -0.02917344f, -0.02237650f, -0.01181084f, 
    -0.02441297f, 0.02005203f, 0.01279860f, 0.01005450f, -0.03210453f, 0.02012887f, -0.01454145f, -0.03121942f, 
    -0.01229069f, -0.02851409f, -0.00853772f, -0.00722796f, 0.01001806f, -0.02146129f, 0.02864823f, 0.02375231f, 
    -0.03884102f, -0.01280669f, 0.01662658f, -0.01017856f, -0.00201938f, 0.00549355f, -0.01071107f, -0.03465167f, 
    -0.00045316f, -0.01912415f, -0.02694097f, -0.01544060f, -0.01735154f, -0.01558728f, 0.02748278f, -0.03138405f, 
    0.02039799f, -0.02091259f, 0.00684743f, 0.00188302f, -0.03198846f, -0.03739944f, 0.00859298f, -0.02739354f, 
    -0.00581816f, -0.00513843f, -0.02264347f, -0.00756789f, 0.01162165f, 0.01148643f, 0.01885299f, -0.03913517f, 
    -0.03958949f, -0.01636184f, 0.00309479f, 0.02118636f, -0.01782457f, -0.01040607f, 0.01869531f, -0.02547652f, 
    -0.03547709f, -0.02569357f, -0.02545912f, -0.04151533f, -0.00966288f, 0.02455878f, -0.02980423f, 0.00237600f, 
    -0.03208021f, 0.02375602f, -0.02961902f, 0.02946423f, -0.00239655f, 0.01614151f, -0.03516724f, -0.04172100f, 
    -0.01711413f, -0.00375333f, -0.00419451f, 0.02468698f, 0.01005005f, -0.00198346f, -0.03049690f, -0.01812386f, 
    -0.00866159f, 0.01846446f, 0.01630758f, -0.01534946f, 0.00137965f, 0.02737484f, -0.01256025f, -0.03420441f, 
    -0.03457433f, -0.02880058f, 0.02170737f, 0.01641131f, -0.01778041f, 0.00201317f, -0.01486493f, -0.03939095f, 
    -0.04013050f, -0.03254776f, -0.03466573f, -0.02783758f, 0.00910011f, 0.00160797f, 0.02487528f, 0.00947048f, 
    -0.02425819f, 0.00235350f, -0.03909955f, 0.02410467f, 0.02396225f, -0.02601590f, 0.00898945f, -0.03726581f, 
    -0.03129539f, 0.02075806f, -0.00477226f, 0.02320309f, 0.01376215f, 0.02584700f, -0.03273733f, -0.02798473f, 
    0.02199105f, 0.00028509f, 0.00382438f, -0.03717158f, -0.00240136f, -0.01652553f, 0.01159119f, -0.01730406f, 
    -0.02052033f, 0.02316064f, -0.01798844f, -0.03475574f, 0.02119044f, -0.02373005f, -0.00617821f, -0.01405126f, 
    -0.01871703f, -0.02956188f, 0.01629364f, -0.00525742f, 0.02623853f, -0.00699672f, 0.00633744f, -0.01480114f, 
    -0.01802496f, -0.02634458f, -0.01553245f, -0.03524416f, 0.01223430f, -0.03536713f, 0.00558457f, -0.01202802f, 
    0.01205923f, -0.00408922f, -0.00594497f, 0.00725680f, 0.00915506f, 0.03785785f, 0.03655615f, 0.02275991f, 
    0.02139496f, -0.03381306f, 0.00586142f, -0.03632578f, 0.02777040f, -0.01649647f, 0.00239576f, 0.03557152f, 
    0.02117668f, 0.00892002f, 0.00014875f, 0.01480539f, -0.01085067f, -0.03939516f, -0.04090488f, 0.02807103f, 
    0.00684417f, 0.02873508f, 0.00007383f, -0.00754778f, -0.01196141f, -0.00059150f, -0.02983100f, -0.02677702f, 
    0.00786904f, -0.02878278f, -0.00809170f, 0.02526288f, -0.03484071f, 0.01680794f, -0.00443020f, 0.00567099f, 
    0.00688958f, 0.01651645f, -0.01065034f, 0.01459236f, -0.03813129f, -0.02580489f, 0.01353661f, -0.01774647f, 
    0.02254600f, 0.03712551f, 0.01015925f, -0.01009016f, -0.00752095f, 0.00039653f, -0.00939876f, 0.02794611f, 
    0.00745861f, -0.03000444f, -0.01865248f, -0.03542905f, 0.02347963f, -0.00243443f, -0.00696158f, -0.02880393f, 
    0.03229510f, 0.01301555f, -0.01648371f, -0.00288910f, -0.03390074f, 0.02371662f, -0.00568045f, 0.02532240f, 
    -0.01974260f, -0.02731035f, -0.03208444f, -0.00237925f, 0.00086492f, -0.02876782f, -0.00454518f, -0.01119137f, 
    -0.04033062f, 0.01160354f, -0.04038731f, 0.02392007f, -0.03176453f, -0.00548323f, 0.01093427f, 0.00906824f, 
    -0.04045418f, -0.04049060f, -0.01724950f, -0.02343417f, 0.02927771f, -0.01973757f, 0.00521266f, 0.00616591f, 
    -0.02164086f, -0.00089404f, -0.03575949f, -0.01533694f, -0.00223660f, -0.01710557f, 0.03950911f, -0.00757808f, 
    -0.00492646f, -0.01519900f, 0.00693490f, 0.00857647f, 0.02055663f, 0.00163360f, -0.00775569f, 0.01333023f, 
    0.02717741f, -0.02437946f, -0.02380551f, 0.02208404f, 0.01815119f, -0.00366246f, -0.00540553f, 0.02806032f, 
    -0.02088966f, -0.02433514f, 0.00611781f, 0.00579731f, 0.00619141f, -0.04062548f, -0.03416024f, 0.02276174f, 
    -0.00521948f, 0.03144781f, 0.00685185f, 0.02126305f, -0.03769905f, -0.00655215f, -0.02666589f, -0.00924155f, 
    0.03125493f, -0.02259805f, 0.03428190f, -0.02841536f, -0.02768866f, -0.02572767f, -0.01651403f, 0.00137601f, 
    0.01219517f, 0.00854809f, -0.01858223f, 0.00640371f, -0.03926461f, 0.00006325f, -0.03591138f, -0.00458573f, 
    -0.02136852f, 0.01180320f, -0.00626681f, 0.02693187f, -0.00626673f, 0.01137149f, 0.00501938f, -0.03946089f, 
    -0.01408400f, -0.01670422f, 0.02311218f, 0.02584677f, 0.00120655f, 0.02706917f, 0.01746262f, 0.01103653f, 
    -0.00680425f, -0.03551638f, -0.02978613f, -0.01372753f, 0.01104715f, 0.01552113f, -0.00194138f, -0.04171651f, 
    -0.00826112f, -0.02561238f, -0.02100426f, -0.04057763f, 0.02375234f, 0.02087099f, -0.03479648f, 0.01642977f, 
    -0.01684861f, -0.03356767f, 0.00387469f, 0.01358100f, -0.03532813f, -0.01850551f, -0.00547894f, 0.00312014f, 
    0.00407369f, 0.02907844f, -0.03042336f, -0.01383207f, -0.03092724f, -0.02332347f, -0.03588543f, -0.00010283f, 
    -0.02716365f, -0.02523891f, 0.03015620f, -0.02617866f, 0.02603986f, 0.01328982f, -0.00327778f, -0.01746060f, 
    -0.01013067f, -0.03141225f, 0.00689883f, -0.02558073f, -0.02553971f, -0.02722675f, -0.02715834f, 0.02659794f, 
    0.03406714f, 0.02798323f, 0.01824109f, 0.02194570f, 0.00917006f, 0.00049841f, -0.00179757f, 0.00609640f, 
    0.01396167f, 0.00883796f, -0.03327319f, 0.03212067f, 0.02404271f, -0.00473219f, 0.00523941f, -0.02663250f, 
    -0.00616002f, -0.03892564f, -0.03444385f, 0.02534367f, -0.02762282f, 0.02168490f, -0.02077890f, 0.02678121f, 
    0.00592754f, -0.02150963f, -0.02525838f, -0.00654472f, -0.02345552f, 0.02030301f, -0.02225867f, -0.03191364f, 
    0.00957244f, -0.02409123f, -0.03882734f, -0.03278482f, -0.01864597f, -0.01050603f, -0.04127168f, -0.02648331f, 
    0.01260760f, 0.01773475f, 0.00666334f, -0.04382166f, -0.00998628f, 0.00176293f, 0.02743207f, 0.01532493f, 
    0.01137812f, -0.02999226f, -0.02436871f, 0.01821407f, 0.00532752f, 0.01655256f, -0.01889882f, 0.00856209f, 
    0.00618574f, 0.00453330f, 0.00802379f, -0.01252264f, 0.01934081f, -0.02223806f, -0.03666507f, -0.00801089f, 
    0.01204508f, 0.03080371f, 0.00024859f, -0.03450337f, 0.01788482f, 0.02491934f, -0.01773760f, -0.03154295f, 
    -0.01123995f, 0.02381299f, -0.00711603f, 0.00756553f, -0.01127035f, 0.00561974f, 0.01056031f, -0.00425145f, 
    -0.03641457f, -0.01863350f, -0.02834528f, 0.02567299f, 0.01511113f, 0.02863319f, -0.02758001f, 0.01818888f, 
    -0.00066581f, -0.03343611f, -0.00632288f, 0.01763454f, -0.00588720f, 0.02315177f, -0.02485202f, 0.03334316f, 
    -0.01972115f, 0.00712262f, -0.00368826f, -0.00921427f, 0.01817204f, 0.02252751f, -0.02920303f, 0.01733362f, 
    -0.01650589f, -0.00776020f, -0.01496977f, 0.03034018f, 0.01759693f, 0.01455631f, -0.02197776f, -0.03911633f, 
    -0.02506050f, -0.01916203f, 0.01205181f, -0.00087690f, 0.00252442f, -0.01363738f, 0.01040052f, 0.02252229f, 
    -0.01429781f, 0.03371368f, -0.03556477f, -0.03253945f, 0.00314323f, -0.02084228f, -0.01593549f, -0.00536370f, 
    -0.01082745f, 0.01800509f, -0.01582070f, -0.03058635f, -0.03828360f, -0.00813315f, -0.03028796f, -0.01661572f, 
    -0.00583111f, -0.01028558f, -0.03082891f, 0.01950598f, 0.02229452f, -0.00816137f, -0.00790379f, -0.02073934f, 
    0.00151008f, -0.02296095f, -0.03040124f, 0.02730118f, 0.01540235f, -0.01443012f, 0.01110565f, -0.03652167f, 
    -0.01382172f, -0.00977230f, -0.01261438f, -0.04485079f, -0.02936254f, 0.01004437f, -0.01567288f, -0.03173915f, 
    -0.00827139f, -0.03325205f, -0.02967869f, -0.01982456f, -0.00106139f, -0.02489800f, -0.00780518f, -0.02018614f, 
    0.01313451f, -0.01075100f, -0.04177138f, 0.01751305f, -0.03743682f, -0.00154240f, 0.02061990f, -0.01977999f, 
    0.02802581f, 0.01890648f, 0.00802368f, -0.00992060f, 0.03266133f, -0.01838868f, -0.04060778f, -0.01063730f, 
    -0.02812555f, -0.02264710f, 0.02334049f, -0.00316217f, 0.02644358f, 0.01055096f, 0.02244975f, 0.01453903f, 
    -0.01099573f, -0.03861772f, -0.00939699f, 0.00991918f, -0.03723557f, 0.01206033f, 0.02669158f, -0.00587536f, 
    0.01546282f, -0.02692743f, -0.03524187f, 0.01954683f, 0.03176797f, -0.01433659f, 0.01430837f, -0.00261773f, 
    -0.02357738f, 0.01111235f, -0.00161005f, -0.03364300f, -0.03295423f, 0.01109364f, -0.02540240f, 0.02256955f, 
    0.02296763f, 0.00372732f, 0.00105789f, 0.02792735f, -0.00351259f, 0.01043759f, 0.01036336f, -0.03016875f, 
    0.01054262f, -0.02221277f, -0.00149394f, -0.02502439f, -0.01880123f, -0.00050422f, 0.00159392f, 0.00491498f, 
    0.03557519f, -0.00816950f, -0.00475950f, 0.03281704f, -0.00626923f, -0.00780164f, -0.02396946f, -0.01530118f, 
    0.03306028f, 0.01775650f, -0.00826250f, 0.03426154f, -0.02283693f, 0.02036499f, 0.01571219f, 0.00283587f, 
    -0.02985071f, 0.03056161f, -0.03046845f, 0.01386311f, -0.02281261f, -0.02060435f, -0.02300034f, 0.01746776f, 
    0.00163618f, -0.01263348f, 0.02446346f, 0.01931498f, 0.01859373f, -0.01550229f, -0.01674501f, -0.03163823f, 
    -0.03578862f, -0.02556550f, -0.01829559f, -0.02550151f, 0.01579043f, 0.00144592f, 0.00479117f, 0.01454469f, 
    -0.02083488f, -0.01491036f, -0.01698925f, -0.02665531f, -0.03272363f, -0.00355938f, -0.02112821f, -0.03497462f, 
    0.02263700f, 0.01304318f, 0.02634642f, 0.03507024f, 0.00277022f, 0.01552861f, 0.00075095f, -0.00943039f, 
    -0.00329250f, 0.02245378f, -0.01721317f, 0.01335953f, 0.01515952f, 0.00259303f, -0.02873827f, -0.01902057f, 
    0.00574310f, 0.03068707f, -0.03538027f, 0.00092904f, -0.02159660f, 0.03303012f, 0.02735610f, 0.03043228f, 
    0.02452561f, -0.02216853f, 0.00195749f, 0.02066441f, 0.00625772f, 0.00105249f, 0.00616239f, -0.02376467f, 
    0.00889628f, -0.01145819f, -0.04026368f, 0.02675521f, 0.00375015f, -0.03167995f, -0.00154154f, -0.02747833f, 
    -0.00343359f, -0.02573012f, -0.03153141f, -0.01663814f, -0.00204711f, 0.00373796f, 0.02539626f, -0.01266401f, 
    -0.00040813f, -0.01323181f, 0.00487573f, 0.00423367f, -0.00255516f, 0.00596947f, -0.01939297f, 0.00032554f, 
    0.02725109f, 0.02870101f, 0.02467507f, 0.02262082f, 0.02612985f, -0.03849497f, -0.02212366f, -0.01160757f, 
    0.03066568f, -0.02762043f, 0.02218690f, -0.01669135f, -0.03744839f, -0.01371037f, -0.01113441f, 0.00297808f, 
    0.00522268f, -0.01601292f, -0.00095606f, 0.00481249f, 0.03183233f, -0.00304597f, -0.02753421f, 0.02613555f, 
    0.01428503f, 0.01505699f, -0.01063994f, -0.01833755f, 0.02647180f, 0.00316374f, 0.02498957f, 0.01506894f, 
    0.00640716f, 0.00410658f, 0.02264708f, 0.01792227f, -0.02827469f, 0.01328298f, -0.02245408f, -0.01381186f, 
    -0.00751573f, -0.00140608f, 0.02727227f, -0.02835372f, -0.02834787f, 0.02534124f, -0.02238689f, -0.04046933f, 
    0.03506728f, -0.02148452f, -0.00887824f, -0.04060072f, 0.02227204f, 0.02666729f, 0.03269814f, -0.00165726f, 
    -0.00346910f, -0.00044521f, -0.01330569f, -0.03113803f, 0.00420142f, 0.00598622f, 0.01024900f, 0.02959707f, 
    -0.01108450f, -0.04288535f, -0.02696822f, 0.03261654f, 0.01031682f, 0.01884174f, -0.02958113f, 0.00913233f, 
    0.01255977f, 0.01558344f, -0.02524627f, 0.01919626f, 0.00672415f, 0.01002900f, 0.00222924f, 0.00785349f, 
    -0.01263965f, 0.01825898f, -0.04280546f, -0.01246101f, 0.01534165f, -0.03517468f, 0.01192866f, -0.03317434f, 
    -0.01325647f, -0.02188271f, 0.03175961f, 0.02188084f, 0.01567375f, -0.01866188f, 0.01726814f, -0.02167136f, 
    0.02391722f, -0.01288786f, -0.03067042f, 0.02790567f, -0.03829955f, 0.00228011f, -0.03226274f, -0.04025825f, 
    0.03012062f, -0.00425900f, 0.01461140f, -0.02921246f, -0.03758547f, -0.02773828f, -0.01726840f, 0.02625052f, 
    0.02311623f, 0.01069214f, 0.02323535f, 0.03219904f, -0.02122897f, -0.00717695f, -0.01224250f, -0.01818002f, 
    -0.02946370f, -0.01403689f, -0.01153750f, -0.00493041f, -0.03996806f, -0.01588061f, -0.04049336f, -0.01209050f, 
    0.00195167f, 0.01289835f, 0.01259991f, -0.01810390f, 0.00446891f, -0.02048229f, -0.00337241f, -0.00092111f, 
    0.00914282f, -0.04147516f, 0.00894634f, 0.00519839f, 0.01581080f, 0.00832263f, 0.00642241f, -0.00742021f, 
    0.01376734f, 0.02501228f, 0.01368523f, 0.01753844f, 0.00647315f, -0.01157334f, -0.02174042f, -0.04255027f, 
    0.00505208f, -0.00042463f, -0.01163332f, 0.02980065f, -0.01274272f, 0.00607691f, -0.02289191f, -0.02777007f, 
    0.02324653f, -0.03582476f, -0.01952212f, 0.02369606f, -0.01506524f, -0.02389067f, 0.02177415f, -0.01336201f, 
    -0.00996461f, -0.01659743f, -0.00819273f, 0.00657119f, 0.03551039f, -0.01177181f, 0.01892367f, 0.00703327f, 
    0.02481391f, 0.01577697f, -0.02782764f, 0.00273396f, 0.01278973f, -0.03722218f, -0.01743146f, 0.02240343f, 
    0.03689203f, -0.00189445f, -0.00123635f, -0.01003442f, -0.03945162f, 0.02251255f, 0.00008967f, -0.01444451f, 
    -0.01314504f, 0.03671267f, -0.02126392f, -0.01218307f, 0.02546721f, -0.00005333f, -0.00977691f, -0.03356893f, 
    -0.02289683f, 0.01631198f, -0.01696643f, 0.03040612f, 0.01387022f, 0.00631812f, -0.00396111f, 0.01113405f, 
    -0.02518013f, -0.02271271f, -0.01926735f, -0.00640104f, -0.02535220f, -0.02432259f, -0.03273942f, -0.00325992f, 
    -0.01199558f, -0.00868236f, -0.00105730f, -0.00544224f, -0.03105801f, -0.00106490f, -0.00302341f, 0.01039996f, 
    0.02621945f, 0.02472621f, -0.00859967f, -0.03737163f, -0.02434384f, -0.00731763f, -0.02136992f, -0.01457680f, 
    -0.03595074f, 0.01109443f, 0.01867634f, -0.00564063f, 0.02120231f, 0.01086401f, 0.01562331f, -0.00154473f, 
    0.02139680f, 0.01931331f, -0.01367076f, 0.01270289f, -0.00660969f, -0.01517091f, 0.03361576f, 0.02285224f, 
    0.01351571f, 0.02771553f, 0.02642608f, 0.02220629f, 0.01553509f, -0.01133962f, 0.01490900f, -0.03054277f, 
    0.01464273f, 0.01936862f, -0.03744702f, 0.02059815f, -0.03283623f, 0.00575121f, 0.01260232f, 0.03198297f, 
    0.01232810f, -0.03112638f, -0.03098198f, 0.00978031f, -0.01231680f, -0.03928942f, -0.00806568f, 0.00098758f, 
    -0.00573571f, -0.00503886f, 0.02840178f, -0.02053754f, -0.01284108f, -0.03643648f, 0.02857913f, 0.00037850f, 
    0.02195453f, -0.03441045f, -0.01883888f, 0.01875466f, 0.00912202f, -0.03097397f, 0.02072741f, -0.01095308f, 
    -0.00900742f, 0.01794251f, 0.00404419f, 0.01035759f, 0.01406480f, 0.02468949f, 0.01807702f, -0.00735759f, 
    -0.02531623f, 0.02690747f, -0.03658357f, 0.02718853f, 0.00670400f, 0.01990230f, -0.01722173f, 0.01803511f, 
    0.02893197f, -0.00000815f, -0.03381502f, 0.02340175f, -0.00412989f, 0.01891481f, -0.03219223f, -0.00918335f, 
    -0.03599863f, 0.00196772f, 0.00150110f, -0.02914958f, -0.03953853f, 0.00565791f, 0.02667334f, 0.01564247f, 
    -0.02468017f, -0.02721832f, -0.00491122f, -0.03462099f, -0.00540362f, -0.00676725f, 0.01081563f, -0.03774244f, 
    -0.03365024f, 0.01439028f, -0.03469498f, -0.02450671f, -0.00412957f, -0.00947990f, 0.01662461f, -0.01708014f, 
    -0.02755094f, -0.04091623f, -0.01873813f, 0.02920860f, -0.02666357f, 0.02835085f, 0.01043664f, -0.01500956f, 
    -0.00778275f, 0.00673711f, 0.02801524f, -0.01548008f, -0.01390941f, 0.02065347f, 0.02657744f, 0.00369072f, 
    0.00888831f, -0.02804997f, -0.00723985f, -0.01259899f, -0.00133848f, -0.00922138f, -0.03117095f, -0.01714543f, 
    0.02348296f, -0.01931062f, -0.01708724f, 0.00442618f, 0.01049394f, 0.00421307f, -0.02927402f, -0.02792034f, 
    0.00184236f, -0.02700530f, 0.00630126f, -0.03646967f, -0.03738945f, -0.01146208f, 0.02400787f, 0.00615818f, 
    0.01932734f, 0.00844121f, 0.01887034f, 0.00261609f, -0.03665727f, 0.01338815f, 0.01696941f, 0.00319232f, 
    0.00827113f, 0.02082681f, 0.00844005f, 0.01376223f, -0.03020077f, 0.01904908f, 0.03066223f, -0.00519210f, 
    -0.03178137f, 0.01708819f, 0.02007381f, 0.01875034f, -0.02195265f, 0.00775229f, 0.01368998f, 0.03206073f, 
    -0.01902472f, -0.01391321f, 0.00792439f, -0.00350061f, -0.01334362f, -0.02976057f, -0.01536154f, 0.00668827f, 
    0.02230785f, -0.02412585f, -0.02895614f, -0.03763146f, -0.00302164f, -0.02250881f, -0.01692590f, -0.02964404f, 
    -0.03596747f, -0.02265909f, 0.00790767f, 0.01714016f, -0.02122369f, -0.00216750f, 0.02193544f, 0.00900137f, 
    -0.02842328f, 0.00649906f, 0.01044401f, -0.02280397f, 0.00948671f, -0.00080953f, -0.00512262f, -0.00658915f, 
    0.01603533f, 0.02832723f, -0.00735241f, -0.00844321f, -0.02564428f, 0.02501213f, -0.03400302f, 0.00925475f, 
    -0.00683121f, 0.02296962f, -0.03394379f, 0.01825877f, 0.01593010f, -0.01406271f, -0.00238831f, 0.02059093f, 
    0.00147657f, 0.01458109f, 0.01775230f, -0.02447458f, -0.01117258f, -0.01260473f, -0.03513982f, 0.02659568f, 
    -0.01487181f, -0.00146782f, -0.03561106f, -0.03996138f, -0.03307839f, 0.01748708f, 0.02490577f, -0.00337121f, 
    -0.01331421f, -0.02081374f, -0.03875163f, 0.03183755f, -0.01075655f, 0.02200947f, -0.02967008f, -0.00890865f, 
    -0.02567882f, -0.00560610f, -0.02860865f, 0.02312778f, -0.01749709f, -0.03391114f, 0.01550694f, 0.01768344f, 
    0.00945333f, -0.01356767f, -0.01348219f, -0.01295030f, -0.01003233f, 0.02150734f, -0.02884326f, -0.01824588f, 
    -0.02450493f, -0.00823748f, 0.01416934f, -0.01891389f, -0.01833250f, -0.00993809f, 0.00737783f, -0.00662753f, 
    -0.03730360f, 0.01756345f, 0.01809646f, -0.00999896f, -0.03075217f, 0.01851676f, -0.02338959f, -0.02800137f, 
    0.00861022f, -0.02608732f, -0.03242188f, -0.03359009f, -0.00328687f, -0.02510349f, -0.03457532f, -0.01292289f, 
    -0.02257786f, -0.02033178f, -0.01241279f, 0.02011295f, -0.00557739f, -0.02423993f, -0.02749585f, -0.00670196f, 
    -0.00398881f, 0.01160079f, -0.02339049f, 0.00093824f, 0.00328907f, -0.03160324f, -0.02607734f, -0.02696100f, 
    0.00710408f, -0.01921946f, -0.02492416f, 0.00939161f, 0.00983461f, -0.02062643f, -0.00972622f, 0.02462428f, 
    0.01862069f, -0.02686931f, -0.00395897f, 0.00907028f, -0.01120762f, -0.00112772f, -0.03448064f, -0.03873407f, 
    -0.01577404f, 0.02265174f, 0.02423121f, -0.00424214f, -0.00273715f, -0.01303291f, -0.00216845f, -0.03735104f, 
    -0.01274159f, -0.02980836f, 0.01090872f, -0.00158799f, 0.03304712f, 0.02814887f, 0.00740982f, -0.02184125f, 
    -0.00569061f, 0.00359551f, -0.04265703f, 0.01287467f, -0.00585500f, -0.00715991f, 0.00412151f, 0.02815212f, 
    0.00645929f, 0.01914075f, -0.02424229f, 0.00162408f, 0.02867280f, 0.02489369f, 0.02479489f, -0.00692099f, 
    0.01003844f, -0.00128070f, 0.02831471f, 0.02897456f, 0.01105704f, 0.00146402f, 0.00054384f, -0.02245467f, 
    -0.02690193f, 0.00960697f, -0.03627156f, -0.03835428f, -0.03514509f, -0.03859251f, -0.01327858f, -0.02483592f, 
    0.02614162f, -0.02961848f, 0.00844684f, -0.00308819f, -0.02269624f, 0.01103127f, 0.02165020f, -0.00093202f, 
    -0.03466299f, 0.00290891f, -0.03342747f, -0.00275663f, 0.01908647f, -0.00064910f, 0.00391240f, -0.00621233f, 
    0.01383566f, 0.02766848f, -0.00279545f, 0.02671984f, 0.02715057f, -0.04026270f, -0.00149183f, 0.01787729f, 
    0.01186353f, 0.01028216f, 0.00298882f, 0.00968889f, -0.02973313f, -0.03459463f, -0.01586122f, -0.04172149f, 
    -0.00790899f, -0.00076940f, 0.00548197f, 0.00874150f, 0.01584973f, 0.00478187f, -0.02126632f, -0.02798374f, 
    -0.03508003f, 0.00551823f, 0.02065132f, -0.02838394f, 0.01100897f, -0.03407637f, -0.01193587f, -0.00104956f, 
    -0.01049064f, -0.02392558f, -0.03642103f, 0.00432937f, -0.03441450f, -0.00827734f, -0.03140098f, 0.02400697f, 
    -0.01750366f, -0.00295475f, -0.03574780f, 0.01067497f, 0.02551000f, -0.00682656f, 0.02139416f, 0.02197172f, 
    0.02102980f, -0.00143262f, 0.02984397f, -0.01962953f, 0.00176341f, 0.02643803f, -0.00435934f, -0.00995660f, 
    0.01189993f, -0.02135785f, 0.02055916f, 0.02482403f, -0.01384518f, 0.01326583f, 0.03011999f, -0.01584359f, 
    -0.02695516f, -0.00876276f, -0.02952910f, -0.01343298f, 0.02196034f, -0.03446411f, -0.00629027f, 0.02350320f, 
    0.02561091f, 0.00357904f, 0.00589770f, 0.02730916f, 0.00362355f, 0.02144689f, 0.01337897f, 0.02390133f, 
    -0.01667887f, 0.01489813f, -0.02218269f, -0.03599512f, 0.00160006f, 0.03141954f, 0.02714684f, 0.01057695f, 
    -0.00854036f, -0.01521326f, 0.02849439f, 0.03182454f, -0.01591261f, 0.00274422f, 0.01391889f, 0.01917721f, 
    0.00055664f, 0.01808272f, 0.00057313f, 0.00702376f, -0.02401697f, -0.03744164f, 0.02897692f, -0.00748501f, 
    -0.00499927f, 0.00453743f, 0.02516066f, -0.01238621f, -0.03504739f, -0.00484850f, 0.01393149f, 0.01179387f, 
    -0.03823343f, 0.01370326f, -0.01392620f, 0.02237763f, 0.00227906f, -0.02336866f, -0.01231864f, -0.00436988f, 
    -0.01167050f, -0.00782612f, 0.02792367f, 0.01677727f, -0.02952573f, 0.02899470f, 0.01549081f, -0.00042475f, 
    -0.00246998f, -0.03202733f, -0.02948080f, 0.02847681f, 0.02676328f, 0.00714351f, 0.03052896f, 0.01236714f, 
    0.00231847f, -0.03329232f, 0.01238659f, -0.02340815f, 0.02242066f, 0.01596323f, -0.02350803f, 0.02519344f, 
    0.01090248f, 0.02022313f, 0.02148448f, -0.01140561f, 0.00053337f, 0.03100649f, -0.01614576f, 0.01979775f, 
    -0.02122546f, -0.04163142f, 0.02958020f, -0.02410062f, 0.01057770f, -0.00322669f, -0.00536609f, -0.03199834f, 
    -0.04063276f, 0.00729871f, -0.02778011f, -0.01268710f, 0.02247900f, -0.03952653f, -0.02178888f, 0.00635324f, 
    0.02246668f, -0.04125287f, -0.00775608f, 0.00946695f, -0.01519910f, -0.01059107f, -0.01621672f, -0.04375619f, 
    -0.02520373f, 0.03116271f, 0.02479636f, -0.00394681f, -0.00509294f, -0.02602528f, -0.03138202f, -0.01987556f, 
    -0.02118158f, -0.00487643f, -0.02707019f, -0.01709340f, -0.02121951f, -0.03793652f, 0.01827227f, -0.02076397f, 
    0.02986383f, -0.01161421f, 0.01299663f, -0.02441437f, 0.01921223f, 0.00382980f, 0.02914065f, 0.00833339f, 
    -0.01838310f, -0.01714176f, -0.02948916f, 0.01526583f, -0.03795673f, 0.00907699f, -0.02851180f, 0.01290678f, 
    0.01468925f, -0.03458880f, 0.01659466f, -0.00918852f, -0.02599056f, 0.00653301f, -0.02961699f, -0.02590395f, 
    0.02924560f, -0.02791176f, -0.02942129f, -0.00660458f, 0.01155759f, -0.02788373f, -0.00996472f, 0.01884049f, 
    -0.01218956f, -0.03424859f, -0.01770818f, -0.01469153f, 0.03020314f, -0.02613862f, -0.00710687f, 0.02448661f, 
    -0.03515679f, 0.01876510f, -0.01974819f, 0.03273957f, -0.02883251f, -0.00901745f, 0.00735094f, 0.02452649f, 
    -0.01579805f, -0.04128326f, -0.02480256f, -0.02409087f, 0.00066555f, -0.03701253f, 0.01590001f, 0.02999650f, 
    -0.01591664f, 0.02557564f, -0.00336875f, -0.03658014f, 0.02037281f, 0.02410480f, 0.01272512f, -0.01332009f, 
    -0.00503322f, -0.03860156f, -0.02678109f, -0.02114386f, -0.02351229f, 0.02244633f, -0.02915777f, 0.01057796f, 
    0.00821559f, 0.01809279f, -0.01042760f, -0.01405641f, 0.00990952f, -0.02532134f, -0.03905731f, 0.03135491f, 
    -0.00560330f, 0.00564186f, 0.02409009f, -0.03251366f, 0.01111994f, 0.02781515f, -0.01773250f, -0.01808120f, 
    -0.03629962f, -0.01812504f, -0.02924317f, -0.03508034f, 0.02962591f, -0.00059651f, -0.02477679f, 0.03389233f, 
    -0.00062933f, -0.01712171f, 0.01767673f, -0.02655621f, -0.02308020f, 0.02691177f, 0.00702682f, -0.03217286f, 
    -0.03438916f, -0.02924291f, -0.02168247f, -0.01698267f, 0.00869551f, -0.01937130f, -0.02107916f, 0.00553948f, 
    -0.02947032f, -0.01210807f, -0.01264024f, -0.03633862f, -0.03731560f, 0.00623040f, -0.01099165f, -0.02033368f, 
    -0.02440506f, -0.01498676f, 0.01622183f, 0.02731870f, 0.00853900f, -0.00407908f, 0.00742396f, -0.01727503f, 
    -0.02350395f, -0.02677418f, -0.04069417f, -0.02789405f, 0.01703407f, -0.03445954f, 0.02702267f, 0.01641267f, 
    -0.01363374f, 0.00707175f, 0.02212194f, -0.01430752f, -0.01369983f, -0.03368933f, 0.00264368f, -0.03471311f, 
    -0.02859932f, 0.00470695f, -0.03443418f, 0.02697613f, 0.01902771f, -0.01618194f, 0.02739805f, -0.02817358f, 
    -0.00833663f, -0.02052940f, 0.01111119f, 0.00819612f, 0.00498363f, 0.02163651f, 0.03026760f, 0.01975615f, 
    -0.03653919f, 0.01115160f, -0.00872584f, 0.02763105f, -0.01563118f, -0.03021590f, 0.03530085f, 0.03424575f, 
    0.01577324f, 0.00908644f, -0.01772075f, -0.01255928f, -0.01506001f, -0.01695566f, -0.01040048f, -0.01053679f, 
    -0.20344076f, -0.02572593f, 0.04761335f, 0.02220477f, 0.00856922f, 0.09069359f, 0.07349221f, -0.13672604f, 
    -0.08499979f, -0.04271635f, -0.15916592f, -0.22965680f, -0.34018692f, 0.05212526f, 0.09364545f, 0.14905873f, 
    -0.13054188f, -0.06623533f, 0.07213736f, -0.09818403f, 0.05176533f, 0.05656827f, -0.01697459f, -0.08052428f, 
    0.13882118f, 0.04830162f, 0.16180257f, 0.00756864f, -0.03099391f, 0.02305747f, 0.04503001f, -0.01522882f, 
    0.12168708f, 0.09349031f, -0.02549833f, 0.02743941f, 0.38167340f, 0.14482380f, -0.22614607f, -0.07638741f, 
    0.07744402f, 0.01390632f, 0.01130449f, 0.08911046f, 0.04932161f, -0.06745252f, 0.05058609f, 0.13478872f, 
    -0.03310251f, 0.05475800f, -0.19147754f, -0.01376303f, 0.01656556f, -0.01757447f, -0.03975317f, 0.13002884f, 
    -0.08842316f, -0.04385687f, -0.07623178f, 0.14890845f, 0.22174288f, 0.08216419f, -0.18011200f, -0.04457201f, 
    -0.04317914f, -0.10392649f, -0.03516828f, 0.02785944f, 0.08227141f, -0.10106604f, -0.04765191f, 0.17622595f, 
    -0.10777157f, -0.02993117f, -0.02736847f, -0.00740225f, -0.13692193f, 0.03138053f, -0.03582376f, 0.00743790f, 
    -0.04757130f, -0.14155954f, 0.12882872f, 0.03793891f, 0.09975909f, 0.20756596f, 0.07913518f, -0.03960998f, 
    -0.02224692f, 0.04942185f, 0.06074376f, -0.05095997f, 0.06622559f, 0.10245799f, -0.02176307f, -0.06931462f, 
    0.07490326f, 0.04295173f, -0.22032619f, 0.08184677f, 0.11703178f, -0.00577687f, 0.20606682f, 0.12710626f, 
    -0.00403645f, -0.15355854f, -0.10401499f, 0.04751180f, 0.15135446f, -0.31052282f, 0.21444611f, 0.02033536f, 
    0.08989945f, -0.05079323f, -0.10257421f, -0.04863637f, -0.02279429f, 0.07705186f, -0.08446113f, -0.00096461f, 
    -0.22446775f, 0.01270036f, 0.02253533f, 0.14232956f, 0.07022027f, 0.22252803f, -0.04622978f, 0.02967541f, 
    0.00133947f, 0.09201819f, 0.02615741f, 0.00263624f, -0.08233285f, -0.28364328f, 0.23771934f, 0.22704373f, 
    0.06095443f, 0.10385842f, -0.06184379f, 0.11037020f, -0.04716891f, 0.00612950f, -0.05585261f, -0.06572380f, 
    0.17727785f, -0.04241378f, 0.06003823f, 0.08543014f, 0.00862975f, -0.17156057f, -0.09680197f, -0.07107908f, 
    0.01182344f, 0.02580493f, -0.02628331f, 0.14950579f, -0.15576860f, -0.20787287f, 0.32255629f, 0.06948818f, 
    -0.02420534f, -0.19387820f, -0.06203602f, 0.01412482f, -0.08363850f, 0.32067582f, 0.00199394f, 0.05987029f, 
    0.02419108f, -0.30064967f, 0.00103726f, 0.17131436f, -0.05397303f, 0.07696997f, 0.02472201f, -0.09559634f, 
    0.09985821f, 0.11432467f, -0.08986194f, 0.19118108f, 0.04335009f, 0.04796698f, 0.11544733f, -0.02958410f, 
    0.02403240f, 0.01966810f, 0.08415247f, 0.01619044f, 0.12872644f, -0.04068264f, -0.02344118f, -0.03176311f, 
    0.16529369f, -0.02147370f, 0.06593288f, 0.18192533f, 0.12684576f, -0.01853842f, 0.03862980f, -0.03029930f, 
    0.06314260f, -0.07176658f, 0.06628496f, -0.09258624f, 0.10170557f, -0.15321103f, 0.15061502f, -0.13143376f, 
    -0.01027805f, 0.07320682f, -0.09187321f, -0.08332301f, 0.04409200f, 0.05980860f, -0.20910156f, -0.07813931f, 
    0.15144491f, 0.06704621f, 0.02733545f, 0.13499345f, 0.09977342f, -0.05751017f, -0.11483781f, -0.03414933f, 
    0.04052335f, 0.05307206f, 0.13526605f, 0.03854357f, 0.32745597f, 0.01553566f, -0.27698401f, 0.05293633f, 
    0.09292674f, -0.08010656f, 0.08244950f, -0.00066442f, 0.01073124f, 0.04683811f, 0.16808982f, 0.12599173f, 
    -0.07405516f, -0.20333296f, -0.04941873f, 0.07883814f, -0.05201102f, -0.00452453f, 0.04176452f, -0.02367223f, 
    -0.01223055f, -0.01375291f, -0.11636529f, -0.05297704f, 0.12410697f, -0.07359797f, 0.04532129f, -0.11057268f, 
    -0.04768022f, 0.05119086f, -0.00530064f, -0.09647956f, -0.05057144f, 0.02851176f, -0.04704532f, -0.08474955f, 
    0.10670524f, 0.08756576f, -0.10454034f, 0.14997086f, 0.02581498f, -0.10720988f, -0.00235964f, 0.14355515f, 
    0.00554856f, 0.02940345f, -0.11641496f, -0.06146393f, -0.12864761f, -0.07392308f, 0.18700871f, 0.09901631f, 
    0.03193467f, 0.06339873f, 0.04371997f, 0.01843737f, -0.00329532f, -0.07093737f, -0.00117322f, -0.03291822f, 
    0.25790715f, -0.01289407f, -0.00571933f, 0.05384313f, 0.00827672f, -0.01673206f, -0.02897955f, 0.06430816f, 
    0.08036089f, -0.02862020f, 0.09067240f, 0.01176155f, 0.06031347f, 0.17938167f, 0.08511431f, -0.09532196f, 
    0.08258175f, 0.04514958f, 0.00816982f, -0.14078635f, -0.09827223f, 0.09116791f, 0.03093212f, 0.04676063f, 
    -0.30024803f, 0.10570428f, 0.12831289f, -0.13180305f, 0.09728941f, -0.03228734f, -0.05368839f, 0.00757241f, 
    -0.02261429f, 0.18511444f, 0.04598371f, 0.07706915f, 0.21100301f, 0.15295108f, -0.15607372f, -0.08164247f, 
    -0.06469698f, -0.05476410f, 0.04350642f, -0.01517975f, -0.00636459f, 0.09792255f, -0.09573395f, -0.10761809f, 
    0.01024325f, 0.24924122f, 0.19780755f, -0.15771726f, 0.06603349f, 0.04498229f, -0.07592063f, -0.10223872f, 
    -0.18223792f, 0.20388857f, -0.07136990f, 0.04581512f, -0.08166853f, -0.03760044f, 0.04863841f, -0.04063549f, 
    -0.08198320f, 0.06485272f, -0.13775580f, 0.01352377f, 0.07633297f, 0.01581441f, -0.00231958f, -0.06677209f, 
    0.09517807f, 0.17183198f, -0.05001024f, 0.11470946f, 0.00662185f, 0.04949361f, -0.05532080f, -0.02689138f, 
    0.07911741f, -0.00452957f, 0.06881078f, -0.02612456f, 0.19065391f, -0.10324001f, 0.13692413f, 0.00217636f, 
    -0.00113957f, 0.10099876f, -0.06062537f, -0.01386298f, 0.07974739f, -0.05246921f, 0.00813792f, -0.10403110f, 
    -0.30264232f, 0.06732297f, -0.25812230f, 0.00603568f, 0.07949626f, -0.18521678f, 0.04550555f, -0.03834065f, 
    0.04955916f, -0.02827332f, -0.04522230f, -0.17455409f, 0.14464745f, 0.05537659f, -0.12100165f, 0.13960488f, 
    0.10575630f, 0.01125547f, -0.01317562f, 0.11820545f, 0.03245285f, 0.07621259f, 0.06832629f, -0.05202582f, 
    -0.04926557f, 0.14939550f, -0.15965821f, -0.08487902f, -0.07751743f, 0.03900057f, -0.02497079f, 0.00214189f, 
    0.07376558f, -0.08117326f, 0.11841828f, -0.05475090f, 0.08306230f, 0.09464453f, 0.13400349f, 0.06913773f, 
    0.00190313f, -0.02871309f, 0.03883304f, 0.00778089f, 0.13591486f, 0.08088287f, 0.15759726f, -0.09032726f, 
    0.08875600f, -0.15035836f, 0.00182429f, 0.06370176f, -0.11398864f, 0.10007720f, 0.09537100f, 0.02147862f, 
    -0.04152616f, 0.15929404f, 0.00937088f, 0.04368163f, -0.09005962f, 0.15826729f, 0.00487295f, -0.07537845f, 
    0.08568068f, -0.05759948f, 0.01234766f, 0.12691800f, 0.03589287f, -0.10481487f, -0.05217383f, 0.01171403f, 
    -0.14217773f, -0.00896791f, -0.11276998f, 0.25476325f, -0.09799103f, 0.03270194f, 0.01228860f, 0.07082455f, 
    0.11760683f, 0.09698838f, 0.16402654f, 0.01010591f, 0.14471078f, 0.17109454f, -0.10333698f, -0.21309246f, 
    -0.01256460f, 0.01701420f, -0.10226373f, 0.05580581f, 0.00568523f, -0.00254458f, -0.04417451f, 0.00715002f, 
    -0.04142739f, 0.18806136f, -0.01054325f, 0.05546097f, 0.05722937f, 0.05418072f, -0.00766570f, 0.00467582f, 
    0.02934245f, 0.01563389f, 0.00294618f, -0.14324959f, 0.36475712f, -0.13618299f, -0.04045560f, -0.13251978f, 
    -0.01332490f, 0.08041883f, 0.04756744f, -0.04589083f, 0.10509333f, 0.03274588f, -0.05820918f, 0.07146610f, 
    0.32960486f, -0.02604453f, -0.30864778f, -0.07545492f, 0.04449555f, -0.03714619f, -0.04062677f, -0.06134772f, 
    -0.07934394f, -0.05000909f, 0.15989766f, 0.18841954f, -0.14399688f, -0.15343457f, 0.22219186f, 0.12712160f, 
    -0.10218488f, 0.07161720f, 0.08742216f, -0.04498790f, -0.01974424f, 0.12089060f, 0.04889279f, -0.00589092f, 
    0.08403866f, 0.06395946f, -0.10043710f, -0.05549406f, 0.05472839f, -0.12050304f, -0.04067105f, 0.09671003f, 
    0.04770752f, 0.08708040f, 0.16347238f, -0.10480379f, -0.02899086f, -0.14615244f, 0.03176446f, -0.00296522f, 
    -0.06359747f, -0.02446486f, 0.09695627f, -0.00143424f, 0.09464718f, 0.02020622f, -0.11474586f, 0.02301483f, 
    0.33903551f, 0.00213433f, -0.11913211f, -0.18285242f, 0.12277528f, -0.05067348f, 0.03446147f, -0.05239123f, 
    -0.07428855f, -0.04908637f, -0.06719546f, 0.11947250f, 0.22256638f, -0.00031790f, 0.01100756f, -0.05802843f, 
    0.07501695f, -0.09125596f, 0.01110909f, 0.11336306f, 0.07736316f, -0.12069424f, 0.07071774f, -0.00056597f, 
    0.24844398f, 0.04907440f, 0.05761182f, -0.16456944f, 0.04400262f, -0.06524622f, 0.02056262f, -0.07558719f, 
    -0.02119219f, -0.01929212f, 0.00145381f, -0.02949275f, -0.04922601f, 0.06963413f, 0.06350670f, -0.07421375f, 
    0.11806820f, 0.00071824f, 0.03458834f, -0.16698648f, 0.05847724f, -0.10607308f, -0.10272997f, -0.00970829f, 
    0.47742888f, 0.05839407f, -0.20590600f, 0.04468674f, 0.05592588f, -0.11841482f, 0.01667449f, 0.00002466f, 
    -0.09829688f, -0.10046370f, 0.04539253f, 0.22095388f, -0.10868131f, -0.11691525f, -0.01678347f, 0.16262999f, 
    0.01220574f, -0.10846523f, 0.05688447f, 0.01500031f, 0.01179482f, 0.21187112f, -0.16246544f, 0.20212032f, 
    0.52435410f, 0.07086893f, -0.08695842f, -0.24239011f, 0.03423414f, 0.09443586f, -0.04439873f, -0.05639936f, 
    0.10078384f, -0.04469449f, -0.06830170f, -0.10165341f, 0.01882862f, -0.25055802f, 0.05898531f, 0.11676798f, 
    -0.01628782f, -0.09099068f, -0.04652534f, 0.13894168f, 0.07428948f, 0.07058796f, -0.01138644f, -0.01304128f, 
    0.16206330f, -0.03863297f, 0.02907021f, -0.08086731f, 0.07176819f, 0.01335524f, -0.02077713f, 0.04993193f, 
    0.12952872f, -0.04412435f, 0.04875729f, -0.07746154f, 0.04005779f, -0.00119463f, 0.10215922f, 0.04112717f, 
    -0.04627971f, 0.05670115f, 0.02988040f, -0.08594927f, -0.05221459f, 0.12377610f, 0.00310767f, 0.16306767f, 
    0.11556138f, -0.02676434f, 0.09770572f, 0.20315245f, -0.07403186f, 0.10733357f, 0.02335296f, -0.09373041f, 
    0.08274463f, -0.05187985f, 0.13336094f, -0.01422057f, 0.13300879f, -0.07453660f, -0.03406148f, 0.10025689f, 
    -0.10141911f, 0.01679577f, -0.03500012f, 0.15000924f, 0.09144022f, -0.04985735f, -0.06202106f, -0.11223971f, 
    0.11210597f, 0.04276215f, 0.00368987f, -0.12741148f, 0.05905796f, 0.02060569f, 0.00685502f, -0.03493632f, 
    -0.05192441f, 0.07895319f, -0.05060894f, 0.02472223f, 0.06503288f, 0.07662801f, -0.09639487f, 0.19769433f, 
    0.04864754f, 0.04973533f, 0.04521307f, -0.12556772f, -0.05465077f, 0.17216742f, 0.05088391f, 0.08393639f, 
    -0.04648058f, -0.10257681f, -0.01496414f, 0.04503918f, 0.02101986f, -0.06185226f, -0.10135564f, 0.00921907f, 
    -0.05056157f, 0.07548818f, 0.06009671f, 0.01039094f, 0.17120934f, 0.21689132f, -0.02089804f, -0.04011952f, 
    0.15627053f, -0.14783643f, 0.05828418f, 0.18023892f, -0.01097316f, 0.02086447f, 0.15174460f, 0.09791868f, 
    0.31404591f, -0.10373110f, -0.03469021f, -0.03010437f, 0.06138948f, -0.08572447f, 0.05735811f, -0.07359669f, 
    -0.01302393f, 0.00902364f, -0.00741639f, -0.06368146f, -0.22494791f, 0.31697515f, 0.01186182f, -0.21470420f, 
    0.36712298f, -0.13929218f, -0.09476644f, -0.02527499f, 0.02163540f, -0.02150470f, -0.12666754f, -0.05274322f, 
    0.01530388f, -0.01424923f, 0.00324396f, 0.02690084f, 0.00189895f, -0.01771982f, 0.01615753f, -0.03066727f, 
    0.01667160f, -0.02073270f, 0.01932086f, 0.00993276f, -0.02349643f, -0.03011656f, 0.01960531f, -0.02355025f, 
    -0.03099282f, 0.00394544f, 0.00978074f, -0.00016307f, -0.02568122f, -0.00065787f, 0.02033159f, -0.03279788f, 
    -0.03784001f, -0.01127570f, 0.00979805f, 0.02907388f, 0.02418836f, 0.00092097f, -0.00065561f, -0.03895126f, 
    0.01540669f, -0.02343277f, 0.01819885f, 0.00841794f, -0.03452031f, 0.02368711f, -0.01045792f, -0.03615481f, 
    0.01600206f, -0.02539869f, -0.01623231f, -0.00755300f, -0.03431984f, 0.01967345f, -0.02927974f, -0.04137140f, 
    0.00047592f, -0.01309564f, -0.01286756f, -0.01913754f, -0.00100994f, -0.01649837f, -0.04067877f, -0.01198875f, 
    -0.03683774f, 0.02505981f, 0.01864844f, 0.01821144f, -0.00788811f, 0.02696584f, 0.02193198f, 0.02494594f, 
    -0.00749905f, 0.02618645f, -0.03503179f, 0.01268771f, -0.02805617f, 0.01477909f, -0.01477976f, -0.04206295f, 
    0.00106410f, -0.03348712f, 0.01965856f, -0.03343904f, -0.01172783f, -0.00903949f, -0.02070007f, 0.00233456f, 
    -0.03058860f, 0.01092637f, 0.02658255f, 0.02024448f, -0.03704008f, -0.04068279f, -0.00900390f, 0.00507827f, 
    -0.01561036f, -0.00072216f, -0.03641284f, -0.03791956f, -0.00503916f, -0.03566913f, -0.03295261f, 0.02605950f, 
    -0.04029772f, -0.01759343f, -0.00827949f, -0.01564665f, 0.02867963f, 0.01083290f, -0.00915782f, -0.00887450f, 
    -0.00823087f, -0.03220172f, 0.01719672f, 0.00750150f, -0.00117581f, 0.02965955f, -0.03570032f, -0.03130313f, 
    -0.02334299f, -0.00748513f, 0.00432022f, -0.03806528f, -0.02486768f, -0.00246679f, 0.00383058f, 0.02694946f, 
    -0.01412549f, 0.01261256f, -0.01910525f, -0.02824366f, 0.02166610f, 0.01038705f, -0.02923382f, 0.02439633f, 
    -0.01056184f, -0.03117436f, -0.02002290f, -0.03621538f, 0.00665839f, -0.02917847f, 0.02483581f, -0.02205072f, 
    -0.04116366f, 0.00319287f, 0.00863016f, -0.03609011f, -0.00579114f, 0.01074873f, 0.02400795f, 0.02051322f, 
    0.02941500f, 0.02670440f, -0.00602696f, -0.02902145f, 0.01762484f, -0.01210080f, 0.02344640f, 0.00077740f, 
    -0.00508474f, -0.03688609f, -0.00118392f, -0.00774456f, 0.01637398f, -0.00967258f, -0.01731972f, -0.02360431f, 
    -0.01339301f, -0.03384889f, -0.03463960f, -0.03194146f, -0.04169456f, -0.01981094f, -0.02616281f, -0.02778011f, 
    -0.00478521f, 0.01178697f, -0.04169425f, -0.01428951f, 0.01874188f, -0.02247483f, -0.04162733f, 0.01648108f, 
    -0.02784462f, 0.02918605f, 0.01623485f, -0.02690235f, 0.02201241f, -0.03461640f, 0.02061728f, 0.02591486f, 
    0.01120066f, -0.02254128f, 0.02365639f, 0.02029384f, -0.02643993f, -0.02806387f, -0.01933671f, -0.00817036f, 
    -0.03432946f, -0.02015484f, 0.01712709f, -0.02099686f, -0.02450412f, -0.00603723f, -0.03304902f, 0.02392909f, 
    -0.00533544f, -0.01944824f, 0.00551224f, 0.00682661f, 0.01989633f, -0.02216499f, -0.02116477f, -0.03351347f, 
    -0.01722732f, -0.00956299f, 0.00537201f, -0.01227931f, 0.01697061f, 0.01328327f, -0.02483731f, -0.00694291f, 
    -0.02258027f, 0.00809866f, 0.02824974f, -0.03293633f, -0.03828676f, 0.02430660f, -0.00281514f, -0.00460710f, 
    -0.01092832f, 0.02280709f, -0.02251438f, 0.00927043f, -0.03547928f, 0.02251706f, 0.02539922f, 0.00804098f, 
    -0.01873507f, 0.01630453f, -0.00532171f, 0.01421773f, -0.03198038f, 0.02812956f, -0.00968744f, -0.03789016f, 
    0.00004121f, -0.02918572f, 0.01440530f, -0.04153403f, -0.03807589f, 0.01995901f, 0.01787352f, 0.00846208f, 
    -0.04108194f, -0.03000355f, 0.02070415f, -0.01899172f, 0.01384606f, 0.00123599f, 0.01524368f, -0.00377866f, 
    0.00282126f, 0.00763208f, -0.00129267f, -0.02797645f, 0.02109682f, 0.00636464f, -0.01815791f, -0.03558735f, 
    -0.03805785f, -0.01138376f, -0.01179747f, -0.01793681f, 0.00377521f, 0.01957298f, 0.01070046f, -0.00655174f, 
    -0.02884421f, 0.00871539f, -0.00515394f, 0.01803683f, -0.03927192f, -0.01927766f, 0.01569506f, 0.01701394f, 
    0.00989691f, -0.00241834f, -0.04072285f, 0.02122095f, -0.00690155f, 0.01345613f, 0.02985849f, -0.03789247f, 
    -0.02269666f, -0.00800236f, 0.00117601f, -0.00211987f, -0.02775489f, 0.01233070f, -0.00668742f, 0.02437110f, 
    0.01215884f, 0.02878002f, 0.00518939f, 0.02812009f, -0.03406493f, -0.03379928f, -0.03891884f, -0.00696320f, 
    -0.02789208f, 0.01433551f, -0.00704268f, 0.01060201f, 0.00717046f, -0.01698374f, -0.00017632f, -0.01477902f, 
    0.02264967f, 0.00796901f, -0.02781559f, -0.00902338f, -0.03871461f, 0.02281741f, -0.01126613f, 0.00351539f, 
    0.01489984f, 0.02775231f, -0.01051554f, -0.03509685f, 0.02618647f, 0.02723361f, -0.02773903f, 0.02444427f, 
    0.00131533f, 0.01773463f, -0.01943234f, 0.00695439f, -0.03883363f, 0.00287486f, -0.04194621f, -0.03010805f, 
    -0.02616178f, -0.03339800f, -0.02946635f, -0.00343017f, -0.03079268f, 0.00578897f, 0.02168561f, -0.02416432f, 
    0.01472801f, -0.01537799f, 0.01854469f, 0.00299846f, -0.03328648f, -0.03987005f, -0.02678789f, 0.00774412f, 
    -0.03953041f, -0.01549567f, -0.01131225f, 0.02754349f, -0.00173923f, 0.02990289f, 0.01311556f, -0.03246874f, 
    -0.03880291f, 0.01652397f, -0.03536552f, -0.03070322f, -0.02975981f, 0.01548485f, -0.03248587f, -0.00748730f, 
    0.01033336f, -0.03251323f, -0.01194470f, 0.01648914f, -0.03304898f, 0.01178384f, 0.01092697f, 0.00034988f, 
    -0.03498565f, -0.00713730f, 0.00272408f, 0.01970256f, 0.01248547f, 0.00452756f, -0.03711598f, -0.03999513f, 
    -0.01035463f, 0.01013407f, 0.01174506f, 0.00858209f, -0.02769415f, 0.02598019f, 0.00821642f, -0.02530565f, 
    -0.00320158f, 0.02704372f, 0.01271489f, 0.02305877f, -0.02837048f, -0.01345370f, 0.01326101f, -0.02895259f, 
    -0.02163669f, -0.00934435f, -0.03162942f, 0.02930884f, 0.00470387f, 0.00841758f, 0.01632694f, 0.00874192f, 
    -0.01715231f, 0.00721892f, -0.04152456f, -0.01005195f, -0.01629516f, -0.00996822f, -0.02386537f, 0.02382193f, 
    0.02749470f, 0.02617616f, 0.01897770f, -0.02448950f, -0.00739618f, -0.02556936f, 0.01314121f, 0.00500333f, 
    -0.03082425f, 0.02797970f, -0.01547528f, 0.00076840f, -0.03094806f, 0.00134648f, 0.02396517f, -0.00464264f, 
    -0.03809314f, -0.03184040f, 0.00622730f, 0.01569481f, -0.01045869f, -0.01164546f, -0.03419072f, -0.00715864f, 
    0.01720662f, 0.01566818f, 0.01641046f, -0.03433314f, 0.00473661f, 0.01712439f, 0.01610038f, -0.01674606f, 
    -0.04183292f, -0.02910802f, -0.01871363f, -0.02343745f, -0.03480035f, -0.00695536f, -0.02782646f, 0.01803401f, 
    -0.01380449f, -0.02962381f, -0.00105177f, -0.03893106f, 0.01040368f, 0.01120586f, -0.01466803f, 0.01246196f, 
    0.02322875f, -0.04093758f, -0.00228912f, -0.02574810f, -0.04170737f, -0.01517929f, 0.02926051f, -0.00521393f, 
    -0.02783067f, 0.00599506f, -0.00110261f, 0.01318445f, -0.01071177f, -0.03905370f, 0.02596846f, -0.02676297f, 
    -0.03285595f, -0.01704857f, -0.03641196f, 0.02612054f, -0.00715452f, -0.01482823f, -0.01795005f, 0.02797972f, 
    -0.00618832f, 0.01256873f, 0.00736839f, 0.00901782f, 0.00922183f, 0.02529809f, -0.02301300f, -0.00307548f, 
    0.02193753f, -0.00824312f, -0.03789680f, -0.01778351f, 0.01785025f, -0.00534148f, -0.02514542f, -0.00666912f, 
    -0.00723350f, -0.02605499f, 0.02972572f, -0.02402344f, 0.00370416f, 0.00139716f, -0.01448302f, 0.02951378f, 
    0.02250275f, -0.02675111f, 0.01164550f, -0.00675570f, 0.01785542f, -0.00369345f, -0.03196114f, 0.01121450f, 
    -0.00488117f, -0.01371601f, 0.02236992f, 0.00064335f, -0.03037583f, -0.03468782f, -0.02063184f, -0.03581372f, 
    -0.02431641f, -0.02738134f, 0.01319954f, 0.00609984f, 0.00162305f, -0.01448609f, -0.01209362f, -0.00974717f, 
    0.00400125f, -0.02424958f, -0.01008635f, 0.02698891f, -0.03292296f, -0.01690036f, -0.00621496f, -0.00978062f, 
    0.01734070f, -0.02910594f, -0.02363558f, -0.00999398f, -0.00839130f, -0.01937680f, -0.04182161f, -0.03658242f, 
    0.02594279f, 0.01951855f, 0.00648295f, 0.02125091f, -0.03049381f, -0.02671929f, 0.02260407f, -0.01338869f, 
    -0.01098526f, 0.02860996f, -0.01339978f, 0.02612839f, -0.01538554f, -0.03015798f, 0.01233856f, 0.01865321f, 
    -0.03514961f, -0.02817622f, -0.02626879f, 0.00294262f, 0.01063232f, -0.01101831f, -0.00567042f, -0.02413923f, 
    0.00038356f, -0.01283351f, -0.03739231f, 0.00078540f, -0.00044398f, -0.03561915f, -0.03486258f, 0.02673669f, 
    0.02681965f, 0.00306638f, 0.02652436f, -0.02051527f, -0.02338085f, 0.00861441f, -0.02423733f, -0.02298912f, 
    -0.02161999f, -0.00347425f, 0.00731338f, 0.00372143f, 0.00843587f, -0.01483648f, 0.01118415f, 0.00736214f, 
    -0.00031625f, -0.01424817f, -0.02770076f, -0.01862405f, -0.03594619f, 0.00562266f, 0.02080110f, 0.02280018f, 
    -0.00139340f, -0.02629118f, 0.00267094f, -0.01620159f, 0.01570384f, -0.03040429f, 0.01852423f, -0.02037033f, 
    0.00561299f, 0.02592127f, 0.02253752f, -0.03583056f, 0.02652606f, 0.01527081f, -0.03515295f, 0.02879593f, 
    0.02572733f, -0.02490945f, -0.00242896f, -0.00522429f, 0.02290526f, -0.01287355f, 0.00521354f, -0.03606116f, 
    0.01373097f, -0.03591240f, -0.03667280f, -0.02927959f, 0.01538978f, 0.02375510f, -0.04080194f, -0.02958537f, 
    -0.01811840f, 0.01377950f, -0.03371188f, 0.01042765f, 0.00854389f, -0.02493149f, -0.03294269f, 0.01553444f, 
    -0.02649494f, -0.02437892f, -0.00746408f, -0.03384221f, -0.03868520f, -0.03997964f, -0.04059816f, 0.00390425f, 
    -0.02877741f, -0.01828391f, 0.02305445f, -0.01779665f, 0.02871485f, 0.01058531f, -0.03173888f, -0.04078933f, 
    -0.01754455f, -0.00747272f, -0.00107672f, -0.02238685f, -0.03150133f, -0.02726091f, 0.00873996f, 0.01872944f, 
    -0.02885995f, -0.01695567f, -0.04145037f, 0.01783610f, 0.02771636f, 0.02779496f, 0.00717674f, -0.01160574f, 
    0.01695682f, -0.02480275f, -0.01951207f, -0.03404287f, -0.03696224f, -0.01043378f, -0.00623096f, 0.01555085f, 
    0.02235410f, 0.02596541f, 0.00038140f, -0.03955390f, 0.02322470f, -0.03348113f, -0.00848017f, -0.01221356f, 
    -0.03145895f, -0.03066667f, -0.02746778f, -0.02797012f, -0.02030363f, -0.01178098f, -0.03510431f, -0.00940925f, 
    0.01745841f, 0.02431908f, -0.03925817f, 0.00502741f, -0.01959583f, -0.00492068f, 0.02078650f, -0.03784582f, 
    -0.00822514f, 0.02198746f, -0.02329784f, 0.01926450f, 0.01686895f, 0.02196364f, -0.00386897f, 0.02178452f, 
    -0.03049077f, 0.01664232f, 0.00547687f, 0.01005934f, -0.03614085f, -0.03864474f, -0.01808597f, -0.03738310f, 
    -0.04040992f, -0.03137856f, -0.01393857f, 0.02369106f, -0.00326843f, -0.00377537f, 0.02783854f, -0.02850232f, 
    0.02659824f, 0.02026133f, 0.02213509f, 0.01083220f, -0.01233202f, -0.00824700f, -0.00812645f, 0.01261777f, 
    -0.00197526f, -0.01752293f, -0.00211268f, -0.00251378f, 0.00339742f, -0.02256920f, 0.01769367f, 0.02019366f, 
    0.02137269f, 0.01667076f, -0.03269484f, -0.00048366f, -0.00442798f, -0.00471427f, -0.02196522f, -0.01086937f, 
    0.01069173f, -0.03352146f, -0.01029970f, -0.00009978f, 0.01606845f, -0.02408127f, -0.02118512f, 0.01132404f, 
    0.18012965f, -0.00726420f, -0.11160138f, 0.05083393f, -0.06021756f, -0.01400156f, -0.00220402f, 0.16713092f, 
    0.01118248f, 0.05080055f, 0.17514899f, 0.16584498f, 0.02692277f, 0.09415767f, 0.09991568f, -0.06620615f, 
    -0.13958645f, 0.02607369f, -0.07062301f, 0.05619421f, 0.07344890f, -0.07659212f, -0.01351774f, 0.01088833f, 
    0.29106918f, 0.10648670f, 0.05519631f, -0.04458546f, -0.04853104f, -0.04531442f, -0.10887132f, -0.09113679f, 
    0.08341230f, -0.05718562f, -0.00775061f, 0.07127973f, -0.09218701f, 0.02076075f, -0.08788635f, 0.00625556f, 
    0.03702101f, 0.06023227f, 0.02887378f, -0.09721123f, 0.03531001f, -0.04640232f, 0.04412379f, 0.01108051f, 
    0.16127189f, 0.04666485f, 0.06228238f, 0.11158881f, 0.00837957f, 0.13432868f, -0.10038271f, 0.12165777f, 
    -0.00379033f, 0.02541178f, 0.17089243f, -0.14940159f, -0.13379864f, 0.09181105f, -0.10328615f, 0.22152840f, 
    0.05220005f, 0.05500343f, 0.06229765f, -0.01986899f, -0.12406392f, 0.05818183f, 0.02447732f, -0.02067895f, 
    0.21851893f, 0.03429888f, -0.01328426f, -0.17942999f, 0.07558175f, -0.03596122f, -0.05087396f, 0.02292505f, 
    0.03499280f, 0.07768999f, -0.06647211f, 0.03892536f, -0.06393614f, -0.01690873f, 0.20967917f, -0.12602505f, 
    -0.15138878f, 0.00468012f, 0.03465329f, 0.04755108f, -0.04662136f, 0.04564050f, 0.06804993f, 0.06715068f, 
    -0.02161936f, 0.03596902f, 0.08142728f, 0.05131619f, 0.08970521f, 0.01528924f, -0.04024390f, -0.09501107f, 
    0.17387378f, 0.07142075f, -0.11657461f, -0.13414422f, 0.16069117f, -0.12122177f, -0.13103075f, 0.30704007f, 
    -0.13725926f, 0.00829925f, -0.04541769f, 0.03602798f, -0.01790005f, 0.01089101f, 0.10665889f, 0.08662231f, 
    -0.20530467f, 0.31604436f, 0.08996122f, -0.15251997f, 0.10747662f, -0.05629569f, 0.00197056f, 0.04076923f, 
    -0.08059777f, -0.03138446f, -0.01207017f, 0.00761709f, 0.27777976f, 0.13280450f, -0.05767090f, -0.00594466f, 
    -0.05443918f, -0.02029583f, 0.04035731f, -0.02844087f, -0.02079351f, -0.06527674f, -0.02898649f, 0.03318864f, 
    -0.01587283f, -0.05404062f, -0.14661217f, 0.03937081f, -0.11448576f, 0.01266924f, 0.03128772f, 0.10573089f, 
    -0.14484040f, -0.09080982f, 0.13844553f, -0.04469609f, 0.34097120f, -0.24572708f, 0.03132354f, 0.38574171f, 
    -0.06976229f, 0.16499700f, -0.00098214f, -0.00403474f, -0.01031764f, -0.10090920f, 0.03189826f, -0.07808212f, 
    0.01620931f, -0.05780550f, -0.01168795f, -0.07925737f, -0.15273453f, -0.08695825f, 0.00635608f, 0.07769982f, 
    0.02101566f, -0.03418864f, 0.08352815f, -0.10784627f, 0.10275277f, 0.12305468f, 0.08429626f, -0.17521566f, 
    -0.10198237f, -0.00078923f, -0.02007907f, 0.04408896f, -0.03103768f, 0.12389655f, 0.00376579f, -0.01705052f, 
    0.18925735f, -0.07074443f, -0.03003003f, 0.28670442f, -0.02973759f, 0.03195177f, -0.12471206f, 0.11430346f, 
    -0.12057674f, 0.14855593f, 0.02003423f, 0.10798748f, -0.06654669f, -0.21883845f, 0.13170661f, 0.00833706f, 
    -0.00713044f, -0.03502240f, 0.06342355f, 0.07675551f, -0.02524927f, 0.06697439f, 0.13365705f, -0.02050989f, 
    -0.19491453f, 0.04269274f, -0.04653504f, 0.16352446f, -0.13243343f, -0.09313029f, 0.02884179f, -0.08236149f, 
    0.07355261f, -0.11850353f, -0.02865156f, -0.11691155f, -0.11109755f, -0.03289193f, 0.09020691f, 0.17324142f, 
    0.02415384f, 0.03924962f, -0.00064228f, 0.01395667f, 0.10429378f, 0.05522712f, -0.14525437f, -0.21615443f, 
    0.34700185f, 0.19638158f, 0.12938175f, -0.14234315f, 0.11402114f, 0.14873783f, -0.03224700f, -0.08232913f, 
    -0.04886954f, -0.04767944f, 0.12022861f, 0.26752678f, -0.07592157f, -0.21047780f, -0.18333122f, 0.05179510f, 
    -0.05452558f, -0.02849944f, 0.18558364f, 0.14544968f, 0.04465060f, -0.00547559f, 0.09537186f, 0.08793456f, 
    0.02324051f, -0.12858075f, -0.03194210f, -0.05321499f, 0.05421762f, 0.05005248f, -0.06867120f, -0.01347341f, 
    0.02342117f, 0.13492969f, 0.04110940f, 0.19497854f, 0.10233045f, -0.18166821f, -0.07274881f, -0.16007002f, 
    -0.04856356f, 0.02074155f, -0.02015694f, 0.02389310f, 0.02060140f, 0.14335234f, 0.06767254f, -0.01048746f, 
    -0.19813520f, -0.00054702f, -0.01540395f, -0.15515828f, 0.01624884f, -0.02418644f, -0.00398928f, -0.08500718f, 
    -0.07049895f, 0.15020354f, -0.04080600f, 0.11843212f, 0.38934889f, 0.17581242f, 0.16973989f, -0.10696598f, 
    -0.06423301f, -0.06827720f, 0.01369660f, 0.10787069f, 0.16472344f, -0.03613371f, 0.01995775f, -0.00124036f, 
    0.25977266f, 0.05943415f, -0.06191025f, 0.06969140f, 0.02653763f, -0.04588023f, -0.05518454f, -0.05663247f, 
    0.05228643f, -0.12029213f, 0.00497533f, -0.02586430f, 0.44011673f, 0.18810727f, 0.22124618f, 0.10317560f, 
    -0.04867427f, 0.00145959f, 0.07191840f, 0.16224019f, -0.03299626f, 0.03203811f, 0.01592910f, 0.05040053f, 
    -0.27391666f, 0.11898433f, 0.13791814f, -0.03714462f, -0.00427319f, 0.00201842f, 0.08488713f, 0.24697210f, 
    0.00115279f, -0.11847710f, 0.02687555f, 0.04714471f, 0.09192990f, -0.06358732f, -0.03763316f, 0.34499404f, 
    0.00318479f, -0.02875555f, 0.15782586f, 0.00678526f, -0.00661145f, 0.02997123f, 0.03556441f, 0.04180571f, 
    0.20226677f, 0.05261361f, 0.18294664f, -0.11862176f, -0.05727465f, -0.08602348f, 0.06242348f, 0.08571927f, 
    -0.03577243f, -0.07462320f, -0.05884922f, 0.03370109f, 0.04838352f, -0.00669269f, -0.13738737f, 0.01257567f, 
    -0.04586667f, -0.07987574f, -0.07810054f, 0.03020066f, -0.07011173f, 0.01601551f, -0.10174586f, 0.10317623f, 
    0.09701823f, -0.03763719f, -0.01605748f, -0.07242604f, -0.04725512f, 0.12690812f, -0.00978742f, 0.03037406f, 
    -0.00865334f, 0.01829694f, 0.00273849f, 0.06150909f, 0.07260117f, -0.02901505f, -0.05141723f, 0.16888894f, 
    0.05433429f, 0.03481440f, -0.03122240f, -0.13401334f, 0.03090638f, 0.05172679f, -0.04963543f, -0.05543523f, 
    0.15324488f, 0.25442234f, 0.15777509f, 0.04085973f, 0.00884448f, 0.00173895f, 0.03194160f, 0.13806720f, 
    -0.05553846f, 0.07913460f, -0.02126586f, 0.02593867f, 0.14016832f, 0.11339663f, 0.15424590f, -0.22349057f, 
    -0.03245045f, 0.02431209f, 0.03881457f, 0.02932879f, -0.11791914f, 0.00946542f, -0.14259073f, 0.12933522f, 
    0.01272752f, -0.02180486f, -0.03043951f, -0.18016990f, 0.00023863f, 0.01488324f, 0.05608011f, -0.05779827f, 
    0.01971876f, -0.02983328f, -0.01914900f, -0.05818811f, -0.02349186f, -0.26493335f, -0.19310032f, -0.00446351f, 
    -0.02631600f, -0.09070455f, -0.04885050f, 0.03900380f, 0.04909062f, 0.01905909f, 0.01346970f, -0.07946600f, 
    0.28200021f, 0.06012698f, 0.05802924f, -0.12178759f, -0.07434885f, 0.13935748f, 0.00325967f, 0.09301419f, 
    0.15246977f, -0.00070785f, -0.02905739f, -0.12701355f, -0.06452345f, -0.02820025f, -0.17614143f, -0.14199910f, 
    -0.06874647f, 0.01820748f, 0.09059730f, -0.00204153f, -0.03291892f, 0.01976640f, 0.03169366f, 0.11952046f, 
    -0.04058916f, 0.09814879f, 0.14688267f, -0.26920894f, 0.08347829f, -0.09519377f, 0.06040875f, -0.02929489f, 
    0.05037956f, 0.02396579f, -0.02374338f, 0.12933289f, -0.11218984f, 0.02544895f, 0.05715564f, 0.05068860f, 
    -0.02719187f, -0.04468464f, 0.02773556f, 0.01317691f, -0.06290565f, -0.04018888f, 0.11405361f, 0.04245119f, 
    -0.15327589f, -0.13237955f, 0.01737127f, 0.25881916f, -0.00220319f, 0.00305154f, -0.02219471f, -0.06611036f, 
    0.01505748f, 0.03508717f, -0.16343121f, -0.12215181f, 0.06517808f, 0.16128005f, -0.16099012f, -0.10764123f, 
    -0.01215684f, -0.10950191f, -0.04661412f, 0.00417043f, -0.00480627f, -0.09660533f, 0.11792845f, -0.12092982f, 
    0.19599335f, 0.02993487f, -0.02519907f, -0.02036109f, -0.06408292f, 0.07293184f, -0.02174522f, 0.01304524f, 
    -0.01235899f, -0.03921750f, -0.03368209f, 0.01036309f, 0.13928236f, 0.15643276f, -0.08032173f, -0.24525122f, 
    0.04839243f, 0.13909082f, 0.08228880f, -0.13867991f, -0.11751568f, 0.04406431f, 0.03011463f, -0.06528568f, 
    -0.14569943f, 0.07150001f, 0.14439535f, -0.13892601f, -0.06931943f, -0.03747171f, 0.08280447f, 0.01879225f, 
    -0.00855918f, -0.00468019f, 0.17300327f, -0.04896423f, 0.03516441f, -0.13890044f, -0.09872127f, 0.13453020f, 
    -0.02184615f, 0.01296988f, 0.03886206f, 0.00524230f, -0.03857270f, 0.14301969f, -0.02623374f, 0.03063098f, 
    0.01326513f, 0.05665210f, -0.01269713f, 0.03754871f, 0.05554492f, 0.03385048f, 0.16506375f, 0.03564862f, 
    -0.04366847f, 0.00882529f, -0.01940586f, 0.18298289f, 0.25660503f, 0.19790009f, 0.10970912f, -0.14692113f, 
    -0.10587367f, -0.04139214f, -0.03341925f, 0.14001389f, 0.06189381f, -0.10335650f, 0.22503763f, -0.10432815f, 
    0.00837925f, 0.06240895f, -0.13963529f, -0.02537130f, 0.05158295f, 0.02945172f, 0.01095134f, 0.01748668f, 
    0.18878934f, 0.23266882f, -0.11083247f, -0.14253120f, 0.18833031f, -0.08533735f, -0.13877642f, 0.13107656f, 
    -0.09824322f, 0.03048176f, 0.06454945f, -0.04114666f, -0.04936982f, -0.06566377f, 0.10385477f, -0.04754157f, 
    -0.12188006f, 0.08990497f, 0.24396539f, 0.16932204f, -0.12844376f, -0.16923256f, 0.10892861f, 0.15303534f, 
    -0.07826612f, 0.07692808f, 0.10058058f, 0.05718061f, 0.13188143f, 0.17328916f, 0.00065685f, -0.05348548f, 
    -0.06243107f, 0.03554162f, 0.13959967f, 0.10552006f, 0.02576250f, -0.03779423f, 0.05268838f, 0.00887041f, 
    0.09793628f, -0.12353989f, -0.16079515f, 0.24739015f, -0.04287760f, -0.02107552f, 0.09936880f, 0.08103395f, 
    -0.06288890f, 0.01987836f, 0.02457697f, 0.00016679f, -0.17482387f, 0.04505842f, 0.08257379f, -0.05165567f, 
    0.05941491f, -0.06397579f, -0.00291733f, 0.01930914f, 0.14694057f, -0.07799762f, -0.12312673f, -0.16614820f, 
    0.01450805f, 0.02581434f, -0.15074486f, -0.10068779f, -0.03556592f, -0.02549874f, -0.09453343f, -0.00462557f, 
    -0.08469848f, 0.08874762f, -0.01540035f, 0.04194016f, 0.23933429f, 0.10502478f, -0.02522393f, -0.16804948f, 
    -0.10348638f, -0.05785020f, 0.14274479f, -0.05601204f, 0.03237988f, 0.03834916f, -0.00020502f, 0.05508766f, 
    0.11231467f, 0.41185880f, 0.15877688f, 0.09763505f, -0.04436665f, 0.08747326f, 0.04740334f, 0.15469177f, 
    0.03879057f, -0.03891023f, 0.10199070f, 0.07916148f, -0.08518947f, 0.09516647f, -0.01895114f, -0.30661643f, 
    0.02114706f, 0.02980887f, 0.00945381f, 0.14434281f, -0.05310812f, -0.07299216f, 0.04810708f, -0.05082957f, 
    0.35800797f, -0.07836161f, 0.07619038f, 0.43253887f, -0.07938896f, 0.08034629f, -0.03697298f, 0.02973137f, 
    0.08315573f, -0.08063655f, -0.03855056f, -0.08202589f, -0.05863008f, -0.11959264f, -0.09707907f, -0.10586070f, 
    -0.09694235f, 0.17876276f, 0.00688512f, 0.02432607f, -0.04299583f, 0.13469088f, 0.09795351f, -0.12044027f, 
    -0.17480038f, -0.15561740f, 0.00051415f, -0.01741671f, -0.04816126f, 0.07524716f, -0.20090026f, 0.14117676f, 
    -0.04125613f, 0.09490267f, 0.08812001f, 0.03028750f, 0.17604966f, 0.04682128f, -0.05144061f, 0.15454659f, 
    -0.02463772f, 0.06680849f, 0.09782521f, 0.16905917f, 0.12309968f, 0.10148532f, -0.02166182f, 0.08026049f, 
    0.00897546f, -0.03856190f, 0.01820014f, 0.02062658f, -0.02601851f, 0.00738700f, -0.01594677f, -0.00228417f, 
    0.02290350f, -0.03749060f, 0.02104725f, 0.01829461f, 0.01725587f, 0.00580560f, -0.04072215f, -0.01591117f, 
    -0.00657105f, 0.00070287f, 0.02714331f, -0.02714526f, 0.00298652f, -0.00419070f, -0.01691599f, 0.01091195f, 
    0.02645166f, -0.01762464f, -0.04633372f, 0.00364187f, 0.01939331f, 0.00438828f, -0.04087607f, 0.00640498f, 
    -0.02745197f, -0.00448614f, -0.00776500f, -0.02249204f, -0.01995576f, 0.00786669f, -0.01421849f, -0.00569324f, 
    0.01230423f, 0.01601829f, -0.01021123f, 0.00165714f, -0.02785473f, -0.00188043f, -0.00943091f, -0.03300811f, 
    0.02638895f, -0.02379101f, -0.01870397f, 0.00349007f, -0.01922238f, -0.04245386f, -0.03468419f, 0.02323306f, 
    -0.02578415f, 0.00452682f, 0.00178978f, 0.02397330f, -0.02721711f, -0.01360957f, -0.01670151f, -0.01271131f, 
    -0.00865079f, 0.03035462f, 0.00563095f, -0.03778767f, -0.02902343f, 0.02679091f, -0.03733354f, -0.01644943f, 
    0.00482493f, -0.02794711f, -0.02366428f, -0.01516687f, -0.00936648f, 0.01317122f, -0.04379836f, 0.02582528f, 
    -0.01364644f, 0.02692166f, -0.00329687f, -0.03505097f, 0.00256994f, 0.00590263f, 0.02104004f, -0.02182560f, 
    -0.01663648f, 0.00532068f, -0.00448719f, -0.01358740f, 0.01213698f, -0.01823796f, -0.00769746f, 0.02302393f, 
    0.03447070f, -0.00133686f, -0.00294575f, -0.02300062f, -0.03280007f, 0.00065148f, 0.00819220f, 0.00473574f, 
    0.02584426f, -0.01763097f, 0.00839314f, 0.00522912f, -0.02791888f, -0.03421333f, -0.00403447f, -0.03350741f, 
    0.01990579f, 0.00673833f, 0.02849509f, -0.01263902f, -0.01672508f, -0.01373928f, 0.03461788f, 0.02865697f, 
    0.00826512f, 0.02563980f, -0.02004568f, -0.00457094f, -0.02225678f, 0.02173395f, 0.02928940f, -0.01347821f, 
    0.00924237f, 0.02323206f, -0.01051279f, 0.02292454f, -0.03283723f, 0.03015898f, -0.01311954f, 0.01241629f, 
    0.01700757f, 0.00130030f, 0.01854831f, -0.00454312f, -0.00718825f, -0.03920536f, -0.00533249f, 0.00187989f, 
    0.01240897f, 0.01443264f, -0.00999071f, 0.02713933f, -0.03363042f, -0.02823464f, 0.00208403f, -0.01914713f, 
    0.02207404f, -0.01970765f, -0.01320837f, -0.00343553f, -0.01553890f, -0.00206338f, -0.02012951f, 0.02148920f, 
    0.01187201f, 0.01302449f, 0.02198059f, -0.03404987f, -0.00569568f, 0.01617104f, 0.00160503f, 0.01272376f, 
    0.02347264f, 0.00907318f, 0.02523550f, -0.03156264f, -0.00536324f, 0.03216937f, 0.01198877f, -0.03070412f, 
    0.02900130f, -0.02871003f, -0.03387196f, 0.00284962f, 0.01763435f, -0.01608880f, 0.00071604f, -0.00187860f, 
    0.03001423f, 0.00845094f, -0.01561585f, -0.01641068f, -0.00753397f, -0.02245423f, 0.00530659f, -0.02858860f, 
    -0.02625528f, -0.01849712f, -0.03220161f, -0.00007351f, -0.02264862f, -0.00826757f, 0.03317282f, -0.02189109f, 
    0.02615912f, 0.03295521f, -0.03083776f, -0.01228791f, -0.01858048f, -0.01072494f, -0.03515616f, -0.02377686f, 
    -0.01451228f, 0.01104794f, -0.01958018f, -0.02289652f, 0.00871337f, -0.01269732f, 0.00619188f, 0.01556052f, 
    -0.01602897f, -0.03912820f, -0.02699581f, -0.02731033f, -0.02527899f, -0.04198072f, 0.00085991f, 0.00085116f, 
    0.01342412f, 0.03106364f, -0.01398114f, -0.02668861f, -0.02152369f, -0.03485958f, 0.00643489f, -0.02039851f, 
    -0.00499864f, -0.01148069f, -0.02886701f, 0.00065605f, -0.00722403f, -0.03077717f, -0.02281524f, 0.02163452f, 
    0.00018860f, 0.00579700f, -0.04838429f, 0.04042968f, -0.01732265f, -0.00896666f, 0.00366976f, 0.00499888f, 
    -0.03783920f, -0.02778416f, 0.01560412f, 0.01082487f, -0.02122208f, -0.02548259f, -0.03267767f, 0.00398601f, 
    -0.02279630f, -0.01696586f, -0.03925981f, 0.02684610f, -0.00105986f, 0.01400084f, 0.02003509f, 0.01145682f, 
    0.03601414f, -0.01717286f, -0.00119378f, 0.00940035f, -0.02387315f, -0.01207401f, 0.00814667f, 0.03068513f, 
    -0.01487096f, -0.01121982f, 0.01972173f, -0.04397922f, -0.02337154f, -0.03270984f, -0.03508445f, -0.02512538f, 
    0.01777954f, 0.00257702f, 0.00192085f, 0.02190199f, 0.00836878f, 0.01387158f, 0.01615033f, -0.04415425f, 
    -0.00679002f, -0.00881384f, 0.03041108f, -0.00288096f, -0.00923252f, -0.00736972f, -0.01393393f, 0.00015062f, 
    -0.00081780f, 0.03047919f, -0.01392564f, -0.02268661f, -0.00319373f, -0.01928541f, -0.04667780f, -0.02987068f, 
    -0.02289925f, -0.03493391f, 0.03176956f, 0.00823641f, -0.01399883f, -0.03000447f, 0.01149727f, -0.03465640f, 
    -0.04044560f, 0.01424875f, -0.00188669f, -0.01039785f, -0.01230851f, -0.01685477f, 0.01727847f, 0.00666521f, 
    -0.00295226f, 0.00719017f, -0.00110383f, -0.02693197f, -0.00471841f, 0.01986980f, -0.00205534f, 0.01992173f, 
    0.01789657f, -0.00279480f, 0.02339702f, -0.03482485f, -0.02064297f, 0.01095296f, -0.01419126f, 0.00488340f, 
    -0.02171997f, -0.02799534f, -0.00241212f, -0.01728630f, 0.01706161f, -0.03853651f, 0.02885571f, 0.02827084f, 
    -0.03761096f, -0.01708157f, 0.00139384f, 0.01119195f, -0.03402122f, 0.00156944f, -0.00905641f, 0.02524359f, 
    -0.01125442f, 0.00166938f, -0.00206319f, -0.00436960f, 0.01959245f, 0.00616296f, -0.03418926f, 0.02462890f, 
    -0.01163825f, 0.00547990f, -0.00688700f, -0.02849962f, 0.02516890f, -0.03310656f, -0.01041952f, -0.01504705f, 
    0.01067016f, 0.00138424f, 0.01981275f, 0.01295456f, -0.03528447f, -0.04015464f, 0.00100949f, 0.01711192f, 
    0.02903775f, -0.01170615f, -0.01480922f, -0.00978723f, -0.01304070f, 0.01100467f, 0.01889210f, 0.02681560f, 
    -0.03277516f, -0.00883261f, 0.01422516f, -0.03813117f, 0.00584001f, -0.00616921f, 0.00835685f, -0.00434506f, 
    -0.04252523f, -0.00126716f, 0.01000064f, -0.02142706f, 0.00146121f, -0.00860628f, 0.00820528f, -0.03614199f, 
    0.01090475f, 0.01683147f, -0.01427701f, 0.00656838f, 0.00532091f, -0.02757120f, -0.01391380f, 0.02576753f, 
    -0.00777020f, -0.02880938f, -0.03812767f, -0.00477940f, -0.02135182f, -0.02399782f, -0.02436797f, 0.02116274f, 
    -0.01733351f, -0.03729611f, -0.01215711f, -0.04462950f, 0.02673334f, 0.01815029f, 0.00083808f, 0.00291331f, 
    -0.03120146f, -0.02703160f, -0.02972341f, 0.02602940f, -0.02771045f, -0.03707949f, 0.01827443f, 0.02392076f, 
    -0.00544372f, -0.04012599f, -0.02347310f, 0.03430107f, 0.02279026f, 0.00670601f, 0.02523755f, 0.00144610f, 
    -0.02054889f, -0.03028586f, 0.00245026f, -0.03289273f, -0.03417754f, -0.01416204f, -0.02873713f, -0.03309521f, 
    -0.02222692f, 0.01415597f, -0.01026948f, -0.00922873f, -0.02334289f, 0.01281327f, -0.04343974f, -0.00237818f, 
    -0.02181491f, -0.03576268f, -0.01686444f, 0.01077026f, 0.00713954f, -0.01694459f, -0.03654451f, 0.02556616f, 
    -0.02300941f, 0.00791076f, -0.01540400f, -0.01834806f, 0.01921543f, -0.02553382f, -0.02143327f, -0.00270059f, 
    0.02421052f, -0.02257710f, 0.02946505f, -0.03350009f, 0.01708149f, -0.01808110f, -0.02770121f, -0.00035609f, 
    0.01583188f, 0.01212565f, -0.03171461f, -0.04049790f, -0.01757101f, 0.00348547f, -0.00244585f, 0.02296848f, 
    0.01046846f, 0.00168179f, 0.02335394f, -0.03408202f, 0.02655508f, -0.01431267f, -0.04815591f, 0.00591294f, 
    0.01630417f, -0.01629735f, 0.03647548f, 0.00220794f, -0.03857404f, -0.02347985f, 0.02024635f, 0.00002142f, 
    0.01676002f, 0.01733343f, -0.01777666f, 0.01703059f, 0.03114632f, -0.02681175f, 0.00617794f, 0.01813932f, 
    0.00299206f, 0.01452180f, 0.00067486f, -0.01047614f, -0.01894927f, 0.02271361f, -0.04108189f, -0.02627721f, 
    -0.03312741f, -0.03307717f, -0.03652921f, -0.02339524f, -0.02896547f, 0.01196551f, 0.01598762f, 0.02952619f, 
    0.03303459f, 0.00210734f, 0.01655732f, -0.01451221f, -0.03033792f, -0.04634903f, 0.02306272f, 0.00944376f, 
    0.01866248f, 0.00907756f, -0.03997980f, 0.00433258f, -0.01646611f, -0.04580136f, -0.02926610f, -0.02491320f, 
    -0.00799933f, -0.00956476f, -0.01585804f, -0.00482767f, -0.03238440f, 0.00266103f, 0.00378562f, -0.01152007f, 
    0.01128354f, -0.00129135f, 0.01590540f, -0.00690903f, -0.01308047f, 0.02050026f, 0.02604158f, 0.02372527f, 
    -0.03473228f, 0.01023556f, 0.01123619f, -0.00071616f, 0.03931003f, -0.00746260f, 0.01733253f, 0.01809436f, 
    0.02177401f, 0.00912788f, -0.02453356f, -0.02734686f, 0.01825339f, 0.00815568f, 0.00526486f, -0.01080617f, 
    0.02099126f, -0.01473021f, -0.03730924f, -0.01494534f, -0.02776793f, 0.01200202f, 0.02017731f, -0.03541584f, 
    -0.01951840f, -0.03102304f, -0.03578329f, -0.03943663f, 0.01835840f, 0.02659512f, -0.01883748f, -0.01895417f, 
    -0.03780274f, -0.01169798f, 0.00678437f, 0.01253333f, -0.02756805f, 0.02343902f, 0.01042507f, 0.02845275f, 
    -0.01930422f, -0.04747752f, 0.00464510f, 0.02893974f, 0.02601861f, 0.03082649f, 0.01396450f, -0.02629732f, 
    -0.00618709f, -0.03258631f, -0.01228437f, 0.02494921f, -0.00814281f, -0.00368261f, -0.01989887f, 0.03026625f, 
    0.03040056f, -0.02500020f, -0.01389955f, 0.02594131f, -0.00813453f, -0.01844302f, -0.00968281f, -0.04265606f, 
    0.00849100f, -0.00253873f, 0.01157087f, -0.00869383f, 0.00343773f, -0.01954939f, -0.02790929f, -0.00271550f, 
    0.01937294f, -0.00126559f, 0.02155335f, -0.01534348f, -0.00275581f, -0.02387515f, 0.02962743f, -0.00926021f, 
    -0.00967175f, 0.01295929f, -0.03408574f, 0.02382942f, -0.02089075f, -0.03658915f, 0.02298653f, -0.00280416f, 
    -0.03673802f, -0.01657864f, -0.03643532f, 0.00413031f, -0.00434553f, 0.03565054f, -0.00545882f, 0.02812586f, 
    -0.02715819f, 0.02426149f, 0.01023449f, -0.02782734f, 0.02483064f, 0.00441594f, -0.03317096f, 0.00488830f, 
    0.02558924f, -0.01514140f, 0.00454000f, 0.02675967f, 0.00734263f, 0.00953642f, -0.02964656f, -0.02546594f, 
    -0.01874544f, 0.01087607f, -0.00680693f, -0.03243965f, 0.02125516f, 0.00895443f, -0.00021479f, 0.01116513f, 
    0.01020031f, -0.02877640f, -0.00844481f, -0.03595366f, -0.03508054f, -0.01551745f, 0.02581703f, 0.01273543f, 
    0.00752245f, 0.02645867f, 0.00104203f, -0.02383089f, 0.01989949f, 0.00882681f, 0.01650305f, -0.02457225f, 
    0.02344436f, -0.01883720f, -0.00558729f, -0.04672609f, -0.03140356f, 0.01076389f, 0.01900517f, 0.02904444f, 
    -0.01827850f, 0.01883493f, 0.00928275f, -0.02826313f, -0.00405272f, 0.00334704f, 0.00693942f, 0.02472321f, 
    0.01174051f, -0.04334707f, -0.00340245f, 0.00210555f, 0.02396031f, 0.01942822f, -0.02395924f, 0.00936887f, 
    0.03518369f, 0.01733048f, -0.03106731f, 0.04329626f, -0.02355605f, -0.00859420f, 0.01710961f, -0.04326435f, 
    -0.02822176f, 0.02636139f, 0.02674428f, 0.01348160f, 0.03600771f, -0.03425388f, 0.01462170f, 0.02597285f, 
    0.00246976f, -0.02449046f, -0.02053368f, -0.01878290f, 0.03202987f, -0.01832835f, 0.01709409f, 0.02180765f, 
    -0.03867118f, 0.00137346f, -0.00216154f, 0.01940093f, 0.01233821f, -0.04066769f, 0.00653031f, 0.01813370f, 
    0.01087568f, 0.02849599f, -0.00716870f, 0.01414359f, 0.03499992f, -0.02992169f, 0.03029194f, 0.02727243f, 
    -0.00494632f, -0.03172310f, 0.02625981f, 0.01965163f, 0.01947279f, 0.01185456f, 0.02444069f, -0.01417787f, 
    0.01418655f, -0.00417285f, 0.01841664f, 0.02298681f, -0.03976343f, 0.02533115f, 0.01139604f, 0.02795509f, 
    0.00737401f, 0.02704506f, -0.04286071f, 0.01844439f, 0.01282655f, -0.00984128f, -0.03476568f, 0.00673919f, 
    0.02086544f, 0.01949414f, -0.00307432f, 0.02307755f, 0.02198369f, -0.03642016f, -0.03000763f, 0.03008894f, 
    0.00227531f, 0.01663349f, -0.03937472f, 0.01535842f, 0.00194511f, 0.00993643f, 0.02039767f, -0.01518813f, 
    -0.00760768f, 0.01787167f, 0.00992914f, 0.01301778f, -0.02171947f, -0.01694456f, -0.00366463f, 0.01277519f, 
    -0.03634785f, 0.00292712f, -0.02292361f, 0.00371947f, 0.02375658f, -0.03343841f, 0.00329930f, -0.01655139f, 
    -0.01209846f, -0.00901149f, 0.01211432f, -0.00754665f, -0.00072353f, 0.02527099f, -0.03174499f, 0.02291410f, 
    -0.01739882f, 0.01645258f, -0.00863134f, -0.02414250f, 0.02698250f, 0.02913419f, 0.02111945f, -0.03682709f, 
    0.02283764f, -0.00932703f, -0.01989005f, -0.00171914f, 0.02317249f, -0.03044214f, -0.03911855f, 0.01568221f, 
    0.00802188f, -0.00370948f, -0.00875894f, -0.04173965f, 0.01547473f, -0.02747801f, -0.03579208f, 0.00078595f, 
    -0.03138572f, -0.03294203f, 0.00432389f, -0.04064593f, -0.01171794f, -0.02637523f, -0.04326871f, 0.00655956f, 
    0.01996192f, -0.02315683f, -0.01268338f, -0.00629209f, -0.02876169f, 0.02126973f, -0.03889367f, 0.02534964f, 
    0.00525566f, 0.00641379f, 0.00130934f, 0.01713073f, 0.02836086f, 0.02665426f, 0.01274695f, -0.02709361f, 
    0.02395719f, 0.02501962f, -0.02414907f, -0.01774810f, 0.00463195f, -0.01131341f, -0.01653259f, -0.01302553f, 
    0.02687426f, -0.03020650f, -0.04068155f, 0.02290482f, 0.00957658f, -0.00614613f, -0.01919472f, -0.01461275f, 
    0.00354630f, -0.00322718f, 0.02738964f, -0.04345577f, -0.02133453f, -0.01333858f, -0.02492277f, -0.00503722f, 
    0.02401933f, -0.00513321f, 0.00167818f, 0.00633071f, -0.00601546f, -0.03420056f, 0.00808490f, -0.02852866f, 
    0.01160728f, -0.01738109f, 0.00909317f, -0.00733135f, -0.02505744f, -0.01111936f, -0.03160696f, -0.00925415f, 
    0.00444065f, 0.01622638f, -0.03510646f, -0.03253964f, -0.04087090f, 0.00477841f, 0.00189319f, 0.01501381f, 
    0.01139943f, -0.02641264f, 0.01275593f, -0.03610841f, -0.04168893f, 0.02578956f, -0.00953706f, 0.02902232f, 
    -0.02140935f, -0.01356941f, 0.01977647f, 0.00894793f, -0.01100178f, -0.01037090f, 0.01993618f, -0.00889802f, 
    -0.01524073f, -0.00371849f, 0.03079454f, 0.00057582f, -0.01479004f, 0.02371891f, 0.01671189f, -0.03747680f, 
    0.02559398f, -0.03786992f, 0.00206998f, 0.01391213f, 0.01757465f, -0.02893237f, -0.02556308f, -0.00337872f, 
    0.00853001f, -0.02691118f, 0.02354027f, -0.02984718f, 0.01727946f, -0.02926269f, 0.02118616f, 0.01582978f, 
    -0.00417427f, -0.03546931f, -0.03864201f, -0.01861498f, -0.03309546f, 0.02302849f, -0.00187180f, 0.00191258f, 
    -0.00879483f, 0.02207482f, -0.00522489f, 0.01370203f, -0.02975602f, 0.01054060f, -0.01715033f, -0.02596292f, 
    0.00933117f, -0.01623899f, -0.03344023f, 0.02685860f, -0.00132649f, -0.03069205f, -0.00486545f, 0.00839713f, 
    0.00276983f, -0.00843821f, 0.01898285f, -0.01420406f, -0.02282031f, -0.04126886f, -0.01206607f, -0.00078966f, 
    0.00480883f, -0.02803079f, 0.01692062f, -0.00707035f, 0.02021251f, -0.02135538f, -0.01599126f, 0.02155261f, 
    0.00577061f, -0.02876894f, 0.01737568f, -0.00109823f, -0.00732444f, -0.04359135f, 0.02165812f, -0.03138323f, 
    -0.03192784f, -0.03754819f, -0.01697999f, 0.00363870f, -0.02708681f, 0.01286661f, -0.00276689f, -0.01248969f, 
    -0.02849108f, 0.01653068f, -0.03160607f, 0.00028130f, -0.00597332f, -0.00010155f, 0.00960495f, 0.02721776f, 
    0.00767392f, -0.04271933f, -0.01382198f, 0.01813092f, -0.00385886f, -0.02162308f, -0.03680921f, -0.01704534f, 
    -0.00009236f, -0.00769156f, 0.01619805f, -0.00419998f, 0.00266635f, -0.01408943f, -0.01818827f, 0.02968388f, 
    0.00836847f, 0.01442574f, 0.00370874f, -0.03736772f, 0.00756948f, 0.01748927f, -0.03671586f, 0.01109756f, 
    -0.00034591f, 0.01176519f, 0.00216265f, 0.00207435f, -0.02502720f, -0.00511153f, 0.00001062f, -0.02041596f, 
    0.00583948f, -0.03646088f, 0.02287644f, -0.03901214f, -0.03141113f, -0.01310461f, 0.01093557f, -0.04061633f, 
    -0.03117583f, -0.03871301f, -0.03275162f, 0.00066136f, 0.02025401f, 0.00543946f, -0.02500744f, 0.00651204f, 
    -0.02489359f, -0.01365798f, 0.01892857f, -0.01888919f, 0.01644797f, -0.02746687f, 0.00375140f, 0.02767729f, 
    0.00346131f, 0.01464400f, 0.01133773f, -0.02693915f, -0.02027988f, 0.01782481f, -0.00936736f, -0.03775349f, 
    0.02268022f, -0.04099639f, -0.03020554f, -0.01203505f, 0.02201128f, 0.01888048f, -0.02211855f, -0.02716437f, 
    0.01087281f, -0.01966487f, 0.00236972f, 0.01344065f, 0.01699561f, -0.01131774f, 0.01613785f, -0.01925878f, 
    0.02595655f, -0.00101913f, -0.03477281f, -0.02865616f, 0.00312756f, 0.02512240f, -0.02789505f, -0.00744447f, 
    -0.04028097f, 0.01725708f, -0.00539826f, 0.00022162f, -0.03537355f, -0.02714580f, -0.00826794f, 0.01278777f, 
    -0.03212799f, 0.00289405f, -0.01099296f, -0.00191121f, -0.00564774f, -0.02618182f, -0.02522073f, -0.01207261f, 
    0.00124652f, -0.01471629f, 0.02650895f, -0.03920692f, -0.03666202f, 0.00029175f, 0.00509789f, -0.01839948f, 
    0.01677776f, 0.02661090f, 0.00148293f, 0.02611683f, 0.01454243f, -0.03984993f, 0.00614735f, 0.00315133f, 
    0.02982669f, -0.01558729f, -0.02229688f, -0.02714327f, -0.03125384f, 0.02298405f, -0.01884823f, 0.01264963f, 
    -0.00829697f, 0.01405260f, 0.01465002f, 0.01729360f, -0.02502162f, 0.01509821f, 0.02292451f, 0.00754566f, 
    -0.00463567f, -0.01195892f, -0.01378627f, 0.00768602f, 0.00626936f, 0.03179890f, -0.00189447f, -0.02656441f, 
    -0.00401717f, -0.01522663f, -0.03354571f, 0.00760948f, -0.00483982f, 0.02263191f, 0.02635706f, -0.02357349f, 
    -0.01890069f, -0.03745673f, 0.00843851f, -0.03063361f, -0.03523095f, -0.00048508f, 0.01051478f, -0.02624088f, 
    -0.02074340f, 0.00604327f, 0.00865184f, -0.04193559f, -0.02099393f, -0.01695124f, -0.00759827f, 0.02643499f, 
    -0.02279917f, -0.01037077f, -0.02856947f, 0.00543969f, 0.01148640f, -0.02403020f, -0.04288562f, -0.02685586f, 
    -0.02783825f, -0.02256542f, -0.03595996f, 0.00634327f, 0.00530176f, -0.04080822f, -0.00825747f, -0.03266951f, 
    -0.02161951f, 0.01779138f, 0.01095676f, -0.03564812f, -0.01342961f, -0.03767719f, -0.00113810f, -0.00004771f, 
    -0.04136262f, -0.01610690f, -0.00264946f, -0.00722456f, 0.00204600f, 0.02622600f, 0.00036220f, 0.00505590f, 
    0.00643698f, -0.00583671f, -0.00920581f, -0.04163230f, -0.03150602f, -0.00976976f, 0.00958478f, -0.01371345f, 
    0.02427347f, -0.01705655f, 0.02251907f, 0.02129422f, -0.03850223f, 0.01082608f, -0.00444839f, -0.01226524f, 
    0.01919167f, -0.00433085f, -0.02566950f, -0.03943628f, -0.00703814f, -0.00093769f, 0.01468618f, -0.02400054f, 
    0.02035501f, 0.01461933f, -0.03254453f, 0.00508997f, 0.00884459f, -0.02677938f, -0.00116585f, 0.01871988f, 
    0.00136942f, 0.01054878f, -0.01954725f, -0.03941494f, -0.01098260f, -0.03754082f, 0.00781419f, 0.00326446f, 
    -0.03993203f, -0.01499717f, 0.01492763f, -0.02298166f, -0.01251443f, -0.03295268f, -0.02121320f, -0.02009501f, 
    -0.02827253f, 0.02736200f, 0.00914180f, -0.01633880f, -0.03950510f, -0.02607272f, -0.00976182f, 0.01524046f, 
    -0.02612663f, 0.01876296f, -0.01180666f, -0.02419181f, -0.03653767f, -0.03493380f, -0.02139411f, 0.00936097f, 
    -0.04073799f, 0.01419488f, -0.02205283f, 0.01888853f, -0.04083910f, 0.02073884f, 0.02028722f, -0.00032871f, 
    -0.01438682f, -0.00257145f, 0.02536814f, 0.02700363f, 0.01198123f, -0.00576672f, -0.02465938f, 0.01742842f, 
    0.02533904f, -0.02218601f, 0.01611523f, 0.00245668f, 0.01809370f, 0.02675249f, 0.00533870f, 0.01908939f, 
    0.01010276f, 0.01186557f, 0.01345746f, 0.01260612f, -0.00471833f, -0.00984645f, 0.02721501f, 0.02365844f, 
    0.00382920f, -0.04019391f, -0.02158960f, -0.00632415f, -0.02317929f, -0.00829621f, -0.01891904f, -0.02460577f, 
    -0.02126911f, -0.02154837f, 0.01986961f, -0.00736349f, -0.00284587f, -0.00590069f, -0.00593748f, 0.01888327f, 
    0.00841057f, -0.01766924f, -0.00686918f, -0.00612541f, 0.01181555f, -0.02609636f, -0.03301414f, -0.03291633f, 
    0.02042470f, 0.02434812f, -0.01450740f, -0.03781187f, 0.02057641f, -0.01609990f, -0.04249205f, -0.02737223f, 
    -0.01197642f, -0.02188344f, -0.01142163f, -0.00461629f, 0.02954244f, 0.01694707f, -0.00807270f, 0.02092190f, 
    0.00921245f, 0.00287399f, -0.00038227f, -0.02662080f, 0.01307186f, -0.03791247f, 0.00933784f, -0.02469511f, 
    0.00139160f, -0.00244909f, 0.02939332f, 0.01102943f, 0.00722240f, -0.03062802f, 0.00140200f, 0.02597258f, 
    -0.00633775f, 0.01149357f, -0.02424510f, -0.00799957f, -0.00863661f, 0.00224032f, 0.02724826f, 0.01747076f, 
    -0.04003095f, -0.03587974f, 0.02318688f, 0.02017255f, -0.02516917f, -0.01781807f, -0.01075086f, -0.03230246f, 
    -0.00115572f, 0.01613144f, 0.02472900f, 0.02577885f, 0.01225139f, 0.00118801f, 0.01248313f, -0.03969635f, 
    -0.01532130f, -0.01214819f, -0.02922974f, 0.02191709f, -0.02790904f, -0.01190912f, -0.02107147f, -0.01480047f, 
    0.02319287f, -0.02180154f, 0.02305026f, -0.04037020f, 0.01558399f, 0.01613578f, 0.02541577f, -0.02140335f, 
    0.00413292f, 0.01079063f, -0.00554834f, -0.02320751f, -0.04356685f, -0.01295369f, -0.03508847f, 0.00230527f, 
    0.01600464f, 0.00651823f, 0.02649303f, 0.01893917f, 0.00788725f, 0.00007709f, -0.01000947f, -0.01314774f, 
    0.00486525f, -0.01313169f, 0.00802536f, 0.01589223f, -0.01335258f, 0.02316340f, -0.01678515f, 0.01367925f, 
    -0.01084373f, 0.03191108f, 0.00677318f, -0.03441571f, 0.00828848f, 0.01918600f, 0.00042887f, -0.00491771f, 
    0.00882234f, -0.00948325f, -0.01031313f, 0.02344026f, -0.01477883f, -0.01163275f, -0.01310918f, -0.01011813f, 
    -0.03016187f, -0.02905792f, -0.00573320f, 0.01781036f, 0.02568560f, -0.00030778f, 0.00586964f, 0.01425134f, 
    0.00565047f, 0.01035285f, -0.02168181f, -0.03598070f, 0.03001530f, -0.00025233f, 0.01413116f, 0.00244663f, 
    -0.00704203f, -0.01654003f, -0.01330934f, 0.02293821f, -0.02670983f, -0.04198984f, -0.01409241f, -0.00172966f, 
    0.01835321f, 0.00350335f, -0.01959017f, -0.01862352f, 0.02741224f, -0.02285133f, -0.03731047f, -0.02268294f, 
    -0.01186353f, 0.00337737f, 0.00674605f, 0.02193191f, -0.04259668f, 0.01093446f, -0.03684570f, -0.02199473f, 
    0.02052547f, -0.00879872f, -0.04087988f, 0.02796387f, -0.03750697f, -0.00291244f, -0.04222651f, -0.00919343f, 
    0.02254729f, 0.02540498f, 0.02899291f, -0.00360272f, -0.00281052f, -0.00296600f, 0.00855714f, -0.02029724f, 
    -0.01269085f, 0.00703892f, -0.00036787f, -0.02648792f, 0.00152366f, 0.00174811f, -0.00617417f, 0.01242172f, 
    -0.03252262f, -0.02200055f, -0.03253030f, -0.00957178f, -0.03413373f, 0.00399226f, 0.02041651f, 0.01516209f, 
    -0.02170378f, -0.02575848f, 0.00984695f, -0.02136226f, -0.01276097f, 0.01916138f, -0.04262627f, -0.02576710f, 
    -0.01220822f, 0.03233492f, -0.00068642f, -0.03167286f, -0.03083778f, -0.03001829f, -0.03593928f, -0.00915070f, 
    -0.03411937f, 0.01298039f, -0.03162740f, -0.02520707f, 0.00182546f, -0.02214182f, -0.00937030f, 0.01968320f, 
    -0.01055492f, -0.03203344f, 0.01707853f, 0.02429594f, 0.01002906f, 0.02714224f, -0.01166006f, 0.02624054f, 
    -0.03052009f, -0.02537246f, 0.00257223f, -0.02046599f, 0.01591542f, -0.00670343f, 0.02312585f, -0.00390339f, 
    0.01081462f, 0.01751968f, 0.00291816f, 0.00979080f, 0.01749444f, -0.02600379f, -0.02499122f, -0.00072779f, 
    0.02270378f, 0.03513181f, -0.01570358f, 0.01923532f, -0.03080714f, 0.02795896f, -0.02132740f, 0.00790921f, 
    -0.01515909f, 0.03496042f, -0.01984986f, -0.00036552f, -0.00765450f, -0.01705707f, -0.02288400f, -0.01957066f, 
    -0.03270823f, 0.02621576f, 0.00048653f, -0.01299607f, 0.01172511f, 0.00111367f, -0.00784799f, -0.00521769f, 
    0.01653847f, 0.02012875f, -0.02651425f, -0.01988929f, 0.00528694f, 0.00281756f, 0.02867257f, 0.00578521f, 
    -0.00217445f, -0.02203512f, -0.02260131f, 0.02803810f, -0.03510093f, -0.00392681f, -0.00969298f, -0.00589104f, 
    -0.00147800f, -0.02726195f, -0.02768024f, -0.02750100f, -0.01753172f, -0.00605913f, -0.00983668f, -0.00992300f, 
    -0.01390551f, -0.00889879f, -0.00287174f, -0.02129609f, 0.02244485f, -0.01922954f, 0.01807661f, -0.01402252f, 
    0.01551881f, 0.01907352f, -0.01061628f, -0.01900810f, 0.00385631f, 0.02998770f, -0.02576110f, 0.02257280f, 
    0.00401630f, 0.00283950f, -0.02171289f, 0.02138358f, -0.01440761f, -0.02361098f, -0.01278020f, 0.02893490f, 
    -0.01191018f, 0.01195617f, -0.01471024f, 0.00889017f, 0.02495946f, 0.00707600f, 0.01808637f, -0.00833058f, 
    -0.03474920f, 0.02374992f, 0.00226500f, -0.02377061f, -0.00076806f, 0.01272185f, 0.03073230f, -0.01029625f, 
    0.00969221f, 0.02750684f, 0.03594248f, 0.00829478f, 0.02187929f, -0.00385089f, -0.00340561f, 0.01018601f, 
    0.02202558f, -0.00073978f, -0.03098692f, -0.02173256f, 0.02071818f, -0.02966442f, 0.03093258f, 0.02481946f, 
    -0.02014619f, -0.03407801f, -0.03592621f, -0.03508443f, -0.00503053f, 0.02437261f, -0.00221155f, 0.02358254f, 
    0.02939916f, 0.01477706f, 0.00846155f, -0.03488136f, -0.02936829f, -0.02013398f, 0.02124440f, -0.02242921f, 
    0.03142300f, -0.03102504f, 0.00495213f, -0.01889389f, -0.00651187f, 0.00908678f, 0.00288393f, -0.01706174f, 
    -0.02036115f, 0.02914610f, -0.02150597f, 0.03454205f, 0.01350723f, -0.00250474f, -0.01477752f, -0.02890877f, 
    0.03240923f, -0.02072205f, -0.01773853f, -0.02870652f, 0.01257484f, 0.00802092f, 0.02791190f, -0.02457625f, 
    0.02655452f, -0.00501871f, -0.03234522f, -0.02612185f, -0.02479722f, -0.00665965f, 0.01998612f, 0.02535260f, 
    -0.01233378f, -0.03160135f, 0.01349219f, 0.02416167f, -0.00353228f, 0.03064921f, -0.00362256f, 0.03228121f, 
    -0.02907627f, -0.03350370f, -0.02911774f, -0.03497148f, 0.03066546f, -0.02567201f, -0.01192988f, -0.02093000f, 
    -0.02512895f, 0.03147043f, -0.02682432f, -0.03386754f, -0.02570238f, 0.01499979f, -0.00365898f, -0.02007635f, 
    0.03169600f, -0.00317386f, -0.00200855f, 0.02806506f, -0.00112885f, -0.01109173f, 0.02638065f, 0.02908793f, 
    0.02747820f, 0.00540923f, -0.02501124f, -0.03334601f, 0.02412978f, -0.01230463f, -0.02084998f, -0.02854551f, 
    0.03032222f, -0.01029249f, -0.01972280f, 0.00565665f, -0.02177525f, -0.01752434f, -0.02946555f, -0.00630246f, 
    -0.02056941f, -0.00623471f, 0.00721700f, -0.00051346f, -0.03564487f, 0.03273430f, 0.02612946f, 0.03468336f, 
    0.02173809f, 0.03068157f, 0.02754360f, -0.02229313f, 0.02583167f, 0.01483781f, -0.00818061f, 0.01123548f, 
    0.01568468f, -0.02480448f, -0.02229456f, 0.02366854f, -0.02135162f, -0.02090250f, -0.01870824f, 0.02580063f, 
    0.02709732f, -0.02447606f, -0.01875252f, -0.00748975f, -0.02292118f, 0.00772136f, 0.01323156f, -0.03590395f, 
    -0.01965319f, 0.01353874f, -0.01608050f, 0.02219639f, 0.01166085f, -0.02625884f, 0.00769470f, -0.01130170f, 
    -0.01424152f, 0.01559098f, 0.02917571f, 0.00150551f, -0.02097347f, 0.01843498f, 0.00814005f, 0.00009749f, 
    -0.03527889f, -0.01775972f, 0.00074571f, 0.02940130f, -0.02584247f, 0.02096124f, -0.01615453f, 0.02609972f, 
    0.00991099f, -0.03562573f, -0.03505260f, 0.01478461f, 0.02969875f, 0.00817886f, -0.00566234f, -0.03391227f, 
    -0.01887888f, 0.00128534f, -0.00418957f, 0.00867647f, 0.01320405f, 0.01332525f, -0.01053147f, -0.01873595f, 
    0.03004904f, -0.02457510f, 0.00703529f, 0.03187591f, 0.03408564f, -0.02113688f, 0.01591314f, 0.00803819f, 
    0.00811551f, -0.00721165f, -0.02728252f, 0.01196665f, 0.01675432f, -0.01708767f, -0.02497628f, 0.03355920f, 
    -0.03238070f, 0.02056953f, 0.02046492f, 0.03033360f, 0.02961020f, 0.00488694f, 0.01998234f, 0.03493030f, 
    -0.00413834f, -0.01197103f, 0.00496598f, 0.02571083f, 0.02136893f, -0.00529002f, -0.01955898f, -0.02287473f, 
    0.03571362f, -0.00780452f, -0.00475867f, -0.02635137f, -0.00989288f, 0.01823821f, 0.03131323f, -0.03182257f, 
    -0.00241320f, -0.01119231f, 0.02312786f, 0.00128382f, 0.02139795f, 0.01547944f, 0.02698926f, -0.02695817f, 
    -0.00653543f, -0.03519482f, 0.01678017f, -0.00862320f, 0.03264406f, -0.01098755f, 0.03037801f, 0.00063781f, 
    0.02652041f, -0.00338482f, 0.00826124f, -0.00237365f, -0.01967643f, -0.03591848f, 0.02379077f, 0.01452990f, 
    0.03420691f, -0.00275340f, 0.01052703f, 0.02910632f, -0.00296319f, 0.00875843f, 0.00117686f, -0.01050076f, 
    0.00758288f, 0.01067651f, -0.03332920f, 0.01215133f, -0.02059462f, 0.03245071f, -0.02549701f, 0.01533229f, 
    0.00439250f, -0.01557058f, -0.01631004f, 0.02182600f, -0.01140622f, 0.02252812f, -0.03608271f, -0.03305897f, 
    0.02979596f, 0.02258088f, 0.02368332f, -0.03096962f, 0.03493540f, -0.01935588f, -0.02897754f, -0.02712898f, 
    -0.02928376f, -0.01522578f, -0.02667101f, -0.01079204f, 0.03512421f, -0.00178416f, -0.02947313f, -0.02678164f, 
    0.00998261f, -0.01349655f, -0.03146224f, -0.03192605f, 0.00118484f, 0.00709054f, 0.03117761f, -0.01231215f, 
    0.03488707f, 0.01321550f, -0.03358499f, -0.00813224f, 0.03356761f, -0.02814172f, -0.01347416f, 0.00018710f, 
    -0.01374448f, 0.01872030f, 0.03501215f, 0.02230407f, -0.00493941f, -0.02232437f, 0.00686150f, -0.00520021f, 
    -0.01864264f, -0.02956864f, -0.02668654f, -0.02161761f, 0.02896331f, 0.03479518f, 0.02701975f, 0.00337925f, 
    -0.01397192f, -0.03105094f, -0.01270525f, 0.00548413f, 0.01394460f, 0.01049697f, 0.03183096f, 0.02492051f, 
    0.02324781f, -0.03555280f, 0.00103836f, 0.02030657f, 0.03513627f, -0.02723533f, -0.00300562f, 0.02070265f, 
    0.00929011f, -0.02979835f, 0.02354569f, 0.03423149f, -0.01251818f, 0.03374780f, 0.00511867f, 0.02569755f, 
    0.00779878f, 0.01884015f, -0.03224337f, 0.02383342f, 0.01076929f, 0.01876453f, 0.00882097f, -0.02769760f, 
    -0.01611169f, -0.02776980f, -0.01765597f, -0.02448798f, -0.01020819f, 0.01346701f, 0.00515097f, -0.03135101f, 
    -0.00774034f, -0.03329162f, -0.02839034f, 0.00917306f, -0.03522745f, -0.02133738f, -0.00400280f, -0.03094509f, 
    -0.01756437f, 0.00399591f, -0.02156768f, -0.02825432f, -0.00572516f, -0.03465647f, 0.00870557f, 0.00981209f, 
    -0.02766160f, 0.00340155f, -0.03548756f, -0.03433577f, 0.02063138f, -0.02545155f, 0.01576448f, 0.00489559f, 
    -0.02328664f, 0.03443030f, -0.01951844f, 0.00471166f, -0.02290689f, -0.01430797f, 0.02643827f, -0.03063799f, 
    0.02258437f, -0.00082316f, -0.01837750f, -0.01919159f, 0.01161266f, -0.01801139f, -0.00046515f, 0.01807890f, 
    -0.03447154f, -0.03166246f, -0.02894167f, -0.02877907f, -0.00961170f, -0.01112043f, 0.00343962f, 0.01614237f, 
    -0.03094201f, 0.02277914f, -0.00895100f, -0.02348034f, -0.01438758f, -0.01140156f, -0.02785083f, 0.01160815f, 
    -0.02694181f, -0.02238442f, 0.03127721f, 0.00713897f, -0.01688305f, 0.01775200f, 0.02417874f, 0.03240707f, 
    -0.01281077f, 0.00490556f, -0.02397899f, -0.00926665f, -0.00431780f, -0.03502002f, -0.01838128f, 0.02967693f, 
    0.00845766f, -0.02669627f, -0.00034064f, -0.01487640f, 0.02293239f, -0.03570747f, -0.03063154f, -0.03254490f, 
    -0.01898272f, -0.00357447f, -0.02500138f, 0.03017701f, 0.02219323f, 0.02647204f, -0.00457867f, -0.00671509f, 
    -0.01238991f, -0.01171218f, -0.02587292f, -0.03385227f, -0.01203412f, 0.03590093f, -0.00194607f, 0.00900076f, 
    0.01273728f, 0.00228745f, 0.00523542f, -0.02440009f, -0.00408228f, 0.00708377f, -0.03192753f, 0.02540033f, 
    0.03126872f, -0.03560955f, 0.00420933f, 0.02753607f, 0.01097006f, -0.00994088f, -0.01849906f, -0.01128384f, 
    0.02209893f, 0.03062175f, 0.00120434f, 0.01477548f, -0.02388028f, 0.00449770f, -0.01449888f, -0.02217500f, 
    0.00853949f, 0.03292161f, -0.00825774f, 0.01436686f, 0.00670408f, 0.01453491f, 0.01503230f, 0.03595376f, 
    0.02923957f, 0.01784801f, -0.02555694f, 0.02634003f, -0.02136600f, 0.02974869f, -0.03477992f, 0.00534049f, 
    0.00122478f, 0.00330788f, -0.02490758f, -0.00331823f, 0.01033219f, -0.03081820f, 0.01935996f, -0.00506349f, 
    -0.02749659f, -0.00049273f, 0.00487479f, -0.01270846f, -0.00899820f, -0.01130546f, -0.02444401f, 0.00666969f, 
    -0.02196211f, 0.03516262f, -0.00499098f, 0.01033618f, -0.02191323f, -0.01127289f, 0.00687468f, 0.02258123f, 
    -0.01210953f, -0.01777217f, -0.00984551f, 0.02565099f, -0.01384394f, -0.03378525f, -0.02960504f, -0.03144694f, 
    -0.00223587f, -0.02093446f, 0.01312191f, 0.00171715f, 0.02432169f, 0.02843126f, 0.01202543f, -0.00971636f, 
    -0.02410414f, -0.01999221f, 0.01363144f, -0.02629518f, -0.02349846f, -0.01027505f, 0.01151937f, 0.01058514f, 
    0.00176379f, 0.01857312f, -0.03538746f, -0.03177061f, -0.01493164f, -0.02374335f, 0.00820427f, 0.01309680f, 
    0.00358517f, -0.02662614f, -0.02880968f, -0.02211941f, -0.00848088f, 0.02484186f, 0.00315426f, -0.03120138f, 
    -0.03537948f, 0.03405961f, -0.00537564f, -0.02056307f, -0.01031974f, 0.02701391f, -0.01185965f, 0.02658484f, 
    -0.02325814f, -0.00097901f, -0.02236312f, -0.00502102f, 0.03179787f, 0.00257588f, -0.01205641f, 0.01438924f, 
    -0.01816617f, -0.03006844f, -0.00209062f, -0.01011782f, 0.01775725f, -0.02106038f, 0.03131397f, -0.03011164f, 
    0.00458536f, -0.00121506f, -0.00346900f, -0.00946602f, -0.00597251f, -0.00704328f, 0.01156336f, -0.01705105f, 
    0.01705110f, 0.01778555f, 0.00610644f, -0.02789954f, -0.00928477f, 0.03477904f, -0.02599320f, -0.01740432f, 
    0.02343628f, -0.01675063f, 0.03575778f, 0.01564917f, 0.02962987f, 0.02153380f, -0.01109177f, 0.02789444f, 
    0.01938909f, -0.01873403f, 0.01978917f, 0.00753716f, 0.03572861f, -0.00400216f, 0.01390542f, -0.01272361f, 
    -0.03199014f, -0.01257829f, -0.00926199f, 0.01884271f, 0.00327929f, 0.01732173f, -0.00161849f, -0.01894210f, 
    -0.03127213f, 0.00358820f, -0.00497595f, -0.00091920f, -0.01554028f, -0.00226956f, 0.00843065f, -0.02801239f, 
    -0.00338300f, -0.00057144f, -0.01345224f, 0.00554140f, 0.01995531f, 0.02300988f, 0.03219739f, -0.02205574f, 
    -0.04192372f, 0.11632307f, 0.11309364f, -0.00395446f, 0.05864818f, 0.06003224f, -0.02930491f, -0.11071198f, 
    0.03205570f, -0.03594378f, 0.09127920f, 0.11762500f, 0.38302568f, 0.00946703f, -0.00091858f, 0.06887683f, 
    0.05544855f, 0.01239573f, 0.11160003f, 0.03821589f, 0.10238644f, 0.11058909f, 0.02974520f, 0.14747635f, 
    -0.21109082f, -0.08100622f, -0.22762939f, -0.01562624f, 0.03442633f, 0.06765598f, 0.11114000f, -0.07277495f, 
    -0.06759553f, 0.08156117f, 0.11740230f, 0.02194422f, -0.09260680f, 0.15552913f, 0.10753199f, 0.04261525f, 
    0.11729996f, -0.01526888f, -0.02055201f, -0.02429878f, -0.03568646f, 0.13319956f, -0.00892051f, 0.06175094f, 
    -0.22112717f, 0.18400301f, 0.16228127f, -0.20257206f, 0.06759580f, -0.01005050f, -0.01122048f, 0.06193470f, 
    0.02187026f, -0.04569118f, 0.01596032f, 0.01743666f, 0.00980442f, 0.09578262f, 0.27920297f, 0.05875112f, 
    0.15778293f, 0.03941529f, 0.00154319f, 0.06232373f, 0.15158314f, 0.04262725f, 0.19807591f, -0.05946961f, 
    0.35856536f, 0.02995475f, -0.13109531f, 0.33398148f, 0.05138682f, 0.04060628f, 0.13681978f, 0.04499177f, 
    0.04504071f, -0.05532799f, 0.04845196f, -0.01623000f, -0.11228698f, -0.19934259f, -0.20144363f, -0.08749076f, 
    -0.00279606f, -0.02311929f, -0.04607249f, -0.06508613f, 0.03553012f, 0.07254317f, -0.00699185f, -0.02638754f, 
    0.01408730f, 0.11726721f, 0.04934274f, -0.20946002f, 0.14332418f, 0.10659895f, -0.04205869f, 0.11597855f, 
    0.01226437f, 0.03506431f, 0.07034505f, -0.05130717f, -0.25963074f, -0.08467875f, 0.13081756f, 0.00177505f, 
    0.05160659f, 0.03898418f, 0.03124397f, 0.04198337f, 0.19836588f, 0.04696183f, 0.16734824f, 0.12967861f, 
    0.11741659f, 0.00587537f, -0.29268169f, -0.22222739f, -0.02357959f, 0.09138127f, 0.03688953f, 0.07856504f, 
    0.08999573f, -0.00057503f, 0.09802923f, 0.07674711f, 0.23989162f, 0.03900513f, -0.05516456f, 0.08585686f, 
    0.02550420f, -0.03165672f, -0.02237354f, 0.17609377f, 0.16554798f, -0.00432461f, 0.06934371f, 0.07970371f, 
    -0.34921098f, -0.01892071f, 0.10976049f, -0.03641682f, 0.18428199f, 0.07493532f, -0.02974433f, -0.00939286f, 
    0.04155070f, 0.09498599f, 0.12954953f, 0.05590048f, -0.18130919f, -0.06003239f, 0.02063250f, -0.10322046f, 
    0.09268610f, -0.08906849f, 0.03415597f, 0.17542721f, 0.03815397f, -0.00927817f, -0.03865347f, 0.15944375f, 
    -0.18822427f, 0.06684832f, -0.11305732f, -0.25809047f, 0.22820857f, 0.02881604f, 0.01310624f, 0.02773749f, 
    0.00395469f, 0.03561434f, 0.09598930f, -0.01296008f, -0.20015404f, -0.03507812f, -0.01016102f, -0.16354540f, 
    0.02654961f, -0.07189167f, -0.03544079f, 0.00126363f, -0.07556184f, 0.03906450f, 0.03909400f, 0.00438371f, 
    -0.14814438f, 0.01651745f, -0.16629572f, -0.16177326f, 0.03339468f, 0.01815970f, -0.01342823f, -0.03649542f, 
    0.06526562f, 0.13943598f, 0.08966709f, 0.16867410f, 0.07902045f, 0.21584527f, -0.15021719f, 0.05143385f, 
    0.02125931f, -0.11877792f, 0.00505703f, 0.11883428f, 0.11769979f, -0.17800806f, 0.02738111f, 0.07159503f, 
    0.09361805f, 0.03251073f, -0.24797136f, -0.26839632f, 0.04364732f, 0.04443151f, -0.16614746f, 0.12000628f, 
    0.10464956f, 0.01054996f, -0.07317655f, 0.10694698f, 0.11420324f, 0.18618494f, -0.00655481f, -0.42419025f, 
    0.10735419f, 0.05104047f, 0.01178116f, 0.14635988f, 0.00193995f, 0.04395757f, -0.00631894f, 0.07522179f, 
    -0.03621764f, -0.19691616f, 0.15874794f, 0.09186929f, 0.02449093f, 0.06744405f, 0.03070002f, -0.00402134f, 
    0.07842940f, 0.12469783f, -0.02918943f, -0.01457236f, -0.20388363f, 0.20700826f, 0.05214847f, -0.03715189f, 
    -0.09105843f, -0.01298508f, 0.08040284f, 0.19802001f, 0.06174292f, -0.05820041f, -0.05959846f, 0.04404366f, 
    -0.29276082f, -0.09143761f, 0.19853316f, -0.05774692f, 0.23066680f, 0.11567081f, 0.05774976f, 0.02832346f, 
    0.00707736f, 0.08449740f, 0.06975866f, 0.06596396f, -0.14962479f, 0.29419166f, 0.12196948f, 0.05657959f, 
    0.00318590f, -0.01358816f, -0.06826024f, -0.00267944f, 0.16830188f, 0.17707999f, 0.10489801f, 0.09981953f, 
    0.03851319f, 0.14970060f, -0.07064361f, 0.14945309f, 0.08569796f, 0.15392865f, 0.14162286f, 0.01442207f, 
    -0.01547078f, 0.16187689f, 0.10560959f, 0.13422453f, -0.26421973f, -0.10292091f, -0.24443525f, -0.27441448f, 
    -0.10309456f, 0.06667658f, 0.03819759f, 0.00567125f, 0.05330073f, 0.00163153f, 0.03969764f, -0.03228764f, 
    0.13601771f, -0.08366273f, -0.10553790f, 0.05867958f, 0.08411945f, 0.08422197f, 0.02387870f, 0.00870089f, 
    -0.02859294f, -0.00531467f, 0.00187620f, 0.04010867f, 0.20311615f, -0.20449057f, -0.14323355f, -0.07176245f, 
    -0.14595656f, 0.00475656f, 0.02258397f, -0.01924204f, -0.01662300f, -0.07594167f, 0.04497076f, 0.03890817f, 
    0.05615211f, -0.12559104f, -0.11089937f, 0.06684893f, -0.10372875f, -0.00556123f, 0.04281178f, 0.04191982f, 
    0.05455101f, -0.03672897f, 0.06540895f, -0.03661072f, 0.04304550f, 0.01822549f, 0.10718239f, -0.05643297f, 
    0.11434291f, -0.10251765f, -0.06812663f, 0.07196499f, -0.01701944f, -0.02619551f, -0.03479194f, 0.08325426f, 
    -0.13341792f, -0.22760540f, -0.15631467f, -0.20754981f, -0.03180092f, 0.03285342f, -0.01059027f, -0.05495866f, 
    0.04746987f, 0.03781614f, -0.00008351f, 0.07390393f, -0.09239808f, -0.06784067f, -0.06390473f, -0.01448826f, 
    0.09883606f, -0.00416697f, 0.06466431f, 0.04523110f, 0.05314580f, 0.03360711f, 0.08036224f, 0.00270686f, 
    -0.02902370f, -0.07139474f, 0.01249275f, 0.07803744f, -0.07873874f, -0.05395949f, 0.05187524f, 0.01350547f, 
    -0.01551993f, 0.03504281f, 0.05919426f, 0.07205208f, 0.04339749f, 0.08011387f, 0.08884995f, -0.23665491f, 
    0.15380658f, 0.02869459f, 0.04709448f, -0.03996002f, 0.09195818f, -0.00794311f, -0.01846872f, 0.05766768f, 
    0.35260761f, -0.28878123f, 0.02277308f, 0.09842889f, -0.06574122f, 0.08292259f, 0.04749820f, -0.03270267f, 
    0.01485003f, 0.00435820f, 0.04994360f, 0.11993179f, -0.09267268f, -0.01832341f, -0.01522993f, -0.03423193f, 
    0.10175248f, 0.02173975f, -0.01474389f, -0.00398876f, 0.08778647f, 0.20154801f, 0.04625999f, 0.00165677f, 
    0.17885014f, 0.01986243f, -0.19464365f, 0.08944634f, 0.06890631f, 0.06883949f, 0.10974661f, 0.05960514f, 
    0.10395467f, -0.02581574f, 0.12252237f, -0.03417122f, -0.26329651f, 0.00636502f, 0.22780125f, 0.06853843f, 
    0.17869262f, 0.16268341f, -0.01207103f, 0.13097732f, 0.05900467f, 0.05293297f, 0.10113876f, 0.06127355f, 
    -0.10976291f, 0.04288250f, -0.06298533f, 0.02041005f, 0.05218154f, -0.01857354f, 0.02987492f, -0.02474750f, 
    -0.05512103f, 0.08162918f, 0.16998631f, 0.09856074f, -0.33043358f, 0.00998173f, 0.22556834f, 0.11839918f, 
    0.16751160f, 0.06160012f, 0.06602713f, -0.00701105f, 0.15117930f, -0.02204636f, -0.02476926f, 0.07210927f, 
    0.04531439f, 0.00577923f, -0.16566549f, 0.01178419f, -0.04170685f, 0.12383583f, 0.10572962f, -0.02298885f, 
    0.05383813f, 0.09211121f, 0.07681391f, 0.01119118f, 0.06340842f, 0.14120553f, 0.20787808f, 0.10765321f, 
    0.10001819f, 0.00776911f, 0.08881043f, 0.03804835f, 0.10214086f, 0.11363287f, 0.10186865f, 0.07360631f, 
    0.33067128f, 0.34670627f, 0.20525239f, 0.02926325f, 0.10510661f, -0.02586542f, 0.01590709f, 0.07398067f, 
    -0.04551075f, 0.11573553f, 0.13019925f, 0.12425571f, 0.00916692f, 0.05414614f, -0.06254273f, -0.15381500f, 
    0.10853414f, 0.05303754f, 0.03863672f, 0.18399753f, 0.17170468f, -0.03709857f, 0.00394377f, 0.11587505f, 
    -0.06086908f, -0.03345246f, 0.05265870f, -0.14571413f, 0.18563941f, 0.17522383f, 0.09608499f, 0.03603265f, 
    -0.01467185f, 0.03161064f, -0.02755864f, 0.02069658f, 0.06068185f, 0.00071906f, -0.09262540f, -0.14788321f, 
    0.08977053f, 0.06496221f, -0.06723264f, -0.04843831f, 0.14298770f, -0.01381358f, 0.03413140f, 0.09319018f, 
    -0.33690932f, 0.02534175f, 0.02856733f, 0.09561967f, 0.10826746f, 0.14822371f, 0.08674528f, 0.09268281f, 
    0.05535056f, -0.01321019f, 0.13855743f, -0.01717937f, -0.47727627f, 0.06798825f, 0.17445871f, -0.06223658f, 
    0.12251943f, 0.15719639f, -0.05241215f, 0.01931653f, -0.01531965f, 0.04002019f, 0.10664506f, -0.02880722f, 
    -0.36465535f, -0.00069378f, 0.12337443f, 0.05221377f, -0.03183682f, 0.06754045f, 0.05898014f, 0.18795903f, 
    0.15005295f, 0.02001107f, 0.02564613f, 0.07939238f, -0.26569024f, -0.23229499f, -0.09178454f, -0.02530676f, 
    0.01656312f, -0.05056648f, -0.01125920f, 0.07398213f, 0.04733074f, 0.04817170f, 0.04055525f, 0.15441920f, 
    -0.27222818f, -0.00356657f, 0.39818224f, 0.21997164f, 0.16890225f, 0.09775539f, 0.00069621f, 0.06106253f, 
    0.07661068f, 0.06191176f, -0.07499658f, 0.04932133f, -0.26559126f, -0.01605423f, 0.16383253f, 0.12938495f, 
    0.12672363f, 0.07765459f, 0.11648193f, 0.15160358f, 0.08334155f, 0.08553172f, 0.03348129f, 0.18204500f, 
    0.09938837f, -0.21981023f, -0.01786324f, -0.11694561f, -0.04483432f, 0.03299547f, 0.07578991f, 0.08668009f, 
    0.06173208f, -0.02017341f, -0.05094782f, 0.15869404f, -0.36980286f, 0.01036874f, 0.13013318f, 0.16880248f, 
    0.11364700f, 0.12515706f, 0.09387985f, 0.05466238f, 0.10061862f, 0.04136653f, 0.08620440f, 0.09355184f, 
    -0.17600347f, 0.08157769f, -0.02657285f, -0.08602604f, 0.06247478f, 0.05870417f, -0.05261173f, -0.05148025f, 
    0.07481694f, -0.01554399f, -0.01073160f, 0.15404804f, 0.26980907f, -0.07287617f, -0.14232889f, -0.25461081f, 
    0.05819539f, 0.00712376f, 0.08740208f, 0.10409373f, 0.12988585f, 0.01074197f, 0.06119636f, 0.07277223f, 
    -0.09653939f, 0.01017318f, -0.19890428f, -0.23964915f, 0.04086592f, 0.03349056f, -0.05713875f, 0.01542689f, 
    0.09571089f, 0.10022651f, -0.08435154f, 0.00565627f, 0.05455470f, -0.00988255f, 0.12966640f, -0.09010404f, 
    0.09641694f, 0.14078173f, 0.02360333f, 0.09363604f, -0.00969959f, 0.02473309f, 0.13123575f, 0.08753578f, 
    0.05043997f, -0.30546746f, 0.03132961f, -0.11690016f, -0.07204121f, -0.14058279f, 0.06780475f, 0.07435466f, 
    -0.03169049f, 0.01885530f, 0.02934430f, 0.06348268f, -0.07511530f, 0.06114563f, 0.01025892f, 0.00520522f, 
    0.00662089f, 0.11497626f, -0.01743324f, 0.06196424f, 0.06036589f, 0.00327258f, -0.04547897f, 0.09802082f, 
    -0.16559295f, 0.05474593f, -0.18719994f, -0.26057041f, -0.01527369f, -0.02578851f, 0.08852876f, 0.07450234f, 
    0.06550816f, 0.16454415f, 0.04594460f, 0.00213847f, 0.07063562f, 0.12176687f, 0.26922289f, 0.01663158f, 
    0.17325141f, 0.15869854f, 0.14219257f, 0.05872886f, 0.03122768f, 0.06624310f, -0.05073612f, 0.05400069f, 
    -0.36386934f, 0.06500588f, 0.31848949f, 0.22716616f, 0.20442219f, 0.19307619f, 0.10412236f, -0.02169720f, 
    0.12030749f, 0.01925246f, 0.05360832f, 0.06554493f, -0.23426908f, -0.08888812f, 0.05675322f, -0.12027417f, 
    -0.06540807f, 0.05352318f, -0.03714070f, 0.07405604f, 0.04292562f, 0.08428302f, 0.15552346f, 0.11971535f, 
    0.00422365f, 0.00287779f, -0.00063376f, 0.02815985f, -0.03364896f, -0.02836862f, -0.01291703f, -0.01620107f, 
    -0.00601656f, -0.01222432f, 0.01444315f, 0.02993890f, -0.04079988f, -0.01430448f, 0.02551034f, -0.02022538f, 
    0.02760313f, -0.00115845f, -0.01589833f, 0.01986252f, 0.02737193f, 0.02733755f, 0.00261107f, -0.01093224f, 
    -0.02295733f, -0.03835019f, 0.00211684f, 0.02723502f, 0.01675191f, -0.02917379f, 0.02718449f, -0.00652013f, 
    0.01969032f, -0.03191761f, 0.00413370f, 0.01350254f, -0.02536272f, 0.00176789f, -0.02704421f, 0.00639472f, 
    0.00063061f, 0.01829042f, -0.04038892f, -0.02189448f, -0.03919113f, -0.03694423f, 0.00043727f, 0.00043099f, 
    0.03145185f, 0.00282182f, -0.00512522f, -0.02865892f, -0.02627800f, 0.02642738f, -0.00979496f, -0.02620128f, 
    0.02098586f, -0.00507631f, -0.03876620f, -0.00675493f, -0.00427292f, 0.00264836f, -0.01085429f, -0.02897269f, 
    -0.02332495f, 0.01071929f, -0.00054402f, 0.02915226f, 0.00394827f, 0.02846028f, -0.00632640f, 0.00061206f, 
    -0.03878937f, 0.01691072f, 0.02734569f, -0.00354445f, 0.02807705f, -0.00275405f, -0.04112536f, -0.00043219f, 
    -0.03040690f, -0.02296775f, -0.01265213f, 0.01295933f, -0.03836928f, -0.02498055f, 0.01076363f, -0.01746786f, 
    0.00408904f, 0.00375705f, -0.03281452f, -0.00183302f, -0.01847436f, -0.03933586f, -0.03546654f, -0.01906754f, 
    -0.02962390f, -0.01508387f, 0.02048123f, 0.00029645f, 0.01640889f, 0.03735984f, 0.00879269f, -0.00745891f, 
    -0.01569075f, -0.00120948f, -0.02302749f, 0.00087218f, 0.02364278f, -0.02292046f, -0.00694940f, -0.03527560f, 
    0.03611982f, -0.03833478f, 0.02706943f, -0.01418277f, 0.02579653f, -0.02929212f, -0.00503230f, 0.00928955f, 
    0.02169389f, -0.02354556f, -0.02144414f, -0.01109868f, 0.01283231f, 0.00833366f, -0.03342339f, -0.01252229f, 
    0.02113579f, -0.00910007f, -0.00454328f, -0.03785240f, -0.01243260f, -0.00738291f, -0.03726844f, -0.02297315f, 
    -0.01601895f, -0.02471801f, -0.00751987f, -0.00960291f, 0.02918209f, -0.01755278f, 0.02069476f, 0.02334743f, 
    0.03517781f, -0.02458727f, -0.02670917f, 0.02784758f, -0.00134122f, -0.02841708f, -0.00565141f, -0.01245969f, 
    0.00272074f, 0.01942659f, 0.02570144f, 0.02167081f, -0.00358337f, 0.02069008f, -0.01106843f, -0.02677390f, 
    0.00285105f, 0.02041081f, 0.02270088f, -0.03695020f, -0.02380766f, -0.02732518f, -0.02283649f, -0.01304712f, 
    -0.02344786f, -0.01115221f, 0.00513612f, 0.00203621f, -0.00769275f, -0.00098351f, -0.00031363f, -0.00939321f, 
    -0.03147154f, -0.02977277f, 0.02281925f, -0.03800210f, -0.03784433f, 0.02498546f, 0.01639812f, -0.01933377f, 
    0.01519483f, -0.03040621f, 0.02272498f, -0.01756168f, 0.02206767f, -0.00054255f, -0.03851189f, 0.00736732f, 
    0.01567018f, 0.00076654f, 0.01405562f, -0.03596472f, 0.00705137f, -0.01870704f, -0.03881380f, 0.01984088f, 
    0.02001736f, -0.01861295f, 0.01817300f, -0.02789916f, 0.03762384f, -0.03223648f, 0.02774058f, 0.01523178f, 
    -0.03658189f, 0.02068509f, 0.00453403f, -0.02467044f, -0.01709718f, -0.02737176f, -0.02716603f, -0.00254936f, 
    0.01996641f, -0.02297764f, 0.00344270f, 0.01913255f, 0.01880388f, 0.01946460f, -0.00933485f, 0.02551896f, 
    0.01444454f, -0.03491278f, -0.03412543f, 0.02962752f, 0.00380446f, 0.04122652f, 0.01815271f, -0.03800489f, 
    -0.00986829f, -0.01442639f, 0.01612953f, -0.03280321f, -0.02734647f, -0.01767521f, -0.01119568f, -0.02852698f, 
    -0.01420741f, -0.01722939f, -0.02584796f, -0.00892825f, 0.00147238f, 0.00496029f, -0.04159778f, 0.00567326f, 
    -0.01648360f, 0.01425503f, 0.02656684f, -0.00382250f, -0.00392313f, -0.03655706f, -0.03469858f, -0.03508786f, 
    -0.00517562f, -0.02849121f, -0.02283743f, 0.00045189f, -0.02387398f, -0.00135749f, -0.02789211f, 0.02479221f, 
    -0.01690651f, -0.00560953f, 0.00981701f, -0.03429092f, -0.03737231f, 0.03988928f, -0.00230940f, -0.04059212f, 
    -0.03183366f, -0.02081822f, -0.03383797f, 0.00146873f, -0.00776710f, 0.01889087f, -0.02985757f, -0.02634128f, 
    -0.02944636f, -0.00420860f, 0.02807343f, -0.03534045f, 0.02952858f, -0.02906376f, 0.01223038f, 0.00514389f, 
    -0.03752748f, -0.02181520f, -0.01650774f, -0.03922453f, -0.04153474f, 0.01054475f, 0.01217763f, -0.01897069f, 
    0.00809695f, -0.01947139f, -0.00078370f, 0.01603780f, -0.02787850f, -0.04114487f, -0.00281908f, -0.04025821f, 
    0.01474778f, -0.00129495f, -0.00575821f, -0.01375357f, 0.00293773f, -0.03816478f, -0.02727645f, 0.00572916f, 
    0.02842279f, 0.02576730f, 0.01965629f, 0.02204170f, -0.00514061f, -0.01566468f, 0.02672480f, 0.02876070f, 
    -0.01519989f, 0.00676117f, 0.01157496f, -0.01984778f, 0.01261451f, 0.01860947f, -0.00623879f, 0.02626873f, 
    0.01741475f, 0.00533298f, -0.00546032f, 0.01006683f, 0.03587921f, -0.00221666f, 0.02394915f, -0.03704055f, 
    -0.00213333f, -0.02343446f, -0.03948750f, -0.00759762f, -0.02630160f, -0.00799701f, 0.01331025f, -0.03348004f, 
    0.00586579f, 0.00461668f, 0.01568062f, -0.01633486f, 0.01083250f, -0.00999148f, 0.01756174f, 0.02666172f, 
    -0.01925326f, -0.01797009f, 0.02395407f, 0.00369960f, 0.02956370f, -0.03481102f, -0.01826054f, 0.00102357f, 
    -0.02480055f, -0.01373021f, -0.01785278f, 0.01267829f, 0.02115962f, 0.00169896f, -0.03187688f, -0.00673156f, 
    0.01462256f, 0.01820417f, 0.01250802f, 0.00188207f, 0.01542111f, 0.00776910f, 0.02548920f, 0.01869431f, 
    0.02221609f, 0.01771168f, -0.02412732f, -0.01781886f, -0.01766375f, -0.00783038f, -0.03786610f, -0.00461299f, 
    -0.01548362f, -0.00258011f, -0.02203188f, -0.03964752f, 0.01894082f, -0.01252881f, 0.02555824f, -0.01597404f, 
    -0.03929670f, 0.00359088f, 0.02128246f, -0.02882310f, -0.01437333f, 0.00872832f, -0.00548453f, -0.00031077f, 
    -0.02143312f, 0.03175759f, -0.02013965f, -0.01357895f, -0.01152809f, 0.00383741f, 0.01133052f, -0.02381696f, 
    -0.02949968f, -0.02265821f, -0.00155185f, 0.00951076f, -0.02065741f, 0.00909104f, -0.02261003f, -0.03741987f, 
    -0.03844838f, -0.01868379f, -0.01440617f, -0.03049006f, -0.01918750f, -0.03031769f, -0.01633744f, -0.01134935f, 
    -0.00835937f, 0.00064836f, 0.00157159f, -0.02587656f, 0.00077475f, -0.00157479f, -0.01264924f, 0.01337818f, 
    -0.01051162f, -0.02731798f, -0.04043157f, -0.04061497f, -0.03196958f, -0.02478227f, -0.00929491f, -0.00739102f, 
    -0.01949745f, 0.00396948f, -0.01635507f, -0.03858474f, -0.00572126f, -0.01095037f, 0.01844193f, -0.01503034f, 
    0.00409180f, 0.03964709f, -0.00867082f, 0.01454724f, 0.02465320f, 0.02289217f, -0.00549852f, -0.02144423f, 
    0.01684658f, -0.02188061f, 0.02457510f, -0.01344891f, -0.01299914f, -0.04109298f, 0.00265903f, -0.00861301f, 
    0.02697033f, 0.02655291f, -0.01647707f, 0.02074825f, -0.00762574f, 0.03003932f, 0.00978460f, -0.02089784f, 
    -0.02408293f, -0.00262053f, -0.00744309f, -0.01978144f, 0.01290443f, 0.01351841f, -0.02042855f, -0.03705934f, 
    0.02103853f, -0.00809268f, 0.01060463f, 0.01963989f, 0.01844338f, 0.02733570f, 0.03370398f, -0.02300248f, 
    0.00425272f, -0.00798522f, -0.03799327f, 0.02732390f, -0.03050327f, -0.01605405f, -0.02086401f, 0.01531803f, 
    0.01135328f, -0.00429145f, -0.02093945f, 0.00212007f, -0.02409149f, -0.03828775f, 0.01465296f, -0.02179258f, 
    -0.03769592f, 0.01601679f, -0.03843476f, -0.02764485f, -0.01759018f, -0.02671019f, -0.01628590f, -0.02466410f, 
    0.00434939f, -0.03175923f, 0.03590445f, -0.01147070f, -0.02050523f, 0.01372352f, 0.01993807f, -0.00037888f, 
    -0.01234286f, -0.03677071f, 0.01114533f, -0.01668641f, -0.00219343f, -0.01781901f, -0.00517516f, 0.02995809f, 
    -0.02645403f, -0.00101000f, -0.03935813f, 0.02854710f, -0.00250837f, 0.01392737f, 0.00755132f, -0.00163276f, 
    -0.03523660f, 0.01738348f, -0.02544914f, 0.00462258f, -0.00077820f, 0.00140571f, 0.02504890f, -0.00177223f, 
    0.01464248f, -0.02435591f, 0.01274629f, -0.03711206f, -0.02965195f, 0.00785833f, -0.01653108f, 0.02111965f, 
    0.01687635f, 0.02074685f, -0.02266154f, 0.01314380f, 0.01745781f, -0.03882901f, 0.04056301f, -0.03706465f, 
    0.02521488f, 0.03589694f, -0.02761102f, -0.04112772f, 0.01309388f, 0.00984623f, 0.01236795f, -0.00612787f, 
    0.02360965f, 0.00144371f, -0.03392478f, -0.00990425f, 0.03314258f, -0.00309459f, 0.01981664f, 0.01226974f, 
    -0.03497269f, 0.00190288f, 0.01794193f, 0.01399179f, -0.01417631f, 0.01030236f, -0.01417279f, 0.00527280f, 
    -0.02058248f, 0.00493701f, 0.01391043f, -0.01017890f, 0.01435618f, 0.03007576f, -0.00391192f, -0.02678549f, 
    -0.00300317f, 0.01794166f, -0.02075044f, -0.00487777f, 0.01251345f, 0.02104327f, -0.03843224f, -0.02760316f, 
    0.01689449f, 0.02347253f, -0.02821746f, -0.03343956f, -0.00142774f, 0.01733466f, 0.00642606f, -0.01089094f, 
    -0.01052890f, 0.01322736f, 0.02623323f, -0.00967343f, -0.03003746f, -0.03456275f, -0.03302030f, -0.02281157f, 
    -0.03663512f, 0.01823101f, -0.00389980f, 0.02133331f, -0.01677013f, 0.01447683f, -0.01231465f, -0.00132351f, 
    0.02153982f, 0.02015218f, -0.04088178f, -0.01102736f, -0.02450352f, -0.00087609f, 0.02306030f, -0.02530419f, 
    0.03126862f, -0.02027201f, 0.00863746f, 0.02642211f, -0.00435269f, -0.01459970f, -0.03286447f, -0.00521712f, 
    0.01803551f, -0.02407263f, 0.00623496f, 0.00824537f, 0.01458556f, -0.03364452f, -0.02751476f, 0.02828017f, 
    -0.00079201f, 0.02249302f, 0.00133731f, -0.00080593f, -0.00368376f, 0.02776672f, 0.02861915f, 0.00705608f, 
    -0.01995530f, -0.01342924f, -0.03003013f, 0.02438458f, 0.02082443f, -0.04034446f, 0.00828733f, -0.03474089f, 
    -0.03531377f, 0.00857186f, 0.00113305f, -0.01201077f, -0.00233206f, -0.01102022f, -0.00943697f, -0.00866054f, 
    -0.01027359f, -0.02182569f, 0.02276636f, 0.01335734f, 0.01376421f, -0.01327493f, 0.02813029f, -0.00501030f, 
    0.00378476f, 0.01878335f, 0.02682138f, 0.03636951f, -0.01717922f, 0.02547863f, -0.02109077f, -0.03371453f, 
    0.00068470f, 0.00854222f, -0.01874954f, -0.01147763f, -0.02519106f, -0.02317772f, -0.01791531f, 0.02418976f, 
    -0.00661842f, -0.00814508f, -0.00862548f, -0.03597014f, -0.01728320f, -0.00245381f, 0.00595193f, -0.02656222f, 
    0.02383181f, -0.02401821f, -0.04002594f, 0.01661271f, 0.02231034f, -0.02838728f, -0.01109799f, 0.01723526f, 
    -0.00837740f, 0.02789749f, -0.03864078f, -0.00436105f, -0.01640955f, -0.00471477f, 0.02256166f, -0.02823547f, 
    0.02463974f, -0.04166181f, -0.01823562f, 0.02593498f, 0.02615583f, -0.01755954f, 0.00972552f, 0.00331359f, 
    -0.00977136f, -0.00696975f, 0.01525199f, -0.01101575f, -0.03892254f, 0.00021643f, -0.02869199f, -0.00162548f, 
    0.01325621f, -0.02863383f, -0.02847079f, 0.01616346f, 0.01361361f, -0.02841759f, -0.03577288f, -0.00223477f, 
    0.01350324f, 0.02768690f, -0.03086371f, 0.00397943f, 0.02234814f, 0.00159200f, -0.02671214f, -0.01128882f, 
    0.00232000f, -0.04204914f, 0.02492145f, 0.01600134f, -0.02083768f, -0.03042417f, 0.01290608f, 0.00386451f, 
    0.01199488f, 0.00685615f, -0.04082116f, -0.01968956f, -0.02535463f, -0.03597858f, 0.00013103f, -0.00956470f, 
    0.07365080f, -0.08341049f, 0.12278932f, -0.08031838f, -0.03562596f, -0.07348874f, 0.13304718f, 0.15202741f, 
    0.03816464f, 0.03317992f, 0.04167966f, 0.14838140f, -0.38159361f, -0.13491434f, 0.03134390f, -0.05707974f, 
    0.09148012f, 0.12461183f, 0.01459964f, 0.01555661f, -0.00432418f, -0.06263134f, 0.03331193f, -0.01529557f, 
    -0.71767509f, 0.29158154f, 0.04854820f, -0.13604397f, 0.25110853f, -0.11203266f, 0.09073927f, -0.02829516f, 
    0.04052077f, -0.04400667f, -0.00943281f, -0.00803803f, 0.50517529f, 0.10553198f, -0.09657834f, -0.03133940f, 
    -0.00679521f, 0.04495863f, 0.00805010f, 0.08964080f, 0.12844728f, -0.00155507f, 0.04168081f, 0.02689011f, 
    0.11644877f, 0.04047394f, -0.04384857f, -0.15318213f, -0.00666149f, 0.06638259f, -0.07106385f, 0.13769580f, 
    0.01484589f, 0.05629685f, 0.14516734f, -0.07108751f, 0.11241440f, 0.07728987f, 0.07452958f, -0.04289781f, 
    -0.01134002f, 0.02890388f, 0.06789902f, 0.07784525f, -0.04770735f, 0.10567610f, 0.00938023f, -0.03234859f, 
    -0.04419364f, -0.04628579f, 0.16879317f, -0.01958709f, 0.11303059f, -0.01412739f, 0.01003424f, -0.02441928f, 
    -0.02477007f, 0.01314988f, 0.02485352f, 0.15600483f, -0.06390318f, 0.01651517f, -0.01062821f, -0.11149036f, 
    -0.07869451f, 0.02271050f, -0.00077605f, -0.01881691f, -0.01957152f, -0.10006850f, 0.06587724f, -0.04861396f, 
    -0.04797833f, 0.24172466f, 0.01306803f, 0.17772412f, -0.09717257f, -0.06979730f, -0.00257174f, 0.07571529f, 
    0.13331592f, 0.10170075f, 0.00446624f, 0.11540952f, 0.04994657f, -0.02548213f, 0.15451393f, 0.00127962f, 
    0.01063502f, 0.00874548f, 0.03038028f, 0.04990835f, -0.01395837f, -0.02254390f, -0.00209527f, 0.04652421f, 
    -0.22565682f, -0.00187362f, 0.27718103f, 0.16571172f, -0.14404571f, -0.12700534f, -0.05412225f, 0.02478392f, 
    -0.08632705f, -0.13427019f, 0.03459432f, -0.08721117f, 0.07351473f, -0.20359504f, 0.10206667f, 0.02300400f, 
    -0.03394540f, -0.01578239f, -0.03159401f, -0.01139347f, 0.08366084f, 0.08137745f, -0.01739700f, 0.14043193f, 
    0.14052983f, 0.12574989f, 0.06018362f, 0.04619562f, -0.00728551f, -0.03353035f, -0.00328297f, 0.05301746f, 
    -0.00603018f, -0.00550102f, -0.02867522f, -0.13297361f, 0.21504109f, 0.01767439f, 0.09105745f, 0.00854989f, 
    0.01823288f, 0.03650951f, 0.04422475f, 0.04269150f, -0.02821585f, -0.07251472f, 0.08765727f, -0.00025599f, 
    0.41785553f, 0.10511281f, 0.11587808f, 0.06347734f, -0.11640420f, 0.02792741f, -0.03330907f, -0.00175543f, 
    0.06083204f, -0.01506663f, 0.07466044f, 0.01034604f, 0.03259095f, 0.04571965f, 0.00414462f, -0.22491360f, 
    0.04796755f, 0.06487012f, 0.04817796f, -0.13456617f, -0.11140090f, 0.03995581f, 0.02750739f, -0.05114828f, 
    0.07015330f, 0.10858296f, -0.00139299f, 0.03803593f, 0.09791394f, 0.01442280f, -0.06043387f, 0.02013068f, 
    0.06712721f, -0.03626692f, 0.08512523f, 0.00954222f, -0.20232072f, -0.12013658f, -0.12048865f, 0.06378707f, 
    0.02279345f, -0.07072012f, 0.16603039f, 0.00551839f, 0.02095437f, 0.02222373f, 0.10743092f, 0.18362442f, 
    0.37477970f, -0.06448222f, 0.12681979f, -0.04597620f, 0.02116894f, -0.14582878f, -0.00884987f, 0.03448092f, 
    0.05851628f, -0.00030313f, 0.03043404f, -0.00290568f, 0.11836095f, -0.06431224f, -0.09768761f, 0.21584016f, 
    -0.02046980f, 0.01823868f, 0.02925421f, 0.00382836f, -0.04057674f, -0.02615989f, -0.03622003f, -0.00024548f, 
    0.23022042f, -0.07822585f, 0.06385683f, 0.19059955f, -0.00166713f, 0.00427133f, 0.04047636f, 0.00111706f, 
    -0.09905175f, 0.07545745f, 0.17242372f, 0.15972756f, -0.19455954f, -0.07069722f, -0.13961452f, -0.02376674f, 
    0.09389255f, 0.02411943f, 0.02737207f, -0.05192851f, 0.02961619f, -0.07485419f, 0.05518182f, 0.06269830f, 
    0.27796176f, 0.15904698f, -0.19667582f, 0.17822060f, 0.00794155f, -0.03161037f, -0.07280495f, 0.05666196f, 
    0.03447924f, -0.04070564f, -0.00099011f, -0.03627870f, 0.21372131f, -0.11761238f, -0.05026010f, -0.02819517f, 
    0.02128190f, 0.01240801f, 0.07112586f, 0.03998178f, -0.09416726f, 0.09914710f, -0.02514527f, -0.00144948f, 
    0.32763222f, 0.09865036f, -0.13481750f, -0.10413872f, 0.06285191f, 0.09025677f, -0.14939897f, -0.02082801f, 
    0.02133876f, -0.04121725f, -0.03814405f, -0.09618107f, -0.33579785f, 0.08790076f, -0.02509847f, -0.00756178f, 
    0.03105749f, -0.00129212f, 0.02497459f, -0.03167767f, 0.11728626f, 0.05259543f, 0.15111633f, 0.01996081f, 
    -0.01369308f, 0.00062084f, 0.09079637f, 0.12004246f, 0.05874745f, 0.06117820f, 0.05654556f, 0.05995323f, 
    -0.15615714f, -0.09201139f, 0.06632163f, -0.09695408f, -0.04787696f, -0.18808928f, -0.01943891f, 0.07916626f, 
    -0.09720282f, 0.18786997f, -0.01917542f, -0.00148684f, -0.09860909f, -0.07237235f, -0.00149524f, 0.00717352f, 
    -0.36084524f, 0.05708502f, 0.08144047f, -0.17091055f, 0.01796921f, -0.04000839f, 0.04862477f, -0.03989970f, 
    0.09231587f, 0.03647567f, 0.01740021f, -0.02031300f, 0.24343434f, -0.10078534f, 0.09237242f, -0.04945073f, 
    -0.03416134f, -0.05259277f, 0.10210042f, 0.03365930f, 0.00173107f, -0.03307135f, -0.03299503f, 0.04339854f, 
    0.03464872f, -0.06427221f, -0.00992436f, -0.07737054f, -0.07783072f, 0.05998726f, -0.05406933f, 0.01481350f, 
    0.04580036f, -0.02099569f, 0.02521181f, -0.09626362f, -0.05366356f, -0.00688414f, -0.19373699f, 0.02081638f, 
    0.05082148f, 0.04339482f, 0.07879766f, -0.07756340f, 0.03346077f, 0.03457286f, 0.07408565f, 0.22712003f, 
    -0.05561686f, -0.04174853f, 0.07092980f, -0.15644941f, -0.18510252f, 0.01087053f, 0.05449764f, 0.08704982f, 
    0.08002637f, 0.12797680f, -0.04251807f, 0.02454245f, 0.04810016f, -0.21775359f, -0.00187080f, -0.04514865f, 
    0.16026187f, -0.20120557f, 0.01447129f, 0.04291314f, 0.01629787f, -0.06558788f, 0.05821488f, 0.06375186f, 
    -0.10676581f, -0.05122205f, 0.01847338f, 0.18142480f, -0.01762151f, 0.05226910f, 0.17087111f, 0.00294188f, 
    -0.17436527f, -0.02200959f, -0.08614159f, 0.02970721f, -0.06624746f, -0.06151680f, -0.01150565f, -0.02791735f, 
    -0.12159483f, -0.05211456f, 0.14757124f, 0.04136928f, -0.11027032f, -0.06897140f, 0.07213209f, 0.04591872f, 
    -0.11043337f, -0.06036231f, -0.07614033f, 0.27865574f, -0.10127731f, 0.03261125f, 0.06506399f, -0.01194036f, 
    -0.07297769f, 0.03759665f, -0.02885473f, 0.04710100f, -0.02192532f, 0.22696462f, -0.06127231f, -0.04505304f, 
    0.02879618f, -0.05121825f, -0.05368077f, 0.07189360f, 0.05113684f, 0.05810812f, -0.01219181f, -0.06063348f, 
    0.21867822f, -0.12341166f, -0.04820880f, 0.18690553f, -0.03752069f, 0.07678504f, -0.04483785f, -0.12144285f, 
    0.00557044f, -0.01106738f, 0.01459072f, 0.06015352f, 0.12830594f, 0.32738698f, -0.21273905f, 0.18865326f, 
    0.01535032f, 0.05800255f, -0.08772447f, -0.03763271f, 0.10901088f, 0.02411773f, 0.06923638f, -0.01619937f, 
    -0.31140277f, 0.02754929f, 0.07843298f, -0.02127149f, 0.03782575f, -0.05138290f, -0.04465865f, 0.09950806f, 
    0.08553176f, -0.16466464f, 0.04078617f, 0.00728427f, -0.07522851f, 0.20600016f, -0.00789443f, 0.05311118f, 
    0.11966432f, -0.03749785f, 0.03696937f, -0.04664158f, -0.05164425f, 0.03595314f, -0.06966351f, -0.02798370f, 
    -0.05648022f, -0.05092261f, -0.00775980f, -0.11396490f, 0.09462349f, -0.04560991f, 0.04985362f, 0.00936739f, 
    0.09012575f, 0.07226960f, -0.06900552f, 0.11566563f, 0.23251075f, -0.23171107f, 0.10287136f, 0.20902438f, 
    -0.01645824f, 0.02026899f, -0.02198465f, 0.03177025f, -0.03763192f, -0.05815612f, 0.09535843f, -0.09636314f, 
    0.19332528f, 0.01807403f, -0.16730808f, 0.34740287f, 0.04002995f, -0.01893388f, 0.01034807f, 0.06943522f, 
    0.13492030f, 0.00528257f, -0.01549735f, 0.01705547f, -0.02478417f, 0.06109456f, -0.06028793f, 0.09185463f, 
    0.06180740f, 0.09331813f, 0.04242402f, 0.03250553f, -0.01275630f, -0.10698016f, 0.03646958f, 0.09587472f, 
    -0.10228857f, 0.20472629f, -0.02559891f, 0.14749017f, 0.08215187f, -0.00706471f, -0.03813984f, -0.04707931f, 
    0.03974560f, 0.14701095f, 0.00522219f, 0.06962110f, 0.42236489f, 0.22791737f, 0.02753820f, 0.04329998f, 
    -0.06846164f, -0.01020512f, -0.03163896f, 0.11206526f, 0.08871438f, 0.14941821f, 0.06382085f, -0.07965535f, 
    0.11559261f, 0.04743506f, -0.13096759f, -0.07168692f, 0.15806779f, -0.09914756f, -0.09762619f, -0.00013737f, 
    -0.01090155f, 0.12022884f, 0.03536588f, 0.09132521f, 0.04972244f, 0.12692171f, -0.12415977f, -0.20068759f, 
    -0.08427932f, 0.02628680f, -0.06458098f, -0.04027665f, -0.00723612f, -0.02746360f, 0.09771326f, 0.02432581f, 
    0.49645048f, 0.26213181f, 0.00034113f, 0.02677272f, 0.01589445f, -0.00988253f, 0.04440200f, -0.08433098f, 
    0.12202092f, 0.13092567f, -0.04417352f, 0.01640174f, -0.08906988f, -0.05927485f, 0.03436350f, -0.00459730f, 
    -0.01050284f, -0.03369593f, -0.02590598f, -0.04526626f, 0.00378743f, 0.01006935f, 0.05534127f, -0.23314869f, 
    -0.40395159f, 0.06171897f, -0.04521197f, -0.08760988f, 0.00124546f, -0.06038998f, 0.01099372f, -0.05937043f, 
    -0.01908903f, 0.07097745f, 0.11425935f, -0.03445996f, -0.20917451f, 0.30563670f, -0.11301012f, -0.09607057f, 
    0.14828229f, -0.07885899f, -0.00301339f, 0.01425153f, 0.09042359f, -0.04980520f, 0.00624666f, -0.11476738f, 
    -0.14754017f, 0.03241241f, 0.05086291f, 0.04141652f, 0.06097478f, 0.00672922f, 0.06761455f, -0.01123345f, 
    -0.03547804f, 0.05026552f, -0.03830343f, -0.05684485f, -0.43263829f, -0.04381314f, 0.09711460f, 0.22043528f, 
    -0.01798267f, 0.04174345f, -0.13384695f, 0.14847037f, -0.06507277f, -0.10504501f, 0.02518667f, 0.01063568f, 
    0.36190397f, -0.04137627f, -0.01432372f, 0.02269372f, -0.06354500f, -0.03402453f, -0.02365371f, -0.05525084f, 
    0.03983298f, 0.07718021f, 0.03227712f, 0.06814069f, 0.08576474f, -0.03087512f, -0.05228503f, 0.09685879f, 
    0.04915923f, 0.05939035f, -0.01297732f, -0.01542104f, 0.18590049f, 0.07667749f, 0.13919750f, 0.11792165f, 
    -0.46218878f, 0.03480455f, 0.00554129f, -0.03784664f, 0.03005183f, 0.12895113f, -0.00017353f, -0.00271354f, 
    0.04623718f, 0.01261076f, 0.18348148f, -0.03730295f, 0.29252541f, -0.06886242f, -0.12031367f, 0.22346571f, 
    -0.15238884f, 0.04555253f, 0.02312044f, -0.06499424f, 0.07524488f, -0.09925947f, -0.00700625f, -0.01385191f, 
    0.17040353f, 0.22140993f, 0.02865184f, 0.17005524f, -0.02839111f, 0.05127800f, 0.04683308f, -0.01064771f, 
    0.06641965f, -0.06740677f, -0.08605634f, 0.05405862f, 0.51637626f, -0.06166130f, -0.20491885f, 0.03299839f, 
    -0.05174199f, -0.01688595f, -0.19903375f, 0.06307673f, 0.05160608f, 0.01586614f, -0.07543597f, -0.00494277f, 
    0.43246511f, 0.14943077f, -0.10051557f, 0.11838862f, 0.07852827f, -0.08521984f, -0.12631288f, -0.00109072f, 
    0.01632553f, 0.07794772f, 0.10248218f, 0.06661616f, -0.25228631f, 0.27651781f, -0.02263110f, 0.09954853f, 
    0.01623549f, 0.02466870f, 0.00945996f, 0.05120055f, -0.04531798f, 0.12912099f, 0.12451869f, 0.05404536f, 
    -0.11379061f, -0.00099184f, 0.09816319f, 0.24816413f, 0.05672323f, 0.02314194f, 0.07180106f, 0.01655987f, 
    0.04553344f, -0.03815430f, -0.09169286f, -0.11422180f, -0.19918135f, -0.03490354f, -0.03952714f, -0.04483950f, 
    -0.09887946f, -0.04414846f, 0.07812796f, 0.01937284f, -0.10575948f, -0.05730871f, 0.06277806f, 0.09248617f, 
    -0.21025589f, -0.17469673f, -0.06096236f, 0.01444787f, 0.09158474f, 0.04697008f, -0.00929546f, 0.17504595f, 
    0.01855761f, -0.02410429f, -0.11761115f, 0.02064617f, -0.20794190f, 0.04721857f, 0.06004731f, 0.32274643f, 
    -0.06760884f, -0.02364359f, -0.01588391f, 0.05942061f, -0.00575282f, 0.11589487f, -0.00498243f, 0.00829054f, 
    0.01859035f, -0.10944092f, 0.14374220f, 0.32179847f, 0.09790881f, 0.03439023f, 0.03272380f, 0.00052319f, 
    -0.11913343f, 0.09915727f, -0.14135215f, 0.12054358f, -0.36823934f, 0.06733558f, -0.02963093f, 0.17463802f, 
    0.04706703f, -0.04478609f, 0.01009466f, -0.00276472f, 0.04218752f, -0.03171566f, -0.08277439f, 0.14276502f, 
    -0.43187124f, 0.29113406f, -0.08483224f, 0.01396426f, 0.01748809f, 0.13874090f, 0.06088941f, 0.07801785f, 
    0.06565124f, 0.04580910f, -0.07728477f, 0.13311638f, -0.00867550f, 0.05632983f, 0.02427261f, -0.12396380f, 
    -0.04762681f, 0.03258541f, 0.12612785f, 0.07509777f, 0.17357922f, -0.07963068f, -0.00087392f, 0.10937562f, 
    0.13870291f, 0.07393289f, 0.11009514f, 0.19095591f, -0.06386190f, 0.04809700f, 0.05439192f, 0.04163343f, 
    0.07128102f, -0.03549520f, -0.07352467f, 0.07502853f, 0.39602035f, -0.02833751f, -0.05531056f, 0.03311376f, 
    -0.01398907f, -0.11770223f, 0.00018664f, -0.12572581f, 0.00078538f, 0.09631328f, 0.03589060f, 0.00752797f, 
    -0.31580389f, 0.26362458f, 0.14419277f, -0.15300162f, 0.13433041f, 0.06155961f, 0.05845155f, 0.08406903f, 
    0.04280856f, 0.11402297f, -0.00400298f, 0.00010908f, -0.03883661f, 0.04802867f, 0.09482960f, 0.17902151f, 
    0.07709543f, 0.03001396f, -0.01902325f, 0.10549601f, -0.03075455f, 0.02541751f, 0.01176612f, -0.11551243f, 
    0.34579137f, -0.06256943f, 0.02765854f, 0.26512694f, -0.01770535f, -0.13977937f, 0.04970604f, 0.02448482f, 
    -0.03213986f, 0.15490030f, -0.17423548f, 0.16107029f, 0.08533379f, 0.01914846f, 0.06492444f, 0.31911275f, 
    -0.03001981f, 0.00825683f, 0.11691383f, -0.03353110f, 0.11784216f, 0.14055493f, 0.02213068f, 0.04955917f, 
    0.16686147f, -0.08164684f, 0.14547576f, 0.37307969f, -0.14172587f, 0.11592479f, 0.04306610f, 0.03774651f, 
    0.00896284f, 0.02758896f, -0.03067642f, 0.09173605f, -0.10545211f, -0.24358051f, -0.04476565f, -0.11683881f, 
    -0.06744730f, 0.01806989f, 0.00576360f, 0.04220575f, 0.11160660f, -0.02890548f, -0.04841835f, 0.02994156f, 
    0.06990622f, -0.14018601f, 0.14636707f, 0.17113011f, -0.08327248f, -0.03039201f, 0.03414200f, 0.06943718f, 
    0.03136402f, -0.04498949f, -0.14950785f, -0.05167335f, 0.10010547f, -0.03480348f, 0.16749129f, -0.05443222f, 
    0.09668935f, 0.05040664f, -0.18669492f, -0.07655382f, -0.02630392f, 0.21060489f, -0.07232818f, -0.14449377f, 
    -0.14651908f, -0.12468136f, 0.36621198f, 0.22618705f, 0.00695249f, -0.03044688f, 0.07388445f, -0.01676481f, 
    -0.14984202f, 0.01998515f, 0.16797623f, 0.09239974f, -0.07847826f, -0.11172076f, 0.13792606f, 0.11575658f, 
    -0.02161549f, 0.03852679f, 0.08811707f, -0.08552475f, 0.08407831f, 0.00387290f, 0.16498886f, 0.13041076f, 
    0.05189541f, 0.06228821f, -0.12326157f, -0.16364411f, 0.00050752f, -0.05588313f, 0.07111057f, 0.00971130f, 
    -0.04726419f, -0.06586681f, -0.01758690f, -0.10505737f, 0.09051566f, -0.13447367f, 0.09460635f, -0.04543439f, 
    0.01105070f, 0.08123965f, -0.17754708f, -0.15000288f, -0.10232107f, 0.09784590f, 0.05657316f, -0.07863437f, 
    0.41116869f, -0.17050642f, 0.08358394f, -0.05164352f, -0.05134071f, 0.08136588f, 0.00894709f, 0.06779071f, 
    0.06341821f, -0.03713280f, -0.03462968f, -0.08012243f, -0.02102069f, -0.07934295f, 0.08477678f, 0.03280338f, 
    -0.03844073f, -0.06111056f, 0.14956154f, -0.06996572f, -0.09661070f, -0.09034078f, -0.09187695f, 0.06682137f, 
    0.13099751f, -0.04356992f, 0.02734105f, 0.17857900f, -0.03140421f, -0.06675791f, 0.02912958f, 0.11115960f, 
    0.11172815f, -0.14438996f, -0.02920004f, -0.06093742f, -0.03485344f, -0.16346592f, 0.03122270f, -0.03120251f, 
    0.00034660f, -0.02866475f, 0.05817001f, 0.02766710f, -0.12550281f, 0.08936291f, 0.06319322f, 0.17250203f, 
    -0.20712432f, 0.24920002f, 0.06290106f, 0.04441867f, -0.02838359f, -0.14884777f, -0.05748054f, 0.03239335f, 
    0.18685544f, 0.07736484f, 0.03029895f, 0.06820899f, -0.48732388f, -0.02277444f, -0.17153642f, -0.30165428f, 
    -0.01119577f, -0.12691942f, 0.00751220f, -0.02220573f, 0.05476049f, 0.05448199f, -0.04539761f, 0.01028438f, 
    -0.23461959f, -0.00906026f, -0.00876024f, -0.00130025f, 0.03036801f, -0.04765919f, -0.03277510f, -0.01630690f, 
    -0.05478585f, 0.14823741f, 0.07521562f, 0.12841755f, 0.07620183f, -0.00731993f, 0.12521730f, 0.35696071f, 
    -0.06938433f, 0.07217133f, -0.02895308f, -0.03721777f, 0.05592265f, 0.11782346f, 0.11170804f, -0.08403838f, 
    -0.07374876f, 0.09835958f, 0.03723561f, -0.10500629f, 0.01100165f, -0.06203770f, 0.00679968f, 0.16573907f, 
    -0.05856625f, 0.09535398f, 0.03256570f, -0.01156516f, 0.15200381f, 0.06030635f, -0.10040722f, 0.00408950f, 
    -0.05406982f, 0.14557303f, 0.00422495f, 0.10094646f, 0.10939571f, -0.07924275f, 0.02796822f, -0.04796377f, 
    -0.19288477f, 0.24988075f, -0.03485606f, 0.05551491f, 0.04388087f, 0.04337526f, -0.08165596f, 0.20027997f, 
    0.16470009f, -0.00967870f, 0.07860936f, 0.04928056f, -0.29516891f, -0.10700933f, 0.24076331f, 0.21117198f, 
    -0.05334862f, 0.10700569f, 0.00703026f, 0.07883894f, 0.01829729f, -0.02551599f, 0.12951143f, -0.09466822f, 
    -0.52727735f, 0.05534920f, -0.09381720f, -0.16374640f, -0.03212055f, 0.02252076f, 0.02249520f, -0.03176739f, 
    0.08756225f, -0.04995815f, 0.00926944f, -0.02215143f, 0.17963299f, -0.04322397f, 0.03082509f, -0.08095376f, 
    0.09295796f, 0.05632189f, 0.08988747f, 0.01562673f, 0.15165971f, 0.05335552f, 0.00456151f, -0.18005821f, 
    -0.24287763f, 0.08612019f, 0.02057806f, -0.06940377f, 0.04484142f, -0.02985555f, -0.06658722f, 0.05042069f, 
    -0.07175346f, 0.09614457f, -0.02360139f, 0.06634150f, 0.12446192f, -0.10421179f, 0.01336924f, -0.14248440f, 
    -0.09737077f, -0.00767370f, 0.08025713f, -0.14735396f, 0.01892218f, 0.04179092f, -0.06750680f, 0.11555286f, 
    -0.22764838f, 0.07803560f, 0.08067134f, -0.13228817f, -0.04334644f, -0.06352032f, 0.06856550f, 0.05269276f, 
    0.00942572f, 0.04032540f, -0.02366755f, 0.02662810f, 0.34923509f, -0.23706929f, 0.01959381f, -0.19012731f, 
    0.06086305f, 0.02013917f, -0.05203844f, 0.20774938f, -0.10516236f, 0.12296479f, -0.00891991f, -0.02206841f, 
    -0.02130073f, -0.03101576f, 0.09128403f, 0.00274815f, 0.01459194f, 0.00616991f, 0.05189529f, 0.08091126f, 
    0.00078720f, -0.00425760f, 0.07383502f, -0.08236186f, 0.14865021f, -0.15136853f, -0.16975325f, -0.20889477f, 
    -0.07003991f, 0.11166986f, -0.04889683f, 0.02014858f, 0.10069533f, -0.06176839f, 0.02997634f, 0.08100847f, 
    -0.48937109f, -0.01825225f, 0.00509118f, 0.19021411f, -0.01392010f, 0.01484256f, 0.10080577f, -0.01629482f, 
    0.11004869f, 0.04978686f, -0.00487260f, 0.06743442f, -0.02214293f, -0.05053478f, 0.20010380f, 0.15543507f, 
    0.08335163f, 0.03187047f, 0.09942104f, 0.01526340f, 0.02264191f, 0.08401179f, 0.07095750f, -0.01943197f, 
    0.19395541f, 0.02251349f, 0.13303967f, 0.02157380f, -0.04337060f, 0.02938357f, -0.01015078f, 0.07235608f, 
    0.05075429f, 0.07368422f, 0.13551933f, 0.04559218f, 0.07951795f, -0.03936303f, 0.05200458f, -0.02011302f, 
    -0.05542725f, -0.10326929f, 0.07530300f, 0.11287395f, 0.02870783f, 0.13361578f, -0.01460976f, 0.03756639f, 
    0.27405101f, -0.17121251f, -0.08390115f, -0.07724240f, -0.03065443f, 0.05155653f, -0.13510859f, -0.01475748f, 
    -0.01665457f, 0.01079370f, -0.00804660f, 0.13548815f, 0.14398320f, -0.26525590f, -0.05704976f, 0.24197143f, 
    -0.12583390f, -0.09611969f, 0.00249881f, 0.01349229f, 0.08938462f, -0.12999970f, -0.07418761f, 0.04024407f, 
    -0.12706122f, -0.20844452f, 0.13638826f, -0.15480234f, 0.00154405f, -0.06129489f, -0.01068475f, -0.04643434f, 
    -0.02625716f, -0.03027570f, 0.07911393f, 0.13802938f, 0.09112411f, 0.00717509f, 0.01693088f, -0.00182412f, 
    -0.02774983f, 0.13471656f, 0.05386222f, 0.02459549f, 0.05588866f, 0.04335841f, -0.14657509f, 0.11140395f, 
    0.03727379f, -0.08609962f, -0.35520303f, -0.02295000f, -0.06154101f, -0.01284862f, 0.03668762f, -0.01289551f, 
    -0.10704453f, -0.16668268f, 0.18280454f, 0.07045542f, 0.46102479f, 0.08107498f, -0.09291259f, 0.07860685f, 
    0.02538619f, -0.00436447f, 0.07513922f, -0.04770990f, 0.02588615f, 0.11543100f, -0.05255565f, 0.04910910f, 
    -0.03729177f, -0.05387620f, -0.15406522f, -0.12021001f, 0.06027874f, 0.00698359f, -0.15458064f, -0.05518282f, 
    0.04648526f, -0.03255891f, -0.01830769f, -0.06763894f, 0.19159614f, -0.25500157f, -0.05674160f, -0.01058397f, 
    -0.03920704f, -0.00078207f, -0.06553461f, 0.01557477f, -0.06639379f, 0.08361354f, -0.08084367f, 0.06958183f, 
    0.22917520f, 0.07826294f, 0.05704679f, 0.08649466f, -0.09487425f, 0.04198224f, -0.10427796f, -0.01979348f, 
    -0.04026445f, -0.04497850f, 0.11073475f, -0.03036538f, 0.06671762f, -0.02786618f, 0.14219688f, -0.00739269f, 
    -0.01200789f, 0.07114273f, -0.04602942f, -0.03712754f, 0.03998177f, 0.14498816f, -0.03196375f, 0.07077994f, 
    0.00321588f, 0.04451276f, 0.34264055f, 0.32153207f, -0.05925099f, 0.14227940f, 0.04323702f, 0.03849401f, 
    0.06611793f, -0.13282947f, 0.17329817f, 0.07287680f, -0.01142198f, 0.23834169f, 0.02966099f, 0.06189067f, 
    -0.04390773f, 0.01069842f, -0.04956555f, 0.00124684f, -0.12637301f, -0.03197637f, 0.06825484f, -0.01782078f, 
    0.05592703f, -0.12145100f, -0.06816730f, -0.13405947f, 0.08497144f, 0.03094876f, -0.02315647f, 0.01545956f, 
    0.10071348f, -0.04195866f, -0.09605601f, 0.04581000f, 0.26748765f, 0.01386217f, 0.22709036f, -0.12226245f, 
    0.08462686f, -0.02162709f, 0.02715034f, 0.06113923f, -0.01180459f, 0.08871478f, 0.02884500f, 0.07465165f, 
    0.22546503f, -0.29393515f, 0.11568423f, 0.26534674f, -0.08410357f, 0.03327204f, -0.05121640f, 0.02283410f, 
    0.02481164f, -0.03288996f, 0.07467452f, 0.10524268f, 0.11967547f, -0.05810501f, -0.08343699f, 0.10749439f, 
    0.00745689f, -0.09500805f, 0.08311919f, 0.07254615f, 0.05715602f, -0.00590167f, 0.04964623f, 0.05142942f, 
    0.31550619f, -0.14577807f, -0.27799535f, -0.03499491f, -0.08632875f, -0.15180399f, 0.03693006f, 0.01336776f, 
    -0.12492564f, -0.05781972f, -0.09595380f, 0.00640229f, 0.10218198f, 0.04047961f, 0.04259935f, -0.01868070f, 
    -0.03656599f, 0.00745557f, 0.01730506f, 0.01959486f, 0.02225952f, -0.06770314f, -0.22120295f, -0.01626710f, 
    -0.00450405f, 0.00918252f, -0.02331170f, 0.03646814f, -0.00188071f, -0.02870386f, 0.02294658f, -0.01102848f, 
    0.01029328f, -0.04120453f, -0.00967044f, 0.00529161f, -0.00313746f, 0.02512126f, 0.01766843f, -0.02195653f, 
    -0.00796653f, -0.02671195f, -0.01678053f, -0.03206005f, -0.03243982f, -0.02788831f, -0.00377354f, 0.01397448f, 
    -0.01133289f, -0.03395912f, 0.01637875f, 0.01390805f, -0.00019579f, 0.00779718f, 0.00182611f, 0.02391641f, 
    0.02810849f, -0.00386528f, 0.00693954f, -0.01277173f, -0.03572628f, -0.01306704f, -0.03263329f, -0.01110126f, 
    -0.00904551f, -0.03517942f, 0.01467057f, 0.03064037f, 0.02839933f, 0.00334399f, 0.01460733f, -0.00099485f, 
    -0.02950513f, -0.02532956f, 0.02830658f, 0.02063010f, -0.01180896f, 0.01410098f, -0.00549462f, 0.03154990f, 
    0.02713321f, -0.03697576f, -0.01475183f, 0.01473683f, -0.04213898f, 0.03221161f, 0.02008210f, 0.01226016f, 
    -0.04090692f, 0.01835857f, -0.00883416f, -0.00719532f, 0.02325920f, 0.02472408f, 0.02541858f, 0.01603203f, 
    0.01627421f, -0.02828988f, 0.02885078f, -0.01606539f, 0.01970715f, 0.02332371f, -0.03230581f, 0.01122751f, 
    -0.02466723f, 0.02295086f, 0.00237085f, 0.02247497f, 0.00044293f, -0.01266011f, -0.03596263f, 0.01282570f, 
    0.01223968f, 0.00052622f, -0.03913626f, 0.02823827f, -0.00990733f, -0.02451959f, 0.02122036f, -0.03685739f, 
    0.02084931f, -0.02390885f, 0.02390972f, -0.00343877f, 0.02511245f, 0.00366531f, -0.00175209f, 0.02985871f, 
    -0.00574435f, 0.01096443f, -0.04399450f, 0.00374184f, 0.01266725f, -0.02356533f, -0.01661080f, -0.01193883f, 
    -0.01012059f, -0.01253846f, -0.01343608f, -0.00195111f, 0.01148057f, -0.03182289f, 0.00585917f, -0.01051357f, 
    -0.00869626f, -0.01081688f, -0.01656586f, -0.02495357f, -0.02929414f, 0.02179146f, -0.02345779f, 0.02258831f, 
    -0.02672372f, -0.01058818f, 0.02314203f, -0.03281805f, -0.02746983f, -0.03413831f, 0.01861154f, -0.03232227f, 
    0.01249864f, 0.02819317f, -0.02213246f, -0.00313242f, 0.02523927f, -0.03938253f, -0.04147178f, 0.02121867f, 
    0.01051285f, 0.01206530f, -0.00572343f, -0.02458542f, -0.01397046f, -0.00151988f, 0.00902382f, 0.02357963f, 
    -0.03965842f, -0.03693766f, -0.01338487f, 0.02498817f, -0.00613849f, 0.02447665f, -0.02152231f, -0.00643359f, 
    0.00808771f, -0.02593757f, 0.01793574f, 0.01925426f, -0.01358315f, -0.02551525f, 0.01280533f, -0.01685916f, 
    -0.00450899f, 0.00886245f, 0.03048248f, 0.00187513f, 0.00903553f, 0.01136444f, 0.02344061f, 0.00733944f, 
    0.01794795f, -0.03821928f, -0.01927782f, -0.01671631f, 0.00482901f, 0.02857659f, -0.02801597f, -0.03156132f, 
    -0.01266987f, -0.01105505f, -0.01867844f, 0.01604599f, -0.02772146f, 0.01706962f, 0.00972491f, 0.02069679f, 
    -0.00309512f, 0.01313939f, -0.02300115f, -0.00888287f, -0.01451221f, 0.00187205f, 0.01463163f, 0.02606301f, 
    0.00565425f, -0.01879768f, -0.03608787f, 0.01063250f, -0.00114603f, 0.00285723f, 0.02606541f, 0.01745666f, 
    -0.02422633f, -0.04476376f, 0.00153118f, 0.02993986f, -0.01579760f, -0.02193463f, -0.00580200f, -0.03766067f, 
    0.02454958f, 0.02366545f, -0.02475301f, 0.00931425f, -0.03245835f, 0.03185379f, 0.01193007f, -0.04328142f, 
    0.02453785f, -0.00064760f, -0.00042206f, -0.01122046f, -0.03591649f, 0.01521328f, -0.01938462f, -0.01770134f, 
    0.01454180f, -0.02695896f, -0.02053208f, -0.01635864f, -0.00072586f, -0.04095658f, -0.02708207f, 0.00326527f, 
    -0.01767827f, -0.00701055f, -0.03417646f, -0.03030821f, -0.02838891f, -0.00461688f, -0.02512275f, -0.03216763f, 
    -0.02935752f, -0.03394546f, 0.02205116f, -0.03228995f, -0.00164196f, -0.00230966f, -0.03915501f, 0.02457190f, 
    0.01670496f, -0.01918857f, -0.03484949f, 0.01012871f, -0.02716103f, 0.01243854f, 0.00016399f, -0.03627259f, 
    -0.01030697f, -0.02090622f, 0.02118256f, -0.00238086f, -0.00373197f, 0.02016417f, -0.01130779f, 0.00850300f, 
    -0.00764602f, -0.02211590f, -0.03194523f, 0.00556173f, -0.01293954f, 0.02000089f, -0.00659290f, -0.00962628f, 
    -0.02868174f, 0.00668344f, -0.02491165f, 0.01302831f, -0.03103452f, -0.01118929f, -0.00447010f, 0.01739865f, 
    -0.00739888f, 0.00680564f, 0.01560061f, 0.00736430f, 0.02631193f, -0.02444883f, 0.02134993f, 0.03990387f, 
    0.02803314f, 0.00500559f, 0.01880315f, -0.00114738f, -0.01971194f, -0.02335548f, 0.01136330f, 0.00188013f, 
    -0.01250400f, -0.03204855f, -0.00391749f, -0.01896429f, -0.01416462f, -0.01823326f, 0.01469157f, -0.01871025f, 
    0.01004863f, -0.03112952f, -0.02197115f, -0.02548917f, 0.00226268f, 0.00304556f, 0.00298172f, -0.03117635f, 
    -0.01400049f, -0.01594636f, -0.04129548f, 0.00578258f, 0.00899615f, -0.01083477f, -0.01605627f, 0.01832833f, 
    0.02739542f, -0.02492704f, -0.00945963f, 0.01431850f, -0.03196251f, -0.01031017f, 0.00679323f, 0.02770598f, 
    -0.01426348f, -0.02245690f, -0.02227554f, 0.02574996f, 0.00640522f, -0.03141657f, 0.00682728f, 0.02670074f, 
    -0.02588614f, 0.01881628f, 0.01403892f, -0.01306332f, 0.01281077f, -0.01092678f, 0.01613164f, -0.00668086f, 
    0.01499615f, -0.03983608f, -0.02375805f, 0.01032832f, 0.00879968f, -0.03765693f, 0.00458940f, -0.02629032f, 
    0.00332927f, -0.00777403f, -0.03542366f, -0.01028103f, -0.00788153f, 0.01817394f, -0.01296186f, 0.00678749f, 
    -0.00316221f, -0.00494441f, 0.02028921f, 0.00848300f, -0.02338143f, -0.00537884f, -0.02584997f, -0.00151200f, 
    -0.01209268f, -0.00439040f, -0.02522675f, 0.01598731f, -0.04273304f, -0.01384112f, 0.02004417f, -0.01413960f, 
    0.02413254f, 0.03941677f, -0.01303046f, -0.02986381f, -0.00389849f, 0.01397442f, -0.01121778f, -0.03578219f, 
    0.01675022f, -0.03787216f, 0.02340749f, -0.03117237f, 0.00598057f, -0.03605567f, 0.02302171f, 0.00698250f, 
    0.02612793f, -0.03039998f, 0.02458423f, 0.01167967f, -0.02941980f, 0.01290244f, -0.00301542f, 0.01114277f, 
    0.02084728f, -0.00545928f, -0.03641411f, 0.00264566f, -0.02205974f, -0.00365500f, 0.01972277f, 0.02420851f, 
    -0.03772810f, 0.01099759f, -0.01536160f, -0.02859278f, 0.00959906f, 0.01570385f, 0.01122719f, 0.01141445f, 
    -0.02765123f, -0.00958093f, -0.03374481f, 0.01915176f, 0.02538298f, -0.01697349f, -0.04222455f, -0.02656716f, 
    -0.00257036f, 0.01902125f, -0.02199213f, -0.03330578f, -0.03314270f, 0.01088672f, -0.03037527f, -0.04300247f, 
    -0.00698379f, -0.03567366f, -0.01059346f, -0.00680614f, 0.00495640f, 0.02337366f, 0.02591494f, 0.01478007f, 
    0.03018197f, -0.03729055f, 0.01388035f, 0.02504100f, 0.00449146f, -0.02842513f, 0.02635106f, -0.03330238f, 
    -0.03895307f, 0.01804790f, 0.01010177f, -0.00214672f, 0.00405236f, 0.01698242f, 0.01039255f, -0.02841782f, 
    -0.00949137f, 0.02078742f, -0.01409632f, -0.01870863f, -0.00650754f, -0.03903329f, -0.03498549f, 0.02608931f, 
    -0.02073555f, -0.03489047f, -0.01999107f, -0.03573914f, 0.00816681f, 0.00489007f, -0.00129918f, 0.00044927f, 
    -0.02710306f, -0.01090176f, -0.04043161f, -0.03390025f, -0.00721673f, -0.00518204f, 0.01646035f, -0.01731976f, 
    0.00175429f, -0.01383151f, -0.03471687f, 0.02692351f, -0.01807736f, -0.01916310f, 0.01110588f, 0.02715054f, 
    0.02640669f, -0.01374750f, -0.01713290f, 0.00018406f, 0.02842379f, 0.00496118f, -0.01045025f, -0.01506687f, 
    0.01750056f, -0.02115414f, -0.02083652f, -0.02155843f, -0.02961038f, 0.00076404f, -0.03711445f, -0.01754123f, 
    0.01264118f, 0.01248040f, 0.01019737f, 0.01761050f, -0.02320132f, -0.03750374f, 0.00229869f, 0.00007866f, 
    0.02573265f, 0.01444397f, -0.00403254f, -0.02395180f, -0.03239721f, -0.02240741f, -0.01688189f, 0.02648355f, 
    0.02319229f, 0.02612202f, 0.02433302f, -0.01644277f, -0.03600564f, 0.01244211f, -0.02236917f, 0.01727274f, 
    -0.03239680f, -0.02965081f, 0.02270430f, -0.00758819f, -0.03058853f, -0.01012918f, 0.03180368f, 0.02887113f, 
    0.01200856f, -0.03153310f, 0.01035509f, 0.02096259f, -0.02558782f, -0.00497736f, 0.02935565f, 0.01882491f, 
    -0.03828121f, 0.00681123f, 0.02258487f, -0.03015782f, 0.02911103f, -0.01974315f, -0.03074964f, -0.01893403f, 
    -0.00129783f, 0.02055958f, -0.01766326f, -0.01557286f, 0.01645492f, -0.04055058f, 0.02535467f, 0.01534891f, 
    0.03204546f, 0.01323932f, 0.01579235f, 0.02707615f, 0.02642007f, 0.02937097f, -0.00315728f, 0.01640302f, 
    -0.03353900f, 0.01528550f, 0.01909227f, 0.00385826f, -0.00928320f, -0.02009645f, -0.02576964f, 0.01372919f, 
    0.01031444f, -0.03989916f, 0.02381791f, 0.00958007f, -0.03504274f, -0.03617071f, -0.00786094f, -0.00283206f, 
    0.01454755f, -0.00407400f, 0.00082295f, 0.02446332f, -0.01818011f, -0.01001408f, -0.01117993f, -0.03580371f, 
    -0.03626462f, -0.00479862f, -0.04275148f, 0.01351602f, 0.02637479f, -0.03436616f, -0.00291820f, -0.02538712f, 
    -0.02186840f, -0.03756906f, -0.00075296f, -0.03764162f, 0.01941783f, -0.01629481f, -0.03237853f, 0.01420598f, 
    0.03007507f, -0.02083357f, -0.00829600f, -0.00021319f, 0.00125057f, 0.00702472f, 0.02652930f, -0.04060119f, 
    0.02193984f, 0.02567237f, 0.01249165f, 0.00105931f, 0.01688125f, 0.01437204f, -0.02319670f, 0.03301925f, 
    0.03203591f, 0.00270717f, 0.01993163f, 0.00376309f, 0.00199347f, -0.00740141f, 0.01225511f, 0.02641925f, 
    0.00578428f, -0.03797596f, -0.02100306f, -0.01106448f, 0.01759635f, 0.00290007f, -0.03140528f, 0.02829522f, 
    -0.01401773f, -0.02449898f, -0.02499256f, 0.03000406f, 0.02042002f, -0.03466146f, -0.03655225f, 0.00782640f, 
    0.02377958f, -0.03378666f, 0.02076362f, -0.00201016f, -0.02554257f, -0.02158512f, -0.00680790f, 0.00224327f, 
    -0.00544780f, -0.03584581f, 0.02389465f, 0.02579132f, -0.00223242f, -0.02878431f, -0.03052750f, -0.00064558f, 
    0.00040879f, 0.02172126f, -0.01426694f, -0.01846233f, 0.00578810f, 0.02867036f, 0.01973951f, -0.00649925f, 
    -0.00357879f, 0.00917686f, 0.00772889f, 0.01277586f, 0.00189705f, -0.03547364f, 0.01724331f, 0.01869651f, 
    -0.00041665f, 0.01048206f, 0.01597681f, -0.00986848f, 0.00614661f, -0.01771150f, 0.03019831f, -0.02104244f, 
    0.01997427f, 0.00587107f, 0.02303443f, -0.00892754f, -0.04003133f, 0.02633904f, -0.00352736f, -0.00116108f, 
    -0.00196927f, 0.01499510f, -0.00822128f, -0.01024791f, -0.00025064f, -0.02295789f, -0.01434301f, 0.02273961f, 
    0.01663767f, -0.01787142f, 0.00273276f, 0.00209144f, -0.00719114f, 0.02958667f, -0.00303480f, -0.02506343f, 
    0.02050764f, -0.00000607f, -0.02410263f, 0.00152648f, 0.02757512f, 0.00460872f, -0.00187380f, -0.00614183f, 
    0.01168335f, -0.02403767f, -0.02585110f, -0.03419914f, -0.04074332f, -0.03637905f, -0.04127779f, 0.03501926f, 
    -0.01785223f, -0.03455240f, 0.00534951f, -0.02566538f, 0.00322256f, -0.03302912f, -0.02796068f, -0.01355275f, 
    -0.01891869f, 0.03201830f, 0.02526006f, -0.00203424f, 0.00964633f, 0.00198494f, 0.00615716f, 0.02583349f, 
    0.02430572f, 0.01981218f, -0.01175057f, -0.02559511f, 0.02890824f, 0.01044596f, 0.01818800f, -0.02833817f, 
    -0.03429754f, 0.01824569f, -0.01887804f, 0.01358663f, -0.03371776f, -0.02825618f, -0.03582428f, 0.02905042f, 
    0.00258899f, -0.03907777f, 0.00420270f, -0.02324840f, -0.00031380f, 0.01066183f, -0.02438062f, 0.01401800f, 
    0.02203904f, 0.03003472f, 0.02802103f, 0.01720882f, -0.00873010f, -0.00877334f, -0.02861395f, 0.02544163f, 
    -0.00974751f, -0.03991499f, -0.01878685f, -0.02593088f, -0.00491101f, -0.02776116f, -0.01965890f, -0.03757774f, 
    -0.00866969f, -0.02914033f, -0.00283669f, 0.02213826f, -0.02413948f, 0.01864705f, 0.01493665f, 0.02479397f, 
    -0.01171445f, 0.02909899f, 0.01634849f, 0.00908402f, 0.02898701f, -0.01602734f, -0.02307393f, -0.03205277f, 
    -0.01471287f, 0.02475944f, 0.02817692f, -0.03139358f, -0.03436473f, 0.02927853f, 0.01812300f, -0.00349394f, 
    -0.03484654f, -0.02477549f, 0.02497498f, 0.00547066f, 0.02367538f, 0.02844349f, 0.00160436f, 0.01289181f, 
    0.03081650f, -0.00364065f, 0.00978979f, -0.02380674f, 0.02438438f, 0.00003251f, -0.03454235f, -0.03434912f, 
    0.00317813f, -0.03485617f, -0.02581559f, -0.00620676f, -0.02310298f, -0.02268606f, -0.01580765f, 0.02829920f, 
    0.01471142f, -0.03726387f, -0.00652270f, -0.03891936f, 0.00825819f, 0.00271867f, 0.01772955f, -0.03845474f, 
    -0.00903744f, 0.01147158f, -0.02858888f, -0.02753018f, 0.02899646f, -0.00965562f, -0.00917193f, 0.01080552f, 
    0.02244871f, -0.02455732f, 0.00566528f, -0.00390872f, -0.03152941f, 0.01223837f, 0.02935005f, 0.01544274f, 
    0.01676073f, 0.01583879f, -0.02942028f, -0.02506297f, -0.00307941f, -0.03134854f, -0.03192954f, 0.01159338f, 
    -0.00934935f, -0.04207845f, -0.00060955f, 0.01216053f, -0.02307911f, 0.00634480f, 0.00288969f, 0.01685414f, 
    -0.01169694f, 0.01751318f, 0.01485324f, 0.02130866f, 0.02619588f, -0.01465923f, 0.01118531f, 0.00732336f, 
    -0.02571675f, 0.01711035f, -0.03767209f, -0.03223942f, 0.02554736f, -0.03884062f, 0.00461443f, -0.02181373f, 
    -0.00121219f, -0.01619882f, -0.03715311f, -0.03029408f, 0.00496101f, 0.02709516f, -0.01702888f, 0.00020165f, 
    -0.02267649f, 0.03225675f, 0.00918214f, -0.04017908f, -0.02357644f, -0.01429748f, -0.00721995f, -0.03789295f, 
    -0.02350578f, 0.02752182f, -0.04020679f, 0.00310828f, -0.02659327f, -0.01128693f, -0.02199599f, 0.02831996f, 
    -0.01308519f, -0.04085190f, -0.03658337f, 0.02114978f, 0.02398673f, -0.02932224f, -0.04162901f, -0.03146164f, 
    -0.03390413f, 0.02682299f, -0.03612440f, -0.03289118f, 0.02288059f, 0.01739047f, -0.02348780f, -0.02025360f, 
    -0.03512587f, 0.00382273f, -0.01891744f, 0.01861180f, 0.01185059f, 0.02417448f, -0.01628793f, -0.00173431f, 
    -0.02536430f, -0.01102002f, 0.00725834f, 0.02062396f, 0.01798033f, -0.01003652f, -0.02976903f, -0.01013663f, 
    -0.02002298f, -0.02975241f, -0.03048559f, -0.03820254f, 0.01170962f, -0.03595392f, -0.00140438f, -0.03919439f, 
    -0.00244899f, -0.02565417f, -0.03537062f, -0.03531646f, 0.01355706f, 0.01298023f, 0.00846598f, 0.00588319f, 
    -0.02307888f, -0.02258380f, -0.03600427f, 0.01431199f, -0.00469245f, 0.00926823f, -0.04116144f, 0.01256944f, 
    -0.03726486f, 0.00293875f, 0.00512024f, 0.01371582f, -0.02211564f, 0.00132255f, 0.01411192f, 0.02065117f, 
    -0.01446624f, -0.04204883f, -0.00807142f, -0.01548230f, -0.03512173f, 0.01997192f, -0.03442650f, -0.03941145f, 
    0.02787014f, 0.03568666f, -0.00455653f, -0.02226305f, -0.02729831f, 0.01279246f, -0.02082877f, -0.02236440f, 
    -0.01409089f, -0.00439068f, 0.00538872f, -0.03136481f, -0.00737334f, 0.02076777f, 0.00748810f, -0.03519716f, 
    0.00949156f, 0.00997157f, -0.00680107f, -0.02421443f, -0.01588902f, -0.01476887f, -0.03692394f, -0.00525346f, 
    0.03090400f, -0.02286041f, -0.01753702f, 0.00979999f, 0.01721956f, 0.02915158f, -0.03366810f, 0.01625826f, 
    -0.01082057f, -0.02921598f, -0.01257899f, -0.04008278f, -0.03379058f, -0.01880365f, -0.02107797f, -0.02136065f, 
    -0.02486265f, 0.02196736f, -0.00845001f, -0.01508939f, 0.00402524f, 0.00393719f, -0.01733064f, -0.02275821f, 
    -0.01989435f, 0.01964084f, -0.03506029f, 0.00985698f, -0.00414128f, -0.01246395f, -0.00049562f, 0.02766584f, 
    -0.02299717f, -0.01629897f, -0.00968441f, 0.00577496f, 0.00491172f, -0.02046061f, -0.01616490f, -0.01903637f, 
    -0.01461382f, -0.04090093f, -0.03172280f, -0.03734905f, -0.01900827f, 0.01755460f, -0.01752717f, 0.02519429f, 
    -0.00152617f, -0.01795303f, 0.01352554f, 0.01140837f, 0.01653332f, -0.01756399f, 0.02865431f, -0.02701429f, 
    -0.00686366f, 0.00105267f, -0.00229556f, 0.02948520f, -0.01594556f, 0.02832679f, -0.00934717f, -0.02187569f, 
    0.02928030f, -0.01964087f, -0.03976194f, -0.03651751f, 0.02261381f, -0.03637089f, -0.00850223f, 0.01395290f, 
    0.02587094f, 0.01394002f, -0.01771808f, -0.01367247f, 0.02545595f, -0.01022619f, -0.04036986f, 0.01415509f, 
    -0.03504648f, 0.00838148f, -0.01805059f, -0.02525005f, -0.02751193f, -0.03977829f, -0.00512959f, -0.01710696f, 
    0.00583027f, -0.01204700f, 0.00390438f, -0.03457158f, -0.00416707f, 0.00933969f, -0.01014264f, -0.01073602f, 
    -0.03020874f, 0.01044666f, -0.03070187f, -0.02655036f, -0.03443692f, -0.02836533f, -0.00363975f, -0.01659008f, 
    -0.02408470f, -0.00784562f, 0.01044655f, -0.03841540f, 0.03471564f, 0.02444672f, -0.03325108f, 0.01484464f, 
    0.02661327f, 0.01579671f, 0.00277703f, -0.03755387f, -0.03688490f, -0.00450956f, -0.00106450f, 0.01697533f, 
    -0.03374645f, 0.00208773f, -0.02347871f, 0.01925741f, -0.00077739f, -0.00208168f, -0.03429366f, 0.01510339f, 
    0.02605029f, -0.02545839f, -0.03271731f, 0.02222573f, -0.02864753f, 0.02786571f, 0.00657639f, -0.01313490f, 
    0.01348264f, -0.02633927f, -0.02645691f, 0.02814357f, 0.00491343f, -0.03420120f, 0.02582304f, 0.01593845f, 
    0.01909958f, -0.01071305f, 0.00863498f, 0.02928849f, 0.00726490f, 0.02453226f, -0.00812200f, -0.00830095f, 
    -0.02426796f, -0.01638830f, 0.02271826f, -0.01838534f, -0.00124628f, -0.00066594f, -0.00766114f, 0.00014657f, 
    0.02200081f, -0.04137367f, 0.02580940f, 0.02936601f, -0.02536157f, 0.00488588f, -0.01238208f, -0.00315572f, 
    -0.01978364f, -0.02608602f, -0.02955735f, 0.02718952f, -0.01445318f, 0.01902588f, -0.00184160f, -0.03707968f, 
    -0.02615279f, -0.04185795f, -0.04140194f, 0.00368619f, -0.02457870f, -0.00508570f, 0.01969609f, -0.01439317f, 
    -0.03654281f, -0.02237682f, 0.01168714f, -0.03668069f, -0.00029654f, 0.00352551f, 0.02204891f, -0.02095968f, 
    -0.01767574f, -0.03862156f, 0.02402923f, 0.00075199f, -0.02530232f, -0.02660456f, 0.00600249f, 0.01603567f, 
    0.00325109f, -0.03502232f, -0.00509492f, 0.02119219f, 0.01364495f, 0.02941356f, 0.00009432f, 0.02833532f, 
    -0.01863167f, -0.03408873f, -0.01877105f, -0.01035891f, 0.02883414f, -0.02768394f, 0.01151725f, -0.01111188f, 
    -0.02158311f, 0.00330905f, 0.00963568f, 0.02731468f, -0.00632951f, -0.02193227f, -0.02957709f, -0.02680716f, 
    -0.03123283f, -0.03631796f, -0.01555043f, 0.01652907f, -0.02459224f, 0.01063279f, -0.03003621f, -0.03002084f, 
    -0.01582042f, 0.01262562f, 0.01276303f, 0.00923323f, -0.04120500f, 0.02750577f, 0.00678793f, -0.02559151f, 
    0.00287949f, -0.01605554f, -0.02252986f, -0.04172466f, 0.02192551f, 0.02829861f, 0.00469046f, -0.03459930f, 
    -0.00569445f, -0.04197006f, 0.02438801f, 0.01527296f, 0.01528091f, -0.02195149f, -0.04010030f, 0.01152795f, 
    -0.01836456f, -0.01325720f, -0.01499972f, -0.01661731f, 0.00818574f, 0.02485130f, -0.00449580f, -0.03909833f, 
    -0.01018365f, 0.00835963f, -0.03672820f, 0.00424238f, -0.02902531f, -0.03716940f, 0.02263568f, -0.04074721f, 
    -0.01078552f, -0.02535409f, 0.00900616f, 0.01645101f, -0.03611541f, -0.03233583f, -0.01191499f, -0.02263883f, 
    -0.01442108f, -0.03309598f, -0.00820785f, -0.00046798f, -0.03947373f, -0.00559674f, 0.02016643f, -0.02983926f, 
    0.02729906f, 0.02758873f, 0.00381353f, -0.03092050f, -0.02925071f, 0.02338015f, -0.01370228f, -0.00535828f, 
    0.01195361f, 0.00993555f, -0.01600188f, -0.03124653f, -0.03421234f, -0.04039939f, -0.01092393f, 0.02060553f, 
    0.01038732f, 0.02606449f, -0.03676876f, -0.00927365f, 0.00510685f, -0.00754311f, 0.00148030f, 0.01213831f, 
    -0.00150255f, 0.00643278f, -0.02576189f, 0.00161530f, -0.01012367f, 0.02869614f, -0.00761136f, 0.00996692f, 
    -0.01281287f, 0.01144412f, -0.02150419f, -0.03439230f, 0.00680074f, -0.02154808f, -0.02314712f, -0.04170869f, 
    -0.03881631f, -0.02908722f, 0.01912623f, -0.03048332f, -0.01060600f, -0.00344539f, -0.01949289f, 0.02589385f, 
    -0.00772723f, -0.01579984f, -0.01438662f, -0.00808861f, -0.00286641f, 0.02908831f, -0.03132081f, 0.02366953f, 
    0.02254106f, -0.02444641f, -0.01657099f, 0.01342700f, -0.02126848f, -0.02641350f, -0.03690064f, 0.02038122f, 
    0.02466031f, 0.01807373f, -0.03514227f, -0.02222497f, -0.03988718f, -0.03543660f, 0.01296623f, -0.03744592f, 
    0.00906170f, 0.02786580f, -0.01809955f, -0.01334497f, -0.04036349f, -0.00672930f, 0.02861370f, -0.02992055f, 
    0.02121793f, 0.00743034f, 0.02965486f, 0.02117444f, -0.00192506f, 0.02607847f, 0.00680492f, 0.02612230f, 
    -0.02182120f, -0.02553238f, -0.01534507f, 0.00188261f, -0.03266779f, -0.02982239f, 0.00670427f, 0.01028786f, 
    0.01713709f, 0.01284157f, 0.02139930f, 0.00733304f, 0.00355118f, -0.02535054f, 0.01772397f, 0.02765049f, 
    -0.01771178f, 0.02025113f, 0.00886763f, -0.01253228f, -0.03513869f, -0.00712059f, -0.00500571f, 0.02919212f, 
    0.01347617f, -0.00601473f, -0.02977058f, -0.01832264f, 0.01485053f, 0.01131458f, -0.04136154f, 0.02427591f, 
    -0.03993678f, -0.02364039f, -0.02956942f, -0.01402258f, -0.02028410f, -0.02677127f, -0.01063999f, 0.01146949f, 
    -0.02254849f, 0.01955352f, 0.00729025f, 0.02900377f, -0.01495743f, 0.01805218f, 0.02760503f, -0.03577748f, 
    -0.00030121f, -0.01113618f, 0.00163502f, 0.01961708f, 0.00194370f, -0.02255170f, 0.01346417f, 0.00419632f, 
    -0.00003148f, 0.02878560f, -0.00447710f, -0.01379807f, -0.02064940f, 0.02981187f, 0.00442610f, -0.03463662f, 
    -0.02624915f, -0.02939994f, -0.00882953f, 0.01151312f, 0.01800950f, -0.01232352f, 0.01629121f, -0.02140803f, 
    -0.01655461f, -0.02202210f, -0.02944836f, -0.03131907f, -0.04145133f, 0.01886737f, -0.00381139f, -0.00882272f, 
    -0.03157320f, 0.01857292f, 0.00522167f, 0.00928087f, 0.02229732f, 0.01133302f, -0.02682325f, 0.01909237f, 
    -0.03263732f, 0.00596703f, -0.03123220f, 0.01195902f, -0.01982818f, -0.01329138f, -0.02792120f, -0.03941103f, 
    -0.02304995f, 0.02809801f, -0.03869393f, -0.03757812f, -0.02802691f, -0.02177715f, -0.01939582f, -0.03322382f, 
    -0.01803020f, -0.02540245f, 0.01817253f, -0.01063095f, 0.00842375f, -0.01001377f, 0.01970707f, 0.01551801f, 
    0.00097620f, -0.01403557f, -0.00832378f, -0.02500295f, -0.03820228f, -0.00120759f, 0.01104122f, -0.00227284f, 
    0.01241264f, 0.00368029f, -0.03809385f, -0.01306662f, -0.01261270f, 0.00502820f, -0.00876786f, -0.03349325f, 
    -0.01971666f, 0.01464224f, -0.00403400f, 0.00416357f, -0.01040278f, -0.01718580f, 0.02871902f, 0.01606827f, 
    -0.01459061f, -0.03597915f, -0.01251209f, -0.02719971f, -0.00387428f, 0.01856110f, -0.02325065f, -0.01936859f, 
    0.03102803f, -0.03496722f, 0.02575077f, 0.02060180f, -0.02467854f, 0.00230616f, 0.02506605f, -0.01545635f, 
    -0.02610064f, -0.00733498f, -0.00237809f, 0.01848498f, -0.02453859f, 0.01483694f, -0.02489853f, -0.01617339f, 
    -0.00730043f, 0.03206864f, -0.00506791f, -0.00423837f, 0.02377417f, -0.01924706f, -0.00802954f, -0.04212950f, 
    0.01390082f, 0.01484653f, 0.01682258f, 0.01081415f, 0.03479147f, -0.03591257f, 0.01268166f, -0.00012785f, 
    -0.02766710f, -0.02737515f, -0.03383101f, 0.01482714f, 0.02741347f, 0.02450521f, -0.01298349f, -0.03143278f, 
    -0.00648651f, -0.00251825f, 0.02036103f, -0.02645236f, 0.01615767f, -0.01129453f, -0.03075476f, -0.01480364f, 
    0.01747450f, -0.00757695f, -0.00829050f, -0.02309173f, 0.00962548f, -0.02366333f, 0.01279213f, -0.01299364f, 
    -0.00913810f, 0.02566901f, 0.00606753f, -0.02503322f, -0.00451825f, -0.00975859f, -0.00256372f, 0.02778609f, 
    -0.02294512f, -0.03776098f, 0.03082636f, 0.02718871f, -0.00095812f, -0.00879282f, -0.03753957f, -0.01605040f, 
    -0.02282367f, 0.00631083f, 0.00070913f, -0.00585260f, -0.00136710f, -0.00609324f, 0.01225868f, -0.02456849f, 
    -0.01539935f, 0.02874240f, 0.02556105f, -0.04289275f, -0.00972485f, 0.02397791f, -0.03589661f, -0.02306596f, 
    -0.03090817f, 0.03263880f, -0.00087295f, -0.02570674f, 0.02555325f, -0.01229712f, 0.02003618f, -0.00409450f, 
    0.02722161f, -0.01973703f, -0.02222110f, -0.01496803f, -0.02122606f, -0.01787019f, 0.00316013f, -0.02723710f, 
    -0.03144416f, 0.00359959f, 0.01614730f, -0.02098278f, -0.03265197f, -0.03092285f, 0.01725273f, 0.00917541f, 
    -0.02771317f, -0.01761313f, 0.00705354f, -0.03272187f, -0.03361700f, 0.02525376f, -0.01401551f, 0.01637157f, 
    -0.00741762f, -0.01501831f, 0.00052035f, -0.00077545f, -0.00119114f, -0.01030072f, -0.04029015f, -0.00850992f, 
    0.00662316f, 0.02875542f, 0.01185676f, -0.00150409f, -0.02547373f, -0.01508719f, -0.03010574f, 0.02155717f, 
    -0.04173667f, -0.00802993f, -0.02594886f, -0.02796568f, 0.01379059f, -0.03761984f, -0.02663754f, 0.00270438f, 
    -0.00648394f, -0.00113944f, 0.03121081f, -0.03062453f, -0.02416876f, -0.00390418f, 0.00994626f, -0.03332921f, 
    -0.00617950f, 0.01703339f, -0.01963520f, 0.00141690f, -0.00230873f, -0.03866617f, -0.02323966f, -0.00531199f, 
    -0.01105442f, -0.01152458f, 0.00637752f, 0.00240013f, -0.01883973f, -0.03391293f, 0.01241922f, 0.03240796f, 
    0.01597317f, 0.01612855f, 0.00866058f, -0.01517440f, 0.01010684f, -0.04217741f, -0.00194145f, -0.03775059f, 
    0.04038783f, -0.04052817f, -0.00664126f, -0.03331790f, 0.00208247f, 0.01086752f, -0.00171625f, -0.00123488f, 
    0.01031475f, 0.01625477f, 0.00843284f, -0.02545236f, 0.02222775f, -0.00836174f, 0.02767283f, 0.00002529f, 
    -0.02349975f, -0.02142609f, -0.01059146f, -0.03956538f, 0.01776730f, -0.00101044f, 0.02471580f, 0.00597402f, 
    0.02753143f, -0.00563380f, 0.03207747f, 0.02613871f, -0.02287793f, -0.01049921f, 0.02475317f, 0.01998590f, 
    0.00089062f, -0.00275152f, 0.00832160f, -0.02503131f, -0.00559261f, 0.03224736f, 0.02704478f, 0.00297469f, 
    0.00291247f, -0.03453240f, -0.00048967f, -0.00857954f, -0.03156352f, -0.02046218f, 0.02243179f, -0.00281964f, 
    -0.01480764f, 0.00754943f, -0.04083715f, -0.00126575f, -0.04028945f, 0.00562754f, 0.02192617f, 0.01127173f, 
    -0.01210105f, -0.02044537f, -0.03154877f, -0.01638420f, -0.04125437f, 0.01752866f, -0.02226284f, 0.02174633f, 
    0.03213495f, 0.00477894f, -0.01689310f, -0.02188531f, 0.02770041f, 0.01117027f, 0.00482540f, 0.00353124f, 
    0.00544455f, -0.00712475f, 0.02725717f, -0.02871588f, -0.01075973f, -0.00781225f, 0.00666029f, -0.01842058f, 
    -0.02162616f, 0.00789344f, 0.02626864f, 0.03436182f, 0.00519704f, -0.02478594f, -0.00015774f, -0.03498702f, 
    -0.01094272f, 0.00730725f, 0.00163659f, 0.02846515f, 0.02022812f, -0.03184812f, -0.00436688f, 0.02206038f, 
    -0.01580265f, -0.01170960f, -0.02421857f, 0.02206741f, 0.03109839f, -0.00064317f, 0.01266800f, -0.00826372f, 
    -0.01842599f, -0.01929679f, -0.00666191f, -0.01034868f, -0.03578580f, 0.01410343f, -0.02578509f, 0.03982223f, 
    0.00009255f, -0.02456773f, 0.01568866f, -0.01815252f, -0.02180994f, 0.01696028f, -0.01954079f, -0.00127223f, 
    0.00875938f, -0.01776815f, 0.02916493f, -0.00026721f, 0.00162785f, -0.00306085f, -0.00383643f, 0.02112684f, 
    0.02672601f, -0.02124790f, 0.00698935f, 0.01138708f, -0.01656798f, -0.02669060f, -0.00961824f, -0.01143222f, 
    -0.04080179f, 0.00998772f, -0.03260440f, 0.00253559f, -0.00069983f, -0.04062724f, -0.00362736f, 0.02357857f, 
    0.01549347f, 0.01666757f, -0.00053454f, -0.00501668f, -0.04387783f, 0.02244925f, -0.02626090f, 0.00164455f, 
    0.00881201f, -0.00524874f, 0.01378889f, 0.02990586f, 0.01749342f, -0.00813538f, -0.01317151f, -0.02957922f, 
    0.01643772f, 0.00030297f, 0.03087969f, 0.00406054f, -0.03157623f, -0.00514894f, -0.02580495f, -0.03393557f, 
    0.01024254f, 0.00916361f, -0.03652304f, 0.01665740f, 0.00019854f, 0.00172428f, -0.02210707f, -0.01544992f, 
    -0.00928352f, -0.01961110f, 0.01413353f, 0.01465041f, 0.00881604f, -0.02603512f, 0.00707754f, 0.00254037f, 
    -0.00192804f, -0.03461217f, 0.03094324f, -0.01781097f, -0.01483006f, 0.02074841f, -0.00056812f, 0.00036922f, 
    0.00555267f, 0.02651389f, 0.02185749f, 0.02583710f, 0.00117361f, 0.01799978f, -0.03165754f, -0.01394560f, 
    0.00444229f, -0.02432476f, -0.02081387f, 0.01136998f, -0.02821113f, -0.02380694f, -0.02159394f, 0.00232120f, 
    0.02729690f, -0.03290401f, -0.00895184f, -0.03745696f, 0.01550166f, 0.01799619f, 0.01108746f, 0.00398347f, 
    0.00187915f, 0.01749630f, 0.00072951f, -0.00069284f, 0.01248688f, -0.00418415f, 0.02180458f, 0.02367847f, 
    -0.00751297f, 0.00297279f, 0.03190732f, -0.03897043f, 0.03213522f, 0.01847973f, -0.02979136f, -0.01538793f, 
    -0.01651332f, 0.00112440f, -0.03530329f, -0.03287957f, -0.03161115f, 0.01262824f, 0.01141917f, 0.00245882f, 
    0.01052603f, -0.03747143f, 0.00859151f, -0.00974804f, 0.02441953f, 0.01566952f, 0.01173895f, 0.00434700f, 
    -0.01039028f, -0.03239309f, -0.02375583f, -0.04353331f, -0.02309115f, 0.00666927f, 0.00416062f, 0.01382053f, 
    -0.04112825f, 0.00500120f, -0.02652416f, -0.00707787f, 0.03366232f, -0.00261832f, -0.03884321f, 0.01723279f, 
    -0.03095336f, 0.00361824f, 0.00999121f, -0.02191730f, 0.01341513f, 0.01931676f, 0.00580177f, 0.01146303f, 
    0.03161000f, 0.02805823f, 0.01442757f, -0.03053584f, -0.03584913f, 0.00507333f, 0.02935125f, 0.01677184f, 
    -0.03261891f, -0.03823398f, -0.02182378f, 0.00503342f, 0.03560433f, -0.03732282f, -0.03163470f, 0.00847157f, 
    -0.03070659f, 0.00555039f, 0.00880424f, 0.01873030f, -0.00972729f, -0.02784085f, 0.02428814f, 0.00425816f, 
    -0.02104593f, -0.03053724f, -0.02284400f, -0.02523326f, 0.01842666f, 0.00382841f, -0.01073896f, 0.02323644f, 
    -0.00283745f, 0.00009636f, -0.00514766f, 0.01161472f, -0.01648009f, -0.00104951f, -0.00718629f, -0.03037071f, 
    0.00157279f, 0.01081452f, 0.01492837f, 0.01761616f, 0.00251671f, -0.01866366f, -0.01612385f, -0.03027505f, 
    -0.02032273f, 0.00600592f, -0.01947665f, -0.02496648f, -0.02333702f, 0.02519747f, 0.02888526f, -0.02302519f, 
    -0.01856258f, -0.01165389f, 0.01072831f, 0.00934108f, -0.02200837f, 0.01023060f, -0.01392976f, 0.01609476f, 
    -0.00913050f, 0.02727256f, 0.00573534f, -0.02309209f, -0.01635269f, -0.03388687f, -0.00739745f, 0.00821749f, 
    0.02770621f, 0.00610327f, -0.03355810f, 0.03088032f, 0.01744538f, -0.03000983f, 0.01431699f, 0.02017941f, 
    0.01826367f, -0.02680715f, 0.02768140f, -0.02826574f, 0.00711120f, 0.01623106f, -0.03116480f, -0.00227167f, 
    -0.01400344f, 0.03054302f, 0.01063215f, -0.03967400f, -0.02463304f, -0.02002209f, -0.01185192f, -0.00032263f, 
    -0.01885241f, -0.03088158f, 0.01868378f, -0.03630556f, 0.00714633f, 0.02184185f, 0.00311387f, 0.00099550f, 
    -0.03599906f, 0.00944363f, 0.01928209f, -0.03700452f, 0.00562541f, -0.03436596f, 0.02272843f, 0.00423983f, 
    -0.03538001f, 0.00875712f, -0.03566961f, 0.00575535f, -0.02196884f, -0.00887308f, 0.01904504f, 0.01439976f, 
    -0.00335455f, -0.00030303f, 0.02125634f, 0.01479441f, 0.01359961f, -0.02672003f, -0.00546537f, 0.01818307f, 
    0.02472638f, 0.02106508f, -0.00719248f, 0.01383106f, 0.02446958f, 0.03099426f, -0.00479777f, 0.03126210f, 
    0.01046537f, -0.02696653f, 0.00535941f, 0.00965971f, -0.02169376f, -0.00334478f, -0.00311422f, -0.03827047f, 
    -0.03486466f, -0.01526218f, 0.02165222f, 0.02115559f, 0.02989077f, -0.01612013f, 0.03115346f, -0.01827166f, 
    -0.01438158f, 0.00932218f, 0.00898897f, -0.01842267f, 0.00169811f, -0.01874334f, 0.01762785f, 0.02748916f, 
    0.03338413f, -0.03427305f, 0.02401417f, -0.02134250f, 0.01610507f, 0.01180616f, -0.01378129f, 0.00582127f, 
    -0.01736643f, 0.01521311f, -0.02430086f, -0.02478369f, -0.01015404f, 0.02394338f, 0.01175451f, 0.02253525f, 
    -0.03871516f, -0.00625696f, 0.00044991f, 0.01966122f, 0.01237851f, 0.02367234f, 0.01174232f, 0.02429726f, 
    -0.03797315f, -0.00467053f, -0.03575209f, 0.02485135f, -0.02021864f, -0.02003412f, -0.01103917f, -0.02282225f, 
    0.03206567f, -0.00086852f, -0.03035441f, -0.01414970f, 0.01680929f, -0.01061164f, -0.00624380f, 0.01785822f, 
    -0.01228665f, -0.02008060f, 0.01035876f, -0.03447867f, -0.03167158f, -0.04338980f, 0.02317947f, 0.02346498f, 
    0.01305136f, -0.01550115f, -0.00639239f, 0.02211344f, -0.00143440f, 0.01163211f, -0.00321182f, -0.01003320f, 
    0.01933817f, 0.00063753f, 0.03167721f, 0.02758978f, -0.02073734f, -0.03450615f, -0.00676285f, 0.01739140f, 
    -0.02016459f, 0.01215629f, -0.02031096f, -0.01999062f, 0.00849816f, -0.00410711f, -0.02285938f, -0.01296147f, 
    0.00357715f, -0.02173958f, -0.01188612f, -0.00775236f, 0.00887305f, -0.02359917f, 0.00219329f, 0.00424378f, 
    0.01127723f, -0.02032928f, -0.03528971f, 0.01072584f, -0.02253719f, 0.02610160f, 0.00449891f, -0.00358222f, 
    -0.00610221f, -0.02861739f, 0.00318536f, -0.03920907f, 0.00540059f, 0.00382655f, -0.02440614f, -0.02144864f, 
    -0.00836810f, 0.00000110f, 0.00915389f, -0.01096971f, 0.01092540f, -0.00082059f, -0.01564997f, -0.02694041f, 
    -0.00038084f, -0.02807794f, -0.02364017f, -0.02166103f, -0.01280745f, -0.00380974f, -0.00311025f, -0.03853473f, 
    -0.02637000f, 0.00688479f, -0.01329273f, -0.01867124f, 0.01086664f, -0.01761119f, 0.02518631f, -0.03598691f, 
    -0.01592434f, 0.00999187f, -0.03911405f, 0.00640592f, -0.02246613f, 0.01441769f, -0.02114200f, -0.02677864f, 
    0.01408039f, -0.00599553f, -0.00241234f, -0.03450472f, -0.02194620f, 0.00910669f, -0.01439610f, -0.02606033f, 
    -0.01981279f, 0.02072481f, -0.01014014f, 0.00501977f, 0.02763202f, -0.02399570f, -0.02530225f, 0.02601665f, 
    -0.02727398f, 0.03409426f, -0.00431212f, -0.04308292f, -0.02449481f, -0.02101376f, -0.01587184f, -0.02831722f, 
    -0.01073955f, -0.00564437f, -0.01205342f, -0.03641209f, -0.02732165f, -0.01417335f, -0.02485135f, -0.00390151f, 
    -0.00389921f, 0.02772394f, 0.02217351f, -0.03141994f, 0.01500499f, 0.01677789f, -0.02879624f, 0.01653297f, 
    -0.01347998f, -0.02510808f, 0.03101517f, 0.00220239f, -0.02643551f, 0.00807479f, -0.00490884f, -0.02465760f, 
    0.00788878f, -0.00286610f, -0.02722363f, -0.01600695f, -0.03396571f, -0.00601480f, -0.03838320f, -0.00787380f, 
    -0.01993414f, 0.00272041f, -0.02151955f, -0.04129574f, -0.00873597f, 0.01738113f, -0.01554414f, -0.00740338f, 
    0.02373612f, -0.02983201f, -0.02473926f, 0.00566541f, -0.00755953f, -0.03352943f, -0.02572956f, 0.02606569f, 
    -0.02665211f, 0.01765712f, 0.00272718f, -0.00810496f, 0.01356658f, 0.02541792f, 0.01597895f, -0.01177697f, 
    -0.03134941f, -0.01491843f, -0.01226671f, -0.02613717f, -0.00696819f, -0.01486313f, -0.01388557f, 0.00869906f, 
    -0.01794373f, 0.01581243f, 0.00108298f, 0.01647954f, 0.02667917f, -0.04453567f, 0.00625122f, -0.03265630f, 
    0.03573590f, 0.02371011f, 0.02759069f, 0.01708126f, 0.01679709f, 0.01185532f, 0.00369490f, 0.00064237f, 
    -0.02847680f, -0.02841229f, -0.01677562f, -0.02185598f, 0.00729893f, 0.02313736f, 0.03529800f, 0.02172373f, 
    0.00345393f, -0.00305019f, 0.00598774f, -0.01435027f, -0.03404870f, -0.01712249f, 0.03492623f, 0.02688614f, 
    -0.02306211f, -0.01400909f, 0.01093922f, 0.00983284f, 0.00098559f, -0.00247837f, -0.03531861f, 0.01600423f, 
    -0.02081882f, -0.03410693f, 0.00354074f, 0.02083752f, -0.01531413f, -0.02114984f, 0.03272359f, 0.00827128f, 
    -0.02872201f, 0.00736109f, 0.01086111f, -0.00598043f, 0.02416438f, -0.00031477f, 0.00067708f, -0.01618617f, 
    -0.00438595f, 0.01878968f, -0.00056842f, 0.01616085f, -0.03481757f, 0.00886013f, 0.00102717f, 0.01496129f, 
    -0.02614251f, 0.00655059f, -0.03518167f, 0.02554304f, -0.01875767f, -0.01630473f, -0.02338158f, -0.02906951f, 
    -0.03450720f, 0.00464780f, -0.00307790f, -0.02878306f, -0.00093012f, 0.03041582f, 0.00753875f, 0.01986298f, 
    0.02591504f, 0.01626105f, -0.02713383f, -0.03849797f, -0.01843086f, -0.00132414f, 0.01217108f, 0.00776838f, 
    -0.00009701f, -0.01462613f, -0.03288013f, 0.02555380f, -0.03258914f, -0.00981316f, -0.02147657f, -0.02410286f, 
    -0.01520352f, -0.03450346f, -0.02551480f, 0.01919681f, 0.00577864f, -0.02444342f, 0.00420047f, 0.03115936f, 
    -0.00663655f, -0.00833479f, -0.03587840f, -0.02453167f, -0.02072234f, -0.00923914f, -0.00190399f, -0.01387647f, 
    -0.03811901f, -0.03256132f, -0.00438715f, -0.01801557f, -0.01309098f, -0.03382308f, -0.00200334f, 0.00601649f, 
    -0.01081427f, -0.00243121f, 0.00627625f, 0.00248602f, -0.01256291f, -0.01806916f, -0.02082008f, -0.00616099f, 
    -0.02953146f, 0.02490116f, 0.00608596f, 0.00528201f, -0.02643090f, -0.03470946f, 0.00573832f, 0.00794268f, 
    -0.01571260f, -0.02220212f, -0.02147851f, 0.01526575f, -0.02689865f, 0.01625508f, -0.03730776f, -0.02549652f, 
    0.03441633f, 0.00283176f, 0.02265062f, 0.02184573f, -0.00107369f, -0.00092649f, 0.00789413f, -0.00661936f, 
    -0.03682496f, 0.02366639f, -0.02246300f, 0.02427510f, 0.01576847f, 0.00451906f, 0.00978941f, -0.00329783f, 
    -0.01298708f, -0.00288576f, -0.01901443f, -0.00857061f, 0.01357564f, 0.01553216f, 0.01813466f, -0.03480967f, 
    -0.00411494f, 0.00293556f, 0.00624654f, -0.02532994f, 0.02159628f, -0.00371717f, 0.00231500f, -0.00647857f, 
    -0.03216775f, -0.04523635f, 0.02331569f, -0.03389633f, 0.02168124f, 0.00135572f, -0.00756102f, 0.02515175f, 
    -0.01983262f, 0.02698405f, 0.00331786f, -0.02820497f, -0.02983776f, -0.01863901f, 0.02214593f, -0.01089252f, 
    0.00545344f, 0.00621126f, 0.00551260f, 0.00982282f, -0.00392037f, -0.03855328f, 0.01012308f, 0.01068808f, 
    -0.01557862f, 0.02642419f, 0.00323836f, -0.02442444f, 0.00659785f, -0.01666440f, 0.01779071f, 0.01626047f, 
    0.03144820f, -0.02647502f, 0.01594769f, 0.02318569f, 0.01395078f, 0.02627414f, 0.00427695f, 0.03301065f, 
    0.01256803f, -0.03563045f, -0.04384496f, 0.00488330f, -0.01894934f, 0.02120418f, 0.00506980f, 0.01207875f, 
    0.01584724f, -0.01729791f, -0.01290392f, 0.01533145f, 0.00100605f, 0.02776688f, -0.03122218f, 0.00805849f, 
    -0.01899200f, -0.00926545f, 0.00953076f, 0.02151662f, 0.02489833f, 0.00605903f, -0.01030578f, 0.01809713f, 
    -0.03620367f, -0.02926207f, 0.03031113f, 0.00373715f, 0.02902902f, 0.03146118f, 0.01988651f, -0.03198135f, 
    -0.00793022f, -0.04053974f, -0.00555405f, -0.03851990f, -0.00622647f, -0.03020155f, -0.03520712f, 0.01449400f, 
    -0.04343236f, -0.00029475f, -0.00306180f, 0.01784994f, 0.02929381f, -0.02735194f, -0.01781291f, -0.01322567f, 
    -0.02597951f, 0.03044519f, -0.00638291f, -0.00852199f, -0.04058860f, 0.03135746f, -0.03840811f, 0.00563347f, 
    0.00488304f, 0.01539433f, 0.01159686f, 0.01150530f, 0.02586208f, -0.01385479f, -0.02304057f, 0.01853371f, 
    0.01637292f, -0.01695028f, -0.01471753f, -0.03013267f, 0.02926598f, 0.02506907f, -0.01801922f, 0.01588244f, 
    -0.00477024f, -0.02702731f, 0.01540501f, 0.01575018f, 0.01355542f, -0.03177431f, 0.00460046f, -0.01835738f, 
    0.01408340f, 0.01153608f, -0.00696703f, -0.01187507f, 0.02950815f, -0.01076310f, -0.03046604f, 0.00258510f, 
    0.02559143f, 0.04347251f, 0.02863435f, -0.02667465f, -0.03463060f, 0.02757882f, 0.02075100f, -0.00183194f, 
    0.02936744f, -0.01964372f, 0.03305453f, -0.00269862f, 0.03155344f, -0.00538718f, 0.03396980f, -0.02031974f, 
    0.00563215f, 0.02178910f, 0.00019962f, -0.01091192f, -0.02734890f, 0.00971821f, -0.03225464f, 0.01483826f, 
    0.01829875f, 0.02335379f, 0.00376707f, -0.01422860f, 0.02567980f, -0.04086987f, -0.03376279f, 0.03259366f, 
    -0.02841899f, 0.00132691f, -0.01196119f, -0.03200205f, 0.02836987f, -0.03102495f, -0.02883246f, -0.02186266f, 
    -0.02324653f, -0.04503404f, 0.03005634f, 0.00507352f, -0.00363996f, 0.00179174f, -0.04297719f, -0.03357044f, 
    0.01568587f, 0.03105980f, -0.01354115f, 0.02563372f, -0.01379627f, -0.01066064f, -0.04194481f, -0.02060880f, 
    0.01322176f, 0.02297853f, -0.01651039f, -0.01569764f, -0.00988914f, -0.02714448f, 0.00778696f, 0.00427972f, 
    -0.01890531f, 0.01600279f, -0.02032046f, 0.00609396f, -0.03347533f, 0.02409584f, 0.01323344f, 0.00775844f, 
    -0.00101146f, 0.02184692f, 0.00781046f, -0.02230101f, -0.03663068f, -0.00968254f, 0.02479650f, -0.02151152f, 
    -0.02922192f, 0.00122022f, -0.03379601f, 0.00089445f, -0.02890779f, -0.00303742f, -0.01255382f, -0.02256182f, 
    -0.00643934f, 0.01867254f, 0.00724749f, 0.00464456f, 0.02971443f, -0.00820397f, 0.01130828f, 0.02059882f, 
    0.00871697f, -0.03117564f, -0.03362482f, 0.02057706f, 0.00514687f, -0.02594140f, -0.00261725f, -0.02635431f, 
    0.00112436f, 0.02838136f, -0.02191670f, 0.00305569f, -0.00953400f, 0.03411192f, 0.00774989f, 0.01917685f, 
    -0.02760179f, -0.03327670f, 0.01352632f, -0.03834792f, 0.00129295f, 0.02230460f, 0.00086296f, -0.00302617f, 
    0.01229261f, 0.03009017f, 0.01820714f, 0.03481448f, -0.02369473f, -0.01593494f, -0.01286238f, -0.00234058f, 
    0.01520284f, 0.03684437f, 0.00125982f, -0.03959861f, 0.01433905f, 0.02226426f, -0.03515936f, 0.00585292f, 
    -0.03257227f, -0.00709344f, -0.01583158f, -0.04615558f, 0.01277895f, -0.03040787f, -0.03919933f, -0.01836544f, 
    -0.03636660f, -0.01288893f, 0.00962900f, -0.02175098f, 0.02310458f, -0.01188339f, 0.00087257f, -0.03438317f, 
    -0.01211317f, 0.01540680f, 0.01567325f, 0.02191493f, -0.03087502f, -0.02848919f, -0.00896216f, 0.00117910f, 
    0.02844533f, 0.01186562f, -0.04122414f, -0.00759533f, -0.00661546f, -0.03978666f, -0.02809417f, 0.00952643f, 
    0.00272326f, 0.00186779f, -0.02231679f, -0.01576873f, -0.01114935f, 0.00958450f, 0.00093503f, -0.01297291f, 
    -0.02200825f, -0.03432361f, -0.00337709f, -0.00968289f, -0.01668847f, -0.00105798f, -0.01618678f, 0.01198618f, 
    -0.03025905f, -0.01824545f, 0.01762422f, -0.01585365f, -0.00672427f, -0.02564056f, 0.02102295f, 0.03125184f, 
    -0.00264684f, -0.02737425f, 0.01705612f, -0.03998828f, -0.00130835f, -0.03759543f, 0.00358280f, -0.00077395f, 
    -0.02628807f, 0.02493337f, -0.01180096f, -0.00922784f, -0.04571256f, 0.01255260f, 0.01397082f, 0.01966803f, 
    0.02923833f, -0.02586407f, -0.00957774f, 0.01605672f, -0.00264043f, 0.02967558f, 0.00863683f, 0.02570480f, 
    0.03380286f, -0.00065431f, 0.01068467f, -0.01268439f, -0.00989542f, -0.00206056f, -0.00873405f, 0.00151181f, 
    -0.01820335f, 0.01258880f, -0.03396310f, -0.02469203f, -0.04503817f, -0.00855431f, 0.00835501f, 0.02763741f, 
    0.02686254f, -0.01123184f, -0.00519893f, 0.01326781f, -0.01739491f, -0.03168128f, 0.02452637f, 0.02091264f, 
    -0.01083079f, 0.01824850f, 0.00131550f, -0.01913966f, -0.01610817f, 0.02337336f, -0.02260062f, -0.00097253f, 
    -0.01228469f, -0.03279347f, -0.03149714f, -0.00467831f, -0.01973736f, -0.02762198f, 0.01192524f, 0.02245096f, 
    0.01807300f, 0.00360025f, -0.01467884f, 0.02258131f, -0.01188029f, -0.02195544f, -0.02289992f, 0.00394117f, 
    -0.01847073f, 0.01648626f, 0.02147878f, -0.02345380f, -0.03542218f, 0.01352611f, -0.02025499f, 0.00557055f, 
    0.01672894f, 0.01166540f, -0.02143710f, -0.00499168f, 0.01217373f, 0.00510905f, 0.00556985f, -0.01131655f, 
    -0.02615042f, 0.02012604f, 0.02730448f, 0.01239475f, -0.01594755f, -0.00076017f, 0.00199547f, -0.04227450f, 
    0.00896425f, -0.02649883f, -0.01249884f, -0.03509417f, 0.02834273f, -0.00992503f, -0.04411009f, 0.01582283f, 
    -0.00964053f, 0.02296259f, -0.01274489f, -0.04573973f, -0.02895538f, -0.03486859f, 0.03443522f, 0.01907672f, 
    0.00343105f, 0.02366676f, -0.02900385f, 0.02000867f, 0.00750649f, -0.00447451f, 0.00458789f, 0.01810854f, 
    -0.01302183f, -0.01596994f, -0.01197278f, -0.02275703f, 0.02076893f, -0.00078302f, 0.02233838f, -0.00376838f, 
    -0.00294996f, 0.00262938f, 0.01977224f, -0.03341859f, 0.02475119f, 0.03250411f, -0.01682700f, 0.02213995f, 
    -0.02131170f, -0.00698145f, -0.02018545f, 0.03120857f, -0.00667666f, -0.02817200f, -0.02293569f, -0.01258580f, 
    -0.02874907f, -0.03738929f, 0.00036799f, 0.03540755f, -0.02239425f, -0.04103784f, -0.01149688f, -0.03429431f, 
    -0.02837527f, 0.00657144f, 0.01919959f, -0.01031295f, -0.02456299f, 0.02483616f, -0.01876422f, 0.02206273f, 
    0.02139897f, 0.02340059f, -0.00871664f, 0.02582324f, -0.00408469f, -0.03130422f, 0.00434345f, -0.02486412f, 
    -0.00013218f, -0.03703028f, -0.02553538f, 0.00731583f, -0.04393429f, -0.01076021f, -0.00027466f, 0.00192861f, 
    -0.03898458f, -0.02070357f, -0.01975975f, 0.01645931f, -0.02909422f, 0.01687031f, 0.00438286f, 0.00194212f, 
    0.01587132f, 0.01715950f, -0.00085951f, -0.03345460f, -0.03137898f, 0.00798886f, -0.00280329f, -0.03417237f, 
    -0.02209078f, -0.01671642f, -0.02212837f, 0.00056634f, 0.01783589f, 0.00373086f, -0.00331944f, 0.02972755f, 
    -0.01674787f, 0.02275145f, -0.00550624f, 0.01956305f, 0.02839619f, -0.02377487f, 0.02584057f, -0.00213222f, 
    0.01732379f, 0.02016224f, -0.00274814f, -0.02487935f, 0.03306244f, -0.01795564f, -0.03313342f, -0.01135261f, 
    0.24521376f, -0.06758896f, -0.03584647f, -0.09290401f, 0.03415361f, 0.15858234f, 0.03288159f, 0.04928625f, 
    0.01225610f, 0.08844406f, -0.07067357f, -0.05769712f, -0.18976416f, -0.03624677f, -0.06789521f, -0.19384417f, 
    -0.05023611f, -0.02098988f, -0.04054161f, -0.01279650f, 0.03239385f, 0.01008734f, -0.04289765f, 0.00597106f, 
    0.42568180f, 0.07045496f, -0.00598528f, 0.19534962f, -0.03288580f, -0.05023601f, 0.07695936f, 0.11048664f, 
    0.07691459f, -0.16001473f, -0.05596996f, 0.00940751f, 0.11510428f, -0.06113286f, 0.02269328f, 0.10042961f, 
    0.04000057f, 0.19692358f, 0.07466549f, 0.10299996f, 0.17721897f, 0.01073693f, 0.05232986f, 0.01625221f, 
    -0.18213768f, -0.06025611f, -0.12380553f, -0.05614052f, 0.12615697f, -0.11639938f, 0.01249103f, -0.05692159f, 
    -0.03345575f, 0.05107714f, -0.17987709f, 0.03033407f, 0.23400402f, -0.05147849f, -0.15677504f, -0.15902446f, 
    -0.01731142f, 0.02708646f, -0.06274075f, 0.00105512f, -0.05017927f, 0.03016698f, -0.05677693f, 0.11038184f, 
    -0.15168791f, -0.08731146f, -0.21357809f, -0.36085063f, -0.02351655f, -0.00173005f, -0.01181336f, -0.04179786f, 
    0.04436602f, 0.01413181f, 0.06058846f, 0.03646876f, -0.04272712f, -0.10184661f, -0.02740806f, 0.08283903f, 
    -0.00191416f, -0.06116799f, 0.06450593f, -0.05332946f, 0.05365659f, -0.13494425f, -0.01863720f, 0.09078225f, 
    0.04562856f, -0.03196187f, 0.01448297f, 0.11619040f, -0.12492594f, 0.10805982f, 0.01661638f, -0.07187594f, 
    0.07849368f, -0.00705730f, -0.07386366f, 0.11888683f, 0.05434056f, 0.05685877f, 0.11742236f, -0.19024885f, 
    0.00444918f, 0.05609935f, 0.07095146f, 0.05988174f, -0.09984167f, 0.00942156f, -0.08326282f, -0.01173733f, 
    0.14410503f, 0.18064301f, -0.09167323f, -0.04319823f, 0.06028084f, 0.01424201f, -0.00673596f, -0.05540322f, 
    -0.00526087f, -0.02821395f, 0.02703591f, 0.06949096f, 0.17019381f, 0.16492777f, -0.00887601f, -0.07140600f, 
    -0.00070319f, 0.09986420f, -0.05886396f, 0.06393709f, 0.04139436f, -0.04394812f, -0.00131770f, 0.12138459f, 
    0.20016386f, 0.00784688f, 0.07674350f, 0.06860546f, 0.02676897f, 0.09612323f, 0.07638212f, -0.01802257f, 
    -0.10149718f, 0.09584589f, -0.05490396f, -0.05265714f, -0.09134866f, -0.01369176f, -0.22911604f, -0.27833599f, 
    0.13276395f, -0.13257007f, 0.05869885f, -0.03401421f, 0.05005855f, 0.14563687f, 0.07282027f, 0.09958790f, 
    0.18660294f, 0.05891921f, 0.12713538f, 0.07470539f, 0.14874804f, 0.05220433f, -0.05820579f, -0.04654900f, 
    0.13280536f, 0.11243188f, -0.06731933f, 0.03924812f, -0.24139765f, -0.16125281f, -0.04816369f, 0.17195934f, 
    -0.01311339f, -0.04941163f, 0.04881359f, 0.08565563f, 0.07622507f, -0.09349843f, 0.01544550f, 0.08321199f, 
    0.15409878f, -0.06983893f, 0.03114197f, 0.13854139f, 0.03495201f, -0.04623248f, 0.12322486f, -0.06416743f, 
    0.04338072f, -0.12258412f, -0.02159646f, -0.00886500f, -0.17141195f, 0.13590744f, 0.00574927f, 0.06915613f, 
    0.04449565f, 0.09794723f, 0.01205600f, -0.02353243f, 0.07059642f, 0.14613271f, -0.08342618f, -0.02394548f, 
    0.06860662f, -0.08446938f, 0.10243524f, 0.21618769f, 0.12570436f, 0.05586383f, -0.06879075f, -0.02381322f, 
    -0.01853138f, 0.08123462f, 0.06816141f, 0.07354128f, -0.10216280f, -0.01229981f, -0.05832518f, 0.31544283f, 
    -0.00290291f, 0.03141487f, -0.01458375f, -0.11942400f, -0.03892449f, 0.00685613f, 0.13675837f, -0.05676985f, 
    0.02937505f, -0.04690699f, -0.14589709f, 0.08233507f, -0.02259062f, 0.01177378f, 0.04205997f, 0.09030178f, 
    0.03426504f, -0.05826852f, -0.13556273f, -0.01177057f, -0.03199528f, -0.00614457f, 0.11342875f, 0.27156630f, 
    0.08779906f, 0.10149981f, -0.02695139f, -0.03465297f, 0.00014836f, 0.04340252f, -0.00523619f, -0.01193055f, 
    -0.18116726f, 0.01325289f, -0.00566732f, -0.04481503f, -0.08764003f, -0.03615254f, 0.05858254f, -0.10438669f, 
    0.26458439f, 0.07414489f, 0.06510364f, -0.17501056f, -0.38195240f, -0.11860025f, -0.07344802f, 0.04053541f, 
    0.04521013f, -0.03667819f, 0.00109504f, 0.10027345f, -0.07522664f, -0.24287175f, -0.06262331f, 0.08609609f, 
    0.27460024f, 0.01974479f, 0.10172912f, 0.05416799f, -0.04696412f, -0.07941744f, 0.07883638f, 0.03092572f, 
    0.07193250f, -0.19381006f, 0.02841925f, 0.00584615f, 0.07095642f, 0.08071667f, 0.15614778f, 0.28438050f, 
    0.08501460f, 0.00839572f, -0.01638448f, 0.00129206f, -0.01184070f, 0.03184991f, -0.00700650f, -0.01953314f, 
    0.04622453f, -0.05207545f, -0.19793709f, 0.09190835f, -0.01764813f, 0.10316901f, -0.02109447f, 0.12067384f, 
    -0.04337071f, 0.03218011f, -0.09516864f, -0.04806254f, -0.26539832f, -0.07087646f, 0.04230138f, 0.29608124f, 
    0.02258782f, -0.13315059f, 0.03433659f, 0.06146698f, -0.08951383f, 0.07355708f, 0.00173210f, -0.07496287f, 
    0.08686737f, -0.01593358f, -0.09733117f, 0.01998696f, -0.00482016f, -0.03564779f, -0.11211153f, -0.01148372f, 
    -0.10327680f, -0.02649965f, -0.06000797f, 0.04101783f, -0.01652724f, 0.13452482f, 0.02838676f, -0.12244735f, 
    0.08856121f, 0.03865363f, -0.03577248f, 0.14677194f, 0.07000008f, 0.02061887f, 0.13157962f, -0.05842061f, 
    -0.12055419f, 0.05783940f, 0.18439324f, 0.24648011f, 0.03069075f, -0.07531314f, -0.01538191f, 0.10155269f, 
    0.00185469f, 0.07732162f, 0.02730948f, -0.05515329f, -0.22823878f, -0.07835849f, -0.00189135f, -0.11522283f, 
    0.01568336f, -0.11420704f, -0.02828578f, -0.05844501f, 0.15080956f, -0.03260032f, -0.02542919f, -0.03019504f, 
    0.29960188f, -0.06362949f, 0.09101191f, -0.29908368f, -0.07399976f, 0.08261848f, -0.05144040f, -0.02071757f, 
    0.00204275f, -0.07768130f, 0.02143494f, 0.08285511f, -0.62588602f, 0.00709039f, 0.16365303f, -0.15991999f, 
    0.10341022f, 0.11657681f, -0.00568851f, 0.16521166f, 0.03792755f, 0.03992527f, 0.12870388f, -0.07479928f, 
    -0.19282399f, -0.15249254f, -0.08563062f, 0.19924885f, -0.01964621f, -0.05485218f, 0.01257358f, 0.05033546f, 
    -0.03660929f, 0.07054222f, 0.08531688f, -0.04859234f, 0.05050506f, 0.01987459f, 0.05647646f, -0.02536326f, 
    -0.04895176f, 0.01049689f, 0.03239908f, 0.03776126f, 0.02291570f, -0.06835493f, -0.06969523f, -0.03530933f, 
    0.04093951f, 0.09520281f, -0.07881108f, -0.07343114f, -0.05395844f, -0.12223155f, -0.03654813f, -0.05341248f, 
    -0.05343909f, 0.05260641f, -0.07497953f, 0.07204866f, -0.10542171f, 0.14865552f, -0.00648909f, 0.10656136f, 
    0.02559584f, -0.12625356f, 0.17193691f, -0.03143042f, -0.03050002f, -0.16063686f, -0.13213666f, 0.06435812f, 
    0.13920958f, -0.15876640f, -0.11407648f, -0.14115277f, 0.02182498f, -0.03884356f, -0.12205502f, 0.07234739f, 
    0.03365551f, 0.05129389f, -0.01078644f, -0.08225267f, 0.26127133f, 0.05985409f, -0.13734291f, -0.05019236f, 
    0.02237571f, -0.13571598f, 0.03682704f, 0.02472683f, 0.03432925f, 0.06813990f, 0.00038557f, -0.10807759f, 
    0.01286744f, -0.12846461f, 0.12229735f, -0.25407624f, -0.02335218f, -0.03066423f, 0.01137821f, 0.07177494f, 
    0.00564878f, -0.01952907f, 0.05083349f, -0.04726728f, 0.15042414f, -0.09330447f, -0.02516776f, 0.19293697f, 
    -0.01387319f, 0.07997623f, 0.04404677f, 0.04489755f, -0.02128271f, -0.07358255f, 0.02697194f, 0.04555622f, 
    0.14794460f, -0.02432945f, 0.01662683f, -0.02637038f, -0.08553933f, 0.02336485f, 0.00409220f, -0.01197085f, 
    -0.05336408f, -0.11771532f, 0.04303782f, 0.04433247f, 0.15227625f, 0.21040255f, 0.06637520f, 0.11509715f, 
    -0.04443632f, -0.02285327f, -0.02716581f, -0.03043355f, -0.04438155f, 0.09664794f, 0.08986923f, -0.02597268f, 
    -0.31790039f, -0.08412132f, -0.11251798f, 0.00516108f, 0.00896360f, 0.03152702f, 0.09504005f, 0.01920268f, 
    0.10838840f, 0.05962113f, 0.06891711f, -0.06688967f, -0.09061168f, 0.09544202f, 0.05337322f, -0.13128595f, 
    0.13822438f, -0.12425475f, 0.05647925f, 0.09694721f, -0.15743740f, 0.09238276f, 0.08788297f, -0.09256712f, 
    0.35266340f, 0.06798580f, -0.07516292f, 0.18581426f, -0.08371580f, -0.06281412f, 0.04984904f, -0.10674334f, 
    0.04343252f, 0.02571582f, -0.01787416f, -0.01492441f, 0.12599704f, -0.06940910f, -0.08762468f, 0.07501241f, 
    0.06948480f, -0.03840389f, -0.04149926f, 0.02920334f, 0.09133482f, -0.05027634f, -0.04876067f, 0.02977596f, 
    -0.29112855f, -0.01773742f, -0.19106027f, 0.29471689f, 0.06136816f, 0.05296533f, -0.10324574f, 0.05934420f, 
    0.05512723f, 0.01412940f, 0.01475429f, -0.05031813f, 0.13107029f, -0.04305469f, 0.12557483f, -0.02247482f, 
    0.06915045f, 0.16302587f, 0.01773922f, -0.05174527f, -0.02862588f, -0.03802044f, 0.00732257f, 0.22875355f, 
    0.27784938f, -0.08570562f, 0.02164991f, -0.17388223f, -0.03627167f, -0.02728771f, 0.09722119f, -0.03974926f, 
    -0.08852674f, -0.07194677f, 0.16807590f, 0.09036468f, 0.11093270f, -0.08050821f, -0.00804952f, -0.02068298f, 
    0.12522200f, -0.01941545f, -0.08824245f, 0.14448003f, 0.03722246f, 0.07388007f, -0.10414488f, -0.00094672f, 
    -0.08260904f, -0.06485346f, 0.12531377f, 0.52952462f, -0.00404445f, -0.05566405f, -0.08045285f, 0.10031661f, 
    0.06528439f, -0.08166035f, 0.01611317f, -0.09659739f, 0.20152043f, -0.12399950f, -0.05202664f, -0.10127737f, 
    -0.01585529f, -0.03488976f, -0.15475827f, 0.10967629f, 0.10604486f, -0.00704222f, 0.00751523f, 0.09959212f, 
    0.27218410f, -0.16672444f, 0.01555210f, 0.11960807f, 0.18636660f, 0.08895603f, 0.09843773f, 0.04586306f, 
    0.00125839f, -0.01070223f, 0.13330312f, 0.00742655f, -0.04648304f, 0.12491815f, -0.06657326f, 0.05258766f, 
    -0.05273019f, 0.00125190f, 0.09995396f, 0.03982433f, -0.10449412f, 0.09011034f, -0.02850372f, 0.08144934f, 
    0.10382253f, 0.10388061f, 0.01828163f, 0.18930076f, 0.26101869f, 0.02347187f, 0.01085466f, -0.05189926f, 
    0.01953986f, -0.08334693f, -0.02699764f, 0.07290093f, -0.19368032f, -0.03953989f, -0.09042345f, -0.00446359f, 
    0.08845074f, -0.02965420f, -0.10653408f, 0.14925514f, 0.09926219f, -0.00779114f, -0.15834218f, -0.01316342f, 
    0.04574595f, -0.00184531f, 0.15436371f, 0.31887904f, 0.09222859f, 0.03954641f, -0.00082109f, 0.08071736f, 
    0.02181845f, -0.00049807f, 0.01354902f, -0.12153498f, 0.06585058f, -0.14565316f, 0.10470474f, 0.10821690f, 
    0.03854734f, -0.00078515f, 0.03884044f, -0.17717108f, 0.01048660f, 0.09676404f, 0.12218601f, -0.03078250f, 
    -0.11289850f, 0.00452780f, 0.07575693f, 0.14753453f, 0.29751238f, -0.07606528f, 0.07778384f, -0.07618567f, 
    0.04277863f, 0.04363121f, -0.00286101f, 0.03266833f, -0.06155226f, 0.02972303f, -0.00892566f, 0.06887630f, 
    -0.08892714f, 0.03715878f, 0.05670415f, -0.12548788f, 0.00239488f, 0.04742993f, 0.05559776f, 0.03330272f, 
    0.33183861f, 0.00612824f, 0.08140915f, -0.23924020f, -0.11506253f, 0.02938224f, 0.10276344f, -0.02964522f, 
    0.02509717f, -0.12693979f, -0.09044855f, -0.00999716f, 0.14742908f, -0.09561469f, -0.26843590f, 0.25962925f, 
    0.05352211f, 0.01133082f, 0.10399821f, -0.18701161f, 0.01557329f, 0.08103149f, 0.07400257f, -0.01263161f, 
    -0.07458777f, -0.14937693f, -0.05942156f, -0.13794143f, 0.05173533f, -0.02569243f, -0.07181417f, -0.07816093f, 
    0.08095568f, 0.05040707f, 0.18049149f, 0.05613100f, 0.49989325f, 0.00682977f, 0.24978085f, -0.01108099f, 
    -0.05848785f, -0.12696892f, -0.00925264f, 0.07074066f, -0.01439936f, -0.03044695f, 0.11854649f, 0.09889141f, 
    0.33445162f, 0.05682576f, 0.02781506f, 0.06592846f, -0.04960169f, 0.08162056f, 0.07563685f, -0.07632431f, 
    -0.03129433f, 0.18034798f, -0.04040463f, 0.04529582f, 0.03494754f, -0.05947594f, -0.18690594f, -0.02186156f, 
    0.10230128f, -0.00332456f, -0.03892526f, -0.01300294f, -0.04765662f, 0.08369019f, 0.02586613f, 0.01346957f, 
    -0.12079299f, -0.00970814f, 0.01302709f, -0.02608814f, 0.17779337f, 0.00013805f, 0.03476850f, -0.00051681f, 
    -0.03547566f, 0.06218696f, 0.07516420f, 0.00199080f, -0.02770642f, 0.13484332f, 0.20061384f, -0.03675868f, 
    0.03498989f, 0.02657519f, 0.00514707f, 0.09613222f, 0.04155139f, -0.01961597f, -0.01202345f, 0.01786909f, 
    0.47391343f, 0.04999340f, -0.05363007f, 0.18982920f, -0.00758879f, -0.03033983f, 0.00740013f, 0.00314647f, 
    -0.09130720f, 0.01154248f, -0.01114899f, 0.09602376f, -0.09205593f, -0.05126855f, -0.03521036f, 0.02595862f, 
    -0.05093766f, -0.05186570f, 0.00124027f, -0.10959457f, -0.09829681f, -0.01354206f, 0.11414017f, -0.03922288f, 
    -0.05418484f, -0.13306901f, -0.12992962f, -0.13437910f, 0.10031099f, 0.07206903f, -0.06060505f, -0.03867714f, 
    0.06682894f, 0.00579505f, 0.09160054f, 0.00043731f, -0.08808889f, -0.02569572f, 0.07356362f, -0.20141760f, 
    -0.04887675f, 0.02766534f, 0.03455209f, 0.04842180f, 0.03325889f, 0.04867949f, 0.04791822f, -0.02670851f, 
    0.18480043f, -0.23143537f, 0.02553895f, 0.05808122f, 0.06132834f, 0.01564869f, -0.09704430f, 0.03275916f, 
    0.04292098f, 0.08300268f, 0.02179988f, 0.07038054f, 0.20126699f, -0.18072246f, -0.03014106f, 0.13929857f, 
    0.04240127f, 0.00227889f, -0.04300317f, 0.12416763f, 0.10471427f, 0.09136604f, -0.03342416f, 0.07784816f, 
    -0.14115857f, -0.10985709f, -0.04033786f, 0.01859948f, 0.10193654f, 0.01521527f, 0.01834337f, -0.10582393f, 
    -0.03514247f, 0.05193220f, 0.01110124f, 0.01471268f, -0.06378382f, 0.10863857f, 0.06404457f, 0.01979386f, 
    0.06264108f, -0.05931951f, 0.11767280f, -0.05146320f, -0.02847812f, -0.01673384f, 0.05496011f, 0.06380018f, 
    -0.16210695f, -0.20365034f, -0.17653155f, 0.03834121f, 0.14020024f, 0.00122370f, 0.01622518f, -0.06454953f, 
    -0.10746253f, -0.08874847f, 0.05688037f, 0.08392470f, -0.00082639f, 0.18979272f, 0.12473229f, 0.19371153f, 
    -0.10146247f, -0.01557998f, -0.15468039f, 0.04644036f, -0.05959064f, 0.03539764f, -0.04958217f, -0.00041745f, 
    -0.17164904f, 0.04223469f, -0.09087756f, -0.09427341f, 0.12764029f, 0.07469389f, -0.02430859f, -0.07694000f, 
    -0.06764060f, 0.12683684f, 0.09593046f, 0.05338031f, -0.10328491f, 0.26206407f, -0.26647526f, 0.11230133f, 
    0.00439823f, -0.00993188f, 0.03003309f, 0.06950169f, 0.09530712f, -0.01021936f, 0.15886950f, 0.01104895f, 
    0.17916484f, -0.17372505f, -0.01063943f, -0.02755899f, 0.13993908f, -0.00197945f, -0.00876252f, 0.00774034f, 
    0.03977318f, 0.01305836f, -0.07645033f, -0.02212394f, 0.04653180f, -0.13530548f, -0.16863117f, -0.07937292f, 
    0.11204115f, 0.06970400f, -0.08588605f, 0.10026381f, 0.08254158f, 0.06126565f, -0.08412198f, -0.10336486f, 
    0.13829975f, 0.14227781f, 0.16200416f, 0.19593702f, 0.02145771f, -0.11834455f, -0.05619287f, -0.14345442f, 
    0.01777042f, 0.06621064f, 0.14013629f, 0.04513673f, -0.29846749f, 0.22521688f, -0.00349987f, 0.00780837f, 
    0.02371914f, -0.01743479f, 0.05093756f, 0.08436419f, 0.02661101f, -0.02494973f, -0.03232234f, -0.04288732f, 
    0.13863625f, -0.14392173f, -0.12204083f, -0.12902051f, 0.06811795f, 0.14085481f, -0.06193731f, 0.00374766f, 
    0.10770702f, 0.00771616f, 0.02576975f, -0.07662646f, -0.08718029f, 0.19567481f, -0.04770632f, 0.07900950f, 
    -0.02027569f, -0.03555696f, 0.03849402f, 0.02313553f, 0.00518081f, 0.09064838f, -0.06741683f, 0.20595600f, 
    0.14961413f, -0.03770686f, -0.15394051f, 0.03690563f, 0.04015765f, 0.07955392f, 0.07160582f, -0.03210049f, 
    -0.11559354f, 0.03886468f, 0.07635200f, 0.08310736f, 0.06467880f, -0.04812166f, -0.06303164f, -0.12837091f, 
    -0.05027220f, -0.05682222f, -0.00923185f, -0.10553224f, 0.02085501f, -0.03085239f, 0.07203560f, -0.09112464f, 
    -0.02490613f, -0.06401508f, -0.08969508f, 0.00253081f, -0.07668246f, 0.00572254f, -0.09384704f, 0.12239351f, 
    -0.12109723f, -0.02409315f, -0.03793679f, 0.03951566f, 0.01126424f, 0.10388973f, 0.11241210f, 0.07993568f, 
    -0.10271732f, 0.03077684f, 0.00696262f, 0.06784154f, -0.06014871f, -0.16839123f, 0.06509216f, -0.04146121f, 
    0.08873712f, -0.17454661f, 0.22588626f, 0.11047428f, -0.17328821f, 0.04082409f, 0.09662139f, -0.14469559f, 
    -0.07496973f, -0.06364790f, 0.11208715f, 0.00173097f, -0.16586675f, -0.09017392f, 0.02658820f, -0.08757301f, 
    0.08018837f, -0.10123610f, -0.02333823f, -0.06574573f, 0.02487012f, 0.00801294f, 0.00463553f, -0.08586308f, 
    -0.09828789f, -0.05832445f, 0.03270724f, -0.19912946f, -0.00463413f, -0.02090436f, -0.00706604f, -0.05747120f, 
    -0.03725357f, 0.02010507f, -0.02858947f, -0.01425328f, 0.10203646f, -0.05393374f, -0.00335549f, 0.11588730f, 
    0.05356794f, 0.04278926f, -0.01586138f, 0.01901230f, 0.06569927f, 0.06505323f, 0.00529919f, 0.02141172f, 
    -0.18466987f, 0.02204517f, 0.23684388f, -0.02970310f, -0.02071854f, 0.01192133f, 0.07579450f, -0.00641959f, 
    -0.04162007f, -0.08049499f, -0.05594362f, 0.13970765f, 0.22692870f, 0.12632075f, -0.07777172f, -0.23682618f, 
    0.03351144f, 0.03105886f, 0.02685283f, 0.13233054f, 0.06724816f, 0.06273925f, 0.04124029f, 0.03043857f, 
    0.07843897f, 0.01534391f, 0.06440169f, 0.14410162f, -0.02061457f, 0.01011281f, 0.06152402f, 0.06393488f, 
    -0.03913095f, -0.00549449f, 0.04165172f, 0.01213770f, -0.04624923f, 0.25517091f, 0.04004437f, 0.04421221f, 
    -0.08358116f, 0.07205959f, -0.02553084f, -0.01387075f, 0.02446520f, 0.09832928f, 0.05091263f, -0.01681026f, 
    0.45890033f, 0.08358167f, -0.16077128f, 0.22524175f, 0.07623776f, -0.05223710f, 0.01757940f, 0.05055043f, 
    0.00313916f, -0.05226503f, -0.00390969f, 0.01686474f, -0.17823128f, 0.01350324f, -0.15431760f, 0.04043206f, 
    0.05237560f, 0.13292411f, 0.06481543f, 0.04157896f, 0.03625313f, 0.02949401f, -0.04890944f, 0.03614941f, 
    0.34302390f, 0.07033785f, 0.00259379f, -0.01858775f, -0.03924786f, -0.05161528f, 0.07327452f, -0.02789750f, 
    -0.00042745f, -0.00599724f, 0.01075333f, 0.07780388f, -0.10940667f, 0.28528485f, 0.12444422f, 0.14770770f, 
    -0.00651956f, -0.02243410f, 0.02142380f, -0.05743114f, 0.20357642f, 0.01407825f, -0.01678208f, 0.11588553f, 
    0.08050649f, 0.20016988f, 0.06279475f, -0.00370330f, -0.12038574f, -0.02256412f, -0.02260769f, -0.00756923f, 
    0.02452661f, 0.00564479f, 0.04575642f, 0.03422204f, -0.04434016f, 0.18706219f, 0.13126053f, 0.21134761f, 
    -0.01190639f, -0.02283332f, 0.09222306f, -0.10312344f, -0.01608645f, 0.06656697f, 0.07015569f, 0.05252431f, 
    0.00582324f, 0.15962939f, 0.18275687f, 0.10690882f, 0.07000333f, 0.03223537f, 0.00337867f, 0.00597128f, 
    -0.12607907f, 0.01519570f, 0.01766830f, -0.11441582f, 0.10064638f, -0.22447011f, -0.00862333f, 0.06192185f, 
    -0.01760036f, -0.02043049f, -0.04850501f, 0.04343493f, 0.04299716f, -0.00407970f, -0.04479110f, 0.03238641f, 
    0.11128122f, 0.14090584f, -0.11626557f, -0.01099956f, 0.11422992f, 0.04937518f, -0.08296213f, 0.04101086f, 
    0.00950311f, 0.02975062f, -0.05637959f, 0.01085912f, 0.21028943f, 0.16907722f, -0.00572550f, -0.09592263f, 
    0.02619114f, -0.07339339f, -0.12091546f, 0.03889513f, 0.15459771f, -0.02679242f, 0.03902267f, -0.03914378f, 
    -0.10013092f, 0.21212956f, -0.02815813f, 0.19971293f, -0.04546622f, 0.10421935f, 0.09112871f, -0.00445445f, 
    0.01363844f, 0.03176950f, -0.06221981f, 0.11093150f, -0.23248893f, 0.05343811f, -0.21221088f, 0.03276564f, 
    0.11298155f, 0.12709408f, -0.07649828f, -0.04051212f, -0.04929833f, -0.06598625f, -0.00514910f, 0.01859924f, 
    -0.12190310f, 0.25462636f, 0.13306068f, 0.15551013f, -0.15460908f, -0.00766824f, -0.02868420f, 0.22802514f, 
    0.05627336f, 0.01939927f, -0.00926755f, -0.04974603f, -0.17627974f, 0.03939083f, 0.14450087f, 0.06789242f, 
    -0.08251712f, -0.02246558f, 0.00953786f, -0.02418499f, 0.10596669f, 0.08872084f, 0.03110055f, 0.11352360f, 
    0.02489996f, 0.02647200f, -0.08816025f, 0.04661181f, 0.13694473f, 0.07209133f, -0.04992248f, -0.00178317f, 
    -0.08266660f, 0.06036266f, 0.07564572f, 0.06471367f, -0.14371066f, 0.03905720f, 0.05185028f, -0.26015502f, 
    0.00514458f, -0.09184620f, 0.15897907f, 0.11933567f, -0.02059390f, 0.04573175f, 0.03729209f, -0.11677883f, 
    0.09167644f, -0.05388341f, 0.23137008f, 0.08260707f, -0.22747770f, -0.01129184f, 0.09125011f, 0.08168006f, 
    -0.05922721f, 0.05908392f, -0.06259450f, -0.01739233f, -0.08365080f, 0.13943397f, 0.22640364f, 0.06188447f, 
    -0.00686884f, -0.04059775f, -0.02899474f, -0.00698073f, 0.04004432f, -0.00071789f, -0.06164454f, 0.03094019f, 
    -0.13875085f, 0.04552097f, -0.09412684f, -0.10581255f, 0.01516025f, -0.08933324f, -0.03643570f, -0.06729411f, 
    0.07450508f, 0.09373149f, -0.03005808f, -0.00662029f, 0.29744136f, -0.04229647f, -0.03836197f, 0.15081131f, 
    0.03115173f, -0.01838012f, -0.02207326f, 0.02165346f, 0.07588597f, 0.06789666f, 0.00261198f, -0.13821441f, 
    -0.09695842f, -0.22487876f, 0.01514844f, 0.01917757f, 0.14043397f, -0.04231001f, -0.01663427f, -0.11428316f, 
    0.12586592f, -0.02121067f, -0.16172223f, 0.05147303f, 0.34522131f, 0.14789224f, 0.02392296f, -0.02157925f, 
    -0.11422168f, 0.01876640f, 0.06653612f, -0.01574245f, 0.10582363f, 0.00976935f, 0.04917037f, 0.03704722f, 
    0.00146132f, -0.03412159f, 0.21580121f, 0.08647870f, -0.20176761f, -0.10966305f, -0.03041801f, 0.02830087f, 
    0.00915183f, 0.00915184f, 0.06226723f, -0.06337929f, -0.05430157f, -0.04855257f, -0.26691973f, 0.09996192f, 
    -0.02509598f, -0.06981429f, -0.05314448f, 0.02256636f, 0.06497684f, 0.03837592f, -0.10207167f, 0.03654031f, 
    -0.32249692f, 0.08881208f, -0.11676615f, -0.07158044f, 0.25038561f, 0.04221439f, 0.06696903f, -0.08786716f, 
    0.03417945f, -0.06607305f, -0.02731702f, -0.04962783f, 0.20190808f, 0.10165308f, -0.09918020f, 0.00347731f, 
    0.08525348f, 0.06984514f, 0.00632241f, 0.05603598f, -0.00099822f, 0.07127696f, 0.05626940f, 0.03409646f, 
    -0.01218017f, 0.08971188f, -0.03444658f, 0.04507591f, 0.01423879f, 0.19539738f, 0.07224929f, -0.02335866f, 
    0.09570184f, 0.00779395f, 0.00747984f, 0.03562685f, -0.16255781f, 0.17494440f, -0.17003399f, 0.15088956f, 
    0.13988402f, -0.00804329f, -0.15918204f, -0.04313019f, 0.08203391f, 0.14119793f, 0.13584912f, -0.03434367f, 
    -0.03395462f, 0.01411267f, -0.01229963f, -0.00962672f, -0.02285587f, -0.00755947f, -0.00594053f, -0.02653430f, 
    -0.04040625f, -0.02223478f, 0.02713035f, -0.00495709f, 0.01100266f, -0.01188684f, -0.02198012f, 0.01119006f, 
    0.00639841f, -0.03541523f, -0.01226261f, 0.01411559f, -0.04216610f, -0.00086086f, 0.00377462f, 0.01263992f, 
    0.00411340f, -0.00732993f, 0.02846837f, 0.02218779f, 0.01690668f, -0.02662158f, -0.02987604f, -0.02278890f, 
    -0.02569425f, -0.01748069f, 0.01494315f, -0.02071091f, 0.02538778f, 0.01302791f, 0.00267492f, -0.03593996f, 
    -0.00316391f, 0.01172341f, -0.03298475f, 0.01959858f, -0.04263752f, 0.01548382f, -0.00059769f, 0.01127076f, 
    -0.03571493f, -0.04070695f, 0.01337581f, -0.01824897f, 0.01495950f, -0.04177291f, 0.01520704f, -0.00326029f, 
    0.02687001f, -0.00104612f, -0.02624662f, -0.01497396f, -0.02655024f, -0.00747212f, -0.03014262f, -0.02234391f, 
    0.00096158f, -0.00808219f, 0.00653616f, -0.00703864f, -0.00683696f, 0.02096999f, -0.01068599f, -0.03756020f, 
    -0.03839172f, -0.03744579f, -0.00582351f, -0.01820009f, -0.00727780f, 0.02025915f, 0.02647105f, 0.01238728f, 
    0.01578839f, -0.03734909f, 0.02254252f, -0.01050759f, 0.02459418f, -0.00651848f, -0.01123501f, -0.03487961f, 
    -0.03515793f, -0.03433142f, 0.01847162f, 0.01816363f, -0.03084112f, 0.02347640f, 0.00533395f, -0.04151393f, 
    -0.02485684f, -0.01855637f, -0.03674838f, -0.02222264f, 0.01086133f, -0.02029504f, -0.04289325f, -0.01175484f, 
    -0.00429912f, -0.00558202f, -0.03062079f, 0.00869388f, 0.02671034f, -0.02093969f, 0.01583739f, -0.02326346f, 
    -0.04268976f, 0.01334510f, 0.02774670f, 0.01173796f, -0.03861383f, -0.01257548f, -0.02925874f, -0.03949788f, 
    0.01872197f, 0.01627968f, -0.04058044f, -0.03188024f, -0.03159891f, -0.03808749f, 0.02917639f, 0.02755598f, 
    -0.02307332f, -0.02126281f, -0.01066662f, -0.03193536f, 0.02772370f, 0.00606361f, 0.02356441f, -0.00033036f, 
    -0.01161283f, -0.03231603f, -0.01597271f, -0.00758956f, 0.02538900f, -0.04375596f, 0.00761252f, -0.01729034f, 
    -0.01366362f, -0.04081887f, 0.02259269f, -0.01837586f, -0.03797001f, -0.04032535f, 0.02656739f, -0.02307989f, 
    0.01070462f, 0.02039164f, -0.02407584f, 0.02226848f, 0.00524457f, -0.03385195f, 0.00109701f, -0.01029343f, 
    -0.03756888f, 0.01818125f, 0.01672428f, 0.01072977f, 0.00769159f, -0.02523373f, -0.03854534f, -0.02008586f, 
    -0.00651106f, -0.02639302f, 0.00947506f, -0.01525006f, 0.01105860f, -0.03060695f, -0.02955059f, -0.03518420f, 
    -0.02368015f, -0.03005712f, 0.01454079f, -0.02562303f, -0.00788175f, 0.02774253f, -0.01600142f, -0.00774034f, 
    0.02450732f, -0.02042919f, -0.02593093f, 0.00027053f, 0.00703906f, 0.00168834f, -0.00582745f, 0.01130208f, 
    0.01068051f, -0.03844266f, -0.00865947f, 0.02695193f, -0.03228393f, -0.01820757f, 0.02362539f, -0.03483440f, 
    -0.04243460f, 0.01066936f, -0.03369107f, 0.02663504f, -0.01436174f, -0.00417235f, -0.02653759f, 0.02370284f, 
    0.01898673f, -0.02199674f, -0.03049618f, -0.00947156f, -0.02319582f, -0.00853053f, -0.00734951f, -0.00525805f, 
    -0.04205323f, -0.03816556f, -0.03776727f, 0.02861908f, -0.03111494f, -0.02572280f, -0.03335100f, 0.02428005f, 
    0.01011872f, -0.00949755f, 0.01252120f, 0.00863437f, 0.00618232f, -0.02664641f, -0.01386887f, 0.01048491f, 
    -0.03316810f, -0.03627359f, -0.01032965f, 0.02627549f, 0.02766505f, -0.01360701f, 0.01472704f, 0.01514136f, 
    0.00666977f, 0.01131585f, -0.01042693f, -0.00689751f, 0.01214497f, -0.01698065f, -0.03885813f, 0.02316161f, 
    -0.02689198f, -0.02726384f, -0.00727607f, 0.02354890f, 0.00576474f, -0.03489240f, 0.00026828f, 0.01851726f, 
    -0.00777972f, -0.01666807f, -0.02865846f, 0.00255503f, -0.01352036f, 0.02651316f, -0.02704730f, -0.03680173f, 
    -0.01236246f, -0.03996993f, -0.00286750f, 0.00282571f, -0.03460058f, 0.02405553f, -0.00297034f, 0.02467567f, 
    -0.02863431f, 0.01701706f, 0.02665696f, -0.03667808f, -0.03088941f, 0.02651853f, -0.03936916f, 0.02183002f, 
    0.01396846f, -0.04272781f, -0.01346242f, 0.02356412f, 0.00789552f, -0.03393523f, -0.03201522f, -0.03237635f, 
    -0.04368678f, -0.00499828f, -0.03885838f, 0.01048796f, 0.01970224f, -0.01005099f, -0.04315476f, -0.03832440f, 
    -0.04087097f, -0.00915110f, -0.00578769f, 0.02524193f, -0.00343063f, 0.00698936f, 0.00593209f, -0.01628438f, 
    -0.01238155f, -0.01680677f, 0.01943417f, -0.00630530f, -0.03740421f, 0.02844393f, -0.01021267f, 0.00179528f, 
    0.00677919f, 0.00179014f, -0.03572350f, -0.00778119f, -0.01963807f, -0.02645930f, -0.00639626f, -0.01783274f, 
    -0.03759149f, 0.01753021f, -0.02419953f, -0.01163305f, 0.01816999f, -0.03188528f, 0.01110568f, 0.00784363f, 
    -0.01180406f, -0.00334803f, 0.01963097f, 0.01098584f, 0.00147072f, -0.01728563f, -0.01876306f, 0.01451878f, 
    -0.03807783f, 0.00807386f, -0.01156426f, 0.02210532f, -0.03264278f, -0.02877477f, 0.01966445f, 0.02605575f, 
    -0.00021875f, -0.03105034f, -0.03918702f, -0.02463650f, 0.01922992f, -0.01397658f, -0.02930337f, -0.02524410f, 
    0.00501140f, 0.02569662f, -0.03552156f, -0.00958018f, -0.03634597f, 0.01649754f, -0.01243614f, 0.01717713f, 
    -0.00794122f, -0.02905666f, 0.00295719f, -0.03077404f, 0.02658712f, -0.02872125f, 0.02614695f, -0.04192363f, 
    0.02869295f, -0.00877888f, -0.03068107f, 0.01584546f, 0.00868058f, 0.01452083f, -0.02127726f, -0.04154919f, 
    -0.03371454f, -0.00890259f, -0.00987588f, 0.02206689f, -0.00301045f, -0.01740520f, 0.00080459f, -0.04009180f, 
    0.00179745f, -0.02726936f, -0.02224461f, 0.00163247f, -0.01133496f, 0.02765752f, -0.03317064f, 0.02256882f, 
    -0.02725216f, -0.03794596f, 0.01631631f, -0.00425778f, 0.01454152f, -0.01323200f, -0.01885956f, -0.00800547f, 
    -0.02724317f, -0.01456918f, -0.00969293f, -0.00369734f, -0.01819854f, -0.02869796f, 0.02666283f, -0.00977286f, 
    0.00873119f, -0.01570717f, -0.03052524f, -0.00221199f, -0.03193384f, -0.02859888f, -0.02933376f, -0.01706153f, 
    0.02382334f, 0.00209055f, -0.00948389f, 0.02701258f, -0.01409456f, 0.02084110f, 0.02499520f, 0.00595836f, 
    -0.00300164f, -0.01726578f, -0.03092863f, -0.00496817f, 0.02854268f, 0.01106637f, -0.00772044f, 0.01032168f, 
    0.02706954f, -0.00756995f, -0.02053901f, -0.03973212f, 0.01323571f, 0.00714766f, -0.03470268f, 0.02120865f, 
    0.02264809f, 0.01951423f, 0.02272676f, 0.02478165f, 0.02711936f, 0.00906529f, -0.00176647f, -0.02598640f, 
    -0.03858141f, 0.02034261f, 0.01290394f, 0.00580488f, -0.00961749f, -0.00595005f, -0.03662184f, -0.03432693f, 
    -0.00109579f, 0.01060797f, -0.01096157f, 0.01529338f, -0.00221766f, -0.02305085f, -0.00709335f, -0.01405598f, 
    -0.03237277f, -0.01355422f, 0.00395723f, -0.01408321f, 0.01951233f, -0.04176666f, 0.01738454f, 0.00372207f, 
    -0.00987434f, -0.02210731f, 0.01699649f, -0.00038177f, 0.02161915f, -0.02168566f, -0.00839838f, -0.00201397f, 
    0.01181328f, -0.03455025f, -0.04125422f, -0.02987015f, -0.00565946f, -0.03762122f, -0.00130390f, -0.01475921f, 
    -0.01778108f, 0.01775004f, -0.00273303f, -0.00544091f, 0.00427963f, -0.01770296f, 0.00369066f, -0.01992531f, 
    -0.00127604f, -0.02186421f, 0.02233163f, 0.01914114f, 0.02205039f, 0.01081068f, -0.03001029f, -0.02314514f, 
    -0.01845989f, 0.02733459f, -0.00004835f, 0.01731827f, -0.03982503f, -0.02433721f, -0.03720793f, 0.00058304f, 
    -0.03078920f, -0.02957689f, -0.01408134f, 0.01736617f, 0.01771200f, 0.00964504f, 0.00446413f, -0.04201036f, 
    -0.02325543f, 0.01236330f, -0.04266900f, 0.00092397f, -0.02051827f, -0.00247680f, -0.00732357f, -0.03431704f, 
    -0.01263688f, -0.01196425f, -0.03007609f, 0.00199635f, 0.01240139f, -0.03854300f, 0.00399781f, -0.00223811f, 
    0.01964130f, -0.01897960f, 0.02020063f, 0.02431640f, -0.00213001f, -0.01945063f, -0.00899702f, -0.00708850f, 
    0.00226922f, -0.03722171f, -0.03794559f, 0.01624356f, -0.03366989f, 0.02613587f, -0.04407900f, -0.00982483f, 
    0.02409411f, 0.02775665f, 0.02596942f, -0.04375345f, 0.01479570f, 0.00335140f, -0.02734096f, 0.02578660f, 
    0.00812690f, 0.00421853f, 0.02637807f, 0.02665775f, 0.01435803f, 0.02111681f, 0.01482736f, -0.03097930f, 
    -0.01813797f, 0.02317466f, -0.04310538f, -0.01460459f, 0.02261456f, 0.00903829f, -0.02243412f, -0.02605472f, 
    -0.03539058f, 0.02466599f, -0.00312085f, -0.03785102f, -0.00913677f, -0.01689231f, -0.01232710f, 0.00835034f, 
    -0.02939578f, -0.03619714f, 0.01971045f, -0.03672425f, -0.01814670f, 0.02339664f, -0.00449308f, -0.04125711f, 
    0.00888347f, -0.02975855f, -0.03463493f, 0.00742867f, -0.03602337f, 0.00366938f, -0.01772627f, 0.00958542f, 
    -0.03010804f, -0.03234698f, 0.01647423f, -0.03414900f, -0.02921077f, -0.00775326f, -0.03673096f, 0.01349643f, 
    0.01457684f, -0.02282866f, -0.04382205f, -0.01790402f, 0.00502792f, 0.01774509f, -0.00092075f, -0.02858849f, 
    -0.01228946f, -0.01517068f, 0.01931603f, 0.01034535f, -0.01318442f, 0.01917609f, -0.00960877f, 0.02079117f, 
    -0.01686819f, 0.01718023f, 0.01500769f, 0.00676571f, -0.00960620f, -0.03068713f, 0.02819092f, -0.02287561f, 
    -0.02838712f, -0.03238934f, -0.03027721f, 0.01284651f, 0.01535762f, -0.01334477f, -0.03595633f, 0.02470019f, 
    -0.01080310f, -0.02603885f, 0.01864584f, 0.01895822f, 0.02078579f, 0.00717845f, -0.03816202f, 0.01734100f, 
    -0.02948315f, -0.02769304f, 0.00175921f, -0.02047444f, 0.00929461f, 0.02288696f, -0.00700709f, -0.02449582f, 
    0.02743391f, -0.02843300f, 0.01797982f, 0.00875021f, 0.01303192f, 0.01216473f, 0.02084894f, -0.04339779f, 
    -0.03053964f, -0.03276329f, 0.02836700f, 0.00695278f, -0.01040395f, 0.01349325f, 0.02701099f, -0.00893868f, 
    0.01713025f, 0.00577292f, -0.03601666f, -0.01950095f, 0.02689147f, 0.00192847f, 0.01471639f, 0.00265147f, 
    -0.01481361f, 0.02121167f, -0.04082637f, 0.01379118f, 0.00749095f, 0.02070237f, -0.03430765f, 0.00386673f, 
    0.01431165f, -0.00837339f, -0.03605241f, 0.02512764f, 0.01598288f, -0.01665262f, -0.03270499f, 0.02716492f, 
    0.00875989f, 0.02810856f, 0.00202800f, 0.01727234f, 0.02071156f, -0.02205032f, -0.02885984f, -0.00790413f, 
    -0.00415033f, -0.03012123f, 0.00029441f, -0.01965151f, 0.01872795f, -0.00679087f, -0.02935956f, -0.03989579f, 
    -0.00838905f, 0.01227951f, -0.01812380f, -0.02295431f, 0.01464788f, -0.01764390f, 0.02435866f, -0.01678649f, 
    -0.03370884f, -0.03418427f, -0.02906173f, -0.03424263f, 0.02389829f, 0.01178247f, 0.01302969f, -0.02787174f, 
    0.01890733f, -0.02032976f, 0.00476071f, -0.04061170f, -0.00754760f, -0.00622653f, 0.00852373f, 0.02033550f, 
    0.02861810f, 0.01291498f, -0.00022670f, -0.00842799f, -0.01606668f, 0.02815348f, -0.02658487f, -0.01797644f, 
    -0.01207258f, -0.00584569f, -0.00650600f, -0.03970236f, 0.01848961f, -0.01393743f, -0.00711393f, -0.03853729f, 
    -0.04187029f, -0.02994039f, -0.04018902f, -0.03211946f, -0.04100918f, -0.00531082f, -0.00068271f, -0.03162005f, 
    -0.03542812f, -0.02398406f, -0.02170633f, -0.01774651f, -0.00753627f, -0.00704897f, -0.00069991f, -0.00319027f, 
    0.00159593f, 0.02851022f, -0.02083875f, 0.02830637f, -0.01690927f, -0.02732974f, -0.00516076f, 0.02482724f, 
    0.02640980f, -0.01765661f, 0.02798242f, -0.03102829f, 0.02600623f, 0.00242117f, 0.02235575f, -0.00771352f, 
    0.01756056f, -0.03012689f, -0.02187937f, 0.01793318f, -0.03646696f, 0.00737711f, -0.03986279f, 0.00321803f, 
    -0.02988987f, -0.01589924f, -0.03449576f, 0.01803277f, -0.00667203f, -0.00801612f, -0.01793486f, -0.01817735f, 
    0.01461469f, -0.02681027f, 0.01090452f, 0.01136541f, 0.02142462f, 0.02060347f, -0.01213937f, 0.02195446f, 
    0.02014006f, -0.00018555f, 0.00710268f, -0.00963772f, 0.02628436f, 0.01282363f, -0.00056356f, -0.04152200f, 
    -0.00940098f, 0.01496891f, 0.01989375f, -0.01475796f, -0.02856503f, -0.01026464f, 0.01855265f, -0.03226979f, 
    -0.03726621f, 0.02662876f, -0.01445249f, -0.01103480f, 0.00426208f, -0.00756308f, -0.02028976f, -0.03421021f, 
    -0.03167395f, 0.00628257f, -0.00679770f, 0.01511955f, 0.01100030f, -0.01379670f, -0.02101034f, -0.01903828f, 
    0.01568847f, 0.01414983f, -0.03228367f, -0.01106834f, -0.01224901f, -0.04097600f, -0.03709487f, -0.02737730f, 
    0.00265802f, 0.01887275f, 0.01524579f, -0.03792700f, -0.01481292f, -0.03448433f, 0.00072406f, 0.01159294f, 
    -0.01567662f, -0.03231875f, 0.00918676f, -0.02948933f, 0.01487024f, 0.02618906f, -0.01050199f, -0.00064602f, 
    0.01818017f, 0.02480880f, -0.02749285f, -0.00561869f, -0.02953313f, -0.03332732f, 0.01673658f, -0.02428248f, 
    -0.00185427f, 0.02622243f, -0.01509574f, -0.01252179f, -0.01908712f, 0.02039748f, -0.01692469f, -0.03737020f, 
    -0.00255028f, 0.00364412f, -0.00208178f, -0.00580520f, 0.02160015f, 0.02590047f, -0.02657450f, 0.02579039f, 
    -0.02575965f, -0.01626212f, 0.00501527f, 0.00030051f, -0.02539288f, 0.01671529f, -0.04080220f, -0.00200371f, 
    -0.03692574f, 0.01672691f, 0.00975584f, -0.01175477f, -0.02445719f, 0.02310445f, -0.03660850f, -0.02458000f, 
    0.02961291f, -0.02433814f, -0.00945602f, -0.02537364f, 0.00971952f, -0.00376816f, 0.01061537f, -0.02690701f, 
    0.00621517f, -0.02253177f, 0.00842035f, -0.02316598f, 0.02350442f, -0.03980601f, 0.02937945f, -0.02613383f, 
    0.02485015f, -0.04189267f, 0.02082764f, -0.04017457f, 0.02422431f, 0.02287377f, -0.03388310f, 0.01276964f, 
    0.02937429f, 0.00289779f, 0.00835180f, 0.00843617f, 0.02281965f, -0.00639107f, -0.03038215f, 0.00786955f, 
    0.00416710f, 0.01053697f, -0.03894110f, -0.01918546f, -0.02232970f, -0.03132741f, 0.03217040f, -0.01190578f, 
    0.01572443f, -0.02265961f, -0.02676357f, -0.01990926f, -0.00120037f, -0.00937857f, -0.01919597f, 0.00285555f, 
    0.01860132f, -0.01307523f, -0.01371424f, -0.01483340f, -0.03425297f, 0.02441306f, -0.01787709f, 0.01706294f, 
    0.00783241f, 0.01613858f, 0.02456115f, -0.03270251f, 0.01353022f, -0.01007322f, -0.02189616f, -0.01976408f, 
    -0.00568743f, 0.01174133f, 0.00281936f, -0.03210517f, -0.00525048f, 0.02084653f, -0.00278173f, 0.01478043f, 
    -0.02914200f, -0.01628470f, -0.02015749f, -0.03276377f, -0.00533624f, 0.02242764f, -0.00178621f, 0.02999670f, 
    -0.01271084f, 0.02911363f, -0.03565829f, -0.00592211f, -0.00208893f, 0.01090592f, 0.00137588f, -0.03390386f, 
    0.02582908f, -0.02196316f, -0.00806372f, 0.02326120f, -0.04047221f, -0.02916673f, -0.01327859f, 0.01693748f, 
    0.01382944f, 0.01995457f, 0.00369288f, -0.01171988f, 0.01762021f, -0.02838323f, -0.02144719f, 0.00930810f, 
    -0.01082666f, -0.03256236f, 0.00704647f, -0.02294166f, 0.01381283f, -0.03730116f, -0.02414841f, 0.00058578f, 
    0.01914326f, -0.00069063f, 0.02531108f, 0.01920089f, 0.02623833f, -0.01780041f, 0.02232427f, 0.01335784f, 
    -0.00244919f, -0.02636820f, 0.02621492f, -0.01341363f, -0.02528123f, -0.01467615f, -0.00797359f, 0.02250947f, 
    -0.00733111f, 0.00608725f, -0.02568971f, 0.02418979f, 0.02353679f, 0.02666694f, -0.00049686f, -0.03019759f, 
    0.02135093f, -0.00417008f, -0.01341752f, 0.01861209f, 0.02427171f, 0.01314802f, -0.00038092f, -0.00674108f, 
    -0.01687277f, -0.02522273f, -0.01334040f, 0.00486933f, -0.00621289f, 0.00879945f, -0.01773465f, -0.03497658f, 
    -0.02700311f, -0.01261696f, 0.00714663f, 0.00747101f, -0.00719903f, -0.02892721f, 0.01286292f, 0.00030553f, 
    -0.00888711f, -0.01447679f, -0.02619222f, 0.02754317f, 0.01448543f, -0.03989644f, -0.02613387f, -0.03116107f, 
    0.00102738f, 0.00691030f, 0.00586046f, -0.00257816f, -0.01633609f, -0.03858148f, -0.01661679f, -0.01717250f, 
    -0.02201254f, 0.02790252f, 0.00763752f, 0.00966313f, -0.03594219f, -0.01036291f, 0.00613994f, 0.01444784f, 
    -0.00193488f, 0.02790268f, 0.02701697f, 0.00145502f, -0.00726678f, 0.00892644f, -0.02218228f, -0.03581373f, 
    -0.02443259f, -0.02062463f, 0.02966708f, 0.00603987f, -0.03681044f, 0.01699608f, -0.02300309f, 0.00865869f, 
    -0.03677065f, -0.00906809f, 0.02701479f, -0.01878308f, 0.02496306f, 0.02846590f, -0.00563638f, -0.03289478f, 
    -0.00506651f, -0.01605224f, 0.00149247f, -0.02956871f, 0.00387526f, -0.00304413f, -0.03394455f, -0.01353992f, 
    -0.00438836f, -0.03718381f, -0.01548420f, -0.02480003f, 0.01312064f, -0.00629587f, -0.04159304f, 0.01624109f, 
    0.02274536f, -0.02561902f, 0.01576516f, -0.00679496f, -0.01808143f, -0.03297346f, -0.03734881f, -0.03999371f, 
    -0.01826297f, -0.01552475f, -0.02083216f, 0.01719906f, 0.00260393f, 0.01428669f, 0.00984477f, 0.01710659f, 
    0.01227429f, 0.00008103f, -0.00053086f, 0.00147458f, -0.01726326f, -0.00062597f, 0.02831054f, -0.02290292f, 
    -0.02624455f, -0.04107106f, -0.01651353f, 0.01704931f, 0.01342391f, -0.02320285f, 0.01046062f, -0.03047709f, 
    0.00066489f, 0.01001383f, 0.00126068f, -0.02153999f, -0.01472220f, 0.02464786f, -0.02710290f, -0.03389461f, 
    0.00176892f, -0.03268032f, -0.01779971f, 0.00444747f, -0.01063929f, 0.02235486f, 0.02568132f, 0.01251283f, 
    -0.04069693f, -0.01221208f, 0.01616731f, -0.03441442f, -0.00311960f, -0.03636964f, -0.01778984f, 0.02646129f, 
    -0.01804620f, 0.02544695f, -0.03402092f, -0.02310567f, 0.02015730f, -0.04010340f, -0.03105192f, -0.02524979f, 
    0.00217729f, -0.02917547f, 0.02984131f, 0.02947883f, -0.03599598f, 0.01308977f, 0.00825912f, -0.01284716f, 
    -0.03541190f, 0.00357124f, -0.01317400f, -0.00742656f, -0.04015464f, -0.00021729f, 0.00525769f, -0.00307918f, 
    0.00716276f, -0.02764393f, -0.03258583f, 0.00308588f, 0.03785159f, 0.02977218f, -0.00407896f, -0.03752055f, 
    -0.03167075f, -0.03971153f, 0.03890401f, 0.01292161f, 0.00224190f, -0.00833741f, -0.03542206f, 0.02310482f, 
    -0.00547995f, -0.03666417f, -0.02665957f, -0.02079402f, -0.03813124f, 0.02744091f, -0.02257039f, 0.00414439f, 
    -0.02055574f, -0.01206419f, -0.02653766f, -0.00629564f, -0.00034828f, -0.01906469f, -0.03424647f, 0.03000447f, 
    0.00373364f, 0.02746214f, 0.00490052f, 0.01666893f, -0.01671130f, -0.03239845f, 0.02592121f, 0.02734497f, 
    -0.01714153f, -0.03252355f, -0.03501105f, -0.01870159f, -0.00822148f, -0.03806300f, 0.00607063f, 0.03322528f, 
    -0.03291422f, -0.00930951f, 0.01321747f, -0.02945658f, -0.02208069f, 0.03000926f, -0.04194066f, 0.01052368f, 
    -0.03180608f, -0.03042024f, -0.01823497f, -0.01809059f, 0.00282230f, -0.01412281f, -0.01333874f, -0.01321459f, 
    0.00387760f, -0.03476606f, 0.00519971f, -0.00552064f, -0.01625694f, 0.01024286f, 0.01662510f, -0.03932346f, 
    -0.01801499f, -0.01877298f, 0.00977517f, -0.00805934f, -0.00537551f, -0.03041099f, -0.03011999f, 0.01546227f, 
    -0.03731814f, 0.00417645f, -0.02085850f, -0.03433267f, 0.00799393f, 0.02409944f, 0.02440473f, -0.03447149f, 
    0.02007680f, -0.03701754f, -0.01416140f, 0.00675909f, 0.00462331f, -0.01685030f, 0.01457095f, -0.00845766f, 
    0.01920027f, 0.00328714f, -0.03723327f, -0.02605440f, -0.01004520f, -0.03703730f, 0.01807053f, 0.00449788f, 
    0.01201825f, -0.02757578f, 0.03883445f, 0.00642765f, -0.00809791f, 0.00022465f, -0.00504053f, 0.02643793f, 
    -0.02785346f, 0.02886566f, 0.00690339f, -0.01566667f, 0.00956775f, 0.00853603f, 0.02850546f, -0.02106513f, 
    -0.03907499f, 0.00312425f, -0.00345109f, 0.02910097f, -0.00979499f, -0.03732570f, -0.03600730f, -0.01802060f, 
    0.02848964f, -0.03253896f, 0.02851641f, 0.00294750f, 0.00601456f, 0.01008573f, 0.02845337f, -0.03025509f, 
    -0.03474702f, -0.03506511f, -0.02002325f, -0.03788592f, 0.01803780f, -0.03590675f, 0.00611216f, -0.03746809f, 
    0.02818039f, 0.01869974f, 0.00243987f, 0.02945569f, -0.01328649f, 0.00612289f, -0.01827088f, 0.00649842f, 
    -0.03735226f, 0.02630714f, 0.02607776f, 0.01842785f, -0.03114405f, -0.03488233f, -0.04088772f, -0.03040980f, 
    0.00497068f, -0.02735550f, 0.01065307f, 0.00399149f, -0.01101334f, 0.02707862f, 0.00657640f, 0.01441414f, 
    0.01410885f, -0.02971181f, -0.03372769f, 0.02759009f, 0.02210934f, -0.02511414f, -0.04204183f, 0.02095815f, 
    -0.02768677f, -0.00862024f, -0.04138341f, 0.00612329f, -0.03784728f, 0.00920688f, -0.01563313f, 0.01796618f, 
    0.03030203f, 0.01420267f, 0.00121626f, -0.03000109f, -0.01099506f, -0.02198778f, 0.02157589f, -0.01211354f, 
    0.01291357f, 0.01478307f, -0.01712088f, -0.00018610f, 0.02406354f, -0.03280845f, 0.01654000f, 0.01521120f, 
    0.01101773f, -0.00327364f, -0.00421977f, -0.00348608f, -0.02726035f, -0.00192961f, 0.01672966f, 0.01611151f, 
    -0.00809878f, -0.03473296f, -0.03806828f, -0.03292215f, -0.01237694f, -0.01971097f, -0.03721742f, -0.00648224f, 
    -0.01713587f, 0.02341394f, -0.01334983f, 0.00901326f, -0.00872752f, -0.01352320f, -0.02260081f, -0.00855900f, 
    0.02816789f, -0.01694162f, 0.01350688f, 0.01720068f, 0.01047214f, -0.02659510f, 0.01141706f, -0.03581888f, 
    0.02637454f, -0.03037922f, 0.01435884f, -0.00553705f, -0.01945292f, 0.00860064f, -0.01536896f, 0.01948891f, 
    -0.03455945f, 0.02778556f, -0.00132916f, -0.02328450f, -0.02616345f, 0.01630124f, -0.01497131f, -0.00783167f, 
    0.01201213f, 0.01486604f, -0.02303568f, -0.02198597f, -0.01524034f, 0.00310390f, 0.02693112f, -0.03512264f, 
    0.01832219f, -0.00860699f, -0.03506153f, -0.00339434f, -0.02011272f, -0.01536586f, -0.00538071f, -0.03931700f, 
    0.00342394f, -0.01932873f, 0.01720041f, 0.00726354f, -0.00993219f, 0.02949126f, 0.01737704f, -0.00864168f, 
    -0.00365538f, 0.02951592f, -0.01585064f, 0.02514632f, 0.01302258f, 0.00569243f, 0.00921707f, -0.01270923f, 
    0.02720770f, -0.02428754f, -0.00032044f, 0.02830603f, -0.01931655f, 0.00482976f, -0.00495935f, 0.02030624f, 
    -0.02564754f, 0.02979276f, -0.02787668f, 0.01191707f, 0.01981056f, 0.02492790f, 0.01365518f, 0.00682567f, 
    0.00758866f, -0.02997344f, -0.01258370f, -0.03504005f, 0.00440090f, 0.02254313f, -0.02378422f, -0.00270353f, 
    -0.00106696f, -0.01674241f, 0.01646949f, 0.01678677f, 0.00159985f, -0.00994202f, 0.01327203f, -0.03635060f, 
    -0.02340486f, -0.02894531f, 0.02165772f, 0.01898350f, 0.03205530f, 0.02770790f, -0.02282201f, 0.01447589f, 
    -0.00519844f, -0.02920049f, -0.02777749f, -0.01449888f, -0.04062557f, 0.00202439f, -0.02856564f, 0.00858448f, 
    -0.00061952f, -0.03050177f, -0.02922638f, -0.01338963f, 0.01450205f, 0.01277358f, -0.02680794f, -0.02783813f, 
    0.01050497f, 0.01191574f, -0.02743979f, 0.02430685f, 0.01633009f, 0.03041591f, -0.03310182f, -0.00734849f, 
    0.00125664f, -0.00946851f, 0.01310249f, 0.03032705f, 0.01827038f, -0.01433815f, -0.03240185f, 0.00726149f, 
    0.02244380f, -0.01124608f, -0.00570807f, 0.01233071f, -0.03759169f, 0.03719380f, -0.00490876f, -0.02244144f, 
    0.00988706f, 0.02474805f, 0.02632793f, 0.00345969f, 0.01363905f, -0.01123825f, -0.03034733f, -0.02128270f, 
    -0.00593693f, 0.01002645f, 0.00542261f, -0.01974713f, 0.00941545f, -0.02367838f, -0.03709598f, 0.00589037f, 
    0.00725922f, 0.00596845f, -0.02993696f, -0.01365496f, -0.00500860f, -0.01390537f, -0.00505829f, -0.01868453f, 
    -0.02669500f, -0.01800709f, -0.03549162f, -0.02901712f, -0.01771601f, -0.00407436f, -0.01816177f, 0.02205366f, 
    -0.02604054f, -0.01792613f, 0.01241595f, -0.03988823f, 0.00035089f, 0.03453644f, -0.02430166f, -0.01588021f, 
    0.02916787f, 0.02172704f, -0.02634648f, -0.00980556f, -0.00854705f, 0.00400246f, -0.02299003f, -0.02202663f, 
    -0.01910361f, 0.02580967f, 0.02241647f, -0.03360657f, -0.01150630f, -0.01414594f, 0.02758805f, 0.02531555f, 
    -0.02815930f, -0.02679088f, -0.02856510f, -0.01181313f, 0.02303796f, 0.01381468f, -0.01644351f, -0.03489801f, 
    0.01174676f, -0.01824342f, -0.03098994f, -0.00749831f, 0.02196173f, 0.03156821f, 0.01324003f, -0.03706291f, 
    0.02007190f, 0.00582584f, -0.01508752f, 0.02029946f, -0.03354621f, -0.01904623f, -0.03089879f, 0.00610409f, 
    -0.00883726f, -0.00372236f, -0.02240355f, -0.03619639f, 0.00244787f, 0.02661230f, 0.00058883f, 0.00928157f, 
    -0.00056052f, -0.00614925f, -0.02521742f, 0.02751093f, -0.02807358f, -0.01952407f, -0.03037253f, 0.02705447f, 
    -0.01795691f, -0.01003321f, -0.03504191f, 0.02653622f, -0.00438714f, -0.00345185f, -0.03367558f, -0.02865674f, 
    0.02408668f, 0.02371469f, 0.03018427f, 0.00079000f, -0.02219293f, -0.02846480f, 0.02174206f, 0.00621079f, 
    -0.01592299f, -0.02648313f, -0.00005835f, 0.01508103f, -0.01308496f, -0.04169991f, 0.00164705f, 0.00798342f, 
    -0.03847245f, 0.03035504f, -0.02009531f, -0.01437033f, -0.03622912f, -0.00571445f, 0.01704709f, -0.01420531f, 
    0.02130736f, -0.02239806f, -0.00385637f, 0.02773379f, 0.00109971f, 0.02825773f, 0.02566611f, 0.03406257f, 
    -0.03305843f, 0.00026335f, -0.01623406f, 0.02451109f, 0.00364047f, -0.00082867f, -0.03849291f, -0.03751593f, 
    -0.00377894f, -0.01534009f, 0.01151259f, -0.00265067f, 0.00957539f, -0.04346426f, -0.01113964f, -0.00417737f, 
    -0.01454602f, -0.02459039f, 0.02827901f, -0.01259030f, -0.00273543f, -0.00061435f, 0.01244496f, -0.02017838f, 
    0.01013398f, 0.00515120f, -0.00779079f, -0.00013790f, 0.03036266f, -0.01963876f, -0.00546122f, -0.03270068f, 
    -0.03435788f, -0.01347502f, -0.00251495f, -0.00528251f, -0.02386761f, 0.01657597f, -0.03673492f, 0.00219630f, 
    -0.01793486f, -0.01864541f, -0.01299760f, 0.00258371f, 0.00252156f, 0.02732255f, -0.00401886f, -0.02539872f, 
    0.02426220f, -0.03466804f, 0.03321445f, -0.02395699f, 0.01951669f, -0.00707380f, -0.02314598f, 0.00950566f, 
    0.02257640f, 0.01945624f, 0.01558373f, 0.02139346f, -0.02790839f, -0.01816047f, -0.01625582f, -0.01972651f, 
    0.00926837f, 0.01423006f, -0.01246420f, 0.00262613f, 0.02353261f, 0.00429165f, -0.01564289f, -0.00607009f, 
    -0.01773666f, 0.00351713f, 0.00490482f, -0.00110723f, 0.02440740f, 0.00594016f, 0.01862281f, 0.01901228f, 
    0.01010000f, -0.02101207f, -0.00655544f, -0.02099460f, 0.01854308f, -0.02740378f, 0.00805897f, 0.00146600f, 
    0.00976900f, 0.01825757f, -0.00557471f, -0.01026129f, 0.02393616f, -0.02049873f, -0.02388180f, -0.03728328f, 
    0.02320498f, -0.01908077f, 0.00675792f, -0.02280336f, -0.01649019f, -0.01339217f, -0.01183667f, 0.02934512f, 
    0.01141369f, 0.02018726f, 0.02535942f, -0.02001489f, 0.02780919f, -0.03090770f, 0.02595435f, -0.02838680f, 
    0.00181905f, -0.02042912f, -0.02440957f, -0.00416291f, -0.01387453f, 0.01912715f, 0.02242890f, 0.00587408f, 
    0.01984640f, -0.02235050f, 0.00254074f, -0.03639320f, 0.03254522f, -0.02764988f, 0.00166836f, 0.02585811f, 
    0.02252859f, 0.00299186f, -0.02835893f, 0.03505004f, -0.01805284f, 0.02385553f, -0.04498098f, -0.02302989f, 
    0.00329685f, -0.02089834f, 0.01004538f, -0.01187529f, 0.00668087f, 0.00645130f, 0.02928558f, -0.01887979f, 
    0.02395871f, -0.00149390f, 0.02149125f, -0.03219232f, 0.00311660f, -0.01696390f, 0.01809057f, 0.01800638f, 
    0.00812460f, -0.02843550f, -0.00128123f, 0.02525414f, 0.02579108f, 0.01817466f, -0.03809293f, 0.01528259f, 
    -0.00706025f, -0.03856054f, -0.00138330f, -0.02874346f, -0.03013572f, -0.00980663f, -0.02841811f, -0.02336360f, 
    -0.03014678f, 0.02798408f, -0.04186418f, 0.01854812f, -0.00310805f, -0.00257371f, -0.00317530f, -0.03354352f, 
    -0.00496351f, 0.00375332f, -0.00104129f, -0.02921801f, 0.01581035f, -0.00735188f, -0.02824320f, 0.00438100f, 
    0.01796699f, -0.01266840f, 0.01436735f, -0.01258996f, -0.01013725f, -0.01381796f, 0.00351162f, -0.01149112f, 
    -0.04055863f, -0.01989659f, -0.03232850f, -0.04038109f, 0.00877359f, 0.02712396f, 0.02403083f, 0.01765994f, 
    0.01405219f, -0.00310801f, 0.02744847f, 0.02942674f, 0.00433948f, -0.01676930f, 0.02030725f, -0.00106727f, 
    0.03104811f, 0.00057520f, -0.01736321f, -0.03661917f, -0.01877779f, -0.01242751f, -0.00898809f, -0.03388564f, 
    -0.01445492f, -0.00613069f, -0.03140781f, -0.02511202f, -0.03556977f, 0.01903537f, 0.00303308f, 0.00138537f, 
    0.02649341f, 0.02243874f, -0.02388193f, -0.00922644f, 0.00797697f, -0.00973709f, 0.02389742f, -0.03876434f, 
    0.02834859f, -0.00685667f, 0.00946339f, 0.01948184f, -0.02908268f, 0.01720554f, -0.02992482f, 0.00028121f, 
    -0.02642181f, 0.01284854f, -0.02482264f, 0.03126952f, 0.02672681f, 0.01202273f, -0.01954950f, -0.02854059f, 
    0.00776056f, 0.02660521f, 0.01670781f, -0.01538824f, -0.00303440f, 0.02365960f, -0.03595283f, 0.00957185f, 
    -0.03777626f, -0.01931768f, 0.00858816f, 0.00000196f, -0.02003164f, 0.01720485f, -0.00625992f, 0.01130181f, 
    0.01548001f, -0.02892664f, -0.03062574f, 0.01873079f, -0.02213267f, -0.00850515f, -0.01746823f, -0.01255825f, 
    -0.01427836f, 0.01911722f, 0.00028581f, -0.02954130f, -0.00621938f, 0.01684212f, -0.03129730f, 0.00315862f, 
    -0.02129261f, 0.01312995f, 0.00785546f, -0.01586341f, -0.02262989f, 0.03025876f, 0.02904802f, -0.00619487f, 
    0.03497240f, 0.02754723f, -0.03419708f, 0.03005163f, 0.00332537f, -0.00111855f, -0.03123406f, -0.00005438f, 
    0.01414416f, 0.02631520f, -0.00664168f, -0.00391863f, -0.02002314f, -0.02800588f, -0.01020449f, -0.03324994f, 
    -0.01174321f, 0.02150442f, 0.00041111f, -0.02708078f, 0.02571990f, 0.02079776f, -0.01287562f, 0.01587056f, 
    0.00509493f, 0.00615105f, 0.01133339f, 0.00643547f, 0.00957518f, 0.00467449f, -0.01000540f, -0.02603306f, 
    0.01377607f, -0.02827676f, -0.02735767f, -0.02757938f, 0.02801018f, 0.02450458f, 0.01198793f, -0.02661216f, 
    0.02260203f, 0.02533203f, 0.03187054f, -0.02764154f, 0.01380651f, -0.01647540f, -0.01482016f, 0.00141613f, 
    0.00009734f, -0.03297658f, 0.03343760f, 0.01473223f, 0.02188831f, -0.00811325f, -0.01392455f, -0.00508937f, 
    -0.02821910f, -0.01883146f, 0.01941494f, 0.02814756f, 0.02093227f, -0.02730590f, -0.00875490f, 0.02329302f, 
    0.02312152f, -0.01686836f, -0.02171953f, -0.03499587f, 0.02123256f, 0.02745715f, -0.01201455f, 0.01858096f, 
    -0.02941459f, 0.00755207f, -0.02048918f, 0.00669131f, -0.01859099f, -0.03158795f, -0.03664289f, -0.02972975f, 
    0.03297348f, -0.00466679f, -0.00395385f, -0.01669976f, -0.01695227f, -0.01308033f, -0.00259523f, -0.00912194f, 
    0.00718296f, -0.01221675f, 0.00946351f, 0.00519520f, -0.03182270f, -0.02355233f, -0.01817365f, 0.02373159f, 
    -0.03903035f, 0.02956885f, -0.03434780f, 0.02925007f, -0.01450848f, -0.03122371f, 0.01441959f, 0.00343876f, 
    0.01174073f, 0.01153395f, 0.03189665f, 0.02983455f, 0.00354291f, -0.03728202f, -0.02357575f, 0.01364914f, 
    -0.01014912f, 0.03376522f, -0.00608284f, 0.01358254f, 0.00117730f, -0.02440871f, -0.00522980f, -0.01883199f, 
    -0.02886273f, 0.01258369f, -0.00476295f, -0.00225550f, -0.03778729f, -0.01911589f, 0.00716135f, 0.02535908f, 
    -0.02905097f, -0.02243142f, -0.00472962f, 0.00346740f, 0.01976472f, 0.01109231f, -0.02546534f, 0.00173486f, 
    0.00633113f, 0.00315598f, -0.00209309f, 0.01751126f, -0.02096078f, -0.03892528f, 0.02374225f, -0.00724829f, 
    0.03335423f, -0.02065835f, -0.02481424f, 0.03163349f, -0.02227217f, 0.01430036f, -0.01996147f, 0.02423700f, 
    -0.02258716f, 0.01233071f, -0.00070488f, 0.01534030f, -0.00531356f, -0.01108855f, 0.02798420f, 0.00325729f, 
    -0.02935179f, 0.02636354f, -0.02219237f, 0.01328731f, -0.02600007f, 0.01178114f, 0.02868829f, -0.03224856f, 
    -0.02821610f, -0.03258955f, 0.00226137f, -0.03521137f, -0.00924161f, 0.01092965f, -0.03949125f, 0.02133051f, 
    -0.02114776f, 0.00754761f, 0.00523384f, 0.03176707f, -0.02591515f, 0.02054551f, -0.02711364f, 0.01531438f, 
    0.00466616f, 0.03394486f, 0.01107090f, 0.02276511f, -0.03230901f, 0.00687385f, -0.03242071f, 0.01836109f, 
    0.01758319f, 0.00103261f, 0.00357568f, -0.00651602f, 0.02096977f, 0.03117134f, -0.00054623f, -0.00149281f, 
    0.02536512f, -0.00327992f, -0.02849517f, -0.00065738f, -0.02190742f, -0.02988460f, -0.02329712f, 0.00988502f, 
    0.01143062f, -0.01224559f, -0.03360159f, -0.04269131f, -0.01554574f, 0.02451836f, 0.00161403f, 0.01192247f, 
    0.01829526f, 0.02402807f, -0.00491257f, 0.03995655f, 0.00087523f, 0.01223398f, 0.01247450f, -0.02997786f, 
    -0.03567150f, -0.01941185f, 0.00575302f, 0.00198252f, -0.03602413f, 0.00628338f, -0.03324133f, 0.00710678f, 
    0.02370991f, 0.01458257f, -0.01034135f, 0.02804247f, 0.02310481f, -0.00374003f, -0.01151288f, 0.01282794f, 
    0.02420652f, 0.01795376f, -0.00659653f, 0.00020895f, 0.00852627f, 0.00493956f, -0.02229611f, -0.01579215f, 
    -0.00461050f, -0.03132219f, -0.00729962f, 0.00226298f, 0.01477534f, -0.00334912f, 0.00202668f, 0.00597457f, 
    0.00824550f, -0.02331398f, -0.01902694f, -0.01754538f, 0.02601383f, -0.03498966f, -0.00291819f, 0.00947176f, 
    -0.01265774f, -0.02118418f, 0.00725603f, -0.01698521f, 0.01982967f, 0.02711429f, -0.02733513f, -0.01677484f, 
    -0.03236624f, 0.00465637f, -0.00150897f, 0.01383154f, -0.04146103f, -0.02608900f, 0.02431745f, -0.00035336f, 
    0.02193656f, -0.00887146f, -0.03244371f, -0.01745774f, -0.02411371f, -0.03898184f, -0.02971443f, -0.01309572f, 
    -0.02103298f, -0.03012170f, 0.01466289f, 0.02329491f, 0.00862688f, 0.02636318f, -0.00621702f, 0.01622130f, 
    0.02213147f, -0.01474470f, 0.01031353f, -0.02427825f, -0.02599099f, 0.00265745f, 0.02129428f, -0.03941384f, 
    0.02306071f, -0.01390785f, -0.00547424f, -0.01182320f, -0.01313686f, 0.00947550f, -0.01952412f, -0.02403937f, 
    0.02654999f, 0.09331013f, -0.03946472f, -0.01198892f, 0.04350340f, 0.06203987f, -0.06839466f, 0.04447496f, 
    0.00542821f, 0.05421211f, 0.11367586f, 0.16193877f, 0.31339967f, 0.20146877f, -0.09037203f, 0.07778254f, 
    0.06504065f, 0.05547130f, -0.16342363f, 0.01343998f, 0.08044560f, 0.06423062f, -0.05107376f, 0.10973693f, 
    0.48948765f, -0.16476166f, 0.02575427f, 0.25403166f, -0.01510695f, 0.06167816f, -0.04263680f, -0.03047945f, 
    -0.02507257f, -0.06828266f, 0.05670785f, 0.01519651f, -0.00946522f, -0.00359831f, 0.05661003f, -0.04640106f, 
    -0.04625472f, 0.20092773f, 0.03095282f, -0.05479417f, 0.08106946f, -0.05953998f, 0.05456871f, 0.11704445f, 
    0.08048900f, 0.06016732f, 0.11743709f, -0.05229354f, 0.03169398f, 0.07091170f, 0.05663648f, -0.01773129f, 
    0.04654445f, -0.05075697f, 0.01790455f, -0.01251740f, -0.09136782f, 0.05433530f, 0.10494807f, -0.04272507f, 
    0.03937696f, 0.05677387f, 0.01494925f, 0.01555814f, 0.00171460f, -0.00967949f, 0.09832750f, -0.02904420f, 
    -0.06703886f, 0.00127427f, -0.07251263f, 0.04374211f, 0.10223571f, 0.02907369f, 0.12894826f, 0.02255951f, 
    0.01415869f, 0.12275217f, 0.01816646f, -0.04762729f, 0.09756122f, 0.02870680f, -0.04594428f, 0.24482489f, 
    0.05349709f, 0.04892095f, 0.01564071f, 0.04285334f, -0.03905419f, 0.02614342f, 0.00384013f, -0.00522753f, 
    0.06737176f, -0.00204705f, 0.10713177f, 0.00829860f, -0.00383902f, 0.11411020f, 0.01715486f, 0.12074723f, 
    0.07442066f, 0.13739203f, -0.04823481f, 0.03451309f, -0.17665628f, 0.13793916f, -0.08653152f, -0.14867328f, 
    0.13897933f, 0.11565594f, 0.00287948f, -0.00546177f, 0.02093670f, 0.00665870f, 0.00093377f, 0.14335696f, 
    0.13494225f, 0.03360694f, 0.06559961f, -0.22922213f, 0.16286527f, 0.07368669f, 0.08060323f, 0.12548850f, 
    0.06574892f, -0.00982461f, -0.05057339f, 0.09322339f, 0.16554570f, 0.33019960f, -0.19469140f, -0.04702805f, 
    0.08991648f, 0.09298661f, 0.00541714f, -0.00370690f, -0.04574420f, -0.01562596f, 0.07600278f, 0.05068631f, 
    -0.09465296f, 0.03217104f, 0.05958423f, -0.16118550f, -0.03441245f, 0.10791164f, -0.00624267f, 0.00130892f, 
    0.01425550f, -0.06422424f, 0.01788961f, 0.04329873f, 0.06831105f, 0.05732128f, -0.19406612f, -0.15059149f, 
    0.01243981f, 0.01107624f, 0.00828191f, -0.00266691f, -0.13264184f, -0.07315252f, 0.04579112f, -0.09013573f, 
    -0.02064367f, -0.06173342f, -0.03957270f, -0.23808843f, -0.06104977f, -0.03937437f, 0.04243154f, 0.04864962f, 
    -0.03653593f, 0.01456761f, -0.05051139f, -0.11543721f, 0.28923818f, 0.06960274f, 0.03149635f, 0.13424709f, 
    -0.06050769f, -0.11491507f, 0.00909783f, 0.08093394f, 0.07876554f, 0.06197266f, 0.13368802f, 0.05430334f, 
    -0.08974982f, 0.02153093f, -0.06475333f, 0.02647920f, -0.09828280f, 0.05772761f, -0.11439434f, 0.03203058f, 
    -0.04659988f, 0.13535994f, -0.07677433f, 0.08962653f, -0.03932568f, -0.17687169f, 0.09445133f, 0.15504657f, 
    0.04663400f, 0.11754595f, 0.07356597f, 0.12510784f, 0.07942067f, 0.11309002f, 0.12818375f, 0.13155146f, 
    -0.19685805f, -0.04203723f, 0.01351560f, -0.07048163f, -0.09487524f, 0.01927418f, -0.03019208f, -0.06540596f, 
    0.07444427f, 0.01801825f, -0.04243573f, -0.04740138f, -0.00886136f, -0.15826537f, 0.07600232f, 0.08756619f, 
    0.03521656f, 0.06537509f, 0.03379830f, 0.02279719f, 0.07575732f, -0.08264311f, -0.06806719f, -0.17360599f, 
    -0.06644242f, 0.18366905f, -0.02992463f, 0.16743158f, -0.01382488f, 0.05487125f, -0.17999241f, 0.04539642f, 
    0.03327531f, -0.02647966f, 0.02786217f, 0.09313352f, -0.19661656f, -0.07335120f, 0.14673661f, 0.21247557f, 
    0.03605237f, -0.00633835f, 0.08217184f, 0.06588031f, 0.10416273f, -0.01966348f, 0.13095035f, 0.15369074f, 
    0.12455510f, -0.07372359f, 0.09463449f, 0.02132825f, 0.08377474f, 0.09452023f, 0.08377372f, -0.07908350f, 
    0.09204335f, -0.04578969f, 0.05829650f, 0.19742265f, 0.00226254f, -0.03851295f, -0.10180524f, 0.00366193f, 
    0.04133392f, 0.05916664f, -0.08274868f, 0.23618919f, 0.04334353f, 0.02752005f, -0.01540138f, -0.03557620f, 
    -0.13125822f, -0.03887798f, 0.04503285f, 0.00078311f, -0.03201532f, -0.08807383f, -0.01980629f, 0.00245802f, 
    -0.00587007f, 0.12552360f, -0.00595761f, 0.14437647f, 0.35586378f, 0.15389740f, 0.13184050f, 0.18408597f, 
    -0.08552054f, -0.06282380f, 0.07914984f, 0.06644756f, 0.03075646f, 0.04131074f, -0.01650963f, -0.05141406f, 
    -0.11263963f, -0.12324069f, -0.12802570f, -0.06517807f, 0.06310823f, 0.15939970f, -0.07861684f, 0.06053248f, 
    0.10864190f, -0.11181533f, 0.13835409f, -0.02876892f, -0.38082132f, 0.01811219f, 0.03597913f, 0.11874595f, 
    0.05043955f, -0.05936093f, 0.07583281f, 0.00965987f, -0.06609928f, 0.07699792f, 0.05579079f, -0.01060786f, 
    0.46064457f, 0.13250349f, -0.02857554f, 0.15549524f, 0.04302463f, 0.00015700f, 0.10871617f, 0.03812373f, 
    -0.09479119f, -0.12057926f, -0.01178193f, -0.03810014f, -0.03425242f, 0.05367256f, -0.15066591f, -0.19277707f, 
    0.06839228f, 0.01786644f, 0.11974987f, 0.00597180f, 0.04218221f, 0.03692680f, 0.04829030f, 0.21299103f, 
    0.16568474f, 0.14921956f, 0.02543736f, 0.11785592f, -0.07281605f, -0.03972847f, 0.16173525f, -0.01487060f, 
    -0.01924496f, 0.10833599f, 0.06075209f, 0.02621276f, 0.10398885f, 0.03029421f, -0.00956380f, 0.23880121f, 
    0.02893929f, -0.16641852f, -0.04548223f, 0.04363671f, -0.02755199f, -0.00251928f, -0.04640438f, 0.20749225f, 
    0.10768594f, 0.13604483f, 0.24660948f, -0.02724962f, -0.02420705f, 0.14085442f, 0.07131017f, 0.04535950f, 
    -0.11806640f, -0.02717774f, 0.14123964f, 0.00990069f, -0.01061265f, 0.22896340f, -0.02717859f, -0.21643786f, 
    0.04422756f, 0.10146676f, 0.08023497f, 0.03434517f, 0.01712946f, 0.08898466f, 0.00813300f, 0.06567530f, 
    -0.38522610f, -0.02284881f, 0.04321678f, 0.02750414f, 0.14458752f, -0.03974741f, -0.10298627f, 0.07888186f, 
    0.00731682f, 0.10579863f, 0.08465011f, -0.06912952f, 0.22735980f, 0.02498312f, -0.01357518f, 0.22390956f, 
    0.02285140f, 0.02167271f, -0.06127258f, -0.02198567f, -0.00590618f, -0.10357665f, -0.02747475f, 0.26197004f, 
    0.08957804f, 0.21068415f, -0.03514345f, 0.02576363f, 0.06848051f, -0.01715806f, -0.00288602f, -0.00281908f, 
    0.11475065f, -0.03991868f, -0.05189177f, -0.02990277f, 0.07644513f, -0.05692018f, -0.00475078f, 0.07587921f, 
    -0.03270218f, -0.09223400f, 0.04491020f, 0.00872314f, -0.09779365f, -0.09012413f, -0.09022208f, -0.01376355f, 
    -0.08290930f, -0.04226619f, -0.00832933f, -0.03008550f, 0.06968491f, -0.04003788f, -0.04908980f, 0.05532122f, 
    0.03120536f, 0.09111328f, -0.11181063f, -0.19047594f, 0.12713471f, -0.03155202f, 0.16762444f, 0.14097530f, 
    0.03503824f, -0.02393946f, 0.01166262f, 0.12582274f, -0.07251022f, -0.00801059f, 0.07199860f, 0.08754348f, 
    0.26327541f, 0.01822061f, 0.07313345f, -0.04718672f, -0.00187701f, -0.01513956f, -0.00013144f, 0.08788408f, 
    0.07414736f, 0.09232107f, -0.09037073f, 0.16021952f, 0.12021764f, -0.13283223f, -0.03625640f, 0.08671752f, 
    0.02722483f, 0.05540393f, -0.00575618f, 0.12110174f, 0.02068025f, 0.05193667f, 0.09755499f, 0.04306920f, 
    -0.10599033f, 0.02675015f, 0.14568864f, 0.08846879f, 0.02042890f, 0.01404084f, -0.05035795f, 0.03513660f, 
    -0.07623437f, -0.01706028f, 0.00823199f, -0.14047134f, 0.14734551f, 0.09089456f, -0.22645234f, -0.10592267f, 
    0.06137946f, -0.01993127f, -0.05159073f, -0.00119732f, -0.01634353f, 0.02491804f, 0.11245786f, -0.01114180f, 
    0.21432871f, -0.00778235f, 0.03013144f, 0.18506642f, 0.00883384f, 0.21444434f, 0.07544978f, 0.06034585f, 
    -0.06101584f, 0.02940642f, -0.05332965f, 0.04893305f, 0.08321504f, -0.09828146f, 0.01733571f, 0.03857215f, 
    0.06249687f, 0.00820275f, 0.00442203f, 0.10905842f, -0.08452291f, 0.08511063f, 0.01917750f, -0.14238906f, 
    0.25598934f, -0.10689548f, 0.08329550f, 0.04213351f, 0.04756743f, 0.01045072f, 0.12943721f, 0.08918253f, 
    0.01632825f, 0.06912714f, 0.01818638f, -0.10722965f, -0.02947537f, 0.08228928f, -0.20238133f, -0.06501944f, 
    -0.07940348f, 0.08831660f, 0.04161631f, -0.02143188f, -0.01042646f, 0.02139672f, -0.15696101f, 0.11130357f, 
    -0.01240313f, 0.03797443f, 0.08344498f, 0.26436251f, -0.05927114f, 0.06059304f, 0.05973244f, 0.08150405f, 
    0.19628222f, 0.13355416f, 0.02838298f, 0.03242951f, 0.14696419f, 0.19531220f, 0.01643417f, 0.09695901f, 
    -0.16028465f, 0.05719190f, 0.03079364f, 0.08075321f, -0.00059852f, 0.12598115f, 0.23782748f, -0.00511477f, 
    0.05677101f, -0.06961134f, 0.11106046f, -0.12386865f, -0.00332028f, -0.02310663f, 0.04915923f, 0.09220459f, 
    0.07219630f, 0.10194530f, -0.05389092f, -0.03419939f, 0.06663709f, 0.06017601f, 0.07569341f, -0.01472693f, 
    0.02208072f, 0.09012957f, 0.05702968f, -0.03619978f, 0.09420040f, -0.03368218f, 0.14005193f, 0.10442314f, 
    0.07157382f, -0.18163915f, 0.00240380f, 0.15475550f, 0.05646706f, -0.20951523f, 0.13337128f, 0.11540924f, 
    -0.06818713f, 0.13334757f, 0.15287521f, -0.07908910f, 0.30516347f, -0.14418706f, 0.11250685f, 0.14827566f, 
    0.00027866f, 0.13289694f, -0.00644311f, -0.08047676f, -0.07653312f, 0.05024508f, 0.07382354f, 0.11163530f, 
    -0.26112792f, -0.05716787f, -0.06987172f, -0.04719085f, 0.12120838f, 0.01415028f, 0.09303802f, 0.04089240f, 
    0.14440726f, 0.07295207f, -0.04247456f, -0.03545992f, 0.26855841f, 0.22937132f, -0.09942642f, 0.19477583f, 
    -0.01749181f, -0.01713461f, 0.19752464f, 0.05366522f, 0.13469081f, -0.00056003f, -0.01785232f, 0.02618312f, 
    -0.08388671f, 0.05161475f, -0.08011533f, -0.13048582f, 0.07529912f, -0.01810288f, 0.00139780f, 0.07872157f, 
    -0.01539359f, 0.05556839f, -0.05024287f, 0.01198302f, 0.17942078f, 0.02540120f, -0.03666869f, 0.04969202f, 
    0.06004276f, -0.01547003f, -0.00586207f, -0.02508987f, 0.05476755f, -0.03722151f, -0.09962473f, 0.11660336f, 
    0.31777978f, 0.14225817f, -0.03042216f, 0.07340057f, -0.02658027f, 0.01080619f, -0.02109065f, 0.06714182f, 
    0.08036171f, 0.00944038f, 0.07603674f, 0.04650454f, -0.00682705f, -0.14850485f, 0.06650320f, 0.15757757f, 
    0.02821488f, 0.05967486f, 0.07382596f, 0.05143346f, -0.02080111f, -0.00020713f, -0.00141572f, 0.01280696f, 
    -0.13502398f, 0.06501231f, -0.04736289f, 0.03778882f, 0.10500192f, 0.02981092f, 0.03722963f, -0.00740058f, 
    0.04073562f, -0.05302019f, -0.09257770f, -0.09211686f, 0.17887801f, -0.08867043f, -0.03410036f, -0.02382932f, 
    -0.01310497f, 0.11138280f, 0.04505613f, -0.05041067f, 0.03421105f, 0.03487323f, 0.01798675f, 0.03485777f, 
    -0.04408685f, 0.04323247f, 0.14582157f, -0.10760581f, -0.04040421f, 0.11534973f, -0.03343511f, 0.04004954f, 
    -0.04235246f, 0.08422275f, -0.06891188f, 0.07516070f, 0.09405027f, -0.05201956f, -0.09586397f, 0.23737800f, 
    0.04102504f, 0.06794088f, 0.06828420f, 0.10618915f, 0.22990865f, 0.03763052f, 0.26072454f, 0.06177209f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02265409f, -0.03309921f, -0.06784567f, 0.02370974f, 0.08088312f, -0.00682082f, -0.02565832f, 0.02847605f, 
    0.00908361f, -0.01481870f, 0.01800085f, 0.01012260f, 0.03424647f, 0.00114302f, -0.04745456f, -0.02369284f, 
    -0.01425315f, 0.02074414f, 0.07244688f, 0.02824124f, 0.02331451f, 0.01024665f, -0.03223952f, 0.00357812f, 
    0.02499632f, -0.03169825f, 0.06573117f, -0.02983729f, 0.00067733f, -0.03419417f, 0.02116784f, 0.08217017f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.03955982f, 0.32605764f, 0.38768974f, -0.14834344f, -0.02510808f, 0.14389455f, -0.31832719f, 0.07642146f, 
    0.07031263f, 0.01600060f, 0.08149513f, 0.00299314f, -0.03126760f, 0.02405752f, 0.42076933f, -0.05016040f, 
    0.11825678f, -0.01885414f, -0.02028351f, 0.06269897f, 0.02184944f, -0.02924246f, 0.10223291f, 0.15567702f, 
    0.02358793f, -0.04460015f, -0.51933670f, -0.55068028f, -0.02507588f, 0.09144945f, 0.09188896f, -0.25664353f, 
    0.27837113f, 0.24164394f, -0.38858303f, -0.00858527f, -0.25922906f, -0.17366348f, -0.29564661f, 0.00500363f, 
    0.02098242f, 0.11509198f, 0.07461450f, -0.16432056f, 0.34484610f, -0.16934742f, -0.05630287f, -0.00062001f, 
    0.13520521f, 0.13809124f, -0.14134219f, -0.05798450f, -0.23254791f, 0.37917507f, 0.05654719f, -0.01148966f, 
    -0.05173457f, 0.09905565f, 0.23745333f, -0.48146129f, 0.07590394f, 0.16893776f, 0.02108536f, 0.06277339f, 
    0.12773709f, 0.30388090f, -0.11612333f, -0.05763622f, -0.55680186f, 0.11712212f, -0.29571655f, -0.07810958f, 
    0.13814883f, -0.07330377f, 0.10540845f, -0.06086113f, -0.01950205f, -0.09000422f, 0.24718334f, -0.06929197f, 
    -0.16504833f, -0.10688898f, 0.05872950f, 0.00744293f, -0.47603843f, -0.60626006f, -0.16899121f, -0.00021227f, 
    -0.15575221f, -0.10704258f, 0.41313604f, 0.17842515f, -0.08213484f, 0.10075898f, -0.10702195f, -0.03021882f, 
    -0.50304663f, -0.61382610f, -0.08556976f, 0.14101593f, 0.09321365f, 0.00949140f, -0.21363793f, -0.02523503f, 
    -0.01582804f, -0.06000951f, 0.02774693f, -0.05496126f, -0.21045163f, -0.02738248f, 0.28239480f, 0.10275737f, 
    0.08119070f, 0.06945786f, -0.11761406f, -0.16516994f, -0.25943658f, 0.56346428f, 0.14009641f, -0.08689541f, 
    -0.17571767f, 0.03585517f, -0.24497344f, 0.29272947f, 0.14888938f, 0.13771774f, -0.01463255f, 0.16560887f, 
    0.02419445f, -0.01152642f, -0.04667617f, -0.00310046f, 0.31525710f, 0.10587215f, -0.10380608f, 0.14873628f, 
    0.11561076f, 0.03822572f, 0.11280684f, -0.15681767f, -0.72501016f, -0.03711650f, 0.26727378f, 0.14882715f, 
    0.06538897f, -0.04983091f, -0.09342186f, 0.13772182f, 0.06563006f, -0.01583852f, -0.04673303f, 0.01951936f, 
    0.15010017f, -0.13919576f, 0.30514973f, -0.42863137f, -0.09123897f, 0.15990385f, -0.06778410f, 0.09939227f, 
    0.00491039f, 0.12458230f, 0.24182606f, 0.11222466f, 0.27967712f, 0.09453136f, 0.14963484f, -0.15247752f, 
    0.15158680f, 0.03207849f, -0.15358225f, 0.02965953f, 0.20085378f, -0.10716927f, -0.75709713f, 0.12695359f, 
    0.05648760f, 0.16668853f, -0.03031412f, 0.15899988f, 0.00665739f, 0.23330346f, -0.01998027f, 0.03936643f, 
    0.03012646f, -0.10664714f, 0.07959424f, -0.32757202f, 0.04811440f, 0.02363768f, 0.14855102f, -0.27513024f, 
    -0.22461556f, -0.00755505f, -0.66585541f, 0.05274843f, -0.16492654f, 0.09179855f, 0.56912506f, -0.16849189f, 
    0.08446015f, -0.09554248f, -0.14822015f, -0.11134661f, -0.19001886f, -0.04349861f, 0.05267702f, -0.11632162f, 
    0.06426012f, 0.00378080f, 0.21238872f, -0.13125582f, 0.20950790f, -0.29491538f, 0.01682339f, -0.04896704f, 
    0.09152544f, 0.08472253f, -0.24253000f, -0.04058185f, -0.08853716f, -0.14459886f, -0.04339379f, -0.03783454f, 
    0.08489900f, -0.24254002f, 0.28992069f, -0.11940079f, 0.22921813f, -0.01232370f, 0.28704992f, 0.00852529f, 
    -0.13112287f, 0.06721731f, -0.08049413f, -0.05200858f, 0.11041607f, -0.05981929f, 0.13030922f, -0.17370850f, 
    -0.16971277f, 0.06600264f, -0.44999328f, 0.08769141f, -0.18019253f, -0.55128062f, -0.17509474f, -0.05084415f, 
    -0.09097483f, 0.11547186f, -0.23867746f, 0.04039950f, 0.09865778f, 0.04276405f, -0.09228133f, 0.12475249f, 
    0.30595362f, -0.17285833f, 0.22035733f, -0.01048982f, -0.51296598f, -0.03080858f, 0.01767017f, -0.06748505f, 
    -0.03028443f, -0.15737967f, 0.15011001f, -0.16360056f, 0.11872391f, -0.08411291f, 0.13896847f, -0.04086566f, 
    -0.11788765f, 0.06895739f, -0.00206146f, -0.04043453f, 0.19193561f, 0.04225472f, -0.02529330f, 0.13240978f, 
    -0.08718371f, 0.01623272f, 0.18090592f, 0.27896845f, -0.16339122f, -0.11273465f, 0.07937909f, -0.52935320f, 
    -0.53039247f, 0.07721000f, 0.45870548f, 0.11118414f, -0.15339614f, -0.02907304f, -0.14202391f, -0.17990229f, 
    0.06640101f, 0.12833744f, 0.13589288f, -0.14726329f, -0.50170213f, 0.06133074f, -0.35590327f, -0.14602298f, 
    0.11756486f, 0.00120791f, 0.28010726f, -0.00580685f, -0.17803352f, -0.37182730f, -0.03724302f, 0.06780531f, 
    0.00045210f, 0.12615886f, -0.07932075f, 0.22938818f, -0.14561564f, 0.04425182f, -0.15862809f, 0.12860709f, 
    0.40688744f, -0.42011672f, -0.46838933f, -0.17655048f, 0.21115179f, 0.13067928f, -0.38043627f, -0.15300439f, 
    0.08323247f, 0.06147605f, -0.06904701f, 0.03669120f, 0.19195326f, 0.08121729f, 0.03863524f, -0.05305034f, 
    -0.05414338f, -0.06813618f, 0.28386229f, -0.05375813f, -0.62996411f, -0.26045367f, -0.11753841f, 0.05779529f, 
    0.05685968f, 0.09480264f, -0.10125837f, -0.03171584f, -0.10028091f, -0.14558090f, 0.04921263f, 0.12962684f, 
    -0.33326203f, -0.25043610f, -0.30806050f, 0.04092930f, -0.00027083f, -0.13142139f, -0.43260700f, -0.00365970f, 
    0.01347557f, 0.14591961f, 0.13534488f, -0.13803178f, 0.37097183f, 0.04894936f, 0.01229286f, 0.10921262f, 
    -0.06232131f, -0.13547239f, -0.07859793f, -0.03150596f, 0.51113206f, -0.30481791f, -0.08837234f, 0.11528709f, 
    -0.02232081f, -0.10213578f, 0.13639344f, 0.06876285f, 0.02186057f, -0.07014183f, -0.08001986f, 0.09097008f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.11293790f, 0.05940675f, 0.05666478f, -0.08390750f, -0.03804564f, -0.03323726f, 0.10733873f, -0.21490483f, 
    -0.16581644f, 0.18055840f, 0.04101731f, -0.04619902f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
