#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.92454451f, -0.20101912f, 0.21565083f, 0.40194190f, 0.61208302f, -0.07835869f, -0.01551527f, 0.55958825f, 
    0.24104947f, 0.41616890f, 0.20469928f, 0.05390618f, 0.33903527f, 0.13089366f, -0.08661500f, 0.21645454f, 
    -0.07520249f, -0.25811327f, -0.46801171f, 0.37802109f, 0.37048665f, -0.08985739f, 0.11307208f, -0.09327259f, 
    0.39040717f, -0.47458830f, -0.43257138f, -0.14523751f, -0.31467155f, -0.09257443f, -0.20162123f, -0.35065910f, 
    -0.41413736f, -0.18730901f, 0.09653352f, 0.02204887f, 0.01152813f, -0.25421411f, -0.19322488f, 0.07534260f, 
    0.09912105f, -0.05321661f, 0.11325398f, 0.08102711f, -0.34735721f, 0.26241758f, -0.17450389f, 0.21756700f, 
    0.33671796f, 0.46490890f, -0.96286047f, -0.19489585f, 0.19494258f, -0.86042035f, -0.22927247f, -0.00211999f, 
    -0.27568412f, -0.74478996f, -0.04349568f, -0.33318564f, -0.14896035f, -0.15894471f, -0.26600254f, -0.67967200f, 
    -0.42584616f, -0.10147996f, -0.13086863f, -0.20206845f, 0.14014041f, 0.03454173f, 0.04128819f, 0.22324753f, 
    0.09161513f, -0.26217553f, -0.23379715f, -0.46426377f, 0.69243187f, 0.58152193f, -0.64780945f, 0.43062046f, 
    -0.80926895f, -0.36758775f, 0.21951383f, 0.56240821f, -0.14426734f, -0.16625105f, -0.21111310f, 0.20047668f, 
    0.24558134f, -0.07333242f, 0.40118062f, -0.18102483f, -0.04075326f, -0.23922013f, -0.29690838f, -0.23900749f, 
    -0.01322868f, 0.22998151f, 0.15635276f, 0.02867385f, 0.38202322f, 0.50455058f, 0.87362021f, -0.73394465f, 
    -0.88299394f, -0.17738873f, 0.12653980f, 0.49355683f, -0.36714739f, -0.27566734f, -0.17596287f, -0.06899660f, 
    0.40415606f, 0.15059368f, -0.12982707f, 0.28089318f, -0.13455169f, -0.30620328f, 0.17730635f, -0.55837399f, 
    0.21006769f, -0.04491380f, -0.07753588f, 0.03381377f, 0.13854478f, -0.67381394f, -0.52951807f, -0.36247382f, 
    -0.10421396f, -0.26333046f, 0.25039372f, -0.38792580f, -0.61938721f, -0.57582605f, -0.24054229f, 0.22070129f, 
    0.24620372f, 0.30340123f, 0.72922683f, 0.26162946f, 0.02722588f, -0.37764990f, 0.02094411f, -0.47201708f, 
    -0.22788610f, -0.04405366f, 0.47133261f, -0.11843113f, -0.05027305f, 0.06686459f, 0.97354847f, -1.27385223f, 
    0.16904476f, -0.39154896f, -0.61173230f, -0.23558645f, 0.19125538f, 0.47502014f, -0.13338219f, -0.26365018f, 
    -0.13724518f, -0.39720938f, -0.32759908f, -0.09577437f, 0.00806263f, -0.02896287f, -0.23106384f, -0.23240152f, 
    0.14967239f, -0.12521014f, -0.33099613f, -0.02143732f, -0.03588246f, 0.08064454f, -0.33966696f, -0.87644678f, 
    -0.60368711f, -0.33516482f, -0.03479026f, -0.43003914f, 0.56578398f, -0.01703738f, 0.10278910f, 0.58618093f, 
    0.73195601f, 0.13017106f, 0.00413884f, -0.35257050f, 0.11451011f, -0.10476044f, -0.20935364f, -0.17902997f, 
    -0.06931669f, -0.19084451f, -0.21421856f, -0.07973024f, -0.00921580f, 0.04254442f, 0.01749019f, -0.29745078f, 
    0.27599797f, -0.20463374f, 0.18956983f, -0.09122062f, 0.73490238f, -0.15396084f, -0.15893014f, -0.25793970f, 
    -0.37405404f, -0.34620509f, -0.26902735f, -0.05839442f, 0.25606897f, -0.52293664f, 0.31314045f, 0.10921737f, 
    -0.20646288f, -0.04908248f, 0.38004392f, 0.11828228f, -0.08438382f, 0.05182070f, -0.05995028f, 0.07039887f, 
    0.66954029f, -0.45609805f, 0.11917753f, 0.45911303f, 0.37020430f, 0.13962391f, -0.16736948f, 0.07862812f, 
    0.25347993f, -0.31967863f, -0.12577091f, 0.02268405f, 0.16507643f, 0.04036515f, -0.10083576f, -0.17409733f, 
    -0.48376095f, -0.19991936f, -0.08908821f, -0.16216080f, 0.06480103f, 0.23076826f, 0.18706916f, 0.41361287f, 
    0.31188786f, -0.00992993f, 0.56918192f, 0.11621745f, 0.44916868f, 0.01570474f, 0.31102383f, 0.08312781f, 
    0.21836734f, 0.41814342f, 0.11944737f, 0.17822340f, 0.02830436f, 0.38550782f, -0.35188556f, -0.50822794f, 
    0.19219549f, -0.05303909f, 0.28912580f, 0.01247101f, -0.12774691f, 0.02682217f, -0.36817458f, 0.23199631f, 
    -0.14029229f, -0.27652505f, -0.28930938f, 0.52268159f, 0.88168824f, 0.12990005f, -0.47641775f, -0.35903177f, 
    -0.11708550f, -0.34105501f, -0.20495172f, -0.17917837f, 0.32627493f, 0.13558246f, -0.18520163f, -0.34733728f, 
    -0.38540351f, -0.05579583f, 0.09792905f, 0.54056460f, 0.03558890f, 0.28581902f, -0.44843519f, -0.46053398f, 
    0.30788794f, -0.14442463f, -0.15894796f, -0.10194735f, 0.28304082f, -0.58772963f, -0.86822790f, -0.10517171f, 
    0.17486426f, 0.32171294f, 0.63083160f, 0.07687842f, -0.32654762f, -0.22545612f, 0.43021244f, -0.12976229f, 
    0.37409571f, -0.24731331f, 0.01128115f, -0.04701314f, -0.09248259f, 0.05642346f, 0.09382706f, -0.23081034f, 
    0.04549559f, -0.10178377f, 0.24579138f, 0.12418529f, 0.09577387f, -0.27348658f, 1.05360782f, 0.67030871f, 
    -0.05328798f, -0.19948098f, 0.12206135f, -0.49450061f, 0.14178324f, -0.04430473f, -0.30776659f, -0.26698929f, 
    -0.14394768f, 0.04157165f, -0.18862155f, -0.09001163f, 0.07525018f, -0.09757517f, -0.23976845f, -0.01983098f, 
    0.27636880f, -0.18941218f, 0.04981804f, -0.15591218f, 0.11551096f, -0.10489906f, 0.54511899f, -0.37088069f, 
    -0.41215023f, -0.52224219f, -0.70646775f, 0.29695576f, 0.42131481f, -0.18824762f, -0.32421178f, 0.26527858f, 
    -0.00380102f, -0.06182647f, 0.08609962f, 0.19912481f, 0.28883600f, 0.23345162f, 0.07726744f, -0.00316622f, 
    -0.04825841f, -0.34617341f, -0.27972114f, -0.36507964f, -0.24400346f, 0.02593920f, -0.05903777f, 1.15546393f, 
    -0.33082175f, -0.72022188f, -0.76490760f, -0.95382905f, 0.19781800f, 0.13949448f, 0.45565781f, 0.18183823f, 
    0.24857682f, -0.07226457f, 0.55095160f, -0.35306385f, -0.37670162f, -0.11928651f, -0.13124616f, -0.07167634f, 
    0.27013704f, -0.00808974f, -0.08036034f, 0.14936303f, -0.00995122f, -0.17323171f, 0.00399155f, 0.27683881f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14878511f, -0.20254216f, -0.24176648f, 0.17847811f, 0.37194413f, 0.01689431f, 0.36793974f, -0.10339187f, 
    0.03014305f, 0.09431355f, -0.17094308f, 0.33605215f, 0.08258536f, 0.28463823f, 0.18330707f, 0.09878591f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03210612f, 0.04037551f, 0.03653195f, -0.02194138f, -0.00757390f, -0.00217858f, 0.03070301f, -0.06977306f, 
    0.01437230f, -0.07349227f, -0.05891581f, -0.06342474f, -0.00165258f, -0.06436741f, 0.04683702f, -0.06840955f, 
    -0.04602379f, 0.06123950f, -0.00466110f, -0.02410989f, 0.01077206f, -0.05679546f, -0.01485076f, -0.05008556f, 
    -0.04113469f, -0.07312062f, -0.05833296f, -0.07346278f, -0.03291465f, 0.04513552f, -0.05051599f, 0.05478339f, 
    -0.04450164f, -0.02038219f, -0.06120760f, 0.02361926f, -0.04426183f, -0.07237692f, 0.00882284f, -0.06196114f, 
    -0.02038165f, 0.01176226f, 0.03288798f, 0.06331376f, -0.03737276f, -0.07656631f, 0.01381269f, 0.00201091f, 
    0.00228286f, -0.04255670f, 0.02821865f, -0.05769619f, -0.07073525f, -0.04896857f, -0.07601520f, -0.01720160f, 
    0.05019654f, -0.07739519f, -0.01221806f, 0.04708392f, 0.04609712f, 0.04274778f, -0.06564257f, -0.03394336f, 
    -0.07006617f, 0.03462890f, 0.06054356f, -0.00947795f, 0.05684666f, 0.00696764f, 0.05448092f, -0.00738798f, 
    0.05051916f, 0.04460506f, 0.01844316f, -0.05497720f, -0.04984719f, 0.05963677f, 0.00217109f, 0.05375540f, 
    -0.00910451f, -0.01369256f, 0.00610737f, 0.01852907f, -0.07102485f, 0.00945099f, -0.07545125f, 0.06343550f, 
    0.04073793f, 0.03061968f, 0.00315238f, 0.03471508f, -0.02090352f, 0.05675703f, -0.07730392f, -0.04161454f, 
    0.04901115f, -0.07499238f, -0.07421415f, -0.01022563f, 0.01533497f, 0.02754069f, 0.06164030f, -0.00830860f, 
    -0.03797936f, 0.06132586f, -0.07166994f, -0.04692161f, 0.04842447f, 0.05345943f, 0.02543084f, 0.03824390f, 
    0.03668361f, -0.04787650f, 0.03812120f, -0.07616964f, 0.03585390f, 0.05377496f, -0.06976302f, 0.03979792f, 
    -0.06867517f, -0.05987589f, 0.04494747f, -0.01748553f, 0.04395163f, -0.02556033f, 0.01119586f, -0.05484283f, 
    -0.04514516f, 0.01145705f, -0.02282129f, -0.01018151f, -0.02245788f, -0.00661664f, -0.04510107f, -0.07281157f, 
    0.03549866f, -0.01673283f, 0.00527012f, -0.02505633f, -0.06236222f, -0.02467184f, -0.00961093f, 0.00899050f, 
    0.06116540f, -0.07830294f, -0.05236220f, -0.06125335f, -0.07562704f, 0.00139520f, -0.04160576f, 0.01251140f, 
    0.00565397f, 0.05975163f, 0.06420439f, -0.01420375f, -0.04593889f, 0.05573502f, 0.05472012f, -0.05165142f, 
    -0.02129290f, -0.04270277f, 0.05426842f, -0.04593163f, 0.05284534f, 0.02597447f, -0.05091192f, -0.01735259f, 
    -0.03325250f, -0.02765249f, -0.04913756f, -0.04461595f, -0.07835273f, -0.06127523f, 0.03367255f, 0.00810050f, 
    0.04017862f, -0.02902299f, -0.03585044f, -0.04374155f, 0.02350796f, -0.04206100f, -0.03760491f, -0.03508125f, 
    0.01999740f, 0.02698230f, -0.00466403f, 0.02157595f, 0.00578570f, -0.07248653f, -0.05984956f, -0.05963529f, 
    -0.13518411f, 0.03976390f, 0.15628906f, 0.09696905f, 0.08228407f, -0.06605399f, -0.13729295f, 0.07701009f, 
    -0.05324925f, 0.00205376f, 0.09120158f, -0.20042147f, -0.22450355f, -0.40504435f, -0.28704521f, -0.22914942f, 
    0.10475710f, -0.12447108f, 0.08433428f, -0.08109013f, -0.09418971f, -0.01728714f, -0.14618689f, -0.13245618f, 
    -0.15893316f, -0.37045908f, -0.09672278f, -0.22066702f, 0.15567033f, 0.31694424f, -0.05220395f, -0.16074334f, 
    -0.05604433f, -0.00880085f, 0.04601163f, 0.02715440f, 0.13441555f, 0.02909554f, -0.00846259f, -0.13641201f, 
    0.00154273f, 0.22723211f, 0.10800803f, 0.05568620f, -0.19946890f, -0.02349224f, -0.03530205f, -0.02164220f, 
    0.39777973f, 0.13458540f, 0.15355590f, -0.33456728f, 0.08510258f, 0.00593647f, 0.16258061f, -0.08562776f, 
    0.06049209f, 0.12688306f, 0.12003977f, 0.07249721f, -0.14743170f, -0.08195934f, -0.24062034f, -0.16035539f, 
    -0.03075902f, -0.12885512f, -0.04636131f, -0.05964440f, 0.02675361f, 0.09698495f, 0.06467234f, 0.04268251f, 
    -0.21806611f, 0.15494183f, 0.05035758f, -0.01589137f, 0.24085531f, 0.13002880f, 0.12652802f, -0.02841991f, 
    0.15465426f, 0.01894250f, 0.25323516f, 0.04437241f, -0.07019080f, 0.13596682f, 0.19672756f, 0.38014430f, 
    0.02819896f, -0.11183175f, 0.00003379f, -0.04665530f, 0.02225736f, 0.17716217f, 0.06336160f, 0.09325564f, 
    -0.36299685f, -0.15307844f, -0.07854574f, 0.28184044f, 0.17423551f, 0.01062797f, 0.05847597f, 0.11799927f, 
    -0.11202650f, -0.20655042f, 0.03181870f, -0.01179458f, -0.19750778f, 0.17104198f, -0.02594406f, -0.05562664f, 
    0.17225589f, 0.08916848f, -0.14481708f, -0.02443134f, -0.14960892f, -0.13982134f, -0.08857472f, -0.10155412f, 
    0.05436231f, 0.21133608f, -0.22376919f, -0.04590492f, -0.12802972f, 0.03741778f, 0.01671136f, 0.12046735f, 
    -0.06343935f, 0.12465440f, 0.20466998f, 0.14165710f, 0.35270244f, -0.00720622f, 0.01168320f, -0.17002381f, 
    -0.11070656f, 0.14967360f, 0.08164755f, 0.15786973f, 0.02538528f, 0.27042034f, 0.17045681f, 0.01101072f, 
    -0.25287321f, 0.33286664f, 0.09590509f, 0.02053448f, 0.01209371f, -0.15398736f, -0.13198261f, 0.03083616f, 
    -0.10309406f, -0.04129152f, -0.01371512f, -0.12157086f, -0.10542846f, 0.07727624f, 0.39769822f, -0.05249109f, 
    0.05746609f, 0.12087648f, 0.03083133f, -0.09265881f, 0.14063379f, 0.04916016f, 0.08957903f, 0.18637444f, 
    0.08501749f, 0.34366164f, 0.04750742f, -0.19350724f, -0.05825975f, 0.02530093f, 0.13469274f, 0.12865375f, 
    0.07815217f, 0.03999421f, 0.07502390f, 0.09046435f, 0.02073930f, 0.39198548f, -0.09404664f, 0.40251708f, 
    0.10389838f, -0.02333067f, 0.12927744f, -0.04817717f, 0.16186953f, 0.18618950f, 0.09430804f, -0.00869215f, 
    0.13744669f, 0.15474495f, -0.29376721f, -0.52469736f, -0.05186022f, 0.05504625f, -0.23340595f, -0.12320889f, 
    0.01613238f, 0.01014144f, -0.28043923f, -0.06789089f, 0.01365068f, 0.09432073f, 0.02182473f, 0.37088409f, 
    -0.08974869f, -0.04845129f, 0.04196758f, -0.01937777f, -0.17846155f, 0.16148897f, -0.18798378f, -0.24191593f, 
    -0.04086730f, -0.08591857f, 0.11244974f, 0.23186193f, 0.14790203f, 0.02838030f, 0.08194707f, -0.15130934f, 
    0.14463960f, -0.05616907f, 0.12134776f, -0.00753898f, -0.01095773f, -0.08295567f, 0.06741989f, 0.11961350f, 
    0.09589767f, 0.18983127f, -0.14175481f, -0.19298305f, -0.15083055f, -0.09384172f, 0.00064974f, -0.12291824f, 
    -0.11252441f, 0.38372222f, -0.11685177f, 0.08902431f, 0.24907103f, 0.00481245f, -0.11936956f, -0.24101754f, 
    -0.02510847f, -0.03015556f, 0.08876604f, 0.07150927f, 0.17408000f, -0.02088552f, 0.27195862f, 0.20702703f, 
    0.08497264f, -0.17995258f, -0.04231941f, 0.16318907f, 0.18372519f, 0.04223223f, -0.06739570f, -0.05084353f, 
    -0.28185713f, 0.23782496f, 0.05136270f, 0.22889985f, 0.02965929f, 0.19783168f, 0.09294622f, -0.00578692f, 
    0.00856021f, 0.00870490f, 0.12296272f, 0.07882399f, -0.00381878f, 0.01439943f, 0.10837060f, 0.27480394f, 
    0.07417349f, 0.04491387f, 0.24735355f, 0.01035372f, 0.17338595f, -0.13679299f, 0.13175607f, 0.32776728f, 
    -0.09073922f, 0.00010146f, 0.32991529f, 0.01076484f, 0.26104444f, -0.07890764f, -0.22249910f, 0.17509083f, 
    -0.25906062f, -0.31928191f, -0.53746295f, -0.68834239f, 0.14448598f, 0.23025623f, -0.24368536f, -0.24690166f, 
    0.12887470f, -0.26193383f, 0.05379095f, -0.30151385f, -0.34269449f, -0.27492103f, -0.19963996f, -0.29421711f, 
    -0.01898596f, -0.12962376f, -0.08932228f, 0.02322179f, 0.20865728f, 0.00571636f, 0.03966803f, -0.14556585f, 
    0.08983567f, 0.09491315f, 0.09418493f, 0.29125941f, 0.13678686f, -0.01371448f, 0.04485509f, 0.14836927f, 
    0.08406463f, -0.00658277f, 0.03645284f, 0.06049438f, -0.02040364f, 0.03835306f, 0.18944475f, -0.05216391f, 
    -0.04378606f, -0.09664722f, 0.10655218f, 0.02251518f, -0.06215065f, -0.08446976f, 0.00354754f, -0.04587043f, 
    0.01231233f, -0.15074256f, 0.00268450f, -0.47334483f, 0.50017989f, 0.35991901f, 0.19516830f, -0.00090876f, 
    0.15961146f, -0.09988794f, -0.12634477f, -0.03604572f, -0.02854233f, 0.02578909f, 0.01908758f, -0.10099132f, 
    -0.21184607f, 0.18284491f, -0.13677247f, 0.10636809f, -0.00097436f, 0.25827900f, 0.04657429f, 0.03114310f, 
    0.03004009f, -0.01579877f, -0.05199217f, 0.29576671f, -0.33968687f, 0.14612308f, -0.01730951f, 0.37773785f, 
    -0.00944724f, 0.19107170f, 0.06320542f, -0.08640719f, -0.03439439f, 0.18968770f, 0.03436067f, 0.02384138f, 
    -0.08664234f, 0.04148500f, -0.04913996f, -0.27691615f, 0.05948107f, -0.00207181f, 0.03750962f, 0.04438250f, 
    -0.11447178f, -0.03293309f, -0.14840667f, 0.02668904f, 0.31434569f, 0.41137770f, 0.26162562f, -0.02129356f, 
    0.09977020f, 0.12958434f, -0.16589142f, -0.01457370f, -0.03846758f, 0.04383867f, -0.07362502f, 0.06167302f, 
    0.46727976f, 0.32773671f, 0.11603755f, 0.02362763f, -0.05741757f, 0.05705183f, 0.11674199f, 0.32795766f, 
    0.08550733f, -0.05034177f, -0.07430523f, 0.08791932f, 0.29047981f, -0.05919520f, 0.29358831f, 0.15736008f, 
    -0.00032449f, -0.04152040f, -0.08457312f, -0.02508049f, 0.09535272f, 0.08695926f, 0.01577786f, -0.03988177f, 
    -0.13853194f, -0.24255896f, 0.12394721f, 0.42139199f, -0.20692846f, 0.19731140f, -0.03615542f, -0.14832780f, 
    -0.17978521f, 0.06589448f, -0.00044798f, -0.01806526f, 0.32534486f, 0.06820983f, 0.03810353f, 0.01848085f, 
    0.06045704f, 0.07593829f, 0.03626284f, 0.14023925f, 0.12444729f, -0.00737522f, 0.01761128f, -0.03518322f, 
    0.07024904f, 0.07100567f, 0.00984551f, 0.14644641f, -0.16233161f, -0.07609858f, 0.19714175f, 0.01722241f, 
    -0.15409534f, 0.08009027f, -0.02598195f, 0.20637727f, 0.36505449f, -0.20631178f, 0.19821928f, -0.28761652f, 
    0.31045905f, 0.11579264f, 0.10754684f, -0.09172277f, 0.05672966f, 0.20529383f, -0.01329490f, 0.06829651f, 
    0.11363059f, 0.18742087f, -0.13755020f, -0.01254384f, -0.09753551f, -0.05114244f, -0.37461230f, -0.22512656f, 
    0.09256988f, 0.00623338f, -0.19083989f, -0.13785301f, -0.01345701f, 0.24052708f, 0.22731762f, 0.14929971f, 
    0.08599898f, -0.08325331f, 0.02359662f, -0.03676450f, -0.05921127f, -0.05548863f, -0.14010563f, -0.03696915f, 
    -0.06973001f, -0.24477382f, 0.01521143f, 0.08757929f, 0.06156373f, 0.11844623f, -0.06186472f, -0.01251229f, 
    0.02000800f, 0.06886967f, 0.00278047f, -0.06490180f, -0.38754669f, 0.14478657f, 0.24178110f, 0.03545259f, 
    -0.00176047f, 0.09383337f, -0.15540607f, 0.02880683f, -0.06698239f, -0.06480348f, -0.05857415f, 0.08073906f, 
    0.21166287f, 0.32657674f, -0.41964051f, -0.00955922f, 0.18938179f, 0.08861469f, 0.13897479f, -0.21332844f, 
    0.05475566f, -0.10659520f, -0.00688439f, -0.20827577f, -0.15821001f, 0.00018622f, 0.04985964f, 0.04847110f, 
    0.09715491f, -0.11496872f, -0.02853306f, 0.08735923f, 0.06135663f, 0.00406407f, -0.05041012f, 0.10256673f, 
    -0.05228113f, -0.19250222f, -0.09174614f, 0.28638017f, -0.01517350f, 0.12266244f, -0.00791188f, -0.03458490f, 
    0.05096052f, -0.01526611f, -0.11354948f, 0.11879880f, 0.07958261f, -0.25138649f, -0.16279054f, 0.05338680f, 
    0.02346004f, -0.02396334f, -0.04922311f, 0.00561237f, -0.09160056f, 0.04662229f, 0.03276372f, 0.07603049f, 
    -0.24389444f, -0.31803575f, 0.03225132f, 0.05247860f, 0.17979884f, -0.03643034f, -0.03553224f, -0.02645445f, 
    0.12385976f, -0.06076308f, 0.22139756f, 0.11083191f, -0.05863480f, 0.07664722f, 0.14372538f, -0.18843149f, 
    0.06234521f, -0.02134021f, 0.07648291f, 0.04913556f, 0.08380126f, -0.00660349f, -0.09087627f, -0.02726270f, 
    -0.08486132f, 0.19369137f, 0.13414598f, 0.02655215f, -0.07919610f, -0.04461439f, 0.15150240f, -0.12351154f, 
    -0.00466297f, 0.00106193f, -0.06256326f, -0.00398234f, 0.10939189f, -0.24855246f, 0.30183801f, -0.07930563f, 
    0.22233543f, 0.10588564f, 0.31689498f, 0.19218233f, -0.03497230f, 0.12930058f, -0.06635962f, 0.04922133f, 
    -0.04374007f, -0.34113398f, 0.26765785f, -0.18547870f, 0.09009969f, 0.19191220f, 0.22300074f, 0.07213489f, 
    0.02716084f, 0.04083555f, 0.13614663f, -0.08587521f, -0.23727940f, 0.31550696f, 0.05357187f, 0.06753329f, 
    -0.06504147f, 0.02104468f, 0.08069795f, -0.14094816f, -0.06234387f, -0.16103046f, -0.05067378f, -0.10506460f, 
    0.61520422f, -0.13732393f, 0.30117628f, -0.03264797f, 0.07183794f, 0.07355443f, -0.01357123f, 0.28953317f, 
    0.02349349f, -0.01862942f, 0.02993448f, -0.19970179f, -0.57862383f, -0.06829082f, -0.33149874f, -0.07227173f, 
    -0.10374667f, -0.14283961f, -0.16527227f, -0.06072347f, -0.02717107f, -0.14799491f, 0.03753411f, -0.05123813f, 
    0.23786750f, 0.03939059f, -0.01112388f, -0.04435042f, 0.05034281f, 0.24895658f, 0.00865006f, -0.03393738f, 
    0.00629146f, 0.13428643f, 0.12114575f, 0.18634875f, 0.09890106f, -0.09938766f, 0.10728276f, 0.01792118f, 
    -0.24072914f, -0.04797060f, -0.03028473f, 0.00558270f, 0.18550666f, 0.01516298f, -0.01589192f, 0.08033099f, 
    0.04789270f, 0.14307581f, 0.05836124f, 0.11310944f, -0.22980617f, -0.11724244f, -0.20782013f, -0.03536783f, 
    -0.10890634f, 0.00462349f, -0.19165219f, -0.14314941f, 0.23869653f, 0.36798766f, 0.35110018f, -0.01967406f, 
    0.08387591f, -0.08681972f, 0.08470568f, 0.11513040f, -0.08632775f, -0.01307838f, 0.06280332f, -0.10421687f, 
    -0.32816491f, -0.25590631f, -0.17069304f, 0.11706619f, -0.11394793f, 0.25275987f, 0.14980605f, 0.15137848f, 
    -0.02168917f, 0.04435425f, 0.06881318f, 0.11160792f, 0.24145508f, 0.05152582f, 0.25622624f, 0.14268161f, 
    -0.01593438f, -0.08059692f, 0.12211668f, 0.07845167f, -0.25244102f, -0.18714873f, -0.12242136f, 0.07933085f, 
    -0.15924485f, 0.07570520f, -0.07807692f, -0.16149057f, -0.12000003f, -0.04803348f, -0.13514781f, 0.11695586f, 
    -0.00329284f, -0.03670966f, -0.04813736f, -0.19398291f, 0.21015845f, -0.26256609f, -0.00048101f, -0.10296965f, 
    -0.00624134f, 0.03445372f, -0.11041038f, 0.22287448f, -0.05223502f, -0.06710655f, 0.05124737f, -0.06526025f, 
    0.06350467f, -0.22200321f, -0.08677646f, -0.06712095f, 0.20225364f, -0.16925120f, -0.04731127f, 0.10893053f, 
    0.18631597f, 0.15886210f, 0.26620433f, 0.10695922f, -0.14025579f, -0.10879170f, 0.15208972f, -0.14950149f, 
    0.14174487f, 0.15567651f, 0.07066847f, 0.02122422f, 0.09844165f, -0.19129539f, -0.07568990f, 0.02261969f, 
    0.08520028f, 0.25391364f, 0.34841833f, -0.02831839f, -0.11118091f, 0.07533232f, 0.18511754f, 0.02416492f, 
    -0.04472059f, -0.00499266f, -0.02119339f, 0.02864128f, 0.39227709f, -0.25087693f, 0.32411122f, 0.13636304f, 
    0.13680719f, -0.10252265f, 0.12945920f, -0.12789673f, 0.09753353f, 0.08824328f, -0.00047670f, 0.12083918f, 
    -0.04943672f, 0.10480432f, -0.03984544f, 0.23705953f, 0.26117533f, 0.18507352f, 0.01489765f, 0.15315750f, 
    0.08925360f, 0.09224191f, 0.04642851f, -0.06196796f, 0.00529383f, -0.05458516f, 0.04015368f, -0.28036326f, 
    0.07316437f, 0.05092289f, 0.03112771f, -0.10061912f, 0.08861288f, -0.17660356f, -0.08799134f, -0.05728490f, 
    0.52039164f, 0.15860687f, 0.05872092f, 0.02206329f, 0.02888420f, 0.09294903f, 0.16846269f, -0.02893931f, 
    0.12774904f, 0.03408104f, 0.01306569f, -0.13721709f, -0.52752113f, -0.52988261f, -0.00980678f, -0.04635813f, 
    0.16875651f, -0.02474547f, -0.04987890f, 0.07320709f, -0.01248748f, -0.05358990f, 0.09067801f, -0.04071719f, 
    -0.02982363f, 0.09647645f, -0.17212328f, 0.07917786f, 0.10130633f, 0.32936159f, -0.07623504f, -0.11069352f, 
    0.13065293f, 0.16393298f, -0.03182048f, 0.23312004f, 0.14032510f, 0.03020156f, -0.05877601f, 0.02832583f, 
    -0.20369753f, -0.00541316f, 0.02179676f, -0.05294903f, 0.09745307f, 0.02790927f, -0.12615632f, -0.13156597f, 
    -0.10596139f, 0.00334865f, -0.15615742f, 0.16677426f, 0.00660613f, 0.04965312f, -0.28995845f, -0.06432620f, 
    -0.10737392f, -0.04425777f, -0.14675660f, 0.13943340f, 0.00445506f, 0.20968881f, 0.41699496f, 0.00045949f, 
    0.16515587f, 0.07249544f, -0.04815545f, 0.41202575f, 0.03584653f, -0.08048885f, 0.22269849f, 0.01096368f, 
    -0.40424752f, 0.20306724f, -0.22527276f, -0.31189841f, -0.07128339f, 0.17924714f, 0.23403867f, -0.02074790f, 
    0.00757206f, 0.08382464f, 0.01503734f, -0.23323926f, -0.24206932f, 0.11502581f, 0.28868839f, 0.11241890f, 
    0.13148890f, -0.10822167f, -0.01428270f, 0.06458300f, -0.07703329f, -0.24530573f, -0.15742628f, 0.00487560f, 
    -0.25265855f, -0.22455040f, -0.11326278f, -0.20556884f, -0.15238051f, 0.15251447f, 0.05328195f, 0.12406433f, 
    0.06895128f, -0.11941962f, -0.04683544f, -0.03764111f, 0.05654266f, -0.10931806f, -0.45332611f, 0.31744242f, 
    -0.04122643f, 0.08454882f, -0.02444350f, 0.10575236f, -0.10627910f, 0.00018937f, 0.13228554f, 0.00302943f, 
    -0.08837210f, 0.09900412f, -0.10971381f, -0.06607095f, -0.01027022f, 0.01887949f, -0.02224321f, 0.02368056f, 
    0.03729308f, -0.00086082f, 0.08213569f, -0.08635543f, -0.28938147f, -0.14907628f, -0.03005543f, 0.13940041f, 
    -0.23890093f, -0.13994816f, 0.03690536f, 0.04492990f, -0.08220378f, 0.06188206f, -0.13277976f, -0.20563725f, 
    -0.29789549f, -0.39773175f, 0.01880161f, 0.28667286f, 0.13905829f, -0.13363838f, -0.04635299f, -0.23149683f, 
    -0.03273967f, 0.09796100f, 0.17799979f, 0.03341313f, 0.06249641f, -0.21598737f, -0.10915135f, -0.19971585f, 
    -0.04137441f, 0.21013765f, -0.06446883f, 0.28381124f, -0.02288672f, 0.02824108f, -0.09388413f, -0.02814739f, 
    0.38102129f, -0.01894506f, 0.15044789f, -0.38539103f, 0.07837252f, 0.07965671f, 0.26899651f, -0.19433773f, 
    -0.14713840f, 0.10712565f, 0.09807854f, 0.23618616f, -0.47417581f, -0.17994395f, 0.25414070f, 0.46619192f, 
    0.07117386f, -0.21892178f, -0.03707105f, 0.09430866f, 0.07704779f, 0.03022931f, -0.00159415f, 0.05875994f, 
    -0.14488630f, 0.22536476f, 0.13001144f, 0.10932803f, 0.10088589f, 0.23172048f, 0.18551843f, -0.08653352f, 
    -0.00833448f, 0.12463209f, 0.28058538f, 0.18531719f, -0.26857826f, 0.19875467f, -0.27004677f, 0.15592748f, 
    -0.21529689f, -0.07568903f, 0.03276490f, 0.10650557f, 0.03605115f, -0.02173359f, 0.01176522f, -0.02802243f, 
    0.09483232f, 0.05913390f, -0.00458621f, 0.17299314f, -0.04197921f, -0.10329149f, -0.00206290f, 0.01353789f, 
    -0.19220537f, -0.07731118f, -0.14224452f, -0.14265724f, -0.03211143f, 0.13234624f, -0.18782538f, -0.27100390f, 
    0.08422594f, -0.06640167f, -0.05411964f, -0.00551290f, -0.09679797f, -0.07061348f, -0.08029626f, 0.04483664f, 
    0.30280194f, 0.16753370f, 0.05722088f, 0.04621925f, -0.12951244f, -0.09356107f, -0.01944519f, 0.02815372f, 
    -0.09933857f, 0.16153312f, -0.07969396f, 0.12292521f, 0.51547068f, -0.05838452f, 0.33946329f, -0.11485516f, 
    -0.08738462f, 0.05150285f, 0.02538140f, -0.07694526f, 0.12260968f, 0.07491057f, 0.04904615f, 0.01529517f, 
    -0.17508264f, -0.18850687f, 0.18413514f, 0.02975988f, -0.21018124f, 0.04998853f, 0.00507031f, 0.04706529f, 
    -0.06360135f, -0.09919727f, 0.05019744f, -0.13598762f, 0.63869143f, 0.10438117f, 0.37646192f, -0.39151222f, 
    -0.06786682f, 0.00770248f, -0.04064204f, 0.00965779f, -0.07348542f, 0.14249034f, 0.14396437f, -0.00083855f, 
    0.16472279f, 0.24069308f, -0.10585074f, -0.04305827f, -0.00033022f, 0.01785339f, 0.10300029f, 0.16620888f, 
    0.14530908f, -0.02336129f, 0.16501281f, 0.08448990f, 0.28688598f, 0.04486477f, -0.17570055f, 0.19773398f, 
    -0.01248045f, 0.14961284f, 0.03716264f, 0.12210393f, 0.18944626f, 0.17620423f, -0.11263371f, -0.10169087f, 
    -0.03169421f, -0.03094265f, -0.06436053f, 0.05012491f, -0.07467826f, 0.05020984f, 0.00762919f, -0.05261369f, 
    -0.06084831f, -0.07252139f, 0.06153535f, -0.00409768f, -0.02047021f, -0.03785537f, 0.06963217f, 0.04961700f, 
    -0.04596618f, -0.03263745f, 0.04995547f, -0.05153065f, -0.00178261f, -0.01974965f, 0.01683485f, -0.01083093f, 
    0.04799689f, -0.07455383f, 0.01164824f, -0.00835201f, -0.07532607f, 0.03339258f, 0.05623339f, 0.06214162f, 
    0.01865657f, 0.01593574f, 0.02974229f, -0.02015146f, -0.04373443f, 0.00005725f, -0.02634609f, 0.03439787f, 
    -0.02029701f, -0.07514152f, -0.08029682f, 0.04453964f, 0.05804342f, 0.01656349f, -0.05058119f, -0.03067319f, 
    0.00333518f, 0.04808098f, 0.04661351f, -0.04659994f, 0.02932589f, 0.03810053f, -0.01979959f, -0.04494012f, 
    -0.03510977f, -0.01006274f, -0.00613566f, -0.01115412f, -0.01038755f, -0.02387960f, -0.04936419f, 0.02461693f, 
    -0.00893116f, 0.03794170f, 0.00339885f, 0.03656740f, 0.05376032f, -0.05234739f, 0.05649922f, -0.03718941f, 
    0.05062129f, 0.03965648f, 0.03089342f, -0.00280619f, -0.06713907f, -0.08339282f, 0.05096037f, 0.05799700f, 
    -0.04612834f, -0.01563495f, -0.04954141f, -0.00781951f, -0.03527840f, 0.02721763f, 0.05244758f, -0.04948300f, 
    -0.07049046f, -0.03613426f, -0.00149087f, 0.04202082f, 0.04227515f, 0.00395351f, 0.06023662f, 0.02448095f, 
    0.03594188f, 0.03747585f, 0.03678454f, 0.03452646f, -0.06926935f, -0.07296930f, 0.04229211f, -0.05724713f, 
    0.06866702f, -0.07467450f, -0.05701844f, -0.01441880f, -0.07560568f, -0.06188241f, -0.02824865f, -0.07015785f, 
    -0.02432389f, 0.02076718f, -0.00368123f, -0.01420208f, -0.00614387f, -0.06511093f, -0.02697584f, 0.00440352f, 
    -0.04131214f, -0.00642502f, 0.03219697f, -0.03281574f, -0.00817250f, -0.04396932f, -0.04549120f, -0.01390193f, 
    0.01913714f, -0.06026835f, -0.02697175f, -0.05631799f, -0.00840604f, -0.07092484f, 0.01605164f, -0.02784103f, 
    -0.03758330f, -0.06787741f, -0.03337800f, -0.00764301f, -0.01378075f, -0.06271723f, 0.02800943f, 0.04909997f, 
    0.03146080f, -0.02643456f, -0.07518294f, 0.07468093f, -0.07375548f, -0.03859043f, -0.07566501f, -0.04598152f, 
    0.01654976f, -0.06917013f, 0.04078174f, -0.01114157f, 0.03184042f, 0.00185923f, 0.01341742f, 0.04842268f, 
    -0.02539935f, 0.00548490f, 0.01189815f, 0.01519582f, -0.06863116f, -0.02657005f, 0.02182749f, 0.02520212f, 
    -0.03249199f, -0.00404069f, -0.00722270f, 0.00019776f, -0.07473665f, -0.07383646f, -0.07901216f, 0.04690769f, 
    0.03253606f, -0.01026525f, 0.01799822f, 0.00382413f, -0.02673491f, 0.04248169f, -0.05494601f, 0.03727385f, 
    -0.06770333f, -0.00904430f, 0.04751898f, -0.00037688f, 0.05191858f, -0.01859692f, -0.07484658f, -0.08116855f, 
    0.16565393f, 0.08785255f, 0.06424215f, -0.23443481f, 0.28809550f, -0.08030917f, -0.24117790f, -0.13522777f, 
    -0.06508732f, -0.00021182f, -0.06763036f, -0.15636604f, 0.20468612f, 0.23661751f, 0.12768927f, -0.01447500f, 
    0.13873883f, 0.10935059f, 0.06243296f, 0.02732049f, 0.02744463f, -0.10926487f, -0.03861341f, 0.11649206f, 
    0.30683297f, 0.38858768f, 0.03155940f, -0.08246071f, 0.03683918f, 0.24115779f, 0.22328378f, 0.11116288f, 
    0.13615996f, -0.02291948f, 0.19253717f, 0.15718777f, -0.23714787f, 0.33206758f, 0.26497442f, 0.31130472f, 
    -0.01234901f, 0.03890141f, 0.02261154f, -0.13369368f, 0.17721069f, 0.00500969f, 0.00885021f, -0.24998195f, 
    -0.49850884f, 0.44004667f, -0.27615726f, 0.51182365f, -0.03311507f, 0.05611297f, -0.14660023f, 0.07315288f, 
    0.11067812f, 0.10752872f, -0.01824444f, 0.09377182f, 0.47345152f, 0.25209761f, -0.05242680f, -0.25557736f, 
    0.07526165f, 0.09976707f, 0.18944852f, 0.04852055f, 0.29676497f, -0.11583867f, -0.15151808f, -0.00382552f, 
    0.21707557f, -0.34509051f, -0.09484100f, -0.03797025f, 0.09067617f, -0.13966748f, 0.26472250f, 0.03014274f, 
    0.00830589f, 0.11087330f, -0.00114262f, 0.00023755f, 0.41379541f, -0.33507523f, 0.10430474f, -0.05856439f, 
    0.32681060f, 0.11963496f, 0.01842281f, 0.01316353f, 0.20910481f, 0.24997298f, 0.17815731f, 0.25757632f, 
    -0.20151304f, -0.08580822f, -0.05990125f, -0.28585318f, 0.30403087f, -0.04753332f, -0.12463534f, -0.03753678f, 
    -0.09357333f, -0.29027247f, -0.29556286f, -0.11863436f, -0.05029677f, 0.10904345f, 0.25373420f, 0.20990315f, 
    -0.08133208f, 0.18846461f, -0.05611207f, -0.12292240f, -0.05539917f, -0.35421607f, -0.27817813f, -0.32112190f, 
    -0.09886729f, -0.01268846f, -0.09623227f, 0.10264205f, 0.06977240f, 0.23623429f, 0.11061164f, 0.08500549f, 
    -0.05101459f, -0.06601145f, 0.13251486f, 0.00036328f, -0.18597160f, 0.01984517f, -0.34806624f, 0.29183373f, 
    -0.14139710f, -0.05128979f, 0.07126758f, 0.25709668f, -0.12498185f, 0.14909983f, 0.02945227f, -0.02531000f, 
    -0.03037426f, 0.16263714f, -0.17242940f, -0.24573806f, 0.22806127f, -0.08163881f, -0.05582442f, -0.19083223f, 
    -0.12689917f, 0.05436587f, -0.11223414f, -0.19376197f, -0.24720493f, 0.18277642f, -0.18059987f, 0.16914535f, 
    -0.08273682f, 0.07761352f, 0.14873788f, 0.02945022f, -0.00893485f, -0.27889782f, 0.00678578f, 0.05540346f, 
    -0.14519303f, -0.15799507f, -0.25951552f, 0.05920517f, -0.15736176f, 0.05373443f, 0.10435773f, 0.11407571f, 
    0.04401143f, 0.16994826f, 0.07671323f, 0.13736132f, -0.41456169f, -0.51736683f, -0.17847607f, -0.00974212f, 
    0.07866199f, 0.00670005f, 0.15653327f, 0.09212246f, -0.07600191f, 0.15316634f, 0.08277934f, 0.03579562f, 
    -0.02813958f, -0.05720358f, -0.00049332f, 0.00515008f, -0.03053849f, 0.03144498f, -0.06090823f, -0.02376511f, 
    -0.01997394f, 0.03889509f, -0.06793738f, 0.01721125f, -0.00634780f, -0.05340403f, -0.06190770f, 0.00002852f, 
    0.01573755f, -0.03102838f, 0.01323759f, 0.02715322f, 0.01120731f, -0.01793781f, 0.01277101f, -0.01347056f, 
    0.02443497f, -0.01902019f, -0.02703957f, -0.00639068f, -0.07619850f, 0.04405762f, -0.00526640f, -0.07756444f, 
    -0.07235705f, -0.01837476f, 0.00780425f, -0.06559574f, -0.05015371f, -0.03978636f, 0.03875139f, -0.03015733f, 
    0.00925053f, 0.00680713f, -0.05547020f, 0.00405221f, -0.07220592f, -0.00417856f, 0.05079110f, -0.05288873f, 
    -0.02792725f, 0.05015846f, 0.01577347f, -0.04243273f, 0.06380274f, -0.07370261f, 0.05643713f, 0.01672499f, 
    0.02569622f, -0.05139738f, -0.02763013f, -0.06063582f, 0.00928460f, -0.03029295f, 0.01207730f, -0.01132842f, 
    0.04017602f, 0.05877864f, -0.06263375f, 0.04830020f, -0.01375027f, -0.06432138f, 0.04349688f, 0.00617685f, 
    0.00421320f, -0.02177611f, -0.06616344f, -0.02927796f, -0.00433320f, 0.03754282f, 0.02446930f, -0.01228810f, 
    -0.07212623f, 0.03798596f, -0.06456140f, -0.06823722f, 0.03852295f, -0.07545824f, -0.05860546f, 0.00674596f, 
    0.06876472f, -0.03503656f, 0.00619763f, -0.04390319f, 0.05986100f, 0.05144150f, -0.04425769f, 0.03740270f, 
    -0.06133595f, 0.06398359f, -0.00354319f, -0.01670443f, -0.03801646f, 0.04698381f, 0.03421166f, 0.01264452f, 
    -0.05621681f, -0.06576611f, -0.03854103f, -0.01218988f, 0.05538444f, -0.07074203f, -0.02610664f, 0.01150503f, 
    -0.01058288f, -0.06253631f, -0.02676931f, -0.04449279f, -0.01834676f, 0.03139570f, 0.04015248f, -0.07183316f, 
    -0.04854361f, 0.04982604f, 0.06023100f, -0.00225380f, -0.05586192f, -0.05226659f, -0.05550826f, -0.07200399f, 
    -0.03968898f, -0.05204493f, 0.00525298f, -0.04948619f, 0.01234312f, 0.00266456f, -0.03702075f, -0.05787650f, 
    0.00002196f, -0.01393030f, -0.06563915f, -0.00441161f, 0.04739160f, -0.00856316f, -0.06338929f, 0.00620781f, 
    -0.00263299f, 0.04968045f, 0.05560036f, 0.03726241f, 0.03248862f, -0.03721921f, 0.05955849f, 0.05593197f, 
    0.04281630f, -0.06546298f, 0.00748057f, 0.02838979f, 0.04137967f, -0.03985084f, 0.02743281f, -0.00033214f, 
    0.04817424f, 0.01208594f, -0.04103061f, 0.04057686f, 0.03136658f, -0.06490849f, -0.07186486f, -0.00781700f, 
    -0.05553814f, -0.06263163f, 0.05526454f, -0.00562262f, 0.03179147f, -0.05543421f, -0.03977942f, 0.01558399f, 
    0.03193161f, -0.02039510f, -0.07723810f, 0.04458832f, 0.05232986f, -0.07695432f, 0.02605654f, 0.06047398f, 
    -0.07404397f, 0.02922253f, 0.02739685f, -0.06519479f, -0.05114928f, 0.03616500f, 0.04815643f, 0.01070505f, 
    0.04070428f, 0.00014716f, 0.02454344f, -0.05253194f, -0.05674474f, 0.03409122f, -0.07154280f, -0.05601272f, 
    -0.06769758f, -0.08308251f, 0.03433178f, -0.02180473f, 0.03390444f, 0.04129876f, -0.06331219f, 0.05686979f, 
    -0.05883592f, 0.06303002f, -0.02715594f, -0.08367410f, 0.03907333f, 0.00491186f, 0.02182839f, 0.03015568f, 
    -0.05912764f, -0.02678924f, -0.07321844f, -0.06361402f, -0.05358447f, 0.00070931f, 0.04367955f, -0.02919669f, 
    -0.07378842f, 0.03081009f, 0.01397139f, -0.07294520f, -0.03771437f, -0.03539821f, 0.03422348f, -0.05156334f, 
    0.05352911f, -0.07057144f, -0.01794136f, -0.03320286f, 0.02200144f, -0.08717353f, -0.03384208f, -0.04125648f, 
    0.02044004f, 0.00679238f, -0.08379062f, -0.07931917f, -0.08910152f, 0.00518848f, -0.08862802f, -0.07618000f, 
    -0.08610862f, -0.00604756f, -0.02166145f, 0.03406978f, -0.05230485f, -0.05198831f, 0.03556735f, 0.06055271f, 
    -0.05536032f, 0.03539061f, -0.04340522f, 0.06089518f, 0.00187819f, 0.02604814f, -0.04703833f, -0.06875140f, 
    -0.06975493f, -0.03360467f, -0.04254944f, 0.03322200f, -0.04704634f, 0.02883867f, 0.01349558f, -0.03385225f, 
    -0.03396891f, 0.01374348f, 0.02524217f, -0.06363668f, 0.05357772f, 0.00906364f, 0.02729001f, -0.00495183f, 
    -0.05530835f, -0.05314353f, 0.00615117f, 0.01032445f, 0.04677298f, -0.06605443f, 0.03455602f, -0.00741490f, 
    -0.00664103f, -0.00865847f, -0.05730518f, -0.06622319f, -0.03056773f, 0.04076745f, -0.03851072f, -0.05802476f, 
    0.03230482f, -0.00468286f, -0.01489362f, 0.00798013f, -0.05433571f, -0.07676701f, -0.06971277f, 0.04308513f, 
    -0.07909953f, -0.07702839f, -0.03237660f, -0.08179288f, 0.02856650f, 0.01961434f, -0.06144776f, -0.06417708f, 
    0.06237735f, 0.04790509f, 0.01624681f, 0.05323681f, -0.06487610f, 0.05887157f, 0.05693045f, 0.04904896f, 
    0.01667256f, -0.08930270f, -0.07779470f, 0.02881477f, 0.00264836f, -0.02595240f, 0.03842168f, 0.04656003f, 
    -0.02571571f, 0.01195099f, -0.05227432f, -0.04504983f, 0.03285413f, -0.03562404f, -0.03726990f, -0.06140485f, 
    0.02707949f, -0.08313202f, 0.05062304f, 0.03385577f, -0.02810202f, -0.07251379f, 0.00987422f, 0.00953547f, 
    0.00157360f, -0.05522511f, 0.03667498f, 0.00907775f, 0.00757245f, 0.02039064f, 0.03679687f, -0.03498996f, 
    -0.04052382f, -0.06590551f, -0.08517205f, 0.00842227f, -0.06274523f, 0.01675078f, -0.07736860f, -0.04941230f, 
    -0.08768872f, -0.00775981f, -0.06797143f, -0.03222740f, 0.02358115f, 0.03070276f, 0.03316206f, -0.08196520f, 
    -0.00867495f, -0.07563747f, -0.01398527f, 0.03116587f, -0.00776094f, -0.04794759f, 0.02751895f, 0.03743524f, 
    -0.06905334f, -0.02755254f, -0.02716630f, -0.06661375f, -0.07569118f, -0.03539830f, -0.03329333f, -0.04974674f, 
    -0.06134462f, -0.04839988f, -0.01271790f, 0.02032739f, 0.01070592f, -0.01788730f, -0.05717621f, -0.01038428f, 
    -0.05505304f, 0.01588960f, -0.01364247f, -0.04152228f, -0.07239546f, 0.02111177f, -0.01410508f, -0.03893653f, 
    0.05413454f, 0.02567968f, -0.04231589f, 0.05431059f, 0.02045326f, -0.01914199f, 0.01360753f, 0.01874072f, 
    -0.02411360f, -0.03602422f, -0.05806094f, -0.04765071f, -0.04666935f, -0.03722799f, -0.01762258f, 0.03399394f, 
    -0.04423927f, -0.08109769f, -0.02047579f, -0.03836027f, 0.01889508f, -0.03938523f, 0.00629268f, 0.05936150f, 
    0.03126359f, -0.02182987f, 0.00782013f, -0.05201816f, 0.05269374f, 0.05532273f, 0.04976087f, 0.04761047f, 
    -0.05542174f, -0.06065623f, -0.04559642f, 0.04738281f, 0.04288779f, 0.01422178f, -0.01159658f, -0.04472642f, 
    0.01800858f, -0.03861786f, 0.03980506f, -0.03029479f, -0.07598219f, 0.00770139f, -0.05905744f, 0.01267564f, 
    0.02789794f, 0.04791589f, -0.04099270f, -0.06053877f, -0.06360729f, 0.06471407f, -0.04290176f, -0.07755689f, 
    -0.02806456f, 0.04551238f, 0.04586988f, -0.01551101f, 0.02700774f, -0.03546465f, 0.03678287f, -0.05700655f, 
    0.04665524f, -0.03691400f, -0.02462381f, -0.00701659f, 0.00233856f, 0.00182842f, 0.03330091f, -0.00465914f, 
    -0.03341815f, 0.04172293f, 0.03508250f, 0.05146681f, -0.06012273f, -0.03830831f, -0.05286415f, 0.02351331f, 
    0.06592939f, -0.02948163f, -0.04491264f, -0.02889968f, -0.03314609f, -0.03385277f, -0.04845822f, 0.02919328f, 
    -0.02715811f, 0.03525578f, -0.00687384f, 0.01675481f, -0.06971966f, -0.02916096f, -0.04016020f, 0.00577404f, 
    -0.03459204f, 0.01936982f, -0.03522368f, 0.04089062f, 0.02651705f, -0.02305630f, 0.02584756f, 0.05652106f, 
    0.01031782f, -0.01251905f, 0.00871229f, -0.04846116f, -0.00980397f, -0.06560156f, 0.00634323f, 0.02167741f, 
    -0.02566233f, -0.06322722f, -0.07614908f, 0.01932907f, -0.06787591f, -0.05243037f, -0.01776292f, 0.01192761f, 
    0.00974445f, 0.02981349f, -0.06299957f, 0.06558052f, 0.05036028f, -0.02478087f, -0.03607482f, 0.05006522f, 
    -0.05950788f, -0.06121769f, -0.00451052f, 0.00897247f, 0.04993320f, 0.00413549f, 0.01128881f, -0.03911587f, 
    -0.04014407f, 0.02882649f, -0.00305967f, -0.07790256f, -0.04716535f, -0.07518948f, -0.07695111f, -0.05706013f, 
    -0.06636772f, 0.03895804f, -0.00114231f, -0.00587166f, 0.05915105f, 0.02434764f, -0.07415051f, 0.03862726f, 
    0.00140989f, -0.02428874f, -0.05634348f, 0.06228052f, -0.07227010f, 0.06305625f, -0.02094276f, 0.06227362f, 
    0.05902983f, -0.02670345f, -0.05885293f, -0.01341327f, 0.02291659f, 0.05587952f, -0.01861208f, -0.02306912f, 
    -0.05078635f, -0.06220481f, 0.00955578f, -0.01997666f, -0.02675465f, -0.05423852f, 0.06304077f, -0.07005132f, 
    0.01815875f, 0.03199657f, -0.19246402f, -0.28505835f, -0.13128570f, 0.01186837f, -0.00390420f, -0.04241841f, 
    0.20789008f, 0.29073668f, 0.20127524f, 0.21282324f, -0.27912340f, -0.34236267f, -0.18918711f, 0.20873529f, 
    -0.09199721f, 0.03995573f, -0.01505358f, 0.12240863f, 0.00843702f, -0.06726988f, -0.07528844f, 0.10786367f, 
    0.03365939f, -0.31470838f, 0.03996336f, 0.20582625f, 0.08264690f, -0.16820109f, 0.04520845f, -0.23207767f, 
    0.09165125f, 0.10665455f, -0.06369358f, 0.00702064f, 0.45089895f, -0.09249392f, -0.17674865f, -0.26373026f, 
    0.08536889f, 0.01466713f, 0.11470596f, -0.02406979f, -0.08252008f, 0.05771443f, 0.18527025f, 0.31866026f, 
    0.03121627f, 0.38265339f, 0.24953134f, 0.09766295f, 0.07113726f, -0.08647225f, 0.05430897f, -0.03080875f, 
    0.16454422f, -0.08661629f, 0.16473682f, 0.21300723f, -0.26208231f, -0.30271110f, -0.00385197f, 0.08878993f, 
    0.06549548f, -0.04021966f, -0.15664336f, 0.22670217f, -0.04867298f, 0.02844212f, -0.18776326f, -0.04927829f, 
    -0.20620644f, 0.27337983f, 0.15112610f, 0.21096708f, 0.03141448f, 0.32051906f, -0.14546664f, 0.08760799f, 
    0.12470770f, 0.15121356f, 0.10826702f, -0.08028822f, -0.24463987f, -0.07289555f, -0.12938920f, -0.01095079f, 
    -0.03327894f, -0.02458375f, 0.02970786f, 0.08275889f, -0.00338112f, -0.07572920f, -0.10303576f, -0.01899931f, 
    -0.05056169f, -0.05436263f, 0.07830349f, -0.00619463f, -0.01374704f, 0.14525241f, -0.06504358f, 0.01334309f, 
    0.06018651f, 0.08571766f, 0.10995004f, 0.05011255f, 0.38794756f, 0.03544590f, -0.11964157f, -0.14518373f, 
    -0.16447066f, -0.09938254f, -0.14289418f, -0.12222905f, -0.02510325f, 0.11010829f, 0.13361926f, 0.21716887f, 
    -0.10907467f, 0.09573298f, 0.13566995f, -0.28153306f, -0.28131458f, -0.07298887f, -0.10888584f, -0.08568484f, 
    -0.01606306f, 0.17620374f, 0.00038880f, 0.28662619f, 0.09903924f, -0.02561757f, 0.21130405f, 0.03066359f, 
    -0.08921183f, -0.11962001f, 0.07022278f, 0.13101701f, 0.07228236f, 0.06554161f, -0.05467978f, 0.00261393f, 
    -0.07817901f, -0.03950442f, 0.32607314f, 0.09426507f, -0.17520313f, 0.05738747f, 0.01923863f, 0.28481773f, 
    0.08986179f, -0.03057376f, 0.12889966f, -0.11470200f, 0.49035954f, 0.11693629f, 0.48583850f, -0.24861260f, 
    -0.13642374f, -0.09591936f, -0.10759472f, -0.01929744f, -0.04500099f, 0.12516500f, 0.17169228f, 0.07762395f, 
    -0.32746017f, -0.12969577f, -0.01048609f, -0.00546746f, -0.12164345f, 0.10707931f, 0.11858927f, 0.38082555f, 
    0.11060474f, -0.05528162f, -0.13507763f, -0.12854019f, -0.00194677f, 0.33693030f, 0.18804100f, 0.24261677f, 
    -0.03277742f, 0.03483623f, -0.04625623f, 0.00287733f, 0.02339629f, -0.11488360f, 0.03127446f, 0.01824973f, 
    -0.06210666f, 0.08562461f, -0.27218768f, -0.01735223f, -0.27609190f, -0.02681195f, -0.00886368f, -0.08222338f, 
    0.08990012f, 0.12444506f, 0.04267503f, 0.28351560f, -0.03704298f, 0.03134543f, 0.13437237f, -0.02434030f, 
    -0.08130873f, 0.13702142f, -0.09545174f, 0.00039685f, -0.10989694f, -0.07485319f, 0.12684059f, -0.05186892f, 
    0.15976539f, 0.23219900f, -0.22364302f, 0.17459254f, 0.09357067f, -0.01911914f, -0.13490671f, 0.30049738f, 
    -0.09629808f, 0.07886086f, -0.22710529f, 0.02957278f, -0.14507832f, 0.04781384f, -0.21834666f, -0.04545097f, 
    0.22002451f, -0.08998921f, -0.02524769f, 0.08752724f, 0.16026741f, 0.20919031f, 0.09166265f, 0.10299520f, 
    0.26540199f, -0.40320760f, 0.17105451f, 0.18957925f, -0.23081058f, -0.07259046f, 0.07594099f, 0.03006207f, 
    0.01876843f, 0.15183486f, 0.00579483f, 0.00416586f, 0.03402370f, -0.12704656f, -0.08299021f, 0.15231813f, 
    0.01450364f, 0.07010680f, 0.14626557f, 0.21905179f, 0.03037767f, 0.03631714f, 0.21197513f, -0.04106762f, 
    0.06413751f, 0.21767625f, 0.10228329f, 0.09436047f, 0.05659747f, 0.02024317f, -0.15733814f, -0.11203271f, 
    -0.01057484f, -0.07019848f, -0.06431205f, 0.24674332f, 0.44971904f, 0.41086993f, 0.27587250f, -0.02529563f, 
    -0.13161306f, -0.01279931f, -0.14246209f, -0.04938732f, -0.05103565f, -0.00986219f, -0.14773251f, -0.10110555f, 
    -0.15077408f, -0.20256597f, -0.44184011f, -0.16562438f, -0.18932313f, 0.00504349f, 0.18754117f, 0.02672700f, 
    0.11341401f, 0.07493687f, 0.14498630f, -0.04146579f, -0.05105506f, -0.10517272f, -0.01251379f, 0.10446643f, 
    0.23892522f, 0.13132600f, 0.20378289f, 0.02926876f, -0.08428638f, 0.15963984f, 0.12940215f, 0.25159329f, 
    -0.06104029f, -0.23872465f, 0.23363616f, -0.17818342f, -0.18448879f, -0.26596662f, -0.11060659f, -0.27467796f, 
    0.04771180f, -0.02869610f, -0.09410785f, -0.04214543f, -0.20797688f, -0.04554660f, 0.19132525f, -0.04310022f, 
    0.13473797f, -0.03655077f, 0.05593566f, -0.11199495f, 0.20657274f, 0.07200097f, -0.29428250f, 0.34745145f, 
    0.56757957f, -0.03934139f, 0.08378500f, -0.15572956f, 0.06806713f, -0.10245030f, 0.21220683f, 0.17084070f, 
    0.25901651f, 0.06920103f, 0.25419876f, 0.18102628f, -0.37054875f, 0.03779731f, -0.16023214f, -0.04379005f, 
    -0.09386928f, -0.22662391f, -0.17952201f, -0.08922386f, -0.04888493f, -0.03704199f, -0.00766501f, -0.11347653f, 
    0.37859461f, -0.34372208f, 0.34956616f, 0.01662946f, 0.13672668f, -0.11256248f, 0.01427532f, -0.06561139f, 
    0.25628707f, 0.11236179f, 0.05541063f, 0.08828608f, 0.53830230f, 0.44307092f, 0.47832066f, -0.29252839f, 
    0.04257220f, -0.01037233f, -0.07095752f, 0.00602799f, 0.15029085f, 0.03405077f, -0.12187173f, 0.12929660f, 
    -0.03877162f, -0.17436306f, -0.01408105f, 0.27139843f, 0.03799081f, -0.00806688f, 0.04558564f, 0.02404972f, 
    -0.02710859f, -0.06447770f, 0.06830957f, 0.04558374f, 0.03064135f, 0.14400469f, 0.17982394f, 0.06622069f, 
    0.08572290f, 0.09364831f, 0.18751067f, 0.13949822f, 0.26685837f, 0.07153565f, 0.06378828f, 0.15381110f, 
    -0.32482746f, 0.12964892f, 0.16592577f, 0.06275011f, -0.00160992f, -0.07939029f, -0.03513367f, -0.01604999f, 
    0.00764135f, 0.04753966f, 0.17173710f, 0.05500690f, -0.52848428f, 0.11307513f, -0.19719483f, 0.19744855f, 
    -0.03258218f, -0.03573978f, 0.04098312f, 0.11166358f, 0.26035208f, 0.10361581f, -0.02031752f, -0.08717407f, 
    0.02976229f, -0.08342040f, -0.15888043f, -0.29327816f, 0.14231388f, -0.02633103f, -0.06700600f, 0.08926287f, 
    -0.04939476f, 0.05722244f, 0.00810588f, -0.09395255f, -0.03296464f, 0.23033318f, 0.20183927f, 0.15149640f, 
    -0.00398096f, 0.09961908f, 0.15324485f, -0.11276882f, 0.02596238f, 0.06581943f, 0.09481550f, 0.01944003f, 
    0.54178762f, -0.05200650f, 0.10443362f, 0.00395045f, 0.04658297f, 0.05087816f, -0.18056032f, 0.09801374f, 
    0.01131238f, -0.00921665f, -0.05507705f, -0.03531461f, -0.08265459f, 0.09954621f, -0.17293145f, -0.08310959f, 
    -0.12583414f, -0.15456527f, -0.06454061f, 0.10830943f, 0.09976497f, -0.08333521f, -0.08216262f, -0.16614476f, 
    0.07796391f, -0.23339020f, -0.03262838f, -0.11501005f, 0.03774653f, 0.00650435f, 0.13492982f, -0.01972499f, 
    0.13473102f, 0.08588292f, 0.05567248f, 0.18720117f, 0.03674335f, -0.18808973f, 0.15611169f, 0.05225572f, 
    -0.00445061f, -0.14508106f, 0.00286108f, 0.06439194f, 0.25791645f, 0.01247446f, 0.06662078f, 0.09704338f, 
    0.11713306f, 0.11762782f, 0.01061368f, -0.03083980f, 0.06356271f, -0.01978266f, 0.03282150f, -0.11220008f, 
    0.02857023f, -0.18287410f, 0.10971680f, -0.36728710f, 0.07859071f, 0.22028476f, -0.23595275f, -0.10224611f, 
    0.14171414f, 0.11320117f, 0.07140599f, -0.05307996f, 0.14597806f, -0.01407680f, 0.12864400f, 0.01071045f, 
    0.05706595f, -0.29478335f, 0.06717322f, -0.19247186f, 0.03340900f, 0.10343391f, 0.02037802f, -0.01619823f, 
    0.20411250f, 0.20219372f, -0.04578374f, 0.24582963f, -0.02831296f, -0.05667078f, -0.82814610f, 0.04170755f, 
    0.06070239f, 0.02998493f, 0.13239926f, 0.03704366f, 0.03181274f, -0.03263704f, -0.08840906f, -0.02825613f, 
    0.33390111f, -0.05669482f, -0.02578553f, -0.16505195f, 0.03322417f, -0.00931604f, 0.05235766f, -0.15208222f, 
    -0.06601387f, -0.13165371f, -0.13214639f, -0.01915648f, 0.22550285f, -0.19502307f, 0.16814221f, -0.32501820f, 
    -0.11271907f, -0.00894068f, -0.05134120f, 0.01102235f, 0.11047881f, -0.35405603f, -0.06221224f, -0.10280799f, 
    0.00273581f, 0.00145172f, 0.01002029f, -0.04789456f, 0.00896761f, 0.04690501f, -0.02980718f, -0.07897666f, 
    -0.00006608f, 0.00253398f, -0.02306828f, -0.08048742f, -0.03347314f, -0.07325556f, 0.04913562f, 0.01014069f, 
    -0.03414162f, -0.01580996f, 0.04007594f, -0.00629072f, 0.01069362f, 0.01533195f, -0.07385679f, -0.04445667f, 
    0.03803122f, -0.02247467f, -0.02235951f, 0.03189119f, 0.05910851f, 0.05197588f, -0.03078159f, 0.05544168f, 
    0.01348739f, 0.03174747f, -0.02361572f, -0.03632652f, -0.07226538f, 0.05142070f, -0.06355887f, -0.06923536f, 
    -0.03305212f, 0.02963841f, 0.03876592f, 0.01780339f, -0.00338233f, -0.04811563f, 0.03463700f, 0.02767272f, 
    -0.05058120f, -0.05122465f, -0.04481198f, -0.05166257f, -0.00829457f, 0.05677565f, -0.03120174f, -0.02139937f, 
    -0.01228128f, 0.04253739f, -0.07866980f, -0.01119878f, -0.05064638f, -0.06728390f, 0.01546068f, -0.05436439f, 
    -0.04912671f, 0.01342667f, 0.03891983f, 0.02144875f, 0.02175749f, -0.02707660f, 0.05667137f, 0.04245086f, 
    -0.04737116f, 0.04812719f, 0.01226909f, -0.03111336f, 0.04504687f, 0.01138574f, -0.02416017f, -0.05956584f, 
    -0.02662626f, 0.03691853f, -0.02425356f, -0.03692130f, 0.03866702f, -0.02715439f, -0.04902905f, -0.01032591f, 
    -0.03970414f, 0.06537528f, 0.03778069f, 0.00159792f, 0.03893359f, -0.07900086f, -0.05816687f, 0.03901392f, 
    0.02062139f, -0.06810790f, -0.03167158f, -0.07888570f, -0.05406749f, 0.02526386f, -0.06224824f, -0.00259403f, 
    -0.06728198f, -0.06436540f, 0.01920401f, -0.03011969f, 0.03990030f, 0.04750339f, 0.03961225f, -0.00953256f, 
    -0.00036344f, -0.03130699f, -0.01298429f, 0.00072014f, 0.01879603f, -0.05024932f, 0.06105166f, -0.00554654f, 
    0.01231905f, 0.02637215f, -0.05800241f, 0.01176634f, -0.07544793f, 0.02492997f, -0.04671509f, 0.00445437f, 
    -0.06040312f, -0.06494211f, 0.02666760f, 0.00767965f, -0.03050660f, -0.04397609f, -0.06875755f, 0.01683650f, 
    -0.07891583f, 0.06085922f, -0.07359905f, -0.03338954f, -0.00820626f, 0.03095878f, -0.00355205f, 0.04058733f, 
    -0.00237680f, 0.03093785f, 0.04825934f, -0.00652208f, 0.05066712f, -0.03350220f, -0.02073450f, -0.02699755f, 
    -0.00694725f, 0.00518427f, 0.02118781f, -0.00999063f, 0.05203739f, -0.01879845f, 0.01859376f, -0.03605648f, 
    -0.00199418f, -0.01405999f, -0.07394604f, 0.02950601f, -0.02293115f, -0.01894009f, -0.07385154f, -0.04796270f, 
    0.01810479f, -0.04462476f, -0.07396799f, -0.02225052f, -0.06897063f, -0.02212180f, -0.00845750f, 0.02247032f, 
    0.02330122f, 0.04592893f, -0.04683520f, -0.02670424f, 0.01712948f, -0.08042239f, -0.06157568f, -0.03277574f, 
    0.01201434f, 0.01684300f, 0.05212033f, -0.04167376f, 0.02164316f, -0.01177177f, -0.04331811f, -0.06126769f, 
    -0.42739949f, -0.13505694f, 0.20493437f, -0.22835976f, -0.18648124f, 0.14421509f, -0.00172364f, -0.11096951f, 
    0.01466748f, -0.07675230f, -0.03613080f, -0.08041368f, 0.27161530f, 0.42914149f, 0.12905043f, 0.40395153f, 
    -0.08953590f, -0.11786889f, -0.04117202f, -0.12316568f, -0.07742212f, 0.08252313f, 0.14198294f, -0.13997936f, 
    0.10727505f, -0.06554502f, 0.00662387f, 0.12738805f, 0.08440279f, -0.00294489f, 0.10239717f, 0.28952658f, 
    0.05633299f, 0.05921221f, 0.12863846f, 0.07649185f, -0.17646453f, 0.06864828f, 0.07348010f, 0.12504715f, 
    -0.06388398f, 0.25497100f, -0.07982192f, 0.04896655f, -0.03060584f, -0.02381825f, -0.09306287f, -0.14450556f, 
    0.08162779f, -0.46751297f, 0.20126809f, -0.01280972f, -0.18686137f, -0.07016756f, 0.04993829f, 0.01953198f, 
    -0.10835274f, -0.06480946f, -0.18663430f, 0.06403787f, 0.24909623f, 0.46949905f, -0.00288863f, 0.22881754f, 
    -0.00715424f, 0.15108305f, 0.06206248f, 0.21762668f, 0.12346531f, 0.08360925f, 0.01876621f, 0.02912489f, 
    -0.28835502f, -0.02395723f, 0.00044675f, 0.05936560f, 0.09762283f, 0.00230409f, -0.08365150f, 0.34071240f, 
    -0.08409742f, -0.07022116f, -0.07117464f, 0.10294078f, 0.25518447f, 0.60196000f, -0.02555050f, 0.12626778f, 
    0.05391920f, 0.13941586f, 0.10822307f, 0.07302292f, 0.00429423f, -0.04882649f, -0.09795363f, 0.13811982f, 
    0.07285985f, -0.01998970f, 0.12157115f, -0.12085432f, -0.00795362f, -0.03629807f, 0.13225144f, 0.21000916f, 
    0.01546177f, -0.04077172f, -0.08911891f, -0.25434241f, -0.17841938f, 0.00686121f, 0.25742003f, 0.02329481f, 
    0.14135748f, 0.02967944f, -0.13095716f, -0.09998103f, 0.00423402f, -0.09715018f, -0.09792682f, -0.03239626f, 
    -0.10003237f, -0.25529325f, -0.44129592f, -0.16397001f, 0.12797977f, -0.08347501f, 0.17412776f, -0.09478700f, 
    -0.08399359f, 0.09175946f, 0.10211526f, -0.08037078f, 0.10547197f, 0.21558133f, -0.35847396f, 0.18635648f, 
    -0.20244700f, -0.04840728f, 0.09006030f, -0.21549407f, -0.02583384f, 0.05502294f, -0.08063410f, -0.03741900f, 
    0.31802112f, -0.11066361f, -0.15295526f, 0.45704985f, 0.04269115f, -0.03612258f, -0.16678038f, 0.05048445f, 
    0.01920561f, -0.07433902f, 0.03233856f, 0.09675297f, 0.35099867f, -0.33440188f, -0.22808433f, 0.28738904f, 
    -0.08052079f, -0.06605255f, 0.02929744f, -0.07769398f, 0.07979840f, 0.04064784f, -0.00451672f, -0.15317543f, 
    0.08630040f, 0.34495786f, 0.07030462f, 0.31416914f, 0.17926493f, -0.08455606f, -0.07148613f, 0.03200975f, 
    -0.02073044f, 0.21382201f, -0.04568631f, 0.13657187f, -0.06761016f, -0.04398968f, 0.21484844f, -0.15353124f, 
    0.09182648f, 0.13536693f, 0.01555612f, 0.07672235f, 0.04592787f, -0.02170018f, -0.04626162f, -0.11254524f, 
    -0.30657247f, -0.11731221f, 0.14151940f, 0.13083151f, 0.07577170f, 0.06994893f, 0.15126206f, 0.07408977f, 
    0.11572300f, 0.00225444f, 0.08669534f, -0.01404163f, -0.10832202f, -0.19323865f, -0.28314981f, -0.34779254f, 
    0.08818506f, -0.15235169f, 0.01293182f, -0.10422553f, -0.16213413f, -0.17128631f, -0.14445384f, -0.11901579f, 
    0.21485412f, -0.10944686f, -0.13918366f, -0.16479190f, -0.04272943f, 0.11698063f, 0.02264399f, -0.11875118f, 
    -0.04691816f, -0.01101581f, -0.14945225f, -0.19388185f, 0.56568015f, -0.22036259f, 0.07201511f, -0.25022712f, 
    -0.00218487f, -0.07980196f, 0.23224773f, 0.17241991f, -0.10402296f, 0.00961953f, -0.07221787f, 0.06259223f, 
    0.30056646f, 0.03199170f, 0.31260878f, -0.54548007f, -0.03205997f, 0.03460987f, 0.26559338f, -0.00292941f, 
    0.15061189f, 0.06615953f, 0.07796118f, 0.12594271f, -0.40100816f, -0.20027769f, -0.20742911f, -0.03935167f, 
    -0.06342576f, -0.29973841f, -0.20639992f, 0.01456385f, -0.24433164f, -0.15040375f, 0.04034917f, 0.08579491f, 
    -0.14652336f, 0.21844453f, 0.21725489f, -0.19774829f, 0.07233429f, 0.06845378f, 0.12830372f, -0.09072609f, 
    0.09643901f, 0.06810824f, 0.08662589f, 0.18241104f, -0.28487581f, 0.10499993f, 0.12626266f, 0.30434054f, 
    -0.05429747f, 0.12560880f, 0.10755402f, 0.00368461f, -0.20037557f, 0.08001088f, 0.07348006f, 0.15323414f, 
    -0.02419096f, 0.08778089f, 0.00725150f, 0.10087886f, -0.00996157f, 0.21985187f, 0.19655059f, -0.03588277f, 
    0.00892394f, -0.10095905f, -0.00733262f, 0.01641335f, -0.03984965f, 0.13310422f, -0.25972316f, -0.19481763f, 
    -0.00091912f, 0.10966903f, -0.01891721f, 0.09300452f, -0.06440508f, -0.06547432f, -0.01046068f, 0.08021674f, 
    -0.07475971f, -0.05364233f, -0.09739771f, 0.02150654f, -0.07866525f, 0.15633693f, 0.01678458f, 0.08413848f, 
    -0.09904543f, 0.28121731f, -0.01171774f, 0.21851535f, 0.31724522f, -0.15757756f, 0.34924182f, -0.25963798f, 
    -0.11398859f, -0.09295793f, 0.01539408f, 0.08185720f, -0.06670639f, 0.00941579f, 0.05225651f, 0.00268947f, 
    -0.35065651f, 0.33507702f, 0.05061366f, 0.04488664f, -0.07879446f, 0.04071955f, -0.05947376f, 0.11569229f, 
    -0.26735726f, -0.04949186f, 0.08850601f, -0.22702195f, -0.02855025f, -0.06798004f, 0.54107541f, -0.22926268f, 
    -0.00408258f, 0.11693820f, 0.07538361f, 0.00778073f, 0.01681689f, 0.07814768f, -0.01535956f, 0.13539806f, 
    0.08965811f, 0.31789768f, -0.03877555f, 0.02146874f, 0.02121560f, -0.11795040f, -0.05665043f, 0.01541644f, 
    -0.00953100f, -0.08849087f, 0.31428418f, 0.17309877f, 0.07224052f, 0.48165521f, -0.30022362f, 0.15162635f, 
    0.19940360f, 0.05322850f, 0.09047269f, -0.03531252f, -0.03591998f, 0.31316847f, 0.00434842f, 0.02272568f, 
    0.04003760f, -0.37960482f, -0.04811572f, 0.23054789f, -0.01881878f, 0.00039767f, -0.11339740f, 0.09306148f, 
    0.03772601f, 0.07379596f, 0.18513106f, 0.12928787f, -0.20432305f, -0.08354973f, 0.09242111f, -0.00812606f, 
    0.07503485f, 0.22642459f, 0.12924324f, 0.15498720f, 0.03633842f, -0.11171439f, 0.03722092f, 0.03510352f, 
    -0.49340880f, 0.23886797f, 0.26016474f, -0.04035980f, 0.09193271f, -0.02256669f, 0.17460692f, 0.04272094f, 
    -0.05676341f, -0.04240263f, 0.03373470f, 0.21778430f, -0.68563610f, 0.00010388f, -0.28108445f, 0.31338230f, 
    -0.02646170f, 0.21868081f, 0.22846973f, -0.07495974f, -0.14082077f, -0.00502962f, 0.07027449f, 0.02983874f, 
    0.22361456f, 0.05769689f, -0.28088638f, -0.04569894f, 0.17048426f, -0.07256640f, -0.10483248f, 0.26916531f, 
    0.05874590f, 0.18111998f, -0.03903336f, 0.07370572f, 0.19698901f, 0.13274446f, 0.25225607f, -0.19345671f, 
    0.09344337f, 0.08301742f, 0.26774701f, -0.14340682f, -0.00488146f, -0.21129106f, -0.20958546f, 0.00798223f, 
    0.55116129f, 0.18965128f, -0.00884302f, -0.14562120f, 0.19412784f, 0.07531898f, -0.04951285f, 0.19614084f, 
    0.15473795f, 0.05373212f, 0.03260462f, -0.04848963f, -0.55726629f, 0.01029410f, 0.02496684f, 0.01600985f, 
    -0.13682246f, -0.20592581f, 0.02696946f, 0.15887283f, 0.16147651f, -0.11834572f, -0.11504255f, -0.15772799f, 
    -0.32573095f, -0.45482817f, -0.18703091f, -0.11341065f, 0.16413315f, 0.22386189f, 0.13151288f, 0.15708971f, 
    0.09895842f, 0.16398132f, 0.03256334f, 0.23882222f, -0.16990975f, -0.16921230f, 0.10359973f, 0.25000581f, 
    -0.23720732f, 0.03638241f, 0.14439163f, -0.12875366f, 0.20189810f, 0.00689697f, -0.10731022f, -0.12802878f, 
    -0.10679273f, -0.20362638f, -0.11548765f, -0.11786042f, -0.12529741f, -0.20848991f, -0.14434925f, -0.22884732f, 
    0.22194827f, -0.27162582f, -0.00369476f, -0.03029557f, 0.16233079f, 0.21389291f, -0.00988933f, 0.10985502f, 
    0.27183971f, -0.04971059f, 0.18373245f, 0.25137898f, 0.16069351f, -0.06283815f, 0.35481730f, -0.02327246f, 
    -0.11803910f, -0.19218020f, 0.16714153f, -0.30544844f, -0.10009005f, -0.02822647f, 0.17395386f, 0.03461407f, 
    0.16073576f, 0.12402489f, 0.02634940f, 0.12561888f, -0.31721854f, 0.02544594f, -0.41038778f, 0.35678750f, 
    0.01875308f, -0.00266641f, 0.02559848f, -0.03530040f, -0.14652431f, -0.15393421f, -0.13369320f, 0.02739358f, 
    0.13131431f, 0.12396485f, 0.08018003f, -0.44811007f, 0.14420140f, 0.19740756f, 0.02947729f, 0.16400722f, 
    0.02521826f, -0.09490811f, 0.04541727f, -0.06680957f, 0.05557176f, 0.11946978f, 0.07683747f, -0.18243837f, 
    0.05416217f, 0.06318805f, 0.02437621f, 0.14531122f, 0.17822874f, -0.21871915f, -0.00127388f, -0.04388946f, 
    -0.28076786f, -0.09700824f, 0.14898033f, 0.05615244f, 0.12223742f, 0.20902950f, 0.01328105f, 0.17202702f, 
    -0.20637850f, 0.04822388f, -0.12253495f, -0.03736600f, 0.29747391f, 0.39793313f, 0.38514999f, 0.32102638f, 
    0.02382435f, 0.19258362f, 0.06560795f, -0.05636860f, -0.10413934f, 0.03175489f, -0.04189971f, -0.04755304f, 
    0.12384294f, 0.29260349f, 0.18811634f, 0.08720054f, -0.01506420f, 0.17233543f, 0.23086987f, 0.38705602f, 
    0.13173509f, -0.03498185f, -0.13994317f, 0.06601653f, -0.15034290f, 0.01923184f, 0.11534689f, 0.19677801f, 
    -0.03854455f, 0.20247656f, 0.02050116f, -0.21386842f, 0.04385088f, -0.08608600f, -0.07371542f, -0.08806109f, 
    0.06141235f, -0.19097054f, -0.00803224f, 0.02131049f, -0.14900497f, 0.02718725f, -0.35489395f, 0.10218104f, 
    -0.01133648f, 0.01099753f, -0.12490888f, -0.13376522f, 0.50452662f, 0.23626339f, -0.02430605f, 0.15173203f, 
    0.25366753f, 0.04412140f, 0.08208158f, 0.26252079f, 0.13250759f, -0.21786459f, 0.02874318f, 0.01051280f, 
    -0.07097474f, 0.14516769f, -0.07643200f, -0.04564598f, 0.13677718f, -0.11516317f, 0.18969910f, 0.19622229f, 
    -0.01431002f, -0.01701280f, 0.12146940f, 0.04321543f, 0.21370775f, -0.02066834f, 0.42367995f, 0.14983273f, 
    0.17960173f, 0.13968143f, 0.18286356f, -0.00828029f, -0.02455339f, -0.00366072f, -0.16875118f, 0.10784049f, 
    -0.18707576f, 0.03725054f, -0.04863091f, -0.07860465f, -0.12198909f, 0.22217049f, 0.12466950f, 0.15950739f, 
    0.05375810f, 0.04783286f, -0.03941484f, -0.11009879f, -0.20090047f, -0.03375357f, 0.14305608f, 0.00641341f, 
    -0.03227084f, 0.05464755f, 0.20549217f, 0.04487331f, 0.02841254f, -0.17454495f, -0.16674325f, -0.13997880f, 
    -0.22635612f, -0.31649557f, -0.21112087f, 0.05856897f, 0.10052142f, 0.09052412f, 0.06031307f, 0.12602040f, 
    0.16331913f, 0.02677527f, -0.04442559f, 0.19987598f, -0.05022253f, 0.16522345f, -0.04951486f, 0.01768505f, 
    -0.05040163f, 0.05475352f, -0.13086131f, 0.04613747f, 0.06123902f, 0.05942477f, 0.05149851f, 0.07476982f, 
    0.03063961f, 0.39645830f, 0.00087498f, 0.19902071f, 0.28403589f, 0.01285474f, -0.04838005f, -0.29409117f, 
    0.11994034f, -0.12825815f, 0.05812377f, -0.10400262f, -0.19767328f, -0.09683634f, 0.11075175f, 0.18939175f, 
    0.12582454f, -0.05693882f, -0.03360875f, 0.05391501f, 0.07223556f, -0.04904212f, -0.12790941f, 0.01524856f, 
    0.06800897f, 0.21433456f, 0.15232879f, 0.09113474f, 0.09843892f, 0.05309656f, -0.12408430f, -0.11877453f, 
    0.12129108f, 0.03327390f, -0.15265182f, 0.20724462f, -0.25629720f, 0.19902405f, 0.07023177f, -0.18452872f, 
    0.02366907f, 0.00416852f, -0.16065253f, -0.05480482f, -0.09920184f, 0.03048733f, 0.03245161f, -0.02674902f, 
    -0.44945952f, -0.06666076f, -0.21235295f, 0.01455454f, -0.03216571f, 0.03135080f, -0.10788546f, 0.00251246f, 
    0.22234216f, 0.07527171f, -0.02059027f, 0.30220804f, 0.11367556f, 0.31086174f, 0.31156832f, 0.27470669f, 
    -0.12177460f, -0.02973303f, -0.00507886f, 0.10037418f, -0.04530892f, -0.00469851f, 0.18118553f, -0.07858052f, 
    -0.12338330f, 0.20714615f, 0.02644054f, 0.20595054f, -0.04766130f, -0.13609973f, 0.14595555f, 0.20812304f, 
    0.14821464f, 0.07412996f, -0.03299990f, 0.03982968f, -0.15712629f, 0.02470762f, -0.12229278f, 0.02971939f, 
    0.25864780f, -0.06143414f, -0.09699931f, 0.13530923f, 0.21410914f, 0.03476446f, -0.03127373f, 0.06916415f, 
    -0.09690571f, -0.29008058f, 0.06766099f, 0.04781404f, 0.01844047f, -0.00213618f, 0.14928733f, -0.11209034f, 
    -0.02653966f, 0.13790800f, 0.00578506f, -0.05824682f, 0.01878516f, 0.06239342f, 0.21392202f, 0.35844213f, 
    -0.19593354f, 0.07091073f, 0.07669833f, 0.21962531f, 0.01768219f, -0.10100133f, 0.11453372f, -0.02977250f, 
    0.20941347f, -0.00138270f, 0.19871378f, -0.00633150f, 0.05632713f, 0.02151536f, -0.14273950f, 0.05278215f, 
    -0.11902938f, -0.01493456f, -0.03601638f, 0.12926058f, 0.17419587f, 0.33313793f, 0.03469388f, -0.11970256f, 
    -0.01449370f, -0.02012485f, -0.06028960f, -0.08233156f, -0.04585251f, -0.12250261f, 0.11802422f, -0.08080667f, 
    0.15110001f, -0.22185609f, -0.18456724f, -0.40479496f, 0.00501486f, 0.03386384f, 0.00227191f, 0.07134689f, 
    0.01743512f, 0.02243247f, -0.10559665f, -0.14286104f, -0.13701403f, -0.03446171f, 0.20504940f, -0.02116641f, 
    0.20866366f, 0.07445917f, 0.08752520f, -0.08285560f, 0.07294085f, 0.10438447f, -0.11710726f, 0.10992815f, 
    -0.23819457f, -0.30260769f, -0.06136712f, -0.07419429f, 0.05588626f, 0.03194995f, -0.05180178f, -0.13872480f, 
    0.15061991f, -0.09706491f, -0.02560673f, -0.04643213f, 0.05811803f, 0.15516447f, 0.01563551f, 0.18284191f, 
    -0.05631349f, 0.08193929f, -0.00563743f, -0.17334792f, 0.04572251f, -0.08743301f, -0.09135501f, 0.05143022f, 
    0.41206542f, -0.48378527f, -0.07256301f, -0.02126108f, -0.05643415f, 0.00408399f, 0.18754014f, 0.26203880f, 
    -0.07341148f, 0.06746942f, 0.16720046f, 0.12860261f, 0.13899253f, -0.15334216f, -0.53769916f, 0.08234344f, 
    -0.03806028f, -0.07697389f, 0.08695257f, -0.01352696f, -0.03793924f, -0.00374869f, -0.02020781f, -0.17063306f, 
    0.09877208f, -0.17431913f, 0.15297048f, 0.04997580f, 0.06026613f, -0.08851017f, -0.12608354f, -0.10719116f, 
    0.07479059f, 0.09094111f, 0.05301024f, -0.04912983f, 0.36166081f, -0.01024075f, 0.56198502f, -0.69728595f, 
    0.00722121f, 0.10936104f, 0.03355630f, -0.06975289f, -0.07495832f, -0.04769054f, -0.04858371f, -0.05352192f, 
    -0.18093146f, 0.03424277f, 0.13375720f, -0.18771394f, -0.14017169f, -0.00512079f, 0.07216414f, -0.04880926f, 
    0.06547076f, 0.10140736f, 0.15366912f, 0.07623031f, 0.11797211f, 0.16083160f, -0.06983760f, -0.07559588f, 
    -0.06011711f, 0.03916800f, 0.02260098f, 0.08392100f, 0.01411322f, -0.01766924f, 0.01217283f, -0.06913354f, 
    0.43408453f, 0.08855311f, -0.15361400f, -0.06923830f, -0.04330518f, -0.04896692f, 0.01191642f, 0.11729726f, 
    -0.13924342f, 0.11205509f, -0.25903252f, -0.09831899f, 0.71052182f, -0.17342825f, 0.14860769f, -0.38516697f, 
    0.19385968f, 0.02008439f, 0.05324251f, 0.20022476f, 0.02420539f, 0.20750134f, -0.02980855f, 0.17825794f, 
    0.25977412f, -0.48320544f, 0.50462294f, -0.15647815f, -0.03163021f, 0.11738501f, 0.21659960f, 0.03212891f, 
    -0.06846957f, -0.15086295f, 0.12984045f, 0.06915574f, -0.26918432f, -0.02077159f, -0.19438924f, 0.06586464f, 
    0.05567176f, 0.05192171f, -0.00562828f, 0.01938307f, -0.03954789f, -0.00240303f, 0.13409963f, 0.03036860f, 
    -0.02510151f, 0.07730442f, 0.21446009f, 0.11599658f, 0.02708285f, 0.09348778f, -0.01216816f, 0.08874790f, 
    0.01266642f, -0.13265309f, -0.01698753f, 0.04798860f, -0.14992878f, 0.06261360f, -0.16984448f, -0.16564439f, 
    0.03733604f, 0.08884300f, -0.11323309f, -0.06532399f, -0.23446779f, -0.00751543f, -0.03018460f, -0.12730370f, 
    0.20459898f, 0.20611224f, -0.16502230f, 0.02048824f, -0.11578631f, 0.01612923f, -0.12578742f, -0.27531624f, 
    0.05389712f, 0.02943555f, 0.04658836f, -0.04087473f, 0.05710537f, 0.01385960f, 0.00095941f, -0.16125728f, 
    -0.05410524f, -0.03857578f, -0.05302788f, 0.13656086f, 0.05418693f, 0.09971109f, 0.10454144f, 0.23284359f, 
    -0.07504766f, 0.04431180f, 0.13717817f, 0.07495626f, -0.10927416f, -0.05856255f, -0.07688504f, 0.04380272f, 
    -0.26859540f, 0.20873219f, -0.14409548f, 0.02196449f, -0.04478680f, 0.24406277f, 0.33193135f, -0.10674671f, 
    -0.16892980f, -0.10393307f, -0.08284957f, -0.03884553f, -0.10493250f, 0.13033205f, -0.15639274f, 0.04511984f, 
    0.01669709f, 0.28244677f, -0.14585549f, 0.40003780f, -0.12894562f, 0.06054781f, 0.04210727f, 0.16767134f, 
    -0.03209487f, 0.04998783f, 0.14761731f, 0.07617971f, 0.19774881f, -0.22515215f, 0.42348242f, 0.08436596f, 
    -0.06042155f, -0.15863582f, -0.06150318f, -0.05528898f, -0.05717385f, 0.06995844f, 0.04953691f, -0.03667047f, 
    -0.20251603f, -0.15548669f, -0.21054974f, 0.07731725f, 0.08156196f, -0.01759267f, -0.12235170f, 0.03093263f, 
    0.03479996f, -0.07343367f, -0.01201682f, -0.14772643f, 0.31547570f, 0.10371903f, 0.06459013f, 0.03019406f, 
    0.11380544f, 0.07303376f, -0.05370416f, 0.07519303f, -0.04826661f, -0.05092284f, -0.00062543f, 0.02448591f, 
    -0.04362794f, -0.05097334f, 0.02512767f, -0.06473832f, -0.01031775f, -0.01951436f, 0.05616579f, -0.06073818f, 
    -0.04227388f, 0.01541784f, -0.03419213f, -0.04654868f, -0.03393156f, 0.03598423f, -0.04941446f, 0.07251968f, 
    -0.02831870f, -0.03100855f, 0.06299812f, -0.02797535f, -0.01803459f, 0.05591144f, 0.01617984f, -0.03431925f, 
    0.01160230f, -0.03150018f, -0.04555513f, 0.04383143f, 0.02648798f, 0.06241572f, 0.03388521f, 0.03261391f, 
    -0.00612950f, -0.00486651f, -0.04979283f, -0.01744487f, -0.07109812f, -0.00635989f, -0.00198437f, 0.03415021f, 
    -0.04038185f, -0.07940838f, 0.02291205f, 0.00840050f, -0.03342320f, -0.06457389f, -0.03277089f, 0.04116941f, 
    0.03786860f, 0.02206101f, -0.04281469f, -0.04595912f, 0.01607464f, 0.02169859f, -0.04669703f, 0.02297845f, 
    0.03583696f, 0.03222733f, -0.05661845f, -0.04823284f, -0.04998138f, 0.05876389f, -0.07617467f, 0.03765780f, 
    -0.02417027f, 0.00232610f, -0.06229768f, 0.00679611f, -0.05095034f, -0.01098359f, 0.00693541f, -0.04002465f, 
    0.05247764f, -0.03135004f, 0.00375508f, 0.00651474f, -0.03103674f, -0.07355198f, -0.07254191f, -0.00692212f, 
    0.04814085f, -0.03681235f, -0.01962606f, 0.05150245f, 0.05389844f, -0.01703500f, -0.01311294f, -0.00176257f, 
    -0.01763035f, -0.07977460f, -0.04500308f, 0.00654706f, -0.00992654f, 0.00675526f, 0.00151131f, -0.02786008f, 
    -0.02560362f, 0.06849603f, -0.01165590f, -0.06664531f, -0.03947931f, -0.01444358f, 0.00169566f, -0.00137786f, 
    -0.04309183f, 0.02476941f, -0.01484184f, 0.02938135f, -0.00022742f, -0.00836282f, 0.03355452f, -0.02762477f, 
    -0.06705713f, -0.07244755f, -0.07397982f, -0.00934756f, 0.01683667f, -0.04633893f, -0.05036306f, 0.00642078f, 
    -0.00150057f, -0.00576132f, 0.05597027f, -0.01964532f, -0.04763596f, 0.03241787f, -0.02361634f, 0.04064465f, 
    -0.04391669f, -0.02016279f, 0.04341365f, 0.00219053f, -0.05346151f, 0.01206721f, -0.04950247f, -0.06920863f, 
    -0.04458113f, -0.06179619f, -0.02105991f, -0.01111621f, 0.03156044f, -0.00792321f, 0.00482501f, 0.02760655f, 
    -0.03014773f, 0.01187790f, -0.02150520f, 0.07216904f, 0.05149817f, -0.01641965f, -0.02801730f, -0.00665650f, 
    -0.07506127f, 0.05114770f, 0.05948488f, 0.06223858f, 0.04406222f, -0.03862347f, -0.06916499f, -0.02627005f, 
    0.02012868f, -0.06825245f, 0.01841643f, 0.03975783f, -0.04000390f, 0.01400659f, 0.01532579f, -0.05349402f, 
    0.03130512f, -0.00524508f, 0.04578191f, 0.05068380f, 0.02215641f, -0.00795397f, -0.06718242f, -0.03570834f, 
    -0.07780680f, -0.00694001f, 0.02491567f, 0.05614618f, -0.07055420f, -0.00141251f, 0.02025430f, 0.02067423f, 
    0.02680836f, 0.05204942f, 0.03493338f, 0.06130196f, -0.04648193f, -0.06873771f, -0.00953245f, -0.06701896f, 
    -0.18421768f, -0.24431999f, 0.18950172f, 0.22851694f, 0.09290747f, 0.11289506f, -0.15058269f, 0.02641181f, 
    0.16340904f, 0.20102389f, 0.10349397f, 0.06311134f, -0.09283101f, -0.09366361f, -0.00756394f, -0.00590022f, 
    -0.02179942f, -0.09895752f, 0.11618645f, 0.07115882f, 0.05407919f, -0.07866719f, 0.00578706f, 0.16111355f, 
    -0.29507542f, -0.11032909f, 0.29411763f, 0.03565531f, -0.06904906f, -0.04908822f, 0.04863624f, -0.15604897f, 
    0.17614104f, 0.04981242f, 0.13718764f, 0.06111715f, -0.29745701f, 0.27852720f, -0.26735201f, 0.19716397f, 
    0.03555441f, -0.00230878f, 0.15679790f, -0.17190345f, 0.02464913f, -0.19370319f, -0.00815312f, 0.01807113f, 
    -0.28121826f, 0.51700270f, -0.31922072f, -0.16087998f, 0.18112046f, -0.06651820f, -0.12389677f, 0.05857851f, 
    0.13569738f, -0.00090781f, 0.00470539f, 0.00780085f, 0.09179309f, 0.20160839f, 0.03505368f, -0.09495010f, 
    0.02252061f, 0.08017044f, 0.11508337f, -0.03896951f, 0.01877708f, -0.11489641f, -0.09405449f, 0.00586147f, 
    0.06184015f, -0.12474681f, 0.09337831f, -0.09206226f, 0.26993608f, 0.02051112f, -0.02981000f, 0.30463833f, 
    0.12557542f, 0.05881089f, 0.15910178f, -0.16457164f, -0.36135170f, -0.13870130f, -0.05858005f, 0.14827473f, 
    -0.09071583f, -0.22783682f, 0.03831658f, -0.15954107f, 0.03874211f, -0.12737267f, 0.08752788f, 0.20213583f, 
    -0.23818442f, -0.34888330f, 0.12230799f, -0.21376400f, 0.26769096f, 0.25136834f, 0.24854310f, 0.35604638f, 
    0.01585152f, 0.01687844f, -0.05276506f, 0.18227562f, 0.03135296f, -0.18241321f, 0.15994343f, 0.11405744f, 
    -0.17355454f, 0.06884211f, -0.16302565f, -0.07759669f, 0.09844580f, -0.11011738f, -0.07889186f, -0.16272001f, 
    -0.09723695f, 0.04933447f, -0.26247203f, -0.16334547f, -0.03378192f, -0.07677745f, 0.02353668f, -0.01665345f, 
    0.11853509f, 0.00952954f, 0.21537124f, 0.04488213f, 0.42746475f, 0.21883677f, -0.41982985f, 0.12374651f, 
    0.04008690f, -0.00317118f, 0.18987021f, 0.08577911f, 0.04003510f, 0.07137309f, 0.25297070f, -0.06589583f, 
    -0.15847066f, -0.15917546f, 0.14528860f, -0.09737966f, 0.05450945f, 0.04935012f, -0.25918838f, 0.02680242f, 
    -0.05027688f, 0.01464332f, 0.11842865f, 0.13715477f, 0.12255941f, -0.03183016f, -0.23077711f, 0.35103586f, 
    0.07887553f, 0.14268638f, 0.10674242f, -0.03895292f, -0.00813750f, -0.14634073f, -0.03013201f, 0.03858126f, 
    -0.19016239f, 0.25449434f, -0.02022556f, -0.21661095f, -0.09078018f, 0.05580527f, -0.05523189f, 0.20702390f, 
    -0.08337196f, -0.02633847f, 0.06556629f, 0.04865290f, -0.40407750f, -0.00847239f, 0.35739800f, -0.19572379f, 
    -0.06274322f, -0.07767861f, 0.04119092f, -0.01359911f, -0.00792107f, -0.06893836f, 0.17280149f, -0.05048715f, 
    0.19198671f, 0.05649032f, 0.17461832f, 0.14636375f, -0.05269001f, -0.01258577f, -0.02758620f, -0.15405126f, 
    -0.07259145f, -0.16673143f, -0.08211553f, 0.13735297f, -0.43447417f, -0.25831217f, -0.49939799f, -0.38024309f, 
    0.03576225f, -0.13582624f, 0.10750239f, 0.13179374f, -0.04541678f, -0.09086123f, -0.04622046f, -0.04159031f, 
    -0.08531420f, -0.28834864f, -0.39716980f, -0.32835478f, 0.16133291f, 0.04763420f, -0.08782298f, 0.08379749f, 
    -0.06804552f, 0.03830459f, 0.04978354f, 0.05684655f, -0.10597151f, 0.33836871f, 0.15327220f, -0.01841584f, 
    -0.01874351f, -0.07536218f, 0.02474974f, 0.12327187f, 0.10489304f, 0.09637660f, -0.03146430f, -0.21472262f, 
    0.54039627f, 0.43103793f, -0.23058540f, 0.24418010f, 0.10044395f, -0.06535803f, 0.24168736f, -0.09235080f, 
    0.28330624f, 0.06254198f, 0.27816850f, 0.23648450f, -0.53506541f, 0.04216613f, -0.18597493f, -0.65656245f, 
    0.17015788f, 0.05103303f, 0.15295942f, 0.19751935f, -0.22458428f, 0.04582481f, 0.05853740f, 0.01115673f, 
    0.01502979f, -0.43764657f, -0.34928122f, 0.06856991f, -0.11000374f, -0.15409695f, 0.18673921f, 0.04398740f, 
    -0.00904027f, 0.00739696f, 0.00558270f, 0.03461987f, 0.09863607f, -0.41890812f, -0.07490743f, -0.46514753f, 
    -0.16146943f, 0.09218594f, -0.16019340f, 0.11305732f, 0.07993162f, -0.09730870f, 0.13885924f, -0.02704282f, 
    -0.01945355f, 0.08224177f, 0.04349861f, 0.04901317f, 0.09493969f, -0.17455998f, 0.08974582f, 0.03207778f, 
    -0.16331688f, -0.17736161f, -0.02633741f, -0.08514598f, 0.21480083f, -0.00018201f, 0.27421850f, 0.37568706f, 
    0.01871958f, -0.04680897f, -0.01460229f, 0.02658947f, -0.12778585f, -0.07091899f, -0.08840664f, -0.07852057f, 
    0.28395522f, 0.22435369f, 0.24493243f, 0.06325001f, -0.11139555f, -0.08280508f, 0.00451096f, 0.03947262f, 
    0.25792518f, 0.03649708f, 0.16571763f, 0.02144631f, 0.44389135f, -0.16749765f, -0.36059892f, -0.03044049f, 
    -0.15605560f, -0.08174351f, 0.23652193f, 0.05130128f, 0.11270634f, 0.38130584f, 0.00310817f, 0.22504571f, 
    0.36745709f, -0.29950979f, -0.06918812f, -0.32175741f, 0.10854987f, 0.03521545f, 0.02410544f, -0.29304186f, 
    0.03425742f, 0.09076725f, -0.10618610f, 0.07978601f, 0.59931338f, 0.44949117f, -0.03668207f, 0.12055209f, 
    -0.31909949f, 0.02745052f, 0.21355528f, -0.06957795f, 0.03444197f, 0.00776337f, 0.20697610f, 0.08189047f, 
    0.19986171f, -0.18928821f, -0.27814391f, -0.06274997f, 0.12124091f, -0.03149303f, -0.11623164f, -0.02011191f, 
    0.14025767f, -0.00172680f, 0.04773960f, -0.15155469f, 0.12772277f, -0.30277002f, -0.01712269f, -0.20100656f, 
    0.01758099f, -0.23591886f, -0.00303252f, 0.04518532f, 0.05982888f, 0.17587474f, -0.02546030f, -0.11117951f, 
    -0.04981621f, 0.05980961f, 0.12585875f, -0.20195101f, 0.02362832f, 0.13361739f, -0.03757094f, 0.13814746f, 
    0.01078994f, 0.05493119f, -0.05335777f, -0.01675278f, 0.01170407f, 0.14747709f, -0.03576016f, 0.47715625f, 
    -0.21851198f, -0.05043973f, 0.03153372f, -0.18523291f, -0.22870664f, 0.05199061f, -0.15203361f, -0.10059187f, 
    -0.02173965f, -0.26980403f, 0.05272400f, 0.18139566f, 0.19066547f, -0.02838573f, 0.07465832f, -0.18881486f, 
    -0.00978216f, -0.03768080f, -0.00714387f, -0.03572122f, -0.00004918f, 0.18179651f, -0.05759162f, 0.10529389f, 
    -0.15195435f, 0.32809925f, -0.04813713f, 0.05827005f, -0.13700655f, -0.09200013f, -0.12819913f, -0.03340508f, 
    0.20261219f, -0.04629307f, 0.25375879f, -0.14418855f, -0.07533921f, -0.06918095f, 0.01318664f, -0.01728971f, 
    -0.13165081f, -0.01969181f, 0.03972626f, 0.11020042f, 0.10737652f, 0.28689992f, 0.05963305f, 0.25663820f, 
    0.01647668f, -0.05319018f, -0.15880562f, 0.24763052f, 0.05999694f, 0.01922546f, -0.15077971f, -0.02509877f, 
    -0.48654830f, 0.11861826f, 0.03986422f, 0.11056969f, 0.15864699f, 0.09898294f, -0.10973921f, 0.16118768f, 
    -0.06932125f, -0.11899775f, 0.07276094f, 0.02424442f, 0.07912052f, 0.36421198f, -0.10039483f, 0.20886090f, 
    0.04011523f, -0.13054027f, 0.21659476f, 0.02549408f, -0.01360509f, 0.00079234f, -0.09640338f, 0.15222865f, 
    -0.19704030f, -0.05589344f, 0.18928130f, 0.02865654f, 0.11983471f, 0.02160699f, -0.00751238f, 0.29880616f, 
    -0.11709240f, -0.21517684f, -0.00848159f, -0.25705731f, -0.13653184f, 0.22594540f, 0.07576831f, -0.19535342f, 
    0.04482996f, -0.08109146f, -0.13552921f, -0.12603870f, -0.16941069f, -0.27816987f, -0.06730421f, -0.01714166f, 
    -0.09093901f, -0.01389053f, -0.35047746f, -0.19479588f, -0.12123311f, -0.09797735f, 0.16773148f, 0.14366181f, 
    0.04691840f, 0.28667662f, 0.29205877f, 0.03109563f, 0.27461904f, 0.06113179f, -0.23611276f, 0.09231199f, 
    0.01594280f, 0.07275969f, -0.03566317f, -0.19239038f, 0.08734953f, 0.03873661f, 0.13752444f, -0.10976280f, 
    -0.02411686f, 0.13105795f, 0.16150568f, 0.56045151f, 0.02089388f, -0.00020445f, -0.25786984f, 0.01612613f, 
    -0.04570309f, -0.06884700f, 0.11544983f, -0.02137390f, 0.35909036f, -0.14129552f, 0.29095531f, 0.02886226f, 
    0.02831608f, 0.08918400f, -0.00500066f, -0.12863591f, 0.13054360f, 0.19680806f, 0.08977903f, -0.03824176f, 
    -0.13538155f, 0.49291655f, 0.03277168f, 0.14922540f, 0.05225865f, -0.03996868f, -0.08238428f, 0.07530753f, 
    0.00643923f, 0.01729050f, -0.21591133f, 0.11755486f, -0.32522351f, 0.20880982f, 0.14946310f, 0.21245210f, 
    0.11970115f, 0.05590749f, -0.04420803f, 0.09757774f, 0.07055248f, 0.00255572f, 0.06388173f, -0.11478745f, 
    -0.24406371f, -0.21838343f, 0.32975894f, -0.20956375f, -0.00440144f, -0.19246717f, -0.08299887f, -0.10457529f, 
    0.10290448f, -0.03800297f, 0.12161026f, -0.17868584f, -0.08258217f, -0.07116943f, -0.19512604f, -0.19257414f, 
    0.06724774f, -0.08963699f, 0.13788287f, 0.08998284f, 0.09059086f, -0.00096724f, -0.06219840f, 0.20545392f, 
    0.16175151f, -0.21181513f, 0.11062922f, -0.13661689f, 0.02677132f, 0.06945217f, 0.02026899f, -0.05948080f, 
    -0.12835166f, 0.04973778f, 0.07034589f, -0.02563548f, 0.33879492f, 0.12208990f, -0.00538734f, -0.16925672f, 
    -0.14109139f, 0.08073670f, 0.05388702f, 0.32460392f, -0.23569742f, 0.04153541f, -0.13636138f, 0.04753910f, 
    0.17598303f, -0.00226856f, 0.13523461f, -0.06622849f, 0.05933031f, 0.04963646f, 0.01374783f, 0.11444028f, 
    0.09932777f, 0.04045023f, 0.08358870f, 0.05240423f, -0.20657679f, 0.39893052f, -0.19572574f, -0.15625151f, 
    -0.01095705f, 0.22668746f, -0.07918590f, -0.06925163f, -0.11201390f, 0.06251478f, -0.04390340f, 0.12731445f, 
    0.23472075f, -0.06107699f, 0.06208142f, 0.04577189f, 0.05056386f, 0.12209970f, 0.10158602f, 0.19757482f, 
    0.16771378f, 0.07187314f, -0.00628036f, -0.18205941f, -0.38791329f, -0.28793234f, -0.43520752f, -0.20694184f, 
    -0.03281872f, 0.07457837f, -0.20367554f, 0.03247694f, -0.03382741f, 0.09205204f, 0.10668673f, 0.04139428f, 
    -0.22873873f, -0.05913648f, 0.04581475f, 0.07240530f, 0.25317439f, 0.00726446f, 0.05119843f, -0.02526217f, 
    0.06512747f, 0.00608223f, 0.11918404f, 0.32868889f, 0.01603471f, -0.10350410f, 0.22536749f, 0.05661261f, 
    -0.11937094f, -0.05306116f, -0.24134439f, -0.06888534f, 0.06631879f, 0.00451876f, 0.14475450f, 0.05125250f, 
    -0.05804513f, 0.16294676f, -0.05432885f, -0.14234738f, -0.10125281f, -0.12529282f, -0.04796208f, 0.00938996f, 
    -0.13625890f, 0.13745582f, 0.28851140f, -0.13944259f, 0.36916974f, 0.13431571f, -0.11598863f, -0.08705662f, 
    -0.08679278f, 0.08742231f, 0.13426268f, 0.11115244f, -0.04143855f, 0.03518844f, 0.09312135f, -0.21507402f, 
    -0.33367547f, 0.25315106f, -0.04491511f, 0.32255676f, -0.01796048f, 0.15923546f, -0.20743784f, -0.06636044f, 
    0.03393981f, 0.20660231f, 0.08079594f, 0.18332753f, 0.05399317f, -0.40347070f, 0.33886606f, 0.19477692f, 
    -0.20471719f, 0.19498280f, 0.02834676f, -0.06443886f, 0.01037415f, -0.07142435f, 0.02075060f, 0.09583381f, 
    -0.10234462f, 0.14471576f, -0.38682604f, -0.12098348f, 0.04442009f, 0.02680846f, -0.05298512f, 0.23814698f, 
    0.03388849f, -0.03316112f, -0.04342605f, -0.25806662f, 0.23365106f, -0.35367385f, -0.15140583f, 0.47065940f, 
    0.10661336f, -0.13848364f, 0.06311055f, 0.16462635f, 0.15457809f, -0.03173215f, 0.13159096f, 0.04927297f, 
    0.10074589f, -0.10196170f, -0.16149288f, -0.14054346f, 0.06137217f, 0.01072282f, 0.12575077f, 0.12534116f, 
    0.04366941f, 0.10461943f, 0.04502169f, 0.15419360f, 0.17321819f, 0.01149343f, 0.15085819f, -0.07223330f, 
    0.02497477f, 0.06050178f, -0.12542738f, 0.02328652f, -0.00243619f, -0.18476030f, -0.05538766f, -0.01228797f, 
    0.06651351f, 0.35311577f, -0.01425226f, 0.08904850f, 0.07686821f, -0.06812117f, 0.02920577f, -0.04458776f, 
    -0.10897884f, -0.03511139f, -0.01920649f, 0.09439094f, -0.05868017f, -0.12401753f, 0.19208123f, 0.15548275f, 
    0.10560539f, 0.01614430f, -0.10635329f, 0.09142008f, -0.02793005f, 0.07141465f, 0.08800078f, -0.01061500f, 
    0.12233126f, -0.06937192f, -0.17564097f, 0.33099249f, 0.13457727f, 0.12646967f, -0.23570165f, 0.01525988f, 
    -0.09869824f, 0.12753452f, -0.02463780f, -0.14472903f, 0.21212398f, -0.11835661f, 0.23609941f, -0.08485839f, 
    0.11628255f, 0.10772859f, 0.00535351f, -0.08929548f, 0.15193392f, -0.10318284f, -0.17717585f, -0.11987466f, 
    0.54090160f, 0.24849798f, -0.04110058f, 0.05594912f, -0.10024676f, 0.04880969f, 0.06628522f, -0.22494043f, 
    -0.03368177f, 0.01654928f, -0.05557697f, 0.12264439f, -0.16665250f, -0.13659221f, 0.20759946f, 0.01251083f, 
    -0.01933805f, 0.12914956f, 0.11040974f, 0.34226361f, 0.21859963f, 0.04973603f, -0.08399554f, -0.03429765f, 
    0.14690317f, 0.09200006f, -0.04860168f, 0.22902818f, -0.01011667f, -0.01666143f, -0.10994770f, -0.12270711f, 
    -0.05381953f, 0.12615408f, -0.03186723f, -0.06172029f, 0.17436837f, 0.10393029f, -0.15489231f, -0.03207782f, 
    -0.00355989f, -0.11492385f, 0.18296726f, -0.01761966f, -0.07367288f, 0.05352563f, -0.01474039f, 0.12189781f, 
    -0.07674973f, -0.17018890f, 0.04064443f, 0.03718984f, 0.06012380f, 0.07078161f, -0.06804989f, -0.04883464f, 
    0.24058349f, -0.03327933f, -0.12701204f, 0.11892595f, -0.36860329f, -0.02926448f, 0.30103448f, 0.04069378f, 
    0.11552955f, -0.02173363f, -0.14340469f, 0.22168207f, 0.06249593f, 0.12379131f, 0.03352535f, 0.01323329f, 
    0.04908087f, -0.06910648f, -0.12972957f, -0.30515748f, -0.01716525f, 0.10619034f, 0.19146934f, -0.06001700f, 
    0.03814752f, -0.02304542f, -0.01590597f, -0.20553546f, -0.26791930f, 0.29208130f, -0.00061646f, 0.03712300f, 
    -0.00528390f, -0.09232441f, -0.18763565f, 0.10869660f, -0.09554512f, 0.02034458f, 0.10935941f, 0.04601394f, 
    0.07924934f, -0.19975060f, 0.09916729f, -0.04332566f, 0.16477154f, 0.36679384f, 0.13212080f, -0.04283137f, 
    0.15018052f, -0.18315601f, 0.00207924f, 0.03098569f, 0.17946254f, 0.15694258f, -0.48675072f, 0.34072572f, 
    -0.00009531f, -0.01920552f, -0.02846264f, 0.02180720f, 0.12743640f, -0.05503530f, 0.01589436f, 0.08414837f, 
    0.01275477f, 0.13150293f, -0.13253914f, 0.21394658f, 0.01600395f, 0.15126579f, -0.17759801f, 0.00527969f, 
    0.08193500f, 0.08337276f, -0.13906336f, -0.22501279f, -0.23856233f, -0.22755116f, -0.00778737f, 0.18101367f, 
    -0.05862989f, -0.03653361f, 0.06476407f, -0.12083846f, -0.10476517f, -0.11181118f, -0.18405394f, -0.00394864f, 
    -0.28919303f, -0.23092635f, 0.08590422f, 0.11234767f, 0.06116980f, 0.09918864f, -0.11057360f, -0.02685817f, 
    0.07855703f, -0.05985710f, 0.05456127f, 0.08843554f, -0.36305428f, 0.21994747f, -0.46012783f, 0.18243879f, 
    0.09234009f, -0.00494315f, -0.07033554f, -0.12739825f, -0.02272808f, -0.03572773f, -0.00346692f, -0.17929824f, 
    -0.06303085f, 0.62854326f, -0.27962598f, 0.02064149f, -0.01084141f, -0.13072272f, -0.00154102f, -0.07390220f, 
    -0.02041588f, 0.18526077f, 0.10738410f, 0.11771104f, 0.09305660f, -0.05776766f, 0.16429378f, 0.08682699f, 
    -0.15180482f, -0.10741927f, -0.01555799f, 0.03930839f, 0.15102434f, -0.05121062f, -0.20354234f, -0.11420985f, 
    -0.18467784f, 0.10123918f, 0.00429794f, -0.02698558f, 0.07921368f, 0.04989678f, 0.13685526f, -0.03486960f, 
    0.01528793f, 0.08890092f, 0.22557791f, 0.08253658f, 0.19034566f, 0.04237232f, 0.21917292f, 0.31470576f, 
    -0.25589919f, -0.05687643f, 0.05971765f, 0.03497292f, 0.10262892f, 0.03776728f, 0.07568823f, 0.16611923f, 
    -0.29473868f, -0.37921011f, 0.11082032f, -0.19773400f, 0.23960647f, -0.18157603f, 0.06726778f, 0.17344722f, 
    -0.17052360f, -0.33483633f, -0.06379893f, -0.06489062f, 0.00088309f, -0.11318305f, -0.00940195f, 0.05570493f, 
    0.21244246f, 0.05954402f, -0.16710332f, -0.22937426f, -0.27086625f, -0.27418652f, -0.07530345f, -0.07083008f, 
    -0.04530175f, 0.07164068f, -0.18852988f, -0.21363136f, -0.16617531f, 0.17406233f, 0.06834657f, 0.02154567f, 
    0.18234530f, 0.07575125f, 0.29129708f, 0.11932184f, 0.28268704f, -0.27312037f, -0.24135122f, 0.18983062f, 
    -0.03256636f, 0.11447909f, 0.09279123f, 0.12696163f, 0.11416173f, 0.27746499f, 0.22285251f, 0.12722354f, 
    0.03434249f, -0.06727026f, 0.38329616f, -0.16880360f, 0.04298958f, -0.07425237f, -0.17379496f, -0.02010686f, 
    -0.07436308f, -0.10859657f, -0.09487539f, -0.17641039f, 0.07918373f, 0.11903853f, -0.37976903f, -0.03420871f, 
    0.00955070f, 0.10646590f, 0.02700147f, 0.02884654f, -0.02810521f, -0.02840466f, 0.21315455f, 0.08597077f, 
    0.13021933f, 0.08181375f, 0.17665116f, -0.08956418f, -0.03935223f, 0.10180875f, 0.14004242f, 0.14574504f, 
    0.06749639f, 0.10853461f, 0.07827395f, 0.21016677f, -0.06427257f, 0.23515569f, 0.39247203f, 0.09584610f, 
    -0.07466917f, -0.18368973f, 0.30959645f, 0.05610264f, -0.11341086f, 0.13729900f, 0.06856822f, 0.07099932f, 
    0.21130908f, 0.20385770f, -0.04417863f, 0.01769097f, 0.05494325f, 0.11137797f, -0.05133517f, -0.15061723f, 
    -0.09534870f, 0.10251746f, 0.01639615f, 0.05012851f, -0.29578882f, -0.09379215f, -0.09268510f, 0.31760138f, 
    -0.12081362f, -0.02331874f, 0.04446410f, 0.29441699f, 0.03211396f, 0.00608879f, 0.04763026f, 0.09039834f, 
    -0.14098294f, -0.32889676f, 0.11850649f, 0.29470471f, 0.07716979f, -0.14536695f, 0.01058229f, 0.02568957f, 
    -0.06881357f, 0.00292644f, 0.01864350f, 0.04650218f, 0.06465928f, 0.23987040f, -0.27363402f, 0.05700011f, 
    0.15676203f, -0.03064934f, -0.03731959f, -0.06149122f, 0.05245987f, 0.08034127f, 0.08639513f, 0.12176458f, 
    -0.32210875f, 0.52385300f, 0.02514551f, 0.32767600f, 0.02467123f, 0.13187540f, 0.09791358f, 0.21395580f, 
    0.04353131f, -0.00949897f, 0.19729158f, 0.18723406f, -0.14288436f, 0.00920912f, -0.02322516f, 0.15312006f, 
    0.05836961f, 0.06598648f, 0.09370267f, 0.22741222f, -0.11730465f, 0.38174701f, 0.00144658f, -0.09205420f, 
    -0.20905222f, -0.11644520f, 0.13963889f, 0.27028921f, -0.06033426f, 0.25060371f, -0.16603100f, 0.24749444f, 
    -0.10853732f, 0.08401129f, -0.06864806f, -0.10959596f, 0.07746143f, -0.02164118f, -0.36429206f, -0.19736630f, 
    -0.05813869f, -0.13272321f, -0.15934931f, -0.27862880f, -0.05704451f, -0.22592095f, 0.00620920f, -0.05684877f, 
    0.01469464f, -0.06683665f, 0.11997914f, -0.25524420f, -0.10002695f, 0.05946459f, -0.08505568f, 0.00031959f, 
    -0.02639477f, 0.00440294f, 0.06546028f, -0.08571239f, 0.30570680f, -0.04804012f, 0.07627809f, 0.11458357f, 
    -0.01014713f, 0.09303964f, 0.01264086f, 0.00648850f, 0.00670501f, -0.02612815f, 0.04529933f, 0.01771831f, 
    0.23539101f, 0.20696329f, 0.33328798f, -0.02905033f, -0.18115781f, -0.06722492f, -0.02246455f, -0.06640210f, 
    0.26135665f, 0.22392865f, 0.31383875f, 0.00739620f, 0.07284183f, 0.45369896f, -0.04417479f, 0.17818725f, 
    -0.00551789f, 0.11008897f, 0.03792387f, -0.12977953f, -0.03080825f, 0.03358564f, -0.00427274f, 0.05866450f, 
    0.12856488f, -0.37066627f, 0.27869052f, 0.27848768f, -0.01278475f, 0.08344682f, 0.04238930f, 0.23321696f, 
    0.05074900f, 0.06563821f, 0.28089127f, 0.22979456f, 0.74765664f, 0.13500951f, -0.24915648f, 0.02957372f, 
    -0.15682206f, -0.06788633f, 0.00868530f, -0.02888349f, -0.02249350f, 0.10300971f, 0.10238088f, 0.07530989f, 
    -0.35139391f, -0.15600207f, 0.12482217f, -0.03191021f, -0.06220895f, -0.04914164f, -0.04665978f, 0.10600672f, 
    -0.11427347f, 0.18877915f, -0.07932762f, -0.20773308f, -0.03894410f, -0.07998412f, 0.63719261f, -0.20456107f, 
    -0.14309706f, 0.03569445f, 0.02979533f, 0.05467218f, -0.04776579f, -0.11910594f, 0.19856851f, -0.01230848f, 
    -0.31310338f, 0.05830214f, 0.12813281f, 0.34061533f, -0.03199710f, 0.09152295f, -0.05723268f, -0.02450441f, 
    0.10086684f, -0.09818461f, 0.08159735f, -0.09167716f, -0.10882916f, -0.11295237f, -0.05857006f, -0.20986772f, 
    0.00113448f, -0.14166681f, 0.07327862f, -0.02623075f, -0.14185290f, -0.10479836f, -0.07588471f, -0.12224413f, 
    -0.32628012f, -0.17484997f, -0.25502917f, -0.02152583f, 0.02650666f, -0.02370436f, 0.02142977f, -0.04564973f, 
    0.10559848f, 0.05342594f, 0.08060268f, 0.00237379f, -0.09544860f, -0.08567391f, 0.08077352f, -0.18406838f, 
    0.21046229f, 0.05976813f, 0.09953172f, 0.11541591f, 0.04741513f, -0.08365811f, 0.02148216f, -0.09136446f, 
    0.29012880f, -0.01318856f, 0.29125452f, -0.59549731f, 0.05976808f, 0.03462183f, 0.33154461f, -0.13498406f, 
    -0.02872635f, 0.00577178f, 0.02712769f, 0.14802600f, -0.31993085f, -0.17118107f, -0.02264344f, 0.15915623f, 
    -0.05633881f, -0.12559436f, -0.02399166f, 0.00541458f, 0.04424953f, -0.05069660f, 0.12284186f, -0.09391572f, 
    -0.08270616f, -0.11740932f, 0.14412843f, -0.19121461f, 0.15636107f, 0.21473196f, -0.04118734f, -0.06088912f, 
    0.10245466f, 0.01798260f, 0.26435542f, 0.10281348f, -0.17225483f, 0.29439053f, 0.10597793f, 0.30904177f, 
    -0.09433243f, -0.02815834f, 0.05268165f, -0.23534085f, -0.15355709f, -0.14906816f, 0.02222922f, 0.02507355f, 
    0.05217033f, 0.04546287f, -0.03585762f, 0.00441511f, -0.10448281f, -0.01709105f, 0.00230075f, -0.01720340f, 
    -0.14036016f, -0.09383772f, -0.02998688f, -0.18198030f, -0.02548960f, 0.00685283f, 0.00296328f, 0.05248876f, 
    0.18106376f, 0.00432408f, 0.07814639f, -0.03155123f, -0.03113668f, -0.12511963f, -0.10754377f, -0.04278118f, 
    0.16304968f, 0.05180485f, -0.20348261f, 0.12852369f, -0.07193021f, 0.02720265f, -0.04382464f, 0.06495777f, 
    0.11530689f, 0.13426913f, 0.04677067f, 0.12251478f, 0.52445966f, 0.09679884f, 0.21037598f, -0.03708355f, 
    -0.05576386f, 0.00524372f, -0.03468424f, 0.05307436f, 0.07088669f, 0.25955305f, 0.00074235f, 0.17211272f, 
    0.10763769f, -0.25537327f, 0.19042411f, -0.06263230f, 0.03380863f, -0.09561761f, -0.02979930f, 0.00122872f, 
    -0.06017720f, -0.02496453f, -0.02883631f, -0.04381033f, 0.23156337f, 0.13601492f, 0.32823622f, -0.12369701f, 
    0.13847552f, -0.02251774f, -0.03904041f, -0.01638426f, 0.05067652f, 0.09222727f, 0.20435537f, 0.06380975f, 
    0.08409065f, 0.33495882f, 0.18438767f, -0.16658673f, 0.00563368f, -0.00496038f, -0.00204689f, -0.02041542f, 
    -0.03457480f, 0.14647253f, 0.29695690f, 0.24091119f, 0.09461101f, 0.35235077f, 0.32704723f, -0.34955245f, 
    0.07943410f, 0.07250966f, -0.03567565f, -0.03249199f, -0.00103508f, 0.12841801f, -0.04684389f, 0.05242072f, 
    0.26651311f, 0.14742994f, -0.61249983f, -0.66969103f, -0.22567768f, -0.11286023f, 0.05414897f, -0.00282773f, 
    0.08990388f, 0.08270136f, 0.05204022f, 0.03753310f, -0.12692097f, -0.20754603f, -0.07944754f, 0.18227905f, 
    0.04855259f, 0.18074462f, -0.15644112f, 0.06559324f, 0.04165189f, 0.03674926f, 0.05958247f, 0.19524309f, 
    0.23760787f, -0.40207762f, -0.09796365f, 0.06394406f, 0.09066701f, 0.00314312f, 0.02693720f, 0.03685286f, 
    0.05770332f, 0.16091618f, -0.19352053f, -0.08630531f, 0.59087926f, -0.15886636f, 0.05299349f, 0.07094276f, 
    -0.01915849f, -0.10950169f, 0.21161374f, -0.06261544f, 0.00569491f, 0.11951868f, 0.04316336f, 0.23852527f, 
    -0.31767774f, 0.22060682f, 0.13513725f, 0.48552290f, 0.13650739f, 0.04030200f, -0.06363638f, -0.05316385f, 
    0.14368296f, 0.02226520f, 0.09242807f, -0.05330708f, -0.11825040f, -0.51248318f, -0.06204310f, 0.07347623f, 
    0.05075596f, -0.01386910f, -0.01177567f, 0.22165129f, 0.06030861f, 0.09598631f, -0.05930638f, -0.05936080f, 
    -0.34189942f, 0.18037038f, 0.09286952f, 0.28069267f, -0.05164307f, 0.16803901f, -0.04959854f, -0.04057882f, 
    0.08039937f, 0.07193243f, -0.05547239f, -0.04627636f, 0.09407248f, -0.30046514f, -0.01132808f, 0.04085644f, 
    0.12437423f, 0.13058826f, 0.10391602f, -0.01130610f, -0.02767484f, 0.01685686f, -0.01362513f, 0.05166158f, 
    -0.13403513f, 0.25497624f, -0.00879029f, 0.07704560f, -0.06782538f, 0.13031422f, -0.13727111f, -0.04014447f, 
    -0.07644840f, 0.00241752f, 0.13941032f, 0.10280624f, 0.38716841f, 0.06817135f, -0.23050800f, -0.14911097f, 
    0.02123198f, -0.05611882f, 0.06382453f, 0.10953720f, -0.06286124f, 0.06281563f, 0.12935226f, 0.13399200f, 
    -0.23050123f, -0.15228282f, 0.28323513f, -0.14513256f, -0.25034559f, -0.17522106f, -0.24053058f, -0.07494088f, 
    -0.16892757f, 0.16136332f, -0.29709235f, -0.02816236f, -0.31706327f, 0.00504931f, 0.48107046f, 0.02216130f, 
    0.01006032f, 0.07981584f, 0.05283182f, 0.10923650f, -0.09799009f, 0.05939917f, -0.12923081f, 0.06372658f, 
    -0.26145157f, 0.12313519f, 0.16257238f, 0.05151914f, -0.12298647f, 0.13590185f, 0.12984173f, -0.03041653f, 
    0.08366336f, -0.02594906f, 0.21444450f, -0.09711610f, 0.12567715f, 0.07849754f, 0.48563340f, -0.14083675f, 
    0.05294889f, -0.07094097f, -0.17229541f, 0.09500223f, -0.10355988f, 0.00599380f, 0.09145147f, -0.01358410f, 
    -0.46988955f, -0.23004809f, 0.05492226f, 0.18643379f, -0.09798858f, 0.05122220f, 0.05858019f, 0.03106650f, 
    0.10039917f, -0.04459262f, 0.00768716f, 0.01734723f, -0.36651024f, 0.24106297f, 0.04287100f, 0.45444861f, 
    0.00252880f, 0.12779051f, -0.05201145f, 0.00044154f, -0.00153946f, 0.03679412f, 0.10584413f, 0.11180049f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01990583f, 0.11899832f, -0.05140132f, -0.15635209f, 0.20658767f, 0.03058597f, 0.12862757f, 0.05580518f, 
    -0.12043443f, -0.02798972f, 0.02824473f, -0.00255175f, 0.24874000f, 0.11948512f, -0.05186725f, -0.01804943f, 
    -0.02552104f, 0.06250887f, 0.26639104f, -0.04968642f, 0.06861613f, 0.04315598f, 0.04586989f, 0.15775743f, 
    0.07379647f, -0.06728994f, 0.05898008f, 0.05780597f, 0.15527059f, 0.09378818f, 0.28829479f, 0.10068507f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00703829f, -0.08666690f, 0.00275322f, 0.23649876f, -0.40013018f, 0.01735311f, -0.22228594f, -0.02686587f, 
    0.27329078f, 0.08326272f, -0.04786269f, 0.10915390f, -0.23527810f, 0.22313683f, -0.43753445f, 0.03920061f, 
    0.22586621f, 0.06243471f, -0.17420189f, 0.25408223f, 0.24314907f, 0.14982022f, -0.15734643f, 0.15811980f, 
    -0.03403102f, 0.03811265f, -0.25323099f, 0.06466549f, 0.09995520f, -0.03314829f, 0.13747026f, -0.19676706f, 
    0.09851952f, -0.06131758f, 0.04374528f, -0.04534860f, -0.14610510f, -0.13330960f, -0.17246133f, 0.02986704f, 
    0.14480893f, -0.09845684f, 0.00748933f, -0.17241162f, -0.05817913f, 0.05939087f, -0.02243315f, -0.08901186f, 
    -0.14660738f, -0.08574942f, -0.03809156f, 0.03064379f, -0.13870606f, -0.08239010f, -0.17678364f, -0.01023140f, 
    -0.15689735f, -0.17483497f, 0.11693190f, -0.20912328f, 0.00377692f, -0.20287007f, 0.02934685f, -0.18792337f, 
    0.09651162f, 0.10973462f, 0.64775413f, -0.23235160f, -0.23588561f, -0.20222524f, 0.38025305f, -0.13346551f, 
    -0.03611682f, -0.06538974f, 0.03058518f, -0.16067609f, 0.16516915f, -0.33906442f, -0.14257596f, 0.16261518f, 
    -0.00629401f, 0.27721986f, -0.16158313f, 0.17360051f, 0.01387816f, -0.28620470f, -0.09624115f, 0.10542788f, 
    -0.34186798f, 0.43230960f, -0.39579612f, -0.06798133f, 0.40437990f, 0.07645748f, 0.22410302f, 0.12680505f, 
    -0.00251965f, 0.02244414f, 0.15008335f, 0.38473186f, 0.37549752f, 0.26137692f, -0.02870195f, -0.06421586f, 
    0.05867938f, -0.08625197f, 0.00772711f, -0.06779809f, -0.01143904f, -0.35429788f, -0.55344951f, -0.14764711f, 
    0.13796505f, 0.08710069f, -0.12749776f, 0.30457175f, -0.00240200f, 0.48086530f, 0.03116206f, -0.05201871f, 
    -0.24233556f, 0.29327363f, 0.13071111f, -0.16711627f, -0.56455207f, 0.15288907f, -0.03732508f, 0.52681768f, 
    -0.03813646f, -0.04182978f, -0.18811826f, 0.40252012f, -0.10911181f, 0.18998697f, -0.00902990f, 0.00569870f, 
    0.26593497f, -0.12161003f, 0.19107516f, 0.06717390f, 0.03842591f, 0.36357296f, -0.23753171f, -0.11082090f, 
    0.13113593f, -0.39892292f, 0.03934218f, 0.12812419f, 0.36952302f, 0.25697044f, -0.06975958f, -0.25533837f, 
    0.54838192f, 0.21780406f, 0.38874528f, 0.04624339f, -0.38758293f, -0.08845073f, -0.39944252f, 0.06775300f, 
    0.12888648f, 0.31731904f, 0.47292247f, 0.13888137f, 0.18864746f, -0.17967853f, 0.16300848f, 0.05049447f, 
    0.38096315f, 0.13269395f, -0.12725604f, 0.15424928f, 0.08117837f, -0.39942244f, -0.21875648f, 0.06371360f, 
    0.44203418f, 0.13810040f, -0.24306805f, 0.11308106f, -0.12357575f, 0.12513134f, -0.07481156f, 0.24443896f, 
    -0.33551234f, 0.65231168f, 0.33068869f, -0.05945050f, -0.11659978f, -0.03546911f, -0.03685928f, -0.32888252f, 
    0.07865651f, 0.05856768f, 0.26234227f, -0.06728755f, 0.37163201f, 0.56712055f, 0.25366566f, -0.04127102f, 
    -0.07764602f, 0.13189982f, -0.09440152f, -0.08414999f, -0.04762765f, -0.40883234f, 0.15009208f, 0.04276829f, 
    -0.14814946f, 0.24075483f, 0.24229582f, 0.05662725f, -0.30490267f, 0.02846554f, 0.02044977f, 0.04365819f, 
    -0.00701576f, -0.14908276f, 0.20474583f, 0.25950715f, -0.09024811f, -0.21577726f, 0.02631158f, -0.21324621f, 
    -0.10571055f, 0.46414363f, -0.10062620f, -0.34574479f, 0.33646289f, 0.16663188f, 0.32494858f, -0.04121689f, 
    0.18824425f, 0.01907172f, 0.17507711f, 0.16831851f, 0.05925999f, -0.32533997f, 0.00316431f, 0.08872509f, 
    -0.38812640f, 0.12736295f, -0.17142254f, -0.50049126f, -0.42488512f, 0.12243956f, -0.07464940f, -0.12580009f, 
    0.56146163f, -0.10002561f, 0.46107927f, -0.14746067f, 0.24812634f, -0.10399155f, 0.19180794f, -0.11797844f, 
    -0.04107592f, 0.17661464f, 0.15620676f, -0.04564568f, -0.03382326f, -0.00694035f, 0.27362084f, 0.07971440f, 
    -0.11400536f, 0.02693710f, -0.15271837f, 0.00802248f, 0.32956469f, 0.14071395f, -0.33010057f, -0.13276391f, 
    -0.18988699f, 0.01096690f, -0.25527954f, -0.15489116f, 0.07833315f, -0.13141514f, 0.08891437f, -0.02023105f, 
    0.08510216f, -0.13595080f, -0.31498900f, 0.11038563f, 0.32606897f, 0.38055912f, 0.17984311f, 0.66152871f, 
    0.15311666f, 0.16392791f, -0.43957290f, 0.00248371f, 0.32918227f, 0.51329482f, 0.34405333f, 0.06525473f, 
    -0.14312036f, -0.13258506f, 0.00889511f, -0.05852172f, 0.15338844f, 0.09525541f, -0.31247464f, -0.13776529f, 
    -0.29849625f, 0.38206202f, 0.38123906f, -0.05641580f, 0.14276040f, 0.01708832f, -0.09578963f, -0.03988934f, 
    0.13667749f, -0.20782129f, -0.24427468f, 0.22578400f, -0.31384110f, -0.15868621f, 0.53894979f, -0.28034991f, 
    -0.11913770f, -0.08697738f, -0.20281129f, -0.13143562f, 0.15777794f, -0.24585599f, 0.06257427f, 0.06625278f, 
    0.31533879f, -0.00026226f, -0.04261046f, 0.13440664f, -0.09588055f, 0.01709569f, 0.12525330f, 0.06752277f, 
    0.01239597f, -0.31331411f, 0.22840060f, -0.12325837f, 0.36024302f, -0.30910364f, 0.12270980f, 0.35326812f, 
    0.34725720f, 0.15237302f, 0.01490458f, -0.12839548f, 0.24770601f, 0.32850969f, 0.29081613f, -0.75670463f, 
    0.14326394f, -0.06044477f, 0.19103286f, -0.01640732f, 0.13068599f, 0.13403009f, -0.15990855f, 0.05528511f, 
    0.25254735f, -0.09619379f, -0.05752537f, 0.13288836f, 0.29436761f, -0.19203857f, 0.12648612f, 0.16081469f, 
    -0.26869947f, -0.34125230f, 0.11001436f, 0.02632600f, 0.13927311f, -0.12548614f, -0.04771140f, 0.50383157f, 
    0.03228691f, -0.13018709f, 0.16225271f, -0.15397102f, 0.31471819f, 0.37810910f, -0.21529856f, 0.47579813f, 
    -0.13305900f, 0.08591811f, 0.07597630f, 0.16886801f, -0.33202556f, 0.02775084f, 0.27841407f, 0.16552860f, 
    -0.20672180f, -0.03654075f, -0.15078606f, -0.05689998f, 0.28886548f, 0.15762627f, -0.51408416f, -0.14585580f, 
    0.00935216f, 0.29703045f, -0.32257327f, 0.07321177f, -0.06447627f, 0.47424614f, -0.14902350f, -0.30737680f, 
    -0.60537183f, 0.37073129f, -0.00340436f, -0.01028442f, -0.00602504f, -0.00510709f, 0.20982158f, 0.73657668f, 
    0.06960871f, -0.18742412f, 0.04623006f, -0.09903479f, 0.12182584f, -0.05466625f, -0.14745803f, -0.03125320f, 
    -0.10579427f, -0.16619103f, -0.05107912f, 0.01615357f, 0.08624663f, 0.23914643f, 0.21336156f, 0.11952063f, 
    0.19513883f, -0.32160211f, 0.33950901f, 0.27349120f, 0.38719964f, -0.22784798f, 0.03578641f, 0.29857987f, 
    -0.18153118f, 0.02898232f, -0.42038497f, -0.00190100f, 0.16323383f, -0.00216296f, 0.21672116f, -0.20012201f, 
    0.05643760f, -0.29855680f, 0.11050490f, -0.27954176f, -0.02818412f, -0.25631249f, -0.13362156f, 0.04140186f, 
    -0.22653127f, 0.05767415f, 0.12585725f, -0.14619204f, 0.01653584f, -0.03671494f, 0.24029455f, 0.00299666f, 
    -0.48770031f, 0.31646702f, 0.06488810f, 0.22044143f, -0.27030748f, 0.02096468f, -0.16218375f, 0.22094318f, 
    -0.44205311f, -0.34905237f, -0.09679148f, -0.16738258f, -0.21404764f, -0.18792866f, -0.05419332f, 0.16682245f, 
    -0.14200033f, -0.32472759f, -0.10385483f, 0.08859578f, 0.02899396f, -0.04547521f, 0.14159581f, 0.02279399f, 
    -0.16873449f, 0.11783498f, 0.02680084f, 0.06988364f, 0.10212024f, 0.04057637f, -0.00466934f, -0.14598328f, 
    -0.02938963f, -0.25970760f, -0.01820790f, -0.10978924f, 0.29759485f, 0.06162661f, 0.07788301f, 0.05235996f, 
    0.50620341f, -0.23720604f, -0.23107570f, 0.17978521f, -0.19816738f, 0.37102392f, -0.02629363f, 0.32764789f, 
    -0.02261493f, -0.02085957f, 0.05255495f, -0.03367737f, 0.57176858f, 0.27431396f, 0.29943296f, -0.00241733f, 
    0.03049566f, -0.02462742f, 0.14304429f, 0.09994782f, 0.34700575f, -0.45295849f, -0.21595609f, 0.04706435f, 
    -0.01949999f, 0.21438392f, -0.23921582f, -0.29044425f, 0.12635335f, 0.19913061f, -0.02372914f, 0.06912410f, 
    -0.12043494f, 0.12293556f, -0.00027255f, -0.23638789f, -0.38646886f, 0.28042185f, 0.39127675f, 0.32747036f, 
    -0.01523893f, 0.21611141f, -0.10800240f, -0.25636294f, -0.07056819f, 0.38373020f, 0.16053629f, -0.09142565f, 
    -0.10712740f, -0.15814205f, 0.15550140f, 0.02934593f, 0.30185768f, 0.04244036f, -0.06698813f, -0.06396556f, 
    -0.21574157f, 0.04607954f, 0.41898263f, -0.04072822f, -0.27042249f, -0.21115427f, 0.12450972f, 0.30549100f, 
    -0.39077857f, 0.18870445f, 0.39506638f, -0.00563587f, 0.51696759f, 0.13357587f, -0.02119184f, 0.33465460f, 
    0.02514386f, 0.49971059f, 0.39810529f, -0.17883281f, -0.43815017f, -0.42843977f, -0.04755259f, 0.01557398f, 
    0.01127109f, 0.11407898f, 0.00598626f, 0.07320859f, 0.06689394f, 0.34925991f, -0.44613385f, 0.08981970f, 
    0.09008577f, 0.10795226f, 0.11214048f, 0.08967405f, 0.12000658f, -0.18956144f, 0.04711253f, -0.03823909f, 
    -0.03286546f, 0.26696134f, -0.53082573f, -0.01109033f, 0.25352186f, -0.21967150f, 0.29824421f, -0.02079324f, 
    -0.00894588f, -0.08049144f, 0.44925156f, 0.26572096f, -0.41141486f, -0.02770264f, 0.02002679f, 0.16662936f, 
    0.53185302f, 0.02823643f, -0.10658481f, -0.07707497f, 0.13177225f, -0.11484689f, -0.37632343f, 0.02591903f, 
    0.06450932f, -0.50899780f, -0.00560060f, 0.22583634f, -0.14245521f, -0.53362715f, 0.07954139f, -0.18616706f, 
    0.16329698f, 0.15533949f, -0.34637898f, 0.21251267f, 0.33385766f, 0.00530080f, -0.23680680f, 0.26518133f, 
    -0.01714898f, -0.57601464f, -0.31390524f, -0.02670846f, 0.14549351f, -0.00240926f, -0.15623969f, -0.08392655f, 
    -0.57602280f, -0.00610331f, 0.00096011f, -0.08531184f, -0.14596717f, -0.35831147f, 0.07171697f, -0.04363101f, 
    -0.12514265f, 0.16365273f, -0.35272720f, -0.20260583f, -0.24261180f, -0.08626769f, 0.04119519f, -0.29784945f, 
    0.34556523f, -0.56559032f, -0.39251074f, -0.07568033f, -0.23469992f, 0.48289970f, -0.09422506f, 0.13087288f, 
    -0.06988550f, 0.08960252f, 0.52754211f, -0.09350631f, -0.26297915f, -0.08686198f, 0.22706957f, -0.10396353f, 
    -0.02218801f, 0.14449872f, -0.15903839f, 0.07745880f, 0.20559938f, -0.25116199f, -0.08852491f, -0.00245778f, 
    0.16591515f, 0.32101601f, -0.15245645f, -0.08571272f, 0.02046306f, -0.27681407f, -0.13090594f, 0.28848663f, 
    0.57577354f, 0.22347656f, 0.06388187f, 0.03976771f, 0.44338956f, 0.08714672f, 0.14805432f, -0.10689023f, 
    -0.18248336f, 0.17864683f, -0.47173589f, -0.14903732f, -0.06882427f, -0.41394323f, 0.21713813f, -0.08333760f, 
    -0.25992745f, -0.17005092f, 0.16174129f, 0.03033535f, 0.08743186f, 0.34856617f, 0.04781928f, -0.04582487f, 
    0.40058872f, 0.06280522f, -0.04731443f, 0.16184394f, 0.17305097f, 0.24467772f, -0.09682824f, -0.19118683f, 
    0.35531098f, 0.08273514f, 0.36200035f, -0.27140659f, 0.07287924f, 0.29666173f, 0.23726399f, -0.23637980f, 
    0.03192084f, 0.01413673f, -0.31087580f, -0.23374723f, 0.10581900f, 0.00627485f, -0.02074864f, 0.07823128f, 
    -0.09883887f, -0.03165707f, -0.14112112f, -0.10686208f, 0.29936755f, -0.00257453f, -0.00653746f, 0.05874864f, 
    0.06466687f, -0.34808713f, 0.46915260f, -0.19655682f, -0.13090199f, 0.09518918f, 0.17192075f, 0.19201609f, 
    0.03629732f, 0.31576332f, 0.53049481f, 0.24065410f, -0.17266332f, 0.16340570f, -0.45176521f, 0.32382819f, 
    0.14407580f, 0.25588977f, -0.14103331f, 0.15007551f, -0.08913952f, 0.07305440f, -0.04938205f, -0.12921488f, 
    0.23245421f, -0.12741917f, 0.02028953f, -0.15279077f, 0.12438925f, 0.27073658f, -0.25369826f, -0.11570934f, 
    -0.16502452f, 0.30138427f, -0.02248538f, 0.14632434f, -0.06897675f, 0.16487522f, 0.06322630f, -0.31122559f, 
    0.08969849f, -0.29939112f, -0.04806275f, 0.20335256f, -0.20448557f, -0.18958196f, 0.06314301f, 0.16698936f, 
    0.05032327f, -0.29043925f, -0.01118793f, 0.01097831f, 0.05316262f, -0.06512146f, -0.28244582f, 0.09485552f, 
    -0.45682240f, -0.14672352f, -0.05365205f, 0.10703047f, 0.03330555f, -0.09723007f, -0.07777997f, 0.03904345f, 
    -0.41616356f, 0.24050905f, 0.05128806f, 0.09228157f, -0.26566646f, 0.32420963f, -0.07654036f, -0.01939208f, 
    -0.27796504f, -0.10821646f, -0.30432114f, 0.27951398f, -0.20314091f, 0.15661883f, 0.05662886f, -0.01653273f, 
    0.12383763f, -0.16943949f, 0.09946359f, 0.32396549f, 0.15197900f, 0.29771701f, 0.21659935f, -0.01314024f, 
    0.30275112f, 0.00955817f, 0.02006004f, 0.13636939f, -0.18391560f, 0.27406096f, 0.12734579f, -0.02823435f, 
    0.23614377f, -0.35574564f, 0.39232349f, 0.39431942f, 0.42477897f, -0.24513154f, 0.00659897f, -0.11602524f, 
    0.23093289f, -0.09833679f, -0.32317582f, 0.27947211f, -0.06583756f, -0.15458770f, -0.15657753f, -0.44619840f, 
    -0.08326960f, 0.43935904f, -0.27509984f, -0.26626763f, 0.06889439f, -0.08377354f, 0.11047676f, -0.12678176f, 
    -0.25037467f, -0.11313351f, -0.04241068f, 0.11216818f, 0.00639221f, 0.03327862f, -0.07619262f, -0.02832840f, 
    0.39049092f, 0.13091512f, 0.50813532f, 0.34759155f, 0.11698560f, -0.24395151f, 0.06370388f, 0.45549747f, 
    -0.06807974f, 0.24830921f, 0.16901612f, -0.16876499f, 0.30839044f, 0.06682820f, 0.44930318f, -0.51405722f, 
    -0.02583033f, -0.08329748f, -0.37423319f, 0.02852827f, 0.15905312f, 0.48871714f, -0.18073861f, -0.02853510f, 
    0.19469053f, -0.01568746f, -0.09502914f, 0.08683486f, 0.31123000f, 0.03541820f, -0.16228804f, 0.06598461f, 
    0.18158677f, 0.19218963f, 0.00330324f, 0.18257894f, 0.25302774f, 0.00775236f, -0.16247764f, 0.13549043f, 
    -0.16367599f, -0.23468471f, -0.00223302f, 0.35850754f, -0.53546435f, -0.13259068f, -0.05799584f, 0.30687994f, 
    0.04738418f, -0.11376961f, -0.16928099f, 0.05234680f, -0.05183274f, 0.08971414f, 0.08547243f, 0.10310050f, 
    -0.08526428f, -0.15959138f, -0.09637272f, -0.06019405f, 0.04483302f, -0.03015091f, -0.12295897f, 0.00119406f, 
    -0.16951026f, -0.05901171f, 0.07758027f, 0.11326309f, -0.07955740f, -0.21239434f, -0.17241699f, -0.13710572f, 
    0.00723130f, -0.06463950f, 0.11022928f, -0.17516519f, -0.07146911f, 0.01544408f, -0.09308636f, -0.14157358f, 
    0.13851492f, -0.03008339f, 0.11531819f, -0.17728570f, 0.01268098f, -0.19742726f, 0.28985569f, -0.11944465f, 
    -0.54824543f, 0.08145051f, -0.07553013f, -0.10079759f, 0.24774390f, 0.43003106f, -0.02064911f, -0.03193885f, 
    0.00661170f, -0.07130996f, 0.17756328f, 0.01139939f, 0.15337940f, 0.13111959f, -0.15375325f, -0.30627003f, 
    -0.01906927f, 0.19057401f, -0.32710889f, 0.13350584f, -0.30340299f, 0.06565271f, -0.02073805f, 0.54801071f, 
    0.04417203f, 0.19740191f, 0.58952844f, 0.17277271f, -0.19118689f, 0.34655437f, -0.18666728f, -0.16302620f, 
    0.45714402f, -0.13246490f, -0.08802784f, 0.16121665f, -0.12130053f, -0.04451999f, -0.20100909f, 0.14513317f, 
    -0.17483759f, -0.04045139f, 0.29618981f, 0.21670263f, -0.13012308f, -0.48215684f, 0.02978822f, 0.17662257f, 
    -0.18779801f, 0.02730625f, -0.35892698f, 0.25569794f, 0.42662665f, -0.05207904f, -0.03394357f, 0.10113186f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12668678f, -0.06662634f, 0.04748595f, -0.06896411f, 0.12013707f, -0.24109921f, 0.11556233f, 0.05286606f, 
    0.08952242f, 0.32004625f, 0.17832108f, 0.02855475f, 0.10340261f, 0.06488507f, 0.02136963f, 0.19951254f, 
    0.04079723f, 0.15893997f, 0.05701128f, -0.22528967f, 0.07467994f, 0.06170170f, 0.17758366f, 0.20151882f, 
    -0.13550656f, -0.05197662f, 0.07255965f, 0.21236265f, 0.22773334f, -0.16492717f, 0.08786426f, 0.13443594f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.25602704f, -0.09834258f, -0.41177368f, 0.15669847f, 0.24587592f, 0.13896564f, 0.06096040f, -0.20312998f, 
    -0.79647768f, -0.11751685f, -0.05127924f, -0.59704381f, -0.44259566f, -0.12603655f, 0.22388323f, -0.30759642f, 
    -0.18996391f, -0.70645058f, 0.09564929f, 0.22700180f, -0.45620066f, -0.77426052f, -0.23270899f, -0.24474792f, 
    0.31338429f, 0.23241094f, 0.19782929f, -0.07507869f, 0.07870775f, 0.01577618f, -0.29010630f, 0.23547716f, 
    0.12500781f, -0.12344009f, -0.37900576f, -0.12630911f, 0.30136833f, -0.65829808f, -0.07140742f, 0.19415607f, 
    0.20547745f, 0.31244501f, 0.15371034f, -0.32787260f, -0.14341295f, 0.16482030f, 0.18018019f, 0.25183851f, 
    0.00329682f, -0.29930356f, -0.27264020f, -0.49262571f, -0.27170157f, 0.12335579f, 0.24310939f, -0.04045524f, 
    0.22939478f, -0.05922461f, 0.27589872f, -0.08321915f, 0.08689508f, -0.04234569f, 0.30216157f, -0.46666774f, 
    -0.10364084f, -0.11742620f, 0.18285605f, -0.22872539f, -0.65355182f, -0.39442518f, -0.06346478f, -0.59181887f, 
    0.15178709f, 0.25055245f, -0.55134904f, -0.26582769f, 0.35198671f, 0.11377908f, 0.29727393f, -0.30317205f, 
    -0.16248702f, 0.15063630f, 0.46455359f, -0.08721382f, -0.03068471f, -0.22115757f, -0.12121121f, -0.28021145f, 
    0.21868932f, 0.00084566f, -0.32019138f, 0.12000936f, -0.07927312f, -0.08479895f, 0.43368953f, 0.26559350f, 
    0.22517306f, -0.09286542f, 0.19371013f, 0.32126382f, 0.21676974f, 0.09844882f, -0.35264692f, -0.28391328f, 
    0.09550449f, -0.36484903f, -0.82557470f, 0.04522868f, 0.50128335f, -0.16514626f, -0.38682094f, -0.13706003f, 
    -0.20033249f, -0.12238473f, -0.04538031f, 0.12543640f, -0.53552556f, 0.11006828f, -0.00992126f, -0.11895849f, 
    0.18072569f, -0.97695094f, -0.14439058f, -0.20098917f, 0.07376867f, -0.16702449f, -0.05789180f, 0.00585763f, 
    -0.01934648f, 0.03802584f, 0.29349554f, -0.02155912f, -0.00340408f, 0.16965345f, 0.14059731f, 0.17740284f, 
    -0.34314764f, -0.38412058f, 0.11666258f, -0.22841676f, -0.26328716f, 0.14536205f, -0.38394508f, 0.10421229f, 
    -0.37041387f, -0.30629590f, 0.21110068f, 0.15331423f, 0.29891914f, 0.31076390f, -0.07790826f, -0.01876681f, 
    -0.54707754f, -0.10788935f, 0.18016624f, 0.09507019f, -0.12047128f, 0.00232259f, 0.11159873f, 0.07814268f, 
    -0.06991964f, -0.08532488f, -0.39252490f, -0.00350786f, 0.09424974f, -0.16459425f, 0.37910283f, -0.24271262f, 
    -0.36526370f, 0.24367380f, 0.16795604f, 0.29047561f, -0.65122396f, 0.17466934f, -0.35392141f, -0.04529880f, 
    -0.01832188f, 0.28329587f, -0.47376862f, -0.09208881f, 0.14267734f, -0.53314495f, -0.27666718f, 0.10242916f, 
    -0.17727603f, -0.45141828f, 0.16857377f, 0.09122525f, 0.19790040f, 0.14405860f, -0.18865526f, 0.19367482f, 
    -0.87851083f, -0.16225402f, 0.13159713f, -0.84209371f, -0.23904720f, 0.10593731f, 0.34984404f, 0.34855267f, 
    -0.04857492f, 0.10146943f, 0.01352795f, -0.26750270f, 0.03777064f, -0.51783890f, -0.07105404f, -0.82482898f, 
    -0.25485769f, 0.34482199f, 0.24910343f, -0.46421549f, -0.05176460f, 0.17700602f, 0.08150514f, 0.06173266f, 
    -0.01096240f, -0.49045643f, -0.69641185f, 0.27310827f, -0.67752796f, 0.03147094f, -0.21913326f, -0.04123508f, 
    -0.76124531f, 0.04088721f, 0.01301205f, -0.18822849f, -0.00673953f, -0.33306029f, 0.04469441f, 0.00961837f, 
    0.25033385f, -0.41298443f, 0.06105005f, 0.33902666f, -0.18037954f, -0.63923419f, -0.59595281f, 0.31648579f, 
    0.02432843f, 0.06636239f, -0.41524002f, 0.61082327f, 0.12849255f, -0.06734794f, -0.04610721f, 0.03221363f, 
    -0.01620506f, 0.12975833f, 0.16118652f, -0.50728911f, -0.51273048f, 0.02530867f, -0.06636788f, 0.34426948f, 
    -0.53409714f, -0.17297284f, -0.41040850f, 0.09638184f, 0.10285801f, -0.68119603f, -0.08822639f, -0.08631755f, 
    0.24878834f, 0.09050334f, -0.30440363f, 0.32893664f, 0.16524240f, -0.41359088f, 0.02604903f, 0.14612471f, 
    0.16655985f, 0.13754502f, -0.05113216f, -0.31957614f, -0.32879555f, -0.24707696f, -0.40117490f, 0.21325339f, 
    0.20959172f, -0.11284540f, -0.63405776f, -0.98563343f, 0.36679086f, -0.10759058f, 0.01883585f, 0.01661149f, 
    0.20032449f, 0.01554123f, 0.15727137f, -0.59510285f, -0.43836156f, -0.12866940f, -0.54429448f, -0.14473298f, 
    0.02937141f, -0.07685305f, 0.51406145f, 0.25227779f, -0.42897740f, 0.26327670f, 0.11823007f, -0.24100113f, 
    -0.24398701f, -0.08567472f, 0.20378768f, -0.19055177f, -0.57086653f, 0.22260167f, 0.14461742f, -0.49369791f, 
    -0.25958502f, -0.28578374f, -0.10562692f, 0.27339238f, -0.24371380f, -0.05247813f, -0.65299559f, 0.10860425f, 
    -0.09428325f, -0.08496829f, -0.37956858f, 0.24263100f, 0.11150282f, 0.24316032f, -0.59294659f, -0.56831604f, 
    -0.25392395f, -0.28966847f, 0.10754702f, 0.01853962f, 0.13963954f, 0.00738620f, -0.57798785f, -0.04518875f, 
    0.11604530f, 0.20593174f, -0.10515847f, -0.70017213f, -0.73340416f, -0.35288548f, 0.49134809f, 0.39287269f, 
    -0.31425822f, -0.63647211f, -0.41129741f, 0.30677339f, -0.01622239f, 0.00915425f, 0.24979019f, -0.92652881f, 
    -0.00733904f, 0.10346655f, 0.29732648f, 0.49450842f, -0.33106855f, 0.37708309f, 0.31189790f, 0.13925727f, 
    0.03527375f, 0.28321236f, -0.14919361f, 0.00477639f, 0.32299209f, -0.38666400f, -0.61463100f, -0.28418687f, 
    0.43373412f, -0.11537974f, -0.43860158f, -0.69283956f, -0.75628954f, 0.01789808f, -0.11665196f, -0.29332787f, 
    -0.16634479f, -0.50300729f, -0.36169913f, -0.05073354f, -0.14923824f, -0.06180442f, -0.16916344f, -0.16794367f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10934170f, 0.05571223f, 0.20561628f, 0.15007694f, -0.11027781f, 0.08909420f, -0.01936193f, 0.17387868f, 
    0.08517751f, 0.02150096f, 0.12964216f, 0.00237202f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
