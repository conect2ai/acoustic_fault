#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.27450162f, 0.69674516f, -0.36769703f, -0.76559645f, -0.54621601f, 0.27498657f, -0.67081988f, -0.53097743f, 
    -0.55549580f, -0.55857182f, -0.36217117f, 0.10779458f, 0.29651007f, 0.14968804f, 0.29855385f, 0.18017109f, 
    0.14578363f, -0.12367585f, 0.18309794f, 0.20359485f, 0.28422067f, -0.06262182f, -0.12182982f, -0.08511682f, 
    0.33129182f, -0.41350433f, -0.95983797f, -0.46638039f, -0.35440940f, -0.24384357f, -0.22606492f, 0.88951629f, 
    0.30494812f, -0.07008908f, 0.37696776f, -0.04565743f, -0.13909388f, 0.06975659f, 0.00221021f, -0.30722597f, 
    -0.03629244f, 0.27210340f, -0.13686323f, -0.12180995f, 0.01282259f, 0.08583254f, 0.24559022f, -0.12582886f, 
    -0.00700958f, 0.34282982f, 0.44212979f, -0.39490426f, 1.01555955f, 0.13215354f, 0.09415759f, 0.48794207f, 
    0.00694962f, 0.41290802f, 0.53757805f, -0.08671438f, -0.26972869f, -0.37868112f, 0.10651082f, -0.05196301f, 
    -0.34058475f, 0.31472921f, 0.00741368f, -0.02955422f, -0.24716488f, 0.09853613f, -0.41784644f, -0.34706104f, 
    -0.21178341f, -0.23883234f, -0.35883006f, 0.48198092f, 0.14756703f, 0.12931839f, 0.45344245f, 0.87990487f, 
    0.01972333f, -0.38648704f, -0.39491352f, 0.54192299f, 0.26104841f, 0.28920433f, 0.40105903f, -0.31792715f, 
    -0.29720023f, -0.06461781f, -0.06892493f, -0.23046090f, -0.18331970f, 0.11778957f, 0.26012030f, -0.03526482f, 
    0.00265253f, 0.38577542f, -0.32674146f, 0.04377965f, 0.77759480f, 0.11197008f, 0.31548148f, 0.77153498f, 
    0.34222507f, -0.18933246f, -0.67880064f, -0.38438028f, -0.40021887f, -0.15741482f, -0.33800310f, 0.03446362f, 
    0.29060042f, -0.12620880f, -0.17439911f, -0.08166178f, 0.19316509f, 0.20011967f, -0.15780468f, 0.34342948f, 
    0.14121817f, -0.02238150f, 0.17645866f, -0.24686807f, 0.27599132f, 0.83358020f, -0.89190108f, 0.60271186f, 
    0.23668505f, 0.41185030f, 0.29142249f, 0.62679064f, -0.19714721f, -0.19681512f, 0.53256065f, -0.03386315f, 
    0.15787868f, -0.04181202f, -0.00583335f, -0.30174834f, -0.20573969f, -0.03657770f, 0.07878599f, 0.16575938f, 
    0.02877581f, 0.08353965f, 0.17482346f, 0.07734924f, 0.18335208f, -0.05476907f, -0.21894725f, -0.32514647f, 
    0.08600802f, 0.48891753f, -0.13142771f, -0.96854860f, 0.20393744f, 0.57868683f, -0.40884873f, 0.36743310f, 
    0.31283626f, 0.27582228f, -0.17069477f, 0.06911014f, 0.24801531f, 0.33508036f, 0.14435951f, 0.10877237f, 
    -0.40931210f, -0.33201322f, -0.22742951f, -0.13033617f, -0.00961002f, -0.04231819f, -0.32443786f, 0.10055614f, 
    0.19347025f, 0.74642390f, -0.90803623f, -0.52360588f, 0.78686255f, -0.48890248f, -0.44298974f, 0.12659773f, 
    -0.47681856f, 0.25945663f, 0.51703215f, 0.06490623f, -0.20048302f, -0.26333168f, -0.12647778f, 0.11790811f, 
    -0.14768976f, -0.29905164f, -0.17691275f, 0.28528374f, 0.11574993f, -0.07055712f, 0.29633352f, -0.07980137f, 
    -0.54299694f, -0.91173798f, -0.73134738f, -0.35936388f, -0.03779309f, -0.60223573f, -0.15565526f, 0.17711401f, 
    -0.24315643f, 0.34299150f, 0.17955643f, -0.00060487f, 0.08048715f, -0.31828305f, 0.09246507f, 0.17173456f, 
    0.13318104f, 0.11945216f, -0.32428434f, -0.05806035f, 0.32980287f, -0.05850769f, -0.25620559f, 0.51571971f, 
    0.06749076f, 0.03394763f, 0.29057232f, 0.23392278f, -0.70489329f, -0.65004367f, -0.49025330f, -0.56821579f, 
    -0.25068438f, -0.30677608f, -0.02905765f, 0.52077669f, 0.32830414f, 0.02087205f, 0.08738396f, -0.34846178f, 
    -0.13169329f, -0.00194651f, 0.12378459f, 0.14430182f, 0.26430362f, -0.03410332f, 0.38184384f, 0.14037114f, 
    0.29744428f, 0.31530926f, 0.62375581f, 0.09373214f, 0.34198681f, 0.56997061f, 0.54056811f, 0.44210956f, 
    0.07289132f, 0.22657114f, 0.09389632f, -0.26282528f, -0.49794713f, 0.20101494f, 0.24127512f, 0.30514896f, 
    0.48644558f, 0.28083062f, 0.01159434f, -0.06951711f, 0.04406003f, 0.37649137f, -0.47813052f, -0.45022067f, 
    -0.35539249f, 0.34028441f, -0.13057987f, -0.58805424f, -0.68209767f, -0.54968840f, 0.43795085f, 0.17823234f, 
    -0.29775852f, 0.75451255f, 0.59684581f, -0.56325310f, 0.24215105f, 0.37861317f, 0.04407647f, 0.21515335f, 
    -0.26815170f, 0.28059444f, -0.37252319f, 0.02600612f, 0.36518738f, -0.24059542f, 0.00868458f, 0.03926639f, 
    0.11123724f, -0.30076987f, -0.04414910f, -0.35837257f, 1.15555882f, 0.86700326f, -0.35724199f, 0.63350725f, 
    -1.07774627f, -0.12981765f, 0.28224745f, 0.08112457f, 0.23198326f, 0.46017227f, 0.38552076f, 0.23293236f, 
    0.01456348f, 0.00530265f, -0.21836224f, 0.04550322f, -0.14203289f, 0.12872088f, 0.04812259f, 0.07809008f, 
    -0.03014304f, 0.08682191f, 0.05234330f, 0.02366159f, 0.09693793f, 0.95930117f, 0.00862137f, 0.20059356f, 
    0.95341414f, 0.43168941f, -0.34146205f, -0.18427674f, -0.26145625f, 0.24658376f, -0.13995939f, -0.50901461f, 
    -0.31513968f, -0.15162048f, 0.16287969f, -0.20469809f, -0.07130399f, 0.08033703f, 0.25645828f, 0.07153183f, 
    0.17102858f, -0.13341519f, -0.02367048f, -0.29098004f, -0.07233746f, -0.23133796f, -0.48774767f, -0.64630419f, 
    0.12116596f, 0.23222697f, -0.28639263f, -0.62932169f, -0.47676247f, -0.07782996f, -0.74249548f, -0.33912641f, 
    0.11168125f, 0.25329587f, -0.26571533f, 0.03077001f, -0.31979337f, -0.16598096f, 0.15160535f, 0.39516509f, 
    -0.02170153f, -0.56017369f, -0.22983323f, -0.10837182f, -0.17303595f, 0.23668049f, 0.13194491f, 0.70991206f, 
    -0.55741221f, -0.55261976f, 0.67366964f, 0.41389740f, 0.45253888f, 0.43798062f, 0.23910983f, 0.68578702f, 
    0.03804313f, -0.16640052f, 0.02411026f, -0.49005356f, 0.27066669f, -0.23277156f, 0.29481336f, -0.05336810f, 
    -0.14710291f, -0.08620370f, 0.07976176f, -0.04177170f, -0.04979630f, 0.29863778f, -0.14638840f, 0.03792525f, 
    -0.41029376f, 0.67275667f, 0.77899653f, 0.53994918f, -0.73316026f, -0.32850340f, -0.24034075f, -0.56173968f, 
    -0.07157485f, -0.44842863f, 0.22706579f, 0.12111522f, -0.10216559f, -0.03724854f, 0.38749629f, -0.17389373f, 
    -0.06327092f, 0.08887005f, 0.02112898f, 0.49315712f, -0.21972212f, -0.00920050f, 0.19825077f, -0.27665168f, 
    0.17495801f, -0.36377472f, -0.06384593f, -0.01759300f, -0.41724721f, 0.55130970f, -0.37524173f, -0.41402483f, 
    0.27389818f, -0.06971659f, -0.55360782f, 0.22415546f, 0.62459308f, 0.02270029f, 0.13840406f, 0.24627541f, 
    -0.47042197f, 0.22926593f, -0.18483935f, -0.19827344f, 0.36165491f, 0.00241060f, -0.20849712f, -0.08655413f, 
    0.12831734f, -0.24497446f, -0.43027630f, -0.85999817f, -0.60533899f, 0.26704797f, -0.12351162f, 0.69976020f, 
    1.00623846f, 0.20064524f, 0.39786857f, 0.06675339f, -0.47579724f, -0.33637300f, -0.49651876f, -0.29515743f, 
    0.06680160f, 0.14429934f, -0.19777763f, 0.10457645f, -0.13508213f, -0.18490961f, -0.11518383f, -0.01061762f, 
    0.04371409f, -0.11880740f, 0.22249573f, 0.16186678f, -0.30094200f, 0.58289129f, 0.58441329f, -0.17877039f, 
    -0.82633287f, -0.53430599f, 0.41229075f, 0.07587061f, -0.51031697f, 0.08841049f, 0.18508074f, 0.20539485f, 
    -0.16802894f, 0.30070525f, 0.00045170f, -0.11822060f, 0.16762097f, 0.31753182f, -0.30529007f, -0.22876510f, 
    0.13284849f, -0.36104423f, 0.24882029f, 0.04748176f, 0.33769572f, -1.06152105f, 0.09596221f, 0.98531920f, 
    0.02440683f, -0.74483103f, 0.25258029f, 0.46172503f, -0.62905759f, 0.11117449f, 0.44346952f, 0.29462662f, 
    -0.26413509f, -0.02502531f, 0.27212572f, -0.53103763f, 0.21905801f, 0.23192762f, 0.02623313f, 0.01035719f, 
    0.02219040f, -0.20523846f, 0.09900381f, -0.23452355f, 0.31515750f, -0.68715197f, -0.37869865f, -0.59893858f, 
    0.09709200f, -0.57531804f, 0.03189068f, -0.04909972f, -0.06631694f, 0.37959814f, 0.01971133f, -0.29697871f, 
    -0.19093548f, 0.04898212f, -0.31413507f, -0.04872343f, 0.08774285f, -0.01176312f, 0.13580668f, -0.27428249f, 
    0.13713314f, 0.11993084f, 0.16528267f, 0.36561808f, 0.22531968f, 0.21240766f, -0.66568136f, -0.28618193f, 
    -0.00751052f, 0.07797888f, 0.33730680f, -0.07357526f, -0.02033844f, -0.48334953f, 0.32803205f, 0.05182141f, 
    0.13886935f, -0.02217319f, 0.04092522f, 0.29177243f, 0.36215734f, -0.49523750f, -0.23427686f, -0.44224936f, 
    0.12429924f, -0.35744375f, 0.02314595f, 0.38574955f, 0.19789121f, 0.34388909f, -0.36570901f, 0.54244846f, 
    -0.69916582f, -0.60614318f, 0.50921500f, 0.28381541f, -0.86905628f, 0.33374467f, 0.70257044f, -0.35754701f, 
    0.03252753f, -0.10550608f, 0.05774291f, 0.04642569f, -0.29850978f, 0.31791678f, -0.28115979f, -0.18859525f, 
    -0.06845809f, 0.10678487f, -0.31777686f, 0.40656093f, 0.00806090f, -0.24083784f, 0.15947174f, 0.04220163f, 
    0.43346289f, 0.64809859f, 0.55193597f, 0.02019721f, 0.53168553f, 0.44563034f, -0.19166915f, -0.04920161f, 
    -0.11900211f, 0.37387499f, 0.21315934f, -0.17177197f, 0.21637270f, 0.12151913f, -0.23486106f, -0.32147592f, 
    -0.25705373f, -0.15151477f, -0.35339710f, -0.30586025f, -0.06670740f, -0.24276431f, 0.50958884f, -0.07564431f, 
    -0.33588967f, -0.42350349f, 0.41853768f, -0.51869565f, -0.64345330f, -0.68454403f, 1.09501576f, 0.13699239f, 
    -0.52337182f, 0.12320740f, -0.15438330f, 0.24021925f, -0.37380582f, 0.34864876f, 0.28136069f, -0.14263707f, 
    -0.08227647f, 0.12014990f, 0.04758570f, 0.14328484f, 0.07293317f, 0.13694105f, -0.17717449f, 0.04550293f, 
    -0.21441656f, 0.05805938f, 0.56808430f, 0.63339263f, 0.92288423f, 0.16742843f, 0.21899801f, -0.57187217f, 
    -0.26696593f, -0.11919398f, 0.29470322f, 0.61672002f, 0.19006418f, -0.22611602f, -0.14999078f, 0.23788795f, 
    -0.11475474f, -0.17530555f, -0.16858865f, 0.19907309f, 0.08946571f, -0.16244949f, 0.50642371f, -0.01290246f, 
    0.06158390f, 0.20777074f, 0.12480319f, -0.27753851f, -0.06813562f, -0.25555840f, 0.11457141f, 0.82847148f, 
    0.71369338f, 0.55161381f, -0.12871458f, 0.02342180f, -0.34304076f, 0.07319282f, 0.49095392f, 0.24397437f, 
    0.08218742f, 0.04870893f, 0.34670702f, -0.10710063f, 0.01041442f, 0.28422946f, 0.11935634f, 0.38250262f, 
    0.17334169f, 0.23263323f, -0.16762225f, -0.21023661f, -0.63442463f, 0.69493997f, 0.16801706f, -0.19367836f, 
    0.56435394f, -0.21748450f, 0.47296882f, 0.55216503f, 0.09014118f, 0.53828919f, -0.53444195f, 0.27001205f, 
    0.26819354f, -0.13142680f, -0.00037790f, 0.42799711f, -0.17114466f, -0.36967367f, 0.24852276f, 0.36506486f, 
    -0.27706569f, -0.06346988f, -0.04715814f, 0.02426085f, 0.10384761f, -1.00830019f, 0.83545947f, 0.70917952f, 
    -0.94917983f, 0.18865651f, -0.38906452f, 0.29299173f, 0.13822493f, 0.13520673f, -0.40963396f, -0.10164517f, 
    -0.01070586f, -0.27015436f, 0.09417690f, -0.02617172f, 0.12554152f, -0.16623108f, -0.08965110f, 0.08674514f, 
    -0.03897682f, 0.26847494f, 0.21511436f, -0.01156933f, 0.24985044f, 0.25232545f, 0.63046122f, 0.88845134f, 
    -0.19798428f, -0.15355425f, -0.04266970f, -0.21761809f, -0.25128567f, -0.60628933f, 0.40593579f, 0.30537128f, 
    0.31389081f, -0.27775717f, -0.29714859f, -0.22958511f, -0.10432097f, 0.12039180f, 0.02973509f, -0.25058410f, 
    -0.06037641f, -0.10684942f, -0.46029118f, 0.22910428f, -0.23627792f, 0.20398928f, -0.31806788f, -0.49089274f, 
    0.46755508f, 0.26053751f, 0.78465766f, 0.12947735f, -0.37634718f, 0.07773974f, -0.63172221f, -0.69189221f, 
    0.09916627f, 0.25974980f, 0.39335969f, 0.37067845f, 0.04525596f, 0.09573138f, 0.20639770f, 0.15261932f, 
    0.11971415f, 0.00265545f, 0.15687807f, 0.18321539f, -0.32094428f, -0.41345593f, -0.09748096f, 0.10166236f, 
    0.94409215f, 0.71874958f, 0.62526721f, 0.79956049f, 0.77303213f, 0.17019595f, 0.08630364f, 0.03676197f, 
    -0.15972701f, -0.32766169f, -0.10411324f, 0.25708678f, -0.41887060f, -0.20731843f, 0.08978587f, 0.01493967f, 
    -0.19990118f, 0.21918768f, 0.24438877f, 0.20000042f, 0.17483377f, 0.25189391f, -0.21491008f, -0.06182636f, 
    0.13809437f, -0.98821914f, 0.17827149f, 0.51071912f, 0.06289674f, -0.52409679f, 0.09562194f, -0.06563712f, 
    0.14483158f, 0.35799667f, -0.07304955f, 0.03685249f, 0.36537164f, 0.21471694f, -0.11521684f, 0.05700502f, 
    0.05609061f, -0.05233774f, 0.41836590f, 0.16567953f, -0.31747374f, 0.32766575f, 0.38484004f, -0.33357194f, 
    -0.06123143f, -0.21820831f, 0.88075560f, 0.14396584f, -0.30668089f, -0.81606144f, 0.45739204f, 0.36623216f, 
    -0.65763956f, -0.13369627f, -0.22240874f, 0.22664133f, -0.27700752f, -0.25041559f, 0.30255827f, -0.04895587f, 
    -0.30332565f, 0.10051317f, 0.18086131f, 0.28045741f, 0.18643679f, 0.15934725f, -0.09270731f, 0.20744334f, 
    -0.05788647f, -0.38104776f, -0.42193869f, 0.44151670f, 0.31675565f, 0.58318561f, 0.64083785f, 0.79754871f, 
    0.38911226f, -0.01332031f, 0.43763283f, 0.31569311f, 0.24741599f, -0.25726679f, -0.14370570f, -0.04515786f, 
    0.57170904f, 0.27325082f, 0.36695975f, 0.24287832f, 0.15843920f, 0.13686256f, -0.17811371f, 0.09514110f, 
    -0.12782502f, -0.19768402f, 0.17599767f, 0.42093703f, 0.05593095f, 0.08595216f, 0.57140726f, 0.18295540f, 
    -0.28736043f, -0.43630734f, 0.39794269f, -0.21897087f, 0.07752283f, -0.78152740f, -0.21383084f, 0.38421986f, 
    -0.50779980f, 0.40880781f, -0.33337247f, 0.20904936f, 0.00974600f, 0.20782550f, -0.01716960f, -0.02833422f, 
    -0.36567292f, -0.11055998f, 0.60386753f, -0.03191344f, -0.01023465f, 0.90414995f, 0.20944083f, -0.54189974f, 
    -0.76927590f, -0.53181559f, -0.17455837f, -0.53264362f, 0.00919525f, -0.05673842f, -0.13658679f, -0.40118161f, 
    -0.15434018f, 0.09528247f, -0.37243390f, -0.37933815f, -0.27279332f, -0.26999974f, 0.01827451f, -0.00735570f, 
    0.29710990f, 0.15265012f, 0.23057653f, -0.18323171f, -0.08746234f, -0.07852620f, -1.04497981f, 1.09936607f, 
    0.18152766f, -0.75634807f, 0.15502986f, 0.06432864f, 0.63547105f, -0.10830610f, -0.17953014f, -0.05238830f, 
    0.30895063f, -0.24232319f, 0.07149933f, -0.12770064f, -0.08137748f, -0.29612049f, -0.17133816f, -0.30782533f, 
    -0.36121744f, -0.05297855f, -0.10686249f, 0.37706795f, 0.03402227f, 0.19665046f, 0.02522565f, 0.28345212f, 
    -0.29028627f, 0.70004982f, 0.52607703f, 0.47218418f, -0.77233618f, 0.09840789f, -0.48515323f, -0.64374888f, 
    -0.05625224f, 0.22968926f, 0.37391505f, -0.29498854f, -0.01598294f, 0.06861190f, -0.43244016f, -0.22486189f, 
    -0.34272453f, -0.13965657f, -0.39176306f, -0.23488623f, 0.17226045f, -0.04728894f, -0.07302858f, 0.05538465f, 
    0.10274298f, 0.34699175f, 0.57247728f, 0.58560479f, 0.47090599f, 0.37824333f, -0.00995030f, -0.01649383f, 
    0.20480874f, -0.20923227f, 0.40797600f, -0.02041308f, 0.20051917f, -0.11194540f, 0.14834842f, -0.31848407f, 
    0.31915176f, -0.03698556f, -0.44977227f, -0.12228315f, -0.27796319f, 0.13703407f, 0.10776287f, -0.29671761f, 
    0.38856256f, 0.41317430f, 0.27769610f, 0.37289736f, 0.68071806f, 0.19608669f, -0.26355419f, -0.34725830f, 
    0.48262823f, 0.25241661f, 0.04245323f, 0.16299434f, -0.02117666f, 0.06717189f, 0.15505034f, 0.08360489f, 
    0.41543952f, 0.11992883f, 0.33374190f, -0.31126049f, 0.16812278f, 0.15377440f, 0.10899108f, -0.12632650f, 
    -0.43380439f, -0.15619646f, -0.37717852f, 0.07578896f, -0.77666700f, -0.62116891f, -0.47411656f, 0.09255160f, 
    -0.21906714f, 0.27159837f, 0.29704112f, 0.61313152f, -0.24025810f, 0.26841915f, -0.00212876f, -0.06295618f, 
    -0.42003492f, 0.23127310f, 0.15525079f, 0.48244527f, 0.01762529f, 0.31712246f, 0.14070567f, 0.05901502f, 
    -0.20163052f, -0.05547811f, 0.12012266f, 0.94776469f, 0.31466645f, -0.65427387f, -0.90048653f, -0.72911763f, 
    -0.08887047f, 0.46286252f, 0.09859639f, -0.27566481f, 0.14722694f, 0.38044348f, 0.01827169f, -0.03865272f, 
    -0.22395006f, 0.20588864f, -0.17384645f, -0.17723922f, -0.02536767f, -0.07249643f, 0.04217901f, 0.15154730f, 
    0.25208065f, 0.04241929f, 0.21367419f, 0.08454134f, -0.09331203f, 0.74841529f, 0.76644886f, 0.49473351f, 
    0.63582116f, 0.78738499f, 0.05969281f, -0.72137904f, 0.45045385f, -0.40817773f, -0.24006163f, 0.16536039f, 
    -0.14863089f, 0.04348904f, -0.52853745f, -0.02160379f, -0.02659456f, 0.04424997f, -0.26425415f, -0.22927223f, 
    0.14878492f, 0.14444990f, 0.04764245f, -0.10171107f, 0.10957643f, -0.06758212f, 0.42839932f, 0.08087882f, 
    0.63145691f, -0.72756171f, -0.49439296f, -0.25145176f, -0.01230121f, -0.23406436f, -0.20201260f, -0.28840324f, 
    -0.05763501f, -0.03663434f, 0.39683723f, -0.22975461f, -0.20292644f, -0.07976297f, 0.00082110f, -0.10479838f, 
    -0.33747682f, 0.00727781f, -0.17031954f, -0.04582147f, 0.19561903f, 0.01346268f, -0.82269615f, 0.74681205f, 
    -0.07008922f, -0.34002614f, 0.18320049f, 0.43834278f, 0.28064001f, -0.03191846f, 0.49259031f, -0.22667083f, 
    -0.32825613f, -0.34718469f, 0.17597505f, 0.09065468f, -0.07525991f, 0.11182723f, -0.35257494f, 0.12673220f, 
    -0.09205599f, -0.17807318f, -0.44826081f, -0.43308115f, -0.36223534f, 0.07793996f, 0.03379943f, -0.63710177f, 
    -0.14195457f, -0.23587453f, -0.55249542f, -0.37920129f, 0.11634798f, 0.95942354f, 0.48868975f, 0.00824135f, 
    0.39986256f, 0.26630956f, -0.12674643f, -0.14537813f, -0.54650772f, -0.19326650f, -0.00339392f, 0.00230309f, 
    0.07803381f, 0.09155682f, 0.10587619f, -0.02101990f, -0.10433742f, 0.13652092f, -0.29579723f, -0.20243819f, 
    -0.47656760f, -0.53669983f, -0.09755812f, -0.31766140f, -0.13029806f, -0.67499864f, -0.14008330f, -0.28663531f, 
    0.07057499f, 0.51736182f, -0.21083920f, 0.21411367f, 0.40003020f, 0.17489539f, -0.44009912f, -0.04892039f, 
    -0.07129288f, 0.26930648f, -0.17142901f, 0.10633377f, -0.27106684f, 0.21638989f, -0.30810478f, -0.09388942f, 
    0.09351406f, -1.00271010f, -0.40295580f, 1.11684835f, -0.04217592f, 0.40047941f, 0.82857889f, 0.31724170f, 
    0.48276761f, 0.06829589f, -0.32776457f, -0.08512769f, -0.04354222f, -0.01690404f, -0.04590785f, -0.04224193f, 
    -0.35558662f, 0.05709887f, -0.14532977f, -0.12133837f, -0.17729722f, 0.01910670f, -0.00038173f, -0.23659270f, 
    -0.21291491f, 0.05441691f, -0.62744391f, -0.43711415f, -0.48221686f, -0.66678399f, -0.49399754f, 0.12582068f, 
    0.45326129f, 0.15795818f, 0.35982805f, 0.45395210f, -0.01440558f, -0.14363179f, -0.24590331f, 0.01741753f, 
    -0.18903509f, 0.13411184f, 0.31752306f, 0.13803023f, 0.14958800f, -0.28574181f, -0.14554541f, 0.04856829f, 
    0.29038271f, -0.07842346f, 0.30192426f, 0.12172003f, -0.60328531f, -0.58370960f, 0.85532212f, 0.03096693f, 
    0.58772904f, -0.24361978f, -0.40310740f, 0.25356191f, -0.43371004f, 0.22097006f, -0.07817594f, 0.12369262f, 
    0.00430819f, -0.27963886f, 0.19753297f, -0.12863800f, 0.04959416f, -0.12891774f, -0.49641463f, -0.36100268f, 
    -0.17817119f, 0.31509596f, -0.14971492f, 0.05238054f, -0.62144476f, 0.14056276f, 0.25484276f, -0.08868876f, 
    0.30463052f, -0.53498369f, 0.29337975f, -0.53062558f, -0.65092188f, -0.11072291f, 0.05327125f, 0.60606623f, 
    0.04707968f, -0.15360710f, 0.01357936f, 0.37015298f, 0.18456404f, 0.47736463f, 0.05854335f, -0.00806646f, 
    -0.00352670f, 0.01130918f, -0.00348558f, 0.09339772f, 0.01939568f, 0.27631044f, -0.69832212f, -0.64554679f, 
    0.17688386f, -0.30215451f, -0.46161780f, 0.58375335f, -0.09822457f, 0.13363163f, 0.03744199f, -0.18118557f, 
    0.53328007f, -0.41039059f, -0.00335651f, 0.26585868f, 0.30905467f, -0.28048772f, -0.47182661f, -0.13211399f, 
    0.26736280f, -0.18632306f, -0.16017871f, 0.00956433f, -0.06193511f, -0.27390844f, -0.85322732f, 0.59332609f, 
    0.60061723f, -0.03039534f, 0.32940629f, 0.79554981f, -0.27211672f, -0.37012830f, 0.12171594f, -0.53825808f, 
    -0.46252850f, -0.35435516f, -0.29422319f, -0.03349150f, -0.56221598f, 0.13466759f, -0.10055950f, -0.10699043f, 
    -0.32279801f, -0.07398556f, -0.11647574f, 0.28083384f, -0.15755929f, -0.02301659f, -0.34447771f, -0.13983271f, 
    -1.36905301f, 0.25249150f, 0.31135628f, -0.32840264f, -0.33183080f, 1.00411284f, 0.37027639f, -0.05589778f, 
    0.22657509f, -0.29173902f, 0.06267478f, 0.00622141f, 0.33625388f, 0.13982618f, -0.34286770f, -0.09547310f, 
    -0.31033310f, 0.07909394f, -0.18398401f, 0.17292285f, 0.24971481f, 0.06337386f, 0.27509373f, -0.03047910f, 
    -0.83730197f, 0.06168418f, 0.57183558f, -0.30702922f, 0.75913584f, 0.44686371f, -0.31798092f, -0.76917005f, 
    -0.55363250f, -0.71107692f, 0.19285190f, 0.32936433f, 0.23210002f, -0.03572309f, -0.18166099f, 0.16071616f, 
    0.09669876f, 0.27704543f, -0.28047806f, 0.07159363f, -0.10647052f, 0.04672006f, 0.02539722f, -0.00412703f, 
    0.22716054f, -0.75890279f, 0.12905620f, 0.63561833f, 0.53282571f, -0.61932772f, -0.08220398f, 0.04173835f, 
    0.41181928f, -0.36433908f, -0.17517048f, 0.26064524f, -0.07168075f, -0.14464502f, 0.30429032f, -0.07161076f, 
    0.04489312f, 0.00236270f, -0.12780695f, -0.00279322f, 0.37483299f, -0.41410187f, -0.08208111f, 0.03990643f, 
    0.43393695f, -0.16521734f, 0.37546819f, 0.46979463f, 0.68801457f, 0.37634814f, 0.75619799f, 0.71458244f, 
    -0.19205491f, -0.83790976f, -0.38253796f, -0.58994597f, 0.20491752f, 0.14451472f, -0.09158091f, 0.38016254f, 
    -0.08746298f, 0.08409867f, 0.15213296f, -0.08405983f, 0.35453287f, 0.21953090f, 0.20026739f, 0.13204150f, 
    0.15864131f, 0.02749169f, 0.23214459f, -0.07663646f, 0.24519160f, -0.26562053f, 0.01984917f, -0.42535686f, 
    -0.19061221f, -0.30765206f, -0.37124473f, -0.18504025f, 0.25991774f, -0.40783519f, -0.14427565f, -0.40742061f, 
    0.36651734f, 0.18329296f, -0.02649962f, -0.24735284f, 0.47394586f, 0.06197140f, -0.24564359f, 0.00610865f, 
    0.01834481f, -0.39385784f, -0.01892501f, 0.42951265f, 0.48195753f, -0.41644877f, -0.85534370f, -0.74684644f, 
    0.03281076f, -0.11308750f, 0.57146263f, 0.35808241f, 0.11571866f, 0.60370779f, -0.57734388f, 0.28158069f, 
    0.30220830f, 0.02124947f, 0.09857522f, -0.16795103f, -0.27171159f, -0.13562895f, -0.08405647f, -0.09173317f, 
    -0.20171633f, 0.07076427f, -0.06569178f, -0.03521521f, -0.27007294f, 0.12084232f, -0.72434980f, -0.68838042f, 
    -0.10933608f, -0.31642500f, -0.64102226f, 0.38937238f, -0.21679071f, -0.57122535f, 0.40278518f, 0.58824480f, 
    0.03849018f, 0.05550750f, -0.08140437f, -0.06544772f, -0.02543561f, -0.19296423f, -0.03266613f, -0.17433089f, 
    -0.39831623f, -0.07077423f, -0.10005940f, 0.13735870f, 0.00552525f, 0.03796705f, -0.52424347f, 0.12691985f, 
    0.19581628f, 0.27656531f, -0.16153607f, 0.46985489f, 0.50120217f, -0.52730405f, -0.19446069f, 0.43954214f, 
    -0.47344863f, -0.38877639f, -0.15224656f, -0.40917009f, 0.34966597f, -0.31579864f, 0.33355290f, -0.08325923f, 
    -0.19484943f, -0.38318667f, 0.05139328f, 0.08023115f, 0.15088722f, -0.44934449f, 0.34049219f, -0.98625296f, 
    -0.52429134f, -0.30870363f, -0.11317333f, 0.05520152f, 0.22674686f, 0.49598590f, 0.21212617f, -0.19596438f, 
    -0.04816521f, 0.34184125f, -0.33491123f, 0.50278455f, -0.09531009f, -0.09510632f, -0.09548243f, -0.17737243f, 
    -0.24233167f, -0.04225427f, -0.41464055f, 0.00352584f, 0.00630104f, 0.09475760f, 0.07405289f, 0.15741964f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.44142759f, 0.23588340f, -0.02758598f, 0.17210972f, 0.12448079f, 0.15237698f, 0.10143363f, 0.22889571f, 
    0.22770533f, 0.19619884f, 0.04690622f, 0.07604831f, 0.18225822f, -0.00174594f, 0.03938990f, 0.00549035f, 
    0.06819351f, 0.10875347f, -0.06004016f, 0.07047620f, 0.21359406f, 0.14087780f, 0.19859819f, 0.05727195f, 
    0.09443250f, 0.24740630f, 0.13425499f, 0.05330306f, 0.12359374f, 0.34535298f, 0.13456145f, 0.04538751f, 
    0.20075430f, 0.07843341f, 0.26921716f, 0.09094585f, 0.16092430f, 0.21265228f, 0.11937125f, 0.07303175f, 
    0.26305467f, 0.17376156f, 0.08008153f, 0.19479212f, 0.12006517f, 0.14811888f, 0.18461725f, 0.06565158f, 
    0.16161382f, 0.12274642f, 0.20311339f, 0.13757539f, 0.30819786f, 0.07470439f, 0.05673125f, 0.15134923f, 
    0.31005272f, 0.10403849f, 0.08893501f, 0.13607350f, -0.07946384f, 0.23158692f, 0.12455013f, 0.23124847f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23948321f, 0.16460153f, 0.11901824f, -0.16636953f, -0.04852325f, 0.04368265f, 0.05128865f, 0.08307563f, 
    0.01200105f, -0.06330846f, -0.12077591f, 0.06883073f, -0.14758791f, 0.25770494f, 0.09040102f, -0.36973220f, 
    -0.05432760f, 0.09209835f, 0.02954414f, 0.10181730f, -0.04643909f, -0.04532487f, -0.12791309f, 0.05242625f, 
    0.14748329f, -0.05051295f, -0.08310821f, 0.21130861f, -0.06738137f, 0.02881327f, 0.11180573f, 0.08563174f, 
    0.02867251f, -0.03015292f, -0.02746335f, -0.00946215f, 0.12671188f, -0.14446411f, 0.08771823f, 0.13507521f, 
    -0.09513914f, 0.00047040f, -0.07097956f, 0.05891967f, 0.04107607f, 0.05560955f, 0.08565816f, -0.11070944f, 
    0.25974545f, -0.03649086f, 0.00021098f, 0.16473033f, -0.11126231f, -0.02666748f, 0.00926929f, 0.09542467f, 
    -0.07234732f, 0.05431113f, -0.14413030f, 0.06704979f, 0.16420615f, -0.02227668f, 0.04447505f, 0.13505901f, 
    -0.10738687f, -0.12178923f, -0.01986103f, 0.02560503f, -0.17737985f, 0.21267675f, -0.05090500f, -0.06034179f, 
    -0.23164518f, -0.12104216f, -0.16894263f, 0.22234112f, -0.10214378f, 0.00582054f, -0.06600934f, -0.06240335f, 
    0.08467634f, 0.03575458f, 0.14680929f, 0.05714948f, -0.18616942f, 0.11240168f, 0.16823524f, -0.10037176f, 
    -0.07282855f, 0.02579410f, 0.05770973f, -0.18951803f, -0.08291891f, 0.03262939f, -0.00763987f, -0.05092725f, 
    -0.22429419f, -0.05361662f, -0.19750996f, -0.00567884f, 0.04935450f, 0.05003827f, -0.10268686f, 0.02233407f, 
    -0.07201600f, 0.02240839f, -0.04141600f, -0.01996627f, -0.24074580f, 0.06190750f, 0.05921733f, 0.06563971f, 
    0.05701972f, 0.03777702f, 0.00437296f, 0.06616511f, -0.03178083f, -0.10272149f, -0.04469576f, -0.06671686f, 
    0.22390856f, -0.21539295f, -0.05559776f, 0.06848875f, 0.02162807f, -0.02822685f, 0.03440025f, 0.05927769f, 
    0.13988969f, -0.09468398f, 0.03964784f, 0.03202581f, -0.39872235f, 0.16957615f, -0.08482508f, 0.15830804f, 
    -0.04345667f, -0.05787513f, -0.14982587f, 0.00295614f, 0.03253224f, -0.05490442f, -0.00882937f, 0.07720040f, 
    -0.15168087f, 0.07431468f, -0.05289538f, -0.02768068f, -0.09187140f, -0.05992681f, -0.09989170f, -0.01291761f, 
    -0.01520920f, 0.02989588f, -0.02732860f, 0.03632190f, 0.26821545f, -0.01237270f, -0.11528125f, 0.33791128f, 
    -0.08910278f, -0.04536416f, -0.03153793f, 0.02150488f, 0.04678984f, -0.12607954f, -0.03620466f, 0.08343333f, 
    -0.38236308f, -0.31056926f, -0.29189259f, 0.13436104f, -0.10689768f, -0.02386823f, 0.01614862f, 0.04745637f, 
    0.01822864f, 0.13576329f, -0.00511305f, 0.04009824f, 0.10389140f, 0.11821195f, -0.14938670f, 0.28742215f, 
    0.03300748f, 0.07322561f, -0.09726078f, -0.01829084f, -0.10094501f, -0.02019228f, 0.02474396f, -0.06276985f, 
    -0.24244170f, 0.25827372f, -0.10876741f, 0.17526469f, -0.05074927f, 0.05157329f, -0.02541884f, 0.07694186f, 
    0.04210085f, 0.05678038f, 0.01101538f, 0.03832644f, -0.15468860f, 0.10477074f, 0.06227003f, -0.06354174f, 
    -0.00835743f, 0.09098994f, 0.02179569f, -0.12299477f, 0.02549895f, -0.10153229f, 0.06462254f, -0.02363972f, 
    0.05599826f, 0.23194316f, 0.14799806f, 0.03215541f, 0.02977254f, 0.05497606f, 0.09887584f, -0.04732993f, 
    0.09111762f, -0.01612402f, 0.09383164f, -0.01640071f, 0.11036079f, 0.01568642f, -0.07931143f, 0.14156641f, 
    -0.04555764f, -0.09252179f, -0.02072322f, -0.00832464f, 0.06855833f, -0.00246410f, 0.02001730f, 0.02701107f, 
    0.09469870f, -0.11691489f, -0.13130990f, 0.18511240f, -0.17355439f, 0.04670614f, 0.04175451f, -0.05507630f, 
    0.07707446f, 0.01538111f, -0.14526600f, 0.05219040f, 0.33922744f, 0.14899187f, -0.23386495f, -0.14438513f, 
    0.04138063f, -0.02853462f, 0.06537350f, 0.00789491f, -0.00470598f, -0.01516449f, 0.01750991f, -0.06093160f, 
    -0.09417390f, -0.07670476f, 0.09410407f, 0.01805068f, 0.14571519f, -0.04739135f, -0.02863651f, -0.02988048f, 
    -0.09548996f, 0.01294626f, 0.03877169f, 0.05524904f, -0.22495349f, 0.07666335f, -0.16312796f, 0.07630712f, 
    0.00078000f, 0.02087119f, -0.07482818f, -0.04070498f, 0.04873556f, -0.03701670f, 0.04037285f, 0.06558325f, 
    0.04000945f, -0.06178203f, 0.17201859f, -0.11808661f, -0.11763253f, -0.07152094f, -0.00246227f, 0.09310848f, 
    0.04630386f, 0.05825331f, 0.00690064f, -0.05314263f, 0.45868573f, -0.15782827f, -0.10836214f, -0.28229827f, 
    0.02858545f, 0.02667388f, -0.01355260f, -0.00276327f, -0.07119367f, 0.01477079f, -0.05985688f, 0.08673058f, 
    0.11824088f, 0.00311458f, -0.18259127f, -0.00747203f, -0.07417452f, -0.14862905f, -0.03798422f, -0.03786767f, 
    0.06936728f, -0.03113243f, -0.01832541f, -0.03985393f, -0.19800501f, -0.06410612f, 0.11885080f, -0.13241905f, 
    -0.05749614f, 0.10213511f, -0.05141497f, -0.12520055f, 0.00511749f, -0.03979534f, 0.06061151f, -0.09167442f, 
    0.01568971f, -0.00705910f, 0.00939652f, -0.06553065f, -0.05159922f, 0.02543807f, 0.00236574f, 0.00729648f, 
    0.07270759f, -0.09284139f, -0.06589326f, -0.04240407f, -0.20828517f, 0.02611078f, 0.18133059f, -0.08802250f, 
    -0.05343483f, -0.00673832f, -0.01706178f, 0.04441423f, -0.03445098f, -0.04164365f, 0.01039899f, -0.00772647f, 
    0.05181949f, -0.01016561f, 0.03786515f, -0.11065175f, -0.09637917f, -0.04417719f, 0.02719168f, 0.07990453f, 
    0.04534427f, 0.05985193f, 0.01787700f, -0.07415702f, -0.17550166f, 0.13220607f, 0.08550925f, 0.01096994f, 
    -0.09164429f, 0.00301395f, 0.13779376f, -0.10215717f, 0.13681182f, 0.03658900f, -0.08699450f, -0.03702404f, 
    0.17395674f, 0.07124958f, -0.02992580f, -0.05569173f, -0.20014161f, -0.03330304f, -0.01350284f, 0.08308180f, 
    -0.04410179f, -0.03203128f, -0.08359872f, 0.01166290f, -0.01795622f, 0.09533215f, 0.04488115f, 0.12072036f, 
    -0.00733242f, -0.00103305f, 0.10422471f, -0.04148985f, -0.02901049f, 0.03902148f, -0.01316485f, -0.17175491f, 
    0.14030963f, 0.01967671f, 0.22257230f, -0.39182806f, -0.06495030f, 0.10725083f, 0.03200939f, 0.00733169f, 
    0.02763340f, -0.03512975f, -0.00104136f, 0.04129478f, 0.01164858f, -0.14148828f, -0.02880430f, 0.14476989f, 
    -0.04964822f, -0.10109522f, 0.00899438f, -0.04302704f, 0.02824778f, 0.06348887f, 0.05581079f, -0.03643334f, 
    -0.08718521f, 0.10031589f, -0.06180831f, 0.11489403f, -0.00496951f, -0.02553690f, -0.06386517f, 0.01114088f, 
    0.15593965f, 0.09519899f, 0.06195429f, -0.20511873f, -0.11201570f, 0.05195133f, 0.03736039f, -0.17903212f, 
    0.04236249f, 0.01295866f, -0.01113573f, 0.01696894f, -0.06149411f, -0.05089082f, 0.02361217f, 0.03171884f, 
    0.23336303f, -0.05778837f, 0.17729431f, -0.13324735f, -0.07504944f, 0.04860160f, 0.11045569f, 0.06701905f, 
    0.00182515f, -0.06808142f, -0.04870542f, 0.08553361f, 0.23305370f, -0.01674612f, -0.21364929f, 0.18747936f, 
    -0.20805039f, -0.09651098f, -0.01669761f, -0.05763277f, -0.13103090f, 0.07969688f, -0.03727445f, 0.11663143f, 
    0.01096230f, -0.02507475f, -0.11955021f, 0.01110157f, -0.16978630f, 0.01172384f, -0.02918405f, -0.07324309f, 
    -0.09713591f, 0.08869184f, -0.00714946f, -0.00783344f, 0.08153521f, 0.00034251f, -0.16815379f, 0.01825046f, 
    -0.16541268f, 0.12186512f, 0.01801357f, -0.01029881f, -0.01307718f, 0.05129616f, 0.00971198f, -0.08354528f, 
    0.25738981f, -0.03843163f, -0.22252153f, -0.36392584f, 0.07231371f, -0.12830137f, 0.02890826f, -0.03089976f, 
    -0.04934437f, -0.05957377f, -0.01045501f, -0.05417578f, -0.44066760f, 0.03347644f, 0.01122771f, -0.22570316f, 
    0.00305581f, -0.02987204f, 0.05932191f, -0.05274997f, -0.03534694f, -0.05233056f, -0.01713642f, 0.04421007f, 
    -0.13078164f, 0.00311509f, 0.03812655f, 0.07009758f, -0.07502427f, -0.06400971f, 0.01679820f, -0.11489323f, 
    -0.05983657f, -0.04363344f, -0.04353389f, 0.06465978f, 0.09165765f, 0.19887133f, -0.09503455f, 0.18492867f, 
    -0.02508430f, -0.00376494f, -0.09944493f, -0.00499267f, -0.04937862f, -0.03251797f, 0.02884715f, 0.04636964f, 
    0.29062051f, -0.00432451f, 0.09615275f, -0.12767380f, -0.05397671f, -0.10461412f, 0.19290100f, 0.02913451f, 
    0.11042757f, -0.14257304f, -0.12941203f, 0.06301963f, 0.26184118f, 0.16280177f, 0.18076502f, -0.37063417f, 
    0.01983544f, 0.05259674f, -0.00819247f, 0.00235116f, 0.00622067f, -0.00118816f, 0.00554977f, 0.02980020f, 
    0.01938477f, -0.16597234f, -0.00496649f, -0.03222782f, -0.11995759f, -0.02757886f, -0.00647898f, 0.09702638f, 
    -0.03831501f, -0.03553128f, 0.01581552f, 0.02301735f, -0.34139985f, 0.10162705f, 0.31771854f, 0.13700697f, 
    0.04399533f, 0.04308602f, 0.09256470f, 0.01287502f, -0.06727061f, -0.07639274f, 0.10249738f, -0.05486502f, 
    0.13132629f, 0.14629500f, 0.01823266f, -0.30500239f, 0.03068578f, 0.07731758f, 0.00657713f, 0.04079282f, 
    -0.04427905f, 0.09194985f, -0.11468165f, -0.02822442f, 0.11304364f, -0.01409667f, -0.04834174f, 0.27172282f, 
    -0.06392849f, 0.10524271f, -0.12640630f, 0.04577856f, -0.08873424f, -0.06987322f, -0.05808226f, -0.09824853f, 
    -0.36950409f, -0.11223996f, 0.04559318f, 0.08891056f, 0.12461573f, -0.07030648f, -0.01282309f, 0.05453937f, 
    0.08211268f, 0.05849120f, -0.04374612f, -0.05407277f, -0.12762001f, -0.08822560f, 0.06073591f, 0.04651142f, 
    -0.03769770f, 0.06947930f, -0.00619239f, -0.13567255f, 0.03439728f, 0.01317752f, 0.17559832f, -0.15758532f, 
    -0.16430698f, -0.07090107f, 0.15386827f, 0.06927661f, 0.02804250f, -0.09480511f, 0.00121067f, -0.12197382f, 
    0.05039516f, -0.06593164f, 0.01196437f, -0.04348593f, -0.09424256f, -0.09748139f, -0.10065603f, 0.17137954f, 
    0.06609740f, 0.03821714f, 0.02558246f, 0.02564620f, 0.05239291f, 0.04342517f, 0.03301699f, -0.02558907f, 
    -0.43496445f, -0.14220719f, 0.09875155f, -0.05176827f, 0.00777721f, -0.03314928f, 0.01503479f, -0.00793891f, 
    0.00790568f, -0.04171636f, 0.01351946f, -0.08986420f, -0.24669857f, 0.14758603f, -0.08963103f, 0.23466827f, 
    -0.03159918f, 0.08711914f, 0.01133863f, 0.08252781f, -0.02899038f, -0.04122857f, 0.13378319f, 0.02886066f, 
    -0.01686548f, 0.00110702f, 0.07521311f, -0.09572414f, -0.11576518f, -0.13100500f, -0.03372665f, 0.00277446f, 
    -0.00996654f, -0.04540406f, 0.02457533f, 0.06550959f, -0.03306515f, 0.07972925f, -0.05144028f, 0.03678941f, 
    -0.12960769f, 0.10961052f, -0.03566754f, -0.05427675f, 0.00067730f, 0.03074099f, -0.04949213f, 0.08971732f, 
    -0.09586335f, -0.13197435f, -0.05869161f, -0.46869677f, 0.01969094f, -0.08745932f, 0.07696001f, -0.07246606f, 
    -0.01769524f, 0.03580227f, 0.09669361f, 0.07150651f, -0.37265223f, -0.15084532f, 0.06706137f, 0.08888091f, 
    0.00360545f, -0.12593617f, -0.03624535f, 0.02054274f, 0.00205430f, 0.08822322f, -0.08139703f, -0.04122979f, 
    0.21309304f, 0.04952131f, 0.13848984f, 0.07289174f, -0.00544495f, 0.02295072f, -0.04201005f, -0.05042143f, 
    0.06009894f, 0.01349188f, -0.03390819f, 0.21452808f, 0.12942989f, 0.01849449f, 0.07579193f, -0.18695036f, 
    0.05930364f, -0.00997893f, -0.10962328f, 0.01237792f, 0.04600171f, 0.04010412f, -0.04015927f, -0.03867095f, 
    -0.09175028f, -0.02131463f, 0.01188130f, -0.15030353f, -0.06421648f, 0.03992784f, 0.09382083f, 0.08326881f, 
    0.05387972f, 0.13907549f, 0.06679545f, -0.00533714f, 0.16643061f, -0.15721710f, -0.13276005f, 0.02453788f, 
    0.01840143f, -0.11108338f, -0.03810373f, 0.02879086f, 0.11588066f, 0.02697207f, -0.01678641f, -0.09266039f, 
    0.02939223f, 0.08724993f, 0.02077000f, 0.07056928f, 0.01852081f, -0.01482242f, -0.11051647f, -0.10667653f, 
    -0.01789240f, -0.04313026f, 0.08345942f, -0.05179032f, 0.13132495f, -0.01550997f, 0.15823658f, 0.25383160f, 
    -0.03920960f, -0.08267418f, 0.01184971f, 0.03593409f, -0.14662440f, -0.02410168f, -0.11183383f, 0.00479366f, 
    0.13030738f, -0.03399628f, -0.01508415f, 0.12393591f, -0.05029553f, -0.00727116f, -0.00194412f, 0.03036686f, 
    -0.04447460f, -0.04862077f, 0.13233268f, -0.07777967f, 0.31625041f, -0.13782056f, 0.04064012f, 0.04724788f, 
    -0.05621965f, 0.01625700f, -0.02195239f, 0.06311432f, 0.17440182f, -0.02305068f, 0.06113393f, -0.00690491f, 
    -0.23128314f, -0.03509007f, -0.04233888f, 0.14365342f, -0.10666991f, -0.05988424f, -0.12442245f, 0.00656474f, 
    -0.08963391f, 0.00370318f, -0.02398936f, 0.05951826f, -0.19037032f, -0.12148107f, 0.00444611f, -0.10088917f, 
    -0.09593678f, -0.00463903f, 0.01392178f, 0.01174502f, 0.05000677f, -0.05858925f, -0.03949281f, -0.05833539f, 
    0.25542206f, 0.01510062f, -0.01995490f, -0.01805191f, -0.11106623f, -0.08476029f, 0.00790677f, 0.04900635f, 
    0.06161715f, -0.10483748f, -0.00103191f, 0.17654273f, -0.12932827f, 0.03450793f, -0.17404583f, -0.09074151f, 
    0.02128828f, 0.03004797f, 0.02278042f, 0.06400514f, 0.05493404f, 0.14375600f, 0.10211258f, 0.01021552f, 
    0.14616853f, 0.04850309f, -0.04145825f, 0.02264080f, -0.12119370f, 0.15886988f, -0.03895541f, 0.02371537f, 
    0.04100480f, 0.03181655f, -0.02434302f, 0.08495062f, 0.29667088f, 0.04631939f, -0.05402494f, 0.13227655f, 
    0.02616051f, 0.06105283f, -0.14650582f, 0.03216889f, 0.01200110f, -0.11758967f, 0.14292312f, 0.02214011f, 
    0.37106913f, -0.15607308f, -0.01568066f, 0.14652322f, -0.13498376f, -0.06282114f, 0.06056360f, 0.05685467f, 
    -0.02742904f, -0.03820136f, -0.07166921f, 0.09443475f, 0.19584963f, -0.15837939f, -0.03691630f, 0.09172659f, 
    -0.05821777f, -0.00911937f, -0.01223698f, 0.07821139f, 0.08345158f, -0.04198308f, 0.00563076f, 0.00497394f, 
    -0.08685290f, 0.01700642f, -0.02294702f, 0.17778926f, -0.07634541f, -0.04125571f, -0.05640615f, -0.02324364f, 
    -0.01503772f, -0.13019529f, 0.05219430f, 0.03718064f, 0.37636298f, -0.14126465f, 0.12312144f, 0.10390615f, 
    -0.07577453f, 0.01305206f, -0.11659548f, 0.10587879f, 0.04962507f, 0.15964922f, -0.00473369f, 0.08108719f, 
    -0.11458810f, -0.08387549f, -0.25662881f, -0.08840775f, 0.04155244f, 0.04253348f, 0.06358482f, -0.07777186f, 
    0.03256934f, 0.00060277f, 0.08765818f, 0.12391593f, 0.05479251f, -0.01594356f, -0.00478172f, 0.00822870f, 
    0.03655431f, -0.08603518f, -0.02108864f, 0.10971319f, -0.02940967f, 0.03163186f, 0.08037660f, -0.07256568f, 
    0.21080387f, -0.13036686f, -0.08116542f, 0.05327416f, 0.02449751f, 0.03914396f, -0.04389508f, -0.00039616f, 
    0.02482789f, 0.10516926f, -0.11133678f, -0.03126948f, -0.33493856f, -0.12658983f, -0.18702765f, 0.07838938f, 
    -0.03788458f, -0.03304989f, -0.05977545f, -0.07359046f, -0.07147615f, 0.04931825f, -0.14375411f, 0.16933139f, 
    -0.29862681f, -0.02742019f, -0.00820019f, 0.24948451f, -0.03660386f, 0.00644478f, -0.11709563f, -0.01877189f, 
    -0.06334376f, -0.05682337f, 0.22962525f, 0.00812423f, -0.18327822f, -0.01712452f, 0.06322410f, -0.05906292f, 
    0.07397969f, -0.00817947f, 0.07562962f, -0.01895531f, 0.08604868f, -0.03647458f, 0.06698837f, 0.08320639f, 
    -0.05352581f, 0.04945628f, -0.17459600f, -0.02595665f, -0.03202089f, 0.03328306f, -0.08774697f, -0.10946908f, 
    0.04232359f, -0.06780752f, -0.11853558f, -0.05114785f, 0.11441729f, -0.26253596f, 0.06426331f, 0.14482528f, 
    -0.04325701f, 0.05233101f, -0.07002680f, 0.00655799f, -0.00131034f, 0.03036025f, -0.01258845f, 0.02076685f, 
    0.18405961f, 0.04453958f, 0.07956039f, 0.07791802f, -0.02400967f, 0.00584718f, 0.06688587f, -0.00864323f, 
    -0.15603638f, -0.13097759f, -0.01367723f, 0.01738672f, -0.37514645f, -0.19413437f, 0.16206652f, 0.00572061f, 
    0.09137186f, -0.00973708f, 0.04941032f, 0.04184876f, 0.02271405f, 0.06953049f, -0.01221679f, -0.09316487f, 
    0.16191703f, 0.06762249f, 0.03054165f, 0.15176874f, -0.04204048f, -0.07072888f, 0.10459257f, 0.10205472f, 
    -0.00834382f, -0.03072797f, -0.08409434f, -0.02866152f, 0.05380796f, -0.01370686f, -0.04182791f, 0.01809874f, 
    -0.14710535f, -0.00598995f, -0.09394822f, -0.02429027f, 0.00209031f, 0.03941943f, -0.05886506f, 0.02119551f, 
    -0.08912998f, 0.10624880f, -0.00378325f, -0.07389614f, 0.13235725f, 0.01769491f, 0.00286932f, -0.08983808f, 
    0.06705526f, 0.07059151f, 0.06202829f, 0.07972855f, -0.32668343f, 0.12448326f, -0.34567723f, -0.21647491f, 
    0.07365960f, 0.06984190f, -0.00023232f, 0.07118492f, 0.07013640f, 0.12043405f, -0.09096120f, -0.01497461f, 
    0.23720375f, -0.04616953f, -0.11259141f, -0.12671471f, -0.03612229f, -0.14257655f, 0.05203288f, -0.04603763f, 
    -0.05317652f, -0.03718308f, -0.10296903f, 0.04530024f, -0.13704379f, -0.13309032f, -0.12626237f, -0.00184514f, 
    -0.08329882f, -0.03493429f, -0.14023291f, -0.18037577f, -0.03357720f, 0.03848935f, 0.10982209f, -0.02385269f, 
    0.12166700f, 0.00335863f, 0.11835659f, 0.25187704f, 0.04866012f, -0.00923423f, 0.05315163f, -0.01008557f, 
    -0.05917779f, 0.04006766f, -0.03705498f, 0.12195166f, -0.47008905f, 0.04407200f, -0.07244035f, 0.06235659f, 
    0.05415117f, -0.03148441f, -0.07231773f, 0.00401956f, -0.03806600f, -0.02679241f, 0.03058958f, 0.12804917f, 
    0.13709642f, -0.13584363f, -0.00522213f, -0.18469292f, 0.05473420f, -0.09122671f, -0.00147863f, 0.02860193f, 
    -0.00627392f, -0.03688019f, 0.11982730f, -0.00897302f, 0.34665877f, 0.17116196f, -0.06872392f, 0.19016801f, 
    -0.12041567f, 0.05788238f, -0.02549948f, 0.01547552f, 0.03153944f, 0.02446683f, -0.05429145f, 0.04156616f, 
    0.06640062f, 0.04643358f, -0.18553218f, 0.02036625f, -0.07352284f, 0.02896705f, 0.06708732f, -0.00315286f, 
    0.00299353f, -0.17284204f, 0.06126446f, 0.23367855f, 0.19597484f, -0.14220905f, 0.07025000f, -0.19690755f, 
    0.00628828f, -0.06249908f, 0.00387739f, -0.03503146f, 0.02188319f, -0.07825024f, 0.02645046f, -0.01896850f, 
    -0.28672102f, 0.14712973f, -0.13194518f, -0.24776351f, -0.15989581f, 0.09427694f, 0.08602269f, -0.11198647f, 
    -0.01844333f, -0.02507684f, -0.00954177f, -0.06167877f, -0.11359453f, -0.06338630f, 0.05784296f, 0.05822619f, 
    -0.02676950f, 0.09290171f, -0.00453524f, 0.05337594f, 0.05848207f, -0.01347404f, -0.09089498f, -0.18224876f, 
    0.08648716f, 0.13697667f, 0.09295000f, 0.16184653f, 0.03373093f, 0.05938362f, 0.09047361f, 0.02731166f, 
    -0.03376220f, -0.03240968f, 0.09902615f, 0.00301534f, -0.05955526f, 0.03649251f, 0.00834188f, 0.11847944f, 
    0.04383166f, -0.20783846f, -0.01084733f, 0.02661673f, 0.05726883f, -0.00095699f, 0.03147870f, 0.11059275f, 
    -0.15141372f, -0.19986002f, -0.02769771f, -0.36045870f, 0.00908258f, 0.07324074f, 0.00541752f, 0.09095292f, 
    0.15316923f, -0.01431549f, -0.00264041f, 0.02316661f, 0.42352271f, -0.12214058f, -0.07293151f, -0.28092736f, 
    -0.05693488f, 0.01859480f, -0.01269981f, 0.08352629f, -0.07024688f, -0.09446873f, 0.01878173f, 0.10083773f, 
    0.21854621f, -0.02419084f, 0.17792886f, 0.15448540f, -0.11280950f, 0.06160282f, 0.01585573f, -0.00376687f, 
    0.00419350f, 0.00696296f, 0.20110857f, -0.08710665f, -0.17266101f, -0.09563865f, -0.27684474f, 0.05150165f, 
    -0.01205178f, 0.12513377f, -0.01446913f, 0.02874986f, 0.01478562f, -0.14699779f, -0.03822300f, -0.07387936f, 
    -0.33159271f, 0.01291967f, -0.01363769f, -0.11483995f, 0.07031123f, 0.14816386f, -0.13132869f, -0.05781722f, 
    0.05329514f, 0.05611938f, 0.03764707f, -0.02314824f, 0.07814053f, -0.07005295f, -0.13689411f, -0.08104256f, 
    -0.02955020f, -0.07744942f, -0.06832960f, -0.07110123f, 0.08066195f, -0.02762916f, -0.02488975f, -0.03892554f, 
    0.00463519f, -0.01886669f, 0.02228937f, -0.09083933f, 0.07546227f, -0.00364474f, 0.08673593f, -0.06071538f, 
    -0.07990090f, -0.09662015f, 0.08493996f, -0.15654543f, -0.07804580f, 0.12635948f, -0.10035618f, 0.01585666f, 
    -0.04522412f, 0.07017890f, -0.00334779f, 0.05896364f, -0.05417762f, 0.09604449f, -0.04832802f, -0.12510706f, 
    -0.04526906f, -0.02267447f, -0.19220211f, -0.10045994f, 0.02365282f, -0.07307555f, 0.03460192f, 0.04684104f, 
    0.12593323f, 0.02260958f, -0.01684469f, -0.02893724f, -0.13885349f, -0.15216273f, -0.15359905f, -0.03181598f, 
    0.09057550f, -0.03129253f, -0.04140075f, 0.03736899f, 0.00283797f, -0.01765554f, 0.01638787f, 0.03134491f, 
    -0.13371520f, 0.03954649f, -0.11099634f, -0.13672037f, -0.01273715f, 0.05346588f, -0.02035863f, -0.00505354f, 
    0.04800656f, 0.04693008f, 0.03988995f, 0.03835982f, 0.23153222f, -0.18093593f, -0.08597343f, 0.07313925f, 
    -0.10524490f, 0.01172251f, -0.01760963f, -0.03171783f, -0.15124837f, 0.12092169f, -0.20856082f, 0.10169473f, 
    0.08204560f, 0.03338526f, -0.19113404f, -0.08332369f, -0.02214441f, 0.14481001f, 0.00224182f, -0.06028363f, 
    0.02975698f, 0.01344969f, -0.00207268f, -0.04616774f, -0.00862780f, -0.13440396f, -0.08222729f, 0.01749763f, 
    -0.04341375f, 0.01681407f, 0.08048142f, -0.03681743f, 0.09493548f, -0.07421888f, -0.13833892f, 0.09079640f, 
    0.08587620f, -0.04456230f, -0.11570916f, -0.18577683f, -0.03929878f, 0.11301485f, -0.01837711f, 0.03896777f, 
    0.06018055f, 0.01114754f, 0.01524053f, 0.02497661f, -0.22588675f, 0.00767452f, -0.11766377f, -0.00106079f, 
    -0.05887512f, -0.04326935f, -0.01795043f, -0.21647607f, -0.11018076f, 0.01135039f, -0.05054732f, 0.03798491f, 
    0.10998161f, -0.09421428f, 0.18867731f, -0.00365784f, -0.10692139f, 0.01109518f, 0.03290926f, 0.00458747f, 
    -0.09447999f, 0.07934819f, 0.00573419f, 0.05089618f, 0.03055874f, -0.04808220f, -0.21775834f, -0.13530606f, 
    -0.07187076f, -0.01028101f, 0.09251945f, 0.03210288f, -0.09807643f, -0.02962791f, -0.06998935f, -0.06670818f, 
    0.20303902f, -0.07682498f, 0.20980966f, -0.22860380f, 0.02023496f, 0.05136169f, 0.00066435f, 0.02368734f, 
    -0.11683712f, 0.00100609f, -0.02671471f, -0.08431508f, 0.20241229f, -0.10992183f, -0.23415591f, 0.05652706f, 
    -0.08155555f, 0.03284305f, 0.00934459f, 0.10452693f, -0.02349789f, -0.08176164f, -0.07672121f, -0.04499216f, 
    -0.10718463f, 0.09646090f, -0.15184090f, -0.02438382f, 0.03255665f, -0.06955232f, 0.10277367f, 0.03665061f, 
    0.05854359f, 0.01776742f, 0.09235324f, -0.21713246f, 0.08415028f, 0.09151606f, -0.14027008f, 0.06046743f, 
    0.05796386f, 0.04237676f, 0.04967176f, -0.01883977f, -0.09249863f, -0.06760944f, -0.08492481f, -0.03232921f, 
    -0.39530426f, 0.04056497f, -0.21963055f, -0.29698622f, -0.01958338f, -0.02085137f, -0.07447245f, 0.02110499f, 
    -0.04281872f, 0.02795592f, -0.14619441f, 0.03934085f, 0.17169695f, -0.00243991f, 0.20061548f, 0.15594617f, 
    -0.10818174f, -0.01996840f, -0.01234652f, 0.00778947f, 0.01460484f, 0.01155883f, 0.06152642f, 0.01765821f, 
    -0.22469628f, 0.07591610f, -0.12497944f, 0.05049676f, 0.01073903f, 0.07047201f, 0.05325813f, 0.01411407f, 
    0.01651847f, 0.02959181f, 0.01198420f, -0.04956309f, 0.06728535f, -0.02623936f, -0.03176079f, -0.04944297f, 
    -0.03389724f, 0.08383087f, 0.04772406f, 0.05181581f, -0.05298222f, -0.04476277f, 0.14611703f, -0.05046525f, 
    -0.26409292f, -0.00469133f, -0.03890840f, 0.06859998f, 0.08508033f, 0.00638912f, -0.07213899f, -0.04197302f, 
    -0.00642788f, 0.07426741f, -0.09615175f, -0.03535188f, -0.19199632f, -0.05264898f, 0.07601444f, -0.17091782f, 
    -0.06078153f, 0.03199285f, 0.03799627f, 0.03457845f, -0.06866461f, 0.02488874f, -0.04126806f, -0.02109553f, 
    0.36581481f, -0.03871034f, -0.05513570f, -0.01205991f, -0.04008044f, 0.07797829f, 0.08659931f, 0.07534798f, 
    -0.00397076f, 0.01951885f, 0.02434226f, -0.09014144f, -0.20884310f, -0.03434211f, 0.09411737f, -0.09365484f, 
    -0.03613936f, 0.06396751f, 0.00564474f, -0.02791670f, -0.03537804f, 0.00434173f, -0.09524970f, -0.06230169f, 
    0.26112041f, -0.27713615f, -0.03153571f, 0.11060102f, -0.04297095f, -0.03293961f, -0.04898656f, 0.01426624f, 
    0.03126932f, 0.01049282f, 0.00726537f, -0.05494680f, -0.47365192f, -0.09816840f, 0.14680935f, -0.16597797f, 
    -0.04438940f, 0.08728359f, 0.02655282f, -0.04825149f, 0.02055526f, -0.11953054f, 0.03120416f, 0.01421099f, 
    -0.08185077f, 0.02819258f, 0.02053438f, 0.02711432f, 0.12365760f, 0.03380870f, 0.00383425f, -0.05632756f, 
    -0.07884769f, -0.13354778f, -0.05827072f, -0.00970494f, 0.33092999f, -0.11189336f, 0.04338611f, 0.08700596f, 
    -0.00579197f, 0.11104264f, -0.06229492f, 0.01544679f, -0.03272924f, 0.01101578f, 0.01031202f, 0.00784484f, 
    0.17889306f, 0.02072315f, 0.10162387f, -0.03058045f, -0.04893113f, -0.05861510f, 0.06083471f, 0.08231552f, 
    -0.10539152f, 0.01057992f, 0.08090037f, -0.03227875f, -0.28011584f, 0.03115412f, -0.03913221f, -0.02291462f, 
    0.12829195f, 0.01878072f, -0.08406742f, -0.01922713f, -0.06908156f, 0.01282166f, -0.04796819f, -0.00841493f, 
    0.17540598f, -0.20029287f, -0.11679132f, -0.08592987f, -0.07379968f, -0.00129572f, -0.08924632f, -0.02386412f, 
    -0.02097848f, 0.03168000f, 0.01243669f, -0.00229812f, -0.09195295f, -0.03734157f, -0.04244791f, 0.01898693f, 
    0.04636808f, -0.03049218f, -0.00579890f, 0.12783030f, 0.07109705f, 0.02413268f, -0.04871180f, 0.04070624f, 
    0.05935753f, 0.07579879f, -0.23947772f, -0.11818239f, -0.03421056f, 0.07224827f, -0.03602608f, 0.04937977f, 
    -0.07360964f, -0.03143638f, -0.10228131f, 0.01522359f, 0.01572820f, 0.06118551f, -0.06489898f, -0.04745289f, 
    -0.06180151f, -0.02332362f, 0.08478932f, 0.00297723f, -0.03474329f, -0.09251349f, 0.06860615f, -0.03729413f, 
    0.13504396f, -0.08130856f, 0.08939261f, 0.16140534f, -0.12923943f, -0.11878514f, -0.05331685f, 0.11935546f, 
    0.08892187f, -0.05402353f, -0.00740659f, 0.05876390f, 0.08922052f, 0.10134145f, -0.10411416f, -0.08541220f, 
    0.00557046f, 0.02637031f, -0.00623932f, 0.01555581f, 0.05207775f, 0.07737543f, -0.04585708f, -0.12562306f, 
    0.40791753f, -0.07227541f, -0.05514005f, -0.00572465f, 0.02032365f, 0.05211389f, 0.04930068f, 0.03513461f, 
    -0.05258097f, 0.02815031f, -0.06889724f, -0.10744534f, 0.03295219f, -0.10611644f, -0.08165621f, 0.14193150f, 
    -0.04638237f, -0.07241157f, -0.15503427f, 0.00353802f, 0.00264001f, 0.02803306f, -0.02057445f, 0.09102767f, 
    0.18265758f, -0.15273978f, -0.00549078f, -0.06446269f, -0.08786112f, 0.07700966f, -0.03110117f, -0.06529116f, 
    0.02316095f, -0.09960066f, -0.02352931f, -0.05822944f, 0.41781121f, 0.02189570f, -0.04627964f, 0.10846499f, 
    0.05525553f, -0.04321730f, 0.11053308f, -0.05091551f, 0.02158984f, 0.02960380f, 0.08005374f, -0.04107020f, 
    0.07475870f, 0.07207321f, -0.01428933f, -0.05271052f, 0.09193597f, 0.03348048f, -0.03178298f, -0.04663285f, 
    -0.06837756f, 0.09739085f, 0.04308259f, -0.02412373f, 0.09717891f, 0.12484632f, 0.06422037f, -0.13799454f, 
    -0.00963076f, -0.07711457f, -0.02545608f, -0.02838072f, -0.06350894f, -0.04562880f, 0.03925954f, -0.02739988f, 
    -0.10056604f, 0.05402240f, -0.06802595f, 0.01221133f, -0.01619338f, 0.07753374f, -0.00057110f, -0.05419577f, 
    0.01972925f, 0.02977728f, -0.04750437f, 0.02668910f, 0.14869711f, -0.06520234f, 0.10884442f, -0.00290382f, 
    -0.07541799f, 0.06700350f, -0.01589862f, -0.07002929f, -0.03337083f, -0.04110589f, -0.05379832f, 0.00232058f, 
    0.22952080f, 0.04847122f, -0.19564548f, 0.08210988f, -0.12912402f, 0.07572648f, 0.06023445f, -0.02650607f, 
    -0.05174976f, -0.00686142f, 0.03013830f, -0.05882369f, 0.18531194f, -0.10315181f, -0.38409472f, -0.05133599f, 
    0.01266948f, 0.01889710f, 0.00677682f, -0.05988457f, -0.01461555f, -0.02542346f, 0.01781904f, -0.04426961f, 
    0.00588722f, -0.17170797f, 0.02902998f, -0.07703757f, -0.02411999f, 0.00677973f, 0.10760970f, -0.00594246f, 
    -0.03722696f, 0.00432970f, 0.02922392f, -0.13775899f, 0.11337484f, -0.03439317f, -0.10339094f, 0.05781435f, 
    -0.00179056f, 0.04385212f, 0.00922191f, 0.05606942f, -0.06889588f, -0.07104168f, -0.09809764f, -0.07726022f, 
    0.00295793f, 0.01496229f, 0.01155815f, 0.03384455f, 0.11980943f, 0.04407437f, -0.00458545f, -0.04369707f, 
    0.05661636f, 0.03418266f, 0.07428108f, 0.00456831f, 0.13706999f, -0.00333920f, 0.03063406f, -0.10133379f, 
    -0.14958625f, -0.07024181f, 0.08112762f, -0.03416644f, -0.04163904f, 0.01984105f, -0.09391378f, -0.00514040f, 
    -0.28751409f, -0.09891331f, 0.07879377f, -0.18168646f, 0.03211560f, 0.05344908f, 0.01941915f, -0.11959513f, 
    -0.07739249f, -0.06029503f, -0.08318742f, -0.06607051f, -0.00636309f, -0.06138369f, -0.02252722f, 0.02844728f, 
    0.06377895f, 0.02062338f, -0.04242130f, -0.01161024f, -0.02477840f, -0.02297861f, -0.11666477f, -0.00316599f, 
    0.10916542f, 0.07552521f, -0.25099033f, -0.06954951f, -0.00072057f, -0.00606349f, -0.01489381f, 0.04802435f, 
    -0.11720865f, 0.04040914f, -0.19322990f, 0.05643904f, -0.34905520f, -0.10556147f, -0.08439679f, -0.12859286f, 
    -0.00436875f, -0.03215295f, 0.09746942f, -0.02779479f, 0.00714540f, 0.01111677f, 0.05806443f, 0.03568287f, 
    0.25301698f, 0.00688019f, -0.06107184f, -0.13411666f, 0.06973579f, 0.11362521f, -0.04454267f, -0.11301821f, 
    0.09147659f, -0.00816038f, -0.01995312f, -0.05200724f, 0.14902405f, 0.16017461f, -0.10247505f, -0.03116552f, 
    0.07880355f, 0.05841761f, 0.05454922f, -0.02686601f, 0.00598828f, 0.15664591f, 0.00434171f, -0.03260522f, 
    0.06077812f, 0.02363952f, -0.09490568f, 0.05099172f, -0.02621013f, 0.04265239f, 0.01922620f, -0.07131157f, 
    0.03177771f, 0.06394661f, -0.08727687f, 0.02273514f, 0.00980770f, 0.00557027f, -0.11539876f, 0.06738879f, 
    0.00476777f, 0.07576936f, 0.00270238f, -0.01767218f, 0.02055683f, -0.01897452f, -0.07154778f, -0.06869953f, 
    0.07781333f, -0.00142957f, 0.09053202f, 0.21045440f, -0.02095535f, -0.17751700f, 0.03962851f, -0.01871123f, 
    0.00979443f, -0.07064347f, -0.11795519f, -0.01297650f, -0.13373677f, -0.00628480f, 0.07809789f, 0.00849858f, 
    -0.09380765f, -0.14573835f, 0.07016859f, -0.05330173f, -0.04951222f, -0.07275995f, 0.07439567f, 0.01749562f, 
    0.16270724f, -0.18357876f, -0.05655541f, 0.08829365f, 0.00326679f, 0.02874686f, -0.02339027f, -0.08070446f, 
    -0.00379449f, 0.07933880f, -0.05103463f, 0.08796355f, -0.25085419f, 0.02113605f, -0.36410090f, -0.20318605f, 
    0.05415868f, 0.02375439f, -0.10155250f, -0.03243716f, -0.05078117f, 0.15861253f, -0.01104789f, 0.02818094f, 
    0.03686175f, 0.03966722f, -0.04188474f, 0.07769721f, 0.05237477f, 0.01150047f, 0.05914458f, -0.02997512f, 
    -0.08772247f, 0.04371422f, 0.04267573f, 0.10214236f, 0.20439897f, 0.01221217f, 0.16261375f, 0.07828080f, 
    -0.07406679f, -0.04033384f, 0.03208137f, 0.16793822f, -0.01374136f, -0.00339411f, 0.02619531f, -0.11346948f, 
    -0.03040935f, -0.04696440f, -0.09159055f, -0.01999041f, -0.05529065f, 0.00153555f, -0.06710017f, 0.05513257f, 
    0.02024859f, 0.03173014f, -0.02238957f, -0.02082518f, 0.20162337f, -0.09217031f, -0.00724572f, 0.04908513f, 
    -0.08177120f, -0.05087077f, 0.13992009f, 0.07540687f, 0.09116179f, 0.00716583f, -0.08794254f, 0.02799882f, 
    0.12294896f, -0.01669175f, 0.15304488f, 0.21784922f, -0.15114675f, -0.10599128f, -0.00324078f, 0.05163419f, 
    -0.06236512f, -0.04401657f, 0.04273963f, -0.01694020f, -0.15134789f, -0.21085128f, -0.06262021f, -0.05518300f, 
    -0.04453695f, 0.05110366f, -0.10098569f, 0.05502703f, 0.00866385f, 0.04967709f, -0.08514427f, -0.06872874f, 
    0.27450344f, -0.14783593f, -0.11417971f, -0.01596672f, 0.03179350f, -0.05074689f, -0.05982130f, 0.04371121f, 
    -0.10911341f, -0.06342100f, 0.00115223f, -0.15204847f, 0.25159067f, -0.14379379f, 0.06154831f, -0.17075005f, 
    -0.11403704f, 0.04254123f, 0.01469175f, 0.07927082f, 0.07164460f, -0.04595258f, 0.08658528f, -0.09353802f, 
    0.07893267f, -0.20049942f, -0.09087344f, 0.03449329f, -0.06351922f, 0.02804564f, -0.01983612f, -0.08269844f, 
    -0.04248157f, 0.05390292f, -0.06047553f, 0.02699826f, 0.27654424f, -0.00667335f, 0.01364176f, 0.03932992f, 
    -0.19507788f, -0.05180588f, -0.02404663f, 0.00003682f, 0.05453601f, -0.01879996f, -0.01764313f, 0.00372140f, 
    0.14261723f, -0.21915874f, -0.15470584f, 0.01919754f, -0.01778290f, -0.10959735f, 0.00067898f, -0.06155586f, 
    -0.12006049f, -0.00485977f, -0.05170496f, -0.06899554f, 0.06906403f, 0.08260608f, -0.28826699f, -0.04981126f, 
    -0.02732342f, 0.14118133f, -0.12853993f, 0.04437434f, -0.01413643f, -0.02866083f, 0.05192234f, -0.09156348f, 
    0.11293261f, -0.04453649f, -0.02349263f, 0.05318536f, 0.10054341f, -0.00862203f, -0.00045793f, -0.11709998f, 
    0.05727139f, -0.04086072f, -0.05920982f, -0.06272266f, -0.13765542f, -0.15486385f, -0.02064801f, -0.05875972f, 
    0.01045831f, -0.06060453f, 0.04828889f, -0.03305046f, -0.01061499f, 0.00169528f, -0.08425771f, 0.00373198f, 
    0.20308030f, 0.12109336f, -0.04818406f, 0.10202464f, -0.09525145f, 0.00123635f, 0.08785082f, 0.06005826f, 
    -0.04939988f, -0.03190561f, -0.02894442f, -0.01121752f, 0.36070564f, -0.04401300f, 0.11873554f, -0.01948649f, 
    -0.07690630f, -0.00644491f, -0.01626793f, -0.05276215f, -0.12780948f, 0.00566779f, 0.01119913f, -0.09122070f, 
    0.07910704f, -0.11332237f, 0.02616784f, -0.14796069f, 0.05262933f, -0.01398086f, -0.00009551f, 0.10308166f, 
    0.01428708f, 0.08022752f, -0.05355239f, -0.01706581f, 0.10101777f, -0.00452662f, 0.09485827f, -0.02327722f, 
    -0.00313834f, -0.09502299f, -0.12334914f, -0.06401093f, 0.05047416f, -0.05079074f, 0.06047814f, -0.09498657f, 
    0.25396386f, 0.04186823f, 0.07914615f, -0.01425166f, -0.00675161f, -0.01155230f, 0.05833092f, 0.01846579f, 
    -0.00534091f, 0.01738200f, -0.06151165f, -0.04755586f, 0.04950346f, 0.01766089f, -0.03882584f, -0.01571046f, 
    -0.02358160f, -0.10794888f, 0.01797388f, -0.03900671f, -0.14086093f, 0.01184861f, -0.00866526f, -0.00130622f, 
    -0.07715580f, -0.27499092f, 0.01015001f, 0.05803086f, -0.05329768f, -0.16039430f, 0.03340381f, 0.12749150f, 
    -0.06838192f, 0.18446545f, 0.02933328f, -0.01001472f, -0.01422800f, 0.01646809f, -0.10669682f, 0.12291751f, 
    0.04684959f, 0.12126032f, 0.03295837f, -0.03455384f, -0.09419947f, 0.04663120f, 0.00409838f, -0.05603942f, 
    0.25309458f, -0.27340162f, -0.04543006f, 0.15522964f, 0.07959461f, 0.07805222f, -0.04341866f, -0.07840089f, 
    0.02749079f, -0.00985384f, -0.10499506f, 0.05041391f, -0.46999916f, -0.11820097f, -0.13591775f, 0.03572607f, 
    0.04064587f, 0.05874104f, -0.12213305f, -0.01220313f, -0.07203510f, -0.03559632f, 0.01959338f, 0.07575814f, 
    -0.12154207f, 0.00288678f, 0.19108437f, 0.00588478f, 0.12630621f, 0.03244496f, 0.01614497f, 0.06975748f, 
    0.04486044f, -0.04068404f, -0.02205764f, -0.00444753f, 0.17234729f, -0.11562433f, 0.03734925f, 0.03446014f, 
    0.00121670f, 0.02911006f, 0.04553857f, 0.07863097f, -0.03387024f, 0.05349778f, -0.21554722f, -0.10747699f, 
    0.16403373f, -0.02315240f, -0.03778839f, 0.02902100f, -0.05020497f, -0.19421332f, -0.10914002f, -0.09827389f, 
    -0.10713340f, 0.08342962f, 0.03306066f, -0.02757117f, -0.06200713f, 0.03519522f, -0.02625617f, 0.12264061f, 
    0.09674792f, 0.02968997f, -0.06930763f, 0.03640026f, 0.11603145f, -0.08096170f, -0.04095331f, 0.04405486f, 
    -0.26039773f, -0.15832366f, 0.00113705f, 0.02230189f, 0.00720775f, -0.17887072f, 0.06008444f, -0.03144323f, 
    -0.03271188f, -0.10556476f, -0.01038295f, -0.07269122f, 0.01034419f, -0.03358423f, 0.07969219f, -0.13426043f, 
    -0.01301946f, 0.07426648f, 0.11421506f, -0.03458586f, -0.00201599f, 0.08813651f, -0.16317092f, 0.02354984f, 
    0.11543612f, -0.55038440f, -0.40691146f, -0.07993007f, -0.13287370f, 0.09099131f, -0.13618959f, 0.09950403f, 
    -0.03319946f, 0.06860239f, -0.02994331f, -0.01477068f, 0.07093623f, -0.30693954f, 0.04385212f, 0.13877691f, 
    -0.02149111f, 0.00593403f, 0.10135113f, -0.07123973f, 0.06573492f, -0.01778548f, 0.07568593f, 0.03079063f, 
    0.02572563f, 0.16171594f, 0.14009283f, 0.06343856f, -0.05473304f, -0.02820455f, -0.00427062f, 0.08238655f, 
    -0.04484384f, -0.03409500f, -0.03637172f, 0.03891033f, 0.10052509f, 0.01420692f, -0.11507399f, -0.14339724f, 
    -0.11593527f, -0.04297192f, -0.03128123f, -0.06731021f, 0.05476711f, -0.02458151f, -0.03354254f, -0.05725836f, 
    -0.18914706f, 0.11057710f, -0.20068979f, 0.02009628f, 0.04772786f, -0.01850071f, -0.01387788f, 0.15372057f, 
    0.01492304f, 0.04751774f, -0.06052835f, -0.05037731f, -0.04128130f, 0.11256461f, 0.04025320f, 0.05659671f, 
    -0.02626292f, 0.04435310f, 0.06706988f, -0.11827623f, 0.01248974f, -0.08970697f, -0.02483436f, -0.00879410f, 
    -0.10344428f, -0.11332317f, -0.14009446f, -0.07036532f, -0.13133383f, -0.11338899f, 0.11654416f, 0.06214834f, 
    0.00420223f, -0.09305651f, 0.06148621f, -0.08315572f, 0.05851289f, -0.00331004f, 0.18550636f, 0.07486441f, 
    0.00592034f, -0.06020161f, 0.11336434f, -0.06073352f, -0.11139143f, -0.09357960f, 0.00244199f, -0.04153541f, 
    -0.04386913f, 0.02732535f, 0.17882016f, -0.05187603f, -0.03138926f, 0.02016357f, 0.03107961f, 0.01328960f, 
    -0.03013168f, -0.02486537f, -0.03222864f, -0.06176297f, 0.16681935f, 0.02685877f, 0.00374121f, -0.12719542f, 
    -0.13612419f, 0.01199025f, 0.03229701f, 0.07830872f, -0.09087902f, -0.00530246f, -0.03276668f, -0.00636656f, 
    0.07301053f, 0.18512192f, 0.06232388f, 0.04186571f, -0.02683506f, 0.01096870f, -0.05450911f, 0.08338227f, 
    0.04878397f, -0.05671204f, 0.14122678f, -0.01526210f, 0.12691519f, -0.00845330f, 0.17165270f, 0.03390664f, 
    0.06495693f, 0.06493123f, 0.06231821f, -0.18491127f, -0.09635830f, 0.08518326f, -0.01733938f, -0.01313950f, 
    -0.04480002f, -0.16686939f, -0.16787456f, -0.04003083f, -0.04327379f, -0.00453192f, -0.08678187f, -0.05989416f, 
    0.05479184f, 0.01605131f, -0.01791407f, 0.05915337f, 0.15502101f, 0.12004155f, -0.07877732f, -0.02209318f, 
    -0.08017152f, -0.06326748f, -0.01735010f, -0.07644549f, -0.00729659f, -0.12806031f, -0.09787118f, -0.00685327f, 
    -0.47696707f, -0.19837996f, -0.21118191f, 0.20350058f, -0.03051637f, -0.01685234f, 0.01594032f, -0.16060096f, 
    -0.09946584f, 0.07372990f, 0.00226172f, 0.01885416f, -0.01127360f, 0.01481322f, 0.05902375f, 0.00753787f, 
    -0.07329179f, 0.01319307f, -0.02275891f, 0.10794937f, -0.08267768f, 0.01321926f, -0.02050482f, -0.03853520f, 
    -0.45760989f, 0.12036429f, -0.05285399f, -0.04869897f, -0.03611109f, -0.13739216f, -0.06642637f, 0.15432230f, 
    0.01388732f, -0.05466850f, -0.05406835f, 0.05185287f, 0.03195347f, 0.19262739f, 0.14088970f, -0.08213099f, 
    0.01434442f, 0.00451234f, 0.04960730f, -0.00451556f, -0.03765243f, -0.05319730f, 0.03593426f, -0.07161474f, 
    -0.01762322f, 0.01348066f, -0.18541503f, 0.04944133f, -0.08734262f, 0.13142928f, 0.06531073f, 0.07323482f, 
    -0.01266347f, 0.02161360f, 0.04729842f, -0.10483512f, -0.39842346f, 0.03069334f, 0.08843628f, 0.14761671f, 
    0.11847163f, 0.03723524f, 0.20396338f, 0.03886781f, -0.06183744f, -0.07345011f, -0.18386732f, -0.02838240f, 
    -0.49074006f, -0.47754776f, -0.10212503f, 0.08304179f, -0.05914458f, -0.06242548f, -0.04865545f, -0.03333582f, 
    -0.06774891f, -0.03720234f, 0.10165568f, -0.12086008f, -0.22529960f, 0.14504261f, 0.11959741f, -0.14458151f, 
    -0.11692039f, 0.04506448f, -0.03220661f, -0.02517394f, 0.03123652f, 0.01204140f, -0.09947507f, 0.09698521f, 
    -0.02566668f, 0.11093484f, -0.05990132f, 0.08869021f, -0.06697946f, 0.04638048f, 0.03062762f, 0.00468814f, 
    0.04905887f, -0.01865076f, -0.08550546f, 0.04142567f, -0.52957851f, -0.17781994f, -0.17987666f, -0.08136572f, 
    -0.12090104f, -0.08505167f, 0.05412424f, -0.11805049f, 0.02524265f, -0.17408493f, 0.04539904f, 0.03311105f, 
    -0.23887038f, 0.21902700f, 0.01563641f, 0.09665053f, -0.09970143f, -0.01433861f, -0.06865649f, 0.06303562f, 
    -0.11483573f, -0.05879373f, 0.10586607f, 0.04579291f, 0.17131644f, -0.01110713f, 0.07218510f, 0.03448484f, 
    -0.02273830f, 0.03177801f, 0.01981419f, 0.10543228f, -0.04661942f, 0.10181861f, -0.06789321f, 0.21269193f, 
    0.12602106f, 0.32928884f, 0.20337757f, -0.16868776f, 0.05804111f, -0.01263638f, -0.00132036f, 0.14795072f, 
    0.08179885f, -0.01622065f, -0.10010009f, 0.01416020f, -0.33187589f, 0.15457280f, 0.06187375f, 0.21700740f, 
    0.02768151f, 0.11126875f, 0.00953056f, -0.05566100f, 0.02141877f, 0.06185903f, 0.05224381f, 0.04713982f, 
    -0.24185918f, -0.05690557f, -0.05171379f, -0.01376062f, -0.05956709f, 0.00651129f, 0.06732775f, -0.04678384f, 
    0.00212913f, 0.00976436f, -0.00601912f, -0.01192883f, 0.03277188f, -0.15926941f, 0.01478200f, 0.04942199f, 
    -0.08090919f, 0.04487232f, 0.13062601f, 0.01757993f, 0.03845062f, -0.04687914f, 0.08304231f, -0.10344024f, 
    -0.03857212f, 0.03880228f, -0.03041508f, -0.19141877f, -0.18546593f, 0.08272010f, -0.04289216f, 0.02950456f, 
    -0.07237429f, 0.01291509f, -0.08042927f, 0.06236111f, -0.02046369f, -0.21626182f, -0.00139256f, 0.05789908f, 
    -0.09260814f, 0.02254436f, -0.06401580f, 0.02710223f, -0.08350604f, -0.00419815f, 0.04844649f, 0.05712170f, 
    0.42329359f, -0.43096673f, -0.20302883f, 0.12145764f, 0.01404189f, -0.06695922f, -0.03609309f, 0.01109127f, 
    -0.03614050f, 0.08255428f, -0.10416226f, 0.01254236f, 0.00019489f, -0.11455085f, 0.06740224f, 0.03708843f, 
    0.02366304f, 0.02459088f, 0.07815367f, 0.03550889f, -0.01357789f, 0.00699278f, 0.01567294f, 0.11745569f, 
    0.15104018f, 0.21199681f, 0.01689221f, -0.01038104f, 0.01065060f, -0.08145704f, -0.04384732f, 0.09705468f, 
    -0.12477470f, -0.01220165f, 0.03011142f, 0.01083872f, -0.25177631f, 0.02434727f, 0.05808775f, -0.25355172f, 
    -0.04410009f, -0.00329969f, -0.02796909f, -0.00868017f, 0.08180387f, -0.09130227f, 0.02066224f, 0.03844517f, 
    -0.02807774f, 0.20416705f, -0.03214784f, -0.03726402f, -0.09684373f, -0.11782304f, -0.03829975f, -0.00384067f, 
    0.02521957f, -0.13252428f, 0.08384822f, 0.10380224f, -0.04856965f, -0.10406584f, 0.03002749f, -0.09678751f, 
    -0.06064757f, -0.06131035f, -0.01196787f, -0.03225458f, 0.04485475f, -0.08861331f, 0.04195843f, -0.06798499f, 
    -0.06574186f, 0.02877218f, 0.03942945f, -0.15041061f, -0.13886510f, 0.01413124f, 0.06454647f, -0.03332169f, 
    -0.03310646f, -0.04458733f, 0.03215351f, -0.00449975f, 0.33796760f, 0.05075509f, -0.08461534f, 0.01841241f, 
    0.10215028f, 0.00145899f, 0.01921196f, 0.03138309f, 0.00636336f, 0.03709896f, -0.04229673f, 0.01910589f, 
    -0.21235231f, 0.23339581f, 0.16835169f, 0.13167650f, 0.10564202f, -0.01259176f, -0.05738135f, -0.01537544f, 
    0.00119062f, -0.01544440f, -0.11725853f, -0.04908359f, 0.05233869f, -0.07044032f, 0.05945445f, 0.00905608f, 
    0.02392086f, 0.01484295f, -0.08824709f, -0.01333605f, 0.04784582f, -0.02569229f, 0.07488873f, -0.07310417f, 
    0.38667685f, -0.08460472f, -0.10888580f, 0.14970437f, 0.04393559f, -0.07777160f, 0.02436287f, 0.14106472f, 
    0.02254676f, 0.06032715f, 0.10344540f, -0.00276253f, 0.16715387f, 0.07322901f, 0.01451195f, 0.01306765f, 
    -0.04364125f, -0.05531806f, -0.06606712f, -0.06195029f, -0.06806896f, -0.07061376f, -0.00176075f, 0.02688527f, 
    0.24760385f, -0.03866622f, 0.14606318f, 0.04932747f, 0.14103808f, -0.00209696f, -0.00704433f, 0.02425118f, 
    0.03170513f, 0.05790175f, -0.12431414f, -0.14237429f, -0.04779636f, 0.09836502f, 0.17849526f, -0.10695574f, 
    0.05745990f, -0.08355194f, -0.03015601f, 0.10633273f, 0.00446496f, -0.12730193f, 0.00338203f, -0.01769903f, 
    0.29236844f, -0.42413670f, 0.04122244f, 0.27919230f, 0.07216911f, -0.01894488f, -0.06290362f, -0.00446920f, 
    -0.00660543f, -0.12808472f, -0.08433143f, -0.07866289f, 0.07528701f, 0.06766926f, 0.11850369f, -0.12144413f, 
    0.02377548f, -0.03424349f, -0.02756506f, 0.00316286f, 0.04513150f, -0.02293905f, 0.03642304f, 0.12544712f, 
    -0.00319346f, 0.02553334f, -0.08506385f, 0.11498067f, 0.00732370f, -0.03363471f, -0.01432287f, -0.00279851f, 
    -0.13132392f, 0.10801765f, 0.07963554f, -0.01853809f, 0.04947440f, -0.00299895f, 0.02721477f, 0.05328701f, 
    -0.04727444f, -0.05384349f, -0.12086090f, -0.03236708f, 0.06058459f, 0.11308398f, 0.01437076f, 0.01150714f, 
    -0.20716158f, -0.11026537f, -0.03641009f, 0.03338203f, -0.02145231f, -0.03397523f, -0.10406823f, 0.08720849f, 
    0.05643851f, -0.01220046f, -0.02582148f, 0.07866004f, 0.09803131f, 0.11258654f, -0.01764192f, 0.01492320f, 
    -0.00709533f, -0.10587373f, -0.02544930f, 0.06664927f, -0.01940045f, 0.01776783f, -0.02359367f, 0.07521481f, 
    0.04784623f, -0.12360335f, 0.02791325f, -0.00439468f, -0.00661580f, 0.06703136f, 0.05637118f, 0.07484943f, 
    -0.01755139f, 0.01334147f, 0.03052751f, 0.03041666f, -0.52169013f, 0.04626699f, 0.12204406f, 0.07570060f, 
    0.04822579f, -0.01274683f, -0.02924173f, 0.09386423f, -0.03092958f, -0.02134115f, 0.07168070f, 0.01116206f, 
    -0.16916472f, 0.17574416f, -0.18836753f, -0.13667244f, 0.08071903f, 0.02092381f, 0.09038403f, 0.17862424f, 
    0.00416111f, 0.03058897f, 0.02720436f, 0.10827447f, -0.03027257f, -0.07865442f, -0.02541022f, -0.02279477f, 
    -0.02055546f, -0.00049066f, 0.03666164f, 0.06051310f, -0.01453488f, -0.08965500f, 0.01390711f, -0.00924046f, 
    -0.04653484f, 0.00447615f, 0.15057088f, 0.13839607f, -0.08699396f, 0.04410761f, -0.01265324f, -0.01108522f, 
    0.03279148f, -0.13744175f, 0.01336135f, -0.01285276f, -0.40551570f, 0.27665180f, -0.08796397f, -0.14162473f, 
    0.08775629f, -0.01501565f, -0.01376197f, 0.09640933f, 0.07357072f, -0.08860073f, -0.12108747f, -0.04949505f, 
    -0.05345324f, -0.11826598f, 0.01286289f, 0.07601275f, 0.03122931f, 0.01330992f, -0.00920390f, 0.03214474f, 
    0.00436378f, 0.04720160f, -0.09443859f, 0.02546372f, 0.10359786f, -0.01324497f, 0.03161575f, -0.23128109f, 
    0.00655096f, 0.04988816f, -0.02019238f, -0.13743129f, -0.15298475f, -0.04312613f, 0.01701925f, 0.03735135f, 
    -0.01551806f, -0.00146946f, -0.01144336f, 0.08736400f, 0.01985837f, -0.07259422f, 0.02493268f, 0.12729910f, 
    0.03995803f, -0.04500268f, 0.05948585f, -0.09285343f, 0.06773705f, -0.05927873f, 0.09960404f, -0.07480076f, 
    -0.06817700f, 0.04628403f, 0.11410959f, 0.01905039f, 0.04179130f, 0.01585913f, -0.05864152f, -0.09320638f, 
    -0.03634561f, 0.11634298f, -0.07286449f, 0.04153229f, 0.04485940f, -0.04602660f, 0.07368821f, 0.06376609f, 
    -0.08919874f, -0.04813597f, 0.08939254f, -0.07640120f, -0.31302804f, 0.15233044f, -0.01934965f, -0.03780986f, 
    -0.03970036f, -0.03969176f, 0.10069421f, -0.12696984f, 0.03884589f, 0.07678930f, -0.08070219f, 0.00085603f, 
    -0.32764229f, -0.25554025f, 0.05965916f, -0.15674494f, -0.08733980f, 0.08616702f, 0.00415106f, -0.03039789f, 
    0.01931173f, -0.05024895f, -0.08794680f, -0.07443353f, 0.21933423f, 0.19234459f, -0.06227083f, 0.08254929f, 
    -0.01185548f, 0.06525295f, 0.05023617f, 0.02644563f, 0.03852249f, -0.03705782f, 0.02151393f, 0.06434564f, 
    0.00406546f, -0.21041420f, 0.18924455f, -0.03522060f, 0.12075928f, 0.01399474f, -0.03418347f, 0.12371519f, 
    0.00285663f, 0.03168302f, -0.03850136f, 0.11128502f, -0.04133072f, 0.08616643f, -0.14410877f, 0.00377161f, 
    0.00874367f, 0.04639098f, 0.06674833f, -0.09779865f, -0.05077417f, -0.03003179f, 0.03785740f, 0.08160065f, 
    -0.27444190f, -0.22551247f, 0.07872134f, -0.22893381f, -0.00724015f, -0.01264772f, -0.09668998f, -0.07287808f, 
    0.01605424f, -0.09042004f, -0.04892043f, -0.12649183f, -0.07864667f, -0.00686892f, -0.08072795f, -0.03005873f, 
    0.07054183f, -0.00924383f, -0.08666544f, -0.09237125f, -0.01957807f, -0.00545322f, -0.00597178f, 0.04975851f, 
    -0.61600953f, -0.08426771f, -0.05831160f, 0.13513047f, -0.01375769f, 0.01865324f, -0.01351976f, 0.02219470f, 
    -0.06837180f, 0.02170638f, 0.07380625f, 0.10524197f, -0.07582621f, -0.15030666f, 0.05879494f, 0.03816338f, 
    -0.01560101f, -0.00768963f, 0.09877455f, -0.00862673f, 0.00487810f, -0.00859823f, -0.01842571f, -0.18252027f, 
    -0.47735760f, -0.04843584f, -0.00514821f, -0.06245222f, 0.07962402f, 0.03570645f, -0.04778807f, -0.07119498f, 
    -0.03736551f, 0.05214917f, -0.13107303f, -0.07353790f, -0.04211772f, -0.19077854f, -0.08199216f, 0.06952443f, 
    0.10414408f, 0.02977330f, -0.09851602f, 0.09438233f, -0.00528381f, -0.03687643f, -0.04116923f, -0.02463634f, 
    -0.00264217f, 0.09675024f, -0.04944955f, 0.02134467f, 0.01033905f, 0.12246452f, -0.00817159f, -0.03499609f, 
    -0.05154977f, -0.08084551f, -0.14853843f, 0.07039180f, 0.02454810f, 0.05364923f, -0.10244320f, -0.11968624f, 
    -0.06887464f, -0.19747785f, -0.04706788f, -0.06695579f, -0.09946765f, -0.07311808f, 0.00707525f, -0.02148251f, 
    -0.13283208f, 0.00114209f, -0.08826111f, 0.16033860f, -0.09121290f, 0.13007669f, -0.08530642f, 0.06125667f, 
    -0.12137273f, 0.00137328f, -0.00297815f, 0.05211816f, 0.01371795f, 0.04531850f, 0.01073895f, 0.12724438f, 
    0.05071938f, 0.01838985f, 0.17919227f, 0.02298261f, 0.01494399f, 0.03974251f, -0.03302391f, 0.03368377f, 
    -0.17211911f, -0.00612511f, 0.04568551f, 0.11813767f, -0.08312999f, -0.04731984f, -0.03112379f, -0.01354782f, 
    0.11510297f, 0.03099439f, 0.02403522f, -0.06891610f, -0.16896440f, -0.00728990f, -0.11883513f, -0.15877333f, 
    -0.02674990f, -0.03412760f, 0.09170265f, -0.02811049f, 0.04038081f, -0.04213903f, 0.04094580f, 0.01553602f, 
    -0.04205139f, 0.03813318f, -0.03160404f, 0.04849533f, -0.07591680f, -0.06185171f, 0.08785698f, 0.03262193f, 
    -0.05270141f, 0.06451788f, -0.06386916f, -0.06133894f, 0.31145245f, 0.23466326f, -0.08388434f, -0.03341692f, 
    -0.15156762f, -0.17767932f, 0.06003189f, -0.10222264f, -0.03227956f, -0.12702264f, 0.01941019f, -0.01704291f, 
    -0.04511500f, -0.17879726f, 0.08545820f, -0.00567789f, -0.07690308f, -0.02247325f, -0.04703270f, 0.00035058f, 
    0.03830836f, -0.05553892f, 0.04992750f, 0.05486230f, -0.30414373f, -0.11760198f, 0.08810149f, -0.00771986f, 
    -0.02750028f, 0.06121311f, -0.00679955f, 0.01221388f, 0.07553540f, 0.06328510f, -0.06112660f, 0.01456499f, 
    0.16222042f, 0.06892242f, 0.01504115f, 0.01246356f, -0.03718704f, -0.10475699f, 0.04903194f, 0.03711616f, 
    0.17006817f, 0.00458565f, 0.00723818f, -0.09891896f, 0.15766470f, -0.00747082f, -0.07663906f, -0.17945118f, 
    0.05465183f, 0.00701337f, 0.05225857f, 0.12860225f, 0.14170393f, -0.08328582f, -0.10132377f, 0.04229812f, 
    0.01929046f, -0.15183470f, -0.16704112f, 0.11913311f, -0.08138151f, -0.00753339f, -0.00309238f, 0.04207666f, 
    -0.03482581f, -0.04150458f, -0.02972014f, 0.04318530f, 0.06610615f, -0.05940366f, -0.05331960f, 0.08383047f, 
    -0.08529217f, -0.05633661f, 0.10257789f, 0.12757236f, 0.00958216f, 0.11828275f, -0.01462536f, -0.16578032f, 
    0.10413473f, 0.12551335f, 0.18014711f, -0.08799560f, 0.00262850f, 0.00666366f, -0.05385754f, -0.09832779f, 
    0.01243747f, 0.05502617f, 0.02810859f, -0.06977356f, 0.01107324f, -0.20014775f, -0.00895095f, 0.06675415f, 
    -0.15267833f, -0.01663750f, 0.17371818f, -0.03876760f, -0.04350276f, 0.08248409f, 0.05477988f, 0.00995295f, 
    0.11371455f, 0.25368798f, -0.20165566f, -0.09506914f, 0.12212227f, -0.04122527f, 0.02384103f, -0.13657050f, 
    0.02425977f, -0.02454798f, 0.03372792f, 0.00956020f, -0.32855245f, -0.07008578f, 0.18755569f, 0.08148829f, 
    -0.01273548f, -0.02126861f, -0.04258420f, -0.02723886f, 0.07699426f, 0.05107863f, 0.05725639f, 0.00155018f, 
    0.05636568f, 0.06389750f, -0.03945857f, -0.01838202f, 0.03708291f, -0.05774900f, 0.04238748f, -0.03930935f, 
    -0.01499457f, -0.03044012f, -0.04539356f, -0.02989723f, 0.09347510f, -0.20551783f, -0.05348658f, 0.05637167f, 
    -0.02195371f, -0.02728795f, 0.03475123f, -0.05318430f, 0.03325314f, -0.00906266f, -0.10116412f, -0.05482726f, 
    0.10569112f, -0.08722992f, -0.00158234f, 0.30038708f, 0.05214920f, -0.02490642f, 0.00014313f, 0.10593528f, 
    -0.03096413f, 0.07673137f, 0.02506862f, 0.01426938f, -0.07532460f, -0.24036138f, 0.06181537f, -0.12711678f, 
    -0.00615059f, 0.03276552f, -0.00760281f, -0.06699660f, -0.02755343f, -0.02459381f, -0.07995366f, -0.03575324f, 
    0.12412371f, 0.32110074f, -0.04208200f, -0.03570041f, -0.11930505f, 0.00274751f, -0.00114595f, 0.09563499f, 
    0.00122110f, 0.02647300f, -0.02053517f, 0.10402937f, 0.00619303f, -0.13795261f, 0.05305732f, -0.07479861f, 
    -0.04740483f, -0.01439206f, 0.05910921f, -0.07727641f, 0.06647743f, 0.04161695f, -0.07921982f, 0.08547749f, 
    0.08932857f, 0.20614660f, -0.13891576f, -0.01869706f, 0.00413825f, -0.01468858f, 0.13733277f, 0.06992170f, 
    -0.06536364f, 0.08711976f, 0.03479169f, 0.02584227f, -0.39325243f, 0.14451735f, 0.19786902f, 0.20482719f, 
    -0.10827971f, 0.12774904f, 0.09345563f, -0.05439481f, -0.05102449f, 0.09378789f, 0.08254799f, 0.03733707f, 
    0.13127647f, -0.05621207f, 0.11272717f, 0.15226568f, 0.09230416f, 0.02116567f, 0.00890868f, 0.06117381f, 
    0.09059641f, 0.08385797f, -0.03405099f, 0.00305340f, 0.29771248f, 0.29828387f, -0.41866797f, -0.22945888f, 
    0.05496648f, -0.03341043f, 0.13328910f, 0.01900060f, 0.01756387f, 0.01352373f, 0.08057310f, 0.01314224f, 
    0.04082332f, -0.14567640f, 0.12306289f, 0.23640589f, 0.00161708f, 0.02281410f, -0.01332083f, 0.11568242f, 
    -0.01898015f, -0.01912831f, -0.01774083f, 0.03119826f, -0.03864389f, 0.24047083f, -0.02818513f, -0.09797452f, 
    -0.14889771f, 0.03212932f, -0.03409589f, -0.06443235f, 0.06321633f, -0.00796958f, -0.01135860f, 0.10135061f, 
    -0.12041841f, 0.07110617f, 0.23393275f, 0.06856181f, -0.04240546f, 0.00727974f, -0.01367975f, -0.04687732f, 
    0.03327055f, -0.03051434f, -0.05249062f, 0.03388978f, -0.22755146f, 0.19698440f, 0.04962116f, 0.11854976f, 
    0.06256466f, -0.13944909f, -0.01605709f, 0.11374803f, -0.05977477f, -0.00172079f, 0.03289291f, -0.00124231f, 
    0.23722465f, 0.34816724f, -0.13920748f, -0.13519628f, 0.03247372f, 0.10398587f, 0.03251798f, 0.12765495f, 
    -0.03207751f, 0.00909194f, 0.04581813f, 0.11287150f, -0.77798837f, 0.28522813f, 0.00662007f, -0.09162688f, 
    0.03497900f, -0.07097122f, -0.10407686f, 0.07369906f, -0.09778501f, -0.11470708f, -0.00224134f, 0.07826063f, 
    -0.21246536f, 0.31354970f, 0.13138451f, -0.23940821f, -0.08186442f, 0.00014052f, -0.06241554f, -0.03916080f, 
    -0.04588522f, -0.00077172f, 0.07023986f, 0.05745266f, 0.03441399f, -0.16392075f, 0.04552162f, -0.25133696f, 
    -0.06721086f, -0.01085931f, 0.04012896f, 0.05533872f, -0.11987600f, -0.08253957f, -0.09313520f, -0.08843303f, 
    -0.28571564f, 0.10455867f, 0.17596690f, -0.01196001f, 0.00559794f, -0.05431188f, -0.02015316f, 0.04013653f, 
    0.03396003f, -0.12036211f, -0.02999334f, -0.08299289f, 0.01009400f, -0.02112202f, 0.12381152f, 0.09921941f, 
    0.05653707f, -0.07846548f, 0.00744802f, 0.03723717f, 0.15062530f, -0.12135629f, 0.03888165f, 0.13685311f, 
    -0.02068193f, 0.05322696f, 0.12035365f, 0.17756175f, 0.07416740f, 0.00838413f, 0.03905873f, -0.01827589f, 
    -0.03700899f, 0.01423132f, 0.01575377f, 0.07964408f, -0.19406816f, -0.05921868f, -0.01018389f, -0.04685728f, 
    0.09875657f, 0.03300586f, 0.08938522f, 0.08477876f, 0.01352919f, 0.03651704f, 0.00192950f, 0.05669430f, 
    -0.16248041f, 0.04247562f, -0.05717245f, -0.03082495f, 0.03560797f, -0.01675090f, -0.01456632f, -0.00374017f, 
    0.01959723f, 0.13009961f, -0.03225166f, 0.02449573f, -0.24893683f, 0.13891305f, -0.16459717f, -0.16472937f, 
    0.15562253f, -0.04774543f, -0.02305685f, 0.09321538f, 0.04907582f, -0.08756156f, -0.01744258f, 0.00131384f, 
    -0.16166151f, -0.03594273f, 0.10515434f, 0.19524544f, 0.14403583f, -0.05800360f, -0.02556953f, -0.14653896f, 
    -0.10419194f, 0.07847264f, 0.22512658f, 0.05700919f, -0.23934144f, -0.13644637f, -0.28800309f, -0.05047457f, 
    0.09046536f, 0.07651918f, -0.05905942f, 0.02348489f, 0.02501526f, 0.09720529f, 0.02617398f, 0.00072619f, 
    -0.04486710f, 0.09382535f, 0.10866616f, 0.22276381f, -0.04323460f, -0.06765635f, -0.02543989f, -0.22834292f, 
    -0.09818226f, -0.05129659f, -0.13531487f, 0.00430430f, -0.11849742f, -0.03273170f, -0.14751939f, -0.40975341f, 
    0.08995527f, -0.00034098f, -0.05303501f, 0.07678200f, 0.07904528f, 0.01042217f, -0.10374712f, 0.06745504f, 
    0.06710953f, -0.05980419f, 0.01570472f, 0.06104726f, -0.02795920f, -0.13581395f, 0.07231419f, -0.00993464f, 
    -0.12709965f, -0.02880919f, 0.07071792f, 0.19294935f, -0.15311934f, -0.00944840f, 0.20616186f, -0.09028983f, 
    -0.02700569f, -0.05566518f, 0.02920207f, -0.00254298f, 0.09251095f, 0.00735254f, 0.16006801f, -0.02400164f, 
    0.12963030f, 0.04107805f, -0.06571537f, -0.21153919f, 0.11683714f, -0.03307937f, 0.04867085f, 0.00650970f, 
    0.04255047f, -0.06533623f, 0.01290735f, 0.05192649f, -0.38913462f, -0.10762942f, 0.03525636f, 0.23983374f, 
    0.02890946f, -0.12099842f, -0.09888811f, 0.08870269f, 0.06466314f, 0.00569638f, -0.01230079f, 0.07484880f, 
    -0.45253310f, -0.05745137f, -0.08241948f, 0.00913474f, 0.06760170f, 0.13928717f, 0.05768461f, 0.06392555f, 
    -0.03497450f, 0.00907274f, -0.13161431f, 0.02459623f, -0.14458938f, 0.06034982f, -0.00647515f, 0.23675771f, 
    -0.08986717f, -0.10312151f, 0.02143899f, 0.03229810f, 0.03175254f, -0.17344511f, 0.03792978f, 0.16681942f, 
    -0.04878858f, 0.17717229f, 0.21527757f, 0.02722345f, 0.06529151f, 0.02077985f, -0.00938923f, -0.13309208f, 
    -0.21097931f, 0.06333879f, -0.00150543f, 0.09855895f, -0.52075469f, 0.03778754f, -0.03426848f, -0.32418200f, 
    0.18690951f, -0.06116631f, -0.01985939f, 0.03844257f, 0.00357720f, 0.00416362f, 0.01074931f, -0.11999116f, 
    0.19973207f, 0.18648888f, -0.08356745f, -0.14883696f, -0.03197733f, 0.01545714f, -0.02946313f, -0.02997593f, 
    -0.08073027f, -0.08888424f, 0.19281049f, -0.05021889f, -0.00053661f, -0.07288511f, 0.04460741f, -0.13352786f, 
    -0.08540929f, -0.07688948f, -0.08519260f, -0.06451935f, 0.00040893f, 0.16127436f, 0.15263432f, 0.04863509f, 
    0.09699435f, 0.11048430f, -0.07228242f, -0.08193998f, 0.05346393f, 0.06180491f, -0.06699852f, -0.04956186f, 
    0.06068934f, -0.10970445f, 0.12951757f, 0.02827047f, -0.28891096f, 0.18802610f, -0.01833767f, -0.18541482f, 
    0.04593974f, -0.06483158f, 0.03407487f, -0.23522682f, 0.13421489f, 0.00415760f, -0.18217489f, -0.03492402f, 
    0.06611744f, 0.12932424f, 0.09011916f, 0.06618207f, -0.10387374f, -0.05862730f, -0.02072213f, 0.01873513f, 
    -0.09071621f, 0.08910397f, 0.01622661f, 0.07554854f, -0.18302408f, -0.12787762f, 0.02013279f, 0.04363685f, 
    0.03956518f, -0.13204543f, 0.12141239f, 0.04773647f, -0.15337718f, 0.07251337f, -0.14362642f, 0.24750902f, 
    -0.07668363f, 0.37090603f, -0.11943422f, -0.19006614f, 0.06121888f, 0.08558248f, 0.05717343f, -0.13370819f, 
    0.02059673f, -0.01892306f, -0.13894919f, -0.10452881f, 0.19553320f, 0.10069067f, -0.02412321f, 0.01198787f, 
    -0.09040619f, 0.02278974f, -0.06206331f, 0.01862602f, -0.09793898f, -0.10691141f, 0.09871525f, -0.03975204f, 
    -0.16450921f, 0.10286516f, -0.12209804f, -0.22973508f, -0.00910361f, -0.01997151f, -0.02933179f, 0.10449894f, 
    0.05100193f, -0.09002487f, 0.09379714f, 0.02647428f, -0.17831524f, 0.00280964f, -0.17651181f, 0.06597958f, 
    0.10686897f, 0.20096691f, 0.09994313f, -0.01597108f, 0.00436890f, 0.03018650f, -0.09083771f, -0.01302998f, 
    -0.05714222f, -0.02264091f, 0.06293616f, -0.11373615f, -0.05453379f, -0.07168501f, 0.16925648f, 0.11668199f, 
    -0.07911745f, 0.17753181f, -0.00002723f, -0.02948571f, -0.21725658f, 0.01221487f, -0.06243878f, -0.33228645f, 
    -0.07357903f, 0.08136132f, -0.15892039f, 0.09630471f, -0.05117214f, -0.00587416f, -0.01142322f, -0.23178062f, 
    -0.06478213f, -0.00036914f, 0.12006525f, 0.06050353f, -0.01830354f, -0.06877080f, 0.04086981f, -0.03747450f, 
    0.06874336f, -0.08939710f, -0.08850655f, -0.15527585f, -0.19446436f, -0.00117361f, -0.10777978f, -0.00434359f, 
    0.05235008f, 0.09778136f, -0.02807380f, 0.00815186f, 0.07153971f, -0.10921032f, 0.16013765f, -0.04270916f, 
    0.10685261f, 0.02803964f, 0.00434206f, -0.08721001f, 0.00291363f, 0.05914512f, -0.05309647f, 0.05409841f, 
    -0.08605815f, -0.04216531f, 0.07947583f, 0.06386029f, -0.14053538f, 0.07647734f, 0.17983475f, -0.21172658f, 
    0.11643464f, 0.01979895f, 0.01211018f, 0.08799225f, 0.07043374f, 0.11195619f, 0.11372506f, 0.03815317f, 
    0.00460837f, -0.05758147f, 0.19162692f, -0.12985936f, -0.06441440f, -0.02195249f, -0.04062790f, -0.13294455f, 
    -0.04497823f, 0.01102945f, 0.04843548f, 0.11648516f, 0.03030862f, -0.13014333f, 0.14736731f, 0.22567610f, 
    0.01737662f, 0.02451367f, -0.01566234f, 0.00038629f, 0.10535127f, 0.13257881f, 0.04949095f, -0.01153172f, 
    -0.00651490f, -0.00704776f, -0.02681221f, 0.02128904f, 0.09578524f, 0.04453405f, -0.10333539f, -0.09554587f, 
    -0.03692448f, -0.02449979f, -0.07561532f, -0.05639538f, 0.06239466f, 0.03117898f, 0.10017686f, -0.05865357f, 
    0.03185297f, 0.02794018f, -0.02094010f, 0.00279113f, -0.08175915f, -0.04492400f, 0.14673007f, 0.14893988f, 
    0.03531310f, 0.05009393f, 0.14650330f, -0.03751495f, -0.07718220f, 0.08347493f, -0.06976320f, -0.01373188f, 
    -0.00356881f, 0.08764671f, 0.08553865f, 0.04066182f, -0.09059566f, -0.21934764f, -0.01858946f, 0.04532176f, 
    -0.01941308f, 0.00213470f, -0.12194145f, 0.09223495f, 0.16388074f, -0.00397903f, 0.10665952f, 0.01794212f, 
    0.02418280f, -0.12930217f, 0.11243841f, -0.03736931f, 0.01607026f, -0.22113965f, -0.03415535f, -0.05634987f, 
    0.10582402f, -0.00160134f, 0.02403503f, 0.00302982f, 0.00338892f, 0.12839743f, 0.18423116f, -0.12005602f, 
    0.05628037f, 0.07515635f, -0.05084873f, -0.00617410f, 0.05127786f, -0.09895304f, 0.11323839f, 0.18585572f, 
    -0.09710381f, 0.02254755f, -0.04036373f, 0.16944608f, -0.02996962f, 0.01425076f, -0.02371245f, 0.08781230f, 
    0.00650983f, -0.06905485f, -0.04361359f, -0.00100483f, 0.17267692f, -0.00573006f, 0.06226354f, -0.02417766f, 
    0.01606831f, -0.13137752f, -0.14111951f, 0.11408950f, 0.06540133f, 0.00043414f, 0.02635203f, -0.19978327f, 
    -0.24136598f, -0.31535292f, 0.11731987f, 0.31613892f, 0.06584389f, -0.14426190f, 0.06425732f, 0.03452177f, 
    0.03995617f, 0.13517140f, -0.15424320f, -0.03171688f, 0.05664809f, -0.03479810f, 0.13847812f, -0.09573350f, 
    -0.00352990f, -0.11751408f, 0.06094581f, -0.02477643f, -0.11501552f, -0.15629168f, -0.02396603f, -0.13567208f, 
    0.06736834f, -0.05183178f, 0.18379359f, 0.00862473f, -0.02465406f, 0.00438804f, 0.04085920f, 0.03556967f, 
    -0.07872257f, -0.12558462f, -0.04392998f, -0.00331300f, 0.16317567f, 0.09323885f, 0.03508209f, 0.00177744f, 
    0.07456256f, -0.02744743f, -0.01532536f, 0.08413812f, -0.00229769f, 0.08984755f, 0.07507704f, 0.07801577f, 
    0.15511957f, -0.04897714f, -0.11365896f, -0.01966673f, 0.06308193f, 0.10526410f, -0.12961750f, -0.03243777f, 
    0.04791335f, -0.10867476f, -0.00628566f, -0.03664180f, -0.02711399f, 0.01817325f, -0.01794985f, 0.12373803f, 
    0.05912072f, -0.10411445f, 0.01386439f, 0.06955900f, -0.00354390f, 0.09648211f, -0.08419774f, -0.10794669f, 
    -0.03484634f, -0.20246130f, 0.18416648f, 0.05052600f, 0.06773986f, -0.03051667f, 0.02601902f, 0.05204589f, 
    0.05508478f, 0.04946455f, -0.08353376f, -0.10602407f, 0.18138467f, 0.13389936f, 0.11809558f, 0.03438676f, 
    0.02079980f, -0.02061659f, -0.02037028f, 0.08082984f, -0.09027510f, -0.09805550f, 0.01651600f, -0.09764320f, 
    0.05078965f, -0.05699265f, 0.33761436f, 0.12084894f, 0.03694092f, -0.03729581f, -0.00624139f, -0.28855082f, 
    -0.01852052f, -0.12119634f, 0.11732662f, -0.17295814f, -0.13634874f, -0.10712539f, -0.22698954f, 0.01668281f, 
    0.06448094f, -0.06560121f, -0.03756823f, -0.11229807f, 0.10722464f, 0.06849393f, -0.02042185f, 0.08384223f, 
    -0.11421857f, -0.06138846f, -0.07296742f, 0.19687478f, 0.16121709f, 0.07056572f, 0.00474080f, 0.02364985f, 
    0.07208183f, -0.07888793f, 0.11943497f, 0.03270228f, -0.34881014f, -0.05234464f, 0.21191494f, 0.10486843f, 
    0.11112475f, -0.06838800f, -0.03925565f, -0.19897436f, -0.04309967f, -0.05335494f, -0.19260208f, -0.01796608f, 
    -0.03503103f, -0.08023357f, -0.20966780f, -0.03122525f, 0.12250424f, 0.13985203f, -0.04661583f, -0.12488700f, 
    0.01520501f, -0.12750860f, -0.06197720f, 0.15033524f, -0.18513706f, 0.06089345f, 0.12623724f, -0.15582928f, 
    0.04639840f, 0.07524969f, 0.07932801f, -0.07575862f, 0.06818972f, -0.02084475f, 0.12298287f, -0.02137901f, 
    0.09186769f, -0.07765858f, -0.14902620f, -0.04250329f, 0.02937510f, -0.03378740f, 0.08336303f, 0.01970854f, 
    -0.00242077f, -0.02425051f, 0.14352505f, 0.17841130f, -0.27546909f, -0.10159310f, -0.07835410f, 0.02617490f, 
    0.06031414f, -0.10612679f, -0.00494403f, -0.10149918f, 0.04182697f, 0.02777901f, -0.25171742f, -0.01880939f, 
    -0.05550958f, -0.07811262f, 0.32648852f, 0.30757278f, 0.01284708f, -0.06038854f, 0.10606767f, -0.01693739f, 
    -0.01287226f, -0.00381270f, -0.14429303f, -0.02835878f, -0.38022301f, 0.11645176f, -0.11939856f, -0.10313919f, 
    0.02107079f, 0.01600329f, -0.03326516f, 0.10823887f, -0.06851231f, 0.07106263f, 0.14107606f, -0.21306635f, 
    -0.09312138f, -0.12376901f, 0.13214819f, 0.14985253f, 0.01870743f, 0.10041826f, -0.01332511f, 0.01784628f, 
    -0.07724880f, 0.02714192f, 0.08901807f, 0.11322193f, 0.04347181f, -0.15937616f, -0.09416056f, -0.02295120f, 
    0.13208048f, -0.07601403f, 0.20654903f, 0.02356447f, 0.02086515f, 0.11572239f, -0.08152708f, 0.09137065f, 
    0.05634395f, -0.00646335f, 0.06971347f, 0.11890577f, -0.08013317f, 0.08545298f, 0.13241838f, -0.03923373f, 
    -0.04425717f, 0.07654282f, 0.00005429f, 0.13591255f, 0.03504257f, 0.06284962f, -0.03829554f, -0.01615457f, 
    0.12281190f, 0.13891307f, -0.14935422f, 0.08495376f, 0.04477056f, -0.06633241f, 0.20827466f, -0.14826843f, 
    -0.13360460f, -0.30087420f, -0.19970663f, -0.17078388f, -0.10219568f, 0.05409251f, -0.03599675f, -0.10247038f, 
    0.12349199f, -0.07578775f, -0.01261878f, -0.04224088f, -0.32199469f, -0.20559201f, 0.07607532f, 0.08637600f, 
    0.09860749f, 0.02178419f, -0.07919669f, 0.02782002f, 0.06699437f, -0.17926389f, 0.02370916f, 0.00936787f, 
    -0.07107512f, 0.18488400f, 0.15278496f, -0.00395298f, -0.02160987f, 0.13227206f, -0.04864017f, -0.06138818f, 
    -0.06328987f, -0.21686751f, -0.08812664f, -0.10767727f, -0.42931333f, -0.17038263f, -0.00495315f, -0.03651289f, 
    0.01750942f, 0.02852836f, 0.09837306f, -0.02766128f, -0.04610102f, -0.12529118f, 0.08000484f, -0.02228830f, 
    0.13131468f, -0.16720651f, -0.08255037f, 0.17626540f, -0.02190360f, 0.03498288f, -0.10644813f, 0.08671138f, 
    -0.03022282f, -0.15104567f, -0.02286571f, -0.00748993f, -0.00626676f, -0.09280226f, -0.06279880f, -0.19692558f, 
    -0.03793973f, 0.07071821f, 0.04922199f, -0.17543775f, -0.03600781f, -0.10848039f, 0.09090414f, 0.12464086f, 
    -0.13755700f, -0.01808427f, 0.01992477f, 0.02451107f, -0.07689144f, 0.07213888f, 0.17559659f, 0.08484421f, 
    -0.01628300f, -0.01905162f, 0.02443653f, 0.10040677f, -0.06267285f, 0.15824369f, 0.11061497f, -0.13427274f, 
    -0.10741072f, -0.01070551f, -0.01390229f, -0.02492324f, -0.01496171f, 0.00233989f, 0.01806635f, 0.07463381f, 
    0.07114162f, 0.15663750f, 0.03638704f, -0.34116879f, 0.06297977f, 0.09330646f, -0.08374267f, -0.00233847f, 
    0.03538974f, -0.03394690f, 0.05534574f, -0.03541667f, 0.37309024f, -0.06730402f, 0.14533639f, 0.06565383f, 
    0.00324315f, -0.06481437f, -0.12372827f, -0.10925194f, -0.05587215f, 0.01002319f, 0.02847192f, 0.09284775f, 
    -0.07171589f, 0.03274475f, 0.04635184f, 0.04209322f, -0.01908177f, 0.01528976f, 0.11606216f, 0.09761100f, 
    0.02797538f, 0.07644920f, 0.05057700f, -0.01326508f, 0.08641093f, -0.03740633f, -0.23743722f, 0.20275304f, 
    -0.02215445f, 0.07473088f, 0.01332845f, -0.03578442f, -0.14563930f, 0.04355222f, 0.08353367f, 0.04712820f, 
    -0.29096290f, -0.06064228f, -0.07288014f, -0.43384778f, -0.09285372f, -0.02557190f, 0.01131586f, -0.13913824f, 
    -0.09547848f, 0.07445981f, 0.04930461f, -0.05710623f, -0.24519822f, -0.17296191f, -0.19205195f, 0.07716488f, 
    0.03019621f, 0.08561822f, 0.05020699f, -0.09428611f, -0.10828488f, -0.17505579f, -0.18421936f, -0.10146724f, 
    -0.05172823f, 0.01011057f, 0.15331703f, -0.08657970f, -0.25329605f, 0.00705383f, 0.01140479f, 0.00813136f, 
    0.17624724f, 0.00406003f, -0.09758797f, -0.20550023f, -0.03872634f, -0.18763691f, 0.03733219f, 0.01091286f, 
    -0.02885844f, -0.04510475f, 0.10177156f, 0.15550669f, 0.03772224f, 0.05850212f, -0.00264996f, 0.11157044f, 
    -0.28451025f, 0.20453539f, 0.16228926f, 0.26092273f, 0.09742969f, 0.08544386f, -0.07537510f, -0.03026280f, 
    0.10179219f, 0.05384259f, -0.00120199f, -0.07108845f, 0.03878284f, 0.22098778f, 0.13625827f, -0.27879879f, 
    -0.01522367f, 0.09639917f, 0.07954974f, 0.01546168f, -0.05754621f, -0.00463069f, -0.08768708f, -0.04093822f, 
    -0.00478499f, -0.05826275f, -0.09005110f, -0.30843723f, -0.05215255f, -0.08705316f, 0.09702776f, 0.01945171f, 
    0.18052530f, -0.01905349f, -0.18198669f, -0.02111565f, -0.12780777f, -0.14023201f, 0.17416802f, -0.08391658f, 
    0.00618098f, 0.03645721f, -0.00949065f, 0.12420976f, 0.01872470f, -0.07553057f, 0.02381762f, -0.01494917f, 
    0.24668661f, -0.00450537f, 0.15951046f, -0.07275646f, 0.07105236f, -0.09554570f, 0.13125135f, 0.05029027f, 
    0.12564023f, -0.02236931f, -0.03218621f, -0.25912023f, 0.02457338f, 0.07284623f, 0.03982911f, 0.03469168f, 
    -0.18004841f, 0.13425797f, -0.06061244f, 0.02016030f, 0.03797191f, -0.05685300f, -0.00012633f, 0.08309197f, 
    0.04541793f, -0.49988014f, -0.00342085f, -0.18051647f, -0.01008251f, 0.06531865f, -0.02568067f, 0.05607902f, 
    -0.02009824f, 0.07539696f, 0.07043230f, 0.16522296f, 0.04670430f, -0.05761444f, 0.13143688f, -0.22973455f, 
    0.06146765f, 0.03906436f, 0.04318412f, 0.00161346f, 0.15374945f, 0.03837661f, -0.03439420f, 0.08141952f, 
    0.45073089f, -0.09529892f, 0.14066134f, -0.09804129f, -0.04464898f, -0.03434134f, 0.00814000f, 0.02630117f, 
    0.02507159f, 0.07475339f, -0.18114801f, -0.04766782f, 0.01240916f, 0.09408297f, 0.04507914f, -0.23367600f, 
    -0.21652269f, -0.00359027f, -0.01888927f, -0.01807700f, -0.05412007f, -0.03313725f, -0.01249804f, 0.03628678f, 
    0.23428801f, 0.05573005f, -0.02891070f, -0.05547827f, 0.00988582f, 0.02889857f, 0.00425637f, -0.05381332f, 
    -0.05512845f, 0.02169349f, 0.01954481f, 0.05617489f, 0.18301295f, -0.15641497f, 0.18137383f, -0.09651995f, 
    0.02864570f, -0.03171914f, 0.11787247f, 0.01876930f, 0.07325155f, -0.04770949f, 0.04139306f, 0.02511343f, 
    -0.04587745f, 0.13134684f, 0.03266796f, 0.09207261f, -0.08435075f, -0.03230793f, 0.01371056f, 0.06360742f, 
    -0.05306381f, 0.11296713f, 0.12530188f, 0.19308123f, 0.19946717f, -0.05697307f, -0.12061808f, 0.17642421f, 
    -0.15196392f, 0.08275516f, -0.11300415f, -0.02612372f, -0.10130204f, 0.01427767f, -0.12005254f, 0.05650725f, 
    -0.11601830f, 0.14682122f, 0.19087617f, 0.03512028f, 0.05851053f, -0.14565440f, -0.04781800f, -0.05450367f, 
    0.03543812f, -0.06500012f, -0.06630021f, 0.04555959f, -0.07416364f, -0.27691466f, -0.12452401f, 0.07593925f, 
    0.02983965f, 0.11089984f, -0.04103929f, 0.13025150f, -0.01152463f, -0.11736389f, -0.15080713f, -0.05293989f, 
    -0.32236460f, -0.09108593f, 0.03420036f, 0.15366380f, -0.07890913f, 0.05568268f, 0.10602294f, 0.06257377f, 
    0.01429279f, -0.07535859f, -0.02733853f, -0.07808762f, -0.02202645f, -0.15453449f, -0.07667959f, 0.07609504f, 
    0.01968492f, -0.00661198f, -0.01319153f, -0.10317897f, -0.14882971f, -0.06972396f, -0.11120155f, -0.06301879f, 
    -0.35013226f, 0.20285995f, -0.02540442f, 0.12329634f, 0.09017058f, 0.12796295f, -0.02182228f, -0.01512282f, 
    -0.00804023f, 0.11528517f, 0.01831890f, 0.05604782f, 0.10849874f, 0.04551757f, 0.10720326f, -0.00699118f, 
    -0.02052427f, -0.01724227f, 0.01298562f, -0.00727568f, 0.04313697f, -0.13142839f, -0.04137800f, -0.16245079f, 
    -0.02304716f, 0.11211059f, 0.12623858f, -0.27486485f, 0.03011891f, 0.06896152f, 0.04973459f, 0.06980398f, 
    -0.02003486f, -0.10283826f, -0.05729548f, -0.00727031f, 0.23571242f, -0.10614105f, 0.17025836f, -0.04185940f, 
    -0.01964099f, -0.02130200f, 0.02476193f, 0.00337127f, -0.05754777f, 0.13667357f, -0.05551001f, -0.07330055f, 
    -0.01811701f, 0.09267579f, -0.00296208f, 0.08286778f, 0.00886066f, 0.16221976f, 0.02410248f, 0.07790878f, 
    -0.09350073f, -0.03614976f, -0.01421204f, -0.04029452f, 0.00106859f, 0.06938776f, 0.16825403f, -0.16513912f, 
    0.02275956f, -0.08142386f, 0.01401543f, 0.02999546f, -0.01833678f, 0.05557306f, -0.05950673f, -0.11461062f, 
    -0.09368879f, -0.09925397f, 0.01299525f, -0.26662511f, 0.13933414f, 0.03209350f, 0.10056312f, -0.01581828f, 
    -0.08811267f, 0.18941993f, 0.11720092f, -0.09880570f, -0.21337165f, -0.15108496f, -0.19828773f, 0.18506952f, 
    -0.01036554f, 0.08096016f, 0.14816867f, -0.03822826f, 0.01945712f, -0.05019032f, -0.05540463f, 0.01911074f, 
    -0.07492196f, -0.13687083f, -0.13785733f, 0.13649705f, -0.06590638f, -0.06360447f, -0.02663517f, 0.02908773f, 
    -0.13452658f, -0.16776568f, 0.01424201f, -0.00227747f, 0.23665529f, 0.06055763f, -0.05509404f, -0.14934014f, 
    0.03564413f, 0.05454961f, 0.03464379f, 0.02398325f, -0.02235928f, -0.03506164f, 0.03603816f, 0.15950036f, 
    0.10677867f, 0.08944987f, -0.01199896f, -0.01217671f, -0.15663317f, -0.09507834f, -0.02445692f, -0.02376753f, 
    0.14085340f, 0.03414939f, 0.02405173f, -0.05845333f, -0.01611655f, 0.17984957f, 0.12528896f, -0.20030917f, 
    0.01838910f, 0.18586037f, -0.04548299f, -0.02463469f, -0.02441239f, -0.02263255f, 0.09387473f, -0.08233958f, 
    -0.36821401f, 0.00085001f, -0.12345766f, 0.10681125f, -0.12072133f, -0.15254478f, 0.10779810f, -0.05773903f, 
    0.03207010f, 0.04920960f, 0.06668408f, -0.08151327f, -0.12170870f, 0.06794816f, -0.28705645f, 0.19371644f, 
    0.12957528f, 0.02336541f, -0.04593308f, -0.02898319f, 0.04928300f, -0.04694331f, 0.02283559f, -0.11998281f, 
    0.00381298f, 0.03916152f, -0.08202368f, -0.08746825f, 0.04704577f, 0.07110007f, 0.01730985f, 0.00153643f, 
    -0.03991737f, 0.00155402f, 0.06509659f, 0.13911383f, -0.02132653f, 0.06691224f, 0.16920811f, -0.02913618f, 
    0.04357028f, -0.13034956f, 0.04577013f, 0.03279784f, 0.04797297f, 0.14324887f, 0.06065306f, 0.05869640f, 
    -0.00775464f, -0.16250297f, -0.06594822f, 0.02229054f, -0.07905965f, 0.02195827f, -0.07362734f, 0.03456750f, 
    -0.02775470f, 0.06664602f, -0.19475472f, 0.13881467f, -0.14606218f, -0.34734291f, -0.24923226f, 0.04693855f, 
    -0.01503552f, 0.01191979f, -0.02190682f, 0.01285823f, -0.04391129f, -0.00112444f, 0.00956043f, 0.03991938f, 
    -0.07935101f, -0.06386346f, -0.18560179f, -0.00332346f, -0.05082547f, -0.04203559f, 0.00630081f, -0.23220369f, 
    -0.02187134f, 0.05739497f, -0.06460112f, 0.08589435f, 0.27791581f, -0.44377720f, -0.12440898f, 0.20620547f, 
    -0.09906681f, 0.06286242f, -0.07284303f, 0.10372103f, 0.11971973f, 0.06692055f, -0.00540048f, 0.06296356f, 
    -0.12542564f, -0.11520275f, -0.18772924f, -0.09414305f, -0.01721052f, 0.02900375f, -0.03894801f, -0.10389386f, 
    -0.01805267f, 0.07684702f, -0.00807996f, 0.08331478f, -0.01259525f, -0.14573570f, 0.02308981f, -0.04128297f, 
    -0.02395416f, 0.00272549f, 0.01000899f, 0.04255247f, 0.08225437f, 0.06612860f, 0.01262531f, -0.00763183f, 
    0.00808008f, -0.07432732f, -0.02827089f, 0.01479093f, 0.02096100f, 0.02908548f, -0.00291398f, -0.09796256f, 
    -0.07355517f, 0.01599637f, -0.12906769f, -0.09119458f, 0.15046340f, -0.00898392f, 0.00397995f, -0.02848119f, 
    -0.01731735f, 0.03357373f, 0.02209136f, -0.12702097f, -0.00983957f, -0.03980813f, 0.20207845f, -0.02752985f, 
    0.16909684f, -0.07306129f, -0.11817383f, -0.20927967f, 0.02022881f, 0.01211477f, 0.01312014f, 0.03917428f, 
    0.02907555f, 0.06603092f, 0.08753785f, 0.05132824f, 0.45443195f, -0.25411791f, 0.12984113f, -0.04872135f, 
    -0.02875360f, -0.01243677f, 0.13930540f, -0.30079609f, 0.03726421f, -0.00226209f, 0.14020169f, 0.07647736f, 
    0.22577831f, -0.09284312f, -0.07073084f, -0.00552278f, -0.01994922f, 0.05274709f, 0.02150424f, -0.00863459f, 
    0.06085933f, -0.05408900f, -0.13619511f, -0.05557707f, 0.13269746f, -0.21025981f, 0.08425207f, -0.06295840f, 
    -0.06771990f, 0.02325549f, 0.01517861f, -0.00778400f, 0.10933579f, -0.06288286f, 0.07223260f, -0.13830502f, 
    0.00947226f, 0.00604841f, -0.06582864f, -0.26732749f, -0.07110564f, -0.00072025f, -0.04232840f, 0.03653362f, 
    0.10433061f, -0.11112957f, -0.00063422f, -0.09102743f, 0.01826747f, 0.13721724f, 0.03672730f, 0.02149377f, 
    0.03125605f, -0.14572038f, 0.08530203f, -0.05006253f, 0.01756357f, 0.04787922f, -0.08408918f, -0.03133852f, 
    -0.26036003f, -0.07265190f, 0.05554305f, -0.08467794f, -0.00813389f, 0.07360353f, 0.00156851f, -0.09062472f, 
    0.02499531f, -0.12241288f, -0.02216973f, 0.18669745f, -0.05474650f, 0.05905007f, -0.12589629f, -0.21342081f, 
    -0.02828969f, 0.01691956f, -0.00247839f, 0.01111135f, 0.00055892f, 0.07457688f, 0.02856194f, -0.02616187f, 
    0.18930969f, -0.03769890f, -0.04857129f, 0.08722083f, -0.01103446f, -0.03425810f, -0.09344216f, 0.07503787f, 
    -0.09234845f, -0.02134186f, 0.07958792f, 0.05922452f, 0.08933527f, -0.17413963f, 0.01237791f, -0.04332044f, 
    -0.05992138f, 0.01010324f, 0.03213742f, -0.03293599f, 0.06254139f, 0.04360592f, -0.03177033f, 0.08360538f, 
    0.09219169f, 0.12768249f, -0.03699107f, 0.17513603f, -0.01711133f, -0.07594244f, -0.06699980f, 0.03496755f, 
    -0.01440726f, -0.01843216f, -0.01293371f, -0.02762356f, 0.03094127f, 0.17976463f, 0.17020838f, 0.11705191f, 
    0.06809974f, 0.04783890f, 0.01693715f, 0.03436090f, -0.01836855f, 0.01994719f, 0.01951178f, -0.02851097f, 
    0.18520506f, -0.03530658f, 0.04770830f, -0.13376895f, -0.09452529f, -0.03270728f, -0.00080344f, -0.06899828f, 
    0.00104721f, 0.00894427f, -0.05231272f, -0.00278308f, -0.30752602f, 0.02268714f, -0.25529248f, -0.06045290f, 
    -0.04797556f, -0.00165597f, -0.00885891f, -0.09426235f, -0.02038948f, -0.07449590f, 0.03634869f, -0.09916218f, 
    -0.16245691f, 0.10487901f, -0.05925509f, 0.00534570f, -0.05511355f, -0.02758365f, -0.06938701f, 0.00893835f, 
    -0.07531472f, 0.06915204f, -0.04480292f, -0.09611969f, -0.02744095f, -0.07088444f, -0.17783144f, -0.01018138f, 
    -0.08567797f, -0.03541144f, -0.00411710f, -0.04675025f, -0.06140775f, -0.01051679f, -0.13727675f, -0.06089491f, 
    0.21626167f, -0.00534692f, 0.04238891f, -0.16414507f, -0.05363126f, 0.05150783f, 0.02264781f, -0.03736557f, 
    -0.03276719f, -0.06629492f, 0.02430448f, 0.00240891f, 0.05351210f, 0.09131145f, -0.13552032f, 0.13978402f, 
    -0.02181530f, -0.05043192f, -0.00070580f, 0.04596839f, -0.05334445f, -0.02001299f, 0.00823609f, -0.03986289f, 
    0.07265284f, 0.01569320f, 0.14320143f, 0.05716472f, 0.04409236f, 0.06331018f, 0.01888929f, 0.01054228f, 
    -0.02558345f, 0.04526093f, 0.01758710f, -0.06261574f, 0.11628190f, 0.04406380f, 0.07974650f, 0.16994709f, 
    0.01297735f, -0.07251859f, -0.03630859f, -0.07984932f, -0.04143013f, 0.01081139f, -0.01257580f, -0.04288229f, 
    -0.15690050f, 0.03309654f, -0.04176850f, -0.08300807f, -0.00938515f, -0.01038001f, 0.04434578f, -0.06895599f, 
    -0.06996355f, -0.03098866f, -0.08927370f, -0.09143020f, 0.15163586f, -0.13033997f, 0.11330357f, -0.13640863f, 
    -0.01336830f, 0.03782555f, -0.00953123f, -0.04078329f, -0.00795455f, 0.07921214f, -0.06298294f, 0.01009430f, 
    -0.17077123f, 0.17281441f, 0.05428166f, -0.16315618f, -0.14992817f, -0.01337046f, -0.01984219f, -0.00820475f, 
    -0.02359804f, -0.03441294f, -0.00625817f, -0.08468989f, 0.05290008f, 0.12993327f, -0.11157870f, -0.00217098f, 
    -0.04314552f, 0.01924347f, 0.00771468f, -0.09663813f, -0.10111321f, -0.04387781f, -0.06156386f, -0.04129997f, 
    0.11858839f, -0.04036018f, 0.13599963f, 0.11813391f, 0.04242278f, -0.00825708f, 0.01141209f, -0.04520333f, 
    0.02810602f, 0.03885172f, -0.04395709f, -0.07900628f, -0.13610126f, 0.04171738f, -0.05885172f, -0.09317593f, 
    -0.10588454f, 0.04041294f, -0.06826141f, -0.02236047f, -0.09064569f, 0.03753991f, -0.11155589f, -0.06111711f, 
    0.10105084f, -0.27741793f, -0.06184708f, 0.12566251f, 0.00959420f, -0.09917972f, 0.00004119f, -0.02381912f, 
    -0.09121334f, -0.03566096f, -0.02886609f, -0.02304880f, -0.02181973f, -0.11986715f, -0.05079577f, 0.04472014f, 
    -0.03944992f, -0.01161877f, -0.04167573f, -0.01506063f, -0.01781189f, -0.04798264f, -0.00920346f, -0.05571368f, 
    -0.07110700f, 0.08563016f, 0.20621143f, -0.01897150f, -0.04795872f, -0.00266714f, -0.08154549f, 0.04988175f, 
    -0.02033527f, 0.10633315f, 0.05748254f, -0.01625873f, 0.28078145f, 0.03361735f, -0.14328700f, -0.05674168f, 
    0.03335742f, -0.00508858f, -0.00576782f, 0.00019215f, -0.04315683f, 0.01929189f, 0.03030494f, -0.10857008f, 
    0.27526689f, 0.04976142f, -0.00990885f, -0.12254912f, -0.10348852f, -0.02193166f, 0.03018099f, -0.06650890f, 
    -0.02052730f, 0.07217557f, -0.06682409f, -0.01274652f, 0.04016723f, 0.07614478f, 0.07395279f, 0.10488772f, 
    0.07520922f, 0.00952662f, 0.02076820f, 0.00998955f, -0.09159086f, 0.04605497f, -0.03334643f, -0.10295652f, 
    -0.05162648f, -0.04376562f, 0.01487530f, -0.06435459f, 0.03336519f, -0.03644608f, 0.02821579f, -0.04773964f, 
    -0.05821263f, -0.00532082f, 0.00929803f, -0.10045119f, 0.23539418f, 0.02723572f, 0.09514529f, -0.14108358f, 
    -0.11768412f, 0.03490271f, -0.01769602f, -0.04184530f, 0.01193883f, 0.03367762f, -0.01442431f, -0.03565978f, 
    -0.09560336f, -0.04620540f, -0.05436894f, -0.11305130f, 0.00731859f, -0.03275599f, -0.01936463f, -0.07013713f, 
    -0.04612345f, 0.02346682f, 0.05162461f, -0.08634932f, -0.12079266f, 0.15791002f, -0.01325572f, 0.17187673f, 
    0.05960792f, -0.09092265f, -0.01384775f, 0.02149206f, 0.03546006f, -0.02055042f, -0.00985498f, -0.00585203f, 
    -0.08856364f, -0.11967499f, -0.10824081f, -0.28928939f, 0.07112028f, -0.00238948f, -0.00787401f, -0.06268669f, 
    -0.00121748f, -0.00572764f, -0.01376011f, -0.04403504f, -0.15464891f, 0.08991743f, 0.03181265f, -0.07070102f, 
    -0.06359836f, 0.00123371f, -0.04099553f, -0.06384689f, -0.00813004f, -0.01165072f, 0.02952431f, -0.04342906f, 
    0.07882293f, -0.14615622f, 0.01707631f, 0.01964524f, -0.02744926f, -0.01274339f, 0.00907312f, -0.04199725f, 
    0.02155656f, -0.00967644f, -0.08077003f, 0.01443238f, 0.20099077f, -0.11906174f, 0.16179889f, 0.12895600f, 
    0.09466409f, -0.01306244f, -0.00455272f, -0.06004280f, 0.00814166f, -0.14000078f, -0.08772600f, -0.00493061f, 
    -0.28430974f, 0.02766199f, -0.07995826f, -0.02732364f, 0.02087522f, -0.04891377f, -0.11281767f, 0.02016907f, 
    -0.04373484f, 0.00349497f, 0.01924895f, -0.00034938f, -0.17510298f, -0.21268423f, 0.00300187f, 0.02198342f, 
    0.05181702f, -0.04610959f, -0.01894064f, 0.00410002f, 0.02282155f, 0.00309629f, 0.03301988f, -0.11897366f, 
    -0.16741662f, 0.03391064f, -0.09896945f, -0.08289289f, -0.06213074f, -0.06604342f, -0.00522543f, -0.05987808f, 
    0.03328910f, -0.01234984f, -0.06542014f, -0.05692855f, 0.13674644f, -0.05219568f, -0.05594055f, -0.02890559f, 
    0.14349139f, -0.01668889f, 0.00759653f, -0.05633935f, -0.06278733f, 0.00093829f, 0.02814581f, -0.05346534f, 
    0.05222174f, 0.02894917f, -0.15448944f, 0.10617539f, 0.00038216f, -0.06113979f, -0.01774774f, -0.02817113f, 
    -0.09763894f, 0.02210985f, 0.04015709f, -0.04964884f, -0.13697726f, -0.04260083f, -0.11891566f, -0.06535830f, 
    -0.00433077f, -0.01292040f, 0.00470708f, -0.09464402f, -0.08762072f, 0.00343257f, -0.01165366f, 0.00510223f, 
    0.01378111f, -0.29460067f, 0.10428203f, 0.07175183f, -0.07959674f, 0.03322577f, 0.03191726f, 0.00570387f, 
    -0.08368839f, 0.01422404f, 0.00793779f, -0.04598215f, 0.07262222f, 0.09810862f, -0.10986947f, 0.12466153f, 
    -0.00951381f, -0.06932089f, -0.04032398f, 0.00362401f, -0.08460663f, 0.03455382f, 0.03812362f, -0.08208338f, 
    0.06889388f, -0.03119470f, 0.15556446f, 0.12933594f, 0.06590852f, -0.03302192f, -0.00933951f, 0.01105601f, 
    -0.07328188f, -0.00723273f, -0.14231871f, 0.00769842f, 0.16040139f, -0.16818197f, -0.03858018f, 0.03083754f, 
    -0.01073008f, -0.05449340f, -0.01543949f, -0.01763039f, -0.07587168f, 0.01014941f, -0.02608904f, -0.01277325f, 
    -0.25043848f, -0.00872086f, -0.16248134f, -0.19287513f, -0.02168531f, 0.01998943f, -0.04435555f, -0.02966198f, 
    -0.08155829f, 0.04236009f, -0.04863829f, -0.06293257f, 0.00411654f, 0.11437991f, -0.05766577f, -0.19589768f, 
    0.00196679f, 0.09344395f, -0.01891247f, -0.02622335f, -0.04759772f, -0.11829470f, -0.04751000f, -0.03271577f, 
    0.10370358f, 0.18859783f, 0.15020129f, 0.19363989f, 0.07141511f, 0.00580566f, 0.00823773f, -0.05169560f, 
    0.00357314f, 0.08002608f, 0.01943723f, -0.10581511f, -0.06616983f, 0.12900263f, -0.07833758f, 0.02329826f, 
    -0.08817711f, -0.05280717f, -0.04988037f, -0.07846021f, 0.03070899f, -0.03752599f, 0.02696357f, -0.02276612f, 
    -0.25537607f, 0.17339696f, -0.06842352f, -0.19537553f, -0.04862180f, 0.02525129f, 0.00946793f, -0.06185830f, 
    -0.10152449f, 0.05144948f, 0.00504596f, -0.00576306f, 0.12425509f, -0.00564689f, 0.01610703f, 0.09250704f, 
    -0.10946634f, -0.05576221f, 0.03606424f, -0.10567585f, 0.01891139f, 0.05750814f, 0.02876563f, -0.02136764f, 
    -0.05752895f, 0.10394689f, -0.02219414f, 0.00767089f, 0.04126905f, -0.01131616f, 0.03163501f, -0.05317527f, 
    -0.03063144f, -0.02386916f, -0.04954715f, -0.00603973f, 0.17848590f, 0.24199878f, 0.10123613f, 0.09830432f, 
    0.10668126f, 0.07609778f, 0.03619829f, 0.00168044f, -0.00130577f, 0.10146932f, 0.05732480f, -0.00104758f, 
    0.06196126f, 0.10299375f, 0.10000951f, 0.06653281f, 0.06536563f, 0.05761044f, -0.00416751f, -0.04691292f, 
    -0.02854230f, 0.03630464f, -0.09240342f, -0.03235497f, -0.02122204f, -0.20201255f, 0.00972774f, -0.04005338f, 
    0.02482585f, -0.03539919f, -0.06064412f, 0.00311673f, -0.02257720f, 0.01323718f, -0.01983680f, -0.08968718f, 
    -0.03687231f, 0.17041102f, 0.17007670f, 0.12280782f, 0.09872080f, 0.10767208f, 0.01059575f, -0.03459122f, 
    -0.06369018f, 0.00861175f, 0.01901410f, -0.00711981f, -0.08443491f, 0.13499376f, 0.02662303f, -0.02245273f, 
    -0.09971472f, -0.00286555f, -0.02018251f, -0.03684018f, -0.11450369f, 0.00081635f, -0.08635718f, -0.11442114f, 
    0.07887336f, -0.17568028f, 0.08444557f, 0.08317340f, 0.04301326f, -0.04763434f, -0.05546505f, -0.00547074f, 
    0.00357398f, 0.00341717f, -0.09080713f, -0.04184480f, 0.08751842f, 0.05943655f, 0.12329283f, -0.06043127f, 
    -0.03050262f, 0.09200275f, -0.02960187f, 0.07000415f, 0.03624758f, 0.03520251f, -0.03292653f, 0.00251115f, 
    0.00105947f, 0.14856142f, 0.04652016f, -0.00996846f, -0.04136764f, -0.00393663f, -0.05358026f, -0.06234003f, 
    -0.08574919f, 0.02665650f, 0.03475501f, 0.02076937f, 0.21938995f, 0.04368472f, 0.12551913f, -0.08654180f, 
    0.00421133f, 0.07251457f, -0.03546411f, 0.05885157f, -0.04002032f, 0.10938185f, -0.04771584f, 0.04189541f, 
    -0.04469128f, -0.06990546f, 0.03830841f, 0.12698950f, -0.08500578f, -0.08013028f, -0.03845683f, -0.02590857f, 
    0.01073732f, 0.00270083f, 0.02426472f, -0.10287882f, 0.15900750f, -0.09042980f, 0.06129202f, 0.18758267f, 
    0.04699604f, -0.03031555f, -0.00071696f, -0.07806571f, 0.00591220f, 0.00227119f, 0.00744754f, -0.17052488f, 
    -0.30053854f, 0.11328430f, -0.21229292f, -0.03653933f, -0.08921320f, -0.10521627f, -0.00896774f, -0.02661121f, 
    0.03148923f, 0.03234356f, 0.00374447f, 0.08300335f, 0.02194193f, 0.04418818f, -0.04491274f, 0.06178505f, 
    0.10739826f, -0.05484878f, 0.01031339f, -0.01003302f, -0.07452451f, 0.05543026f, 0.01159606f, 0.02348930f, 
    -0.01369673f, 0.01961502f, 0.14765961f, 0.05944439f, -0.10190878f, 0.08151070f, -0.00470749f, -0.02728856f, 
    0.05628908f, -0.05070354f, 0.00139139f, -0.01043419f, 0.18359506f, 0.11315954f, 0.20749711f, 0.03436573f, 
    -0.09172920f, 0.02047723f, -0.02594737f, -0.03462140f, -0.01184997f, -0.00099973f, -0.09576226f, -0.02411303f, 
    0.02558671f, -0.00613361f, 0.02768831f, -0.01844606f, -0.03527204f, -0.03699388f, -0.02590586f, -0.00966392f, 
    -0.08384230f, 0.04926793f, -0.04722951f, -0.00475317f, -0.07230389f, 0.03121331f, 0.10412916f, 0.08766758f, 
    0.03190459f, 0.00896933f, 0.01167327f, 0.04240846f, -0.05352704f, 0.00046383f, -0.00604799f, -0.03043650f, 
    0.01587153f, 0.12101860f, -0.19413267f, -0.27372411f, -0.03724306f, -0.10960112f, -0.17585784f, -0.05851986f, 
    0.12866738f, 0.03948847f, 0.03508919f, -0.07134358f, -0.09193750f, -0.01480342f, 0.16594999f, -0.06527811f, 
    -0.00691453f, 0.03962067f, -0.03557555f, -0.01962640f, 0.02759410f, -0.09035655f, -0.02601282f, 0.00549537f, 
    0.17993237f, 0.01726181f, 0.15116285f, 0.02252153f, -0.02146257f, -0.08714814f, -0.06528644f, -0.15560187f, 
    -0.05919834f, 0.02694073f, 0.03315351f, 0.00139059f, -0.10097123f, -0.04471321f, 0.07188981f, 0.08615533f, 
    0.03586884f, 0.02092602f, 0.02081063f, 0.05691803f, 0.00758318f, 0.08010659f, -0.09614085f, 0.06409509f, 
    -0.15095282f, -0.05460652f, -0.01854711f, 0.04468042f, 0.06688386f, -0.00709904f, 0.00309238f, -0.07273876f, 
    0.10634237f, 0.07012828f, 0.07179981f, -0.06178532f, 0.14848229f, 0.07299561f, -0.11038648f, 0.04165958f, 
    -0.01235655f, 0.01869473f, -0.00332612f, -0.15981893f, 0.03595428f, -0.06845759f, 0.09489248f, 0.04028217f, 
    0.10194198f, -0.07788585f, -0.08109923f, -0.03924486f, 0.07269693f, -0.06036988f, 0.07277203f, -0.12243044f, 
    0.00400682f, 0.04885640f, -0.00272965f, 0.01634168f, 0.28234687f, 0.15980984f, -0.07588111f, -0.11733943f, 
    0.00846940f, -0.08129451f, 0.07588543f, 0.02268530f, 0.05695260f, -0.00069464f, -0.06867220f, 0.13505785f, 
    -0.30957904f, 0.07998840f, 0.12984991f, -0.00343725f, 0.01630053f, 0.04016723f, -0.00877321f, 0.06408491f, 
    0.01168785f, -0.01565924f, -0.16154326f, 0.06114558f, 0.10169576f, 0.11713320f, -0.16423756f, -0.27364445f, 
    0.07988533f, -0.08040275f, 0.06174019f, 0.07476953f, 0.00675477f, 0.04900714f, 0.04017582f, 0.07471478f, 
    -0.00489138f, -0.10970309f, 0.01957215f, 0.06574264f, -0.01941248f, 0.01744413f, 0.00892117f, -0.09796346f, 
    -0.07141809f, 0.15931684f, 0.00963473f, -0.02727989f, 0.07855364f, -0.01863691f, 0.04321906f, 0.08219052f, 
    -0.09335744f, -0.08829752f, 0.00871905f, -0.02281056f, 0.05626907f, 0.00679044f, -0.09271701f, -0.01537233f, 
    0.15986639f, 0.09483730f, -0.14464438f, 0.03654800f, 0.18069144f, -0.09785710f, -0.09411575f, -0.03079303f, 
    0.00878509f, 0.01063908f, 0.02468361f, 0.06284189f, -0.16673584f, -0.16889308f, 0.13736455f, 0.14613396f, 
    0.06932142f, -0.05996703f, -0.00338924f, 0.01778234f, -0.03817492f, 0.06256740f, 0.19401886f, -0.08132150f, 
    -0.19662985f, -0.22843242f, -0.01172286f, -0.18554486f, -0.04771482f, -0.01772311f, 0.01086602f, -0.12815176f, 
    -0.06134671f, -0.08948902f, 0.02247894f, 0.02973780f, 0.10709795f, -0.03656185f, 0.11807744f, 0.04916064f, 
    -0.06149109f, -0.07119897f, 0.02065714f, -0.02856182f, -0.07428962f, -0.06303548f, 0.01134765f, 0.04982864f, 
    0.06072463f, -0.28365758f, -0.06252675f, -0.14225146f, 0.01543664f, -0.06727092f, -0.01985808f, -0.04468299f, 
    0.11419042f, 0.06631366f, -0.05853723f, 0.06591997f, -0.03165890f, -0.00663635f, -0.02012002f, -0.05777715f, 
    0.10514368f, -0.03509437f, -0.05310109f, 0.00105083f, 0.00607015f, 0.08728937f, -0.02281086f, 0.15142839f, 
    0.16873500f, 0.00038028f, 0.14590366f, 0.03136154f, -0.03668910f, -0.04828598f, -0.00486367f, -0.06723297f, 
    -0.00522864f, 0.02683426f, -0.15440778f, -0.08997267f, -0.05987201f, -0.22437391f, 0.11058696f, -0.05710918f, 
    0.06151799f, -0.00598132f, -0.08838482f, 0.00248426f, 0.00668333f, 0.06603041f, 0.03781284f, 0.09405404f, 
    0.06116726f, -0.12620506f, -0.07797205f, -0.11710096f, -0.02270864f, -0.06686833f, 0.04727236f, 0.02871793f, 
    0.04911693f, 0.02578783f, -0.03618536f, 0.06757696f, -0.17268199f, -0.11794861f, 0.18690963f, -0.12053591f, 
    -0.05536695f, 0.01476667f, 0.05797184f, -0.01667895f, -0.02339480f, 0.04665919f, 0.00407705f, -0.02379653f, 
    -0.17236055f, -0.08880593f, 0.07283997f, 0.08600398f, 0.05510875f, -0.07761564f, -0.00030204f, -0.04017800f, 
    0.15107557f, 0.05254528f, -0.00548913f, -0.10276795f, -0.18343851f, 0.19045901f, -0.07412281f, -0.08619761f, 
    -0.07473330f, -0.03882976f, -0.09905631f, 0.15338419f, -0.00578777f, -0.01664677f, -0.04277709f, -0.05086925f, 
    0.07286351f, 0.02416014f, 0.03020299f, 0.08237891f, 0.09461833f, -0.00434670f, -0.02240112f, 0.00890942f, 
    0.03374933f, -0.03309781f, 0.01601868f, -0.17378290f, 0.01219025f, 0.22137474f, -0.06400932f, -0.16598177f, 
    -0.06079514f, -0.05317652f, -0.07658620f, -0.03443134f, -0.02469091f, 0.08132341f, 0.08441875f, -0.01715934f, 
    -0.03255379f, -0.11802024f, 0.06205892f, 0.11602033f, 0.11551034f, 0.04757173f, -0.01355740f, -0.01990941f, 
    0.05909945f, 0.00832421f, 0.14742447f, -0.14050958f, 0.08325645f, -0.00090968f, 0.01764461f, 0.09517575f, 
    -0.07876933f, -0.06209760f, 0.07640627f, 0.07142726f, 0.02836105f, -0.03724422f, 0.01276077f, 0.07817329f, 
    0.23504962f, 0.11599771f, 0.12253695f, 0.15836163f, -0.00504280f, -0.08135101f, -0.08817598f, -0.14472133f, 
    -0.01018727f, 0.06976323f, -0.03791941f, 0.04418729f, -0.02944725f, -0.07696412f, -0.06973532f, -0.07933727f, 
    0.01742310f, -0.01563561f, -0.06798036f, 0.01609332f, 0.01640096f, 0.06289428f, -0.00859707f, 0.03418337f, 
    -0.12938122f, 0.07860687f, -0.12320392f, 0.01292903f, 0.09710116f, -0.05461086f, -0.03599082f, -0.04373508f, 
    0.00218012f, -0.06812114f, -0.18364458f, 0.07179607f, 0.13381229f, 0.01853883f, -0.12780276f, -0.05659540f, 
    -0.05449770f, -0.09501328f, -0.04920397f, 0.01349352f, -0.03071102f, 0.07736909f, 0.08280496f, 0.04868588f, 
    0.08614198f, -0.02458505f, 0.05030128f, 0.14496404f, 0.05444957f, -0.01133158f, -0.04517890f, 0.02395661f, 
    -0.04892120f, 0.01872233f, 0.00684869f, 0.10960773f, 0.07832835f, -0.19735062f, 0.09118945f, -0.09780556f, 
    -0.02244700f, -0.10199244f, -0.06711306f, 0.13188571f, 0.01901775f, -0.01605527f, 0.05907590f, -0.01930004f, 
    -0.21429758f, 0.11520837f, -0.11807575f, -0.08315970f, -0.07864807f, 0.00583918f, -0.09993409f, -0.01420702f, 
    0.10520055f, 0.02566039f, 0.04412158f, -0.01790000f, 0.10691402f, -0.09298178f, 0.04980479f, 0.14309195f, 
    -0.00097797f, 0.04309157f, -0.07355633f, -0.04072080f, -0.03780088f, 0.05289061f, 0.09158441f, 0.01481175f, 
    0.05127496f, -0.31859571f, -0.16726269f, 0.02004103f, 0.06517298f, -0.01736708f, 0.02454005f, -0.09049524f, 
    0.01323442f, -0.04297915f, -0.08393856f, 0.08735044f, -0.20835261f, 0.06001638f, -0.19205603f, -0.18504934f, 
    -0.01080391f, -0.02469137f, -0.09365202f, 0.11434236f, 0.08019813f, 0.00530510f, 0.06658944f, -0.12740858f, 
    0.02354792f, 0.11786468f, -0.02932179f, 0.07585033f, 0.06981376f, -0.02720553f, -0.07077330f, 0.10063723f, 
    -0.01369781f, 0.00488341f, -0.06932188f, -0.06067852f, -0.17541713f, -0.16065034f, -0.17434189f, 0.02313516f, 
    0.01558536f, -0.06542486f, -0.04126499f, -0.09747742f, 0.07595707f, -0.04641553f, -0.02692523f, 0.00283014f, 
    0.03259815f, -0.05871731f, 0.11302279f, 0.10802853f, 0.09833691f, 0.04016649f, -0.01546093f, -0.07708032f, 
    0.06495857f, -0.03680865f, -0.08356236f, -0.00727547f, 0.10347497f, -0.15140979f, 0.02774472f, 0.02817636f, 
    0.09037290f, -0.05465067f, -0.11063853f, 0.01695129f, -0.03242675f, 0.00784829f, 0.05365415f, -0.01617788f, 
    -0.20197412f, 0.16438703f, 0.07447157f, 0.16047451f, -0.06196761f, -0.03275600f, -0.17964356f, 0.07089600f, 
    0.07148839f, -0.04853968f, 0.11643751f, 0.04362711f, 0.07979931f, 0.27041414f, -0.17670412f, -0.02631563f, 
    0.04205507f, 0.01268137f, 0.03389892f, -0.01024386f, 0.04229909f, 0.01835975f, -0.07976104f, 0.07199159f, 
    0.06375324f, -0.14025258f, 0.01412193f, 0.17409866f, 0.05639769f, 0.01171776f, -0.09658469f, 0.00033888f, 
    0.15865006f, -0.08826596f, 0.00873530f, -0.07939051f, -0.05336518f, -0.24701855f, -0.04038063f, -0.00374908f, 
    -0.06034163f, -0.08615123f, -0.05779516f, -0.00374737f, 0.04963197f, -0.00916695f, 0.05273524f, -0.09017089f, 
    0.00712237f, -0.03238846f, -0.07931461f, 0.01803511f, -0.05680685f, -0.03745892f, -0.15511045f, 0.00944713f, 
    -0.09823952f, -0.02363086f, 0.02653849f, -0.17793955f, 0.17100152f, 0.02310764f, 0.05571431f, 0.09716450f, 
    -0.03272108f, -0.14803903f, 0.06647094f, -0.08017341f, -0.07489099f, -0.03580164f, -0.00332232f, 0.00734902f, 
    -0.13053076f, 0.03484213f, 0.15085162f, -0.10647452f, 0.00077794f, -0.05004884f, -0.14235587f, -0.05174321f, 
    0.01622679f, -0.10999997f, 0.00742809f, 0.05113191f, 0.14165942f, 0.03530719f, 0.06440275f, 0.10394063f, 
    -0.05249358f, -0.08477658f, -0.10822124f, -0.10775083f, 0.03406337f, -0.09228017f, 0.01086226f, -0.14634697f, 
    -0.14366174f, -0.03666983f, 0.15447532f, 0.07674003f, -0.04365246f, -0.00995169f, 0.01171221f, -0.16964668f, 
    0.01976615f, -0.16850251f, -0.01444944f, -0.02059772f, -0.01385251f, -0.13185567f, 0.16119981f, 0.06021548f, 
    -0.08059929f, -0.01724169f, 0.11321343f, -0.05164434f, -0.02795170f, -0.00276489f, -0.01821916f, -0.02308549f, 
    -0.10526831f, -0.10467765f, -0.24102171f, -0.15080655f, -0.15023685f, -0.00877131f, 0.07576315f, -0.13895379f, 
    0.02461280f, 0.05491093f, 0.02059262f, 0.09235016f, -0.09073591f, 0.17201802f, -0.06070126f, -0.15015747f, 
    0.00159908f, -0.07395560f, -0.01042837f, -0.00527003f, 0.00655141f, -0.00791509f, -0.00715629f, -0.00699898f, 
    -0.02822421f, -0.09596173f, 0.05288200f, -0.01812256f, 0.04396109f, -0.14680333f, -0.10837080f, 0.06043853f, 
    0.06157737f, 0.00373558f, 0.02103304f, -0.01465001f, 0.01592927f, -0.03309974f, 0.11463280f, -0.02880844f, 
    0.11698863f, 0.12279887f, -0.02995926f, 0.16187103f, 0.07037455f, -0.00458570f, -0.00348464f, -0.05216918f, 
    -0.16908744f, -0.16913702f, -0.13812011f, -0.17045127f, -0.04943273f, -0.03466436f, -0.03777976f, -0.04537784f, 
    0.06741959f, 0.07174664f, -0.01518340f, 0.04303888f, 0.01473171f, -0.15995862f, -0.00690772f, -0.07604237f, 
    0.06021921f, -0.09678572f, 0.09553272f, -0.14792868f, -0.07908524f, 0.03565585f, -0.06286514f, 0.11388691f, 
    -0.02220676f, -0.04998660f, -0.14390530f, 0.13119994f, 0.06255805f, 0.06789438f, -0.04049345f, -0.05180320f, 
    0.07827590f, 0.00462267f, 0.04552191f, 0.05834440f, -0.17927425f, -0.05363180f, -0.11216418f, -0.18459992f, 
    0.00111433f, 0.05027582f, -0.12786342f, 0.04318022f, 0.00800123f, 0.01980979f, 0.09415468f, -0.12230157f, 
    -0.04930818f, 0.30822867f, -0.05568880f, 0.01223606f, -0.06313627f, 0.10345396f, -0.09909828f, -0.03456730f, 
    0.07496623f, 0.03907169f, -0.01655434f, -0.03971466f, -0.16641003f, 0.09407795f, 0.03514757f, -0.15919228f, 
    0.04515649f, -0.01758601f, 0.00882543f, -0.01445530f, -0.02919676f, -0.05684276f, 0.06938881f, 0.04914672f, 
    0.04894240f, -0.09284875f, -0.13539025f, -0.08352922f, -0.00350172f, -0.01869155f, 0.00049041f, -0.00182579f, 
    0.07413480f, -0.05397839f, -0.04046863f, 0.00042012f, -0.13538298f, -0.07260469f, 0.12388240f, -0.07211788f, 
    -0.05203783f, 0.06685692f, 0.01091236f, -0.23451521f, -0.02821224f, -0.04974706f, -0.01242337f, -0.03950714f, 
    -0.13711829f, -0.04505415f, 0.09957252f, -0.11889552f, 0.00445605f, 0.00468927f, 0.00650970f, -0.00301422f, 
    0.01119059f, -0.19764815f, -0.09712747f, 0.04378176f, 0.14637725f, -0.29513741f, -0.05327511f, 0.05787289f, 
    0.04183189f, -0.02267946f, -0.02083373f, 0.05492006f, -0.11921903f, 0.13869710f, -0.06152838f, 0.03467161f, 
    0.48949683f, -0.07429968f, 0.12027167f, -0.12887956f, 0.08784653f, 0.01441878f, -0.01515178f, 0.04170432f, 
    0.22801982f, 0.08544227f, 0.02402256f, 0.05336592f, -0.17961779f, 0.17816892f, 0.13758963f, -0.16693313f, 
    -0.00369679f, 0.04287679f, 0.00689548f, -0.21101205f, 0.03593758f, 0.00513571f, 0.04658415f, -0.01585004f, 
    -0.20466638f, 0.09389862f, -0.15369245f, -0.37165955f, 0.00927813f, -0.06231400f, 0.09671377f, 0.04294987f, 
    -0.04399515f, -0.02510891f, -0.07322057f, -0.06904366f, -0.01756514f, 0.13810101f, -0.24467240f, -0.09102972f, 
    0.03720412f, 0.13254280f, 0.06707305f, -0.04786356f, -0.17659731f, 0.03549259f, -0.10980164f, -0.02548988f, 
    0.01583464f, 0.05919462f, 0.11241318f, -0.06374955f, -0.09011330f, -0.02311419f, 0.06436736f, -0.09662575f, 
    0.04808806f, -0.06029217f, 0.09232497f, -0.16548905f, 0.20356871f, 0.13141906f, 0.06466381f, -0.18092164f, 
    0.00456922f, -0.05824186f, -0.00357646f, 0.00994370f, 0.05892716f, 0.02146765f, 0.18896413f, 0.04589573f, 
    0.06601296f, -0.15063187f, -0.15211861f, 0.06533449f, 0.03035379f, 0.00352285f, 0.09198736f, -0.05583832f, 
    -0.01548950f, -0.00627805f, -0.07290972f, -0.00477936f, 0.17616124f, -0.10628271f, 0.12524854f, -0.22885171f, 
    -0.02140249f, -0.05396103f, -0.10637772f, -0.17454483f, -0.14192252f, 0.08281767f, 0.05935054f, 0.00276913f, 
    -0.00085223f, 0.11196744f, -0.44985148f, -0.17367733f, 0.12148392f, -0.02599117f, -0.00395607f, 0.11726125f, 
    0.04948270f, 0.04761322f, 0.00227744f, 0.08877987f, 0.14822163f, -0.19269449f, 0.04503204f, 0.01606027f, 
    0.01884923f, 0.12921365f, -0.07679258f, 0.02500953f, -0.00989794f, 0.04850558f, -0.02378130f, -0.04013653f, 
    -0.31832910f, 0.23323612f, 0.25796711f, 0.03864148f, -0.02115531f, -0.04649190f, 0.14189988f, -0.05309236f, 
    -0.00675478f, 0.01154713f, -0.02729357f, -0.05147343f, -0.26445368f, 0.09534423f, -0.05960060f, -0.13691391f, 
    0.01666147f, -0.13108180f, 0.07939919f, -0.03137998f, -0.06839933f, 0.02516153f, -0.09157692f, -0.01861961f, 
    0.00789818f, 0.02552262f, -0.13907598f, 0.02262561f, -0.02276329f, 0.06919685f, 0.07895500f, 0.02400605f, 
    -0.02355852f, 0.12806810f, 0.11836142f, -0.08827934f, -0.04541227f, 0.33780289f, -0.08455548f, 0.00082854f, 
    0.02628435f, 0.04831328f, -0.01893702f, -0.03546299f, -0.01032895f, -0.02077597f, 0.14129609f, 0.04160391f, 
    -0.01945691f, 0.10014045f, 0.06265094f, -0.03472671f, -0.08682629f, 0.14843428f, -0.01075961f, -0.02917053f, 
    -0.11420488f, -0.01453452f, 0.01085112f, 0.00218020f, 0.06842427f, -0.18208268f, -0.06296498f, 0.04212059f, 
    -0.11986040f, -0.02855927f, -0.05978340f, 0.07985693f, 0.06439453f, 0.07177448f, 0.15384912f, -0.15744734f, 
    -0.19963625f, 0.16994391f, 0.04233224f, 0.18088783f, 0.15858375f, -0.01841578f, -0.03602346f, -0.06149795f, 
    -0.02569986f, -0.06415820f, -0.01923243f, 0.06785580f, -0.00933036f, 0.05131392f, -0.03616764f, 0.08619126f, 
    -0.04403544f, -0.02105265f, -0.02090881f, -0.02502415f, -0.07755746f, 0.05640654f, 0.01137647f, -0.02767204f, 
    -0.06434309f, 0.03811899f, -0.02118588f, -0.03000479f, 0.08219435f, -0.10730410f, 0.11408113f, 0.03427752f, 
    0.00814231f, -0.05801788f, 0.09300470f, -0.00003769f, -0.17099935f, 0.01957337f, 0.03890430f, 0.10082766f, 
    -0.00089127f, -0.05815889f, 0.04858017f, -0.02295936f, -0.02941448f, 0.01383530f, 0.03967641f, 0.02841244f, 
    -0.09462836f, -0.19434573f, -0.06595274f, 0.01777127f, -0.00083442f, -0.00739264f, 0.03199132f, 0.03890496f, 
    0.12389931f, -0.06323391f, 0.17514467f, -0.00377871f, -0.47178337f, 0.02100657f, -0.30483884f, 0.03472103f, 
    0.07796140f, 0.08058816f, 0.06241291f, 0.00979649f, -0.01455491f, 0.07621822f, 0.02307701f, 0.05959550f, 
    -0.02388786f, -0.00597571f, -0.03779553f, -0.24912181f, 0.06468283f, 0.07954741f, -0.02099210f, -0.04358057f, 
    0.10525058f, 0.01157013f, 0.00910681f, -0.01787318f, -0.48693988f, -0.04655204f, 0.25943387f, -0.04471411f, 
    0.02374323f, -0.05145263f, -0.07801756f, -0.03048021f, 0.07125550f, -0.09203159f, -0.04653084f, -0.04416257f, 
    -0.00953915f, -0.18471690f, 0.16028102f, -0.16056487f, -0.03334382f, 0.12135302f, -0.00956086f, -0.11895943f, 
    -0.07868451f, 0.02234092f, -0.01305122f, 0.02966363f, 0.09956903f, 0.31687382f, -0.12559429f, 0.30970415f, 
    0.12300085f, -0.08086942f, 0.00560431f, -0.06224404f, -0.10452211f, 0.06752940f, -0.08891919f, -0.17676252f, 
    0.39566964f, -0.47178438f, 0.05337949f, 0.05692637f, 0.11977028f, -0.04350639f, 0.00183942f, -0.01470947f, 
    0.14900899f, -0.10513319f, 0.05828966f, -0.08426090f, 0.09785596f, -0.48004290f, 0.14253572f, -0.10756993f, 
    0.05747429f, -0.00553634f, 0.00117014f, 0.00542896f, -0.12950742f, -0.04613113f, 0.06918076f, 0.05914403f, 
    0.02390513f, 0.09252574f, 0.18661742f, -0.06069250f, -0.02795944f, 0.02528495f, 0.03210469f, 0.05866631f, 
    0.10045579f, -0.03314789f, 0.14643429f, -0.04249334f, 0.10865903f, 0.13067624f, 0.01604742f, -0.21963388f, 
    -0.01358813f, 0.01102996f, -0.01573005f, 0.19463955f, -0.01936494f, 0.09016876f, -0.16952850f, -0.10181339f, 
    -0.27378032f, 0.11386378f, -0.19160205f, 0.02145304f, 0.02835866f, -0.02376378f, 0.06344722f, -0.08195594f, 
    -0.11752889f, 0.03652839f, -0.02011556f, -0.18787749f, 0.05024425f, -0.01076785f, 0.02697171f, 0.31194362f, 
    0.06363216f, 0.09754445f, 0.03081103f, -0.16170231f, -0.07289223f, -0.00725034f, -0.08930165f, 0.09117271f, 
    -0.07380199f, 0.19099839f, -0.01819931f, 0.04087390f, -0.12116277f, 0.16887540f, 0.03973389f, 0.04017156f, 
    0.00271205f, -0.00342996f, -0.12646039f, -0.03979196f, 0.09065658f, 0.08199713f, -0.14453202f, -0.17886239f, 
    0.17754392f, 0.04436108f, -0.09209127f, -0.15995552f, -0.02874938f, -0.06419326f, -0.04344251f, -0.00217846f, 
    0.08951043f, -0.03584649f, 0.07948408f, -0.04004600f, -0.02116251f, 0.08200836f, -0.06764303f, 0.04925280f, 
    0.01978607f, -0.01345425f, 0.04708591f, 0.07378617f, 0.02887336f, 0.18155119f, 0.11884545f, -0.05050900f, 
    0.03353545f, 0.00385492f, -0.09305782f, -0.01971962f, -0.05614569f, 0.03988495f, -0.03155005f, 0.05058343f, 
    0.17733349f, -0.60106939f, 0.05465269f, -0.16269369f, -0.05605623f, -0.03653979f, -0.07029729f, 0.00918460f, 
    -0.05750929f, 0.03607988f, 0.13680759f, 0.07328546f, -0.25878057f, -0.01981981f, 0.05358216f, -0.32266781f, 
    0.02802182f, -0.01269693f, 0.00484299f, -0.00987129f, 0.01999538f, -0.01017664f, 0.04303004f, 0.04371617f, 
    -0.08445678f, 0.07706665f, -0.07690063f, -0.19913952f, 0.01506135f, 0.08394566f, -0.09881821f, 0.09044030f, 
    -0.06899227f, 0.01828996f, 0.01914890f, 0.09967776f, -0.05521982f, 0.04696217f, 0.11487931f, 0.03112161f, 
    -0.08620074f, -0.00958304f, 0.04822277f, -0.05680115f, 0.02526458f, -0.02032236f, -0.03950648f, -0.02481873f, 
    -0.16992179f, -0.31061873f, 0.18418096f, -0.20698291f, 0.05280254f, 0.05071681f, 0.05112297f, 0.12152565f, 
    -0.27829033f, -0.05262704f, -0.13068521f, 0.11241421f, -0.04032554f, 0.17826806f, 0.28436628f, 0.21506211f, 
    -0.02934458f, -0.06040284f, -0.02633643f, 0.11042161f, 0.00981255f, 0.01946348f, 0.12581432f, 0.11640161f, 
    -0.30038118f, 0.18962109f, -0.03132081f, -0.27341086f, 0.06199125f, -0.07546867f, -0.02716469f, -0.02861115f, 
    -0.10040499f, -0.04840260f, 0.04243291f, -0.11110425f, -0.09209693f, -0.03976224f, 0.04796403f, -0.02511430f, 
    0.04063577f, -0.00427923f, -0.01154687f, -0.00768872f, -0.00753643f, 0.04413204f, -0.02839665f, -0.01521548f, 
    0.00753291f, -0.26852864f, 0.07152414f, 0.01051247f, -0.05963620f, -0.00815662f, 0.01094449f, 0.13730577f, 
    0.08448274f, -0.01043293f, 0.11788876f, 0.01180122f, -0.01417111f, -0.24658675f, -0.04705397f, 0.09628814f, 
    0.10792568f, 0.07548349f, -0.10357119f, 0.13369510f, -0.09934952f, -0.01252081f, -0.03431154f, -0.10795666f, 
    -0.10063482f, -0.27461332f, 0.05340406f, -0.18882179f, -0.13431466f, 0.09651469f, 0.06726643f, 0.06828471f, 
    -0.11300248f, 0.15395494f, -0.12585410f, 0.07613879f, 0.16233972f, 0.05962195f, -0.02637927f, -0.09986518f, 
    0.15535910f, -0.02139208f, 0.01861896f, -0.08942824f, -0.01510892f, -0.03171556f, 0.02934695f, 0.16173032f, 
    -0.06611861f, -0.34169877f, -0.04136684f, -0.09957609f, 0.09863485f, -0.08016276f, -0.04109873f, 0.15067047f, 
    -0.01842543f, -0.00307454f, 0.05421401f, 0.05796865f, -0.02350583f, 0.15386151f, -0.11356787f, 0.07210539f, 
    0.11409295f, 0.01323396f, 0.03993979f, -0.03672781f, -0.09442370f, 0.00983289f, -0.00107719f, -0.01336603f, 
    0.05203139f, -0.03373919f, 0.05856888f, -0.03568859f, -0.03714054f, 0.03735610f, 0.01221105f, 0.01148642f, 
    -0.01702640f, -0.02106922f, -0.04742616f, -0.14952961f, -0.32855472f, 0.02363205f, -0.16122374f, -0.05791497f, 
    0.01695250f, 0.09212292f, 0.01994774f, 0.12739247f, 0.03015460f, -0.03541649f, 0.10253273f, 0.11513358f, 
    -0.18049569f, -0.07596358f, -0.04345656f, -0.03319101f, -0.01258587f, -0.05591090f, -0.06777828f, -0.05111697f, 
    0.01707157f, -0.01671382f, -0.01039257f, 0.02727058f, 0.18531704f, -0.18894006f, 0.12257431f, 0.03053364f, 
    0.00202283f, 0.07418364f, -0.11540408f, -0.09352694f, -0.12675323f, 0.10628106f, -0.14550377f, 0.01462456f, 
    -0.04500061f, 0.09576317f, -0.28470337f, -0.11438941f, 0.09912122f, -0.05041261f, 0.05735063f, 0.04978085f, 
    0.04734611f, -0.00501249f, -0.02726723f, 0.00024364f, 0.13705888f, 0.23215075f, -0.07873385f, 0.07344897f, 
    0.09284955f, 0.03107074f, -0.11818224f, 0.13297576f, 0.12665561f, -0.02153056f, 0.00315300f, 0.11255039f, 
    -0.11091893f, 0.31655544f, -0.33780557f, -0.38066605f, 0.20937367f, -0.03950840f, -0.02651302f, 0.11167818f, 
    -0.08596797f, 0.00965844f, -0.03787572f, -0.13432516f, -0.16171099f, -0.13258095f, 0.12611531f, -0.00350725f, 
    -0.04619272f, -0.00739504f, 0.07867807f, -0.03471322f, -0.10055117f, 0.01876700f, -0.05125336f, -0.00944111f, 
    -0.21599412f, 0.09005898f, -0.05702967f, 0.22409412f, -0.01959698f, -0.06927626f, -0.09117396f, 0.18332060f, 
    0.08616345f, 0.07372896f, -0.01561249f, -0.03694742f, -0.23302169f, -0.02964477f, -0.09232045f, 0.12118363f, 
    -0.07216323f, 0.02474077f, -0.05006212f, -0.06922515f, 0.01575654f, 0.16655914f, 0.01272868f, -0.01717389f, 
    0.04210477f, -0.04432326f, 0.15484704f, -0.03273853f, 0.02111549f, 0.00460506f, 0.02402617f, -0.11580382f, 
    -0.03534531f, 0.09410530f, 0.03047671f, 0.07511542f, 0.24157436f, -0.21151315f, -0.01709475f, 0.19917564f, 
    -0.02712721f, -0.03090263f, -0.08429875f, 0.16999626f, 0.02975460f, 0.14576039f, 0.10300686f, 0.00680270f, 
    0.14088121f, -0.04464710f, -0.05834283f, -0.01869176f, 0.04127258f, 0.06760392f, -0.04784131f, -0.06508955f, 
    -0.00774948f, 0.09669729f, -0.00924095f, -0.00031354f, 0.22262484f, 0.02491870f, -0.04499287f, -0.05312250f, 
    -0.19650322f, -0.01743556f, 0.00105666f, 0.00466926f, 0.11067882f, 0.01187664f, 0.04881195f, -0.07729439f, 
    -0.41888705f, -0.08283503f, 0.07171346f, -0.24518247f, -0.00433162f, 0.05734665f, -0.12044101f, -0.11796106f, 
    -0.05013657f, -0.10458160f, -0.11618392f, -0.03947545f, 0.07256006f, -0.07806796f, -0.04117494f, -0.06732216f, 
    0.07842082f, -0.04068572f, 0.05138087f, 0.01347967f, 0.09227289f, 0.00529230f, -0.03483176f, 0.08169226f, 
    -0.07772989f, -0.06038698f, 0.09437473f, -0.17568141f, 0.02472757f, -0.04418497f, 0.10164431f, -0.03611949f, 
    0.01823032f, 0.04609507f, 0.02234137f, 0.02964825f, -0.01578158f, -0.23143552f, 0.04648544f, 0.08745761f, 
    0.06065466f, 0.00476293f, 0.05516951f, -0.04121660f, 0.10580719f, 0.04247886f, 0.14164372f, 0.01074131f, 
    -0.08348845f, 0.08492313f, -0.08007652f, 0.01356397f, 0.05587531f, 0.03707557f, -0.04608045f, -0.08760179f, 
    -0.06472622f, -0.14069968f, 0.00279512f, 0.05157977f, -0.21079727f, 0.00487669f, -0.00915383f, -0.11418901f, 
    0.09279466f, -0.00339570f, 0.01970936f, 0.02444716f, 0.02164003f, 0.05646003f, 0.02223394f, -0.02103165f, 
    0.05730297f, 0.07045221f, 0.01118922f, -0.09116564f, 0.06527165f, 0.06044654f, 0.01088057f, -0.00854065f, 
    0.05169732f, -0.01716650f, 0.07734610f, 0.10167386f, 0.15285321f, 0.20862658f, 0.11926148f, 0.03607839f, 
    0.11989027f, 0.00477357f, -0.01600405f, -0.01682142f, 0.12080272f, 0.20683955f, 0.01984147f, -0.02992474f, 
    -0.21284650f, -0.34473157f, -0.15305272f, -0.03030513f, 0.03218728f, -0.00547320f, -0.04179802f, -0.01089846f, 
    0.05215086f, 0.10375768f, 0.03097409f, 0.08017980f, 0.10560178f, 0.00834063f, -0.06252889f, 0.07149233f, 
    0.04980582f, -0.12703983f, -0.09182388f, -0.00181129f, -0.02066713f, -0.00655419f, -0.04561516f, 0.01553542f, 
    -0.65681136f, -0.34493995f, -0.01478610f, 0.06324632f, 0.12505624f, -0.01930337f, -0.01198201f, -0.01649428f, 
    0.12854475f, 0.01785181f, -0.00205939f, 0.13270454f, -0.64036000f, -0.42031604f, 0.11179683f, -0.21282631f, 
    -0.04375549f, -0.19306777f, -0.02277259f, 0.01563418f, 0.02476119f, 0.06389629f, 0.00609040f, -0.09395375f, 
    0.21494217f, 0.16313271f, 0.00164702f, -0.06683660f, 0.07329469f, 0.06528134f, -0.00693229f, -0.00361966f, 
    -0.10001092f, -0.05865739f, 0.00410736f, -0.01945296f, -0.24974053f, -0.35439879f, -0.11463927f, 0.00044219f, 
    0.05253298f, -0.03565198f, 0.05086995f, 0.03509298f, 0.04844394f, -0.07095671f, -0.08195867f, 0.01965457f, 
    -0.24172959f, 0.15955850f, 0.07072415f, 0.02177049f, 0.05288342f, -0.07424797f, 0.01597962f, -0.01178951f, 
    -0.00981895f, 0.05323483f, 0.05713119f, 0.07128844f, 0.28698334f, 0.04263068f, -0.00170210f, -0.15441778f, 
    0.07614730f, 0.10071904f, 0.00192367f, 0.09856959f, 0.02868712f, 0.07850515f, 0.00605101f, -0.01114178f, 
    0.30756915f, 0.08279040f, -0.13909507f, 0.00938731f, -0.13615604f, -0.01866932f, 0.03359382f, 0.02095606f, 
    0.01687470f, 0.05292023f, -0.13078283f, -0.06688032f, -0.12835525f, 0.10625190f, -0.05678469f, -0.05396128f, 
    0.10392801f, 0.05199679f, -0.08290018f, 0.01397463f, 0.01171813f, 0.11129422f, -0.00674962f, 0.13246803f, 
    -0.05833054f, 0.01021344f, 0.00343361f, 0.11947224f, 0.00026805f, 0.04752520f, -0.03589302f, 0.05626431f, 
    0.01711746f, 0.09444930f, 0.07920153f, 0.05117610f, 0.10075472f, 0.04578734f, 0.01057026f, 0.05555052f, 
    0.07883906f, -0.03411406f, 0.04180832f, -0.12593949f, 0.03825584f, 0.11018639f, 0.10160682f, 0.08077729f, 
    0.19681633f, 0.11451229f, -0.05609666f, 0.06620388f, 0.05142969f, 0.00286764f, -0.00331546f, 0.03672753f, 
    -0.00359290f, 0.08255388f, -0.08835115f, -0.04760241f, 0.02455608f, -0.13131638f, 0.00452934f, 0.11133631f, 
    -0.05805555f, 0.11529915f, -0.08975181f, 0.23155275f, -0.02032142f, 0.02480193f, -0.11605979f, -0.01250298f, 
    -0.36322001f, -0.01285395f, -0.00803782f, -0.15762009f, 0.10079456f, 0.00799107f, 0.01716372f, -0.00885604f, 
    0.05306840f, -0.04230758f, -0.03593075f, -0.03930512f, 0.04082584f, -0.05782967f, -0.18533333f, 0.00639216f, 
    -0.04836014f, -0.03572409f, 0.04673856f, 0.06428193f, 0.06735662f, 0.07243162f, 0.02169690f, 0.03236265f, 
    -0.33262706f, 0.05903128f, 0.01822871f, -0.00983983f, 0.06273101f, 0.02769995f, 0.02751103f, 0.05220744f, 
    -0.02648674f, 0.06978095f, 0.03970036f, 0.02559828f, 0.10819766f, 0.04160967f, -0.07486620f, 0.05812845f, 
    -0.02657147f, -0.09894037f, 0.11395232f, 0.03248546f, -0.01775425f, -0.04883990f, 0.11974289f, 0.11044998f, 
    -0.12465044f, 0.09532939f, -0.02871966f, -0.07968726f, 0.01581973f, 0.04039261f, -0.07247974f, -0.00629576f, 
    0.03302324f, 0.03581470f, 0.02326552f, 0.07434309f, -0.19176559f, 0.06588071f, -0.00742699f, -0.13243316f, 
    0.06958769f, 0.10370182f, 0.01179524f, 0.06343369f, 0.11873100f, 0.11743890f, -0.03660360f, 0.08213616f, 
    -0.30748308f, -0.14380649f, 0.08204658f, 0.14136338f, 0.08376035f, -0.05102259f, 0.03083597f, -0.04805287f, 
    0.03073973f, -0.09330662f, -0.09850849f, 0.05653714f, 0.06674895f, 0.11174188f, -0.02334409f, -0.01398250f, 
    -0.08499528f, 0.04148035f, -0.13318022f, 0.03037846f, -0.07008354f, 0.00149611f, 0.14353231f, 0.02302466f, 
    -0.44443244f, -0.12151917f, -0.12072853f, -0.31057462f, -0.03668292f, 0.02429384f, -0.04797373f, -0.04654691f, 
    0.04263301f, 0.03051401f, -0.04523589f, 0.13018309f, 0.04690570f, 0.08530246f, -0.18017820f, -0.02817127f, 
    -0.07194504f, -0.16211455f, 0.00696907f, -0.02033137f, -0.11465520f, 0.01110584f, 0.20418763f, 0.03611422f, 
    -0.19102265f, -0.11770686f, 0.05823993f, 0.07184127f, 0.05114787f, -0.03890990f, 0.05825073f, 0.00246735f, 
    0.06901808f, -0.01034199f, 0.05777220f, 0.02390928f, -0.50452292f, -0.25615722f, -0.13829620f, -0.00825126f, 
    0.06377376f, -0.03272627f, -0.09203944f, 0.03422482f, -0.01739695f, 0.08191767f, 0.07744232f, 0.02390344f, 
    -0.08706120f, 0.06355269f, 0.08559969f, -0.02677986f, 0.03266313f, 0.00528068f, 0.16751739f, 0.05266167f, 
    0.10252643f, 0.01281199f, 0.04296548f, 0.01455913f, -0.29165277f, -0.04959359f, 0.18175733f, 0.07309847f, 
    0.06576519f, 0.06630742f, -0.03420104f, -0.02960387f, 0.06459535f, -0.14258063f, -0.00362484f, -0.15307745f, 
    -0.16844821f, 0.05414928f, -0.30865952f, -0.04374719f, 0.02648843f, -0.02146592f, -0.06392381f, -0.04753932f, 
    0.10703918f, 0.07633059f, -0.06244256f, 0.00631176f, 0.01401035f, 0.17657475f, 0.00985537f, -0.01383556f, 
    0.00078145f, 0.01646300f, -0.04947500f, 0.04552730f, -0.04850731f, -0.03227923f, -0.06710292f, -0.15999141f, 
    -0.22496319f, -0.08022343f, -0.09097890f, -0.08761997f, 0.04989307f, -0.03626601f, -0.05798886f, -0.00436301f, 
    0.06196613f, -0.06672606f, 0.01281501f, 0.05205633f, -0.40078160f, -0.04987509f, -0.08438776f, -0.08053154f, 
    0.11081474f, -0.12457544f, -0.11800262f, -0.02889463f, -0.13063328f, 0.03552153f, 0.02566749f, 0.16295123f, 
    0.00796843f, 0.12963691f, -0.08543269f, 0.00888918f, -0.01164549f, -0.02084513f, -0.02934914f, -0.05217574f, 
    0.00769121f, 0.00445548f, 0.15302792f, -0.02575519f, -0.09817784f, -0.12095902f, 0.05504082f, 0.02458496f, 
    -0.08102546f, 0.00221280f, 0.04326587f, 0.06811140f, 0.15764044f, 0.03364263f, -0.00977792f, -0.05307722f, 
    -0.47142750f, -0.05426464f, -0.21400215f, -0.40603039f, 0.07058623f, -0.00044764f, -0.02813054f, 0.02844128f, 
    0.03714447f, -0.17015031f, 0.08510674f, 0.00962622f, -0.12777412f, 0.05350790f, 0.15309705f, -0.00412174f, 
    0.08668014f, 0.04837698f, 0.01878523f, 0.00605353f, 0.06445938f, -0.11161173f, 0.00148732f, -0.02832459f, 
    -0.11477954f, -0.10477480f, -0.13997209f, -0.11275875f, -0.06047099f, 0.05016971f, -0.08113983f, -0.13064297f, 
    -0.00898884f, -0.02314215f, -0.09430722f, -0.12453780f, 0.10670517f, 0.04715608f, -0.10439084f, -0.04741054f, 
    -0.08891556f, -0.15414317f, 0.00656077f, -0.02830176f, -0.04190792f, -0.06334333f, -0.13119058f, 0.01621732f, 
    0.22869788f, 0.16250534f, -0.02369220f, -0.02096155f, 0.10333157f, 0.00070623f, -0.07213249f, -0.00713383f, 
    -0.02421720f, -0.02075801f, 0.01863807f, -0.11608224f, -0.00750015f, 0.18435170f, -0.06626087f, -0.09335779f, 
    0.00436485f, 0.00969098f, -0.08313429f, 0.06809632f, 0.13495225f, -0.02720041f, -0.09085136f, -0.16318865f, 
    0.16578642f, 0.09698061f, -0.01322438f, -0.01026320f, -0.14666770f, 0.00066680f, 0.03655076f, -0.03292437f, 
    0.07226562f, 0.00533657f, 0.03954712f, -0.03825479f, 0.07645568f, -0.01117514f, 0.13191713f, 0.10140461f, 
    0.05636167f, -0.06259651f, 0.07040460f, -0.03485072f, 0.03196774f, 0.00360771f, -0.11162731f, -0.01332938f, 
    0.18074715f, 0.09052370f, -0.12266185f, -0.05931627f, -0.06391470f, 0.03996371f, 0.10326126f, -0.04487894f, 
    -0.05068093f, 0.08515995f, 0.14712361f, 0.08594095f, 0.02719766f, -0.09272248f, 0.02501792f, 0.08559465f, 
    -0.00424789f, -0.00057854f, 0.01386508f, -0.04430561f, 0.05640559f, -0.11401115f, -0.18277143f, 0.11542122f, 
    -0.30057311f, 0.03673403f, 0.05238248f, -0.16224757f, 0.16126919f, -0.06184344f, -0.02970644f, -0.06691964f, 
    -0.07790140f, -0.08451435f, -0.06248202f, -0.04196286f, 0.24692538f, -0.09537565f, -0.06393892f, 0.02941285f, 
    -0.08451392f, 0.03034468f, 0.15800348f, -0.04657483f, 0.03541848f, 0.09243193f, 0.04285564f, -0.09340837f, 
    0.23691553f, 0.22136682f, -0.14376962f, -0.07295325f, 0.04750745f, 0.05634532f, 0.08883192f, 0.07779741f, 
    0.03699807f, -0.07739405f, 0.09098370f, 0.03065426f, -0.24346989f, -0.00863160f, 0.02609900f, 0.01464046f, 
    -0.01511667f, 0.07591666f, 0.04489399f, -0.01139577f, -0.02798463f, 0.06192462f, -0.01636464f, 0.13827614f, 
    -0.23527764f, -0.02639630f, -0.16105552f, -0.24455364f, 0.02982473f, 0.01165606f, 0.05474388f, 0.03708773f, 
    0.11103634f, 0.10718816f, 0.09225749f, 0.06479456f, -0.05943344f, -0.02992441f, -0.04473487f, 0.11598280f, 
    0.01687332f, 0.06003672f, -0.13798138f, -0.03704767f, -0.04660461f, 0.05642753f, -0.06729619f, -0.06554089f, 
    0.11535632f, -0.03991461f, -0.06180896f, -0.09495192f, -0.17564428f, -0.03955276f, 0.08070705f, -0.01612826f, 
    0.04097581f, -0.15477394f, 0.01868522f, -0.16935670f, 0.13559362f, -0.00555821f, -0.04989840f, -0.07136068f, 
    0.04125075f, 0.08051030f, 0.08198548f, 0.03928605f, -0.08627804f, -0.16545133f, -0.02224067f, 0.00813935f, 
    0.02132645f, 0.09982094f, -0.13627845f, 0.08632331f, 0.04357084f, 0.02224256f, 0.06709324f, -0.06932689f, 
    0.07705662f, -0.05943225f, 0.02296143f, -0.12539656f, 0.18013996f, 0.08048204f, -0.00428979f, 0.11778595f, 
    -0.08150082f, 0.05848084f, 0.01833708f, -0.06548533f, 0.05237993f, -0.01000331f, -0.00002874f, -0.04935901f, 
    -0.03524397f, -0.04443411f, -0.16037641f, 0.15380013f, -0.04069848f, 0.01140794f, 0.00292497f, -0.04028612f, 
    0.06403881f, -0.01323048f, -0.00294414f, -0.07611190f, 0.02384400f, 0.11921405f, -0.03394757f, 0.06140575f, 
    -0.04302334f, -0.01602361f, 0.00861853f, -0.07085387f, 0.02639181f, -0.08085261f, 0.07943946f, -0.07744501f, 
    -0.21950409f, -0.18887340f, -0.12765509f, -0.24002959f, -0.05147323f, -0.05710895f, -0.08501320f, 0.07737172f, 
    -0.00955530f, -0.00843902f, 0.06256378f, -0.09270041f, 0.23435712f, -0.04498774f, -0.19204406f, 0.06573462f, 
    0.04803929f, 0.07131644f, -0.00712735f, 0.13173626f, 0.03582416f, 0.00285017f, 0.06516366f, -0.01690696f, 
    -0.00562727f, 0.09775346f, -0.12567560f, 0.01332103f, 0.13107708f, -0.04572488f, -0.02492674f, 0.08200911f, 
    0.06068511f, 0.05769877f, 0.02984154f, -0.02921074f, -0.01877275f, -0.10394012f, -0.19802225f, -0.04219918f, 
    0.08841673f, 0.00549899f, 0.04679123f, -0.02708703f, -0.12217971f, -0.02918116f, -0.07208806f, 0.09323549f, 
    -0.08373094f, 0.29224610f, -0.09788052f, -0.09337381f, 0.00699661f, 0.02960154f, -0.02578456f, 0.06188352f, 
    -0.06814864f, 0.07013706f, -0.04009328f, -0.04856266f, 0.18215953f, -0.14963467f, -0.02024675f, 0.15459736f, 
    0.11629505f, 0.05707166f, -0.02199806f, -0.03375426f, 0.11454665f, 0.01433363f, -0.04502585f, -0.03506389f, 
    0.02762782f, 0.12613744f, -0.02792120f, -0.03474193f, -0.14747089f, -0.05291599f, 0.02470515f, -0.15257090f, 
    0.00765563f, 0.01315945f, 0.02661899f, -0.07495525f, 0.28793555f, -0.08757037f, -0.04401822f, 0.06065803f, 
    -0.09075906f, -0.00608929f, -0.15198754f, 0.02648632f, 0.00218745f, 0.03837723f, -0.03861020f, -0.01161845f, 
    -0.04666753f, -0.19851229f, 0.05345583f, -0.02132987f, 0.01352505f, -0.03264252f, -0.07399872f, 0.00424485f, 
    -0.01260978f, -0.06399345f, -0.07492677f, -0.01574367f, -0.05734073f, 0.05582644f, -0.02751990f, 0.00488059f, 
    0.00903472f, 0.03635326f, 0.05018871f, -0.07958990f, -0.00980345f, -0.06573024f, 0.05027246f, -0.11233958f, 
    0.22642563f, -0.02856144f, -0.03760812f, -0.00454081f, 0.15995230f, -0.03671239f, -0.13084191f, 0.04082373f, 
    -0.02809160f, 0.07140179f, 0.01881733f, 0.00123677f, -0.06256672f, 0.01283849f, -0.11426900f, -0.28103545f, 
    0.03904143f, 0.08123983f, -0.03430635f, -0.04733002f, 0.08832895f, -0.04335804f, -0.13270079f, -0.04462293f, 
    -0.25348711f, 0.11410477f, -0.09916968f, -0.11376575f, -0.03575525f, 0.02603987f, -0.00934909f, -0.16955045f, 
    -0.00244984f, 0.00154807f, -0.08494806f, -0.16466716f, -0.23861168f, -0.25235340f, 0.04061909f, -0.14643851f, 
    0.07771087f, -0.00782187f, 0.02942307f, 0.11432825f, 0.00733925f, 0.04269407f, 0.01170896f, -0.06545286f, 
    0.36684602f, -0.16716397f, 0.04253664f, 0.15702955f, -0.00785089f, 0.02296891f, -0.05035423f, 0.02933108f, 
    0.03437116f, -0.13783565f, 0.04522584f, 0.08680364f, -0.09790688f, 0.04627573f, -0.04748556f, 0.12979938f, 
    0.07037538f, 0.03947879f, 0.07540527f, -0.00014772f, 0.00560761f, -0.00254334f, -0.09130013f, -0.15570733f, 
    -0.03111326f, -0.24352849f, -0.05746075f, -0.01695132f, -0.03054489f, -0.00428292f, -0.01358406f, 0.10476676f, 
    -0.11003838f, -0.03949077f, 0.07950334f, -0.03461974f, -0.19214435f, 0.09743538f, 0.00562176f, -0.17618205f, 
    -0.00110481f, 0.02656371f, -0.07308899f, 0.01004377f, 0.11690257f, -0.03653272f, -0.01841489f, 0.00709010f, 
    -0.32825032f, 0.14485125f, -0.05682091f, -0.13231660f, 0.08393670f, -0.00574109f, 0.04479452f, -0.05279929f, 
    -0.02126771f, -0.00811982f, 0.03206029f, -0.00785416f, 0.02128091f, 0.06637841f, 0.04076323f, -0.06993707f, 
    -0.15858373f, -0.03545718f, -0.08897159f, 0.00804870f, 0.03665604f, 0.00714617f, 0.03407802f, -0.08123355f, 
    -0.07219291f, -0.00514308f, 0.04920710f, 0.06621560f, -0.02795421f, 0.08081120f, 0.05737494f, 0.09059469f, 
    0.01556213f, -0.05548770f, -0.06221781f, 0.16933334f, -0.44223970f, 0.15945415f, -0.05927256f, 0.12510315f, 
    0.16253449f, -0.07856450f, 0.10954136f, -0.10877750f, 0.07060207f, -0.06165425f, 0.01788423f, 0.06491471f, 
    0.31860217f, -0.13256100f, -0.14832915f, 0.02251246f, 0.01067217f, 0.00475329f, -0.10718819f, 0.06827339f, 
    0.04400383f, 0.04817907f, 0.07234965f, 0.02499493f, 0.21307622f, -0.31785968f, -0.16980088f, 0.04989627f, 
    -0.08702578f, 0.06422734f, -0.00794025f, -0.08471946f, 0.00161399f, 0.05357713f, -0.06625652f, 0.03559782f, 
    0.54746360f, 0.08636919f, -0.13111661f, -0.30793750f, -0.00734357f, 0.02280545f, 0.03597590f, 0.08076449f, 
    -0.03506061f, -0.05683008f, -0.13204744f, 0.09708223f, 0.15899712f, -0.13090824f, 0.10586369f, 0.06688966f, 
    0.03003410f, -0.02476013f, -0.03353845f, 0.03211632f, -0.00134081f, -0.05912841f, -0.00416373f, -0.00652869f, 
    -0.36780518f, 0.23751415f, -0.19806577f, -0.02517280f, 0.10819498f, 0.01705274f, -0.03478530f, 0.19165958f, 
    -0.00995455f, -0.02938110f, -0.10047709f, -0.13185064f, -0.07820913f, 0.13278341f, 0.07537039f, 0.13176446f, 
    -0.09129419f, -0.00982083f, -0.05653667f, 0.03136798f, 0.02848998f, -0.11334488f, 0.02939742f, 0.04482848f, 
    0.36645275f, 0.08500857f, -0.06544834f, 0.03228512f, -0.02925363f, 0.01197645f, -0.03216102f, -0.02755035f, 
    0.00852021f, 0.08298672f, 0.07695932f, 0.03866221f, 0.20099585f, 0.00649854f, -0.10107248f, 0.00659377f, 
    0.03895488f, 0.01985864f, 0.07910412f, 0.00708549f, -0.03839029f, -0.10271192f, 0.04553594f, 0.07460050f, 
    0.26653150f, -0.11007715f, -0.11420922f, -0.03617268f, 0.05449592f, 0.02265175f, -0.02501635f, 0.01072875f, 
    -0.02235734f, -0.08758205f, -0.07648789f, -0.00222748f, -0.06997280f, 0.16918373f, 0.01030852f, -0.05758977f, 
    -0.02271278f, 0.17494980f, 0.01175929f, -0.16617073f, 0.07977479f, 0.01261032f, -0.15939218f, -0.10330021f, 
    0.09517033f, 0.04527084f, -0.16116250f, 0.27619550f, 0.14360727f, -0.21896623f, -0.02758535f, -0.04656966f, 
    -0.05348010f, 0.02599399f, 0.02539648f, 0.02867616f, -0.17094092f, -0.26958206f, -0.06309775f, -0.18128623f, 
    -0.02244558f, 0.02816646f, -0.03381608f, 0.07609890f, -0.08976190f, -0.10532860f, -0.05831890f, -0.04878541f, 
    0.18588586f, -0.13634305f, 0.01869516f, 0.02570156f, 0.03823731f, -0.06510656f, -0.01828970f, -0.00878798f, 
    -0.01367859f, -0.00674655f, -0.15004805f, -0.15839155f, 0.03117834f, 0.36093834f, -0.11528870f, 0.11594340f, 
    -0.03756809f, -0.05831183f, -0.11233808f, -0.11310734f, -0.02143913f, 0.05219921f, 0.03601547f, 0.13348417f, 
    -0.21007343f, -0.12524644f, 0.03517298f, 0.18133257f, 0.01749126f, 0.13859086f, -0.13569863f, 0.08059359f, 
    -0.01556417f, 0.02767886f, 0.18377358f, 0.04452769f, 0.25781095f, 0.01238701f, -0.27763176f, -0.07058988f, 
    0.09919316f, -0.11056179f, 0.01958225f, 0.04711467f, 0.11445762f, 0.09124883f, -0.00204188f, 0.06614608f, 
    0.15350570f, -0.17604917f, 0.04123617f, -0.07958921f, 0.05008063f, 0.01549476f, 0.01333821f, 0.09983110f, 
    0.08258416f, 0.09517631f, -0.00882001f, 0.01242864f, -0.12857620f, 0.00734239f, 0.00699677f, -0.12576503f, 
    -0.06745346f, 0.06448101f, -0.01084598f, 0.05473757f, -0.01704544f, -0.04613694f, 0.02502489f, -0.06396452f, 
    0.11393337f, 0.09318934f, -0.08717470f, -0.03673454f, -0.09185193f, 0.03625164f, 0.01208765f, -0.21815149f, 
    -0.03468931f, 0.04328907f, -0.10069430f, -0.13214901f, 0.05822687f, 0.03041276f, 0.04836900f, 0.02915486f, 
    0.05265341f, 0.04195473f, -0.03607801f, -0.08931949f, 0.02188250f, 0.01929757f, 0.05763668f, 0.01407039f, 
    0.13049802f, -0.08747849f, -0.05383344f, -0.06677489f, -0.07432661f, 0.01497387f, -0.00686578f, -0.00774201f, 
    0.03520694f, -0.02547146f, -0.05874924f, -0.02124205f, 0.27125916f, 0.09457816f, 0.04917054f, -0.08265793f, 
    -0.09408395f, 0.02986979f, 0.01926418f, -0.04708343f, 0.02564716f, 0.06936844f, 0.04251562f, -0.08418653f, 
    -0.11583497f, -0.00213856f, 0.01602386f, 0.08370791f, 0.02508209f, -0.01753475f, -0.01847023f, 0.13870032f, 
    0.03587791f, -0.02994759f, 0.05846304f, 0.16058938f, -0.12363453f, -0.02441128f, -0.03729802f, 0.03991536f, 
    -0.08842905f, 0.04229973f, 0.04318585f, 0.09855567f, -0.12545446f, 0.11425311f, 0.00388809f, -0.13792968f, 
    -0.01446020f, 0.10034769f, -0.11668789f, -0.11365905f, -0.08130997f, -0.08685485f, 0.01736467f, 0.04020751f, 
    0.02763177f, 0.02334812f, -0.07971727f, -0.06245816f, -0.36404324f, -0.28902936f, 0.06494757f, -0.20425704f, 
    -0.10930101f, 0.09000805f, -0.05339073f, 0.14267373f, -0.07764889f, 0.04692322f, 0.02373535f, 0.17028046f, 
    -0.02208501f, 0.09901176f, 0.03867677f, 0.04577097f, -0.11714412f, -0.09853601f, -0.05660816f, 0.00825739f, 
    -0.12309232f, 0.04021408f, 0.00639716f, -0.17873695f, 0.12299342f, -0.26605657f, 0.06463820f, -0.05983883f, 
    0.05874208f, -0.07687561f, 0.00894176f, 0.07596008f, -0.01432713f, -0.02286641f, 0.08349727f, 0.07734811f, 
    0.08500171f, 0.06283390f, -0.06048587f, 0.08687496f, -0.05743454f, -0.03688313f, -0.01660477f, 0.08525840f, 
    -0.09876632f, -0.11080579f, 0.00309815f, -0.08727656f, -0.00836894f, 0.04474444f, 0.00605299f, 0.04641858f, 
    0.00883633f, -0.00845163f, -0.06212530f, 0.03847334f, 0.09724326f, 0.00894306f, 0.02326007f, -0.02845978f, 
    -0.25540963f, 0.00291370f, 0.00328568f, -0.03557760f, -0.07093360f, 0.06424221f, -0.00409992f, -0.01619893f, 
    0.00007958f, 0.01643717f, -0.00137281f, -0.02357618f, -0.49311316f, 0.15949929f, -0.02305694f, 0.07659946f, 
    0.12301105f, -0.02233452f, -0.05185657f, 0.01835426f, 0.03612663f, -0.01815739f, 0.03288006f, 0.05327861f, 
    -0.04768406f, -0.07031606f, 0.05404803f, 0.37223321f, -0.02005407f, -0.00464493f, 0.05766710f, 0.01243529f, 
    -0.07636652f, -0.06561283f, -0.01747707f, 0.00484059f, -0.01224885f, 0.16287434f, 0.08239464f, 0.06736347f, 
    -0.06152906f, 0.04184097f, -0.16646878f, -0.03402330f, -0.08606780f, 0.05268685f, 0.06058051f, -0.09704254f, 
    0.24811640f, -0.21878494f, 0.00993632f, 0.25010213f, -0.00558313f, -0.05178785f, 0.00141990f, -0.06439053f, 
    -0.04906266f, 0.04279191f, -0.05349296f, -0.05874244f, 0.17299497f, -0.02331670f, -0.04742674f, 0.02993343f, 
    -0.13328314f, 0.00865859f, 0.07349443f, 0.00492494f, 0.09363244f, -0.02070508f, -0.05101548f, 0.04149226f, 
    -0.06912900f, 0.00889850f, -0.15225415f, 0.08022526f, 0.08177157f, -0.09934902f, -0.06634928f, -0.06567590f, 
    0.01636336f, 0.01096434f, 0.00172064f, 0.05625313f, 0.03483385f, 0.13495430f, -0.14836945f, 0.03260248f, 
    0.16989522f, -0.03858529f, 0.02903909f, -0.13591987f, -0.03352762f, 0.04036254f, -0.00530752f, 0.04002524f, 
    0.02870097f, -0.28463155f, -0.01002245f, -0.09636427f, -0.05812140f, 0.02250260f, 0.07786019f, 0.08748034f, 
    0.00654654f, 0.05928691f, -0.05853904f, -0.02647798f, -0.01944752f, -0.11495662f, 0.09525538f, 0.04776869f, 
    -0.09181071f, -0.01887503f, 0.06858422f, -0.00215946f, 0.01236039f, 0.12113587f, 0.01184355f, 0.09617849f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01648430f, 0.02943639f, -0.07399710f, -0.00926106f, 0.03186084f, -0.00922296f, 0.01157995f, -0.04870216f, 
    -0.00499911f, 0.03928026f, 0.09340594f, 0.01049572f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
