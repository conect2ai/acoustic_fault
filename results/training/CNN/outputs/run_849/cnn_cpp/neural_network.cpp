#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.39719978f, 0.82924402f, 0.33946601f, 0.88588482f, 0.42782542f, 0.20033541f, -0.21944937f, -0.76749671f, 
    0.00675927f, -0.12364364f, 0.11609229f, 0.31752133f, 0.07840146f, 0.27585512f, -0.45590898f, 0.03106064f, 
    0.26589459f, 0.36523601f, -0.23787880f, -0.02989677f, -0.39054525f, 0.06328524f, -0.22673671f, -0.04188205f, 
    -0.22392967f, 0.16167392f, -0.43051356f, 0.54993635f, -0.19988805f, 0.81769180f, 0.49913269f, -0.45926440f, 
    -0.35628283f, -0.32484996f, -0.46320835f, 0.31548864f, 0.59706235f, 0.05735366f, -0.05529526f, 0.28831393f, 
    0.31182271f, 0.17570832f, -0.21638687f, -0.03586330f, 0.22407621f, 0.08190213f, 0.13699670f, -0.15280321f, 
    0.35997382f, 0.32889012f, 0.60981899f, 0.66565388f, -0.19039197f, 0.30289814f, 1.08432853f, 0.00127977f, 
    0.18582647f, 0.12690122f, 0.58715373f, 0.21121539f, -0.19931500f, -0.14442123f, 0.02147119f, -0.00484313f, 
    -0.20411302f, -0.14389096f, 0.19545959f, -0.06187436f, 0.23305421f, -0.17702867f, 0.17304775f, -0.11804813f, 
    -0.06718288f, 0.10287878f, 0.28881294f, 0.18290442f, -0.61001045f, 0.35983297f, -0.19132012f, -0.51341820f, 
    -0.70608771f, 0.45174128f, -0.24987647f, 0.19122791f, -0.16288288f, -0.22251508f, -0.09996802f, -0.30835557f, 
    -0.23382892f, -0.16185389f, -0.36358243f, -0.44351554f, -0.07421070f, -0.33920565f, 0.07910299f, 0.05618731f, 
    -0.13335741f, -0.06087395f, -0.05401509f, 0.45769429f, -0.34997886f, 0.20618822f, 0.07303220f, 0.67662233f, 
    0.85810351f, 0.62291050f, 0.73222083f, 0.84600818f, -0.16360639f, 0.12296363f, -0.03660516f, -0.35109854f, 
    0.02772265f, -0.30253148f, 0.18234567f, -0.44979742f, -0.21111707f, -0.07836457f, -0.11543547f, 0.00619900f, 
    0.40302455f, -0.14333820f, -0.17468908f, 0.09544937f, -0.05039104f, 0.50831902f, -1.04608583f, 0.61241019f, 
    0.47331199f, -0.18498066f, 0.46959138f, 0.27755582f, 0.50353897f, -0.00800090f, -0.35514209f, -0.35206994f, 
    -0.10088555f, -0.21597289f, 0.04538536f, -0.40392035f, -0.43661359f, -0.03188737f, 0.32788557f, 0.31931385f, 
    0.11533450f, 0.10137233f, 0.24137141f, -0.21177432f, 0.00033525f, -0.34783578f, 0.68992358f, 0.19227816f, 
    -0.84218943f, -0.40833956f, -0.78884238f, 0.22219041f, 0.35368556f, 0.14387096f, -0.15179546f, -0.03138482f, 
    0.33550262f, 0.30497292f, -0.34997126f, 0.09136765f, -0.07562871f, 0.03568571f, 0.18335514f, 0.09207406f, 
    0.02786615f, -0.12026519f, -0.25630766f, 0.27342167f, 0.28835878f, 0.04838282f, 0.20594198f, 0.40211475f, 
    0.90322721f, 0.71174359f, 0.45793268f, -0.09460886f, -0.56882089f, 0.72375250f, -0.15330043f, -0.08166372f, 
    0.21771796f, -0.12396123f, 0.12511997f, -0.05935235f, 0.35717443f, 0.36817485f, -0.22848111f, -0.02101887f, 
    -0.15016256f, 0.07929120f, -0.00374615f, 0.20716901f, 0.17311391f, 0.29383907f, 0.33920416f, 0.23286150f, 
    1.07177925f, -0.00732078f, 0.33607158f, 0.63703227f, -0.13303016f, 0.68325394f, 0.31467912f, -0.11545074f, 
    0.26877597f, -0.27200845f, 0.16310185f, -0.02368618f, -0.02251242f, 0.04284208f, 0.15627618f, 0.25391573f, 
    -0.17558280f, 0.18742101f, -0.19094530f, 0.17664157f, -0.45008612f, -0.15684967f, 0.13802898f, 0.02191859f, 
    -0.07595871f, 0.42014799f, -0.62747598f, -0.27128857f, -0.54161882f, -0.48921838f, 0.40301362f, -0.33355042f, 
    -0.31354052f, -0.40007168f, -0.21647635f, 0.05060536f, -0.58327395f, 0.00500529f, -0.38979903f, -0.22548813f, 
    -0.23548092f, 0.26927516f, -0.23264314f, 0.23713151f, -0.06597452f, 0.22273612f, 0.35281840f, -0.20438746f, 
    -0.41934660f, -0.32879010f, 0.69888020f, 0.30179578f, 0.10486112f, -0.19844247f, 0.76330084f, -0.41654843f, 
    -0.41580874f, 0.48732150f, 0.08187746f, 0.13442817f, 0.09579380f, -0.03110992f, 0.07061023f, -0.40194276f, 
    0.17020138f, 0.08331587f, 0.09325694f, 0.14839341f, 0.32401645f, 0.46447730f, -0.05883071f, -0.15505216f, 
    -0.05109604f, -0.38207126f, 0.14248376f, -0.69419211f, -0.66182667f, -0.67114574f, 0.33848190f, 0.49596617f, 
    -0.04737545f, 0.35158864f, -0.00878572f, 0.20606484f, -0.44928348f, -0.32286680f, -0.16986907f, -0.61355859f, 
    -0.34429273f, 0.03490420f, -0.15869182f, -0.07761216f, 0.44259447f, -0.20718132f, -0.23769437f, 0.28303349f, 
    0.36568162f, -0.17182563f, 0.15853702f, 0.10930439f, -0.03890049f, -0.09791366f, 0.05284901f, -0.59258807f, 
    -0.06241279f, 0.93372238f, -0.37232009f, 0.09456107f, 0.04978275f, 0.23875549f, 0.60606354f, -0.22063456f, 
    0.12731703f, 0.45755389f, -0.22744921f, 0.08920205f, -0.20605849f, -0.07618377f, -0.13227846f, 0.10479669f, 
    -0.15238255f, 0.18032543f, -0.12217418f, 0.10313543f, -0.31682298f, -0.98287833f, -0.21663184f, 0.53768128f, 
    0.31420889f, -0.61910325f, 0.52563697f, 0.18433343f, 0.33341655f, -0.33203030f, -0.42945343f, -0.33553541f, 
    0.36880612f, -0.21855021f, 0.34777027f, 0.28756341f, -0.19204041f, 0.05658437f, 0.00051177f, -0.34500039f, 
    0.11540503f, 0.15691960f, 0.01169249f, 0.42151806f, 0.29321483f, -0.28436717f, -1.03543472f, 0.37471089f, 
    0.33148161f, -0.48695040f, -0.39286584f, 0.14638679f, 0.86799318f, -0.65600663f, -0.14941676f, 0.52830762f, 
    -0.36670119f, 0.15215789f, 0.21627226f, -0.53136170f, 0.10608620f, -0.07426438f, -0.19649029f, -0.10457714f, 
    -0.14575484f, -0.15563725f, 0.22528224f, 0.03570898f, 0.08613938f, 0.07383001f, 0.23330612f, -0.42824224f, 
    0.23216221f, 0.06119081f, 0.32662782f, -0.56774843f, -0.69302440f, -0.46928185f, 0.12588391f, 0.34877232f, 
    0.09369095f, 0.38131353f, 0.35415649f, 0.36491221f, 0.31870520f, -0.17560749f, 0.30744407f, 0.14708392f, 
    -0.13384876f, -0.14092194f, -0.08647946f, 0.25564206f, 0.02370767f, 0.30187339f, -0.11811173f, -0.14519672f, 
    -0.37174630f, 0.81760859f, -0.59230524f, -0.53225952f, -0.03571585f, 0.05347393f, 0.46172670f, 0.35386953f, 
    0.16072048f, -0.49696830f, -0.21143794f, 0.17841300f, -0.08519413f, -0.09525193f, -0.03275225f, 0.34716594f, 
    0.06995383f, -0.05660352f, 0.02797066f, -0.51855934f, 0.31208155f, 0.09065232f, 0.13255243f, 0.00863293f, 
    0.41654146f, 0.58380985f, 0.69172353f, 0.75379270f, 0.12764606f, -0.21190916f, -0.75591946f, 0.43807626f, 
    -0.33285514f, -0.33533919f, 0.09489216f, -0.25274679f, 0.16558692f, -0.01322257f, 0.45085323f, -0.08930933f, 
    -0.24573532f, -0.37023836f, -0.18934104f, -0.08804077f, -0.18992068f, -0.44471419f, 0.15821220f, -0.12358510f, 
    0.09894250f, 0.08157682f, 0.16934820f, -0.23918885f, -0.31131303f, -0.52390081f, 0.27340719f, 0.43805274f, 
    0.43419290f, 0.67362475f, 0.42532638f, 0.51934367f, 0.27767465f, 0.12609854f, -0.51115316f, -0.03987507f, 
    -0.14623123f, 0.44176561f, 0.14369611f, -0.08490246f, 0.37584692f, -0.08435965f, -0.20549990f, 0.10595166f, 
    -0.04012320f, 0.17780797f, 0.13608305f, -0.70528674f, -0.83727717f, -0.67493993f, -0.53209507f, 0.05173898f, 
    -0.43082911f, -0.29681373f, 0.06633946f, -0.17625567f, 0.30157417f, 0.24631421f, -0.10545984f, 0.20369542f, 
    0.21134897f, 0.09563880f, -0.10367166f, 0.25986168f, -0.07210359f, 0.22619604f, 0.05104512f, 0.16478802f, 
    -0.41555509f, 0.29818022f, 0.14133249f, -0.08028205f, 0.39432362f, -0.52584237f, 0.49773952f, 0.22767220f, 
    0.68447161f, 0.51801753f, 0.35836774f, 0.16428907f, 0.36582106f, -0.04177375f, -0.27345306f, 0.16817117f, 
    -0.10961669f, 0.18484947f, 0.21828520f, 0.26184672f, 0.17546880f, -0.32274336f, 0.40017053f, 0.63805193f, 
    -0.28085467f, -0.19924162f, -0.00248588f, -0.30281258f, 0.07244648f, -0.95543796f, -0.30002296f, -0.37561023f, 
    0.46269289f, 0.51522130f, 0.56019861f, 0.04050678f, -0.30929819f, 0.50652701f, -0.73732227f, 0.29053724f, 
    0.11155759f, -0.11763219f, 0.39974254f, -0.26004523f, 0.01738710f, 0.05036043f, 0.16845104f, -0.26741931f, 
    -0.06642775f, -0.16654798f, -0.08427239f, -0.09537008f, 0.00295955f, 0.16130941f, 1.00652826f, -0.10706341f, 
    0.87087482f, 0.03150919f, -0.18803026f, 0.19844557f, -0.09952509f, -0.44586796f, 0.31481975f, 0.00739949f, 
    0.17088866f, 0.34343779f, -0.24351689f, -0.01066539f, -0.18681487f, -0.13393046f, -0.46390423f, 0.04725954f, 
    0.08414355f, -0.07256439f, 0.12815860f, 0.41115776f, -0.05667501f, -0.08974500f, 0.24430624f, 0.82118207f, 
    0.97491485f, -0.10261619f, -0.55775213f, -0.55129588f, 0.42010179f, -0.41137534f, -0.64941382f, -0.33748317f, 
    0.18192732f, 0.20780124f, -0.22220579f, 0.43124551f, 0.19690968f, -0.24375692f, -0.01605510f, 0.16960868f, 
    0.04002125f, -0.02670968f, -0.19077012f, -0.14851704f, -0.13659735f, 0.09538054f, -0.21340458f, 0.34882307f, 
    -0.16476090f, -0.52229697f, 0.78020531f, 0.32429102f, -0.13892946f, 0.23566386f, 0.39677507f, 0.56802928f, 
    0.52857035f, 0.54531461f, -0.32091874f, 0.26720205f, 0.10322582f, 0.22918984f, -0.22433053f, -0.06966630f, 
    -0.50280148f, -0.32863972f, -0.22836898f, -0.06768212f, 0.36445335f, -0.08837774f, 0.02629485f, 0.05731744f, 
    -0.30308503f, 0.58318293f, 0.59032744f, 0.83700293f, 0.73339647f, 0.26397291f, -0.15463014f, -0.41146225f, 
    -0.54768366f, -0.55458957f, -0.11283100f, -0.15241443f, 0.21377225f, 0.09813550f, -0.03679023f, -0.08169974f, 
    0.29264310f, 0.31051505f, 0.25166020f, -0.29150030f, 0.25898585f, -0.04244499f, 0.12200294f, -0.03065323f, 
    0.02660284f, 0.33910236f, 0.06535520f, 0.58356351f, 0.65698266f, 0.10044248f, -0.33298197f, -0.07922500f, 
    -0.22473484f, -0.01775781f, 0.38458896f, 0.60605627f, -0.59290594f, -0.33020732f, -0.35987821f, 0.20014486f, 
    0.47607508f, 0.24874082f, 0.19896726f, -0.16079904f, -0.18945858f, 0.04970279f, 0.00468891f, -0.09715827f, 
    -0.05662249f, -0.33131632f, 0.57556796f, -0.39282560f, -1.08843136f, -0.63912719f, 0.07173566f, 0.37893468f, 
    -0.70028770f, 0.65463054f, 0.50442064f, -0.66465652f, 0.27264073f, 0.40103278f, 0.09237834f, -0.19658326f, 
    -0.26593250f, 0.29553223f, 0.08594128f, 0.26414269f, -0.19205241f, 0.06484760f, -0.13452967f, 0.03709507f, 
    -0.24501000f, 0.06372536f, -0.07757045f, 0.13864888f, 0.27070406f, -0.53796464f, 0.62114459f, 0.26746020f, 
    0.38930622f, -0.71272945f, 0.11426373f, -0.49618730f, -0.16115119f, 0.27762702f, 0.16694367f, 0.38558778f, 
    0.06347634f, 0.28175440f, -0.01067629f, -0.32309511f, -0.09103233f, -0.41069594f, 0.22476508f, -0.01387114f, 
    0.21378030f, 0.17033364f, -0.05456915f, 0.03890493f, -0.03863265f, -0.33796737f, -0.71733361f, -0.20525502f, 
    0.05776334f, -0.38034463f, -0.14992104f, -0.35008937f, 0.34680584f, -0.31771916f, -0.25669146f, 0.10813215f, 
    0.44873992f, 0.32294485f, 0.43228710f, 0.46786207f, 0.27621794f, 0.09117647f, -0.02049236f, -0.09929021f, 
    -0.06494583f, -0.02737595f, -0.43760917f, -0.05449507f, -0.36995971f, 0.09544389f, -0.61930871f, -0.45418251f, 
    -0.73829764f, -0.40592951f, -0.61170763f, 0.21304215f, 0.30487889f, 0.23653384f, 0.25090107f, 0.43626475f, 
    0.11983412f, -0.33125517f, -0.11364251f, -0.00061297f, 0.19518334f, 0.04494095f, -0.12999314f, 0.22721981f, 
    -0.12787667f, -0.32536161f, 0.11773563f, -0.14684282f, 0.17566405f, -0.09342144f, 0.27818730f, -0.35391057f, 
    -0.64718854f, 0.08312631f, -0.43410361f, -0.45212948f, -0.46675104f, 0.62604940f, 0.56979328f, -0.10484991f, 
    0.09393895f, -0.18425219f, 0.02950954f, -0.02815834f, -0.00749020f, 0.15536505f, 0.19063933f, -0.33456248f, 
    -0.22511259f, 0.00620940f, 0.11233409f, 0.26564720f, 0.38813931f, 0.47832870f, 0.25093272f, 0.27782002f, 
    -0.70438570f, 0.57695478f, 0.20916520f, -0.59016186f, -0.03206546f, 0.11723089f, -0.32572868f, -0.38323858f, 
    -0.38804302f, -0.14009629f, 0.25354013f, -0.18362859f, -0.09081808f, -0.19801925f, 0.09858198f, -0.35643673f, 
    -0.17679815f, -0.41811162f, -0.64952695f, -0.44083720f, -0.03504424f, 0.36879879f, 0.14112094f, -0.19935808f, 
    -0.10841283f, -1.22266829f, 0.43095279f, 0.74132878f, 0.16617306f, -0.17497462f, -0.51463115f, 0.41014478f, 
    0.13916402f, 0.43976858f, -0.35304174f, 0.01875409f, 0.04301495f, 0.11427397f, -0.07059690f, -0.07457674f, 
    0.30799928f, 0.20351113f, 0.21097967f, -0.08026719f, -0.30722421f, 0.04110862f, 0.08438578f, -0.43994293f, 
    0.05635593f, 0.10312881f, 0.04483964f, -0.93863302f, -0.81619233f, 0.36346436f, -0.34059283f, -0.59448504f, 
    0.93089360f, 0.16693021f, 0.05189508f, 0.22601070f, 0.38624954f, 0.08141701f, -0.00533664f, 0.17995141f, 
    0.13049899f, -0.19377147f, -0.05438847f, 0.13397904f, -0.04078158f, 0.01813172f, 0.03688456f, 0.06598301f, 
    0.22896986f, -0.01937298f, 0.21699826f, 0.64277530f, 0.49467486f, -0.36236814f, -0.65700144f, 0.04278335f, 
    -0.21543051f, -0.85198081f, 0.27433345f, -0.49516547f, -0.56035918f, -0.07385615f, 0.23788595f, 0.23578286f, 
    0.35951748f, 0.09140518f, 0.19755378f, -0.01373708f, -0.22838427f, 0.28867963f, 0.58012313f, 0.12054412f, 
    0.20627387f, 0.09159227f, -0.26320654f, -0.22723088f, -0.33213681f, 0.76009399f, 0.63694644f, 0.15592392f, 
    -0.31107157f, -0.56782991f, 0.15261522f, -0.00866172f, -0.24292165f, -0.39911756f, 0.34885556f, 0.03954242f, 
    -0.33332172f, -0.16324447f, -0.06145046f, 0.18246834f, 0.26438591f, -0.17392497f, 0.39144963f, -0.27677241f, 
    0.00027708f, -0.39817402f, -0.08738078f, -0.12935169f, 0.28574422f, 0.88476175f, -0.48635411f, 0.24334766f, 
    -0.74449897f, 0.63753510f, 0.57335943f, 0.17959499f, 0.01801445f, -0.72339296f, -0.04117334f, -0.01049385f, 
    0.37115324f, 0.28068271f, 0.35166615f, -0.21401390f, -0.34349522f, -0.05034336f, -0.13787423f, 0.04987742f, 
    -0.35118240f, -0.07968254f, -0.17604369f, -0.11324944f, -0.16281149f, 0.12583226f, 0.44763771f, 0.16137308f, 
    0.20053393f, -0.20246093f, 0.02040790f, -0.34528846f, -0.35701963f, -0.21817924f, 0.60365564f, 0.40158492f, 
    -0.13289328f, -0.59719211f, -0.36942983f, 0.04098619f, 0.13275985f, 0.14155120f, 0.28141868f, 0.13053073f, 
    0.18048504f, 0.35461646f, 0.34592065f, -0.08107151f, 0.23659459f, 0.33769313f, -0.00210786f, -0.95191103f, 
    0.30300507f, -0.31203514f, 0.43570861f, -0.92585248f, 0.56762516f, 0.41935697f, -0.46740183f, 0.12782043f, 
    -0.29902929f, -0.37259388f, -0.36031401f, 0.00827470f, -0.00426734f, 0.08669918f, -0.00351541f, -0.13582234f, 
    -0.13072090f, -0.23942681f, -0.16158496f, -0.15624651f, 0.14987473f, 0.34788311f, 0.26684597f, 0.13911061f, 
    -0.76816469f, -0.49105003f, -0.25819853f, -0.40636405f, -0.08545667f, -0.37482458f, -0.41525725f, -0.07318683f, 
    -0.44581860f, 0.15933923f, -0.15110514f, 0.01511856f, 0.29332995f, -0.35546207f, -0.08515850f, 0.31856081f, 
    -0.11865342f, -0.07074809f, 0.38842729f, -0.08451746f, 0.28960630f, 0.02870652f, 0.26057914f, -0.14445426f, 
    -0.04637766f, -0.31202713f, 0.12665495f, -0.11076202f, -0.73827541f, -0.58838820f, 0.12837420f, 0.54590815f, 
    0.25267962f, -0.16218427f, 0.02326778f, 0.41901445f, 0.20929468f, -0.41835967f, 0.07735308f, -0.21068282f, 
    0.41383389f, -0.02296144f, 0.01632256f, -0.05067000f, 0.28689772f, -0.01669184f, 0.33903486f, -0.11835039f, 
    0.30875358f, 0.09447157f, -0.93198127f, 0.03851277f, 0.37935469f, -0.52456933f, -0.19709431f, 0.77877492f, 
    0.56726730f, 0.14648908f, 0.19157407f, 0.29052284f, -0.23674569f, -0.45909497f, -0.42571574f, -0.34725595f, 
    -0.01716985f, -0.48838508f, -0.12301871f, -0.33559290f, -0.03476035f, -0.31021598f, -0.20675710f, 0.00168717f, 
    -0.09552689f, -0.23989020f, -0.14894940f, -0.39703348f, -0.27650675f, 0.51109982f, -0.06439232f, 0.58919382f, 
    -0.92726499f, -0.31244761f, -0.60834485f, -0.61168307f, -0.07782175f, 0.46039417f, 0.13052829f, 0.26794490f, 
    0.09556740f, -0.26508328f, -0.19895798f, 0.04484435f, -0.19539468f, 0.23913972f, -0.14407121f, 0.05419715f, 
    -0.11046558f, -0.25339869f, -0.05662430f, 0.31212667f, 1.11022854f, 0.18797950f, -0.00433756f, 1.05896938f, 
    0.74916464f, 0.34062135f, 0.40448526f, -0.11088183f, 0.45859465f, -0.26849598f, -0.36249781f, -0.18987437f, 
    -0.25172356f, -0.12073331f, -0.25147909f, 0.11450967f, -0.08950187f, -0.04666322f, -0.01942129f, 0.06141723f, 
    0.08151264f, 0.02473628f, -0.33849433f, -0.06521636f, 0.09868240f, -0.09825893f, -0.24581105f, 0.49744123f, 
    0.36364514f, -0.20512652f, -0.56714141f, -0.33316791f, -0.36393359f, -0.38126913f, -0.55112839f, 0.04119631f, 
    0.12248595f, -0.43292829f, -0.19332273f, 0.33165702f, -0.11932574f, -0.26502460f, -0.14692643f, 0.20961048f, 
    0.17142579f, 0.03853264f, -0.21991450f, 0.31134045f, -0.02295364f, -0.17670707f, 0.13127238f, -0.48631775f, 
    0.20852055f, 0.60700655f, 0.49278671f, -0.81524277f, -0.21230918f, -0.20382527f, -0.74291027f, 0.06120387f, 
    0.36373752f, 0.38032058f, -0.29381388f, 0.45956340f, -0.19608213f, 0.06818017f, -0.33807784f, -0.09195407f, 
    0.02874882f, -0.60841382f, -0.06005726f, 0.18856314f, 0.16606164f, 0.25158978f, 0.02401616f, 0.84666145f, 
    0.38533211f, 0.39354938f, 0.64418375f, -0.08244142f, -0.24380963f, -0.49585545f, 0.46623501f, -0.24236907f, 
    0.35311496f, 0.27350271f, -0.24500138f, -0.11869517f, -0.37912333f, -0.31380907f, -0.26282367f, 0.07746218f, 
    -0.01774939f, 0.10064614f, -0.18417297f, 0.18874572f, 0.19753218f, -0.12289489f, 0.16207242f, 0.20778126f, 
    -1.02045405f, 1.09715962f, -0.09518246f, -0.72733873f, 0.44404179f, 0.27899531f, -0.21442229f, -0.20051186f, 
    0.61680555f, -0.60569841f, -0.01277882f, -0.02202982f, -0.58325630f, 0.28759211f, -0.06060046f, 0.06415847f, 
    0.07598251f, 0.05300197f, -0.20043844f, 0.25352922f, -0.04452667f, 0.07829981f, 0.04837350f, 0.22431591f, 
    0.05303554f, 0.75313723f, 0.72734571f, 0.68468249f, 0.60626680f, -0.51467615f, -0.37458238f, -0.06973708f, 
    0.10010255f, 0.15421973f, 0.20665018f, 0.41483551f, 0.32345662f, -0.30125058f, 0.32439736f, 0.06441365f, 
    -0.10109821f, 0.00933084f, 0.13584992f, -0.23755760f, 0.16071200f, -0.09288376f, 0.22208808f, 0.07251880f, 
    0.17023025f, 0.01254878f, 0.39398137f, 0.28796509f, -0.42838413f, -0.43424997f, 0.15583912f, -0.36008602f, 
    -0.54744923f, -0.57942349f, -0.13050988f, -0.24940948f, -0.28184006f, 0.34737411f, 0.54274833f, 0.05955514f, 
    0.21023877f, 0.33274502f, 0.05795738f, 0.13605586f, 0.19115968f, 0.54642373f, -0.14352034f, 0.08820242f, 
    0.13346392f, -0.40338197f, -0.14752848f, 0.74702716f, 0.17974612f, 0.15673673f, 0.70743853f, 0.90362406f, 
    0.32098553f, 0.29025915f, -0.36665145f, 0.35192022f, -0.06332937f, 0.17114252f, 0.18949206f, -0.42017001f, 
    0.11032140f, -0.04325484f, 0.11903381f, -0.18094204f, -0.07134676f, -0.00447826f, 0.26840243f, 0.49934316f, 
    0.42112190f, 0.48143312f, -0.10289307f, 0.21660250f, -1.08157170f, -0.12996614f, -0.73676533f, -0.25340381f, 
    -0.71781802f, 0.38477969f, -0.08268218f, -0.47421277f, 0.55408859f, 0.45185494f, 0.11905043f, -0.09222039f, 
    -0.05087236f, 0.15887536f, 0.19041488f, 0.03436334f, 0.27041396f, -0.06958787f, -0.03563765f, -0.17599349f, 
    -0.11660198f, -0.09763666f, 0.00004729f, 0.16693784f, -0.00901885f, 0.27031532f, -0.83558065f, 0.88089335f, 
    0.40851721f, -0.11265384f, 0.47544801f, -0.60028011f, -0.04917074f, -0.03852101f, -0.33339107f, 0.09948949f, 
    -0.29854241f, -0.07964953f, 0.15312688f, -0.10984416f, 0.43562046f, 0.12833844f, 0.04372641f, -0.12020568f, 
    0.17286479f, -0.30120555f, 0.17663525f, 0.54732007f, -0.13763481f, 0.07667519f, -0.25680602f, 0.92036027f, 
    0.82470626f, -0.12783235f, 0.54953772f, -0.37179586f, 0.16157979f, -0.16053873f, -0.25035703f, -0.30446893f, 
    0.31782889f, -0.35676506f, -0.12246006f, 0.00935120f, 0.20017773f, -0.20800939f, -0.32685611f, 0.11825335f, 
    -0.24552806f, 0.04437630f, 0.15007165f, -0.19188929f, 0.32534668f, 0.26913732f, 0.18357210f, -0.53023887f, 
    0.68836945f, 0.84823275f, -0.75561285f, -0.69150221f, -0.18571517f, -0.07885605f, 0.04464768f, -0.42703941f, 
    -0.44898945f, -0.13222586f, 0.61093652f, -0.25018251f, -0.00250994f, -0.23115793f, -0.34209624f, -0.04133093f, 
    -0.30152011f, -0.00804118f, -0.05555813f, 0.34789151f, 0.10633259f, 0.04709885f, 0.22925398f, 0.01181406f, 
    0.32543537f, -0.73998094f, -0.35860914f, -0.10416671f, 0.44829312f, 0.82734066f, 0.00501529f, -0.20006990f, 
    -0.43948773f, -0.27892265f, 0.24386826f, 0.18401898f, 0.00737331f, 0.09630387f, -0.04314226f, -0.34078345f, 
    0.04777011f, -0.57586634f, -0.06151682f, 0.19884701f, 0.11112378f, 0.19231993f, 0.18223026f, 0.15943992f, 
    -0.38656288f, 0.36808208f, 0.21787073f, 0.79566097f, -0.54962355f, -1.05211961f, -0.37601998f, -0.52566367f, 
    -0.04379215f, 0.12515497f, 0.05541592f, 0.34475583f, 0.39774728f, -0.38563892f, 0.12843643f, 0.04457469f, 
    0.01813392f, -0.13061485f, 0.09686457f, -0.06457382f, 0.14347905f, 0.09949064f, 0.20548308f, -0.01330436f, 
    0.12065589f, 0.14403269f, -0.04947831f, -0.90223664f, -0.78869861f, -0.22746493f, -0.06239262f, 0.59757400f, 
    0.74064982f, 0.20030472f, 0.22418962f, 0.26441061f, -0.48350114f, 0.14336784f, -0.32404238f, 0.03831359f, 
    -0.23873951f, -0.20203960f, -0.02563757f, -0.07704768f, 0.09965121f, -0.05475977f, -0.14894108f, -0.28671774f, 
    -0.18506029f, -0.21789932f, -0.09637350f, 0.11343659f, 0.81330204f, 0.22430030f, -0.24383350f, 0.65291256f, 
    -0.19496974f, -0.28134257f, -0.56108981f, -0.45514190f, -0.15126012f, 0.27659911f, 0.17248660f, -0.08853976f, 
    -0.10920983f, 0.18579699f, -0.21342093f, -0.02871945f, -0.13878599f, -0.14141251f, 0.21545492f, -0.33774188f, 
    -0.10915925f, -0.12064267f, -0.38480714f, 0.13558546f, 0.14733177f, -1.43344021f, 0.28724125f, 0.99732637f, 
    0.12405949f, -0.39437348f, 0.47184306f, 0.79188949f, -0.29714370f, -0.00717292f, 0.16811758f, -0.04158729f, 
    -0.39558098f, -0.01342809f, -0.09292832f, -0.03169857f, 0.18519987f, -0.29805800f, 0.11257513f, -0.26912344f, 
    -0.07733180f, 0.09366218f, 0.06980725f, -0.09185045f, 0.09137645f, 0.69582862f, 0.11968318f, -0.58980668f, 
    -0.98219389f, -0.27791610f, -0.02506513f, 0.49530035f, 0.48769563f, 0.42661816f, 0.44109967f, -0.33776143f, 
    -0.19824524f, -0.22018942f, -0.16883488f, -0.12789728f, -0.23239224f, 0.12682045f, -0.05456793f, 0.23565270f, 
    0.05185177f, -0.23356602f, 0.11742594f, -0.54129189f, -0.34406334f, -0.02038914f, 0.51987696f, 0.38877627f, 
    0.81148636f, 0.77640671f, 0.31571198f, 0.67134297f, -0.16983472f, -0.46025088f, -0.12575692f, 0.33675736f, 
    -0.17187816f, 0.23624001f, 0.17384540f, 0.30073726f, -0.23344100f, 0.12997495f, 0.05476746f, 0.12290498f, 
    -0.11854272f, -0.23062974f, 0.41061896f, -0.02913372f, -0.07733043f, -0.24765816f, -0.23748301f, -0.53276724f, 
    0.21458998f, -0.08311311f, -0.36933833f, 0.60596764f, -0.57401812f, -0.47005948f, -0.64456612f, -0.38413310f, 
    -0.21052638f, 0.07819384f, 0.12928131f, 0.54111767f, 0.05842579f, 0.12076362f, -0.03490725f, 0.08239102f, 
    -0.31118849f, 0.24103586f, -0.00488096f, -0.21306321f, -0.12364201f, 0.08546322f, -0.07227279f, 0.24634852f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00620015f, 0.18628089f, -0.08173744f, 0.10780204f, 0.09886076f, -0.06593362f, -0.05901713f, 0.10273375f, 
    0.07384181f, 0.10056793f, 0.03250718f, -0.11186961f, -0.02049185f, 0.06597158f, 0.07480054f, 0.22258316f, 
    0.13926020f, 0.11035702f, 0.01251474f, 0.22852473f, 0.08588175f, 0.15405217f, 0.10788695f, 0.09407054f, 
    0.22846571f, 0.02996174f, -0.06834511f, 0.05670878f, 0.05994045f, 0.12260750f, -0.04828890f, 0.01775744f, 
    0.25968519f, 0.32673883f, 0.12117016f, 0.26546034f, -0.04472014f, 0.13916139f, -0.02214936f, 0.22653151f, 
    0.04646816f, -0.03545938f, -0.02889712f, 0.06472866f, 0.23707849f, 0.29681411f, 0.14656174f, 0.24878672f, 
    0.21411778f, 0.18632311f, 0.22091289f, 0.04391623f, 0.18761025f, 0.15825498f, 0.01937616f, 0.15523349f, 
    0.06085921f, 0.16005702f, 0.06701673f, 0.15669414f, -0.00873094f, 0.02448766f, 0.13771558f, 0.28217489f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.10727124f, 0.03259035f, -0.03796141f, 0.12883787f, -0.14174055f, -0.04547870f, 0.03570189f, 0.06836647f, 
    0.07637063f, 0.16857058f, -0.09138856f, -0.04498003f, -0.03969569f, -0.14597058f, 0.14043242f, -0.06696982f, 
    0.06081063f, 0.03389851f, 0.06539124f, -0.06186498f, 0.00668572f, -0.04890088f, 0.06900340f, 0.01848366f, 
    0.02156573f, 0.12791820f, 0.21773076f, 0.02325990f, -0.00937561f, 0.12363639f, 0.05983207f, 0.02661241f, 
    -0.04408525f, 0.07715160f, 0.09848982f, -0.02875007f, 0.00279435f, -0.08372384f, 0.03841500f, 0.09085069f, 
    -0.08805107f, 0.04351358f, 0.01739245f, -0.02916221f, 0.13546968f, 0.10162637f, -0.09108897f, 0.02404706f, 
    -0.14010981f, 0.03835175f, 0.14245091f, 0.05482958f, 0.00466989f, 0.00318913f, 0.03850364f, -0.04108780f, 
    -0.02346449f, -0.08846182f, -0.05669927f, 0.08152431f, 0.08065975f, 0.05237361f, 0.00676871f, 0.15390593f, 
    -0.05908675f, -0.03908508f, 0.15476352f, -0.04579490f, 0.05919999f, -0.00433571f, 0.00209002f, 0.02752076f, 
    -0.08718064f, -0.11159129f, 0.07088757f, -0.20007174f, -0.00989209f, 0.07293066f, 0.02697343f, -0.13238795f, 
    -0.10325473f, 0.02077030f, -0.01615996f, -0.00462848f, 0.05368049f, 0.02570074f, -0.03102343f, 0.06664708f, 
    -0.13290469f, 0.04078858f, -0.05212426f, -0.05562478f, -0.07816765f, -0.08814225f, -0.02790855f, -0.06133064f, 
    0.17852235f, -0.12878513f, -0.20025423f, 0.19087453f, -0.20856909f, 0.04153701f, -0.04551191f, 0.09251479f, 
    0.09287815f, -0.02478534f, -0.08876785f, -0.02696356f, -0.20245261f, -0.26738209f, 0.20469157f, -0.14310409f, 
    0.03532434f, 0.05093911f, 0.00120906f, -0.09536853f, -0.23577832f, 0.03271920f, 0.11674640f, 0.00745994f, 
    0.11761793f, 0.04678467f, 0.07137732f, -0.21200523f, -0.18237625f, 0.06396613f, -0.09324284f, 0.09174183f, 
    0.02273791f, -0.02219965f, 0.05213791f, -0.02971749f, -0.31540477f, 0.15411170f, -0.02206804f, -0.02888094f, 
    0.12828362f, -0.04621160f, 0.04217422f, 0.08151001f, 0.01230213f, -0.03282636f, 0.07401231f, -0.00621605f, 
    0.17332777f, -0.28586569f, 0.03666825f, -0.16493887f, -0.08723925f, 0.03093783f, -0.01915298f, -0.13202208f, 
    0.03093375f, 0.13872591f, 0.07153200f, 0.04737398f, -0.23470131f, 0.20431134f, 0.01135468f, 0.11418892f, 
    0.11840670f, 0.02943654f, -0.07120764f, 0.00501444f, 0.01570032f, 0.01261229f, 0.01832386f, -0.08577945f, 
    0.45958602f, 0.02115650f, 0.27119139f, -0.13923232f, -0.05097903f, 0.03713837f, 0.05169306f, -0.02039984f, 
    0.01597398f, 0.03358982f, 0.04946383f, 0.03076695f, -0.09765378f, 0.07755218f, -0.10312350f, 0.12158112f, 
    -0.05794276f, -0.05919976f, -0.04408187f, -0.00118387f, -0.01476627f, 0.02132456f, 0.03927648f, -0.09166325f, 
    0.12984264f, 0.06457759f, 0.05909464f, -0.31537974f, 0.04749845f, -0.07185921f, -0.01511398f, -0.00609145f, 
    -0.10122970f, 0.01269007f, -0.02464559f, -0.01828220f, 0.11939416f, 0.08167894f, -0.06213013f, 0.04174441f, 
    -0.12860778f, 0.02263327f, -0.15288369f, 0.12135467f, -0.11363668f, 0.00913844f, -0.04671990f, 0.03752053f, 
    0.11616595f, 0.12774272f, 0.01360917f, -0.17864157f, 0.08355781f, 0.01600315f, 0.00116560f, -0.09199788f, 
    -0.00162207f, 0.00557921f, -0.02545982f, -0.02405875f, -0.15723711f, 0.01808598f, -0.19330934f, -0.04823580f, 
    0.12049339f, -0.02636521f, -0.02846409f, 0.11366747f, -0.00223352f, 0.00707636f, -0.07217627f, -0.11708774f, 
    0.02040263f, -0.17394124f, 0.02876003f, 0.01548220f, -0.11528575f, 0.01276442f, 0.04040899f, 0.00230303f, 
    0.13031332f, -0.06800181f, 0.02206636f, 0.04399425f, -0.24043053f, -0.01048490f, -0.10578650f, -0.01968275f, 
    0.04763187f, -0.05243922f, -0.04232410f, -0.01335077f, 0.06207971f, -0.06185433f, 0.01004192f, -0.06085012f, 
    0.27358010f, -0.07288682f, 0.01687867f, 0.08155066f, 0.00671920f, -0.07960849f, 0.01354832f, -0.02864638f, 
    -0.10368562f, 0.12143964f, -0.16654678f, 0.03824437f, -0.07148001f, 0.10213427f, 0.20042123f, -0.45295072f, 
    -0.14390643f, -0.03398343f, 0.05059291f, 0.01281655f, 0.00215899f, -0.03932817f, 0.01067762f, 0.01247415f, 
    -0.07060993f, 0.00862287f, -0.15998280f, 0.19041440f, -0.01709818f, 0.01601456f, 0.04254131f, 0.04274287f, 
    0.00158902f, -0.03906089f, 0.09744347f, -0.06167294f, 0.13973604f, 0.08270802f, -0.03527994f, 0.11713310f, 
    -0.08799147f, -0.16692917f, 0.08772811f, 0.08360363f, 0.03202235f, 0.02302155f, -0.14394945f, 0.03761007f, 
    0.02202527f, 0.06732995f, -0.19317617f, 0.15089673f, 0.00373039f, 0.01565042f, 0.06792430f, 0.00167615f, 
    0.16369683f, 0.10302249f, -0.04012457f, 0.12818655f, -0.36913738f, 0.06966937f, -0.00265339f, 0.07500020f, 
    0.01872329f, -0.02369958f, -0.09884437f, -0.02941492f, -0.02059486f, -0.01550417f, -0.03716232f, 0.05803549f, 
    0.28935409f, -0.11824280f, -0.12041615f, 0.12462277f, -0.11317418f, -0.05455948f, 0.01739006f, -0.02611440f, 
    -0.10452545f, 0.05275042f, -0.05179840f, -0.00781821f, -0.19848935f, -0.10206094f, 0.07138944f, 0.12904908f, 
    0.02080987f, 0.08299495f, -0.02815192f, 0.03344186f, 0.08310201f, 0.05655058f, -0.02266677f, 0.01905201f, 
    0.27517024f, 0.05667298f, -0.16855131f, -0.30419448f, 0.08233820f, -0.02436951f, -0.05007584f, 0.04737455f, 
    -0.00047156f, -0.03833077f, -0.13608931f, 0.05797628f, -0.12051780f, -0.05951160f, 0.01789983f, -0.21470654f, 
    -0.00271770f, 0.03548332f, 0.04119982f, 0.06077275f, 0.09620963f, 0.07102056f, -0.01256635f, -0.00227665f, 
    -0.12622012f, -0.05163673f, 0.01854867f, -0.02186856f, 0.02441766f, -0.03831491f, -0.01092669f, -0.05331776f, 
    -0.09656825f, -0.05689560f, 0.08204243f, 0.04134193f, -0.11992667f, 0.11752549f, 0.08342373f, 0.18061914f, 
    -0.13479589f, -0.16739097f, 0.11575892f, -0.02318051f, -0.05378384f, 0.02833207f, -0.09033301f, -0.01920354f, 
    -0.26625437f, 0.05638367f, -0.05623632f, 0.05014464f, -0.01192350f, -0.01938256f, 0.00515036f, -0.09170892f, 
    0.06516769f, 0.04080039f, -0.04240919f, 0.04980144f, 0.01844610f, 0.03637211f, 0.16064692f, -0.24673370f, 
    0.01332037f, 0.08994742f, -0.04677966f, 0.05307003f, 0.00858954f, -0.14429848f, -0.07458108f, 0.03025237f, 
    -0.26622200f, 0.19062625f, -0.03799422f, 0.03043295f, 0.01944718f, 0.00471352f, 0.05235329f, -0.02927542f, 
    -0.02049159f, -0.03778659f, 0.04044725f, 0.00419012f, 0.00816855f, -0.07367740f, 0.12327133f, -0.49887553f, 
    -0.09688993f, -0.03079140f, -0.03458460f, 0.02677781f, -0.01471068f, 0.18859583f, 0.04925887f, 0.01542742f, 
    0.15399899f, -0.00289010f, -0.09571313f, -0.04162724f, -0.01107142f, -0.04464486f, -0.00124619f, 0.02833966f, 
    -0.01447246f, 0.06000886f, 0.09103274f, -0.01837790f, 0.52174908f, 0.15593797f, -0.02655230f, -0.06704416f, 
    -0.02574527f, 0.00121668f, -0.14407568f, 0.01644223f, 0.04225200f, 0.03791720f, -0.01699751f, 0.05909626f, 
    -0.36356941f, -0.16778035f, -0.17921326f, -0.01826882f, 0.00904111f, -0.13747279f, 0.03419080f, 0.04628647f, 
    -0.06799918f, -0.07150425f, -0.17448322f, -0.03301577f, -0.08795732f, 0.01606884f, 0.12301315f, -0.23463362f, 
    -0.11302081f, 0.13105248f, 0.00814833f, -0.01606689f, -0.06565672f, 0.00980295f, 0.01975650f, 0.05019959f, 
    0.26324624f, 0.12106468f, 0.28502664f, 0.03493270f, 0.11947008f, 0.09060097f, 0.05999084f, 0.05488214f, 
    -0.08812247f, 0.01476222f, -0.00576717f, 0.10701234f, -0.08625079f, -0.15014082f, -0.04643550f, -0.00165805f, 
    -0.04910138f, -0.02969806f, -0.04683282f, -0.06250403f, -0.06529275f, -0.02843907f, -0.08066774f, -0.03013543f, 
    0.10373151f, -0.01377836f, -0.07946355f, 0.30288965f, -0.03203372f, -0.04661853f, 0.02716658f, 0.04212921f, 
    -0.01556074f, -0.03647044f, -0.02000427f, -0.03503586f, -0.01300238f, 0.04989503f, -0.07907081f, 0.11669795f, 
    -0.08733357f, 0.01481476f, 0.00178237f, 0.02737599f, 0.02865290f, 0.02858763f, 0.10402240f, -0.06612566f, 
    0.07722057f, -0.02331446f, -0.10263482f, 0.26657248f, -0.09373322f, -0.05078025f, 0.00203122f, 0.01643389f, 
    -0.09545393f, 0.07100458f, -0.00713385f, -0.09317810f, 0.10521533f, -0.00175671f, -0.00748187f, 0.08098695f, 
    -0.10160457f, -0.06333846f, -0.05878675f, -0.06733767f, -0.08619071f, -0.01681931f, 0.01279447f, -0.05697376f, 
    -0.15696768f, 0.04400355f, 0.07620747f, -0.14603895f, -0.00285545f, 0.00552915f, 0.04413654f, 0.02994855f, 
    0.00909619f, -0.01436253f, 0.01790367f, -0.04942711f, 0.05126581f, -0.01145398f, -0.12075162f, 0.11748362f, 
    -0.20903847f, -0.12069514f, -0.13024499f, -0.04478156f, -0.03526716f, -0.02702446f, -0.05209229f, 0.01256680f, 
    -0.07242434f, -0.09861559f, 0.14619742f, -0.21650252f, -0.07262321f, -0.06899258f, -0.07090807f, 0.04660046f, 
    -0.00004493f, -0.10993684f, -0.02957577f, 0.02901196f, 0.09140653f, -0.04595340f, 0.02223020f, 0.10390121f, 
    0.00497844f, -0.00831383f, -0.11516941f, 0.05013421f, -0.01515694f, 0.02423488f, -0.00794762f, -0.11027671f, 
    0.47544739f, -0.04501147f, -0.21186431f, -0.17704919f, 0.01941493f, -0.02205183f, -0.04066333f, 0.04366420f, 
    -0.01053704f, -0.04026389f, -0.06584918f, 0.04033795f, 0.12731700f, -0.24155469f, -0.08445746f, 0.17106627f, 
    0.03779012f, 0.00891868f, -0.04825024f, 0.02799498f, -0.07290638f, 0.00688393f, -0.04087126f, -0.09451924f, 
    -0.04209986f, 0.09883469f, 0.08256527f, -0.21484762f, -0.13592540f, -0.16634400f, 0.02350726f, -0.05537295f, 
    0.03451631f, -0.14702034f, 0.08059990f, -0.06046085f, -0.47469985f, 0.25104371f, 0.18211170f, 0.10008036f, 
    0.09593183f, 0.06146734f, 0.01413738f, -0.09517350f, -0.01940437f, -0.07448931f, 0.02146848f, -0.01974230f, 
    -0.02205689f, 0.00892702f, 0.01104762f, -0.09413188f, 0.02002079f, -0.01632406f, -0.08327034f, -0.07168914f, 
    -0.01427065f, 0.00906621f, 0.08410743f, -0.09656949f, -0.33652246f, 0.07505099f, 0.05677873f, 0.11515209f, 
    -0.04452315f, 0.01238311f, -0.11656862f, -0.09501197f, -0.02393189f, -0.03225222f, -0.03855403f, 0.06621984f, 
    0.05565117f, 0.12753665f, 0.01038179f, -0.22996393f, 0.04551282f, 0.05271372f, 0.12750879f, -0.01158648f, 
    0.02855870f, -0.05811857f, 0.02937361f, 0.06085898f, -0.02753914f, 0.07276499f, 0.20704845f, -0.14434919f, 
    -0.07905579f, -0.03184043f, 0.11648048f, 0.10500323f, 0.05101258f, -0.01917395f, -0.04495978f, -0.03105569f, 
    -0.04027143f, 0.06876936f, -0.08052067f, 0.25961822f, -0.09253943f, 0.05415359f, 0.06782321f, -0.03876797f, 
    -0.03375723f, 0.00473093f, -0.09167872f, -0.04867729f, 0.07417634f, 0.01704978f, -0.10599228f, -0.49726728f, 
    0.10156313f, -0.05091733f, 0.04923924f, -0.07811261f, 0.00032761f, -0.04546427f, -0.02596140f, 0.10207434f, 
    0.07431886f, 0.05521181f, -0.10591025f, 0.11266509f, 0.02936930f, -0.03930932f, 0.05658562f, -0.07441801f, 
    -0.02864341f, 0.04580000f, -0.08846841f, -0.06013644f, -0.24903862f, -0.27343482f, 0.09315208f, -0.05134188f, 
    -0.02050138f, -0.07437375f, -0.18337518f, -0.03263048f, -0.05024505f, 0.00994608f, -0.05362986f, -0.04010070f, 
    0.17176734f, -0.13381959f, 0.03550032f, 0.05291098f, 0.07155155f, -0.01702960f, -0.01607154f, -0.00456779f, 
    0.04580460f, -0.11860211f, 0.10551334f, -0.09306875f, -0.18495663f, -0.06590969f, 0.05055172f, -0.16058250f, 
    -0.09539551f, 0.05844798f, -0.08845019f, 0.09044185f, 0.01669906f, 0.09976300f, -0.07083088f, -0.00190180f, 
    0.24895605f, 0.01482265f, -0.07900034f, 0.21502273f, 0.01093889f, -0.04671265f, -0.03719280f, 0.08927106f, 
    0.01660909f, -0.07517210f, -0.13357992f, -0.06698716f, -0.00507152f, 0.01974642f, -0.17539737f, -0.17333341f, 
    0.03569617f, -0.01371757f, -0.03096036f, 0.08764632f, -0.08893169f, -0.18388499f, 0.03007976f, -0.08025429f, 
    0.22794133f, 0.19324499f, -0.07352311f, 0.12269488f, 0.06713758f, 0.05665674f, -0.08478539f, -0.03304194f, 
    -0.03724768f, 0.11692087f, -0.00440592f, 0.01344077f, 0.18195026f, -0.12556691f, 0.01187258f, 0.17599124f, 
    0.01603867f, -0.07408939f, -0.04716137f, 0.00994061f, 0.16019587f, 0.00815831f, -0.01755479f, -0.07936433f, 
    0.33150840f, -0.24328293f, -0.18485706f, -0.15650299f, -0.03863491f, 0.07349415f, -0.08770947f, -0.00591310f, 
    -0.06788154f, -0.10498327f, 0.02133448f, 0.04165215f, 0.11772013f, 0.14663917f, -0.08837125f, 0.06537024f, 
    -0.07280026f, 0.00627693f, 0.07566179f, 0.01605916f, 0.14901368f, -0.01803455f, 0.00458764f, 0.06018176f, 
    0.28137383f, -0.01802185f, 0.11713365f, 0.03903605f, 0.07936563f, 0.00481423f, -0.05830484f, -0.02738537f, 
    -0.01494657f, 0.06540359f, 0.04751362f, 0.05942732f, 0.05057856f, -0.00178944f, -0.01114229f, 0.07971478f, 
    0.03517934f, -0.08887091f, -0.06623852f, 0.12217415f, 0.12645949f, 0.03942199f, -0.07458536f, -0.01745033f, 
    0.19461145f, -0.01471870f, -0.01600691f, 0.11346813f, -0.02544730f, -0.13433188f, -0.03477728f, 0.04545584f, 
    -0.06063053f, -0.02185452f, -0.02104859f, 0.01809335f, 0.17568569f, -0.01074727f, -0.23848556f, -0.00119358f, 
    0.10947397f, 0.10499638f, 0.00468423f, 0.00316444f, 0.06016406f, 0.01752003f, -0.03456908f, -0.05149486f, 
    -0.16453594f, -0.09909357f, 0.13133582f, -0.08533162f, 0.03107140f, 0.00725943f, 0.03969403f, 0.02229327f, 
    -0.23186249f, 0.03282097f, 0.06449100f, -0.09804124f, -0.21968111f, 0.00880160f, -0.24593341f, 0.14369684f, 
    -0.05670976f, -0.04945711f, 0.00704826f, -0.13661331f, 0.04009340f, -0.02063856f, -0.01943363f, 0.03904920f, 
    -0.56149030f, 0.03500647f, -0.15343857f, -0.07924519f, 0.02836368f, -0.10157491f, -0.00131339f, 0.04112510f, 
    -0.01347084f, 0.04717845f, 0.05673400f, -0.09327658f, -0.27062675f, -0.11069636f, -0.06480861f, 0.02072402f, 
    0.07774603f, -0.01251865f, -0.11692344f, 0.04526190f, -0.03081082f, -0.11466482f, -0.02917498f, 0.08606609f, 
    -0.12189344f, -0.01405237f, -0.06735681f, -0.23276694f, -0.05619213f, 0.04076110f, -0.02678015f, -0.02281621f, 
    0.14664881f, -0.11965879f, 0.00584208f, -0.01710287f, 0.08744112f, 0.17677638f, -0.01188110f, -0.09371100f, 
    -0.06530201f, -0.05928589f, 0.03601363f, 0.02401048f, 0.05095976f, -0.10954428f, -0.06560729f, -0.05824455f, 
    0.13092135f, -0.22551049f, 0.09566338f, -0.10919371f, 0.03767244f, 0.01520245f, -0.07867310f, 0.05798897f, 
    -0.01043828f, 0.02152280f, 0.00809328f, 0.05836664f, 0.30208752f, 0.00602129f, 0.02277681f, -0.04929518f, 
    -0.04765709f, 0.05028061f, -0.01922498f, 0.01421367f, -0.01785581f, -0.06561935f, -0.00408221f, 0.15550172f, 
    0.27167040f, -0.05682096f, -0.00376626f, 0.10096578f, -0.07449341f, -0.01418883f, -0.03034527f, -0.09432709f, 
    -0.11580012f, 0.16698441f, -0.01071348f, 0.09622023f, -0.10426426f, 0.21005376f, -0.29971832f, 0.10336790f, 
    0.15234056f, 0.10156627f, -0.01249718f, 0.19820990f, -0.04640716f, -0.01914947f, 0.04185547f, -0.07356359f, 
    0.11393559f, -0.09316898f, 0.13851972f, 0.06978017f, -0.10856505f, -0.00938703f, -0.05343685f, 0.07213175f, 
    -0.05339369f, -0.05405665f, -0.02504662f, -0.09978055f, 0.22269627f, -0.10227953f, 0.00125314f, -0.22565341f, 
    -0.01478277f, -0.08342348f, 0.12103163f, -0.02719648f, -0.15297854f, -0.01403895f, 0.01917428f, -0.04669809f, 
    0.16805950f, 0.11927108f, 0.03939836f, 0.02628089f, -0.01320351f, 0.15750293f, 0.03297403f, -0.09998842f, 
    0.02868617f, -0.10379571f, -0.05833072f, -0.07878199f, 0.12958252f, -0.03650609f, 0.08607469f, 0.14670822f, 
    -0.07317189f, 0.06361377f, 0.05539309f, -0.02140638f, 0.07568052f, -0.08218636f, 0.10880724f, -0.10134568f, 
    0.09506354f, 0.10530742f, -0.11468408f, -0.03821130f, -0.15849453f, -0.07576834f, 0.11690920f, -0.01465449f, 
    -0.09472995f, -0.02343594f, 0.01534074f, -0.26517087f, 0.42433682f, -0.12385722f, -0.05517793f, 0.04035143f, 
    -0.14542359f, 0.04456966f, -0.05394990f, 0.05645191f, -0.00080029f, -0.06918658f, 0.04020694f, 0.04913851f, 
    -0.20829019f, -0.13366781f, 0.02346345f, 0.09125385f, 0.07768978f, 0.00631572f, -0.04147164f, 0.10637707f, 
    0.05976396f, 0.08038840f, -0.03835262f, -0.11518768f, -0.16616647f, 0.11906601f, -0.01361177f, 0.06149380f, 
    -0.10010424f, -0.09085873f, -0.00981540f, 0.05075480f, -0.03797282f, 0.04373292f, -0.01930650f, -0.08609597f, 
    0.08752149f, 0.09863336f, -0.07729611f, -0.00092275f, -0.00078488f, -0.00037991f, 0.04024654f, 0.03729054f, 
    0.07121772f, 0.05832021f, -0.05444712f, 0.00261657f, -0.00534131f, 0.01963039f, -0.18664925f, -0.02793182f, 
    0.03603036f, 0.01167153f, -0.06124635f, -0.04262284f, 0.02780631f, 0.04902962f, -0.06917614f, -0.04336739f, 
    -0.02913582f, 0.03255955f, -0.08232990f, -0.21051700f, -0.00593706f, -0.01220264f, 0.08268286f, -0.08588760f, 
    0.00361398f, -0.15755591f, -0.18349510f, -0.01792181f, -0.27138931f, 0.09680991f, -0.16740473f, -0.09978217f, 
    -0.10125016f, 0.08039881f, -0.11078957f, 0.03996326f, -0.05647464f, -0.11272280f, 0.04944924f, 0.06818197f, 
    0.32311565f, -0.23576985f, -0.25797769f, 0.11828157f, -0.15287387f, 0.02042279f, -0.01062013f, 0.08038536f, 
    -0.06354444f, -0.04278135f, 0.05279859f, 0.05548214f, 0.06803758f, -0.20428243f, 0.08063241f, -0.18991916f, 
    0.02631005f, -0.14676858f, 0.13799158f, 0.03446427f, -0.07355837f, 0.14848931f, 0.10628992f, 0.11289877f, 
    -0.09837757f, -0.01656291f, -0.33364788f, 0.00331110f, -0.03461728f, 0.04844347f, 0.00640226f, -0.09703100f, 
    0.05715664f, 0.03649045f, -0.09753895f, 0.00805485f, 0.34476155f, -0.05518427f, 0.09065773f, -0.05087694f, 
    -0.00907247f, -0.04111985f, -0.04319152f, 0.07454596f, -0.03335634f, -0.18714918f, -0.01504769f, -0.00176634f, 
    0.15135074f, -0.01925277f, -0.04040914f, 0.10080703f, -0.04262005f, 0.02291742f, 0.02139688f, 0.02062488f, 
    0.06635708f, -0.07989339f, -0.05483333f, 0.08562221f, -0.56478131f, -0.13408442f, -0.05647517f, -0.00960034f, 
    0.02569471f, -0.01384565f, 0.13934840f, 0.08113196f, 0.02121332f, -0.04148668f, 0.06312230f, -0.05344998f, 
    0.12566072f, 0.14173111f, 0.03626152f, -0.05390758f, 0.06849513f, -0.03926000f, -0.03265651f, 0.04867019f, 
    -0.01472924f, 0.04837437f, 0.06833774f, 0.08277522f, -0.07560769f, -0.01830505f, -0.30733803f, -0.17257874f, 
    -0.10807947f, -0.04573792f, -0.11507987f, 0.02042688f, 0.03010964f, 0.06000853f, 0.01678603f, -0.03487525f, 
    -0.25897294f, 0.04888519f, -0.09234625f, -0.00023209f, -0.03209787f, -0.08939100f, -0.07796186f, -0.05544958f, 
    0.00090817f, 0.11824892f, -0.21982951f, -0.18497469f, -0.06738666f, -0.17939235f, -0.07044831f, -0.03967148f, 
    0.09054462f, -0.05082485f, -0.01530394f, 0.12245113f, 0.01169186f, 0.17649744f, 0.06455341f, -0.09399866f, 
    0.25138193f, -0.08847810f, 0.11441746f, 0.21695259f, -0.10121929f, 0.12154234f, -0.08594102f, 0.02215097f, 
    -0.04601091f, 0.09386911f, -0.02427367f, -0.03955469f, -0.35676605f, -0.04276936f, -0.25334343f, -0.03196326f, 
    0.07634766f, 0.02204395f, 0.01652168f, -0.05797429f, -0.13046764f, -0.02715537f, 0.07633127f, 0.11384749f, 
    -0.28495222f, -0.08833443f, -0.00712977f, 0.05570418f, 0.05573167f, 0.07342096f, -0.04376629f, 0.08460997f, 
    0.03908565f, -0.09801830f, -0.14670375f, 0.02841000f, 0.10906418f, 0.10941888f, 0.15572467f, 0.32997489f, 
    -0.13389918f, -0.02734660f, 0.04553024f, 0.05683332f, 0.08324686f, 0.02111477f, 0.04659839f, 0.06762251f, 
    -0.34628555f, -0.01163877f, -0.21721204f, -0.32344565f, 0.03871857f, 0.08315668f, 0.06796004f, -0.04042228f, 
    0.05088831f, 0.14081281f, 0.02208595f, 0.01028924f, 0.08115996f, 0.05988818f, 0.03578898f, 0.11278708f, 
    -0.05311115f, -0.07404653f, 0.09061535f, -0.01977535f, -0.05455270f, -0.02174773f, 0.04951017f, 0.09510020f, 
    0.08989501f, -0.09738287f, -0.02100780f, -0.07796562f, 0.05856862f, -0.03121518f, 0.05224870f, -0.01259941f, 
    -0.04846723f, 0.10014026f, 0.06007582f, -0.01069278f, 0.23785603f, -0.14722420f, 0.21244046f, 0.23625103f, 
    -0.09440998f, -0.00617786f, 0.04941511f, 0.00334531f, -0.00835201f, 0.14849600f, -0.02514546f, 0.09316147f, 
    -0.23123778f, 0.06931598f, 0.00322424f, -0.05536563f, 0.13780627f, -0.06605642f, 0.04137186f, 0.00657577f, 
    0.00087890f, -0.04990988f, -0.08055748f, 0.04402789f, -0.24200790f, 0.16423172f, -0.00507032f, -0.10411304f, 
    0.02055498f, -0.00861499f, 0.10149789f, -0.07398953f, 0.14183137f, -0.06577036f, 0.12743884f, 0.02928904f, 
    -0.07833754f, 0.18843789f, 0.04680252f, -0.00289447f, 0.08638787f, 0.08017033f, 0.03759434f, -0.00684490f, 
    -0.02294843f, 0.04241722f, -0.08633378f, 0.10823990f, -0.23425689f, 0.06492697f, -0.39437017f, -0.21440396f, 
    -0.03075081f, 0.06485428f, 0.00671719f, -0.00788000f, 0.02765091f, 0.13874300f, -0.02950346f, -0.14594689f, 
    0.20922099f, -0.19352151f, 0.02144035f, -0.16579254f, 0.03003788f, 0.00872347f, -0.04703211f, -0.01607862f, 
    -0.00546932f, 0.00734346f, -0.01553193f, -0.04392505f, -0.20596820f, 0.05962152f, -0.36906725f, -0.11337306f, 
    0.05710251f, 0.01385446f, 0.02529812f, 0.04694598f, -0.00952555f, 0.05881245f, 0.06009084f, 0.06431623f, 
    0.22617200f, -0.25991425f, -0.02419467f, -0.07182367f, 0.07488020f, -0.06363816f, -0.08681758f, 0.07522462f, 
    0.00443464f, 0.00261532f, -0.01731291f, 0.01683892f, 0.05028412f, -0.02504851f, -0.14544302f, -0.15985127f, 
    0.00147301f, -0.09523468f, -0.03804742f, -0.13200197f, 0.01953347f, -0.03251525f, 0.00816333f, 0.02884441f, 
    -0.18080889f, -0.11204094f, 0.02016282f, 0.27022284f, -0.16296263f, -0.00940369f, -0.04607206f, 0.00323240f, 
    0.06848502f, -0.01770082f, 0.00092362f, 0.03713154f, 0.28778207f, -0.11618869f, 0.11458705f, -0.28193086f, 
    0.13887282f, -0.11242862f, 0.01454201f, -0.01301651f, -0.11965594f, 0.03684476f, 0.07789567f, -0.05838176f, 
    0.07624581f, 0.12632056f, 0.16880293f, 0.00188462f, -0.17017612f, -0.05466649f, -0.01304694f, -0.09380669f, 
    0.09228186f, -0.05835302f, 0.09993365f, 0.00255319f, 0.02122613f, -0.07701843f, 0.02199610f, -0.11392894f, 
    0.03214421f, 0.00250013f, 0.11989950f, -0.00804094f, 0.11877666f, 0.14125206f, 0.00913431f, -0.00899555f, 
    0.10970872f, -0.01761010f, -0.02012383f, 0.01996744f, 0.07575624f, -0.01031473f, 0.05113463f, -0.11051144f, 
    -0.06420789f, 0.00923662f, -0.08249327f, -0.08372717f, 0.08795211f, -0.00958737f, 0.09838352f, -0.02876903f, 
    -0.01210381f, -0.07223941f, 0.05845448f, -0.06285948f, 0.02812198f, -0.11048326f, 0.05399716f, -0.14494443f, 
    0.05066434f, -0.13395955f, 0.01621903f, -0.11775388f, 0.08760548f, -0.00288167f, 0.08614138f, -0.06684972f, 
    -0.00610620f, 0.04442922f, -0.03466183f, -0.00577820f, -0.07344832f, -0.02343055f, -0.09645949f, -0.08708858f, 
    -0.01458433f, -0.05396484f, 0.07269645f, 0.06647717f, 0.09075846f, 0.06486189f, 0.07100470f, -0.03905171f, 
    0.03944442f, -0.05793869f, 0.05162984f, 0.00917060f, 0.08168600f, -0.01383524f, 0.02988710f, -0.05101717f, 
    0.04611981f, 0.02503422f, 0.08774623f, 0.09012273f, -0.39800650f, 0.02036377f, 0.03498408f, -0.01258822f, 
    -0.03202984f, 0.01397109f, 0.00241542f, -0.00966411f, 0.00619829f, -0.02445592f, -0.02443112f, 0.01138978f, 
    -0.08038551f, 0.02844627f, 0.09697334f, -0.00223765f, -0.00270413f, -0.05276764f, 0.05089463f, -0.04674953f, 
    0.04463087f, -0.04997518f, 0.05149017f, -0.00346105f, 0.11550218f, 0.15283254f, -0.15304096f, -0.12349038f, 
    -0.02031104f, 0.06856367f, 0.00588997f, -0.05580645f, -0.08188572f, 0.06047960f, 0.00967501f, -0.09158204f, 
    0.07402166f, -0.07723891f, 0.03610852f, -0.06163033f, 0.09769664f, -0.06670450f, -0.01907480f, 0.08775175f, 
    -0.13461581f, 0.05308443f, -0.04364472f, -0.02468437f, -0.34865704f, -0.20907785f, -0.01084798f, -0.23197819f, 
    -0.09265792f, -0.00618740f, 0.04272781f, -0.06429591f, 0.03245383f, -0.00016842f, 0.00288498f, 0.02059646f, 
    -0.04745361f, 0.10972265f, 0.01796404f, 0.04653099f, 0.11013771f, 0.02698846f, 0.07486930f, 0.01557925f, 
    -0.03154545f, -0.04950081f, 0.02355734f, -0.08871283f, -0.07246190f, -0.21401292f, -0.06708622f, 0.02766486f, 
    -0.18484133f, -0.01535600f, -0.03199280f, -0.03305747f, 0.02171761f, 0.00471176f, -0.02044774f, 0.09269143f, 
    -0.04035043f, 0.22501285f, 0.05448900f, 0.06401556f, -0.07691213f, -0.00592675f, -0.09374700f, -0.11376499f, 
    0.06193645f, 0.00304847f, -0.11182807f, -0.07575597f, 0.26924372f, 0.03726989f, -0.16858661f, -0.20786098f, 
    -0.20349763f, -0.01251217f, -0.12185442f, 0.03437149f, 0.03216960f, -0.07529928f, 0.04130876f, -0.13292216f, 
    0.43497372f, -0.11592031f, -0.01350037f, -0.18778305f, 0.04243824f, -0.07814852f, 0.02416210f, 0.06318901f, 
    0.07222152f, 0.09257296f, 0.02030854f, -0.06286371f, -0.08266085f, 0.08593639f, -0.06767663f, 0.00883136f, 
    -0.02088875f, -0.01493760f, -0.05077938f, 0.02555973f, 0.00070731f, -0.00090830f, -0.00515996f, -0.04863257f, 
    0.04034801f, 0.09358077f, -0.04337187f, 0.09327923f, 0.00760797f, -0.08086457f, -0.06545144f, -0.01920065f, 
    -0.03554885f, 0.00612571f, 0.02698911f, 0.01209568f, -0.07348105f, 0.13793045f, -0.18974911f, -0.12471035f, 
    -0.01205684f, 0.09008843f, 0.01208221f, -0.03055212f, -0.05329715f, 0.20851196f, -0.08734688f, 0.03988384f, 
    0.10928048f, 0.11456855f, 0.14957190f, 0.19719575f, -0.10393599f, -0.06535793f, -0.03779668f, 0.06073854f, 
    -0.03470877f, -0.05746812f, -0.03245176f, 0.01505587f, 0.20135130f, -0.13191219f, 0.00836135f, 0.03421830f, 
    -0.11292841f, 0.01208251f, -0.16919543f, -0.01639730f, -0.02322076f, -0.01800346f, -0.00786548f, -0.04493273f, 
    0.00725963f, 0.02808080f, 0.06485760f, 0.01239905f, 0.04694802f, 0.08796890f, 0.03142434f, 0.01028013f, 
    -0.04538469f, -0.21970175f, -0.02434418f, -0.03483596f, 0.09047050f, -0.14818177f, 0.00546869f, 0.01923936f, 
    -0.10502279f, -0.09879534f, -0.11319091f, -0.02280916f, -0.09574252f, 0.04603009f, -0.10838928f, -0.00197703f, 
    -0.21676244f, 0.06979760f, 0.03919379f, -0.11831065f, -0.02306296f, 0.13139404f, 0.04615453f, 0.01738638f, 
    0.05970441f, -0.01056086f, 0.05538996f, 0.03503645f, -0.12321728f, -0.02575943f, 0.07573619f, -0.19927371f, 
    0.07180499f, 0.01299686f, 0.06805465f, -0.08971177f, -0.04038634f, -0.01796906f, 0.00550119f, -0.02512293f, 
    0.10665540f, 0.06617902f, -0.01087230f, 0.00203581f, -0.14362751f, 0.03836180f, -0.01099814f, -0.05752674f, 
    -0.00206828f, 0.09939262f, 0.07282740f, -0.04959388f, -0.13104646f, 0.00630375f, -0.12678605f, 0.13276984f, 
    0.03213106f, 0.09434125f, -0.02506526f, 0.02657671f, -0.10240300f, -0.00111540f, -0.15370949f, -0.01241123f, 
    0.03223366f, -0.09413628f, -0.04885261f, 0.01879529f, 0.06361037f, 0.11928327f, 0.04639958f, 0.04189353f, 
    -0.02323859f, -0.02004838f, -0.03423899f, 0.00220661f, 0.46919101f, -0.08641019f, 0.06910405f, 0.04523422f, 
    -0.02369500f, -0.02003019f, 0.01498621f, -0.07046357f, -0.02441825f, -0.03344960f, 0.04108113f, 0.02906474f, 
    0.08309916f, 0.11553016f, -0.00500131f, -0.02740486f, -0.08800480f, 0.04411659f, 0.02042622f, 0.06222149f, 
    -0.00879814f, -0.02223520f, 0.02549790f, 0.00199103f, 0.15528339f, -0.00667133f, -0.05891649f, -0.22202666f, 
    -0.01542201f, -0.00446726f, -0.02590702f, 0.07805120f, 0.02053867f, -0.03060739f, -0.08297352f, -0.10208663f, 
    0.15504812f, 0.12419432f, 0.12889393f, 0.30354917f, -0.13481265f, -0.16781940f, -0.09045103f, 0.01498745f, 
    -0.03355079f, -0.08802647f, -0.04154970f, -0.08730739f, 0.22436863f, 0.02990210f, -0.06950002f, 0.16789852f, 
    -0.20400825f, -0.07320650f, -0.12103580f, -0.01779283f, 0.00832034f, -0.07615911f, 0.02983638f, 0.02119054f, 
    0.05661079f, -0.10180286f, -0.13561477f, -0.29939339f, 0.00419178f, 0.05493640f, -0.04346498f, -0.06416651f, 
    0.01277976f, 0.08042595f, -0.08357281f, 0.02852871f, 0.25904861f, 0.03546271f, -0.21572196f, 0.05927175f, 
    -0.02680109f, 0.01012326f, 0.05454875f, -0.01369731f, -0.02936921f, -0.01050178f, -0.08462624f, -0.08744008f, 
    0.39342654f, -0.00543459f, 0.11320732f, 0.15227054f, 0.00243343f, 0.06118894f, 0.03357285f, -0.02878976f, 
    -0.00171711f, -0.07734150f, 0.03311542f, 0.07251835f, -0.48755595f, 0.09093907f, -0.09340050f, -0.15580666f, 
    0.09893054f, 0.00652247f, 0.14956069f, -0.02664956f, -0.10229474f, 0.00352499f, -0.02840209f, -0.07225537f, 
    0.14213312f, 0.08622973f, -0.18386805f, -0.01696245f, 0.01366512f, -0.03244259f, 0.00517647f, -0.03921999f, 
    -0.18992874f, -0.00203924f, 0.02789374f, -0.04930716f, -0.27845880f, -0.00933125f, 0.03792213f, -0.14402676f, 
    0.15946947f, -0.18514457f, 0.04990500f, -0.01244095f, -0.10542415f, 0.06907189f, -0.06155808f, 0.01909753f, 
    -0.15581003f, -0.07533480f, 0.16684093f, 0.10085613f, 0.02904032f, 0.04798045f, -0.02456923f, -0.03231960f, 
    -0.05511678f, -0.09974573f, 0.12736018f, -0.06882725f, 0.10995363f, -0.01482559f, -0.21175238f, -0.17559277f, 
    0.06474850f, -0.07250442f, -0.19126722f, 0.01830523f, -0.04060977f, 0.03344017f, 0.05322088f, 0.06802486f, 
    -0.04546466f, -0.20702332f, -0.06013607f, -0.01216719f, -0.15046391f, -0.00511672f, -0.13694394f, -0.00748749f, 
    0.06342005f, -0.03909407f, -0.04091524f, 0.04627392f, 0.13157353f, 0.03247761f, 0.15043354f, -0.03681242f, 
    0.03403571f, -0.01982260f, -0.02573834f, 0.06689887f, 0.00276477f, -0.09791943f, 0.02238807f, -0.08936897f, 
    0.43020058f, -0.08370850f, 0.08676751f, 0.08649019f, -0.05514910f, -0.04098658f, 0.08581573f, 0.01583301f, 
    -0.01782078f, 0.08426481f, 0.09012656f, 0.01120643f, 0.30330947f, -0.00542803f, -0.16370636f, 0.12989600f, 
    0.01657914f, -0.03406320f, 0.06507163f, -0.01719484f, -0.01479024f, -0.05729346f, -0.02732462f, 0.02873022f, 
    -0.01366395f, -0.06360727f, 0.00564045f, -0.04781500f, 0.14424597f, -0.01322303f, -0.02449818f, 0.04856341f, 
    -0.03126424f, -0.01052551f, 0.03005284f, -0.05385087f, 0.07786076f, -0.08723440f, -0.19592510f, -0.11452021f, 
    -0.03866462f, -0.01110774f, -0.13159506f, 0.02633497f, -0.00192000f, -0.04801501f, -0.01618210f, -0.06553125f, 
    0.23129682f, -0.10152630f, -0.12703492f, -0.02087664f, 0.00529562f, 0.07609934f, -0.08774655f, 0.02034616f, 
    -0.03268634f, 0.02322451f, 0.08085942f, -0.04421356f, -0.12056289f, 0.17631434f, -0.01242699f, -0.02751012f, 
    0.00975207f, -0.03667885f, 0.03444669f, 0.02835318f, -0.11228936f, 0.02253514f, 0.02694637f, 0.03675829f, 
    0.02056040f, -0.07389320f, -0.21926574f, 0.04473119f, -0.09017541f, -0.01407764f, 0.09638316f, -0.05234117f, 
    -0.09262463f, 0.01298589f, -0.01052651f, -0.00092847f, 0.02921904f, 0.09864008f, 0.01183721f, -0.06204558f, 
    0.00456110f, 0.07982635f, 0.05033897f, 0.01448386f, -0.03980257f, 0.03795670f, -0.01151232f, -0.03618379f, 
    -0.28698310f, 0.00514005f, -0.03107555f, -0.14633620f, 0.05641507f, 0.08265524f, 0.05379413f, 0.01169660f, 
    0.02056253f, 0.01465527f, -0.06461518f, -0.10638598f, 0.18196683f, -0.07475054f, -0.05049454f, 0.02584155f, 
    0.03774647f, 0.02904259f, -0.06001852f, -0.10861047f, 0.02999496f, -0.03853839f, 0.09967703f, 0.03139473f, 
    0.18566276f, 0.09866228f, 0.14137112f, 0.08215940f, -0.00094100f, -0.12228244f, -0.09611165f, 0.07065894f, 
    -0.07946841f, 0.00497691f, 0.01910851f, -0.01935410f, -0.17271422f, -0.09599807f, -0.13588983f, 0.00002681f, 
    -0.07870859f, 0.06000870f, -0.10915959f, 0.05565469f, -0.06710772f, -0.05777235f, -0.13200974f, -0.09291229f, 
    0.11427620f, 0.04426571f, -0.25805965f, 0.04179018f, 0.06557794f, -0.00008130f, 0.00664793f, -0.05100367f, 
    0.05865695f, 0.02076869f, 0.05555461f, 0.05360815f, 0.11953489f, 0.01963554f, -0.20974603f, -0.17885944f, 
    -0.03425712f, 0.02568001f, 0.01206877f, -0.02473976f, -0.06653351f, -0.04054038f, 0.00707937f, 0.00140748f, 
    -0.32192785f, -0.20297316f, -0.00245281f, -0.04982869f, -0.12194719f, 0.04501894f, -0.01701346f, -0.06482270f, 
    0.06641023f, -0.09055600f, -0.01565697f, -0.07617430f, -0.49727938f, -0.10100770f, 0.15184982f, -0.23051140f, 
    -0.04030400f, 0.11723813f, -0.02152373f, 0.02838265f, 0.06309703f, -0.17713714f, -0.00316468f, 0.02275610f, 
    0.22007747f, 0.00368477f, 0.23565724f, 0.12681529f, -0.14587213f, 0.00872592f, 0.06246252f, 0.14127667f, 
    -0.02505296f, -0.01427604f, -0.00845326f, -0.04818625f, 0.03097817f, -0.01166417f, -0.03515976f, -0.01843500f, 
    0.05341401f, 0.03232383f, 0.03421296f, -0.11319425f, -0.02640434f, 0.01131940f, 0.01043388f, -0.04107375f, 
    0.32446107f, -0.13189638f, -0.07420763f, 0.03798404f, -0.05238159f, 0.03760526f, -0.03749163f, 0.03510611f, 
    0.01885414f, 0.05217250f, 0.05075150f, -0.08009528f, 0.00708885f, 0.20376337f, 0.01020076f, 0.18031394f, 
    -0.04348323f, -0.06371117f, 0.12884398f, 0.12184834f, -0.13534588f, -0.03160293f, -0.04619596f, 0.03242401f, 
    0.04285565f, -0.05655496f, -0.00123180f, 0.00131968f, 0.06296490f, 0.05612617f, -0.00976599f, -0.05192650f, 
    0.02427687f, 0.04303201f, -0.07346456f, -0.03430609f, 0.04771542f, -0.05932066f, 0.01136794f, -0.14646763f, 
    0.11423142f, -0.05600005f, -0.05543890f, 0.05267005f, -0.04031042f, -0.00543557f, -0.01763548f, -0.07519864f, 
    0.25248319f, -0.10323302f, -0.18881117f, 0.36468577f, -0.02543714f, 0.10590253f, 0.08438913f, 0.06264208f, 
    0.05738927f, 0.03515670f, -0.04467605f, 0.00190191f, 0.03123975f, 0.00522667f, 0.00226066f, 0.22628342f, 
    0.05530523f, -0.03749063f, 0.02291080f, -0.01659983f, -0.07302060f, -0.01492281f, 0.00658150f, -0.26213700f, 
    -0.02162627f, -0.07798199f, -0.27402967f, -0.20656975f, -0.04703802f, 0.01134075f, 0.04627253f, 0.01567581f, 
    0.00134471f, -0.01929879f, -0.01700083f, 0.00772950f, -0.00963330f, 0.30607221f, 0.01501322f, 0.03872634f, 
    0.04550467f, 0.04232388f, -0.01651218f, -0.00156437f, -0.10634008f, 0.00530143f, 0.08191749f, 0.11316387f, 
    -0.52944821f, -0.14444502f, 0.05116354f, -0.06883972f, -0.10301566f, 0.01505096f, 0.07521437f, -0.07161265f, 
    0.08039665f, -0.02001986f, -0.02269318f, -0.05880335f, -0.02704909f, -0.11941523f, 0.02585485f, -0.04129849f, 
    -0.06678795f, 0.04467397f, -0.04874962f, 0.09580397f, 0.03926082f, -0.00021172f, 0.01353215f, 0.11672541f, 
    0.14176393f, -0.21858026f, -0.01897424f, 0.12942348f, -0.18151796f, -0.02094929f, -0.00987701f, 0.06514721f, 
    -0.03095139f, 0.04876893f, -0.13114992f, 0.06459668f, -0.59865689f, -0.16330774f, -0.01965417f, -0.02313819f, 
    -0.11018751f, -0.03202692f, -0.02144192f, -0.03276921f, -0.07827424f, -0.12431649f, 0.00710367f, 0.06730392f, 
    -0.08764312f, -0.15383412f, -0.16348633f, 0.07467790f, -0.13751048f, -0.04963754f, -0.03424187f, 0.13863458f, 
    0.11492401f, -0.08194479f, 0.04957370f, -0.02205445f, 0.12728652f, -0.04083096f, 0.02529619f, -0.00331321f, 
    -0.09828212f, 0.07830683f, -0.01615828f, 0.03392617f, 0.00729224f, -0.00709724f, -0.04537284f, 0.06540158f, 
    0.10054105f, -0.04470906f, -0.09684010f, 0.12957728f, 0.00088445f, 0.17269991f, 0.08247328f, 0.00433831f, 
    0.09466466f, -0.02967919f, -0.05949073f, -0.01338239f, 0.00644234f, 0.07526639f, 0.01848269f, 0.07526940f, 
    -0.07891314f, -0.10444640f, 0.10153399f, 0.01407241f, -0.04742816f, 0.08039815f, -0.00692757f, -0.01307983f, 
    0.08571190f, 0.16580467f, -0.10387342f, 0.01885216f, 0.04019130f, -0.02271352f, -0.06623777f, 0.07966780f, 
    0.00256686f, -0.11327212f, -0.00008175f, 0.01680017f, 0.05480561f, 0.04996200f, 0.08437649f, -0.17716345f, 
    -0.04582936f, -0.05768114f, -0.03397004f, 0.07029336f, -0.00423478f, -0.03942466f, -0.01282746f, 0.07213742f, 
    -0.09617741f, 0.14746654f, 0.08122344f, -0.10054331f, 0.01131518f, 0.07175937f, -0.04040877f, 0.07549354f, 
    -0.01400521f, -0.01467279f, -0.07972282f, 0.05071010f, -0.11372454f, 0.16509350f, -0.05597945f, 0.00896392f, 
    0.06312257f, 0.07883339f, 0.00006063f, -0.04127593f, -0.03255458f, 0.04150964f, 0.02960924f, -0.02610085f, 
    0.00446606f, 0.12396668f, 0.02794810f, -0.02954243f, -0.08567408f, 0.06622545f, 0.13825323f, -0.00519545f, 
    -0.07377984f, 0.15656997f, -0.10259124f, -0.05658666f, -0.39068332f, 0.12465750f, -0.09010879f, 0.03202712f, 
    -0.06942557f, 0.05228539f, 0.05715932f, 0.02670726f, -0.04215733f, 0.01562007f, 0.11571550f, 0.09662241f, 
    -0.19623499f, -0.02766499f, -0.23774414f, -0.19091859f, -0.05496535f, -0.04952556f, -0.04096073f, -0.08028899f, 
    -0.07915556f, 0.04392201f, 0.06160603f, -0.00784773f, 0.08975809f, 0.07205024f, -0.03924149f, 0.00300605f, 
    -0.10645805f, -0.09220587f, -0.04400780f, -0.01692757f, -0.05283469f, -0.05256706f, -0.00858778f, -0.04092339f, 
    -0.24565999f, -0.12961794f, -0.10165416f, 0.04288421f, 0.02363901f, -0.05204969f, -0.09187446f, -0.11860742f, 
    0.01519095f, -0.00900575f, -0.04513585f, 0.00899683f, 0.32298335f, 0.10711481f, 0.03335349f, -0.00695896f, 
    0.07472666f, -0.12231807f, 0.11805284f, -0.01444992f, 0.00865436f, 0.08164226f, 0.01541634f, -0.09144048f, 
    -0.09828714f, -0.07881115f, -0.25300500f, 0.05836542f, -0.03341356f, 0.02412131f, -0.06846576f, 0.04162690f, 
    0.00398633f, 0.01125338f, -0.00378796f, -0.07191174f, 0.17077236f, -0.03641818f, -0.05999307f, 0.12694590f, 
    -0.19625793f, -0.09952639f, -0.01740800f, 0.06846397f, 0.04988800f, 0.02044291f, -0.03272186f, 0.03694185f, 
    -0.08737457f, -0.08345275f, -0.03024420f, -0.19202442f, 0.00446312f, -0.01314835f, 0.01952494f, -0.08775950f, 
    -0.00409085f, 0.01596518f, 0.04161341f, -0.01320581f, -0.06393732f, -0.54419965f, -0.16958174f, 0.22193773f, 
    0.06245336f, -0.01543238f, -0.03122213f, -0.02723744f, -0.00685271f, -0.05556599f, -0.12468868f, 0.02650565f, 
    -0.23634017f, -0.12017817f, 0.00578570f, -0.03847471f, -0.02499085f, 0.00987437f, -0.02254767f, 0.05941240f, 
    -0.02929121f, -0.04045758f, 0.01599829f, 0.11225859f, 0.07180061f, -0.01650392f, 0.14414737f, 0.03562923f, 
    0.05881828f, -0.07699689f, 0.02599712f, -0.01962873f, 0.01326235f, 0.01421696f, -0.10636698f, -0.05358808f, 
    -0.25619933f, 0.22492555f, 0.11052058f, 0.11901633f, -0.04549995f, 0.09632687f, 0.02889961f, -0.10671526f, 
    -0.04191024f, 0.01586160f, 0.05738436f, -0.00383580f, 0.13629492f, -0.11684501f, 0.03113717f, -0.02847929f, 
    0.01156437f, -0.08673677f, -0.01891939f, -0.06084066f, 0.03510031f, 0.06076385f, 0.05372424f, 0.04840376f, 
    0.00633170f, -0.01171683f, -0.07327404f, -0.22298804f, -0.04677459f, -0.05209653f, 0.05325418f, 0.01332612f, 
    0.04152657f, 0.00627937f, -0.01618863f, -0.02327842f, 0.22279523f, 0.01585941f, 0.01869189f, 0.06640586f, 
    0.02786708f, -0.08701438f, -0.02236960f, -0.05408520f, -0.07072347f, -0.11811326f, 0.05674569f, 0.02236127f, 
    0.17588863f, 0.10490056f, 0.04306285f, -0.02805546f, 0.00276755f, -0.03363000f, -0.07528687f, 0.00425844f, 
    0.06824710f, 0.11723898f, 0.03110202f, -0.05895423f, -0.34468293f, 0.28862637f, 0.09551689f, -0.05224461f, 
    0.08782712f, 0.01536675f, 0.02891691f, 0.03957494f, -0.08723068f, -0.03935391f, -0.03987490f, -0.02269749f, 
    0.16906634f, -0.14585273f, -0.14342654f, -0.00653420f, -0.11897191f, -0.14666435f, 0.03098172f, -0.07542679f, 
    -0.02162568f, -0.02948271f, -0.12497617f, 0.00657026f, 0.19991124f, -0.09405509f, -0.06767782f, 0.08633209f, 
    -0.04124414f, 0.04362523f, 0.00098475f, 0.06312521f, 0.05672623f, -0.02676681f, -0.02113385f, 0.01225538f, 
    -0.28276551f, 0.24517143f, -0.01150591f, 0.14580040f, 0.06231762f, 0.05444796f, 0.00250063f, 0.11306752f, 
    -0.02892350f, 0.05875638f, -0.04629336f, -0.11907160f, -0.09208941f, -0.03910678f, -0.03690055f, 0.12512954f, 
    0.00263246f, 0.08248777f, 0.06609742f, 0.07543192f, -0.03559315f, -0.00549829f, -0.00105924f, 0.07169025f, 
    -0.11094794f, 0.07615551f, -0.05470508f, -0.06916314f, 0.08075973f, 0.07466991f, -0.00910922f, -0.06289929f, 
    -0.01497116f, -0.04337357f, -0.05645176f, 0.08533630f, 0.06414381f, 0.19109169f, -0.09064045f, 0.04345021f, 
    0.00516849f, 0.00021253f, -0.03314492f, 0.08113642f, -0.09487282f, -0.01613235f, -0.04988632f, -0.02227142f, 
    0.11430139f, 0.05527142f, 0.06755381f, -0.00382239f, -0.02289576f, -0.08998063f, -0.06780240f, 0.01050806f, 
    -0.01440804f, -0.07247771f, -0.03840606f, -0.00579948f, -0.06587181f, -0.04791874f, 0.11897378f, -0.16155827f, 
    -0.11114666f, -0.08349513f, 0.02901911f, -0.02846942f, 0.05629174f, -0.08292905f, -0.08441351f, 0.06490897f, 
    -0.18737254f, 0.02901595f, 0.04667611f, -0.06972513f, -0.00166826f, -0.06966574f, -0.07552201f, 0.09037416f, 
    0.11843920f, -0.05921444f, 0.11011092f, -0.02730765f, -0.23042862f, 0.17604010f, 0.14924712f, 0.18768476f, 
    0.08319846f, 0.00565886f, 0.05785168f, -0.12523538f, -0.10525648f, 0.00335467f, -0.01319692f, -0.10926107f, 
    -0.13267563f, -0.31146863f, -0.09325811f, 0.02344610f, -0.05453690f, -0.09956682f, -0.02330512f, -0.04765115f, 
    0.07146451f, -0.01464486f, 0.14040200f, -0.01578829f, 0.00977701f, 0.15955451f, 0.05309405f, 0.05775769f, 
    0.05922549f, -0.02519558f, -0.15587433f, 0.03307470f, -0.04434307f, -0.05386990f, 0.03317285f, -0.11405484f, 
    -0.22640514f, 0.09269358f, 0.25913864f, 0.18079004f, 0.11309833f, 0.01122185f, -0.07934042f, -0.08397891f, 
    0.07516946f, 0.06246001f, 0.03834067f, -0.06908176f, 0.15743375f, -0.55861884f, -0.25577867f, 0.16360900f, 
    -0.06233821f, 0.02250311f, 0.00403432f, 0.01975697f, -0.11862965f, 0.03552512f, 0.03513446f, -0.00648365f, 
    0.50964403f, 0.22519341f, 0.09358009f, -0.07747737f, 0.05754325f, -0.05402279f, 0.02830652f, -0.03213590f, 
    -0.07618006f, -0.04900026f, -0.03435087f, -0.12373861f, -0.38301191f, -0.43396997f, -0.22263066f, -0.05289276f, 
    -0.10705935f, 0.02002363f, 0.07766216f, 0.01624003f, 0.03485660f, -0.03680417f, -0.01041488f, -0.03783860f, 
    0.11810064f, -0.02432938f, 0.06275035f, 0.07369423f, -0.03768213f, 0.14013648f, -0.02081181f, 0.00810218f, 
    0.02679980f, -0.05328004f, -0.05783584f, -0.00481888f, -0.15307848f, -0.19561180f, -0.11889687f, -0.06153424f, 
    0.07474858f, -0.00935767f, -0.10226071f, -0.08510395f, -0.13545921f, -0.06742599f, 0.02204846f, -0.07873867f, 
    0.01644837f, 0.12110247f, -0.02960579f, -0.13273844f, -0.01655014f, 0.01045297f, -0.02668715f, 0.05030869f, 
    0.05365524f, -0.08997717f, 0.07339066f, 0.04340456f, 0.17212385f, -0.23559590f, -0.14848298f, 0.15266785f, 
    0.06427539f, 0.07094929f, -0.14188567f, 0.03599434f, -0.01695228f, -0.00360606f, -0.01095345f, -0.03270417f, 
    -0.14066303f, 0.05652992f, 0.14342584f, 0.03100374f, -0.00171341f, -0.08283120f, 0.04852087f, 0.02388930f, 
    -0.05518838f, 0.07389676f, 0.08106516f, -0.11429438f, 0.06658971f, 0.19044743f, 0.20401594f, 0.02367154f, 
    0.00808636f, 0.10887743f, 0.07027610f, -0.01764181f, -0.02484634f, 0.11221667f, -0.07684703f, 0.00892286f, 
    0.11377016f, 0.15392955f, -0.09183735f, 0.12092844f, -0.10797040f, 0.08416224f, 0.02428314f, 0.13168482f, 
    -0.02468854f, -0.09347202f, 0.10556599f, -0.06558547f, -0.01752328f, 0.00272724f, -0.05198144f, 0.01226995f, 
    0.05401831f, -0.06690600f, -0.02714360f, -0.01432129f, 0.06477580f, 0.02948566f, -0.01359624f, -0.04178258f, 
    0.01125435f, -0.05269060f, -0.19224089f, -0.03053593f, -0.04226987f, -0.02285915f, 0.04859898f, -0.06988405f, 
    -0.08776954f, -0.01755852f, 0.14717910f, -0.04684770f, 0.19186552f, -0.03187605f, 0.05649130f, 0.10858283f, 
    0.00831809f, 0.08390903f, 0.03919058f, 0.07472050f, 0.02057795f, -0.05229001f, -0.03853812f, -0.13876694f, 
    -0.00921562f, 0.02648450f, 0.25041640f, -0.04262272f, -0.00422489f, 0.07215714f, -0.01742958f, 0.02495881f, 
    -0.09463675f, 0.06088887f, 0.00961591f, -0.09885646f, -0.19670202f, -0.03756179f, -0.08213498f, -0.04549687f, 
    -0.11324301f, -0.06766487f, -0.02839247f, 0.04808041f, -0.05534047f, 0.06360018f, -0.06050042f, 0.09005057f, 
    0.05072572f, -0.38194042f, -0.21342012f, 0.22605281f, 0.02051557f, 0.02762954f, 0.06777637f, -0.08972441f, 
    0.02402840f, 0.00668393f, -0.15769479f, 0.07181803f, 0.05353028f, 0.11475758f, 0.15796284f, 0.12244423f, 
    0.02591981f, 0.03663085f, -0.03145841f, 0.00451462f, 0.04854993f, 0.02181456f, -0.02418126f, -0.01604412f, 
    -0.09241646f, -0.02513648f, 0.12488771f, 0.06806131f, -0.14162254f, 0.10266335f, 0.01238332f, 0.10471302f, 
    -0.02775470f, -0.12449531f, -0.03037270f, 0.00569869f, -0.13354748f, -0.12157059f, 0.08670151f, -0.06267598f, 
    0.02508894f, 0.01713153f, -0.05474596f, -0.04520408f, 0.03431650f, -0.11814351f, -0.03870905f, -0.10079753f, 
    0.25556120f, -0.09852448f, -0.07109810f, 0.07722622f, -0.18275085f, -0.12333123f, -0.02152291f, 0.06402457f, 
    -0.05406526f, 0.02521662f, 0.07686217f, 0.05324230f, -0.23572722f, -0.10778960f, 0.13422409f, 0.04154169f, 
    -0.00115638f, 0.04639924f, -0.03854898f, -0.04828723f, -0.02698936f, -0.00077218f, 0.04059586f, -0.00177527f, 
    0.02475728f, 0.04079196f, -0.21115087f, 0.05891857f, -0.09307583f, 0.03179397f, 0.22654590f, 0.04999784f, 
    0.00380676f, -0.06366830f, 0.13361655f, -0.02000262f, -0.16824901f, 0.29805362f, -0.10176335f, -0.16395932f, 
    -0.01655276f, 0.05373007f, 0.01675053f, -0.00017736f, -0.09921148f, -0.01448028f, 0.05931249f, 0.02627685f, 
    -0.20834635f, 0.07373768f, 0.02360550f, 0.02807909f, -0.07108551f, 0.05430112f, 0.05775435f, 0.00835209f, 
    -0.04023710f, 0.09603822f, -0.06082594f, 0.06954032f, -0.32556105f, 0.19159290f, 0.12245108f, 0.14707305f, 
    -0.03216924f, -0.13696721f, -0.05706621f, -0.05992630f, 0.02167522f, -0.04038183f, -0.01341724f, -0.07227580f, 
    0.00609626f, 0.25554666f, -0.03905692f, -0.21153170f, -0.09038749f, -0.01160837f, -0.05600344f, -0.01118315f, 
    -0.07552674f, -0.08718938f, 0.11573906f, -0.01167165f, -0.04560431f, 0.16689456f, 0.10071298f, 0.08724806f, 
    -0.12557594f, 0.03407535f, 0.11716194f, 0.00494893f, -0.01898671f, 0.05565829f, -0.00071008f, 0.13724433f, 
    0.12801619f, -0.32029840f, -0.13021050f, -0.00116206f, -0.08216346f, -0.01659277f, 0.05045203f, -0.08709095f, 
    0.10505457f, 0.02651833f, 0.00584884f, -0.02500340f, -0.00207820f, -0.09266985f, -0.13432989f, -0.25126925f, 
    -0.05525654f, 0.01787049f, -0.02428204f, -0.01917418f, -0.09447950f, 0.01640191f, 0.08016108f, 0.04531016f, 
    0.08677363f, 0.16411583f, 0.05644268f, -0.03336645f, 0.10089526f, -0.05910910f, -0.11295421f, 0.07271482f, 
    -0.03581368f, 0.04385246f, -0.06151589f, 0.01162216f, 0.02937472f, -0.05078039f, -0.10104783f, -0.49286592f, 
    0.00809980f, 0.05195274f, -0.05665629f, 0.06729703f, -0.08955405f, -0.08916973f, -0.03766349f, 0.08103093f, 
    -0.37427959f, 0.07747639f, 0.08097672f, 0.06910644f, -0.00122488f, -0.06747767f, -0.11060733f, -0.03804859f, 
    0.10667299f, 0.00424076f, -0.10563260f, 0.06816839f, 0.13597730f, -0.21133925f, -0.04327760f, 0.11581521f, 
    0.00018020f, 0.03232077f, 0.00222859f, -0.10687229f, -0.03357874f, 0.07167775f, -0.10637493f, 0.03580844f, 
    0.13341121f, -0.16203895f, -0.05344403f, -0.13776961f, -0.06120929f, -0.10422986f, 0.10299764f, 0.04248598f, 
    0.09450386f, 0.01262990f, -0.06652765f, -0.01777438f, -0.30803114f, -0.03355191f, 0.19077934f, 0.04555984f, 
    0.02057950f, -0.07833455f, 0.01967327f, -0.02446091f, 0.10560847f, 0.00643487f, 0.02963715f, -0.00538192f, 
    -0.19493994f, -0.09837526f, -0.03370782f, 0.14379260f, 0.06034744f, -0.02647458f, -0.09175564f, -0.10085709f, 
    0.05038907f, 0.01712158f, 0.02973530f, -0.09040132f, 0.02974289f, 0.12927754f, -0.05060767f, 0.21769896f, 
    0.09265597f, -0.05685943f, 0.13500778f, 0.16532418f, 0.06669853f, 0.06636181f, 0.02487119f, -0.07547574f, 
    -0.20920013f, 0.11402478f, -0.17913474f, -0.08984292f, 0.10605428f, -0.13215093f, 0.00159566f, 0.10859805f, 
    0.05739911f, -0.08449522f, 0.01505419f, -0.14781494f, -0.09591482f, 0.15522912f, -0.04288960f, -0.32572123f, 
    0.02029296f, 0.01353771f, 0.01407099f, -0.10334305f, 0.11482368f, -0.02723105f, 0.09130536f, 0.09535305f, 
    -0.24675438f, 0.09017068f, 0.12945873f, -0.10706397f, 0.01640642f, 0.05294461f, 0.00506488f, 0.02859888f, 
    0.08115131f, -0.06210534f, 0.07830994f, -0.01833103f, -0.17061147f, -0.23060314f, 0.01269739f, 0.09418046f, 
    -0.20012125f, 0.11466294f, 0.06148108f, -0.00351000f, 0.03481971f, 0.03192227f, 0.05191309f, -0.03722910f, 
    -0.25059053f, 0.03752119f, 0.01776398f, 0.06419092f, 0.10536496f, -0.03051019f, -0.01693480f, 0.15702392f, 
    -0.00285744f, -0.00221699f, 0.02713799f, 0.01263250f, -0.15472582f, 0.02853362f, 0.19963798f, 0.04244860f, 
    -0.07690838f, 0.06026031f, -0.11827286f, -0.02093953f, 0.08737933f, -0.02911988f, -0.01824623f, -0.00995449f, 
    0.02936278f, -0.04754656f, 0.00156374f, -0.14823365f, 0.00740726f, -0.08833941f, -0.07110293f, -0.05819579f, 
    -0.01924460f, 0.03964197f, 0.09895782f, 0.13672741f, -0.40336928f, 0.04280505f, -0.09511770f, 0.06149473f, 
    -0.02873219f, -0.10008498f, 0.05991000f, 0.07349011f, -0.00150558f, -0.01915103f, 0.00728501f, -0.04185729f, 
    -0.38475859f, -0.06814718f, 0.07017261f, 0.00141685f, 0.08526187f, -0.07283435f, -0.06058334f, -0.10725621f, 
    0.03690077f, -0.02365913f, 0.03071729f, -0.03599005f, 0.01606474f, 0.15998754f, -0.00754109f, 0.03036402f, 
    0.04817982f, 0.10580418f, 0.02247594f, 0.09147004f, -0.04588300f, -0.09658797f, -0.02801450f, -0.00566978f, 
    -0.23634183f, -0.15459248f, 0.02465956f, 0.17591462f, 0.09166385f, 0.01349678f, 0.07210450f, 0.10713428f, 
    -0.04657563f, -0.02762455f, 0.04602062f, 0.04046999f, -0.31474528f, 0.02500832f, 0.01698621f, -0.00076022f, 
    -0.02155917f, -0.02443217f, 0.05496350f, 0.04671912f, -0.11051112f, -0.11731448f, -0.07801062f, -0.02075503f, 
    0.15847741f, 0.12761857f, -0.02748616f, -0.04395048f, -0.01433454f, -0.02305689f, 0.00993447f, 0.05432684f, 
    -0.07081997f, 0.03925087f, 0.05355239f, 0.12555955f, 0.08478144f, 0.08208691f, -0.05714270f, -0.14590393f, 
    0.02290453f, 0.02029181f, 0.11435842f, -0.00618324f, 0.09090735f, 0.09744444f, -0.08334807f, -0.04507525f, 
    -0.41687372f, 0.22475384f, 0.05134443f, -0.01888385f, -0.00534258f, 0.10181116f, 0.02706137f, 0.02253485f, 
    -0.02743547f, -0.07143338f, -0.10807735f, -0.00840397f, 0.04594479f, -0.01119701f, -0.02483160f, 0.13164900f, 
    -0.18351068f, -0.01368565f, -0.01171831f, -0.23841450f, -0.00523338f, -0.03137379f, 0.10389963f, -0.10421287f, 
    -0.03196876f, -0.11991203f, 0.07492119f, -0.07743455f, -0.00192340f, -0.03438308f, 0.10549747f, 0.07070291f, 
    -0.00548905f, 0.11511324f, -0.01937006f, -0.21907754f, -0.18059763f, -0.03112007f, 0.00572116f, -0.23306586f, 
    0.13598558f, 0.00387001f, -0.07019996f, -0.01455782f, 0.04836253f, -0.00007896f, -0.05449870f, -0.02373755f, 
    0.05139050f, 0.05739311f, 0.06384677f, 0.08653513f, 0.05597094f, -0.04637795f, -0.01204705f, -0.00841755f, 
    0.11360820f, -0.07862820f, -0.09140804f, 0.04623703f, 0.00134032f, -0.15682040f, -0.10210694f, -0.23032610f, 
    0.12072430f, 0.00496990f, -0.04609159f, 0.09945881f, 0.05371969f, -0.12402576f, -0.11327077f, 0.05557082f, 
    0.10082710f, -0.03154096f, 0.08703835f, 0.07543132f, -0.03680724f, 0.01543397f, 0.00575498f, 0.12687710f, 
    0.02308908f, -0.04200682f, 0.03944961f, -0.04080936f, -0.00248236f, 0.03098688f, 0.15840700f, 0.05459564f, 
    -0.02555278f, -0.02969405f, 0.14090525f, 0.07015681f, 0.03117986f, -0.00551289f, 0.06191330f, 0.00301246f, 
    0.16336383f, 0.05482053f, -0.09032983f, 0.02988376f, -0.04060589f, 0.02867414f, 0.16826166f, 0.01679369f, 
    -0.00983897f, 0.04068078f, 0.08603770f, 0.13234761f, -0.19057481f, -0.04140319f, 0.08901407f, -0.00517827f, 
    0.02922072f, -0.05324582f, -0.04621056f, -0.00356232f, 0.10291657f, -0.08148810f, 0.00505443f, -0.02438484f, 
    0.39996922f, 0.14346856f, -0.11909436f, 0.00287810f, -0.06448998f, 0.01692184f, 0.11969016f, 0.05613242f, 
    0.03377741f, -0.00151625f, 0.07746652f, 0.05824596f, -0.04361721f, -0.08776950f, 0.12636715f, 0.02662155f, 
    0.03186371f, 0.02950003f, -0.04730542f, -0.07914179f, 0.08912218f, -0.09242155f, 0.01765592f, 0.01032281f, 
    -0.25707814f, -0.06167698f, 0.21698533f, 0.05619699f, 0.11416036f, -0.08645516f, 0.03509041f, -0.08677694f, 
    -0.03495230f, 0.04531055f, -0.03453906f, 0.06938215f, -0.06253608f, -0.07202546f, 0.16904446f, -0.03008810f, 
    -0.10095135f, 0.01180774f, 0.00324006f, -0.01781579f, 0.04562420f, 0.09304752f, -0.04358555f, -0.13468578f, 
    0.39710310f, 0.19938143f, -0.07588505f, -0.19718699f, -0.08231750f, -0.02078222f, -0.01830853f, -0.11313352f, 
    0.05732474f, -0.11031915f, 0.07023028f, 0.03568194f, -0.18725742f, -0.17122664f, 0.12588190f, -0.03606351f, 
    -0.12454183f, -0.00643741f, -0.01937320f, -0.02027778f, 0.02924104f, 0.00315781f, -0.03128798f, 0.02346581f, 
    0.04474338f, -0.05891786f, -0.00721870f, 0.22190984f, -0.08746904f, 0.04250424f, 0.07152479f, 0.02023444f, 
    0.09958819f, -0.00428181f, 0.04377455f, 0.03403837f, 0.08436681f, 0.03636701f, 0.04223388f, 0.04934579f, 
    -0.04202671f, -0.08471476f, 0.07331427f, -0.04352993f, -0.05459659f, -0.05535393f, -0.03910939f, -0.07180373f, 
    0.30397040f, -0.05077124f, 0.07207716f, 0.14003581f, -0.00247566f, 0.05347159f, -0.02817593f, 0.08115545f, 
    0.07626089f, -0.04284493f, 0.01969583f, 0.04455811f, -0.17841981f, 0.12570010f, 0.09953212f, -0.10014197f, 
    0.06676758f, 0.03373179f, -0.14284214f, 0.03120694f, 0.08185195f, -0.06676938f, 0.01222181f, -0.06488280f, 
    -0.07222492f, 0.12049386f, -0.02238385f, 0.09467959f, -0.01042724f, 0.01876299f, -0.00933974f, -0.07110251f, 
    -0.05441563f, -0.08549222f, -0.09729489f, -0.04525114f, 0.27023995f, -0.11505835f, 0.09031513f, -0.21660072f, 
    -0.05489684f, -0.00890994f, 0.09161498f, 0.00779757f, 0.05055430f, -0.07917036f, 0.09115395f, -0.01757389f, 
    -0.25217053f, 0.07637876f, -0.16196895f, -0.11612177f, 0.06380823f, -0.00788789f, 0.03656346f, -0.05912650f, 
    -0.04952487f, -0.05037389f, -0.07079575f, 0.03480364f, 0.18397805f, -0.28375122f, 0.11079740f, -0.18827230f, 
    -0.03874688f, 0.04026312f, 0.07880865f, -0.02003270f, 0.00660254f, 0.00354260f, 0.06870816f, -0.06109693f, 
    -0.60050869f, 0.08919141f, 0.13648142f, 0.30452061f, 0.08380874f, -0.06203826f, 0.09189876f, -0.01867167f, 
    0.06446470f, 0.08760799f, 0.05678459f, 0.02446899f, -0.27666256f, -0.04900898f, 0.04009298f, 0.05116896f, 
    -0.01622241f, 0.04800543f, 0.00985462f, -0.04077688f, -0.03683520f, 0.03317203f, 0.02860587f, 0.07649927f, 
    -0.50133622f, 0.18257408f, -0.06441271f, -0.15504923f, 0.08224267f, 0.07984392f, -0.06873536f, 0.03261634f, 
    -0.08108991f, 0.00303101f, -0.03265612f, -0.06304932f, -0.24875271f, -0.17498198f, 0.26549882f, 0.15591538f, 
    -0.11429147f, 0.05648942f, 0.05549471f, 0.01308323f, 0.02412640f, -0.00360203f, 0.11090815f, 0.03258770f, 
    -0.20656511f, -0.01516275f, -0.05010289f, 0.01082860f, -0.02077186f, 0.03371483f, -0.03734643f, 0.05343708f, 
    -0.03957590f, -0.04501530f, 0.01281817f, 0.14731584f, -0.12858132f, 0.05542170f, 0.06892934f, 0.13090731f, 
    -0.05102744f, -0.00798741f, 0.00993793f, 0.04457122f, 0.10683560f, -0.06298107f, 0.02013854f, 0.08292340f, 
    0.05359245f, 0.00079963f, 0.12983565f, -0.00110114f, -0.00892845f, 0.05131240f, 0.01577465f, -0.06220587f, 
    -0.08448733f, -0.04684910f, 0.03256538f, 0.22402935f, -0.10815293f, 0.05648406f, 0.09469157f, 0.22008470f, 
    -0.01873320f, 0.00809024f, -0.01395292f, 0.01151718f, -0.03932551f, 0.10636511f, 0.01940062f, 0.19853291f, 
    0.03903031f, 0.06448152f, 0.19410186f, -0.15357067f, -0.03198026f, 0.01266414f, -0.07696374f, -0.12399288f, 
    0.11847047f, -0.13923520f, -0.01267235f, -0.11189599f, -0.06431656f, -0.06923515f, -0.09595851f, 0.08775380f, 
    0.05338601f, 0.07065267f, -0.00989269f, 0.01046118f, -0.04713193f, -0.05565408f, -0.13872869f, -0.09662430f, 
    -0.16593635f, 0.20871674f, 0.27708045f, -0.20555733f, -0.03354670f, 0.05236899f, -0.04762646f, 0.07558406f, 
    0.01001536f, 0.00097263f, -0.06603205f, -0.22903691f, -0.20139340f, 0.13657017f, 0.08593910f, -0.05278299f, 
    0.04745327f, -0.03343121f, -0.24098079f, 0.01617850f, -0.09746806f, 0.03162145f, 0.11911921f, -0.16482656f, 
    -0.03217357f, 0.09502732f, -0.04135607f, -0.00896303f, 0.09604419f, -0.07162543f, 0.00775803f, 0.14656986f, 
    0.02974482f, -0.01787513f, -0.12793289f, 0.03303449f, 0.08474477f, -0.07602434f, 0.08609441f, -0.05774382f, 
    -0.01930925f, 0.11461792f, 0.01230580f, 0.12485216f, -0.02575652f, 0.02621366f, 0.04174309f, 0.03162744f, 
    -0.04031845f, 0.16573891f, -0.02824719f, 0.23083977f, -0.00168653f, 0.04404381f, 0.08884861f, -0.05359693f, 
    -0.08334276f, 0.08169529f, -0.01915725f, -0.03667584f, 0.12277649f, -0.17410554f, -0.12120871f, 0.03869155f, 
    0.12789114f, -0.04725047f, 0.02401444f, 0.06221949f, 0.13147783f, 0.00247922f, -0.08960894f, -0.12085733f, 
    0.01840749f, -0.01122627f, 0.07243773f, -0.18011041f, -0.07401921f, -0.03353167f, -0.10503098f, -0.14751028f, 
    -0.12976100f, 0.02427864f, 0.06946120f, 0.15792671f, -0.06518596f, 0.22706343f, 0.04812246f, -0.21676660f, 
    -0.02384834f, 0.12727788f, -0.08669116f, 0.04471074f, 0.16000426f, -0.01204762f, -0.06846173f, -0.20234779f, 
    -0.16231804f, -0.23245130f, -0.08646354f, 0.04578435f, -0.00753044f, -0.06263603f, 0.00487196f, 0.02221103f, 
    0.20210078f, -0.17756428f, -0.09381519f, -0.01931768f, -0.30431229f, -0.09853613f, 0.18901043f, 0.05590106f, 
    0.04325232f, -0.00952050f, 0.12323691f, 0.04784504f, 0.02858545f, 0.09052549f, -0.11960195f, -0.07600699f, 
    -0.29583988f, -0.25165951f, -0.13456556f, 0.00305048f, 0.09639037f, 0.01916119f, 0.04397398f, -0.03363211f, 
    -0.06529623f, -0.11096448f, 0.07916339f, -0.10508703f, 0.18363857f, 0.01996225f, 0.03543361f, -0.01338481f, 
    0.04843874f, -0.09999032f, 0.00854340f, -0.01475251f, 0.09008694f, 0.06219525f, 0.01237021f, 0.10300751f, 
    -0.09358955f, 0.00127309f, -0.04882112f, 0.13992181f, 0.06466497f, 0.20650980f, -0.06576631f, -0.01956479f, 
    0.11030453f, 0.01132042f, 0.00724653f, 0.03370374f, 0.07665212f, -0.10001056f, 0.00753389f, 0.13983889f, 
    -0.07196087f, 0.06304724f, -0.03774941f, -0.07949615f, -0.09452905f, -0.10065841f, 0.01858119f, -0.10810443f, 
    0.07076255f, 0.01751002f, -0.01324173f, -0.11212046f, -0.05394672f, 0.10961191f, -0.00674937f, -0.14056484f, 
    0.02055701f, -0.02667872f, -0.17977703f, 0.09826913f, -0.36699629f, -0.22979927f, -0.15459813f, 0.01288082f, 
    0.06461709f, 0.03864400f, 0.03669501f, -0.03236471f, 0.05131855f, 0.10615014f, 0.05660626f, 0.09613939f, 
    -0.20403366f, 0.22047810f, 0.06248602f, -0.11315102f, 0.10913627f, 0.10902563f, -0.05604047f, -0.11895001f, 
    0.02949121f, 0.03928632f, -0.09764278f, 0.03993576f, -0.20349810f, -0.23254070f, 0.17085642f, -0.22410755f, 
    -0.06397371f, -0.03581333f, -0.00850420f, -0.19647339f, -0.04018287f, -0.08240940f, -0.01887582f, 0.06592695f, 
    -0.09396378f, -0.03131328f, 0.00784061f, 0.18640886f, -0.07211605f, -0.03665639f, 0.05198111f, 0.05969663f, 
    0.04302552f, -0.00572184f, 0.03775850f, -0.02909620f, -0.14961240f, 0.20980136f, -0.06737977f, 0.06231079f, 
    -0.02265193f, -0.06403487f, 0.04944996f, -0.04701855f, 0.02267408f, -0.20941678f, -0.03102359f, 0.05569135f, 
    -0.08424568f, 0.07316267f, -0.04825316f, -0.10185885f, -0.01551966f, -0.31417736f, -0.06189181f, 0.03693506f, 
    -0.03485772f, 0.05040528f, -0.09362727f, 0.06318545f, 0.10117365f, 0.00940513f, 0.06385124f, 0.13073623f, 
    -0.07041237f, -0.00166624f, 0.05707898f, -0.05900937f, -0.15543783f, 0.05278648f, 0.11945503f, 0.22045359f, 
    0.14033267f, 0.00548055f, 0.06183931f, -0.00426728f, 0.05540667f, 0.00318338f, -0.11349879f, -0.11897221f, 
    -0.00972073f, 0.08139025f, -0.10458154f, 0.11875589f, -0.53631675f, 0.02218199f, -0.00286025f, -0.33462498f, 
    0.09765597f, 0.06041113f, -0.01746980f, -0.02641773f, -0.01390153f, -0.01645634f, -0.10941622f, 0.03847422f, 
    0.08057477f, -0.02938859f, 0.11766235f, -0.13072337f, -0.01568505f, 0.00632452f, 0.07475594f, -0.00767096f, 
    -0.08134475f, -0.01429233f, 0.04656094f, -0.00912731f, -0.27072090f, -0.22747751f, -0.04320224f, 0.02882341f, 
    0.06091173f, 0.02366475f, -0.13701370f, -0.00373287f, 0.04607758f, 0.10188333f, 0.08478431f, 0.12937424f, 
    -0.30720645f, -0.10079719f, -0.23863186f, -0.00719522f, 0.13696969f, 0.13900343f, -0.00731251f, -0.06486083f, 
    0.17515735f, -0.00807284f, 0.04541714f, 0.03386885f, -0.25507665f, -0.11653993f, -0.11290766f, -0.03475928f, 
    0.09247158f, 0.08363443f, 0.18087001f, 0.09478796f, 0.06553603f, 0.13187444f, -0.04145193f, 0.00559941f, 
    -0.27527606f, -0.07061011f, 0.19373955f, 0.21988301f, 0.05833183f, -0.04408011f, 0.08629163f, 0.08813640f, 
    -0.03119024f, -0.01892592f, -0.07754964f, -0.17583734f, -0.10761801f, -0.16166466f, 0.05810532f, 0.06708256f, 
    0.04983103f, -0.05105683f, -0.12741955f, -0.03485075f, 0.15843390f, -0.03401597f, 0.07739674f, 0.00126446f, 
    -0.55011904f, 0.00378958f, -0.00113779f, -0.09452370f, 0.09886388f, 0.00588321f, -0.07135610f, 0.01165088f, 
    0.05996301f, 0.02170582f, 0.05455346f, -0.06547920f, 0.02919434f, 0.10467639f, 0.17455384f, 0.18901651f, 
    -0.04849682f, -0.13432969f, 0.02025627f, -0.11854780f, -0.05737346f, 0.06343091f, -0.03791139f, 0.08906334f, 
    -0.03573068f, -0.00598511f, 0.07253154f, 0.09460974f, -0.17385826f, 0.06053095f, -0.00322387f, 0.02144713f, 
    -0.00857660f, -0.03300917f, 0.05968252f, 0.19290884f, -0.00460873f, 0.12463577f, 0.26768970f, 0.20171329f, 
    -0.00202420f, 0.08246653f, 0.02448533f, 0.06359374f, 0.04466887f, -0.11126561f, 0.08528724f, -0.03957072f, 
    0.08170841f, -0.04195592f, -0.08617897f, 0.00869213f, -0.01815856f, 0.00411475f, 0.02747369f, 0.01431212f, 
    0.07391375f, 0.14831559f, 0.09976946f, 0.00973239f, -0.17387135f, 0.13422742f, 0.03464340f, 0.04455932f, 
    -0.10713061f, 0.06818938f, 0.10724695f, 0.06940816f, 0.00265928f, 0.04540619f, -0.07433039f, -0.09674670f, 
    -0.31417501f, -0.27787563f, -0.08875965f, 0.08730138f, 0.12505971f, 0.12989418f, 0.01297943f, -0.03225911f, 
    0.00762754f, 0.03427684f, 0.06094566f, -0.01121012f, 0.13233280f, -0.21281439f, -0.05069839f, 0.06981878f, 
    0.18628255f, -0.02180489f, 0.02851578f, 0.01254436f, 0.12120922f, 0.07914324f, -0.22763079f, 0.07579960f, 
    -0.08790208f, 0.02507983f, -0.00163325f, -0.04865941f, 0.07184713f, -0.10599574f, 0.03257306f, -0.10882793f, 
    0.09925155f, -0.21144363f, -0.05783601f, -0.18560028f, 0.10722219f, 0.06541002f, -0.00232836f, 0.01635751f, 
    0.00572938f, 0.05996047f, 0.01427560f, -0.06884135f, -0.09941672f, 0.04683876f, 0.00379432f, 0.17497560f, 
    -0.07024862f, 0.10525879f, 0.08053008f, -0.11823355f, -0.05417374f, -0.03183436f, -0.07999695f, -0.05277381f, 
    0.02767925f, 0.05084669f, -0.09528079f, 0.09081483f, 0.04901199f, 0.03722114f, -0.00960164f, 0.06079036f, 
    -0.08443712f, 0.01691848f, 0.10735155f, 0.11884426f, -0.04170955f, 0.10147321f, -0.03176266f, -0.06497304f, 
    0.13915062f, -0.01251267f, 0.08427086f, -0.08063634f, -0.09021534f, -0.04202422f, -0.06378150f, -0.05646658f, 
    -0.00927800f, -0.11813860f, -0.00409901f, 0.08746979f, 0.16176897f, -0.05068499f, 0.00243041f, -0.06248350f, 
    -0.14021471f, 0.08111932f, -0.18439774f, -0.00664397f, 0.11590345f, -0.08870605f, 0.01193288f, -0.06079982f, 
    0.03382655f, -0.22760017f, 0.25080973f, 0.31381503f, -0.07780112f, -0.12476792f, -0.00778775f, -0.00897794f, 
    -0.06030603f, 0.05476198f, -0.00108905f, 0.06486284f, 0.02625134f, 0.09949027f, -0.06685297f, -0.07987575f, 
    -0.05578938f, 0.04365226f, -0.03501660f, 0.05788724f, -0.08567944f, -0.07010061f, 0.15462051f, -0.07831274f, 
    0.09837847f, 0.00729904f, 0.05791157f, 0.03505233f, -0.01996299f, -0.18685472f, 0.15232433f, -0.07470138f, 
    -0.02920252f, 0.08173152f, 0.05380055f, 0.10666079f, -0.14355613f, 0.04155926f, 0.05276135f, -0.18897401f, 
    -0.02413472f, 0.02871476f, -0.05714437f, 0.08369286f, 0.16029549f, 0.09106608f, -0.03893693f, 0.09514043f, 
    -0.36007667f, -0.17463246f, -0.13410218f, -0.02735293f, 0.05391771f, 0.08480826f, 0.02076344f, -0.19243464f, 
    0.09510478f, 0.06471535f, 0.05904962f, -0.03497689f, -0.15333502f, 0.03345424f, -0.13721400f, 0.21769966f, 
    -0.13656031f, 0.04917853f, 0.16198342f, -0.02105907f, 0.10331132f, 0.05590953f, 0.04650076f, 0.11728400f, 
    0.03079904f, -0.10006940f, 0.01600313f, 0.29603556f, -0.16938952f, -0.01383545f, 0.02850635f, 0.07629459f, 
    -0.00383002f, 0.02737357f, 0.00577642f, -0.08219124f, -0.20296137f, -0.09075904f, 0.02980358f, 0.15144749f, 
    -0.04268485f, -0.15247506f, -0.02947016f, 0.10174093f, -0.05131162f, 0.00096422f, -0.07716874f, 0.01479953f, 
    -0.14001942f, -0.09174886f, 0.15200341f, 0.00996588f, 0.05411989f, 0.08731903f, 0.00238166f, 0.05611398f, 
    0.02410792f, 0.13845573f, 0.06493613f, 0.03181922f, -0.16796701f, 0.05578233f, -0.14154182f, 0.12999433f, 
    -0.10581144f, -0.18161342f, 0.06356055f, 0.12519869f, -0.03200252f, 0.10606009f, 0.00087373f, -0.00900732f, 
    -0.14713770f, 0.14051898f, -0.25546002f, -0.13820529f, 0.07235303f, 0.07693106f, -0.16873452f, -0.17752676f, 
    -0.00277321f, -0.08387747f, -0.03075406f, -0.14195818f, 0.04400677f, 0.02472370f, -0.03079395f, 0.14623620f, 
    0.00317242f, -0.05150061f, 0.03650488f, 0.01765744f, -0.19498549f, -0.00994593f, -0.03042645f, 0.06637824f, 
    -0.35859552f, 0.25797877f, -0.06364433f, -0.20628479f, 0.07888743f, -0.02420069f, 0.00384336f, -0.00865598f, 
    0.00531785f, -0.08560762f, -0.10754254f, 0.00405528f, 0.22259858f, -0.14938436f, -0.21239631f, -0.01176598f, 
    -0.07983323f, 0.03774788f, -0.26223189f, -0.14466712f, 0.02140888f, -0.09137212f, -0.03019002f, -0.10223980f, 
    0.11824062f, 0.01738781f, 0.06941633f, 0.06648660f, 0.16367957f, -0.01221693f, -0.00027823f, 0.10396711f, 
    -0.07615203f, 0.12480386f, -0.02348081f, 0.03766910f, 0.05859042f, 0.04807466f, -0.06631591f, 0.04244949f, 
    0.09467395f, -0.02028854f, 0.05409525f, -0.03193504f, -0.16028479f, -0.07367526f, 0.14985274f, 0.15112214f, 
    0.03678733f, 0.20571344f, 0.02786691f, -0.30279651f, -0.04862634f, 0.02245320f, 0.03512080f, -0.00451089f, 
    0.09468392f, 0.09667144f, -0.05580882f, -0.02801119f, 0.12718296f, -0.00772193f, -0.00037658f, 0.00699102f, 
    -0.01502806f, -0.00476877f, 0.00305674f, -0.05917367f, 0.02608464f, -0.01138144f, -0.05491311f, -0.13652366f, 
    -0.32823870f, 0.17431359f, 0.10199634f, -0.19859473f, -0.01037994f, -0.05968994f, 0.16701294f, -0.00930863f, 
    -0.10188450f, 0.15436369f, -0.05650933f, 0.05080465f, 0.24841462f, -0.19321904f, 0.00462846f, -0.07539779f, 
    0.00401984f, -0.06880251f, 0.03033121f, -0.11656285f, -0.02551550f, -0.00939974f, 0.18299027f, -0.03524786f, 
    0.09487403f, -0.33812290f, -0.00835639f, 0.03496259f, -0.03852713f, -0.01884932f, 0.04446364f, -0.02761630f, 
    0.03681171f, -0.07313256f, -0.03054627f, 0.13312016f, 0.10872446f, -0.26757905f, 0.10656653f, 0.04000597f, 
    0.02990104f, 0.02625854f, 0.20709707f, 0.04800067f, -0.05678594f, -0.02842088f, -0.08866423f, 0.14246994f, 
    0.01858296f, -0.00647025f, -0.15058593f, 0.24926333f, 0.03178432f, -0.04645751f, -0.11611514f, -0.02993284f, 
    0.03772889f, 0.00575481f, 0.00648505f, -0.07544587f, -0.10483943f, 0.16005751f, 0.16886550f, -0.13674697f, 
    0.05182782f, -0.07589110f, -0.04249342f, -0.01145255f, -0.06137864f, 0.09126543f, -0.01705679f, -0.05307703f, 
    -0.18264534f, 0.01660872f, 0.09314026f, -0.07164566f, -0.07410752f, -0.01446934f, 0.04794658f, -0.03681985f, 
    0.02618484f, -0.00516653f, -0.01960502f, -0.02549723f, -0.07998162f, -0.10393453f, -0.26282224f, -0.04708337f, 
    -0.16223514f, 0.04499501f, -0.08909795f, -0.07524759f, -0.03084723f, -0.06658550f, 0.08378662f, 0.17115834f, 
    -0.03885793f, 0.23294315f, 0.23723814f, 0.01924886f, 0.04812880f, 0.07336664f, 0.17616664f, 0.07253923f, 
    0.03682368f, 0.02180338f, -0.03077545f, -0.08192458f, 0.02601716f, -0.19794510f, -0.01265867f, -0.04659368f, 
    0.14562614f, 0.00271909f, 0.08766583f, -0.03200832f, -0.09761867f, -0.03846271f, -0.03041060f, 0.10836319f, 
    -0.10205436f, -0.07649568f, -0.21507238f, 0.14430676f, -0.10738500f, 0.14321828f, 0.01494517f, 0.00055116f, 
    -0.08331375f, 0.05013024f, 0.09421196f, 0.06029121f, 0.29095948f, -0.31487697f, 0.10661636f, -0.03697199f, 
    0.00163502f, 0.14050426f, -0.02589378f, -0.08774188f, 0.00569572f, 0.00576894f, 0.11114674f, -0.12573700f, 
    0.12917162f, -0.02169777f, -0.16719544f, 0.18890642f, -0.04626046f, 0.09307349f, 0.07517377f, -0.02430164f, 
    -0.07650536f, -0.01681304f, 0.02459062f, 0.12938125f, -0.13351926f, 0.00157591f, 0.10674810f, 0.04036799f, 
    0.01138197f, 0.02270275f, 0.00331090f, -0.00549106f, -0.00657793f, 0.11922173f, 0.03705794f, -0.04529197f, 
    -0.21077244f, 0.03094687f, -0.03809121f, 0.16872612f, 0.01929644f, -0.05761915f, -0.00968252f, -0.08055854f, 
    -0.11109897f, -0.00882053f, -0.06121190f, -0.07329136f, -0.04130938f, 0.16376935f, 0.08716179f, 0.00861217f, 
    0.10006501f, -0.05603703f, 0.04921573f, 0.04021657f, 0.02471826f, 0.06207085f, 0.05225582f, 0.09554243f, 
    -0.27444306f, -0.15699616f, -0.03100964f, 0.02913489f, -0.04864653f, -0.05545322f, -0.05010663f, 0.08989885f, 
    0.01546349f, 0.01882072f, 0.12865815f, 0.02851707f, -0.44161600f, 0.07930418f, -0.08592125f, -0.28475973f, 
    -0.05970780f, -0.00529798f, -0.09842067f, -0.02800912f, 0.05127119f, 0.04180793f, 0.01886687f, -0.03349754f, 
    0.00399805f, 0.03172924f, 0.09947246f, -0.05753737f, -0.23937385f, -0.05079491f, -0.02897394f, 0.09795033f, 
    -0.04588569f, -0.06399802f, -0.00842144f, -0.15871374f, 0.07867656f, -0.26409447f, -0.01498097f, 0.13018537f, 
    -0.05797440f, 0.10437926f, 0.00677841f, 0.10381829f, 0.00919087f, 0.08161767f, -0.05795514f, -0.00666613f, 
    -0.19819196f, 0.12217634f, -0.01558945f, 0.08671722f, 0.03966590f, -0.10080487f, 0.01621568f, -0.05583468f, 
    -0.06390010f, 0.03068904f, 0.06059644f, 0.01067116f, 0.10389405f, 0.08756602f, -0.12417976f, 0.32479998f, 
    0.15235479f, 0.19111124f, -0.05925711f, 0.04944874f, -0.00657278f, 0.13578267f, -0.05187606f, -0.01188375f, 
    0.03339532f, -0.23798087f, 0.11798709f, 0.12496566f, -0.00412187f, 0.00390458f, -0.00585226f, 0.00179854f, 
    -0.00196264f, 0.04896569f, 0.05594332f, 0.10808977f, 0.01051065f, 0.17919503f, 0.07622747f, -0.28385451f, 
    0.07203245f, 0.03363603f, -0.01667897f, 0.03789150f, 0.10938451f, -0.09663203f, -0.06886056f, -0.17632143f, 
    -0.02576517f, 0.26890278f, 0.10404219f, 0.19448005f, -0.05872474f, 0.00979637f, 0.11994658f, 0.08074348f, 
    0.00777289f, 0.06154853f, 0.05469216f, -0.37292850f, 0.12311134f, -0.03636756f, 0.09232620f, 0.02700316f, 
    -0.00949401f, -0.08319490f, 0.03502193f, 0.05861059f, 0.01656118f, -0.00163858f, 0.09805194f, 0.00675312f, 
    0.24467815f, 0.12548912f, -0.04907731f, -0.04622644f, -0.01327761f, 0.03535753f, -0.08263785f, -0.09961046f, 
    0.06801389f, -0.04570777f, 0.10363995f, 0.03760235f, -0.05657652f, -0.05317293f, 0.08930394f, -0.06491013f, 
    -0.03395680f, -0.02132591f, 0.02435953f, 0.01509934f, 0.06378499f, -0.11413285f, 0.03884702f, -0.06259039f, 
    -0.17040636f, -0.08520526f, -0.17881091f, -0.25873941f, -0.16380110f, -0.09256826f, -0.06801128f, -0.12521704f, 
    -0.19137102f, 0.03847695f, 0.07306521f, 0.07191640f, 0.12045006f, -0.14424130f, -0.05650379f, -0.04233627f, 
    -0.05611442f, 0.03568428f, -0.05409147f, -0.23719341f, -0.00880250f, -0.12955065f, 0.09666197f, -0.06646406f, 
    0.06639872f, 0.05064686f, -0.18197425f, 0.01389227f, -0.11095771f, -0.02787697f, -0.02833126f, 0.03196184f, 
    -0.19688913f, -0.00889259f, 0.11612993f, 0.05679918f, 0.30214220f, -0.11024757f, 0.09738231f, -0.05086412f, 
    0.03636036f, 0.04636650f, 0.07936705f, -0.01824816f, 0.00882115f, 0.08348142f, -0.09014315f, -0.04777902f, 
    0.11018830f, -0.05508942f, 0.07425562f, -0.16748954f, 0.01233428f, 0.00496778f, 0.09859802f, -0.04442425f, 
    -0.00488835f, -0.03512468f, 0.07247938f, -0.01860609f, -0.07608371f, -0.15453789f, -0.17705148f, 0.00901387f, 
    -0.03312689f, 0.03273733f, -0.06624382f, 0.02849939f, -0.08185491f, -0.12294237f, 0.10466702f, -0.00816471f, 
    0.12424931f, 0.04603978f, 0.20128289f, -0.07952414f, 0.16081145f, -0.19921124f, 0.16521695f, 0.03330515f, 
    0.05489892f, -0.04082342f, -0.11413133f, -0.03705507f, 0.22602941f, -0.12003542f, -0.01620668f, 0.14518487f, 
    -0.06827439f, 0.11185106f, -0.08924010f, -0.07095283f, 0.07403092f, -0.04876354f, 0.04771070f, -0.00592780f, 
    -0.28287178f, 0.06931260f, 0.08668473f, 0.03280072f, -0.01678807f, -0.07782875f, -0.01025202f, -0.01176426f, 
    -0.11434244f, -0.09263229f, 0.08844882f, -0.20873101f, 0.34429768f, 0.05185194f, 0.33755654f, 0.07880075f, 
    -0.01773558f, -0.01879815f, -0.10331577f, -0.01673692f, -0.09327088f, -0.00434134f, 0.03502225f, 0.02956482f, 
    -0.14810172f, 0.04195803f, -0.05899549f, -0.30013290f, -0.09748006f, 0.03221979f, -0.09232550f, -0.06088077f, 
    -0.11160178f, 0.03790026f, -0.00731436f, 0.04825432f, -0.14187689f, -0.09318013f, -0.31720954f, 0.26026756f, 
    -0.04078403f, 0.03826052f, 0.01626934f, -0.15454549f, -0.11509950f, -0.06034380f, -0.02978582f, -0.17139859f, 
    0.17727683f, -0.37655851f, -0.27656466f, 0.12412063f, -0.06478067f, 0.08435884f, -0.06500545f, 0.02490572f, 
    -0.08655515f, 0.04888915f, 0.04320423f, 0.17439637f, 0.19213080f, -0.02781636f, -0.05165713f, -0.13246244f, 
    -0.03682416f, 0.11612192f, -0.07161468f, -0.09398969f, 0.11245691f, -0.14467919f, -0.08950872f, -0.00699740f, 
    -0.09695661f, 0.13030355f, 0.08954152f, -0.21973877f, 0.03186387f, 0.09885852f, 0.08124476f, 0.05831559f, 
    0.01999670f, -0.06160476f, 0.01369717f, -0.06657727f, 0.08675487f, -0.03556676f, 0.02235513f, -0.28981319f, 
    0.00147371f, 0.00492203f, 0.00583548f, 0.02717626f, 0.02512584f, 0.13657467f, -0.05191234f, 0.04860973f, 
    0.27083224f, 0.10830083f, -0.22310744f, -0.34844077f, 0.03016531f, -0.00881517f, 0.06735484f, 0.02044201f, 
    0.03787903f, 0.03437455f, -0.02018784f, -0.07472073f, -0.03313086f, 0.10315304f, 0.14182225f, -0.23125988f, 
    0.09705864f, 0.04305270f, 0.00685109f, -0.00773063f, -0.05661092f, 0.15819243f, 0.03059157f, 0.13494132f, 
    -0.10011899f, -0.07130092f, 0.06687286f, 0.10580493f, 0.07862766f, -0.00174069f, -0.01051590f, -0.09885340f, 
    0.00293150f, 0.04792544f, -0.11716394f, 0.10484836f, -0.21549937f, 0.15665878f, 0.05188844f, 0.01402477f, 
    -0.00345606f, 0.00160046f, -0.03082910f, 0.01336720f, -0.02922179f, 0.00486461f, -0.06672159f, 0.01499922f, 
    -0.09135357f, -0.01524946f, -0.01255237f, -0.02841645f, 0.00956981f, 0.06624845f, -0.03487850f, 0.01741187f, 
    -0.01923633f, -0.15841827f, -0.01305794f, 0.02491268f, -0.02408241f, 0.04998092f, 0.02051169f, -0.19681306f, 
    0.02101951f, -0.05740326f, -0.10936314f, 0.05608644f, -0.08884880f, -0.11429126f, 0.09753849f, -0.07220329f, 
    0.01996456f, 0.03357792f, -0.05393654f, -0.06056321f, -0.14358453f, -0.00762377f, -0.09173413f, -0.03435753f, 
    -0.15771091f, 0.17292894f, 0.01046934f, 0.01113420f, -0.01188907f, -0.01166999f, -0.02543451f, -0.12564573f, 
    -0.02332819f, 0.01716189f, 0.02911477f, 0.01961111f, -0.06489316f, 0.08143964f, -0.03113266f, -0.04097817f, 
    0.14736646f, 0.08367220f, 0.15423085f, -0.05404523f, 0.03456118f, -0.15683453f, -0.08909795f, 0.01059406f, 
    0.10721818f, -0.06239491f, -0.02754306f, 0.09640203f, -0.03573816f, -0.18241024f, -0.13695984f, 0.13716999f, 
    -0.03481989f, 0.06533645f, -0.03076278f, 0.00286284f, 0.01609133f, -0.01743366f, 0.06257287f, 0.05568109f, 
    0.21278602f, -0.02329044f, -0.13428298f, -0.14112641f, -0.15547068f, -0.04062153f, -0.01141447f, -0.02217335f, 
    0.05176138f, -0.16062827f, -0.00572276f, 0.00485752f, -0.54371268f, 0.04917483f, -0.13880916f, 0.34589326f, 
    0.07805537f, 0.01937445f, 0.06522208f, -0.09603482f, -0.08728036f, -0.12262482f, -0.09633380f, -0.20454696f, 
    -0.11538325f, -0.45306495f, -0.08893219f, -0.15731016f, -0.08526146f, -0.02026153f, -0.02360641f, 0.10674351f, 
    0.01773936f, 0.09833929f, -0.00464559f, 0.23083852f, -0.06316882f, 0.19806711f, 0.02076195f, -0.04071666f, 
    -0.09146478f, 0.08578569f, 0.05082444f, 0.07880690f, 0.12628500f, -0.07617357f, -0.05841315f, 0.04879040f, 
    0.57247502f, -0.37851563f, 0.28943148f, -0.16621882f, 0.13855302f, -0.02627692f, 0.07011180f, 0.04689258f, 
    0.02563938f, 0.01932354f, 0.06392344f, 0.01045804f, -0.40182844f, -0.05356087f, -0.17505550f, 0.11829163f, 
    0.12479109f, -0.04113302f, 0.05504376f, -0.02131672f, 0.09235529f, -0.06407455f, 0.02912597f, 0.05615580f, 
    0.11822632f, 0.08874358f, 0.08656678f, -0.12503821f, -0.09183253f, -0.02160380f, 0.10722033f, 0.01208321f, 
    0.06828976f, -0.06076881f, 0.02077590f, -0.10266820f, -0.08975612f, 0.10780048f, 0.01422036f, -0.09235400f, 
    -0.11902754f, 0.07403404f, -0.01572940f, -0.03885280f, -0.09749310f, -0.07290242f, -0.07236319f, -0.08336011f, 
    -0.48296246f, 0.10356089f, -0.05068670f, 0.04268389f, -0.01306211f, -0.02084195f, -0.00096194f, -0.02245218f, 
    -0.06993864f, -0.00896625f, 0.03950945f, -0.04146360f, -0.14626716f, -0.07972994f, -0.13331944f, -0.01197061f, 
    -0.05518729f, -0.05647708f, -0.03363569f, -0.05422899f, 0.01130069f, 0.00819404f, 0.01609857f, 0.01152463f, 
    -0.22191265f, 0.08308920f, 0.06066200f, -0.02178490f, 0.01327024f, 0.00193258f, -0.01342871f, -0.02185151f, 
    -0.08428270f, 0.00745454f, -0.00453579f, 0.06042887f, 0.13510256f, -0.04634413f, 0.05322094f, -0.00355219f, 
    -0.04228893f, -0.05692047f, 0.04117933f, 0.01157462f, -0.00564396f, -0.00671650f, -0.08644272f, -0.05924813f, 
    -0.09055725f, -0.14476526f, -0.07131510f, -0.09785117f, -0.07575112f, -0.00163486f, -0.02527320f, -0.06319406f, 
    0.00153023f, -0.01077924f, 0.02817733f, -0.02839383f, 0.09381612f, -0.08106747f, 0.02552550f, -0.08934200f, 
    -0.05925725f, 0.01320593f, 0.00827969f, -0.03840300f, -0.02692680f, 0.03578566f, 0.02077392f, -0.04075607f, 
    -0.17988166f, 0.21058251f, 0.04284224f, -0.00304203f, -0.02595778f, 0.06200576f, 0.02016786f, 0.01453238f, 
    0.00811799f, 0.01989905f, 0.02364239f, 0.02287762f, 0.05663373f, -0.14218487f, -0.09437340f, -0.18618441f, 
    0.06841435f, 0.03608842f, -0.03956255f, -0.03727902f, 0.02388412f, -0.02116035f, 0.02394066f, 0.06904297f, 
    -0.24932513f, 0.23271523f, 0.00031300f, -0.01124078f, -0.13474050f, -0.07927829f, 0.01980309f, -0.06581692f, 
    -0.02944641f, 0.01524637f, -0.05972053f, -0.08579110f, 0.00986918f, 0.14737628f, 0.00097244f, 0.16372849f, 
    -0.00220325f, -0.01252883f, 0.03660714f, 0.03324482f, -0.12627737f, -0.08905992f, -0.05599821f, -0.10214106f, 
    -0.20105706f, -0.08885831f, -0.11097866f, 0.02089448f, 0.02248385f, 0.00160568f, -0.07146140f, -0.03858070f, 
    -0.04898991f, -0.09391443f, -0.03376370f, -0.09029733f, -0.00550261f, 0.04291607f, 0.18347129f, -0.04204378f, 
    0.07524773f, 0.01314668f, 0.01844816f, -0.03691114f, -0.01179557f, 0.06240320f, 0.06103077f, -0.04136334f, 
    -0.15860353f, 0.12931222f, -0.02700374f, 0.03001563f, 0.01839052f, -0.03548905f, -0.01714066f, -0.00193231f, 
    0.04946947f, 0.05064999f, -0.03606912f, -0.03375121f, 0.26440805f, 0.04603932f, 0.05496170f, 0.17092815f, 
    0.07768661f, -0.00741061f, 0.00031571f, 0.01175764f, -0.01696216f, -0.00609119f, -0.02227669f, -0.03689958f, 
    0.22742152f, 0.10646749f, 0.07007037f, 0.11011834f, 0.11908225f, -0.05009367f, 0.00804683f, -0.00816395f, 
    0.01733767f, -0.06043565f, -0.01816926f, 0.02218347f, -0.02863568f, -0.05731662f, -0.01067264f, -0.01064059f, 
    -0.05520234f, 0.01151260f, -0.06280795f, -0.07985601f, -0.01074008f, -0.01492363f, 0.03634540f, -0.05766391f, 
    -0.01050270f, -0.00676741f, 0.04142858f, 0.04558927f, 0.00582124f, -0.09495825f, 0.01777563f, -0.00712993f, 
    0.02984484f, -0.00108769f, 0.03838426f, -0.02240147f, 0.14256838f, -0.27387393f, 0.01141774f, -0.08244820f, 
    -0.01150876f, 0.02155450f, -0.02016937f, 0.00607432f, -0.06843939f, -0.00899672f, -0.03020304f, 0.00238458f, 
    -0.21067558f, 0.10850541f, 0.07409984f, 0.00031484f, 0.01665666f, 0.02242181f, 0.01906262f, -0.06553903f, 
    0.03832281f, 0.09426922f, 0.01774583f, -0.01311827f, 0.02837387f, 0.13687378f, 0.16648236f, 0.06485707f, 
    0.10232686f, 0.02425792f, 0.02874841f, -0.09064813f, -0.00572551f, 0.05067486f, 0.01359325f, -0.06154269f, 
    -0.00425666f, 0.05900758f, -0.04305199f, -0.02015733f, -0.00873278f, 0.03611696f, 0.04843116f, -0.04439825f, 
    0.00891407f, -0.04129824f, -0.05277558f, -0.05531067f, -0.17366798f, 0.00814947f, 0.11913947f, -0.06035033f, 
    0.03515627f, -0.00320901f, -0.04559219f, -0.07992840f, -0.00983208f, 0.03444250f, 0.10008316f, -0.07620320f, 
    -0.06583446f, -0.08894444f, -0.28179431f, 0.02442146f, -0.01638407f, -0.05183766f, 0.00032406f, -0.05606471f, 
    -0.09517585f, -0.03939475f, -0.02934690f, 0.02239576f, -0.28356975f, 0.02182929f, -0.09108327f, 0.00408015f, 
    0.01186270f, -0.04539690f, -0.05475357f, 0.05092784f, -0.03350057f, 0.06949594f, 0.02126396f, -0.03154691f, 
    -0.04571234f, -0.03922788f, -0.03623832f, -0.09498620f, -0.02320884f, -0.05399582f, -0.02594115f, -0.03749227f, 
    0.06490692f, -0.04005260f, 0.01094756f, -0.01549644f, -0.10604505f, -0.13145609f, -0.04832423f, -0.00989083f, 
    -0.04300905f, -0.11064657f, -0.04295493f, -0.05200521f, -0.00364352f, 0.06111758f, 0.03040537f, -0.09694990f, 
    -0.08974847f, -0.13358986f, -0.00572405f, -0.10681257f, 0.02006124f, 0.07621380f, 0.02147147f, -0.02878546f, 
    0.02723806f, 0.01097423f, -0.04866230f, 0.01932475f, 0.22232640f, -0.01019704f, 0.20782691f, -0.05083877f, 
    -0.04228470f, 0.06741513f, -0.02635917f, -0.01068076f, -0.01232738f, 0.11049940f, -0.07609394f, 0.01716179f, 
    0.20087489f, -0.11325555f, -0.01663498f, -0.08097194f, -0.04276974f, 0.00574752f, -0.03646194f, 0.02120364f, 
    -0.03430358f, -0.04764934f, -0.05622838f, 0.06821749f, 0.19588897f, 0.03536262f, 0.05639369f, 0.02411612f, 
    -0.02754820f, -0.01319902f, -0.06140081f, 0.00839501f, 0.04852508f, -0.02990486f, -0.03812500f, 0.01044923f, 
    0.06364239f, 0.11479184f, 0.12204207f, 0.15252645f, 0.15388842f, 0.06001154f, 0.05545374f, -0.02967094f, 
    -0.01703304f, 0.03286906f, 0.04891161f, -0.03697674f, 0.17311111f, 0.08318520f, 0.21469405f, 0.10940862f, 
    0.08315232f, 0.13442616f, -0.01729344f, -0.01645817f, -0.01699596f, -0.01884530f, 0.02898116f, -0.05970061f, 
    0.05955746f, 0.00985601f, 0.03179738f, 0.17582630f, 0.04906702f, -0.06376597f, -0.05836961f, -0.03554471f, 
    -0.06854362f, -0.02412001f, 0.00102298f, -0.02931118f, 0.16394775f, -0.32649925f, 0.12296087f, 0.03538661f, 
    0.13167746f, -0.07342187f, -0.05743045f, -0.13482456f, -0.01604061f, -0.03144784f, 0.05905304f, -0.07898312f, 
    0.17911798f, 0.07445168f, 0.21529944f, -0.06425197f, -0.02682603f, 0.06736678f, 0.01023718f, 0.06970980f, 
    -0.03055483f, 0.07214782f, -0.04820502f, -0.00039060f, -0.01924034f, 0.14978662f, -0.04926879f, 0.12025618f, 
    -0.04266480f, -0.07362557f, -0.10460842f, 0.00211873f, 0.00240200f, -0.07213335f, -0.05942593f, -0.10988075f, 
    0.07140771f, -0.35383055f, 0.13367136f, 0.10543355f, 0.09487086f, -0.08826764f, -0.03346955f, -0.01602004f, 
    -0.02004487f, -0.02215612f, -0.01738126f, -0.02705176f, -0.15705360f, -0.17669435f, -0.15526745f, -0.02344814f, 
    -0.07256090f, -0.02795217f, 0.00653646f, -0.05960643f, -0.02711869f, -0.05470403f, -0.06194016f, -0.02051364f, 
    -0.02644120f, 0.00297369f, -0.03018407f, -0.08136230f, -0.00200757f, 0.02109432f, -0.08446451f, -0.02161965f, 
    0.05845465f, 0.03816676f, 0.01758779f, 0.07431611f, 0.04416289f, 0.05822198f, 0.06687982f, 0.10507511f, 
    0.09453497f, -0.04385989f, 0.03183048f, 0.01255398f, -0.09558484f, 0.06086925f, 0.04319850f, 0.03060439f, 
    0.18127947f, 0.03454443f, 0.18409552f, 0.17485152f, 0.15146860f, 0.00064329f, -0.02884524f, -0.01223137f, 
    -0.05966356f, 0.00078965f, -0.05008708f, -0.07402665f, 0.09473369f, 0.23366843f, 0.16484892f, 0.24043199f, 
    0.13162945f, 0.11665851f, 0.07875393f, -0.02963632f, -0.01815565f, -0.06215976f, 0.04792077f, -0.08461895f, 
    0.00170587f, 0.17938550f, 0.03666753f, 0.05738773f, 0.06062150f, 0.08059529f, 0.04432536f, 0.00059464f, 
    0.04304877f, 0.02268156f, 0.07384992f, 0.06022127f, 0.09950291f, -0.15631908f, 0.05135553f, 0.09573999f, 
    -0.01031850f, -0.06760737f, -0.06426092f, -0.03563798f, 0.02767348f, -0.04352183f, -0.07127484f, -0.00071795f, 
    -0.10381828f, 0.21109898f, -0.00896411f, -0.06840369f, -0.11937574f, -0.03349780f, 0.03277736f, -0.04955592f, 
    -0.02611583f, -0.04647317f, -0.13303807f, -0.09483092f, 0.17164534f, -0.10706639f, 0.03431447f, 0.06525371f, 
    -0.00820757f, -0.06222874f, -0.00429987f, -0.00875010f, -0.03206926f, -0.02675742f, -0.06771484f, -0.07019745f, 
    0.12115145f, -0.02408657f, 0.01171811f, 0.02959961f, -0.07795530f, -0.07380123f, -0.03760985f, -0.06832109f, 
    -0.05376539f, 0.02893545f, -0.03258085f, -0.00980406f, -0.10413752f, -0.01720570f, -0.17304786f, -0.28735149f, 
    -0.02186299f, -0.09359993f, -0.04482134f, -0.05602727f, 0.00781186f, -0.09478324f, -0.04416764f, -0.03885349f, 
    -0.09130878f, 0.13003464f, 0.05493193f, 0.03582708f, 0.09728824f, -0.06838045f, -0.01056000f, -0.01850516f, 
    -0.06593798f, -0.11380743f, 0.00728506f, 0.00888624f, 0.06793537f, -0.00241179f, -0.11039727f, -0.19317763f, 
    0.03290797f, 0.01369240f, -0.01026309f, -0.05733353f, 0.02378077f, -0.07258701f, 0.08276965f, -0.04441743f, 
    -0.01699312f, 0.06518258f, -0.06424306f, 0.08350895f, -0.07290395f, -0.06678715f, -0.09367529f, 0.02275082f, 
    -0.00017925f, -0.04620321f, -0.00521110f, -0.09402664f, -0.19909586f, 0.02600532f, -0.14241423f, 0.01527011f, 
    -0.09744126f, 0.00749391f, -0.04680670f, -0.06445479f, -0.05609454f, 0.00014237f, 0.03640471f, -0.01668077f, 
    -0.05967461f, 0.17172697f, 0.06023848f, 0.14025642f, 0.09233101f, -0.02519307f, 0.00183861f, -0.04818961f, 
    0.00191012f, -0.02840930f, -0.01775702f, -0.09732164f, 0.11069760f, -0.00141212f, -0.05556105f, -0.03252213f, 
    -0.13119891f, -0.05228016f, -0.09483130f, 0.02181229f, -0.06119379f, 0.01102553f, -0.03370202f, -0.09520338f, 
    0.05189772f, -0.44180754f, 0.08912853f, 0.06393567f, 0.05094338f, 0.00310422f, -0.01577980f, -0.03781559f, 
    -0.12543613f, -0.03641130f, -0.04362924f, -0.04435041f, 0.23071925f, -0.19285168f, 0.06089189f, 0.20949998f, 
    0.08821858f, -0.09447566f, 0.03472750f, -0.07380141f, -0.04395359f, -0.06711487f, -0.04471058f, -0.11226363f, 
    -0.14401135f, 0.03521835f, -0.08642168f, 0.01848220f, -0.02108989f, -0.00989241f, 0.01866719f, 0.01951242f, 
    -0.07083751f, -0.00666546f, -0.08367448f, -0.03652966f, 0.07954022f, -0.01628581f, 0.02760877f, 0.14708635f, 
    0.03694115f, -0.06364550f, -0.04624863f, -0.00617637f, -0.00785166f, -0.06462889f, -0.00638391f, -0.11648588f, 
    0.08967719f, 0.09015959f, 0.09204566f, 0.03617840f, -0.03523721f, 0.08468461f, 0.10326910f, 0.01064111f, 
    -0.02221776f, 0.08482745f, -0.07520395f, 0.02269188f, -0.16980307f, -0.14734346f, 0.01829365f, 0.10087904f, 
    0.00006425f, -0.04545898f, -0.00274177f, -0.04201899f, -0.02820899f, -0.05434304f, -0.01767982f, -0.05618843f, 
    0.32728499f, -0.08408403f, 0.03888870f, -0.16205341f, -0.03325360f, 0.03106089f, -0.01808565f, -0.00157824f, 
    -0.03517202f, 0.09044865f, -0.01647811f, -0.02187306f, 0.00734371f, 0.10334248f, -0.04295760f, 0.04313110f, 
    -0.05746933f, -0.01567864f, -0.00082305f, -0.04702806f, -0.00119124f, -0.04517709f, 0.00124142f, -0.07264477f, 
    -0.21210827f, 0.05863162f, -0.11973426f, -0.16645502f, 0.02218232f, 0.00209246f, 0.01784053f, -0.03922298f, 
    -0.00245143f, 0.01669005f, -0.04694065f, -0.08345038f, -0.08684394f, -0.01939253f, 0.04272365f, 0.10423792f, 
    -0.02577536f, -0.10187248f, -0.09453160f, 0.02091339f, -0.06709917f, -0.04430470f, 0.00250524f, -0.02046386f, 
    -0.04130422f, -0.19281568f, -0.08942947f, 0.15489283f, 0.07043454f, -0.00794072f, -0.04430551f, 0.04218827f, 
    0.06765624f, -0.03435345f, 0.08713505f, -0.02795037f, -0.08276650f, 0.03414918f, -0.08782170f, -0.04398704f, 
    -0.11159634f, 0.05952924f, 0.03665120f, -0.04647566f, 0.05147889f, 0.08585311f, -0.08900065f, 0.02285362f, 
    0.14805281f, -0.04802242f, -0.09323348f, 0.18349572f, 0.06468905f, 0.04074453f, -0.10400702f, -0.02339099f, 
    0.00878644f, -0.01537691f, 0.11663791f, -0.03244317f, 0.03049344f, -0.12750448f, -0.07736017f, -0.16500778f, 
    -0.00747752f, 0.05317505f, 0.00368745f, -0.07944635f, 0.00356946f, 0.02189643f, -0.14437173f, 0.00475665f, 
    0.26727140f, 0.02698750f, 0.05398785f, 0.16060075f, -0.02318344f, -0.08745472f, -0.08169371f, -0.10059284f, 
    -0.03644747f, 0.01141835f, -0.11954638f, -0.12631343f, 0.06315374f, 0.13982335f, 0.07309699f, -0.00815157f, 
    0.00759555f, -0.04990849f, -0.06230617f, 0.06975454f, 0.06905127f, 0.00876656f, 0.11205114f, -0.10858423f, 
    0.02300846f, 0.28712168f, -0.04514420f, -0.09347551f, -0.05882533f, -0.04791674f, -0.00699147f, -0.07688443f, 
    0.06398194f, -0.12554280f, 0.02205700f, 0.09459452f, 0.10329731f, -0.14287837f, -0.13373199f, 0.07695969f, 
    0.07416750f, 0.01243432f, -0.01138268f, -0.04372146f, 0.10031569f, 0.02227132f, 0.05739529f, -0.06170776f, 
    0.15205126f, -0.03358554f, 0.13480225f, 0.13447434f, -0.01140554f, 0.06440452f, -0.03867497f, -0.10766200f, 
    -0.04326925f, 0.01095023f, -0.04787691f, -0.06769323f, -0.24259824f, 0.11732822f, -0.12210146f, -0.24404733f, 
    -0.02855075f, 0.05019016f, -0.08067308f, 0.08096800f, 0.09104703f, -0.06770430f, -0.03556492f, -0.07706504f, 
    -0.06305163f, 0.00811743f, -0.01835920f, -0.03542664f, 0.07962695f, -0.04006625f, -0.09617255f, -0.08350939f, 
    0.01804366f, 0.05741895f, 0.09473918f, -0.01364644f, -0.14492857f, -0.04903959f, 0.08050494f, -0.10914950f, 
    -0.08555023f, 0.04201019f, -0.03315049f, 0.08720880f, 0.05878307f, 0.04103916f, -0.07156616f, 0.08464433f, 
    -0.00503970f, 0.14721370f, 0.12247492f, 0.05565900f, 0.04447895f, -0.03632851f, -0.02053770f, -0.02054412f, 
    -0.03161737f, 0.01484869f, 0.03724917f, 0.05357935f, 0.01611702f, -0.11288214f, 0.02309418f, -0.22924979f, 
    -0.05255222f, -0.02764665f, 0.12330512f, -0.05822082f, -0.07829504f, 0.08402302f, -0.02504199f, 0.01427968f, 
    0.13193646f, 0.03117717f, -0.11197579f, 0.02961303f, 0.00063264f, 0.05891344f, 0.14035545f, 0.03064356f, 
    -0.02198705f, -0.05923754f, -0.04588220f, -0.02249583f, 0.12008869f, -0.02490378f, 0.05028806f, -0.03039894f, 
    0.03811581f, -0.07466911f, 0.01469943f, 0.02659942f, 0.05213812f, 0.00500945f, 0.06657892f, 0.08150799f, 
    0.07875801f, 0.12472917f, -0.10445739f, 0.04093646f, 0.04527919f, -0.05517200f, -0.10489589f, 0.01605642f, 
    -0.01557935f, -0.04620154f, -0.03159703f, 0.04221624f, 0.11637992f, -0.27627566f, -0.35107461f, 0.04836346f, 
    0.14861786f, 0.02277106f, 0.01975301f, -0.06180025f, 0.04327090f, -0.01765938f, 0.11996675f, -0.06384244f, 
    0.07039768f, 0.17182265f, 0.00787582f, 0.16732244f, -0.10948685f, -0.04270326f, 0.06539050f, -0.09909906f, 
    -0.09399123f, -0.16918185f, -0.00887057f, 0.12784968f, -0.19322607f, 0.02388866f, 0.18435901f, -0.04524347f, 
    -0.08200879f, 0.00003557f, 0.05274714f, -0.18234316f, 0.00288932f, -0.04051858f, 0.09282774f, 0.06541353f, 
    0.06213620f, -0.05774273f, 0.10558211f, 0.12260696f, -0.05770716f, -0.07074752f, 0.00119209f, -0.09896748f, 
    -0.19396587f, 0.06032496f, 0.02548466f, 0.05154369f, -0.10867878f, -0.30865684f, 0.13584037f, 0.02329047f, 
    -0.08754823f, 0.03227000f, 0.02133217f, -0.11678294f, -0.06407779f, 0.07879360f, 0.00668946f, 0.14190893f, 
    0.19737184f, -0.01346787f, 0.06783468f, 0.11429288f, 0.02221282f, 0.03254489f, -0.05372785f, -0.09156729f, 
    0.03511024f, 0.02756291f, 0.05586926f, -0.02806661f, -0.00089054f, 0.18896036f, -0.33283496f, -0.04222814f, 
    0.02184728f, 0.01631477f, -0.15778776f, -0.02730096f, 0.02618557f, -0.05730079f, 0.09770276f, 0.10964998f, 
    0.11685345f, -0.15649816f, 0.09528325f, 0.13816701f, -0.05702695f, 0.10758936f, -0.03282290f, 0.00696653f, 
    -0.00700952f, -0.03388025f, 0.01504323f, -0.06755612f, -0.13295670f, -0.17300418f, -0.06102320f, 0.11249324f, 
    0.05945283f, -0.01342725f, 0.02483802f, -0.02251860f, 0.07021507f, 0.05085056f, 0.07778815f, 0.07975994f, 
    -0.05852816f, -0.11950786f, 0.02488397f, 0.04251330f, 0.01973332f, -0.00232305f, -0.11574273f, 0.07260199f, 
    0.05359341f, -0.03663322f, -0.09245849f, 0.06833412f, -0.18983430f, 0.07350677f, 0.02416989f, -0.03261244f, 
    -0.05160215f, -0.02978432f, 0.01769843f, -0.11249343f, 0.03165881f, 0.08364772f, -0.07917979f, 0.08799616f, 
    0.03257276f, -0.04896228f, -0.11348503f, -0.06826535f, 0.00896288f, -0.02676122f, 0.00765645f, 0.02541108f, 
    0.03639066f, -0.00160037f, 0.11813641f, -0.02571169f, -0.00356935f, -0.07284348f, 0.00437196f, -0.15489525f, 
    0.12448776f, -0.05235815f, 0.08973583f, 0.01720316f, 0.02964084f, 0.05956098f, 0.05462450f, 0.02326057f, 
    -0.08543491f, 0.01155639f, 0.25893977f, -0.02952163f, 0.04433251f, 0.09769057f, -0.12268730f, -0.03445339f, 
    -0.11972822f, 0.06315542f, -0.00343857f, -0.08352165f, -0.03187027f, -0.04171499f, 0.10170183f, -0.05479750f, 
    0.06548484f, 0.01133079f, 0.15868810f, 0.05239722f, 0.05250650f, -0.02763570f, -0.02815717f, 0.06815277f, 
    -0.09018359f, 0.03602297f, -0.05151642f, -0.19275706f, 0.09569222f, -0.06527815f, 0.00238768f, 0.01854127f, 
    0.06742898f, 0.07897801f, -0.11666708f, -0.06425432f, 0.03400996f, -0.11763925f, 0.01230653f, -0.04602697f, 
    -0.04594806f, -0.03333924f, -0.04653718f, -0.08374069f, 0.10163122f, 0.03719113f, -0.03866548f, -0.00425196f, 
    0.06951932f, 0.04500757f, 0.11636379f, -0.01621390f, -0.01613473f, -0.05130996f, -0.04865833f, 0.03036008f, 
    0.00558752f, -0.00268187f, -0.01314806f, 0.02780135f, -0.06247284f, 0.16032118f, -0.25835869f, -0.19712134f, 
    0.04839908f, 0.06440940f, -0.12141224f, 0.07097708f, 0.07727178f, 0.10003740f, 0.00882795f, -0.00551397f, 
    0.04621040f, 0.02970980f, -0.06793237f, -0.00001735f, 0.00869673f, -0.00455146f, -0.05652232f, -0.08294367f, 
    -0.00162603f, -0.02734466f, -0.05113373f, 0.15785564f, -0.07037636f, 0.12715760f, -0.19967683f, -0.00471736f, 
    0.01556142f, -0.01868360f, -0.07799020f, -0.11128300f, 0.05686769f, -0.01812394f, 0.00017586f, -0.02327827f, 
    -0.18169560f, -0.08666620f, -0.08439931f, 0.00616153f, -0.04044335f, 0.04681714f, 0.07306749f, 0.00209940f, 
    0.07527518f, 0.02147323f, -0.05666729f, -0.07182000f, 0.02407824f, -0.22294988f, 0.05474840f, -0.29972562f, 
    -0.05536394f, -0.05276165f, -0.00759385f, -0.14781846f, -0.01599230f, -0.07093316f, -0.04675270f, -0.11575828f, 
    -0.17273268f, -0.15826307f, 0.15899141f, -0.13535996f, -0.01462318f, 0.03994161f, 0.09548969f, 0.01510424f, 
    0.06191324f, -0.07356887f, 0.09778188f, -0.02417542f, 0.08711421f, 0.16973567f, 0.01774757f, -0.01273992f, 
    0.07744653f, -0.16339007f, 0.09787384f, -0.04273157f, -0.00954832f, -0.08017380f, -0.02327285f, 0.11936528f, 
    0.06437401f, -0.06898743f, -0.00083864f, 0.02071327f, -0.05460393f, -0.09343503f, -0.01636237f, 0.02637984f, 
    -0.03238803f, -0.04918140f, 0.03787836f, -0.20360930f, -0.18489860f, -0.06478576f, -0.12779592f, -0.09315530f, 
    -0.01669497f, -0.01226592f, -0.04501976f, -0.14036830f, -0.05344062f, -0.02555136f, 0.01680378f, 0.01024813f, 
    0.13667238f, -0.04080895f, 0.18467177f, 0.15060845f, 0.00507283f, 0.01799067f, -0.02212609f, -0.01520541f, 
    -0.06913566f, 0.06220527f, 0.05752043f, -0.05437352f, -0.16772999f, -0.16207099f, -0.07713277f, -0.22569053f, 
    -0.02185673f, -0.08019823f, 0.05566635f, -0.09047566f, -0.02158905f, 0.03921425f, -0.06260688f, 0.04243066f, 
    -0.18527895f, -0.14301983f, 0.00401538f, -0.11913736f, 0.04742515f, 0.00876575f, 0.06978283f, -0.01772475f, 
    0.06948792f, -0.03947822f, 0.11411256f, 0.09804332f, 0.09715962f, -0.00907506f, 0.00962974f, 0.04316225f, 
    0.11192242f, -0.03456147f, -0.00771539f, -0.04039045f, 0.02507804f, -0.09148191f, 0.02819511f, -0.01905891f, 
    -0.13593782f, -0.06706533f, -0.09002898f, -0.21901399f, -0.00606826f, -0.00263839f, -0.10063946f, 0.00916703f, 
    0.04793443f, 0.04753612f, -0.01769719f, -0.00955263f, 0.07861436f, -0.20158297f, -0.04530634f, 0.06278596f, 
    0.09212027f, -0.00650201f, 0.03297012f, -0.03305702f, 0.06254180f, -0.06874952f, -0.00516656f, 0.00656431f, 
    -0.17406446f, -0.04053092f, -0.20264739f, -0.15273638f, -0.04901621f, -0.03015781f, -0.14633627f, -0.02506252f, 
    0.02653806f, 0.08426172f, 0.02789263f, -0.06185400f, 0.01713455f, 0.03325000f, -0.03542466f, 0.19116725f, 
    -0.01990878f, 0.03454459f, 0.04047559f, 0.01328579f, -0.00243868f, 0.09453842f, -0.06584477f, 0.01512489f, 
    -0.14403552f, -0.01864300f, 0.17962998f, 0.03386542f, 0.00554590f, -0.01919183f, 0.03167857f, -0.07323131f, 
    0.00776894f, -0.01355538f, 0.00606183f, 0.06957990f, -0.07073095f, -0.00058756f, 0.09159961f, -0.02176735f, 
    -0.08081220f, -0.05779738f, -0.01953804f, -0.15220357f, 0.00183004f, 0.01531489f, -0.08760245f, 0.13641900f, 
    0.01032684f, -0.07187203f, 0.05639970f, 0.10632651f, 0.12556377f, 0.00460675f, -0.00998057f, 0.07054181f, 
    0.01907352f, 0.10057683f, 0.00245034f, -0.01651494f, 0.18433748f, -0.02326356f, -0.08183844f, -0.18946412f, 
    0.03418466f, -0.01367072f, 0.03740345f, 0.01991862f, 0.06417547f, -0.02717080f, -0.09424505f, 0.03149962f, 
    -0.25805554f, 0.17486805f, -0.01118705f, -0.05673522f, -0.15706685f, 0.01337138f, 0.13937503f, 0.05888167f, 
    0.03791169f, 0.06326636f, -0.11330225f, -0.00156260f, 0.24509530f, 0.01487716f, -0.25901246f, -0.22208703f, 
    -0.00149351f, -0.01116086f, 0.08220495f, -0.00773878f, 0.04012877f, -0.01611825f, 0.00261330f, 0.09130049f, 
    -0.00653074f, 0.03211434f, 0.13745955f, 0.04421211f, -0.09108792f, -0.05960633f, -0.05326842f, -0.03012176f, 
    -0.07337391f, -0.06282991f, -0.06218548f, -0.04723496f, -0.03236668f, 0.00452647f, -0.06365860f, -0.00700364f, 
    0.06163920f, 0.09892578f, -0.13457872f, -0.03138940f, -0.03750205f, 0.02634483f, -0.07230221f, -0.01063024f, 
    -0.16034372f, -0.19710620f, 0.11337480f, -0.05343680f, 0.05440760f, -0.19571860f, 0.01869174f, 0.01020720f, 
    0.08291411f, -0.06940185f, -0.16184704f, 0.09172716f, -0.06866438f, 0.27355999f, -0.06034645f, 0.04859647f, 
    -0.03991322f, 0.20550944f, -0.26554319f, 0.00854251f, 0.07353880f, 0.07729758f, -0.04348719f, -0.09963746f, 
    0.10222556f, -0.13376169f, 0.02172729f, 0.14635302f, -0.02682193f, -0.02603427f, -0.04674731f, 0.04082496f, 
    0.06912617f, 0.01600693f, 0.10044894f, -0.22224490f, -0.20230716f, 0.07883419f, -0.14506383f, -0.18817393f, 
    -0.08392476f, 0.00762202f, -0.08025873f, -0.01560644f, 0.06581597f, 0.01517800f, 0.05828875f, -0.07105531f, 
    -0.33586201f, 0.21336672f, 0.02848621f, -0.29040864f, 0.05661332f, -0.02460362f, -0.04492868f, 0.06700758f, 
    0.02043104f, 0.10028331f, -0.02801996f, -0.07543223f, 0.15463866f, 0.21185236f, -0.38172674f, -0.15334624f, 
    0.01631415f, -0.10002207f, 0.03565062f, 0.02043172f, -0.04170480f, 0.01552821f, 0.12557018f, -0.02713905f, 
    -0.14865394f, 0.01736162f, -0.04512441f, 0.00215780f, 0.05161517f, 0.05363572f, -0.09708572f, -0.04726556f, 
    -0.05788425f, -0.02548325f, -0.01982992f, 0.04324495f, 0.04486294f, -0.05467407f, -0.01443149f, -0.08194203f, 
    -0.00269137f, -0.06872423f, 0.06570849f, 0.07817110f, 0.01673220f, 0.14522339f, -0.02330568f, 0.16916814f, 
    0.14730224f, 0.07158379f, -0.23012394f, -0.10620243f, 0.07932124f, 0.00437685f, -0.14826769f, -0.07573419f, 
    -0.02214804f, -0.00798585f, -0.03368927f, 0.04383109f, 0.38923246f, 0.10996863f, -0.18219845f, 0.04122477f, 
    0.02932933f, 0.00276224f, 0.07732051f, -0.06994384f, -0.16509897f, 0.00350782f, -0.08997814f, 0.10885801f, 
    -0.14206685f, 0.11094688f, 0.30978933f, 0.03999018f, 0.03737668f, 0.02354310f, 0.03892969f, 0.06160151f, 
    0.00134388f, 0.01502938f, 0.05960836f, -0.07396336f, 0.02938486f, -0.18172881f, 0.10815174f, -0.08293925f, 
    0.03334093f, 0.02562967f, -0.01324695f, -0.01430255f, -0.01214040f, -0.11868922f, -0.07981104f, 0.06153623f, 
    -0.02424630f, 0.14756784f, -0.18718123f, -0.18214135f, 0.07188395f, -0.00799956f, -0.08026985f, 0.08052332f, 
    0.13984962f, -0.03909416f, -0.00757090f, 0.03592193f, 0.08404071f, 0.19248331f, -0.00885781f, -0.09013890f, 
    0.12214334f, 0.11832029f, 0.06592046f, -0.05199579f, -0.11733475f, -0.01637515f, 0.02937004f, 0.04410475f, 
    0.05753331f, -0.06769766f, -0.04889778f, 0.13774784f, -0.01227243f, 0.01571815f, 0.04938586f, -0.02927487f, 
    -0.09041203f, -0.05102990f, -0.01141186f, -0.05068341f, -0.07140653f, -0.05140749f, -0.09219001f, 0.31072515f, 
    -0.05725226f, 0.04570762f, 0.02287616f, -0.10146329f, -0.09291795f, -0.07137880f, -0.03814732f, 0.13732204f, 
    0.07506961f, 0.07580175f, 0.07129551f, -0.14107455f, -0.02319307f, -0.01947070f, 0.12156381f, 0.00311305f, 
    0.11899064f, -0.00128526f, 0.03930226f, 0.01559019f, 0.18513636f, 0.06807865f, -0.04167462f, 0.27746919f, 
    0.08998999f, -0.00062870f, -0.09775397f, -0.00261101f, 0.00529840f, -0.05122171f, 0.04641859f, 0.04299092f, 
    0.24112585f, -0.27911338f, 0.25752854f, -0.07951269f, -0.01948672f, -0.01791559f, 0.05752880f, 0.01558368f, 
    0.10022068f, 0.05358986f, 0.10355090f, 0.09143454f, -0.01948569f, -0.01983827f, 0.11616065f, 0.01088618f, 
    -0.05529625f, 0.02742478f, 0.06770766f, -0.00567111f, 0.00258615f, -0.05498869f, -0.05246151f, -0.13498729f, 
    0.02934931f, -0.18017037f, 0.19639847f, 0.19041604f, 0.08539282f, -0.04919722f, 0.01733196f, 0.05236017f, 
    -0.05464242f, 0.04380191f, 0.09240868f, 0.05912812f, 0.00307148f, -0.21227907f, 0.06382140f, -0.12838309f, 
    -0.02328520f, 0.02207338f, -0.04196772f, 0.04196688f, -0.06168424f, -0.02558286f, -0.03293194f, 0.05419768f, 
    0.10931727f, 0.02316996f, -0.11950381f, 0.05190585f, 0.11302862f, -0.04206129f, 0.07515931f, 0.13542277f, 
    0.00994266f, -0.02397065f, 0.05116358f, -0.10883699f, -0.02261137f, -0.41858688f, -0.10978079f, -0.00672441f, 
    -0.03358689f, 0.00418789f, -0.04769745f, -0.05734217f, -0.06533126f, -0.08761661f, -0.00430410f, -0.04147380f, 
    0.15637542f, 0.07816213f, -0.04800443f, -0.08119738f, 0.20093179f, 0.04256713f, 0.11431448f, 0.01569018f, 
    0.05632659f, 0.06446696f, 0.03117368f, 0.07433206f, 0.01072831f, 0.11453936f, -0.23688571f, 0.41359344f, 
    -0.12998199f, 0.00212451f, 0.09814843f, 0.05329903f, -0.01519336f, 0.00429717f, -0.01300723f, -0.06984653f, 
    0.29274955f, 0.14130864f, 0.03609798f, -0.28023559f, -0.11573596f, -0.03141075f, 0.05545221f, -0.15878993f, 
    -0.15973467f, 0.10673365f, -0.11570095f, 0.07225205f, -0.05535147f, 0.09985323f, 0.26116392f, -0.08008182f, 
    -0.12420933f, -0.04700143f, -0.08287226f, 0.06542601f, -0.06230948f, -0.02226221f, -0.10390345f, -0.04841790f, 
    0.23496242f, 0.06264094f, 0.15102871f, -0.15970908f, 0.01677953f, 0.06650998f, 0.03375075f, -0.18316382f, 
    0.00617858f, 0.07906117f, -0.07172822f, 0.09703643f, -0.19392069f, 0.13614297f, -0.00923432f, -0.40049449f, 
    0.09915445f, 0.03062089f, -0.14655069f, 0.09147994f, -0.11262125f, 0.02138607f, -0.06628690f, -0.20539150f, 
    0.11467545f, -0.15639277f, 0.20806509f, -0.03831757f, 0.10543253f, 0.02468601f, -0.01603241f, -0.01737795f, 
    0.02708209f, -0.10875995f, 0.02517823f, 0.04038722f, 0.04023252f, -0.23031574f, -0.25025672f, 0.12041982f, 
    0.02068966f, -0.00715232f, 0.04171443f, -0.03147508f, 0.02712231f, 0.05860951f, 0.10463995f, -0.08537667f, 
    -0.15546387f, 0.03498141f, -0.06685783f, -0.18197779f, 0.00239885f, 0.08167390f, 0.09685276f, -0.02729527f, 
    -0.15903886f, -0.03544728f, -0.10766618f, 0.13448538f, 0.09996556f, -0.00974918f, -0.18784060f, 0.09225615f, 
    0.03380534f, -0.04113714f, 0.03338623f, -0.04550246f, -0.12860703f, 0.05347789f, -0.09376847f, -0.04947692f, 
    -0.21514654f, -0.09716360f, 0.04378033f, -0.03777252f, -0.01936543f, -0.09317948f, 0.07517645f, 0.05971652f, 
    0.14108600f, 0.00401383f, 0.01438104f, 0.03337335f, 0.06736640f, -0.02597488f, 0.01927244f, 0.08883251f, 
    0.07397100f, -0.05711908f, -0.15040934f, -0.05094577f, -0.17771448f, 0.13834749f, -0.07274080f, 0.03856752f, 
    -0.14525837f, -0.26885468f, 0.03474433f, 0.03247354f, -0.03680991f, 0.08008205f, -0.01340462f, -0.00182528f, 
    0.05545906f, 0.00355816f, 0.07788204f, 0.12332602f, 0.17600279f, -0.06727872f, 0.03873752f, 0.26668978f, 
    0.01134303f, -0.06204236f, 0.02409640f, 0.03941117f, -0.10592146f, -0.02171178f, -0.01052675f, 0.02522423f, 
    -0.31790635f, -0.14243965f, 0.00616391f, 0.01961136f, -0.01986946f, 0.01157101f, -0.10202304f, -0.00436217f, 
    -0.04110328f, 0.04693958f, -0.08507849f, -0.06946640f, -0.05037654f, -0.08980861f, 0.05866196f, -0.07520859f, 
    0.00840530f, 0.11332709f, 0.04347295f, 0.05052033f, 0.01110265f, 0.00687312f, -0.10403246f, -0.06601486f, 
    0.14543764f, -0.07964978f, 0.02687822f, 0.02473352f, -0.07250345f, -0.03760483f, -0.16540003f, 0.05168489f, 
    0.04065167f, 0.05364260f, 0.11655897f, -0.11099853f, -0.05626342f, 0.27736169f, -0.28569275f, 0.10870656f, 
    0.04033489f, 0.13518019f, 0.12912267f, -0.02328755f, -0.10488472f, 0.05642400f, -0.02996357f, 0.05201165f, 
    0.10772368f, -0.13058288f, 0.02158349f, -0.06815500f, -0.11039585f, 0.08989123f, -0.04794788f, 0.08121215f, 
    -0.12313392f, -0.06328391f, -0.02548229f, -0.05180119f, -0.14653963f, -0.06418329f, 0.01817532f, 0.14247602f, 
    0.00714842f, 0.00816042f, 0.04813673f, -0.04071021f, 0.07262569f, 0.06742909f, 0.00058168f, 0.03556660f, 
    0.00106760f, -0.15864837f, -0.19121502f, 0.11850072f, 0.02086943f, 0.05449835f, 0.05162952f, -0.07186092f, 
    -0.08508967f, 0.00082928f, -0.07051288f, -0.01231978f, -0.16793257f, -0.11790784f, 0.02220848f, -0.01698979f, 
    0.07200897f, -0.00713778f, -0.09226464f, 0.06559686f, -0.00403611f, -0.05472417f, 0.08879099f, 0.03983013f, 
    -0.31699803f, -0.11594326f, 0.04800550f, -0.07410767f, 0.11665957f, -0.05868760f, 0.03319747f, -0.03858067f, 
    0.04602965f, 0.05548662f, 0.05422307f, 0.12615471f, -0.13103969f, -0.09389615f, -0.10042027f, -0.23854981f, 
    0.03610802f, -0.05295836f, 0.07145892f, 0.03747300f, 0.05278125f, 0.03481653f, -0.00641168f, -0.05140547f, 
    -0.43211788f, 0.24141040f, -0.07298138f, -0.10255035f, 0.15312324f, -0.07391374f, 0.04417087f, -0.06622189f, 
    -0.04506183f, 0.00332571f, 0.01388891f, 0.06294899f, 0.01212244f, 0.01325229f, 0.00885025f, 0.01180640f, 
    -0.04368855f, 0.03463155f, -0.02049605f, -0.04975563f, 0.05739276f, -0.11762585f, 0.04899292f, -0.00928977f, 
    -0.10540008f, -0.02129610f, -0.01673780f, -0.20133324f, -0.15623882f, -0.04905770f, -0.00542644f, -0.02970215f, 
    0.04429742f, 0.07786263f, 0.06446138f, 0.01133260f, -0.13319348f, 0.09741235f, -0.09222738f, 0.03512233f, 
    -0.01413443f, -0.07113618f, 0.08488520f, -0.04722248f, -0.03557430f, -0.07840008f, -0.05514336f, -0.00398507f, 
    -0.20844553f, -0.21395387f, -0.14063309f, -0.03339358f, -0.10616575f, -0.01644165f, 0.03420590f, 0.07328636f, 
    -0.05994241f, -0.20942512f, 0.04874722f, -0.15609582f, 0.08253296f, 0.10403576f, 0.16835412f, -0.02234033f, 
    -0.00205944f, 0.07214654f, 0.04203632f, -0.12883447f, 0.01494216f, -0.03733852f, -0.06275988f, -0.07143521f, 
    -0.20977204f, 0.05075343f, 0.06880539f, -0.05750699f, 0.03313360f, 0.07907230f, -0.04056858f, 0.03649563f, 
    0.01779410f, -0.01136155f, -0.15942056f, -0.07090602f, -0.33953956f, 0.30433950f, -0.20187181f, -0.22474018f, 
    0.05419862f, 0.02685262f, 0.08927637f, -0.11440682f, -0.11591969f, -0.09687328f, -0.04653346f, -0.07998218f, 
    -0.53262377f, -0.27224883f, -0.03439700f, 0.01136163f, 0.01706475f, -0.03906230f, 0.02596930f, 0.01418517f, 
    0.02588946f, -0.05602972f, 0.09216812f, 0.05160009f, 0.47399625f, 0.08681571f, 0.01859205f, -0.31477046f, 
    0.06086979f, 0.02549484f, 0.01418176f, 0.08911079f, -0.12465363f, -0.07208313f, -0.02262573f, -0.08747257f, 
    0.00841867f, -0.31438470f, -0.08861802f, -0.32599205f, 0.12062005f, 0.05288840f, -0.11532036f, 0.01249855f, 
    0.02155351f, -0.03199059f, 0.02197187f, -0.05430628f, 0.08454178f, -0.15606679f, 0.13014957f, -0.11162812f, 
    -0.01821144f, -0.15329866f, -0.02652116f, -0.06421766f, -0.12279579f, 0.00727040f, 0.06625444f, 0.10053171f, 
    -0.02723499f, 0.14164609f, -0.11338928f, 0.18999015f, 0.11461251f, 0.07121808f, -0.14226523f, 0.15623872f, 
    -0.05869762f, 0.08470137f, 0.03265462f, -0.02659306f, 0.45526308f, 0.01753906f, 0.20539586f, -0.10706282f, 
    -0.04844521f, 0.01222558f, 0.06469386f, -0.01148170f, -0.09095328f, 0.03901228f, -0.02990564f, 0.04593404f, 
    -0.17320743f, 0.05751897f, 0.01787881f, 0.04074319f, 0.10590394f, 0.06979383f, -0.00854722f, 0.03926864f, 
    0.03359168f, 0.03447729f, -0.01915460f, -0.04254847f, -0.01953439f, -0.10412962f, 0.08643357f, -0.24125953f, 
    -0.02849548f, -0.09743956f, -0.07131590f, 0.03851272f, 0.07067012f, 0.08190559f, 0.05321120f, -0.01881869f, 
    0.25293320f, 0.01866286f, -0.00749128f, -0.00022611f, 0.04882146f, 0.00060762f, 0.08002072f, 0.01107022f, 
    0.05893692f, -0.00757536f, 0.16019826f, 0.07651812f, -0.09169950f, 0.17387325f, 0.05534063f, 0.14096427f, 
    0.05336764f, -0.02706486f, 0.05845360f, 0.17605849f, -0.02476517f, 0.13796437f, -0.08675910f, 0.08877478f, 
    -0.16415626f, 0.19672346f, -0.03438805f, -0.28664562f, 0.03464724f, 0.08440468f, -0.05972266f, 0.01616340f, 
    -0.07240773f, 0.02691973f, -0.08176267f, -0.01111809f, 0.10899653f, -0.23015751f, -0.06882408f, -0.10409772f, 
    -0.10993925f, 0.03984864f, 0.02129682f, 0.02872844f, 0.05731053f, -0.00086581f, 0.03606154f, -0.04873834f, 
    -0.20535851f, -0.28815117f, -0.04075496f, -0.27612057f, 0.02572697f, -0.18935168f, -0.10680719f, -0.00502190f, 
    0.02246985f, -0.03813169f, 0.09746073f, 0.08712410f, 0.17587118f, 0.13065353f, 0.04009604f, -0.19711043f, 
    0.08650482f, 0.04579238f, 0.09523756f, 0.10740165f, 0.09008233f, 0.06824248f, 0.05371606f, 0.20561624f, 
    -0.24816167f, -0.28903583f, -0.19849312f, 0.03294211f, 0.01362245f, -0.00872668f, -0.08462908f, -0.01705970f, 
    0.00623547f, 0.02550512f, -0.02893054f, 0.06858070f, 0.00290773f, -0.01240447f, 0.02326888f, 0.01215910f, 
    0.00679509f, 0.09743419f, 0.00583477f, -0.03609941f, 0.07080618f, -0.00769270f, -0.13236082f, -0.13975900f, 
    0.05609104f, 0.09615283f, -0.20684609f, -0.13601807f, -0.01278438f, -0.12499534f, -0.11324526f, 0.08397967f, 
    -0.00131250f, -0.02233363f, -0.08578975f, -0.04196509f, -0.05837099f, -0.22420423f, 0.04265305f, -0.03882664f, 
    -0.10242365f, 0.02709924f, -0.04053806f, -0.08420542f, -0.01916851f, 0.02551699f, 0.02935456f, -0.10653085f, 
    -0.17005996f, 0.01559786f, -0.05389225f, -0.04460472f, -0.02617818f, 0.00013527f, 0.01877168f, -0.05910764f, 
    0.06704711f, -0.02878882f, 0.07870696f, -0.13678205f, -0.38430193f, -0.09456620f, -0.03460890f, 0.00739057f, 
    0.05633393f, 0.02317210f, 0.02477171f, 0.00612419f, 0.11440556f, 0.11408678f, 0.01076528f, -0.04205753f, 
    -0.60109794f, -0.39349738f, 0.00333726f, -0.08442640f, 0.02504607f, 0.10007861f, 0.01059636f, -0.12364374f, 
    0.10038648f, 0.06174167f, 0.02790673f, 0.01575092f, -0.07866797f, -0.02764268f, -0.02361994f, 0.07485824f, 
    0.03344079f, -0.04319936f, 0.01053172f, -0.11639187f, 0.01606233f, 0.00515489f, -0.02688700f, -0.09325299f, 
    -0.32543272f, -0.00115792f, 0.04337115f, -0.08400355f, 0.05769726f, -0.09630980f, -0.09407032f, 0.03454604f, 
    -0.06269886f, 0.06302536f, 0.05337609f, 0.14604089f, 0.33585107f, -0.11129702f, -0.05638306f, 0.18880472f, 
    -0.03772640f, -0.07291745f, -0.08218594f, 0.06475392f, -0.08841796f, 0.04335873f, -0.00633354f, -0.05020686f, 
    -0.04082676f, -0.01430114f, -0.01625578f, -0.06578577f, -0.01755870f, -0.05247089f, 0.08681711f, 0.05436393f, 
    0.00618574f, 0.08454187f, 0.01307863f, 0.02670205f, -0.11301327f, 0.07074299f, -0.09616306f, 0.14570221f, 
    0.05486185f, 0.01498434f, 0.13104795f, 0.00865158f, 0.03033515f, 0.12232868f, 0.09054001f, -0.03141823f, 
    -0.10317910f, 0.14187422f, -0.18818098f, 0.10430069f, -0.01562477f, -0.02867480f, -0.06324759f, -0.03422905f, 
    0.01582038f, 0.02070535f, 0.00407983f, -0.22158347f, 0.16502614f, 0.10620042f, 0.13045986f, -0.05593835f, 
    0.00717002f, 0.03209053f, 0.11822842f, 0.05794958f, -0.05567542f, -0.00352079f, 0.15715638f, 0.09955700f, 
    0.09920254f, -0.12610258f, 0.11598951f, 0.00696846f, -0.12591489f, 0.01760028f, -0.02208669f, 0.00004052f, 
    0.00359284f, -0.02560628f, 0.01358184f, 0.06583042f, -0.40752566f, -0.22042280f, 0.11325630f, 0.02648137f, 
    0.07285021f, 0.01227116f, -0.01135071f, -0.08820035f, 0.05645603f, -0.05024836f, -0.14848924f, -0.09929527f, 
    0.15875269f, 0.01982716f, 0.05733002f, 0.02293309f, 0.01865875f, -0.00839029f, 0.09075024f, 0.07222248f, 
    0.04195944f, 0.00925969f, -0.07189684f, 0.02711480f, 0.14946839f, 0.04282372f, -0.00887435f, -0.06337326f, 
    -0.03059769f, 0.01757795f, 0.01068861f, -0.06236421f, 0.03885017f, 0.09341609f, 0.02519056f, 0.04036147f, 
    -0.18159659f, -0.09346495f, -0.05006788f, -0.01345056f, -0.03813263f, 0.00359573f, -0.01233486f, 0.02563657f, 
    0.07751396f, 0.02147668f, 0.05579604f, 0.10315778f, 0.21219453f, 0.09991951f, -0.02513439f, 0.01733213f, 
    0.03218465f, 0.08332873f, -0.05696051f, 0.23496635f, -0.01287949f, -0.08677974f, -0.05863869f, 0.00146775f, 
    -0.47533029f, -0.24982370f, 0.08232246f, -0.12290701f, 0.08815017f, 0.04019281f, 0.01927648f, -0.01333651f, 
    0.06779078f, 0.11834110f, -0.04483018f, 0.08279645f, -0.50570881f, -0.14848079f, -0.01484228f, 0.03577950f, 
    0.22598909f, -0.00960131f, -0.00464592f, -0.05170232f, 0.01467605f, -0.07844771f, -0.00954641f, -0.02692571f, 
    0.05238460f, -0.01109140f, -0.04094443f, 0.04696596f, -0.03827634f, 0.03311421f, -0.01714638f, 0.05463130f, 
    -0.02083311f, 0.03124120f, -0.06683487f, -0.01118114f, -0.28588384f, -0.06154421f, 0.02631145f, -0.29663652f, 
    0.04225479f, -0.04559193f, -0.02324295f, -0.02571537f, -0.01178599f, 0.07583013f, 0.10176409f, 0.11647618f, 
    -0.36105916f, 0.04192948f, -0.10322971f, 0.06750200f, 0.07853770f, -0.01669292f, -0.09944739f, -0.05040119f, 
    -0.02581695f, -0.06275105f, -0.07641796f, 0.03532347f, 0.04932959f, -0.07374700f, -0.04410354f, 0.02218528f, 
    -0.03663799f, -0.00347925f, -0.04535557f, 0.09651636f, -0.03130615f, 0.04655027f, -0.03549141f, 0.05999088f, 
    0.12358215f, -0.07701684f, 0.05616130f, 0.01091988f, 0.05591460f, 0.03549032f, -0.05476670f, 0.08672224f, 
    0.02254738f, 0.12458184f, -0.02503804f, -0.03179317f, 0.06817706f, 0.01822747f, -0.03222413f, 0.00804270f, 
    0.03434748f, -0.00983064f, 0.09574176f, -0.03937217f, -0.03782170f, 0.01669467f, -0.03972440f, 0.06966805f, 
    0.16203293f, 0.02913990f, 0.05481208f, -0.04688425f, -0.13118486f, -0.04549829f, -0.03988646f, -0.04224429f, 
    -0.05964423f, -0.02434057f, -0.08558608f, -0.03784668f, 0.13248003f, -0.00574186f, -0.00993265f, -0.10065408f, 
    -0.11929427f, -0.01757565f, 0.10064019f, -0.03281138f, 0.08909349f, 0.10920046f, 0.00595898f, 0.02418619f, 
    -0.12953487f, 0.07964115f, -0.09001768f, 0.03930463f, 0.07045536f, 0.07190015f, -0.03891065f, 0.02596539f, 
    0.02065988f, -0.06248533f, -0.11798890f, -0.12188621f, -0.17792405f, 0.03537208f, -0.07972461f, -0.09035908f, 
    0.03376847f, 0.11744883f, -0.03853855f, 0.05438025f, 0.00968490f, 0.04645744f, 0.05687950f, 0.00853397f, 
    0.10310075f, -0.04473855f, -0.00564367f, -0.03749181f, 0.01004148f, 0.08108014f, -0.01464468f, 0.10142256f, 
    0.07903658f, 0.10690652f, -0.00736871f, 0.02260238f, 0.06643471f, -0.12948392f, 0.06503082f, -0.06547970f, 
    0.03813744f, 0.05915528f, -0.01745016f, 0.00444213f, -0.03732936f, 0.12164577f, 0.05847320f, 0.07690857f, 
    -0.25702906f, 0.13807502f, -0.05748638f, -0.09822930f, 0.00376682f, 0.04396524f, -0.14257088f, -0.06611983f, 
    -0.00696205f, -0.05141430f, 0.03617677f, 0.13579941f, -0.09318489f, -0.02711691f, 0.19248174f, -0.00409036f, 
    -0.02346252f, -0.10811855f, -0.04225165f, 0.01783497f, 0.05965307f, -0.04973754f, 0.04000464f, -0.08391119f, 
    -0.26475811f, -0.11344143f, 0.07920600f, 0.06015361f, 0.07089754f, -0.06271573f, -0.04279183f, -0.01076204f, 
    0.05765457f, 0.13725118f, -0.04540076f, -0.05121162f, 0.04417866f, 0.03189701f, 0.00137159f, 0.11949694f, 
    -0.04571662f, -0.01330872f, 0.00538007f, -0.13389426f, 0.10725359f, -0.00491330f, 0.06896722f, -0.06720018f, 
    0.13582453f, 0.13929945f, -0.10507951f, -0.03881729f, -0.07613672f, 0.07864696f, 0.13346557f, -0.03285590f, 
    -0.06127169f, 0.08706523f, 0.09044065f, -0.05092731f, 0.05299348f, -0.01933585f, -0.05381062f, -0.08650865f, 
    -0.10274056f, 0.00384898f, -0.07327298f, 0.01342640f, 0.01952795f, 0.07117328f, 0.04605529f, 0.05288906f, 
    0.05121796f, 0.10867234f, -0.08655732f, -0.04796400f, -0.07991350f, -0.11849887f, -0.04749226f, -0.05801500f, 
    -0.03398694f, -0.04579527f, -0.26017544f, -0.21998319f, 0.31387782f, 0.21841738f, -0.00476185f, -0.15085372f, 
    -0.05195516f, 0.09545917f, -0.08224693f, 0.14586198f, -0.03947001f, 0.04099281f, 0.00287428f, -0.00176889f, 
    -0.37776542f, -0.35083753f, -0.05098843f, -0.20356520f, 0.01800432f, 0.03607747f, 0.00706282f, -0.00878477f, 
    -0.01749953f, 0.00783571f, -0.08210167f, 0.06852202f, 0.08939979f, 0.20731588f, 0.14465232f, 0.06504571f, 
    0.03296257f, -0.02554128f, 0.06222963f, 0.05985770f, 0.06149910f, 0.04255286f, -0.02806627f, 0.12182108f, 
    0.25999287f, 0.12888649f, -0.02981133f, 0.01198292f, 0.09927177f, 0.00125884f, 0.02845962f, 0.07221749f, 
    -0.01849703f, -0.02621802f, -0.01287472f, -0.02661410f, -0.43196863f, -0.10343271f, -0.11271603f, -0.09100953f, 
    0.09018895f, 0.07433787f, 0.06467222f, -0.00677674f, 0.06966814f, -0.08439820f, -0.00096046f, 0.06700236f, 
    -0.14451702f, -0.01377925f, -0.06590833f, 0.00219509f, 0.10605633f, 0.11396541f, -0.00219475f, 0.07482443f, 
    0.02504699f, 0.18271339f, -0.00548139f, 0.07383228f, -0.42671651f, -0.05777586f, -0.04668548f, 0.03600465f, 
    0.10117926f, -0.05727774f, -0.03967644f, -0.07420930f, 0.01474742f, 0.07251541f, -0.01618606f, 0.10234059f, 
    0.12656495f, -0.00287095f, 0.00234873f, -0.04574332f, 0.10606895f, -0.00632448f, -0.04197251f, 0.06601530f, 
    -0.05172718f, 0.07722722f, 0.14363712f, -0.01155714f, -0.26619840f, -0.08802100f, -0.17762654f, -0.07933433f, 
    -0.00682933f, -0.07638399f, 0.11952065f, 0.03501954f, 0.13846891f, 0.10602467f, 0.05728264f, 0.22166149f, 
    0.06921083f, 0.05788190f, 0.02240153f, 0.05539600f, -0.08919438f, -0.08780026f, 0.06677779f, -0.01746978f, 
    -0.02437255f, -0.02153934f, -0.02692595f, 0.00269313f, -0.22622533f, 0.05363620f, 0.17604986f, 0.13706073f, 
    0.01134788f, -0.07104678f, 0.12108508f, -0.06018811f, 0.02475120f, 0.10828430f, 0.09530430f, 0.07310859f, 
    -0.33968270f, 0.16608186f, -0.12543058f, -0.35398996f, 0.06241940f, 0.09822787f, -0.09766719f, 0.11095724f, 
    0.11422864f, 0.04535607f, -0.04299378f, 0.04846214f, -0.29870531f, 0.13122959f, -0.15713620f, -0.03277921f, 
    0.00654321f, -0.02645049f, 0.00801698f, 0.01006833f, 0.02444162f, 0.03921085f, -0.03297089f, -0.06650282f, 
    0.18835540f, -0.00434771f, 0.08991136f, 0.12057592f, 0.07522407f, -0.15848942f, 0.07511738f, -0.09974452f, 
    0.09956476f, 0.05512958f, -0.08734116f, 0.05197778f, -0.13829444f, 0.12035342f, 0.15264921f, 0.09669094f, 
    0.12333125f, -0.04870227f, 0.00329083f, -0.02322425f, 0.01778901f, 0.16088547f, -0.00495998f, 0.12100688f, 
    0.22412294f, 0.14490391f, -0.01465230f, -0.09298529f, -0.15099595f, -0.07418697f, -0.02662855f, 0.01835399f, 
    -0.06579657f, -0.18407999f, -0.11346433f, -0.10753598f, -0.02920523f, 0.11626516f, -0.10572268f, -0.07495434f, 
    0.01241592f, -0.01239201f, -0.02857547f, -0.05660460f, 0.10339120f, 0.06379707f, -0.02052029f, 0.04909298f, 
    -0.06212815f, -0.12398181f, -0.17572993f, 0.06474984f, 0.02701459f, -0.13269788f, -0.08460013f, -0.04453309f, 
    0.00592150f, -0.04080822f, -0.09026696f, 0.00801076f, 0.05718394f, -0.10542606f, -0.03942519f, -0.04036887f, 
    -0.02845008f, 0.10819063f, 0.00090151f, -0.09593441f, 0.08617467f, -0.10082331f, -0.03549610f, -0.27988416f, 
    -0.43427300f, -0.15601555f, -0.03680744f, -0.17787260f, 0.07818436f, -0.19934340f, -0.08495269f, -0.04918702f, 
    -0.03984144f, -0.07305195f, 0.13933942f, -0.03031900f, 0.28833896f, 0.15391287f, -0.10906184f, -0.08966273f, 
    0.05916658f, 0.00485944f, 0.05723995f, 0.01876625f, -0.03725407f, 0.05359853f, 0.00823526f, 0.02940887f, 
    0.07862818f, -0.01585689f, -0.19294956f, -0.03286985f, 0.05678345f, -0.06403074f, 0.04618281f, -0.08442949f, 
    0.03523778f, 0.02339086f, -0.02055835f, 0.05133857f, 0.11021526f, -0.13538109f, 0.04200882f, 0.25459078f, 
    -0.02495068f, -0.03461789f, 0.01142202f, 0.07673350f, -0.08973085f, 0.11232898f, -0.03888682f, 0.03889440f, 
    -0.09485533f, 0.04578150f, -0.08768848f, 0.08836527f, 0.06826051f, 0.08985323f, 0.00912033f, 0.07096706f, 
    0.07824297f, -0.05734851f, -0.05218903f, -0.05290406f, -0.19133203f, 0.18986128f, 0.05307698f, -0.00886420f, 
    -0.02345769f, -0.11628180f, -0.09473707f, 0.06392670f, -0.00414496f, -0.00847315f, 0.05114377f, -0.01493589f, 
    -0.21013911f, -0.32000643f, 0.01369974f, -0.12949401f, -0.01154272f, 0.02588005f, 0.00498187f, -0.03654458f, 
    -0.06863636f, 0.05539910f, 0.10682713f, 0.14577581f, -0.26898643f, -0.20852797f, 0.16133045f, -0.16338319f, 
    0.02937536f, 0.01921809f, -0.00215446f, -0.03786866f, 0.01176761f, -0.10343697f, -0.20103677f, -0.03667196f, 
    0.08290984f, -0.15298721f, -0.03581976f, -0.04608145f, 0.06263327f, -0.03910915f, -0.02671611f, -0.17941077f, 
    0.01316105f, -0.01539193f, 0.04691873f, -0.18433747f, 0.37698063f, -0.05384270f, -0.11734118f, -0.04493403f, 
    -0.06470658f, -0.20276242f, -0.05072625f, 0.04342542f, -0.08507216f, -0.00670424f, 0.00853062f, 0.04580430f, 
    -0.05524452f, -0.54921931f, 0.05001359f, -0.05476477f, 0.15556303f, -0.07044303f, 0.01487169f, -0.02874130f, 
    -0.01418195f, -0.03899077f, -0.08996119f, -0.07294805f, 0.10412127f, -0.16601197f, -0.03699826f, -0.02627247f, 
    0.00795146f, -0.08909512f, -0.01289112f, -0.07227342f, -0.03985953f, -0.06129144f, 0.04027097f, -0.08627582f, 
    -0.13945246f, 0.20253973f, -0.14611951f, 0.16109407f, 0.08431154f, 0.05111155f, 0.05862208f, 0.03142855f, 
    0.06529007f, 0.00260922f, -0.08782721f, -0.06860235f, 0.08223426f, 0.01941124f, 0.15751900f, -0.06627143f, 
    -0.04714971f, -0.16118169f, -0.05533331f, -0.12504964f, -0.06003688f, -0.04635093f, 0.09400292f, -0.06025520f, 
    0.14380586f, -0.26859996f, -0.03636945f, 0.13832888f, 0.07403476f, 0.04934298f, 0.01709448f, 0.10505152f, 
    0.00806597f, 0.00332198f, 0.01218817f, 0.05766292f, -0.22454727f, 0.03040307f, 0.12584819f, 0.02879247f, 
    -0.14717998f, 0.03094150f, -0.12410682f, -0.05503718f, -0.07563749f, -0.00945365f, 0.10726039f, 0.04588423f, 
    -0.00236021f, 0.01263565f, -0.05274710f, 0.08641867f, -0.13863373f, 0.14586025f, -0.09975034f, 0.01463678f, 
    -0.04580346f, 0.02721463f, 0.01800993f, -0.02539578f, 0.05610755f, 0.03977514f, -0.05166747f, -0.15424475f, 
    -0.04764232f, 0.09799068f, -0.00351781f, 0.03965344f, 0.00470932f, 0.04945613f, -0.06894907f, -0.08199911f, 
    -0.14117993f, 0.04021704f, 0.03937668f, 0.05259878f, 0.06579074f, 0.05937898f, 0.00088792f, -0.07287595f, 
    -0.12006533f, -0.04594706f, 0.11209024f, -0.02383982f, 0.41941389f, 0.12692827f, -0.07582860f, -0.01025263f, 
    0.03552624f, -0.09972605f, -0.10859761f, 0.01653827f, 0.08035436f, 0.09247724f, 0.01283745f, -0.00782130f, 
    -0.18310951f, -0.00228617f, -0.09566429f, 0.00267032f, -0.01665587f, -0.02704241f, 0.04138969f, 0.09374400f, 
    -0.12107033f, -0.01296815f, -0.07900870f, -0.26137987f, 0.07140675f, 0.15205941f, 0.01285047f, -0.05021536f, 
    -0.13300343f, 0.04586182f, -0.02001704f, -0.10833384f, -0.01443603f, -0.01550158f, -0.04150246f, -0.00927209f, 
    -0.00202236f, -0.20837604f, 0.06105086f, 0.02700325f, -0.04561813f, 0.01870239f, -0.04378252f, 0.06651527f, 
    -0.01378745f, 0.03916473f, -0.02726436f, -0.10409522f, 0.24570233f, -0.10491925f, 0.15791211f, -0.08395701f, 
    0.06755373f, -0.02240743f, 0.02553104f, -0.02663383f, 0.01529722f, 0.05807372f, 0.00514406f, -0.02166075f, 
    0.26898190f, 0.02948571f, -0.06190695f, -0.09416743f, 0.11169870f, 0.01641941f, -0.09290037f, 0.05402660f, 
    0.13369842f, -0.08259211f, 0.01785252f, 0.08573832f, 0.41629633f, -0.19258563f, -0.26012886f, 0.07217041f, 
    0.13090542f, -0.10832717f, -0.11864067f, 0.00982484f, 0.11602585f, 0.09648485f, -0.00461633f, 0.09526972f, 
    -0.46554106f, -0.01780559f, 0.00989628f, -0.24923182f, 0.04185418f, 0.05453212f, -0.05498735f, 0.13818367f, 
    0.07124490f, -0.00531514f, -0.04128462f, 0.02461926f, 0.19347471f, 0.10525981f, -0.18046273f, -0.02688079f, 
    0.01135249f, -0.04098270f, 0.06325313f, -0.00680538f, 0.02557350f, -0.01557370f, -0.09652954f, -0.04745758f, 
    -0.04264678f, 0.03919444f, 0.10384282f, -0.15272224f, -0.11392888f, 0.02611837f, 0.09288537f, 0.07566639f, 
    0.00119018f, -0.04007906f, 0.04639324f, 0.01728968f, -0.16145077f, 0.20231071f, -0.02192924f, 0.00551186f, 
    0.05675910f, -0.05862020f, 0.12839451f, -0.05681298f, -0.04584780f, -0.02397939f, 0.02130903f, -0.07438581f, 
    0.02998321f, 0.05389997f, -0.19238830f, 0.02496518f, 0.17442030f, -0.04131078f, 0.03932752f, 0.14106686f, 
    -0.04889280f, -0.02105527f, -0.03959279f, 0.04222035f, -0.07522230f, 0.05507515f, 0.02709824f, -0.03373243f, 
    0.02127516f, 0.00798779f, 0.05127902f, -0.15012406f, 0.01436049f, -0.07967532f, 0.00224273f, -0.04335394f, 
    0.04766120f, -0.05987434f, -0.01648607f, 0.02127721f, -0.08975460f, 0.00020209f, -0.03768807f, -0.10730598f, 
    -0.07827291f, 0.03892856f, 0.04618980f, -0.14639720f, -0.20003748f, 0.22327492f, 0.04652439f, 0.06353082f, 
    -0.01520193f, -0.08439866f, -0.16362147f, 0.05298952f, -0.01058725f, 0.00519016f, 0.11005776f, -0.11473469f, 
    0.06598232f, -0.15239905f, -0.05002362f, 0.12554944f, -0.12424507f, 0.08139376f, -0.04233174f, -0.04109609f, 
    0.09773147f, 0.03765910f, 0.15059668f, -0.01330384f, -0.18126394f, 0.10204219f, 0.10896043f, -0.10439879f, 
    -0.08210559f, 0.02274537f, -0.04764748f, 0.07909963f, -0.01347179f, 0.07497572f, 0.01556260f, 0.09116621f, 
    -0.05085682f, 0.19107936f, 0.09316029f, 0.01730352f, 0.10239254f, -0.04353980f, -0.06959359f, 0.00920878f, 
    -0.03349512f, -0.00049762f, 0.03372985f, -0.11905180f, 0.02903689f, 0.14224385f, -0.07208078f, 0.11620095f, 
    0.06826729f, -0.07283439f, -0.03092168f, 0.06762353f, 0.09990371f, -0.04292076f, -0.03115331f, -0.05932016f, 
    0.19188881f, -0.14462464f, -0.03194818f, -0.01902362f, -0.01535641f, 0.05314409f, 0.02040525f, 0.00700034f, 
    0.01086317f, -0.07402188f, 0.03401702f, 0.08269791f, -0.08017870f, -0.25669405f, -0.23618384f, 0.13632727f, 
    -0.03941000f, -0.06569525f, 0.09920138f, -0.02643534f, -0.00003616f, 0.12023135f, 0.03410219f, 0.02749338f, 
    0.24642263f, 0.10998996f, -0.00078232f, -0.03857116f, 0.04338870f, 0.00193865f, -0.02146537f, -0.01519257f, 
    -0.08054197f, -0.03822068f, -0.05787167f, 0.02040434f, -0.13685821f, -0.15007928f, -0.03395067f, 0.03634450f, 
    -0.02461299f, 0.09026457f, 0.00609514f, 0.00492628f, -0.00047125f, 0.03608137f, 0.03170845f, 0.03132337f, 
    -0.10695598f, 0.18418953f, -0.11655919f, -0.01077542f, -0.19657938f, -0.05547901f, -0.02319612f, -0.07071293f, 
    0.06019037f, -0.02464977f, -0.04500158f, -0.09090224f, -0.07153839f, -0.05342330f, -0.04582551f, 0.06000530f, 
    -0.08404247f, 0.00919607f, 0.00121855f, -0.03474239f, -0.04522413f, 0.05793905f, 0.12271138f, -0.13216792f, 
    -0.35770404f, -0.16432685f, 0.00883187f, -0.05484617f, -0.04314272f, 0.11304066f, -0.01220755f, 0.00718059f, 
    -0.06465665f, 0.08235299f, 0.05915743f, 0.05264457f, -0.19893174f, 0.09706181f, -0.12028734f, 0.12964067f, 
    -0.02261511f, 0.02774125f, 0.03602144f, 0.13466606f, 0.00034479f, 0.01438536f, -0.00049639f, 0.07737578f, 
    -0.08930728f, -0.24663378f, 0.03677370f, -0.26690766f, 0.03002554f, 0.00486242f, 0.01302165f, 0.02374052f, 
    -0.03414009f, 0.01204895f, -0.05912522f, 0.00989771f, 0.13235189f, -0.04567374f, 0.00759444f, 0.12968889f, 
    0.02491227f, 0.02516023f, -0.02528835f, -0.01620219f, 0.00933748f, -0.03897411f, -0.09549598f, -0.03297498f, 
    -0.01685967f, 0.10183235f, -0.24963421f, -0.06926034f, 0.09470335f, -0.00446047f, 0.10147031f, -0.02003391f, 
    -0.03622812f, -0.03034671f, -0.09212366f, 0.01098939f, 0.11530503f, 0.14196049f, -0.17171426f, -0.23933008f, 
    0.14766236f, -0.06210556f, -0.01766379f, 0.08563123f, -0.02692657f, 0.04132793f, 0.02186782f, 0.01075774f, 
    -0.07591717f, 0.01537733f, 0.07274631f, 0.25148562f, 0.03840849f, 0.02014712f, -0.06562279f, 0.10394516f, 
    0.00650965f, -0.04593556f, -0.02285632f, 0.01037006f, 0.42465875f, -0.03344343f, -0.03828585f, -0.14606243f, 
    0.06957935f, -0.05586668f, -0.06454859f, 0.01694978f, 0.05801182f, -0.04625164f, -0.01706570f, 0.01795098f, 
    -0.03625078f, 0.13229145f, -0.16281222f, 0.14691763f, 0.02470615f, -0.07709694f, -0.11196247f, -0.11696937f, 
    -0.03253033f, -0.04959872f, -0.09480734f, -0.09978732f, 0.20614718f, -0.15867284f, 0.01674351f, 0.05653977f, 
    -0.07549549f, 0.05879430f, -0.01944778f, -0.00895290f, -0.00588097f, -0.13173097f, -0.06354619f, -0.07593271f, 
    0.20000350f, -0.03688768f, -0.06854964f, -0.04543530f, -0.07103602f, -0.00062147f, 0.02365068f, -0.00002044f, 
    -0.03818261f, -0.02731862f, -0.09984330f, -0.02109538f, 0.07934467f, -0.08417225f, 0.13380845f, 0.07457490f, 
    0.11498946f, -0.09579724f, -0.08508578f, 0.10039092f, -0.04116164f, -0.09656792f, -0.00226840f, -0.03289606f, 
    0.20363332f, -0.12924609f, -0.11504040f, 0.12659262f, -0.13053907f, 0.08943991f, -0.02031498f, 0.05177972f, 
    0.02204194f, -0.01609282f, 0.03165554f, -0.09974607f, 0.11262012f, 0.00788434f, 0.02143401f, 0.13574968f, 
    -0.09392909f, 0.04388391f, -0.06922615f, -0.04173781f, 0.09059335f, 0.02575706f, 0.09168268f, -0.01211131f, 
    0.10338267f, -0.20996554f, 0.11854488f, 0.11240785f, -0.00429789f, -0.02077041f, 0.05891198f, -0.09700625f, 
    -0.02007445f, 0.02934568f, -0.00537735f, 0.07745136f, 0.29908827f, -0.01153847f, 0.06614590f, -0.03113959f, 
    0.00200488f, 0.03195143f, -0.20746361f, 0.00947017f, 0.13077919f, -0.06111149f, 0.01817381f, -0.00124568f, 
    -0.00899537f, -0.15017839f, -0.11118186f, -0.01964172f, -0.02205694f, 0.05960567f, 0.04106371f, -0.04979080f, 
    0.01789588f, -0.02922374f, -0.04766402f, -0.00149390f, 0.27208373f, 0.03150589f, -0.29096422f, 0.28079435f, 
    0.04413320f, 0.12066690f, -0.00189092f, -0.02980588f, -0.01756333f, 0.06146668f, 0.07175480f, -0.07453305f, 
    -0.45015591f, 0.09506462f, -0.16007374f, -0.06313860f, 0.05163984f, -0.09713840f, -0.07087548f, -0.01967467f, 
    -0.00284236f, 0.04642820f, 0.02187055f, 0.07226010f, -0.16773573f, 0.11765125f, -0.04705971f, 0.09818029f, 
    -0.01656243f, -0.01189825f, 0.00911570f, -0.07436491f, -0.01614635f, 0.06796587f, 0.05640175f, 0.01306601f, 
    0.23860948f, -0.13165645f, -0.04299071f, -0.07815497f, -0.01066251f, 0.01837334f, 0.01003766f, -0.01091004f, 
    0.03875136f, 0.01787333f, -0.02932053f, 0.07791685f, -0.11874674f, -0.01877315f, -0.06560601f, 0.16387953f, 
    -0.01856376f, 0.01385551f, 0.04024333f, 0.08131935f, 0.04533273f, -0.01228607f, -0.02418805f, 0.00314072f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01971358f, 0.04084624f, -0.04885313f, -0.03983928f, 0.02873335f, -0.00970790f, -0.03281141f, -0.05202034f, 
    -0.04722445f, 0.04375937f, 0.04975724f, -0.00977416f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
