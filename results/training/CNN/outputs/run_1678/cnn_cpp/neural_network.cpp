#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.46486789f, 0.82891595f, 0.70374918f, 0.06423000f, -0.24472615f, -1.07132900f, -0.89598620f, -0.38452280f, 
    0.20025901f, 0.29331350f, -0.44132662f, -0.37279364f, -0.35544556f, 0.22913532f, 0.10219849f, 0.12489005f, 
    0.43504623f, 0.28841662f, 0.21032114f, -0.24861641f, -0.13501455f, 0.08293810f, -0.10761777f, -0.26996627f, 
    -0.28748798f, 0.21570298f, 0.25391036f, 0.29118675f, -0.29848608f, 0.48254311f, 0.01181541f, -0.20132504f, 
    0.13604374f, -0.19565366f, 0.35708416f, 0.26072598f, 0.16028644f, -0.33556864f, -0.11302169f, 0.38952050f, 
    -0.12837976f, -0.30450481f, -0.01476091f, 0.09634952f, -0.38252550f, 0.10769849f, -0.05715211f, -0.25735435f, 
    0.22764505f, 0.18908310f, 0.05927726f, 0.12959041f, -0.21177103f, 0.12208635f, 0.51778036f, 0.12493613f, 
    0.57432705f, -0.88386047f, -0.76796186f, 0.46560746f, -0.22439276f, 0.15340142f, -0.11380771f, 0.16054189f, 
    0.11340851f, -0.12205309f, -0.37398720f, -0.06234776f, 0.19241823f, 0.25868505f, -0.10548408f, -0.23716752f, 
    0.41510785f, -0.10777954f, -0.13071144f, 0.60981542f, 0.13603757f, 0.07798757f, -0.20984474f, -0.22829197f, 
    -0.10714909f, 0.02793102f, 0.41828790f, -0.34608111f, -0.09960922f, -0.19102204f, -0.26442036f, 0.85677540f, 
    -0.56052810f, -0.50525624f, -0.02439235f, 0.08294153f, -0.17882849f, 0.16853872f, -0.24749233f, -0.28574094f, 
    -0.05308793f, 0.08078961f, 0.32816800f, 0.35432580f, 0.42060548f, 0.61845154f, 0.28442663f, -0.15783130f, 
    -0.77918667f, -0.57497245f, 0.05558585f, -0.27743694f, -0.38233238f, -0.53188473f, 0.31275272f, -0.23261698f, 
    -0.41761705f, -0.23641591f, -0.33982912f, -0.38301021f, -0.38235480f, -0.03997647f, -0.09020228f, -0.26474321f, 
    -0.16568802f, -0.32500184f, -0.20807683f, -0.30412549f, -0.15175061f, -0.39256403f, -0.34843940f, -0.25646022f, 
    -0.24769828f, 0.65191638f, 0.66424948f, 0.18484481f, -0.92346621f, -0.18494546f, 0.25039327f, 0.10266109f, 
    0.52185321f, -0.52370292f, -0.31947550f, -0.56079507f, -0.14109209f, -0.30254027f, -0.07275095f, 0.30598626f, 
    -0.60477191f, 0.42974609f, -0.20683324f, -0.27538729f, -0.07544335f, 0.17384443f, -0.31308812f, 0.27787301f, 
    0.15607931f, -0.28352034f, -0.12894370f, 0.05880274f, -0.80684179f, -0.86069137f, 0.15674275f, -1.07401800f, 
    0.38247108f, -0.01247417f, 0.47223547f, 0.41842273f, 0.47891921f, -0.15738317f, -0.11064080f, -0.47289288f, 
    -0.31220466f, -0.15272473f, -0.10061873f, -0.09996098f, 0.08312453f, 0.11121955f, 0.11377276f, 0.09872324f, 
    -0.18722087f, -0.71080619f, -0.42855734f, 0.02216544f, 0.22819225f, 0.36179182f, 0.29922071f, -0.33412129f, 
    0.04816567f, 0.27928951f, 0.35499966f, 0.03682689f, 0.01294563f, 0.19978133f, -0.00365675f, -0.21254003f, 
    0.24536219f, -0.15691365f, -0.23420411f, -0.32413480f, -0.28910494f, -0.10564257f, 0.09528225f, 0.10026561f, 
    0.28054076f, -0.06543991f, -0.36171368f, -0.62935060f, -0.58431661f, -0.45678237f, -0.60127282f, -0.34122178f, 
    -0.92702645f, -0.93359149f, -0.37203577f, -0.49413353f, -0.24388123f, 0.87412202f, -0.28300223f, -0.00382226f, 
    -0.36431327f, -0.41913268f, -0.22231978f, -0.34970003f, 0.24519633f, 0.12993754f, 0.02315007f, 0.15708508f, 
    0.00196915f, 0.23158348f, 0.14847776f, 0.08352344f, 0.21612036f, -0.26148877f, 0.01352354f, -0.24420261f, 
    0.11499961f, 0.51829404f, 0.36442900f, 0.27444211f, -0.01956184f, -0.06114871f, 0.00841996f, 0.27578521f, 
    -0.30853420f, 0.50890052f, 0.04840513f, 0.14119177f, -0.23550174f, -0.18839416f, 0.22550759f, 0.31297839f, 
    0.22363482f, -0.18992087f, 0.76249456f, -0.43080789f, -0.50561440f, -0.45945266f, -0.45310262f, 0.78268540f, 
    -0.42501450f, 0.15975715f, 0.53528458f, -0.00195082f, 0.10618369f, -0.06035578f, -0.11506129f, 0.20397882f, 
    0.11795352f, -0.56552207f, 0.01467045f, 0.08148042f, 0.36954808f, -0.33458033f, 0.02239170f, 0.36083299f, 
    0.31281826f, -0.07613605f, -0.14585564f, 0.06241898f, -0.52411151f, -0.54942268f, -0.51997077f, -0.28407446f, 
    -0.31184283f, -0.38900551f, 0.16794331f, -0.26173034f, -0.03167683f, 0.55624068f, 0.56638396f, 0.54980326f, 
    0.23016395f, 0.08970273f, -0.07656558f, 0.23416625f, 0.02470387f, -0.19935763f, -0.13699968f, 0.20755337f, 
    -0.21780682f, 0.22305392f, -0.36793441f, -0.22909316f, -0.01476742f, -1.35457373f, -0.18402863f, 0.51860869f, 
    0.96457040f, -0.24179927f, 0.11552586f, 0.35139865f, -0.09127856f, 0.12407342f, -0.30803555f, -0.50886917f, 
    -0.31664845f, -0.09926344f, 0.30913547f, 0.07033353f, -0.05392865f, -0.24425912f, 0.28550693f, 0.03999728f, 
    -0.45956749f, -0.53312570f, -0.27416179f, -0.60194957f, -0.59647942f, -0.80291116f, -0.41572148f, -0.65643632f, 
    -0.80866808f, -0.46123034f, 0.65709352f, 0.48607525f, 0.09799293f, -0.28460339f, -0.36224198f, 0.10111497f, 
    0.35536915f, -0.16685788f, -0.13530126f, -0.03308724f, -0.53981829f, -0.56864750f, -0.39411962f, -0.09464458f, 
    -0.32815203f, 0.16921264f, -0.04863188f, 0.09907969f, 0.06769690f, 0.32565379f, -0.20813321f, 0.37994614f, 
    0.50912565f, -0.07246890f, -0.07388684f, -0.39917129f, -0.18608078f, -0.16488533f, -0.28135827f, -0.03996785f, 
    -0.31835872f, 0.43071574f, -0.05918626f, -0.08836675f, 0.24093060f, 0.45041633f, 0.17494065f, -0.12912931f, 
    0.34961700f, -0.60985124f, 0.03146276f, 0.07643686f, -0.21478631f, 0.03718885f, 0.63114285f, -1.22540474f, 
    -0.01014791f, 0.37913418f, 0.15713562f, 0.59833199f, 0.35494745f, 0.40509126f, -0.03947521f, -0.12799054f, 
    0.32391053f, 0.30712011f, 0.03285024f, -0.36123028f, 0.26659387f, -0.44108143f, 0.08890543f, 0.04238508f, 
    -0.34017119f, 0.24805759f, -0.05343708f, -0.09446959f, 0.21478106f, -0.09378630f, 0.10323997f, -0.52648306f, 
    -0.89613295f, -0.49358833f, -0.24632898f, 0.04612543f, 0.20286919f, 0.03239658f, -0.39073047f, -0.28075007f, 
    0.56174141f, 0.31648257f, 0.03816969f, 0.19336431f, 0.00120898f, 0.00584814f, 0.18888685f, -0.05073640f, 
    -0.05878581f, -0.26597616f, -0.39947921f, 0.08296935f, 0.19330224f, 0.30771777f, 0.43991593f, 0.30493808f, 
    0.33776408f, 0.17979366f, 0.17994331f, 0.20144810f, -0.18823284f, 0.50578213f, -0.74995208f, -0.42210123f, 
    -0.01672178f, 0.37994030f, 0.58114100f, -0.02184942f, 0.10735226f, 0.16986191f, 0.03165461f, -0.08057628f, 
    0.00655909f, -0.08138496f, 0.07581127f, 0.01340205f, -0.20444088f, 0.19364959f, -0.04007794f, -0.04572722f, 
    -0.05516790f, -0.09431954f, 0.57633060f, 0.12934129f, 0.08136199f, -0.84181279f, -0.98040372f, -0.78073215f, 
    -0.25466746f, -0.37270755f, -0.14450341f, -0.03333599f, 0.64697987f, 0.29044068f, 0.41566154f, -0.20523222f, 
    -0.32223639f, 0.10779287f, 0.22477995f, 0.17926145f, -0.30024981f, -0.37217012f, 0.03204896f, 0.10083769f, 
    0.11009260f, -0.15201519f, 0.33826339f, -1.17225361f, -0.57164907f, -0.09940825f, -0.38609394f, -0.32877940f, 
    0.39030001f, 0.08748437f, 0.10088000f, 0.43954739f, 0.67823863f, 0.08327804f, 0.05884270f, -0.07175088f, 
    0.30023128f, -0.40005782f, 0.19811271f, -0.29632410f, -0.00396050f, 0.15448546f, -0.14791363f, 0.03877747f, 
    0.26471242f, 0.18167537f, -0.17301843f, 0.01918656f, 1.15713894f, -0.84325844f, -0.87373275f, -0.20008186f, 
    -0.16936411f, 0.53765923f, 0.60996813f, 0.80960077f, 0.20414501f, -0.01687632f, -0.29131094f, 0.40251353f, 
    -0.30523744f, -0.42595854f, -0.09323046f, -0.10150602f, 0.13424227f, 0.16763870f, -0.15862413f, -0.22080979f, 
    0.09290129f, -0.02821487f, -0.29330456f, -0.07203296f, 0.15350252f, -1.04653120f, -0.70920682f, 0.05026450f, 
    -0.17020176f, -0.46144012f, 0.99636084f, 0.08060119f, -0.08760355f, -0.18338640f, 0.46919063f, -0.08493238f, 
    -0.21192570f, -0.00250782f, 0.25546402f, -0.61847347f, -0.06777135f, 0.15332596f, -0.30338439f, -0.34349790f, 
    -0.39387655f, -0.44577605f, -0.38354537f, -0.11098273f, -0.12837094f, -0.34199840f, -1.18516719f, 0.03930471f, 
    0.81009096f, -1.39583230f, -0.90981287f, -0.23332255f, 0.55560249f, 0.65997022f, 0.50973231f, 0.09618887f, 
    -0.23260273f, 0.09688359f, -0.17770222f, 0.01236753f, -0.12669550f, -0.03122236f, -0.00991791f, -0.10236660f, 
    0.09322790f, 0.15729241f, -0.24242806f, 0.06174227f, 0.17940815f, -0.24736002f, -0.30354208f, -0.86944270f, 
    -0.05284706f, -0.36658499f, -0.74111289f, -0.57179028f, 0.25199050f, 0.17003594f, -0.06845509f, -0.32384577f, 
    -0.28059679f, -0.03336408f, 0.15064389f, 0.03234142f, -0.03667525f, 0.10831220f, -0.05605278f, -0.14056467f, 
    -0.28813463f, 0.14982766f, 0.36198619f, 0.18021815f, -0.21290138f, -0.30918446f, -0.18773027f, -0.61027861f, 
    -1.15004945f, -0.37775183f, -0.52928305f, -0.12143170f, 0.19502994f, -0.60657525f, -0.46639434f, -0.14199854f, 
    0.32313481f, 0.07416469f, -0.35536987f, -0.51750189f, -0.40566254f, -0.06698557f, -0.03213020f, 0.29959014f, 
    -0.11518007f, -0.28288144f, -0.41872805f, -0.37527838f, -0.43915033f, -0.50796318f, -0.20169677f, -0.36196506f, 
    -0.33804506f, 0.81041849f, 0.19252568f, 0.15927422f, 0.02208377f, 0.11770247f, 0.15231839f, 0.06580418f, 
    0.26008078f, -0.18532966f, 0.02392781f, -0.30273041f, 0.17964070f, -0.03924234f, -0.16907048f, 0.10855499f, 
    -0.06224008f, 0.00606438f, -0.05795108f, -0.13600539f, -0.31268439f, -0.33322504f, 0.04078110f, -0.17288782f, 
    -0.30244294f, -0.21265836f, -1.03010070f, -1.30825257f, -0.50190544f, -0.00566617f, -0.68935680f, -0.46451688f, 
    -0.24024525f, -0.55231094f, -0.99314612f, -0.61649930f, 0.04728346f, -0.23232034f, -0.18266991f, 0.12348518f, 
    -0.18875760f, -0.06585933f, 0.04058959f, 0.08791092f, -0.08463690f, -0.12660713f, -0.40384257f, -0.11398341f, 
    0.07335668f, 0.41439360f, -0.40225381f, 0.84159803f, -0.27116346f, -0.60625756f, -0.38928947f, -0.52567208f, 
    0.35325733f, -0.21307737f, 0.36084720f, -0.35816410f, 0.14457858f, -0.16811112f, -0.42820469f, 0.42769387f, 
    -0.31844121f, 0.14024173f, -0.25130594f, -0.51293987f, 0.24481000f, 0.24488276f, 0.02528318f, -0.43913031f, 
    0.12177982f, 0.01762518f, 0.18651660f, 0.28715447f, -1.16944981f, -0.88872123f, 0.36428657f, 0.37016001f, 
    0.42125717f, 0.44956440f, 0.12203199f, -0.36253375f, -0.07927182f, 0.20394440f, -0.06505115f, -0.34495139f, 
    -0.24973659f, 0.14588115f, -0.35291564f, -0.49848610f, 0.33664349f, -0.10152788f, 0.15542245f, -0.11166927f, 
    0.28043172f, -0.29388496f, -0.15342975f, -0.01494558f, 0.22865157f, 1.14353788f, 1.15925038f, -0.31968233f, 
    -0.88625014f, 0.42677167f, -0.09729900f, 0.04720982f, -0.01146947f, -0.80018705f, -1.01344717f, -0.07502183f, 
    0.37440667f, -0.26524192f, 0.01869063f, 0.00411100f, 0.01843889f, 0.19423532f, 0.17210352f, 0.10205835f, 
    -0.01401024f, -0.09457354f, 0.11311293f, -0.03584540f, -0.10296306f, -0.05432859f, 0.44358051f, -0.10083520f, 
    -0.93146098f, -0.83431375f, -0.39384356f, -0.42698830f, -0.28328836f, -0.23068464f, -0.28815249f, 0.64948982f, 
    0.09368610f, 0.40512189f, 0.56056571f, 0.10845943f, 0.13319992f, -0.05262752f, -0.17010598f, 0.01519141f, 
    -0.30821407f, 0.10507458f, 0.10802009f, -0.37843516f, -0.14255126f, -0.04388883f, -0.17947690f, 0.64920515f, 
    0.45861816f, -0.04221711f, -0.15406059f, -0.74979693f, -0.33819711f, -0.02881129f, 0.32163742f, 0.10102497f, 
    0.38479039f, 0.40012902f, -0.05077304f, -0.18567760f, 0.11697695f, -0.29119429f, 0.01240965f, -0.24370961f, 
    0.37416366f, -0.41174901f, -0.09402302f, 0.09852367f, -0.11396477f, 0.00689105f, -0.18829317f, 0.11287491f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.44656608f, 0.04765693f, 0.34940517f, 0.41418889f, 0.19653440f, 0.15242670f, -0.02973227f, 0.05292736f, 
    -0.24968085f, 0.30517843f, 0.27308220f, 0.22890057f, -0.17950147f, 0.09051351f, 0.27037013f, 0.42784283f, 
    -0.00016242f, 0.25559416f, 0.33385769f, 0.21713351f, 0.31839964f, -0.05986404f, 0.29767162f, -0.14622933f, 
    0.11705576f, 0.08721926f, -0.27136388f, 0.51692647f, 0.41117686f, 0.14871207f, 0.33048433f, 0.61765808f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.27716392f, 0.41822836f, 0.30368409f, -0.52716720f, 0.02921896f, -0.15388358f, -0.03526315f, -0.13186449f, 
    0.07133937f, -0.03368198f, -0.02990129f, 0.03665604f, -0.57312411f, -0.23203768f, -0.36411926f, 0.14256330f, 
    0.02337063f, 0.09631217f, -0.00764825f, 0.01231411f, -0.10116689f, 0.04686073f, 0.07090797f, -0.06086361f, 
    -0.16565128f, 0.18817930f, -0.43141428f, 0.06624125f, -0.01679020f, -0.20676680f, 0.09180208f, -0.11932048f, 
    -0.05805851f, -0.01719266f, 0.06945146f, -0.06427733f, -0.34108251f, -0.27220589f, -0.30382600f, -0.06815479f, 
    -0.02582432f, 0.01587295f, 0.00132162f, 0.10283255f, -0.02173616f, -0.10432030f, -0.06905733f, 0.08199307f, 
    -0.00429611f, -0.01126584f, -0.09093495f, -0.06439610f, -0.17982236f, -0.18383507f, -0.31787926f, 0.03208339f, 
    -0.10175365f, -0.14841005f, -0.02148502f, 0.20427717f, 0.41892993f, 0.40914038f, -0.31848019f, -0.03641554f, 
    -0.17536631f, 0.02070329f, 0.14689136f, -0.09540910f, -0.15021613f, -0.08364742f, 0.01609306f, -0.10335687f, 
    0.58533806f, 0.11112639f, -0.46753058f, -0.33862391f, -0.18460770f, 0.10873011f, -0.20613979f, 0.27150801f, 
    0.07382294f, 0.02479743f, -0.02883226f, -0.07559808f, 0.06877983f, -0.05721857f, -0.18999600f, 0.22264330f, 
    0.08847342f, 0.02913420f, 0.03985922f, -0.06448498f, -0.03547629f, 0.01715416f, -0.10227305f, 0.02259295f, 
    0.27736428f, 0.12058716f, -0.04776971f, -0.15712553f, 0.16664673f, 0.08094027f, -0.13415596f, 0.02880520f, 
    -0.06045063f, -0.05336895f, 0.03616940f, -0.08471455f, 0.02489322f, -0.02919455f, -0.01027708f, 0.01220741f, 
    -0.10203769f, 0.03546828f, 0.06373315f, 0.02002027f, -0.25608784f, -0.38459378f, -0.13275631f, -0.16312344f, 
    0.11763458f, -0.25974864f, -0.25911456f, 0.11289656f, -0.03070380f, -0.01620473f, -0.16106521f, -0.03061416f, 
    -0.15758701f, -0.02818181f, -0.15186086f, 0.05086570f, 0.34722838f, 0.24830337f, -0.11400287f, -0.12577160f, 
    0.04674549f, 0.02854360f, -0.16093604f, 0.03795196f, -0.06370040f, 0.05667966f, 0.01154885f, 0.05651977f, 
    0.25443241f, 0.03640037f, 0.21691944f, -0.06330083f, -0.01454859f, -0.00064644f, 0.11899435f, -0.04007672f, 
    0.08284436f, 0.08300100f, 0.06552361f, 0.30656812f, 0.19937395f, 0.03612460f, -0.41403666f, -0.02147554f, 
    0.11552539f, 0.19783647f, -0.06875086f, -0.12767088f, -0.28349781f, -0.31526226f, -0.33180785f, -0.06073441f, 
    -0.02798994f, 0.02892087f, -0.01911291f, -0.11309852f, -0.36217707f, -0.13463698f, -0.18015434f, -0.08106694f, 
    -0.05353100f, 0.04372545f, 0.00976606f, 0.00015602f, 0.14023291f, 0.02998643f, 0.02719605f, -0.02890554f, 
    -0.06433656f, 0.12412528f, 0.05524553f, 0.02365688f, -0.27563179f, 0.05392483f, -0.08540843f, 0.10107484f, 
    0.17715119f, 0.31476590f, 0.13247491f, -0.05986411f, -0.06095935f, -0.04836397f, -0.16148873f, -0.13505071f, 
    0.04672636f, -0.05380862f, -0.00915854f, -0.04396544f, -0.19655061f, -0.04073988f, 0.08426498f, 0.05752929f, 
    0.05858838f, 0.08654269f, 0.04528732f, 0.03743814f, -0.05800953f, -0.11543240f, 0.02685581f, 0.05627701f, 
    0.34490338f, -0.03660648f, -0.24055013f, -0.23974817f, 0.00270826f, -0.03869411f, 0.10301737f, -0.06948990f, 
    -0.06374417f, -0.11356389f, 0.05593048f, 0.00963246f, 0.10772087f, 0.14505862f, 0.18714540f, -0.18475100f, 
    0.08702867f, 0.18722302f, 0.07377899f, -0.01429930f, -0.01693322f, 0.04846046f, -0.14940344f, -0.02435199f, 
    -0.04961194f, -0.43461460f, -0.53110540f, 0.09488816f, 0.06247168f, 0.08197871f, 0.08013023f, -0.01466260f, 
    -0.16048662f, 0.03268954f, -0.16183656f, -0.07863852f, 0.39064154f, 0.08852237f, -0.04855780f, -0.22070804f, 
    -0.02299812f, 0.07358039f, 0.03657685f, 0.03888182f, 0.23179072f, 0.02374029f, 0.10865310f, 0.11845163f, 
    -0.36371472f, -0.49943370f, 0.09211930f, -0.05673749f, 0.02444052f, 0.15948008f, 0.06255275f, 0.27188274f, 
    -0.02496426f, -0.13550781f, -0.11154424f, -0.06392607f, 0.30618823f, 0.23442143f, -0.02399184f, -0.03976044f, 
    0.04669131f, 0.20875335f, 0.15612312f, -0.00355357f, -0.06160678f, -0.07782325f, 0.07003431f, -0.00499235f, 
    0.33157390f, 0.30682352f, 0.21559389f, 0.01488718f, -0.03250630f, 0.22804812f, 0.00116795f, -0.06075357f, 
    -0.19902231f, -0.16446665f, -0.04019282f, 0.01160737f, -0.50154841f, -0.43295893f, -0.14184467f, 0.04316961f, 
    0.08505593f, 0.02349526f, 0.04875052f, 0.05588942f, -0.08712158f, 0.05489613f, 0.02862450f, -0.04853598f, 
    0.57306278f, 0.18577549f, -0.01500152f, -0.32927692f, 0.23844717f, 0.10607867f, 0.14431024f, 0.08742167f, 
    -0.07473153f, -0.08464927f, 0.03491728f, 0.00194819f, -0.09836842f, -0.08383502f, -0.21394497f, -0.03317466f, 
    0.10425749f, -0.21808489f, -0.21239483f, -0.19790526f, -0.08734161f, -0.18756169f, -0.16264306f, 0.05674131f, 
    0.71874678f, 0.19028965f, 0.06097541f, -0.38745058f, -0.30624899f, -0.10669152f, 0.14452402f, 0.16565497f, 
    0.02455991f, -0.11478361f, -0.26808324f, -0.23822515f, 0.00762992f, -0.48201829f, -0.88214880f, 0.16036026f, 
    -0.11461435f, -0.37096888f, -0.00714735f, -0.03448218f, -0.01442514f, 0.09274406f, -0.05735895f, -0.07038486f, 
    0.24167901f, 0.27745923f, -0.17811051f, 0.01342748f, 0.02884769f, 0.07626106f, -0.14852667f, -0.17002755f, 
    -0.12786961f, 0.00198701f, 0.03516591f, 0.07184679f, -0.57547933f, -0.58869481f, -0.16838056f, 0.14538769f, 
    0.04292596f, 0.00695050f, -0.05315179f, -0.00680807f, -0.17361288f, -0.17892894f, -0.15180996f, -0.13465986f, 
    -0.14800698f, -0.03386525f, 0.18108049f, -0.22773953f, 0.15335791f, -0.04467645f, -0.16555564f, 0.02227012f, 
    -0.04800389f, -0.04307895f, -0.05116272f, -0.01421116f, 0.33846295f, 0.26543671f, 0.14978515f, 0.00275441f, 
    -0.01960635f, -0.00346747f, -0.00789915f, 0.05882267f, 0.04967288f, -0.16889745f, 0.03252267f, -0.10370459f, 
    0.31228110f, 0.14407377f, -0.15153266f, -0.00196843f, 0.08704485f, 0.06534936f, -0.04622458f, -0.10287210f, 
    0.01535640f, 0.06568950f, 0.03674865f, -0.11216468f, 0.38492367f, 0.08785515f, 0.10946018f, 0.08341168f, 
    -0.08771126f, -0.05044554f, 0.03214009f, 0.00347191f, -0.06781478f, -0.08973575f, -0.01784276f, 0.08368254f, 
    0.29370490f, -0.21551058f, 0.13163562f, -0.82286692f, 0.01999484f, -0.09397138f, -0.21162398f, 0.25771835f, 
    0.00206156f, -0.13728444f, -0.03277542f, -0.03450878f, 0.12530479f, -0.15613770f, -0.35368064f, 0.22446710f, 
    -0.12005478f, 0.04912024f, -0.10716778f, 0.14854826f, 0.20262697f, -0.21654655f, -0.29057041f, 0.18617368f, 
    -0.39636463f, -0.39831108f, -0.18799680f, -0.10011449f, 0.10594296f, -0.18526180f, 0.24908580f, 0.02692372f, 
    -0.11239634f, -0.11040404f, 0.13077377f, 0.01992299f, 0.08689177f, -0.21698470f, -0.25697395f, -0.13343944f, 
    -0.07654680f, 0.06445756f, -0.00252303f, -0.03866009f, 0.12382269f, 0.11574003f, 0.03307702f, -0.01561310f, 
    0.30674028f, -0.08861101f, 0.27669060f, 0.04145973f, -0.01539709f, -0.07606673f, -0.03559603f, 0.00118787f, 
    -0.06306350f, -0.02256170f, 0.09224221f, -0.01536735f, -0.11113536f, 0.04819227f, 0.08798619f, -0.01131303f, 
    -0.02521919f, 0.00548315f, 0.02447087f, 0.06308903f, 0.04529093f, 0.19625825f, -0.06002341f, 0.05039164f, 
    0.26679644f, 0.11571021f, -0.06823640f, -0.11059309f, -0.02820552f, 0.05550132f, -0.01298450f, 0.11611877f, 
    -0.26992363f, 0.10835885f, 0.05034149f, -0.20646308f, -0.37299255f, -0.09877745f, -0.04981915f, -0.03585093f, 
    -0.01961151f, 0.16297634f, 0.16446543f, -0.05803777f, 0.10312696f, 0.02136850f, -0.03177154f, 0.02240861f, 
    -0.23695509f, -0.02445279f, -0.13803154f, 0.09548813f, -0.00382912f, 0.12137448f, -0.05003240f, -0.04527158f, 
    -0.32744151f, -0.39366654f, 0.07965905f, -0.38886002f, -0.07275417f, -0.07316906f, 0.05179194f, -0.09383421f, 
    0.04798205f, 0.11464599f, 0.18092202f, 0.29990870f, 0.11346744f, 0.06520944f, -0.08274452f, 0.15361688f, 
    0.07480743f, -0.06056731f, 0.00224402f, -0.05582533f, 0.00728401f, -0.02317086f, 0.00673290f, -0.12030575f, 
    -0.06218747f, 0.05151938f, -0.00613853f, -0.04772115f, 0.20735319f, -0.09258305f, -0.07412168f, 0.12606984f, 
    -0.06597902f, -0.04816784f, 0.01859750f, 0.09140180f, -0.12709717f, -0.18932246f, -0.01390834f, 0.20138857f, 
    -0.20471428f, 0.10390010f, 0.01162573f, 0.03236888f, 0.17268108f, 0.07154907f, 0.04490764f, 0.21449026f, 
    -0.19396318f, 0.04027408f, 0.07176539f, -0.05407345f, -0.14385840f, 0.11288085f, 0.25789177f, 0.02653657f, 
    0.01370924f, 0.02294584f, -0.10155534f, 0.01709855f, 0.07168537f, 0.01371145f, 0.07961307f, 0.05760743f, 
    0.09306889f, -0.28410903f, 0.02228250f, -0.41275308f, -0.05279218f, -0.07975398f, -0.30257833f, -0.00402955f, 
    0.02832758f, 0.11910014f, -0.07840187f, 0.10850626f, -0.13371745f, 0.23692261f, -0.24081439f, -0.08129941f, 
    -0.05969077f, 0.08992499f, 0.02120022f, 0.09470811f, -0.24503227f, 0.02108481f, -0.08009315f, -0.01380021f, 
    1.40387630f, 0.23099458f, -0.02583272f, -0.02103057f, 0.02295478f, -0.06168734f, -0.02469263f, -0.08456296f, 
    0.11837053f, 0.07714810f, -0.39882150f, -0.01240822f, 0.31331930f, 0.01929687f, -0.15454146f, -0.12640236f, 
    0.05262278f, 0.02596632f, 0.03211768f, -0.10419422f, -0.16397673f, -0.35936019f, -0.28306022f, -0.60680437f, 
    -0.36041313f, -0.25002444f, -0.05006094f, -0.19662052f, -0.03647896f, 0.06444886f, -0.35567254f, -0.05240873f, 
    -0.03515678f, 0.15273711f, 0.01374441f, -0.12800585f, 0.15731081f, -0.08566416f, 0.09205921f, 0.07910059f, 
    -0.02202562f, 0.15694909f, -0.09462790f, -0.00780091f, -0.17240871f, -0.00833597f, 0.15176553f, 0.02745688f, 
    -0.01937408f, 0.11679755f, 0.02391340f, -0.04109601f, 0.19435658f, -0.18052754f, -0.12386147f, -0.01848368f, 
    0.08152822f, 0.03499538f, 0.02727391f, -0.09880672f, 0.24544400f, 0.06661875f, 0.11781901f, 0.07895135f, 
    -0.07150986f, 0.04897678f, -0.01323210f, -0.06520928f, -0.00542423f, 0.13787882f, -0.15706047f, 0.08412078f, 
    0.21736814f, 0.09100152f, 0.46956831f, 0.17375925f, -0.12644990f, -0.12149540f, -0.06834422f, 0.00707071f, 
    0.03106094f, 0.01431864f, -0.00761201f, -0.01416159f, 0.40252885f, -0.08388028f, -0.13490157f, 0.08532804f, 
    -0.13313757f, 0.20666327f, 0.07707858f, -0.02431310f, 0.12197907f, 0.20781241f, 0.07537013f, -0.18447754f, 
    -0.01104168f, -0.02636073f, -0.14219460f, -0.32704920f, -0.05827232f, -0.00796402f, 0.05662881f, -0.01305615f, 
    0.26166055f, -0.08802384f, -0.02662309f, -0.00005967f, 0.36024222f, -0.02670393f, -0.37603274f, -0.11803162f, 
    -0.22342025f, -0.27146149f, 0.15686940f, -0.04803751f, -0.14847553f, 0.10234997f, -0.09295730f, 0.19528913f, 
    -0.10149841f, -0.33646190f, -0.05161558f, 0.14550808f, 0.18792053f, 0.14949076f, 0.00066304f, -0.08118877f, 
    0.36527613f, -0.01456800f, 0.01753716f, 0.00655654f, 0.22807738f, -0.11154391f, 0.36311406f, -0.25146127f, 
    0.02137816f, 0.02132840f, 0.05967826f, 0.10249129f, 0.17936520f, -0.03976261f, -0.02263047f, -0.00879755f, 
    -0.29648927f, -0.28213558f, 0.20163372f, -0.03057637f, 0.00094999f, 0.06308726f, -0.15788539f, -0.02898103f, 
    0.01152734f, -0.03781588f, 0.02413143f, 0.07367064f, -0.26220095f, -0.56753343f, 0.09632193f, -0.03196803f, 
    -0.03339309f, -0.06398389f, -0.02077908f, 0.08897169f, -0.06070992f, 0.01350859f, -0.09363767f, -0.00921244f, 
    0.05688912f, -0.02827866f, 0.02542872f, -0.28486434f, 0.01250912f, -0.06761850f, 0.02502178f, 0.02687393f, 
    0.03826063f, 0.11575110f, 0.08634505f, -0.09412077f, -0.09155364f, -0.16082975f, 0.03863782f, -0.34429565f, 
    -0.02629674f, 0.04542523f, 0.04169273f, -0.04271843f, 0.04268307f, -0.11818000f, 0.14573781f, -0.12130668f, 
    -0.01904100f, 0.29179177f, 0.38724011f, -0.36592507f, 0.04172523f, 0.04015013f, -0.03127056f, -0.33926421f, 
    0.04178153f, -0.00717334f, 0.02882779f, -0.03320841f, -0.16983250f, -0.04403656f, -0.07579906f, -0.18102616f, 
    0.06930295f, -0.03926609f, -0.17094715f, 0.15568544f, 0.07054938f, -0.30302981f, 0.00092809f, -0.02988744f, 
    -0.90832311f, -0.51201099f, 0.00390815f, -0.58317888f, 0.11040137f, -0.23518364f, -0.24202353f, -0.29881340f, 
    -0.07452958f, 0.12884833f, -0.10748850f, -0.04729586f, 0.02301420f, 0.01615795f, 0.28276438f, -0.12224801f, 
    -0.07259057f, 0.00355695f, 0.05097131f, 0.00243996f, -0.22990794f, 0.00234926f, -0.01574427f, 0.10858519f, 
    -0.93281066f, -0.49184200f, -0.08446085f, -0.35485721f, -0.04792562f, 0.05662551f, -0.11102569f, -0.34509936f, 
    0.03257100f, -0.13147415f, 0.01074321f, -0.04642788f, -0.23784119f, -0.05103271f, 0.00616092f, 0.02349353f, 
    0.00296933f, -0.05314573f, -0.02251697f, 0.00722851f, -0.13632008f, -0.14213970f, -0.09102733f, 0.02519611f, 
    -0.59327179f, 0.40201491f, 0.12282431f, 0.12304344f, 0.02588804f, -0.02824073f, -0.11922999f, 0.00209969f, 
    0.07429352f, -0.06977265f, -0.06641929f, 0.03652781f, 0.00229718f, 0.03340163f, 0.03969633f, 0.07030825f, 
    -0.11082666f, -0.10782324f, 0.11357474f, -0.19730902f, 0.08506885f, 0.12431666f, -0.03242065f, 0.07806499f, 
    0.06505821f, -0.13499659f, -0.15192305f, 0.10567590f, 0.02662842f, -0.02890819f, 0.08154072f, 0.01337865f, 
    0.24820824f, 0.19322705f, 0.13082744f, -0.03705371f, 0.01301677f, 0.29047477f, 0.52573711f, 0.20184468f, 
    -0.01109952f, -0.15507482f, 0.05175289f, 0.05583532f, -0.02143440f, -0.15394580f, -0.22994502f, -0.19198200f, 
    -0.09705642f, -0.18506803f, 0.07058368f, 0.10645128f, -0.06985637f, 0.11439831f, -0.19646949f, 0.14345439f, 
    0.06979724f, -0.16526374f, -0.04249179f, -0.05709129f, 0.11357306f, -0.15545481f, -0.05156171f, 0.03505508f, 
    0.05544647f, -0.08640528f, 0.09093110f, 0.08873011f, 0.01934451f, 0.00533089f, 0.09035929f, 0.18829586f, 
    0.02042293f, -0.13822713f, -0.03843690f, 0.17820871f, -0.09248295f, 0.11103667f, -0.08098038f, -0.11906514f, 
    -0.09118556f, -0.02007269f, -0.14902392f, -0.00496770f, -0.04006320f, -0.15085663f, 0.05744985f, 0.25208381f, 
    -0.06045640f, -0.05665818f, 0.01266641f, 0.03259721f, 0.01679282f, -0.01308921f, -0.00228135f, 0.00833474f, 
    -0.49497503f, 0.17225650f, -0.29409361f, -0.28209478f, 0.16499542f, 0.22111021f, -0.04745401f, -0.14875823f, 
    0.01064487f, -0.01452353f, -0.04674279f, 0.09010257f, 0.02133724f, 0.14703023f, 0.24281709f, 0.39465737f, 
    0.14188001f, 0.13388753f, -0.03040759f, 0.14448845f, 0.07004431f, -0.20974779f, 0.09385014f, 0.09234592f, 
    -0.31692573f, 0.49403033f, 0.47710124f, 0.08045810f, -0.08767921f, 0.01198189f, 0.00305771f, -0.03220348f, 
    0.15666737f, 0.04318197f, -0.02420212f, 0.12579691f, 0.03840163f, -0.12460630f, 0.59312582f, 0.40761784f, 
    0.00174467f, -0.00558077f, 0.04742522f, 0.08402386f, 0.07093478f, -0.02871250f, 0.08724391f, 0.09107433f, 
    0.60205734f, 0.73696196f, 0.03315956f, 0.19679244f, 0.02463874f, -0.08860754f, 0.17912844f, 0.04077132f, 
    0.10161774f, 0.03377157f, 0.04362454f, 0.09591068f, 0.09458571f, -0.13215852f, 0.13667174f, 0.22417526f, 
    0.06932304f, -0.24533303f, -0.01381550f, 0.15850842f, 0.07006370f, 0.16067979f, 0.04984724f, -0.03989550f, 
    -0.13046889f, 0.01435575f, 0.06005334f, 0.34708166f, -0.01278949f, 0.03728658f, -0.07727677f, -0.10541444f, 
    -0.18154845f, -0.06099473f, -0.09734248f, 0.12596777f, -0.06196370f, -0.10432371f, -0.04752532f, -0.01533482f, 
    -0.00324604f, -0.03019970f, -0.00611116f, 0.06729131f, -0.00478641f, -0.00780228f, -0.00612195f, 0.07180564f, 
    -0.94082373f, -0.43478197f, 0.24047098f, -0.18614474f, -0.09428313f, -0.19214104f, 0.14240013f, 0.07864585f, 
    -0.05073771f, -0.01429214f, 0.04963813f, -0.03372876f, -0.48605025f, 0.25723362f, 0.11374156f, -0.02274186f, 
    -0.21299058f, 0.16294751f, -0.12216320f, -0.10551025f, 0.06285887f, 0.01403241f, 0.10187326f, -0.13786548f, 
    0.17791408f, 0.11899435f, 0.14902171f, 0.06398600f, 0.01266421f, 0.13774589f, -0.23239025f, 0.31457496f, 
    0.04235557f, 0.00725517f, -0.08326223f, 0.02416902f, -0.09325677f, -0.42076406f, 0.22911912f, -0.44359279f, 
    -0.17234555f, -0.43919399f, -0.35165152f, -0.11058605f, 0.01468336f, -0.02249886f, 0.03422774f, 0.08579301f, 
    0.08971544f, -0.05591121f, 0.07687846f, 0.25934085f, -0.07708097f, 0.02431928f, -0.02652440f, -0.15215218f, 
    -0.11356434f, -0.00164565f, 0.03536239f, 0.01820614f, -0.26268664f, 0.29820126f, 0.04912189f, -0.14256176f, 
    0.06245083f, 0.07803583f, -0.04138628f, 0.00282147f, 0.14716564f, -0.05653543f, 0.11344644f, 0.09330033f, 
    0.17253864f, -0.24036829f, 0.28320873f, 0.01357191f, -0.44738352f, 0.03862929f, 0.06211086f, -0.01501915f, 
    -0.02300642f, -0.02277776f, 0.02977541f, -0.08876380f, -0.27752426f, 0.20747477f, -0.35711387f, 0.04935310f, 
    0.04433570f, -0.41884971f, 0.30263370f, -0.27077720f, -0.02732111f, 0.13685030f, -0.11399359f, 0.20782615f, 
    -0.12635678f, -0.04354852f, -0.52476388f, -0.17455900f, 0.08935212f, -0.15016888f, -0.09595492f, -0.18879794f, 
    0.03875376f, -0.35384965f, -0.04911441f, 0.21652925f, -0.30614281f, 0.27269945f, -0.29224670f, 0.16942997f, 
    -0.04859514f, 0.06224860f, -0.23036651f, -0.22767043f, 0.00613625f, -0.00638625f, 0.10446793f, -0.07401941f, 
    -0.16669495f, -0.19383751f, 0.23387042f, 0.21736734f, -0.21146140f, -0.00630063f, -0.06291289f, 0.08236665f, 
    -0.04568522f, 0.01840788f, -0.09677705f, -0.02547942f, -0.15631913f, 0.07282396f, -0.44696099f, 0.05749021f, 
    0.10448010f, -0.19059449f, -0.06502477f, -0.15093496f, -0.19632734f, 0.05117164f, 0.00211529f, 0.12944068f, 
    0.16647400f, -0.34073082f, 0.05779269f, -0.08357761f, 0.13292637f, 0.17188211f, 0.17909697f, 0.25758797f, 
    -0.12677346f, -0.06580301f, 0.02997118f, -0.22151455f, -0.14098372f, -0.15599515f, -0.30041230f, 0.26167160f, 
    0.18049090f, -0.04575736f, 0.10415691f, -0.16278665f, 0.12515907f, -0.08711678f, 0.19743660f, -0.07041416f, 
    -0.08097284f, -0.28064978f, 0.00484830f, 0.26130834f, -0.02258935f, 0.06252147f, 0.15344946f, 0.15109040f, 
    -0.03032395f, -0.04960111f, 0.05311738f, -0.03063277f, 0.12547660f, -0.69319975f, 0.07070838f, -0.18952483f, 
    -0.14384781f, -0.02378343f, -0.30309400f, -0.24112989f, -0.21143897f, -0.04125336f, -0.25517461f, 0.07999361f, 
    -0.49510640f, -0.22238393f, 0.18496697f, 0.04482020f, 0.11579942f, 0.06117036f, -0.22322112f, -0.33841473f, 
    -0.10537377f, -0.09393986f, 0.03198130f, 0.24539970f, -0.14770205f, -0.21966758f, -0.19487625f, 0.23335297f, 
    0.18186487f, 0.14936969f, 0.08831312f, 0.08152581f, -0.04053659f, 0.01991056f, -0.02459300f, 0.00976921f, 
    -0.13978396f, 0.63407469f, -0.51438326f, 0.16327126f, 0.02700359f, 0.06447402f, 0.05871611f, -0.06196212f, 
    -0.00615050f, 0.14094241f, 0.07210639f, 0.06276166f, 0.01392873f, 0.02246092f, -0.04780881f, 0.16285652f, 
    0.12618531f, -0.09646691f, 0.07903853f, -0.06580984f, -0.07297482f, 0.03890431f, 0.21620850f, 0.06533434f, 
    0.21365188f, 0.20266782f, 0.32262942f, -0.14509615f, -0.18703470f, 0.08091787f, -0.10677856f, -0.19901904f, 
    -0.17891519f, 0.05508412f, -0.13389228f, -0.14744861f, 0.14791566f, 0.59378844f, -0.42171109f, -0.75760305f, 
    0.17185013f, 0.15047641f, 0.03146440f, 0.00768888f, -0.10678884f, -0.21092461f, -0.09530116f, -0.16831309f, 
    0.25816533f, -0.00991465f, -0.04467918f, -0.05663405f, 0.04916170f, -0.00408084f, -0.12081685f, 0.01177768f, 
    0.20280634f, 0.39571723f, -0.13332334f, 0.11769919f, -0.23390275f, -0.01699871f, -0.15717089f, -0.29711312f, 
    -0.30966467f, -0.19312784f, -0.11749546f, -0.12145366f, -0.09187117f, -0.13755947f, -0.00099016f, -0.12532881f, 
    -0.05874713f, -0.03754770f, -0.08581423f, 0.21074979f, 0.10328267f, 0.09653012f, -0.11185011f, -0.04282713f, 
    -0.04472315f, 0.11783764f, -0.02837565f, 0.05980528f, 0.34693006f, -0.08918494f, -0.01917433f, 0.03033610f, 
    0.15250702f, 0.16757682f, -0.04588721f, -0.10783919f, -0.15894279f, -0.06748141f, 0.03132107f, -0.05167847f, 
    -0.10387434f, 0.65707695f, -0.14946726f, 0.11188886f, 0.20803177f, 0.08622744f, 0.35618940f, 0.00342964f, 
    -0.13049218f, 0.03074538f, -0.07985120f, 0.16337641f, -0.23426424f, 0.07339310f, 0.04552883f, 0.06072807f, 
    0.22663358f, 0.19720191f, -0.07762814f, -0.05449136f, -0.13748538f, 0.04238926f, -0.02375291f, -0.01981816f, 
    1.05435026f, -0.21232082f, 0.18409853f, 0.27160013f, 0.13059163f, 0.19613762f, -0.13493297f, -0.16846159f, 
    -0.02586731f, -0.09685307f, 0.01982393f, 0.02318656f, -0.01077202f, -0.11631868f, 0.03709568f, 0.27868772f, 
    0.16105741f, -0.07949414f, 0.12241041f, -0.09313752f, 0.08880363f, -0.10813403f, 0.09662282f, 0.15243386f, 
    0.15722312f, -0.05188944f, -0.26780885f, -0.03747247f, 0.01850689f, -0.04540095f, -0.04395755f, -0.05059341f, 
    -0.00972222f, 0.12132062f, 0.05812101f, 0.16247371f, -0.50972384f, -0.08527244f, -0.12119213f, -0.15339020f, 
    -0.00372724f, -0.15610023f, -0.09959729f, 0.10754051f, 0.06711086f, 0.07996499f, -0.11818816f, 0.10708395f, 
    -0.24875511f, 0.01819032f, -0.09326135f, 0.30676100f, 0.02644934f, 0.02163070f, -0.05912229f, -0.02748601f, 
    -0.01669598f, 0.02574192f, 0.01626104f, -0.01557135f, -0.43965131f, 0.01946255f, -0.14125942f, 0.30780831f, 
    -0.00456179f, -0.16523334f, -0.18569136f, -0.23110898f, 0.09061424f, -0.02546488f, 0.19961938f, -0.17368640f, 
    -0.35575441f, 0.49717376f, -0.27747732f, -0.50883698f, 0.23447156f, 0.05510493f, -0.13631490f, -0.16639672f, 
    -0.40037620f, 0.05641671f, -0.02259555f, -0.02631549f, -0.16865692f, -0.12659979f, 0.96555102f, 0.62427539f, 
    -0.02078310f, 0.03629351f, -0.10697185f, -0.05488179f, 0.13735200f, -0.06276469f, -0.03792803f, 0.17622267f, 
    -0.19151945f, -0.13817781f, -0.10728249f, 0.20798342f, 0.01836248f, -0.11808357f, 0.00501948f, 0.01362699f, 
    0.10810281f, -0.09203246f, 0.07541283f, 0.10045374f, -0.79576886f, 0.14002025f, -0.09081358f, -0.02599282f, 
    -0.14974198f, 0.10679856f, -0.11744560f, -0.08928034f, -0.18162470f, 0.19813131f, 0.06214163f, -0.14104764f, 
    0.20187868f, 0.07163157f, -0.30833760f, 0.39712340f, -0.14397173f, -0.07219820f, -0.12840040f, -0.37273455f, 
    0.10208503f, 0.01457717f, 0.02753073f, 0.01824460f, -0.10031264f, -0.10008019f, 0.30329964f, 0.26346481f, 
    0.02529562f, 0.06245190f, 0.06772818f, -0.01143108f, -0.01611395f, 0.01824726f, 0.03059999f, -0.07002458f, 
    -0.05416246f, -0.15563442f, 0.06419383f, 0.16070330f, 0.07368331f, -0.27140224f, -0.04146966f, 0.06632194f, 
    -0.22238617f, 0.08737343f, -0.00358128f, 0.11212461f, -0.24206159f, -0.23564160f, -0.13982663f, -0.17736997f, 
    0.10885756f, 0.03876859f, 0.03332891f, 0.06270217f, -0.02330874f, -0.06865961f, -0.08099767f, -0.28836676f, 
    0.18321005f, 0.33548319f, -0.02044340f, 0.12882964f, 0.15356666f, -0.08784425f, 0.02522549f, -0.08922764f, 
    0.01422388f, -0.03581427f, 0.10911094f, 0.10276365f, -0.15406020f, -0.18446907f, -0.24183425f, 0.14038701f, 
    -0.01851826f, -0.01053297f, -0.04351134f, -0.06230601f, -0.21504681f, -0.00561725f, -0.04482156f, -0.28050739f, 
    0.07469525f, 0.55513859f, 0.27833542f, 0.44865671f, 0.14245157f, 0.13912095f, -0.08880230f, 0.10372557f, 
    0.02215174f, 0.02688918f, 0.00860998f, 0.01749769f, 0.04415283f, 0.03366055f, -0.02796679f, -0.02697393f, 
    0.06113501f, 0.04457490f, 0.04934761f, 0.01396819f, -0.07856431f, -0.05868700f, -0.13111249f, -0.31446564f, 
    0.04346005f, 0.27614471f, 0.17661004f, 0.17235592f, 0.01688172f, 0.04746053f, 0.02618779f, 0.13509467f, 
    0.02865629f, 0.02176367f, -0.02526715f, 0.05741417f, 0.10029468f, -0.03392249f, 0.02702459f, -0.06651840f, 
    0.08783922f, 0.05414959f, -0.00874643f, -0.02753413f, -0.03220472f, -0.17808978f, -0.00785774f, -0.14014120f, 
    0.00964895f, 0.06520248f, 0.03097840f, 0.03562246f, -0.09336779f, 0.02026896f, 0.08365265f, 0.00187275f, 
    0.14747897f, -0.14493908f, -0.20183609f, 0.04520515f, 0.18674524f, 0.06086920f, 0.27197349f, 0.21173659f, 
    -0.05502729f, -0.13828431f, -0.06824403f, -0.02802895f, 0.17380992f, -0.06677438f, 0.03878519f, 0.00052517f, 
    -0.09815729f, -0.04751148f, 0.11851275f, 0.00698331f, -0.16280812f, 0.02221168f, 0.02988170f, -0.03640099f, 
    0.13397102f, 0.19950598f, 0.00070379f, 0.32392782f, 0.28635034f, 0.07743205f, 0.18556605f, 0.27512825f, 
    -0.04745898f, -0.17090337f, -0.18343653f, -0.22728792f, 0.01226374f, -0.05677482f, -0.04800913f, -0.08321726f, 
    -0.06280673f, -0.04669608f, 0.04809415f, 0.25243402f, 0.00518922f, -0.25361860f, -0.09885132f, -0.07314833f, 
    0.04555700f, -0.09810020f, -0.11457253f, -0.12583147f, 0.04034787f, -0.14120813f, 0.05612863f, 0.03833825f, 
    -0.01210337f, -0.10759097f, 0.07311250f, -0.02181773f, -0.08754990f, 0.09294096f, -0.03477272f, 0.16596153f, 
    0.12699342f, 0.06257747f, 0.01388190f, 0.08902891f, -0.07020139f, 0.01885425f, 0.00140937f, -0.19013487f, 
    0.10787330f, -0.04206832f, -0.05006205f, 0.02482951f, -0.12041765f, -0.10636164f, -0.11486601f, -0.05718844f, 
    -0.01643080f, -0.02566656f, -0.00756305f, -0.04478238f, 0.09692535f, -0.04307843f, 0.00421147f, -0.03426406f, 
    0.06008893f, 0.15514320f, 0.25094327f, 0.17731644f, -0.11968230f, -0.04345061f, -0.11278911f, -0.14866787f, 
    0.08254423f, -0.02179326f, 0.06626379f, -0.10270957f, 0.18781544f, 0.10636252f, -0.07963892f, 0.09397665f, 
    -0.26839364f, -0.14166322f, -0.07953526f, -0.10270861f, 0.11201407f, -0.09196882f, -0.13133618f, -0.06528489f, 
    -0.44707868f, -0.35308754f, 0.01041547f, -0.23094355f, 0.06501997f, 0.12668496f, -0.10911957f, 0.14759479f, 
    -0.07123220f, -0.19143102f, -0.02579379f, 0.07026264f, 0.04053661f, -0.04474970f, 0.11929796f, 0.09004441f, 
    -0.16212229f, -0.22026342f, 0.16115543f, -0.00030816f, 0.08027889f, 0.05898288f, 0.03260291f, 0.23506829f, 
    -0.34253731f, -0.04986468f, -0.05664588f, -0.12639938f, -0.08278953f, -0.39085805f, 0.02694862f, -0.24153785f, 
    -0.07658139f, -0.24704860f, 0.05659140f, 0.02934588f, 0.01501785f, -0.05200197f, 0.08989406f, 0.14289512f, 
    0.02180269f, -0.17450915f, -0.11410687f, 0.03743583f, -0.05410897f, 0.14041193f, -0.11295219f, 0.22948368f, 
    -0.13707517f, -0.11431055f, 0.02438109f, 0.04365420f, -0.04248689f, 0.08512211f, 0.02528717f, 0.01464079f, 
    -0.04572637f, 0.04810098f, 0.07214298f, 0.11345730f, 0.14418782f, -0.11929761f, -0.09244428f, -0.07734089f, 
    0.09083671f, 0.03829760f, -0.00324262f, -0.03759830f, 0.09650837f, 0.10101442f, 0.13983825f, 0.20923547f, 
    -0.00591255f, 0.12985091f, 0.08655737f, 0.08965189f, -0.28284705f, -0.14494596f, 0.19904321f, -0.05815643f, 
    -0.00060050f, 0.00767210f, 0.02368597f, 0.12529081f, -0.24890497f, 0.05589433f, -0.05864590f, -0.03093763f, 
    -0.18229412f, -0.25172651f, -0.00459571f, -0.12099812f, -0.31298473f, -0.22837891f, -0.04876909f, -0.01603040f, 
    -0.26239291f, -0.71612757f, -0.16333123f, 0.09047648f, -0.11660889f, 0.07406198f, -0.02901205f, -0.54881793f, 
    -0.28902099f, -0.02584686f, -0.10354768f, -0.23566973f, 0.16212545f, 0.56856370f, -0.53152210f, 0.00238456f, 
    0.27845439f, 0.26398367f, 0.27609283f, -0.23331855f, 0.08032431f, 0.03523398f, 0.13435583f, -0.23589598f, 
    0.03381510f, 0.17568417f, 0.10713681f, 0.08689863f, 0.10609830f, -0.05768334f, 0.05428593f, -0.11101505f, 
    0.12628587f, 0.05622442f, 0.03437732f, 0.03416266f, -0.08806787f, -0.26731384f, -0.08436169f, -0.04928665f, 
    0.08208176f, -0.02264503f, -0.09770391f, 0.05797319f, -0.00415314f, -0.06265499f, -0.16951928f, -0.03618631f, 
    -0.06335235f, -0.10260366f, 0.10883216f, 0.22721677f, 0.03712931f, 0.05426054f, -0.05735123f, 0.35793492f, 
    -0.02749238f, 0.11279012f, 0.10457188f, -0.11319092f, -0.53073639f, 0.09871271f, -0.04227919f, 0.06235852f, 
    0.10150407f, 0.00006988f, -0.19023669f, 0.08226777f, -0.04771971f, 0.05915523f, 0.02993490f, 0.37723917f, 
    -0.38293776f, -0.01270815f, 0.15032497f, -0.03602274f, -0.20416287f, 0.00204513f, 0.09737606f, 0.35754672f, 
    0.15329060f, -0.08628312f, -0.17110986f, 0.08426270f, 0.21761328f, 0.00611261f, -0.25868201f, 0.14431545f, 
    0.11961964f, 0.06416409f, -0.11110127f, -0.10961618f, 0.11050245f, 0.07860693f, -0.02759958f, 0.16709536f, 
    0.09344429f, 0.16184369f, -0.25932351f, 0.45563483f, 0.13241170f, 0.14826638f, 0.05780471f, 0.00305063f, 
    -0.00795440f, 0.01596655f, -0.08873539f, -0.15151961f, -0.43526858f, 0.19282551f, 0.48202243f, -0.59374118f, 
    0.07327157f, 0.01003400f, 0.09298290f, -0.00557303f, 0.17269209f, 0.20425037f, 0.10191748f, 0.21553338f, 
    -0.06577730f, 0.24474862f, -0.09439731f, 0.01770992f, -0.25615582f, -0.04140471f, -0.01336072f, -0.09400581f, 
    0.04308361f, 0.04735235f, -0.13046190f, -0.03941876f, -0.02320809f, 0.10455260f, -0.10147987f, -0.16333266f, 
    -0.04626603f, 0.01105580f, -0.04020951f, 0.04846051f, -0.03134096f, -0.24501164f, -0.07955483f, 0.08667011f, 
    0.08830472f, 0.36599991f, -0.01233239f, -0.19431309f, 0.26474565f, -0.00630654f, -0.09266026f, -0.04409984f, 
    0.04783816f, 0.09680873f, -0.07039252f, 0.07986461f, -0.05774048f, -0.15392807f, -0.16980220f, 0.04015368f, 
    0.08693073f, -0.02374835f, -0.17279376f, 0.10635969f, 0.14489931f, 0.08349176f, 0.32923216f, -0.02176270f, 
    0.13027033f, -0.32212159f, 0.02093110f, -0.21023473f, -0.00321764f, -0.09015048f, -0.08033504f, -0.03292808f, 
    0.28511250f, 0.07488751f, 0.20771043f, -0.12035614f, 0.31763759f, -0.08211055f, -0.00263409f, -0.24025722f, 
    0.06909812f, 0.08694929f, -0.05574093f, 0.00595958f, -0.15763451f, 0.02624287f, 0.03864808f, -0.02622369f, 
    0.09317881f, -0.17207888f, 0.24150641f, -0.15171833f, -0.00197734f, -0.23187603f, -0.00659333f, 0.07940584f, 
    -0.32458791f, -0.20195839f, -0.56754845f, -0.50740051f, -0.11349855f, 0.08889111f, -0.21245649f, -0.39739767f, 
    -0.06090274f, 0.12369496f, 0.00549303f, -0.11733826f, 0.13583776f, 0.07185411f, 0.07414898f, -0.11956087f, 
    -0.27864239f, 0.00740069f, -0.20480904f, 0.03281162f, 0.24528953f, 0.35247350f, -0.12355171f, 0.33496436f, 
    -0.02629188f, -0.05188283f, 0.11154865f, 0.35622767f, -0.44508290f, -0.03137613f, 0.13184194f, 0.03931778f, 
    0.11379723f, -0.06769573f, -0.04832197f, -0.00607386f, 0.11346214f, 0.06697497f, 0.01126651f, -0.12494874f, 
    -0.07866359f, -0.25177029f, 0.12939468f, -0.02075552f, -0.09221873f, -0.03885687f, 0.04607285f, -0.16062982f, 
    0.18351156f, 0.03764103f, -0.13764985f, 0.00469720f, -0.06125906f, -0.13089678f, -0.00773699f, 0.09349721f, 
    -0.07066912f, -0.15032235f, 0.06004798f, 0.05498959f, -0.03483210f, 0.05967794f, -0.02082162f, 0.02924418f, 
    0.09040140f, 0.17871775f, -0.04287327f, 0.13667467f, 0.07440399f, 0.14822248f, 0.12854649f, 0.07481471f, 
    -0.03381376f, -0.05726485f, 0.11168512f, 0.01467814f, -0.57943469f, -0.52070373f, 0.08057693f, -0.16504516f, 
    0.07714186f, -0.09883625f, 0.11460408f, -0.06844427f, 0.07807205f, 0.00636914f, 0.11370261f, -0.01808721f, 
    -0.49653405f, -0.58365142f, -0.19226356f, -0.16986795f, -0.05724609f, -0.10468088f, -0.04935124f, -0.02390237f, 
    -0.00050322f, -0.31103140f, 0.20834205f, -0.21409419f, -0.45556340f, -0.01633061f, -0.07361538f, -0.33586222f, 
    0.03135051f, 0.02093240f, -0.03895086f, -0.08322098f, 0.16811289f, -0.11568817f, -0.07782274f, -0.15376195f, 
    -0.27386963f, 0.01916066f, -0.62199676f, 0.05081786f, 0.07990620f, -0.07499393f, 0.16986786f, 0.19242156f, 
    0.09598646f, 0.04096074f, -0.24771853f, -0.01470380f, -0.24173091f, 0.25891948f, -0.12004774f, -0.16345364f, 
    -0.00567501f, 0.04578808f, -0.03458198f, 0.08617793f, 0.13090323f, 0.02320864f, -0.05044584f, -0.21673031f, 
    -0.12278132f, 0.06489258f, 0.21987921f, 0.12186126f, -0.10756501f, -0.04611027f, -0.05005135f, -0.03184065f, 
    0.10552791f, -0.20885032f, -0.33183178f, -0.18716437f, -0.08475661f, -0.15436579f, -0.04804878f, 0.15345058f, 
    -0.00156113f, 0.05483758f, 0.07464318f, 0.09013710f, 0.20709394f, -0.07378746f, -0.05298238f, -0.31260532f, 
    0.04300305f, 0.15843630f, 0.09333657f, -0.11928935f, 0.37751058f, 0.32102361f, -0.01116562f, -0.14135969f, 
    0.15238068f, 0.07103919f, 0.03802824f, 0.03289606f, 0.24690443f, -0.03337031f, -0.05785889f, -0.15646195f, 
    0.24203557f, 0.10579856f, -0.12500262f, 0.18860473f, 0.10870922f, 0.07616748f, -0.03429496f, 0.17737903f, 
    -0.03126225f, -0.03788109f, 0.41440600f, 0.37256569f, 0.01161656f, -0.09868541f, 0.05011931f, 0.19372854f, 
    -0.03639520f, -0.02060470f, 0.03348145f, 0.15642996f, -0.20988269f, 0.11557649f, -0.58966470f, -0.43518609f, 
    0.23136234f, 0.08044817f, -0.11314902f, -0.02713662f, -0.02819052f, -0.04779814f, 0.05885790f, -0.04842465f, 
    0.17727734f, -0.04730319f, 0.05124717f, -0.17275994f, -0.10349353f, -0.02598911f, -0.04578661f, 0.12894583f, 
    -0.23999444f, -0.03465322f, -0.05302522f, -0.07216822f, 0.45686874f, 0.07897657f, -0.64702004f, 0.26396495f, 
    0.03687964f, -0.06219930f, -0.01568871f, -0.06320763f, -0.05573580f, -0.04123424f, -0.02793529f, 0.21191671f, 
    0.16343246f, -0.49439669f, -0.65337044f, -0.24800213f, -0.36371109f, 0.26164356f, 0.17605396f, 0.07918267f, 
    -0.03927636f, 0.02997647f, -0.00622254f, 0.00580995f, 0.24153766f, 0.02091785f, -0.26649874f, 0.08010145f, 
    0.13569228f, -0.06942554f, 0.13337573f, 0.03460284f, -0.04496324f, -0.03872900f, -0.14615612f, 0.03137145f, 
    -0.24504818f, -0.32864711f, -0.05933693f, 0.40523738f, 0.05978013f, 0.22207980f, -0.01030691f, 0.12793985f, 
    -0.01055683f, -0.06457009f, 0.07582960f, 0.12414730f, -0.02734560f, -0.10612173f, 0.01073098f, -0.39147988f, 
    -0.01222912f, -0.09335867f, -0.06703257f, 0.06795063f, -0.07981003f, 0.22588833f, -0.26076376f, -0.01189700f, 
    -0.10606480f, -0.56227291f, -0.00346041f, -0.42105830f, 0.11012295f, -0.03564700f, 0.22058572f, -0.16200207f, 
    0.02001475f, 0.13936247f, 0.07974588f, 0.12803356f, -0.01726298f, -0.30063361f, 0.19510315f, 0.33636618f, 
    0.21373498f, -0.04673940f, 0.13067138f, -0.13646165f, 0.10285608f, 0.09101968f, 0.05754590f, -0.11627873f, 
    -0.68028593f, -0.29043102f, -0.01810185f, -0.25224656f, 0.26503381f, -0.20701741f, -0.10409822f, -0.09550738f, 
    0.16368830f, -0.08634761f, 0.03099716f, 0.07871583f, -0.02971995f, 0.37315497f, 0.15667559f, -0.03184951f, 
    -0.11777949f, -0.05247112f, -0.05198552f, 0.03249317f, -0.04793416f, 0.08695141f, 0.07741632f, -0.01716647f, 
    -0.69161379f, -0.89158416f, -0.35865596f, -0.41073358f, 0.12942581f, -0.08291284f, -0.12876393f, -0.27154240f, 
    0.06491569f, -0.06989305f, -0.02168432f, 0.02435709f, 0.16535568f, -0.02165141f, -0.21612288f, 0.01365605f, 
    -0.10322718f, 0.05318787f, -0.03212344f, 0.02418448f, -0.03405540f, -0.17062552f, -0.24950865f, -0.16550061f, 
    -0.01626763f, 0.48920733f, -0.05211936f, 0.04553450f, -0.04033224f, -0.02646192f, -0.05027237f, 0.14482415f, 
    0.16196634f, -0.07565462f, -0.03978840f, 0.23783098f, 0.00720815f, 0.30404121f, 0.10859358f, -0.36295289f, 
    -0.14657992f, -0.03788830f, -0.43359935f, -0.11081833f, -0.02235362f, -0.00642858f, -0.10226909f, -0.01565986f, 
    -0.17664982f, -0.05561143f, -0.15952681f, -0.00378200f, -0.02399504f, 0.05793966f, 0.08941139f, 0.15171318f, 
    0.22399752f, 0.01493454f, 0.23097074f, 0.03599444f, -1.06605005f, -0.06921932f, 0.57560450f, 0.01634738f, 
    -0.12232850f, -0.25504169f, -0.02851788f, -0.17295712f, -0.11710469f, 0.05214424f, 0.01866804f, 0.07289337f, 
    0.05329970f, -0.23561096f, -0.14364904f, -0.13880207f, -0.02353553f, -0.04070430f, 0.18355909f, -0.20952608f, 
    -0.01561118f, -0.01563038f, -0.04886631f, -0.06270144f, 0.03982219f, -0.08592964f, 0.18051513f, -0.02833985f, 
    -0.00361670f, 0.01842466f, -0.00431377f, 0.09425221f, 0.16453405f, 0.02637062f, 0.12507425f, -0.05544875f, 
    -0.15816979f, -0.13890493f, -0.08362165f, 0.03033686f, -0.18620513f, -0.34134471f, -0.18928486f, 0.25409824f, 
    -0.11178555f, -0.04018721f, 0.11093956f, -0.07048324f, 0.25442493f, -0.14182010f, -0.43166485f, -0.18735151f, 
    -0.08169827f, -0.05033414f, 0.08679058f, 0.12718265f, -0.17655340f, -0.01539456f, -0.06046831f, -0.11470604f, 
    0.35504803f, -0.30124164f, -0.43382391f, -0.39269522f, -0.05565688f, -0.21556634f, 0.13178176f, -0.14594553f, 
    0.07545837f, 0.02641295f, -0.18020594f, -0.23134127f, -0.45197856f, -0.12943813f, 0.49391747f, 0.20718105f, 
    -0.08222939f, -0.05300292f, -0.00742952f, 0.10906339f, -0.03043919f, 0.10614556f, -0.00079759f, -0.02502866f, 
    -0.34417248f, 0.37710464f, -0.01206299f, 0.09965880f, -0.02723840f, 0.03378597f, 0.02494271f, 0.10769112f, 
    0.12737668f, 0.07219505f, 0.27825004f, 0.13516124f, -0.18637548f, -0.02736193f, 0.46744126f, -0.18412255f, 
    -0.04392231f, -0.01624692f, -0.02204488f, -0.00409304f, 0.05997669f, 0.22392693f, 0.00893803f, 0.27083650f, 
    -0.09642553f, -0.11931664f, 0.50247997f, 0.24344188f, -0.18192193f, 0.18777396f, 0.00389185f, -0.04330933f, 
    0.07151071f, 0.16965716f, 0.11202507f, -0.00769104f, -0.36551958f, -0.16965516f, 0.03499920f, -0.18342154f, 
    -0.12116357f, 0.24489899f, 0.08249192f, -0.18954238f, 0.13999142f, -0.02381057f, 0.00845415f, 0.12057295f, 
    -0.24057314f, -0.60974878f, -0.47806236f, -0.10483388f, -0.24116647f, 0.03093629f, 0.08979109f, 0.08310448f, 
    -0.11467600f, 0.05535379f, 0.14505979f, 0.05066021f, 0.07350789f, 0.07982550f, -0.04283411f, -0.17895797f, 
    0.01084418f, -0.01549819f, 0.05893636f, 0.10455222f, -0.09779426f, -0.11767092f, 0.04276064f, 0.13568529f, 
    -1.13349438f, -1.25387537f, -1.06433427f, -0.15416992f, -0.28304395f, -0.06799202f, -0.31311783f, -0.53442556f, 
    -0.02004886f, -0.00905405f, -0.03779711f, 0.05769747f, 0.35414153f, 0.39667717f, 0.15368199f, 0.29528335f, 
    -0.03346063f, -0.21860528f, 0.14281657f, 0.18447450f, -0.01605630f, 0.01501511f, -0.12191720f, 0.06430583f, 
    -0.07231390f, -0.10027022f, 0.22466423f, 0.09485957f, 0.15525247f, -0.05839363f, 0.08734682f, -0.10743086f, 
    -0.17880869f, 0.17614599f, -0.01021247f, 0.01169732f, 0.27888829f, -0.37922689f, 0.08664326f, -0.24484701f, 
    0.11113571f, 0.16121432f, 0.18803535f, -0.12822779f, 0.14292063f, -0.08328703f, 0.04319153f, -0.01595254f, 
    0.41562846f, 0.25923654f, -0.16412322f, -0.11507508f, -0.02682707f, 0.03864830f, -0.07549257f, 0.12901431f, 
    0.10516144f, 0.00810751f, 0.04487855f, 0.09265150f, 0.48803771f, 0.02755676f, -0.32233250f, 0.09245820f, 
    0.03256310f, -0.10007721f, 0.19329976f, 0.00457845f, 0.10947281f, 0.09818131f, -0.08002516f, -0.18602537f, 
    -0.09329976f, 0.04377044f, -0.06296611f, -0.09461993f, 0.07655349f, 0.27380127f, 0.05137216f, -0.20978978f, 
    0.00388589f, 0.02144002f, 0.09171050f, 0.10018798f, -0.01717762f, -0.05951995f, 0.07753528f, -0.06021808f, 
    0.03032221f, -0.05354063f, -0.07416997f, -0.00928921f, 0.02205331f, 0.05972722f, -0.04206573f, -0.13500398f, 
    -0.06035492f, -0.00813061f, 0.03014999f, -0.12475904f, 0.03856930f, 0.00239204f, -0.02515839f, 0.08691949f, 
    0.08984032f, 0.06437105f, 0.06400661f, -0.15222019f, -0.11840480f, 0.27360886f, -0.26563609f, -0.10049445f, 
    0.14128512f, 0.10313982f, 0.08757340f, -0.00222267f, -0.00805031f, 0.04798311f, -0.01940982f, -0.05501501f, 
    -0.52294302f, 0.48396474f, -0.30345488f, 0.05980775f, -0.24104686f, -0.05800900f, -0.03911434f, 0.03720133f, 
    0.01451454f, 0.00304986f, 0.12625258f, 0.10385737f, 0.23487251f, 0.10892989f, 0.41887379f, -0.07477771f, 
    0.01526476f, -0.00646368f, -0.11542652f, 0.12552151f, -0.09922858f, -0.11803432f, 0.14800961f, -0.18227050f, 
    -0.72060513f, 0.44204420f, 0.33233041f, 0.28577033f, 0.05384321f, -0.00031136f, -0.02218023f, 0.12549075f, 
    0.06427336f, -0.09597411f, 0.15960817f, 0.02332920f, 0.02288989f, 0.03850906f, 0.07950532f, 0.03144404f, 
    0.00731445f, -0.02675098f, -0.04190256f, 0.00318811f, 0.02574234f, 0.09828656f, -0.02397409f, 0.09529525f, 
    -0.68265998f, 0.52894145f, -0.09990462f, 0.34529206f, 0.11520959f, 0.09301918f, 0.20020893f, 0.06282556f, 
    -0.01458234f, 0.02820534f, -0.07294118f, -0.08997930f, 0.02298250f, -0.05301142f, 0.12238037f, -0.07684127f, 
    -0.07234789f, 0.03382926f, -0.04617018f, -0.10729405f, -0.15354881f, -0.21447316f, 0.03191942f, -0.04789143f, 
    0.00060481f, -0.05633450f, 0.15137348f, -0.15291494f, -0.03826978f, -0.12079731f, 0.12857024f, -0.01803826f, 
    0.03685334f, -0.05717407f, 0.05045231f, 0.02792721f, -0.33979505f, -0.22642483f, -0.18116178f, 0.00671879f, 
    0.18909983f, 0.08058821f, 0.05829553f, 0.07309517f, -0.09988242f, -0.11642896f, 0.13215844f, 0.10679728f, 
    0.38038206f, -0.29861850f, -0.06747074f, 0.00267069f, 0.02594225f, -0.19264962f, -0.01385359f, -0.18299708f, 
    0.10355703f, 0.20223387f, 0.08289474f, 0.03624516f, 0.08345442f, -0.21729994f, -0.48056269f, -0.34170681f, 
    0.04685686f, -0.06290725f, -0.05169788f, 0.06637741f, -0.02570228f, 0.01955668f, 0.07944876f, 0.10334948f, 
    -0.02297433f, 0.11369047f, -0.01589355f, 0.06484073f, -0.04078886f, -0.18179967f, -0.11788758f, -0.15213425f, 
    -0.06401180f, -0.03813984f, -0.05291016f, -0.02936612f, 0.37150273f, 0.17912984f, -0.09787658f, -0.17996150f, 
    0.01377911f, -0.02173306f, -0.03192391f, -0.05688300f, 0.00240686f, -0.15917538f, -0.10118628f, -0.31336260f, 
    0.32721183f, -0.07637059f, 0.07846428f, 0.04122217f, -0.28866059f, 0.03058584f, -0.05827114f, 0.06426332f, 
    0.03672574f, 0.07858634f, 0.04306135f, 0.05992990f, 0.01457444f, -0.14540054f, -0.02674961f, -0.16265075f, 
    0.04875432f, -0.02048326f, -0.07979297f, -0.10301214f, 0.02783536f, -0.01128062f, -0.06238613f, -0.17224047f, 
    -0.85643703f, -0.36124179f, -0.45882398f, 0.65591556f, -0.08814742f, 0.00041378f, -0.15267827f, -0.26021209f, 
    0.04568723f, 0.04973650f, 0.02908362f, 0.07533915f, 0.69654053f, -0.27941537f, -0.37971553f, -0.46655267f, 
    -0.07514399f, -0.23539454f, -0.35229826f, 0.11888043f, 0.06553923f, -0.00971810f, 0.04912417f, -0.01410362f, 
    -0.32685310f, -0.30765390f, 0.04507392f, 0.05296573f, -0.00390635f, 0.03234213f, 0.17539431f, -0.07488659f, 
    -0.09925471f, 0.10996910f, 0.02311085f, -0.15022296f, 0.55027741f, -0.16602498f, -0.18935405f, -0.55248320f, 
    -0.09417495f, -0.04604493f, -0.31889766f, 0.16993935f, 0.21331573f, 0.24208783f, 0.12540431f, 0.15362649f, 
    0.08301212f, -0.07039850f, -0.06974366f, 0.12826546f, 0.02490212f, 0.10465869f, -0.14812255f, -0.15653700f, 
    0.06841201f, -0.11522303f, 0.01880183f, -0.06258439f, -0.24774508f, -0.03994100f, -0.36621177f, -0.13995777f, 
    0.38208815f, 0.00626043f, 0.02353011f, 0.09062582f, 0.06692130f, -0.13477679f, 0.02354473f, 0.07643640f, 
    0.18447919f, -0.68684447f, -0.14374878f, 0.02522429f, -0.19671772f, 0.00617599f, -0.09474824f, 0.11940577f, 
    0.08017518f, -0.06597935f, -0.11555724f, 0.00012828f, 0.03335102f, 0.08498089f, 0.11121655f, 0.07973061f, 
    -0.01327593f, -0.08338413f, 0.00561084f, 0.00170646f, 0.09266209f, -0.14360948f, -0.01890499f, -0.05138081f, 
    -0.37636504f, -0.77997917f, -0.22869432f, -0.14011273f, 0.06698628f, -0.16622505f, -0.11269798f, 0.23133077f, 
    0.04768999f, -0.01547552f, -0.05489057f, -0.02175145f, -0.44905594f, 0.34297132f, 0.15941752f, -0.49529794f, 
    -0.04484618f, 0.07876737f, 0.03921951f, -0.13381496f, -0.15289663f, -0.08720143f, 0.02604881f, -0.03370459f, 
    0.38174668f, -0.12406137f, -0.03972660f, -0.71733445f, -0.12095735f, 0.03639197f, -0.23695867f, 0.26980531f, 
    -0.12766853f, 0.03745876f, -0.14673831f, -0.12368126f, -0.51070118f, 0.48906294f, 0.05241575f, 0.14823580f, 
    0.04251817f, -0.21771169f, 0.11907589f, 0.06826209f, 0.17796248f, 0.03510915f, 0.17456877f, -0.03309714f, 
    -0.84183425f, -0.34311393f, -0.03757596f, -0.24928422f, -0.03164085f, -0.01444110f, 0.12837413f, 0.16593781f, 
    -0.13541342f, -0.05990033f, 0.10580128f, -0.07942031f, -0.17558520f, -0.07516123f, 0.05561861f, 0.00312887f, 
    0.00491440f, 0.07321930f, -0.09343728f, -0.09643799f, -0.01873216f, -0.17978126f, 0.17470893f, -0.03848754f, 
    -0.40513945f, 0.19281070f, 0.24890833f, 0.07764149f, 0.26139995f, -0.11417297f, -0.04415725f, -0.02441066f, 
    -0.17798448f, -0.09278443f, -0.03681267f, -0.12769023f, 0.02838086f, -0.11906566f, -0.11669084f, -0.26411471f, 
    -0.00914130f, -0.17133296f, 0.00719953f, 0.03712171f, 0.10329010f, 0.00657352f, 0.15636753f, -0.01454901f, 
    0.10842956f, -0.06539548f, 0.12127531f, -0.07043418f, -0.06893549f, 0.14103794f, -0.06606515f, -0.05622564f, 
    -0.07159274f, -0.03666250f, 0.01603444f, 0.06165857f, -0.35924008f, -0.04719837f, 0.06933669f, 0.42065150f, 
    -0.00995871f, 0.02554583f, -0.03914612f, -0.12633863f, 0.16330962f, 0.07814324f, 0.11118978f, 0.14602737f, 
    -0.69774610f, 0.07071323f, -0.11862139f, 0.13040619f, 0.18253975f, 0.01808862f, -0.04970639f, 0.00435795f, 
    -0.08966070f, 0.08819488f, -0.00330392f, -0.07626142f, 0.54572833f, 0.04043433f, -0.27324429f, -0.36524269f, 
    -0.06421793f, -0.13053069f, 0.24380709f, 0.01212058f, -0.00321434f, 0.12779163f, 0.16647917f, -0.06846379f, 
    0.19827075f, -0.47065431f, 0.13682711f, -0.49071047f, -0.09607529f, -0.22227813f, -0.04463815f, 0.16014367f, 
    0.17842759f, 0.07300263f, 0.08310500f, 0.02982032f, -0.26417696f, -0.32947311f, 0.00152328f, 0.01773955f, 
    -0.09919781f, 0.01601996f, 0.05678990f, 0.09579016f, 0.13729727f, -0.04352000f, -0.05235644f, -0.06873398f, 
    -0.71704119f, -0.68294358f, -0.25180936f, -0.04999201f, -0.06258855f, -0.03628368f, -0.18346165f, -0.12451618f, 
    -0.00353030f, 0.02863026f, 0.12349603f, 0.02042340f, -0.14816585f, 0.10912084f, -0.02027052f, -0.04877492f, 
    -0.00582282f, -0.08803608f, -0.02052856f, 0.02383937f, 0.14660908f, 0.09152965f, 0.06444778f, 0.14320457f, 
    -0.31250614f, -0.31753993f, 0.03247613f, 0.00197094f, 0.13781174f, 0.10166645f, -0.04932899f, 0.11137246f, 
    -0.09433573f, 0.10463733f, -0.06899488f, 0.20511164f, -0.23134713f, -0.26461712f, -0.23698273f, 0.00757805f, 
    -0.17939062f, 0.05314462f, -0.02723226f, 0.10116903f, -0.31803858f, -0.13566187f, -0.25549513f, -0.15333620f, 
    0.34402910f, -0.01533545f, -0.11578683f, -0.11889996f, 0.07951595f, 0.05766323f, 0.01356710f, -0.01852969f, 
    0.08974259f, -0.31841734f, 0.05253536f, -0.49282163f, -0.35444579f, -0.77824837f, -0.38015211f, 0.23696716f, 
    -0.07710600f, 0.23638475f, 0.15372534f, 0.02832001f, 0.08918393f, 0.15909114f, 0.19127770f, 0.17261016f, 
    0.02991509f, 0.07031121f, 0.21199255f, 0.06905811f, 0.09707642f, -0.17762703f, -0.13695735f, 0.14772153f, 
    0.20343828f, 0.11501431f, 0.19059773f, 0.00723211f, 0.04685357f, -0.08280950f, -0.27812874f, -0.42441973f, 
    -0.11970170f, -0.06300722f, -0.00008128f, 0.05112758f, 0.09896091f, 0.11228161f, -0.01193168f, 0.03679253f, 
    0.02407726f, -0.28710434f, -0.31235445f, -0.15979648f, 0.16154653f, 0.16071369f, 0.04757849f, 0.02150479f, 
    0.07399159f, 0.08699612f, 0.09922658f, 0.11525799f, 0.36532241f, 0.17221476f, -0.14816968f, -0.19895276f, 
    0.08312251f, 0.01929243f, 0.01410428f, 0.01028764f, -0.11124080f, -0.00349302f, 0.11085421f, 0.10578255f, 
    -0.15847158f, -0.26581514f, -0.21250653f, 0.40513542f, 0.17709497f, -0.01800168f, -0.15667154f, 0.13037206f, 
    -0.13393714f, 0.07238925f, 0.12374796f, -0.01580383f, -0.07588489f, -0.32884943f, -0.27540255f, 0.12870009f, 
    0.01792956f, 0.21405151f, 0.15976016f, 0.13260092f, -0.00691278f, 0.10534906f, 0.01344450f, 0.04189590f, 
    -0.28146386f, -0.37793466f, 0.02671585f, -0.02317670f, -0.09461625f, 0.03770668f, 0.02839324f, -0.21933724f, 
    0.22860450f, 0.04883526f, -0.04333075f, 0.08250811f, -0.21206392f, -0.33842865f, -0.14066815f, 0.08555540f, 
    -0.05974080f, 0.16776314f, 0.08903958f, 0.04764733f, -0.30086267f, -0.15267265f, -0.11627877f, -0.58013958f, 
    -0.23523813f, -0.04475613f, 0.21114205f, 0.40371481f, 0.09821714f, 0.18004137f, 0.11065292f, 0.31468651f, 
    -0.05398580f, 0.11263884f, 0.07972700f, -0.21651983f, 0.12538457f, -0.26022363f, -0.04558428f, 0.14415041f, 
    0.11570024f, 0.17687801f, 0.07857065f, 0.02162598f, -0.22120352f, -0.10760050f, -0.05978886f, -0.18920930f, 
    0.34562761f, -0.10675626f, -0.10897327f, -0.21622954f, 0.24511674f, 0.10070895f, 0.11736138f, -0.05959362f, 
    0.14589147f, -0.04446164f, -0.15618093f, -0.40051514f, -0.45694381f, 0.06096753f, 0.00643739f, -0.16615520f, 
    -0.00955349f, -0.04074588f, -0.04110458f, -0.00765936f, -0.16838373f, -0.24316509f, -0.19818990f, -0.14572559f, 
    -0.02690040f, -0.24175203f, -0.81265867f, -0.63043010f, 0.04354427f, -0.30045745f, 0.11489285f, -0.16613592f, 
    0.04900411f, -0.02171496f, -0.05639924f, 0.08738609f, -0.06930698f, -0.43119866f, 0.23422641f, 0.41450667f, 
    0.15659927f, 0.02121865f, 0.14737430f, 0.02353565f, 0.07304917f, 0.10257250f, 0.11593215f, 0.29754835f, 
    0.44087955f, 0.41249996f, -0.31068105f, -0.30249241f, 0.02864040f, -0.24189763f, 0.11309299f, 0.14783886f, 
    0.17296673f, 0.01248723f, 0.19005413f, 0.33372259f, -0.90688705f, -0.07434002f, 0.13669865f, 0.22384390f, 
    -0.07692017f, 0.15462369f, -0.14593992f, 0.01663175f, -0.11959869f, -0.09752025f, 0.00057906f, 0.06090859f, 
    -0.09494499f, -0.35307997f, -0.20348947f, 0.04785855f, 0.11489687f, 0.12854943f, -0.03197104f, 0.06334867f, 
    -0.30256504f, -0.09617630f, -0.08882619f, -0.15205799f, -0.55662018f, 0.40397260f, 0.06720906f, 0.19949086f, 
    -0.00607693f, 0.02307092f, -0.14980403f, 0.07660858f, -0.10870348f, 0.17952946f, 0.10184918f, 0.13112497f, 
    0.13814530f, 0.31777701f, -0.98025423f, 0.08927073f, 0.17971535f, 0.01892610f, 0.16131878f, -0.05798866f, 
    -0.02789578f, 0.01311774f, 0.01103644f, 0.08942869f, -0.18168141f, -0.39957061f, -0.03921292f, -0.06933036f, 
    -0.08616540f, -0.02562330f, -0.02270479f, -0.24351674f, -0.04464605f, 0.00395622f, -0.01051013f, -0.19141933f, 
    0.30011591f, -0.67155904f, 0.25527602f, -0.58485651f, 0.06650086f, 0.15898558f, -0.17356072f, -0.04707308f, 
    0.08613186f, -0.21564613f, -0.06855985f, -0.14279200f, -0.27947834f, -0.01103086f, -0.28372484f, 0.09211185f, 
    0.15219197f, -0.05455757f, 0.19719726f, 0.13178946f, -0.10243691f, -0.07987868f, -0.13230580f, -0.17712575f, 
    -0.22779353f, -0.00216020f, -0.23134997f, -0.24045996f, -0.12985167f, 0.08983789f, 0.15735418f, 0.09055184f, 
    0.04387122f, 0.14541663f, 0.05896252f, 0.12483881f, 0.17711338f, -0.57974291f, 0.34721044f, -0.08785047f, 
    -0.09700334f, 0.07021163f, -0.14201568f, -0.23034930f, -0.08846665f, 0.22820181f, -0.01725950f, 0.03899780f, 
    0.39593047f, 0.07723324f, -0.39158583f, 0.16024603f, -0.22801219f, 0.10398799f, 0.00003079f, -0.01932308f, 
    0.00691908f, -0.04055262f, 0.01367509f, -0.19287565f, 0.25279000f, 0.03928539f, 0.41784808f, 0.10445154f, 
    0.05888039f, -0.14348623f, -0.05776424f, -0.06647485f, -0.00559774f, 0.09924202f, -0.06370614f, 0.10566414f, 
    -0.21449538f, 0.12985146f, -0.54606795f, -0.03494733f, -0.31611311f, 0.01171885f, 0.21935245f, -0.00206991f, 
    0.00516117f, 0.12925103f, 0.02290355f, -0.04236906f, 0.13087550f, -0.07206997f, -0.03450691f, -0.01992707f, 
    0.05931636f, 0.05406871f, 0.08104494f, -0.02842079f, 0.12789328f, -0.08899076f, 0.07785796f, -0.01949946f, 
    0.29489264f, -0.38778719f, 0.24555023f, -0.42194796f, 0.06999305f, -0.26399297f, 0.06862566f, -0.27458724f, 
    -0.03473742f, -0.04510950f, 0.08461405f, -0.01594996f, 0.11469182f, 0.30115610f, 0.23801766f, -0.01879842f, 
    0.06615133f, -0.18145365f, -0.05214715f, -0.07663553f, -0.02972645f, 0.09489344f, -0.05424637f, 0.01758797f, 
    -0.01820647f, -0.10273493f, 0.24158390f, 0.29394591f, 0.10748203f, 0.04268711f, -0.03854354f, -0.00226982f, 
    0.05762923f, 0.07856899f, 0.15978700f, 0.29187542f, 0.08890193f, 0.19625188f, 0.07538985f, -0.41861412f, 
    0.02890291f, -0.08796356f, -0.38626945f, -0.11907421f, -0.13998447f, -0.00954770f, 0.09599524f, 0.01640966f, 
    -0.15684581f, -0.05861784f, -0.34128079f, -0.14440605f, 0.03652378f, -0.03301751f, 0.23262756f, 0.16831428f, 
    0.13665977f, -0.10763761f, -0.21658811f, -0.01766783f, -0.18275820f, 0.00976360f, 0.21103939f, 0.54750621f, 
    -0.07294314f, 0.11812112f, -0.20030271f, -0.19460158f, 0.10869662f, 0.05180045f, 0.04992106f, -0.03404362f, 
    0.02453455f, 0.15936355f, 0.10085728f, 0.00012580f, 0.03837914f, -0.14674987f, 0.08602856f, -0.07448332f, 
    -0.01482407f, -0.06585217f, 0.02664466f, -0.03188616f, -0.09315465f, 0.10435128f, -0.05874484f, 0.20401333f, 
    0.12326989f, 0.06282856f, 0.27871588f, -0.33089042f, 0.23485623f, -0.04936448f, -0.13024834f, 0.03634643f, 
    -0.05344182f, 0.57924849f, 0.18796167f, -0.55640990f, -0.08149095f, -0.15518339f, 0.13673581f, 0.16163148f, 
    -0.12703298f, 0.03611413f, -0.07637633f, -0.04815657f, 0.13044339f, 0.07192528f, -0.07388919f, 0.17478144f, 
    -0.25371441f, -0.14982975f, -0.25039637f, -0.35062453f, 0.15034801f, -0.10996558f, -0.12437760f, 0.04909331f, 
    0.26804450f, -0.17620173f, 0.41219306f, -0.02527682f, 0.06550831f, -0.13160972f, -0.07632905f, 0.03563549f, 
    -0.10425200f, 0.21761128f, 0.10122619f, -0.00517906f, -0.05008462f, -0.14097992f, -0.25531545f, 0.14686111f, 
    -0.11404102f, 0.01241000f, -0.16744027f, -0.02268185f, 0.05646208f, 0.02001825f, 0.09900492f, 0.07274262f, 
    -0.66201162f, 0.20418952f, -0.18861969f, -0.19732948f, -0.04435242f, -0.17732139f, -0.19749755f, -0.16388001f, 
    0.02087328f, -0.20119131f, 0.17271599f, 0.08832417f, -0.41073936f, 0.21550132f, 0.03499338f, -0.47946832f, 
    -0.34711805f, -0.04317236f, -0.05363719f, -0.05639282f, 0.06992277f, -0.04484653f, 0.11516321f, 0.07267030f, 
    -0.21491842f, 0.21164416f, 0.17862628f, 0.26729316f, 0.14454916f, 0.02767387f, -0.08292228f, -0.09203806f, 
    0.15976180f, 0.07796895f, 0.05341812f, 0.07803097f, -0.02941483f, -0.17328678f, 0.09729091f, 0.02312319f, 
    0.11962633f, 0.05731192f, 0.08296337f, -0.02295911f, 0.04751198f, -0.02474495f, 0.21637687f, 0.04312591f, 
    -0.43806446f, -0.29816276f, 0.06597048f, 0.26842004f, -0.06382038f, -0.07418565f, -0.01689161f, 0.45139733f, 
    0.08685461f, -0.04893009f, 0.12541696f, -0.03264258f, 0.04313884f, -0.24123117f, -0.13227066f, -0.84153146f, 
    -0.04179053f, -0.03415994f, 0.10516941f, -0.05372575f, -0.26578477f, -0.10533970f, -0.10462318f, 0.09564907f, 
    -0.19129845f, -0.43515956f, -0.04838716f, 0.48550680f, 0.07951818f, 0.06733966f, -0.25912651f, -0.06933232f, 
    0.05943972f, -0.04333670f, 0.06666732f, -0.00048700f, -0.25924644f, 0.13451663f, -0.24031833f, -0.39111200f, 
    0.05298712f, -0.04116692f, 0.19695087f, 0.11055566f, 0.17439370f, 0.01189479f, -0.16650504f, -0.05053742f, 
    -0.20127030f, 0.36663404f, 0.59977102f, -0.52172846f, -0.10942811f, -0.12165693f, -0.00767043f, -0.16417909f, 
    -0.06736594f, -0.01921310f, 0.04731102f, 0.13235632f, -0.06108110f, 0.19181402f, -0.11029158f, -0.14219031f, 
    -0.19703388f, -0.00623060f, 0.18512338f, -0.16119917f, 0.10454517f, 0.16376211f, -0.08846647f, -0.03462402f, 
    -0.09728744f, -0.16356105f, -0.54557842f, -0.00597114f, -0.00863931f, -0.18703495f, 0.09115496f, -0.08448504f, 
    -0.20732461f, 0.06025161f, -0.27457961f, 0.02940632f, -0.27510118f, 0.09998124f, -0.20074482f, -0.08148319f, 
    -0.21760724f, 0.11286825f, 0.25506991f, -0.05106288f, 0.08543966f, 0.17024828f, 0.08183060f, 0.09006363f, 
    -0.31315547f, 0.27882710f, 0.29178771f, 0.13389672f, -0.14941865f, 0.00858919f, 0.03826172f, -0.26047480f, 
    0.25961816f, 0.18659212f, 0.07617693f, 0.21865562f, 0.12324185f, -0.17053358f, 0.38601446f, 0.24340431f, 
    -0.10764723f, -0.01085532f, 0.04686524f, 0.17801176f, -0.09509155f, -0.11407121f, 0.30829129f, 0.41902721f, 
    0.12443928f, -0.14388770f, 0.17015263f, 0.14690225f, 0.05817029f, -0.07769588f, 0.08611639f, -0.04389496f, 
    0.11038635f, -0.10392588f, -0.17191404f, -0.22972710f, -0.01075089f, -0.02871128f, 0.25673586f, 0.00668792f, 
    0.16483584f, -0.01725806f, 0.09052017f, 0.04161551f, -0.04823340f, -0.04870398f, -0.18952301f, -0.06854055f, 
    -0.19963624f, 0.00255155f, -0.07891617f, 0.06176291f, 0.10106142f, 0.08672757f, 0.24702723f, -0.32974190f, 
    0.03035871f, 0.19514178f, 0.03016528f, -0.00324392f, -0.04594888f, 0.22722636f, 0.02531656f, 0.18402566f, 
    0.12520112f, 0.03956329f, -0.18924460f, 0.07163496f, -0.12257109f, 0.16680369f, 0.01835481f, -0.23337147f, 
    -0.07141277f, 0.09448197f, -0.24076222f, 0.06665174f, -0.18029457f, 0.04556053f, -0.09972069f, 0.03227859f, 
    0.23266760f, 0.14289068f, -0.11637897f, 0.07706007f, -0.13951707f, 0.07622525f, -0.52705622f, -0.13858913f, 
    -0.00697544f, 0.10152385f, 0.17185119f, -0.11467826f, -0.17720652f, 0.12708414f, 0.17603946f, 0.13246524f, 
    0.01254200f, 0.31518313f, -0.44056103f, 0.44119787f, -0.18311206f, -0.18436725f, 0.20043761f, 0.04854507f, 
    -0.02883642f, 0.38465187f, -0.11340444f, -0.12609147f, -0.44884816f, -0.35385469f, -0.03852949f, 0.24504179f, 
    0.07859106f, -0.10003579f, 0.04001313f, 0.04943758f, -0.01531172f, -0.11526451f, 0.00055632f, 0.09401917f, 
    -0.57354462f, 0.24914406f, 0.26670513f, -0.38289294f, -0.14838025f, 0.16864435f, -0.10179634f, -0.00906235f, 
    -0.20592803f, -0.18735296f, -0.48570660f, -0.55058444f, 0.43804756f, -0.31756589f, 0.11981056f, 0.05932997f, 
    -0.14547184f, 0.10686145f, 0.05855110f, 0.21829936f, 0.02777574f, 0.13495578f, 0.06669863f, -0.11340983f, 
    -0.08647769f, -0.57090694f, 0.00794038f, -0.11630608f, -0.14120595f, 0.09972895f, 0.40584978f, -0.13161397f, 
    -0.12395611f, 0.03289391f, 0.02877778f, 0.08598711f, 0.04350825f, 0.24508630f, 0.26569742f, -0.45694914f, 
    -0.00812616f, 0.04462014f, 0.00907862f, 0.01087657f, -0.02801407f, 0.17026661f, -0.03184398f, -0.17422244f, 
    -0.17326894f, 0.28888750f, -0.15049431f, -0.12937531f, -0.02095239f, 0.08067872f, 0.14914088f, -0.00239740f, 
    -0.02837154f, 0.08728065f, 0.30614489f, 0.21310532f, -0.74426645f, 0.27478895f, -0.41673246f, -0.28822672f, 
    -0.21208660f, -0.00151432f, 0.22792426f, 0.04956718f, -0.06139293f, 0.10342710f, 0.07142623f, 0.05966687f, 
    -0.22037785f, -0.40173045f, 0.17345516f, 0.27199775f, -0.18518087f, -0.19996390f, 0.11202251f, 0.03475766f, 
    -0.15537812f, -0.06730769f, 0.00779052f, 0.19227733f, 0.00340087f, 0.40249494f, 0.04564174f, -0.22875933f, 
    0.03376516f, -0.32737604f, 0.06777161f, 0.06882182f, -0.17202151f, 0.16282055f, 0.00713892f, 0.08938220f, 
    -0.48795015f, 0.23674449f, -0.01114051f, -0.05806922f, 0.04892741f, -0.16611181f, -0.06420640f, -0.01636471f, 
    -0.02666418f, -0.12255361f, -0.01020178f, -0.30402130f, 0.02417102f, 0.36848974f, -0.04015901f, 0.24050194f, 
    0.14116046f, -0.11907697f, -0.04450855f, 0.05897159f, -0.18748179f, -0.06960142f, -0.28101465f, -0.46650544f, 
    0.62612879f, -0.17945713f, 0.30717981f, -0.25209191f, -0.00120367f, -0.15530178f, 0.11970238f, -0.07050566f, 
    -0.05581594f, 0.08463550f, -0.25684598f, -0.24919194f, 0.24673150f, -0.44923949f, 0.03295135f, -0.18378422f, 
    -0.02972900f, 0.16138276f, 0.02043810f, -0.03631720f, -0.28222430f, 0.00407341f, -0.14553383f, -0.24828373f, 
    -0.15796514f, 0.22993636f, -0.15455759f, -0.21405283f, -0.00973609f, 0.00713313f, 0.08890703f, 0.23382409f, 
    -0.13599962f, 0.14195241f, -0.19483921f, -0.42532352f, -0.14335151f, 0.17299576f, -0.02824528f, -0.03446425f, 
    -0.13499101f, -0.25971800f, -0.10548180f, 0.01593764f, -0.17574923f, -0.02799387f, 0.00079850f, -0.08299416f, 
    -0.53659970f, -0.07114170f, -0.63778442f, 0.02476311f, -0.14679974f, 0.04575959f, -0.14839788f, -0.12417995f, 
    0.01037545f, 0.23704568f, 0.13454141f, 0.00588421f, -0.01250927f, 0.14744861f, 0.26529890f, 0.44960108f, 
    0.16505331f, -0.06748863f, 0.13207220f, 0.11938600f, 0.21940400f, 0.11140629f, 0.16622716f, 0.14590794f, 
    -0.38232550f, 0.14791070f, -0.18715820f, 0.08099619f, 0.06692485f, -0.11857318f, 0.07506731f, -0.00912048f, 
    0.05399873f, -0.03213114f, 0.12127477f, -0.07115977f, 0.08851825f, -0.54982680f, 0.39543849f, -0.11685094f, 
    -0.04130120f, -0.03495062f, 0.12230900f, -0.04623428f, -0.14284714f, -0.07532913f, 0.19523707f, -0.08600829f, 
    -0.20902298f, 0.28514862f, 0.01403230f, -0.01738968f, -0.02223781f, 0.05130103f, -0.05628552f, 0.06376354f, 
    -0.07599442f, -0.14308496f, -0.00814383f, -0.10826762f, 0.08203837f, 0.08721179f, -0.14339928f, -0.04673938f, 
    -0.16255018f, -0.12889299f, 0.13808487f, -0.00481206f, 0.03712248f, -0.10956846f, 0.20114128f, 0.07780235f, 
    0.73303723f, -0.06450243f, 0.42610773f, 0.03245186f, 0.16199481f, -0.18308531f, 0.01508401f, 0.05770686f, 
    -0.06765322f, -0.02717848f, -0.03199682f, -0.17877071f, 0.38630575f, 0.17196621f, -0.21298091f, -0.19292712f, 
    0.11555412f, 0.04453558f, -0.17982732f, -0.11588480f, -0.15601192f, -0.01410189f, -0.05018392f, -0.08559743f, 
    0.12375347f, 0.49322334f, -0.38115156f, 0.24474585f, 0.10737705f, 0.04405476f, -0.08189238f, -0.19344711f, 
    -0.05938478f, 0.13718446f, -0.02168687f, 0.08510458f, 0.12917995f, 0.07481514f, 0.64630812f, -0.34460625f, 
    -0.01994902f, 0.06968577f, -0.25101042f, 0.07781609f, -0.24457188f, 0.07277916f, 0.01061897f, -0.10050066f, 
    -0.26311329f, -0.40542704f, 0.10325732f, 0.12222627f, 0.00069172f, 0.08670144f, -0.01620011f, -0.08219951f, 
    0.09121998f, 0.11970276f, 0.09713955f, 0.10788590f, -0.48831680f, 0.22250076f, -0.40444070f, 0.33475426f, 
    0.07286371f, 0.14046349f, -0.01113361f, -0.23965938f, 0.05162742f, -0.05455930f, 0.18353829f, 0.08354239f, 
    0.32075894f, -0.41117290f, 0.36969227f, 0.11810884f, -0.06246327f, 0.06775694f, -0.20264612f, -0.08784750f, 
    0.12579393f, 0.06580549f, -0.07309989f, 0.16242568f, -0.42755193f, 0.20598376f, -0.03282663f, 0.20928133f, 
    -0.07513404f, -0.03943121f, -0.03725032f, -0.04774849f, -0.14968480f, 0.02463616f, 0.02349972f, 0.07519194f, 
    -0.26029995f, -0.53039128f, 0.60513180f, -0.19585398f, -0.44416746f, -0.36842450f, -0.06382339f, -0.21411471f, 
    0.05305337f, -0.01988049f, 0.00569305f, 0.11761743f, 0.03481188f, 0.08659618f, -0.02754528f, 0.11001158f, 
    -0.01121040f, -0.05851420f, 0.12988392f, -0.07159610f, 0.02375359f, 0.08377811f, -0.10223415f, -0.09746835f, 
    -0.31629923f, -0.37787631f, 0.18240702f, 0.56024265f, 0.02876967f, 0.13559346f, -0.00877500f, -0.03335217f, 
    0.02968051f, -0.29117140f, -0.06176306f, -0.02989241f, -0.19734637f, -0.32691291f, 0.02098633f, -0.03608938f, 
    -0.12526581f, -0.01600926f, -0.04767415f, -0.24155368f, 0.06944396f, 0.06652241f, -0.05187442f, -0.08665650f, 
    -0.00839465f, 0.06824871f, -0.04095654f, 0.12918660f, 0.10266524f, 0.00966960f, 0.08850405f, -0.06719874f, 
    0.17557853f, 0.17010096f, 0.15720996f, 0.32277870f, -0.45536521f, -0.22623368f, -0.30350861f, -0.17015645f, 
    -0.06504494f, -0.10265124f, -0.10621690f, -0.05928667f, -0.07114943f, -0.02316323f, 0.03627868f, -0.10441734f, 
    0.28273290f, 0.27844819f, 0.11448821f, -0.16181120f, 0.07916263f, -0.03742855f, 0.02620779f, -0.07003177f, 
    -0.10027140f, 0.19171929f, 0.12687306f, -0.13036689f, -0.48477024f, -0.09516528f, -0.36426315f, 0.03036155f, 
    0.05341397f, 0.09026089f, 0.05004883f, -0.17812769f, 0.05555075f, 0.02324211f, 0.35397997f, 0.07387766f, 
    -0.19517933f, -0.09251556f, 0.17111100f, -0.21281335f, 0.26989841f, 0.00399789f, 0.04050250f, 0.01578151f, 
    -0.07573105f, -0.12207440f, -0.27437210f, -0.38486677f, 0.46118075f, 0.02102572f, 0.24190351f, 0.07850493f, 
    0.16552176f, 0.30527425f, -0.05083400f, 0.04321396f, -0.09116977f, -0.00992174f, -0.00607614f, -0.10852575f, 
    -0.12452826f, -0.11557975f, 0.28505588f, -0.12225434f, -0.09673122f, 0.17460266f, 0.10614787f, 0.00562728f, 
    -0.02755011f, 0.06871147f, 0.06176875f, -0.11408138f, -0.15733582f, 0.07116491f, -0.05146550f, 0.08275155f, 
    0.19536874f, -0.11734857f, -0.05071099f, -0.14847578f, -0.05569428f, -0.04961522f, 0.07833458f, -0.16300572f, 
    -0.61101931f, -0.04929740f, -0.38905036f, 0.26187941f, -0.03290488f, 0.09018286f, -0.13092709f, 0.20771646f, 
    -0.30298957f, -0.02533150f, 0.21909571f, 0.07694009f, -0.51818138f, 0.32528850f, -0.39180258f, 0.04222272f, 
    0.11593608f, -0.11808662f, 0.07787473f, -0.12622477f, -0.14817375f, 0.01956914f, -0.02515727f, 0.24026191f, 
    0.27564523f, -0.09291806f, 0.02785197f, -0.72995728f, 0.10356574f, 0.17388082f, 0.27554929f, -0.10662987f, 
    -0.05596624f, 0.09655704f, 0.03916870f, 0.03156935f, 0.00732913f, 0.01266804f, 0.05223959f, -0.24714106f, 
    -0.34030643f, -0.18294762f, 0.10637889f, -0.16095532f, 0.10470895f, 0.06753808f, -0.11038281f, -0.06435700f, 
    -0.08060446f, -0.15349072f, 0.16895403f, -0.29269207f, 0.01550271f, -0.09184775f, 0.05880035f, -0.06637281f, 
    0.00941592f, 0.16163094f, 0.31206638f, 0.14012463f, 0.04784529f, 0.16241187f, -0.14938334f, 0.01276945f, 
    -0.11783081f, -0.00952559f, -0.07434788f, 0.02737835f, -0.06599354f, 0.12988321f, 0.08205324f, -0.10175798f, 
    0.05498509f, -0.29549015f, -0.17544095f, 0.16499290f, -0.31559083f, -0.14976792f, -0.18671232f, 0.04438779f, 
    -0.02545437f, -0.06048832f, -0.02846077f, -0.06087946f, -0.01180557f, 0.08877634f, 0.31616572f, -0.36732727f, 
    -0.02918296f, 0.01896202f, 0.09566438f, 0.25686067f, -0.07974992f, 0.04789442f, -0.10791977f, -0.29207250f, 
    -0.74942672f, -0.15083267f, -0.28747982f, 0.39691159f, 0.28744939f, 0.09588873f, 0.10420725f, -0.29397833f, 
    0.00455557f, 0.07453170f, 0.12473749f, 0.13730285f, 0.46826437f, 0.02475775f, 0.37983960f, 0.07345045f, 
    -0.18550655f, 0.40824491f, -0.56624609f, 0.15629239f, -0.08068348f, -0.04569542f, 0.07764576f, 0.00569874f, 
    -0.48645192f, -0.24748398f, -0.18808155f, 0.00888444f, -0.02385625f, 0.00122519f, 0.06321311f, -0.10988553f, 
    -0.07129444f, 0.18000932f, 0.00683316f, 0.01224742f, 0.03038479f, -0.26733631f, 0.44385174f, 0.09791566f, 
    0.07224748f, -0.00240020f, 0.12493958f, -0.03954935f, -0.40699515f, -0.05607420f, 0.08251341f, -0.11059798f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18175021f, 0.06232148f, 0.11608099f, -0.11525152f, -0.11349086f, 0.13674085f, 0.02667378f, -0.20425862f, 
    0.12724639f, -0.00139498f, 0.03726929f, -0.03045153f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
