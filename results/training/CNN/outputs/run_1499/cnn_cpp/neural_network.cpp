#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.84298790f, -0.54494709f, -0.30472320f, 0.77186435f, 0.65221089f, -0.08400796f, -0.30447274f, -0.27025375f, 
    0.33247229f, 0.52761209f, -0.03225561f, 0.09262179f, -0.33126596f, 0.17466934f, -0.03215231f, -0.07124756f, 
    -0.08260012f, 0.07276620f, -0.09910084f, -0.59898150f, -0.19636776f, -0.30913118f, -0.59889299f, -0.34181312f, 
    -0.10635170f, -0.08478201f, 0.12160657f, 0.11355223f, -0.03780865f, -0.35519570f, 0.04339531f, -0.09768478f, 
    -0.25080404f, 0.93362558f, -0.33164272f, -0.08589379f, -0.27155992f, -0.34418520f, -0.17717168f, -0.14498757f, 
    0.29024336f, -0.39181617f, -0.28807801f, -0.23198760f, 0.47170147f, -0.08817259f, -0.06649162f, 0.04677599f, 
    -0.20411265f, 0.16624144f, -0.46014389f, -0.31080464f, -0.56403708f, -0.28859702f, -0.08298866f, -0.65882611f, 
    -0.35131040f, -0.42898077f, -0.61492330f, -0.25509509f, 0.26009125f, -0.28674957f, 0.26880026f, -0.20128267f, 
    -0.13053563f, 0.20796202f, 0.21578646f, 0.22957750f, 0.32285604f, 0.19212173f, -0.13608475f, -0.01942389f, 
    -0.03163180f, -0.18693487f, 0.06657374f, 0.13448618f, -0.17560303f, -0.45515287f, 0.08866452f, -0.46629262f, 
    -0.10452405f, -0.12045302f, 0.11866079f, 0.19716796f, 0.31642199f, 0.29493022f, 0.17445616f, -0.02239996f, 
    0.32062256f, 0.23510255f, -0.01471469f, -0.16359539f, -0.15983416f, -0.23650078f, -0.03804790f, 0.06642061f, 
    -0.07793189f, -0.05414533f, 0.13295887f, -0.19039942f, 0.55743212f, -0.18363170f, -0.15744202f, -0.18575767f, 
    0.37160784f, -0.20392706f, 0.27492532f, -0.10225864f, -0.33417749f, -0.48214394f, -0.09263491f, 0.01271087f, 
    0.22338441f, 0.03730752f, -0.03917170f, 0.03385893f, 0.01679472f, 0.03502967f, 0.01968299f, 0.00002402f, 
    -0.22583295f, 0.26073706f, 0.11804473f, -0.12313328f, 0.17334843f, 0.63869441f, 0.08955027f, 0.13602045f, 
    0.30939320f, 0.29959902f, -0.09022370f, -0.11018094f, 0.32950106f, -0.51677328f, -0.42770967f, 0.10098522f, 
    -0.09934442f, -0.04785788f, -0.34561461f, 0.03176905f, -0.03151460f, 0.15175116f, 0.06902414f, -0.16989963f, 
    -0.14443639f, 0.24454907f, -0.30714867f, -0.18234050f, 0.29957831f, -0.19390531f, -0.16030025f, -0.36379758f, 
    0.04986252f, -0.02382544f, 0.20246865f, 0.37964126f, 0.26024958f, 0.00998390f, -0.26339322f, 0.44232893f, 
    0.37844402f, -0.30536836f, -0.10871408f, -0.09418193f, 0.22940373f, 0.11451009f, -0.35099214f, -0.00350082f, 
    0.15137054f, -0.12174066f, 0.24057546f, 0.15538904f, 0.00704373f, -0.07383898f, -0.38367021f, -0.64235824f, 
    -0.42490438f, -0.45031083f, -0.38803366f, -0.46694863f, 0.54925269f, 0.22735517f, 0.19538525f, 0.15919498f, 
    0.48190239f, 0.07500071f, 0.25208583f, -0.14894207f, 0.24821104f, -0.29164550f, -0.17388132f, 0.22563848f, 
    -0.14583720f, -0.09704939f, 0.08962820f, -0.09191164f, -0.03344615f, -0.06392913f, 0.18518145f, -0.19690421f, 
    -0.44475868f, 0.91592598f, 0.97528321f, -0.31058115f, -0.36991996f, -0.62345970f, -0.58977622f, -0.37138548f, 
    -0.40862101f, -0.41025966f, 0.23994096f, -0.20515217f, -0.46844855f, -0.07029302f, -0.50340116f, -0.16453223f, 
    -0.05920591f, 0.11418073f, 0.02009528f, -0.14937305f, 0.04131384f, -0.01093434f, -0.13446213f, -0.26191914f, 
    -0.29901466f, -0.07166528f, -0.12133488f, 0.04606204f, 0.23992524f, -0.04096714f, -0.05316806f, -0.10299360f, 
    0.21389538f, 0.31073514f, -0.51755702f, 0.04850278f, 0.51210994f, 0.19890119f, -0.17054373f, -0.21075538f, 
    -0.18040827f, 0.10574023f, -0.07654954f, -0.53121042f, 0.28327823f, -0.03636554f, 0.45699248f, 0.10174891f, 
    -0.28056067f, 0.04184077f, 0.22589502f, -0.09350884f, -0.33592236f, -0.47957060f, -0.65797412f, -0.50234985f, 
    -0.52677494f, -0.46755412f, -0.59925646f, -0.57212067f, 0.16051561f, -0.41166833f, 0.06649767f, 0.06215241f, 
    -0.06806953f, -0.23990275f, -0.45451477f, 0.00172782f, -0.22215042f, -0.08669093f, -0.01389349f, -0.16686425f, 
    0.04691858f, 0.28863466f, 0.26045936f, -0.85929215f, -0.33068165f, -0.71423864f, -0.63587868f, -0.39472792f, 
    0.51039380f, 0.16236053f, 0.49700388f, 0.56676692f, 0.25181016f, 0.29814607f, 0.17220581f, -0.10410134f, 
    -0.21729206f, 0.02790521f, -0.31398466f, -0.24526475f, 0.09284593f, -0.09249672f, -0.39766839f, -0.18941838f, 
    0.46262705f, 0.18128118f, 0.05716701f, 0.31499487f, 0.57166785f, 0.16719249f, 0.14179407f, 0.20582828f, 
    0.39412734f, -0.46442658f, -0.33114487f, 0.26348615f, 0.19202119f, -0.14007641f, -0.13045910f, 0.24628970f, 
    -0.08104076f, -0.01526118f, -0.04424455f, 0.05542498f, -0.04530806f, -0.19302683f, -0.15705240f, 0.25718123f, 
    -0.18469200f, 0.06011316f, 0.05108218f, 0.03374193f, -0.19580689f, -0.49943626f, -0.51532298f, -0.14526814f, 
    -0.31187728f, 0.01792188f, -0.12701051f, 0.29226810f, 0.09448908f, 0.23163144f, -0.14447565f, -0.02895547f, 
    -0.13756424f, 0.20226388f, -0.15819030f, 0.35972220f, -0.29249275f, -0.12889966f, -0.27090779f, -0.04058121f, 
    -0.28521717f, 0.20036204f, 0.41194963f, 0.41638920f, 0.16046692f, 0.35857671f, 0.48278123f, 0.04233966f, 
    -0.20558938f, -0.51680160f, -0.74685776f, 0.23158546f, 0.22099116f, -0.00955142f, -0.09477427f, -0.26487169f, 
    0.37816256f, 0.14022161f, 0.19405353f, -0.04160343f, -0.04538975f, -0.31439272f, 0.27259842f, -0.07870321f, 
    -0.21758646f, 0.14893888f, -0.13581905f, 0.08106605f, -0.03447537f, -0.06415125f, -0.35592464f, 0.44237447f, 
    0.37584272f, -0.37945595f, 0.25753686f, -0.55655277f, -0.47409150f, -0.01759508f, 0.26168799f, 0.01925165f, 
    -0.02541426f, 0.11034603f, -0.42888582f, -0.51337498f, -0.27947211f, -0.06648678f, -0.01446928f, -0.15936340f, 
    0.08024744f, -0.20434952f, -0.42554164f, -0.39281741f, 0.01807621f, -0.15116152f, -0.05744872f, -0.14034972f, 
    0.50327194f, -0.28856730f, -0.28676131f, -0.54638779f, 0.03093634f, 0.21496902f, -0.05662563f, 0.02851343f, 
    -0.31860277f, 0.23948455f, -0.40412799f, -0.31936949f, -0.21325658f, 0.14347319f, 0.26550019f, -0.15974595f, 
    -0.28657463f, -0.37878799f, -0.31818250f, -0.65780640f, -0.08389594f, -0.50046390f, -0.20969760f, -0.25863156f, 
    -0.36837983f, 0.83122271f, -0.37397751f, -0.22710183f, 0.23980956f, 0.07632843f, -0.14922035f, 0.02608234f, 
    0.04129035f, 0.06849458f, -0.08049141f, 0.34497148f, -0.27426329f, 0.05612911f, -0.09472777f, -0.06910390f, 
    -0.08912653f, -0.08749017f, 0.18975605f, -0.07409687f, -0.33265767f, 0.10537732f, -0.10596114f, 0.02735020f, 
    0.19571905f, -0.17418456f, -0.02377675f, 0.36991248f, 0.00457522f, -0.27521896f, 0.07891672f, -0.43165761f, 
    -0.34243417f, -0.11790855f, 0.07097726f, -0.24957019f, 0.08073476f, -0.33702809f, -0.08455820f, 0.17755619f, 
    -0.06909881f, 0.09083078f, 0.19111580f, 0.03349113f, -0.28998974f, -0.24035752f, -0.01160149f, 0.16514263f, 
    0.02943972f, 0.34719244f, 0.16388294f, 0.58923906f, 0.30047536f, 0.17062801f, -0.07436743f, 0.12490112f, 
    -0.07461302f, 0.01625887f, -0.11934537f, -0.34156746f, -0.29735389f, 0.21881789f, 0.16349860f, -0.14310835f, 
    -0.03191705f, -0.19806844f, -0.07215799f, -0.00590882f, 0.17464396f, -0.04282782f, -0.14979354f, -0.03585798f, 
    0.10979687f, -0.32533342f, -0.19603333f, -0.35116470f, -1.04903138f, -0.73147929f, -0.29818603f, 0.38262203f, 
    0.40971881f, 0.04487078f, -0.14582659f, 0.07761624f, 0.53648472f, 0.51200932f, 0.29763889f, -0.01105268f, 
    -0.20883533f, -0.24372053f, -0.21473096f, -0.03964945f, -0.05697588f, 0.03781223f, 0.28814450f, 0.32058915f, 
    -0.06699266f, 0.09654306f, -0.10796458f, -0.01999911f, -0.13818564f, 0.49278614f, 0.36248964f, 0.32801881f, 
    0.10253207f, 0.00948729f, 0.08064437f, 0.22535460f, 0.11920313f, 0.07195652f, 0.00988277f, 0.14605485f, 
    -0.02923732f, 0.08019052f, 0.28648227f, -0.12760365f, -0.00362074f, -0.02058225f, -0.03964469f, -0.03587511f, 
    0.00485917f, 0.04674283f, 0.05003178f, -0.01956021f, -0.05597304f, 0.08512857f, -0.66280335f, -0.26746368f, 
    0.29710096f, 0.32040533f, 0.53777152f, -0.31824854f, 0.15966496f, 0.27097592f, -0.21590774f, -0.33584720f, 
    -0.06429806f, -0.10884801f, 0.10773630f, -0.04056008f, -0.14281149f, 0.00046001f, -0.24409473f, 0.15804009f, 
    0.11723620f, 0.03036827f, 0.11372630f, -0.27601337f, 0.14686523f, 0.20343801f, 0.03819350f, -0.36389214f, 
    -0.69784564f, -0.50216347f, -0.25068977f, -0.02256997f, -0.45705539f, -0.54128069f, -0.64319199f, -0.66458768f, 
    -0.73001784f, 0.16826205f, -0.04618594f, 0.34296992f, 0.62988389f, -0.04439480f, 0.06971712f, -0.31988180f, 
    0.04949834f, -0.13515988f, 0.02984827f, -0.15616204f, 0.13126343f, 0.24310444f, 0.18006940f, -0.01156582f, 
    -0.75736928f, 0.06979096f, 0.16606708f, 0.15008080f, 0.28977168f, -0.62227356f, -0.43482628f, 0.42404121f, 
    0.14427942f, 0.14854392f, 0.02864733f, -0.00380769f, 0.29352301f, -0.03560468f, -0.32429194f, 0.26655370f, 
    -0.03678909f, -0.09808172f, -0.13678840f, -0.09903993f, 0.17709517f, -0.38757655f, 0.05109400f, 0.29531839f, 
    0.00702683f, 0.12899575f, 0.30977470f, 0.11018171f, -0.37023422f, -0.06369568f, -0.31666172f, 0.01079568f, 
    0.27450338f, 0.27624002f, 0.13476676f, -0.41225865f, -0.26413652f, -0.23020628f, 0.18185087f, 0.15725912f, 
    0.52364206f, -0.06380067f, 0.00239476f, -0.21382974f, -0.00718274f, -0.16552053f, -0.02918521f, -0.06990219f, 
    -0.14304410f, 0.07715532f, -0.91437864f, -0.76945150f, 0.18773817f, 0.62909168f, 0.37125251f, 0.29767022f, 
    0.49142954f, 0.08657990f, -0.05566734f, -0.36273295f, 0.15308230f, -0.29551178f, -0.31342211f, 0.22569747f, 
    0.01107728f, 0.10536860f, -0.07823960f, 0.03013572f, 0.11688602f, -0.05471391f, -0.09046394f, -0.07251678f, 
    0.04536443f, 0.04119880f, 0.11173008f, -1.16611898f, -0.73029327f, -0.62154430f, -0.34275031f, -0.21978079f, 
    0.42309111f, 0.52331257f, -0.54502273f, -0.71324909f, -0.18723744f, -0.23551668f, -0.42247939f, -0.47930306f, 
    -0.51514453f, -0.30131188f, -0.03946251f, 0.06183492f, -0.22230195f, 0.00923601f, 0.05314877f, 0.21552609f, 
    -0.07133319f, -0.12482379f, 0.16587315f, -0.29613993f, -0.06129875f, -0.10366455f, -0.55225730f, -0.22501011f, 
    0.37477916f, 0.38784868f, -0.48998418f, -0.52739114f, -0.64374280f, -0.21125324f, 0.29495284f, -0.04672703f, 
    0.04552889f, 0.03857293f, 0.52379239f, -0.23424992f, 0.31818539f, -0.21695559f, -0.12553731f, -0.32873097f, 
    -0.39486462f, -0.27674064f, 0.31931114f, 0.15548493f, 0.07382996f, -0.85008097f, -0.38868383f, -0.18514957f, 
    0.08696429f, 0.21526143f, -0.05439573f, -0.48742354f, -0.42212474f, 0.01792513f, 0.45410088f, -0.21774948f, 
    -0.32466054f, -0.11963409f, 0.38936415f, 0.27810860f, 0.27819169f, -0.28998241f, 0.10940246f, -0.44131228f, 
    -0.10976230f, 0.10435223f, 0.02477570f, -0.18571296f, -0.21992013f, -0.37703168f, -0.82669663f, -0.72851896f, 
    -0.10895185f, 0.42149842f, 0.39178640f, 0.17513753f, 0.15915543f, 0.14006314f, -0.27704036f, -0.23680949f, 
    -0.16114023f, 0.33282918f, 0.07762673f, 0.47882563f, -0.45775247f, -0.16289434f, 0.09319682f, -0.16253999f, 
    0.34511268f, 0.16865481f, 0.08052313f, -0.26871148f, -0.22452585f, 0.04867008f, 0.18220729f, 0.60963249f, 
    0.23694700f, -0.09153569f, -0.34414732f, -0.03019678f, 0.25275660f, 0.05431876f, -0.10079095f, 0.08506522f, 
    0.20433420f, -0.21839954f, 0.00267969f, 0.21894595f, -0.16826396f, -0.28201345f, -0.17766502f, -0.05844234f, 
    0.31966004f, -0.12618355f, -0.24930014f, 0.06546964f, 0.00815545f, -0.24543525f, 0.00768134f, 0.18924572f, 
    -1.17242992f, 0.40568072f, 0.53021657f, -0.93664277f, -0.55921680f, 0.21088052f, 0.39628318f, 0.15196963f, 
    0.28893360f, 0.28240612f, -0.16669279f, 0.03894027f, -0.27373278f, -0.47591320f, 0.14115316f, 0.05590226f, 
    0.17836431f, -0.13153325f, 0.18368645f, 0.10740682f, 0.07705478f, -0.03581459f, -0.04074082f, -0.31480995f, 
    -0.38905632f, 0.10409954f, -0.08057997f, -0.04667037f, -0.01652532f, -0.17611612f, 0.29595834f, 0.31951118f, 
    -0.21924523f, -0.07208957f, 0.25570077f, 0.09769517f, 0.15870152f, -0.12973684f, -0.11776478f, -0.07813060f, 
    -0.30498147f, -0.12662625f, -0.02335565f, 0.26237589f, 0.07626371f, 0.31002581f, 0.10438789f, 0.04646829f, 
    -0.02586823f, 0.19848630f, -0.64991713f, -0.28600812f, 0.23402534f, 0.69433212f, -0.13369784f, -0.56247151f, 
    -0.19348191f, -0.47806832f, -0.09649806f, 0.51174057f, 0.50473607f, -0.35169959f, -0.07422285f, 0.08405554f, 
    0.37839949f, -0.38746104f, 0.23406163f, -0.14710128f, -0.05430484f, -0.12241908f, 0.09644080f, -0.03712740f, 
    -0.14134945f, 0.26702398f, -0.08312088f, 0.21790685f, 0.11974683f, -0.00763636f, 0.23938122f, -0.09513507f, 
    -0.00665589f, 0.16239256f, 0.01691770f, -0.34551099f, 0.02872290f, -0.12170113f, 0.20083116f, 0.02462109f, 
    -0.15823601f, 0.09623033f, -0.13631660f, 0.25141168f, 0.24878648f, -0.01126307f, -0.00440187f, 0.20780328f, 
    -0.29982856f, -0.14447354f, -0.00902100f, -0.18006951f, -1.11246681f, -0.00955269f, 0.11293849f, -0.94444907f, 
    -0.51208520f, 0.08972766f, -0.14363453f, -0.45717350f, -0.29042265f, 0.14885779f, 0.03638808f, -0.03808428f, 
    -0.18269980f, -0.20617282f, -0.10884923f, -0.20377095f, -0.21566650f, -0.25562206f, -0.26665822f, -0.15919925f, 
    -0.01114284f, 0.07967515f, -0.21326667f, 0.06241453f, -0.13957869f, 0.22469139f, 0.52761954f, 0.21479207f, 
    -0.23863608f, -0.19995265f, -0.49937588f, -0.49862611f, -0.25569072f, 0.42236200f, 0.23485482f, 0.15968579f, 
    -0.19049525f, -0.21755372f, 0.30226651f, -0.18158981f, 0.10357273f, 0.10222451f, 0.02642922f, 0.14117958f, 
    -0.15331498f, 0.17600434f, 0.34630966f, 0.11732902f, -0.21892504f, -0.09622736f, -0.10115577f, -0.04085052f, 
    0.22196840f, 0.21679538f, -0.42043114f, -0.29032525f, -0.65853620f, -0.39976376f, 0.33437371f, 0.20385225f, 
    -0.11456558f, 0.27256078f, 0.21968313f, 0.15579489f, 0.38200581f, -0.13100822f, 0.19535376f, -0.10776200f, 
    -0.02635972f, -0.36889330f, 0.08116746f, -0.16866019f, 0.10875323f, -0.08707249f, -0.09339418f, 0.43500873f, 
    0.64124453f, -0.16845705f, 0.02615659f, -0.36518398f, -0.55806148f, -0.39791659f, 0.18777727f, 0.19714999f, 
    0.09908007f, -0.33768114f, -0.44015953f, 0.02029387f, 0.34610069f, -0.29896143f, 0.32510641f, 0.24544390f, 
    0.33100250f, 0.11597025f, -0.23120727f, -0.09971121f, -0.17761755f, -0.23194797f, -0.13444032f, -0.21892247f, 
    -0.65979671f, 0.19538653f, -0.45231125f, -0.23795637f, -0.04797790f, 0.05592266f, 0.46599910f, -0.31342489f, 
    -0.31093612f, 0.56724715f, 0.19427468f, -0.22021580f, -0.10383540f, -0.08266246f, 0.01473877f, 0.11130241f, 
    0.21895932f, 0.15934573f, -0.02419330f, -0.09922774f, -0.17641522f, -0.22943448f, -0.05824544f, -0.15241882f, 
    0.20899153f, -0.22882035f, -0.07385494f, -0.22567131f, 0.22683434f, 0.35968086f, 0.36357895f, -0.08224178f, 
    0.26594445f, 0.07169955f, -0.18954189f, -0.22402617f, -0.30261892f, -0.26872835f, -0.12802105f, 0.06783365f, 
    0.14823502f, -0.06591518f, -0.00561243f, -0.26694587f, -0.14297605f, 0.01131647f, -0.21303205f, 0.20528349f, 
    0.19295792f, 0.05482111f, -0.09848101f, -0.02197947f, -0.04027564f, -0.31734154f, 0.27233908f, 0.22156502f, 
    0.38665035f, -0.71485758f, -0.23645468f, -0.27873361f, -0.17310601f, 0.35219204f, -0.24253529f, -0.06588940f, 
    -0.05597227f, 0.02558059f, 0.01832439f, -0.06612603f, 0.34522295f, 0.01838270f, 0.04722822f, 0.13468216f, 
    -0.13021471f, 0.12597723f, -0.30671921f, 0.27201471f, 0.56983817f, 0.56958878f, -0.60187155f, -0.90002918f, 
    -0.46813869f, 0.48710668f, 0.13424753f, 0.58436745f, -0.66563708f, -0.37117204f, -0.30474743f, 0.00684181f, 
    -0.18141416f, 0.34984294f, 0.31462348f, 0.07638051f, -0.20690449f, -0.12429202f, 0.15763497f, -0.20235427f, 
    -0.13014559f, -0.12884729f, 0.08105399f, -0.15086783f, -0.23706168f, -0.65539336f, -0.55889326f, -0.64187771f, 
    -0.53103572f, -0.39396119f, -0.10357638f, 0.56738615f, 0.45199394f, -0.08414895f, 0.16383503f, 0.26044267f, 
    -0.00921183f, -0.19137682f, 0.01231452f, -0.09859417f, -0.19691311f, -0.14436479f, -0.29547080f, -0.19884090f, 
    -0.22219294f, -0.20340504f, -0.14837699f, -0.35520905f, -0.42789450f, -0.59682411f, -0.26730284f, 0.05138890f, 
    0.19164914f, 0.51557529f, 0.29079148f, 0.06666141f, -0.26659289f, 0.35357732f, 0.02792030f, -0.15648696f, 
    0.01202267f, -0.14612326f, -0.11267392f, 0.45639122f, -0.13468777f, 0.01624443f, -0.23529208f, -0.19819884f, 
    0.10558425f, 0.31833300f, -0.34360486f, -0.14395039f, 0.38169459f, 0.07945614f, -0.51261240f, 0.04335850f, 
    -0.08143164f, 0.20772301f, -0.02936078f, 0.38493493f, -0.00038826f, 0.06854811f, -0.05398855f, 0.08648830f, 
    0.17604733f, -0.36005387f, 0.30554175f, 0.28734800f, -0.37473273f, -0.27772048f, 0.16832669f, -0.22235411f, 
    -0.28143755f, 0.03829586f, 0.15660042f, -0.01050398f, 0.23166588f, 0.04882470f, 0.24592377f, 0.13736922f, 
    -0.38153860f, 0.10705048f, 0.16096891f, 0.20052741f, 0.20340127f, 0.03253004f, -0.20302446f, -0.05905203f, 
    0.16790599f, 0.02781371f, -0.02604123f, 0.08095499f, -0.25108293f, 0.23931165f, -0.16000077f, -0.25429523f, 
    0.10892893f, 0.01659520f, -0.01144627f, -0.01461575f, -0.10447015f, 0.41868705f, -0.18937905f, -0.12245940f, 
    0.23277810f, -0.34792134f, -0.19930273f, -0.03674122f, -0.44990689f, 0.41854668f, 0.30456233f, 0.07170133f, 
    -0.41126698f, 0.30160651f, 0.27821562f, 0.21539377f, 0.01229520f, -0.11362065f, 0.17094086f, -0.09701768f, 
    -0.33899286f, 0.10766498f, -0.40716708f, -0.17984214f, 0.00270165f, -0.18479908f, 0.30426818f, 0.44441456f, 
    0.42248049f, -0.37692872f, -0.37002960f, -0.09725834f, 0.10442702f, 0.35633370f, 0.14474110f, -0.32599837f, 
    -0.00285112f, -0.49681240f, 0.33370960f, -0.13321443f, -0.21154125f, 0.32117268f, -0.16824718f, -0.19730328f, 
    -0.06888431f, -0.15981515f, -0.38630977f, -0.19827591f, 0.20224498f, -0.14631194f, -0.21116406f, -0.32878804f, 
    -0.06475520f, -0.17040640f, 0.60303760f, 0.26382053f, 0.24744321f, -0.40187892f, -0.44613209f, 0.24979365f, 
    0.31832045f, 0.22222748f, -0.31917062f, -0.35258260f, 0.16683419f, 0.22704948f, -0.30652931f, -0.25486681f, 
    -0.03546982f, 0.16224925f, -0.21680640f, 0.07224235f, 0.06424159f, -0.33809781f, 0.25114244f, 0.04398608f, 
    0.14133948f, -0.14660987f, -0.05037030f, -1.20953536f, 0.16678144f, -0.40041447f, -0.71138829f, -0.71792281f, 
    0.48677507f, 0.28304893f, -0.05510283f, 0.16239370f, 0.66592276f, 0.09004654f, -0.10223864f, 0.12573217f, 
    -0.20093668f, 0.07677665f, -0.02270875f, 0.01058154f, 0.00885668f, 0.11104869f, 0.19973364f, -0.00419191f, 
    0.09768588f, 0.00404463f, -0.09842240f, 0.11762884f, -0.10891598f, 0.06990106f, 0.11919624f, 0.35717773f, 
    0.36709160f, 0.21297053f, 0.53079462f, 0.21453011f, 0.30378392f, 0.10886171f, -0.15753463f, 0.19059272f, 
    0.30594009f, -0.03926999f, -0.16029409f, 0.24254964f, -0.17310064f, -0.21458180f, -0.15386550f, -0.23502445f, 
    -0.05476908f, -0.05662123f, 0.02340036f, 0.03284587f, 0.14250660f, 0.07529452f, 0.15304181f, 0.13500862f, 
    0.31490046f, -0.29950559f, 0.01928098f, -0.33582366f, -0.26222360f, 0.25674477f, -0.13087684f, -0.31095564f, 
    -0.12285078f, 0.36796480f, -0.34958860f, 0.31135929f, 0.08482456f, 0.35794407f, -0.12714978f, -0.12370763f, 
    -0.05301498f, -0.14943290f, -0.15084848f, -0.14686495f, 0.00996935f, 0.12491430f, -0.27668172f, -0.12801287f, 
    0.25899085f, -0.05595725f, 0.34217960f, 0.16306823f, 0.13399641f, -0.32761124f, -0.34176892f, 0.37299359f, 
    -0.07490642f, 0.21777005f, -0.05638590f, -0.14299168f, -0.00331945f, -0.12530446f, -0.26997823f, 0.13056549f, 
    0.06511410f, 0.09779502f, 0.09459707f, -0.07674760f, -0.02429708f, 0.13334973f, -0.21970938f, -0.04253117f, 
    -0.66453373f, 0.16025431f, 0.26628900f, 0.14150707f, 0.59330601f, -0.31475374f, -0.47781757f, 0.25372005f, 
    0.15393117f, 0.36811391f, -0.09043414f, -0.01954004f, 0.11419421f, -0.26390019f, -0.24992380f, 0.10012095f, 
    0.21756223f, -0.29615068f, 0.00440933f, -0.19295932f, 0.05389215f, 0.28524551f, 0.15463115f, -0.07225218f, 
    0.37125245f, 0.59141105f, 0.26644379f, 0.10412577f, -0.00735741f, -0.31468084f, -0.34110695f, -0.15504788f, 
    -0.32986444f, -0.43515652f, -0.01630786f, 0.10068151f, -0.07798171f, -0.05203656f, 0.37042665f, 0.14447030f, 
    -0.02785256f, 0.03485548f, -0.10756703f, 0.04724962f, -0.00551333f, 0.27263159f, 0.03474275f, -0.06096561f, 
    -0.01200810f, 1.21454287f, -0.55965638f, -0.82214516f, -0.23984616f, -0.63359272f, 0.77298462f, 0.64874387f, 
    0.25518823f, -0.24473590f, -0.08801583f, -0.40260145f, 0.34189978f, -0.27583903f, -0.06163917f, 0.18014756f, 
    0.17079058f, -0.08512900f, 0.18218489f, -0.02144278f, -0.16944112f, 0.22397317f, -0.06668777f, -0.14298116f, 
    -0.10946460f, 0.13645834f, 0.13279191f, -0.54183042f, 0.05277029f, 0.41450217f, 0.40450919f, 0.56034654f, 
    0.28154859f, -0.11016262f, -0.37511405f, -0.45601022f, 0.06672593f, -0.15802640f, -0.11224404f, -0.19537109f, 
    0.21632712f, -0.08694395f, -0.09448449f, 0.09766428f, 0.22139440f, 0.16652057f, 0.43494466f, -0.23865092f, 
    -0.22265005f, -0.12889723f, -0.39135960f, 0.19774328f, -0.23348959f, -0.16044033f, 0.47396764f, -0.07097673f, 
    -0.20636153f, -0.05944212f, -0.24213038f, -0.14533804f, 0.28007072f, -0.11572486f, 0.23136476f, -0.34148082f, 
    -0.26494348f, 0.40482184f, 0.12396615f, -0.07241794f, -0.32358652f, 0.20849197f, -0.01492063f, -0.04982785f, 
    -0.08362913f, 0.01105748f, 0.11063100f, 0.09400081f, -0.32957697f, 0.54284930f, 0.10350659f, 0.25292823f, 
    0.15436274f, -0.45809844f, -0.08322652f, 0.10626583f, 0.18683502f, -0.09862820f, -0.08714354f, -0.14394489f, 
    0.25679475f, -0.21277940f, -0.09473193f, -0.13858959f, 0.09950025f, 0.18165356f, 0.14625064f, -0.03875746f, 
    -0.09138639f, -0.15793125f, -0.07198529f, -0.28015894f, -0.12974954f, 0.06235180f, -0.76654863f, -0.51878750f, 
    -0.47022426f, -0.00595671f, 0.15895335f, -0.07851952f, -0.17986664f, 0.03186009f, -0.18943675f, 0.22904247f, 
    0.04630155f, 0.35356340f, -0.10418050f, 0.41053879f, -0.20178075f, 0.02343918f, -0.16431750f, 0.08823683f, 
    -0.13215546f, 0.17913155f, -0.44715562f, -0.15375607f, 0.20940967f, 0.00104715f, -0.13996443f, 0.26052770f, 
    0.15303013f, -0.15823226f, -0.45045614f, -0.05642470f, -0.44066414f, -0.47374499f, -0.44897369f, -0.48716825f, 
    0.01196334f, 0.20962824f, -0.18357754f, -0.24547115f, 0.31959614f, -0.14656739f, 0.00213326f, -0.30577061f, 
    -0.30938172f, -0.53024572f, 0.01357045f, -0.03005660f, 0.14611690f, 0.03651599f, 0.00484274f, -0.13329843f, 
    -0.30344591f, -0.39146885f, 0.59437567f, 0.53345245f, -0.18029243f, -0.43318769f, -0.14676915f, -0.00186821f, 
    0.44264209f, -0.31021297f, -0.04947821f, -0.21530446f, 0.37512982f, -0.00121853f, 0.15038985f, -0.29966059f, 
    0.25595841f, 0.09726699f, -0.51345450f, -0.12602654f, 0.17453839f, 0.09132292f, -0.07836864f, 0.20810941f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01094416f, -0.06674421f, -0.17699713f, -0.02292455f, 0.21578436f, 0.10853009f, 0.05898358f, 0.14463748f, 
    0.02212937f, 0.09046301f, -0.33732998f, 0.27529240f, -0.10253669f, -0.29809681f, 0.20918885f, -0.05117146f, 
    0.22457068f, 0.36277518f, 0.17346379f, 0.05249227f, 0.01136697f, -0.03813638f, 0.16506137f, -0.02501541f, 
    0.24275586f, 0.14975795f, 0.32245204f, -0.44348904f, 0.02303081f, 0.10628191f, 0.16903144f, 0.34826484f, 
    -0.01383252f, -0.13227776f, 0.23368527f, 0.02871326f, 0.02138890f, 0.22435735f, 0.18806785f, -0.04452359f, 
    0.06532522f, 0.05793959f, 0.11703131f, 0.23369579f, -0.26725200f, 0.34360409f, 0.00235037f, 0.18714759f, 
    0.06772572f, 0.11631609f, 0.48924416f, 0.13899404f, 0.05137996f, 0.12244210f, 0.23159651f, 0.27681559f, 
    0.10591794f, 0.25285399f, 0.02883434f, 0.29691768f, -0.04379071f, 0.23376992f, 0.13588756f, 0.24868152f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.08213949f, 0.23248027f, 0.14693530f, -0.08651053f, -0.01542902f, 0.03013166f, 0.08547224f, 0.05748779f, 
    -0.01656417f, 0.08530072f, -0.13117491f, 0.03677352f, -0.21291177f, 0.14701256f, 0.00193501f, -0.31402808f, 
    -0.03360290f, -0.00515181f, 0.01975325f, 0.10664007f, 0.03713749f, 0.00583309f, -0.01293073f, -0.08431192f, 
    0.41980794f, 0.23044537f, 0.05321154f, -0.16655849f, 0.22138017f, 0.15578414f, 0.12882933f, 0.06727861f, 
    0.01548704f, 0.06731173f, 0.04763437f, 0.02942315f, 0.01121237f, -0.00326358f, 0.07214053f, 0.06643925f, 
    0.00567058f, 0.01293650f, -0.00573776f, 0.02822257f, -0.05560214f, 0.04536379f, -0.09674360f, 0.07720377f, 
    0.07902554f, -0.04244728f, -0.01430796f, 0.06383812f, -0.05926509f, -0.11772610f, 0.03056102f, -0.00827607f, 
    -0.03346659f, 0.05720333f, 0.02580707f, -0.04453753f, -0.32517251f, -0.58556288f, -0.10053419f, 0.07651351f, 
    0.04762924f, -0.00882572f, -0.05936867f, -0.02946007f, 0.01297096f, -0.01403087f, 0.04090346f, 0.04469366f, 
    -0.08894224f, 0.03322758f, -0.12460198f, 0.00126479f, -0.03474354f, 0.01988028f, 0.07261601f, 0.02356715f, 
    -0.16316155f, -0.09516790f, -0.13552707f, 0.01443760f, 0.12904371f, -0.09833629f, -0.01458241f, 0.01209443f, 
    0.09562538f, 0.10322573f, 0.00569607f, -0.04674710f, -0.01994288f, 0.12060333f, -0.00217245f, -0.10557334f, 
    0.05732850f, 0.28284192f, -0.11245930f, -0.08350326f, -0.13879138f, 0.08203943f, -0.03657262f, 0.08121133f, 
    0.02702141f, -0.01506393f, 0.03283109f, 0.04011123f, -0.15117963f, 0.04996137f, -0.04212769f, -0.09087774f, 
    -0.11824607f, -0.01719835f, -0.01119066f, -0.03544722f, -0.14653367f, -0.06292373f, 0.19125333f, -0.21787082f, 
    0.29425940f, 0.18720986f, -0.12997849f, -0.22479005f, 0.12095117f, 0.08511516f, -0.00223114f, -0.00321179f, 
    -0.00879281f, -0.00644511f, 0.00517569f, -0.01909548f, 0.07714036f, -0.05489142f, -0.05601439f, -0.05255739f, 
    0.10098147f, 0.16875772f, 0.04786716f, -0.18429331f, -0.01168707f, -0.07841595f, -0.10764232f, 0.05587380f, 
    -0.19053629f, -0.16203679f, -0.09742657f, 0.07243726f, 0.04519580f, 0.01222229f, 0.00835599f, -0.00870347f, 
    -0.03417708f, 0.03879713f, 0.03001905f, 0.03741309f, 0.08607760f, 0.08043279f, -0.00064141f, -0.07365796f, 
    0.13964573f, 0.07102592f, 0.07185449f, -0.19958813f, -0.04500511f, -0.10030545f, -0.10977311f, -0.00085155f, 
    0.12580658f, -0.16056558f, -0.29188696f, 0.04113995f, 0.07427503f, 0.00037828f, -0.12831274f, -0.04655882f, 
    -0.14027856f, -0.01478984f, -0.04755261f, -0.07417010f, -0.04158529f, -0.00525579f, 0.11667534f, 0.09478955f, 
    -0.04037128f, 0.02516153f, -0.00159737f, 0.02455223f, -0.05064436f, -0.04786107f, 0.00558961f, 0.24776164f, 
    0.09434722f, 0.04556740f, -0.09387336f, 0.00663382f, -0.00699516f, -0.02855299f, -0.10065716f, -0.17634578f, 
    -0.02742568f, -0.05950778f, 0.05479034f, 0.00880059f, -0.30152160f, -0.46862257f, -0.26616696f, -0.05451471f, 
    -0.00836905f, 0.04403942f, -0.01484275f, -0.03383489f, -0.00767744f, -0.03239456f, -0.05274696f, 0.04117993f, 
    0.14697567f, 0.12002504f, 0.05958939f, -0.11184937f, -0.00389507f, 0.09499020f, -0.08984804f, -0.09929954f, 
    -0.00420318f, -0.01849064f, -0.03987968f, -0.00632305f, -0.11715810f, -0.16250546f, -0.40726119f, 0.01314534f, 
    0.05420529f, 0.04344787f, -0.04540332f, -0.00543171f, -0.02090773f, 0.02956951f, 0.01921776f, 0.06800412f, 
    0.38301373f, 0.35616705f, 0.12896095f, -0.12530699f, 0.05490588f, 0.02939795f, 0.12214799f, -0.20480582f, 
    0.09126922f, -0.03531472f, -0.04887799f, -0.07326205f, -0.04172503f, -0.01086740f, -0.00534702f, 0.07065503f, 
    0.05192111f, 0.04360693f, 0.04455448f, -0.01167572f, -0.02737439f, 0.03917355f, -0.02173178f, -0.00624772f, 
    0.18405114f, -0.00951095f, 0.18029782f, -0.11743920f, -0.15367731f, -0.10825229f, 0.05379928f, 0.03912470f, 
    -0.09637576f, -0.00186859f, 0.02373911f, 0.01871878f, 0.32238591f, 0.22284155f, -0.12399953f, -0.23820771f, 
    0.00142999f, 0.00050379f, 0.09902092f, 0.04956179f, -0.01612698f, -0.01434991f, -0.05095869f, -0.02134238f, 
    -0.29422590f, 0.22483568f, 0.35058498f, -0.23735280f, -0.08305842f, -0.00322380f, 0.06807283f, 0.10285412f, 
    -0.03627900f, -0.10116004f, -0.08580005f, 0.06937751f, -0.72346252f, 0.04538110f, 0.14594489f, 0.02445284f, 
    -0.02002299f, 0.02696283f, -0.05336648f, 0.05415153f, -0.00666830f, 0.01006131f, 0.03198825f, -0.25191119f, 
    0.43458253f, -0.30677953f, -0.04961786f, -0.45704553f, -0.14962028f, -0.12144405f, 0.03935376f, 0.00536396f, 
    -0.05822849f, -0.06045687f, -0.19392291f, 0.13017204f, 0.44530573f, 0.25212264f, -0.17020628f, -0.13519342f, 
    0.19779344f, 0.14372206f, 0.21245185f, 0.10724176f, -0.00838367f, -0.00956091f, -0.04601587f, -0.05363474f, 
    0.29397446f, 0.08251051f, -0.29619449f, -0.08890690f, -0.02975894f, 0.09259807f, -0.23143023f, -0.11868881f, 
    -0.15669267f, -0.06375085f, -0.04604557f, -0.07997531f, 0.23881659f, 0.22839011f, 0.04498381f, -0.15014371f, 
    -0.00165643f, 0.08076258f, -0.03672054f, 0.00881075f, -0.10899711f, -0.00255299f, 0.00621237f, -0.04111198f, 
    0.36511707f, 0.13461399f, -0.05304549f, -0.05147735f, -0.04699804f, -0.09030738f, 0.06662960f, -0.01941191f, 
    -0.06211923f, -0.27709833f, -0.07784286f, -0.08061057f, -0.44354773f, -0.56517923f, -0.64891356f, 0.11164560f, 
    0.04068141f, -0.00766375f, -0.01108841f, 0.04163196f, -0.03991820f, -0.06459215f, 0.01873202f, -0.03406927f, 
    -0.34130600f, 0.05285425f, 0.05446917f, -0.00219461f, 0.00785204f, 0.24631324f, 0.08459375f, 0.05907918f, 
    0.06147543f, 0.10898805f, -0.02500814f, -0.02458597f, -0.03334058f, -0.01505594f, -0.00567934f, 0.00898447f, 
    -0.00348928f, -0.03750912f, 0.05189180f, 0.02472793f, -0.00251964f, -0.00932944f, -0.07521065f, -0.06587738f, 
    -0.12226743f, 0.11418801f, 0.29474482f, -0.66781455f, -0.05055494f, -0.08036974f, -0.03677979f, 0.07092208f, 
    -0.09785238f, 0.04225823f, -0.14032604f, -0.09294663f, 0.01142289f, 0.05264129f, 0.05717406f, 0.03459292f, 
    0.03537358f, 0.04283965f, -0.06195165f, 0.01192071f, -0.06938147f, -0.07356733f, -0.01941134f, -0.05481886f, 
    0.19359608f, 0.22449176f, 0.00595197f, -0.12171952f, 0.02704388f, 0.21653950f, -0.01564308f, 0.08897692f, 
    -0.10948239f, -0.14071168f, -0.16884717f, -0.11076919f, -0.04405376f, 0.00525414f, 0.07253621f, -0.02650346f, 
    -0.26254532f, 0.01422798f, -0.07507782f, -0.15612747f, -0.01011794f, -0.08098192f, -0.04949838f, -0.04803015f, 
    0.15636669f, 0.10292736f, 0.14009644f, -0.20422053f, -0.08843063f, -0.04037064f, -0.01715090f, 0.02818534f, 
    0.04872196f, -0.20212011f, -0.09703720f, 0.02189909f, -0.19661607f, 0.13063532f, 0.20211847f, 0.00779805f, 
    0.02984396f, 0.06003760f, -0.09751514f, -0.07897432f, 0.04576495f, 0.05470436f, -0.05417564f, 0.07130905f, 
    0.03488344f, 0.13353749f, 0.00387000f, 0.04725771f, 0.03937890f, 0.06387209f, -0.00802452f, 0.00427002f, 
    0.01043097f, 0.02730898f, 0.01819579f, -0.03777463f, 0.16437122f, -0.02582727f, 0.16746202f, -0.02119367f, 
    -0.08245147f, 0.02316962f, 0.01953322f, -0.00715874f, -0.00970621f, 0.02936184f, 0.10971522f, 0.00732015f, 
    0.13429435f, 0.14811268f, -0.13169046f, 0.01385654f, -0.07938378f, 0.02572909f, 0.08293138f, -0.06200834f, 
    -0.00296201f, -0.01885129f, 0.04207545f, -0.05765630f, -0.41296744f, -0.53521538f, 0.31135157f, -0.03303614f, 
    -0.05214420f, 0.06844658f, -0.24591671f, -0.05457298f, -0.17894508f, -0.10995859f, 0.13363270f, -0.03073361f, 
    0.19630416f, 0.04559023f, -0.07433132f, -0.06606120f, 0.09679322f, 0.09030560f, -0.00459579f, -0.09829371f, 
    -0.04963820f, -0.03935120f, 0.02107464f, 0.12103380f, -0.07666865f, 0.07593840f, 0.03559190f, -0.26072916f, 
    -0.05120384f, -0.01039014f, 0.08587335f, 0.00605529f, -0.22248265f, -0.08155583f, -0.03999474f, -0.30907321f, 
    -0.02879679f, -0.10042903f, 0.04972433f, -0.13650446f, -0.00832035f, 0.05501639f, -0.03106706f, 0.03151977f, 
    -0.00453194f, 0.02121721f, -0.20268707f, -0.26833960f, -0.22983488f, -0.02436660f, -0.03492742f, 0.03419254f, 
    -0.02802820f, 0.00733387f, -0.00194385f, 0.00917746f, 0.01059970f, -0.07747171f, 0.04933747f, -0.02951274f, 
    0.10007223f, -0.12259469f, -0.16191097f, 0.08858746f, 0.09439319f, 0.05220590f, -0.02491969f, -0.12096434f, 
    -0.09914498f, -0.18383937f, -0.38058874f, -0.03840693f, 0.28338632f, 0.17477843f, -0.00659512f, -0.01660901f, 
    -0.09018213f, -0.07434794f, 0.01172739f, -0.12758581f, -0.06667717f, -0.18585095f, 0.04001803f, -0.06617703f, 
    -0.05951727f, -0.71781111f, -0.35720348f, 0.07491648f, -0.04337470f, 0.09713715f, -0.03239475f, -0.08902108f, 
    -0.06294332f, -0.06499908f, 0.00196050f, -0.00913283f, 0.05646627f, 0.01283313f, 0.00938743f, -0.06301580f, 
    0.06364854f, 0.20021769f, 0.00041884f, 0.03744546f, 0.03725640f, -0.03099204f, 0.02158061f, -0.04493015f, 
    -0.24216668f, -0.24696487f, -0.13264000f, -0.00430035f, 0.00092478f, 0.03317227f, 0.03203267f, 0.00565379f, 
    -0.05796127f, -0.01625444f, -0.06550748f, -0.10052839f, -0.13911387f, 0.07163607f, 0.01760070f, -0.16909207f, 
    -0.20665604f, 0.04949105f, -0.11578199f, 0.04646134f, 0.01529205f, -0.11343204f, -0.07206207f, 0.05066195f, 
    0.03007219f, 0.05673799f, -0.02730079f, -0.01904238f, -0.03642876f, -0.00677091f, -0.00266644f, 0.02635710f, 
    -0.03587612f, -0.06885386f, 0.06711132f, -0.12742072f, 0.03413084f, 0.12000374f, -0.01192375f, -0.06656043f, 
    -0.02802084f, 0.06860515f, -0.07872310f, -0.06554376f, 0.07345297f, 0.02421789f, -0.11287208f, -0.07908798f, 
    0.00630050f, -0.03495069f, -0.02819575f, -0.05904994f, -0.10850056f, -0.04790060f, -0.01422967f, -0.08625165f, 
    0.01560347f, 0.01622942f, 0.03472658f, -0.01512316f, -0.03704676f, -0.22562586f, -0.30251229f, 0.01299507f, 
    0.02720018f, -0.02149768f, -0.07500684f, -0.19298531f, -0.06386548f, -0.01410392f, -0.05274307f, -0.13838075f, 
    0.06955423f, -0.21426706f, -0.08963697f, -0.00363316f, -0.06021919f, -0.10214183f, 0.10005642f, -0.01217147f, 
    -0.13665499f, -0.09091296f, 0.03164449f, 0.11929406f, -0.10125962f, 0.17649443f, 0.05745497f, -0.19664890f, 
    -0.05249292f, -0.00215092f, -0.09012053f, -0.14698067f, -0.08472906f, 0.01435548f, 0.00482938f, -0.06877342f, 
    -0.34058973f, -0.14166394f, 0.21055786f, 0.01466349f, 0.01861180f, -0.03810807f, 0.01265271f, 0.03388933f, 
    -0.01792144f, 0.02216097f, 0.02196720f, 0.04908690f, 0.18494135f, 0.11867796f, -0.28512722f, -0.11717599f, 
    0.05801418f, 0.04336794f, -0.07856508f, -0.11068717f, -0.03990871f, -0.15318486f, -0.02759871f, -0.00143199f, 
    0.19825774f, 0.07744449f, -0.20389640f, -0.18027380f, 0.00170523f, 0.04144774f, -0.13177858f, -0.02072122f, 
    -0.02712008f, -0.02104473f, -0.07646535f, -0.07470495f, -0.25696850f, 0.34283140f, 0.06412145f, -0.44326583f, 
    -0.17891851f, -0.05753145f, 0.13223028f, -0.05186420f, -0.00758943f, -0.11716748f, -0.07860744f, -0.07503268f, 
    -0.11883244f, 0.16133930f, -0.18268622f, -0.05273258f, 0.00532971f, 0.02887502f, 0.03930432f, -0.02290972f, 
    -0.15932937f, -0.48591322f, -0.45925564f, -0.19092363f, -0.37496531f, 0.27400085f, -0.19303052f, -0.21382871f, 
    -0.02516874f, -0.03244807f, 0.04565492f, -0.06442952f, 0.03572810f, -0.02460163f, -0.05579063f, -0.06437273f, 
    0.05624049f, 0.10890818f, 0.04782909f, 0.03079794f, -0.22844543f, -0.10761675f, 0.02048786f, -0.29469505f, 
    -0.03864701f, -0.01876920f, -0.05994479f, 0.01472352f, -0.18272161f, -0.08575004f, -0.02492003f, -0.12154928f, 
    -0.02856290f, 0.02537483f, -0.03305864f, -0.01383820f, 0.16590244f, -0.13992092f, 0.06444062f, 0.02451691f, 
    0.12512580f, -0.01271567f, -0.01109448f, 0.00212064f, -0.18096809f, 0.01504941f, 0.06061507f, -0.05661185f, 
    -0.08037701f, -0.00356570f, 0.02647164f, 0.02396108f, 0.25586277f, 0.24241588f, 0.18304497f, 0.03400468f, 
    -0.05568289f, -0.04547441f, 0.06171156f, -0.10247986f, 0.02250433f, -0.01178158f, -0.01693052f, 0.06745374f, 
    0.14392823f, 0.07205033f, -0.14225455f, 0.08587004f, -0.08109421f, -0.01549064f, -0.03830041f, 0.08714431f, 
    -0.15706421f, -0.14410560f, 0.03693573f, 0.03033422f, 0.38646498f, -0.10924059f, -0.23948658f, -0.17893013f, 
    -0.06789944f, 0.00776335f, 0.05369834f, -0.07324670f, -0.02561179f, -0.10957228f, -0.02522094f, -0.09778523f, 
    -0.11149555f, -0.30795413f, -0.14962600f, -0.58790725f, 0.03750160f, -0.11918116f, -0.16519709f, 0.14914672f, 
    -0.01723618f, -0.04367673f, -0.00865133f, 0.00245838f, 0.00369751f, 0.05863424f, -0.12691961f, -0.07411361f, 
    0.11793993f, -0.16508891f, 0.00248836f, -0.00805767f, -0.06994728f, 0.04760830f, -0.25780338f, 0.09336366f, 
    0.13604318f, 0.06007889f, 0.21799307f, -0.09852109f, -0.08002801f, -0.10819376f, -0.01481858f, 0.01684010f, 
    -0.02694044f, -0.01619524f, -0.01341820f, 0.07799376f, -0.29676676f, 0.23034771f, -0.33401313f, -0.30361462f, 
    0.02585934f, 0.01822327f, -0.00644337f, 0.01600187f, -0.07878300f, 0.14822829f, -0.09356212f, -0.09696057f, 
    0.09440011f, 0.15394722f, 0.16445893f, 0.02893913f, 0.03267034f, -0.08073164f, -0.02385660f, -0.04152832f, 
    -0.02851167f, 0.06247777f, -0.05610083f, -0.00060801f, -0.21401502f, 0.24009901f, 0.19258015f, 0.05631933f, 
    0.06245717f, 0.09812319f, 0.08003023f, 0.11176294f, -0.09202660f, -0.00099161f, -0.00117237f, -0.07242984f, 
    0.08883391f, -0.23342757f, -0.07010037f, -0.12798773f, -0.02543451f, 0.02638844f, -0.00822681f, 0.01119362f, 
    0.08520989f, 0.04783739f, 0.02192073f, 0.02286508f, -0.02586658f, 0.16461949f, 0.31511965f, -0.31678566f, 
    0.00892558f, 0.00629518f, 0.01076312f, -0.09845937f, -0.03799837f, 0.08006128f, -0.35114208f, 0.15044266f, 
    0.32175708f, -0.00524452f, 0.08865874f, 0.05241920f, 0.04885027f, 0.04760534f, 0.00205803f, -0.07052330f, 
    -0.03629804f, -0.18060412f, -0.21944471f, -0.61389560f, 0.20635039f, 0.49182951f, 0.34251866f, 0.11532619f, 
    -0.02061853f, -0.03407084f, -0.02890805f, -0.01476610f, -0.04591997f, -0.02359025f, 0.03092412f, 0.06339957f, 
    -0.01511410f, 0.09344335f, 0.07364608f, 0.00379847f, -0.06465740f, -0.05661964f, 0.14565456f, 0.02411436f, 
    -0.02916730f, 0.04051590f, -0.02436413f, -0.02140892f, 0.09973459f, 0.06808888f, 0.00797979f, -0.08029343f, 
    -0.00900514f, -0.06510642f, -0.03289137f, 0.08023508f, -0.04315487f, 0.00315850f, -0.01963397f, 0.11073687f, 
    -0.09577382f, 0.09505174f, -0.18774374f, -0.01558462f, -0.11841446f, 0.02794975f, 0.03681749f, -0.08271503f, 
    -0.01567838f, -0.09103633f, -0.17764799f, 0.12625936f, 0.10668460f, 0.12192468f, 0.08314986f, 0.14898889f, 
    -0.08605839f, -0.02940276f, 0.00296777f, -0.02886549f, 0.02118324f, 0.01804421f, 0.03364944f, 0.02684464f, 
    -0.22328338f, -0.06470998f, -0.00813315f, 0.04613272f, 0.13892394f, 0.00332287f, 0.09289868f, -0.09944170f, 
    0.03466287f, 0.03467135f, 0.01252573f, -0.01302443f, -0.11030830f, 0.00570667f, 0.17105204f, 0.24254504f, 
    -0.07217940f, -0.02458164f, 0.12743200f, -0.03473884f, -0.02869249f, -0.04459133f, 0.06025806f, 0.05470058f, 
    -0.72220051f, -0.09355680f, 0.00551637f, 0.04446900f, 0.03599797f, 0.00760387f, 0.06356189f, -0.04778003f, 
    0.04955781f, 0.06601780f, 0.04234706f, 0.08366701f, 0.03369839f, 0.03183576f, 0.11801942f, 0.02538654f, 
    0.05911838f, -0.02336053f, -0.00333099f, 0.02039359f, 0.02447410f, 0.16227004f, -0.05969048f, 0.02200835f, 
    -0.01653598f, -0.27759871f, 0.09058232f, 0.03454677f, 0.02313991f, -0.04449786f, 0.06576843f, 0.05178115f, 
    0.24332739f, 0.06545263f, 0.09679733f, -0.06625435f, 0.48092416f, 0.12306260f, 0.41160986f, -0.03920086f, 
    0.04761156f, -0.12490610f, -0.07788432f, -0.07964010f, 0.01092927f, -0.05117556f, -0.03437556f, 0.01930101f, 
    0.05244798f, -0.11699319f, 0.01968883f, -0.01195028f, 0.14667009f, -0.10274148f, 0.17367262f, 0.02121551f, 
    0.10427748f, 0.07806798f, 0.02240628f, -0.02234893f, -0.26731667f, -0.00504033f, -0.03267901f, 0.12207070f, 
    0.17724916f, -0.02643582f, -0.02723076f, 0.12671193f, -0.02625109f, 0.02025707f, 0.11953750f, -0.09617802f, 
    -0.13326681f, -0.12401161f, -0.05822626f, 0.05402024f, 0.01272122f, 0.02720308f, 0.18097359f, -0.14822996f, 
    0.19018432f, -0.22377928f, 0.02202412f, 0.11260130f, 0.42107928f, 0.08335182f, 0.25751567f, 0.06113673f, 
    -0.05280559f, 0.03302646f, -0.01530890f, -0.05259591f, -0.00280205f, 0.10877270f, 0.09696561f, 0.05992429f, 
    -0.07744173f, 0.12138546f, 0.05851839f, -0.18234296f, 0.01426194f, 0.01479093f, -0.30381855f, -0.09020288f, 
    -0.09319790f, -0.01753551f, -0.07583679f, -0.19525516f, 0.08553078f, 0.01693304f, -0.03155778f, 0.00643006f, 
    0.00137996f, 0.07486884f, 0.00531318f, 0.02013027f, -0.03446923f, 0.04546690f, -0.02021381f, -0.00208508f, 
    -0.59263325f, 0.26188034f, -0.08817211f, -0.49123642f, -0.12085783f, -0.02253702f, -0.00268756f, 0.07939145f, 
    0.03571112f, -0.04547830f, 0.15263541f, -0.03798695f, 0.06216583f, 0.00199797f, 0.00908161f, -0.00676148f, 
    0.00999422f, 0.01725928f, 0.00791941f, -0.01169059f, 0.23820387f, -0.18696691f, -0.00630100f, 0.01140245f, 
    0.13263209f, -0.01658437f, 0.09216046f, 0.26446187f, 0.10657553f, 0.10860553f, -0.15441349f, 0.15251893f, 
    -0.03989392f, -0.00597216f, -0.01289622f, 0.00581634f, -0.04215497f, -0.06136151f, 0.17910345f, -0.06549771f, 
    0.11994690f, 0.00922342f, -0.06285179f, 0.11005208f, -0.08077200f, -0.03339977f, 0.01618521f, -0.01801941f, 
    -0.44865385f, -0.02944853f, 0.06608833f, -0.26939058f, 0.00717231f, 0.11715567f, 0.01311527f, 0.03849433f, 
    -0.00558233f, 0.04553026f, 0.08011479f, -0.01596284f, -0.05682090f, -0.08069386f, 0.04576105f, -0.02924624f, 
    0.13774015f, -0.01171745f, -0.06901156f, -0.16649358f, 0.04301657f, -0.03016928f, -0.05280737f, 0.05331987f, 
    0.10579387f, -0.13091592f, -0.06828503f, 0.01678514f, 0.14206444f, -0.00253264f, -0.19322532f, -0.34914023f, 
    0.18179309f, -0.04700216f, -0.11786630f, -0.08298749f, -0.09591834f, -0.13678695f, 0.25993472f, 0.19560361f, 
    -0.04769640f, 0.03503032f, 0.00810761f, -0.01509295f, 0.06678823f, 0.06893560f, -0.03324899f, -0.05242509f, 
    0.11905669f, -0.18578957f, -0.18999228f, -0.02246330f, 0.01519566f, -0.07209741f, -0.02394349f, 0.17401493f, 
    -0.01647560f, -0.04360472f, -0.01350020f, 0.10329968f, 0.14668280f, -0.22994605f, 0.13837527f, -0.04242223f, 
    0.02362162f, -0.00168095f, 0.18242280f, -0.18939500f, 0.01863225f, 0.13687754f, -0.19962348f, -0.09374113f, 
    -0.28591719f, -0.04074837f, -0.01709186f, -0.03033329f, -0.04148570f, 0.14784779f, -0.03176090f, -0.01861789f, 
    -0.02299473f, -0.03975735f, -0.00514251f, 0.01803936f, -0.16041899f, -0.08056848f, 0.00862871f, 0.30359364f, 
    0.01076471f, 0.04515987f, 0.05812380f, 0.00644885f, 0.21723101f, 0.03739928f, 0.05114339f, -0.02340803f, 
    -0.22814654f, 0.06597031f, 0.02005651f, -0.00905273f, -0.03974893f, -0.02940571f, 0.17890893f, -0.00422119f, 
    -0.02721751f, -0.10882133f, 0.12247913f, -0.04435971f, 0.13078736f, 0.04925477f, 0.05060541f, 0.05363914f, 
    -0.02034649f, -0.02612735f, -0.00162302f, 0.01953833f, -0.03486933f, 0.06830250f, 0.04303988f, -0.19150597f, 
    0.13609739f, -0.02263705f, 0.00415521f, -0.10451473f, -0.07859030f, 0.03085617f, 0.01828518f, 0.08186646f, 
    0.10388158f, 0.06713005f, -0.08490541f, 0.00257162f, 0.11086211f, -0.02089337f, -0.32038176f, 0.14762244f, 
    0.01099997f, 0.08166612f, 0.05672318f, -0.03593371f, -0.07935634f, -0.04431070f, -0.16980439f, -0.28422353f, 
    0.45308656f, -0.11540627f, 0.19298807f, 0.05802263f, -0.12360419f, -0.01476762f, -0.00397995f, 0.05090004f, 
    -0.08057529f, -0.03733210f, -0.07413466f, 0.02524468f, 0.00626644f, 0.20338146f, -0.00380953f, -0.09415589f, 
    -0.00989881f, 0.13217853f, -0.15824424f, -0.21794192f, -0.06722027f, 0.05287299f, -0.02774006f, -0.07173400f, 
    0.16855039f, 0.07085483f, 0.17981032f, 0.17882933f, -0.06540066f, 0.02305128f, 0.00450783f, -0.06225004f, 
    0.02104541f, 0.07965491f, 0.07348361f, 0.11957525f, 0.00582939f, 0.06559258f, -0.04509017f, -0.12705378f, 
    0.11407103f, 0.02240895f, -0.03444615f, -0.13742945f, 0.01085193f, 0.06825343f, -0.02962906f, -0.04308433f, 
    0.11069190f, 0.06299450f, 0.04840638f, 0.06386304f, -0.03067592f, -0.04081884f, -0.01977006f, 0.02026251f, 
    0.01974292f, -0.02733668f, 0.05911799f, -0.05603672f, 0.05359029f, 0.08869307f, -0.17035873f, 0.02059101f, 
    -0.04430601f, -0.13706015f, 0.07090892f, 0.12934344f, -0.08736129f, 0.15134072f, 0.00003006f, -0.06079407f, 
    0.11249115f, -0.08040930f, -0.08775759f, -0.04889331f, -0.12365762f, -0.08915400f, -0.03788116f, -0.02955119f, 
    -0.05000043f, 0.03511877f, -0.01109363f, 0.00902021f, 1.06504953f, -0.23066677f, -0.23376340f, -0.01849023f, 
    -0.05188318f, 0.05089998f, -0.10252678f, -0.11840013f, 0.01977531f, -0.07200297f, -0.05373723f, 0.03673371f, 
    0.15564734f, -0.01359326f, -0.02704619f, 0.04037230f, 0.01898329f, -0.08596883f, -0.03351273f, 0.01605790f, 
    0.15566969f, 0.02405808f, 0.07154275f, -0.11710180f, 0.12596466f, 0.06692000f, -0.08534497f, -0.06742113f, 
    -0.11596216f, 0.02255783f, -0.09683696f, -0.01061446f, -0.03629496f, 0.03482912f, 0.06096768f, -0.03271949f, 
    -0.10435384f, 0.07888430f, 0.02643286f, -0.04505316f, -0.00140358f, 0.01752846f, -0.04182037f, -0.02312330f, 
    -0.02165800f, -0.08046063f, 0.01246037f, 0.01691536f, -0.08816514f, -0.15644361f, 0.06551503f, 0.12640217f, 
    0.02623762f, 0.17438951f, 0.06346817f, -0.18092684f, 0.16818799f, 0.05343557f, 0.05264398f, 0.03538750f, 
    -0.17757525f, -0.27672741f, 0.05373301f, -0.13788086f, -0.04827302f, -0.06388211f, 0.09108537f, 0.19838423f, 
    -0.05340805f, -0.01443519f, -0.01097212f, 0.06880501f, -0.19550809f, 0.10331494f, -0.11253747f, 0.10012682f, 
    -0.01688933f, 0.02564962f, 0.04621181f, -0.04178508f, -0.08106054f, 0.11208308f, -0.03365476f, -0.00639763f, 
    -0.13477942f, -0.10436057f, -0.08877899f, 0.09899452f, -0.04200560f, -0.00794551f, -0.01531722f, 0.07171549f, 
    0.08656205f, -0.00435024f, 0.03015525f, 0.01203090f, -0.31434733f, -0.07324845f, -0.20417689f, -0.07039187f, 
    -0.02134892f, -0.02695133f, -0.03109478f, 0.04911257f, -0.07553863f, 0.00543027f, -0.10576717f, -0.01554026f, 
    -0.65858006f, -0.55397326f, -0.24250583f, -0.24745791f, 0.03240311f, 0.01899578f, 0.04739270f, -0.09601605f, 
    -0.00403639f, -0.01443731f, 0.02012299f, -0.05794885f, -0.14399737f, 0.09226926f, 0.02467281f, 0.10000469f, 
    -0.07447549f, -0.03115185f, 0.02856990f, -0.08233751f, -0.02983200f, 0.07946318f, -0.04197241f, 0.16681808f, 
    -0.01568979f, -0.02959766f, -0.02249150f, 0.03019551f, -0.20995767f, -0.01024407f, -0.05270078f, 0.00227262f, 
    0.04231459f, 0.02096747f, 0.00502015f, -0.00693719f, -0.23270164f, 0.04862238f, -0.06942784f, 0.20242801f, 
    -0.04991784f, -0.11927181f, 0.10565444f, 0.01401446f, 0.02510520f, 0.00437891f, -0.04653409f, 0.06867464f, 
    -0.02874043f, -0.16067562f, 0.12383019f, 0.06832272f, -0.00851698f, -0.00873357f, -0.00296397f, 0.06965611f, 
    0.05491654f, -0.01139274f, 0.15271665f, 0.03973841f, 0.01579231f, 0.27789164f, 0.28084317f, 0.18934245f, 
    -0.04681464f, -0.00799283f, 0.09916785f, 0.01178061f, 0.10140137f, -0.11924689f, -0.03264042f, 0.13462175f, 
    0.03687073f, -0.03493584f, 0.41599098f, -0.49066022f, 0.00816219f, -0.06803883f, -0.27460229f, -0.03715448f, 
    0.00911779f, -0.03549820f, 0.02510612f, -0.03171480f, 0.06506475f, 0.00133740f, -0.33185634f, -0.06396504f, 
    0.04826996f, -0.11743275f, 0.00022469f, 0.07042794f, 0.06920097f, -0.06681499f, -0.05016651f, -0.14819063f, 
    -0.83606207f, -0.42890397f, -0.13357207f, -0.34665430f, 0.02465964f, 0.14570154f, -0.00811410f, -0.15997607f, 
    -0.06976349f, -0.02859106f, 0.00967005f, -0.04067318f, -0.21589617f, 0.46833873f, 0.21138012f, 0.23788573f, 
    -0.01105928f, 0.01973097f, 0.00648327f, -0.01478901f, -0.12846860f, -0.04687775f, -0.09935598f, 0.04238638f, 
    -0.16491827f, -0.02634254f, -0.03302962f, 0.11140472f, -0.08495313f, -0.00503266f, 0.05110367f, -0.02748691f, 
    0.02047901f, 0.01904724f, -0.10559739f, 0.03426197f, -0.09053732f, -0.03538888f, -0.03750860f, 0.11298069f, 
    -0.15790746f, 0.14583527f, -0.10077838f, -0.01285130f, -0.04107097f, -0.10829969f, -0.11758292f, -0.05846220f, 
    -0.05460373f, 0.06509712f, 0.06652325f, -0.04655819f, -0.06269094f, -0.12194426f, 0.07517965f, -0.15383808f, 
    0.08627272f, 0.08288287f, -0.09511229f, 0.04631858f, -0.21594228f, -0.02712600f, 0.09718169f, -0.11174542f, 
    0.04139079f, -0.00928009f, -0.02535714f, -0.04898253f, 0.04963440f, -0.01387459f, -0.17487551f, 0.04136819f, 
    -0.12214749f, 0.00489155f, 0.19751661f, 0.03076159f, -0.00965783f, -0.01676629f, -0.00222980f, -0.04716182f, 
    -0.05587966f, 0.07579891f, -0.01344708f, 0.09514423f, -0.21066542f, 0.21358535f, 0.01717838f, 0.06850106f, 
    0.02315067f, -0.04304666f, 0.05464888f, -0.00120406f, 0.00197645f, 0.03893876f, 0.04165174f, 0.06270260f, 
    -0.09127912f, -0.17206183f, 0.08181051f, 0.00394679f, 0.03597673f, -0.00864620f, 0.06380697f, -0.10181764f, 
    0.00691340f, -0.05457815f, 0.01678695f, 0.01573189f, -0.03493150f, -0.03790040f, 0.07874602f, -0.11889092f, 
    -0.02986797f, -0.03026211f, -0.07443901f, 0.10006086f, 0.05868663f, -0.09893131f, 0.03460490f, 0.03996890f, 
    -0.09218889f, 0.03515304f, -0.05617793f, 0.18708514f, 0.05558188f, -0.02157224f, -0.06350835f, 0.08435544f, 
    0.02174882f, 0.03238753f, -0.06061313f, -0.09318000f, -0.22427116f, -0.07358334f, -0.02301125f, -0.01727509f, 
    -0.05235056f, -0.03977243f, -0.01411480f, 0.04425005f, -0.05058733f, -0.08253039f, -0.01498444f, -0.02212508f, 
    0.00492183f, 0.05905932f, -0.22325332f, 0.02047141f, 0.03344463f, 0.04727352f, 0.07708476f, 0.03965815f, 
    -0.09657508f, 0.03825513f, 0.02503688f, -0.08554004f, -0.56178790f, -0.44051725f, -0.15760396f, -0.20611587f, 
    0.11638899f, -0.10699815f, 0.18813732f, -0.11467659f, -0.00992422f, -0.03302098f, 0.01582532f, -0.04295086f, 
    0.15002063f, -0.03964069f, -0.39999706f, 0.12748900f, -0.03744629f, 0.02320312f, 0.09411817f, 0.01006483f, 
    -0.03129752f, -0.04147843f, 0.00858454f, -0.02012145f, 0.13212784f, -0.06974100f, -0.06152967f, -0.00178905f, 
    0.00812454f, 0.05479458f, -0.02028832f, 0.01062729f, 0.00036145f, 0.04761258f, -0.01316255f, 0.06245814f, 
    -0.04761619f, 0.03943025f, 0.08683732f, 0.16532606f, 0.07731775f, -0.01966194f, -0.01455500f, 0.14597000f, 
    -0.06947535f, 0.04345784f, 0.14382604f, -0.09517066f, -0.60090613f, -0.39726448f, 0.38507846f, 0.16791567f, 
    -0.02756430f, -0.20297769f, 0.05345847f, 0.04676633f, -0.02374594f, 0.03416077f, -0.02746972f, -0.14849001f, 
    -0.27781928f, -0.52581006f, -0.03830800f, -0.08609295f, -0.06083145f, 0.01731862f, -0.15288042f, -0.20191784f, 
    -0.10181079f, 0.05287277f, -0.05773955f, -0.01767462f, 0.11152350f, -0.36869249f, 0.12045256f, 0.33463746f, 
    0.08591036f, 0.01403892f, -0.09701405f, 0.08809952f, -0.06002560f, -0.02218747f, -0.02367182f, 0.00653588f, 
    0.04662611f, -0.02759408f, -0.03438084f, 0.06361541f, -0.05764781f, -0.00163374f, -0.02735453f, 0.12570472f, 
    0.09800421f, 0.07374261f, 0.12919956f, -0.03256022f, -0.01889467f, 0.14128187f, 0.25697285f, -0.11366621f, 
    0.03579037f, 0.00328946f, -0.00441296f, 0.00986199f, 0.05047031f, 0.00556216f, 0.17249811f, -0.13101231f, 
    0.52352113f, 0.26902443f, 0.12286233f, 0.17301302f, 0.00017685f, -0.05987293f, -0.05640879f, -0.01164486f, 
    0.11596574f, 0.12391497f, -0.09564801f, 0.11401192f, -0.03881807f, 0.04327011f, -0.00846296f, -0.12142513f, 
    0.09660854f, -0.01311717f, -0.11737652f, 0.09208846f, 0.02360073f, -0.06969539f, 0.08562917f, -0.19257754f, 
    0.15025321f, -0.02582237f, -0.08865935f, 0.15207423f, 0.10869903f, 0.02700990f, -0.13136157f, 0.01934031f, 
    -0.01803786f, 0.02495671f, -0.02753860f, 0.05771173f, -0.04911596f, -0.05763718f, 0.00385719f, -0.04895597f, 
    0.01195751f, -0.01691514f, -0.03953897f, 0.05700144f, 0.05231449f, 0.04522497f, -0.01557084f, 0.05242893f, 
    0.45917511f, 0.26941261f, 0.10803909f, 0.56457698f, 0.01510045f, -0.06184481f, -0.09248001f, 0.10680220f, 
    0.02496048f, 0.01523070f, -0.09897898f, 0.03067505f, -0.11135612f, -0.07025772f, 0.09330208f, 0.05821629f, 
    -0.05495118f, 0.05226540f, -0.18535793f, 0.17152426f, 0.07204690f, -0.07115299f, -0.03719070f, 0.05047018f, 
    -0.00769021f, -0.07257745f, 0.04563938f, 0.11694387f, -0.06755382f, 0.03243545f, -0.07951234f, -0.22092985f, 
    0.11492343f, -0.02874225f, -0.00948854f, 0.08128862f, -0.12462611f, -0.04068277f, 0.00849921f, 0.01158945f, 
    0.00496044f, -0.03881665f, -0.01396227f, -0.08118982f, 0.04300466f, 0.02516793f, 0.09662766f, 0.01603310f, 
    0.16297546f, -0.17376821f, 0.12814206f, 0.00763221f, 0.16178402f, 0.06366237f, -0.12172012f, 0.02913840f, 
    0.12436580f, 0.01494528f, 0.02581008f, 0.10651088f, -0.08337855f, -0.01895853f, -0.15143907f, 0.07689166f, 
    0.01783049f, 0.01324309f, 0.02637871f, -0.05273170f, 0.01324583f, 0.03417639f, -0.01813861f, -0.03483928f, 
    0.08397713f, -0.02993855f, -0.04194969f, -0.32913646f, 0.17297694f, -0.14108789f, 0.06447563f, 0.15688276f, 
    0.01774743f, -0.02308422f, -0.01233314f, 0.01688375f, -0.06036592f, 0.03080057f, -0.29826641f, -0.20105287f, 
    0.04977937f, -0.07635217f, 0.07690550f, -0.08563520f, -0.06745826f, 0.12120005f, -0.07496960f, 0.01432182f, 
    -0.18602544f, 0.40249705f, 0.06624226f, 0.16740143f, -0.10091085f, -0.06224128f, 0.11316953f, 0.00809005f, 
    -0.02458899f, 0.08542255f, -0.03827425f, 0.01712946f, 0.06786932f, -0.02970424f, -0.04988000f, 0.10322787f, 
    0.03468935f, 0.02018106f, 0.06801474f, 0.11303663f, -0.08758413f, 0.05492318f, -0.13045551f, 0.05469237f, 
    -0.03606752f, -0.20784102f, -0.14877470f, -0.04660601f, 0.07477766f, -0.03211607f, 0.05582560f, 0.01441706f, 
    0.08360182f, -0.06602588f, -0.09840543f, -0.16830857f, -0.09527457f, 0.09387524f, -0.00780782f, -0.01437703f, 
    0.01149378f, -0.02480379f, 0.01864292f, 0.05575511f, -0.00403935f, 0.02376684f, 0.04592327f, -0.09789114f, 
    -0.28528026f, -0.20175999f, 0.19387940f, -0.09174723f, -0.01083222f, 0.03999196f, -0.00076583f, -0.08696126f, 
    -0.20557289f, -0.16584450f, -0.11672363f, -0.01055294f, 0.11088474f, -0.23170345f, -0.14947598f, 0.26073492f, 
    0.01238406f, 0.08095390f, 0.00241525f, -0.03714575f, 0.04254885f, 0.00651043f, 0.04333761f, -0.04695108f, 
    0.00672413f, -0.02234536f, 0.09130733f, -0.33637145f, 0.05332402f, -0.05616872f, -0.09991930f, 0.05048499f, 
    0.07569858f, 0.02060797f, -0.04689271f, 0.02805989f, 0.46614441f, 0.22677147f, 0.28076261f, 0.35693803f, 
    0.03322378f, 0.06137900f, -0.12933020f, 0.13388136f, 0.08055613f, 0.06623129f, 0.01212462f, 0.07981863f, 
    -0.06693542f, -0.13439246f, -0.24298567f, 0.04267482f, -0.01237341f, -0.01400883f, 0.03419524f, 0.07637612f, 
    0.01376036f, -0.05942764f, 0.09108865f, -0.18071768f, -0.15013246f, 0.08196602f, -0.02221429f, -0.12274461f, 
    0.01602608f, 0.04649176f, -0.02850309f, -0.10669765f, -0.01583917f, 0.08593749f, 0.00956353f, -0.06615546f, 
    0.10258854f, -0.01467206f, -0.03205001f, 0.01003023f, 0.02422859f, -0.08105624f, 0.02309532f, 0.04874673f, 
    -0.02934092f, 0.07491086f, 0.06647059f, -0.10952022f, -0.13367982f, 0.12173990f, -0.00378651f, 0.06296511f, 
    0.02002607f, -0.03042282f, 0.01411659f, 0.04673208f, -0.05492458f, -0.17825538f, 0.09206986f, -0.01078651f, 
    -0.26093423f, -0.12301401f, 0.00416657f, -0.00134760f, -0.10879018f, -0.30611289f, -0.32144406f, -0.08107923f, 
    0.00497230f, 0.02683055f, -0.05988266f, 0.03849847f, -0.30324730f, 0.31654206f, 0.45755699f, -0.19072583f, 
    -0.03814705f, 0.09130072f, -0.17692362f, 0.00910444f, 0.12145088f, -0.00174896f, -0.06239693f, 0.13773943f, 
    0.07287171f, 0.11822096f, -0.30369887f, -0.17678162f, 0.02050329f, -0.12467807f, 0.03187744f, 0.22151640f, 
    -0.01916924f, 0.09533712f, -0.04879066f, 0.00950305f, -0.09236272f, -0.04591613f, -0.03022099f, 0.11532706f, 
    0.04116295f, 0.13735883f, -0.04904761f, 0.01163284f, 0.00999515f, -0.00516088f, -0.01742833f, 0.04998388f, 
    -0.00171271f, -0.01393438f, -0.13475604f, -0.05533109f, -0.04830206f, -0.01147049f, 0.07656850f, -0.02504703f, 
    -0.01764485f, -0.07761981f, 0.07507758f, -0.10050115f, 0.04938409f, -0.04513179f, 0.18804701f, 0.06544007f, 
    -0.05847636f, -0.02852849f, -0.04289488f, 0.03243538f, -0.09248861f, 0.10328412f, 0.01181799f, 0.00524265f, 
    -0.27091345f, -0.11871108f, 0.03317237f, -0.25081423f, 0.15414201f, -0.01978692f, -0.09965640f, -0.26811200f, 
    0.00955640f, -0.02805022f, -0.06484063f, -0.04543346f, -0.19180863f, 0.05314736f, -0.08744820f, 0.14763734f, 
    -0.07673958f, 0.10170624f, 0.02715900f, 0.03090575f, -0.00144566f, -0.10735388f, 0.07675645f, -0.12489552f, 
    0.08913865f, 0.10185121f, -0.33228090f, -0.01396873f, 0.03518592f, -0.04665079f, -0.01873618f, -0.00008411f, 
    -0.14691746f, 0.10479437f, 0.00285063f, -0.03958898f, 0.31574768f, -0.26067242f, 0.09674427f, -0.23038362f, 
    -0.07590881f, 0.05747200f, 0.05917900f, 0.20563599f, 0.01727303f, -0.08287706f, -0.02958945f, -0.12472857f, 
    0.02583426f, -0.10979825f, -0.19069619f, 0.13315161f, 0.03174876f, 0.04920743f, 0.09768500f, 0.00381906f, 
    -0.04124815f, 0.01815312f, -0.01030823f, 0.00597986f, -0.15387899f, -0.13082011f, 0.07985662f, 0.15667437f, 
    0.07484034f, 0.03472276f, -0.03561319f, 0.07509606f, 0.00404603f, -0.01550724f, -0.02386733f, -0.14178993f, 
    -0.16553223f, 0.11437442f, 0.10781432f, 0.31304032f, 0.12159168f, -0.03341146f, -0.12026611f, -0.08617834f, 
    0.04826553f, -0.09474647f, -0.06730891f, -0.11144944f, -0.17283049f, 0.38239032f, 0.05986508f, 0.35089278f, 
    -0.06931914f, -0.01227220f, -0.05293099f, -0.00612985f, 0.07823349f, 0.20493783f, -0.03348323f, 0.18018664f, 
    -0.07709367f, 0.05292800f, -0.11170227f, -0.32590407f, 0.02500699f, 0.10220366f, 0.00842288f, -0.09641608f, 
    -0.09358136f, -0.17931215f, 0.11010825f, -0.04879782f, -0.11208054f, -0.36418355f, 0.00275809f, 0.04060359f, 
    0.07866593f, 0.16664141f, 0.07617163f, 0.01814378f, -0.04163562f, 0.03707205f, -0.08210416f, 0.06510247f, 
    0.08801489f, -0.05882906f, 0.28372961f, 0.04578451f, 0.06127976f, 0.06958621f, 0.10928026f, 0.06533100f, 
    -0.01617200f, 0.04198042f, -0.06658299f, 0.05141774f, -0.19813104f, -0.46935043f, -0.06337337f, -0.23052225f, 
    -0.06828773f, -0.10746397f, -0.09316061f, 0.27309024f, -0.04253172f, 0.18504669f, -0.21847157f, -0.09584223f, 
    0.01279590f, -0.05606534f, 0.03995340f, 0.20282410f, -0.04186624f, 0.16624112f, 0.16974764f, 0.11133024f, 
    -0.02076473f, -0.03627316f, -0.03521263f, -0.14148116f, 0.25090590f, -0.08444194f, -0.03811138f, 0.21310876f, 
    0.18309329f, -0.03281999f, 0.03845511f, -0.03338749f, 0.05195160f, -0.02285067f, -0.00523566f, 0.02195994f, 
    -0.64505512f, -0.44246218f, 0.36619648f, -0.20894673f, -0.03042506f, -0.23167066f, -0.14516662f, 0.09933632f, 
    0.05474892f, 0.12778057f, 0.06380466f, 0.03158287f, 0.16102558f, 0.15343966f, 0.13874875f, 0.10897522f, 
    0.08419436f, -0.03657353f, -0.06803549f, 0.02435354f, 0.12353320f, -0.00741650f, 0.06653680f, -0.01004990f, 
    -0.37948042f, -0.17962839f, 0.12401757f, 0.45425847f, 0.01624349f, -0.12686186f, -0.05465549f, -0.06912513f, 
    -0.01958232f, 0.10510284f, -0.16974528f, 0.16626279f, -0.21500874f, -0.13732548f, 0.13762727f, -0.03292106f, 
    0.02292270f, -0.12916918f, -0.05969168f, 0.03626890f, -0.14584525f, 0.11543284f, -0.07600116f, -0.07561035f, 
    -0.09219886f, -0.02740042f, -0.04145530f, 0.13412829f, -0.02138757f, -0.01359629f, 0.01582961f, 0.01021045f, 
    -0.04683200f, 0.01661486f, -0.02300920f, 0.01409578f, -0.60475427f, 0.45701662f, -0.12620495f, 0.11843387f, 
    -0.06642888f, -0.18377133f, 0.03444296f, -0.11904019f, -0.13016213f, 0.12541467f, 0.05935746f, -0.01095985f, 
    0.15574895f, -0.10677777f, 0.07858516f, 0.04449608f, -0.08113356f, -0.00037206f, -0.01364926f, -0.05455487f, 
    0.02396494f, -0.00924475f, -0.02209351f, -0.13099962f, -0.15093607f, 0.04222015f, 0.36669415f, 0.15160400f, 
    -0.04401154f, -0.06425029f, -0.17608932f, 0.00974770f, 0.18453945f, 0.16798519f, 0.00816457f, 0.22053674f, 
    0.06971109f, 0.03649387f, -0.10249365f, -0.53492886f, 0.13720939f, -0.03484976f, 0.02830284f, 0.07815143f, 
    -0.10631803f, 0.00414432f, -0.02864936f, -0.01489831f, -0.37379098f, -0.32133558f, -0.27274758f, -0.06951233f, 
    -0.06806760f, -0.28023401f, -0.13659512f, -0.08759458f, 0.05108390f, 0.01841805f, 0.07695781f, -0.09389748f, 
    -0.11189207f, 0.33608791f, -0.31179386f, -0.12327899f, -0.02226189f, 0.01729923f, -0.07301792f, -0.10095920f, 
    0.01779394f, -0.10547036f, 0.14377207f, 0.09616385f, -0.01531494f, -0.18619412f, -0.20224281f, 0.20435601f, 
    0.09353104f, 0.04429347f, -0.04823794f, 0.07396204f, -0.02812562f, -0.02208797f, 0.07926791f, -0.11028903f, 
    0.33022484f, 0.12971798f, -0.21759818f, -0.39724994f, -0.09168202f, -0.12773298f, -0.07585967f, -0.07431090f, 
    -0.02841664f, 0.05300933f, -0.11603863f, 0.04704195f, 0.49569759f, -0.21155562f, 0.02173078f, -0.18649422f, 
    -0.22224422f, -0.05468806f, 0.00349226f, 0.02617986f, -0.20657806f, -0.09345149f, 0.14066246f, -0.04341765f, 
    -0.41554463f, 0.62350398f, -0.49622682f, -0.41563413f, 0.17897499f, 0.02186244f, -0.11619271f, 0.04055869f, 
    -0.29654816f, -0.13968469f, 0.01412587f, -0.03854698f, -0.10583724f, 0.02879819f, -0.15928812f, 0.02320891f, 
    0.06843234f, 0.06352666f, -0.01813340f, -0.01519316f, -0.02651753f, 0.09633732f, 0.00774299f, 0.02425352f, 
    -0.04592960f, -0.23522715f, -0.11265555f, 0.17474370f, -0.00393803f, 0.05020282f, 0.16385077f, -0.02402262f, 
    0.06975813f, 0.00301597f, -0.03781396f, 0.06591239f, 0.09377032f, 0.03429752f, -0.17112504f, -0.00381455f, 
    0.03465013f, -0.03786537f, 0.01252196f, -0.01042413f, -0.06477908f, 0.07698791f, -0.09875225f, 0.03195646f, 
    -0.38166946f, 0.37926599f, -0.40731439f, -0.21996395f, 0.11027516f, -0.05345134f, 0.03002219f, 0.01367592f, 
    -0.23001729f, -0.10418584f, -0.06228602f, 0.06844181f, -0.34489927f, -0.06124330f, -0.13605741f, 0.10252608f, 
    0.09468874f, 0.01457359f, -0.07551461f, -0.05183282f, -0.01818971f, 0.11425417f, -0.05974451f, -0.17447349f, 
    0.97492254f, -0.04084936f, 0.22455184f, 0.25840509f, 0.15545662f, 0.07534759f, -0.01089405f, -0.07265255f, 
    -0.02934903f, -0.03875232f, 0.03285059f, 0.19202235f, -0.24337120f, 0.06338546f, -0.18551442f, 0.13218705f, 
    0.17515925f, -0.03361726f, -0.13755284f, -0.05842230f, -0.11545651f, -0.13776986f, -0.00080611f, -0.00393348f, 
    0.33272764f, -0.00769900f, -0.01797829f, -0.14367411f, -0.05256936f, -0.05335480f, -0.07679413f, -0.10463906f, 
    -0.08869594f, 0.00691544f, 0.02870202f, 0.10194869f, -0.00814685f, 0.13506128f, -0.01614468f, 0.26380116f, 
    -0.15289013f, -0.05927190f, 0.00897721f, -0.15995698f, 0.03512426f, 0.03180987f, -0.15451857f, 0.14450783f, 
    0.21531464f, -0.10796157f, 0.02990085f, 0.21471725f, 0.01756600f, -0.07897902f, -0.03104275f, -0.11867050f, 
    -0.05551434f, 0.10910273f, -0.02936466f, 0.08519828f, -0.00356672f, 0.01265562f, 0.00802790f, -0.26492223f, 
    -0.23547830f, 0.06719817f, -0.11307744f, -0.05046806f, -0.03155839f, -0.14497687f, -0.06235731f, -0.14481848f, 
    0.05925367f, -0.09391338f, -0.09544173f, 0.00417759f, 0.05620094f, -0.03227288f, 0.08486396f, -0.00115858f, 
    0.00335466f, 0.03870510f, -0.22189192f, -0.00175834f, 0.16269745f, -0.34124705f, 0.16335234f, 0.00048219f, 
    -0.30608663f, -0.06782661f, 0.05939719f, 0.07193021f, 0.07076429f, 0.03048556f, 0.13101441f, -0.02878272f, 
    0.32203743f, -0.20429687f, -0.13686074f, 0.01728469f, 0.04130423f, 0.05777731f, 0.02930843f, -0.22407062f, 
    -0.14088053f, -0.07368019f, 0.01937649f, -0.12846930f, 0.16150884f, 0.18280770f, -0.17066421f, -0.26894861f, 
    0.16370812f, 0.03614339f, 0.04981052f, 0.01907380f, -0.14940201f, -0.03182877f, 0.04316450f, 0.16319114f, 
    -0.01312249f, 0.06702997f, -0.08658792f, 0.05911805f, -0.06994176f, -0.06028838f, -0.08496973f, -0.06871323f, 
    0.05243246f, -0.00762531f, -0.02592083f, 0.13765945f, 0.48743898f, -0.17501658f, 0.25156173f, -0.15505227f, 
    -0.25729340f, -0.06351510f, -0.11267202f, 0.05999797f, -0.06223951f, -0.02238736f, 0.04083805f, -0.05366397f, 
    0.04650101f, -0.10045369f, -0.04874969f, 0.15382549f, 0.13506204f, 0.02508306f, 0.07475983f, -0.01027207f, 
    0.02305881f, 0.10440864f, 0.00700238f, 0.08756398f, -0.18373509f, 0.31240535f, -0.17718127f, -0.54595983f, 
    0.02513985f, 0.00766088f, -0.07573711f, -0.08511089f, -0.19884372f, -0.01549473f, -0.26671800f, 0.09512769f, 
    0.14602122f, -0.03360797f, 0.05470799f, -0.08997409f, 0.10665125f, 0.13853048f, -0.03850907f, -0.06271512f, 
    -0.01966060f, 0.11514739f, 0.01330064f, 0.04450686f, -0.34518504f, -0.00923134f, -0.03674394f, -0.41641214f, 
    0.07960242f, -0.05864731f, 0.01886139f, -0.17729698f, 0.12641793f, -0.01799600f, -0.01831236f, -0.00636413f, 
    -0.17948444f, -0.03011592f, 0.11242694f, 0.26486853f, 0.05051419f, -0.11499747f, 0.03423246f, -0.04856696f, 
    0.08200906f, 0.14570408f, 0.11874850f, -0.16749531f, -0.20162220f, 0.10206424f, -0.19728224f, -0.07791208f, 
    -0.03711578f, 0.02620300f, -0.07779396f, 0.02339413f, -0.03617305f, -0.05212342f, 0.01840009f, 0.06599975f, 
    -0.37453750f, 0.08614455f, 0.05730572f, 0.19224310f, -0.00225729f, 0.10874154f, -0.17975339f, 0.04616800f, 
    -0.07700624f, 0.00048461f, 0.09549268f, -0.01436180f, 0.53870124f, -0.24175079f, 0.03312516f, 0.18860874f, 
    0.13677801f, -0.02696024f, -0.02763569f, -0.18096381f, -0.06623258f, -0.03565826f, 0.02593902f, 0.06951371f, 
    -0.26731598f, 0.08536756f, -0.23039778f, -0.26724336f, 0.07931939f, 0.01939233f, 0.05898737f, 0.03348303f, 
    -0.20601331f, -0.06626708f, -0.04232819f, -0.08878143f, 0.14043218f, -0.17284037f, 0.01751105f, 0.05178531f, 
    -0.10272071f, -0.18275680f, -0.05242589f, -0.03200428f, 0.01268738f, 0.23005144f, -0.23397857f, -0.02953346f, 
    -0.40087029f, 0.10624656f, -0.31931174f, -0.39027309f, -0.03063775f, -0.08280746f, -0.06070710f, -0.29327923f, 
    0.05244865f, -0.12342391f, 0.01618518f, 0.09985304f, -0.29813918f, -0.01829122f, -0.04384628f, -0.33966002f, 
    0.13320543f, 0.10673270f, 0.05753236f, -0.03718429f, -0.16621892f, 0.05679637f, -0.05592718f, -0.04240596f, 
    -0.08595504f, -0.22782071f, 0.40003669f, 0.11900918f, 0.13655388f, 0.08566511f, -0.14459381f, 0.11861292f, 
    0.01716484f, -0.18362778f, 0.02080338f, 0.02413355f, -0.32654598f, 0.20521164f, 0.04002833f, 0.31799826f, 
    0.02742603f, 0.04576775f, 0.03169943f, 0.08155154f, -0.07258298f, -0.12496755f, 0.18624483f, -0.04993215f, 
    -0.30583072f, 0.79139769f, -0.13795243f, 0.31714496f, -0.04084660f, 0.19457845f, 0.04074942f, -0.17409006f, 
    -0.11111418f, 0.03356582f, 0.26144290f, 0.07323218f, -0.10827784f, -0.01747902f, -0.12191776f, 0.11212879f, 
    -0.12116938f, -0.14308499f, 0.00165000f, -0.15968758f, 0.01553676f, -0.01419910f, -0.09590169f, 0.08446722f, 
    0.27195105f, 0.09810860f, 0.00130809f, -0.10714076f, -0.11340939f, -0.05122863f, -0.14030534f, -0.01503722f, 
    0.09043925f, 0.07447537f, -0.09272527f, 0.01251581f, -0.14416778f, -0.05116410f, -0.12118385f, 0.09184465f, 
    0.10263734f, -0.01411093f, 0.20761938f, -0.02831551f, -0.07952803f, 0.03380447f, -0.05754530f, 0.07986913f, 
    0.01589458f, -0.08538590f, 0.10519492f, 0.12242749f, 0.03985588f, 0.00567072f, 0.08162757f, 0.03202213f, 
    -0.11050270f, -0.01951636f, -0.06430548f, -0.05223471f, 0.35656801f, 0.05779456f, -0.35597995f, 0.00549842f, 
    0.06402498f, -0.21830419f, -0.09015226f, -0.05004662f, -0.07369116f, 0.06082713f, 0.16129650f, 0.07534086f, 
    -0.03285934f, -0.06197695f, 0.02681280f, 0.06590441f, -0.06045258f, -0.01444411f, -0.08167331f, -0.05753640f, 
    -0.07487088f, 0.17678852f, 0.12561172f, 0.17016265f, -0.03857832f, -0.10584430f, -0.10720575f, 0.08123874f, 
    0.02680742f, -0.01188661f, -0.01712647f, -0.00884999f, 0.00524837f, -0.00115015f, -0.05574517f, 0.07770602f, 
    0.01409172f, 0.05746897f, 0.23894250f, 0.18653667f, -0.09595461f, 0.01615335f, -0.20080929f, 0.08265898f, 
    0.08192468f, 0.01429195f, 0.00567407f, 0.00803026f, 0.10314144f, 0.05049366f, 0.05917326f, 0.03045927f, 
    -0.02097876f, 0.00238162f, 0.06210003f, 0.04186971f, -0.05974804f, 0.03816172f, -0.23395689f, 0.00981873f, 
    0.11648350f, -0.00244785f, 0.11353353f, -0.03314001f, 0.00623435f, 0.04185697f, 0.03600905f, -0.10155665f, 
    0.02955370f, -0.06744397f, 0.00384539f, -0.03541289f, 0.16747561f, -0.03298966f, 0.07211622f, -0.13383378f, 
    0.03906680f, 0.04936265f, 0.02537762f, 0.10098312f, 0.04674233f, 0.01375589f, 0.05330114f, -0.02869437f, 
    0.07453074f, 0.10584775f, -0.09463551f, -0.04688015f, 0.03305763f, 0.01033882f, 0.05130406f, -0.06606326f, 
    0.10010617f, -0.05659920f, -0.20686220f, 0.08272741f, 0.09643245f, 0.25150514f, 0.08609217f, 0.01334399f, 
    0.00534945f, -0.07559453f, 0.03490456f, 0.08766517f, -0.01405138f, -0.11631110f, -0.04967616f, 0.08164363f, 
    0.29190138f, 0.02335601f, -0.01761401f, 0.38162503f, 0.01639683f, 0.04208206f, 0.04681566f, -0.14872845f, 
    0.04310801f, -0.02631626f, 0.07772608f, -0.02617255f, 0.11893308f, -0.12448499f, 0.11824144f, -0.09720265f, 
    -0.00601907f, 0.07390925f, -0.03725054f, -0.10682038f, 0.02182220f, -0.04033588f, -0.08073001f, -0.04219390f, 
    -0.01897980f, 0.14124537f, 0.22469600f, 0.22634496f, -0.02814899f, 0.01960966f, 0.01931177f, 0.16731116f, 
    -0.04605485f, 0.03399260f, -0.00790828f, -0.03431218f, 0.19880980f, 0.15965052f, 0.07386804f, 0.16227184f, 
    -0.00575176f, -0.04239837f, -0.05972983f, -0.04701068f, -0.00698416f, -0.14435990f, -0.11417079f, -0.05181691f, 
    0.02443452f, -0.07876547f, -0.00163450f, -0.02583697f, 0.01784393f, 0.08388663f, 0.05593619f, -0.00969613f, 
    0.03515397f, 0.00895476f, 0.10355573f, 0.04602390f, 0.11452328f, -0.12205018f, -0.01398009f, 0.03804819f, 
    0.04967300f, 0.02575403f, -0.04554489f, -0.03973367f, 0.07998448f, -0.03294415f, -0.01475011f, -0.02989743f, 
    -0.01096653f, 0.04846844f, 0.09788575f, 0.00332611f, 0.10623295f, -0.02438281f, -0.05357914f, -0.08315734f, 
    0.09210880f, -0.07264742f, 0.13078070f, -0.07284492f, -0.20201337f, 0.21132189f, -0.16805410f, -0.04693940f, 
    -0.00095796f, 0.02146210f, 0.01762149f, 0.05300525f, 0.07230181f, -0.00870574f, 0.08037130f, 0.06233902f, 
    -0.02753692f, 0.07320686f, -0.08471988f, -0.05270172f, -0.08412729f, -0.06974474f, -0.06263798f, 0.02379270f, 
    -0.03995186f, 0.09449013f, 0.09054864f, 0.27049518f, -0.02437998f, -0.77297211f, 0.00591644f, -0.28239769f, 
    0.00439261f, -0.09412535f, 0.03055830f, 0.03753931f, 0.06037440f, -0.09604350f, -0.04007823f, -0.02955588f, 
    -0.04833576f, 0.01808424f, 0.05162601f, 0.20127818f, 0.01769399f, 0.10662395f, -0.10229343f, 0.09125619f, 
    0.00694425f, -0.06287821f, -0.00754816f, -0.10708541f, 0.14452969f, -0.01973162f, -0.03895605f, 0.23776188f, 
    0.07776359f, -0.06593991f, 0.06307388f, -0.09948616f, 0.10558095f, 0.03461850f, 0.05995877f, 0.01963778f, 
    -0.01377344f, -0.26381579f, -0.05066384f, 0.12988390f, -0.21568625f, -0.03598598f, -0.11001610f, -0.01467740f, 
    0.02258009f, 0.08597032f, -0.06274973f, -0.02628153f, 0.03506887f, 0.02105869f, -0.03374178f, 0.02093169f, 
    0.12260163f, 0.10243469f, 0.00084364f, 0.05177138f, 0.10170970f, 0.06850594f, -0.01046774f, 0.08747007f, 
    -0.01543127f, -0.18299462f, 0.24659716f, 0.19011195f, -0.00101142f, 0.01219076f, -0.02211512f, -0.00506156f, 
    -0.08597477f, -0.04864577f, -0.01278380f, -0.03284277f, 0.17165236f, 0.21397880f, 0.22657412f, 0.17414233f, 
    -0.15164472f, 0.01532537f, -0.05947125f, 0.13760781f, 0.00582727f, 0.05876337f, -0.01327395f, -0.01110700f, 
    -0.01381800f, -0.06375523f, -0.06310023f, -0.04935990f, -0.24513598f, 0.04217923f, -0.10987646f, -0.09007311f, 
    -0.03986868f, -0.12489751f, 0.03254987f, -0.09651408f, -0.25064376f, 0.11441901f, -0.21156041f, -0.14474951f, 
    0.05764016f, 0.06995357f, -0.03446146f, 0.02410929f, -0.08341274f, 0.02004071f, -0.13212782f, -0.02260384f, 
    0.05789889f, -0.60601544f, 0.03901922f, 0.00731983f, -0.18345615f, 0.09997758f, -0.02239797f, -0.12577441f, 
    -0.19016989f, 0.12499968f, -0.19025287f, -0.13048391f, -0.24698642f, -0.20959599f, -0.06489875f, 0.13006093f, 
    0.05304788f, -0.02541537f, -0.00092848f, -0.10873048f, -0.03598380f, -0.01051647f, -0.00586069f, 0.06586376f, 
    0.19425498f, 0.25811714f, 0.14176661f, 0.14743909f, 0.02051356f, -0.08358859f, -0.11893491f, 0.16433378f, 
    -0.08769845f, -0.04676633f, -0.03128370f, -0.07007115f, -0.02758739f, -0.03168508f, 0.00000702f, 0.02473366f, 
    -0.15501915f, 0.00481751f, -0.08125456f, -0.14988431f, 0.01082290f, -0.03626757f, -0.00152147f, 0.11915451f, 
    0.02428299f, -0.31704602f, 0.23921181f, 0.02314290f, -0.16082248f, 0.09499498f, -0.17500959f, 0.07982285f, 
    -0.11699594f, 0.12001621f, -0.05226327f, -0.05431217f, -0.01466804f, -0.24899973f, -0.39210960f, -0.31504038f, 
    0.00376111f, 0.01294650f, 0.02901107f, 0.03753757f, -0.04197674f, -0.04047110f, -0.03029813f, 0.02994658f, 
    -0.06032201f, -0.29596680f, -0.25973940f, 0.03979070f, -0.08008225f, -0.31357333f, 0.09644985f, -0.07323205f, 
    -0.09802721f, -0.02216775f, 0.17424141f, 0.08341829f, 0.14787184f, 0.08271879f, 0.05952894f, 0.02559325f, 
    0.00948744f, 0.09734140f, 0.00727856f, 0.05169375f, -0.04750567f, -0.04824153f, -0.15851833f, -0.08416908f, 
    -0.17958353f, -0.01293792f, -0.18686405f, 0.28603721f, -0.07204293f, -0.23262420f, -0.17962044f, -0.16816664f, 
    -0.20141424f, 0.01407616f, -0.27000055f, -0.01546811f, 0.05146911f, -0.00184463f, -0.00011848f, 0.04368660f, 
    0.16852523f, -0.01664152f, 0.03368056f, -0.04931173f, -0.04760473f, -0.05887970f, 0.06120188f, -0.01493918f, 
    -0.03288971f, 0.03136341f, -0.01657817f, 0.10396969f, 0.02762578f, -0.08345399f, -0.06230484f, -0.29581934f, 
    0.01013160f, -0.02751067f, 0.04578759f, 0.15833877f, 0.02484239f, 0.03259734f, -0.07829382f, 0.11728089f, 
    -0.13099882f, 0.00385102f, -0.04075624f, -0.13545677f, 0.10043888f, -0.06200910f, -0.03626027f, -0.01758070f, 
    -0.05283625f, 0.06129075f, 0.04728065f, 0.10581826f, 0.05031641f, -0.04107402f, -0.06036650f, -0.08776822f, 
    -0.05580125f, -0.03982754f, 0.01534742f, -0.03570483f, 0.02711772f, 0.08924478f, -0.04470734f, 0.09734705f, 
    0.06333126f, 0.10405688f, -0.04726050f, -0.00435484f, 0.09430402f, 0.01870141f, -0.13820283f, 0.09653614f, 
    -0.08723521f, 0.00307206f, -0.06971464f, 0.05518620f, -0.07287553f, -0.03681114f, 0.13039027f, -0.02112553f, 
    -0.06964010f, 0.03205215f, -0.01384958f, 0.00769595f, -0.15490910f, -0.22503719f, -0.04475668f, 0.03069217f, 
    0.09698404f, 0.03085524f, 0.04031654f, 0.05518800f, -0.04377181f, -0.07342101f, -0.08727340f, -0.16283821f, 
    -0.00843925f, 0.00757790f, 0.03466953f, 0.30001318f, 0.13301671f, -0.05626301f, -0.08788668f, -0.10990263f, 
    -0.03079488f, -0.02694297f, -0.02287402f, -0.07092453f, -0.22478510f, 0.34791064f, -0.27694064f, -0.07300401f, 
    0.06936061f, 0.02202288f, -0.16267905f, -0.14667752f, -0.03729646f, 0.01440364f, 0.04763668f, 0.12673439f, 
    -0.00866915f, 0.07544450f, 0.17627950f, 0.15349001f, -0.02602386f, -0.06772682f, 0.06913468f, 0.01161060f, 
    0.17778243f, 0.02870345f, 0.10954906f, 0.17094253f, 0.22025594f, -0.35676396f, -0.05468439f, 0.05146478f, 
    -0.01826351f, 0.02192242f, -0.02602097f, -0.06700138f, -0.12903276f, -0.21323501f, -0.17154148f, -0.05067873f, 
    0.21545888f, 0.13500082f, -0.12770225f, 0.06388116f, 0.02304431f, 0.01922071f, 0.01943044f, -0.05612262f, 
    -0.02152593f, -0.08249395f, -0.16559152f, -0.24950132f, -0.09191814f, -0.18235043f, -0.05399941f, -0.12272998f, 
    0.07712795f, -0.01713391f, 0.02034876f, -0.02629745f, -0.08711264f, -0.05226078f, -0.11212398f, 0.12204517f, 
    0.17939517f, 0.11902923f, 0.02239761f, 0.08748658f, 0.10230777f, -0.09935224f, 0.01447198f, -0.04476785f, 
    -0.52629870f, -0.31614056f, 0.13020059f, -0.01635296f, -0.08449415f, -0.00516593f, 0.04847026f, -0.09602445f, 
    -0.04096466f, -0.00147647f, 0.00877150f, 0.02422153f, 0.06780082f, 0.11354920f, 0.02473330f, 0.12299477f, 
    0.03456612f, 0.24691854f, -0.48826993f, -0.07554481f, 0.15062083f, -0.07076806f, 0.04658106f, -0.05423374f, 
    0.01115745f, 0.02720730f, -0.15683328f, -0.14720407f, -0.13968259f, 0.04374152f, 0.05466433f, 0.10524599f, 
    -0.13730271f, -0.13496414f, 0.02957080f, 0.05184475f, 0.05947457f, 0.00858504f, 0.02577350f, 0.04774824f, 
    0.11764928f, -0.07024118f, -0.00974691f, -0.04665023f, 0.05511492f, 0.07089697f, 0.05485812f, 0.05993414f, 
    0.01258641f, 0.02654667f, 0.06861729f, -0.09541716f, 0.07981799f, 0.03600953f, 0.04655852f, -0.23107806f, 
    -0.15847775f, -0.07491107f, 0.07180843f, 0.01555904f, -0.03417435f, -0.06331225f, 0.01518703f, -0.11782663f, 
    -0.11917990f, -0.01790968f, -0.11157802f, 0.10473150f, 0.05319729f, -0.02572722f, -0.01528981f, 0.01067892f, 
    -0.27538487f, -0.05181711f, -0.03458938f, 0.18388337f, 0.14830936f, -0.08040087f, -0.14850652f, -0.06666788f, 
    0.04036867f, 0.03779737f, 0.04280566f, -0.17339173f, 0.00170611f, -0.12725490f, -0.18636155f, -0.18130881f, 
    0.05899958f, 0.15399392f, 0.11010385f, 0.17708389f, 0.05443884f, 0.19819632f, 0.10892280f, 0.06359795f, 
    0.03151457f, -0.05265908f, -0.03077532f, -0.04501539f, -0.19312453f, -0.00978353f, -0.17358987f, -0.03730687f, 
    0.00543695f, -0.03608279f, -0.07242632f, -0.09778041f, 0.02645950f, 0.06193241f, -0.00752256f, 0.13488767f, 
    0.04070659f, -0.15747283f, 0.18336655f, 0.06927519f, 0.12511060f, -0.03989103f, -0.02906630f, 0.00815068f, 
    0.11285293f, -0.08752935f, -0.03742667f, 0.11509085f, -0.02688880f, -0.10990794f, 0.00519146f, -0.06955857f, 
    -0.07888021f, -0.00596781f, -0.02912914f, -0.04022199f, -0.08446917f, -0.03814692f, -0.19270317f, -0.06355610f, 
    0.24218960f, -0.13846193f, 0.11946009f, 0.13648097f, 0.00237672f, 0.00234632f, 0.07756507f, -0.11190669f, 
    0.08319486f, -0.09379059f, 0.14143993f, 0.05780461f, 0.14746767f, 0.01157562f, 0.19421391f, 0.14296943f, 
    -0.08759762f, -0.04103395f, -0.15543902f, -0.02858764f, 0.01422186f, -0.02599954f, -0.06145322f, 0.00904941f, 
    0.04637155f, 0.15636389f, 0.00492117f, 0.20122349f, 0.11656037f, 0.01377394f, 0.05511526f, -0.04734899f, 
    -0.04993808f, -0.07708883f, 0.01408480f, -0.08615739f, -0.42362499f, -0.25492477f, 0.14959751f, -0.04526465f, 
    -0.03746175f, 0.04853836f, -0.05189029f, 0.06030001f, -0.10012256f, -0.15051846f, -0.01917759f, 0.01934694f, 
    -0.13352582f, -0.25391659f, 0.31186116f, -0.10069077f, -0.00803765f, -0.00476248f, 0.00835255f, 0.05962407f, 
    0.09951348f, -0.33756086f, -0.02168735f, -0.03710235f, 0.41088688f, -0.24082057f, -0.27305949f, 0.25767246f, 
    0.04215378f, 0.01461600f, -0.00121980f, 0.00062282f, -0.02980470f, -0.01026457f, 0.04656474f, 0.10190674f, 
    0.03186221f, 0.12399303f, 0.18038125f, -0.10406563f, 0.19176118f, 0.04078160f, 0.01362777f, 0.14570355f, 
    -0.03156749f, -0.02228777f, 0.06145455f, 0.13417706f, 0.21021333f, -0.11580500f, -0.13305379f, 0.01679655f, 
    0.02908294f, -0.04396213f, -0.01311210f, 0.01292931f, -0.14954746f, 0.20213754f, 0.21728887f, -0.21588866f, 
    -0.01741420f, 0.04076114f, -0.11923639f, -0.02347928f, 0.08255068f, -0.02020359f, 0.10357724f, 0.09053461f, 
    0.06804121f, 0.12331250f, 0.02904052f, 0.10797884f, -0.22549768f, -0.46035242f, -0.36711869f, -0.14407247f, 
    0.07230607f, 0.12132574f, -0.09991142f, 0.14422075f, -0.06320086f, -0.03989243f, 0.07445799f, -0.09516720f, 
    -0.18422523f, 0.05284206f, 0.14621846f, -0.14697544f, 0.07766615f, -0.04932905f, -0.03300382f, 0.04994282f, 
    0.20110811f, 0.23284383f, -0.06436568f, -0.08125558f, -0.50588566f, -0.27519253f, -0.18587419f, -0.07025631f, 
    0.05021668f, 0.03610473f, -0.16882902f, -0.00907627f, -0.01413776f, 0.06500607f, 0.13159455f, -0.00627021f, 
    -0.22340214f, 0.21825054f, 0.15139161f, 0.13858072f, 0.08019079f, -0.15317681f, 0.03921835f, 0.05389661f, 
    -0.01104974f, 0.07792138f, -0.06714250f, -0.04142476f, 0.09486441f, -0.17727965f, -0.03584193f, 0.32366571f, 
    0.00399696f, -0.00784117f, 0.17216620f, -0.12096696f, 0.10264014f, -0.05048508f, 0.33762059f, -0.03345625f, 
    0.15718840f, 0.15567134f, 0.04594844f, -0.01058752f, 0.14740908f, 0.10593708f, -0.09012111f, -0.18639037f, 
    0.04924601f, 0.05448478f, 0.00359371f, 0.07373060f, -0.26567370f, -0.28943631f, -0.12460812f, -0.14775145f, 
    -0.11382012f, 0.01407683f, 0.07290410f, 0.01956865f, 0.19451107f, -0.11322894f, 0.02310047f, 0.02328764f, 
    -0.08896536f, -0.18041523f, -0.04384202f, 0.15614864f, 0.05357384f, 0.04347290f, -0.00239048f, -0.04471961f, 
    -0.00876600f, -0.03144963f, 0.01039953f, -0.07483408f, -0.07013525f, -0.25213391f, -0.11695973f, -0.02788467f, 
    -0.11270234f, -0.07198700f, -0.03868540f, -0.19062617f, 0.19486530f, 0.10268066f, -0.02454337f, 0.02648537f, 
    0.07326475f, 0.11363901f, -0.29742897f, -0.09700668f, 0.11012155f, 0.05564336f, 0.01294742f, 0.03048031f, 
    0.06952645f, -0.12069265f, 0.18593258f, -0.08490206f, 0.63015741f, -0.29254249f, -0.33229876f, 0.12362600f, 
    0.02048230f, 0.01860955f, 0.03705182f, 0.12841345f, 0.00275782f, -0.11387305f, -0.01625842f, -0.25833800f, 
    -0.04561337f, 0.08883491f, 0.09028325f, -0.05647412f, 0.05682363f, -0.03963805f, 0.03716484f, 0.06220075f, 
    0.01107883f, -0.06177550f, -0.20426628f, -0.14254726f, 0.20775937f, -0.29600117f, -0.26723686f, -0.16098167f, 
    0.06857748f, 0.13301852f, 0.00747723f, 0.04343186f, -0.00531187f, -0.03135882f, -0.01555606f, -0.00075535f, 
    0.03415787f, 0.02857141f, -0.01479851f, -0.09764014f, 0.09893479f, 0.06304443f, -0.00066543f, 0.02116274f, 
    0.04101712f, 0.01857275f, 0.03195524f, 0.08932267f, -0.05056434f, -0.01684349f, -0.15214917f, 0.01068135f, 
    0.07395763f, 0.10309439f, -0.05661534f, -0.03862083f, -0.03032378f, -0.10320488f, -0.05385134f, -0.22630993f, 
    -0.46255875f, -0.27589265f, 0.06711816f, 0.03771466f, -0.05873198f, -0.00503293f, 0.01970848f, 0.13497458f, 
    -0.07092705f, 0.01622512f, 0.01815519f, -0.00523960f, -0.09924079f, -0.14714064f, -0.10439886f, 0.02781038f, 
    0.00710894f, 0.05428223f, -0.01971455f, -0.05176990f, -0.01498758f, -0.02871254f, -0.04029762f, 0.05785834f, 
    0.18941893f, 0.00619775f, 0.07865267f, -0.00443305f, -0.10497692f, -0.09538860f, 0.11558674f, 0.03287880f, 
    0.09762508f, -0.00231302f, -0.04447377f, 0.03927652f, 0.06079156f, 0.21881986f, 0.05955718f, -0.15090989f, 
    0.18107115f, 0.07092455f, 0.06118118f, -0.09403813f, 0.07171023f, 0.01346343f, -0.01655219f, 0.00892127f, 
    0.08777250f, 0.11706226f, 0.16932832f, 0.13406156f, 0.13263643f, -0.12395341f, -0.01265415f, 0.08858790f, 
    -0.00756417f, 0.01592220f, -0.03140444f, -0.04465018f, -0.10720333f, -0.12177718f, -0.03577334f, 0.06361131f, 
    -0.01634638f, -0.03690454f, -0.04162319f, -0.01116135f, 0.18917020f, -0.33148572f, -0.09735020f, 0.06116125f, 
    -0.00284251f, 0.15473573f, 0.12815164f, -0.00617977f, 0.03104206f, -0.08554290f, 0.05739578f, -0.10773828f, 
    0.01685949f, -0.15163159f, -0.21679348f, 0.02530796f, -0.21929763f, 0.26956293f, 0.03097129f, -0.09725108f, 
    -0.09247512f, 0.00186928f, -0.01104089f, 0.07176387f, 0.03014563f, 0.01299489f, 0.03843678f, -0.03375364f, 
    -0.08202385f, 0.24002436f, 0.07236895f, -0.20967351f, -0.06718437f, 0.05267049f, 0.11106361f, -0.20706590f, 
    0.01753084f, -0.06136055f, -0.02040110f, 0.07326095f, -0.04381057f, 0.05247428f, 0.31835294f, -0.08024846f, 
    -0.06349478f, -0.13434905f, 0.05760926f, 0.02748865f, 0.00211942f, -0.10346233f, -0.14155400f, -0.05854783f, 
    0.23071577f, 0.09991244f, -0.03186290f, -0.06182611f, 0.03713311f, 0.01002333f, -0.04592886f, 0.05474389f, 
    -0.00287683f, 0.20427436f, 0.09603816f, -0.02850582f, -0.10543983f, 0.04806337f, -0.34705162f, -0.04805915f, 
    -0.02012691f, 0.03646883f, -0.02862692f, 0.02881311f, 0.10158312f, -0.21154167f, -0.02645231f, 0.09742001f, 
    -0.70016593f, 0.11548336f, -0.36678165f, -0.07886426f, 0.03296700f, -0.07837965f, -0.00204033f, 0.27537680f, 
    -0.02614344f, -0.13911480f, -0.10146760f, -0.02424759f, -0.08685383f, -0.18018499f, 0.02246157f, 0.02531974f, 
    -0.15874562f, -0.15317023f, -0.00241024f, -0.15993863f, 0.24001768f, 0.05301198f, 0.11087224f, 0.04770715f, 
    0.15051933f, -0.09394933f, 0.36462051f, 0.27696317f, 0.01279519f, 0.10243805f, 0.07944448f, 0.22436972f, 
    0.09073834f, -0.00501228f, 0.05940592f, -0.03235545f, 0.02932353f, -0.07671889f, -0.07626368f, -0.02338929f, 
    0.02976689f, 0.00838742f, -0.05631525f, 0.07136381f, -0.09280387f, 0.14824134f, 0.12439931f, -0.25307602f, 
    -0.22152461f, 0.15709130f, 0.11451618f, -0.26778346f, -0.05442834f, -0.06432696f, 0.06482864f, 0.07989463f, 
    0.09166318f, -0.03453293f, 0.02543979f, -0.24015634f, -0.06903824f, 0.11392111f, -0.15037155f, 0.00004703f, 
    0.08436658f, -0.16872601f, 0.04163338f, 0.09768351f, 0.02244690f, 0.16904905f, 0.14127146f, -0.04916320f, 
    0.15610921f, -0.20284477f, 0.05485980f, 0.19325565f, -0.04551066f, -0.07576962f, -0.01735962f, 0.04534440f, 
    -0.00056864f, 0.01411748f, -0.04176214f, -0.17153296f, 0.24705705f, 0.00410337f, -0.11232983f, 0.07052518f, 
    -0.05981382f, 0.04440526f, -0.13945122f, 0.05775483f, -0.11065291f, -0.00664486f, 0.12114624f, -0.22103269f, 
    -0.32221827f, 0.21135597f, -0.02248105f, -0.17163457f, -0.09310607f, -0.04945186f, 0.06138345f, 0.24581571f, 
    -0.14214033f, -0.06182712f, 0.01448739f, 0.15154824f, 0.00131109f, 0.17214909f, -0.06113379f, -0.08874765f, 
    -0.06769096f, 0.00494907f, -0.05074901f, 0.02259683f, -0.06027533f, -0.10884786f, 0.12168919f, 0.13723701f, 
    -0.09680841f, 0.20005573f, 0.04697861f, -0.28895780f, 0.02131038f, -0.02247803f, 0.12185445f, 0.08812693f, 
    0.01759247f, 0.12801151f, 0.06917878f, -0.02576421f, 0.07719387f, 0.04254300f, -0.54962432f, 0.16786695f, 
    -0.00725909f, -0.03745373f, -0.01930433f, 0.19921948f, 0.04781555f, -0.22926451f, -0.00940752f, 0.01389239f, 
    0.18847057f, -0.11975973f, -0.15387580f, -0.08679960f, -0.00069141f, -0.00388322f, -0.03404117f, 0.02610833f, 
    -0.07340591f, -0.25993368f, -0.03767162f, -0.35064602f, -0.11870050f, 0.00771655f, 0.20584366f, 0.13665795f, 
    -0.09567775f, -0.10071685f, -0.06203779f, 0.04961768f, 0.08497006f, 0.14949837f, 0.12178327f, 0.15098068f, 
    -0.02573584f, -0.06056094f, -0.04635450f, 0.21403623f, -0.06763900f, -0.08192177f, -0.11947640f, 0.04959179f, 
    0.02558544f, 0.02635612f, 0.02601953f, 0.17212632f, 0.05966517f, -0.03407286f, -0.05317210f, 0.01425727f, 
    -0.03155988f, 0.06453621f, -0.04072576f, 0.02017567f, 0.03052755f, 0.10500960f, -0.04509463f, 0.02743277f, 
    -0.07866959f, 0.01806729f, -0.11043856f, -0.13860834f, -0.03348439f, 0.10551490f, -0.07491227f, -0.00133716f, 
    0.25657985f, 0.08267409f, -0.01819839f, -0.10496742f, -0.00674797f, 0.03219959f, 0.33438450f, 0.04447861f, 
    -0.05018433f, -0.08886008f, -0.08937509f, 0.02959686f, -0.02958068f, -0.06159541f, -0.17992873f, -0.08611162f, 
    -0.08318774f, 0.11836503f, -0.27503660f, -0.19838245f, 0.09239154f, -0.01660242f, -0.03630843f, 0.04130834f, 
    0.04931131f, -0.02776488f, 0.09720685f, 0.06752965f, -0.64999777f, -0.17061965f, -0.24731022f, -0.28305060f, 
    0.05884386f, -0.06987365f, -0.01324372f, 0.10508274f, -0.00247936f, -0.01420177f, -0.00835838f, 0.04704587f, 
    -0.20586424f, -0.22724809f, -0.05603628f, 0.03801823f, -0.01938146f, -0.01912534f, -0.05910760f, 0.02399233f, 
    0.15574558f, -0.13222486f, 0.05334555f, 0.21143638f, 0.05481872f, -0.24974400f, -0.02027806f, 0.29239416f, 
    0.01971640f, -0.02909614f, -0.08711595f, 0.04501604f, 0.04215473f, -0.00595563f, 0.17203587f, 0.12683652f, 
    -0.03677317f, -0.11326605f, 0.08443307f, -0.05985312f, 0.01064669f, 0.04805795f, -0.06721509f, 0.06100084f, 
    0.12165011f, 0.06874397f, 0.00934874f, -0.03786945f, 0.11540842f, -0.20832191f, 0.16140828f, 0.00264344f, 
    -0.11762554f, 0.11229130f, 0.03231008f, -0.09926787f, 0.17097670f, -0.13557436f, 0.18963555f, 0.03096094f, 
    -0.10522581f, -0.05772854f, -0.13117199f, -0.03691909f, 0.07153163f, -0.01240883f, 0.16808434f, 0.08313885f, 
    0.05486527f, 0.03389872f, -0.01399457f, 0.01484570f, -0.32867372f, -0.04838850f, -0.13155288f, -0.37050411f, 
    0.11669122f, -0.03965001f, -0.02384398f, 0.09913111f, 0.04120192f, -0.08059779f, -0.02040360f, -0.16921385f, 
    0.01059988f, -0.03034291f, 0.04032145f, -0.00856999f, -0.12117299f, -0.03753358f, -0.02735288f, 0.04087587f, 
    -0.01492305f, 0.10856399f, -0.23483564f, -0.16001034f, -0.01938768f, -0.02871637f, 0.20937614f, 0.03486242f, 
    0.19212198f, -0.04010573f, 0.06474891f, 0.17147042f, 0.07949799f, 0.05329812f, 0.06029335f, 0.15554388f, 
    -0.16552569f, -0.07507649f, -0.07787706f, 0.17707936f, 0.03230736f, -0.07191817f, -0.07629437f, 0.12875631f, 
    0.01870998f, 0.09222497f, -0.05219256f, -0.14091429f, 0.14869696f, 0.04347787f, 0.02518308f, -0.19295514f, 
    0.02966739f, -0.02871944f, 0.04166251f, 0.12381453f, -0.01062210f, -0.03976081f, -0.04956171f, -0.05468054f, 
    0.13050652f, 0.18979242f, -0.01417208f, -0.06401764f, -0.03235751f, -0.00772690f, 0.05192950f, 0.01470517f, 
    0.02406790f, 0.01289338f, 0.00923312f, 0.06193039f, 0.01531725f, -0.17561020f, 0.38291636f, -0.22359245f, 
    -0.09362585f, 0.07530703f, -0.06822521f, 0.18544549f, 0.15254070f, -0.00275636f, 0.03968129f, 0.08846379f, 
    -0.15061089f, 0.01293016f, 0.01270762f, 0.01594304f, -0.04606587f, -0.12546466f, 0.07474593f, 0.12334357f, 
    0.15043826f, 0.16954435f, 0.08319875f, 0.08594830f, -0.02181957f, 0.17129703f, 0.15596683f, 0.18802187f, 
    0.02324804f, -0.00767048f, 0.02101363f, -0.06067551f, -0.05390541f, -0.04629248f, 0.19184467f, -0.04012102f, 
    -0.43851590f, -0.54507792f, -0.63621742f, -0.44508898f, -0.21170813f, -0.19484037f, -0.04763265f, -0.17874773f, 
    0.05395030f, 0.03048057f, -0.05653225f, -0.00525969f, 0.20530309f, 0.31624362f, 0.03659284f, 0.10382493f, 
    -0.06343760f, -0.03855031f, -0.08741795f, 0.08945891f, 0.14025626f, -0.09174138f, 0.13089716f, -0.06709918f, 
    -0.14841695f, -0.08744819f, -0.00215373f, 0.03795671f, 0.02506841f, 0.01734029f, 0.00971556f, 0.00278625f, 
    0.04521017f, -0.03230030f, -0.04983315f, -0.02025929f, -0.17296593f, -0.10724312f, -0.02392444f, 0.00082814f, 
    0.06190199f, 0.07217349f, 0.00767018f, -0.10250083f, -0.02332524f, 0.04298630f, 0.00597480f, -0.03109413f, 
    0.07253590f, 0.08675971f, 0.09396163f, -0.01628430f, 0.01996522f, -0.00668584f, -0.01678110f, 0.02871295f, 
    -0.01623735f, 0.04317427f, 0.01011117f, 0.09428374f, -0.25670335f, 0.09747909f, 0.34460837f, 0.23310213f, 
    -0.07923059f, 0.00778132f, -0.00354888f, -0.06162600f, -0.04929755f, 0.11186356f, 0.00961446f, 0.10073508f, 
    -0.39315009f, -1.01621926f, -0.56645525f, -0.26492828f, -0.03487148f, 0.19384320f, 0.04044001f, -0.25276458f, 
    0.00027147f, 0.07191228f, 0.02683566f, 0.03747490f, -0.17913936f, 0.09106915f, 0.19254053f, -0.12245871f, 
    -0.06032141f, 0.16365781f, -0.01207332f, -0.11140028f, -0.02935609f, -0.13995527f, 0.07504302f, 0.08204687f, 
    -0.33131897f, -0.58044642f, -0.37812024f, -0.30011675f, -0.01014801f, -0.30479729f, -0.08563295f, -0.19391018f, 
    0.00062907f, -0.08806492f, -0.07302500f, -0.07342201f, -0.33393231f, 0.33636081f, 0.27661291f, 0.22591680f, 
    -0.07924385f, -0.09011374f, -0.07046702f, 0.12520888f, 0.01370467f, 0.08782433f, 0.11253468f, 0.04008137f, 
    -0.21878764f, 0.05841675f, -0.17440142f, -0.17113601f, -0.04159984f, -0.02074765f, 0.03315727f, 0.02942564f, 
    -0.10110629f, -0.04552469f, 0.01921414f, -0.08951665f, -0.20804645f, -0.02355860f, -0.01082987f, -0.05230747f, 
    -0.26631254f, -0.25979027f, 0.00387523f, 0.12925725f, -0.06795137f, 0.01077534f, -0.02240216f, -0.02565753f, 
    0.31728885f, 0.21377084f, 0.14986168f, -0.14895886f, 0.00727691f, 0.00272766f, -0.06559696f, -0.24691060f, 
    0.07633241f, -0.08280363f, 0.03209644f, 0.12260196f, -0.06507276f, 0.08301517f, -0.30921912f, -0.19446214f, 
    -0.06117242f, -0.02493713f, 0.07273247f, 0.01021121f, -0.00058860f, 0.10958818f, 0.26599568f, -0.01820382f, 
    -0.10516119f, 0.00821793f, -0.09417894f, -0.24200879f, -0.06443525f, 0.00043139f, 0.09471220f, 0.13514236f, 
    -0.00901854f, 0.14204827f, 0.17523536f, 0.27166563f, 0.04744837f, 0.04431697f, -0.20642592f, -0.13470666f, 
    0.04230583f, -0.00145380f, 0.02374496f, -0.02238475f, 0.07303581f, 0.10257574f, -0.05554838f, -0.04897538f, 
    -0.19531815f, -0.17903858f, -0.21370764f, -0.38911730f, -0.07542950f, -0.13717534f, -0.13257249f, -0.08813300f, 
    -0.03257995f, -0.06378841f, -0.05346428f, -0.06337287f, 0.08961172f, -0.15551431f, 0.00168018f, -0.10931250f, 
    0.06174761f, 0.07095952f, 0.13684461f, -0.02030040f, 0.00198312f, 0.01229997f, 0.00760195f, -0.01291116f, 
    -0.20485479f, 0.07327371f, 0.16764943f, 0.07843336f, -0.11118900f, -0.01425407f, -0.11613863f, 0.06710330f, 
    -0.02180400f, 0.09557462f, 0.13107906f, -0.07127878f, 0.06131711f, -0.00396192f, -0.11312014f, -0.10459329f, 
    0.03230067f, -0.03325317f, 0.05709545f, -0.02523780f, -0.16158944f, -0.08665901f, -0.25739726f, -0.15415871f, 
    0.02220477f, -0.13363780f, -0.24086125f, 0.04092509f, 0.14346801f, -0.12629975f, -0.07238533f, -0.01824308f, 
    -0.04697952f, 0.00027626f, -0.04752451f, 0.06613942f, -0.71794134f, -0.58058649f, -0.46450669f, -0.03753536f, 
    -0.11549476f, -0.14775065f, -0.46337208f, -0.28951338f, -0.00647923f, -0.05139733f, -0.00995319f, 0.03284280f, 
    0.28975156f, -0.21248955f, -0.20002462f, -0.03982812f, -0.17141519f, 0.10058726f, -0.07257473f, 0.07460015f, 
    -0.04156508f, -0.01661247f, 0.00752590f, -0.13570885f, 0.20725554f, 0.06482858f, 0.02687154f, 0.07232148f, 
    -0.11319577f, -0.00935061f, 0.05632946f, 0.06944428f, 0.01770608f, -0.04904862f, 0.16135968f, -0.03455153f, 
    -0.24423522f, -0.09723062f, 0.04788346f, -0.10648234f, 0.06439628f, -0.09951924f, -0.03767800f, -0.14563937f, 
    -0.05930826f, 0.05116228f, 0.14146329f, -0.10292768f, -0.34957650f, -0.68062931f, -0.55681020f, -0.07557128f, 
    -0.19208702f, -0.09785812f, -0.09296624f, -0.22639018f, -0.06274841f, 0.01234718f, 0.00107504f, -0.03179118f, 
    -0.83596152f, -0.34159005f, 0.06045699f, 0.10847329f, 0.01704071f, -0.15681823f, -0.26203954f, 0.03307550f, 
    -0.01450374f, -0.03861855f, 0.09040629f, -0.01765958f, -0.18276355f, -0.58289689f, -0.52373016f, -0.02418417f, 
    -0.04462492f, 0.10948701f, 0.05600957f, 0.04964255f, 0.00421333f, 0.04782373f, 0.05810561f, 0.07136554f, 
    -0.26836479f, 0.00502524f, 0.37428975f, 0.03589988f, -0.19035609f, -0.12242300f, 0.03544486f, -0.14270371f, 
    -0.15351795f, 0.14939214f, -0.11805697f, 0.05635377f, -0.07437859f, -0.02194891f, -0.12890054f, -0.15972160f, 
    -0.00778918f, -0.02410434f, 0.02354514f, 0.00842182f, 0.00377455f, 0.14310960f, -0.16823064f, 0.03818144f, 
    -0.02550723f, -0.23699404f, 0.08748961f, 0.19176355f, -0.10224400f, 0.09694853f, 0.04433998f, -0.07269732f, 
    0.08646685f, 0.01907767f, 0.09255121f, -0.00798709f, -0.03000407f, -0.09298616f, -0.03811410f, 0.07820246f, 
    0.04148445f, -0.07578179f, 0.00851917f, -0.02705882f, -0.08467864f, -0.18363105f, 0.01787291f, 0.02786090f, 
    -0.25767747f, -0.35973939f, -0.03433973f, 0.11399568f, -0.08654372f, 0.10776725f, 0.13636969f, 0.10777789f, 
    0.03648643f, 0.00427259f, 0.07163072f, -0.04739973f, 0.02898148f, -0.11499480f, -0.03463191f, 0.02907752f, 
    -0.04324815f, -0.04058142f, 0.07002230f, -0.09457517f, -0.11023032f, -0.02686225f, -0.14302289f, 0.10630464f, 
    -0.92588884f, -0.69261062f, 0.27865979f, -0.06159841f, 0.01877154f, -0.03488602f, 0.00937575f, -0.20567498f, 
    0.01919300f, -0.00254430f, 0.03838762f, -0.00021030f, 0.21384297f, -0.01651814f, -0.38453034f, -0.04938683f, 
    -0.13470332f, 0.03147096f, 0.11622182f, 0.04654697f, 0.04704524f, 0.01261892f, 0.03433055f, -0.15480657f, 
    0.20152971f, -0.12030289f, -0.30170879f, -0.18039241f, -0.04004187f, -0.03940199f, -0.01134035f, 0.14671330f, 
    0.17456818f, -0.13157418f, -0.06030118f, 0.03617999f, 0.17533825f, 0.02356758f, -0.20877308f, -0.18856721f, 
    -0.20732769f, 0.17693527f, 0.26960668f, 0.20272930f, 0.14081693f, 0.03788596f, -0.08685338f, 0.04729643f, 
    -0.13897626f, -0.05629189f, 0.24121763f, 0.02126871f, -0.01907769f, -0.05148989f, 0.19275412f, 0.33742315f, 
    -0.06573480f, 0.07782856f, 0.04726230f, 0.00485554f, 0.05076598f, -0.21583079f, 0.04114552f, -0.01161487f, 
    0.02826335f, -0.03317748f, -0.07310105f, 0.06075862f, -0.01687158f, -0.04248234f, -0.03538378f, -0.03829245f, 
    -0.25596088f, -0.52522367f, 0.05229630f, 0.56757301f, 0.11556154f, 0.13306682f, -0.09342172f, -0.21797775f, 
    0.03196452f, -0.00750623f, -0.03289604f, -0.03291894f, 0.36147487f, -0.07168268f, 0.43384606f, 0.03071417f, 
    -0.11340653f, 0.03129490f, 0.16607015f, -0.10318616f, 0.07213432f, -0.05454801f, 0.10419058f, 0.05007626f, 
    -0.24713150f, 0.30427885f, -0.08087398f, -0.04834732f, -0.10549876f, 0.05393153f, -0.05426611f, 0.03330625f, 
    0.08369072f, 0.04213080f, 0.09201101f, 0.00105159f, -0.02815428f, -0.17240623f, 0.08195999f, 0.07627287f, 
    0.01057748f, -0.05117519f, 0.04613406f, 0.10907894f, 0.06410304f, -0.05402654f, 0.14517117f, 0.03707973f, 
    -0.08397434f, -0.06441164f, 0.31228676f, -0.11740863f, 0.03872067f, -0.11439044f, -0.11976555f, 0.02493349f, 
    -0.03224267f, 0.07386737f, -0.02576487f, 0.17437617f, -0.04412373f, 0.03242610f, 0.05297530f, 0.20347129f, 
    -0.00193477f, 0.04492575f, -0.01881910f, 0.03159329f, 0.02436963f, 0.03599422f, -0.01970235f, 0.15504931f, 
    0.05218910f, 0.21295823f, 0.15617776f, 0.12190883f, -0.10429943f, -0.16799469f, -0.02649563f, 0.07119944f, 
    -0.09457448f, 0.02023736f, 0.12459905f, -0.06589423f, -0.05415507f, -0.02750564f, 0.14996509f, 0.01662249f, 
    -0.04120149f, -0.01033570f, 0.08948671f, 0.08348904f, -0.00180316f, 0.03525433f, 0.07745172f, 0.15492201f, 
    0.16921274f, 0.03976581f, 0.06720471f, -0.22135338f, 0.13954343f, -0.03102340f, 0.07554296f, -0.05384452f, 
    0.08168834f, -0.00796656f, 0.03632173f, -0.01396012f, -0.40386152f, 0.03025291f, 0.50587428f, 0.22413050f, 
    -0.03651866f, -0.05561074f, 0.10111228f, 0.09803449f, 0.00001006f, -0.04721052f, 0.01478720f, 0.06300262f, 
    -0.03551425f, -0.03973311f, 0.13326186f, -0.11890402f, 0.00833401f, 0.00363140f, -0.00387223f, 0.06070321f, 
    -0.07403305f, 0.02604430f, -0.03802491f, 0.08815110f, 0.06356762f, -0.06050724f, -0.12339915f, -0.04414490f, 
    -0.11933096f, 0.09911032f, 0.13900436f, 0.17154412f, 0.02786446f, -0.02631484f, 0.01804762f, 0.02966064f, 
    0.05355197f, -0.05736945f, 0.01499080f, 0.08606226f, -0.01345852f, 0.07702193f, 0.02354783f, 0.00507744f, 
    0.11699376f, 0.04300622f, -0.02892778f, 0.16286866f, -0.14420177f, -0.04179967f, 0.12823638f, 0.00341418f, 
    0.04808549f, 0.09455866f, -0.12342769f, -0.00334460f, 0.16425923f, 0.10725879f, 0.01802382f, -0.13226523f, 
    0.10158703f, -0.35756868f, -0.06642752f, -0.04358716f, -0.03578335f, 0.08998023f, 0.29019740f, -0.20527484f, 
    -0.01240846f, -0.06171316f, -0.02662036f, -0.02889073f, 0.19394255f, 0.31539834f, 0.04935304f, 0.04033777f, 
    0.12552196f, 0.01633393f, 0.12805541f, -0.05723688f, 0.13830554f, 0.05431627f, 0.21094881f, -0.04665606f, 
    -0.09913999f, -0.08432526f, -0.02593961f, 0.26483864f, 0.17539302f, 0.11181459f, 0.00479170f, -0.16869161f, 
    0.06686144f, -0.11065343f, 0.04873614f, 0.00025510f, -0.01307028f, -0.21699232f, -0.17548862f, 0.19218402f, 
    -0.01881363f, 0.01167036f, 0.05572798f, 0.10415450f, 0.03522512f, -0.06652427f, 0.05291596f, -0.04721588f, 
    -0.07915948f, 0.03740045f, -0.08241651f, -0.11814595f, 0.03825923f, -0.03055817f, 0.10372324f, 0.09890502f, 
    -0.05177127f, 0.02323666f, -0.00035448f, 0.05996319f, -0.34614205f, 0.47753868f, -0.02399311f, -0.23683016f, 
    -0.13788603f, -0.03156097f, 0.04873741f, 0.16503149f, 0.02889821f, -0.05411800f, 0.02857969f, -0.02006969f, 
    -0.19608296f, -0.62816727f, -0.24369162f, -0.34513748f, -0.03547488f, -0.18428378f, 0.00016037f, -0.17929809f, 
    0.02567949f, 0.02300578f, 0.08214361f, -0.03324218f, 0.00732431f, -0.19595538f, -0.26284343f, 0.17852300f, 
    0.06933421f, -0.05429795f, -0.01800156f, 0.13182862f, -0.06565076f, 0.02223389f, -0.02111239f, 0.03065136f, 
    0.35987270f, -0.51698583f, 0.09936417f, -0.40374625f, -0.02499690f, -0.00336174f, -0.04879211f, -0.03786118f, 
    0.03760977f, 0.15632388f, -0.05312129f, 0.01521199f, -0.02331540f, 0.45577934f, 0.05083431f, 0.10006393f, 
    0.02115088f, 0.09802132f, -0.00103429f, -0.05002103f, -0.03000122f, 0.07061917f, 0.00552506f, -0.08903854f, 
    -0.26473528f, -0.24823464f, -0.16917527f, -0.20774743f, 0.15743746f, -0.06458544f, 0.00451731f, 0.09377856f, 
    0.00653581f, -0.04198702f, -0.02027299f, -0.00532467f, 0.04053545f, -0.16894063f, -0.11319581f, -0.11447529f, 
    0.01801788f, 0.02467933f, -0.04763006f, 0.01968940f, -0.16660143f, -0.15114281f, 0.01038232f, 0.11319093f, 
    -0.11660610f, 0.07969139f, 0.07039529f, -0.07473651f, 0.06919216f, -0.14981133f, 0.00677183f, -0.08951869f, 
    -0.03741446f, 0.00689179f, 0.03658793f, -0.01785599f, 0.06263441f, 0.03718969f, -0.05158312f, -0.17322415f, 
    -0.00860096f, -0.04310039f, -0.05234421f, -0.05510367f, 0.06040189f, 0.04067218f, 0.04108253f, -0.03769436f, 
    0.12933053f, -0.17979994f, 0.09110200f, -0.14416438f, 0.02188599f, -0.02481033f, -0.02663575f, -0.05210574f, 
    -0.08158460f, -0.05506952f, 0.01899688f, -0.20123698f, 0.25663185f, -0.19486219f, -0.11993279f, -0.25455505f, 
    -0.13594739f, -0.11047236f, -0.11549564f, 0.02720681f, 0.07926943f, 0.03537953f, 0.05943107f, 0.02318965f, 
    -0.67434341f, -0.04806958f, -0.23740280f, 0.29607821f, -0.06815977f, 0.12886874f, 0.03666640f, 0.08684782f, 
    0.00247834f, 0.03246789f, 0.02730213f, 0.05477247f, 0.04351842f, 0.05384183f, 0.04604882f, 0.05718680f, 
    -0.06527526f, -0.00874297f, 0.05669183f, 0.02472124f, -0.00274594f, 0.07426203f, 0.02189445f, -0.07188991f, 
    -0.28265148f, -0.18014638f, -0.06665938f, 0.35218105f, -0.00530159f, -0.02278337f, 0.07390247f, 0.10754026f, 
    -0.03011308f, -0.03420892f, -0.04474489f, -0.02309213f, 0.44107562f, -0.69794214f, -0.53227496f, -0.73442650f, 
    -0.02789186f, -0.11464068f, 0.06880310f, 0.05400016f, 0.08158717f, 0.00127066f, 0.14759126f, 0.08545934f, 
    0.06557139f, -0.03801489f, -0.06075926f, -0.09548091f, 0.01230754f, -0.03643316f, 0.01930171f, -0.03518843f, 
    0.06153356f, 0.07148562f, 0.03430057f, -0.00592239f, 0.31276697f, 0.03338699f, -0.08833404f, -0.07224964f, 
    -0.01573982f, -0.09938523f, 0.12748940f, 0.08319072f, -0.00283692f, 0.08136998f, 0.05808394f, 0.07746771f, 
    -0.13062152f, 0.11059700f, -0.06465429f, -0.03646646f, -0.02767377f, -0.01703696f, 0.11266410f, 0.07505145f, 
    -0.00559083f, -0.08087636f, -0.01194602f, 0.10135056f, -0.02416453f, 0.11338101f, 0.21997158f, 0.20035219f, 
    -0.00716737f, 0.09297621f, -0.07050440f, -0.04897862f, -0.00322314f, -0.12649907f, 0.06085888f, 0.01875036f, 
    -0.18078603f, -0.00838258f, -0.08444513f, 0.05489081f, -0.09278844f, -0.13713181f, -0.05840597f, -0.03895828f, 
    -0.01218943f, 0.04200536f, 0.02284245f, 0.06114742f, -0.03591515f, -0.15183365f, 0.05368599f, -0.17007624f, 
    -0.00180853f, 0.01859121f, 0.01478695f, -0.02488523f, 0.02406157f, -0.02543377f, -0.00680149f, -0.03409385f, 
    -0.34323823f, -0.04292242f, -0.06838945f, 0.31122407f, 0.00439442f, 0.12313002f, -0.05318490f, -0.02010657f, 
    -0.01146856f, 0.01538672f, -0.03619745f, -0.04899600f, -0.00535496f, 0.05463695f, 0.09522535f, -0.04866426f, 
    -0.03585755f, -0.04424765f, 0.02647529f, -0.01287360f, 0.06341704f, -0.01605445f, 0.05268780f, 0.07011776f, 
    0.50053251f, -0.15476367f, 0.01455962f, -0.21745008f, 0.16551940f, -0.01010449f, -0.20327272f, 0.04852902f, 
    -0.02157249f, -0.10653023f, -0.01720116f, -0.02956329f, 0.00523708f, 0.01710217f, 0.03243991f, -0.02675928f, 
    0.01760552f, -0.01548911f, -0.04560119f, 0.02679155f, 0.05000861f, -0.02371797f, -0.00059957f, -0.02980893f, 
    0.09971280f, 0.04616392f, -0.28604960f, 0.05771187f, -0.09727382f, -0.12091489f, -0.00771647f, 0.03100481f, 
    -0.05054252f, 0.03023621f, -0.02551819f, -0.02753595f, -0.48236376f, -0.29369745f, 0.03343375f, 0.02081756f, 
    0.09864340f, 0.06806406f, 0.09188460f, 0.11517850f, 0.00220842f, 0.03550364f, 0.00609317f, -0.05730599f, 
    0.18607381f, 0.06043106f, -0.28308639f, 0.14050967f, -0.01132162f, -0.00398233f, -0.08338992f, -0.04860635f, 
    -0.13324265f, -0.00977191f, -0.15722543f, 0.06070986f, -0.03249995f, 0.05609358f, 0.02810267f, 0.10451494f, 
    -0.00463517f, 0.11221097f, 0.01970959f, 0.00544346f, -0.04163713f, 0.05143977f, -0.07949279f, 0.05968228f, 
    0.23250856f, 0.02503940f, -0.17053778f, -0.18602520f, -0.10040866f, -0.01664382f, 0.03603732f, -0.10194837f, 
    -0.06630768f, 0.05447847f, -0.11605644f, -0.07503556f, -0.09866590f, -0.66756028f, 0.13322139f, -0.66106331f, 
    -0.01879041f, -0.15784441f, -0.05216694f, 0.33560491f, -0.02960939f, -0.00669303f, -0.05043496f, 0.05678408f, 
    -0.51023984f, -0.16421367f, 0.48334500f, -0.09185939f, -0.00145766f, 0.07055754f, -0.12057980f, 0.01556828f, 
    -0.16842276f, -0.04628414f, 0.04541935f, -0.07281981f, 0.34145397f, -0.39874211f, 0.20525771f, -0.25580910f, 
    0.00731770f, 0.09962313f, -0.01320876f, -0.12601578f, -0.04501846f, 0.03720256f, -0.05411899f, -0.07134364f, 
    0.21435934f, 0.14730377f, -0.02796618f, -0.16798159f, 0.11037558f, 0.15189709f, -0.07311621f, 0.02945130f, 
    -0.10151767f, 0.00605487f, -0.04971107f, 0.01740290f, -0.01718297f, -0.00068597f, 0.04723603f, -0.02423200f, 
    0.01355653f, 0.04507503f, -0.01079205f, -0.05081595f, 0.00360247f, -0.09062630f, 0.03479657f, -0.01930543f, 
    0.20990060f, 0.02292587f, 0.03052136f, -0.02130970f, 0.04200426f, 0.09687409f, 0.00885239f, -0.06715458f, 
    0.09444982f, -0.02488201f, 0.02876987f, 0.01256875f, 0.02748713f, -0.01523183f, 0.09808576f, -0.03401247f, 
    0.04944514f, 0.05298297f, 0.04929048f, 0.02771921f, -0.00567763f, 0.00809703f, -0.00163313f, -0.06087343f, 
    0.17779005f, -0.62591332f, 0.10234745f, 0.22850417f, 0.01250634f, 0.14467256f, -0.05466607f, -0.03871902f, 
    -0.08556174f, 0.10069580f, -0.06294515f, -0.03815572f, -0.01067383f, 0.07847251f, 0.02764207f, 0.03915379f, 
    0.02416938f, 0.04170835f, 0.02612031f, -0.04824968f, -0.27679747f, -0.03863430f, 0.10589804f, 0.05579477f, 
    0.00750616f, -0.45622334f, -0.19757244f, -0.13129495f, 0.05121106f, 0.13896465f, -0.05776963f, 0.11632364f, 
    0.06142489f, 0.00876877f, -0.00231475f, 0.08885891f, -0.10584594f, -0.10324499f, 0.14404160f, -0.02364679f, 
    -0.17783546f, 0.13455991f, -0.13442937f, -0.06715391f, 0.01392242f, 0.00175049f, 0.03231830f, 0.09520558f, 
    -0.12188786f, -0.25118706f, 0.06365723f, 0.12213794f, -0.04603038f, -0.01792685f, 0.02703009f, -0.00907793f, 
    -0.00717904f, -0.03458491f, 0.07382128f, -0.10124737f, -0.03300207f, 0.03028329f, 0.02005431f, 0.04756888f, 
    0.03930152f, 0.06494136f, 0.00219611f, -0.04888327f, -0.08189981f, -0.01152812f, 0.12756246f, 0.14217390f, 
    0.16053721f, -0.06567735f, 0.04130068f, -0.07512873f, -0.13236229f, 0.03182515f, 0.01667316f, -0.09002016f, 
    0.01945942f, 0.01232915f, -0.05505653f, -0.10531105f, 0.25451508f, -0.07862821f, 0.00589890f, -0.09111068f, 
    0.08236810f, 0.02086299f, 0.03564208f, 0.04969636f, 0.02417691f, -0.03026703f, -0.07285907f, -0.10890051f, 
    -0.21871087f, -0.13308205f, 0.10489091f, -0.07972340f, -0.01919455f, 0.01160303f, -0.00645577f, 0.03901635f, 
    0.02157151f, -0.04844861f, 0.01958288f, -0.05929716f, -0.16411106f, 0.43324170f, -0.30956373f, 0.30782628f, 
    -0.16655028f, 0.15150248f, -0.01618255f, -0.03771983f, -0.14508025f, -0.02502729f, -0.08411770f, -0.04195366f, 
    -0.05867876f, -0.48816887f, -0.22003153f, -0.10527674f, -0.18231042f, -0.11362585f, 0.03524234f, 0.06567552f, 
    0.16114278f, 0.02942445f, -0.04648621f, -0.00898973f, 0.30812630f, -0.08586659f, -0.05685196f, -0.39751408f, 
    0.05001165f, 0.10655038f, -0.08614852f, -0.06701567f, -0.12142675f, 0.09769634f, -0.09097491f, -0.11577903f, 
    0.23796444f, 0.12582351f, -0.05358552f, -0.16971718f, 0.01686207f, 0.06931846f, 0.01481160f, 0.03816396f, 
    -0.04374658f, 0.00637549f, 0.03344328f, 0.10368832f, 0.05985240f, -0.07752899f, -0.00301253f, -0.15923475f, 
    0.01314531f, 0.02579817f, 0.02963489f, 0.01735898f, 0.12034481f, -0.11596906f, 0.04430172f, -0.22290117f, 
    0.08273353f, -0.00344375f, -0.03376769f, -0.04778825f, 0.02089212f, 0.08617060f, -0.00918278f, -0.01493027f, 
    -0.11957465f, 0.02131144f, 0.07896486f, 0.08135006f, 0.10598024f, -0.12686414f, -0.05138406f, -0.13780116f, 
    -0.03852904f, -0.08822533f, -0.06497331f, 0.01387237f, 0.06373920f, 0.10248464f, 0.09634182f, 0.00484133f, 
    -0.11584014f, 0.18781278f, -0.01876669f, 0.03665326f, -0.03783565f, -0.07654407f, 0.01425431f, 0.00797626f, 
    0.02750850f, -0.02683133f, -0.01024330f, -0.07038515f, 0.52771294f, -0.35097471f, -0.31767344f, -0.13431036f, 
    -0.09628094f, -0.08155623f, -0.10271678f, 0.00391731f, 0.05163943f, -0.03041284f, 0.05164067f, 0.05851942f, 
    0.08993664f, 0.10399360f, -0.00982395f, -0.06178397f, -0.01694362f, 0.01828454f, 0.01308759f, -0.04974632f, 
    0.02286381f, -0.08712748f, -0.29999664f, -0.35721001f, -0.02058152f, 0.08267231f, 0.01569747f, -0.01595745f, 
    -0.08445612f, -0.08291011f, -0.15602821f, -0.12139131f, -0.06914067f, -0.01302030f, 0.00051352f, 0.02852502f, 
    0.08024798f, 0.00287882f, 0.02665560f, -0.01586883f, 0.02479041f, -0.03432270f, -0.05116431f, -0.02441712f, 
    -0.07976381f, 0.00727030f, 0.00503883f, -0.20293966f, 0.09401324f, -0.05802767f, 0.13354501f, -0.14026926f, 
    -0.04867895f, 0.09494804f, -0.04842545f, -0.00538184f, 0.01353027f, 0.00644603f, -0.16987705f, -0.03509033f, 
    -0.17023230f, 0.15459388f, 0.01138044f, -0.00788072f, -0.10751945f, -0.17291132f, -0.07832829f, 0.04427290f, 
    0.05538163f, 0.01207593f, 0.01786279f, -0.03143332f, -0.25869563f, 0.06780222f, 0.13282673f, 0.15659525f, 
    -0.04667570f, -0.05302092f, 0.16792618f, 0.02367996f, -0.11342271f, 0.01755754f, 0.03342204f, 0.03254353f, 
    0.06223601f, -0.02050396f, 0.01201599f, -0.08493880f, -0.04025909f, -0.01510626f, 0.02423298f, 0.01271192f, 
    0.00659270f, 0.09507090f, 0.06692927f, -0.04883688f, -0.17392440f, -0.16171767f, 0.09520839f, -0.12107468f, 
    -0.08021725f, 0.04353219f, -0.09974032f, -0.15109378f, 0.01424666f, 0.02738173f, -0.07122521f, -0.01924555f, 
    0.13761976f, 0.12028976f, -0.04408393f, -0.05910690f, 0.00905347f, 0.02953136f, -0.05747153f, -0.11227454f, 
    0.01125364f, 0.07668678f, 0.04412011f, 0.02577451f, -0.47587016f, -0.47057185f, 0.00191971f, -0.32177296f, 
    -0.02267181f, -0.04966836f, -0.09422258f, -0.03663098f, -0.05647796f, 0.04401192f, 0.00656706f, 0.06210590f, 
    -0.46391067f, 0.20039244f, 0.22347675f, 0.32925990f, -0.04171201f, 0.02362783f, 0.01547164f, -0.04551329f, 
    -0.00797020f, -0.02918885f, 0.01876860f, -0.08186713f, 0.20636094f, -0.35343197f, 0.22954570f, -0.24332000f, 
    0.08922295f, 0.01953661f, -0.04991773f, -0.06825738f, 0.02459409f, -0.04110843f, -0.03637763f, -0.02010330f, 
    0.19359669f, -0.06884415f, -0.17968631f, -0.18041053f, 0.06773461f, -0.03111086f, 0.04645963f, -0.02231679f, 
    -0.06333456f, 0.07639271f, -0.00363151f, -0.23641628f, -0.04193053f, 0.08715157f, 0.20893370f, -0.06361810f, 
    -0.03555603f, -0.09965826f, -0.03204272f, -0.00444629f, -0.02787440f, 0.00848847f, -0.01421461f, 0.10416160f, 
    0.04186410f, -0.26846492f, -0.39213860f, -0.12776972f, -0.19523923f, -0.07295213f, -0.08401263f, -0.10704879f, 
    -0.07613525f, -0.04573058f, -0.09822714f, -0.05565423f, -0.15654373f, -0.14628193f, -0.11972248f, -0.18259960f, 
    -0.02736704f, 0.02654856f, 0.03018388f, 0.01951558f, -0.06857957f, -0.12363364f, -0.04936535f, -0.08478969f, 
    -0.09809402f, -0.12337283f, 0.00883536f, 0.00781484f, 0.03346075f, 0.01948320f, -0.01491111f, -0.00306765f, 
    0.01935859f, 0.02819355f, 0.04860102f, 0.12234131f, -0.23951931f, 0.10121772f, 0.13805120f, 0.11878727f, 
    -0.04145921f, -0.15977035f, -0.06105937f, -0.13076067f, -0.04965214f, -0.02699241f, -0.03268847f, -0.08805136f, 
    -0.00007094f, -0.17774390f, -0.01116654f, -0.07438765f, -0.00925867f, 0.03598245f, 0.00062957f, 0.01786365f, 
    0.03073214f, 0.10299641f, -0.03541897f, -0.11462367f, -0.24991111f, -0.17397222f, -0.07134154f, 0.10520505f, 
    -0.05458105f, 0.10699420f, 0.09512325f, 0.18442209f, 0.01875049f, 0.02688930f, -0.03452635f, 0.02313833f, 
    -0.02589402f, 0.15993609f, 0.09101483f, 0.08349107f, 0.15616305f, 0.05783297f, -0.18795913f, -0.09010554f, 
    -0.10527490f, -0.00809202f, -0.03495414f, -0.00748917f, -0.09062087f, 0.02394807f, 0.06311904f, -0.06282232f, 
    -0.12148296f, 0.03986022f, -0.04852052f, -0.04899572f, -0.02492136f, 0.06858965f, 0.01726060f, 0.26474977f, 
    -0.37843651f, -0.38005492f, -0.09666227f, -0.15562239f, 0.01538836f, -0.21529743f, -0.05760345f, -0.14692838f, 
    -0.02663496f, -0.00173154f, 0.10389244f, 0.04136606f, -0.31678739f, -0.37296161f, -0.17076501f, 0.21634264f, 
    -0.00669228f, 0.06236934f, 0.14380169f, 0.14089744f, 0.05559425f, 0.08371542f, 0.11329845f, 0.13366234f, 
    -0.12993099f, 0.20061454f, 0.03778294f, -0.08510979f, -0.01450772f, -0.00605300f, 0.00143082f, -0.11794949f, 
    -0.03177256f, -0.13207044f, 0.00176935f, -0.00787053f, -0.20101801f, -0.28625384f, -0.28406009f, -0.25534922f, 
    0.06046087f, 0.10540186f, -0.01561713f, 0.04270515f, 0.12737434f, 0.04383791f, 0.06069235f, 0.15399241f, 
    -0.28134042f, -0.14218880f, 0.01846043f, 0.10500520f, -0.09373661f, 0.05636144f, -0.05129033f, 0.19311857f, 
    -0.04089229f, 0.06553806f, -0.11636103f, -0.13573758f, -0.44395900f, 0.11175775f, 0.06544233f, -0.08739704f, 
    -0.05798357f, 0.01569348f, 0.02305874f, 0.05421498f, 0.01164456f, 0.01687064f, 0.02451764f, -0.03436554f, 
    0.01618464f, -0.40215167f, -0.07288388f, -0.10911023f, 0.06518682f, 0.09117532f, 0.05494510f, 0.05364536f, 
    0.07978173f, -0.08030350f, -0.03605625f, -0.38890764f, 0.13300817f, 0.11452663f, 0.02085533f, -0.10732765f, 
    0.03281111f, 0.00439925f, -0.02429564f, -0.05178217f, 0.00193419f, 0.03772681f, -0.02099657f, 0.02900919f, 
    -0.08003005f, -0.01270836f, -0.06424143f, -0.04172304f, 0.12703378f, -0.12888582f, -0.02064769f, 0.06500610f, 
    0.08170671f, 0.01933334f, 0.07451738f, 0.10684810f, -0.20888171f, 0.06839050f, -0.00230235f, 0.03105986f, 
    -0.04988383f, -0.08526431f, -0.06888247f, -0.11328327f, -0.26143017f, 0.00357221f, -0.11580444f, -0.10135257f, 
    0.12021521f, -0.06321774f, -0.28992254f, -0.37175694f, 0.10396799f, -0.01850678f, 0.07687540f, 0.00324446f, 
    0.01075983f, -0.00387951f, 0.13822930f, 0.01029123f, -0.23242544f, 0.13899149f, 0.00761421f, -0.05594027f, 
    -0.04663148f, -0.06224152f, -0.07593441f, -0.07342407f, -0.04144196f, -0.03539543f, 0.00347913f, 0.00871524f, 
    0.30830970f, 0.14407672f, -0.03714495f, -0.08005830f, -0.18498705f, -0.02051898f, 0.01624922f, -0.05860985f, 
    0.09803340f, 0.05865849f, 0.02206547f, 0.05523808f, 0.07016627f, -0.56902790f, -0.25937337f, -0.17113715f, 
    -0.14741534f, -0.05592296f, -0.02438015f, -0.10201303f, 0.02424029f, 0.03991134f, -0.02433585f, 0.08961558f, 
    0.51566696f, -0.03616223f, -0.20511335f, -0.00650235f, 0.07196712f, 0.08500010f, 0.03971377f, -0.09034196f, 
    0.19974041f, 0.05071697f, 0.13681473f, 0.05701935f, -0.21620283f, -0.10342464f, 0.05173676f, 0.06234301f, 
    0.02577613f, -0.06169036f, -0.08146929f, -0.00757892f, -0.13549848f, -0.03185344f, 0.08546492f, -0.03915606f, 
    0.12194134f, 0.18899398f, -0.13106403f, -0.24722344f, -0.05954915f, -0.01500968f, 0.01730890f, 0.14162104f, 
    0.09172236f, 0.07965360f, 0.05697433f, 0.16328071f, 0.22744992f, 0.02131581f, -0.64895612f, -0.13435625f, 
    -0.12033183f, 0.05399699f, 0.17350869f, -0.26432127f, -0.02191834f, -0.05558236f, 0.01557306f, -0.01079454f, 
    -0.05070427f, -0.16212068f, -0.09099249f, -0.02184705f, 0.03888876f, 0.03913872f, 0.07015733f, 0.14101970f, 
    0.19466016f, -0.00348059f, -0.01436714f, 0.02879647f, 0.13225710f, -0.09951402f, -0.22830170f, -0.17532411f, 
    0.05315544f, 0.11274719f, 0.21558085f, 0.06642482f, 0.04816642f, -0.05723877f, -0.08237514f, -0.07014014f, 
    0.17816399f, 0.03278796f, -0.36112806f, 0.02353143f, -0.14035755f, 0.02349371f, 0.11037635f, -0.03883963f, 
    0.08280477f, -0.08973659f, 0.05105514f, -0.06953680f, -0.33474982f, 0.06739008f, 0.05473464f, 0.16120613f, 
    -0.03641139f, -0.02377000f, -0.02158205f, -0.01051379f, 0.00692565f, 0.07646075f, -0.01530406f, 0.05860375f, 
    -0.22684495f, -0.03368156f, 0.09676043f, 0.14048214f, 0.05432199f, 0.08458524f, 0.06161307f, 0.07826571f, 
    -0.09548387f, -0.00188627f, -0.08670996f, -0.19093613f, -0.05654317f, -0.06528281f, 0.01982617f, 0.11493497f, 
    -0.04878485f, -0.05780329f, 0.00375394f, 0.00630205f, -0.00055557f, 0.06539983f, 0.14640139f, 0.10504834f, 
    0.49680731f, 0.20922682f, -0.12502488f, -0.21796696f, 0.05520751f, 0.00305412f, 0.15980971f, -0.02271372f, 
    0.07357975f, 0.00848702f, 0.18674450f, 0.04489241f, -0.18353429f, -0.06189467f, 0.03778798f, 0.00394466f, 
    -0.05197388f, -0.01104357f, -0.02193733f, -0.08072728f, 0.00508596f, 0.02411119f, -0.08855800f, 0.05916081f, 
    -0.34484631f, -0.52027082f, -0.53384244f, -0.16593945f, 0.10384851f, 0.03207048f, 0.10513020f, 0.04603167f, 
    -0.03434345f, -0.03235292f, 0.08659492f, -0.05944061f, -0.19283123f, 0.08326373f, 0.00908613f, 0.06543857f, 
    0.20283408f, -0.04003422f, -0.04216598f, 0.14147949f, -0.08760158f, 0.06363184f, 0.10371082f, 0.11698735f, 
    0.16179568f, -0.09069613f, -0.01831889f, -0.06791139f, 0.15325041f, -0.06739179f, -0.09046175f, 0.06807380f, 
    -0.09638225f, -0.10195068f, -0.02915583f, -0.09264288f, -0.40489474f, -0.04074140f, 0.00983486f, 0.05029371f, 
    0.04448388f, 0.05420595f, -0.02394126f, -0.01818214f, -0.06855538f, -0.24025531f, -0.01408219f, -0.13873343f, 
    -0.08169706f, -0.15687829f, -0.05900500f, -0.04554697f, -0.08784559f, 0.13891332f, 0.05848244f, 0.09447886f, 
    -0.01273916f, -0.02458475f, -0.04329742f, -0.06668551f, 0.12318669f, 0.08793250f, -0.05127938f, -0.20893368f, 
    -0.06677829f, -0.12727967f, -0.05364037f, -0.01787265f, 0.03928568f, 0.03836242f, 0.09844386f, 0.04815847f, 
    0.13957964f, 0.00785085f, 0.07416688f, 0.07005952f, -0.07520791f, 0.00171157f, -0.04936348f, -0.12828828f, 
    -0.02710330f, 0.03354653f, -0.00154195f, 0.01469740f, -0.50639027f, -0.17358580f, 0.23845498f, 0.16848353f, 
    0.06646851f, -0.07876986f, -0.20856085f, 0.14882167f, 0.04515660f, -0.02786004f, 0.13317941f, 0.00354839f, 
    -0.25571492f, -0.23183981f, -0.09603657f, -0.06655201f, 0.04497062f, 0.08207606f, 0.08992714f, 0.10020250f, 
    -0.33304229f, -0.20102067f, -0.30059364f, -0.22728784f, 0.22036345f, 0.02225542f, -0.13117386f, -0.34229806f, 
    -0.02625430f, 0.00329305f, 0.01271445f, 0.09176219f, 0.14326990f, -0.01023592f, 0.23298484f, -0.07484418f, 
    0.02232457f, -0.07918065f, -0.07537122f, -0.11338675f, -0.04012329f, 0.01099238f, 0.01613684f, -0.07288507f, 
    0.02966625f, 0.10231199f, 0.09848675f, 0.17207570f, 0.07505906f, -0.04811780f, 0.12720262f, -0.04325699f, 
    -0.05424290f, -0.05788500f, -0.05870681f, -0.03162723f, 0.00277220f, -0.04108020f, -0.04866845f, 0.08643715f, 
    -0.20151095f, -0.21764219f, -0.01840753f, 0.13477027f, -0.07921578f, 0.07622419f, 0.06523357f, 0.01679232f, 
    0.21759035f, 0.03266632f, 0.16488560f, 0.09506013f, 0.17251076f, -0.01064980f, -0.18449390f, -0.00332453f, 
    0.07471228f, 0.09308223f, 0.08291816f, -0.00473634f, 0.04770343f, -0.11277360f, -0.00996701f, -0.14072466f, 
    -0.44621196f, 0.02499551f, 0.16640124f, 0.17524126f, -0.08953793f, 0.00252338f, -0.09163743f, -0.00050816f, 
    -0.01594537f, 0.05120749f, 0.02429980f, 0.07835022f, -0.18486191f, -0.31832847f, -0.30360529f, 0.12220193f, 
    0.01218531f, 0.10456713f, 0.16843989f, 0.13180853f, 0.01481717f, -0.04521873f, 0.01063395f, -0.04728958f, 
    -0.00890148f, -0.00780362f, -0.11113715f, -0.19654141f, -0.03978871f, 0.06424151f, 0.00983387f, -0.01608849f, 
    0.06039139f, 0.12914485f, 0.02914203f, 0.05702455f, -0.15151417f, -0.07450483f, 0.08036081f, 0.17950286f, 
    0.13872632f, -0.07865539f, -0.00153232f, 0.08623701f, 0.05933504f, -0.00000151f, -0.01530680f, -0.01601521f, 
    0.07507922f, -0.03265872f, -0.01837484f, -0.02963382f, -0.05445370f, -0.03169969f, -0.03173929f, 0.02544405f, 
    -0.04679893f, -0.05566301f, -0.08427734f, 0.04266541f, 0.10144199f, 0.04143230f, -0.01780090f, -0.14046033f, 
    0.02036911f, -0.07063127f, -0.02554598f, 0.06098719f, 0.06838300f, 0.08518095f, 0.10791308f, 0.16061945f, 
    -0.28023973f, 0.01223166f, 0.05256401f, -0.02890322f, 0.01842629f, 0.01546899f, -0.20560226f, -0.08374487f, 
    -0.01731492f, 0.05796893f, 0.07513093f, 0.01596593f, -0.39456415f, -0.31016731f, 0.25811777f, 0.15469553f, 
    -0.03317368f, 0.08777899f, 0.13117319f, -0.01922688f, -0.01448403f, 0.11532547f, 0.05251691f, 0.06484215f, 
    0.05878966f, 0.02478637f, 0.00805750f, -0.13722201f, -0.06968642f, -0.10381650f, -0.02489200f, -0.14756067f, 
    -0.13915941f, -0.05448710f, -0.16229029f, 0.06731003f, 0.13770528f, 0.00098533f, 0.09758991f, 0.00432136f, 
    0.13927217f, 0.03964664f, 0.02331086f, -0.05030664f, 0.06790316f, 0.14270501f, 0.13003969f, 0.00885345f, 
    0.25060666f, 0.07425934f, -0.05369528f, -0.02552895f, -0.05486017f, -0.02174373f, 0.06042506f, -0.03338638f, 
    -0.02995383f, -0.04961903f, -0.14531560f, -0.04023730f, 0.16738796f, -0.21214771f, -0.28775278f, -0.09529928f, 
    -0.01712982f, 0.00188838f, 0.07086991f, 0.04954555f, -0.06301288f, -0.12524979f, 0.02174786f, -0.06688680f, 
    -0.20249312f, -0.21398194f, -0.03713302f, -0.26711583f, 0.13791133f, 0.03986130f, -0.04403363f, 0.09160085f, 
    0.03244538f, 0.06990507f, 0.10485747f, 0.08911862f, 0.27425990f, 0.11830235f, -0.04590612f, -0.19477881f, 
    0.05440773f, -0.04195265f, -0.07010255f, 0.02446314f, 0.09633691f, 0.11943955f, 0.03914451f, 0.15548763f, 
    0.18599561f, -0.20032078f, 0.30784494f, 0.39994314f, 0.04945008f, 0.01315896f, -0.02979606f, -0.05750444f, 
    0.04530295f, 0.14859220f, 0.21264236f, 0.04712698f, -0.68884873f, -0.22235002f, -0.49324083f, -0.00774812f, 
    0.03263520f, -0.08044866f, 0.06743725f, 0.07409549f, -0.02682948f, -0.01562928f, -0.01272842f, -0.00506364f, 
    -0.30164582f, 0.00733632f, 0.20966348f, -0.11664717f, -0.03046620f, -0.08858888f, 0.05695673f, 0.21583612f, 
    0.03153461f, 0.04910656f, -0.01296329f, 0.00925305f, 0.14653875f, 0.17823839f, 0.35149476f, 0.00665835f, 
    0.01701776f, -0.12052434f, -0.11311428f, -0.15676299f, 0.01368254f, 0.03739670f, 0.06357853f, 0.15252343f, 
    0.02448745f, -0.12823097f, 0.04771571f, -0.21227036f, 0.08642013f, -0.07379745f, 0.04445287f, 0.04836328f, 
    0.02289485f, -0.09480894f, -0.06548408f, -0.09362809f, -0.07268575f, -0.29779989f, -0.14631058f, -0.00940190f, 
    0.11841919f, 0.12602161f, 0.08044181f, 0.16780227f, -0.00699345f, -0.01429117f, 0.00915459f, -0.03375884f, 
    0.11229374f, -0.12275928f, 0.19739215f, 0.23475607f, -0.02123167f, 0.04052702f, -0.12065588f, -0.16671693f, 
    -0.00311555f, -0.01895907f, 0.12274729f, -0.08606096f, 0.23853110f, 0.15200524f, 0.10482389f, -0.00536851f, 
    -0.02559862f, -0.02429342f, -0.13466413f, -0.10228923f, 0.09023526f, -0.00672385f, 0.01858796f, 0.14203206f, 
    -0.36776966f, 0.17835049f, -0.59551895f, 0.17595243f, -0.17863962f, -0.01422002f, 0.13599770f, -0.06065295f, 
    0.00691613f, 0.05747637f, -0.04261075f, -0.02565599f, -0.23174430f, -0.10328146f, -0.05574322f, 0.24271633f, 
    0.22450139f, -0.02869198f, -0.13904837f, 0.13862136f, 0.13718131f, 0.01579710f, -0.19501124f, 0.05775158f, 
    -0.02466591f, 0.10461763f, -0.09404242f, -0.21235088f, -0.16580413f, -0.01243873f, 0.26867497f, 0.23788422f, 
    -0.03684306f, 0.09349819f, 0.06297698f, -0.06833873f, 0.36635348f, -0.01421624f, 0.30349591f, 0.04291296f, 
    0.09625936f, -0.27706027f, -0.12567733f, -0.11374199f, -0.04990430f, -0.04658306f, 0.06441911f, -0.00248747f, 
    -0.07188073f, -0.28673148f, -0.44815904f, 0.01025491f, 0.21834965f, 0.09192476f, 0.10186512f, 0.03808236f, 
    0.11231446f, -0.10259069f, 0.10078271f, -0.02294265f, -0.00876555f, 0.11016881f, 0.05525368f, -0.07747049f, 
    0.14694743f, -0.11921022f, -0.10436754f, 0.04683682f, -0.13765110f, -0.18738821f, -0.00162813f, -0.05067306f, 
    -0.02457563f, 0.30876747f, 0.24485989f, -0.31691390f, -0.01358950f, 0.01313851f, 0.05104866f, 0.16631503f, 
    -0.02271205f, 0.08594265f, -0.01245945f, -0.05091487f, -0.06691810f, -0.04944582f, -0.08342289f, 0.06608659f, 
    0.05201898f, -0.01053824f, -0.00811709f, -0.04953946f, 0.03747926f, 0.00973050f, 0.12115571f, -0.02192123f, 
    0.09711336f, -0.12849826f, 0.04725920f, 0.00784758f, 0.07325969f, -0.00334948f, -0.00494201f, -0.03406966f, 
    0.03144510f, 0.05857127f, 0.09407961f, 0.14298928f, 0.03013490f, -0.31915018f, 0.03924812f, -0.08634045f, 
    0.01730028f, 0.07384837f, 0.01724465f, -0.03046106f, 0.04341539f, -0.04600660f, -0.04167579f, -0.11178938f, 
    -0.00114743f, 0.17564586f, -0.29029655f, 0.09918119f, -0.00228311f, -0.07950976f, 0.09213436f, -0.07529274f, 
    -0.02193484f, -0.05631175f, -0.00424808f, -0.06548852f, -0.04869556f, -0.05616088f, -0.05634737f, -0.02725995f, 
    -0.01322271f, 0.13404815f, 0.18049118f, 0.08358829f, 0.10400917f, 0.08263937f, -0.04065263f, -0.01611182f, 
    -0.23248030f, 0.02648354f, 0.55622768f, 0.38890103f, 0.06832461f, 0.00289016f, -0.17205288f, -0.09936265f, 
    0.19930121f, -0.07504912f, -0.03771435f, 0.11158132f, -0.14392143f, -0.09717882f, -0.10215910f, -0.01556042f, 
    0.06183212f, 0.02219200f, 0.18023035f, 0.11491372f, 0.10913843f, 0.01091643f, -0.03202259f, -0.02614218f, 
    -0.52736449f, -0.23465714f, 0.17262128f, 0.01438992f, 0.13534470f, 0.17374268f, -0.03605289f, 0.11918177f, 
    -0.08476049f, -0.05778529f, 0.05028167f, -0.07301333f, -0.20830321f, -0.06021368f, 0.06120894f, -0.16589268f, 
    -0.09358441f, -0.03461841f, 0.06376344f, 0.17522304f, -0.00088862f, 0.02255616f, -0.00801419f, 0.02027496f, 
    -0.61451155f, 0.03560598f, -0.10000204f, 0.24504901f, 0.08290352f, -0.05508498f, -0.01277708f, -0.13967462f, 
    0.03533689f, -0.02951329f, -0.10595116f, -0.11962967f, -0.15515740f, 0.19531876f, -0.39721084f, 0.00637555f, 
    0.05625366f, -0.13389547f, 0.10870628f, -0.15371236f, 0.11117396f, 0.07713996f, 0.10387495f, -0.03340670f, 
    -0.22521402f, 0.01505855f, 0.10614378f, 0.47689798f, 0.08889097f, 0.20784684f, -0.30158556f, 0.20830995f, 
    0.05379061f, -0.07627365f, -0.03167392f, -0.06729218f, -0.38549334f, -0.24709344f, 0.02613236f, -0.03065927f, 
    -0.07622179f, 0.00811650f, -0.18384619f, 0.18138969f, 0.08660754f, 0.02447045f, 0.05117654f, 0.00459958f, 
    0.32046580f, -0.33317375f, 0.03871358f, -0.24592166f, 0.04027213f, -0.10563498f, -0.03299451f, 0.21637222f, 
    -0.08769222f, -0.00634852f, -0.03945754f, -0.08772959f, 0.06133391f, 0.11583212f, 0.12450091f, 0.30325714f, 
    -0.13984947f, 0.05175059f, -0.04344762f, -0.14839503f, 0.14560753f, -0.01538300f, 0.07648427f, 0.02198012f, 
    -0.19583741f, -0.20705131f, -0.12957443f, 0.32482991f, 0.11091785f, -0.15108126f, -0.27916420f, 0.16656213f, 
    0.11098911f, -0.09910416f, 0.02867183f, 0.06198893f, 0.19485544f, -0.02290950f, -0.03743983f, -0.06754500f, 
    0.02525186f, -0.09695392f, 0.04828905f, -0.06592955f, -0.04376465f, 0.01861655f, -0.24367893f, -0.07439780f, 
    -0.42459902f, 0.16706207f, 0.00062796f, -0.08135010f, -0.16213357f, -0.00279609f, -0.11317596f, -0.15136859f, 
    0.16823070f, -0.06959695f, -0.04236436f, 0.03933566f, 0.15566081f, -0.18270126f, 0.18252993f, -0.19905309f, 
    0.01696146f, 0.04083987f, 0.01290812f, -0.02504374f, 0.02586206f, 0.03214583f, -0.10325217f, 0.15009345f, 
    0.15003622f, -0.37284723f, -0.02811496f, 0.02511954f, 0.07155535f, 0.01065296f, -0.17114818f, -0.26997045f, 
    -0.04027573f, -0.01417129f, -0.03407611f, -0.00794815f, -0.01829949f, 0.00228577f, 0.03386969f, -0.09166367f, 
    -0.03552466f, 0.15717770f, 0.04026371f, 0.06570511f, 0.08049542f, 0.09553170f, -0.08620446f, 0.10928909f, 
    -0.41241533f, 0.05021704f, 0.04767036f, -0.25943875f, -0.19515942f, -0.07915695f, 0.08016453f, 0.06594026f, 
    0.07665564f, 0.06735100f, 0.11142515f, 0.05795996f, 0.06331157f, 0.29557586f, -0.49640360f, 0.07446118f, 
    -0.03298552f, 0.10433733f, 0.15744764f, -0.11074024f, 0.08596079f, -0.06232957f, -0.11678144f, 0.06772400f, 
    0.30119401f, 0.30537182f, -0.08568399f, 0.04160649f, -0.15641005f, -0.08247931f, 0.00372047f, 0.01579374f, 
    0.02254124f, 0.09264223f, 0.05525473f, 0.07665915f, -0.21227725f, 0.25234652f, -0.40213615f, 0.06728404f, 
    0.16252060f, -0.27781612f, 0.07815932f, -0.14419465f, -0.01990375f, 0.08205518f, 0.02255879f, 0.10829710f, 
    0.16931662f, -0.03218867f, -0.03704128f, 0.02408669f, -0.10660253f, -0.10127132f, -0.10470617f, -0.26821506f, 
    0.10273914f, 0.01210279f, 0.04655821f, -0.06247933f, -0.13237992f, 0.23167893f, -0.02012873f, 0.06753676f, 
    0.04972134f, 0.03449919f, 0.06702019f, 0.05256339f, -0.06173864f, -0.07846103f, 0.01280031f, -0.09209164f, 
    -0.03336175f, -0.12702212f, 0.08829574f, -0.45111352f, -0.22982533f, 0.12730534f, -0.08277836f, 0.09879103f, 
    0.02780318f, 0.00968800f, -0.03431400f, 0.00913219f, -0.52252001f, 0.13240571f, -0.76574534f, -0.23649870f, 
    0.12847736f, -0.17961879f, 0.05211291f, 0.12656689f, 0.02826076f, -0.07450808f, 0.10137989f, 0.11439223f, 
    -0.07736135f, 0.02074094f, 0.37039223f, 0.06506807f, 0.04475579f, -0.17934066f, -0.07418568f, -0.10338084f, 
    -0.06294471f, 0.02853061f, 0.04784176f, -0.00797736f, 0.03017570f, 0.10642158f, 0.00442624f, 0.16230728f, 
    0.00403744f, -0.07011946f, -0.21575865f, -0.18486273f, -0.24945478f, -0.04347833f, 0.00110594f, -0.00513902f, 
    -0.07481635f, -0.05621905f, -0.01702981f, 0.22148380f, 0.01199598f, 0.14528947f, -0.09994371f, -0.02260651f, 
    -0.13733079f, -0.13598765f, -0.08190666f, -0.08215339f, 0.09300885f, -0.24499932f, 0.18222705f, 0.04069110f, 
    0.03475501f, 0.02645687f, -0.05832578f, -0.13414386f, -0.06420919f, -0.03704237f, 0.01873430f, 0.06662163f, 
    0.20325457f, -0.08137696f, 0.11965479f, -0.22594684f, 0.02739795f, -0.05476761f, -0.08316197f, -0.01504583f, 
    -0.24026765f, 0.04212600f, 0.00966780f, 0.04596727f, -0.21482201f, -0.14985888f, -0.08874529f, -0.07078671f, 
    0.05333887f, 0.10640375f, -0.11928476f, 0.05361090f, 0.06318463f, 0.11086074f, 0.01803457f, 0.08161905f, 
    -0.17082600f, -0.11255981f, 0.09231845f, -0.01463510f, -0.02269256f, 0.06132426f, 0.06479613f, 0.00929554f, 
    0.02028922f, -0.00370487f, -0.10673854f, -0.08251575f, -0.09446430f, -0.00282815f, -0.09206636f, -0.43773332f, 
    -0.20894904f, -0.10438420f, 0.09427965f, -0.24334049f, 0.08142959f, 0.02593607f, 0.06096446f, 0.01935808f, 
    -0.20787926f, 0.10357109f, 0.12793075f, 0.18764178f, 0.05586445f, 0.01553675f, -0.08050732f, -0.07317892f, 
    -0.02947158f, 0.15337494f, -0.05624518f, 0.01152093f, 0.05122824f, 0.07101739f, -0.50368345f, 0.05020971f, 
    0.01332815f, -0.03349128f, 0.12813985f, 0.03788038f, 0.03865566f, -0.15988703f, -0.06545085f, -0.01243242f, 
    -0.08141959f, -0.18852241f, 0.17110813f, -0.10268830f, 0.05631323f, 0.07712160f, -0.09045652f, -0.12458672f, 
    -0.09522920f, 0.07743047f, -0.01403273f, 0.04716347f, 0.15016177f, -0.26137057f, 0.10526150f, 0.09648310f, 
    0.06412213f, 0.01229008f, -0.23137711f, 0.07105898f, -0.16843835f, -0.05944519f, -0.03966475f, 0.04419829f, 
    0.20718510f, 0.12778637f, -0.31772247f, -0.07739905f, 0.09213425f, 0.13215324f, 0.08030908f, 0.10895984f, 
    0.05506550f, -0.11677406f, -0.11172448f, -0.04908409f, 0.06881677f, -0.26341453f, 0.07595265f, -0.42285839f, 
    -0.07808051f, -0.09599196f, -0.04937272f, 0.09299576f, -0.01175079f, 0.07505850f, -0.02778981f, 0.03734522f, 
    -0.07209517f, -0.35319412f, 0.25505599f, -0.23731628f, 0.01135292f, 0.13346115f, -0.05265380f, 0.01403396f, 
    -0.12274715f, 0.04318195f, 0.02690549f, 0.17798296f, 0.14685009f, -0.34185562f, 0.02002363f, -0.27651712f, 
    -0.02539283f, -0.01681564f, 0.02782500f, 0.05498649f, -0.03454153f, -0.10525113f, -0.04873934f, -0.09628395f, 
    -0.27106467f, -0.21051970f, -0.17320660f, 0.13004251f, 0.05836002f, 0.14713165f, 0.03607705f, -0.01469016f, 
    -0.03977723f, -0.08779354f, 0.01297302f, 0.03694791f, 0.06502273f, -0.12786269f, 0.22354858f, 0.00638259f, 
    0.07044371f, -0.20801176f, -0.07673844f, -0.08435030f, -0.04221398f, 0.06314606f, 0.05626130f, 0.09116048f, 
    0.09933183f, -0.01723125f, -0.10552341f, -0.05796001f, -0.12655868f, 0.12048030f, 0.05379148f, 0.07445186f, 
    0.10345085f, 0.01297768f, -0.08345783f, -0.02028462f, 0.15704061f, -0.54902202f, 0.02912682f, 0.07043228f, 
    0.04629885f, 0.04195384f, -0.04882136f, 0.03096231f, -0.01288517f, -0.06888952f, -0.13277745f, -0.12034162f, 
    -0.32478634f, 0.28427947f, -0.18467689f, -0.12988925f, -0.02479262f, 0.06251991f, -0.06222519f, 0.08457226f, 
    -0.02990180f, -0.32932970f, -0.08964571f, -0.48941979f, 0.21376629f, 0.31201154f, 0.49836046f, -0.14667192f, 
    0.01661366f, 0.09213945f, -0.07528168f, -0.10031245f, 0.12869166f, -0.14748032f, -0.22712344f, 0.01888424f, 
    -0.17420113f, -0.34767494f, -0.09870026f, 0.14455105f, 0.09943450f, 0.06036294f, -0.16018488f, -0.09311832f, 
    -0.05478107f, -0.02838397f, 0.07869087f, -0.02688561f, -0.20285338f, 0.11372785f, -0.08533499f, -0.11060144f, 
    0.09562006f, 0.11249714f, 0.00458529f, -0.05194029f, -0.11793198f, -0.13795778f, -0.07275739f, -0.02812309f, 
    -0.15286525f, 0.02189852f, -0.04770054f, 0.03952225f, 0.00398321f, 0.08667463f, -0.01236723f, 0.21262749f, 
    -0.10680043f, 0.07582270f, 0.11277492f, 0.08021141f, -0.17766714f, -0.17228314f, 0.06541324f, -0.03938523f, 
    -0.05293385f, 0.10836615f, -0.21688432f, -0.02156748f, -0.01007761f, -0.16058967f, -0.08949121f, -0.01894114f, 
    -0.11613584f, 0.18599100f, 0.13299216f, 0.15052091f, -0.02841832f, -0.12553649f, -0.09901782f, -0.00818898f, 
    0.05980241f, 0.16391429f, -0.12008081f, 0.04335309f, 0.00900823f, 0.16873060f, 0.09907421f, 0.02961197f, 
    0.09432594f, -0.07942203f, -0.14816473f, -0.03075675f, -0.09391323f, 0.12069816f, 0.08623090f, -0.30208740f, 
    0.18789379f, -0.24027152f, -0.15809789f, -0.05654487f, -0.00197582f, -0.07781823f, -0.03823930f, -0.18613486f, 
    0.03430251f, 0.07113680f, -0.11159783f, -0.04384720f, -0.28060815f, 0.36397231f, 0.17389075f, 0.05223950f, 
    -0.04219627f, 0.02696627f, 0.09853475f, 0.03600227f, -0.15843350f, 0.01562174f, 0.10246522f, 0.13179047f, 
    -0.07717068f, -0.39291114f, -0.24413994f, 0.13260552f, -0.09343199f, -0.07543325f, -0.06508488f, -0.03698533f, 
    0.12004999f, 0.04945193f, 0.02083989f, 0.05035342f, 0.20247665f, -0.05648702f, 0.06250612f, 0.04445875f, 
    -0.19799128f, -0.12441892f, 0.10115749f, -0.03846904f, 0.00761858f, 0.02505675f, -0.06679566f, -0.04447629f, 
    -0.32486892f, -0.11997658f, -0.01156523f, -0.19556832f, -0.17418960f, -0.12890217f, -0.04125571f, 0.06960691f, 
    -0.16124713f, 0.05456249f, 0.03927673f, -0.18586710f, 0.05937791f, 0.18588690f, 0.17458408f, -0.05156128f, 
    -0.06135284f, -0.00953336f, 0.05642189f, 0.06026687f, 0.14672491f, 0.16630796f, 0.18706864f, 0.16967511f, 
    -0.07746026f, -0.19241895f, 0.11025207f, 0.21898240f, -0.13857277f, 0.01839655f, 0.01500581f, 0.08563625f, 
    -0.28302854f, -0.11478843f, -0.07009571f, -0.20168184f, -0.11351924f, -0.08392506f, -0.10098621f, -0.00759039f, 
    0.04953078f, 0.02979598f, 0.03967279f, 0.01765630f, -0.09502680f, -0.19879997f, -0.16639027f, -0.06527812f, 
    -0.12698779f, 0.16927865f, -0.06809242f, 0.13320751f, 0.04133902f, 0.08264408f, 0.00282856f, 0.11219482f, 
    -0.03577945f, -0.17748162f, -0.35515475f, -0.33621314f, -0.26364082f, 0.10744238f, -0.24336530f, 0.40478265f, 
    0.01484796f, 0.05193366f, -0.13572729f, 0.13729332f, -0.00833998f, -0.07258914f, 0.01628407f, 0.03081574f, 
    0.05204837f, 0.04707222f, -0.17883991f, 0.07857376f, -0.09767048f, 0.05300770f, 0.17362960f, 0.02556363f, 
    0.02167413f, 0.04682300f, -0.10304728f, 0.14277947f, 0.08385763f, 0.03587738f, -0.04281039f, 0.05611654f, 
    -0.03437247f, -0.05945892f, 0.05321842f, 0.03214836f, -0.19325320f, -0.07175039f, -0.16508228f, -0.21535105f, 
    -0.56404090f, 0.13032617f, -0.05073063f, -0.23972446f, -0.08591043f, -0.06529742f, -0.01055341f, -0.07788611f, 
    -0.21435808f, -0.05632882f, -0.11911008f, -0.20728685f, -0.00053577f, -0.23969151f, -0.29142556f, -0.25062633f, 
    -0.12561332f, -0.12518995f, -0.09017162f, -0.00335081f, -0.08723266f, 0.08155062f, -0.02864083f, -0.01546565f, 
    -0.10760377f, -0.13565397f, 0.11423141f, 0.00667139f, -0.17457494f, 0.06904215f, -0.08443734f, -0.00775977f, 
    0.01739039f, -0.04176692f, 0.02151822f, 0.17293541f, -0.26426679f, 0.11056118f, -0.14296490f, 0.18280928f, 
    0.01302928f, 0.02100685f, -0.13885149f, 0.12648343f, 0.02921516f, 0.12648432f, -0.02602363f, 0.05486240f, 
    -0.11056609f, -0.06170032f, 0.28753129f, -0.12790658f, -0.14214149f, 0.10601726f, -0.16730529f, 0.02909509f, 
    -0.04979721f, 0.02793513f, -0.02901830f, 0.07815370f, -0.00068736f, -0.03242311f, -0.01201170f, -0.08451532f, 
    -0.20306210f, 0.01845357f, 0.09644137f, 0.04122858f, -0.05121345f, -0.03523993f, -0.14651799f, -0.00493693f, 
    -0.09449592f, 0.27607507f, 0.06577159f, 0.04668139f, 0.07015621f, 0.08755108f, 0.02130464f, 0.00336007f, 
    0.07394928f, 0.02192462f, 0.01064554f, 0.22973001f, -0.22885203f, -0.52208149f, -0.12754965f, 0.15489045f, 
    -0.05468632f, -0.01651224f, -0.22804970f, 0.07486846f, -0.05591755f, 0.03063809f, 0.00513249f, -0.13283765f, 
    -0.19135161f, 0.34889340f, -0.30601925f, 0.35338926f, -0.03820212f, -0.04450296f, 0.00584799f, 0.05649354f, 
    0.02969804f, 0.11018708f, 0.15501860f, 0.12608041f, -0.20607667f, 0.13194899f, -0.39276156f, -0.01259494f, 
    -0.00300799f, -0.06321404f, 0.03477804f, 0.12349958f, -0.11803169f, 0.01469960f, 0.00642998f, -0.02415382f, 
    -0.27811638f, 0.27610302f, 0.06249553f, 0.15536366f, 0.20669270f, 0.07170527f, -0.21874897f, -0.02785431f, 
    -0.02966307f, -0.04324630f, 0.09916089f, -0.14203778f, -0.10870581f, 0.12485174f, -0.06692580f, 0.16345537f, 
    0.01086845f, -0.06304467f, 0.05225310f, -0.01443877f, 0.00260093f, -0.01205238f, 0.09630923f, 0.17567125f, 
    0.54488230f, -0.29333025f, 0.18713547f, -0.16923709f, 0.02641323f, -0.11580040f, 0.09971745f, 0.07704739f, 
    -0.20045397f, 0.14551154f, -0.13648964f, -0.19853641f, -0.08129487f, 0.11274356f, 0.19036879f, 0.00640091f, 
    -0.04266842f, -0.16560584f, 0.00676480f, -0.04799420f, 0.02980519f, 0.10023471f, -0.12377454f, 0.00571330f, 
    -0.31975394f, -0.05642947f, 0.04528015f, -0.03665649f, -0.04749297f, 0.17805558f, 0.08531939f, -0.10022743f, 
    -0.07664267f, 0.10609449f, 0.03355419f, -0.00582152f, -0.06688453f, -0.08793473f, -0.09403638f, -0.18335599f, 
    -0.04027244f, 0.07499549f, -0.03230842f, 0.07396346f, -0.14517100f, -0.00655808f, -0.00187921f, -0.07864742f, 
    0.20083287f, -0.35255468f, -0.10682242f, -0.27278781f, -0.05663421f, 0.01692224f, 0.17971197f, 0.04206428f, 
    0.01318302f, 0.06405555f, 0.06124416f, -0.11934531f, 0.00176862f, 0.16634651f, -0.23176138f, -0.07719928f, 
    -0.02128158f, -0.25479582f, 0.13382968f, -0.01989951f, -0.01567385f, 0.14417967f, -0.14048937f, 0.10439470f, 
    -0.55070931f, 0.08908428f, -0.02444418f, -0.12313530f, 0.11865165f, 0.04624834f, 0.09491821f, 0.00083452f, 
    -0.29942062f, 0.03786716f, -0.02568059f, -0.05268404f, -0.11208125f, 0.01735213f, -0.23453833f, -0.08283427f, 
    -0.00022372f, -0.09217808f, 0.00347097f, -0.09814969f, -0.08260026f, 0.06893711f, -0.26256979f, -0.05916173f, 
    0.00849714f, 0.04275903f, 0.22104609f, 0.14023183f, -0.03845330f, -0.11801630f, 0.16096222f, 0.14888443f, 
    -0.08070319f, 0.08936676f, 0.06379513f, 0.09096938f, 0.00462606f, -0.03164519f, -0.14089617f, 0.17745104f, 
    -0.06002601f, 0.02236842f, 0.03952176f, -0.06539966f, 0.04780748f, -0.02301621f, -0.00584741f, 0.15130825f, 
    -0.05442156f, -0.03932399f, 0.27628776f, 0.12954009f, 0.00299499f, 0.01313944f, 0.13469659f, 0.06376103f, 
    -0.05316321f, -0.05965504f, 0.07531760f, 0.00737793f, 0.14833406f, 0.10817973f, 0.44237152f, 0.16306359f, 
    -0.13047484f, 0.11508773f, -0.05435627f, 0.02717626f, -0.00589257f, 0.03212395f, 0.00862544f, -0.11904135f, 
    -0.04794022f, -0.02990879f, 0.00127895f, -0.12586087f, 0.07123841f, -0.13038810f, -0.20417838f, 0.07632072f, 
    -0.06256295f, -0.18109678f, -0.30812687f, -0.38451225f, -0.26170576f, 0.27199686f, -0.09886479f, -0.13787480f, 
    -0.03154964f, -0.00946583f, -0.00673915f, -0.07985580f, 0.11666702f, 0.11495525f, 0.14191779f, -0.02840351f, 
    0.06886307f, 0.25921619f, 0.09481364f, 0.01678284f, 0.01292093f, 0.08400612f, 0.11605935f, 0.00236030f, 
    0.04519074f, 0.15429926f, 0.05251860f, 0.26430652f, -0.28899834f, 0.21376380f, -0.00452750f, 0.14795753f, 
    -0.02038352f, 0.02143474f, 0.03979234f, 0.08838431f, 0.04143435f, 0.00143349f, -0.08048166f, 0.18558304f, 
    0.07593209f, 0.22969501f, 0.08519628f, 0.03746822f, -0.06884029f, -0.01763518f, -0.15870543f, -0.02380959f, 
    0.11437705f, 0.12325080f, 0.04875626f, 0.21075501f, -0.10727073f, 0.09937003f, 0.16684251f, -0.00431661f, 
    0.01178130f, 0.06318837f, -0.02504102f, 0.04042427f, 0.02432785f, -0.12409449f, -0.15323307f, -0.10482446f, 
    0.06882417f, -0.19855726f, 0.16608696f, 0.17592853f, -0.02677665f, -0.13223630f, 0.04017527f, 0.12272377f, 
    -0.08785132f, -0.04150418f, -0.16454482f, 0.03932776f, 0.21548694f, -0.09571876f, 0.20432743f, -0.05867342f, 
    0.06162351f, -0.08625537f, 0.07419604f, 0.12347622f, -0.09477083f, 0.08970942f, 0.07631078f, -0.17638610f, 
    -0.19664074f, -0.07452015f, 0.05999770f, -0.38845846f, 0.02720178f, 0.04266874f, -0.10925384f, -0.16969790f, 
    0.02615519f, -0.17032763f, -0.01270534f, 0.19093210f, -0.06608187f, 0.13813356f, 0.19005266f, 0.08679985f, 
    0.02249300f, 0.18652482f, -0.00284412f, -0.02072808f, -0.12331743f, -0.03467752f, 0.07809375f, -0.05730870f, 
    -0.19403207f, 0.15856324f, 0.07321443f, -0.08508928f, -0.07801274f, 0.04460732f, 0.10450286f, 0.02106632f, 
    0.09898612f, -0.08800872f, -0.08368343f, -0.00871131f, -0.22948900f, 0.25377503f, -0.21569069f, 0.09650841f, 
    0.06575625f, 0.00250654f, 0.12131044f, 0.09319218f, -0.19306809f, 0.08527686f, -0.03535706f, 0.16398948f, 
    -0.18192868f, -0.22711721f, 0.06315485f, -0.09888261f, -0.01741891f, -0.05519813f, 0.09632567f, -0.07439953f, 
    -0.05422482f, 0.02311817f, 0.04758655f, 0.01872638f, -0.08452235f, 0.20328505f, 0.16275109f, 0.21814694f, 
    0.15662649f, -0.04001257f, -0.03380703f, 0.09550213f, -0.08354662f, 0.04045793f, -0.10432847f, -0.05718374f, 
    -0.17737892f, 0.13384825f, -0.15093935f, -0.06782845f, -0.13760154f, 0.08104929f, -0.17462893f, 0.04078705f, 
    -0.00684998f, -0.17739180f, -0.01966881f, -0.18920122f, -0.15497972f, 0.16202389f, 0.03050464f, 0.00389438f, 
    0.02809322f, 0.13594073f, 0.02296905f, -0.02914725f, -0.01171689f, 0.05183087f, 0.17003417f, 0.04048485f, 
    -0.11193819f, -0.01268856f, 0.14849810f, -0.00198856f, -0.15464997f, -0.02295140f, 0.07715429f, 0.01036850f, 
    -0.07887249f, -0.04141847f, -0.11599151f, -0.08401177f, -0.20071355f, 0.37335125f, -0.09495287f, 0.24792203f, 
    -0.00259971f, -0.04761204f, -0.17605177f, 0.05148292f, 0.00916603f, 0.05485827f, 0.07231195f, -0.02762945f, 
    -0.05858461f, -0.03946282f, 0.02750630f, 0.03369975f, 0.00496681f, 0.00228105f, -0.00697749f, -0.04041566f, 
    0.04152058f, 0.05436264f, 0.11363000f, 0.07142155f, -0.46025896f, 0.33982038f, -0.32730666f, 0.14866433f, 
    -0.00892209f, 0.07818761f, 0.02998579f, -0.18278736f, 0.14275886f, -0.01582057f, 0.00518138f, 0.12462059f, 
    -0.38481262f, -0.06663395f, -0.37051761f, 0.17334686f, 0.12072702f, 0.05622628f, -0.03719842f, -0.03195439f, 
    0.13907082f, 0.19382200f, 0.13006230f, 0.07639987f, 0.08965210f, -0.67283988f, 0.48515362f, 0.08665411f, 
    0.12521523f, 0.06759581f, -0.00767334f, -0.07854963f, 0.19971596f, -0.00424133f, 0.05834822f, 0.03597711f, 
    0.00268901f, -0.11251228f, -0.03483852f, -0.00979266f, -0.19919370f, -0.04887023f, -0.17785542f, -0.17791098f, 
    0.01230188f, -0.02678907f, 0.01215178f, -0.12132214f, -0.07502051f, -0.09306416f, 0.01618162f, 0.22805460f, 
    -0.04831326f, -0.05158621f, 0.11148928f, 0.07707442f, 0.10559919f, 0.03491202f, -0.21831910f, 0.10266574f, 
    0.13259627f, 0.15083426f, -0.01038138f, -0.01185514f, -0.07042683f, 0.08543259f, -0.19530717f, -0.00257047f, 
    -0.06949646f, -0.03737085f, -0.13705486f, -0.12501623f, 0.33807853f, 0.25349364f, 0.03261461f, -0.14004017f, 
    -0.05577008f, -0.02994066f, 0.05896153f, 0.07231046f, -0.00864737f, 0.11565132f, -0.02838838f, -0.04992177f, 
    -0.40238723f, 0.16305278f, -0.33093071f, 0.12650098f, -0.01213390f, 0.02403656f, 0.06767347f, -0.10747203f, 
    0.05234113f, -0.07207020f, 0.26897421f, 0.19209413f, -0.18586387f, 0.16609599f, -0.26516598f, -0.11904236f, 
    0.01713718f, -0.05533266f, 0.06889129f, 0.04430959f, -0.03799289f, -0.04410451f, -0.03547263f, 0.01350690f, 
    0.07576652f, -0.21365616f, 0.42341349f, -0.01408928f, -0.05854846f, -0.13224371f, 0.03604779f, -0.05039261f, 
    -0.04325610f, 0.03528339f, -0.00533018f, 0.05081991f, 0.04287692f, 0.02926468f, 0.08299630f, -0.02500100f, 
    -0.11009203f, 0.08022391f, 0.00516011f, 0.09200346f, 0.06723979f, 0.01978487f, 0.20452003f, -0.17973541f, 
    -0.08128895f, -0.22172557f, -0.10179277f, -0.16528147f, -0.17063780f, -0.14191340f, -0.11155785f, -0.03986103f, 
    -0.01337717f, 0.04424614f, 0.03212203f, -0.04311872f, -0.18288128f, -0.20577946f, 0.01815875f, -0.06471432f, 
    0.03839127f, -0.06540088f, -0.08202846f, 0.09268567f, -0.17214172f, -0.03752822f, 0.05765769f, -0.14579432f, 
    0.51074731f, 0.13540336f, 0.02012206f, 0.12922984f, -0.01998794f, 0.10756452f, -0.10327084f, 0.18042491f, 
    -0.10937254f, 0.02270471f, 0.01358720f, 0.05806274f, -0.08731794f, -0.13603260f, -0.02393136f, -0.07466026f, 
    0.03291253f, 0.00658611f, 0.05450013f, -0.17157574f, -0.21842426f, -0.20038871f, -0.05440623f, -0.21654710f, 
    -0.19236228f, -0.10444287f, 0.00884132f, 0.23488967f, -0.21122628f, 0.01067686f, 0.05202748f, -0.03290053f, 
    -0.06319616f, 0.15584953f, -0.06133116f, 0.14340183f, 0.00669793f, -0.20471920f, -0.16370615f, 0.14778893f, 
    0.03854791f, -0.03761844f, 0.05223018f, -0.04611255f, -0.02811868f, -0.05138086f, 0.07058887f, 0.06627965f, 
    -0.51863760f, 0.03444961f, -0.09470452f, -0.13483576f, -0.04376803f, -0.02578277f, 0.01273572f, 0.06222304f, 
    -0.00876466f, 0.05578777f, 0.09789079f, 0.17769313f, 0.09017827f, 0.01616002f, -0.00462301f, 0.26159751f, 
    -0.11666849f, -0.00722397f, 0.03715790f, 0.14481398f, -0.02000035f, -0.02280553f, 0.07050525f, 0.00043804f, 
    0.31003988f, -0.04257346f, 0.24823426f, -0.06328934f, -0.08130161f, -0.10637786f, -0.31113538f, 0.05638747f, 
    0.01426072f, -0.06345218f, -0.06515707f, -0.11744563f, 0.05844061f, 0.15749180f, 0.06278758f, 0.02418800f, 
    -0.09648924f, 0.08870628f, -0.08770415f, -0.01189427f, -0.04056180f, 0.00932382f, 0.16692612f, -0.02874386f, 
    -0.05760673f, -0.17424451f, -0.38422868f, 0.11161229f, 0.22552989f, 0.10320456f, 0.11555827f, -0.02943878f, 
    0.05559061f, 0.07683311f, 0.16898930f, -0.00079543f, 0.19226852f, 0.06816073f, 0.22424272f, -0.09575079f, 
    -0.03819918f, 0.03316038f, -0.04813977f, 0.09493566f, -0.12988330f, -0.01631020f, 0.04333642f, -0.07536598f, 
    -0.00911611f, 0.11826470f, 0.05244212f, -0.10266858f, 0.06087546f, 0.02015341f, -0.14900014f, -0.05672004f, 
    0.02242943f, -0.02043568f, -0.07679363f, 0.06505285f, -0.18036199f, -0.18993799f, 0.05621879f, -0.12041618f, 
    -0.11250965f, -0.08320870f, -0.29234421f, -0.13320589f, 0.00338605f, -0.05851090f, 0.00448479f, -0.05353703f, 
    0.07105232f, -0.13223521f, 0.23010762f, -0.24578507f, 0.22450836f, -0.03817894f, 0.04168085f, 0.18670622f, 
    -0.05754770f, 0.11421251f, 0.15986107f, 0.06428766f, 0.29353234f, -0.21359080f, 0.12965536f, -0.15606208f, 
    -0.12022783f, -0.09676506f, 0.05221660f, 0.04773636f, -0.04024518f, -0.13781822f, 0.12141164f, 0.03424722f, 
    -0.36744764f, 0.04072872f, -0.18353644f, 0.23482105f, 0.14738877f, 0.11344065f, 0.09669178f, -0.06400766f, 
    -0.00997670f, 0.04805577f, 0.15299468f, 0.11097216f, -0.23671252f, -0.09952570f, -0.20672725f, 0.52222139f, 
    -0.14091644f, 0.17942095f, 0.06955796f, -0.06466317f, -0.00334832f, 0.01673039f, 0.03070413f, 0.00316052f, 
    -0.31811133f, -0.08518869f, 0.15144494f, -0.07510152f, -0.22024903f, 0.16068172f, -0.06160387f, -0.01780733f, 
    0.00143548f, 0.03499014f, -0.04347990f, 0.11340259f, -0.35088950f, -0.15534452f, -0.11575507f, -0.07540502f, 
    -0.02575160f, -0.31745186f, 0.01227203f, -0.12606911f, 0.16761258f, 0.09340498f, 0.18657115f, -0.01767756f, 
    -0.33330071f, -0.02696627f, -0.02089001f, -0.02224765f, 0.17512015f, 0.03803737f, 0.00054131f, -0.07425319f, 
    0.03880566f, 0.00801859f, 0.02444655f, -0.05264328f, -0.05232503f, -0.08155458f, 0.29780191f, 0.04626732f, 
    -0.06036084f, 0.04695612f, -0.12236153f, 0.01411305f, -0.15274844f, 0.01505570f, -0.04727723f, -0.11897527f, 
    -0.02570441f, 0.02385562f, -0.07076597f, -0.30605006f, 0.00757528f, 0.16192418f, 0.15371086f, -0.10408933f, 
    0.03718338f, 0.08171801f, 0.08382520f, 0.08585995f, -0.25984481f, 0.19329922f, -0.13373628f, 0.08583930f, 
    -0.00733551f, -0.03223724f, 0.05483318f, -0.08867929f, -0.05087573f, -0.00467924f, -0.02381957f, 0.08758669f, 
    -0.11539783f, 0.22804520f, -0.48834959f, 0.34757334f, 0.14067896f, -0.25282022f, 0.16190164f, -0.11390549f, 
    0.17058375f, 0.01012795f, -0.05834265f, 0.01153073f, -0.01485204f, 0.07108545f, -0.11789425f, 0.04911662f, 
    0.01410358f, -0.08565037f, 0.05373495f, -0.03535968f, -0.05098901f, 0.12513024f, 0.00080487f, 0.06653012f, 
    -0.24330947f, -0.13829789f, -0.31217423f, -0.26242262f, -0.19131316f, -0.29360789f, 0.17429352f, -0.12803607f, 
    0.07617190f, 0.08825476f, -0.01068792f, -0.00573925f, 0.23902161f, -0.23819076f, 0.40868840f, 0.19643074f, 
    0.19932604f, 0.11934733f, 0.00973694f, -0.10644444f, -0.09800860f, -0.06932271f, 0.01355237f, -0.04702531f, 
    0.10527577f, 0.09214719f, 0.03741310f, 0.19762768f, 0.19858843f, -0.03034478f, 0.08438580f, -0.03662866f, 
    -0.07075995f, 0.20205824f, -0.03847405f, 0.19108659f, 0.39939696f, -0.23105998f, 0.23916273f, -0.09072877f, 
    0.08088521f, -0.14773688f, 0.02616540f, 0.19292025f, -0.10133883f, 0.04927021f, 0.01444551f, -0.04247922f, 
    -0.28992328f, 0.42731285f, -0.22509031f, 0.20599279f, -0.01260285f, -0.03265280f, -0.06184852f, 0.04308293f, 
    0.08286214f, 0.03362773f, 0.04992480f, -0.05191870f, -0.23796752f, -0.11614562f, -0.04650095f, -0.04261914f, 
    0.02833989f, -0.08031727f, -0.03429699f, -0.07140296f, -0.08408462f, 0.01733908f, -0.04086094f, 0.03462066f, 
    -0.20290652f, 0.21658613f, -0.08969663f, 0.13730495f, -0.11428273f, 0.12994419f, 0.07323396f, -0.28046978f, 
    0.00854141f, -0.01806472f, -0.04469541f, -0.03699008f, 0.29586968f, -0.23693581f, 0.23476575f, -0.16856474f, 
    0.11150429f, -0.00188687f, 0.02684566f, 0.05148761f, 0.13681382f, -0.01135821f, -0.10974371f, 0.06671603f, 
    0.00625350f, -0.38899505f, -0.03096274f, -0.33726555f, 0.04725027f, -0.03606973f, 0.00505890f, -0.06514630f, 
    -0.00569719f, 0.13607295f, 0.11249091f, -0.01005734f, -0.35826600f, -0.16817190f, -0.03939174f, -0.02167067f, 
    0.20575279f, 0.01856994f, 0.09155383f, -0.09170370f, -0.08024959f, -0.03353597f, -0.08216015f, 0.09143643f, 
    -0.35899758f, -0.24723050f, -0.11252902f, 0.09433264f, 0.04059970f, -0.15887780f, 0.03999608f, 0.03771237f, 
    0.03104162f, -0.06150743f, -0.03992993f, -0.03521231f, -0.12763944f, 0.16159761f, -0.26408222f, 0.04329536f, 
    -0.05396841f, 0.00390704f, 0.01069695f, -0.02881657f, -0.01416015f, 0.00724786f, 0.07163236f, 0.01184370f, 
    -0.39690080f, 0.12640910f, -0.31692743f, 0.01180622f, 0.08423364f, -0.16907336f, 0.15123600f, 0.17435414f, 
    -0.18265310f, -0.05638028f, -0.14769487f, 0.05454255f, -0.35549676f, -0.08592744f, -0.02144178f, -0.25117043f, 
    0.03350344f, 0.00267824f, 0.07309470f, -0.10103775f, 0.00271851f, 0.00695356f, 0.17299581f, 0.02162263f, 
    -0.16484493f, 0.03900985f, 0.06773160f, -0.02765898f, -0.08605301f, 0.13643147f, -0.04957535f, -0.08253005f, 
    -0.09073103f, 0.00111657f, 0.18223603f, -0.04425127f, -0.18515112f, 0.33992437f, -0.09803951f, -0.14937103f, 
    0.00212227f, -0.03895653f, 0.01846381f, 0.05320605f, -0.01711517f, -0.02571874f, -0.08312201f, -0.16134377f, 
    -0.04319007f, 0.00012335f, -0.19871646f, -0.09901245f, 0.01769345f, -0.00240495f, -0.04569961f, 0.03773140f, 
    -0.04994036f, 0.08964397f, -0.02994266f, -0.10194240f, 0.20573407f, 0.08193361f, 0.23931961f, 0.04114877f, 
    0.08470073f, 0.00596704f, 0.11110592f, 0.02048625f, -0.05136200f, 0.09769009f, -0.02748266f, 0.01448778f, 
    -0.17458153f, 0.09561542f, -0.25645977f, 0.01045532f, -0.04854700f, -0.03937377f, 0.09708526f, -0.11820555f, 
    0.03696815f, 0.00341444f, -0.05722145f, 0.04852475f, -0.27950108f, 0.03095863f, -0.03596255f, 0.33362833f, 
    0.02817821f, -0.11732704f, 0.08415107f, 0.04043303f, 0.00909089f, -0.06715396f, -0.00115637f, -0.01741251f, 
    0.34499592f, 0.28055418f, 0.13818103f, -0.06402412f, 0.01205199f, 0.03472456f, -0.10285697f, -0.02981115f, 
    -0.07233156f, -0.04113686f, 0.01720427f, 0.06831028f, -0.64779389f, 0.13828307f, -0.23604582f, 0.42142028f, 
    -0.15055259f, 0.08407737f, 0.03716321f, 0.21392234f, -0.25240678f, -0.08079908f, -0.04595836f, 0.00478740f, 
    -0.34563369f, 0.17196491f, -0.14108288f, 0.04363428f, -0.08818208f, 0.06491297f, 0.19398494f, -0.02901848f, 
    0.00921901f, 0.01843824f, 0.11894161f, 0.19310494f, -0.03169371f, 0.22994277f, -0.20156032f, 0.16676457f, 
    -0.02850239f, -0.15935272f, 0.14244188f, 0.08837166f, 0.04352492f, -0.04371044f, -0.16609034f, -0.00684638f, 
    0.24060787f, -0.00811348f, 0.10989943f, -0.09878044f, 0.04630362f, -0.04783529f, -0.04407080f, 0.14793226f, 
    -0.08129894f, 0.08998463f, -0.11418401f, -0.02789642f, -0.21434662f, -0.24017830f, -0.05242751f, 0.12275812f, 
    -0.02294028f, -0.12716497f, -0.04842129f, -0.16630051f, 0.02442591f, 0.02248921f, -0.06212237f, 0.01378502f, 
    -0.09000459f, 0.21584162f, 0.06143915f, 0.12139789f, -0.19720294f, 0.02454194f, -0.10896960f, -0.19544889f, 
    -0.01272793f, 0.10274788f, 0.03911746f, 0.11174300f, 0.20423031f, 0.10343014f, -0.46069261f, 0.25928694f, 
    0.15511242f, -0.08411076f, 0.06200646f, -0.06303640f, 0.00598957f, 0.11295152f, 0.06385573f, -0.07220665f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10335366f, 0.04437022f, 0.03613181f, -0.08796950f, -0.06623605f, 0.06682434f, 0.01218446f, -0.08611982f, 
    0.06136567f, 0.02595386f, 0.06185839f, -0.00567398f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
