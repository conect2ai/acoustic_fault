#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.98426598f, -0.56233406f, -0.50935709f, -0.45290336f, -0.39878428f, -0.12713505f, -0.30720088f, -0.24509232f, 
    0.09810954f, -0.68253613f, -0.47607183f, -0.46570995f, 0.46856228f, 0.55366975f, 0.54788083f, 0.61453635f, 
    -0.43232316f, -0.05173611f, 0.61139208f, 0.48591837f, 0.64765298f, 0.49139601f, -0.19265974f, 0.45092472f, 
    -0.18163680f, 0.03750193f, -0.15782467f, 0.54267085f, -0.61220002f, 0.53948063f, -0.54429567f, -0.52569360f, 
    -0.29568231f, -0.26991495f, 0.20811944f, -0.12013122f, -1.02679336f, 0.59017414f, -0.73633677f, 0.25569454f, 
    -0.18456322f, -0.61798644f, -0.13580565f, 0.42086354f, -0.06477920f, -0.30116525f, -0.06644533f, 0.61919934f, 
    0.83001530f, 0.92079645f, 0.12850924f, 0.19270082f, 0.30312943f, 0.14099875f, 0.08285334f, 0.42925274f, 
    0.57992518f, 0.45158404f, 0.65314901f, 0.57903945f, -0.06363632f, -0.51915669f, 0.17532483f, -0.55602103f, 
    -0.71274382f, -0.76416481f, 0.11504333f, -0.45959279f, -0.02296251f, 0.08209047f, 0.00373141f, 0.12291130f, 
    0.66419709f, -1.05084133f, 0.78843355f, 0.70485812f, -0.28471863f, 0.31784895f, 0.09024979f, -0.11125171f, 
    0.05112870f, -0.21936087f, -0.00378182f, 0.30205521f, -0.74167424f, 0.03095116f, 0.31804040f, 0.22035451f, 
    0.54983497f, -0.80426359f, -0.67269200f, -0.63770962f, -0.69805330f, -0.78908730f, -0.00385301f, -0.31905618f, 
    0.10335605f, 0.26678547f, -0.27914482f, 0.71946281f, 0.70663422f, 0.86718243f, -0.49685642f, -0.33139503f, 
    -0.79688370f, -0.10922670f, -0.38549480f, 0.20931579f, 1.05999207f, 0.68330961f, 0.48283353f, -0.06427020f, 
    0.10188723f, 0.33686712f, -0.16857846f, 0.53324193f, 0.08083430f, -0.24163952f, -0.32337236f, 0.20344831f, 
    -0.82114667f, -0.37376630f, -0.64208388f, 0.32358015f, 0.38168380f, 0.53182787f, -0.57717913f, -0.50875318f, 
    -0.63499004f, 0.33159935f, 0.36547664f, 0.65004784f, -0.59547848f, -0.01183457f, -0.42627180f, -0.97421438f, 
    -0.64085817f, -0.08141731f, -0.69761324f, 0.01551898f, 0.39295754f, -0.08099375f, 0.15719488f, 0.27081403f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14947368f, -0.12326564f, 0.30813736f, -0.16990429f, 0.15727159f, -0.10534430f, 0.23958318f, -0.15726498f, 
    -0.06539495f, -0.35197011f, 0.00303744f, -0.20698604f, 0.49386197f, 0.22112426f, 0.04130328f, 0.21348196f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.44655946f, 0.32351854f, -0.29387796f, -0.04237604f, -0.05001546f, -0.32507408f, 0.06105337f, -0.12608010f, 
    -0.12639663f, 0.01662055f, 0.34154195f, -0.14404635f, 0.19484639f, 0.13678899f, -0.10605524f, -0.02572503f, 
    -0.05128234f, 0.24622695f, -0.33773935f, -0.16573767f, -0.00167453f, 0.08538937f, 0.27165851f, 0.21871851f, 
    -0.01890514f, 0.07635026f, 0.00486596f, 0.16018750f, 0.10854461f, 0.14494950f, -0.23549825f, 0.02299716f, 
    -0.01136597f, 0.06676407f, -0.10536273f, -0.16243862f, 0.13591318f, -0.11784776f, 0.09115924f, -0.03265336f, 
    -0.11606494f, 0.01137854f, -0.14810310f, 0.03956810f, -0.15993547f, -0.23501720f, 0.04263417f, -0.18386999f, 
    -0.10210353f, -0.12030397f, -0.09305901f, 0.14360556f, 0.13744050f, 0.00766487f, -0.24084519f, -0.02408591f, 
    0.16214672f, 0.08191878f, -0.00263465f, 0.05806476f, 0.05281635f, 0.04744166f, 0.11455185f, 0.24833767f, 
    0.05537218f, -0.16038321f, -0.00509461f, -0.01098887f, 0.04190465f, -0.14007802f, 0.18898225f, 0.07498411f, 
    -0.30469403f, -0.35234308f, -0.28168270f, 0.19091466f, 0.00346340f, 0.01527572f, 0.25482193f, -0.04197566f, 
    0.18860434f, 0.04145326f, 0.07269755f, 0.09557621f, -0.26612201f, -0.04303764f, 0.08666692f, 0.01939565f, 
    -0.09296964f, -0.09453296f, -0.27673244f, 0.45583326f, -0.35493267f, -0.18342778f, 0.00986946f, -0.02143641f, 
    0.03783222f, 0.08289613f, -0.10284904f, 0.36314476f, -0.56505972f, 0.31694469f, 0.22895294f, 0.11193244f, 
    0.32246131f, 0.02890887f, 0.01101208f, 0.11202946f, 0.26899683f, -0.58810127f, -0.04671759f, 0.10302663f, 
    -0.08931033f, -0.00196512f, 0.07759698f, 0.04948616f, -0.08597293f, 0.01332513f, 0.32269993f, -0.06496897f, 
    0.05989553f, 0.01250899f, 0.06891187f, 0.05104666f, 0.09300292f, 0.08617948f, 0.13259304f, 0.20766816f, 
    -0.01071694f, -0.12432420f, -0.05712915f, -0.19591500f, -0.13861187f, 0.20594776f, 0.01383597f, -0.20329009f, 
    0.16345970f, -0.09736778f, -0.16596352f, -0.23670274f, -0.00950321f, 0.06327751f, -0.03387943f, 0.18282309f, 
    -0.09843873f, -0.47710970f, 0.06943703f, -0.13956222f, 0.06983534f, 0.25205520f, -0.21944159f, -0.00110694f, 
    0.20876113f, 0.26197255f, -0.11216537f, -0.37974456f, 0.14730233f, 0.19549750f, 0.16588145f, 0.04166158f, 
    -0.19647293f, -0.29211530f, -0.10045485f, -0.01414717f, 0.22055043f, -0.04635959f, -0.17105597f, -0.11501942f, 
    0.12311506f, -0.01960906f, 0.02979228f, 0.19046855f, -0.12234175f, -0.02060363f, -0.18378100f, 0.00829529f, 
    0.02146785f, -0.02958564f, 0.21163386f, 0.07140791f, -0.01739166f, -0.31500104f, -0.22995542f, 0.13823952f, 
    0.09067400f, -0.08367925f, 0.12181061f, -0.12228306f, 0.03878442f, -0.09119013f, 0.20777465f, 0.46097657f, 
    0.11969988f, 0.22500220f, -0.10802043f, -0.17495015f, 0.00000821f, 0.02991974f, -0.02341670f, 0.18854745f, 
    -0.02899315f, -0.10747354f, -0.05495188f, -0.26795012f, 0.33627725f, 0.09103883f, 0.12106720f, -0.05379728f, 
    0.12941130f, -0.07950964f, 0.17017844f, 0.07951652f, -0.10551164f, 0.13009115f, 0.12048628f, -0.02518672f, 
    0.00963300f, -0.20293462f, 0.07032344f, -0.12116496f, 0.14080341f, -0.00567809f, 0.14295547f, 0.02127194f, 
    0.11075122f, -0.39845678f, -0.28744441f, -0.07710606f, -0.05743223f, 0.00263379f, -0.13448688f, 0.29169264f, 
    0.29938564f, 0.12006938f, -0.39078984f, -0.14137769f, 0.09006747f, -0.05855750f, 0.23864298f, 0.23408373f, 
    0.09078366f, 0.04029359f, -0.26275685f, 0.26760781f, 0.14968354f, 0.07380294f, -0.13427971f, -0.16720353f, 
    0.03500501f, -0.28881329f, 0.22185788f, 0.14504144f, 0.39529639f, 0.27698848f, -0.09312706f, 0.00846636f, 
    -0.27579704f, -0.04755750f, -0.10697815f, -0.00177196f, 0.27511689f, 0.11027131f, -0.11970047f, 0.03150225f, 
    -0.00790983f, -0.02182727f, 0.14758275f, -0.26429468f, -0.09687510f, 0.21503417f, 0.16908857f, 0.29993287f, 
    -0.65568519f, 0.17349754f, 0.12396076f, 0.10641438f, 0.13040210f, -0.12776816f, 0.08543507f, -0.44174945f, 
    0.00615307f, -0.14036764f, 0.04422475f, 0.11812829f, 0.06759257f, 0.00276298f, -0.06453721f, -0.05651104f, 
    0.05630664f, -0.19773877f, -0.16368209f, 0.00146821f, 0.12919727f, 0.14719425f, 0.07499102f, 0.01234553f, 
    0.02385438f, -0.25277311f, -0.25602278f, -0.30015385f, 0.16388197f, 0.02468170f, 0.07053007f, 0.12230202f, 
    0.11109664f, 0.03128304f, -0.16525942f, 0.54119241f, 0.39228001f, 0.31240043f, 0.15129210f, 0.07590829f, 
    0.06418221f, 0.07978705f, -0.04344368f, 0.40180996f, -0.19181044f, 0.03711086f, -0.24537252f, 0.06699073f, 
    -0.07201912f, -0.13679899f, 0.11431708f, -0.17964919f, -0.28963754f, -0.12180711f, 0.09874764f, -0.12315506f, 
    -0.00008304f, -0.01319214f, 0.15135656f, -0.03081747f, 0.11165341f, 0.01306884f, -0.83513939f, -0.16261423f, 
    0.03909860f, 0.00597643f, 0.19096097f, 0.00745186f, -0.02673166f, -0.14728883f, 0.27974385f, 0.00599521f, 
    -0.08074893f, 0.05297198f, 0.09932548f, -0.03664374f, 0.00725723f, -0.00904438f, -0.13716264f, -0.37574521f, 
    0.05683543f, -0.17944293f, 0.14306083f, -0.08646619f, -0.21232294f, -0.29049784f, 0.09521552f, -0.22747613f, 
    0.36786997f, -0.22158934f, -0.24780235f, 0.00878035f, -0.10490312f, -0.02712088f, -0.00997032f, -0.04054632f, 
    0.04363570f, -0.08008616f, -0.02215184f, 0.01539876f, -0.03726149f, -0.05456385f, -0.08327952f, 0.07646360f, 
    0.15844283f, -0.01559173f, 0.05909580f, -0.07346433f, -0.02102941f, 0.10631340f, 0.14870667f, -0.03346965f, 
    0.02933432f, -0.08083551f, -0.04428177f, 0.06572475f, 0.37187114f, 0.37470937f, -0.12830803f, 0.07699754f, 
    -0.08396010f, -0.07104374f, -0.02512002f, 0.05752682f, -0.48253846f, 0.34064239f, 0.33438233f, -0.01573899f, 
    0.17593037f, -0.14751717f, -0.23148640f, 0.05550672f, 0.00463767f, 0.12042503f, -0.14250664f, -0.10422512f, 
    0.10223116f, 0.10496104f, 0.09725713f, 0.11105231f, -0.13742986f, -0.00902108f, -0.03305447f, -0.19640388f, 
    -0.08014117f, -0.01363107f, -0.07049710f, 0.14088553f, -0.03117175f, -0.13299192f, 0.02720640f, -0.14378373f, 
    -0.31374463f, -0.00531326f, 0.05574558f, 0.03913372f, 0.04022452f, -0.13691601f, 0.06332006f, 0.18716393f, 
    0.53334051f, 0.10221861f, 0.00554219f, -0.30581665f, -0.08999279f, -0.17041600f, 0.14064880f, 0.09722482f, 
    0.05527933f, -0.26929721f, -0.00574316f, 0.03371580f, 0.26966715f, 0.26845095f, -0.03869957f, -0.08003855f, 
    0.05852950f, 0.09355593f, 0.17513116f, 0.14838679f, -0.15394028f, -0.12014055f, 0.13324749f, 0.16503468f, 
    -0.06328913f, 0.03275075f, -0.20510194f, 0.18215927f, -0.01518800f, -0.04747943f, 0.11052025f, -0.12406464f, 
    -0.04970390f, 0.05303718f, -0.00363503f, 0.18850300f, -0.23337296f, 0.19520734f, 0.20290451f, 0.15170440f, 
    -0.08113834f, 0.14772581f, 0.01907600f, -0.01963128f, -0.07691776f, 0.12565419f, 0.20234062f, 0.02848442f, 
    0.10293847f, -0.05289788f, 0.10291369f, 0.24143213f, -0.02179918f, -0.11284792f, -0.24025826f, -0.15266134f, 
    0.00751312f, -0.04374958f, -0.00408014f, -0.23625687f, 0.14378558f, -0.02601135f, 0.01964229f, -0.12450252f, 
    -0.27773416f, 0.31417784f, 0.22707987f, 0.33544815f, 0.05102829f, 0.16993338f, 0.17547253f, 0.04932187f, 
    -0.13569953f, -0.31098887f, -0.30320898f, 0.11009452f, -0.00501744f, -0.01505367f, -0.17202348f, -0.31788144f, 
    -0.06827605f, 0.13154130f, -0.11759093f, -0.10687630f, 0.05507669f, -0.07377955f, -0.05375403f, 0.00332948f, 
    0.11038360f, -0.10174169f, 0.11401606f, -0.00106687f, 0.19987106f, -0.01149030f, 0.12066456f, -0.20217012f, 
    0.10011730f, -0.11133949f, -0.13991775f, 0.11789589f, -0.12978584f, -0.19699652f, -0.04307716f, -0.09691370f, 
    -0.06941412f, -0.11312732f, 0.03544001f, 0.02725022f, -0.34995794f, 0.21699059f, 0.04201152f, -0.28896922f, 
    0.03219748f, -0.08495715f, -0.06401329f, -0.04594160f, 0.07750501f, 0.02369493f, -0.32664838f, 0.02220125f, 
    -0.23993798f, -0.17543478f, 0.05350797f, 0.01016093f, 0.03723013f, -0.11993290f, 0.17564331f, 0.23149893f, 
    0.42148149f, 0.19408511f, 0.04727899f, -0.02389327f, -0.20814461f, 0.11145116f, 0.30881825f, 0.10609964f, 
    -0.04177828f, 0.04125999f, -0.03198601f, -0.01248811f, 0.03754669f, -0.06793709f, -0.00028972f, 0.08027783f, 
    0.26706517f, 0.01118241f, -0.08836526f, -0.03715692f, 0.00583684f, -0.27139461f, 0.08652227f, 0.13141000f, 
    0.21976827f, -0.21679223f, 0.06841509f, -0.11636460f, 0.21185158f, 0.04948137f, -0.01839393f, -0.05548302f, 
    -0.22663428f, 0.00678578f, -0.03471393f, 0.18703941f, -0.08372871f, 0.22161956f, 0.24821915f, 0.11158699f, 
    0.18218288f, 0.09959071f, -0.14132370f, -0.09401456f, -0.31899366f, -0.01996305f, -0.21742363f, 0.14734897f, 
    -0.35733739f, 0.10413755f, 0.08768918f, 0.15266961f, 0.36858085f, 0.20643483f, 0.29576024f, -0.25643605f, 
    0.11143157f, -0.08583103f, 0.06809595f, 0.04756143f, 0.29890579f, -0.02089974f, -0.02934107f, 0.07586744f, 
    0.36468264f, 0.09845761f, -0.03537899f, -0.07999583f, 0.24882035f, -0.42763335f, -0.09533794f, -0.06733272f, 
    -0.00331912f, 0.46050179f, -0.00588707f, 0.17493722f, -0.01106191f, 0.19211015f, -0.14355001f, 0.45029303f, 
    -0.11653718f, -0.14373313f, 0.00706303f, 0.11708504f, 0.11878107f, 0.28096738f, -0.28550825f, -0.14913775f, 
    -0.38650081f, -0.06202056f, -0.29460597f, 0.07629912f, 0.11453415f, 0.10990036f, -0.17323710f, -0.01081948f, 
    -0.13247281f, -0.14439875f, -0.15332662f, -0.39612609f, -0.22600690f, 0.01809316f, -0.23715605f, 0.30587655f, 
    0.16904363f, 0.06072829f, -0.14900027f, 0.15370041f, 0.17441073f, 0.13649711f, 0.25128555f, 0.07129284f, 
    -0.29316509f, 0.23683205f, 0.20221911f, 0.29294637f, 0.27008808f, 0.21086778f, -0.07613339f, 0.01883492f, 
    -0.15150385f, -0.15614957f, 0.04121531f, 0.29512233f, 0.17662604f, 0.20100319f, 0.01239092f, -0.11023870f, 
    0.26033807f, 0.03217873f, 0.09641097f, 0.09677900f, -0.03609138f, 0.07717542f, -0.23999153f, 0.14568877f, 
    0.27961469f, 0.11555685f, -0.18221043f, 0.05486106f, -0.06155077f, 0.06800940f, -0.19532682f, 0.07571146f, 
    -0.02867277f, -0.01849394f, 0.02703459f, 0.07094854f, -0.25351140f, -0.11010059f, 0.07382137f, -0.20640941f, 
    0.24789804f, -0.05426459f, -0.00021230f, 0.21755074f, 0.18973215f, 0.05554460f, -0.07661155f, 0.17364457f, 
    0.04068398f, 0.02383820f, -0.03624904f, 0.04305804f, 0.00351292f, -0.07649024f, -0.06570767f, -0.08275469f, 
    -0.06917848f, -0.06937234f, 0.04319059f, -0.07137176f, -0.05444206f, -0.00852459f, -0.00560955f, 0.04219572f, 
    -0.00224085f, -0.03509050f, -0.01334064f, -0.00957930f, -0.06672405f, 0.05764053f, -0.06242478f, 0.05801594f, 
    0.05847835f, 0.02533507f, -0.05940768f, 0.03483826f, -0.04401035f, -0.01226465f, 0.02552014f, 0.02554256f, 
    0.06428065f, -0.01568691f, 0.06503129f, 0.02800286f, -0.04139080f, 0.06647103f, 0.05696991f, 0.01823196f, 
    -0.01161449f, -0.04109707f, -0.05212184f, -0.08044734f, -0.03487180f, 0.04221708f, -0.03495967f, -0.01993714f, 
    -0.02945139f, 0.06747279f, 0.02893947f, -0.08563387f, -0.04238214f, -0.01503062f, -0.00948299f, -0.00264849f, 
    -0.01302950f, -0.06081568f, 0.01675641f, -0.07187798f, 0.01424565f, 0.04315876f, -0.08127134f, -0.02620785f, 
    -0.08220579f, 0.06003208f, -0.01522825f, -0.02592730f, 0.05779175f, -0.03704965f, -0.05856067f, -0.02453176f, 
    0.03224934f, 0.07652569f, 0.03270357f, 0.05024952f, 0.05565965f, 0.00607273f, -0.02313200f, -0.07052974f, 
    -0.02969170f, -0.06316987f, 0.03191700f, 0.03923604f, -0.06620323f, -0.02516912f, 0.00000485f, -0.06241377f, 
    -0.03173878f, 0.05338777f, -0.02579335f, -0.08567274f, -0.07792532f, -0.00363406f, -0.05728409f, -0.04914317f, 
    -0.00133558f, -0.03862120f, -0.07459355f, -0.00220132f, -0.01522988f, -0.03290119f, 0.03370777f, 0.07244775f, 
    -0.08618159f, -0.01207674f, -0.02835876f, -0.01213109f, -0.00358272f, -0.00818100f, -0.07523769f, -0.03668358f, 
    -0.06679302f, 0.01405668f, 0.02438681f, 0.05362879f, -0.02981144f, 0.07028758f, 0.00949808f, -0.06019283f, 
    -0.05390136f, -0.07521524f, -0.08232455f, 0.04543919f, -0.03419837f, 0.05354971f, 0.02345312f, -0.06709740f, 
    0.00702012f, 0.00787546f, -0.02531342f, 0.00012335f, -0.05406526f, -0.00121898f, -0.01828928f, 0.03978390f, 
    -0.01770652f, -0.04257666f, 0.01018813f, -0.00844537f, 0.01434001f, 0.05112436f, 0.02238461f, -0.02284904f, 
    0.17599982f, 0.17405000f, -0.06055902f, -0.04609049f, 0.01378498f, -0.17510681f, -0.16523530f, -0.09205376f, 
    -0.00052559f, 0.16370702f, 0.12761435f, 0.09888454f, -0.12110288f, 0.13980657f, 0.18741247f, -0.02831490f, 
    0.04041051f, -0.13125123f, 0.01294885f, 0.04330753f, 0.18009520f, 0.04431015f, -0.07702331f, 0.09086320f, 
    -0.03736506f, 0.08528654f, 0.09693933f, 0.23698936f, 0.19672446f, -0.12389655f, 0.00521075f, -0.03286761f, 
    -0.03909401f, -0.25616595f, 0.12667154f, -0.01725177f, 0.36776847f, 0.03239161f, -0.01398778f, 0.12255771f, 
    0.04959308f, 0.05822792f, -0.07160656f, 0.13266918f, -0.27129430f, -0.02145504f, -0.05704676f, 0.18367396f, 
    0.10669538f, -0.03353731f, -0.17014936f, 0.30838245f, -0.02843943f, 0.08510026f, -0.09808784f, 0.10031717f, 
    -0.05326276f, 0.09246039f, -0.05373580f, -0.12369949f, 0.14659034f, -0.04161699f, 0.07161875f, 0.32835600f, 
    0.28377721f, 0.34265479f, 0.00257441f, 0.08570118f, 0.32153803f, 0.09839374f, 0.22885546f, 0.20147826f, 
    0.16861710f, -0.21315657f, -0.22759618f, -0.08247451f, 0.15287358f, -0.18261269f, -0.05417461f, 0.16093045f, 
    0.13327192f, -0.39200723f, 0.29287085f, 0.16352448f, 0.00524687f, 0.02123635f, -0.18656002f, -0.10794094f, 
    -0.06791393f, 0.47311112f, -0.02397408f, -0.06140244f, 0.53221965f, 0.20171049f, -0.18688016f, 0.19515486f, 
    0.21450467f, 0.03419534f, -0.13852054f, -0.77056861f, -0.37509379f, -0.06592226f, -0.24825223f, 0.08534300f, 
    0.20535754f, -0.22220501f, -0.18706658f, 0.03131296f, -0.27837837f, -0.22813833f, -0.00928517f, -0.12509780f, 
    -0.08870940f, -0.13726334f, 0.03906901f, -0.06714834f, 0.21895248f, -0.25179264f, -0.02297631f, -0.10617298f, 
    -0.17120105f, -0.04791122f, 0.02285423f, -0.26690149f, -0.06908165f, -0.20403068f, 0.14357305f, 0.14644501f, 
    0.14309898f, 0.23851518f, 0.13465305f, -0.01982596f, 0.21218100f, -0.01417430f, -0.00591874f, 0.12245162f, 
    -0.03393065f, 0.05472913f, 0.07678790f, -0.12339798f, -0.26484400f, -0.10687546f, 0.07186541f, 0.20624964f, 
    -0.18290465f, -0.17645447f, 0.01044770f, 0.03195709f, -0.01382272f, 0.02568976f, 0.05398697f, -0.14986536f, 
    0.00297181f, 0.35973990f, 0.06739633f, -0.13424313f, 0.01177938f, 0.06803901f, 0.06278616f, -0.08054326f, 
    0.06691322f, 0.00594921f, -0.76070243f, -0.14462119f, -0.33025324f, 0.18808571f, 0.16834676f, 0.16169383f, 
    0.04739258f, 0.00806923f, -0.10181672f, 0.35791177f, 0.23446687f, 0.09606872f, 0.19092989f, 0.28458294f, 
    0.09409130f, 0.06151874f, 0.11619450f, -0.09203222f, 0.03644212f, -0.26331857f, -0.03207384f, -0.04906809f, 
    -0.11501137f, 0.22782108f, 0.15556899f, 0.01040335f, 0.17991738f, 0.01670203f, 0.04817037f, -0.26082608f, 
    0.02585458f, 0.13706797f, -0.09916561f, 0.27997574f, -0.04339693f, 0.22496791f, -0.26635298f, 0.00726030f, 
    0.04649836f, -0.08874294f, 0.09800120f, 0.08770519f, -0.09469421f, 0.12147462f, -0.17972434f, 0.05675893f, 
    0.04019123f, 0.31950828f, -0.13421671f, -0.11605704f, -0.04593369f, -0.17255977f, 0.02321286f, 0.15584882f, 
    -0.43495888f, 0.28398359f, -0.13324791f, 0.04351069f, -0.11731411f, -0.26533177f, -0.14673218f, 0.16501488f, 
    0.26779467f, 0.13613941f, -0.05809114f, 0.00736449f, -0.04318396f, 0.02628964f, -0.12793559f, 0.02600280f, 
    0.11466558f, -0.00868947f, -0.07877573f, 0.15185997f, 0.08050769f, 0.08958919f, 0.12140083f, 0.03776300f, 
    0.03156601f, -0.04278798f, -0.07149854f, -0.61981606f, -0.10835607f, 0.10016730f, 0.15168609f, 0.11517876f, 
    -0.04140663f, -0.30723351f, -0.00948084f, -0.03282910f, -0.86074364f, -0.37532225f, -0.08618566f, 0.04680358f, 
    -0.03326528f, 0.05561356f, 0.15880746f, 0.05058666f, 0.00043267f, 0.25641465f, 0.24356928f, -0.03012936f, 
    0.05308905f, -0.21037734f, 0.06237721f, -0.05533167f, 0.15849498f, 0.18164757f, 0.36100084f, 0.07950201f, 
    -0.05200986f, 0.06654131f, 0.04072379f, -0.13869549f, 0.02254545f, 0.08233844f, -0.10419277f, -0.15648794f, 
    -0.09418898f, -0.14520293f, -0.09013471f, -0.07202765f, 0.01404214f, 0.19949538f, 0.06401046f, 0.14455739f, 
    0.03341725f, 0.00588836f, 0.06395648f, 0.00872888f, -0.03229508f, 0.01150214f, -0.03027184f, 0.05164142f, 
    -0.03046216f, -0.00290906f, -0.02201039f, -0.04405648f, -0.02468719f, -0.06836708f, -0.04939884f, -0.08377691f, 
    -0.02670745f, 0.04830749f, 0.00642140f, -0.08054566f, 0.01227913f, 0.02936334f, -0.00490868f, -0.03644563f, 
    -0.07237666f, 0.04947465f, -0.04347756f, -0.08733680f, 0.01839056f, -0.05750778f, -0.07382686f, -0.02539084f, 
    -0.00969619f, -0.03731793f, -0.06864943f, -0.07972477f, 0.01249059f, 0.00979255f, 0.03670010f, -0.04136764f, 
    -0.07428478f, -0.04840218f, -0.06811340f, 0.02613156f, -0.02095446f, -0.04631311f, -0.07927287f, -0.00061080f, 
    0.04397659f, 0.06222348f, -0.08834414f, -0.09591454f, 0.06080078f, 0.02505823f, 0.04649937f, 0.02388313f, 
    0.04962577f, -0.00364467f, 0.03982632f, -0.02227188f, -0.09885804f, -0.07104827f, -0.05309093f, -0.06230066f, 
    -0.06647293f, 0.01752218f, 0.07240777f, -0.06155452f, -0.02877873f, 0.04434865f, -0.00786655f, 0.02704356f, 
    -0.01093790f, 0.06686433f, -0.07178487f, -0.07128512f, -0.05753129f, 0.04403668f, -0.04705255f, -0.02894183f, 
    0.05480309f, -0.07893144f, 0.07165892f, 0.01239773f, -0.00630878f, 0.01724914f, 0.03572205f, -0.04854817f, 
    0.01089365f, -0.08189947f, -0.04732041f, -0.01743544f, -0.01333423f, 0.06556747f, 0.02060442f, 0.06377362f, 
    0.06306502f, 0.00762063f, 0.04928564f, 0.00904095f, 0.01883289f, 0.04822060f, 0.05336234f, 0.00276531f, 
    -0.08809108f, -0.05775153f, -0.03523938f, -0.05599322f, -0.05119960f, -0.00561935f, 0.04582189f, 0.05605652f, 
    0.00535375f, 0.01620446f, -0.05718857f, 0.04021235f, -0.08558548f, -0.07443399f, -0.03604002f, -0.01640461f, 
    -0.04217873f, 0.06567810f, -0.07551236f, -0.07612806f, -0.05125394f, 0.01323493f, -0.07364757f, -0.06563627f, 
    -0.01385378f, 0.04671466f, -0.04758160f, 0.01709454f, 0.05769454f, 0.00789841f, -0.02249013f, 0.03056197f, 
    -0.00065460f, -0.01968281f, -0.08660217f, 0.07090990f, 0.01563498f, -0.03785777f, -0.06706698f, -0.06860311f, 
    0.16116121f, 0.13503662f, -0.18471131f, 0.07097892f, -0.03306378f, 0.11712600f, 0.02929641f, -0.08813164f, 
    -0.10222958f, 0.05610741f, 0.13884564f, 0.48982808f, 0.16281162f, -0.03601788f, 0.05523418f, 0.21812132f, 
    -0.23917826f, -0.06465112f, -0.01546315f, 0.02666502f, -0.02704943f, 0.12190561f, 0.05338620f, 0.08165497f, 
    0.01225140f, -0.09694515f, 0.13701625f, -0.53803360f, 0.19088808f, -0.25379705f, -0.01035580f, 0.00505216f, 
    -0.05287999f, -0.17006670f, -0.08370046f, -0.09770704f, 0.06764518f, -0.10755126f, -0.17031911f, -0.26218674f, 
    -0.00733610f, -0.10200504f, -0.06038652f, 0.06247428f, 0.10281093f, 0.35818028f, 0.08783693f, 0.05992502f, 
    -0.17934041f, 0.20924518f, 0.11855966f, 0.20694499f, 0.20602025f, 0.26049614f, 0.10701539f, 0.09737450f, 
    -0.13880934f, 0.17550918f, -0.08262036f, 0.07058378f, -0.09020822f, 0.07643823f, 0.01146550f, -0.07360228f, 
    0.35225251f, 0.37915680f, -0.13555187f, 0.07049804f, -0.13329895f, 0.10772926f, -0.03380205f, 0.02794079f, 
    -0.42593315f, 0.02410689f, -0.14281555f, 0.26447108f, -0.12765533f, -0.26903543f, 0.08776157f, -0.02801665f, 
    -0.13503820f, -0.26029620f, -0.17905796f, -0.43896943f, 0.18355416f, -0.07358778f, -0.10208178f, -0.14169165f, 
    -0.09946730f, -0.00400269f, 0.44398072f, 0.11542209f, 0.03417396f, -0.08554558f, -0.01239717f, 0.04848304f, 
    -0.13884468f, -0.04439110f, 0.09346714f, -0.23721893f, 0.02039593f, -0.25985590f, 0.03404780f, 0.05467682f, 
    -0.03148676f, 0.12864543f, 0.07782528f, -0.11816382f, -0.12662892f, 0.13172866f, -0.07538863f, 0.06943116f, 
    -0.04790846f, 0.08357649f, 0.04812328f, -0.09479295f, 0.12009925f, -0.19023713f, -0.10302132f, -0.29064593f, 
    -0.12503666f, -0.05722917f, -0.07286223f, -0.14339359f, 0.09539659f, -0.16767894f, 0.56414366f, 0.22728689f, 
    0.47225386f, -0.15681314f, -0.02387254f, 0.04383227f, -0.11101601f, -0.01443439f, 0.10593697f, 0.43185318f, 
    -0.26852196f, -0.02753879f, -0.14477782f, 0.00407140f, -0.13072968f, -0.00254934f, -0.03231977f, 0.12206610f, 
    0.23723561f, 0.31634194f, 0.05733957f, -0.13829781f, 0.16573021f, 0.04994037f, 0.13154952f, 0.09066481f, 
    -0.11594846f, -0.12915784f, 0.00801364f, 0.19446611f, -0.26154718f, 0.09784727f, -0.04542426f, -0.25490880f, 
    0.12040475f, 0.23811439f, 0.12136373f, -0.19955902f, -0.01812067f, 0.06353946f, 0.07168727f, 0.24992727f, 
    -0.12800318f, -0.05213753f, -0.16867884f, 0.07672660f, 0.22408421f, -0.07335949f, 0.17517501f, -0.08831766f, 
    0.04389514f, 0.09510613f, -0.07881018f, -0.02501834f, 0.08017118f, 0.04972077f, 0.10926464f, -0.09608614f, 
    -0.15128456f, 0.00935671f, -0.05734742f, 0.03128593f, 0.09575817f, 0.15664625f, 0.16546997f, -0.00198659f, 
    0.05505842f, -0.07755353f, 0.11418471f, -0.03197781f, 0.06825017f, -0.05068148f, -0.20849988f, -0.23212811f, 
    0.12017572f, -0.04069857f, -0.19336087f, 0.29852971f, 0.07235167f, -0.01657817f, -0.05929958f, -0.07077283f, 
    -0.33827886f, 0.32351398f, 0.07953772f, -0.10741120f, 0.08740907f, -0.12842689f, -0.00541466f, 0.00866219f, 
    0.21624275f, 0.09763521f, -0.15817851f, -0.20319024f, -0.00015833f, 0.22881909f, -0.09972271f, -0.01491421f, 
    -0.27221140f, 0.00818146f, 0.24007505f, -0.20581631f, -0.01146491f, 0.34200099f, 0.10874479f, -0.19508614f, 
    0.02790481f, 0.13656098f, -0.17026483f, 0.16654907f, 0.21720818f, -0.19828196f, 0.01951860f, -0.05409036f, 
    -0.05325433f, 0.08229791f, 0.15376820f, 0.18416184f, 0.03311422f, -0.23546138f, 0.26234180f, -0.14187936f, 
    0.00091301f, 0.03095458f, -0.11399411f, 0.02487337f, -0.29331672f, -0.13479063f, -0.05250885f, 0.00237872f, 
    0.12553373f, 0.09200428f, 0.01605750f, 0.02250505f, -0.16695723f, -0.01677149f, -0.05457748f, 0.01527471f, 
    0.17366782f, 0.04059258f, -0.40751052f, 0.15711296f, -0.13811526f, 0.05576511f, -0.38675147f, -0.16149813f, 
    0.32941133f, -0.19602707f, -0.00773683f, 0.05419258f, 0.01863195f, 0.01919717f, 0.20343751f, 0.07261043f, 
    0.03884247f, -0.00384273f, -0.14046457f, -0.18324040f, 0.09386092f, 0.02595905f, 0.04558436f, -0.00432009f, 
    -0.08364645f, -0.11547896f, 0.00349598f, -0.03433442f, -0.09314108f, 0.02606781f, -0.05809202f, 0.01016598f, 
    -0.05033448f, 0.02524544f, -0.05397434f, -0.09673208f, -0.10243931f, -0.00134801f, 0.02555156f, 0.02969598f, 
    -0.09220918f, -0.08704222f, -0.08294925f, 0.00323860f, -0.03420469f, -0.00401307f, 0.00957893f, -0.01680754f, 
    -0.05122502f, 0.01677186f, -0.08338252f, 0.05819480f, -0.12113819f, 0.01213057f, -0.07592685f, 0.01356327f, 
    -0.09771867f, -0.00609543f, -0.09303941f, -0.11420786f, -0.06543359f, 0.01082441f, 0.00289421f, 0.04300660f, 
    -0.05864241f, 0.04245143f, -0.09036303f, 0.03150530f, 0.02124178f, -0.02986283f, -0.07944051f, -0.00136249f, 
    -0.12239195f, -0.10777099f, 0.04787017f, 0.02519235f, -0.07809843f, -0.08119641f, -0.07267556f, -0.04465863f, 
    -0.04053856f, 0.02705586f, 0.02665151f, 0.06271800f, -0.08666573f, 0.04384863f, -0.07438163f, -0.11654965f, 
    0.00254477f, 0.03551967f, 0.00819409f, -0.02088656f, 0.03883432f, -0.05135461f, -0.04982642f, 0.02941835f, 
    -0.10783894f, 0.00279802f, 0.02548822f, -0.09371813f, -0.00197585f, -0.07676141f, 0.01034521f, -0.02218133f, 
    -0.10385953f, -0.07274940f, 0.02979680f, -0.06371573f, -0.02435940f, 0.02143793f, -0.06518262f, -0.00501517f, 
    0.00530051f, -0.03481283f, -0.04669373f, -0.06514682f, -0.02764211f, -0.07312997f, -0.06984230f, -0.08164635f, 
    -0.05702682f, 0.05630926f, -0.02167270f, -0.06739303f, -0.01917571f, -0.05097151f, -0.01991981f, 0.03523491f, 
    -0.00768033f, -0.08151525f, -0.01112620f, 0.01007851f, -0.03972613f, 0.00750601f, -0.10631854f, -0.00006644f, 
    -0.10210451f, -0.04855901f, -0.01753229f, -0.09867577f, -0.06989532f, -0.10022701f, -0.11542902f, -0.06953684f, 
    -0.08240478f, -0.05421983f, 0.02387728f, -0.10356887f, -0.06705762f, 0.01732404f, 0.03211478f, -0.02755086f, 
    0.01905645f, -0.01128709f, -0.09705514f, 0.02149454f, 0.03141160f, -0.03564334f, -0.06405509f, -0.10730317f, 
    -0.06308372f, -0.08090210f, -0.02059008f, -0.08713726f, -0.09021056f, 0.00073322f, -0.11646558f, -0.07195958f, 
    -0.41215816f, 0.07954855f, -0.38052928f, 0.17605460f, -0.06410844f, 0.39811605f, -0.04019323f, 0.12119493f, 
    -0.20695171f, -0.02769250f, 0.23578842f, -0.18047132f, 0.03033359f, -0.24473044f, -0.12154277f, 0.16149351f, 
    0.08557051f, -0.00491934f, -0.13867517f, 0.16694961f, -0.12266021f, 0.09705012f, 0.04045694f, -0.08740348f, 
    -0.05907930f, -0.02479838f, 0.30911398f, -0.50275737f, 0.02369805f, -0.18110175f, 0.39445430f, -0.08834691f, 
    0.41008404f, -0.39228544f, -0.09826639f, 0.00383197f, 0.21931754f, -0.22241631f, -0.35474035f, 0.03072512f, 
    0.24395661f, 0.15095307f, -0.05161827f, -0.07607342f, 0.02795935f, 0.28244430f, -0.41286814f, 0.12871708f, 
    -0.25106409f, -0.04634131f, 0.06500901f, -0.02272597f, 0.03020133f, -0.15656681f, -0.02365455f, 0.32565385f, 
    0.02318784f, 0.07619797f, 0.02225813f, -0.00565394f, -0.02457930f, 0.04046530f, 0.08143306f, -0.09513067f, 
    0.32321170f, 0.15012115f, -0.14320973f, 0.18805492f, -0.32192552f, 0.13478838f, 0.11488016f, -0.21949011f, 
    -0.96562207f, 0.31043431f, 0.11290301f, -0.02741827f, -0.06595176f, -0.13520233f, 0.12831374f, 0.05763435f, 
    0.07808981f, -0.13814849f, 0.04184282f, -0.45176953f, -0.07321026f, -0.03835456f, 0.09607514f, 0.13101275f, 
    0.25797296f, -0.11658796f, 0.27083057f, -0.17398554f, 0.19871318f, 0.00946266f, 0.13686655f, 0.02033378f, 
    -0.11843984f, 0.01655648f, -0.14974067f, 0.00082884f, 0.22244109f, 0.17442909f, 0.08796754f, 0.10901531f, 
    0.17967634f, -0.17634614f, 0.14482056f, 0.01333757f, -0.14315018f, 0.37420464f, 0.04782403f, 0.16695677f, 
    -0.09717521f, 0.15612280f, -0.02254653f, 0.13504198f, -0.00236324f, 0.23739490f, -0.01615761f, -0.14897922f, 
    0.09307189f, 0.22527644f, 0.13660753f, 0.12499686f, 0.07257742f, 0.08519141f, 0.02393525f, -0.08909890f, 
    -0.12915602f, -0.14990816f, -0.08670793f, -0.31016916f, -0.04358429f, -0.13453355f, -0.02957235f, 0.24439214f, 
    -0.20075603f, -0.23993960f, 0.21740004f, -0.11338807f, 0.03049278f, -0.16529244f, -0.14716080f, 0.03894944f, 
    0.02880682f, -0.04499156f, -0.04713895f, -0.03866689f, -0.04160728f, -0.07971316f, 0.06666801f, -0.03045590f, 
    -0.01088766f, 0.05676005f, -0.03221173f, -0.08234735f, 0.07444949f, -0.01225970f, 0.07039418f, -0.02661738f, 
    -0.01753022f, -0.07984746f, -0.06527200f, -0.00096091f, -0.03081952f, 0.01805749f, 0.05613932f, 0.01537409f, 
    -0.00363889f, 0.00981459f, 0.01628391f, -0.06246316f, -0.06208904f, -0.01310972f, -0.02038766f, -0.08994970f, 
    -0.06568459f, -0.07570194f, 0.04446148f, 0.00769536f, -0.08491442f, 0.01249616f, 0.02446246f, 0.00656488f, 
    -0.03361275f, 0.03785984f, -0.02360842f, -0.03763571f, 0.00594504f, 0.07145443f, 0.03645229f, -0.01874570f, 
    -0.06161213f, -0.08662912f, -0.00601048f, 0.01136064f, 0.02264744f, -0.05144024f, 0.04961838f, -0.06876486f, 
    -0.08042061f, 0.01025404f, -0.05439215f, -0.07678651f, -0.06474677f, -0.00244468f, -0.04139673f, -0.07482921f, 
    -0.02146877f, -0.07694350f, -0.06510754f, 0.02471527f, -0.01595759f, -0.04758688f, -0.00057935f, -0.03623974f, 
    0.02301018f, -0.08986636f, 0.01055276f, -0.01767099f, 0.03746624f, -0.01991418f, 0.02851398f, 0.07351526f, 
    0.00711716f, -0.01085523f, 0.06620859f, 0.03952325f, -0.04135995f, 0.01403214f, -0.08792247f, -0.04014655f, 
    -0.08001513f, -0.06278527f, -0.07851809f, 0.04963170f, 0.00422731f, 0.01054412f, -0.01828769f, 0.00565009f, 
    -0.04600397f, -0.03958023f, -0.09173072f, 0.01154410f, -0.03170836f, -0.04888971f, 0.07853808f, -0.00965130f, 
    -0.02798345f, 0.07457540f, -0.07100257f, -0.07596625f, 0.02001676f, 0.07397617f, -0.06776380f, -0.03171524f, 
    -0.05825581f, -0.01250586f, -0.01196196f, 0.07728663f, -0.05963742f, 0.02704538f, -0.05682292f, -0.02705344f, 
    0.02102408f, -0.01968737f, 0.02008629f, -0.06254044f, 0.03272973f, -0.06227192f, 0.00019880f, -0.06484771f, 
    -0.06533161f, 0.04504913f, 0.05026456f, 0.01430606f, -0.09207424f, 0.00298023f, -0.06156153f, 0.03288945f, 
    -0.07654477f, 0.02097997f, -0.00073125f, 0.02628141f, -0.05844830f, -0.07748975f, 0.06005628f, -0.00669316f, 
    -0.43793106f, 0.28840303f, -0.11831345f, 0.18408467f, 0.12608480f, -0.01389558f, 0.09925523f, 0.01755490f, 
    -0.14432512f, 0.26375565f, 0.05021987f, -0.01513139f, -0.08755898f, 0.09303309f, -0.15515432f, -0.00210573f, 
    -0.10254596f, 0.08284760f, -0.02435223f, 0.05252535f, 0.08125467f, -0.32221910f, 0.15064469f, 0.01189583f, 
    -0.15980761f, 0.13113144f, -0.05583224f, 0.21703489f, -0.22575785f, -0.12510537f, 0.12212329f, -0.04023958f, 
    -0.16101775f, -0.02202080f, 0.16200364f, 0.15310381f, -0.35952634f, -0.66387534f, -0.53095889f, 0.00014458f, 
    0.02571123f, 0.09641344f, 0.15086739f, -0.11641796f, 0.04863234f, 0.13964176f, 0.08792537f, -0.01765999f, 
    -0.04129481f, -0.09090953f, -0.14618446f, -0.07127870f, -0.04801918f, 0.04242381f, 0.45554480f, 0.11485817f, 
    0.28549087f, 0.02736702f, 0.04846399f, -0.01200321f, 0.01457759f, 0.25474137f, 0.00157732f, 0.28042680f, 
    0.41204709f, 0.33622378f, -0.23842591f, -0.28801998f, 0.23057172f, 0.01874675f, -0.06160803f, -0.02953581f, 
    0.28676939f, -0.05102270f, -0.01096636f, 0.02812210f, -0.00261499f, -0.14395168f, 0.11174822f, -0.07634554f, 
    -0.03020752f, -0.21773593f, -0.12138728f, -0.12351672f, -0.10173161f, 0.04376632f, 0.01091741f, -0.06072297f, 
    -0.02089997f, -0.10864426f, 0.03390192f, -0.10607342f, 0.03556656f, -0.03235158f, -0.04305977f, 0.05654140f, 
    0.01242954f, -0.03785139f, 0.05298243f, -0.24558918f, -0.27578965f, 0.13258094f, 0.01785662f, 0.19660874f, 
    0.02226467f, -0.03039677f, -0.12287065f, -0.01947744f, 0.05150678f, 0.03001779f, -0.00996113f, -0.05627020f, 
    0.04715719f, 0.10511474f, 0.10941218f, -0.04453440f, 0.00501458f, -0.47428307f, -0.17199196f, 0.04530045f, 
    0.05423393f, 0.08089594f, 0.02142801f, 0.14404732f, -0.14914195f, 0.12245782f, -0.02744075f, 0.02256048f, 
    0.01416004f, 0.04969468f, -0.24125987f, 0.11895784f, 0.18054068f, 0.20543616f, -0.15325031f, 0.00919446f, 
    0.28151274f, 0.25215760f, 0.06889174f, -0.24594961f, -0.04642449f, -0.13536006f, 0.18530129f, -0.08055017f, 
    0.08907907f, 0.14514862f, 0.10781226f, -0.07358550f, -0.08370882f, -0.08167306f, 0.08266471f, -0.09641308f, 
    0.21923724f, -0.05047151f, -0.05235605f, 0.35203847f, -0.22594778f, -0.15216166f, 0.12872352f, -0.18581662f, 
    -0.00181270f, -0.07023738f, 0.02350327f, 0.28594473f, 0.09476939f, 0.19919090f, 0.20804876f, -0.03403572f, 
    0.08241836f, -0.05772029f, 0.08364613f, -0.61248022f, -0.23485845f, -0.34965545f, 0.00869108f, -0.08774398f, 
    -0.08878494f, -0.09531885f, 0.03231224f, 0.01265666f, -0.48969105f, -0.34235191f, 0.03509903f, 0.12373004f, 
    0.17837946f, -0.12379960f, -0.02455825f, -0.03725563f, 0.05006261f, 0.00371438f, -0.26112154f, -0.09789961f, 
    -0.04216522f, -0.19279009f, 0.07628154f, 0.02993927f, -0.05686550f, 0.11969132f, -0.05636607f, 0.06752381f, 
    -0.23036164f, 0.14720418f, -0.17000566f, -0.23670425f, 0.11158437f, 0.03227000f, 0.25865212f, -0.90411383f, 
    0.01226375f, 0.26782936f, 0.00085444f, 0.07616784f, -0.03378594f, -0.17049451f, 0.08257831f, 0.08717984f, 
    0.12038195f, 0.17081785f, 0.16086347f, -0.05388561f, -0.01620044f, 0.00090451f, 0.08464497f, 0.07216048f, 
    0.08526862f, -0.35954762f, 0.27264282f, -0.01051809f, 0.06626819f, 0.14012928f, -0.12431537f, 0.23772249f, 
    0.11687066f, -0.25124300f, -0.38477442f, 0.13174720f, 0.00980703f, 0.14182912f, -0.03041171f, -0.00852868f, 
    -0.01365999f, 0.09606007f, -0.13015646f, -0.29398429f, 0.07039964f, -0.61266261f, 0.27034187f, -0.05051379f, 
    -0.03604036f, 0.13137470f, -0.07919767f, 0.06996858f, 0.13094391f, 0.16257635f, 0.07600044f, 0.19741856f, 
    -0.01079564f, -0.03608228f, 0.13331813f, -0.03638329f, -0.10848387f, 0.26375812f, 0.18982701f, -0.26546329f, 
    0.04811901f, -0.03704836f, -0.02736348f, 0.08448751f, -0.07221303f, 0.00439997f, -0.29913703f, -0.06140244f, 
    0.08730093f, 0.07056378f, -0.04992364f, -0.00493213f, -0.05764673f, -0.03085982f, -0.07086076f, -0.22848237f, 
    -0.06721767f, 0.34987727f, -0.08945420f, 0.06178721f, 0.11980388f, -0.05635161f, -0.06780562f, 0.28107986f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.11328395f, 0.16956253f, 0.17302428f, -0.22519331f, 0.16011575f, -0.04768269f, -0.06982747f, 0.17833854f, 
    -0.03698282f, -0.13870151f, -0.00607771f, -0.06545857f, 0.16741827f, 0.01126581f, 0.16509072f, 0.11037436f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16931994f, 0.32110244f, -0.37447923f, -0.45253217f, 0.22900382f, 0.03283250f, 0.35406998f, 0.14502470f, 
    0.19570544f, -0.27101415f, -0.30562162f, 0.17777379f, 0.17142932f, -0.14985621f, 0.23973669f, -0.24085495f, 
    -0.14359683f, -0.14533788f, -1.18919671f, -0.09834089f, 0.37526214f, -0.13479266f, 0.05748967f, 0.35958216f, 
    -0.24413365f, 0.05075894f, 0.15820099f, 0.16550094f, -0.10105859f, 0.22849438f, -0.44011414f, -0.01195804f, 
    0.64831293f, 0.23934637f, -0.06184492f, 0.20739944f, -0.07924394f, -0.13427430f, 0.36211923f, -0.16828628f, 
    0.12664466f, -0.39195153f, 0.03606426f, 0.12287310f, -0.07288887f, 0.23262152f, 0.48152077f, 0.14322592f, 
    -0.05877265f, 0.47104642f, 0.22349891f, -0.09000841f, -0.11490423f, -0.05542171f, 0.47540843f, -0.41139507f, 
    0.21058373f, -0.19330689f, -0.45486185f, 0.21759313f, 0.21033587f, -0.21914384f, 0.31148413f, -0.50197250f, 
    -0.35101533f, 0.06809723f, 0.54662156f, 0.29644871f, -0.00452056f, 0.11191958f, 0.07743711f, 0.19759928f, 
    -0.09797356f, 0.26853657f, -0.40028349f, 0.05954335f, 0.08413409f, 0.21480331f, -0.29725474f, 0.04027886f, 
    -0.04642166f, 0.03769866f, -0.29734325f, 0.12068879f, -0.21223751f, 0.16611569f, -0.07394210f, 0.00188095f, 
    0.00660945f, -0.21037532f, 0.18260314f, 0.18314691f, -0.20892541f, 0.06810229f, 0.15782550f, -0.04618351f, 
    -0.37660009f, 0.42825282f, 0.39597234f, 0.38755000f, 0.32425860f, -0.04931840f, -0.30838263f, -0.01058990f, 
    0.19038749f, -0.19690050f, 0.22048095f, 0.10276081f, -0.48597005f, 0.23570532f, -0.45126852f, -0.06437487f, 
    -0.10357241f, -0.20826946f, 0.44117370f, -0.02093561f, 0.44431987f, -0.14158779f, -0.00706339f, -0.19026722f, 
    0.00490089f, 0.00757316f, -0.01453611f, 0.05122354f, 0.16886091f, -0.07382283f, -0.53491956f, -0.17764564f, 
    0.07698688f, 0.22184230f, -0.22837491f, 0.16340277f, -0.36142021f, -0.14950372f, 0.28901452f, 0.22508378f, 
    0.07809044f, 0.32061183f, -0.00181350f, -0.07708011f, -0.34810102f, -0.12439932f, 0.23693515f, 0.52432269f, 
    -0.33440036f, 0.08633354f, 0.29407763f, 0.65311408f, -0.07547709f, -0.03423479f, 0.32100257f, 0.19442599f, 
    -0.06819019f, 0.54357767f, -0.09477269f, -0.07479740f, -0.36281767f, 0.17676498f, -0.30653933f, -0.93429291f, 
    0.19662394f, 0.27311522f, -0.06856026f, -0.33162475f, 0.32634956f, -0.22543649f, 0.07208700f, -0.35178193f, 
    -0.14275098f, -0.63696462f, 0.27823767f, 0.20518112f, 0.12509273f, 0.01453702f, -0.23534289f, 0.45450738f, 
    -0.04602246f, -0.32658550f, 0.32997283f, 0.19770427f, 0.19973536f, -0.16100460f, -0.38784143f, 0.47600532f, 
    -0.07361311f, 0.27918643f, 0.48789069f, 0.21237159f, 0.25955641f, -0.12248938f, -0.28087118f, 0.05130926f, 
    0.08915605f, -0.23791127f, -0.20224594f, 0.43659401f, -0.15973444f, -0.04327176f, -0.38598764f, 0.52473515f, 
    -0.09863038f, 0.32823947f, 0.55568635f, 0.14175284f, 0.23939823f, -0.12024508f, 0.49420682f, 0.52974296f, 
    -0.88726473f, 0.23763733f, -0.13841806f, -0.06868066f, 0.08557016f, 0.13137344f, -0.08858211f, -0.25701091f, 
    -0.05749610f, 0.24131151f, 0.35530731f, 0.12644319f, -0.03367160f, 0.01319906f, 0.35325235f, -0.45851931f, 
    -0.19887620f, -0.24114385f, -0.06401601f, 0.15051812f, -0.15675142f, -0.19574028f, -0.22923896f, 0.02895257f, 
    0.12402767f, -0.08551705f, -0.19447005f, -0.00519499f, -0.02949920f, -0.21888807f, 0.17366499f, -0.00319231f, 
    0.30464548f, -0.48768908f, -0.17374405f, 0.17320938f, 0.12132526f, 0.13992268f, 0.25348309f, 0.68579328f, 
    0.16643448f, -0.22784732f, 0.04323517f, -0.09553196f, -0.23961173f, -0.15517220f, 0.53033435f, 0.37468994f, 
    -0.15745513f, 0.50947535f, 0.09009433f, 0.08469544f, 0.39584786f, -0.17994577f, -0.20554069f, -0.31550246f, 
    -0.13592590f, -0.22324495f, -0.05240489f, -0.22652236f, -0.20413095f, 0.09421691f, -0.43771785f, -0.20135404f, 
    -0.16028474f, 0.30669940f, 0.22289689f, -0.31424946f, 0.08717250f, -0.06776936f, 0.18572843f, -0.70334297f, 
    0.06009166f, -0.42208773f, -0.74157435f, -0.05277366f, 0.32232893f, -0.17373823f, 0.28200799f, 0.50120288f, 
    -0.20647584f, 0.56010383f, 0.32957992f, 0.04908648f, 0.08239416f, -0.19283924f, -0.03152021f, -0.00755223f, 
    -0.19910198f, -0.57611942f, -0.00141925f, -0.10960925f, -0.52313817f, 0.01096159f, 0.03062137f, 0.14320318f, 
    0.22048147f, 0.01324355f, -0.14967543f, 0.17349333f, 0.38997290f, -0.19434571f, -0.39506426f, -0.34333175f, 
    0.12113023f, -0.52886301f, -0.13484779f, -0.04670358f, 0.10866552f, -0.19250885f, -0.29698381f, -0.77415067f, 
    -0.26476011f, -0.07051793f, 0.42893863f, 0.04858719f, 0.30246326f, -0.08653816f, -0.41077009f, -0.14211309f, 
    0.06723396f, -0.15612185f, 0.32033843f, 0.11570357f, 0.04569703f, -0.03106298f, 0.35240975f, -0.02317023f, 
    0.13897437f, 0.10804325f, -0.41007647f, 0.40873027f, 0.33497587f, -0.19179745f, -0.34567440f, 0.06300811f, 
    0.23399256f, 0.01725562f, 0.36213237f, 0.03725227f, -0.37098888f, -0.11498076f, -0.23618416f, -0.44672033f, 
    -0.16338432f, -0.09490067f, -0.19259259f, -0.20045590f, -0.02328244f, 0.04725084f, -0.04190359f, -0.18293715f, 
    0.11753595f, 0.23331803f, -0.07725519f, 0.08589470f, -0.21620700f, 0.14798310f, -0.14683002f, -0.12632367f, 
    0.17197607f, -0.02479216f, -0.43748122f, -0.11424463f, -0.19048975f, -0.06870335f, -0.06096676f, -0.22289182f, 
    0.17606057f, 0.14866650f, 0.16106589f, -0.11329348f, 0.56212652f, 0.21870591f, 0.26137123f, 0.40645120f, 
    -0.19832592f, 0.18971783f, -0.12262957f, -0.26033935f, 0.34795424f, -0.01473833f, -0.38058215f, 0.51280028f, 
    -0.01603629f, -0.32974228f, -0.18212149f, -0.01161606f, 0.36905175f, 0.19197725f, -0.13922849f, -0.37469959f, 
    -0.09679365f, 0.29524240f, -0.94872260f, 0.39587292f, 0.44734067f, -0.11397931f, 0.00550246f, -0.00044841f, 
    0.16678002f, -0.13895093f, -0.16764447f, -0.18657888f, -0.44432795f, -0.12724945f, -0.03724448f, -0.35567796f, 
    0.27351698f, 0.33284366f, 0.40166551f, 0.25394684f, -0.09674008f, 0.19175363f, -0.16222066f, -0.09460728f, 
    -0.19549130f, -0.32426056f, -0.30819020f, -0.01849354f, 0.04406033f, -0.14946209f, -0.38866532f, 0.81201476f, 
    0.03849202f, 0.50889808f, -0.35951126f, -0.18137480f, -0.35482240f, -0.14271985f, 0.23397949f, 0.21656154f, 
    0.19081147f, 0.22674343f, -0.41522571f, 0.04470720f, 0.56579059f, -0.07972526f, 0.46435702f, -0.11735902f, 
    0.01290863f, -0.15642343f, -0.24913469f, -0.04575113f, 0.22256222f, 0.08311439f, 0.58879960f, 0.12105452f, 
    0.11554468f, 0.18176159f, 0.34305865f, 0.08417560f, -0.67942679f, 0.19643845f, 0.36118710f, -0.75222188f, 
    0.41310060f, -0.07954837f, 0.12670225f, 0.11662011f, 0.30723262f, 0.03308013f, 0.26089832f, 0.19031739f, 
    0.16105549f, -0.34113932f, -0.08175843f, 0.04946165f, -0.09086746f, -0.15133898f, -0.46730468f, -0.36439541f, 
    0.24418388f, -0.02712355f, -0.18410389f, -0.17203180f, -0.10313553f, 0.02050965f, -0.07551713f, 0.03936885f, 
    0.20034742f, -0.04382078f, 0.45237246f, -0.06200438f, 0.18852071f, -0.01832373f, 0.61421460f, -0.47310951f, 
    -0.08235633f, -0.19902197f, -0.20391488f, 0.08637473f, -0.23112655f, 0.23279232f, -0.19240144f, 0.03465638f, 
    0.21872118f, -0.20908526f, -0.07321826f, 0.21037894f, -0.14530745f, 0.04611349f, -0.06410769f, -0.03528640f, 
    -0.18937151f, -0.05491724f, 0.02804335f, -0.21003000f, -0.23158744f, -0.19334373f, -0.04929961f, 0.20267235f, 
    -0.18397357f, 0.04000070f, -0.22715004f, 0.13944243f, -0.09184541f, 0.15047000f, -0.04591063f, -0.06489138f, 
    0.10648853f, 0.29559863f, 0.07444057f, -0.63315839f, 0.17357051f, 0.05859328f, -0.31163988f, 0.29151902f, 
    -0.14456904f, -0.13679583f, -0.45338252f, -0.02889370f, 0.29083365f, 0.03256270f, -0.29169074f, -0.48228520f, 
    -0.24658212f, -0.18779624f, 0.17740303f, -0.23082736f, -0.14608008f, 0.20898712f, 0.07853159f, -0.02037272f, 
    -0.06644052f, 0.03995171f, -0.15081334f, 0.09761360f, -0.19711795f, -0.16814950f, -0.21430275f, -0.22309411f, 
    0.11665962f, -0.16851653f, 0.02480660f, -0.13520591f, -0.18400942f, -0.15530685f, -0.23552507f, 0.23425141f, 
    -0.04356116f, -0.18601291f, -0.14732046f, -0.10853146f, -0.23119166f, -0.02733207f, 0.18456097f, 0.02455160f, 
    0.14030522f, -0.14094277f, 0.02097080f, 0.06645820f, 0.34770337f, 0.21967751f, -0.34131780f, -0.63490921f, 
    -0.06589754f, -0.13510931f, 0.08160837f, -0.11312620f, 0.29191259f, -0.11336840f, -0.29256105f, 0.19173713f, 
    -0.09222884f, 0.28866884f, 0.39928487f, 0.01482797f, 0.25806236f, 0.19478621f, 0.11796308f, -0.39226168f, 
    -0.12036993f, -0.22784024f, -0.06038246f, 0.04893023f, -0.32322308f, -0.08509675f, 0.16755870f, -0.08545673f, 
    -0.33054367f, 0.18347344f, 0.14108443f, 0.11017678f, 0.14704730f, 0.14080457f, -0.31875914f, 0.11740601f, 
    0.14895038f, 0.29449034f, 0.07388496f, -0.20078112f, 0.07793848f, 0.11496164f, 0.24487133f, 0.44660294f, 
    -0.23984315f, -0.21219283f, 0.52622491f, 0.08818188f, -0.00316387f, 0.10418867f, -0.15835711f, 0.38096029f, 
    0.01662255f, 0.23323414f, 0.32099202f, -0.06120897f, 0.15110689f, 0.09246037f, -0.19924684f, 0.71410120f, 
    0.02405825f, 0.48539644f, 0.09949692f, -0.04699838f, -0.21018824f, -0.09116483f, 0.37601271f, -0.03767110f, 
    0.10334371f, 0.02455497f, -0.08126777f, -0.01079119f, -0.16600874f, -0.04665001f, 0.53016669f, -0.23634000f, 
    0.38670951f, 0.03724147f, 0.04670194f, 0.18602480f, 0.33313802f, -0.11600528f, -0.18814668f, -0.39168534f, 
    -0.16615179f, -0.09227430f, -0.27349174f, 0.17116170f, 0.11742260f, -0.25215510f, -0.43102753f, 0.37107804f, 
    -0.24738635f, 0.21124876f, 0.12008502f, -0.17475510f, 0.07378589f, -0.22845516f, -0.42623585f, -0.36092117f, 
    -0.11790201f, -1.18381059f, 0.16733006f, 0.22954246f, 0.33863708f, -0.18284258f, 0.11060687f, 0.78703201f, 
    0.36042693f, -0.10601443f, -0.08451518f, -0.00022512f, -0.08621339f, -0.13829312f, 0.69196451f, 0.26650602f, 
    0.22084537f, -0.31099531f, -0.07400385f, 0.19748390f, -0.04995607f, 0.09355480f, -0.02152697f, -0.28402707f, 
    -0.04395283f, -0.21679233f, -0.28189793f, -0.01659420f, -0.08762076f, 0.11040175f, 0.20869833f, -0.13568053f, 
    0.05942262f, -0.06976055f, -0.10044426f, 0.15595341f, 0.14311217f, 0.08515444f, -0.16119222f, 0.03915562f, 
    0.36623424f, -0.32488060f, 0.11888881f, -0.14660826f, 0.24362828f, -0.06217191f, -0.10879052f, 0.11709911f, 
    0.10847306f, -0.41880089f, 0.33119118f, -0.09860560f, -0.07829598f, 0.17079136f, 0.10690068f, -0.42707086f, 
    -0.25884697f, 0.21746513f, -0.03157937f, 0.30588147f, -0.06754872f, -0.09632227f, 0.28004158f, -0.02276868f, 
    0.00502220f, 0.30802825f, -0.35208780f, -0.05851297f, -0.07633074f, 0.24592134f, 0.70105666f, 0.41092494f, 
    0.04249727f, -0.46724334f, -0.01183788f, 0.15964356f, 0.17370057f, 0.14348939f, 0.47417656f, 0.19454594f, 
    -0.06825463f, 0.54994011f, -0.52002805f, 0.00201603f, -0.10814647f, -0.17260569f, -0.19759260f, -0.55175954f, 
    0.07124297f, -0.01175091f, -0.02002603f, -0.26783657f, -0.23405384f, 0.09020507f, -0.18060388f, 0.11538177f, 
    -0.20290534f, -0.00624135f, 0.18818705f, -0.11272372f, -0.10554837f, 0.02151853f, 0.11259905f, -0.19794506f, 
    0.23354974f, 0.00105802f, 0.54997206f, 0.58474112f, 0.01437788f, -0.01823020f, 0.21128921f, -0.23816857f, 
    -0.03774260f, 0.09091352f, 0.18657826f, 0.01533484f, -0.36977819f, 0.18541111f, -0.21932481f, -0.08678498f, 
    -0.41697097f, 0.26853445f, -0.00622433f, -0.51277059f, -0.15985610f, 0.04456300f, 0.52686727f, 0.07118528f, 
    -0.07786522f, 0.23307811f, 0.03592318f, -0.23526463f, 0.72120941f, -0.18109593f, -0.16399693f, -0.04126387f, 
    -0.04064076f, -0.17078541f, -0.12163515f, 0.12519439f, -0.12648100f, -0.05789417f, -0.05112024f, -0.15535522f, 
    -0.19479258f, -0.05834463f, -0.01147453f, 0.24195385f, 0.08062121f, 0.20957190f, -0.10559644f, -0.06833711f, 
    0.32749853f, 0.11503931f, 0.41148740f, -0.47073045f, 0.01279424f, 0.13325277f, 0.08092252f, 0.31976992f, 
    -0.07421576f, -0.08892411f, -0.42959088f, 0.17413488f, 0.11459916f, -0.20385253f, -0.16571014f, -0.36029258f, 
    -0.09952205f, 0.10213888f, 0.09360612f, -0.08948732f, -0.18252394f, -0.20976499f, -0.17944524f, -0.01727631f, 
    0.06383049f, -0.09783231f, 0.16585778f, 0.24230772f, -0.23941258f, -0.04527414f, -0.18787782f, 0.12959898f, 
    0.37336457f, -0.05980956f, 0.04044466f, 0.36857966f, -0.39891669f, -0.07458021f, 0.06555936f, -0.26677662f, 
    -0.15087527f, 0.41625661f, 0.40688610f, -0.19843885f, 0.37627810f, -0.19626854f, 0.26312813f, 0.37747303f, 
    0.22662747f, 0.20210531f, 0.22923361f, -0.33182535f, 0.07560661f, 0.19413245f, 0.19040591f, -0.06536716f, 
    0.21930411f, -0.03681625f, -0.26004612f, -0.03430606f, -0.00500052f, -0.12370524f, 0.10041851f, -0.50004905f, 
    -0.27549395f, 0.31578755f, 0.26732144f, 0.32447982f, 0.02251553f, -0.15922159f, 0.30693808f, -0.33522373f, 
    -0.25028762f, 0.15246777f, 0.16407247f, 0.15442340f, -0.19893903f, 0.22321182f, 0.01252945f, 0.45765951f, 
    0.35234803f, -0.21289563f, 0.00102498f, -0.01414987f, 0.47041723f, -0.11343285f, -0.30903769f, 0.23618656f, 
    0.00339611f, 0.05455336f, 0.49400178f, 0.12635790f, -0.11856899f, 0.24352860f, -0.30010593f, -0.42956677f, 
    0.07343619f, -0.04512050f, -0.17869614f, 0.68462229f, 0.11030630f, -0.04792130f, -0.06632818f, -0.50337464f, 
    -0.11574093f, 0.54972267f, -0.14231698f, -0.21880971f, 0.34102592f, 0.03168425f, 0.02163902f, -0.07458482f, 
    0.04396714f, 0.29360217f, -0.28420261f, 0.81726569f, 0.11938236f, -0.06674682f, -0.40590909f, -0.14216481f, 
    0.18424639f, 0.42150006f, -0.19462442f, -0.06218724f, 0.03012708f, 0.20526741f, -0.26885837f, 0.48734930f, 
    -0.37427488f, 0.13531397f, 0.08651392f, 0.39238328f, 0.38123652f, 0.08693999f, -0.05118922f, -0.34365410f, 
    0.12708136f, -0.00343816f, -0.33211589f, 0.02431663f, 0.42391142f, 0.19816571f, -0.14595318f, -0.39742419f, 
    0.15147759f, -0.25307542f, -0.07289473f, -0.14854744f, 0.02112208f, 0.13038741f, -0.47989503f, 0.80692202f, 
    0.13946989f, 0.08431843f, 0.57564121f, -0.09576875f, 0.25839356f, 0.14225589f, -0.16437803f, -0.23253416f, 
    0.23101358f, 0.29315954f, -0.27082679f, -0.25471756f, 0.35192090f, 0.19951448f, -0.13484408f, -0.12730309f, 
    -0.21632147f, 0.07413559f, -0.19367523f, 0.14750685f, 0.44209650f, -0.02397546f, -0.08787108f, -0.09676833f, 
    0.48123509f, -0.17598411f, 0.61205989f, -0.11016911f, 0.15392241f, 0.23516361f, 0.02111257f, -0.13692190f, 
    -0.20528293f, -0.30670688f, 0.32212114f, -0.12687424f, -0.26766813f, 0.01759739f, -0.18313056f, 0.51243824f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00670259f, 0.05427521f, -0.15083371f, 0.01168567f, 0.01750675f, 0.06891386f, 0.02323288f, 0.29353952f, 
    0.05704012f, -0.26277134f, 0.13537711f, 0.05017253f, -0.10555201f, 0.11431424f, -0.12870523f, 0.12620582f, 
    0.43191141f, 0.34075180f, 0.24701861f, 0.09804114f, 0.69569576f, 0.15598728f, -0.20168939f, 0.02550483f, 
    0.63215721f, 0.19057658f, -0.10876988f, 0.11218339f, 0.12217288f, -0.04002926f, -0.11045117f, -0.05843303f, 
    0.14389181f, 0.48375970f, -0.16446164f, 0.06586802f, 0.24039768f, 0.16997001f, 0.52106375f, 0.24658641f, 
    0.03187813f, -0.17232129f, 0.24049464f, 0.37063539f, -0.10339029f, -0.02584666f, 0.03536332f, -0.17800391f, 
    -0.12977849f, -0.19819011f, 0.30080506f, 0.21118571f, 0.48710406f, -0.05644675f, -0.47198984f, -0.12116345f, 
    -0.24586149f, -0.24213371f, -0.40957272f, -0.26543579f, -0.01853582f, 0.26666176f, -0.15140015f, 0.33691195f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.24096113f, 0.05902579f, 0.04846622f, 0.16318281f, -0.04728807f, 0.15599962f, 0.12450957f, -0.02153523f, 
    0.13356000f, -0.17314759f, 0.02970769f, -0.22282481f, -0.10190619f, -0.03172978f, 0.02328569f, -0.43733481f, 
    0.23569860f, -0.16812152f, 0.23665480f, 0.28081125f, -0.16052149f, 0.14943554f, 0.07476670f, -0.00998096f, 
    0.11171972f, 1.05096316f, -0.39807183f, 0.15409330f, 0.26184157f, -0.19685480f, -0.00005330f, 0.04226241f, 
    -0.02871412f, 0.05278847f, 0.10105263f, 0.07998058f, -0.30314180f, 0.10913654f, 0.06535085f, -0.34153894f, 
    0.37713945f, -0.26744634f, -1.23257077f, -0.26381305f, -0.00141100f, -0.11640000f, 0.15038757f, -0.82042772f, 
    -0.04838443f, -0.07767414f, 0.04589322f, 0.01429924f, 0.06152710f, 0.01299379f, -0.10933094f, 0.22109209f, 
    0.09568971f, -0.11675684f, -0.14225714f, -0.09574097f, 0.03856183f, -0.20608859f, 0.07165883f, -0.42340848f, 
    0.26114336f, -0.45118004f, 0.12419461f, 0.35766798f, -0.16771981f, -0.06240475f, -0.35367185f, -0.22631627f, 
    0.20154299f, -0.27124459f, 0.01702295f, -0.47701845f, -0.15734912f, 0.52295405f, 0.04938452f, 0.25788844f, 
    0.15900193f, 0.61719400f, -0.13883749f, -0.09348264f, 0.11075652f, -0.21719404f, 0.10446914f, 0.04785755f, 
    0.17297865f, 0.05909728f, -0.06182408f, 0.35879207f, 0.34284949f, -0.21689361f, 0.06182464f, -0.08572902f, 
    0.01424344f, 0.33386382f, 0.10593453f, -0.08642337f, 0.05447060f, 0.05873857f, -0.12854175f, -0.34892040f, 
    0.33903927f, -0.24550430f, 0.19966006f, 0.26236776f, -0.20480639f, -0.23732020f, 0.25510547f, 0.07536263f, 
    0.04605679f, -0.17379917f, 0.09700923f, 0.04516803f, 0.08964559f, -0.14413750f, -0.00033437f, 0.14050755f, 
    -0.11352329f, -0.39401075f, -0.06135895f, -0.43438771f, -0.02606025f, -0.08778141f, -0.09477177f, -0.46457818f, 
    -0.28663474f, 0.13573736f, -0.80814880f, -0.32478949f, 0.16502409f, -0.06890183f, -0.12276300f, 0.23534499f, 
    -0.44062582f, -0.06112634f, -0.23158082f, 0.51133734f, 0.20231259f, 0.33499527f, 0.00083405f, -0.92087203f, 
    -0.14568494f, -0.39969909f, -0.93864727f, -0.15139307f, 0.09310450f, -0.11800919f, -0.10274704f, 0.18820831f, 
    0.13510169f, -0.46854806f, -0.37661704f, 0.06090684f, -1.00926197f, -0.33299851f, -0.01172226f, -0.02595292f, 
    -0.01209014f, -0.21184683f, 0.06705199f, 0.06999714f, 0.23072642f, -0.25823221f, 0.11591439f, 0.40388429f, 
    -0.42131051f, 0.02052708f, -1.06610894f, -1.32584953f, -0.03148600f, -0.13961226f, -0.06491330f, 0.00285513f, 
    -0.07380147f, -0.30914271f, 0.35321674f, 0.11532561f, -0.15203689f, -0.04597562f, 0.18782067f, -0.33615530f, 
    -0.15989606f, -0.01320298f, 0.28277415f, 0.11385648f, 0.15981303f, 0.63369799f, 0.18841057f, -0.55647016f, 
    0.14922668f, 0.09126594f, 0.23938170f, -0.44477955f, -0.80257553f, -0.09073875f, -0.50873119f, 0.11508778f, 
    -0.23106243f, -0.46843711f, 0.40082628f, 0.11133424f, 0.00814344f, -0.57545173f, 0.01070556f, 0.13891846f, 
    -0.61164194f, -0.95201635f, -0.61401153f, -0.07516440f, -0.65784979f, -0.01885440f, 0.07384391f, 0.14439486f, 
    -0.32575577f, -0.14642321f, -0.40974656f, -0.18815215f, 0.15105309f, 0.33321577f, 0.15945306f, 0.03882273f, 
    0.07275938f, -0.05038719f, -0.02989121f, -0.10030699f, -1.12541687f, -0.13704404f, -0.43143120f, -0.04866718f, 
    -0.35094666f, 0.11429267f, -0.97770464f, 0.35388562f, 0.09492426f, 0.52156454f, -0.88546836f, -0.00135420f, 
    0.10103004f, 0.12338227f, -0.16213141f, 0.03004984f, 0.19133776f, 0.08548454f, 0.14573838f, 0.22226015f, 
    -0.49619469f, 0.24422105f, -0.44083852f, -0.72129750f, -1.10402000f, 0.17606834f, -0.00948559f, 0.48685259f, 
    -0.00086028f, -1.16788483f, -0.10301488f, -0.39319953f, -0.18937929f, -0.07770909f, 0.16213316f, 0.23187967f, 
    -0.32007343f, 0.13229299f, 0.07994163f, 0.13150355f, 0.00886371f, 0.13760532f, -0.02666028f, 0.06725528f, 
    0.02342955f, -0.24694447f, 0.09914187f, -0.63592935f, 0.24487151f, 0.11307208f, -0.11105074f, 0.02131539f, 
    -0.04643232f, -0.41461682f, -0.29038981f, -0.32939750f, 0.19669756f, 0.03982417f, 0.05608108f, -0.05535728f, 
    0.02592709f, -0.52636272f, 0.04858252f, -0.04188147f, -0.18705311f, 0.16056728f, 0.12227271f, 0.12733240f, 
    -0.20420823f, -0.00616223f, -0.18370429f, -0.06267780f, -0.20114981f, 0.09106286f, -0.03607494f, 0.30259597f, 
    0.09493406f, 0.09232451f, -0.00110437f, 0.07477961f, -0.28202611f, -0.01033877f, -0.27836338f, -0.17971681f, 
    0.08558670f, 0.02500892f, -0.06724638f, 0.01868815f, 0.08736472f, 0.00584959f, -0.01263608f, 0.06245699f, 
    0.17191267f, -0.07516713f, 0.07855918f, 0.18705848f, 0.20303835f, 0.09717324f, 0.07599670f, 0.13546833f, 
    -0.25457308f, 0.64419180f, 0.10194499f, -0.24656993f, -0.40300447f, -0.82266617f, 0.06728996f, -1.00916672f, 
    0.16023619f, 0.30357203f, 0.10294784f, -0.88950217f, -0.53217071f, -0.17159350f, -0.05444497f, 0.24163462f, 
    -0.04611580f, -0.37717262f, 0.24547514f, 0.20191580f, -0.09010971f, 0.17806803f, -0.43063051f, 0.03393513f, 
    0.06522603f, 0.17226551f, -0.04312122f, 0.03477481f, -0.04652565f, -0.04739604f, -0.20468393f, -0.21987155f, 
    -0.06794932f, 0.26796025f, 0.59033823f, 0.10611740f, -0.05330200f, -0.94099581f, -0.15144065f, 0.37054110f, 
    0.03882620f, 0.05816314f, 0.22883785f, -0.06812426f, 0.12610988f, -0.15195440f, -0.09497175f, 0.08084473f, 
    0.04484418f, -0.26982281f, 0.09829217f, 0.14054768f, 0.32558808f, -0.37653503f, 0.09972694f, -0.20144297f, 
    -0.15611139f, -2.15978336f, -0.20676661f, -0.06037646f, 0.22559452f, -0.08277089f, 0.41610190f, 0.29176134f, 
    -0.12562011f, -0.06550436f, 0.14676915f, 0.05433766f, -0.49220464f, -0.08158898f, -0.05034149f, -0.36614308f, 
    0.25367802f, -0.11194869f, 0.25431916f, 0.28562897f, 0.15293996f, -0.01637345f, 0.08803606f, -0.58239448f, 
    0.07061080f, -1.39400518f, 0.15332603f, -0.35857347f, -0.17710052f, 0.09711318f, -0.32451046f, 0.02271327f, 
    -0.01275166f, 0.37727892f, -0.08524208f, 0.08039976f, 0.24446027f, 0.20261203f, -0.03071169f, 0.06671819f, 
    -0.07090276f, 0.11876183f, -0.57659638f, -0.17153007f, -0.11734840f, 0.17020865f, -0.23329452f, -0.59288186f, 
    -0.04367838f, 0.19673409f, -0.04342911f, -0.00752464f, 0.26650959f, -0.03000489f, -0.57076889f, 0.03994875f, 
    -0.01478302f, 0.06893121f, -0.30525517f, -0.25628951f, 0.00897474f, -0.24560837f, 0.02359496f, 0.31909984f, 
    -0.71107191f, 0.26223978f, 0.09611492f, -0.11110065f, -0.17084517f, -0.00708307f, -0.30727640f, -0.21407452f, 
    0.12397140f, 0.40098995f, -1.02139270f, 0.13191871f, 0.18045326f, 0.44267750f, -0.09295762f, -0.14930367f, 
    -0.77464265f, 0.44566339f, -0.88364720f, -0.34396905f, 0.05744489f, 0.06634313f, 0.09007229f, -0.08114519f, 
    -1.33992851f, 0.23679422f, -0.13295928f, -0.10281438f, 0.04523113f, 0.02397496f, -0.03082451f, 0.07911992f, 
    -0.06361711f, -0.69065064f, 0.06363539f, 0.00010700f, -0.85358465f, -0.21533248f, -0.15910122f, 0.05361214f, 
    -0.03415301f, -0.42216337f, -0.65659112f, -0.21774152f, -0.00478111f, 0.05031947f, 0.13747892f, 0.11200962f, 
    -0.03136106f, 0.35571149f, -0.34963572f, -0.14391765f, -0.76903284f, -0.10188075f, 0.28014591f, -0.12679870f, 
    0.06312134f, 0.09008633f, 0.30750296f, 0.20810388f, 0.09365132f, 0.01802772f, -0.38541868f, -0.01288553f, 
    0.04002285f, 0.41139102f, 0.19239902f, 0.07325383f, -0.17806701f, 0.08056101f, -0.71161795f, -0.54799116f, 
    0.50414485f, -0.34627175f, 0.18208881f, -0.35253388f, 0.16442172f, -0.69568825f, 0.09421390f, 0.05211366f, 
    -0.28741866f, 0.35054666f, 0.18026249f, -1.23287404f, -0.34950849f, -0.57836479f, -0.11648419f, 0.34503278f, 
    -0.69700783f, -0.43578503f, 0.37904447f, 0.29604393f, -0.68860370f, -0.39417106f, -0.08990946f, 0.11922178f, 
    0.00442572f, -0.96356899f, 0.05543768f, 0.08441017f, -0.01405182f, -0.08532066f, 0.07736923f, 0.07811647f, 
    0.25117204f, 0.02617976f, -0.30256054f, 0.13825627f, -0.05916326f, -0.15381569f, 0.30454704f, -0.60880512f, 
    -0.01559444f, -0.31888247f, 0.04585896f, 0.06547115f, -0.37779033f, -0.05688324f, 0.40855280f, -0.37687829f, 
    0.21520603f, -0.61482477f, 0.01095912f, 0.19776602f, -0.60922605f, -0.41846463f, 0.10341210f, 0.07855938f, 
    -0.36147311f, -0.28915426f, 0.01980596f, -0.50705177f, 0.04137415f, -0.02621920f, 0.34216756f, 0.00897124f, 
    0.15984637f, 0.17981499f, -0.11091724f, -0.00955476f, -0.01199810f, -0.20809120f, -0.03762932f, -0.12448347f, 
    -0.00523102f, -0.25480723f, 0.58561999f, 0.10485407f, 0.24803258f, -0.10075687f, 0.10122529f, -0.41934451f, 
    -0.24471465f, -0.33050486f, 0.18054378f, -0.56581366f, -0.16019437f, -0.06855418f, -0.35513344f, 0.00547582f, 
    -0.08635000f, -0.38805777f, -0.10406876f, 0.04364783f, -0.08949738f, 0.24776720f, 0.09361533f, 0.23630448f, 
    -0.00589669f, 0.07100482f, 0.85684472f, -0.13233973f, -0.17951666f, -0.02298532f, 0.17729612f, 0.24735001f, 
    0.08109362f, 0.35423738f, -0.67426956f, -0.09937855f, 0.10132906f, 0.01225927f, 0.05541458f, -0.04130908f, 
    0.24955663f, -0.16565759f, -0.15507664f, 0.09934247f, -0.28040588f, -0.29390773f, -0.21458529f, 0.31191608f, 
    0.13732859f, 0.49310219f, -0.12253553f, -0.30601597f, 0.19169870f, -0.11717275f, -1.27420187f, -0.08762491f, 
    0.17631975f, -0.49840507f, -0.21891861f, 0.26601705f, 0.25517520f, -1.48658681f, -0.01610911f, 0.35968381f, 
    -1.00118053f, -0.39106670f, -1.02547002f, -0.49519965f, -0.18587120f, -0.04969116f, -0.03426103f, -0.04100979f, 
    0.38708067f, 0.05755402f, -0.30594352f, 0.24968694f, 0.06280117f, 0.04263370f, -0.09107163f, 0.00835608f, 
    -0.09327982f, 0.33754620f, -0.03350878f, 0.02090572f, -0.43374202f, -0.49496394f, 0.13753109f, 0.33220896f, 
    -0.23155399f, -0.49416408f, -0.87068069f, 0.11442706f, -0.27329788f, -0.04753245f, -0.04354238f, 0.23199025f, 
    0.00101591f, -0.56080699f, 0.17526300f, 0.01115204f, 0.31210831f, -0.10477182f, -0.25515187f, -0.13807067f, 
    -0.79611123f, -0.03151469f, -0.79648995f, -0.24658598f, -0.39579526f, 0.37730640f, -0.10639998f, -0.13949224f, 
    0.00550502f, 0.11581997f, 0.18165490f, -0.03068319f, -0.62628412f, -0.00370910f, -0.12049308f, 0.01390552f, 
    -0.12857252f, -0.43132991f, 0.15444513f, 0.00018312f, 0.17973828f, -0.45854485f, 0.00612032f, -0.06910536f, 
    0.09876344f, -1.11095846f, -0.56004536f, 0.72751045f, 0.05288647f, 0.32393008f, 0.06641905f, 0.10102916f, 
    0.08704119f, 0.20652710f, -0.12136692f, -0.39853752f, -0.17456001f, -0.05695004f, 0.17892788f, -0.10378419f, 
    -0.01311203f, 0.02479900f, -0.07418667f, -0.04560698f, 0.27744424f, -0.04997338f, 0.04477153f, -0.35551864f, 
    -0.42181605f, 0.39513275f, -1.14156067f, -0.36108553f, 0.01371262f, 0.20484473f, -0.19015837f, -0.33464170f, 
    -0.08032463f, -0.11267262f, -0.97048151f, -0.04168691f, -0.03853666f, -0.13037032f, 0.04286456f, -0.09733549f, 
    -0.44500762f, 0.20992886f, 0.22711244f, 0.38060579f, -0.15000737f, 0.18414760f, 0.24047576f, -0.06229229f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17891014f, 0.13867326f, -0.08906970f, -0.02778732f, 0.36508343f, -0.02510008f, 0.00447900f, -0.54903877f, 
    -0.05544122f, 0.05624089f, 0.37294656f, -0.17870145f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
