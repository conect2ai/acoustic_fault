#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.15145823f, 0.12385184f, 0.82942921f, -1.03147209f, -0.59768689f, -1.35360110f, 0.23793258f, 0.61740929f, 
    -0.07388980f, -0.50677192f, -0.44231534f, -0.42296511f, 0.23563844f, -0.79188150f, -0.51417947f, -0.62526834f, 
    -1.04922485f, 0.28704280f, 1.09426332f, 0.76366496f, 0.80748415f, 0.49408117f, 0.15821916f, 0.03036727f, 
    -0.09943991f, 0.67906106f, 0.10157794f, 1.38386297f, -1.29883957f, 0.58409709f, -0.10302208f, -0.88220966f, 
    -0.13777618f, -0.35713053f, 0.40119383f, -0.30264425f, -1.16748655f, 0.64002132f, 0.17283368f, 0.92461967f, 
    1.67784238f, 0.69091916f, 0.16674510f, -0.09119359f, 0.21575370f, 1.17367125f, 1.09831035f, 0.66309619f, 
    -0.19243091f, -0.23647983f, 1.26483107f, -0.12403583f, -0.22915703f, 0.26191413f, -1.45223176f, -1.26809299f, 
    -0.45915967f, 0.13422273f, -0.69210243f, 0.62733543f, 0.15800947f, -0.01141578f, 0.41727141f, 0.08534653f, 
    -0.90375036f, -0.98886883f, -0.11570542f, -0.89230174f, -0.48442301f, -0.53527665f, 0.62229830f, 0.26986444f, 
    0.38029560f, -1.29881907f, -0.04472610f, -1.51331484f, -0.64111072f, 0.49268439f, 0.21119057f, 0.28353509f, 
    0.44422090f, -1.38157856f, -0.52162790f, 1.08956075f, 0.50394368f, 0.49554574f, 0.84946823f, -0.45729494f, 
    -0.67484599f, 0.27155742f, 0.70933223f, -0.05380306f, 0.50548518f, 1.15617490f, 0.58437258f, 0.46389741f, 
    0.29925773f, 0.51461703f, -0.44426656f, -0.62339270f, -0.92325401f, -0.88889271f, 0.71112394f, 1.17725646f, 
    -0.68290269f, 0.15446064f, -0.13477167f, 0.47609600f, -1.15392935f, -0.60482299f, 0.28860712f, 0.51473039f, 
    -0.27568832f, -1.02172208f, 0.17413397f, 0.32734814f, 0.76937133f, 0.24446447f, 1.30244768f, -0.72810054f, 
    1.32195973f, 0.14262344f, -1.20038283f, 0.08708376f, 0.07017975f, -0.23345743f, -0.98597366f, -0.77904379f, 
    -0.98172987f, 0.07728219f, 1.00705183f, -0.11276934f, 0.20857182f, -0.16350965f, -1.06196976f, 1.00386488f, 
    1.25014186f, 1.05456758f, -0.67803252f, -0.22031824f, -1.04412186f, -0.27446944f, -0.47298723f, -0.24925360f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.43853307f, -0.36440825f, 0.54720104f, -0.10091668f, -0.48956004f, 0.46677670f, 0.16160941f, 0.56475258f, 
    0.18457209f, 0.24303603f, 0.26202792f, -0.15054435f, -0.16421339f, 0.12343916f, 0.25045833f, 0.22519676f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01625436f, 0.06356028f, 0.01582593f, 0.04148366f, 0.00759649f, -0.02443168f, 0.01246222f, 0.02545282f, 
    -0.07723984f, 0.05915563f, 0.05287728f, 0.02179460f, -0.01234253f, 0.04732186f, -0.00237594f, 0.05589764f, 
    0.03684030f, 0.04727116f, 0.05111419f, -0.05428651f, -0.08492893f, -0.07230450f, 0.04914133f, -0.01661464f, 
    0.06035773f, 0.05142181f, 0.06140346f, -0.03491696f, -0.04663144f, 0.03078066f, -0.06506500f, -0.06485412f, 
    -0.00564317f, 0.03615375f, -0.10319575f, 0.02914598f, 0.05508239f, -0.08090575f, -0.04360721f, 0.02834925f, 
    0.03565650f, 0.01019793f, 0.05904660f, 0.00521780f, -0.03916307f, -0.09244266f, -0.04292337f, 0.01086362f, 
    0.02004507f, -0.01229958f, -0.04597034f, -0.00337500f, 0.03751653f, -0.04591293f, 0.02155265f, -0.02156141f, 
    0.01023391f, -0.00319876f, 0.06161138f, 0.04751673f, 0.03605586f, -0.04777445f, 0.06622569f, 0.01160824f, 
    0.04411641f, 0.05720766f, -0.04672230f, -0.00659311f, 0.01645811f, -0.07126179f, 0.02403093f, -0.02002510f, 
    -0.07772028f, 0.00118614f, 0.04937952f, -0.09247753f, 0.04023973f, -0.03021830f, 0.03360877f, -0.05587719f, 
    -0.06963029f, -0.06814037f, -0.05811115f, 0.04192301f, -0.03239706f, -0.09567364f, -0.10199852f, 0.01155486f, 
    -0.04692855f, -0.06766734f, 0.00177190f, -0.08582277f, 0.04790252f, -0.03642472f, -0.06098171f, -0.06199986f, 
    0.04311060f, -0.06296923f, -0.03115324f, -0.07012039f, -0.06781618f, -0.01731026f, -0.07523940f, -0.05316451f, 
    0.03023721f, 0.05400898f, 0.04402579f, -0.03999877f, -0.01202819f, -0.08215564f, 0.00522446f, -0.05103180f, 
    0.05151696f, -0.02440421f, 0.05410367f, 0.06522597f, -0.08070498f, 0.02670835f, 0.03703958f, 0.02599044f, 
    0.00273893f, -0.04154045f, -0.06573833f, -0.03724437f, -0.05651074f, 0.01485174f, -0.01036107f, 0.01982681f, 
    0.01779060f, -0.04377526f, -0.05479657f, -0.05314414f, -0.04569159f, 0.02667545f, -0.02277045f, -0.03354092f, 
    -0.02013850f, 0.04924810f, -0.06986783f, 0.00030758f, 0.01994198f, -0.03309104f, -0.05170026f, -0.04801894f, 
    0.29016256f, -0.06307903f, -0.27288386f, 0.12829731f, 0.09493481f, -0.00573929f, 0.04246767f, 0.01449422f, 
    0.05723700f, 0.24666256f, -0.40815517f, -0.02357849f, -0.07733808f, -0.17220400f, 0.01114601f, 0.16192542f, 
    -0.02241167f, -0.35448670f, 0.22116449f, -0.10061058f, 0.06767475f, 0.18777533f, 0.19710678f, -0.00819608f, 
    0.47620013f, -0.24311109f, 0.26551554f, -0.29879308f, -0.62279999f, 0.26415610f, -0.16753149f, -0.21023479f, 
    0.09552564f, -0.13643070f, -0.11024769f, 0.00038946f, -0.28748557f, -0.48372072f, -0.30043033f, 0.16459991f, 
    0.22347079f, 0.11755147f, -0.01847563f, 0.09824356f, -0.21434362f, 0.05932216f, -0.13728040f, -0.59001875f, 
    0.08392547f, -0.07708456f, 0.12775661f, 0.09061792f, -0.04604206f, -0.09076090f, 0.53468847f, 0.00281272f, 
    -0.21023799f, 0.10499255f, 0.26397213f, 0.04488026f, 0.24191543f, 0.25476822f, -0.03804372f, 0.35704160f, 
    0.18845931f, -0.05166833f, -0.21679032f, 0.15658398f, -0.26021838f, -0.00109798f, 0.13920443f, 0.08665512f, 
    -0.31072608f, 0.03678390f, -0.05543059f, -0.00523999f, -0.34018937f, 0.18841168f, 0.06457617f, 0.26829880f, 
    0.05896443f, 0.09173866f, 0.14471804f, -0.08907311f, 0.04585612f, 0.11235676f, 0.07177936f, -0.15969311f, 
    -0.02416639f, 0.15503989f, -0.01385033f, 0.09501993f, -0.26846221f, 0.17967406f, 0.02385187f, 0.11692809f, 
    0.14926592f, -0.12279881f, 0.36192563f, 0.21295322f, -0.21358129f, 0.15151472f, -0.05418246f, -0.02163211f, 
    -0.23592274f, -0.14016697f, 0.13476788f, -0.13190493f, -0.16049998f, -0.21232106f, 0.14948396f, -0.25516382f, 
    -0.09208737f, -0.01474608f, 0.21107726f, -0.14176001f, 0.20937778f, -0.14238445f, 0.18308005f, 0.08498853f, 
    0.18001391f, -0.24234466f, -0.07313920f, 0.11251397f, -0.01387962f, 0.06756885f, 0.04399614f, 0.27109322f, 
    0.16199808f, -0.19250777f, 0.07523753f, -0.23469833f, -0.28665373f, 0.00219546f, -0.04739163f, 0.45234343f, 
    0.02640068f, -0.29332808f, -0.08362631f, -0.14215419f, 0.01849046f, -0.07572604f, 0.02862050f, 0.11625917f, 
    0.12184326f, 0.03583549f, 0.35443839f, -0.16955708f, -0.08496126f, -0.46806654f, -0.05662252f, -0.08059619f, 
    0.25035277f, 0.10797658f, 0.07597016f, 0.14637339f, 0.14174679f, 0.14031301f, -0.17048252f, -0.11818280f, 
    0.28940141f, 0.26487419f, -0.34602985f, -0.05904821f, -0.10367333f, -0.07876373f, 0.01933961f, 0.44336289f, 
    0.02313541f, 0.07394749f, -0.13119873f, 0.16978681f, 0.04926717f, -0.18097048f, -0.18737404f, -0.24697880f, 
    -0.02176698f, -0.08722574f, 0.09658385f, 0.10814999f, 0.25241107f, 0.25789100f, 0.14623624f, 0.12664902f, 
    -0.00248039f, 0.17912218f, -0.00060383f, 0.01583208f, -0.29470214f, -0.35068867f, -0.26367906f, -0.14169377f, 
    -0.23865396f, 0.07320540f, 0.17681307f, 0.34836081f, 0.07371418f, -0.37346476f, 0.26277390f, -0.33931476f, 
    0.03465552f, -0.08696309f, 0.33384648f, -0.10283924f, 0.02254204f, -0.08620677f, -0.10171605f, 0.23724580f, 
    -0.27193832f, 0.07289706f, 0.36314261f, 0.16451555f, 0.33371288f, 0.23501521f, 0.06945008f, 0.04563401f, 
    0.14655027f, -0.60187525f, -0.22600061f, -0.23107716f, 0.07120571f, -0.09955801f, 0.21668354f, 0.02265864f, 
    -0.11913434f, 0.08203217f, -0.03370900f, 0.12964766f, 0.00630989f, -0.08941816f, 0.21950583f, 0.02065934f, 
    0.04810524f, -0.33766502f, -0.54423767f, 0.06351195f, -0.13087992f, 0.19969705f, 0.10179070f, 0.26850986f, 
    -0.09425099f, -0.07610194f, -0.43299839f, -0.13097395f, -0.22460173f, 0.00855520f, 0.02485790f, -0.00948370f, 
    -0.10674841f, -0.10830193f, 0.12696508f, 0.47733879f, 0.14901850f, -0.17415884f, 0.03386718f, -0.06486725f, 
    -0.07628968f, -0.15765086f, 0.19907489f, -0.11230239f, -0.07661648f, 0.36295256f, 0.28749588f, 0.03553718f, 
    -0.03222086f, -0.20117423f, 0.27029976f, -0.35039940f, 0.15778641f, -0.34120667f, 0.18311499f, 0.19543712f, 
    0.27172533f, -0.09157223f, 0.14158589f, 0.06798111f, -0.17881687f, 0.08657227f, 0.35778147f, 0.03726927f, 
    0.14306490f, 0.15706804f, 0.03108847f, -0.32407400f, 0.11198229f, 0.31605849f, 0.09788280f, 0.08555261f, 
    0.07263026f, -0.05918387f, 0.24481028f, 0.09533100f, -0.14239340f, 0.00429452f, 0.18143976f, -0.08245515f, 
    -0.10396975f, 0.02502910f, -0.22993164f, 0.15988579f, -0.21060102f, 0.23509704f, -0.10701515f, 0.10270192f, 
    -0.01589510f, 0.10683365f, 0.20281903f, -0.01442430f, 0.24563941f, 0.19453445f, -0.07420467f, -0.00259946f, 
    0.20364898f, 0.35349974f, 0.15027776f, -0.74268693f, -0.14746171f, -0.17104726f, 0.05709128f, 0.10848528f, 
    -0.23436883f, -0.04692623f, 0.07599477f, -0.07347035f, -0.64967442f, 0.02689686f, -0.11004061f, 0.01995050f, 
    0.31179178f, -0.06416526f, -0.07141048f, 0.13880669f, -0.07738064f, 0.73201311f, -0.18111175f, -0.01314984f, 
    -0.06230501f, -0.13772498f, -0.23119499f, 0.03200438f, 0.06159487f, 0.15056130f, -0.21035205f, 0.22986846f, 
    -0.31294367f, -0.03572300f, -0.06706196f, 0.03753845f, 0.17518720f, -0.18030562f, 0.12095625f, 0.47732994f, 
    0.08863340f, -0.56382751f, 0.25572863f, -0.26501560f, -0.11628816f, -0.05588641f, 0.15117057f, -0.17594022f, 
    -0.34764069f, -0.00882531f, -0.27832881f, 0.03502321f, 0.03786619f, 0.17634845f, 0.06696010f, -0.04977717f, 
    0.08672913f, -0.45648623f, -0.10601997f, -0.42967090f, -0.10189263f, 0.08101687f, 0.08982420f, -0.07952479f, 
    0.19468689f, -0.00371773f, -0.38218474f, -0.12072163f, 0.10755942f, 0.25992665f, 0.09191162f, -0.15975203f, 
    -0.07165357f, -0.05444259f, -0.13648497f, -0.40321383f, 0.10557646f, -0.46684927f, 0.04949808f, -0.15234323f, 
    -0.16248930f, 0.20475563f, -0.35785332f, 0.06960871f, -0.26459417f, 0.13866363f, 0.02441639f, -0.18453561f, 
    0.07896971f, 0.04345664f, 0.17030278f, 0.20093957f, -0.12061104f, 0.08299984f, -0.27948841f, 0.33665374f, 
    0.16345958f, 0.11083258f, 0.05725656f, -0.22124228f, -0.07667385f, -0.06702899f, 0.11653676f, 0.19597544f, 
    -0.08820181f, -0.09370501f, -0.02564698f, -0.04913706f, -0.24056271f, 0.15859419f, 0.06436200f, 0.61026251f, 
    0.21941873f, 0.25446948f, -0.09145831f, 0.29055569f, 0.27549371f, 0.09594077f, 0.00454846f, 0.22497201f, 
    0.78370583f, 0.45754063f, 0.27266148f, 0.41383812f, -0.26293164f, 0.14946225f, -0.20709118f, 0.08507583f, 
    0.16914502f, -0.32609701f, 0.09321968f, -0.11349805f, 0.01401834f, -0.07581498f, 0.02718274f, -0.05421801f, 
    -0.10597799f, -0.26175550f, -1.35914302f, -0.59439552f, -0.49556920f, -0.17114022f, 0.20357952f, 0.08425400f, 
    0.16956551f, 0.19433546f, 0.13939768f, 0.17678136f, 0.00260109f, 0.28755438f, 0.27997294f, 0.18912676f, 
    0.01514729f, -0.10504581f, -0.04128278f, 0.15187880f, 0.27362365f, 0.15601768f, -0.27609167f, 0.09153090f, 
    -0.30564281f, -0.24864066f, 0.17835268f, 0.00822056f, 0.20245893f, -1.20226943f, -0.32192826f, 0.05393580f, 
    -0.12991385f, 0.14941151f, 0.11428311f, 0.03817470f, 0.05927947f, -0.12166637f, 0.17009977f, 0.06741136f, 
    -0.01338889f, -0.15591386f, -0.09217246f, -0.00697847f, -0.15289795f, 0.12940693f, 0.10443265f, 0.06849404f, 
    -0.00397274f, 0.07968470f, -0.18792409f, -0.12630342f, 0.04833029f, 0.08358000f, 0.01033167f, 0.26987922f, 
    0.09887103f, 0.03606102f, 0.18197361f, -0.11362372f, 0.02793015f, -0.04319538f, 0.22327150f, 0.18150677f, 
    0.11514388f, 0.23127688f, -0.22402933f, -0.34461933f, 0.00500064f, 0.03481700f, 0.22762479f, 0.32950354f, 
    -0.05396075f, 0.04932783f, -0.29914141f, -0.17178880f, 0.33514458f, 0.04134770f, 0.03439508f, 0.16771197f, 
    0.08103649f, 0.14113438f, 0.12816463f, -0.00797184f, 0.14204279f, -0.03256124f, -0.00471098f, -0.50640959f, 
    0.18496574f, -0.06140276f, 0.20745181f, -0.00603978f, 0.14995822f, -0.02586257f, -0.17571326f, -0.28192002f, 
    -0.48582375f, -0.06296697f, 0.15789442f, -0.24940583f, 0.46180066f, 0.15426241f, -0.30870086f, -0.41589317f, 
    0.06372156f, 0.09412930f, 0.15892750f, 0.09714945f, -0.14809178f, 0.16740474f, 0.21778809f, -0.21087210f, 
    -0.02044855f, -0.22116233f, -0.13659875f, -0.01063895f, -0.15077920f, 0.07564706f, -0.08985851f, -0.34099799f, 
    0.17659967f, 0.15397166f, 0.37746102f, 0.16925292f, 0.04211544f, -0.03677112f, -0.22772281f, 0.06218429f, 
    -0.01293803f, 0.05821631f, -0.00168985f, -0.07050886f, -0.07222985f, 0.04301108f, -0.04171934f, -0.06256017f, 
    0.04075021f, 0.04311561f, -0.01165844f, -0.07115231f, -0.06237361f, 0.06500244f, -0.10017259f, 0.00211329f, 
    0.06529815f, 0.00939852f, -0.00688284f, -0.03526288f, 0.02056921f, -0.00029873f, 0.04431564f, -0.05990507f, 
    0.02452098f, -0.00833246f, 0.00504493f, -0.01477012f, 0.06052837f, 0.02480383f, -0.04619029f, -0.04889254f, 
    0.01051660f, 0.07153855f, -0.06944749f, 0.00137725f, -0.05665528f, -0.07212128f, 0.00550418f, 0.05005996f, 
    0.02670762f, -0.08486462f, 0.04357158f, 0.06077486f, -0.05111668f, 0.07418636f, -0.08303577f, -0.00709238f, 
    0.02455563f, 0.02828189f, -0.00225781f, 0.00925985f, 0.03266297f, 0.06220693f, -0.03087894f, -0.04974550f, 
    0.02045069f, -0.06646466f, -0.06875418f, -0.07671803f, -0.08589592f, -0.05826398f, 0.00282206f, -0.05327781f, 
    -0.07894251f, -0.07632198f, 0.00392766f, -0.07248688f, -0.03003735f, -0.05388788f, 0.03697874f, -0.09396957f, 
    -0.03367568f, -0.07062425f, -0.07380021f, 0.00852754f, -0.03924076f, 0.06116239f, -0.05604561f, 0.05141370f, 
    0.04067266f, 0.05105786f, -0.02453598f, 0.00365575f, -0.07872345f, 0.01018409f, -0.07505710f, 0.01956023f, 
    0.06091646f, -0.01321577f, 0.00425726f, -0.05707136f, 0.04852612f, -0.06704675f, -0.07815014f, -0.05907100f, 
    0.00141522f, -0.07202891f, 0.03456521f, 0.00166940f, -0.00457069f, 0.00460391f, 0.00117386f, -0.08895269f, 
    0.01630428f, -0.01236082f, 0.00425069f, -0.04954450f, 0.03731598f, 0.02402858f, 0.01420798f, -0.08626681f, 
    -0.03810196f, 0.06458626f, 0.02916710f, 0.05574555f, 0.03086133f, 0.04147223f, 0.00491643f, -0.02251402f, 
    0.03242614f, 0.05385978f, 0.05715520f, -0.05877828f, 0.03587860f, -0.04742039f, -0.06280708f, 0.05199068f, 
    -0.04532463f, -0.03772581f, -0.06651525f, -0.05668325f, -0.08895428f, -0.06740911f, 0.00846714f, -0.02898178f, 
    -0.05687644f, -0.02078472f, 0.05013468f, -0.00394814f, -0.03906356f, 0.07327327f, 0.02669572f, 0.07104356f, 
    -0.18515773f, 0.27983934f, -0.52901059f, 0.18623975f, 0.03201522f, -0.16084448f, 0.29572794f, -0.01185553f, 
    -0.21160944f, 0.21044803f, -0.08259571f, -0.16861218f, -0.31938529f, 0.17007853f, 0.13536412f, -0.02427436f, 
    0.06063498f, 0.02705212f, 0.54722774f, -0.17706430f, -0.17679024f, 0.20330977f, 0.05730961f, 0.04847299f, 
    0.05228011f, -0.14088570f, -0.25462121f, 0.32880434f, 0.10232797f, -0.18700509f, -0.05662507f, -0.17930281f, 
    -0.24632342f, 0.10374499f, 0.03506105f, 0.13475680f, -0.72165745f, -0.46567297f, 0.03985821f, 0.08453230f, 
    0.16787699f, -0.05023364f, -0.36621186f, 0.02264370f, 0.03179219f, 0.33748052f, 0.21957166f, 0.32410476f, 
    0.03997602f, 0.21201885f, -0.11631156f, 0.01816309f, -0.19313215f, 0.01199876f, 0.24243011f, -0.08285549f, 
    0.30954599f, -0.07491811f, -0.00120932f, 0.22376628f, -0.17047095f, -0.39603385f, 0.12548910f, 0.33663228f, 
    0.23351416f, 0.34252957f, 0.01236333f, -0.18723902f, -0.18616584f, 0.12976433f, -0.10109666f, -0.19085346f, 
    -0.40911961f, -0.09170412f, -0.23198438f, 0.01697854f, 0.00878369f, 0.06597724f, -0.02267281f, 0.06436208f, 
    0.05625851f, -0.08009368f, -0.24857917f, 0.04936821f, 0.03836338f, 0.16721013f, 0.08527756f, 0.20344539f, 
    -0.17461231f, 0.03092499f, 0.16243027f, -0.21197014f, -0.03277810f, 0.03102051f, 0.30225298f, 0.31015441f, 
    0.06645319f, -0.03094273f, -0.10877915f, -0.21854728f, -0.42909709f, 0.40989468f, 0.14231250f, -0.14594433f, 
    0.11556242f, -0.05761070f, 0.10630586f, 0.03644695f, -0.08013748f, 0.01156917f, -0.04629315f, 0.10880984f, 
    -0.28856823f, 0.04895660f, -0.00767583f, -0.23687476f, -0.37599239f, 0.31975177f, 0.13136703f, -0.11179655f, 
    0.01393214f, -0.10512639f, -0.01815855f, 0.10805737f, 0.03751330f, 0.01637346f, -0.46861827f, -0.08713797f, 
    0.12714544f, -0.10815103f, -0.15692808f, -0.02767193f, -0.06085616f, 0.34852013f, 0.32321090f, 0.56725824f, 
    0.46988934f, -0.24307346f, 0.13554779f, -0.31341588f, -0.11761843f, 0.06294613f, -0.01660581f, 0.17994964f, 
    -0.04686794f, -0.00298414f, -0.02414673f, -0.04938083f, -0.06876803f, -0.02539499f, -0.01230618f, -0.04086270f, 
    -0.10177822f, -0.00536345f, 0.02859663f, -0.01878885f, 0.01629733f, -0.01725801f, 0.00314994f, -0.09156091f, 
    -0.08787258f, -0.08844811f, 0.02631382f, 0.04409892f, -0.01087375f, -0.03054425f, 0.03344929f, -0.03529013f, 
    -0.03273979f, -0.07451107f, -0.00723303f, 0.05254104f, 0.01834841f, 0.03696347f, -0.03865102f, 0.00374632f, 
    0.04575046f, -0.02352377f, -0.04600952f, 0.03010464f, -0.07525131f, 0.06754179f, -0.00744424f, 0.02202981f, 
    -0.01676466f, -0.04187294f, 0.04344781f, 0.04694853f, -0.01770020f, -0.03352755f, 0.00414474f, -0.08982353f, 
    -0.04703138f, 0.03130446f, -0.06453142f, 0.01093787f, 0.03065238f, 0.04982892f, -0.08235455f, 0.05812768f, 
    0.00408796f, -0.00059493f, -0.05301527f, -0.05539713f, 0.06160932f, 0.01183350f, 0.04666493f, -0.04432661f, 
    -0.08512419f, 0.04147596f, -0.04405142f, 0.04523445f, 0.00281394f, -0.04305025f, 0.05409002f, 0.01968621f, 
    -0.03856256f, 0.03071469f, -0.02131693f, -0.00060015f, -0.06823984f, -0.05184022f, -0.08825448f, -0.08329435f, 
    0.04961282f, 0.02072072f, -0.00275935f, 0.05161436f, 0.00563317f, -0.02905110f, -0.06964276f, -0.09145436f, 
    -0.02747801f, -0.03204248f, 0.02140089f, -0.06427414f, -0.05309713f, -0.08157634f, 0.03948558f, -0.00503454f, 
    0.05562453f, 0.05606961f, 0.00479096f, -0.09518655f, -0.00875973f, 0.04334845f, 0.05507040f, 0.02328420f, 
    0.01152902f, -0.03131962f, 0.01764591f, -0.01249542f, -0.01418313f, 0.04234737f, -0.04038422f, -0.06008800f, 
    -0.00283791f, -0.00536276f, -0.04167327f, -0.09412877f, -0.09598386f, -0.06812717f, -0.05099261f, 0.00159740f, 
    0.04014910f, -0.01399013f, -0.00533638f, 0.05868143f, -0.00925679f, -0.05460406f, -0.08456805f, -0.08094272f, 
    -0.08155011f, 0.06440794f, -0.08081622f, 0.04520414f, 0.04711220f, -0.05922034f, 0.04401033f, -0.02984262f, 
    0.00125671f, 0.01814508f, -0.02529029f, -0.06941834f, 0.02918779f, 0.03665179f, 0.02548570f, -0.05276939f, 
    0.02615012f, -0.03159914f, 0.40899792f, -0.06199854f, -0.05830881f, 0.19363183f, 0.04238411f, 0.14398211f, 
    0.33610401f, -0.13423160f, 0.11445832f, 0.04998487f, 0.24729407f, -0.10078587f, 0.13210407f, 0.41745886f, 
    0.14229819f, 0.20697416f, 0.28873625f, 0.28103006f, 0.09244435f, 0.03362707f, -0.09940486f, 0.10176619f, 
    0.11073217f, 0.10159146f, 0.04529748f, 0.14894770f, -0.21514520f, -0.08207323f, -0.20119801f, 0.22321938f, 
    0.13897207f, 0.00876852f, -0.30646163f, -0.14163868f, 0.85445637f, 0.20147632f, 0.12930667f, 0.33256239f, 
    -0.11730267f, -0.10266725f, -0.24020033f, -0.18955927f, 0.11543608f, 0.04650786f, -0.08210696f, -0.07431111f, 
    -0.18284768f, -0.12893738f, -0.03153127f, -0.01439781f, 0.16470462f, -0.03328057f, 0.20560870f, 0.18655489f, 
    -0.33437869f, 0.37986457f, 0.24337353f, 0.17249046f, 0.13368453f, -0.11911667f, 0.10491269f, -0.51540834f, 
    0.25104457f, 0.25218996f, 0.10256431f, 0.09884427f, 0.23861903f, -0.15462334f, 0.00655292f, -0.16817458f, 
    -0.44154862f, -0.30612135f, -0.09010089f, 0.15926448f, 0.33337826f, 0.10103511f, -0.01967796f, 0.04017530f, 
    -0.09340053f, 0.20504391f, 0.73924172f, 0.39416471f, -0.06006810f, -0.14983110f, -0.28506795f, 0.14721687f, 
    0.05376745f, -0.05631057f, 0.23686405f, 0.00909857f, -0.54817474f, 0.37999806f, 0.04294057f, 0.43156898f, 
    0.33958977f, -0.12677030f, 0.19049686f, 0.13687195f, -0.44975668f, -0.30284581f, 0.19451146f, 0.08846301f, 
    -0.00378583f, -0.31892699f, 0.09953925f, -0.29642290f, -0.93046284f, -0.40069115f, -0.22964686f, 0.17449003f, 
    -0.19170444f, -0.12380879f, 0.20745648f, -0.04474802f, 0.12947109f, -0.45695433f, 0.16222395f, -0.10383347f, 
    -0.09480749f, -0.14117649f, -0.06840169f, -0.04046741f, 0.03937384f, 0.06803366f, -0.57527512f, -0.32571128f, 
    -0.22891584f, 0.20801790f, 0.17610416f, 0.05291821f, 0.11465105f, -0.16507722f, 0.03724104f, 0.17782342f, 
    -0.13566515f, 0.12202106f, -0.33450606f, -0.17787485f, -0.04288453f, 0.14858153f, 0.50991338f, 0.12803085f, 
    0.11850592f, -0.36471325f, -0.32536286f, -0.03042114f, -0.25082809f, -0.32518786f, 0.01752516f, -0.11798335f, 
    -0.14195666f, 0.03068171f, 0.61848211f, 0.01785549f, 0.12533890f, -0.11857696f, 0.11948254f, -0.07673176f, 
    -0.14098489f, 0.03226493f, -0.07803308f, 0.24210328f, -0.00752223f, -0.14269318f, 0.07508478f, -0.05008686f, 
    0.02623359f, 0.19004133f, -0.13788818f, 0.20953561f, 0.70683479f, -0.26055855f, -0.17724575f, -0.12165588f, 
    -0.07235359f, -0.36870465f, 0.26805288f, 0.02950391f, 0.05384956f, 0.04424057f, 0.13649376f, 0.00213760f, 
    0.14055754f, 0.13619703f, -0.03624965f, 0.18651514f, 0.21305618f, -0.27391234f, 0.04146430f, 0.30194420f, 
    -0.05709619f, -0.02015327f, -0.03014234f, -0.09668296f, -0.00519235f, 0.17679121f, -0.07686336f, 0.09825906f, 
    0.35939074f, 0.24103312f, 0.14638655f, 0.23705330f, 0.33259431f, -0.17408784f, -0.04631938f, 0.13836551f, 
    0.31663895f, 0.29126918f, 0.21302509f, -0.09477840f, 0.12324060f, -0.00224810f, -0.13200943f, -0.01139423f, 
    0.30541879f, -0.21745807f, 0.13726923f, -0.32858208f, 0.03701241f, -0.15864071f, -0.16108121f, 0.24882200f, 
    -0.00386392f, 0.03998332f, -0.33496296f, -0.52310050f, 0.10185460f, -0.05823075f, -0.10586277f, -0.02706354f, 
    -0.09592242f, -0.02270264f, 0.11319728f, -0.26510286f, -0.38841093f, -0.02412029f, -0.06104404f, -0.23300694f, 
    0.19339180f, -0.13295992f, 0.03026217f, -0.33934736f, 0.06005614f, 0.41208205f, -0.07426625f, -0.06192201f, 
    -0.00478482f, 0.06507585f, 0.15651372f, -0.00675455f, 0.01007197f, 0.10348940f, -0.43377578f, 0.05574035f, 
    -0.08241051f, 0.31383353f, -0.40606457f, 0.01760613f, -0.43920571f, -0.53058940f, 0.08750769f, -0.03174664f, 
    0.11371130f, -0.10585179f, -0.04269380f, 0.03496832f, -0.02501209f, -0.09495869f, 0.00376332f, 0.43567300f, 
    0.74779087f, 0.32254586f, -0.03458621f, 0.28962436f, 0.00423000f, 0.05693531f, 0.10264168f, -0.46043390f, 
    -0.01478255f, 0.11333460f, -0.04668341f, 0.03955445f, 0.27146992f, -0.13730353f, -0.07041824f, 0.09415743f, 
    0.00288531f, -0.03959675f, 0.02229394f, -0.07083704f, 0.06171140f, -0.07907978f, -0.08423105f, 0.07514320f, 
    -0.06731109f, -0.06909994f, -0.03510531f, 0.02730647f, -0.05716317f, -0.06774055f, 0.07660340f, -0.04400213f, 
    0.02765920f, -0.06855973f, -0.07136009f, -0.04619393f, -0.06931931f, 0.01766385f, -0.05721045f, -0.00495979f, 
    -0.01708721f, -0.01794866f, -0.00034124f, 0.01475500f, -0.01915609f, -0.04891483f, -0.02106234f, -0.03556551f, 
    0.01853901f, 0.00651633f, 0.00342461f, -0.04090789f, -0.00441113f, 0.04335184f, -0.07279544f, 0.02704488f, 
    0.01459426f, -0.07438634f, 0.05872995f, -0.04917115f, -0.06612937f, -0.04639693f, -0.11798545f, 0.06012627f, 
    0.00178988f, 0.04313764f, 0.05726844f, 0.01865277f, -0.01578970f, 0.06605109f, -0.03175675f, -0.01991730f, 
    -0.04553274f, -0.02435226f, -0.02920981f, 0.00074394f, 0.06618395f, -0.02637860f, 0.06199634f, -0.03557627f, 
    0.02735020f, -0.08091868f, -0.06278586f, 0.05740156f, 0.06846948f, -0.09013020f, 0.04035630f, -0.03722158f, 
    -0.07343463f, -0.02200261f, -0.03367329f, 0.03223636f, -0.09497285f, 0.02349727f, -0.01400911f, -0.02749074f, 
    0.02202621f, -0.04190930f, -0.02725494f, 0.01951770f, -0.02601012f, 0.05099451f, 0.05510686f, 0.01807615f, 
    -0.07572455f, -0.10061868f, -0.02825410f, 0.04546231f, -0.03916075f, -0.08373830f, -0.02574374f, -0.06049516f, 
    -0.02779168f, 0.02680468f, 0.03355717f, -0.02739173f, -0.02442784f, -0.04710999f, 0.06245085f, -0.04701046f, 
    0.01335345f, -0.04010164f, -0.06144192f, -0.07764910f, -0.07428862f, 0.06066849f, 0.00520290f, -0.02475437f, 
    0.05255619f, -0.01252406f, 0.05464790f, 0.02917082f, 0.01486840f, -0.03491476f, -0.09008557f, -0.06594533f, 
    0.06211804f, -0.02374161f, -0.08636233f, -0.06966741f, 0.03378988f, 0.05932149f, 0.04334958f, 0.08407327f, 
    0.02130958f, -0.09017570f, 0.02948346f, 0.06306720f, -0.07757618f, 0.04949507f, 0.03256296f, 0.04782759f, 
    -0.05444294f, 0.02979189f, -0.05196166f, 0.02465900f, -0.02328597f, -0.06723059f, 0.04400658f, -0.07692847f, 
    0.13492203f, -0.33086967f, 0.09891957f, 0.21233383f, 0.14494000f, 0.11393795f, 0.00129640f, -0.16906752f, 
    -0.15381932f, 0.28144214f, -0.02309675f, 0.06456619f, -0.00846384f, 0.09320477f, 0.21052237f, 0.20132434f, 
    -0.36986110f, -0.06333411f, -0.53026497f, -0.55648351f, 0.12660980f, -0.01432826f, -0.05530587f, 0.13595140f, 
    0.18195367f, -0.13814139f, -0.08838189f, 0.26453009f, -0.09717661f, 0.18260336f, -0.09633356f, -0.00727265f, 
    0.06726402f, 0.06667345f, -0.20262599f, -0.30405971f, 0.09645706f, 0.12333078f, 0.21606275f, 0.42035043f, 
    -0.10549742f, 0.02918592f, -0.31561726f, 0.21340497f, 0.35077447f, -0.41296563f, -0.76055855f, 0.09868377f, 
    0.01047942f, 0.21558514f, -0.08761635f, 0.12083446f, 0.05704566f, 0.07082509f, 0.05946523f, 0.54900229f, 
    0.08871265f, -0.14630885f, 0.02859095f, -0.11983727f, -0.00932067f, 0.28118134f, -0.02076256f, 0.45331618f, 
    0.23423830f, -0.11175296f, 0.10832312f, -0.25612086f, -0.15014559f, 0.03518793f, -0.00749220f, -0.08433473f, 
    -0.05623325f, 0.34435022f, -0.30534202f, -0.22660936f, -0.41014302f, -0.16348018f, 0.13693044f, 0.07184749f, 
    0.25271991f, -0.09138706f, 0.07983147f, 0.21421841f, -0.16981219f, -0.00013874f, 0.12091124f, -0.11452366f, 
    0.14897245f, -0.06750251f, -0.20591578f, 0.08396262f, -0.13613740f, -0.07847648f, -0.03124429f, -0.17922257f, 
    0.14148138f, 0.04140691f, 0.01975699f, 0.06055493f, 0.46548474f, -0.20082174f, -0.13246544f, 0.31113058f, 
    0.04140979f, -0.01418178f, 0.27950785f, -0.20148686f, -0.38438386f, -0.01747947f, 0.28683883f, -0.25737047f, 
    -0.14927858f, -0.31114218f, -0.02087454f, -0.13082971f, 0.00555558f, 0.91126513f, -0.03836500f, -0.33065543f, 
    -0.15721151f, -0.23902689f, -0.11784637f, -0.07765361f, 0.13626494f, 0.00885653f, 0.16179240f, 0.44601113f, 
    0.29308593f, -0.07047260f, 0.18265009f, 0.02589396f, 0.08405260f, 0.24055199f, 0.05437338f, 0.00373208f, 
    -0.79548645f, 0.20350483f, 0.08011864f, 0.02684090f, 0.13781616f, -0.18547289f, -0.03061922f, 0.35002851f, 
    0.28591719f, 0.49714276f, -0.01882861f, 0.02908374f, 0.27142102f, 0.11022370f, 0.09696157f, -0.18491191f, 
    -0.00402432f, 0.24996890f, 0.07618815f, -0.34909242f, -0.03896280f, 0.05099983f, -0.39384621f, 0.19615510f, 
    0.30251089f, 0.08568624f, -0.01125039f, 0.32520926f, 0.34103313f, -0.02701526f, 0.09838122f, 0.15057532f, 
    0.07897507f, 0.07672295f, 0.06287276f, 0.04202188f, -0.12894851f, -0.47332153f, -0.38194373f, -0.15726508f, 
    0.11405573f, -0.12016877f, -0.00805650f, -0.08892964f, -0.11115935f, -0.44784009f, -0.31455591f, 0.02847031f, 
    0.23045531f, -0.07804996f, 0.21023867f, -0.28606153f, -0.16388017f, -0.38518837f, 0.41058299f, 0.21598680f, 
    -0.00026262f, 0.26836324f, 0.08247007f, -0.07930461f, 0.06463329f, -0.14685349f, -0.86608493f, -0.27406734f, 
    -0.35872096f, 0.14516540f, 0.13301559f, 0.14384159f, -0.08179551f, -0.21927463f, -0.17300320f, -0.19971636f, 
    -0.09793481f, -0.24462253f, -0.01319133f, 0.08782984f, -0.19084880f, -0.05012460f, 0.17425945f, -0.07099874f, 
    -0.00230228f, 0.06047785f, -0.25539246f, -0.14054817f, -0.13436536f, 0.01327061f, 0.22150303f, -0.12891339f, 
    0.34156999f, 0.24133126f, -0.66665143f, -0.23446755f, 0.00683074f, -0.10593681f, 0.37756106f, -0.10275810f, 
    -0.09291472f, 0.05143995f, -0.08152107f, -0.03461735f, 0.27156678f, -0.04343796f, 0.04027532f, -0.01175304f, 
    0.13055937f, -0.06945811f, -0.07618239f, -0.47695231f, 0.00997860f, -0.29889318f, -0.07947263f, -0.11321563f, 
    -0.03739439f, 0.05567273f, 0.00332832f, -0.00475721f, 0.01294382f, -0.28821689f, -0.32843301f, 0.03962520f, 
    0.16728322f, -0.02351868f, 0.16923985f, -0.01921823f, 0.28315693f, -0.22508955f, 0.25427485f, 0.44402948f, 
    0.20161162f, -0.00395161f, -0.18905912f, 0.17284279f, -0.06383651f, 0.36121112f, -0.13317099f, 0.03397765f, 
    -0.59818417f, 0.12946226f, 0.20837864f, -0.00568540f, 0.02565194f, 0.01391046f, -0.10498924f, 0.19747363f, 
    0.38824093f, 0.20977719f, 0.23416181f, -0.01307213f, -0.03742495f, 0.10935481f, 0.02987833f, 0.07107330f, 
    0.05533988f, 0.03689687f, -0.27656984f, 0.20703395f, 0.00126294f, 0.35931548f, -0.07022623f, 0.11629657f, 
    -0.10359026f, -0.12537162f, 0.20104636f, -0.57057238f, -0.27892092f, 0.05735219f, 0.41659218f, -0.14519289f, 
    -0.22798236f, 0.25714979f, 0.04931739f, 0.00596156f, 0.13197249f, 0.13014272f, 0.15296543f, -0.24553157f, 
    0.09352603f, 0.00292943f, 0.42243737f, -0.48553649f, 0.40096593f, -0.11805478f, 0.19596040f, 0.18250199f, 
    0.07099072f, 0.05309516f, -0.02688913f, -0.34461555f, -0.41707492f, -0.07577137f, -0.17389688f, -0.23359165f, 
    -0.23366451f, 0.01658678f, 0.04790994f, -0.07484230f, -0.16180725f, 0.05740500f, -0.01588746f, 0.35680613f, 
    0.31917122f, -0.29423553f, -0.10934540f, 0.04007917f, 0.01111007f, 0.41841462f, -0.22527102f, 0.46894097f, 
    0.43593806f, 0.11145431f, -0.24303272f, 0.02856668f, 0.08788815f, 0.32051128f, 0.10761335f, 0.21118490f, 
    -0.04650326f, -0.05315758f, 0.06309786f, 0.01786112f, 0.18307541f, -0.05465398f, 0.13065916f, -0.08765749f, 
    0.01691501f, 0.25530592f, -0.03359682f, 0.12388097f, -0.08359833f, 0.21831836f, 0.02739662f, -0.06372639f, 
    -0.00544512f, 0.29068500f, 0.19065604f, 0.09224193f, -0.01523375f, 0.06606594f, -0.24513684f, -0.04065583f, 
    -0.08928437f, -0.01771227f, 0.36320737f, -0.05373307f, 0.08546783f, -0.12392900f, 0.22804466f, -0.17556615f, 
    0.23996966f, 0.15535627f, 0.26257634f, 0.13848375f, -0.15573855f, -0.10417191f, -0.19393133f, 0.00087053f, 
    0.02883447f, 0.06523455f, -0.02562371f, 0.11403101f, -0.44338053f, -0.28369603f, -0.32936782f, -0.13454445f, 
    0.13895555f, -0.12818012f, -0.08667992f, 0.14423947f, -0.12726817f, -0.15690230f, -0.32409602f, -0.31440288f, 
    0.08924526f, 0.07429632f, -0.24744530f, 0.07459290f, -0.12814294f, 0.17718516f, -0.04818228f, -0.27766404f, 
    0.30905357f, -0.07745212f, 0.03883595f, -0.20534000f, 0.16168074f, -0.06770692f, -0.33818495f, -0.55867285f, 
    -0.47273609f, -0.09667688f, 0.27914539f, 0.20528446f, -0.10396966f, -0.23845865f, -0.09714875f, -0.25985631f, 
    0.02548672f, 0.40033954f, -0.14857887f, 0.03614230f, 0.19412120f, 0.04415571f, -0.03623452f, -0.11087319f, 
    0.06273033f, -0.37511879f, -0.34879753f, -0.11674439f, 0.17673844f, 0.16143706f, 0.02795121f, -0.04176960f, 
    0.06333797f, 0.21837205f, -0.02731392f, -0.09952588f, -0.05779437f, 0.02901915f, 0.05175221f, 0.12130726f, 
    -0.21268792f, 0.09547818f, 0.08144333f, -1.20592344f, 0.19002017f, -0.27628565f, 0.33785218f, 0.01539966f, 
    -0.22734986f, -0.03360982f, 0.16076182f, -0.15000778f, 0.94174486f, 0.50605798f, 0.12803845f, 0.12711042f, 
    -0.53557700f, 0.02613963f, 0.00719951f, 0.14611734f, 0.21438667f, -0.52160072f, 0.24755184f, -0.64002776f, 
    0.04812758f, -0.12645555f, 0.20585126f, -0.13033645f, -0.08641752f, 0.30085370f, -0.16947187f, 0.34288394f, 
    0.36497164f, -0.14895318f, -0.05361383f, -0.30663559f, -0.14659005f, -0.16058405f, -0.12240429f, -0.35057065f, 
    -0.34698978f, 0.09329178f, -0.04002440f, -0.09542710f, -0.16182743f, 0.15639842f, 0.12307110f, -0.20758359f, 
    0.89926469f, -0.09244686f, -0.51729912f, -0.04529819f, -0.07492010f, 0.09219547f, 0.08073433f, 0.02192903f, 
    0.14246966f, 0.29144448f, 0.34818241f, 0.11980086f, -0.11767740f, -0.07012127f, -0.02684590f, 0.17920151f, 
    -0.01455761f, 0.06088743f, 0.06595394f, 0.10153090f, 0.14857006f, -0.07872082f, -0.04721215f, -0.00722676f, 
    0.26180345f, -0.03965848f, 0.11969918f, 0.01144646f, 0.08805145f, 0.38631046f, -0.12875627f, -0.11245299f, 
    0.13625263f, 0.14801534f, -0.03888559f, -0.09264635f, 0.30709332f, -0.24447896f, -0.28977406f, 0.02003960f, 
    -0.17583388f, -0.28319174f, -0.01035735f, -0.06246719f, 0.01492604f, 0.15568718f, -0.58816785f, -0.18316503f, 
    -0.08632153f, -0.02069497f, -0.00411313f, -0.10970838f, 0.01101337f, 0.04606221f, -0.02011248f, 0.14194927f, 
    0.19583246f, 0.00579347f, 0.04842483f, 0.01951430f, 0.07683085f, -0.17792536f, -0.06025282f, -0.13513911f, 
    0.14097792f, -0.21814451f, 0.05675638f, 0.13474205f, 0.17849886f, 0.03489131f, 0.16492960f, 0.00744646f, 
    -0.40957803f, -0.58862638f, -0.18025091f, -0.11061117f, 0.08601309f, -0.00135581f, 0.01221918f, 0.06121421f, 
    0.21159357f, -0.02582856f, -0.00055931f, -0.20061114f, -0.06819993f, 0.04676663f, 0.31972322f, -0.09171427f, 
    0.02228360f, -0.03890532f, 0.08638912f, 0.27167070f, 0.24759030f, -0.17526676f, -0.08376090f, -0.03362080f, 
    0.06114098f, -0.15298256f, 0.05891736f, -0.43244743f, -0.21352313f, 0.13129215f, 0.03699376f, 0.10585427f, 
    -0.16640797f, -0.10518058f, 0.01934158f, -0.15876341f, 0.12177516f, 0.39072379f, 0.07159663f, 0.00241746f, 
    0.05552956f, -0.46301344f, 0.24342251f, 0.02573949f, 0.00999233f, -0.14383334f, 0.21587202f, -0.27732378f, 
    0.09286446f, -0.36772642f, 0.16563354f, 0.03296622f, 0.09696668f, 0.05342185f, 0.44953042f, 0.73391533f, 
    0.05190555f, 0.25455922f, -0.31170231f, 0.23147996f, 0.05932203f, -0.03728190f, 0.00117488f, -0.01532886f, 
    -0.10157938f, 0.31287614f, -0.09833759f, 0.17705652f, 0.00110623f, -0.11368326f, -0.11657134f, 0.12262403f, 
    -0.50175178f, -0.54069889f, 0.09254371f, 0.07576682f, 0.07441774f, -0.03060071f, 0.07611322f, 0.12709267f, 
    0.10347862f, -0.41543275f, 0.41972360f, 0.04449838f, 0.24816076f, -0.00347027f, -0.08008686f, -0.03406687f, 
    0.18875568f, 0.10605963f, 0.15268704f, -0.16309008f, 0.05678476f, -0.01484216f, 0.19653296f, -0.01640692f, 
    -0.06525894f, 0.20039546f, -0.12971832f, 0.34665495f, -0.17360242f, -0.17637409f, -0.12844288f, 0.11506541f, 
    0.01198621f, 0.02210744f, -0.07796358f, -0.11415409f, -0.52542388f, -0.08083137f, -0.05694720f, -0.00176742f, 
    0.00963690f, 0.10686561f, -0.02880529f, -0.08857857f, 0.13219303f, -0.19018446f, -1.13485813f, -0.16610406f, 
    -0.30916902f, -0.09407777f, -0.02555042f, -0.16644593f, -0.00714388f, 0.19607234f, 0.68789017f, -0.23552395f, 
    -0.45571890f, 0.30010656f, -0.11747193f, 0.10667167f, 0.23977792f, 0.20868951f, -0.23533270f, 0.51996857f, 
    0.20572150f, -0.01990560f, -0.06964792f, 0.11062150f, 0.05472399f, -0.13135561f, -0.11697901f, 0.07300832f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05827875f, 0.25415137f, 0.01131421f, 0.03270615f, 0.27182510f, -0.06197590f, 0.06465272f, -0.05953273f, 
    0.24497196f, -0.17578390f, -0.08104609f, -0.13680646f, 0.36852247f, 0.18778525f, 0.02115520f, 0.22647029f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.11927506f, 0.00811442f, 0.49781841f, -0.84599078f, -0.33672893f, 0.04371399f, -0.44542018f, -0.22948042f, 
    0.66750509f, -0.18121573f, -0.07406817f, -0.26352677f, -0.56663507f, -0.63091350f, 0.01743836f, 0.36742386f, 
    0.12226543f, -0.33590716f, -0.48910055f, 0.17817993f, -0.31969821f, -0.23853660f, -0.16081716f, -0.23163821f, 
    0.41531289f, 0.09059704f, 0.00855096f, -0.33341527f, 0.04278377f, 0.44585484f, -0.32808059f, 0.89982152f, 
    0.23590364f, -0.50233912f, 0.18488707f, -0.53832591f, 0.12556826f, 0.19945335f, 0.22767819f, -0.04451847f, 
    0.09220668f, -0.45198649f, 0.17694396f, -0.94130212f, -0.56754190f, -0.24349478f, 1.27120292f, -0.19767009f, 
    -0.21280615f, -0.16805279f, 0.35351011f, 0.07230653f, 0.48914561f, -0.19098099f, -0.04770684f, 0.16807695f, 
    -0.63840878f, -0.38927075f, 0.21329738f, 0.55343777f, -0.47278714f, -0.12833805f, -0.28775018f, -0.73504937f, 
    -0.19679582f, 0.02501257f, 0.44777286f, 0.22787338f, -0.11274189f, -0.21403825f, 0.17328812f, -0.13393900f, 
    0.03383826f, 0.25843710f, -0.13223088f, -0.26686496f, -0.01026273f, -0.30914900f, -0.08756428f, -0.39498174f, 
    0.21190694f, 0.52448714f, -0.14083230f, 0.15142104f, -0.44274202f, 0.22709206f, -0.65769488f, -0.07037396f, 
    0.19853881f, 0.45990121f, 0.09225931f, -0.21972328f, 0.60829043f, 0.12888812f, -0.31732920f, -0.02525347f, 
    -0.08635078f, -0.26235947f, 0.18361968f, 0.71934390f, 0.20569669f, -0.00067220f, 0.35845238f, -0.19001088f, 
    -0.21734975f, -0.24979226f, -0.20396140f, -0.30563071f, 0.71854544f, -0.61790210f, -0.70420945f, -0.28495800f, 
    0.03279625f, -0.28583786f, 0.23247288f, -0.06519068f, -0.34171993f, -0.23371945f, -0.81032008f, -0.19426584f, 
    -0.39033160f, 0.90271580f, 0.05661931f, 0.43860102f, -0.16368103f, -0.51509219f, -0.11764114f, -0.35700431f, 
    -0.06761691f, -0.22393927f, -1.30885434f, 0.83184057f, -0.92885154f, -0.21724549f, 0.06488491f, -0.01397157f, 
    0.28785816f, -0.24772859f, 0.17446855f, 0.21551694f, -0.58963633f, 1.15577555f, 0.17439482f, -0.07142459f, 
    0.22525549f, 0.45940140f, 0.25071687f, -0.81675810f, -0.28921381f, -0.22159621f, 0.47501919f, 0.08268184f, 
    0.41282529f, -0.08882774f, 0.13938414f, -0.42697361f, 0.34401074f, -0.33546585f, -0.40287796f, -0.56133091f, 
    -0.18338558f, 0.30566046f, -0.22147068f, 0.12692478f, 0.91188985f, 0.13663599f, -0.33117521f, -0.08825219f, 
    -0.58683884f, -0.26810768f, 0.23423268f, -0.15886548f, -0.62316513f, 0.56390482f, 0.30897307f, -0.33265501f, 
    0.18557331f, 0.79830253f, 0.27780086f, 0.64729601f, -0.21614479f, 0.12056705f, 0.43797481f, -0.10794514f, 
    -0.36359334f, -0.80141318f, -0.26597726f, 0.14348301f, -0.67153555f, -0.32459697f, -0.16261758f, 0.03652163f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19982208f, 0.09331275f, -0.47961384f, -0.10769899f, 0.27110881f, 0.13801354f, 0.17061248f, -0.80288613f, 
    -0.02445622f, 0.19417447f, 0.13311881f, -0.20178945f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
