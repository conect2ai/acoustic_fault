#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.04932050f, 0.29753035f, 0.13456219f, -0.28962594f, 0.43927431f, 0.23456895f, 0.18616486f, -0.54478514f, 
    -0.22579011f, 0.21899231f, -0.09169821f, -0.18345968f, -0.42745316f, 0.30504447f, -0.60901499f, -0.27957389f, 
    0.37377012f, 0.09045534f, -0.20690413f, -0.49527410f, -0.47504601f, 0.83244723f, 0.68175942f, -0.47569948f, 
    -0.39345273f, -0.40834203f, -0.28537163f, -0.71242100f, -0.32059836f, -0.47895610f, 0.21922648f, 0.55459100f, 
    -0.07539681f, 0.40651929f, 0.46330652f, 0.30536091f, -0.89887017f, -0.49095565f, -0.40641636f, 0.91396421f, 
    -0.16979416f, -0.04777166f, -0.09510739f, -0.38794461f, 0.03042357f, 0.83447295f, -0.34460977f, 0.53239542f, 
    0.19788262f, -0.57286429f, -0.47941780f, -0.39562675f, -0.30068323f, 0.67466009f, -0.19297209f, -0.43507954f, 
    -0.74622434f, -0.21244499f, 0.84219873f, 0.94165486f, 0.25195050f, 0.17056623f, -0.21578206f, 0.09520820f, 
    0.37306461f, 0.87277836f, -0.60707957f, -0.35864595f, -0.23152845f, 0.29082766f, -0.10258527f, 0.18155123f, 
    -0.80477989f, -0.18474959f, -0.35824117f, -0.16738145f, -0.27760127f, -0.54314530f, 0.12859435f, -0.28788960f, 
    -0.47802031f, -0.13096896f, -0.54326016f, 0.47123078f, -0.54381275f, -0.59275573f, 0.36043227f, -0.49787748f, 
    0.31580216f, -0.11662966f, -0.46803835f, 0.97163266f, -0.44296479f, -0.13698086f, -0.31726146f, -0.11572488f, 
    0.21151480f, -0.46763772f, 0.54783010f, 0.21947265f, 0.37002775f, -0.21565351f, -0.32992136f, 0.69074559f, 
    -0.54098076f, -0.16036309f, -0.31892401f, -0.28474930f, 1.36147714f, -0.59121358f, -0.90041804f, 0.32064134f, 
    0.13119172f, -0.01861002f, 0.07253201f, 0.32025695f, 0.01708233f, 0.54360181f, 0.16277245f, 0.34848252f, 
    0.43795636f, -0.19257195f, -0.53596717f, 0.39150611f, 0.01873593f, -0.18645254f, -0.22786440f, 0.09649292f, 
    0.26795563f, 0.02942399f, -0.81261158f, -1.04605389f, 0.45475268f, -0.18414803f, 0.32579431f, 0.25915626f, 
    -0.01799316f, -0.22796106f, -0.49636987f, 1.02333939f, -0.71947384f, -0.25994954f, 0.45951223f, 0.28454188f, 
    -0.13334829f, -0.00598633f, 0.63807464f, -0.20405780f, 0.39879790f, 0.37681639f, -0.07226080f, 0.21993224f, 
    0.37046739f, -0.61110240f, -0.08565423f, 0.56236607f, -0.29588619f, 0.08272479f, 0.57752287f, 0.60882300f, 
    -0.63799024f, -0.20331885f, -0.48760182f, -0.04727566f, 0.08920662f, 0.10925706f, 0.27239451f, 0.35239872f, 
    -0.12495853f, 0.14632799f, 0.25958133f, 0.40397906f, -0.01454512f, -0.03505516f, 0.28515685f, -0.03194904f, 
    0.23837997f, -0.08445916f, 0.79451215f, -0.77481300f, -0.34592816f, 0.64445502f, -0.30142039f, -0.20392001f, 
    -0.12186893f, -0.35963956f, 0.44895384f, 0.47104964f, 0.52371830f, 0.00328923f, -0.11448622f, -0.06814201f, 
    -0.51531488f, -0.75590682f, -0.71499044f, -0.12353034f, 0.78952098f, -0.44471058f, -0.57685137f, -0.47362936f, 
    -0.06557103f, -0.04996742f, 0.13602041f, 0.21811801f, 0.13970165f, 0.15720512f, 0.42829674f, 0.50204915f, 
    -0.15273529f, -0.66938406f, -0.64548916f, -0.22481629f, -0.32664132f, -0.26031658f, -0.48004341f, -0.29706863f, 
    0.17445956f, 0.12475346f, -0.20522583f, 0.57756382f, -0.60350507f, 0.06074325f, -0.02120466f, 0.35660699f, 
    0.30913466f, -0.50835520f, 0.43345326f, -0.04698201f, 0.23416759f, 0.16823497f, 0.55906743f, -0.55232185f, 
    -0.08741280f, -0.50194663f, -1.19668853f, 0.56853664f, 0.73490506f, -0.57592213f, -0.40629199f, 0.49365413f, 
    0.17602010f, 0.30127332f, -0.29561335f, 0.04322911f, 0.12469249f, 0.46788341f, -0.15936047f, -0.10811665f, 
    -0.29374471f, 0.39230022f, -0.49445742f, -0.16286607f, 0.22206576f, 0.36675936f, 0.38123080f, -0.18763258f, 
    0.50440264f, 0.30015573f, -0.17095491f, 0.25191155f, -0.35206342f, -0.35192671f, -0.12247469f, -0.40499333f, 
    -0.69222647f, 0.04164642f, -0.70116103f, 0.36274862f, 0.17140411f, 0.55584329f, -0.11239318f, -0.46276054f, 
    -0.67042458f, 0.05193992f, -0.26072037f, 0.33253944f, -0.36454672f, 0.00741121f, 0.76559353f, -0.08780584f, 
    1.09277749f, -1.19615805f, -0.04111514f, 0.05688471f, -0.02972651f, 0.27319884f, 0.05324291f, 0.16373850f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22664161f, 0.16734615f, 0.13709703f, -0.19295342f, -0.25482202f, -0.05625632f, -0.05152051f, 0.16404107f, 
    0.17223811f, 0.27417168f, -0.09779777f, 0.12582925f, 0.35242602f, 0.23338965f, 0.16330770f, -0.03123191f, 
    0.38486791f, -0.17942829f, 0.15924966f, -0.04816634f, -0.10967661f, 0.07756644f, 0.43151703f, -0.38040513f, 
    -0.28305200f, -0.15442911f, -0.03902956f, 0.27544281f, 0.04379870f, -0.27709219f, -0.20512006f, -0.12159514f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.04593436f, -0.06080829f, 0.35042188f, -0.04115304f, -0.04136245f, -0.06801161f, 0.11046330f, 0.21137743f, 
    0.06568111f, -0.00313737f, -0.08368228f, 0.19718392f, -0.02489542f, 0.08762747f, 0.01364769f, 0.15851076f, 
    0.02428076f, 0.08681225f, 0.06930988f, -0.14737928f, 0.05972259f, 0.04530807f, 0.15681091f, -0.12056579f, 
    -0.14697465f, 0.00951800f, -0.07960395f, -0.09070074f, -0.22443669f, 0.00238126f, -0.09020446f, -0.02299158f, 
    -0.03191391f, -0.02808308f, -0.04063663f, 0.00799330f, -0.11513472f, -0.17154045f, -0.13844460f, 0.07255115f, 
    0.21562886f, -0.18833460f, -0.36553979f, 0.06136819f, -0.22159941f, 0.25776151f, 0.44255471f, 0.04987350f, 
    -0.25333861f, 0.11399800f, -0.08669061f, 0.24428076f, 0.19432463f, 0.02308132f, 0.00141373f, -0.12466116f, 
    -0.30028474f, -0.01989902f, -0.05602702f, 0.00412615f, -0.05417151f, -0.15251279f, 0.08689725f, 0.00238395f, 
    0.27770340f, 0.01697809f, -0.01087806f, -0.01124950f, -0.12693098f, -0.05679069f, 0.05656114f, -0.01084107f, 
    0.12873742f, 0.09500185f, -0.07564973f, -0.19048731f, 0.08537535f, 0.00705608f, -0.07866678f, -0.01075270f, 
    -0.05902886f, -0.17933841f, 0.31084359f, 0.16023859f, -0.24855906f, 0.03001089f, -0.01026849f, 0.09507416f, 
    -0.04058488f, 0.05044146f, -0.57554549f, 0.11285274f, -0.82153481f, -0.13669182f, -0.21059386f, 0.31603754f, 
    -0.11754419f, 0.24253955f, 0.06557127f, 0.19838485f, -0.27201986f, 0.22514746f, 0.06184956f, -0.07329226f, 
    -0.13549057f, 0.02372306f, -0.00695521f, -0.01129151f, 0.02026078f, -0.16172102f, 0.15526363f, 0.00176346f, 
    0.10830025f, 0.32954001f, -0.04251194f, 0.06599144f, 0.00151328f, 0.22046489f, 0.37735841f, 0.11272059f, 
    0.08677911f, -0.08678524f, -0.15796089f, 0.12594752f, 0.15549147f, 0.17384402f, -0.49410826f, -0.06994482f, 
    0.23276474f, -0.12426557f, 0.06984013f, -0.34516829f, -0.03513354f, 0.09989581f, 0.12159079f, 0.08771798f, 
    -0.32208350f, 0.28655994f, 0.08328240f, -0.11944183f, 0.05622956f, 0.21296354f, -0.00195709f, -0.01180503f, 
    0.18248229f, 0.10651670f, -0.10573110f, 0.08588319f, 0.04298989f, -0.00211576f, 0.11692742f, 0.03288474f, 
    -0.09904332f, -0.11232730f, 0.13686667f, 0.37707528f, 0.07253760f, 0.02396908f, 0.02075029f, 0.08863020f, 
    0.02834824f, 0.13686951f, -0.02844257f, -0.04064483f, -0.18499604f, 0.12161208f, -0.04714090f, -0.01648781f, 
    -0.12496509f, 0.01103943f, 0.03099042f, 0.11423212f, -0.07352225f, 0.33461976f, -0.00411168f, -0.06763105f, 
    -0.01414705f, 0.05395291f, 0.18833974f, 0.11818402f, -0.19868439f, -0.16315496f, -0.11379044f, 0.10694550f, 
    0.13639817f, -0.00788237f, 0.11738341f, 0.08067942f, 0.07000287f, -0.19161768f, -0.25637224f, 0.26251444f, 
    -0.20349318f, 0.14813195f, -0.29480532f, 0.06470416f, 0.12112566f, 0.13287781f, -0.14770246f, -0.14733678f, 
    -0.18444662f, 0.00699898f, -0.10377796f, -0.05656570f, -0.02806964f, 0.03929537f, 0.00301360f, -0.10564655f, 
    -0.07545232f, -0.07485570f, -0.13542405f, -0.22658305f, 0.21435335f, -0.05467822f, -0.16392651f, -0.06461754f, 
    -0.02414483f, 0.10748957f, 0.00114057f, 0.01548291f, 0.02712761f, -0.03588246f, -0.12875313f, 0.16983712f, 
    -0.11975804f, -0.09530712f, -0.15730830f, -0.29453245f, 0.06717440f, -0.02517300f, 0.04554886f, -0.04111826f, 
    -0.13324881f, 0.13538216f, -0.21111374f, 0.15002422f, -0.23081189f, -0.11745323f, 0.22548248f, -0.11172345f, 
    -0.04133667f, 0.18842207f, 0.14667712f, -0.09207303f, 0.20823155f, 0.25906610f, -0.20454590f, -0.13590327f, 
    -0.09699958f, 0.02187523f, 0.07549158f, 0.08360948f, 0.20676234f, 0.10693053f, 0.15896431f, -0.02552663f, 
    0.00471117f, -0.05501368f, -0.04787638f, 0.14969505f, 0.13149740f, -0.56832558f, -0.48722139f, -0.17005172f, 
    -0.05048758f, 0.02117391f, -0.29041258f, 0.02508992f, -0.00166540f, 0.09851085f, 0.08820861f, 0.20008825f, 
    -0.73798573f, 0.06879693f, -0.22179259f, 0.01909641f, 0.11589105f, 0.07434807f, -0.24928164f, -0.16189900f, 
    -0.20765367f, -0.34107313f, 0.03798523f, -0.00588416f, 0.11576340f, 0.10487787f, -0.13608216f, -0.08241943f, 
    -0.07297705f, 0.10575496f, 0.04210922f, -0.10383759f, 0.00047981f, -0.12296227f, 0.08885423f, -0.00398138f, 
    0.08859224f, -0.15054272f, 0.16383730f, 0.26383522f, 0.14426337f, 0.00929052f, 0.12219924f, 0.04639480f, 
    0.11949822f, 0.05051741f, -0.32797703f, 0.16863725f, -0.34179455f, -0.09354658f, 0.03588297f, 0.05354844f, 
    0.06701396f, -0.03327221f, 0.13234229f, 0.08140435f, -0.16643474f, 0.02112032f, -0.13105001f, 0.14160974f, 
    -0.05299656f, 0.15972890f, -0.08000469f, 0.04169841f, -0.74862856f, -0.29162765f, -0.40237597f, 0.06058576f, 
    -0.10476073f, 0.20453095f, -0.19223350f, -0.05675918f, 0.06294950f, -0.16862778f, -0.09242365f, -0.09276654f, 
    -0.03223102f, -0.00556761f, -0.13713036f, 0.19657935f, -0.10698680f, -0.00166273f, -0.16533709f, -0.60465628f, 
    -0.21264981f, 0.02352737f, 0.01879952f, -0.02426177f, 0.10582667f, -0.02922780f, 0.15621161f, 0.10429274f, 
    -0.03612335f, 0.05458788f, 0.10101987f, 0.03115389f, -0.03288945f, -0.02938015f, 0.06321826f, -0.00664962f, 
    -0.05575314f, 0.12841032f, 0.07126466f, -0.01379629f, -0.08374438f, 0.04634264f, -0.05947723f, 0.04687673f, 
    0.15340954f, 0.08857568f, 0.01177818f, 0.26815191f, -0.08579233f, -0.07369270f, -0.02600361f, 0.14074555f, 
    0.12862964f, 0.05419382f, 0.25600827f, -0.17262703f, -0.39942226f, -0.06145946f, 0.12021099f, 0.15556572f, 
    -0.04708664f, 0.17422736f, 0.04655654f, 0.13101742f, 0.14815804f, 0.07861748f, -0.03870462f, -0.06037251f, 
    -0.10289408f, 0.15016921f, -0.09115721f, 0.02136084f, -0.36487547f, -0.04294230f, 0.03855687f, -0.07205088f, 
    0.20726085f, 0.06211025f, 0.04199945f, 0.11449277f, -0.01081848f, 0.01201310f, -0.01968887f, -0.24948430f, 
    0.10091031f, 0.10850952f, 0.01133421f, 0.04771793f, -0.03357711f, 0.12069049f, -0.05966319f, 0.17552818f, 
    0.20031473f, -0.02539519f, -0.03638908f, -0.12205786f, 0.14128606f, 0.07260394f, -0.05837452f, -0.45425236f, 
    0.08065148f, 0.28674173f, 0.07590461f, 0.16464861f, -0.12254705f, 0.17398374f, 0.22175524f, -0.13864008f, 
    0.15223867f, -0.04180073f, -0.06692545f, 0.02191168f, -0.05341967f, -0.13030669f, 0.09293474f, 0.03924518f, 
    -0.05245572f, 0.01916991f, 0.22544700f, -0.14536156f, 0.22115074f, -0.05634205f, 0.02130685f, 0.09677099f, 
    -0.08315285f, -0.02529985f, 0.20589115f, -0.10185914f, -0.21241942f, -0.03597749f, 0.07585187f, -0.08370090f, 
    0.15307698f, -0.08450916f, -0.01264972f, -0.39894149f, 0.16703482f, -0.11194717f, 0.11414847f, -0.01133289f, 
    -0.21634108f, 0.05842309f, -0.01794059f, 0.14135651f, -0.10384544f, -0.21753138f, -0.28496009f, -0.16633567f, 
    0.02886852f, -0.00021788f, -0.01759870f, 0.04929333f, -0.12967828f, -0.00869793f, -0.01630675f, 0.32649389f, 
    -0.09524668f, -0.03212165f, 0.04411423f, 0.13140891f, -0.05927450f, 0.20745146f, 0.23013903f, -0.22413519f, 
    -0.12161840f, 0.04098735f, 0.07689621f, -0.01257400f, 0.12959275f, -0.15260081f, -0.07463992f, 0.13089922f, 
    -0.01036352f, -0.21535422f, -0.03631474f, -0.05892403f, -0.00949153f, 0.08987673f, -0.20161068f, 0.04869890f, 
    -0.17109077f, 0.03877434f, -0.19122508f, -0.28742978f, -0.11435241f, -0.16806740f, 0.18969157f, 0.08732001f, 
    0.12492118f, -0.09791342f, 0.11691652f, -0.05024365f, -0.05335454f, 0.09910870f, -0.24963321f, -0.16888310f, 
    0.13779189f, 0.06842303f, 0.01805379f, -0.00935475f, 0.24407300f, -0.00668376f, -0.15481022f, -0.17814606f, 
    0.05674242f, 0.06327387f, 0.14196759f, 0.04529685f, 0.19125682f, 0.24706006f, 0.06529763f, 0.05670909f, 
    0.02319502f, 0.08016361f, 0.10038202f, 0.22207366f, -0.08956520f, 0.07764532f, 0.11711367f, 0.02332809f, 
    -0.06946222f, -0.24384782f, -0.06084841f, 0.01162036f, 0.03174388f, -0.07139877f, -0.30916035f, 0.25540370f, 
    -0.09107821f, -0.16047689f, -0.22648419f, -0.17444654f, -0.04085098f, 0.03649002f, -0.24425356f, -0.12165646f, 
    -0.15143462f, 0.22206619f, 0.06042071f, -0.04236168f, -0.05208122f, -0.01528817f, -0.30707219f, 0.36706248f, 
    -0.22615860f, -0.68656480f, 0.08052669f, -0.11809410f, 0.09797534f, 0.00387200f, 0.01105212f, -0.04595408f, 
    -0.00719939f, -0.04371927f, 0.04430877f, 0.04212661f, 0.04951717f, -0.05159238f, -0.05629481f, -0.00615375f, 
    -0.05650379f, 0.04549554f, 0.05702211f, -0.03414429f, -0.05148675f, 0.01630818f, 0.03869670f, -0.02616306f, 
    -0.03880337f, -0.05541519f, 0.02254824f, 0.04847511f, -0.04881528f, -0.01710910f, -0.00430904f, -0.04732553f, 
    -0.02400852f, -0.01462047f, -0.05201753f, -0.00616888f, 0.05017192f, 0.04237349f, 0.01081533f, 0.02714713f, 
    -0.05364721f, -0.04039107f, 0.02774731f, 0.00117088f, -0.01496894f, -0.01797609f, -0.05262630f, -0.05779287f, 
    -0.03893488f, 0.00699184f, -0.01439716f, 0.04029571f, 0.04437035f, -0.00569513f, -0.05855793f, 0.04183941f, 
    0.03058464f, -0.02180648f, -0.05144110f, -0.05836472f, -0.02230736f, -0.05578785f, -0.00214608f, -0.01424373f, 
    0.05234891f, 0.00728998f, -0.04785188f, 0.04493548f, -0.02211826f, -0.04965991f, 0.02198204f, 0.02451566f, 
    -0.01518012f, -0.04635623f, 0.01155912f, -0.03089305f, 0.04403009f, -0.03310140f, -0.00152134f, 0.02764057f, 
    -0.03789324f, -0.04595058f, -0.00961613f, 0.00524097f, -0.03396047f, -0.01847605f, -0.01531051f, 0.04876130f, 
    -0.03601419f, -0.02505726f, -0.03029938f, -0.05808156f, 0.01493614f, 0.00555170f, -0.03984336f, 0.01394862f, 
    0.02486110f, -0.04272792f, -0.05401278f, -0.01897971f, 0.02391735f, 0.02768768f, 0.05140987f, 0.04800986f, 
    -0.01188341f, -0.01484303f, -0.04861931f, -0.05342519f, -0.00739034f, -0.03708735f, -0.03571492f, 0.04481526f, 
    -0.04101625f, 0.05455842f, -0.01881279f, 0.00989443f, -0.01553844f, -0.06155178f, -0.05476348f, -0.04216696f, 
    -0.05125972f, -0.04019450f, 0.04215162f, -0.00531731f, 0.05072991f, 0.03673482f, -0.00943131f, -0.06219947f, 
    0.00156151f, 0.01059224f, 0.03812262f, -0.03552179f, -0.06170650f, 0.03473854f, -0.05844004f, -0.02882748f, 
    0.04521959f, 0.02008972f, -0.06237380f, 0.05259169f, -0.06098131f, -0.03256077f, -0.04138067f, -0.03487955f, 
    0.00409791f, 0.03673585f, -0.04657600f, 0.05057313f, 0.03063107f, -0.04858650f, -0.00853476f, 0.01944729f, 
    -0.03212440f, -0.01290910f, -0.00582784f, -0.05154930f, -0.01790470f, 0.03796440f, 0.00088534f, -0.03079577f, 
    -0.04847218f, 0.01753538f, -0.05110931f, -0.01543328f, -0.04374640f, -0.01906015f, -0.02260324f, 0.01312058f, 
    -0.04613480f, -0.05293227f, -0.01042858f, 0.01678165f, 0.04516784f, -0.03769497f, -0.02324221f, 0.00458528f, 
    -0.06316217f, -0.02442068f, 0.03838513f, 0.00780505f, 0.02404354f, -0.02757801f, 0.04370099f, 0.00873674f, 
    0.05214234f, -0.06462362f, 0.04558926f, -0.04942136f, 0.04008809f, -0.06487638f, 0.01829253f, -0.01619825f, 
    0.04682694f, 0.00542626f, 0.01325771f, -0.03296705f, 0.03506936f, -0.01209653f, -0.04026727f, 0.01354029f, 
    -0.04092379f, -0.00143813f, -0.01042287f, -0.03294392f, 0.04810001f, -0.01536742f, -0.03147145f, 0.02535435f, 
    -0.06440180f, 0.02495031f, 0.00964472f, -0.00562067f, -0.04747703f, -0.02244168f, 0.00066499f, 0.03172559f, 
    0.00463505f, -0.03134245f, -0.00830161f, -0.00167949f, -0.05947560f, 0.00925166f, -0.00322105f, -0.02605267f, 
    0.04189754f, 0.01714998f, -0.01882921f, -0.02388261f, -0.02000316f, -0.00256452f, -0.02206935f, 0.00454580f, 
    -0.04271696f, 0.02568970f, 0.00441559f, 0.00203778f, -0.04172016f, 0.03515010f, -0.03868908f, -0.04826980f, 
    0.03321464f, -0.06252991f, -0.05044089f, -0.05007383f, 0.03715673f, 0.04374152f, -0.01365748f, 0.04991464f, 
    0.04411051f, 0.03614604f, 0.01813478f, -0.04702232f, -0.01706819f, -0.03174399f, 0.01269147f, -0.00606270f, 
    -0.02546756f, 0.03650629f, 0.00631823f, -0.00181749f, 0.03641310f, -0.02234222f, 0.00325745f, -0.00013439f, 
    -0.04146853f, 0.00742141f, -0.01128506f, 0.02873728f, 0.04598985f, -0.03832194f, 0.05431625f, -0.02351381f, 
    0.01749291f, -0.02351821f, -0.06382351f, 0.00463828f, 0.03821928f, -0.00585252f, 0.01833301f, -0.05652138f, 
    0.01976096f, -0.01909633f, -0.04930796f, -0.06490535f, -0.01763894f, -0.02012938f, -0.05524116f, 0.02268286f, 
    -0.00934427f, -0.01413156f, -0.01833826f, -0.03657799f, -0.00470979f, -0.05928868f, -0.03074023f, -0.05006051f, 
    -0.08278245f, -0.11608852f, 0.08191036f, -0.01752576f, -0.10619063f, -0.05435718f, -0.39558783f, -0.05987523f, 
    -0.09088519f, 0.09604542f, 0.24509889f, 0.12147177f, -0.01224023f, 0.12044878f, -0.00485561f, 0.12732421f, 
    -0.21832579f, 0.00623494f, 0.07670018f, 0.09435931f, -0.32517210f, 0.02187376f, -0.03601756f, -0.01883578f, 
    -0.13610481f, -0.23097925f, -0.13195594f, 0.15225871f, 0.17748910f, -0.02646912f, 0.06477938f, -0.14170167f, 
    0.02841081f, -0.01304413f, 0.03238277f, 0.00331904f, 0.34950215f, 0.19316937f, -0.12854974f, 0.16724098f, 
    0.01420128f, 0.10582928f, 0.01017528f, -0.08140528f, 0.04284751f, 0.18221709f, -0.15526120f, -0.09030713f, 
    0.00330696f, 0.00070926f, 0.04459637f, 0.10661644f, -0.39723676f, -0.18703689f, 0.09452207f, -0.03008184f, 
    0.16091812f, 0.03950520f, 0.11604837f, -0.06115568f, -0.20101975f, -0.02488806f, -0.03161698f, -0.19860053f, 
    -0.10060316f, 0.05551711f, 0.09632670f, -0.01200873f, 0.12963577f, -0.06324325f, 0.12139161f, -0.05136152f, 
    0.21332723f, 0.30039304f, -0.04610824f, -0.00910134f, 0.01733069f, 0.00044062f, 0.09252965f, -0.03997266f, 
    -0.12047190f, 0.07777815f, 0.19485600f, 0.21977809f, 0.05711124f, -0.01410327f, 0.00611320f, 0.08022659f, 
    0.06947910f, -0.17619163f, 0.06031991f, 0.20336834f, 0.42223424f, 0.11596952f, 0.33836210f, 0.09109519f, 
    0.00460287f, -0.02940131f, -0.14487961f, 0.10582452f, -0.01690895f, -0.02754954f, 0.00352221f, -0.10045005f, 
    -0.01650884f, -0.16717830f, -0.10627414f, -0.21109621f, -0.01021553f, -0.05641763f, -0.25002792f, 0.15217626f, 
    0.13195476f, -0.19103619f, -0.03635296f, -0.34553379f, -0.05515132f, -0.05371574f, -0.06535109f, 0.01828578f, 
    -0.03415689f, 0.03610473f, 0.02614849f, -0.14866634f, 0.05145159f, -0.12607993f, -0.01606706f, 0.18291907f, 
    0.06417017f, -0.05562987f, 0.08133622f, 0.04980046f, 0.06364015f, -0.06692123f, -0.14587344f, 0.18873778f, 
    0.14087999f, 0.25707090f, -0.03145638f, 0.03677491f, -0.17300440f, 0.13696693f, 0.10007451f, 0.14752004f, 
    0.04091654f, -0.07019194f, 0.12816125f, -0.14034276f, -0.01152143f, -0.02609640f, -0.06806307f, 0.02116007f, 
    -0.01048843f, -0.03951387f, -0.15790924f, 0.33442858f, 0.07464202f, -0.06457628f, -0.04085106f, -0.30750751f, 
    -0.19221455f, -0.02669936f, 0.08801620f, -0.06187254f, 0.06109774f, -0.07665679f, -0.11912207f, -0.13199097f, 
    0.03089508f, 0.04505054f, 0.06823956f, -0.00299181f, 0.16795377f, -0.09921429f, 0.02819834f, -0.06531529f, 
    -0.00710271f, -0.10830089f, -0.04206338f, -0.10174580f, 0.00291766f, 0.05217094f, 0.10046219f, -0.29216415f, 
    -0.08619104f, 0.08037518f, 0.05645040f, 0.26038530f, 0.00967956f, 0.08823065f, 0.28204325f, -0.22131935f, 
    0.03843586f, 0.23356719f, 0.14292686f, 0.03106339f, -0.02974807f, -0.07950743f, 0.16625042f, 0.07833563f, 
    0.03643630f, 0.00881792f, -0.25979209f, -0.11813068f, 0.02591315f, 0.08868172f, 0.03693143f, 0.09896881f, 
    0.24387714f, 0.18485203f, 0.09248710f, 0.07932564f, -0.02686485f, 0.24181405f, -0.07903215f, -0.16990674f, 
    0.04676582f, 0.14422356f, 0.10674804f, 0.04619149f, 0.05004332f, -0.20879343f, 0.13050014f, 0.13788612f, 
    0.07026304f, 0.01232945f, -0.11654168f, 0.05582710f, 0.16158524f, 0.10061370f, 0.07670671f, -0.32877457f, 
    -0.26973405f, -0.28021953f, 0.07043475f, 0.11046574f, 0.42126444f, -0.02333784f, -0.28123128f, 0.08498316f, 
    -0.14161235f, 0.05829570f, -0.22612505f, -0.11112617f, 0.04205995f, 0.07231487f, 0.06222103f, -0.05072689f, 
    -0.02931307f, -0.22670150f, 0.09197940f, -0.01528252f, 0.03705509f, -0.15202121f, 0.07680642f, -0.05774320f, 
    0.02830105f, 0.11256585f, -0.15921903f, -0.21794768f, -0.09087823f, 0.10819717f, 0.39674520f, 0.30991235f, 
    -0.11502095f, -0.01892559f, 0.08935213f, 0.13732876f, 0.05951848f, 0.13223569f, 0.11278253f, 0.09316420f, 
    0.07735899f, -0.02600989f, 0.03584126f, -0.16546442f, 0.12710585f, -0.07547374f, 0.19798766f, -0.01599288f, 
    0.07519342f, 0.04625270f, 0.04790743f, 0.07932623f, -0.10947597f, -0.03018071f, 0.00447493f, -0.03517710f, 
    0.18708271f, -0.01747272f, -0.11613256f, 0.13777255f, 0.02624273f, 0.04181054f, 0.13969557f, 0.04851371f, 
    0.03141350f, -0.05786464f, 0.15464559f, 0.14439648f, 0.01420764f, 0.09925916f, -0.03665736f, -0.17149094f, 
    -0.20914811f, 0.07640393f, -0.12293977f, 0.07279249f, 0.13203467f, 0.10094982f, 0.12493691f, -0.14989091f, 
    -0.08178327f, 0.07330531f, 0.15856662f, -0.08267619f, -0.15075389f, 0.09931003f, 0.03355232f, 0.09466308f, 
    0.05422284f, -0.03883693f, -0.31000894f, 0.05752061f, -0.36482272f, -0.22133744f, 0.16524641f, 0.18617094f, 
    -0.02484481f, -0.01495618f, 0.11975201f, -0.14143093f, 0.19474357f, 0.22458509f, 0.15272655f, -0.08384828f, 
    0.04185732f, 0.09092570f, -0.03843203f, 0.06360894f, -0.07362969f, -0.00757963f, 0.02148391f, 0.23552898f, 
    -0.31610858f, 0.01219112f, -0.10081109f, 0.08767400f, -0.14870602f, 0.15401089f, 0.16014837f, 0.04305205f, 
    -0.24870358f, -0.28755197f, 0.04619964f, -0.11201379f, 0.04544131f, 0.00987648f, 0.04644486f, 0.03121709f, 
    -0.09970619f, 0.04969448f, 0.17476836f, 0.02205306f, 0.02355602f, 0.08145805f, 0.14415495f, -0.04694677f, 
    0.15098649f, -0.07070228f, -0.08760569f, 0.13994181f, 0.07447319f, 0.11291680f, 0.02270760f, -0.03790037f, 
    0.13542375f, -0.09213016f, 0.04500862f, 0.21328358f, -0.21450357f, -0.12290929f, -0.15121709f, 0.00713514f, 
    0.18193112f, 0.25148910f, -0.11681639f, 0.19249855f, -0.07890090f, -0.03854834f, 0.26147512f, -0.23894058f, 
    -0.03923539f, 0.12530763f, 0.05081955f, 0.12303434f, 0.09402584f, 0.14144407f, -0.04752553f, -0.08377696f, 
    -0.04362975f, 0.03133383f, -0.03883616f, -0.00253237f, 0.21738288f, 0.23761646f, -0.08232836f, -0.06803500f, 
    0.09491672f, 0.09985236f, 0.01309628f, 0.06944946f, 0.00293855f, 0.01914867f, 0.22833440f, -0.04094675f, 
    0.23061314f, -0.03389490f, -0.19190069f, -0.01802047f, 0.02668343f, -0.05266185f, -0.09565682f, -0.22231174f, 
    -0.06537937f, 0.10545028f, -0.10964090f, 0.13381006f, 0.13867113f, -0.26202285f, -0.11299877f, 0.11403369f, 
    0.02519801f, -0.10055417f, -0.18888950f, 0.05618509f, 0.02999768f, 0.05156868f, -0.10158074f, -0.07295449f, 
    -0.11302254f, -0.07636602f, -0.13914642f, -0.29161516f, 0.05815903f, 0.20001352f, 0.07257115f, 0.18161462f, 
    -0.04036077f, 0.14969237f, -0.04847933f, -0.02058185f, -0.08637642f, 0.14255212f, -0.03270243f, -0.07485142f, 
    -0.05356935f, -0.04211515f, -0.06519409f, 0.25660470f, -0.04636637f, -0.24166912f, 0.10965901f, -0.01343194f, 
    -0.00040360f, -0.05468012f, -0.08447954f, 0.02499039f, 0.21257286f, 0.12417117f, -0.10205755f, -0.02160960f, 
    -0.01844949f, 0.09614720f, 0.16981038f, -0.17134319f, -0.60332263f, 0.14638826f, 0.05154850f, 0.31121510f, 
    -0.03133687f, 0.16166820f, -0.03584169f, -0.05278678f, -0.12911746f, 0.01908016f, 0.01671008f, 0.02057827f, 
    -0.02206035f, 0.06941035f, 0.05403466f, 0.04426996f, 0.11095918f, -0.08644056f, -0.17862295f, 0.14831996f, 
    0.24390970f, 0.33508945f, 0.22483307f, 0.17487492f, 0.08676215f, 0.02048225f, -0.01162920f, 0.03120755f, 
    0.16449924f, 0.06277657f, -0.11801095f, -0.16271138f, -0.05040986f, 0.04516963f, 0.07081355f, -0.06132409f, 
    -0.17842852f, 0.29528570f, -0.07492242f, -0.46771055f, 0.14927928f, -0.10127669f, 0.14548177f, 0.00744993f, 
    -0.07653841f, 0.24116921f, 0.04248564f, -0.05619880f, -0.14304516f, 0.01276517f, 0.02144973f, -0.15466496f, 
    0.13923995f, 0.05733350f, 0.01886803f, 0.17197366f, -0.10568964f, 0.27075249f, 0.11441313f, -0.01815807f, 
    0.14085408f, 0.05452266f, 0.10997050f, 0.09589284f, 0.25308365f, -0.14193213f, 0.00955118f, 0.20994809f, 
    -0.01868316f, -0.06738027f, 0.01086066f, -0.00285910f, 0.07408476f, 0.30502719f, -0.04113190f, 0.13695981f, 
    -0.03906902f, -0.00897003f, -0.03925490f, 0.15983655f, -0.34230530f, -0.34281239f, 0.08370988f, 0.11757743f, 
    0.48579428f, 0.33794069f, 0.10426719f, 0.07043143f, 0.02604802f, 0.19984314f, -0.34533298f, 0.27431637f, 
    0.10372256f, -0.31625658f, -0.02403235f, -0.08854529f, 0.04981906f, 0.07828014f, 0.11932767f, -0.27367726f, 
    -0.00131703f, 0.05083580f, 0.12774278f, -0.02015275f, -0.00314103f, -0.11615779f, -0.20925359f, -0.02399497f, 
    0.01490740f, -0.34619570f, -0.23805086f, 0.33489177f, 0.02049286f, -0.00942587f, 0.03498788f, 0.03504616f, 
    0.04144957f, 0.15917906f, 0.10987189f, -0.39971229f, 0.08602548f, -0.13140610f, -0.03990231f, -0.00295617f, 
    0.09461201f, -0.03348447f, -0.11632717f, 0.17959893f, -0.18318561f, -0.23332661f, 0.13142733f, 0.11773305f, 
    0.06838401f, 0.05919154f, -0.03565979f, -0.00684018f, 0.92537856f, -0.51941437f, -0.88405704f, -0.11606701f, 
    0.00467853f, -0.08983763f, 0.09821288f, 0.05038852f, -0.12912068f, 0.05594047f, -0.30773598f, 0.20940161f, 
    -0.06678492f, 0.08381835f, 0.03875040f, 0.16755000f, 0.15057404f, 0.11405154f, -0.14499599f, -0.07310728f, 
    -0.41053274f, 0.05611262f, -0.26575735f, 0.06133552f, -0.03064634f, -0.02040502f, 0.06162203f, 0.01558695f, 
    0.03783246f, -0.04065007f, -0.02114397f, 0.08816677f, 0.01383571f, 0.09860132f, 0.24239345f, 0.09303481f, 
    -0.00965381f, -0.30627680f, -0.30405793f, -0.04209379f, 0.02897163f, -0.05956591f, 0.04503176f, 0.06765532f, 
    -0.14626275f, -0.10853831f, -0.15541010f, -0.21743228f, 0.07139241f, 0.04011306f, -0.01124709f, 0.17734106f, 
    -0.02291611f, 0.05729805f, -0.01524576f, 0.12951787f, -0.46229085f, -0.07305030f, 0.09819178f, 0.29100829f, 
    -0.03307839f, 0.21650679f, 0.05432387f, 0.00826921f, 0.14983635f, 0.15944558f, 0.05568523f, -0.04515582f, 
    -0.02166877f, -0.04289659f, -0.06443749f, -0.15345217f, -0.09800132f, -0.22239818f, 0.31917381f, 0.07320890f, 
    -0.14214063f, 0.19889830f, 0.02485640f, -0.06546281f, 0.07882638f, 0.02468683f, 0.04149634f, 0.15692973f, 
    -0.14707805f, -0.03645119f, -0.03893000f, -0.01061445f, -0.01829494f, 0.05591349f, -0.57666051f, -0.79402083f, 
    -0.03645506f, -0.01080413f, 0.18534806f, -0.03798932f, 0.10861486f, 0.07933482f, 0.00133518f, -0.17412953f, 
    -0.02311973f, 0.39341432f, 0.09068289f, -0.06310675f, -0.03358751f, 0.08946198f, 0.03952523f, 0.18984750f, 
    0.01414141f, 0.19205217f, -0.12618984f, -0.13053711f, -0.07333481f, -0.07554292f, -0.04452338f, -0.07501328f, 
    -0.02257993f, 0.20577063f, 0.15558371f, 0.23630808f, -0.00678824f, 0.06490473f, 0.23848444f, -0.12755780f, 
    -0.06077876f, 0.05397245f, 0.12811172f, 0.07571136f, -0.23904496f, -0.05288366f, -0.09883186f, -0.03465657f, 
    0.09114122f, -0.05173420f, -0.01236479f, -0.02192190f, 0.08667037f, 0.29044142f, -0.16654548f, -0.18758820f, 
    -0.08333785f, 0.08217315f, -0.01155065f, 0.06397354f, -0.00493460f, 0.02368076f, 0.07442687f, -0.08380843f, 
    0.05802605f, 0.04988312f, 0.06221662f, 0.07036706f, 0.13106751f, -0.32870394f, -0.29628223f, 0.09579540f, 
    0.03837170f, 0.00055211f, -0.04245505f, 0.11816347f, 0.09989059f, -0.06451566f, 0.11296998f, -0.04165517f, 
    -0.35597610f, 0.09922937f, 0.01191916f, -0.02228434f, 0.04864366f, 0.02114213f, -0.04223933f, -0.17907751f, 
    -0.31845117f, -0.20441332f, 0.00194185f, -0.03752297f, 0.05074485f, 0.17796759f, 0.01129721f, -0.04209663f, 
    0.00563524f, 0.09243328f, 0.16327584f, -0.18784788f, -0.06851494f, -0.10889566f, 0.05471629f, -0.02194428f, 
    0.05344945f, 0.02700225f, 0.17905222f, 0.01133573f, -0.03533002f, -0.04666623f, -0.00952584f, 0.02538941f, 
    -0.21227579f, 0.22007698f, 0.48654056f, 0.18496403f, -0.30503833f, 0.18210581f, 0.00410844f, -0.00872979f, 
    -0.07474754f, 0.06374417f, 0.00642454f, -0.07308306f, 0.01793173f, 0.10892851f, -0.08019951f, 0.02012130f, 
    -0.10291728f, 0.00258309f, -0.04882535f, -0.09639391f, 0.08512624f, 0.14159186f, 0.07297385f, -0.18006860f, 
    -0.03606231f, -0.09029427f, 0.09251585f, -0.08143982f, -0.01170760f, -0.17635639f, -0.38759488f, -0.02565835f, 
    0.08862970f, 0.02167816f, 0.01132953f, 0.01543479f, -0.09541557f, -0.05041291f, 0.08335286f, -0.15089798f, 
    -0.39647263f, 0.07564019f, 0.12432352f, -0.07438137f, -0.02238681f, -0.04812767f, -0.05820204f, 0.05724348f, 
    -0.06282239f, -0.06770834f, -0.17618021f, 0.10678017f, 0.17888664f, -0.03546317f, 0.00098132f, -0.02459590f, 
    0.16680655f, 0.02940410f, 0.05550765f, 0.05788858f, 0.03484817f, 0.04466105f, 0.10010795f, 0.05790312f, 
    0.09099638f, 0.01327533f, 0.05328919f, -0.03751481f, 0.10182065f, 0.09331185f, 0.08605924f, 0.00438353f, 
    0.01822987f, -0.00137312f, 0.02609338f, 0.15780815f, -0.21283008f, 0.03259389f, 0.20681892f, -0.12143085f, 
    -0.09790710f, 0.16889991f, 0.16941838f, -0.41631871f, -0.12408735f, 0.11215191f, -0.18583225f, -0.09429095f, 
    0.04939820f, -0.15977591f, -0.22180110f, -0.23142175f, -0.35739598f, 0.13541594f, 0.35856351f, -0.03085717f, 
    -0.15461087f, -0.12238737f, -0.14857292f, 0.17851183f, 0.15890454f, -0.11817844f, 0.47046286f, -0.20312983f, 
    -0.14844142f, 0.40314797f, 0.17474157f, -0.03157816f, -0.02412269f, 0.05062333f, -0.06946775f, 0.00295055f, 
    0.19664918f, -0.12745826f, -0.02724519f, -0.04234982f, 0.03235350f, -0.01858838f, 0.16332169f, 0.30172944f, 
    0.11732802f, -0.00407022f, -0.14776863f, -0.03933712f, -0.00642918f, -0.06196651f, -0.06842647f, -0.07396817f, 
    -0.16770005f, 0.01493637f, 0.02518666f, 0.03891258f, 0.07443199f, -0.05805641f, -0.03482795f, 0.08761205f, 
    0.17209022f, -0.12231177f, 0.24881518f, -0.09489372f, 0.02373678f, 0.09571435f, 0.32171509f, 0.11494185f, 
    0.08909836f, 0.07468287f, -0.37014058f, 0.16624030f, -0.20524819f, 0.06334552f, -0.09699932f, 0.22092861f, 
    0.06378352f, -0.06717286f, -0.02130490f, -0.00323876f, -0.30125183f, 0.03307777f, 0.13026616f, 0.11154804f, 
    0.10758347f, 0.06648625f, 0.13687536f, 0.13160403f, 0.17888065f, 0.03258410f, 0.01451488f, 0.06086328f, 
    0.10309466f, 0.10207797f, 0.09656172f, 0.21121120f, 0.04631978f, 0.26460695f, 0.13117516f, 0.03742469f, 
    0.10369811f, 0.13973823f, 0.06136758f, -0.10968867f, 0.20071916f, -0.00460168f, -0.07313593f, -0.07436637f, 
    -0.30836910f, -0.05650355f, -0.13582543f, -0.15586725f, -0.10191992f, 0.00350109f, -0.11842255f, 0.17141417f, 
    -0.29437751f, 0.23796536f, 0.07284900f, -0.06202225f, 0.10847563f, 0.02442889f, -0.16468817f, -0.04987790f, 
    0.02304017f, -0.05974291f, 0.02350058f, 0.10670909f, 0.08771468f, -0.06150273f, 0.17313044f, 0.23846194f, 
    -0.10595715f, -0.20574160f, 0.16413429f, 0.11892211f, 0.01154602f, 0.20563045f, -0.05774491f, 0.08078346f, 
    0.20338199f, 0.07171152f, -0.16466045f, -0.03988195f, 0.13368985f, 0.06382448f, 0.00158616f, -0.02423326f, 
    0.07208434f, 0.03451628f, -0.13229211f, 0.20715986f, -0.24417494f, 0.24020813f, 0.06807724f, 0.07293680f, 
    0.13298085f, 0.09486043f, 0.17003445f, -0.12648869f, 0.01694859f, -0.07846369f, -0.08365388f, 0.04747212f, 
    0.01877439f, -0.12265022f, -0.16526243f, -0.39928579f, -0.63304442f, -0.29994777f, -0.12698522f, -0.21252809f, 
    -0.04217016f, -0.14446908f, -0.10791086f, -0.00972375f, 0.02097284f, -0.09180957f, -0.27193683f, 0.09423742f, 
    0.23139104f, -0.12104964f, -0.00125573f, -0.00760983f, 0.00379226f, 0.01095912f, -0.08433487f, -0.10927036f, 
    -0.19127052f, -0.30282867f, 0.02982403f, -0.09470925f, -0.31991258f, -0.06820680f, 0.06711791f, 0.14781697f, 
    0.01048202f, -0.00047182f, 0.12943122f, 0.13542849f, -0.02176279f, -0.12755273f, 0.07558734f, 0.12392725f, 
    -0.21659946f, 0.06524572f, -0.10928059f, 0.07874952f, -0.04988588f, -0.13819738f, -0.05762309f, 0.15392597f, 
    0.13692337f, -0.09253209f, -0.39059702f, 0.06657935f, -0.24016646f, 0.07930501f, 0.09756874f, -0.07576744f, 
    0.02084921f, 0.06407785f, 0.04739375f, 0.05420506f, 0.00728470f, 0.10253379f, 0.08076575f, 0.05588310f, 
    0.21606652f, -0.02043684f, 0.11182783f, 0.08595382f, 0.15349229f, -0.00863242f, 0.07875303f, 0.02217043f, 
    -0.01131881f, -0.00022231f, -0.00715009f, -0.03071859f, -0.14390765f, -0.27681458f, -0.08261053f, 0.05356736f, 
    0.11569524f, 0.11758848f, -0.15541199f, -0.05193382f, -0.14882641f, -0.17842616f, -0.15410201f, 0.38055596f, 
    -0.07680377f, -0.13460331f, 0.03333801f, -0.34935230f, 0.11943411f, 0.04831228f, -0.18661030f, -0.16656123f, 
    -0.03319938f, -0.04593170f, 0.05178069f, -0.00714299f, 0.12194927f, 0.01056038f, -0.03772768f, -0.04360251f, 
    0.12759702f, 0.03925297f, 0.10055627f, 0.06678004f, 0.12962981f, 0.05797967f, -0.01861051f, 0.12573178f, 
    -0.11496063f, -0.00961225f, -0.09606871f, 0.13330539f, 0.15281257f, 0.12330207f, -0.02627533f, 0.12784877f, 
    -0.05473385f, 0.03333657f, -0.23213512f, 0.03643436f, 0.09846340f, -0.10443553f, 0.03611522f, -0.00295674f, 
    -0.06070592f, -0.17521070f, 0.08152794f, -0.24520184f, 0.01024557f, -0.08343496f, -0.03072380f, -0.20331161f, 
    -0.03646292f, 0.10411160f, 0.12958960f, -0.02533125f, -0.57864261f, 0.18394224f, 0.26630074f, -0.21731558f, 
    -0.15646031f, -0.00957123f, -0.01262925f, -0.22606280f, -0.22602215f, 0.05817159f, 0.09751482f, 0.01633371f, 
    -0.00799097f, -0.06684428f, -0.22482201f, 0.23741990f, 0.07948970f, -0.04388548f, 0.05475202f, -0.00738806f, 
    0.06477558f, -0.01730889f, -0.09270955f, 0.26355350f, -0.01248468f, -0.12489538f, 0.02071345f, -0.11628620f, 
    -0.06174903f, 0.24021840f, 0.04804554f, -0.07572492f, -0.12895121f, 0.14620216f, 0.12897368f, 0.01791292f, 
    -0.25774646f, 0.00959716f, 0.14944732f, -0.10327364f, 0.02979336f, 0.03156799f, 0.01092810f, 0.09646818f, 
    -0.00061469f, 0.18950666f, -0.23212466f, 0.05145257f, 0.19203740f, 0.13282171f, 0.16101709f, 0.15627493f, 
    -0.13606030f, -0.08543381f, 0.25214955f, -0.40852371f, -0.08832849f, 0.23769553f, -0.06502067f, 0.00107216f, 
    0.08387896f, -0.05729724f, -0.05293144f, -0.04602892f, 0.02023060f, -0.01247130f, 0.01208214f, 0.14126275f, 
    0.08577224f, -0.25159386f, -0.18579935f, -0.07653331f, 0.43056959f, 0.19967741f, -0.09347155f, 0.00438853f, 
    0.14304720f, -0.05586198f, 0.01801335f, 0.06880514f, 0.00900510f, -0.02618549f, 0.02932899f, 0.11765633f, 
    0.13540150f, 0.03045244f, -0.22665949f, 0.17383498f, 0.16341116f, 0.11683483f, -0.03924927f, -0.17832397f, 
    0.19286968f, 0.07099060f, 0.09221685f, -0.13072266f, 0.08516818f, 0.08103810f, 0.03331788f, -0.04916646f, 
    -0.18198590f, 0.15505882f, 0.07227585f, 0.09669647f, -0.02823075f, 0.17659707f, 0.14657417f, 0.03911521f, 
    0.13228883f, 0.03522782f, 0.03209908f, -0.06103519f, -0.06303281f, -0.05013591f, 0.10351446f, 0.06234151f, 
    0.11496893f, 0.03750197f, 0.05354015f, 0.07784875f, -0.09666252f, -0.02813406f, -0.15135846f, -0.02480298f, 
    -0.05581424f, -0.03569795f, 0.03517759f, 0.04772157f, 0.03505073f, 0.01139207f, 0.02627984f, -0.06281082f, 
    0.13835029f, 0.02120884f, 0.04602756f, 0.16245256f, 0.04106729f, -0.00944424f, 0.01219431f, -0.15939569f, 
    0.15191449f, -0.05076984f, -0.13654293f, 0.11974923f, -0.00522887f, -0.21071097f, -0.20288295f, 0.09798852f, 
    -0.16622263f, -0.05234313f, 0.12524700f, 0.14209533f, 0.06350496f, -0.13265340f, -0.07650198f, 0.05579715f, 
    -0.01081855f, -0.07335683f, -0.06761432f, 0.05073419f, -0.02365642f, 0.05413472f, 0.01462226f, -0.04933013f, 
    -0.05622710f, 0.09154046f, 0.08436743f, 0.18528214f, 0.19381835f, 0.12535264f, 0.08282021f, -0.22936167f, 
    -0.35264465f, -0.14899614f, 0.00555204f, 0.10024466f, -0.05695257f, -0.10726696f, -0.01257966f, -0.06931654f, 
    0.02181742f, -0.11510304f, -0.16575700f, 0.09140765f, 0.04972514f, 0.06138875f, 0.21885765f, 0.17680477f, 
    -0.04995289f, -0.01809109f, 0.06112551f, 0.05898228f, 0.04554162f, -0.14547020f, 0.00176603f, -0.06999952f, 
    -0.27632767f, -0.38583744f, -0.27359039f, -0.46182573f, 0.31744650f, -0.08753674f, -0.04676801f, 0.07862186f, 
    0.17013009f, -0.07440833f, -0.03499318f, 0.12819730f, 0.11222868f, 0.20940854f, 0.13252744f, 0.07053586f, 
    -0.02661385f, -0.07002398f, 0.18148269f, -0.02322643f, 0.04328663f, 0.03136608f, 0.14210503f, 0.05270968f, 
    -0.18152279f, -0.04559505f, 0.06147787f, -0.00044364f, -0.11975668f, -0.05699576f, -0.07510830f, -0.22311601f, 
    0.04743766f, -0.16905829f, -0.08170968f, -0.02507116f, 0.00079147f, 0.10155243f, -0.22358313f, -0.18589336f, 
    -0.10355174f, 0.01669644f, -0.24881764f, -0.07548260f, 0.09215441f, 0.10264628f, 0.02483401f, 0.29380012f, 
    -0.01558858f, -0.40101957f, 0.19026542f, -0.04573198f, 0.02455229f, -0.00287782f, 0.00848986f, 0.14911069f, 
    -0.11318521f, -0.01591465f, 0.01776224f, -0.10455832f, 0.03251176f, -0.03736528f, -0.12808996f, -0.13403094f, 
    -0.21461284f, 0.21227525f, 0.15650243f, 0.10296338f, 0.00130403f, 0.12994803f, 0.15215252f, 0.12440028f, 
    -0.05661349f, 0.18449731f, -0.01644501f, 0.25066650f, 0.25221691f, -0.11076780f, -0.19132827f, -0.12278865f, 
    -0.09817743f, -0.07142727f, -0.11153627f, -0.04513620f, 0.15741962f, 0.19451250f, 0.07906327f, -0.12158366f, 
    -0.07676740f, -0.05020346f, -0.06803431f, -0.02437472f, -0.09440664f, -0.04700185f, 0.35786271f, 0.02693633f, 
    -0.21926540f, -0.10178120f, -0.05877814f, 0.00669674f, 0.09776668f, -0.21070765f, -0.01103181f, -0.08896768f, 
    -0.05895433f, 0.16316085f, 0.03539554f, 0.03430817f, -0.07147593f, -0.18103831f, 0.06730499f, 0.20966956f, 
    0.24962157f, -0.06544258f, -0.05654208f, 0.06239054f, -0.13478349f, -0.26344514f, -0.05955121f, -0.32497627f, 
    -0.19819619f, 0.05110278f, 0.13694508f, -0.02110664f, 0.07696544f, 0.02255212f, -0.05220054f, 0.13196231f, 
    0.02981111f, 0.03842439f, 0.09004861f, -0.04574497f, 0.01662883f, 0.02575075f, 0.06109503f, 0.17116918f, 
    -0.07597539f, 0.21791518f, 0.04838581f, 0.07056732f, 0.00304081f, 0.01089203f, -0.00583817f, 0.17243122f, 
    0.13920872f, -0.20676348f, 0.07052892f, -0.09086683f, -0.01940761f, 0.18916366f, 0.11845488f, -0.39469093f, 
    -0.14478078f, -0.04762269f, -0.14998974f, -0.19203219f, -0.16707300f, -0.10677286f, -0.02962766f, 0.03119127f, 
    0.05626104f, -0.19834316f, -0.16395390f, -0.19267958f, 0.05813761f, -0.00703953f, 0.19725384f, 0.02423854f, 
    0.06460929f, 0.05581001f, -0.24934293f, 0.09721784f, 0.19911420f, -0.24292560f, -0.13861327f, 0.03700723f, 
    -0.12602460f, 0.03617264f, 0.05628879f, -0.11385659f, -0.01582018f, 0.10101137f, 0.08304591f, 0.03758154f, 
    0.35422826f, -0.10756094f, 0.13628092f, 0.08325603f, 0.02754742f, 0.08872626f, -0.02671340f, 0.24021676f, 
    -0.00557930f, -0.02823107f, 0.00580870f, 0.19413833f, 0.15434630f, 0.27502641f, -0.21305479f, 0.21799570f, 
    -0.02417046f, 0.01187688f, -0.09243999f, 0.02860796f, -0.03485480f, -0.10207619f, 0.04277374f, 0.08111759f, 
    0.04561130f, -0.27112073f, 0.11475471f, 0.04817610f, 0.01667505f, 0.20486152f, -0.07003135f, -0.03695230f, 
    0.03805144f, -0.11901791f, 0.01434494f, 0.18922180f, 0.08972349f, 0.09944318f, -0.07076004f, -0.03389253f, 
    0.00397593f, -0.04521826f, 0.04093125f, 0.05163077f, -0.09706257f, 0.01784568f, -0.09195542f, 0.14572729f, 
    0.11062709f, -0.03145985f, -0.02588777f, 0.06904370f, 0.04816176f, -0.11624343f, 0.03417234f, 0.16059564f, 
    -0.00423222f, 0.03480714f, 0.08002175f, -0.01847540f, 0.00821801f, 0.19816726f, 0.08365642f, 0.47207493f, 
    0.03370395f, 0.01713537f, 0.14421093f, 0.12109176f, 0.13626119f, -0.05733407f, 0.05496766f, 0.11980945f, 
    0.07140309f, -0.09136013f, 0.04477927f, 0.01183654f, -0.02013730f, 0.05801182f, 0.05833206f, -0.10160442f, 
    -0.00062475f, -0.22420125f, -0.07456245f, -0.00206920f, 0.03902495f, -0.15016587f, -0.05777841f, -0.13172573f, 
    0.05955526f, -0.18133327f, 0.07269873f, 0.15908411f, -0.09008759f, -0.14293344f, 0.05985515f, 0.15434520f, 
    -0.01927960f, 0.00202509f, -0.05970335f, 0.09223633f, 0.05311639f, -0.19852629f, -0.04284887f, 0.18978864f, 
    -0.25007719f, -0.04898153f, 0.19968663f, -0.34818047f, 0.21963273f, 0.16593209f, -0.02789557f, 0.13373551f, 
    -0.11556173f, 0.14158224f, 0.26330715f, -0.28824961f, -0.09328198f, 0.09047945f, 0.03002778f, 0.00893655f, 
    -0.00978931f, -0.07505684f, -0.09397610f, -0.05051713f, -0.04926892f, -0.09331553f, 0.00024961f, 0.04787031f, 
    -0.01491543f, 0.09691890f, 0.09391844f, -0.19331592f, -0.10949466f, 0.23886199f, 0.10513620f, 0.39557791f, 
    -0.00378027f, 0.09066572f, 0.09305342f, 0.03437586f, 0.03014095f, -0.08463079f, -0.08317128f, 0.43882453f, 
    0.35964540f, -0.20611858f, 0.13343552f, -0.09761015f, 0.01108939f, -0.07013465f, -0.16859743f, -0.05631311f, 
    -0.05056058f, 0.21381147f, 0.23732099f, -0.13554557f, 0.06924987f, -0.06496154f, 0.19090289f, 0.12534104f, 
    0.06448864f, 0.12356792f, -0.00298264f, -0.10308391f, 0.14727753f, 0.04546037f, 0.14101422f, 0.03190333f, 
    -0.08495498f, -0.13045347f, 0.01305545f, 0.01119629f, -0.10073911f, 0.10117576f, 0.05103911f, 0.00735644f, 
    0.07671583f, -0.13177308f, 0.08194996f, 0.11200874f, 0.02330862f, -0.04203578f, -0.03499317f, 0.04404684f, 
    -0.02085750f, 0.30779481f, 0.26431999f, -0.01650298f, 0.06754472f, 0.02125334f, 0.08595580f, 0.05275803f, 
    -0.13401103f, 0.09238923f, -0.09079002f, -0.05991006f, 0.24480894f, -0.06254948f, -0.08690008f, -0.05072978f, 
    0.00050341f, 0.21073620f, 0.04749474f, 0.14690217f, 0.18808086f, 0.04434010f, 0.24948768f, 0.04042006f, 
    0.16360547f, -0.12546352f, 0.07743076f, 0.10823870f, 0.10731646f, -0.28541982f, 0.02474909f, 0.36059070f, 
    -0.01027443f, 0.02951399f, 0.10548493f, 0.02704255f, -0.02867790f, -0.14606567f, -0.04274234f, 0.16115165f, 
    0.22693013f, -0.12162603f, 0.06962983f, 0.04164144f, 0.01206844f, -0.00059914f, -0.00069163f, -0.19270045f, 
    0.17766213f, -0.02835048f, -0.18047677f, -0.09676820f, -0.02221095f, -0.08249021f, -0.01713834f, -0.03287748f, 
    0.22318104f, 0.01840775f, -0.00756052f, -0.00312030f, -0.03623294f, 0.02084679f, 0.03154419f, 0.07771210f, 
    -0.04227174f, 0.05539066f, -0.16032325f, 0.10825919f, -0.13155699f, 0.08707564f, 0.00130492f, -0.09199459f, 
    -0.05828775f, -0.10542007f, -0.11430458f, -0.04354065f, 0.02004633f, 0.06602912f, 0.03718470f, 0.08676544f, 
    0.13472874f, 0.20862848f, 0.27033091f, 0.06570524f, -0.25813979f, 0.07046583f, 0.07388227f, -0.02121552f, 
    0.05606065f, 0.04068835f, 0.01504356f, 0.07688292f, 0.00235837f, 0.02032288f, 0.10281885f, -0.17692906f, 
    -0.03821042f, 0.01341216f, 0.20312209f, -0.06029755f, 0.06545090f, -0.19877118f, 0.20107523f, 0.12665361f, 
    -0.15222856f, 0.24983203f, 0.01471684f, 0.02416945f, -0.14109813f, 0.04463611f, -0.30841938f, -0.18555927f, 
    0.06317218f, 0.04626517f, -0.02636312f, 0.05390370f, -0.04981900f, -0.20821796f, -0.07037343f, -0.13735086f, 
    0.00534198f, -0.02309200f, -0.05476788f, 0.02594783f, 0.15409394f, 0.01562575f, 0.02255519f, -0.08047753f, 
    -0.12094023f, 0.27510655f, 0.11543030f, 0.14474423f, -0.04987285f, 0.19444996f, 0.03441350f, 0.03537995f, 
    -0.17635529f, 0.07307635f, 0.04468612f, 0.15649119f, -0.02811534f, -0.01553235f, 0.05790767f, 0.04849330f, 
    -0.02391027f, -0.39056256f, -0.22108622f, -0.02657932f, 0.20711260f, -0.09489718f, -0.11113507f, 0.14415681f, 
    0.12239861f, 0.02863673f, 0.07694592f, 0.15150921f, -0.01510746f, 0.11209003f, 0.02571882f, 0.18456443f, 
    0.00277787f, -0.24011651f, -0.11389610f, -0.27180448f, -0.42429569f, -0.06377638f, -0.02706861f, 0.08899606f, 
    -0.01031240f, 0.12596676f, 0.07184079f, 0.03721568f, -0.06515694f, -0.03607119f, 0.14915200f, 0.07356443f, 
    0.06699952f, -0.02950156f, 0.06072091f, -0.01171720f, -0.01785719f, -0.40474522f, -0.29289567f, 0.06049335f, 
    0.05982943f, 0.09117638f, -0.03114520f, -0.12578061f, 0.03911687f, -0.01616840f, 0.09933444f, 0.10666157f, 
    -0.02697245f, -0.00767416f, -0.03521568f, 0.10502371f, -0.06445404f, 0.04073346f, -0.15896450f, -0.11489540f, 
    -0.10707118f, -0.13670225f, 0.08905409f, 0.02134217f, -0.03684146f, 0.05273228f, 0.12434687f, 0.15969305f, 
    0.25673917f, 0.01683620f, 0.18422662f, 0.20728299f, -0.02659756f, -0.10344209f, 0.08752095f, 0.13678931f, 
    0.24323004f, -0.03952132f, 0.07883216f, 0.07744912f, 0.23716328f, -0.08295063f, 0.03804440f, -0.00082136f, 
    -0.07811526f, 0.07884815f, -0.04216939f, -0.03723222f, -0.03288257f, 0.02379265f, -0.06755864f, 0.02114351f, 
    0.10662525f, 0.11477828f, 0.05713607f, 0.02280640f, -0.06288166f, 0.04143340f, 0.05792262f, -0.13824739f, 
    0.12132290f, 0.07753598f, -0.28192279f, -0.10053644f, -0.11886235f, -0.23433554f, 0.03880149f, -0.05606784f, 
    -0.00414490f, 0.33149588f, 0.00565889f, -0.04223744f, -0.33893776f, -0.03945659f, -0.21210597f, -0.03208101f, 
    0.25964347f, 0.12102474f, 0.02618408f, 0.03858468f, -0.27885887f, -0.29142427f, -0.03955532f, -0.16291627f, 
    -0.01967094f, -0.06401028f, -0.06011665f, -0.09408101f, -0.04937725f, 0.10417119f, -0.31805453f, 0.01758130f, 
    -0.20669493f, 0.09067858f, 0.10429566f, 0.02985783f, -0.07792882f, 0.07613274f, -0.06977984f, 0.11865789f, 
    -0.05752232f, 0.05547786f, 0.06481025f, -0.08134282f, -0.32599998f, 0.06158982f, -0.04809344f, -0.02666188f, 
    0.01261822f, 0.02792865f, -0.22466108f, -0.05738005f, 0.01342153f, 0.13155226f, 0.17945717f, 0.16515353f, 
    -0.21137989f, -0.02860961f, -0.06641771f, 0.09505460f, 0.09254327f, 0.02815823f, -0.24988127f, 0.12330163f, 
    0.02038259f, 0.12952198f, -0.04069139f, -0.01263608f, 0.08544341f, -0.12908196f, -0.17484017f, 0.35884675f, 
    0.06718168f, 0.07523450f, 0.05325899f, -0.21832600f, -0.20414449f, 0.24994212f, 0.19608825f, -0.12560543f, 
    0.07432359f, 0.03058066f, 0.09639562f, 0.07516972f, 0.04506213f, 0.06957527f, -0.04247355f, -0.29103535f, 
    0.26427642f, -0.04757528f, 0.05185677f, 0.09233216f, 0.07739604f, -0.03583923f, -0.00822091f, 0.02469919f, 
    -0.00660533f, 0.08735650f, -0.03264352f, 0.02423182f, -0.06336895f, 0.06203299f, -0.03386351f, -0.21766546f, 
    -0.04181806f, -0.09873380f, -0.03180908f, 0.01287453f, -0.02654053f, 0.00795307f, 0.00134391f, 0.00042985f, 
    0.00596330f, -0.08762939f, 0.16199675f, 0.41324472f, 0.32011861f, 0.08866633f, 0.11570604f, -0.00462216f, 
    -0.09175908f, 0.21358916f, -0.18830943f, -0.07447309f, -0.00513606f, -0.06087726f, 0.00669092f, -0.07973078f, 
    0.07083637f, -0.18351464f, 0.15714233f, -0.28483886f, -0.21297117f, -0.08422150f, 0.26179168f, 0.23255615f, 
    -0.03378723f, 0.02143194f, -0.09512966f, 0.12155209f, 0.07126044f, -0.22183204f, 0.09293527f, 0.04922477f, 
    0.07112791f, 0.07711285f, -0.02042711f, -0.05598262f, 0.06595786f, -0.19016987f, 0.11800233f, 0.31834489f, 
    -0.24039772f, 0.09566891f, -0.00753658f, 0.08547644f, -0.01288215f, 0.00049887f, -0.06439357f, 0.23048979f, 
    0.06220147f, 0.13586982f, -0.07201293f, 0.02589334f, -0.24037705f, 0.19738208f, 0.12370688f, 0.13762973f, 
    -0.07900266f, 0.06172008f, 0.05112919f, -0.02585533f, -0.07765113f, 0.03106081f, 0.03975564f, 0.05004508f, 
    -0.01803873f, 0.09345919f, -0.10784065f, 0.05877145f, -0.03708823f, -0.12988748f, 0.04998440f, 0.00772028f, 
    0.10574609f, -0.50353169f, 0.01197076f, -0.06542900f, 0.00103972f, 0.08550642f, 0.04946420f, -0.03900464f, 
    0.01034202f, -0.06928828f, 0.15742823f, -0.03955898f, -0.07547703f, 0.00431377f, -0.07380609f, 0.09998428f, 
    -0.12718625f, 0.00059741f, 0.00452722f, 0.03842101f, 0.05502658f, 0.26104107f, 0.00859750f, -0.09056316f, 
    -0.17190564f, -0.06240726f, 0.10762151f, 0.17136684f, 0.05443595f, -0.06769406f, 0.13638060f, -0.22995944f, 
    -0.14034972f, 0.19474715f, 0.09668987f, 0.04206860f, -0.03787530f, -0.07883178f, -0.02797379f, -0.11190391f, 
    0.07948871f, 0.03097624f, 0.00715415f, -0.20762603f, 0.04086507f, -0.14211476f, 0.08056489f, -0.11662060f, 
    -0.17971191f, -0.09022082f, -0.02578146f, -0.01448470f, 0.03053781f, -0.01913151f, -0.04183123f, -0.05807853f, 
    0.06816850f, 0.09425732f, 0.01644300f, 0.03792960f, -0.02127049f, 0.00447320f, 0.01557852f, 0.14161700f, 
    0.16101131f, -0.00358500f, 0.04871543f, -0.04549300f, 0.07895108f, -0.05025289f, 0.18904525f, -0.44363555f, 
    0.10729321f, -0.24992697f, 0.28230667f, 0.40436640f, -0.02291813f, -0.05195240f, -0.08362493f, -0.09160903f, 
    0.20569408f, -0.09273326f, -0.27767807f, -0.19242300f, -0.00066789f, 0.10885500f, -0.04226973f, 0.05166230f, 
    0.11505846f, -0.07983124f, 0.10884649f, -0.00802527f, -0.10470184f, -0.05529274f, 0.01165375f, -0.01230956f, 
    0.07225439f, 0.11311398f, 0.01570778f, 0.01993462f, -0.10336246f, 0.13211519f, 0.19463654f, -0.02727904f, 
    -0.16159095f, -0.02828605f, -0.01596604f, 0.03151589f, 0.14935093f, 0.08582515f, -0.20392464f, -0.12655704f, 
    -0.11811843f, 0.02109065f, 0.01794571f, -0.14131731f, 0.04950546f, -0.12076253f, 0.22788255f, -0.10034999f, 
    0.47233984f, 0.07292794f, 0.09965599f, -0.10017371f, -0.04276617f, -0.02268361f, 0.28879774f, -0.06865815f, 
    0.00847885f, -0.11775125f, 0.01199861f, 0.00499945f, 0.00040612f, -0.01581268f, 0.00883841f, 0.01200885f, 
    -0.04421086f, -0.05796851f, 0.18733008f, 0.37399083f, -0.08293617f, -0.00153024f, 0.06657273f, 0.05655172f, 
    0.10138899f, 0.06135990f, 0.02810570f, -0.10591516f, 0.06896295f, 0.07092296f, -0.11043122f, -0.23302084f, 
    -0.14538333f, -0.01634800f, 0.09126218f, 0.26317260f, 0.21842055f, 0.26413906f, -0.06772585f, 0.03287334f, 
    -0.10290114f, 0.13924465f, 0.00486268f, 0.00821094f, -0.34763381f, -0.59862435f, 0.16180511f, -0.09427839f, 
    -0.07567294f, -0.14252645f, 0.02715284f, 0.06224993f, 0.04401319f, 0.06862221f, 0.38781625f, 0.22050469f, 
    -0.32366797f, 0.11832615f, 0.26676074f, -0.03501173f, -0.13142285f, -0.12700030f, -0.35101917f, 0.06973170f, 
    -0.19058757f, -0.00178652f, -0.18860474f, 0.00072159f, 0.00083398f, 0.02500150f, 0.24803418f, 0.07447143f, 
    0.28779945f, -0.02207635f, -0.18906775f, 0.06076176f, -0.15137465f, 0.04134768f, -0.02471135f, -0.07937809f, 
    -0.18365774f, -0.20063190f, 0.23513182f, -0.08701859f, -0.07691908f, -0.05676055f, 0.05167462f, -0.00247737f, 
    0.00381696f, -0.18078791f, 0.18318854f, 0.14530043f, -0.04346421f, -0.02880643f, 0.03423886f, 0.10263746f, 
    -0.05416483f, 0.02332744f, -0.18292782f, 0.31393814f, -0.09442758f, 0.05807783f, -0.00092876f, -0.12078888f, 
    -0.06315301f, -0.02678035f, -0.10216811f, 0.22367175f, 0.11982358f, 0.19029504f, 0.05576007f, 0.07786386f, 
    -0.16148755f, -0.01096784f, 0.00948717f, 0.07861867f, -0.20291774f, -0.19019267f, 0.04525331f, -0.13792576f, 
    -0.03293984f, 0.06387040f, -0.11126173f, -0.07282064f, 0.13936204f, 0.06292374f, -0.04341206f, -0.16424535f, 
    -0.00096811f, 0.03291327f, -0.08931495f, 0.10808061f, 0.05798317f, -0.13481045f, -0.06397831f, 0.16210490f, 
    0.27226806f, -0.01007123f, -0.03531775f, -0.23453672f, 0.02961663f, -0.11327494f, -0.00842808f, -0.09404267f, 
    0.24761909f, 0.20073840f, -0.02571373f, -0.29721615f, -0.01301436f, -0.02995435f, 0.01197629f, 0.07744072f, 
    -0.23009130f, -0.02032217f, -0.19988634f, -0.03173457f, -0.01913805f, 0.01155200f, -0.00683042f, -0.05383851f, 
    -0.03919278f, -0.41969773f, 0.10555961f, 0.12696530f, -0.17591751f, -0.18877861f, 0.16112281f, -0.03649133f, 
    -0.04488824f, -0.00823989f, 0.00414248f, 0.24857087f, 0.01504363f, -0.05288724f, -0.00268716f, 0.02272827f, 
    0.02664323f, -0.06924330f, -0.03547209f, -0.07259227f, 0.20968537f, 0.22579734f, 0.06254403f, -0.28448361f, 
    -0.26301390f, -0.05095685f, 0.28072262f, 0.06435485f, -0.10710525f, 0.11737177f, -0.10661834f, -0.09185914f, 
    0.10310096f, -0.05738724f, 0.09046414f, -0.01582565f, -0.06097579f, 0.04107105f, 0.36416739f, 0.34647045f, 
    -0.12751235f, 0.00617497f, 0.00655527f, 0.00392407f, 0.14704359f, -0.04166282f, 0.02723394f, 0.21532190f, 
    0.10360134f, 0.10423646f, 0.03701893f, -0.14186171f, 0.09260864f, -0.03671515f, -0.02327282f, 0.06458306f, 
    -0.33611998f, 0.25327343f, -0.00605214f, -0.01180859f, 0.03676366f, 0.15112203f, 0.02544915f, 0.00726860f, 
    -0.21244821f, -0.17143954f, 0.15634032f, 0.08343301f, -0.01988962f, -0.17346835f, 0.02696185f, -0.07371315f, 
    0.06846922f, -0.42975646f, -0.03615335f, -0.30715373f, 0.06377818f, -0.03432415f, 0.05990477f, -0.04162603f, 
    0.00055191f, 0.15813394f, 0.09566624f, -0.23270783f, -0.30824712f, -0.16014583f, -0.06613057f, -0.27214336f, 
    0.09417251f, -0.03305205f, 0.08368159f, 0.12583885f, 0.17685488f, 0.36052647f, -0.01114038f, -0.00147127f, 
    -0.00296152f, -0.00486957f, 0.06204794f, -0.00594010f, -0.07662329f, 0.19993249f, -0.15371162f, 0.09438276f, 
    -0.00376912f, -0.05194818f, 0.04771186f, 0.13546446f, 0.14309937f, -0.11499111f, 0.19874416f, 0.50736344f, 
    -0.00293471f, 0.07098451f, -0.37459624f, -0.01246129f, -0.03240263f, -0.09273788f, -0.15843616f, 0.15423387f, 
    0.08945489f, 0.02216158f, -0.14581853f, 0.03322339f, -0.00170260f, -0.02735264f, -0.04643271f, -0.17423892f, 
    0.06201830f, 0.06577339f, 0.07410327f, 0.39046130f, 0.00752456f, 0.04109682f, -0.19381726f, -0.02783196f, 
    -0.03779033f, 0.01602818f, 0.04438404f, -0.06118598f, -0.01862976f, -0.09870034f, 0.02116460f, 0.10908420f, 
    0.15959302f, -0.07272231f, 0.09375118f, -0.06659339f, -0.08695165f, -0.07339258f, -0.15212253f, -0.02304216f, 
    -0.14647980f, -0.17107630f, -0.05294604f, -0.02141387f, 0.02000373f, -0.19510967f, -0.12045341f, -0.16856989f, 
    0.05180632f, 0.00627955f, 0.04564214f, 0.27988788f, 0.01667040f, -0.04608199f, 0.04844232f, 0.04303635f, 
    -0.06793986f, 0.10123489f, 0.03261107f, 0.07654880f, 0.29787359f, 0.06024695f, 0.01977144f, -0.11116880f, 
    -0.03130883f, -0.26816949f, 0.08915998f, 0.01879339f, -0.10690150f, -0.42905161f, 0.15117644f, -0.26825652f, 
    -0.01166801f, 0.03724723f, 0.18466380f, 0.09070738f, -0.24572842f, -0.07331606f, 0.06489044f, 0.18617028f, 
    0.12631300f, -0.26271251f, -0.45024452f, -0.35441869f, 0.08887837f, -0.06832621f, -0.01082548f, -0.36686626f, 
    -0.05000619f, 0.05600284f, 0.18534154f, 0.08427757f, 0.04257037f, -0.00954454f, -0.02619121f, 0.03098208f, 
    0.13638104f, -0.10887504f, -0.09197871f, -0.02059593f, -0.04589624f, -0.14843594f, 0.03023625f, -0.04745370f, 
    0.09641569f, -0.11540024f, 0.09603494f, -0.17233782f, -0.10552265f, -0.05248508f, -0.04523355f, -0.02143920f, 
    0.01782676f, -0.12170887f, -0.17482165f, 0.11620508f, 0.18725890f, -0.10388327f, 0.27705005f, -0.34336632f, 
    0.06251979f, 0.02434864f, 0.04611198f, -0.00690983f, 0.05325431f, 0.03509217f, -0.02398008f, -0.07167707f, 
    -0.15989012f, 0.03687317f, -0.10203183f, -0.13329196f, -0.06249760f, -0.19084784f, 0.27020633f, -0.01564892f, 
    -0.37064627f, 0.05501631f, 0.15412839f, 0.03948830f, -0.01327693f, 0.05225221f, -0.10032740f, 0.10874331f, 
    0.10587752f, 0.11017287f, -0.01736690f, 0.17943616f, -0.09558217f, -0.10196649f, -0.05196791f, -0.06615561f, 
    0.28140298f, -0.09112584f, 0.01463464f, -0.15269387f, -0.00465468f, -0.07000778f, 0.20329867f, -0.06816810f, 
    0.01525674f, 0.23493904f, 0.03713185f, 0.02564357f, -0.16882798f, 0.06267734f, 0.06682346f, -0.27607757f, 
    0.03059872f, 0.13273333f, 0.03790640f, -0.10292118f, -0.10256319f, -0.14243531f, 0.00192113f, -0.02003140f, 
    -0.07938812f, -0.14684039f, 0.10513892f, 0.27228808f, -0.21703988f, -0.22615847f, -0.14133929f, 0.02062822f, 
    0.15413310f, 0.00795169f, 0.20600626f, 0.20592715f, 0.07396000f, -0.06991325f, -0.05239894f, -0.27297047f, 
    0.05917476f, -0.09585468f, 0.00864062f, 0.22137822f, 0.28566098f, 0.20440409f, -0.15648937f, -0.12477740f, 
    -0.09314464f, 0.18386309f, -0.09185043f, -0.12220259f, 0.30600810f, 0.05239373f, -0.04790298f, 0.04239812f, 
    0.31774747f, 0.10857943f, 0.04861462f, 0.03256599f, 0.03918898f, 0.13287656f, 0.20718171f, 0.25250497f, 
    -0.14311369f, -0.03747996f, -0.05253195f, 0.00998057f, -0.06344313f, 0.06567387f, 0.22126444f, 0.10960472f, 
    -0.01260831f, -0.01647596f, 0.08834615f, -0.09577644f, 0.08040980f, 0.01593880f, -0.05722139f, 0.23082994f, 
    0.27219081f, -0.22061829f, 0.12669227f, -0.07357983f, 0.06063613f, -0.09341443f, -0.04474427f, 0.10319464f, 
    0.15355459f, -0.01990962f, 0.22836317f, -0.11115664f, 0.07273526f, 0.06216218f, 0.15768348f, 0.01352982f, 
    0.04857060f, 0.03283369f, 0.15799116f, 0.08216611f, 0.02672886f, -0.10514457f, -0.15796840f, 0.08821625f, 
    -0.00677254f, 0.18384016f, 0.26631021f, 0.14020634f, -0.09249072f, -0.10634855f, -0.09590442f, 0.07339989f, 
    0.18610424f, 0.07983691f, -0.10335889f, 0.04064678f, -0.17668135f, 0.05719879f, 0.13602079f, 0.00373507f, 
    -0.10976122f, -0.03324601f, -0.24669923f, -0.08354174f, 0.09617886f, 0.10274182f, 0.08516973f, 0.16131449f, 
    0.13202304f, -0.03502087f, 0.06390993f, 0.12897964f, 0.06040037f, 0.39836693f, 0.35580015f, 0.27337149f, 
    -0.07105000f, -0.00915511f, -0.01715764f, 0.02518803f, -0.11013668f, -0.09902765f, 0.28164008f, 0.10338941f, 
    0.02161083f, -0.08148209f, 0.05000881f, -0.11748720f, 0.11074562f, 0.00106813f, -0.03694110f, 0.07584613f, 
    -0.03146706f, -0.01321236f, 0.04486158f, 0.18284279f, -0.00141142f, -0.01072961f, 0.01389293f, -0.06002262f, 
    -0.02638072f, -0.02029860f, -0.03551006f, -0.03602354f, -0.06414095f, -0.04920423f, -0.02891677f, 0.01631506f, 
    0.00066463f, -0.05814892f, 0.00181705f, -0.03325564f, -0.00081112f, -0.05356400f, 0.02626435f, -0.03209994f, 
    -0.04276712f, -0.03967550f, -0.03519183f, -0.02595523f, -0.02045911f, -0.04994220f, 0.00312399f, 0.00559465f, 
    -0.02179235f, 0.04078882f, 0.02825284f, -0.01826893f, -0.06651334f, -0.01516165f, 0.00042453f, -0.00679962f, 
    0.02131008f, -0.05395720f, 0.03854974f, -0.00221603f, 0.01068648f, 0.03332408f, -0.01103490f, -0.01028878f, 
    0.00499029f, 0.04643627f, -0.01244853f, 0.01080258f, 0.04140498f, 0.01152718f, -0.04255002f, 0.00723259f, 
    -0.04487708f, 0.02194287f, 0.01423196f, 0.03009674f, 0.01176415f, 0.02915511f, 0.05818252f, 0.00398254f, 
    0.04796461f, -0.01881929f, -0.03096799f, -0.05498248f, 0.00151568f, -0.02768559f, -0.06528771f, 0.01515739f, 
    -0.00284304f, -0.03148497f, 0.03722933f, -0.06153835f, -0.00892221f, -0.02336223f, -0.05228991f, 0.01223566f, 
    0.02768514f, -0.02702240f, -0.03283508f, 0.02857661f, 0.03011525f, -0.05037574f, -0.05829672f, -0.05345351f, 
    -0.06248504f, 0.01268737f, 0.01914972f, -0.02438897f, -0.04537392f, -0.01986118f, 0.00074470f, -0.05485860f, 
    -0.06851719f, -0.05705240f, -0.06855936f, -0.00723450f, -0.02286077f, 0.02546309f, -0.05400766f, -0.01658656f, 
    0.02887319f, -0.03948460f, 0.03070634f, -0.04348217f, -0.04375603f, -0.03623863f, -0.02483678f, 0.04694573f, 
    -0.00998527f, -0.06690963f, -0.02206633f, -0.01407398f, 0.02462949f, -0.04378038f, 0.00328553f, 0.02399480f, 
    -0.03863121f, 0.01184292f, 0.00736209f, 0.02176078f, 0.01614156f, -0.01536257f, 0.03594396f, -0.01789556f, 
    -0.00056637f, -0.05572505f, -0.03413649f, 0.02281394f, -0.04247444f, 0.02226124f, -0.03840669f, -0.04389524f, 
    -0.02280220f, -0.00082474f, -0.03217616f, 0.00078093f, -0.04526396f, -0.03151850f, 0.00250876f, -0.04868456f, 
    0.03194610f, -0.00871833f, -0.02193218f, -0.00385081f, -0.05729008f, 0.02317983f, -0.01051985f, 0.03905907f, 
    0.03441281f, -0.06014965f, -0.04971985f, 0.00065049f, 0.01032482f, -0.03537273f, -0.00682704f, 0.00390925f, 
    0.03952721f, 0.05015457f, -0.05769700f, 0.00671379f, 0.05607847f, -0.01874514f, -0.00648299f, -0.01987418f, 
    -0.06811518f, -0.06802981f, -0.01241147f, 0.03818140f, -0.05467229f, 0.01416167f, -0.02738207f, -0.04305524f, 
    -0.03876130f, -0.05770781f, 0.02014137f, 0.05108788f, 0.04804036f, -0.01310581f, -0.03951542f, 0.03247070f, 
    -0.01217029f, -0.06070644f, -0.04020253f, -0.00869674f, -0.00427840f, 0.02798794f, 0.01921541f, -0.00345630f, 
    -0.01454548f, 0.00803578f, -0.06729506f, -0.01175724f, -0.00749255f, 0.02246578f, 0.04236428f, 0.00013626f, 
    0.00920639f, 0.02571885f, 0.02858770f, -0.04708232f, 0.01136739f, -0.05330623f, -0.03698284f, -0.05573769f, 
    0.00160662f, -0.00261371f, -0.05550705f, -0.00853132f, -0.02519951f, -0.03160443f, -0.06644310f, -0.01674333f, 
    0.01736250f, 0.02520085f, 0.01358042f, -0.03427975f, -0.02124332f, -0.04425276f, -0.03871473f, 0.03076092f, 
    0.04790024f, -0.04270834f, 0.01048156f, -0.04432782f, -0.04860361f, -0.05238465f, -0.02405143f, -0.04536562f, 
    -0.06226432f, 0.01863191f, -0.00004304f, -0.01590424f, 0.01162936f, -0.03153434f, -0.03171874f, -0.04544147f, 
    0.04615770f, 0.05509917f, -0.03751565f, -0.06740935f, 0.00831935f, -0.04075759f, -0.03544186f, -0.05723634f, 
    0.04176196f, 0.01270408f, -0.01746727f, 0.00791837f, -0.01744701f, 0.00810330f, 0.00041782f, 0.00769282f, 
    -0.03255029f, -0.01134223f, -0.06584954f, -0.00795456f, 0.00660553f, -0.04516360f, 0.01545998f, -0.02697864f, 
    0.05889003f, -0.02970745f, -0.05227083f, 0.00053207f, -0.02988575f, 0.01286994f, 0.00590465f, -0.05931859f, 
    -0.01345704f, 0.01565849f, -0.06568988f, -0.02274307f, 0.00592263f, -0.04102894f, 0.01261057f, -0.00258050f, 
    -0.04359514f, 0.01105035f, -0.02418116f, -0.02912528f, -0.00837109f, -0.01775531f, -0.04451304f, -0.04375079f, 
    0.00792977f, -0.01248422f, -0.02291990f, 0.01320781f, -0.01854149f, -0.00366173f, -0.04137601f, -0.00016889f, 
    -0.19697015f, 0.04766437f, 0.02532485f, -0.03500220f, -0.12433742f, 0.08909254f, 0.08545306f, -0.13342239f, 
    0.03620454f, -0.00061504f, 0.11258674f, 0.09314875f, 0.04037849f, 0.02679852f, 0.03525208f, 0.07137460f, 
    -0.15382041f, 0.12414079f, 0.34997720f, 0.00064150f, 0.04151082f, -0.01700602f, 0.01125012f, 0.00010950f, 
    0.02175896f, -0.03847885f, 0.06857263f, -0.16815655f, -0.16320287f, -0.06197046f, 0.04703800f, 0.08194473f, 
    0.01296016f, -0.04175581f, 0.01098667f, 0.03325232f, 0.45809627f, 0.16011254f, 0.15291633f, 0.08905350f, 
    -0.08781825f, -0.07361531f, 0.08448192f, 0.13355529f, -0.04815230f, -0.41077900f, -0.01550328f, -0.14096919f, 
    -0.10554369f, 0.04809514f, -0.16772303f, 0.26879850f, -0.09787071f, -0.17831291f, -0.11914462f, -0.05608289f, 
    -0.01681294f, -0.15448700f, -0.27025792f, 0.07618830f, -0.02908542f, -0.03809782f, 0.04857649f, -0.52637112f, 
    -0.04301172f, 0.13729076f, -0.16080263f, -0.03614136f, -0.01358471f, 0.11885496f, 0.19785692f, 0.16312489f, 
    0.33251414f, 0.07696532f, 0.01980099f, 0.08259683f, 0.09813851f, 0.00629868f, -0.03028708f, 0.07487487f, 
    -0.11864796f, 0.18686517f, 0.17575788f, -0.04071449f, 0.02039298f, 0.14526235f, -0.01599241f, 0.12836204f, 
    0.03457463f, -0.04483252f, -0.02678009f, -0.06667337f, 0.14255585f, -0.05386266f, 0.14688733f, -0.00632178f, 
    0.06535009f, 0.17039964f, 0.03567025f, -0.18625377f, 0.13151041f, 0.14672734f, -0.00772056f, 0.02097382f, 
    -0.00394149f, 0.21415065f, -0.05405929f, -0.13663587f, 0.15803680f, -0.19795360f, 0.11205861f, -0.17995046f, 
    0.00189539f, -0.03639140f, 0.03405981f, 0.09534101f, 0.25133204f, -0.61352617f, -0.23908296f, 0.11819306f, 
    -0.14480950f, -0.16219530f, 0.08684466f, 0.05044533f, -0.00912263f, 0.05477794f, 0.00501555f, -0.01991231f, 
    0.08242108f, -0.15194754f, 0.13414091f, -0.07583220f, -0.06851057f, 0.11285814f, 0.09256896f, -0.16558443f, 
    0.05490989f, 0.14204827f, -0.04631348f, -0.11672846f, 0.02038980f, 0.15290049f, -0.28708854f, 0.08518290f, 
    -0.20194149f, -0.00665026f, -0.06048768f, -0.27005967f, 0.00703679f, 0.03940727f, 0.12844454f, 0.11657358f, 
    0.03479664f, -0.26093608f, 0.09781013f, -0.24727543f, -0.04743638f, 0.00301490f, -0.10774687f, -0.00831064f, 
    -0.18364857f, 0.14979973f, -0.12203542f, -0.09090316f, -0.06935205f, -0.02240194f, 0.00688848f, 0.05853798f, 
    0.01386326f, 0.08545969f, 0.11048220f, -0.28501412f, -0.09908676f, -0.02026223f, -0.10353600f, -0.04848883f, 
    0.10383799f, 0.10735053f, -0.08900235f, 0.19694306f, -0.11542143f, -0.29257300f, -0.13237233f, -0.16641223f, 
    0.10705627f, 0.12968804f, -0.00357728f, 0.05536937f, 0.14371000f, 0.10148690f, 0.02709500f, 0.04243189f, 
    -0.07622340f, 0.06638322f, -0.00598818f, 0.04519043f, -0.07660424f, 0.17571801f, -0.05506365f, -0.00289890f, 
    0.01131882f, 0.09676475f, 0.09789117f, 0.04431985f, 0.08021107f, 0.04048484f, 0.07524958f, 0.13469401f, 
    0.10365472f, 0.34440249f, -0.01007812f, 0.18617827f, 0.02826579f, -0.07313929f, -0.05560826f, -0.19685215f, 
    -0.16631801f, -0.31431776f, 0.09581732f, 0.08783879f, -0.08793800f, -0.18835422f, 0.05137665f, -0.08428752f, 
    -0.09822250f, -0.23119716f, -0.07013017f, -0.10961831f, -0.03661493f, -0.02036011f, -0.12938718f, -0.19925690f, 
    -0.06189034f, -0.07098439f, 0.41868314f, 0.22188324f, -0.09117031f, -0.10286213f, 0.08034771f, 0.11929167f, 
    0.03451566f, 0.07962582f, 0.31260058f, -0.29105413f, 0.00526065f, -0.01240195f, -0.00617634f, -0.17228064f, 
    -0.05886383f, 0.09340670f, -0.01150274f, -0.01553002f, -0.30229911f, -0.02552308f, -0.02603713f, -0.07202356f, 
    -0.03512511f, 0.03987812f, 0.02360268f, -0.03949506f, -0.03887012f, 0.09896880f, 0.18269612f, 0.11896283f, 
    -0.09739152f, 0.05929668f, -0.00518178f, 0.08624376f, 0.11192171f, -0.01084383f, 0.06967629f, 0.15034810f, 
    0.03991798f, 0.12830159f, 0.19406711f, -0.03174073f, 0.16463524f, -0.03165637f, -0.05387785f, -0.35373786f, 
    -0.44764167f, 0.14490338f, -0.13256021f, 0.07926023f, 0.10010254f, 0.09006563f, 0.17872666f, 0.02810793f, 
    -0.07806093f, 0.07413228f, 0.08338328f, -0.03375091f, 0.02372019f, 0.04581681f, 0.06695777f, 0.02902820f, 
    0.04260014f, 0.14377661f, -0.11238804f, -0.08769090f, -0.08512823f, 0.09724101f, -0.04446562f, -0.00547260f, 
    0.03626953f, -0.07083191f, 0.01849539f, 0.05132511f, 0.30017841f, -0.01605851f, 0.20435514f, 0.29256946f, 
    0.01226772f, 0.19856088f, 0.26064995f, -0.16459158f, -0.02117677f, -0.05290003f, -0.00085947f, -0.02264996f, 
    0.05179299f, -0.02583850f, -0.02597514f, -0.01060057f, -0.07377683f, -0.01173898f, -0.03454980f, -0.15309584f, 
    -0.17629561f, 0.17172329f, 0.17424272f, 0.17853597f, 0.23869200f, 0.32367325f, -0.07199243f, 0.29248795f, 
    -0.23931511f, -0.18439534f, 0.13287771f, -0.07276099f, -0.01794918f, 0.03322337f, 0.27492413f, 0.06995608f, 
    0.20108409f, -0.09917684f, -0.04244885f, -0.05620826f, -0.08556187f, -0.06221869f, -0.04019725f, 0.18509695f, 
    -0.04120905f, -0.37881872f, 0.00942507f, -0.11758867f, -0.09355555f, -0.01484290f, -0.12551923f, -0.10572646f, 
    -0.18117964f, -0.07618006f, -0.08840202f, 0.11070818f, 0.14340702f, 0.10184500f, 0.01039641f, 0.10139757f, 
    0.23085684f, -0.10708106f, -0.03295299f, -0.09540217f, -0.02610314f, 0.00818091f, 0.11424163f, 0.10674673f, 
    -0.04703970f, 0.17897812f, -0.02271885f, -0.14755984f, 0.24877785f, 0.28083137f, -0.22085451f, -0.07080936f, 
    0.00562386f, -0.09281328f, -0.04463721f, 0.04401872f, -0.03675401f, 0.18703134f, 0.10448253f, 0.09265491f, 
    0.15735297f, 0.15570807f, 0.26542363f, -0.00735032f, 0.04594146f, 0.09867264f, 0.10101400f, 0.12652029f, 
    0.00138310f, 0.14811102f, -0.07648671f, -0.00569599f, 0.02963996f, 0.17123662f, -0.11921530f, -0.02607751f, 
    0.01250733f, -0.02766236f, 0.04802425f, 0.02017439f, 0.04724649f, -0.09786522f, -0.04857059f, -0.26557249f, 
    -0.11361954f, 0.23400027f, -0.09491576f, 0.20814700f, 0.03419894f, -0.08290228f, 0.01346772f, 0.26988134f, 
    -0.06115019f, 0.12670405f, -0.11146255f, 0.04868976f, -0.03582334f, -0.02421835f, 0.08288301f, -0.21641974f, 
    -0.07544623f, 0.11521279f, -0.05159007f, 0.06741355f, 0.05863500f, -0.02424940f, -0.06377308f, -0.02018194f, 
    -0.12070505f, -0.15535223f, 0.30598503f, 0.13818441f, -0.13083108f, 0.09982222f, -0.07166205f, -0.00972434f, 
    0.03890761f, 0.07367833f, -0.04631738f, 0.13274491f, -0.02639887f, 0.03221927f, -0.07356893f, -0.08663303f, 
    -0.10587019f, -0.10015997f, -0.23154488f, -0.05944670f, 0.01092146f, 0.12049288f, 0.04100299f, 0.02798448f, 
    0.01450114f, 0.03583191f, -0.16275543f, -0.06699234f, -0.06408645f, 0.03726721f, 0.02665120f, 0.12000560f, 
    0.09682389f, 0.01272955f, -0.36765915f, -0.08869699f, -0.17482828f, -0.10420721f, -0.05707922f, 0.11600440f, 
    -0.01406290f, -0.11180340f, -0.01252316f, 0.00826093f, -0.02958988f, 0.15692140f, -0.08542953f, 0.14626330f, 
    0.15014565f, 0.11510155f, -0.03285342f, -0.07866371f, -0.18430713f, -0.07587876f, -0.02639442f, -0.18064466f, 
    -0.12338429f, 0.03456005f, 0.22717698f, 0.09357611f, 0.06707525f, 0.03472878f, 0.08696393f, 0.06905162f, 
    -0.08263806f, -0.00742634f, 0.01053475f, 0.02882283f, -0.07268548f, -0.05405834f, -0.12510012f, -0.05948614f, 
    -0.18400806f, 0.03004141f, -0.02064615f, 0.03198285f, 0.00074233f, 0.04287948f, 0.03822904f, 0.07634425f, 
    0.02503746f, -0.00725315f, -0.12515394f, 0.17983097f, -0.21030779f, 0.05829947f, 0.05767571f, 0.25621912f, 
    -0.04616090f, -0.06184835f, 0.03462055f, 0.01234384f, -0.03621518f, -0.28746587f, -0.11378001f, -0.03596700f, 
    -0.04220578f, 0.10159241f, -0.06348339f, -0.01077823f, -0.00652111f, 0.04210560f, -0.04530564f, 0.10413282f, 
    0.01870319f, 0.09330722f, -0.03201885f, -0.00664946f, -0.17984167f, -0.24704403f, -0.18683513f, -0.11931300f, 
    0.12649933f, 0.04697964f, -0.16525032f, -0.07870956f, -0.08825403f, -0.05037943f, -0.13840230f, -0.00896267f, 
    0.14123307f, -0.12275529f, -0.13160400f, -0.19019394f, -0.01503178f, -0.05999500f, -0.10337610f, 0.30101380f, 
    -0.09275789f, 0.39126906f, 0.10410461f, 0.10279604f, 0.08718916f, 0.02776663f, -0.16982612f, -0.21179169f, 
    -0.03487432f, 0.04836622f, 0.05137052f, 0.04494081f, -0.05465427f, -0.05549046f, -0.01069055f, 0.03664447f, 
    0.04545685f, -0.03234432f, -0.05606200f, -0.03241822f, -0.01070337f, -0.03302964f, 0.04122106f, -0.01276032f, 
    0.05685674f, -0.04146295f, -0.05454998f, 0.01872920f, -0.05087244f, -0.00818263f, -0.02872323f, 0.00275175f, 
    -0.02832836f, -0.03962135f, -0.02109025f, 0.00545089f, -0.01467342f, -0.00492863f, -0.03724496f, 0.02334158f, 
    0.03843012f, 0.05060945f, 0.02208935f, -0.06498812f, -0.03318284f, 0.00730876f, 0.03470085f, 0.03865767f, 
    -0.00726213f, 0.01973192f, -0.04255190f, 0.00573661f, 0.05042672f, -0.04979353f, -0.00583934f, -0.05126865f, 
    0.03238605f, -0.00604980f, -0.03473369f, -0.04045532f, -0.00080142f, -0.06114610f, 0.02648694f, 0.03817426f, 
    0.01349002f, -0.00506114f, -0.00692263f, -0.03241706f, 0.04631535f, -0.01556126f, -0.03945790f, -0.04404792f, 
    -0.03912222f, -0.04311536f, 0.00406319f, -0.01285650f, 0.02251819f, 0.02476550f, -0.02150323f, -0.02056027f, 
    -0.03602209f, 0.01254645f, 0.01890676f, -0.05987974f, 0.01684142f, -0.05356210f, 0.03768791f, 0.03843572f, 
    0.00396520f, -0.04996569f, -0.03611030f, -0.05609493f, 0.02565915f, 0.03420490f, -0.02690735f, -0.03819494f, 
    0.05354826f, -0.02885515f, -0.04238565f, -0.02562312f, 0.04573939f, -0.03274845f, -0.06283312f, -0.02463244f, 
    0.04621598f, -0.02866825f, -0.06518066f, -0.03689078f, 0.01055804f, 0.04837201f, -0.04292392f, 0.03021848f, 
    0.02036493f, -0.04660986f, 0.03351791f, 0.03390489f, -0.00794641f, 0.04384822f, 0.00975966f, 0.01718510f, 
    -0.01924236f, 0.01522163f, -0.04653731f, 0.00918225f, 0.01408411f, 0.04735635f, -0.00664177f, -0.03449779f, 
    -0.04712315f, 0.02947201f, 0.01392206f, 0.02705063f, -0.05085056f, -0.03184564f, 0.00976133f, -0.00193265f, 
    0.04187527f, -0.00855945f, 0.00954346f, 0.05135593f, -0.02564283f, 0.04289885f, -0.01980062f, -0.00941993f, 
    0.02686182f, -0.04525004f, -0.05585326f, -0.04918127f, 0.01602401f, 0.00996631f, -0.06092591f, -0.02821092f, 
    -0.01101373f, 0.04076731f, -0.05268198f, -0.05942706f, -0.05340314f, 0.03166721f, -0.03782932f, -0.06091848f, 
    -0.04395686f, -0.05029611f, 0.01016161f, 0.00325828f, 0.05549511f, 0.02060202f, 0.01250581f, -0.06444344f, 
    -0.05069683f, 0.00532901f, -0.03348459f, 0.03150078f, 0.00885938f, 0.01456165f, -0.00368770f, -0.03117729f, 
    0.04513287f, 0.03934313f, 0.02416892f, -0.02845224f, -0.03160351f, -0.01693582f, 0.01750744f, -0.05409006f, 
    0.02124331f, -0.05608294f, -0.02579069f, -0.01647558f, -0.06292584f, -0.05070204f, -0.01403875f, -0.02756646f, 
    0.01021828f, 0.04560314f, -0.03220651f, -0.01611114f, 0.03248220f, 0.03386605f, -0.00264033f, -0.06062387f, 
    0.01355666f, 0.00398740f, -0.02718141f, -0.00437033f, -0.03976651f, 0.02726586f, -0.04066695f, -0.03572150f, 
    0.01680986f, 0.02174139f, 0.04410574f, 0.00164910f, -0.06328019f, 0.02180011f, 0.00034262f, -0.04116721f, 
    0.00823195f, -0.04389110f, -0.04708326f, -0.04640302f, 0.02428171f, -0.04606590f, 0.00733646f, 0.04271577f, 
    -0.05344027f, 0.05018812f, -0.01932206f, -0.04771919f, 0.00202122f, -0.04698781f, -0.00025485f, -0.03676565f, 
    0.03854374f, 0.03021056f, -0.00777583f, 0.04237822f, -0.01763359f, -0.02678932f, 0.01413665f, -0.00084814f, 
    -0.00557276f, 0.02374802f, 0.00956184f, 0.04277587f, 0.01226696f, -0.04286470f, -0.02221340f, -0.01745610f, 
    0.00954545f, -0.02255061f, 0.01976180f, -0.03321659f, 0.02451556f, -0.02007702f, 0.00216455f, 0.03309967f, 
    -0.06126091f, -0.01476953f, -0.01941618f, -0.03783770f, -0.00682694f, -0.01053612f, -0.04981165f, -0.01504348f, 
    -0.03402359f, -0.01982060f, -0.03769894f, -0.01616135f, 0.04367821f, -0.03920346f, 0.03104054f, 0.00038988f, 
    0.02449529f, -0.05308450f, -0.06016076f, 0.04679535f, 0.00687703f, 0.04197948f, 0.05061496f, 0.02992126f, 
    -0.02705838f, -0.00701294f, -0.01440577f, -0.03013102f, -0.03152920f, 0.01635143f, -0.04870726f, 0.01614132f, 
    0.03497647f, 0.02387258f, 0.01764133f, 0.00120614f, 0.02267724f, 0.01101592f, 0.05160499f, 0.03736882f, 
    0.03420016f, -0.19051753f, 0.09019926f, 0.12625103f, -0.09074549f, -0.18609044f, -0.02670078f, -0.16495845f, 
    0.01600101f, 0.01841434f, 0.01299332f, -0.01102625f, 0.11494254f, -0.07067001f, -0.07173013f, 0.04170338f, 
    0.00911001f, -0.19248533f, -0.20169906f, 0.07379140f, 0.15588410f, -0.08438221f, -0.12972784f, -0.08691449f, 
    0.13833597f, 0.01795671f, 0.02398189f, 0.45682916f, 0.03803717f, 0.14986260f, -0.25575900f, -0.11925264f, 
    0.00612430f, 0.11319295f, 0.04476348f, 0.18997331f, -0.03681349f, 0.09580186f, 0.30471301f, -0.15930694f, 
    -0.10201412f, -0.04928718f, 0.01830902f, -0.08619482f, -0.03454673f, 0.03700415f, 0.06670301f, -0.39153031f, 
    0.15287121f, 0.22254689f, -0.00509094f, -0.07676580f, -0.14931062f, -0.06327831f, -0.10741270f, 0.33617041f, 
    -0.24406515f, -0.26830336f, -0.20353609f, -0.00453674f, 0.18553114f, -0.00586702f, 0.05146857f, -0.25613907f, 
    -0.57670540f, 0.11975235f, 0.11860096f, 0.00476525f, -0.06905630f, -0.17440179f, 0.05469936f, 0.05733881f, 
    0.08656255f, 0.17083740f, 0.14533426f, -0.11600685f, -0.04797655f, -0.07273366f, 0.19191842f, 0.00754131f, 
    -0.03259796f, -0.04556328f, 0.13589999f, 0.06180781f, -0.02028450f, 0.10347839f, 0.01112108f, -0.03642504f, 
    -0.01909866f, -0.10870658f, 0.17633469f, -0.03627760f, 0.24417964f, 0.10249975f, -0.28159556f, 0.06779689f, 
    -0.07351327f, 0.12035149f, -0.06766569f, 0.05441020f, 0.00790295f, 0.00995724f, 0.04168208f, -0.14093481f, 
    -0.17183281f, 0.13132250f, -0.10753608f, 0.00054218f, -0.56431144f, -0.40805265f, -0.45690528f, -0.04056821f, 
    -0.14934742f, -0.11038953f, 0.05394348f, 0.00476534f, 0.02414697f, -0.37959662f, -0.76339108f, -0.25336847f, 
    0.18628010f, -0.08116259f, 0.11102214f, 0.13397314f, 0.16410862f, -0.02779856f, 0.20480886f, 0.01827375f, 
    0.17260666f, -0.09212674f, -0.12532274f, -0.05713943f, 0.13133746f, 0.06956604f, 0.05283943f, -0.43479297f, 
    -0.16547485f, 0.11067067f, 0.14577068f, -0.04808035f, -0.07898657f, 0.04735590f, 0.20576812f, 0.06034053f, 
    -0.37628832f, 0.03043239f, -0.42004713f, -0.09023713f, 0.06279957f, -0.03469902f, 0.02420924f, -0.00485180f, 
    0.13628031f, -0.17529185f, 0.03248060f, 0.05639230f, -0.25990349f, -0.22079040f, -0.12145913f, -0.02522466f, 
    -0.02978655f, 0.01200743f, 0.07034902f, 0.11057402f, -0.11533791f, -0.32053071f, 0.08937786f, 0.02999119f, 
    -0.03864450f, -0.01010444f, 0.05791526f, -0.28108174f, -0.00368663f, -0.28292513f, 0.09231101f, 0.02467650f, 
    0.02906647f, -0.03630369f, -0.02379043f, -0.45543045f, 0.33074185f, -0.06189449f, 0.12442899f, 0.05809765f, 
    0.06706844f, 0.05736613f, 0.03188643f, 0.10289127f, -0.11938499f, 0.20849159f, 0.20910281f, 0.23917004f, 
    -0.02671268f, 0.04200089f, -0.02814387f, -0.00629717f, 0.00730746f, -0.26137125f, 0.33030027f, 0.01814870f, 
    -0.06150402f, -0.05864718f, 0.05192162f, -0.02707498f, 0.11246557f, 0.02209627f, -0.02603131f, 0.22421519f, 
    0.22640525f, 0.06891216f, 0.05172423f, 0.08246192f, 0.05332486f, 0.15696931f, -0.04959234f, 0.09224857f, 
    0.04261293f, -0.46515945f, 0.07350860f, 0.07609718f, -0.02885817f, 0.11138204f, 0.18167244f, -0.09429476f, 
    0.25435996f, -0.27020615f, -0.03954079f, -0.32747728f, -0.25683668f, -0.09870154f, 0.01106883f, 0.01080848f, 
    -0.12412815f, -0.15179123f, -0.49366805f, -0.11060567f, 0.42970955f, -0.01670984f, -0.04730670f, -0.15667596f, 
    -0.12870423f, 0.09440018f, -0.00155325f, 0.12880300f, -0.50537497f, 0.18142025f, 0.06334928f, 0.00303102f, 
    -0.00100869f, -0.06079646f, -0.11957701f, -0.00822302f, 0.01379835f, -0.16581492f, -0.57051915f, 0.04336908f, 
    -0.08984321f, -0.11236759f, 0.14247248f, -0.01832139f, 0.09349041f, 0.34098396f, 0.33275214f, 0.34867370f, 
    -0.01378452f, -0.09567077f, -0.18314046f, -0.03284708f, 0.04073261f, -0.06686104f, 0.15643758f, 0.36136463f, 
    0.09713918f, -0.04109057f, -0.04198890f, -0.00066723f, -0.08851419f, -0.05185078f, 0.14332831f, 0.16097268f, 
    -0.34257632f, -0.61501241f, 0.03692540f, 0.02483440f, 0.06488367f, 0.01824082f, 0.24675681f, -0.05662900f, 
    0.04482572f, -0.10622335f, -0.01478481f, -0.04138734f, 0.00161417f, -0.00519497f, 0.03747656f, 0.07265653f, 
    -0.04888997f, -0.14989227f, 0.22894174f, 0.32096559f, 0.21497095f, -0.01396280f, -0.06999309f, -0.07195483f, 
    0.02452067f, 0.12495170f, -0.25583047f, 0.35342598f, 0.42956123f, 0.05345625f, 0.07769944f, -0.04204966f, 
    0.13244902f, 0.04012827f, 0.04557452f, -0.14789893f, 0.33562964f, -0.02568362f, -0.25939879f, -0.04893553f, 
    -0.06062412f, 0.00490083f, -0.01550344f, 0.02940595f, -0.56001353f, 0.45987725f, 0.39391980f, -0.14022434f, 
    -0.03652555f, 0.00380627f, 0.05525904f, -0.00256358f, -0.07671617f, -0.13609505f, -0.05286200f, -0.01993683f, 
    -0.09154991f, -0.05735196f, -0.01021486f, -0.14559293f, 0.02890000f, 0.04672511f, -0.03454516f, 0.33867821f, 
    0.05471389f, -0.07145119f, 0.13047943f, -0.04827669f, 0.22184810f, -0.02944818f, 0.06335290f, -0.35672119f, 
    -0.32444677f, -0.23305918f, -0.04974094f, -0.08441272f, -0.06507105f, -0.05149863f, 0.11336156f, -0.06896745f, 
    -0.30010024f, -0.01767271f, 0.02722468f, -0.02191105f, 0.07872937f, 0.04084801f, -0.02544170f, 0.06668837f, 
    -0.07592390f, 0.02475494f, -0.17628519f, 0.13971031f, 0.06657443f, 0.03837026f, 0.07690595f, 0.07241444f, 
    0.04022816f, 0.06908530f, -0.05051418f, -0.40300277f, 0.08611559f, -0.10056649f, 0.07985060f, 0.39508247f, 
    -0.07153610f, 0.01756599f, 0.01658989f, -0.11015800f, 0.11614604f, 0.39079499f, -0.02573968f, 0.08164584f, 
    0.07259401f, -0.08124760f, -0.05347541f, -0.07624934f, 0.66208446f, -0.06990682f, -0.16754758f, -0.01674166f, 
    0.07406385f, -0.03662167f, 0.06665732f, 0.15788478f, 0.14218614f, -0.17105117f, -0.16964695f, -0.22146693f, 
    0.04971905f, -0.08914145f, -0.04217127f, 0.01001423f, 0.15731904f, 0.04704304f, -0.49466869f, -0.06075574f, 
    0.11039989f, -0.02904876f, -0.13569044f, -0.09987411f, 0.10268976f, 0.16299342f, 0.13755974f, -0.42685705f, 
    -0.05895029f, 0.45018196f, 0.14420821f, 0.23311736f, -0.18657430f, -0.20121048f, 0.17073268f, 0.03314727f, 
    -0.04340393f, -0.19140825f, -0.19602290f, -0.14787371f, 0.04981189f, 0.00698735f, 0.16601110f, 0.24418747f, 
    0.20677097f, 0.01883369f, -0.24648200f, -0.24163942f, -0.33612978f, -0.08139574f, -0.15422852f, -0.09909112f, 
    0.01896671f, 0.12025880f, 0.00131423f, 0.05594586f, -0.06148405f, -0.04275336f, 0.11591586f, 0.15538612f, 
    0.13757943f, 0.11654516f, 0.14905202f, -0.02934338f, -0.17021467f, 0.17739819f, -0.04067006f, -0.09045265f, 
    -0.09937560f, -0.00394460f, -0.10251129f, 0.36622232f, -0.15980993f, -0.33997256f, -0.13185909f, -0.15390860f, 
    -0.01164309f, -0.01532135f, 0.03574864f, -0.07075023f, 0.06648431f, -0.31657031f, -0.05469638f, 0.19270524f, 
    -0.01977256f, -0.09845281f, -0.23563784f, 0.00003045f, 0.00353446f, 0.11723511f, 0.11919618f, 0.33468154f, 
    0.03380916f, -0.01863063f, 0.18751173f, 0.12785493f, 0.13622503f, 0.10440040f, 0.05539734f, -0.01272051f, 
    0.07941808f, -0.27077496f, -0.06579800f, -0.09829532f, -0.26682684f, -0.01311984f, 0.04539871f, -0.02057263f, 
    -0.02248579f, -0.24677841f, -0.09727552f, -0.12294332f, -0.10536915f, -0.13112651f, 0.03924337f, -0.01179181f, 
    0.12766139f, -0.18609011f, -0.12206522f, -0.09839702f, -0.10113878f, -0.00553322f, -0.12377263f, 0.02594845f, 
    0.00181824f, -0.10315147f, -0.05859806f, -0.40428373f, -0.09777835f, 0.05116956f, -0.00594442f, 0.00991124f, 
    0.07146402f, -0.16433625f, 0.02330761f, 0.17378147f, -0.02207661f, -0.14944638f, 0.03817493f, 0.04702318f, 
    0.10453292f, 0.09969088f, 0.08795103f, 0.18012862f, -0.07277889f, -0.12807576f, -0.01466244f, -0.17437942f, 
    -0.18553913f, -0.18294100f, 0.01766975f, -0.07310084f, 0.00730081f, -0.60533583f, -0.21309587f, 0.03935531f, 
    -0.01510681f, -0.01169881f, -0.18771145f, -0.06036712f, 0.09795233f, 0.09222762f, -0.09926003f, -0.24898697f, 
    0.24802186f, 0.06483475f, 0.01779612f, -0.00528970f, 0.08344102f, -0.09803960f, 0.06499528f, -0.03121517f, 
    -0.52344871f, -0.06945847f, -0.11173440f, 0.26568300f, 0.33607712f, 0.02574683f, -0.04784966f, 0.07527667f, 
    0.05018121f, -0.11930095f, 0.01464319f, 0.03601954f, 0.23319995f, 0.03301020f, 0.07690232f, -0.13502891f, 
    0.08530177f, 0.07239388f, -0.06098155f, 0.13888265f, -0.05289552f, 0.04869355f, 0.04396646f, -0.05628203f, 
    0.08562462f, -0.00305806f, -0.02783138f, 0.12264618f, -0.01061393f, -0.06598313f, 0.13253433f, 0.11296742f, 
    0.06723170f, 0.19234973f, 0.24755253f, -0.15796761f, -0.11319119f, 0.04692006f, 0.06787253f, 0.03169293f, 
    -0.03296396f, -0.15842953f, -0.11990477f, -0.06544971f, -0.25371593f, -0.01977176f, -0.12467594f, 0.26228571f, 
    0.05417539f, 0.20592421f, 0.04809514f, 0.17368147f, 0.20096530f, -0.18579097f, 0.09019301f, 0.31693998f, 
    -0.19344540f, -0.20800029f, -0.12207047f, 0.16122317f, 0.03774742f, 0.07378613f, -0.12102175f, -0.14547783f, 
    0.25425929f, 0.10102366f, 0.11134340f, 0.02576693f, -0.14999554f, 0.02206482f, 0.03211660f, 0.05502888f, 
    -0.10901868f, 0.07201730f, -0.06555131f, -0.03485452f, -0.17294775f, -0.04329396f, 0.01506858f, -0.10528871f, 
    0.07979823f, 0.21830462f, -0.02002863f, 0.04009675f, 0.00051616f, -0.11532986f, -0.04501640f, 0.04601083f, 
    0.07627830f, 0.05180128f, 0.16527390f, 0.08385020f, 0.02903576f, -0.11350205f, 0.10190652f, -0.05055670f, 
    0.04523200f, -0.00988469f, 0.39451465f, -0.01140508f, 0.25143197f, -0.01192177f, 0.07966585f, 0.05968033f, 
    0.08620352f, 0.25787252f, 0.04544044f, 0.33325708f, 0.15235512f, 0.09494070f, 0.03081605f, 0.13233480f, 
    0.11337864f, 0.03978953f, 0.06842213f, 0.25832841f, -0.11054888f, 0.19513650f, 0.08531424f, -0.10562979f, 
    0.04650844f, -0.08240709f, 0.12890455f, 0.16003190f, -0.12425712f, -0.09972139f, -0.07945204f, -0.02146867f, 
    -0.08527564f, 0.03681163f, -0.08817085f, 0.08999787f, 0.12303236f, 0.00168768f, 0.18039994f, -0.04522332f, 
    -0.02771901f, 0.14822590f, 0.05054834f, 0.15071374f, -0.02216869f, 0.13032511f, -0.14171676f, -0.13707051f, 
    -0.01015711f, 0.07711355f, -0.14807491f, 0.06200632f, -0.02060748f, 0.00501718f, -0.01783599f, 0.09597827f, 
    0.00825887f, -0.00066492f, 0.05590092f, -0.05551563f, 0.01103458f, 0.01623025f, -0.01348934f, -0.13818999f, 
    0.00201877f, 0.25924298f, 0.01290413f, -0.04036953f, 0.01322367f, 0.00174547f, -0.03073590f, 0.13850926f, 
    0.11102434f, 0.24940883f, 0.03991500f, -0.07358642f, 0.07759096f, 0.03924999f, 0.03226211f, 0.03315572f, 
    -0.12260173f, -0.23998174f, -0.16336495f, -0.08909208f, 0.08664995f, -0.03616709f, 0.06267357f, -0.04498143f, 
    0.11597670f, 0.10217390f, -0.10396741f, 0.47510153f, 0.01165993f, 0.02288638f, 0.05697136f, 0.03940447f, 
    -0.01489583f, -0.04462830f, -0.03935480f, -0.09227910f, -0.21624510f, 0.24774390f, -0.00977012f, 0.02682762f, 
    0.06766587f, 0.06293062f, 0.23001826f, -0.11000302f, -0.04776527f, 0.08115581f, -0.03207079f, -0.05402339f, 
    -0.03435037f, 0.01521225f, 0.02524673f, 0.01349138f, -0.04087040f, -0.04186696f, -0.24907087f, 0.19491915f, 
    0.25106627f, 0.18142015f, 0.06009633f, 0.01350705f, 0.15490654f, -0.16213724f, 0.09024226f, -0.03130074f, 
    -0.07350293f, -0.01865066f, -0.23990209f, 0.03790249f, -0.13539504f, 0.00323901f, -0.17209549f, 0.12168869f, 
    0.06946563f, 0.14409725f, -0.47315639f, -0.09739035f, -0.03364015f, 0.07561762f, 0.13821995f, 0.05157014f, 
    -0.03963288f, 0.19736657f, 0.29421079f, 0.47653610f, -0.09250889f, 0.02767033f, 0.00428192f, 0.03660671f, 
    0.09486908f, 0.15095066f, 0.15530786f, 0.06475900f, 0.04274421f, 0.14894368f, 0.00646610f, 0.10816364f, 
    -0.09832871f, -0.00416879f, -0.06463514f, -0.11762608f, 0.04185008f, -0.11638364f, 0.05897218f, 0.03642435f, 
    0.04303130f, 0.05908366f, 0.05661630f, -0.17232105f, 0.17916526f, 0.30449149f, 0.02918872f, -0.12023795f, 
    0.20194805f, 0.15714397f, 0.17058428f, -0.06915697f, -0.00334645f, -0.20344332f, 0.02809251f, -0.10603084f, 
    -0.01822854f, 0.09803845f, 0.08775868f, -0.17445627f, 0.21375480f, 0.16492674f, -0.07025071f, 0.23257045f, 
    0.14813016f, 0.18791959f, -0.06175541f, -0.01600760f, -0.06237462f, -0.02120671f, 0.00419560f, 0.11473269f, 
    0.00088149f, -0.01483346f, 0.02056617f, 0.03281223f, -0.06105009f, 0.03790246f, -0.01306564f, -0.04990307f, 
    0.04059951f, 0.01047068f, 0.00456648f, -0.02363358f, 0.03909291f, -0.00443673f, -0.05662720f, 0.01396286f, 
    -0.02214018f, -0.04358086f, -0.04959737f, -0.02432990f, 0.04973774f, 0.05008726f, 0.02173063f, 0.03852259f, 
    -0.00195642f, -0.06423303f, -0.05717862f, 0.00409869f, 0.01311051f, 0.03449138f, 0.02495037f, -0.01715604f, 
    -0.01710413f, 0.03992651f, 0.01251362f, -0.05061803f, -0.06459703f, -0.06003890f, 0.04319438f, -0.04267132f, 
    0.02518907f, -0.06683110f, 0.02398704f, -0.03810157f, -0.00956689f, -0.01218382f, -0.04029956f, -0.03242113f, 
    -0.06545692f, -0.01116016f, -0.01194279f, 0.00978324f, 0.02263087f, -0.00864195f, -0.03907625f, -0.02249551f, 
    -0.04438929f, 0.01731561f, -0.01233405f, 0.00192177f, -0.00144308f, -0.01081283f, -0.02739082f, 0.03634109f, 
    -0.05710968f, 0.03013457f, 0.00634655f, -0.06408732f, -0.02068361f, 0.04775370f, -0.01880293f, 0.02600349f, 
    -0.04020965f, -0.01940531f, -0.04791432f, -0.01381129f, 0.02114116f, -0.03000627f, -0.02540461f, 0.04074507f, 
    -0.05828731f, 0.00824798f, -0.01413764f, -0.05895177f, -0.04806182f, -0.05919059f, -0.05320145f, -0.04464567f, 
    0.00298935f, -0.05531666f, -0.02716955f, -0.06316313f, -0.00491970f, -0.01315218f, -0.02790740f, 0.01878849f, 
    0.03543912f, 0.02669742f, -0.04115241f, -0.00877540f, -0.01850729f, -0.01531293f, -0.04004733f, -0.01916508f, 
    -0.01331750f, 0.01760605f, -0.01106534f, 0.00867818f, -0.02096241f, 0.04697761f, -0.04135027f, -0.06331362f, 
    -0.00154659f, -0.04895444f, -0.05796932f, -0.04159410f, -0.05077539f, 0.00441659f, -0.00099612f, 0.02377308f, 
    -0.04614256f, -0.01426406f, -0.04453182f, 0.02179578f, -0.03505001f, -0.01299907f, -0.02020761f, -0.00005849f, 
    -0.06014588f, -0.04094725f, 0.03463583f, 0.00654834f, 0.03123414f, 0.04151612f, -0.03403423f, 0.02824340f, 
    -0.06826198f, -0.06639345f, -0.01226842f, 0.01929442f, 0.01467410f, 0.01284629f, 0.00835726f, 0.04188414f, 
    0.00942618f, 0.04168578f, 0.01149936f, 0.04152730f, -0.06047383f, -0.00568615f, -0.02879454f, 0.01917076f, 
    -0.00531707f, 0.03658253f, -0.00257071f, 0.01672419f, 0.04812780f, 0.00100089f, 0.03618510f, 0.03300482f, 
    0.04070771f, 0.03908198f, 0.01193019f, 0.04651622f, -0.00399737f, 0.03179792f, -0.02049688f, 0.00429210f, 
    -0.06480247f, -0.03054573f, -0.04857761f, -0.01452040f, 0.02969296f, -0.02800325f, -0.03437598f, 0.03257447f, 
    0.03630992f, -0.01276028f, -0.00672729f, 0.02812493f, -0.03507733f, -0.06522198f, 0.04730001f, -0.01009500f, 
    0.03648929f, -0.00498976f, -0.04930449f, -0.02655119f, -0.00255425f, -0.04445430f, -0.00611130f, -0.01490625f, 
    -0.03495078f, 0.03674161f, -0.00567260f, -0.04186261f, 0.01834056f, -0.05179488f, 0.02672380f, -0.06906607f, 
    -0.05387890f, -0.01482982f, -0.04589856f, 0.00070375f, -0.02155008f, -0.02622060f, 0.00758379f, -0.04376678f, 
    0.03722383f, -0.04286697f, 0.01887414f, -0.02434272f, -0.01370937f, 0.01529407f, -0.01960128f, 0.04858725f, 
    0.03124341f, 0.00709470f, -0.06400590f, -0.03664828f, 0.01697068f, 0.00578674f, -0.05998942f, 0.04706807f, 
    -0.05898196f, 0.01037584f, -0.04670570f, -0.02762770f, 0.02326410f, -0.02523696f, -0.03357393f, 0.02459692f, 
    -0.05002780f, 0.03149254f, 0.00942188f, -0.00492993f, -0.03948859f, -0.01016872f, -0.05077042f, -0.05038653f, 
    -0.05728082f, 0.01334488f, -0.04045771f, -0.05502846f, 0.04490289f, -0.04156925f, -0.05513860f, 0.04725390f, 
    -0.02241892f, 0.03453721f, -0.05536180f, 0.00428269f, 0.02163820f, 0.02862852f, -0.05799889f, 0.02368998f, 
    0.01697200f, -0.03453158f, -0.02833535f, -0.02106186f, -0.02389737f, -0.05565600f, -0.01288417f, -0.01228815f, 
    0.00770098f, 0.04587144f, -0.01613229f, 0.02870541f, -0.02704346f, -0.02513457f, 0.01183662f, 0.05507971f, 
    -0.01965208f, -0.06072387f, 0.00431504f, 0.03285699f, 0.00130437f, -0.00364338f, 0.01884270f, 0.04706205f, 
    0.00993982f, 0.00861248f, -0.04603955f, -0.00791792f, -0.03526283f, -0.07011189f, 0.02919946f, -0.05965160f, 
    0.07941498f, 0.33688384f, 0.16881904f, -0.04936642f, 0.08217436f, -0.02288684f, 0.12393634f, 0.16100132f, 
    0.04285954f, -0.19154721f, 0.13970105f, -0.11477933f, 0.04699156f, 0.10609233f, 0.06561199f, 0.10774144f, 
    0.02327926f, 0.07389424f, -0.27135718f, -0.16148633f, -0.28513420f, 0.10211652f, 0.19669694f, 0.11923714f, 
    0.05697750f, 0.16110095f, -0.03527328f, -0.21644971f, -0.21622708f, -0.24453427f, -0.01948256f, 0.08801885f, 
    -0.09546500f, -0.02430317f, -0.03255334f, -0.08330517f, -0.19147369f, -0.43243912f, -0.51164633f, 0.03373651f, 
    0.01165452f, -0.04856693f, 0.07032757f, 0.11176895f, -0.05599611f, 0.37787092f, 0.23856217f, 0.04885676f, 
    0.10792910f, -0.19378226f, -0.19168676f, -0.02520049f, -0.14846162f, 0.05367178f, -0.18424839f, -0.30145869f, 
    -0.28521460f, -0.09276908f, 0.04520797f, 0.09659372f, 0.03502703f, -0.05568723f, -0.05642601f, 0.22084641f, 
    0.15878178f, 0.01764677f, 0.08162897f, 0.00529643f, -0.16276863f, -0.10240361f, 0.02939897f, -0.10287210f, 
    0.11401664f, -0.22348122f, -0.05569527f, 0.15750191f, 0.07206824f, 0.10537795f, -0.04978152f, 0.04114801f, 
    0.05746676f, 0.27497038f, -0.05031408f, -0.02145389f, 0.13787699f, 0.09488224f, 0.14986169f, 0.02681311f, 
    0.01079466f, 0.20831759f, -0.05925889f, -0.18944839f, -0.38884300f, 0.05603314f, 0.12617363f, -0.03095242f, 
    -0.26548004f, 0.05980003f, -0.07228301f, -0.14799464f, 0.40037274f, 0.18159869f, -0.03530923f, 0.04808251f, 
    -0.04217195f, 0.00710930f, 0.14069599f, 0.14517444f, -0.34561700f, 0.23331997f, 0.12256672f, 0.01855153f, 
    0.25771418f, 0.05090171f, 0.17211165f, 0.10949586f, -0.12846251f, 0.04523051f, 0.26252431f, -0.07016374f, 
    -0.04769460f, -0.05002734f, -0.00491718f, 0.08113518f, 0.08836693f, -0.03250271f, -0.08057201f, 0.18615189f, 
    -0.00340228f, 0.07821082f, -0.02640186f, -0.08271350f, -0.05814580f, 0.07932585f, -0.03314271f, -0.34348288f, 
    0.29647028f, -0.10444390f, 0.02823600f, 0.20462230f, 0.06058901f, 0.18711008f, -0.17085151f, -0.16032217f, 
    0.17451693f, 0.08032598f, 0.06712048f, 0.02048825f, -0.00761736f, 0.02843816f, 0.15182145f, -0.15804403f, 
    0.04847639f, 0.10982877f, 0.21901037f, -0.23402603f, -0.08476809f, 0.23606855f, 0.17908773f, 0.18435495f, 
    -0.14315258f, -0.31202009f, 0.00550241f, -0.11353219f, -0.07887180f, 0.03233275f, -0.01893014f, 0.06117243f, 
    -0.02023466f, -0.02378390f, 0.05663082f, -0.09352931f, 0.37159741f, -0.07943153f, -0.01934992f, 0.11563528f, 
    0.00738456f, 0.26423085f, -0.03886998f, -0.04180465f, -0.08065976f, -0.09106904f, -0.24360470f, 0.06414333f, 
    0.10608511f, -0.03302412f, -0.02990213f, 0.03726080f, -0.14548419f, 0.00736865f, 0.02541242f, 0.20798881f, 
    0.03946998f, 0.09644224f, -0.02124394f, 0.03571582f, 0.08674081f, -0.02358981f, -0.01990269f, -0.23754506f, 
    -0.25140744f, 0.03413741f, -0.02589251f, 0.02301847f, -0.04018228f, 0.01360733f, -0.07827268f, -0.08575050f, 
    -0.26884311f, -0.15385766f, 0.01206720f, 0.15075943f, 0.09633164f, -0.04093208f, 0.04393112f, 0.03383232f, 
    -0.11678346f, 0.05546352f, -0.19614284f, 0.01354255f, 0.08900168f, 0.02692306f, 0.04679516f, -0.10882733f, 
    -0.32990482f, -0.05087944f, -0.03003667f, -0.01030454f, -0.10097741f, 0.09650765f, -0.08208399f, 0.14630769f, 
    0.14860556f, -0.16688913f, 0.35643777f, -0.19470666f, 0.00038290f, 0.22302274f, 0.35144213f, 0.10647879f, 
    -0.06025162f, 0.04349259f, 0.12771128f, 0.22191708f, 0.40738827f, 0.07883094f, -0.08818074f, 0.00296542f, 
    -0.07162365f, -0.10010545f, 0.04952043f, 0.04269252f, 0.06765854f, 0.25784108f, 0.19631289f, -0.03805374f, 
    0.08681256f, -0.08657304f, 0.15400277f, -0.00417343f, 0.10687925f, -0.19387344f, -0.42818633f, -0.22759445f, 
    -0.12797652f, -0.12566034f, -0.13067615f, -0.01650316f, -0.04054878f, -0.14315085f, -0.38315916f, -0.26427600f, 
    -0.28488943f, -0.01356918f, 0.02475210f, 0.09498873f, -0.19712390f, 0.02579016f, -0.06771895f, -0.14521830f, 
    -0.11761547f, -0.40773129f, 0.05768616f, 0.10060867f, -0.08556285f, -0.06896744f, -0.03507134f, -0.10896693f, 
    -0.14307410f, -0.12450410f, 0.23575899f, 0.03853370f, -0.07968365f, -0.01301066f, -0.06908413f, 0.06965166f, 
    0.06575634f, 0.08455276f, 0.10568339f, -0.18094473f, -0.08325431f, -0.02260725f, 0.16450332f, -0.01460269f, 
    -0.18678898f, -0.12167227f, 0.14193454f, 0.03061610f, -0.29060224f, -0.04846059f, 0.03036563f, 0.14870885f, 
    -0.08520158f, -0.04281146f, 0.02412175f, 0.06059410f, 0.20661186f, -0.15063058f, 0.14929670f, -0.07636740f, 
    0.14120786f, -0.00975646f, 0.10900756f, -0.03838255f, 0.36787760f, 0.14724004f, -0.06900528f, 0.09216425f, 
    0.02644766f, 0.13110138f, -0.02126206f, 0.04124874f, 0.15462792f, -0.20267148f, -0.43402389f, -0.31119773f, 
    -0.01928527f, -0.01090235f, 0.01831633f, -0.11993834f, -0.10504715f, -0.09588005f, -0.02388093f, -0.19834155f, 
    -0.11988492f, 0.01908761f, 0.06180559f, -0.14376923f, 0.07635841f, -0.00712042f, -0.06528530f, -0.02625479f, 
    -0.28925335f, -0.09446657f, -0.00485462f, 0.15477285f, 0.01898757f, 0.03135261f, 0.17921780f, 0.03705153f, 
    0.34884819f, 0.17843930f, 0.09289842f, 0.03807110f, 0.09583410f, 0.10016634f, -0.08968902f, -0.00686526f, 
    -0.07743819f, 0.34594652f, 0.05193814f, 0.04953494f, -0.11720544f, 0.00478508f, 0.04580822f, 0.10150310f, 
    -0.04587685f, -0.02744422f, -0.01304744f, -0.01266934f, 0.11080430f, -0.06805985f, -0.05538189f, -0.01834104f, 
    -0.15887253f, 0.03216753f, 0.14142904f, -0.13143481f, -0.09234651f, -0.12510934f, -0.07112595f, -0.12864590f, 
    0.12245392f, -0.09611621f, 0.10770033f, 0.03511833f, -0.10681455f, 0.25716776f, -0.29265776f, -0.06839699f, 
    -0.10606246f, -0.00426302f, 0.04191460f, -0.02719838f, 0.09051167f, -0.28842556f, -0.13199884f, -0.07144082f, 
    -0.05462011f, 0.01776514f, 0.03944698f, -0.08852414f, 0.06711627f, -0.02150472f, 0.14939561f, 0.02343921f, 
    -0.02998066f, -0.09952775f, 0.09276716f, -0.04771104f, 0.04038136f, -0.01556444f, 0.05270640f, 0.09413764f, 
    0.17204358f, -0.25289053f, 0.02494190f, -0.20401247f, 0.21594167f, 0.07858314f, -0.04026568f, 0.00105470f, 
    -0.01151158f, -0.12271999f, -0.02960085f, -0.03654753f, -0.22165737f, -0.21937643f, 0.10830695f, 0.10235565f, 
    0.05591796f, 0.04129127f, -0.35735908f, 0.24935338f, 0.14568426f, 0.07292229f, 0.13198689f, -0.16245879f, 
    0.03229576f, -0.11538235f, -0.05769759f, -0.06089944f, 0.01423923f, 0.01656490f, -0.15685138f, -0.15810183f, 
    0.00250386f, 0.04342676f, 0.15300678f, -0.18381242f, 0.09482709f, -0.06248107f, 0.27317119f, 0.01920721f, 
    0.00607597f, 0.02908551f, 0.09294324f, -0.22101477f, 0.16123153f, 0.06168048f, -0.04859384f, -0.18847409f, 
    -0.08681657f, 0.05544164f, 0.06517829f, 0.00654503f, 0.01567078f, 0.21521775f, 0.04707297f, 0.01849793f, 
    -0.01281188f, 0.04038930f, 0.01967228f, 0.01670975f, -0.00891989f, 0.08198635f, 0.00957026f, 0.05704640f, 
    -0.06564672f, 0.10821106f, -0.09435908f, 0.01628975f, -0.02595654f, 0.16636255f, 0.04160286f, 0.07539044f, 
    0.12951384f, 0.08828823f, 0.01066359f, 0.00277449f, -0.02581934f, -0.23682007f, 0.13507256f, -0.07366423f, 
    0.01929049f, -0.01374218f, -0.18693459f, -0.01504073f, 0.03476175f, -0.11249971f, -0.06866188f, -0.07244658f, 
    -0.01793340f, -0.01586176f, -0.04618257f, 0.19485705f, -0.02026365f, -0.05335442f, -0.22536580f, -0.00444909f, 
    -0.14688674f, -0.06275409f, 0.11624532f, 0.18831812f, 0.37394780f, -0.00164623f, -0.19390540f, 0.00892757f, 
    -0.13983467f, 0.15716301f, -0.08664535f, -0.13788541f, 0.02124336f, 0.06330877f, 0.03548852f, 0.05627946f, 
    0.01917729f, -0.13269478f, 0.09081797f, 0.06711425f, -0.05033846f, -0.07316960f, -0.03993165f, 0.18029295f, 
    -0.01508440f, -0.10540152f, 0.05356972f, -0.07561059f, 0.00736450f, 0.15133344f, 0.25030741f, 0.03690090f, 
    -0.03763526f, -0.03214123f, 0.06109698f, 0.03514707f, -0.00717939f, 0.01403770f, 0.03761488f, 0.19413732f, 
    -0.29226330f, 0.15738544f, 0.18633495f, 0.03857475f, 0.09106844f, -0.07774805f, 0.18145990f, -0.09587484f, 
    0.10922358f, -0.15843390f, -0.32322520f, -0.04698142f, 0.08123381f, 0.06609861f, 0.02905675f, 0.01675139f, 
    -0.04336218f, -0.04232665f, -0.00901426f, -0.09070787f, -0.00973691f, 0.05514675f, 0.05493458f, 0.00117120f, 
    0.16082238f, -0.10284418f, 0.07969332f, 0.08046253f, 0.05810213f, -0.00667124f, 0.01640940f, -0.00687286f, 
    0.03769061f, 0.14191879f, 0.18882050f, -0.35561329f, -0.04230504f, -0.27748543f, 0.03695129f, -0.11637008f, 
    0.12222205f, 0.01344701f, 0.08475661f, -0.00813037f, -0.27164397f, -0.01121718f, -0.01171644f, -0.15044905f, 
    -0.08660953f, -0.08269344f, 0.06232719f, 0.02091648f, 0.13796242f, -0.07423892f, -0.26811171f, -0.26267484f, 
    0.11383390f, -0.19992065f, 0.09165878f, -0.14059302f, 0.09265424f, -0.06991124f, -0.85235184f, 0.30141184f, 
    0.29524574f, -0.08801480f, -0.06302968f, 0.02544267f, -0.30628312f, 0.13558154f, 0.25376645f, -0.29441422f, 
    0.15509023f, 0.10511844f, -0.15948367f, -0.24823752f, -0.00270322f, 0.08533257f, 0.01577796f, 0.14823854f, 
    0.25741476f, -0.75353122f, 0.13515149f, 0.10096569f, 0.06321088f, 0.00042764f, 0.04355374f, 0.06296749f, 
    -0.27893189f, -0.01981689f, 0.34966111f, 0.04933075f, -0.08168934f, 0.06164307f, 0.06251846f, 0.01868405f, 
    0.13583159f, -0.45001739f, -0.04115793f, -0.23341897f, 0.17542326f, -0.12075995f, 0.12744784f, 0.04009908f, 
    0.02697730f, 0.05960735f, -0.63382035f, 0.46187493f, -0.67489123f, 0.02121796f, -0.05414841f, 0.00977633f, 
    -0.08204865f, 0.05602403f, -0.22842002f, 0.19444257f, -0.23130631f, 0.01257969f, 0.02256486f, -0.04301016f, 
    0.09788779f, -0.00638142f, 0.12734768f, -0.06437789f, 0.15575923f, -0.11486955f, 0.41341269f, -0.04699456f, 
    -0.21155110f, 0.34524080f, 0.04264183f, 0.07898548f, 0.17207016f, 0.15589288f, -0.31922805f, 0.08075411f, 
    0.01070617f, 0.03570102f, 0.01070764f, 0.03377631f, 0.06387191f, -0.06490532f, 0.37419939f, 0.09275046f, 
    -0.47324502f, -0.10813370f, 0.09008324f, 0.03568282f, -0.04299748f, 0.05973214f, 0.01817101f, -0.07020305f, 
    -0.05930886f, 0.05352217f, 0.02518058f, 0.08998588f, 0.14561984f, 0.08702812f, -0.00398342f, 0.06008299f, 
    -0.17206188f, 0.11299694f, 0.04217470f, 0.02619868f, -0.01895208f, 0.01754416f, 0.10784163f, 0.11457513f, 
    -0.00049304f, -0.48643860f, -0.02643986f, 0.18669379f, -0.06025052f, -0.23292977f, -0.09131907f, -0.10333023f, 
    0.09748021f, 0.01614610f, 0.03718346f, 0.12478601f, -0.04680901f, 0.00089838f, -0.11768679f, -0.17247353f, 
    0.08518799f, 0.05675588f, 0.02867824f, 0.01175528f, -0.07596860f, 0.15627293f, -0.06571282f, 0.10527518f, 
    -0.26062593f, -0.07326201f, 0.01189207f, 0.02921764f, -0.11910821f, 0.22640267f, -0.15481223f, 0.02870327f, 
    -0.01395874f, 0.06446308f, 0.01720740f, 0.23820283f, 0.06584846f, 0.14684467f, 0.21387911f, 0.09819926f, 
    -0.13366310f, -0.19814135f, 0.08352683f, 0.03613166f, 0.10712346f, -0.02765264f, -0.02761678f, -0.11097369f, 
    0.14010617f, 0.05171072f, -0.05712417f, -0.12338495f, -0.00567065f, 0.07587444f, 0.07177393f, -0.01062043f, 
    0.05561565f, -0.26370135f, -0.06715040f, -0.12071203f, -0.14637151f, 0.12011407f, 0.01061972f, 0.04276612f, 
    0.07106761f, 0.00840208f, -0.17049301f, 0.07788461f, -0.04515904f, -0.02056209f, 0.09381384f, 0.25709122f, 
    0.14807376f, 0.04462498f, 0.12376375f, -0.06421489f, -0.13845301f, -0.20244394f, 0.05527544f, 0.14672098f, 
    -0.13344847f, 0.16505945f, -0.90830415f, -0.13984059f, -0.27003932f, -0.06060493f, -0.12897041f, 0.02147057f, 
    0.04200359f, 0.10105742f, 0.05049653f, 0.08749777f, -0.28087491f, -0.30508181f, 0.05006317f, 0.10960396f, 
    0.08234371f, 0.05670621f, 0.01324563f, 0.09344819f, -0.23423417f, 0.01419803f, 0.01423322f, -0.08563502f, 
    0.04472833f, -0.01721489f, 0.09999914f, 0.08367311f, -0.01223820f, -0.28967968f, 0.28063527f, 0.16042435f, 
    0.04189603f, -0.09586015f, 0.04476108f, -0.09487113f, -0.01728704f, 0.08652613f, -0.51995105f, -0.16160138f, 
    0.21781303f, -0.26024330f, -0.09501817f, -0.24874932f, 0.06420467f, -0.13612886f, -0.00504054f, -0.40689933f, 
    0.56021953f, -0.09604118f, 0.09907397f, 0.00251465f, 0.28944853f, -0.01696476f, 0.18716522f, 0.01531676f, 
    0.05033603f, 0.03208758f, 0.06230505f, 0.05740182f, -0.14948902f, -0.10603122f, -0.10535462f, -0.07524046f, 
    -0.08643311f, 0.19156004f, -0.29585639f, 0.09856451f, 0.11069570f, 0.17571521f, -0.15376599f, 0.02140100f, 
    0.07965875f, -0.01766308f, 0.10441563f, 0.09697726f, -0.03156806f, -0.09194506f, -0.09847882f, 0.04524704f, 
    -0.03909003f, -0.30984691f, -0.07614439f, -0.24006376f, -0.26002702f, -0.12461500f, 0.05026991f, 0.11389343f, 
    -0.00359804f, 0.21224129f, 0.00429358f, -0.00900203f, -0.21063490f, 0.18721798f, -0.20529670f, -0.11440762f, 
    -0.26330900f, -0.12229814f, -0.02884773f, -0.20677494f, -0.13129143f, 0.12673797f, -0.22259799f, 0.28670257f, 
    -0.09126874f, 0.02122170f, 0.00578827f, 0.12984084f, 0.15014669f, 0.05525781f, -0.16961396f, -0.37336290f, 
    -0.06144196f, -0.06595050f, 0.08031862f, -0.00545323f, 0.08176599f, -0.11222698f, -0.00669112f, 0.22641554f, 
    0.19678532f, 0.23229930f, -0.05233242f, -0.03703794f, 0.10087749f, 0.01134385f, 0.05568053f, 0.14001149f, 
    0.00801212f, 0.03446199f, -0.23634867f, -0.11653685f, -0.18633220f, 0.00735806f, 0.02404679f, 0.00139827f, 
    -0.01470304f, 0.31143966f, -0.01349962f, 0.04069341f, 0.04039375f, 0.05279583f, 0.03907203f, 0.00242211f, 
    0.16119264f, -0.08067738f, 0.02108330f, 0.07021508f, 0.10246657f, 0.17441262f, -0.26341775f, 0.14183345f, 
    0.29753828f, -0.00934222f, -0.07530947f, -0.24724725f, -0.12384741f, 0.03292033f, 0.18197051f, -0.13023664f, 
    -0.08002783f, -0.02943833f, -0.10219143f, -0.11566760f, -0.04418709f, -0.20123272f, 0.19437110f, 0.03495139f, 
    0.17907733f, 0.10254230f, 0.04153887f, 0.03008043f, 0.09537870f, -0.11609937f, 0.22732039f, 0.19504781f, 
    -0.12426543f, 0.11362450f, 0.06725010f, 0.05040122f, 0.09054918f, 0.13287075f, -0.02684586f, -0.06283431f, 
    0.09977425f, -0.00819354f, -0.02501399f, 0.04688404f, 0.09911911f, 0.12809725f, 0.12196550f, 0.12501147f, 
    -0.33085909f, -0.05578168f, 0.18274066f, 0.05046767f, -0.16016513f, 0.00543302f, 0.14727162f, -0.11930114f, 
    0.20038640f, 0.17589806f, 0.12100065f, 0.07742105f, 0.14395908f, 0.08449762f, 0.00866192f, 0.10827105f, 
    0.12906456f, 0.19587162f, -0.11566878f, -0.05373421f, -0.07656266f, -0.10536883f, -0.08152314f, -0.04905059f, 
    0.00285672f, 0.03733069f, -0.02779641f, -0.02668686f, -0.12983198f, 0.11864958f, 0.06492675f, 0.05478618f, 
    0.07584918f, 0.20813422f, 0.12286708f, 0.01021725f, -0.13910593f, 0.27101195f, -0.07791975f, 0.03294957f, 
    0.01958972f, -0.30477384f, 0.15765993f, 0.02774645f, 0.02875986f, -0.08317587f, 0.04680448f, -0.07602535f, 
    -0.02641375f, 0.05064093f, 0.21429892f, 0.09588517f, 0.05348581f, 0.11419564f, -0.21780524f, -0.11463465f, 
    -0.08122960f, 0.06467052f, 0.01463150f, 0.03006728f, 0.16239659f, 0.14795262f, -0.04683952f, -0.18341210f, 
    -0.24698041f, 0.13798104f, 0.13295072f, 0.08410267f, 0.23073108f, 0.17963794f, 0.06023532f, -0.10498697f, 
    -0.36946478f, -0.51242101f, -0.06903256f, -0.01269969f, -0.06840775f, -0.01096787f, 0.06097668f, -0.04170004f, 
    -0.03985054f, -0.19265212f, 0.14204034f, 0.04144239f, 0.03279392f, -0.01643580f, 0.22358748f, 0.00999089f, 
    -0.01554382f, -0.18134204f, 0.00290531f, 0.00587685f, 0.09122244f, -0.13120854f, -0.11199871f, -0.26816899f, 
    -0.08926909f, -0.25209436f, 0.32344452f, -0.04911473f, 0.04819405f, 0.09493735f, -0.06741644f, 0.11545907f, 
    0.05316735f, 0.04619272f, 0.01748999f, -0.14192626f, 0.08856907f, 0.02524853f, -0.00070839f, -0.02873581f, 
    0.02164339f, 0.09223347f, 0.00447980f, 0.03677801f, -0.07417025f, -0.00728233f, 0.16809513f, 0.03557529f, 
    -0.07069407f, -0.04405436f, -0.05686971f, -0.03773699f, -0.17467591f, -0.03339570f, 0.06450309f, 0.10789673f, 
    -0.04913067f, -0.04806970f, -0.11255822f, -0.01942245f, 0.02224138f, 0.05127689f, 0.04520149f, 0.06220263f, 
    -0.05718711f, -0.17777069f, -0.05790064f, -0.23431678f, 0.08444438f, -0.09786738f, 0.01434251f, -0.43718296f, 
    -0.14008468f, 0.02108389f, 0.09609708f, -0.18651424f, 0.09758118f, 0.16065431f, 0.00857950f, -0.09129415f, 
    -0.48875573f, -0.01573017f, 0.24062461f, 0.01011565f, -0.15918961f, -0.04406191f, 0.09268260f, -0.04986431f, 
    0.06719539f, 0.03003937f, 0.16649903f, 0.04605214f, -0.07977618f, -0.07191598f, 0.02461160f, -0.00446394f, 
    -0.01984109f, 0.02893458f, 0.37078804f, 0.01232100f, -0.06331106f, 0.03015866f, 0.00248366f, -0.02754181f, 
    0.14998749f, -0.02345004f, 0.03446669f, 0.05427171f, -0.16393308f, -0.39466619f, 0.11003812f, 0.11982881f, 
    0.22788444f, -0.11826453f, 0.11370175f, 0.00959750f, 0.48085818f, 0.26996171f, 0.06449429f, 0.04482935f, 
    0.06890669f, -0.00064064f, 0.03888202f, 0.00980791f, -0.00132322f, -0.17675936f, -0.04581010f, -0.13648036f, 
    -0.14709413f, -0.06511469f, -0.19265909f, 0.04372440f, 0.05497065f, -0.05697690f, 0.06003060f, -0.45056784f, 
    -0.15061757f, 0.03421032f, 0.01721579f, 0.08745783f, 0.11703061f, 0.15475801f, -0.07033970f, -0.19163965f, 
    -0.27241009f, -0.13602360f, -0.02474261f, -0.09511761f, 0.02051825f, -0.00263766f, 0.04600115f, 0.08528090f, 
    0.29118037f, 0.24518098f, 0.12465811f, 0.03820978f, 0.07702755f, 0.07716759f, 0.11460701f, -0.05513733f, 
    0.05112018f, 0.09026437f, 0.18023401f, 0.06144413f, 0.02843356f, 0.08233715f, -0.01808270f, 0.04349752f, 
    0.01408581f, -0.00495734f, -0.24086782f, 0.10758374f, -0.15903158f, 0.04175005f, -0.26996079f, 0.16345994f, 
    0.02592801f, 0.29438788f, 0.03085837f, -0.09645902f, -0.12997888f, 0.16797376f, -0.04679589f, -0.03967812f, 
    -0.11013872f, 0.11162392f, 0.07595486f, -0.03368338f, 0.43647093f, 0.08171455f, -0.52599770f, -0.11678056f, 
    -0.15546492f, -0.01982903f, 0.00555659f, 0.12344996f, -0.03183334f, -0.32004815f, -0.29466045f, -0.01208774f, 
    -0.06242743f, 0.03430766f, -0.06264201f, -0.01532755f, 0.10855983f, 0.05553102f, 0.07333770f, 0.12682129f, 
    0.08631539f, -0.16089563f, -0.16891617f, -0.17244464f, -0.16384143f, -0.02793146f, 0.11297381f, -0.21588860f, 
    0.12203135f, -0.01711130f, 0.02473844f, -0.06222601f, 0.22488458f, 0.04200259f, 0.22722843f, -0.03995958f, 
    0.00766785f, -0.21200828f, -0.03367829f, -0.04094208f, -0.00924082f, 0.05108691f, 0.11751457f, 0.17887115f, 
    -0.02042644f, -0.53346324f, -0.34082311f, -0.03769735f, -0.07873802f, -0.01338923f, -0.01160361f, -0.08125988f, 
    0.09704222f, 0.10366711f, -0.26509351f, -0.29760435f, -0.25360167f, 0.08016188f, -0.00099412f, 0.10873118f, 
    0.07878641f, 0.16229643f, 0.18749620f, -0.05468662f, 0.06712631f, -0.05926046f, -0.03089445f, 0.08628318f, 
    -0.07797199f, -0.25474897f, 0.05292498f, 0.19380116f, 0.24121083f, 0.13942905f, 0.00731418f, -0.01890356f, 
    -0.06202776f, 0.00509749f, -0.06398637f, 0.16564414f, 0.00969944f, 0.07631267f, 0.13394970f, 0.01545913f, 
    -0.07922052f, -0.07895982f, -0.21972856f, -0.04354801f, -0.06070045f, 0.07228222f, -0.07978262f, -0.12822308f, 
    -0.15839107f, 0.08694565f, 0.06252821f, 0.13383405f, -0.02403130f, 0.15946077f, 0.08193590f, 0.15605552f, 
    0.13828771f, 0.45050260f, 0.03680609f, 0.05113004f, -0.00130913f, -0.01414674f, 0.03853727f, 0.02080783f, 
    0.16238537f, 0.16604520f, 0.02162063f, -0.04244954f, 0.10193272f, -0.04264779f, -0.07418329f, -0.01547672f, 
    0.12818506f, -0.39394432f, -0.05441979f, 0.03527738f, 0.04591653f, -0.10940597f, -0.15485725f, -0.03494722f, 
    -0.07848616f, -0.06264265f, -0.68563974f, -0.00599367f, 0.31050059f, -0.11152130f, 0.03724345f, 0.04455455f, 
    0.08272316f, 0.16651455f, 0.01614913f, -0.30098924f, 0.00433550f, -0.01911181f, -0.03840820f, 0.03934998f, 
    0.10008220f, -0.04797919f, -0.00518815f, 0.04023499f, 0.14189667f, -0.22182576f, -0.16628163f, 0.12746705f, 
    -0.06041176f, -0.01943405f, 0.10745402f, 0.02152594f, -0.01521328f, 0.16423929f, 0.28866249f, 0.31368107f, 
    -0.15194887f, -0.25521794f, -0.06226354f, -0.03280803f, 0.00124039f, 0.02396904f, -0.05698731f, 0.11230683f, 
    0.01271177f, 0.28648257f, 0.28776509f, 0.00503823f, 0.00982803f, 0.00098766f, 0.02246175f, -0.15756090f, 
    -0.16844222f, -0.45202291f, -0.13822378f, -0.15207255f, 0.20601460f, -0.00880218f, 0.12826307f, -0.24274819f, 
    0.01096795f, -0.16244560f, -0.10762312f, -0.03792669f, 0.03336185f, 0.09858482f, 0.05448908f, 0.05686694f, 
    -0.02266945f, 0.06216894f, -0.16145281f, -0.28596637f, 0.15691331f, 0.08220342f, 0.06859238f, 0.10923720f, 
    0.08527704f, 0.12953928f, -0.01946948f, 0.06171323f, -0.01213811f, -0.02005328f, -0.01231342f, -0.05340449f, 
    0.03621504f, -0.28571835f, -0.02963762f, -0.18218979f, 0.05893214f, -0.04557811f, -0.01239762f, -0.10947718f, 
    -0.04177032f, -0.12260399f, -0.04533175f, -0.01849232f, -0.42704129f, 0.16780366f, 0.00252844f, 0.01083483f, 
    -0.30522865f, -0.17925686f, 0.00040967f, -0.17868087f, -0.09721668f, 0.12402593f, 0.15250480f, -0.09615007f, 
    0.09274549f, -0.00961587f, 0.01797839f, 0.20289238f, -0.12970445f, 0.02738788f, -0.17481741f, -0.05726887f, 
    -0.00250405f, 0.20431626f, 0.10889389f, -0.00739403f, -0.14244874f, -0.04198206f, -0.19758216f, 0.08604974f, 
    0.15938655f, 0.04698475f, 0.11969136f, 0.15348093f, 0.09884062f, -0.03515315f, 0.18887269f, 0.17160407f, 
    -0.26332277f, 0.09305669f, 0.05084001f, -0.01278701f, -0.06586184f, -0.04663254f, -0.03641994f, 0.06238480f, 
    -0.11035315f, 0.23848504f, -0.01248708f, 0.10105722f, -0.00554859f, 0.27041242f, 0.10269359f, 0.05446753f, 
    0.02886539f, -0.04906853f, -0.33448562f, 0.26137951f, 0.16139048f, 0.24435374f, -0.08390742f, 0.24861570f, 
    0.13255723f, 0.14795819f, -0.12092370f, -0.03879822f, -0.03344041f, 0.02454351f, -0.03804848f, -0.02744401f, 
    0.03742825f, -0.21884719f, -0.03145138f, -0.25848636f, 0.24067128f, 0.12770471f, 0.01431389f, 0.01699337f, 
    0.12113234f, 0.03940274f, 0.01488495f, -0.00119395f, -0.10767253f, -0.11904939f, -0.13113928f, 0.03507187f, 
    0.16450661f, 0.00032611f, 0.03211896f, -0.10803689f, 0.22770512f, 0.09273872f, -0.15600097f, 0.04038316f, 
    -0.28899240f, 0.18483701f, 0.19339512f, -0.02022386f, 0.17029454f, 0.17346790f, 0.05563805f, 0.28243220f, 
    -0.04761717f, -0.01966475f, -0.18608534f, -0.02934519f, 0.07496852f, 0.18538442f, 0.25981960f, 0.11267503f, 
    0.01381367f, 0.01972925f, 0.05378332f, 0.06488560f, 0.08555865f, 0.13241257f, 0.01803954f, 0.10684520f, 
    0.22148792f, -0.12168287f, -0.06719192f, 0.10824457f, 0.03408127f, -0.21131265f, -0.06326679f, -0.11442886f, 
    0.18910854f, -0.08251236f, -0.08036172f, 0.00070649f, 0.08599045f, 0.07169289f, 0.02924513f, 0.07957955f, 
    -0.06690501f, 0.01704834f, 0.08861240f, -0.09556219f, -0.01933782f, -0.04621451f, 0.05273723f, 0.08760718f, 
    -0.00579928f, 0.04335738f, 0.08092710f, -0.03052207f, -0.07570944f, 0.08752650f, -0.05697338f, -0.21633071f, 
    -0.11519757f, -0.02013071f, 0.25701755f, 0.07120039f, 0.13514347f, -0.05334301f, -0.14031397f, -0.34935737f, 
    0.16003898f, 0.16068579f, -0.01456422f, 0.09591979f, -0.13206436f, -0.00181225f, 0.04147468f, 0.09239954f, 
    0.07714841f, 0.06361811f, -0.00031085f, 0.03124117f, -0.04747970f, 0.12843557f, 0.04499687f, -0.12928039f, 
    -0.02645936f, -0.49999624f, 0.01877751f, -0.06864596f, -0.00728534f, -0.04983194f, 0.03617568f, -0.14884345f, 
    -0.02819003f, 0.05301841f, -0.14792354f, 0.06814105f, -0.07885338f, -0.03890582f, 0.00462061f, -0.06556406f, 
    0.11213931f, -0.01294184f, -0.11360071f, -0.21494548f, -0.03476971f, -0.01723199f, 0.00891672f, -0.14296871f, 
    -0.20596515f, -0.06363403f, 0.00522117f, 0.08378583f, 0.30890793f, -0.19947784f, -0.11191832f, -0.19211690f, 
    -0.00765386f, 0.12580110f, 0.28527135f, 0.12303647f, -0.06497431f, -0.08597768f, 0.06117669f, 0.10640731f, 
    0.04317531f, 0.04965977f, 0.19881494f, -0.01622355f, -0.11667538f, -0.03179631f, -0.01908587f, -0.06509542f, 
    0.08417640f, -0.10540247f, 0.04184740f, -0.09383197f, -0.00101056f, -0.02046011f, 0.10756896f, -0.27114201f, 
    -0.28425741f, 0.07041696f, -0.02572452f, 0.11223505f, 0.05688634f, 0.12866430f, 0.12941252f, 0.03687419f, 
    -0.03474661f, -0.23623776f, 0.00113272f, -0.12342615f, 0.04485844f, 0.01454994f, 0.11387607f, -0.21171407f, 
    0.36243773f, 0.05104238f, 0.00529529f, -0.17789678f, 0.29025108f, 0.10356818f, 0.19172965f, -0.16964112f, 
    0.04421652f, -0.04177547f, -0.25399953f, 0.13149226f, 0.03031989f, -0.11052827f, 0.12833601f, -0.03213940f, 
    0.09956661f, 0.09015524f, 0.05663351f, 0.36316812f, -0.07780202f, 0.04456418f, 0.34895271f, -0.13891813f, 
    0.12503158f, 0.13980392f, -0.07592226f, 0.20088607f, 0.18502097f, -0.00335543f, 0.04400742f, -0.00741016f, 
    0.16097727f, 0.05813394f, -0.07355418f, -0.30457240f, -0.14123903f, 0.14886875f, 0.08961926f, 0.10253488f, 
    0.10617565f, -0.00680380f, 0.08695006f, 0.10714287f, -0.50387979f, 0.01062560f, 0.27139840f, 0.04462472f, 
    -0.28602311f, -0.01755683f, 0.08005196f, -0.03821078f, 0.07646130f, -0.14357930f, -0.15557440f, -0.19209130f, 
    -0.30167508f, 0.09308211f, -0.14328963f, 0.16490801f, -0.09089332f, -0.37013206f, -0.14054871f, -0.17564265f, 
    0.09338642f, -0.03105903f, 0.04787409f, -0.14599079f, -0.08860893f, 0.07668262f, 0.07354286f, -0.10959143f, 
    0.05871880f, -0.28495139f, -0.02487684f, -0.06393554f, 0.12224406f, -0.11976557f, 0.08108692f, 0.06662093f, 
    -0.17323872f, 0.08203823f, 0.31630808f, -0.00324618f, -0.00680314f, 0.12915930f, 0.18863425f, -0.01956274f, 
    0.11094116f, 0.22774829f, -0.09739081f, -0.05500442f, 0.09299940f, -0.00972630f, -0.01047056f, 0.12143940f, 
    0.11907314f, -0.02794535f, 0.16169165f, 0.14187491f, -0.31116152f, -0.10249396f, 0.02002182f, -0.09316827f, 
    -0.16225043f, -0.01010507f, -0.12045275f, 0.07797103f, -0.19586535f, -0.04590698f, 0.10039436f, -0.06270650f, 
    0.09949083f, 0.12733957f, -0.01164237f, -0.04007621f, 0.01305111f, 0.13501829f, 0.11508175f, 0.07062982f, 
    -0.05011129f, 0.06264637f, 0.12592369f, 0.03099893f, 0.11873248f, -0.24866483f, -0.14166622f, -0.10691750f, 
    -0.09418579f, -0.06326315f, -0.12181731f, 0.09443662f, 0.03773010f, 0.11004192f, 0.10310939f, 0.12235456f, 
    0.25477713f, 0.00259743f, -0.00611288f, 0.11297189f, -0.03772501f, 0.02595057f, -0.10298049f, -0.25917131f, 
    -0.10347105f, 0.23011154f, -0.21120061f, -0.00850054f, 0.37107641f, 0.02423673f, 0.10190927f, 0.23421516f, 
    -0.15739423f, -0.28181317f, -0.27142072f, -0.02225927f, -0.19705245f, -0.12712105f, 0.09598389f, 0.10421857f, 
    0.12438546f, 0.00512660f, -0.17253636f, -0.34682700f, 0.25402904f, -0.17385156f, -0.13653331f, 0.18756515f, 
    0.00552027f, -0.13290159f, -0.14082278f, -0.20470244f, -0.12371196f, 0.15684761f, -0.08007864f, -0.07335190f, 
    0.09353352f, 0.19858056f, 0.16259952f, -0.34899822f, -0.29120475f, -0.18273839f, 0.22616965f, -0.19311684f, 
    -0.07977811f, 0.17045820f, 0.04731778f, 0.17527762f, 0.17707416f, -0.09249043f, -0.04070142f, 0.01560143f, 
    -0.08232521f, 0.01919792f, -0.03283972f, 0.05384192f, 0.03501647f, -0.01994631f, 0.11655127f, 0.28015625f, 
    -0.06849330f, -0.00321960f, 0.16598530f, -0.03703249f, 0.02273491f, -0.03828646f, -0.03889745f, -0.22941415f, 
    0.06748043f, 0.09240610f, -0.02390380f, -0.07090271f, 0.06405585f, 0.16784520f, 0.13477790f, -0.09670378f, 
    -0.16412753f, 0.19150576f, -0.01603584f, 0.00060210f, -0.03793946f, 0.06650211f, 0.03835560f, -0.27124032f, 
    -0.18545350f, -0.16257480f, -0.54677892f, -0.00785939f, 0.00769131f, -0.06879484f, 0.12054797f, 0.15483484f, 
    0.15188028f, 0.12393218f, -0.09940125f, -0.03827062f, 0.02282707f, -0.15375108f, -0.01109236f, -0.09026928f, 
    -0.03777885f, -0.06976363f, 0.61170048f, -0.16434515f, -0.43929291f, 0.20295431f, -0.03263076f, -0.21147403f, 
    -0.06499404f, -0.08733904f, 0.13708642f, -0.08509920f, 0.12114518f, 0.02370504f, 0.06587614f, -0.01559298f, 
    0.05260231f, 0.08331360f, 0.15254153f, 0.17112121f, -0.23272486f, -0.13651167f, -0.08779365f, 0.08229744f, 
    -0.28039697f, -0.07267290f, -0.06863103f, -0.03114759f, 0.17274812f, 0.00767006f, -0.24509281f, 0.27726641f, 
    0.08039109f, 0.03197607f, 0.14455563f, -0.14341344f, -0.04454337f, -0.05585505f, -0.10274331f, -0.25208157f, 
    0.15581478f, 0.07742110f, -0.10350154f, -0.03683001f, 0.01457735f, 0.23821212f, -0.24210054f, 0.13283311f, 
    -0.12349680f, -0.18597288f, 0.00211706f, -0.09004181f, 0.05186306f, -0.06543807f, 0.04057803f, 0.22489281f, 
    -0.27236158f, 0.17774101f, 0.16041690f, 0.14387177f, -0.24554248f, -0.12793390f, -0.05730644f, 0.07266268f, 
    -0.10752545f, -0.01606942f, 0.10500211f, 0.24593410f, 0.00884145f, 0.03333183f, -0.13997121f, 0.07978552f, 
    -0.00106290f, 0.04281764f, -0.07338285f, -0.01142206f, 0.11375007f, 0.04853258f, -0.04636152f, -0.13502224f, 
    0.24159043f, 0.15056939f, 0.06235911f, 0.00983061f, -0.58131200f, -0.09390804f, -0.34102046f, 0.00760537f, 
    0.03655784f, -0.03590188f, 0.08662513f, 0.11546759f, 0.05977645f, -0.11149590f, 0.09472559f, -0.13007176f, 
    0.08300859f, -0.14478576f, 0.14620201f, 0.06802011f, -0.15634897f, 0.22283353f, -0.05398710f, -0.08535089f, 
    -0.07867648f, 0.02359658f, 0.14956258f, 0.05980138f, 0.05699503f, -0.07223259f, -0.34393519f, -0.62490904f, 
    0.12789614f, -0.08424181f, 0.02373144f, -0.08670645f, 0.16842228f, -0.01631480f, -0.05776555f, -0.26771221f, 
    -0.21882057f, -0.22520708f, 0.10000657f, 0.18851423f, -0.09796344f, -0.10802098f, 0.10544822f, -0.02013755f, 
    0.01261370f, 0.12778848f, 0.03765640f, -0.07702039f, 0.01891479f, 0.04454478f, -0.02113047f, -0.08381274f, 
    -0.09891155f, -0.13099490f, 0.13483666f, 0.27999824f, 0.04499272f, 0.09550595f, -0.05783299f, 0.11496008f, 
    0.06230405f, -0.02092090f, -0.29492244f, 0.01742861f, 0.26547453f, 0.22823901f, -0.08806226f, 0.39533430f, 
    0.06932740f, -0.08567115f, 0.13760895f, -0.11927757f, 0.14859287f, 0.22153746f, 0.21767178f, -0.13242057f, 
    0.02919044f, 0.01669933f, 0.04140291f, -0.24031946f, 0.18877290f, -0.44505468f, -0.38418901f, -0.02769040f, 
    0.20130232f, -0.07312979f, 0.01826944f, 0.00391758f, 0.14672999f, -0.01325165f, -0.40982643f, 0.00847550f, 
    -0.10033847f, 0.19401069f, -0.02224132f, 0.05514637f, 0.05542088f, -0.09744622f, -0.11076459f, -0.00419864f, 
    0.03311343f, -0.02006550f, 0.06702478f, -0.20007621f, 0.03829210f, 0.18880992f, 0.03738443f, -0.21695665f, 
    -0.07384909f, 0.27923676f, 0.05582930f, 0.13179196f, -0.09894381f, -0.02330274f, 0.02551339f, 0.15548244f, 
    -0.32412854f, -0.31343749f, -0.07290337f, 0.06900143f, 0.15755996f, 0.06048714f, 0.08171543f, 0.06247997f, 
    -0.02561979f, -0.79886097f, -0.23857924f, 0.18660814f, -0.08920217f, -0.24590239f, -0.02796089f, -0.02886335f, 
    -0.16008185f, 0.05447263f, -0.22481112f, -0.32664561f, -0.12107210f, -0.15049170f, 0.04369174f, 0.16313154f, 
    -0.02695529f, 0.05800448f, 0.08406262f, 0.07884330f, 0.08302871f, 0.24044736f, -0.22527722f, 0.05971524f, 
    -0.07647079f, -0.01851975f, -0.06698182f, 0.06420811f, -0.16932592f, 0.03949248f, -0.09693968f, 0.02380112f, 
    0.01784443f, 0.13713785f, -0.00597821f, -0.01194019f, 0.26102358f, -0.08647273f, 0.07591627f, 0.31661853f, 
    -0.13169579f, -0.11146300f, -0.08824862f, -0.01588466f, -0.01513233f, 0.10512760f, 0.10793994f, -0.06309988f, 
    -0.11682431f, -0.09731422f, 0.09353787f, 0.16198385f, 0.02863135f, 0.09340132f, 0.06572197f, -0.03173351f, 
    0.27078554f, 0.09377070f, 0.03510869f, -0.03481966f, -0.12638098f, 0.07024170f, 0.03536128f, 0.05948738f, 
    -0.34230524f, -0.07590012f, 0.03400934f, 0.03893976f, -0.18215825f, 0.08004829f, -0.08112442f, 0.04374772f, 
    0.08926954f, -0.83119196f, 0.10303441f, 0.01098064f, 0.05581309f, -0.02993712f, -0.10793974f, 0.12030501f, 
    0.00757622f, -0.16579874f, -0.87340182f, -0.14342704f, 0.23826230f, -0.00592615f, 0.03005021f, -0.01046136f, 
    0.01317674f, 0.08293837f, 0.12011490f, 0.06875471f, 0.06678852f, -0.22777483f, 0.14617153f, -0.04808675f, 
    -0.04474986f, -0.02820725f, 0.04350711f, -0.12579770f, -0.00300050f, -0.42353529f, 0.12597390f, -0.19279590f, 
    -0.28527075f, -0.12707864f, 0.01598753f, 0.26253292f, 0.04672569f, -0.19282356f, 0.12257521f, 0.35739321f, 
    -0.14542624f, -0.01886891f, -0.14878973f, 0.07564388f, -0.06430097f, 0.07993016f, -0.01729557f, 0.08991469f, 
    0.26123393f, -0.00363828f, 0.02459436f, -0.12926209f, -0.19194362f, -0.11857305f, 0.11228288f, -0.17097923f, 
    -0.39811674f, -0.26983601f, -0.04056780f, 0.18915656f, 0.32471305f, -0.04462693f, -0.12181112f, 0.05041084f, 
    -0.01603290f, 0.12394892f, 0.05570029f, -0.06374135f, 0.19206835f, 0.09077452f, 0.19917296f, 0.23070420f, 
    0.38130271f, -0.21069732f, -0.00816440f, -0.31200999f, 0.06297800f, -0.01204639f, -0.01623581f, 0.02480025f, 
    -0.00761754f, -0.01700736f, -0.01504661f, -0.58783507f, -0.13286804f, 0.07694954f, -0.10321414f, -0.02951837f, 
    -0.04136444f, 0.01943857f, 0.25938639f, -0.11083584f, 0.17772856f, 0.08861723f, -0.21745992f, -0.05748018f, 
    -0.03659534f, 0.00880525f, -0.01266868f, -0.05890706f, -0.08876241f, -0.23453927f, 0.14089273f, 0.02274505f, 
    -0.14829905f, -0.30873632f, -0.10405798f, 0.02704641f, 0.01653009f, 0.39709389f, -0.15645346f, -0.03287577f, 
    -0.04910148f, 0.18293639f, -0.01829665f, 0.27349502f, 0.07551127f, -0.17624880f, -0.08828849f, 0.01690948f, 
    -0.03472063f, -0.23378687f, -0.21426044f, -0.19601335f, 0.03669478f, 0.04535992f, -0.05695797f, 0.35531610f, 
    -0.47700852f, -0.09033534f, 0.01334461f, 0.09897410f, 0.03145429f, 0.06756880f, 0.05594365f, -0.08457161f, 
    -0.29276726f, -0.47025973f, -0.19598779f, 0.02883461f, 0.10477412f, 0.02220885f, -0.14167474f, 0.03375734f, 
    0.24505979f, -0.18210863f, -0.23822860f, -0.64724660f, -0.10115021f, 0.06221755f, 0.07167421f, -0.09180144f, 
    0.05118675f, -0.09286390f, -0.40023670f, -0.35446224f, -0.30562073f, -0.07201228f, 0.07034049f, -0.03130128f, 
    -0.17439850f, 0.07080363f, -0.04293051f, -0.16723646f, -0.23308313f, 0.00864220f, -0.05279076f, 0.18703625f, 
    0.06936127f, 0.15450527f, 0.07878913f, 0.27915302f, 0.38301757f, 0.41279235f, -0.22046170f, -0.04968608f, 
    -0.18777412f, -0.18015972f, 0.08400147f, 0.11002720f, 0.05624025f, 0.22816919f, -0.21399379f, -0.02551110f, 
    0.17243819f, 0.11853424f, -0.06323546f, -0.00885642f, -0.10918452f, 0.14433786f, -0.47997102f, -0.63820422f, 
    -0.15475549f, 0.11731694f, 0.03333911f, -0.02096850f, -0.06383488f, -0.15928113f, -0.03428224f, -0.37777582f, 
    0.12160756f, 0.20062536f, -0.01551426f, -0.03573360f, -0.01265026f, 0.18153927f, 0.04075646f, -0.08692031f, 
    0.13683468f, 0.08754499f, 0.05691109f, -0.04930269f, -0.05087384f, -0.08009530f, 0.07436786f, 0.03069068f, 
    -0.08439983f, -0.00168947f, 0.31720659f, 0.20631246f, -0.01689107f, -0.00536946f, -0.14689362f, 0.03635161f, 
    0.21888088f, 0.26311544f, 0.03189345f, 0.13928200f, 0.05891440f, -0.09475890f, -0.07682481f, -0.02984384f, 
    0.06951226f, 0.05704377f, -0.00446121f, 0.19800608f, 0.00503670f, -0.02535702f, 0.10114459f, -0.05340842f, 
    0.07943355f, 0.11400265f, 0.07263340f, 0.14727668f, -0.03877806f, -0.03269019f, 0.02119139f, 0.07384796f, 
    0.27110094f, 0.14332046f, -0.03069597f, -0.10249157f, -0.09724170f, -0.39625955f, -0.12421378f, -0.62914181f, 
    0.16110577f, -0.00155245f, -0.09307989f, 0.01031732f, -0.16222437f, 0.11763106f, 0.01563872f, 0.27637854f, 
    0.10130664f, -0.01155951f, 0.03211593f, 0.07071978f, 0.07796865f, 0.04918371f, -0.06244559f, -0.47845155f, 
    0.18722934f, -0.49383911f, -0.05152876f, 0.00378155f, 0.00715071f, 0.14424853f, -0.05697159f, 0.03094765f, 
    0.01218961f, 0.11130467f, 0.10247006f, -0.08979627f, 0.02084272f, -0.01141585f, -0.04410127f, 0.01582936f, 
    0.00789557f, -0.00860894f, 0.16751914f, 0.03351748f, 0.07108932f, -0.03264184f, -0.02214829f, 0.18044960f, 
    0.05708516f, 0.11010034f, -0.50285995f, -0.30157757f, 0.29069999f, -0.00622662f, 0.06414460f, 0.06981796f, 
    -0.07466193f, 0.04332960f, 0.03510436f, 0.05736227f, -0.08706467f, -0.08737842f, 0.12687342f, 0.12690128f, 
    0.01524360f, 0.06124547f, 0.07330198f, 0.26121914f, 0.06078518f, 0.05408287f, 0.13385886f, -0.05276744f, 
    0.13727720f, -0.07234924f, 0.00368946f, 0.08862571f, 0.07235724f, -0.35398552f, -0.30645505f, -0.40922406f, 
    -0.07769027f, 0.07462279f, -0.01758328f, 0.00504148f, -0.10169685f, -0.18767096f, -0.13446310f, 0.60024059f, 
    -0.07007367f, 0.17306645f, 0.09542333f, -0.06238584f, -0.11046977f, -0.05836210f, -0.24130994f, 0.24982069f, 
    0.14212877f, -0.34983480f, 0.01755121f, 0.07849832f, 0.16340508f, 0.01505086f, -0.08385634f, -0.00681327f, 
    0.03810560f, -0.03805367f, -0.05148535f, -0.04963697f, 0.01333463f, -0.03338901f, -0.05048941f, -0.02792539f, 
    -0.03654536f, 0.04148091f, 0.00761493f, -0.05633958f, 0.01767387f, 0.05078895f, 0.03858967f, -0.00727243f, 
    -0.00230655f, -0.04915215f, 0.01207770f, 0.01675795f, -0.00547804f, -0.04948524f, -0.01280908f, -0.02972187f, 
    -0.05553984f, -0.03735078f, -0.06171780f, 0.01642656f, -0.05004095f, -0.06087629f, -0.03076974f, -0.05680473f, 
    0.01385929f, -0.05028300f, 0.01003148f, 0.01199481f, 0.03132292f, -0.04250737f, 0.00611805f, 0.02874182f, 
    -0.02691697f, -0.03998055f, 0.00057242f, -0.01054896f, -0.02776940f, -0.02503696f, 0.00831355f, -0.03040791f, 
    0.00006562f, 0.02686088f, 0.04889123f, 0.03541594f, 0.01059640f, 0.01045897f, -0.05963314f, -0.04385635f, 
    0.05748567f, -0.05577787f, -0.00716947f, -0.02855149f, -0.05325637f, -0.04438965f, -0.03012035f, 0.02383859f, 
    -0.04762673f, -0.00157525f, -0.06257540f, -0.03057588f, 0.05248290f, -0.01522922f, 0.04224181f, 0.00143340f, 
    -0.00303192f, -0.02914605f, -0.01540935f, 0.03199245f, 0.02234134f, -0.05121686f, 0.04332606f, 0.02165656f, 
    0.02632688f, 0.02525767f, 0.00731731f, -0.06313301f, -0.00026601f, -0.01974880f, 0.01282651f, -0.03621377f, 
    -0.03917585f, -0.03044649f, 0.04641591f, -0.05244246f, -0.04706233f, -0.06443086f, -0.00021451f, -0.04684139f, 
    -0.00244267f, -0.02590102f, -0.04321443f, 0.04532968f, -0.03682172f, -0.02799052f, -0.04403394f, 0.01574538f, 
    -0.04581212f, -0.02593253f, -0.05201447f, -0.02960073f, 0.04128497f, 0.04724621f, -0.05111707f, 0.03381212f, 
    -0.04950302f, -0.03228992f, -0.04499595f, 0.04438078f, -0.00669467f, -0.04807986f, -0.02090430f, -0.03306092f, 
    0.00715590f, 0.02609487f, 0.00861099f, 0.00221932f, 0.01821166f, -0.02104989f, -0.00905038f, 0.03999220f, 
    -0.01352957f, -0.00395385f, 0.00814250f, -0.02240615f, -0.02441336f, 0.03929121f, -0.02090544f, -0.02948898f, 
    -0.00784062f, -0.05595961f, 0.00415541f, -0.01012606f, -0.06026632f, -0.05915789f, 0.02243324f, 0.00072992f, 
    0.04037715f, 0.00514660f, -0.05377503f, -0.05571117f, 0.00323625f, -0.05200613f, -0.02624678f, -0.02267107f, 
    -0.02937727f, 0.02554812f, -0.02373508f, 0.03716169f, 0.05646005f, -0.00078518f, -0.05873461f, -0.03051931f, 
    -0.05613628f, -0.02184901f, -0.05179996f, -0.01228708f, 0.00648570f, -0.02519026f, -0.02444635f, -0.03927336f, 
    0.02582539f, 0.00555243f, 0.01131718f, 0.03524055f, -0.05915619f, -0.00684892f, 0.01570027f, 0.04348793f, 
    -0.00709143f, 0.00178475f, -0.06139378f, 0.04422019f, 0.05408092f, 0.03898673f, -0.04552466f, -0.05413069f, 
    0.01572677f, -0.03377498f, 0.02448905f, -0.02630033f, 0.01053246f, 0.02373765f, -0.01466941f, 0.00908072f, 
    0.02632602f, 0.00405346f, -0.05908007f, -0.00296739f, 0.03528439f, -0.03563654f, -0.02158407f, 0.04851792f, 
    -0.06203245f, 0.02076066f, 0.03618921f, 0.03285328f, 0.04609835f, 0.03397758f, 0.02141496f, -0.06147215f, 
    -0.05976069f, -0.00088579f, -0.01036397f, 0.01055643f, 0.00122432f, -0.05642811f, -0.02109543f, -0.05545385f, 
    -0.00339489f, 0.03405561f, 0.03517969f, 0.01026232f, 0.04071409f, -0.04604296f, -0.03695315f, 0.01908477f, 
    -0.01493565f, -0.03671287f, -0.05276710f, 0.04467204f, -0.05239632f, 0.04601597f, 0.04236963f, -0.04566855f, 
    0.02896770f, -0.02711780f, -0.00983967f, -0.03467134f, 0.02656243f, 0.02173652f, 0.01368775f, -0.00580382f, 
    0.01153568f, 0.01537100f, -0.02105627f, 0.05282585f, 0.05007625f, 0.00659210f, -0.04652368f, -0.01364024f, 
    -0.03537621f, 0.04690814f, -0.03409392f, 0.00256731f, 0.03316882f, -0.06081067f, -0.04200950f, 0.05377389f, 
    0.00064750f, -0.03236793f, 0.03912102f, 0.05151722f, -0.02359330f, -0.01967596f, -0.03631458f, 0.04220599f, 
    0.03978251f, -0.04029765f, -0.00991404f, 0.03605906f, -0.01325961f, -0.03972202f, 0.03803771f, -0.04662676f, 
    -0.04678360f, -0.00058188f, -0.03057927f, 0.00544279f, 0.00237272f, -0.03394299f, 0.00772305f, 0.02931849f, 
    -0.02909503f, -0.03452404f, -0.05054259f, -0.03258566f, 0.04158601f, -0.05727834f, -0.02976841f, 0.01364190f, 
    -0.08543219f, 0.01285539f, 0.08927903f, -0.15452845f, 0.11832558f, 0.00495541f, -0.17051019f, -0.10707254f, 
    0.02556119f, 0.10940240f, -0.09855825f, -0.04401538f, -0.01226617f, 0.13610007f, -0.01566809f, -0.05102598f, 
    -0.02851751f, -0.07429684f, 0.13988084f, -0.22442478f, -0.10974081f, 0.04104616f, -0.09433167f, -0.00975424f, 
    0.07064311f, -0.04763523f, 0.08039542f, 0.01373929f, 0.00761305f, 0.08215765f, -0.20053117f, -0.03944726f, 
    0.02121715f, 0.05253227f, 0.07998489f, 0.01946904f, 0.34779522f, 0.04287129f, -0.09271669f, 0.08977369f, 
    -0.26357558f, 0.01170429f, -0.07470848f, 0.09956570f, -0.11869039f, 0.26394793f, -0.15500996f, -0.24034993f, 
    0.20590836f, 0.01694695f, -0.09061828f, 0.09182446f, 0.01462937f, 0.08258144f, 0.09504229f, 0.05003780f, 
    0.08852941f, 0.04416038f, -0.23669967f, -0.04196889f, -0.05164348f, -0.04442172f, 0.10185725f, -0.10184377f, 
    0.25808290f, -0.06089134f, 0.00835321f, 0.05163143f, 0.10055450f, 0.13149369f, 0.03679496f, -0.09342284f, 
    0.30194411f, 0.03493959f, -0.01554512f, -0.10204763f, -0.16021402f, -0.07798249f, -0.12542218f, 0.04316579f, 
    -0.00118303f, 0.32840097f, 0.02960652f, -0.20359187f, 0.02568755f, 0.05105211f, -0.03333460f, -0.05719399f, 
    -0.04272554f, -0.04717278f, -0.00414969f, -0.02010113f, -0.11084122f, -0.08027238f, 0.12220699f, 0.18967107f, 
    -0.00630150f, 0.02629064f, -0.20739986f, -0.29818302f, -0.12873191f, -0.03598505f, -0.03974910f, 0.04077806f, 
    0.12030501f, -0.19114369f, -0.18145390f, -0.04545511f, 0.09334830f, 0.07616185f, 0.02825683f, 0.09968117f, 
    -0.00856625f, -0.03650731f, -0.04072815f, 0.12162507f, -0.27166128f, -0.05634113f, -0.08091740f, 0.01934977f, 
    0.00089306f, -0.04667647f, 0.00417513f, -0.01574694f, -0.12314036f, 0.07053334f, 0.03659442f, -0.11007109f, 
    -0.03386747f, -0.02620392f, 0.18262011f, -0.06534208f, -0.04189871f, 0.11585161f, 0.02946439f, -0.06565809f, 
    0.00708642f, 0.19573721f, 0.00289256f, -0.15399034f, -0.02986892f, 0.08492196f, 0.10916407f, -0.12634484f, 
    0.04935348f, 0.10969289f, 0.09914079f, -0.05250569f, -0.22359356f, -0.13506210f, 0.06071888f, -0.00415712f, 
    0.15314978f, 0.16391264f, 0.14492783f, 0.04993284f, 0.09890117f, 0.16082150f, -0.14068650f, 0.02103954f, 
    0.05299418f, 0.13022523f, 0.05123845f, 0.04422444f, 0.06165145f, 0.05966292f, -0.22890845f, 0.14676087f, 
    0.03389057f, 0.09209442f, 0.15251806f, -0.00413285f, -0.03277613f, 0.06662242f, 0.12898828f, -0.15525787f, 
    0.02222621f, -0.05752321f, 0.17570908f, 0.17608190f, -0.16348408f, -0.18392681f, 0.14174929f, -0.11134883f, 
    -0.27451485f, -0.07003416f, 0.04835543f, 0.08688100f, 0.22902954f, 0.17734538f, -0.05536196f, -0.18990187f, 
    0.01062660f, 0.11515775f, -0.06626295f, -0.02801870f, -0.05192722f, 0.08376952f, 0.02254827f, 0.06757469f, 
    -0.04104128f, -0.04462572f, -0.25735104f, 0.00604551f, -0.03253816f, 0.12050728f, 0.04863949f, 0.02956163f, 
    0.01594346f, -0.12237232f, -0.02185357f, 0.03674021f, -0.07389572f, -0.07074728f, -0.13414508f, 0.06293532f, 
    0.01570203f, -0.00573734f, 0.09342598f, -0.12011333f, -0.24812329f, -0.05889572f, 0.05278359f, 0.12146779f, 
    0.04279423f, -0.20711337f, 0.04168865f, 0.18899606f, 0.00406124f, 0.10057458f, -0.07339831f, -0.15380548f, 
    -0.35245788f, -0.16712022f, 0.39341444f, 0.14501134f, 0.13155296f, 0.18981971f, -0.02143147f, -0.01064125f, 
    0.04659542f, 0.12552758f, 0.11057244f, 0.00977813f, 0.06433994f, -0.01442060f, -0.05165228f, -0.02234799f, 
    0.02316841f, -0.05383978f, 0.12371266f, -0.01765603f, -0.13418020f, 0.05558420f, 0.14298730f, -0.08023994f, 
    0.00679879f, 0.01902303f, -0.17113021f, -0.23567192f, -0.17962222f, -0.06724121f, -0.11805938f, -0.25407702f, 
    -0.17113045f, 0.07402363f, 0.09698683f, 0.07824784f, 0.07535798f, 0.02467306f, 0.18844219f, 0.10774882f, 
    -0.02884691f, 0.20426427f, -0.15345383f, -0.04804964f, 0.02486841f, 0.03651501f, 0.10011087f, -0.08391881f, 
    -0.06814019f, -0.20671509f, -0.14807501f, 0.05686593f, -0.09142349f, 0.15089238f, 0.01193076f, 0.01416836f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.09537675f, 0.11402290f, -0.06140869f, -0.14518023f, 0.07203209f, -0.00747108f, 0.22772989f, 0.36590594f, 
    0.07601403f, -0.06667887f, -0.07365751f, 0.05948966f, -0.11536637f, -0.01004648f, 0.03428014f, 0.07808772f, 
    -0.00720689f, 0.02006462f, 0.26544896f, -0.05445681f, -0.05859477f, 0.12923960f, 0.02455041f, 0.16862197f, 
    0.15136667f, 0.02130806f, 0.25469765f, 0.16665168f, 0.12641744f, 0.14474869f, 0.05141324f, -0.03825157f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.01218990f, -0.08937810f, 0.03109885f, 0.06980202f, 0.15636228f, -0.59009016f, -0.06854706f, -0.08635717f, 
    0.10293755f, 0.08366254f, -0.03081876f, -0.24217059f, 0.11205522f, -0.00693250f, 0.34405249f, -0.14445722f, 
    -0.09559122f, 0.27208641f, -0.29707831f, 0.02553596f, -0.11159550f, -0.03148913f, 0.41987699f, 0.23988622f, 
    -0.34125733f, 0.52124083f, -0.24977955f, 0.12661684f, 0.29783720f, -0.79938108f, -0.02436663f, 0.23017934f, 
    0.25427282f, 0.03417531f, -0.11173762f, -0.08452791f, 0.18136440f, 0.09193345f, 0.28511357f, -0.03396985f, 
    -0.12226763f, 0.08515659f, -0.14797691f, -0.40158671f, -0.12855266f, 0.12844910f, -0.08749516f, -0.00682182f, 
    -0.07197677f, -0.30084649f, 0.15271130f, 0.11497384f, -0.10959169f, -0.13295691f, -0.12839253f, -0.38916478f, 
    0.08227371f, 0.06649677f, 0.01536164f, 0.01424320f, 0.02993381f, 0.02194634f, -0.12405894f, 0.11116219f, 
    0.10916823f, -0.48098519f, -0.05025285f, -0.47909170f, -0.03365186f, -0.38121781f, 0.32633579f, -0.09584190f, 
    0.11240263f, 0.07081468f, -0.25654468f, -0.20945129f, -0.22763005f, -0.08241675f, 0.02972083f, -0.01160435f, 
    -0.08366437f, -0.11202051f, 0.49138302f, 0.03508368f, 0.11176909f, 0.37497672f, -0.01975853f, -0.02334872f, 
    0.05996787f, 0.06945544f, 0.22015674f, 0.10483076f, -0.11140643f, 0.33625507f, -0.06451332f, -0.02408063f, 
    0.12209971f, 0.13933350f, -0.16950659f, -0.17785303f, 0.02221570f, 0.32324424f, -0.20019297f, -0.22127804f, 
    0.15671602f, 0.28058380f, 0.09483062f, 0.33981076f, -0.12092207f, 0.08326218f, 0.20029369f, 0.01256886f, 
    0.09009256f, -0.61482942f, 0.09876680f, 0.05028602f, -0.09137780f, 0.27158713f, -0.06517886f, -0.30853930f, 
    -0.05044874f, -0.15898348f, -0.06742524f, 0.22617099f, -0.56201994f, -0.36580175f, -0.06755482f, 0.21565484f, 
    -0.28635740f, -0.29685214f, -0.09759220f, -0.09329446f, -0.02930516f, -0.17671800f, 0.27652079f, 0.17776847f, 
    0.22359867f, 0.04789570f, -0.16612229f, 0.08194280f, -0.04530580f, 0.17613751f, -0.06369706f, 0.27309951f, 
    0.10409963f, 0.25300577f, 0.68144566f, -0.15689801f, 0.15549840f, 0.13014083f, -0.07330543f, 0.24431978f, 
    0.03954566f, -0.11426711f, 0.27840003f, -0.05759505f, 0.43289492f, 0.15993571f, 0.01253327f, -0.02849863f, 
    -0.11802950f, 0.18963352f, -0.00450254f, -0.40062833f, 0.29201427f, -0.33708444f, 0.05084429f, -0.19907522f, 
    0.12323992f, 0.43477532f, -0.41068199f, 0.32881480f, 0.20190747f, 0.04310220f, -0.06727701f, 0.27963406f, 
    0.14686689f, 0.24979648f, 0.08949112f, 0.24741811f, -0.00832146f, 0.31702155f, -0.29399019f, 0.11907002f, 
    -0.70430279f, -0.33624113f, -0.40011871f, 0.36395961f, -0.05937478f, 0.05575634f, -0.05115291f, -0.37454289f, 
    0.63325328f, 0.36484197f, -0.03997723f, 0.01040475f, 0.05834274f, 0.09329022f, 0.19711335f, 0.12750591f, 
    0.05047377f, 0.04605015f, -0.11705290f, 0.40217319f, -0.35600337f, 0.15300001f, -0.17306149f, 0.09560345f, 
    -0.01656695f, 0.40097567f, 0.31856936f, 0.17832349f, -0.08238116f, -0.33751413f, -0.14411035f, -0.43600833f, 
    0.07988968f, -0.24516824f, 0.06771400f, 0.02280260f, 0.13814564f, 0.13705330f, -0.15592954f, -0.06042570f, 
    -0.18239325f, -0.22099060f, -0.03058344f, -0.17777361f, 0.10813244f, -0.20528531f, -0.19535311f, -0.01334668f, 
    -0.17879200f, -0.10375201f, -0.17305748f, 0.09438217f, 0.02658340f, -0.09092310f, -0.13807862f, 0.11191677f, 
    -0.15824702f, 0.05420986f, 0.06784002f, -0.15762703f, 0.00936124f, 0.10919764f, 0.00330933f, 0.03328082f, 
    -0.00340993f, -0.01269920f, -0.11494213f, -0.02200730f, 0.00713185f, -0.08357834f, -0.07085282f, 0.03379190f, 
    0.09709307f, 0.40432805f, -0.03071425f, 0.10965847f, 0.17467335f, -0.36407977f, 0.18699846f, 0.17165074f, 
    0.06465717f, -0.01118046f, -0.00124193f, -0.03406209f, -0.41673827f, -0.07764167f, 0.00655121f, -0.43358910f, 
    0.07907043f, -0.27897850f, 0.03986119f, -0.00678176f, -0.00494425f, 0.06167324f, 0.24881096f, 0.18211459f, 
    0.18631594f, -0.10817284f, 0.19567201f, 0.52315307f, -0.40927240f, -0.56907922f, -0.12895665f, -0.03943736f, 
    -0.32962143f, -0.51245749f, 0.16563039f, -0.04474710f, 0.15693147f, -0.20203052f, 0.15956552f, -0.14196679f, 
    0.01391727f, -0.04989830f, 0.01291011f, 0.10044990f, 0.10843933f, 0.08363146f, 0.23302868f, -0.10707910f, 
    -0.01150601f, -0.34053683f, 0.08154292f, 0.29306370f, 0.11290695f, -0.02380718f, -0.02599597f, 0.14286350f, 
    -0.17524664f, -0.24503516f, 0.20344624f, 0.13198292f, -0.20350721f, -0.01134981f, -0.07875008f, 0.09344617f, 
    -0.16225968f, 0.10504244f, 0.02420491f, 0.32714769f, 0.13971624f, -0.02774800f, -0.23077644f, -0.07118789f, 
    -0.04097206f, -0.03573269f, 0.26667708f, -0.08114603f, -0.00975191f, 0.16756696f, 0.23245823f, -0.33923697f, 
    0.12878366f, -0.28895521f, 0.16328768f, 0.15986998f, -0.06797301f, -0.16764593f, 0.37709722f, 0.13096574f, 
    0.04583682f, 0.44514078f, 0.06284669f, 0.38010424f, 0.00857011f, -0.27886581f, -0.15885003f, 0.14191450f, 
    -0.19349308f, 0.35540894f, -0.08994178f, -0.13674828f, 0.09183116f, 0.01883437f, -0.11744170f, 0.04874071f, 
    0.01058601f, 0.22795019f, 0.12843727f, 0.34798613f, -0.04667832f, 0.17638494f, 0.08590489f, 0.12402478f, 
    -0.06334079f, -0.58723056f, 0.21118864f, 0.06629177f, -0.01971958f, 0.07134540f, -0.00306201f, 0.28898945f, 
    -0.03029305f, -0.54241180f, 0.22352761f, 0.13813332f, -0.42102647f, -0.20524251f, 0.16819513f, 0.17592207f, 
    0.36488688f, 0.56439418f, -0.13197520f, 0.21933064f, -0.12439341f, 0.10657590f, -0.00614619f, -0.00793504f, 
    0.19650197f, -0.10260432f, 0.13138774f, -0.00355821f, -0.32147676f, -0.10434597f, 0.14178413f, -0.20031227f, 
    -0.16364981f, -0.48781684f, 0.38687977f, 0.07465798f, 0.07209174f, -0.07118395f, -0.20594241f, -0.29461622f, 
    0.38357946f, 0.07167448f, 0.15062442f, 0.06020115f, 0.11560345f, -0.17994568f, 0.00790136f, 0.09487195f, 
    -0.21833733f, -0.12028059f, 0.12048166f, 0.17826004f, 0.10041010f, -0.17010407f, 0.10253830f, -0.22094725f, 
    0.00132432f, 0.14235941f, 0.15411279f, 0.24088009f, 0.32407171f, 0.17201056f, 0.37400463f, 0.02694336f, 
    -0.01701098f, -0.11995251f, -0.11732873f, 0.32510537f, 0.09252040f, -0.21664488f, 0.15287209f, 0.25809506f, 
    -0.26518875f, 0.14575392f, -0.21187516f, -0.08900008f, -0.00275696f, -0.09834418f, 0.15590453f, 0.04261586f, 
    0.33850184f, 0.32246965f, -0.02025720f, 0.00131242f, 0.20042662f, 0.17652290f, -0.18665130f, 0.17037895f, 
    0.02728167f, -0.16432895f, -0.13468874f, 0.33616745f, -0.23804533f, 0.12404915f, -0.32363158f, 0.05088673f, 
    -0.07638980f, -0.03410946f, 0.09951229f, -0.09089014f, 0.03066540f, 0.29229027f, 0.02686045f, 0.03012748f, 
    -0.08242766f, 0.05663559f, 0.21858345f, 0.31961969f, 0.40997210f, 0.17660610f, -0.15180230f, -0.04659514f, 
    -0.00086561f, -0.29404527f, -0.04127137f, -0.05248276f, 0.24798295f, -0.08353923f, 0.08862912f, 0.07689881f, 
    0.42083347f, -0.29127672f, 0.00468160f, 0.16673903f, -0.14329453f, 0.09378617f, 0.15888058f, -0.17109774f, 
    -0.14192553f, -0.22340164f, 0.02102409f, 0.02807536f, 0.04642488f, -0.10289123f, 0.06929836f, 0.20020397f, 
    0.14735553f, -0.01389063f, 0.26800507f, 0.41461429f, 0.42189929f, -0.37114769f, -0.17655019f, -0.29284549f, 
    0.10288294f, 0.33526537f, 0.00357310f, -0.09522721f, 0.21519721f, 0.30003744f, -0.00316502f, 0.01420415f, 
    0.16055179f, 0.21368502f, -0.10553337f, 0.32429564f, 0.38240704f, 0.02546728f, 0.01070860f, -0.04106989f, 
    -0.00183082f, 0.61529678f, -0.63622057f, -0.13906741f, -0.08395683f, 0.32109645f, 0.22465809f, 0.38946211f, 
    -0.08098275f, 0.04824463f, -0.29606226f, 0.13190621f, 0.21245021f, -0.08503116f, -0.07067179f, 0.08688119f, 
    -0.08512159f, 0.54595953f, 0.09995382f, -0.06986706f, -0.14833327f, 0.04022574f, -0.11056814f, 0.06036816f, 
    -0.14111410f, 0.06448580f, 0.10535055f, 0.31044936f, -0.15662086f, 0.02269148f, -0.02603511f, 0.17987189f, 
    0.14514427f, 0.09262929f, -0.16981766f, -0.04590377f, -0.10449485f, 0.42633823f, 0.18012775f, 0.69869298f, 
    0.08024523f, -0.18509693f, 0.07095775f, 0.00812764f, 0.33674350f, 0.04155514f, -0.02370861f, -0.23166898f, 
    0.17512475f, 0.53887486f, 0.04751766f, 0.07045785f, 0.16657528f, 0.09226499f, -0.21340682f, 0.14029740f, 
    -0.23495138f, 0.08594920f, 0.23043492f, 0.15185784f, -0.04673825f, -0.15033142f, -0.15771060f, -0.32892489f, 
    0.10806216f, 0.24744429f, -0.02603878f, 0.03872579f, 0.09901959f, 0.02158881f, 0.16336298f, -0.07701771f, 
    -0.23221208f, 0.01494005f, 0.11160222f, 0.13791689f, -0.01001284f, -0.34728238f, 0.16879730f, 0.01172171f, 
    -0.04805794f, 0.21653576f, 0.04277810f, 0.08733730f, -0.26446149f, 0.18357901f, -0.12960324f, -0.14009906f, 
    0.13581213f, 0.13277505f, -0.12154528f, -0.00578919f, 0.04327158f, -0.16559514f, 0.24864952f, -0.05703253f, 
    0.09686490f, -0.31741199f, -0.22211610f, 0.08291885f, 0.15649360f, 0.44302118f, 0.28468186f, -0.20989281f, 
    0.21248789f, 0.20780236f, -0.00589243f, -0.11036449f, 0.04892929f, -0.09233610f, -0.09886144f, 0.13061704f, 
    0.42817813f, 0.37648636f, -0.01207971f, -0.27229530f, -0.05428160f, 0.16069779f, 0.05640152f, -0.01431252f, 
    -0.07610518f, 0.12607312f, -0.15591986f, 0.65123779f, -0.13790689f, 0.07533646f, -0.08927434f, -0.02150758f, 
    -0.09047813f, -0.14162929f, 0.00784540f, 0.23196249f, -0.06091995f, 0.54962516f, -0.01640072f, -0.03141011f, 
    -0.29350406f, -0.22639573f, -0.37228468f, 0.27476138f, -0.41372406f, 0.37487322f, -0.10149406f, -0.12965861f, 
    0.18906836f, -0.16120955f, 0.08550906f, -0.20655213f, -0.03678964f, -0.42760792f, 0.37626815f, -0.09475847f, 
    -0.07303458f, 0.39424476f, -0.12533845f, 0.18783469f, -0.13955298f, -0.09027291f, 0.09379312f, 0.20300013f, 
    -0.16353323f, 0.08004347f, -0.51265711f, 0.32367653f, -0.01733845f, 0.09314498f, -0.11196952f, 0.44284478f, 
    -0.16664046f, 0.19943868f, -0.11267926f, 0.01437256f, -0.25684980f, -0.14904685f, -0.06833724f, -0.15347496f, 
    -0.10684671f, -0.10525792f, -0.12031515f, 0.09789176f, 0.03298198f, -0.20960505f, -0.22019486f, -0.01985467f, 
    -0.10885869f, -0.20464213f, -0.16544098f, -0.11807351f, -0.15224676f, -0.03981436f, 0.06530371f, -0.08699793f, 
    0.09267196f, -0.09423818f, -0.10412213f, -0.00836854f, -0.01903516f, 0.00541308f, -0.10171720f, -0.02212022f, 
    0.12140780f, 0.02338843f, -0.21068954f, -0.18646741f, 0.12270458f, 0.06199881f, -0.07821241f, 0.00273258f, 
    0.17746830f, 0.00136210f, -0.09721443f, -0.09458558f, 0.01932625f, 0.15830314f, -0.17119399f, -0.07454582f, 
    0.24917753f, -0.18672664f, 0.00630936f, 0.04148690f, 0.24053094f, 0.03783131f, 0.06172755f, -0.05513969f, 
    -0.08058667f, -0.06894584f, -0.50437778f, -0.07281855f, 0.12247179f, 0.07002979f, -0.08702856f, 0.15919454f, 
    -0.09996054f, 0.14177811f, 0.14352907f, 0.14767694f, -0.17298393f, 0.16341406f, -0.09009150f, 0.07761469f, 
    -0.13434811f, -0.31070799f, -0.02020299f, -0.25713980f, 0.37929124f, -0.39715052f, 0.22014466f, 0.07193591f, 
    -0.18576722f, 0.28193375f, -0.04274308f, 0.23777357f, 0.07453822f, 0.10583434f, 0.12837431f, 0.19529259f, 
    -0.14440863f, 0.55895215f, -0.04407852f, 0.30118498f, 0.03071912f, -0.12893602f, -0.03870323f, 0.34957147f, 
    -0.15894324f, 0.08377035f, -0.04872850f, -0.00081700f, 0.02407421f, -0.01813794f, -0.14269437f, -0.24522494f, 
    0.16454661f, 0.19055851f, 0.07264428f, -0.15606381f, 0.03581865f, -0.25701788f, 0.03738255f, 0.03190960f, 
    -0.07931781f, 0.21906400f, -0.13355120f, 0.32221958f, -0.25727320f, -0.02152147f, 0.06742213f, -0.02977294f, 
    -0.09250849f, -0.00069526f, 0.71355927f, 0.30136335f, -0.08020267f, 0.03942725f, -0.30534413f, -0.69537175f, 
    -0.32762694f, -0.24837841f, 0.06884045f, 0.10146611f, 0.14785159f, -0.11837709f, 0.13952981f, -0.24614036f, 
    0.26434723f, 0.01749622f, 0.05437054f, -0.03317470f, -0.15717921f, 0.04871099f, 0.03517156f, -0.30375022f, 
    -0.02223722f, 0.06771167f, 0.26084954f, 0.44944787f, -0.17745849f, -0.02367989f, 0.21275185f, 0.24287498f, 
    -0.11555930f, -0.47850147f, 0.22280265f, 0.07993500f, 0.10165554f, -0.02483969f, -0.17798927f, 0.06651936f, 
    0.20379770f, -0.28280097f, 0.01425572f, -0.16397947f, -0.11995640f, 0.01249634f, 0.06131900f, -0.11359902f, 
    -0.12010587f, 0.19729446f, -0.00472675f, 0.07089160f, 0.17107183f, -0.10217623f, -0.04840353f, 0.33856249f, 
    0.05571842f, -0.28239387f, -0.09550978f, -0.12513506f, -0.37179387f, -0.17497034f, 0.28409117f, -0.37435433f, 
    0.06547829f, -0.35213158f, 0.14494692f, -0.10760074f, 0.14566840f, 0.17887913f, 0.18102171f, -0.00834490f, 
    0.30169588f, 0.24223131f, 0.23013996f, 0.34757826f, 0.44075170f, -0.26081416f, -0.00915033f, -0.11233210f, 
    0.26179346f, -0.00538065f, -0.13037725f, 0.03429153f, 0.02310727f, -0.21556671f, 0.37114254f, 0.07422753f, 
    0.05166474f, -0.02603638f, 0.16317344f, 0.18026289f, -0.23485762f, 0.01805043f, -0.08965174f, 0.39141211f, 
    0.06957185f, 0.13757594f, 0.43958363f, -0.22515573f, 0.06904852f, -0.28839147f, -0.22215568f, 0.20949739f, 
    0.21367705f, 0.03383582f, 0.21506414f, 0.08377329f, 0.55341363f, -0.06507693f, 0.15151428f, -0.16004153f, 
    -0.29118979f, -0.44858766f, 0.08338419f, 0.01659963f, 0.10533170f, -0.17038126f, -0.03583375f, -0.29681540f, 
    0.03424077f, -0.03089550f, 0.22765668f, -0.05872272f, 0.33803347f, -0.06033333f, 0.19722004f, -0.12660883f, 
    0.04100616f, 0.11314625f, -0.13936822f, 0.21366677f, -0.10528403f, -0.10388180f, 0.24356449f, 0.38635731f, 
    0.07032916f, 0.52802235f, 0.11859650f, 0.12001699f, 0.65656936f, -0.27518579f, -0.03076283f, -0.32365382f, 
    0.00691906f, -0.06538738f, 0.08637108f, 0.11464273f, -0.12585109f, -0.12345846f, -0.12412021f, -0.03289947f, 
    -0.02465869f, 0.03869939f, -0.12231286f, 0.01516192f, -0.20675130f, -0.10905225f, -0.08993075f, -0.04062840f, 
    0.12379830f, -0.08213510f, -0.09988979f, -0.17731993f, -0.17549448f, 0.09205423f, 0.00890611f, 0.06778555f, 
    0.05569320f, 0.01859314f, -0.03638034f, -0.08459068f, -0.14977348f, 0.05931921f, 0.16774043f, -0.18790728f, 
    0.52449435f, 0.33051902f, 0.03588697f, 0.09670483f, 0.15650168f, 0.18107262f, -0.13963509f, 0.05749177f, 
    0.15686968f, -0.03869595f, -0.04189182f, 0.23567119f, 0.17622937f, 0.08496653f, -0.19288447f, 0.00062145f, 
    0.05916779f, -0.45114735f, -0.37208065f, -0.15628989f, 0.10131928f, 0.54741597f, -0.08353421f, 0.11744270f, 
    0.07639115f, 0.01457589f, -0.23479226f, -0.04378355f, -0.28838000f, -0.03701447f, -0.08807693f, 0.02869852f, 
    0.02927551f, 0.28192347f, -0.03832838f, 0.22368345f, 0.05840491f, -0.26449317f, 0.31366852f, 0.05500688f, 
    0.00061290f, -0.02449278f, 0.23933215f, 0.59086603f, -0.03700121f, -0.12722681f, -0.11585366f, 0.15124121f, 
    0.03411569f, 0.20685343f, -0.06980958f, 0.06315888f, 0.15565595f, -0.27966684f, -0.05696651f, 0.09929877f, 
    0.21571398f, -0.24522738f, -0.02926525f, 0.27088207f, -0.32482475f, -0.18023202f, -0.03933462f, -0.24289107f, 
    0.15261494f, 0.17173524f, -0.17684606f, 0.02281808f, -0.12081644f, -0.02188400f, -0.07056913f, 0.04803280f, 
    -0.11011145f, -0.05406729f, 0.00093753f, 0.03614498f, -0.20792192f, -0.05105075f, 0.02364825f, -0.06064759f, 
    -0.13785008f, -0.01249217f, -0.14624536f, -0.04054011f, 0.09971217f, -0.03943433f, 0.03183340f, -0.19089164f, 
    0.14144281f, -0.08722311f, -0.06435367f, 0.12785509f, 0.13819607f, -0.14571308f, -0.03887958f, 0.01525959f, 
    0.03117354f, 0.28928170f, -0.08362316f, -0.11338637f, 0.25829998f, -0.17888427f, -0.23614351f, 0.42113677f, 
    -0.11159847f, 0.03739970f, 0.04500642f, -0.05730317f, -0.50223994f, -0.06979783f, -0.13027319f, -0.18034168f, 
    0.05382545f, 0.20602791f, 0.10866316f, -0.15521827f, -0.13752910f, 0.27565029f, -0.10625593f, 0.24275263f, 
    -0.23364393f, 0.13779487f, 0.33827353f, 0.35757276f, 0.26481810f, 0.13550875f, 0.16757868f, -0.09191090f, 
    0.22304544f, 0.09787408f, 0.03131923f, -0.04156358f, -0.07094706f, 0.16659522f, 0.12025931f, 0.03718270f, 
    0.36862016f, 0.14518622f, 0.20056242f, 0.21390675f, -0.05562777f, 0.15701433f, 0.20136854f, 0.09917425f, 
    0.02032301f, -0.45883533f, -0.08341933f, -0.00293960f, 0.04212122f, 0.14437631f, -0.06879333f, -0.04808678f, 
    0.38468891f, -0.17627600f, 0.01503989f, 0.26243284f, -0.30451003f, -0.28436390f, 0.07136323f, -0.06847591f, 
    0.10647764f, -0.11061806f, 0.01221372f, 0.08832099f, -0.16667300f, -0.05154262f, -0.06816984f, 0.00136390f, 
    -0.03402595f, 0.06574144f, 0.06384813f, -0.00310921f, -0.12813392f, -0.08277034f, -0.15194911f, -0.12310463f, 
    0.08075343f, 0.14073056f, 0.07158550f, 0.11646878f, -0.00304536f, -0.05336285f, -0.09307735f, -0.17271197f, 
    0.02804696f, -0.01299486f, -0.18170786f, -0.14822949f, 0.01509801f, -0.21528980f, 0.07833064f, -0.05439619f, 
    -0.25875750f, -0.11212105f, -0.10722926f, -0.37825578f, -0.13788837f, -0.01198551f, 0.08194530f, -0.17694078f, 
    -0.01917416f, 0.14478292f, 0.21447305f, 0.00708475f, -0.10130575f, 0.07303425f, -0.15365347f, 0.00317671f, 
    0.16682778f, -0.06011034f, 0.36128452f, 0.06297778f, -0.06559617f, 0.21287683f, -0.23546492f, -0.15963788f, 
    -0.07482945f, 0.12762016f, 0.07566484f, 0.02268890f, -0.02984243f, 0.29236603f, -0.08263311f, 0.08286528f, 
    0.13231075f, 0.55882102f, -0.15862280f, -0.09010225f, -0.01018709f, -0.01183864f, 0.12288605f, -0.06930802f, 
    0.03970129f, 0.05247303f, 0.11410616f, -0.18114999f, -0.20763431f, 0.02490971f, 0.05227824f, 0.19194724f, 
    0.15217690f, -0.47678125f, -0.05133608f, 0.19478676f, 0.03773225f, 0.25075203f, 0.07142129f, -0.07416470f, 
    0.28027996f, -0.36447272f, 0.01895528f, 0.20334049f, -0.30247721f, -0.07160911f, -0.11372302f, 0.20583488f, 
    0.43033150f, 0.14916584f, -0.16842014f, -0.03241548f, 0.10104774f, 0.08231651f, 0.17528456f, 0.04116426f, 
    0.25082180f, -0.14260513f, -0.20526443f, -0.05917303f, 0.01210683f, -0.01138764f, -0.00700228f, 0.01045119f, 
    -0.10171983f, 0.09245344f, 0.17649791f, -0.17059939f, -0.05458618f, 0.07828584f, -0.17929986f, -0.24230430f, 
    0.24712206f, 0.02855072f, -0.01233195f, 0.12768425f, 0.14330281f, 0.10212577f, 0.02978269f, -0.14548199f, 
    -0.02922094f, -0.01800005f, 0.10584582f, -0.05718195f, 0.01223880f, -0.01799330f, -0.15417144f, 0.00292665f, 
    0.00089251f, -0.06752332f, 0.07693651f, -0.08558460f, 0.14802848f, 0.01848818f, 0.12879790f, 0.09919656f, 
    -0.06074553f, -0.20467557f, -0.04450045f, -0.15869687f, -0.16748561f, 0.02668700f, -0.08787698f, -0.10982060f, 
    -0.18325686f, 0.15651323f, -0.07470832f, -0.12730180f, -0.00582872f, -0.12042140f, -0.16082531f, -0.12069208f, 
    0.39725122f, 0.15902747f, -0.00515187f, -0.17042215f, 0.13992724f, -0.17738403f, 0.15820493f, -0.01487394f, 
    0.08018016f, 0.19430842f, -0.11206504f, 0.74501199f, 0.09108159f, -0.09304994f, 0.02046620f, 0.17734747f, 
    0.09407568f, 0.53905523f, 0.34101969f, 0.26032230f, 0.07983547f, -0.09018272f, -0.27704322f, -0.36397859f, 
    -0.20427454f, -0.31724408f, -0.32000488f, 0.02182864f, 0.03827561f, -0.46668860f, -0.16238582f, -0.32828280f, 
    -0.37202677f, -0.78320259f, 0.14860791f, 0.18745780f, 0.04514826f, -0.12283046f, -0.12461282f, -0.07913580f, 
    0.14427176f, 0.04714304f, -0.14575064f, -0.62303901f, 0.05611334f, -0.07131404f, 0.36085656f, -0.05090464f, 
    -0.01022024f, 0.06478816f, 0.01316138f, 0.01460779f, -0.01032750f, -0.15441483f, 0.16634385f, -0.33615306f, 
    0.21233884f, 0.36362812f, -0.11846323f, -0.29731211f, 0.41468975f, -0.17533895f, 0.10634001f, -0.04409572f, 
    -0.09639857f, 0.46570599f, 0.15983275f, 0.13591726f, 0.21862268f, -0.14722905f, -0.12730043f, 0.17902412f, 
    0.17668486f, 0.10915530f, 0.08348527f, -0.01193036f, 0.13329430f, -0.01139395f, 0.09178220f, -0.20617524f, 
    0.07461252f, 0.59355277f, -0.22926030f, -0.12873487f, -0.01866528f, 0.25371897f, 0.17146385f, 0.01816501f, 
    0.09896205f, -0.19584450f, -0.08086695f, 0.20799786f, -0.25856346f, -0.15565915f, 0.10306431f, -0.04078718f, 
    -0.16678211f, 0.00945392f, -0.12983996f, -0.01518922f, 0.01340366f, -0.16019253f, 0.06667456f, 0.35282674f, 
    -0.07918087f, 0.02331832f, -0.09192393f, -0.11909717f, -0.00175612f, 0.10288328f, -0.12426507f, 0.22452462f, 
    -0.10892202f, 0.40726334f, 0.45871940f, 0.00508065f, 0.02653022f, 0.25148746f, 0.01916630f, -0.08675957f, 
    -0.02588292f, 0.00331893f, 0.07257002f, -0.14688396f, 0.39113346f, 0.36430180f, -0.05185303f, -0.08687201f, 
    -0.09691183f, 0.02430270f, -0.17340896f, 0.08629401f, 0.17262724f, -0.01512618f, 0.07147921f, 0.29410401f, 
    -0.11011937f, 0.00894011f, -0.02362425f, -0.46097243f, 0.05812901f, -0.03918587f, 0.02926212f, -0.20958976f, 
    -0.01124172f, 0.20402132f, 0.25889626f, 0.17997037f, 0.01467709f, -0.14523189f, 0.18568152f, -0.57208186f, 
    -0.23510516f, 0.15132506f, -0.09568311f, 0.23873369f, -0.10995262f, 0.31893215f, -0.03086858f, 0.22770841f, 
    -0.01813317f, 0.07115109f, -0.14089756f, 0.22015873f, 0.16663133f, -0.15658012f, 0.04294536f, 0.03297504f, 
    -0.05000966f, -0.11497533f, -0.00628448f, -0.47477055f, -0.05412555f, 0.01055830f, -0.01810308f, -0.06427001f, 
    -0.06128542f, 0.53735691f, 0.27621359f, 0.17079107f, -0.00673411f, -0.11506429f, -0.07590377f, -0.44874334f, 
    0.18888633f, 0.30718473f, 0.03070728f, -0.21667744f, 0.39545450f, 0.17089564f, 0.06298614f, 0.21471706f, 
    -0.35848257f, -0.42447785f, -0.02906072f, -0.12791333f, -0.00860992f, -0.13611475f, 0.20474836f, 0.12940139f, 
    0.17399763f, 0.20093955f, -0.36375529f, -0.33345643f, 0.07863218f, -0.11500175f, 0.09324045f, 0.01889111f, 
    -0.05518098f, -0.12294247f, 0.13437699f, -0.01745615f, 0.13207245f, 0.27506551f, 0.21175162f, 0.01764169f, 
    -0.34302011f, 0.18018608f, 0.06139689f, 0.31456825f, -0.14908609f, 0.25244239f, -0.15400124f, 0.10475269f, 
    -0.14412434f, -0.16316473f, -0.07012306f, 0.12596051f, -0.19761778f, 0.01077607f, 0.00206392f, -0.06704653f, 
    -0.07177317f, -0.22999039f, -0.20246969f, -0.04056161f, -0.12599823f, -0.09433284f, -0.00680263f, -0.11734126f, 
    0.06443927f, 0.17253777f, 0.07868574f, 0.08833872f, -0.03893534f, -0.04883575f, -0.06416150f, 0.02643257f, 
    -0.20707951f, -0.12196742f, 0.05221005f, -0.09772485f, 0.12890492f, -0.06194065f, -0.00208355f, -0.14018559f, 
    -0.17020136f, -0.26062113f, 0.12899102f, -0.24069488f, -0.15309456f, -0.08489431f, 0.04466322f, 0.13256979f, 
    0.18681297f, -0.07092047f, -0.01819462f, -0.23905541f, -0.18685399f, 0.02619478f, 0.19548918f, -0.01750076f, 
    -0.11553615f, -0.47993422f, 0.61009061f, 0.14553750f, -0.15945974f, -0.07123632f, 0.17693493f, 0.11065865f, 
    0.01119603f, -0.07313050f, 0.27881542f, 0.15987425f, -0.03182571f, -0.14595428f, 0.15130232f, -0.03145987f, 
    -0.07057340f, -0.14907713f, -0.02367949f, -0.04890295f, -0.18153313f, -0.21086557f, -0.18922228f, -0.18147160f, 
    -0.16125508f, -0.08197867f, -0.15124261f, 0.02181013f, -0.21023084f, -0.11290013f, 0.15245898f, -0.02888175f, 
    0.02397799f, 0.09690386f, -0.21642619f, 0.08922034f, -0.08965488f, 0.02114066f, -0.18225798f, 0.03812855f, 
    0.10720866f, 0.11703946f, -0.19620153f, 0.01955441f, 0.10525293f, 0.10136361f, 0.17228499f, 0.11575148f, 
    0.12311804f, -0.21196137f, -0.10277516f, -0.18165784f, -0.00594842f, -0.11195326f, -0.20101537f, 0.00456995f, 
    -0.18164127f, -0.04853381f, -0.15999915f, -0.18706511f, -0.07358126f, -0.03245370f, 0.08942163f, -0.16179614f, 
    0.03644258f, -0.14927363f, -0.11684451f, 0.02262256f, 0.10099305f, -0.04829186f, -0.17089872f, -0.14024737f, 
    -0.03308564f, -0.15656273f, -0.09037249f, 0.04736255f, -0.16251458f, 0.02612151f, -0.12132577f, 0.03625589f, 
    -0.03726157f, -0.03539146f, 0.05098692f, -0.15668683f, -0.14165683f, 0.10430154f, -0.00702549f, 0.00337267f, 
    -0.11855803f, -0.14852366f, -0.16116112f, -0.21566175f, 0.05001095f, -0.13196065f, -0.09767812f, -0.12399708f, 
    0.07919890f, 0.14150052f, -0.07699659f, -0.09624327f, -0.12272015f, 0.05391752f, -0.05978515f, -0.08289596f, 
    -0.05274864f, 0.03416583f, -0.22236460f, 0.14108279f, 0.18057504f, -0.03851529f, -0.03067545f, -0.09336867f, 
    0.23386304f, -0.04006793f, -0.16874009f, -0.18483454f, 0.31872758f, 0.02239584f, 0.30462992f, -0.02702994f, 
    -0.34345210f, 0.14965588f, -0.03500681f, -0.13013206f, -0.04761742f, -0.15132704f, -0.12681931f, 0.12730493f, 
    0.15370439f, 0.30661198f, -0.16804263f, 0.30305964f, -0.04183334f, -0.18071833f, 0.13042967f, 0.05453884f, 
    -0.10527888f, 0.25480023f, -0.16482860f, -0.20473294f, 0.00491445f, 0.09901712f, 0.03926908f, 0.06862327f, 
    -0.06851423f, -0.07058340f, 0.17316701f, 0.08305968f, -0.22454916f, -0.12487965f, -0.09266346f, 0.04083194f, 
    0.01743103f, -0.17968713f, -0.17168778f, 0.07927637f, -0.01457027f, 0.04742789f, -0.11151866f, -0.00708669f, 
    -0.13309421f, 0.01181133f, -0.01830700f, 0.01673219f, -0.08212615f, -0.17495726f, -0.14840013f, -0.03183344f, 
    -0.04018426f, 0.11010680f, -0.08491461f, 0.09479155f, 0.02982560f, -0.00837754f, 0.14857128f, -0.22518136f, 
    0.04178007f, -0.07447841f, -0.07368614f, -0.13585058f, -0.17460451f, 0.03307752f, 0.00689664f, -0.08826591f, 
    0.01192006f, 0.09261321f, -0.15293221f, 0.02944613f, -0.11351845f, 0.15893199f, -0.11969583f, 0.05014206f, 
    -0.12308856f, 0.09648380f, -0.08053768f, -0.07060535f, -0.06823140f, -0.10820681f, -0.08120720f, 0.16896270f, 
    -0.03302368f, -0.15026768f, 0.10668634f, 0.00604552f, 0.05458702f, -0.10694324f, -0.13809824f, -0.15236929f, 
    0.45403859f, 0.07639416f, -0.12794553f, 0.10395952f, 0.23345758f, 0.22769000f, 0.08901602f, -0.15877886f, 
    -0.11804841f, -0.17007972f, 0.10494366f, 0.27120006f, 0.30342188f, 0.11686777f, 0.15291089f, 0.24664730f, 
    -0.12667981f, 0.35664031f, -0.24280037f, 0.22159888f, -0.15747437f, -0.26986319f, -0.20543993f, -0.18668544f, 
    0.03062463f, 0.29960656f, -0.16204895f, -0.05790872f, 0.64331359f, -0.02840871f, 0.04189720f, -0.25302142f, 
    -0.26348037f, -0.28094387f, 0.11782335f, -0.21835670f, 0.34486747f, -0.72702390f, 0.17627528f, -0.11969022f, 
    0.01651515f, 0.06603853f, -0.18586135f, -0.00769264f, 0.05420379f, 0.01389877f, 0.09009783f, -0.12661341f, 
    -0.03067184f, -0.08886788f, 0.31794450f, 0.26504943f, 0.12594165f, -0.17919156f, 0.13023929f, -0.26826555f, 
    -0.26348338f, 0.04594373f, -0.05218437f, 0.49464202f, -0.40735573f, -0.40273008f, -0.06897259f, -0.06415837f, 
    0.24171944f, 0.51530343f, -0.03321292f, 0.05420191f, 0.27175468f, -0.30872279f, 0.08911016f, 0.16921227f, 
    -0.02370781f, 0.06955397f, 0.02848900f, 0.06575587f, -0.35665342f, -0.06676293f, -0.20317322f, -0.16926031f, 
    0.12852252f, -0.29489866f, 0.03665632f, 0.15018846f, -0.14939423f, -0.18073790f, 0.12197936f, -0.70922750f, 
    0.00289482f, 0.05180187f, -0.04142653f, 0.21104169f, -0.24386469f, -0.23036328f, -0.01199786f, -0.02380330f, 
    -0.26562139f, -0.13660944f, 0.11461467f, -0.10275395f, -0.10753314f, 0.08745369f, 0.01146896f, 0.19088541f, 
    -0.22189738f, 0.00140047f, 0.17615435f, 0.49376562f, 0.06202680f, -0.16210897f, 0.05718936f, 0.19786444f, 
    -0.08001169f, 0.20173141f, 0.41101018f, 0.04831126f, 0.06763370f, -0.10978052f, 0.03927836f, 0.47986314f, 
    -0.11638583f, -0.29270968f, 0.15068960f, 0.06161243f, 0.16342391f, -0.10083248f, 0.05241668f, -0.27305323f, 
    -0.20916639f, 0.55945224f, 0.10895474f, 0.25715163f, -0.02819262f, 0.08624530f, -0.16829023f, -0.02648216f, 
    -0.17998502f, 0.12776299f, 0.19535361f, 0.42146924f, 0.32084087f, 0.18618496f, 0.06958921f, -0.11047678f, 
    0.15291457f, 0.15655538f, 0.03022478f, 0.14430684f, 0.02213520f, -0.03571590f, -0.15942760f, 0.14129801f, 
    -0.02822482f, -0.11257517f, -0.04173398f, 0.03009937f, -0.20591018f, -0.01152447f, -0.01684974f, -0.08549995f, 
    -0.05751812f, -0.35259622f, 0.04347562f, 0.00058766f, 0.00259253f, -0.15450008f, 0.00689277f, 0.16009974f, 
    0.09136363f, 0.05151506f, -0.17940462f, -0.28154865f, 0.20432068f, -0.01621115f, 0.23120569f, -0.04796939f, 
    -0.15483063f, 0.11973942f, 0.01983889f, 0.04711410f, -0.00104317f, 0.09624620f, -0.04967462f, 0.13310355f, 
    -0.26754287f, 0.27132964f, 0.06113501f, -0.29725206f, 0.32330492f, 0.25217295f, -0.16170464f, 0.11670555f, 
    -0.07140265f, -0.15253359f, -0.10976074f, 0.04201462f, -0.12224083f, 0.10684939f, 0.16191457f, -0.07475113f, 
    -0.12176108f, -0.17940232f, -0.11391973f, -0.04731627f, -0.18573248f, 0.09433139f, 0.13536151f, 0.11645997f, 
    0.15820196f, -0.20401669f, 0.11378189f, -0.00114448f, -0.15842958f, -0.04941935f, -0.16054146f, -0.05018751f, 
    0.03308288f, -0.06926938f, -0.02728686f, -0.17238601f, -0.02312178f, 0.06271645f, -0.02609400f, -0.16099323f, 
    0.04077399f, 0.20374013f, 0.11468404f, -0.34323233f, 0.13132641f, 0.09930466f, 0.12772079f, 0.21437187f, 
    -0.21433464f, 0.02308270f, -0.26284277f, 0.26025420f, 0.12170414f, -0.17599340f, -0.13598531f, 0.20537581f, 
    -0.13310570f, -0.34128672f, -0.05788198f, 0.04735017f, 0.12158182f, 0.16301310f, 0.08396465f, 0.42334387f, 
    -0.30174273f, -0.20349684f, -0.11953756f, 0.03180688f, -0.11585109f, 0.21582605f, 0.06908576f, 0.07677728f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07664101f, 0.10423920f, 0.34987414f, 0.06477504f, 0.30800912f, -0.02014608f, 0.17928310f, -0.02128294f, 
    0.09290996f, 0.14190736f, 0.05145309f, 0.06485379f, 0.21028498f, 0.07155243f, 0.28993699f, 0.41993105f, 
    -0.13457489f, 0.13157886f, -0.13823850f, 0.06156435f, -0.00089136f, 0.04362862f, 0.06395879f, -0.21584430f, 
    0.23332512f, 0.21659601f, 0.27423874f, 0.20899639f, 0.17894307f, 0.09370500f, -0.19248322f, 0.02980756f, 
    0.19299982f, -0.20347667f, 0.31043139f, 0.24671459f, 0.00601270f, 0.18710604f, 0.09762084f, 0.21192029f, 
    -0.10472114f, 0.20450102f, -0.13811766f, 0.08189639f, 0.33149529f, 0.13298716f, 0.02543442f, 0.16611636f, 
    -0.15583842f, 0.43886834f, -0.10949889f, 0.10518476f, 0.04954914f, -0.14928821f, -0.15751116f, -0.05933456f, 
    0.06511319f, 0.23600608f, 0.10015009f, 0.03981310f, 0.09308229f, 0.12994985f, -0.19418748f, -0.01670855f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.31872457f, -0.06014445f, 0.40910572f, -0.34321097f, -0.12345538f, -0.51630640f, -0.45520839f, -0.06952645f, 
    -0.44398767f, -0.02332606f, 0.06915863f, -0.18871693f, -0.25930664f, 0.22818671f, -0.32968286f, -0.16176553f, 
    0.07025830f, -0.13577707f, -0.05183257f, 0.19697206f, 0.05711712f, 0.23306148f, 0.02825411f, -0.02138575f, 
    0.18485154f, -0.60132504f, -0.08387313f, -0.10661549f, -0.29027718f, 0.22566798f, -0.05247884f, -0.00793040f, 
    -0.22073659f, -0.06505892f, -0.61670321f, -0.36931765f, 0.06423648f, -0.03545126f, -0.23366666f, -0.23275681f, 
    0.10098643f, -0.31460077f, 0.40160862f, 0.06138788f, -0.09187335f, 0.08040138f, 0.21603589f, 0.01420763f, 
    -0.02548477f, -0.31109753f, 0.01255992f, 0.04025828f, 0.03474647f, 0.13643041f, -0.04769330f, 0.04738843f, 
    0.06883519f, 0.01823016f, -0.24182737f, -0.16537708f, 0.08573860f, 0.26526999f, -0.07377873f, -0.06779461f, 
    -0.01051722f, 0.02882022f, 0.37341529f, -0.33044595f, 0.16572808f, -0.68960381f, -0.02371969f, -0.11655817f, 
    -0.09293608f, 0.02737341f, 0.08558141f, -0.31671470f, 0.03079765f, -0.08627730f, 0.15227908f, 0.26210871f, 
    -0.01494641f, -0.14804988f, -0.40748990f, 0.05532965f, 0.61092365f, -0.55841029f, -0.05965922f, 0.03495001f, 
    -0.30555883f, -0.41074875f, -0.21793248f, 0.38087499f, 0.04128021f, 0.20521198f, -0.01794351f, 0.17153469f, 
    -0.25804853f, -0.00825482f, 0.17407858f, -0.04017469f, -0.03267121f, -0.14469600f, -0.18486893f, 0.14729244f, 
    0.03103882f, -0.97351050f, 0.48371115f, -0.11706999f, 0.05216717f, 0.04405262f, 0.11389775f, 0.18981136f, 
    0.00895806f, 0.19623573f, -0.08468155f, -0.09177759f, -0.08060518f, -0.13023998f, 0.00813469f, 0.08614317f, 
    -0.02501723f, -0.03920104f, -0.28075799f, -0.22851709f, -0.21563204f, 0.14268236f, -0.06565827f, 0.10664973f, 
    -0.97696644f, 0.13523631f, 0.30189952f, 0.08450814f, 0.21214765f, 0.11937974f, -0.06856778f, 0.10074441f, 
    0.21749647f, 0.18539414f, -0.13814330f, 0.05828070f, -0.06014932f, -0.09473027f, -0.09693424f, -0.00345778f, 
    -0.27866027f, -0.33823648f, -0.24382696f, -0.24892770f, -0.38055131f, -0.20469293f, -0.06341307f, 0.14988448f, 
    -0.01229878f, 0.43528861f, -0.27324829f, -0.07944774f, 0.01581421f, -0.45643267f, 0.08242805f, -0.45908725f, 
    -0.03252235f, -0.02705235f, -0.09394369f, -0.01846293f, 0.06205063f, 0.12818323f, -0.05592082f, -0.01743359f, 
    -0.07461461f, 0.31351215f, -0.16330194f, 0.05528439f, 0.01617457f, 0.25874981f, 0.06359673f, 0.23203097f, 
    -0.03089055f, 0.36813074f, -0.00325270f, 0.00299093f, -0.02059713f, -0.07913311f, -0.07149756f, 0.09004973f, 
    -0.31194082f, 0.42205688f, 0.26314744f, -0.00028079f, 0.04947237f, -0.06053085f, 0.01236019f, -0.11160638f, 
    -0.01362871f, 0.10270355f, 0.02282470f, 0.53844059f, -0.67839515f, 0.25005680f, -0.16551654f, -0.03753207f, 
    0.23286276f, 0.37913814f, 0.15158938f, 0.02246939f, -0.04029548f, 0.26712763f, -0.20955314f, 0.08392525f, 
    0.02086390f, -0.46127912f, -0.05850652f, 0.08456032f, -0.01545641f, 0.15232043f, 0.02812777f, 0.50563705f, 
    -0.00009466f, 0.01912936f, -0.01750015f, -0.13420826f, -0.52640206f, 0.08470496f, -0.09929895f, 0.21073003f, 
    0.10747267f, 0.04263179f, -0.52585465f, 0.21335067f, -0.11424909f, -0.19773798f, 0.02165547f, -0.17506507f, 
    -0.00410887f, 0.15309225f, -0.13379373f, 0.01837072f, -1.14570189f, 0.09698182f, -0.19494687f, 0.13484448f, 
    0.10695039f, 0.03908339f, -0.03504078f, 0.02402678f, 0.05634841f, 0.00721141f, 0.01779802f, 0.03821908f, 
    0.01712884f, 0.32670894f, 0.17118123f, -0.37169299f, 0.14658374f, -0.15960900f, 0.04585046f, -1.02433896f, 
    -0.01562286f, -0.06872374f, -0.51436096f, -0.50596815f, 0.04733162f, 0.44497678f, 0.22777529f, -0.06712007f, 
    -0.45863256f, -0.10266179f, -0.13531326f, -0.27973199f, -0.28697753f, 0.07474955f, 0.06001821f, 0.10423053f, 
    0.28798991f, -0.11837970f, -0.07991445f, -0.18283089f, -0.74111241f, 0.01829136f, 0.07060132f, 0.05452294f, 
    0.23742765f, -0.00289868f, -0.11450126f, -0.30448595f, 0.08284266f, 0.06507973f, -0.04576680f, 0.03509955f, 
    0.21173292f, 0.10904749f, -0.11999361f, -0.06695148f, -0.09063451f, -0.09663684f, -0.31264117f, 0.14320518f, 
    -0.11198249f, 0.44944483f, -0.00458680f, 0.18355995f, -0.01497717f, -0.07357689f, -0.00642753f, 0.02252265f, 
    -0.13008836f, -0.52991277f, -0.06114529f, -0.11918526f, 0.06000670f, 0.05549614f, -0.06986770f, -0.07064784f, 
    0.18738735f, 0.04242821f, -0.24853933f, -0.02849618f, 0.07876778f, -0.02490245f, -0.16229035f, -0.06868969f, 
    0.03360980f, 0.04115918f, -0.83792132f, -0.43782535f, -0.11799438f, -0.50852716f, 0.17684902f, 0.06463245f, 
    0.39378029f, -0.17751344f, 0.19539976f, -0.07436487f, 0.03844253f, -0.02251857f, 0.20133971f, 0.00931899f, 
    0.03934153f, 0.08918788f, 0.34581029f, -0.18116151f, -0.65741301f, -0.32472920f, 0.00290887f, -0.15319481f, 
    -0.13798732f, -0.05025120f, -0.27896866f, 0.25682420f, 0.05339591f, 0.05671394f, 0.03698823f, 0.00529771f, 
    0.23163964f, 0.06058508f, 0.39869860f, -0.08252673f, -0.01110009f, -0.26014590f, -0.03414513f, -0.03791742f, 
    -0.01230606f, -0.17968340f, -0.34181020f, 0.17175177f, 0.05355043f, 0.12870865f, 0.12802552f, -0.12514530f, 
    -0.01132445f, -0.14913081f, -0.03853417f, 0.00078427f, -0.06292225f, 0.08714347f, 0.03709124f, -0.00588031f, 
    -0.00786203f, 0.02987231f, 0.34135306f, -0.09684194f, 0.11835156f, -0.14976192f, -0.05948743f, -0.15324599f, 
    -0.35918310f, 0.07055976f, 0.52105981f, 0.05040385f, 0.24053229f, 0.22260807f, 0.12205326f, 0.07097923f, 
    -0.82889444f, 0.12365349f, -0.57706833f, 0.12821867f, -0.08639926f, -0.19992754f, 0.10563189f, -0.61047262f, 
    -0.43838862f, -0.00984291f, -0.25025368f, -0.26084372f, 0.20529227f, 0.02685541f, -0.08453801f, -0.34795684f, 
    0.03378456f, 0.37971702f, 0.08968934f, -0.96205819f, 0.03763189f, -0.81273991f, -0.02732928f, -0.56792265f, 
    -0.07019804f, -0.09560453f, 0.19283210f, -0.16030924f, -0.09315123f, 0.41413611f, 0.00056702f, -0.03648959f, 
    0.02452259f, 0.01046598f, -0.14239542f, -0.45273361f, 0.21047159f, 0.06858736f, -0.01423291f, 0.18901856f, 
    -0.07822444f, 0.16797687f, 0.06758531f, -0.07207461f, -0.06197818f, 0.13880567f, -0.04605347f, 0.00550514f, 
    -0.26630792f, -0.88350654f, -0.07479292f, 0.08131515f, -0.21309483f, 0.04031922f, 0.07620931f, 0.11930429f, 
    -0.55164695f, 0.02098756f, -0.99447632f, 0.61314642f, -0.16434105f, 0.46267092f, -0.00737903f, -0.01171456f, 
    -0.58716941f, -0.44691080f, -0.32437015f, 0.07848963f, 0.04049783f, -0.35855097f, 0.20800860f, -0.82528371f, 
    0.29052508f, 0.11740442f, 0.48148647f, 0.11049700f, 0.22656921f, -0.53591418f, 0.05515096f, 0.11406954f, 
    -0.66539544f, 0.20715296f, -0.08940327f, -0.48647386f, -0.24600780f, -0.24684344f, 0.02400784f, 0.07699741f, 
    -0.47224414f, -0.11586881f, 0.10056029f, 0.00565451f, -0.04059875f, 0.01474777f, 0.08719789f, 0.06947342f, 
    -0.11058721f, 0.23545659f, -0.16808289f, 0.04788270f, -0.16801560f, -0.10049896f, 0.06589966f, -0.16673788f, 
    -0.07455633f, -0.46412948f, -0.07696065f, 0.01807318f, 0.00690593f, -0.00229568f, 0.02536042f, 0.04611808f, 
    0.20183311f, -0.51412803f, -0.00262317f, -0.06839406f, 0.12529910f, -0.13407978f, 0.07670144f, 0.09585534f, 
    -0.57818991f, -0.07693598f, -0.14467530f, 0.27965412f, 0.15435523f, -0.81998038f, -0.03930708f, 0.10074663f, 
    0.44923252f, -0.31091362f, 0.19286935f, 0.22700624f, 0.25737780f, -0.22261924f, 0.13863140f, -0.08747285f, 
    0.08175970f, 0.19376235f, 0.00770627f, 0.36380917f, -0.15689602f, -0.34357229f, -0.03830878f, -0.10715857f, 
    -1.12778735f, -0.23650259f, 0.07869834f, 0.17975879f, -0.02799301f, -0.44912300f, 0.00514211f, 0.05294736f, 
    0.16116540f, 0.13898884f, -0.05066676f, 0.29702818f, 0.09513135f, -0.01658306f, 0.18973884f, 0.14905880f, 
    -0.08697926f, -0.63684618f, 0.06206540f, 0.37176314f, -0.11777232f, -0.35182512f, -0.11100017f, 0.08851497f, 
    0.05686547f, 0.12946501f, 0.09257965f, -0.05111967f, 0.02088472f, -0.54881698f, -0.04893906f, -0.05290355f, 
    -0.57484502f, -0.70278025f, 0.01781499f, -0.16358422f, 0.10919895f, -0.24063499f, -0.07596595f, -0.38230643f, 
    -0.14198631f, -0.17258057f, 0.02332413f, -0.04968869f, 0.17271990f, 0.27499452f, -0.34594446f, 0.00826911f, 
    0.23424664f, 0.18555637f, -0.14184970f, 0.16741896f, -0.55572736f, 0.06105461f, 0.03103608f, -0.06642942f, 
    0.32547316f, 0.31716177f, -0.07148668f, -0.13615672f, -0.06861447f, 0.52923584f, 0.01087466f, -0.07537204f, 
    0.30416766f, -0.38388804f, -0.14905106f, -0.38274807f, -0.00652268f, 0.03909506f, 0.05151041f, -0.03063080f, 
    0.04890151f, -0.02807886f, 0.18045044f, 0.00538423f, 0.05381740f, -0.15105334f, -0.05399739f, -0.21326354f, 
    -0.06279943f, -0.24473841f, -0.48142469f, 0.06429173f, -0.15993589f, -0.47192475f, -0.61869943f, 0.26524225f, 
    0.07905067f, 0.06797545f, -0.13058285f, -0.11563402f, 0.07548200f, 0.11195868f, -0.00977684f, 0.12290475f, 
    -0.42052889f, 0.01374491f, -0.38557264f, 0.20662826f, -0.06996128f, 0.06658313f, -0.12659432f, 0.35397303f, 
    -0.60089213f, -0.39045304f, -0.44797480f, 0.11483419f, 0.18049522f, -0.55680281f, -0.05081652f, 0.08014119f, 
    -0.27267280f, 0.22966400f, 0.20676452f, 0.21395227f, 0.16235107f, 0.25764459f, 0.06777395f, 0.32378268f, 
    -0.27352953f, 0.14371651f, 0.01328539f, -0.14398250f, -0.19396418f, -0.64658362f, 0.09304411f, -0.15373817f, 
    -0.25393042f, 0.15150468f, 0.22381957f, 0.02812602f, 0.25896248f, 0.21408060f, -0.03976929f, -0.44555470f, 
    0.23909745f, -0.03679067f, -0.18044822f, 0.06549453f, 0.00544406f, 0.04847337f, -0.24823649f, -0.14012541f, 
    -0.07441577f, 0.13668481f, -0.41539830f, -0.08753446f, -0.24368237f, -0.63546914f, -0.23788330f, -0.62853312f, 
    -0.12550384f, 0.22285339f, -0.12433676f, -0.07695527f, -0.10371414f, -0.54389006f, 0.04008652f, -0.04575482f, 
    0.16452806f, -0.43926784f, -0.50050950f, 0.43626300f, 0.38695067f, -0.20935293f, -0.06050595f, -0.22646455f, 
    -0.18924718f, 0.20616806f, -0.12119559f, 0.09022560f, -0.09597446f, -0.21571018f, 0.30870301f, -0.00227674f, 
    0.08182201f, -0.21091609f, -0.45201778f, -0.01009153f, 0.23091263f, -0.20814604f, -0.02193333f, 0.03137600f, 
    -0.07035710f, -0.08760980f, -0.23660092f, -0.08476756f, 0.02246803f, 0.39242128f, 0.03148123f, -0.27330974f, 
    -0.07546975f, 0.19076398f, 0.26031256f, -0.58396894f, 0.30530536f, -0.35458547f, -0.03193803f, -0.10537121f, 
    0.27040419f, 0.00491869f, -0.24579065f, 0.26362953f, 0.04982610f, -0.20734048f, 0.20473886f, 0.10837653f, 
    0.11228592f, 0.47945511f, -0.32860389f, -0.28660747f, -0.44786432f, -0.61427832f, -0.20960067f, -0.56608623f, 
    0.07049101f, -0.11837999f, 0.03757780f, 0.09050363f, -0.07159521f, 0.20735453f, -0.03595912f, -0.04506390f, 
    0.37085888f, -0.13423079f, 0.27386165f, -0.23143494f, -0.31470090f, -0.50078839f, -0.05037775f, -0.13036305f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16712202f, 0.14408556f, -0.01286516f, -0.07388660f, 0.04514381f, -0.15691359f, 0.01903638f, -0.04444780f, 
    0.16725583f, -0.11742001f, 0.19800641f, 0.01552209f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
