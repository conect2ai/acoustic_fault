#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.80109704f, 0.55353683f, -0.74053222f, -1.32159972f, -1.30064452f, 0.63251191f, -0.02782460f, -0.62841749f, 
    -0.19522825f, -0.14527944f, 0.06322230f, -0.13711144f, 0.55814046f, 0.32028192f, -0.12236428f, 0.14831610f, 
    0.23744902f, 0.34570783f, 0.04322823f, -0.22836928f, -0.11265577f, -0.19914132f, 0.16004933f, -0.27286607f, 
    0.12229553f, 0.98746765f, -0.56401348f, 0.59888345f, 1.36443686f, 0.38393581f, -0.84938061f, -0.27452421f, 
    0.08897609f, -0.07382068f, -0.77133828f, -0.18088478f, -0.64310288f, -0.25287479f, 0.14163794f, 0.51162463f, 
    -0.29846916f, 0.15532207f, 0.37188774f, 0.14158125f, 0.21208724f, -0.24886213f, -0.59310716f, -0.37113127f, 
    -0.52585691f, -0.49021855f, 0.41369805f, -0.67325264f, -0.86650640f, -1.19695818f, -0.41972312f, -0.77504939f, 
    0.31230289f, -0.08885325f, -0.12433044f, 0.25224200f, -0.71852541f, 0.37095359f, 0.00968214f, 0.21974021f, 
    -0.31320813f, 0.46691352f, -0.23342416f, 0.01309014f, 0.34349981f, 0.63872629f, -0.30977386f, 0.07302577f, 
    -0.24706355f, -0.22107716f, -0.20606551f, 0.48260933f, 1.10963297f, -0.37594885f, 0.33284187f, 1.86725616f, 
    -0.11331943f, 0.36401191f, 1.08728266f, 0.58376449f, 0.20839633f, -0.85708493f, -0.29490164f, 0.08466728f, 
    0.29957196f, 0.41295412f, 0.07927813f, 0.22183672f, 0.23927844f, 0.72971654f, 0.26367396f, -0.12125179f, 
    -0.02692499f, -0.10455167f, 0.48398012f, 0.11192328f, 1.26375043f, 0.52852994f, 0.94862390f, 1.13872385f, 
    1.10217559f, 0.05070196f, 0.13497688f, -0.11935852f, -1.06631863f, -0.34318849f, 0.20505670f, 0.06543179f, 
    -0.63226122f, 0.10216063f, 0.29612774f, -0.19180346f, -0.06856405f, 0.14327189f, 0.53077215f, 0.17044719f, 
    0.41431230f, 0.23553079f, -0.02253125f, 0.55035657f, 0.62820083f, -0.22962739f, -1.61119378f, 0.12080067f, 
    0.64333397f, 1.06392193f, -1.23638511f, 0.49506345f, 0.72062403f, -1.01676893f, 0.18181267f, 0.81384045f, 
    0.76371175f, 0.11697953f, -0.32257476f, -0.09634352f, -0.20307626f, 0.17934853f, 0.05546696f, 0.39551535f, 
    0.06063254f, 0.00694276f, -0.13305669f, 0.10039902f, -0.03915444f, -0.15977883f, -0.13335894f, -0.52099198f, 
    -0.29009801f, -0.85746855f, -0.15169866f, -0.27644193f, -1.34208632f, -0.88844192f, -0.96581644f, -1.04643619f, 
    0.26883420f, -0.06457956f, 0.42331782f, -0.21027996f, -0.03362537f, 0.04490933f, -0.28502133f, -0.56163013f, 
    0.31939277f, 0.64302260f, 0.26206535f, 0.52287781f, 0.10913206f, -0.16745147f, 0.34577975f, 1.79449749f, 
    0.71335894f, -1.57303059f, 1.18226075f, 0.20204897f, -0.91972047f, -0.66059518f, -0.19381209f, 0.26111346f, 
    0.21782197f, -0.24216983f, -0.26125884f, 0.32425871f, -0.22380547f, -0.19592808f, -0.04389989f, 0.08466425f, 
    -0.17424481f, -0.29160684f, -0.02897776f, 0.36612758f, 0.31501392f, 0.23670036f, -0.03240253f, 0.02730051f, 
    -0.99396634f, -1.82493150f, -0.74384433f, 0.93084145f, 0.81826699f, -0.16185902f, 1.05564332f, 0.53477877f, 
    0.58166587f, 0.14515883f, -0.25209668f, -0.11929259f, -0.32703328f, 0.11378652f, -0.31311643f, -0.05971618f, 
    -0.19663337f, 0.02985813f, -0.32950899f, -0.49751589f, 0.15850270f, 0.17924559f, 0.00263622f, 0.03948946f, 
    -0.23600970f, 1.18495190f, 0.48502189f, 1.47683501f, 1.57768452f, 1.05848670f, 0.41649497f, 0.30191615f, 
    -0.18753275f, 0.32661447f, 0.53402376f, 0.28118816f, 0.27695349f, 0.07542072f, -0.07753803f, -0.25175190f, 
    -0.28173682f, -0.17780958f, 0.14690106f, -0.39651588f, -0.30030671f, -0.10543007f, -0.25202239f, 0.11064368f, 
    -0.32569605f, -0.05826308f, -0.24642850f, 1.13072801f, 1.37927485f, 0.49783382f, 0.20138194f, -1.54702365f, 
    0.33378479f, -0.31081828f, -1.24143112f, -0.33926132f, 0.06678890f, 0.23567906f, 0.11595487f, 0.49855804f, 
    0.40392619f, -0.07503212f, -0.00965814f, 0.02277564f, -0.20006561f, 0.40922147f, 0.09824741f, 0.29678559f, 
    0.31252861f, 0.27048925f, -0.31674525f, 1.70178592f, 0.27594897f, -0.42634439f, 0.32613227f, 0.59703392f, 
    1.17853069f, 0.83401734f, -0.25190198f, 0.82636583f, 0.60005164f, -0.97320455f, 0.40543163f, -0.36505240f, 
    0.40021163f, -0.57327533f, -0.21798886f, -0.00050920f, -0.25803730f, -0.23630074f, -0.31049502f, -0.05173240f, 
    0.16159578f, -0.39887816f, -0.13824315f, 0.25395104f, -1.52867889f, -0.33574638f, -0.52447540f, -0.83124548f, 
    -0.66568768f, -0.01456094f, -0.55681121f, 0.47671953f, 1.35658622f, 0.41881594f, 0.15677731f, 0.06803789f, 
    -0.47909495f, 0.26219571f, 0.04104181f, -0.33577529f, 0.38942710f, -0.47438273f, 0.00697737f, 0.02360060f, 
    0.36687255f, 0.02106159f, 0.19786392f, 0.09865329f, 0.34093815f, -0.06490976f, -0.70642513f, -1.19643378f, 
    -0.61111122f, -0.29926598f, -0.50829446f, 1.26934266f, 1.32199252f, -1.02403462f, 0.30311516f, 0.36196661f, 
    -0.17952171f, 0.57369524f, -0.14429720f, 0.30453551f, -0.86939508f, -0.30304733f, -0.18558924f, 0.00625847f, 
    -0.06408022f, 0.11996860f, 0.00048217f, -0.15733938f, -0.08707091f, 0.02451265f, -1.25840962f, -1.06345141f, 
    1.68948412f, 0.37679985f, -0.92849553f, 0.80386835f, 0.70916510f, 0.69035655f, -0.24143986f, -0.66023922f, 
    -0.35158619f, -0.06071832f, -0.43868726f, -0.00797924f, -0.21645807f, -0.05935489f, 0.34780279f, -0.00384942f, 
    -0.43092901f, -0.26859614f, -0.11520082f, -0.11862691f, 0.12094444f, 0.06865085f, -0.24825022f, 0.99235654f, 
    1.05576587f, -0.25693870f, -0.88504922f, -0.51280743f, -0.88451821f, 0.75330251f, -0.29054084f, 0.16737239f, 
    0.43413329f, 1.00293267f, 0.38908088f, -0.16527796f, -0.10755629f, 0.14235277f, 0.23881961f, 0.49945071f, 
    0.24019444f, 0.14304720f, 0.25207302f, 0.00632377f, 0.36236003f, -0.34991476f, 0.20235811f, 0.05725817f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.47396025f, -0.14487070f, 0.15778637f, 0.13498659f, 0.21571568f, 0.17479683f, 0.33540493f, 0.48370087f, 
    0.17914155f, 0.31279919f, 0.29183272f, 0.31218097f, 0.35471958f, 0.55340606f, 0.16840404f, 0.39687428f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.51026261f, 0.00297423f, 0.16187215f, -0.45185623f, 0.02039585f, 0.04147035f, -0.07332335f, -0.06105035f, 
    -0.03604026f, 0.01345184f, -0.13187791f, -0.01010018f, 0.44629458f, 0.05199881f, -0.54586661f, 0.52597082f, 
    -0.38029838f, 0.03060032f, 0.13869992f, -0.05513808f, 0.04282286f, -0.17472161f, -0.03872103f, -0.01591977f, 
    -0.34686252f, -0.44773921f, 0.13065746f, -0.52828729f, -0.06840348f, -0.10026020f, 0.08922247f, 0.13505414f, 
    -0.08216961f, -0.02118552f, -0.04832775f, -0.03393429f, 0.22100247f, -0.00297748f, 0.24816848f, -0.13313474f, 
    -0.30416900f, 0.17639312f, 0.02435664f, 0.01283982f, 0.11929915f, 0.17116183f, -0.09460214f, 0.10367264f, 
    0.61115265f, -0.00404292f, -0.08707989f, 0.05270449f, -0.36124596f, -0.24397975f, -0.04865286f, 0.10147226f, 
    -0.18855296f, -0.17912108f, -0.02489246f, -0.10221463f, -0.19995341f, -0.08378448f, -0.20281160f, 0.06438277f, 
    -0.13398598f, 0.07141952f, -0.03095187f, 0.02828946f, 0.02552453f, 0.08141849f, -0.06145617f, 0.02007627f, 
    -0.66809565f, -0.44953084f, 0.38012800f, -0.18467838f, -0.00084804f, 0.07793198f, 0.17219253f, -0.01252603f, 
    -0.07957764f, -0.39838621f, 0.10136602f, -0.07393073f, 0.18119986f, -0.04923348f, -0.01707351f, 0.36057907f, 
    -0.21847376f, 0.17084843f, -0.17306933f, 0.10272890f, -0.00111387f, 0.00413844f, 0.07008372f, -0.00937778f, 
    -0.53040600f, 0.50161117f, -0.27348357f, 0.14761762f, 0.05312676f, 0.05614479f, 0.15820184f, 0.06417167f, 
    0.02652320f, -0.13026987f, 0.02182789f, 0.08809952f, 0.18103099f, -0.09884347f, -0.40102160f, 0.51027179f, 
    -0.17448814f, -0.06338982f, 0.08347086f, 0.11271091f, 0.00733422f, 0.16651028f, -0.14650643f, -0.00215782f, 
    -0.01659460f, 0.27701509f, -0.57957000f, 0.14533883f, 0.18138929f, 0.02744877f, -0.13151234f, -0.15821880f, 
    -0.14342637f, -0.00720908f, 0.13848805f, -0.10759433f, 0.39671087f, -0.29696417f, -0.07349276f, 0.09377231f, 
    0.15290779f, -0.22340336f, 0.09091687f, 0.04445957f, -0.26874581f, 0.21705301f, 0.01826169f, 0.05544556f, 
    0.11028923f, 0.21507391f, -0.35491893f, -0.34307468f, 0.06062496f, 0.06970093f, -0.16423266f, 0.07462399f, 
    0.04827852f, -0.06063895f, 0.08230626f, -0.10878898f, -0.95130587f, 0.25637916f, -0.08755171f, -0.32223484f, 
    0.03012991f, -0.23027490f, -0.10279141f, -0.03338194f, 0.01009997f, -0.11785076f, -0.06862189f, 0.25099766f, 
    -0.49290922f, 0.35005999f, 0.35884956f, 0.64448845f, 0.09070602f, 0.04927193f, 0.08756728f, 0.07828178f, 
    -0.09467663f, -0.10384014f, 0.02791064f, -0.21461128f, -0.66556591f, 0.18577762f, 0.06167575f, 0.01321058f, 
    -0.18242122f, -0.12164912f, 0.08152016f, -0.19089039f, 0.12800491f, -0.05442275f, -0.00061037f, 0.03064729f, 
    -0.27023175f, -0.14693360f, 0.00794192f, -0.11420521f, 0.03670468f, -0.10352556f, 0.22027554f, 0.12836111f, 
    0.01039923f, 0.05043801f, 0.22038876f, -0.00043072f, -0.12739161f, -0.10548474f, -0.37418428f, 0.10360853f, 
    0.07651429f, 0.00652547f, -0.29558036f, -0.06217908f, -0.06142545f, -0.03029793f, 0.20264456f, -0.00557738f, 
    0.46141157f, -0.32707071f, 0.22404249f, -0.55342603f, 0.14871007f, 0.11661959f, 0.04560392f, -0.23535793f, 
    -0.15919328f, -0.05633456f, -0.01467470f, 0.07012536f, 0.23013836f, 0.23620303f, -0.03532984f, 0.12529147f, 
    0.09254644f, 0.02633847f, 0.08606329f, 0.18329763f, -0.00062553f, -0.16465920f, -0.09205145f, -0.17077182f, 
    0.22328900f, -0.03967861f, 0.14594185f, 0.41604775f, -0.30773637f, 0.14718837f, 0.07434602f, 0.06682411f, 
    -0.12927572f, 0.28151241f, -0.05372351f, 0.12672405f, -0.08903959f, -0.17142266f, -0.01990619f, 0.17609680f, 
    -0.27523533f, 0.00183483f, -0.10925702f, 0.15785111f, -0.04441050f, -0.14804733f, 0.15439461f, 0.02689389f, 
    -0.15187539f, 0.07283942f, 0.00033725f, -0.36562878f, -0.04941946f, 0.13873981f, -0.00940463f, -0.04286358f, 
    -0.08176054f, 0.30487302f, -0.08423587f, -0.05928214f, 0.45260108f, -0.54784250f, 0.03334729f, -0.08545460f, 
    -0.08342746f, -0.34032288f, 0.00893054f, 0.12089051f, -0.12460425f, 0.03063825f, -0.25009504f, 0.06946758f, 
    0.56242055f, -0.21217400f, -0.31449819f, 0.04763957f, 0.03711368f, 0.15144503f, -0.04745520f, 0.00695201f, 
    0.05071516f, 0.05717429f, -0.14093153f, -0.08757452f, 0.46486002f, 0.01946010f, 0.35615069f, 0.32372630f, 
    -0.25921410f, -0.07963666f, 0.14139003f, 0.14418177f, -0.02212209f, -0.25365424f, 0.17684858f, -0.07149886f, 
    -0.41819361f, 0.16079414f, -0.15544492f, -0.18363121f, -0.03574733f, 0.06658129f, -0.02790216f, -0.07807376f, 
    0.08896932f, -0.05975145f, 0.12141985f, 0.17570913f, 0.53825581f, -0.08382422f, 0.10539910f, 0.05447052f, 
    -0.13750950f, -0.14928104f, -0.13565700f, -0.04617415f, -0.06161700f, -0.16039579f, 0.01299095f, -0.18034892f, 
    -0.40694231f, -0.09335449f, -0.21430810f, -0.28632909f, -0.16245718f, -0.04111009f, -0.14477177f, 0.14953168f, 
    0.23955111f, -0.19182545f, -0.03720722f, 0.08317963f, 0.56681210f, -0.28781953f, -0.05887753f, -0.09296357f, 
    -0.01660122f, -0.00635045f, -0.20992009f, -0.01054390f, 0.01963815f, -0.14144690f, -0.00453418f, -0.22391042f, 
    -0.81865436f, 0.06470468f, -0.38233772f, 0.26050311f, -0.20316011f, 0.03059976f, 0.04142527f, -0.28312021f, 
    -0.11273134f, 0.04546002f, -0.17150770f, -0.02298236f, 0.71261370f, -0.01852808f, -0.37215963f, -0.33507168f, 
    -0.21214157f, -0.09391788f, 0.10187263f, 0.20607944f, 0.13471131f, 0.18082882f, 0.12719211f, 0.17592697f, 
    -0.34304750f, 0.02475958f, -0.02505904f, -0.30996639f, 0.16612773f, -0.30464324f, -0.05109944f, -0.03512400f, 
    -0.09927586f, -0.09676226f, -0.09881472f, -0.16399267f, -0.14816743f, 0.16784887f, -0.42979735f, -0.03737139f, 
    0.18302146f, 0.09993574f, -0.19376050f, 0.22625165f, 0.03567640f, -0.02485133f, -0.13051941f, -0.22599667f, 
    -0.32802615f, 0.03391466f, -0.08347649f, -0.09980130f, -0.47230190f, 0.17995432f, 0.19561431f, 0.07828642f, 
    -0.15413050f, -0.05640902f, -0.31705889f, 0.18825382f, -0.02372636f, -0.35326597f, -0.02012676f, -0.20719397f, 
    0.11743874f, 0.11466571f, 0.13826121f, -0.13691428f, -0.00241573f, -0.27418616f, 0.00361382f, 0.08986881f, 
    -0.05690875f, 0.05007243f, 0.03290637f, -0.03290332f, 0.31165498f, 0.07612332f, -0.04226111f, -0.07471094f, 
    0.18385480f, -0.03682860f, 0.04995158f, -0.08716472f, 1.14683700f, -0.40740412f, -0.07256545f, 0.11794231f, 
    -0.21200633f, 0.18808308f, -0.02252409f, -0.12332200f, -0.19659199f, -0.16322552f, -0.14806765f, -0.09101276f, 
    -0.89911878f, -0.22800389f, -0.52303171f, -0.73326838f, 0.17812198f, -0.10915996f, 0.15393031f, -0.34041482f, 
    0.14939557f, 0.08291817f, 0.06559076f, -0.26836568f, 0.09120168f, -0.09776674f, -0.39861816f, -0.27196360f, 
    0.16567767f, -0.15262395f, 0.18338600f, -0.01273435f, -0.04902229f, 0.09668677f, 0.03864355f, -0.17305169f, 
    0.60113299f, -0.36468443f, -0.08562306f, 0.22890700f, -0.20018750f, 0.10938792f, -0.21994650f, -0.14561832f, 
    0.19155012f, 0.01999419f, 0.03762268f, 0.11089362f, 0.01092402f, 0.19412546f, -0.10566451f, 0.10238662f, 
    0.05613608f, 0.08890756f, -0.02936605f, 0.10991280f, -0.18436147f, 0.21325324f, -0.01225054f, -0.02313632f, 
    0.33530444f, 0.37638462f, -0.37803620f, 0.01952519f, 0.07379395f, 0.12854873f, -0.02934707f, -0.10563725f, 
    -0.18997824f, -0.20065925f, 0.00806425f, -0.23322135f, 0.31931019f, -0.43481052f, 0.15919331f, -0.16962354f, 
    -0.05407007f, -0.27085552f, 0.23468512f, 0.11742521f, -0.14843205f, 0.07774433f, 0.03439747f, -0.00134270f, 
    0.51952636f, 0.19951963f, 0.24288785f, 0.33842257f, -0.28173888f, -0.10416545f, -0.07863829f, 0.05797746f, 
    -0.09182155f, -0.07720600f, 0.16002004f, -0.03788842f, 0.54471302f, 0.20972763f, -0.02384373f, 0.17436852f, 
    0.01677404f, -0.22033325f, -0.12907459f, 0.31822428f, -0.15696348f, -0.03353108f, -0.01892753f, -0.15524979f, 
    0.20078000f, -0.17365071f, 0.09479322f, -0.35813746f, -0.37526131f, -0.06528728f, 0.07726979f, 0.19375713f, 
    0.35596463f, 0.12652427f, 0.02110524f, -0.38775474f, 0.16934583f, -0.17374542f, 0.20784870f, -0.43967214f, 
    0.00207839f, -0.06789371f, 0.04579916f, 0.02369741f, -0.17664357f, -0.15332782f, 0.06316801f, -0.14229238f, 
    -0.03770599f, -0.08917553f, -0.07859889f, -0.29686096f, -0.28899938f, -0.15598425f, -0.03598316f, 0.04205486f, 
    0.03441836f, 0.13702665f, -0.20453824f, 0.04620934f, 0.07869539f, -0.21662085f, 0.44500646f, 0.16235840f, 
    0.06342062f, 0.12728508f, 0.20561564f, 0.04058426f, 0.03134022f, 0.03486862f, 0.06623912f, 0.06671400f, 
    -0.12156242f, 0.11675938f, 0.04932588f, 0.06782810f, -0.11712497f, -0.11780827f, 0.04502742f, 0.21448676f, 
    -0.06398150f, 0.12549913f, -0.07672253f, 0.23928146f, -0.92063838f, -0.11240322f, -0.32637104f, -0.17739147f, 
    -0.25254953f, 0.04507221f, 0.08886345f, 0.03893144f, 0.05435697f, -0.23467205f, -0.02947839f, 0.15239437f, 
    -0.87551558f, -0.70304608f, -0.04571932f, 0.17755826f, 0.02955613f, 0.00537188f, -0.01477165f, -0.25454649f, 
    -0.10304260f, -0.19930321f, 0.02965107f, -0.20769484f, -0.36244836f, 0.33933532f, 0.58070385f, 0.10534018f, 
    -0.08950005f, 0.18965554f, -0.03604095f, -0.05554743f, -0.12592113f, 0.17851512f, -0.15049364f, -0.05362454f, 
    0.59675807f, 0.21975762f, 0.12454418f, 0.36812267f, -0.04898204f, -0.02101529f, -0.00378089f, -0.11749596f, 
    0.18640228f, -0.08862334f, -0.12895072f, -0.06630055f, 0.89592320f, 0.02334292f, -0.16609792f, -0.24603345f, 
    0.10553569f, 0.08100228f, 0.04980298f, -0.10434932f, 0.09667001f, -0.11953465f, -0.03901891f, -0.14743407f, 
    -0.13087566f, 0.25473481f, 0.07032344f, 0.17635107f, -0.07080377f, -0.14644296f, 0.14936206f, -0.01265717f, 
    -0.02090803f, 0.05456988f, -0.10933291f, -0.09057401f, -0.44791240f, -0.62992781f, -0.29715031f, -0.01178383f, 
    -0.06339328f, 0.16311145f, 0.10058263f, -0.19008358f, 0.30917579f, 0.20377667f, -0.07584160f, -0.11884299f, 
    -0.83466500f, 0.45274332f, 0.45134676f, 0.16157290f, 0.09478018f, 0.03740743f, -0.11590602f, -0.09053943f, 
    -0.07579986f, -0.20651777f, -0.05109585f, -0.03534360f, -0.21747513f, -0.43772155f, -0.36763176f, -0.17048559f, 
    -0.10236595f, 0.04851641f, 0.08354981f, -0.10279795f, -0.01781087f, -0.05016286f, 0.14627181f, 0.07150745f, 
    -0.08392230f, 0.08918615f, -0.04528071f, -0.26899010f, -0.10341047f, -0.10426288f, -0.12907422f, -0.06912646f, 
    -0.08537101f, -0.17061070f, 0.06566656f, 0.06201697f, 0.25863108f, -0.48873839f, 0.18665199f, -0.04638992f, 
    -0.04960212f, 0.08757582f, 0.20728664f, 0.16997825f, -0.04742575f, 0.17977174f, -0.00283860f, 0.20455717f, 
    0.25374088f, -0.02571178f, 0.08509506f, -0.36761048f, 0.02885518f, -0.29243618f, 0.09672721f, 0.30548459f, 
    0.05814452f, -0.06336238f, 0.01692085f, 0.09208709f, -0.49777755f, -0.03885302f, -0.16666423f, -0.14830106f, 
    -0.20413150f, 0.31266323f, -0.12009777f, 0.22361381f, 0.20528056f, -0.00518901f, -0.12940890f, -0.06790365f, 
    0.31619543f, -0.17445579f, -0.05073836f, 0.08567914f, 0.01916288f, 0.00202149f, 0.40832305f, 0.09278366f, 
    0.09582560f, 0.19512267f, -0.08491728f, 0.16775645f, -0.01828200f, -0.02892052f, 0.02599898f, -0.03911552f, 
    0.17058504f, 0.24241985f, -0.01202432f, -0.00317312f, 0.07184226f, 0.05834153f, -0.09588310f, 0.09593092f, 
    0.04683751f, 0.15737714f, 0.38108391f, 0.55217820f, 0.06203780f, -0.11282755f, 0.08839041f, 0.12382418f, 
    0.12349009f, 0.18375850f, 0.05294784f, -0.11120657f, 0.73246384f, -0.36715820f, -0.29328915f, 0.11282015f, 
    -0.25783971f, -0.00035484f, 0.09428044f, -0.01771326f, 0.01150682f, 0.09010352f, -0.19963410f, -0.05236601f, 
    -0.16283651f, 0.32039043f, 0.26851609f, -0.04819695f, 0.07186630f, 0.05144031f, -0.08196788f, -0.00352330f, 
    0.18504876f, -0.07761181f, 0.01377043f, -0.34564897f, -0.67827541f, -0.13387696f, -0.02724445f, -0.05618043f, 
    0.17232817f, -0.14559433f, -0.00162553f, -0.10430539f, 0.00476019f, 0.16426852f, -0.09340727f, 0.05044442f, 
    -0.04451022f, -0.00788085f, 0.07490558f, 0.05684584f, -0.09363195f, -0.01500810f, 0.03163459f, 0.16400154f, 
    -0.18892448f, -0.22829279f, 0.08174906f, 0.15750265f, 0.32628337f, -0.12292267f, 0.07336923f, 0.21271759f, 
    -0.31568348f, 0.06110779f, -0.07403880f, -0.37354282f, 0.01142249f, 0.04061872f, -0.01157562f, -0.17088583f, 
    -0.79679096f, 0.01550677f, -0.14308807f, -0.04620190f, -0.09742533f, 0.25191510f, -0.06994348f, -0.04705250f, 
    -0.01750274f, -0.08772257f, 0.08616701f, 0.08179136f, -0.24043055f, 0.08750746f, -0.23087278f, 0.04791019f, 
    -0.11046975f, -0.05106146f, 0.07763088f, 0.09948146f, 0.04917767f, 0.00465245f, -0.10899420f, 0.08342157f, 
    -0.89715481f, -0.28712007f, 0.55305833f, 0.18163167f, -0.20416872f, -0.16618539f, 0.05439251f, -0.28661796f, 
    -0.01100861f, -0.03915137f, -0.03290975f, 0.01258511f, -0.15075196f, 0.02084041f, -0.06682564f, 0.39805305f, 
    -0.00595777f, 0.12279218f, 0.00900187f, 0.05963618f, -0.05333081f, -0.05114138f, -0.00343984f, 0.01235250f, 
    0.60331720f, 0.00713612f, -0.14483330f, 0.25408679f, 0.01452797f, 0.10644218f, 0.03743059f, 0.13260515f, 
    0.09977789f, -0.25630614f, 0.05132558f, 0.13241445f, -0.49456400f, -0.20315962f, 0.02002191f, 0.04765305f, 
    -0.04167121f, 0.01651494f, 0.09624016f, -0.02534120f, -0.15259498f, -0.08725397f, 0.05765193f, 0.16418602f, 
    0.10765200f, -0.18587179f, -0.46155488f, -0.60501361f, 0.13295650f, -0.02880941f, 0.05621852f, 0.13349122f, 
    0.00842808f, 0.05747285f, -0.01245890f, 0.13834280f, -0.47403190f, -0.30895936f, 0.12299062f, -0.10796494f, 
    -0.08013047f, -0.04629491f, 0.04239121f, -0.04684554f, 0.13917881f, -0.00854196f, -0.22480045f, -0.20879158f, 
    -0.61330354f, 0.12189218f, 0.16192809f, -0.05972959f, 0.13415971f, 0.07729102f, -0.07819063f, -0.18512319f, 
    0.19634427f, -0.18272577f, 0.19976340f, -0.01730491f, -0.22513674f, 0.15266082f, 0.02132812f, -0.08477203f, 
    -0.08617412f, -0.10234825f, -0.21708544f, 0.07632060f, -0.23414344f, 0.20323747f, 0.21366620f, -0.10720344f, 
    0.05351469f, -0.53832245f, -0.24548399f, -0.00009992f, 0.07038426f, -0.05103170f, -0.20598206f, -0.05102529f, 
    0.07711510f, -0.11522375f, 0.14494458f, -0.07224161f, 0.03632798f, 0.15059967f, 0.74107987f, -0.31912619f, 
    0.00364030f, -0.01436483f, 0.04917157f, -0.26876712f, 0.01158214f, 0.08693499f, 0.44554174f, 0.20784260f, 
    0.09478594f, -0.13738123f, 0.13303655f, -0.07787256f, -0.01412795f, 0.19449122f, -0.12138777f, -0.06100942f, 
    -0.06393266f, 0.08109225f, 0.10745770f, 0.15719450f, -0.37241653f, 0.00092292f, -0.02365244f, -0.61297947f, 
    0.18973912f, -0.03134701f, 0.06648041f, -0.12565465f, 0.00573695f, -0.04586104f, 0.09964076f, 0.15180890f, 
    -0.07069899f, -0.15812910f, -0.07236594f, 0.56155926f, 0.03488924f, -0.10880820f, -0.11499029f, 0.10837319f, 
    -0.21827969f, 0.31405884f, 0.03198563f, -0.00327378f, -0.15745467f, 0.04986583f, 0.21615635f, -0.14413740f, 
    -0.23101160f, 0.07135011f, 0.00275062f, 0.00101727f, -0.03423341f, -0.13389730f, -0.09999092f, -0.00424409f, 
    -0.62285697f, 0.48526192f, 0.07471083f, -0.46733239f, 0.17890650f, -0.07364690f, 0.04372230f, 0.00064404f, 
    -0.00409659f, -0.13764507f, -0.16596563f, -0.25363445f, 0.01699469f, -0.05919677f, 0.34130052f, 0.10059759f, 
    -0.01774583f, -0.08712903f, 0.03038247f, -0.04204313f, -0.04454254f, -0.15910636f, -0.06282292f, -0.00683662f, 
    0.41554692f, -0.18972947f, -0.00837840f, -0.05333348f, -0.15653726f, -0.09180134f, 0.12404352f, 0.21329282f, 
    -0.06917319f, 0.15011579f, 0.02960258f, 0.20046815f, 0.05775900f, -0.04057404f, 0.10744739f, -0.12228615f, 
    -0.02154380f, -0.04595511f, -0.24392588f, -0.11977846f, 0.04684022f, -0.14429870f, -0.25222549f, 0.02054506f, 
    -0.21359546f, -0.74097824f, -0.36685607f, 0.28663281f, 0.35445660f, 0.02490890f, 0.06781866f, -0.24398585f, 
    0.04439947f, 0.29662603f, -0.26716080f, 0.13265681f, -0.73479784f, 0.32628068f, -0.09633484f, 0.07100455f, 
    0.12827244f, -0.23195589f, 0.05624517f, 0.01340109f, -0.03400159f, 0.22487223f, 0.19208997f, -0.17303196f, 
    -0.58107412f, 0.10944585f, 0.20118310f, 0.18317519f, 0.12218265f, -0.15072739f, 0.11252230f, -0.14391910f, 
    0.28248629f, -0.04381630f, -0.26435181f, 0.05265788f, 0.12678921f, 0.06143557f, 0.00744202f, -0.07744889f, 
    0.01730370f, -0.05647648f, -0.02657712f, -0.12092905f, -0.14267576f, 0.11151352f, 0.16088387f, 0.22202070f, 
    0.42650333f, 0.25594586f, -0.22220215f, 0.55252910f, -0.20243376f, 0.15931641f, 0.01436234f, -0.14701356f, 
    -0.18120259f, 0.18486162f, -0.15934531f, 0.05372160f, 0.48263636f, 0.23950449f, 0.43970960f, -0.58476079f, 
    -0.14357628f, 0.14082700f, 0.33570910f, 0.08259790f, 0.04794898f, -0.12418527f, -0.24080196f, 0.11743599f, 
    -0.21668558f, -0.13332646f, -0.56424505f, -0.08059815f, -0.15260816f, 0.06212816f, 0.29349771f, 0.09793034f, 
    -0.00749886f, -0.10303017f, 0.12948488f, -0.03992247f, -0.54679078f, 0.10560695f, 0.33946770f, -0.26758718f, 
    0.02466366f, -0.06268638f, -0.05310825f, 0.01806680f, 0.12937970f, -0.11042930f, -0.30441782f, -0.13210535f, 
    0.31669423f, 0.13687731f, 0.18747526f, -0.57597828f, 0.06558307f, -0.11427150f, 0.07896847f, 0.19555792f, 
    0.24328893f, 0.03342091f, -0.05897779f, 0.01359836f, 0.59889179f, 0.17904644f, 0.09306791f, 0.20357785f, 
    0.00756073f, 0.04005750f, 0.12650637f, 0.10307921f, 0.26804975f, -0.17022733f, -0.22569458f, -0.14729537f, 
    -0.24310531f, -0.41684738f, -0.35222971f, -0.27317619f, -0.06184874f, 0.11003266f, 0.00844726f, -0.08790032f, 
    -0.03202974f, -0.50860327f, 0.18923280f, 0.11845440f, -0.30137298f, 0.32750502f, -0.02768892f, -0.08570221f, 
    0.05659275f, 0.11385998f, -0.22377454f, 0.06822426f, 0.02000363f, -0.01062138f, 0.16603726f, 0.07361527f, 
    0.36124003f, -0.51100004f, 0.26140961f, -0.14393559f, 0.11464312f, 0.00968393f, -0.05319839f, 0.03221498f, 
    0.02040210f, 0.05949388f, 0.17955749f, 0.01972562f, -0.01088456f, 0.23029011f, 0.27115580f, -0.38147116f, 
    -0.33754501f, -0.01652541f, -0.08262419f, 0.08443802f, 0.02695020f, 0.06927609f, 0.19386312f, 0.07474731f, 
    0.05200192f, 0.00572724f, 0.00795465f, -0.22107103f, 0.17117178f, 0.00595111f, 0.10403638f, 0.04939069f, 
    0.02899633f, -0.09099443f, -0.19560806f, -0.12681571f, -0.48759630f, -0.07278752f, 0.18484262f, -0.08084914f, 
    -0.25981632f, -0.01325861f, 0.20061466f, -0.02060262f, -0.08027002f, -0.05071169f, 0.00021151f, 0.11955620f, 
    -0.58415186f, -0.13155270f, -0.18859303f, -0.33963677f, 0.00377028f, -0.01580509f, 0.06558833f, -0.34399629f, 
    -0.20984918f, 0.02089817f, 0.22519498f, -0.17246705f, -0.26732859f, -0.15799412f, -0.28334495f, -0.04053604f, 
    0.00862641f, 0.20876154f, -0.09922590f, -0.08565196f, 0.10670807f, -0.12646106f, 0.07081372f, 0.27545038f, 
    0.17070615f, -0.91924804f, -0.19363683f, -0.15301318f, -0.02629126f, 0.13073561f, -0.01032150f, -0.02625684f, 
    -0.14888884f, -0.06005529f, 0.17824107f, 0.04648542f, -0.45028049f, 0.13248535f, -0.04618111f, 0.57488781f, 
    0.21289527f, 0.04253478f, -0.04263867f, 0.10434193f, -0.03229084f, -0.31050748f, -0.18241349f, -0.30298364f, 
    0.19109941f, 0.33402750f, 0.13042974f, 0.29827666f, 0.25639868f, -0.06781553f, -0.09726191f, -0.03725147f, 
    -0.00786779f, -0.04957161f, -0.05139190f, -0.21788441f, 0.40710589f, 0.15532826f, -0.02490069f, 0.05380163f, 
    -0.24546373f, 0.06145494f, 0.13224529f, -0.10756398f, -0.13780963f, -0.22354294f, -0.08324507f, -0.13019799f, 
    0.23718268f, 0.24660523f, 0.20025936f, 0.22128262f, 0.13009009f, 0.25185031f, -0.02805963f, 0.00457516f, 
    -0.06742243f, 0.00558833f, -0.21387534f, -0.09309367f, -0.33779013f, 0.26911303f, -0.02517343f, 0.03433468f, 
    -0.11146666f, -0.02895392f, -0.01815563f, -0.13386619f, -0.07781629f, -0.07268886f, -0.06453714f, -0.07584124f, 
    -0.48969314f, -0.35759470f, -0.29395124f, -0.13125497f, -0.08472851f, -0.06154408f, 0.02758717f, -0.15834776f, 
    0.06334396f, 0.00644666f, 0.03745819f, -0.24509273f, 0.28345144f, -0.62534946f, -0.00646134f, -0.10098930f, 
    -0.14837834f, 0.01525816f, -0.04567292f, -0.03906240f, -0.05134906f, 0.20388639f, -0.20222229f, 0.03116659f, 
    0.13600455f, 0.13601357f, 0.04120767f, 0.51354998f, -0.11276629f, -0.36844325f, -0.15609011f, -0.08174169f, 
    -0.09271253f, -0.14155489f, -0.22385609f, -0.08140791f, -0.54024279f, 0.44844842f, -0.20831257f, -0.12632072f, 
    -0.09360693f, 0.00836659f, -0.41846839f, -0.11434572f, -0.12751873f, -0.02002501f, 0.12582818f, -0.15231331f, 
    0.02084209f, -0.34949166f, 0.24312693f, -0.32900262f, 0.07504768f, -0.03256012f, -0.10611000f, 0.02211299f, 
    -0.04840622f, 0.04055249f, 0.07217767f, -0.09021512f, -0.77239543f, 0.20746639f, -0.20873478f, -0.23639125f, 
    -0.01703580f, 0.02874128f, -0.14034449f, -0.12359116f, -0.23282173f, -0.07461349f, -0.11706550f, -0.22456776f, 
    0.36029360f, -0.86713433f, 0.22860402f, 0.08525231f, 0.13608314f, -0.12124886f, 0.00774220f, 0.01971323f, 
    -0.11721810f, -0.03125644f, 0.01209867f, -0.09722662f, -0.11154685f, 0.20952384f, -0.28164601f, -0.06263284f, 
    -0.19982354f, 0.00041491f, -0.05972950f, -0.15580525f, 0.05952429f, 0.13952193f, -0.03010738f, -0.22921929f, 
    0.11713331f, 0.37777039f, 0.22938101f, 0.41856137f, 0.30964008f, 0.12384886f, 0.19099373f, -0.05445658f, 
    -0.16959816f, -0.04039951f, 0.06067505f, -0.22780824f, 0.33894974f, 0.03660778f, 0.31558689f, 0.06707913f, 
    -0.23828095f, 0.05262484f, 0.03888328f, -0.12242422f, 0.07131138f, 0.01552744f, -0.14106621f, -0.04073745f, 
    0.28034440f, 0.09685212f, 0.21870130f, 0.26324674f, 0.24222839f, 0.15650551f, -0.09973694f, 0.07620699f, 
    -0.09599385f, 0.01574003f, 0.13231443f, -0.07590513f, -0.27989337f, 0.01484880f, 0.11014313f, -0.12554187f, 
    0.10060018f, -0.25386733f, -0.04913731f, -0.10674188f, -0.04895258f, -0.11335677f, -0.02452895f, -0.13235125f, 
    -0.15923540f, 0.47280997f, -0.07409328f, -0.20479554f, -0.00019088f, -0.24712248f, -0.31190729f, -0.22331564f, 
    -0.00835359f, -0.25887096f, 0.26696107f, -0.02132989f, -0.34160119f, -0.51909894f, -0.07333507f, 0.01695069f, 
    -0.06549214f, -0.23553118f, 0.10696263f, -0.06367375f, -0.08780821f, 0.11867867f, 0.29272312f, -0.32133925f, 
    -0.50389624f, 0.48391187f, -0.09603743f, -0.25977567f, 0.06107470f, -0.13191187f, -0.08862713f, -0.28428873f, 
    0.21092172f, 0.01584361f, -0.14824545f, -0.15727158f, 0.33717659f, -0.00953591f, -0.14581342f, 0.29941338f, 
    0.09764989f, -0.21686400f, -0.18496785f, -0.14878492f, -0.11988592f, 0.18624872f, 0.31012321f, -0.15554523f, 
    -0.36654401f, -0.00141017f, -0.14432551f, 0.40269372f, 0.09396455f, 0.05014027f, 0.03652516f, -0.00412847f, 
    0.00308449f, 0.03721892f, 0.10342723f, 0.31289747f, -0.20916203f, -0.13590384f, -0.04339931f, -0.08170003f, 
    -0.13238549f, -0.17099801f, 0.01967493f, -0.31860614f, 0.00114198f, -0.06093898f, 0.13326150f, 0.11003926f, 
    -0.33772442f, 0.10312542f, -0.30750781f, -0.76406819f, -0.29285789f, 0.03181282f, -0.22534662f, 0.05413608f, 
    0.29676396f, 0.06723351f, 0.10543218f, -0.04717859f, -0.15740818f, -0.21939151f, -0.17412999f, -0.08578569f, 
    0.06895480f, -0.15992744f, 0.00882235f, 0.06430589f, 0.21851808f, 0.02574926f, -0.04888936f, -0.10251863f, 
    -0.44502720f, -0.31612948f, 0.35085759f, 0.14618731f, -0.09739204f, -0.07268745f, -0.00031257f, -0.24692313f, 
    0.06502536f, -0.13526350f, -0.35430226f, -0.19192341f, 0.21955910f, -0.18469182f, 0.23374954f, 0.29226562f, 
    0.33306322f, -0.11967462f, -0.01507510f, -0.16273409f, -0.25334173f, -0.17685007f, 0.07765476f, -0.30696744f, 
    0.16686910f, -0.28972873f, -0.24508843f, -0.06006395f, 0.04253500f, -0.02899732f, 0.17271139f, -0.04880507f, 
    0.30649006f, 0.31418374f, 0.12074995f, 0.06803872f, 0.48112068f, 0.17055452f, 0.37100577f, 0.05507221f, 
    -0.09549289f, -0.09511882f, -0.16371354f, -0.05324434f, 0.07342280f, -0.02284919f, 0.11321802f, -0.23763736f, 
    -0.21762049f, -0.33371171f, 0.52212703f, 0.04283467f, -0.07898504f, -0.01549169f, 0.06497001f, 0.09620222f, 
    0.23249803f, -0.14015315f, -0.11487837f, 0.06034278f, 0.09672837f, 0.32876274f, -0.00734170f, -0.23870683f, 
    0.03100935f, 0.07659165f, -0.01257454f, 0.20716758f, 0.15322681f, 0.08726121f, -0.01478081f, 0.08313412f, 
    0.23406287f, -0.26308444f, 0.16784921f, -0.37400937f, -0.28451395f, -0.30851197f, 0.06855109f, -0.24374118f, 
    -0.16527610f, -0.16739027f, -0.35863751f, 0.15684414f, 0.14006644f, 0.43471536f, -0.57449955f, 0.03916144f, 
    0.07598493f, 0.13802245f, -0.21834834f, -0.19654928f, 0.11175738f, -0.08090332f, 0.16934444f, 0.21644510f, 
    -0.78204250f, -0.28140649f, 0.52685946f, -0.08049195f, 0.08577953f, 0.14106105f, -0.25190297f, 0.34188518f, 
    0.00043048f, -0.21914032f, -0.15338279f, 0.02789624f, 0.07859348f, -0.01589530f, -0.02589415f, -0.04969861f, 
    -0.13214038f, -0.15967761f, 0.12678035f, -0.00772486f, 0.18308453f, -0.10326155f, 0.04169452f, 0.03558666f, 
    -0.23169787f, 0.06087069f, -0.19842507f, 0.19498968f, -0.10444213f, 0.14616422f, -0.11129988f, -0.00645046f, 
    -0.27777100f, 0.07960691f, -0.17625540f, 0.05736698f, 0.10162436f, -0.11203692f, -0.57277304f, 0.08043252f, 
    0.10304943f, 0.16528484f, 0.15478761f, -0.08640040f, -0.03920331f, -0.14437065f, -0.02457323f, -0.11511953f, 
    -0.48502684f, 0.39612177f, -0.51548374f, -0.26241812f, 0.22727546f, -0.18546142f, -0.02151274f, -0.05902477f, 
    -0.25260270f, -0.12587538f, -0.17792813f, -0.16957270f, -0.27904564f, 0.03268697f, -0.21317062f, -0.00487973f, 
    0.16848108f, -0.18171269f, -0.02425659f, -0.04784997f, 0.12390381f, 0.08622462f, 0.03878551f, -0.30653152f, 
    -0.01446948f, 0.03812942f, -0.18850411f, -0.20019564f, 0.03118692f, 0.02989641f, 0.19601884f, -0.19779482f, 
    0.05409979f, 0.17944874f, -0.04977293f, 0.09528022f, -0.91306651f, -0.05054329f, 0.28334188f, -0.17690843f, 
    -0.03409822f, -0.05839106f, 0.12956649f, -0.14584295f, -0.14112851f, -0.17960839f, 0.26640603f, 0.11456753f, 
    0.09426429f, -0.29571819f, 0.14705376f, 0.25662467f, -0.09520303f, -0.02295617f, 0.04294413f, 0.04840503f, 
    -0.06289949f, 0.18818089f, -0.02674310f, 0.11141841f, -0.58478689f, 0.47001982f, 0.08154313f, -0.50043356f, 
    0.12772924f, 0.10444516f, 0.00796273f, -0.14728352f, 0.03073064f, 0.00210100f, 0.11986761f, -0.00537954f, 
    0.21598914f, -0.28595629f, 0.19806904f, -0.59193254f, -0.03320678f, 0.18706119f, -0.24411494f, 0.01183207f, 
    0.09822760f, -0.26854965f, -0.04389459f, -0.12082583f, -0.86729169f, 0.88244754f, 0.13923085f, -0.10193629f, 
    0.23759332f, 0.11522424f, 0.11664823f, 0.01964504f, 0.13276507f, 0.20556396f, 0.34310579f, -0.08204745f, 
    -0.62173033f, -0.30387014f, -0.03161414f, -0.01844587f, 0.04237648f, -0.29114026f, 0.17695121f, 0.17328548f, 
    -0.03453426f, -0.04652235f, 0.08583821f, 0.06057015f, -0.14749081f, -0.10852182f, -0.06196987f, 0.18482904f, 
    -0.02541067f, 0.03934646f, -0.02667038f, 0.01062337f, -0.23531786f, 0.25064158f, -0.14964403f, -0.05550489f, 
    0.97383225f, 0.31986383f, -0.11318516f, 0.06947756f, 0.38597104f, 0.08420544f, -0.12993957f, -0.05090538f, 
    -0.06721818f, 0.12874083f, 0.25908849f, 0.19126213f, 0.28219047f, -0.32621104f, 0.39352679f, 0.16819063f, 
    -0.06061237f, 0.03014397f, 0.08677112f, 0.00802748f, -0.02128985f, -0.04480927f, 0.07393681f, -0.25025922f, 
    0.07949810f, -0.06775003f, -0.10592644f, 0.00866518f, -0.04356788f, -0.07786658f, 0.09101760f, -0.12057534f, 
    -0.08852253f, 0.00637881f, 0.26457128f, -0.06853628f, -0.95663667f, 0.02016316f, 0.01958851f, 0.05848219f, 
    0.00112290f, -0.31001714f, -0.27792171f, -0.15745012f, -0.39828360f, 0.11523602f, -0.28382546f, -0.22053109f, 
    0.09617968f, -0.11002821f, 0.00604463f, -0.13153678f, 0.15368745f, 0.20751745f, -0.07306788f, -0.11349012f, 
    0.16103205f, -0.08984154f, 0.13576613f, -0.28713104f, -0.81965077f, -0.45006993f, -0.35890457f, -0.04680710f, 
    0.15152796f, -0.09944564f, -0.07366641f, 0.10667825f, -0.05778044f, 0.36043733f, 0.12447812f, 0.00464650f, 
    -0.33305296f, 0.12237281f, -0.11841360f, -0.29075980f, -0.09890218f, 0.02575774f, -0.01066880f, 0.20443983f, 
    0.06472675f, 0.12570052f, 0.01072299f, 0.30781123f, 0.31912658f, 0.23547384f, -0.16352712f, -0.18553604f, 
    0.09085859f, -0.01882580f, -0.15983070f, 0.20302184f, 0.07479418f, -0.08403891f, 0.02722939f, 0.18081653f, 
    0.44720933f, 0.19103464f, 0.02885023f, -0.22173052f, 0.24113777f, 0.20547253f, 0.12116029f, 0.05643531f, 
    -0.08133639f, 0.33633354f, -0.02562229f, 0.17654845f, -0.80178738f, -1.10889375f, -0.03602824f, 0.28721279f, 
    0.23278023f, 0.09570881f, 0.34629139f, 0.25082710f, 0.22230808f, 0.11267077f, 0.06009934f, 0.06900959f, 
    0.69480991f, -0.15049106f, -0.33814493f, 0.00997748f, 0.03339732f, -0.21826410f, -0.06884014f, 0.15675588f, 
    -0.20185804f, -0.12871352f, -0.17448653f, -0.02176577f, -1.10172904f, -0.29870787f, -0.22112492f, -0.57580781f, 
    0.31595483f, -0.04202790f, -0.15805957f, -0.12023997f, -0.07570913f, -0.18245289f, 0.08727558f, -0.01885683f, 
    -0.49160844f, 0.45722687f, -0.01819091f, -0.14043953f, 0.21079771f, 0.09704920f, 0.12577163f, 0.19341193f, 
    0.08823611f, 0.14871907f, 0.00850189f, 0.15232851f, -0.69455075f, -0.49200946f, -0.03364984f, 0.00409331f, 
    0.05100380f, 0.14087310f, -0.00933625f, -0.04625642f, 0.13038252f, -0.29052109f, 0.06319337f, 0.02546096f, 
    0.29303327f, -0.01433995f, 0.01306217f, -0.25920239f, -0.19961306f, 0.00570613f, 0.10891447f, 0.00741527f, 
    0.15538226f, 0.22080891f, -0.04483509f, -0.09504754f, 0.32854480f, 0.18260421f, -0.00991309f, -0.04233352f, 
    -0.31295842f, 0.17811699f, 0.01462743f, -0.04559639f, 0.23821855f, 0.06231628f, -0.08327284f, -0.13290013f, 
    0.00246743f, 0.12710622f, -0.12701596f, 0.10061483f, -0.19379592f, 0.14574932f, -0.11408765f, -0.14515322f, 
    0.09221638f, -0.08386610f, -0.02701839f, -0.22098306f, -0.53401768f, -0.21484803f, 0.26297340f, 0.05358480f, 
    0.25996569f, -0.02588713f, -0.00904225f, -0.04400633f, 0.20879799f, 0.16067326f, 0.05853127f, 0.33463565f, 
    0.27909744f, -0.27992523f, -0.48884660f, 0.17542779f, -0.14749365f, 0.22023092f, -0.21703793f, -0.06981972f, 
    0.04687495f, -0.06399880f, -0.06339639f, 0.07806255f, -0.28275925f, -0.08437432f, 0.19908953f, -0.51780170f, 
    0.32089129f, -0.12095628f, -0.07281310f, 0.03008873f, 0.12620673f, -0.11135732f, 0.00931519f, 0.09883981f, 
    0.01580977f, 0.48037040f, -0.16408379f, -0.03227313f, -0.05715226f, -0.22411078f, -0.42554849f, -0.14151296f, 
    0.14442503f, 0.00964623f, -0.17937824f, 0.07330946f, -0.79711783f, 0.20269856f, -0.20012209f, 0.39430854f, 
    0.13585779f, -0.06792624f, -0.13628234f, 0.22726816f, 0.09519067f, -0.25405517f, -0.10863690f, -0.09243669f, 
    0.30032447f, -0.23795839f, -0.13396350f, 0.00101128f, 0.08927746f, -0.08290887f, 0.09139030f, -0.20222893f, 
    0.04340192f, -0.15572689f, -0.22436970f, -0.11345276f, -0.81119215f, 0.39393985f, -0.48322323f, -0.00835720f, 
    0.03060164f, -0.09480349f, 0.28352013f, 0.15042537f, -0.09374727f, -0.15060809f, -0.02784150f, -0.12000883f, 
    0.05197662f, -0.07258128f, -0.10338113f, 0.14121458f, -0.08096696f, -0.02240366f, 0.06592792f, 0.16915268f, 
    0.12561154f, -0.17190890f, -0.05074869f, -0.07039566f, 0.20962277f, 0.59003246f, -0.17725495f, 0.15454996f, 
    0.46151236f, -0.03607905f, 0.10447900f, 0.02976240f, -0.01176595f, 0.24194393f, 0.11062245f, 0.06696197f, 
    -0.12609024f, 0.09121933f, -0.07049783f, -0.22646923f, 0.08540003f, -0.21442279f, 0.18509120f, -0.00175217f, 
    -0.00708461f, 0.09187374f, 0.19850865f, 0.06741967f, 0.55059892f, -0.38786662f, -0.43551719f, -0.67567521f, 
    -0.00070016f, -0.13262181f, 0.03301027f, -0.07150701f, 0.12492294f, 0.09260527f, -0.08761442f, 0.02103309f, 
    0.47328937f, 0.01085223f, -0.29864910f, 0.40347064f, -0.21320313f, -0.18328345f, -0.09515055f, 0.22518675f, 
    -0.09786884f, -0.20398635f, -0.06675790f, -0.18854874f, -0.43481082f, -0.20623207f, -0.16042529f, -0.30491799f, 
    -0.07727847f, 0.08281746f, 0.24441029f, 0.16501999f, 0.21491671f, 0.16488267f, -0.01565326f, -0.11722519f, 
    -0.12538469f, 0.41838583f, 0.06907060f, -0.05815586f, -0.17842737f, 0.15344682f, -0.25135055f, -0.18489252f, 
    -0.21622650f, 0.18906301f, 0.02568886f, -0.03634035f, -0.30276272f, -0.13641588f, 0.10523952f, 0.26498708f, 
    0.17129472f, 0.15608262f, 0.24530533f, -0.04961341f, 0.07157420f, -0.09680123f, -0.04392751f, -0.01116393f, 
    -0.52765900f, -0.17865726f, 0.18628217f, -0.16654897f, -0.25417390f, 0.01501634f, -0.20697299f, -0.10010326f, 
    -0.03286622f, 0.07992640f, 0.20970885f, -0.03186380f, 0.36067662f, 0.00964772f, 0.05726498f, 0.19343776f, 
    0.23254848f, 0.08803700f, 0.16196014f, 0.06108747f, -0.14349820f, 0.15297294f, -0.05170576f, -0.12625761f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15853058f, -0.03254956f, -0.10694345f, 0.07606718f, 0.02328944f, 0.09028420f, 0.05348969f, -0.22394854f, 
    -0.10964520f, 0.11434887f, 0.20230167f, 0.10108697f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
