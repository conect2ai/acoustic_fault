#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.03203874f, 0.07974081f, 1.19066632f, -0.10565022f, -0.44351348f, -0.46154478f, -0.42431530f, -0.28206778f, 
    -0.46075797f, -0.44123477f, -0.87638515f, -0.53141308f, 0.64966649f, 1.00576067f, -1.67591321f, -0.11408266f, 
    0.02229307f, 0.07768396f, 0.39243352f, 0.80675030f, 0.55828732f, 0.26903358f, 0.60269600f, 0.24029236f, 
    0.00159837f, 0.25095019f, -0.08731522f, 0.69142455f, -0.09361672f, 0.48403737f, -0.21627116f, 0.53247392f, 
    -0.57755232f, 0.09228580f, -0.32200852f, 0.24591719f, 0.90170276f, 0.76760888f, 0.25576645f, -0.55425262f, 
    0.11870597f, -0.39312908f, 0.43935785f, 0.43331751f, 0.22838417f, -0.09924056f, -0.23728265f, -0.91776729f, 
    -0.97605866f, -0.76007956f, -0.80457407f, -0.54948086f, -0.63416892f, 0.23969375f, 0.48622590f, 0.54689968f, 
    -0.22319119f, -0.19114459f, 0.59971565f, -0.26977500f, -0.16723071f, 0.32769778f, 0.21607824f, -0.20271775f, 
    0.18739958f, 0.14003859f, 0.23743260f, 0.81762785f, -1.09654677f, 0.31033659f, 0.14390177f, 0.40072715f, 
    -0.81885517f, -0.35086468f, 1.19253135f, 0.81741869f, -0.23403370f, 0.26988846f, -0.17728625f, -0.49605206f, 
    -0.05538929f, 0.27018866f, 0.59692216f, 0.75941300f, -1.01864696f, -0.35478988f, 0.79347873f, 0.32425439f, 
    0.09751295f, -0.50772911f, 0.06202876f, 0.47507459f, 0.49933794f, 0.31165648f, 0.68472910f, 0.21965227f, 
    0.34910551f, -0.93553114f, 0.24267690f, -1.37252939f, -0.78757352f, 0.34781039f, 0.37043825f, 0.03002370f, 
    -0.31236508f, -0.25876927f, -0.68943185f, -0.91674566f, -0.24129856f, 0.18613793f, -1.10488558f, 0.17772277f, 
    -0.44557348f, 0.05646228f, -0.65458083f, -0.64096910f, -0.51732600f, 1.14033937f, -0.56449747f, -0.80100697f, 
    0.25557494f, 0.25469080f, -0.76186222f, 0.79194325f, 0.33235556f, -0.24889091f, -0.48516333f, -0.91595113f, 
    -1.17808998f, 0.15359078f, 1.04422581f, 0.33299738f, 0.03497978f, 0.09731437f, 0.00461701f, -0.69440567f, 
    -0.87073964f, -1.08570027f, -0.25267392f, 0.40549687f, 0.40766659f, -0.09526867f, 0.22065659f, 0.71881318f, 
    0.43265757f, -0.52556759f, -1.10166442f, 0.46342716f, 1.19400573f, 0.50323433f, -0.40477851f, -0.49413741f, 
    -0.68401855f, -0.63523525f, 1.30374181f, -0.77379459f, -0.67333472f, 0.12841950f, 0.15897143f, 0.51945472f, 
    0.29852420f, 0.61278033f, -0.11227672f, 0.46992582f, 0.87070656f, 0.79360950f, -1.05974805f, -0.69061047f, 
    -0.02515010f, -0.22032444f, -0.07490803f, -1.14790404f, -0.73837388f, -0.34323192f, 0.41535667f, -0.24068396f, 
    -0.54047871f, 0.27858198f, 0.51233053f, 0.29788712f, -0.51799959f, -0.50604957f, 0.06488464f, -1.29267132f, 
    -1.16521895f, 0.65471083f, 0.49733147f, -0.35605401f, -0.36451560f, -0.60000491f, -0.04489965f, -0.52876168f, 
    0.31660995f, -0.33217752f, 0.31493446f, 0.22719140f, 0.61700326f, 0.52433085f, -1.06082749f, -0.74715209f, 
    -0.67726040f, 0.87900835f, 0.11057681f, 0.17767993f, -0.18581207f, 0.26894867f, -0.73283601f, -0.69342232f, 
    -0.89355022f, 0.98087496f, 0.14693226f, -0.62311602f, 0.71890938f, 0.44230321f, 0.06766136f, 0.13219360f, 
    1.70733595f, -0.98901886f, -0.53833097f, -0.03896559f, -0.14536604f, -0.58118147f, 0.36548269f, -0.03723937f, 
    0.50760722f, -1.19621325f, -0.12313949f, 0.74442041f, -0.28121033f, -0.59496057f, -1.03883588f, -0.32890111f, 
    -0.30896977f, -1.09235740f, 1.53049266f, -1.76248944f, 0.07259294f, -0.40523279f, -0.24979770f, -0.15139890f, 
    -0.02588105f, 0.27863634f, -0.67841369f, -0.96874398f, -0.33951369f, 1.00568366f, 0.48090079f, 0.32551169f, 
    0.52233720f, 0.06474184f, 0.30342731f, 0.61986530f, 0.72864974f, 0.62131804f, 0.52580798f, -0.07203446f, 
    -0.46490857f, -0.35270774f, -0.38764435f, 0.08798556f, 0.60065681f, 0.56766319f, 0.51068670f, 0.11954885f, 
    0.25104314f, 0.07596009f, 0.36510181f, -0.04524430f, -0.60947490f, -0.81755406f, 0.06875175f, -0.33900711f, 
    -0.58026922f, -0.96053964f, -0.80628753f, -0.97565037f, 0.19230026f, 0.06946000f, 0.58082008f, 0.11671803f, 
    0.18896136f, 0.82164896f, -0.47425956f, -0.49351764f, -0.82565933f, 0.76182914f, -0.05592818f, 0.79940951f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10838501f, -0.36966768f, -0.25449920f, 0.74781871f, 0.42328721f, -0.38655567f, 0.77237147f, 0.07442597f, 
    0.33202121f, 0.27710849f, 0.27680981f, -0.41874388f, 0.16388702f, 0.33458129f, 0.41973618f, -0.09215463f, 
    -0.09268906f, 0.07444599f, 0.43922061f, 0.12214489f, 0.64259750f, 0.43507770f, 0.35547251f, -0.13220069f, 
    -0.12210952f, -0.21331888f, 0.39904654f, 0.10620391f, 0.32179508f, -0.08271040f, 0.13794337f, 0.15634896f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.20632227f, -0.36881664f, 0.28620932f, 0.11613096f, -0.04292901f, 0.06967017f, -0.17764619f, 0.07727956f, 
    0.00795352f, -0.29573286f, -0.26772818f, -0.04677722f, -0.30856669f, -0.14754067f, -0.37387887f, 0.11132854f, 
    -0.03393840f, 0.28695330f, -0.16214024f, -0.12732823f, -0.09657165f, 0.00091930f, 0.09041546f, 0.16052848f, 
    0.15966877f, 0.09565824f, 0.15703169f, 0.11637115f, 0.02978078f, -0.07616442f, 0.24308813f, 0.07216994f, 
    0.09442186f, 0.05690470f, 0.12907358f, 0.06177689f, -0.01978801f, 0.12262695f, -0.00540541f, 0.07848984f, 
    -0.12353817f, 0.02508714f, 0.23507875f, 0.12985976f, -0.07414266f, -0.28009355f, -0.50922310f, 0.02088979f, 
    -0.01899168f, -0.16489154f, -0.06165382f, 0.02704629f, 0.01314230f, 0.04511058f, 0.15753984f, 0.05267862f, 
    -0.04798289f, 0.05185876f, -0.04434180f, 0.17519797f, 0.21700710f, 0.00351797f, 0.20020494f, 0.10033843f, 
    -0.21329719f, -0.15653171f, 0.16408609f, -0.08442487f, -0.05345336f, 0.01740476f, -0.11189982f, 0.35819703f, 
    0.09002566f, -0.11626372f, -0.13652594f, 0.01245413f, -0.02178062f, 0.00446825f, 0.09356220f, -0.10792783f, 
    -0.28690118f, -0.49014792f, -0.21959777f, -0.00861196f, 0.10753191f, 0.08636077f, 0.01982872f, -0.03466369f, 
    0.16486853f, 0.11047961f, 0.13605605f, -0.11992874f, 0.03674308f, 0.09076457f, 0.11580590f, 0.13244063f, 
    -0.03181962f, -0.00062492f, 0.27597359f, -0.29405797f, -0.01657555f, 0.10688663f, 0.00081067f, -0.21170028f, 
    -0.01575273f, 0.08015484f, 0.04480747f, 0.03488556f, 0.11158128f, -0.09434270f, 0.19454981f, -0.01300263f, 
    -0.05623160f, 0.07737605f, 0.03124790f, -0.04592336f, 0.06592731f, 0.04047848f, 0.07944269f, -0.02039896f, 
    -0.16751869f, -0.26883274f, -0.01057753f, 0.38119215f, 0.06959824f, 0.06369886f, 0.34566191f, 0.09451967f, 
    0.24437223f, 0.01488541f, 0.08255182f, 0.35101059f, -0.00532570f, 0.15207238f, 0.02459407f, -0.06524391f, 
    -0.26352188f, 0.27252004f, -0.16707757f, -0.26634574f, 0.10512496f, -0.02628631f, 0.06175283f, -0.09491620f, 
    0.23747891f, -0.30545682f, 0.12458607f, -0.25866956f, -0.27619538f, 0.00635674f, -0.06743570f, 0.01464318f, 
    0.02537528f, -0.13254745f, -0.00141365f, -0.00167524f, 0.14622769f, -0.07735854f, -0.21935199f, -0.03029577f, 
    0.26071468f, 0.03654350f, -0.04460881f, 0.11485022f, 0.26720491f, 0.33163366f, 0.07540250f, 0.14064023f, 
    0.05773774f, -0.05761046f, 0.03555122f, -0.21591948f, -0.26032203f, 0.14473218f, 0.16027646f, -0.17641579f, 
    -0.09188158f, 0.09899376f, -0.01592618f, 0.13589144f, -0.02595020f, 0.17095211f, -0.03458230f, 0.35980812f, 
    -0.10047004f, 0.13913117f, 0.04054169f, 0.07634725f, 0.14634052f, 0.07303640f, -0.01664344f, 0.12208807f, 
    0.10608669f, -0.06414115f, 0.14609192f, 0.06164609f, -0.16322449f, 0.13682166f, 0.16216114f, 0.29586187f, 
    0.03966307f, -0.04821697f, -0.06039872f, 0.26890749f, 0.07161850f, 0.05508611f, 0.08281200f, 0.14795819f, 
    -0.08739288f, -0.16994570f, 0.11147951f, -0.20200118f, 0.01678589f, 0.19138882f, -0.09294744f, 0.08185816f, 
    -0.15159386f, 0.08119895f, -0.14859396f, -0.40458313f, 0.11271331f, -0.31431919f, 0.37359616f, 0.21377945f, 
    0.04662569f, -0.20913902f, -0.09061521f, 0.24940924f, 0.01650748f, 0.02791714f, 0.02767063f, 0.05900791f, 
    -0.01860409f, -0.07902960f, -0.05348182f, -0.01772825f, -0.26466924f, 0.15388153f, -0.20952407f, -0.02744876f, 
    0.09245193f, 0.05178884f, 0.16178614f, 0.23340760f, -0.00474014f, -0.01358682f, 0.12839317f, -0.05691166f, 
    0.05231739f, 0.04628792f, 0.02087919f, -0.00517408f, -0.00415225f, 0.12282418f, 0.09896898f, 0.14628743f, 
    0.01404644f, -0.03100685f, -0.00677497f, -0.03227193f, -0.00791130f, -0.01924916f, -0.45888865f, 0.02556629f, 
    -0.03382166f, 0.05326045f, 0.02201185f, 0.11205328f, -0.05533944f, 0.21049051f, -0.07312352f, -0.09519510f, 
    0.08539329f, 0.12997156f, 0.07186427f, 0.06637033f, -0.04273308f, 0.06820965f, 0.03619246f, 0.13995115f, 
    0.12503637f, -0.11527713f, -0.07195942f, -0.01527628f, -0.21883905f, 0.29425210f, 0.17738943f, -0.14988667f, 
    -0.61543638f, -0.59203935f, -0.30146065f, 0.03653636f, 0.21017785f, 0.17311877f, 0.08425172f, 0.14808424f, 
    -0.29821235f, -0.16866601f, -0.36575264f, 0.38984567f, -0.01526523f, -0.04404923f, -0.23220235f, -0.06135627f, 
    0.08054379f, -0.02628244f, -0.47909325f, -0.22530416f, -0.29191816f, 0.12575664f, -0.00583894f, -0.09386542f, 
    0.18273507f, 0.06079175f, 0.10477714f, -0.10411055f, -0.31738660f, -0.36989054f, -0.01533143f, 0.17341807f, 
    0.01209228f, 0.14729020f, -0.05740355f, 0.24754705f, -0.05904101f, -0.57478851f, -0.17486973f, -0.02056500f, 
    -0.13239463f, 0.29020020f, 0.13320230f, -0.19187732f, 0.01828265f, -0.05837579f, 0.59046078f, 0.26219729f, 
    -0.07503100f, -0.07686612f, -0.28305814f, 0.09020542f, 0.02658827f, -0.00343195f, -0.18650261f, -0.81175947f, 
    -0.27639794f, 0.01737951f, 0.30808455f, 0.18551263f, 0.26267982f, 0.05761962f, 0.07258960f, -0.47531193f, 
    -0.10795677f, -0.15365098f, 0.01689489f, 0.20773287f, 0.00265088f, 0.14396201f, 0.03393740f, 0.04837491f, 
    -0.62641901f, -0.29828939f, -0.17151651f, -0.17268954f, 0.15459563f, -0.00970936f, -0.00587077f, 0.31221944f, 
    0.09391522f, -0.48350871f, -0.56812543f, -0.12537925f, 0.13760114f, -0.26066232f, -0.00400272f, -0.12626010f, 
    0.30847615f, 0.08254643f, -0.43161649f, -0.07894246f, -0.27445376f, -0.16357188f, -0.11396398f, -0.12576285f, 
    -0.06290342f, 0.02461907f, 0.10893443f, -0.12695958f, -0.11851865f, 0.15964104f, -0.04594104f, -0.21617781f, 
    -0.05176058f, 0.25677899f, -0.07667713f, 0.17297709f, 0.16530205f, 0.42021701f, 0.13477576f, 0.09467420f, 
    0.00698145f, 0.12734312f, 0.07430793f, 0.09758424f, -0.00787287f, 0.06071074f, -0.50773436f, -0.21622263f, 
    -0.12945192f, -0.11350503f, 0.30172899f, 0.16835272f, -0.07455685f, -0.10267547f, -0.03981450f, -0.07212511f, 
    0.38872981f, 0.10811391f, 0.14062160f, 0.08887126f, 0.16731854f, 0.13767670f, -0.04419671f, -0.21329843f, 
    -0.07464565f, 0.22073694f, -0.01460629f, 0.14557865f, 0.03801234f, 0.16828690f, -0.06955563f, 0.16033366f, 
    -0.04612118f, 0.07335244f, 0.35947266f, -0.12203546f, -0.08940987f, -0.27203971f, 0.24874203f, 0.13359955f, 
    -0.04299737f, -0.14235389f, -0.14636634f, -0.47863820f, 0.17497361f, -0.12696099f, 0.35698396f, 0.09768154f, 
    -0.07481211f, -0.16263819f, -0.45434469f, -0.36694956f, -0.38945228f, -0.18737425f, 0.07351496f, 0.09606407f, 
    0.04708058f, 0.16394253f, 0.01950895f, 0.23022132f, 0.02340887f, 0.44674793f, 0.20723984f, 0.19132595f, 
    -0.00578625f, -0.04487962f, -0.06536252f, 0.24671790f, -0.17882524f, 0.30688971f, 0.46742308f, -0.14452705f, 
    0.15574996f, -0.00527875f, 0.19363192f, 0.20265751f, 0.10063572f, -0.02783493f, 0.07714255f, 0.24849300f, 
    0.19484159f, 0.03035032f, -0.00758719f, 0.08817112f, 0.18994409f, 0.28019425f, 0.35729131f, 0.10330609f, 
    0.26191467f, 0.12374088f, 0.17235757f, -0.01008929f, 0.23591264f, -0.14720315f, 0.23313290f, -0.48233074f, 
    -0.44013381f, -0.30800405f, -0.14260109f, 0.36144269f, -0.03502902f, 0.30661690f, 0.08876592f, -0.09085245f, 
    0.20545030f, -0.08049741f, -0.17307089f, -0.21948436f, 0.13781378f, 0.07223673f, -0.06479818f, -0.16399588f, 
    0.06978343f, -0.23885448f, -0.08349946f, 0.20246159f, -0.07670783f, -0.02961028f, 0.15074554f, 0.05894224f, 
    0.00454473f, 0.06496481f, 0.19159795f, -0.03667645f, 0.04775591f, -0.00095270f, 0.07030185f, -0.02996396f, 
    0.10005943f, 0.02419925f, -0.06591137f, -0.68694580f, -0.22261100f, -0.43644178f, -0.03330462f, 0.04893255f, 
    0.11352141f, 0.05564895f, 0.35182703f, 0.37982190f, -0.23528244f, -0.57419091f, -0.27317071f, -0.20711078f, 
    -0.00998323f, 0.16450876f, 0.00990120f, -0.03060956f, -0.10472801f, -0.10088950f, 0.00671988f, -0.31667089f, 
    0.10035089f, -0.13927244f, 0.01783807f, -0.03302300f, -0.11105041f, 0.04058870f, 0.20895465f, 0.42169449f, 
    0.30589509f, -0.07734465f, 0.07790396f, -0.08574362f, 0.11707659f, -0.09634724f, -0.04412175f, 0.27977526f, 
    -0.01450575f, -0.12219296f, -0.11211961f, -0.02395665f, 0.05423889f, -0.14882070f, -0.30817002f, 0.00104935f, 
    -0.28284660f, -0.03510080f, -0.29528362f, -0.28232232f, 0.04084378f, -0.13286020f, 0.06466811f, 0.01368840f, 
    0.06359640f, 0.44357082f, 0.19139679f, 0.28206170f, -0.01015733f, -0.07516357f, 0.00987789f, -0.18894331f, 
    0.24676478f, -0.15840822f, -0.40145606f, -0.31777567f, -0.22563323f, -0.40886503f, -0.07278337f, -0.16651545f, 
    -0.05303937f, -0.30133852f, -0.30657104f, -0.08420914f, 0.51648271f, 0.09741084f, -0.17644902f, 0.14284992f, 
    0.15300815f, 0.15044905f, 0.12315132f, 0.20134148f, -0.85004759f, -0.11642830f, -0.07484648f, -0.02556472f, 
    -0.07580795f, 0.08097939f, 0.02866462f, -0.15285411f, 0.13674937f, -0.19768357f, -0.55423278f, 0.13873415f, 
    -0.14212978f, 0.06875252f, -0.06989837f, 0.10455820f, -0.00430102f, -0.01965107f, -0.51258767f, 0.39322197f, 
    -0.08488008f, 0.12832060f, -0.14528996f, -0.18478602f, 0.08695030f, 0.02958058f, 0.23403759f, -0.21081957f, 
    0.57751286f, -0.25012058f, 0.04690774f, -0.10132986f, 0.12923472f, 0.08634854f, 0.13201806f, 0.37949660f, 
    0.14353828f, 0.19852181f, 0.10842140f, 0.13043647f, 0.29248083f, -0.30360189f, 0.16554697f, 0.18644388f, 
    -0.28531155f, 0.00210219f, 0.42128083f, -0.16522117f, -0.27425647f, -0.03509717f, 0.28911480f, 0.04839041f, 
    -0.06040605f, 0.13531081f, -0.11928774f, -0.25790432f, -0.07551664f, -0.08142643f, 0.14560261f, 0.07663016f, 
    0.02197687f, -0.11575227f, 0.06065892f, 0.21714482f, -0.10873710f, 0.07992949f, -0.19947284f, 0.18132579f, 
    -0.13893501f, -0.01234522f, -0.03150172f, -0.22035244f, 0.05422823f, 0.06452317f, 0.08828714f, 0.08537767f, 
    0.25411940f, 0.09159774f, 0.12110683f, -0.16279767f, 0.02094297f, 0.00592685f, 0.31474531f, 0.17425011f, 
    -0.26668411f, 0.15283829f, 0.26707658f, 0.05840184f, -0.09393033f, -0.04618195f, -0.01182516f, 0.16124754f, 
    -0.15270710f, 0.00965109f, 0.04333598f, 0.03426911f, 0.11750817f, -0.18292125f, -0.14903992f, 0.06450980f, 
    0.17313765f, -0.19822045f, 0.01169906f, 0.06719214f, 0.10297205f, 0.25473174f, -0.01262921f, -0.15587048f, 
    0.05036784f, 0.13219732f, 0.22454529f, 0.04807429f, -0.00955537f, -0.25801557f, 0.02690561f, -0.60771555f, 
    -0.26611611f, -0.52679199f, -0.16553634f, 0.17501290f, 0.36315390f, 0.26453987f, 0.00811673f, -0.00817819f, 
    -0.01747302f, 0.12986436f, -0.34166294f, -0.15290222f, 0.37320617f, -0.09459820f, 0.05995944f, -0.11975222f, 
    -0.01195453f, 0.22038431f, 0.20715907f, 0.09417408f, -0.00689104f, 0.09939013f, -0.05745189f, 0.07553449f, 
    0.20237075f, -0.06937493f, 0.04938715f, 0.11337006f, 0.02567848f, -0.06329078f, -0.32063293f, 0.11447660f, 
    -0.07583576f, 0.19178911f, 0.07658730f, 0.06536993f, 0.04251701f, -0.00368082f, -0.19072923f, 0.00294808f, 
    0.00869183f, 0.11788956f, 0.25732127f, 0.09323640f, 0.19706725f, -0.04132901f, 0.01819978f, 0.22789785f, 
    0.21993706f, 0.05281365f, 0.21300621f, 0.17607215f, 0.08352469f, 0.03006851f, -0.31676838f, -0.34876823f, 
    0.01058752f, -0.61780888f, 0.00897676f, 0.12692724f, -0.05140049f, -0.09285268f, 0.18340585f, -0.02209845f, 
    0.17972320f, -0.71526062f, 0.04693826f, -0.23539865f, -0.05145259f, 0.23629127f, -0.21256167f, 0.12335332f, 
    0.01765061f, 0.37884870f, -0.26109675f, 0.10501233f, -0.12304776f, 0.07147990f, -0.08559072f, -0.12017710f, 
    0.05434662f, -0.19077468f, 0.24283423f, 0.09559149f, -0.15991661f, -0.21427915f, 0.03226979f, 0.22537908f, 
    0.19371006f, 0.32599351f, 0.04066838f, -0.08396006f, 0.07827278f, -0.10949129f, -0.17336583f, 0.17158774f, 
    0.12210607f, 0.15936840f, -0.01403243f, -0.04328367f, -0.62138945f, 0.21060950f, -0.07330042f, -0.08302319f, 
    0.04968852f, -0.13927747f, 0.16627564f, 0.24030772f, 0.10340045f, -0.16278847f, -0.04910330f, -0.16090235f, 
    -0.10135069f, -0.34205398f, -0.36041197f, -0.01687122f, 0.01621116f, -0.06670358f, -0.10319583f, -0.54166418f, 
    0.11385530f, -0.08733216f, 0.05318264f, 0.12937398f, -0.04875741f, -0.01585375f, 0.05509200f, -0.30935860f, 
    0.04802669f, 0.03288624f, -0.02449664f, 0.00565530f, 0.15262979f, 0.04991314f, 0.18005753f, 0.34473667f, 
    -0.01073440f, -0.00922683f, 0.01401380f, -0.04776103f, -0.05024796f, 0.03815813f, 0.01806685f, 0.03008247f, 
    0.00606451f, -0.03212389f, 0.02690244f, -0.03612320f, -0.06120709f, 0.02915650f, -0.02764908f, -0.02623545f, 
    -0.03013240f, -0.00157891f, 0.00072461f, -0.06099006f, -0.04903899f, 0.02057989f, -0.02947601f, -0.01276035f, 
    0.01530318f, -0.00129034f, 0.01665708f, -0.05623375f, -0.01106477f, -0.04647807f, 0.04271123f, -0.01839893f, 
    -0.03002369f, 0.04696163f, 0.02876989f, 0.01693980f, -0.01137332f, -0.04866685f, -0.04345869f, 0.01882494f, 
    0.01129952f, -0.00711482f, 0.03614227f, -0.04097624f, 0.01763958f, -0.03017917f, 0.04761923f, 0.02146991f, 
    -0.01300214f, -0.05456135f, 0.03787787f, -0.04942207f, 0.03707652f, -0.06589762f, 0.02163851f, -0.06458759f, 
    0.00062114f, 0.02759725f, -0.03387675f, 0.04201429f, -0.06176412f, 0.00709692f, -0.03577351f, -0.01619953f, 
    0.03192653f, 0.00802483f, -0.06043018f, 0.03203711f, 0.04644392f, 0.03880819f, -0.00084741f, -0.03207887f, 
    -0.05217436f, -0.04584188f, -0.01763304f, -0.00473086f, -0.01450492f, -0.06375811f, -0.01885986f, -0.05945596f, 
    -0.06394990f, -0.04956670f, 0.02057200f, 0.02719213f, -0.01761634f, -0.03802326f, -0.03533660f, -0.00212933f, 
    0.04134014f, 0.05205701f, -0.05710670f, 0.02990109f, -0.04423966f, 0.04150401f, 0.02800626f, 0.02112091f, 
    -0.05641100f, 0.03488274f, -0.01150852f, -0.02131244f, 0.01853355f, -0.03659554f, -0.03776681f, -0.03052919f, 
    0.02603233f, -0.03234301f, -0.05821448f, -0.04777567f, -0.00709648f, -0.05802333f, -0.02372486f, -0.02065899f, 
    0.02283646f, 0.03979051f, 0.01085474f, -0.04948752f, -0.04008573f, 0.00005991f, -0.05644187f, 0.01702392f, 
    0.01508437f, 0.00156810f, 0.03308320f, 0.00292015f, 0.01477191f, -0.02866014f, 0.01232325f, 0.01892861f, 
    -0.03777236f, -0.02125563f, -0.00471602f, 0.04770159f, -0.05791727f, -0.03081301f, 0.02511166f, 0.01584564f, 
    -0.01379175f, 0.04453230f, 0.03523566f, 0.03440000f, -0.05167381f, -0.06501540f, 0.03970673f, 0.04313793f, 
    0.02828891f, 0.04184974f, -0.03539625f, 0.02053198f, -0.01868986f, -0.02344885f, 0.04121237f, -0.03110348f, 
    0.03753679f, -0.02638361f, -0.03138320f, -0.05747820f, 0.01389672f, -0.02163815f, -0.01285085f, -0.03645841f, 
    0.00368626f, 0.00076849f, -0.01866827f, 0.02074835f, 0.02804478f, -0.01926649f, 0.05104993f, -0.00584708f, 
    0.02816767f, 0.01842440f, 0.04817821f, 0.04997086f, 0.01805702f, -0.02457849f, 0.00017374f, -0.05960352f, 
    -0.00473494f, -0.01761559f, 0.01977879f, 0.03373989f, -0.06187907f, -0.04350307f, -0.04939450f, -0.03242760f, 
    -0.04290297f, 0.02946863f, 0.03170568f, -0.03458256f, 0.03560641f, 0.02567750f, 0.04314438f, -0.01791153f, 
    -0.05743470f, 0.04817459f, 0.00113969f, 0.01718332f, 0.01199802f, 0.04625871f, 0.00929286f, 0.05419180f, 
    0.02541249f, 0.01978359f, -0.02968350f, -0.03605926f, -0.01657874f, -0.03391858f, -0.06013021f, -0.03699265f, 
    0.04682522f, 0.00733951f, -0.01091828f, 0.02649392f, -0.03828789f, -0.00076372f, -0.00222763f, 0.00470054f, 
    -0.02649669f, -0.03657524f, 0.00218660f, -0.01449802f, -0.03176052f, -0.03009310f, 0.00980510f, -0.05439721f, 
    -0.04658601f, -0.04592706f, -0.03077404f, -0.03954380f, 0.03670156f, 0.04999802f, -0.00955889f, 0.02027759f, 
    0.02373355f, -0.02291729f, 0.04328409f, -0.00217089f, -0.05495866f, 0.00738849f, 0.01989291f, -0.05028962f, 
    0.01899903f, 0.04688480f, 0.04951130f, 0.02171691f, -0.05191917f, 0.00536849f, -0.00211481f, -0.01634584f, 
    0.03770902f, -0.03980197f, -0.02345911f, -0.01987410f, -0.02053628f, 0.02808429f, 0.04303648f, -0.06208022f, 
    -0.02444012f, -0.05289571f, -0.05322929f, -0.03518615f, 0.00116630f, -0.05129486f, -0.04683687f, 0.03986688f, 
    0.02103535f, 0.04634251f, -0.02250765f, 0.00065545f, -0.00122407f, 0.00092893f, -0.00443288f, 0.04863592f, 
    -0.02143415f, -0.02703579f, -0.04709381f, -0.05850376f, 0.04178952f, -0.05835971f, -0.03963536f, 0.01760063f, 
    0.03372747f, -0.03418988f, 0.02922678f, -0.01656612f, -0.00850138f, -0.01173141f, -0.06064026f, -0.01069025f, 
    -0.03877733f, -0.00188312f, 0.17345446f, 0.00473263f, -0.00431173f, -0.02161555f, -0.16075870f, -0.15207620f, 
    -0.01076571f, 0.08752693f, 0.23614956f, 0.17395726f, -0.35172141f, 0.05694110f, -0.16078748f, 0.06391244f, 
    -0.15559056f, 0.27363068f, -0.06128029f, 0.12068197f, 0.19692369f, -0.02684908f, -0.15064304f, 0.02878218f, 
    0.15182433f, -0.26036519f, -0.08205042f, 0.02863595f, 0.06053503f, 0.14061105f, 0.03451668f, 0.06753801f, 
    -0.10907401f, -0.02270007f, 0.20566753f, 0.07559405f, -0.15780424f, -0.03425015f, 0.17870890f, 0.12612319f, 
    -0.08446650f, 0.09159191f, 0.16264570f, 0.17036079f, 0.27543119f, -0.31146199f, -0.13309206f, -0.36603573f, 
    0.03912838f, -0.05948712f, -0.13228822f, 0.23688212f, 0.11032525f, -0.18518837f, 0.15384482f, -0.03641218f, 
    0.14618804f, 0.24834947f, -0.13631153f, 0.20384572f, 0.28169334f, -0.14964393f, 0.08271707f, 0.34012294f, 
    0.00914959f, 0.08212535f, -0.09331448f, 0.28974628f, 0.19183612f, 0.10570602f, 0.09059638f, 0.05000628f, 
    0.04086863f, 0.04895173f, 0.03281992f, -0.16802590f, 0.16392013f, 0.11630773f, -0.09230662f, -0.08885466f, 
    -0.38136920f, 0.00843562f, 0.20039219f, 0.47409821f, 0.02673963f, -0.03275710f, -0.05818601f, -0.02288305f, 
    0.06497958f, 0.30671138f, -0.00245658f, 0.09178258f, 0.20753494f, -0.10034211f, 0.18622331f, 0.01775742f, 
    -0.08946399f, -0.35215968f, -0.13998407f, -0.59162939f, 0.09743048f, 0.26646668f, -0.12725253f, -0.10584463f, 
    -0.08683521f, 0.06737147f, -0.19864760f, -0.76713437f, 0.06800411f, 0.12328384f, -0.19657391f, -0.12515789f, 
    -0.03056837f, -0.04602978f, -0.05103753f, 0.00872950f, -0.28362122f, -0.07882971f, -0.09077604f, 0.06670358f, 
    -0.19266197f, 0.00852157f, 0.17340930f, 0.03771237f, 0.26270008f, 0.00887355f, 0.28384820f, -0.04468316f, 
    -0.07031374f, -0.12460893f, -0.05120134f, -0.12340639f, -0.06047517f, -0.07350606f, 0.10777158f, 0.09359024f, 
    0.11409657f, 0.31731194f, -0.21127105f, -0.11861891f, -0.12851608f, 0.02127361f, -0.00988626f, 0.20984267f, 
    -0.05086981f, -0.11017933f, 0.01309484f, -0.41711605f, 0.02727657f, -0.24746521f, -0.18695532f, -0.34321192f, 
    -0.23512562f, 0.20125440f, -0.11326658f, 0.08209341f, 0.28867349f, -0.04065005f, 0.03853602f, 0.05074032f, 
    -0.10369633f, 0.28427377f, -0.08227080f, 0.05928478f, 0.19705066f, 0.03824902f, 0.05401753f, -0.00647742f, 
    0.12056894f, 0.12237959f, -0.10640138f, -0.04630430f, 0.04270519f, 0.41299605f, -0.09628730f, -0.11538776f, 
    0.04812989f, 0.17945066f, 0.11489946f, 0.07545021f, 0.02280316f, 0.18192065f, 0.06603691f, 0.20094129f, 
    0.05506842f, 0.07836826f, -0.10353084f, 0.13119788f, -0.19440037f, 0.10883648f, -0.10434493f, -0.00148018f, 
    0.28105989f, -0.02697559f, -0.02714339f, 0.17390217f, 0.03947125f, 0.09520401f, 0.10587338f, -0.05484998f, 
    -0.19663393f, -0.06952376f, -0.12377296f, -0.01385059f, -0.02739761f, -0.08440736f, -0.03059575f, 0.24844719f, 
    -0.08999441f, -0.24306786f, 0.15076317f, -0.26154011f, -0.01565598f, 0.03692200f, 0.11025380f, -0.09687360f, 
    -0.33809400f, -0.07172346f, -0.26969886f, 0.10047220f, 0.10883524f, -0.02951482f, -0.13862288f, 0.17032383f, 
    0.11111039f, -0.49500653f, -0.09898545f, 0.20351723f, 0.08646607f, -0.00666739f, 0.13505253f, 0.08107755f, 
    0.03110405f, -0.51495624f, 0.30782524f, -0.35696071f, -0.33220261f, 0.10894384f, -0.06855911f, 0.03773570f, 
    -0.01824559f, 0.19287439f, -0.12907891f, 0.18475890f, 0.12181683f, 0.06738554f, 0.13072935f, -0.04013328f, 
    0.11221097f, -0.00250177f, 0.00889875f, -0.04672620f, -0.08972740f, -0.11729802f, 0.12853251f, 0.14989141f, 
    -0.08975105f, 0.01810293f, 0.21667379f, 0.07855182f, 0.06692809f, -0.01636611f, 0.06484726f, 0.02602056f, 
    -0.03027758f, 0.05283234f, 0.06035949f, -0.03446612f, -0.37248242f, -0.17335588f, -0.12116778f, 0.14671822f, 
    -0.03878210f, 0.01881269f, 0.10731528f, 0.10741223f, 0.05666180f, 0.22011013f, -0.10291238f, 0.06062390f, 
    -0.09985728f, -0.31423625f, 0.10431206f, 0.03578959f, 0.18648443f, 0.04080057f, 0.36212283f, 0.12929885f, 
    0.08051638f, -0.10013317f, -0.44603360f, 0.09266922f, -0.17656787f, -0.14565341f, 0.30082253f, -0.14531781f, 
    -0.12069704f, 0.79133528f, 0.05059226f, 0.17863375f, -0.10815232f, 0.04962567f, 0.36371839f, 0.01414676f, 
    0.02484865f, 0.16171853f, -0.16226698f, 0.08105034f, -0.53508073f, 0.28892872f, 0.03057216f, -0.02698701f, 
    -0.27359557f, -0.13991831f, 0.06093461f, -0.06580198f, -0.72960472f, -0.00021186f, -0.22037554f, -0.49798191f, 
    -0.21008615f, -0.12382324f, 0.07443051f, -0.18301569f, -0.38280675f, -0.29523301f, 0.15576917f, -0.00158824f, 
    0.10148635f, -0.27600449f, -0.11059978f, 0.05441890f, 0.11626261f, 0.33439702f, 0.36514863f, 0.28141594f, 
    -0.09931770f, -0.03691937f, -0.03868878f, -0.03342893f, 0.01067724f, -0.10782740f, -0.31894255f, -0.65661681f, 
    -0.43011075f, 0.15852070f, -0.30460337f, 0.01639896f, -0.06934512f, 0.11415779f, -0.35495633f, -0.02707094f, 
    -0.35687640f, 0.61834371f, 0.17653510f, 0.00210224f, 0.40309757f, 0.05114767f, 0.01284618f, -0.03226280f, 
    0.40584391f, -0.26251847f, -0.00287532f, -0.27138352f, -0.03132498f, 0.10537534f, 0.34421018f, 0.07522354f, 
    -0.13166936f, -0.46911389f, -0.13560747f, 0.31390503f, -0.10903145f, -0.11333637f, -0.46896079f, -0.21738830f, 
    -0.05857396f, 0.13171589f, 0.16523758f, -0.41403538f, -0.31095541f, 0.17320406f, -0.53629977f, -0.05577875f, 
    0.06749728f, -0.09833862f, -0.08107229f, 0.77277601f, 0.04294361f, 0.37430301f, 0.04749456f, 0.12928756f, 
    0.06742959f, 0.05537678f, 0.12135912f, -0.11299851f, 0.03109130f, 0.40484837f, 0.47657210f, -0.07846939f, 
    0.04297277f, 0.26764658f, 0.07359213f, 0.01554899f, -0.05855938f, 0.10792191f, 0.28871995f, -1.05422747f, 
    -0.04848041f, -0.09607764f, 0.04112384f, -0.14539315f, 0.30078065f, 0.10878658f, 0.35136998f, 0.03069463f, 
    -0.27736571f, 0.12007572f, 0.14305921f, 0.20751415f, 0.02067077f, -0.02013578f, -0.00568470f, 0.34905714f, 
    0.38344058f, -0.28767699f, 0.13260759f, 0.00513430f, 0.28271702f, 0.14821161f, 0.07410794f, 0.01066511f, 
    0.72367561f, -0.20235470f, -0.34537414f, 0.32768390f, 0.18780406f, 0.15946808f, 0.25343022f, 0.06819182f, 
    0.20573926f, -0.27921712f, 0.09497450f, -0.43526006f, -0.00237143f, -0.29081458f, 0.03116682f, 0.16594136f, 
    0.22043107f, -0.24008797f, -0.43071854f, -0.15449923f, -0.55415612f, -0.17765155f, -0.14480069f, -0.39476630f, 
    -0.11005695f, -0.08904687f, -0.15779904f, 0.47632959f, 0.28773701f, 0.22825104f, -0.03828235f, -0.16931707f, 
    0.15706618f, -0.11168569f, -0.02093247f, 0.07945151f, 0.01190838f, 0.20187894f, 0.22033557f, -0.06613933f, 
    -0.07736044f, -0.18869375f, -0.04032733f, 0.08602330f, -0.05148473f, -0.08544897f, -0.08542494f, -0.20754917f, 
    0.15384094f, -0.15358198f, -0.02576275f, -0.21428180f, 0.06063951f, -0.01772583f, 0.14860284f, -0.11116600f, 
    0.33404472f, 0.11917368f, 0.12434463f, 0.16608174f, -0.02467626f, 0.10832674f, 0.00214497f, 0.01924502f, 
    -0.75702953f, 0.79195386f, -0.19680354f, 0.23860636f, 0.30544028f, 0.06764252f, 0.26006600f, -0.04281323f, 
    0.55274552f, 0.82242191f, -0.81548661f, -0.37899384f, 0.02345683f, -0.11866810f, 0.16259575f, 0.46160933f, 
    0.06607656f, 0.51842898f, 0.09564062f, 0.03896806f, -0.00654891f, 0.15400432f, 0.03400743f, 0.09247213f, 
    -0.24198675f, 0.07498479f, 0.25952414f, 0.21456456f, -0.24638775f, -0.01348559f, -0.11033666f, -0.09619423f, 
    -0.00707074f, -0.11519732f, 0.01362646f, -0.17106403f, -0.20718212f, -0.14604667f, -0.12886688f, -0.06426572f, 
    0.10374463f, 0.06617381f, -0.00210231f, 0.03905656f, -0.17832702f, -0.78514344f, -0.22826467f, 0.09981403f, 
    -0.01837687f, -0.32563677f, 0.06331502f, 0.24612793f, -0.22943814f, 0.07579582f, -0.13000183f, -0.42773557f, 
    0.20669834f, 0.00707132f, 0.08141740f, 0.04505873f, -0.13790292f, 0.05968156f, 0.25553587f, 0.32178152f, 
    0.20853832f, -0.12456465f, -0.12842868f, -0.02381576f, 0.01515741f, -0.02715007f, 0.07179271f, -0.10454827f, 
    0.07080997f, 0.47824198f, -0.07235146f, -0.03056109f, -0.15158243f, -0.25311488f, 0.16611332f, 0.21110119f, 
    0.00591086f, 0.05163150f, -0.20267335f, 0.03376208f, 0.00779052f, 0.00879946f, -0.05226235f, -0.03245920f, 
    0.19869131f, -0.84589088f, -0.37275988f, -0.69578862f, -0.03270604f, -0.14437552f, 0.18883373f, 0.11046778f, 
    -0.01966414f, -0.01358229f, 0.18390235f, -0.01894850f, 0.05338197f, -0.04491197f, -0.01992181f, -0.08051693f, 
    -0.22252764f, -0.35202244f, -0.08975788f, 0.21475177f, -0.09596246f, 0.02038196f, 0.01026404f, 0.15694968f, 
    0.04032120f, 0.16943727f, 0.07718649f, 0.09191237f, 0.27145287f, 0.02616188f, -0.01072634f, 0.06206469f, 
    -0.06255550f, 0.16030329f, 0.11779103f, 0.07534615f, -0.18202983f, -0.28161719f, -0.05638328f, -0.66548187f, 
    -0.03393774f, -0.09441619f, -0.11204599f, -0.02490099f, -0.06041982f, 0.03944724f, 0.12216887f, 0.05865962f, 
    -0.03487426f, 0.03925429f, 0.05427074f, 0.08591501f, 0.03639260f, -0.05928003f, -0.01693992f, 0.00316091f, 
    -0.09772051f, -0.04213102f, 0.11085686f, 0.01209830f, 0.09883121f, 0.25205913f, -0.02118172f, 0.05249894f, 
    0.07449345f, 0.20698404f, 0.11007822f, 0.06220053f, 0.04074820f, -0.13109982f, 0.12331492f, -0.03059756f, 
    0.14150698f, 0.28488475f, -0.01593990f, -0.02412261f, -0.07276856f, -0.07910014f, 0.03135302f, -0.15299228f, 
    0.52461809f, -0.11253385f, 0.04482938f, 0.09594063f, 0.11203913f, 0.06537636f, 0.06373416f, -0.02631909f, 
    -0.19149199f, -0.23923023f, 0.08364674f, -0.50906539f, -0.17797561f, -0.53157920f, -0.24366701f, -0.15725616f, 
    -0.07487182f, -0.11821825f, -0.18318076f, -0.05305882f, -0.14488296f, -0.53572977f, -0.52517772f, -0.09467988f, 
    -0.04316708f, -0.17379147f, -0.14511558f, -0.04953520f, 0.06873660f, 0.11379403f, 0.18432663f, -0.15381707f, 
    0.25690255f, 0.23549710f, -0.02379263f, 0.36763886f, 0.07982897f, 0.02049410f, 0.05317532f, 0.23601529f, 
    0.15215969f, -0.26462430f, -0.07644527f, -0.02690912f, 0.00387887f, -0.01688709f, -0.19280235f, 0.02862408f, 
    0.50531781f, 0.21795388f, 0.07991132f, 0.13804036f, 0.15574580f, 0.01365433f, -0.02665409f, -0.04854465f, 
    0.15846525f, 0.04350579f, 0.20907071f, -0.41441774f, 0.03374198f, -0.18229711f, 0.02352491f, -0.00980228f, 
    -0.01957346f, -0.17379110f, 0.07720990f, -0.06250560f, -0.06986506f, -0.07071983f, -0.26111710f, 0.11206491f, 
    0.12977554f, -0.00233122f, 0.01340111f, 0.02444455f, -0.08408225f, 0.03359131f, 0.11267009f, 0.04733391f, 
    0.14838877f, -0.17732452f, 0.24247378f, -0.28205064f, 0.30168086f, 0.48424533f, -0.16338527f, -0.09513548f, 
    0.07623018f, 0.12113086f, 0.05389617f, 0.07786977f, -0.47898534f, -0.46915573f, -1.44975686f, 0.04475187f, 
    0.03803474f, 0.02320607f, -0.03484838f, 0.05610028f, 0.01163829f, -0.10760518f, 0.02202045f, 0.04159324f, 
    -0.12671518f, 0.00025900f, 0.02957004f, 0.19324413f, 0.04725409f, 0.07922407f, 0.00505141f, -0.22387938f, 
    -0.08271146f, -0.30743787f, -0.07464671f, 0.13119079f, -0.00275065f, 0.02110066f, 0.06063206f, -0.05229059f, 
    -0.13614301f, -0.11891086f, -0.28091344f, -0.05890005f, -0.17741251f, 0.27192652f, -0.03940164f, 0.00570422f, 
    0.25778148f, 0.66286957f, -0.40793565f, -0.14798747f, 0.23523274f, -0.07511505f, 0.31465235f, 0.06725703f, 
    0.18519162f, -0.06788896f, -0.20552641f, -0.84384930f, -0.08659586f, -0.07900552f, -0.15340573f, -0.03154803f, 
    -0.23488775f, 0.02841803f, -0.06701555f, 0.24050194f, -0.55995375f, 0.05572405f, 0.09890675f, 0.16925886f, 
    0.20253736f, 0.06923398f, 0.05597888f, 0.04335999f, 0.03747462f, 0.15709464f, -0.19671696f, -0.28744984f, 
    -0.12598629f, 0.13340257f, -0.08335500f, -0.01058239f, 0.15125372f, 0.07958568f, -0.09171633f, -0.02736335f, 
    0.03818494f, 0.12825720f, -0.02844598f, 0.05373380f, -0.30065250f, 0.09070326f, 0.03368743f, 0.08372327f, 
    0.01920130f, 0.00139762f, -0.14518560f, 0.05995272f, 0.15062700f, 0.37499520f, -0.09060556f, -0.04160826f, 
    -0.25920641f, 0.02870752f, 0.05974675f, -0.12940875f, 0.08414602f, -0.05518237f, 0.06592687f, 0.35514113f, 
    0.10749596f, 0.28336319f, -0.09097154f, 0.12603287f, 0.09110025f, 0.14983578f, 0.12425807f, 0.03312466f, 
    0.16644333f, 0.44619849f, -0.08741038f, -0.03543081f, -0.04404725f, -0.05400922f, -0.10502024f, -0.14552277f, 
    -0.15996778f, -0.07281201f, -0.10424438f, -0.64281458f, -0.02997180f, 0.18805429f, 0.09533876f, -0.01709990f, 
    -0.12618417f, -0.27146992f, -0.11084705f, 0.15443313f, -0.02516670f, 0.02221345f, -0.00510292f, -0.05447183f, 
    0.08441974f, 0.08850620f, -0.02061497f, 0.05043540f, 0.18505192f, 0.27367726f, 0.06608952f, 0.02806484f, 
    0.02081001f, 0.06540748f, -0.12444685f, 0.06551684f, -0.00180610f, 0.16303657f, 0.12226125f, -0.01064593f, 
    0.11572826f, 0.02227886f, 0.02985782f, 0.16776827f, 0.03623284f, 0.10772807f, -0.19327758f, -0.09437111f, 
    -0.00124568f, -0.06828675f, -0.06562662f, -0.10400124f, 0.00616914f, 0.17958750f, -0.10509119f, 0.07327355f, 
    0.06817456f, 0.04697424f, -0.00080992f, 0.01313604f, 0.05876875f, 0.19281104f, -0.03923082f, -0.18630697f, 
    0.08130094f, -0.10390416f, 0.23370905f, -0.03367644f, 0.02106980f, 0.15827283f, 0.02307490f, -0.16818038f, 
    -0.18990484f, 0.09940342f, -0.29353043f, -0.00727783f, -0.11647536f, 0.16588975f, -0.01681610f, 0.06662845f, 
    -0.03380583f, 0.03920689f, 0.38654068f, -0.05766442f, -0.12186452f, 0.07549150f, 0.17651971f, 0.00513731f, 
    -0.03070281f, -0.14617646f, -0.13879849f, -0.01061044f, 0.03507282f, -0.07732549f, 0.07815745f, 0.03558519f, 
    0.13767663f, 0.16250710f, 0.01589219f, 0.20464469f, -0.09442790f, -0.49798763f, 0.13955934f, -0.04079892f, 
    0.01209167f, -0.02347998f, 0.21149048f, 0.07296401f, -0.03196993f, -0.11801019f, 0.08060659f, 0.04041780f, 
    -0.26059157f, 0.05366373f, 0.05217798f, 0.25889501f, 0.13658249f, -0.12292092f, -0.01861885f, 0.24234709f, 
    -0.24145865f, 0.03985284f, -0.01283840f, 0.11113919f, -0.06381162f, 0.01098048f, 0.27017793f, -0.51705158f, 
    -0.22992145f, 0.08526585f, 0.12809344f, 0.14924069f, -0.01499339f, 0.05649221f, 0.00567887f, 0.22698657f, 
    -0.79628217f, -0.17925298f, 0.06490437f, 0.00271303f, 0.06920784f, 0.01087040f, -0.05988533f, -0.01030914f, 
    0.13019669f, -0.48143992f, 0.11999296f, -0.03845883f, 0.11756915f, 0.03583717f, 0.25691444f, -0.04928124f, 
    0.25738171f, 0.13033536f, 0.40258420f, -0.04195344f, -0.09095053f, 0.21833752f, -0.03258182f, 0.09858792f, 
    0.15979937f, -0.21526012f, -0.02804892f, 0.40948209f, -0.14268404f, 0.07426105f, -0.09251835f, 0.02997863f, 
    -0.14849728f, -0.01496111f, -0.16119176f, 0.19202939f, -0.01901412f, -0.25166172f, -0.00384497f, 0.12423541f, 
    0.05001964f, 0.04623681f, -0.16125068f, -0.02315344f, 0.02053410f, -0.55525041f, -0.06569786f, -0.00945644f, 
    0.05145033f, 0.07342032f, 0.07284087f, -0.03102622f, 0.21502244f, 0.12966527f, -0.14482036f, -0.02359946f, 
    0.10827072f, 0.18243851f, -0.00918743f, 0.21246789f, -0.08352232f, 0.07165329f, 0.36950234f, -0.12639707f, 
    -0.32188150f, 0.13282542f, 0.12653579f, 0.18094346f, 0.09753493f, -0.06148875f, 0.01197400f, 0.04710798f, 
    0.11237595f, -0.14577059f, 0.20315301f, 0.12066369f, 0.00757234f, 0.06999031f, 0.10952999f, 0.02720943f, 
    -0.00042573f, -0.25045851f, 0.71852309f, -0.30465901f, -0.32863522f, 0.17374474f, 0.07898878f, -0.09724410f, 
    -0.09222408f, 0.07677013f, 0.10763196f, -0.29294631f, -0.02398525f, -0.16059572f, -0.03324846f, 0.06115048f, 
    0.01910381f, 0.12209681f, 0.12396708f, -0.46048707f, 0.21365568f, 0.02386630f, 0.08544772f, 0.04747705f, 
    0.17503017f, -0.03162500f, -0.01881484f, -0.12107859f, 0.05121506f, -0.15836947f, 0.04908470f, -0.06741459f, 
    -0.11055843f, 0.07400987f, 0.05253097f, -0.00501817f, -0.13184337f, 0.14299622f, 0.07687340f, 0.04000164f, 
    0.07520042f, 0.03588828f, -0.12937549f, 0.15291958f, 0.10357310f, -0.13380550f, 0.02411851f, 0.05331805f, 
    -0.07199015f, -0.04601121f, -0.05820215f, -0.17311594f, -0.04781869f, -0.24624068f, -0.17286402f, -0.44254333f, 
    -0.04990279f, -0.04189458f, -0.02865216f, 0.12493780f, -0.09062203f, 0.04038235f, -0.02638106f, -0.01573551f, 
    0.19164646f, 0.00600156f, 0.13841993f, 0.03594147f, 0.13957192f, 0.07283525f, -0.06707844f, -0.01065674f, 
    0.04103103f, 0.46818608f, 0.07701094f, -0.04666944f, -0.06396703f, 0.00110012f, 0.12865947f, -0.25538513f, 
    0.09372372f, -0.06980222f, 0.00804750f, -0.60493267f, 0.13410804f, -0.10626573f, 0.25014779f, 0.05923045f, 
    0.09332838f, -0.00647598f, 0.17632781f, 0.00610207f, -0.03427783f, 0.03340131f, -0.00100251f, -0.00350155f, 
    -0.12309209f, -0.06410198f, -0.13368554f, -0.13081799f, -0.00002397f, -0.09346421f, 0.02278946f, 0.07695741f, 
    -0.00798204f, 0.11384209f, 0.13376218f, 0.18665139f, -0.09869886f, -0.03148882f, -0.12680361f, -0.06982761f, 
    0.02532598f, -0.00462816f, -0.03239062f, -0.05032854f, -0.09728236f, 0.23737893f, 0.15638669f, -0.01905280f, 
    0.03063837f, 0.06429739f, -0.04789772f, -0.11059892f, 0.09770581f, -0.12916146f, -0.03786554f, 0.02151912f, 
    -0.03642206f, -0.06082770f, -0.18584278f, -0.06213055f, -0.05393496f, -0.27109161f, -0.09704099f, -0.03073484f, 
    -0.14886159f, -0.11031380f, 0.09648285f, -0.29412279f, 0.56800526f, 0.08142494f, 0.03911023f, 0.00395727f, 
    0.28484970f, 0.19774364f, -0.13067335f, -0.14727221f, 0.11340140f, -0.00736139f, 0.23845214f, -0.00689869f, 
    0.03041557f, 0.02422128f, -0.22439788f, 0.08023979f, -0.12178135f, -0.15657248f, -0.24638453f, 0.00389472f, 
    -0.05278649f, -0.30809024f, 0.02812542f, -0.03640536f, -0.11094754f, 0.11615197f, 0.02456697f, -0.12240637f, 
    0.18013869f, 0.06333598f, 0.08998895f, 0.23518854f, 0.49089831f, -0.28655982f, 0.06207029f, 0.13766499f, 
    0.18123479f, 0.01341392f, -0.13333896f, -0.11385071f, 0.20193128f, -0.08909720f, -0.07825924f, -0.00395281f, 
    0.04487982f, 0.16143958f, 0.11875061f, -0.01762383f, 0.17390794f, 0.09147739f, 0.25594422f, -0.30222076f, 
    -0.18436888f, -0.24839021f, -0.13491841f, 0.11740457f, 0.13118465f, 0.11796629f, 0.14252310f, 0.25139442f, 
    -0.13317941f, 0.00676080f, 0.06876814f, -0.01208879f, 0.00790546f, 0.02635901f, -0.07345416f, 0.08885621f, 
    0.31245849f, 0.01612167f, 0.18388882f, 0.11260750f, -0.07975543f, -0.01096993f, 0.01186695f, -0.02657926f, 
    0.31809509f, -0.05863445f, -0.06893379f, 0.05357775f, 0.19332492f, 0.00372405f, 0.01876324f, 0.13664685f, 
    -0.26802188f, -0.17007622f, 0.03884256f, -0.07687797f, 0.03022726f, -0.20683490f, -0.10401835f, 0.11208121f, 
    -0.08678497f, -0.01719560f, 0.05021592f, 0.34536961f, 0.03349600f, -0.18785793f, 0.00940580f, 0.03700329f, 
    0.22876552f, -0.18525900f, 0.17464630f, -0.00497696f, 0.06751435f, -0.19909659f, 0.08558960f, -0.06168265f, 
    -0.06732925f, -0.06576045f, 0.07623766f, 0.04832107f, 0.18643942f, 0.11452690f, 0.16157109f, 0.06155155f, 
    -0.04859778f, -0.17784548f, -0.00898058f, 0.08357430f, -0.07174074f, -0.14801161f, -0.05469668f, -0.01398952f, 
    0.26382798f, -0.11083486f, 0.00614177f, -0.06300782f, -0.05025090f, 0.03511391f, -0.21212366f, -0.08652655f, 
    -0.35594612f, -0.03737592f, 0.22545570f, 0.02302005f, 0.03088413f, 0.12707005f, 0.18859419f, -0.10023199f, 
    0.00280114f, 0.11498328f, 0.04764378f, 0.05235076f, -0.11930621f, 0.06239574f, 0.15789680f, -0.10245440f, 
    -0.27770919f, 0.21363963f, -0.26774904f, -0.15629117f, -0.17608950f, 0.00915100f, 0.03857171f, 0.16297862f, 
    0.19505034f, 0.36097187f, 0.47453943f, -0.24421506f, 0.06707643f, 0.09466788f, 0.13219678f, -0.02051267f, 
    -0.26403701f, 0.03986503f, 0.00569991f, 0.19766837f, -0.06849395f, 0.03075197f, -0.38013256f, -0.05065306f, 
    -0.02375912f, 0.25725910f, -0.02670022f, 0.15518859f, -0.01974524f, 0.02926837f, 0.11477181f, 0.04901038f, 
    -0.34569165f, 0.11166666f, -0.02313144f, -0.01837058f, -0.02955060f, 0.13017343f, -0.01481129f, -0.03031904f, 
    0.10525023f, -0.05116244f, 0.02640487f, 0.04919979f, -0.00084700f, 0.10264180f, -0.07326436f, -0.12995540f, 
    0.11771058f, 0.06927218f, 0.02081221f, 0.02403326f, -0.04857638f, -0.20211303f, 0.48396936f, 0.08537796f, 
    -0.16820417f, -0.00762630f, -0.02313681f, 0.04856040f, -0.04303171f, 0.09935784f, 0.08244544f, 0.00439195f, 
    -0.00483538f, -0.09875754f, -0.19000837f, 0.11333183f, -0.08339401f, 0.09537297f, 0.15464355f, 0.18756287f, 
    0.45428175f, 0.76642871f, 0.04293219f, -0.07602847f, 0.18522790f, 0.01972372f, 0.19753632f, 0.09606687f, 
    0.07145212f, -0.09733690f, -0.28665343f, -0.04676044f, -0.19922434f, 0.11401539f, -0.22545034f, 0.05654771f, 
    0.21373786f, -0.08229808f, 0.01679765f, -0.07830294f, 0.01383814f, 0.09093582f, 0.09260464f, 0.20010942f, 
    0.16500728f, 0.00407561f, -0.08195269f, 0.01707635f, 0.06133818f, -0.02284953f, 0.08141311f, -0.02640846f, 
    0.02144005f, 0.07111490f, 0.18922415f, -0.02379985f, 0.17840339f, 0.07398787f, -0.08812520f, 0.09846224f, 
    -0.07449690f, 0.09927033f, 0.21667737f, -0.11048367f, -0.16611600f, -0.11565403f, -0.09209485f, 0.33075312f, 
    0.09251203f, 0.15019666f, 0.09738092f, -0.12240720f, -0.14305206f, 0.00095655f, -0.00102797f, -0.08082915f, 
    -0.02808039f, 0.04438021f, -0.14843093f, 0.04829663f, 0.09075710f, -0.10994194f, -0.05278448f, 0.00292052f, 
    -0.07652213f, 0.02858715f, -0.00965120f, 0.00680007f, -0.07435655f, -0.39662543f, -0.05865506f, -0.38700345f, 
    0.14707437f, 0.05808419f, -0.32979721f, -0.01846110f, 0.16583644f, 0.10499140f, 0.23828034f, 0.01147594f, 
    0.13678251f, 0.01592727f, 0.41702649f, -0.46579024f, -0.17860711f, -0.02871391f, 0.00292606f, 0.24869603f, 
    -0.15698430f, -0.17380476f, 0.03868007f, -0.09908298f, 0.04241541f, 0.18544197f, 0.10914304f, 0.10765517f, 
    0.04329726f, 0.02677673f, -0.20932510f, 0.00511231f, 0.05037675f, -0.35679492f, 0.10370788f, 0.39019215f, 
    0.23592989f, 0.08400545f, 0.00352109f, 0.10312371f, -0.21466632f, -0.24125603f, 0.25820348f, -0.00334248f, 
    -0.09558435f, 0.05914013f, 0.00493938f, 0.04084812f, 0.21130730f, 0.22049209f, 0.00050584f, 0.34717390f, 
    0.22332311f, 0.05850374f, 0.29908499f, 0.02684591f, -0.18126202f, -0.25605926f, 0.12296208f, -0.05145617f, 
    0.35509747f, -0.26276541f, -0.28052717f, -0.12743632f, -0.01675044f, 0.19912353f, -0.06235040f, 0.16291244f, 
    0.01943220f, 0.31184980f, -0.13416094f, 0.04529227f, -0.22475587f, -0.01107688f, 0.13642676f, -0.03688436f, 
    0.03946201f, -0.24439220f, 0.42542890f, 0.00255541f, -0.02458993f, 0.16526946f, -0.03416124f, 0.10614365f, 
    -0.09958605f, -0.10150135f, 0.03617447f, -0.03794571f, 0.06684981f, 0.11918546f, 0.06900544f, -0.29252467f, 
    -0.76418334f, -0.26510283f, 0.37485614f, 0.38586810f, -0.20027903f, -0.07028182f, -0.05597369f, 0.15607823f, 
    -0.00290195f, 0.11720376f, -0.05935230f, -0.02657943f, -0.07219336f, -0.00686719f, 0.09200538f, -0.01244194f, 
    0.20068812f, 0.22706324f, -0.15750888f, -0.00247671f, -0.26689366f, 0.20297159f, 0.17457108f, -0.03132231f, 
    0.23586720f, -0.00022959f, 0.05617515f, -0.08896631f, 0.01960147f, 0.09653556f, 0.02442624f, 0.06510690f, 
    0.09294690f, 0.04431451f, -0.13595334f, 0.08244374f, -0.15873289f, -0.15755251f, -0.05640671f, -0.02033358f, 
    -0.14003181f, -0.03186158f, 0.01205793f, 0.04707148f, 0.25617021f, -0.11816459f, 0.18352672f, 0.01990092f, 
    0.33142170f, 0.12433492f, 0.12820859f, 0.18684427f, -0.12189672f, 0.21919492f, -0.16013321f, -0.32482868f, 
    0.08741805f, 0.07983637f, 0.55682975f, 0.15100816f, 0.12835605f, -0.09244017f, 0.12759848f, 0.11788345f, 
    -0.11868674f, -0.04676846f, 0.27877039f, -0.10815367f, 0.17016940f, 0.19554721f, 0.03771999f, 0.02715021f, 
    0.09206709f, 0.15947632f, -0.34713936f, 0.22812647f, 0.35409534f, -0.01987293f, -0.05210971f, 0.17791159f, 
    -0.01753279f, 0.17833272f, 0.30670351f, -0.03410706f, 0.10674325f, 0.11146504f, 0.04748394f, 0.02949711f, 
    0.01238855f, -0.05942309f, -0.08557051f, -0.44860342f, 0.01870853f, 0.11503199f, -0.10600141f, -0.03853052f, 
    -0.02463062f, 0.01967742f, 0.11457825f, -0.01999085f, -0.14414634f, 0.02747617f, 0.04669656f, -0.07671482f, 
    0.09805713f, 0.09420368f, 0.13734122f, 0.25393507f, 0.04651127f, -0.11896913f, 0.18683328f, -0.02609131f, 
    0.32095265f, 0.20929311f, 0.16040275f, -0.04786622f, -0.03506739f, -0.17508145f, -0.13404161f, 0.09131432f, 
    0.04104792f, -0.04592277f, 0.16942653f, -0.07905155f, 0.05614541f, -0.09750506f, -0.19162838f, -0.46895653f, 
    -0.12410776f, -0.23759702f, 0.12228339f, 0.10881601f, 0.06123662f, 0.09093969f, -0.07292037f, 0.10127586f, 
    -0.21324787f, 0.09659364f, 1.04325771f, -0.50014472f, -0.06409803f, 0.20275062f, -0.19405869f, 0.05371244f, 
    -0.08058970f, 0.30433092f, -0.01985264f, -0.12274100f, 0.01232168f, 0.11430239f, 0.17514767f, 0.03645501f, 
    0.16731201f, -0.00968619f, -0.12331931f, -0.12890747f, -0.17447880f, -0.03028080f, 0.03060198f, 0.05907309f, 
    0.06810672f, -0.12228907f, -0.10692978f, -0.17536280f, -0.21439342f, -0.07190650f, -0.03231286f, 0.04472068f, 
    0.10040271f, 0.13509163f, -0.09948148f, 0.13049985f, -0.09480987f, 0.42859271f, 0.47619280f, 0.38700154f, 
    0.19742183f, 0.05999256f, 0.13070853f, 0.09592535f, -0.13376400f, -0.06853827f, -0.18844990f, -0.14493231f, 
    -0.06706057f, 0.05454159f, 0.13189635f, 0.08137883f, -0.09166836f, -0.02524214f, 0.00158423f, 0.06817896f, 
    0.21675619f, 0.13760382f, 0.04659642f, 0.07833863f, -0.22112106f, -0.07492165f, 0.03384197f, -0.01552742f, 
    -0.09954961f, -0.10165565f, 0.20931260f, 0.02135728f, -0.05902931f, -0.11582311f, -0.20348074f, -0.19252987f, 
    -0.41148484f, -0.15765238f, -0.13406318f, -0.04469399f, -0.00847093f, -0.01562059f, 0.19028267f, -0.01580043f, 
    0.10913142f, 0.04185402f, -0.07957677f, -0.16496933f, -0.09103739f, 0.11282398f, 0.11917353f, 0.06912313f, 
    -0.05663145f, -0.23635297f, -0.15496144f, 0.00838058f, 0.04130600f, 0.09247027f, 0.11078954f, 0.13889748f, 
    -0.06875624f, 0.11104916f, 0.11450768f, -0.23477344f, 0.03908008f, 0.17029361f, -0.00825331f, 0.13493012f, 
    0.12582180f, -0.07076079f, -0.03665381f, -0.03722826f, -0.34202904f, 0.03205467f, 0.32375509f, -0.14193785f, 
    0.03153125f, 0.05187983f, -0.25987598f, 0.03412255f, -0.04151711f, 0.15799840f, 0.03525673f, 0.06150076f, 
    -0.55186814f, 0.21771617f, -0.10465909f, 0.05072508f, 0.08761618f, -0.02292774f, -0.03435965f, 0.04335323f, 
    0.15731888f, -0.15211557f, 0.29836047f, -0.19030030f, -0.11295574f, 0.17332341f, 0.05130019f, 0.15069138f, 
    0.11391041f, 0.16930540f, -0.69848943f, 0.25102779f, 0.00288630f, 0.05594939f, -0.03458648f, -0.21284699f, 
    -0.28746474f, 0.05506093f, 0.16841182f, 0.09017225f, -0.12562260f, 0.01020994f, -0.15431044f, -0.07386993f, 
    0.17697236f, -0.08083595f, -0.31129593f, -0.53125542f, -0.03698887f, 0.11392590f, -0.02242514f, 0.13624096f, 
    -0.15359688f, 0.05882549f, -0.33689165f, 0.25449148f, 0.18259127f, -0.02306859f, 0.09193963f, 0.04099593f, 
    -0.05931051f, 0.12997665f, -0.02563476f, 0.02903106f, 0.12225605f, 0.13694464f, 0.03974554f, 0.06395093f, 
    -0.06091942f, 0.26948988f, 0.07675685f, 0.00963676f, -0.17743774f, 0.09263943f, 0.16605449f, 0.12680270f, 
    0.03626243f, 0.04756340f, -0.16504119f, 0.06006931f, 0.07117146f, 0.00824367f, 0.00716454f, 0.13145058f, 
    -0.30121204f, 0.22245020f, 0.02153026f, -0.12202480f, -0.11919320f, -0.15136197f, -0.19947638f, 0.30524677f, 
    0.22621857f, 0.47087109f, 0.17443705f, -0.02437834f, 0.04779907f, -0.01102648f, 0.05198679f, -0.02999956f, 
    -0.12757921f, 0.12045800f, 0.03762317f, 0.15267828f, 0.11860955f, 0.07390682f, 0.22044966f, -0.24718258f, 
    0.16177759f, 0.06735500f, 0.28736821f, 0.18742421f, 0.01479262f, 0.06462772f, 0.11437107f, 0.17045003f, 
    0.07115178f, -0.34247646f, 0.21987179f, 0.19457349f, -0.04751980f, 0.13447936f, 0.23330674f, 0.19730918f, 
    0.11795763f, -0.03621650f, 0.00198730f, 0.06282620f, 0.01400407f, 0.05298429f, 0.02152572f, -0.03819058f, 
    -0.19664894f, -0.12252782f, 0.00571992f, 0.03066748f, -0.06559861f, -0.23640364f, 0.01763602f, 0.12376258f, 
    -0.01296549f, 0.19734715f, -0.00801998f, -0.00974413f, -0.08053485f, 0.00406276f, -0.10569103f, -0.03538615f, 
    0.23240103f, 0.02575642f, 0.11900113f, -0.16477691f, -0.03457977f, -0.21693616f, 0.24297482f, 0.23784129f, 
    0.13560735f, 0.14590134f, 0.03911703f, 0.08504982f, 0.08097497f, -0.08880467f, 0.02284523f, -0.10095087f, 
    -0.00903177f, 0.06726697f, 0.11484530f, 0.13408610f, 0.07096714f, -0.01858391f, -0.15343599f, -0.28741908f, 
    -0.06650431f, 0.00320386f, -0.04811910f, 0.03448892f, -0.04861743f, 0.01762693f, -0.02973014f, -0.00605845f, 
    0.04308704f, 0.02116711f, -0.03295827f, -0.02366392f, 0.01693540f, 0.01696941f, 0.01877145f, 0.02894634f, 
    -0.02779612f, -0.05663599f, 0.02654775f, -0.05554159f, 0.01355335f, 0.04073556f, -0.03398829f, -0.03714320f, 
    0.02018584f, 0.02848099f, -0.01923074f, -0.00479711f, 0.04097106f, -0.04418631f, -0.01473375f, 0.04911702f, 
    -0.00804956f, -0.03736440f, -0.05709706f, -0.06041027f, -0.01355043f, 0.01319187f, 0.03546130f, 0.01661789f, 
    -0.01148329f, -0.01150789f, 0.01061101f, -0.02539605f, -0.03366115f, -0.06085627f, -0.04323961f, 0.02917468f, 
    -0.01309473f, 0.00492373f, -0.00558573f, -0.02197735f, 0.01081045f, -0.03518170f, -0.01504760f, -0.04333615f, 
    -0.00727202f, 0.03544032f, 0.03774571f, -0.04885312f, -0.00314703f, -0.01425245f, 0.02203838f, -0.05040215f, 
    0.01087216f, -0.04690941f, -0.03459817f, 0.04462674f, 0.04267300f, 0.04581048f, -0.00633778f, -0.03933842f, 
    -0.01995312f, 0.03718836f, -0.04602913f, -0.04601441f, 0.03603802f, -0.01021306f, -0.00942260f, -0.04190668f, 
    -0.04972355f, 0.02393952f, -0.02006848f, 0.05356346f, 0.04787090f, -0.03118171f, -0.02224598f, -0.01687627f, 
    0.00376205f, 0.03033176f, -0.05733113f, 0.04738013f, -0.05422204f, -0.02559208f, -0.03410714f, 0.00880345f, 
    -0.01282431f, 0.03639858f, -0.04512811f, -0.00587332f, -0.05780097f, 0.04366664f, -0.03859891f, 0.00780526f, 
    0.04969094f, 0.00863035f, -0.04054445f, 0.01199952f, 0.04875180f, -0.01567153f, -0.02070486f, -0.04420887f, 
    -0.04896045f, 0.04177650f, -0.04523088f, -0.01842655f, -0.00336502f, -0.03638202f, -0.01897125f, -0.03559548f, 
    -0.02024243f, 0.00531653f, 0.05319430f, -0.05590433f, 0.03052576f, -0.01634630f, -0.01404469f, 0.04777972f, 
    -0.05284921f, -0.01137764f, 0.04821047f, -0.01210829f, -0.02899705f, -0.03215082f, -0.00537651f, -0.00411740f, 
    -0.00378810f, 0.01509809f, -0.00201645f, -0.01999172f, -0.00156729f, 0.02083340f, -0.06043921f, 0.03220285f, 
    -0.01555512f, 0.05030152f, -0.01416339f, -0.05732970f, 0.00125629f, 0.03634315f, -0.03420823f, 0.02861433f, 
    -0.00020886f, 0.00820824f, -0.04124331f, -0.02923591f, 0.02533028f, 0.02321325f, -0.00122652f, 0.03559202f, 
    0.02275405f, -0.03560204f, -0.05998803f, 0.02605892f, 0.02634407f, 0.03975274f, 0.01598632f, 0.02587989f, 
    -0.04727229f, 0.03555020f, 0.05028526f, -0.01677456f, -0.00268232f, 0.03375553f, -0.03623775f, 0.03354540f, 
    -0.04142220f, 0.03187227f, -0.01082353f, -0.00689662f, 0.00373024f, 0.02068928f, 0.01972118f, -0.05719892f, 
    -0.03990472f, -0.04212131f, -0.02803515f, -0.02032563f, 0.04964563f, 0.00251373f, 0.00176165f, -0.06157754f, 
    -0.00007614f, 0.04476117f, -0.00438236f, 0.00185736f, -0.03854080f, 0.02070765f, -0.01457879f, -0.03944118f, 
    0.03281169f, -0.04734807f, 0.02971507f, 0.02212879f, 0.04970639f, -0.04301065f, 0.00867082f, 0.00369622f, 
    -0.04580372f, -0.06032193f, -0.00691967f, 0.01497088f, -0.03968854f, -0.02211428f, -0.05529469f, -0.06148333f, 
    0.04256512f, -0.00735660f, -0.06105267f, 0.02531632f, -0.06463708f, 0.03547217f, 0.03416297f, 0.01130608f, 
    0.05073076f, 0.04996621f, 0.03983547f, -0.02334404f, -0.05312915f, -0.05585453f, 0.04479214f, -0.04927510f, 
    -0.05157779f, -0.02567616f, -0.05038794f, -0.02253984f, -0.05993254f, -0.03108162f, 0.04471814f, -0.00786860f, 
    0.02713154f, 0.04678889f, -0.05490620f, -0.03592479f, 0.00443761f, -0.01990507f, -0.03898394f, -0.01340026f, 
    0.01786987f, -0.00430016f, -0.02309172f, 0.01131230f, 0.00222955f, 0.03069713f, -0.02638447f, -0.05122897f, 
    0.00515635f, 0.01618691f, 0.01221342f, 0.01591196f, -0.05817321f, 0.02336784f, -0.01818490f, 0.00842526f, 
    -0.00699052f, -0.04459916f, 0.01809657f, -0.04696626f, 0.00351659f, -0.00786811f, 0.00718225f, -0.01083211f, 
    0.00183030f, -0.05358700f, -0.00578170f, 0.02879967f, 0.04268553f, -0.03584399f, -0.00057177f, -0.00262872f, 
    -0.03951700f, 0.04519588f, -0.02143080f, 0.01416373f, 0.02021599f, -0.05206627f, 0.05205286f, -0.01815875f, 
    0.04817748f, 0.03121811f, -0.04836499f, 0.04773508f, 0.01211783f, -0.01308075f, -0.04111146f, -0.05563905f, 
    -0.02656563f, 0.01345289f, 0.03590751f, -0.05758399f, -0.06360440f, -0.05305428f, -0.00650571f, 0.01223871f, 
    0.01881521f, -0.05795468f, 0.00978449f, 0.03278938f, 0.00470277f, -0.02842689f, 0.05008126f, -0.04884912f, 
    -0.03661289f, -0.06051951f, -0.03449190f, 0.01369575f, 0.02684416f, 0.03956386f, -0.00121976f, 0.00383445f, 
    -0.01232494f, -0.03126188f, -0.04454827f, -0.01987277f, 0.00565633f, -0.03805776f, 0.04755036f, 0.02290762f, 
    -0.01443237f, -0.02340127f, -0.03214396f, 0.01513103f, -0.02232089f, -0.04979913f, -0.00633362f, 0.01199282f, 
    -0.02006302f, 0.04347245f, -0.05122260f, -0.02188763f, -0.03013868f, -0.05134624f, -0.04163574f, 0.02181506f, 
    0.00410102f, -0.03046924f, 0.00483412f, 0.02567957f, -0.03838033f, -0.03170127f, 0.03688515f, -0.04254925f, 
    0.02528877f, 0.02013208f, 0.00131672f, -0.04923029f, 0.04855818f, -0.04494998f, -0.00842253f, -0.00759755f, 
    -0.00808322f, -0.02637450f, 0.03716449f, 0.01817408f, -0.03549841f, -0.00857450f, -0.03160336f, 0.04678396f, 
    0.05358070f, 0.04665018f, 0.04678916f, -0.06000305f, 0.00439496f, 0.01539190f, -0.03756864f, 0.00621639f, 
    0.02704087f, -0.06070519f, -0.05511764f, 0.03240210f, 0.00945846f, 0.00167776f, -0.00152420f, -0.04849041f, 
    -0.01150210f, -0.01589310f, -0.03299114f, -0.03300077f, 0.04990866f, -0.03317180f, 0.01938638f, -0.00873577f, 
    0.01225563f, 0.00335804f, -0.00717991f, -0.04237862f, -0.04500549f, -0.05735304f, -0.04530123f, 0.03600209f, 
    -0.06190509f, -0.02383703f, -0.00810655f, 0.05177200f, -0.03728994f, 0.03012739f, 0.00603581f, -0.03246456f, 
    -0.01501813f, -0.05763282f, 0.01388156f, 0.03795015f, 0.00107160f, 0.03794701f, 0.02892469f, -0.05518278f, 
    -0.02792354f, 0.00028574f, -0.02553114f, -0.04547632f, -0.04702210f, -0.04754888f, -0.00895425f, 0.02716590f, 
    0.03632404f, 0.00975762f, -0.03732566f, 0.00663196f, 0.03441778f, -0.05173987f, -0.01414910f, 0.00009995f, 
    0.04386514f, 0.00344753f, -0.04129058f, -0.06355508f, -0.04400522f, -0.04884942f, 0.00299660f, 0.04607857f, 
    -0.01305022f, 0.00867230f, 0.02038296f, -0.03656482f, -0.01733325f, -0.00568892f, 0.00563672f, 0.01898077f, 
    -0.01970858f, -0.00785541f, 0.03578965f, -0.05505509f, -0.05800315f, -0.03441114f, 0.00803403f, 0.00767588f, 
    -0.02401085f, -0.04801919f, -0.06140714f, 0.00249785f, -0.02688358f, -0.05678446f, 0.04183607f, -0.04203948f, 
    0.01658711f, 0.00472879f, -0.00442315f, -0.03251116f, 0.02602821f, 0.00310272f, 0.05052166f, -0.03895639f, 
    -0.01133929f, 0.05012469f, -0.06262407f, -0.05223763f, -0.06107196f, -0.04028480f, -0.03393144f, -0.06206159f, 
    0.03861784f, 0.03806698f, -0.04692586f, -0.02389748f, 0.03578214f, 0.03531718f, -0.00276104f, -0.01516631f, 
    -0.03740747f, -0.01807811f, -0.03425618f, -0.06332552f, -0.04143643f, 0.03651491f, -0.02064619f, -0.00639244f, 
    -0.02020663f, -0.02825853f, -0.00221020f, 0.03981891f, 0.04964027f, -0.05006016f, -0.05092751f, 0.03362565f, 
    -0.01430121f, 0.02909228f, -0.01683864f, -0.05120024f, -0.04660656f, -0.02463782f, -0.01404370f, 0.02002669f, 
    0.05115292f, 0.02138267f, -0.00638393f, 0.01464340f, -0.04285934f, 0.00296431f, 0.03554256f, 0.04800943f, 
    0.00919417f, -0.01028284f, -0.01086494f, -0.05169384f, 0.03826298f, 0.00711885f, 0.01311269f, -0.00090923f, 
    0.03117450f, -0.00110829f, -0.06296606f, -0.03402057f, 0.02928750f, 0.05017282f, -0.00401980f, 0.01378887f, 
    -0.04045127f, -0.05744779f, -0.00618709f, -0.02573860f, -0.01731324f, -0.06364483f, -0.02849688f, 0.03360068f, 
    -0.00144607f, -0.02551551f, 0.04068377f, -0.05575732f, 0.00300434f, -0.04051644f, -0.04709306f, -0.01876103f, 
    0.00534080f, 0.00459676f, -0.03257889f, -0.02178431f, 0.01817027f, 0.01835471f, -0.02490108f, -0.04537367f, 
    0.02226348f, -0.02446601f, -0.02622998f, -0.02007759f, -0.04148621f, 0.02057804f, -0.02891664f, -0.00667506f, 
    -0.02561350f, 0.03718539f, 0.02393972f, 0.03951721f, -0.04889164f, -0.00929635f, 0.03984262f, 0.03523022f, 
    -0.03754694f, -0.18302706f, 0.17643732f, 0.00026614f, -0.33639619f, 0.23959947f, -0.00216398f, -0.01285708f, 
    0.06078888f, -0.69046903f, -0.21273151f, -0.64042699f, -0.32474968f, 0.01266427f, -0.18336813f, -0.06414159f, 
    -0.15008122f, -0.07918883f, 0.12885496f, 0.26275235f, 0.21447231f, -0.19005816f, -0.14467971f, -0.21501365f, 
    -0.09607355f, -0.05283316f, 0.03492387f, 0.17417029f, 0.13705562f, 0.21345246f, -0.11901724f, -0.04671639f, 
    -0.01556332f, 0.10619846f, 0.04856386f, 0.09726077f, 0.14379844f, 0.23612729f, 0.11016589f, -0.12371132f, 
    0.02388906f, -0.08246371f, 0.03568829f, 0.10997538f, 0.03871264f, -0.04065694f, -0.16004986f, -0.50575453f, 
    -0.29881695f, -0.40364721f, -0.08478622f, 0.07022497f, 0.07201894f, 0.10659263f, 0.19309886f, 0.14684609f, 
    0.15555875f, -0.07236360f, 0.12742397f, -0.05713585f, 0.05938244f, 0.11456091f, 0.02919572f, -0.15591902f, 
    -0.05706337f, -0.06753324f, -0.07537607f, -0.02335334f, -0.04813106f, 0.27223116f, 0.14346549f, -0.24289516f, 
    -0.11589721f, -0.31898162f, -0.33501887f, 0.09759628f, -0.11870269f, 0.17949907f, -0.01712116f, 0.01697735f, 
    0.09459255f, 0.16357510f, 0.19047168f, 0.57818949f, -0.24841471f, -0.14471316f, -0.19558285f, -0.00820797f, 
    -0.02657655f, 0.19173221f, -0.06985374f, 0.00881207f, 0.04048488f, -0.10840097f, -0.01502338f, -0.16745780f, 
    -0.07450517f, 0.03930670f, 0.21255079f, 0.59406048f, -0.14137079f, -0.76525617f, -0.23842119f, -0.03204764f, 
    0.27755535f, 0.06858359f, 0.09344157f, 0.24030361f, 0.15342464f, -0.23377882f, -0.26595291f, -0.09763954f, 
    0.11484007f, 0.06611789f, 0.14876531f, -0.01110837f, 0.06091538f, -0.44912881f, -0.11349469f, -0.35565811f, 
    -0.05066157f, 0.31520158f, 0.28997651f, 0.22613727f, 0.18308954f, 0.07469768f, 0.01759346f, -0.70601743f, 
    -0.44655448f, -0.21221659f, 0.03109444f, 0.03857832f, -0.03467539f, 0.02177776f, -0.03770366f, 0.18870667f, 
    -0.50678921f, -0.15563053f, -0.24473287f, -0.03728124f, 0.03601294f, -0.00322726f, -0.09158048f, -0.09403701f, 
    -0.34785360f, -0.49418038f, -0.20602736f, -0.28061429f, 0.17456128f, -0.26861382f, -0.02112853f, -0.28365439f, 
    0.14563656f, 0.13039084f, -0.40667209f, -0.15359089f, 0.02753394f, -0.07470467f, -0.03790480f, 0.43129668f, 
    0.08495986f, -0.07623626f, 0.09680719f, 0.24574572f, 0.24792688f, 0.15411553f, -0.26090962f, -0.04056837f, 
    -0.04437309f, 0.15173222f, 0.11318221f, 0.12368333f, -0.45286900f, -0.34175622f, -0.21318223f, -0.08551466f, 
    0.14181530f, -0.08151739f, -0.07794538f, 0.02008316f, 0.25651863f, -0.56897384f, 0.46920484f, 0.07016647f, 
    -0.29736111f, -0.02561763f, 0.18321961f, 0.16972274f, 0.11975536f, -0.09738901f, -0.44560620f, -0.10210153f, 
    -0.03220263f, 0.08220091f, 0.04422618f, 0.30789945f, 0.09518782f, -0.12240427f, 0.18313293f, -0.34616071f, 
    -0.34056953f, -0.04100984f, 0.01316113f, 0.14383145f, -0.08091707f, 0.01308212f, 0.03192763f, -0.03492228f, 
    -0.58711624f, -0.17234235f, -0.00494505f, 0.03355421f, 0.07717825f, -0.12878394f, -0.00908564f, -0.20550890f, 
    -0.25918999f, -0.21038051f, -0.22668073f, -0.06131769f, 0.25741553f, -0.11264793f, -0.10662648f, -0.13342023f, 
    0.13761367f, 0.35839331f, -0.00985492f, -0.35907450f, -0.02447343f, -0.16149196f, 0.45581496f, 0.21209416f, 
    0.06351461f, 0.19038539f, 0.45802703f, -0.32251662f, -0.75624567f, 0.11740865f, 0.24689820f, 0.18275054f, 
    0.03322254f, -0.00313761f, -0.05530241f, 0.10823651f, -0.18469909f, -0.17208917f, -0.01891679f, 0.04549378f, 
    0.12656860f, 0.11483216f, 0.00935522f, -0.03662592f, 0.20821871f, 0.17508234f, 0.38322783f, 0.11913105f, 
    -0.04278575f, 0.02297250f, 0.17286228f, 0.14407822f, 0.05589351f, -0.35337612f, -0.16081624f, 0.35768700f, 
    -0.06491651f, 0.02683928f, -0.12269218f, -0.17487554f, -0.13037145f, 0.25229767f, 0.21160108f, -0.10010894f, 
    -0.12170813f, -0.02981759f, -0.13560995f, 0.03596328f, 0.02270230f, -0.00661234f, 0.13454691f, 0.14557560f, 
    0.20826946f, 0.28217664f, -0.04362915f, -0.14914775f, 0.04918150f, 0.05344654f, 0.29983801f, 0.19405933f, 
    0.03336519f, -0.07226034f, -0.59981376f, -0.00785708f, -0.12052021f, -0.14646555f, -0.04889108f, 0.10381678f, 
    0.26321644f, -0.35542008f, -0.24587423f, 0.12911279f, -0.43392956f, 0.05194478f, 0.00130734f, 0.23631369f, 
    -0.15587412f, 0.01808335f, -0.18032028f, 0.36326751f, 0.26667857f, -0.20727484f, -0.27189809f, -0.17369428f, 
    0.14423491f, -0.00381634f, -0.11081230f, 0.09091134f, 0.09427567f, 0.03243509f, -0.01289041f, 0.07419847f, 
    -0.02678338f, 0.07344898f, 0.10121629f, 0.14354520f, -0.16365996f, 0.06310490f, -0.05602017f, -0.06347099f, 
    -0.16987804f, -0.17461245f, 0.00326916f, 0.01122126f, -0.11722682f, -0.30096152f, -0.32153845f, -0.46646574f, 
    -0.05044201f, -0.13816461f, -0.34319955f, 0.01734322f, 0.06067177f, 0.15693775f, -0.20431319f, 0.27211443f, 
    0.17210081f, 0.08231957f, 0.10141526f, 0.02038650f, 0.08399796f, 0.18090783f, -0.09448238f, 0.06805398f, 
    0.23157960f, -0.15204737f, -0.04338727f, -0.18582377f, 0.15441619f, 0.03820068f, 0.04159497f, -0.10780083f, 
    0.08007676f, 0.17934942f, -0.10723697f, 0.05219944f, -0.06632048f, 0.13066015f, 0.04983223f, 0.02517243f, 
    0.17573856f, 0.05241807f, 0.07703860f, 0.03972257f, 0.09006068f, 0.03198359f, -0.17851035f, 0.21351586f, 
    0.00740394f, 0.02949369f, -0.09419544f, 0.26827863f, 0.14386947f, -0.13216057f, -0.29025042f, -0.21927546f, 
    0.11408848f, -0.00116813f, 0.21143346f, 0.19104598f, 0.08275918f, 0.14066242f, -0.13916074f, -0.29244417f, 
    -0.02079753f, 0.11637398f, 0.09079479f, 0.09809293f, -0.10251636f, -0.12318100f, -0.26365024f, 0.13735266f, 
    0.06780464f, 0.08723636f, 0.14510134f, 0.19206159f, 0.13422869f, 0.19903511f, 0.05441782f, -0.44620597f, 
    0.06166700f, 0.13763663f, -0.11313731f, 0.06145839f, 0.34522229f, 0.00031999f, -0.06471530f, 0.10978414f, 
    -0.08005753f, -0.18174902f, 0.24771176f, 0.05506368f, 0.17620832f, -0.06581995f, 0.08823143f, 0.07172650f, 
    0.42753756f, -0.09074597f, 0.02536604f, 0.15206498f, -0.01932465f, 0.11067823f, -0.21792066f, 0.09858961f, 
    -0.11455070f, 0.07976974f, 0.32165274f, -0.37449405f, -0.04194476f, -0.28952193f, 0.08399100f, -0.05330126f, 
    -0.17488095f, -0.04146874f, -0.42999047f, -0.31290063f, -0.05723103f, 0.19592552f, -0.10474052f, -0.08604461f, 
    -0.09157877f, -0.09275257f, -0.33959877f, 0.15424408f, -0.19041444f, 0.13724652f, -0.11538836f, -0.08666568f, 
    0.22333369f, 0.25370654f, 0.14334235f, -0.10368989f, 0.30839348f, 0.53111714f, 0.14546074f, -0.12677099f, 
    0.13022736f, 0.04087340f, -0.02976685f, 0.03017533f, -0.46131811f, -0.37331554f, 0.12697983f, 0.02101511f, 
    0.09275217f, 0.30747205f, -0.09162542f, 0.14842576f, -0.14012127f, 0.05996114f, -0.00150084f, -0.11880538f, 
    0.11772989f, 0.11580743f, 0.09106125f, -0.10193703f, 0.15971923f, 0.10444104f, -0.17735447f, 0.23964751f, 
    0.25913641f, -0.13773498f, -0.01635858f, 0.14003286f, 0.08962263f, 0.07943192f, -0.12896785f, -0.10538693f, 
    -0.53337163f, -0.83093315f, -0.13584854f, -0.01447856f, 0.22555947f, -0.18543150f, 0.04099126f, -0.14837982f, 
    0.72482216f, -0.10593995f, -0.85618573f, 0.34289774f, 0.07301613f, -0.32778683f, 0.09283075f, -0.02442692f, 
    -0.06275943f, 0.01863793f, -0.02587174f, -0.20042622f, 0.09217408f, -0.11352961f, 0.18310939f, 0.07564718f, 
    0.12749621f, 0.20370506f, 0.61398244f, -0.16457662f, -0.30251271f, 0.08425374f, 0.22986548f, -0.05860672f, 
    -0.04754141f, 0.18886468f, -0.00607551f, 0.13335414f, 0.06099781f, -0.28505439f, 0.03962627f, -0.20471576f, 
    0.29805830f, 0.04886999f, 0.09490488f, 0.19976358f, -0.16996735f, -0.08195911f, -0.14368391f, 0.08566455f, 
    -0.08230358f, -0.20569757f, 0.03545625f, -0.05076565f, 0.02564509f, -0.10792140f, 0.40836221f, -0.03773296f, 
    -0.14548518f, -0.03534637f, -0.09725609f, -0.09864005f, 0.09990919f, 0.12663139f, -0.39595631f, -0.14163303f, 
    -0.23427042f, -0.01919522f, -0.05147019f, -0.18936336f, -0.07320770f, 0.00012239f, 0.06302693f, -0.22616507f, 
    -0.00912636f, -0.14028817f, 0.01496844f, -0.20951802f, -0.31482652f, -0.02133613f, -0.06217420f, -0.04255292f, 
    0.04736560f, 0.04583988f, -0.00088492f, -0.04325010f, 0.01479623f, -0.04647643f, -0.03756428f, 0.01060235f, 
    0.01290459f, 0.05216690f, -0.00879819f, 0.03052406f, 0.04705672f, -0.03276799f, -0.03611416f, -0.03134638f, 
    -0.05783561f, -0.04511971f, 0.04221910f, -0.05750057f, 0.04537570f, 0.00828405f, 0.03619765f, 0.00362073f, 
    -0.02921225f, 0.02692723f, -0.00077127f, -0.06101396f, 0.00427179f, 0.01545330f, -0.02696150f, -0.03117352f, 
    0.05231139f, 0.03169386f, -0.01070105f, -0.03927339f, 0.00802414f, -0.00835844f, 0.05076358f, -0.04698486f, 
    0.01942565f, 0.04557231f, -0.02743108f, 0.00361589f, -0.05792579f, -0.01246440f, -0.03251086f, 0.02123385f, 
    0.01938248f, -0.01437094f, -0.01993402f, -0.04747214f, 0.01043586f, 0.01211238f, 0.00686702f, 0.00525687f, 
    -0.00748738f, -0.00827302f, 0.00917351f, -0.03627973f, 0.01499510f, 0.01890949f, -0.04760190f, -0.00823475f, 
    0.00004808f, -0.03653287f, -0.05354935f, 0.00543312f, -0.02514377f, -0.03558975f, 0.02243034f, 0.00958087f, 
    -0.01552438f, -0.00865245f, -0.06450891f, -0.04606941f, 0.01989865f, 0.02033110f, 0.01866160f, 0.00466390f, 
    0.03292721f, -0.01585899f, 0.04900777f, 0.01587232f, -0.06182879f, -0.04143243f, -0.00451595f, -0.04501883f, 
    -0.05618761f, 0.03551010f, -0.02960736f, -0.01661333f, 0.04771565f, -0.05168995f, 0.03553377f, 0.04316472f, 
    0.04479578f, -0.05173439f, 0.04205738f, 0.04475722f, 0.02752025f, -0.04326509f, 0.04773554f, 0.00606849f, 
    -0.00335192f, -0.00409700f, 0.00369210f, 0.01305498f, -0.00683427f, 0.04793314f, -0.00219878f, -0.00157334f, 
    -0.03127724f, -0.02192727f, 0.05211154f, 0.00922306f, -0.02440656f, 0.04838124f, -0.02956861f, -0.01376317f, 
    0.04277351f, -0.05708527f, -0.00851530f, -0.03031279f, -0.06280792f, 0.03613899f, 0.01953143f, 0.00818091f, 
    0.04018267f, 0.04536205f, -0.03469787f, -0.05781829f, -0.03957425f, -0.02306963f, 0.01310160f, -0.02893271f, 
    -0.02564884f, 0.01475206f, -0.02189041f, 0.03589348f, -0.01234714f, 0.03076766f, 0.00260176f, -0.04867763f, 
    0.02329594f, -0.00719467f, -0.05737953f, -0.03198682f, -0.00397754f, -0.03272225f, -0.05883253f, 0.01813548f, 
    -0.00532590f, 0.00298461f, -0.04193053f, -0.02818352f, 0.02196112f, -0.04699916f, 0.03304653f, -0.02023228f, 
    -0.06018991f, -0.00415756f, -0.02733758f, -0.01195460f, -0.03412070f, 0.02861544f, 0.03791221f, -0.03725443f, 
    -0.05267201f, -0.02794929f, -0.04875719f, -0.04689182f, -0.03346561f, -0.02426008f, -0.00156793f, -0.04376142f, 
    -0.04224402f, 0.03746635f, -0.05819467f, 0.04145445f, -0.02007819f, -0.00792920f, 0.04950811f, 0.03477697f, 
    0.01794076f, -0.00107727f, 0.00630737f, 0.01059778f, 0.02210795f, 0.01521455f, -0.03394329f, 0.04785329f, 
    -0.03997399f, -0.03796701f, -0.05538809f, 0.00846249f, -0.02025453f, -0.05416832f, -0.03699162f, -0.02360573f, 
    -0.04478841f, 0.04972167f, -0.06126580f, 0.04412080f, 0.04007128f, -0.02993031f, 0.00647327f, -0.02288952f, 
    -0.02897340f, -0.05343778f, -0.00153744f, -0.04595461f, -0.00582912f, 0.06176640f, -0.03210581f, 0.01513458f, 
    -0.00891736f, -0.03447124f, -0.04985245f, 0.00289646f, 0.03094385f, 0.01625347f, 0.04535262f, 0.01703744f, 
    -0.00624814f, -0.04652902f, -0.01496937f, -0.02877234f, -0.02222366f, -0.02327361f, 0.03834721f, -0.05467279f, 
    -0.00111561f, -0.02773695f, 0.04981210f, 0.02109174f, 0.04142395f, -0.05428365f, -0.00273634f, 0.03429698f, 
    0.04004296f, -0.01590164f, -0.04650585f, -0.01877545f, 0.01300468f, -0.03503289f, -0.00913565f, -0.00958916f, 
    -0.03213437f, 0.01327596f, 0.01401637f, -0.05295555f, -0.01079672f, -0.01799033f, 0.03416341f, -0.04496898f, 
    0.01885141f, 0.04200621f, -0.01379394f, -0.06093348f, -0.03950515f, -0.06446687f, -0.05744396f, 0.05282790f, 
    -0.04424357f, -0.04306913f, -0.05847483f, -0.01871261f, -0.06479291f, -0.00425521f, 0.02061885f, -0.01612233f, 
    -0.06012582f, 0.04625082f, -0.05054933f, -0.05595596f, -0.02136527f, -0.01092824f, -0.02072290f, 0.02758139f, 
    0.01739766f, -0.05844588f, 0.02211319f, 0.03113166f, -0.01538118f, 0.03826727f, -0.05399624f, 0.00034855f, 
    0.26955682f, 0.00546381f, 0.13884161f, -0.01661545f, -0.13728808f, -0.10206539f, 0.24076413f, -0.13348198f, 
    0.01966032f, -0.72062904f, 0.01029003f, 0.09621762f, 0.14279591f, 0.05228359f, -0.11000640f, -0.15255184f, 
    0.01533365f, -0.08085506f, 0.03071938f, 0.05453512f, 0.07521798f, -0.14538032f, -0.12230276f, -0.05590183f, 
    -0.14035428f, 0.02203556f, 0.07677996f, 0.02051649f, 0.09688672f, 0.23536648f, 0.10591535f, -0.03908858f, 
    -0.07174513f, -0.07796717f, 0.00819707f, 0.06864657f, -0.10040657f, 0.10802342f, 0.01028796f, -0.04435712f, 
    0.03876468f, -0.09732085f, 0.03259584f, -0.07960908f, 0.03618046f, -1.15570891f, -1.29709327f, -0.58879280f, 
    -0.09922052f, -0.10618654f, -0.26782846f, -0.09591477f, -0.26430839f, -0.08362008f, 0.11904999f, 0.12855433f, 
    0.13398701f, -0.03223063f, -0.00042351f, -0.00376380f, -0.00930414f, 0.02359142f, 0.06503392f, 0.08902860f, 
    0.12987050f, -0.06684968f, -0.18304755f, -0.15898184f, -0.10219269f, -0.00804715f, 0.08053696f, 0.00211534f, 
    0.21589348f, -0.09473033f, -0.07628240f, 0.16073000f, -0.26650497f, 0.14509884f, 0.20138928f, 0.18801935f, 
    0.04868561f, 0.10977839f, 0.13576117f, -0.06446598f, 0.10762197f, 0.06566917f, -0.11776771f, -0.19854674f, 
    0.11657679f, 0.20080522f, 0.10416369f, 0.06760100f, 0.01584790f, -0.10126345f, -0.17458571f, 0.00715314f, 
    0.15094048f, 0.12507483f, 0.17620479f, -0.43312186f, -0.31639937f, -0.10599621f, -0.09391631f, -0.18078244f, 
    -0.11239958f, -0.12446360f, -0.26431859f, -0.05646921f, 0.00512252f, -0.18991672f, -0.13843989f, 0.05053376f, 
    0.08927523f, 0.05597010f, 0.03300086f, 0.02464853f, -0.09519480f, -0.57753748f, 0.31338447f, 0.00582726f, 
    -0.28262255f, -0.10971870f, 0.01966035f, 0.18071115f, 0.08424068f, 0.03009233f, -0.04592359f, 0.04840264f, 
    0.40976745f, 0.02870341f, 0.14541377f, 0.10282223f, 0.08324216f, 0.13495272f, 0.05292188f, -0.32278794f, 
    0.34389311f, 0.66894960f, -0.14650089f, 0.06367337f, -0.07486472f, 0.02139061f, -0.07483821f, 0.02810734f, 
    -0.43310916f, -0.07554576f, 0.24908870f, -0.16601713f, 0.13129862f, -0.04888015f, 0.09663016f, 0.15275712f, 
    0.06312326f, 0.20618740f, -0.25521481f, -0.19411580f, -0.41110617f, -0.13292451f, -0.11190878f, 0.09585853f, 
    0.15432042f, 0.08722140f, 0.18988094f, 0.17493963f, 0.07147960f, -0.00373486f, -0.02533563f, -0.11496461f, 
    0.09672380f, 0.00981880f, -0.07570022f, -0.48997134f, -0.13589168f, 0.36041376f, 0.14834213f, -0.00997289f, 
    0.00203791f, 0.03941065f, 0.09941380f, -0.12617156f, -0.34257278f, 0.45403367f, 0.30992305f, 0.06054137f, 
    0.15965140f, 0.10230099f, 0.01217260f, 0.06620687f, 0.13357538f, 0.10395692f, 0.04666930f, 0.03103259f, 
    -0.11087407f, -0.10648137f, 0.07351606f, 0.08102690f, 0.04275959f, -0.04097855f, -0.19678001f, 0.02770085f, 
    0.58019143f, 0.15711799f, -0.02643255f, 0.36053455f, 0.06063341f, 0.01969855f, 0.07552768f, 0.30669752f, 
    -0.35072282f, -0.19559857f, 0.02644705f, 0.01501682f, 0.04187931f, 0.00299683f, 0.12429613f, -0.05440946f, 
    -1.41759360f, 0.32126608f, -0.63937789f, -0.33930701f, -0.02032591f, -0.09339475f, 0.17538901f, 0.01434866f, 
    0.21889800f, -0.20474033f, 0.21510732f, 0.12138641f, 0.00053288f, -0.23563816f, -0.08114368f, 0.27532321f, 
    -0.10222172f, 0.15801607f, -0.02954570f, 0.28846997f, -0.05203378f, 0.08879203f, 0.29523578f, 0.00375102f, 
    -0.04469986f, 0.06538364f, -0.06889289f, 0.26180559f, -0.00424552f, -0.25448015f, -0.19009726f, -0.08844852f, 
    0.05302493f, 0.17854533f, 0.16850415f, 0.06439390f, 0.07928733f, 0.03220721f, -0.01729902f, 0.03979631f, 
    0.01012195f, -0.02098172f, -0.10348335f, -0.05581603f, 0.05662631f, -0.03231482f, 0.11963318f, 0.09252689f, 
    -0.07557067f, -0.08323362f, -0.02611071f, -0.07628255f, -0.12144720f, 0.00888391f, -0.80105180f, -0.27051151f, 
    0.11552565f, -0.04217120f, -0.00125694f, -0.04425612f, 0.07622559f, -0.05865938f, 0.00938917f, -0.33591732f, 
    -0.15720628f, -0.01759166f, 0.03398592f, 0.08330575f, -0.33649015f, 0.08678149f, 0.22239159f, 0.08451173f, 
    -0.24957299f, -0.43909937f, -0.00055710f, 0.00614565f, 0.04344376f, 0.01638632f, 0.02520684f, 0.09790606f, 
    0.05598726f, -0.91907614f, -0.69558537f, -0.59356755f, -0.45286781f, 0.07005290f, -0.42480493f, 0.28919628f, 
    0.11549414f, 0.06714192f, -0.08428475f, -0.10733917f, 0.02440908f, 0.12333205f, 0.08597320f, 0.04032004f, 
    0.14190342f, 0.01391684f, 0.00725564f, 0.06448586f, -0.16746548f, -0.00015746f, 0.31452814f, 0.17348236f, 
    0.07097422f, 0.17403039f, 0.12494159f, 0.12326815f, 0.19682674f, -0.02097047f, -0.13819563f, 0.06159932f, 
    0.08742125f, 0.10989898f, 0.20171760f, -0.13511318f, -0.18276823f, -0.06599288f, -0.26482612f, -0.62148875f, 
    -0.26774648f, -0.28375301f, -0.08161455f, -0.02753725f, 0.04160092f, -0.08706692f, 0.03566949f, -0.02164526f, 
    0.21409737f, 0.23467705f, 0.12748429f, 0.18436271f, 0.13501850f, -0.00780084f, -0.01676940f, -0.08075404f, 
    -0.34862009f, 0.03159290f, 0.01634274f, 0.14415625f, -0.13580491f, -0.21613835f, -0.03360978f, -0.23633514f, 
    -0.08993516f, 0.22693662f, 0.14341922f, -0.27188203f, 0.00751648f, -0.09059501f, 0.34961337f, 0.04307526f, 
    0.30091637f, -0.04679665f, -0.23062564f, -0.64562815f, -0.01718942f, 0.20637725f, 0.05115299f, 0.24987875f, 
    0.08077288f, 0.04457342f, -0.01364746f, 0.11794788f, 0.21878672f, 0.03907185f, 0.04386367f, -0.00344597f, 
    0.03997113f, 0.10680512f, 0.14409058f, -0.30755880f, 0.10819161f, 0.08592749f, 0.07411786f, 0.02866407f, 
    -0.07070794f, 0.04129568f, -0.02817304f, 0.09006055f, 0.01384205f, 0.09219638f, -0.18109293f, -0.15123823f, 
    0.14529933f, 0.13209665f, 0.13545941f, 0.16408698f, -0.07490979f, 0.36346185f, -0.09257246f, 0.23289523f, 
    0.20865802f, -0.12017580f, -0.16484722f, 0.06594642f, -0.28578666f, -0.18574560f, -0.03803041f, 0.37643284f, 
    0.36084744f, 0.01300315f, 0.17727943f, -0.28789288f, 0.14208777f, 0.18861648f, 0.21403113f, -0.49836224f, 
    0.34396791f, 0.36995482f, 0.03173891f, -0.09617419f, -0.37126186f, -0.14198129f, 0.17021866f, -0.05695642f, 
    0.16640241f, -0.04254781f, -0.08024564f, -0.12516932f, -0.01380005f, -0.35044840f, 0.29184940f, 0.07579811f, 
    0.24398786f, -0.24063118f, 0.09529082f, 0.08226553f, -0.08323159f, -0.05654566f, 0.03811798f, 0.11826974f, 
    -0.21258174f, -0.35084948f, 0.15936953f, -0.33527517f, 0.08408696f, 0.03394200f, 0.24229366f, 0.05011068f, 
    0.19832686f, 0.01875982f, 0.08411694f, -0.43995544f, 0.15310749f, 0.43486971f, 0.23470910f, 0.04990748f, 
    -0.27911332f, -0.03947958f, 0.06127826f, -0.01695877f, -0.34579721f, -0.08172492f, -0.36573491f, 0.21020515f, 
    0.08966459f, 0.25510442f, -0.00241911f, 0.01834185f, -0.05128531f, -0.19387943f, 0.29737043f, 0.22664611f, 
    0.06123101f, 0.04679399f, -0.06078696f, -0.14066754f, 0.11371033f, -0.03749725f, -0.11498475f, 0.46889386f, 
    0.67283976f, 0.16560419f, 0.01093768f, -0.13603017f, 0.13758060f, 0.23430663f, 0.39339632f, -0.09819558f, 
    0.18656464f, 0.02090604f, -0.11418456f, 0.02837864f, -0.07461723f, -0.19012573f, -0.39811468f, -0.17028832f, 
    0.26138556f, 0.20874260f, -0.33087948f, -0.32437521f, -0.67056257f, 0.00374452f, -0.01425483f, -0.00138646f, 
    -0.39719334f, -0.23026222f, -0.31554019f, -0.41402152f, 0.05809771f, -0.17614800f, -0.03317003f, -0.01110848f, 
    -0.00751519f, 0.07826167f, -0.43060556f, -0.30214602f, -0.31188166f, 0.13730434f, 0.04632023f, 0.00432110f, 
    0.20597683f, -0.02975524f, -0.05036207f, -0.06589511f, 0.12715194f, 0.19874099f, -0.07467249f, 0.02871393f, 
    0.00613044f, -0.17748453f, 0.03295767f, -0.15226823f, 0.09518626f, -0.12059068f, -0.17183876f, 0.02979017f, 
    0.11018945f, 0.10741246f, -0.01380844f, -0.00567147f, -0.11541753f, 0.22221678f, 0.04956367f, -0.17707293f, 
    0.02205695f, -0.01278969f, -0.05292727f, 0.13226080f, 0.10795926f, 0.19625483f, -0.01712899f, 0.04755882f, 
    -0.31118494f, -0.06809415f, -0.18468800f, 0.09630490f, 0.01438617f, -0.03516564f, -0.10925088f, 0.23878291f, 
    -0.09194534f, -0.29664698f, -0.08690677f, 0.16387387f, 0.02919624f, -0.15801764f, -0.24373095f, -0.33851361f, 
    -0.26789162f, -0.49252394f, -0.40355140f, -0.01355347f, 0.08957880f, -0.10500624f, 0.08961117f, -0.14584517f, 
    0.10821304f, 0.55771255f, 0.03450338f, 0.50318229f, 0.10675941f, -0.39565295f, -0.14126600f, 0.16493839f, 
    -0.11591427f, 0.05527959f, 0.27114818f, -0.02619719f, 0.12659688f, -0.25556567f, -0.09467102f, -0.31365258f, 
    -0.21795088f, -0.10035878f, 0.01194231f, 0.28813574f, 0.11281583f, 0.10735546f, -0.06017913f, 0.10934491f, 
    -0.01747492f, 0.02240730f, 0.05690146f, 0.01409033f, 0.56531280f, 0.08321983f, -0.00752581f, 0.08479706f, 
    0.09702291f, 0.06552541f, -0.06453498f, 0.09978468f, 0.04218925f, 0.25189912f, 0.38419858f, -0.21361651f, 
    -0.03657754f, -0.11656591f, -0.11842170f, 0.11844438f, 0.14742884f, 0.13296781f, 0.38425770f, 0.10093703f, 
    0.21936038f, 0.04785426f, 0.01795266f, 0.07905934f, 0.03891458f, 0.12965788f, -0.07732584f, -0.26154363f, 
    0.11613987f, 0.17760083f, 0.04412555f, 0.18869431f, 0.09210910f, 0.16527851f, 0.01469324f, 0.10474081f, 
    -0.17435211f, -0.01331846f, 0.11803619f, 0.24905394f, 0.05212685f, -0.01798926f, 0.16206491f, -0.00315392f, 
    0.12490063f, 0.49389440f, 0.08470251f, 0.08779810f, -0.06897254f, -0.02228010f, -0.05893819f, -0.01095075f, 
    -0.08186134f, 0.17842959f, 0.08630285f, 0.06268252f, -0.04285615f, -0.08260713f, -0.05762407f, -0.11972708f, 
    -0.11494800f, -0.10238883f, 0.10954994f, -0.06507881f, -0.07180917f, -0.09377377f, -0.09888501f, -0.09000728f, 
    -0.00742019f, -0.01830527f, -0.15221767f, 0.02159701f, -0.07314183f, -0.00034463f, -0.16095442f, 0.06025425f, 
    -0.07345111f, -0.42694780f, -0.08957049f, -0.09032033f, -0.05298206f, -0.19712228f, 0.17487866f, 0.06627441f, 
    0.03370258f, 0.31141326f, 0.11772118f, 0.04547266f, 0.02346503f, 0.20700611f, -0.66817141f, -0.19103922f, 
    -0.02857749f, -0.09826669f, 0.08953378f, -0.03206373f, 0.07342296f, 0.02712815f, 0.01961324f, -0.16871142f, 
    0.59328794f, -0.01691364f, 0.20586991f, 0.10506220f, -0.05327844f, 0.02357064f, 0.02290839f, -0.04355002f, 
    -0.42710361f, -0.32970849f, -0.37600920f, -0.02219339f, 0.13206232f, -0.11507288f, -0.05506200f, -0.19151212f, 
    0.20005129f, -0.05773798f, -0.06928905f, 0.07829387f, 0.18655641f, 0.04797509f, 0.03040326f, 0.13385113f, 
    0.06552354f, 0.01144595f, -0.01830575f, -0.27026284f, 0.04720118f, 0.09828054f, 0.04855561f, -0.14562781f, 
    0.26555082f, -0.01988294f, 0.11632254f, -0.25928450f, 0.12276277f, 0.22138876f, -0.06136280f, -0.12353949f, 
    -0.25081962f, 0.08608950f, -0.08057976f, -0.01090262f, -0.40036154f, -0.39726710f, -0.57430601f, -0.18024735f, 
    -0.08799862f, 0.05918443f, -0.06459235f, -0.03748972f, 0.08612917f, -0.31774455f, 0.04730825f, 0.00388890f, 
    -0.08704122f, 0.01542416f, -0.11482780f, -0.04894604f, 0.04345770f, 0.05065871f, -0.15534678f, -0.29668754f, 
    0.05593704f, 0.12383912f, 0.03153402f, 0.01498677f, -0.02488307f, 0.04819565f, 0.01503231f, -0.40731055f, 
    -0.05453751f, 0.01471037f, 0.06860769f, 0.07791897f, 0.10117190f, -0.00825191f, -0.08247465f, 0.02261271f, 
    0.28447911f, 0.14211012f, -0.52121985f, 0.23635232f, -0.05401587f, 0.23418665f, 0.06095824f, -0.00965997f, 
    -0.16076812f, 0.06475379f, -0.16722918f, -0.13162749f, -0.13403805f, 0.08889204f, -0.00574107f, 0.03128096f, 
    -0.08346339f, 0.02849047f, -0.18538135f, 0.03143994f, -0.60537392f, 0.15811332f, 0.11076884f, 0.23670705f, 
    0.02702962f, -0.15085493f, 0.12976809f, -0.15746388f, -0.00983410f, -0.05759861f, 0.04500826f, 0.20369636f, 
    0.06890023f, 0.08661276f, 0.08280545f, 0.19503842f, 0.41990274f, 0.02483531f, 0.09850392f, 0.00334043f, 
    0.07854188f, 0.17395955f, 0.00099640f, 0.26182276f, -0.08221016f, -0.01423144f, -0.01786819f, -0.02859905f, 
    -0.12388819f, -0.06058877f, -0.22389983f, -0.03604931f, -0.15376669f, 0.17294551f, -0.32759649f, -0.37258536f, 
    -0.56273603f, 0.04949771f, -0.01797824f, -0.16387925f, 0.06150687f, -0.06422158f, 0.05867856f, 0.26911479f, 
    -0.10268658f, 0.04931511f, 0.11957327f, 0.11611858f, 0.17132078f, -0.18830496f, -0.03164614f, 0.03867505f, 
    0.04273735f, -0.06376202f, 0.01867962f, -0.03636962f, 0.01561689f, 0.01568222f, 0.02142974f, 0.01832288f, 
    -0.00100341f, 0.01476360f, -0.03844544f, 0.02650077f, 0.01130551f, -0.04298936f, -0.04165129f, 0.03968205f, 
    0.00025667f, -0.01341172f, -0.06137530f, 0.00051413f, 0.03095490f, 0.05668730f, -0.01266396f, -0.02794970f, 
    -0.03075931f, 0.06704905f, 0.03556220f, 0.04123803f, 0.00206450f, -0.06368795f, -0.03520293f, 0.01931949f, 
    -0.03912104f, -0.02676057f, -0.05116392f, -0.01586819f, 0.01163833f, -0.02384451f, -0.03276481f, -0.04964303f, 
    -0.03606749f, -0.04839662f, -0.01734904f, -0.04207373f, 0.05673226f, 0.03958235f, -0.02658547f, -0.06419940f, 
    0.04769277f, 0.03074662f, -0.02320477f, 0.02911492f, -0.03938768f, -0.03525417f, 0.00874400f, -0.00287282f, 
    0.03157159f, -0.00737543f, -0.00731944f, -0.02860998f, 0.00446259f, -0.02850071f, 0.03421134f, -0.00406751f, 
    -0.01286927f, -0.06455524f, 0.01966939f, -0.03171416f, -0.00886228f, -0.05542580f, -0.01746082f, 0.05063649f, 
    0.01190262f, 0.00600727f, -0.02134436f, -0.05772358f, 0.01570185f, 0.00242561f, 0.03760549f, 0.00744740f, 
    0.01945531f, -0.05378201f, 0.04197988f, -0.02575961f, -0.05077682f, -0.05487544f, 0.01888624f, -0.02939914f, 
    -0.05749181f, 0.01011022f, 0.03661878f, 0.00035549f, -0.01371248f, -0.04750406f, 0.02203260f, -0.03272045f, 
    -0.03854231f, 0.00451586f, -0.05886129f, -0.00575281f, -0.02271750f, -0.02076476f, 0.02926575f, 0.04612168f, 
    0.03848650f, 0.02155037f, -0.04588803f, -0.05618567f, 0.01239174f, 0.03742042f, 0.00491435f, -0.01091828f, 
    -0.04215040f, 0.01630249f, -0.06171592f, -0.05962509f, -0.01965306f, -0.00228154f, -0.02802286f, -0.00429956f, 
    -0.00670517f, 0.00951337f, -0.04552099f, -0.02479037f, -0.00820283f, -0.01207596f, -0.04499780f, -0.03084297f, 
    0.00891597f, -0.04388681f, 0.01459530f, -0.01246017f, 0.04711405f, -0.01822501f, 0.00500329f, -0.06427475f, 
    -0.00235068f, -0.00283198f, -0.05235471f, -0.02016215f, 0.04068122f, -0.01351468f, 0.01296490f, 0.02709498f, 
    0.03873815f, -0.03084699f, -0.00481533f, -0.01748890f, 0.02067311f, -0.00760372f, -0.00915312f, -0.06267522f, 
    -0.03524488f, 0.02097565f, 0.02806647f, -0.05594828f, -0.05014823f, 0.03802174f, -0.04867016f, -0.01400922f, 
    -0.03153516f, 0.02613418f, 0.02330242f, -0.02654704f, -0.05105093f, -0.05152068f, -0.04502486f, 0.01668357f, 
    0.04889234f, 0.00381863f, 0.03656499f, -0.02410973f, -0.06078751f, -0.01311692f, -0.01771614f, -0.03458039f, 
    0.00849921f, 0.00212338f, 0.00252897f, 0.04029354f, -0.01431682f, 0.04620420f, 0.02635897f, 0.01489935f, 
    0.03599702f, 0.00398302f, -0.05022659f, 0.03390743f, -0.02947793f, -0.01272279f, -0.04637857f, -0.05897688f, 
    -0.06790906f, 0.01620481f, -0.06152113f, -0.03438978f, -0.03605401f, -0.04777944f, 0.01458675f, -0.02361910f, 
    0.00347704f, 0.01335436f, -0.05181623f, 0.01735678f, 0.02565851f, -0.02977829f, 0.00789681f, -0.02221936f, 
    0.00939643f, 0.01564820f, 0.04611301f, -0.06188972f, 0.02233605f, -0.04860779f, 0.00644289f, -0.04648713f, 
    -0.02317806f, -0.05042256f, 0.02129063f, -0.04389285f, -0.05455381f, -0.02328186f, -0.00602452f, -0.05722065f, 
    0.02819578f, 0.02124000f, -0.04677870f, -0.00021276f, -0.06728471f, 0.01777607f, -0.00369327f, -0.01960452f, 
    -0.06475166f, 0.03488461f, -0.00137588f, 0.02690308f, -0.01110190f, -0.02733541f, -0.06061261f, -0.00929652f, 
    -0.03547328f, 0.04606846f, -0.03885496f, -0.01873437f, -0.04313650f, -0.05228000f, -0.01830588f, 0.02921465f, 
    0.03163060f, 0.00393326f, 0.00482289f, 0.01270123f, 0.04202521f, -0.06493297f, 0.04589829f, -0.01506803f, 
    0.04028533f, -0.02514886f, -0.06520671f, -0.03868131f, 0.05351630f, 0.03984739f, 0.03980191f, -0.01141798f, 
    -0.00771611f, 0.01213975f, 0.04900972f, 0.00529167f, -0.06257766f, 0.01428823f, -0.00778407f, -0.03622754f, 
    -0.01195428f, 0.01842781f, -0.04880834f, 0.02400692f, -0.06663100f, 0.00540601f, -0.02096443f, 0.02923745f, 
    -0.06549232f, -0.02409660f, -0.01346900f, -0.01761425f, 0.05080435f, -0.03255400f, 0.04771729f, 0.03174171f, 
    -0.15433641f, 0.13588172f, -0.01251962f, -0.05128074f, 0.09939655f, 0.06471446f, 0.03009465f, -0.21348557f, 
    0.21161342f, 0.19367027f, 0.19152665f, 0.40577143f, -0.16458400f, 0.03487564f, -0.11666204f, 0.19197480f, 
    0.06408310f, 0.00666568f, 0.05250996f, 0.07950100f, 0.14140114f, -0.11001182f, -0.13096881f, -0.20297654f, 
    0.02632359f, -0.12181183f, -0.00531778f, -0.00339985f, -0.06501999f, 0.22309773f, -0.06740980f, 0.04825412f, 
    0.00747680f, -0.07715763f, 0.05886713f, 0.13320041f, -0.13479759f, -0.20424831f, 0.30212018f, -0.01282557f, 
    0.00032652f, 0.10594217f, -0.06984542f, -0.05522807f, 0.16135858f, 0.02585213f, 0.41417086f, -0.10134251f, 
    -0.06005622f, 0.15404750f, 0.02126166f, -0.01128026f, 0.01806972f, -0.22096103f, -0.00669169f, 0.00309933f, 
    0.15486771f, -0.04492367f, -0.11903860f, -0.04933936f, 0.07035444f, 0.03952144f, 0.02685904f, 0.14102034f, 
    0.34825268f, 0.33550560f, -0.04053370f, -0.01978055f, 0.08366008f, 0.04488726f, 0.04771985f, 0.01588628f, 
    0.28090009f, 0.26624885f, 0.18941051f, -0.14673927f, 0.33317268f, -0.27280682f, -0.05788871f, 0.08486638f, 
    0.08144020f, -0.01688969f, -0.33059722f, 0.34327936f, -0.04438505f, 0.04592270f, 0.09534590f, 0.01951600f, 
    0.10325051f, -0.01360115f, 0.19733307f, 0.08073098f, 0.13118577f, -0.22458282f, -0.05923387f, -0.25487190f, 
    -0.14417958f, -0.18412705f, -0.01984361f, 0.34469229f, -0.19905216f, 0.20360948f, -0.05922447f, -0.12573265f, 
    -0.16091794f, 0.21425611f, -0.18712437f, -0.11937375f, -0.10773867f, 0.13382317f, -0.52972269f, -0.01658901f, 
    -0.01011206f, 0.03996427f, -0.11936508f, 0.12076459f, 0.07893296f, 0.25718367f, -0.12470762f, 0.08233275f, 
    -0.11212867f, -0.16674395f, 0.36318308f, -0.01316172f, 0.03240505f, 0.14052582f, 0.17873624f, -0.25915805f, 
    -0.76245230f, -0.19857164f, -0.22213754f, -0.11151129f, 0.11744171f, 0.03383708f, -0.01192363f, 0.46086001f, 
    0.04715264f, -0.67229688f, -0.10126061f, -0.09949664f, -0.06298358f, 0.14487252f, 0.09132612f, -0.03254324f, 
    0.14914003f, 0.15225694f, -0.21962814f, 0.04178441f, -0.17421226f, -0.22380978f, 0.04417524f, -0.11559854f, 
    0.16455264f, 0.05590663f, 0.12778015f, 0.21775468f, -0.06623738f, 0.02330680f, 0.05188021f, -0.00171307f, 
    0.04604972f, 0.02354930f, -0.14303331f, -0.04482288f, 0.12132328f, -0.04394541f, 0.11421871f, -0.01952077f, 
    -0.16330059f, 0.22971129f, 0.12835249f, 0.83397877f, 0.11900572f, -0.05167981f, -0.02895099f, -0.04486296f, 
    -0.14532530f, 0.13381667f, 0.04995778f, 0.09507832f, -0.24669853f, -0.34474897f, -0.17064582f, 0.09322868f, 
    0.02937670f, -0.04253617f, -0.08276369f, 0.03947438f, -0.31813556f, 0.32620910f, 0.01184630f, -0.14761469f, 
    0.02408411f, 0.00683231f, -0.11863947f, 0.09203786f, -0.06108239f, -0.00298127f, 0.48636520f, -0.34622890f, 
    -0.39735201f, -0.19118492f, -0.08182822f, -0.24172874f, 0.10527399f, -0.12873484f, -0.03727388f, 0.21176876f, 
    0.39023563f, -0.09764864f, 0.19376157f, -0.14980908f, 0.08091579f, -0.00362098f, 0.07293873f, -0.01469256f, 
    0.06059607f, 0.21355963f, 0.55920410f, -0.19410351f, 0.22495182f, 0.24579038f, -0.23432885f, 0.06644207f, 
    0.17547897f, -0.08369771f, -0.29978403f, 0.25116524f, 0.02475833f, 0.00682612f, -0.15084375f, 0.11287116f, 
    -0.15631650f, -0.36131644f, -0.11806794f, 0.02553058f, -0.29730046f, -0.02552862f, -0.07086243f, 0.34080720f, 
    -0.05446828f, 0.24535984f, -0.32882479f, 0.21235357f, 0.30271259f, 0.08756228f, -0.25524271f, -0.15476631f, 
    -0.06635837f, -0.11933087f, 0.00772043f, -0.05086006f, -0.18185873f, -0.31531036f, 0.12563127f, -0.07541503f, 
    0.00238377f, 0.12129235f, -0.04008819f, 0.02936008f, 0.03752833f, 0.19052607f, 0.03996976f, 0.08175758f, 
    0.11272203f, -0.05082285f, -0.13294493f, 0.21460301f, -0.10424797f, -0.06747147f, -0.48876935f, 0.26300782f, 
    -0.02651941f, 0.01513356f, 0.05499131f, 0.15047275f, -0.00854892f, -0.01885651f, -0.13690460f, -0.61607957f, 
    0.17414600f, 0.61484432f, 0.13443068f, 0.13798797f, 0.42948034f, -0.10034336f, -0.01522866f, 0.22537740f, 
    -0.02136974f, 0.02677810f, -0.05031312f, -0.01005135f, 0.00795918f, 0.01342590f, 0.03014575f, -0.01880290f, 
    -0.03699807f, 0.00279527f, -0.06077170f, 0.04077209f, 0.00052394f, -0.01204333f, -0.02414039f, 0.04211558f, 
    -0.02176715f, -0.04783944f, 0.01295854f, 0.01027761f, 0.02412455f, -0.02136896f, 0.00470076f, 0.00880173f, 
    0.02890718f, 0.03668829f, -0.00840524f, -0.06387724f, -0.01350379f, -0.05124041f, 0.04954228f, -0.03553137f, 
    0.01125292f, 0.02976237f, 0.05075935f, 0.04138999f, 0.05064718f, 0.04453736f, -0.05893158f, -0.02620537f, 
    0.01772318f, 0.01011266f, 0.01183671f, -0.02995585f, -0.02059286f, -0.01962204f, 0.02205147f, 0.02910643f, 
    0.02852021f, -0.03921336f, -0.04925658f, 0.03405623f, -0.00499705f, -0.04417340f, -0.01526746f, 0.02691387f, 
    0.04144445f, 0.00560307f, 0.01100423f, 0.01583040f, 0.05002537f, -0.00211639f, 0.02262910f, 0.02425006f, 
    0.03703978f, -0.04322007f, -0.02963175f, -0.02491689f, 0.05090158f, -0.03915939f, -0.06353437f, -0.01024946f, 
    -0.04804324f, -0.00872102f, 0.02479436f, -0.05229018f, -0.04476447f, 0.02122416f, 0.03227649f, -0.00794667f, 
    0.00570715f, 0.05453496f, -0.06153527f, 0.00712210f, 0.06025502f, -0.00945226f, -0.04426568f, 0.04144952f, 
    -0.02281846f, 0.03070805f, 0.00936069f, -0.01196909f, 0.01623769f, 0.02343364f, -0.05479043f, -0.04304596f, 
    0.02368376f, 0.00674383f, 0.02468699f, -0.02551016f, -0.04424553f, -0.01612129f, -0.00510471f, 0.01876075f, 
    0.03596437f, 0.04707137f, 0.01720652f, 0.00198541f, 0.00197675f, 0.00557381f, -0.03084729f, 0.02247206f, 
    -0.06466822f, 0.03242929f, -0.04837884f, -0.03723868f, -0.01945321f, -0.00824681f, -0.03902405f, -0.01510412f, 
    0.00174989f, -0.05577042f, -0.02559698f, -0.04023320f, -0.01784266f, -0.02020698f, 0.04181797f, 0.01245219f, 
    -0.03276792f, -0.01355340f, -0.06106461f, 0.01723195f, -0.05814844f, 0.02381276f, -0.06579787f, 0.00363592f, 
    -0.00046635f, 0.03663880f, -0.02552158f, 0.02231320f, 0.00586877f, 0.01742852f, -0.04292899f, -0.00343889f, 
    -0.05353830f, -0.02089115f, -0.00655953f, -0.05066935f, -0.04501726f, 0.03371853f, -0.02430604f, 0.03388253f, 
    0.04779622f, -0.03279535f, 0.00850267f, -0.05434921f, -0.04650557f, 0.05068940f, -0.01115691f, -0.06426309f, 
    -0.05052685f, 0.00284361f, 0.01894590f, -0.02925619f, 0.03425733f, 0.02238527f, -0.01937659f, -0.02057815f, 
    -0.04947350f, 0.03277517f, -0.00578156f, -0.02440155f, 0.04698151f, -0.00270663f, 0.04494750f, 0.04573449f, 
    -0.00247890f, 0.02988748f, 0.03818470f, -0.02376393f, -0.03574939f, -0.04764833f, 0.01546358f, 0.01045381f, 
    0.02949418f, 0.03944849f, -0.05972589f, -0.01979644f, 0.02014363f, -0.05433879f, 0.00279194f, -0.05139273f, 
    -0.02473718f, -0.06019846f, 0.04225575f, -0.04883771f, -0.01782469f, -0.02435734f, -0.05183132f, -0.00844012f, 
    0.04123392f, 0.03987207f, -0.00401744f, -0.06063386f, -0.00503103f, -0.00511922f, -0.02431335f, 0.00889626f, 
    0.01009475f, -0.02793611f, 0.03023841f, 0.04578445f, 0.00820808f, 0.04265675f, -0.05152523f, 0.05780092f, 
    -0.03094521f, -0.02021703f, -0.05039129f, 0.04900797f, 0.00640161f, -0.00358089f, -0.05666760f, -0.05439788f, 
    0.02898827f, -0.04443761f, 0.03247033f, -0.02157230f, -0.02302250f, 0.02163621f, 0.02275696f, 0.01007759f, 
    -0.06557605f, 0.00249791f, -0.02105854f, -0.03735999f, 0.02628747f, 0.05063485f, 0.01846018f, 0.02951692f, 
    0.00026444f, -0.03927059f, -0.02776919f, -0.06026777f, -0.05274997f, -0.01726659f, -0.05359240f, -0.02916673f, 
    -0.06056560f, 0.02439618f, -0.04748031f, -0.04381672f, 0.00178062f, 0.01875038f, 0.03511059f, -0.05903745f, 
    -0.03956225f, 0.02501028f, -0.04350193f, -0.02872349f, -0.02128094f, 0.03321063f, 0.04994099f, -0.06225217f, 
    0.03438673f, 0.05220542f, -0.01480213f, -0.05197549f, 0.03845213f, 0.04222410f, 0.03454236f, 0.04097208f, 
    0.00426421f, -0.01498875f, -0.05160492f, -0.02922163f, -0.04967723f, -0.02645558f, -0.04231532f, 0.04644601f, 
    -0.02872068f, -0.05918757f, -0.01733564f, -0.01206420f, -0.03856273f, -0.05999095f, 0.01191880f, 0.00677715f, 
    0.25363439f, 0.24451396f, 0.12195147f, 0.15000206f, -0.26077953f, -0.23636037f, 0.13458495f, 0.11307587f, 
    0.12504400f, -0.27685678f, 0.08257845f, -0.24831228f, 0.03343004f, 0.11685510f, 0.16282071f, -0.13423485f, 
    -0.02121202f, 0.02661835f, 0.03092752f, 0.20189275f, -0.12286136f, -0.00583698f, -0.06551291f, 0.11093842f, 
    -0.09023533f, 0.02506817f, 0.22972140f, -0.23587061f, 0.01711084f, -0.28115553f, 0.11623316f, 0.00890180f, 
    -0.13164091f, 0.23964687f, -0.01961937f, 0.11840817f, -0.07015786f, 0.10724474f, -0.02738745f, 0.18258934f, 
    0.05328387f, 0.16587521f, -0.02708238f, -0.06706639f, -0.14847332f, 0.16527204f, 0.00477641f, 0.21654111f, 
    0.13448492f, 0.00756301f, 0.05430843f, -0.10156944f, 0.04116869f, -0.10782214f, -0.09551913f, 0.08034781f, 
    -0.06612030f, -0.05041189f, 0.02121672f, 0.14054702f, 0.08780407f, -0.06612962f, 0.05031785f, 0.04392670f, 
    -0.14276831f, -0.38705182f, -0.16719483f, 0.12492095f, 0.04556819f, -0.00901858f, -0.13770986f, -0.17563285f, 
    0.03277265f, 0.14818259f, -0.27809381f, 0.14549989f, 0.05688859f, 0.02966040f, 0.01714955f, 0.10473252f, 
    -0.07543822f, 0.05903660f, 0.15379618f, -0.32061985f, -0.00052202f, 0.02668446f, -0.27764508f, 0.05841061f, 
    0.04934762f, -0.00581197f, 0.05667231f, 0.22790229f, -0.05500783f, 0.09866120f, 0.08805034f, 0.07386663f, 
    0.16896743f, -0.08785985f, 0.18178715f, -0.04299695f, 0.17022680f, -0.15017809f, -0.02231271f, -0.19233860f, 
    0.05826391f, -0.15243794f, -0.00455685f, 0.12826134f, 0.24544644f, -0.38087198f, 0.06324376f, 0.04104022f, 
    0.05486644f, 0.09561618f, 0.07128079f, -0.08518014f, 0.15497610f, -0.52570933f, 0.29885480f, -0.07410402f, 
    -0.06181223f, -0.02825498f, -0.05571799f, 0.05862724f, 0.06658025f, -0.00438944f, -0.22609659f, 0.00677428f, 
    0.33623204f, 0.08500580f, 0.08447155f, 0.13726816f, -0.14961414f, 0.03929326f, 0.06026793f, -0.11847895f, 
    -0.40629506f, 0.24919669f, -0.03003614f, -0.12457047f, -0.08512296f, -0.28290057f, 0.01675357f, 0.12600850f, 
    -0.36404788f, 0.39172706f, 0.19843222f, -0.10594174f, 0.25184482f, 0.24956946f, -0.01782527f, -0.08894324f, 
    0.03881188f, 0.04344061f, -0.11176061f, -0.41727588f, -0.00447696f, 0.10211308f, -0.36317962f, -0.26279575f, 
    -0.01019824f, -0.34255546f, -0.15165570f, 0.18598907f, 0.42641941f, -0.05267373f, 0.05786866f, -0.05127563f, 
    0.26092666f, 0.02996181f, -0.14165150f, -0.14623062f, -0.28182155f, -0.07087158f, 0.20988771f, -0.21190396f, 
    0.10208196f, 0.04995561f, 0.04324547f, -0.02059902f, 0.32025087f, -0.01596575f, 0.28605214f, 0.02081210f, 
    0.10844452f, 0.01662170f, -0.02145216f, 0.02629929f, -0.07613882f, -0.07155886f, -0.12867106f, -0.21044371f, 
    0.14252442f, -0.11820187f, 0.09909209f, -0.12796392f, 0.02743570f, -0.13467142f, -0.38321763f, -0.21733437f, 
    -0.18034099f, 0.12254929f, -0.01513199f, 0.29775301f, -0.04233782f, 0.07446102f, 0.24809405f, 0.40315562f, 
    -0.46918419f, -0.62811500f, 0.07205098f, -0.05290352f, -0.16537289f, 0.28189987f, 0.06712503f, -0.30154723f, 
    -0.43393245f, 0.24182312f, 0.02830053f, 0.09636677f, 0.07567497f, -0.11055163f, 0.27354372f, 0.02072986f, 
    -0.20695068f, 0.26658589f, 0.24386270f, 0.22556485f, 0.07557577f, 0.06931541f, -0.10057786f, -0.02747034f, 
    0.05084927f, 0.16998422f, -0.45635772f, 0.29100174f, -0.04359917f, 0.10381564f, 0.35546505f, -0.05049618f, 
    0.01695486f, 0.11390728f, 0.05706390f, 0.17694890f, -0.28441426f, -0.25581598f, 0.10513314f, 0.03956028f, 
    -0.05018371f, -0.10295706f, -0.23983376f, -0.22471181f, -0.14362364f, -0.01977297f, -0.00579958f, 0.08533454f, 
    -0.05397617f, -0.00643361f, 0.21284531f, -0.05375246f, -0.03391298f, -0.30691037f, -0.22077355f, -0.08608750f, 
    -0.02152262f, 0.13004988f, 0.09121306f, 0.14235979f, 0.03832654f, 0.14207493f, 0.14207858f, -0.02414090f, 
    0.27221307f, 0.18653508f, 0.15628293f, 0.03248447f, -0.04615812f, 0.01661173f, -0.08538336f, 0.10309999f, 
    -0.11364275f, -0.06765027f, 0.26617885f, 0.17081013f, -0.02638230f, 0.14570643f, -0.07701750f, -0.26230961f, 
    0.35104424f, -0.15237218f, 0.30187464f, -0.03494715f, -0.08879135f, -0.13688768f, -0.40036935f, 0.04689212f, 
    -0.10801070f, -0.53730661f, -0.06886549f, 0.73275411f, 0.00629582f, 0.06678016f, 0.16951138f, 0.07903649f, 
    0.02794697f, -0.04563914f, 0.11559597f, 0.00291394f, -0.02772197f, -0.07299542f, -0.20878591f, -0.22716759f, 
    -0.02485049f, 0.14800110f, 0.00845729f, 0.25413331f, -0.02519168f, 0.06052821f, 0.00061509f, 0.08127633f, 
    -0.04066950f, 0.24849020f, -0.03263904f, 0.04872585f, 0.19629052f, -0.00375213f, -0.17303132f, 0.07720875f, 
    -0.07884256f, -0.06118025f, 0.09961797f, 0.22692400f, 0.12712884f, 0.06206040f, -0.14416341f, 0.03199046f, 
    -0.21817519f, -0.09104399f, 0.05350493f, 0.17718337f, -0.10140087f, -0.03202064f, 0.20109414f, 0.07935657f, 
    0.00069244f, 0.07926489f, 0.00610742f, 0.06523786f, 0.04764581f, 0.12927499f, 0.11198096f, -0.02525499f, 
    -0.13340737f, 0.06493615f, -0.41635951f, 0.05154149f, 0.09391586f, 0.20835701f, 0.06444000f, 0.04757279f, 
    0.14097403f, -0.04923510f, -0.06878895f, -0.04267843f, -0.20735915f, 0.02512157f, -0.05769701f, 0.10646491f, 
    -0.14116324f, -0.07973448f, -0.13737868f, 0.07320350f, 0.04805387f, -0.06296294f, -0.09207661f, -0.15310754f, 
    0.19535540f, -0.09344586f, 0.16119400f, 0.03596296f, 0.02721843f, -0.39261040f, -0.09882710f, -0.18358672f, 
    0.10450947f, 0.15036109f, -0.23922954f, -0.54583001f, -0.16383336f, 0.23914064f, -0.12884428f, -0.13026379f, 
    0.01071032f, -0.09456506f, 0.16159356f, -0.05244737f, -0.17141081f, -0.03359623f, -0.21109226f, -0.02989016f, 
    -0.07179406f, 0.17503330f, 0.39524952f, 0.27292770f, 0.04347900f, 0.03873100f, 0.13236944f, 0.15903002f, 
    0.31359202f, 0.07209665f, -0.03138660f, 0.15072112f, -0.07520062f, 0.33277830f, -0.18247820f, -0.10262175f, 
    0.15692401f, -0.00498232f, 0.24281234f, 0.07846862f, 0.00431323f, 0.14522381f, 0.09015680f, -0.16858630f, 
    -0.22633955f, -0.02720352f, 0.05143280f, 0.13730496f, -0.03782792f, 0.08829142f, -0.08118907f, -0.09393463f, 
    -0.17797825f, 0.01964533f, -0.03682496f, -0.08923025f, 0.24523950f, -0.03800988f, -0.06867501f, 0.03718740f, 
    0.09214451f, 0.03511149f, -0.01345876f, -0.32545945f, -0.44208950f, -0.22038130f, 0.05707462f, -0.05569765f, 
    0.15572381f, -0.02416220f, 0.32588920f, -0.10481361f, 0.10543343f, -0.07895652f, 0.03646065f, -0.16220106f, 
    0.27155575f, -0.03459585f, 0.01813792f, -0.01342851f, -0.10066643f, 0.15552546f, 0.20502868f, 0.01100281f, 
    0.04786675f, 0.08230210f, 0.06615774f, 0.10018329f, 0.11953622f, -0.26028663f, 0.24534738f, 0.00027487f, 
    0.05255190f, 0.00060192f, 0.02471611f, -0.09379012f, 0.14261462f, 0.01685375f, -0.04631262f, -0.14653015f, 
    -0.21331146f, 0.01910549f, -0.00732714f, 0.19235118f, 0.00796586f, 0.09456552f, -0.17106248f, 0.18444724f, 
    0.08460747f, -0.00888028f, 0.10777099f, 0.19333349f, 0.03318802f, -0.00341856f, -0.01401913f, 0.04755591f, 
    -0.29898983f, -0.31694704f, 0.06430375f, -0.15807194f, -0.06516021f, 0.21217145f, 0.05891078f, -0.02420105f, 
    0.26647750f, -0.07826988f, -0.16149829f, 0.23732120f, -0.02688675f, -0.06069039f, -0.07951203f, 0.02793590f, 
    -0.05569777f, -0.33316386f, -0.29776064f, 0.57864869f, -0.12431220f, -0.15821964f, -0.01580273f, 0.10587687f, 
    0.07512935f, 0.19911772f, 0.56530493f, 0.11385942f, 0.32921696f, 0.18009274f, 0.04905935f, -0.00216030f, 
    0.06985314f, 0.03433527f, 0.33316773f, 0.06672889f, 0.02005108f, -0.17288198f, -0.31241807f, -0.19612662f, 
    -0.29469529f, -0.02386019f, 0.17488584f, 0.09207408f, 0.19137195f, 0.03229797f, 0.02439849f, -0.17078911f, 
    -0.00657604f, -0.12657055f, 0.06739409f, -0.04770913f, 0.01675993f, 0.18334956f, 0.08716998f, 0.07479867f, 
    -0.13110581f, -0.05673632f, -0.16925381f, 0.13813508f, -0.52636659f, -0.26548570f, 0.07937174f, -0.00708711f, 
    0.17338400f, -0.09624124f, -0.10839954f, -0.02676707f, -0.09275875f, -0.12539996f, -0.00955197f, -0.11008023f, 
    -0.23276453f, -0.08164877f, -0.01387876f, -0.02654215f, -0.14973910f, -0.07689124f, 0.00554036f, 0.14384978f, 
    -0.01276269f, -0.01982602f, -0.01893331f, -0.05400521f, -0.01571177f, 0.01346290f, 0.03738356f, 0.04279623f, 
    0.02656858f, 0.03581212f, -0.03644693f, -0.04352417f, 0.04366789f, 0.00437668f, 0.02372640f, -0.04633590f, 
    0.03492796f, -0.06011325f, -0.00772908f, 0.00300848f, 0.02301043f, -0.01855625f, 0.04789262f, -0.01413954f, 
    0.00436900f, -0.00076307f, -0.02089331f, -0.06059063f, 0.04371572f, 0.00408448f, 0.03857603f, -0.02722111f, 
    0.04413196f, -0.05612289f, 0.02209707f, -0.00093975f, 0.02292666f, 0.04339011f, -0.04029535f, -0.01505418f, 
    -0.04939811f, 0.01151497f, 0.02929314f, -0.00421444f, 0.03267062f, 0.02015949f, -0.00889347f, -0.03289351f, 
    -0.00895360f, -0.01520353f, 0.04609176f, 0.04184730f, -0.03681381f, -0.03051293f, -0.03633710f, -0.02941583f, 
    -0.01106162f, -0.03590527f, 0.00841490f, -0.03966272f, -0.04915497f, -0.01653630f, 0.00297274f, 0.05148117f, 
    -0.05787260f, 0.00055270f, 0.00744058f, 0.00281518f, -0.01464140f, 0.02368537f, 0.01685376f, -0.06641339f, 
    -0.05856608f, -0.01675830f, 0.02445988f, -0.06599104f, 0.04868240f, -0.04189814f, -0.05595590f, 0.04164533f, 
    -0.02343763f, -0.00500784f, 0.03349410f, -0.04085508f, -0.05984080f, -0.00666662f, 0.00401083f, -0.04055279f, 
    -0.06466869f, -0.04904165f, 0.04886705f, -0.02398205f, 0.02742702f, -0.01415760f, -0.02118422f, 0.03862192f, 
    -0.05255119f, 0.03101838f, -0.00779350f, -0.04115452f, -0.06091238f, 0.02285609f, -0.04009963f, 0.02054037f, 
    -0.02603476f, -0.03746421f, -0.00569435f, -0.01386046f, -0.04975469f, -0.06233298f, -0.04680330f, -0.05615173f, 
    0.02390095f, 0.04176790f, 0.02523597f, -0.05102598f, -0.03118394f, -0.03897455f, 0.04680439f, 0.01666245f, 
    -0.01447464f, -0.00717148f, 0.01496465f, 0.05251848f, -0.00657685f, -0.02015582f, -0.02499396f, 0.00660453f, 
    0.04299765f, 0.01829507f, -0.03989109f, 0.02409728f, -0.00687640f, -0.06817352f, -0.05161528f, 0.04265953f, 
    0.01739437f, 0.04313650f, 0.03362772f, -0.04705761f, 0.03791161f, -0.00083033f, 0.02390521f, -0.02428700f, 
    -0.04995985f, -0.03709587f, -0.06789975f, -0.01725640f, -0.03503510f, -0.00770155f, -0.01166984f, 0.04071872f, 
    0.02194040f, -0.01131295f, -0.00455776f, 0.01481512f, -0.05689770f, 0.02606709f, -0.01694194f, 0.01763411f, 
    -0.03636190f, -0.04584157f, -0.00649142f, 0.02778267f, -0.05679800f, 0.02817609f, -0.03280442f, 0.01643824f, 
    0.02347189f, -0.02008843f, -0.00439420f, 0.00338873f, 0.04542921f, 0.00013249f, -0.05595622f, 0.01199954f, 
    0.04644244f, 0.04500996f, 0.01175604f, 0.03175789f, -0.06696104f, -0.05864670f, -0.04883414f, -0.00656092f, 
    -0.02972091f, 0.04595652f, 0.01561569f, -0.06070856f, -0.06324798f, 0.03121165f, -0.05151371f, 0.00250434f, 
    -0.05973260f, -0.03519626f, 0.01241088f, 0.03878166f, -0.02488391f, 0.00914638f, 0.01528241f, 0.00250469f, 
    0.00575442f, 0.04554900f, -0.03652170f, -0.01954341f, 0.02286828f, -0.06450633f, -0.01292376f, -0.02784912f, 
    0.04463411f, -0.03849157f, -0.01600724f, -0.01591445f, -0.00528503f, 0.00379628f, 0.00145395f, -0.02989279f, 
    -0.00178498f, -0.02417345f, 0.05446006f, 0.05219122f, -0.02242110f, -0.05037612f, -0.02910267f, -0.00789396f, 
    -0.03912430f, -0.00166798f, -0.02545916f, -0.00263782f, -0.01870690f, -0.01596931f, -0.00233476f, -0.01430303f, 
    0.01568772f, -0.03191946f, 0.04529703f, -0.05485274f, -0.03058136f, -0.02821495f, 0.04134171f, -0.05471237f, 
    0.03694144f, -0.00100432f, -0.03021012f, -0.04009359f, -0.03814188f, 0.03200912f, -0.00087346f, -0.06520776f, 
    -0.04837658f, -0.00949652f, 0.04062231f, -0.01282153f, 0.01770228f, -0.01599263f, -0.06432986f, -0.04421150f, 
    -0.02577479f, -0.05819703f, -0.00288144f, -0.00808481f, -0.03740887f, 0.00563545f, 0.03653597f, 0.01557864f, 
    -0.01265185f, -0.05487226f, 0.04701024f, 0.00682605f, -0.02479713f, 0.01832984f, -0.05052876f, 0.02805943f, 
    0.02640665f, -0.03168977f, 0.00885335f, 0.02172813f, 0.03511902f, -0.04087747f, -0.03693397f, 0.03180889f, 
    -0.03443252f, -0.01468527f, 0.00357958f, -0.02286809f, -0.03501942f, 0.00238191f, 0.03811574f, -0.00753738f, 
    -0.71034044f, 0.49301705f, 0.06914613f, -0.11054195f, 0.18298507f, -0.05148723f, 0.09461389f, 0.16156538f, 
    -0.05142160f, -0.11578990f, -0.34405711f, -0.06597862f, -0.44177720f, -0.33864182f, 0.07013794f, 0.08589841f, 
    0.00624559f, 0.21566665f, 0.01566257f, -0.08541322f, 0.13557419f, 0.03926424f, -0.02250333f, 0.01077819f, 
    -0.00536353f, 0.22548217f, -0.13400292f, -0.09524282f, 0.14838156f, 0.23790263f, 0.11650376f, 0.05911123f, 
    -0.03685439f, -0.08441548f, 0.19109789f, 0.24885948f, -0.01380645f, 0.01313632f, 0.10254928f, 0.03253476f, 
    -0.07053208f, -0.13752799f, -0.07079904f, -0.08982991f, -0.07879184f, -0.75142783f, -0.13852869f, -0.04275535f, 
    -0.05233767f, 0.04165735f, -0.51129329f, -0.22806108f, 0.02123410f, 0.13484862f, 0.23639125f, -0.09159335f, 
    0.06272832f, 0.02108569f, -0.10348887f, -0.02586410f, 0.01061487f, 0.08836129f, -0.15169935f, 0.05700320f, 
    -0.11368510f, 0.00775892f, 0.02675912f, -0.16018939f, 0.01869764f, -0.20720375f, -0.04099971f, 0.10320575f, 
    0.07009709f, 0.36060545f, 0.01598748f, -0.06658473f, 0.23636107f, -0.03420452f, 0.15013753f, 0.08904199f, 
    0.05923824f, -0.26207525f, -0.11118003f, 0.05378204f, 0.13015190f, 0.01710201f, 0.09847602f, -0.04478963f, 
    0.04760561f, -0.05881285f, 0.17500617f, -0.05801417f, 0.08995312f, 0.05436260f, 0.09266835f, -0.03240479f, 
    0.20895706f, 0.25116038f, 0.17069365f, -0.29093769f, 0.44360512f, -0.28838885f, 0.02007649f, 0.36264589f, 
    0.23816934f, -0.05407610f, 0.10085290f, 0.27242407f, -0.14832467f, 0.01919863f, 0.12143314f, 0.05212270f, 
    0.20107703f, 0.11633519f, -0.01726571f, 0.10663082f, 0.38839325f, 0.30872503f, -0.02261428f, 0.09858901f, 
    0.09585497f, -0.16434309f, 0.16133083f, 0.15396643f, -0.26198474f, -0.04299436f, 0.01412477f, 0.38041562f, 
    0.21372381f, -0.26904234f, 0.02311327f, -0.00000209f, -0.02533198f, -0.00856745f, 0.12768459f, -0.10013371f, 
    0.38270557f, 0.19459026f, -0.23994498f, 0.17080185f, -0.33707356f, 0.09199525f, 0.13008559f, -0.12181283f, 
    0.10689132f, -0.19490562f, 0.25672284f, -0.23298277f, -0.06362446f, -0.17539723f, -0.08719892f, 0.14719892f, 
    0.40040278f, -0.22279763f, 0.05929718f, 0.09966315f, 0.00867004f, 0.07129095f, 0.12512232f, -0.18729448f, 
    -0.34968138f, -0.47300780f, -0.07785957f, 0.23438698f, 0.20829977f, 0.00902336f, 0.01645819f, -0.15468435f, 
    0.07428516f, 0.14917895f, 0.25206268f, -0.34131533f, 0.14642659f, 0.22865199f, 0.00565525f, -0.12929879f, 
    -0.10466801f, -0.00940747f, 0.06193657f, -0.06264903f, -0.34066024f, -0.03412506f, -0.02203417f, 0.17730114f, 
    0.14713085f, -0.05746840f, 0.01630719f, 0.02715779f, 0.11620726f, -0.01402889f, 0.14510803f, 0.13238429f, 
    0.06509795f, 0.11875399f, -0.05531348f, -0.07716770f, -0.29731250f, -0.22150221f, -0.26635396f, 0.30564201f, 
    0.35175318f, -0.26931414f, 0.06390401f, 0.11316549f, -0.08911477f, 0.15467764f, 0.40231770f, -0.26389495f, 
    0.43838045f, 0.10801238f, -0.04298484f, 0.10115381f, -0.10666046f, 0.01140632f, 0.01641561f, -0.29926348f, 
    -0.18855111f, 0.03706995f, 0.15440539f, -0.10042071f, -0.19338053f, 0.03988073f, 0.17137124f, 0.18490665f, 
    -0.12187458f, -0.17592549f, 0.26505348f, -0.39224008f, 0.17825641f, 0.13654850f, -0.00264222f, -0.06674877f, 
    0.13329977f, 0.09250345f, -0.29146183f, 0.27526960f, 0.44976595f, -0.09911274f, -0.12041964f, 0.22145176f, 
    0.05328746f, 0.14409810f, 0.34734878f, 0.02566068f, 0.15408184f, 0.04665214f, 0.02339045f, 0.17347448f, 
    0.01064154f, -0.00784373f, 0.08981553f, -0.21349441f, -0.04679443f, 0.22590746f, 0.10945697f, 0.00753704f, 
    0.11393785f, -0.10031507f, 0.00439051f, 0.01401561f, 0.00343798f, 0.10029045f, -0.39231279f, -0.08502356f, 
    0.07346338f, -0.00558949f, 0.04426264f, 0.06696925f, 0.02503026f, -0.06993082f, -0.51737374f, -0.29209319f, 
    -0.29603189f, 0.07052815f, 0.10431092f, -0.35962167f, -0.13667917f, -0.05041809f, -0.11112063f, -0.23200871f, 
    0.00205828f, -0.04474432f, -0.03216135f, -0.12449235f, -0.21892835f, -0.28680938f, -0.20211008f, -0.08083537f, 
    -0.23527424f, -0.10542506f, 0.07936353f, 0.06160828f, 0.12883846f, 0.06884376f, -0.08296333f, 0.06567338f, 
    -0.13903418f, -0.26129824f, 0.23211919f, 0.31673324f, -0.23336022f, 0.08578805f, 0.05373860f, 0.16705434f, 
    0.03383447f, 0.02714240f, -0.09655365f, 0.00099776f, -0.09341940f, 0.12435192f, -0.04575427f, -0.22605179f, 
    0.25925216f, -0.05004464f, -0.22624949f, -0.04893683f, 0.12099767f, -0.06392339f, -0.00135354f, -0.00517028f, 
    0.13901463f, -0.07840277f, -0.11195584f, -0.13861606f, -0.07312436f, -0.18216498f, -0.10099250f, -0.05978992f, 
    0.10224114f, -0.09327046f, -0.02555197f, 0.12647973f, 0.32548210f, 0.32129923f, 0.48117191f, 0.23612843f, 
    0.08367880f, 0.05515134f, 0.07865320f, 0.18821323f, 0.11898118f, -0.00409872f, -0.12901223f, -0.09045894f, 
    -0.00350761f, -0.03192288f, 0.07973625f, -0.06357408f, 0.03707199f, -0.05218936f, 0.20432447f, -0.08811826f, 
    0.12697859f, 0.00249890f, 0.04766398f, 0.00293783f, -0.10961134f, 0.27245116f, 0.13777596f, -0.00866574f, 
    -0.61660129f, -0.28990099f, 0.02695262f, -0.09967240f, 0.02156603f, -0.18964310f, -0.30712235f, -0.42073762f, 
    -0.08182949f, -0.09052500f, 0.03273611f, -0.07489494f, -0.09839433f, 0.06801601f, 0.05652372f, -0.09169996f, 
    0.12556650f, -0.09513068f, -0.16150624f, -0.00084886f, 0.00971734f, -0.06256790f, -0.23068890f, -0.11676315f, 
    0.00726891f, -0.21813419f, -0.22795831f, -0.61433107f, -0.43845886f, 0.01851384f, -0.06345161f, 0.15037143f, 
    -0.07724039f, -0.05949482f, 0.06382206f, -0.05677266f, -0.08324234f, -0.05713582f, -0.01734403f, 0.06900691f, 
    0.06205139f, -0.06085392f, -0.27864677f, -0.14130984f, -0.10553043f, -0.11290430f, -0.07322931f, 0.16332370f, 
    0.11439012f, -0.33063149f, 0.07185982f, 0.09566175f, 0.04457822f, -0.00881574f, -0.22073112f, 0.17125902f, 
    0.04612492f, -0.06597610f, 0.13922076f, 0.01624123f, 0.03593614f, -0.04667110f, 0.09276068f, 0.10204495f, 
    0.12826520f, -0.07555168f, -0.06246881f, -0.07353151f, -0.16260239f, 0.06679298f, 0.02802548f, 0.09405453f, 
    -0.44114015f, 0.05930647f, -0.31706670f, -0.15828474f, 0.01342580f, -0.12798098f, -0.13302602f, -0.16642466f, 
    -0.10970052f, 0.01283264f, 0.06636238f, 0.13474663f, 0.11549783f, 0.14505762f, 0.09337210f, 0.04506826f, 
    0.28176168f, 0.18199489f, -0.13137130f, -0.12093029f, 0.03768434f, 0.00096885f, 0.03108987f, -0.05641792f, 
    0.03077997f, -0.03139650f, -0.19359127f, 0.20207717f, 0.20135561f, 0.03579895f, -0.02356393f, 0.09746162f, 
    0.00973550f, 0.10716558f, -0.02370648f, 0.05735000f, -0.05603126f, 0.08682560f, 0.28651685f, 0.06203616f, 
    -0.07947899f, 0.19227949f, 0.14042471f, 0.19189534f, 0.13875663f, 0.14496388f, 0.13351369f, -0.06489962f, 
    -0.20119861f, -0.09410410f, -0.14679131f, 0.26007783f, 0.18182138f, 0.07244707f, -0.34013489f, -0.05041608f, 
    0.21761107f, -0.07616699f, 0.08104286f, -0.01686932f, -0.01726991f, -0.08741281f, -0.19481009f, 0.04727330f, 
    0.09141535f, 0.08274817f, 0.07621695f, 0.05454705f, 0.00668481f, 0.06607436f, -0.13613142f, 0.11513069f, 
    -0.07862123f, -0.39792308f, 0.12896039f, -0.17827369f, -0.27901316f, 0.44123238f, 0.08791570f, -0.11109424f, 
    0.20483886f, -0.28947079f, -0.01334202f, 0.17285711f, -0.00668636f, 0.03335618f, 0.04598473f, 0.10513306f, 
    0.01846396f, -0.01989471f, 0.50693935f, -0.16906102f, 0.30532610f, 0.01522908f, 0.08986714f, 0.49371690f, 
    0.02300323f, -0.01572877f, -0.01217299f, -0.11139303f, -0.08979678f, -0.10261315f, 0.17356095f, -0.03397946f, 
    -0.05464491f, 0.04639276f, -0.03896847f, 0.03164089f, -0.21671386f, -0.02284380f, 0.24013495f, -0.11913066f, 
    0.00494786f, -0.01118616f, -0.02479578f, -0.04761942f, 0.10371528f, -0.04833781f, -0.01474311f, -0.03848065f, 
    -0.07196195f, -0.15502307f, 0.02108183f, 0.16697343f, -0.18020314f, -0.30789575f, 0.20774780f, 0.28488842f, 
    0.24258031f, -0.10050359f, -0.02998287f, 0.05536992f, 0.18155895f, 0.05482663f, 0.05514402f, -0.35980627f, 
    0.22397706f, 0.20358886f, -0.18794103f, 0.11830825f, -0.10983819f, 0.05743053f, 0.23019107f, 0.12208966f, 
    -0.76428688f, -0.70512211f, 0.05566565f, 0.11103056f, 0.01091099f, 0.04785114f, 0.07381474f, -0.01868926f, 
    0.10890228f, -0.36817178f, -0.33211818f, -0.08319192f, -0.18990637f, -0.17364168f, -0.18137342f, -0.08089131f, 
    0.09725489f, -0.04220539f, -0.13677153f, -0.01934662f, -0.04380765f, -0.11993001f, -0.01529497f, -0.13141452f, 
    -0.08042065f, -0.03085133f, 0.05134229f, 0.15793908f, -0.18357179f, 0.11253288f, 0.14236780f, 0.09271772f, 
    0.01955007f, 0.06680109f, 0.06075349f, 0.21846330f, 0.28913185f, -0.15833300f, -0.22675383f, 0.08510476f, 
    0.10365988f, -0.06095306f, 0.00745174f, 0.05664735f, 0.13257787f, 0.08124186f, -0.00566967f, -0.21886358f, 
    0.04707525f, -0.05907456f, -0.14704689f, 0.20206831f, 0.03063850f, 0.19638810f, 0.18337132f, 0.02300486f, 
    0.16614920f, 0.17892373f, 0.14404269f, 0.17467952f, 0.02027198f, -0.02592938f, 0.14337833f, -0.19790611f, 
    -0.13659446f, 0.08431882f, 0.10092262f, 0.05002198f, -0.07610054f, 0.06770210f, 0.15333991f, 0.04395786f, 
    -0.35971725f, 0.25228286f, 0.30511475f, 0.02229621f, -0.08063537f, 0.18793108f, 0.14487113f, -0.11728530f, 
    0.10093474f, -0.13005446f, -0.36874333f, 0.09386738f, -0.07399489f, 0.13290086f, -0.14515623f, 0.08644304f, 
    0.14118025f, 0.11460482f, -0.05531643f, 0.14996412f, 0.32865879f, -0.09076947f, -0.04537994f, -0.15169707f, 
    -0.13438128f, 0.06662425f, 0.08608352f, -0.13022076f, -0.17416456f, 0.18538013f, 0.01928653f, -0.03968790f, 
    0.07769203f, -0.05963987f, -0.14816971f, -0.18680051f, 0.07601921f, 0.10154675f, -0.10119949f, -0.00728574f, 
    -0.01928173f, -0.08803463f, 0.14595383f, -0.10421623f, -0.00443309f, 0.14083402f, 0.18251945f, 0.12918343f, 
    -0.15475935f, 0.10963883f, 0.09045395f, -0.07515451f, 0.28445309f, -0.09374449f, -0.16275577f, -0.24477953f, 
    -0.05196427f, 0.02989321f, 0.02368233f, 0.03409320f, 0.00358859f, -0.01239596f, 0.08113877f, -0.28495622f, 
    -0.15257058f, 0.06013732f, 0.01896881f, -0.00659000f, -0.18792228f, 0.05698738f, -0.14606190f, 0.12569147f, 
    -0.19907656f, -0.10110275f, -0.39549378f, -0.09201740f, -0.09554164f, -0.04877434f, -0.00036382f, -0.23603213f, 
    0.04540702f, -0.28216124f, -0.06058428f, -0.20281291f, -0.03538942f, 0.01522300f, 0.10909131f, 0.19544731f, 
    0.20739615f, 0.16523999f, -0.23859529f, -0.35174587f, 0.39900964f, 0.13311082f, 0.11512309f, 0.05646189f, 
    0.24794006f, 0.10165118f, 0.16208680f, -0.38897246f, -0.14723314f, 0.04210501f, -0.08952675f, 0.19185811f, 
    -0.02353105f, 0.05033567f, 0.05713105f, 0.04799969f, -0.17367373f, -0.02731626f, 0.29950812f, 0.01739941f, 
    0.10052259f, 0.07516624f, 0.04511613f, 0.18808833f, 0.06973551f, -0.23374972f, 0.20428175f, -0.07800704f, 
    0.02107345f, -0.00483627f, 0.00318550f, 0.07006441f, 0.15895008f, 0.10935110f, 0.08658745f, 0.05305329f, 
    0.11802400f, 0.04530935f, -0.13587788f, -0.09887748f, 0.02030265f, 0.03614590f, 0.00237018f, -0.33163753f, 
    0.16723521f, 0.12994258f, -0.08814908f, -0.23831056f, 0.36125669f, -0.08085184f, -0.11193480f, -0.03271889f, 
    0.50042582f, -0.25664723f, -0.48285419f, -0.32247081f, 0.10292818f, 0.24079101f, -0.01058550f, -0.08074298f, 
    0.03053763f, -0.43343848f, -0.42555487f, -0.02670130f, 0.11892892f, 0.02578194f, 0.24769603f, -0.03301318f, 
    -0.00428431f, -0.03782578f, 0.00111501f, -0.33433214f, -0.03754838f, 0.10709546f, 0.08691821f, 0.00338884f, 
    -0.03859818f, 0.01535671f, 0.22973506f, -0.04946344f, 0.05310759f, 0.03864383f, 0.05161369f, -0.11067542f, 
    -0.04520668f, 0.03743453f, 0.07028954f, 0.13654432f, 0.19475488f, -0.50526774f, 0.08864561f, 0.06771478f, 
    -0.00325826f, 0.02574189f, 0.03441359f, 0.10497729f, 0.02301664f, -0.08308554f, 0.06199290f, -0.06760662f, 
    -0.21085334f, -0.03709171f, -0.00305380f, -0.10993008f, -0.02878315f, 0.00456522f, 0.09443487f, 0.04980735f, 
    -0.28374022f, 0.00408402f, -0.12658997f, 0.03346948f, 0.14076716f, 0.20905487f, 0.11176416f, 0.11913181f, 
    -0.17951846f, -0.48752576f, 0.15737954f, -0.06244916f, -0.00954554f, 0.01576102f, 0.06108404f, 0.11085108f, 
    -0.11916353f, 0.28778094f, -0.08763428f, 0.11431321f, 0.08004470f, -0.02883171f, -0.09895778f, -0.13007465f, 
    0.02569745f, 0.34712467f, -0.10890482f, -0.06413471f, 0.11232244f, -0.16957967f, -0.19240679f, 0.19460888f, 
    -0.18634473f, 0.16224642f, -0.33864409f, -0.02281139f, -0.12068542f, -0.15261689f, -0.10142411f, -0.05072298f, 
    0.00313514f, 0.05243172f, -0.11998957f, -0.10462257f, 0.38081726f, 0.17804746f, 0.01423412f, -0.02935708f, 
    0.20710365f, 0.06385293f, 0.21674249f, -0.02653292f, -0.40339345f, 0.13388042f, -0.16390175f, -0.15426934f, 
    0.05615095f, -0.00319021f, 0.11032519f, 0.10234980f, 0.08828374f, -0.06439573f, -0.36871746f, 0.03207690f, 
    0.02767491f, 0.05681124f, -0.00697364f, 0.15642424f, 0.09925940f, -0.12582526f, -0.25901026f, 0.17451015f, 
    -0.17437412f, -0.06414235f, 0.05940985f, 0.04200344f, -0.01137195f, 0.05688585f, 0.17719018f, -0.19253483f, 
    -0.17323981f, -0.19462106f, 0.24769330f, -0.10055277f, 0.25497901f, 0.33621442f, 0.26704487f, 0.08668294f, 
    0.21411708f, 0.23998632f, -0.04392455f, 0.10504875f, 0.01261680f, 0.05584137f, 0.02922321f, -0.08086863f, 
    -0.08801441f, -0.12065213f, 0.18443285f, -0.24056903f, -0.14992875f, 0.17261849f, 0.12622747f, -0.17979720f, 
    0.08102103f, -0.20280233f, -0.30471742f, -0.11293708f, -0.14690046f, -0.11449593f, -0.11811725f, 0.23000725f, 
    -0.09094907f, 0.34159106f, -0.38793269f, 0.02561779f, -0.15323716f, -0.16965657f, 0.08808373f, -0.02532829f, 
    0.04881641f, -0.14032497f, -0.17381354f, -0.06132966f, -0.02400022f, -0.18438405f, -0.00729766f, 0.07492855f, 
    -0.04040454f, 0.08999200f, 0.04959334f, -0.10343689f, -0.31083855f, -0.14711955f, 0.08345121f, 0.06907935f, 
    0.04143447f, 0.16114305f, -0.31007603f, 0.06340816f, 0.27227557f, 0.13863908f, 0.14089184f, 0.14192784f, 
    -0.14997521f, 0.00498667f, 0.15633599f, 0.04032813f, -0.00577871f, -0.15806317f, 0.21099818f, -0.11630790f, 
    -0.08572949f, 0.12045550f, -0.14479804f, -0.04071416f, -0.13148303f, 0.13958465f, -0.13745309f, 0.23107468f, 
    0.15385844f, -0.14511028f, -0.34222382f, -0.01622161f, -0.01073099f, 0.11281095f, -0.24632812f, -0.16551915f, 
    -0.46453211f, 0.03612603f, 0.22332990f, -0.07359432f, -0.08376019f, -0.06490461f, -0.08250004f, 0.10332562f, 
    0.46000603f, 0.22399071f, -0.14780886f, 0.34036726f, -0.14754486f, 0.17021489f, 0.05029459f, -0.04640159f, 
    -0.04299686f, 0.12728955f, -0.08151595f, -0.13510804f, -0.13986683f, 0.08199181f, 0.04703042f, 0.00536144f, 
    -0.04837806f, 0.00714698f, 0.04400569f, 0.22407784f, 0.11160184f, -0.14011340f, -0.19619638f, 0.03724416f, 
    -0.01246986f, 0.17025492f, -0.13763310f, 0.18710214f, -0.10743795f, -0.12686799f, 0.00791134f, 0.07939838f, 
    0.02536957f, -0.13584690f, -0.07474873f, 0.08667307f, -0.00516835f, 0.20613535f, 0.04113608f, 0.07586259f, 
    -0.02269312f, 0.00346248f, 0.00464527f, -0.11557236f, -0.04811220f, -0.15660453f, 0.20856130f, -0.04339054f, 
    0.00201180f, -0.32458109f, -0.10937053f, -0.21400891f, -0.17009644f, -0.11317237f, -0.00685411f, 0.13255638f, 
    -0.25123429f, -0.26061156f, 0.70779872f, 0.39539415f, 0.07295552f, 0.01281887f, -0.14417510f, -0.10973195f, 
    0.09046417f, 0.07423890f, 0.02388429f, 0.03419302f, 0.22653112f, -0.04649013f, 0.05731752f, -0.07762725f, 
    -0.01951180f, -0.03892573f, 0.16705449f, -0.03281578f, 0.24663575f, 0.08046423f, 0.11126762f, 0.10283386f, 
    -0.18684678f, 0.13169235f, 0.08616246f, -0.18343525f, -0.13994911f, -0.13124241f, 0.03812069f, -0.06906053f, 
    0.12202583f, 0.00752794f, -0.18622872f, 0.17620023f, -0.36192307f, 0.29387379f, 0.07877726f, -0.03664465f, 
    0.03251502f, 0.10117229f, 0.07503437f, -0.01896316f, 0.17779410f, -0.32490987f, -0.11271886f, -0.10861547f, 
    -0.11615423f, -0.25878397f, 0.12880486f, -0.01365701f, 0.09917736f, -0.33264270f, 0.12774156f, -0.18652390f, 
    0.10058547f, 0.03158343f, 0.02191906f, 0.11872466f, 0.16803578f, 0.02438330f, 0.19555999f, -0.04196476f, 
    0.33051690f, 0.09341585f, 0.08007032f, -0.00837840f, 0.11960704f, 0.18554503f, 0.28897747f, 0.01887748f, 
    -0.01765083f, 0.03017598f, -0.02881829f, 0.03054699f, -0.01443145f, 0.02519909f, -0.00774764f, 0.00933685f, 
    -0.05032111f, -0.05362742f, 0.00283489f, 0.01250569f, 0.00376183f, -0.04969071f, -0.05723710f, 0.00286298f, 
    -0.04612556f, -0.05894455f, -0.03753389f, -0.01897153f, -0.00345973f, -0.04689853f, 0.03470938f, -0.03906976f, 
    0.02885823f, -0.01638939f, -0.02392016f, -0.02868514f, 0.01867411f, 0.05151033f, -0.00355054f, -0.00971324f, 
    0.03885749f, -0.03837569f, -0.02827208f, -0.01057784f, 0.04134522f, -0.03706535f, 0.00112575f, 0.01698540f, 
    -0.04197352f, -0.04989953f, -0.00470683f, 0.00905011f, 0.04644457f, 0.00112329f, 0.03248615f, 0.00327741f, 
    -0.01189289f, -0.01302992f, -0.04167509f, 0.02248973f, 0.03707237f, 0.01436730f, -0.00914306f, 0.03704237f, 
    0.02230756f, -0.01988235f, -0.00148249f, -0.04169960f, 0.05270740f, 0.03201311f, 0.03243406f, 0.00403794f, 
    -0.06488635f, -0.04350656f, -0.00247343f, 0.03420642f, 0.01316001f, -0.03712182f, -0.07046798f, -0.01672674f, 
    0.01446028f, 0.00004661f, -0.04348110f, -0.02204292f, -0.01171601f, 0.03738634f, -0.01231287f, 0.04938363f, 
    -0.01115582f, -0.05791022f, -0.00199214f, -0.03731625f, 0.02969980f, 0.02485354f, -0.03750153f, -0.02146071f, 
    -0.00517893f, 0.02736552f, 0.01796633f, 0.03599195f, -0.03955968f, 0.02013242f, -0.00841161f, 0.04287876f, 
    0.04752529f, 0.02433546f, 0.01679968f, 0.04633906f, -0.00417396f, -0.06121733f, -0.04331214f, -0.06177605f, 
    -0.02095532f, -0.04313429f, 0.04645112f, 0.02403467f, -0.01665987f, -0.05334842f, -0.01608852f, -0.00819495f, 
    -0.03020022f, -0.04663799f, 0.02242051f, -0.04513992f, 0.04207227f, 0.04551235f, 0.00772911f, -0.05922112f, 
    0.04574651f, 0.03369055f, 0.04022450f, -0.05874585f, 0.02957077f, -0.03268902f, 0.04523050f, 0.02206562f, 
    0.00641613f, 0.04244386f, -0.05920213f, -0.06123808f, -0.00729845f, 0.03243193f, -0.00209407f, 0.01657387f, 
    0.03116739f, 0.02305265f, -0.03912615f, 0.05266335f, -0.06394690f, -0.06085847f, -0.01023581f, -0.05030353f, 
    0.04606613f, -0.04314538f, -0.02426298f, 0.00698436f, 0.02345247f, -0.04181449f, 0.04405661f, -0.05857319f, 
    0.01787473f, -0.03155252f, -0.00507596f, -0.05110528f, -0.00069212f, -0.00057363f, -0.00718919f, -0.00587298f, 
    -0.05174353f, 0.00727519f, 0.04054538f, -0.05600721f, -0.02286601f, -0.05175415f, -0.04131700f, 0.04965844f, 
    -0.02630711f, -0.02889804f, 0.02342916f, -0.04214250f, -0.06564495f, -0.00877936f, -0.05128179f, -0.05125766f, 
    -0.01101661f, -0.02421439f, 0.00307853f, -0.05943310f, -0.00827549f, 0.03143033f, 0.02941908f, -0.01412995f, 
    -0.05833628f, 0.03117633f, 0.04078109f, -0.04497840f, 0.00467934f, -0.03490338f, -0.05740016f, 0.03963619f, 
    -0.04209865f, 0.04070188f, 0.01577414f, -0.02264724f, 0.03503231f, -0.00693450f, 0.00367267f, -0.04156280f, 
    -0.02835770f, 0.02606422f, -0.02986486f, -0.00522256f, 0.01893019f, 0.04646555f, -0.02976215f, 0.02401623f, 
    -0.05481160f, -0.04722130f, -0.00742782f, 0.03221506f, -0.04811789f, -0.06488167f, 0.04855481f, -0.03471895f, 
    -0.03540723f, 0.01528522f, -0.04889816f, 0.02259237f, -0.04427847f, 0.01881969f, -0.01427986f, 0.00320608f, 
    0.03610388f, -0.02790168f, 0.02792137f, -0.00062478f, -0.04882393f, -0.01057721f, 0.00245458f, -0.00839231f, 
    -0.06311665f, 0.00018834f, -0.00886687f, 0.03424526f, -0.06689095f, -0.03312260f, -0.06308103f, -0.01686019f, 
    -0.03663456f, 0.00632210f, 0.01531200f, -0.02050291f, 0.03906578f, 0.02069215f, 0.01656189f, -0.02687244f, 
    -0.03347414f, -0.02898777f, -0.02862738f, -0.00251842f, -0.00378823f, -0.02857694f, 0.02007230f, -0.05280103f, 
    -0.03092242f, 0.03992463f, 0.04048262f, -0.04031982f, -0.03894378f, 0.05572431f, -0.02543381f, -0.05987576f, 
    0.00506205f, -0.04351558f, -0.05596222f, 0.00807442f, -0.02220233f, 0.02121594f, -0.00369157f, -0.05358609f, 
    -0.04544880f, -0.02929311f, -0.06178904f, -0.00886737f, -0.02603645f, 0.02330722f, -0.02521772f, -0.01238340f, 
    0.04899527f, -0.03847761f, 0.00844342f, 0.02443986f, -0.05863103f, -0.04979048f, 0.03782965f, 0.01494484f, 
    0.24016905f, -0.17710100f, -0.17965063f, -0.13089141f, -0.08766643f, 0.01778846f, -0.01636060f, -0.11029360f, 
    0.03925949f, 0.09568438f, -0.35483128f, -0.24158785f, -0.01133294f, 0.32268989f, 0.24405797f, -0.07156380f, 
    -0.11971691f, -0.05032739f, 0.03728642f, 0.09965569f, -0.07824583f, -0.00964687f, 0.01693891f, 0.06882444f, 
    0.12862489f, -0.17810990f, -0.37253210f, 0.16411929f, 0.12104820f, -0.18191761f, 0.04983410f, -0.07644374f, 
    0.06781349f, 0.12923379f, -0.00682930f, -0.10563176f, 0.11329306f, 0.07338215f, 0.05173920f, -0.08085258f, 
    -0.02657374f, -0.04436997f, 0.08329330f, 0.07386468f, -0.18828867f, -0.09172075f, -0.19920690f, -0.03393071f, 
    -0.12891476f, -0.04619260f, 0.05595154f, -0.05945979f, -0.04567264f, 0.02230209f, 0.08418402f, 0.25362322f, 
    0.01844369f, 0.04941821f, 0.05247509f, 0.08952635f, 0.12706105f, 0.07171509f, -0.12778546f, 0.02023288f, 
    0.21870007f, -0.10102078f, 0.05385918f, 0.11531713f, -0.05905402f, 0.05937469f, -0.49945939f, -0.46171880f, 
    -0.31121683f, 0.02028702f, -0.05273288f, 0.04962844f, 0.09860562f, 0.06224971f, 0.08038506f, 0.15628339f, 
    0.32815343f, 0.43375403f, 0.24931543f, 0.02696283f, -0.00981832f, 0.04264875f, 0.26251063f, 0.08610685f, 
    0.00541182f, -0.16241981f, -0.03809698f, 0.10846620f, -0.03270744f, 0.13105631f, -0.05364721f, 0.06242086f, 
    -0.04979014f, 0.01492744f, -0.22516175f, -0.11156807f, 0.16585915f, 0.12742156f, 0.08860480f, -0.20443144f, 
    0.09520431f, 0.16365243f, -0.07638839f, 0.33819377f, -0.11655699f, 0.00953789f, 0.07793516f, 0.04108483f, 
    0.02258804f, 0.08628110f, 0.07187174f, 0.05613209f, 0.19019994f, -0.30225882f, 0.02891424f, 0.18888277f, 
    0.12997647f, 0.12845701f, 0.12429825f, -0.16007736f, -0.30451426f, -0.12744398f, -0.04751915f, -0.18064332f, 
    0.21184129f, -0.19590960f, -0.06770067f, 0.24060127f, -0.02373491f, 0.07154363f, 0.04560623f, -0.18905340f, 
    -0.03701434f, -0.01828910f, -0.06636844f, -0.02507719f, 0.07847878f, -0.10061312f, -0.04135218f, -0.03635722f, 
    -0.22583815f, 0.15096985f, 0.23692931f, 0.08709932f, 0.07112939f, 0.20034575f, 0.13780008f, 0.06456911f, 
    -0.05774829f, 0.11434929f, -0.18371642f, -0.00326896f, 0.02776935f, 0.02231879f, -0.05185226f, -0.37957114f, 
    0.09370854f, 0.01068577f, 0.33380917f, -0.01775164f, 0.02860153f, -0.02743329f, 0.10121518f, 0.17516814f, 
    0.03780212f, -0.00331875f, 0.12944920f, -0.20760719f, -0.20122266f, -0.05298709f, -0.03329949f, 0.06090646f, 
    0.00086183f, 0.02330754f, 0.03753302f, 0.09590337f, -0.08799646f, 0.05042208f, 0.03267227f, 0.18246140f, 
    0.04827919f, 0.28081533f, 0.08165760f, -0.03800556f, 0.26478410f, -0.24967687f, -0.29612774f, 0.08035323f, 
    0.06680679f, 0.01233958f, -0.03588404f, -0.11070923f, 0.01906989f, 0.05059756f, -0.06823006f, -0.08296337f, 
    0.09957628f, 0.12897994f, 0.02523110f, 0.24635229f, -0.03086124f, -0.00906688f, -0.06693710f, -0.38100463f, 
    0.03299893f, -0.12988420f, 0.08848979f, 0.09097946f, 0.05369259f, -0.25743535f, -0.34423590f, -0.26439506f, 
    -0.25040153f, 0.03603130f, 0.09939679f, 0.15552588f, 0.09755114f, -0.03552333f, -0.16360030f, -0.14797004f, 
    -0.13829836f, 0.04382245f, 0.19711702f, -0.22206563f, -0.03945450f, -0.16723160f, 0.09588198f, 0.13904268f, 
    -0.05120141f, 0.22609167f, -0.21640469f, 0.00335581f, 0.25522172f, -0.15025012f, 0.04273922f, -0.03021593f, 
    0.13215008f, -0.10033391f, 0.20832878f, -0.14034340f, 0.26320550f, -0.06392287f, 0.07962121f, 0.06266294f, 
    0.01985779f, -0.26757011f, 0.02660009f, -0.20776871f, 0.28346306f, 0.13219179f, -0.10631374f, -0.10310128f, 
    -0.10281318f, 0.03524391f, 0.06657208f, -0.01281588f, -0.08784714f, -0.55674046f, 0.09877338f, -0.03928382f, 
    -0.05712337f, -0.01996262f, 0.08106425f, -0.01231876f, -0.04682269f, -0.00925110f, -0.30792153f, -0.30478749f, 
    -0.04279974f, 0.04957260f, 0.07083614f, 0.01994766f, -0.10485499f, -0.06387694f, 0.08758672f, 0.00053105f, 
    -0.06106549f, -0.08545031f, 0.16310844f, 0.05745377f, -0.13205585f, -0.04789392f, -0.12566821f, -0.20894645f, 
    0.22856218f, 0.26633641f, 0.31357637f, 0.06468093f, -0.08888040f, 0.04127974f, -0.29854465f, -0.12448876f, 
    -0.07482966f, -0.63147807f, -0.28033274f, -0.29145297f, -0.21528897f, 0.22943746f, -0.15649782f, -0.00865228f, 
    -0.16014695f, -0.17062640f, 0.23842867f, 0.15908000f, 0.14359620f, -0.08697326f, 0.02129569f, -0.24644266f, 
    -0.00757242f, 0.03471921f, -0.11592428f, 0.34783390f, 0.30758625f, 0.26785955f, 0.03041063f, -0.00089402f, 
    -0.02034998f, -0.07782238f, 0.09656594f, 0.05052241f, 0.51043707f, 0.26134086f, 0.08596431f, -0.08398225f, 
    0.11456884f, -0.02114316f, -0.10349140f, 0.07445523f, -0.06029037f, -0.01099421f, 0.11935237f, -0.16271555f, 
    -0.07358522f, -0.14208546f, -0.16804846f, -0.11012544f, 0.12859473f, -0.04651113f, 0.37820229f, 0.23978336f, 
    0.17263386f, 0.11974846f, 0.05780087f, -0.07344303f, 0.18282269f, 0.19491312f, -0.07392804f, -0.31203657f, 
    -0.20375758f, 0.09844567f, 0.07350506f, 0.04743916f, -0.17477246f, 0.22121274f, -0.08969533f, -0.22664167f, 
    -0.47044665f, -0.23743993f, -0.23370267f, 0.05754830f, 0.01902481f, 0.08997021f, 0.23924820f, 0.00269194f, 
    0.03073062f, 0.31095389f, 0.19183239f, 0.23650785f, -0.18121752f, 0.02417660f, -0.07828196f, -0.16727073f, 
    -0.04716293f, 0.13563406f, -0.04056253f, 0.09542172f, -0.00088750f, -0.07096354f, 0.11701479f, -0.17213880f, 
    -0.04139508f, 0.10324547f, 0.10073791f, 0.13589314f, 0.05094327f, -0.35709968f, 0.00722373f, 0.07120781f, 
    0.08304133f, 0.12582937f, 0.15346636f, 0.10422266f, -0.09647870f, 0.04292843f, 0.05677601f, 0.04511020f, 
    0.04598136f, 0.04295006f, 0.12984735f, -0.02200582f, 0.05195753f, -0.24348712f, -0.01602764f, 0.02110959f, 
    -0.39480188f, 0.20593593f, 0.10118120f, 0.18324420f, 0.19257359f, -0.05691066f, -0.04595992f, -0.09756240f, 
    -0.15687454f, -0.04721160f, 0.04983927f, -0.06000833f, -0.12472323f, -0.02327597f, -0.03784978f, 0.21413863f, 
    -0.02867454f, 0.11971790f, -0.10070036f, 0.10210527f, -0.09577921f, -0.01069467f, -0.05941531f, -0.04750661f, 
    -0.32214910f, -0.53747457f, -0.32165164f, -0.22486137f, 0.04345990f, 0.12021583f, -0.13449028f, -0.17317426f, 
    0.15651143f, -0.13757458f, -0.26455224f, -0.17917562f, 0.23306079f, -0.12179815f, -0.28780606f, 0.23389532f, 
    0.18698031f, -0.09756759f, 0.31688112f, 0.24747834f, 0.53732914f, 0.02491971f, 0.04557947f, -0.21033615f, 
    0.03185458f, 0.00027675f, -0.06407014f, -0.09767184f, 0.02340866f, 0.16563652f, -0.08376133f, -0.07735918f, 
    0.05138558f, 0.13052408f, -0.07867330f, -0.01880961f, 0.11036136f, -0.44983643f, 0.10108441f, 0.04693995f, 
    -0.12595288f, -0.03441586f, 0.16965535f, -0.06499407f, 0.17085038f, -0.13281077f, 0.02797253f, -0.15813878f, 
    0.01767923f, -0.05200312f, 0.02225910f, 0.05811612f, 0.04384379f, -0.14641897f, 0.05256320f, -0.01210325f, 
    -0.35110113f, -0.00179567f, -0.09962599f, 0.18279499f, 0.06245176f, 0.08023759f, 0.00058616f, -0.33835727f, 
    -0.22011602f, -0.07510997f, -0.04428131f, 0.00801772f, -0.05022429f, -0.08727497f, -0.02466816f, -0.26300827f, 
    0.22460859f, -0.12651291f, -0.05450667f, -0.30098963f, -0.07917035f, 0.02465891f, -0.13306533f, -0.05242293f, 
    0.00517529f, -0.08005236f, -0.03546998f, -0.31205046f, 0.15410487f, -0.01412051f, 0.16053751f, -0.01922885f, 
    0.03618334f, 0.02321667f, 0.06708433f, -0.18960497f, -0.22181427f, 0.02292504f, -0.01628649f, 0.16025527f, 
    -0.07364248f, -0.12658381f, -0.22537678f, -0.25690848f, -0.04072076f, -0.23104352f, 0.01767717f, 0.07506555f, 
    0.00341860f, 0.06054793f, -0.07538135f, -0.15387535f, 0.59693551f, 0.31517011f, 0.30173668f, 0.00423565f, 
    0.05465166f, -0.15917276f, 0.00307924f, 0.12578240f, -0.09368850f, -0.04095057f, -0.04721396f, 0.17600489f, 
    -0.18439528f, -0.11466576f, -0.22379294f, -0.15760228f, -0.06174045f, 0.27343461f, -0.11104296f, -0.26726142f, 
    -0.12068256f, -0.11272359f, -0.06116140f, -0.11665546f, -0.04769775f, -0.02101872f, 0.10456003f, 0.36370504f, 
    -0.00839344f, 0.11261965f, 0.04498037f, 0.01395313f, -0.00004046f, 0.03997880f, 0.10104373f, -0.02352838f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.27768999f, 0.19997916f, 0.25281793f, -0.05391512f, 0.27869213f, -0.24179205f, 0.19297597f, -0.05779425f, 
    -0.08896721f, -0.13587539f, -0.13243404f, -0.04723902f, -0.03736414f, 0.18957900f, 0.35005546f, -0.03114766f, 
    0.16712281f, 0.34540546f, 0.13686165f, -0.02635962f, -0.00438608f, 0.00377819f, 0.10540909f, 0.30514038f, 
    -0.00521056f, 0.05056982f, 0.02176730f, 0.31238073f, 0.17954874f, -0.03370057f, 0.18291731f, 0.14271630f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19872661f, -0.17824455f, -0.24104863f, -0.10666727f, -0.25440618f, 0.74477631f, 0.20867042f, -0.02991729f, 
    0.24383877f, -0.03821180f, 0.19851704f, 0.06288835f, 0.07070559f, -0.22075017f, -0.00525493f, -0.15565801f, 
    -0.06700976f, 0.22890450f, 0.00550125f, 0.07021116f, 0.21688163f, -0.01531536f, -0.28913170f, -0.45823422f, 
    0.12640189f, -0.07101937f, -0.22297546f, -0.14143509f, -0.53062397f, 0.12193723f, -0.12880790f, -0.30818021f, 
    -0.15649731f, 0.37306410f, 0.27235970f, 0.13297714f, 0.25813875f, 0.24707417f, 0.13503519f, -0.45610970f, 
    -0.02276683f, -0.30485323f, -0.18034096f, -0.01178484f, -0.14670764f, 0.11586095f, 0.42668653f, -0.04285968f, 
    -0.38322303f, -0.12737760f, 0.25650942f, 0.12804481f, 0.31125408f, 0.11658055f, -0.41205052f, -0.00533512f, 
    0.10279973f, -0.18108341f, -0.16208141f, 0.24765727f, -0.05486396f, 0.16045012f, 0.07282939f, 0.39030308f, 
    0.25332439f, -0.31964293f, 0.21696061f, 0.06300739f, 0.05659465f, -0.34210506f, -0.15429018f, -0.32405135f, 
    0.00353527f, -0.09618307f, -0.02773119f, 0.14305638f, 0.07622848f, -0.62820190f, 0.67791665f, -0.03140828f, 
    0.62348795f, 0.15311223f, -0.25053054f, 0.00131974f, -0.12600711f, -0.07743695f, 0.13000013f, 0.16723244f, 
    -0.11867543f, 0.15067852f, -0.43644083f, -0.25188628f, -0.15856603f, 0.14617158f, 0.07291710f, -1.01789486f, 
    0.19360358f, -0.28868830f, 0.32947761f, -0.05013755f, -0.30766159f, -0.09664267f, 0.64635861f, 0.10999130f, 
    0.37764755f, 0.32744366f, -0.11092218f, -0.12672646f, -0.07746604f, 0.08168017f, -0.58938986f, 0.04323171f, 
    -0.76746291f, -0.42941785f, -0.55286676f, 0.15415201f, -0.04234735f, 0.16843142f, 0.70903587f, -0.28436869f, 
    0.09291168f, 0.17824513f, -0.35132971f, -0.79677844f, 0.35213855f, 0.03409926f, -0.40809429f, -1.00637233f, 
    -0.18385807f, 0.45662215f, -0.58066046f, 0.01881806f, -0.07115018f, 0.06630526f, 0.05134023f, 0.23238793f, 
    -0.31563324f, 0.29783747f, 0.09473020f, 0.01709061f, -0.02505806f, -0.14569609f, -0.93258506f, -0.03031393f, 
    -0.17768808f, 0.18576623f, 0.02086657f, -0.12087046f, 0.00545065f, -0.12733880f, -0.20739937f, 0.12619421f, 
    -0.00260690f, 0.02604120f, 0.52000982f, -0.35327384f, -0.53545868f, 0.09813597f, 0.20693280f, -0.15411150f, 
    0.31116262f, 0.17090805f, -0.45830125f, 0.05797007f, -0.06018589f, -0.13084443f, -0.08296070f, -0.25674435f, 
    -0.01614099f, -0.26282242f, 0.39504379f, -0.12412314f, 0.14907010f, 0.05195595f, -0.45607123f, 0.00892712f, 
    -0.08317997f, -0.15765262f, 0.08206357f, 0.16289587f, -0.09001350f, 0.08405541f, -0.01051811f, 0.51720518f, 
    0.01842167f, -0.09846481f, 0.13334030f, 0.21518032f, 0.16551498f, -0.00750403f, -0.44778672f, -0.11268087f, 
    -0.22555912f, -1.29360425f, 0.03858750f, 0.00524105f, -0.50264901f, -0.52282310f, 0.27029374f, -0.09279012f, 
    0.14983325f, 0.09194124f, -0.39408040f, 0.00872217f, -0.15068267f, -0.68861014f, 0.46939027f, -0.08868190f, 
    0.06275874f, 0.38899097f, 0.45647511f, -0.04898817f, -0.11646854f, 0.08324871f, 0.10777377f, 0.08525570f, 
    -0.09396398f, 0.14504836f, -0.05307358f, 0.23508482f, -0.17071795f, 0.11567830f, 0.18019140f, -0.44553867f, 
    -0.23648244f, -0.25529832f, -0.25344202f, -0.07909288f, -0.05213933f, 0.32155600f, -0.23498420f, 0.19055244f, 
    -0.47165167f, -0.01862506f, 0.18138644f, -0.02594191f, -0.16103928f, 0.27605733f, 0.16812184f, -0.10351712f, 
    0.41632709f, -0.49624020f, 0.04858151f, -0.02153324f, 0.34157509f, -0.17433722f, 0.29363623f, 0.18062460f, 
    0.09023766f, -0.28771642f, -0.26714000f, -0.12667681f, -0.22637153f, -0.12381800f, 0.19857749f, -0.00431543f, 
    0.07330582f, -0.50971973f, 0.23008268f, 0.04200348f, 0.31952798f, -0.14123434f, -0.36593470f, 0.27916482f, 
    -0.24784127f, -0.63154215f, 0.20480365f, -0.05580264f, 0.12328732f, 0.42703149f, 0.38877746f, -0.17047966f, 
    0.28810024f, -0.28027457f, 0.02025523f, 0.12407762f, -0.37586060f, -0.11048687f, -0.00637587f, -0.19942370f, 
    -0.09687357f, -0.50535721f, 0.39900902f, 0.06065948f, 0.31181237f, 0.16434839f, 0.34616038f, 0.18218602f, 
    0.24287216f, 0.07835816f, -0.86362153f, -0.14415374f, -0.10118359f, -0.19481006f, -0.28962091f, 0.46722645f, 
    -0.07846203f, 0.29190508f, -0.37744668f, 0.01400599f, 0.12747304f, -0.48138472f, -0.22421117f, 0.02059225f, 
    -0.19036070f, 0.46689317f, -0.60508806f, 0.05132311f, -0.29699081f, 0.03933375f, 0.16242813f, -0.00073106f, 
    -0.02941005f, -0.06022344f, -0.25217336f, 0.51685536f, -0.29336989f, -0.05261992f, 0.24598990f, 0.28613949f, 
    -0.08202495f, -0.43069765f, 0.80628556f, -0.15395962f, -0.20964938f, -0.42174074f, -0.20749062f, 0.53969252f, 
    -0.36754596f, -0.21464248f, 0.18476592f, -0.05440447f, 0.14306433f, -0.64565140f, -0.44700810f, -0.09656952f, 
    -0.25107664f, -0.08212624f, -0.01807266f, -0.11715694f, 0.20333049f, -0.05827244f, -0.56491214f, 0.04886864f, 
    -0.00691987f, 0.06404036f, 0.41103992f, 0.06748670f, 0.55697203f, -0.09653663f, -0.28132528f, -0.77451885f, 
    0.05057439f, -0.46460903f, 0.13656583f, -0.15151349f, -0.25323096f, -0.53369266f, -0.48416662f, -0.14026761f, 
    0.12466865f, 0.23829770f, 0.11964043f, -0.01149001f, 0.03839941f, 0.32224244f, -0.96480161f, 0.11198914f, 
    -0.00621121f, -0.27337632f, 0.37986279f, 0.15547046f, -0.53166097f, 0.13753918f, -0.42890406f, -0.15023506f, 
    -0.09463032f, 0.53845465f, 0.00217280f, 0.18555957f, -0.18857297f, 0.06579958f, 0.10206190f, 0.61380363f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.39403203f, 0.27281323f, 0.18412653f, -0.04582046f, 0.02988761f, 0.03690875f, -0.09698822f, -0.36494309f, 
    -0.08213490f, 0.09648027f, -0.11269184f, -0.09568521f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
