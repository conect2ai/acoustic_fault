#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.55344194f, 1.32916939f, 0.98650110f, -0.78651881f, -1.04794252f, -0.61467600f, -0.12218057f, -0.69162434f, 
    -0.42976251f, -0.97150636f, -1.55223930f, -0.27640489f, -1.01763976f, -0.89756626f, 0.05304481f, 0.46095982f, 
    -0.37775928f, -0.41574213f, 0.80330813f, 0.07973170f, -0.43539685f, 0.23575966f, 0.90741211f, 0.03127113f, 
    -0.21753766f, 0.77734178f, -0.18553799f, 0.77434456f, 0.30378416f, -1.08269775f, -0.24108870f, -1.09790754f, 
    -1.02840984f, -0.53570682f, -0.61852968f, -0.40179518f, 0.70251679f, -1.62655163f, -0.41663152f, -0.68388909f, 
    -0.58415169f, -1.23128009f, -0.11588068f, 0.43828571f, 0.58535492f, -1.42035544f, 0.70405483f, -0.07679850f, 
    -0.75045532f, -0.67216116f, -1.16572344f, 0.16763213f, 0.48184922f, 0.11149928f, -1.77908194f, -1.61056244f, 
    -0.47554037f, 0.94173098f, 0.72389060f, 0.34793311f, -0.04019733f, 0.10883828f, 0.00756417f, 0.67771608f, 
    -0.37702313f, 1.06723261f, -0.90590888f, -0.30989793f, 0.20776874f, -0.72117156f, 0.29529655f, 0.74107957f, 
    0.77885222f, -0.37643507f, 0.40712407f, -0.38014781f, 0.60897666f, -0.34821084f, 0.10705422f, 0.16589947f, 
    -0.28892559f, 0.92028421f, -0.45792064f, -0.96270084f, 0.61473572f, 0.64851266f, 0.70240790f, -0.63182235f, 
    -0.29502013f, -0.56414407f, -1.84576738f, 0.17020787f, 1.08349848f, -0.11873133f, 0.18206798f, 0.56901717f, 
    0.34472898f, 0.07598176f, -0.35751793f, 1.15480196f, 1.03562796f, -1.36413383f, -0.98863930f, 0.10370156f, 
    0.29441032f, 0.38878661f, -0.18693531f, 0.24097721f, 0.76401693f, 0.65436935f, 0.52004701f, -0.07579672f, 
    0.63252014f, 0.42517895f, -0.11074934f, 0.38490555f, -0.36154890f, 1.59312797f, -1.37792015f, -0.88745028f, 
    0.15409084f, -0.33858210f, 0.71242267f, -0.52444828f, 0.32561883f, 0.07275917f, -1.30176771f, -0.78497672f, 
    0.65515161f, -0.22898611f, -0.26026255f, -1.07615829f, -0.59609431f, -0.70325053f, -1.17346859f, -0.44415858f, 
    0.41834652f, -0.70433778f, -0.73776668f, -0.42387345f, 0.49624506f, 0.43735287f, 0.59787148f, 0.59135336f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06877866f, 0.12877762f, 0.48315048f, -0.00217223f, 0.25158751f, 0.59428775f, 0.26254094f, 0.14373972f, 
    0.57368279f, 0.39197135f, 0.11660088f, 0.20054190f, -0.15775514f, 0.46685383f, -0.05181069f, 0.35935086f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.42204428f, 0.49416137f, 0.03475324f, -0.38624462f, 0.03528767f, -0.31602252f, -0.32793331f, -0.30083072f, 
    -0.08896955f, -0.09187464f, 0.09026626f, -0.04165886f, 0.02948975f, 0.10249456f, 0.10521840f, 0.00422291f, 
    0.18213178f, 0.10536156f, 0.02154381f, 0.10590536f, 0.47712341f, 0.36091235f, 0.19429563f, -0.66962844f, 
    0.00152956f, 0.20560834f, 0.23573369f, 0.31855619f, -0.11760505f, 0.00014948f, 0.06434953f, 0.00068072f, 
    -0.00115660f, -0.00604398f, 0.00099891f, 0.02838006f, -0.03851106f, -0.02673525f, -0.14477311f, -0.00386929f, 
    -0.27489924f, -0.14003661f, -0.23693800f, 0.08387148f, 0.02891504f, 0.05901463f, -0.03732649f, -0.05545883f, 
    0.02450876f, 0.01886129f, -0.21187337f, -0.12952219f, -0.38304356f, -0.45395908f, -0.31211403f, 0.02499319f, 
    0.02902510f, -0.02768218f, -0.02527326f, 0.11985954f, -0.04998958f, 0.43635419f, 0.19794802f, -0.29284516f, 
    -0.39793620f, 0.00014409f, 0.12339148f, 0.09020875f, -0.07847475f, 0.10200433f, -0.12284933f, -0.06827702f, 
    -0.00033466f, -0.00762703f, 0.02917621f, 0.00489023f, 0.01017635f, 0.27594560f, 0.03971428f, 0.10630807f, 
    0.40092924f, 0.34682921f, -0.06818561f, -0.47001669f, -0.14420232f, 0.09227131f, 0.04149149f, 0.09873407f, 
    -0.33141932f, 0.09761729f, -0.03935188f, -0.02056087f, -0.02395219f, 0.00098849f, 0.01478816f, -0.03029172f, 
    -0.04660220f, 0.02247161f, 0.13239476f, 0.05589775f, 0.28463751f, 0.40947682f, -0.07951903f, -0.37228623f, 
    -0.26208475f, -0.20638454f, 0.01039878f, -0.10233172f, 0.01399232f, -0.07177097f, 0.05141098f, -0.08710863f, 
    -0.04106035f, -0.04726931f, -0.03247245f, -0.06381065f, -0.01235140f, 0.01105152f, -0.25955901f, -0.02703566f, 
    0.67143732f, 0.26701418f, -0.31621179f, -0.30228448f, 0.09350310f, 0.17004581f, 0.19567390f, 0.25641277f, 
    -0.03512359f, 0.01913419f, -0.12144723f, -0.06018184f, -0.02088172f, 0.03455880f, 0.07256716f, 0.02949227f, 
    0.13452648f, 0.04995317f, 0.01497085f, -0.02223830f, -0.33126259f, -0.23800083f, 0.33347824f, -0.11038086f, 
    -0.16307709f, -0.15222099f, -0.11722959f, -0.20471449f, -0.07806735f, -0.05979556f, 0.03493627f, -0.04370582f, 
    0.03634884f, 0.09692780f, 0.00661165f, -0.24441585f, -0.03411188f, -0.02752003f, -0.19101509f, -0.33513337f, 
    -0.55290902f, -0.43801239f, -0.10833774f, -0.16819848f, -0.18117446f, -0.05163148f, -0.06382748f, -0.03911183f, 
    -0.06939188f, 0.00432988f, -0.14626050f, 0.02777902f, 0.00643314f, -0.02971553f, -0.01569553f, -0.12358019f, 
    -0.25448394f, -0.40317208f, -0.24248175f, 0.04462899f, -0.00174670f, -0.71381450f, -0.62666482f, 0.18231270f, 
    -0.36669305f, 0.09314525f, 0.07409544f, 0.04645852f, -0.02000896f, 0.16559334f, 0.08799273f, 0.09609697f, 
    -0.23607041f, 0.07302084f, -0.14214627f, -0.01308467f, 0.19137603f, 0.11182222f, 0.03019468f, 0.02998198f, 
    -0.30092388f, -0.20572151f, 0.32060662f, -0.16734105f, 0.12524898f, -0.06346589f, 0.08337316f, 0.11207964f, 
    0.12565139f, 0.04559979f, -0.04861799f, -0.06744026f, -0.13400626f, 0.09460829f, -0.03055770f, 0.03157149f, 
    -0.05521757f, 0.00974101f, -0.14410874f, 0.07810428f, -0.27516627f, -0.08875169f, -0.23786153f, 0.05054106f, 
    -0.24948360f, -0.09823924f, -0.02143767f, -0.31023610f, 0.08630371f, 0.07333836f, -0.01656562f, 0.04371112f, 
    -0.08574396f, 0.01408873f, 0.08215826f, -0.23449074f, -0.09175499f, -0.11738956f, -0.05599390f, -0.11006375f, 
    -0.20189753f, -0.12502390f, -0.11437909f, -0.00008808f, 0.07089347f, 0.03919549f, 0.07385010f, 0.04221942f, 
    0.03322597f, 0.06970114f, 0.00256981f, 0.12556687f, 0.04920207f, -0.02150402f, 0.03221296f, -0.00953884f, 
    -0.18547417f, 0.08419154f, -0.05328368f, 0.06726327f, 0.01522166f, -0.00822204f, -0.32204786f, -0.02690009f, 
    -0.02117883f, -0.00481556f, -0.13060233f, -0.02964868f, -0.24068056f, -0.18402503f, -0.08577945f, -0.01203553f, 
    -0.03097436f, -0.05712725f, -0.16635257f, -0.02061167f, 0.03104317f, -0.12827238f, -0.02179888f, 0.01180541f, 
    0.62797624f, 0.27956328f, 0.02310514f, -0.35454223f, -0.00634567f, 0.04552943f, 0.13802636f, 0.15066691f, 
    0.11877935f, 0.16884264f, -0.03886951f, -0.01885339f, -0.08779613f, -0.21972850f, -0.24996835f, 0.06169163f, 
    -0.25382090f, -0.11898372f, 0.06152888f, 0.08053043f, 0.32252622f, 0.23306111f, 0.14034975f, 0.04616712f, 
    -0.04569069f, 0.02110281f, -0.08159807f, 0.07063469f, -0.01594952f, -0.15474474f, 0.11242301f, 0.13972385f, 
    -0.00614600f, -0.00006694f, 0.01655889f, -0.00988044f, -0.13446984f, -0.04506329f, -0.07562471f, -0.07244950f, 
    -0.22929923f, -0.25687739f, -0.32687390f, -0.69137633f, -0.26003912f, 0.06388184f, -0.39182174f, -0.18666136f, 
    0.04970522f, -0.32906112f, -0.00405609f, -0.00737019f, 0.00528666f, -0.06965271f, 0.03324980f, 0.00419910f, 
    -0.04631815f, -0.15470408f, -0.07489286f, -0.10617734f, -0.23791337f, 0.46485239f, 0.07192684f, 0.22501996f, 
    0.19639890f, -0.13272603f, 0.00920522f, 0.24560234f, -0.10407732f, 0.08456600f, -0.04017413f, 0.00356547f, 
    0.00238151f, -0.09557598f, 0.03031152f, 0.08165896f, 0.02935561f, 0.03015069f, -0.16953360f, 0.03224810f, 
    0.48600376f, -0.07637783f, 0.01202009f, 0.10091696f, 0.03762019f, -0.06760690f, -0.05237313f, -0.05001965f, 
    -0.06956058f, -0.02201363f, 0.14641592f, 0.21512420f, -0.14848000f, -0.15256976f, 0.08072945f, -0.12636878f, 
    -0.07819539f, -0.17993489f, 0.09172478f, 0.00649775f, 0.06125833f, 0.23457401f, -0.29141390f, -0.00373658f, 
    -0.79735202f, -0.00875742f, -0.19919556f, -0.04147721f, -0.19980869f, -0.00615161f, -0.01511167f, 0.07439689f, 
    -0.00666446f, 0.03511504f, 0.05267913f, -0.15468815f, -0.11210177f, -0.24202384f, -0.25263232f, -0.27697867f, 
    -0.24155021f, 0.09443671f, -0.31013897f, 0.18278070f, -0.15515178f, -0.04458214f, 0.15871197f, -0.14031996f, 
    -0.11837824f, -0.05028665f, 0.03670633f, -0.07502668f, 0.00744239f, 0.05256153f, 0.04986880f, 0.00609136f, 
    0.02692766f, 0.07252056f, -0.08797512f, 0.20487161f, -0.45271805f, 0.10270561f, -0.03781207f, 0.17682645f, 
    -0.02689932f, -0.17604367f, -0.00874036f, -0.30066735f, 0.08775506f, 0.06693418f, -0.06253013f, -0.01285143f, 
    -0.04170394f, 0.11397363f, 0.02487633f, -0.10251104f, 0.01185547f, -0.00880828f, -0.03946424f, -0.06272227f, 
    -0.03353706f, -0.36561266f, -0.16578256f, 0.09423413f, -0.13613014f, 0.02274432f, 0.11426516f, 0.25352252f, 
    0.12231704f, -0.10844667f, 0.22467025f, -0.03568928f, -0.04756584f, -0.11800466f, -0.10991215f, 0.05938097f, 
    -0.03350722f, -0.07697025f, -0.06079606f, -0.00328602f, 0.05451848f, 0.19069980f, -0.03642417f, -0.16165346f, 
    0.01058478f, -0.11666005f, 0.07314009f, -0.12584065f, -0.32928512f, 0.19920453f, -0.07272612f, -0.01442723f, 
    0.10859076f, 0.00517778f, -0.10011666f, 0.10582885f, 0.16949278f, -0.02054002f, 0.03840421f, 0.05208800f, 
    0.34878114f, 0.09036966f, -0.09688585f, 0.09490800f, 0.10289279f, -0.06871947f, -0.01945775f, -0.12096109f, 
    -0.11653683f, -0.04954937f, -0.07993584f, 0.01133010f, -0.00160530f, 0.05839854f, -0.06775372f, -0.03696070f, 
    0.00009776f, 0.10470374f, 0.06999167f, -0.03417975f, 1.31469727f, 0.01208730f, 0.28571770f, 0.33664998f, 
    -0.17658965f, -0.04677474f, -0.03434040f, 0.02360035f, -0.03907834f, -0.03683216f, 0.12339336f, -0.14542721f, 
    -0.04866208f, -0.15126413f, 0.04122585f, 0.29690042f, -0.12118331f, -0.16724919f, 0.08285803f, -0.04303505f, 
    -0.32363141f, -0.50969809f, -0.00320690f, 0.05611240f, 0.12632315f, 0.00198996f, -0.05088643f, 0.05744810f, 
    0.08811563f, 0.08686479f, -0.10496837f, 0.06909488f, 0.05959940f, 0.28831694f, -0.11703247f, -0.03936523f, 
    -0.04867890f, 0.08050290f, -0.00930147f, -0.14172684f, -0.11834958f, -0.18472181f, 0.36134622f, -0.00071423f, 
    -0.28077781f, 0.11138155f, -0.10523436f, -0.10681432f, 0.03678687f, 0.02168125f, 0.03149083f, -0.05649922f, 
    -0.01376268f, 0.22091182f, -0.11092187f, 0.04840454f, -0.09791571f, 0.07394689f, 0.16832107f, -0.03495364f, 
    0.32347527f, 0.09339347f, 0.07567602f, 0.12337323f, 0.21525005f, -0.02600082f, -0.01878104f, 0.00136361f, 
    -0.09849516f, -0.02902759f, 0.03205573f, -0.04336200f, 0.01187016f, 0.01440118f, -0.02073673f, -0.26749426f, 
    0.05273302f, -0.09564527f, 0.04776864f, -0.03329828f, 1.32142842f, 0.33143973f, -0.48510405f, 0.07281336f, 
    -0.23718221f, 0.00579120f, 0.27863494f, 0.06970077f, -0.21280211f, 0.08647213f, 0.02344999f, -0.02238071f, 
    -0.13618886f, -0.01029443f, -0.06646163f, -0.15308186f, 0.19033930f, 0.02773957f, -0.11090292f, 0.12384899f, 
    0.07893895f, 0.15144771f, 0.06860159f, 0.04626692f, 0.18547335f, 0.30045471f, -0.04401203f, -0.02629013f, 
    0.18465416f, 0.13836671f, 0.11360501f, 0.02062795f, 0.12928633f, -0.00969457f, 0.11721942f, -0.14713199f, 
    0.02285500f, -0.23783644f, -0.14614758f, -0.16985591f, -0.34815916f, -0.32198775f, -0.09195811f, -0.15577972f, 
    -0.07512189f, 0.09813442f, 0.14029960f, 0.10921288f, 0.10475657f, 0.10470291f, 0.08251689f, 0.09690755f, 
    0.02094905f, 0.10052503f, -0.04386304f, -0.07042819f, -0.03363871f, -0.06972311f, -0.04126794f, 0.08317521f, 
    -0.78180522f, -0.25603488f, 0.35452336f, -0.66977316f, 0.06156462f, -0.01657895f, 0.06352652f, -0.01825622f, 
    0.03042963f, 0.12769213f, -0.02030070f, -0.06488349f, 0.04164336f, 0.02421616f, -0.08781590f, -0.02625726f, 
    0.02945951f, -0.09497817f, 0.11601684f, -0.02579287f, -0.48411533f, 0.13327366f, -0.19871901f, 0.29714319f, 
    0.27015567f, 0.24667594f, 0.09667818f, 0.01078205f, 0.29062760f, 0.11655281f, 0.00951227f, 0.07259168f, 
    0.08426692f, 0.04467174f, -0.10901872f, -0.02537654f, 0.00011037f, -0.00198705f, -0.17367941f, 0.04687944f, 
    -0.00347065f, 0.05677414f, 0.14533721f, -0.12446122f, 0.10008067f, -0.00654403f, -0.01288613f, 0.06558887f, 
    -0.03124919f, 0.12982702f, 0.05461707f, -0.20791364f, -0.09520217f, 0.18489526f, 0.20918244f, 0.09730995f, 
    -0.11831030f, -0.01525989f, 0.20602258f, -0.09652922f, -0.94951022f, -0.30448696f, 0.53374696f, -0.12721546f, 
    -0.68068373f, 0.06381397f, -0.00618363f, -0.23282413f, 0.08672432f, -0.23169276f, -0.09563988f, 0.02913451f, 
    -0.05775439f, -0.09799770f, -0.03021947f, -0.02152073f, -0.00324165f, 0.19669951f, 0.13525958f, 0.22870412f, 
    -0.47286084f, -0.37860963f, -0.54215187f, 0.02897335f, -0.94574082f, 0.09860260f, -0.01673560f, -0.16046165f, 
    -0.13339707f, -0.40612355f, 0.06179583f, 0.01560165f, 0.05055356f, -0.02330091f, -0.03390678f, -0.00175008f, 
    0.01475506f, -0.03924046f, 0.04811355f, -0.15200055f, 0.55653316f, -0.70721447f, -0.54179293f, 0.03988884f, 
    -0.29450637f, 0.20728132f, 0.04744264f, -0.25030017f, 0.10554171f, 0.00887819f, 0.03246333f, 0.04400769f, 
    0.02463275f, 0.01057197f, -0.07100008f, 0.05157118f, -0.00556626f, -0.01940310f, 0.01603008f, 0.11275996f, 
    -0.12984149f, -0.23796216f, 1.16471255f, 0.54768783f, 0.47923052f, -0.06824388f, -0.13123769f, 0.05484578f, 
    0.36364424f, -0.09976549f, 0.05347925f, 0.06565098f, 0.01626351f, -0.01292346f, 0.06388477f, 0.08209568f, 
    -0.03954957f, 0.00159706f, -0.04899019f, 0.02185973f, -0.31392032f, 0.13765380f, -0.12680814f, -0.15743768f, 
    0.21823597f, -0.29991874f, 0.23615760f, 0.00814474f, -0.21263586f, 0.14030442f, 0.07059330f, -0.00763825f, 
    0.03451282f, -0.01497514f, -0.02671167f, 0.12025640f, -0.17989884f, -0.10777766f, -0.25440755f, -0.07343419f, 
    -0.10476983f, -0.02047223f, -0.01414186f, 0.01551420f, -0.08111382f, 0.00507956f, -0.09574290f, -0.04310342f, 
    0.01656586f, 0.14729740f, 0.13198516f, -0.02323877f, -0.05009008f, 0.06769963f, -0.06327454f, 0.11433053f, 
    -0.20004995f, -0.08332228f, 0.07485914f, -0.01346751f, -0.46777830f, -0.09034546f, 0.48439959f, -0.16830151f, 
    0.00019425f, -0.00106309f, -0.05498283f, 0.00076153f, -0.05247217f, 0.13915551f, 0.07821034f, -0.01841783f, 
    -0.07473106f, -0.11077439f, -0.02838443f, 0.14166826f, 0.08876280f, 0.29924592f, 0.19006170f, -0.17043161f, 
    0.65542179f, 0.06257923f, -0.22560143f, -0.02050899f, 0.37234199f, 0.03444807f, 0.16903922f, -0.02936023f, 
    0.04462329f, 0.02033360f, -0.17505011f, 0.04148978f, -0.10974569f, 0.22205858f, -0.25422567f, 0.09458812f, 
    0.01715909f, 0.06789531f, -0.06935178f, 0.08697975f, -0.35641086f, 0.06537943f, 0.11652635f, 0.06300930f, 
    -0.02791043f, 0.07261273f, -0.02825436f, -0.09582935f, -0.15612836f, 0.04541523f, -0.04337002f, -0.11661194f, 
    -0.11184420f, 0.11275396f, -0.04246691f, 0.18421040f, -0.06305476f, 0.00604217f, 0.06955371f, -0.12738462f, 
    -0.25617817f, -0.36581242f, -0.16295815f, -0.26238453f, 0.03247523f, -0.05836606f, -0.07870875f, -0.03582456f, 
    0.08135878f, 0.08519481f, -0.01876507f, -0.06073648f, -0.07398745f, 0.16193688f, -0.01167175f, -0.07225095f, 
    -0.20238011f, -0.00867609f, 0.04257872f, -0.07467814f, -0.22764914f, 0.89682889f, 0.05578640f, 0.20816672f, 
    0.06273036f, -0.24683993f, 0.06516273f, -0.11540423f, -0.25955483f, 0.21907313f, 0.13874605f, 0.21512818f, 
    -0.02982325f, 0.03394012f, 0.11636659f, -0.01087621f, -0.13119340f, -0.10158721f, 0.01826419f, -0.15808335f, 
    -0.10646205f, -0.21599109f, -0.00032811f, 0.65710276f, 0.19501427f, -0.01173229f, -0.10809091f, -0.27333298f, 
    0.17578650f, -0.13938321f, -0.07370604f, -0.05252119f, -0.00674626f, -0.08176009f, -0.03736007f, -0.16730084f, 
    0.05759390f, 0.07500141f, -0.16470438f, 0.17862189f, -0.01192759f, 0.14749616f, -0.15583172f, 0.17137618f, 
    0.20302081f, -0.01502581f, -0.00045219f, -0.07426625f, -0.24691565f, -0.35311612f, -0.00005159f, -0.03316282f, 
    0.02929009f, 0.04202673f, 0.00132937f, 0.01260099f, -0.06996968f, -0.01409519f, -0.11649063f, -0.07377376f, 
    0.29923743f, 0.00257136f, 0.68187064f, -0.24392855f, 0.57902330f, -0.26062602f, 0.25737908f, 0.27058822f, 
    0.08706179f, 0.11046293f, 0.13483705f, 0.00435126f, 0.02012633f, 0.05234821f, 0.08111545f, -0.15544252f, 
    -0.17563573f, 0.03699505f, 0.03969656f, -0.02818234f, -0.09986525f, -0.03873380f, -0.25855231f, -0.12621096f, 
    0.20474090f, -0.03650419f, 0.01527724f, -0.31157696f, 0.04860115f, -0.21921508f, 0.06620848f, 0.00891339f, 
    0.06560648f, -0.00750406f, 0.05941048f, -0.15695637f, -0.00323347f, 0.24302132f, -0.13449378f, -0.01466398f, 
    -0.35842746f, 0.23011050f, -0.52143353f, 0.15243100f, -0.38132328f, 0.10740571f, -0.15663876f, 0.02752546f, 
    -0.04370867f, -0.11110856f, 0.00325806f, -0.00284989f, 0.09068469f, 0.07622278f, -0.19801611f, 0.03485946f, 
    -0.02809887f, -0.13994770f, -0.03549408f, -0.26187673f, -0.10568322f, -0.48429039f, -0.21778296f, 0.24593307f, 
    0.64210248f, -0.19083856f, 0.08023104f, 0.02571666f, 0.14636405f, -0.00034262f, 0.02581144f, -0.04473902f, 
    -0.04574240f, -0.17076644f, -0.05497439f, -0.04819015f, -0.03460709f, -0.00798379f, 0.06315356f, 0.05803608f, 
    -0.23216620f, 0.00491721f, -0.46764633f, 0.33534905f, 0.25163078f, 0.01128322f, -0.15018308f, 0.24614419f, 
    -0.02216939f, 0.19394569f, 0.05164873f, -0.02155443f, -0.03156557f, -0.07378373f, -0.09208718f, 0.03216096f, 
    -0.18921158f, 0.10430383f, -0.23486626f, -0.13448134f, 0.21636103f, -0.00026201f, -0.28584656f, -0.27754658f, 
    0.38379997f, 0.19166626f, 0.07425676f, -0.03619665f, -0.06874212f, -0.02456767f, -0.06556891f, -0.09474207f, 
    -0.08070113f, 0.02401503f, -0.01533479f, -0.10599639f, -0.07258788f, -0.16835800f, -0.03032672f, 0.16811912f, 
    -0.57261282f, 0.44295132f, -0.12449910f, -0.11025094f, 0.52409589f, 0.41425487f, 0.08227939f, -0.03396208f, 
    0.03449516f, -0.29381704f, -0.38578925f, 0.04288379f, 0.07364605f, 0.11914950f, 0.15379363f, -0.12319228f, 
    0.02882279f, 0.04455835f, 0.03104536f, 0.08805606f, -0.26099840f, -0.14799418f, 0.22189659f, -0.03960401f, 
    -0.20372316f, -0.05928276f, -0.07532707f, 0.08163541f, 0.04174074f, -0.17513797f, 0.15894705f, 0.21060103f, 
    -0.07600641f, -0.03172739f, 0.23088238f, 0.02694372f, 0.03832334f, 0.03049567f, -0.23963760f, -0.20337601f, 
    -1.21059787f, 0.17625216f, -0.37243962f, -0.04096783f, -0.74441576f, -0.07989162f, -0.28916073f, 0.09353673f, 
    -0.17967589f, -0.29507920f, -0.09022423f, 0.08674720f, -0.01241542f, -0.17321768f, -0.22309108f, -0.00641153f, 
    0.03630731f, -0.01476768f, 0.15896630f, -0.24876875f, 0.36936888f, 0.83301610f, -0.04168407f, 0.14047910f, 
    -0.20779426f, 0.28199384f, 0.12010375f, 0.16630653f, 0.28304395f, 0.06059540f, -0.13730611f, -0.14844869f, 
    0.06884322f, -0.05803837f, 0.04370401f, -0.08168650f, -0.07309534f, -0.09989487f, -0.04370708f, -0.04248964f, 
    0.93300724f, 1.26175475f, -0.10448564f, -0.67523450f, -0.22450104f, 0.30584592f, 0.10292860f, -0.20708674f, 
    -0.07968309f, -0.45988604f, -0.13204861f, -0.06976297f, 0.02823173f, -0.05759618f, 0.04471184f, 0.11075437f, 
    0.10110567f, -0.31101182f, 0.29107311f, 0.12212986f, -0.96234053f, 0.22232448f, 0.35199472f, 0.61317319f, 
    0.68255430f, -0.28874233f, -0.23246557f, -0.24063483f, -0.03609597f, -0.17060001f, -0.06787234f, -0.03211094f, 
    0.00981553f, -0.11504614f, 0.13030872f, -0.21001907f, 0.00004683f, 0.08564769f, 0.17226177f, 0.05307736f, 
    -0.83679497f, -0.53879684f, -0.06073339f, -0.24853055f, -0.64098638f, 0.22439811f, -0.21969539f, -0.04009186f, 
    0.23210239f, 0.21959025f, -0.02265530f, 0.03177565f, 0.12694617f, 0.12763666f, -0.04024756f, 0.00900271f, 
    -0.01132839f, -0.20515862f, -0.19920494f, -0.19567163f, -0.56140715f, 0.14331859f, 0.05928922f, 0.06698201f, 
    0.55108273f, -0.05229681f, -0.10658526f, 0.00874684f, -0.33638364f, -0.07445634f, -0.04670721f, -0.08806951f, 
    -0.07343739f, -0.05629522f, -0.04746501f, -0.01929926f, 0.03703172f, 0.20299031f, -0.10397386f, -0.16190906f, 
    -0.03125114f, 0.31336302f, -0.09283133f, -0.02693514f, 0.26855841f, 0.03469596f, 0.13834500f, -0.07892898f, 
    -0.12116618f, 0.16430815f, -0.10430274f, 0.13726439f, -0.02158511f, 0.07240578f, 0.04554477f, 0.03868970f, 
    -0.06398350f, 0.19360441f, -0.09756892f, -0.11507088f, -0.04262410f, -0.19344234f, -0.42544666f, 0.01062400f, 
    0.29549205f, 0.15613146f, 0.08470396f, 0.15841028f, -0.05958863f, -0.01756278f, 0.04881724f, -0.04909777f, 
    0.00335044f, -0.14921077f, -0.01652395f, 0.18723668f, -0.19703519f, 0.05624975f, -0.08038224f, 0.03062128f, 
    0.49951127f, -0.00088689f, -0.35726798f, 0.67622542f, 0.10097740f, 0.12802884f, 0.17559555f, 0.07876902f, 
    0.32090563f, 0.15888213f, 0.09646491f, -0.10221665f, 0.03355437f, 0.00155901f, 0.06463733f, 0.03698118f, 
    0.26500294f, 0.09672939f, 0.04637310f, 0.07865088f, -0.00197234f, 0.03669647f, 0.18855256f, 0.22295730f, 
    0.08230503f, -0.32964778f, -0.09120978f, -0.14076272f, -0.12934187f, -0.05435998f, 0.02729758f, 0.06626366f, 
    -0.03812785f, 0.18399367f, -0.01129031f, -0.00762763f, 0.06724755f, -0.13146476f, 0.06628343f, 0.10125144f, 
    0.04870843f, -0.06277996f, 0.01395272f, -0.13377586f, -0.10533433f, 0.05616025f, -0.02454880f, 0.10252900f, 
    -0.02118907f, -0.00097877f, -0.08047878f, -0.13989313f, -0.01131397f, -0.17766541f, 0.05238438f, 0.13629247f, 
    0.05112072f, -0.02322087f, -0.19865760f, -0.09510655f, 0.09000941f, 0.19189177f, 0.36750749f, -0.06010795f, 
    0.04954192f, -0.04798701f, 0.25841880f, -0.00044790f, 0.16004008f, 0.08985320f, 0.05028613f, 0.01583816f, 
    -0.08276338f, 0.13012154f, -0.03189825f, 0.00451010f, 0.20243269f, -0.20504080f, 0.15182807f, 0.37660545f, 
    0.35762730f, 0.07158621f, 0.57996136f, 0.00378251f, 0.37777644f, -0.02356895f, 0.14242098f, 0.08258586f, 
    0.14172706f, 0.06296168f, -0.06130522f, -0.00367684f, 0.04949665f, 0.03407682f, -0.01369722f, 0.04095709f, 
    -0.03248353f, -0.20987396f, -0.16369516f, -0.41103777f, 0.07114657f, 0.29643542f, 0.29725105f, 0.43421522f, 
    0.14042881f, -0.07144573f, -0.08914418f, -0.04399545f, -0.06437794f, 0.23130734f, -0.02496162f, -0.03906209f, 
    0.04233307f, -0.02486521f, 0.04693779f, -0.03686008f, -0.09340850f, -0.16322842f, -0.17792952f, -0.22903655f, 
    0.19659632f, -0.42803538f, 0.43446466f, 0.15325505f, 0.06543151f, -0.44711399f, -0.20430280f, -0.12955821f, 
    -0.17847939f, 0.12933317f, 0.02864124f, 0.01056792f, -0.06934657f, -0.12236506f, 0.02123814f, 0.05401319f, 
    0.02436909f, 0.04571585f, 0.00042069f, -0.09389170f, -0.14056218f, -0.19085823f, 0.03370644f, -0.03940033f, 
    0.22965617f, -0.02933121f, -0.16578729f, 0.00412863f, 0.08569149f, 0.11371189f, 0.04566816f, -0.02948181f, 
    -0.04367711f, -0.13131762f, 0.08471540f, -0.00380322f, -0.40902206f, -0.06569523f, -0.01509035f, -0.08543310f, 
    0.05078664f, -0.20604214f, -0.08622670f, -0.24204107f, 0.02271277f, 0.13833791f, -0.02126334f, -0.00030214f, 
    0.09009056f, -0.07806757f, 0.14943272f, -0.01430894f, -0.08054223f, 0.02032811f, 0.13901088f, 0.05857239f, 
    0.07388770f, -0.14657646f, -0.18469995f, 0.00333194f, -0.94043505f, -0.16694979f, -0.05879764f, -0.74818349f, 
    -0.30986634f, 0.09135897f, 0.17361654f, -0.01814854f, 0.07747073f, 0.09311180f, -0.02328347f, 0.01505334f, 
    -0.04588773f, 0.03924100f, -0.08393735f, -0.11215787f, 0.11201538f, -0.15121374f, -0.21594042f, 0.10711484f, 
    0.02222505f, -0.55017662f, -0.17067684f, -0.01080319f, -0.09094600f, 0.00881375f, -0.17641029f, -0.03548322f, 
    -0.16395579f, 0.00653484f, -0.04496152f, -0.07541037f, 0.18280709f, -0.09722712f, -0.17563911f, -0.02372093f, 
    -0.10844552f, -0.04964155f, -0.16409440f, -0.06179014f, -0.13182518f, -0.32347161f, -0.08748040f, -0.11847510f, 
    -0.01666388f, 0.06839956f, 0.04091045f, 0.20087166f, -0.22998263f, -0.02585012f, 0.04041555f, -0.08117115f, 
    0.20731521f, -0.18245339f, -0.07056872f, -0.14822941f, 0.00775457f, -0.19594112f, -0.15429755f, -0.14931066f, 
    0.14748819f, 0.09043210f, -0.03006461f, -0.07172133f, -0.02955633f, 0.20667693f, 0.05500636f, 0.03382988f, 
    0.09255666f, 0.07439539f, 0.20605356f, 0.17101678f, 0.04724891f, 0.00019644f, 0.13569041f, 0.12665550f, 
    0.03039325f, 0.00511382f, -0.03239039f, 0.11952069f, 0.05564188f, -0.49732095f, 0.09080697f, -0.17014097f, 
    -0.06293552f, -0.12852250f, -0.10277424f, -0.05642654f, -0.15835491f, -0.48153409f, -0.07534117f, -0.29258764f, 
    0.05486283f, 0.11272851f, -0.04824688f, -0.12840222f, -0.07641345f, -0.04889354f, -0.16382593f, -0.16647029f, 
    -0.32601860f, -0.29751593f, 0.01633371f, -0.02952921f, -0.08911072f, -0.21223529f, 0.05754929f, 0.06112107f, 
    -0.41655567f, -0.14587228f, -0.07622087f, 0.03332246f, -0.04421886f, 0.11308942f, -0.03190382f, 0.06155682f, 
    0.16356543f, 0.05274856f, 0.09836187f, 0.29408893f, 0.13015869f, 0.23995158f, 0.22054835f, 0.03459248f, 
    -0.01638500f, 0.05097393f, 0.05140939f, -0.02645104f, -0.04055326f, -0.00828607f, 0.17694938f, -0.02015642f, 
    0.06791595f, -0.01649630f, 0.00109777f, -0.02248659f, -0.15380491f, -0.05543770f, -0.09946639f, -0.02342900f, 
    -0.50799948f, 0.00435254f, 0.16202524f, 0.26203507f, -0.51030362f, 0.21962470f, -0.16119908f, -0.26254651f, 
    0.02449401f, 0.09734111f, -0.00316629f, 0.12276864f, -0.01644221f, -0.03598968f, -0.02611943f, 0.01894918f, 
    -0.07042874f, 0.31500590f, -0.09119784f, -0.05310984f, 0.20435689f, -0.28507638f, 0.06425656f, 0.16306861f, 
    -0.27211735f, 0.19876553f, 0.14159572f, 0.07920827f, -0.03822675f, 0.00384962f, 0.10190143f, 0.03320745f, 
    -0.08921622f, 0.08288667f, 0.07076211f, -0.18366370f, 0.00276501f, -0.02198555f, 0.11191258f, -0.13916878f, 
    -0.22990404f, -0.08894221f, -0.45084846f, -0.22397143f, 0.06023691f, 0.08306019f, 0.04874748f, -0.02508657f, 
    -0.10349831f, -0.05819951f, 0.09396644f, -0.08620710f, 0.23322122f, 0.10554586f, -0.02122393f, -0.03090954f, 
    -0.03208001f, 0.36383346f, 0.03981430f, -0.02722740f, 0.42952818f, 0.30211216f, 0.09999856f, -0.06112316f, 
    0.22829635f, 0.02314853f, 0.17262593f, 0.03540722f, 0.12799737f, 0.11454095f, 0.15045455f, 0.11114255f, 
    0.03774933f, -0.04837123f, -0.01274731f, -0.07073601f, -0.03260787f, -0.27164835f, -0.12642738f, -0.38078684f, 
    0.29203230f, -0.06816828f, 0.52815634f, -0.09004603f, -0.15459447f, 0.17889656f, 0.03550965f, -0.16370369f, 
    -0.06272043f, 0.12703985f, 0.12847450f, -0.05584211f, 0.06998865f, -0.03103302f, 0.01519802f, -0.03981850f, 
    0.06048081f, -0.08817296f, 0.12306755f, 0.28869069f, 0.05476069f, 0.00911941f, 0.50579852f, 0.01437659f, 
    -0.26945409f, 0.12036210f, 0.06260813f, 0.24429408f, 0.11595561f, -0.24411266f, 0.03733230f, -0.04554434f, 
    0.01414921f, -0.03525995f, 0.08544425f, 0.06991995f, 0.02399898f, -0.00836004f, -0.00204380f, 0.19241060f, 
    -0.60045195f, 0.02386551f, -0.45267722f, -0.45633721f, -0.50289047f, 0.06851067f, 0.01165013f, -0.10185442f, 
    -0.19847530f, 0.04498041f, 0.08064768f, 0.06101639f, -0.07097968f, -0.07542580f, -0.11678280f, -0.09217021f, 
    -0.10357179f, 0.07996324f, -0.04342061f, 0.04927904f, 0.05023213f, -0.43126619f, -0.19280480f, 0.46591684f, 
    -0.02590771f, 0.12146618f, -0.03452104f, -0.06514963f, 0.21635152f, -0.06012116f, -0.01144398f, -0.00845400f, 
    -0.07582049f, 0.01154493f, 0.19877404f, 0.00881747f, 0.04391654f, 0.02449053f, -0.15111049f, 0.31598955f, 
    0.01509880f, -0.12618980f, -0.03922246f, 0.09323186f, 0.16438641f, 0.15064852f, 0.01687084f, 0.00473005f, 
    0.05024423f, -0.05255039f, 0.06457711f, -0.08950315f, -0.02238358f, 0.12484371f, 0.01468802f, 0.04723102f, 
    -0.02357299f, 0.16618136f, 0.14103365f, -0.12273651f, -0.22603086f, 0.18209061f, -0.18413107f, -0.39144456f, 
    0.40082502f, -0.03540895f, -0.02595560f, -0.02376811f, -0.04007919f, -0.07815608f, -0.03601260f, -0.05665108f, 
    -0.00277404f, -0.08279419f, 0.04429873f, -0.28834063f, -0.02135509f, 0.12455177f, -0.07840165f, -0.07556187f, 
    -0.34041479f, 0.42275617f, -0.28176633f, 0.05123108f, -0.29788247f, 0.00896239f, -0.14046709f, -0.22180250f, 
    0.10565396f, -0.01108221f, 0.16602752f, -0.08587066f, -0.21153870f, -0.10513711f, 0.16588181f, -0.06231857f, 
    0.13714536f, 0.02502167f, -0.10713845f, -0.02102638f, 0.90204883f, -0.06323315f, -0.62087202f, -0.14601681f, 
    0.27214304f, 0.00137976f, -0.09096833f, -0.04709673f, -0.31185570f, 0.12651756f, 0.02329975f, 0.01805363f, 
    -0.04071731f, -0.05884458f, -0.13731781f, 0.16809908f, 0.19197349f, -0.02385523f, -0.20760152f, 0.04852543f, 
    -0.15832601f, -0.22553964f, -0.16686165f, 0.13701871f, 0.15449926f, -0.01130829f, 0.03926403f, -0.07776146f, 
    -0.00989058f, 0.04545805f, 0.07192660f, -0.17374532f, -0.05982941f, 0.13742487f, 0.04625878f, 0.07081309f, 
    -0.04029583f, 0.08839411f, 0.02979956f, -0.15095420f, -0.23214625f, -0.40578356f, 0.21366049f, -0.11078072f, 
    -0.18014641f, 0.19982624f, 0.00949878f, -0.19311741f, 0.18002941f, 0.13392822f, 0.06029142f, 0.17349458f, 
    0.01514890f, -0.04208213f, 0.01808996f, 0.10925545f, -0.19300008f, 0.00247571f, 0.16673805f, 0.18758190f, 
    -0.13764431f, -0.11914828f, 0.36552736f, 0.05247840f, -0.30557495f, -0.05738253f, -0.01154418f, -0.00360263f, 
    0.14124587f, -0.16980776f, -0.04349753f, 0.00660527f, 0.04645609f, -0.07522471f, 0.05254632f, 0.03383669f, 
    -0.12488588f, -0.10700042f, -0.28636929f, -0.30655846f, 0.09001665f, 0.06416543f, -0.00504487f, 0.12017877f, 
    -0.17195491f, -0.00529107f, -0.20214956f, -0.05692543f, 0.10601217f, 0.14123791f, -0.25309789f, -0.09702750f, 
    -0.14578271f, -0.09337474f, -0.07410957f, 0.09378461f, 0.18341295f, 0.17107037f, 0.01917860f, 0.07085947f, 
    -0.97052801f, -0.89926702f, -1.29544115f, -0.32384357f, 0.36465293f, -0.24652924f, 0.29468349f, 0.16188680f, 
    -0.08299664f, -0.13400304f, -0.00580287f, -0.05520156f, -0.03620720f, 0.03578456f, 0.00763356f, -0.03144280f, 
    0.05206765f, 0.06832790f, 0.19559497f, -0.11459755f, -0.97489172f, -0.97098476f, -0.37242681f, 0.21169242f, 
    -0.23105948f, -0.23386049f, 0.00893280f, 0.01152611f, -0.30244935f, -0.21783327f, -0.01404485f, -0.00762149f, 
    0.03643380f, -0.14210722f, -0.00075905f, -0.01942783f, -0.00149906f, -0.04193981f, 0.26857895f, -0.05227969f, 
    0.04744336f, 0.17684959f, 0.06894393f, -0.01624900f, 0.08294585f, 0.06777722f, -0.02031488f, 0.04742786f, 
    -0.09140280f, -0.02673311f, -0.13912022f, 0.25748807f, 0.19973879f, 0.07873248f, 0.17846586f, 0.07222161f, 
    -0.06357039f, -0.01914123f, -0.22560869f, 0.05991301f, -0.38384321f, -0.98211128f, -0.66727304f, -0.00002607f, 
    -0.29466310f, 0.01970902f, 0.09721818f, 0.03095458f, -0.03902517f, -0.58184379f, 0.06002716f, -0.05631600f, 
    -0.00847414f, 0.06401249f, 0.14010297f, -0.03737108f, -0.03615708f, 0.24328874f, 0.11164145f, 0.03855909f, 
    -0.70043826f, -0.56531668f, -0.76077861f, -0.06161324f, -0.32240584f, -0.00556319f, 0.14048563f, -0.20666979f, 
    -0.05010980f, -0.63416576f, 0.04353498f, -0.04012755f, -0.12459946f, -0.00974019f, 0.04798150f, -0.03498203f, 
    -0.04122148f, 0.25514698f, -0.10262759f, -0.05251607f, -1.35187292f, -1.01696992f, -0.52673829f, -0.08292309f, 
    0.39547533f, -0.21759897f, 0.11579248f, -0.16758470f, -0.00677510f, -0.22942540f, 0.02811888f, 0.03317556f, 
    -0.07362261f, -0.07511121f, 0.05638477f, -0.04336037f, 0.00161161f, 0.12938197f, 0.31507137f, 0.04710467f, 
    -0.65737671f, 0.62907863f, 0.88246381f, 0.06125985f, 0.47465444f, -0.28139830f, -0.17283306f, -0.02749029f, 
    -0.35284784f, 0.28158632f, -0.15261416f, 0.15530054f, 0.10182311f, 0.17552513f, 0.01669781f, -0.00324079f, 
    0.01077322f, -0.00532782f, 0.06305435f, 0.02074063f, 0.20449419f, -0.29004982f, -0.71592021f, -0.13387866f, 
    0.28402707f, -0.26297018f, 0.04515553f, 0.19973665f, 0.25544974f, 0.14407988f, -0.09310065f, -0.02666292f, 
    -0.24851270f, 0.01125848f, 0.11534950f, -0.07025629f, 0.21568342f, -0.03258792f, 0.09808239f, 0.01713978f, 
    0.16209307f, 0.03092373f, -0.01911343f, 0.15868278f, -0.00349158f, 0.01599594f, 0.02652059f, 0.14239940f, 
    -0.05818253f, 0.13459831f, 0.02718340f, -0.01312351f, 0.04556764f, 0.00753455f, 0.02765233f, 0.07286600f, 
    0.10583431f, -0.08866235f, -0.06983268f, 0.13167349f, -0.27802366f, 0.04238283f, 0.19943807f, -0.18574220f, 
    0.32077920f, 0.01738955f, 0.01058771f, -0.01067055f, 0.01975835f, -0.01458780f, 0.09418020f, 0.13393623f, 
    0.22689098f, 0.02227058f, 0.00594540f, 0.02329813f, 0.06797466f, 0.11655489f, 0.01010544f, 0.13023384f, 
    -0.35755080f, -0.02880841f, 0.21744186f, 0.14664422f, -0.09272997f, -0.15656976f, -0.00379543f, -0.04086602f, 
    -0.07722083f, 0.28681433f, 0.07489501f, 0.03913758f, 0.27498204f, -0.22027881f, 0.16999392f, -0.06127530f, 
    0.05425707f, -0.28499103f, 0.07136827f, -0.08074193f, 0.61832088f, 0.22624552f, -0.47402272f, -0.20050839f, 
    0.06272632f, -0.10174406f, -0.14459968f, 0.17800026f, 0.21673940f, 0.03029925f, 0.16353947f, 0.12290166f, 
    -0.01232375f, -0.24902792f, 0.04505900f, 0.01462391f, -0.04042297f, -0.17084672f, -0.18628345f, 0.05844332f, 
    0.01901372f, -0.06297771f, -0.17166278f, -0.23580156f, -0.12942927f, -0.03618505f, -0.01073911f, 0.06438436f, 
    -0.16959012f, 0.05241765f, -0.14927199f, -0.13109010f, -0.19284116f, -0.15539972f, -0.13264689f, -0.29871166f, 
    -0.12036963f, -0.19985297f, 0.04779505f, 0.07912298f, -0.21831520f, 1.08413231f, -0.40442684f, -0.26760343f, 
    0.36488047f, 0.03340735f, 0.08082877f, 0.11419353f, 0.19456725f, 0.03967808f, 0.14574087f, -0.02719326f, 
    -0.00351877f, 0.08268847f, -0.01303900f, 0.14962494f, -0.05621320f, 0.13557369f, 0.03074578f, 0.02351485f, 
    -0.01171446f, -0.33127511f, -0.70862639f, 0.06187113f, 0.20044209f, -0.04109494f, -0.01282049f, 0.07896460f, 
    -0.23035645f, -0.06092250f, -0.11437758f, -0.00647698f, -0.05003620f, 0.12150460f, -0.07951585f, -0.05103278f, 
    -0.00469963f, 0.17992106f, 0.28106567f, 0.06772458f, -0.14582576f, 0.30436924f, 0.03675573f, -0.14917567f, 
    0.00857406f, -0.27800933f, -0.04572092f, -0.21259694f, 0.10266075f, -0.08010791f, 0.10051309f, -0.07677671f, 
    -0.02795704f, -0.06725965f, 0.01892342f, 0.00595411f, -0.07423313f, -0.01963459f, 0.11105176f, -0.17002983f, 
    -0.53253710f, 0.29247090f, -0.18261012f, 0.39612350f, -0.51436788f, -0.08939964f, 0.17923433f, -0.13051096f, 
    -0.18167104f, 0.02075469f, 0.04566017f, -0.00105603f, 0.04320613f, 0.06860202f, -0.00559355f, 0.02398152f, 
    0.08424237f, -0.17119998f, -0.10407552f, -0.03404028f, 0.51106536f, -0.85260451f, -0.95207494f, 0.24011631f, 
    -0.22918734f, 0.20419657f, 0.01280327f, -0.06415003f, 0.26272160f, 0.10171799f, -0.05166544f, 0.07178718f, 
    -0.05799957f, -0.08610912f, -0.00927238f, -0.18089233f, 0.10207362f, -0.00594567f, -0.00629251f, -0.25303718f, 
    -0.16087903f, 0.14556782f, 0.06854100f, 0.04172011f, -0.13345629f, 0.01439193f, -0.05776446f, 0.07427487f, 
    -0.09479173f, -0.07793222f, -0.02846836f, -0.29094860f, -0.08676247f, -0.20527807f, -0.23506081f, -0.01718693f, 
    0.03053026f, 0.01397756f, 0.00023549f, 0.02117097f, -0.85631019f, -0.48138785f, 0.79569757f, -0.05568494f, 
    0.30725923f, 0.25321680f, -0.00743623f, 0.09299257f, -0.03334720f, 0.16596547f, 0.04635430f, -0.12126715f, 
    -0.03497578f, 0.03364375f, 0.01054518f, 0.27614096f, 0.23260242f, -0.09477576f, -0.05170190f, -0.11643904f, 
    -1.34516466f, -1.00859916f, 0.75914592f, -0.08808974f, 0.71579623f, -0.15381490f, 0.14547159f, 0.23370789f, 
    0.12305884f, -0.00064110f, 0.02993083f, -0.02515899f, -0.09243261f, -0.04466899f, -0.04429419f, 0.01194060f, 
    0.00446089f, -0.14613229f, 0.01546953f, -0.02878626f, 0.20287721f, -1.19242525f, 0.01285234f, 0.78256541f, 
    -0.48098144f, -0.05890324f, 0.11198415f, -0.01458120f, -0.12751649f, 0.14066021f, -0.01014444f, -0.03238839f, 
    0.02827078f, -0.11982283f, -0.01707515f, 0.11116475f, 0.04062055f, -0.10129268f, -0.02739267f, -0.02070799f, 
    0.95978922f, -0.49710453f, -1.08199167f, -0.42157525f, -0.50010175f, 0.01720435f, 0.07121241f, -0.40763348f, 
    0.42834318f, -0.34284547f, 0.07642115f, 0.10342234f, 0.11893803f, 0.01598635f, 0.05024603f, -0.00851574f, 
    0.02148889f, -0.00605742f, 0.09210824f, 0.06858110f, -0.13733757f, 0.03565031f, -0.22645204f, 0.12085240f, 
    -0.19182548f, 0.12535805f, -0.00187425f, -0.09774125f, -0.03443418f, -0.24151392f, 0.12024767f, 0.11539215f, 
    0.02495236f, -0.01680344f, -0.13372062f, -0.08169673f, -0.12185394f, 0.10482470f, 0.00036665f, 0.06690611f, 
    0.05447735f, 0.05984953f, -0.01081664f, -0.12671356f, -0.11173858f, -0.04369428f, 0.00640845f, -0.02205885f, 
    -0.21998866f, -0.07428831f, -0.01530463f, 0.03657493f, -0.02369978f, -0.01436906f, -0.05005535f, -0.16685231f, 
    -0.26466671f, -0.12396391f, 0.06829286f, 0.03127539f, -0.08817938f, -0.04328635f, -0.18197842f, 0.16616766f, 
    -0.02211981f, 0.14254582f, 0.08235083f, 0.26130211f, -0.04612187f, -0.03323351f, -0.29436031f, -0.00307145f, 
    0.02817130f, 0.09512525f, 0.03639776f, -0.11004616f, -0.13907577f, -0.17796035f, 0.13285756f, 0.23740034f, 
    0.44279701f, 0.41384527f, 0.00757718f, -0.17477432f, -0.33355087f, 0.16122800f, -0.02980719f, 0.01910239f, 
    -0.04975686f, -0.12650035f, -0.15269780f, 0.12944768f, -0.00322204f, -0.08572830f, -0.11416181f, -0.07063308f, 
    -0.05919062f, -0.01464571f, -0.01348078f, -0.16324714f, -0.13020092f, 0.22159038f, 0.00964876f, 0.05012526f, 
    -0.00437361f, 0.08521933f, -0.02745923f, -0.00003225f, -0.05349501f, -0.07736615f, 0.11476970f, 0.06441181f, 
    0.09773071f, -0.02183093f, 0.17290249f, -0.01741001f, -0.18488044f, -0.02441911f, -0.01920493f, 0.06677528f, 
    0.01733355f, 0.08364957f, 0.05556803f, 0.02064971f, -0.29304728f, 0.04296200f, -0.01295388f, 0.02439517f, 
    -0.00889526f, -0.08377548f, 0.03138639f, 0.01588795f, 0.05511232f, -0.04875179f, -0.01412470f, 0.01541053f, 
    -0.11225547f, 0.09198936f, 0.10841259f, 0.06630629f, -0.52392972f, -0.66110933f, 0.25435156f, -0.58518267f, 
    0.33550581f, 0.01543174f, -0.00553681f, 0.27186269f, -0.06868164f, 0.13810633f, -0.17554060f, 0.07185575f, 
    0.10653732f, -0.02509859f, -0.06662975f, -0.05389033f, -0.05901913f, 0.07281075f, -0.05596804f, -0.05325150f, 
    0.18612264f, -0.57061213f, 0.00724688f, 0.39256954f, -0.05207464f, 0.07781445f, -0.02581489f, -0.39821091f, 
    0.09931698f, 0.20724735f, 0.00591388f, -0.04751546f, -0.18313147f, -0.13689566f, -0.13048095f, 0.12780382f, 
    0.12103168f, -0.17457804f, 0.19411093f, 0.04608575f, 0.43271604f, -0.22851144f, -0.40860566f, 0.10639920f, 
    -0.21307459f, 0.28879949f, 0.00609135f, 0.04283118f, -0.19934028f, 0.12626548f, -0.02692202f, 0.03777116f, 
    0.15596397f, 0.08578704f, -0.05995440f, 0.05294484f, -0.05621486f, 0.09547566f, -0.15077512f, -0.13765143f, 
    0.53436798f, 0.26938492f, 0.40332821f, 0.00752319f, -0.24236985f, 0.19627358f, -0.35386431f, -0.16967165f, 
    -0.00809403f, -0.46299648f, -0.03703967f, -0.08868786f, -0.02197276f, -0.05747747f, -0.05258827f, 0.00059959f, 
    -0.00882518f, -0.44972804f, -0.05523634f, -0.31805634f, -0.14575358f, -0.74756801f, -1.07994115f, -0.64307374f, 
    0.13084431f, -0.04732621f, -0.10380038f, -0.03915848f, 0.05338110f, 0.18307975f, -0.02118985f, -0.00960400f, 
    -0.00320219f, 0.06608258f, -0.00148059f, 0.02039108f, -0.01153099f, 0.06963166f, -0.07093047f, 0.19987230f, 
    -0.47672883f, -0.05212056f, 0.26813409f, 0.03989108f, -0.12438353f, -0.14229709f, 0.14532068f, -0.02121532f, 
    0.08467520f, 0.06772251f, 0.09732395f, 0.11085854f, 0.07055602f, 0.17212950f, 0.11076501f, 0.00794409f, 
    0.12711509f, -0.02640681f, 0.18337440f, 0.12582982f, -0.16968068f, -0.39672801f, 0.02891024f, -0.07809954f, 
    -0.05926840f, 0.06397104f, -0.24629717f, -0.11854088f, -0.25107452f, -0.23241907f, 0.08244773f, 0.02840790f, 
    0.11660054f, -0.12888856f, 0.05700336f, 0.10580548f, -0.13771148f, -0.03548348f, -0.27325943f, -0.37660390f, 
    1.03241599f, -0.89421427f, -0.62257153f, 0.19116619f, 0.04995174f, 0.19924995f, -0.09913990f, -0.17889093f, 
    -0.04420781f, 0.09436707f, 0.02471310f, -0.03146642f, 0.01964443f, -0.01548296f, 0.01259329f, 0.02428542f, 
    0.08619429f, 0.05135208f, -0.02793507f, 0.02653101f, 0.57324392f, -0.23349538f, -0.28565264f, -0.28656894f, 
    -0.09728456f, 0.18464766f, -0.10282748f, 0.02479415f, -0.00252470f, -0.03876931f, -0.01807913f, 0.11515543f, 
    0.03480130f, 0.06324213f, 0.05352456f, -0.00055074f, 0.06223094f, 0.13639027f, 0.23919785f, 0.17915192f, 
    0.02841596f, -0.67628634f, -1.43326128f, -0.50823134f, 0.18303210f, -0.17446582f, 0.04339183f, 0.30088940f, 
    0.30875006f, 0.02736372f, 0.12686370f, -0.13390097f, -0.08969780f, 0.01489350f, -0.06027830f, 0.01777524f, 
    0.00719346f, -0.03660169f, -0.04764578f, -0.15879510f, 0.40859863f, 0.15079890f, 0.04819784f, 0.16293505f, 
    -0.42312422f, 0.20363657f, -0.05853196f, -0.08800757f, -0.02975717f, -0.09769350f, 0.01976934f, 0.02543532f, 
    0.02172621f, 0.00528068f, -0.05033652f, -0.01593865f, 0.18956289f, 0.09556392f, 0.22935106f, -0.04354510f, 
    -0.04645962f, 0.29805872f, 0.13237885f, 0.12111282f, -0.10289831f, 0.02242805f, 0.03660251f, -0.07243884f, 
    0.10721549f, 0.12884408f, -0.03894690f, -0.00345481f, -0.02881010f, -0.02891348f, 0.07599894f, -0.10189392f, 
    0.18930814f, 0.06118308f, -0.07357661f, 0.10132638f, -0.58539337f, -0.24493146f, 0.35366800f, 0.11487932f, 
    0.10061492f, -0.14504281f, -0.08466650f, -0.07943613f, -0.18778063f, -0.12874651f, -0.00857363f, 0.00084160f, 
    0.03819698f, -0.00761225f, 0.06239950f, -0.14045653f, -0.08624794f, -0.09391472f, -0.07931053f, -0.15067881f, 
    0.10111553f, -0.16828248f, -0.30511791f, -0.43012494f, -0.19176081f, -0.12090044f, 0.11696859f, -0.02834696f, 
    0.07933705f, -0.15350705f, 0.03884147f, 0.01715647f, 0.17989683f, 0.10488967f, 0.15322746f, -0.09661405f, 
    -0.01789970f, 0.06359291f, 0.23544660f, 0.08023696f, -0.50275099f, 0.01168906f, 0.04608717f, -0.00563600f, 
    0.27447501f, -0.05516937f, 0.12252934f, -0.14296801f, 0.07809919f, -0.06983612f, -0.01076794f, 0.01486200f, 
    0.07142565f, 0.09804551f, 0.03803739f, -0.00163868f, -0.04605866f, 0.13722061f, 0.12016785f, 0.07583936f, 
    -0.53866851f, 0.18393134f, 0.28286436f, -0.04288640f, -0.27267119f, -0.14346936f, -0.07955956f, -0.12296689f, 
    0.00215826f, -0.02821514f, -0.21427643f, -0.11062273f, -0.09850685f, -0.02578283f, -0.05518165f, 0.10678770f, 
    0.06121862f, 0.03033736f, 0.00238033f, -0.00772893f, 0.26032096f, -0.88666916f, -0.50233549f, 0.05470220f, 
    0.41279778f, 0.33943081f, 0.10928248f, 0.25163603f, 0.00296392f, 0.28455910f, 0.10256829f, 0.05095898f, 
    0.06083408f, 0.14439544f, 0.03546710f, 0.02966179f, 0.04111908f, -0.12091411f, 0.01816661f, 0.03432179f, 
    0.25747204f, 0.33241850f, -0.28422612f, -0.39941555f, -0.11302008f, -0.02816114f, -0.06013824f, 0.02433380f, 
    -0.01623313f, 0.02967459f, 0.03988323f, -0.00639474f, -0.01893556f, 0.15900721f, 0.06752903f, 0.09624270f, 
    -0.00358764f, 0.10756379f, -0.24870472f, -0.63651878f, 0.08741821f, -0.26871464f, -0.33485678f, -0.10904878f, 
    -0.03250132f, -0.23067260f, -0.05635373f, -0.01690386f, 0.04869037f, -0.02782249f, 0.07314412f, 0.02021748f, 
    -0.15431988f, -0.05732406f, -0.07395996f, 0.00707620f, 0.15671760f, 0.12301061f, 0.21728644f, 0.08786740f, 
    -0.19445567f, 0.18010308f, -1.26868224f, 0.44273090f, -0.22569799f, 0.05121605f, 0.30422744f, 0.35203496f, 
    -0.07801878f, 0.14859952f, -0.00787576f, -0.00632939f, -0.08305057f, -0.01130681f, -0.08355732f, 0.00792049f, 
    0.00537175f, -0.10214845f, 0.14677477f, 0.07165042f, -0.39583778f, -0.18310019f, 0.57737631f, 0.34720758f, 
    -1.05019975f, 0.19262058f, -0.56099385f, 0.06973810f, 0.18744612f, 0.25935185f, 0.00213155f, 0.03378191f, 
    0.07670325f, -0.02236184f, -0.02712256f, -0.06713174f, 0.07537688f, 0.02368883f, -0.04851697f, 0.01938227f, 
    0.08740384f, 0.12325511f, 0.21425320f, -0.46783543f, 0.17042275f, 0.02378522f, -0.14934175f, -0.06082395f, 
    0.04823092f, -0.04336807f, 0.10244451f, 0.11182027f, 0.03602361f, -0.04818891f, 0.01556478f, 0.16450872f, 
    0.13935144f, -0.11904249f, -0.06249695f, 0.12056695f, 0.73301923f, -0.82103312f, -0.43127951f, 0.13200785f, 
    -0.05328391f, -0.08867099f, -0.04237428f, 0.09098098f, -0.08421866f, 0.18847071f, -0.09811684f, 0.02765161f, 
    -0.03417977f, -0.02057978f, 0.04785220f, -0.02401577f, 0.16843009f, 0.31598887f, 0.07329205f, 0.22583173f, 
    -0.24434537f, -0.30343464f, 0.42739430f, 0.09586260f, -0.29644796f, -0.39293092f, -0.14088519f, 0.11474096f, 
    -0.03412179f, 0.04998066f, 0.00163901f, -0.00354911f, 0.01852384f, -0.05631412f, -0.14048292f, -0.00066994f, 
    -0.02778143f, -0.00258940f, -0.11929551f, -0.12854618f, -0.40497860f, 0.23714224f, -0.25847411f, -0.06823175f, 
    -0.17193247f, -0.06700114f, 0.01631323f, 0.27193120f, -0.15563214f, 0.12265633f, 0.04289201f, -0.10491722f, 
    -0.01360011f, -0.14167786f, -0.08767021f, 0.12460269f, -0.02679060f, 0.06082462f, 0.07968163f, -0.36860082f, 
    0.02449949f, 0.29135561f, 0.08434117f, 0.80730671f, -0.61420113f, -0.13274303f, -0.06788791f, -0.78585875f, 
    0.04059221f, -0.19587903f, 0.22277904f, -0.07700548f, 0.09895957f, 0.17657042f, 0.07773356f, 0.17198138f, 
    0.08977418f, -0.02761990f, 0.00746421f, 0.06491996f, -0.29457679f, 0.27717325f, -0.68091977f, -0.02733880f, 
    -0.26673511f, 0.46534824f, -0.01795301f, 0.12295232f, -0.19089319f, -0.12581271f, 0.19244915f, -0.18845561f, 
    -0.17552300f, -0.09357119f, -0.17979485f, -0.24111019f, -0.14558107f, -0.32049403f, -0.04005741f, 0.11974581f, 
    -0.07971535f, -0.21768415f, -0.19827980f, -0.44604829f, 0.35598782f, 0.07560232f, 0.19461386f, -0.06826644f, 
    0.01898985f, 0.10613474f, 0.19605355f, 0.07425063f, 0.11335167f, -0.08207603f, -0.07051926f, -0.02317635f, 
    -0.04337463f, -0.14718623f, -0.17217420f, -0.01054241f, 0.18287602f, -0.13490373f, -0.07973450f, -0.07765917f, 
    0.15476194f, 0.06475033f, -0.20706274f, 0.14973621f, 0.14655274f, -0.12490828f, -0.09303225f, 0.07337610f, 
    -0.00392229f, -0.05946937f, -0.07531084f, 0.19070306f, 0.18587525f, 0.14529267f, -0.02825308f, 0.26546609f, 
    -0.75780618f, 0.16354504f, 0.17736247f, 0.72251928f, 0.25711182f, -0.06063469f, -0.02516125f, -0.35417265f, 
    -0.13068241f, -0.10091349f, -0.00528758f, 0.03405552f, 0.07267997f, -0.24231800f, 0.09937968f, 0.14175460f, 
    -0.16841525f, -0.28181198f, 0.05792191f, 0.06825197f, -0.57224995f, 0.52239907f, -0.17547889f, -0.54744291f, 
    0.09001461f, 0.05766665f, -0.09907892f, 0.18619159f, -0.09072641f, 0.08770659f, 0.03783086f, -0.00955679f, 
    -0.08203812f, -0.02397486f, 0.19141126f, -0.06762721f, 0.22849831f, -0.15007177f, -0.02929343f, -0.03211581f, 
    -0.42034307f, -0.09979584f, -0.32419494f, -0.31938487f, 0.28320205f, 0.07788034f, 0.17189302f, 0.19756000f, 
    0.09758151f, 0.05306531f, 0.07239632f, 0.05262816f, 0.11462601f, 0.09649857f, 0.00015260f, 0.07986162f, 
    0.02680708f, 0.09881251f, -0.01672652f, 0.02196729f, -0.27438349f, -0.48541477f, 0.64501905f, -0.28295800f, 
    -0.72238171f, -0.01325448f, -0.44072813f, -0.11683626f, -0.10468460f, -0.03162225f, -0.04875715f, 0.09044649f, 
    -0.05750194f, 0.12625149f, 0.06926353f, 0.02647194f, -0.24485971f, -0.05015820f, -0.10913665f, 0.03084057f, 
    -0.44731009f, 0.01602583f, -0.28230307f, 0.31512910f, -0.69391799f, -0.22149326f, 0.08639499f, -0.06491068f, 
    0.14583565f, 0.09666803f, 0.16113904f, -0.00811537f, 0.09587631f, 0.14868192f, 0.08255489f, -0.11005562f, 
    0.21222427f, 0.05803574f, 0.35070291f, 0.17281555f, -0.30863735f, 0.40068322f, 0.43957469f, -0.00072923f, 
    -0.21832559f, 0.09304496f, -0.26691255f, -0.05053605f, -0.12467158f, 0.01207435f, -0.03798330f, 0.13366011f, 
    0.05627737f, -0.07868882f, -0.02652243f, -0.01179682f, -0.16224003f, -0.15220369f, 0.05322100f, -0.09823187f, 
    -0.04472136f, -0.40137908f, -0.22787331f, -0.04967132f, 0.25267074f, -0.00699657f, -0.20854957f, 0.09069343f, 
    -0.38487244f, -0.31929699f, -0.08434229f, 0.14404772f, -0.02900107f, -0.00064187f, -0.01266106f, 0.23401105f, 
    -0.42849591f, -0.21273860f, -0.28281537f, -0.12388029f, -0.69951475f, -0.01557766f, -0.32800037f, 0.02547851f, 
    0.21256055f, -0.19062661f, -0.08382246f, -0.28410754f, 0.02755111f, 0.03626541f, -0.06226590f, 0.10573820f, 
    -0.05658005f, 0.10676247f, 0.00898904f, 0.11487862f, -0.10263272f, -0.05849029f, -0.09398176f, -0.05474323f, 
    -0.03843972f, -0.20802937f, 0.33835343f, 0.02966361f, -0.19259143f, -0.01929055f, 0.02809696f, -0.16441788f, 
    0.01476766f, 0.13421963f, -0.13978700f, -0.12285204f, 0.03266849f, 0.05021391f, -0.11650317f, -0.18624809f, 
    -0.00435738f, 0.17698853f, 0.04906667f, -0.09706422f, -0.04444442f, 0.10253672f, -0.78131473f, 0.09781632f, 
    -0.00171861f, -0.01083328f, -0.05097259f, 0.35527569f, -0.09459984f, 0.00401839f, 0.10258728f, 0.08384240f, 
    -0.10851919f, -0.01950159f, -0.16205490f, 0.07280251f, -0.26448607f, -0.15738219f, -0.57272995f, -0.28727922f, 
    -0.78326458f, 0.31449792f, -0.28863719f, 0.35105085f, 0.07355903f, 0.03080507f, -0.05451174f, -0.23229516f, 
    0.33797777f, 0.11240951f, -0.13590747f, -0.00232640f, 0.01218630f, 0.12608168f, -0.00135637f, -0.03655332f, 
    0.06698626f, -0.42265400f, 0.04956319f, 0.10033629f, -0.13792109f, 0.14208202f, 0.04700657f, -0.12899055f, 
    0.28502592f, -0.08249274f, -0.04780129f, 0.38292578f, 0.11394405f, 0.06279114f, -0.05428131f, 0.20144367f, 
    0.03089751f, 0.05510912f, 0.01453409f, 0.20873484f, 0.05529481f, 0.14714594f, 0.02881314f, 0.06916962f, 
    0.29556468f, 0.31091654f, -0.15179262f, 0.01750753f, 0.06243756f, 0.09754991f, -0.03601221f, -0.22435562f, 
    -0.08243804f, 0.04039592f, -0.15021452f, 0.14285146f, -0.05440252f, -0.25154376f, -0.30452916f, 0.02474995f, 
    -0.06588291f, -0.10362044f, 0.08293035f, -0.04384774f, -0.63718623f, -0.74481338f, 0.32207501f, 0.21494907f, 
    -0.04640537f, -0.12830502f, -0.14633210f, 0.13212588f, 0.52096671f, 0.03265176f, -0.33013847f, -0.04405368f, 
    -0.01539529f, 0.08012264f, -0.10430232f, 0.00347898f, 0.05807449f, 0.16605604f, 0.45605063f, 0.19234456f, 
    -0.15504637f, 0.01154816f, 0.48659572f, -0.04759661f, -0.02504248f, 0.13375841f, -0.22908287f, 0.19989833f, 
    0.11660993f, 0.10094062f, -0.28769019f, 0.07639164f, 0.18828140f, -0.13609956f, 0.04069669f, -0.12851696f, 
    0.11483938f, 0.17211232f, 0.02297352f, 0.14639880f, -0.18020804f, 0.18945709f, -0.07645341f, 0.15552187f, 
    -0.04855398f, 0.07995538f, -0.00984341f, -0.01738687f, -0.16948776f, -0.10134121f, 0.10258154f, 0.17552060f, 
    -0.05940375f, 0.01871177f, -0.02704666f, -0.12180011f, -0.19522080f, 0.00249865f, -0.19551778f, -0.28525054f, 
    0.73420101f, -0.01187826f, 0.44572425f, -0.32711399f, -0.31681275f, -0.15099041f, -0.16101035f, 0.27823147f, 
    -0.06107519f, -0.01717253f, -0.01159277f, -0.04338744f, -0.24868317f, 0.03111717f, 0.05689281f, 0.02051469f, 
    -0.19918378f, 0.17393184f, 0.02890429f, 0.08083676f, -0.16245416f, -0.40387467f, -0.26019865f, 0.54816604f, 
    -0.06204768f, -0.24183260f, -0.09189001f, 0.40723568f, 0.02392439f, -0.28677428f, -0.00529585f, -0.07151418f, 
    0.10363076f, 0.07372004f, 0.14296219f, -0.01594437f, -0.06502177f, 0.28101605f, 0.11196379f, 0.09584060f, 
    0.01787091f, -0.65013582f, -0.01496075f, -0.56086069f, -0.53194398f, -0.06186822f, -0.41312680f, -0.09211511f, 
    0.11086359f, -0.26931322f, -0.23428066f, 0.15537834f, 0.03435263f, -0.17324120f, -0.03157309f, 0.25822130f, 
    -0.01645964f, 0.06007484f, 0.12469856f, -0.15170649f, -0.79295164f, 0.24335964f, 0.04800664f, 0.34802249f, 
    0.12654653f, 0.08094813f, 0.01119476f, -0.23248017f, 0.40735301f, 0.21910328f, -0.06898217f, -0.08537579f, 
    0.01407974f, -0.08602029f, 0.01596713f, -0.11843623f, 0.08944771f, -0.18132119f, 0.11147868f, 0.06851045f, 
    -0.15940002f, 0.15665275f, -0.22472213f, 0.15712897f, 0.12705123f, 0.05991948f, 0.00641312f, 0.25089151f, 
    0.00093994f, -0.22073893f, 0.03429057f, 0.00702679f, 0.12917589f, -0.02932804f, 0.00352810f, -0.00442647f, 
    -0.18151167f, -0.23404205f, -0.16949554f, -0.16368026f, -0.22531465f, -0.32317999f, 0.21129186f, 0.07658435f, 
    -0.10961806f, -0.10969459f, 0.10211293f, 0.05390174f, 0.21291497f, -0.05890486f, -0.10149938f, 0.00538375f, 
    -0.00573145f, 0.08580719f, 0.07218973f, 0.09605618f, 0.21941270f, 0.07825886f, 0.25290957f, 0.36882138f, 
    0.84986651f, -0.40390551f, 0.75616348f, -0.20457147f, 0.06679251f, 0.04686704f, -0.23443340f, 0.05814543f, 
    0.21796866f, -0.08622488f, -0.05675190f, 0.03699860f, -0.02057490f, -0.17052822f, -0.08524884f, -0.16414236f, 
    0.09275063f, -0.09491914f, 0.02009766f, 0.22772512f, 0.45739514f, -0.36720887f, 0.13139807f, -0.01378266f, 
    0.13270140f, -0.16099989f, -0.27511787f, -0.01303677f, -0.09123910f, -0.19477065f, 0.12959120f, 0.10282337f, 
    0.18700488f, -0.07227715f, -0.17067611f, 0.01681584f, -0.04908698f, 0.09593181f, 0.03655409f, -0.11824515f, 
    -0.14330889f, -0.04000334f, -0.64856237f, 0.36344853f, 0.16971987f, -0.08327087f, 0.32900873f, 0.03642540f, 
    0.28852656f, 0.07317112f, -0.17440522f, 0.02219788f, 0.05090348f, 0.16693892f, 0.03814946f, -0.08722334f, 
    -0.00012086f, 0.03797662f, -0.27074262f, -0.02678049f, 0.12392007f, -0.62513769f, -0.21665227f, 0.21757475f, 
    0.09900906f, -0.01132288f, -0.44716817f, -0.05116801f, 0.06410725f, -0.21892618f, 0.00951675f, -0.04287784f, 
    0.05556273f, -0.05191890f, -0.06387246f, 0.14086288f, 0.06138689f, 0.14153776f, 0.34158042f, -0.12453888f, 
    -0.42312926f, -0.11835576f, -0.38101113f, 0.30738795f, -0.14712033f, -0.12824292f, -0.59311283f, -0.05772820f, 
    0.11797797f, -0.13338594f, -0.10237019f, 0.08180936f, -0.05552788f, 0.05418385f, 0.10438533f, 0.17778879f, 
    -0.06672861f, 0.16751756f, 0.11081783f, -0.08743028f, 0.00700254f, -0.55242079f, -0.10920677f, -0.02183505f, 
    0.13768306f, -0.09010278f, -0.26673293f, -0.10990607f, -0.10173123f, 0.01868585f, 0.03245507f, -0.00293394f, 
    -0.08236250f, 0.06615317f, -0.07363501f, 0.20812689f, -0.11911707f, -0.10103984f, 0.00016441f, 0.07809104f, 
    -0.76876503f, -0.03828299f, -0.20111950f, 0.17574818f, -0.91640979f, 0.14899158f, 0.00241732f, 0.00760555f, 
    -0.20502865f, 0.28480640f, -0.16863047f, -0.10704660f, 0.05341670f, 0.12349004f, -0.02006840f, -0.05584876f, 
    -0.10176908f, -0.04222295f, -0.12259615f, 0.08472891f, 0.54893005f, 0.54639465f, 0.66225559f, -0.01565610f, 
    -0.04731694f, 0.00934700f, 0.16420485f, 0.17947713f, 0.07940082f, -0.20385639f, -0.24491751f, 0.06216371f, 
    0.17743687f, -0.04099991f, 0.08953432f, 0.07315038f, -0.13533650f, -0.07670505f, 0.05495010f, -0.11974362f, 
    0.04025745f, 0.19205837f, 0.03315050f, 0.16959082f, -0.07629151f, -0.12387402f, 0.01935246f, 0.14963324f, 
    0.17304114f, -0.06147182f, -0.06988428f, -0.06554039f, -0.03793006f, -0.12778205f, -0.07528917f, 0.30628014f, 
    -0.03350669f, 0.14635478f, 0.06167253f, -0.00914021f, -0.49943247f, -0.09377393f, -0.42601433f, 0.21193029f, 
    0.06099932f, -0.04518449f, 0.15686291f, -0.09357207f, 0.10192821f, -0.12075645f, -0.37458166f, -0.05203866f, 
    0.15458336f, 0.21103103f, 0.05950573f, 0.12450846f, 0.01660527f, 0.14652853f, -0.07118520f, 0.00707955f, 
    -0.45614663f, -0.31251699f, 0.11468378f, -0.08781505f, 0.31254864f, 0.06153077f, 0.32392979f, 0.15890197f, 
    -0.23509289f, 0.26349854f, 0.09178109f, 0.19321723f, -0.01974689f, -0.00500157f, 0.03365659f, 0.09513691f, 
    0.02301471f, 0.00352906f, -0.16057158f, 0.03667665f, 0.62385434f, -0.27582681f, 0.44856191f, 0.19709995f, 
    0.04070492f, -0.01968409f, 0.43430755f, -0.26343298f, 0.24918266f, -0.15434419f, -0.32793453f, -0.00158612f, 
    -0.03753824f, -0.05856704f, 0.02438942f, -0.15095140f, 0.10954532f, 0.05119578f, 0.09875004f, -0.00597828f, 
    0.12004727f, -0.18960565f, -0.07539821f, -0.02980971f, -0.15104881f, -0.09885942f, 0.15781079f, -0.16985629f, 
    0.08132786f, -0.04171179f, -0.21298940f, -0.09170929f, -0.00302350f, -0.13040221f, -0.09417588f, 0.03680507f, 
    0.12029515f, -0.02303471f, -0.29076412f, 0.02236031f, -0.64331728f, -0.39360645f, 0.31812790f, 0.84654939f, 
    -0.44714385f, -0.06392013f, 0.08547140f, -0.15069337f, 0.54135388f, -0.32246402f, -0.13903528f, -0.06016827f, 
    -0.09915695f, -0.05887835f, 0.19790897f, 0.00103175f, -0.13009933f, 0.24033298f, 0.11730525f, -0.15132827f, 
    -0.13165556f, -0.60793257f, -0.39888051f, -0.19641747f, 0.15228535f, -0.02687525f, -0.05165144f, 0.32111731f, 
    -0.13505018f, -0.05883667f, 0.04573483f, 0.02813413f, 0.12275624f, 0.05909202f, 0.08106993f, 0.09439940f, 
    -0.00063240f, 0.10306293f, -0.00205843f, 0.00119049f, -0.02292041f, -0.24548499f, 0.06362145f, -0.02043971f, 
    0.39009967f, 0.11521129f, 0.13727953f, -0.20608701f, 0.06843490f, -0.08395095f, -0.02442070f, 0.18272392f, 
    -0.13788037f, -0.04896634f, 0.10094213f, -0.04059339f, -0.08862796f, -0.01425245f, -0.31170064f, -0.30092439f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.30293146f, 0.13337746f, 0.12399884f, -0.12456179f, -0.05384910f, 0.00089915f, 0.11635597f, -0.10228889f, 
    0.04951689f, 0.06435438f, 0.02604054f, -0.04515873f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
