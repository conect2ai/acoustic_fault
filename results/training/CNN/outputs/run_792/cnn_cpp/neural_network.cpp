#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.73818314f, -1.20323873f, -0.85969239f, -0.77676028f, 0.88813126f, 0.51745778f, -0.26627117f, -0.04077589f, 
    -0.38810959f, 0.88644463f, 0.02229003f, 0.72381204f, 0.81338328f, 0.67151105f, 0.56297791f, -0.69325233f, 
    -0.56514001f, 0.38072914f, -0.55691522f, -0.51384544f, 1.01660669f, -1.31726503f, -0.42465043f, -0.38847864f, 
    0.43455124f, 0.23144825f, 0.03012444f, 0.04459909f, 0.02490177f, -0.30611414f, 1.06482553f, 0.42958131f, 
    0.39044264f, -0.71581984f, 0.18172744f, 0.78012633f, -1.81265819f, 0.99913508f, -0.09576656f, 0.06546592f, 
    0.04374034f, 0.44044289f, 0.01558259f, 0.34289941f, 0.78738886f, -0.93491018f, -0.88946503f, -0.90000284f, 
    0.12321494f, -0.74512303f, -0.17798354f, -0.46134621f, -0.25571787f, -0.42235380f, -0.92975533f, -1.24289262f, 
    -0.91251749f, -0.16502099f, -0.00246064f, -0.31976035f, 0.83343154f, 0.38840303f, 0.63017237f, 1.09702349f, 
    0.79758471f, 0.98514587f, -0.46977094f, -0.89328784f, -0.18485862f, -0.79626209f, -0.72453058f, -0.46748602f, 
    0.86590117f, 1.11314297f, 0.17527761f, -0.77220166f, 1.03641772f, -0.27469581f, -0.37226030f, 0.41079572f, 
    0.63652790f, 0.13934977f, 0.69178069f, 0.43695986f, 0.53308213f, -1.13666630f, 0.81412899f, 0.07049491f, 
    0.11188021f, 0.42398462f, 0.61993200f, 1.04654241f, 1.28117943f, -0.68389148f, 0.65187263f, -0.78992754f, 
    0.16758303f, 0.25698206f, -0.25065735f, 1.10555184f, 0.75814283f, 0.97071826f, 0.52083361f, -0.28852010f, 
    0.49284714f, 0.59448040f, 0.88266712f, -0.33048591f, 0.26664019f, -1.46320093f, 0.09889157f, 0.90829748f, 
    0.34212035f, 1.08190429f, -0.28608024f, -0.50447381f, -0.33220798f, 0.02802337f, -0.40390831f, -0.48542029f, 
    0.51846981f, 0.19920178f, -1.07617891f, -0.73062646f, -0.81198955f, -0.19708745f, -1.29959667f, -0.70490575f, 
    -0.18999620f, 1.00265801f, 1.01226640f, -0.02250622f, -0.18919362f, 0.02933478f, -0.35586289f, 0.62842244f, 
    -0.84127963f, 0.95387751f, -0.01406633f, -1.45120120f, 0.69876152f, -0.24756743f, 0.33319041f, -0.23020138f, 
    -0.78408247f, -0.57328343f, 0.45571452f, -0.50956607f, 1.13674140f, -0.78561461f, 0.28051344f, -0.19077891f, 
    -0.38948879f, -0.92697102f, -0.19569577f, -1.23494554f, 0.16104908f, 0.76886487f, 1.25844276f, 0.03225382f, 
    -0.01248821f, -0.14892240f, -1.16752148f, -1.27357829f, 0.15694338f, 0.35795525f, -0.45633292f, 0.43653452f, 
    0.56016928f, -0.18347071f, -0.06864724f, 0.48291519f, 1.07295048f, -0.05655458f, -0.77330154f, -1.20711255f, 
    -0.82461458f, 0.57107329f, -0.49579081f, 0.20221822f, -0.88875997f, 0.54150540f, 0.72971028f, 1.10586059f, 
    0.87677336f, 0.38580522f, 0.60365403f, -0.20096439f, -0.33804724f, -0.11021436f, -0.88848841f, 0.09083420f, 
    -1.08400440f, 0.75997061f, -1.01452744f, -0.15797743f, 0.50395405f, -0.06931814f, -0.43990070f, 0.14583693f, 
    -0.07968254f, -0.26039359f, -0.80464828f, -0.93246305f, -0.27523944f, 0.51792681f, 0.99836141f, -1.17266297f, 
    -0.87343913f, -0.02622674f, 0.53998333f, -0.42983180f, 0.34961420f, 0.21339068f, -0.45721769f, 0.35207027f, 
    1.12719965f, 1.13299060f, -0.89993048f, 0.49126792f, -0.10547510f, -0.06468090f, 0.28076595f, 0.48867974f, 
    -0.14194606f, -0.46467450f, 0.68032920f, -0.71162134f, -0.94704628f, -0.77648562f, -0.88331234f, -0.39979169f, 
    0.68889248f, -0.28779411f, -0.21098270f, 1.12506843f, -0.56657642f, 0.84379488f, 1.03153586f, 0.13835409f, 
    0.39064065f, -0.27056158f, -0.14516847f, 1.00508344f, 0.64731598f, -0.34717202f, -0.64638764f, -0.38567892f, 
    -0.76824361f, 0.80022836f, 0.36701366f, -0.30964869f, -0.09012069f, -0.65442079f, 0.43182260f, -1.04984438f, 
    0.33437267f, 0.53342950f, 0.70040512f, 0.35299221f, 0.26486546f, 0.34061193f, 0.40452605f, 1.44009304f, 
    0.78429389f, -0.73741955f, -0.21572252f, 0.33415675f, -0.23009740f, 0.19965225f, -0.97857779f, -0.11079916f, 
    0.95941192f, -0.46297848f, -0.23059586f, 0.73184043f, -0.22671029f, -0.43840316f, -0.51827532f, -1.04580224f, 
    0.33764407f, 0.69923419f, -0.12972188f, 1.01739454f, 0.96830624f, -0.52457273f, 0.47547570f, 0.30537713f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.07245164f, 0.26658681f, -0.19088441f, 0.31401104f, -0.04484598f, -0.01671058f, 0.09592767f, 0.21462011f, 
    0.26902220f, -0.01710831f, 0.40170625f, 0.00647443f, -0.16997451f, 0.31136721f, 0.06875411f, -0.01517615f, 
    -0.05553864f, 0.03558803f, 0.13831413f, 0.09691729f, -0.35268554f, 0.03972721f, 0.05692431f, 0.14701043f, 
    0.04065038f, 0.38562772f, -0.31596988f, -0.04076708f, 0.03098945f, -0.01285051f, -0.15950927f, -0.20402944f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05657464f, -0.15051228f, -0.02076725f, 0.13201512f, -0.14009099f, -0.01715088f, -0.16892235f, -0.07479871f, 
    -0.20908011f, 0.15211371f, 0.33025265f, 0.14294283f, 0.03100149f, -0.06556237f, -0.27784970f, 0.01733520f, 
    0.27438739f, 0.09472684f, 0.17973986f, 0.25516653f, -0.05667248f, 0.05758012f, -0.05132744f, 0.09412503f, 
    0.05069323f, 0.20698375f, -0.21638428f, 0.24230078f, 0.18560761f, 0.09427957f, -0.00042632f, 0.20221479f, 
    0.08178893f, 0.06888210f, 0.03869798f, 0.00180498f, -0.49821040f, -0.06614900f, -0.07273532f, -0.00084001f, 
    0.00190401f, -0.04686204f, -0.04202913f, 0.03468849f, 0.15958475f, -0.17918798f, 0.36007547f, -0.25048941f, 
    0.15544593f, 0.22785832f, -0.01353424f, -0.00162119f, 0.17669350f, -0.21841869f, -0.12942152f, 0.22778046f, 
    -0.31819141f, -0.09330224f, 0.13900833f, 0.17456761f, 0.17417528f, 0.07514830f, -0.08283005f, -0.04040286f, 
    0.05311923f, -0.01744929f, 0.16310643f, 0.00919195f, 0.09548973f, -0.19223490f, -0.33687690f, -0.05342790f, 
    -0.10028196f, -0.04811184f, 0.00963314f, 0.15685955f, 0.09876213f, -0.08139490f, -0.04948934f, 0.07055323f, 
    0.20997144f, 0.05534295f, 0.06690188f, 0.13597952f, 0.23634766f, -0.21511756f, 0.08932419f, 0.06363172f, 
    0.02683345f, 0.28306207f, 0.07596958f, -0.10497960f, 0.01092844f, 0.08581701f, 0.17700702f, 0.10083636f, 
    -0.07366345f, -0.07966714f, 0.17026292f, 0.09509479f, 0.12163515f, 0.15326127f, 0.16411620f, 0.04812081f, 
    -0.14467943f, 0.09345367f, 0.13904747f, 0.18038301f, -0.03051472f, 0.05787401f, 0.14370318f, -0.08051072f, 
    0.09776359f, -0.33451390f, -0.08399452f, 0.12832038f, -0.22091064f, -0.06252502f, -0.05137977f, 0.03567881f, 
    0.06084434f, 0.05932973f, -0.02351605f, -0.14976029f, 0.04587923f, -0.23229982f, -0.22048514f, 0.03816950f, 
    -0.12623046f, -0.23649640f, 0.01440395f, -0.05730559f, 0.05138320f, -0.07759298f, -0.14891976f, -0.17872612f, 
    0.04881249f, 0.14967233f, -0.06576654f, -0.21199970f, 0.24100533f, 0.11976945f, -0.08897694f, 0.10934679f, 
    -0.19103372f, 0.01637177f, -0.08036821f, -0.01344169f, 0.15217850f, 0.05448008f, 0.08680564f, -0.31391829f, 
    -0.22748958f, 0.21440598f, 0.04847127f, 0.06002482f, -0.11108124f, 0.08607023f, -0.33409116f, 0.04643367f, 
    -0.09840027f, 0.00130546f, -0.59056395f, 0.08280562f, -0.10916747f, 0.20722680f, -0.15251547f, 0.10349111f, 
    0.11770429f, 0.18149818f, 0.01657546f, 0.09757694f, -0.19855648f, -0.10158319f, 0.21120557f, -0.03630378f, 
    0.19754706f, -0.00592692f, -0.05641251f, 0.02530319f, 0.08042082f, 0.07839175f, 0.03760653f, -0.22029822f, 
    -0.02303336f, -0.10963932f, 0.04768065f, 0.17729770f, 0.17494969f, 0.08103825f, -0.09741579f, 0.04470595f, 
    -0.13980180f, 0.00980679f, 0.15158033f, -0.01262324f, -0.19790791f, -0.06343393f, 0.21280913f, -0.15943182f, 
    -0.09883274f, -0.03234603f, 0.10996271f, 0.18521337f, -0.05207082f, 0.27203745f, 0.12891242f, -0.42476574f, 
    0.23865353f, -0.17219053f, 0.16994558f, -0.00833515f, 0.03467280f, 0.16403064f, 0.16238295f, -0.10627986f, 
    -0.05958331f, -0.24163309f, -0.24994056f, 0.01467466f, 0.07483130f, -0.06590734f, -0.00254868f, 0.01516570f, 
    0.26979318f, 0.11495353f, -0.19656791f, -0.33690053f, -0.00730071f, 0.00951079f, 0.23616484f, -0.09932379f, 
    -0.19957133f, -0.12048629f, 0.33045545f, -0.17786014f, -0.09784302f, 0.00080446f, -0.01758981f, -0.31980282f, 
    0.22607817f, 0.08499718f, 0.00427863f, -0.06690829f, -0.16038932f, 0.01438670f, -0.11667462f, 0.17000452f, 
    -0.00241168f, -0.03300617f, -0.19807552f, 0.12866499f, 0.02224356f, 0.07002125f, 0.14242813f, 0.08445130f, 
    -0.16422844f, 0.12735416f, 0.10322381f, -0.01338947f, 0.13688372f, -0.13695680f, -0.05301641f, 0.25368059f, 
    0.25735161f, -0.00688065f, -0.02739031f, -0.01746098f, 0.02391538f, 0.03070698f, 0.00687807f, 0.10273686f, 
    0.03621682f, 0.12765537f, -0.02019562f, -0.27539271f, -0.08932992f, 0.08133564f, -0.08781032f, -0.25699160f, 
    0.11407649f, 0.03444898f, 0.07658885f, 0.01537616f, -0.22283907f, 0.07779638f, -0.06444959f, 0.03208043f, 
    0.31116724f, 0.01340809f, 0.06994761f, 0.05844631f, 0.07087933f, 0.10780476f, -0.04802566f, 0.06710491f, 
    0.03197644f, 0.19007921f, -0.02938240f, 0.07942118f, -0.06572498f, -0.12098137f, -0.22937168f, 0.22239210f, 
    0.15545024f, -0.11075173f, 0.02228225f, -0.95367980f, 0.00643891f, -0.08172343f, -0.03823098f, 0.10821282f, 
    -0.26216853f, 0.04820208f, 0.16862756f, 0.16294345f, -0.26038507f, -0.09907049f, 0.06945959f, -0.07181704f, 
    -0.17282052f, 0.15695122f, 0.14653517f, -0.04544227f, 0.18310192f, -0.10268476f, -0.09572732f, 0.29843968f, 
    -0.23452114f, 0.14171956f, 0.10003451f, -0.23854795f, 0.07581297f, 0.12115885f, -0.01438159f, 0.23068689f, 
    0.24344110f, 0.16245918f, 0.05401829f, 0.27069110f, -0.16884811f, 0.10490953f, 0.12065997f, 0.16095839f, 
    0.07226001f, 0.21329676f, 0.06778020f, 0.04522049f, -0.09987297f, -0.07760603f, 0.00511133f, 0.28292382f, 
    0.13193950f, 0.20708092f, -0.45260698f, -0.27681920f, -0.30732763f, 0.20534782f, 0.25661924f, 0.07332260f, 
    0.01699654f, -0.23433727f, -0.02123819f, -0.08663263f, -0.13655221f, -0.02431204f, 0.00512450f, 0.14616199f, 
    0.25626889f, -0.13417315f, 0.16942917f, 0.00073626f, -0.04783935f, -0.12763381f, -0.05692784f, -0.09289509f, 
    0.02440398f, 0.01368951f, -0.07935167f, -0.23078936f, 0.12600616f, -0.07354357f, 0.04978879f, -0.15319198f, 
    0.18779558f, -0.00493607f, 0.11359264f, 0.17713314f, -0.01191527f, -0.21781509f, -0.24582693f, -0.05104764f, 
    0.01368948f, 0.11449102f, -0.00818322f, 0.13252202f, 0.32667604f, -0.03264669f, 0.01427810f, 0.22552039f, 
    0.13645673f, 0.02129932f, 0.15209116f, -0.17329575f, 0.06896812f, 0.06195894f, 0.14812800f, 0.11067376f, 
    0.14914799f, -0.02692619f, -0.04089008f, 0.21840341f, 0.10902986f, -0.05270498f, 0.10680229f, 0.34679630f, 
    -0.03350139f, 0.22420140f, 0.04176578f, -0.03182253f, 0.04550430f, 0.05143438f, 0.13556932f, -0.04809903f, 
    -0.08615309f, 0.05614372f, -0.21558976f, 0.00617441f, 0.12460846f, -0.08970158f, 0.10839439f, -0.01284648f, 
    -0.29308629f, 0.22653651f, 0.11052593f, 0.04336457f, 0.04069236f, 0.12944920f, 0.00904420f, 0.08542851f, 
    -0.34507343f, 0.41645172f, -0.03485024f, -0.28411022f, 0.16611761f, 0.01387135f, -0.13479629f, -0.07094815f, 
    0.10506646f, 0.09780016f, -0.02863807f, 0.04522636f, 0.20372325f, 0.10899834f, 0.02948430f, 0.12411530f, 
    0.11403431f, -0.08493587f, -0.00502432f, -0.26206511f, 0.27731526f, 0.32456246f, -0.19780309f, -0.33936143f, 
    -0.04141423f, -0.28093985f, -0.06928627f, 0.01962078f, -0.29971838f, 0.43051216f, 0.08642029f, -0.15304686f, 
    0.02520144f, -0.10634849f, 0.20292662f, 0.09618372f, 0.03519864f, -0.18779385f, -0.31401291f, 0.36955619f, 
    0.02443240f, 0.17719151f, 0.27141216f, -0.36450723f, -0.09638409f, -0.19105786f, -0.44133475f, -0.00648793f, 
    0.08217678f, 0.03765587f, -0.01414843f, -0.00532634f, -0.05305525f, 0.08908494f, -0.14694038f, -0.06074635f, 
    0.19508152f, 0.13051291f, 0.23423414f, -0.01065778f, 0.08494868f, 0.17567174f, -0.16577555f, -0.02824226f, 
    0.01529740f, 0.16322213f, -0.06567577f, -0.09675399f, -0.14407752f, 0.00479845f, -0.00877253f, 0.17144345f, 
    0.00894201f, -0.29961836f, -0.08164544f, 0.16268530f, 0.11078825f, -0.10163165f, -0.00775974f, -0.10948405f, 
    -0.00484970f, -0.04404888f, -0.20956939f, 0.04702352f, -0.28778452f, 0.20820919f, 0.17606680f, -0.15312311f, 
    0.06562977f, -0.02503572f, 0.17479981f, -0.31201938f, 0.05707350f, 0.08461788f, -0.06019892f, -0.06447325f, 
    -0.09539694f, -0.01480304f, 0.00813310f, 0.05648606f, -0.28789267f, -0.58367682f, -0.16497613f, -0.03687142f, 
    0.00635126f, -0.08217285f, 0.13522957f, -0.15076156f, 0.07307534f, -0.14216569f, 0.16538642f, -0.04009248f, 
    -0.29504797f, 0.04168711f, -0.27979553f, 0.17798693f, 0.05097932f, -0.00585647f, 0.05373776f, 0.09227175f, 
    0.17807837f, 0.06322392f, 0.03294094f, -0.18723959f, -0.06810285f, 0.03575549f, -0.02562928f, 0.20940118f, 
    0.22217205f, -0.00636314f, -0.11644666f, -0.13593224f, -0.15936613f, 0.04778490f, -0.02337867f, 0.26726255f, 
    -0.01356561f, -0.04215204f, -0.03272020f, -0.00096567f, 0.03702974f, 0.00504825f, -0.06321472f, -0.00570441f, 
    0.00858035f, -0.06854650f, -0.03552678f, -0.02000038f, -0.03213604f, -0.00663351f, -0.01191641f, -0.03598454f, 
    -0.01377931f, -0.00964467f, -0.04156931f, 0.05862814f, 0.00655693f, 0.04430065f, -0.06663761f, -0.03460310f, 
    0.04033399f, 0.00714673f, -0.04200064f, 0.01271831f, 0.02022255f, -0.01419770f, 0.03426357f, -0.05074272f, 
    0.02816212f, -0.06403194f, -0.01620081f, 0.01472123f, -0.00380393f, 0.00432268f, 0.00264515f, -0.01112394f, 
    -0.00550140f, -0.05711588f, 0.03686687f, 0.00143893f, -0.03579663f, 0.03818886f, -0.06016215f, -0.01876541f, 
    -0.02109875f, 0.03199405f, -0.02034273f, -0.04852135f, -0.00438990f, -0.01881057f, -0.03734957f, 0.00445793f, 
    -0.02772242f, -0.04350859f, 0.03026995f, -0.05306645f, 0.02836042f, -0.04957844f, 0.00897322f, -0.00757568f, 
    -0.00667122f, -0.02429707f, 0.05057197f, 0.01142503f, -0.03741072f, 0.02889223f, 0.02344920f, -0.02524802f, 
    -0.02567755f, -0.05781544f, -0.02086553f, -0.00194550f, -0.04887097f, -0.03032753f, -0.03607355f, 0.04167897f, 
    0.04672211f, -0.01397357f, 0.00815884f, -0.02655050f, 0.00894992f, -0.02474497f, -0.04635419f, 0.00071616f, 
    0.03872685f, -0.05866963f, -0.02383422f, -0.04253993f, -0.01677785f, 0.02461862f, -0.02616854f, -0.05261627f, 
    -0.06422275f, 0.04458190f, 0.04296675f, 0.00795258f, -0.05672773f, -0.01021138f, 0.02234769f, 0.01524438f, 
    0.00049262f, 0.01560888f, -0.03742588f, 0.04847167f, 0.01021648f, -0.03290128f, -0.02286053f, -0.05872101f, 
    -0.01087850f, 0.02263640f, -0.02068427f, -0.02707185f, -0.06556793f, -0.00777866f, -0.05476836f, -0.00850338f, 
    -0.04427882f, -0.05653363f, 0.00094743f, 0.01921058f, 0.00509085f, -0.05626255f, -0.01517731f, -0.06014081f, 
    0.02778710f, 0.00708424f, -0.00772105f, -0.00789432f, -0.00177918f, 0.02769352f, 0.00155002f, -0.05163690f, 
    0.04426771f, 0.01057004f, 0.02941124f, 0.02036886f, 0.05077659f, 0.05351544f, -0.02038641f, -0.03797308f, 
    -0.04810380f, 0.02749608f, -0.04338003f, -0.04169948f, 0.01895102f, -0.04491609f, -0.03210985f, 0.00946820f, 
    -0.05313723f, -0.00138836f, -0.03590202f, -0.05770256f, 0.01529425f, 0.00935399f, 0.00373749f, 0.00801906f, 
    0.04822415f, -0.05566686f, 0.05027011f, 0.03201469f, -0.01942141f, -0.02494455f, 0.03300852f, 0.03589146f, 
    -0.04220482f, -0.05823158f, 0.02061401f, 0.00312079f, 0.01553479f, -0.00923005f, 0.01264288f, 0.01421353f, 
    0.04103742f, -0.05645154f, 0.03536181f, -0.04018629f, 0.04613142f, 0.05502140f, -0.03694608f, 0.05138985f, 
    -0.00514052f, -0.06763425f, 0.04573035f, 0.01205365f, 0.03706181f, -0.05290351f, -0.04331876f, -0.02828506f, 
    -0.03525009f, -0.04793936f, -0.02896683f, 0.04269495f, 0.03533363f, 0.03468509f, -0.03433897f, -0.05660028f, 
    -0.05879157f, -0.00777459f, 0.04452433f, 0.01277207f, 0.04635277f, 0.00142355f, -0.03915004f, 0.02174692f, 
    0.03471743f, -0.01035952f, 0.03132136f, 0.01020055f, -0.05253715f, 0.03556650f, -0.03598793f, -0.03149763f, 
    -0.02738071f, -0.03491520f, -0.03118484f, 0.01902262f, 0.01012769f, -0.00478137f, 0.00203698f, -0.05337613f, 
    0.02482853f, -0.04215447f, -0.01645060f, 0.00870814f, -0.01826949f, 0.01893505f, 0.00476499f, 0.02778836f, 
    -0.02414803f, -0.05004647f, -0.04266324f, 0.03578837f, -0.05493081f, 0.01139589f, 0.05091882f, 0.03806788f, 
    -0.01116365f, 0.00214152f, -0.01875339f, -0.04183846f, 0.01967469f, 0.00989849f, 0.05325832f, -0.04337286f, 
    -0.00933160f, 0.03389953f, -0.00670474f, 0.01978754f, -0.02086846f, -0.04482204f, -0.03089784f, -0.01539922f, 
    -0.01973442f, -0.05530542f, 0.01503872f, -0.02330487f, 0.04448700f, 0.00150173f, -0.00254494f, -0.05817631f, 
    -0.03718206f, 0.01460898f, 0.01362981f, -0.01790653f, -0.02227398f, -0.01922522f, 0.00857001f, 0.01429365f, 
    -0.04417009f, 0.00730571f, 0.03906244f, 0.06023538f, -0.00473955f, 0.04378315f, 0.03830161f, -0.03172309f, 
    0.00265210f, -0.04000747f, 0.00875335f, -0.03157331f, 0.04739918f, -0.04597643f, 0.02599707f, -0.06162256f, 
    0.00456463f, 0.00038954f, -0.01632995f, -0.05969293f, -0.04905426f, -0.01226636f, -0.01530250f, 0.00750934f, 
    0.00191618f, 0.04002034f, 0.03868638f, -0.00871603f, -0.01878941f, -0.03636646f, 0.05048114f, 0.04972612f, 
    0.00896932f, 0.04422176f, 0.03440229f, -0.05306050f, 0.00136907f, 0.04984706f, 0.00298833f, -0.05271733f, 
    -0.01770145f, -0.03204360f, -0.04995792f, 0.00592255f, 0.01366710f, -0.01895052f, -0.04768437f, -0.02993829f, 
    -0.03514897f, -0.02273152f, 0.01401632f, 0.04404642f, 0.01149787f, -0.06003783f, -0.03398755f, 0.00811735f, 
    -0.03764090f, 0.04896919f, 0.01250005f, -0.03454830f, -0.01181650f, -0.02552420f, 0.03157628f, -0.03503069f, 
    -0.01146372f, -0.03858555f, -0.03128948f, 0.04903274f, -0.04163748f, -0.05969424f, 0.03066865f, 0.01653335f, 
    0.00629654f, 0.00604961f, -0.00273616f, -0.04150711f, -0.03169156f, -0.02565772f, -0.06370243f, 0.00587632f, 
    -0.04644470f, -0.00759331f, 0.03632362f, -0.02518237f, 0.00045080f, -0.01506451f, 0.00827284f, -0.00748978f, 
    -0.05392358f, -0.00764537f, -0.00414644f, -0.05866606f, -0.04672327f, -0.01807966f, -0.00585098f, 0.01382314f, 
    -0.02908172f, -0.04587105f, -0.00034429f, -0.00877125f, -0.03123000f, 0.01722952f, 0.04765317f, 0.00487927f, 
    0.03282802f, 0.01867208f, -0.02215798f, 0.03418846f, -0.02984376f, -0.05497290f, -0.04414805f, -0.05527154f, 
    0.01163968f, -0.03701023f, 0.00162797f, -0.02497911f, -0.05559691f, 0.04214342f, -0.02605647f, 0.00821673f, 
    -0.01816676f, -0.02441440f, 0.01087493f, -0.00681605f, -0.01760058f, 0.04326166f, -0.02149620f, 0.01730786f, 
    -0.03645600f, 0.04368791f, 0.02567900f, -0.00266162f, -0.04452385f, -0.01771565f, -0.00292817f, 0.04228935f, 
    0.04415174f, -0.04858767f, -0.01780662f, 0.03747520f, -0.01315393f, 0.03040597f, 0.00965218f, 0.04518810f, 
    -0.00272600f, -0.05378999f, 0.04397748f, -0.04017169f, -0.00063596f, -0.05748317f, -0.01970286f, -0.03098493f, 
    0.04651076f, 0.04927895f, -0.00119320f, -0.05314974f, -0.05195488f, -0.02700945f, -0.05678120f, -0.01327563f, 
    -0.01265020f, -0.05472328f, -0.01940564f, -0.01364739f, -0.03643537f, 0.00991382f, -0.01966535f, -0.00844969f, 
    -0.01126956f, 0.01812565f, -0.02683280f, -0.05356618f, -0.00081935f, 0.02565644f, -0.02445325f, -0.04841174f, 
    -0.04131048f, -0.02341338f, -0.02537595f, -0.00016837f, -0.03798474f, 0.01329161f, -0.06315127f, 0.00992226f, 
    -0.00221140f, 0.02037787f, -0.03269543f, 0.02121310f, -0.05253657f, -0.00020914f, 0.03610005f, -0.06418119f, 
    0.00517618f, 0.01568826f, 0.00460608f, -0.02645713f, 0.00527375f, 0.04417290f, -0.05046848f, 0.02231005f, 
    -0.03722528f, 0.05056320f, -0.01637371f, -0.03239470f, 0.04790624f, -0.06409766f, -0.01300137f, -0.06711040f, 
    -0.04907570f, -0.04039775f, -0.01980649f, -0.00979935f, -0.02698536f, -0.00378241f, -0.04922083f, -0.02397236f, 
    -0.03528348f, 0.00323095f, -0.04936948f, -0.00514523f, 0.03929859f, -0.06311274f, 0.01898681f, 0.04013678f, 
    0.03765365f, -0.00290578f, -0.02244534f, 0.04193080f, 0.02383025f, 0.00499712f, -0.02501007f, 0.01174033f, 
    -0.05938644f, -0.00634022f, -0.02102211f, -0.06077785f, 0.04662036f, 0.04178562f, 0.01554573f, -0.00350737f, 
    -0.04787491f, -0.06475857f, 0.03602659f, 0.00012182f, -0.01847039f, 0.04573029f, -0.04695495f, 0.01743124f, 
    -0.00642786f, 0.02369305f, -0.05511487f, -0.04079338f, -0.02881122f, -0.02492986f, 0.02048402f, 0.01280425f, 
    0.03228093f, 0.04132149f, 0.01527193f, -0.03514347f, 0.00804987f, -0.02681296f, 0.00255342f, -0.03805058f, 
    0.02689435f, 0.00538186f, 0.01968945f, -0.01519789f, -0.02954510f, -0.01781032f, -0.02516637f, -0.04319067f, 
    -0.03450274f, -0.06551538f, -0.04439231f, -0.04157879f, 0.03553148f, -0.03373199f, 0.05321722f, 0.01730393f, 
    0.01758171f, 0.04057746f, -0.00901290f, 0.04126926f, -0.02790676f, 0.03070951f, 0.04356814f, -0.03079718f, 
    -0.01636142f, -0.01190361f, 0.04402553f, 0.02065472f, 0.02625706f, -0.01589232f, -0.04355380f, 0.02547176f, 
    0.04554136f, 0.02654086f, -0.03363031f, -0.05878239f, 0.01563372f, 0.03983438f, -0.01097676f, 0.00241653f, 
    0.18893777f, -0.22575580f, 0.14409301f, 0.08126288f, 0.28502396f, 0.03596847f, -0.37396136f, 0.11397167f, 
    0.15272504f, 0.03964223f, 0.18899022f, -0.06424633f, 0.04309838f, -0.24551919f, -0.05575271f, -0.05264428f, 
    -0.01402106f, -0.40081108f, 0.25432780f, -0.05040323f, 0.06026372f, 0.16887067f, 0.11957040f, -0.20708413f, 
    0.21194573f, -0.07786522f, 0.02016566f, -0.08719523f, -0.08342896f, 0.27362505f, 0.16667737f, -0.12451547f, 
    -0.13420297f, -0.34576002f, -0.14286266f, -0.03395502f, 0.25219661f, -0.10229465f, -0.00240521f, -0.28122523f, 
    0.08643917f, 0.13053715f, 0.05070974f, 0.09135089f, -0.10180289f, -0.19190104f, -0.02042678f, -0.19053794f, 
    0.09942763f, 0.18344238f, 0.16151881f, 0.09187805f, -0.00119457f, 0.16063707f, -0.23398098f, 0.21215017f, 
    -0.11455604f, 0.32314891f, 0.17642328f, -0.02540699f, -0.16799520f, 0.06415930f, -0.13042110f, 0.22261058f, 
    0.23606813f, 0.04214597f, -0.03667529f, 0.07857439f, -0.06161593f, -0.00012862f, 0.02018373f, -0.03486211f, 
    -0.05716525f, 0.11263092f, -0.09889023f, -0.08269154f, -0.12229411f, -0.04718830f, -0.09221454f, -0.03337246f, 
    -0.34440622f, 0.03426842f, -0.10579664f, -0.08169556f, -0.01670589f, 0.08093093f, 0.02359233f, -0.09828879f, 
    -0.17385261f, -0.27904609f, 0.03302613f, -0.07234000f, -0.05085196f, -0.10685841f, -0.11479365f, 0.01336303f, 
    -0.06837233f, -0.06099464f, 0.00574244f, -0.04372304f, -0.02694711f, -0.04974856f, 0.04355948f, 0.14453536f, 
    -0.24923043f, -0.28809136f, -0.09499783f, -0.07609723f, 0.32260764f, 0.01060613f, 0.12779149f, 0.07430285f, 
    -0.03981000f, 0.17481905f, -0.11429333f, -0.22060595f, -0.09744453f, 0.04262093f, 0.14205731f, -0.07026671f, 
    0.14753936f, 0.08408552f, 0.09049556f, -0.17386499f, 0.05769902f, 0.20251125f, -0.13314734f, -0.02710697f, 
    0.01928520f, 0.21659027f, 0.06274086f, 0.06244168f, -0.10062915f, -0.07952111f, -0.01761628f, 0.37586069f, 
    -0.11491345f, -0.15958253f, 0.12881748f, -0.08080389f, 0.14742103f, 0.01852851f, -0.01807644f, 0.00523971f, 
    -0.00624754f, -0.09494500f, -0.00157395f, 0.02811360f, -0.14349599f, 0.09130259f, -0.05503633f, 0.08059564f, 
    0.03044843f, -0.08834758f, -0.02310891f, 0.44031140f, 0.13038649f, 0.11558501f, 0.36311060f, -0.03197080f, 
    -0.21458542f, -0.11983421f, -0.10633334f, 0.16411054f, -0.14464942f, 0.18324371f, 0.18381977f, 0.09347332f, 
    0.03986144f, -0.00236484f, 0.04079036f, -0.02693984f, 0.08555049f, 0.02088648f, -0.18534735f, 0.17370300f, 
    -0.03828788f, 0.11208842f, -0.02549290f, 0.11582768f, -0.04244294f, -0.38995409f, 0.09431056f, 0.07685504f, 
    0.16893952f, -0.06268244f, 0.03042800f, -0.18808725f, -0.42666242f, 0.05846669f, 0.14352570f, 0.03418054f, 
    -0.02526278f, 0.01491839f, 0.05578899f, -0.12168988f, 0.11711614f, 0.09992351f, -0.00216135f, 0.02323487f, 
    0.00345839f, 0.06664796f, 0.02472413f, -0.02080749f, 0.01004922f, 0.10067933f, -0.12246976f, -0.04161670f, 
    -0.00855473f, -0.13024333f, 0.04285393f, 0.19165596f, 0.17206959f, -0.09249008f, 0.14126725f, -0.03330928f, 
    -0.08668789f, 0.31326708f, 0.30843654f, -0.14090490f, 0.04501616f, -0.07491127f, 0.06579938f, 0.05455136f, 
    -0.02766366f, 0.00745762f, 0.12100497f, -0.06320904f, 0.02633693f, 0.13120738f, 0.09501003f, 0.08747422f, 
    -0.02476901f, 0.24442036f, 0.15579884f, -0.11467252f, 0.32626060f, -0.11702666f, 0.04053511f, 0.01084560f, 
    -0.00013491f, -0.28198320f, -0.47314069f, -0.09205749f, 0.28460199f, -0.14621149f, -0.05380139f, 0.05851227f, 
    -0.28645349f, -0.04802474f, 0.07971292f, 0.18917067f, -0.15508047f, 0.05831338f, -0.00538914f, -0.03806529f, 
    0.17627229f, -0.15829329f, -0.04620275f, -0.13393275f, -0.05121600f, 0.09651759f, -0.10433540f, -0.22830483f, 
    -0.31735265f, 0.13367315f, 0.03758528f, 0.13386610f, -0.18610798f, 0.00196566f, 0.16063251f, 0.13181739f, 
    0.23664063f, 0.03292742f, -0.09768999f, -0.08250744f, 0.29112664f, -0.04392201f, -0.07748985f, 0.12289807f, 
    -0.11269025f, 0.15122171f, 0.08737460f, 0.06979017f, 0.07620879f, 0.17734195f, -0.11932621f, -0.28470325f, 
    0.06500975f, 0.18087107f, -0.42003033f, 0.10144456f, -0.09672158f, 0.24927573f, -0.14743885f, 0.08049444f, 
    0.18249850f, -0.00647902f, 0.00731084f, 0.14452852f, 0.01421585f, 0.27686399f, 0.09501844f, -0.00483817f, 
    -0.14493352f, -0.19389796f, 0.21522841f, 0.06617680f, -0.15395385f, -0.16625336f, -0.03264854f, 0.00472781f, 
    0.07997048f, 0.08490954f, -0.26313505f, 0.11160511f, -0.12804417f, -0.01395145f, -0.08151197f, 0.04696324f, 
    0.04457273f, 0.02065736f, -0.21692008f, -0.03018196f, -0.04920160f, -0.21410385f, -0.00338210f, 0.07535976f, 
    0.02191963f, 0.06193547f, 0.12643452f, -0.09689937f, -0.01379263f, 0.05553606f, 0.08448078f, -0.28326407f, 
    -0.16484717f, 0.06706634f, -0.01658983f, 0.20919611f, 0.14610898f, 0.09263407f, -0.46306926f, -0.04439467f, 
    0.01370752f, 0.09973888f, 0.23975056f, 0.14747724f, -0.01852626f, -0.00307348f, 0.04540167f, -0.12772086f, 
    0.13329537f, 0.24458164f, -0.00498222f, 0.30314210f, 0.09385546f, 0.21165727f, 0.02055211f, 0.10733690f, 
    -0.07282462f, 0.26912430f, 0.10590702f, 0.05613820f, 0.06921118f, 0.02234904f, -0.10353212f, -0.14908499f, 
    -0.05201545f, 0.01027772f, 0.22346675f, 0.06785487f, -0.29858023f, 0.13566440f, -0.02330130f, 0.09746110f, 
    -0.09104694f, -0.25260484f, -0.00000090f, 0.15423928f, 0.22202265f, -0.18081625f, 0.04593348f, 0.03565647f, 
    -0.06372193f, 0.02602815f, -0.00555521f, -0.18183529f, 0.26600918f, 0.30184260f, -0.04740781f, 0.25850269f, 
    -0.04642413f, -0.07408181f, 0.02144561f, -0.16114588f, 0.01518394f, -0.02584415f, -0.42614588f, 0.04975803f, 
    0.09703061f, 0.16952795f, -0.05194816f, 0.03515758f, -0.11180305f, 0.19973604f, -0.03336935f, -0.08693822f, 
    -0.06176788f, 0.08855235f, -0.01685939f, 0.10164414f, -0.08355422f, 0.16641182f, 0.25096634f, -0.04097028f, 
    -0.08796088f, 0.12624273f, -0.01248874f, 0.19149181f, -0.00137981f, -0.00286978f, -0.06853712f, -0.11598743f, 
    -0.07746156f, -0.10526785f, -0.13838030f, -0.04495345f, -0.24354847f, -0.12155558f, -0.15556794f, 0.26227686f, 
    0.02225570f, 0.12637854f, -0.11435174f, -0.21132791f, 0.08260498f, 0.06228171f, -0.07763747f, 0.03566575f, 
    0.09112065f, -0.09030098f, 0.08928985f, -0.15399671f, 0.05287305f, 0.04949602f, 0.27983361f, -0.06114207f, 
    -0.07314251f, -0.00378416f, -0.38831428f, -0.32608077f, -0.20401043f, 0.19254321f, -0.06589530f, -0.03006400f, 
    0.02183539f, 0.00229445f, -0.04143563f, -0.02170916f, 0.00467957f, -0.14552622f, -0.06157299f, 0.04907922f, 
    0.04458724f, 0.10400788f, 0.04805493f, -0.02343340f, 0.13062012f, -0.18186638f, 0.29166615f, 0.10064587f, 
    -0.18798658f, 0.12500301f, 0.13704972f, -0.00192378f, 0.02024082f, 0.36765757f, 0.09718971f, -0.02380421f, 
    -0.03702544f, -0.11056153f, -0.05232604f, -0.14049312f, 0.08667136f, 0.09164894f, 0.16532290f, 0.14638044f, 
    -0.16793978f, 0.03084631f, 0.09061182f, -0.22005996f, -0.10378902f, 0.15970926f, 0.22129251f, -0.20966035f, 
    -0.46256486f, -0.29446989f, 0.17544203f, 0.13778378f, 0.00911819f, 0.03670165f, -0.02246110f, 0.00194192f, 
    0.06916120f, 0.05035388f, 0.22761424f, -0.42733461f, 0.07836692f, -0.00900422f, 0.09334818f, -0.13005129f, 
    -0.10855632f, 0.05866995f, 0.08981953f, 0.02828979f, -0.00893464f, -0.11093707f, -0.14250429f, -0.14250863f, 
    0.16724962f, 0.20750076f, 0.15199715f, 0.13214171f, 0.10475850f, -0.01817511f, -0.01275988f, 0.10770895f, 
    0.10608699f, -0.12635376f, -0.07665488f, 0.12854356f, 0.01642128f, 0.09189208f, -0.21739365f, -0.07290903f, 
    -0.06629355f, 0.03655887f, 0.03841656f, -0.14110790f, 0.14930387f, 0.00117761f, -0.05453061f, 0.10496251f, 
    -0.16586812f, 0.16552350f, 0.09391915f, -0.13636012f, 0.04125650f, 0.12197468f, 0.18761742f, 0.33835360f, 
    0.05551241f, 0.07965951f, 0.12551516f, 0.11371500f, 0.20452033f, -0.07866146f, -0.00948914f, -0.12781918f, 
    0.30519956f, -0.08870252f, -0.00603458f, -0.15015082f, -0.10493433f, -0.09967937f, -0.01110329f, -0.11217839f, 
    -0.15258235f, 0.29777730f, 0.03263784f, -0.09179053f, 0.08426296f, 0.06594084f, -0.05648563f, -0.06553532f, 
    -0.05207528f, -0.03627333f, -0.03282292f, -0.00070873f, 0.01951978f, 0.03492152f, -0.00945468f, -0.04252909f, 
    -0.05006866f, 0.01304338f, -0.03741582f, -0.05799955f, 0.01107114f, 0.03144486f, -0.04901127f, 0.00977107f, 
    -0.04314958f, -0.05619030f, -0.05735838f, -0.03733251f, 0.04407293f, 0.05193940f, 0.00152357f, 0.00616316f, 
    0.05254013f, -0.06200703f, -0.04537726f, 0.00799135f, 0.01093576f, -0.01622120f, 0.03812457f, -0.06758251f, 
    0.03024544f, -0.03028690f, -0.05178121f, -0.00779661f, 0.02909447f, 0.00495950f, 0.01335980f, -0.02188593f, 
    0.00983398f, 0.00148738f, -0.04566222f, -0.06597289f, -0.01041835f, 0.02975475f, 0.04385402f, 0.00822588f, 
    -0.00614617f, 0.04941872f, 0.02409524f, 0.00121791f, -0.01670219f, 0.02438049f, -0.01642927f, -0.03833878f, 
    0.04610873f, 0.02708379f, -0.04000821f, -0.00443207f, -0.03812457f, -0.00178011f, -0.02172730f, -0.01268594f, 
    0.04230136f, -0.02620766f, -0.01048845f, -0.02640446f, -0.05986665f, 0.04855219f, -0.02269026f, -0.05950805f, 
    0.04760544f, -0.00746279f, -0.04065677f, -0.06386808f, 0.01288392f, 0.01909406f, -0.04234697f, 0.03618750f, 
    0.04572890f, -0.03258031f, -0.00439036f, 0.04907224f, -0.00700943f, -0.03176505f, 0.00251709f, -0.04018321f, 
    0.01047667f, -0.03012716f, 0.01810610f, 0.04933165f, -0.05925458f, 0.04820891f, -0.05963060f, -0.01942032f, 
    -0.02543859f, 0.01855165f, -0.03370531f, -0.00857044f, 0.01901216f, 0.02314816f, -0.04822499f, -0.00456382f, 
    -0.05112030f, 0.04937582f, 0.01866100f, -0.06095879f, 0.01031437f, -0.02219728f, 0.01174608f, 0.01343248f, 
    0.05424265f, 0.03362755f, -0.02352687f, 0.00566384f, -0.06087074f, -0.03371194f, 0.04336998f, -0.04742611f, 
    0.03202301f, 0.00853165f, -0.01990325f, -0.00009387f, 0.03841204f, 0.03447486f, -0.04603916f, -0.01963183f, 
    0.03276539f, 0.02134866f, -0.04683760f, -0.04581829f, -0.00628916f, 0.04332291f, -0.01064705f, -0.05113328f, 
    0.02671137f, 0.04892245f, 0.00302432f, 0.01567757f, -0.05186233f, 0.02959754f, -0.03330795f, -0.02940414f, 
    0.02402226f, 0.01678806f, -0.02114684f, 0.03496182f, 0.01827150f, 0.05174233f, 0.00592882f, 0.05098657f, 
    -0.01380437f, 0.03605824f, 0.01531067f, 0.01572019f, -0.00777408f, 0.03432971f, 0.03156311f, -0.02772548f, 
    0.01779735f, 0.05550044f, -0.03507134f, -0.02746855f, -0.04211593f, -0.05514819f, -0.05211190f, -0.03489036f, 
    -0.01905894f, -0.02879266f, -0.02230491f, 0.03086617f, 0.00202288f, -0.05766819f, 0.02795147f, -0.06273820f, 
    -0.03906538f, -0.04010987f, -0.03719525f, -0.01255775f, -0.00787396f, -0.05939150f, 0.03624336f, -0.02574911f, 
    0.02040015f, 0.01655808f, -0.05715333f, 0.00983461f, 0.04354608f, -0.02830406f, -0.00494739f, 0.03318497f, 
    0.02703849f, 0.02356421f, -0.05006815f, 0.06059203f, -0.05679864f, -0.03509702f, -0.04151126f, -0.00344367f, 
    -0.03041852f, -0.02767205f, -0.01417965f, -0.00311585f, 0.04617629f, -0.06824856f, -0.02449114f, -0.01404564f, 
    -0.01667714f, 0.04000890f, -0.02602073f, -0.04577499f, -0.05932020f, -0.02229788f, 0.03713430f, -0.03705897f, 
    0.01111096f, 0.00000256f, 0.02515060f, 0.02203340f, 0.02958445f, 0.00150115f, 0.00984526f, -0.05922679f, 
    -0.02138860f, 0.04369008f, 0.00787724f, 0.02675097f, 0.04482571f, 0.05080515f, -0.05844947f, 0.00834088f, 
    0.03993579f, -0.06304698f, -0.05226979f, -0.03255082f, 0.02317362f, -0.05209157f, -0.05518392f, 0.02435342f, 
    -0.06464418f, -0.05553996f, -0.00794482f, 0.00291386f, -0.03801749f, 0.02907237f, -0.02866634f, -0.04911868f, 
    -0.04054838f, 0.03362647f, 0.03456211f, 0.02237063f, -0.03220963f, -0.06361338f, -0.03161438f, -0.04425269f, 
    -0.00799919f, -0.05652451f, 0.03525349f, 0.03019048f, -0.01656738f, -0.04170269f, -0.06275108f, 0.03767560f, 
    -0.04232384f, 0.04785543f, -0.00083953f, 0.01989385f, 0.01628689f, 0.00433394f, -0.01972322f, 0.05077904f, 
    -0.04152032f, -0.04134848f, -0.02130467f, 0.01939117f, -0.00018830f, -0.03581008f, -0.02146151f, -0.04085850f, 
    -0.04321952f, 0.03288150f, 0.00441412f, -0.05481771f, -0.00582481f, -0.03846872f, -0.06402744f, -0.01385805f, 
    -0.19651753f, 0.23273139f, 0.20463425f, -0.06940661f, 0.01168207f, -0.10132018f, -0.06941294f, 0.15922070f, 
    0.16753685f, 0.23648687f, 0.14664418f, 0.07170741f, -0.04572978f, 0.06385305f, 0.12115311f, -0.11926710f, 
    -0.00448106f, -0.03227192f, -0.40581650f, -0.07213762f, 0.07681783f, 0.09120240f, -0.05918836f, -0.12803945f, 
    0.08322996f, -0.11125842f, -0.03622082f, 0.09205837f, -0.18784784f, 0.17149906f, 0.10680205f, 0.12069660f, 
    0.01684476f, -0.20249474f, 0.10007838f, -0.10559054f, 0.20947452f, -0.00580644f, -0.05836770f, 0.06755048f, 
    -0.10777022f, -0.03624656f, -0.06760637f, 0.01555737f, 0.20282634f, 0.05537804f, -0.19634564f, 0.30970758f, 
    0.11800507f, 0.08654902f, 0.04794173f, 0.11768510f, 0.05011602f, 0.00126378f, -0.00914770f, -0.00011147f, 
    0.39751056f, 0.06760208f, -0.00606671f, -0.17170906f, -0.11120167f, 0.07527995f, 0.04568709f, -0.49688476f, 
    -0.20212983f, -0.01609840f, 0.22033252f, 0.13340418f, 0.05780474f, -0.02158244f, -0.07056370f, 0.09188530f, 
    0.24737321f, -0.07486447f, -0.13641705f, 0.01555936f, -0.10077486f, 0.01691810f, 0.16518639f, 0.12875384f, 
    -0.08365672f, 0.00139859f, -0.08672734f, 0.10725912f, 0.02578325f, 0.14612399f, -0.03891074f, 0.12093975f, 
    0.06017464f, -0.12182413f, 0.01213634f, -0.14519612f, -0.09978409f, 0.06422257f, 0.06726602f, 0.09883412f, 
    0.15975820f, -0.05307582f, -0.06828721f, 0.12413397f, -0.04748465f, 0.11630831f, 0.15978794f, -0.10402803f, 
    0.11231169f, 0.10857331f, -0.01896871f, -0.22959504f, 0.45136887f, 0.13607965f, 0.34446588f, -0.16719872f, 
    -0.20133257f, 0.05981093f, -0.02393165f, 0.10030019f, -0.08304531f, -0.02938993f, -0.20919146f, -0.14544988f, 
    -0.19315735f, -0.06029842f, 0.18765901f, -0.15024607f, 0.01048731f, 0.21774313f, 0.08967759f, -0.21967144f, 
    0.12428401f, 0.05022521f, -0.03630266f, -0.04175193f, 0.09313359f, -0.10915145f, -0.04549888f, 0.02574656f, 
    0.02195435f, -0.34383154f, 0.09764891f, 0.01182619f, 0.12575081f, -0.00988016f, 0.37671134f, 0.01803176f, 
    -0.27150333f, -0.31410873f, -0.10894628f, 0.27238303f, -0.07852323f, -0.15245807f, 0.15855260f, -0.16274546f, 
    0.04389658f, -0.10796239f, 0.04928644f, 0.07825501f, -0.04088111f, 0.02970541f, -0.05687950f, 0.03196121f, 
    -0.05475255f, 0.00986000f, 0.27309251f, -0.26962847f, 0.40863791f, 0.04119103f, -0.18882212f, -0.06840472f, 
    -0.11423632f, -0.02785247f, -0.06893239f, -0.42048118f, -0.05406963f, -0.60279685f, 0.27767619f, 0.10130472f, 
    -0.09623165f, -0.00727849f, -0.08428221f, -0.02834713f, 0.40001538f, -0.05899757f, 0.12031842f, -0.06617258f, 
    -0.04653178f, 0.02770480f, 0.09714018f, 0.06005830f, 0.02767839f, 0.01862442f, -0.10237332f, -0.13673022f, 
    0.04728315f, 0.00153279f, -0.02784754f, 0.11594480f, -0.07580277f, -0.00588059f, 0.06867768f, 0.07149098f, 
    -0.27412236f, -0.09355219f, -0.01489907f, -0.11021103f, 0.09537402f, -0.21738595f, 0.01863471f, 0.28322104f, 
    -0.15068163f, 0.34732386f, 0.07639182f, -0.09776095f, -0.01858647f, -0.09295787f, -0.00083451f, -0.04047046f, 
    0.21515903f, 0.18509631f, -0.10364147f, 0.13210683f, -0.03115175f, -0.13564561f, -0.22746438f, -0.14329572f, 
    0.07387700f, -0.04966756f, 0.15968856f, -0.48808664f, 0.19710313f, 0.04900865f, -0.17826687f, 0.06268968f, 
    0.07119291f, -0.11440527f, 0.11086208f, 0.01832012f, -0.07871122f, -0.10782459f, -0.13746566f, 0.12427574f, 
    0.00185353f, 0.22476317f, -0.07994987f, 0.07955486f, 0.07931477f, -0.44213772f, 0.09410902f, -0.03723201f, 
    -0.07988390f, 0.03943413f, -0.14699486f, -0.01342943f, 0.00725037f, 0.07612951f, 0.19868550f, -0.03834277f, 
    0.17732684f, 0.06110818f, -0.20443572f, -0.00179449f, -0.08620968f, 0.21099934f, -0.18669641f, -0.14990132f, 
    -0.11284620f, -0.04838330f, -0.08622210f, -0.01876533f, 0.01687828f, -0.00667031f, 0.19110505f, 0.11838496f, 
    0.07308686f, 0.13587822f, -0.00970979f, -0.07014294f, -0.03647904f, -0.00351029f, 0.14405249f, 0.33360460f, 
    0.02940428f, 0.23743752f, -0.17946823f, 0.01988255f, 0.08044209f, -0.17888550f, 0.07291725f, -0.15915053f, 
    0.25592825f, -0.08497471f, -0.13303602f, -0.12720735f, -0.07069176f, -0.23497355f, -0.03958203f, -0.00479664f, 
    -0.00575379f, -0.15490575f, -0.00121235f, -0.05664140f, 0.03008270f, -0.24733059f, 0.05358310f, -0.07852973f, 
    0.10030913f, 0.11721633f, 0.47409189f, 0.24456325f, -0.28695908f, -0.24794658f, 0.04610956f, 0.16916211f, 
    -0.21773247f, -0.06392905f, -0.10513397f, -0.09286594f, 0.21835005f, 0.01962238f, 0.13989469f, -0.03806134f, 
    0.08152677f, 0.02486698f, 0.01448663f, 0.23423046f, 0.05635408f, 0.00431282f, -0.10588259f, 0.05597406f, 
    0.14170404f, 0.04280776f, 0.02817491f, -0.20618309f, 0.17601103f, -0.05347552f, 0.07933792f, -0.04423378f, 
    -0.07629662f, 0.21916372f, -0.12990162f, -0.05897706f, 0.13418002f, -0.01418384f, 0.31974691f, -0.05123528f, 
    -0.11105292f, -0.35101047f, 0.03209282f, -0.18675815f, 0.03409673f, 0.12160885f, -0.08838776f, -0.03720644f, 
    -0.07797895f, -0.27812731f, 0.15827392f, 0.23287159f, 0.09778789f, -0.38956112f, -0.23128872f, 0.06964152f, 
    -0.12146699f, 0.10657670f, 0.00480122f, 0.22833937f, 0.05534370f, 0.06602706f, -0.14080638f, -0.08015533f, 
    0.09621787f, -0.24812414f, 0.13708046f, -0.12459791f, 0.23304382f, 0.08647939f, 0.20208475f, 0.06755366f, 
    0.05439831f, 0.22561221f, -0.13823031f, 0.00324474f, -0.11289835f, 0.04855695f, 0.11179695f, 0.26267546f, 
    -0.16387475f, 0.23162337f, -0.08546486f, -0.14867525f, 0.30973700f, -0.01539161f, 0.02879811f, 0.07013611f, 
    -0.04876038f, 0.20851101f, 0.12502173f, 0.23661450f, -0.24437672f, 0.03107891f, -0.00023600f, -0.14253530f, 
    -0.04314680f, 0.02976004f, -0.07963970f, 0.04983466f, -0.13842976f, -0.26603252f, -0.02954408f, 0.01916139f, 
    0.13604972f, -0.03789965f, 0.00928604f, -0.01376253f, -0.09301738f, 0.03029984f, 0.12017938f, -0.04316413f, 
    -0.10336382f, -0.05580100f, -0.12843381f, -0.06951578f, 0.01502225f, -0.08693863f, 0.00780356f, -0.59839243f, 
    -0.03053237f, -0.09251499f, 0.07632805f, 0.04740503f, 0.09098861f, -0.13367966f, -0.02010915f, 0.16809085f, 
    0.06861339f, -0.22778143f, -0.19411953f, -0.05621581f, -0.13537312f, 0.04260098f, 0.10779794f, -0.07126488f, 
    -0.18170369f, 0.21933635f, 0.19524570f, 0.06964245f, -0.10395725f, 0.08297855f, -0.12095744f, 0.08166981f, 
    -0.02162432f, 0.03965659f, -0.02628034f, 0.19132529f, 0.09119170f, 0.05866480f, -0.10255199f, -0.02246844f, 
    0.05399324f, -0.05366232f, -0.02106027f, 0.26500973f, -0.09969515f, -0.07149270f, 0.19194752f, -0.04795022f, 
    0.21507350f, -0.03639853f, -0.03697110f, -0.02095449f, 0.35487118f, -0.11630657f, -0.33389246f, 0.15246435f, 
    -0.06273488f, -0.05527779f, -0.04387701f, -0.01526207f, 0.13104373f, 0.07895052f, -0.04841012f, -0.07005233f, 
    -0.16389064f, 0.02199871f, 0.20440488f, -0.03339515f, -0.02231359f, -0.08036115f, 0.09802505f, -0.04243728f, 
    -0.18558139f, 0.01018436f, 0.15568864f, -0.02291240f, 0.01033205f, -0.01148529f, 0.08407378f, 0.07703135f, 
    0.22691251f, -0.03159373f, -0.16586839f, -0.11501516f, 0.02286657f, 0.03345872f, -0.00215805f, -0.07493653f, 
    0.00120308f, -0.24448374f, -0.05436293f, -0.04165960f, -0.00527868f, 0.10532629f, 0.07246798f, 0.09677346f, 
    0.15896703f, 0.11195171f, -0.02534313f, -0.11082599f, 0.07972221f, -0.13657212f, 0.27504176f, 0.00102555f, 
    0.03836725f, -0.11120591f, 0.02454376f, -0.11302172f, -0.23829241f, 0.02818215f, 0.00423108f, -0.08401606f, 
    0.18681076f, -0.22947527f, -0.00490290f, 0.18291813f, 0.02202893f, 0.03822927f, -0.03791366f, -0.15879050f, 
    0.17896362f, 0.15514341f, 0.07719852f, 0.00187095f, 0.39990002f, 0.06976478f, -0.01339675f, 0.06689293f, 
    -0.03398233f, -0.06307641f, 0.13450828f, 0.08752669f, -0.15777124f, 0.10259724f, -0.04561090f, 0.07476832f, 
    0.20681536f, 0.05098158f, -0.01853607f, 0.18887576f, -0.21790309f, -0.04171191f, 0.21747391f, -0.11725456f, 
    -0.15745161f, -0.21557984f, -0.28497407f, 0.00180954f, -0.06263398f, 0.00747422f, 0.13551654f, 0.14117259f, 
    -0.22580034f, -0.26557007f, 0.02621190f, -0.11644412f, 0.09581932f, -0.01122398f, 0.01691013f, 0.06503732f, 
    0.17874752f, 0.59590840f, 0.02052416f, 0.26547146f, 0.12959662f, -0.13671924f, 0.21255453f, -0.02449124f, 
    -0.15033062f, -0.07810160f, 0.01298622f, -0.00302098f, -0.19661877f, -0.11891600f, -0.01147050f, 0.01671176f, 
    0.08266771f, 0.23242529f, -0.48623490f, 0.20262906f, 0.08932507f, -0.17302120f, -0.19766861f, -0.25041509f, 
    -0.23775683f, -0.03841551f, 0.15537016f, -0.02643871f, -0.00738739f, -0.20130722f, -0.23844583f, -0.12034177f, 
    0.01917184f, 0.13184555f, 0.04609160f, -0.17622198f, -0.11127833f, 0.19082321f, 0.15880704f, 0.05289321f, 
    -0.16359462f, -0.09833409f, -0.07384791f, -0.03094012f, 0.01357233f, 0.10316420f, 0.49801978f, 0.00298999f, 
    0.04676692f, 0.02925567f, 0.13399436f, 0.10532706f, 0.07430308f, -0.00615746f, -0.07201651f, 0.55676711f, 
    -0.05635392f, -0.08398566f, 0.03067572f, -0.02945858f, 0.00471003f, 0.14664289f, -0.01057960f, -0.20679072f, 
    -0.49933329f, 0.07934897f, -0.12447164f, 0.06099038f, -0.05729375f, -0.08988401f, -0.10832541f, 0.19302182f, 
    0.11158553f, -0.36227742f, -0.09940891f, -0.18864478f, -0.02249125f, 0.23207453f, -0.09102113f, -0.21744278f, 
    -0.05275312f, 0.32624310f, -0.20069169f, -0.22805727f, 0.04812477f, -0.01045668f, 0.22645955f, 0.15426147f, 
    -0.07584377f, 0.01826386f, -0.26606354f, -0.29979238f, 0.11035262f, 0.00351535f, 0.01618219f, 0.16586311f, 
    -0.13038403f, -0.27426815f, 0.07108641f, -0.36932197f, -0.17101486f, 0.01472053f, -0.14565934f, -0.02871788f, 
    0.06524251f, -0.05926321f, -0.04567970f, 0.06661163f, 0.38486004f, 0.04184109f, -0.24807419f, 0.29714704f, 
    0.35428178f, -0.23638861f, 0.24067314f, 0.21377118f, 0.00861968f, 0.28121167f, 0.25326940f, -0.18000910f, 
    -0.22852333f, 0.23646131f, -0.00934209f, -0.06762692f, -0.00329235f, -0.20862250f, -0.08240853f, 0.29422152f, 
    0.09899362f, 0.06603812f, 0.19736549f, -0.02288987f, 0.18197684f, -0.04905897f, 0.15323927f, 0.02143659f, 
    -0.08394297f, -0.03088659f, -0.18542233f, -0.12167750f, 0.02747148f, 0.00588990f, -0.06075944f, 0.03829299f, 
    0.13751875f, 0.24554324f, 0.06155522f, 0.04866731f, 0.00917547f, 0.19245407f, -0.14335896f, -0.14866163f, 
    -0.15847117f, -0.01414140f, 0.33090308f, -0.00004582f, 0.15021445f, 0.10859813f, -0.10811397f, 0.24725656f, 
    0.15132101f, 0.10556623f, 0.01525577f, 0.43386242f, 0.25009635f, 0.06376690f, 0.01622192f, -0.10731872f, 
    0.03161040f, 0.08582718f, 0.15115014f, 0.27705160f, -0.38893241f, -0.26845711f, 0.09448263f, -0.01718930f, 
    0.13968351f, -0.04072109f, -0.03960862f, -0.06049662f, -0.01433456f, 0.06506123f, 0.33057824f, 0.03954399f, 
    -0.18165499f, -0.14400412f, 0.24304338f, -0.05709852f, 0.04800363f, 0.27079928f, 0.41296259f, 0.08618848f, 
    -0.03142873f, -0.05713511f, 0.14441127f, -0.11417283f, -0.24323367f, -0.25817207f, 0.07969658f, -0.17277281f, 
    0.01018523f, -0.12561451f, -0.00004679f, -0.17306486f, 0.13070615f, -0.00273971f, -0.05952386f, -0.03235175f, 
    0.45002308f, 0.17062476f, 0.00445902f, 0.17169383f, 0.05864065f, 0.03170715f, -0.04672212f, 0.03238581f, 
    0.65338719f, -0.33288318f, 0.00350856f, -0.19720347f, -0.13778079f, -0.09780101f, -0.18778525f, -0.00310961f, 
    -0.13751659f, -0.09148800f, -0.07192368f, -0.21675004f, -0.12662847f, 0.05282242f, 0.08123876f, -0.02662642f, 
    -0.17629559f, -0.13009809f, 0.16431300f, 0.03570191f, 0.12288485f, 0.07034829f, -0.26082617f, -0.16828197f, 
    -0.03299668f, 0.11684314f, 0.20348632f, 0.19251972f, -0.39165777f, -0.26129931f, -0.11073469f, 0.08447410f, 
    0.08274697f, -0.15628190f, -0.04523812f, -0.12753648f, -0.26991409f, 0.06685176f, -0.06190695f, -0.14230610f, 
    -0.21269280f, -0.19419147f, 0.16646786f, -0.01205163f, 0.00924139f, -0.02427645f, -0.29096270f, -0.08486382f, 
    0.20830569f, 0.01708169f, 0.11804215f, -0.05441875f, 0.03122844f, 0.03449347f, -0.07271920f, -0.08602095f, 
    0.16916375f, -0.02392755f, 0.04242356f, -0.22335598f, -0.02462237f, 0.11003612f, 0.27213237f, -0.14220834f, 
    0.16393778f, 0.23500940f, 0.09895505f, -0.08450473f, -0.23334424f, -0.05836378f, 0.16550978f, -0.11950329f, 
    -0.23675822f, -0.33855274f, -0.81960249f, 0.02516125f, 0.08973893f, 0.00021308f, 0.03853179f, -0.09887694f, 
    -0.09389383f, -0.01972863f, -0.00237616f, 0.01094970f, 0.17983879f, 0.18369789f, 0.05066887f, 0.10976653f, 
    0.08962482f, -0.11241061f, 0.13241237f, 0.23462725f, -0.15697080f, -0.25300866f, 0.09955675f, -0.11693306f, 
    0.06289296f, 0.06872434f, 0.25114241f, -0.09323705f, 0.31253830f, 0.25825283f, 0.10365503f, 0.06494252f, 
    0.03414758f, 0.17521787f, 0.01555656f, 0.07859028f, 0.33859691f, -0.54589665f, -0.10730932f, -0.16594248f, 
    0.07551320f, -0.02269775f, -0.17074721f, -0.02022811f, 0.05223832f, -0.38865843f, 0.05182317f, -0.09016861f, 
    -0.04763472f, 0.11485899f, -0.03299672f, -0.05303695f, 0.03319409f, -0.03661188f, -0.54405993f, -0.38254449f, 
    -0.07090469f, 0.08026779f, 0.06671244f, 0.13094912f, 0.10194699f, 0.00141642f, -0.19240126f, -0.06904007f, 
    -0.08790901f, 0.14056040f, -0.05543441f, 0.15140294f, 0.01548539f, 0.01908076f, 0.05918183f, 0.00056717f, 
    0.00451540f, -0.22598320f, 0.15569763f, 0.15018176f, 0.16830468f, 0.16947712f, -0.16205189f, 0.17740273f, 
    0.07783074f, -0.19120266f, 0.01092372f, 0.17423891f, -0.01393076f, 0.09116568f, 0.07292588f, -0.01342310f, 
    0.16785540f, -0.04088391f, 0.19990341f, -0.08276237f, 0.35816371f, 0.05295298f, 0.13385673f, 0.07124498f, 
    0.00602436f, 0.04302326f, 0.09055659f, 0.31386533f, 0.25241110f, 0.16412149f, -0.08127642f, 0.22184552f, 
    0.21667382f, -0.10505199f, 0.11553939f, 0.02126338f, 0.96676111f, 0.02009752f, -0.57919109f, 0.16000175f, 
    -0.11098798f, -0.04045377f, -0.00932221f, -0.18673609f, -0.15846692f, -0.31220287f, -0.02457920f, -0.26180014f, 
    0.14780782f, 0.07479546f, -0.00904891f, 0.25190285f, 0.26218513f, 0.05983180f, -0.34062782f, -0.23311573f, 
    -0.19296102f, 0.05516447f, 0.07892247f, -0.01479507f, 0.11732680f, -0.05197167f, -0.01745901f, 0.42696744f, 
    0.10746364f, -0.08707429f, -0.17577489f, -0.06290755f, 0.10120542f, -0.07178979f, -0.10172718f, -0.00162524f, 
    -0.11707091f, -0.45818466f, 0.03584263f, 0.00765070f, 0.10707735f, -0.04311613f, 0.16165884f, -0.04097919f, 
    -0.11232455f, -0.04267530f, -0.19525228f, -0.12660217f, 0.15859509f, -0.04528292f, 0.02611090f, -0.08471192f, 
    0.00243403f, -0.12592199f, 0.11331637f, -0.26689088f, -0.32296720f, -0.09625603f, -0.00219042f, 0.07189767f, 
    0.04421993f, 0.01308214f, 0.06579146f, 0.02572036f, 0.20799926f, 0.20750459f, -0.08454575f, 0.04929076f, 
    -0.02021524f, -0.18247633f, -0.02294262f, 0.09060743f, -0.37996313f, -0.29038015f, -0.20252801f, 0.02939857f, 
    -0.13747321f, -0.22510198f, -0.06392640f, -0.09211996f, -0.09121079f, -0.34446144f, -0.00393207f, -0.05555418f, 
    0.00935930f, 0.11977510f, 0.13318467f, -0.05156507f, 0.06728996f, -0.11127596f, 0.18661688f, 0.13202991f, 
    -0.20677096f, -0.01277648f, -0.00394551f, -0.00480300f, -0.12873311f, 0.12793559f, 0.05439439f, 0.07361207f, 
    -0.01701188f, -0.27689958f, 0.09999964f, -0.03274220f, 0.05529910f, 0.04755969f, -0.00825898f, -0.00933747f, 
    -0.39538291f, 0.30182445f, 0.33038485f, 0.08219463f, 0.10946333f, -0.21747892f, 0.07588927f, -0.04958933f, 
    0.04496752f, 0.02045391f, -0.22729383f, -0.05014915f, -0.13275713f, 0.09663823f, -0.01943495f, -0.09650562f, 
    0.07720938f, 0.12103471f, -0.25136024f, -0.18441845f, 0.22278203f, 0.01125853f, -0.04211802f, -0.20536496f, 
    -0.03308615f, 0.03606115f, -0.04118222f, 0.00176179f, 0.19893979f, -0.01172230f, -0.06884485f, -0.04633521f, 
    0.04657834f, 0.12019037f, -0.06189855f, -0.03319048f, -0.06353325f, 0.03537073f, 0.06038939f, -0.14419502f, 
    -0.02455514f, -0.17105700f, 0.13168313f, -0.24677306f, 0.08124801f, 0.13421570f, -0.01163399f, 0.08484890f, 
    0.16385391f, 0.02607924f, -0.06372383f, 0.06830224f, -0.13627699f, -0.03001811f, -0.13771778f, -0.09443339f, 
    -0.21294728f, -0.13896684f, -0.02252980f, -0.12719069f, -0.01963036f, 0.17288585f, 0.00607494f, 0.55867898f, 
    -0.38075814f, -0.07748535f, -0.06559092f, 0.09971829f, -0.13603489f, 0.09251893f, 0.06677207f, -0.17752057f, 
    -0.06501615f, -0.01891535f, -0.02895270f, 0.00842137f, 0.03202260f, 0.01115374f, -0.05950669f, -0.04308154f, 
    0.04767917f, 0.01471115f, 0.00678926f, -0.01457403f, 0.03549705f, 0.04230707f, -0.06530272f, -0.02471839f, 
    -0.06450476f, 0.04860378f, -0.06412304f, 0.00587982f, -0.06258993f, -0.03294856f, -0.02045513f, -0.03563902f, 
    0.04851865f, -0.01786684f, -0.05814006f, 0.03387816f, 0.02859495f, 0.01642921f, -0.03156596f, -0.00901447f, 
    0.03946924f, -0.04666184f, 0.01508274f, 0.01794414f, -0.05240503f, -0.05162357f, 0.02620080f, 0.00061954f, 
    -0.06856006f, 0.00378811f, -0.02000243f, -0.00994433f, 0.01658582f, 0.02615232f, -0.00873017f, 0.05343375f, 
    0.03036439f, -0.00655933f, 0.04935660f, 0.00508982f, -0.00132544f, -0.03606174f, -0.04372066f, -0.03804291f, 
    -0.03421300f, 0.03351382f, -0.02800637f, 0.01359711f, -0.04658793f, -0.02877552f, -0.02850851f, -0.03636805f, 
    0.04556507f, -0.06335668f, 0.04649205f, 0.01156669f, -0.05366279f, -0.02387910f, -0.03567171f, 0.03819574f, 
    0.01164662f, -0.01374603f, -0.03665064f, 0.03644680f, 0.05077790f, -0.01636832f, -0.00708991f, 0.04570496f, 
    -0.02805183f, 0.00736666f, -0.01424955f, -0.05893220f, 0.02598181f, 0.00216427f, 0.03675012f, -0.05831556f, 
    -0.06365101f, 0.01062146f, 0.04777282f, -0.06222352f, -0.03074734f, -0.04349628f, 0.03750597f, 0.03091737f, 
    -0.00652627f, 0.01081826f, -0.06271785f, -0.04728279f, -0.06210012f, 0.04460536f, 0.03379058f, -0.05680821f, 
    0.04220385f, 0.01256941f, 0.02742063f, 0.02972640f, -0.03747084f, -0.05325858f, 0.01448815f, -0.06039881f, 
    0.05317995f, 0.04559258f, 0.02044034f, 0.00713607f, 0.02518394f, -0.01507608f, -0.05264894f, 0.01857326f, 
    -0.04930246f, 0.00044088f, -0.03770335f, 0.02849049f, -0.03668403f, -0.01856695f, -0.01370975f, -0.04313375f, 
    -0.02895413f, 0.04989339f, -0.05066547f, -0.03369725f, -0.06235226f, 0.01367921f, 0.04915493f, 0.04659469f, 
    0.01011611f, -0.01753025f, 0.03759360f, -0.06539287f, -0.01393119f, 0.02541859f, -0.02439272f, -0.03324347f, 
    0.04026698f, 0.03300375f, -0.06161197f, 0.04680495f, 0.01455426f, -0.04142514f, -0.04582919f, 0.01490963f, 
    0.04846885f, -0.05655419f, 0.04536676f, -0.06250159f, -0.00188019f, 0.01699003f, -0.01441041f, -0.02409669f, 
    -0.03824049f, -0.05556317f, -0.03276189f, -0.05317902f, -0.05793391f, 0.03750525f, 0.01254458f, -0.05426493f, 
    -0.05906351f, -0.01179307f, -0.03834537f, 0.02530393f, -0.05791096f, -0.00942812f, 0.02126023f, -0.04065594f, 
    -0.00769389f, -0.05935294f, -0.04096628f, 0.01472048f, -0.04511432f, -0.00334945f, -0.03742083f, 0.00835159f, 
    -0.03640265f, -0.00311964f, -0.04887526f, 0.04768240f, -0.03717332f, 0.01312898f, -0.05134892f, 0.01625765f, 
    0.04580018f, -0.02882524f, 0.02056008f, 0.01331832f, -0.03540697f, 0.04957442f, 0.02136523f, 0.04836150f, 
    0.03711994f, -0.00359146f, -0.04360495f, 0.04308181f, 0.04100654f, -0.02472026f, 0.02755492f, 0.01021021f, 
    -0.00237283f, 0.05064149f, 0.00273724f, 0.03528000f, 0.02175193f, -0.01130323f, -0.05025529f, 0.00571807f, 
    0.05071083f, 0.04551278f, 0.03835834f, 0.01681509f, -0.02569672f, 0.00086117f, 0.02769575f, -0.03674329f, 
    -0.04244021f, -0.04249766f, 0.03977577f, -0.04255330f, -0.00781088f, 0.00783284f, -0.06266043f, -0.05798297f, 
    -0.03601058f, -0.00907133f, 0.00767070f, 0.04189903f, 0.04600565f, 0.03599813f, 0.04692989f, -0.03335072f, 
    -0.02755041f, 0.00479453f, 0.05013982f, -0.02261443f, -0.05365914f, 0.05001301f, -0.03144179f, 0.01599638f, 
    0.02888806f, -0.04221348f, -0.00606295f, 0.01254603f, -0.05066641f, 0.02962715f, 0.01442871f, 0.03106003f, 
    -0.02311847f, 0.00642517f, 0.05226853f, 0.03421875f, 0.03555644f, -0.01581664f, -0.03045484f, -0.02839187f, 
    -0.05234117f, 0.00780847f, 0.02717083f, 0.03866419f, 0.02492743f, -0.00236693f, 0.02142864f, -0.00288635f, 
    -0.05307780f, 0.02212395f, 0.04670510f, -0.06037411f, 0.04468508f, -0.03046028f, -0.04911651f, 0.04977297f, 
    -0.03214554f, 0.01279057f, -0.01543529f, -0.05131608f, -0.02973149f, -0.03500601f, -0.05159575f, -0.04250436f, 
    -0.68244904f, 0.23022042f, -0.03827147f, 0.21697953f, 0.08313734f, 0.08486482f, 0.02106826f, -0.20851620f, 
    -0.02204643f, 0.25130969f, 0.17217517f, -0.02215593f, 0.06321978f, 0.16216242f, -0.19138561f, 0.35189742f, 
    0.12474242f, 0.13080439f, 0.01376622f, -0.43414548f, 0.27728534f, 0.01535978f, 0.05987239f, 0.01546207f, 
    -0.06494406f, -0.06441788f, -0.05134153f, -0.08033101f, 0.05564480f, 0.08542516f, 0.11499259f, 0.07860953f, 
    -0.00508664f, 0.16639210f, 0.13521992f, 0.04115289f, -0.36593366f, -0.26762494f, -0.26358148f, -0.05368912f, 
    0.16065836f, -0.06928299f, 0.03472575f, 0.12218557f, -0.26482561f, -0.42232099f, 0.01328340f, 0.02530932f, 
    0.18425508f, 0.19063912f, -0.08542495f, 0.17650564f, 0.19310747f, -0.03650437f, -0.45565194f, -0.23388828f, 
    -0.02443801f, 0.30743435f, 0.08112191f, -0.09430649f, 0.14393164f, 0.00614991f, -0.05423424f, 0.12357914f, 
    0.11610689f, 0.38056335f, 0.09244890f, 0.22762498f, -0.10075174f, 0.39726388f, 0.09400763f, 0.21531902f, 
    -0.27031606f, 0.30911633f, 0.15357907f, -0.01382057f, 0.01172858f, 0.22836702f, -0.04838561f, 0.05874962f, 
    0.02190385f, -0.44154948f, 0.00677243f, 0.15356737f, 0.03095611f, -0.06702744f, 0.08977227f, -0.12503891f, 
    -0.10797760f, -0.15188192f, -0.08799039f, 0.34130085f, 0.47011060f, 0.08482828f, 0.04539940f, 0.03990292f, 
    0.07082550f, 0.12807487f, -0.04829990f, -0.55057913f, 0.03469332f, 0.15221532f, 0.22974393f, 0.19325314f, 
    -0.04391104f, -0.04085473f, -0.00805303f, -0.18289351f, -0.19866775f, 0.26645207f, -0.06444072f, 0.10295919f, 
    -0.06080756f, -0.09102885f, 0.03248684f, -0.08970418f, 0.05586989f, 0.13548511f, -0.11816275f, 0.10796696f, 
    0.05731073f, 0.17653887f, 0.01619930f, 0.21894906f, 0.17914033f, 0.20119339f, -0.19785486f, -0.08754341f, 
    -0.25485951f, 0.04977145f, -0.03942887f, 0.19403301f, 0.15163884f, -0.13473341f, 0.08990475f, -0.21761292f, 
    -0.26224369f, -0.05637291f, 0.13881907f, -0.04255950f, 0.12254906f, -0.13987266f, 0.15985517f, -0.07687492f, 
    -0.32066035f, -0.08316752f, -0.11794038f, 0.08789094f, 0.07455708f, 0.25461993f, 0.00375266f, -0.09369364f, 
    -0.05384669f, -0.35034001f, 0.25700217f, -0.24373603f, 0.03050194f, 0.25963217f, 0.17129773f, 0.12291300f, 
    -0.15674739f, 0.13414766f, -0.96215808f, -0.12655710f, -0.20350775f, 0.21708056f, 0.01877543f, 0.07053931f, 
    0.03183322f, 0.09266007f, -0.01876839f, 0.06041212f, -0.08153833f, 0.32064193f, -0.31081343f, -0.09612083f, 
    0.01609150f, -0.11097560f, -0.05296751f, 0.15705223f, 0.10475071f, 0.34954208f, 0.07113277f, 0.15200543f, 
    0.03683354f, 0.04941330f, 0.00364326f, -0.22164172f, 0.00928436f, -0.18612328f, -0.04275979f, 0.02908089f, 
    -0.00343458f, 0.06920925f, 0.23439711f, -0.01093028f, -0.06446377f, 0.15559381f, 0.10024179f, -0.07611316f, 
    -0.09626184f, 0.04258177f, 0.04964428f, 0.05241872f, 0.06654229f, 0.17825551f, 0.33304435f, -0.79559064f, 
    -0.25605336f, -0.34678978f, 0.17789802f, 0.09517889f, 0.00271389f, 0.15380256f, -0.02756442f, 0.07824121f, 
    -0.54960519f, -0.16304785f, -0.14588127f, -0.14435273f, -0.11025956f, -0.07707211f, -0.11576184f, -0.13503104f, 
    -0.09753171f, 0.22849549f, 0.17341162f, 0.09526163f, 0.08803258f, 0.14439103f, 0.06353144f, -0.10737717f, 
    0.02365514f, 0.14580195f, -0.13416611f, 0.12146321f, -0.03968341f, 0.19551142f, 0.08232481f, 0.07864930f, 
    0.07906498f, 0.02010123f, 0.07113963f, -0.10017483f, 0.00259120f, -0.08945646f, -0.33900464f, -0.12360139f, 
    -0.02862994f, -0.17778769f, 0.03253448f, 0.02988368f, -0.28959993f, -0.19406292f, -0.02349136f, 0.18372089f, 
    -0.10973238f, 0.30440685f, 0.21480377f, -0.09423396f, 0.19283187f, -0.21554607f, 0.05090317f, 0.41028896f, 
    0.06397233f, 0.19638984f, -0.17833835f, 0.09478914f, -0.06498062f, -0.05435786f, 0.39888462f, -0.08670944f, 
    -0.27760395f, -0.16559698f, -0.00680264f, -0.25818381f, -0.00923074f, 0.12199654f, -0.06271687f, -0.02852730f, 
    -0.08906413f, 0.21713735f, -0.13505022f, 0.11382874f, 0.06659476f, 0.01483948f, -0.10919474f, 0.12764546f, 
    -0.27820647f, 0.03204635f, 0.13361844f, -0.02877071f, 0.06877853f, -0.11062127f, -0.04508308f, -0.06581625f, 
    0.01284644f, 0.11757577f, -0.16170007f, -0.03333946f, -0.00312307f, 0.02799695f, -0.02052063f, 0.18107270f, 
    0.22714581f, 0.07641873f, -0.50968492f, -0.17472126f, -0.03192777f, -0.06774652f, -0.05291439f, -0.08605047f, 
    0.10049715f, -0.09590119f, 0.10848017f, 0.23364201f, -0.15048212f, -0.05527762f, -0.06080747f, 0.03565384f, 
    0.21037076f, 0.01571623f, 0.10104220f, 0.09369196f, -0.08439574f, -0.40179554f, 0.07113449f, 0.21042070f, 
    0.11421084f, 0.03027182f, -0.02863033f, -0.07672803f, 0.02294544f, -0.17335501f, -0.43549705f, 0.35494208f, 
    0.00639799f, -0.12288264f, -0.11461726f, -0.01662292f, 0.06464772f, 0.18285806f, -0.35259089f, -0.27371305f, 
    0.50985676f, 0.10350645f, 0.12241399f, 0.13013916f, -0.09241462f, -0.00816588f, 0.23710616f, -0.26103300f, 
    0.06037359f, 0.05132119f, 0.12046688f, 0.07787732f, -0.01049626f, -0.06917712f, 0.00051775f, 0.05104632f, 
    -0.16806822f, -0.06512235f, -0.38800910f, 0.11221869f, -0.12398903f, 0.07109258f, -0.07114251f, -0.10618501f, 
    0.00114985f, -0.08371277f, 0.25444570f, -0.12782077f, -0.10443392f, 0.07736992f, 0.31194708f, 0.08730850f, 
    -0.04207977f, -0.01687501f, -0.11212786f, 0.11868971f, -0.02357091f, 0.08016760f, 0.04185800f, 0.18914989f, 
    0.00029726f, -0.07161185f, 0.16698253f, -0.03988190f, 0.14969043f, 0.12333266f, -0.06796996f, 0.04883788f, 
    0.14074381f, -0.16231261f, 0.05267293f, 0.15652542f, 0.51282167f, -0.00047565f, -0.19704616f, -0.14736143f, 
    0.09337822f, 0.02686925f, 0.06463996f, 0.10041773f, 0.09082402f, -0.17640108f, 0.01105003f, -0.15832958f, 
    -0.09740350f, -0.14972535f, 0.11242156f, -0.03213708f, -0.03156185f, 0.25267097f, 0.19459423f, -0.16469605f, 
    0.16811070f, -0.21728808f, 0.02842735f, -0.05698374f, -0.01576023f, -0.03177605f, -0.05430498f, 0.01339075f, 
    0.04688793f, -0.26488879f, 0.04047637f, 0.21690527f, 0.06858376f, -0.26080844f, 0.14416635f, -0.04653792f, 
    -0.75943631f, -0.31757265f, -0.09409390f, -0.03821026f, 0.08520810f, 0.10106373f, 0.12739734f, -0.04663648f, 
    -0.11414967f, 0.04387212f, -0.19252405f, 0.00646677f, -0.03297977f, 0.08576758f, -0.09247732f, -0.00733128f, 
    0.13694239f, -0.03868317f, 0.29242530f, -0.22399013f, 0.21834485f, -0.00098717f, -0.16792029f, -0.00591887f, 
    -0.00613709f, 0.06943801f, 0.03178875f, -0.16042602f, 0.28820240f, -0.26902348f, 0.07631783f, 0.11411072f, 
    0.05808315f, 0.05088351f, 0.12513708f, -0.04612453f, -0.07665833f, 0.31839496f, -0.02304224f, 0.22984432f, 
    -0.16089843f, -0.08431906f, 0.06065897f, 0.02735568f, 0.09766594f, -0.66527212f, -0.05992149f, -0.05701728f, 
    -0.05548902f, 0.05922305f, -0.03012120f, 0.01724728f, -0.11056158f, 0.17865548f, -0.21629366f, -0.10041445f, 
    -0.10755981f, 0.03500513f, 0.13083719f, 0.23214312f, 0.06251699f, 0.11000528f, 0.02453024f, 0.14382625f, 
    -0.02423833f, 0.37143391f, -0.15000716f, -0.16492692f, 0.07790617f, 0.13423134f, 0.03289657f, 0.04648901f, 
    -0.07353009f, 0.25177220f, -0.05071956f, -0.14384675f, -0.17065652f, -0.14112705f, -0.00319599f, 0.04713205f, 
    0.11553200f, -0.48990718f, -0.29592055f, -0.53339857f, 0.16660422f, -0.04950124f, 0.07906382f, 0.02280806f, 
    0.21929096f, -0.12379472f, -0.17170870f, 0.05828102f, -0.35780686f, 0.08769501f, -0.04523522f, -0.25939420f, 
    0.03033877f, -0.11186565f, 0.32024679f, -0.10154432f, 0.09231082f, -0.10053814f, -0.13679340f, 0.12363007f, 
    -0.01661954f, -0.05636799f, -0.00140681f, 0.00391355f, -0.37403247f, -0.00583956f, 0.10812692f, 0.00571220f, 
    -0.03502441f, 0.03568213f, -0.08801873f, -0.07924604f, 0.19253111f, 0.08644823f, 0.37164050f, -0.11804073f, 
    0.11280121f, -0.04071087f, -0.05848301f, -0.14738673f, -0.03274692f, 0.06546270f, 0.08236378f, 0.14809766f, 
    0.31190804f, -0.05487444f, -0.23750946f, -0.04916227f, 0.23803720f, 0.09993230f, 0.11243231f, 0.26276690f, 
    0.02976695f, 0.28260785f, 0.01051566f, 0.09454481f, -0.05659560f, -0.10142599f, 0.13642712f, 0.00786535f, 
    0.29751292f, 0.30722514f, -0.42349750f, 0.29873577f, -0.05809559f, 0.11311343f, -0.04336379f, 0.06070599f, 
    0.00696989f, -0.35744372f, -0.02567706f, 0.17632467f, -0.12932190f, 0.05223394f, -0.00552025f, -0.10186695f, 
    0.08132707f, 0.26193666f, 0.38168067f, -0.30099621f, -0.41777751f, 0.04262973f, 0.06474826f, -0.11656984f, 
    -0.16769923f, 0.06477477f, -0.06397331f, -0.03789780f, 0.09675609f, -0.02896419f, -0.13005044f, 0.03916996f, 
    -0.05393419f, 0.02252854f, 0.12343393f, -0.07774918f, 0.32898143f, 0.03917705f, -0.17023161f, -0.01378758f, 
    -0.04078799f, -0.00768956f, -0.23777507f, -0.03037514f, -0.19083402f, -0.13246971f, 0.05441829f, -0.22440369f, 
    0.13620785f, -0.14069745f, -0.02281323f, 0.02315477f, -0.04601350f, -0.05502974f, 0.21550035f, -0.12497104f, 
    -0.04204377f, -0.18181215f, 0.04036582f, -0.07687265f, -0.01735600f, -0.07855047f, -0.26873189f, -0.02575883f, 
    0.28803456f, -0.24915959f, -0.14267495f, -0.02412928f, 0.13140038f, 0.05214315f, -0.00673446f, 0.15931690f, 
    0.07837825f, 0.25067514f, -0.24183159f, -0.08751513f, -0.05359159f, 0.09047472f, -0.30568284f, 0.07014234f, 
    -0.11444846f, -0.33788988f, 0.16886182f, -0.02432903f, 0.13894041f, 0.12814319f, 0.00353626f, -0.10563544f, 
    0.08120693f, -0.12094548f, 0.13009688f, 0.29464847f, -0.35761926f, -0.09571132f, 0.03592762f, -0.06392887f, 
    0.00492778f, -0.01429923f, -0.14904118f, -0.25771412f, 0.23417503f, -0.03541397f, -0.26959744f, 0.04969608f, 
    0.01295422f, -0.03973049f, 0.11166927f, -0.06753123f, 0.00118856f, 0.35060042f, 0.00349893f, 0.11002833f, 
    -0.10516263f, -0.08793494f, 0.15854746f, -0.16785896f, 0.03866430f, 0.03155770f, -0.25231963f, -0.13198434f, 
    -0.01359632f, -0.02868402f, -0.04957252f, 0.07832765f, 0.20654134f, 0.02706905f, 0.69008672f, 0.17075597f, 
    0.18672240f, -0.07968997f, -0.15379006f, 0.00054253f, 0.11500432f, 0.02415677f, -0.20678923f, -0.56184781f, 
    0.07158348f, -0.42132732f, -0.04596607f, 0.15045634f, -0.11340762f, -0.02547238f, -0.07433905f, 0.09165802f, 
    0.11245930f, 0.24276087f, -0.11286858f, -0.00133947f, -0.01788967f, 0.01689469f, 0.04800484f, 0.15338838f, 
    0.04475720f, 0.30633736f, 0.45715907f, -0.21132764f, 0.19406250f, -0.05240196f, 0.00880822f, 0.19966163f, 
    -0.18356778f, 0.25519308f, -0.20573671f, 0.05749164f, 0.04928327f, 0.11490358f, -0.15034750f, 0.18252285f, 
    0.04898426f, -0.01967791f, -0.09738006f, -0.17461252f, 0.16229703f, -0.06325459f, 0.18444481f, 0.13163944f, 
    0.16839615f, -0.07978051f, -0.02003101f, -0.05909488f, 0.49817282f, 0.00329543f, 0.13695522f, -0.11951645f, 
    -0.10859287f, 0.00651031f, -0.05629003f, 0.04812135f, 0.13643943f, 0.08041367f, -0.14267512f, 0.00420516f, 
    -0.00253960f, 0.04908579f, -0.00675743f, -0.03140872f, 0.05287343f, -0.00410310f, -0.25349990f, -0.01145705f, 
    -0.27124947f, 0.00276656f, -0.06647923f, -0.15255627f, -0.06387342f, 0.14223753f, -0.16966124f, 0.05592380f, 
    0.19488719f, 0.08387344f, -0.01828728f, -0.20151895f, 0.16654211f, -0.13370034f, 0.13084468f, -0.14161797f, 
    0.37702751f, -0.14681707f, 0.09052986f, -0.21057807f, 0.02179658f, -0.03508549f, -0.13301143f, 0.14412855f, 
    0.14769596f, -0.42516932f, -0.21547469f, -0.16654713f, -0.09759140f, 0.07889745f, -0.05370561f, -0.16479845f, 
    0.02369600f, -0.05344228f, 0.36668879f, 0.21222225f, -0.23569384f, -0.04549356f, -0.18033560f, -0.06845375f, 
    -0.09767658f, -0.00854602f, -0.02420765f, 0.19516928f, 0.22084588f, 0.12345024f, 0.03575693f, 0.27735913f, 
    0.12414050f, -0.03747426f, 0.03969792f, 0.13741359f, 0.36178046f, -0.04536472f, -0.13055386f, 0.06955220f, 
    0.04277201f, 0.00468459f, -0.14103293f, 0.04147071f, 0.07920898f, -0.25300464f, 0.12131312f, -0.01341619f, 
    -0.00282358f, 0.24528982f, -0.18013744f, 0.01640421f, -0.10188477f, 0.04922947f, -0.09674612f, 0.12511608f, 
    -0.40083411f, 0.02429864f, -0.16511090f, 0.07183535f, 0.15277003f, 0.02856091f, -0.04627754f, 0.12539539f, 
    0.16384476f, -0.15452491f, 0.16102844f, -0.20254877f, 0.15971281f, -0.15130633f, -0.11315021f, -0.02157921f, 
    0.16096613f, 0.34134108f, 0.05401983f, 0.21285345f, -0.00005801f, -0.03391201f, 0.20925273f, 0.09739638f, 
    -0.00083413f, -0.18585213f, -0.18970749f, -0.08731125f, 0.02761990f, -0.01536106f, -0.11215430f, 0.00983100f, 
    -0.08212961f, -0.08548447f, 0.16926630f, 0.21794458f, -0.09290059f, -0.09245571f, -0.16724087f, -0.09753200f, 
    -0.09698132f, 0.21850979f, -0.12190603f, -0.07927326f, -0.05889510f, -0.08687805f, 0.19017142f, -0.03459350f, 
    0.08612142f, 0.12301524f, 0.22609678f, 0.08645773f, -0.13937332f, -0.22114348f, -0.02098046f, -0.04435727f, 
    0.01776011f, -0.04189454f, -0.00384224f, 0.03547464f, 0.04201683f, 0.38117671f, 0.26983860f, 0.53103143f, 
    0.14330806f, 0.10156909f, -0.07595522f, -0.08579942f, 0.10766990f, 0.02630209f, 0.11744969f, 0.21025515f, 
    0.26877457f, -0.01236016f, -0.00269161f, -0.15424110f, -0.11110020f, 0.00685870f, -0.00492116f, -0.42186275f, 
    -0.21812506f, 0.14615227f, -0.02590405f, -0.01629576f, 0.01716154f, -0.15141834f, 0.00559635f, 0.10663836f, 
    -0.82906967f, -0.15363134f, 0.12802979f, 0.16127144f, 0.10413286f, 0.10968190f, -0.06478320f, -0.01816742f, 
    -0.09272429f, -0.20353878f, -0.20676355f, -0.08037687f, 0.14022291f, -0.12823333f, 0.07492630f, -0.07351891f, 
    0.08015524f, -0.15081926f, -0.42821804f, 0.05948968f, -0.27704081f, 0.05404050f, -0.06313351f, 0.00317445f, 
    -0.13191053f, 0.09108893f, 0.01184773f, -0.05259845f, 0.04129716f, -0.08729041f, -0.13644265f, -0.01096733f, 
    -0.00928486f, 0.01265398f, -0.04795885f, 0.00794190f, 0.22683655f, 0.35160944f, -0.10177252f, 0.13232420f, 
    -0.02196292f, -0.01057244f, -0.14127760f, 0.21916734f, 0.21729767f, 0.19002286f, 0.29112306f, -0.01002720f, 
    -0.13882057f, -0.08871248f, 0.16581006f, 0.04946531f, 0.02137349f, -0.18117172f, 0.42040530f, 0.24067344f, 
    0.06830320f, 0.14574274f, -0.12060931f, 0.06958895f, 0.00263727f, 0.11872922f, 0.11758355f, 0.18971172f, 
    0.07054392f, 0.07735443f, -0.04953763f, -0.27359813f, -0.14739004f, -0.10193585f, 0.05252920f, 0.15872934f, 
    0.16933553f, 0.18419810f, -0.00013319f, 0.09529544f, 0.02004577f, 0.01774300f, -0.05156041f, -0.13871507f, 
    0.06617229f, 0.11125979f, 0.13634028f, 0.24193704f, 0.22142193f, 0.14182596f, -0.10172718f, 0.16593090f, 
    0.14754270f, 0.00249843f, 0.05286926f, 0.14443494f, 0.30696172f, 0.11498478f, -0.02950071f, -0.01531605f, 
    -0.10123014f, 0.15136358f, -0.08083125f, -0.01587645f, 0.02158848f, -0.27229604f, 0.12409095f, -0.25307673f, 
    0.16525963f, -0.21313566f, 0.16650048f, -0.18383917f, 0.01176181f, 0.02816514f, 0.07394453f, 0.06446791f, 
    0.21053717f, -0.01618373f, -0.01689960f, 0.04350719f, 0.16564353f, -0.15270375f, -0.05065264f, 0.06959975f, 
    0.12984495f, 0.18003833f, 0.15249193f, -0.14377798f, -0.16626622f, -0.15319809f, 0.18183756f, -0.12512612f, 
    -0.25188380f, 0.07938604f, -0.16308555f, -0.09869552f, -0.20026459f, -0.12201526f, 0.19649956f, 0.29389948f, 
    0.22398849f, 0.31373107f, -0.19768825f, -0.14193960f, -0.00990445f, -0.11207260f, 0.12554637f, -0.05503073f, 
    -0.26973236f, 0.09709106f, 0.09375438f, -0.03187615f, 0.04481628f, -0.27899644f, 0.06184024f, 0.02571166f, 
    -0.07759313f, 0.01114312f, -0.18052195f, 0.05472059f, -0.01199205f, -0.05171710f, -0.01993179f, -0.14417771f, 
    -0.11108863f, 0.07641184f, 0.05039422f, 0.07215749f, -0.02115495f, 0.10878455f, 0.03239146f, -0.27656755f, 
    0.00904975f, -0.02981125f, -0.00524752f, -0.39334351f, -0.06331077f, -0.07823487f, -0.02743405f, -0.12894644f, 
    -0.07466679f, -0.18306457f, 0.06938003f, 0.01995003f, -0.44273698f, -0.02520639f, -0.14652254f, 0.01713780f, 
    -0.12593228f, -0.13764690f, 0.13603148f, 0.03605099f, -0.22019309f, -0.55105472f, -0.02266925f, -0.36875033f, 
    0.03943123f, -0.13709456f, 0.05924177f, -0.10078310f, -0.11191046f, 0.03528528f, 0.06452222f, -0.02223626f, 
    0.09507205f, -0.13107026f, 0.14199828f, -0.07409069f, 0.13218565f, -0.10005943f, 0.00124179f, -0.25984961f, 
    -0.05934200f, -0.08981308f, 0.03987992f, 0.03235080f, -0.17505844f, 0.05470126f, 0.12823707f, -0.09606327f, 
    -0.00109918f, 0.04106413f, -0.03149562f, -0.06063570f, 0.03255169f, -0.03191799f, -0.01969187f, -0.04319404f, 
    0.04050515f, -0.04958548f, -0.00123265f, -0.01127959f, -0.05306221f, -0.05126854f, 0.04086081f, -0.01048781f, 
    -0.03092378f, -0.00271967f, -0.04538673f, 0.00687105f, 0.00718774f, 0.02587053f, 0.04746278f, -0.01380245f, 
    0.05010010f, 0.03202343f, -0.00464526f, -0.05222595f, 0.02246634f, -0.01727294f, 0.02256290f, -0.01316661f, 
    -0.02303581f, 0.02413962f, -0.01021949f, 0.00445627f, -0.02639895f, -0.03935208f, -0.04711796f, -0.00248938f, 
    -0.06299990f, -0.00432231f, 0.02611072f, -0.05343018f, -0.01261651f, -0.05359169f, 0.00040849f, -0.01219825f, 
    -0.02087157f, -0.01441348f, -0.02472557f, 0.05038209f, 0.03020426f, -0.01179307f, -0.06674718f, 0.02202477f, 
    -0.02408633f, -0.06184064f, 0.03475021f, -0.04224338f, -0.04238969f, 0.01068631f, 0.00366582f, 0.03873001f, 
    -0.04837835f, -0.05062656f, 0.03626580f, -0.06100012f, -0.01403257f, 0.01085921f, 0.01219423f, -0.05540956f, 
    -0.06400316f, -0.04309653f, 0.01281860f, 0.01396886f, 0.01664955f, -0.06625535f, 0.04701263f, -0.04392939f, 
    0.00075945f, 0.04703899f, -0.01935156f, 0.02679439f, 0.04389343f, 0.01034434f, -0.00528411f, 0.04667135f, 
    -0.04352469f, 0.00538050f, -0.00953429f, -0.05010481f, -0.04570903f, -0.01870242f, -0.00819465f, -0.03173582f, 
    0.01624928f, 0.01786881f, -0.01113858f, -0.06061018f, -0.02451835f, 0.02210774f, -0.05022552f, 0.02347672f, 
    -0.04222220f, -0.00199435f, 0.02144012f, 0.00867517f, 0.04737418f, 0.00694649f, -0.05133771f, -0.02923213f, 
    -0.02301893f, 0.00832054f, 0.02907180f, -0.01007064f, 0.04628915f, 0.03160818f, -0.01973801f, 0.01438520f, 
    0.03548113f, 0.03244508f, 0.03165918f, 0.00143871f, -0.01127717f, 0.04506405f, 0.05098704f, 0.04793755f, 
    0.03620753f, -0.00756947f, 0.01553619f, 0.02518186f, -0.05660243f, 0.00529781f, -0.03039227f, -0.00082577f, 
    0.00490393f, -0.04030650f, -0.05783811f, -0.05308321f, -0.05907318f, -0.03447516f, 0.01729775f, -0.00958613f, 
    -0.05198370f, 0.03002615f, -0.03371202f, 0.05086862f, 0.01909796f, -0.03935368f, -0.03106873f, 0.01378846f, 
    -0.04730403f, -0.06050496f, -0.05478710f, 0.00606408f, -0.00212194f, 0.04232224f, -0.00589215f, -0.02530085f, 
    0.01350449f, -0.00414878f, 0.01352613f, -0.00723358f, -0.02606025f, -0.01859096f, -0.05623927f, -0.04316894f, 
    0.00345997f, 0.00699274f, 0.03822168f, 0.00420236f, -0.06317551f, -0.04581373f, 0.04450441f, -0.05084469f, 
    -0.01293020f, -0.05063368f, 0.04605216f, -0.01758526f, -0.01227533f, -0.02856896f, 0.01490382f, 0.00522632f, 
    0.04232164f, -0.02067514f, -0.01559266f, -0.02379337f, -0.02149139f, -0.01476922f, 0.00455504f, -0.00643925f, 
    -0.02926839f, -0.00026490f, 0.01914219f, -0.01798146f, -0.01952841f, 0.02716566f, -0.01800696f, 0.04747525f, 
    0.03279735f, -0.04123072f, -0.06562751f, 0.00541549f, -0.05019260f, 0.02559627f, -0.06219384f, 0.04719285f, 
    -0.05077937f, 0.01354664f, -0.00038156f, -0.04026527f, -0.01519356f, -0.04231770f, 0.00910941f, 0.03582642f, 
    -0.05806407f, 0.01480440f, 0.02086710f, 0.01568902f, 0.05002552f, 0.03538742f, -0.00784066f, 0.05559919f, 
    -0.02380896f, 0.03968785f, 0.01094451f, 0.02028698f, 0.00580887f, 0.04848834f, 0.05006020f, 0.04724853f, 
    -0.03382256f, -0.01437695f, 0.04965739f, 0.00350088f, -0.00553596f, 0.02559999f, -0.01081809f, 0.04499139f, 
    -0.03708057f, -0.02509260f, 0.03013775f, -0.00605536f, -0.01278839f, -0.02454678f, -0.04969602f, -0.03716043f, 
    -0.04810062f, -0.02287281f, -0.03829774f, 0.00122039f, 0.02777301f, -0.04755856f, 0.00995282f, -0.02801588f, 
    0.01535525f, 0.00846090f, -0.04501624f, 0.00941506f, -0.03872104f, -0.01012902f, -0.03176103f, -0.02438751f, 
    0.04866236f, 0.04715129f, 0.04454021f, 0.01015161f, -0.04499463f, 0.02337489f, 0.05042515f, -0.00965347f, 
    -0.04595155f, 0.03292213f, -0.06140484f, -0.03515745f, -0.05971910f, 0.04416602f, -0.03255184f, -0.05157259f, 
    0.00863573f, 0.03716161f, -0.06148318f, -0.05441302f, -0.01789625f, -0.05083498f, -0.04889020f, -0.03777184f, 
    0.20464382f, -0.02034496f, -0.13289610f, -0.17564134f, -0.00730939f, 0.04053032f, -0.12697363f, 0.13199140f, 
    -0.01050345f, -0.86216748f, -0.26227376f, -0.09874022f, 0.03886651f, 0.00420301f, 0.16635510f, 0.03988114f, 
    0.03611923f, -0.04031301f, 0.58237517f, 0.22386628f, 0.22938563f, -0.10206741f, -0.17891790f, 0.11736353f, 
    0.07026022f, 0.11481292f, -0.02041851f, -0.13778839f, -0.23323895f, -0.03555318f, 0.15973756f, 0.01278154f, 
    0.17804199f, -0.09928184f, 0.00701282f, -0.05991110f, 0.22510378f, -0.09046848f, -0.07466241f, -0.16545057f, 
    -0.10879549f, -0.18550265f, 0.12995337f, 0.04978262f, 0.12467260f, -0.26082146f, -0.09621275f, -0.13745014f, 
    -0.28927067f, 0.09597979f, -0.01273065f, 0.08817537f, -0.04585078f, 0.04845990f, 0.03636096f, 0.08475296f, 
    0.12378997f, -0.01448569f, -0.08701387f, -0.03691924f, 0.22301936f, 0.03844377f, -0.08906550f, 0.10494284f, 
    0.05429671f, 0.25835362f, 0.05728556f, -0.03192270f, -0.05720920f, -0.06573101f, -0.16053450f, -0.14759082f, 
    -0.16064505f, 0.06128203f, -0.08680025f, 0.13255514f, 0.05325728f, -0.01422834f, -0.09388733f, -0.05347385f, 
    0.02072117f, -0.35692877f, -0.20681216f, 0.21577559f, 0.05969051f, 0.12410376f, 0.06719450f, 0.03871436f, 
    -0.05992719f, 0.24009880f, 0.41304472f, -0.17237282f, 0.19709174f, -0.00655968f, 0.03550258f, 0.05649062f, 
    -0.06250037f, -0.05580527f, -0.03887536f, -0.48107371f, -0.22248729f, -0.01150820f, -0.16644590f, 0.09941183f, 
    0.03273218f, 0.01138479f, 0.17585072f, -0.06999013f, 0.00583314f, -0.21243007f, -0.11403145f, 0.05492706f, 
    -0.00333732f, 0.06809355f, -0.05156340f, -0.07473727f, -0.18137342f, -0.20077725f, -0.08202261f, -0.05781469f, 
    -0.05669948f, 0.06659683f, -0.10471422f, 0.06433677f, -0.12691000f, 0.08799537f, 0.16527346f, -0.07372712f, 
    0.01260834f, -0.12301222f, 0.00975949f, 0.03199054f, 0.17995608f, 0.09861677f, 0.02695199f, -0.08111607f, 
    0.01563082f, 0.37877309f, 0.05079562f, 0.04899001f, 0.11351159f, -0.11707461f, 0.22314525f, -0.11066581f, 
    0.14915670f, -0.02844906f, 0.12906645f, -0.09394448f, -0.03320172f, 0.21329212f, -0.11655774f, 0.15023726f, 
    -0.10492039f, 0.11978753f, -0.17092215f, -0.14141680f, -0.14592235f, 0.03796863f, 0.03735086f, 0.03049775f, 
    0.07739073f, 0.04566547f, -0.08462563f, 0.01145184f, -0.18860148f, -0.29163373f, 0.00042708f, -0.18215775f, 
    -0.05428450f, 0.25312665f, -0.01709729f, 0.70623511f, -0.04682867f, 0.07941464f, 0.19967645f, 0.05107671f, 
    -0.04688247f, 0.12423760f, -0.00959873f, 0.00304694f, -0.09618969f, -0.27854398f, -0.15863894f, 0.09011588f, 
    0.11882270f, -0.08256558f, 0.12248177f, 0.01558576f, -0.08095164f, 0.48087314f, 0.03509405f, -0.00379634f, 
    0.05697521f, -0.12084561f, 0.02920372f, 0.12356672f, 0.06011947f, -0.02978773f, 0.27368277f, -0.02212435f, 
    0.12384500f, 0.03654117f, -0.00187478f, 0.09566812f, 0.15347028f, -0.01744180f, 0.11640190f, -0.04673869f, 
    -0.02024117f, -0.17900191f, -0.13006414f, 0.13399532f, -0.02435169f, 0.03871858f, 0.01722128f, 0.13283306f, 
    -0.25984770f, -0.27147096f, 0.08063975f, -0.02336058f, 0.03514258f, -0.11344057f, -0.03309868f, 0.03235551f, 
    0.01493874f, 0.25204778f, 0.08639858f, 0.13532728f, 0.13218404f, 0.15268748f, 0.03928197f, 0.05113402f, 
    0.17221886f, -0.05089441f, -0.04102431f, -0.19558682f, -0.16310644f, -0.01225544f, 0.13471569f, -0.22203907f, 
    0.08333673f, 0.14933880f, -0.09701733f, 0.11465032f, 0.06790350f, -0.01895493f, 0.30116278f, 0.00913212f, 
    -0.17705350f, -0.04560778f, 0.13727325f, 0.01381053f, 0.12026536f, 0.36023837f, 0.11925456f, 0.02449281f, 
    0.03247001f, -0.05834742f, -0.01840569f, 0.06626627f, 0.01689176f, -0.66581768f, -0.01050552f, 0.51199263f, 
    0.14369449f, -0.20709360f, 0.20368081f, -0.12337206f, -0.03249166f, 0.05683853f, -0.40952972f, 0.05406362f, 
    0.06870867f, -0.24215931f, -0.22573967f, -0.07052967f, -0.05627374f, 0.09896471f, 0.15175129f, 0.03850342f, 
    -0.06414235f, 0.00403969f, 0.03976435f, -0.17541058f, 0.02108694f, 0.02707841f, 0.09669685f, -0.03988435f, 
    -0.01356226f, -0.03264995f, 0.26048997f, 0.19957390f, -0.13997151f, -0.00726365f, -0.01099656f, 0.20373394f, 
    0.05345107f, 0.08230186f, 0.01346848f, 0.18200876f, 0.02997473f, -0.06014906f, 0.01470339f, -0.01932301f, 
    0.25289419f, 0.01744234f, -0.63633972f, -0.42107999f, -0.25669497f, 0.03881735f, -0.02235035f, 0.04465476f, 
    -0.18372482f, 0.01669210f, -0.00041243f, 0.14497983f, -0.06958079f, 0.14794023f, -0.03474330f, -0.01118822f, 
    -0.26749110f, 0.16751204f, 0.24692214f, 0.01927817f, 0.16167049f, 0.29806677f, -0.32945207f, -0.08807687f, 
    0.01459953f, 0.13529676f, 0.09036164f, -0.04297090f, 0.10978436f, 0.25543344f, 0.06181686f, 0.04534730f, 
    0.17242788f, -0.05191169f, 0.03749782f, 0.06135926f, 0.09740552f, 0.04168030f, 0.32786879f, -0.03873130f, 
    0.13642761f, 0.04987707f, -0.06937308f, 0.04668518f, 0.02015835f, -0.00180359f, -0.08549492f, -0.09796687f, 
    -0.19064070f, -0.00927996f, 0.13664550f, 0.11224046f, 0.03150649f, -0.05118061f, 0.06844096f, -0.04051205f, 
    0.19477457f, 0.22970979f, -0.05803056f, -0.07437699f, 0.10366841f, 0.02858195f, 0.02359181f, 0.12850046f, 
    -0.13541308f, 0.18410124f, -0.24313048f, -0.16498187f, 0.04857764f, -0.03249006f, 0.13251664f, 0.01481740f, 
    -0.24144730f, 0.07803288f, -0.08273491f, 0.16390209f, 0.11743344f, 0.03564664f, 0.10912656f, -0.00604630f, 
    0.09249347f, 0.14819315f, 0.05347793f, -0.40461087f, 0.02186705f, 0.03457368f, 0.01773987f, -0.25904617f, 
    0.04345010f, -0.00562821f, -0.05151508f, 0.12504411f, -0.19206110f, 0.22400624f, 0.36710978f, 0.09941924f, 
    0.25731221f, -0.11390126f, 0.18811069f, 0.07739522f, -0.18018751f, 0.05845784f, -0.21731609f, -0.09062307f, 
    0.05042113f, 0.15469354f, 0.12235133f, 0.00865211f, -0.05913750f, 0.00601128f, 0.26854622f, -0.06959424f, 
    0.10455130f, 0.09862552f, 0.10468455f, -0.09705334f, 0.12027519f, 0.20258282f, -0.02179685f, -0.27367347f, 
    -0.09960870f, -0.24352182f, 0.10749410f, 0.18556264f, -0.08005921f, 0.05371930f, 0.05034565f, 0.16573782f, 
    -0.00879907f, 0.00661927f, -0.43296057f, 0.05020840f, 0.15604398f, 0.19808194f, 0.14959888f, -0.07894143f, 
    -0.07415244f, 0.28326753f, 0.08617813f, -0.01148213f, 0.26845178f, 0.01241609f, 0.08047836f, 0.17331572f, 
    0.13256244f, 0.02619972f, 0.21834649f, 0.17372850f, 0.15713418f, 0.01890693f, -0.09024806f, -0.05775892f, 
    0.03249983f, 0.06090642f, -0.00939701f, -0.45634317f, -0.32432681f, -0.02463247f, -0.26384830f, 0.10937046f, 
    -0.05486618f, -0.18093686f, -0.24856350f, 0.06636389f, 0.20216830f, 0.12156114f, 0.17081286f, -0.05438974f, 
    0.04661561f, 0.07013990f, -0.05970368f, 0.15804552f, -0.06219622f, -0.23033367f, -0.27370185f, -0.00274210f, 
    0.13000369f, 0.02719227f, 0.25282076f, -0.11250959f, -0.05624336f, -0.10282599f, -0.29210868f, -0.09889124f, 
    -0.13719417f, -0.04989601f, 0.07952736f, 0.02529011f, 0.10885452f, 0.05903456f, -0.18013987f, 0.36261621f, 
    0.32549298f, -0.05970686f, 0.02775575f, -0.11608152f, -0.00649115f, 0.23962358f, -0.00264212f, 0.03090852f, 
    -0.28460994f, -0.17627962f, -0.10275416f, -0.07793748f, 0.03184364f, -0.07978210f, -0.07777373f, 0.03810345f, 
    0.07230792f, -0.16247183f, -0.22520037f, -0.16826050f, 0.00132032f, 0.06829882f, 0.21063642f, -0.23804329f, 
    0.08471491f, -0.10612979f, 0.15097255f, 0.03130194f, 0.10643235f, 0.13978122f, -0.09655739f, -0.06261378f, 
    0.25560972f, 0.13335529f, 0.04152086f, -0.43393943f, -0.21827808f, 0.01853867f, -0.03157793f, -0.03671828f, 
    -0.07178999f, 0.00990661f, 0.00363133f, -0.07978056f, -0.23707169f, -0.10674191f, -0.19994324f, -0.05924623f, 
    0.02409986f, 0.24149479f, -0.10068174f, 0.06276356f, -0.12369013f, 0.05510827f, 0.18841524f, -0.17968799f, 
    -0.08332170f, -0.00637159f, 0.08148420f, -0.30309299f, -0.00556987f, -0.14577384f, 0.11992721f, -0.05739449f, 
    0.09634001f, -0.02127421f, -0.04807033f, -0.11787633f, -0.14141889f, -0.09317528f, 0.00054039f, -0.03982745f, 
    0.32111654f, -0.03079771f, 0.06625328f, -0.17201343f, 0.01418746f, -0.10555292f, -0.00924300f, 0.09150308f, 
    -0.24214309f, 0.32467610f, 0.02138053f, -0.03725938f, -0.14125417f, 0.00369932f, 0.01674161f, -0.04056673f, 
    0.02407750f, -0.04220142f, 0.06621917f, -0.01211038f, -0.02221905f, -0.05936887f, 0.10826579f, -0.36271465f, 
    0.01714598f, 0.06950598f, 0.55299699f, 0.19440582f, -0.20112054f, -0.24129860f, 0.08026482f, 0.11571617f, 
    0.16099019f, 0.04422979f, 0.14523259f, 0.10891247f, 0.06440411f, -0.01688426f, 0.21658228f, -0.05081099f, 
    0.13312098f, 0.06134829f, 0.04389416f, -0.11070609f, 0.33946729f, 0.01922098f, -0.06776568f, -0.14545600f, 
    -0.16198520f, 0.04169726f, -0.09276928f, 0.16986836f, 0.01505966f, -0.30419824f, 0.11972113f, -0.07308155f, 
    -0.09205746f, -0.08085946f, -0.04362519f, 0.02320376f, -0.13038628f, -0.05809424f, -0.17272726f, 0.04551798f, 
    -0.04197257f, 0.23808625f, -0.13000023f, 0.02055905f, -0.02261029f, 0.26786864f, -0.00593352f, -0.11231311f, 
    0.10250372f, 0.03462905f, 0.14335898f, -0.01931560f, 0.06702197f, -0.02894933f, -0.06796044f, 0.17577751f, 
    -0.18761730f, -0.16680269f, 0.03745062f, -0.00279281f, 0.19785191f, 0.06088769f, -0.09890911f, 0.00760363f, 
    0.01188043f, -0.19501884f, 0.01108665f, -0.10506611f, 0.15772367f, 0.13665012f, -0.05183481f, 0.04618545f, 
    -0.13172236f, 0.00986612f, 0.04732124f, -0.01263478f, 0.04315585f, 0.01312019f, 0.24462306f, 0.08994184f, 
    -0.25458044f, -0.01383529f, -0.06753802f, -0.21294494f, -0.12423625f, -0.09671748f, -0.04023145f, -0.02911382f, 
    0.20249803f, 0.08326329f, -0.03560068f, -0.13560298f, 0.20505415f, 0.27355972f, 0.01071346f, -0.12883963f, 
    -0.28776157f, -0.25010929f, 0.26409194f, 0.03552360f, -0.02268930f, -0.08297246f, -0.16775104f, 0.02672383f, 
    0.03212216f, 0.00173307f, -0.02350528f, -0.01067729f, 0.21466881f, 0.20764564f, 0.12116026f, 0.20757462f, 
    0.20859499f, -0.17179424f, -0.16274601f, -0.07090118f, 0.00899874f, -0.09697130f, -0.01633005f, -0.14498623f, 
    -0.26494247f, -0.30592671f, 0.17800759f, 0.08616012f, -0.05358099f, 0.02273025f, 0.05998382f, -0.09924251f, 
    -0.52972883f, -0.10732014f, -0.13099644f, 0.06386164f, 0.03132304f, -0.12067869f, -0.03583641f, -0.05076372f, 
    -0.16616143f, 0.15703689f, 0.17491594f, 0.26664117f, -0.27243453f, -0.03073200f, 0.11408238f, 0.00460853f, 
    -0.13819553f, 0.24697629f, -0.51829606f, 0.22600091f, -0.16321243f, -0.02099419f, 0.07565834f, 0.07213814f, 
    -0.06482989f, 0.13810730f, 0.01536446f, 0.36482540f, 0.03356703f, 0.25220585f, 0.16975833f, 0.22745834f, 
    -0.03534539f, 0.27734935f, -0.13363424f, -0.02186617f, 0.47617570f, -0.02010989f, 0.11834954f, -0.05307541f, 
    -0.15599599f, 0.27581605f, 0.17973153f, -0.13424349f, 0.00312585f, 0.03378197f, -0.17316718f, -0.23045200f, 
    0.10435575f, 0.15363041f, -0.07118260f, 0.05226891f, -0.08914080f, -0.15901899f, 0.00497971f, -0.13147283f, 
    -0.03816967f, 0.05634234f, -0.22989234f, -0.22609086f, 0.24670264f, 0.05922587f, 0.04324550f, -0.27655759f, 
    0.07890510f, 0.07693234f, -0.07303397f, 0.04506936f, -0.09843950f, -0.13865127f, -0.08649989f, -0.09576268f, 
    0.03747771f, -0.23517041f, 0.10934473f, 0.00633747f, -0.10637243f, 0.06308164f, -0.03189023f, -0.01951077f, 
    0.02633416f, 0.32752332f, -0.11106614f, 0.12685160f, -0.00721871f, -0.15016885f, -0.02979263f, 0.09815051f, 
    -0.04246308f, 0.04999052f, 0.58141005f, -0.11377782f, 0.02514961f, -0.37049434f, -0.01329091f, 0.23083071f, 
    -0.06073718f, -0.05786299f, 0.11017772f, 0.17999521f, 0.03351526f, 0.22395383f, 0.03757215f, 0.18475786f, 
    0.12511727f, -0.07309455f, -0.13548391f, -0.01182963f, -0.04131998f, 0.05404875f, -0.31170723f, -0.13429096f, 
    0.04542785f, 0.10252823f, 0.01426011f, 0.17411749f, -0.05526462f, -0.16790876f, -0.00736155f, 0.05813736f, 
    -0.03645475f, 0.00514262f, 0.01281871f, -0.26951528f, 0.00736380f, -0.11888087f, -0.15700911f, 0.34824374f, 
    -0.15337290f, -0.30313125f, 0.05525355f, 0.07783095f, 0.09797467f, 0.05646907f, 0.01497374f, 0.30371156f, 
    0.19198167f, 0.25366431f, -0.12820497f, -0.14671384f, 0.07385546f, 0.06829905f, -0.16287044f, -0.11747795f, 
    -0.10593598f, 0.16140087f, -0.70284522f, 0.02918174f, 0.08303045f, 0.08957856f, -0.06215980f, 0.03066790f, 
    0.01303623f, 0.10651685f, 0.11373725f, -0.08326878f, -0.03965190f, -0.09807757f, 0.01729523f, -0.06698597f, 
    0.26568761f, 0.00591651f, -0.23665352f, -0.41018343f, -0.12124962f, -0.00050809f, 0.01848294f, -0.15664174f, 
    -0.13698252f, -0.00792115f, 0.15788302f, -0.35865849f, 0.04210654f, -0.36095628f, -0.12246312f, 0.06575941f, 
    -0.04527625f, 0.03911564f, 0.10906715f, 0.06515963f, -0.00104391f, -0.25252843f, -0.55083978f, -0.13405471f, 
    -0.01404752f, 0.13058582f, -0.12610610f, -0.01870008f, -0.24273846f, 0.14890622f, 0.11021916f, -0.43245727f, 
    0.10219729f, -0.18125214f, 0.20944229f, 0.10083453f, 0.01385986f, -0.08003311f, -0.12281124f, 0.29267427f, 
    -0.34767389f, -0.09121431f, 0.11979248f, -0.23047091f, 0.00593905f, 0.05461594f, -0.04382414f, 0.43702978f, 
    0.14043920f, 0.03760111f, -0.09023547f, -0.09546071f, 0.05542149f, 0.03686056f, 0.10925749f, 0.14090431f, 
    0.35028312f, 0.13997848f, -0.18329343f, -0.02596910f, -0.01243646f, -0.04461770f, 0.03399381f, -0.00716975f, 
    0.21738145f, 0.28417781f, 0.20576246f, 0.12070411f, 0.16913661f, -0.01120536f, -0.01784588f, -0.12852351f, 
    0.01861317f, 0.03833623f, 0.28967223f, 0.38310322f, -0.06828500f, -0.07097594f, -0.18498914f, -0.12704317f, 
    -0.02604811f, 0.03275222f, 0.10654320f, 0.27601734f, 0.14407921f, 0.02466413f, 0.16321352f, -0.21972765f, 
    -0.02283134f, 0.16551575f, 0.03091244f, -0.23228413f, 0.12500495f, 0.08696210f, -0.40144750f, 0.11693455f, 
    0.33170971f, 0.13851972f, -0.06311169f, -0.09981991f, -0.02572630f, -0.08996614f, -0.22127523f, -0.05266121f, 
    -0.01220942f, 0.08504829f, 0.00167156f, 0.21366106f, 0.14641690f, -0.01336085f, 0.03826378f, 0.06147572f, 
    0.13366720f, 0.22033718f, 0.01133944f, -0.15247346f, -0.04883889f, -0.06179067f, -0.10379383f, -0.29782113f, 
    0.12708710f, -0.01557988f, -0.05543867f, -0.01481256f, 0.07282927f, 0.08308633f, 0.03167078f, 0.23575576f, 
    -0.11681920f, -0.51524389f, -0.18147621f, -0.10288119f, 0.11068599f, 0.05042950f, 0.05040317f, -0.04554639f, 
    -0.06660669f, 0.08500859f, 0.13381560f, -0.27974480f, 0.13182735f, -0.06941444f, -0.00834388f, -0.17918350f, 
    0.08674636f, -0.04235468f, -0.39706692f, 0.27850956f, 0.01667154f, -0.03749301f, 0.07918490f, 0.09723143f, 
    -0.13148986f, -0.06630631f, -0.07384918f, 0.38465855f, 0.22018047f, -0.07930909f, 0.15124017f, 0.19504562f, 
    0.09193382f, 0.11708490f, -0.10179535f, 0.09707707f, -0.40607426f, -0.22028147f, 0.39766437f, -0.14845885f, 
    0.11199599f, -0.05807965f, -0.02726674f, 0.12159398f, 0.04418559f, -0.06354658f, -0.60326761f, -0.23505376f, 
    0.17193492f, 0.12436428f, 0.11943589f, 0.11069161f, 0.13580517f, -0.20028420f, -0.21697897f, -0.00193981f, 
    -0.00279655f, 0.06884707f, -0.18805657f, -0.15650250f, -0.11926548f, 0.03286784f, 0.21840508f, -0.44519961f, 
    0.32460380f, -0.13687350f, 0.04380741f, -0.02662369f, 0.12841608f, 0.15245578f, -0.05226955f, -0.10527572f, 
    0.44477838f, -0.33067983f, 0.31176984f, -0.29259077f, -0.24615662f, -0.12213281f, 0.19440018f, 0.09378406f, 
    0.12111216f, -0.11613238f, -0.24152361f, -0.02065731f, 0.16115229f, 0.00460291f, 0.03358686f, -0.00803878f, 
    -0.03724468f, 0.05763459f, 0.24868004f, -0.26202881f, 0.08842288f, -0.26236308f, 0.14231318f, 0.00502265f, 
    -0.01908790f, 0.05931118f, 0.01833497f, 0.37579036f, -0.02953095f, -0.01762985f, 0.16797793f, -0.15135136f, 
    0.19923149f, 0.09681647f, 0.07360493f, 0.14057997f, 0.10082716f, 0.08647379f, -0.22849396f, -0.03664358f, 
    0.00818950f, -0.07483781f, -0.07370337f, -0.01027227f, 0.00701660f, -0.04283506f, 0.16695392f, 0.31423247f, 
    -0.11724453f, 0.09437821f, 0.00142966f, 0.09087652f, 0.25466588f, -0.21628433f, -0.81577778f, -0.08372750f, 
    -0.06375432f, 0.00981678f, -0.04343649f, -0.10656491f, 0.22479568f, 0.04353951f, 0.22425535f, -0.66262943f, 
    0.06986787f, -0.24837080f, -0.01210434f, -0.01771088f, -0.12107738f, 0.06768951f, 0.08057375f, -0.10136617f, 
    -0.01404990f, 0.02288965f, -0.04819942f, -0.03643579f, 0.00129099f, -0.02501069f, 0.04826252f, -0.06547162f, 
    -0.05891924f, 0.02028004f, 0.03385575f, 0.02768364f, 0.04412201f, -0.00422888f, 0.01571093f, -0.01919113f, 
    -0.05216988f, -0.01988769f, 0.01388232f, 0.00848261f, 0.00313217f, -0.00748748f, 0.04260895f, -0.04103656f, 
    -0.08846466f, -0.06198406f, -0.03736845f, -0.01199735f, -0.05396639f, -0.04574547f, -0.03187499f, 0.00831746f, 
    -0.04421515f, 0.04539743f, -0.00800407f, 0.01725675f, -0.00318703f, -0.01922603f, -0.06587055f, -0.06292651f, 
    -0.02823778f, 0.04345721f, 0.00776327f, -0.02885415f, -0.02081353f, -0.06350064f, 0.01332573f, 0.03523726f, 
    -0.01563203f, 0.00657184f, -0.00898876f, -0.00797968f, 0.04078325f, -0.01943213f, 0.03642452f, -0.07908438f, 
    -0.05771961f, -0.01266027f, 0.04350344f, -0.05780665f, 0.00137065f, 0.08291510f, -0.01314013f, -0.06885904f, 
    -0.05153894f, 0.02176489f, 0.03613270f, 0.01125968f, -0.05314581f, -0.05951641f, 0.01718305f, 0.01342587f, 
    0.01417776f, 0.00025971f, -0.02965738f, -0.02136418f, -0.01449524f, 0.03139902f, 0.02211884f, 0.03653495f, 
    -0.05883344f, -0.01444846f, 0.01611364f, -0.04891380f, 0.03815646f, -0.01003056f, -0.00274677f, -0.06058292f, 
    0.00564544f, 0.04171311f, -0.05940562f, -0.04610232f, -0.03558379f, 0.03445638f, -0.00918654f, -0.06158504f, 
    -0.00875557f, 0.00607304f, -0.02416546f, 0.02735150f, 0.00848818f, -0.01383747f, 0.01752297f, -0.06648029f, 
    0.01290214f, 0.04041339f, -0.00662643f, -0.02099366f, -0.06756617f, 0.06712840f, -0.05785754f, -0.07562280f, 
    -0.01457074f, -0.02652099f, -0.03846312f, -0.03977222f, 0.02397596f, -0.04405063f, 0.02285486f, -0.00341814f, 
    0.01696070f, -0.04776831f, 0.04066304f, -0.06602806f, -0.04264870f, -0.07031011f, -0.02701809f, -0.06007181f, 
    0.03634351f, -0.00642559f, 0.01641494f, -0.06990074f, 0.02479984f, -0.05959572f, -0.05591701f, 0.00882705f, 
    0.02120541f, 0.02254925f, -0.00072557f, -0.03651676f, 0.04764448f, 0.04381491f, -0.07729395f, -0.06949068f, 
    0.01748018f, 0.04556320f, -0.06078863f, 0.00982142f, -0.03595663f, 0.01007038f, -0.01359620f, -0.02193724f, 
    -0.05918236f, 0.00202898f, 0.02640610f, -0.04817155f, -0.04867192f, 0.03683358f, -0.03801290f, 0.03602872f, 
    0.03283903f, -0.03693508f, -0.00907616f, -0.03886302f, 0.01959365f, -0.06526347f, 0.05379356f, 0.01304351f, 
    0.03431988f, -0.05120049f, -0.04756631f, -0.02419388f, 0.01401195f, -0.05039606f, -0.01230074f, 0.07194474f, 
    0.01840681f, 0.00830668f, -0.04235101f, -0.01711328f, -0.01337674f, -0.01098832f, -0.03140653f, -0.05291978f, 
    -0.01439957f, -0.05848487f, 0.03414816f, -0.05013594f, 0.05361091f, -0.02291717f, 0.00859555f, -0.07291359f, 
    0.00152371f, 0.06162507f, -0.03303268f, -0.04983531f, -0.04714528f, -0.06234777f, -0.02258432f, 0.04387905f, 
    -0.06425466f, -0.05491669f, 0.01241203f, -0.02852382f, 0.03849196f, -0.03982535f, 0.00957902f, -0.01460475f, 
    -0.05991745f, -0.03007992f, -0.05757280f, -0.01373995f, -0.02664135f, -0.02811147f, -0.04216450f, -0.03495814f, 
    -0.02829540f, -0.02224717f, 0.03621882f, 0.04178073f, -0.04175238f, 0.01656340f, -0.05323750f, 0.02002661f, 
    -0.00002286f, 0.04342325f, -0.05795166f, -0.00721083f, -0.03453436f, 0.02498061f, 0.04229960f, 0.05354023f, 
    -0.01288494f, -0.04747551f, -0.03148447f, 0.06603660f, 0.00640452f, -0.01018477f, -0.04582436f, -0.04453284f, 
    -0.02163143f, -0.04722315f, -0.01631696f, -0.02566517f, -0.03922764f, -0.06488250f, 0.04088648f, -0.03446918f, 
    0.04508514f, -0.00770470f, -0.02757445f, -0.04695902f, 0.02833032f, 0.04554435f, -0.07431591f, -0.02909072f, 
    -0.01024309f, 0.00676254f, -0.05478096f, 0.02713057f, -0.04603978f, 0.04778431f, -0.05195975f, -0.04144016f, 
    0.04137906f, 0.04371270f, 0.02283831f, -0.08597469f, 0.03117233f, 0.00060644f, -0.01932672f, -0.06564610f, 
    -0.02117395f, 0.01729047f, -0.02261721f, -0.02619516f, 0.04264266f, -0.05483529f, -0.00645242f, 0.07497700f, 
    0.03820391f, -0.00705184f, 0.02267686f, -0.01474735f, 0.03431351f, -0.04056675f, -0.00852332f, -0.00395994f, 
    -0.04951978f, 0.14576520f, 0.22794078f, 0.26949358f, -0.03788750f, 0.04169467f, -0.05226200f, 0.01871103f, 
    -0.13520390f, -0.27177340f, -0.16964690f, -0.09450444f, 0.00325037f, -0.11365494f, 0.00327977f, 0.13545015f, 
    0.04820431f, 0.03329759f, 0.26538223f, 0.23395263f, -0.04093219f, 0.02614362f, -0.12638660f, 0.01176673f, 
    -0.00834632f, -0.04468185f, -0.15158726f, -0.08786644f, -0.21261127f, -0.34661776f, -0.06479075f, -0.00706855f, 
    0.08610065f, -0.01605853f, 0.27273178f, -0.03463072f, 0.20950855f, -0.06017961f, -0.18393494f, -0.15507483f, 
    -0.00062789f, 0.05819176f, 0.18992467f, 0.03658725f, 0.12610497f, -0.23533483f, 0.10988810f, 0.20240732f, 
    -0.05230656f, 0.05201701f, 0.00855267f, 0.05057547f, -0.20778021f, -0.08946170f, -0.08958694f, 0.23279662f, 
    0.41900605f, -0.13983737f, 0.00788015f, 0.05352935f, 0.11554118f, 0.02787229f, 0.10933707f, -0.33347228f, 
    0.33932623f, 0.45308074f, 0.10717058f, 0.00872189f, -0.13144237f, -0.13313009f, 0.07158768f, -0.07846402f, 
    -0.26596320f, 0.09377111f, 0.03731970f, -0.00104373f, 0.00039585f, -0.06100699f, 0.04418288f, 0.00371827f, 
    0.13905664f, -0.01135258f, -0.26622176f, 0.01127088f, 0.02090807f, 0.16684677f, 0.12427790f, 0.05408461f, 
    0.18211460f, 0.20873040f, -0.28606844f, 0.37763456f, 0.06551979f, 0.27310696f, 0.04856926f, -0.15606755f, 
    0.05060460f, -0.09624576f, -0.06613569f, -0.49475399f, -0.05391253f, -0.02271657f, 0.02347235f, -0.07413626f, 
    -0.02447152f, -0.04549069f, -0.03669122f, -0.05292908f, 0.00640990f, -0.27056503f, -0.10607894f, -0.09442744f, 
    0.20707455f, -0.22146156f, 0.14888211f, 0.10122097f, 0.05466082f, 0.10108212f, -0.07468805f, -0.05987660f, 
    -0.07610426f, -0.15245569f, 0.08189134f, -0.02710377f, -0.10968027f, -0.04291024f, 0.03548776f, -0.18713993f, 
    -0.12229570f, 0.04736678f, -0.09737825f, 0.08146304f, 0.21722645f, 0.04465146f, -0.06356209f, 0.22747415f, 
    0.17689683f, 0.21992716f, 0.01212676f, 0.03676202f, -0.17475957f, -0.08910126f, 0.02443399f, -0.05581978f, 
    0.10325661f, 0.25598663f, 0.00768748f, -0.01874430f, -0.16423362f, -0.07302847f, 0.00019026f, -0.31110668f, 
    0.22348744f, -0.09408919f, -0.23995529f, 0.01575975f, 0.07631365f, 0.09140392f, -0.00481121f, 0.12814274f, 
    0.04366275f, 0.13803555f, -0.17172053f, -0.13093500f, 0.08519536f, -0.16982563f, -0.05215916f, -0.15650038f, 
    0.14440495f, -0.06985926f, -0.03816045f, -0.25352439f, 0.02449282f, 0.01980582f, 0.14488430f, 0.28761432f, 
    -0.13583389f, -0.11843441f, -0.08713066f, -0.07195400f, 0.25103807f, -0.07357954f, -0.20921564f, -0.08506986f, 
    -0.03562737f, -0.01985065f, 0.19190854f, -0.15879144f, -0.00684410f, 0.20241745f, 0.21117570f, 0.02380987f, 
    0.09351469f, -0.01533968f, 0.03697820f, -0.07949261f, -0.00952465f, -0.01182913f, 0.09982469f, 0.00973152f, 
    -0.10494054f, 0.04036653f, 0.09597681f, -0.28929943f, -0.04284725f, 0.14793055f, 0.04711214f, -0.11078895f, 
    -0.06883367f, 0.04842008f, -0.08869211f, -0.07824562f, -0.02171877f, 0.03311863f, -0.05565760f, -0.02146835f, 
    -0.25716522f, -0.27637851f, -0.25632226f, 0.00955700f, -0.02925185f, 0.01045878f, -0.00361843f, 0.03507601f, 
    0.06902542f, 0.11514078f, 0.01551002f, -0.03921460f, -0.00635540f, 0.07570461f, -0.07577421f, -0.08366780f, 
    0.10120773f, -0.04959015f, 0.01799356f, -0.17039077f, -0.07941785f, -0.03457509f, -0.00515804f, -0.17474329f, 
    0.16521937f, -0.09243800f, 0.22840992f, -0.20560631f, -0.09074817f, -0.04566564f, 0.11272126f, 0.21353355f, 
    0.09223364f, 0.08547562f, 0.01802725f, -0.00875178f, 0.07526202f, 0.00780558f, -0.03011877f, -0.10674240f, 
    -0.20693414f, 0.23187254f, -0.06215268f, 0.06780256f, 0.22765827f, -0.06571605f, 0.16282552f, -0.09871554f, 
    -0.05928046f, -0.01175593f, -0.01606935f, -0.16334255f, 0.19210891f, -0.09605456f, 0.17938337f, -0.02856516f, 
    -0.05007259f, 0.04002821f, -0.11603743f, -0.05506082f, 0.22102344f, 0.06097515f, -0.08868642f, -0.00028215f, 
    0.09805898f, -0.36440718f, 0.00175451f, 0.21671644f, -0.01081712f, 0.04028600f, -0.02019866f, 0.08575734f, 
    0.25865743f, -0.39521343f, 0.11281849f, 0.05316504f, 0.10225550f, 0.14253221f, 0.11156178f, -0.02513444f, 
    0.00411346f, -0.18701981f, 0.15513866f, 0.18900032f, 0.12656964f, 0.08451717f, 0.02259114f, 0.07854467f, 
    -0.11280257f, 0.01254238f, -0.63360202f, -0.26552421f, -0.08013987f, 0.20674287f, 0.02068077f, -0.00112431f, 
    -0.01391601f, -0.13667727f, -0.03052544f, -0.17686678f, 0.02085325f, 0.10036214f, 0.18025535f, 0.22101055f, 
    -0.05860882f, 0.08709078f, -0.09175482f, 0.07951058f, -0.07547482f, 0.12514824f, -0.24943906f, 0.13951708f, 
    0.09788143f, 0.00974088f, 0.20122077f, -0.26245403f, 0.06093691f, 0.30452734f, -0.12956151f, -0.34863308f, 
    -0.00883263f, 0.26889366f, 0.12653702f, 0.15422697f, 0.14938213f, 0.00939894f, 0.38776863f, -0.00868481f, 
    -0.00027547f, 0.02195414f, 0.11942409f, -0.04130772f, -0.09857375f, 0.06060432f, -0.04872344f, 0.10115526f, 
    0.17810044f, 0.07450512f, 0.02844582f, -0.10475418f, 0.06677477f, -0.15236668f, -0.13303284f, -0.01577479f, 
    0.25681233f, 0.21930970f, 0.07564421f, -0.16610830f, -0.01461932f, 0.18899265f, -0.07410479f, -0.07527755f, 
    -0.03483495f, 0.09813270f, 0.04555395f, 0.06978353f, 0.11839709f, -0.00326015f, 0.02927981f, -0.10353594f, 
    -0.17064987f, 0.01368191f, 0.19638920f, 0.02435216f, 0.05965953f, 0.01826561f, 0.07919995f, 0.12870319f, 
    -0.04995052f, 0.02157303f, -0.16619821f, -0.01112019f, -0.09460841f, 0.17554016f, -0.07133974f, -0.21080282f, 
    -0.01185315f, 0.09648339f, 0.11091359f, -0.11352850f, -0.28396493f, -0.00705800f, 0.17001800f, 0.21907730f, 
    0.13517690f, 0.09612297f, 0.10698341f, -0.18681180f, -0.02260205f, -0.01412592f, -0.36234245f, -0.43905395f, 
    0.07322447f, 0.22258252f, 0.17018591f, 0.10651192f, 0.01520348f, 0.02701990f, 0.14057423f, -0.17089534f, 
    -0.19259800f, -0.13259675f, -0.01388415f, 0.22121236f, 0.13532272f, 0.09623960f, 0.12913129f, -0.49840367f, 
    0.17437376f, -0.01899393f, 0.05700877f, -0.07680929f, -0.04960698f, 0.11914954f, 0.04904167f, -0.04616788f, 
    0.03142023f, -0.29138649f, -0.60801387f, 0.09487671f, 0.13017485f, 0.04042359f, -0.14803016f, -0.00827150f, 
    -0.13878445f, 0.40293148f, -0.16721490f, -0.19799705f, 0.00409956f, 0.00499249f, -0.11317627f, -0.04076357f, 
    -0.16530207f, 0.16578032f, 0.16134736f, 0.15584621f, 0.08435715f, 0.00046030f, 0.01235531f, 0.05929606f, 
    -0.11900329f, -0.03316765f, 0.00013470f, 0.03149559f, -0.09744389f, -0.00773139f, 0.06593803f, -0.09983596f, 
    0.04253174f, -0.25307336f, 0.00154250f, 0.18769079f, -0.39398766f, 0.07978136f, 0.09418562f, 0.07715319f, 
    0.11622787f, 0.13231204f, 0.08007149f, -0.16582182f, -0.25614908f, -0.17893790f, -0.36489642f, -0.31104127f, 
    0.05520982f, 0.15482122f, 0.09097423f, 0.17967522f, 0.11265015f, -0.14130320f, -0.04372243f, 0.04876240f, 
    -0.16757561f, -0.00542476f, 0.02003244f, 0.16584978f, 0.02975492f, -0.05778157f, 0.25250363f, 0.10600651f, 
    0.42901525f, -0.01754123f, 0.14163463f, 0.09580293f, -0.05181155f, 0.24732034f, -0.01603735f, 0.08852874f, 
    -0.20049945f, -0.20856909f, 0.06947330f, -0.09593830f, -0.02498217f, -0.11214560f, -0.00375686f, -0.11649302f, 
    0.04774257f, 0.10096458f, 0.24100620f, -0.16592798f, -0.02299828f, 0.03829833f, 0.09401709f, 0.04439391f, 
    -0.24444444f, 0.22468841f, -0.31653199f, 0.00274161f, 0.03660277f, -0.06241552f, 0.17008074f, -0.01112427f, 
    -0.24683720f, -0.05371209f, -0.19651195f, -0.03357202f, -0.11875381f, -0.01304796f, -0.10435040f, -0.02266965f, 
    -0.06940478f, 0.10415011f, -0.00129315f, -0.23206396f, -0.03885782f, -0.03738116f, 0.00751372f, 0.02749637f, 
    0.13472900f, 0.11315379f, 0.02345265f, 0.03596076f, -0.24107577f, 0.04626247f, 0.25439683f, 0.13366558f, 
    -0.36396769f, 0.04347002f, 0.11448511f, 0.11579605f, -0.05760783f, 0.04247773f, -0.06211748f, -0.02302377f, 
    -0.31281367f, 0.04813701f, -0.03354206f, -0.08700003f, 0.04915694f, -0.17215282f, -0.23962137f, -0.53032917f, 
    0.21845189f, -0.16951248f, -0.10863420f, 0.13522960f, 0.03774314f, 0.10641206f, -0.20884979f, -0.09867980f, 
    0.00184358f, -0.01806359f, 0.00480893f, -0.04389111f, -0.04473811f, -0.01306599f, -0.05377156f, 0.00423921f, 
    0.02423327f, 0.04974909f, 0.04764247f, -0.00048438f, -0.03112336f, 0.00573779f, 0.01344630f, 0.01017206f, 
    -0.00975777f, -0.06155603f, 0.04624999f, -0.05633015f, 0.04383374f, -0.01586369f, -0.05797094f, -0.04496066f, 
    -0.03535566f, 0.03541225f, -0.00450627f, 0.03465405f, -0.00384428f, -0.03306173f, 0.04222475f, -0.04548619f, 
    -0.00302462f, 0.00610870f, 0.01128833f, 0.02560892f, -0.04118074f, -0.01474459f, -0.05590038f, -0.04495380f, 
    -0.03357478f, -0.04575805f, 0.01488368f, 0.02676184f, -0.01109766f, 0.00960305f, 0.01549864f, -0.03126637f, 
    -0.06594125f, -0.01710507f, -0.05263174f, 0.01190793f, -0.04020270f, -0.06141061f, 0.03984369f, 0.02539884f, 
    0.02914482f, -0.01213784f, 0.01779883f, -0.00472589f, -0.03300676f, 0.01658453f, -0.03201862f, -0.05837660f, 
    0.00781122f, 0.00223285f, -0.00279589f, -0.04514082f, -0.01934838f, -0.03208243f, 0.02734843f, 0.00843585f, 
    -0.02484442f, 0.03408625f, -0.04454342f, 0.02361697f, 0.04243230f, -0.01756059f, -0.02020106f, -0.03986665f, 
    0.02036677f, 0.03988997f, 0.03006046f, -0.06384432f, -0.01943419f, 0.04337345f, -0.01393685f, -0.02950587f, 
    -0.02940850f, 0.05096801f, 0.03394237f, -0.02923441f, -0.02560149f, 0.01744012f, 0.04711884f, -0.00509995f, 
    -0.03942338f, 0.02008765f, 0.03316049f, -0.03756189f, -0.02084258f, 0.01122194f, -0.02982725f, -0.03866735f, 
    -0.02659201f, 0.02554248f, 0.04995238f, 0.04760355f, -0.04853408f, 0.04185556f, -0.02324681f, 0.03689383f, 
    -0.00770205f, -0.05919412f, -0.03217024f, 0.00982233f, -0.00061898f, 0.01589873f, -0.01629320f, 0.03977544f, 
    -0.00634138f, -0.01464476f, -0.06572760f, -0.04402606f, 0.04909226f, -0.02989361f, -0.06015185f, -0.02845329f, 
    -0.04408707f, -0.01248586f, 0.02747875f, 0.01926027f, -0.03756313f, -0.06452733f, 0.01215292f, 0.04466997f, 
    0.04906471f, -0.00480374f, 0.02035767f, -0.02829909f, 0.00082065f, 0.04890311f, -0.05535993f, 0.03555501f, 
    0.03251517f, 0.03371816f, -0.03827111f, 0.01006650f, 0.03174188f, -0.02829506f, 0.02441195f, -0.00509053f, 
    -0.01923007f, 0.01555087f, -0.05895971f, 0.01808747f, -0.06708449f, -0.05744846f, -0.01541569f, -0.05685235f, 
    -0.03784512f, -0.03547950f, -0.00901614f, -0.02354172f, -0.04783052f, 0.04518772f, 0.03628884f, 0.01766741f, 
    0.04076077f, -0.05924711f, -0.04946453f, 0.03094256f, -0.00836561f, -0.03198208f, 0.01746527f, -0.05767989f, 
    -0.06307901f, -0.01282019f, 0.03536584f, -0.05490683f, -0.00211395f, -0.01524055f, -0.01074436f, -0.06859955f, 
    -0.00563932f, 0.04749157f, -0.03301276f, -0.04390302f, 0.00108493f, -0.00133784f, -0.04142382f, -0.02713745f, 
    0.00413239f, -0.02482979f, 0.03991117f, 0.04578977f, -0.06093108f, -0.00105425f, 0.04039777f, 0.03207605f, 
    -0.02757680f, -0.06524333f, -0.00964279f, -0.02218500f, -0.03014723f, 0.00397638f, -0.06260059f, 0.04328326f, 
    -0.00619582f, -0.05101248f, 0.04626302f, 0.02397250f, 0.02290631f, -0.00584729f, -0.04901288f, -0.04679872f, 
    -0.04137115f, 0.01025374f, -0.01665723f, -0.00948547f, -0.01301047f, -0.02802916f, 0.03425416f, -0.05954455f, 
    -0.00127157f, 0.01453035f, 0.02882183f, -0.05325843f, -0.04224075f, -0.02230203f, -0.03105535f, 0.03183758f, 
    -0.03058107f, -0.05593253f, 0.00487247f, -0.04815128f, -0.01574378f, -0.04953147f, -0.05677593f, -0.01807405f, 
    0.02204915f, 0.04442073f, -0.02911553f, 0.00957714f, -0.00324150f, 0.00947871f, 0.04218826f, -0.04089435f, 
    0.01935805f, -0.03979099f, -0.03692824f, -0.02262883f, -0.05376528f, -0.06674411f, -0.06093886f, -0.04435343f, 
    -0.01966611f, -0.03621522f, -0.04703665f, 0.04465502f, -0.01751881f, 0.03288926f, 0.00384690f, 0.00502025f, 
    -0.03988655f, 0.01644454f, -0.06519397f, -0.04580503f, 0.02371978f, 0.00046950f, -0.03680203f, 0.01489687f, 
    -0.00757479f, -0.05684286f, 0.02744529f, -0.02451636f, -0.01020510f, -0.04964616f, -0.02707541f, 0.03100098f, 
    -0.06056219f, 0.00211611f, 0.00466296f, -0.01711659f, 0.03693239f, 0.04005075f, -0.04033770f, -0.04401718f, 
    -0.00526624f, 0.12493750f, -0.20830944f, 0.07889356f, 0.03109500f, -0.09134249f, -0.02748604f, -0.09498139f, 
    0.00962111f, -0.16609031f, 0.05703012f, 0.01640633f, -0.00926777f, 0.03393957f, -0.07104124f, 0.07007986f, 
    0.02708629f, 0.25604618f, 0.11368454f, -0.11465480f, -0.11042197f, 0.00845035f, 0.30208954f, 0.03764929f, 
    0.07675744f, -0.14040379f, 0.01460870f, -0.26934555f, 0.13506317f, 0.21142936f, -0.05834325f, -0.05137846f, 
    -0.05288494f, 0.03439209f, -0.22316580f, 0.16729160f, -0.49535301f, -0.59510553f, 0.29806727f, -0.12623492f, 
    -0.00993104f, -0.00242897f, -0.03134651f, -0.13232233f, 0.17531569f, -0.03850212f, 0.02071141f, -0.26425332f, 
    0.01985903f, 0.06065460f, -0.07505205f, -0.16798900f, -0.08148469f, -0.19439586f, -0.07901299f, 0.12040485f, 
    0.08506822f, 0.04314066f, 0.13867603f, 0.08557155f, 0.06822351f, -0.12546624f, -0.25523829f, 0.31523737f, 
    0.26502883f, -0.02829183f, -0.02619192f, 0.04001426f, -0.00023834f, -0.04125997f, -0.03942941f, 0.10133109f, 
    0.30976310f, 0.05987616f, -0.06022894f, -0.00855659f, -0.04624249f, -0.01602280f, -0.03433273f, -0.01737282f, 
    0.15881819f, 0.05993225f, 0.13265803f, 0.06863655f, 0.33284953f, 0.02687326f, 0.10558842f, 0.03367059f, 
    -0.06720644f, 0.17658912f, 0.21589470f, 0.17883955f, -0.11674622f, 0.10913494f, -0.05666740f, 0.13945924f, 
    0.11562254f, -0.05223338f, 0.04996441f, 0.39552605f, 0.18393061f, 0.01286615f, 0.08825497f, 0.23189668f, 
    0.11541177f, 0.30588955f, 0.02796411f, 0.02789880f, -0.06811605f, -0.03122351f, -0.12361596f, -0.06398604f, 
    -0.02140103f, 0.05954326f, -0.26541305f, 0.04080372f, 0.07476813f, -0.17068678f, 0.02380560f, -0.20108445f, 
    0.01605275f, 0.01154809f, -0.10289822f, -0.06421693f, 0.00699514f, 0.09855933f, -0.37873036f, -0.34517035f, 
    0.06081748f, 0.03603667f, 0.05654621f, 0.01347127f, 0.03037566f, -0.20010382f, -0.04323609f, -0.07422681f, 
    0.12511396f, -0.06206705f, 0.01998351f, -0.02301632f, 0.12269864f, 0.27903143f, 0.28340054f, 0.18655419f, 
    -0.35841197f, -0.21586756f, -0.07447901f, 0.06486884f, -0.04294169f, 0.04183612f, 0.03978543f, -0.07418501f, 
    0.23981418f, -0.38367933f, 0.20346449f, 0.15276951f, 0.01664431f, -0.06498875f, -0.08980545f, -0.06457176f, 
    -0.08502334f, -0.06408571f, -0.09376985f, -0.01059768f, 0.00755477f, -0.13684486f, -0.02809337f, 0.02665548f, 
    -0.03802434f, 0.23468931f, 0.09592428f, 0.38879889f, 0.14098375f, -0.50153190f, 0.02041699f, 0.17016847f, 
    -0.01235411f, 0.00921979f, 0.02327674f, -0.16615622f, -0.22639932f, -0.43856823f, -0.03656125f, 0.03837087f, 
    0.16596092f, -0.15498725f, -0.15351713f, 0.04116756f, 0.04802556f, -0.27131456f, 0.03227306f, -0.22562946f, 
    0.02874724f, 0.13182101f, 0.27902099f, 0.04321088f, -0.09880816f, 0.01058792f, -0.08416095f, -0.03737834f, 
    -0.36389813f, -0.02225004f, 0.16257699f, 0.00091594f, 0.26222256f, -0.22423996f, -0.12851246f, -0.31403506f, 
    -0.13976188f, 0.12031496f, -0.06214186f, -0.06027692f, -0.07312819f, 0.01498868f, 0.11813860f, -0.03806454f, 
    0.38015342f, 0.33032405f, 0.29624030f, 0.09257375f, -0.06630426f, -0.25232688f, -0.13053626f, 0.11140961f, 
    0.08203246f, -0.12351357f, -0.04156112f, -0.20854661f, 0.04908462f, 0.07915826f, 0.01388134f, 0.01781533f, 
    -0.03036159f, -0.12509990f, -0.20094764f, -0.28724867f, 0.26763725f, -0.02490312f, -0.01493884f, 0.06926361f, 
    -0.07729287f, 0.13632031f, -0.00090664f, 0.48699290f, 0.11968254f, -0.20827305f, 0.07703555f, 0.03065785f, 
    0.03114611f, -0.06973108f, -0.04793474f, -0.03289668f, 0.31390089f, 0.12183167f, 0.36039743f, 0.07857919f, 
    0.02325807f, 0.06988025f, 0.15619802f, 0.34396997f, 0.06156164f, 0.14837801f, 0.07852703f, -0.07161234f, 
    0.02921335f, -0.06501453f, -0.03047634f, -0.02256693f, 0.13965724f, -0.00854100f, -0.19541439f, -0.02371234f, 
    0.07223648f, 0.01699596f, 0.06959306f, -0.09642427f, -0.12911132f, 0.06870697f, 0.18923287f, -0.23057330f, 
    -0.27370265f, 0.13674466f, 0.08254186f, 0.22902414f, -0.01617738f, -0.06520691f, -0.08777375f, 0.08952598f, 
    -0.05989631f, -0.01996644f, -0.01089311f, 0.02374824f, 0.00571311f, -0.05281449f, -0.00350385f, 0.04620524f, 
    0.02774546f, 0.03325288f, 0.03628539f, 0.03304866f, -0.02927682f, 0.02066658f, 0.01770161f, -0.04562771f, 
    0.03719153f, 0.01397761f, -0.00100015f, 0.02892020f, 0.04897217f, -0.06389629f, 0.04339286f, 0.01255805f, 
    -0.05024938f, -0.03615345f, -0.01356418f, -0.06101214f, 0.01606014f, -0.03530532f, 0.04797535f, -0.03742153f, 
    -0.04922277f, 0.02142004f, 0.02587532f, -0.02770204f, -0.03548767f, -0.04971953f, 0.02402024f, -0.03941223f, 
    0.04021414f, -0.00228547f, 0.04562461f, -0.00190972f, 0.02313594f, -0.02800918f, 0.05035546f, -0.05821466f, 
    -0.02525436f, -0.01665430f, -0.05144001f, -0.00905420f, 0.04491434f, -0.04554763f, 0.02022398f, -0.05765390f, 
    -0.00920850f, -0.04928169f, -0.02098097f, -0.01986523f, -0.04132405f, -0.05419228f, 0.00391835f, 0.04378351f, 
    -0.04773061f, -0.01577049f, 0.04528459f, -0.03147812f, -0.04478379f, -0.04094559f, -0.01534633f, -0.00033559f, 
    0.01885312f, 0.01314293f, -0.01296544f, 0.00400685f, -0.00227377f, 0.03965541f, -0.03986263f, -0.04898805f, 
    0.05348473f, -0.00619456f, 0.02370966f, 0.00012362f, -0.02311286f, -0.01299928f, 0.00301552f, -0.05733326f, 
    -0.06421392f, 0.01850669f, -0.00423705f, -0.02594412f, 0.03489015f, 0.04172792f, 0.02432170f, 0.05104113f, 
    0.04538808f, -0.01261311f, -0.03077462f, 0.03029361f, 0.03295027f, -0.02905967f, 0.03756892f, 0.04267209f, 
    -0.06137586f, -0.03306487f, -0.03215095f, 0.00980255f, -0.01332736f, -0.02989043f, -0.05139802f, -0.00166472f, 
    0.03646301f, 0.04195615f, -0.00074875f, -0.06404104f, -0.05860509f, -0.02124279f, -0.04680441f, 0.01261039f, 
    0.01428107f, -0.05650092f, -0.04640480f, -0.00652244f, 0.00045953f, 0.03340550f, 0.02967831f, 0.02286232f, 
    -0.02223346f, -0.04791326f, -0.01485875f, 0.02865932f, 0.04088000f, 0.04161415f, -0.00453203f, -0.06137026f, 
    0.01152453f, -0.02432203f, -0.02226521f, 0.02404728f, 0.02483829f, -0.03988556f, 0.00961198f, -0.05753869f, 
    0.00901230f, -0.04221839f, -0.02260744f, -0.00315321f, -0.01611356f, 0.01640540f, 0.01681794f, 0.02775006f, 
    0.01608780f, -0.04990309f, -0.05652580f, 0.04645095f, 0.00227482f, -0.05683471f, 0.01945141f, -0.05395721f, 
    -0.04228393f, -0.03521364f, -0.00851397f, -0.00199823f, -0.00024355f, 0.02763453f, 0.03823716f, -0.00235025f, 
    0.00792881f, 0.03306993f, -0.03086613f, 0.04344396f, -0.06374644f, 0.01644278f, -0.04043978f, -0.00357905f, 
    0.00679812f, -0.06421296f, -0.00854213f, -0.03254800f, -0.03191321f, -0.05385482f, -0.05254417f, -0.00180375f, 
    0.05008583f, -0.05564927f, 0.04104115f, 0.04939779f, -0.00940794f, -0.00469712f, -0.04159457f, 0.01899219f, 
    0.01857913f, -0.05206980f, 0.01935473f, 0.01002667f, -0.04879958f, 0.04967422f, 0.01237067f, -0.04570548f, 
    -0.01327247f, -0.02684690f, 0.01013346f, -0.02534492f, -0.05267213f, -0.04594146f, -0.03423829f, 0.04449068f, 
    -0.06150411f, -0.02662315f, 0.01034310f, -0.00338071f, -0.04512054f, -0.04475666f, 0.01139380f, -0.01579710f, 
    -0.00241131f, 0.00153379f, -0.00022769f, 0.02108859f, -0.00293678f, -0.04931072f, 0.04606407f, 0.03731876f, 
    -0.00460773f, -0.03747214f, -0.03103306f, -0.05783091f, -0.01600518f, -0.03112063f, -0.04863643f, -0.05211515f, 
    -0.00759362f, -0.03079605f, 0.04651288f, 0.01659235f, 0.03571529f, -0.03493579f, -0.05277695f, -0.02961136f, 
    -0.00299621f, 0.03360282f, 0.04139945f, 0.01649394f, 0.05135163f, -0.00529514f, -0.02198799f, 0.04118389f, 
    -0.04419373f, -0.05315332f, -0.02100947f, -0.03128485f, -0.02853137f, -0.04681799f, -0.01380960f, 0.02677156f, 
    -0.01137801f, -0.04904398f, -0.03324511f, -0.05694575f, -0.01230379f, 0.05714750f, 0.00407194f, -0.04302051f, 
    0.01505812f, -0.01849663f, -0.04097736f, -0.04593845f, 0.00291264f, 0.03116248f, -0.04176970f, 0.01786058f, 
    -0.02863996f, -0.01873764f, -0.05219002f, 0.00471324f, 0.01362969f, -0.02012817f, -0.01670120f, -0.04827850f, 
    -0.01823782f, 0.02051009f, -0.04822512f, -0.06241870f, -0.04120576f, 0.02035921f, -0.05476803f, 0.01823353f, 
    0.17299226f, 0.11384051f, -0.10485145f, -0.10501469f, 0.04838753f, -0.00324609f, -0.14676669f, 0.10109499f, 
    0.04362009f, -0.22093509f, -0.18528843f, 0.06493665f, -0.06490553f, 0.11075895f, -0.00609891f, 0.02400066f, 
    0.14122519f, -0.31177703f, 0.39998829f, 0.15280823f, 0.22958657f, 0.01756233f, -0.07567427f, -0.18725647f, 
    -0.06351411f, -0.00303587f, 0.02279796f, -0.14652689f, -0.02527098f, 0.10571590f, -0.02733193f, -0.06474701f, 
    -0.13178048f, -0.01398094f, 0.05264923f, -0.16283289f, 0.17472576f, 0.32457522f, -0.09290098f, -0.42070967f, 
    0.06698009f, -0.10538193f, 0.10079369f, 0.08006784f, -0.06362212f, -0.23531324f, -0.13360193f, 0.14408882f, 
    -0.21723376f, -0.09372105f, 0.08491187f, -0.03043325f, -0.17774127f, 0.13520528f, 0.10825478f, 0.00719473f, 
    0.14616151f, -0.12597440f, -0.06021582f, -0.20494132f, -0.20773011f, -0.02230632f, -0.06558138f, -0.43177029f, 
    -0.03330339f, -0.02468010f, 0.11491673f, 0.09624062f, 0.08283710f, 0.23944946f, 0.10617398f, -0.07734889f, 
    -0.57325858f, 0.37452859f, -0.05542562f, -0.06832135f, 0.01747041f, 0.09198779f, 0.20320906f, -0.18439372f, 
    0.13262916f, -0.27907357f, 0.06652471f, -0.08266067f, 0.05879568f, 0.21615435f, 0.04793417f, -0.01925167f, 
    -0.10951582f, -0.29639620f, -0.25844076f, 0.11793542f, 0.26545045f, 0.09495259f, 0.05732276f, -0.01546602f, 
    -0.06259440f, -0.30918723f, -0.18406646f, -0.57391512f, -0.23936047f, 0.02982393f, 0.24080803f, 0.09483406f, 
    -0.06320201f, -0.11224888f, 0.05081745f, -0.08895905f, 0.18895867f, 0.03439098f, 0.16600081f, -0.28051370f, 
    0.14482306f, 0.04520128f, -0.05580360f, 0.12697661f, -0.30590823f, 0.07805926f, -0.15429151f, 0.10551898f, 
    0.02752666f, -0.10447778f, 0.16989878f, -0.03640572f, -0.01856059f, 0.24509075f, 0.39210841f, 0.25744352f, 
    -0.10748767f, 0.02455352f, -0.06054607f, -0.06297731f, 0.10596731f, 0.25604564f, -0.06861333f, 0.33764660f, 
    0.12768666f, 0.27393922f, 0.05740019f, 0.18359892f, -0.10241973f, -0.03956726f, -0.11945233f, -0.09400563f, 
    0.15264444f, 0.22499269f, 0.14323407f, -0.18513201f, -0.03130486f, -0.01774439f, -0.12126061f, 0.04699313f, 
    0.07395136f, 0.31377882f, 0.08271310f, -0.05053502f, 0.03377025f, 0.15242293f, 0.11668734f, 0.02644687f, 
    0.07652029f, 0.14871587f, 0.15568961f, -0.01351673f, -0.03908107f, -0.22028759f, -0.00750874f, -0.12673618f, 
    0.11099090f, -0.04083458f, -0.18022978f, -0.16041702f, 0.12623572f, 0.08268024f, 0.24970587f, 0.13482235f, 
    -0.25472966f, -0.06085088f, -0.01648735f, 0.12826885f, 0.21399759f, 0.19044270f, -0.11294487f, -0.12163994f, 
    0.17141843f, 0.12745968f, 0.11415378f, 0.01949505f, 0.01753225f, 0.03567376f, 0.24672137f, -0.03731105f, 
    0.07271369f, 0.13483836f, -0.19045442f, 0.02656174f, -0.19924960f, 0.19020185f, 0.09656184f, 0.02536233f, 
    0.03418316f, -0.21278323f, -0.35289791f, -0.22368439f, -0.02943185f, 0.23701812f, 0.05083658f, 0.09252099f, 
    -0.01185852f, 0.06252937f, -0.25832516f, 0.00577596f, -0.13408083f, 0.09544459f, -0.14742775f, -0.11588933f, 
    -0.41552562f, -0.07821650f, -0.16455133f, 0.11885075f, -0.14499588f, 0.20060934f, -0.15786313f, -0.01513220f, 
    -0.09595200f, 0.27426970f, 0.13851337f, 0.11208839f, -0.07251268f, 0.16327634f, 0.11825312f, -0.06293117f, 
    0.07002836f, 0.21122442f, 0.19737877f, 0.16024473f, -0.05310578f, -0.07544658f, 0.10462976f, 0.18731906f, 
    0.08027944f, 0.01938345f, 0.12890887f, -0.05686662f, -0.01227315f, -0.06507871f, 0.18984862f, 0.05042216f, 
    0.00154225f, 0.05855333f, 0.14922889f, 0.13822548f, 0.00187721f, 0.10039690f, -0.07738465f, 0.07345834f, 
    -0.03140443f, 0.19350719f, -0.07273836f, -0.00224420f, 0.03101963f, -0.15047501f, -0.09643374f, 0.04647717f, 
    0.03358902f, 0.14922906f, -0.15104470f, -0.28964108f, 0.18598033f, 0.01154141f, 0.23576161f, -0.04196168f, 
    -0.04112011f, -0.35803887f, -0.00118185f, 0.24485832f, 0.09990662f, -0.05715443f, -0.12563860f, 0.19454123f, 
    0.17365371f, -0.18697236f, -0.30263916f, 0.05183693f, 0.24779542f, 0.01387066f, -0.12630513f, -0.08123416f, 
    -0.37925705f, 0.02138176f, 0.24521106f, -0.06101045f, -0.13862209f, -0.08412845f, -0.18204392f, 0.12521489f, 
    0.08588091f, -0.08802896f, -0.22448979f, -0.09672114f, 0.16411044f, 0.05710654f, 0.18082128f, 0.11722679f, 
    -0.06865872f, 0.02440980f, -0.32196039f, 0.09617428f, -0.33681196f, 0.29537889f, 0.09504443f, -0.02495484f, 
    0.03216227f, 0.11189806f, -0.05640862f, -0.12499665f, -0.17884742f, 0.05833336f, 0.14945538f, 0.23359951f, 
    0.21431592f, -0.02232014f, -0.20203184f, -0.15765750f, 0.09519568f, 0.23808397f, -0.00226863f, -0.04407783f, 
    0.03829925f, 0.14281885f, -0.19065760f, -0.10166949f, -0.24931380f, 0.09889640f, -0.10630712f, 0.22120933f, 
    -0.25200996f, -0.21900247f, 0.09586570f, -0.07388127f, 0.08077180f, 0.08549953f, -0.02186429f, -0.06177506f, 
    0.17808647f, -0.08157273f, -0.15613587f, -0.00592018f, -0.07541833f, -0.06972310f, 0.03195022f, 0.37208450f, 
    0.21793608f, -0.17016087f, 0.12081768f, 0.02441899f, -0.08175096f, -0.10416406f, 0.08937512f, -0.05027540f, 
    -0.07159451f, 0.27413198f, -0.13173296f, 0.11303051f, -0.13136820f, 0.10570872f, 0.15156935f, -0.14259647f, 
    0.05765028f, -0.23026520f, -0.06275249f, -0.20106781f, 0.04847569f, -0.10958868f, 0.23152193f, 0.13148981f, 
    0.06738988f, -0.13087013f, 0.43171662f, 0.22340934f, -0.30062291f, 0.05376396f, -0.00939974f, -0.05039600f, 
    0.17170075f, -0.03732282f, 0.13271821f, 0.10539283f, -0.56778562f, -0.15341449f, 0.15340993f, 0.24075325f, 
    -0.03470893f, -0.09034070f, 0.12564796f, -0.05119497f, -0.15852404f, -0.18173027f, 0.11616001f, 0.01889574f, 
    0.08062079f, 0.15007824f, 0.03192610f, -0.27187672f, -0.02488295f, -0.06038089f, -0.26677823f, 0.16445965f, 
    -0.10429271f, -0.07074463f, 0.19523267f, -0.12391319f, 0.11203410f, -0.01553175f, -0.22951943f, -0.17405230f, 
    0.19516961f, -0.06678204f, -0.03609212f, 0.17101072f, -0.11525846f, 0.04426616f, 0.12196817f, -0.13193682f, 
    -0.09437211f, -0.21911776f, -0.05899389f, -0.03843348f, -0.10958541f, 0.24876843f, -0.08924769f, 0.12127027f, 
    -0.34908462f, 0.08770154f, -0.11916218f, -0.02241559f, -0.23929046f, 0.02040781f, 0.02985125f, 0.14136517f, 
    -0.03533026f, -0.20223343f, -0.03135110f, 0.20953535f, 0.19115281f, 0.12868890f, -0.14685184f, -0.03957835f, 
    -0.00507307f, 0.10069335f, 0.19499090f, 0.17657548f, -0.05469919f, -0.00800868f, 0.05856366f, -0.06007959f, 
    -0.13830742f, -0.05018664f, 0.05503622f, 0.35817334f, 0.32059002f, -0.15799704f, 0.18343641f, -0.04614246f, 
    -0.04934517f, 0.04324589f, 0.06501777f, -0.11720403f, 0.08141231f, -0.29432499f, -0.22949427f, -0.00886182f, 
    0.15792936f, 0.02272202f, -0.14110424f, 0.12081837f, -0.03709982f, -0.43043682f, 0.15343867f, -0.16085878f, 
    -0.03621112f, -0.19393757f, 0.16664276f, 0.01398218f, -0.07822595f, -0.10114109f, -0.06637999f, 0.14139551f, 
    -0.01742621f, 0.00430895f, -0.21552490f, 0.01944069f, 0.25215152f, -0.08748586f, -0.15326314f, 0.17062311f, 
    0.03168037f, 0.17065065f, -0.04747049f, -0.04026837f, 0.07632024f, -0.02701389f, 0.01203446f, 0.12233025f, 
    0.10848551f, 0.28310880f, 0.24803084f, 0.16002688f, -0.00526109f, -0.07860507f, 0.10141093f, -0.00953722f, 
    -0.14520833f, 0.00273638f, 0.11014088f, 0.01690529f, 0.01088049f, 0.01561579f, 0.09453116f, -0.06456710f, 
    0.04707295f, 0.07344003f, -0.07957453f, -0.21440662f, -0.00543512f, 0.24092245f, 0.20271973f, 0.18794802f, 
    -0.10721780f, 0.01691495f, 0.20479918f, 0.13501853f, 0.28084406f, 0.06830183f, 0.13441208f, 0.07071886f, 
    -0.25911805f, -0.13398117f, 0.04876481f, -0.12918253f, -0.10036810f, -0.10674008f, 0.02933775f, -0.08566782f, 
    0.11395004f, -0.01781836f, -0.12512416f, -0.00954697f, -0.01170635f, 0.41089544f, -0.02890667f, -0.26376173f, 
    0.02801193f, 0.10681062f, -0.08456708f, 0.07036658f, -0.00326871f, -0.13825616f, 0.05245546f, 0.15370463f, 
    -0.09240457f, -0.01756665f, 0.07812088f, 0.01626423f, 0.00720482f, -0.01020185f, -0.02294165f, -0.42545617f, 
    0.15807956f, 0.05554131f, 0.01136225f, 0.07437462f, 0.04099124f, -0.12734804f, -0.12216151f, -0.06184097f, 
    0.00409669f, 0.15012646f, 0.14378569f, -0.04377996f, -0.15685838f, -0.11230124f, -0.10601367f, 0.14992267f, 
    0.05593581f, -0.21858719f, -0.10602315f, -0.22198284f, 0.04819331f, -0.08650147f, 0.02926105f, 0.13564694f, 
    0.25050446f, -0.01395975f, -0.13387057f, -0.09197231f, 0.00453509f, 0.07373850f, -0.04521465f, -0.28133523f, 
    0.09915525f, 0.09063718f, -0.09158412f, -0.06666322f, 0.06880209f, 0.07887021f, 0.21851970f, 0.06122150f, 
    0.12711553f, 0.04143936f, 0.14610085f, -0.20340125f, -0.12475237f, 0.06529560f, -0.09163025f, 0.20522580f, 
    -0.00860711f, -0.01282078f, -0.15672176f, 0.15955356f, -0.06461888f, 0.22867738f, -0.06161128f, 0.32102585f, 
    -0.05585504f, -0.08561900f, -0.06632042f, -0.06453668f, 0.04021042f, 0.00906193f, -0.31180596f, -0.21133699f, 
    0.22746499f, 0.08827205f, 0.06647910f, -0.25519821f, -0.05428816f, 0.02687138f, 0.10752815f, -0.11214700f, 
    -0.23707302f, 0.00889120f, -0.19364339f, 0.03296082f, 0.02812226f, 0.18299256f, 0.04530956f, -0.13117836f, 
    -0.19019404f, -0.10780030f, -0.08145145f, -0.08070721f, 0.22291403f, 0.02756680f, -0.01356834f, -0.03107210f, 
    0.09292652f, -0.09843822f, 0.04120489f, -0.14493820f, 0.09631537f, -0.11718785f, 0.06000951f, 0.08219104f, 
    0.17319757f, -0.21424910f, -0.02175671f, 0.05003878f, 0.04881879f, -0.00772574f, 0.01102617f, 0.05027263f, 
    -0.07278990f, 0.13722736f, -0.09589491f, -0.19480744f, 0.02705684f, 0.00547464f, 0.15261947f, -0.17066392f, 
    -0.04007995f, 0.13379730f, -0.03463309f, -0.15024555f, 0.18693635f, -0.02587866f, -0.23577999f, 0.12334063f, 
    -0.01994440f, -0.09621214f, 0.00684093f, 0.22269133f, 0.20068924f, 0.24156845f, 0.10765974f, 0.20523088f, 
    -0.05764671f, -0.03306828f, 0.03214215f, 0.18564798f, 0.10174494f, 0.18022309f, -0.02088340f, 0.10025131f, 
    0.24383703f, 0.18264729f, 0.00508479f, 0.16551343f, -0.07845375f, 0.00773226f, 0.19246863f, 0.13788219f, 
    -0.23017266f, -0.03714770f, -0.17080723f, 0.12659352f, -0.08925746f, 0.08459056f, -0.02918988f, -0.27978513f, 
    0.15627228f, 0.29158840f, 0.16946326f, -0.04725592f, -0.05589919f, 0.01372702f, 0.04402428f, 0.04785552f, 
    -0.04862022f, -0.12750827f, 0.05083847f, -0.06800090f, 0.00660237f, -0.03357992f, 0.03747863f, -0.02072302f, 
    0.08298692f, 0.06714708f, 0.13470072f, -0.12132082f, -0.05356482f, 0.30487221f, 0.13902223f, -0.06070259f, 
    0.01377095f, 0.02653666f, 0.00772627f, 0.09233321f, -0.14977907f, 0.04722312f, -0.00125868f, -0.09142443f, 
    0.02614801f, -0.04939789f, 0.03750660f, -0.13074771f, 0.00008200f, 0.20010218f, 0.03452906f, 0.03965320f, 
    0.01456617f, 0.11521915f, 0.11671950f, 0.12515925f, 0.04987099f, -0.23838997f, 0.11917259f, 0.17586789f, 
    0.31638864f, -0.13140064f, -0.23042984f, 0.03401524f, -0.04985292f, -0.04946378f, 0.02519794f, -0.13560440f, 
    0.10125939f, -0.11387935f, -0.10258988f, -0.03034455f, -0.12421746f, 0.03987485f, 0.10925563f, 0.26791191f, 
    -0.09336694f, 0.01013491f, 0.12977761f, 0.07139026f, -0.13775234f, 0.00885022f, 0.02541085f, -0.02113780f, 
    0.20419122f, 0.09502939f, -0.05056249f, 0.04220679f, -0.02413075f, -0.04027027f, 0.12609044f, -0.13541231f, 
    -0.00299719f, 0.12214085f, -0.05694179f, 0.07381283f, -0.10529483f, -0.08638676f, -0.10553863f, -0.09066369f, 
    0.01357981f, -0.10268178f, -0.22546868f, 0.33960420f, 0.09990945f, 0.16913000f, 0.15700580f, -0.04019945f, 
    0.03573721f, 0.14020923f, 0.08321357f, -0.16089508f, -0.14403357f, -0.03805728f, -0.12688093f, -0.11441021f, 
    -0.06748851f, -0.10385964f, -0.05874454f, 0.16753440f, 0.24362250f, -0.12260898f, -0.06694732f, 0.01219415f, 
    -0.18083610f, 0.13639334f, 0.20638692f, -0.11987905f, -0.06988176f, -0.52037477f, 0.10119241f, -0.13962266f, 
    0.21854262f, -0.23167443f, -0.02431472f, 0.09324005f, 0.05033367f, -0.01670942f, 0.03454451f, -0.04654568f, 
    -0.02339099f, -0.01312349f, -0.04124419f, -0.06610775f, -0.04683828f, 0.16560501f, 0.01396010f, -0.11760182f, 
    0.09264030f, -0.10431218f, 0.11901131f, -0.13739234f, 0.20823425f, -0.00619191f, 0.14626506f, -0.11039222f, 
    -0.07357062f, 0.14259988f, 0.07837957f, 0.19101226f, 0.01430242f, -0.49608317f, 0.09106689f, 0.17627724f, 
    0.20084897f, -0.24264522f, -0.10088241f, -0.04952014f, 0.15722631f, 0.04969566f, 0.11158524f, 0.10493715f, 
    -0.01404657f, 0.14151101f, -0.20638849f, 0.00927654f, -0.27901363f, -0.18883991f, -0.11628626f, 0.18388239f, 
    0.11112443f, 0.18641667f, -0.02182542f, -0.10896206f, -0.04457981f, -0.00401437f, 0.04499291f, 0.05639781f, 
    0.14837658f, 0.25333789f, -0.18306567f, -0.25987318f, -0.36145157f, -0.05984493f, 0.10031937f, -0.08194873f, 
    0.04679562f, 0.18878354f, 0.27977487f, 0.01091046f, -0.30932593f, 0.27773988f, 0.16522184f, 0.10196206f, 
    -0.11220316f, -0.07777906f, -0.11561523f, 0.02225008f, -0.16723514f, -0.08017527f, -0.07310229f, 0.20670055f, 
    0.24142176f, -0.09573694f, -0.00738734f, 0.06078030f, 0.11742341f, 0.14444195f, -0.06021902f, 0.01988795f, 
    0.17140277f, 0.00429573f, -0.03040798f, -0.10492891f, 0.07614126f, 0.11969773f, -0.06966329f, 0.08538178f, 
    0.15417463f, 0.19279431f, 0.01791096f, -0.12412032f, 0.16079661f, 0.00490015f, 0.08081646f, -0.12523974f, 
    -0.04872449f, -0.29954153f, -0.06020979f, -0.05649217f, 0.05962320f, -0.06264710f, 0.20287046f, -0.21602693f, 
    0.02021765f, -0.15370968f, 0.44492075f, -0.09737045f, -0.01276897f, -0.13332713f, 0.01573519f, 0.15692556f, 
    -0.12159153f, 0.12843901f, 0.13203351f, 0.02174809f, -0.18484522f, -0.10758479f, 0.06734605f, 0.26666290f, 
    0.08385514f, 0.01784948f, 0.14698775f, -0.09384085f, -0.07414974f, -0.35905898f, -0.21531048f, 0.01010637f, 
    0.13976504f, 0.01106461f, -0.11537414f, 0.02790870f, 0.14920813f, 0.02950585f, -0.07855470f, -0.03987281f, 
    0.24046429f, 0.04290291f, 0.07859163f, -0.18749745f, -0.07181497f, -0.00207488f, -0.01307399f, 0.24270214f, 
    0.20422602f, 0.03799465f, 0.20028403f, 0.02327316f, -0.01932575f, 0.04149407f, 0.29103675f, -0.24510425f, 
    -0.49937570f, -0.26534742f, -0.27445635f, -0.18793939f, 0.13632308f, 0.06539884f, 0.03537360f, 0.06508057f, 
    0.12474982f, 0.25891003f, 0.02766651f, -0.01044498f, -0.00618274f, 0.15268558f, -0.29459399f, 0.22256160f, 
    0.01695213f, -0.06716844f, -0.00971925f, 0.20907915f, 0.18292342f, 0.08695774f, -0.09487969f, 0.11389197f, 
    0.07452756f, 0.01208357f, 0.00543541f, 0.00254614f, -0.05974315f, 0.00022192f, 0.19465519f, -0.09578809f, 
    0.13598022f, 0.17048201f, -0.05158097f, 0.22394250f, -0.05027985f, -0.00075035f, -0.09066141f, -0.25660846f, 
    -0.15665108f, 0.10038256f, 0.08309910f, 0.00375836f, 0.04154067f, 0.04894038f, -0.04975556f, 0.08025198f, 
    0.06703179f, 0.12922029f, 0.09330381f, 0.19108269f, -0.09290364f, -0.04684140f, 0.00610742f, -0.03428670f, 
    -0.07390382f, -0.13417821f, 0.06646851f, -0.09853803f, 0.04616144f, -0.20967494f, 0.11815560f, -0.23151757f, 
    0.11964541f, -0.09269679f, -0.19217604f, -0.10980924f, 0.13879897f, 0.02592494f, -0.23726930f, 0.05748892f, 
    -0.08702884f, -0.00685798f, -0.04700975f, 0.19104801f, -0.00159630f, 0.13130115f, 0.11261907f, 0.06279440f, 
    0.18945043f, 0.39907980f, 0.15462638f, 0.28105226f, 0.02615919f, -0.07230601f, 0.11634008f, -0.05388560f, 
    0.01634581f, -0.12370156f, -0.12165821f, 0.11958272f, -0.14713122f, -0.10357804f, -0.30823532f, 0.12563476f, 
    -0.06823249f, -0.05573598f, -0.39658397f, 0.22481053f, 0.12804702f, 0.17530698f, 0.12700783f, 0.25159529f, 
    -0.08053201f, 0.19892940f, -0.14550069f, 0.15089047f, 0.10761216f, -0.07696395f, -0.11083993f, -0.11133044f, 
    -0.37370908f, 0.06504597f, 0.06277257f, 0.02946283f, -0.05805174f, 0.14493105f, -0.14546065f, -0.02489648f, 
    0.00954265f, 0.06517688f, -0.02019128f, 0.07293072f, -0.03090899f, -0.01785316f, -0.27882236f, -0.06995004f, 
    0.26035270f, -0.13932352f, 0.24763633f, 0.02150310f, 0.10111713f, -0.05577708f, -0.07153080f, 0.10534535f, 
    0.10598930f, -0.13653046f, 0.04838016f, -0.19711035f, 0.06062817f, -0.19211251f, -0.07425917f, -0.17231809f, 
    0.09656227f, -0.04762432f, 0.16328490f, 0.01214145f, -0.07513807f, 0.16334382f, -0.05766462f, 0.16840142f, 
    0.20541629f, -0.21859346f, -0.06731266f, -0.10268330f, -0.07875846f, -0.16053034f, 0.25938961f, 0.17634447f, 
    0.03864669f, -0.07748835f, -0.02516473f, -0.07600094f, 0.03811198f, 0.06376643f, 0.07887740f, 0.05181213f, 
    0.08970318f, 0.11150589f, 0.43471399f, 0.33567747f, 0.11994416f, -0.08348285f, -0.06303701f, 0.00266028f, 
    -0.09534740f, -0.01972114f, 0.00144399f, -0.15396589f, 0.03346496f, 0.05101520f, 0.11862914f, -0.03672681f, 
    0.14620963f, 0.12252370f, 0.19025306f, 0.07948252f, -0.16398799f, 0.05485165f, -0.18899290f, 0.04801697f, 
    0.03906702f, -0.13149518f, -0.06146097f, -0.17597821f, 0.00444118f, 0.13604252f, -0.06979427f, 0.18440530f, 
    0.09664402f, 0.07769744f, 0.02451623f, 0.01951154f, 0.11356460f, 0.08682829f, 0.11309281f, -0.00616503f, 
    -0.06544866f, -0.06325690f, -0.21928881f, -0.02103234f, 0.18810353f, 0.03431738f, -0.15084268f, -0.14354002f, 
    -0.16012838f, -0.03775238f, 0.16108437f, 0.05586654f, 0.12428378f, -0.12695758f, -0.18150973f, 0.12947717f, 
    -0.34629741f, -0.17898755f, 0.00504867f, 0.08972812f, 0.21176735f, -0.03954585f, -0.03866896f, 0.00478478f, 
    0.03368119f, -0.56915003f, -0.35770813f, 0.04336957f, 0.23311366f, -0.04732142f, 0.01260248f, -0.01589943f, 
    0.21974830f, 0.33336502f, -0.26333532f, -0.15694025f, -0.13818879f, 0.07757270f, 0.03842777f, -0.00551645f, 
    -0.05216533f, 0.06035572f, 0.03400109f, -0.69227046f, -0.33264190f, -0.27227548f, 0.00597037f, 0.04464710f, 
    -0.08105534f, 0.03182187f, 0.03569914f, -0.21141624f, 0.20289046f, 0.20582739f, 0.05919809f, -0.06819018f, 
    0.17840783f, -0.16190809f, 0.03039009f, 0.11868364f, 0.09195309f, -0.10992493f, 0.04436142f, 0.02370149f, 
    0.02795189f, 0.07094087f, 0.16472569f, 0.09197879f, 0.04840704f, 0.04687515f, 0.16525593f, 0.12472031f, 
    0.13255155f, 0.03488021f, -0.02795452f, 0.10541195f, 0.11526288f, -0.01364151f, 0.05522126f, -0.10505056f, 
    0.12792507f, 0.04531336f, -0.10873631f, -0.14385277f, 0.20094323f, 0.22364637f, 0.16424100f, 0.05810545f, 
    -0.09724431f, -0.19089055f, -0.00056977f, -0.11930528f, -0.00918226f, -0.00301800f, 0.19532020f, 0.15329735f, 
    -0.14094818f, 0.27864334f, 0.16516459f, 0.11952439f, -0.10282177f, 0.14463411f, -0.24992123f, -0.02756257f, 
    0.08295266f, -0.01914927f, 0.18405479f, -0.03560043f, -0.04254021f, -0.06586600f, -0.06373458f, 0.06877400f, 
    -0.00711265f, 0.14378211f, 0.09721223f, 0.38131836f, 0.05438925f, 0.12263463f, 0.01146255f, 0.14081718f, 
    -0.09274366f, -0.14104700f, 0.01389079f, 0.02050821f, -0.25621325f, -0.02596301f, -0.20101352f, 0.31531683f, 
    0.17422675f, -0.11794475f, 0.06219415f, -0.02774142f, -0.20937122f, -0.01792666f, -0.28875923f, 0.10237172f, 
    0.11621446f, -0.06000878f, 0.05066847f, 0.17818779f, 0.04730306f, -0.07914569f, 0.22277641f, 0.10526235f, 
    0.10833470f, -0.09303550f, 0.01048486f, 0.05273839f, 0.07486261f, 0.02492218f, -0.18318087f, 0.16505320f, 
    0.01513848f, -0.03003869f, -0.02825226f, -0.10263581f, 0.12957637f, 0.04654704f, -0.03725781f, 0.02225847f, 
    -0.40556797f, -0.33890402f, 0.06877106f, 0.01470156f, 0.05749741f, -0.13876125f, 0.10661647f, -0.15882255f, 
    -0.12666683f, 0.35404229f, 0.17044096f, 0.27479956f, 0.02424538f, -0.02861823f, 0.15788528f, 0.04536232f, 
    0.00681033f, -0.18689607f, -0.04988228f, -0.03390363f, -0.28317645f, 0.20090355f, 0.18103610f, -0.16476044f, 
    0.02357430f, -0.11192089f, -0.11079793f, 0.12084822f, 0.00110580f, 0.24246947f, 0.03446543f, -0.05763901f, 
    -0.02351455f, 0.00938389f, 0.04060184f, -0.29017952f, -0.20134190f, -0.05112838f, -0.02494048f, 0.04937103f, 
    -0.11765307f, -0.03905347f, 0.13001095f, 0.10561202f, 0.03431012f, -0.91918117f, -0.21089152f, 0.00288429f, 
    0.22855316f, -0.10565183f, 0.09474812f, -0.10643278f, -0.08149781f, 0.13091482f, 0.10313436f, -0.02907513f, 
    -0.14369401f, -0.15269104f, 0.08206952f, 0.13181630f, -0.21737915f, 0.02578278f, -0.15065777f, -0.20793813f, 
    0.07269884f, -0.20989104f, 0.00398706f, 0.05766938f, 0.02390129f, 0.01371268f, 0.04130894f, -0.12968409f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.04627858f, -0.00818980f, 0.02650419f, 0.03860566f, 0.03521212f, 0.05263550f, 0.00345346f, 0.03102824f, 
    0.08880061f, -0.16679546f, 0.13476396f, 0.01096925f, 0.24160717f, 0.04283831f, -0.09995031f, -0.06748700f, 
    -0.03042755f, -0.02172798f, 0.12390329f, -0.02144093f, 0.01797118f, 0.04842488f, -0.00066540f, 0.16328242f, 
    -0.02871703f, 0.06075357f, -0.02341972f, -0.01379587f, 0.05992952f, 0.00635937f, -0.06999604f, 0.17239703f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.47877082f, 0.59100384f, -0.06428070f, 0.11802327f, -0.07248314f, 0.08606827f, 0.12030954f, -0.31393149f, 
    -0.66577774f, -0.17332555f, -0.33930391f, 0.02268403f, -0.06404895f, 0.06186651f, 0.45032230f, 0.07364463f, 
    0.14478095f, -0.27234524f, 0.02035493f, 0.50994575f, 0.53424948f, -0.16609152f, -0.09243109f, -0.46352050f, 
    0.14463164f, -0.32263222f, -0.02182689f, 0.04426271f, -0.55204672f, 0.48771036f, -0.05325189f, -0.21521142f, 
    0.08243675f, 0.29540238f, -0.14486131f, 0.05327784f, -0.50744820f, -0.22691542f, -0.03604304f, 0.18294705f, 
    0.01560452f, 0.17217836f, 0.24532445f, -0.08969466f, -0.19329427f, 0.34963626f, 0.00256185f, -0.04354813f, 
    -0.07648548f, -0.25897336f, 0.56050301f, -0.53292876f, 0.44400933f, 0.06320333f, 0.21760771f, 0.85456145f, 
    -0.09163789f, -0.12050073f, -0.11049459f, -0.30608001f, -0.29319265f, -0.38102680f, -0.38732752f, -0.00174999f, 
    -0.26775008f, -0.28405720f, -0.16317505f, -0.14790116f, 0.31551293f, -0.01790000f, 0.13748322f, -0.01129141f, 
    0.61052275f, -0.67799497f, -0.45866856f, -0.07325315f, -0.10838354f, -0.03036394f, 0.96007359f, -0.73552448f, 
    -0.08751836f, -0.12392627f, 0.26936910f, 0.23011163f, -0.10957374f, 0.05918722f, 0.00723667f, -0.21799482f, 
    0.03173748f, 0.14792545f, 0.08226451f, 0.23308975f, -0.34468240f, -0.58123887f, -0.26953387f, -0.44006464f, 
    0.01240943f, -0.67289245f, 0.15798622f, 0.07896587f, -0.18308431f, 0.32464722f, 0.16723476f, -0.22800353f, 
    -0.17124780f, 0.59825981f, -0.44614890f, -0.13944556f, -0.30441934f, 0.18221954f, -0.60549957f, -0.18323095f, 
    -0.05218403f, 0.60478699f, -0.52483851f, 0.26531267f, -0.22612599f, -0.12140982f, 0.34284338f, -0.45044836f, 
    -0.11880107f, -0.46233958f, 0.11746143f, 0.36667013f, 0.26298973f, 0.20338131f, -0.09126125f, 0.11863220f, 
    -0.35383651f, 0.01986472f, 0.11815532f, 0.14664076f, -0.03507968f, -0.10315279f, -0.01929597f, 0.44302127f, 
    -0.34679896f, -0.39804608f, -0.69790226f, -0.07460938f, 0.60910118f, -0.21546511f, -0.51876903f, -0.09204188f, 
    -0.07860778f, -0.30316466f, 0.30357838f, 0.11667513f, -0.55431235f, 0.14071999f, 0.17342499f, 0.05960595f, 
    0.02726010f, -0.29919997f, -0.12987264f, 0.29455870f, 0.38116607f, 0.09457617f, -0.02988850f, 0.00374824f, 
    0.41589221f, 0.09160514f, 0.04480869f, 0.01848711f, -0.32394600f, 0.42323327f, 0.10281754f, -0.64327902f, 
    0.31353676f, 0.05839076f, 0.25565812f, -0.08055449f, 0.58133668f, -0.23740433f, -0.03428744f, 0.26033098f, 
    -0.09251961f, -0.29919371f, -0.10873988f, -0.28576165f, -0.18621430f, -0.15255728f, -0.44131142f, 0.04350005f, 
    -0.05660856f, -0.08006418f, 0.05162440f, -0.61533689f, -0.34083724f, -0.03209335f, 0.00807581f, 0.01065641f, 
    -0.14098805f, -0.30240837f, 0.10214450f, 0.02895245f, 0.12354176f, 0.45760801f, -0.17408720f, -0.13454108f, 
    -0.45102835f, -0.21136758f, 0.08271351f, -0.14582004f, 0.11587410f, -0.88478154f, -0.01655120f, -0.69355613f, 
    0.03833327f, 0.25810012f, -0.50987148f, -0.58149683f, 0.51203138f, -0.16192557f, 0.34985927f, 0.04003746f, 
    0.01305554f, 0.46389121f, 0.01514157f, 0.28629324f, -0.14999987f, -0.24428298f, 0.14621338f, -0.28090370f, 
    -0.40141934f, 0.25241542f, 0.01015797f, -0.08754735f, 0.23526300f, -0.01769132f, 0.09355327f, 0.13453810f, 
    -0.33848247f, 0.47768977f, -0.13356099f, -0.00315009f, -0.50382000f, 0.27704319f, 0.00187324f, 0.47319636f, 
    -0.06167071f, -0.72265911f, 0.12435111f, -0.25224265f, -0.16890697f, 0.00561832f, 0.38183537f, -0.51817888f, 
    0.14970547f, -0.59007895f, -0.05992351f, 0.15361668f, -0.40081140f, 0.14352089f, 0.30934581f, -0.19405527f, 
    0.31675208f, -0.10202280f, -0.02285054f, 0.02597862f, -0.24890590f, -0.51211786f, 0.03756785f, 0.73656279f, 
    0.07581717f, 0.59966618f, -0.42342421f, -0.10147925f, 0.02802760f, 0.62387866f, -0.33457774f, -0.04280832f, 
    0.00935115f, -0.34015763f, -0.12220189f, 0.41184103f, 0.21073660f, -0.15734099f, 0.01162064f, -0.27202967f, 
    0.07777572f, 0.29754931f, 0.04989310f, -0.57584250f, -0.06881762f, -0.47940081f, -0.43126723f, -0.33997259f, 
    -0.50935042f, 0.17832999f, -0.11257717f, -0.05922949f, 0.59767783f, -0.22190459f, 0.08458905f, 0.04500581f, 
    -0.18612458f, -0.12486578f, 0.93434906f, 0.13059749f, -0.16633265f, 0.59194428f, -0.20650394f, 0.25084701f, 
    -0.07336811f, -0.27620387f, -0.42801055f, -0.17976606f, -0.48104152f, -0.06366996f, -0.35393783f, -0.23756465f, 
    -0.11470123f, 0.29815963f, 0.15253209f, -0.16191770f, 0.30379230f, 0.25073656f, 0.11943676f, -0.11455964f, 
    0.42727518f, -0.39165512f, 0.08680830f, -0.13383226f, -0.40457568f, -0.58074987f, -0.06069044f, -0.10509126f, 
    0.49090970f, -0.35263011f, -0.21410245f, -0.06635407f, -0.42613775f, -0.10829373f, -0.02544131f, 0.67093235f, 
    -0.02953704f, 0.13549210f, 0.10487118f, 0.25075236f, -0.43656802f, -0.09044285f, 0.25511774f, -0.05460443f, 
    0.03499150f, 0.23534736f, -0.13814077f, 0.16412832f, -0.17592393f, -0.33736768f, -0.17983183f, 0.69859475f, 
    0.02530885f, -0.32161391f, -0.00587285f, 0.16185129f, 0.08172613f, -0.31561801f, 0.12625517f, 0.01586987f, 
    0.13784073f, -0.12299842f, -0.59738606f, -0.04873873f, -0.50577849f, -0.91475320f, -0.16437550f, -0.55788225f, 
    -0.00650447f, 0.33893785f, -0.37361372f, 0.10218023f, 0.12648360f, -0.09231550f, -1.03221142f, 0.32733604f, 
    -0.08613274f, 0.25671431f, 0.03654906f, -0.11942171f, 0.81318033f, 0.24032351f, 0.61493140f, 0.32365334f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10780331f, -0.15438558f, -0.19164616f, -0.20841530f, 0.24479273f, 0.09809941f, 0.02229011f, -0.11583427f, 
    0.02061557f, -0.13741070f, 0.16769308f, 0.11831667f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
