#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.94104683f, -0.08424251f, 0.71597439f, 0.35452044f, 0.22907102f, 0.20643455f, 0.64118719f, 0.77554184f, 
    -0.55584788f, -0.59855986f, 0.02178891f, -0.25229892f, 0.22234607f, 0.15767342f, -0.06918668f, -0.03795596f, 
    0.33650643f, 0.21922126f, 0.01222728f, 0.20744987f, 0.01728143f, 0.13643904f, -0.29826352f, -0.06352747f, 
    -0.39497551f, 1.01810110f, 1.07994986f, -0.40378085f, -0.53833348f, -0.86296713f, -0.36056560f, -0.09092528f, 
    -0.47682557f, -0.23912594f, -0.06124563f, 0.00831645f, 0.30191287f, -0.03067527f, 0.24967334f, 0.20753349f, 
    -0.18881877f, -0.06829747f, 0.29330912f, 0.01225056f, -0.13419507f, 0.29225701f, -0.22784773f, -0.13570903f, 
    0.08847161f, -0.13181348f, -1.66404200f, 0.41372317f, 1.03701437f, -0.55684561f, -0.56663799f, 0.67404872f, 
    0.38848898f, -0.02169556f, 0.28548792f, 0.08318792f, -0.05446161f, 0.20050275f, 0.09701832f, 0.04732465f, 
    0.12427931f, -0.13785082f, 0.01444309f, 0.14441112f, -0.09364309f, -0.28071082f, 0.29605523f, 0.16757362f, 
    0.26177534f, 0.20766450f, 0.08315033f, 0.21182905f, -0.43027589f, -0.02278367f, 0.16768257f, 0.83740211f, 
    -0.86472505f, -0.29485908f, 0.27282384f, -0.87529206f, -0.29408145f, 0.13495643f, 0.52233899f, -0.18919522f, 
    -0.06626908f, 0.37599134f, -0.34296817f, -0.02737856f, 0.25003991f, 0.39863941f, -0.03120555f, -0.28039837f, 
    0.05934312f, -0.31987730f, -0.16359064f, -0.10647987f, -0.69801569f, 0.47750783f, -0.84394222f, -0.62230277f, 
    0.04368556f, 0.46788087f, -0.48848942f, -0.95986879f, 0.23502305f, -0.21197183f, -0.40543270f, -0.25396943f, 
    -0.04750308f, 0.45365316f, -0.25159270f, 0.17172334f, 0.04997607f, 0.30828422f, 0.24433640f, 0.01456272f, 
    0.34095332f, -0.13303520f, -0.00547145f, -0.00074885f, 0.20108195f, 0.92417967f, 0.57034361f, 0.96121436f, 
    0.46169522f, 0.75492162f, 0.35125262f, -0.25799739f, -0.23781960f, -0.32250822f, -0.46509606f, 0.47013173f, 
    0.03198516f, -0.21256427f, 0.10818204f, 0.18076468f, 0.12480465f, -0.03412430f, -0.19491410f, 0.25312236f, 
    0.27321267f, 0.08390540f, -0.04487128f, 0.33769932f, 0.19338691f, 0.21074153f, -0.04660321f, 0.07905425f, 
    -0.49660769f, -0.92988110f, -0.35225371f, 0.18085742f, -0.52855456f, 0.57219166f, 0.67619222f, -0.23864500f, 
    -0.30274883f, -0.08246920f, -0.11459879f, -0.26504439f, -0.50150138f, -0.10494538f, 0.18022080f, 0.43684375f, 
    0.11512742f, 0.27892640f, -0.21980287f, -0.18650547f, -0.37560359f, -0.16012646f, 0.18653469f, 0.93519461f, 
    0.53096902f, -0.18927820f, -0.41771278f, 0.12120219f, 0.57665098f, 0.34413189f, 0.50047964f, 0.63729304f, 
    0.57563788f, 0.13881250f, 0.52450031f, -0.39691910f, -0.12079071f, 0.21644458f, -0.17993136f, -0.20864402f, 
    -0.15538438f, 0.23913212f, -0.08450974f, 0.13999853f, 0.04424548f, -0.03406815f, 0.07959931f, 0.22690392f, 
    -0.93595994f, 0.05315706f, 0.30735344f, -0.08184816f, 0.39760664f, -0.41459739f, 0.66122478f, -0.27837014f, 
    -0.62107515f, 0.38663960f, 0.07943231f, 0.45434600f, 0.45914060f, -0.44378769f, -0.11011380f, 0.18081723f, 
    0.09388532f, 0.09218340f, 0.29399234f, -0.16581708f, 0.22791521f, -0.25469944f, 0.22479230f, 0.26991075f, 
    -0.12932301f, -0.31164980f, -0.85904354f, -0.85482997f, -0.53105378f, -0.07568066f, 0.39417762f, 0.54325968f, 
    -0.24507889f, 0.34555155f, 0.53952336f, 0.21062090f, 0.04513177f, -0.21091729f, 0.08275910f, 0.17657942f, 
    -0.13751166f, 0.00352559f, 0.41054857f, -0.11799482f, -0.00485575f, -0.11326838f, -0.23772162f, -0.35586673f, 
    -0.22852343f, 0.05550102f, 0.45896602f, 0.65752578f, 0.57579094f, 0.65244025f, 0.63057107f, 0.31762749f, 
    -0.37686658f, -0.71283633f, -0.10867427f, -0.32835585f, 0.12682380f, 0.19806351f, 0.26059723f, 0.08138076f, 
    0.07081947f, 0.02892556f, -0.13373055f, 0.03146700f, -0.06468602f, 0.10790287f, 0.34680408f, 0.39032111f, 
    -0.27037770f, -0.14117523f, 0.54809260f, 0.47726914f, 0.43719605f, 0.71431154f, 0.75499183f, -0.03176599f, 
    -0.19959840f, -0.54974705f, 0.42923439f, 0.40606958f, 0.54524982f, 0.16723119f, 0.36244580f, -0.33444226f, 
    0.06623649f, 0.13358919f, 0.23932736f, 0.05794452f, -0.21582747f, -0.49989173f, -0.32154542f, 0.57331562f, 
    0.05453679f, -0.04157760f, -0.10360024f, -0.07976721f, -0.40417773f, 0.81728244f, -0.33735251f, -0.85708308f, 
    0.07729766f, -0.61799473f, -0.35049418f, -0.45349291f, -0.85202265f, -0.39190811f, 0.33113047f, 0.37116283f, 
    0.01047151f, -0.01227826f, -0.11467884f, 0.12139887f, 0.03860680f, -0.16023688f, 0.15796211f, 0.31855059f, 
    0.34266382f, 0.11297866f, 0.16581199f, 0.08912422f, 0.40359420f, -0.78952843f, -0.82848650f, -0.40126479f, 
    -0.42786324f, -0.50011849f, 0.46014172f, 0.74474543f, -0.37565422f, -0.28261834f, 0.43859246f, -0.02508276f, 
    0.25216457f, 0.09907692f, 0.41902015f, 0.66573679f, -0.26418322f, -0.15686607f, -0.49432248f, 0.06289510f, 
    0.17746873f, -0.11828345f, -0.21892940f, 0.12393103f, -0.23628595f, -0.20222680f, 0.33827862f, 0.68616140f, 
    0.17685345f, 0.88987058f, 0.11717911f, 0.18181670f, -0.43540874f, -0.42985269f, -0.39078361f, -0.07705882f, 
    -0.00600785f, 0.30797479f, 0.01791076f, 0.02827422f, 0.21207908f, 0.21184301f, 0.24519701f, 0.28724471f, 
    0.05013607f, 0.60719270f, 0.31129724f, -0.33577064f, -0.04896937f, 0.10685748f, 0.06151488f, 0.77845329f, 
    -0.18258467f, -0.02360981f, 1.11195171f, 0.70460099f, 0.34280092f, 0.65953422f, 0.47446743f, 0.21516834f, 
    0.39565426f, -0.41448721f, -0.16143052f, -0.00673243f, 0.03640805f, 0.07006178f, -0.36749539f, -0.45690250f, 
    0.15479879f, -0.13851966f, -0.06897659f, 0.31819120f, -0.06372781f, -0.14245108f, -0.02886474f, -0.10276108f, 
    -0.50627589f, 0.17611292f, 1.08206689f, 0.35264266f, 0.54682583f, 0.73635805f, 0.35244247f, 0.55080593f, 
    0.38319594f, -0.22659226f, 0.22864528f, 0.01755688f, 0.04467279f, -0.22887972f, -0.20434542f, -0.24773440f, 
    -0.25987953f, -0.05513851f, -0.01857024f, -0.03709394f, -0.27865314f, -0.22761267f, -0.16860944f, 0.06133522f, 
    -0.07570842f, -0.73329180f, -0.60629731f, 0.40707231f, -0.04366858f, 0.57087636f, 0.49294510f, 0.74796492f, 
    -0.84226120f, -0.38592258f, -0.64410204f, 0.19749399f, -0.28515810f, 0.02645512f, -0.28941330f, -0.02536553f, 
    0.08126353f, -0.02211886f, -0.29201987f, -0.29898489f, -0.39759424f, -0.10082211f, 0.25118515f, 0.14920536f, 
    0.21070145f, 0.03036255f, 0.08490440f, -0.14854032f, -1.15050042f, 1.17732728f, 0.62208319f, 0.32603732f, 
    0.23828205f, -0.65558571f, 0.40750492f, -0.22401550f, 0.05445896f, 0.06268199f, -0.30078977f, -0.17940238f, 
    -0.26569664f, 0.12985468f, 0.21859312f, 0.00198171f, -0.13236828f, -0.14867105f, 0.09238294f, -0.25782138f, 
    -0.15618230f, -0.06661144f, -0.12366269f, 0.80973232f, 0.86696571f, 0.25033778f, -0.62404060f, -0.76659143f, 
    0.33636227f, 0.52252102f, -0.36502334f, -0.04880103f, -0.04754245f, -0.10262796f, 0.27971339f, -0.02781865f, 
    -0.03193972f, 0.21999483f, -0.03088242f, -0.05739040f, -0.18530023f, -0.29156491f, -0.33742353f, -0.22797619f, 
    0.28928912f, 0.04315593f, -0.08291024f, -0.13363180f, -0.51239759f, -0.61685818f, 0.01102508f, -0.66247469f, 
    -0.42835611f, 0.60108620f, -0.51125193f, -0.42451751f, -0.45600945f, -0.42465913f, -0.04745813f, -0.33558476f, 
    -0.18568304f, 0.01302736f, 0.27567226f, 0.06027704f, 0.07871058f, -0.37691143f, 0.04813103f, 0.20897888f, 
    0.35360941f, 0.01941586f, -0.05009732f, 0.41948432f, -0.13313083f, 1.18710518f, 0.10997225f, 0.23415397f, 
    1.19633150f, 0.32614741f, 0.31604230f, 0.23198256f, -0.37189487f, -0.05870596f, -0.18487990f, -0.37396562f, 
    0.27709070f, -0.00890337f, 0.28180256f, -0.29311371f, 0.00451999f, 0.32385570f, 0.11100798f, 0.15615050f, 
    -0.02178798f, -0.00211300f, 0.20194051f, 0.00537300f, -0.11441412f, 0.00929467f, -1.08652449f, 1.23322725f, 
    -0.85263145f, 0.58990920f, -0.34251967f, 0.49645218f, 0.65846235f, -0.57558298f, -0.02571897f, 0.48764905f, 
    -0.18652928f, -0.26635173f, 0.03036902f, -0.38794753f, 0.18222955f, 0.29893059f, -0.01409203f, -0.13777417f, 
    0.12596180f, -0.14839874f, 0.19173405f, 0.00381349f, 0.11416230f, -0.12911415f, -0.18868816f, 0.03695912f, 
    -1.00002277f, 0.25599322f, 0.83722037f, 0.33136106f, -0.79791552f, -0.61030000f, -0.18695249f, -0.58397108f, 
    -0.05605699f, 0.63031179f, 0.16807863f, -0.18777134f, 0.07405785f, -0.12077732f, -0.25195450f, 0.08465009f, 
    0.18808810f, 0.03316779f, -0.42292288f, -0.14533627f, -0.29341167f, -0.05037071f, -0.16779605f, 0.20943275f, 
    1.05574846f, 0.82377136f, 0.16241440f, 0.54959440f, 0.67729956f, -0.03691952f, 0.42657581f, 0.23171027f, 
    0.07731460f, 0.07643985f, -0.47947827f, -0.10916000f, -0.23412760f, -0.25028124f, -0.21607216f, -0.14284059f, 
    0.01877821f, 0.15131834f, 0.08293965f, 0.20137525f, -0.09555604f, 0.06978504f, -0.04150598f, 0.13086596f, 
    0.27610007f, -0.21322036f, -1.10328722f, -0.53497434f, 0.61737686f, -0.00818654f, -0.06645860f, 1.15954745f, 
    0.18779792f, 0.49724430f, 0.47737065f, -0.23633847f, -0.53690320f, -0.51494217f, -0.19454755f, -0.19570433f, 
    -0.40651277f, -0.07221887f, -0.31447971f, 0.01173233f, -0.32375652f, 0.05135601f, -0.00859597f, -0.08323356f, 
    -0.03281868f, -0.01396135f, 0.56796706f, 0.80725175f, 0.51563996f, 0.30471233f, 0.21162307f, -0.59086132f, 
    -0.15398525f, 0.43690518f, -0.22139286f, 0.43142131f, 0.49267322f, 0.26887858f, -0.18826777f, 0.32633191f, 
    -0.50729024f, 0.22750705f, -0.40670946f, -0.03433242f, -0.05705999f, -0.46856773f, 0.08562633f, 0.27331898f, 
    -0.17068356f, -0.13067487f, -0.25878620f, -0.16692078f, -0.74980092f, -0.63347489f, -0.76728362f, 0.09043742f, 
    -0.43331429f, -0.70540768f, -0.66728956f, -0.24339248f, -0.37302840f, 0.11141019f, 0.58380485f, 0.05960309f, 
    0.22586384f, -0.02427816f, -0.00353278f, 0.11444298f, 0.20039546f, -0.17889559f, 0.17671667f, 0.05061743f, 
    -0.30652833f, 0.35409096f, 0.26671839f, -0.00692014f, -0.91281587f, -0.00927207f, -0.22355755f, -0.55565840f, 
    -0.25396600f, 0.43372938f, 1.02378094f, 0.08696323f, 0.49248829f, 0.75289333f, -0.19822159f, -0.02572225f, 
    0.04848722f, -0.33641779f, -0.41571555f, 0.20068972f, -0.07217360f, 0.15591842f, -0.13699302f, -0.24534187f, 
    -0.13301457f, -0.06306106f, -0.19740397f, -0.08532568f, 0.12392636f, 1.23450994f, 0.22914380f, -1.00053954f, 
    -0.55839813f, -0.14984381f, 0.42470020f, -0.07789973f, 0.62353903f, 0.39106259f, 0.07466631f, -0.51067865f, 
    -0.04858881f, -0.27985319f, 0.40865791f, 0.22557822f, 0.09447990f, -0.13456236f, -0.24939157f, -0.13350976f, 
    0.25198543f, -0.13947690f, 0.22635835f, -0.09270453f, 0.08010019f, 0.08727987f, -0.44790095f, -0.92956042f, 
    0.24632786f, 0.40557656f, -0.22323285f, 0.24361646f, -0.32447222f, 0.64462173f, 0.12622845f, -0.35557845f, 
    -0.36909771f, -0.19364540f, -0.34675863f, 0.04897329f, -0.33488917f, 0.57039696f, 0.42920431f, -0.12085626f, 
    0.05877412f, 0.14279155f, -0.09979162f, -0.20174727f, 0.57076526f, 0.21494496f, 0.35894990f, 0.35455176f, 
    -0.11280244f, -1.02584386f, -1.04578698f, -0.25311339f, -0.32137159f, 0.50001156f, 0.28253824f, -0.16416080f, 
    0.52624226f, 0.44803089f, -0.41782850f, 0.30950403f, -0.09059185f, 0.14321966f, 0.10009319f, -0.12578335f, 
    -0.09479388f, 0.04663641f, 0.13345994f, 0.22933064f, 0.09445307f, 0.18332866f, 0.24453716f, 0.03931409f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04854739f, 0.24902688f, 0.25798073f, 0.32925487f, 0.32798102f, 0.27411994f, -0.03570089f, 0.19512072f, 
    0.33542427f, 0.33873013f, 0.37137538f, 0.42394057f, 0.45202732f, 0.13658524f, 0.11789799f, 0.18566637f, 
    0.30656159f, 0.25866693f, 0.35266581f, -0.15028968f, 0.17820019f, -0.01520312f, -0.04381140f, 0.30244344f, 
    0.32627380f, 0.12236501f, 0.24266858f, 0.43784291f, -0.12866493f, 0.13377434f, 0.02398420f, 0.21782465f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00877668f, 0.02669392f, -0.05108945f, -0.02608597f, -0.02565323f, -0.00265684f, 0.03536895f, -0.00297260f, 
    -0.02198848f, 0.02493856f, -0.04891710f, -0.04917983f, 0.01150198f, 0.01149317f, 0.02181032f, -0.01811473f, 
    -0.00700730f, -0.03279239f, -0.03365375f, 0.04639865f, 0.00373233f, 0.03564136f, -0.03480993f, 0.03641600f, 
    -0.04947991f, -0.05166814f, -0.03564621f, -0.05431626f, -0.00468087f, -0.03133860f, -0.03806508f, 0.00378978f, 
    -0.01946786f, -0.04152472f, 0.03437302f, 0.03580806f, 0.03597395f, 0.04479438f, -0.02726405f, -0.05174541f, 
    -0.01516733f, -0.00431688f, -0.03841271f, -0.02231862f, -0.01804726f, -0.00467821f, -0.01167552f, 0.03543992f, 
    -0.03432066f, -0.02495285f, -0.00078330f, 0.01287456f, -0.01348668f, -0.03620422f, 0.03074221f, 0.04567915f, 
    -0.00938352f, -0.05157507f, 0.00374362f, -0.03748067f, 0.00300402f, -0.03055343f, 0.05530105f, -0.04798501f, 
    0.02347157f, -0.02607334f, 0.03426548f, 0.04380380f, -0.00743156f, -0.02407117f, 0.02679783f, -0.02339330f, 
    -0.02910872f, 0.02852064f, 0.02533406f, 0.03797537f, -0.04221865f, -0.01289337f, -0.02941298f, -0.04452369f, 
    -0.02414128f, -0.03734919f, 0.04091169f, -0.01224905f, 0.00096382f, 0.00022882f, -0.04966712f, 0.05361539f, 
    -0.00144354f, 0.02857438f, -0.00577333f, 0.02881341f, 0.03828260f, -0.02213831f, 0.00042950f, 0.00350002f, 
    -0.00049347f, -0.01709169f, -0.03213066f, 0.03108517f, 0.04364011f, -0.04185488f, -0.01601551f, 0.04541161f, 
    0.02949759f, -0.03199556f, 0.01939713f, 0.03380176f, -0.01807217f, -0.02715938f, 0.03479488f, -0.02553643f, 
    0.04237391f, 0.04163242f, 0.02112784f, -0.00844253f, 0.01345484f, -0.00849620f, -0.02826608f, -0.01219638f, 
    -0.05203067f, 0.04054783f, 0.00864536f, -0.01094910f, -0.04283565f, -0.03609265f, 0.02317256f, -0.04242788f, 
    0.03367499f, -0.00052133f, 0.01173224f, -0.03094328f, -0.00814575f, -0.04610690f, -0.03464948f, 0.05423478f, 
    -0.04879412f, 0.01790562f, -0.04836169f, -0.00236130f, -0.05090675f, 0.02350227f, -0.01187196f, 0.02770027f, 
    -0.04327251f, -0.01900950f, 0.03762100f, -0.02911169f, -0.02380519f, -0.03048482f, -0.01132141f, -0.03213206f, 
    -0.02586754f, 0.04022808f, 0.03826642f, 0.03463685f, -0.05115196f, 0.01556510f, 0.00733539f, 0.01842909f, 
    -0.02994920f, -0.03807059f, -0.03120945f, -0.01045706f, 0.00226742f, -0.04241019f, -0.00898488f, 0.00225849f, 
    0.01081734f, 0.01237624f, 0.05106796f, -0.05265176f, -0.03168736f, 0.00582742f, 0.01682585f, 0.03841531f, 
    -0.00154797f, 0.02143738f, -0.02692694f, -0.04156497f, -0.03842981f, -0.00424274f, 0.00817037f, 0.01402446f, 
    -0.00259121f, -0.00587780f, -0.03859152f, 0.03851319f, 0.05013958f, -0.02019361f, -0.02487233f, -0.04458802f, 
    -0.02022097f, 0.04511145f, 0.01007987f, -0.03639362f, 0.01907437f, -0.01036341f, -0.02694535f, 0.00502927f, 
    0.02042144f, -0.01430172f, 0.04281497f, 0.04333587f, -0.00641583f, -0.04368759f, 0.03375768f, 0.01482624f, 
    0.02685625f, -0.03985295f, 0.02222777f, -0.01560751f, -0.03059085f, -0.04380604f, -0.02034353f, -0.04746253f, 
    0.04984960f, 0.04573458f, 0.01315297f, 0.03742252f, -0.04010071f, 0.04349789f, -0.04780987f, 0.00093682f, 
    -0.04491445f, -0.01741799f, -0.00571658f, -0.03738301f, -0.03739537f, -0.01743669f, 0.00320987f, 0.02647138f, 
    -0.03544210f, -0.00554627f, 0.02258598f, -0.02905530f, 0.02702621f, -0.01628839f, -0.02873530f, -0.02619069f, 
    -0.00874440f, -0.05751639f, 0.00785541f, 0.02583234f, -0.00708619f, -0.04706632f, 0.00221816f, 0.03688641f, 
    -0.03222625f, 0.04396545f, -0.01413298f, -0.02181824f, 0.03207652f, -0.04310145f, 0.02207587f, -0.01254655f, 
    -0.01658989f, -0.01149695f, 0.00098746f, -0.04289339f, -0.01817842f, 0.02381326f, -0.04831981f, 0.01642440f, 
    -0.04414063f, 0.03223884f, 0.03469370f, -0.01950654f, 0.01978704f, -0.03567789f, -0.02183841f, 0.02546731f, 
    0.00182232f, -0.00027107f, 0.00881977f, 0.03292590f, 0.04874123f, -0.04731443f, -0.04228622f, -0.03393967f, 
    0.03211678f, 0.04215955f, -0.00810412f, 0.04855273f, -0.00083780f, -0.02371571f, -0.05645828f, 0.03345810f, 
    -0.04635549f, -0.02789605f, 0.01982138f, -0.02484185f, 0.01065758f, -0.04151795f, 0.04497470f, -0.02551524f, 
    0.02938140f, -0.04870509f, 0.02135506f, -0.01687958f, -0.02949027f, 0.03598157f, 0.03327466f, -0.00599553f, 
    -0.04287221f, -0.01407843f, -0.02618693f, 0.03166070f, -0.05481201f, -0.04091748f, 0.03884164f, 0.02055806f, 
    0.01570836f, 0.03793322f, 0.03842656f, -0.01088459f, -0.04242383f, -0.01634005f, 0.03253026f, 0.02683258f, 
    0.02743449f, 0.01836053f, -0.00838453f, -0.01594506f, 0.02921046f, -0.02764902f, -0.00836199f, 0.01249676f, 
    -0.04185958f, -0.05452745f, -0.04243712f, 0.01040640f, 0.04530232f, 0.02509243f, 0.04053384f, -0.03807394f, 
    -0.03695768f, -0.04008887f, 0.01104646f, -0.00657352f, 0.04615104f, 0.03176373f, -0.04588539f, -0.05373701f, 
    0.00836612f, 0.03279929f, -0.02375088f, 0.02026857f, -0.02545620f, -0.01867719f, -0.02788090f, -0.04062615f, 
    0.02097997f, 0.00387003f, 0.03325687f, -0.02777034f, 0.02371652f, -0.05101359f, -0.02756584f, 0.00642822f, 
    -0.03515323f, 0.04663659f, -0.00938357f, 0.00035055f, 0.02557408f, -0.00880864f, -0.01351741f, -0.02864411f, 
    -0.04888001f, -0.03824587f, -0.03634096f, -0.02683697f, -0.01506749f, -0.00174709f, 0.00218358f, -0.03842289f, 
    0.04857635f, -0.02385857f, -0.00168717f, 0.02165329f, 0.04603179f, 0.01451191f, 0.01904823f, -0.00518461f, 
    0.47366217f, -0.26185346f, 0.08017930f, 0.09389335f, 0.04159233f, -0.07138731f, 0.18779992f, 0.08457386f, 
    -0.04995283f, 0.02031826f, -0.13197060f, 0.05186299f, 0.19258814f, -0.18506235f, -0.10127547f, 0.13610364f, 
    0.12605312f, 0.24667029f, 0.06365354f, 0.08692773f, -0.02398086f, -0.09409019f, -0.05674172f, 0.05246579f, 
    0.40946609f, -0.24227409f, 0.14099094f, -0.27661359f, -0.00056446f, -0.04917281f, 0.01216880f, 0.07589779f, 
    -0.06668837f, -0.06688170f, -0.02684090f, -0.01911281f, 0.06776397f, 0.08465869f, 0.07735661f, -0.05954238f, 
    -0.03289326f, 0.17152677f, 0.06394720f, 0.08439261f, 0.16831544f, 0.07284933f, 0.00639028f, 0.11335106f, 
    -0.04533307f, -0.05882386f, 0.27773491f, -0.21170714f, 0.00268548f, -0.10394983f, -0.06828456f, 0.03559655f, 
    0.05765608f, 0.03702157f, -0.03788105f, -0.10766606f, -0.19347267f, 0.12839735f, 0.29873553f, 0.05203806f, 
    0.07760650f, 0.19797681f, -0.04054845f, 0.05138862f, 0.05550315f, -0.02240399f, 0.07018762f, -0.18531466f, 
    -0.34034637f, -0.16140370f, 0.06644609f, 0.02941836f, -0.12708408f, -0.06091719f, 0.12996371f, 0.18434787f, 
    0.18210857f, -0.05780031f, 0.11849833f, 0.12206021f, 0.24532197f, 0.18749112f, -0.05369355f, 0.07244129f, 
    -0.06578336f, -0.02755858f, -0.06647238f, 0.08237224f, -0.15540889f, -0.16089050f, 0.01030978f, 0.00167734f, 
    -0.11811002f, -0.02091755f, 0.12947895f, 0.00951540f, 0.17688689f, -0.02025574f, 0.06984524f, -0.21282971f, 
    -0.00955507f, -0.05199007f, -0.14423992f, 0.00103554f, -0.26532379f, -0.07260177f, -0.02765590f, -0.09389569f, 
    -0.02950438f, 0.05002214f, -0.12048534f, 0.05649561f, -0.01995244f, 0.19530185f, 0.08014987f, 0.17131743f, 
    -0.02800048f, -0.07630394f, -0.06264000f, 0.05276977f, -0.07709370f, 0.05413468f, -0.10331292f, -0.05283529f, 
    0.02428697f, -0.07594332f, -0.02764281f, -0.18530779f, -0.04304530f, -0.10255422f, 0.10093926f, 0.29794472f, 
    -0.00942218f, -0.12243109f, 0.06661563f, 0.00195441f, 0.13443047f, 0.08779152f, 0.08144672f, -0.02260796f, 
    -0.16678074f, -0.07215361f, 0.07398485f, -0.23368300f, -0.06478514f, 0.03344919f, 0.00461863f, 0.11595237f, 
    -0.04998729f, -0.01574049f, 0.11481591f, -0.03268372f, -0.04850972f, -0.04778457f, -0.02542765f, -0.15758817f, 
    -0.02817848f, -0.01173324f, -0.00710408f, -0.04464077f, -0.00455416f, 0.04446667f, 0.14382638f, 0.05468618f, 
    0.11416127f, -0.05454147f, -0.08275256f, -0.04351032f, 0.10637932f, 0.06060507f, -0.02002306f, -0.05568937f, 
    0.03734697f, -0.11207690f, -0.05068157f, -0.11336391f, 0.28515941f, -0.06753931f, 0.21993288f, 0.05150560f, 
    -0.06808540f, 0.01208618f, 0.11453515f, 0.07553588f, -0.01991426f, 0.18274166f, 0.09744861f, 0.07700358f, 
    0.36499971f, -0.30014265f, 0.11162952f, 0.39212057f, 0.05006770f, -0.14435886f, 0.11596035f, 0.08320253f, 
    0.09296058f, 0.00509920f, 0.13407603f, 0.11926910f, 0.04378979f, -0.12284750f, -0.31997049f, -0.00347837f, 
    0.02610849f, 0.06846791f, -0.18042055f, 0.17099042f, -0.03355221f, 0.07272007f, -0.15809907f, 0.08616738f, 
    0.03141470f, -0.00086329f, -0.02197866f, 0.13819906f, -0.06189149f, 0.09178779f, 0.05235803f, -0.05934588f, 
    0.08815914f, -0.00410169f, -0.08290766f, -0.10765573f, 0.37147617f, 0.45317066f, -0.03176287f, 0.31902748f, 
    0.06034972f, 0.23702113f, -0.04707535f, 0.07866465f, -0.00499531f, 0.24597459f, -0.08228322f, 0.09011671f, 
    0.00663873f, 0.09588445f, 0.11166070f, -0.35706359f, -0.10539759f, -0.00303189f, 0.00862996f, 0.12645429f, 
    -0.02089223f, 0.03347054f, 0.01199184f, 0.02852111f, 0.41891369f, 0.17272970f, 0.06147829f, 0.04515781f, 
    0.01906188f, 0.05323921f, -0.00300200f, -0.01914060f, -0.00922461f, 0.02473818f, 0.12698515f, 0.01663187f, 
    0.39213735f, 0.36805880f, 0.03298190f, 0.06903239f, 0.01442162f, 0.08073447f, 0.10525885f, 0.06714151f, 
    0.03882363f, -0.05451201f, -0.11464615f, 0.01255741f, -0.08764040f, -0.16171797f, 0.29383165f, -0.13940880f, 
    -0.07440754f, 0.01697456f, 0.06919213f, -0.00979594f, 0.11515615f, 0.01204631f, 0.03247063f, 0.10301193f, 
    -0.14847879f, 0.05667494f, 0.10947989f, 0.17072068f, 0.06669578f, -0.00305737f, -0.01939910f, -0.02032475f, 
    -0.06124103f, -0.00182872f, -0.00209501f, 0.12906577f, 0.05127642f, -0.14422117f, 0.13743623f, -0.06027544f, 
    -0.01674588f, 0.17070106f, 0.01744358f, -0.12162116f, -0.05409946f, 0.07544974f, 0.27645862f, 0.18989904f, 
    -0.13291901f, -0.13999000f, 0.20568323f, 0.22668827f, -0.00408053f, -0.02782741f, 0.06373487f, 0.03690234f, 
    -0.00877793f, 0.09118970f, 0.09873161f, -0.03578061f, -0.34365973f, 0.17717931f, 0.12082398f, -0.03669628f, 
    -0.11904788f, -0.02833649f, -0.08197001f, -0.05185075f, 0.01891769f, -0.02354200f, 0.00967204f, 0.15036583f, 
    -0.12035982f, -0.33063951f, -0.05341658f, 0.04005912f, -0.02967390f, -0.04559286f, 0.10301561f, 0.08585550f, 
    0.05527960f, 0.09556521f, -0.00469286f, 0.15636487f, 0.00202161f, 0.15752532f, 0.01914897f, -0.01624662f, 
    -0.03142028f, 0.03989325f, -0.09711318f, 0.14384605f, 0.15547350f, -0.12881297f, -0.08598708f, 0.01776778f, 
    -0.04882732f, -0.05112519f, -0.05355714f, -0.15487909f, -0.01702738f, -0.05646782f, -0.00919137f, -0.03567512f, 
    -0.11886934f, -0.03608738f, -0.10449560f, 0.22826470f, -0.21856235f, 0.03464210f, -0.14756487f, 0.03691928f, 
    -0.03750878f, -0.02813904f, 0.05964088f, 0.08798239f, 0.01231246f, -0.02858338f, 0.03612658f, -0.00124518f, 
    0.03305344f, -0.03275375f, -0.00329951f, -0.01427493f, 0.01049700f, 0.00127364f, -0.03693197f, -0.00909765f, 
    0.04119587f, 0.02153188f, -0.00802541f, 0.03109618f, 0.04508814f, -0.00296466f, 0.04653735f, -0.03395614f, 
    0.01436263f, -0.02855848f, 0.04876696f, -0.00420549f, 0.00569043f, 0.00582899f, -0.02229898f, -0.01802420f, 
    -0.03637616f, -0.02529463f, -0.00349789f, -0.01281628f, -0.00313865f, -0.03893384f, 0.03949970f, -0.05684700f, 
    0.01749510f, -0.01651870f, -0.03804106f, -0.00747499f, 0.05086198f, -0.04723174f, 0.00970700f, -0.01241466f, 
    -0.02466676f, 0.00064506f, -0.02916291f, 0.00175597f, -0.02801869f, 0.02596870f, 0.00221222f, 0.02066988f, 
    -0.02816325f, 0.01598853f, -0.01393308f, -0.03521204f, 0.04458993f, -0.02368032f, 0.02538356f, -0.03053086f, 
    0.02434379f, -0.03178935f, -0.04357855f, 0.00153260f, 0.04525086f, 0.01413735f, 0.03507818f, -0.01604788f, 
    0.04108024f, -0.03027691f, 0.04291150f, -0.03740599f, -0.02722337f, -0.00078835f, -0.01580898f, 0.01531985f, 
    -0.04591455f, 0.00325018f, 0.00038383f, 0.03588907f, -0.04847103f, -0.04055009f, 0.04194741f, 0.01287236f, 
    0.00926540f, -0.02463970f, -0.05255568f, -0.05933039f, -0.00794948f, -0.02323588f, 0.01695003f, 0.01585189f, 
    0.00032882f, 0.02369545f, 0.00398704f, 0.03852584f, -0.03138274f, 0.02256774f, 0.01887281f, 0.03436968f, 
    -0.04152057f, -0.03653122f, -0.01497711f, -0.03336538f, 0.03959603f, -0.00217315f, 0.03577215f, -0.01212397f, 
    0.02011072f, 0.00233761f, -0.02381784f, 0.03844516f, 0.01953905f, -0.02574231f, 0.04258275f, -0.04705119f, 
    -0.00063127f, 0.04132985f, -0.04251866f, 0.05134944f, 0.02048386f, 0.02723957f, 0.00346299f, 0.04181168f, 
    0.00480431f, -0.03143709f, -0.00907557f, -0.00042246f, 0.04398699f, -0.01706763f, -0.02368921f, 0.00036730f, 
    -0.01794508f, -0.04708501f, -0.02145655f, 0.02217615f, -0.00300576f, -0.00255051f, -0.00322659f, -0.04888451f, 
    0.01010003f, -0.05030832f, -0.03679449f, -0.04104978f, -0.01957728f, -0.05548448f, 0.02453716f, 0.02984018f, 
    -0.04744755f, 0.02234132f, -0.04555515f, 0.00091830f, 0.00820057f, 0.01955182f, 0.04280388f, -0.04713003f, 
    -0.03091769f, 0.02116536f, 0.04369233f, 0.00095188f, 0.00645305f, 0.03559347f, -0.01582724f, 0.02909056f, 
    -0.03991498f, 0.00987721f, 0.03134476f, -0.04192476f, 0.04348150f, -0.01986119f, 0.02812801f, -0.03266633f, 
    0.03629269f, -0.02639245f, 0.03461605f, -0.04909931f, 0.02273691f, -0.01409610f, 0.03159355f, 0.00280283f, 
    -0.02410142f, 0.02588414f, -0.02163496f, -0.04490494f, -0.03172524f, -0.02507350f, 0.01157556f, 0.00785909f, 
    0.04273709f, 0.00920828f, -0.02621739f, -0.04241313f, 0.03608339f, 0.04164418f, -0.03188716f, -0.01126565f, 
    -0.03871907f, -0.01499538f, 0.03128146f, -0.03109214f, 0.03571788f, -0.03881516f, 0.00525698f, 0.03810648f, 
    -0.03866218f, -0.00050074f, -0.04744809f, 0.01781454f, 0.02505971f, 0.04000836f, 0.03122400f, -0.03698510f, 
    0.00603524f, 0.02468582f, -0.02394304f, -0.04226499f, -0.01111389f, -0.00821137f, -0.02300273f, -0.01061450f, 
    0.00358862f, -0.00488927f, -0.01156999f, 0.03484306f, -0.04896687f, -0.02150782f, -0.00538275f, 0.01083700f, 
    -0.05191808f, -0.04590066f, -0.00868253f, 0.01208015f, -0.03521682f, -0.01135945f, 0.04250763f, 0.00994988f, 
    0.03617139f, -0.00788761f, 0.03272527f, -0.02771239f, 0.01965813f, -0.04736777f, 0.03646223f, 0.04513246f, 
    -0.01830982f, -0.04416202f, -0.01963744f, -0.02522543f, 0.02235681f, -0.04042929f, 0.02548482f, 0.00258186f, 
    0.01312866f, -0.04774895f, 0.01449811f, 0.04025785f, 0.01944278f, -0.01505435f, -0.01670420f, -0.02609382f, 
    0.01222007f, 0.04851268f, -0.01509680f, -0.05914442f, 0.01847225f, 0.02906706f, 0.01002660f, -0.04931064f, 
    -0.04433718f, 0.03847616f, -0.03054589f, -0.02991674f, 0.03963467f, 0.01169583f, 0.02243354f, -0.02224530f, 
    -0.05015929f, -0.01895614f, -0.04699800f, -0.01500115f, -0.01793200f, -0.00561064f, -0.00866149f, 0.00644023f, 
    -0.03843969f, 0.03714431f, -0.02074242f, -0.02639466f, 0.05234532f, -0.03047129f, -0.01503997f, 0.03468062f, 
    -0.04928476f, -0.02532777f, -0.02336138f, 0.02936088f, -0.03418502f, 0.01529492f, 0.01248397f, -0.04863552f, 
    0.03095984f, -0.02065142f, -0.04518658f, -0.04695196f, 0.00717670f, -0.02583048f, 0.03220364f, -0.01961315f, 
    -0.00135318f, 0.00753950f, -0.01147697f, 0.01927455f, -0.02739544f, -0.05104582f, -0.00313896f, -0.01039548f, 
    0.01547509f, -0.03261897f, -0.05323911f, 0.03001007f, -0.00589347f, -0.02456334f, -0.03248935f, -0.03263276f, 
    -0.00344642f, -0.05210446f, 0.03534981f, 0.02264060f, 0.03968687f, -0.04032740f, 0.05156057f, -0.00246987f, 
    -0.02810863f, -0.05194306f, -0.03228602f, 0.03804749f, -0.02612487f, -0.02974056f, -0.01973697f, 0.02805182f, 
    -0.00291870f, 0.01499511f, -0.04063413f, 0.01212229f, -0.05236667f, 0.02866890f, 0.03529015f, -0.05602878f, 
    -0.01442520f, 0.01671772f, 0.00475127f, -0.03362897f, 0.00830994f, -0.03079751f, -0.01764623f, 0.03705634f, 
    0.01729064f, 0.03946523f, -0.02620597f, -0.00562010f, -0.01996330f, -0.00940385f, 0.03371082f, 0.00657944f, 
    -0.03286937f, 0.02597538f, 0.00641339f, -0.01795170f, -0.00106384f, -0.04500351f, 0.01140168f, -0.02602636f, 
    -0.04097795f, 0.03567420f, -0.00662650f, 0.00488911f, 0.03934614f, 0.01127882f, -0.00335823f, -0.04527745f, 
    0.00231919f, -0.05242195f, -0.01083945f, 0.00486370f, 0.02270134f, -0.00190837f, 0.02305991f, -0.03827139f, 
    0.03493482f, 0.03456527f, -0.01012664f, -0.02737525f, -0.05455561f, -0.01008951f, 0.03147798f, 0.03151921f, 
    0.03034332f, -0.05739788f, 0.03951626f, 0.02493170f, 0.03487289f, 0.02747354f, -0.05487020f, 0.01557656f, 
    -0.02289770f, -0.02476094f, -0.03901910f, -0.01285934f, 0.01830843f, -0.01681734f, -0.01776229f, 0.01298923f, 
    0.01191102f, -0.05253467f, 0.00823251f, 0.00557433f, -0.05282068f, -0.04262027f, -0.01633725f, -0.04904553f, 
    -0.00990341f, 0.04260318f, 0.01862841f, 0.03404445f, -0.04321089f, -0.01209570f, 0.04247543f, 0.02802812f, 
    -0.02992851f, -0.01843916f, -0.04649854f, -0.04587805f, -0.03246855f, -0.04777846f, -0.04136206f, 0.01898470f, 
    -0.01881395f, 0.02323776f, 0.04540522f, -0.01035199f, 0.04138613f, 0.03637063f, 0.02016872f, 0.03257241f, 
    -0.04615954f, -0.01252665f, 0.03053143f, 0.00579884f, 0.02061287f, 0.01166025f, -0.01890101f, -0.00268739f, 
    -0.03172005f, -0.03063086f, -0.00098387f, 0.00536378f, -0.04758382f, -0.00356378f, -0.05018159f, -0.00517409f, 
    0.00794139f, -0.03596764f, -0.05423262f, 0.00472672f, -0.00331894f, 0.04539663f, 0.03892531f, 0.03821632f, 
    -0.00564735f, 0.00554999f, -0.00906083f, -0.03274664f, -0.00944914f, -0.02168256f, 0.01253337f, -0.04809964f, 
    -0.00284556f, -0.01660781f, -0.00908169f, -0.01334982f, 0.00301546f, 0.04257483f, 0.02503960f, -0.03052222f, 
    0.00342645f, 0.03824055f, -0.04784085f, 0.01718114f, 0.00177180f, -0.01107134f, -0.05083697f, 0.01665001f, 
    0.01847129f, -0.05002422f, 0.02247939f, 0.04319758f, 0.01386705f, 0.02916972f, -0.04241741f, -0.04939552f, 
    0.01906325f, 0.03478222f, 0.04624395f, 0.00400104f, -0.04296089f, 0.03733595f, 0.02514838f, 0.03108463f, 
    0.03311614f, -0.05045874f, 0.02690903f, 0.00043631f, -0.05456499f, 0.03059672f, -0.05240823f, 0.03779577f, 
    -0.04317014f, 0.00736589f, -0.05251398f, 0.02954250f, -0.01940951f, -0.00144182f, -0.01817047f, 0.00040784f, 
    -0.04474784f, -0.01470258f, -0.03840632f, 0.02332954f, -0.01393613f, -0.05254205f, -0.03637910f, -0.01427537f, 
    -0.05669885f, -0.02723241f, 0.03077332f, -0.05257347f, 0.03235160f, -0.03228767f, 0.02983764f, 0.03114389f, 
    0.00575666f, -0.04867067f, 0.03266477f, 0.02294888f, -0.02294296f, 0.02513663f, -0.05316750f, -0.03109032f, 
    -0.01293567f, 0.03872474f, 0.01835524f, -0.04825767f, -0.05670797f, 0.00241311f, -0.02726878f, 0.02015019f, 
    0.01750707f, -0.01529594f, 0.03766862f, 0.02830910f, -0.03681843f, -0.02595436f, 0.01651250f, 0.03165508f, 
    -0.02966891f, 0.00588066f, -0.04076703f, 0.03379115f, 0.03362698f, -0.01637521f, -0.04499678f, 0.02427522f, 
    0.00170757f, 0.01832093f, -0.03509394f, -0.01070294f, -0.02473205f, 0.03630548f, -0.01035180f, 0.00420585f, 
    -0.02669671f, 0.01473390f, -0.00733456f, 0.01164131f, -0.01622567f, 0.04348157f, -0.02713406f, -0.02622723f, 
    0.00467746f, -0.02902177f, -0.02174624f, -0.03973404f, -0.03001134f, 0.02663262f, -0.05301294f, 0.01583583f, 
    0.00787070f, 0.01156639f, -0.02932006f, -0.00916900f, 0.02313993f, 0.04381331f, 0.00642374f, 0.02923545f, 
    -0.04855811f, 0.01296458f, -0.00996187f, -0.03633490f, -0.05158181f, -0.02599182f, -0.05697834f, 0.01710746f, 
    0.01817484f, -0.01528358f, -0.04130271f, -0.02961341f, -0.03379629f, 0.03910540f, 0.03757956f, -0.00009752f, 
    -0.01536082f, -0.03209442f, 0.03445572f, -0.03405134f, 0.01107506f, -0.04820280f, 0.03767317f, -0.03482776f, 
    -0.00589818f, 0.03452949f, -0.01904481f, 0.04057015f, -0.01117374f, -0.01715406f, -0.04319931f, -0.03224845f, 
    -0.03893385f, -0.04683436f, -0.02927266f, -0.04785509f, -0.00646803f, -0.00578534f, -0.00632389f, -0.00263584f, 
    0.02849876f, -0.04989522f, -0.04916620f, 0.03321941f, -0.05159440f, 0.01930160f, -0.05452855f, -0.01414970f, 
    -0.01992369f, -0.03991234f, -0.04851643f, 0.01756513f, 0.03809742f, -0.04841074f, -0.02662555f, -0.03850440f, 
    -0.01675036f, -0.03928940f, -0.00593871f, -0.01531086f, -0.00271490f, 0.00068330f, -0.05283453f, 0.02450568f, 
    0.02236952f, -0.02803051f, -0.04501602f, 0.00894960f, 0.01435763f, 0.04223968f, 0.02316155f, 0.01274312f, 
    -0.00911975f, 0.01499786f, 0.02091981f, -0.02062575f, 0.02811193f, -0.00486640f, 0.00176345f, -0.00222473f, 
    -0.03641586f, 0.00455372f, -0.02154667f, 0.01168059f, 0.01134509f, 0.04264836f, -0.00277293f, -0.00020023f, 
    -0.05236358f, -0.01044510f, -0.02663175f, 0.01074624f, -0.02497081f, -0.04498913f, -0.00770681f, -0.00914115f, 
    -0.04356332f, -0.04225156f, 0.04815970f, 0.01789936f, 0.01154235f, 0.04014212f, 0.02840766f, -0.04117557f, 
    -0.00887623f, 0.00493383f, 0.04680736f, 0.01554809f, 0.02137863f, 0.04176066f, 0.00039634f, 0.01834698f, 
    -0.04393867f, 0.01303444f, -0.03883754f, -0.03676588f, -0.03909413f, -0.04569392f, 0.02897104f, -0.04493467f, 
    -0.00522151f, -0.00571472f, -0.04145211f, 0.01648967f, -0.04786958f, -0.01370011f, 0.03797918f, -0.04692719f, 
    -0.04253817f, 0.04339530f, 0.00764781f, -0.02173566f, -0.01080481f, -0.04021376f, -0.04063930f, -0.03599455f, 
    0.03158228f, -0.04651880f, -0.05082072f, 0.01721138f, -0.03906187f, -0.02493365f, -0.01815275f, 0.02953225f, 
    -0.02146235f, -0.03472162f, 0.02286000f, 0.00906846f, -0.04354343f, -0.03859073f, -0.03222685f, 0.01350120f, 
    -0.00412032f, -0.04200753f, -0.04048237f, -0.03150870f, 0.02711380f, 0.02296937f, 0.03264933f, 0.02712180f, 
    -0.00341176f, -0.03130061f, -0.05345536f, -0.02405298f, -0.00211419f, -0.02400355f, -0.02288693f, -0.02771598f, 
    0.28302237f, 0.26124483f, -0.36986989f, 0.07688477f, -0.07179186f, 0.10964296f, -0.13618244f, 0.07635760f, 
    -0.09946443f, 0.06682590f, 0.04982393f, -0.02056806f, 0.26957136f, 0.20002447f, 0.08736224f, -0.10513958f, 
    0.07055980f, -0.02390561f, 0.11887919f, -0.01727171f, 0.07720648f, 0.05885838f, -0.13517933f, 0.05124001f, 
    0.10947027f, 0.15515329f, -0.11536208f, 0.10231470f, -0.09570195f, 0.10607538f, 0.00021814f, -0.08997118f, 
    -0.01798679f, 0.13639721f, 0.02405743f, 0.14369382f, 0.03758411f, -0.04322253f, -0.16321659f, 0.01000768f, 
    0.20574556f, -0.02504448f, -0.00986895f, 0.16523246f, 0.13835534f, 0.09347197f, 0.06612898f, -0.00673207f, 
    -0.33325571f, -0.11419632f, -0.01727493f, 0.06586273f, -0.10279603f, -0.01538665f, -0.10186350f, 0.03246490f, 
    -0.00921753f, 0.08143701f, -0.13565557f, 0.02915406f, 0.46080515f, 0.19418496f, -0.06736424f, -0.26865056f, 
    0.00520694f, -0.09271429f, -0.06001774f, 0.03202740f, 0.00952631f, -0.04164230f, 0.02797998f, -0.04088205f, 
    -0.17206919f, 0.11655720f, 0.11802480f, -0.20447849f, 0.02524344f, 0.00511309f, 0.03566625f, 0.18802206f, 
    0.06361111f, -0.05237996f, -0.10096461f, -0.13443267f, -0.09048295f, 0.24230675f, 0.25189701f, 0.20710392f, 
    0.09064656f, 0.01961305f, 0.02948331f, 0.19487280f, 0.05336665f, 0.09562722f, 0.03542780f, -0.13023011f, 
    0.55568385f, -0.10969699f, -0.26181239f, 0.00062178f, -0.03356764f, 0.02976931f, -0.17679445f, 0.04264728f, 
    -0.01659256f, -0.14176317f, 0.05306820f, -0.07815793f, 0.48449793f, -0.06631375f, 0.19399315f, -0.04789984f, 
    0.08418205f, -0.04233966f, 0.14028324f, 0.21646012f, -0.05586426f, -0.02404493f, -0.00906158f, -0.07399939f, 
    0.08018531f, 0.21851715f, 0.08699850f, -0.22272372f, 0.01030410f, -0.07214189f, -0.01561761f, -0.04443752f, 
    0.13295254f, 0.01465317f, 0.04398696f, -0.01952706f, 0.10611393f, 0.14922354f, 0.22924660f, 0.07635685f, 
    0.09991876f, 0.01903028f, 0.05110690f, -0.08990224f, 0.05294542f, -0.05915472f, 0.06512514f, -0.04404818f, 
    -0.06288877f, -0.05604744f, -0.20737641f, -0.35795507f, 0.08747253f, 0.18512008f, -0.04753874f, -0.05044798f, 
    0.11018401f, -0.05949464f, 0.18426500f, -0.06665475f, 0.52691787f, 0.03072722f, -0.04093082f, 0.00442329f, 
    -0.09618794f, 0.13844408f, 0.02970687f, -0.05372016f, 0.06003786f, -0.02193419f, -0.21996248f, -0.13764420f, 
    -0.06663296f, 0.23092842f, -0.13863540f, 0.00347803f, 0.10888940f, -0.09293434f, -0.08531786f, -0.04055618f, 
    0.00829414f, -0.08793075f, -0.13082403f, -0.13319726f, -0.03555577f, -0.07701402f, -0.10283974f, 0.34398279f, 
    0.12860848f, 0.15402314f, 0.08808029f, 0.11896257f, -0.00488708f, 0.13538519f, -0.01451370f, 0.31194800f, 
    0.16562273f, -0.00385940f, -0.19280709f, 0.00783497f, -0.02378109f, 0.12915099f, 0.11571476f, 0.12730540f, 
    -0.06173408f, 0.11625212f, 0.02194815f, 0.07481030f, 0.17538109f, -0.37256050f, -0.19704273f, -0.29883873f, 
    -0.01784499f, 0.01611931f, 0.02873087f, -0.13965130f, -0.00797175f, -0.06430836f, -0.00198016f, 0.09559987f, 
    -0.24764910f, -0.19269302f, -0.23255862f, 0.44802034f, 0.05203179f, 0.05777017f, -0.08190404f, 0.12475123f, 
    -0.08121123f, 0.04714100f, -0.04708564f, 0.03322617f, 0.03824898f, 0.05427025f, 0.26430851f, -0.23144166f, 
    0.13460021f, 0.05075695f, 0.02704332f, -0.08624867f, 0.07406531f, -0.00737126f, 0.10575628f, 0.21638705f, 
    -0.11582394f, 0.04059440f, 0.05414724f, -0.20191799f, -0.25581416f, 0.02791767f, -0.08451059f, -0.18270047f, 
    0.04596281f, -0.30487686f, -0.06160926f, 0.16418812f, 0.23665668f, 0.24398643f, -0.08169186f, -0.12079214f, 
    -0.04310754f, -0.05811798f, -0.19265768f, -0.02279930f, 0.04769741f, 0.05144268f, -0.14698157f, -0.20756404f, 
    0.40395364f, -0.50255889f, -0.30463871f, 0.10150286f, 0.04236200f, -0.00320995f, -0.07199556f, -0.03149696f, 
    0.02220435f, 0.02570142f, -0.01177043f, 0.09681126f, -0.11240797f, 0.06272203f, -0.32742643f, -0.03634479f, 
    -0.02096593f, -0.04275472f, 0.11593267f, 0.06452574f, 0.02776170f, 0.10628907f, 0.01486238f, -0.02413142f, 
    0.14454566f, 0.27325326f, -0.13066889f, 0.15428616f, 0.16742089f, 0.04510276f, 0.05849685f, 0.08495608f, 
    0.04493999f, 0.02995281f, -0.20001543f, -0.00750187f, 0.15108120f, -0.29491287f, 0.08376019f, 0.23305541f, 
    0.15329835f, -0.00378393f, 0.13077043f, 0.05324777f, 0.07186542f, 0.12670046f, 0.09252517f, 0.20932023f, 
    0.25879341f, 0.20728061f, 0.03391247f, -0.26097432f, 0.21611077f, 0.08004418f, 0.01291176f, 0.07662557f, 
    0.06523453f, 0.16087648f, 0.05819567f, -0.02570778f, -0.00328781f, -0.14488748f, -0.10232831f, -0.33106339f, 
    -0.01323053f, 0.17889795f, 0.13686799f, 0.05242975f, -0.15392104f, -0.10837328f, -0.09022208f, -0.13971277f, 
    0.48624319f, -0.16667052f, 0.00537611f, 0.05853579f, -0.06998240f, 0.14682674f, 0.00689530f, 0.26278728f, 
    -0.05652466f, 0.15545462f, 0.01547746f, 0.02314432f, 0.04859610f, 0.03110173f, 0.08366507f, 0.06996487f, 
    0.24844399f, -0.15020993f, -0.00343981f, 0.20121194f, -0.03501191f, -0.16471268f, -0.02984961f, 0.09821600f, 
    0.00139227f, 0.09871905f, -0.08239698f, 0.02409699f, -0.14208391f, 0.08948543f, -0.16119343f, 0.07242297f, 
    -0.01053616f, -0.05667529f, 0.05492275f, -0.12573630f, 0.38200456f, 0.17837861f, 0.11942091f, -0.21940874f, 
    -0.09280950f, -0.09087364f, -0.01869245f, -0.03905005f, -0.07594453f, -0.10162386f, 0.12859905f, 0.04714907f, 
    -0.00094916f, 0.00100840f, 0.01880882f, 0.00110866f, 0.01745636f, -0.01294315f, 0.00418814f, 0.04026178f, 
    -0.02793363f, -0.03683759f, -0.04196937f, 0.01208060f, -0.03485353f, -0.00567706f, 0.03303461f, 0.02435883f, 
    -0.04836211f, -0.05696153f, -0.05322243f, 0.03221011f, -0.05062286f, 0.03119520f, 0.00337255f, 0.03291014f, 
    -0.00517172f, -0.02735079f, -0.02960510f, -0.00904174f, -0.02213199f, 0.01855192f, 0.03991169f, -0.03041795f, 
    -0.00554908f, 0.03862255f, 0.03346913f, 0.01102271f, -0.04182896f, -0.05355836f, -0.00157087f, -0.05817172f, 
    0.00940682f, 0.00156543f, 0.02400332f, -0.02919872f, 0.00006508f, -0.01319709f, 0.03686842f, -0.01567634f, 
    -0.00967103f, -0.00062938f, 0.01093558f, 0.00334427f, -0.05547614f, -0.02264514f, -0.01730081f, -0.04924772f, 
    -0.03382526f, 0.00533999f, -0.02294347f, -0.00184463f, -0.03588152f, -0.01236595f, -0.05537646f, -0.02505984f, 
    0.02088077f, 0.00898738f, -0.04079042f, -0.00591392f, 0.02482847f, -0.04894624f, -0.01831710f, 0.02568427f, 
    -0.00016243f, 0.03742807f, -0.00802851f, -0.00475608f, -0.03325015f, -0.04521308f, -0.00760637f, 0.02593955f, 
    0.01142452f, -0.03167827f, -0.05722950f, 0.02600261f, 0.03224500f, 0.04066722f, 0.03537589f, -0.02243095f, 
    0.03900188f, 0.00457807f, -0.00691140f, -0.02364550f, 0.03881497f, -0.04668145f, 0.03326332f, -0.02438254f, 
    -0.02436479f, -0.04744603f, 0.02218660f, 0.00382414f, -0.02905397f, -0.03184776f, -0.01235984f, -0.01319078f, 
    0.01680248f, 0.03035846f, 0.01869206f, 0.03186633f, 0.01911905f, 0.00617911f, 0.03296021f, -0.00649023f, 
    -0.05815549f, -0.00937612f, -0.00331706f, 0.03855553f, -0.05893946f, -0.03005855f, 0.04219688f, -0.01735105f, 
    -0.05495809f, -0.03570712f, 0.00452274f, -0.05250141f, -0.00194254f, -0.05525101f, -0.05331038f, 0.00271460f, 
    0.01463018f, -0.03605738f, 0.00054556f, -0.05235533f, -0.02153373f, 0.01028831f, -0.00159532f, 0.01568407f, 
    -0.00422512f, -0.04041430f, -0.00909266f, -0.05272813f, 0.00024819f, -0.03090968f, -0.01047492f, -0.05197407f, 
    -0.02148773f, -0.03350436f, 0.03351093f, 0.04440860f, -0.03161060f, 0.03302578f, 0.00019881f, -0.04309000f, 
    0.02272343f, -0.05415921f, 0.02427981f, 0.03292827f, -0.03688408f, -0.01671640f, -0.03762024f, -0.00581430f, 
    -0.04984606f, -0.04598335f, 0.02508928f, -0.01085485f, 0.02337833f, 0.01858431f, 0.01504804f, -0.01553545f, 
    0.04214721f, -0.03374303f, 0.03076362f, -0.03373567f, -0.03759860f, 0.00100525f, -0.02400130f, 0.01629798f, 
    -0.00758253f, 0.00938742f, -0.04448119f, -0.00265877f, 0.02388165f, -0.02493852f, -0.04990558f, -0.04258690f, 
    0.03839110f, 0.00506526f, 0.03060051f, -0.02082031f, -0.03173598f, -0.00766562f, -0.01073654f, -0.04437408f, 
    -0.04300857f, 0.02373872f, 0.01853231f, -0.00144256f, -0.01082484f, 0.03634113f, -0.05650437f, -0.03746939f, 
    0.02057789f, -0.01892982f, -0.01298892f, -0.02127470f, 0.03796977f, 0.02929940f, -0.05482117f, 0.02353595f, 
    -0.04381895f, -0.02520463f, -0.03903022f, -0.03011382f, -0.01186248f, 0.00863945f, -0.00380382f, -0.04284196f, 
    -0.05750083f, 0.02973480f, 0.01151274f, -0.04814208f, 0.04096182f, 0.01228893f, -0.04679176f, 0.03599975f, 
    0.03250593f, 0.03144899f, -0.01728437f, -0.04276771f, -0.04360288f, -0.02272655f, 0.01809104f, -0.02095335f, 
    -0.01151248f, -0.04429569f, -0.04169663f, -0.02290208f, -0.03225511f, -0.03018237f, -0.01604335f, 0.00872143f, 
    0.04143281f, 0.01693607f, 0.01782697f, -0.05097610f, 0.02466126f, -0.03159097f, -0.01800282f, -0.00702521f, 
    -0.00257874f, 0.01401444f, -0.05723937f, -0.02644032f, 0.00342632f, 0.00953406f, 0.01742497f, 0.02845076f, 
    -0.02065892f, 0.02969090f, -0.03801049f, 0.03841598f, 0.02152841f, 0.02292610f, -0.00771326f, 0.01195213f, 
    0.02563298f, -0.00540938f, -0.02619216f, -0.02911814f, -0.01728744f, 0.02743285f, -0.02271071f, 0.01009241f, 
    -0.04791218f, -0.03397113f, -0.02471694f, 0.03398204f, 0.01057962f, -0.00422216f, 0.00396028f, -0.03348231f, 
    -0.05378876f, 0.00700093f, 0.00212211f, -0.04570266f, 0.02295873f, -0.02448676f, -0.03591936f, -0.02682486f, 
    0.02923908f, -0.04185798f, -0.03604038f, -0.04291301f, -0.03374330f, -0.05525210f, 0.02499615f, 0.02262415f, 
    -0.05240526f, -0.01138014f, 0.01235605f, 0.00554360f, -0.01620829f, 0.01214414f, 0.00894153f, -0.04647686f, 
    0.03750848f, 0.01903046f, 0.01322923f, -0.02193369f, -0.00663185f, -0.04498616f, -0.05095688f, 0.04299707f, 
    -0.02902486f, 0.01751520f, 0.01732697f, -0.01813742f, 0.00019430f, -0.05425569f, -0.00507678f, -0.02417468f, 
    0.02040422f, 0.02395504f, -0.04961344f, -0.03537711f, -0.04148887f, 0.00520369f, -0.04001683f, -0.03002255f, 
    -0.04655785f, -0.00318999f, -0.01453572f, 0.03517354f, 0.00457712f, -0.01362099f, 0.01853434f, 0.01993825f, 
    0.01748170f, -0.03962358f, -0.01163065f, 0.01163229f, -0.03302383f, -0.03343936f, -0.04046880f, -0.01004512f, 
    0.02853817f, 0.01265180f, -0.04747324f, -0.01080517f, -0.00042681f, 0.02167454f, -0.05619020f, -0.02754272f, 
    -0.04526709f, 0.01170909f, -0.01205970f, 0.02810474f, -0.03532786f, -0.00650325f, -0.04811189f, -0.03929213f, 
    0.00331477f, -0.02692166f, 0.00952981f, -0.01759885f, 0.02500947f, 0.04014442f, 0.00607174f, -0.02779409f, 
    -0.03273566f, 0.04186957f, 0.01184319f, -0.01606871f, 0.02346743f, 0.02094357f, -0.00692706f, -0.03723198f, 
    -0.03551618f, 0.04088518f, -0.02434003f, -0.02103043f, -0.05206666f, 0.00211834f, 0.03281329f, -0.04592124f, 
    -0.03624629f, 0.01277091f, 0.02092602f, 0.00794055f, -0.02991359f, -0.01721838f, 0.00226065f, -0.02019047f, 
    0.00349220f, -0.02533485f, -0.00776206f, 0.00474356f, -0.03834940f, -0.02208829f, 0.03305604f, -0.00444928f, 
    0.03347379f, -0.02645225f, -0.04792169f, 0.04263007f, -0.01458756f, 0.03633301f, -0.01695059f, -0.00912545f, 
    -0.03833652f, -0.00158850f, -0.02213658f, -0.02090349f, -0.00704966f, 0.02843084f, 0.02474948f, -0.05591196f, 
    -0.02192778f, -0.04520075f, -0.03962323f, 0.00019135f, -0.03739040f, 0.02628857f, -0.03150545f, -0.00151896f, 
    -0.00197731f, -0.05592328f, -0.03501609f, -0.01254598f, 0.02112026f, -0.04662464f, -0.00998214f, -0.02208587f, 
    -0.00056045f, -0.01808519f, -0.04898276f, 0.01652082f, -0.04218367f, -0.03649077f, -0.03808708f, 0.04206561f, 
    -0.01559523f, -0.04499949f, 0.00450337f, 0.02782304f, 0.04047436f, -0.02223033f, -0.02525640f, 0.01936112f, 
    0.00691726f, 0.00213550f, -0.01235225f, -0.02562455f, 0.02663922f, -0.03663097f, -0.04622661f, 0.03344534f, 
    -0.00703562f, 0.02652437f, -0.04485139f, -0.03593815f, 0.02727753f, -0.05759208f, 0.00014998f, -0.00438418f, 
    0.01080955f, 0.03809839f, 0.03704540f, -0.02458256f, -0.02983471f, -0.05393542f, 0.04183427f, 0.01339387f, 
    -0.03036102f, -0.04857299f, 0.03746685f, 0.01314195f, -0.05370167f, -0.05017006f, -0.00176206f, -0.03564390f, 
    0.02587897f, 0.00179277f, -0.02659347f, 0.04205006f, -0.01161304f, -0.01294253f, -0.00635159f, -0.05864237f, 
    -0.01847783f, -0.04615477f, -0.03054311f, -0.04404214f, 0.03579779f, 0.01846925f, 0.02639306f, 0.01726049f, 
    0.03624601f, -0.00175337f, -0.04061258f, -0.03097702f, -0.05796387f, 0.03310885f, -0.04742954f, 0.00057172f, 
    -0.02458901f, -0.04984657f, 0.00030162f, 0.04067018f, 0.00460564f, 0.03294184f, 0.01781606f, 0.01032673f, 
    -0.02125940f, 0.01783455f, -0.04925955f, 0.01402044f, 0.01753415f, -0.02327158f, -0.03943865f, -0.01527801f, 
    0.00188415f, -0.04150417f, -0.02627654f, 0.02060798f, 0.02656066f, 0.00326056f, -0.01083780f, -0.04256737f, 
    -0.05274367f, -0.03339770f, -0.02912269f, -0.05083436f, -0.03143876f, -0.00718963f, 0.03466731f, -0.03483871f, 
    -0.01863769f, 0.03782324f, 0.02514965f, 0.03462548f, -0.04384117f, -0.03779564f, 0.00847899f, 0.00718752f, 
    -0.03751074f, -0.02886907f, 0.03470702f, 0.00054010f, -0.04445149f, -0.04671194f, 0.04305598f, 0.04190381f, 
    -0.02054403f, -0.00447973f, -0.02144931f, -0.04025562f, 0.02859277f, 0.02729143f, 0.03829111f, -0.02727542f, 
    0.02884107f, 0.02842135f, 0.02511154f, -0.04938262f, -0.00481733f, 0.03616931f, 0.02184013f, -0.01732528f, 
    0.03388342f, -0.03604640f, -0.02660305f, -0.02695683f, -0.03288241f, -0.03691877f, -0.05220324f, -0.01878965f, 
    0.04007332f, 0.03518984f, -0.01481628f, -0.01858793f, 0.02227077f, 0.03876485f, -0.00537556f, -0.04692585f, 
    0.03652584f, 0.03107856f, -0.05781932f, -0.05142547f, -0.05426773f, -0.03651047f, -0.01407886f, -0.04939250f, 
    -0.03547534f, -0.00563372f, -0.04223333f, -0.02756112f, 0.03562048f, -0.03929309f, -0.05404159f, 0.01958848f, 
    -0.00861590f, 0.04036077f, 0.03342524f, -0.05546805f, 0.03648672f, 0.03812078f, 0.03083030f, 0.03294475f, 
    -0.02910111f, -0.00586805f, 0.02557596f, -0.04374319f, 0.01625618f, 0.00068349f, -0.04935899f, 0.00189069f, 
    -0.03190556f, -0.02943248f, -0.05449073f, -0.01687589f, 0.02744806f, -0.03708806f, 0.02016783f, -0.02213300f, 
    0.01831731f, -0.03882868f, -0.02836773f, 0.03240690f, -0.05344158f, 0.00098447f, 0.01059828f, 0.02641010f, 
    -0.03152236f, -0.05729664f, 0.02694942f, -0.02324828f, 0.02515261f, -0.01320128f, 0.01503118f, 0.03862739f, 
    0.03782615f, 0.01414539f, -0.00949118f, -0.03623912f, 0.03715942f, 0.03823722f, -0.03899432f, 0.02856774f, 
    0.00351194f, 0.01511752f, -0.04455011f, -0.00357776f, 0.03140939f, -0.04304603f, -0.04195318f, -0.05337109f, 
    -0.00601266f, -0.02946063f, 0.04698192f, -0.00243660f, 0.01460481f, 0.01379622f, 0.00564116f, 0.00392369f, 
    0.00785636f, -0.03844900f, -0.03127499f, -0.05135700f, 0.01944448f, -0.01025771f, 0.03301676f, -0.04159421f, 
    -0.01875552f, -0.05210391f, 0.00364797f, 0.00022229f, -0.04940669f, 0.01013798f, -0.00269320f, 0.01839824f, 
    0.01744897f, -0.03848634f, 0.02731310f, -0.02769323f, -0.01613802f, -0.03914214f, -0.05435949f, 0.02038030f, 
    -0.03404048f, 0.00229219f, -0.01060798f, 0.01899795f, -0.03364091f, 0.00092707f, 0.03126040f, -0.05353635f, 
    -0.05399194f, -0.03150421f, 0.02041362f, -0.04798377f, 0.01521765f, -0.04931667f, -0.02276334f, 0.03637671f, 
    0.02869662f, 0.03511460f, 0.04271693f, -0.03285919f, 0.03964251f, 0.01380048f, -0.05632975f, -0.03979433f, 
    -0.03762664f, -0.00270502f, -0.04750669f, 0.01224469f, -0.03678824f, -0.02334365f, -0.02119661f, 0.01664783f, 
    0.02511443f, 0.02700879f, 0.03254076f, 0.00062259f, -0.01193975f, 0.02157135f, 0.02686084f, 0.01284284f, 
    -0.04517529f, -0.03950238f, 0.01638859f, -0.02560908f, -0.04841376f, 0.01873227f, 0.01204748f, 0.00646988f, 
    0.03735257f, -0.00564248f, 0.01768894f, -0.03207327f, -0.03945825f, 0.02563507f, 0.00274694f, -0.00420388f, 
    -0.05818120f, -0.04773612f, -0.05087450f, 0.02495247f, -0.04156946f, -0.00438269f, 0.01905804f, 0.03474799f, 
    -0.00813015f, -0.00887113f, 0.01911663f, -0.03377311f, 0.01966981f, -0.04888146f, 0.02484908f, 0.00330174f, 
    -0.04630311f, -0.03789006f, -0.03315896f, -0.03637186f, 0.04032405f, 0.00356017f, 0.03804151f, -0.02079868f, 
    -0.13057299f, 0.23888706f, -0.05386994f, 0.17784083f, 0.05188630f, -0.00091416f, 0.01392076f, 0.02598203f, 
    0.02778644f, -0.17053102f, -0.05116335f, -0.04151439f, -0.06649303f, -0.07137336f, 0.43506142f, -0.18578039f, 
    0.03474802f, 0.16445518f, 0.18845457f, 0.03790565f, -0.18050244f, -0.00532276f, 0.01566501f, 0.07012122f, 
    -0.22823773f, 0.11692034f, 0.03246590f, 0.03875490f, -0.11520597f, -0.21416149f, -0.05101817f, 0.06159155f, 
    0.02709130f, -0.04428394f, 0.10006831f, 0.04474168f, 0.30488646f, 0.16579165f, 0.27238646f, 0.14314491f, 
    -0.01101597f, 0.22093144f, -0.07430311f, 0.19593348f, -0.16840835f, 0.01618802f, 0.11509803f, -0.00766951f, 
    0.13504717f, -0.09491839f, 0.06349681f, -0.02721793f, -0.00473004f, -0.00823976f, 0.26522619f, -0.02669198f, 
    -0.02888290f, 0.02758369f, -0.14502339f, 0.12727170f, 0.10247356f, 0.04308812f, 0.24879059f, 0.00729037f, 
    -0.05703642f, -0.01646322f, 0.07307002f, 0.07587297f, -0.02990911f, -0.03391381f, -0.00368891f, -0.00499358f, 
    -0.22931609f, -0.27419192f, 0.07725440f, -0.33907968f, 0.06520553f, -0.02962176f, 0.03303513f, -0.05536685f, 
    -0.04970788f, -0.01478775f, -0.04408880f, 0.09225417f, 0.42602286f, -0.16198425f, 0.28218663f, -0.29018626f, 
    -0.03312916f, -0.06315996f, 0.05352234f, 0.02634541f, -0.01517980f, 0.09556969f, 0.18930367f, 0.13576521f, 
    0.01917420f, 0.00261112f, -0.01279685f, -0.07222143f, 0.13546169f, -0.07462962f, -0.15745123f, 0.08766078f, 
    0.07921997f, 0.08636635f, -0.01635150f, 0.00665194f, 0.24501607f, -0.32671475f, -0.23086627f, -0.20217331f, 
    0.00269406f, -0.13426761f, 0.05826600f, 0.11467849f, 0.00151151f, 0.04785734f, -0.02610565f, 0.04541324f, 
    0.38498008f, -0.19559303f, 0.01881589f, -0.05675896f, 0.01207334f, 0.10544667f, 0.19904475f, -0.00679964f, 
    -0.20249039f, 0.08445328f, -0.12756346f, 0.01817284f, -0.09201303f, 0.16059780f, 0.04148364f, 0.38308316f, 
    -0.12329217f, 0.02586087f, 0.07948405f, -0.10346889f, -0.02778298f, -0.03998648f, 0.08593091f, -0.04629480f, 
    -0.16732436f, -0.07717218f, 0.19627258f, -0.21428883f, 0.02585914f, 0.26163271f, 0.12476977f, -0.00231718f, 
    -0.09745643f, 0.10120822f, 0.13471311f, 0.02179029f, 0.16039926f, -0.17377129f, -0.15070692f, -0.21904838f, 
    -0.15546156f, -0.00750527f, -0.19686639f, 0.09752707f, -0.01149105f, -0.07265723f, 0.05189886f, -0.11688010f, 
    0.27076527f, -0.06317126f, -0.01040740f, 0.05662720f, -0.04541794f, 0.05052074f, 0.06527779f, 0.08317102f, 
    -0.00247414f, -0.00416566f, -0.08079662f, 0.21585438f, -0.11242732f, -0.06451405f, 0.16760260f, 0.07983910f, 
    -0.07456372f, 0.15319818f, -0.08465270f, 0.13436215f, 0.16647243f, 0.25824261f, -0.01660700f, 0.09976733f, 
    -0.27299798f, 0.05943395f, 0.05679026f, 0.19295223f, -0.09900352f, 0.04098580f, 0.14192805f, 0.01219630f, 
    -0.04869420f, 0.09996846f, 0.00773716f, 0.01166299f, 0.21883121f, 0.01955701f, 0.02884527f, 0.16201365f, 
    0.11621675f, 0.09341113f, 0.09841449f, 0.12640759f, 0.00353817f, 0.09193136f, -0.06298922f, -0.16800918f, 
    0.02432641f, -0.16817148f, -0.10961409f, 0.17810152f, 0.13759963f, 0.14282854f, -0.05818613f, 0.04635135f, 
    0.07774655f, 0.10450529f, -0.10619173f, -0.00801074f, -0.31499699f, 0.11582884f, 0.24221998f, -0.11618941f, 
    -0.13627084f, 0.01895147f, 0.08424935f, 0.07066417f, 0.06938658f, -0.04751383f, -0.12576984f, -0.01515370f, 
    0.09324995f, -0.08160847f, -0.13913701f, 0.00564173f, -0.10233144f, 0.06308226f, -0.00077434f, -0.05308803f, 
    0.02904218f, 0.05328399f, 0.16334507f, 0.11763028f, 0.00222093f, -0.24927591f, -0.05448829f, 0.14323990f, 
    -0.12333778f, 0.01728384f, -0.04645060f, 0.05009575f, 0.01645386f, 0.08334000f, -0.04927713f, 0.08103561f, 
    0.36754364f, 0.24290343f, 0.17580223f, -0.06629794f, -0.01781066f, 0.13764389f, 0.08349025f, -0.08485718f, 
    0.04380615f, -0.00053620f, 0.11318728f, -0.08143236f, 0.03856997f, 0.03436602f, 0.01896390f, 0.34038368f, 
    -0.12871113f, 0.21820083f, 0.05494249f, -0.02137999f, 0.00428596f, 0.12918748f, 0.15205103f, -0.12907310f, 
    0.06857391f, -0.07148352f, 0.25113538f, -0.10395783f, -0.24383728f, 0.00405925f, 0.01835324f, 0.15408549f, 
    0.06481083f, -0.06738359f, 0.05363797f, 0.10689840f, 0.27160236f, -0.13469961f, -0.22041371f, 0.02337883f, 
    0.03893996f, 0.08706227f, 0.11305747f, -0.12227093f, 0.01884755f, 0.23630105f, 0.02699562f, 0.09023209f, 
    -0.13081516f, 0.33764368f, 0.33303392f, 0.16026919f, -0.16864787f, 0.02595061f, 0.11109241f, -0.06385127f, 
    0.06763880f, -0.10908765f, 0.04187239f, 0.04060199f, -0.02379825f, -0.32972607f, 0.21660958f, 0.03261920f, 
    -0.03425181f, 0.04530780f, 0.08834872f, 0.11944763f, 0.00894349f, -0.02598768f, -0.03123417f, 0.01544760f, 
    0.34988531f, -0.06355499f, -0.13680229f, -0.29861864f, 0.01667625f, -0.01435419f, -0.01115102f, -0.01965627f, 
    0.00070623f, 0.02770076f, -0.06946451f, -0.11544631f, 0.29642755f, -0.43461165f, 0.19219549f, -0.20390482f, 
    0.04271439f, -0.24775639f, 0.13268135f, 0.14768685f, -0.13528173f, -0.09303869f, 0.00264392f, 0.08216761f, 
    0.05515397f, -0.01198068f, -0.15345244f, 0.18538921f, 0.09944431f, -0.05889965f, -0.00965759f, 0.09446796f, 
    0.10878742f, -0.02261895f, -0.01210793f, -0.05050819f, 0.08271996f, -0.33887732f, -0.00463657f, -0.36850148f, 
    -0.01184450f, -0.06340826f, 0.07448734f, 0.06301486f, -0.07117355f, 0.08525082f, 0.07971671f, 0.15408115f, 
    0.55076349f, -0.13511048f, -0.28898814f, 0.00737374f, -0.02632886f, 0.17846100f, 0.10223011f, 0.15657327f, 
    0.15431781f, -0.01937287f, 0.07038788f, 0.01470524f, -0.16819158f, 0.01793845f, 0.00657806f, 0.12210225f, 
    0.00893115f, -0.09325381f, 0.14888471f, 0.01192824f, -0.10440339f, -0.15199111f, -0.04031120f, -0.19519337f, 
    0.48286909f, -0.17418866f, -0.05435044f, 0.05009240f, 0.07551946f, 0.01850523f, 0.13013355f, -0.10406666f, 
    -0.12089957f, 0.03625247f, 0.04312478f, -0.00689099f, 0.27176663f, -0.11313170f, -0.04530367f, -0.22961342f, 
    -0.25301978f, -0.08565461f, -0.09885012f, -0.01736728f, 0.12379288f, 0.00779939f, 0.08098980f, 0.04158985f, 
    -0.59050447f, -0.04470497f, 0.17161135f, -0.02930390f, 0.09723253f, 0.01845602f, -0.15813969f, 0.02783054f, 
    0.07983570f, 0.13715015f, 0.09100775f, 0.01679941f, -0.19342083f, 0.38836229f, 0.25826684f, -0.11882906f, 
    0.19067474f, -0.00271251f, 0.05396530f, 0.01875454f, 0.06277876f, 0.04914667f, 0.01149172f, 0.06826130f, 
    -0.05065532f, 0.15011519f, -0.01775469f, 0.08442654f, 0.09309260f, -0.07460477f, 0.00450624f, 0.15441260f, 
    0.03053426f, -0.01297459f, 0.09166971f, -0.01981571f, 0.17041652f, 0.33656403f, 0.03028993f, 0.09785330f, 
    -0.00945680f, -0.13300455f, 0.03603270f, 0.03381332f, 0.11222298f, 0.02844299f, 0.13434200f, -0.05548152f, 
    0.15197074f, -0.31672814f, -0.01769364f, -0.11043194f, 0.13387641f, 0.05821268f, -0.06048915f, -0.08931016f, 
    0.06754625f, -0.04272606f, 0.01209007f, -0.06907666f, -0.26095819f, -0.02392600f, 0.05372566f, 0.13188599f, 
    0.23225917f, 0.09825473f, 0.01705493f, 0.01868050f, 0.06024325f, 0.05323544f, 0.04758370f, 0.02815644f, 
    -0.31479374f, 0.26734462f, 0.12331467f, -0.09962183f, 0.05440896f, 0.02427726f, 0.00195587f, 0.00355883f, 
    0.03158789f, -0.08305749f, 0.05337876f, 0.03650375f, 0.10897241f, 0.09912911f, 0.21718733f, 0.03641025f, 
    0.07265068f, 0.03665062f, -0.04037035f, -0.04636730f, 0.13946532f, 0.03991684f, 0.14858651f, -0.09061080f, 
    -0.19559336f, -0.19762933f, 0.01421134f, -0.08823922f, -0.01587121f, -0.11246984f, 0.01066107f, -0.11630673f, 
    -0.07752378f, -0.06240276f, 0.03440146f, 0.04044262f, -0.07872353f, -0.02764464f, 0.06722670f, -0.03344868f, 
    0.05597799f, 0.06276486f, 0.07478575f, -0.04757360f, 0.05415964f, 0.13316143f, 0.07703217f, -0.06190106f, 
    -0.17755581f, 0.18534042f, 0.26834092f, -0.31699696f, 0.03608160f, 0.01877516f, 0.02829824f, -0.03377400f, 
    -0.00508636f, 0.00629164f, -0.00280755f, -0.04972545f, 0.31469408f, 0.27655923f, 0.27022195f, 0.11909911f, 
    0.03377572f, 0.01533571f, -0.00013265f, 0.16057156f, -0.07706278f, 0.02517989f, 0.00732757f, -0.09582203f, 
    0.30947027f, 0.03029089f, 0.00339604f, 0.30288032f, 0.02222881f, -0.04367545f, 0.12842795f, -0.09360513f, 
    0.07932138f, -0.09732240f, -0.11214092f, 0.03420735f, 0.00947409f, -0.02742230f, -0.20013426f, -0.27720574f, 
    -0.10146093f, -0.04806756f, -0.13999787f, -0.11223461f, 0.04312432f, 0.03632950f, -0.10967395f, -0.04467315f, 
    -0.45671269f, 0.02089170f, 0.04916835f, 0.11236843f, 0.02754329f, 0.09260782f, -0.15061635f, 0.01537079f, 
    0.15842777f, -0.16463751f, -0.11218030f, -0.00439024f, -0.04706655f, 0.12750435f, 0.09280177f, 0.07052617f, 
    0.03008037f, 0.09525893f, 0.04454769f, 0.01958462f, -0.00941640f, 0.06501780f, 0.09937518f, 0.02366295f, 
    -0.37597898f, 0.12513350f, 0.09333583f, -0.08228361f, 0.06046120f, -0.01141558f, 0.01012678f, -0.07118560f, 
    0.13696557f, 0.07206631f, 0.06829295f, 0.04832913f, 0.06589703f, 0.48746148f, 0.06640439f, -0.07371441f, 
    0.13163136f, -0.00167389f, 0.00676418f, -0.01062576f, -0.07107073f, 0.18161142f, 0.14459620f, -0.12435993f, 
    0.06056865f, -0.14270617f, 0.28084925f, 0.04214530f, 0.04524444f, 0.12316634f, 0.04691003f, -0.04597664f, 
    0.08995821f, 0.05831499f, 0.05614237f, 0.03890422f, 0.34167159f, -0.06935717f, 0.08852407f, -0.17901665f, 
    -0.09320999f, -0.06220830f, -0.00615945f, -0.00377615f, 0.09874643f, 0.04946749f, -0.07590332f, 0.06874330f, 
    0.09406324f, 0.16192892f, 0.29254729f, 0.12040711f, 0.04667329f, -0.02961373f, 0.12892379f, 0.05131279f, 
    -0.04091217f, 0.06656974f, -0.03533524f, 0.11024346f, 0.01203723f, -0.01151851f, 0.20596677f, -0.05977694f, 
    0.07548133f, 0.16783009f, -0.12394490f, 0.02006508f, -0.08440720f, -0.03087138f, 0.10276181f, 0.14180271f, 
    -0.09616850f, 0.06957547f, 0.22423938f, -0.01623662f, 0.04388862f, -0.03765703f, 0.04523613f, 0.03321093f, 
    -0.22196446f, -0.11456702f, 0.13325824f, 0.04654672f, -0.26301584f, 0.04110134f, 0.07311448f, -0.12262929f, 
    0.07881761f, 0.10541645f, 0.07751090f, 0.04799454f, 0.10872722f, -0.11137759f, -0.03565766f, 0.04021776f, 
    0.47634000f, -0.13746390f, 0.07555434f, 0.31032848f, 0.07498772f, -0.01429387f, 0.05614349f, 0.09428852f, 
    0.04765086f, 0.12380683f, 0.02000609f, 0.21582051f, 0.08458691f, 0.28474343f, 0.01642782f, 0.05998990f, 
    0.07021233f, -0.00480486f, 0.05269006f, 0.12120566f, 0.04566889f, -0.13249099f, -0.03849794f, 0.08572896f, 
    -0.09942715f, -0.05689550f, -0.19055612f, 0.01213948f, 0.00243660f, 0.14623740f, 0.02972437f, -0.17270522f, 
    0.03545454f, 0.06856929f, 0.04021874f, 0.22701639f, -0.33444726f, 0.12824710f, 0.13333933f, 0.18620653f, 
    0.05532197f, -0.02235444f, 0.05655622f, 0.12106725f, 0.03234651f, -0.13817614f, -0.04629621f, -0.08356146f, 
    -0.00272671f, -0.04586853f, 0.00336714f, -0.03027852f, -0.00407250f, -0.05693256f, 0.01537320f, 0.02939374f, 
    0.00153929f, 0.03750555f, -0.00645321f, 0.00840270f, -0.00919568f, -0.03641714f, 0.01909105f, 0.02664013f, 
    0.02375187f, 0.00627112f, -0.00281780f, 0.00822038f, -0.00510681f, -0.03979600f, -0.00955911f, 0.04061483f, 
    -0.01575827f, -0.04315915f, -0.00649326f, -0.00300434f, -0.04371735f, 0.04062542f, 0.00909206f, 0.00210480f, 
    -0.03159626f, 0.02314244f, -0.00851672f, -0.03215718f, 0.01073272f, -0.02964260f, -0.04309590f, 0.02356438f, 
    0.00513931f, -0.04880717f, 0.02105613f, -0.04708330f, -0.00492633f, 0.01593189f, -0.01684216f, -0.05336678f, 
    0.02908170f, -0.02236767f, 0.02970872f, -0.01751000f, 0.04035999f, 0.01916013f, -0.03602220f, 0.02779157f, 
    -0.01795252f, -0.04673110f, 0.03728513f, -0.02499120f, 0.02963126f, -0.03185747f, -0.04095150f, 0.01413114f, 
    0.03147666f, -0.01840892f, 0.02831985f, -0.01764994f, -0.04943540f, -0.00540578f, 0.02444597f, 0.02187785f, 
    0.04316158f, 0.00237732f, -0.03583346f, -0.05653100f, -0.01564770f, -0.00110246f, -0.01071917f, -0.05346113f, 
    0.03323393f, -0.00155425f, -0.05123966f, -0.05467910f, 0.00116269f, 0.00333805f, 0.04217720f, -0.04028323f, 
    -0.01331191f, -0.03730367f, 0.03395830f, 0.02183072f, -0.01212599f, 0.01961260f, -0.03495126f, -0.05684356f, 
    0.01466696f, -0.02002686f, 0.02374892f, 0.00176990f, 0.02809821f, -0.01375617f, 0.03138223f, -0.03551111f, 
    -0.04277729f, 0.00427898f, 0.03589870f, 0.01089427f, -0.02606381f, -0.02606734f, 0.04200701f, 0.00991825f, 
    -0.02584394f, -0.05001867f, 0.00363060f, 0.01282731f, -0.02087475f, -0.00473069f, -0.03957618f, 0.02684801f, 
    0.04436688f, -0.02324510f, -0.05519622f, -0.03316372f, -0.04867198f, -0.03588878f, -0.03442249f, 0.02154429f, 
    -0.04903455f, -0.01364498f, -0.01178993f, -0.03922767f, -0.01065309f, -0.01074780f, 0.00061783f, 0.01660279f, 
    -0.00567896f, -0.03951193f, 0.00485276f, -0.03454802f, 0.02320350f, -0.04138162f, -0.00110153f, 0.02600528f, 
    -0.00660054f, -0.00806262f, 0.03371964f, -0.00630776f, -0.03729267f, -0.00038411f, -0.04534522f, 0.01666475f, 
    -0.00235905f, -0.02515921f, -0.04415386f, 0.01878504f, -0.05445678f, -0.01227101f, -0.04260338f, 0.03442138f, 
    0.00132535f, -0.03056265f, 0.04251174f, 0.01467438f, 0.04439785f, -0.03237547f, 0.00832519f, 0.01343634f, 
    0.01772837f, 0.01100156f, -0.03208977f, 0.00663671f, -0.04114395f, -0.05397233f, -0.03317065f, -0.00661727f, 
    -0.01253875f, 0.00240454f, -0.03374748f, 0.03286720f, -0.05698653f, 0.00153757f, 0.04083183f, 0.04180872f, 
    0.02742011f, -0.00389468f, -0.05319874f, -0.04699733f, -0.02769593f, -0.01206794f, 0.01500000f, -0.00573807f, 
    -0.00415439f, -0.01686045f, 0.03667573f, 0.04306305f, 0.01795125f, 0.04388192f, 0.00210233f, -0.02314765f, 
    -0.01336259f, -0.03586385f, 0.01914985f, 0.03725947f, -0.04745895f, -0.01275278f, 0.01566422f, -0.00597986f, 
    -0.00516936f, 0.00124340f, -0.02865943f, -0.03982068f, -0.03747688f, -0.04002813f, -0.02025875f, -0.02177521f, 
    0.03516937f, -0.01184864f, 0.01821327f, -0.04094576f, -0.04445981f, 0.03318676f, -0.05625731f, 0.03421434f, 
    0.00415391f, 0.01760250f, -0.03800275f, 0.00909486f, 0.01508994f, -0.03140530f, -0.03270158f, 0.01695927f, 
    -0.01309340f, 0.02735909f, -0.04717264f, 0.00744983f, 0.02621270f, 0.01847306f, -0.02050587f, -0.05111131f, 
    -0.00900927f, 0.00357440f, 0.01668183f, -0.00089611f, -0.04082438f, 0.01137937f, -0.00248453f, 0.02345635f, 
    -0.01156491f, -0.01469342f, 0.01463056f, 0.01812636f, -0.04316632f, -0.00504220f, 0.00810506f, 0.03278155f, 
    -0.03650230f, 0.01235414f, 0.03867251f, 0.03351061f, -0.03740866f, 0.00220112f, 0.00960343f, 0.01245787f, 
    -0.01504922f, -0.02729536f, -0.04976235f, 0.01329172f, -0.03063325f, -0.02744969f, 0.01070853f, 0.03725320f, 
    -0.01356156f, 0.04360575f, 0.01514232f, -0.03712994f, 0.00858080f, 0.00566255f, 0.03419932f, -0.05699902f, 
    0.01694324f, 0.04381900f, -0.04660884f, -0.04863793f, 0.03958585f, -0.00298034f, -0.00065950f, -0.02189929f, 
    -0.00237657f, 0.03766010f, 0.00279927f, -0.03802509f, 0.03100659f, -0.01486286f, -0.01159000f, -0.02919245f, 
    -0.02848159f, 0.00827683f, -0.05210647f, 0.03267212f, -0.02809995f, -0.04369335f, -0.04740963f, 0.03947829f, 
    0.02751611f, -0.04032058f, -0.02649204f, 0.01745737f, 0.03092463f, 0.00964467f, -0.00241715f, -0.01018562f, 
    -0.01802435f, 0.01618666f, -0.05325620f, 0.01104069f, 0.03836068f, -0.03596153f, -0.00278596f, 0.01519721f, 
    0.01698806f, -0.04268181f, 0.02837405f, -0.04569145f, 0.03024098f, -0.02053784f, -0.02112450f, 0.01608955f, 
    -0.00039652f, -0.00334673f, 0.00716914f, 0.00770861f, -0.00363492f, -0.00383046f, -0.05532985f, -0.02206873f, 
    -0.03153118f, 0.01716993f, 0.00790590f, -0.03125278f, 0.00414656f, 0.03005283f, -0.02613570f, -0.04787546f, 
    0.02619722f, -0.02069789f, -0.00609417f, -0.05337738f, -0.03988384f, 0.01295095f, 0.02854427f, 0.00489186f, 
    -0.03192125f, 0.02082368f, -0.03017870f, 0.00185362f, -0.03114509f, -0.03999399f, -0.02858733f, 0.02173837f, 
    -0.04674369f, -0.03070269f, 0.00096068f, -0.00560993f, -0.02468852f, -0.04490976f, -0.04312506f, 0.01848154f, 
    0.00242879f, -0.04771673f, -0.01019471f, 0.03607364f, -0.03163701f, 0.01272957f, 0.04241591f, -0.00209885f, 
    0.01585490f, 0.00335742f, -0.04795460f, -0.04644712f, -0.02707075f, 0.02945448f, -0.02278266f, 0.01726457f, 
    -0.49020538f, 0.00215602f, 0.06185045f, -0.11600915f, -0.01149213f, -0.12667757f, -0.01346016f, -0.09078366f, 
    -0.02999509f, -0.01494165f, 0.09698223f, -0.04522747f, 0.15196872f, -0.18510929f, -0.00225395f, -0.09873761f, 
    0.16422808f, -0.04807027f, 0.08741768f, -0.02489467f, 0.07298645f, 0.03853544f, 0.12017131f, 0.07041955f, 
    -0.23729195f, 0.06014382f, -0.18639903f, -0.07934470f, -0.26000294f, 0.05373760f, 0.04807147f, 0.13645533f, 
    0.06614523f, 0.01693777f, -0.05596525f, -0.06559861f, 0.17726505f, 0.12653232f, 0.13085869f, 0.08176950f, 
    0.22580238f, -0.03060165f, -0.10110369f, 0.01804762f, -0.02202858f, 0.08742557f, 0.00685378f, 0.19663273f, 
    0.20761624f, -0.09235188f, -0.08450653f, 0.04321494f, -0.05803129f, 0.11932027f, 0.03880274f, 0.02143435f, 
    0.03252728f, 0.06220738f, 0.10479453f, -0.16200556f, 0.00562777f, 0.00856111f, 0.31667849f, 0.27564022f, 
    0.08249416f, 0.07143546f, 0.14294098f, -0.03251009f, 0.10499900f, 0.24704817f, -0.00603493f, 0.15498656f, 
    -0.33497858f, -0.05242950f, -0.15029167f, 0.11275684f, -0.08703146f, 0.00694158f, -0.10548030f, -0.28615135f, 
    0.04419670f, -0.11787823f, 0.07935597f, -0.06238491f, 0.03321578f, -0.20082076f, 0.00741185f, 0.05422806f, 
    0.03403675f, -0.03347706f, 0.10508613f, -0.09186831f, -0.11905454f, -0.15927760f, -0.01183662f, 0.25654125f, 
    -0.12167876f, 0.32798731f, -0.15333721f, 0.12446991f, -0.31806350f, -0.00319846f, 0.11289736f, 0.02502232f, 
    0.00104287f, -0.01040046f, 0.18768065f, 0.16117494f, 0.17761219f, 0.02426627f, -0.00753079f, 0.11281104f, 
    -0.01383093f, 0.01941356f, -0.10376773f, 0.03402087f, -0.10784762f, -0.01650517f, 0.05220913f, 0.09723753f, 
    0.19003101f, -0.26009721f, 0.17828463f, 0.46751469f, 0.09541875f, 0.21885593f, 0.02952191f, 0.11380807f, 
    0.20863235f, 0.07522266f, 0.12737359f, -0.00333928f, -0.04902130f, 0.03787145f, -0.05855978f, 0.20608222f, 
    0.00387243f, -0.05995598f, -0.04631772f, 0.31418127f, 0.02923778f, 0.02439672f, -0.06752076f, 0.20732190f, 
    -0.12190385f, 0.33408701f, -0.12537134f, 0.13181925f, -0.02686037f, -0.06866729f, 0.16720265f, 0.08210444f, 
    0.04464695f, 0.24226414f, 0.12934943f, 0.07561368f, 0.01032892f, -0.08570483f, 0.00240841f, 0.04555970f, 
    0.01995164f, -0.16710418f, 0.07564069f, 0.12823233f, -0.17825152f, 0.01472686f, -0.00622964f, 0.06575172f, 
    0.32864669f, -0.16223809f, 0.15049009f, 0.15756813f, 0.00242485f, 0.19007805f, -0.04103243f, 0.04013727f, 
    0.11522744f, 0.10655709f, 0.21363384f, 0.21408454f, 0.49908653f, -0.11107320f, 0.29194063f, -0.08188102f, 
    -0.07581768f, -0.03524496f, -0.05637971f, 0.05348334f, 0.14946294f, 0.01374463f, 0.02161417f, 0.01146165f, 
    0.16659681f, 0.00563367f, 0.14392449f, -0.02421487f, -0.08260535f, -0.02561763f, -0.02329383f, 0.12079831f, 
    0.03909678f, 0.08512902f, 0.00013920f, -0.03694629f, 0.01292999f, 0.03809098f, -0.21873888f, -0.16787094f, 
    -0.04752871f, 0.01025868f, 0.16183956f, 0.03454393f, 0.12897441f, -0.08928414f, -0.03114613f, -0.11067158f, 
    0.56471807f, -0.32611424f, -0.12777612f, -0.18616706f, 0.04789340f, -0.03700985f, -0.06785213f, 0.08417853f, 
    0.00169732f, -0.05264683f, -0.05210355f, 0.04708840f, -0.04836329f, 0.00681358f, -0.19697252f, -0.10312160f, 
    0.05179397f, -0.19215673f, 0.12660851f, 0.00287739f, -0.10576599f, -0.13065997f, -0.08112858f, -0.11848859f, 
    0.04686290f, -0.20616210f, 0.20261596f, -0.16395028f, -0.00220419f, 0.00000149f, 0.08989376f, -0.05910756f, 
    0.01267391f, 0.14795217f, -0.09153139f, -0.01091814f, 0.27213627f, -0.24466690f, 0.36832067f, 0.04978034f, 
    0.01208758f, -0.01812849f, -0.01035314f, 0.02314431f, 0.07190543f, 0.02482272f, -0.00629580f, 0.16383977f, 
    -0.48776281f, 0.27508390f, -0.05137035f, 0.01184394f, 0.16861987f, 0.02920662f, -0.13440949f, 0.04482450f, 
    0.02047623f, 0.03564160f, 0.12443850f, -0.15998451f, 0.00117815f, 0.01315203f, 0.18278825f, 0.12212604f, 
    0.10369117f, 0.08022598f, -0.16869225f, 0.18349816f, -0.04720604f, -0.23443015f, 0.04575725f, 0.16207990f, 
    0.27114081f, -0.09252892f, 0.04300343f, -0.10392376f, 0.22259253f, 0.10243862f, 0.08554864f, 0.00077247f, 
    0.07329146f, -0.04879200f, 0.16563413f, 0.08487719f, 0.25061539f, -0.06048908f, -0.15762101f, 0.11181401f, 
    -0.08717328f, -0.01398008f, -0.16465585f, 0.09945886f, 0.08513867f, -0.12325782f, -0.12006374f, -0.11962989f, 
    -0.09975886f, 0.21432632f, -0.07112557f, 0.12983441f, 0.03695694f, -0.00368493f, -0.06367033f, 0.10582729f, 
    0.23549558f, -0.04881099f, -0.08765239f, 0.12084001f, 0.27010861f, 0.05807287f, 0.00817538f, -0.11314956f, 
    0.13435364f, 0.01008885f, -0.00759952f, 0.02421978f, -0.03094742f, 0.15144600f, 0.16963619f, 0.17258394f, 
    -0.07596699f, 0.03158172f, -0.14247265f, 0.00441226f, -0.10966283f, -0.10594493f, 0.03422971f, -0.23585378f, 
    0.04697559f, -0.09527104f, -0.02456377f, -0.14496642f, -0.11448168f, -0.25740120f, -0.10232598f, -0.01998453f, 
    -0.03578619f, 0.10923056f, 0.02052468f, -0.19196086f, -0.06679548f, 0.14010432f, -0.02907945f, 0.06278803f, 
    -0.60822248f, -0.14096609f, 0.07796694f, -0.25674570f, -0.13303439f, 0.02759332f, 0.09068731f, -0.13583939f, 
    0.17811640f, 0.00044013f, -0.21524099f, 0.07134637f, 0.32479522f, -0.10047740f, -0.18785951f, -0.13902408f, 
    0.09346880f, 0.11671831f, 0.06699416f, -0.08926620f, 0.08568203f, -0.05853508f, -0.11293693f, -0.05542926f, 
    -0.00959750f, -0.05527100f, -0.03019442f, 0.04289731f, -0.01269824f, 0.01936487f, -0.04176163f, 0.00869438f, 
    -0.04376061f, -0.00407422f, -0.05364207f, 0.00815481f, -0.03756802f, -0.05764227f, -0.04810116f, -0.01693085f, 
    -0.02553179f, 0.00789009f, 0.00977493f, -0.03510717f, 0.02563826f, -0.05338500f, -0.04142841f, -0.02926933f, 
    -0.01668687f, 0.01936808f, -0.03609294f, -0.00955229f, -0.03283790f, 0.04027135f, 0.00138926f, -0.03788039f, 
    -0.00953727f, -0.04889413f, -0.01811240f, -0.03251962f, -0.04317582f, -0.04223935f, -0.04292307f, -0.00701397f, 
    -0.04625661f, -0.04322457f, -0.04465180f, -0.04103016f, -0.05139088f, -0.03567980f, 0.02205518f, -0.03577091f, 
    0.04402503f, -0.01569375f, -0.01267274f, -0.00521872f, -0.03600289f, 0.01024774f, -0.01332294f, 0.03174511f, 
    -0.04561274f, 0.03782403f, -0.02123630f, 0.01911714f, -0.00951199f, 0.00492392f, 0.04285341f, -0.03949922f, 
    -0.04931175f, 0.01377474f, -0.00280645f, 0.02248915f, -0.01903560f, -0.00252292f, -0.01695272f, -0.03455398f, 
    -0.02273180f, 0.03518657f, 0.01555425f, -0.00591448f, 0.03470703f, -0.05397183f, 0.03597708f, 0.00214388f, 
    0.02885549f, 0.02303823f, 0.01340907f, 0.00137837f, -0.00112639f, -0.03785625f, -0.04086462f, -0.02944552f, 
    0.04179197f, -0.03991450f, -0.05410777f, 0.04043521f, -0.04353568f, -0.02850043f, -0.00431934f, 0.03340888f, 
    0.02024735f, -0.04678033f, 0.03160491f, -0.01504314f, -0.00286769f, 0.00257424f, 0.02915844f, -0.02304292f, 
    0.00094272f, -0.02255237f, 0.00720648f, -0.04738982f, -0.01008499f, -0.03670581f, 0.02916116f, 0.02068533f, 
    -0.03364193f, -0.00216617f, 0.03801386f, -0.02713150f, -0.05450038f, 0.03633324f, 0.01795801f, -0.05509477f, 
    0.02858359f, 0.03676406f, 0.01690961f, -0.04020946f, 0.01914562f, -0.01806723f, 0.01784468f, 0.04398977f, 
    -0.00128853f, 0.04139631f, 0.01873685f, -0.00976405f, -0.01645704f, 0.00751913f, -0.02393886f, -0.04758025f, 
    -0.01482290f, 0.01910369f, 0.02059465f, -0.04427683f, -0.04144088f, -0.05219043f, 0.03749778f, 0.02826458f, 
    -0.00621153f, -0.01091868f, -0.03369673f, -0.01381913f, -0.00602791f, 0.01310645f, 0.04268406f, 0.00862976f, 
    -0.04565470f, -0.02084451f, -0.04182719f, -0.05429910f, -0.00364372f, 0.03641317f, 0.03629898f, -0.03637049f, 
    -0.05629256f, 0.00484494f, 0.01504554f, 0.00812919f, -0.00124841f, 0.03178991f, -0.00402326f, 0.02860671f, 
    0.00229221f, -0.03171079f, -0.00249582f, 0.00711590f, 0.01054930f, -0.01189209f, -0.04287259f, 0.02719657f, 
    0.00815956f, -0.02502956f, -0.00594824f, 0.03398576f, 0.02666100f, 0.02158661f, -0.04514925f, 0.01920952f, 
    -0.00822040f, -0.04400510f, -0.02555938f, 0.02932391f, -0.00933421f, 0.04199544f, -0.02545311f, 0.00865598f, 
    0.02287691f, -0.03905540f, -0.00083837f, -0.00054475f, 0.04170121f, -0.04112416f, -0.00264301f, -0.00525332f, 
    0.00940701f, -0.02346157f, -0.05319309f, -0.02431193f, 0.00009087f, 0.01762212f, 0.00112005f, 0.00707970f, 
    -0.00344169f, -0.04609167f, -0.02627921f, -0.01854804f, -0.03105834f, -0.00152215f, -0.05550026f, -0.02710256f, 
    -0.04197389f, -0.02992609f, 0.03101542f, -0.01786437f, 0.03244518f, 0.02273596f, -0.00272539f, 0.00069610f, 
    0.02251387f, -0.01618242f, -0.03400586f, -0.00461245f, -0.00382330f, 0.02020696f, 0.03823889f, 0.03596245f, 
    0.01143002f, -0.05418615f, -0.02092825f, -0.04928899f, 0.02823596f, -0.02879320f, -0.02396952f, 0.04178431f, 
    0.03116147f, -0.03699426f, -0.04300871f, 0.00680732f, 0.02767625f, -0.00088324f, -0.03791826f, 0.00005837f, 
    0.03776194f, -0.02824784f, -0.02586037f, 0.02479258f, 0.01200294f, -0.02330874f, -0.02686002f, 0.00701084f, 
    -0.03436152f, 0.00315009f, -0.04942423f, -0.03988493f, -0.03453490f, 0.03726962f, 0.00838264f, 0.01021359f, 
    -0.04122762f, -0.05366174f, 0.04316958f, 0.00027054f, 0.02063361f, 0.01696217f, 0.02123214f, 0.03558015f, 
    0.02943931f, 0.02907184f, -0.00546188f, -0.04576343f, -0.01235357f, 0.03130500f, 0.04293627f, 0.00474189f, 
    -0.00983605f, 0.02546266f, -0.00132350f, 0.02419987f, 0.02001261f, 0.01155111f, -0.00381028f, -0.00293437f, 
    -0.01707121f, -0.01795318f, -0.03392627f, 0.01623133f, -0.01428376f, -0.05639432f, 0.02598169f, -0.03023873f, 
    0.00317145f, 0.02924324f, -0.04766973f, 0.03933693f, -0.00254895f, -0.04014929f, -0.04436297f, 0.03895202f, 
    0.02198499f, -0.03260414f, -0.00509495f, -0.01420037f, 0.03497462f, 0.03321780f, -0.00374399f, -0.04253874f, 
    -0.03023644f, 0.01167554f, -0.03486886f, -0.05171145f, 0.01578847f, 0.01823101f, -0.03363288f, 0.02090733f, 
    -0.04653015f, -0.05288037f, 0.01733847f, 0.01805095f, -0.04810233f, 0.01222749f, 0.02259596f, -0.00510029f, 
    -0.00285012f, 0.00814710f, -0.04430165f, 0.03720457f, 0.01589929f, -0.03690968f, 0.02389412f, -0.00350704f, 
    0.02765586f, 0.00898813f, 0.00338483f, -0.02246701f, -0.02611930f, -0.03326739f, 0.01591315f, 0.01045483f, 
    -0.00841346f, -0.05050534f, 0.01935017f, -0.01288449f, -0.02725812f, 0.02117650f, -0.04869160f, -0.02932706f, 
    0.02392810f, -0.00119146f, 0.03634566f, -0.03261818f, -0.00809635f, -0.02781107f, 0.02333153f, -0.02831515f, 
    0.02736255f, -0.05481283f, 0.00961136f, -0.03454889f, -0.04826130f, -0.03377918f, -0.01856821f, 0.01097896f, 
    0.00993924f, -0.04383120f, 0.03012557f, -0.03845217f, 0.02579579f, -0.00906608f, -0.03416628f, 0.03771348f, 
    -0.05602824f, -0.00274407f, 0.00678813f, -0.01955644f, 0.00967752f, 0.02174900f, 0.01298400f, -0.01138571f, 
    0.02048984f, -0.01671063f, -0.01815463f, -0.05023019f, 0.00343559f, -0.04458786f, -0.00427216f, 0.00345543f, 
    0.03383710f, 0.02282664f, -0.01249518f, -0.01492974f, -0.03575084f, 0.02956462f, 0.00110761f, -0.04775808f, 
    -0.02453487f, -0.01226687f, 0.02371871f, -0.00873853f, -0.00964003f, -0.05075900f, -0.04482194f, 0.03674929f, 
    0.04258797f, 0.03776171f, 0.00291807f, -0.01775544f, -0.02167780f, -0.02287380f, 0.02930716f, 0.02659213f, 
    -0.04379414f, -0.01866478f, -0.02310350f, -0.03882724f, 0.00740522f, 0.01290521f, 0.02697138f, 0.00416662f, 
    0.03276129f, -0.00911047f, 0.02632262f, -0.01771861f, -0.04355931f, 0.00467193f, -0.00224788f, -0.00788006f, 
    -0.00071622f, 0.03738005f, -0.02763291f, 0.01313049f, 0.03213108f, 0.03310183f, 0.00235022f, 0.03499116f, 
    -0.02761933f, 0.02920721f, -0.05381121f, -0.01714890f, 0.00053477f, 0.00065448f, 0.02826224f, -0.01004832f, 
    0.02520994f, -0.02279248f, -0.00253596f, 0.04671803f, -0.03713203f, 0.00390622f, -0.01169307f, 0.04173925f, 
    0.01039924f, 0.03669636f, -0.05632036f, -0.02653389f, -0.03014138f, 0.00855768f, 0.03323296f, 0.01463188f, 
    0.02284888f, 0.02700276f, -0.02499078f, -0.04022864f, 0.01813174f, 0.01432110f, 0.00962711f, -0.04870891f, 
    -0.05673162f, -0.00107033f, 0.01802164f, -0.03686686f, 0.00157036f, -0.02392954f, 0.04167972f, 0.01053692f, 
    0.02326586f, 0.01193509f, -0.01571562f, 0.01425980f, -0.01073086f, -0.00249060f, -0.02378621f, -0.03161603f, 
    -0.01669715f, -0.00983771f, -0.00622582f, -0.04680412f, -0.04163085f, -0.03117858f, -0.03475399f, -0.02284645f, 
    -0.05409206f, -0.04012967f, -0.04118431f, -0.04061899f, -0.02145947f, 0.03652626f, -0.03691519f, -0.01591565f, 
    -0.02651693f, -0.01786499f, -0.02285108f, -0.00945013f, -0.02828806f, -0.01477043f, -0.04452629f, 0.00328766f, 
    -0.03745466f, 0.03667072f, 0.04538385f, 0.03087376f, -0.05040022f, 0.02545131f, -0.01228029f, -0.01870086f, 
    -0.02689457f, -0.02032096f, -0.02389733f, 0.03920202f, -0.02315528f, -0.04370241f, -0.03045789f, -0.02878873f, 
    -0.02725780f, -0.04216827f, -0.01768068f, -0.03330492f, 0.00474125f, -0.04347124f, -0.01677142f, -0.03150307f, 
    -0.02118415f, 0.03962636f, 0.03101245f, 0.03458209f, 0.01520740f, 0.01266742f, 0.02542139f, 0.02160928f, 
    -0.04231872f, 0.01794438f, 0.00021527f, -0.02682733f, 0.04152526f, 0.00927601f, -0.02768689f, -0.03501127f, 
    -0.04052620f, 0.01211332f, -0.00319188f, 0.00656913f, -0.03573500f, 0.01983243f, -0.04756877f, 0.03481501f, 
    0.01202373f, 0.00420938f, 0.00508977f, -0.01793492f, -0.02489667f, 0.03874026f, 0.02478146f, -0.01417666f, 
    -0.02080152f, -0.02932295f, -0.00633587f, 0.01138428f, 0.03597741f, 0.01481706f, -0.00026092f, -0.00611785f, 
    -0.05510823f, -0.04503959f, 0.03220926f, 0.02665658f, -0.02926516f, -0.05745159f, -0.04578500f, -0.03100131f, 
    -0.04342287f, 0.00779561f, -0.00522827f, -0.02728696f, -0.03144264f, 0.00657008f, 0.02480735f, -0.04010230f, 
    -0.02446629f, -0.00877084f, -0.02860964f, -0.03973757f, 0.00683844f, -0.01668021f, 0.02791599f, 0.03921743f, 
    -0.04408791f, 0.00847893f, 0.03720143f, 0.02310095f, 0.00752527f, 0.00734733f, 0.03994651f, -0.05884060f, 
    0.01267211f, 0.03490549f, 0.01225415f, 0.00703857f, 0.04721615f, 0.03206909f, -0.02367213f, -0.03486752f, 
    -0.01278048f, -0.05454304f, -0.02605572f, -0.01335954f, -0.01884846f, -0.02561780f, -0.01679746f, -0.04275341f, 
    -0.03010054f, 0.02489466f, -0.03858145f, 0.02616564f, 0.01306622f, 0.01190711f, 0.00767878f, 0.02999108f, 
    -0.00565520f, -0.05245211f, 0.01115772f, -0.04331845f, 0.03021012f, 0.03908337f, -0.00074490f, -0.04398002f, 
    0.04092053f, -0.01116639f, -0.01395373f, -0.04959203f, -0.03312748f, 0.04448120f, -0.02559142f, -0.05097366f, 
    -0.05229137f, 0.00528217f, 0.04387031f, 0.02743555f, -0.01913460f, 0.02082678f, 0.03241330f, 0.01351466f, 
    -0.04694001f, -0.03672752f, -0.04007497f, 0.00200071f, -0.01038176f, -0.05287861f, -0.00440917f, -0.03895379f, 
    0.02870066f, -0.03501292f, -0.00059056f, -0.02942583f, 0.02920420f, 0.02709406f, 0.03148646f, -0.04618677f, 
    0.02397860f, -0.00734522f, 0.01751793f, -0.03651090f, 0.03568851f, 0.03415744f, -0.03733749f, -0.01787169f, 
    0.00415016f, -0.01317642f, 0.01509561f, 0.00302206f, -0.05338457f, 0.01310302f, -0.02554737f, 0.00767038f, 
    0.02946466f, -0.00121636f, -0.02288351f, -0.01554975f, -0.00208470f, -0.04936014f, -0.04274622f, -0.05590340f, 
    0.02640019f, 0.03063116f, -0.02204312f, 0.02203222f, 0.02066755f, 0.00008426f, 0.03810791f, -0.00152023f, 
    0.01237715f, 0.00145313f, 0.00271446f, 0.02841133f, -0.04237875f, 0.03499690f, 0.03284793f, -0.00640799f, 
    -0.03782600f, 0.02903098f, 0.01493502f, 0.00209802f, 0.01361199f, -0.01340327f, -0.05490578f, 0.03184906f, 
    -0.05449718f, -0.03094582f, -0.00910471f, 0.01234233f, -0.05020662f, -0.04751118f, 0.03853719f, -0.00291993f, 
    0.02048051f, 0.04390153f, 0.02679938f, 0.01081002f, 0.01895293f, -0.05004300f, -0.01968573f, 0.04146046f, 
    -0.00605442f, -0.01498803f, 0.03410783f, 0.04097150f, -0.01905420f, 0.03767515f, -0.02403948f, -0.02938220f, 
    -0.00766044f, -0.03347320f, -0.02216422f, 0.00723013f, 0.03942306f, 0.02856704f, -0.05348164f, -0.03339129f, 
    0.04398641f, -0.02053760f, -0.00359401f, -0.02303635f, -0.03131660f, -0.01040998f, -0.00767893f, -0.05002959f, 
    0.02882865f, 0.03276831f, 0.01227950f, -0.02779421f, 0.02073025f, -0.04518683f, -0.01539104f, -0.01751988f, 
    -0.04481928f, -0.00359462f, -0.02846102f, -0.03321395f, 0.02730661f, 0.01799752f, 0.01450716f, 0.03465093f, 
    -0.01227769f, -0.03573541f, -0.04097002f, -0.01571199f, 0.01839284f, -0.02176058f, 0.02636632f, -0.03273284f, 
    -0.05909986f, 0.03940179f, -0.04829890f, 0.00091648f, 0.03341926f, 0.01279493f, -0.05436976f, -0.05666891f, 
    0.00449149f, -0.03314509f, -0.01965859f, -0.03588462f, -0.05512994f, -0.05251948f, 0.01099865f, 0.01507181f, 
    0.03940308f, 0.01587226f, -0.02454959f, -0.00413939f, -0.04691343f, 0.03032481f, -0.02894690f, 0.00406209f, 
    0.02552934f, -0.03591440f, 0.02690625f, 0.01392624f, -0.00955039f, -0.05470477f, -0.02612093f, -0.03719950f, 
    0.03630858f, -0.04476108f, -0.03169493f, 0.03730963f, 0.01576868f, -0.01218396f, 0.00937887f, -0.03295736f, 
    0.01893057f, 0.02117315f, -0.03729717f, 0.00758702f, 0.03216510f, 0.02702224f, 0.03477598f, -0.03965281f, 
    0.01576651f, 0.00896857f, 0.02480357f, 0.01616045f, -0.05899286f, -0.04658489f, 0.02835595f, -0.02418799f, 
    0.03475066f, -0.04036358f, -0.05736464f, 0.03730767f, -0.04644481f, -0.03290339f, 0.00560081f, 0.00993266f, 
    -0.01900828f, 0.00902171f, 0.02769976f, 0.03792165f, -0.01059949f, 0.01631557f, -0.00775408f, -0.02838791f, 
    0.00663905f, -0.05799806f, -0.02745222f, -0.03242610f, 0.00288360f, -0.00792032f, -0.05453731f, -0.02486091f, 
    -0.02870249f, 0.03124601f, -0.00197595f, 0.00692497f, -0.04816204f, 0.01983454f, 0.00695910f, -0.02223657f, 
    0.01373812f, -0.02394888f, -0.04793473f, 0.03346147f, -0.04584212f, 0.00011636f, -0.02772900f, -0.02298689f, 
    -0.02457803f, 0.02558867f, -0.03739654f, -0.03869309f, -0.01516877f, 0.01703400f, -0.03531795f, 0.03162714f, 
    -0.01440465f, 0.00274101f, -0.01018357f, 0.01028248f, -0.00696650f, 0.03666008f, 0.01200409f, 0.02465479f, 
    -0.02484340f, 0.03778455f, 0.02351769f, -0.01581295f, -0.01421889f, -0.01596030f, 0.01942968f, 0.00390316f, 
    -0.04004293f, -0.00218927f, 0.03584872f, 0.00980039f, 0.01909395f, 0.03623377f, -0.04928861f, -0.05149327f, 
    0.03901527f, 0.05067776f, 0.00014083f, -0.03261606f, -0.00570311f, 0.01141619f, 0.00161956f, 0.03408406f, 
    -0.01912328f, 0.00985062f, 0.02109827f, -0.00008558f, -0.04065441f, -0.04683258f, 0.03328505f, 0.02989187f, 
    0.01652259f, 0.03141904f, -0.02560451f, 0.01341652f, -0.03284533f, -0.03108967f, -0.02754501f, 0.02327113f, 
    -0.00824851f, -0.02856915f, 0.03350182f, 0.03038955f, 0.03309559f, -0.01908971f, 0.00045022f, -0.04593698f, 
    -0.04049138f, -0.03468605f, 0.02415953f, -0.01968067f, -0.05586427f, -0.00583426f, -0.04144245f, -0.03690733f, 
    0.01302898f, -0.05480098f, -0.03281693f, -0.04170856f, -0.03359484f, 0.03920277f, 0.02147614f, -0.00969850f, 
    -0.04015529f, -0.00069409f, -0.01368116f, 0.01435910f, 0.03397128f, 0.03928761f, 0.01900625f, 0.03617244f, 
    -0.05761611f, -0.03335886f, 0.01620208f, 0.01460502f, -0.04957312f, -0.04024380f, 0.03473075f, 0.03307714f, 
    0.03776878f, -0.03618595f, -0.04846707f, -0.03603606f, -0.04799996f, 0.04039782f, 0.03069283f, -0.00929016f, 
    -0.00295138f, 0.01505555f, 0.02634548f, -0.04548599f, -0.01438917f, -0.05825149f, -0.02184426f, -0.00660133f, 
    -0.01948210f, 0.01573097f, 0.01247946f, 0.02325746f, -0.05627858f, -0.04958756f, -0.03982937f, 0.03680070f, 
    -0.01413540f, -0.01653456f, -0.02086299f, -0.01793328f, 0.00477726f, -0.05938035f, 0.01128222f, -0.04461920f, 
    -0.02013743f, 0.00349096f, -0.01360094f, -0.01181015f, 0.02197094f, -0.05159843f, -0.05400996f, -0.01960052f, 
    -0.05754697f, -0.06135829f, 0.03793602f, 0.03713410f, 0.00515077f, 0.00045509f, -0.02926193f, 0.02577187f, 
    -0.02746667f, 0.02236786f, -0.02890311f, -0.05190608f, -0.05443193f, -0.04430813f, -0.02951754f, -0.01916734f, 
    -0.00348448f, -0.05242324f, 0.01597309f, 0.02224727f, 0.03614085f, -0.03441855f, 0.00005367f, 0.03619261f, 
    -0.01400408f, 0.01074126f, 0.01271817f, 0.00282039f, -0.00041355f, -0.03139297f, -0.02052342f, 0.03904504f, 
    0.03261587f, 0.00815446f, 0.01461713f, -0.00763507f, -0.04036520f, -0.05402666f, 0.03783807f, -0.02821278f, 
    -0.05397043f, 0.01152593f, -0.01609909f, -0.05362389f, 0.00595391f, 0.00016047f, 0.00209363f, -0.01418057f, 
    -0.02350226f, -0.03930301f, -0.04695370f, -0.05103550f, 0.03675340f, -0.04545738f, 0.02290460f, -0.03580582f, 
    0.02366853f, -0.01198741f, 0.00694790f, -0.03110671f, -0.03097775f, 0.03795289f, -0.03956046f, -0.01722734f, 
    0.00635785f, -0.05741785f, 0.01916696f, -0.02226154f, 0.02189022f, -0.04724443f, 0.01434986f, -0.00859407f, 
    -0.01557682f, 0.00387481f, -0.03833378f, -0.00692524f, -0.01442706f, 0.03343391f, -0.01356191f, 0.01203748f, 
    -0.01806925f, 0.02781238f, 0.00815709f, -0.05220708f, 0.02250267f, -0.05103594f, 0.00674370f, 0.03843896f, 
    -0.00110693f, 0.02988162f, 0.00140633f, -0.01187974f, -0.04434306f, -0.00251194f, 0.02257907f, -0.04235356f, 
    -0.02459160f, 0.02680100f, -0.01185911f, -0.05910329f, 0.03977005f, 0.02183850f, -0.01412805f, -0.00602267f, 
    -0.02197172f, 0.03091135f, 0.00242208f, -0.04369523f, 0.00702990f, -0.06056255f, 0.00576451f, -0.00923407f, 
    -0.03265137f, -0.03401544f, 0.01318161f, -0.02162729f, -0.05428329f, -0.00155129f, -0.02548713f, -0.01422708f, 
    0.00449803f, 0.02351124f, 0.01048633f, -0.02076315f, -0.04088776f, -0.00805118f, 0.00756178f, -0.03995726f, 
    -0.05671627f, -0.00103286f, -0.05082876f, -0.01588439f, -0.00062559f, -0.05594988f, 0.02272484f, -0.00462464f, 
    -0.06421184f, 0.04824666f, 0.10987685f, 0.03611935f, -0.00601675f, 0.07157300f, 0.06030591f, -0.02011537f, 
    -0.02425157f, 0.08914195f, 0.05013301f, -0.02124057f, -0.11452461f, -0.19158462f, 0.11184738f, 0.28865829f, 
    0.07750608f, -0.02214490f, 0.00460790f, 0.01170291f, 0.23645467f, 0.22246826f, -0.14147981f, 0.09014798f, 
    0.43367881f, 0.32990500f, -0.12664357f, 0.07617311f, 0.12403499f, 0.00882700f, -0.10229263f, 0.11438110f, 
    -0.01789754f, 0.02237892f, -0.09009609f, -0.09441533f, -0.25379404f, -0.10132241f, 0.16316989f, 0.34808236f, 
    0.29033428f, 0.13537920f, 0.13866782f, 0.09368505f, 0.20651305f, -0.02767953f, -0.16916326f, -0.07207649f, 
    0.56027609f, 0.26060769f, -0.13632768f, 0.12604658f, -0.01316289f, -0.13706483f, 0.12057336f, 0.00904717f, 
    -0.12390091f, -0.00121141f, -0.01207827f, 0.10571976f, -0.05712195f, -0.23636344f, -0.13203147f, -0.19254600f, 
    -0.24904585f, -0.19656886f, 0.01525058f, 0.05972762f, 0.00675683f, -0.13880545f, 0.20845185f, -0.14742362f, 
    0.14772598f, -0.08115349f, -0.08347673f, -0.00121662f, 0.04603906f, -0.12939864f, 0.28909290f, 0.02280554f, 
    0.11872520f, 0.21054195f, -0.09915055f, -0.01170024f, -0.64259762f, -0.20163852f, -0.01013699f, 0.03423072f, 
    0.07279491f, 0.05785649f, -0.05921809f, 0.05573589f, 0.11304055f, 0.10900642f, -0.01021156f, -0.22288595f, 
    -0.21018212f, 0.17594220f, 0.22657329f, 0.20031515f, 0.15767452f, -0.03260474f, -0.13735935f, 0.11622279f, 
    -0.00891224f, 0.05306059f, -0.22353919f, 0.05319479f, 0.07941134f, 0.14381662f, 0.01151340f, 0.02069377f, 
    -0.04189587f, -0.10312807f, 0.11314274f, 0.11974053f, -0.03533115f, 0.04292208f, 0.09697890f, 0.08910258f, 
    -0.10773722f, 0.11847613f, -0.04335294f, -0.03779644f, -0.11414990f, -0.14060524f, -0.08925679f, 0.03749152f, 
    0.04905409f, -0.13694352f, -0.00842643f, -0.01939927f, -0.19899561f, -0.04113779f, 0.02374844f, -0.10336311f, 
    -0.08171763f, 0.16784365f, 0.12963630f, -0.01330726f, -0.07961854f, -0.00439251f, 0.06473166f, -0.05398815f, 
    0.19248959f, 0.01054959f, -0.05320231f, 0.24828152f, 0.09640307f, 0.13090229f, 0.12839985f, 0.07881038f, 
    0.02664815f, -0.20935957f, -0.04209241f, -0.19644988f, 0.22003217f, 0.29049617f, -0.00229635f, 0.22361630f, 
    -0.06090448f, 0.04909727f, -0.00044835f, 0.12473159f, 0.04924910f, -0.05565197f, -0.19538237f, 0.23961453f, 
    -0.11820655f, 0.11470322f, -0.06980471f, 0.17526087f, -0.07452057f, -0.01064501f, 0.08249543f, 0.00234708f, 
    0.06147426f, -0.08871126f, -0.03846176f, -0.18928881f, -0.17604022f, -0.15001044f, -0.21577843f, 0.03544391f, 
    -0.08943512f, 0.08943391f, 0.12851353f, -0.04926145f, -0.02331611f, 0.08933596f, -0.01982864f, 0.26643357f, 
    -0.09951702f, -0.03449793f, -0.17966789f, -0.24625015f, -0.03683593f, 0.02095027f, 0.16592367f, 0.13548878f, 
    0.16026615f, 0.11123679f, 0.10778180f, 0.14635240f, 0.07004555f, 0.21654545f, 0.21387151f, 0.08380776f, 
    0.11642352f, 0.12464315f, 0.00762379f, 0.14267656f, 0.01790358f, -0.01033530f, 0.24674486f, 0.03054394f, 
    0.31662995f, 0.21761167f, -0.14184891f, 0.21857202f, 0.05720622f, 0.12192964f, 0.15013823f, 0.09189230f, 
    -0.10018455f, 0.06836826f, 0.11282133f, -0.05919091f, -0.28409854f, -0.27243897f, 0.17174698f, 0.13320427f, 
    0.10041098f, 0.02191756f, -0.08588488f, 0.11126489f, -0.08897480f, 0.08423722f, 0.05529464f, 0.04763269f, 
    0.46468896f, 0.14088088f, -0.06375054f, 0.21660884f, 0.00238880f, 0.23897325f, -0.04709713f, -0.03044043f, 
    -0.12221647f, -0.30546176f, -0.01156203f, -0.04182242f, 0.04801056f, -0.04297501f, -0.01691379f, -0.18371031f, 
    -0.17829749f, 0.12838142f, -0.08880205f, 0.03128415f, -0.08188771f, -0.01870387f, -0.15443730f, -0.02839530f, 
    -0.06683550f, -0.10730801f, -0.11984414f, 0.22334138f, -0.09455872f, 0.00995259f, 0.07119264f, 0.18762544f, 
    -0.05687461f, 0.06228954f, -0.05696099f, 0.07005226f, -0.07878744f, 0.24489379f, -0.02210668f, 0.04510210f, 
    0.07830993f, -0.01501399f, 0.16693331f, -0.01181781f, -0.00925837f, 0.11174753f, -0.06724968f, -0.11390723f, 
    -0.34168053f, -0.02729313f, -0.08598436f, -0.09289605f, -0.19112813f, -0.00157603f, 0.06688128f, 0.11176757f, 
    -0.00989014f, 0.01649993f, -0.10623468f, -0.05063740f, -0.20878342f, -0.02197687f, 0.04888479f, -0.01158382f, 
    -0.11672187f, -0.02738623f, 0.17049415f, 0.01071452f, -0.00048310f, 0.06811473f, 0.12716225f, 0.20374012f, 
    -0.23541215f, -0.12066484f, -0.07453221f, -0.02018810f, 0.02271483f, 0.04978029f, 0.07616043f, 0.06732429f, 
    0.00764965f, 0.20493680f, 0.00893320f, -0.10538102f, 0.33887103f, 0.03456429f, -0.07116550f, 0.12590049f, 
    0.06935145f, 0.16750190f, 0.02605988f, 0.05431652f, 0.01281224f, -0.02756532f, -0.16238402f, -0.07217085f, 
    -0.56333107f, 0.20418246f, 0.08440366f, -0.11833230f, -0.08066654f, 0.05467582f, 0.09795460f, 0.07136969f, 
    -0.02772336f, 0.19986635f, 0.10423265f, 0.11167435f, 0.03773712f, -0.33712468f, -0.12674992f, 0.18048871f, 
    0.08002020f, 0.08771931f, 0.06644665f, 0.16943495f, -0.01472059f, -0.00058325f, 0.07354640f, -0.03940165f, 
    0.28143254f, -0.03098606f, 0.21974589f, 0.21978569f, -0.00788092f, 0.05381193f, -0.13686419f, 0.21786080f, 
    -0.04597520f, -0.01566784f, 0.18388636f, -0.14123438f, 0.20930475f, -0.05273563f, -0.05651164f, 0.01914753f, 
    -0.13204293f, -0.01446886f, -0.07521623f, -0.06887154f, 0.04908086f, 0.01753984f, 0.02521260f, -0.01763217f, 
    0.19001156f, -0.01369799f, -0.12380498f, -0.04415807f, 0.06463351f, 0.02031514f, -0.18465824f, 0.07497918f, 
    -0.13671625f, 0.06271204f, 0.07053705f, 0.01339643f, 0.08241895f, -0.17222066f, 0.03648599f, 0.11279979f, 
    0.32145831f, 0.00879870f, 0.08984888f, 0.16774091f, 0.10971997f, 0.06194379f, 0.09480842f, 0.14610125f, 
    -0.55837226f, -0.00897800f, -0.16037701f, 0.09571571f, -0.04354245f, 0.00031737f, -0.02335828f, 0.02070367f, 
    -0.07023627f, 0.09737659f, 0.09843984f, 0.21595155f, 0.14865437f, 0.07429191f, 0.14997427f, 0.11211059f, 
    0.12708205f, -0.08243748f, -0.05347784f, 0.14084873f, -0.00867735f, 0.10002530f, 0.08438100f, 0.08266124f, 
    -0.04721626f, -0.14196829f, 0.09169775f, -0.01747590f, -0.05619890f, 0.16751005f, 0.06295843f, 0.04704805f, 
    0.09889179f, 0.14464185f, 0.09281378f, -0.12913391f, -0.15072097f, 0.09609477f, 0.13219076f, -0.00353392f, 
    0.27123201f, -0.00146585f, 0.05920067f, -0.07562075f, -0.02143541f, 0.12595788f, 0.02210487f, 0.19009244f, 
    -0.23805064f, -0.15969713f, 0.02437768f, -0.07886098f, -0.02139785f, 0.08977618f, -0.01073805f, -0.11324943f, 
    0.10920803f, -0.17191741f, -0.04513205f, -0.09294870f, 0.06358217f, -0.07200449f, 0.05041287f, 0.05461267f, 
    -0.02713254f, -0.04104434f, 0.10081847f, 0.02958084f, 0.12759107f, -0.02450877f, -0.05616427f, 0.16412526f, 
    0.21881974f, 0.21259470f, -0.24889478f, 0.09517403f, -0.11797231f, 0.06344271f, 0.08387475f, -0.01538342f, 
    -0.02958247f, 0.03569547f, 0.28771669f, 0.06482313f, 0.26251033f, 0.10412294f, -0.07663974f, 0.05873394f, 
    0.06091930f, 0.09884624f, -0.05723891f, 0.03022860f, -0.06476936f, 0.01210150f, 0.05750266f, 0.08364009f, 
    -0.05324493f, -0.11309066f, 0.12841111f, 0.09656579f, 0.18682523f, 0.13776961f, 0.03720190f, 0.05282557f, 
    0.19671953f, 0.06527752f, 0.12009785f, -0.02306671f, -0.06732159f, 0.12071250f, -0.05399657f, 0.05066993f, 
    0.22588602f, -0.03885071f, -0.12085061f, 0.15732175f, -0.01817062f, -0.02524595f, -0.10391837f, 0.13078275f, 
    0.22506090f, 0.19903900f, -0.09636748f, -0.01892409f, 0.05877823f, 0.04709200f, -0.01221077f, 0.01806182f, 
    -0.01376336f, 0.37935248f, 0.17647466f, 0.18989640f, 0.19201387f, 0.02071277f, -0.17160304f, 0.10523012f, 
    -0.08606920f, -0.15065771f, 0.19984108f, 0.01982021f, -0.18639171f, -0.02579697f, 0.02246737f, -0.03978768f, 
    0.01423361f, -0.09806773f, 0.09644198f, 0.02635317f, 0.08149032f, 0.05278423f, -0.12516938f, 0.00376409f, 
    0.12816256f, -0.03472102f, 0.20395705f, 0.18216702f, 0.18998656f, -0.08513240f, 0.11918151f, -0.12192853f, 
    -0.01854013f, -0.10711651f, -0.01929768f, -0.04530126f, 0.24819370f, -0.02462748f, 0.12209360f, 0.08428016f, 
    0.11599202f, 0.03562442f, 0.12717237f, -0.11264797f, 0.17356944f, 0.02438200f, -0.17863496f, -0.03477100f, 
    -0.12794748f, 0.00601504f, 0.04877823f, -0.09528553f, 0.24991615f, 0.22698992f, -0.34852150f, 0.11699294f, 
    0.03458319f, 0.06070310f, 0.07644561f, 0.04935896f, 0.06704755f, -0.04000835f, -0.00074301f, -0.03847709f, 
    0.07632407f, -0.18074323f, -0.08633180f, 0.07851619f, 0.17983231f, -0.12919590f, 0.09759228f, 0.07513715f, 
    0.03146790f, -0.04464522f, -0.01965330f, 0.11663858f, -0.16178896f, 0.04980327f, -0.05607486f, 0.01644383f, 
    0.06312579f, -0.04608852f, -0.06465184f, -0.04966990f, -0.02489362f, -0.21957938f, -0.03024646f, -0.00454997f, 
    0.19859318f, -0.02647918f, 0.09925646f, 0.00452215f, 0.08952449f, -0.06090864f, 0.08928616f, -0.05598581f, 
    -0.03063387f, 0.19965555f, -0.05217391f, 0.08839914f, -0.28000712f, -0.31803554f, 0.25773680f, -0.14686073f, 
    -0.05362163f, -0.08346044f, -0.02730826f, -0.07418846f, 0.21276949f, -0.04348603f, 0.10583910f, 0.01103794f, 
    -0.64952785f, 0.01679826f, -0.14796373f, 0.10169165f, 0.15850167f, 0.04027256f, -0.11003554f, 0.19318694f, 
    -0.02971540f, 0.01321160f, 0.23609851f, -0.03197914f, 0.22365013f, 0.31288448f, 0.27032501f, 0.01437597f, 
    0.16319129f, -0.01809175f, -0.11861277f, 0.22332044f, 0.03983615f, -0.21378639f, 0.22755434f, 0.13804285f, 
    -0.22986805f, -0.11787324f, -0.02111003f, -0.07465899f, 0.13879637f, 0.17987429f, -0.05044353f, -0.12367626f, 
    0.15717487f, -0.02431027f, 0.03918178f, 0.15065220f, 0.40422726f, -0.25222555f, -0.12405235f, -0.05540827f, 
    -0.00629638f, -0.09045526f, -0.04928380f, 0.20036796f, 0.21714769f, -0.08839836f, -0.14450155f, -0.04123403f, 
    -0.08154681f, 0.11032345f, 0.01603492f, 0.01822304f, 0.23007019f, 0.11232001f, -0.08002583f, 0.05610692f, 
    0.14098614f, -0.17315055f, -0.12774442f, 0.12708984f, 0.39660531f, 0.15545392f, -0.06086090f, -0.16652738f, 
    0.24085365f, 0.13996726f, -0.03213537f, 0.01428763f, -0.00587255f, 0.17866278f, 0.12561077f, 0.30463877f, 
    -0.07948162f, -0.10058533f, -0.31399065f, -0.04802937f, -0.12296942f, -0.07550117f, -0.07894838f, -0.21161360f, 
    -0.02025594f, -0.05711312f, 0.03951044f, -0.02640716f, -0.13554125f, -0.14984198f, 0.00839411f, -0.06610395f, 
    -0.10160152f, 0.19791643f, -0.08108364f, -0.13829553f, 0.00577195f, -0.00172094f, 0.07180468f, 0.01521864f, 
    -0.33455467f, -0.08021670f, 0.04652319f, -0.33086795f, -0.15238416f, -0.09201821f, 0.21991444f, -0.02073238f, 
    0.13546494f, 0.09098288f, -0.09268703f, 0.11920241f, 0.43463889f, -0.19797643f, 0.00066823f, -0.11715249f, 
    -0.01175840f, 0.17213897f, 0.07959800f, 0.02091123f, 0.08021363f, 0.02033640f, -0.06551881f, 0.01822695f, 
    0.04255804f, -0.03166977f, 0.03036919f, -0.03812932f, -0.03906165f, -0.00830191f, 0.01693924f, -0.03094873f, 
    0.03055969f, -0.01041957f, 0.01711529f, -0.00874570f, -0.00093306f, -0.03306445f, -0.02729129f, -0.05756940f, 
    -0.00963954f, -0.00357624f, -0.01611668f, 0.04336264f, 0.03559269f, -0.01428003f, -0.02690407f, 0.02993256f, 
    0.02729152f, 0.01142233f, 0.02775540f, -0.00873036f, -0.03848624f, -0.01065492f, -0.04656271f, -0.03265555f, 
    0.00880315f, 0.01196037f, 0.00479130f, 0.00876196f, -0.00091209f, -0.02281188f, -0.04306482f, 0.02334609f, 
    0.02940488f, 0.03317951f, 0.02465403f, 0.00755804f, 0.02702500f, -0.01582541f, 0.01400622f, -0.04082846f, 
    -0.00879613f, 0.02578994f, -0.01674755f, 0.00750193f, -0.00950657f, 0.03321662f, -0.00156704f, -0.01595513f, 
    -0.00466827f, 0.02778915f, -0.01221047f, 0.00337299f, 0.00230907f, -0.01564362f, -0.05403079f, 0.03141259f, 
    0.00783905f, -0.04788090f, -0.04384405f, 0.01357012f, 0.03411347f, 0.00729736f, 0.01055361f, -0.01038584f, 
    0.02625315f, 0.03559764f, -0.04992350f, -0.02060733f, -0.03278605f, -0.03704192f, 0.03153353f, -0.03938742f, 
    0.02226880f, -0.03482542f, -0.04420605f, -0.01607824f, 0.00082140f, -0.01203007f, 0.02683751f, -0.01590635f, 
    -0.04917589f, 0.03034852f, 0.00416353f, -0.05670508f, 0.00194773f, -0.03735650f, 0.03837245f, -0.00515001f, 
    -0.00602477f, -0.02398125f, -0.00431139f, -0.00261359f, 0.01794126f, 0.02211520f, -0.04555384f, -0.00172162f, 
    0.03230781f, -0.05919170f, 0.02144244f, -0.02832977f, 0.00743275f, -0.04086423f, 0.00276944f, 0.02088856f, 
    0.02628610f, 0.00918757f, -0.02704290f, 0.03931628f, 0.04002489f, 0.00796789f, 0.01767152f, -0.02685913f, 
    -0.05925851f, -0.05120601f, -0.00243391f, 0.01142357f, -0.05067960f, 0.03605529f, 0.05240629f, -0.00778138f, 
    0.00391495f, 0.02853032f, -0.00131712f, 0.02845932f, 0.02211288f, 0.02708097f, -0.04822933f, 0.03122641f, 
    0.00503918f, 0.02080835f, -0.04037586f, -0.00534008f, -0.02414682f, -0.05163559f, 0.01775648f, -0.00207266f, 
    0.03213536f, -0.00269674f, -0.04352999f, -0.03112599f, -0.03896570f, 0.04485705f, -0.04189646f, 0.04244076f, 
    0.02417047f, -0.03575869f, -0.04025827f, -0.03857131f, -0.04840006f, 0.04881544f, -0.04188845f, 0.03283281f, 
    0.01747761f, 0.03347588f, -0.01600622f, -0.05300641f, 0.02019038f, -0.05255578f, -0.04237814f, -0.01754803f, 
    -0.01225704f, 0.00244673f, -0.05393815f, -0.01744461f, -0.03704418f, 0.00053072f, -0.00598265f, -0.01877820f, 
    0.01499455f, -0.01225069f, 0.01048672f, 0.00152885f, -0.02838251f, 0.00987580f, 0.02292768f, 0.04977694f, 
    -0.05971587f, -0.02565676f, -0.00639218f, 0.03629436f, 0.00818744f, -0.04655424f, 0.02146032f, -0.04687572f, 
    -0.00814563f, 0.04312764f, 0.02326978f, -0.04605306f, 0.04144452f, 0.01865796f, 0.01770128f, -0.02745201f, 
    -0.02968952f, 0.02132367f, 0.03703781f, -0.00268877f, -0.02466244f, -0.05092994f, 0.03594742f, 0.02498790f, 
    -0.02250041f, 0.03602686f, 0.04244541f, -0.05321142f, -0.03375487f, -0.00267965f, -0.03915963f, -0.02439844f, 
    -0.01690421f, 0.02957837f, 0.04371359f, 0.01599528f, -0.04839763f, 0.01517828f, 0.02721659f, 0.01606762f, 
    0.02209185f, 0.02932508f, -0.00648889f, -0.00004168f, -0.01175701f, -0.03955436f, 0.01222875f, 0.01678716f, 
    0.03842862f, -0.00555003f, -0.00542022f, -0.02132661f, 0.03087035f, 0.02606360f, 0.02608242f, -0.02761746f, 
    -0.00023142f, 0.01365115f, -0.04287422f, -0.05403234f, -0.04785350f, -0.00803879f, -0.03560794f, -0.04345335f, 
    -0.00099350f, 0.02884971f, 0.03234398f, 0.00911713f, 0.01751915f, 0.01911178f, 0.04366301f, -0.02836586f, 
    -0.00979665f, 0.02391701f, -0.01479023f, -0.04035778f, -0.02850788f, 0.03029677f, -0.00330177f, -0.02235395f, 
    0.00559825f, 0.03406662f, -0.00694628f, 0.03681343f, -0.01944236f, 0.02511663f, 0.01021406f, 0.02777997f, 
    0.01293701f, 0.02400924f, 0.01411152f, -0.01397685f, 0.00878011f, -0.01672141f, 0.04780669f, 0.03353617f, 
    -0.02466806f, -0.05583421f, -0.03484070f, 0.02344226f, 0.01666893f, 0.02516380f, 0.02173129f, 0.02309723f, 
    -0.04611883f, -0.01462347f, 0.04387431f, -0.03866854f, 0.01517601f, -0.04176394f, -0.03704393f, 0.00350460f, 
    0.04338117f, -0.04723277f, 0.00329866f, -0.00586182f, 0.00248666f, -0.01741107f, -0.02807157f, -0.02479017f, 
    0.03403466f, -0.02215224f, -0.00663698f, 0.02751490f, -0.02729366f, -0.01686759f, -0.00410203f, -0.04235161f, 
    0.01737184f, 0.02559105f, 0.02396599f, -0.03698997f, -0.01981508f, 0.02181540f, 0.04228090f, -0.04578827f, 
    -0.01080651f, -0.02899229f, 0.01939312f, -0.00420310f, 0.02444998f, -0.05083312f, -0.03030450f, -0.03135792f, 
    -0.02630544f, -0.04455572f, 0.00550435f, -0.03007438f, 0.03907478f, -0.00407909f, 0.01033648f, -0.04908664f, 
    -0.03064793f, -0.00379055f, -0.03601649f, -0.02114313f, 0.02552900f, 0.04010094f, -0.03829288f, -0.01532354f, 
    -0.03818922f, -0.03948493f, -0.05275907f, 0.02316213f, -0.04201857f, 0.00271758f, 0.01694852f, -0.03634894f, 
    -0.03064788f, 0.00752080f, -0.00381587f, 0.00733851f, -0.00275113f, -0.05403351f, 0.00404351f, 0.01399955f, 
    -0.00799398f, 0.00225800f, -0.05077406f, 0.03994616f, -0.04856613f, 0.03240309f, 0.02887523f, 0.00258223f, 
    -0.00388553f, 0.00185011f, -0.00728101f, -0.04085049f, 0.03753271f, -0.00120056f, 0.02353079f, -0.01461403f, 
    -0.02288050f, -0.03511556f, -0.01871757f, 0.00196244f, -0.05887383f, -0.00946833f, 0.03303776f, 0.00553805f, 
    0.03644406f, -0.04396546f, -0.05064492f, -0.05307450f, 0.03163984f, -0.02156866f, -0.01274238f, -0.04155673f, 
    -0.01496936f, 0.00460594f, 0.01008798f, -0.02485895f, 0.03924551f, 0.02646080f, 0.02478827f, -0.05406570f, 
    -0.02481925f, -0.04390419f, 0.03844591f, -0.01231142f, -0.02546385f, 0.03905997f, 0.00414168f, -0.01381379f, 
    -0.05006598f, 0.02716853f, -0.03215928f, -0.04199935f, -0.04997215f, 0.02232074f, -0.00241971f, -0.01087515f, 
    -0.00098222f, -0.05087331f, -0.00951003f, 0.00074164f, 0.00076562f, -0.01649063f, 0.03127854f, -0.05268330f, 
    0.01256606f, 0.00905182f, 0.00602840f, -0.02859883f, -0.05712957f, 0.02702213f, -0.00180710f, -0.00007826f, 
    -0.00315581f, 0.03721010f, -0.02609709f, -0.04544808f, 0.02083508f, 0.01686279f, -0.03378486f, -0.04539709f, 
    -0.04259118f, -0.02262444f, 0.03327543f, 0.04290400f, -0.05171269f, 0.04380433f, -0.01142150f, -0.04818870f, 
    -0.04792034f, -0.01438910f, -0.04912839f, -0.02980831f, 0.03508830f, -0.00355437f, 0.04341317f, -0.00199552f, 
    0.01093537f, 0.02718106f, -0.01321318f, 0.04146067f, -0.04243280f, 0.02868178f, -0.00345339f, -0.00928363f, 
    0.01538691f, -0.01359519f, -0.02353849f, 0.01396075f, 0.03134036f, -0.05118234f, -0.05507928f, -0.01387465f, 
    -0.00407668f, 0.03402908f, -0.02140270f, 0.01549946f, -0.01720047f, -0.05113711f, 0.00383572f, -0.02849993f, 
    0.00042979f, 0.03535488f, 0.03315715f, -0.03603972f, -0.04985198f, -0.00346327f, -0.01634918f, -0.04521791f, 
    -0.03718469f, 0.03568931f, 0.01745660f, 0.02032092f, 0.03004733f, 0.00166900f, -0.02377281f, -0.03384729f, 
    -0.00750454f, -0.02315460f, -0.03754786f, 0.00901725f, -0.03337522f, 0.01731720f, -0.03848995f, 0.02937950f, 
    -0.01823735f, -0.04897235f, 0.02802115f, -0.00242441f, -0.02503344f, 0.00162350f, -0.05685151f, 0.00614762f, 
    -0.03600094f, -0.03366230f, -0.03987900f, -0.02331396f, 0.02291629f, -0.01709301f, 0.02996456f, 0.02361483f, 
    -0.05134061f, -0.02415952f, -0.00387324f, -0.02299762f, -0.04437943f, -0.05527256f, 0.03412903f, 0.01872157f, 
    -0.03704995f, 0.00979006f, 0.02180293f, -0.00419277f, -0.04709950f, -0.03730915f, 0.01468528f, 0.03850195f, 
    -0.01845826f, 0.03503848f, -0.05082991f, -0.01855321f, -0.05823715f, 0.03820849f, -0.04978902f, -0.03671862f, 
    -0.02217839f, -0.03112731f, -0.01700614f, 0.01198965f, -0.01504845f, -0.03555438f, -0.01323324f, -0.00003529f, 
    0.01246123f, 0.01177282f, -0.03114990f, -0.02769519f, 0.02847414f, 0.00990942f, 0.00064188f, -0.03979343f, 
    0.00192506f, -0.03737068f, 0.00708838f, 0.00524713f, 0.02247684f, -0.03405816f, -0.02829921f, -0.05331373f, 
    0.02255659f, 0.01033979f, 0.02545098f, -0.00856549f, -0.03441833f, 0.01754763f, 0.03347132f, -0.01867587f, 
    -0.01585047f, -0.03117694f, 0.03597654f, 0.01237883f, -0.03082180f, 0.04291634f, 0.01292031f, -0.05077942f, 
    0.04157430f, -0.00840537f, -0.01859611f, -0.04826606f, 0.02822264f, -0.04869422f, -0.04791148f, 0.02323679f, 
    0.00024587f, -0.04967384f, -0.00328551f, 0.01015866f, 0.02537944f, -0.02519859f, -0.02271804f, 0.00517387f, 
    0.00831045f, -0.00871773f, 0.00907041f, 0.04367740f, 0.03497713f, 0.00865125f, 0.00476339f, -0.04965543f, 
    -0.03353623f, 0.02908729f, 0.04313366f, 0.02945444f, -0.00527763f, 0.03768159f, -0.02720116f, 0.01817780f, 
    0.00899947f, -0.00245838f, -0.05471471f, -0.03100746f, -0.05290946f, 0.02802639f, 0.00302101f, 0.04280249f, 
    -0.00181937f, -0.05202906f, -0.03419179f, 0.02418801f, 0.02379308f, 0.03103697f, -0.04122471f, -0.03241634f, 
    -0.05309417f, -0.02781997f, -0.00095266f, -0.02730058f, 0.03115014f, -0.00442384f, 0.01156660f, 0.01375956f, 
    0.00018586f, -0.03379674f, 0.01719616f, -0.02987102f, 0.02506988f, -0.02277664f, 0.03203515f, -0.05429666f, 
    -0.00696937f, 0.01167490f, -0.04760936f, -0.02578402f, -0.03836638f, 0.03575332f, -0.03702658f, 0.00329162f, 
    -0.00692464f, -0.01557693f, 0.01720320f, 0.02098072f, -0.04095682f, 0.00502486f, -0.00044559f, 0.03972663f, 
    -0.04575432f, -0.01453288f, -0.00321768f, -0.04356330f, -0.01491683f, -0.02223412f, 0.00179614f, 0.03718392f, 
    -0.03307566f, -0.00583061f, 0.03013339f, 0.01687564f, -0.05316807f, -0.03199928f, 0.01946005f, -0.00539473f, 
    0.04179947f, 0.03136101f, -0.00440696f, 0.01609579f, 0.00345683f, 0.01174186f, 0.01719178f, -0.02293939f, 
    0.03659929f, 0.01451547f, -0.00162602f, -0.03498466f, -0.04508773f, -0.01587934f, 0.02655315f, -0.05692584f, 
    -0.02617851f, -0.00476392f, -0.00683389f, -0.00129065f, 0.01307493f, -0.04258583f, -0.02515220f, 0.00820793f, 
    0.00083813f, 0.02484420f, 0.03229180f, 0.03109821f, -0.02945493f, -0.01307728f, -0.03057879f, 0.03399350f, 
    -0.01131292f, 0.01416688f, 0.03458143f, 0.00360139f, 0.02443140f, -0.03812102f, -0.01993056f, 0.01918987f, 
    -0.02370974f, 0.00937833f, 0.03663802f, -0.05216847f, -0.00335784f, -0.01626547f, -0.00398585f, -0.00573481f, 
    -0.03578203f, -0.03957969f, -0.01684691f, -0.05665781f, -0.00193104f, 0.01686022f, -0.05039537f, 0.03262947f, 
    -0.02213801f, 0.01391948f, -0.03193188f, 0.01887074f, -0.05741637f, -0.01163619f, -0.05604542f, 0.02357241f, 
    -0.04436965f, -0.02391366f, 0.03386214f, 0.02130507f, -0.05529798f, 0.03849445f, -0.04003085f, -0.04145273f, 
    -0.05584116f, 0.03940284f, -0.04306751f, 0.04021142f, 0.01575455f, -0.05200045f, -0.01093414f, -0.03761274f, 
    0.00677745f, -0.05210732f, -0.02870184f, -0.03004286f, 0.00705860f, -0.03293644f, 0.01299737f, 0.03680609f, 
    -0.47038341f, -0.09706169f, 0.43640950f, 0.18888885f, 0.04777699f, -0.08952151f, -0.04178005f, -0.01314336f, 
    0.08727348f, -0.13003863f, 0.06749295f, -0.05477837f, 0.10062601f, 0.42785269f, -0.17903063f, -0.17164887f, 
    -0.05886176f, 0.06482651f, -0.14014964f, 0.04657691f, -0.07884931f, 0.02712889f, 0.11360724f, 0.14475420f, 
    -0.36834228f, -0.12656908f, 0.37332356f, 0.23125172f, 0.08585153f, 0.00962567f, 0.11588224f, 0.04829872f, 
    0.10215417f, -0.02047229f, 0.11674398f, -0.03201484f, 0.21912667f, 0.16967706f, -0.01413845f, -0.06133050f, 
    -0.19365840f, 0.09239016f, -0.01199553f, 0.10825007f, -0.16856284f, -0.02274952f, -0.05441136f, 0.14053474f, 
    0.20176905f, 0.00927932f, -0.02419143f, -0.07769016f, 0.09108546f, 0.02143446f, 0.08553223f, 0.04708571f, 
    0.07831965f, -0.06026825f, 0.13147961f, -0.04079784f, 0.11815096f, -0.08841125f, 0.03849937f, 0.25666872f, 
    -0.06902622f, 0.10117915f, 0.04045349f, -0.01986084f, 0.03579300f, 0.17225972f, -0.16137768f, 0.18810850f, 
    0.20001332f, 0.28180167f, -0.05275674f, -0.36341083f, 0.10436231f, 0.22462103f, -0.14681323f, -0.13230875f, 
    -0.04177570f, -0.01144767f, -0.02019537f, 0.09354495f, 0.47177899f, -0.12454090f, -0.09238396f, -0.12531176f, 
    0.01612968f, 0.04722174f, 0.00845661f, -0.02372560f, -0.12278378f, -0.04368863f, 0.09284203f, 0.12840222f, 
    -0.05913379f, 0.09326924f, -0.02879957f, 0.13857916f, -0.00266237f, -0.03986748f, 0.04277450f, 0.06921127f, 
    0.05746426f, 0.00585874f, 0.01264469f, 0.03615133f, 0.10468688f, 0.07782471f, -0.06217505f, -0.19495432f, 
    -0.06625968f, 0.00208700f, -0.08718765f, -0.11247980f, -0.01304344f, 0.00505411f, -0.11241905f, 0.08268385f, 
    0.33710203f, -0.24426721f, -0.08025217f, 0.19580932f, 0.12575465f, 0.09686727f, 0.07298284f, 0.05596713f, 
    -0.08199780f, 0.22666100f, -0.04669601f, 0.17760946f, -0.02694869f, 0.01414983f, -0.20356704f, 0.12685619f, 
    0.04750708f, -0.16495940f, -0.11380579f, 0.15282302f, -0.06649003f, -0.06201652f, 0.00840076f, -0.02151594f, 
    -0.05909684f, 0.28562903f, 0.15178722f, 0.04626825f, 0.00078657f, 0.11255682f, -0.06842480f, 0.10620368f, 
    0.00236787f, 0.17750578f, -0.02800168f, 0.14497805f, 0.10782589f, -0.09661596f, 0.16320217f, -0.07469132f, 
    -0.01031648f, 0.08568890f, -0.05717399f, 0.00561094f, 0.04241442f, 0.08279080f, 0.22042313f, -0.00812804f, 
    0.39926100f, -0.23875837f, -0.01423165f, 0.09706127f, -0.03347997f, -0.12624384f, 0.09845285f, -0.01129582f, 
    0.12772790f, 0.25776079f, -0.01727958f, 0.26090696f, 0.10038242f, -0.00176862f, 0.11167625f, 0.13627574f, 
    -0.11301453f, -0.03225827f, -0.16701174f, 0.03261369f, 0.09845545f, 0.05949409f, 0.03080025f, -0.14237805f, 
    -0.30199289f, -0.06969696f, 0.31040698f, 0.26004493f, -0.08181855f, 0.07258169f, -0.09771684f, -0.11026376f, 
    0.00519421f, -0.04691584f, 0.00330695f, -0.07310221f, -0.15209469f, -0.19297472f, 0.31992525f, 0.31408376f, 
    -0.05516842f, 0.01280599f, 0.07624889f, -0.06475566f, -0.07200237f, 0.07836440f, -0.11448068f, -0.06080235f, 
    0.07520583f, -0.11323377f, 0.26161698f, 0.02875676f, -0.07104219f, -0.01518810f, 0.04005795f, 0.03685864f, 
    0.02397124f, 0.02446409f, -0.01042388f, 0.02265479f, 0.20450294f, 0.16300789f, -0.24768269f, -0.05495935f, 
    -0.18328789f, 0.00665912f, 0.14461190f, -0.14935374f, 0.02526180f, 0.07174493f, -0.12988262f, -0.03291726f, 
    -0.21067357f, -0.18255030f, 0.00345705f, 0.05999862f, 0.02636389f, -0.15833941f, 0.14854909f, 0.03128770f, 
    0.05364548f, 0.26418167f, 0.05338478f, 0.01425297f, 0.17758860f, -0.41289303f, 0.04505944f, 0.51988888f, 
    -0.03922628f, -0.08748471f, 0.01711792f, -0.01222016f, 0.02320972f, -0.01158353f, 0.04889739f, 0.13095880f, 
    0.42894548f, 0.51904929f, -0.04172479f, -0.00951922f, 0.00546114f, -0.17272758f, -0.11936757f, -0.13908181f, 
    0.13574591f, 0.05464618f, -0.05546258f, -0.00705324f, 0.10250371f, -0.11340083f, -0.00687029f, 0.21875300f, 
    -0.14979741f, 0.05484159f, 0.00758156f, -0.06886691f, -0.12894295f, -0.05872483f, 0.04751087f, 0.13176818f, 
    0.14619252f, -0.10960023f, -0.00122211f, 0.14283362f, -0.04457016f, 0.01470363f, -0.12572156f, 0.06835759f, 
    -0.02980791f, -0.07366997f, 0.18295383f, 0.01822321f, 0.36164367f, 0.07000209f, 0.01981435f, -0.05249763f, 
    0.06872840f, -0.07317617f, 0.10107309f, -0.07277808f, -0.02704898f, 0.03923455f, -0.15903528f, -0.25028703f, 
    0.19809830f, 0.13649553f, -0.10850894f, 0.02338919f, 0.05200424f, -0.00401197f, -0.09694777f, -0.01128605f, 
    0.00599658f, 0.01459924f, 0.08657912f, -0.07173473f, -0.10286667f, 0.00587146f, 0.21785358f, -0.01681850f, 
    -0.11520934f, -0.05981401f, 0.07173514f, -0.03208409f, -0.00457625f, -0.06153258f, -0.04128139f, -0.02741740f, 
    0.30910400f, 0.33922592f, 0.05799123f, -0.21519002f, 0.01485497f, -0.00572204f, -0.06290241f, -0.07965077f, 
    0.04092355f, -0.25493193f, -0.13690270f, -0.17377749f, 0.30777612f, -0.04938266f, -0.06511713f, -0.35040027f, 
    -0.03962656f, -0.08699539f, -0.01115118f, -0.15869683f, -0.00039560f, 0.06257840f, -0.01846817f, -0.07121242f, 
    -0.17079847f, 0.07563467f, 0.07325008f, 0.06936735f, -0.03861544f, -0.00070708f, 0.08708496f, 0.03714390f, 
    0.10193483f, 0.04635656f, -0.10960127f, -0.09016311f, -0.29744163f, 0.27045575f, -0.05121657f, -0.32465392f, 
    0.14235041f, 0.05798990f, 0.08523699f, -0.09126009f, 0.03621724f, 0.04159316f, 0.12823692f, 0.09592058f, 
    -0.59577441f, -0.07017597f, 0.24094878f, 0.00455048f, 0.08812400f, -0.05495072f, 0.05980102f, -0.12010950f, 
    -0.04950648f, 0.11813318f, 0.05487011f, -0.00887232f, 0.69066858f, 0.12599722f, -0.11996388f, 0.17421286f, 
    0.18869884f, -0.00542751f, 0.05868056f, 0.06625080f, 0.04501551f, 0.09250834f, -0.02884698f, 0.10178395f, 
    -0.29196063f, -0.17014197f, 0.12408417f, 0.11692882f, -0.13282713f, 0.10037848f, -0.10679890f, 0.00653811f, 
    0.01150118f, -0.04663850f, -0.27970856f, -0.09524330f, -0.20813103f, -0.02562804f, -0.03956598f, 0.11230962f, 
    0.17730692f, 0.04431140f, 0.04403621f, -0.01877258f, 0.13931808f, 0.00981398f, -0.03969622f, 0.12584096f, 
    0.41399282f, -0.13155153f, 0.04506746f, 0.06813094f, -0.03205933f, 0.03222288f, -0.01011441f, -0.06994790f, 
    0.08454616f, -0.07013144f, 0.06735910f, -0.09934780f, 0.60413575f, 0.04605573f, 0.30510667f, 0.34951103f, 
    -0.17733112f, -0.00147456f, 0.05648735f, 0.04869571f, 0.01867333f, 0.09598742f, 0.09677401f, -0.04454543f, 
    -0.00505389f, -0.09539738f, -0.19798194f, 0.17626087f, -0.09728964f, -0.03401510f, 0.11663493f, -0.23495121f, 
    0.08630972f, -0.11759932f, 0.03503513f, -0.02302045f, -0.14749654f, -0.24263178f, -0.04220657f, -0.01516940f, 
    0.02698801f, -0.02112259f, -0.25850189f, 0.02611497f, -0.14554381f, -0.14142500f, -0.22220346f, -0.00121514f, 
    -0.52139735f, 0.09782977f, -0.09264399f, 0.05806585f, -0.01656668f, 0.03718593f, 0.03175269f, -0.00413202f, 
    0.01241834f, -0.04451395f, -0.00573524f, 0.14839025f, -0.05176359f, -0.11563196f, -0.22024922f, -0.13543713f, 
    0.05038131f, 0.01234649f, -0.01202081f, -0.11074007f, -0.01993496f, 0.18212877f, 0.07040855f, 0.00137693f, 
    0.43700224f, 0.06274773f, 0.12997063f, 0.39640018f, -0.17379613f, 0.04853567f, -0.07912815f, 0.08123603f, 
    0.06101276f, -0.08898559f, 0.05781068f, -0.10093024f, 0.21056126f, 0.07512857f, 0.10794886f, 0.01646611f, 
    -0.11486093f, -0.10262400f, -0.05555719f, 0.23074764f, 0.08442078f, 0.08304018f, 0.01668931f, 0.12057018f, 
    -0.22535239f, -0.11646962f, -0.08888648f, 0.48658085f, -0.14320143f, -0.04978270f, 0.07414985f, 0.02707445f, 
    0.06529421f, -0.09537690f, 0.12439221f, -0.08006378f, -0.47075963f, 0.02073149f, -0.05443808f, 0.04066207f, 
    0.12441772f, 0.13351403f, 0.07728831f, -0.02121597f, 0.01856127f, 0.06452260f, -0.03086624f, 0.21957621f, 
    0.39806256f, 0.20249720f, 0.17262368f, 0.14864784f, -0.02699982f, 0.10305164f, -0.09945308f, -0.09149076f, 
    -0.00247146f, -0.13466921f, -0.02134544f, -0.01945308f, 0.25105995f, -0.12143987f, 0.24522686f, 0.07247056f, 
    -0.09584907f, 0.10320815f, 0.09491099f, 0.03708293f, 0.02776673f, -0.00279309f, -0.01499223f, 0.11739691f, 
    0.08431922f, -0.14870153f, 0.15159623f, 0.11994967f, -0.12680793f, 0.00366499f, 0.15429723f, 0.21879147f, 
    0.10562658f, 0.05232615f, 0.05375367f, 0.09200792f, -0.23207070f, -0.03091388f, -0.01929318f, -0.03760973f, 
    0.06137899f, 0.19581316f, 0.02763123f, 0.13684538f, 0.01648510f, 0.03527895f, 0.14708811f, 0.08556516f, 
    0.35226291f, 0.10760560f, 0.07152214f, -0.22314121f, -0.02073822f, 0.19136263f, -0.04640400f, -0.05953501f, 
    0.03558264f, 0.16870198f, 0.08896140f, -0.14503287f, 0.50521362f, 0.02153273f, -0.10989939f, 0.28257725f, 
    0.04589576f, 0.02795779f, 0.03820868f, 0.15925878f, -0.04280340f, 0.05109003f, -0.11613782f, -0.02864093f, 
    0.22325082f, -0.07796255f, 0.20451775f, -0.01490009f, -0.16637358f, 0.07730977f, 0.02002149f, -0.01276485f, 
    -0.09623478f, 0.04707789f, 0.08886690f, 0.00411598f, 0.86305493f, 0.11230168f, 0.40380329f, 0.00477706f, 
    -0.06900061f, 0.01570438f, -0.02217207f, -0.03407286f, -0.03487830f, 0.00960230f, -0.05821783f, 0.06406717f, 
    -0.09077948f, 0.12887129f, 0.08338308f, 0.09377986f, -0.11396993f, 0.08331205f, -0.05547455f, 0.04988455f, 
    -0.13687971f, -0.01277691f, -0.11052926f, -0.11988726f, -0.25777912f, 0.04834002f, 0.00706430f, -0.15239896f, 
    0.11366724f, -0.17244874f, 0.05970929f, 0.01106633f, 0.02669975f, -0.05222872f, 0.01824365f, 0.10150851f, 
    0.34341973f, 0.22868457f, 0.17317459f, 0.06055488f, 0.10224497f, 0.15477966f, 0.09914944f, 0.09961466f, 
    -0.00169778f, -0.05896316f, -0.10005561f, -0.03091959f, -0.21543956f, 0.04238376f, -0.10342803f, -0.09514093f, 
    0.05574416f, 0.10934457f, 0.04823327f, -0.03472214f, -0.01972581f, -0.08827931f, 0.19598515f, 0.06374163f, 
    0.38659626f, 0.20005099f, 0.05974105f, 0.06782715f, -0.15116857f, -0.18351297f, 0.06521850f, 0.17431077f, 
    0.11308037f, 0.09746494f, 0.00335247f, 0.10725473f, -0.11247705f, 0.02831650f, 0.02070111f, 0.17212303f, 
    0.07870208f, -0.06491789f, 0.04328934f, 0.10502304f, -0.09296712f, 0.04837667f, 0.03261596f, 0.17823148f, 
    -0.42010027f, -0.39173546f, -0.21766673f, -0.13227734f, 0.00360888f, 0.07083741f, 0.08107273f, -0.11966938f, 
    0.07030042f, 0.04857441f, 0.04652611f, 0.13097024f, 0.16995485f, -0.27792150f, -0.16050819f, -0.18803725f, 
    0.05427485f, 0.00155390f, -0.15441020f, -0.12095497f, -0.02595887f, 0.12751794f, -0.03336031f, 0.02883036f, 
    -0.35015875f, 0.22719294f, 0.05835038f, -0.22941267f, 0.05452239f, -0.00046877f, -0.02382303f, -0.01210168f, 
    -0.02698806f, -0.12809220f, -0.13842511f, -0.11097415f, 0.06539205f, -0.05601631f, -0.32843339f, -0.30089188f, 
    0.26043364f, -0.00709364f, -0.08018980f, 0.01222261f, 0.08852253f, -0.06666552f, -0.02045188f, -0.07243846f, 
    -0.02219777f, -0.00133689f, -0.01133973f, -0.01088574f, -0.03866013f, -0.04696133f, 0.02348042f, 0.03015844f, 
    0.01662189f, -0.00396684f, -0.05486729f, 0.02427463f, 0.01735912f, 0.01936621f, -0.04740486f, -0.02852830f, 
    0.02429019f, 0.00729698f, 0.00301968f, -0.02347308f, -0.04265683f, -0.03770223f, -0.04703116f, -0.00657479f, 
    -0.00829932f, -0.04994588f, 0.02236439f, -0.02192325f, 0.03635732f, 0.03847280f, -0.01578688f, 0.01873440f, 
    -0.00442877f, -0.05619903f, 0.03604857f, -0.05228985f, 0.00065793f, -0.00881174f, -0.00179581f, -0.02977913f, 
    -0.04201595f, 0.01854793f, -0.04063489f, -0.00533259f, -0.02537475f, 0.02232616f, -0.03426143f, -0.02685485f, 
    0.01673404f, 0.00869707f, -0.05505077f, -0.04322567f, -0.00009746f, -0.02588792f, 0.03150776f, -0.00772056f, 
    -0.00143224f, 0.04439225f, -0.05165387f, -0.05551991f, 0.02282118f, -0.02273438f, -0.02208103f, 0.02266010f, 
    0.01833215f, -0.01061267f, 0.02636125f, 0.02253990f, -0.03754259f, -0.00937371f, -0.04370480f, -0.04096639f, 
    -0.01027691f, -0.00684129f, -0.03919546f, -0.04384151f, 0.04173901f, -0.04502166f, -0.01568299f, 0.01739340f, 
    -0.01630296f, -0.05517136f, -0.04341014f, 0.01561458f, -0.00358911f, 0.03857737f, 0.01399582f, -0.02376136f, 
    -0.05699121f, 0.04152514f, -0.04446382f, -0.03304245f, 0.02358680f, -0.01032482f, -0.02972974f, 0.02354264f, 
    0.02751641f, -0.04565402f, 0.03956980f, -0.03301296f, 0.01430440f, -0.05129649f, 0.04282149f, 0.01450661f, 
    -0.01407686f, 0.00040727f, -0.00157615f, 0.00363223f, -0.04427995f, -0.05160313f, 0.03512863f, 0.02228466f, 
    0.01585377f, -0.01348176f, 0.02332528f, 0.00568812f, -0.00571587f, 0.01299305f, -0.01125288f, -0.04210159f, 
    0.01861861f, -0.04997541f, -0.03203741f, 0.02321925f, 0.02506020f, -0.01597438f, -0.04288703f, -0.01184731f, 
    -0.03137559f, -0.04341914f, -0.03704734f, -0.01283676f, 0.02243274f, -0.05113504f, -0.01510726f, -0.05601421f, 
    -0.04019434f, 0.03476539f, -0.03805483f, 0.01453150f, -0.02450506f, 0.01773882f, -0.03280270f, 0.01833392f, 
    0.03764192f, 0.03468674f, -0.02221129f, -0.02290396f, -0.04402024f, -0.01481639f, -0.05395125f, -0.00854657f, 
    0.01591591f, 0.01426299f, -0.00589411f, -0.01250327f, -0.00486279f, -0.00488162f, 0.03990895f, -0.00511863f, 
    0.00035009f, 0.03576622f, 0.01911200f, 0.04485772f, 0.03911667f, 0.03810063f, -0.05283553f, 0.03928925f, 
    -0.03246829f, 0.02378136f, 0.00460864f, -0.04861530f, 0.03343176f, -0.05570938f, 0.04071398f, 0.00673804f, 
    -0.04311708f, -0.02649866f, -0.03620675f, -0.04070226f, 0.01839752f, -0.05113846f, -0.05286081f, 0.00465146f, 
    0.01902529f, -0.01388077f, -0.00099551f, -0.05588590f, -0.05687105f, 0.03683415f, -0.05391832f, -0.04814843f, 
    0.03692274f, -0.05366771f, -0.00115713f, 0.00515198f, -0.00483146f, 0.02754357f, -0.04927829f, -0.03912676f, 
    -0.05417905f, 0.01463553f, -0.00523069f, 0.02387593f, -0.01620274f, 0.00879034f, -0.01187656f, 0.03590798f, 
    -0.02503652f, -0.01533987f, -0.05524560f, -0.02172569f, -0.05425926f, 0.02423591f, -0.03380365f, 0.00049676f, 
    -0.01332576f, 0.00300060f, 0.02719305f, -0.00847375f, 0.00684664f, 0.01423898f, 0.02965325f, -0.03456090f, 
    0.03912424f, 0.01939939f, -0.02192308f, 0.02591393f, 0.02226223f, 0.01068699f, -0.03513210f, 0.01715318f, 
    -0.00132573f, 0.02902152f, 0.02019525f, -0.03098807f, -0.00270928f, -0.00216504f, 0.02292472f, -0.03376362f, 
    0.01418561f, 0.02086299f, -0.01157575f, 0.00477393f, -0.02935612f, -0.01002087f, 0.01223044f, 0.01085535f, 
    -0.01232655f, -0.03075119f, -0.04229478f, -0.00036574f, -0.04969443f, -0.00268590f, -0.00400400f, 0.04802771f, 
    -0.01295919f, 0.04216789f, -0.02299877f, -0.00260195f, 0.01750313f, -0.02885155f, 0.03878721f, -0.02792851f, 
    -0.01839926f, 0.01569446f, -0.04885300f, -0.03913574f, -0.02666373f, 0.03856377f, -0.02097295f, -0.02871615f, 
    0.03494008f, -0.00678921f, 0.01737269f, -0.00642201f, -0.04692437f, 0.03627396f, 0.01482225f, 0.01419601f, 
    -0.00691863f, -0.03407216f, -0.04781350f, -0.03967390f, -0.01530414f, 0.03171625f, 0.03082713f, -0.00307198f, 
    -0.01861035f, -0.01488937f, -0.04040391f, 0.02245368f, 0.02276395f, 0.02737456f, -0.03944886f, 0.03890635f, 
    -0.03965601f, 0.03957024f, -0.05199312f, 0.01678186f, 0.01352428f, 0.02169607f, -0.00613867f, -0.05131594f, 
    -0.05506015f, -0.02430931f, -0.04466901f, 0.01897344f, -0.04606243f, 0.00906144f, -0.05489628f, 0.00148352f, 
    0.02753036f, 0.04141193f, -0.00125584f, 0.00932526f, 0.04080769f, 0.03008005f, -0.03120491f, -0.04970518f, 
    -0.00096979f, -0.02790434f, 0.00961272f, -0.00887880f, -0.00723586f, -0.00000200f, -0.04942171f, 0.01341736f, 
    -0.01864233f, -0.03090448f, -0.01793974f, -0.04048119f, -0.02567219f, -0.00398226f, -0.00778087f, 0.00534796f, 
    -0.05247283f, 0.02450873f, 0.02386146f, 0.03236982f, -0.02472292f, 0.03439074f, -0.05141555f, -0.02333340f, 
    0.00342258f, -0.00013742f, 0.03043831f, -0.00882817f, -0.00405989f, -0.02547646f, -0.01987133f, -0.00973047f, 
    -0.02807742f, 0.02173006f, 0.02815468f, 0.04413320f, -0.03299647f, -0.00774860f, -0.03647611f, 0.03299963f, 
    0.02025360f, -0.03228222f, -0.03818095f, -0.00278849f, -0.01537941f, -0.04945670f, -0.03144598f, -0.03029851f, 
    0.02780990f, 0.02520628f, 0.03346563f, 0.01721988f, 0.02853538f, 0.00348992f, -0.04716111f, -0.00403043f, 
    0.04321198f, 0.02992836f, -0.03026273f, -0.01826406f, -0.02866391f, 0.01220301f, 0.02608754f, -0.00772506f, 
    -0.25522995f, 0.06496896f, 0.17935178f, -0.03182655f, -0.10568675f, -0.05073966f, 0.17870024f, 0.10969799f, 
    0.08455259f, -0.03863554f, 0.02018150f, 0.12089270f, -0.33554900f, -0.19183780f, 0.01908245f, -0.01076294f, 
    -0.11735258f, 0.09355905f, 0.04782773f, -0.26869151f, 0.08614697f, -0.01130103f, 0.00037892f, -0.12005713f, 
    1.15843976f, 0.23780574f, 0.05052038f, -0.40445757f, 0.03297354f, -0.02645888f, -0.07971145f, -0.05267540f, 
    -0.06766685f, -0.04172010f, -0.17855127f, -0.11402766f, 0.16064392f, 0.08026997f, -0.10520385f, -0.01442212f, 
    0.06918224f, 0.22125502f, 0.11135647f, -0.10234800f, 0.10263870f, -0.02854816f, -0.07238975f, -0.11689092f, 
    0.57817495f, 0.01989751f, 0.03168508f, 0.04491679f, -0.00882937f, -0.19079600f, -0.01539591f, -0.01212430f, 
    -0.07241838f, -0.05250488f, 0.05830875f, 0.03443530f, -0.09579801f, 0.11844476f, 0.08851804f, 0.03029360f, 
    0.05459788f, 0.04917667f, -0.17854749f, 0.02690880f, 0.09427044f, -0.11558387f, 0.16623841f, -0.22897935f, 
    -0.04166196f, 0.22821482f, -0.15151653f, 0.23405045f, 0.06788025f, -0.05473625f, 0.22083156f, 0.05560159f, 
    -0.01664064f, 0.06310406f, 0.09579451f, 0.04550958f, -0.23232050f, -0.24803448f, -0.26277086f, -0.22230378f, 
    0.11136837f, 0.00482690f, 0.01286276f, -0.09247268f, 0.00558409f, -0.08577802f, -0.04141545f, 0.04340531f, 
    -0.20152013f, -0.04389629f, 0.24944048f, 0.08023876f, 0.13576671f, -0.09993851f, -0.08423964f, -0.02880300f, 
    -0.01793749f, 0.02098747f, -0.23871750f, -0.00855198f, -0.19590858f, 0.03471193f, 0.12824915f, 0.12988478f, 
    -0.05774423f, -0.00174236f, 0.09180307f, 0.04517709f, 0.03170495f, 0.03996487f, -0.00315439f, 0.14437421f, 
    0.00972062f, 0.06805997f, 0.07258625f, 0.09231557f, 0.03637112f, -0.08467195f, -0.22050837f, -0.11955560f, 
    0.08998175f, -0.20255384f, -0.04930752f, -0.02438613f, -0.07922357f, -0.25251374f, -0.14917265f, 0.15992557f, 
    -0.12549759f, 0.04476616f, 0.13450822f, -0.00159691f, -0.05091466f, 0.06041882f, 0.10700667f, 0.08813856f, 
    -0.10332286f, 0.03685872f, 0.10226920f, 0.08756146f, -0.02116912f, -0.08605605f, 0.14482722f, -0.04195958f, 
    0.06748565f, -0.27735242f, -0.05495822f, -0.05638519f, 0.13787046f, -0.06479613f, 0.20148592f, -0.11401705f, 
    0.08496764f, 0.08630889f, -0.08393759f, 0.18324552f, 0.14746194f, -0.21715768f, 0.10934614f, 0.17058516f, 
    0.02380973f, 0.08436872f, 0.02107102f, -0.04570495f, -0.04858994f, -0.09838802f, 0.09871123f, -0.11203465f, 
    0.06402723f, -0.22208899f, -0.15659831f, -0.13822860f, 0.12536679f, -0.10611722f, -0.12316957f, 0.08899427f, 
    0.00801547f, -0.06824733f, 0.10177894f, -0.05595330f, -0.02510007f, -0.01829003f, 0.04386244f, -0.05668997f, 
    0.11389776f, -0.01065305f, -0.15328419f, 0.10862543f, -0.03635601f, -0.15557297f, 0.20779362f, 0.19198871f, 
    0.16719194f, 0.02344401f, 0.06423513f, 0.12302997f, -0.22504573f, -0.01832666f, 0.18942034f, -0.25599679f, 
    0.04109201f, -0.02230834f, -0.13775410f, 0.06343168f, 0.03065864f, 0.08019537f, 0.18080446f, 0.25046858f, 
    0.30412751f, 0.03607210f, 0.18737254f, -0.01798218f, 0.01556200f, 0.05388847f, 0.05702276f, -0.01775264f, 
    0.18451118f, -0.01300244f, 0.13632849f, -0.03796842f, -0.31962034f, -0.08445818f, -0.04529489f, -0.00645832f, 
    -0.03008175f, 0.12726751f, 0.08862893f, 0.15916152f, 0.10531014f, 0.24037752f, -0.02506418f, 0.00547515f, 
    0.11776476f, -0.16330305f, 0.26339394f, -0.20845607f, 0.05101904f, 0.03718673f, 0.05051456f, -0.06126271f, 
    0.04182285f, -0.15786536f, 0.02199101f, -0.00084353f, 0.21698809f, 0.16807218f, -0.13585863f, 0.08899143f, 
    0.11265186f, -0.00810020f, -0.02542652f, -0.08396418f, -0.16058584f, 0.14250028f, -0.08174596f, 0.04344696f, 
    0.60264337f, 0.16513358f, 0.16350748f, -0.13755812f, 0.03876389f, 0.07378327f, -0.02166664f, 0.00987664f, 
    -0.06619023f, -0.01381251f, -0.01711723f, -0.05074891f, 0.24897566f, -0.19945762f, 0.05393958f, 0.12956582f, 
    0.04114283f, -0.04677166f, 0.17250556f, -0.07749551f, -0.07315395f, 0.12007422f, -0.12795193f, -0.11332711f, 
    0.05526766f, -0.05135036f, 0.06378159f, -0.15225087f, 0.00815747f, -0.20171678f, 0.00246499f, 0.04813534f, 
    0.02283580f, 0.10685777f, 0.04139467f, 0.06076885f, -0.31982598f, 0.20236339f, 0.13023311f, 0.13848794f, 
    -0.17561045f, 0.07273027f, 0.17220609f, 0.12742315f, -0.18120170f, 0.02850041f, 0.33429873f, 0.24438083f, 
    -0.15957908f, -0.17575938f, -0.14334100f, 0.08476468f, -0.01310588f, 0.00298595f, -0.11521291f, -0.09809985f, 
    -0.09033924f, 0.06542843f, 0.02868000f, -0.19060284f, -0.05943614f, -0.05176178f, 0.02280031f, 0.10629170f, 
    -0.08370842f, -0.09000833f, -0.05032254f, -0.09697696f, -0.03179032f, 0.02512361f, -0.01300149f, -0.05424611f, 
    0.31290486f, 0.27938461f, 0.10473323f, 0.13216384f, -0.02482499f, 0.11740978f, 0.20379956f, 0.11420128f, 
    -0.06135947f, 0.00579063f, 0.00758408f, 0.04444957f, 0.06483485f, -0.15375352f, -0.22825509f, 0.13317554f, 
    0.04346564f, 0.06411960f, 0.18409155f, -0.00571305f, 0.06797863f, 0.02849463f, -0.08280749f, 0.08813077f, 
    -0.08447549f, -0.01130928f, 0.01901473f, 0.24275760f, 0.13313608f, -0.04044537f, -0.25835109f, 0.03318713f, 
    0.04728485f, -0.04640722f, 0.09878358f, -0.11797403f, -0.34116143f, 0.10118732f, -0.05705957f, 0.17003721f, 
    0.04536572f, -0.04846146f, 0.08264750f, -0.07902189f, -0.03339640f, -0.05153397f, 0.01969371f, -0.10153275f, 
    -0.11581112f, 0.45825997f, -0.23437998f, -0.12391651f, 0.17769107f, 0.02269732f, 0.09253325f, -0.15397494f, 
    -0.12213107f, 0.10496441f, 0.05335612f, 0.10079483f, -0.03785151f, -0.07552197f, 0.27685121f, -0.28839597f, 
    -0.22045660f, 0.09006644f, -0.05784429f, -0.13235164f, -0.03012658f, -0.02554815f, 0.05226345f, 0.02692980f, 
    -0.33835417f, 0.01206805f, 0.05292790f, -0.12560047f, 0.13237555f, -0.05670423f, -0.06091009f, -0.04926128f, 
    0.15505593f, -0.11331785f, -0.08710476f, 0.06690492f, -0.46759450f, -0.33591133f, -0.03705170f, -0.09633623f, 
    -0.12165850f, -0.15453078f, -0.08167404f, -0.14703089f, -0.04681884f, 0.02592384f, 0.08416627f, 0.05908171f, 
    -0.11667194f, -0.03536325f, 0.20354250f, -0.10066776f, 0.02998023f, 0.06429900f, 0.19360238f, 0.07742891f, 
    0.16617939f, 0.00788046f, 0.07719025f, 0.08105052f, 0.01605402f, 0.00153367f, 0.18325722f, 0.10917734f, 
    -0.09815358f, -0.00352992f, -0.01544122f, 0.06663374f, -0.02486102f, -0.07731239f, 0.04874705f, 0.13234866f, 
    0.51086938f, -0.15474753f, 0.18930827f, -0.10944876f, 0.01915056f, 0.11947455f, -0.12082985f, 0.18666573f, 
    -0.11282748f, 0.02438979f, 0.15914322f, 0.21347401f, 0.25388679f, -0.12515895f, 0.07559651f, -0.19133383f, 
    0.05483214f, 0.10216960f, -0.17235580f, -0.21194479f, 0.12535965f, 0.00783617f, -0.06101365f, 0.12840275f, 
    -0.37005648f, -0.03863988f, 0.21428946f, -0.27170205f, 0.01046212f, -0.08533037f, -0.11578738f, 0.04879731f, 
    0.10932732f, 0.04961997f, 0.00926400f, 0.05237220f, -0.36638114f, 0.00645951f, -0.10575614f, 0.20887022f, 
    0.23973125f, 0.05949925f, 0.08780835f, 0.02149422f, 0.09449335f, -0.07148173f, -0.01078530f, -0.00815424f, 
    -0.13522734f, 0.07761055f, 0.17292151f, 0.07506279f, -0.15066104f, -0.01667112f, -0.03856132f, 0.02256920f, 
    -0.20212670f, -0.00290074f, -0.02312545f, 0.03405461f, 0.25005090f, -0.16267452f, 0.10565279f, 0.15402614f, 
    -0.09722993f, -0.06222818f, -0.00700680f, -0.11132438f, 0.06061029f, 0.08225173f, -0.11229104f, 0.04880825f, 
    -0.02390324f, -0.05246872f, 0.35028556f, 0.03553357f, -0.10210624f, -0.12015156f, 0.09385407f, 0.02674984f, 
    0.08240072f, 0.04979941f, 0.05561072f, 0.09942515f, -0.86214668f, -0.12200643f, -0.08575463f, 0.06984942f, 
    0.23593134f, -0.02267417f, 0.07583482f, 0.01414867f, 0.07877929f, 0.12034845f, -0.05958981f, 0.07379150f, 
    -0.15966225f, 0.11127134f, 0.06356864f, -0.00938413f, -0.21109700f, 0.15485945f, 0.01385113f, 0.02403764f, 
    -0.02740791f, 0.17765923f, 0.01443374f, 0.06643610f, 0.07488721f, 0.42732340f, -0.27689359f, 0.34336570f, 
    0.03378144f, 0.02582372f, 0.06879868f, -0.12707520f, -0.03432015f, -0.00069649f, -0.00361039f, -0.11860857f, 
    -0.22940359f, 0.43758950f, -0.11189020f, 0.11172041f, 0.19118127f, -0.00350797f, 0.05539401f, -0.01785132f, 
    -0.14231624f, -0.08124526f, 0.05677184f, -0.11249421f, -0.55279034f, 0.42828539f, 0.15398481f, -0.20554189f, 
    0.04527974f, 0.16866177f, 0.05145341f, 0.06261092f, -0.01155030f, 0.05022540f, 0.03768730f, 0.02388497f, 
    -0.08620390f, 0.38395059f, -0.00943088f, -0.11736684f, 0.11688973f, 0.00733204f, -0.06974641f, 0.02970093f, 
    0.04772572f, 0.18971002f, 0.04803343f, 0.00708364f, -0.10110918f, -0.17145993f, 0.09235919f, -0.17907803f, 
    0.01015785f, 0.01207874f, -0.01204421f, 0.07755682f, 0.02292696f, 0.03459387f, 0.07859905f, 0.10904945f, 
    0.12866123f, 0.03461107f, 0.18420815f, 0.41826141f, 0.27695146f, 0.04979044f, 0.10434861f, 0.12727572f, 
    0.04087840f, 0.04195171f, -0.04990719f, 0.07135593f, 0.25098038f, 0.39463475f, -0.18704212f, 0.48956764f, 
    0.17816918f, -0.06846963f, 0.04248018f, 0.19700260f, 0.04954458f, -0.02565771f, 0.08304424f, 0.26561877f, 
    -0.16759136f, -0.28093997f, 0.27530754f, -0.30885899f, -0.14710857f, 0.07555903f, 0.11173606f, -0.24640650f, 
    0.16297325f, 0.08223167f, -0.01316544f, -0.00641879f, -0.49019226f, -0.13266046f, 0.01161007f, 0.19381554f, 
    -0.03813891f, -0.10228214f, -0.03948512f, -0.11773092f, 0.05059619f, 0.05631065f, 0.05918210f, 0.00110847f, 
    0.54165572f, 0.18702380f, 0.02644768f, 0.17973459f, -0.06657939f, 0.00808989f, -0.13924927f, -0.02735318f, 
    0.04472806f, 0.04778536f, 0.01593146f, -0.10717099f, -0.59065926f, 0.53773797f, -0.20324032f, 0.20077711f, 
    0.12530287f, 0.16079004f, -0.08765476f, -0.09183145f, -0.12717207f, 0.01039276f, -0.12713160f, -0.12333968f, 
    0.08303171f, -0.28246620f, 0.15905087f, 0.07983217f, -0.15002246f, -0.28229454f, 0.06481163f, -0.08875246f, 
    0.05659043f, -0.10675130f, -0.08718163f, -0.02541492f, -0.04050246f, -0.10175713f, 0.22899804f, 0.55921751f, 
    0.13090250f, 0.09071939f, 0.16886777f, 0.21452758f, 0.05875571f, 0.05790552f, 0.17768236f, 0.14371291f, 
    -0.20856948f, -0.03159295f, 0.17208660f, 0.06804454f, 0.38071147f, 0.07956909f, -0.00322024f, 0.15524809f, 
    0.12738340f, 0.05584912f, 0.07660389f, 0.05500484f, 0.48884082f, -0.12909834f, 0.12669784f, -0.22036441f, 
    -0.03128958f, 0.05029957f, -0.06460198f, -0.08599882f, -0.02947166f, 0.23785162f, 0.14855506f, -0.01708023f, 
    0.34656939f, 0.13086236f, -0.05017615f, 0.18990219f, 0.35087124f, -0.03753692f, 0.15018383f, 0.07380070f, 
    0.10906984f, 0.13776875f, 0.00513316f, 0.14893222f, -0.02117484f, -0.24940218f, -0.04560088f, -0.05639568f, 
    0.13524154f, 0.05502995f, 0.14689606f, 0.27450278f, 0.00084914f, 0.05701999f, 0.01105251f, 0.00656641f, 
    0.01766070f, 0.04388214f, -0.00998291f, -0.01365832f, -0.00417806f, -0.02644794f, -0.04593934f, 0.03993868f, 
    -0.02369098f, 0.02930668f, -0.02018219f, 0.00212959f, -0.04758334f, -0.03574193f, -0.01464344f, 0.03474106f, 
    0.03731557f, -0.02685435f, -0.00205468f, 0.03819777f, -0.00391233f, 0.03278505f, -0.01366716f, 0.00587729f, 
    0.02211829f, 0.02742755f, 0.02210358f, -0.04185094f, 0.01814335f, -0.02993911f, -0.00432572f, 0.02505625f, 
    -0.03084379f, 0.01416727f, -0.03436452f, 0.01026094f, 0.01405042f, 0.00689615f, -0.02313767f, 0.02332295f, 
    -0.01454875f, -0.00531796f, -0.05760190f, -0.04935597f, -0.03094759f, 0.02387723f, 0.03074005f, -0.03931125f, 
    0.03014792f, -0.01671050f, -0.04236832f, 0.01536428f, 0.03301887f, 0.01662409f, -0.03230024f, 0.01728766f, 
    0.02564558f, -0.04287194f, 0.01793351f, -0.01673033f, -0.06727911f, -0.01980347f, -0.00481592f, 0.01615295f, 
    -0.03328029f, 0.02796602f, 0.01072123f, 0.00453614f, 0.04738078f, 0.00725082f, -0.02954980f, 0.02414494f, 
    0.01843492f, -0.03353120f, 0.03087621f, -0.01822196f, -0.01257423f, -0.02874998f, 0.03334072f, -0.03087373f, 
    0.02126551f, -0.04955480f, 0.01931073f, 0.05085364f, -0.04021442f, -0.05818737f, -0.06151355f, 0.01329311f, 
    -0.01550648f, -0.03318070f, 0.05064468f, 0.00161475f, -0.00967878f, 0.00567509f, 0.00393943f, 0.03831833f, 
    -0.05776864f, 0.00888919f, 0.01628372f, 0.02737335f, 0.01684333f, 0.00549927f, -0.02313282f, 0.03122941f, 
    -0.01720078f, 0.02710397f, 0.02715234f, 0.00262036f, 0.02834939f, 0.04473030f, 0.03951919f, -0.04975937f, 
    0.02972375f, 0.01726533f, 0.02757543f, 0.00967592f, -0.03987370f, -0.03692469f, 0.02760257f, -0.05463519f, 
    -0.05844859f, 0.01392087f, -0.00959374f, -0.02524704f, -0.03076971f, -0.03677218f, 0.00794823f, -0.01585585f, 
    -0.03656165f, 0.00785470f, -0.03766090f, -0.02563891f, -0.05055709f, 0.00514347f, 0.00747457f, 0.03784906f, 
    -0.04416360f, -0.04820984f, -0.05407505f, -0.06516740f, -0.01561180f, 0.03582233f, 0.03221060f, -0.04489887f, 
    -0.01728114f, 0.00909542f, 0.02854645f, -0.00549238f, 0.02451212f, -0.00932663f, -0.01473474f, -0.00897280f, 
    -0.00533091f, 0.01426984f, 0.00497845f, -0.02360634f, 0.00574017f, 0.03820829f, -0.00280581f, -0.01159548f, 
    -0.02894890f, -0.01255460f, 0.02368198f, 0.01669267f, -0.01599205f, 0.01016894f, 0.03770691f, 0.00376360f, 
    -0.00381673f, -0.00269462f, -0.00768746f, -0.04297055f, -0.01560539f, -0.03645643f, -0.03412705f, 0.02194482f, 
    0.01845278f, 0.03493806f, -0.01842530f, 0.03003274f, -0.04983819f, -0.03377470f, -0.05761765f, 0.01263323f, 
    -0.03099459f, -0.04150630f, -0.01327489f, 0.00841264f, -0.03547631f, -0.00580589f, 0.00479222f, -0.02574465f, 
    -0.06434674f, -0.00274852f, -0.03223129f, -0.05408446f, -0.02543306f, -0.02761682f, 0.01353530f, 0.01299989f, 
    -0.04821400f, -0.00663945f, 0.00578426f, 0.00041169f, 0.04345449f, 0.03204240f, 0.03176031f, -0.00371656f, 
    0.02928864f, -0.02954527f, -0.05343482f, 0.02778290f, 0.00308975f, 0.01268933f, 0.05095522f, -0.00014884f, 
    0.04455247f, -0.00859787f, 0.00067720f, 0.00232345f, -0.04137739f, 0.03427365f, -0.02650210f, -0.02585998f, 
    0.01937048f, -0.00438783f, 0.02494001f, -0.00810122f, 0.00616739f, -0.00417757f, 0.01371704f, -0.00447097f, 
    -0.00129194f, -0.04495230f, -0.03114410f, 0.02732558f, 0.04389284f, -0.00221103f, -0.01388441f, 0.02847358f, 
    -0.02016570f, 0.04437034f, 0.00819863f, 0.02850679f, -0.00130100f, 0.01036555f, -0.03155776f, -0.03766764f, 
    -0.03868129f, -0.04661353f, 0.00311850f, -0.02836967f, -0.01688309f, 0.01703393f, -0.02457073f, -0.05365286f, 
    0.01270796f, 0.02270454f, -0.01826102f, -0.00087483f, -0.02752295f, 0.01823645f, -0.05086681f, 0.00095948f, 
    -0.00369589f, -0.01628671f, -0.05418965f, -0.01245018f, -0.03109471f, -0.04194977f, -0.05436956f, 0.00905667f, 
    0.00281143f, -0.04972542f, -0.02761749f, -0.00627568f, -0.00549865f, -0.04623913f, -0.03757440f, 0.01438992f, 
    -0.00543136f, 0.02564339f, -0.05728225f, 0.03818820f, 0.04822175f, -0.05879181f, 0.00743228f, -0.05271045f, 
    -0.01958050f, 0.01932519f, -0.01994558f, 0.04478755f, -0.00057363f, 0.02770548f, 0.01896611f, -0.03842414f, 
    -0.02003231f, -0.04360364f, 0.01128269f, -0.04220726f, -0.02297963f, -0.02792685f, -0.04284310f, -0.04008841f, 
    -0.04201530f, -0.05584567f, -0.03943963f, 0.04072261f, 0.02863202f, -0.03676211f, 0.00272678f, 0.01457239f, 
    -0.03044872f, 0.01110850f, -0.06223743f, -0.04544037f, -0.03526125f, -0.01207446f, 0.02427542f, 0.03546425f, 
    0.00983674f, -0.01295246f, 0.01158095f, -0.04938062f, 0.02983794f, 0.00429176f, 0.02674476f, -0.03468955f, 
    0.01474274f, 0.02610322f, -0.01608242f, -0.04435474f, -0.01048259f, 0.02340455f, -0.04364666f, 0.03018944f, 
    -0.04160315f, 0.01387509f, -0.04054579f, -0.01565304f, -0.00441680f, -0.03630594f, -0.01677167f, 0.02507229f, 
    -0.03916988f, -0.03928171f, -0.03834084f, -0.06292772f, 0.03437025f, -0.01364805f, -0.03767556f, -0.05161414f, 
    0.05271316f, 0.01367437f, 0.01495212f, -0.01026393f, -0.03007974f, -0.02183412f, 0.00122164f, -0.00942013f, 
    -0.02263640f, 0.03525904f, 0.00152089f, -0.01828326f, 0.04351922f, 0.03845243f, -0.02602898f, 0.03071390f, 
    -0.05043055f, -0.02350848f, -0.03072938f, 0.00976328f, -0.03945896f, 0.02569092f, 0.01196869f, 0.02062424f, 
    0.01481562f, -0.00084289f, -0.04419350f, -0.03647289f, -0.00889492f, -0.04200878f, 0.03833345f, -0.00813361f, 
    0.01946949f, 0.36640000f, 0.03535176f, 0.06484810f, -0.07666629f, -0.06770656f, 0.06800240f, -0.01256925f, 
    -0.20720121f, 0.13709421f, -0.05759810f, 0.04186999f, 0.06283780f, -0.03492132f, -0.11032631f, -0.40564874f, 
    -0.08752547f, 0.04530051f, 0.05045635f, -0.15225612f, 0.14390638f, 0.04931936f, 0.07084102f, 0.07499924f, 
    0.20210944f, 0.36483434f, -0.03194262f, -0.44910949f, 0.06635608f, -0.00581138f, 0.07401276f, 0.16280937f, 
    0.03882401f, -0.03695991f, -0.07451373f, 0.07970837f, -0.23152012f, -0.11533480f, 0.11262479f, 0.04272397f, 
    0.27837324f, -0.04503789f, -0.00203149f, -0.05476428f, -0.06092139f, 0.10316063f, 0.03145394f, -0.07677618f, 
    0.26457465f, 0.28345594f, -0.13250424f, -0.07251897f, -0.03692302f, -0.03341345f, 0.02961864f, 0.14540230f, 
    0.07131948f, -0.03164988f, 0.02155495f, -0.01151706f, 0.01360976f, -0.24668089f, -0.06523298f, 0.39209956f, 
    0.06225541f, 0.11307221f, -0.06120807f, -0.10235160f, -0.06618728f, -0.10599454f, -0.07871985f, -0.13094635f, 
    -0.10599195f, 0.32191557f, 0.03885131f, 0.05504644f, -0.09793331f, 0.16119932f, -0.05324909f, 0.20475130f, 
    -0.05053053f, 0.09429783f, 0.15787925f, 0.02464204f, 0.10799438f, 0.07782265f, 0.03361437f, 0.02482904f, 
    0.12431414f, 0.03382957f, 0.02331541f, 0.00298996f, -0.08824503f, -0.07450151f, 0.01126446f, -0.01440389f, 
    0.33249888f, 0.26043707f, 0.20622918f, 0.05551564f, -0.21501172f, -0.04951772f, 0.04682246f, 0.01784933f, 
    -0.02307291f, -0.03627382f, -0.01776180f, -0.05713511f, 0.27098945f, 0.29123890f, 0.46336338f, 0.29902950f, 
    -0.09228631f, -0.02805140f, 0.02227332f, 0.15867883f, -0.02515787f, -0.07048933f, 0.03956523f, -0.00219816f, 
    0.05315134f, -0.19624288f, 0.02179162f, 0.22143224f, 0.01406775f, -0.00440180f, -0.05881187f, -0.14592537f, 
    0.05751683f, 0.06292105f, -0.05655674f, -0.05601937f, 0.02042103f, -0.25552976f, -0.06179747f, 0.07794725f, 
    -0.19348311f, 0.07604353f, 0.10505379f, -0.03717646f, -0.03923631f, 0.03564743f, -0.12852132f, 0.00209338f, 
    0.16114625f, 0.29973459f, -0.08924017f, -0.29854259f, -0.01328911f, -0.05834302f, -0.00323226f, -0.02413419f, 
    0.09554853f, 0.12629554f, 0.05693913f, -0.08065715f, 0.38529965f, 0.10340132f, 0.25946400f, 0.10057016f, 
    0.05523075f, -0.16355674f, 0.02346884f, 0.17316858f, -0.10580638f, -0.05497285f, -0.14421485f, 0.04336789f, 
    -0.13190629f, -0.33162463f, -0.20009863f, 0.38707232f, 0.16991895f, 0.03363144f, -0.01937259f, -0.05796295f, 
    -0.08288860f, 0.12076863f, -0.05645292f, -0.10134364f, 0.15175804f, 0.07566778f, -0.18846893f, 0.24163157f, 
    0.11504971f, 0.07132038f, 0.13864674f, -0.08675941f, 0.07724929f, 0.07600168f, 0.16083261f, 0.02200599f, 
    -0.07329857f, 0.36602399f, -0.15562831f, -0.02697293f, 0.02457041f, -0.02250277f, -0.00030385f, 0.05350472f, 
    -0.15490614f, 0.08400639f, 0.19604428f, -0.01673025f, -0.24570507f, -0.10896806f, 0.01974149f, -0.23992908f, 
    -0.00084896f, 0.06545430f, -0.06029708f, -0.08049394f, 0.06522312f, -0.02040569f, 0.07631593f, 0.13865317f, 
    0.30943531f, -0.30307320f, -0.02210996f, -0.08961640f, 0.09414895f, 0.04848659f, 0.03706086f, -0.05088810f, 
    -0.05545045f, 0.15766691f, 0.09386249f, 0.07301103f, 0.22627702f, 0.10821404f, 0.00547181f, -0.41898957f, 
    0.06016051f, -0.08420784f, -0.05307880f, -0.05276462f, 0.06849121f, 0.07245986f, -0.03021804f, 0.05652582f, 
    0.12320521f, 0.15875199f, 0.28851667f, 0.02299639f, 0.06325980f, -0.02830832f, -0.00423148f, 0.02841161f, 
    0.06328753f, -0.21733928f, -0.13169956f, 0.13005620f, 0.06345409f, 0.03218838f, -0.00363263f, 0.47254068f, 
    0.12894909f, 0.05486788f, -0.06203045f, -0.00614281f, -0.02906911f, -0.09825971f, -0.07373611f, 0.05966255f, 
    -0.01942471f, -0.12318950f, -0.37347931f, -0.29794186f, 0.12526983f, -0.03421298f, -0.04859433f, -0.03862403f, 
    0.03105583f, -0.00678043f, -0.10648165f, 0.17320803f, -0.38575724f, -0.24129190f, 0.00212794f, 0.35649154f, 
    -0.01865567f, 0.11351420f, -0.13139413f, -0.00667798f, -0.10502571f, 0.01996523f, 0.01983184f, -0.09304112f, 
    0.37609917f, -0.11371143f, -0.19552138f, 0.17484309f, 0.19536926f, -0.00365863f, -0.00820930f, 0.01390884f, 
    -0.07651816f, 0.05123645f, 0.07273872f, -0.00485561f, 0.01375567f, 0.08791484f, -0.06839587f, 0.37691274f, 
    -0.04470279f, -0.13450696f, 0.03950439f, 0.03698393f, 0.05286583f, 0.10743390f, -0.03064603f, -0.00229560f, 
    0.03280550f, -0.19626345f, -0.19126599f, 0.23442355f, 0.04818745f, 0.09058070f, 0.09502836f, -0.11028302f, 
    0.10651080f, 0.10717037f, -0.17944501f, -0.03429272f, 0.13460825f, 0.13624474f, 0.12700430f, 0.05864780f, 
    -0.02854425f, 0.05942035f, -0.02198100f, 0.06961348f, 0.03502841f, 0.17825575f, 0.14094886f, -0.11782765f, 
    -0.01323158f, 0.51276684f, 0.26639566f, 0.24216868f, -0.03560826f, 0.04268762f, 0.03796090f, 0.26186895f, 
    0.05330041f, 0.08317358f, 0.11150180f, -0.11629824f, 0.07676990f, 0.04394602f, 0.03568066f, 0.19293895f, 
    0.08142060f, -0.00254211f, 0.01764678f, 0.12106165f, -0.13479859f, 0.15069938f, 0.02719962f, -0.04648121f, 
    0.21442355f, -0.12278947f, 0.08141414f, 0.16436018f, 0.00080005f, -0.08394457f, -0.13267227f, 0.07823122f, 
    -0.04002373f, 0.07987195f, 0.08468902f, 0.09246048f, 0.44026399f, 0.17594120f, 0.10990524f, 0.18663862f, 
    -0.19067982f, -0.02539546f, 0.03964023f, -0.02399628f, -0.01143863f, 0.04626333f, 0.04768178f, 0.03877435f, 
    0.00451393f, 0.02074905f, -0.04779713f, -0.01990137f, -0.04823944f, 0.03276087f, 0.00724699f, -0.01071561f, 
    0.00850027f, -0.02433775f, -0.05471279f, 0.03139275f, 0.01159746f, -0.03924181f, 0.00696453f, 0.04431891f, 
    -0.03378102f, 0.00107028f, 0.03026880f, 0.02400110f, -0.00132992f, -0.02690076f, 0.00943839f, 0.03807652f, 
    0.02642024f, -0.00288545f, -0.00744061f, -0.02481003f, -0.00438346f, 0.02347768f, -0.00038797f, 0.01592428f, 
    0.04460154f, -0.05680098f, 0.03951235f, 0.00978594f, 0.01529240f, -0.04328819f, 0.00584827f, 0.01825128f, 
    -0.01874194f, 0.04445587f, -0.02606901f, 0.02530734f, -0.05266894f, 0.00577964f, 0.02300145f, -0.05339864f, 
    0.03792524f, -0.02341693f, -0.01573743f, -0.03122492f, 0.01849825f, -0.02151004f, -0.04507916f, -0.02900712f, 
    -0.03188772f, -0.05841663f, -0.02235122f, 0.00968274f, 0.00771500f, 0.03743409f, -0.05212320f, -0.02849657f, 
    0.00901887f, -0.05560176f, 0.03396019f, 0.00465458f, 0.04392588f, -0.03415620f, 0.00157646f, 0.01399081f, 
    0.01690139f, -0.01300357f, 0.01783089f, 0.02930849f, 0.03651955f, 0.01745936f, -0.01264884f, -0.00494808f, 
    0.01079317f, -0.00829776f, 0.02074299f, -0.00950394f, -0.03505497f, -0.04139169f, -0.03447878f, 0.04337225f, 
    -0.04622770f, -0.01864696f, -0.03629952f, -0.03796780f, -0.00959846f, -0.03489998f, -0.02236545f, 0.04715090f, 
    0.02217313f, -0.05232909f, -0.05550324f, -0.03968275f, -0.04065587f, 0.00795154f, -0.01803580f, 0.00753282f, 
    0.01059360f, 0.01485060f, -0.02526962f, -0.04059434f, -0.00081913f, 0.03918597f, 0.03868917f, -0.03227910f, 
    -0.01424744f, -0.01842799f, 0.04164732f, -0.02883571f, -0.04927269f, -0.01629419f, -0.04420058f, -0.00427354f, 
    0.01422484f, -0.05082059f, -0.00436705f, -0.02278870f, 0.02659693f, -0.02238037f, 0.01101957f, 0.03256797f, 
    -0.04556396f, -0.00869990f, -0.00846549f, -0.04229560f, -0.04574988f, 0.04132821f, -0.03086986f, -0.02886992f, 
    -0.02693490f, 0.00978696f, 0.03802726f, 0.03125785f, -0.01509035f, 0.00461092f, 0.04022330f, 0.02783801f, 
    -0.05051323f, -0.03109775f, 0.00214717f, 0.00551347f, -0.01354122f, 0.04198185f, -0.00006809f, -0.02374537f, 
    0.03512267f, -0.03020594f, -0.04426947f, 0.01235236f, -0.02935810f, -0.02320612f, 0.02930931f, -0.03142966f, 
    0.01220427f, -0.03267288f, 0.05151221f, -0.03912999f, -0.00653891f, -0.00105063f, -0.04175184f, 0.00025110f, 
    -0.05121329f, 0.00270689f, 0.03305771f, -0.04486177f, -0.03590434f, 0.04186736f, -0.02088710f, -0.00677107f, 
    -0.02262880f, -0.00965692f, -0.03129331f, 0.04026528f, -0.00111703f, 0.02262613f, -0.00343186f, 0.00827909f, 
    0.00606993f, 0.01908895f, 0.03567046f, -0.02579461f, -0.02773929f, 0.03478968f, -0.02246723f, -0.01378988f, 
    -0.04408599f, -0.01079731f, 0.03398858f, 0.03434279f, 0.03444250f, -0.00339062f, -0.03750484f, -0.01283780f, 
    -0.03256286f, 0.01086028f, 0.03329998f, 0.00057474f, 0.01269532f, 0.05170343f, 0.02112970f, -0.05082577f, 
    -0.00056515f, -0.05216977f, -0.04284772f, -0.00176798f, -0.05021410f, 0.04504250f, 0.00513089f, 0.02791506f, 
    -0.00478280f, -0.03185372f, -0.03165246f, 0.01614030f, 0.00294167f, 0.02619895f, 0.02737384f, -0.01764898f, 
    0.01329358f, 0.00494209f, -0.00807276f, -0.03025831f, 0.04937218f, 0.00150689f, 0.02452078f, -0.01556063f, 
    -0.02956469f, -0.02054176f, 0.03177579f, 0.03014608f, -0.03230988f, -0.02775371f, -0.03413953f, -0.01229650f, 
    -0.00552589f, 0.00028093f, -0.01002262f, -0.01798343f, 0.02194638f, -0.00898110f, -0.04390795f, -0.00615734f, 
    0.04167124f, -0.05444916f, -0.04802587f, 0.03802171f, 0.02646015f, -0.03929497f, -0.00416606f, 0.00153114f, 
    0.02346884f, -0.04572235f, -0.04072405f, 0.04511973f, 0.03745204f, 0.04297090f, -0.01909218f, -0.05092278f, 
    -0.02048670f, 0.03920642f, -0.05278783f, 0.03038220f, -0.00845290f, -0.04936488f, 0.01433669f, 0.01467786f, 
    -0.05429051f, -0.03409366f, 0.02758829f, -0.03309243f, 0.04078116f, -0.03462270f, -0.00196787f, 0.01127782f, 
    -0.01726324f, -0.04089633f, -0.01815998f, 0.02666601f, -0.03642470f, -0.02054322f, -0.02965581f, -0.02293537f, 
    -0.02177008f, 0.04239467f, -0.01168742f, 0.01640781f, -0.01873918f, 0.02184974f, -0.03900159f, -0.03537267f, 
    0.00102429f, -0.05334292f, 0.03983219f, 0.03242864f, -0.01624176f, -0.01127917f, -0.01702305f, 0.02150193f, 
    0.04418795f, -0.01207583f, 0.01343773f, -0.01470782f, -0.00970243f, -0.03188671f, -0.01331009f, -0.01153414f, 
    0.01528005f, 0.01653104f, 0.02344847f, 0.01018608f, 0.02499701f, 0.01171088f, -0.02908086f, 0.03788155f, 
    0.03726726f, 0.03682653f, 0.04055189f, 0.02613427f, -0.02387799f, 0.03158078f, -0.01830486f, -0.03975424f, 
    -0.03131180f, -0.01834117f, -0.01805451f, 0.00217414f, -0.04236543f, 0.00105542f, -0.03233264f, -0.01026755f, 
    -0.04488327f, 0.02660859f, 0.01314639f, 0.04574446f, -0.05101328f, -0.01057749f, 0.00425033f, -0.01505911f, 
    0.03830082f, 0.02833059f, 0.00502450f, 0.03283810f, 0.01866274f, -0.01595775f, -0.02362035f, -0.04283000f, 
    -0.03993718f, 0.01633757f, 0.04369598f, -0.03608907f, 0.03510574f, 0.01404529f, -0.01387744f, -0.01424434f, 
    -0.04342201f, -0.04827394f, -0.02836838f, 0.02417581f, 0.01439996f, -0.01471784f, -0.03374968f, -0.01653725f, 
    -0.02387659f, 0.02944509f, 0.01483714f, 0.04713962f, 0.03631062f, 0.03013465f, -0.02060271f, -0.04421785f, 
    -0.03117091f, 0.00636527f, 0.03558728f, 0.02352946f, 0.01269853f, 0.00943702f, 0.02799089f, 0.00551391f, 
    -0.18209331f, 0.08557820f, 0.07309495f, -0.09777252f, -0.00017075f, 0.02628212f, -0.01584044f, 0.03952941f, 
    0.10376285f, 0.05117327f, -0.07724151f, 0.12002347f, 0.44602802f, 0.48358721f, 0.06737112f, 0.05302140f, 
    -0.10838223f, 0.08070018f, 0.02652196f, -0.01051101f, 0.01488780f, -0.14828593f, 0.09407891f, -0.04801839f, 
    -0.45122728f, -0.28535348f, 0.20418546f, 0.05820668f, -0.19131832f, 0.02222406f, -0.11527615f, 0.00085331f, 
    0.03169261f, -0.11978014f, 0.10789833f, 0.15669227f, -0.14284468f, 0.11821293f, -0.08925430f, -0.07867753f, 
    -0.01989328f, -0.02200744f, 0.15702310f, -0.15237945f, -0.13153869f, -0.02165737f, 0.14146639f, -0.00605626f, 
    -0.07059368f, -0.27957383f, -0.01629941f, 0.18360808f, -0.11543897f, 0.17471354f, -0.02637874f, -0.06782655f, 
    0.02963868f, -0.19260736f, -0.05271306f, 0.08698103f, 0.52265131f, 0.02444590f, -0.33091521f, 0.12453854f, 
    0.17866153f, 0.13780896f, 0.00696286f, -0.05946992f, 0.08111879f, 0.00744190f, -0.04741692f, 0.10594422f, 
    0.13543952f, -0.17616764f, 0.17819805f, 0.22377749f, -0.09938339f, 0.07956631f, -0.08948230f, 0.03834401f, 
    -0.12142631f, -0.14276248f, -0.11282993f, -0.01722879f, 0.11670672f, 0.18157041f, 0.14285603f, 0.09642988f, 
    0.01098947f, 0.11577747f, 0.06337783f, 0.02591818f, 0.09356539f, 0.01181697f, -0.07075753f, -0.00581354f, 
    0.10304688f, -0.17857240f, -0.05823717f, -0.04084356f, 0.05953142f, 0.03624253f, 0.18142760f, 0.13620207f, 
    -0.03185382f, 0.01904338f, 0.10396864f, -0.02959934f, 0.01846367f, -0.23593998f, -0.07755868f, 0.06820842f, 
    -0.03723706f, 0.05473502f, 0.13658302f, -0.13030528f, 0.17514858f, 0.03975559f, -0.10852825f, -0.16192466f, 
    0.44298300f, 0.10529097f, -0.11443091f, -0.02202671f, 0.12373074f, 0.05603538f, 0.02910615f, -0.05087262f, 
    -0.11236221f, 0.02879713f, -0.10719556f, 0.07214287f, 0.22261217f, 0.03435884f, -0.07117903f, -0.21809590f, 
    0.10547019f, 0.06198482f, -0.02660582f, 0.17304677f, 0.02630842f, 0.06807368f, 0.05766075f, 0.08357233f, 
    -0.00593130f, -0.18391384f, 0.13962848f, 0.30974227f, -0.05863251f, -0.03090793f, -0.05777028f, -0.01686392f, 
    -0.03325821f, -0.13236260f, -0.09644113f, -0.09062324f, -0.41733381f, -0.23687084f, -0.11373609f, -0.22747464f, 
    0.08291921f, 0.15999418f, -0.03670116f, -0.04279123f, 0.12247804f, -0.07478216f, 0.16861136f, -0.06923435f, 
    0.28343871f, 0.10815889f, 0.00354466f, -0.14647739f, 0.10929695f, 0.12015212f, -0.06322148f, 0.01927158f, 
    -0.16536540f, -0.07219524f, 0.04964050f, 0.04403440f, -0.63207072f, 0.11466855f, -0.02801985f, -0.40414548f, 
    0.26707205f, -0.03021090f, 0.02416513f, -0.01821374f, 0.00514494f, -0.08479630f, -0.12444571f, 0.02528151f, 
    -0.11417591f, -0.07432695f, 0.07565039f, -0.07778864f, 0.15415598f, 0.03535036f, -0.01710164f, -0.03429982f, 
    0.05064158f, 0.01700510f, 0.02799189f, 0.03887318f, 0.17627110f, -0.13908570f, 0.18055275f, 0.48938516f, 
    -0.02207627f, -0.09061914f, 0.16385972f, 0.13636328f, -0.09980313f, 0.08723488f, 0.14552650f, 0.05491121f, 
    -0.14450873f, 0.21161710f, 0.37379745f, -0.13916861f, -0.14221291f, -0.12683025f, 0.24647506f, -0.17011420f, 
    0.12668456f, 0.18890777f, 0.08222176f, 0.08561722f, 0.48264888f, -0.13371854f, 0.08166996f, 0.23432237f, 
    0.00827006f, 0.10495976f, 0.04497661f, -0.13296832f, 0.27131996f, 0.18666260f, 0.07654524f, 0.07656127f, 
    -0.02305599f, -0.21861133f, -0.19718488f, -0.18071401f, -0.06305763f, 0.00471082f, -0.06622015f, 0.23195119f, 
    0.14223287f, 0.10016870f, 0.24276255f, -0.08407843f, -0.33165044f, 0.00240996f, -0.13045095f, -0.31376797f, 
    0.29518193f, 0.02648420f, 0.17426865f, 0.08812432f, 0.04087394f, -0.04960382f, -0.06359681f, -0.00072246f, 
    0.25845587f, -0.00148340f, 0.25175315f, -0.06774341f, -0.14879909f, 0.16116752f, 0.11569920f, 0.00971789f, 
    -0.06486206f, -0.01753693f, -0.04925757f, 0.01401037f, -0.04710943f, 0.09756782f, -0.01782696f, -0.27355510f, 
    0.15658435f, 0.01497422f, 0.03762285f, 0.05057103f, 0.18211763f, 0.05582008f, 0.12100999f, 0.14497627f, 
    -0.22585507f, 0.06772783f, -0.14090857f, -0.18371011f, 0.19327801f, 0.01383390f, 0.01334820f, -0.08221663f, 
    0.10996449f, 0.11180943f, 0.02866566f, -0.01977214f, -0.30983505f, 0.25525743f, -0.05182609f, -0.07881244f, 
    0.11714335f, -0.09468556f, 0.00334547f, 0.05175343f, 0.05476357f, -0.01731758f, 0.04968343f, 0.00065836f, 
    0.45973194f, 0.09546723f, 0.00956057f, -0.10924871f, -0.02667949f, -0.00677606f, 0.04613997f, -0.00114205f, 
    0.07447492f, 0.11004945f, 0.14845997f, 0.01927765f, -0.28498954f, -0.15879758f, -0.18111552f, 0.17427629f, 
    -0.03746000f, -0.17035298f, -0.04303867f, -0.07435581f, 0.02626636f, 0.08687936f, 0.02809969f, -0.00642509f, 
    0.24992801f, -0.35790396f, -0.05210917f, -0.03958235f, 0.04661899f, 0.04001384f, 0.03043028f, 0.02037107f, 
    -0.06176172f, -0.07786968f, -0.07221618f, -0.00975664f, -0.24429014f, 0.74655837f, 0.18778308f, 0.14648889f, 
    0.04372651f, -0.10562925f, 0.10682996f, -0.05471355f, 0.01975539f, -0.07354810f, 0.05912509f, 0.11756404f, 
    0.14454573f, 0.28141388f, 0.02394043f, -0.03303159f, 0.20226686f, -0.15777366f, 0.01531694f, 0.14126815f, 
    -0.04784060f, -0.01879260f, 0.04361332f, -0.04497136f, -0.30339083f, 0.08293416f, 0.15641108f, 0.25918093f, 
    0.15881492f, -0.11174411f, -0.07720095f, 0.13698997f, -0.13230538f, 0.13069913f, -0.09764297f, 0.15815689f, 
    0.02222774f, 0.02171507f, -0.04612851f, -0.04348499f, 0.01358939f, 0.03297350f, 0.00181733f, 0.05052170f, 
    -0.03215571f, 0.01103754f, -0.03572781f, -0.04344687f, -0.00267829f, 0.00870344f, 0.00662814f, 0.01079704f, 
    -0.00903607f, -0.03709548f, -0.03113987f, -0.02430844f, 0.02571599f, 0.03696539f, -0.05648638f, 0.01011000f, 
    -0.04469761f, -0.03632296f, -0.04773723f, -0.03711047f, -0.00331376f, 0.04431692f, -0.04191073f, -0.03206076f, 
    0.02571455f, -0.04509300f, 0.02941659f, 0.00212430f, -0.00442147f, -0.04544748f, -0.02802050f, -0.01181955f, 
    -0.02837571f, 0.04698977f, 0.03192999f, 0.03205591f, 0.01385198f, -0.01669586f, 0.02279246f, 0.01688457f, 
    -0.02172737f, -0.04172081f, 0.04320234f, -0.02085407f, -0.02136419f, -0.01989324f, -0.03090833f, -0.05125345f, 
    -0.02267428f, -0.02002453f, 0.03968421f, -0.04054829f, -0.02785068f, 0.03052478f, 0.03081694f, 0.00768359f, 
    0.03656462f, 0.02106419f, 0.01153541f, -0.01765455f, 0.04256848f, -0.03625744f, -0.03061823f, 0.00248399f, 
    -0.03104983f, 0.03460220f, 0.03375503f, 0.03261285f, -0.00202956f, 0.05107807f, 0.02705615f, 0.00728393f, 
    -0.02255258f, 0.00773541f, -0.01663632f, 0.02784173f, -0.00186123f, -0.02863714f, -0.03568234f, 0.03011568f, 
    -0.02792226f, 0.03917179f, 0.01650188f, 0.00387504f, 0.02403849f, 0.03532978f, 0.01992605f, 0.01262157f, 
    0.01407561f, -0.01834181f, 0.00847570f, 0.03279293f, -0.05130141f, -0.03606756f, 0.03755144f, -0.04741456f, 
    -0.05135512f, -0.01041794f, 0.02770020f, -0.05153922f, 0.03508821f, -0.03963222f, -0.02905120f, -0.03276534f, 
    -0.03247423f, 0.02227249f, -0.02993033f, 0.00107066f, 0.04644014f, -0.00746650f, -0.05101831f, 0.00420959f, 
    0.03068905f, 0.02699061f, 0.01733725f, 0.01534929f, 0.04175441f, 0.03583372f, 0.02260996f, 0.03947533f, 
    -0.03515504f, -0.04865083f, -0.02090779f, -0.02626840f, -0.00523905f, -0.03824945f, -0.00402072f, 0.03953495f, 
    -0.02413519f, -0.03871189f, -0.05111327f, -0.03708988f, -0.02798641f, -0.00110024f, -0.01282188f, -0.02128201f, 
    0.00072570f, -0.05166539f, -0.02700385f, 0.02866326f, -0.05482582f, -0.05202259f, -0.04565326f, 0.00491781f, 
    -0.01091036f, -0.05714903f, 0.03305161f, 0.00035033f, -0.04291112f, -0.00691647f, -0.02214718f, -0.02092247f, 
    0.03328579f, -0.02109706f, -0.02395238f, 0.01184112f, -0.03405651f, 0.01641690f, -0.05454273f, -0.00843433f, 
    -0.03501255f, -0.03118775f, 0.02340524f, -0.04106937f, 0.02039788f, 0.01626137f, -0.00652886f, 0.00950991f, 
    0.02897833f, -0.00352873f, -0.05849715f, -0.05453580f, 0.02872624f, -0.04032480f, -0.01781948f, 0.00304167f, 
    -0.04016554f, -0.04000146f, -0.01746999f, -0.05076550f, -0.04177332f, -0.00698827f, -0.03865391f, 0.03058270f, 
    -0.03223189f, -0.03015563f, 0.03962510f, -0.01225272f, -0.05354645f, -0.05527899f, 0.03432832f, -0.04295085f, 
    0.01361857f, 0.00910445f, 0.00893048f, -0.02460788f, -0.01434402f, -0.01812763f, -0.00884616f, 0.01101745f, 
    -0.05172199f, 0.04048495f, 0.01923895f, -0.03326694f, 0.01910652f, -0.00110751f, -0.03081257f, 0.02158699f, 
    0.01160306f, -0.03068192f, 0.02432179f, -0.01131109f, -0.04652360f, 0.00179483f, 0.04092845f, -0.05363749f, 
    -0.00579341f, -0.05171720f, 0.00159389f, -0.00409400f, 0.01025143f, -0.02867836f, 0.02467695f, 0.02115897f, 
    -0.02053946f, 0.02892899f, -0.01638615f, -0.03031443f, 0.03102701f, 0.02866199f, -0.02111096f, 0.03304743f, 
    -0.01674311f, -0.03997214f, -0.04579369f, -0.05765631f, -0.05889175f, -0.03448034f, -0.01918970f, 0.02914480f, 
    0.00508879f, 0.01078919f, -0.01447327f, -0.02438777f, 0.03637745f, -0.03141971f, -0.05107087f, 0.00472768f, 
    0.04108227f, 0.00194210f, -0.00328278f, -0.04146881f, 0.04047771f, -0.04271646f, 0.02624043f, 0.02281913f, 
    0.03862687f, 0.02753938f, -0.02826852f, 0.01039489f, 0.04153505f, 0.04206794f, -0.05192426f, -0.00931606f, 
    0.01292259f, -0.02207647f, -0.00358751f, -0.05534016f, 0.02120662f, 0.04471762f, -0.04687900f, 0.03286806f, 
    -0.03393276f, -0.04247288f, -0.02088165f, -0.05469897f, 0.01015143f, 0.00873069f, 0.03550792f, 0.01635141f, 
    -0.03063065f, -0.04951147f, -0.00709228f, 0.03548320f, -0.03606725f, 0.03702608f, 0.02171967f, -0.02877694f, 
    0.01896929f, -0.04792307f, -0.03373441f, 0.03345088f, 0.01380379f, -0.03264260f, 0.02243209f, -0.05420538f, 
    -0.01086021f, -0.00632675f, -0.03460309f, 0.04410973f, -0.06062482f, 0.01510143f, 0.02296682f, -0.04099878f, 
    0.00845419f, -0.03566211f, -0.01996404f, -0.03823170f, 0.02663009f, 0.03594248f, -0.01243535f, 0.04126026f, 
    -0.02713835f, 0.05255016f, 0.02923972f, 0.02244835f, -0.04852772f, 0.04325727f, 0.02074247f, 0.03812638f, 
    -0.02066279f, -0.04216293f, 0.03627160f, -0.00114874f, -0.05332810f, -0.01944236f, -0.00512617f, 0.02265404f, 
    0.04522696f, -0.02268149f, 0.02070135f, 0.00123468f, 0.00918236f, 0.00810885f, 0.02665540f, -0.04385220f, 
    -0.02387389f, 0.00086947f, -0.04836230f, -0.04534011f, 0.02543118f, 0.03234895f, 0.02434170f, -0.03241700f, 
    -0.02125500f, -0.03692150f, -0.02297692f, 0.01833421f, -0.00897559f, 0.02413737f, 0.01990785f, -0.01200994f, 
    0.00497691f, -0.01249125f, 0.01749195f, -0.00966182f, 0.03823804f, 0.00954738f, -0.04403573f, -0.02529593f, 
    -0.04551784f, 0.01605585f, -0.04389898f, -0.02823787f, -0.00820630f, -0.03184877f, 0.03601697f, -0.00068183f, 
    0.01721554f, 0.00440815f, -0.04145285f, -0.00711724f, -0.04213599f, -0.04622007f, 0.00741713f, -0.03242581f, 
    -0.05236997f, -0.03351577f, -0.04691950f, -0.03071625f, 0.00567627f, -0.04709637f, -0.03162516f, 0.02275568f, 
    -0.04947421f, -0.01552814f, -0.01222897f, 0.03487591f, 0.01163052f, 0.01179252f, -0.02954612f, 0.02657815f, 
    0.00243169f, 0.03810322f, 0.04250292f, -0.04569446f, -0.04128426f, 0.04205388f, -0.01977154f, 0.01193066f, 
    -0.04990840f, -0.01251513f, -0.04204717f, -0.02141864f, 0.04322191f, 0.00801480f, -0.01887350f, 0.03861530f, 
    0.03009897f, -0.04889242f, 0.02836978f, 0.01518740f, -0.01896366f, -0.04029537f, -0.04603852f, 0.02317601f, 
    0.04017874f, -0.02575823f, -0.02890776f, -0.02996087f, -0.05822812f, -0.04688998f, 0.00356810f, 0.00887128f, 
    -0.04432894f, 0.03523051f, 0.03620962f, 0.01045551f, -0.01491695f, -0.01672432f, -0.05613163f, 0.03924112f, 
    0.01094926f, 0.01503342f, -0.05505063f, 0.00638801f, 0.01035501f, -0.01383904f, -0.00501600f, -0.05800057f, 
    -0.04949848f, -0.04712404f, -0.03512943f, 0.01766283f, -0.04072232f, -0.04224382f, -0.03123406f, -0.02700794f, 
    0.03108089f, 0.00848814f, -0.05640058f, 0.02849932f, -0.03904242f, -0.02231648f, -0.00608143f, 0.01840276f, 
    0.01762326f, -0.00564010f, 0.02934762f, -0.04593525f, 0.03969629f, 0.03470067f, -0.04405642f, -0.04150775f, 
    -0.03670242f, -0.03953366f, -0.00646016f, -0.03646352f, 0.02902110f, -0.04071791f, -0.04004435f, -0.02032347f, 
    0.00592647f, 0.01026811f, 0.02111007f, -0.01530563f, -0.01643535f, -0.00143561f, 0.01461351f, -0.04371209f, 
    -0.02730847f, -0.04844505f, 0.04061872f, 0.02429026f, -0.00571276f, -0.02856478f, -0.02812218f, 0.00335170f, 
    0.00789812f, 0.00401988f, -0.05466098f, -0.02073627f, -0.01589255f, -0.03881492f, -0.04216111f, -0.04250526f, 
    -0.00169277f, -0.03450675f, 0.02658587f, -0.05001833f, -0.03746172f, -0.02692903f, -0.00776675f, 0.01987344f, 
    0.00208384f, 0.03441836f, -0.03540095f, 0.00161447f, 0.03918185f, -0.00175006f, -0.01194719f, 0.02778496f, 
    0.02178874f, 0.03413034f, 0.01877461f, -0.01175843f, 0.03758658f, 0.00194305f, 0.00791238f, -0.01242373f, 
    -0.02077513f, -0.01793011f, 0.04209355f, -0.04978004f, -0.03062092f, -0.04972860f, -0.04207989f, -0.01650352f, 
    -0.01959553f, -0.05406521f, -0.01264048f, -0.03210175f, -0.00591404f, 0.03741813f, 0.02369954f, 0.03464825f, 
    -0.02645573f, 0.00222506f, 0.02174984f, -0.01271938f, -0.02733624f, -0.00922688f, 0.03483185f, -0.00202622f, 
    0.03129831f, -0.04836957f, -0.03611900f, 0.01937194f, -0.01945330f, -0.02430606f, -0.04443100f, 0.01604349f, 
    -0.00228420f, 0.01591852f, 0.04034021f, -0.05450661f, 0.01092698f, 0.01863684f, -0.04418568f, -0.01411567f, 
    0.01765707f, -0.04903595f, 0.03876799f, -0.03143243f, 0.02124582f, -0.02931270f, -0.02565189f, -0.03976176f, 
    0.02746177f, 0.01518891f, 0.01207762f, -0.01566940f, -0.03409459f, -0.02626774f, -0.04514094f, -0.01963605f, 
    -0.00891346f, -0.04918317f, -0.04497058f, 0.01504636f, 0.04166406f, -0.01510395f, -0.03045932f, 0.03871272f, 
    -0.05678127f, -0.00811936f, 0.04305134f, -0.01301486f, 0.02530452f, -0.00773994f, -0.03034940f, 0.02538196f, 
    -0.01526297f, -0.01819605f, 0.03854183f, -0.04395591f, -0.00700458f, -0.02564591f, 0.02092302f, 0.04119612f, 
    0.01687889f, 0.03494705f, 0.01403133f, -0.01223442f, 0.02327092f, 0.02512084f, -0.01743631f, -0.01891593f, 
    0.03924384f, -0.02665820f, 0.01943893f, -0.00331093f, 0.01835012f, 0.02071201f, -0.04721768f, -0.01028290f, 
    0.03877460f, -0.04272705f, -0.00572422f, -0.04515128f, 0.02809355f, 0.03665796f, -0.01573043f, 0.01214276f, 
    -0.03187105f, -0.04075731f, 0.02027655f, 0.00323661f, -0.05703200f, -0.00478889f, -0.01948968f, 0.02129392f, 
    -0.04674080f, 0.03439610f, 0.03027357f, 0.04141358f, -0.02715450f, 0.01003024f, -0.03369247f, 0.02672650f, 
    0.02395941f, -0.00248571f, 0.03686609f, -0.05562729f, -0.02787955f, 0.00337355f, 0.02200625f, -0.05846446f, 
    -0.02825764f, 0.03849573f, 0.02349640f, 0.03188305f, -0.05089093f, -0.02170703f, -0.02375621f, 0.03768899f, 
    -0.04110827f, 0.03522830f, 0.02885452f, -0.05310595f, -0.04442729f, 0.01665648f, 0.03618252f, -0.04791411f, 
    -0.00848412f, 0.01998548f, 0.03908492f, 0.00749735f, 0.02653979f, -0.04775605f, 0.01183436f, -0.03496686f, 
    0.03682211f, 0.00210759f, 0.00113769f, -0.02269104f, -0.05265026f, -0.01218385f, -0.02851808f, -0.00045478f, 
    -0.02492157f, -0.03283205f, 0.01782448f, 0.00160639f, -0.00882451f, 0.02108083f, 0.03934632f, -0.00560783f, 
    -0.03161624f, -0.05083339f, -0.03352389f, 0.02149856f, 0.02768966f, -0.00576029f, -0.03730988f, -0.02670983f, 
    -0.01867686f, -0.03643753f, -0.05615326f, -0.02080786f, -0.05309831f, -0.04570827f, -0.05813956f, -0.03684754f, 
    -0.00046661f, 0.02573896f, -0.00066341f, -0.04802544f, 0.03943145f, 0.02323848f, -0.04423440f, -0.04781029f, 
    -0.01933846f, -0.02352305f, -0.00554396f, 0.02162822f, -0.04009814f, -0.05602399f, 0.00675266f, -0.05639549f, 
    0.02656516f, -0.03864205f, -0.02563662f, 0.01336232f, 0.03528146f, -0.04668793f, 0.03084666f, -0.03097316f, 
    0.02888573f, 0.02552311f, 0.02085666f, -0.01206679f, -0.01056125f, 0.02015815f, -0.04162514f, 0.01814164f, 
    0.02396697f, 0.02202178f, 0.01346439f, -0.03180521f, -0.00441699f, -0.04541591f, -0.04496937f, -0.01568813f, 
    -0.01552983f, -0.04733377f, -0.00058207f, -0.01120037f, -0.05814189f, -0.03941157f, -0.04987698f, 0.03897019f, 
    -0.00031114f, -0.00698141f, -0.05115001f, -0.01482524f, 0.02293804f, 0.01769662f, 0.02073371f, 0.02979256f, 
    -0.04555546f, 0.04364478f, -0.02109323f, -0.02391356f, -0.00516112f, 0.03620236f, -0.04414869f, -0.03906483f, 
    0.02828271f, -0.02984272f, -0.01469143f, -0.00584444f, -0.00868063f, 0.00400796f, 0.03194470f, -0.04012171f, 
    -0.02872861f, 0.04145668f, -0.00444156f, 0.00227701f, -0.03571863f, 0.00673139f, 0.00645353f, 0.00090634f, 
    0.04057028f, -0.03628726f, -0.03854039f, -0.02098024f, -0.04084623f, -0.00074431f, 0.02794451f, 0.00763019f, 
    0.01811606f, -0.01016027f, -0.03131941f, 0.02224706f, -0.04258690f, -0.05565820f, -0.00264906f, 0.02810406f, 
    0.04264297f, -0.01634009f, -0.03529104f, -0.05125514f, -0.03443865f, -0.03572812f, -0.04905937f, -0.02553985f, 
    -0.00248191f, -0.03007867f, -0.00706897f, -0.04312280f, -0.02440122f, -0.00011139f, 0.04444062f, -0.01530613f, 
    -0.04008196f, -0.02729316f, -0.01210536f, 0.03038742f, -0.03995181f, -0.02099735f, 0.01174544f, 0.02924275f, 
    -0.00505879f, -0.03990112f, 0.03849480f, -0.00636492f, 0.03994295f, 0.02892921f, 0.00369046f, 0.00008989f, 
    0.00007644f, -0.05206227f, 0.00666463f, 0.04039672f, -0.02732146f, -0.00253372f, 0.03630221f, -0.05156536f, 
    0.02503741f, 0.02066313f, 0.01459585f, 0.02295360f, 0.01222075f, 0.04534291f, -0.01945417f, -0.04039524f, 
    0.04069366f, -0.02876768f, -0.03901832f, -0.00246400f, -0.04654329f, -0.05611962f, 0.03681403f, -0.01693886f, 
    0.03238488f, -0.04797839f, -0.02715217f, -0.01237040f, 0.04205386f, -0.02164209f, -0.02047216f, 0.01760568f, 
    0.01631450f, -0.01312180f, 0.04421449f, -0.02671465f, -0.03382016f, 0.03696816f, 0.00508292f, -0.00829856f, 
    0.04158472f, 0.00041870f, 0.03921702f, -0.05467857f, 0.03929842f, 0.02285500f, 0.00626111f, 0.02132460f, 
    -0.02855436f, 0.03093775f, 0.02174728f, 0.01472453f, 0.02759263f, -0.03485580f, -0.05134146f, 0.00798491f, 
    -0.01352248f, -0.03191492f, -0.05500884f, -0.01527926f, -0.00691819f, -0.05266625f, 0.00744614f, -0.03907363f, 
    0.02979954f, -0.03221240f, 0.00298992f, 0.01689321f, 0.00421757f, -0.01385318f, 0.04573575f, 0.00616256f, 
    -0.04786254f, -0.02987641f, 0.03621113f, -0.04976820f, -0.00428480f, -0.02594313f, 0.00276767f, 0.01734186f, 
    0.03663372f, 0.05190971f, 0.03479978f, -0.04160029f, -0.04382567f, -0.04219142f, -0.03452333f, 0.00872007f, 
    -0.00714669f, -0.01380658f, 0.02332422f, -0.00566850f, 0.02534699f, -0.05492162f, -0.00527625f, -0.02057261f, 
    0.03935273f, -0.00653312f, -0.05047018f, 0.03287492f, -0.02691611f, -0.01813696f, -0.05197578f, -0.03857002f, 
    -0.03487078f, 0.02488406f, 0.01269503f, 0.01529062f, 0.03361395f, 0.01009800f, -0.00064316f, -0.04378024f, 
    -0.00928881f, -0.04989658f, -0.00521645f, 0.03609157f, -0.03769525f, -0.04947501f, 0.03400971f, 0.04509722f, 
    -0.04492994f, -0.03319202f, 0.02819141f, 0.02212673f, 0.00120114f, 0.02760568f, 0.00817143f, -0.01523022f, 
    -0.02290443f, 0.00360891f, 0.04442486f, -0.01617223f, 0.01126985f, -0.03110925f, 0.04866590f, 0.01236170f, 
    0.04339188f, 0.03543339f, -0.05415330f, 0.04133936f, 0.04355755f, -0.01671072f, 0.02314305f, -0.05339697f, 
    -0.00136831f, -0.00656852f, -0.05425848f, 0.02739775f, -0.03812613f, -0.00362196f, 0.05541517f, -0.04326829f, 
    -0.04503823f, -0.05596635f, 0.01594116f, -0.02353803f, 0.00984010f, -0.00724965f, -0.04735959f, 0.00758393f, 
    0.00352010f, -0.02857014f, -0.05387482f, -0.02251864f, 0.01913113f, -0.02981286f, 0.02557842f, 0.00788390f, 
    -0.02956587f, 0.02310407f, -0.03720572f, 0.02795891f, -0.03306236f, 0.04580385f, -0.04398708f, -0.04587812f, 
    0.04952841f, 0.03969136f, -0.03060660f, -0.02675085f, 0.00976260f, -0.03035179f, 0.02471203f, -0.04404858f, 
    0.02025140f, -0.03757093f, 0.00735362f, 0.03818049f, -0.02151756f, 0.02000351f, -0.00612465f, -0.03923832f, 
    -0.00439977f, 0.03019431f, -0.05050348f, -0.01648833f, -0.00485017f, -0.01931286f, 0.01016996f, -0.05286031f, 
    0.00592248f, -0.04808147f, -0.04268391f, -0.00168334f, 0.02607677f, 0.01220128f, -0.03673364f, 0.05436212f, 
    -0.02346286f, -0.05354851f, 0.01442384f, -0.04093542f, 0.03327724f, 0.01926526f, -0.01281461f, -0.03620858f, 
    -0.00365214f, 0.02823387f, -0.04274760f, -0.02632894f, 0.03731957f, 0.04139487f, 0.01949603f, -0.00237401f, 
    -0.01925205f, 0.01686723f, 0.03714104f, 0.00562460f, -0.03602454f, -0.01737459f, -0.01994873f, -0.00720625f, 
    -0.02055013f, -0.03822650f, -0.04037013f, -0.04285145f, 0.01216354f, -0.02255533f, 0.01769941f, -0.05580434f, 
    -0.02694637f, -0.00604575f, 0.00320006f, 0.01676947f, -0.05268272f, -0.05565708f, -0.03186690f, -0.03998048f, 
    0.04104693f, -0.04801481f, -0.00227382f, -0.00315833f, -0.00311346f, 0.04214735f, -0.04433122f, 0.03719135f, 
    -0.05376474f, 0.04019585f, -0.04104696f, 0.02389169f, 0.01574557f, 0.00097742f, 0.01839039f, -0.03658115f, 
    -0.04567654f, -0.00903043f, 0.01712390f, -0.01559966f, 0.02810521f, -0.00842075f, 0.00741298f, 0.00295056f, 
    0.03229970f, 0.02728721f, -0.04007046f, -0.03915462f, 0.01399621f, 0.04153579f, -0.00639527f, -0.05285135f, 
    -0.05568776f, -0.02518717f, 0.01037622f, -0.00074208f, -0.03555835f, 0.05086456f, -0.01983728f, -0.04515124f, 
    0.01813453f, 0.03026159f, 0.00263318f, 0.01162976f, -0.03454902f, -0.02387467f, 0.02964541f, -0.00237693f, 
    0.02627087f, -0.02731674f, 0.00086694f, 0.02249208f, -0.03644312f, 0.02423836f, -0.05012975f, -0.01455136f, 
    0.01890950f, -0.05296839f, -0.02674933f, -0.00759065f, 0.03184880f, -0.01806273f, -0.00402371f, -0.03446444f, 
    0.01177572f, 0.00534461f, 0.00720695f, 0.03711585f, -0.03248598f, 0.01243508f, 0.04388555f, -0.02528482f, 
    0.04522802f, 0.03571014f, 0.01227132f, -0.01186352f, -0.00917248f, 0.03280406f, -0.02924102f, 0.00882077f, 
    -0.04544996f, 0.03023569f, 0.04056989f, -0.04663707f, 0.03920796f, -0.01497174f, 0.00075012f, 0.04598844f, 
    0.04028156f, -0.03012898f, -0.02274818f, 0.01202138f, -0.04931752f, -0.05574645f, 0.02435763f, 0.03548170f, 
    -0.01762496f, -0.05238553f, 0.02153141f, -0.02709244f, -0.00505405f, -0.02744856f, -0.02234543f, 0.00915665f, 
    -0.02377290f, -0.03978935f, 0.02695936f, -0.03939504f, -0.02696129f, -0.01717221f, 0.02123546f, 0.01633605f, 
    -0.01412905f, -0.05800585f, 0.01491151f, 0.01109615f, -0.04705066f, -0.02677734f, 0.02756550f, 0.00558904f, 
    0.01795783f, 0.03342117f, 0.02132152f, 0.02850085f, -0.03156615f, 0.02735182f, -0.01589690f, -0.00891731f, 
    -0.01527264f, 0.03588798f, 0.02385699f, -0.01923387f, 0.02109853f, 0.03256034f, -0.04628985f, 0.02302106f, 
    0.02383172f, -0.02303736f, -0.00359319f, -0.02591807f, 0.03650314f, -0.02319106f, -0.04432438f, 0.03883762f, 
    -0.02763149f, -0.05807347f, -0.01584140f, 0.00838366f, -0.03712659f, 0.02644916f, -0.01158007f, -0.03101713f, 
    0.02093410f, -0.03587443f, 0.01168038f, 0.04196443f, 0.01840689f, -0.05733188f, 0.01780543f, -0.04511085f, 
    -0.02348605f, -0.00509824f, -0.02443205f, 0.02301185f, 0.02643946f, -0.04649973f, 0.02749198f, -0.03147803f, 
    0.00145169f, 0.02004373f, 0.01047330f, -0.01129864f, -0.01222318f, -0.00854014f, -0.01531572f, 0.03554998f, 
    -0.05047663f, -0.05487531f, -0.04765226f, -0.05508903f, -0.02173026f, -0.00942979f, 0.01405634f, 0.01803704f, 
    0.02903826f, -0.00672480f, -0.04317071f, -0.02389667f, 0.02867552f, 0.01867629f, 0.02304491f, -0.04866236f, 
    -0.00274849f, -0.05595058f, -0.01370214f, 0.02218233f, -0.05126625f, 0.00173444f, 0.02797915f, -0.01028197f, 
    0.03840916f, 0.02636886f, -0.04352273f, -0.04228486f, -0.01988512f, -0.05397582f, 0.00627098f, -0.01550118f, 
    0.03328599f, 0.02562885f, -0.02309990f, -0.00437223f, -0.02884554f, 0.01326276f, -0.01539651f, 0.01453278f, 
    -0.02073991f, -0.01384650f, 0.03703450f, -0.01741206f, 0.00777100f, 0.03040465f, 0.00870725f, -0.03298031f, 
    -0.03185248f, -0.02977367f, -0.02435717f, -0.04537793f, -0.05614581f, 0.01687737f, 0.04128192f, 0.01571027f, 
    0.03100616f, 0.00050373f, 0.02151467f, -0.04836678f, -0.02818466f, -0.01410436f, -0.01162645f, -0.02616045f, 
    0.01889532f, 0.01187730f, 0.01701879f, 0.00548864f, -0.04940901f, -0.00164783f, -0.05466171f, -0.05160736f, 
    -0.03855450f, -0.04094505f, -0.00630711f, -0.03769397f, 0.01206709f, -0.02803021f, -0.01496893f, 0.01870520f, 
    -0.02333490f, 0.01921024f, 0.03343732f, -0.01003604f, 0.02308298f, 0.03247808f, -0.03523788f, 0.02900097f, 
    0.00801619f, -0.05401454f, -0.00755101f, -0.04655415f, -0.02562363f, 0.03372874f, 0.01990789f, 0.01235741f, 
    -0.03408447f, 0.01507575f, -0.02292359f, 0.01949984f, 0.01971072f, 0.04311014f, 0.03126470f, 0.00255176f, 
    0.03115843f, 0.02439514f, 0.03945507f, 0.01110336f, 0.02778594f, -0.02416253f, -0.05135736f, 0.04818559f, 
    -0.02607857f, 0.02963725f, -0.00504393f, 0.01581923f, 0.02953609f, -0.00807908f, -0.04354715f, -0.05471659f, 
    0.00686423f, -0.00326267f, -0.04930973f, -0.00737342f, -0.02682833f, 0.02277922f, -0.01448099f, -0.04984736f, 
    -0.00756716f, -0.00965099f, 0.04337500f, 0.03133781f, -0.02759050f, 0.00147620f, 0.01047809f, -0.04389369f, 
    -0.02632729f, 0.04112010f, 0.00462466f, 0.03219152f, 0.01576898f, 0.01460268f, 0.01782541f, -0.04721364f, 
    -0.04552212f, -0.04858552f, 0.02776674f, 0.03714005f, 0.00695183f, -0.00516420f, 0.00244296f, 0.01894489f, 
    0.04290040f, -0.02078674f, 0.02758788f, -0.04086368f, 0.00128692f, -0.04516813f, -0.04997252f, -0.01599943f, 
    -0.03734933f, 0.03232635f, 0.01319022f, -0.05273591f, -0.03822666f, -0.02501434f, -0.00831726f, 0.03713031f, 
    0.04625959f, -0.02188173f, -0.02180516f, 0.02618400f, -0.03211452f, -0.04468360f, -0.02360098f, 0.00094298f, 
    0.00434941f, -0.01652437f, 0.01206562f, -0.04187898f, -0.00399363f, -0.01403211f, 0.01005005f, -0.01594443f, 
    -0.05717054f, 0.01182286f, -0.04115953f, -0.00522115f, 0.04205158f, 0.01055351f, 0.01181170f, -0.01942450f, 
    -0.02634692f, 0.00292978f, 0.00727296f, 0.00699615f, 0.02151404f, 0.02018675f, 0.02812240f, 0.02642713f, 
    -0.05622308f, -0.01932712f, -0.04397592f, -0.04620920f, 0.02979112f, 0.02288051f, -0.04057114f, 0.02961115f, 
    -0.04783747f, 0.01413775f, 0.03872490f, -0.02503420f, -0.00181865f, -0.03146350f, -0.02263192f, 0.02393776f, 
    -0.04824670f, -0.04682613f, -0.05758575f, 0.01769645f, -0.04822369f, -0.03862928f, -0.03930984f, -0.01287601f, 
    0.04146649f, -0.02812968f, -0.00837166f, 0.00759183f, 0.00103016f, -0.05341109f, -0.00488711f, 0.00690535f, 
    0.00518737f, -0.00802663f, -0.04575494f, -0.05641866f, -0.02218338f, 0.01761961f, -0.02441602f, 0.04137387f, 
    -0.04602182f, 0.01823268f, 0.03343000f, -0.00941729f, -0.03349378f, -0.02794797f, -0.00379940f, -0.02363341f, 
    0.00070535f, 0.00218419f, 0.02488401f, -0.02109592f, -0.05490744f, 0.02666967f, 0.01526828f, -0.00058895f, 
    0.02474523f, -0.04790394f, 0.00191372f, 0.02393717f, -0.04848966f, -0.01707592f, 0.01318050f, 0.04145868f, 
    -0.01953722f, -0.04596706f, -0.01602493f, -0.00001313f, 0.02286022f, -0.05614221f, -0.05278710f, -0.03796617f, 
    0.48245940f, -0.29635280f, 0.13286899f, -0.05449757f, 0.00470221f, 0.10687326f, -0.02489279f, 0.10459486f, 
    0.15551013f, -0.01563292f, -0.00564520f, 0.00733535f, -0.20168337f, 0.01098637f, -0.03998635f, 0.54942465f, 
    0.12432280f, -0.00579042f, 0.02965123f, 0.05771352f, 0.14184235f, 0.00688440f, -0.04248860f, -0.02956193f, 
    0.27686748f, -0.03338147f, 0.04233466f, 0.26027972f, 0.12781526f, 0.10598357f, 0.01738594f, -0.01410816f, 
    -0.10849290f, 0.04949448f, 0.08408789f, 0.08611663f, 0.18436676f, 0.12026493f, -0.00028923f, 0.09974966f, 
    -0.01318895f, -0.01986518f, 0.25455961f, -0.03257736f, 0.20265277f, -0.06011682f, -0.05558809f, -0.08030025f, 
    -0.05710978f, 0.22217545f, -0.02568754f, 0.24904281f, 0.05829424f, 0.14401035f, -0.11822198f, -0.12584078f, 
    -0.11618481f, 0.02864351f, 0.06079567f, 0.02701645f, -0.28291783f, 0.08641867f, -0.26975667f, -0.28970808f, 
    0.11476141f, -0.03043879f, -0.00046391f, 0.02380018f, 0.06739417f, 0.00566150f, 0.13265316f, 0.03675117f, 
    0.31880450f, 0.03979859f, 0.03025880f, 0.28882891f, 0.10456041f, 0.02231389f, 0.16478731f, 0.13578677f, 
    0.16774032f, 0.09741113f, -0.17817618f, -0.04261125f, -0.38900480f, 0.08500995f, -0.09127395f, 0.20458286f, 
    -0.08077652f, 0.00304060f, 0.07832891f, 0.01646096f, 0.29776183f, 0.07872200f, -0.01620217f, -0.17911319f, 
    0.11314696f, 0.01091334f, 0.03586518f, 0.15080389f, 0.21131551f, 0.03298065f, 0.14282432f, -0.02385787f, 
    -0.02364257f, 0.15363280f, 0.04064792f, -0.01721586f, -0.01666499f, 0.20484950f, 0.02202059f, 0.10143636f, 
    -0.03064423f, 0.04625600f, 0.10984055f, -0.05874686f, 0.09708472f, 0.09615049f, 0.02413507f, 0.04827883f, 
    -0.26932472f, 0.23128723f, -0.10407523f, -0.19172503f, 0.18023157f, -0.03518024f, -0.04128479f, 0.02868375f, 
    0.06148208f, -0.15684840f, 0.09640231f, 0.14053293f, -0.09009457f, 0.09236554f, -0.13377357f, -0.36962092f, 
    0.20385805f, 0.17476417f, -0.00963762f, -0.02646629f, 0.00387927f, 0.04960682f, 0.03153642f, -0.04234598f, 
    0.39433047f, -0.00396151f, 0.07024729f, 0.43644181f, 0.11661456f, 0.04238888f, -0.04046910f, 0.01354728f, 
    0.01804150f, -0.07884826f, -0.06116853f, -0.00093184f, 0.24910201f, 0.18945630f, 0.00542999f, 0.09213634f, 
    -0.07925695f, 0.05876195f, 0.11182705f, 0.00710751f, 0.14194556f, -0.08071494f, 0.07855269f, 0.02185165f, 
    -0.19452371f, 0.20083867f, 0.09124399f, -0.24138178f, 0.09611972f, -0.02384119f, -0.00396435f, 0.01934967f, 
    0.03538633f, -0.11049619f, 0.12966725f, -0.09956896f, -0.38163471f, -0.06620456f, -0.06992977f, -0.35686994f, 
    0.07672437f, -0.08709181f, 0.09248202f, -0.12349026f, -0.02964305f, -0.07158919f, 0.00559341f, 0.01655130f, 
    0.09844717f, -0.14815260f, -0.01742221f, -0.22894777f, 0.13547422f, 0.07570056f, -0.06057819f, -0.01605703f, 
    0.07184320f, -0.01089257f, -0.04204327f, 0.06535275f, 0.47346631f, 0.36805597f, 0.12500079f, 0.54986483f, 
    0.15863201f, -0.03190458f, 0.02150851f, 0.09970040f, -0.01866247f, 0.11275254f, 0.11508577f, 0.06678863f, 
    -0.19695288f, 0.34048921f, 0.23419762f, 0.15161559f, -0.04765565f, -0.09359210f, 0.32736921f, 0.05574013f, 
    0.05624197f, -0.12699762f, 0.12610623f, 0.06285100f, -0.17083451f, -0.21613151f, -0.00669237f, 0.43938500f, 
    0.08779338f, 0.13159591f, -0.06073792f, 0.04193903f, 0.10099711f, 0.04054636f, 0.18311481f, 0.00618333f, 
    0.21993624f, 0.23809496f, -0.12600516f, 0.22216637f, 0.14211762f, 0.08862405f, 0.03655032f, 0.13697645f, 
    0.00775372f, 0.03815421f, 0.18515715f, -0.06489161f, -0.58405429f, -0.04919239f, -0.08637846f, -0.51920462f, 
    0.03876749f, 0.02973991f, 0.15441960f, -0.07897440f, 0.08522382f, -0.08113284f, -0.00403281f, -0.14766020f, 
    -0.23702203f, 0.00351539f, 0.08715920f, 0.23862891f, 0.05529404f, 0.01136648f, 0.09185239f, 0.31536105f, 
    -0.13671428f, 0.01506829f, 0.11383222f, 0.11591006f, 0.54633743f, 0.35822991f, 0.19904937f, -0.30092844f, 
    0.13526459f, -0.02796508f, 0.05502612f, 0.12736520f, 0.17846449f, 0.12704316f, -0.04242419f, 0.01140380f, 
    -0.66948843f, -0.06345074f, -0.06099340f, -0.17140432f, -0.02218601f, 0.01153672f, 0.06492266f, -0.09101479f, 
    0.10073893f, 0.13200249f, -0.01360474f, 0.05552112f, 0.07157113f, -0.00335995f, 0.16391619f, -0.28098515f, 
    -0.08088008f, -0.09885413f, 0.04575370f, 0.10236967f, 0.03610996f, 0.05858970f, 0.17284434f, 0.10797794f, 
    -0.10212364f, -0.04816159f, -0.13626157f, -0.09192910f, 0.18854432f, 0.19519916f, 0.03659601f, 0.01540248f, 
    -0.09975376f, 0.05098639f, 0.07765672f, 0.00469526f, 0.25650379f, 0.25410047f, -0.14391585f, 0.02348946f, 
    0.10701872f, 0.03913188f, -0.14545068f, -0.07214771f, 0.04323451f, 0.00575736f, -0.09751216f, 0.03167794f, 
    -0.15095338f, 0.07179684f, -0.07784010f, 0.02263225f, -0.01338369f, 0.04939394f, -0.04886018f, -0.02569531f, 
    -0.05334713f, 0.04995757f, 0.09217723f, 0.13919069f, -0.27615663f, 0.42537132f, 0.00384906f, 0.30911896f, 
    -0.02141629f, 0.26245907f, 0.05788797f, -0.02470415f, 0.15814471f, -0.11902350f, -0.01742486f, 0.02127800f, 
    0.31347474f, 0.13566865f, 0.19754903f, -0.01805586f, -0.01003173f, 0.06071658f, 0.02115802f, 0.07496957f, 
    -0.00961951f, 0.01200616f, 0.23640087f, -0.04440742f, -0.03688046f, 0.21218279f, 0.16148978f, 0.42400429f, 
    -0.00902018f, 0.15208247f, -0.12492881f, -0.05611831f, 0.04732170f, 0.06266195f, -0.08891179f, 0.00236728f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04391756f, -0.07823916f, -0.03244410f, -0.01889792f, 0.08572601f, 0.00842971f, -0.05818040f, 0.04617016f, 
    -0.09375106f, 0.01023968f, 0.11783382f, -0.00114928f, 0.02193826f, -0.04820937f, 0.04435560f, 0.25900280f, 
    -0.00633951f, 0.02597510f, 0.00463947f, 0.03655107f, 0.02301712f, -0.06784957f, 0.03123721f, 0.01709210f, 
    0.00159254f, -0.05327188f, 0.09346105f, 0.01023292f, 0.01054018f, 0.00099837f, -0.01020479f, 0.10776436f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04830653f, -0.09307040f, -0.02713600f, 0.00013054f, 0.13456802f, 0.12312432f, -0.09593222f, 0.37629294f, 
    0.01872089f, -0.02311444f, -0.17153110f, 0.00118047f, -0.03780322f, -0.12908234f, -0.07474789f, -0.50514507f, 
    0.02860153f, -0.11781458f, 0.52463961f, -0.01653897f, -0.05097027f, 0.50291693f, 0.24292995f, -0.09936967f, 
    -0.13798469f, -0.01607517f, -0.10649884f, 0.06266619f, -0.08877426f, -0.01793197f, 0.05990241f, -0.47407180f, 
    0.01305394f, -0.01941456f, 0.01561829f, -0.09523385f, 0.32420662f, 0.10883372f, -0.04593174f, 0.29338077f, 
    -0.13479668f, -0.03216860f, 0.26263359f, 0.13665639f, -0.07639972f, -0.00845288f, -0.11348484f, 0.18694003f, 
    0.07777867f, -0.13571422f, 0.00720475f, 0.18215233f, 0.09626799f, -1.05320215f, 0.17293528f, 0.16675660f, 
    0.20922205f, -0.07733531f, -0.43273380f, -0.13924491f, 0.04859251f, 0.16155611f, -0.08783078f, -0.51112485f, 
    0.10739955f, -0.02196886f, 0.05661837f, 0.02074003f, 0.40282390f, -0.05763007f, -0.16398288f, 0.23451835f, 
    0.28059536f, -0.14389850f, 0.12571934f, -0.06101094f, -0.17359944f, -0.07609334f, -0.41112635f, -0.10605911f, 
    -0.13081044f, -0.07000700f, -0.24317607f, -0.61607754f, 0.14601590f, 0.33984023f, -0.62273335f, -0.15430531f, 
    0.30042693f, -0.13547036f, 0.08293606f, -0.05290075f, -0.14566149f, 0.11018049f, -0.08974126f, -0.16967613f, 
    0.01294473f, 0.18556099f, -0.04405332f, 0.06302435f, -0.80038792f, 0.05721787f, 0.02848828f, 0.25849104f, 
    -0.86282414f, 0.12372141f, 0.06970689f, -0.16217327f, 0.03824122f, 0.12159426f, 0.26091766f, -0.08074449f, 
    0.14657225f, -0.00043332f, 0.15258616f, -0.14793950f, -0.15951708f, 0.35749003f, -0.24716362f, 0.15718675f, 
    0.30366367f, 0.08138053f, -0.10715663f, -0.16959049f, 0.01203620f, 0.09640471f, 0.06894641f, 0.03435478f, 
    0.07244277f, 0.00666737f, -0.06911071f, -0.05825754f, -0.11108100f, 0.00520932f, 0.02475510f, -0.28555134f, 
    0.11526865f, 0.10683864f, 0.16231073f, -0.13549188f, -0.00398121f, -0.15548910f, 0.13936147f, -0.18059450f, 
    -0.07574353f, -0.04412371f, -0.77054906f, 0.14885734f, -0.13999610f, 0.56101519f, 0.44609976f, -0.01160881f, 
    0.16239062f, 0.14353836f, -0.24085793f, 0.06439635f, -0.04522127f, -0.00910607f, -0.14027548f, -0.15140580f, 
    0.14616974f, -0.00056643f, -0.08338903f, 0.04480990f, -0.59906739f, 0.00386696f, 0.11891895f, 0.11895923f, 
    0.06400795f, -0.15127808f, 0.21480031f, -0.02840518f, 0.09952237f, -0.03727616f, -0.44810671f, 0.07235504f, 
    -0.09892851f, -0.15022755f, 0.16567180f, 0.21492302f, -0.11297906f, -0.26984838f, 0.24446769f, -0.19437262f, 
    -0.51923400f, 0.08775215f, 0.48103997f, 0.04836075f, -0.05082072f, 0.06818843f, -0.17037448f, -0.05410670f, 
    0.12234363f, 0.37233692f, -0.14635116f, -0.15897948f, 0.18104841f, 0.14064409f, -0.17246643f, -0.02186386f, 
    0.30535796f, 0.08364656f, -0.03348925f, 0.08348731f, 0.04649904f, 0.08989817f, 0.06806716f, 0.00162474f, 
    0.14060223f, 0.15508088f, -0.43538913f, 0.23687050f, 0.16595188f, 0.16701993f, -0.56172693f, -0.06048649f, 
    -0.83367211f, -0.07898296f, -0.08991247f, -0.09810611f, 0.05980116f, -0.06275195f, 0.11041056f, 0.21121864f, 
    -0.04373813f, -0.43252248f, -0.01519702f, -0.15232618f, -0.03380611f, -0.07342509f, 0.08574846f, -0.70920748f, 
    0.18924633f, 0.15872490f, -0.51078105f, -0.15747096f, 0.06438576f, 0.11081102f, 0.25781456f, -0.24104099f, 
    0.03453552f, 0.02183685f, -0.14176881f, -0.29182342f, -0.08769177f, 0.10977832f, 0.11308178f, 0.05626949f, 
    0.21439056f, -0.02573945f, -0.45985031f, 0.14074494f, -0.02073223f, -0.17427307f, -0.14257334f, 0.41416284f, 
    -0.03362579f, 0.36235902f, -0.15789813f, 0.08402550f, -0.10235634f, 0.14560823f, 0.04882780f, -0.70647639f, 
    0.13710064f, -0.16252269f, 0.30094776f, -0.09679447f, 0.08047733f, -0.04603290f, -0.63616800f, 0.06590773f, 
    0.13250767f, -0.01647492f, 0.45808038f, -0.05506020f, -0.01968723f, -0.19137189f, -0.18977074f, -0.01563088f, 
    0.32347348f, 0.11332038f, -0.12770674f, 0.04116510f, -0.06291237f, 0.17041139f, -0.05278847f, -0.28245094f, 
    -0.05085355f, 0.09962831f, -0.01721802f, -0.03761507f, 0.39192694f, 0.09128928f, -0.15876789f, -0.04712619f, 
    0.22239622f, -0.03895715f, -0.84069306f, -0.00835248f, -0.03508491f, -0.15478435f, -0.07560184f, -0.14741299f, 
    0.12257959f, -0.05156546f, -0.67432588f, -0.38938078f, 0.03248797f, -0.23409946f, 0.23821053f, 0.10142724f, 
    -0.13480523f, -0.08800316f, 0.46648529f, 0.17360595f, -0.02193535f, 0.00921683f, -0.16260757f, 0.19993339f, 
    0.06365493f, -0.70305037f, -0.11557215f, 0.05616997f, 0.07349479f, -0.04238180f, -0.09747573f, 0.01156597f, 
    -0.24730760f, 0.06674246f, 0.38255388f, 0.07957778f, 0.04107027f, 0.06849580f, 0.12860647f, 0.53075510f, 
    -0.12779270f, -0.09630347f, -0.08034386f, -0.73650348f, -0.05444934f, -0.41327757f, -0.32126012f, 0.13655612f, 
    -0.11671071f, -0.04661893f, -0.31145823f, -0.06303480f, -0.09069958f, 0.07569505f, -0.07372531f, 0.36998564f, 
    0.14243567f, -0.43698117f, -0.07080984f, -0.05031718f, 0.34488550f, 0.02336048f, 0.03295644f, -0.33874285f, 
    -0.61958116f, 0.12653710f, 0.14138719f, -0.00557320f, 0.13331954f, -0.00516681f, 0.14650588f, -0.05721099f, 
    -0.14611417f, 0.06507982f, -0.05943536f, 0.42672479f, 0.13620180f, -0.18304123f, -0.26807991f, 0.03626006f, 
    0.07071768f, 0.09904014f, 0.61590177f, 0.03057453f, -0.14532894f, -0.00787080f, -0.01263845f, 0.02487957f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.25289705f, 0.09874976f, -0.11598893f, -0.01715087f, -0.07945561f, 0.11667324f, -0.07030828f, -0.05589416f, 
    -0.19127725f, -0.04157860f, 0.07729581f, -0.09307811f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
