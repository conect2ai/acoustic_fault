#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.37280950f, -0.87950414f, -0.52798039f, 0.10764320f, 0.63625294f, 0.14751308f, 0.59755534f, 0.08494902f, 
    0.33981395f, 0.15095250f, 0.07133896f, 0.22344624f, -0.21723229f, -0.21475644f, 0.16428617f, -0.19899282f, 
    -0.17011936f, 0.29441562f, -0.06134310f, -0.31938481f, 0.06165306f, -0.28737628f, 0.25228763f, -0.32403332f, 
    0.23821592f, -0.23594606f, 0.15544568f, -0.22659612f, 0.77272004f, -0.43338585f, -0.40924674f, -0.43508199f, 
    -0.25808439f, 0.34751910f, 0.51755452f, 0.53947800f, -0.54488915f, -0.34525460f, 0.30420288f, 0.26830074f, 
    -0.12921418f, 0.00871965f, -0.14958648f, -0.25286457f, -0.18955187f, 0.23778597f, -0.09827164f, 0.34728947f, 
    0.17565989f, -0.09722587f, -0.67448121f, -0.40186322f, -0.69693279f, -0.18116683f, -0.90034175f, 0.10083028f, 
    -0.20365435f, -0.33736122f, -0.12461512f, -0.63772148f, -0.06408525f, -0.22843854f, 0.30800122f, -0.18095805f, 
    0.05125517f, 0.22764455f, 0.40115210f, 0.05840151f, -0.53767544f, -0.10559966f, 0.29538536f, 0.15147099f, 
    0.15602605f, 0.23141785f, 0.35532287f, 0.09949856f, -0.02374047f, 0.05571754f, 0.20402765f, 0.25112274f, 
    0.05129120f, 0.37098855f, -0.41236064f, -0.06817561f, 0.06362608f, -0.11809658f, 0.10179925f, 0.15713242f, 
    -0.22612230f, -0.06435335f, -0.19273140f, -0.00416927f, 0.29580301f, 0.10605559f, 0.04655171f, -0.12766555f, 
    0.31422722f, 0.29262474f, -0.13621643f, -0.42040229f, 0.03930213f, 0.39194870f, 0.44260567f, 0.08249609f, 
    0.17402992f, -0.44484252f, -0.46075764f, 0.06693506f, 0.17639926f, 0.64870185f, -0.00583907f, -0.06885760f, 
    0.10913575f, 0.21390368f, 0.02470569f, -0.28715774f, -0.30075073f, 0.10050289f, 0.22239260f, -0.11560381f, 
    -0.10690965f, -0.00837007f, -0.14553939f, -0.10912824f, 0.32274613f, 1.07696998f, -0.65516806f, -0.48050690f, 
    -0.14715926f, -0.52092791f, 0.61013299f, 0.29965931f, 0.39624992f, 0.18738343f, 0.14495650f, 0.04235072f, 
    -0.07418480f, -0.22054987f, 0.17754349f, -0.10462277f, 0.00044459f, -0.00088305f, 0.08942053f, -0.08469915f, 
    -0.20149751f, 0.07749042f, -0.15652964f, 0.02913292f, 0.11676706f, 0.05762104f, 0.20518959f, 0.26276121f, 
    -0.42709184f, 0.12046637f, -0.28959623f, -0.27993396f, -0.82986301f, -1.02287185f, -0.73970443f, -0.93719256f, 
    0.09614404f, 0.33608165f, 0.24487557f, -0.14990245f, -0.19938563f, 0.04846035f, 0.12857912f, 0.30607438f, 
    0.23707221f, -0.13387917f, -0.23752359f, 0.00826187f, -0.35244149f, 0.11563648f, -0.27801719f, 0.11756726f, 
    0.40596369f, -0.58768481f, -0.39926377f, -0.07997174f, 0.18447728f, -0.37052196f, 0.17114688f, 0.11028139f, 
    0.15576454f, -0.02070656f, 0.26583725f, -0.26090002f, 0.15073404f, 0.29640171f, -0.44245017f, -0.13885193f, 
    -0.08532982f, 0.01657960f, 0.25411126f, 0.19566664f, 0.45144865f, 0.19933870f, 0.06507719f, 0.24056326f, 
    1.03518724f, -1.34881616f, -0.13473387f, -0.23787582f, 0.63059103f, -0.57636106f, -0.29038337f, 0.57803154f, 
    -0.18220294f, -0.07224888f, -0.30724081f, -0.01432655f, 0.47379994f, -0.29622912f, 0.45052654f, 0.22229588f, 
    -0.19190496f, -0.36848494f, 0.23156755f, -0.22051655f, -0.13453747f, -0.36592910f, -0.08147512f, 0.11486540f, 
    0.30783868f, -0.65332335f, 0.21276322f, 0.39472684f, 0.18772453f, 0.10199317f, -0.37125248f, -0.20186931f, 
    0.18218306f, -0.05277268f, 0.15773028f, -0.18851629f, 0.14921397f, 0.13592778f, -0.22199263f, -0.18971124f, 
    -0.17261454f, 0.41361484f, -0.21001288f, 0.10004079f, -0.26100704f, 0.16935749f, 0.16484702f, 0.01410096f, 
    0.14157875f, 0.29799509f, 0.49119830f, 0.01726648f, -0.72911870f, -0.74940223f, -0.43961367f, -0.17929490f, 
    -0.44107461f, -0.19868551f, -0.07034880f, 0.39216611f, 0.30092570f, 0.16100013f, 0.45372227f, 0.04034469f, 
    0.05135119f, -0.01243694f, -0.05905596f, 0.18846995f, -0.39719138f, 0.15771425f, -0.01376470f, -0.22748160f, 
    0.11081357f, -0.12213255f, -0.08778320f, -0.80463660f, -1.55302298f, -0.17736579f, 0.84963477f, 0.79997724f, 
    0.74888170f, 0.74349099f, 0.05085146f, -0.71770638f, -0.03655356f, 0.15868175f, -0.04674956f, -0.23471420f, 
    -0.61508524f, -0.14120144f, 0.11390878f, 0.03301610f, -0.25299606f, 0.24962433f, -0.05471007f, 0.22671925f, 
    -0.27759394f, -0.19588806f, 0.24274294f, 0.07082030f, 0.90930629f, 0.65648443f, -0.17323948f, -0.60306001f, 
    -0.57410562f, 0.15420698f, 0.22353989f, 0.31628510f, -0.07355276f, -0.54720807f, 0.16841510f, -0.00935536f, 
    -0.03781299f, -0.19178364f, -0.27118570f, 0.18158847f, 0.10684256f, -0.23508985f, -0.03701163f, -0.29949668f, 
    -0.64977711f, -0.13967791f, -0.59252924f, -0.32598478f, -0.67769581f, 0.85353756f, -0.05478940f, -0.67365050f, 
    -0.94043678f, -0.95897979f, 0.08181288f, 0.40665674f, 0.13605651f, -0.01891671f, 0.41829786f, 0.11172875f, 
    0.57012331f, 0.05956797f, 0.12997262f, 0.25826991f, -0.01135253f, -0.20778145f, 0.04149848f, -0.06293724f, 
    -0.21443595f, 0.21464066f, -0.31364897f, 0.03226139f, 0.26123446f, 0.08116983f, -0.58633775f, -0.35926616f, 
    -0.63737661f, -0.87731874f, -0.99748832f, 0.35310662f, 0.18476281f, -0.20150563f, -0.04806536f, 0.30015093f, 
    0.10719384f, -0.16355018f, 0.10585642f, 0.09139102f, 0.13077012f, -0.03041797f, 0.21486579f, 0.12849459f, 
    0.30433285f, 0.14533713f, -0.13073558f, 0.00700133f, -0.18226278f, -0.43499559f, -0.35877746f, -1.57770884f, 
    -0.27384505f, -0.61465293f, -0.32827836f, 0.01697937f, -0.12495843f, 0.04520339f, 0.61977428f, 0.72066426f, 
    0.17195201f, 0.40213686f, -0.18693894f, 0.20025110f, -0.03324083f, -0.13947985f, 0.02535277f, -0.35395446f, 
    0.13451529f, -0.21147574f, -0.16636163f, 0.01756075f, 0.42438555f, 0.35700193f, 0.03068203f, 0.08431868f, 
    0.64420009f, -0.70343423f, -0.56843710f, 0.03657609f, -0.05902724f, 0.81481445f, 0.36796686f, -0.18116651f, 
    -0.16445480f, 0.21273121f, 0.16376789f, 0.73118955f, -0.25237194f, -0.25407743f, -0.28042984f, -0.30686894f, 
    0.04789300f, -0.00048357f, -0.06207181f, -0.20274572f, 0.42536473f, 0.13095696f, 0.28172430f, -0.05677697f, 
    0.09614871f, 0.41284221f, -0.61988086f, 0.20244630f, 0.32965317f, -0.13581224f, 0.01704950f, 0.07933086f, 
    0.66484797f, -0.13371943f, -0.01489588f, -0.47556326f, -0.25489298f, 0.01007630f, -0.20013402f, 0.47760183f, 
    0.21209373f, -0.37786132f, -0.38365647f, 0.10633668f, 0.13886884f, 0.23084736f, -0.22758736f, -0.08087396f, 
    0.10370373f, -0.05327757f, 0.39593214f, -1.51305020f, 0.62697846f, -0.10289036f, 0.16427438f, -0.71652836f, 
    -0.36529943f, -0.13187960f, 0.44336936f, 0.00923193f, -0.38300392f, 0.21252809f, 0.06275521f, -0.36876360f, 
    0.08049966f, -0.20723085f, 0.09467014f, -0.38664740f, -0.36555162f, -0.53596205f, -0.06389870f, -0.17972536f, 
    -0.30718359f, -0.31779736f, -0.16554207f, -0.48138151f, 0.81589049f, 0.30843282f, -0.35227296f, -0.75208420f, 
    0.35142091f, 1.14326394f, -0.43359011f, -0.80882102f, -0.65625262f, -0.20924427f, 0.32600358f, -0.28100997f, 
    -0.31571162f, 0.24719732f, -0.46210751f, 0.03841271f, 0.23706354f, -0.13889594f, -0.27215302f, -0.04962868f, 
    0.25579223f, -0.03589673f, 0.02581988f, -0.11373652f, -1.43200588f, 0.26631036f, 0.67246461f, 0.22853927f, 
    0.23890662f, -0.00076973f, -0.14547862f, -0.04991632f, 0.00817559f, -0.06450103f, -0.12805900f, -0.46615374f, 
    0.20177843f, -0.19308938f, -0.22784030f, -0.10986137f, -0.38570461f, -0.32503358f, -0.16822815f, -0.18719284f, 
    -0.00830066f, -0.09647372f, -0.46816576f, -0.12658778f, -0.60707414f, 0.84673101f, 0.85604972f, 0.64586872f, 
    0.00882585f, -0.11700387f, -0.91345149f, -0.50726086f, -0.18312219f, -0.24962258f, -0.45078886f, -0.04494944f, 
    -0.27396560f, -0.33367401f, 0.09219807f, 0.37292185f, 0.24458227f, 0.18666631f, -0.02621941f, -0.13790628f, 
    -0.02999191f, -0.13602221f, 0.06080262f, -0.08512691f, 0.07216281f, -0.20021936f, -0.10149668f, -0.37780952f, 
    -0.47585714f, -0.18313327f, -0.93284029f, -0.70369756f, -0.62675244f, -0.64951766f, -0.71925908f, -0.29213506f, 
    0.59115225f, -0.24241993f, -0.09441043f, -0.01486420f, 0.01504581f, -0.25408363f, 0.29449239f, -0.01813088f, 
    -0.32798871f, -0.39814529f, -0.11354973f, 0.01091635f, 0.09454333f, 0.25241441f, -0.29240090f, 0.97929507f, 
    -0.55422610f, -0.61359310f, -0.66346228f, -0.75370085f, 0.55294895f, -0.04442528f, 0.08156805f, 0.46656013f, 
    -0.26340076f, 0.02501525f, -0.46215510f, -0.19273663f, -0.12403148f, 0.10684348f, -0.32995349f, -0.32294738f, 
    -0.09368147f, -0.10234898f, -0.50656015f, -0.53682458f, -0.13254911f, -0.15985559f, -0.13828535f, -0.37556234f, 
    0.20625658f, -0.40864763f, -1.09928930f, -0.90610194f, -0.58203173f, -0.10272982f, -0.09673119f, 1.04435015f, 
    -0.03688626f, -0.55078703f, -0.60577399f, -0.34326649f, -0.42100674f, -0.33178517f, -0.28249207f, -0.36914277f, 
    -0.29646716f, -0.03024052f, -0.13667931f, -0.19062203f, 0.08467383f, 0.22240698f, 0.13808362f, 0.03904104f, 
    0.23855275f, -0.34992927f, 0.19563174f, -0.24924362f, -0.56460398f, -0.66841215f, -0.35761940f, -0.08472440f, 
    -0.38758534f, -0.55365121f, -0.43421355f, 0.10617236f, 0.09693738f, 0.13189197f, -0.48673642f, -0.14360486f, 
    0.53018063f, -0.11912919f, 0.19223267f, -0.00288810f, -0.17941722f, -0.02857349f, -0.32868388f, -0.19442788f, 
    0.21940178f, 0.67813694f, -0.97481418f, -0.58217192f, -0.87858051f, -0.51234233f, -0.78078139f, 0.16035314f, 
    0.33200467f, 0.32099411f, 0.55092841f, 0.47885343f, 0.27826756f, 0.24507491f, -0.25838876f, -0.17265444f, 
    -0.45174563f, -0.00527769f, 0.16760084f, -0.21496105f, -0.03556613f, 0.06727375f, -0.13901980f, -0.14210364f, 
    -0.03014078f, 0.02927413f, -0.11354158f, -0.07015305f, 0.15805772f, -0.20504221f, 0.54391605f, -0.08914594f, 
    -0.26168257f, -0.33107251f, -0.22358796f, 0.21262945f, -0.23193273f, -0.43025890f, 0.01745091f, 0.16309807f, 
    0.08016217f, -0.29473698f, -0.08435180f, 0.36495200f, 0.22670393f, 0.16526675f, 0.17860968f, -0.30690238f, 
    0.29271457f, -0.06611617f, -0.02510079f, -0.41587552f, 0.47272396f, 0.25866422f, 0.18076222f, 0.17525743f, 
    -0.26036978f, 0.10844921f, 0.06779293f, -0.00541059f, 0.16583636f, 0.19102499f, -0.14626320f, 0.10484189f, 
    0.17543626f, 0.00614575f, 0.09761227f, -0.14042312f, 0.32258803f, 0.10884092f, -0.09202658f, -0.11891975f, 
    -0.16532622f, -0.06994575f, -0.06730283f, -0.12443680f, 0.02491880f, -0.09349415f, -0.34549731f, -0.23100850f, 
    -0.38652495f, -0.52711809f, -0.41430113f, -0.44654006f, -0.67399991f, -0.75063318f, -0.94715977f, 0.66627145f, 
    0.09926698f, 0.09114859f, -0.10852502f, 0.13945185f, -0.47691166f, -0.29113546f, -0.53875059f, -0.51567382f, 
    -0.48173043f, -0.17103800f, -0.30542532f, 0.30824387f, -0.08219694f, -0.36836967f, 0.54866457f, 0.89380980f, 
    0.18110114f, 0.02643205f, -0.39963174f, -0.03283653f, -0.47249970f, 0.01454726f, 0.44371203f, -0.35480565f, 
    0.00519165f, 0.14901948f, 0.33368802f, -0.28742868f, -0.52394861f, 0.19744122f, 0.10382873f, 0.07390334f, 
    0.13856554f, -0.26770264f, -0.24257608f, 0.02280460f, -0.02224069f, -0.13253525f, 0.10071721f, 0.19095136f, 
    0.83569854f, 0.57254010f, -0.29287991f, -0.61494875f, 0.40702623f, -0.07716915f, -0.19616780f, -0.19981793f, 
    0.14354885f, -0.03042305f, -0.31352529f, 0.09166915f, 0.05673777f, -0.29111058f, 0.07897871f, -0.27426606f, 
    -0.25045297f, 0.23743838f, -0.04956098f, -0.24816166f, 0.24935313f, 0.14293225f, -0.15328886f, 0.03587370f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13436823f, 0.25740498f, -0.03322572f, -0.21437266f, 0.02150347f, 0.52467632f, 0.02533260f, 0.15537806f, 
    0.26561943f, 0.26098037f, 0.50664252f, 0.40543261f, 0.12545472f, 0.29152232f, -0.20813347f, 0.53475922f, 
    0.23045856f, 0.56682831f, 0.09173813f, 0.41322058f, -0.22607550f, 0.23480086f, -0.22612728f, -0.08442753f, 
    -0.19167833f, 0.02678705f, -0.04941094f, 0.19524547f, -0.09964927f, 0.23389550f, 0.52082497f, 0.31834567f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.24222733f, 0.23932569f, -0.11544149f, 0.11654055f, 0.08958651f, 0.04861369f, 0.01961673f, 0.03265736f, 
    0.05561029f, -0.01537752f, -0.13383344f, 0.06098759f, -0.30445117f, -0.02812587f, 0.36284226f, -0.52597159f, 
    -0.21981168f, 0.27344558f, -0.25358891f, -0.01656333f, -0.07037824f, 0.01105595f, -0.24743317f, -0.14963841f, 
    0.39733204f, 0.10998010f, -0.10339551f, -0.26930586f, -0.02437564f, 0.11332213f, -0.00409394f, 0.05708605f, 
    -0.04400738f, -0.06376354f, 0.05420063f, -0.00134469f, 0.00490907f, -0.04262432f, 0.07218468f, 0.02558327f, 
    0.01264881f, -0.20542175f, 0.06747632f, 0.00997520f, -0.03884952f, -0.03463315f, 0.06528331f, 0.00476205f, 
    -0.37001958f, -0.29903251f, -0.02684066f, 0.11254602f, 0.07112360f, 0.05794695f, 0.01557981f, 0.02335983f, 
    0.01318723f, -0.07920060f, -0.01313144f, -0.05635982f, -0.38291672f, -0.75295436f, -0.54382950f, 0.10973503f, 
    0.03322929f, -0.04774914f, 0.03044959f, -0.04938043f, 0.14586163f, 0.00980369f, -0.23959820f, -0.10209302f, 
    0.37064460f, 0.29521164f, -0.37560731f, -0.05599204f, 0.18177743f, -0.13215011f, -0.08978273f, 0.19256881f, 
    0.01598074f, 0.04120655f, -0.06215620f, 0.03657256f, -0.04932452f, 0.00121098f, -0.09398116f, 0.01425351f, 
    -0.14234716f, -0.12757649f, -0.11387892f, 0.00497352f, -0.22476882f, -0.11293773f, -0.12168030f, -0.04210757f, 
    -0.05795620f, -0.01103810f, -0.06100411f, -0.12547816f, -0.02937483f, -0.04919242f, 0.04035453f, -0.19369221f, 
    -0.22532234f, -0.03418509f, -0.17691460f, 0.04126811f, 0.02423973f, 0.15442464f, 0.25447404f, -0.20743822f, 
    -0.15273896f, -0.12043347f, -0.02066732f, 0.05186290f, 0.02495595f, -0.05511837f, -0.00095991f, -0.01971105f, 
    0.24923842f, 0.10330412f, -0.21114226f, 0.05107412f, -0.00171392f, -0.01504671f, -0.17742473f, -0.13211466f, 
    -0.14222501f, -0.11326202f, 0.02330184f, 0.02392104f, 0.71147466f, -0.16864963f, -0.43894762f, -0.30325767f, 
    -0.12837565f, -0.11440926f, 0.10194533f, -0.07042276f, -0.16004097f, -0.09645859f, 0.07064594f, 0.04634323f, 
    -0.28720888f, -0.71817827f, -0.47042200f, 0.21569289f, 0.05251841f, 0.01602421f, -0.31033862f, -0.01487985f, 
    -0.20746288f, 0.06831110f, -0.14626004f, 0.13243312f, 0.20544963f, -0.07567221f, -0.13035651f, 0.15939154f, 
    0.12561090f, 0.01223903f, -0.08343536f, -0.05252885f, -0.13343945f, 0.03311567f, -0.04912948f, -0.00397426f, 
    0.48403534f, 0.16225927f, -0.14397468f, -0.08180953f, 0.14658698f, 0.31432489f, 0.05456068f, 0.14177899f, 
    0.01880706f, 0.06947464f, 0.04156256f, 0.11834170f, -0.01873881f, 0.22345863f, 0.17687872f, -0.18097517f, 
    0.09972239f, 0.20600830f, 0.04651851f, -0.20819752f, -0.09957602f, -0.20879400f, -0.11751755f, -0.04626693f, 
    -0.00265697f, 0.03778958f, -0.37075439f, 0.19011348f, 0.02978875f, 0.00541447f, 0.01496687f, -0.13293524f, 
    -0.02154786f, -0.07743619f, -0.34187222f, -0.25909826f, -0.33322328f, -0.26928484f, 0.02854044f, -0.18470156f, 
    0.05731549f, -0.00412697f, 0.04567259f, -0.01736219f, 0.08770232f, 0.00964003f, -0.00533396f, -0.09036944f, 
    0.00328557f, 0.27001879f, 0.27967232f, -0.31669235f, -0.13228647f, -0.12971611f, -0.01651448f, -0.23362407f, 
    -0.27144265f, -0.26703331f, 0.04127996f, 0.19945681f, 0.19188690f, -0.02507758f, -0.13872540f, -0.14605068f, 
    -0.27435899f, 0.05120192f, 0.02757918f, -0.03505244f, -0.18611038f, -0.16735673f, -0.01326695f, -0.05171340f, 
    0.35502359f, 0.35528722f, 0.13676764f, 0.01492783f, -0.14563729f, -0.05093132f, 0.07985660f, 0.07894852f, 
    -0.10518745f, 0.06657474f, 0.05232047f, 0.11313088f, -0.22973450f, 0.07019535f, 0.21934129f, -0.46308222f, 
    -0.01965716f, -0.04140714f, -0.31644586f, -0.26550865f, 0.06540649f, 0.08403943f, -0.02685692f, 0.05212304f, 
    0.45290411f, 0.34538922f, -0.01187690f, -0.31696412f, 0.27870083f, 0.08750364f, -0.12738293f, 0.04075932f, 
    -0.03217978f, 0.04674902f, -0.00129485f, 0.00779035f, 0.24727136f, -0.13645869f, -0.10746740f, -0.01487989f, 
    0.05966059f, -0.07312867f, -0.26415476f, 0.00803415f, 0.04776614f, -0.02606315f, 0.03298418f, 0.30846244f, 
    0.29702350f, -0.04244488f, -0.05098661f, -0.01930891f, 0.15513180f, 0.13780522f, 0.09486615f, 0.02106834f, 
    -0.00682895f, -0.09728124f, -0.17514932f, 0.16205348f, 0.27942118f, 0.17610238f, -0.24498467f, -0.09604295f, 
    0.15061928f, -0.10414934f, 0.07737430f, 0.02848743f, -0.04381743f, 0.01488322f, 0.02979227f, 0.01055963f, 
    0.34964713f, 0.08474249f, -0.04158559f, -0.11271043f, 0.15635888f, 0.22777872f, 0.02705860f, 0.05645307f, 
    0.01758763f, 0.07416847f, 0.06878789f, -0.00258784f, -0.13037199f, 0.05670754f, 0.09170453f, -0.06285862f, 
    -0.04248503f, 0.02804252f, -0.17468412f, -0.15543544f, 0.00768777f, 0.01814373f, -0.02696867f, 0.00786683f, 
    -0.06115079f, -0.03738183f, 0.04666961f, 0.10385508f, 0.10035277f, 0.08445285f, 0.01675519f, 0.02403373f, 
    -0.37712592f, -0.29875457f, -0.10301629f, -0.11554852f, 0.31743029f, 0.11268736f, -0.31992507f, -0.30248547f, 
    0.04952545f, 0.01468695f, -0.14866960f, 0.07183877f, -0.10294948f, -0.00240220f, -0.14363222f, -0.15092878f, 
    -0.63474619f, -0.19011377f, -0.34870580f, 0.26059681f, -0.01798180f, 0.01576187f, -0.03620579f, 0.03423848f, 
    -0.02323675f, -0.02638886f, -0.01565617f, 0.07657374f, -0.54279673f, -0.77738893f, -0.77487123f, 0.04818132f, 
    0.03855301f, -0.03607583f, -0.03735222f, 0.02370555f, -0.02629630f, -0.03737996f, -0.00169215f, 0.05255258f, 
    0.14370660f, -0.07516906f, 0.02145217f, 0.07812289f, -0.07688648f, 0.04268312f, -0.03303215f, -0.00506899f, 
    0.01482644f, -0.08074035f, -0.17702447f, -0.08024061f, -0.84161878f, 0.16323335f, 0.03454667f, -0.45406774f, 
    0.07616104f, 0.04791687f, 0.03601198f, 0.10803052f, 0.00674443f, -0.14711821f, 0.18124454f, -0.10171641f, 
    -0.00537745f, 0.22322556f, 0.38357767f, 0.04023947f, -0.02948861f, -0.03249343f, 0.03335709f, -0.09142465f, 
    -0.03709951f, 0.00203619f, -0.03963296f, -0.04152529f, 0.14763862f, 0.04779816f, 0.06746717f, -0.05259309f, 
    -0.00446960f, 0.05970215f, -0.02480637f, 0.03832590f, -0.04559766f, -0.02341853f, 0.02536568f, -0.05650338f, 
    0.05115261f, 0.41097847f, 0.16457923f, -0.02763499f, -0.01163749f, 0.05221453f, -0.08312549f, -0.00517239f, 
    0.07048976f, 0.01855625f, 0.06666433f, -0.05562034f, 1.01976216f, 0.04031137f, -0.00081162f, -0.03920506f, 
    0.02189860f, 0.00433937f, 0.07547625f, -0.07253651f, 0.04080184f, -0.04576632f, 0.01189290f, -0.00763151f, 
    -0.04070726f, 0.00864818f, -0.25165269f, -0.12169329f, -0.14727838f, -0.12101798f, -0.12080496f, 0.20192419f, 
    -0.00697022f, 0.00726222f, -0.01685781f, 0.18950024f, 0.12206089f, -0.01181649f, -0.03159792f, 0.01403122f, 
    0.07729010f, -0.00614028f, -0.00335597f, 0.06464132f, -0.25676000f, 0.06920758f, -0.04215158f, 0.08083934f, 
    0.13956116f, -0.10344579f, -0.39699262f, 0.24385166f, -0.36019769f, 0.34355336f, 0.14996190f, -0.27201504f, 
    0.15009539f, 0.01508172f, 0.11903924f, -0.02232347f, -0.14492162f, 0.02983711f, -0.09242734f, 0.10622265f, 
    0.06086340f, 0.06866923f, 0.05008810f, -0.00797598f, 0.02629147f, -0.00453127f, -0.03654290f, 0.09175495f, 
    -0.08495934f, -0.19841291f, -0.04090043f, -0.11293177f, 0.20614301f, 0.08632524f, 0.15785688f, -0.10272478f, 
    0.23778772f, -0.03283292f, 0.02018147f, -0.01486194f, 0.35701388f, -0.51068872f, -0.00972173f, 0.28271139f, 
    -0.03601984f, 0.01237913f, 0.12773573f, -0.13365398f, 0.26078287f, -0.19260722f, 0.08996791f, 0.13416135f, 
    0.27337238f, -0.16396818f, 0.24532779f, -0.19679008f, 0.04380909f, -0.10697920f, -0.11975466f, 0.10965663f, 
    -0.39712366f, -0.28686231f, -0.35882300f, 0.07568949f, 0.32320088f, -0.43206063f, -0.20635642f, -0.33612579f, 
    0.05887131f, 0.13826248f, -0.05859129f, -0.01403643f, 0.29191235f, 0.00367787f, -0.14192392f, -0.00453832f, 
    0.11288889f, 0.18441361f, 0.13342787f, 0.04573296f, -0.08229470f, 0.03936708f, -0.21409318f, -0.41208932f, 
    -0.13180150f, -0.00527944f, -0.05025554f, -0.06196315f, -0.55488950f, 0.00625526f, -0.16876099f, -0.22987662f, 
    -0.02374653f, 0.04137409f, 0.09112939f, 0.00124264f, -0.23377165f, 0.06044057f, 0.02907319f, 0.03965222f, 
    0.40339416f, 0.10860665f, -0.13782276f, -0.02401570f, -0.07001923f, -0.16961432f, -0.01695278f, 0.12440611f, 
    -0.08893777f, 0.20075086f, -0.23809411f, 0.06367176f, 0.43086201f, -0.02366955f, 0.03495778f, 0.45713925f, 
    -0.08925971f, -0.02730712f, 0.03347426f, -0.09141089f, 0.06872177f, 0.14266817f, 0.09496380f, -0.11249910f, 
    -0.51455945f, 0.30252427f, -0.30756640f, -0.04087392f, 0.00124825f, 0.09150876f, 0.01338596f, -0.09445384f, 
    0.00105223f, 0.08109949f, -0.12979367f, -0.21412447f, -0.02448267f, -0.84627622f, 0.41535911f, -0.18274401f, 
    0.08731838f, -0.05995618f, -0.15250009f, 0.09641530f, 0.06522722f, 0.13941969f, -0.06864025f, 0.16506797f, 
    -0.00231798f, -0.25853670f, -0.28334057f, 0.09224754f, -0.03193446f, -0.02194907f, 0.07594095f, 0.01828278f, 
    -0.17985572f, 0.04451790f, -0.16225927f, -0.23770347f, 0.28149071f, -0.07487806f, -0.02013912f, -0.09759759f, 
    -0.11272274f, -0.22545536f, -0.17951444f, 0.11160965f, -0.05493417f, 0.09684748f, -0.02283318f, 0.02996888f, 
    0.12641218f, 0.13183218f, 0.16997170f, -0.08986243f, -0.01845559f, -0.28068417f, -0.16997944f, 0.10892448f, 
    0.00035196f, 0.04437958f, -0.00985838f, 0.04143023f, 0.39851558f, 0.20556311f, -0.03344841f, 0.03188091f, 
    0.04654290f, 0.17221420f, 0.00756753f, -0.15717088f, -0.02412028f, -0.14755417f, -0.29380220f, -0.50657541f, 
    0.32251924f, 0.51485240f, 0.13008626f, 0.03957212f, -0.18117265f, 0.05427111f, 0.35379416f, -0.10487493f, 
    0.01451630f, 0.10888224f, -0.11635704f, -0.12743278f, 0.14245804f, -0.05446588f, 0.18743750f, -0.28690135f, 
    -0.02101005f, 0.33601075f, -0.10398974f, -0.10882866f, -0.00410682f, -0.01804367f, -0.11818597f, 0.00311394f, 
    0.17134967f, 0.00061561f, -0.23314546f, -0.04767067f, -0.01535738f, 0.00960549f, -0.02836869f, -0.33136252f, 
    -0.04458458f, -0.18551919f, -0.11762487f, -0.02122236f, -0.19404364f, 0.11294448f, 0.01476943f, -0.11322685f, 
    0.16722985f, -0.19993331f, -0.11642586f, -0.07113401f, -0.11144041f, -0.07805045f, -0.06710901f, 0.05336291f, 
    0.06171484f, 0.04007884f, 0.14878723f, 0.12349634f, -0.00659157f, 0.03902389f, -0.05387179f, -0.05476750f, 
    0.23523201f, 0.22349919f, -0.07643710f, -0.05480275f, -0.16196690f, -0.13475686f, 0.15730363f, -0.07423916f, 
    -0.01651102f, 0.12939572f, 0.13207392f, 0.42171860f, -0.04463078f, -0.08133723f, 0.06335858f, 0.12135668f, 
    0.14680426f, 0.20515977f, 0.34147215f, -0.15438955f, -0.02609253f, -0.00530422f, 0.01664686f, -0.09022718f, 
    -0.04286503f, 0.06707186f, -0.00464789f, 0.09048818f, 0.46487036f, 0.14404699f, 0.26816130f, 0.22779647f, 
    -0.16726260f, -0.01838333f, 0.02044284f, 0.07493637f, -0.06000027f, 0.02305659f, 0.09019049f, -0.08689948f, 
    -0.07859275f, -0.12504441f, 0.19658338f, -0.01599569f, 0.05091257f, 0.03187462f, 0.01856697f, 0.12845516f, 
    -0.21468152f, 0.00308871f, -0.10808467f, -0.12763901f, -0.19817387f, -0.14390916f, -0.34201565f, 0.00408971f, 
    0.10046460f, -0.17421374f, 0.10617891f, -0.11999800f, 0.05321988f, 0.03089366f, 0.02934452f, 0.23928003f, 
    -0.32829908f, -0.37692159f, 0.16597702f, 0.04495959f, -0.19076087f, 0.14970443f, 0.12071951f, -0.08542898f, 
    -0.00128516f, -0.00215619f, -0.03533788f, 0.00945690f, -0.04640475f, -0.02017294f, -0.07249764f, -0.10992397f, 
    0.00042705f, -0.05402153f, 0.08259166f, 0.00958523f, -0.01600276f, -0.02280612f, 0.07233570f, -0.06447878f, 
    -0.59107798f, -0.00820170f, 0.19203782f, -0.05272740f, 0.01332243f, 0.07021693f, -0.03099668f, 0.01532398f, 
    0.03674069f, -0.11251746f, 0.01121650f, -0.08415576f, -0.50088155f, 0.53105700f, 0.43124628f, -0.06428985f, 
    -0.04309987f, 0.08675802f, 0.02405667f, -0.08834615f, 0.02819364f, -0.02544200f, 0.16203155f, 0.13242489f, 
    -0.56322402f, -0.42683822f, 0.07979215f, -0.46187678f, 0.06295341f, -0.04692296f, -0.17239195f, -0.00517231f, 
    -0.00162571f, -0.01134096f, 0.08856395f, -0.07309119f, -0.01047482f, -0.01195673f, -0.02225597f, 0.05009727f, 
    0.04686819f, 0.08278369f, -0.20538378f, 0.03884227f, -0.08239008f, -0.06775537f, -0.18836623f, -0.02652895f, 
    0.16194873f, 0.19713588f, -0.13505693f, 0.26524428f, -0.27354482f, 0.09283827f, -0.10410894f, -0.27650097f, 
    0.05120824f, 0.22205350f, 0.06792053f, -0.15047555f, -0.01409933f, -0.03364883f, -0.05167526f, -0.15119575f, 
    -0.00508507f, 0.26341340f, -0.04243724f, 0.09741923f, 0.02752765f, -0.07182212f, -0.04100460f, 0.02342452f, 
    -0.09314055f, 0.17954886f, 0.09617941f, 0.19119331f, -0.03503340f, -0.06207130f, 0.10542933f, -0.09409533f, 
    0.06286208f, 0.15956543f, -0.01920911f, 0.03520553f, 0.08727810f, -0.33511633f, 0.22317924f, 0.07452659f, 
    0.11167325f, -0.06265811f, 0.01311687f, 0.18753785f, 0.11486171f, 0.03372209f, -0.03987394f, -0.03923042f, 
    -0.09078140f, 0.02573953f, 0.04404432f, -0.22180857f, 0.03955342f, -0.09490147f, 0.02434396f, -0.14154486f, 
    0.08738002f, 0.07801487f, 0.06075703f, 0.35472468f, -0.12311722f, 0.38934997f, 0.23039897f, -0.01877723f, 
    -0.04834508f, 0.11981093f, 0.02413005f, -0.34677318f, -0.20174938f, 0.08222135f, -0.16883895f, 0.14228474f, 
    -0.05197449f, 0.16088489f, 0.31909093f, 0.21934615f, -0.24615668f, -0.08091394f, -0.01072378f, 0.14475498f, 
    0.12765783f, 0.03122816f, 0.02332780f, -0.00479534f, 0.02485436f, 0.26157048f, -0.07469600f, 0.23771931f, 
    0.07596137f, 0.08356473f, 0.08388150f, -0.14272632f, 0.01798880f, -0.09719490f, 0.04770657f, 0.04186560f, 
    -0.13849895f, -0.09575180f, -0.15266290f, -0.28926098f, 0.09579992f, -0.06427971f, 0.06500970f, -0.05954488f, 
    0.04739813f, -0.27714479f, -0.23224743f, -0.14878255f, 0.14304036f, -0.03302952f, -0.36088076f, 0.31209934f, 
    0.04662598f, 0.06129281f, -0.02177755f, -0.00365780f, -0.10130891f, 0.11095224f, 0.07808937f, 0.06530500f, 
    0.14606851f, -0.05082710f, -0.22819974f, 0.15041564f, -0.16133654f, 0.06756040f, -0.17417128f, -0.02043553f, 
    -0.06081583f, 0.17254223f, 0.09181220f, 0.29166308f, 0.58884615f, 0.10453421f, 0.04099716f, -0.41843840f, 
    -0.01878298f, 0.00568593f, -0.21604773f, 0.18524405f, -0.07503104f, 0.07876108f, 0.02198797f, -0.13992010f, 
    0.26287341f, -0.05195919f, -0.33528924f, -0.01735784f, 0.01529778f, -0.01552956f, -0.02036845f, 0.04241537f, 
    -0.16316199f, 0.03427836f, 0.11221425f, -0.05703179f, -0.61088395f, -0.29369316f, 0.18626532f, -0.08840770f, 
    -0.08688803f, -0.03438938f, -0.00132029f, -0.33000571f, 0.06252602f, 0.02681376f, -0.08993378f, 0.06586491f, 
    -1.32159996f, -0.75743860f, -0.28053984f, -0.33226934f, -0.06321492f, -0.06467298f, 0.11970094f, -0.07355686f, 
    0.01378329f, 0.00678172f, -0.05613032f, 0.06736547f, -0.69006813f, 0.57537496f, 0.34069890f, 0.14060746f, 
    -0.07279740f, 0.01989476f, 0.06211449f, -0.01074416f, 0.09992912f, 0.12563011f, 0.16626047f, 0.03467835f, 
    -0.50268602f, 0.67565840f, 0.54914600f, 0.27060610f, -0.29143333f, 0.05924098f, 0.11920919f, -0.07122953f, 
    -0.02445316f, -0.12574251f, -0.00478335f, -0.33753026f, -0.04117430f, -0.30828947f, 0.03772982f, -0.45255548f, 
    -0.01562436f, -0.01046937f, -0.00904767f, -0.07346523f, -0.04776442f, 0.01539372f, 0.00578161f, -0.04170227f, 
    0.22879180f, 0.83858979f, 0.34866849f, 0.32254022f, -0.10311158f, -0.02608364f, 0.16702874f, 0.08191918f, 
    0.05689507f, -0.00448484f, -0.14445998f, 0.15451820f, -0.15513995f, 0.05659442f, -0.01976766f, -0.08741485f, 
    -0.17595023f, -0.17121409f, -0.00661191f, 0.23240381f, -0.01910607f, -0.03139208f, 0.07370187f, -0.05191069f, 
    -0.14547242f, 0.02259074f, 0.02754715f, -0.02429762f, -0.03005885f, -0.06699479f, -0.04669653f, 0.00146581f, 
    -0.03070847f, -0.12158220f, -0.05876937f, 0.16307162f, -0.27658886f, -0.16552840f, 0.05908859f, -0.22509609f, 
    0.12251908f, -0.02763257f, 0.11512725f, -0.18821979f, 0.01179401f, 0.05328657f, -0.18765485f, 0.09829673f, 
    -0.30191571f, -0.20530173f, 0.33269826f, -0.41080639f, -0.03304821f, -0.01248156f, 0.02813414f, 0.10120431f, 
    0.03635804f, -0.09687801f, 0.05792122f, -0.05194724f, -0.26704028f, -0.10933637f, 0.45419458f, -0.61547524f, 
    0.05661233f, -0.02863327f, -0.03669242f, 0.14714135f, 0.02892157f, -0.01277061f, 0.02489314f, 0.00399762f, 
    0.10513291f, 0.73312706f, -0.49189413f, -0.64239407f, 0.48336405f, 0.10183533f, 0.16867691f, -0.26129040f, 
    -0.27596435f, -0.02328284f, -0.11045483f, -0.12507759f, 0.35947689f, 0.02407574f, 0.04045001f, -0.31670180f, 
    -0.05653572f, -0.11389719f, -0.07071946f, -0.34577122f, 0.11872836f, -0.03150886f, -0.04227215f, 0.11535467f, 
    -0.05738298f, -0.23448035f, -0.09500144f, 0.24201158f, 0.09423150f, 0.00203891f, -0.14155538f, 0.12276740f, 
    0.05799256f, 0.25677174f, -0.30983132f, 0.07055151f, -0.13653061f, -0.09554936f, 0.00206707f, -0.25411922f, 
    0.06975195f, 0.06922462f, -0.23021473f, 0.00067724f, 0.16777895f, 0.13713570f, -0.10242322f, -0.06106712f, 
    -0.10818993f, 0.32238480f, -0.23169079f, -0.16592106f, 0.14703502f, 0.02156886f, -0.01156400f, -0.60042238f, 
    0.13492893f, -0.07315730f, 0.09492217f, -0.17999838f, -0.63928974f, 0.16492926f, 0.10744516f, -0.01050497f, 
    0.21095024f, 0.10350748f, 0.21000083f, -0.04067888f, -0.28608215f, -0.23493092f, 0.00568674f, -0.00389945f, 
    -0.13335717f, -0.19507162f, 0.14724238f, 0.21488203f, 0.04224821f, 0.09092313f, 0.04943511f, 0.01943981f, 
    0.02443369f, 0.03229665f, -0.16165696f, -0.00979181f, -0.15789266f, 0.06592033f, -0.07865158f, 0.19554205f, 
    0.18766989f, 0.01792737f, -0.30159163f, -0.07501709f, -0.00902484f, -0.10163622f, 0.07737163f, -0.17562287f, 
    -0.88119912f, 0.51844388f, -0.31052399f, 0.14180662f, 0.17922279f, -0.08826073f, 0.14123860f, -0.24232924f, 
    -0.05341014f, -0.07357085f, 0.03521626f, -0.28473309f, 0.33705655f, 0.14155738f, 0.01538127f, -0.16495351f, 
    -0.20053665f, -0.06463135f, -0.03906570f, -0.31199864f, 0.00183231f, 0.08313151f, -0.11377151f, 0.15236069f, 
    -0.31699356f, -0.11447446f, -0.17490120f, 0.17147893f, -0.02115395f, -0.06439555f, 0.05659971f, -0.21285614f, 
    0.05095144f, -0.08377436f, -0.06266382f, 0.03570960f, -0.69288337f, 1.16348338f, -0.31273371f, -0.41600317f, 
    0.26017424f, 0.01368172f, -0.12146481f, -0.24170859f, -0.30827236f, 0.00361651f, -0.05228167f, 0.08255675f, 
    -0.21957161f, -0.03537998f, 0.30130535f, 0.17400804f, -0.13099991f, -0.06838512f, -0.01486818f, 0.02187937f, 
    0.24035122f, 0.17920682f, -0.07200294f, -0.02858846f, -0.43624690f, -0.00153602f, -0.06934547f, 0.45133263f, 
    0.05815370f, 0.03724952f, 0.03889417f, -0.06590769f, 0.00830906f, -0.16605556f, 0.25888079f, 0.04400588f, 
    0.16731554f, -0.19367866f, 0.06844773f, 0.32923734f, 0.13897161f, -0.08937521f, 0.00486042f, -0.12588806f, 
    0.05442230f, -0.05132069f, 0.00939472f, 0.14101134f, 0.56648481f, -0.10982123f, -0.08327718f, -0.05265413f, 
    0.15618747f, -0.08093725f, 0.01943879f, -0.08302703f, 0.01780391f, 0.17029314f, 0.02117097f, 0.02198998f, 
    -0.02727635f, 0.06429341f, -0.34404156f, -0.09190961f, 0.02760484f, 0.02283613f, 0.08164415f, -0.28258345f, 
    -0.15735309f, 0.16660017f, 0.15665519f, 0.10405767f, -0.73561615f, 0.44040662f, -0.35528001f, -0.10789002f, 
    0.01242286f, -0.06615764f, -0.19331211f, -0.00297138f, -0.08006653f, -0.19969186f, 0.03725229f, -0.19060427f, 
    -0.20682965f, 0.00606705f, -0.14710259f, 0.07652833f, -0.13075025f, 0.03014711f, -0.10419205f, 0.04062326f, 
    0.00539779f, 0.09380846f, -0.24623704f, -0.10725370f, 0.02946337f, -0.25725338f, 0.15031232f, 0.31025067f, 
    -0.03854123f, -0.25327325f, -0.10885754f, -0.17294243f, -0.11216927f, -0.06062383f, -0.13207456f, 0.01961458f, 
    0.26900539f, 0.26127917f, 0.01655809f, -0.16367044f, -0.06775104f, 0.10279615f, 0.02884024f, -0.13258125f, 
    -0.06595265f, -0.00200849f, 0.12314786f, 0.00199530f, -0.04248520f, -0.58801281f, 0.49317011f, 0.20231047f, 
    -0.22623454f, -0.10609702f, -0.03723670f, 0.18260041f, -0.02440413f, -0.03218494f, 0.12742972f, 0.11249896f, 
    -0.03460880f, -0.27524570f, -0.01168904f, 0.22949836f, 0.03569457f, -0.03203267f, 0.09725913f, -0.06127650f, 
    0.07083199f, 0.05243867f, -0.22221455f, 0.00150794f, -0.35873845f, 0.03631597f, -0.05753049f, 0.24646144f, 
    -0.02850783f, -0.01111069f, -0.05016249f, -0.06971105f, -0.01307130f, 0.04902281f, 0.00172743f, 0.05941683f, 
    0.24003276f, 0.00094831f, -0.00445200f, 0.25592804f, 0.12873013f, -0.01220179f, -0.05776752f, 0.06948258f, 
    0.02760698f, 0.07413363f, 0.05472642f, 0.00685231f, 0.01030572f, -0.25453609f, 0.06568621f, 0.19043170f, 
    -0.08121890f, 0.06361248f, -0.04641337f, -0.21551788f, -0.01778931f, 0.02488494f, 0.11272214f, -0.15173987f, 
    0.14833039f, -0.14353782f, 0.09511396f, 0.15047160f, 0.12732857f, 0.04289647f, 0.12551267f, -0.00535834f, 
    0.00804036f, 0.02592964f, -0.04052595f, 0.09620756f, 0.11014525f, 0.07731400f, -0.01505769f, 0.14320561f, 
    -0.23908968f, -0.19450691f, -0.04180254f, 0.06824173f, -0.12400522f, 0.26088268f, -0.00585616f, 0.16629249f, 
    -0.13466799f, -0.31927192f, -0.26171848f, -0.14686345f, -0.04057908f, -0.14351980f, 0.00252332f, 0.17830439f, 
    0.12178262f, 0.10646279f, -0.29814443f, -0.07816478f, -0.01213990f, -0.09919488f, -0.05410103f, 0.20413236f, 
    -0.02623033f, -0.00690726f, 0.27562794f, 0.11160864f, -0.10015039f, -0.00085405f, 0.03833294f, 0.01903189f, 
    -0.23004642f, -0.26360574f, 0.31780234f, -0.12216701f, -0.23965684f, -0.01888486f, -0.20232609f, -0.14545219f, 
    -0.04137525f, 0.06253091f, -0.03752629f, 0.11613593f, -0.05182937f, 0.18131854f, 0.64021558f, -0.09305890f, 
    -0.05043644f, 0.19631778f, -0.21561770f, -0.00922388f, -0.09359290f, -0.07018226f, 0.32617018f, -0.17224310f, 
    -0.00571854f, -0.19960831f, -0.18395148f, 0.02198896f, -0.06180694f, 0.00410826f, -0.05222176f, 0.05543233f, 
    0.21491116f, -0.02701404f, -0.07446194f, -0.14307100f, -0.19664255f, -0.20496483f, -0.14934553f, 0.19039792f, 
    -0.13037644f, -0.16718630f, -0.03967674f, 0.05600655f, -0.16925748f, -0.10297230f, -0.37475619f, -0.06776524f, 
    0.11433883f, 0.12316217f, 0.14126794f, 0.15914477f, -0.04022661f, -0.22538316f, -0.02686189f, -0.09775208f, 
    0.03458853f, 0.01230001f, 0.00830922f, -0.00981159f, 0.12123986f, 0.03009350f, 0.04056081f, 0.19096759f, 
    0.13192819f, 0.02141118f, 0.02783703f, -0.06998607f, 0.00081758f, -0.01581232f, -0.01754227f, -0.01189399f, 
    -0.13325113f, -0.28243333f, -0.09926919f, 0.11734109f, 0.03292342f, -0.00413845f, 0.05305268f, 0.03052376f, 
    0.03720869f, -0.00155725f, -0.03037526f, 0.12210329f, -0.19106174f, -0.03630266f, -0.04037303f, -0.10180337f, 
    -0.00914388f, -0.05761613f, -0.05028872f, 0.16283225f, -0.15748343f, -0.10480906f, -0.18599987f, 0.07017551f, 
    0.19047332f, 0.22221139f, 0.36352715f, 0.12441504f, 0.05266702f, 0.07890812f, -0.02898278f, 0.01691720f, 
    0.06320392f, 0.01586866f, 0.03834240f, -0.17158593f, -0.01522288f, 0.11986092f, 0.03730855f, -0.01621229f, 
    -0.06020433f, 0.13759311f, 0.12718914f, 0.04151004f, 0.17265552f, -0.18971118f, -0.07113419f, 0.05831487f, 
    0.41498646f, -0.34516308f, 0.16569249f, -0.44977707f, -0.06770489f, -0.02946040f, -0.02447176f, 0.10380965f, 
    -0.23302908f, -0.20722423f, -0.14250045f, 0.04595842f, 0.01125700f, -0.11936055f, -0.00708210f, 0.17117009f, 
    0.17831238f, -0.18473749f, 0.11263387f, 0.00206912f, -0.05836960f, -0.13467593f, -0.05327301f, -0.15536730f, 
    -0.02334198f, 0.01832445f, 0.03952956f, 0.00584766f, 0.12114997f, -0.11352265f, -0.11325938f, -0.07242941f, 
    0.02560551f, 0.04421573f, 0.01450547f, -0.07374302f, 0.07580699f, -0.71950054f, 0.07085309f, 0.07748031f, 
    -0.15524206f, 0.13236940f, -0.09737883f, -0.06465734f, -0.31316021f, 0.07716495f, -0.23958255f, -0.09931264f, 
    0.04866597f, 0.24384266f, -0.21219759f, -0.03599352f, 0.12512428f, 0.02531150f, 0.08427599f, -0.11139339f, 
    0.06494458f, -0.10311364f, 0.13735244f, 0.15376139f, 0.06557625f, -0.02332179f, -0.05552887f, 0.08066215f, 
    -0.02289796f, -0.14947684f, 0.06909721f, 0.04189098f, 0.01796408f, -0.06789652f, 0.12117065f, -0.03817113f, 
    -0.21758062f, 0.06493106f, 0.15570682f, 0.13539907f, -0.11671853f, -0.13863650f, -0.12838292f, -0.13890952f, 
    0.12898666f, 0.10395466f, 0.05132679f, 0.07310363f, 0.32235777f, -0.19168749f, -0.03366623f, 0.03528688f, 
    -0.14411274f, -0.09697673f, -0.14196916f, 0.06554837f, 0.09374734f, -0.19204687f, -0.12539923f, -0.05212660f, 
    0.22670062f, 0.18524344f, -0.07656399f, -0.02622888f, 0.07675275f, 0.02260460f, -0.08474911f, -0.04178967f, 
    0.03699243f, -0.24009638f, -0.24366355f, -0.04588628f, -0.14087844f, -0.16312379f, -0.20743917f, -0.69534111f, 
    0.04821002f, 0.07181954f, -0.01745907f, 0.04078273f, 0.01723566f, 0.00191124f, -0.33127910f, 0.06168759f, 
    0.14203542f, 0.06915425f, 0.11774530f, -0.07841332f, 0.01514724f, 0.02783396f, -0.01095155f, -0.18037942f, 
    -0.09484916f, 0.09361910f, 0.04517906f, 0.20040865f, 0.12047919f, 0.02191858f, -0.26173097f, 0.06837676f, 
    0.31807378f, -0.34144208f, 0.01156168f, -0.25827694f, -0.22056094f, -0.04644636f, -0.01134895f, -0.35109365f, 
    -0.07872726f, -0.40858275f, -0.24414264f, 0.13653116f, 0.03894768f, -0.06541502f, 0.01490732f, -0.05592713f, 
    0.17624941f, 0.01652998f, 0.16412620f, 0.54757392f, 0.06567448f, 0.64392936f, -0.29041621f, 0.54561853f, 
    -0.06464414f, 0.31415629f, 0.13874532f, -0.02476024f, 0.09123868f, -0.04422221f, -0.00018980f, -0.03217786f, 
    -0.09341682f, 0.11355419f, 0.20404854f, 0.14827041f, -0.14899337f, 0.02861865f, 0.00521774f, 0.11102996f, 
    0.02045287f, -0.02771019f, 0.09440607f, 0.04635336f, -0.05387900f, 0.06863280f, 0.17005971f, 0.11598457f, 
    0.00916045f, 0.00350580f, -0.02046205f, -0.11004428f, -0.02338854f, -0.06443457f, -0.04991442f, 0.15736505f, 
    -0.49995250f, -0.13459845f, 0.07975321f, 0.01046167f, -0.16439743f, 0.01541635f, -0.11079287f, -0.18821764f, 
    -0.03702624f, -0.01391786f, 0.02459012f, -0.07343820f, 0.03076995f, 0.25923163f, 0.05625977f, 0.15785381f, 
    -0.01217301f, -0.14859706f, 0.06411535f, -0.01133483f, -0.03912928f, -0.00046346f, 0.02461515f, -0.00819098f, 
    0.06544245f, 0.12437847f, 0.15719825f, 0.18305868f, -0.12918444f, -0.13799751f, 0.07357637f, 0.16493241f, 
    -0.07908890f, -0.07361413f, -0.04296300f, 0.09057774f, 0.15759817f, -0.25624791f, 0.17825352f, 0.29279792f, 
    -0.12497533f, 0.21101096f, 0.06084988f, -0.06513951f, 0.04440224f, -0.18049122f, -0.00219413f, -0.01943232f, 
    0.05924568f, -0.02052118f, -0.02510403f, 0.02838532f, 0.06988414f, 0.07517029f, 0.09498725f, 0.05036429f, 
    -0.06535359f, 0.05055296f, 0.01521110f, 0.14549738f, 0.07865070f, 0.20299737f, 0.30073702f, 0.13072942f, 
    -0.09900689f, -0.09609579f, -0.13915470f, -0.04021695f, -0.03996646f, -0.04256223f, 0.07501591f, 0.04000727f, 
    0.14069749f, -0.20723186f, -0.35002977f, -0.03134157f, 0.04561624f, 0.07416105f, 0.10756471f, 0.05342926f, 
    0.10809281f, -0.05064916f, 0.07970200f, -0.11167663f, 0.40943560f, 0.01750016f, -0.70794243f, 0.32551855f, 
    0.07278039f, 0.03395889f, 0.03649882f, 0.01998929f, -0.03070439f, -0.06421591f, -0.02972881f, -0.06834929f, 
    -0.15761290f, -0.06837811f, 0.12833719f, 0.01935931f, -0.02553546f, -0.11543810f, 0.01115142f, -0.03862651f, 
    -0.17795110f, -0.07599986f, 0.11600864f, 0.27229443f, 0.23836543f, -0.08843822f, 0.19339807f, 0.06092018f, 
    -0.03631487f, -0.19922549f, -0.32072616f, 0.20527171f, -0.00136554f, 0.23401111f, 0.06918693f, 0.00084349f, 
    0.00095241f, 0.11284029f, -0.09777548f, -0.05631908f, 0.35980332f, 0.26116303f, 0.05463033f, 0.10762470f, 
    -0.02670926f, -0.05999633f, 0.08225298f, 0.11136388f, -0.03194576f, -0.09083777f, -0.13004129f, 0.08698431f, 
    -0.12498904f, -0.07951728f, -0.08524402f, 0.08957072f, 0.20398924f, 0.10544247f, -0.04559628f, -0.01014388f, 
    -0.42446882f, -0.33019164f, 0.20344386f, 0.28804815f, 0.03390849f, -0.09127997f, 0.00003426f, 0.03877221f, 
    -0.06692470f, 0.05783531f, -0.13354065f, 0.11082244f, -0.22700797f, -0.36296162f, -0.27991918f, -0.22211134f, 
    -0.03117004f, 0.05873661f, -0.09123383f, 0.04743959f, 0.21825103f, -0.00511860f, 0.04759107f, -0.18201943f, 
    0.13045779f, 0.23630674f, 0.07795935f, -0.24840225f, -0.08515606f, -0.12636048f, -0.02739877f, -0.20984961f, 
    -0.03206022f, -0.10723342f, 0.04820116f, -0.00913422f, -0.07850318f, -0.12389968f, -0.03752686f, -0.06683028f, 
    -0.25185961f, 0.06858564f, -0.30416611f, -0.25765410f, 0.33578327f, 0.26890969f, 0.10932951f, -0.05761138f, 
    0.11100242f, -0.31798631f, 0.36905140f, -0.05064324f, 0.30896294f, -0.15213253f, -0.15202272f, 0.13293815f, 
    0.16395102f, 0.02350882f, -0.06327131f, 0.16580726f, -0.04927028f, -0.03100844f, 0.08786377f, 0.15790862f, 
    -0.06000485f, -0.06197768f, -0.09617418f, 0.08933104f, 0.01683707f, 0.04834347f, 0.09942252f, 0.10098182f, 
    0.15103096f, 0.02589385f, 0.00194406f, -0.21306287f, -0.23281062f, 0.16308045f, -0.02943691f, 0.17893650f, 
    -0.18300483f, -0.04005110f, 0.02177499f, -0.09137060f, -0.33947322f, 0.22540271f, 0.19529079f, -0.14953387f, 
    0.06812556f, -0.10547412f, 0.04767752f, 0.19416609f, 0.04185741f, -0.00867997f, -0.29837880f, 0.07421298f, 
    0.24613446f, 0.13438354f, -0.55772567f, -0.11134031f, -0.06991240f, 0.16740489f, 0.08078767f, -0.10369202f, 
    0.11926687f, -0.34420916f, -0.21240409f, -0.56876791f, -0.10004903f, -0.04823786f, -0.31938529f, -0.20074469f, 
    -0.04505268f, 0.02491542f, 0.03911116f, 0.07975093f, 0.06157823f, 0.12025402f, -0.06380671f, -0.16628237f, 
    -0.29574686f, -0.00536581f, -0.19184262f, -0.42213178f, 0.06360358f, -0.08545774f, 0.00847850f, 0.36129978f, 
    -0.12199441f, -0.07071313f, -0.07334064f, -0.08991233f, -0.36884016f, -0.10926662f, -0.04833397f, 0.10775182f, 
    -0.08122607f, -0.06202750f, 0.04828850f, -0.07374913f, 0.21584503f, 0.02328594f, 0.00826971f, -0.04830764f, 
    -0.26161203f, -0.18202852f, 0.20216803f, -0.14674671f, -0.11818673f, 0.13265443f, 0.00836648f, -0.03446084f, 
    0.22364290f, 0.00527288f, 0.48455733f, -0.19109000f, 0.19227611f, -0.18712741f, 0.41630459f, -0.11385136f, 
    0.16843352f, -0.11304872f, -0.02891072f, 0.18235411f, -0.08220900f, -0.05233312f, 0.01719496f, 0.05497968f, 
    0.59806657f, -0.49679595f, 0.24029863f, 0.44572347f, 0.07409585f, -0.03615550f, -0.05150353f, 0.14973053f, 
    0.26614001f, -0.27650678f, 0.20342048f, -0.35946137f, -0.08925349f, 0.72829574f, -0.43266404f, -0.20135021f, 
    0.07052260f, 0.14797001f, 0.19338204f, 0.19200948f, 0.26914060f, -0.08234584f, 0.09487496f, 0.01502843f, 
    -0.81319332f, 0.20630443f, 0.59207594f, 0.17718907f, 0.06206122f, -0.04741559f, -0.05531119f, 0.07752846f, 
    0.17813170f, -0.31041765f, -0.41917324f, -0.63877517f, -0.15087195f, -0.29599437f, -0.20305881f, 0.09094599f, 
    0.27805057f, 0.06028686f, -0.09037169f, 0.08571849f, 0.00231092f, 0.01784816f, 0.03668442f, -0.09084867f, 
    0.11213886f, 0.09278554f, 0.20463334f, 0.05086172f, 0.10481764f, 0.36097875f, 0.06696060f, -0.05578205f, 
    0.00733156f, 0.03346416f, 0.09362806f, -0.01515712f, 0.21088977f, -0.26531988f, -0.28694710f, -0.44667962f, 
    -0.07547171f, 0.04750636f, 0.04473952f, 0.20555997f, 0.04870662f, -0.17910610f, -0.01231860f, -0.37943262f, 
    0.07879695f, 0.00072122f, -0.18723965f, -0.31408754f, 0.23532905f, -0.06659713f, -0.26770872f, 0.00147975f, 
    0.01601675f, 0.06835029f, 0.15532742f, 0.05784193f, 0.04215710f, 0.30084723f, 0.07441081f, 0.04877298f, 
    0.19502582f, 0.14699936f, -0.07461770f, 0.13787642f, -0.02859526f, -0.01645556f, 0.06772092f, 0.14639157f, 
    -0.38218924f, -0.31725475f, -0.19357428f, -0.16369282f, -0.04140120f, -0.05253189f, -0.17369729f, 0.03287903f, 
    -0.09780027f, -0.10380580f, 0.01112886f, -0.05933471f, 0.30875000f, -0.08538459f, -0.04476398f, 0.17497888f, 
    -0.10035962f, 0.01246764f, 0.19383636f, 0.19288203f, 0.07269649f, 0.20291217f, 0.11571628f, -0.14693424f, 
    0.01675297f, -0.17602937f, -0.03694079f, -0.00823140f, 0.02262102f, -0.02382455f, -0.09827399f, 0.04977417f, 
    0.09735181f, -0.20898238f, 0.18744776f, -0.19009045f, 0.07969607f, 0.15026517f, 0.03264052f, -0.10784027f, 
    0.06667952f, 0.05465506f, 0.03565412f, -0.28786829f, -0.06844483f, -0.00834709f, 0.05911944f, -0.07140277f, 
    0.42797324f, 0.08827718f, -0.45189902f, 0.35107294f, 0.01191791f, 0.06158941f, -0.03392532f, 0.00328454f, 
    0.07369091f, -0.03854934f, -0.05677155f, 0.08964788f, -0.21684951f, 0.07072272f, -0.60972410f, -0.20330735f, 
    0.10425657f, -0.07695189f, 0.05285377f, 0.04828087f, 0.15010506f, 0.04100344f, -0.06593858f, 0.18316683f, 
    -0.35451630f, 0.14859086f, 0.17630073f, -0.00790115f, -0.00352927f, 0.01588591f, 0.00527410f, -0.00760587f, 
    0.10514362f, -0.00437522f, 0.14736658f, 0.07300287f, 0.22003798f, -0.12153741f, -0.55763632f, 0.05932550f, 
    -0.00173729f, 0.11888804f, 0.06529222f, 0.10915589f, 0.02009846f, 0.01051079f, 0.02248793f, -0.30953464f, 
    -0.95917374f, -0.26846859f, -0.37404180f, -0.40942517f, 0.04836686f, -0.47722927f, -0.05354171f, -0.27812216f, 
    -0.02322370f, 0.07793765f, -0.06015232f, 0.00096449f, -0.07027624f, -0.11674336f, -0.17587377f, 0.06442698f, 
    0.00582938f, 0.02681296f, -0.20059636f, 0.01854615f, -0.10551215f, -0.04805031f, -0.05830768f, -0.05726575f, 
    0.17039859f, -0.11009973f, -0.41631028f, 0.09208301f, -0.10905758f, 0.00406194f, 0.05394937f, 0.07033061f, 
    -0.11651592f, -0.06730862f, -0.04845447f, 0.04263664f, -0.07783653f, 0.40042442f, 0.03512268f, 0.15097305f, 
    0.09325132f, 0.02892775f, 0.09913039f, 0.06768686f, 0.14178717f, -0.00795648f, 0.26234362f, 0.21662976f, 
    -0.35289201f, -0.50391763f, -0.48183990f, 0.21569292f, -0.03078629f, 0.05085961f, 0.15243047f, -0.29859656f, 
    0.09503711f, -0.07735404f, -0.11669412f, 0.09369032f, 0.15049376f, 0.01984826f, -0.08534565f, 0.07263993f, 
    0.02879216f, -0.38984209f, -0.00363923f, 0.18079364f, 0.05692181f, -0.26134524f, 0.00538890f, -0.03185682f, 
    -0.10539754f, 0.54828203f, -0.48306590f, -0.14268422f, -0.15949616f, -0.17880142f, 0.14005329f, 0.39528120f, 
    -0.10910382f, -0.06117329f, 0.21157572f, 0.14264879f, -0.07300797f, -0.16240808f, -0.36909652f, -0.19527002f, 
    -0.20585817f, -0.03140566f, 0.03541958f, -0.02552189f, 0.02753490f, 0.01467160f, -0.06077974f, -0.00716462f, 
    0.48267400f, 0.29888380f, -0.14821787f, -0.02045167f, 0.06154945f, 0.00161033f, -0.31884781f, 0.27610639f, 
    0.24292369f, -0.05830789f, -0.06424239f, -0.03466060f, -0.09335468f, -0.10884330f, 0.25536865f, 0.11406504f, 
    0.08137923f, -0.10244343f, 0.09027192f, 0.03695787f, -0.14455418f, 0.20134209f, 0.06565397f, -0.21996936f, 
    0.29120842f, 0.30255154f, 0.13235417f, -0.09495545f, 0.08219261f, -0.04411017f, 0.03704084f, 0.02156646f, 
    0.06580070f, 0.32397863f, 0.32284871f, -0.05665734f, 0.65214002f, 0.38230830f, -0.05107850f, 0.00541763f, 
    -0.01228405f, -0.05962378f, -0.05026511f, 0.05234031f, -0.14878896f, -0.01953049f, 0.15305316f, 0.07218205f, 
    -0.51103264f, -0.06360701f, 0.10208649f, -0.02651140f, 0.06623541f, 0.34449214f, 0.09995183f, 0.05922156f, 
    0.00587584f, -0.00348571f, -0.04452991f, 0.03420817f, -0.49100736f, 0.21460499f, 0.29634634f, 0.17691474f, 
    -0.25312343f, 0.01666453f, -0.19344649f, 0.11764627f, -0.01340792f, 0.04845393f, 0.05255618f, -0.02505459f, 
    -0.19570521f, -0.02176253f, 0.12398101f, 0.07535792f, 0.08414300f, 0.08333191f, -0.14156224f, -0.05350656f, 
    -0.03307413f, 0.09139217f, -0.00436913f, 0.04019074f, 0.01562410f, 0.05370488f, -0.00827149f, 0.06234317f, 
    -0.03092173f, 0.05685072f, 0.04590424f, -0.05352072f, -0.00560499f, -0.20332780f, 0.11918840f, 0.00306945f, 
    -0.14479360f, -0.01547820f, -0.75671327f, -0.41848740f, -0.08284608f, -0.01104374f, 0.09358187f, 0.21968834f, 
    -0.17445859f, -0.10740232f, 0.12455171f, 0.04839148f, -0.63076532f, -0.55884135f, 0.26398188f, 0.03604363f, 
    0.13533337f, 0.10187957f, 0.10804708f, -0.31594273f, 0.10187498f, 0.04714797f, 0.04060621f, 0.10697800f, 
    0.04083297f, -0.03134992f, -0.10020632f, -0.39827374f, -0.03853460f, -0.02798035f, 0.12056202f, 0.00731977f, 
    0.08719953f, 0.10775781f, 0.20563504f, 0.29094940f, 0.27381790f, -0.56220227f, -0.36569598f, -0.45185393f, 
    -0.09610958f, 0.18698040f, 0.32542115f, -0.22706452f, -0.06112950f, -0.03265878f, 0.05077809f, -0.02556938f, 
    -0.81955236f, -0.82402790f, -0.42275164f, -0.20360383f, -0.37275580f, -0.08803361f, -0.17190592f, -0.28169852f, 
    -0.01086158f, -0.05395078f, 0.02709985f, -0.11995330f, -0.49462369f, 0.45986500f, -0.01100012f, -0.06162485f, 
    -0.05124968f, 0.00830306f, 0.11087344f, -0.01467716f, 0.08757495f, 0.03899546f, 0.16863863f, 0.25938842f, 
    -1.15562940f, -0.53124148f, -0.01967152f, 0.16000648f, -0.19048986f, -0.15452828f, -0.08008776f, 0.14633240f, 
    0.03646652f, 0.03795668f, 0.07391784f, -0.10571216f, -0.62084532f, -0.68067503f, -0.09703242f, -0.44354656f, 
    -0.28979483f, -0.32996222f, -0.02719227f, -0.23253402f, -0.00620327f, 0.03355229f, -0.01274266f, -0.04484473f, 
    -0.93053526f, 0.03783786f, 0.45837426f, 0.51742703f, -0.13019064f, 0.13854352f, -0.24098301f, 0.00079196f, 
    0.00352248f, 0.12039113f, 0.14313141f, -0.09773318f, -0.09257209f, -0.10907127f, -0.12480790f, -0.08488841f, 
    -0.29789802f, 0.08920713f, 0.16941300f, 0.06278713f, 0.04567418f, -0.05853219f, -0.03100155f, 0.03925439f, 
    0.16514878f, 0.01101246f, -0.10056788f, -0.10883411f, -0.01934196f, -0.06588617f, 0.01334012f, -0.00462522f, 
    -0.22787549f, 0.05362165f, -0.19697469f, 0.01395690f, -0.92949694f, -0.67973840f, -0.06003654f, -0.29771969f, 
    0.01185282f, 0.02845819f, -0.23930533f, -0.30858698f, 0.05437113f, -0.01186074f, 0.01634732f, -0.01026468f, 
    0.07533802f, -0.08021948f, -0.04843949f, -0.59025127f, 0.02506876f, 0.10205010f, 0.14245488f, -0.00547800f, 
    -0.06944205f, 0.09361168f, -0.14974152f, 0.02116733f, 0.11578587f, 0.07499113f, -0.08631097f, -0.27646446f, 
    -0.02623797f, 0.07317162f, 0.01533088f, -0.01587716f, -0.07196188f, -0.01658291f, 0.04041183f, 0.01151692f, 
    0.32549274f, -0.11069702f, -0.03225280f, -0.20801423f, 0.11436551f, 0.05767290f, 0.05492375f, -0.12080790f, 
    0.10241982f, -0.01843787f, -0.08344106f, -0.30538484f, 0.37026238f, -0.65506858f, 0.48945177f, 0.38113937f, 
    -0.12513533f, 0.03137928f, -0.20608470f, -0.11630713f, 0.01508127f, -0.06959096f, -0.01321604f, -0.04992976f, 
    -0.65189016f, -0.61711377f, -0.25813681f, -0.13352819f, 0.03807985f, 0.01246560f, 0.02861097f, 0.00442932f, 
    0.07779372f, 0.07695626f, -0.04087551f, 0.00120860f, 0.03200341f, 0.07346712f, 0.06831352f, -0.11804900f, 
    0.06075145f, -0.05299027f, 0.05022077f, -0.01564939f, 0.10678612f, -0.02096423f, 0.09681965f, -0.03248041f, 
    0.14201990f, -0.17253023f, -0.05627805f, -0.20837955f, 0.00070760f, 0.12850989f, -0.01994320f, 0.00467752f, 
    0.05282974f, 0.08835863f, 0.03360201f, -0.05787614f, -0.11199214f, -0.11166492f, 0.09275749f, -0.07631704f, 
    -0.00961976f, 0.07428005f, 0.12446321f, -0.10447232f, -0.21374907f, -0.03263878f, -0.22005598f, -0.06966493f, 
    -0.67796892f, -0.01776725f, 0.27027482f, -0.16465150f, 0.19136593f, -0.01320112f, 0.01947098f, 0.05496432f, 
    0.05786866f, -0.12419583f, 0.04020759f, 0.04740464f, 0.00761841f, 0.00399594f, 0.09397653f, -0.06953140f, 
    -0.07712028f, -0.28025711f, 0.14418216f, -0.08148143f, -0.02193638f, -0.00256278f, 0.06049605f, -0.04122032f, 
    -0.15970995f, -0.12636033f, -0.16049157f, -0.03184614f, -0.00765704f, -0.11751761f, 0.05232646f, 0.01733981f, 
    -0.00074741f, 0.27910668f, -0.00030889f, -0.12394707f, 0.23142712f, 0.01719750f, -0.04139636f, 0.25083867f, 
    0.12796183f, -0.19161147f, -0.02217701f, 0.00564301f, -0.03324046f, 0.05793033f, -0.03506752f, 0.00079218f, 
    -0.23127326f, -0.25235292f, 0.05687527f, -0.11079530f, -0.07319351f, -0.08533660f, -0.06392779f, 0.00491185f, 
    -0.07153182f, 0.02926886f, -0.00516250f, 0.02666126f, 0.41415411f, -0.08159167f, -0.04054043f, -0.49687809f, 
    -0.02899856f, -0.03944902f, 0.08002012f, 0.07098936f, -0.06731636f, 0.04700357f, 0.08037826f, -0.23477496f, 
    -0.24741954f, 0.27545628f, 0.02607980f, 0.30099276f, 0.00027155f, -0.00627313f, 0.18748797f, 0.04641321f, 
    0.15817390f, 0.16294977f, 0.06754791f, -0.16035141f, -0.52784830f, -0.36132449f, -0.09836092f, 0.00956457f, 
    0.03624662f, -0.00658716f, 0.01736531f, 0.03461165f, -0.14756259f, -0.02724244f, 0.18236901f, -0.03257338f, 
    -0.43746814f, -0.32398701f, -0.25628614f, -0.18228009f, -0.05800712f, 0.23368068f, 0.16942658f, 0.05696110f, 
    0.10941453f, 0.03723178f, -0.04648623f, 0.05321158f, 0.80275428f, 0.04065971f, -0.36345747f, -0.25878033f, 
    0.09503695f, -0.24610518f, -0.12462273f, -0.07337852f, 0.06609590f, 0.03998304f, 0.03775710f, 0.05146449f, 
    -0.02346357f, 0.03299370f, 0.23021722f, -0.14265361f, 0.10259511f, -0.03688719f, 0.17549513f, 0.02172356f, 
    -0.00560629f, -0.13821679f, 0.03627929f, 0.05076766f, 0.01388160f, -0.02230578f, -0.33149108f, 0.13485536f, 
    0.07529780f, 0.04435420f, 0.04896594f, -0.17679718f, -0.09202582f, 0.07800328f, -0.07194477f, -0.01585737f, 
    -0.19100717f, -0.74275815f, -0.23460093f, 0.04774135f, -0.21829036f, -0.11552599f, -0.02687584f, -0.08204106f, 
    0.23563842f, -0.06715319f, -0.10331687f, -0.10844068f, -0.12324630f, 0.73896301f, -0.01972301f, 0.08049595f, 
    0.00908018f, -0.12846468f, 0.19445986f, 0.05925304f, -0.21733440f, -0.12721914f, 0.09030785f, -0.22720380f, 
    0.32123810f, 0.17465933f, -0.28450269f, -0.09705933f, 0.02035973f, -0.02011943f, -0.08348770f, 0.01037582f, 
    -0.02334396f, 0.12285663f, 0.17164493f, 0.10722548f, -0.16809081f, 0.26915559f, -0.13931432f, -0.08047533f, 
    -0.06049317f, 0.04421167f, -0.10286225f, 0.12507860f, 0.03151052f, 0.01887040f, 0.03438674f, 0.02004595f, 
    -0.62915111f, -0.69564497f, -0.07883239f, 0.39905122f, 0.10914874f, 0.04480461f, 0.04761313f, -0.00420478f, 
    0.03413469f, -0.03568545f, -0.08017106f, -0.09817937f, -0.17809446f, -0.14170508f, -0.20043577f, -0.25555384f, 
    -0.13795951f, -0.20515747f, 0.01538530f, -0.05227649f, 0.03795903f, 0.07354873f, 0.07768219f, 0.08607745f, 
    -1.14206028f, 0.41707149f, -0.80775189f, -0.17991617f, 0.28490254f, -0.07614856f, 0.36362419f, -0.01080454f, 
    -0.02478505f, -0.02723427f, -0.07910276f, -0.03467702f, -0.54760426f, -0.11621127f, -0.28121620f, 0.29123843f, 
    0.01789042f, -0.15445091f, -0.07136820f, 0.10409560f, 0.06587296f, 0.04214321f, -0.04846878f, -0.05302330f, 
    0.42880943f, -0.95786089f, -0.52558386f, -0.48171285f, -0.07965479f, -0.31240153f, 0.01843026f, 0.22638616f, 
    0.08912496f, 0.00623086f, -0.00293151f, -0.10221537f, 0.05293236f, -0.04898710f, -0.06547179f, -0.08577134f, 
    0.01334196f, -0.09363372f, -0.01025513f, -0.21504892f, -0.02028090f, 0.04089287f, 0.12533975f, 0.03827315f, 
    0.02757441f, 0.05661116f, 0.07181293f, -0.04836192f, -0.05708252f, 0.04633215f, -0.03964620f, 0.02067405f, 
    -0.09783866f, -0.42030320f, 0.06685907f, 0.00167212f, -0.83365607f, 0.24367000f, 0.18859480f, 0.56004202f, 
    0.12800196f, -0.02970259f, 0.06124144f, 0.02234934f, -0.08617940f, -0.11016089f, 0.03651107f, -0.07173035f, 
    -0.14816201f, 0.17766783f, -0.15318789f, -0.06676240f, 0.05557604f, -0.03656163f, -0.02132190f, 0.03481583f, 
    -0.00795444f, 0.02055720f, 0.03579583f, 0.01348342f, -0.20475852f, 0.14146574f, -0.05255498f, -0.14438514f, 
    0.03140775f, 0.15275668f, 0.02379714f, -0.02127874f, 0.01954352f, 0.04912465f, 0.04471917f, 0.03245198f, 
    -0.11093979f, -0.24547873f, -0.28988594f, -0.24119560f, -0.16135289f, -0.13026845f, -0.02412589f, -0.04488098f, 
    0.06215754f, -0.02788912f, 0.15543079f, -0.03797571f, 0.59153533f, 0.11251631f, -0.26105055f, -0.49175549f, 
    0.28293177f, 0.01242213f, 0.05528641f, -0.16756268f, 0.04593111f, 0.22867700f, 0.26653951f, 0.14313821f, 
    -0.56098932f, -0.54819661f, -0.33585644f, 0.16231777f, 0.03816394f, -0.19451393f, -0.04053253f, -0.14675008f, 
    -0.08604130f, -0.01840416f, -0.05444294f, 0.11764374f, -0.15734489f, 0.05235052f, 0.07900725f, -0.00134109f, 
    -0.01921244f, -0.05615012f, 0.00089551f, -0.00227176f, -0.00773348f, 0.05295349f, -0.07150030f, 0.13170309f, 
    0.36626816f, 0.11609892f, -0.09433225f, -0.08710030f, 0.10610308f, -0.09916893f, 0.00388301f, -0.05431842f, 
    0.00961880f, -0.00570283f, 0.14205483f, 0.02929218f, -0.49427998f, -0.11508480f, 0.24271898f, -0.10944223f, 
    -0.01712233f, 0.05003094f, -0.04076461f, -0.12112186f, 0.19614370f, 0.19718604f, -0.07854343f, 0.19345134f, 
    -0.19943763f, 0.20397867f, -0.03843654f, 0.07461182f, -0.22941305f, 0.15049769f, 0.00929787f, -0.31384403f, 
    0.02145912f, 0.01256014f, -0.04176815f, -0.02524568f, -0.14527971f, -0.12775332f, 0.00262202f, -0.05933961f, 
    0.12861316f, 0.13895798f, 0.08561835f, -0.00031032f, 0.02976266f, 0.17254843f, 0.27666539f, 0.22543053f, 
    0.71071440f, -0.15705551f, -0.48236781f, 0.05874673f, 0.21881425f, 0.02381401f, -0.06254901f, 0.03166904f, 
    0.35039186f, 0.04926439f, 0.09176719f, 0.26470324f, 0.16173920f, 0.16761598f, -0.00578676f, -0.03658856f, 
    0.18331425f, -0.13847695f, -0.14446869f, -0.05633682f, 0.12805580f, 0.12151703f, 0.10197637f, 0.06347496f, 
    -0.17714712f, -0.19732748f, -0.02746302f, 0.08324382f, 0.00161588f, 0.00212317f, 0.03488579f, 0.23477876f, 
    -0.23896028f, -0.14486256f, -0.07438724f, -0.03325823f, 0.33817053f, 0.02967395f, -0.51293200f, -0.30418089f, 
    -0.36118421f, -0.27185923f, -0.05038585f, -0.06755091f, 0.13424645f, -0.02017890f, 0.27398211f, 0.06052537f, 
    -0.59500951f, -0.14872289f, 0.09630238f, 0.24037200f, -0.05027016f, 0.10994548f, -0.19007985f, -0.03380078f, 
    -0.34886554f, -0.23921868f, -0.26599675f, -0.54908061f, -0.63273960f, -0.25341105f, 0.13241588f, 0.16602227f, 
    -0.04288896f, 0.12460710f, 0.05471256f, 0.09608473f, -0.02179039f, -0.09958090f, -0.05859090f, 0.01489810f, 
    0.08724996f, -0.41456026f, -0.34012625f, 0.13342024f, 0.03954545f, 0.14994180f, 0.03613231f, 0.19587928f, 
    -0.20343095f, -0.12803178f, -0.14850008f, -0.12002140f, -0.08464484f, -0.39114797f, -0.37076184f, -0.07593285f, 
    0.05739709f, 0.21192667f, 0.10520349f, 0.12261131f, 0.12995160f, 0.24505769f, -0.06465518f, 0.05949570f, 
    -0.21571118f, -0.27927831f, 0.00492944f, 0.12168624f, -0.14742666f, -0.03714510f, 0.07470449f, -0.04197793f, 
    0.03090716f, 0.06641226f, 0.09596930f, 0.27984715f, 0.02264786f, -0.06768492f, 0.10328501f, -0.09411895f, 
    -0.05412125f, -0.00424715f, -0.06226496f, -0.16601026f, -0.05360463f, -0.00775486f, 0.14010553f, -0.19770147f, 
    1.09935534f, -0.10136129f, -0.16010389f, -0.10300258f, 0.16301687f, 0.11550980f, -0.10995958f, 0.02899273f, 
    0.06887163f, 0.19728501f, -0.21046099f, -0.38872600f, -0.42898479f, -0.07878782f, 0.07373641f, 0.16861489f, 
    -0.16751400f, 0.14208119f, 0.13903837f, 0.22048995f, 0.16199709f, 0.05249606f, 0.00952560f, 0.11197886f, 
    0.32701716f, 0.08625098f, -0.17825623f, -0.29846603f, 0.05893735f, -0.01613458f, 0.06240046f, 0.06852079f, 
    -0.04072731f, 0.04951234f, 0.08521743f, -0.37232569f, -0.64638263f, 0.17868772f, 0.31911892f, 0.00475856f, 
    0.38249481f, -0.20930770f, -0.15725903f, -0.10643565f, -0.05210271f, -0.14718243f, 0.07083932f, -0.08454262f, 
    0.05317751f, -0.59666717f, -0.07768558f, -0.23277028f, -0.16686082f, -0.19280569f, -0.09246234f, -0.04242714f, 
    -0.03971410f, 0.02471499f, 0.01688021f, 0.05530633f, -0.28633249f, -0.61530751f, -0.00560630f, 0.18446024f, 
    0.12972307f, 0.10410257f, 0.09462185f, 0.07954647f, -0.24517132f, -0.14284010f, -0.19377318f, -0.44545928f, 
    -0.05098462f, -0.74423605f, -0.24702610f, 0.34090114f, -0.19665124f, 0.05362216f, 0.10586458f, 0.01994167f, 
    -0.00870615f, 0.05303522f, 0.05162244f, 0.18980214f, -0.50199658f, -0.36813021f, -0.00761056f, 0.12391225f, 
    -0.15758653f, -0.08517654f, -0.13277124f, -0.09085821f, 0.00224882f, -0.05209420f, 0.04190103f, 0.02355054f, 
    -0.29039711f, -0.56960237f, -0.34343556f, 0.09359024f, 0.02031379f, 0.26898333f, 0.03981320f, -0.02468047f, 
    0.02292178f, -0.02527681f, 0.00505161f, -0.03758903f, -0.08432443f, 0.06734530f, -0.14658938f, -0.01932390f, 
    0.32551822f, -0.00946765f, 0.13975337f, -0.14158064f, 0.05271201f, -0.04024294f, -0.09352273f, 0.02300019f, 
    -0.31214094f, -0.03854304f, -0.09291696f, -0.00768107f, 0.01830396f, -0.05822060f, -0.00109061f, -0.01900188f, 
    -0.07549537f, -0.00284565f, -0.01102187f, 0.16836606f, 0.03781271f, -0.50264388f, -0.36080179f, -0.55100220f, 
    -0.05945098f, 0.05087028f, 0.00323635f, 0.02292932f, 0.18222237f, 0.08680420f, 0.14680727f, 0.07482995f, 
    -0.28053319f, 0.11491603f, 0.00172251f, 0.11123984f, 0.01380372f, -0.01233755f, -0.03033825f, -0.04150554f, 
    -0.03416041f, -0.00680165f, -0.13862990f, 0.07444336f, -0.39562085f, 0.00682922f, 0.17916383f, 0.18566103f, 
    -0.02873894f, -0.10788871f, -0.14212504f, -0.00789688f, 0.00607212f, 0.15162770f, 0.09746665f, 0.10752842f, 
    0.36556199f, -0.04666371f, 0.48040339f, 0.35723764f, 0.23054351f, -0.22067444f, -0.11013413f, -0.11491007f, 
    -0.07398299f, 0.08157089f, -0.09950460f, 0.02187065f, 0.20421532f, -0.09454672f, -0.13086908f, 0.03816186f, 
    -0.06095137f, -0.08151515f, -0.25383258f, -0.13651910f, 0.10779180f, -0.14488570f, 0.02176135f, -0.06966336f, 
    -0.18299524f, 0.17623420f, -0.36546791f, -0.13825054f, -0.34270111f, 0.20312320f, 0.13815300f, 0.12546784f, 
    0.06929447f, -0.09579557f, 0.02319792f, -0.10656543f, 0.10530026f, -0.52791101f, -0.02603610f, -0.18411207f, 
    0.17378552f, 0.19124423f, 0.06148914f, 0.12409651f, 0.13990000f, -0.02206952f, 0.08550054f, 0.10865510f, 
    -0.15591460f, -0.17076837f, -0.27760381f, 0.24374902f, 0.10985442f, 0.12429211f, 0.08909813f, -0.12498564f, 
    0.02994105f, 0.03024574f, 0.00612073f, 0.10971862f, 0.28399798f, -0.18153645f, 0.19383065f, 0.02253713f, 
    -0.00263311f, -0.07979966f, -0.18434581f, -0.17487167f, -0.13754724f, 0.02721614f, 0.02244285f, -0.24145493f, 
    0.17490813f, 0.01293922f, -0.01775207f, -0.10664288f, -0.17435750f, 0.04100168f, -0.01208726f, 0.16346601f, 
    -0.03384659f, 0.17753749f, -0.03309016f, -0.11275338f, 0.00142053f, 0.06707213f, -0.02740301f, -0.21653552f, 
    0.11125102f, -0.28750372f, 0.19888903f, -0.19970402f, -0.00017161f, 0.01186221f, -0.09267138f, -0.04305883f, 
    -0.53646076f, -0.24206723f, 0.37782472f, -0.11615211f, 0.23378496f, -0.50298357f, 0.01847501f, -0.22331218f, 
    -0.20238195f, -0.08622462f, -0.03901674f, -0.01869910f, -0.31251651f, -0.19601643f, -0.36568263f, 0.13308060f, 
    0.04575176f, 0.05813918f, 0.13557972f, -0.02169414f, -0.00830663f, -0.18325518f, -0.09784518f, -0.12318932f, 
    0.01220371f, 0.40729123f, 0.59960574f, -0.67909443f, -0.15382944f, -0.13201673f, 0.09791400f, -0.17226626f, 
    -0.20696877f, 0.10655459f, 0.02624030f, 0.06896262f, -0.28165287f, -0.41496524f, 0.17934768f, 0.11640979f, 
    0.02700303f, 0.17996313f, -0.42576385f, 0.26336816f, 0.04318666f, 0.01085949f, -0.01061740f, -0.12565188f, 
    -0.06271640f, 0.20747009f, 0.18919349f, -0.24411343f, -0.01372524f, 0.06759475f, 0.19026676f, 0.08849873f, 
    0.22246359f, 0.20336702f, 0.18331645f, 0.23608202f, 0.01913146f, 0.34963322f, 0.77216637f, -0.68007219f, 
    -0.07649783f, -0.26752901f, -0.01942478f, -0.08362752f, -0.11289538f, 0.17576215f, 0.21114700f, 0.06776309f, 
    -0.06283925f, -0.11991384f, 0.05173179f, -0.36447710f, -0.31439066f, -0.15610072f, 0.05407024f, -0.16192646f, 
    0.21264404f, 0.01863656f, 0.13901727f, 0.11917764f, -0.00456711f, 0.28631473f, 0.25346819f, 0.32123128f, 
    0.19146401f, -0.41583407f, -0.16897744f, -0.14535213f, 0.09164649f, -0.06559982f, -0.11444834f, 0.06646897f, 
    0.33854848f, -0.39164358f, 0.42729175f, -0.37873694f, 0.16360207f, 0.00138449f, -0.40725863f, -0.02290975f, 
    -0.09450221f, 0.08733813f, -0.10033204f, 0.11010295f, -0.17398934f, -0.04848037f, -0.12875128f, -0.03896689f, 
    0.19090380f, 0.03964463f, -0.10693057f, 0.14506693f, -0.02680165f, -0.03206106f, 0.05044109f, 0.10227621f, 
    -0.26739386f, -0.11142880f, 0.23694211f, 0.11643863f, 0.10512172f, -0.10161107f, -0.03331450f, -0.22236913f, 
    0.21803701f, 0.08179352f, 0.07099535f, 0.07337786f, -0.61576664f, -0.22005151f, 0.05982806f, -0.48429617f, 
    -0.23310819f, 0.05860220f, -0.23792197f, 0.03265995f, 0.10932128f, 0.01396136f, -0.15454550f, 0.16532601f, 
    -0.76862603f, -0.27155954f, -0.05263917f, 0.41345409f, 0.06214277f, 0.20394334f, 0.03781775f, 0.06292041f, 
    -0.14820826f, 0.19695987f, -0.07601839f, 0.12622055f, 0.10294423f, 0.22877476f, -1.10622489f, -0.03039242f, 
    0.10801481f, 0.00589363f, 0.27664745f, 0.26959097f, 0.03090689f, -0.14261502f, 0.02744390f, 0.00930580f, 
    0.01759268f, 0.10909440f, 0.07883328f, -0.14353922f, 0.03844592f, -0.06569384f, 0.09012777f, 0.21795236f, 
    0.04547761f, 0.08568423f, 0.02491935f, -0.10460001f, 0.35484463f, -0.35383630f, 0.25234360f, -0.59423018f, 
    0.02638199f, 0.03861314f, -0.08091608f, 0.02269551f, -0.06480534f, 0.02266685f, 0.15812850f, 0.08922748f, 
    0.02758653f, -0.42460889f, -0.13948201f, -0.36004353f, 0.02356806f, -0.31288666f, 0.00315916f, 0.17568980f, 
    -0.04844177f, 0.02365274f, 0.07187508f, -0.01850139f, -0.68861246f, 0.30042201f, 0.10811307f, -0.33946812f, 
    -0.15484695f, -0.16100574f, 0.19508131f, 0.30795115f, 0.10383841f, 0.02457217f, 0.04387309f, -0.06828886f, 
    -0.11335576f, 0.01680747f, 0.22794084f, -0.17322995f, 0.00796694f, -0.22477625f, -0.01427832f, -0.05721087f, 
    0.04826811f, 0.08190582f, 0.14668335f, 0.10984945f, 0.05111506f, -0.27334797f, -0.45533127f, -0.03563114f, 
    0.15506130f, -0.01812429f, -0.35819021f, 0.00640715f, 0.12495802f, -0.08542110f, 0.01410428f, 0.08225170f, 
    -0.05711329f, 0.01738952f, -0.08862133f, 0.05303522f, 0.02711832f, 0.08339220f, 0.07724381f, 0.04994304f, 
    0.03094625f, -0.01693449f, 0.19366188f, 0.16015708f, 0.14695789f, 0.07279504f, -0.11438773f, -0.23685493f, 
    -0.11494842f, -0.09418516f, -0.04848788f, 0.07423835f, 0.17214753f, 0.11761549f, -0.08973373f, -0.15050881f, 
    -0.40756109f, -0.11148167f, -0.58106524f, 0.50359225f, 0.10812001f, 0.06227342f, 0.08127691f, 0.02247391f, 
    -0.00483145f, -0.00081111f, -0.07020597f, -0.13655226f, -0.36689243f, -0.11888523f, -0.12235774f, -0.00124491f, 
    0.02856776f, 0.05183873f, 0.19439097f, 0.00246204f, -0.01649443f, -0.12138480f, -0.18718889f, -0.13576537f, 
    -0.37543437f, 0.50005651f, -0.03528925f, -0.13873918f, 0.01116800f, 0.01494656f, 0.13685839f, 0.00814806f, 
    0.15712638f, -0.10589797f, 0.30030173f, 0.10141536f, -0.27477226f, 0.23788600f, -0.22813295f, 0.13243955f, 
    0.02007613f, 0.38860756f, 0.53565693f, 0.15226422f, -0.26540679f, -0.06771079f, -0.07539988f, 0.25433373f, 
    -0.08468353f, 0.05584326f, 0.26702085f, 0.26964197f, -0.09955847f, 0.07463655f, -0.04101777f, 0.14613494f, 
    -0.01993337f, 0.11754774f, 0.10338782f, 0.11873136f, -0.14427732f, -0.10042337f, 0.15780234f, -0.14495026f, 
    -0.06791384f, -0.06542094f, -0.12989895f, 0.00765908f, 0.02638870f, -0.02011519f, -0.04209276f, 0.04663961f, 
    -0.68740284f, 0.17308497f, -0.28911686f, -0.37605029f, -0.60640329f, -0.06431358f, 0.13532497f, -0.14280081f, 
    0.02167258f, 0.25006592f, 0.21109314f, -0.01262416f, -0.16847093f, 0.16287389f, -0.24067400f, 0.24124140f, 
    0.00817113f, 0.00425221f, -0.00746551f, 0.15147124f, 0.03475471f, 0.10241798f, -0.02285179f, -0.16107774f, 
    0.01197429f, -0.53804004f, -0.22530942f, -0.09911854f, 0.13850631f, 0.11409384f, 0.25977847f, -0.19163139f, 
    0.19104539f, 0.05298157f, -0.08763098f, -0.07619873f, 0.04580783f, 0.14983001f, 0.31377444f, 0.14305346f, 
    -0.20524524f, 0.03467431f, 0.26910904f, -0.16663474f, 0.14768215f, 0.15738608f, 0.31712025f, 0.22239800f, 
    -0.77260804f, 0.43090957f, 0.19544953f, 0.08541613f, -0.09433597f, 0.10189790f, -0.18738031f, 0.57229996f, 
    0.04098225f, -0.09002509f, 0.21766105f, -0.07100509f, 0.04835238f, -0.21636833f, 0.26452926f, 0.03056334f, 
    -0.13794276f, 0.11049484f, 0.08444609f, 0.04707927f, 0.05267024f, 0.11728240f, 0.16084059f, 0.15511324f, 
    -0.19659972f, 0.10790415f, -0.19058236f, 0.29871729f, 0.07138177f, -0.13508442f, 0.10719229f, 0.09989423f, 
    0.02795331f, -0.01397672f, 0.11178584f, 0.07940745f, -0.44600481f, 0.15216285f, 0.12580547f, 0.18788643f, 
    0.09816089f, 0.24440286f, -0.33453643f, -0.02452321f, -0.10121219f, -0.09691155f, 0.06665049f, -0.03409319f, 
    0.22435883f, -0.18309036f, 0.00478586f, 0.11605845f, 0.11520262f, -0.08454844f, -0.10520484f, 0.06158874f, 
    -0.38403487f, -0.18395162f, -0.38954267f, -0.35463783f, -0.03050847f, 0.06381340f, 0.20051670f, -0.04977381f, 
    -0.05453856f, -0.01290606f, -0.06727210f, 0.01150215f, 0.08637825f, -0.04486590f, -0.13850980f, -0.21857066f, 
    0.09965988f, -0.18096854f, -0.10991512f, -0.04389296f, 0.21311815f, -0.23032251f, -0.04568774f, -0.06585983f, 
    -0.16596726f, 0.14508225f, -0.15096062f, -0.30533364f, 0.32176143f, 0.15796076f, 0.20965770f, 0.00010583f, 
    -0.24674924f, -0.05681178f, 0.19368581f, 0.15679388f, 0.00639873f, -0.02683832f, 0.00373913f, 0.18649624f, 
    -0.26669097f, 0.34441701f, 0.17795338f, 0.12818594f, -0.09010153f, -0.12184157f, 0.05680932f, 0.08032394f, 
    -0.15252049f, 0.08994792f, -0.00542553f, 0.25622660f, -0.24606463f, 0.31004909f, 0.37526822f, -0.04705894f, 
    -0.07124281f, -0.03628727f, -0.29626608f, 0.14876613f, 0.07173393f, -0.06145250f, -0.08796045f, -0.19701254f, 
    -0.75216156f, 0.43028799f, 0.30010277f, 0.03936810f, 0.00336546f, -0.06017242f, 0.26831999f, 0.41355133f, 
    -0.24789490f, -0.15092002f, -0.50204426f, -0.32873955f, 0.63735014f, -0.38786450f, 0.50610936f, 0.19057627f, 
    -0.11733472f, 0.17145850f, 0.03849668f, 0.22964761f, -0.04396030f, 0.01047986f, 0.04315038f, 0.05858821f, 
    0.46191001f, -0.18617244f, 0.25570846f, -0.10988394f, -0.06137394f, 0.03416508f, -0.07534803f, -0.13402887f, 
    0.02861358f, -0.21080150f, -0.40239426f, -0.36966690f, -0.21391377f, -0.67358613f, -0.06283651f, -0.26455808f, 
    0.07416572f, -0.24504933f, 0.06728765f, 0.03410795f, -0.25343403f, 0.15412836f, -0.12637746f, -0.06560486f, 
    -0.33150148f, -0.28726342f, -0.64139175f, 0.24630609f, 0.06821997f, -0.21778408f, -0.02484676f, -0.10762391f, 
    -0.01306005f, 0.07356139f, -0.02585586f, 0.01356639f, -0.22224870f, 0.18585718f, -0.40389296f, 0.23057669f, 
    0.13388476f, -0.07096933f, -0.05601946f, 0.22468154f, 0.05973400f, -0.14193158f, -0.51805043f, -0.63635236f, 
    -0.14855757f, -0.45847380f, 0.00144706f, 0.17843986f, -0.08344617f, 0.11735168f, -0.02982677f, -0.02901317f, 
    0.17820249f, 0.07143707f, -0.13994591f, 0.22514778f, 0.02156297f, -0.73550981f, 0.04223934f, 0.11579734f, 
    -0.23274095f, 0.07270382f, 0.20338595f, 0.10089666f, -0.00621589f, -0.01943974f, -0.01784927f, 0.12121612f, 
    -0.11459175f, 0.02281384f, -0.02978138f, -0.12707423f, 0.02357855f, 0.06576742f, -0.24449307f, -0.06606407f, 
    -0.09384803f, 0.00550282f, -0.20771585f, -0.62915951f, -0.04053418f, 0.22820328f, -0.13519058f, 0.02248738f, 
    -0.04882858f, 0.11564995f, 0.18024729f, -0.10798529f, -0.13752869f, 0.00573021f, 0.04002857f, -0.10345006f, 
    -0.12301046f, -0.23171921f, -0.21792190f, -0.22609815f, -0.12203840f, -0.18022570f, -0.15542443f, 0.01582311f, 
    -0.27914333f, -0.12174511f, 0.14147408f, -0.18891922f, -0.25214893f, -0.02209146f, -0.26848251f, 0.36934778f, 
    0.02254451f, 0.05387070f, -0.11423545f, 0.07081842f, 0.12182522f, 0.21462137f, 0.06284571f, -0.04402688f, 
    -0.03580356f, 0.01832100f, 0.07822430f, -0.04406226f, -0.19982210f, -0.03759188f, 0.05478083f, -0.11763029f, 
    0.00272457f, 0.06073015f, 0.06929111f, 0.05588663f, 0.26746595f, 0.05370406f, -0.18582085f, 0.38475293f, 
    -0.17292185f, -0.12216298f, -0.00580894f, -0.09668803f, 0.10720932f, 0.15166515f, -0.25950581f, 0.19001098f, 
    -0.53205097f, 0.03900352f, -0.49242589f, 0.47234592f, 0.09116068f, 0.12377809f, -0.04228641f, -0.02978010f, 
    0.04622939f, 0.19710374f, -0.02864825f, 0.03606066f, -0.13340183f, 0.25006157f, -0.00760628f, 0.67943251f, 
    0.13090332f, -0.23019503f, 0.38458422f, -0.05871240f, 0.07022698f, 0.04966713f, 0.15897988f, 0.04887473f, 
    -0.20115179f, 0.01801140f, 0.44550568f, 0.13493468f, -0.11340912f, -0.01029564f, -0.24004038f, -0.01008816f, 
    0.05132141f, -0.09453694f, -0.11988070f, -0.28373209f, -0.06914140f, 0.22443582f, -0.10176616f, 0.12239089f, 
    -0.09839909f, 0.11646117f, 0.12718618f, -0.17493147f, -0.12964089f, -0.10266957f, -0.04906091f, -0.13932803f, 
    0.50435340f, 0.05401936f, 0.22677714f, -0.30139944f, 0.05039838f, 0.09874055f, 0.18710831f, 0.11149283f, 
    -0.10529827f, -0.02486279f, -0.05412008f, -0.15288854f, -0.49284574f, -0.19638246f, -0.12217323f, 0.28389516f, 
    -0.12501694f, 0.04301446f, 0.05346925f, 0.18185918f, -0.23081641f, -0.07693963f, 0.07626969f, 0.16861926f, 
    -0.21203633f, -0.42589074f, 0.12453587f, 0.13538021f, -0.27719191f, -0.23569094f, -0.19409621f, -0.08166953f, 
    0.04659966f, 0.19127990f, 0.00871153f, 0.05307651f, 0.14365196f, -0.10819079f, 0.00998954f, -0.03141459f, 
    0.08097744f, 0.16950451f, -0.12040283f, 0.26294458f, -0.09462311f, -0.28387138f, -0.17139299f, -0.07575423f, 
    -0.07241596f, -0.44568807f, 0.51564986f, 0.14379688f, 0.03798994f, -0.09195381f, -0.20128408f, 0.17996496f, 
    -0.20484763f, -0.05059409f, -0.02389777f, -0.04323615f, -0.13292851f, -0.06022413f, 0.24067961f, -0.49137658f, 
    0.19781567f, 0.11061693f, -0.12574728f, -0.03030126f, -0.25826293f, -0.07052013f, -0.12078099f, -0.17123424f, 
    -0.14463191f, -0.09394114f, 0.21705732f, 0.10952253f, -0.17030337f, 0.06089194f, 0.02945863f, -0.15119144f, 
    0.13211051f, 0.15234341f, -0.13565364f, 0.02011159f, -1.06433916f, 0.25114077f, -0.38381612f, 0.15273623f, 
    0.16554481f, 0.11156183f, 0.12907748f, 0.01819064f, -0.08022443f, 0.04287526f, 0.02985610f, 0.05121592f, 
    0.06265613f, -0.06189290f, 0.12760164f, -0.19488682f, 0.05138760f, 0.09557786f, -0.04543980f, 0.11677867f, 
    -0.06903744f, 0.24021240f, 0.25125942f, 0.19371678f, -0.38199973f, -0.10540567f, -0.25336686f, 0.18716122f, 
    -0.08879584f, -0.03279880f, 0.09780777f, 0.09714044f, -0.17917189f, -0.09213037f, -0.19091333f, 0.11468793f, 
    0.05576130f, 0.17523685f, -0.26623484f, -0.28711152f, -0.17938961f, -0.15487982f, 0.29626319f, -0.05934391f, 
    0.05631489f, 0.08110275f, 0.00901853f, -0.11771408f, -0.30233195f, -0.36161137f, 0.16149916f, 0.09020764f, 
    0.07036521f, -0.03094688f, -0.11403498f, 0.08267058f, -0.16362914f, -0.01890743f, 0.09329882f, -0.26802868f, 
    -0.46063462f, 0.28041446f, -0.58754534f, 0.49243119f, -0.18562676f, 0.12266765f, 0.10026683f, 0.37427431f, 
    -0.07454418f, -0.07924703f, 0.08873012f, -0.26326251f, -0.03855816f, -0.00414177f, -0.03258176f, -0.11882225f, 
    -0.07714469f, -0.15547274f, 0.29892331f, 0.07689736f, 0.13069862f, -0.04793879f, -0.18517137f, 0.10059429f, 
    -0.42636225f, -0.34013933f, -0.14219588f, -0.15768354f, 0.27736700f, 0.08257363f, 0.19035554f, 0.12481282f, 
    0.04238253f, 0.10323380f, 0.28667492f, 0.03979488f, -0.63040531f, 0.29838714f, -0.30770245f, 0.12112276f, 
    0.02025896f, 0.14867251f, 0.14537336f, -0.18032277f, -0.00500891f, 0.27645966f, 0.02381481f, -0.00078213f, 
    -0.21626429f, -0.31314501f, -0.04187852f, -0.19992317f, 0.17137249f, 0.06838819f, 0.00167017f, -0.05403825f, 
    0.13804406f, 0.08261348f, 0.03914662f, 0.14969434f, 0.80349714f, 0.18583007f, 0.35708490f, -0.08490542f, 
    -0.07803548f, 0.05685710f, -0.25219199f, 0.03987089f, -0.10665746f, -0.03186451f, -0.00939357f, -0.02924468f, 
    -0.19873296f, -0.01676911f, -0.43471301f, -0.05568722f, -0.22460242f, -0.15774290f, -0.05922253f, -0.30875021f, 
    0.02371982f, -0.00742827f, -0.05526645f, -0.10429207f, -0.37595749f, -0.24275886f, 0.32420906f, 0.08297587f, 
    -0.02253501f, -0.09240311f, -0.02464155f, 0.06332569f, -0.10606702f, 0.19059096f, 0.08326612f, 0.08474828f, 
    -0.02932473f, -0.27026734f, 0.61251211f, -0.79772013f, 0.03742408f, 0.12333985f, -0.26708776f, -0.00162851f, 
    -0.02348764f, -0.05439295f, 0.09580826f, 0.02016360f, -0.03543543f, 0.03965381f, -0.00925395f, -0.09313931f, 
    -0.06119576f, -0.22324693f, -0.10684519f, 0.00880754f, -0.00416995f, 0.10506855f, -0.05020566f, -0.14581329f, 
    -0.15968318f, 0.10313604f, -0.13343127f, -0.74575120f, 0.14489026f, -0.01250805f, 0.08720516f, 0.00169066f, 
    0.03998261f, 0.07648388f, 0.11340072f, 0.05915301f, 0.20791188f, 0.00397397f, 0.23997359f, -0.11522534f, 
    -0.00200835f, 0.10953717f, 0.00253341f, 0.01247862f, -0.11317180f, -0.05310024f, -0.14660886f, -0.02828071f, 
    0.18158168f, -0.03636786f, 0.02245306f, -0.01525190f, -0.12229771f, -0.02404252f, 0.14030434f, 0.12260651f, 
    0.03915311f, 0.14118515f, 0.06532867f, -0.16577643f, -0.70926917f, -0.46539342f, -0.08177953f, 0.18644556f, 
    -0.26020494f, -0.17179765f, -0.07003596f, -0.22874787f, 0.02850255f, 0.12875021f, -0.05579330f, 0.05699077f, 
    0.33941722f, -0.08283430f, 0.42102218f, 0.22532091f, 0.03422539f, -0.10101237f, -0.08536211f, 0.00919783f, 
    -0.17177695f, 0.08859964f, -0.09072460f, -0.09732229f, -0.06513264f, -0.10150055f, 0.48684955f, -0.16119407f, 
    -0.02405374f, 0.04963945f, -0.01192053f, -0.12015310f, -0.08948623f, -0.12849669f, 0.04586725f, -0.08842434f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15766697f, 0.08127135f, 0.05427750f, -0.13041174f, -0.14347735f, 0.12296623f, 0.08426597f, -0.15224943f, 
    0.08242711f, -0.02599570f, 0.08191591f, 0.01401642f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
