#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.16365042f, -0.28791350f, -0.05570615f, -0.06931750f, 0.06665410f, 0.26488459f, -0.38675690f, -0.30282900f, 
    -0.03701184f, -0.40061086f, -0.26682612f, -0.49058229f, 0.48138231f, -0.18711938f, -0.58271205f, -0.23712212f, 
    -0.24123932f, -0.12402078f, -0.32287708f, -0.22548902f, -0.15120313f, -0.07822844f, -0.16394986f, 0.12234133f, 
    -0.08683999f, -0.65939260f, 0.05723865f, -0.40780813f, -0.62462091f, -0.27062747f, 0.74801695f, 0.09663924f, 
    -0.33211812f, 0.23927194f, 0.42522603f, 0.20748666f, -0.12052646f, 0.11647168f, -0.12818682f, 0.02346996f, 
    0.00931638f, -0.12621565f, 0.31803927f, -0.05578045f, -0.41333371f, -0.19305369f, -0.04013332f, 0.26725239f, 
    0.28033817f, -0.06635321f, -0.82405782f, 0.50363129f, 0.40513751f, 0.13215084f, 0.47934648f, -0.73931456f, 
    0.48104087f, 0.47623911f, -0.69312680f, -0.19413622f, 0.12125944f, 0.10594668f, 0.38513419f, 0.21279754f, 
    0.02992668f, 0.04544380f, 0.14523348f, 0.33726358f, 0.06661300f, 0.10692641f, 0.17747968f, -0.22123034f, 
    -0.11967035f, -0.03435713f, -0.26855150f, 0.72235948f, -0.54438466f, -0.72537667f, -0.55834460f, 0.45472953f, 
    0.47640055f, -0.30309638f, 0.30002102f, 0.44215682f, 0.15716912f, -0.27730459f, -0.13077082f, -0.35152537f, 
    0.11505598f, 0.06484351f, 0.01781893f, -0.19450834f, -0.27749160f, 0.03141471f, 0.11302413f, 0.00229287f, 
    0.06767054f, 0.20185320f, 0.19492248f, -0.38701016f, 0.60567909f, 0.25252071f, 0.34660596f, 0.77586341f, 
    0.52233481f, 0.11233816f, -0.40603629f, -0.45585245f, -0.32666606f, 0.00823702f, 0.25203666f, 0.05647835f, 
    -0.04455240f, 0.23071124f, -0.08189981f, 0.21295251f, 0.06965265f, 0.26744223f, -0.19836913f, 0.53581113f, 
    -0.01567209f, -0.24286723f, -0.00040995f, -0.20750163f, -0.06934406f, -0.27677450f, 0.77381229f, 0.09253810f, 
    -0.42343137f, 0.14346905f, -0.49567300f, 0.10242262f, 0.65960264f, 0.04843896f, -0.39477223f, -0.00889729f, 
    -0.05333606f, -0.24371074f, -0.14208725f, 0.14718616f, 0.26021865f, -0.41859087f, 0.25827786f, 0.04714305f, 
    0.01071389f, -0.41807732f, -0.03675510f, -0.13968010f, -0.27958563f, -0.13680632f, 0.36057150f, 0.20775674f, 
    -0.48041117f, -0.55704606f, -0.51407576f, 0.30558044f, 0.44833854f, 0.46575770f, 0.48480678f, 0.49862579f, 
    0.33924150f, -0.16922013f, -0.12703879f, -0.08382379f, 0.06104959f, 0.00326751f, 0.14652975f, -0.11236807f, 
    0.08542872f, 0.11890166f, 0.04927844f, -0.48744386f, -0.07027343f, -0.29118064f, 0.17862450f, -0.42400411f, 
    -0.92773330f, -0.80891687f, -0.49525127f, 0.14132501f, 0.05556709f, 0.87820756f, 0.39981905f, 0.15126459f, 
    0.42614040f, -0.07754762f, 0.01445501f, 0.20066756f, -0.13462105f, 0.09658026f, -0.14848477f, -0.11467665f, 
    0.14182277f, 0.05493655f, -0.31460220f, 0.01667830f, -0.05958636f, -0.34699973f, -0.18069999f, -0.16453646f, 
    -0.43909115f, 0.03746802f, -0.31247148f, -0.52152646f, -0.59604901f, 0.60028535f, -0.56731045f, -0.15087514f, 
    0.43283245f, 0.18526828f, -0.29371005f, -0.11719617f, 0.24750583f, 0.05181132f, -0.44047037f, 0.09118871f, 
    0.17940784f, 0.00636569f, -0.11636273f, 0.37449574f, -0.08409887f, -0.14972124f, -0.07963474f, 0.11940780f, 
    0.27850232f, -0.33490804f, 0.22614944f, 0.19707775f, 0.60818917f, 0.30007648f, -0.37199244f, -0.50391716f, 
    0.25423104f, 0.39869213f, 0.08359712f, -0.27322313f, 0.43718845f, -0.15546399f, -0.03995824f, -0.14653519f, 
    -0.11279821f, 0.04326289f, -0.48908859f, 0.05132828f, 0.12827519f, -0.33403203f, 0.01224619f, 0.30951455f, 
    -0.36371633f, -0.08171178f, 0.00762109f, -0.04915609f, 0.30849928f, 0.77610284f, 0.48429465f, 0.61465561f, 
    0.24959764f, 0.56476480f, 0.27945378f, -0.14969742f, -0.28595155f, -0.00590756f, -0.15916987f, -0.01115842f, 
    0.24729265f, -0.06523163f, -0.00169095f, 0.09038328f, 0.00119144f, 0.14251910f, -0.38244653f, -0.14688742f, 
    -0.03570451f, 0.16301806f, 0.04754947f, 0.16017987f, 0.88868594f, -0.67755711f, -0.39780405f, -0.26360056f, 
    0.73076659f, 0.00025857f, -0.33949041f, 0.01146162f, -0.04540049f, 0.38643816f, -0.14489339f, 0.21606700f, 
    0.41344744f, 0.02961191f, 0.17649664f, -0.13200748f, 0.11332026f, 0.03104409f, 0.28309196f, 0.01320353f, 
    -0.10261351f, 0.14444210f, 0.00655419f, 0.30081192f, 0.81256002f, -0.54621136f, 0.80697227f, 0.47106090f, 
    0.24336769f, 0.47310954f, -0.43409520f, 0.39533505f, -0.24647753f, -0.29385638f, 0.06497977f, -0.39477125f, 
    -0.37267807f, 0.12459984f, -0.10861312f, 0.08740240f, 0.11528166f, 0.00438446f, 0.13435526f, 0.03931944f, 
    0.01520580f, 0.00756143f, 0.17068143f, -0.15399367f, 0.00882165f, -0.13980076f, 0.68455523f, 0.38442340f, 
    -0.40869492f, -0.76812202f, 0.08397298f, 0.29399401f, -0.19113792f, -0.21727121f, 0.35881901f, 0.30988690f, 
    0.05304545f, -0.46614230f, 0.10030495f, 0.14601746f, -0.01453141f, 0.01417397f, -0.00510912f, 0.21599165f, 
    0.21532531f, -0.11020375f, 0.09650894f, -0.13178077f, -0.24778582f, -0.04991018f, -0.36079839f, -0.28235912f, 
    -0.58237922f, -0.29824531f, 0.02777505f, -0.18338823f, 0.07307358f, 0.10764410f, -0.35597003f, 0.27229252f, 
    -0.44245425f, -0.14280999f, -0.16742690f, -0.11005759f, -0.06716756f, 0.32401359f, -0.02539086f, 0.46242750f, 
    0.14067590f, 0.09189299f, 0.02486421f, 0.39233291f, -0.14256757f, -0.24459018f, -0.11243964f, 0.43838266f, 
    0.56532305f, -0.28311881f, -0.69150621f, -0.41105503f, -0.32837659f, -0.55897087f, -0.57688576f, -0.33491677f, 
    -0.35377386f, -0.03475975f, 0.26047170f, 0.31842446f, 0.08213522f, -0.27817339f, -0.43903342f, 0.09337784f, 
    -0.09390070f, 0.08563791f, 0.44667795f, 0.09229708f, 0.34419671f, 0.10062613f, -0.11885601f, 0.00162389f, 
    0.87496120f, 0.43279749f, 0.42486203f, -0.43015736f, 0.08262160f, 0.00352002f, -0.06373212f, 0.09816409f, 
    0.03627856f, 0.46606854f, -0.22775473f, 0.35818982f, -0.19230866f, 0.04449719f, 0.17541572f, 0.05378193f, 
    -0.02647388f, -0.15636382f, 0.11424294f, 0.23144525f, -0.60894436f, 0.18185015f, -0.22432250f, -0.17164308f, 
    0.00274683f, -0.77010489f, -0.42410231f, 0.62885821f, 0.44529808f, 0.55278087f, 0.57117605f, 0.36884019f, 
    0.08667479f, -0.09029523f, 0.00682744f, -0.01464996f, -0.17097855f, -0.14716417f, -0.04181227f, -0.18950133f, 
    -0.10822192f, 0.03251214f, -0.15986243f, -0.21676993f, -0.11204438f, 0.09067421f, 0.11319268f, -0.20215189f, 
    0.09638098f, -0.04206603f, 0.31323135f, 0.80285615f, 0.30116028f, -0.10934666f, -0.02162143f, -0.39036611f, 
    0.41995621f, -0.59462011f, -0.63601100f, 0.02048790f, 0.11986724f, 0.28989959f, 0.24814716f, 0.09840305f, 
    0.05327256f, -0.22812258f, -0.13489302f, 0.22938599f, -0.01624460f, -0.05273465f, 0.16725633f, 0.30009139f, 
    0.23588134f, 0.34826812f, 0.13388717f, -0.24742910f, -0.59045500f, -0.56127429f, -0.29132873f, 0.04228694f, 
    -0.41258192f, -0.43556035f, -0.47204000f, -0.13755636f, -0.07494932f, 0.34861371f, -0.04073436f, 0.44742566f, 
    0.11741687f, 0.11726495f, 0.20141736f, -0.31695879f, -0.40989181f, 0.05741192f, 0.15260033f, -0.08612207f, 
    0.12480313f, 0.10662209f, -0.12305550f, 0.35616398f, -0.37206107f, -0.12792164f, -0.13918595f, 0.36392736f, 
    0.12735541f, -0.66423863f, -0.59612453f, -0.45729050f, 0.16352813f, 0.28235304f, -0.24812025f, 0.41013482f, 
    -0.31094286f, 0.12909245f, -0.38691792f, 0.09557559f, 0.14557973f, 0.01079899f, -0.21214822f, -0.10737263f, 
    0.11837559f, 0.28000113f, 0.07096692f, -0.06911787f, -0.11043543f, -0.39050883f, -0.62466460f, -0.45302570f, 
    -0.32508743f, -0.36951399f, -0.40288433f, -0.24426763f, 0.34027293f, 0.44547278f, -0.10238329f, 0.03748213f, 
    -0.03683081f, 0.04877787f, -0.17784025f, -0.10955770f, 0.26516119f, 0.31399134f, 0.03487350f, -0.21682847f, 
    -0.32424814f, -0.07034726f, -0.31458467f, 0.19679567f, 0.14881955f, 0.12984963f, 0.79563504f, 0.21053395f, 
    0.16572714f, -0.20929042f, 0.37705010f, 0.45193326f, 0.35923117f, 0.22710657f, 0.27839708f, 0.21925321f, 
    -0.08234104f, 0.34944755f, -0.27745897f, -0.14349996f, 0.11679584f, -0.00678199f, 0.07948713f, 0.14996751f, 
    -0.24312286f, -0.02840957f, 0.17253163f, 0.13966416f, 0.21736614f, 0.11520696f, -0.03287467f, 0.77638507f, 
    0.43442973f, -0.48687810f, 0.17128454f, 0.04142093f, 0.26641870f, 0.34154117f, -0.44725001f, 0.51791453f, 
    -0.17200063f, -0.14152755f, 0.24915029f, 0.01607233f, 0.29293433f, -0.39620954f, 0.14831726f, -0.09063636f, 
    -0.33693412f, -0.07241907f, -0.27511686f, 0.04486272f, 0.00590275f, 0.13132823f, -0.17133023f, 0.31447241f, 
    -0.46331313f, -0.25599599f, 0.06405321f, 0.60039133f, 0.49654502f, 0.13939102f, 0.82491952f, -0.03685527f, 
    -0.52634436f, 0.11735253f, 0.18231530f, -0.14011297f, 0.01211470f, 0.24920438f, 0.31185198f, 0.24821946f, 
    0.18345012f, -0.19631761f, 0.23254171f, -0.12694965f, 0.06584900f, 0.05036280f, 0.07284579f, 0.18244837f, 
    -0.32598186f, -0.59130144f, 0.47489518f, 0.03236420f, -0.63185269f, 0.08810158f, 0.52882361f, -0.50031161f, 
    -0.57905686f, -0.15439948f, -0.58429134f, -0.16301540f, -0.02613658f, 0.02372338f, 0.17785779f, 0.16682465f, 
    -0.01826234f, 0.02867320f, 0.12391549f, 0.08075887f, 0.21700899f, 0.22458047f, -0.28730717f, 0.13459495f, 
    -0.05501339f, -0.22222698f, 0.24753696f, 0.54675937f, -0.09443069f, 0.87161344f, 0.26367635f, 0.38952535f, 
    0.16399916f, -0.00284924f, 0.32417873f, 0.28578228f, -0.41916558f, -0.32547840f, -0.17312513f, 0.12191232f, 
    -0.47714818f, -0.25622138f, 0.08814662f, -0.03247042f, -0.02599443f, -0.14301345f, 0.02306948f, 0.14079233f, 
    0.00968715f, -0.02362352f, -0.11021779f, 0.80328918f, 0.43639985f, 0.43002579f, 0.37341011f, 0.55314565f, 
    -0.56351548f, -0.33971357f, 0.16184512f, -0.09201583f, -0.18278399f, 0.11822443f, 0.18693411f, -0.20003510f, 
    0.39426222f, 0.00018197f, 0.19930184f, -0.41418758f, 0.11418947f, 0.34501109f, 0.08120458f, 0.06382185f, 
    0.06400189f, 0.10823791f, -0.00178509f, 0.03799970f, 0.88302022f, 0.31798604f, -0.77653944f, -0.55374467f, 
    -0.38411251f, -0.47200412f, -0.05422318f, 0.23574394f, 0.03832468f, -0.33822531f, -0.21976946f, -0.16296640f, 
    0.11855549f, -0.18313201f, -0.16431345f, -0.02212355f, -0.29031694f, 0.06571252f, -0.09457918f, 0.02643753f, 
    0.29636890f, 0.13114004f, -0.07112256f, -0.14568855f, -0.15461177f, 0.88811368f, -0.22385497f, -0.25273004f, 
    0.21122353f, 0.05091010f, -0.50606632f, -0.11637337f, -0.49693182f, -0.33357769f, -0.14654422f, -0.32802731f, 
    -0.16413036f, -0.11966013f, -0.32927793f, -0.36434308f, -0.03981228f, -0.36566368f, -0.46448284f, -0.08495720f, 
    -0.24875446f, -0.01222335f, 0.24452518f, -0.03625932f, -0.12526323f, -0.10714709f, -0.24458779f, 0.50204170f, 
    0.33806831f, 0.52535260f, -0.49698511f, -0.83151460f, 0.22610866f, -0.44747114f, -0.32641453f, -0.52047318f, 
    0.28602666f, -0.16426328f, -0.09661084f, 0.02059366f, -0.07025830f, -0.09612257f, -0.12897252f, 0.04976452f, 
    0.12879194f, -0.43540132f, 0.14891952f, -0.08511956f, -0.07625985f, 0.03085019f, 0.24644567f, 0.57711619f, 
    0.64377195f, 0.74897826f, 0.57139438f, 0.45399728f, -0.07348853f, -0.12902431f, -0.75300169f, 0.43890393f, 
    0.04061532f, -0.04318133f, -0.30746606f, 0.08272380f, 0.08406093f, -0.09274700f, 0.03240360f, 0.08471674f, 
    -0.11627607f, 0.03830839f, 0.01361371f, 0.38834620f, 0.06267888f, 0.24021511f, 0.01202503f, 0.24669880f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00971630f, 0.05155760f, -0.10102400f, 0.11045086f, -0.04207815f, 0.17425714f, 0.24499780f, 0.07915160f, 
    0.02509617f, -0.05012859f, -0.02022578f, 0.29448351f, 0.18362156f, -0.10699712f, -0.07237851f, 0.35847434f, 
    0.15471844f, -0.08042876f, 0.15069717f, 0.30461973f, 0.29504147f, 0.17929681f, 0.20463617f, 0.09632655f, 
    -0.08983734f, 0.07567271f, 0.10862779f, 0.18508972f, 0.13608423f, 0.14063191f, 0.18359335f, 0.00570246f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00915595f, 0.00148588f, -0.19367559f, -0.18595937f, -0.11703228f, 0.02612868f, 0.07078897f, -0.06941763f, 
    -0.00322383f, 0.06489377f, -0.06639601f, 0.04800880f, -0.12820269f, -0.12956266f, -0.02289038f, 0.03832339f, 
    -0.04607970f, 0.02594436f, -0.10094229f, -0.03456477f, -0.05438879f, 0.08879081f, 0.02186891f, 0.13438477f, 
    0.21857625f, 0.13287979f, -0.17516907f, -0.05767175f, -0.02247741f, 0.11306366f, -0.09308902f, 0.01156520f, 
    -0.03906865f, -0.02463833f, -0.01573625f, -0.06606276f, -0.13321464f, -0.24553345f, 0.04276076f, 0.01189591f, 
    -0.03544093f, -0.05782677f, 0.01119677f, 0.01237562f, 0.04084664f, 0.02044832f, -0.04833240f, 0.17681672f, 
    -0.05719403f, 0.02772183f, 0.08390852f, -0.17225017f, -0.00296021f, -0.06923650f, -0.03392539f, -0.00986374f, 
    0.01848006f, -0.02511665f, 0.00663156f, -0.03355712f, 0.01793373f, 0.02775294f, -0.17448525f, 0.00389189f, 
    0.15361525f, 0.12571405f, 0.06593151f, 0.12310369f, 0.02846824f, -0.03691132f, -0.03002930f, 0.12837067f, 
    -0.04584466f, -0.15670766f, 0.09769508f, 0.14449556f, 0.07019727f, 0.03254527f, 0.05600809f, 0.13034432f, 
    0.01226819f, -0.02479270f, 0.10638767f, -0.01591603f, 0.33771154f, -0.13431904f, -0.00084511f, 0.10204150f, 
    -0.02987421f, -0.03243927f, 0.01440928f, 0.12604468f, 0.03470335f, 0.03660615f, 0.04332797f, -0.01853170f, 
    -0.41673085f, -0.04941629f, 0.10774530f, -0.14492829f, -0.20206822f, -0.01629481f, 0.03172489f, 0.07698251f, 
    0.07513480f, 0.03961520f, 0.04862671f, -0.04835431f, -0.07973167f, 0.09972598f, 0.14053230f, -0.11259887f, 
    -0.03567924f, -0.02501263f, 0.11087779f, -0.02838179f, 0.03317553f, 0.10933553f, 0.02311698f, 0.02644148f, 
    0.11467566f, -0.13050166f, -0.02544389f, -0.06893404f, -0.04543407f, 0.04792546f, -0.03464079f, 0.20121524f, 
    -0.04093282f, 0.04015147f, -0.04094774f, 0.12448370f, -0.00178827f, -0.33035001f, 0.00178686f, 0.13762490f, 
    0.12995191f, -0.02590139f, -0.03512152f, -0.00526953f, -0.01495912f, 0.07931575f, 0.01731005f, -0.03072543f, 
    -0.06527501f, 0.07902963f, 0.00990087f, -0.14787169f, 0.15368719f, 0.02169999f, 0.06245453f, 0.02960191f, 
    -0.01619770f, 0.07360314f, 0.05501296f, 0.07221074f, -0.22195655f, -0.11808839f, -0.13921021f, 0.10745955f, 
    -0.15858065f, 0.01521958f, -0.10028125f, -0.00005494f, 0.01846142f, -0.03032414f, -0.07663828f, -0.02606480f, 
    0.00619736f, 0.04932477f, -0.13034052f, 0.08418161f, -0.02493152f, -0.03589980f, -0.01873456f, 0.04642750f, 
    0.04009950f, 0.12597890f, -0.10146392f, -0.07644006f, 0.04151881f, -0.13731202f, -0.02320938f, -0.07990532f, 
    0.09380324f, 0.03873208f, -0.03125847f, 0.04639350f, 0.03107387f, 0.18116146f, 0.15174113f, 0.02995231f, 
    0.01445222f, 0.08862812f, 0.03305377f, 0.25497401f, 0.19084685f, 0.07925188f, 0.02950446f, -0.05536068f, 
    0.12851870f, -0.01872126f, 0.05540824f, 0.03122800f, 0.45990452f, -0.12136262f, -0.18699130f, -0.00549225f, 
    -0.00983102f, 0.09801237f, 0.03547990f, 0.09231024f, 0.00328661f, 0.04159390f, 0.01636984f, 0.06906508f, 
    0.14374971f, 0.08495381f, -0.02604161f, -0.11913368f, 0.14619742f, 0.04027982f, -0.01941405f, 0.03450972f, 
    0.06537655f, -0.03713554f, 0.10693480f, 0.00578917f, 0.04837202f, 0.16238834f, 0.00189241f, -0.12788333f, 
    0.10536282f, 0.11410712f, 0.10226816f, -0.01769371f, -0.00755758f, -0.02232332f, -0.10854756f, -0.05968640f, 
    -0.03255070f, 0.01938655f, 0.01759260f, -0.20050797f, 0.00678159f, 0.02637773f, 0.12048118f, 0.06903776f, 
    0.00045513f, -0.07333255f, 0.04655724f, 0.01939087f, 0.02825073f, -0.02434711f, 0.04128774f, -0.01463154f, 
    -0.10230511f, -0.04991348f, -0.06387632f, 0.01418863f, 0.06152638f, -0.02879963f, 0.07135627f, 0.04164084f, 
    0.00299953f, 0.10067482f, 0.09233833f, 0.12019524f, 0.06634302f, -0.00041140f, 0.04199113f, 0.00230817f, 
    0.05400395f, -0.06662484f, 0.06573901f, 0.00155417f, 0.00559391f, -0.08502269f, 0.15256783f, 0.10339603f, 
    0.15967818f, 0.00242129f, 0.06429696f, 0.05042763f, 0.04350338f, 0.09621353f, 0.00749454f, 0.00360463f, 
    0.16258501f, -0.08219697f, -0.19710037f, 0.05229978f, -0.05840217f, 0.03807984f, -0.04232473f, 0.04308821f, 
    -0.01375980f, 0.05001052f, -0.03193004f, 0.01402570f, 0.10198039f, -0.13834724f, 0.01347935f, -0.02331507f, 
    0.00480693f, 0.08826502f, -0.00697916f, 0.04235371f, -0.03577740f, 0.00993140f, -0.04770412f, 0.01814882f, 
    0.03496981f, -0.07051629f, -0.02882400f, -0.00030090f, 0.06033847f, -0.00353830f, 0.03377523f, 0.11070467f, 
    0.00694761f, 0.03535313f, 0.10855861f, 0.04042343f, -0.03875654f, 0.07867774f, 0.10161684f, 0.08653013f, 
    0.07491781f, -0.06046898f, 0.07992183f, 0.04755581f, 0.06539387f, 0.07630160f, -0.11317068f, 0.12663618f, 
    0.01735396f, -0.18090272f, -0.01638631f, 0.09936313f, 0.00920020f, -0.05126055f, 0.05899137f, 0.09488060f, 
    0.10931265f, -0.12883356f, -0.04093641f, 0.02005457f, -0.08389203f, 0.10846511f, -0.12205605f, -0.21423417f, 
    0.05309423f, 0.09444059f, 0.13192421f, 0.02286719f, 0.00955083f, 0.04941989f, -0.08080839f, 0.09058882f, 
    0.06933042f, -0.04192363f, -0.12231386f, -0.16460826f, -0.00619845f, 0.19240300f, 0.02855745f, 0.16806567f, 
    0.16186486f, 0.03414978f, -0.02348381f, 0.07001822f, 0.14883080f, 0.03846826f, 0.22637157f, 0.02445447f, 
    -0.00907241f, 0.09261980f, -0.01243068f, 0.11029979f, 0.04335658f, 0.00642706f, 0.07069620f, -0.14001207f, 
    0.02223672f, 0.00138054f, 0.01312087f, 0.00765310f, -0.04327347f, -0.05086889f, 0.01524145f, 0.01381557f, 
    -0.05364616f, 0.00633394f, -0.01163108f, -0.04783279f, 0.02523485f, 0.00124568f, 0.01011721f, 0.03585214f, 
    0.02462466f, 0.01325153f, 0.01457240f, 0.03477638f, -0.03899283f, -0.03397164f, 0.00606232f, 0.04116082f, 
    0.00554902f, -0.01452497f, -0.01491726f, -0.03925123f, -0.04370101f, -0.01711078f, 0.00670295f, 0.00371629f, 
    -0.01401455f, -0.00554378f, 0.02535798f, -0.01103070f, -0.03557397f, -0.05238402f, 0.04296890f, -0.04955056f, 
    -0.00622053f, 0.01382829f, -0.02178498f, -0.05117474f, 0.01453287f, -0.00995619f, -0.01589075f, -0.04473499f, 
    -0.04791163f, -0.01439406f, -0.00904607f, 0.02667343f, 0.02273230f, -0.05215665f, -0.03637395f, 0.03651504f, 
    -0.02280167f, -0.00834608f, 0.04658597f, -0.00094185f, 0.03931376f, 0.03605448f, 0.00104811f, -0.03861736f, 
    0.00860877f, -0.04682094f, 0.00701259f, 0.00036179f, 0.00122129f, -0.00497971f, -0.00646892f, -0.02321888f, 
    0.01669769f, 0.03808372f, 0.02172818f, 0.01034596f, -0.01010886f, -0.05399566f, 0.01235672f, -0.03466957f, 
    0.00972183f, 0.03794356f, -0.05137848f, -0.04750309f, 0.04815194f, 0.03394558f, -0.02965836f, 0.00909497f, 
    0.00204161f, -0.02119151f, 0.04279244f, 0.00921273f, 0.02822794f, -0.02503891f, -0.02388284f, -0.00973663f, 
    -0.01423227f, 0.01909550f, -0.02935901f, -0.03082680f, 0.01101079f, -0.01721481f, -0.04060181f, -0.03279186f, 
    -0.03074545f, 0.03048684f, -0.05426649f, 0.03813980f, 0.04557522f, -0.00750850f, 0.01702602f, -0.03044531f, 
    0.00453645f, -0.03502332f, 0.01070837f, -0.01906766f, 0.01133073f, 0.04909471f, 0.04252892f, -0.02034666f, 
    0.00996727f, -0.03139760f, 0.03650695f, -0.03110860f, -0.00500903f, -0.00124511f, 0.04216946f, -0.04714073f, 
    -0.03691887f, 0.04701819f, -0.05186542f, -0.00290932f, -0.02881038f, 0.02031523f, -0.02134986f, -0.00311418f, 
    -0.00599478f, -0.00828204f, -0.03188249f, -0.00498970f, 0.00400732f, 0.03527992f, -0.01461359f, -0.04037891f, 
    0.02249720f, -0.03258924f, 0.02665390f, -0.02155559f, -0.00276784f, 0.01830033f, -0.04080974f, -0.05221044f, 
    0.03292779f, -0.02069229f, 0.03136925f, 0.02094258f, -0.05239557f, 0.01224358f, -0.01837038f, -0.01431670f, 
    0.00531854f, 0.03789303f, 0.01489441f, -0.00208087f, -0.03239465f, 0.03656105f, 0.03379143f, 0.03307220f, 
    0.03283829f, 0.04695876f, -0.01895425f, 0.01299454f, 0.03862154f, -0.03659697f, 0.00652130f, -0.01461426f, 
    0.01677893f, -0.03296890f, 0.03875132f, 0.02727905f, -0.03599975f, 0.00319508f, 0.00795476f, -0.05082366f, 
    -0.00959559f, 0.02264990f, -0.01779411f, -0.01103033f, 0.02462360f, -0.02358308f, -0.02734983f, -0.04375771f, 
    -0.02510253f, -0.05796272f, 0.01326771f, 0.00032618f, -0.01404841f, 0.02642255f, 0.01332716f, 0.01280590f, 
    -0.03081373f, -0.03237543f, 0.03276433f, 0.04397958f, -0.05134012f, -0.02430160f, 0.02676627f, -0.03147073f, 
    -0.03951055f, 0.00306814f, 0.02545811f, 0.02565177f, -0.00283612f, 0.04550512f, -0.00200242f, -0.01743232f, 
    -0.01255720f, 0.04237600f, -0.00304979f, 0.01013950f, -0.03610597f, -0.01123297f, -0.03435684f, 0.00356851f, 
    0.01880843f, -0.05430398f, -0.03972079f, -0.05137084f, -0.01870301f, -0.02032063f, -0.04214039f, 0.03439616f, 
    -0.01776444f, -0.04905633f, -0.02567481f, -0.02407999f, -0.03567705f, 0.00059882f, -0.02129565f, -0.03882920f, 
    -0.03867011f, 0.04014587f, 0.04438080f, 0.00758229f, 0.04444877f, 0.04486469f, 0.00535731f, 0.00841650f, 
    -0.00718829f, 0.01129565f, -0.04139088f, 0.02017286f, -0.04262517f, 0.04405413f, -0.02858982f, -0.03823689f, 
    -0.02893406f, -0.05361536f, -0.02114554f, -0.02827457f, 0.03615037f, -0.00264638f, 0.01194025f, -0.00568531f, 
    -0.03371407f, 0.02918350f, 0.02648641f, 0.00734342f, -0.01004101f, 0.02595202f, -0.03790332f, -0.01409712f, 
    -0.01075080f, -0.03082887f, 0.01162185f, 0.01500044f, 0.01951050f, -0.01876728f, 0.04410800f, -0.01070241f, 
    0.02675730f, -0.02456566f, -0.01302443f, -0.03634891f, -0.02138107f, -0.00824182f, 0.02303390f, 0.01294892f, 
    -0.00810239f, 0.02355864f, 0.04417689f, -0.03810218f, 0.01834789f, -0.00205395f, -0.03696353f, -0.03744129f, 
    -0.00523531f, -0.01545481f, 0.03247810f, -0.03701833f, -0.00894493f, 0.05067917f, 0.01015291f, -0.04358512f, 
    -0.02899393f, -0.02614015f, -0.00523742f, 0.01323201f, 0.01392852f, 0.02311588f, 0.00200261f, 0.01298607f, 
    0.02331334f, -0.00858593f, -0.03322267f, -0.01956131f, 0.01649562f, -0.00037458f, -0.02482219f, 0.00569020f, 
    0.03405489f, -0.05682456f, -0.00450267f, 0.02192719f, 0.01150440f, -0.03304873f, -0.05770820f, -0.02388870f, 
    -0.01034015f, 0.02469905f, 0.01511084f, -0.01700584f, -0.03679920f, 0.03369486f, 0.03413595f, 0.03864715f, 
    0.00013051f, 0.01816270f, 0.01593573f, 0.02735825f, 0.03067130f, 0.04335107f, 0.03947032f, 0.03328533f, 
    -0.05340996f, -0.01110215f, 0.02542927f, -0.02935316f, -0.04645256f, 0.01683105f, 0.00214177f, -0.04547771f, 
    0.02850484f, 0.03261002f, -0.04240203f, -0.05551633f, -0.05164750f, -0.02776221f, 0.01173028f, -0.05508971f, 
    0.03162012f, -0.01990807f, -0.04396043f, -0.04317841f, 0.01594407f, 0.00054282f, 0.02222357f, -0.02975343f, 
    0.01444933f, 0.03869139f, -0.02188550f, -0.03000085f, 0.02394009f, 0.01060877f, 0.02042506f, -0.02277633f, 
    -0.02784561f, -0.02773648f, -0.01209710f, 0.02193080f, 0.03200144f, 0.04610652f, -0.03889727f, -0.01297037f, 
    0.02183662f, -0.01879127f, 0.03703192f, -0.00944412f, -0.01653306f, 0.01557015f, -0.00344811f, -0.01281655f, 
    0.01404641f, -0.05320466f, -0.05414397f, -0.02416862f, -0.05158684f, -0.04538512f, -0.04794597f, 0.03163480f, 
    0.02636374f, 0.00717418f, -0.01315319f, 0.02616039f, -0.04111909f, 0.00157405f, -0.01975295f, -0.02853476f, 
    -0.02877740f, -0.00506519f, -0.01492042f, -0.03115995f, 0.00162465f, -0.00535577f, 0.02141570f, 0.03332957f, 
    -0.04413079f, -0.02973514f, -0.00663377f, -0.02460674f, 0.00232202f, -0.04667137f, -0.04808252f, 0.01645173f, 
    -0.01877882f, 0.04225655f, -0.03933601f, 0.01440714f, 0.03663506f, -0.04627224f, -0.02424403f, 0.02777655f, 
    -0.04499719f, 0.00710024f, 0.00289105f, 0.03832765f, 0.03343858f, -0.03355348f, 0.01504920f, 0.03738672f, 
    -0.01341851f, -0.01104337f, -0.04543529f, -0.03657260f, -0.02857006f, -0.02998091f, 0.01340478f, 0.01850150f, 
    0.00691200f, 0.01234950f, 0.00143758f, 0.00874161f, 0.04196377f, 0.01275482f, -0.02871369f, -0.05199819f, 
    -0.01258003f, -0.04706953f, 0.00587983f, -0.02346141f, 0.03992642f, -0.03654417f, -0.03029907f, 0.04191719f, 
    0.01992510f, -0.04030692f, -0.03570761f, -0.00993892f, -0.01927440f, 0.01217067f, 0.02723037f, -0.00761970f, 
    -0.04851377f, 0.01373113f, -0.05106049f, -0.02672884f, -0.02842444f, -0.03741585f, 0.04327206f, 0.02321910f, 
    -0.05240991f, -0.02197190f, -0.00294247f, -0.05327141f, -0.00273187f, -0.02086763f, -0.03581802f, -0.03454664f, 
    0.03041727f, -0.03700193f, -0.02363842f, 0.04416081f, -0.00804153f, -0.04146709f, 0.01374122f, 0.03283888f, 
    -0.00018500f, 0.00252313f, -0.05408805f, -0.03059089f, 0.00049673f, -0.03511364f, -0.03063267f, 0.00382992f, 
    -0.02460530f, -0.01946482f, -0.04359293f, -0.00825636f, -0.03967875f, -0.05604859f, 0.03380720f, -0.00597212f, 
    0.03111023f, 0.02816246f, -0.03560896f, -0.02307969f, 0.00810526f, 0.01499718f, -0.03038735f, -0.02698728f, 
    0.01594944f, -0.04630277f, 0.03606217f, -0.01211888f, -0.00472968f, 0.03348920f, -0.01890692f, 0.01806366f, 
    -0.03404310f, -0.00846410f, 0.02761671f, 0.04136088f, 0.01687076f, -0.04191252f, -0.02462416f, 0.03856140f, 
    -0.03454808f, -0.05372285f, 0.02357509f, 0.01778802f, 0.02366176f, -0.02114043f, 0.02834693f, -0.01262597f, 
    -0.01583284f, -0.05505962f, 0.00330104f, 0.00824507f, 0.00928824f, -0.01305407f, -0.03093697f, -0.00031365f, 
    -0.02648074f, -0.02872655f, -0.04136563f, 0.00084675f, 0.00312945f, -0.01911013f, -0.01891781f, 0.02732210f, 
    0.04313983f, -0.01164914f, -0.00735582f, -0.02315360f, -0.00153715f, 0.03234406f, 0.02819943f, -0.02884116f, 
    -0.03754135f, 0.00909038f, 0.02165345f, -0.01122801f, -0.04429980f, 0.02332436f, -0.05765269f, -0.05578933f, 
    -0.01287247f, -0.04059375f, -0.02596571f, 0.02512787f, 0.02438976f, -0.02934034f, -0.03873025f, 0.02353546f, 
    -0.00796681f, 0.02943695f, -0.02173706f, -0.03393641f, 0.03567963f, -0.02012047f, -0.05093483f, 0.02225716f, 
    -0.01897210f, 0.00598609f, 0.03888314f, 0.02136990f, 0.03592308f, -0.02523218f, 0.03305314f, 0.03849986f, 
    0.02698755f, -0.01754064f, -0.03389722f, 0.00064912f, -0.02105403f, -0.00331516f, -0.03037791f, -0.05316959f, 
    -0.04595875f, -0.00838857f, 0.04334920f, 0.00674837f, -0.01408945f, -0.00366209f, 0.01896461f, -0.05302399f, 
    -0.05513836f, 0.01181828f, 0.03226730f, 0.03726853f, -0.00756436f, -0.02526984f, -0.05141051f, 0.00768405f, 
    0.02318364f, -0.04897258f, -0.02839359f, -0.01666400f, 0.03449075f, 0.00681600f, -0.04625414f, -0.00647332f, 
    -0.00723496f, -0.00742791f, -0.03422586f, -0.01636536f, -0.00160885f, -0.04954438f, 0.01103605f, 0.01945588f, 
    -0.00519862f, -0.02935919f, 0.02622446f, 0.01169373f, -0.02928069f, -0.01927944f, -0.05423810f, -0.00521453f, 
    0.04464075f, -0.01885019f, 0.01244998f, 0.00749756f, -0.02078243f, 0.01766877f, 0.01051535f, 0.01195348f, 
    -0.04137298f, -0.03456851f, 0.02542774f, 0.00720242f, -0.03827562f, -0.02344051f, 0.03334041f, -0.02764904f, 
    -0.02714699f, -0.03307910f, 0.03435277f, -0.05560906f, -0.03643489f, 0.00110119f, -0.00400058f, -0.02297274f, 
    0.00726065f, -0.02558269f, -0.02688956f, 0.02168748f, 0.00608480f, -0.04987976f, -0.01461252f, -0.01640587f, 
    -0.02673944f, 0.04034369f, -0.00968922f, -0.01445101f, -0.00681039f, -0.04607026f, 0.02272617f, 0.04019209f, 
    -0.00474293f, 0.01455205f, 0.02381192f, 0.04042325f, -0.03220155f, 0.01492871f, -0.01869941f, -0.05492355f, 
    -0.01034082f, 0.02120904f, -0.03829706f, 0.00331899f, 0.03095827f, 0.01824930f, -0.02502940f, -0.00690297f, 
    -0.00101689f, -0.02930690f, -0.04621181f, 0.04291789f, 0.00132143f, -0.01630873f, 0.01213165f, 0.02990447f, 
    -0.04929959f, -0.01377911f, -0.01590572f, -0.05479622f, -0.01769434f, -0.04258195f, -0.03816728f, 0.02180208f, 
    -0.05319240f, 0.00070686f, -0.05849654f, 0.04219957f, 0.02155950f, 0.03047029f, 0.02408055f, -0.00799267f, 
    -0.00655266f, 0.00097473f, 0.01491719f, 0.01102775f, -0.01095419f, 0.03358754f, 0.01401001f, 0.03815635f, 
    0.03539480f, -0.05338417f, -0.04209465f, -0.03777841f, -0.05218242f, 0.00883355f, -0.03194061f, -0.01869542f, 
    0.00843385f, 0.04025905f, -0.01719826f, -0.00528288f, 0.00830442f, -0.01537558f, -0.05138121f, -0.03281096f, 
    -0.05156377f, -0.02172094f, -0.03088766f, 0.01814862f, -0.02470992f, 0.03174415f, -0.03797760f, 0.03840162f, 
    0.00344865f, -0.02201627f, -0.01604666f, -0.02592758f, -0.03678695f, 0.04395216f, -0.04074254f, 0.03386060f, 
    -0.20484608f, -0.11766542f, -0.01158423f, 0.08931897f, 0.07353007f, 0.01331412f, -0.02006578f, 0.00211196f, 
    0.07599036f, -0.00199651f, 0.07607789f, -0.03159191f, 0.11471723f, -0.33910826f, 0.07569987f, -0.05430394f, 
    0.07488570f, 0.08165912f, -0.00014199f, 0.07678899f, 0.05644964f, -0.07838397f, -0.06625947f, -0.09089904f, 
    -0.22596695f, 0.01909812f, -0.06753171f, 0.03423297f, 0.05393878f, -0.08602504f, 0.08443444f, 0.05413316f, 
    0.07414166f, -0.01300734f, -0.00445267f, 0.01778675f, -0.06161411f, 0.14942692f, -0.04390453f, 0.07056282f, 
    0.16940217f, -0.05989791f, -0.05725199f, 0.03851534f, -0.00457391f, -0.04270483f, 0.03342700f, -0.01695109f, 
    0.18708022f, 0.02384971f, 0.07374092f, 0.15850081f, 0.08179918f, 0.03232927f, -0.00675299f, 0.00704550f, 
    0.05341845f, 0.05187680f, -0.06634521f, 0.15994971f, 0.14579108f, 0.06473242f, 0.11374559f, 0.03314413f, 
    -0.23151788f, -0.08348571f, 0.04830772f, -0.00479397f, 0.08966579f, 0.06313971f, 0.04376137f, -0.09824777f, 
    0.16552900f, 0.07477925f, 0.05630302f, -0.04365931f, -0.03449455f, 0.00764568f, 0.07832965f, 0.02190827f, 
    -0.01996470f, -0.00207239f, -0.03305666f, -0.01711000f, -0.43446612f, 0.10446921f, -0.07185720f, -0.12039739f, 
    0.16704068f, -0.00922246f, 0.00802584f, 0.02145403f, 0.06179526f, 0.02341220f, 0.04855992f, -0.04994599f, 
    0.11008491f, -0.22064316f, -0.07875836f, -0.08115786f, 0.06944785f, 0.07926932f, -0.11997992f, -0.11644442f, 
    -0.00849102f, -0.11271315f, -0.02735359f, 0.02674231f, 0.03657198f, 0.05475253f, 0.02719420f, -0.02334632f, 
    0.05638448f, 0.03699227f, -0.04255265f, 0.07263499f, 0.04585873f, -0.01746080f, 0.04107839f, 0.09207900f, 
    -0.17647456f, 0.04260679f, -0.02073027f, 0.01430347f, 0.14286576f, 0.03061520f, 0.11582644f, 0.06460311f, 
    -0.08122725f, 0.03536729f, -0.02067454f, -0.02919844f, 0.20442757f, -0.07962912f, 0.08958338f, -0.04107930f, 
    -0.04043637f, 0.11918103f, 0.07397582f, -0.07051134f, 0.05400383f, 0.05501454f, 0.03145489f, 0.07977553f, 
    0.20090689f, -0.01828367f, -0.00630389f, -0.02476724f, -0.00358185f, -0.09363881f, -0.01284881f, -0.04926081f, 
    0.10123274f, 0.02838829f, -0.02699873f, -0.00921910f, 0.11628052f, -0.19742270f, 0.24423438f, -0.14217994f, 
    0.03377858f, -0.04964119f, 0.04454012f, 0.09754555f, 0.04001942f, 0.11377598f, 0.10203502f, 0.09560934f, 
    -0.02072718f, -0.02977493f, -0.11319943f, 0.00219433f, 0.03192426f, 0.05094153f, 0.01600846f, -0.04160626f, 
    0.02663755f, -0.07832862f, 0.03466942f, 0.10312796f, 0.01718413f, 0.01831927f, 0.16679636f, 0.02991497f, 
    0.03086982f, -0.04180287f, 0.16527100f, -0.09463416f, 0.00976676f, -0.10543720f, -0.11564200f, 0.02029807f, 
    0.29349849f, 0.11180856f, 0.19685264f, -0.11642971f, -0.01253177f, 0.07960069f, 0.03874029f, 0.00186562f, 
    -0.05888829f, -0.01745994f, 0.02899873f, 0.01674596f, -0.32264411f, 0.14103955f, 0.13028899f, -0.07730825f, 
    0.02337364f, -0.05753279f, 0.06299888f, -0.07625470f, 0.00609728f, -0.00175380f, -0.05044717f, 0.14793721f, 
    0.15913470f, 0.11763437f, 0.08827458f, 0.10313596f, -0.10383032f, -0.01099763f, -0.00822040f, -0.01524112f, 
    -0.01071920f, 0.00904360f, 0.00996709f, -0.02444308f, -0.18674405f, -0.20154883f, -0.03269953f, 0.11512303f, 
    0.05274373f, -0.06401315f, 0.02056346f, 0.11282099f, 0.08782939f, -0.03300539f, 0.02548075f, 0.12063277f, 
    0.02433569f, -0.07836915f, -0.04886979f, 0.15411125f, -0.04566576f, -0.03534376f, 0.02644618f, 0.05191318f, 
    0.10137497f, 0.15725991f, -0.05941800f, 0.06590581f, -0.05684869f, -0.01623464f, -0.23788944f, 0.04787611f, 
    0.12605935f, 0.04584258f, 0.04943472f, 0.08887343f, -0.00361976f, -0.03362688f, 0.00786973f, -0.00909416f, 
    0.18295534f, 0.04214090f, -0.02783485f, -0.02167147f, 0.06925711f, 0.03939995f, 0.08326480f, 0.03872804f, 
    0.03641087f, -0.00152136f, 0.05114935f, -0.00167261f, -0.12161727f, 0.12660123f, 0.04381537f, -0.05015527f, 
    -0.01253377f, 0.02689269f, 0.00160063f, -0.12481654f, 0.07309728f, -0.03947289f, -0.04063483f, -0.03636001f, 
    -0.12120420f, 0.11507834f, 0.08126424f, -0.07007817f, 0.06213724f, 0.09407510f, 0.02295493f, -0.00865971f, 
    0.07667802f, -0.11021302f, 0.09947509f, 0.14379941f, -0.36655182f, -0.26581791f, 0.08414230f, -0.02698280f, 
    -0.04299536f, -0.02564051f, 0.14005275f, -0.03105249f, 0.01722501f, 0.01309742f, 0.07867200f, 0.10295075f, 
    0.07982218f, 0.00590937f, 0.06753917f, 0.11213014f, 0.00937962f, 0.05551313f, 0.15201810f, -0.00532280f, 
    -0.03656657f, 0.01683578f, -0.07263764f, -0.02550082f, 0.26685518f, 0.14895779f, 0.01039694f, 0.03085234f, 
    -0.06284688f, 0.01287453f, 0.03139120f, 0.00835342f, 0.08199358f, -0.06113337f, 0.02140285f, -0.07416564f, 
    -0.12546560f, 0.26942927f, 0.10446510f, -0.04521859f, -0.00993953f, 0.06276195f, -0.03645879f, -0.04229642f, 
    0.03048072f, 0.05377841f, -0.03598979f, 0.07870617f, 0.00317974f, 0.13852048f, 0.03441650f, 0.10026601f, 
    0.06698318f, -0.03988187f, 0.04178196f, 0.00244030f, 0.04020709f, 0.06989751f, 0.06742827f, 0.02963418f, 
    0.00634180f, 0.06494883f, 0.07137272f, 0.03311714f, -0.15787971f, 0.04183041f, -0.06153229f, -0.01170584f, 
    0.01913345f, 0.02275917f, 0.00048118f, -0.06417073f, 0.25647610f, 0.10311810f, -0.11285918f, 0.02548803f, 
    -0.13435151f, -0.00746014f, -0.03876858f, -0.02884836f, 0.00573606f, -0.01985278f, -0.09806213f, 0.11591533f, 
    0.19875130f, 0.31793576f, 0.05676090f, 0.03543096f, 0.08498133f, 0.03613009f, 0.02257792f, 0.11781028f, 
    -0.08089048f, -0.00353666f, 0.02473726f, -0.01781799f, -0.20135090f, 0.09758342f, 0.00906482f, 0.12786075f, 
    0.20002232f, -0.04055381f, 0.16906469f, 0.07383418f, 0.03883331f, 0.03810784f, -0.02207013f, -0.05662592f, 
    -0.17027496f, -0.12558103f, 0.12214644f, 0.12466324f, 0.03178233f, -0.04923610f, -0.00958701f, -0.04906924f, 
    -0.13545419f, 0.09025624f, -0.13858967f, -0.09849264f, -0.03614740f, -0.08684994f, -0.13451205f, 0.13177048f, 
    0.13536966f, -0.00187703f, -0.07825711f, 0.02720731f, 0.00609441f, 0.10314540f, 0.01642865f, 0.04471219f, 
    0.00765958f, -0.00925745f, -0.04786428f, 0.11409012f, -0.05904171f, 0.12041862f, 0.03701432f, -0.05013842f, 
    -0.08192072f, -0.04343755f, 0.04897975f, 0.03104666f, 0.27301317f, -0.18649058f, 0.03598867f, 0.09333386f, 
    -0.12106486f, 0.05794772f, -0.02515716f, -0.09594665f, -0.01096968f, 0.02196010f, -0.06623015f, -0.02169879f, 
    -0.05423110f, 0.01552533f, 0.01750255f, 0.20461343f, -0.05870304f, 0.05708787f, -0.07632799f, -0.02828485f, 
    -0.04180617f, -0.02268455f, 0.04262260f, 0.15723404f, -0.06802300f, 0.07712083f, 0.01402973f, 0.21856771f, 
    0.05658872f, 0.10077620f, 0.03674506f, -0.05425651f, 0.00598143f, -0.02239927f, -0.01527236f, -0.08506601f, 
    0.08243769f, 0.08264516f, 0.00994939f, 0.19588821f, 0.19880840f, 0.06774903f, -0.03667803f, 0.01050753f, 
    0.06786440f, 0.05413344f, -0.00487416f, -0.03745004f, 0.05929247f, -0.09313328f, 0.04914209f, -0.02091019f, 
    -0.09261442f, 0.14468133f, 0.08103453f, 0.04201829f, 0.02630519f, -0.08621781f, -0.11529263f, -0.06644736f, 
    -0.17140530f, 0.10774234f, -0.11002462f, -0.03376265f, 0.07897224f, -0.08843199f, 0.09236586f, 0.01385931f, 
    -0.00126276f, -0.05662869f, 0.10079206f, -0.10958157f, -0.25403324f, 0.26351738f, -0.14661673f, 0.04157788f, 
    -0.04167869f, -0.07728548f, -0.01722750f, 0.04928751f, 0.00760144f, -0.06708178f, -0.01029655f, -0.04406692f, 
    0.05908507f, 0.01997963f, 0.04976256f, -0.00865710f, -0.09237206f, 0.05253621f, -0.00946448f, -0.01137326f, 
    0.07472231f, -0.16967840f, -0.07014371f, -0.01831187f, -0.12501577f, -0.00772905f, -0.04418322f, -0.12269715f, 
    0.02762696f, 0.00678811f, -0.04474135f, -0.03729372f, -0.08313341f, 0.09300885f, 0.02064399f, 0.09680681f, 
    0.10133859f, 0.12948145f, 0.14515111f, 0.13220784f, 0.12231907f, 0.21796331f, -0.01256582f, -0.00083929f, 
    0.01388159f, 0.04342369f, 0.00776821f, 0.09084257f, 0.15100046f, 0.17569827f, 0.01478420f, 0.17203170f, 
    -0.16936599f, -0.02431677f, 0.10204666f, -0.01350298f, 0.05392929f, 0.04328040f, -0.18562491f, 0.00247533f, 
    -0.18471898f, -0.10124290f, -0.05386754f, -0.01577590f, -0.06583573f, -0.01364768f, -0.06810879f, -0.03264821f, 
    -0.09907539f, 0.07109559f, -0.03019957f, 0.07993091f, -0.10960003f, 0.33413938f, -0.13246840f, -0.15127584f, 
    0.04865682f, 0.00117240f, 0.08403887f, 0.03536731f, 0.03644666f, 0.00089577f, -0.05674209f, -0.11682355f, 
    -0.20737641f, 0.01958169f, 0.05901927f, 0.00381544f, -0.13959911f, -0.06903482f, -0.07268810f, -0.04308067f, 
    0.00896224f, -0.08337129f, -0.12693144f, -0.03844384f, 0.19108512f, 0.16368741f, 0.05995023f, 0.20782955f, 
    0.09343784f, 0.04022940f, 0.03868956f, -0.01204637f, -0.01323498f, -0.02286340f, 0.03862142f, 0.08798245f, 
    0.19393237f, 0.23635085f, 0.17586184f, 0.12856618f, 0.01050049f, 0.15347093f, -0.06345981f, -0.13058898f, 
    -0.00587987f, -0.10161430f, -0.06710272f, -0.01890583f, 0.19048969f, -0.03427441f, 0.07812869f, 0.30117455f, 
    0.15137482f, 0.19285576f, 0.09662166f, 0.15738860f, 0.06424925f, -0.10257377f, -0.00952301f, 0.02196044f, 
    -0.11312935f, -0.23344581f, -0.06152686f, -0.10838061f, 0.04407459f, -0.10318642f, -0.19821319f, -0.01469678f, 
    0.08102812f, -0.02424640f, -0.06573483f, 0.06163153f, 0.01462487f, -0.00786054f, -0.23554727f, 0.09010720f, 
    -0.18495998f, -0.09218910f, -0.02354930f, -0.10999925f, -0.04607080f, -0.08481562f, -0.02874028f, 0.01895817f, 
    -0.41832486f, 0.02783011f, -0.00122303f, -0.11224679f, -0.05943192f, -0.02537379f, 0.11776163f, -0.03224199f, 
    0.05492285f, 0.01522078f, -0.02157130f, -0.04323068f, 0.25890145f, 0.26925573f, 0.09125400f, -0.00686380f, 
    0.00628830f, -0.06562575f, 0.05515285f, 0.04863911f, -0.03517617f, 0.08009825f, 0.01429284f, -0.05382730f, 
    -0.09858333f, 0.00070930f, 0.05369535f, -0.01301111f, -0.01670151f, 0.04346659f, 0.06248851f, 0.05388338f, 
    -0.01517721f, 0.04912931f, 0.03214435f, -0.03327627f, -0.19277059f, -0.30057859f, 0.02675538f, 0.16566952f, 
    -0.06192557f, 0.01984649f, 0.01085446f, -0.11910895f, 0.01102590f, -0.09196883f, -0.04369365f, -0.03950745f, 
    0.29888293f, -0.07637972f, 0.12516233f, 0.07404956f, -0.07392765f, 0.04427764f, 0.05351807f, -0.05858941f, 
    -0.07699312f, 0.16283657f, -0.05389749f, -0.11735428f, 0.18288997f, 0.07163720f, 0.16155784f, 0.01621254f, 
    -0.13964421f, -0.11083977f, -0.02567435f, -0.03912895f, -0.03010732f, 0.07126500f, -0.02271418f, -0.09882189f, 
    0.08563872f, 0.01108762f, 0.10122319f, 0.02969090f, -0.08727544f, 0.04520736f, -0.04626851f, 0.00706474f, 
    0.03268531f, -0.05703879f, -0.12166256f, -0.10983663f, -0.19978280f, -0.06229752f, -0.01100926f, 0.11691981f, 
    -0.10994951f, -0.05230676f, -0.03001248f, 0.04285717f, -0.00674772f, -0.07151410f, -0.00607160f, 0.08315743f, 
    -0.08886956f, -0.14665720f, -0.05370225f, -0.02256877f, 0.03443887f, 0.05201888f, -0.03910638f, 0.00666528f, 
    0.01236321f, 0.08193415f, -0.06910239f, 0.05573104f, 0.00945432f, -0.39512515f, 0.00996384f, -0.13704169f, 
    0.18559429f, 0.01785895f, -0.00394738f, 0.11698378f, 0.06456292f, -0.05459579f, -0.05435899f, -0.05363325f, 
    -0.15200573f, -0.10737560f, -0.04595116f, -0.08513319f, 0.03555626f, -0.08193988f, 0.02052084f, -0.02020234f, 
    0.05255663f, -0.08315662f, 0.05899145f, -0.05947700f, 0.23103397f, -0.02754115f, 0.08952235f, 0.07626361f, 
    0.14082325f, -0.00520092f, -0.01660497f, -0.01063478f, 0.00863090f, 0.03016471f, 0.09820079f, 0.07465965f, 
    0.13141213f, 0.10272056f, 0.09021560f, 0.13452175f, -0.15863432f, -0.07668590f, -0.03244330f, 0.06842142f, 
    0.06034950f, 0.03236498f, -0.01194977f, 0.08159997f, 0.10216665f, -0.09096273f, 0.06312454f, 0.02332995f, 
    -0.02876848f, -0.01643820f, 0.06990449f, 0.14775607f, 0.07578494f, 0.10682809f, -0.02682779f, -0.12271176f, 
    0.09388217f, -0.13241580f, 0.14964545f, -0.20856486f, 0.10847382f, -0.04151001f, 0.03927010f, 0.14949211f, 
    -0.00106227f, 0.04123490f, -0.02707524f, -0.00814045f, -0.17815152f, 0.00947848f, -0.04317608f, -0.11226185f, 
    0.18289721f, 0.03258073f, 0.08615278f, 0.04078279f, 0.08215143f, 0.04395079f, 0.01623358f, 0.01590713f, 
    0.04639938f, -0.26378265f, 0.01519278f, -0.15530124f, 0.17234735f, 0.02699074f, 0.01784506f, -0.01171241f, 
    -0.00576066f, -0.01223435f, 0.03179210f, -0.02209472f, -0.06728875f, -0.04884978f, 0.02120825f, 0.01297193f, 
    -0.07071941f, 0.00880258f, -0.09653387f, 0.08653933f, 0.02417354f, -0.05807848f, 0.11693379f, -0.03751542f, 
    0.00807437f, 0.10253674f, -0.14805259f, 0.15859157f, 0.21019153f, 0.02154992f, 0.01977409f, 0.04405382f, 
    0.00505880f, -0.04743484f, 0.07744740f, 0.01518173f, 0.06283179f, -0.17523636f, 0.30684003f, -0.11756887f, 
    -0.05573109f, -0.00429591f, 0.06273438f, 0.07439159f, -0.00908820f, 0.00900287f, -0.06318118f, -0.01788667f, 
    0.47963130f, -0.11135057f, -0.03972920f, -0.01286255f, 0.00360677f, 0.02037891f, 0.01680685f, -0.01934142f, 
    0.02504771f, 0.04392920f, -0.03219758f, -0.04314487f, 0.09101903f, -0.11844283f, 0.19339962f, -0.13530785f, 
    -0.03867669f, 0.01791043f, -0.01805390f, -0.01790044f, 0.01797721f, 0.05072308f, 0.09454835f, 0.06616815f, 
    0.09619791f, 0.00157845f, -0.14272921f, -0.01710363f, 0.09218840f, 0.07211293f, 0.11046892f, -0.00224404f, 
    0.09807967f, -0.06148053f, 0.09380166f, 0.05011646f, 0.14228827f, -0.01496350f, 0.10979391f, -0.03421711f, 
    -0.03641270f, 0.03176406f, 0.01877678f, -0.05517870f, -0.01631877f, -0.05651590f, 0.01311108f, -0.00346955f, 
    0.48223490f, -0.06160717f, 0.16118872f, -0.13698509f, 0.06191093f, -0.02758772f, -0.00957568f, 0.01730165f, 
    0.02665518f, -0.09295046f, 0.01515709f, -0.03387200f, -0.34879667f, 0.27496111f, -0.05370074f, -0.06370672f, 
    0.11710629f, -0.01309524f, -0.01514863f, -0.02331023f, -0.12726696f, 0.04941377f, -0.02270511f, 0.08344281f, 
    0.17503749f, 0.05628622f, 0.09221862f, 0.02013122f, -0.15598533f, 0.05736892f, -0.04038050f, -0.03081844f, 
    0.01644488f, 0.03195539f, 0.01848149f, -0.05027813f, -0.22510837f, -0.16578716f, -0.10398568f, 0.09994401f, 
    0.01644741f, -0.06806884f, 0.04583529f, 0.14201151f, 0.03285912f, 0.04971860f, -0.07002605f, -0.07610636f, 
    -0.04966339f, -0.20429477f, 0.00330463f, 0.09719393f, -0.08685987f, 0.06259566f, 0.02675162f, 0.04317236f, 
    0.01947462f, -0.00515322f, -0.09686148f, -0.01536529f, 0.01801962f, 0.11405286f, -0.13694213f, 0.00833806f, 
    0.02729251f, 0.09735782f, 0.09359173f, 0.09054314f, 0.02351286f, 0.02168334f, 0.05287550f, -0.05804057f, 
    0.16017276f, 0.01806787f, 0.05490158f, 0.02760941f, -0.01973085f, 0.15786861f, -0.02547939f, -0.01723997f, 
    0.01040539f, 0.07151653f, -0.04989692f, -0.02700881f, -0.08617945f, 0.18179241f, 0.06156892f, -0.03148448f, 
    -0.02267513f, 0.04432569f, -0.05675126f, -0.02340838f, 0.03327348f, 0.04114787f, -0.04228383f, 0.06140291f, 
    -0.00895873f, 0.17401287f, 0.04631443f, -0.14807951f, 0.01516823f, 0.07367472f, -0.04355391f, -0.03135505f, 
    0.01976491f, 0.01104068f, 0.02451126f, -0.01446809f, -0.29893225f, -0.10782974f, -0.05252454f, 0.07971594f, 
    -0.05788957f, 0.04379727f, 0.11417694f, -0.01515764f, 0.05068003f, 0.00273917f, 0.04132219f, 0.06538001f, 
    -0.00133795f, 0.13342157f, 0.01245737f, 0.10913182f, -0.02303714f, 0.10424430f, 0.02542360f, 0.00635093f, 
    -0.03481892f, 0.05369745f, -0.02876627f, -0.02921763f, 0.25050721f, 0.05694240f, 0.00834759f, 0.00867108f, 
    -0.07360958f, -0.04366142f, -0.07925260f, 0.05745998f, 0.06119023f, -0.07577326f, -0.05772850f, 0.00553814f, 
    0.14774771f, 0.13645609f, 0.17827699f, -0.16548212f, -0.08931433f, 0.02675005f, -0.02351009f, 0.00719075f, 
    -0.04624264f, 0.00497285f, 0.03147247f, 0.09155529f, 0.10503288f, 0.13374819f, -0.11927149f, 0.18734892f, 
    0.01801645f, -0.07628978f, 0.02014325f, -0.00246219f, -0.06357571f, 0.04254887f, -0.01309544f, 0.01923754f, 
    -0.10144847f, -0.04399602f, -0.09941064f, 0.08837523f, -0.16469114f, 0.02614473f, -0.03995316f, 0.01164640f, 
    -0.04523733f, 0.07343926f, 0.03824590f, -0.10191884f, 0.26489934f, 0.05357637f, -0.07244963f, -0.00582144f, 
    -0.18937807f, -0.02820735f, 0.02968382f, 0.00020780f, -0.06087613f, -0.06000005f, -0.09431978f, 0.00509733f, 
    0.03414595f, 0.05183901f, 0.10293127f, 0.14651141f, 0.12860724f, 0.06560196f, -0.04007237f, 0.02787670f, 
    0.05686254f, -0.01244762f, 0.03228845f, -0.16583888f, 0.22099909f, 0.29431415f, 0.10356458f, 0.08594880f, 
    0.04767210f, -0.02844980f, 0.10785117f, 0.05122091f, 0.04136213f, -0.00818104f, 0.02179491f, -0.05465189f, 
    -0.10462211f, 0.13919945f, -0.03079257f, -0.00725985f, 0.09936199f, 0.07703799f, -0.02166163f, -0.05908540f, 
    -0.01594128f, 0.10082944f, 0.18202408f, 0.07871512f, 0.19663507f, -0.00663080f, 0.14637011f, -0.00477436f, 
    -0.01502704f, 0.08702533f, 0.20566280f, -0.01875604f, -0.04669695f, -0.05557603f, -0.10130005f, -0.10046087f, 
    0.03506862f, -0.17879222f, -0.07999191f, 0.29614288f, 0.10191899f, 0.00868910f, 0.05567101f, 0.01334090f, 
    -0.00135777f, 0.11262940f, 0.02054130f, 0.08061281f, -0.17900825f, 0.10809392f, 0.02054998f, -0.10484440f, 
    0.01167710f, -0.03102729f, -0.11957693f, 0.00459089f, -0.11875514f, -0.04390234f, -0.01956034f, 0.08774067f, 
    0.17269205f, 0.11128383f, -0.02507785f, -0.11016464f, 0.01591251f, -0.04929621f, -0.07328548f, -0.11380067f, 
    -0.04027005f, -0.02696682f, -0.08288880f, -0.08346599f, 0.42797202f, 0.26177979f, 0.04234968f, 0.01870758f, 
    -0.04666751f, 0.00062476f, 0.02331450f, -0.07416701f, -0.03124536f, -0.01126112f, -0.02132671f, -0.07848815f, 
    0.26274362f, 0.25913015f, 0.02601823f, 0.05717174f, 0.07490738f, -0.03422240f, 0.09464641f, 0.01153066f, 
    -0.03382436f, 0.06719161f, 0.04353590f, -0.00391927f, 0.12986282f, 0.04462177f, -0.19857813f, -0.02104543f, 
    0.13996835f, -0.03409497f, -0.04994597f, -0.06041219f, -0.08795164f, 0.04807914f, -0.06042049f, 0.02670586f, 
    -0.10716803f, 0.08079989f, 0.14383307f, 0.07547487f, -0.10201149f, 0.02998948f, -0.11022133f, -0.11709149f, 
    0.03990558f, 0.06074521f, 0.01300841f, -0.04138551f, -0.02011240f, 0.11021467f, -0.10571659f, -0.14603816f, 
    0.01592529f, -0.05524397f, 0.00937983f, 0.00234013f, 0.08428287f, 0.01597430f, 0.03751360f, 0.20849925f, 
    -0.36924338f, -0.16657180f, -0.00406770f, 0.28080961f, -0.07096410f, -0.05596000f, -0.10637078f, 0.00737424f, 
    -0.03062025f, 0.12165272f, 0.07398148f, -0.01911583f, -0.04081981f, 0.30993330f, -0.01380996f, 0.04972510f, 
    0.12742531f, -0.01463084f, 0.00951434f, -0.05587699f, 0.02490025f, 0.00611484f, 0.02667069f, 0.03852126f, 
    0.20993449f, 0.02730478f, 0.16375965f, 0.06121905f, 0.03984823f, -0.00143513f, -0.09101148f, -0.02909918f, 
    0.00348983f, -0.05635934f, 0.09977821f, -0.05368694f, 0.00629774f, 0.24723807f, -0.08611845f, -0.08211137f, 
    0.04866667f, 0.04755415f, -0.05850124f, 0.05023418f, 0.06654081f, 0.08930739f, 0.11510489f, -0.04079009f, 
    -0.04337781f, -0.06301252f, -0.05578858f, -0.14838815f, 0.04254217f, -0.01356790f, -0.00356329f, 0.00746122f, 
    -0.06248763f, 0.04518392f, -0.01385801f, -0.05555749f, -0.35738224f, -0.06956763f, 0.19565988f, 0.10804790f, 
    -0.07404614f, -0.03045239f, -0.03301746f, 0.00238768f, 0.01426431f, -0.04879966f, -0.02229465f, -0.17886841f, 
    0.22018510f, 0.02487433f, -0.11483862f, 0.09046596f, 0.01240309f, -0.06929522f, 0.08687526f, 0.01413206f, 
    0.04196512f, 0.12712854f, 0.02028559f, -0.00738979f, 0.17277466f, 0.13108827f, 0.07144597f, 0.02037518f, 
    -0.01375643f, -0.04864301f, -0.04946605f, -0.10486259f, -0.11979747f, 0.10271820f, 0.07165108f, 0.00665765f, 
    0.09899894f, 0.05775728f, -0.07056249f, -0.01182251f, 0.11079963f, -0.18827434f, 0.02071334f, 0.00150329f, 
    0.02590085f, -0.05443304f, -0.01983303f, 0.03083785f, 0.12950368f, 0.10406337f, 0.12642604f, -0.04573847f, 
    0.00228981f, 0.06786636f, 0.05295691f, -0.12517580f, 0.06727303f, 0.04924037f, -0.07309551f, -0.01358730f, 
    0.10602736f, -0.13198483f, 0.06143059f, -0.06380806f, -0.01335147f, -0.05331804f, 0.16214792f, -0.05421102f, 
    -0.02480639f, -0.00195890f, -0.03270039f, 0.06302753f, 0.13064061f, -0.26250929f, -0.10070623f, 0.01900653f, 
    0.05421872f, -0.03410670f, -0.00618788f, 0.04634587f, -0.00718085f, 0.04073211f, 0.08435193f, 0.01237109f, 
    0.18151683f, 0.02115544f, 0.10520344f, 0.03953958f, -0.02017890f, 0.05303993f, -0.06359844f, 0.02686978f, 
    0.00119754f, 0.04004505f, 0.05221227f, 0.11695550f, 0.07976600f, 0.11478680f, -0.04698179f, 0.10706066f, 
    0.07717507f, -0.09750266f, -0.00744900f, -0.03308140f, -0.03260756f, 0.10460498f, 0.00662953f, -0.05115118f, 
    -0.04093979f, -0.04143597f, -0.14990865f, -0.07865363f, 0.04034522f, -0.14233844f, -0.10966919f, -0.04667351f, 
    0.06457914f, -0.03418137f, -0.04382646f, -0.03986304f, 0.01230604f, -0.06833015f, -0.11937634f, 0.01805435f, 
    0.11863840f, 0.04921575f, 0.04167296f, 0.05870104f, -0.01310082f, -0.02858009f, 0.05277353f, 0.03818523f, 
    -0.11013632f, 0.07267552f, 0.05370157f, -0.03082098f, 0.01508441f, 0.05448048f, -0.10807467f, 0.03903726f, 
    -0.00079846f, 0.01653594f, 0.02879058f, 0.02147296f, 0.04137497f, -0.13426191f, 0.19878599f, 0.08389489f, 
    -0.02531927f, 0.01709470f, 0.04148590f, 0.07766196f, 0.02502565f, 0.00975645f, -0.06306490f, -0.16890493f, 
    0.17687608f, 0.13422726f, -0.11601806f, 0.10826544f, -0.06321651f, -0.01565785f, 0.05365026f, -0.04228374f, 
    -0.15313494f, -0.06567608f, 0.10567393f, 0.06532533f, -0.08880943f, -0.25126091f, -0.29378846f, 0.13011080f, 
    0.10674349f, -0.08455148f, 0.00445254f, 0.02133049f, 0.05512352f, 0.13792053f, -0.02137924f, 0.16140248f, 
    -0.08730207f, 0.00305256f, -0.16564423f, -0.28365827f, -0.04869641f, 0.00171898f, -0.07077761f, -0.05671427f, 
    0.02472901f, 0.12819965f, -0.08927831f, 0.22207008f, 0.00917654f, 0.28196156f, 0.02263980f, -0.02406836f, 
    -0.10936568f, -0.06391849f, -0.00069057f, -0.06643307f, -0.09541106f, 0.07110021f, 0.00789425f, 0.19219576f, 
    0.29995680f, 0.13741830f, -0.01994475f, -0.01827764f, -0.05193193f, 0.08158454f, 0.02723704f, -0.05194235f, 
    -0.03506154f, -0.04373706f, -0.00279134f, -0.05086555f, -0.03130520f, 0.02127405f, 0.13348207f, -0.07006378f, 
    -0.04587209f, 0.14968964f, 0.07653864f, 0.02139572f, 0.04881306f, -0.00713792f, -0.04114844f, 0.00227598f, 
    -0.09812266f, 0.04256431f, 0.12183800f, -0.08237821f, -0.16140187f, -0.07097149f, -0.02663960f, 0.06226733f, 
    0.05682636f, -0.06888885f, -0.00945924f, -0.16450055f, -0.15657672f, -0.00105202f, -0.12699574f, -0.11935671f, 
    0.25546005f, 0.08877902f, 0.01579932f, 0.00981702f, -0.05607074f, -0.09492591f, 0.09764180f, 0.04347521f, 
    -0.17672414f, 0.00749053f, 0.08622431f, 0.14701545f, 0.01562043f, 0.03838700f, 0.05151089f, 0.08250274f, 
    0.05227114f, -0.00640682f, 0.13951151f, -0.00569382f, 0.28152880f, -0.06115582f, 0.15731922f, 0.17324822f, 
    -0.06462152f, 0.00407180f, -0.04344377f, 0.09396887f, 0.01601132f, 0.01828888f, 0.06044763f, 0.10004778f, 
    -0.33720851f, 0.14511329f, 0.09777667f, -0.04469906f, -0.07414476f, -0.02010933f, 0.20952567f, 0.15939227f, 
    0.02791855f, 0.14065139f, 0.09708234f, 0.03435092f, -0.10212420f, 0.08496772f, 0.15844265f, 0.19797687f, 
    0.00077881f, -0.08298316f, 0.01209244f, -0.05599779f, -0.00546445f, 0.00122861f, 0.12359732f, -0.10197002f, 
    0.32302970f, 0.01386590f, 0.00790613f, 0.20838000f, -0.11723313f, 0.07123225f, -0.11436448f, 0.05744936f, 
    0.15790412f, 0.01853381f, 0.03910585f, 0.12920257f, -0.04874137f, -0.02915793f, -0.03944604f, 0.05292214f, 
    0.04987157f, -0.03487088f, -0.02435777f, -0.02850998f, -0.08003621f, -0.06056583f, 0.07945648f, -0.07726420f, 
    0.08352491f, 0.12681356f, 0.12272620f, -0.11455067f, 0.13822617f, 0.06452854f, -0.03766259f, 0.02845673f, 
    -0.00464541f, 0.00168206f, 0.09379824f, 0.02373817f, -0.08913334f, 0.12742659f, -0.11466937f, 0.01950704f, 
    -0.07446507f, 0.15014428f, 0.03696288f, -0.02463139f, -0.05381756f, -0.14920066f, -0.11031035f, -0.07936325f, 
    -0.27124166f, -0.06810403f, 0.11332199f, 0.02149931f, -0.07717368f, -0.01674643f, 0.00632238f, 0.01565371f, 
    -0.01812351f, 0.06467575f, -0.05583720f, 0.06960128f, -0.14995685f, -0.17520005f, -0.24357201f, -0.32166043f, 
    0.05767052f, 0.10505661f, -0.05786708f, -0.01259792f, -0.01155002f, 0.02943734f, 0.07621961f, -0.03370433f, 
    -0.21052052f, 0.16968502f, -0.04974701f, 0.17735597f, 0.14313540f, 0.06054934f, -0.07966705f, 0.08849942f, 
    0.17573540f, 0.05640067f, 0.03637119f, 0.01886101f, 0.50580406f, -0.05730510f, -0.03624889f, 0.14855495f, 
    -0.02428291f, 0.01725644f, -0.02936057f, 0.03011102f, -0.00831448f, 0.03462194f, 0.13643596f, 0.08759621f, 
    -0.03412230f, 0.03075701f, -0.02663130f, -0.16891421f, 0.22361583f, 0.00351343f, -0.02540724f, -0.04009256f, 
    0.07286805f, -0.04452827f, 0.00646022f, 0.08857346f, -0.09750053f, 0.01914398f, 0.10187667f, -0.31029570f, 
    0.03257647f, 0.05218109f, 0.06627655f, -0.00549259f, -0.05649634f, -0.01844699f, -0.14976083f, -0.09604836f, 
    -0.23230565f, -0.05641638f, 0.07133818f, -0.17677644f, 0.00610815f, 0.07503721f, -0.05809005f, -0.05225481f, 
    -0.10685287f, -0.07106028f, 0.09093571f, -0.08988193f, -0.17180015f, -0.03684209f, 0.18392488f, -0.16307665f, 
    -0.05303233f, -0.13293910f, -0.15115620f, 0.11270862f, -0.03082612f, 0.07806263f, 0.01268940f, 0.00410326f, 
    -0.02330645f, 0.21197635f, 0.06204597f, 0.21101119f, -0.09038316f, -0.05388324f, -0.01753431f, -0.03670361f, 
    -0.13444053f, -0.00215045f, 0.03202089f, -0.07227063f, 0.16172504f, 0.02645880f, 0.07939103f, 0.09304991f, 
    0.02254976f, -0.05545533f, -0.09844447f, 0.07794473f, -0.11129690f, 0.19390865f, 0.06838247f, -0.01761534f, 
    0.30691445f, -0.10532018f, -0.13114001f, 0.10456951f, -0.04637311f, -0.03503463f, -0.00431144f, 0.03475945f, 
    0.02106205f, 0.11792759f, -0.09155627f, -0.16485804f, 0.21068421f, 0.08683519f, -0.14138138f, -0.23810260f, 
    0.12234078f, 0.06674309f, -0.08322801f, 0.06203527f, -0.02481617f, -0.10637140f, -0.05375319f, -0.02487437f, 
    0.20209432f, 0.00626713f, 0.07265679f, 0.26628587f, 0.00207615f, 0.03503064f, -0.07965948f, -0.02742924f, 
    -0.00630457f, 0.07836946f, 0.04419281f, -0.02685033f, -0.02115928f, 0.06290454f, 0.13219935f, 0.12034205f, 
    0.13734938f, -0.00362524f, -0.04219369f, 0.06373366f, 0.07825245f, 0.09549300f, -0.07688756f, -0.01074265f, 
    0.00102641f, -0.22850522f, -0.19386844f, -0.07515232f, -0.03775575f, -0.09798102f, 0.00191955f, 0.09719361f, 
    0.05031180f, -0.04678985f, 0.03172767f, 0.01470728f, -0.02859324f, -0.01344163f, -0.22414570f, -0.16886351f, 
    -0.02371803f, 0.12983741f, -0.05856628f, 0.02277253f, 0.00801609f, -0.07257167f, -0.03245756f, 0.09248990f, 
    -0.11972930f, -0.24437954f, -0.19338368f, -0.27539599f, 0.19976252f, 0.10365741f, 0.17772146f, 0.04701829f, 
    0.06973160f, 0.02386591f, -0.07476185f, 0.02086979f, -0.10043459f, 0.10906069f, 0.18503505f, 0.16787644f, 
    0.06526541f, -0.00062577f, 0.01369962f, -0.04722361f, 0.04226789f, 0.01867109f, 0.19031072f, -0.20489331f, 
    -0.05178887f, 0.15111867f, -0.03046122f, -0.09896776f, -0.07098909f, -0.00619356f, 0.10253538f, 0.12423131f, 
    -0.04666162f, -0.02547968f, -0.00851930f, 0.04076812f, -0.08162983f, 0.20143285f, -0.05338359f, 0.07339239f, 
    0.04387472f, -0.05533888f, 0.06450966f, 0.06075663f, -0.01702060f, -0.05236079f, -0.01010807f, 0.05907162f, 
    -0.28856304f, 0.11107443f, 0.00660655f, 0.04824519f, 0.00006735f, 0.01744911f, 0.02015267f, 0.00808978f, 
    -0.11476537f, 0.01963804f, 0.01025965f, -0.01526080f, -0.22328851f, -0.19847310f, -0.09771842f, 0.00619334f, 
    0.03721075f, 0.05804652f, 0.02180117f, 0.00196228f, -0.01387757f, 0.06662365f, -0.10908275f, 0.04609016f, 
    -0.04633351f, -0.15876737f, -0.02942588f, 0.14654757f, -0.05703283f, 0.07372308f, -0.06328861f, -0.11218990f, 
    -0.04970629f, -0.00299884f, 0.10468943f, -0.08197355f, 0.07834395f, 0.13262653f, -0.03545746f, -0.08368115f, 
    0.04464060f, -0.01000353f, -0.03665813f, -0.12692317f, -0.07554704f, 0.02579584f, -0.15329078f, 0.08554228f, 
    -0.05131630f, 0.05835899f, 0.03514105f, 0.15596993f, -0.04545230f, 0.06291833f, -0.07166638f, 0.10618810f, 
    -0.03169202f, 0.01625329f, 0.08017450f, 0.10239442f, -0.12526482f, 0.16105977f, 0.17068385f, 0.17591378f, 
    -0.05296873f, -0.04886198f, 0.00448349f, 0.02274209f, 0.02708063f, -0.07890151f, 0.14156435f, -0.02244926f, 
    -0.10289641f, -0.10608567f, -0.03240709f, 0.07284310f, -0.09281605f, 0.02267624f, -0.02976400f, 0.14206702f, 
    0.03783716f, 0.05617205f, 0.04146980f, 0.03693027f, 0.04035512f, -0.11219931f, 0.02259210f, 0.03367584f, 
    0.00630972f, -0.04196014f, -0.02112780f, -0.01690682f, 0.02931087f, -0.10760717f, -0.13968527f, 0.00293130f, 
    0.14816268f, -0.07161648f, -0.09258577f, -0.02471864f, 0.02039324f, -0.07810617f, 0.02320249f, 0.04414061f, 
    -0.08190484f, 0.02432518f, 0.00587373f, 0.04813248f, -0.02767987f, 0.03901361f, -0.29964149f, 0.11649562f, 
    0.08948823f, 0.03822951f, -0.04809591f, 0.00762334f, 0.02670603f, -0.04937225f, 0.04189340f, -0.07149155f, 
    -0.23056705f, 0.22251558f, 0.10918496f, -0.06117142f, 0.08047007f, -0.00106908f, -0.08427984f, -0.04943397f, 
    0.13287883f, -0.06142960f, 0.08428497f, -0.00141787f, 0.03053849f, 0.04070673f, -0.04681613f, -0.13275802f, 
    -0.08590315f, -0.01389078f, -0.02833328f, -0.04505493f, -0.02238039f, 0.13181230f, -0.10921551f, -0.01985463f, 
    -0.12750690f, 0.02195347f, 0.18782243f, 0.23062231f, -0.02101172f, -0.10031989f, -0.06409919f, 0.05905526f, 
    0.20911087f, 0.17544246f, 0.02401632f, -0.01366031f, 0.01122516f, -0.02044840f, -0.01439730f, -0.00350034f, 
    -0.05255376f, 0.07847200f, 0.02995684f, 0.08054615f, 0.07276952f, 0.18882161f, 0.07754935f, 0.04907145f, 
    -0.10072832f, -0.15620033f, -0.03201711f, 0.00585409f, 0.00232300f, 0.04802367f, -0.08162877f, -0.04300586f, 
    0.13491386f, 0.13975306f, 0.04351003f, 0.08393275f, 0.02214925f, 0.11054460f, -0.11030670f, -0.15431935f, 
    0.01204146f, 0.00358918f, -0.05652611f, 0.11164672f, 0.06766285f, 0.02747674f, 0.06381152f, 0.02635205f, 
    -0.27079016f, -0.05480577f, 0.03083916f, 0.02543776f, 0.07379251f, 0.07741138f, -0.01694659f, -0.17707872f, 
    0.24575329f, -0.07185885f, 0.06925173f, 0.03590322f, 0.14737490f, 0.18267570f, 0.06746193f, -0.05838650f, 
    0.00427996f, -0.00167072f, 0.00925360f, 0.02845189f, -0.03844541f, 0.05255419f, 0.08675610f, 0.01808667f, 
    0.09973982f, 0.10653732f, 0.07235727f, 0.10825284f, 0.02104299f, 0.01397582f, -0.07736632f, -0.00886686f, 
    0.03677936f, -0.08902398f, 0.11935104f, 0.04480177f, -0.09117395f, -0.03106365f, 0.17573437f, 0.02832413f, 
    0.00153897f, -0.05932321f, 0.10426623f, 0.07712159f, -0.14470549f, -0.03560153f, -0.00465329f, 0.16268919f, 
    0.12813474f, -0.18502128f, -0.05647995f, -0.06097057f, 0.06539907f, 0.01440257f, -0.00481978f, -0.08424982f, 
    0.07642248f, -0.03944810f, -0.03622087f, 0.05208997f, 0.33631647f, -0.20353977f, -0.12047114f, 0.00748629f, 
    -0.03624737f, -0.00865023f, 0.00610345f, 0.04405477f, 0.13998818f, -0.02709989f, 0.02534672f, -0.01946793f, 
    -0.39549789f, 0.03138700f, -0.19622619f, 0.06663612f, 0.00387975f, -0.09172063f, -0.03375170f, -0.01658814f, 
    -0.01491207f, -0.10490128f, 0.06382946f, 0.13067351f, 0.12845387f, 0.04414987f, -0.07563966f, -0.12251295f, 
    -0.01771512f, 0.01741162f, 0.03163725f, -0.02680547f, 0.03036906f, 0.09026159f, -0.04887831f, -0.07082964f, 
    0.23981389f, -0.11179508f, -0.01297299f, 0.15345009f, 0.08682540f, 0.04799568f, -0.06443278f, 0.05764442f, 
    0.02344730f, -0.04096139f, 0.05651966f, 0.05261970f, -0.17657430f, -0.13085668f, 0.05693008f, 0.25592044f, 
    0.05898305f, -0.06949836f, -0.03223709f, -0.01043315f, 0.12753032f, 0.13008615f, -0.03871263f, -0.02456662f, 
    0.15991002f, -0.15530080f, -0.14156267f, -0.09547608f, -0.11825930f, -0.02792501f, 0.02185572f, -0.07683646f, 
    0.00191415f, 0.01636037f, -0.08611923f, -0.06756946f, -0.00753553f, -0.02832607f, 0.12965509f, 0.08642736f, 
    -0.00576307f, 0.01307220f, 0.02988341f, -0.00984589f, 0.16793385f, -0.01201143f, -0.00518903f, -0.02953625f, 
    -0.19509314f, -0.19384274f, 0.06642240f, -0.15977500f, 0.07649909f, 0.06624229f, 0.09534259f, 0.06176347f, 
    0.17785159f, 0.01849423f, 0.03124182f, 0.11403241f, -0.00575448f, -0.07871096f, 0.07000206f, 0.30623600f, 
    -0.00852423f, -0.03852519f, -0.05588965f, 0.03263088f, 0.07462312f, 0.06643416f, 0.03207575f, 0.01739929f, 
    -0.19030048f, -0.18525438f, -0.01460976f, 0.15087098f, 0.06939163f, 0.03998982f, -0.04556463f, -0.06316667f, 
    0.03165696f, 0.19303501f, 0.11035671f, 0.03775973f, 0.15686764f, -0.09295692f, 0.13828743f, 0.07199919f, 
    0.04440279f, 0.06177800f, -0.11677425f, 0.09367712f, -0.05595904f, 0.03622675f, -0.02708545f, 0.03214752f, 
    0.36672980f, 0.01069363f, -0.07188994f, 0.01365711f, 0.04516412f, -0.01320295f, -0.02586179f, -0.01814929f, 
    0.06514616f, 0.08910804f, 0.03239845f, 0.02884934f, 0.12709877f, 0.32113001f, 0.06384049f, 0.18592946f, 
    -0.05565093f, 0.05072403f, 0.04124639f, 0.07569800f, -0.07922468f, -0.07417063f, 0.04427046f, 0.00587700f, 
    0.08381861f, -0.04214679f, -0.01687705f, 0.17400007f, 0.16229460f, 0.03204610f, -0.01360817f, 0.03978988f, 
    -0.07217044f, -0.02315793f, -0.11479911f, -0.01168403f, -0.06440942f, -0.07947821f, 0.04372166f, 0.05698244f, 
    0.03213387f, 0.09998475f, 0.02328688f, 0.14956102f, 0.04776103f, 0.06026842f, 0.07836825f, -0.09897059f, 
    -0.05488690f, 0.06958042f, 0.09492716f, -0.02222457f, 0.00566631f, -0.04362616f, 0.05770013f, 0.01124936f, 
    -0.01558191f, -0.00913555f, -0.00152194f, -0.11911832f, 0.17783031f, 0.05522186f, 0.05561865f, 0.02948522f, 
    0.07195019f, 0.07497440f, 0.06579754f, 0.10639207f, 0.00290236f, 0.01734665f, -0.08619423f, 0.00663071f, 
    0.11076073f, 0.23191823f, 0.07659695f, -0.00410560f, 0.14411971f, 0.01750701f, 0.03998945f, -0.00123453f, 
    -0.05493471f, 0.00572641f, -0.00591174f, -0.05207746f, -0.15334925f, 0.04536473f, -0.08966313f, 0.04254893f, 
    0.02469991f, 0.04847836f, -0.02745425f, -0.06737286f, -0.06788364f, 0.00271260f, 0.18438256f, 0.04474497f, 
    0.03899042f, 0.07843544f, 0.11284366f, -0.01370249f, -0.04343250f, -0.02737216f, -0.08625821f, -0.01973946f, 
    -0.01560593f, 0.00438128f, 0.04421329f, 0.01550256f, -0.04160123f, 0.12733088f, 0.14951010f, -0.12655151f, 
    0.06262827f, -0.08125739f, -0.03195424f, 0.05355231f, -0.10202081f, -0.05387304f, -0.01636540f, 0.07032446f, 
    0.08536584f, -0.06990408f, -0.17990556f, -0.03536228f, -0.04287678f, -0.08061628f, 0.03081165f, 0.04060985f, 
    -0.03619824f, -0.04770658f, 0.02367091f, -0.11925430f, 0.20720036f, 0.18044789f, 0.17886609f, 0.03740102f, 
    0.09548602f, 0.10156957f, 0.03062595f, 0.03243196f, 0.03444435f, -0.17939356f, 0.07938691f, -0.01581647f, 
    0.10675395f, 0.03606813f, -0.02504583f, 0.03457702f, 0.00141653f, 0.05561322f, 0.07902578f, -0.14627090f, 
    -0.02873562f, -0.13834475f, 0.01403563f, 0.02251655f, -0.08494937f, 0.19384170f, -0.09138774f, -0.15776187f, 
    0.05077134f, -0.03156715f, -0.02800167f, -0.06541277f, -0.06059849f, -0.00639758f, -0.09215013f, -0.00671176f, 
    0.25686580f, 0.19435838f, -0.02196011f, -0.11182075f, 0.03365318f, 0.01315553f, 0.02002293f, 0.10013127f, 
    -0.08620411f, -0.05865408f, -0.00863599f, -0.03433829f, -0.02494894f, -0.26662651f, 0.14241962f, 0.11951383f, 
    -0.03020702f, -0.03388699f, 0.03188771f, -0.10386943f, -0.00097495f, 0.04672880f, -0.00409965f, 0.10042620f, 
    0.53495413f, 0.02477399f, -0.26517516f, -0.08283050f, 0.01010018f, -0.01142239f, 0.01914328f, 0.01531212f, 
    -0.12676147f, 0.00693207f, -0.02543815f, -0.02579711f, -0.11511464f, -0.01513559f, -0.04307910f, -0.00673170f, 
    -0.00485179f, 0.02967247f, 0.03678272f, -0.06503981f, 0.03592328f, -0.02025138f, 0.00563607f, -0.10773989f, 
    -0.24066524f, -0.18994057f, -0.10130771f, -0.22027457f, -0.03916096f, -0.03327941f, 0.09778686f, 0.06129284f, 
    0.03342978f, -0.03574482f, -0.09150407f, -0.05487769f, 0.16573584f, 0.18470989f, 0.03107624f, 0.12486218f, 
    -0.05794570f, -0.01301676f, -0.07763263f, -0.00197893f, 0.05876075f, 0.07517327f, 0.07585105f, -0.12216336f, 
    0.04480093f, 0.29739702f, 0.01867107f, 0.00807552f, 0.03736953f, 0.02561097f, 0.07174381f, 0.01838208f, 
    -0.07419971f, -0.02307229f, 0.03041084f, -0.14630716f, 0.03173894f, 0.13798352f, 0.00655970f, -0.01945374f, 
    0.10255118f, -0.06170987f, 0.03160555f, -0.09828189f, -0.11015673f, 0.17599219f, 0.12494963f, -0.00376714f, 
    0.45121044f, -0.10635074f, 0.10155450f, -0.04450842f, 0.00080216f, 0.08608028f, 0.03718941f, -0.00079424f, 
    0.01014530f, -0.01262502f, -0.04362641f, -0.01902562f, -0.15573099f, -0.00329309f, -0.05869966f, 0.14827579f, 
    0.03795830f, 0.05105492f, -0.01493133f, 0.01520674f, 0.07344497f, -0.06635211f, -0.09464975f, 0.01389977f, 
    0.03420880f, 0.06113889f, -0.08438270f, -0.11059567f, 0.04153664f, -0.06544024f, -0.02791308f, -0.17962024f, 
    0.02258503f, 0.03097924f, -0.00190026f, -0.01950088f, 0.16942371f, 0.12413293f, -0.22393857f, -0.09528794f, 
    0.02201402f, 0.10866488f, 0.02460404f, 0.01254915f, -0.03960016f, -0.06827600f, -0.00775522f, 0.02643312f, 
    -0.10631011f, 0.41075549f, -0.10962430f, 0.08177327f, 0.10465971f, -0.04152356f, -0.07867497f, 0.01634138f, 
    0.05312524f, 0.09391542f, 0.05390780f, 0.08225749f, -0.08439970f, 0.22767173f, -0.29682791f, -0.07905954f, 
    -0.00024264f, 0.07320958f, -0.03327819f, 0.06348974f, -0.08051528f, 0.10429232f, 0.13221121f, -0.00339960f, 
    0.33723778f, 0.01550005f, -0.25947011f, 0.05846930f, -0.00662833f, -0.15218703f, -0.04806327f, -0.12044457f, 
    -0.20680720f, 0.14356980f, 0.05304276f, -0.00243358f, 0.12361129f, -0.07745104f, -0.22722544f, -0.08205434f, 
    0.03163826f, 0.09302922f, 0.00255258f, -0.10233729f, -0.11910205f, -0.05508636f, -0.02717815f, -0.03303304f, 
    -0.03172427f, -0.03178513f, -0.07875898f, 0.07536554f, 0.05011557f, 0.05429861f, 0.05219808f, 0.07689378f, 
    -0.01000675f, 0.08859928f, 0.08914156f, -0.07628795f, -0.11146495f, -0.09449740f, 0.07771028f, -0.07299227f, 
    -0.04956099f, -0.02698433f, -0.02174211f, 0.06690876f, 0.05282594f, -0.05464150f, 0.03169707f, 0.01086874f, 
    0.19846629f, 0.00329256f, 0.15214530f, 0.04972880f, 0.07654765f, 0.04570233f, 0.02361644f, 0.04136708f, 
    0.01710300f, 0.03702368f, -0.03538951f, 0.05811093f, -0.17469926f, 0.03982083f, -0.00472967f, -0.00820956f, 
    0.03026031f, 0.03498137f, 0.00197560f, -0.00267758f, 0.03033836f, 0.02996052f, -0.01327109f, 0.03407335f, 
    0.14814445f, -0.07231913f, 0.00054068f, 0.10753644f, 0.15004754f, 0.15213467f, 0.11233376f, -0.00104010f, 
    -0.00978718f, -0.01392174f, -0.04668339f, 0.12379391f, -0.04919485f, 0.03156463f, -0.01070749f, 0.07868180f, 
    -0.01418346f, 0.04088332f, 0.14093287f, 0.09744707f, 0.04985391f, 0.03356335f, 0.05830367f, 0.06283005f, 
    0.11639692f, -0.05576259f, -0.04229701f, 0.01429851f, -0.07266399f, -0.04537581f, 0.01595618f, -0.01249783f, 
    0.00050842f, -0.02858752f, -0.00064362f, 0.00197609f, 0.05962653f, -0.16891503f, -0.18275279f, -0.05241123f, 
    0.03308960f, -0.03189847f, -0.13247624f, 0.09804992f, -0.04593967f, -0.00432293f, -0.03795059f, 0.03524490f, 
    -0.25969386f, 0.00060691f, 0.09230660f, -0.10531457f, 0.05503576f, -0.01660773f, 0.00642057f, -0.00469485f, 
    -0.05201434f, -0.03447101f, 0.05397956f, -0.02140708f, 0.10613231f, 0.16622476f, 0.02969599f, 0.02862738f, 
    0.02815541f, 0.01949118f, 0.18471344f, 0.06532621f, 0.01197118f, 0.07290668f, 0.05314342f, 0.02428492f, 
    -0.13707717f, 0.21981427f, 0.27298898f, -0.06717209f, 0.04963071f, 0.05929275f, -0.01918869f, -0.02649418f, 
    0.03997378f, 0.06280802f, 0.03070079f, -0.06426904f, 0.08533979f, 0.19680056f, 0.01777166f, -0.06489016f, 
    0.01843731f, -0.04931489f, 0.05532564f, 0.03713955f, -0.05233048f, -0.05979337f, 0.04526464f, 0.03179727f, 
    -0.13853721f, -0.07458447f, 0.03223760f, 0.15568586f, 0.04505360f, 0.04850442f, 0.02843209f, -0.02337600f, 
    0.00911373f, -0.03219500f, -0.04152298f, 0.11645735f, -0.28977191f, 0.01000298f, -0.08713395f, -0.02466905f, 
    -0.04631018f, -0.06281074f, 0.02659364f, 0.15111512f, -0.01903916f, -0.02525413f, 0.07860382f, -0.01305501f, 
    -0.04530814f, -0.00461934f, -0.16993485f, -0.05885831f, -0.06561127f, -0.00734134f, 0.06926762f, 0.06907817f, 
    0.03485574f, 0.04358352f, -0.02263783f, -0.02008745f, -0.04850521f, -0.06871670f, 0.04612802f, 0.13214004f, 
    0.04161175f, -0.17120579f, 0.13457009f, 0.07490655f, -0.04805246f, -0.05190156f, -0.03339335f, 0.06912225f, 
    -0.05771132f, 0.19791152f, 0.13746755f, 0.06320519f, 0.02394537f, -0.03132946f, 0.15800728f, -0.00571384f, 
    -0.10159674f, 0.01161161f, -0.03389677f, -0.03208645f, 0.17250550f, -0.14409921f, 0.05703002f, 0.03966943f, 
    -0.00295270f, -0.01239423f, 0.03325929f, -0.06726976f, 0.15021499f, 0.01933672f, -0.07122892f, -0.05337461f, 
    0.01993478f, 0.14081688f, 0.08550959f, 0.02839766f, 0.07302645f, -0.03648042f, 0.05493892f, 0.06280822f, 
    -0.14235835f, -0.00820414f, -0.01888434f, -0.07401023f, 0.06388677f, -0.03754114f, -0.04126795f, 0.06824066f, 
    0.02786939f, -0.00504991f, -0.04698036f, -0.14415789f, -0.01239581f, -0.01481010f, 0.08269543f, 0.06569596f, 
    -0.04865741f, 0.08160995f, -0.14337909f, 0.08595153f, 0.03524155f, 0.13093865f, 0.12084257f, -0.01522352f, 
    0.05788418f, -0.00000539f, 0.01803551f, 0.02097393f, 0.03151030f, -0.23400502f, -0.17746826f, 0.13561018f, 
    -0.00795177f, 0.00473196f, -0.03606601f, -0.00006327f, 0.20229651f, -0.01120051f, -0.00934437f, 0.03051579f, 
    -0.07984975f, 0.07380977f, 0.08075158f, 0.02235178f, -0.02771791f, -0.01908489f, 0.00868804f, 0.00924055f, 
    0.01764530f, -0.06098656f, -0.02943837f, 0.11143878f, 0.11999770f, -0.01356957f, 0.02081031f, 0.03385300f, 
    0.05222613f, 0.00739864f, 0.14585498f, -0.02475952f, -0.02035415f, -0.00307488f, -0.08838318f, 0.05104645f, 
    0.17587724f, 0.01605859f, 0.21300177f, -0.11548492f, 0.00252532f, 0.10478381f, 0.11063158f, 0.06937476f, 
    0.07581180f, -0.04897685f, 0.06751604f, -0.03308382f, 0.08620473f, -0.11970606f, 0.12932836f, 0.00464944f, 
    0.02852362f, 0.00667056f, -0.04832941f, 0.07437638f, -0.06477654f, 0.13315499f, 0.01109242f, 0.04917312f, 
    0.01208745f, 0.00996323f, 0.04830365f, -0.06172165f, 0.06561488f, -0.06254052f, 0.05929204f, -0.04723346f, 
    0.05993142f, 0.08197727f, 0.00772788f, 0.03814049f, -0.01361195f, 0.04689314f, 0.16543540f, 0.04920620f, 
    0.05325595f, 0.17496894f, 0.12028462f, -0.01620388f, -0.14451890f, -0.08426946f, 0.08686921f, 0.06680039f, 
    0.10908072f, -0.22192003f, -0.02963729f, 0.16625980f, 0.06490383f, -0.05978631f, 0.17982358f, 0.20872588f, 
    0.02400964f, 0.13825940f, -0.00108425f, 0.01615268f, 0.06586287f, -0.06994832f, -0.05769243f, -0.10792731f, 
    -0.01741092f, 0.07944243f, 0.06736810f, 0.14180319f, 0.04184373f, 0.04972335f, 0.07054871f, 0.00560856f, 
    -0.00747650f, 0.27142051f, -0.05446085f, 0.04178323f, 0.07062000f, 0.01737149f, -0.00309921f, 0.14528039f, 
    -0.02910036f, 0.01424536f, 0.01435246f, 0.05333043f, 0.14021434f, -0.02481002f, 0.02709210f, 0.08990620f, 
    0.07866876f, 0.08465198f, 0.07412938f, -0.09552195f, 0.02411944f, 0.04188176f, 0.02561457f, 0.06466577f, 
    -0.05495540f, 0.09036068f, 0.02692575f, -0.03860461f, -0.00985875f, 0.07456244f, -0.03065154f, 0.04975769f, 
    -0.04922608f, -0.01642201f, -0.05415027f, -0.11113361f, -0.20812972f, -0.07047451f, 0.15763615f, -0.04895059f, 
    0.06784764f, -0.05062303f, -0.08596081f, 0.06219812f, 0.15725164f, -0.00895740f, 0.06258463f, 0.01836946f, 
    0.08483849f, 0.02161269f, -0.23293439f, -0.24233063f, 0.04492822f, 0.09054900f, -0.09688126f, 0.03793267f, 
    -0.00784539f, 0.05098346f, 0.12598377f, 0.00190654f, 0.18987389f, -0.08734313f, 0.10669913f, 0.00608813f, 
    0.00661737f, -0.04658162f, -0.06043242f, 0.01732153f, 0.06917039f, 0.09655838f, 0.01751862f, 0.04946086f, 
    -0.16022925f, -0.01296945f, -0.01334790f, -0.09152351f, -0.01039688f, -0.09316283f, -0.03653760f, 0.03542385f, 
    -0.04806989f, 0.06616976f, 0.09954174f, 0.04826799f, 0.07893228f, -0.16354956f, -0.10199471f, -0.08035974f, 
    0.12527163f, 0.10968751f, -0.06285468f, 0.09840526f, 0.03318585f, 0.07010040f, -0.04408571f, 0.04614309f, 
    0.23801139f, -0.14372434f, 0.13794847f, -0.16918659f, 0.08916315f, -0.07153752f, -0.00827960f, 0.10546661f, 
    -0.06639060f, 0.00719139f, -0.02572260f, 0.08852414f, 0.44504550f, -0.06375156f, 0.02066878f, 0.02382989f, 
    -0.03053087f, 0.00940720f, 0.01461345f, 0.05534045f, 0.03371644f, 0.01909865f, -0.09462431f, -0.05705633f, 
    -0.32059681f, -0.08176126f, 0.13050386f, -0.20821570f, -0.03478188f, -0.11010177f, 0.06650414f, 0.11537401f, 
    0.08513792f, 0.10780617f, 0.07107517f, -0.01030888f, -0.04443713f, -0.03720032f, 0.06574285f, 0.04854845f, 
    0.06295820f, -0.05063122f, 0.00621446f, -0.01940017f, 0.02007330f, -0.00039668f, 0.00709823f, -0.05987631f, 
    0.10029574f, 0.16812532f, -0.15168712f, 0.13493235f, 0.09302020f, 0.17347293f, -0.11489974f, 0.13326083f, 
    0.03490893f, -0.03260530f, 0.13068703f, 0.04701477f, -0.25076246f, -0.18539070f, 0.23915854f, -0.16710621f, 
    -0.01742362f, -0.01569945f, 0.16004694f, 0.06698751f, 0.01253692f, 0.08554201f, 0.06109263f, -0.05508075f, 
    0.11303342f, 0.05668664f, 0.00842344f, 0.08382456f, 0.00647797f, -0.00155965f, -0.00918902f, 0.09326912f, 
    0.04781419f, 0.04350446f, 0.11177167f, -0.03610108f, -0.31263927f, -0.06437927f, -0.13559376f, -0.10465419f, 
    -0.01893412f, -0.08109210f, -0.08219548f, -0.07792383f, -0.00773721f, 0.00580591f, -0.04865398f, 0.05208173f, 
    0.11588898f, -0.07329769f, -0.06266811f, -0.00587409f, 0.03252139f, 0.07080127f, -0.05242876f, 0.08062746f, 
    -0.00605126f, 0.11947345f, -0.06590179f, -0.00881752f, -0.02355391f, -0.02792713f, 0.18401177f, -0.19872147f, 
    0.06018846f, 0.06603881f, 0.03369490f, -0.03789566f, -0.05389706f, 0.19580562f, 0.15995300f, -0.02255160f, 
    0.08110362f, -0.18002152f, 0.16840823f, 0.07375812f, 0.15003552f, -0.04675270f, 0.12899800f, -0.10089209f, 
    0.04128596f, 0.00464730f, 0.02938477f, -0.01225956f, -0.06569526f, 0.32103896f, -0.19377519f, -0.02654600f, 
    0.02742106f, 0.10989113f, -0.10718673f, 0.04043231f, -0.00260952f, -0.08018914f, -0.04776188f, 0.03492223f, 
    -0.14071766f, 0.08565634f, 0.15658601f, -0.23626512f, -0.00649585f, 0.10229804f, 0.05465079f, 0.02451871f, 
    0.08772843f, 0.00916693f, 0.14187665f, -0.00549908f, 0.09742270f, 0.00993892f, 0.04793014f, 0.07945677f, 
    0.08618206f, -0.03390571f, 0.04024655f, -0.03562091f, -0.14171851f, 0.11968826f, -0.19649988f, -0.02462164f, 
    0.04381203f, -0.04856572f, 0.10168881f, -0.01596629f, 0.04021500f, -0.03927220f, 0.03407488f, 0.03036884f, 
    0.03131395f, -0.15336069f, 0.09619243f, -0.01541246f, 0.14828792f, -0.08592917f, 0.09490001f, 0.11017254f, 
    0.01673360f, 0.13919090f, 0.02444050f, 0.01781544f, 0.00909935f, -0.16183220f, 0.04654719f, 0.03278589f, 
    0.13021933f, 0.10477351f, 0.03539112f, 0.02820981f, 0.03226567f, 0.12555824f, 0.02642289f, -0.04230235f, 
    0.02561927f, 0.00296202f, 0.07214832f, 0.06229430f, -0.15244108f, -0.06110675f, 0.19313782f, -0.03365253f, 
    0.11463536f, -0.01106292f, 0.06440621f, 0.11817605f, 0.01644909f, -0.07147541f, 0.02810790f, -0.00243471f, 
    0.19088089f, 0.02170068f, -0.31995061f, -0.04725784f, -0.12805247f, 0.01576768f, -0.12311119f, 0.00212608f, 
    0.05222649f, 0.07095818f, -0.06978611f, 0.04000981f, -0.09915473f, 0.08745994f, 0.01501398f, -0.09101260f, 
    0.05593961f, 0.00286533f, 0.02123890f, 0.02426896f, 0.00103068f, 0.12789981f, 0.03773339f, 0.00116006f, 
    -0.09573013f, -0.05931606f, -0.10291234f, 0.08946114f, 0.01117098f, -0.04203772f, -0.06158883f, 0.02082030f, 
    0.03235006f, 0.00599704f, 0.03926439f, -0.02483466f, -0.02379327f, -0.12722054f, 0.11659541f, 0.05138044f, 
    -0.04431183f, -0.13720828f, 0.03544171f, 0.02218429f, 0.08150207f, 0.03660130f, -0.05897105f, 0.19846788f, 
    0.09562986f, -0.34176233f, 0.25326148f, -0.09346993f, -0.01239893f, -0.07545806f, 0.03592344f, 0.08831594f, 
    -0.03503844f, -0.11940198f, -0.04546719f, -0.02809607f, -0.05908016f, -0.07628673f, 0.10648670f, -0.02709043f, 
    -0.06379667f, 0.04167493f, 0.08745637f, 0.00945423f, -0.07177769f, 0.06810105f, -0.17460641f, -0.02868992f, 
    -0.12791821f, 0.00727527f, 0.00438717f, -0.02033293f, -0.12950177f, 0.15980890f, -0.08520110f, 0.07396936f, 
    0.14140311f, -0.08176994f, 0.06487642f, 0.02348100f, -0.18805386f, -0.22872511f, 0.20376833f, 0.02117082f, 
    0.02778000f, -0.00299788f, -0.00006953f, 0.13288482f, 0.02537439f, 0.01413382f, -0.01214411f, -0.03998643f, 
    0.04827695f, 0.05106154f, -0.00310823f, -0.01907477f, -0.00049209f, -0.12179269f, -0.04099600f, -0.09413247f, 
    0.06048770f, 0.09474301f, 0.07026512f, 0.14947917f, 0.24481118f, -0.11061725f, -0.10305139f, 0.18234801f, 
    -0.01816018f, 0.10505691f, 0.03918677f, -0.07628871f, -0.03581459f, 0.20474847f, 0.05556250f, -0.01237405f, 
    0.19358303f, -0.02367028f, -0.16062203f, -0.00942125f, -0.08095723f, 0.05109549f, 0.06659129f, 0.05670954f, 
    0.02982718f, -0.04287103f, -0.00763685f, 0.06748968f, 0.05400538f, 0.09639487f, -0.04427527f, 0.10242499f, 
    0.06250178f, -0.01250837f, 0.03634875f, 0.03750965f, 0.05550803f, -0.15537202f, 0.05233964f, 0.05948204f, 
    0.03437075f, 0.27154711f, 0.00020322f, -0.24082014f, -0.05782710f, -0.09922429f, -0.04483140f, 0.05228369f, 
    0.10371240f, -0.08363412f, -0.13955034f, 0.01644076f, 0.08436403f, -0.06536290f, 0.03907520f, 0.24295340f, 
    -0.14877412f, -0.01410400f, 0.08574785f, -0.00310607f, 0.05309836f, -0.01717354f, 0.13317819f, -0.07612399f, 
    -0.08372456f, 0.00529093f, 0.07497303f, 0.03699005f, 0.05116149f, -0.01151211f, 0.25796947f, 0.04035565f, 
    0.08643702f, -0.01625388f, 0.07346338f, -0.07812297f, -0.04827914f, 0.00378706f, 0.06216309f, -0.00818042f, 
    0.03998997f, 0.08441150f, 0.09736783f, 0.05792617f, 0.01660492f, -0.01341753f, 0.04816154f, 0.03604592f, 
    0.35741171f, 0.19338559f, -0.04350932f, 0.19333389f, 0.04925908f, -0.01265369f, 0.00414511f, -0.08810293f, 
    0.04574752f, -0.01128608f, -0.03676295f, 0.05665786f, 0.06182710f, 0.06080148f, -0.01482391f, -0.07660052f, 
    -0.06765877f, 0.05007325f, -0.06884440f, -0.00071454f, 0.04073742f, 0.05128725f, 0.22026569f, 0.10699261f, 
    -0.02784306f, -0.21483800f, -0.16756144f, -0.18684396f, 0.02044536f, 0.05757565f, 0.01458642f, 0.11467519f, 
    0.01723149f, -0.04543267f, 0.01468276f, 0.00028904f, -0.03259890f, -0.15402269f, 0.08466282f, 0.10315800f, 
    0.14110805f, 0.02698865f, 0.02441228f, -0.01128877f, 0.06130882f, 0.03786179f, -0.07699353f, 0.01558207f, 
    0.13390838f, -0.03630856f, -0.10080864f, -0.17703496f, 0.07560433f, -0.04607132f, 0.06985974f, 0.04359590f, 
    -0.05439417f, 0.11152597f, -0.05073233f, -0.02859138f, 0.35312426f, -0.13497160f, 0.22538024f, 0.25105643f, 
    0.08861908f, 0.18329681f, 0.07319845f, 0.00717662f, -0.04067540f, -0.05264449f, -0.04722888f, 0.00038873f, 
    0.08609030f, -0.05687333f, 0.04189196f, 0.08166142f, 0.00652041f, 0.10560557f, 0.09933858f, -0.17156552f, 
    -0.17063153f, -0.12327518f, 0.05207290f, 0.09753444f, -0.08278932f, 0.12268607f, 0.12285872f, 0.10588843f, 
    0.09059358f, 0.07898042f, -0.00559520f, -0.12100773f, -0.04005465f, -0.07941997f, -0.08880461f, -0.06692364f, 
    -0.15274520f, 0.08234640f, 0.07064485f, -0.11410040f, 0.02588641f, 0.16128109f, 0.06139186f, 0.09287815f, 
    0.15938167f, -0.04416391f, 0.03427928f, 0.05159685f, 0.19813928f, -0.13566363f, 0.04450247f, -0.04853438f, 
    0.04299347f, -0.05423631f, 0.02549460f, -0.05574660f, 0.02563293f, 0.03041593f, 0.14965758f, 0.14544316f, 
    0.12232333f, -0.01431671f, -0.01682246f, -0.08535513f, -0.02138961f, 0.10849679f, -0.09003603f, 0.08826620f, 
    -0.10984693f, -0.00746134f, -0.10618405f, 0.05657375f, 0.02597591f, -0.05374251f, 0.05565538f, 0.03936619f, 
    -0.01976351f, 0.08503254f, 0.04932686f, 0.12934269f, 0.13379306f, -0.01656889f, -0.08493666f, 0.01756533f, 
    0.17899360f, -0.06913792f, 0.09813114f, -0.04439240f, -0.05632392f, 0.00450209f, 0.09552571f, 0.02380427f, 
    -0.03831394f, 0.20537303f, 0.08185277f, -0.01072518f, 0.00588728f, 0.21267484f, -0.05168975f, -0.01191109f, 
    0.10747125f, 0.05617652f, 0.08908202f, -0.05592581f, -0.07264698f, 0.02529568f, 0.06192371f, -0.11130552f, 
    -0.22768058f, 0.04938754f, -0.02362752f, 0.03346163f, -0.02209708f, 0.08913692f, 0.05204943f, 0.10933067f, 
    -0.00721564f, 0.14679120f, 0.07089697f, -0.03966412f, -0.46905470f, 0.25758043f, 0.08219983f, -0.09544641f, 
    0.10944834f, 0.06188101f, 0.05418243f, -0.01744204f, -0.00197393f, 0.11264273f, 0.05095493f, 0.00685288f, 
    0.20774502f, -0.07516916f, -0.04064806f, 0.02506453f, 0.20037828f, 0.04914182f, -0.02077547f, 0.07378446f, 
    0.04622674f, -0.01080360f, 0.01990612f, 0.02654556f, -0.27494857f, -0.02448381f, -0.00881716f, 0.07454664f, 
    0.05971429f, 0.05459319f, -0.00575772f, 0.01275192f, -0.01489293f, -0.08316223f, -0.02277368f, 0.06238852f, 
    -0.20426576f, 0.04679594f, 0.04872833f, -0.16293685f, 0.04559479f, 0.13556591f, 0.09060439f, -0.03176208f, 
    -0.11128910f, 0.07329961f, -0.05978731f, 0.09952746f, 0.23023415f, 0.21730900f, -0.06025121f, -0.27618101f, 
    -0.01135721f, -0.03574019f, -0.04043875f, 0.06092418f, 0.07762665f, 0.03537245f, 0.00455824f, -0.13057366f, 
    -0.28715792f, 0.37782496f, -0.00907224f, 0.17404617f, 0.02211156f, 0.05086768f, -0.02902267f, -0.18355845f, 
    0.07261150f, -0.03705601f, 0.10283459f, 0.06598246f, -0.20660844f, 0.26679569f, -0.04773426f, 0.02914463f, 
    0.03168072f, -0.04388039f, -0.02227806f, -0.00910153f, -0.02603143f, -0.01087074f, 0.13475133f, 0.15332811f, 
    0.25360456f, 0.01899114f, 0.24503444f, -0.02176550f, -0.04595125f, -0.07920831f, 0.02120315f, -0.09787966f, 
    0.05068541f, 0.06045490f, -0.02969761f, -0.11628260f, -0.08810052f, 0.29043913f, 0.05281739f, -0.37792352f, 
    -0.01840679f, -0.04666957f, -0.07353765f, -0.01270171f, -0.02654807f, -0.01120263f, -0.00818643f, 0.03592354f, 
    0.10641360f, -0.03307486f, 0.11312212f, 0.16787195f, 0.13494962f, 0.03367885f, 0.00544645f, 0.06218637f, 
    -0.07138872f, -0.08257403f, -0.02699811f, -0.10657013f, 0.08080985f, 0.13720685f, 0.01883046f, -0.21011402f, 
    0.07524859f, 0.00075970f, 0.10363147f, -0.07131223f, 0.11171637f, 0.01972941f, -0.00766764f, -0.02603474f, 
    -0.07506381f, -0.08955198f, 0.11393203f, -0.08569324f, 0.11099251f, 0.05087672f, 0.00641753f, 0.04589707f, 
    -0.02738511f, -0.01389093f, 0.14923346f, 0.04697452f, 0.37225887f, -0.13048957f, 0.16498685f, -0.19161266f, 
    0.03545634f, -0.01179854f, 0.06278928f, -0.07999779f, 0.05039680f, 0.04832210f, -0.02545437f, -0.06452044f, 
    0.04633252f, 0.00891394f, -0.01828294f, 0.05481695f, -0.09138115f, -0.02973636f, 0.02740932f, 0.08179663f, 
    0.07394215f, 0.03513788f, 0.02680917f, 0.09924725f, -0.17131992f, 0.05745996f, 0.15414093f, -0.02519326f, 
    0.04031680f, -0.05641352f, -0.07912013f, -0.00594260f, -0.01015596f, -0.07526129f, -0.00418971f, 0.08953711f, 
    0.18684588f, -0.02871396f, -0.17116103f, -0.28104770f, 0.02034977f, -0.02838941f, -0.11011276f, -0.14912523f, 
    0.05666222f, 0.03131892f, 0.02080320f, 0.07239917f, 0.25868720f, 0.01709639f, -0.08738601f, -0.25689238f, 
    -0.02302445f, -0.00118745f, -0.00452615f, -0.10574806f, 0.03253605f, 0.00752738f, -0.03722830f, 0.03776390f, 
    0.11104167f, 0.05262724f, 0.00207368f, -0.04315672f, 0.08814461f, -0.05313815f, 0.13931270f, -0.07598928f, 
    0.08572500f, 0.02414272f, 0.07790603f, -0.01573071f, 0.15182546f, -0.02558276f, -0.05337459f, -0.03679253f, 
    0.15903646f, -0.10637348f, 0.05336349f, 0.06604914f, -0.03088651f, 0.01792872f, -0.04642458f, -0.06053293f, 
    -0.03658076f, 0.12317011f, 0.11608461f, 0.11821366f, -0.05409554f, 0.04968451f, 0.02570953f, -0.11711147f, 
    0.12642145f, 0.05072118f, 0.04514885f, -0.03041776f, -0.06734449f, 0.05182075f, 0.05837043f, -0.10474336f, 
    -0.09508690f, -0.00204150f, 0.03323709f, -0.00279436f, 0.08583680f, 0.11116199f, -0.05574841f, 0.09355870f, 
    -0.00631016f, -0.19940743f, -0.01818740f, 0.29317540f, -0.14416401f, 0.06624094f, 0.03562441f, -0.01069695f, 
    -0.04128932f, 0.00744351f, 0.02404981f, 0.02065529f, -0.17337863f, 0.27772039f, -0.22758180f, 0.11230079f, 
    0.06248872f, -0.00887068f, 0.02999659f, -0.13016652f, 0.02090594f, 0.07702982f, 0.00303404f, 0.08613363f, 
    0.05294701f, 0.00733919f, 0.07787162f, -0.19289012f, 0.06716564f, 0.09248608f, -0.03647216f, 0.02070676f, 
    -0.00892340f, 0.02549053f, 0.04430432f, -0.07806605f, 0.05557670f, 0.08179291f, 0.05447885f, 0.01233558f, 
    0.01743574f, -0.00809166f, -0.00979021f, 0.04289722f, -0.03052468f, -0.04857025f, -0.00896088f, -0.02068191f, 
    0.02001885f, -0.02666777f, 0.01871476f, -0.07264912f, 0.01256232f, -0.06525235f, 0.15488747f, -0.03458210f, 
    -0.07130961f, -0.00945318f, -0.03734594f, -0.08219732f, -0.30191427f, 0.08573262f, 0.09900055f, 0.14363927f, 
    0.02388082f, 0.03911611f, 0.00128615f, 0.03525298f, -0.07107845f, -0.11833453f, -0.03357200f, -0.15477327f, 
    -0.09120052f, 0.00229923f, 0.08870423f, 0.05979966f, -0.00316250f, -0.03046873f, 0.07685724f, 0.02680485f, 
    -0.03643043f, 0.14486176f, 0.02348595f, -0.00447649f, 0.00306931f, 0.01277567f, 0.05346020f, 0.03684204f, 
    -0.02140701f, -0.01739357f, -0.00817750f, -0.05964835f, -0.10313377f, 0.07195227f, 0.02695174f, 0.00512561f, 
    0.13632561f, -0.01790720f, -0.05762108f, 0.02654068f, 0.11369218f, -0.06661902f, 0.01857215f, 0.08730046f, 
    -0.07080930f, -0.04821622f, 0.02220239f, -0.06203220f, 0.10150301f, -0.03615556f, 0.04679585f, -0.13673751f, 
    0.04295924f, 0.12274491f, 0.00967341f, -0.09363133f, 0.10181158f, 0.03709182f, -0.02251869f, 0.00624262f, 
    -0.01158645f, -0.00964964f, 0.05210982f, -0.02814865f, -0.11357887f, 0.00401962f, 0.01899808f, 0.00873991f, 
    -0.04041016f, 0.03472311f, -0.01856555f, 0.12444546f, -0.10696782f, -0.10863302f, 0.03918499f, 0.04342749f, 
    -0.03003255f, 0.04054693f, -0.06513342f, 0.00332926f, -0.01126095f, -0.03195362f, 0.01366373f, 0.01018826f, 
    0.01852632f, 0.08888852f, 0.15023510f, 0.02313031f, -0.02454669f, 0.05161790f, 0.02281045f, -0.02315941f, 
    0.04773268f, 0.09766906f, 0.04667919f, 0.03066868f, -0.03071561f, 0.09683070f, 0.04700233f, 0.16658780f, 
    0.05022169f, -0.05358585f, -0.01368558f, 0.03097787f, 0.02104586f, 0.09953281f, 0.05413570f, 0.04770574f, 
    -0.15354402f, 0.11371034f, 0.01157894f, -0.04601137f, -0.04909542f, -0.07829925f, -0.08050156f, -0.00418991f, 
    -0.00824332f, -0.04035145f, -0.08430310f, 0.04037439f, 0.10005688f, -0.02901536f, -0.00309485f, -0.09004804f, 
    -0.04143060f, 0.03794874f, 0.01096431f, 0.03776941f, -0.00856135f, -0.00914246f, 0.07712545f, 0.12494171f, 
    0.05064115f, -0.06946798f, 0.15588039f, -0.02782268f, 0.06232908f, 0.04390371f, -0.08905285f, 0.07232469f, 
    -0.02674738f, -0.05571546f, -0.02123891f, -0.04479335f, 0.23955387f, -0.22511539f, 0.16010840f, 0.17969985f, 
    0.04954840f, 0.04608559f, -0.02374792f, 0.04954002f, -0.11398653f, -0.05310550f, -0.08805275f, -0.09190419f, 
    -0.01463412f, 0.19633657f, 0.01005223f, 0.15878779f, -0.01496189f, 0.01824595f, -0.05459420f, -0.00740320f, 
    -0.08614519f, -0.04841987f, -0.00124125f, 0.03574333f, -0.17511451f, -0.13783897f, -0.09249785f, -0.07359721f, 
    -0.01513447f, -0.18746145f, 0.06811330f, 0.07851636f, -0.03283760f, 0.02271478f, -0.05085275f, 0.12756564f, 
    -0.03154982f, 0.09778342f, 0.16152047f, 0.02192990f, 0.10580670f, -0.08713162f, -0.06611156f, 0.01350498f, 
    0.04989321f, 0.06491528f, 0.01120799f, 0.03408234f, 0.27838826f, 0.17139006f, 0.09672148f, 0.04765823f, 
    0.00469114f, -0.07571777f, 0.07338828f, 0.11702882f, -0.07250338f, 0.06752603f, -0.05475196f, -0.03352376f, 
    -0.22320673f, 0.10123235f, 0.07888557f, 0.16835602f, -0.05490522f, -0.05202460f, 0.12290513f, 0.00644661f, 
    0.06213643f, -0.04588985f, -0.11375184f, 0.05014950f, 0.00176177f, 0.32698959f, -0.00450834f, 0.28724509f, 
    0.11364608f, 0.12466776f, 0.04725830f, 0.01931314f, -0.01237650f, -0.08079047f, 0.11642877f, -0.02704929f, 
    -0.00631738f, -0.04911790f, -0.02568947f, 0.14711235f, -0.04652315f, 0.02767910f, 0.00340125f, 0.03616828f, 
    0.06229964f, 0.03102114f, -0.04041867f, -0.08090942f, 0.07339817f, -0.02698337f, 0.07007314f, -0.13230497f, 
    -0.09632854f, -0.07208939f, 0.02877652f, -0.00223070f, -0.02627707f, 0.09100384f, 0.00062548f, -0.09156871f, 
    -0.09272360f, 0.15730797f, 0.14692594f, -0.04457698f, -0.03504305f, -0.01047901f, 0.07927106f, 0.08770213f, 
    0.01441755f, -0.04630584f, -0.01789902f, 0.05816048f, -0.19581023f, 0.20435379f, 0.10374696f, 0.08459845f, 
    -0.06218651f, -0.05941505f, 0.10683268f, -0.00822673f, -0.04843364f, 0.05826866f, 0.01724948f, 0.04776833f, 
    0.38837579f, 0.11514795f, -0.12582782f, -0.01150654f, 0.18188679f, -0.01315414f, -0.08255830f, 0.07085314f, 
    -0.03701566f, 0.01849909f, 0.05937584f, 0.09231930f, -0.02768112f, -0.02682787f, -0.04558752f, 0.21546677f, 
    0.03106335f, 0.10577978f, -0.15482111f, 0.03811111f, 0.09334639f, -0.01662543f, 0.06750100f, -0.00121103f, 
    -0.05579322f, 0.01453706f, -0.25216094f, 0.10985177f, -0.03693961f, -0.13791485f, 0.04910843f, 0.02166978f, 
    0.02828519f, -0.08715466f, 0.02869468f, -0.02871622f, 0.05613315f, 0.21256052f, 0.13401511f, -0.15207154f, 
    -0.01012836f, 0.03167839f, 0.03319968f, 0.02592720f, 0.01570755f, -0.03703253f, -0.01607160f, -0.01948534f, 
    0.08952904f, -0.03126191f, -0.05085069f, -0.07254369f, 0.00636370f, 0.07858621f, 0.02252202f, 0.01337937f, 
    -0.00368246f, -0.02649937f, 0.01463011f, -0.08233096f, 0.23695235f, 0.00419639f, 0.38636392f, -0.12968028f, 
    0.04894466f, 0.05608147f, 0.12086847f, -0.06255971f, 0.07146887f, 0.06139311f, -0.01475726f, 0.04724853f, 
    -0.05011429f, -0.12862824f, 0.07347953f, 0.11777630f, -0.05347745f, -0.03948091f, 0.04213844f, -0.14395486f, 
    0.03845830f, -0.06995636f, 0.06623203f, 0.16074516f, -0.05704753f, 0.11072481f, 0.02427958f, -0.08671066f, 
    -0.04711280f, 0.21678224f, 0.02671136f, -0.04898935f, 0.05165508f, -0.04254751f, -0.14053102f, 0.04107953f, 
    -0.14328554f, -0.08123381f, -0.10467428f, -0.23301047f, 0.02766502f, 0.00944458f, -0.07120117f, 0.11825818f, 
    0.12336639f, -0.00789242f, 0.09374447f, 0.07331780f, -0.23976497f, 0.15789668f, 0.06483310f, 0.05953608f, 
    0.00560738f, -0.19427374f, -0.04827943f, -0.00391490f, 0.04582447f, -0.04288991f, 0.09496532f, 0.01369397f, 
    -0.19164379f, -0.02605013f, 0.06779592f, 0.00999967f, 0.01062774f, 0.12079404f, -0.03270593f, -0.04645432f, 
    0.02075692f, 0.01409311f, -0.12152608f, 0.03127791f, 0.02047615f, -0.07556614f, 0.03329977f, 0.05523325f, 
    -0.03834168f, -0.03659188f, 0.05700525f, 0.01338860f, 0.09226462f, 0.00892857f, 0.11091458f, -0.03104377f, 
    0.01322731f, -0.07109418f, 0.18205211f, 0.22720169f, -0.03116499f, 0.06057129f, -0.12858890f, -0.07920170f, 
    -0.02092043f, 0.07883041f, 0.00222095f, -0.00403500f, 0.08076781f, 0.08949112f, -0.00624824f, 0.05094120f, 
    -0.01330106f, -0.06077111f, 0.02162796f, 0.04840502f, -0.09075118f, 0.02695887f, 0.06110748f, -0.06794720f, 
    -0.01170743f, -0.00547431f, -0.11451720f, -0.06771810f, -0.01966242f, 0.04302314f, 0.05235743f, 0.00466589f, 
    -0.07635827f, 0.06747551f, 0.04113228f, -0.00860180f, -0.04656241f, 0.11529593f, -0.05263760f, -0.11514515f, 
    -0.09233681f, -0.01609496f, -0.01295149f, 0.06082131f, 0.00080425f, 0.06646951f, 0.09036330f, -0.05551096f, 
    -0.09357899f, 0.04597298f, 0.10429368f, 0.13557090f, 0.08531802f, 0.03729656f, -0.00905135f, 0.03108574f, 
    0.03106177f, -0.06489937f, -0.01510570f, 0.01039791f, 0.08069050f, 0.25695843f, -0.04934869f, -0.14635502f, 
    0.03649516f, -0.07316716f, 0.06834214f, -0.03015275f, -0.01374283f, -0.17225987f, 0.02151906f, -0.04339977f, 
    0.04622412f, -0.09093847f, -0.08923937f, 0.18924259f, 0.06593471f, 0.05483593f, -0.00484198f, -0.04560560f, 
    -0.01007883f, -0.02618370f, 0.00445910f, 0.13074985f, -0.00107913f, -0.05796320f, -0.09872118f, 0.02510715f, 
    0.04324337f, 0.06268192f, -0.06035494f, 0.02322754f, 0.04949111f, 0.01425458f, 0.06101127f, -0.14298837f, 
    -0.09429077f, 0.14242887f, -0.00760031f, -0.16044579f, -0.12242159f, 0.05257964f, -0.02044806f, -0.06048444f, 
    -0.02289718f, 0.15362123f, 0.08291681f, 0.09414288f, 0.01904138f, 0.21622652f, 0.13250597f, 0.10524543f, 
    -0.02339944f, -0.07613575f, -0.03605343f, -0.01721505f, 0.02425932f, 0.05591968f, 0.19410466f, 0.07452457f, 
    -0.23079157f, -0.01113421f, 0.07210791f, 0.01329913f, 0.11328600f, -0.06830600f, 0.04502570f, -0.13160217f, 
    -0.05335109f, 0.08739950f, -0.06190810f, -0.10165483f, -0.06815014f, -0.01002723f, -0.18889022f, 0.12629628f, 
    0.06837746f, -0.02219503f, -0.08257034f, -0.13490775f, 0.02254122f, -0.04806102f, -0.01316376f, 0.06744990f, 
    -0.04328391f, -0.05147024f, -0.02773170f, -0.00206105f, -0.01848460f, -0.00924090f, -0.04895597f, 0.04644594f, 
    -0.00100414f, 0.00203171f, 0.03934359f, 0.04223467f, 0.04146958f, -0.02960645f, -0.01954196f, -0.01211059f, 
    -0.04633969f, -0.03023993f, -0.03976393f, -0.05019355f, -0.03510644f, 0.05464176f, 0.02055755f, -0.04391393f, 
    0.03442758f, -0.01011524f, 0.01661079f, 0.01479579f, -0.02338355f, -0.01316588f, 0.01140987f, 0.04291835f, 
    0.03150332f, -0.03011744f, -0.04282030f, 0.04411832f, -0.04969047f, 0.00150003f, -0.04331688f, -0.02389552f, 
    0.01536481f, -0.00875491f, 0.01222097f, 0.00808681f, -0.00559312f, 0.04444223f, -0.04985974f, -0.04911940f, 
    -0.04822940f, 0.01911749f, 0.00675687f, 0.01877467f, -0.00808302f, -0.00801385f, -0.00611761f, -0.05365853f, 
    -0.04681474f, -0.00285312f, 0.04266690f, 0.01901108f, 0.01239595f, -0.05186038f, -0.04081376f, -0.03573699f, 
    -0.04284321f, 0.02984016f, 0.02573552f, -0.03820039f, 0.02507125f, 0.00436419f, -0.03938339f, 0.03397676f, 
    -0.01589489f, -0.04407436f, 0.04136775f, -0.04473585f, 0.03968165f, -0.02730786f, 0.02436174f, -0.03913197f, 
    -0.03551841f, -0.04175301f, -0.02692296f, 0.03800133f, -0.01568890f, 0.03794042f, 0.03775205f, 0.00993044f, 
    0.04861851f, 0.04217097f, -0.00526301f, -0.03114615f, 0.05157636f, 0.00765227f, -0.01192726f, -0.04112351f, 
    0.02074699f, -0.02548709f, -0.04258403f, -0.03594618f, 0.04216607f, -0.04270910f, -0.00965127f, 0.03256388f, 
    0.01048784f, -0.04774665f, -0.04108214f, -0.02625565f, 0.00303192f, -0.00425715f, -0.03920044f, 0.04804002f, 
    -0.00866222f, -0.05154253f, -0.04043119f, 0.00809294f, 0.03754071f, -0.01563849f, 0.02054838f, -0.01583832f, 
    0.02324918f, 0.04628251f, 0.00614792f, 0.00647411f, 0.04328551f, 0.02112210f, -0.03401655f, -0.00065827f, 
    0.02231128f, 0.05640946f, -0.05229827f, 0.03971506f, 0.03667698f, -0.04825807f, 0.00806041f, -0.02701432f, 
    0.02686324f, -0.03029029f, -0.03897003f, 0.01629821f, 0.00290482f, -0.04732308f, -0.04929795f, 0.02582332f, 
    0.00116688f, 0.02008118f, 0.00993671f, -0.02761641f, -0.01582487f, -0.03079701f, 0.04858184f, -0.03328749f, 
    0.01306602f, -0.00479741f, 0.04094661f, 0.03963460f, -0.00027182f, -0.02433440f, 0.04336272f, 0.03325758f, 
    0.02591996f, 0.02379511f, -0.01613903f, -0.03757572f, -0.04248204f, -0.00585873f, 0.04739710f, -0.01762122f, 
    -0.03684101f, -0.00932371f, 0.02818620f, -0.00346267f, 0.02343264f, -0.02382146f, -0.03683743f, 0.01066792f, 
    -0.01887530f, 0.02388093f, 0.01383805f, -0.01909973f, 0.02779191f, -0.02141543f, 0.00365650f, -0.03750506f, 
    0.03352438f, -0.05057786f, 0.03654882f, 0.00261124f, -0.05454819f, 0.03391482f, 0.02128177f, 0.03347760f, 
    0.01447925f, -0.00870578f, -0.02477029f, -0.01360093f, -0.00733167f, -0.00856172f, -0.02328459f, -0.02421801f, 
    0.04649658f, -0.01509473f, -0.02871273f, 0.01264988f, -0.04064994f, 0.03202695f, -0.02874904f, -0.01564828f, 
    0.00455908f, -0.01380628f, 0.00447154f, -0.05272606f, -0.03050669f, 0.02351056f, 0.04661626f, -0.03347553f, 
    -0.04185060f, 0.03420713f, 0.05964242f, 0.03781364f, 0.00853985f, 0.02445597f, -0.00123265f, 0.02013901f, 
    0.00114015f, 0.03714566f, -0.01468569f, 0.00289268f, -0.02808440f, -0.05139119f, -0.04366590f, -0.01135989f, 
    -0.05461023f, -0.01361572f, -0.01481620f, 0.04644122f, 0.01591584f, -0.04803035f, -0.00443176f, 0.00175165f, 
    -0.03372504f, 0.03902504f, 0.04951091f, 0.00093531f, 0.04757649f, 0.01553048f, 0.04310939f, -0.01831237f, 
    -0.00088586f, 0.04323094f, 0.01005601f, -0.00215245f, 0.04256191f, -0.01111886f, -0.03512321f, -0.03722913f, 
    0.03991470f, 0.03310521f, 0.03223145f, 0.01747015f, -0.02414175f, 0.02803868f, -0.03499430f, 0.03930859f, 
    0.04875807f, -0.04282320f, -0.04319740f, -0.00322454f, 0.00145039f, 0.02749958f, 0.04598603f, 0.00776492f, 
    0.02039694f, 0.00962070f, 0.01285959f, -0.05396387f, -0.02574869f, -0.03625517f, -0.01879674f, 0.00598417f, 
    -0.03749386f, -0.00860051f, 0.04114929f, 0.02367634f, -0.00844024f, 0.00475336f, -0.01984535f, -0.00250504f, 
    0.03662384f, 0.02007542f, 0.04394331f, -0.05498167f, -0.05331327f, -0.03355290f, -0.02062183f, -0.02642956f, 
    0.02543687f, -0.01749977f, -0.04634308f, -0.02674003f, 0.04304091f, 0.01181657f, 0.00617896f, -0.03537319f, 
    -0.04438478f, -0.04868982f, -0.00472434f, -0.04630573f, -0.00947118f, -0.05433689f, -0.02164009f, -0.04057907f, 
    0.03506167f, 0.02018624f, 0.02188080f, 0.02668416f, 0.02288937f, -0.04955979f, -0.04454542f, 0.04580251f, 
    -0.01946626f, 0.03139943f, 0.01483547f, -0.01867974f, -0.05184123f, -0.03312292f, -0.02259951f, -0.04777483f, 
    -0.00629116f, -0.04229221f, 0.01130607f, -0.03949551f, -0.04597585f, -0.04598267f, -0.05141549f, 0.00628153f, 
    0.02242517f, 0.00871038f, 0.03903821f, -0.02227901f, -0.01878317f, 0.04869317f, 0.00736381f, 0.03848585f, 
    -0.01236238f, -0.00956337f, 0.02888507f, -0.00267149f, -0.03170095f, 0.00091779f, -0.03797674f, -0.02547914f, 
    -0.01987282f, -0.00226807f, -0.01526707f, -0.00624583f, -0.04478483f, 0.01715323f, 0.00991156f, -0.02711619f, 
    0.03586245f, 0.01631624f, -0.00247768f, 0.02893298f, -0.01372964f, -0.03170539f, -0.00909620f, 0.01402686f, 
    -0.05229795f, -0.03847698f, 0.04102987f, -0.01396659f, -0.00629475f, 0.03927730f, -0.00150991f, -0.04529079f, 
    -0.03528712f, -0.03155086f, 0.01419083f, -0.00412766f, -0.02436662f, -0.01728191f, 0.04594308f, -0.04636716f, 
    -0.11338446f, 0.00834869f, -0.00064968f, -0.02725613f, 0.02702784f, -0.10060633f, -0.00971033f, 0.02350822f, 
    0.05092620f, -0.00610279f, -0.00657201f, 0.17798962f, 0.17467338f, 0.05859963f, 0.03587014f, 0.25235298f, 
    -0.01786982f, 0.08207472f, 0.06965112f, 0.06708103f, -0.08292348f, 0.06844209f, 0.01108121f, 0.00745303f, 
    0.10541119f, 0.03845578f, -0.12934522f, 0.16825745f, -0.10557813f, -0.03995103f, 0.06956741f, 0.05096586f, 
    0.03706086f, 0.04749843f, -0.07173964f, 0.02039401f, -0.25649473f, 0.16975249f, -0.10424442f, 0.26925766f, 
    0.04443799f, 0.03276788f, -0.04512727f, 0.00960572f, -0.00986206f, -0.09992515f, 0.02907765f, 0.05904198f, 
    -0.05258769f, 0.05306014f, -0.00028571f, -0.02685502f, 0.04532622f, 0.09110511f, 0.01976769f, 0.07093348f, 
    0.01993468f, 0.01290660f, -0.02195827f, -0.00238776f, 0.24522731f, -0.04602640f, -0.06908397f, 0.13234326f, 
    -0.18596415f, 0.04436964f, 0.09199601f, -0.02699581f, -0.03102399f, 0.05035340f, 0.03996358f, -0.06488194f, 
    -0.11363062f, 0.18567060f, 0.06393120f, 0.27660742f, -0.08103099f, 0.10158718f, 0.12039255f, 0.03685298f, 
    0.01972224f, -0.01182712f, 0.02426855f, -0.03679601f, -0.40124375f, 0.10839901f, 0.06108646f, 0.11580774f, 
    -0.02900029f, -0.05174435f, 0.05168276f, 0.00413273f, 0.05678251f, -0.00076010f, 0.07032153f, 0.03141772f, 
    0.18736830f, 0.02688304f, -0.10080574f, 0.06965590f, 0.03072930f, 0.09357429f, -0.08582963f, -0.08603002f, 
    0.04942308f, -0.02341372f, -0.01761490f, 0.12400308f, -0.06349947f, 0.01231830f, 0.05553790f, 0.04408714f, 
    0.02181666f, 0.15311669f, -0.00031390f, 0.06332254f, 0.12198665f, 0.01872367f, -0.00553501f, 0.11407574f, 
    -0.07987383f, -0.19672021f, -0.10777894f, -0.10303343f, 0.03311648f, -0.08381081f, 0.03205922f, 0.10035161f, 
    -0.07308348f, -0.08384241f, -0.00554171f, -0.01243124f, 0.14813553f, 0.03686835f, -0.07903880f, 0.05587938f, 
    0.09159347f, 0.07958123f, -0.06925041f, -0.03423664f, 0.01945776f, -0.05902454f, -0.00884691f, 0.00919793f, 
    0.03111654f, 0.12797679f, 0.01342019f, -0.18189618f, 0.10558341f, -0.05933798f, -0.01622073f, 0.01029596f, 
    0.04985090f, -0.01569052f, -0.04091784f, 0.01135593f, 0.43496791f, -0.27624759f, 0.27765119f, 0.00276882f, 
    -0.04327073f, 0.05083723f, 0.02873905f, 0.06106229f, 0.02895895f, -0.03907090f, -0.06880450f, 0.03952248f, 
    -0.04708669f, 0.00047562f, -0.01128924f, 0.14465822f, -0.03572018f, -0.02759100f, 0.05952181f, -0.11915988f, 
    0.00275856f, -0.07832669f, 0.02150020f, 0.15634154f, -0.07101183f, 0.02119854f, -0.00458402f, 0.05651562f, 
    -0.03934265f, 0.01164146f, 0.07813865f, -0.05694805f, 0.06635103f, -0.06770847f, -0.09302903f, 0.03788664f, 
    -0.06176831f, 0.03092261f, 0.04929908f, -0.12262134f, -0.07470472f, 0.11010210f, -0.06341965f, 0.01284479f, 
    0.16515529f, 0.08385098f, 0.07100481f, 0.06212997f, 0.15259163f, -0.02637007f, 0.05392820f, -0.10948045f, 
    -0.00004095f, -0.07125223f, 0.06109053f, 0.00320818f, 0.11092309f, 0.03670156f, 0.14597528f, 0.14278579f, 
    -0.03790715f, 0.02177487f, -0.02458025f, 0.05338984f, 0.09111086f, 0.05273920f, -0.07563249f, -0.04532750f, 
    -0.02354386f, -0.11414071f, -0.10885284f, 0.01640865f, -0.12052256f, -0.10251400f, -0.04897269f, -0.00167308f, 
    -0.02932068f, 0.01993094f, 0.04723261f, 0.10520848f, 0.13993257f, 0.01656796f, 0.09090134f, 0.08769848f, 
    0.04314528f, 0.00363138f, 0.08980201f, 0.09569322f, -0.08940584f, 0.10424006f, 0.00533737f, -0.06155985f, 
    0.03426993f, 0.11213114f, -0.03306036f, 0.11528196f, -0.19568308f, 0.07266495f, -0.11385185f, 0.09602389f, 
    0.00339619f, -0.12403917f, 0.01237084f, 0.12529561f, -0.08996674f, 0.03704556f, 0.04078136f, -0.01995949f, 
    -0.04634212f, 0.07170422f, -0.07230911f, 0.01748157f, 0.09334178f, 0.01982770f, -0.03155904f, 0.10495625f, 
    0.02543350f, 0.09097191f, 0.04252316f, 0.06034943f, -0.06007126f, 0.18731125f, -0.12603702f, -0.01541689f, 
    0.01124271f, -0.01641424f, 0.02483375f, -0.11503761f, 0.01010030f, -0.05165276f, 0.00034443f, -0.11010013f, 
    -0.13981904f, -0.02521281f, -0.06164709f, -0.00573093f, 0.12723860f, -0.02164464f, 0.02588317f, 0.05789789f, 
    0.05201885f, -0.09319087f, 0.04757315f, 0.04516256f, -0.13287964f, -0.11390519f, 0.01500562f, -0.17330444f, 
    -0.04276903f, -0.04226070f, -0.02393913f, 0.04580923f, -0.04118326f, -0.06438086f, -0.00029429f, 0.01535045f, 
    0.10022850f, -0.05763153f, 0.13731082f, 0.02163980f, 0.06450200f, 0.04682222f, 0.07019446f, 0.03661500f, 
    -0.07256211f, 0.04660293f, -0.00508099f, -0.00107012f, -0.03434823f, 0.07152048f, -0.08885034f, -0.09757291f, 
    0.03064492f, 0.05257309f, 0.03057992f, -0.00473028f, 0.05498892f, 0.00725272f, 0.03670183f, -0.16835652f, 
    -0.20025608f, 0.20409672f, -0.18142797f, 0.04030796f, -0.06948629f, 0.04602709f, -0.01724926f, -0.13035595f, 
    0.06009388f, 0.09874533f, 0.07432979f, -0.01079132f, -0.18297359f, 0.27830437f, -0.10329477f, 0.00740998f, 
    -0.01161126f, -0.08102375f, 0.04637606f, 0.02826221f, 0.03466105f, -0.08949317f, 0.14136627f, 0.10812956f, 
    -0.00084698f, -0.12969771f, 0.18805927f, -0.20207757f, 0.07859652f, -0.03544709f, 0.06746139f, -0.05717716f, 
    0.06635521f, 0.08823767f, -0.02557751f, -0.02456810f, 0.01711160f, 0.24274001f, 0.02117360f, -0.03976973f, 
    0.06565058f, 0.04541307f, -0.04150538f, -0.02178283f, 0.06897353f, 0.06159196f, -0.08818449f, -0.00260035f, 
    0.03265844f, -0.02398071f, 0.02082553f, 0.10749985f, -0.00701395f, 0.06260263f, 0.06763944f, 0.03609637f, 
    -0.08111615f, -0.15737411f, -0.00851893f, -0.05616799f, -0.11722309f, -0.12313292f, -0.12849295f, 0.01091133f, 
    0.12504062f, 0.05732784f, 0.05661425f, 0.04961164f, 0.04615467f, -0.12282050f, -0.01412982f, -0.05163663f, 
    -0.32767934f, -0.04753562f, 0.12408100f, 0.15948966f, 0.00463219f, -0.03194995f, 0.01474089f, 0.03940361f, 
    -0.00118590f, -0.00556682f, -0.07996678f, 0.01386460f, -0.00492763f, -0.12217993f, -0.11938547f, -0.14276502f, 
    0.08052306f, -0.00415298f, -0.05505560f, -0.03918964f, -0.00172150f, 0.11323696f, -0.05666776f, 0.00569266f, 
    0.16095121f, -0.05758683f, 0.01930308f, 0.24519303f, -0.01133919f, 0.19004674f, 0.12315423f, -0.07306290f, 
    -0.09191746f, 0.01345546f, 0.01616392f, 0.14575569f, 0.14184719f, 0.08444198f, 0.02927733f, -0.00838337f, 
    -0.17119829f, -0.06980935f, 0.08238420f, -0.10964774f, 0.00625206f, -0.00041871f, -0.08643074f, 0.07036669f, 
    0.08269475f, 0.00207781f, -0.14177014f, 0.07634710f, 0.01344560f, 0.02133925f, -0.13462527f, -0.01707062f, 
    -0.01888176f, 0.00708157f, 0.00765115f, 0.05693258f, -0.51603466f, 0.06473974f, -0.04244735f, -0.02932923f, 
    0.20233780f, 0.08447635f, -0.00565003f, -0.13488291f, -0.02743581f, -0.02618886f, 0.07609247f, 0.03966675f, 
    0.23430853f, -0.15181449f, -0.08900243f, 0.23015775f, 0.03711213f, 0.02783555f, -0.17840652f, -0.13117947f, 
    -0.00190513f, -0.13197501f, -0.06478201f, 0.03916940f, 0.03988198f, -0.08805229f, -0.04817921f, -0.14837132f, 
    -0.06402270f, 0.01814121f, 0.02544027f, 0.08210848f, 0.00467044f, -0.13283007f, -0.08368079f, 0.05550259f, 
    0.04745733f, 0.02388890f, 0.04405199f, -0.02437648f, 0.07884127f, -0.03275912f, 0.17410688f, -0.05951906f, 
    -0.10187878f, 0.05291878f, 0.00013499f, -0.10230605f, 0.13124619f, 0.03093410f, -0.15456967f, 0.11352033f, 
    -0.02431509f, 0.01948294f, -0.03223922f, -0.08904397f, 0.07499997f, -0.00179214f, -0.04069466f, -0.00126697f, 
    0.10882944f, 0.12673104f, 0.11945197f, 0.04251639f, -0.03176635f, -0.00600702f, -0.02914491f, -0.11578275f, 
    0.05592952f, -0.08342797f, 0.02011300f, 0.12799527f, 0.21013460f, -0.00086443f, 0.07525270f, -0.07157638f, 
    0.00073308f, -0.05476587f, 0.04208116f, 0.10766012f, 0.05200103f, 0.16447051f, 0.00361055f, 0.07204764f, 
    -0.01634507f, 0.12007171f, 0.09993157f, 0.07068504f, 0.07438442f, 0.07753062f, -0.06220725f, 0.05987866f, 
    0.13496532f, -0.05940535f, 0.00028250f, -0.11685058f, 0.19720799f, -0.04177553f, -0.03811698f, 0.26009449f, 
    -0.14404415f, -0.12830257f, 0.13074787f, 0.03401266f, 0.04069757f, -0.03443678f, -0.03575957f, -0.00155971f, 
    0.30369675f, 0.01654786f, -0.00166841f, -0.04692653f, -0.12601645f, -0.01951787f, 0.02167006f, -0.07495438f, 
    -0.14106244f, -0.01081849f, 0.01932522f, -0.01984719f, -0.28574589f, 0.12188131f, 0.07322382f, -0.05489157f, 
    0.05482440f, 0.00158784f, 0.05400826f, -0.00136858f, -0.01097793f, 0.04522046f, -0.05829044f, -0.03427514f, 
    -0.04310196f, -0.04062863f, 0.08057141f, 0.25197324f, -0.08660321f, -0.08041539f, -0.00963567f, -0.06129265f, 
    -0.01370056f, -0.03520260f, -0.02683946f, -0.03530987f, -0.05783082f, -0.08233099f, -0.01426674f, 0.20665194f, 
    0.03196615f, -0.12339522f, -0.02782595f, 0.07482314f, 0.01302493f, 0.04507683f, 0.13877237f, 0.13794625f, 
    0.00910154f, 0.07008355f, -0.12042622f, 0.09943867f, -0.00727896f, 0.01561834f, -0.05919224f, -0.00483882f, 
    0.06508510f, 0.06407643f, -0.07163640f, 0.09769272f, -0.00503198f, 0.12261079f, -0.09250486f, 0.17058690f, 
    0.17177050f, 0.12258027f, 0.12034786f, 0.04413706f, -0.05204549f, 0.02299441f, -0.03599498f, 0.04901135f, 
    0.11199176f, -0.23610452f, 0.09404862f, -0.09722610f, -0.02201215f, -0.07599518f, -0.05485944f, -0.08669852f, 
    0.10512731f, -0.04370073f, -0.09656415f, 0.02973247f, 0.33515587f, 0.09840871f, -0.11437115f, -0.03203232f, 
    -0.19126208f, 0.09366093f, -0.01038680f, -0.04634450f, 0.11342786f, -0.10615285f, -0.07173848f, 0.04745360f, 
    -0.42526576f, 0.13843113f, 0.15136312f, -0.11380608f, 0.00574308f, -0.00546763f, 0.05641033f, -0.08794188f, 
    0.04436312f, 0.00059404f, 0.13657138f, 0.02952401f, -0.03892540f, -0.06663635f, 0.16518156f, 0.26484719f, 
    -0.14604947f, -0.04471394f, 0.03166403f, -0.09797127f, 0.05017152f, 0.12973556f, -0.00203294f, 0.04390438f, 
    0.20262945f, 0.21490549f, 0.17638084f, -0.00616230f, -0.04404612f, 0.05747152f, 0.11629946f, 0.06644166f, 
    0.05622286f, -0.00757774f, -0.01264946f, 0.02750659f, 0.12965547f, 0.00881486f, -0.00775488f, 0.18443923f, 
    -0.00333782f, -0.00263796f, 0.08544645f, -0.00465447f, -0.03282587f, -0.06579993f, 0.01447890f, -0.00657481f, 
    0.26945236f, 0.04048920f, -0.05015843f, 0.05460961f, -0.00073085f, -0.00910374f, -0.01013255f, -0.00728653f, 
    -0.01053743f, 0.14925358f, -0.05694008f, -0.08365888f, 0.18252724f, -0.13188538f, 0.13320580f, 0.24587049f, 
    -0.00999446f, -0.06168452f, 0.02155120f, 0.01996685f, 0.00490900f, -0.02891483f, 0.03153919f, -0.04539363f, 
    -0.07413838f, -0.08992624f, 0.11559199f, 0.11207312f, -0.07164724f, -0.03441035f, 0.01305394f, 0.05545559f, 
    0.06469787f, 0.01097255f, -0.03438402f, 0.03988534f, 0.22833963f, 0.08374318f, -0.05473564f, 0.21508329f, 
    -0.12056465f, 0.02530060f, 0.11891940f, 0.00807393f, 0.06810401f, -0.02173899f, -0.04664016f, 0.07134150f, 
    0.00745774f, -0.01538218f, 0.08232820f, 0.04721279f, 0.10022962f, 0.00771001f, -0.03496878f, -0.00858446f, 
    0.05137614f, 0.10512067f, -0.03008800f, -0.04671069f, 0.17622736f, 0.20856597f, 0.12780333f, -0.10626888f, 
    0.07166764f, -0.11775719f, 0.06011718f, 0.13471182f, 0.08387748f, -0.11655424f, -0.01431049f, -0.00765533f, 
    -0.26503533f, 0.03346469f, 0.24451962f, -0.04275722f, 0.05811486f, -0.01806847f, 0.00796430f, -0.06584625f, 
    0.01010742f, 0.01832054f, 0.08488600f, 0.03254923f, 0.25561500f, 0.18257776f, 0.06300367f, 0.10715349f, 
    0.00898496f, 0.10393631f, 0.01841712f, -0.03130522f, -0.02103003f, -0.06273102f, 0.08486653f, -0.02048282f, 
    -0.03041104f, -0.13406184f, 0.02726971f, 0.33024609f, -0.08314084f, -0.00292410f, -0.01854984f, 0.05912466f, 
    0.05704618f, 0.04315240f, -0.02542480f, -0.12433232f, -0.18071543f, 0.01471752f, 0.15907064f, -0.21256351f, 
    0.02417356f, 0.04489192f, -0.05736535f, 0.09940548f, 0.06018534f, 0.02096424f, -0.00959417f, -0.02378861f, 
    -0.07872886f, 0.11100023f, 0.12093074f, -0.21107766f, 0.02223268f, 0.00426578f, -0.08051160f, 0.02436779f, 
    0.02956922f, 0.07021049f, -0.02840440f, 0.07859749f, 0.04148541f, 0.15946093f, 0.11041181f, 0.06678686f, 
    0.00943172f, -0.03011818f, 0.06837846f, -0.08193355f, -0.00811520f, -0.00439351f, -0.06350668f, 0.05252361f, 
    0.12671000f, -0.01696881f, 0.02964537f, -0.04387323f, 0.16044310f, 0.01817693f, 0.06080074f, 0.12071545f, 
    -0.07461789f, -0.03427067f, 0.10455116f, 0.03511669f, -0.11975365f, -0.07785442f, 0.05650848f, 0.16091102f, 
    -0.02233252f, -0.05386958f, -0.08837725f, -0.01596451f, -0.05173258f, -0.02698090f, 0.04598112f, 0.03334462f, 
    0.02521482f, 0.11252665f, -0.16345887f, 0.25304848f, 0.01597596f, -0.12900752f, -0.02936753f, -0.07407422f, 
    0.00178103f, -0.01600923f, 0.14486846f, 0.05403124f, 0.03972727f, 0.19076526f, 0.16035795f, -0.15764773f, 
    -0.06634934f, -0.02833396f, 0.02782501f, 0.12849349f, -0.00908417f, -0.00072457f, 0.03360085f, 0.00200151f, 
    0.24380849f, -0.11905780f, 0.05546179f, 0.14908624f, -0.13024765f, 0.10876469f, 0.01375525f, 0.06498563f, 
    -0.10050078f, -0.02655864f, 0.05017739f, -0.03100798f, -0.05462992f, 0.23492154f, 0.14148219f, -0.07306968f, 
    0.00910509f, 0.05757567f, 0.00210276f, -0.03102520f, 0.10583718f, 0.05288358f, 0.05610645f, 0.10960660f, 
    -0.00297970f, -0.12879515f, 0.10241670f, 0.04534805f, 0.01510134f, 0.01867804f, 0.00847342f, -0.06258276f, 
    0.06254343f, 0.05653781f, 0.11561696f, 0.05580590f, 0.09196166f, 0.03647147f, -0.01404960f, -0.18937804f, 
    0.02273220f, 0.17599200f, -0.03069666f, 0.05727125f, 0.04336824f, -0.03939858f, -0.02118691f, -0.00505637f, 
    0.14897461f, -0.03231955f, -0.15425731f, -0.07148651f, 0.08719254f, -0.04846194f, -0.04206615f, 0.02106556f, 
    -0.03913042f, -0.06537735f, 0.07263456f, 0.05718971f, -0.34009022f, 0.16189340f, 0.04287431f, 0.11880962f, 
    -0.05587035f, -0.09680591f, 0.03359959f, 0.00911672f, -0.08950487f, -0.01744257f, -0.01401169f, -0.06708626f, 
    -0.06667168f, -0.06998759f, -0.00123270f, -0.01161647f, -0.07576659f, 0.06255963f, 0.06237772f, -0.05111445f, 
    0.08135559f, 0.02179157f, 0.02357975f, -0.01862622f, 0.05428319f, 0.06994586f, -0.02500273f, 0.06887028f, 
    -0.01390404f, -0.00040963f, -0.02039542f, -0.04919948f, -0.01935752f, 0.04618913f, -0.00286312f, -0.10645054f, 
    -0.05411828f, -0.05248944f, 0.14280075f, 0.11430706f, -0.06533373f, 0.02990972f, -0.09470285f, 0.04998590f, 
    0.00522640f, -0.02193577f, -0.05133470f, -0.03995858f, 0.16214038f, 0.08745177f, 0.03290759f, -0.06231558f, 
    -0.10220041f, -0.01412399f, 0.00802743f, 0.01531404f, -0.00293390f, 0.06650253f, -0.00414269f, -0.06117077f, 
    0.08802729f, 0.00610826f, -0.08321394f, -0.04924471f, -0.08386585f, 0.11353865f, -0.01275982f, 0.00517667f, 
    -0.04056804f, 0.04631001f, -0.02622530f, -0.06706213f, 0.29466176f, -0.08706418f, -0.00958071f, -0.02322676f, 
    -0.06787857f, -0.01742794f, -0.05667600f, 0.08135811f, -0.02095801f, 0.05600949f, 0.06916236f, 0.04244005f, 
    -0.01181512f, 0.07318941f, 0.04992111f, 0.07343932f, 0.01243343f, 0.11414529f, 0.00179040f, 0.00193144f, 
    0.03663082f, 0.02860449f, -0.07059938f, 0.01779702f, 0.25506192f, 0.31900096f, -0.04147570f, 0.02001142f, 
    0.01338860f, -0.06299914f, -0.00158677f, -0.04382172f, 0.04378263f, -0.09715229f, 0.00489868f, 0.02867735f, 
    0.00740602f, -0.06461403f, -0.11496281f, 0.21056102f, -0.09351616f, -0.03032985f, -0.12372912f, -0.05411125f, 
    0.02737497f, -0.04585250f, 0.05163173f, -0.00999477f, 0.01185844f, -0.10413161f, 0.00819238f, 0.14377795f, 
    0.00836463f, 0.04272290f, -0.02788376f, -0.00732597f, 0.12778021f, 0.00206629f, 0.00100708f, -0.09013572f, 
    0.08288065f, 0.08515170f, 0.04800837f, -0.22281377f, -0.01200824f, 0.00006533f, -0.05249961f, -0.01016651f, 
    -0.09573490f, 0.09349243f, 0.02566160f, 0.08678133f, 0.18029594f, 0.00761826f, 0.12555844f, 0.08662638f, 
    -0.01332073f, -0.00719452f, -0.02329494f, -0.04586920f, -0.04121937f, 0.09487111f, 0.08521658f, -0.04768821f, 
    -0.22174360f, -0.01627946f, -0.11629528f, 0.04096069f, -0.03082740f, -0.00424398f, -0.00634805f, -0.08008416f, 
    -0.12649940f, -0.01208287f, 0.06790966f, 0.00483661f, -0.01743263f, -0.18137507f, -0.24050270f, 0.09642534f, 
    0.05225430f, -0.08801609f, 0.05580796f, -0.04835498f, -0.03420274f, -0.00580062f, 0.01310550f, 0.05262557f, 
    0.00203035f, -0.05361084f, -0.04743254f, 0.02866936f, 0.00671899f, -0.00138325f, -0.01603798f, -0.03538068f, 
    -0.01005324f, 0.01178566f, 0.00612790f, 0.01209675f, 0.04274956f, -0.01697757f, 0.01073733f, 0.03085341f, 
    0.02614756f, -0.02862097f, -0.00652188f, -0.00826838f, -0.02839399f, -0.05505619f, -0.00419594f, 0.01490997f, 
    0.01487855f, -0.04388908f, -0.01015554f, 0.01939172f, -0.03111709f, -0.02172977f, -0.03706405f, -0.04823823f, 
    -0.01678636f, -0.04095177f, 0.01311273f, 0.02820381f, -0.03659837f, -0.02524284f, 0.00206604f, 0.01535424f, 
    0.02766347f, -0.05537963f, -0.03059127f, -0.02304551f, 0.01559588f, 0.02191097f, 0.00806998f, -0.05382623f, 
    -0.02886308f, -0.03959201f, -0.02642914f, 0.04462920f, 0.01886828f, -0.00595607f, -0.05140194f, -0.01503819f, 
    0.03147871f, -0.03322177f, -0.04584102f, -0.05162474f, 0.00356809f, -0.04060486f, -0.04923694f, 0.03718631f, 
    0.03293635f, -0.01810833f, 0.00182353f, -0.01042710f, -0.00344163f, -0.04012702f, 0.00753955f, 0.04110323f, 
    -0.05083272f, 0.02342649f, -0.01288889f, 0.00872474f, 0.03492969f, -0.01620679f, -0.03601991f, 0.02433599f, 
    -0.04220868f, -0.05410758f, 0.00799007f, -0.02309626f, -0.00174367f, -0.02715105f, -0.01330553f, -0.00520495f, 
    0.03527399f, 0.00411781f, 0.01103354f, 0.03341608f, -0.00866972f, -0.01190114f, 0.00301364f, -0.03528526f, 
    -0.05644119f, -0.03629618f, 0.01001977f, 0.02441347f, -0.03173337f, 0.00813336f, 0.03927377f, 0.00852831f, 
    0.01264449f, 0.04304861f, 0.01900947f, -0.02394694f, -0.04572575f, 0.03320983f, 0.00810747f, -0.00191206f, 
    -0.02520942f, 0.00960893f, -0.05371628f, 0.00339479f, -0.03792576f, -0.05307549f, -0.00298071f, 0.02136328f, 
    0.04074594f, -0.04432512f, 0.00839541f, 0.01069758f, 0.03598658f, -0.05575883f, -0.03102395f, -0.01243680f, 
    0.03348855f, -0.03164818f, -0.00348722f, -0.05272933f, -0.04215329f, 0.01666703f, -0.05687352f, 0.02031199f, 
    0.01297466f, -0.05414915f, 0.03485107f, -0.04784643f, 0.00936271f, 0.01082104f, 0.01015085f, -0.01495512f, 
    -0.05495033f, -0.02395945f, 0.03938955f, -0.05662822f, -0.04438396f, -0.00300264f, 0.01323473f, -0.05626556f, 
    0.02629801f, 0.03564388f, 0.00245948f, -0.05347078f, -0.05543016f, -0.02421013f, 0.01534468f, 0.03489177f, 
    -0.03813439f, 0.04092318f, -0.03347501f, -0.01509133f, 0.02526374f, -0.01430719f, -0.04596211f, -0.04422195f, 
    0.02672443f, -0.01607777f, -0.00088374f, -0.01749659f, 0.01520088f, 0.03168537f, 0.03643220f, 0.04395071f, 
    0.04030311f, 0.02041687f, -0.04283463f, -0.04021240f, -0.02824795f, -0.02672300f, -0.01277950f, -0.04628133f, 
    0.04479284f, 0.03426241f, 0.01996682f, 0.00365588f, -0.04347603f, 0.01919783f, -0.03941248f, 0.04268923f, 
    -0.02815134f, 0.03561284f, -0.01936994f, -0.05261318f, 0.02216503f, 0.03182881f, -0.05395164f, -0.00126144f, 
    -0.04236902f, 0.02481585f, 0.03935449f, 0.00174505f, -0.04752749f, 0.01142852f, -0.00459571f, -0.02879133f, 
    -0.02276072f, -0.05334838f, 0.01808337f, 0.04268899f, -0.04792465f, 0.00331533f, -0.01992992f, -0.03517677f, 
    -0.03221989f, -0.01135836f, 0.03924979f, -0.03151386f, 0.02722344f, -0.03673466f, -0.04525352f, -0.05497251f, 
    -0.03628420f, 0.00091818f, -0.02092674f, 0.01990787f, 0.00901985f, 0.03186662f, -0.02202208f, 0.00406384f, 
    -0.01938077f, 0.02490960f, -0.03936255f, 0.00680037f, -0.00501840f, -0.02005328f, -0.05481543f, -0.00444972f, 
    0.03879708f, -0.03678900f, -0.05565400f, -0.01962806f, 0.04087949f, -0.00017526f, -0.02098588f, -0.03296215f, 
    -0.01997237f, 0.03785678f, -0.00722556f, -0.00245665f, -0.02816067f, -0.03947188f, -0.03156101f, -0.01440145f, 
    -0.04779184f, 0.04297638f, -0.05352091f, 0.02427158f, -0.00582544f, 0.02276215f, -0.00584520f, -0.02550182f, 
    0.00945501f, -0.00381762f, -0.02045708f, 0.04446053f, 0.01857725f, -0.05376084f, 0.02605952f, 0.03831738f, 
    0.01323200f, -0.05150005f, 0.01596144f, -0.03878696f, -0.02456218f, -0.05362353f, -0.02247526f, -0.00888552f, 
    -0.04308768f, -0.01855106f, 0.02562009f, 0.01466570f, 0.03927504f, 0.03520439f, 0.00702391f, -0.00417126f, 
    0.02537352f, 0.01903687f, 0.00388832f, -0.04568463f, 0.00190740f, -0.00645574f, 0.01511019f, 0.01671303f, 
    0.04340219f, -0.00281690f, 0.01029333f, -0.05064082f, -0.05464399f, -0.03827644f, -0.03463059f, -0.01345564f, 
    0.00485039f, 0.00284251f, 0.01848946f, 0.02911922f, -0.05422110f, -0.02813643f, -0.00540882f, 0.00354398f, 
    0.00075361f, 0.00087128f, -0.00516762f, 0.03084642f, -0.00424814f, -0.00598964f, -0.00597634f, -0.02738837f, 
    -0.02644586f, -0.00558296f, 0.02197180f, -0.00757630f, 0.02404732f, -0.01758981f, 0.02444985f, -0.05301480f, 
    -0.01302666f, -0.02670398f, 0.00434380f, 0.04447852f, -0.01100894f, 0.02886386f, 0.03680185f, 0.02809878f, 
    0.03459276f, -0.01680441f, -0.01239788f, -0.03712780f, -0.04185975f, 0.01008248f, -0.03780148f, -0.01757238f, 
    0.00089158f, -0.02636149f, -0.01989724f, -0.01422644f, 0.02642581f, -0.02898552f, 0.00432444f, -0.05688917f, 
    0.02422152f, -0.00845545f, -0.04599353f, 0.03556779f, 0.00123100f, -0.02453510f, -0.01235573f, -0.02061581f, 
    0.03461496f, -0.02818213f, -0.02249851f, -0.04257163f, 0.02023612f, 0.02447615f, 0.03199081f, -0.04343002f, 
    0.00750964f, -0.03413391f, 0.01636306f, -0.01986312f, -0.04479067f, 0.00697753f, -0.02785882f, 0.00187981f, 
    -0.04767138f, -0.03732634f, -0.05345637f, 0.00955434f, 0.03576887f, -0.02943725f, -0.01196917f, -0.02709001f, 
    0.10107099f, 0.03774386f, 0.02304099f, 0.05570962f, -0.00234373f, 0.02899379f, 0.19130801f, -0.00183039f, 
    0.05779745f, -0.15284148f, 0.02734140f, -0.09246564f, -0.06788702f, -0.02035721f, -0.05186810f, 0.07624523f, 
    -0.03075976f, 0.06904038f, 0.03617162f, -0.05510173f, 0.05287648f, 0.05625984f, 0.08750156f, -0.08930173f, 
    0.05254723f, 0.09468618f, -0.19310375f, -0.10788029f, 0.03230088f, 0.08566631f, -0.14176105f, 0.07435305f, 
    0.03156170f, 0.09967661f, 0.18431646f, 0.07771116f, -0.01499895f, -0.10564304f, 0.05856951f, -0.08188137f, 
    -0.07289255f, -0.14375265f, 0.02642566f, 0.04565811f, 0.06202513f, 0.08370245f, -0.15393560f, -0.02174355f, 
    0.00432575f, -0.09672309f, -0.11023029f, -0.21630988f, 0.16581634f, -0.11787282f, -0.07535894f, -0.02450660f, 
    0.00298199f, 0.07271618f, 0.05051083f, 0.14783986f, -0.02569638f, 0.03233643f, 0.01794394f, 0.08271386f, 
    0.01197119f, 0.07478626f, -0.08972294f, 0.00951320f, -0.01859782f, -0.02800083f, -0.03449201f, 0.12376650f, 
    0.21832211f, 0.01958275f, -0.06570608f, 0.06160498f, 0.04879268f, 0.06585336f, 0.08322140f, -0.07107364f, 
    -0.01703066f, -0.01888717f, -0.00325400f, -0.03813969f, 0.23680803f, 0.05963155f, -0.05809751f, 0.02416638f, 
    0.02697703f, 0.09650729f, -0.03930702f, 0.05006768f, -0.00979795f, -0.04216883f, -0.03052003f, -0.09001859f, 
    0.01572123f, 0.03724046f, 0.09814301f, -0.01976329f, -0.15920404f, 0.09753340f, -0.01552658f, -0.04480308f, 
    0.02279738f, -0.03941189f, -0.02102892f, -0.04383382f, -0.00754062f, -0.03008823f, -0.11727501f, -0.30351359f, 
    0.12329628f, -0.13129438f, 0.09164476f, -0.08819211f, -0.00168993f, 0.10919677f, -0.05067624f, 0.12627509f, 
    -0.03703319f, -0.24622753f, 0.17438692f, -0.20270406f, -0.05621687f, 0.09776009f, -0.04097141f, -0.01592818f, 
    -0.10001133f, 0.09778187f, -0.09616145f, 0.10043122f, -0.02426079f, -0.26511195f, -0.22058685f, 0.19104524f, 
    0.19049183f, -0.00123260f, 0.00381588f, 0.00555629f, 0.14990519f, 0.09300695f, 0.05943826f, 0.14326553f, 
    -0.41359162f, -0.12036919f, 0.01042205f, 0.02048008f, 0.07589538f, -0.16710803f, -0.05096997f, -0.07367966f, 
    0.06363446f, 0.16869694f, 0.09645510f, 0.05710704f, 0.11808768f, -0.08895470f, -0.24799259f, 0.22503158f, 
    0.16968793f, -0.05264206f, -0.16576381f, 0.07049064f, -0.07276686f, 0.06558612f, -0.00906247f, 0.13361542f, 
    0.06949238f, 0.12397179f, 0.04132073f, -0.04141481f, 0.05197178f, 0.02866538f, -0.21593052f, 0.01754415f, 
    -0.06448796f, -0.04133440f, 0.02475728f, -0.19132616f, 0.22628266f, 0.18331751f, -0.04978634f, 0.10364007f, 
    0.05458024f, -0.03919892f, -0.06688092f, 0.04451507f, 0.08275459f, 0.22005959f, 0.07002460f, -0.01474036f, 
    0.05626826f, 0.01995813f, 0.02588479f, 0.13540895f, 0.01307064f, 0.02812663f, 0.09133237f, -0.16269630f, 
    0.05744803f, 0.07818374f, 0.00304413f, 0.02802846f, -0.01910552f, -0.22234192f, 0.06921551f, -0.03108712f, 
    -0.01248462f, 0.05336101f, -0.10113559f, 0.04167240f, 0.03359997f, 0.11415086f, -0.10956172f, 0.03910762f, 
    0.36724389f, -0.04928182f, -0.23834170f, 0.16469820f, 0.05360004f, -0.10275432f, 0.13326612f, 0.07510394f, 
    0.06592924f, 0.05899788f, 0.14700568f, 0.01815020f, 0.08752248f, 0.21131980f, 0.11666195f, -0.05341293f, 
    0.06222378f, 0.03429184f, -0.01705670f, 0.03206874f, -0.00413866f, 0.09249732f, -0.05549400f, 0.08103925f, 
    0.09808507f, 0.10587614f, -0.07672925f, -0.15551193f, 0.08354131f, -0.15422811f, 0.14684039f, 0.11444384f, 
    -0.00657138f, -0.04381898f, 0.01382729f, 0.07226765f, -0.05750479f, 0.10832538f, 0.21005945f, -0.21402588f, 
    -0.06673361f, 0.01205179f, 0.06556361f, -0.18414538f, 0.05302369f, -0.00787653f, 0.02705486f, 0.06972714f, 
    -0.02594654f, -0.07071869f, 0.03582430f, 0.02040804f, 0.02959057f, -0.00451246f, 0.12938662f, 0.03779960f, 
    0.11375931f, 0.02646331f, -0.00301861f, 0.11098232f, -0.14707041f, -0.24945025f, -0.01909255f, 0.07282269f, 
    0.12309181f, 0.13643742f, -0.00115832f, -0.04820395f, 0.11261524f, -0.04576154f, -0.04071519f, 0.10508010f, 
    0.00404159f, -0.02306669f, -0.06711408f, 0.12084397f, -0.06391656f, -0.10742904f, 0.04419098f, 0.00057879f, 
    -0.15949067f, 0.05445049f, 0.09694673f, 0.11824415f, -0.14168642f, -0.24113877f, 0.02674566f, 0.15545201f, 
    0.00255722f, -0.00709286f, -0.10008675f, -0.02180015f, 0.05262532f, 0.13490488f, 0.02481949f, -0.09737187f, 
    -0.05484624f, -0.08110053f, 0.01853316f, -0.28426170f, 0.09741490f, -0.11424251f, -0.03441446f, 0.02152695f, 
    0.05137561f, -0.05292172f, 0.04728601f, -0.14083183f, 0.00640689f, 0.01350599f, -0.14214380f, -0.03543310f, 
    0.09440673f, 0.05213230f, 0.02708414f, 0.02633023f, 0.03970049f, 0.03302215f, 0.01576899f, 0.15715800f, 
    -0.26359648f, 0.22797497f, 0.02169878f, 0.09377514f, 0.19190194f, 0.04667065f, -0.16439499f, -0.07736733f, 
    0.13832010f, -0.14957297f, 0.02803697f, -0.04794472f, -0.22481287f, -0.09912898f, 0.04273047f, -0.07505908f, 
    0.17344432f, -0.00520471f, 0.11096896f, -0.02857050f, 0.08920836f, -0.13820280f, -0.16172902f, -0.13511676f, 
    0.38365683f, 0.08847722f, 0.07590042f, -0.02518810f, -0.14251797f, 0.00047432f, -0.01833345f, 0.05588146f, 
    -0.01917485f, -0.08569304f, 0.04967826f, 0.13225026f, -0.02686679f, -0.09421363f, -0.00857758f, -0.16731194f, 
    0.11681042f, 0.06533896f, 0.03732168f, 0.10649416f, 0.13087617f, 0.08747083f, 0.01248859f, 0.04242893f, 
    -0.01651318f, 0.00090312f, -0.00898546f, 0.00580817f, 0.02962484f, -0.03451260f, 0.04555009f, 0.00631728f, 
    0.04295320f, 0.03132593f, -0.05086095f, 0.00508012f, 0.03685643f, -0.03817120f, 0.01649875f, -0.04399746f, 
    -0.04968982f, 0.03522709f, -0.02217671f, 0.03921226f, -0.03338687f, -0.02106577f, 0.04051775f, -0.02666980f, 
    -0.02802368f, 0.03627402f, -0.05389002f, 0.05178345f, -0.02795254f, -0.01691675f, 0.00784216f, -0.03384921f, 
    0.00542938f, 0.00882095f, -0.04777889f, 0.02490676f, 0.01269079f, -0.03527811f, 0.03793499f, 0.00418081f, 
    -0.03026780f, -0.04952295f, 0.01512714f, 0.03797105f, -0.05344828f, -0.04885750f, 0.01740125f, -0.03642039f, 
    -0.00443276f, -0.03967639f, -0.05433768f, -0.01777022f, 0.01769850f, -0.05409124f, -0.02195788f, -0.02730848f, 
    -0.01336909f, 0.04228315f, -0.04425399f, -0.04131961f, 0.02538675f, -0.03616495f, 0.04524017f, 0.01101725f, 
    -0.01871259f, 0.03652951f, 0.02224707f, -0.00487484f, 0.02800313f, 0.03712451f, -0.00905536f, -0.00489464f, 
    -0.05152726f, 0.00070810f, 0.02662628f, 0.05157378f, 0.01742561f, 0.01115349f, 0.00323862f, 0.01396654f, 
    -0.00619048f, -0.00400173f, -0.03341575f, 0.03223769f, 0.03520684f, 0.04679378f, -0.03566839f, -0.00037040f, 
    0.02299586f, 0.03640680f, 0.02154994f, 0.02413057f, -0.02089474f, -0.02407806f, 0.01731060f, -0.05370323f, 
    -0.04901876f, -0.00120193f, 0.00103591f, 0.00002277f, -0.00527538f, -0.04368712f, 0.02480406f, 0.03070494f, 
    0.00221233f, -0.02174339f, 0.01236837f, 0.01311684f, -0.00041773f, -0.04964032f, 0.02013054f, -0.04807481f, 
    -0.00550549f, 0.04213997f, 0.03518770f, 0.02016580f, -0.05875060f, -0.03336133f, 0.04161635f, 0.02077337f, 
    0.01859317f, -0.02863758f, 0.05529162f, 0.00385703f, -0.00692693f, -0.04962774f, -0.00943742f, -0.03352077f, 
    -0.02935102f, -0.03953918f, 0.01501435f, 0.01406432f, 0.01934722f, -0.00444876f, 0.02714251f, 0.03889589f, 
    -0.01279111f, -0.03796146f, 0.00341331f, -0.04542109f, 0.02638371f, -0.00131094f, -0.02693510f, 0.01287308f, 
    -0.01164660f, 0.02722054f, 0.02057534f, 0.04474066f, 0.02596910f, -0.04097409f, -0.00544648f, -0.02749986f, 
    0.04294318f, 0.01551527f, 0.03328020f, -0.00847682f, 0.02669954f, 0.03798478f, -0.01374373f, 0.01548441f, 
    0.00789917f, 0.04029520f, -0.01836599f, -0.05661038f, 0.01945816f, -0.05185363f, 0.02305546f, 0.02248254f, 
    0.02846077f, -0.03256305f, -0.01333339f, 0.01523104f, -0.05231987f, 0.02335766f, -0.00464417f, -0.00552690f, 
    -0.03607500f, 0.00358866f, 0.01282757f, -0.04557430f, -0.02684152f, 0.02094871f, 0.00099810f, 0.01784026f, 
    0.04479421f, -0.04130848f, -0.04428795f, -0.02605384f, -0.00676513f, -0.04063892f, -0.02231394f, -0.05449976f, 
    -0.04370631f, -0.04416946f, -0.02305960f, 0.03472687f, -0.02048329f, -0.01054167f, 0.02089790f, 0.02625877f, 
    -0.00640618f, -0.02885018f, 0.00782325f, 0.01090041f, -0.02703534f, 0.04042796f, 0.03276074f, -0.02199652f, 
    0.00312362f, 0.02645639f, -0.02835332f, -0.02895817f, 0.00758881f, -0.00107449f, -0.03455972f, -0.05371614f, 
    0.03329839f, -0.02166829f, 0.00284255f, -0.03798492f, 0.04961850f, -0.04424953f, -0.04473017f, -0.03361573f, 
    0.00437554f, -0.03754304f, 0.00788875f, 0.01126114f, -0.00615970f, -0.02446935f, 0.05081379f, -0.04554693f, 
    -0.02216348f, -0.02222222f, -0.02155103f, -0.05380247f, 0.00517478f, -0.04956686f, -0.03499806f, -0.03920785f, 
    -0.02882554f, 0.04001662f, -0.02727727f, -0.03206115f, -0.02571076f, -0.01868647f, -0.00880531f, -0.01856085f, 
    -0.04599353f, 0.03659286f, -0.01765291f, -0.00009589f, -0.05128511f, -0.03534668f, -0.00737924f, -0.04176781f, 
    -0.02703365f, 0.02004030f, 0.01158256f, 0.02733964f, 0.00270196f, 0.01350408f, 0.01497942f, 0.02116155f, 
    0.01412026f, -0.05118416f, -0.05294215f, -0.02797123f, 0.01897161f, -0.00455499f, 0.03183777f, 0.01532217f, 
    0.03416221f, 0.00643418f, -0.02329182f, -0.02146277f, 0.04468324f, 0.03846275f, -0.04746890f, -0.01453575f, 
    -0.01427683f, 0.03787499f, 0.03569837f, -0.00891253f, -0.03461307f, -0.01527601f, -0.00410857f, 0.00138805f, 
    -0.03794443f, -0.01205050f, -0.05089914f, -0.02464724f, -0.00644436f, -0.00819739f, -0.02236376f, -0.05882617f, 
    0.02307614f, 0.03432214f, 0.04750368f, -0.04919833f, 0.00561809f, -0.02184580f, 0.03751828f, -0.00790004f, 
    -0.01822188f, -0.05888651f, 0.04257442f, 0.03674068f, 0.01289671f, -0.01701102f, -0.02002558f, 0.00315817f, 
    0.03958830f, 0.02706302f, 0.04318941f, -0.03547822f, -0.01937275f, 0.04188671f, 0.02281605f, 0.05060465f, 
    -0.01803742f, -0.01878295f, 0.01957145f, -0.00705230f, -0.01081756f, -0.00474392f, -0.01711010f, -0.00712458f, 
    -0.01072849f, 0.01471948f, 0.03473884f, -0.00498729f, 0.01522129f, 0.00091492f, -0.00728606f, -0.00872535f, 
    -0.00971008f, -0.02497866f, 0.01767889f, 0.04132304f, 0.03658313f, 0.01561543f, -0.04588396f, -0.05280585f, 
    0.02423897f, 0.02341859f, 0.02984741f, -0.03043383f, -0.04954395f, -0.02045682f, 0.00307029f, -0.03085050f, 
    -0.04176490f, 0.03671732f, -0.02657090f, -0.00722815f, -0.02092343f, -0.02278460f, 0.02377935f, 0.03322829f, 
    0.03902088f, -0.04075627f, -0.01536227f, -0.00757676f, -0.05782035f, -0.02932819f, 0.01969193f, 0.04346115f, 
    -0.02480693f, 0.02605717f, -0.01416857f, 0.04222391f, -0.03901669f, -0.01059905f, 0.03906671f, -0.01289683f, 
    -0.01309484f, -0.02733009f, 0.03376807f, -0.02305321f, -0.01128669f, 0.01156415f, -0.00280412f, -0.02404285f, 
    -0.10359200f, -0.16557838f, 0.12231651f, -0.10200779f, 0.07945614f, 0.11475194f, 0.01724362f, -0.03878537f, 
    -0.00507554f, -0.09502102f, 0.05678875f, -0.08898529f, 0.12523355f, 0.13492219f, -0.05633704f, -0.07702886f, 
    -0.04640951f, 0.12950839f, 0.15664895f, -0.11146575f, -0.09848517f, 0.06905935f, 0.08362733f, -0.03030655f, 
    0.17293686f, -0.07081974f, -0.08347418f, 0.03883175f, -0.01880113f, 0.02567331f, -0.00497525f, 0.00715028f, 
    -0.00851317f, 0.03616675f, 0.18070774f, 0.01724712f, 0.08169558f, -0.12570836f, 0.16062754f, -0.26499262f, 
    -0.03070761f, -0.02815363f, 0.10707287f, 0.01164636f, -0.04745882f, 0.02640774f, -0.16416980f, -0.00161065f, 
    0.10718980f, 0.09030751f, -0.01164391f, 0.05834124f, -0.08623453f, 0.05823473f, 0.00082676f, 0.04637913f, 
    0.05950082f, 0.00905269f, -0.02507862f, 0.14293520f, -0.07146639f, 0.12354601f, -0.00988566f, 0.03068198f, 
    0.07421743f, -0.21050014f, -0.05142417f, -0.17023990f, -0.02572756f, -0.05358220f, 0.05627876f, 0.18438077f, 
    0.26903051f, 0.07814956f, -0.31138343f, -0.02879762f, 0.03866737f, 0.02064403f, -0.05689200f, -0.17214377f, 
    -0.01709059f, 0.00926026f, 0.13692962f, 0.00023198f, -0.00133399f, 0.06839073f, -0.06162944f, -0.21891868f, 
    -0.02838539f, 0.09306329f, -0.11946753f, 0.06035226f, 0.03942462f, -0.03277126f, -0.00358012f, 0.10919775f, 
    0.00106741f, 0.04349159f, 0.06964620f, 0.01302328f, -0.02788436f, -0.05136807f, 0.02447058f, -0.14886446f, 
    0.05781685f, 0.01978082f, 0.11131073f, 0.12371950f, 0.09313791f, 0.15687080f, -0.05690151f, -0.07304819f, 
    0.18709348f, -0.15874252f, 0.02483709f, -0.01941475f, -0.12954596f, 0.04739675f, -0.10323950f, -0.03671099f, 
    0.10438769f, 0.10212085f, 0.27786323f, 0.09403218f, -0.10053771f, 0.12115942f, -0.16106395f, -0.15479583f, 
    0.04006150f, 0.08002456f, -0.09407348f, 0.00695844f, -0.07913508f, 0.07343689f, -0.22713713f, 0.01889206f, 
    -0.05388483f, 0.00074677f, 0.04501778f, -0.14698477f, 0.10839275f, -0.04378121f, 0.03526880f, 0.17124143f, 
    -0.20712055f, 0.02775641f, 0.07058906f, 0.27689925f, -0.05737147f, -0.03048065f, -0.07635783f, -0.06765266f, 
    -0.00315024f, 0.07862475f, 0.03509263f, 0.05800642f, 0.00642804f, 0.23789901f, -0.32102475f, 0.08258757f, 
    0.08893690f, -0.01218992f, 0.10528263f, -0.11663895f, -0.07491333f, -0.00210898f, 0.03447037f, -0.02007260f, 
    -0.14922486f, 0.05401713f, 0.09878048f, -0.07213297f, 0.09476592f, 0.00912181f, -0.06286404f, -0.01636460f, 
    -0.06660185f, -0.04019496f, -0.05072460f, -0.08217669f, -0.25009951f, 0.03121986f, 0.01435495f, -0.09521861f, 
    0.10638739f, -0.06589087f, -0.01065726f, 0.07278935f, -0.04789161f, -0.01978077f, 0.04462851f, 0.06699705f, 
    -0.13040923f, 0.17556460f, 0.03554159f, -0.06835944f, -0.02849446f, 0.00091018f, 0.06261680f, -0.03329226f, 
    0.01707333f, -0.02551140f, -0.06506867f, -0.01805166f, 0.16311613f, -0.19661880f, 0.20224875f, 0.12768178f, 
    -0.09427379f, 0.05849803f, 0.03333195f, -0.02527796f, 0.12814665f, -0.07391196f, -0.02024829f, -0.01543614f, 
    0.01501376f, 0.18524003f, -0.01276004f, 0.10815842f, 0.02146217f, 0.03991598f, 0.08668207f, -0.04599047f, 
    -0.10225964f, 0.08783896f, -0.01547317f, 0.12269131f, -0.15272918f, -0.09370640f, 0.05978299f, -0.05086232f, 
    0.00824648f, 0.12673835f, -0.04290574f, -0.02080864f, -0.01736871f, 0.00324304f, 0.11838714f, -0.00061020f, 
    -0.01074955f, 0.02372371f, -0.11265389f, -0.07538570f, 0.18184984f, -0.06594059f, 0.05325378f, 0.04205398f, 
    0.02322671f, 0.03623749f, -0.03347513f, 0.02978848f, -0.33263204f, -0.12010768f, -0.02053320f, -0.12306467f, 
    0.17844228f, 0.11552773f, -0.04167115f, -0.09647316f, 0.16571280f, 0.09564646f, -0.15144013f, 0.05010873f, 
    0.14385563f, 0.04068139f, 0.12696941f, 0.06488757f, -0.10853888f, -0.10199973f, 0.09820592f, 0.04375588f, 
    -0.02544400f, 0.04093508f, 0.03634806f, 0.16009612f, -0.04254283f, -0.15014179f, -0.06176601f, -0.02250937f, 
    0.07654432f, 0.02524559f, -0.07115632f, -0.00854653f, -0.05498451f, -0.03143211f, 0.06654578f, 0.01904395f, 
    0.10578722f, -0.07562278f, 0.04236581f, 0.01587128f, -0.05277176f, 0.04214487f, 0.00202872f, 0.04465815f, 
    0.05816552f, -0.00432969f, 0.04796869f, 0.05647403f, -0.16091554f, -0.10003141f, 0.09592585f, -0.10090844f, 
    0.07005028f, -0.00244029f, -0.01008628f, -0.04929469f, 0.13895510f, 0.01723334f, 0.08071139f, 0.06888452f, 
    0.18030240f, 0.17669122f, 0.19491149f, 0.08892958f, -0.01155876f, -0.12367761f, -0.05169494f, 0.07378849f, 
    0.01330401f, 0.08463478f, 0.01002237f, -0.02136249f, 0.14987952f, 0.18769817f, 0.13286035f, -0.05920433f, 
    -0.05081744f, 0.02214523f, -0.10468413f, 0.08665284f, -0.13619027f, -0.01209309f, 0.08215590f, 0.13745601f, 
    -0.23470330f, -0.07998365f, -0.10735727f, 0.01325854f, 0.13713267f, -0.08432214f, 0.00328954f, 0.05909690f, 
    0.03758708f, -0.11234716f, 0.05093595f, -0.10811874f, 0.07305291f, -0.08834293f, 0.14262012f, 0.01965823f, 
    0.06280461f, 0.08246301f, -0.07440113f, 0.08776589f, -0.01215730f, -0.18423082f, -0.01420712f, -0.07199829f, 
    0.21366571f, 0.11867195f, -0.05561182f, 0.09767523f, 0.04334880f, -0.09593228f, 0.07626233f, -0.05702520f, 
    -0.02363166f, -0.06685411f, -0.02488471f, 0.09006732f, -0.05544269f, 0.18603198f, 0.19721806f, 0.10849920f, 
    0.17671746f, -0.17130840f, -0.02827462f, -0.06569824f, 0.06040001f, 0.01927438f, -0.02752565f, 0.11530640f, 
    -0.01617621f, 0.01769157f, -0.04332976f, -0.03085676f, -0.02161615f, -0.03978721f, 0.02757792f, -0.03037592f, 
    -0.00263640f, -0.00398502f, -0.01520365f, 0.00144356f, -0.03767630f, -0.01510503f, -0.03766450f, -0.04257732f, 
    -0.00102725f, 0.00231748f, -0.03147228f, 0.02554741f, 0.01734230f, -0.04279178f, 0.00838073f, 0.02919797f, 
    -0.01001345f, -0.05063136f, 0.03929524f, 0.02884236f, -0.03525693f, 0.01755325f, 0.02462256f, -0.01595384f, 
    0.02065465f, -0.05568977f, -0.04108983f, 0.02816688f, 0.01474311f, 0.00343277f, -0.02892083f, -0.03666666f, 
    -0.03932916f, -0.04330344f, -0.02143876f, -0.04934810f, -0.04305097f, -0.04376205f, -0.02619980f, -0.01298024f, 
    0.03569303f, -0.02660067f, -0.05884846f, -0.04571379f, -0.03685328f, -0.02002841f, 0.01102580f, -0.04514449f, 
    0.03762994f, -0.04365433f, 0.01010832f, -0.00398992f, 0.02903503f, 0.00806309f, -0.03384156f, -0.00495359f, 
    0.00018223f, 0.00511383f, 0.03697793f, -0.02445113f, -0.02136379f, -0.05716450f, -0.05316012f, 0.01200456f, 
    -0.00083706f, -0.02203393f, -0.00648909f, 0.03037660f, 0.03559904f, -0.01931674f, 0.03264149f, -0.01648849f, 
    -0.03732279f, 0.02953072f, -0.01397308f, -0.05543014f, 0.00532339f, -0.02111583f, 0.00930910f, -0.04557697f, 
    -0.04570394f, 0.03331410f, 0.01574811f, -0.02958205f, -0.04445884f, 0.01616254f, -0.02248162f, 0.02037190f, 
    0.02647096f, -0.00784998f, 0.01166340f, 0.02628469f, -0.00787681f, -0.05168175f, 0.02945416f, -0.03478754f, 
    -0.04283698f, 0.00758734f, -0.00165842f, 0.04137726f, -0.00453907f, 0.00676361f, -0.01054499f, 0.00338368f, 
    -0.00658427f, -0.05602610f, -0.05249092f, -0.05113262f, 0.00412646f, -0.01920379f, 0.03162338f, -0.04731569f, 
    0.04520638f, 0.03873434f, -0.04324139f, 0.03494259f, -0.03804115f, 0.01764612f, 0.01765876f, 0.00583532f, 
    -0.04492615f, -0.01316604f, -0.04962019f, -0.02086251f, -0.04834506f, -0.04222044f, 0.03518589f, 0.03074224f, 
    0.02911356f, -0.03206038f, 0.03941146f, -0.03214822f, 0.01676345f, 0.04102920f, -0.03018218f, 0.03424076f, 
    0.02576507f, -0.00028136f, 0.01911676f, 0.02728086f, 0.02881051f, -0.01750135f, -0.00144514f, -0.04920411f, 
    0.03383788f, 0.04215072f, 0.00891508f, 0.02210387f, 0.05210315f, -0.04047844f, -0.01793149f, -0.04487848f, 
    -0.01614022f, -0.03033587f, 0.00415737f, -0.02184715f, 0.03172512f, 0.00308164f, -0.05960058f, -0.01465770f, 
    0.03738796f, -0.03143572f, 0.01418634f, -0.01536428f, 0.01781330f, -0.03816297f, -0.03764272f, -0.01938728f, 
    0.03129788f, 0.04871039f, -0.01243368f, -0.01754519f, 0.01904704f, -0.04705891f, -0.05497294f, 0.02844464f, 
    0.04008316f, 0.01236789f, 0.00393631f, -0.01154209f, -0.00810449f, -0.03917152f, -0.01262764f, -0.01181027f, 
    -0.03733173f, 0.00305275f, -0.03876905f, 0.00474156f, -0.00867121f, -0.04239696f, -0.00201779f, -0.05348947f, 
    0.01765943f, 0.01231797f, -0.02051662f, -0.02669974f, -0.01857835f, -0.01282947f, -0.05456273f, -0.00281889f, 
    -0.02610252f, -0.02098637f, -0.04162336f, 0.01870702f, 0.03741550f, 0.01688372f, 0.03448233f, 0.02369310f, 
    -0.00571978f, -0.02292430f, -0.05523993f, -0.05206816f, 0.00095948f, -0.00828317f, 0.03580563f, 0.02218616f, 
    0.03258426f, -0.01136635f, -0.03069426f, 0.03340954f, -0.00133793f, 0.02371551f, -0.01346292f, 0.04176077f, 
    -0.01792281f, 0.02291236f, -0.02408953f, 0.01537030f, 0.03444121f, 0.04405694f, -0.00182419f, 0.01480525f, 
    -0.03092096f, 0.03207420f, -0.01303742f, -0.03022661f, -0.00758881f, -0.00098070f, 0.02903574f, 0.04037999f, 
    -0.00412572f, 0.03358600f, 0.02149829f, 0.01859599f, 0.03202735f, 0.03599709f, 0.04056267f, -0.02476639f, 
    0.03188183f, -0.01676198f, -0.02088332f, -0.05720904f, 0.02674729f, 0.04149940f, -0.00646229f, -0.04939245f, 
    -0.02173250f, -0.00911319f, -0.02313283f, 0.02549149f, -0.00993342f, -0.00971488f, -0.00877496f, -0.05001809f, 
    -0.02299318f, -0.04491106f, -0.01119900f, 0.04341248f, 0.01410055f, -0.02665007f, 0.02583806f, -0.01045252f, 
    -0.02866195f, 0.00146852f, -0.00929870f, 0.01154049f, 0.00365039f, -0.01704455f, -0.03118697f, 0.02100842f, 
    0.04608218f, -0.00549096f, 0.00015394f, 0.02479902f, -0.05615217f, 0.01772958f, -0.05669048f, 0.00465782f, 
    -0.04638838f, 0.00710993f, -0.02711779f, 0.00997194f, 0.01152504f, 0.03503368f, 0.01127290f, -0.02337521f, 
    0.02900540f, -0.03128345f, 0.01666177f, -0.01454953f, -0.00530510f, 0.01318330f, 0.00615419f, 0.00292406f, 
    0.02632823f, 0.01323002f, 0.02241899f, 0.02563383f, 0.03470979f, -0.04205350f, -0.02071732f, 0.00940796f, 
    -0.04275125f, 0.02536688f, 0.00837677f, -0.02015414f, -0.04328723f, -0.04500297f, -0.04178720f, -0.04207832f, 
    -0.01649874f, -0.02987681f, -0.03422388f, 0.02173878f, 0.04280657f, -0.03470977f, -0.03430074f, -0.05337782f, 
    -0.04840600f, -0.01576026f, -0.01319187f, 0.04729109f, -0.02048343f, 0.03435335f, -0.00211976f, -0.05094496f, 
    0.02015362f, 0.02487194f, -0.00617001f, 0.00320112f, -0.00004840f, -0.05331769f, -0.03398231f, -0.03854936f, 
    0.00043846f, -0.03878110f, -0.01949976f, -0.02321145f, 0.03885201f, -0.02316307f, 0.02324408f, -0.01496360f, 
    -0.03045370f, -0.01764236f, 0.04065534f, -0.03380743f, 0.00520093f, 0.01384585f, 0.01483166f, -0.00537529f, 
    -0.04047261f, -0.02294306f, -0.00366031f, 0.00461415f, 0.01701329f, -0.02413547f, -0.03811580f, -0.01750528f, 
    -0.00536445f, 0.02945188f, -0.02960248f, 0.03526902f, -0.04435276f, 0.04654258f, 0.02984245f, -0.00536747f, 
    -0.01162557f, -0.10567581f, 0.05459828f, 0.10656554f, 0.03717108f, 0.13589618f, 0.04954410f, 0.01630344f, 
    0.10124018f, -0.04266547f, 0.10700236f, -0.12502602f, -0.13384202f, -0.22604817f, 0.13727780f, -0.13621959f, 
    0.08384563f, 0.10809220f, 0.01506360f, 0.05660380f, 0.10503837f, -0.05353633f, -0.00406871f, -0.06687129f, 
    -0.02475993f, -0.01493456f, -0.00574346f, -0.15591128f, 0.09425089f, 0.00717126f, -0.00670815f, 0.05711263f, 
    0.03903563f, 0.04775611f, 0.20485352f, 0.05208075f, -0.05203468f, 0.06362769f, 0.11910614f, -0.01369663f, 
    -0.08326472f, -0.05526845f, 0.05097061f, 0.08002042f, 0.10137395f, 0.08024363f, 0.06955781f, -0.03625790f, 
    0.15621476f, -0.06635471f, -0.03358797f, 0.04912785f, 0.14563651f, 0.04355945f, 0.06148304f, -0.03790161f, 
    0.05285642f, 0.02167540f, 0.05190713f, 0.16451557f, -0.06828530f, 0.06139823f, 0.04839480f, 0.00521788f, 
    0.02146665f, 0.04982845f, -0.02182244f, 0.14053209f, 0.05616712f, 0.04873946f, 0.00866539f, 0.11534547f, 
    0.27509850f, -0.02764323f, -0.07054615f, -0.05118240f, -0.02116254f, -0.01220053f, -0.04535735f, -0.04578811f, 
    -0.00300897f, 0.01803328f, 0.00377057f, 0.04174708f, 0.00706623f, -0.12213020f, -0.09448703f, -0.09989934f, 
    0.11939199f, 0.04748840f, -0.14811039f, 0.05230803f, 0.04072244f, 0.00485572f, 0.00665504f, -0.04196254f, 
    -0.22156359f, -0.17987858f, 0.18828936f, -0.32525364f, -0.01461450f, 0.06473783f, -0.04780928f, -0.00056152f, 
    0.00464129f, -0.04858770f, -0.00680922f, -0.02958105f, -0.02938998f, 0.02693502f, 0.09511752f, 0.04743967f, 
    0.13340129f, -0.14480838f, 0.02452400f, 0.01291853f, 0.03818826f, 0.09335690f, -0.07692254f, 0.07490949f, 
    -0.17610663f, 0.10359459f, 0.22465518f, -0.01707489f, 0.03463340f, 0.07124428f, -0.03012263f, -0.06085183f, 
    0.00333365f, 0.04173011f, 0.00105264f, 0.04025500f, 0.11059158f, 0.04545365f, -0.02093049f, -0.00225402f, 
    -0.03166525f, 0.08113649f, -0.00092978f, -0.02045343f, 0.06379531f, 0.02259448f, 0.01332827f, 0.09837124f, 
    0.03031304f, -0.21367462f, -0.06497380f, 0.16465269f, -0.04016890f, -0.08082588f, 0.02661464f, 0.02248866f, 
    0.07110087f, 0.04113393f, 0.03827300f, 0.06508236f, -0.12211271f, -0.05103932f, -0.12254984f, -0.12975098f, 
    0.07700431f, -0.12004077f, -0.15415695f, 0.12672412f, 0.11262983f, -0.04684981f, 0.06326418f, 0.11910317f, 
    -0.05985845f, 0.01094660f, -0.15484883f, -0.24475293f, -0.02589049f, 0.01803871f, -0.03640386f, 0.04213376f, 
    -0.01372367f, 0.04072880f, 0.06736814f, -0.04569144f, 0.15123671f, 0.12614331f, 0.03025389f, -0.06027877f, 
    0.09099222f, -0.04394417f, 0.01048208f, -0.00512572f, 0.05179102f, 0.01634325f, -0.00576725f, 0.04000718f, 
    0.35477197f, 0.16110501f, 0.06204523f, 0.13393331f, 0.06338480f, -0.03191521f, 0.01791067f, -0.01838602f, 
    -0.12844202f, -0.00514351f, -0.07594932f, 0.02103335f, -0.15093671f, -0.08084538f, 0.09209925f, 0.16999990f, 
    0.02337390f, -0.04383894f, 0.07391745f, -0.03758378f, -0.00706998f, -0.00041405f, -0.17399545f, 0.00155490f, 
    0.39762709f, 0.12274100f, -0.22638391f, 0.14619000f, 0.02942656f, -0.00319349f, 0.16494870f, 0.05824847f, 
    -0.08068664f, 0.01722519f, 0.10720865f, 0.00653183f, -0.12532222f, -0.05598313f, -0.01551846f, -0.00854393f, 
    0.07772615f, 0.06208135f, -0.05640133f, 0.03271911f, 0.02138833f, 0.00054946f, 0.06165725f, 0.04431733f, 
    -0.11589982f, 0.01482306f, -0.04707251f, -0.04040178f, -0.00580101f, -0.00221935f, 0.18314739f, 0.03771212f, 
    0.11892691f, -0.03361928f, -0.03906672f, 0.07316016f, -0.04115101f, -0.15083192f, -0.06919752f, -0.04588388f, 
    0.03018646f, -0.04232246f, -0.05444031f, -0.03378721f, 0.12261420f, -0.00946021f, -0.07546139f, 0.07053512f, 
    0.08980463f, 0.14405349f, -0.01325206f, 0.02285243f, -0.05022463f, 0.04467402f, 0.06451774f, 0.08965545f, 
    -0.02520644f, -0.02916455f, 0.01737158f, 0.07871763f, 0.13505645f, -0.10968498f, 0.00513278f, 0.06223612f, 
    0.12944926f, 0.04072981f, 0.01998064f, -0.13081422f, 0.02797082f, -0.10930012f, -0.04826458f, 0.10369456f, 
    0.09426586f, 0.13526021f, 0.11588401f, 0.02321919f, -0.02246768f, -0.02646868f, 0.04529103f, 0.01338731f, 
    -0.02996216f, -0.01909626f, 0.00187183f, 0.01957121f, -0.08945512f, -0.17136882f, 0.08636300f, 0.01599095f, 
    -0.09196350f, 0.00254381f, -0.02732066f, 0.02089827f, 0.04553478f, 0.08930258f, 0.07477809f, 0.00911148f, 
    0.02071582f, -0.03304537f, -0.01061544f, 0.02821585f, 0.02259891f, -0.14455462f, 0.05432382f, -0.05440508f, 
    0.07720984f, 0.04717231f, -0.04417254f, -0.10453703f, 0.11399306f, -0.00738382f, 0.07825123f, 0.07776384f, 
    -0.05498825f, 0.09909367f, 0.05851181f, 0.01923286f, -0.00729589f, -0.03114373f, 0.05697261f, 0.19459897f, 
    -0.08758108f, 0.07842373f, 0.09906788f, -0.03290427f, 0.13800426f, 0.09164775f, -0.07960115f, 0.17087637f, 
    0.03723936f, 0.00843811f, -0.03254583f, 0.03608871f, -0.00616609f, 0.03839533f, -0.00137326f, -0.11004838f, 
    0.08769920f, 0.06576288f, 0.07881843f, 0.08483941f, 0.08237099f, 0.02306027f, -0.04943300f, -0.10721324f, 
    0.12044316f, 0.27179211f, -0.17231134f, 0.03382664f, -0.07140532f, 0.01088394f, -0.10309642f, 0.14194635f, 
    -0.07489879f, -0.04564211f, 0.18695197f, 0.05168074f, 0.30165026f, -0.18687639f, -0.04450555f, 0.05315333f, 
    0.09446488f, 0.05272890f, 0.04252536f, 0.04222456f, 0.02969172f, 0.04620006f, -0.06048015f, -0.01881414f, 
    0.13366462f, 0.15635516f, -0.00562773f, 0.06354459f, -0.05003215f, -0.02373027f, -0.06911725f, 0.05887183f, 
    0.10483349f, 0.19040608f, -0.05265809f, 0.15673928f, 0.01597072f, 0.07033852f, 0.07181602f, 0.09434864f, 
    -0.00030571f, -0.10748482f, -0.01599806f, 0.16096038f, 0.05508327f, -0.04335363f, -0.11740784f, -0.02652088f, 
    -0.36987999f, 0.11118104f, -0.02883882f, -0.04483714f, 0.00320805f, 0.12981813f, 0.03963063f, -0.02829742f, 
    -0.02940147f, -0.10424120f, -0.01737555f, -0.07241230f, 0.14532268f, 0.06358910f, -0.08225772f, 0.27081719f, 
    0.14531778f, 0.12075139f, 0.12997720f, 0.10318864f, -0.03565206f, -0.06338803f, 0.08679237f, 0.05474054f, 
    -0.06481013f, -0.15122925f, -0.06149895f, 0.19520602f, 0.12221753f, -0.05633549f, -0.01659506f, -0.03137417f, 
    -0.04526433f, 0.06913599f, -0.03660344f, -0.11029416f, -0.02931663f, -0.00559594f, 0.03442604f, -0.01577194f, 
    -0.05384468f, 0.19424021f, -0.08597941f, 0.16567671f, 0.04588807f, 0.06723262f, 0.03984350f, -0.10940637f, 
    -0.08782666f, -0.04485590f, 0.20003639f, -0.04189818f, 0.08283667f, 0.02478972f, 0.06028924f, 0.27768722f, 
    -0.02413951f, -0.04198407f, -0.05888180f, 0.04016230f, 0.18781394f, 0.06189830f, 0.07861761f, 0.18263206f, 
    -0.03746042f, -0.08739494f, 0.17156942f, 0.07632054f, -0.04231433f, 0.01905652f, -0.01528467f, -0.11975683f, 
    0.09225162f, 0.09393053f, -0.01409646f, 0.21597706f, 0.06128260f, 0.09245343f, 0.00120591f, 0.12727967f, 
    -0.07195607f, -0.06440766f, 0.04462755f, -0.02644822f, -0.01358536f, -0.06371234f, -0.07111708f, 0.03371051f, 
    -0.01438506f, 0.07824577f, -0.15693940f, 0.02265526f, -0.00796856f, 0.05701736f, 0.10057982f, 0.02619000f, 
    -0.24044658f, -0.14448009f, -0.31284252f, -0.24741185f, 0.07919829f, -0.12730430f, -0.01938600f, 0.01170736f, 
    -0.05290482f, -0.01712173f, 0.05399958f, -0.01814739f, 0.02081602f, -0.08649293f, 0.14619766f, -0.07621685f, 
    0.01021366f, -0.03336303f, 0.09867103f, 0.12812319f, 0.07429573f, 0.00245023f, -0.03889206f, 0.01082723f, 
    -0.01645952f, -0.16778930f, -0.02664054f, -0.07399429f, -0.00067392f, -0.07408059f, -0.01144506f, 0.01627101f, 
    0.00078134f, 0.00764396f, 0.06129513f, -0.02756136f, 0.01465387f, -0.01284050f, 0.34536198f, 0.07369578f, 
    -0.04994646f, 0.13714556f, -0.06902228f, 0.01623015f, 0.09904574f, 0.01948399f, 0.04412606f, 0.10428379f, 
    0.18095221f, -0.06692513f, -0.04699183f, 0.18906757f, -0.01793558f, -0.00075868f, -0.02353033f, -0.05638343f, 
    0.04874823f, 0.08481551f, 0.04003034f, 0.01123966f, 0.15830883f, 0.18100087f, 0.13596699f, 0.13570762f, 
    -0.01617493f, 0.09035747f, -0.00967047f, -0.00229682f, -0.00011136f, 0.10861346f, -0.01831908f, -0.03620138f, 
    0.05082362f, -0.23092058f, -0.12451093f, -0.16048141f, 0.01405368f, -0.00306616f, 0.07073613f, 0.04332354f, 
    0.09084000f, 0.02177615f, -0.01399499f, 0.12333796f, -0.32138833f, 0.12534119f, -0.10551121f, -0.16651046f, 
    -0.11492368f, -0.10538823f, -0.10287195f, 0.02548879f, -0.15079772f, 0.04362945f, 0.02441781f, -0.05245006f, 
    -0.00089487f, -0.12370186f, 0.00964626f, 0.04720309f, -0.12703833f, 0.04101132f, -0.04979980f, -0.06561949f, 
    0.14362724f, 0.05186344f, 0.01744905f, -0.01762868f, 0.28305307f, 0.13133739f, -0.06940073f, 0.19724956f, 
    0.03885077f, -0.08187696f, -0.01221776f, -0.02845060f, -0.02819023f, 0.04283144f, -0.00049269f, -0.06043100f, 
    0.22276510f, 0.03287085f, 0.11325840f, 0.05428173f, 0.02704758f, -0.04169386f, 0.06051577f, 0.05844771f, 
    -0.07257329f, 0.02162000f, -0.01155972f, 0.08195768f, 0.22973868f, 0.14517120f, 0.06239715f, 0.18841447f, 
    -0.01341521f, -0.00174667f, 0.03277136f, 0.13138925f, -0.09885256f, 0.02712029f, 0.08301564f, -0.08958279f, 
    -0.12784413f, -0.13839833f, -0.18884756f, -0.19076383f, 0.12801456f, 0.06170561f, 0.03894827f, -0.04657441f, 
    0.01528693f, 0.01750640f, 0.00705446f, -0.06252469f, 0.07206320f, -0.21780366f, -0.04886943f, -0.10914135f, 
    -0.07234874f, -0.09041134f, -0.02794567f, 0.05415940f, 0.08309717f, 0.06606030f, 0.02568208f, 0.05714175f, 
    -0.05729159f, 0.00565125f, -0.04446941f, 0.04469520f, 0.01263998f, 0.05796452f, -0.10960243f, -0.00935268f, 
    -0.10842238f, -0.11013949f, -0.03127934f, 0.03696318f, 0.19346178f, 0.17944935f, -0.07321244f, 0.26976815f, 
    0.08869301f, 0.09086157f, 0.06082722f, -0.13228159f, -0.12014731f, -0.01244987f, -0.06154083f, -0.05124202f, 
    -0.04254185f, -0.18456596f, -0.29794973f, -0.16802455f, -0.00387818f, -0.06959228f, -0.03874717f, -0.05064457f, 
    0.05441255f, 0.04403290f, 0.07804306f, 0.15614419f, -0.01998611f, -0.21364170f, -0.11764944f, 0.06121877f, 
    0.08597030f, -0.01096655f, -0.02366505f, -0.03882935f, 0.06112078f, -0.00759443f, 0.02926619f, -0.14799803f, 
    0.00796678f, 0.14131857f, 0.20102876f, 0.06344725f, -0.09548474f, 0.10014119f, -0.06242545f, -0.12031521f, 
    -0.06914300f, 0.02936172f, 0.00824413f, 0.12021878f, 0.00383025f, 0.13891102f, 0.11724237f, 0.10996931f, 
    0.02310059f, -0.09320330f, -0.01533561f, -0.10201285f, 0.14659548f, 0.13251497f, 0.03454099f, 0.05781941f, 
    -0.03586325f, 0.11164681f, 0.00108760f, 0.13828732f, -0.10751783f, 0.02960748f, -0.05969573f, -0.15309927f, 
    -0.03401501f, 0.04725236f, 0.08026583f, 0.05983337f, 0.14239317f, -0.27158085f, -0.23010598f, -0.13553157f, 
    -0.04750184f, -0.10843378f, -0.12876070f, -0.04643060f, -0.11346470f, 0.07237154f, -0.03352213f, 0.07328611f, 
    -0.21295115f, -0.01505215f, -0.09315711f, -0.15738130f, 0.05589702f, -0.03718174f, 0.07523691f, 0.03808079f, 
    -0.02837733f, -0.26277173f, -0.06383482f, -0.16374484f, -0.02121018f, 0.03870800f, 0.04664468f, 0.08072367f, 
    0.00458776f, -0.06611430f, 0.00753010f, 0.01258054f, 0.08577105f, -0.16932714f, 0.03786403f, -0.00295687f, 
    0.04472528f, 0.17753367f, -0.17521356f, 0.10854843f, 0.06046111f, 0.06111227f, -0.00098687f, -0.00163212f, 
    -0.09063131f, 0.03841918f, 0.08429070f, 0.04972896f, -0.01533991f, -0.10541347f, 0.07343674f, 0.00708143f, 
    0.06011941f, -0.00155851f, 0.00552499f, -0.05302187f, 0.08372106f, 0.12697305f, -0.14562672f, 0.07970244f, 
    -0.13665703f, -0.19030549f, -0.01160516f, 0.25651193f, 0.13939367f, -0.00259612f, -0.07516424f, -0.13445677f, 
    -0.15381642f, 0.10924476f, 0.01955809f, 0.12303029f, 0.21192889f, 0.15464514f, -0.20369226f, -0.07116068f, 
    0.17045270f, -0.02602101f, -0.04274551f, 0.00830002f, -0.01544270f, 0.07510532f, -0.13733126f, 0.12216503f, 
    0.22590841f, 0.02566349f, 0.16254085f, 0.14587815f, -0.04779723f, -0.06623033f, -0.10507297f, 0.13824892f, 
    -0.14609386f, 0.03178876f, -0.02221244f, -0.04322005f, 0.14549012f, 0.14753476f, 0.07567980f, 0.21004154f, 
    -0.12261679f, -0.05841559f, -0.02968813f, -0.01606361f, 0.07140063f, 0.06399197f, 0.07952813f, -0.24352252f, 
    -0.14950170f, -0.23319040f, 0.05825734f, -0.00274925f, -0.06594351f, 0.06410085f, -0.12672663f, 0.02379526f, 
    0.00627840f, -0.02130984f, 0.01224760f, 0.01333754f, 0.07246223f, -0.01859978f, -0.08923850f, 0.03161201f, 
    0.08820368f, 0.02608735f, -0.01395541f, -0.07535714f, 0.04621381f, -0.03583467f, -0.09196089f, -0.04534599f, 
    0.16816446f, 0.14994955f, 0.05516011f, 0.09279363f, 0.02543195f, -0.00797115f, -0.00494582f, 0.05858294f, 
    -0.16889884f, 0.15930827f, 0.04969576f, -0.01368922f, 0.05490954f, -0.06246649f, -0.12860502f, 0.04135324f, 
    0.12088960f, 0.00145385f, -0.01087694f, 0.04903953f, -0.01965559f, 0.01301374f, 0.10093936f, 0.01454241f, 
    -0.23854807f, 0.22763687f, -0.04134577f, 0.13628078f, 0.07973314f, -0.09511035f, -0.04018926f, -0.05681209f, 
    0.12256770f, 0.08596680f, 0.08282287f, 0.05306705f, 0.03765808f, -0.12836529f, -0.09689980f, -0.22592455f, 
    -0.05191617f, -0.08355791f, -0.01161525f, -0.03944702f, -0.02463980f, 0.08478499f, -0.00880830f, 0.05992461f, 
    0.05770301f, 0.11799017f, -0.05078534f, 0.04244798f, 0.07645910f, -0.09373491f, -0.09117279f, 0.04520064f, 
    0.19944835f, 0.08368345f, -0.04238443f, -0.15074025f, -0.05504309f, -0.07006349f, -0.10016669f, -0.15486360f, 
    0.06410110f, 0.01255555f, 0.02086400f, 0.08457183f, 0.01336884f, 0.18026091f, 0.18845737f, 0.00604728f, 
    0.33228758f, -0.09119651f, 0.01912512f, 0.02141315f, 0.14853093f, 0.00317157f, -0.11878221f, -0.11480360f, 
    -0.07894988f, 0.01363119f, 0.03495723f, -0.02317960f, -0.06591465f, 0.13543326f, -0.06138628f, -0.01458427f, 
    -0.06111944f, -0.00286488f, -0.08713800f, 0.11443567f, 0.02422403f, 0.07012890f, -0.05635918f, -0.04211536f, 
    0.07250313f, 0.06815510f, -0.08212373f, 0.01289083f, -0.00462568f, 0.02611044f, 0.16203885f, -0.16914682f, 
    0.07848258f, 0.00207179f, 0.17177255f, 0.03434822f, -0.00203280f, -0.00804886f, -0.03101852f, -0.08006318f, 
    0.09866475f, -0.04658591f, -0.02294336f, 0.10805227f, -0.02032390f, 0.04554225f, -0.04063653f, 0.06148862f, 
    0.07661774f, -0.10000471f, -0.01744493f, -0.13152213f, -0.04736247f, -0.02005797f, -0.02638918f, 0.04880006f, 
    0.15191296f, -0.11369800f, -0.04632519f, 0.01289257f, -0.02189662f, -0.00774904f, 0.09494546f, 0.00379292f, 
    -0.10133701f, 0.01585725f, 0.05580506f, 0.02975900f, -0.00008141f, -0.11717745f, 0.03540098f, 0.22273490f, 
    0.29774663f, 0.01065481f, 0.12510608f, 0.03611453f, 0.13264892f, 0.04039168f, 0.15308689f, -0.02093003f, 
    0.11149924f, -0.04573568f, -0.02307370f, -0.00831882f, 0.33025521f, -0.06351439f, 0.04788159f, 0.07573679f, 
    -0.04646122f, -0.01973292f, -0.05050964f, -0.00041575f, 0.05004286f, -0.04162826f, 0.02977862f, -0.02015196f, 
    -0.15383513f, -0.01040857f, -0.09671783f, 0.03053985f, -0.13974969f, -0.07698533f, 0.05111266f, 0.02588079f, 
    -0.08015337f, 0.01740401f, -0.02278409f, 0.21567583f, -0.10700799f, -0.19780466f, -0.07679388f, -0.07645505f, 
    -0.01892642f, 0.06254561f, 0.00211957f, -0.03894959f, 0.05074358f, 0.11740409f, -0.02116719f, -0.04702240f, 
    0.26308766f, -0.13123885f, -0.00073870f, 0.17355385f, 0.12756802f, 0.05548525f, 0.01028221f, 0.04820437f, 
    0.01748041f, -0.09704016f, 0.04945118f, -0.12680230f, -0.13452074f, -0.14268138f, -0.10439301f, 0.28962147f, 
    0.14851071f, -0.00599651f, 0.07787995f, -0.05074691f, 0.09867501f, 0.08245926f, -0.01998970f, 0.10803375f, 
    0.03019190f, 0.02279039f, -0.27183375f, -0.28644377f, 0.04705791f, -0.12695928f, -0.11017130f, 0.07864966f, 
    -0.01147640f, -0.03364808f, -0.06420916f, -0.11192073f, -0.08931411f, -0.09082506f, -0.02135410f, -0.06681671f, 
    0.06721089f, -0.03452415f, 0.02410784f, 0.02909258f, 0.05598995f, 0.01834179f, -0.20163120f, -0.06609879f, 
    -0.05724974f, -0.23038423f, -0.16457866f, -0.15897964f, -0.08341794f, 0.16003571f, -0.02701212f, -0.01260872f, 
    0.07826407f, 0.01227356f, 0.00345905f, 0.12125619f, 0.04190222f, -0.21582918f, 0.12375455f, 0.36291349f, 
    0.07613320f, 0.03445574f, 0.05505193f, 0.11606696f, 0.03530405f, 0.12361154f, -0.04475951f, -0.00010075f, 
    -0.00610570f, 0.21957439f, 0.03042740f, 0.02659284f, 0.04781189f, -0.00796217f, -0.04637522f, 0.10167140f, 
    0.04421720f, 0.11111955f, 0.09028210f, -0.00988301f, 0.03327217f, 0.31767911f, 0.14036210f, 0.24603486f, 
    0.00019673f, -0.22704260f, 0.08394544f, 0.09744513f, -0.04826129f, -0.02469239f, 0.04325482f, 0.07290353f, 
    0.35851729f, 0.08883988f, 0.00458870f, 0.18254296f, 0.05036637f, 0.07360936f, 0.07397071f, -0.06125987f, 
    0.02724752f, 0.00306831f, -0.17184103f, 0.03193074f, -0.17596893f, 0.25347215f, -0.14894873f, 0.24392156f, 
    -0.06027336f, 0.04868150f, 0.01738458f, 0.04773137f, 0.01778082f, -0.09892432f, -0.07483547f, 0.00766054f, 
    -0.10219730f, -0.12281431f, -0.07601217f, 0.09992982f, 0.25121468f, 0.16032757f, 0.04742136f, -0.02703963f, 
    -0.01503332f, 0.04871015f, -0.00254441f, -0.03665777f, 0.06097456f, -0.00607255f, -0.09658220f, 0.02834880f, 
    -0.01386365f, 0.09608818f, 0.01247782f, -0.00203825f, -0.05544203f, 0.00143341f, -0.03468043f, -0.09833159f, 
    0.02476617f, 0.19648181f, 0.07791156f, 0.16148603f, -0.11944261f, 0.01058627f, 0.00346387f, 0.08576392f, 
    -0.04875044f, -0.06236943f, -0.05350190f, 0.01029485f, 0.21595427f, 0.19189386f, 0.09669285f, 0.22462097f, 
    -0.18262735f, -0.07903060f, -0.02624591f, 0.03038713f, -0.11144662f, -0.02199319f, -0.02615334f, -0.06842092f, 
    0.06352995f, 0.29650250f, 0.00276183f, 0.15272705f, 0.04395175f, -0.00736964f, -0.00255051f, 0.11118753f, 
    -0.07078689f, 0.11022474f, 0.06684913f, -0.01273272f, 0.06826565f, 0.05263076f, -0.13380052f, 0.16688450f, 
    -0.00341286f, 0.14692932f, -0.06328456f, -0.12793863f, 0.06570683f, -0.00746977f, 0.01231359f, -0.01632100f, 
    -0.12217513f, 0.11780421f, 0.09740674f, -0.13454121f, -0.03752605f, -0.03195620f, -0.05836554f, -0.03306504f, 
    -0.00874939f, 0.04622494f, 0.06412244f, -0.06022693f, -0.02572593f, 0.30101323f, 0.01355870f, -0.04572994f, 
    0.04313875f, -0.10252040f, 0.01263798f, 0.06585181f, -0.11386349f, -0.08006153f, 0.05937240f, -0.02589045f, 
    -0.42197090f, 0.18891959f, -0.10059368f, 0.06372392f, 0.07622377f, 0.09746744f, -0.04479604f, -0.04527853f, 
    0.03067699f, -0.00023701f, 0.00404464f, -0.03928827f, 0.01886853f, 0.10602520f, 0.11623242f, -0.09033815f, 
    0.01630981f, 0.06227558f, 0.01942969f, 0.02816953f, -0.03634146f, -0.13281603f, -0.01757349f, -0.00995791f, 
    0.03658958f, -0.10018959f, 0.02943418f, 0.15643826f, -0.04460454f, -0.00677898f, 0.01431851f, -0.00420606f, 
    -0.02497502f, 0.04760620f, -0.00299408f, 0.14663061f, -0.24330938f, 0.05020355f, 0.04293840f, 0.02592811f, 
    -0.03228595f, 0.00840176f, 0.10555769f, -0.06486614f, 0.02597570f, 0.11425302f, -0.02220155f, -0.02354631f, 
    -0.40153614f, -0.00923055f, -0.00342627f, -0.09198496f, -0.03366166f, 0.04305618f, 0.04233607f, 0.04162836f, 
    -0.05787208f, 0.10921439f, 0.00101616f, 0.03069764f, 0.13075547f, -0.04393881f, 0.09239455f, 0.02894262f, 
    0.01334897f, -0.09590286f, -0.06610020f, -0.08258612f, 0.18462360f, -0.07092524f, 0.07992359f, -0.09057468f, 
    -0.16391580f, -0.00739673f, 0.04745378f, -0.05812939f, 0.06104802f, 0.03375661f, 0.02483119f, -0.04122478f, 
    0.02922237f, -0.03843326f, -0.03213060f, -0.05182663f, 0.19863567f, 0.04963170f, -0.04657743f, -0.00780318f, 
    0.01564473f, 0.02604998f, -0.02807735f, -0.14104448f, 0.08526888f, 0.02913062f, 0.12872106f, 0.00166400f, 
    0.01883195f, 0.01237290f, 0.06928579f, -0.00552769f, -0.01226692f, 0.04675822f, -0.04310651f, -0.11448829f, 
    -0.01563826f, -0.02060464f, 0.02998679f, 0.05286830f, 0.12928325f, -0.12803967f, 0.05495143f, 0.19216372f, 
    -0.08831038f, 0.00538274f, 0.00194819f, 0.10167942f, -0.00269158f, 0.01794359f, 0.01251729f, 0.01423075f, 
    -0.02908509f, 0.00786136f, -0.04939728f, 0.00583548f, 0.09833147f, -0.04599238f, 0.03541926f, -0.02192398f, 
    0.00517870f, -0.04533193f, 0.02709296f, 0.06476942f, 0.11832472f, 0.02528295f, -0.08605794f, -0.04291507f, 
    0.02446191f, -0.09197894f, 0.16344783f, 0.00113995f, -0.10369083f, 0.08519765f, 0.10584655f, -0.08120086f, 
    0.13396691f, -0.05559051f, 0.09963992f, -0.00737006f, 0.03240434f, 0.03488528f, 0.05298075f, 0.05549975f, 
    0.00723580f, -0.13206470f, -0.00715696f, 0.00337964f, 0.19095919f, 0.20429364f, -0.05492577f, -0.11148267f, 
    0.10943992f, -0.05992455f, -0.00616332f, 0.04227059f, -0.08801168f, 0.01555571f, -0.01080229f, -0.04771898f, 
    0.06552114f, -0.11202397f, -0.01265250f, -0.09458828f, 0.15124856f, -0.02870777f, -0.05655240f, -0.05931099f, 
    0.00278237f, 0.06514999f, 0.01232130f, 0.06211260f, -0.21898624f, -0.08204969f, 0.00872528f, 0.04124630f, 
    0.12606727f, 0.12346791f, 0.07190993f, -0.11113155f, -0.05355496f, 0.01239384f, 0.12052276f, -0.02677397f, 
    -0.03831764f, -0.07318033f, -0.14864245f, 0.10550176f, 0.03914200f, -0.03533255f, 0.16972229f, 0.02374976f, 
    0.01145493f, 0.07843253f, -0.00394134f, -0.00273246f, -0.14638461f, 0.02266683f, -0.03122398f, -0.12242839f, 
    -0.02397752f, 0.02966769f, 0.05924636f, 0.03549270f, 0.07009818f, 0.05751034f, 0.08621065f, 0.01988334f, 
    0.03298792f, 0.06657162f, -0.02802958f, 0.00977932f, 0.12445053f, -0.04900809f, -0.01951290f, -0.04391478f, 
    -0.03503971f, -0.05048390f, -0.01287231f, -0.04102606f, -0.24867450f, -0.09872422f, -0.10358794f, 0.11473609f, 
    0.12809654f, 0.10295016f, -0.02201868f, -0.08812694f, 0.01850940f, 0.12561828f, 0.00524545f, 0.02558830f, 
    0.01653044f, 0.03533528f, 0.02869743f, -0.00109352f, -0.03430247f, -0.02540022f, -0.04752031f, -0.05679926f, 
    0.03761313f, -0.05532020f, -0.04242539f, -0.04757050f, 0.00111446f, 0.00430986f, -0.02339454f, 0.04456493f, 
    0.03758073f, -0.02149952f, -0.02834665f, -0.05369890f, -0.02406730f, -0.04844891f, 0.03440055f, 0.00218123f, 
    0.03046697f, -0.01819074f, -0.01653672f, 0.03662089f, -0.04295544f, -0.02273647f, -0.01386306f, -0.02751066f, 
    0.00534094f, -0.01222611f, -0.04936256f, 0.00126335f, -0.01939060f, -0.03390221f, 0.01497901f, -0.03921492f, 
    -0.03767443f, -0.03131808f, -0.03683392f, -0.01895335f, 0.03746701f, -0.01694759f, -0.00473657f, -0.01280096f, 
    0.02700423f, -0.03638796f, -0.03989274f, -0.03256372f, 0.01468282f, -0.04349567f, 0.00598356f, -0.03534279f, 
    -0.04561933f, -0.00425195f, 0.00593077f, -0.05512546f, -0.01684963f, 0.00694249f, 0.03302381f, -0.01707742f, 
    -0.01116186f, -0.00400034f, 0.00630953f, -0.01303068f, -0.02338044f, 0.01098788f, -0.05139842f, -0.03389284f, 
    0.01470567f, 0.03474946f, -0.01837806f, 0.02666923f, -0.03191355f, -0.03440677f, -0.03065119f, 0.03091859f, 
    -0.04961796f, -0.03217934f, 0.02199445f, -0.00423386f, -0.01035967f, 0.00734814f, 0.02137958f, 0.04093938f, 
    0.03822370f, -0.02128909f, -0.05320704f, 0.00180800f, -0.02836574f, 0.04540590f, -0.03312905f, -0.01006994f, 
    -0.05661353f, -0.04397887f, -0.00848090f, -0.00698064f, 0.00422517f, -0.04925795f, 0.03602419f, 0.02238154f, 
    -0.00621558f, 0.02145998f, -0.02721696f, 0.00350818f, -0.02825562f, -0.00946772f, 0.00153580f, -0.02160903f, 
    -0.00856213f, 0.04358945f, 0.02213100f, -0.02728863f, 0.01698741f, 0.02974372f, -0.01386086f, 0.04310108f, 
    -0.00356890f, 0.02533028f, -0.03860459f, 0.00727454f, 0.02358172f, -0.04065606f, -0.00334790f, -0.02501328f, 
    -0.01293870f, -0.03261371f, -0.00161666f, -0.04417362f, -0.05614882f, 0.01529928f, 0.01500327f, -0.04372938f, 
    -0.00211846f, -0.01864906f, 0.03431294f, -0.05206940f, -0.04671737f, -0.02843848f, -0.01177636f, 0.00829067f, 
    0.03185841f, -0.02627095f, 0.01907511f, -0.00321011f, 0.00097335f, 0.02488200f, -0.04348576f, 0.02261974f, 
    0.02875088f, -0.01277631f, -0.04013127f, 0.02323538f, -0.00013904f, -0.05499180f, -0.03671252f, -0.00995032f, 
    0.01545761f, 0.01834952f, 0.01234386f, 0.02658697f, -0.01939848f, 0.04581860f, 0.04034124f, 0.03077710f, 
    0.01165498f, -0.03255337f, -0.04722654f, 0.03731442f, -0.02343727f, -0.05450602f, 0.03822960f, -0.01073621f, 
    0.05130105f, -0.04184867f, -0.02832145f, -0.05566769f, -0.01153185f, -0.03907194f, -0.00166752f, 0.02396804f, 
    0.00276201f, -0.01002218f, 0.02009678f, 0.00582734f, 0.00176903f, -0.00808083f, -0.01067815f, -0.03868178f, 
    0.03934072f, 0.01810716f, 0.04218546f, -0.04759667f, 0.02423140f, -0.01101120f, -0.00470115f, -0.01516191f, 
    0.03206186f, 0.04268890f, -0.04986842f, -0.04513019f, -0.01085121f, -0.02961050f, -0.05084824f, 0.01180679f, 
    0.00619598f, 0.01570130f, -0.02157207f, -0.03013268f, 0.03934947f, -0.00619955f, -0.02413275f, 0.00744067f, 
    -0.02355718f, 0.04311889f, -0.00242723f, -0.04801742f, -0.04661183f, 0.02342991f, 0.04406501f, 0.02163069f, 
    0.00371655f, 0.00403794f, -0.04114376f, 0.03206104f, -0.03191376f, 0.02418416f, 0.04483306f, 0.02230955f, 
    -0.01843326f, -0.01313277f, 0.01381807f, 0.02484911f, -0.00287531f, -0.04047253f, -0.04183687f, -0.05232046f, 
    -0.00780497f, 0.01854117f, 0.00513978f, 0.00367198f, -0.01164292f, 0.03140317f, 0.01528906f, 0.04220095f, 
    -0.03053380f, 0.02880808f, -0.03415347f, -0.01996192f, 0.02644645f, -0.02480705f, 0.01102487f, -0.03710859f, 
    -0.00435708f, 0.04308420f, -0.01229867f, 0.03305463f, -0.03585934f, -0.03080411f, -0.00578870f, 0.04354975f, 
    0.01145975f, -0.01979476f, -0.00219630f, -0.02693865f, 0.03482744f, 0.01487059f, -0.01119549f, -0.01430464f, 
    -0.00449429f, -0.02591934f, -0.01023510f, -0.01096899f, 0.02765230f, -0.02822625f, -0.00933651f, -0.01522455f, 
    -0.03468145f, 0.01792230f, -0.00527255f, -0.00529000f, -0.00407642f, -0.04820240f, 0.01299871f, -0.01869127f, 
    -0.00637887f, -0.01100682f, -0.00688567f, -0.04081289f, 0.04258351f, 0.00787443f, -0.00538159f, -0.05219852f, 
    -0.01239443f, 0.00388194f, 0.03110732f, -0.03121881f, -0.00572845f, -0.01489433f, -0.02914540f, -0.02392902f, 
    -0.02793738f, -0.02353609f, 0.04306904f, -0.02347086f, -0.02395896f, -0.02782464f, 0.01448499f, -0.04268285f, 
    -0.02905369f, 0.01165193f, 0.02691405f, -0.03402233f, -0.02976760f, 0.03281808f, -0.01333580f, -0.04108145f, 
    0.03548191f, 0.00430987f, -0.04784685f, -0.00648111f, -0.05004358f, -0.02210505f, -0.02443714f, 0.03379097f, 
    -0.00457686f, -0.03169096f, 0.02644072f, 0.01705874f, -0.05230720f, -0.00935724f, -0.04127161f, -0.05517350f, 
    0.03112842f, -0.00310379f, 0.03275813f, -0.04291323f, -0.01592873f, 0.04829322f, 0.03509585f, 0.00822582f, 
    0.00818360f, -0.04043360f, 0.00425174f, 0.03673954f, 0.01945414f, -0.03567360f, 0.00305773f, -0.00362784f, 
    -0.00078601f, 0.00260550f, 0.03001385f, -0.04543496f, -0.04139835f, -0.03793196f, 0.04073080f, -0.02615820f, 
    -0.05449952f, 0.01413020f, 0.00136327f, -0.04661499f, 0.04551958f, -0.01704502f, 0.03760868f, -0.04836728f, 
    -0.00858508f, 0.04216248f, -0.01923500f, 0.00181083f, 0.02877852f, -0.02244684f, -0.01995785f, -0.01453185f, 
    0.02556474f, 0.03629312f, 0.04716526f, 0.00673820f, -0.03827804f, -0.01901224f, 0.02374246f, -0.03336723f, 
    0.21735264f, 0.08428633f, -0.02037134f, 0.14310947f, -0.05317135f, -0.01827083f, 0.10604715f, 0.07244601f, 
    0.02624155f, -0.14768137f, 0.02415958f, -0.02264537f, -0.13854648f, 0.06213783f, -0.11231326f, -0.01771339f, 
    -0.14391802f, 0.07413249f, 0.00729710f, -0.04783567f, 0.00405720f, -0.00230091f, 0.09028871f, -0.06739169f, 
    -0.19950882f, 0.06147551f, 0.06764774f, -0.07138908f, 0.01026240f, 0.01939505f, -0.03097721f, 0.09706231f, 
    0.04249305f, 0.00827312f, 0.01120140f, 0.06695942f, -0.19463284f, -0.16320308f, 0.00244152f, -0.14141859f, 
    -0.09488776f, -0.07763899f, 0.09953058f, 0.02738290f, 0.09137248f, 0.10093883f, -0.03290437f, 0.01433660f, 
    0.06431967f, -0.09257744f, -0.05185696f, -0.03440368f, 0.08578531f, 0.07309254f, 0.05083306f, -0.08012101f, 
    0.07557017f, -0.03414494f, 0.11161948f, 0.14409170f, -0.17337465f, 0.15247768f, 0.04655726f, 0.14165781f, 
    -0.04176639f, -0.01815693f, -0.04860542f, -0.04887353f, 0.07504135f, 0.01690475f, 0.03139334f, 0.16875552f, 
    0.12889095f, -0.05252631f, -0.20305678f, 0.06618720f, -0.04028693f, 0.07750719f, 0.03411767f, -0.09341848f, 
    -0.04638970f, 0.03825308f, 0.04350993f, -0.05726148f, 0.01639748f, 0.01764663f, -0.18480201f, -0.06633087f, 
    -0.03920102f, -0.05303725f, -0.09396964f, 0.01852462f, 0.03155678f, -0.03089440f, 0.06479126f, -0.07779568f, 
    -0.11938628f, -0.11129380f, -0.05238474f, -0.09942093f, -0.16431543f, 0.06472363f, -0.05595359f, -0.03055538f, 
    -0.00612226f, -0.05252666f, -0.05226256f, -0.03897693f, 0.10999154f, 0.06971787f, -0.00282002f, -0.13265403f, 
    0.13299845f, -0.07819373f, 0.16780074f, 0.11502997f, 0.05411058f, 0.12098064f, -0.10100315f, 0.16997007f, 
    -0.18047699f, -0.12441044f, 0.20103191f, -0.26570314f, -0.04363470f, 0.00592724f, 0.03779639f, -0.09295960f, 
    -0.08971989f, 0.01099976f, -0.05457723f, -0.05477704f, 0.12027057f, 0.06444217f, -0.29717046f, 0.15951861f, 
    0.06242485f, 0.04394089f, 0.00284046f, -0.05293123f, 0.16542390f, 0.08585852f, 0.05177237f, 0.02570547f, 
    -0.30617964f, -0.13634787f, 0.12680861f, 0.11815861f, -0.01878508f, -0.03126935f, 0.00246818f, -0.07866098f, 
    0.08317655f, 0.00139812f, 0.06386770f, 0.10939418f, -0.23173039f, 0.03289379f, -0.21997197f, 0.08258706f, 
    -0.00842427f, -0.03930072f, -0.06312852f, 0.16773356f, -0.00597120f, 0.03243247f, 0.01653153f, 0.02579400f, 
    -0.03261513f, 0.10029683f, -0.05493823f, -0.20251781f, -0.12822573f, 0.01536751f, -0.06403507f, 0.15123755f, 
    0.03661107f, 0.10175188f, -0.04378910f, -0.17713659f, 0.16601378f, -0.00967699f, 0.00796551f, 0.22842546f, 
    0.07488277f, -0.04784821f, -0.04171110f, 0.11168820f, 0.04363896f, 0.08638843f, 0.08894646f, 0.13275559f, 
    -0.19703619f, 0.09298885f, 0.01968613f, 0.16555364f, -0.05047698f, -0.03690093f, 0.09394868f, -0.07380343f, 
    -0.02412820f, 0.10816552f, 0.00868905f, 0.05212453f, 0.06856402f, -0.19361474f, 0.07811233f, 0.04027704f, 
    -0.05114227f, -0.03087064f, -0.02923076f, 0.08701821f, 0.08706947f, 0.01473962f, -0.02120992f, -0.05559804f, 
    -0.05641377f, 0.00619397f, 0.00655907f, 0.24208055f, 0.08635403f, -0.10837754f, 0.03925522f, 0.05622669f, 
    -0.01896966f, 0.12232779f, 0.06511309f, 0.01721467f, 0.13719423f, 0.21033284f, -0.01472946f, -0.08387972f, 
    -0.03136413f, -0.00422143f, -0.05611315f, -0.07219078f, 0.05867743f, 0.02303045f, 0.15604477f, 0.12155686f, 
    0.08601696f, 0.28707278f, -0.07498994f, 0.01179890f, 0.15367033f, -0.01511816f, 0.13584331f, -0.01265697f, 
    0.04292778f, 0.02276486f, -0.02009428f, 0.09163352f, -0.07829471f, -0.20417079f, 0.06942295f, -0.12028220f, 
    -0.01266669f, -0.00037882f, -0.00245069f, -0.13684925f, 0.05326145f, -0.06328621f, -0.07463478f, 0.05737426f, 
    -0.19621143f, -0.20643243f, 0.01796640f, -0.01339390f, 0.02156332f, 0.00428356f, 0.04129432f, -0.04390877f, 
    0.06278446f, -0.04318409f, 0.07266442f, 0.13866103f, 0.04117792f, -0.23160933f, -0.09464009f, 0.03465144f, 
    0.11317028f, 0.08067154f, 0.05028146f, -0.12965459f, 0.11674827f, -0.05454485f, -0.05737078f, 0.06493987f, 
    -0.24296553f, 0.01522730f, 0.11767871f, 0.07310458f, 0.09184313f, -0.12739806f, 0.03976135f, 0.00755708f, 
    0.00864959f, -0.03594681f, 0.07683195f, 0.04216807f, 0.23975988f, -0.16627145f, 0.04499103f, 0.04412735f, 
    -0.00518079f, -0.01124877f, -0.08167482f, 0.08730869f, 0.06205140f, 0.09981693f, 0.00035800f, -0.05832824f, 
    -0.07025320f, -0.07194061f, -0.08987101f, -0.24300173f, 0.07035740f, -0.12822659f, 0.00746748f, -0.01031577f, 
    0.12507246f, -0.08056822f, 0.05163009f, 0.00932933f, -0.12985548f, -0.00511799f, 0.14313240f, 0.01422691f, 
    0.03353943f, 0.16296646f, 0.08907647f, 0.05836274f, -0.07779340f, 0.02706872f, 0.14322089f, 0.06589457f, 
    -0.09695521f, -0.10308283f, 0.07327183f, 0.12021209f, 0.07664909f, 0.11212663f, 0.01466887f, 0.04722829f, 
    -0.00014675f, 0.03233329f, -0.02375850f, -0.00681770f, -0.06754364f, -0.09887547f, 0.21667692f, -0.03264791f, 
    0.14979744f, 0.06869704f, 0.00938669f, 0.04133395f, 0.16796841f, -0.04379562f, -0.04477479f, -0.08196082f, 
    0.04474599f, 0.31048429f, 0.20545425f, 0.02379399f, -0.00902594f, 0.11077755f, 0.09377799f, 0.10699004f, 
    0.05551241f, -0.14332131f, -0.00203427f, 0.09843016f, 0.05972883f, -0.09336916f, -0.04713367f, -0.01460482f, 
    0.10716771f, 0.00611095f, -0.00582934f, 0.01949817f, 0.16998129f, 0.09356112f, 0.00614087f, 0.09018587f, 
    0.13917194f, 0.14452639f, 0.03225548f, 0.12805797f, 0.06224905f, 0.01892765f, 0.06434204f, 0.09291543f, 
    0.08445469f, 0.04207323f, 0.03583379f, 0.11506779f, -0.12178032f, 0.02984352f, -0.02246458f, 0.09803738f, 
    -0.05829415f, 0.18754072f, 0.05789063f, -0.03611345f, -0.00041532f, 0.11273161f, 0.07794651f, 0.01860134f, 
    0.34795988f, -0.29473317f, 0.09300174f, 0.09038882f, -0.05934926f, -0.08928461f, 0.08826000f, 0.12149430f, 
    0.17761983f, 0.02101147f, 0.04347280f, 0.03997733f, -0.12367517f, 0.26760921f, -0.09419090f, 0.13562238f, 
    -0.04089528f, -0.01887526f, -0.05837443f, 0.02951259f, 0.00656075f, -0.04327539f, 0.09212242f, -0.02197857f, 
    -0.17690930f, 0.29223794f, 0.02035367f, -0.32778168f, 0.00858614f, 0.02744133f, 0.09403740f, 0.04470324f, 
    0.07660118f, 0.00266713f, 0.05158892f, 0.00685530f, 0.16392778f, -0.21105388f, 0.16244800f, 0.29924792f, 
    -0.08777156f, -0.04046637f, 0.04194866f, -0.02684383f, 0.03931227f, -0.03547883f, 0.21198794f, 0.00349744f, 
    -0.19712125f, 0.19651091f, -0.13939853f, 0.11373182f, 0.03921731f, 0.13884188f, 0.06606230f, -0.12573099f, 
    0.17001517f, -0.01566415f, -0.00495557f, 0.10016353f, -0.43754694f, -0.12785262f, -0.03254235f, -0.00326936f, 
    -0.03710933f, 0.08681610f, -0.03051370f, -0.05290787f, 0.00705816f, 0.06965037f, 0.00664438f, 0.01085722f, 
    0.26126745f, -0.02157715f, 0.01557831f, 0.00689029f, -0.01165984f, 0.00114953f, 0.02100601f, -0.04242068f, 
    0.04701933f, -0.06872506f, -0.02067152f, 0.15583819f, -0.07501604f, -0.10855191f, 0.19692224f, -0.00628428f, 
    0.07206354f, -0.04063758f, 0.04836086f, 0.00566449f, 0.12545221f, 0.09307898f, 0.04019927f, 0.03877861f, 
    0.06010826f, -0.08318479f, 0.04843851f, -0.09706023f, -0.00976651f, -0.03438329f, 0.07012730f, -0.11706945f, 
    0.07271171f, -0.08815777f, -0.03879375f, 0.01904987f, -0.11856087f, 0.29070973f, 0.07503827f, 0.10453633f, 
    0.00852245f, 0.14371981f, -0.10475451f, -0.08924540f, 0.04699995f, -0.06159038f, -0.02607456f, 0.01071860f, 
    0.29628488f, 0.10058466f, -0.02481368f, -0.11872155f, -0.02973796f, 0.02365247f, 0.04258723f, -0.00116314f, 
    -0.03584281f, 0.01100702f, -0.05177056f, 0.06468441f, 0.31082100f, -0.07410081f, 0.02994222f, 0.20641200f, 
    0.18026809f, 0.07646017f, -0.01463583f, 0.05534443f, 0.00255183f, -0.10661914f, 0.04413774f, 0.06395600f, 
    -0.10747192f, -0.08619937f, 0.05238919f, -0.14964135f, -0.04992730f, 0.04021048f, 0.13198379f, -0.05920784f, 
    -0.11624043f, -0.06385335f, 0.08224880f, 0.02925820f, 0.03716099f, -0.02649506f, 0.03566578f, 0.20613539f, 
    -0.04870022f, -0.04314964f, -0.00601411f, 0.03056995f, 0.04390089f, -0.09872736f, -0.16463156f, 0.10276100f, 
    -0.20737040f, 0.15308477f, -0.06193116f, 0.10321579f, -0.09982451f, 0.08109004f, 0.00915098f, -0.00770911f, 
    0.08608631f, -0.00837969f, -0.04847972f, 0.10059813f, 0.20421213f, -0.10384683f, 0.10595550f, -0.05836553f, 
    0.05791774f, -0.05841352f, 0.11140351f, -0.08522469f, 0.08481327f, -0.03013657f, 0.08622373f, 0.09190389f, 
    -0.12373523f, -0.10041574f, -0.06708400f, 0.04983478f, 0.06429665f, 0.08846176f, -0.05846026f, 0.09599201f, 
    -0.19959740f, -0.03514444f, -0.12864771f, 0.07966459f, -0.21385224f, 0.01373532f, 0.04159753f, 0.05634093f, 
    -0.15871786f, 0.09963982f, 0.02704388f, -0.01853151f, 0.13675591f, -0.04232349f, 0.10475063f, 0.09755486f, 
    -0.01593367f, -0.03154213f, 0.12842639f, 0.03097231f, 0.02615167f, -0.02593298f, -0.02727604f, 0.01157669f, 
    0.05167197f, 0.05481718f, -0.01614890f, -0.03090377f, -0.20461923f, -0.04109920f, -0.05679679f, 0.07051829f, 
    0.07567414f, -0.00543672f, 0.07721224f, 0.00738634f, -0.03597615f, 0.01212315f, -0.00697714f, -0.05539946f, 
    -0.17929579f, 0.16302213f, -0.11980178f, 0.07643773f, -0.03605226f, -0.04558389f, -0.08251313f, 0.06171998f, 
    0.11754172f, 0.11165350f, 0.02365853f, -0.01975202f, -0.40544146f, 0.37551314f, -0.11186132f, 0.11772947f, 
    0.08107519f, 0.18152401f, 0.03940986f, -0.09339477f, 0.01171177f, -0.06154431f, 0.03430937f, 0.01950674f, 
    -0.03155200f, 0.03542551f, -0.05153146f, -0.06237947f, 0.15683037f, -0.07842369f, 0.11290041f, 0.08969477f, 
    0.07404038f, -0.03268712f, -0.00111473f, -0.02085254f, -0.04588101f, 0.01272098f, 0.09426162f, -0.16183685f, 
    -0.01455310f, -0.06077787f, -0.07895653f, 0.04788981f, 0.04320015f, -0.04751508f, 0.03160775f, -0.00041898f, 
    -0.13827118f, 0.15683499f, 0.14280722f, -0.08307681f, 0.07934860f, -0.05570698f, 0.05947180f, -0.06379075f, 
    0.03230371f, 0.00779960f, -0.07609326f, -0.00185814f, -0.05253573f, 0.06803507f, 0.05227901f, -0.28264186f, 
    -0.05164687f, 0.15250914f, -0.06535464f, 0.00818808f, -0.07931236f, 0.01386492f, 0.11898512f, -0.07291968f, 
    -0.09864829f, 0.20987743f, -0.01171445f, 0.26194194f, 0.12703028f, 0.10388216f, -0.08797284f, -0.00737474f, 
    0.07631750f, 0.05404217f, 0.07314306f, 0.04474939f, -0.16497657f, 0.13507430f, -0.15621506f, 0.06804202f, 
    -0.06322017f, 0.01677664f, -0.07561152f, 0.06072795f, 0.01404916f, -0.06276098f, 0.16963622f, 0.19071177f, 
    0.08752503f, 0.01825426f, 0.40361837f, 0.00182160f, 0.13349195f, -0.12321601f, 0.00362006f, -0.01340555f, 
    0.01623986f, 0.04772931f, 0.02789540f, 0.01106892f, -0.36842453f, 0.17492880f, 0.17587242f, -0.35207433f, 
    0.04840964f, -0.00048168f, -0.10813462f, 0.02580651f, -0.01776323f, 0.00485460f, -0.00447533f, -0.03188760f, 
    -0.02903112f, 0.03474676f, -0.02788566f, 0.01266227f, -0.00572951f, -0.02263435f, 0.02553070f, -0.02249891f, 
    0.00433478f, -0.02584119f, -0.00486748f, -0.01861695f, -0.05173611f, 0.02661956f, 0.01506405f, 0.00606799f, 
    -0.01752564f, -0.01300853f, 0.01804016f, -0.02623867f, 0.01807736f, 0.01591607f, -0.00149102f, 0.02530221f, 
    -0.04809693f, -0.04349268f, 0.02847056f, 0.01393392f, 0.02101103f, -0.00431061f, 0.03687459f, 0.00987631f, 
    0.00829572f, -0.02670571f, 0.01001013f, -0.04381544f, -0.02144382f, -0.02391776f, 0.04486918f, 0.01506924f, 
    0.00006763f, -0.05007129f, 0.03818171f, -0.00765046f, -0.00602998f, 0.01161125f, 0.04126328f, 0.04292298f, 
    0.02127400f, 0.03695843f, -0.01039287f, -0.04657781f, -0.00921754f, -0.02869999f, -0.01865915f, -0.04546757f, 
    -0.04029454f, -0.04274371f, -0.04625693f, -0.00541472f, -0.05239471f, -0.00006837f, 0.03909454f, -0.01516032f, 
    -0.00029238f, -0.05006740f, -0.01928588f, 0.00852127f, -0.05513981f, -0.05106932f, -0.03942382f, -0.01641535f, 
    -0.01911020f, 0.00530841f, -0.04850745f, 0.01717695f, -0.03177635f, -0.01411991f, -0.03364832f, 0.01069287f, 
    0.01610287f, -0.02067057f, 0.03611226f, -0.05285640f, -0.02833067f, -0.04149969f, -0.02368712f, -0.03909376f, 
    0.02597478f, -0.03576373f, 0.01496349f, 0.03055438f, 0.01434209f, -0.02730133f, 0.04980873f, -0.02218316f, 
    0.00143350f, -0.05551190f, -0.01691907f, 0.01162698f, -0.03514118f, -0.02980543f, -0.03056237f, -0.02685730f, 
    -0.01141453f, -0.01325062f, -0.01873795f, 0.00303523f, 0.02271034f, -0.03556594f, -0.01778714f, 0.03268080f, 
    0.02706860f, -0.03165822f, -0.05115286f, 0.01966120f, 0.04217023f, -0.04999815f, -0.04779543f, -0.03855399f, 
    -0.01748219f, 0.00023568f, -0.02239646f, 0.03280786f, -0.04122924f, -0.03636163f, 0.04416891f, 0.03593747f, 
    0.03228896f, -0.05555730f, -0.02121047f, 0.00872470f, 0.01846118f, -0.01780275f, 0.00413532f, -0.00082958f, 
    0.02104686f, -0.02713546f, -0.01933108f, 0.02036124f, -0.00651364f, 0.04365174f, -0.00853311f, -0.03471851f, 
    0.02653666f, 0.02720127f, 0.03432474f, -0.00763439f, -0.03709348f, -0.04983192f, -0.04028613f, 0.00798018f, 
    -0.03034225f, -0.00697603f, -0.01903388f, 0.01708808f, 0.01571292f, 0.02670531f, -0.05350002f, -0.05498179f, 
    -0.00591872f, -0.04914571f, 0.04271035f, -0.01379992f, -0.02355134f, -0.01862060f, 0.01642863f, 0.01392505f, 
    0.01916580f, 0.02442651f, -0.02724016f, -0.04873672f, -0.05421377f, -0.00049921f, 0.00740296f, -0.05586855f, 
    0.03547614f, 0.00513136f, -0.04378494f, -0.01434385f, 0.01456122f, -0.00601531f, -0.00634021f, -0.00030051f, 
    0.04121158f, 0.02563402f, 0.00233622f, 0.02226763f, 0.04709877f, 0.04310689f, -0.04087197f, -0.03944992f, 
    -0.05401122f, -0.02280253f, -0.04283928f, 0.03571400f, -0.00360761f, -0.01589759f, -0.02140047f, -0.04002149f, 
    -0.04563779f, -0.04301061f, 0.02623842f, -0.04248019f, 0.02050524f, 0.03060417f, 0.02003998f, -0.00899607f, 
    -0.02053928f, -0.05482535f, 0.03379367f, -0.05557240f, 0.02766786f, -0.03024236f, -0.02849233f, -0.05351669f, 
    0.02457165f, -0.03056471f, -0.01137889f, -0.05500075f, -0.00363951f, 0.03757346f, 0.05039821f, -0.02519128f, 
    0.01674561f, -0.02138482f, -0.04579896f, -0.04029841f, -0.02051998f, -0.00913203f, -0.00485877f, -0.04954164f, 
    -0.02471034f, 0.03966706f, -0.00605767f, -0.03366464f, 0.02032200f, -0.03106456f, 0.03536756f, 0.02551405f, 
    0.03568561f, -0.03920193f, -0.02416156f, 0.00801344f, 0.00593610f, -0.02676863f, -0.05436411f, -0.03964592f, 
    0.03116760f, -0.01581948f, 0.03208330f, -0.05437426f, -0.01455170f, 0.03786237f, -0.01005451f, -0.01661178f, 
    0.04632575f, -0.04644039f, 0.01773769f, 0.04059481f, -0.04429016f, 0.04423650f, -0.01127487f, -0.03549993f, 
    -0.00539904f, -0.00701229f, 0.01814544f, -0.03271298f, 0.04220107f, -0.01908801f, 0.02545288f, -0.04709481f, 
    -0.00604135f, 0.03851948f, -0.01060980f, -0.01362073f, -0.02318042f, 0.03459178f, -0.02416129f, -0.01288011f, 
    -0.01076681f, -0.04424576f, -0.05025653f, -0.01298248f, 0.01954341f, -0.01408602f, 0.03435514f, -0.02453623f, 
    -0.03364099f, 0.02469136f, 0.00153393f, -0.00889310f, -0.05506883f, 0.02453556f, 0.02250079f, -0.03338866f, 
    -0.01090484f, -0.01984674f, 0.03876523f, 0.00073979f, 0.01504115f, 0.01481385f, -0.05554960f, -0.03444872f, 
    0.03206828f, 0.04361137f, 0.03972656f, -0.04005945f, 0.02418920f, -0.05101009f, -0.03421627f, -0.02413931f, 
    -0.03486058f, -0.02871495f, -0.03136867f, -0.02857865f, -0.01114490f, 0.04169393f, -0.04944948f, 0.04353875f, 
    0.04120985f, 0.00414989f, 0.02493585f, -0.01377088f, -0.03530880f, 0.04444156f, 0.01877490f, 0.01627911f, 
    0.01315631f, -0.01348949f, -0.02176416f, -0.03495466f, 0.00203719f, -0.02359607f, -0.04945847f, 0.01680454f, 
    0.04240788f, 0.01587211f, -0.03237685f, -0.04896659f, -0.01795608f, -0.01878472f, 0.04435975f, -0.05290366f, 
    0.04451022f, 0.00245697f, -0.02138110f, 0.03231892f, -0.02318970f, 0.03420877f, 0.01100642f, -0.01518429f, 
    0.02694123f, 0.04759492f, -0.03839668f, -0.00243445f, -0.03445651f, 0.02911223f, -0.05293067f, -0.00566135f, 
    0.04525097f, -0.00831967f, -0.02797101f, -0.04298069f, 0.02628312f, -0.01826024f, -0.02343728f, -0.05070245f, 
    -0.04645279f, 0.03752359f, 0.04235152f, 0.04041108f, 0.02345232f, -0.03793418f, -0.01766403f, 0.03816466f, 
    0.03778666f, -0.01898201f, 0.01010750f, 0.01589986f, -0.04392174f, -0.05574834f, 0.00797802f, 0.03776672f, 
    -0.04275665f, -0.02547689f, 0.02431205f, 0.03176640f, 0.04634216f, 0.02233350f, 0.04224088f, 0.01518076f, 
    0.03924503f, -0.00046281f, 0.01695663f, 0.00218373f, 0.01034606f, -0.02140549f, 0.02486973f, -0.00555453f, 
    0.04326076f, -0.00568281f, -0.01790344f, -0.03078296f, 0.03019147f, 0.01177236f, 0.03674443f, -0.02003784f, 
    -0.04152798f, -0.02661825f, -0.02559173f, -0.03769379f, -0.03155649f, 0.03143010f, -0.00204012f, 0.01392839f, 
    0.02335649f, 0.02467423f, -0.04866826f, -0.02281809f, 0.01347008f, 0.03886732f, 0.00162772f, -0.03995838f, 
    -0.02217934f, -0.03644114f, 0.03892088f, 0.03661665f, 0.00007734f, -0.05142199f, -0.03748681f, 0.01092222f, 
    -0.02133232f, -0.00906856f, -0.04801338f, 0.04221223f, -0.01554764f, 0.05143511f, 0.01654455f, -0.00767703f, 
    -0.04453517f, -0.00846083f, -0.04190544f, -0.01738325f, -0.00368256f, 0.04004282f, -0.03345544f, -0.03522396f, 
    -0.03085727f, 0.00247479f, -0.02485173f, -0.03384272f, -0.02973604f, -0.02235562f, 0.03288409f, -0.04603209f, 
    0.03333558f, -0.00650676f, -0.00885097f, 0.03816917f, -0.06006729f, -0.00738247f, -0.03046962f, 0.02344932f, 
    -0.02645972f, -0.03309908f, 0.01858588f, -0.06259149f, -0.03634298f, 0.01252178f, -0.00162222f, 0.01710203f, 
    0.03989939f, -0.04452359f, -0.02167628f, 0.02446516f, 0.03865169f, -0.03778511f, 0.03536738f, -0.01648114f, 
    0.02065399f, -0.01158334f, -0.02625166f, -0.00084575f, 0.00238519f, 0.00761042f, -0.05277390f, 0.00281912f, 
    -0.04996137f, 0.03612667f, 0.00420246f, -0.00788073f, 0.03200018f, -0.01140844f, 0.04189383f, -0.00355231f, 
    -0.02694765f, 0.03848232f, 0.00047378f, -0.00973967f, 0.00809677f, 0.00093732f, -0.00070994f, 0.04053498f, 
    -0.04425286f, -0.03063961f, -0.01647892f, 0.02366966f, -0.05067137f, 0.03782159f, -0.01916983f, -0.05009510f, 
    -0.03795046f, 0.02346105f, 0.00810096f, -0.02681985f, 0.00957279f, 0.01213621f, 0.02994845f, -0.00528689f, 
    -0.05076406f, -0.01889399f, -0.04699427f, 0.00369887f, 0.01628518f, -0.00816458f, -0.01926760f, 0.01757578f, 
    0.01679205f, -0.02555736f, 0.03470569f, 0.03192409f, 0.03280552f, -0.04066109f, -0.02072844f, -0.02656810f, 
    0.00247267f, -0.00043003f, -0.02155843f, 0.02061603f, -0.04313222f, 0.03169854f, 0.03139654f, 0.00050814f, 
    -0.00035346f, 0.02239712f, -0.04132418f, -0.04466255f, 0.00363477f, 0.01003041f, -0.03176447f, 0.02045419f, 
    0.02113907f, -0.06448792f, -0.05931863f, -0.03790126f, -0.05659864f, -0.01714550f, -0.01464335f, -0.02958988f, 
    0.02553395f, 0.03973237f, 0.03249538f, -0.04664072f, 0.00934568f, 0.02336376f, -0.04340348f, -0.00619126f, 
    0.00238175f, 0.02939455f, 0.04086324f, -0.02094918f, 0.04031682f, -0.00281008f, 0.01031303f, 0.01007353f, 
    -0.02199657f, -0.01505029f, -0.02426164f, 0.03138134f, -0.05033262f, 0.03219256f, 0.02326418f, -0.00215091f, 
    0.00425874f, 0.02056354f, 0.03630226f, -0.05132702f, -0.04416338f, 0.00828469f, 0.04189469f, 0.01259322f, 
    0.02140270f, -0.00252095f, -0.02773744f, -0.01615092f, 0.02018006f, -0.01760686f, 0.03917665f, 0.04375523f, 
    0.00167609f, 0.03543023f, -0.04584873f, 0.00992181f, 0.02185742f, 0.01201240f, -0.04736366f, -0.03884260f, 
    0.01857615f, -0.02569106f, 0.00414513f, -0.03273721f, -0.03315457f, 0.00398008f, -0.05441557f, 0.00686918f, 
    -0.01736428f, -0.03063248f, -0.00000329f, 0.01550282f, 0.04461347f, 0.02284873f, -0.01216317f, -0.05473080f, 
    -0.05261791f, 0.03824417f, -0.00692859f, -0.01349613f, -0.01694579f, -0.03070995f, -0.04278432f, -0.01939582f, 
    -0.03014394f, 0.01111059f, -0.00815240f, 0.04590501f, 0.02422073f, 0.01836563f, 0.00062529f, -0.05604171f, 
    0.01965848f, -0.03713343f, -0.01878351f, -0.03764873f, -0.00745101f, -0.04605662f, -0.02464843f, 0.01672876f, 
    0.02256013f, -0.00044133f, 0.04753595f, -0.03486116f, 0.03812765f, 0.03414237f, -0.00444085f, -0.04324193f, 
    0.03308489f, -0.03320177f, -0.03143549f, 0.04098877f, 0.01484039f, -0.00447325f, -0.03602874f, -0.02809340f, 
    -0.00365114f, -0.05218701f, -0.03452179f, 0.03342930f, 0.03827283f, -0.01978743f, -0.04569837f, -0.01418861f, 
    -0.05276000f, -0.04668395f, -0.03505255f, -0.02779662f, -0.01788435f, 0.02796730f, -0.02534996f, -0.03989113f, 
    0.03762452f, -0.00301300f, 0.00654759f, 0.01924745f, -0.03200860f, 0.00731638f, 0.01013801f, 0.03244859f, 
    0.02703407f, -0.02963792f, 0.01131455f, -0.03605074f, 0.04309047f, -0.05265325f, -0.02763717f, -0.02681580f, 
    -0.03034363f, -0.02883517f, 0.01407707f, -0.01830874f, 0.00170335f, -0.05103477f, 0.01950394f, -0.04801968f, 
    0.00363503f, -0.01772778f, 0.02239441f, -0.02665533f, 0.02826330f, 0.03269514f, -0.04430194f, 0.03749339f, 
    0.03963451f, -0.03892018f, -0.02945371f, 0.00903423f, -0.01711510f, -0.03981401f, 0.01418793f, 0.01777700f, 
    -0.02411583f, -0.01495312f, 0.02161193f, -0.03086905f, 0.03247891f, 0.01452999f, 0.02417196f, 0.02520366f, 
    -0.03326675f, 0.00568653f, 0.05097999f, 0.00302062f, -0.03715716f, -0.02630189f, -0.00369766f, -0.03834856f, 
    0.01111265f, -0.01997095f, -0.01088001f, -0.02512104f, 0.03705417f, -0.01401415f, 0.01113310f, 0.04385497f, 
    -0.00741849f, -0.01704798f, 0.02764595f, -0.01823937f, -0.05475985f, -0.04968076f, -0.02693061f, -0.00037254f, 
    0.00321225f, 0.02905998f, 0.03122864f, -0.03717828f, -0.01150885f, 0.00084997f, 0.03435180f, 0.05797397f, 
    -0.02801722f, 0.00286512f, -0.02135064f, 0.00917517f, -0.02257920f, 0.00032327f, 0.02731345f, -0.02160889f, 
    -0.03069816f, -0.17134470f, -0.14574900f, -0.05590877f, -0.00010275f, 0.11955241f, 0.08981589f, -0.03192420f, 
    -0.02973057f, 0.01342600f, 0.05050705f, -0.01663399f, -0.19695547f, -0.15816589f, 0.03791356f, -0.05466714f, 
    0.00878038f, 0.15961419f, -0.07992942f, -0.05033050f, 0.03941578f, 0.01287556f, 0.02181054f, 0.03302440f, 
    0.44499192f, -0.13385016f, -0.01793390f, -0.07019057f, 0.10143106f, 0.01717128f, -0.03798219f, -0.00546488f, 
    -0.01179152f, 0.02690361f, 0.08812105f, -0.02978703f, 0.08261152f, -0.11730846f, 0.14396431f, -0.17107818f, 
    -0.11771048f, -0.00297770f, -0.08971913f, 0.06834257f, 0.02201121f, 0.11871036f, -0.07402702f, 0.07111062f, 
    -0.01119761f, 0.09839766f, -0.00021473f, -0.09962536f, -0.01935687f, -0.04257722f, -0.04449686f, 0.03124166f, 
    -0.03095863f, 0.01828325f, 0.00114384f, 0.05257049f, -0.01828926f, -0.02251397f, -0.07059991f, 0.09939913f, 
    0.15817784f, 0.11244021f, 0.01084241f, -0.01630690f, 0.07129938f, -0.01649378f, 0.07884117f, 0.09020437f, 
    0.00431653f, -0.03087842f, -0.06272238f, 0.02353600f, 0.10287511f, -0.01146687f, -0.02797737f, -0.02572713f, 
    -0.03595499f, -0.00340945f, 0.06724120f, -0.04333841f, 0.12733245f, -0.15913689f, -0.02190349f, -0.01525294f, 
    0.10160370f, 0.11552014f, -0.09257127f, 0.08017305f, 0.02163176f, 0.01235541f, 0.02021138f, 0.07228251f, 
    -0.25145718f, 0.00686948f, 0.21005203f, -0.02037430f, -0.13208300f, -0.03703351f, 0.11536385f, 0.03751604f, 
    0.04136633f, 0.02241226f, -0.03812883f, -0.03787893f, -0.15000924f, 0.01671271f, 0.09371217f, -0.14798018f, 
    0.04361501f, -0.05027522f, 0.05172709f, -0.02835003f, -0.05367212f, 0.05759164f, 0.05150297f, -0.06498934f, 
    0.23838080f, -0.03232034f, 0.27440685f, 0.01525201f, -0.05233983f, 0.10999762f, -0.00210413f, -0.08096884f, 
    0.07276803f, 0.06970301f, -0.07335065f, 0.07657594f, -0.10368560f, -0.14199039f, -0.04206222f, 0.14692335f, 
    0.06320997f, -0.06692461f, -0.03285103f, -0.07129480f, -0.04801534f, 0.08747770f, 0.04602620f, -0.05401443f, 
    0.13788077f, 0.05300008f, 0.04476203f, 0.02740745f, 0.02151066f, -0.05445414f, 0.06615008f, -0.03635081f, 
    0.07265197f, -0.02818686f, 0.03470396f, 0.10927620f, 0.05148097f, 0.10625391f, -0.28687173f, 0.15156297f, 
    0.05662229f, 0.07467788f, -0.02382455f, -0.00502130f, -0.01006086f, -0.10815312f, -0.00215670f, -0.04690943f, 
    0.04562056f, 0.19164909f, 0.05511536f, -0.04767670f, 0.02056787f, 0.01502283f, -0.02126147f, 0.06677203f, 
    -0.06531364f, 0.01641246f, 0.00928869f, -0.10271884f, 0.05511124f, 0.01057659f, -0.16792683f, 0.00977373f, 
    0.06711316f, -0.13796601f, -0.01522625f, 0.01746670f, -0.06590325f, 0.09712775f, 0.11241541f, 0.00972759f, 
    0.21480232f, 0.22493733f, -0.01200058f, 0.20697939f, 0.10270435f, -0.00078568f, 0.01915206f, 0.04344663f, 
    -0.09885392f, -0.03039157f, -0.03419088f, -0.03639502f, 0.28858101f, -0.26046848f, -0.01764309f, -0.01384522f, 
    -0.04608767f, 0.09589104f, 0.05685132f, -0.07285373f, -0.01503600f, 0.07973653f, -0.10436757f, 0.03657186f, 
    0.42723230f, 0.10250456f, -0.24019906f, -0.00328535f, 0.00308878f, -0.07080654f, 0.09609573f, 0.09150295f, 
    -0.07826507f, -0.01616461f, 0.06772842f, -0.03431151f, -0.11882614f, 0.04625142f, 0.04385514f, -0.08460738f, 
    0.07237327f, 0.10169610f, 0.00879212f, 0.00398265f, -0.11215074f, -0.00454208f, -0.08214140f, 0.00339123f, 
    -0.18056265f, -0.01934624f, -0.13048334f, -0.29326367f, 0.03227882f, -0.07779886f, 0.05230667f, 0.07523210f, 
    0.03146693f, -0.02623050f, 0.05260199f, -0.08421564f, -0.10191424f, 0.00220020f, 0.10295048f, -0.06377317f, 
    0.08747077f, 0.07660593f, -0.04738277f, -0.00765649f, 0.04173037f, -0.01403238f, 0.03820230f, 0.05726818f, 
    0.06578889f, 0.23891266f, 0.15103045f, 0.10770784f, -0.02680103f, -0.01994218f, 0.01926988f, -0.02010106f, 
    -0.02669027f, -0.05021242f, 0.01742502f, -0.04746705f, 0.15063229f, 0.12981433f, 0.03323775f, 0.15119417f, 
    0.09406283f, 0.08978090f, -0.05211041f, 0.00423290f, 0.01361709f, 0.08051448f, 0.00188431f, 0.03359163f, 
    0.30976230f, -0.05251179f, -0.07317884f, -0.00764348f, -0.08912963f, -0.04071504f, 0.01018572f, 0.02283526f, 
    -0.07857793f, 0.11809914f, 0.02423819f, 0.00662105f, -0.05377260f, -0.12527385f, 0.10519478f, 0.18423595f, 
    -0.03178031f, 0.09362546f, -0.06670661f, -0.01496088f, 0.05284647f, 0.08462401f, -0.00268330f, 0.02088692f, 
    0.09873798f, 0.15017337f, 0.13455100f, -0.09361044f, -0.06163694f, -0.01168411f, 0.01542182f, 0.06702935f, 
    0.07519850f, 0.00975080f, 0.03134603f, -0.07909366f, 0.11272509f, 0.15803334f, 0.02296209f, 0.05675289f, 
    0.01515979f, 0.03741952f, 0.01722203f, 0.05221236f, -0.02357701f, 0.04839208f, -0.07307010f, 0.14967422f, 
    0.05147829f, 0.13495639f, -0.14362878f, 0.12943700f, 0.12315844f, -0.04917542f, -0.00170655f, 0.15655285f, 
    0.08020692f, -0.09350113f, 0.04501852f, 0.03059090f, 0.04394629f, -0.06275737f, -0.22862715f, -0.17698127f, 
    0.03424207f, 0.04747727f, 0.01377773f, 0.00198932f, -0.01835277f, -0.01201319f, -0.11828887f, -0.00144624f, 
    0.30563417f, -0.12369982f, -0.15769397f, -0.00285356f, 0.00397673f, 0.00467844f, -0.00430344f, 0.07872130f, 
    0.06804550f, 0.06093874f, 0.01255141f, 0.17671776f, 0.12935445f, 0.06488790f, 0.19442712f, -0.01026135f, 
    -0.04565614f, -0.02220115f, 0.04816735f, 0.06571458f, 0.03754222f, 0.02843962f, 0.04299809f, -0.08479670f, 
    -0.03934863f, 0.03891407f, -0.00644042f, 0.04247932f, 0.04894596f, 0.05207327f, 0.05187012f, 0.06725656f, 
    0.04136989f, -0.27382514f, -0.00745237f, -0.29315501f, -0.19841905f, 0.02215931f, 0.01940417f, 0.08190888f, 
    0.11410157f, 0.02039374f, 0.04904105f, -0.01091228f, 0.21929708f, -0.11568768f, 0.06644833f, -0.17829767f, 
    0.08514193f, -0.03152664f, -0.13962378f, -0.07992335f, 0.01378979f, -0.03144639f, -0.06627844f, 0.08908159f, 
    -0.07498189f, 0.10742019f, 0.27250513f, 0.02604931f, -0.02365177f, -0.02018621f, 0.13379771f, 0.02761408f, 
    -0.05356719f, -0.07721552f, 0.06697569f, 0.04500167f, 0.10462327f, 0.09725800f, -0.12505239f, -0.05481517f, 
    -0.11068526f, -0.08780646f, -0.16658083f, 0.01827405f, 0.19180469f, -0.06750212f, -0.07972328f, -0.05091195f, 
    -0.04650572f, 0.17961164f, 0.07552069f, 0.27872244f, 0.21102290f, -0.01324370f, -0.02522186f, 0.06018218f, 
    -0.01674008f, -0.03311893f, -0.10851429f, -0.07442468f, -0.06660953f, 0.05476291f, -0.09095836f, 0.18077248f, 
    0.30777740f, 0.12449457f, 0.07892358f, 0.07279503f, 0.01235216f, 0.02308092f, -0.06711143f, -0.03423372f, 
    -0.12877284f, 0.02402426f, -0.13300326f, 0.01191963f, 0.09017716f, 0.14750470f, 0.02783242f, 0.08133771f, 
    -0.07038605f, -0.00706196f, -0.11974588f, -0.01909079f, 0.06769485f, -0.04206298f, 0.03996725f, -0.22523014f, 
    -0.07820512f, -0.08330984f, 0.13977870f, -0.00925667f, -0.01471083f, 0.01783940f, -0.10563278f, -0.02083126f, 
    -0.00494319f, -0.06484848f, 0.06252068f, 0.03337721f, 0.06635441f, -0.05073191f, -0.01019345f, -0.10323057f, 
    0.17071752f, -0.05277637f, 0.03553194f, -0.08955545f, 0.01089934f, 0.05257845f, -0.21645138f, 0.01511949f, 
    -0.03066338f, 0.03710086f, 0.10199580f, -0.01790507f, 0.06732687f, 0.04254212f, 0.03446485f, -0.06318402f, 
    -0.12173616f, 0.08262713f, 0.00767362f, 0.01819933f, -0.14159706f, -0.09625643f, -0.09515447f, -0.04129614f, 
    0.09709524f, -0.01317409f, 0.03195351f, -0.02576197f, 0.16778317f, 0.09542529f, 0.13593933f, 0.16679032f, 
    -0.34785840f, 0.16236182f, -0.04737051f, 0.19139387f, 0.01348743f, -0.17028926f, -0.04681117f, -0.10397317f, 
    0.20192756f, 0.04913687f, 0.12607667f, 0.12780420f, 0.05559241f, -0.06432916f, -0.15684696f, -0.10347045f, 
    0.19528829f, -0.16250591f, -0.13934624f, -0.05305140f, -0.09830475f, 0.12903921f, 0.04891163f, 0.16664152f, 
    0.08290694f, 0.10995414f, 0.04114253f, -0.05392251f, 0.08463179f, 0.01604625f, -0.12516442f, 0.00498747f, 
    0.03276410f, 0.08397670f, -0.01861303f, -0.14453460f, 0.07792594f, 0.08722357f, 0.02821572f, -0.06248852f, 
    -0.00338786f, -0.09247324f, 0.07413607f, 0.00154509f, 0.08840781f, 0.19434562f, 0.08151523f, 0.04461044f, 
    0.27580881f, -0.06733206f, 0.14720583f, -0.04174555f, 0.01913928f, -0.00084796f, 0.00315358f, -0.26214352f, 
    -0.05933851f, 0.02002671f, -0.00976467f, 0.01383587f, -0.22689104f, 0.23963615f, 0.08462207f, -0.02032620f, 
    -0.00287398f, -0.03060704f, -0.10981001f, 0.08226795f, 0.08387392f, -0.06683064f, -0.16182421f, -0.03462209f, 
    0.13412546f, 0.03043533f, -0.04746482f, 0.09376937f, -0.03942046f, 0.02079942f, 0.20048527f, -0.03498373f, 
    0.11966885f, 0.05331391f, 0.19201371f, 0.02212713f, 0.07065645f, 0.05167676f, 0.07276061f, 0.09826959f, 
    0.12577270f, 0.03392293f, -0.08208228f, 0.02853555f, -0.15886739f, 0.13845323f, 0.05847906f, 0.13700473f, 
    0.09364764f, -0.01461892f, -0.03690705f, -0.06032275f, -0.00135009f, -0.12426228f, -0.04232229f, 0.03124258f, 
    0.14514019f, -0.00883675f, -0.02651941f, 0.12086868f, -0.04478635f, 0.01044427f, 0.11942825f, 0.02070458f, 
    0.05833865f, 0.21810704f, 0.15699805f, -0.01738868f, 0.00282465f, -0.17474282f, -0.07708827f, 0.19263478f, 
    0.28995469f, 0.01295517f, 0.07064819f, -0.03643175f, 0.09351946f, 0.01037624f, 0.14126727f, -0.08600727f, 
    0.20981771f, 0.02823756f, 0.02475773f, 0.10456340f, 0.01095557f, -0.11318730f, -0.03293555f, 0.05050980f, 
    0.10008409f, 0.04153886f, 0.01637176f, -0.07661525f, 0.17739542f, -0.16635065f, 0.00711924f, 0.04642640f, 
    -0.17112319f, 0.14852935f, -0.15879914f, -0.09872234f, -0.17854936f, -0.14155149f, -0.02353727f, 0.08375309f, 
    -0.04311058f, 0.04632990f, 0.03632335f, 0.19308983f, -0.30778793f, -0.16962129f, 0.09524094f, -0.01486380f, 
    -0.07791127f, -0.17736569f, -0.00519618f, -0.05722839f, 0.11237698f, 0.26005667f, 0.02990132f, -0.08651900f, 
    0.00711980f, -0.08892598f, -0.02754535f, -0.03104986f, 0.16175222f, -0.02600604f, -0.01435209f, 0.02494977f, 
    -0.02683995f, -0.05250342f, 0.02739550f, -0.10980406f, -0.03942801f, -0.08393470f, -0.03494166f, 0.13688357f, 
    0.06168980f, 0.03167791f, 0.01021460f, -0.04530941f, 0.07509480f, 0.04951465f, 0.07232063f, 0.14434536f, 
    -0.08407769f, -0.02223050f, 0.06987055f, -0.04639631f, 0.10047981f, -0.03713296f, -0.16923961f, -0.01339100f, 
    -0.00147295f, -0.10712118f, -0.05708366f, -0.19173402f, -0.14796767f, -0.16275333f, 0.15241162f, 0.04003399f, 
    0.03805088f, -0.06967831f, 0.09216443f, 0.00978459f, 0.10882558f, -0.06749615f, -0.20200500f, -0.14682913f, 
    0.11794282f, 0.02417015f, 0.10193874f, -0.00460881f, -0.13295616f, 0.07082672f, -0.11872370f, -0.02026244f, 
    0.00320632f, -0.09305199f, 0.16853386f, 0.15533037f, -0.15024735f, -0.22951730f, 0.06692668f, 0.09846856f, 
    0.12135284f, -0.02714129f, 0.07510296f, 0.12002965f, 0.13637769f, 0.11519364f, -0.03447824f, 0.10734306f, 
    0.18580467f, 0.18391258f, -0.12249373f, 0.07832208f, -0.05671730f, 0.01263560f, 0.05957572f, 0.08458394f, 
    -0.00419324f, -0.05572651f, -0.09096212f, 0.03487694f, -0.29867208f, -0.17127542f, -0.05094481f, -0.00909319f, 
    0.05814397f, 0.03292957f, -0.04223760f, -0.04074861f, 0.00805506f, 0.05235782f, 0.12432663f, 0.05210951f, 
    0.06237635f, -0.20336670f, 0.02956879f, -0.09299609f, -0.00634568f, 0.08737296f, -0.10948207f, 0.08469382f, 
    0.00493455f, -0.00183417f, 0.02130705f, -0.04831541f, 0.19072409f, -0.12844753f, 0.00042182f, -0.03831019f, 
    0.03165704f, -0.00563939f, -0.18761106f, 0.03994736f, 0.08688611f, 0.15183623f, 0.05834420f, 0.08894632f, 
    -0.19811456f, 0.21249363f, 0.00672821f, -0.30982861f, -0.08991049f, -0.09614024f, 0.02205616f, 0.02841653f, 
    -0.02305250f, -0.05544604f, 0.05631198f, -0.03481409f, 0.16524619f, -0.26772669f, -0.07394025f, 0.25675079f, 
    0.11995441f, 0.14070405f, 0.00556056f, 0.05413333f, 0.10778104f, -0.04189210f, 0.04009191f, -0.06062275f, 
    -0.06299433f, -0.09030758f, -0.00526259f, -0.03315462f, 0.05983532f, -0.00406304f, 0.07336057f, 0.06278165f, 
    0.07910321f, 0.03735505f, -0.03781147f, 0.01405327f, 0.14219458f, -0.21502586f, 0.00615069f, 0.00479305f, 
    0.09859300f, -0.01879445f, 0.04916843f, -0.00102691f, 0.03714157f, -0.01503016f, 0.06335066f, -0.07995196f, 
    -0.16161709f, -0.07226800f, 0.00686619f, 0.08286346f, -0.04361454f, 0.05485063f, 0.12604094f, 0.08916118f, 
    0.09844369f, 0.02095503f, -0.04336498f, -0.08094623f, -0.11428138f, -0.13836025f, 0.07949776f, -0.14250967f, 
    -0.05471282f, 0.01991982f, 0.06593060f, 0.01472969f, 0.05017981f, -0.01834889f, 0.05343766f, -0.11672039f, 
    0.20706224f, 0.02201775f, -0.07872299f, -0.05331011f, 0.14187926f, 0.06721032f, 0.04880314f, 0.04526497f, 
    -0.04325153f, -0.02671121f, -0.00070130f, 0.01223582f, -0.20191641f, -0.18780844f, 0.24262689f, 0.09314236f, 
    -0.02317107f, 0.06265920f, 0.07964941f, 0.04245265f, 0.03722122f, 0.11819106f, 0.02336345f, -0.12858926f, 
    0.39837396f, 0.05148581f, -0.02691765f, -0.15834287f, 0.02004546f, -0.02554689f, 0.03206348f, 0.05167682f, 
    0.05884511f, -0.03306290f, -0.05150956f, 0.03923239f, 0.00052736f, -0.11761130f, -0.08780544f, 0.17419800f, 
    -0.02751300f, -0.00538650f, -0.06605144f, 0.04778706f, 0.00494315f, -0.00163878f, -0.02505569f, 0.00594202f, 
    0.04907034f, 0.03295060f, 0.04394173f, 0.02973883f, 0.06634772f, 0.16374417f, -0.01030676f, 0.06142940f, 
    -0.06409261f, 0.02504141f, -0.02302565f, -0.06049081f, 0.21487692f, -0.17131113f, 0.03997799f, 0.14052813f, 
    -0.05962928f, -0.02474278f, 0.01468179f, -0.02601821f, -0.06808044f, 0.08169515f, 0.06141837f, -0.08154529f, 
    0.06795751f, -0.07074844f, 0.02818516f, 0.28579375f, 0.02872582f, 0.06400482f, 0.11774395f, -0.06004558f, 
    0.01969408f, -0.07165111f, -0.00106236f, -0.01510104f, 0.13977316f, 0.23088977f, -0.18278046f, -0.09530683f, 
    0.11880830f, 0.11143006f, -0.00192051f, 0.05519130f, -0.07569999f, 0.00007218f, 0.01734738f, 0.17254238f, 
    -0.02183074f, -0.15618099f, 0.03183198f, -0.02888406f, -0.00410080f, -0.04142413f, 0.00223262f, 0.03784196f, 
    0.00283602f, 0.01184685f, 0.06920336f, 0.06249128f, 0.01809428f, 0.05130567f, -0.03306514f, 0.08592303f, 
    0.02827622f, 0.01221651f, 0.08952864f, 0.05877735f, 0.05313846f, 0.03200536f, -0.11216039f, 0.04187192f, 
    -0.00439129f, -0.05516528f, 0.07081975f, -0.09305527f, -0.02049307f, 0.03151198f, 0.09805534f, -0.00623967f, 
    -0.04521730f, -0.03428167f, 0.05997508f, -0.02450584f, 0.13530010f, 0.09583107f, 0.09317441f, 0.09197624f, 
    0.03263205f, 0.02757425f, 0.03471683f, -0.01182578f, -0.05830555f, -0.06473226f, 0.11565018f, -0.02172080f, 
    -0.13142839f, 0.06369885f, -0.01076872f, 0.05670818f, 0.05859796f, 0.12449679f, -0.04870845f, -0.03266216f, 
    0.09874522f, -0.01025640f, -0.00922071f, -0.03492509f, -0.25992197f, 0.18310879f, 0.09617628f, 0.01873218f, 
    0.07262018f, 0.09440814f, -0.01167832f, 0.06989223f, 0.01249922f, -0.03165650f, 0.04151749f, 0.06228405f, 
    -0.00465132f, -0.00562243f, -0.18204157f, -0.05315595f, -0.10070772f, 0.01881981f, -0.08303743f, 0.02851737f, 
    -0.07130680f, 0.11372286f, 0.00116685f, -0.06403346f, -0.05648874f, 0.05510221f, -0.02084975f, 0.21271227f, 
    -0.05198390f, 0.08960862f, -0.01523928f, 0.00698513f, -0.00006021f, -0.01431838f, -0.01146479f, 0.04729145f, 
    -0.23017095f, 0.14033855f, -0.00297160f, -0.18111804f, -0.01992095f, 0.07745268f, 0.06555554f, 0.06938851f, 
    0.05227964f, -0.03673576f, -0.03085329f, 0.02437353f, -0.00056925f, -0.00382312f, 0.02691356f, -0.03938991f, 
    -0.01885310f, -0.06934204f, 0.03570910f, 0.00510031f, -0.00364404f, 0.02338834f, -0.07492282f, 0.05449379f, 
    0.24420452f, -0.01289545f, 0.21100132f, 0.20753533f, -0.00204138f, 0.00869839f, 0.05232330f, 0.01384045f, 
    0.02419245f, -0.08059511f, -0.02821876f, 0.04143420f, -0.07919735f, -0.03652343f, -0.10331737f, 0.09609493f, 
    0.02128109f, 0.02892200f, 0.03837191f, -0.03361367f, -0.02246118f, -0.03713806f, -0.10768548f, 0.09697521f, 
    -0.00345861f, -0.18003434f, 0.24328056f, 0.01350961f, -0.03050609f, 0.07509509f, -0.00148237f, 0.01006816f, 
    0.15418293f, -0.02964802f, -0.00103479f, -0.03787919f, -0.14539605f, 0.06191399f, 0.20368114f, -0.29463109f, 
    -0.03125509f, 0.06407628f, -0.03229335f, 0.05081216f, -0.09336343f, -0.10537177f, 0.06693441f, -0.03896953f, 
    -0.05644372f, 0.07215964f, 0.07782470f, 0.05454147f, 0.01061486f, 0.16827320f, -0.00973904f, 0.16769601f, 
    -0.01001494f, -0.08851571f, 0.07794366f, -0.06748875f, -0.41231102f, -0.18954112f, 0.02506227f, -0.16379312f, 
    0.19033875f, 0.07980563f, 0.10095177f, 0.06424445f, 0.07960655f, -0.11093551f, 0.00930306f, -0.00515509f, 
    0.21303648f, -0.18969008f, 0.13104558f, -0.00195580f, 0.03844260f, -0.04264206f, -0.09192074f, 0.03853087f, 
    -0.00598024f, 0.11031282f, 0.13792339f, 0.01758818f, -0.10338676f, 0.11171633f, 0.03035485f, -0.07230830f, 
    -0.01083093f, -0.01573261f, -0.12929671f, 0.03235691f, 0.08534580f, 0.15903240f, 0.04523408f, -0.03645452f, 
    -0.00615021f, 0.12505341f, -0.00267440f, 0.03890707f, -0.03038821f, 0.02381155f, 0.02790366f, -0.04761121f, 
    0.04966692f, 0.04587011f, 0.09033949f, 0.09103806f, 0.24729067f, -0.10433929f, 0.02321886f, 0.14038271f, 
    -0.04711143f, 0.01014636f, 0.00118912f, 0.01071051f, 0.01870271f, 0.10768417f, 0.08693976f, 0.01816309f, 
    0.08198969f, 0.00703902f, -0.01397908f, -0.05068741f, -0.00988998f, 0.04876851f, -0.04666166f, -0.00861295f, 
    -0.03189280f, 0.06418429f, -0.03173859f, 0.13690038f, -0.40825853f, -0.19273122f, -0.04950400f, -0.08833248f, 
    0.07684939f, -0.00252653f, -0.10542411f, 0.13723759f, -0.03228360f, 0.00673051f, 0.00882493f, -0.04771753f, 
    -0.24936478f, -0.25285867f, 0.15072870f, -0.20027931f, -0.00718560f, -0.04227010f, -0.00707203f, -0.06881536f, 
    0.01843916f, -0.09163191f, 0.12370379f, 0.06234803f, -0.13800450f, -0.11246826f, 0.20507881f, 0.22419615f, 
    0.03908855f, -0.02941066f, -0.01265274f, -0.00893066f, 0.01636009f, 0.02050080f, -0.07855588f, 0.04984983f, 
    -0.01025663f, 0.25388351f, 0.02584749f, 0.09728295f, 0.12398726f, -0.04963712f, 0.04320755f, -0.11229985f, 
    -0.01353085f, 0.04499008f, 0.02157470f, 0.03563598f, -0.07914518f, 0.26492372f, 0.14771527f, -0.09145060f, 
    -0.01745944f, 0.10502538f, -0.02205903f, -0.06695609f, 0.05431539f, 0.02853648f, 0.06900954f, 0.02319296f, 
    0.35592347f, 0.16934605f, 0.11048893f, 0.15379176f, -0.01694460f, -0.05636798f, 0.04446216f, -0.11518072f, 
    0.14022452f, -0.00203516f, 0.02331462f, 0.14370789f, -0.05672641f, -0.04896361f, -0.06441811f, -0.26113564f, 
    0.00981807f, -0.07097726f, -0.03510593f, 0.03692180f, 0.04081082f, -0.02377671f, 0.03343713f, 0.05233527f, 
    -0.22164479f, -0.16277538f, -0.08400072f, -0.10308444f, 0.07359455f, 0.07515561f, 0.14643186f, 0.17039517f, 
    0.07786280f, 0.13279651f, -0.06981796f, -0.00581225f, -0.02010870f, -0.01892926f, 0.06981676f, 0.02833646f, 
    -0.09285543f, -0.06839737f, 0.11147798f, -0.00583047f, 0.03820968f, -0.03295101f, -0.06110234f, 0.10277491f, 
    0.16331722f, 0.03696511f, 0.16328150f, 0.02433553f, 0.08132401f, -0.00185112f, -0.00044190f, -0.13107991f, 
    0.01894275f, -0.12608117f, -0.02736453f, -0.02581073f, -0.06449209f, 0.24463676f, 0.02358181f, 0.00275792f, 
    0.14483094f, 0.05137638f, -0.08038687f, 0.03742680f, -0.09273820f, -0.07996975f, -0.06512292f, 0.09477277f, 
    -0.10528160f, 0.05214790f, 0.16180100f, 0.06903245f, -0.08968143f, 0.01471831f, 0.03564383f, -0.02112633f, 
    -0.08591615f, -0.06561134f, 0.05931508f, -0.01663077f, -0.23072389f, -0.15863179f, 0.05198326f, 0.04810026f, 
    -0.00561924f, -0.02566501f, 0.01590827f, 0.02019264f, -0.13751554f, -0.00583853f, 0.10398995f, 0.16723803f, 
    -0.15876378f, -0.08381056f, 0.15287298f, 0.15750857f, -0.03301777f, 0.11435274f, -0.05945199f, -0.04872794f, 
    0.12769517f, -0.00791183f, -0.09603199f, 0.03137604f, -0.28720123f, -0.22258955f, -0.20062001f, 0.04519228f, 
    0.17018931f, 0.07852424f, 0.03094057f, 0.10247384f, 0.03845036f, -0.13005340f, -0.06960408f, 0.19229294f, 
    0.21119221f, 0.14598697f, -0.06974348f, 0.03796420f, 0.03979456f, 0.03815192f, -0.04182395f, -0.00264268f, 
    0.13812141f, -0.01166423f, -0.00446738f, 0.07183144f, -0.05775898f, 0.22262958f, -0.05897074f, 0.02294543f, 
    -0.06224231f, 0.09177609f, 0.03382736f, -0.17493434f, 0.10003439f, -0.14918421f, -0.04212044f, 0.05125510f, 
    -0.20997249f, 0.12410733f, -0.06313854f, -0.08994979f, -0.02777033f, -0.08192060f, 0.04762083f, 0.11113279f, 
    0.03811936f, -0.04015225f, -0.02555616f, 0.03131149f, -0.17314434f, -0.04221108f, 0.02481512f, -0.27746192f, 
    -0.06870382f, 0.00211782f, -0.00929575f, 0.10403778f, 0.12437075f, 0.07969673f, 0.11382278f, 0.00806995f, 
    0.02028360f, 0.13010477f, 0.14845780f, 0.21676445f, -0.04226200f, -0.07868332f, -0.02731350f, -0.02397132f, 
    0.07430659f, -0.02903344f, 0.01544779f, 0.00409926f, 0.00275637f, 0.00164986f, 0.22755347f, 0.09237286f, 
    -0.12611988f, -0.01927746f, -0.08124349f, -0.17101972f, -0.03664186f, 0.00645476f, 0.04332423f, 0.14160082f, 
    0.02132141f, -0.10478202f, 0.13797916f, -0.10818505f, -0.05846473f, 0.06116441f, -0.00401774f, 0.10320650f, 
    0.13754582f, 0.08063240f, -0.04407042f, -0.07712131f, -0.03732847f, 0.04216732f, 0.10666270f, 0.05833830f, 
    -0.07706545f, -0.01712730f, 0.03704267f, 0.03961967f, 0.04436151f, 0.01708741f, 0.06375186f, 0.00882466f, 
    -0.21884109f, 0.02887778f, 0.12884219f, 0.02532353f, 0.02183099f, 0.01068922f, -0.24595487f, 0.05805084f, 
    0.10498399f, -0.05889621f, 0.12937096f, 0.03323678f, 0.00744900f, -0.07853381f, 0.26660323f, 0.16420662f, 
    0.06328207f, 0.05579558f, -0.06508924f, -0.04915858f, 0.03221546f, -0.08135559f, -0.02285407f, -0.02705375f, 
    -0.02301979f, -0.05013696f, 0.03683062f, -0.05210131f, -0.00738721f, -0.01479008f, 0.00504100f, -0.01767564f, 
    0.01511632f, -0.00455151f, -0.00982710f, -0.01447646f, -0.03757698f, -0.04273495f, 0.03813354f, -0.04522832f, 
    -0.04423292f, -0.05256661f, 0.00810667f, 0.02850583f, -0.02057663f, -0.03608097f, 0.02086341f, -0.00952437f, 
    0.01139029f, -0.03173691f, 0.04842128f, 0.04925466f, -0.03871902f, 0.00795811f, -0.03401534f, -0.00309591f, 
    0.03246050f, -0.00649471f, 0.04168020f, 0.00114892f, -0.00864011f, 0.01642911f, 0.02405078f, -0.01338748f, 
    -0.01863688f, 0.03866459f, -0.00943241f, -0.03854462f, -0.01349376f, -0.03505975f, -0.03124156f, 0.00094901f, 
    0.04065913f, -0.01555097f, 0.02543582f, -0.05305808f, 0.03116571f, -0.03854761f, -0.00988765f, 0.02133121f, 
    0.02924327f, 0.04641605f, -0.01317760f, -0.04738192f, -0.02388127f, -0.02187171f, -0.03351621f, 0.04422374f, 
    -0.04557806f, -0.05208622f, -0.03523384f, -0.04620914f, -0.02752713f, 0.04609260f, -0.04712659f, -0.03816465f, 
    0.01811120f, -0.04419083f, -0.05377585f, 0.04824996f, 0.02882019f, 0.04262578f, -0.00075479f, 0.00009361f, 
    0.01644757f, -0.04556014f, -0.04620106f, 0.02230766f, -0.01584165f, -0.05766775f, 0.04018817f, 0.03071797f, 
    -0.01887657f, 0.00004327f, 0.02111933f, -0.02764817f, 0.00277811f, -0.04523606f, 0.00754758f, 0.01890930f, 
    -0.02850831f, -0.01056878f, 0.02000859f, -0.03216967f, -0.03509414f, -0.03735249f, -0.03009667f, 0.00048291f, 
    -0.03358275f, -0.03112066f, -0.05369982f, -0.04244260f, 0.02290345f, -0.04079743f, 0.04254948f, 0.02953541f, 
    -0.04922507f, 0.02950030f, 0.02050069f, -0.01655799f, -0.00544538f, 0.01768005f, -0.04901509f, 0.00636716f, 
    -0.02906094f, -0.02101728f, 0.01043629f, -0.05413162f, -0.03611000f, -0.03375636f, -0.01947837f, 0.04193428f, 
    -0.02529057f, -0.05906094f, 0.02458093f, 0.02351027f, -0.05992900f, 0.01966470f, -0.02693051f, 0.04606668f, 
    -0.00231735f, 0.02943755f, 0.00527454f, -0.00067092f, -0.00003901f, -0.03865681f, -0.04671913f, -0.01881229f, 
    -0.02305054f, -0.04568191f, 0.03795449f, -0.02312930f, -0.03056156f, -0.04328555f, 0.02832007f, 0.00803032f, 
    -0.02670757f, 0.00097215f, 0.02875471f, -0.01068596f, -0.03533461f, -0.02934045f, 0.00030813f, -0.02073394f, 
    -0.01574024f, 0.01154527f, 0.00857111f, -0.04332593f, 0.03869966f, -0.03466518f, 0.01153132f, 0.00406064f, 
    0.02720102f, 0.03474562f, -0.01361762f, 0.02756089f, -0.00704491f, 0.01529936f, 0.04566425f, 0.00315144f, 
    -0.00984431f, -0.03752716f, -0.04331710f, -0.01727247f, -0.03345648f, -0.04797741f, -0.05388151f, -0.00570349f, 
    -0.04518668f, -0.00320268f, -0.01965299f, 0.00657630f, -0.00378646f, -0.01047897f, 0.01813311f, -0.01410602f, 
    0.01200030f, 0.00985549f, -0.00749810f, -0.03493012f, -0.02007764f, -0.03109035f, 0.04231746f, -0.03633839f, 
    -0.03486461f, 0.00769171f, -0.01995096f, 0.02979450f, -0.04030991f, -0.04817031f, 0.00150593f, -0.00412927f, 
    -0.02070505f, 0.02235577f, 0.00219067f, -0.03755064f, 0.03032206f, -0.03712570f, 0.04210598f, 0.03506404f, 
    -0.01268480f, -0.02132823f, 0.01024079f, -0.02205221f, 0.03874901f, -0.00779486f, 0.04801944f, 0.00608717f, 
    0.01110470f, -0.01880978f, -0.04034479f, 0.03887621f, 0.01664175f, -0.01306121f, -0.00930664f, 0.02745389f, 
    -0.00903925f, -0.05445872f, -0.00360682f, 0.04208929f, 0.02287658f, 0.03144050f, 0.03582070f, -0.01576051f, 
    -0.05018245f, 0.00091585f, -0.02157290f, -0.03977988f, -0.03941575f, -0.02078060f, 0.03822003f, -0.02688351f, 
    -0.04275264f, 0.02057078f, 0.02406232f, -0.01697267f, -0.05505673f, 0.00049692f, 0.01927985f, -0.03090959f, 
    -0.01493826f, -0.01578011f, 0.04422300f, 0.02349372f, -0.01069195f, 0.02340809f, -0.00557304f, 0.01640574f, 
    0.00280958f, 0.02511362f, -0.04759489f, 0.01607649f, -0.02836954f, -0.01083872f, -0.04618368f, -0.01028173f, 
    0.02737640f, -0.00719387f, 0.01298373f, -0.02909984f, 0.00578032f, -0.04811340f, -0.05786829f, -0.00137695f, 
    -0.04092397f, -0.00679884f, 0.01681950f, -0.02019534f, 0.02730967f, -0.00178176f, -0.01065536f, -0.01257706f, 
    -0.00601682f, -0.04699711f, 0.01085965f, 0.01489670f, 0.02946614f, -0.00277082f, -0.05088406f, -0.01336961f, 
    0.01320125f, 0.02646613f, -0.03704894f, 0.02811814f, -0.04006544f, -0.02627604f, -0.01439182f, -0.05580895f, 
    -0.00759181f, 0.02812104f, 0.00590294f, -0.01293260f, -0.03371842f, -0.01180521f, -0.01908031f, 0.03569754f, 
    -0.01477241f, -0.00688854f, -0.02296195f, 0.00778759f, -0.05488186f, -0.00055955f, -0.02309351f, -0.04477884f, 
    0.02824774f, 0.03230276f, 0.05115684f, 0.01543374f, -0.06090824f, 0.02757494f, -0.04716671f, 0.03234613f, 
    -0.02161179f, -0.00402474f, 0.04333815f, -0.02958591f, -0.03205165f, -0.03101130f, 0.00107578f, -0.02532322f, 
    -0.00729855f, -0.04840766f, -0.02233351f, -0.03610236f, 0.02140571f, 0.03660055f, 0.01113932f, 0.01998930f, 
    -0.04165701f, 0.01787367f, 0.03409146f, -0.02083389f, -0.00189167f, 0.03638840f, -0.01187207f, 0.02831844f, 
    0.03711832f, 0.02604534f, -0.00123015f, 0.00166207f, 0.03911540f, 0.03803255f, 0.02904903f, 0.03809655f, 
    0.00926173f, -0.02523489f, -0.00175985f, -0.00288567f, -0.04330437f, 0.04541982f, 0.02736392f, 0.01108757f, 
    -0.04302195f, -0.03461701f, 0.01614254f, 0.01164607f, -0.03953095f, -0.00132042f, 0.03737155f, -0.04313299f, 
    0.04153982f, 0.03325535f, 0.00538281f, -0.04948792f, -0.02444260f, -0.00899922f, 0.00478334f, -0.04458091f, 
    0.32114694f, 0.24680051f, 0.03727730f, 0.03660152f, -0.00448774f, -0.05717068f, -0.01612127f, 0.00440903f, 
    0.05428802f, -0.06627948f, 0.06140335f, -0.03065482f, 0.01281642f, 0.01484907f, -0.14150712f, 0.13445519f, 
    -0.18828414f, 0.00330403f, 0.07236317f, -0.01012751f, -0.03303127f, 0.08036140f, 0.10923952f, -0.03266967f, 
    -0.06044726f, 0.03725697f, -0.00252448f, 0.07179549f, -0.10845948f, 0.05818095f, 0.04320978f, 0.06379505f, 
    0.02409752f, -0.00556488f, -0.04791695f, 0.05974352f, -0.13652387f, -0.06064916f, -0.15457475f, 0.00627116f, 
    -0.03832901f, -0.05649802f, -0.04304102f, 0.05563979f, 0.02228872f, -0.01032605f, -0.01001282f, 0.04102818f, 
    0.03983041f, -0.06791335f, -0.00124135f, -0.18003339f, 0.01046410f, -0.01661623f, -0.01283680f, -0.01007889f, 
    0.01736963f, -0.07714146f, 0.12522247f, 0.01596292f, 0.02874816f, 0.04828230f, -0.02824647f, 0.22856966f, 
    -0.03931215f, 0.08380384f, 0.01703516f, -0.07219215f, 0.04922625f, -0.04195179f, -0.06336028f, 0.09892243f, 
    -0.01568809f, -0.03250502f, -0.17525925f, 0.07708598f, -0.09501461f, 0.06556613f, 0.13984622f, -0.07103683f, 
    0.05633550f, -0.03017590f, 0.01162940f, -0.08342943f, 0.02833280f, -0.01481822f, -0.12482359f, 0.03664851f, 
    -0.05825283f, 0.04611276f, -0.03871101f, -0.03294391f, -0.03651025f, -0.05692369f, 0.08638833f, -0.01286422f, 
    0.15340371f, 0.04302483f, -0.07960424f, 0.18980110f, -0.13406469f, 0.04284253f, -0.08157425f, -0.00511858f, 
    0.05933834f, -0.02366206f, -0.07430442f, 0.01151676f, 0.17968978f, 0.09008938f, -0.08563289f, -0.18495975f, 
    0.02277761f, -0.01383813f, 0.16349985f, 0.04926228f, 0.00047829f, 0.21998467f, 0.01902580f, 0.08776269f, 
    -0.11860812f, -0.17062142f, 0.13382620f, -0.29410613f, -0.10288563f, 0.02032104f, 0.06408903f, -0.07715062f, 
    -0.11313181f, 0.00692368f, -0.06427614f, -0.12526314f, 0.04573205f, -0.03309193f, -0.20787713f, 0.24957001f, 
    0.16761136f, 0.03673735f, -0.04531647f, 0.01789330f, 0.08904974f, -0.00339312f, 0.00448121f, -0.00297669f, 
    -0.30872136f, -0.12742178f, 0.05548435f, -0.12380289f, 0.07154344f, -0.06684145f, -0.02201970f, -0.01091329f, 
    -0.03401619f, -0.01428453f, 0.02022580f, 0.08272421f, -0.10002593f, -0.05791229f, -0.11215316f, 0.30472872f, 
    0.04548506f, 0.00348755f, -0.14085810f, 0.18486904f, -0.09042309f, 0.00955197f, -0.05546153f, 0.03451039f, 
    0.10742769f, 0.12564793f, -0.09053715f, -0.03863693f, -0.04168130f, -0.00456078f, -0.10313712f, 0.03219814f, 
    -0.08977885f, 0.05290591f, -0.01317819f, -0.08503560f, 0.15384802f, 0.07241657f, -0.02214593f, 0.33371329f, 
    0.03625322f, -0.10975837f, -0.01801586f, 0.10566267f, 0.05324785f, 0.04049229f, -0.09113590f, 0.07426023f, 
    -0.43251935f, 0.05895824f, -0.05451802f, 0.16172910f, -0.08850465f, 0.11646526f, 0.06077268f, -0.08793224f, 
    0.01474358f, 0.07515901f, 0.03367548f, 0.03652653f, 0.20934881f, -0.10945225f, -0.00241508f, -0.07944316f, 
    0.00782493f, 0.05411325f, 0.01437465f, -0.04472129f, 0.02431598f, 0.15785888f, 0.02871516f, -0.04392622f, 
    -0.03127976f, -0.10411146f, -0.02911378f, 0.19668452f, 0.06831593f, -0.05887425f, -0.02418644f, 0.17325300f, 
    -0.04164730f, -0.01969377f, 0.02817039f, -0.02005108f, 0.28270110f, 0.27391517f, -0.04847605f, -0.05959379f, 
    -0.03444732f, -0.02586834f, -0.03010227f, -0.05046862f, 0.14055045f, -0.00468361f, 0.07418880f, 0.10686228f, 
    0.25888532f, 0.24025610f, 0.02793172f, -0.01890504f, 0.02976643f, 0.04956864f, 0.04234533f, -0.08387735f, 
    -0.01509743f, 0.08707377f, 0.11184797f, 0.06343058f, 0.08763332f, -0.00764867f, 0.13013990f, -0.11242201f, 
    -0.03405072f, 0.03015029f, 0.09013741f, -0.15414631f, -0.04125404f, -0.04214726f, 0.08191173f, -0.04261229f, 
    -0.37725705f, -0.20905735f, 0.01088585f, -0.00350335f, 0.01727031f, -0.02652196f, -0.01807819f, 0.02214678f, 
    0.11494607f, -0.03466343f, 0.04939865f, 0.12831567f, -0.18036015f, -0.09229340f, -0.05132221f, 0.01112127f, 
    0.00906236f, 0.12549376f, 0.16658707f, 0.00386381f, 0.08878139f, -0.06981778f, -0.11532450f, 0.07864565f, 
    -0.23484147f, -0.03798074f, 0.07645381f, 0.16056386f, 0.05466259f, -0.13418521f, 0.08728825f, 0.05401095f, 
    -0.03193631f, 0.00630938f, 0.03167552f, 0.03821144f, 0.32195687f, -0.04648511f, -0.00741591f, 0.13380656f, 
    0.05831617f, 0.10548409f, -0.08449582f, -0.01999802f, 0.00312240f, 0.09589718f, 0.00948534f, -0.03853430f, 
    -0.18660739f, -0.06719398f, -0.00355336f, -0.29753083f, 0.08463756f, -0.00787587f, 0.12089803f, 0.04538350f, 
    -0.00648571f, -0.06773752f, 0.04533696f, 0.04944026f, -0.15123264f, -0.02450911f, 0.00332282f, -0.07771055f, 
    0.05102850f, 0.11544615f, 0.06805507f, 0.02500994f, -0.13167340f, -0.02993722f, 0.11253711f, 0.03392333f, 
    -0.12210536f, 0.09639496f, 0.05219001f, 0.34423736f, 0.10153323f, 0.09303047f, -0.02852058f, -0.12464175f, 
    0.07539915f, 0.05108216f, 0.02087555f, -0.02871683f, -0.10491878f, 0.05251658f, 0.06983433f, -0.04824712f, 
    0.17091660f, 0.03700337f, -0.05189664f, 0.06906714f, 0.15259930f, -0.10664623f, -0.00324362f, 0.05083986f, 
    0.18153198f, 0.15953267f, 0.33112866f, 0.04647450f, -0.00445994f, -0.04225876f, 0.06602085f, 0.09915818f, 
    -0.02565797f, -0.00704464f, -0.04962336f, 0.04232254f, -0.10948212f, 0.00631980f, 0.00871831f, -0.25457692f, 
    0.04923608f, 0.00747861f, -0.06367907f, 0.07329816f, 0.03757825f, 0.02073893f, 0.03609123f, 0.08484176f, 
    0.18400553f, -0.08573447f, 0.15989226f, 0.21384951f, 0.07199962f, 0.15414669f, 0.11072298f, 0.10421395f, 
    -0.00981506f, -0.09963541f, 0.02704022f, -0.11224400f, -0.23400511f, 0.07284252f, 0.01516709f, -0.21285996f, 
    0.06566534f, 0.09914480f, 0.04617688f, 0.01497740f, 0.16413374f, -0.07181344f, 0.01961757f, -0.05163293f, 
    -0.13596918f, -0.19928740f, 0.24307261f, -0.07464495f, 0.04857218f, -0.03987084f, -0.08265447f, 0.03886351f, 
    0.10384300f, 0.08527218f, 0.12216895f, -0.00561240f, 0.27272436f, -0.03661082f, 0.11109026f, -0.19131023f, 
    -0.10094858f, 0.00243840f, -0.00645280f, -0.08127690f, 0.01943947f, 0.14431499f, 0.05494326f, -0.08494475f, 
    0.04592440f, -0.03404950f, 0.02371787f, -0.01217529f, -0.01455194f, 0.08445372f, 0.01562412f, 0.04880096f, 
    0.05306769f, 0.07798920f, 0.05993965f, 0.10445026f, -0.16034158f, -0.03931269f, 0.17457876f, 0.00761973f, 
    0.03374388f, -0.13308962f, -0.03907043f, -0.02582940f, 0.06312884f, -0.01769312f, 0.02846391f, 0.11348259f, 
    0.16809221f, 0.00177589f, -0.18093003f, -0.16734311f, 0.03543275f, -0.02378381f, -0.08999269f, -0.20950559f, 
    0.02759281f, 0.06293653f, -0.05938525f, 0.02814945f, -0.10456626f, -0.04061212f, -0.06364775f, -0.19383232f, 
    0.05529615f, 0.04814021f, -0.08956946f, -0.07388578f, -0.02553187f, 0.01971829f, 0.00679575f, -0.00689365f, 
    0.00066598f, -0.12157257f, 0.07526840f, -0.10130664f, 0.00218892f, -0.01263886f, 0.03556391f, -0.04171130f, 
    0.02535832f, -0.11901344f, 0.03268277f, -0.00049476f, -0.07393555f, -0.06442770f, 0.00908338f, -0.04697123f, 
    0.09622823f, -0.14697216f, 0.06301268f, 0.09484813f, -0.06211236f, 0.03514947f, -0.11212328f, -0.01525810f, 
    0.05019071f, 0.10732095f, 0.11444271f, 0.10751466f, -0.00175541f, 0.06685410f, 0.09365970f, -0.13723315f, 
    0.08290622f, 0.07630257f, -0.04311896f, -0.04139344f, -0.00757765f, 0.15573609f, 0.04714269f, 0.00697159f, 
    -0.05852697f, 0.05271704f, -0.06199209f, -0.00588545f, 0.14401729f, 0.06603864f, -0.00059492f, 0.04928464f, 
    0.19368146f, -0.07531444f, 0.07886827f, 0.33625063f, -0.06018277f, 0.09654151f, -0.01849592f, -0.02400663f, 
    0.06015988f, 0.04167737f, 0.14130522f, 0.12275943f, -0.15854356f, 0.20951845f, -0.20556985f, 0.07676095f, 
    0.09693104f, -0.04386818f, -0.04876402f, -0.04705943f, 0.05389803f, 0.03332321f, 0.03174413f, 0.06503260f, 
    -0.03477541f, 0.08099058f, 0.18237182f, -0.23180334f, 0.12034743f, 0.10607982f, -0.04031400f, 0.15356281f, 
    -0.02766870f, 0.05338657f, 0.00984933f, -0.15868679f, 0.22685003f, -0.00872639f, -0.01769127f, 0.09219464f, 
    -0.05487423f, -0.08242888f, -0.03461901f, 0.16181168f, 0.04336724f, -0.09532604f, -0.00581782f, 0.08864047f, 
    0.23911327f, 0.01440393f, -0.01852755f, 0.12707536f, -0.03223917f, -0.06449647f, 0.08479384f, -0.01590278f, 
    -0.04922169f, -0.02372508f, -0.09869152f, -0.06618180f, -0.26603779f, 0.05733710f, 0.06127312f, 0.10991933f, 
    0.06282111f, 0.06981020f, 0.01312081f, 0.00320238f, -0.09076371f, -0.00221919f, -0.04859722f, -0.05973019f, 
    0.01854642f, 0.04147771f, -0.02986333f, 0.16166085f, -0.04270383f, -0.07092530f, 0.00997617f, 0.01384852f, 
    -0.09115257f, 0.13746685f, -0.00748854f, 0.00576998f, -0.11111973f, 0.01042608f, 0.12828164f, 0.13217518f, 
    -0.02818646f, -0.03586932f, -0.05525026f, -0.01773636f, -0.12990904f, -0.01405334f, 0.10237096f, 0.12034094f, 
    -0.05844218f, 0.09775476f, -0.07506575f, 0.10963733f, 0.12630986f, -0.08202781f, 0.02512882f, 0.06181909f, 
    0.04267672f, -0.04667800f, -0.07002810f, -0.02382371f, -0.08067494f, -0.05867994f, 0.02225628f, -0.13907000f, 
    0.09381704f, 0.10137625f, 0.08639478f, -0.05656558f, 0.01655497f, -0.04055576f, -0.09904544f, -0.00183701f, 
    0.09419385f, -0.03135587f, 0.07760394f, 0.05851650f, -0.06975116f, 0.04712650f, -0.04134974f, -0.05652620f, 
    0.06433152f, 0.05363001f, -0.02742038f, 0.09543376f, 0.03801714f, -0.03846674f, 0.00047848f, 0.11377281f, 
    0.04336014f, 0.19145519f, -0.08145172f, -0.06540504f, 0.07570563f, -0.08111280f, 0.01902453f, 0.08014225f, 
    -0.09680166f, 0.09369279f, 0.05885056f, 0.02547581f, -0.08867330f, -0.00581254f, 0.08275829f, 0.07277964f, 
    0.00670401f, 0.07780343f, -0.05287450f, 0.05937524f, 0.10800595f, 0.05507543f, 0.12327808f, 0.08349022f, 
    -0.07977058f, -0.01801648f, -0.05576621f, -0.00677086f, 0.13180697f, 0.08717822f, 0.09809266f, 0.03709204f, 
    -0.07710302f, 0.17118371f, 0.05201787f, 0.02955234f, -0.08028287f, -0.14299443f, -0.01297063f, 0.02251629f, 
    0.11716264f, -0.09027924f, 0.00066264f, -0.03289714f, -0.01191737f, -0.06739314f, 0.06084756f, 0.01497580f, 
    -0.08104901f, 0.09664467f, -0.04144762f, 0.08710635f, -0.09214871f, -0.04830449f, 0.08816459f, 0.15472643f, 
    0.16508076f, -0.11825650f, 0.20204817f, -0.06926029f, 0.11586856f, 0.04462207f, -0.11200243f, 0.12689002f, 
    -0.01610168f, 0.08089774f, 0.00465196f, -0.00309196f, 0.25737870f, -0.28064576f, 0.15777387f, 0.15816234f, 
    0.03259033f, 0.00841708f, -0.02167078f, 0.06637865f, 0.03168430f, -0.08370627f, -0.11625028f, -0.12541038f, 
    -0.10211439f, 0.16743715f, 0.07376782f, 0.15255281f, 0.00287720f, -0.01494414f, -0.00507956f, 0.07088684f, 
    -0.04113899f, -0.03338058f, 0.07933263f, 0.07819498f, -0.13043480f, -0.24515651f, -0.01161333f, -0.00409853f, 
    0.08054031f, -0.06913390f, 0.09041997f, 0.05515339f, 0.06824302f, -0.05098800f, 0.01161043f, 0.07109991f, 
    -0.09022184f, 0.18157008f, 0.10882749f, 0.05629030f, 0.08419137f, 0.01509790f, 0.00296299f, -0.01778429f, 
    -0.01593417f, 0.00565783f, 0.00127316f, -0.05287650f, -0.15412177f, 0.17399256f, 0.08253504f, 0.25479934f, 
    0.09857584f, -0.01545615f, 0.15051703f, -0.00490100f, 0.06157612f, -0.02059617f, 0.08340039f, -0.07482923f, 
    0.58516759f, -0.15342897f, -0.21141224f, 0.09337619f, 0.02375092f, 0.01638131f, -0.00249095f, -0.02564365f, 
    -0.04788554f, 0.09165908f, -0.01031213f, 0.01040248f, -0.04604912f, 0.16482383f, -0.11743750f, 0.19067590f, 
    0.02421443f, 0.02477036f, -0.04034935f, 0.00475092f, 0.03157641f, 0.03901914f, -0.05128375f, -0.03939302f, 
    -0.26224181f, 0.10405883f, -0.10310579f, -0.13149707f, 0.15528797f, 0.02811678f, 0.00983631f, -0.07148757f, 
    -0.02064827f, 0.07819534f, 0.04012936f, 0.06755923f, 0.38303581f, -0.20106921f, -0.14742200f, 0.13245700f, 
    -0.06693561f, 0.01385699f, -0.02002392f, -0.11731657f, -0.07013456f, 0.03982454f, -0.04880476f, -0.00507987f, 
    0.13681738f, 0.26922438f, 0.10097847f, 0.19583087f, -0.11380977f, 0.03675510f, 0.09590153f, 0.07101888f, 
    -0.00412316f, -0.02358393f, -0.03051876f, 0.03489363f, -0.07361282f, 0.06688741f, 0.19113062f, 0.13388841f, 
    -0.09945346f, -0.01254649f, -0.09974668f, 0.08126289f, -0.00194837f, -0.00575533f, 0.02445380f, -0.13181591f, 
    0.03336290f, 0.12455652f, 0.02277510f, 0.26193711f, 0.04846658f, -0.05426838f, -0.07568915f, -0.08728056f, 
    0.02820569f, 0.13819936f, 0.08401093f, 0.10984903f, 0.10683066f, -0.10223261f, -0.06300456f, 0.01922637f, 
    0.03684343f, 0.14161783f, -0.07739127f, -0.12924525f, 0.04388215f, 0.00814735f, -0.05917025f, -0.03390938f, 
    0.08606481f, 0.17043963f, -0.03879290f, -0.03011737f, 0.06335954f, -0.01759201f, -0.04502692f, 0.02162100f, 
    -0.01323117f, -0.03188788f, -0.00291209f, -0.06381572f, -0.29131472f, 0.22190057f, 0.11744940f, -0.08619992f, 
    0.03479141f, -0.05378660f, 0.05522461f, -0.04679130f, 0.04916561f, -0.03138520f, 0.06191409f, 0.02672287f, 
    -0.17623107f, 0.40198776f, -0.02270806f, -0.02160339f, 0.08700734f, -0.07032824f, 0.01487424f, -0.06677349f, 
    0.11842842f, 0.04761545f, -0.04042936f, -0.01091957f, 0.15424366f, -0.01350583f, 0.05309594f, -0.07222268f, 
    0.07963282f, 0.02379528f, 0.10056762f, -0.09860089f, -0.08972540f, -0.04443556f, -0.04624415f, 0.04937524f, 
    0.07012575f, -0.09299783f, 0.10413869f, 0.19632958f, 0.12786610f, 0.11841736f, 0.06099424f, 0.05857225f, 
    -0.05548348f, 0.10093523f, -0.06961657f, 0.02995475f, -0.20150654f, 0.00980236f, 0.16118288f, 0.03849286f, 
    -0.06182015f, -0.12906362f, 0.11218780f, -0.06410423f, -0.02649488f, 0.06731912f, 0.02805259f, -0.01666306f, 
    -0.21885310f, -0.08683877f, 0.13360994f, -0.11460514f, -0.06044999f, 0.09760357f, -0.00776511f, -0.05560708f, 
    0.05546436f, -0.00749797f, 0.03483452f, 0.01115965f, 0.15325920f, 0.18572141f, -0.12879859f, -0.16124094f, 
    0.09782448f, 0.06212732f, -0.03341529f, -0.01591942f, 0.11764356f, -0.09066094f, 0.05522692f, -0.02052362f, 
    -0.24793313f, -0.02072666f, 0.16771863f, -0.13989992f, -0.06001416f, 0.11975648f, 0.08448128f, -0.04257662f, 
    0.01476364f, -0.04170692f, -0.04283992f, 0.00949283f, -0.04610376f, -0.03555572f, 0.08057961f, 0.17818554f, 
    -0.00921965f, 0.06269817f, -0.00632336f, -0.01248764f, -0.02073548f, 0.08140883f, 0.02167038f, 0.12773912f, 
    0.15873668f, -0.12476885f, 0.12622929f, 0.09894111f, -0.03492491f, 0.01231953f, -0.13994917f, -0.11571953f, 
    0.05675102f, 0.02666633f, 0.09719320f, 0.05557173f, 0.00556558f, 0.01232340f, 0.02362873f, 0.27882355f, 
    0.17710288f, 0.16141768f, 0.08576041f, 0.07808493f, -0.07830288f, -0.04457524f, 0.06063693f, 0.04910875f, 
    0.15525286f, 0.12972595f, -0.02485310f, -0.02077227f, 0.01971800f, -0.03315925f, 0.03104852f, -0.02648814f, 
    0.17593370f, 0.04994506f, 0.00022843f, 0.12468385f, -0.30727151f, 0.25244811f, -0.07575768f, -0.04860481f, 
    -0.02214786f, 0.01389895f, 0.08782344f, -0.08059349f, 0.06376239f, -0.10411221f, 0.12186384f, -0.06106786f, 
    0.05138941f, 0.00560255f, -0.14521059f, -0.16141519f, -0.04053764f, -0.08664826f, -0.04991581f, 0.01224450f, 
    0.06633358f, -0.08496311f, 0.06049187f, -0.01500240f, -0.23468231f, 0.11014076f, 0.01915976f, -0.18871105f, 
    0.07297804f, -0.06477792f, 0.04375443f, 0.06325324f, -0.04644623f, 0.11906584f, 0.10708903f, -0.09533039f, 
    0.03216024f, 0.10545643f, 0.19907944f, -0.06522054f, 0.07729280f, 0.02634791f, -0.01834289f, -0.04516029f, 
    -0.10171728f, -0.09241457f, -0.03128505f, -0.00565689f, -0.18625076f, -0.00812723f, 0.03935044f, -0.06302153f, 
    -0.00799572f, 0.01419898f, 0.03284698f, -0.18135780f, -0.02033899f, 0.02495347f, 0.07069977f, 0.06594567f, 
    0.01926370f, -0.00979207f, 0.02090251f, 0.04428891f, 0.02334850f, -0.00013338f, 0.03623279f, 0.00463077f, 
    0.06349357f, -0.03502428f, 0.01388116f, -0.10764595f, -0.14857611f, -0.03408932f, -0.00780711f, 0.05947800f, 
    -0.11811130f, -0.06665773f, 0.11331960f, 0.01692245f, -0.01464616f, -0.06995218f, -0.01385569f, 0.07328949f, 
    0.03688431f, -0.14040904f, 0.23357038f, -0.02728839f, 0.03469452f, 0.05643181f, -0.04126799f, -0.01888516f, 
    0.06166325f, -0.08984196f, 0.04604566f, -0.07150555f, -0.45485860f, 0.08998369f, 0.20575078f, -0.00686409f, 
    0.11621371f, 0.07329035f, -0.05743361f, -0.05392478f, 0.01202873f, -0.00734771f, 0.01189307f, 0.04473686f, 
    -0.14330681f, -0.09920614f, -0.02460730f, -0.21588930f, 0.00194618f, 0.03975468f, -0.03404830f, -0.05688338f, 
    0.08689145f, 0.07138723f, -0.02582067f, 0.09828717f, 0.27085775f, -0.14761180f, 0.01770965f, -0.20028760f, 
    -0.00058556f, 0.05527506f, -0.01817578f, -0.04707344f, -0.05521696f, 0.06786022f, -0.02249066f, 0.11630914f, 
    -0.15954682f, 0.16212547f, -0.15005004f, -0.12521090f, 0.02382255f, 0.04109607f, 0.00307366f, 0.08671065f, 
    0.06075102f, -0.05457304f, 0.07296438f, 0.00676101f, 0.11501650f, -0.16384706f, 0.16103816f, -0.05069306f, 
    0.16100939f, 0.05727822f, 0.13509978f, 0.01360477f, 0.05195729f, -0.00183682f, 0.08635121f, 0.14028218f, 
    0.13975775f, 0.17848003f, 0.10272644f, -0.09360853f, -0.17246190f, -0.07072224f, -0.01171279f, 0.15756027f, 
    0.09760352f, -0.04388128f, -0.00360899f, 0.04394177f, -0.03203727f, 0.16247953f, -0.00670590f, -0.02674742f, 
    0.03967867f, -0.05484995f, 0.09987421f, 0.04850031f, 0.03104220f, -0.00345335f, 0.11260736f, -0.01900014f, 
    0.02783218f, -0.19308560f, 0.05705021f, -0.12049510f, 0.08504621f, 0.03874203f, 0.15195759f, 0.10767989f, 
    0.11845754f, 0.01784386f, 0.14909057f, 0.03571891f, 0.14074846f, -0.02230804f, -0.02671767f, -0.15700863f, 
    0.08961198f, -0.05053709f, 0.15770629f, 0.13579565f, 0.10369664f, 0.07886495f, 0.02442218f, 0.15309660f, 
    -0.09668639f, -0.14300393f, 0.02117087f, -0.19901814f, 0.02375264f, -0.06040278f, 0.10028846f, 0.02673265f, 
    0.04699960f, 0.11478929f, 0.00888184f, 0.08221748f, 0.14415225f, 0.14284371f, 0.10390478f, 0.21598391f, 
    -0.03283352f, 0.01347983f, -0.01181096f, 0.07202473f, 0.08425312f, 0.06614939f, 0.10412880f, 0.04126347f, 
    -0.01172437f, 0.06277236f, -0.13788176f, 0.08656029f, 0.01329513f, 0.07588300f, -0.00634529f, 0.30069545f, 
    0.13154200f, 0.01460980f, 0.04506633f, 0.15945908f, 0.10895267f, -0.25235653f, 0.12812388f, -0.08088899f, 
    0.01184911f, 0.11656397f, 0.08405628f, 0.00730589f, -0.00343340f, 0.06836011f, 0.01540066f, -0.01367843f, 
    0.18947294f, 0.03263740f, 0.04820006f, -0.12009206f, 0.08102258f, 0.00277824f, -0.01598250f, 0.12137458f, 
    0.01792559f, 0.10764969f, -0.01372920f, -0.03559766f, -0.26577878f, -0.07439504f, 0.12812498f, -0.02319176f, 
    -0.09212086f, 0.10492786f, 0.14720663f, -0.05753961f, -0.04513602f, 0.03533489f, -0.03868768f, -0.04691766f, 
    0.03401858f, -0.07753376f, -0.06922642f, 0.08950802f, 0.01804366f, 0.03816437f, 0.12780173f, -0.03736178f, 
    0.00116913f, 0.00377093f, 0.00577318f, 0.15962689f, -0.16766256f, -0.08949631f, 0.16484925f, -0.21466815f, 
    0.19144920f, 0.20366223f, 0.11173707f, -0.07362022f, -0.05050743f, -0.07398238f, 0.10708429f, 0.04869522f, 
    -0.08784542f, -0.01043910f, 0.17771694f, -0.05100419f, 0.15729380f, 0.08714779f, 0.06050875f, 0.06243549f, 
    0.19973381f, 0.02152533f, 0.08390003f, 0.08495130f, 0.21960115f, 0.15771382f, -0.09093442f, 0.00697159f, 
    0.02197704f, 0.06098603f, 0.05955270f, 0.11132973f, -0.03017848f, 0.01112332f, 0.11599739f, 0.05632962f, 
    -0.22791900f, 0.17360632f, 0.21927860f, -0.23260297f, -0.04840751f, 0.14146397f, 0.01817182f, 0.00307536f, 
    0.04865739f, -0.04420302f, -0.04959410f, -0.00130416f, -0.00867278f, -0.14842455f, -0.09617842f, 0.01154007f, 
    0.10720082f, 0.07472084f, 0.11875463f, 0.14955191f, 0.01708543f, 0.05793618f, -0.09644025f, -0.04016265f, 
    0.07068363f, -0.06791104f, 0.10417094f, 0.11742149f, 0.01533217f, 0.10553646f, 0.04128404f, 0.05880527f, 
    -0.06248816f, 0.07737032f, 0.01498940f, -0.04112238f, -0.05218615f, -0.04129403f, -0.07753990f, -0.08300868f, 
    -0.01851037f, -0.05582898f, -0.06273041f, 0.07070947f, 0.03309923f, 0.07009758f, 0.08123755f, 0.03371614f, 
    0.02138566f, -0.02080118f, 0.11330394f, 0.02258769f, 0.00437503f, 0.06482121f, 0.06611848f, 0.09166633f, 
    0.00893349f, 0.10412490f, 0.13082685f, 0.04204775f, -0.19799867f, -0.05245392f, 0.22389935f, -0.01888104f, 
    0.05661122f, -0.01845076f, -0.03071607f, 0.08982306f, -0.00761465f, 0.11754876f, 0.05409314f, -0.07583328f, 
    0.17212613f, 0.07128327f, -0.11291067f, 0.04787704f, 0.04153853f, 0.07290501f, -0.05549248f, 0.11844563f, 
    0.08841592f, 0.02029607f, -0.05281195f, -0.05712595f, -0.22492269f, -0.06541051f, 0.01794014f, -0.19826165f, 
    0.06453591f, 0.11875437f, 0.11281051f, 0.06276881f, -0.03706284f, -0.10320409f, 0.03463170f, 0.14966723f, 
    -0.02735174f, -0.09159333f, -0.00887852f, 0.20709404f, -0.06067727f, 0.17854762f, 0.01423464f, 0.10221642f, 
    0.04709436f, 0.14670704f, 0.05339911f, 0.21729466f, 0.20753944f, 0.20326723f, 0.20002592f, -0.09043496f, 
    -0.07071060f, -0.15299392f, -0.06462978f, 0.11773956f, 0.12920405f, 0.05227141f, -0.03115669f, 0.00924061f, 
    -0.13568771f, -0.25908595f, 0.17532198f, -0.14401674f, -0.01832589f, -0.05212750f, 0.18421376f, -0.06105798f, 
    0.04683992f, -0.08414952f, 0.12515523f, 0.22488783f, 0.02905613f, 0.07192291f, 0.13019510f, -0.07573103f, 
    0.09733023f, 0.12875471f, 0.02391810f, 0.05344499f, -0.09359735f, 0.04906155f, 0.08819109f, 0.07788997f, 
    -0.10678620f, 0.13882700f, -0.02366993f, -0.11147695f, 0.05307155f, 0.22183689f, 0.06956319f, 0.02258467f, 
    0.10413576f, 0.03286246f, -0.01337881f, -0.08387068f, 0.21848550f, 0.22111122f, 0.26691765f, 0.04400486f, 
    -0.12252616f, -0.03925378f, -0.02615675f, 0.02047858f, 0.02585110f, -0.02538998f, 0.01615915f, 0.00306348f, 
    0.04157901f, -0.05268976f, -0.05616865f, 0.02911023f, -0.05096543f, 0.02829089f, 0.01514632f, -0.00052899f, 
    -0.01874143f, 0.03649524f, -0.02574152f, -0.02008523f, 0.04271961f, -0.03643334f, -0.05028722f, 0.04026020f, 
    0.01463784f, -0.00563597f, 0.01475091f, -0.05014129f, 0.03771311f, 0.02023558f, 0.03804903f, -0.01269636f, 
    -0.00683562f, 0.01186886f, -0.02995894f, 0.01585438f, -0.02903579f, -0.05344646f, 0.03159542f, -0.04901310f, 
    -0.00677459f, -0.05002943f, -0.04692686f, -0.04060283f, 0.03743486f, 0.02272790f, -0.01347484f, 0.03287174f, 
    -0.01485257f, 0.01609637f, -0.02522883f, 0.02035163f, -0.01884768f, 0.02558738f, -0.01229659f, -0.00715409f, 
    0.04348309f, -0.00507164f, -0.04213990f, -0.01149758f, -0.03604745f, -0.02521677f, -0.04109299f, 0.04032587f, 
    -0.03588804f, 0.03726903f, -0.01380958f, -0.04890904f, -0.05666858f, 0.03525311f, -0.04227468f, 0.03999951f, 
    0.01697565f, -0.04626032f, 0.01591462f, -0.05295500f, -0.02978505f, 0.00359381f, -0.00493601f, -0.03814663f, 
    0.00713796f, -0.05054761f, -0.04785136f, -0.05098126f, -0.02031181f, -0.01988147f, -0.01537302f, 0.03738792f, 
    0.03306440f, 0.01143318f, 0.02141185f, 0.00629203f, 0.02339617f, -0.02649506f, 0.00479012f, -0.02443719f, 
    0.00891398f, 0.03328468f, -0.01064255f, -0.04931350f, 0.00876830f, 0.02250508f, 0.04300158f, 0.02357627f, 
    -0.02498591f, 0.00224224f, 0.00120344f, 0.00279579f, 0.04039695f, -0.05460695f, -0.04848963f, 0.00561595f, 
    -0.05582966f, -0.02745599f, -0.03902871f, -0.00614993f, 0.02815090f, -0.00747017f, 0.03793355f, -0.04623079f, 
    -0.00130626f, 0.03130393f, -0.04811936f, -0.04324035f, -0.01943893f, -0.03823763f, -0.04704132f, -0.03032888f, 
    0.03728441f, -0.03764306f, -0.01410919f, 0.00087724f, 0.04483175f, 0.02850401f, 0.02715792f, -0.02321834f, 
    -0.00609550f, 0.02609462f, 0.02829308f, -0.02907726f, -0.03967024f, -0.01785810f, -0.02299082f, -0.04122299f, 
    -0.02065744f, -0.04907992f, 0.01868634f, 0.03605737f, -0.00137806f, -0.04050714f, -0.03241470f, -0.01327210f, 
    -0.02584800f, -0.01861054f, 0.02843301f, -0.05224779f, 0.04386696f, -0.01429418f, 0.01507812f, -0.03238736f, 
    -0.04751717f, 0.00109475f, -0.01545668f, -0.01070634f, -0.05630512f, -0.04495234f, 0.02651046f, 0.01652837f, 
    -0.05011631f, -0.04981289f, -0.04656387f, 0.00583456f, 0.04274104f, -0.00594933f, 0.01125138f, 0.01489491f, 
    -0.01428678f, 0.02745032f, -0.02449509f, -0.02574475f, -0.01622835f, 0.04415609f, 0.04128852f, -0.00091144f, 
    0.04259688f, 0.03437149f, 0.00812982f, 0.04030030f, -0.00462494f, 0.01158241f, 0.02750523f, -0.01774668f, 
    0.04210336f, 0.02332543f, 0.01294024f, -0.04513380f, 0.02878619f, -0.03307264f, -0.01467771f, 0.04487201f, 
    -0.02861386f, 0.01500519f, -0.03837668f, 0.01096225f, 0.04099455f, 0.01151658f, -0.04487460f, 0.00620203f, 
    -0.03723775f, -0.00280190f, -0.02024198f, -0.04714207f, 0.02008043f, -0.01310185f, -0.02382423f, 0.00669346f, 
    0.00958323f, -0.00541649f, 0.01670486f, -0.03413692f, -0.02748152f, 0.03643596f, -0.00415769f, 0.04248973f, 
    -0.00354814f, -0.00816849f, -0.02654328f, 0.02422072f, 0.03897899f, -0.00901920f, 0.03983505f, -0.02634775f, 
    -0.00508255f, 0.03248871f, -0.04135233f, 0.02178429f, 0.01918173f, 0.01059281f, 0.04190763f, 0.02215089f, 
    -0.04910256f, -0.03676729f, 0.01911450f, -0.00540930f, 0.02893868f, -0.03893447f, 0.00243417f, 0.01252371f, 
    -0.02102228f, -0.01788994f, 0.04115314f, 0.01943949f, 0.02043374f, 0.00253023f, -0.01752889f, -0.04245057f, 
    0.02825592f, 0.03895864f, 0.04101560f, 0.03121908f, -0.05376502f, -0.02922199f, 0.01978464f, 0.00897822f, 
    -0.05265381f, -0.02951557f, 0.00682467f, -0.02503197f, -0.02511437f, 0.02244529f, -0.03561927f, -0.01147600f, 
    -0.04885111f, 0.02292862f, 0.01380665f, -0.00066815f, -0.02102875f, 0.02238184f, -0.02142862f, -0.03697230f, 
    -0.01354416f, -0.02117409f, 0.00401397f, 0.03416653f, -0.04723963f, 0.00394034f, 0.02413225f, 0.00718325f, 
    -0.03620855f, 0.01176852f, 0.00222416f, 0.00688596f, 0.00149693f, 0.01900771f, 0.03553127f, 0.01096634f, 
    0.03943508f, -0.02280155f, -0.02827593f, -0.05485282f, -0.02625877f, 0.02681674f, -0.04441873f, -0.04056757f, 
    -0.02017050f, -0.03341735f, -0.04590692f, -0.01847691f, 0.03216672f, -0.03705033f, 0.03110798f, -0.05564287f, 
    -0.00270734f, 0.00255059f, -0.05618956f, 0.03220919f, -0.03456088f, -0.04302970f, -0.04698463f, -0.05196935f, 
    -0.04296967f, -0.02738436f, -0.01074658f, -0.04287864f, -0.01704754f, -0.04952054f, 0.03575487f, -0.01959911f, 
    -0.00615499f, -0.00512405f, -0.05362276f, 0.03704849f, 0.00667374f, -0.01774531f, -0.02574129f, 0.03063565f, 
    -0.00056842f, 0.02194359f, 0.04013926f, 0.02681803f, 0.01739171f, -0.00836500f, -0.04956529f, -0.00353524f, 
    -0.04362285f, -0.03702540f, -0.02920882f, -0.04392382f, 0.02795377f, -0.02588688f, 0.02328740f, 0.00898634f, 
    -0.01294784f, -0.05299066f, 0.02323637f, -0.00296761f, -0.02945814f, -0.05092483f, 0.00439176f, 0.01369101f, 
    0.02602411f, 0.04108638f, -0.04701233f, -0.03934104f, 0.04746590f, 0.01079936f, -0.00226497f, -0.02685629f, 
    0.01302168f, -0.04390139f, -0.04426908f, -0.03222276f, -0.01621066f, -0.00224468f, 0.04217859f, 0.04142809f, 
    -0.00156524f, 0.00543705f, -0.01691586f, 0.02928822f, 0.04147060f, -0.01993007f, 0.02705424f, -0.01360849f, 
    -0.04497462f, -0.00964177f, 0.03346205f, -0.04062999f, -0.05271269f, 0.02952514f, 0.03560708f, -0.01730705f, 
    -0.01486826f, -0.04776478f, -0.00461414f, 0.01654116f, 0.02856156f, 0.03719668f, -0.04537946f, 0.00297217f, 
    0.02219418f, -0.01406161f, 0.00312816f, -0.02980626f, -0.02459522f, -0.03559252f, -0.00934204f, -0.04253235f, 
    0.02134436f, -0.01168459f, -0.02227525f, 0.01251004f, -0.03333683f, 0.00978948f, 0.00554489f, -0.00858136f, 
    -0.02703644f, -0.01967906f, 0.04185128f, 0.03898897f, -0.04124552f, -0.04258645f, -0.03974771f, 0.00091823f, 
    0.02263999f, -0.04955658f, -0.02877115f, -0.03315602f, 0.00077666f, -0.04046822f, 0.01457733f, 0.03845405f, 
    -0.03137397f, 0.01394990f, 0.01749011f, 0.03018465f, 0.02116389f, 0.00911908f, -0.00564958f, -0.00712459f, 
    -0.01860329f, 0.00055849f, -0.01492238f, -0.02550469f, 0.00308895f, -0.00900727f, -0.05524404f, 0.00817805f, 
    -0.03696695f, 0.02662345f, -0.05491969f, 0.03080905f, -0.02711820f, 0.03005721f, 0.02658810f, 0.03266907f, 
    -0.01690251f, 0.01157126f, -0.02945498f, -0.04090571f, -0.05417670f, 0.01732905f, 0.03937914f, -0.04371583f, 
    -0.04844362f, 0.03581649f, -0.01174485f, 0.02404955f, -0.00533020f, 0.01983107f, -0.02069547f, -0.03559647f, 
    0.04256424f, 0.04093268f, -0.02394782f, 0.01282234f, 0.00102275f, 0.00636102f, -0.03829650f, 0.00000217f, 
    0.00571492f, 0.04070926f, -0.04600384f, -0.00732816f, 0.01074654f, 0.00533300f, -0.00015126f, -0.02952118f, 
    0.00552045f, -0.00356256f, 0.02950295f, -0.03882058f, 0.02619242f, -0.04917630f, -0.04162524f, 0.01964384f, 
    -0.00307279f, 0.03112377f, -0.00324837f, -0.04415182f, -0.04870105f, 0.04150532f, -0.00755955f, -0.04005606f, 
    0.00663941f, 0.03636216f, -0.03361464f, -0.01336288f, 0.00591243f, -0.00670128f, -0.02423700f, 0.00756490f, 
    -0.02603104f, 0.02660718f, -0.02948844f, -0.04945364f, -0.05006175f, -0.00060970f, -0.03941554f, 0.01348254f, 
    -0.00112884f, 0.00437124f, 0.02632276f, 0.00270052f, -0.01207334f, 0.00786795f, -0.04057554f, 0.03296841f, 
    0.02331237f, -0.03826781f, 0.03240054f, 0.02086768f, 0.01367974f, -0.05615380f, -0.04177148f, -0.04816838f, 
    0.03319898f, -0.01155221f, 0.03706304f, 0.04250982f, 0.02705733f, -0.02281944f, -0.04865669f, -0.04392146f, 
    -0.02398126f, -0.02800969f, 0.02693568f, -0.01019769f, 0.00997088f, -0.05130772f, -0.01659485f, -0.01178378f, 
    -0.01890099f, -0.02244225f, 0.02132677f, 0.03185866f, 0.03016362f, 0.02228476f, -0.03170689f, -0.00492878f, 
    0.02060411f, -0.03700774f, 0.02874846f, -0.02298521f, 0.01214482f, 0.02840874f, -0.03353009f, -0.02643067f, 
    -0.01331793f, 0.00700279f, 0.02746285f, -0.00167071f, -0.04655112f, -0.02172545f, -0.03013420f, 0.01686170f, 
    -0.01522042f, -0.05246111f, -0.01729612f, 0.00542219f, 0.03605393f, 0.01599431f, -0.04643845f, -0.05507989f, 
    -0.02814241f, 0.00075093f, -0.03117212f, 0.01979308f, 0.04106751f, 0.02445369f, -0.04268975f, -0.00755216f, 
    -0.03896425f, -0.02831729f, 0.02822106f, -0.04208812f, 0.02072205f, -0.05006545f, 0.04020101f, -0.05839466f, 
    0.01387175f, -0.05141704f, 0.03487657f, -0.03262310f, -0.05637354f, -0.01060624f, -0.03798495f, -0.00822499f, 
    -0.00519814f, 0.04341063f, -0.04005256f, 0.03354842f, -0.04131296f, 0.01179174f, -0.02749810f, -0.02780178f, 
    -0.00578133f, -0.02813526f, 0.03021368f, 0.03593120f, 0.01047374f, 0.04100291f, 0.03191618f, -0.01157182f, 
    -0.01794384f, -0.02330669f, 0.02670207f, 0.04258819f, -0.03513060f, 0.00060775f, -0.00658785f, 0.01530329f, 
    0.01966395f, -0.02835525f, -0.02123825f, -0.05059078f, -0.02050469f, -0.03757623f, 0.02740735f, -0.00900048f, 
    0.04230936f, -0.02468801f, -0.05470182f, -0.02796951f, -0.00143551f, -0.04070660f, -0.03277354f, -0.02397223f, 
    -0.02738703f, 0.02028372f, 0.01398183f, -0.04292880f, -0.04965839f, -0.01719044f, 0.02827652f, -0.00642130f, 
    -0.02916090f, 0.02086327f, 0.00514301f, -0.03020741f, 0.00349567f, 0.00579193f, 0.00584740f, 0.01868203f, 
    -0.05163805f, 0.00012856f, 0.03126878f, -0.04060184f, -0.03247953f, -0.01838233f, 0.02360017f, 0.03230644f, 
    -0.04057734f, -0.02982994f, -0.03279867f, 0.00225253f, -0.05118321f, -0.03726617f, -0.01701807f, -0.06066053f, 
    0.01380599f, -0.04711526f, 0.02078078f, 0.01717431f, 0.03727574f, 0.01182636f, -0.04024009f, -0.05874709f, 
    0.02948924f, 0.03554362f, -0.02946890f, -0.00838468f, -0.00985866f, -0.03189057f, 0.04705958f, -0.01905353f, 
    0.03372278f, 0.04668441f, 0.03732071f, 0.00117374f, 0.02768618f, -0.03824947f, 0.03422342f, 0.02197763f, 
    -0.00778952f, 0.04020265f, -0.01294190f, -0.04110836f, 0.02347343f, 0.00404944f, 0.02097781f, -0.00747941f, 
    -0.04235706f, -0.02893455f, 0.01794972f, -0.02357169f, -0.02461245f, 0.03690499f, 0.00790466f, -0.02246344f, 
    -0.01225403f, -0.02253307f, 0.00628132f, 0.03363050f, 0.03853910f, -0.02591281f, -0.01936549f, -0.06066107f, 
    0.03719653f, -0.03627251f, -0.03538620f, 0.00690262f, 0.04012270f, 0.04600190f, 0.02038200f, -0.04122872f, 
    0.03464613f, -0.02312740f, -0.04265394f, -0.02508878f, -0.04156541f, 0.01828906f, -0.04523930f, 0.02881436f, 
    -0.01085259f, -0.00676563f, -0.00697780f, 0.00035335f, -0.01399924f, 0.01543344f, 0.03264867f, 0.01709392f, 
    -0.02958694f, -0.00886916f, 0.01776183f, 0.01769206f, -0.00027991f, -0.01571547f, -0.01239339f, -0.05368949f, 
    -0.02421540f, 0.02875664f, -0.03410461f, 0.02750373f, 0.03080000f, 0.00018993f, 0.00403705f, 0.03672562f, 
    0.03355574f, 0.01432983f, 0.02281077f, -0.00566626f, -0.01235528f, 0.00112132f, -0.03292275f, 0.04692690f, 
    0.03284111f, 0.01619626f, -0.03507500f, -0.01380622f, -0.01026737f, -0.01979317f, -0.01965472f, 0.02650685f, 
    -0.00447368f, -0.05258574f, -0.04968503f, 0.00241071f, 0.02515790f, 0.02736784f, -0.04919100f, 0.04745626f, 
    -0.01399671f, 0.00732837f, -0.04326683f, 0.02185728f, 0.01161723f, -0.03135040f, -0.01250738f, 0.04285444f, 
    0.03545417f, 0.01896719f, 0.01905430f, -0.02704535f, 0.00701504f, 0.01841068f, -0.00151268f, -0.00248019f, 
    -0.02495226f, 0.00163011f, -0.00329255f, -0.03737956f, -0.03677469f, 0.00101214f, 0.01726021f, 0.00160682f, 
    -0.00435544f, -0.01239399f, 0.04055371f, 0.00992281f, -0.05507163f, -0.00879481f, -0.02505480f, -0.00468570f, 
    0.00960425f, -0.00757610f, -0.03325495f, -0.01927132f, 0.00089280f, 0.01560729f, -0.01810687f, -0.05563721f, 
    0.01805413f, -0.05896862f, 0.01070349f, 0.01268039f, -0.04840440f, 0.03193187f, 0.03598232f, -0.04711600f, 
    0.00007087f, -0.04740112f, -0.00863313f, 0.00389993f, -0.02927051f, -0.00297546f, 0.01534777f, 0.02804924f, 
    0.02456435f, 0.02513933f, -0.05078247f, -0.03434614f, 0.02923357f, -0.01855164f, 0.03702731f, 0.01370117f, 
    -0.03826030f, -0.02207876f, -0.00313084f, 0.03605989f, -0.03983202f, 0.00960069f, -0.05453810f, -0.03540836f, 
    0.03386900f, -0.04105840f, 0.03984078f, 0.00989675f, -0.05198497f, -0.01251950f, -0.01498375f, 0.01235493f, 
    -0.02025185f, -0.00619342f, 0.00250305f, -0.05540555f, 0.00265230f, 0.02850643f, -0.01016668f, 0.01324584f, 
    -0.00145484f, 0.01880881f, 0.00111073f, -0.04910431f, -0.03999111f, -0.05889448f, -0.05553779f, -0.00693900f, 
    0.03514052f, 0.00260398f, -0.00493962f, -0.00004952f, -0.04731741f, 0.02850465f, -0.00101896f, 0.03030192f, 
    -0.00430142f, -0.03495023f, -0.03443184f, -0.01390584f, -0.02284832f, -0.03453324f, -0.03388955f, 0.00980448f, 
    -0.03588751f, -0.00620126f, 0.04083895f, -0.05699257f, -0.03902709f, -0.00499057f, 0.01328749f, -0.04392027f, 
    0.03070430f, -0.01361639f, 0.02214246f, 0.02837094f, 0.03828861f, 0.01107617f, -0.05377487f, -0.00966440f, 
    -0.04318383f, -0.01373732f, 0.02258057f, -0.01184146f, 0.00907541f, 0.02198010f, -0.03053133f, -0.03104560f, 
    -0.00411541f, 0.01140246f, 0.03367501f, -0.00422107f, 0.03656780f, 0.04048676f, 0.03291408f, 0.02255922f, 
    0.03407208f, -0.05566695f, 0.00874219f, -0.05345062f, -0.03434529f, 0.01162066f, -0.04835455f, -0.03164302f, 
    -0.03142172f, 0.02935961f, -0.03095575f, 0.03885137f, -0.01404629f, -0.05096762f, -0.03278064f, -0.03165568f, 
    0.00738989f, 0.03195247f, -0.04540636f, 0.03183799f, -0.05740346f, 0.01970956f, -0.03948415f, -0.02521428f, 
    0.02820599f, -0.04595526f, -0.01578736f, -0.00393155f, 0.03540826f, -0.02496680f, -0.01680946f, -0.00389081f, 
    -0.04452612f, 0.00683190f, -0.02214967f, -0.02960265f, -0.00569103f, 0.02684905f, -0.00184667f, 0.04134203f, 
    0.03211248f, -0.05101918f, -0.03225905f, 0.03298438f, -0.00899753f, 0.02303545f, 0.02042852f, -0.00372606f, 
    -0.01482931f, -0.00824278f, 0.01109321f, -0.00117499f, -0.03137905f, -0.03808659f, -0.04256091f, 0.03023827f, 
    -0.03333019f, -0.04811382f, -0.05061164f, 0.03117918f, -0.04338958f, 0.03219900f, 0.00488436f, 0.02586583f, 
    -0.03748585f, -0.00054679f, -0.05756061f, -0.03641675f, 0.00093909f, -0.01023688f, -0.00713196f, 0.03438515f, 
    -0.03112861f, -0.02398111f, -0.04055125f, -0.05871713f, 0.02402462f, 0.03434379f, -0.04307723f, 0.02772547f, 
    -0.05758457f, 0.00628645f, -0.01115829f, -0.04728445f, -0.00904381f, -0.03561464f, 0.03901633f, -0.03297475f, 
    0.03970833f, -0.01832581f, -0.03498944f, -0.01996018f, -0.05335427f, 0.01022046f, 0.01181919f, -0.02734286f, 
    0.01386608f, -0.02876415f, -0.04380155f, 0.01270135f, 0.02265290f, 0.02558884f, -0.05566635f, -0.00993745f, 
    -0.04715924f, 0.00091156f, 0.03351203f, 0.01355669f, -0.02998349f, -0.03300473f, -0.00077632f, -0.05056160f, 
    0.02720325f, 0.01951517f, 0.04560443f, -0.03201580f, 0.02495574f, -0.04937314f, -0.00868653f, -0.02266607f, 
    0.00809749f, 0.00934827f, 0.01840988f, -0.03335772f, -0.01098564f, -0.04311217f, 0.04508699f, 0.01663929f, 
    -0.00145060f, -0.01603896f, 0.02254358f, -0.03781088f, -0.02089397f, -0.02814417f, -0.03500940f, -0.04335733f, 
    0.03339439f, -0.00739208f, -0.05852013f, 0.02548219f, -0.04270886f, -0.01419871f, -0.05105410f, -0.00882429f, 
    0.02641121f, -0.02042201f, -0.00268189f, 0.00189816f, -0.00159112f, -0.05829964f, 0.02138778f, 0.02233792f, 
    -0.03599054f, -0.02162586f, 0.00044860f, -0.05364301f, -0.04244087f, -0.02877023f, 0.03159226f, -0.01016750f, 
    0.02515982f, -0.00980612f, -0.00418728f, 0.01984666f, 0.03643331f, 0.03465787f, -0.03488538f, -0.01426251f, 
    -0.00337207f, 0.03850989f, -0.01622763f, -0.01818639f, 0.01712338f, -0.03391658f, -0.03155506f, -0.05598658f, 
    0.01189003f, -0.02097411f, 0.01500710f, -0.03908479f, -0.01750135f, 0.03566546f, -0.03971166f, 0.04095931f, 
    0.00917320f, -0.05426784f, -0.01015970f, -0.03278268f, -0.03812092f, 0.02553447f, -0.04001841f, -0.01580741f, 
    -0.04520791f, -0.02919066f, 0.03392123f, -0.00559631f, 0.03554557f, 0.00887708f, 0.00207718f, -0.02176365f, 
    0.01393030f, 0.01613900f, -0.00770318f, -0.03292557f, 0.01937204f, 0.03939090f, 0.00462516f, 0.01967351f, 
    0.04104625f, 0.02390058f, -0.04961608f, 0.00407739f, -0.01695877f, 0.01256002f, 0.01924454f, 0.00726984f, 
    -0.00687654f, 0.01842307f, -0.03628880f, -0.05012365f, 0.00757439f, -0.03595840f, -0.01774450f, -0.01427713f, 
    -0.01626157f, 0.01908109f, -0.03198509f, -0.03342224f, -0.00253115f, 0.01020103f, 0.03779588f, -0.05207189f, 
    0.02380661f, -0.05403420f, -0.03651707f, -0.02644257f, -0.03005322f, 0.02097773f, -0.00406510f, 0.00370639f, 
    0.01845300f, -0.01979432f, -0.03407063f, -0.03315460f, -0.02426142f, 0.00615985f, 0.02714084f, 0.01607127f, 
    -0.02346842f, 0.02742213f, -0.02973929f, 0.01872286f, 0.03175329f, -0.01356636f, -0.03283439f, -0.04332709f, 
    -0.05436415f, 0.04167605f, -0.04086300f, -0.02669312f, 0.03836000f, -0.04626179f, 0.03785481f, 0.01027602f, 
    -0.02846724f, 0.02464760f, -0.03710207f, 0.01179138f, 0.01603527f, -0.04845577f, -0.00169425f, -0.03113445f, 
    0.02955721f, -0.04413337f, 0.04319337f, 0.03614281f, 0.00663804f, -0.01729180f, -0.02977790f, 0.00015194f, 
    -0.00716913f, 0.02486671f, -0.03075259f, -0.04069658f, -0.04981117f, 0.03737019f, -0.05872928f, -0.04108141f, 
    -0.00491977f, -0.04250562f, 0.02824089f, -0.04826838f, -0.05164741f, 0.04080905f, -0.00019030f, 0.02007285f, 
    -0.00675275f, -0.00842566f, 0.02431185f, -0.03018345f, -0.02806206f, -0.00207876f, 0.03862808f, -0.04644722f, 
    0.02515058f, -0.01309444f, -0.00878268f, -0.03159150f, 0.01569758f, -0.01841035f, -0.04843925f, -0.00721684f, 
    0.00117117f, 0.00207314f, 0.03591039f, 0.03236580f, -0.02191770f, 0.04424712f, 0.01185629f, -0.01205246f, 
    0.04538388f, 0.02390108f, 0.04413635f, -0.06026307f, -0.01073453f, 0.02867770f, 0.02179298f, 0.03695961f, 
    0.02247800f, -0.04723152f, 0.03130068f, -0.02482292f, -0.02705462f, -0.06100157f, 0.02707886f, 0.00407691f, 
    -0.02112233f, 0.00972275f, -0.00661735f, 0.01645153f, -0.00760024f, -0.01163298f, -0.03783112f, -0.02275702f, 
    -0.01798704f, -0.02904665f, 0.00949412f, -0.04149619f, 0.02853029f, 0.01283354f, 0.02019364f, -0.02268555f, 
    -0.00023361f, -0.05172937f, 0.01871815f, -0.01967608f, 0.02124501f, 0.02959752f, 0.01383053f, 0.05247425f, 
    -0.01807999f, 0.04685896f, 0.02322040f, -0.04716406f, -0.03228715f, -0.04746509f, 0.00872746f, -0.01063688f, 
    0.01755633f, 0.03341518f, -0.05926857f, -0.05079433f, 0.02987028f, -0.05479044f, -0.04731403f, -0.00829929f, 
    -0.02493519f, -0.02278239f, -0.02350544f, -0.00043589f, 0.02934875f, 0.00133042f, 0.04035178f, 0.03853159f, 
    0.04762091f, 0.01797899f, -0.04693370f, -0.02505953f, 0.02675215f, 0.02350780f, -0.03239919f, 0.03873821f, 
    -0.01267237f, -0.02563951f, 0.03890155f, 0.00706102f, -0.00701532f, -0.04454136f, 0.00353366f, 0.01577392f, 
    -0.01473003f, -0.02120448f, -0.05171816f, 0.01325207f, -0.05516902f, 0.02729899f, -0.03098284f, -0.00980604f, 
    0.00946372f, -0.00503001f, 0.03359196f, -0.01485113f, 0.01419567f, 0.01958113f, -0.00623392f, -0.03416843f, 
    -0.02870393f, 0.05084809f, -0.02161511f, -0.04297247f, -0.05381291f, -0.00179264f, 0.03938740f, -0.00362247f, 
    0.01383336f, 0.04428371f, -0.02499085f, -0.00383735f, -0.00877950f, -0.03079672f, 0.02666575f, -0.00983463f, 
    0.01190581f, -0.00620246f, 0.02419064f, 0.03948241f, 0.02722405f, 0.02264189f, -0.06299610f, 0.00491191f, 
    -0.00019881f, -0.02496815f, -0.05420465f, 0.00398871f, -0.01324882f, 0.02507869f, 0.02951640f, -0.03186182f, 
    -0.02599966f, 0.00204853f, -0.05529181f, -0.05175268f, 0.00013574f, 0.00981239f, -0.03685272f, 0.01353892f, 
    -0.01627229f, -0.00145527f, 0.01664861f, 0.02770559f, -0.03763026f, -0.02002622f, -0.03620831f, -0.03902157f, 
    -0.00335511f, -0.02667058f, 0.00955076f, -0.05605752f, -0.04198864f, -0.00684150f, 0.00563360f, -0.04014428f, 
    0.01198756f, -0.01680910f, 0.03210140f, -0.01089223f, -0.02114815f, -0.01170013f, -0.01879677f, 0.01690411f, 
    -0.03802484f, -0.00282570f, -0.01008996f, -0.03390430f, -0.02728266f, -0.03664472f, 0.03589949f, -0.04768013f, 
    0.03821173f, 0.00669004f, 0.00767326f, -0.04029258f, 0.03150698f, -0.00682165f, -0.00533199f, 0.00304890f, 
    -0.00171890f, 0.03754514f, -0.02485850f, -0.03989753f, -0.00319755f, -0.01981270f, -0.05014178f, 0.02314850f, 
    0.01606932f, 0.03032516f, -0.03211017f, 0.04334163f, 0.04208053f, 0.04047164f, 0.02218705f, -0.00305453f, 
    -0.04276223f, -0.00384384f, 0.03067498f, -0.02019718f, 0.04394209f, -0.01975284f, -0.02284770f, -0.04875075f, 
    -0.03558172f, -0.01873401f, -0.03826248f, -0.02255251f, -0.03397357f, -0.04130972f, 0.00215988f, -0.01435952f, 
    -0.00872173f, 0.03863994f, -0.03804219f, -0.00399947f, -0.02512018f, -0.01204097f, -0.05510132f, 0.01504143f, 
    0.04961430f, 0.02836906f, -0.02744184f, -0.01561838f, -0.02776845f, -0.05868869f, -0.00179445f, 0.03541395f, 
    0.00762845f, -0.02429862f, -0.03213793f, 0.03086897f, -0.01873854f, -0.02756319f, 0.00881160f, 0.04158599f, 
    -0.00405695f, 0.02737113f, -0.03426054f, -0.05114308f, -0.02619004f, 0.00106542f, -0.01256445f, 0.00120330f, 
    -0.03289200f, 0.04348361f, 0.01979176f, 0.01115709f, -0.01731351f, -0.00222243f, 0.02931883f, -0.04455053f, 
    0.04076659f, -0.01060631f, 0.02199307f, 0.04127431f, 0.00536996f, -0.02229830f, -0.03095568f, 0.02612086f, 
    -0.06349912f, 0.02940307f, 0.02080999f, 0.02438996f, 0.01939149f, -0.04307699f, 0.01336868f, -0.03361656f, 
    0.03430433f, -0.01512577f, -0.01976059f, -0.02604667f, 0.02507013f, 0.01234033f, 0.01627188f, -0.06462299f, 
    -0.01323921f, 0.03820896f, 0.02725886f, -0.03427044f, -0.01478790f, -0.04035604f, -0.04581584f, 0.04663337f, 
    -0.05483210f, -0.00243566f, 0.05302791f, 0.00120958f, -0.00083023f, 0.01160460f, 0.03314074f, -0.01002915f, 
    -0.03552809f, -0.03966859f, 0.00942559f, -0.00323897f, 0.01427483f, -0.03508775f, 0.03439252f, 0.01612850f, 
    -0.01598180f, -0.03902406f, -0.00633842f, -0.04009704f, 0.04098513f, -0.02372243f, -0.01327981f, -0.02116029f, 
    -0.02617870f, -0.00924290f, -0.03865988f, 0.00938730f, -0.04186791f, -0.00146059f, -0.04128113f, 0.02320688f, 
    0.02784447f, -0.01434227f, -0.04104635f, 0.01441965f, -0.02188647f, -0.00769182f, -0.01281108f, 0.00600686f, 
    0.03533763f, -0.01349633f, -0.00941704f, -0.04872353f, 0.03583414f, -0.00469005f, 0.00174165f, -0.03428338f, 
    -0.01879879f, -0.01668461f, -0.05321416f, -0.04096208f, 0.01781311f, 0.00251050f, -0.04910091f, -0.04251070f, 
    -0.00145730f, 0.00322678f, -0.01413698f, 0.03175164f, 0.01887599f, 0.01562574f, 0.04386546f, 0.03962483f, 
    -0.01384555f, 0.02872027f, 0.00624535f, -0.04951937f, 0.01943773f, 0.00943378f, -0.01730711f, -0.02266454f, 
    0.04415977f, -0.04080216f, -0.05015174f, 0.02547234f, 0.00073075f, -0.04688145f, 0.01962044f, -0.00766012f, 
    -0.02227286f, 0.01650268f, 0.02747200f, -0.01821664f, -0.00519485f, 0.04128646f, -0.03762696f, 0.02316668f, 
    -0.00674986f, -0.04844892f, 0.00041539f, -0.04454577f, 0.04021345f, 0.01068001f, -0.00262517f, 0.01443531f, 
    0.01896786f, 0.04032246f, 0.00636017f, 0.00701991f, 0.04189729f, -0.01727051f, -0.02596829f, -0.04213120f, 
    0.03970042f, -0.03576007f, 0.03487719f, -0.04673774f, 0.01970013f, -0.02180209f, 0.01937727f, 0.02753154f, 
    -0.02408403f, 0.02299370f, 0.04551540f, 0.00044403f, -0.00865227f, 0.02405277f, -0.00315795f, 0.03239388f, 
    0.00619954f, -0.00310410f, 0.02183189f, 0.04396018f, 0.00066108f, 0.00975889f, 0.00893871f, -0.01146343f, 
    0.04601511f, -0.00780191f, 0.00317126f, -0.02268230f, -0.02168330f, -0.02111462f, 0.03265369f, 0.04638031f, 
    0.03309294f, -0.02487496f, 0.00647939f, -0.02281170f, -0.04275272f, 0.02569848f, 0.01076898f, -0.01868676f, 
    -0.00486032f, 0.02044958f, -0.03001848f, -0.00119595f, 0.03256174f, 0.01464756f, -0.03199393f, -0.04880273f, 
    -0.05000072f, 0.02142181f, -0.03007220f, -0.02969093f, 0.01610017f, 0.02903064f, -0.03204677f, -0.01482853f, 
    -0.05429072f, 0.03685888f, -0.00992239f, -0.04820134f, 0.04431196f, 0.04090619f, -0.02621289f, 0.02181669f, 
    -0.00271918f, -0.00187615f, 0.01561711f, -0.02124852f, 0.01534163f, -0.00758970f, -0.00924179f, 0.01740397f, 
    -0.01049824f, -0.00037754f, -0.04235405f, -0.00363192f, -0.00724244f, -0.03203440f, 0.04692401f, -0.05029486f, 
    -0.02622567f, -0.01778267f, 0.01227631f, -0.01007808f, 0.01885355f, 0.02282378f, -0.02632752f, -0.01603405f, 
    0.03148041f, 0.01864155f, -0.04626453f, -0.05311270f, 0.00080822f, -0.05370028f, -0.03863115f, -0.02591483f, 
    0.03835896f, 0.02085148f, -0.03798053f, -0.05171523f, -0.03574698f, -0.02497734f, -0.02865855f, 0.03674422f, 
    -0.01040884f, 0.03905261f, -0.04077937f, 0.02014395f, 0.00727942f, 0.04020248f, -0.00656558f, -0.04596136f, 
    -0.04038262f, -0.04091848f, 0.01143724f, 0.04236161f, -0.04287546f, -0.01021793f, -0.01097095f, -0.04585499f, 
    0.03773963f, -0.05313950f, 0.01173991f, 0.03760806f, -0.03162608f, -0.04905864f, 0.03497766f, -0.05116720f, 
    0.03094074f, 0.02774660f, 0.04500190f, -0.04870903f, 0.01645035f, -0.05426067f, -0.04413162f, -0.02633695f, 
    -0.02208541f, 0.03009962f, 0.04451906f, -0.00348430f, 0.03223605f, -0.04314360f, -0.00031978f, 0.01239007f, 
    -0.04406893f, -0.04613782f, -0.01861126f, -0.01166050f, 0.00457401f, -0.00544345f, -0.02572783f, -0.05218627f, 
    -0.01686263f, 0.04372820f, -0.04431054f, -0.01444691f, -0.02962123f, -0.00980570f, -0.02599004f, -0.04390303f, 
    0.02256606f, -0.03901552f, 0.02500643f, -0.03980420f, -0.04610334f, -0.02879851f, 0.03087687f, 0.03261959f, 
    -0.02502242f, -0.01361637f, 0.03030849f, 0.00684991f, 0.03143097f, -0.03904061f, 0.01602077f, 0.01725825f, 
    -0.05120199f, 0.03897497f, -0.00203444f, -0.00107632f, -0.01124002f, 0.02497624f, -0.03603534f, -0.02807647f, 
    -0.00790856f, -0.03274098f, 0.03988671f, 0.03828226f, -0.00060330f, 0.01135814f, -0.02126449f, -0.03812910f, 
    -0.00247195f, 0.01522080f, 0.02683000f, -0.00411453f, 0.01169482f, -0.01251558f, -0.04740898f, -0.03605887f, 
    -0.02483036f, -0.01389748f, -0.00954411f, -0.01951952f, -0.04017308f, 0.00265603f, 0.03443629f, -0.02359168f, 
    -0.01811127f, -0.03869547f, -0.01650698f, 0.00592761f, -0.04914116f, -0.01165613f, -0.00630900f, -0.00026125f, 
    0.00804126f, -0.01899958f, -0.04585781f, 0.02392537f, -0.02811319f, 0.00652767f, -0.04246581f, -0.01208459f, 
    0.04056624f, -0.03413771f, 0.03603610f, -0.00969683f, 0.01787654f, 0.03706225f, 0.02158129f, 0.02932022f, 
    0.03983910f, -0.03814618f, 0.00565256f, -0.02261207f, 0.04323626f, -0.05343517f, -0.01968424f, -0.00061701f, 
    0.03489569f, 0.03402617f, 0.01574529f, -0.03994974f, 0.03523558f, -0.01422767f, 0.00302062f, 0.04622395f, 
    0.03710062f, -0.05344836f, -0.04587754f, 0.04609780f, -0.03446552f, -0.01594794f, 0.00256530f, -0.02719664f, 
    -0.00267543f, -0.04734066f, -0.02985751f, 0.03038662f, 0.03577975f, 0.00275186f, -0.03865634f, -0.00893497f, 
    -0.04164594f, 0.03356897f, -0.03588239f, -0.00473126f, 0.01314941f, -0.03235894f, -0.00920161f, -0.02180697f, 
    -0.02302887f, 0.02455253f, 0.01282631f, -0.03245707f, -0.04001391f, -0.01553924f, -0.05122365f, 0.03429731f, 
    0.04543800f, 0.04157411f, 0.02625206f, 0.04084053f, -0.00233948f, -0.04735472f, 0.03722116f, -0.04552099f, 
    -0.14851102f, -0.08304092f, -0.01287233f, 0.03499397f, -0.03400206f, 0.06436612f, 0.03923169f, 0.03199492f, 
    0.03157150f, 0.12380373f, 0.08059011f, -0.07048199f, -0.25429821f, -0.19629796f, 0.18496038f, -0.04987144f, 
    0.15019061f, -0.07182689f, -0.06542871f, 0.15559788f, 0.09918057f, -0.17476371f, -0.09182911f, 0.04902242f, 
    0.03519540f, -0.01956176f, 0.16738127f, 0.08233762f, 0.11651485f, -0.00864281f, 0.01960202f, -0.06382189f, 
    0.00652361f, 0.00742812f, -0.08940184f, -0.00593915f, -0.06938862f, 0.27543131f, -0.11005008f, 0.17594212f, 
    0.00498111f, 0.01335931f, -0.06947164f, 0.06806223f, -0.03538684f, 0.03277272f, 0.06870000f, -0.01458739f, 
    -0.01136215f, -0.07072642f, 0.03542637f, 0.33328006f, 0.12191295f, 0.11071850f, 0.07853288f, -0.07685857f, 
    -0.06673708f, -0.00988043f, -0.00907269f, -0.00942477f, -0.01849343f, -0.11229882f, -0.00111577f, 0.00628202f, 
    0.03535713f, 0.11231833f, 0.05589532f, 0.15205409f, 0.13799581f, 0.14814751f, 0.08208571f, -0.11885021f, 
    0.02647852f, 0.01712924f, 0.16364828f, 0.00983080f, -0.05421314f, 0.00570887f, -0.09851082f, 0.16995659f, 
    -0.05093132f, 0.06203932f, -0.03368095f, 0.00777382f, -0.03342064f, 0.00446197f, -0.05383210f, 0.10629716f, 
    0.06573480f, -0.07065666f, 0.02951088f, 0.05555497f, 0.01523027f, 0.05139749f, -0.02473638f, -0.03516415f, 
    -0.17478989f, -0.13448869f, 0.09286202f, -0.13456605f, 0.18031842f, 0.10586780f, -0.07576089f, 0.05158890f, 
    -0.10143887f, -0.11645218f, 0.02240285f, -0.01063849f, -0.21708025f, 0.00791584f, 0.13013113f, 0.18478768f, 
    -0.09318791f, 0.09645690f, -0.00096881f, 0.07551119f, 0.05319817f, -0.03963931f, 0.03614852f, 0.05317968f, 
    -0.04922009f, 0.31029382f, -0.03142329f, 0.06545383f, 0.12188782f, -0.09330061f, 0.06698408f, -0.00239036f, 
    -0.00871114f, 0.06354515f, 0.07948621f, 0.05954989f, 0.10699550f, 0.15318237f, 0.23362476f, -0.09929693f, 
    -0.02107388f, -0.06820240f, 0.02473919f, 0.08774760f, -0.11939122f, -0.00556039f, -0.00495757f, -0.03154349f, 
    0.27257231f, 0.02053860f, -0.07664690f, -0.01945170f, -0.04194494f, 0.04039408f, 0.01744623f, 0.02490710f, 
    0.04855382f, -0.06335524f, 0.00715609f, -0.01611401f, 0.04804948f, -0.06722333f, 0.17026818f, -0.27176571f, 
    -0.08838764f, -0.03889734f, -0.12833615f, 0.07927623f, 0.17484707f, -0.09950300f, 0.13320476f, 0.07192714f, 
    0.01361246f, -0.00427128f, -0.13407354f, 0.01093404f, -0.02469729f, 0.05231071f, 0.11250646f, 0.05205796f, 
    0.08543611f, -0.02042301f, 0.03135547f, 0.02685790f, 0.05703225f, -0.04486421f, 0.00198091f, -0.06259518f, 
    0.00574815f, -0.01795083f, 0.09166501f, 0.00141941f, 0.00997636f, 0.00631234f, -0.10006072f, 0.05879812f, 
    0.46251261f, 0.09222002f, 0.04755552f, 0.00172693f, 0.03705979f, -0.05415091f, -0.01152755f, -0.00306166f, 
    -0.17841919f, 0.00718956f, -0.05359719f, -0.02526860f, -0.19610944f, 0.07558678f, -0.01912538f, 0.04612862f, 
    0.02110481f, 0.00482939f, -0.00516786f, -0.09958449f, -0.05356071f, 0.13277492f, -0.04572191f, 0.08990959f, 
    0.25383911f, 0.00454881f, -0.08372248f, 0.07164099f, -0.04349764f, -0.03597199f, 0.07129639f, 0.01347651f, 
    -0.00717707f, -0.08690990f, 0.03528688f, -0.03558654f, -0.07452898f, -0.09408113f, -0.11333166f, 0.07781170f, 
    -0.00046080f, -0.01635290f, 0.00618200f, 0.00773384f, 0.07677057f, -0.04149552f, -0.00836221f, 0.01978581f, 
    -0.17704339f, -0.03168727f, 0.06672041f, 0.01536002f, -0.14937758f, 0.12012862f, 0.02373288f, -0.02186191f, 
    0.05766633f, -0.02051864f, -0.08306982f, -0.00066979f, 0.08634263f, -0.13771898f, -0.10557689f, 0.17207161f, 
    -0.05202087f, -0.08571099f, -0.03014928f, 0.25833681f, 0.05280414f, -0.03409932f, 0.06530526f, 0.02523149f, 
    0.20854452f, 0.21569577f, -0.11995511f, 0.00223952f, 0.07282241f, 0.09077021f, -0.04078058f, -0.01322690f, 
    -0.03728956f, -0.06156475f, -0.00780758f, -0.04703528f, 0.44202128f, 0.19995672f, 0.08218159f, 0.04465982f, 
    -0.06738646f, -0.02786768f, 0.05948275f, -0.12599954f, -0.06453475f, -0.03214752f, -0.03854858f, 0.06568298f, 
    0.06083273f, 0.11287480f, 0.07339146f, -0.14652616f, -0.04370365f, 0.07451338f, 0.06511480f, -0.02661682f, 
    0.02911203f, -0.01982121f, 0.07478575f, 0.03337601f, 0.04108115f, -0.02210846f, 0.03073965f, -0.00752616f, 
    -0.11350310f, 0.05594494f, 0.10164290f, -0.01192244f, -0.01418693f, -0.02104589f, -0.04920591f, 0.00419625f, 
    0.13412867f, -0.06163169f, -0.10843925f, 0.13003697f, -0.02553986f, -0.04082449f, 0.01453815f, -0.05317798f, 
    0.05417521f, 0.02022035f, 0.05174971f, -0.01542118f, 0.01423579f, -0.12375174f, 0.01892597f, 0.24185121f, 
    0.04802895f, 0.04809728f, 0.10682505f, -0.04688930f, 0.01132752f, -0.04836007f, -0.05039124f, -0.03563331f, 
    0.30617100f, 0.08608319f, 0.00596116f, -0.05885915f, -0.05134881f, 0.00333822f, 0.06934854f, 0.07829665f, 
    -0.05774521f, 0.12489715f, -0.09448654f, 0.06681505f, 0.05084846f, 0.14517184f, -0.12347332f, -0.09454856f, 
    -0.08851867f, 0.00949603f, -0.04308372f, 0.06157880f, 0.00473096f, 0.14335029f, 0.13875285f, 0.01529227f, 
    -0.11632848f, -0.09459165f, -0.23560357f, 0.00988328f, -0.07140663f, -0.03815541f, -0.09590172f, 0.07130061f, 
    -0.00317231f, 0.09089795f, 0.03403829f, -0.02132735f, 0.30784771f, -0.24197012f, -0.15401512f, 0.22109520f, 
    -0.01332908f, 0.08821145f, 0.11427727f, -0.12709828f, -0.08361503f, -0.07270897f, -0.03153095f, -0.04862276f, 
    0.20903283f, 0.18866342f, -0.00824873f, 0.06494411f, 0.02224070f, 0.04805363f, -0.04761482f, 0.16778132f, 
    -0.09497465f, -0.03616005f, -0.09835348f, 0.04136114f, -0.23042485f, 0.16666509f, -0.03988829f, -0.08402243f, 
    0.03841669f, -0.00336637f, 0.08060879f, -0.01084114f, 0.05008408f, -0.04390012f, 0.03991345f, -0.00798489f, 
    -0.09479758f, -0.19044696f, 0.17808251f, 0.00487997f, -0.00396447f, 0.01626191f, 0.04477349f, 0.04520928f, 
    -0.03887913f, -0.05199085f, -0.11247012f, -0.00435694f, 0.08154190f, -0.21433498f, -0.02186750f, -0.12339100f, 
    0.02294726f, 0.07207123f, -0.01815839f, -0.12586214f, 0.08518261f, 0.08733179f, 0.02881326f, -0.05042673f, 
    -0.07290935f, 0.09280058f, 0.01828752f, -0.11848766f, -0.10744268f, 0.09279444f, 0.05276224f, -0.02656765f, 
    0.01082493f, -0.08370192f, 0.12111585f, 0.09085871f, 0.15361451f, -0.10367063f, -0.03917944f, 0.15362252f, 
    0.03313532f, -0.07935058f, 0.09050428f, -0.15513872f, 0.01762936f, 0.00180208f, -0.01049251f, 0.07452785f, 
    0.06168194f, -0.10109257f, -0.04773010f, 0.01740824f, -0.08603101f, 0.07096081f, -0.07422302f, -0.07506772f, 
    0.02452075f, 0.03571081f, 0.00652653f, 0.13207053f, -0.03546080f, -0.10161849f, -0.00760461f, -0.01091279f, 
    -0.04973559f, -0.02951770f, -0.01593578f, -0.02300860f, -0.03356674f, -0.05039375f, 0.01987844f, 0.05412643f, 
    -0.05455329f, -0.03769292f, 0.00147879f, 0.17389134f, 0.00036338f, -0.11178806f, -0.05654742f, -0.02200889f, 
    0.09512191f, 0.01866724f, 0.00050612f, 0.02952413f, 0.16237940f, -0.06950973f, 0.06699315f, 0.01595773f, 
    -0.04215570f, 0.05842859f, 0.05622010f, 0.05864599f, 0.05373682f, -0.09138858f, -0.08384256f, -0.13336284f, 
    -0.02488907f, 0.16757949f, -0.08785957f, 0.01912290f, 0.08787545f, -0.00546686f, 0.10569741f, -0.02559165f, 
    0.06436814f, -0.01746196f, 0.08368191f, -0.04055048f, -0.10190818f, 0.10919082f, 0.04714726f, -0.03475812f, 
    -0.04927023f, 0.02842632f, 0.02126103f, 0.02381441f, 0.00816990f, -0.00811556f, -0.02788596f, -0.07940783f, 
    0.11984736f, 0.15124965f, 0.04720677f, 0.07093854f, -0.01672600f, 0.09160381f, 0.05725856f, 0.02700146f, 
    0.08147051f, 0.01706069f, 0.02614335f, 0.09028543f, -0.19752991f, 0.02824344f, -0.13024473f, 0.05413554f, 
    -0.02168617f, -0.09992870f, 0.04441908f, -0.01823781f, -0.02300606f, 0.09614864f, -0.01634559f, -0.09615606f, 
    -0.01602936f, 0.01942987f, 0.09209749f, 0.01750156f, 0.01676789f, 0.08905584f, 0.08159162f, 0.17647716f, 
    0.02442332f, 0.14979848f, -0.06424022f, 0.04312757f, -0.00561590f, -0.18190652f, 0.15196270f, 0.24218228f, 
    -0.03918856f, -0.05141395f, 0.11693162f, 0.04680713f, -0.09449799f, -0.04574542f, -0.02403882f, 0.02927197f, 
    -0.15747240f, -0.09519491f, 0.04871360f, 0.04348961f, 0.03261416f, 0.05009231f, 0.07627878f, -0.02700704f, 
    0.01151474f, -0.02994146f, 0.00217822f, -0.02196809f, 0.01185364f, 0.25408936f, -0.14124244f, -0.04755721f, 
    0.17015629f, 0.10829733f, -0.01226488f, 0.08683631f, 0.10187406f, -0.08475097f, 0.02119064f, -0.05353343f, 
    -0.42396995f, -0.06193515f, 0.31919768f, 0.01079390f, -0.06096019f, 0.02006007f, -0.05665343f, 0.05284312f, 
    0.06912816f, 0.04267240f, -0.02009489f, -0.01489910f, 0.12032861f, 0.00912052f, -0.00891280f, 0.20019129f, 
    0.01709225f, -0.06426908f, -0.02693936f, -0.06663413f, -0.03873756f, 0.06962248f, 0.02618161f, 0.03214499f, 
    0.18470755f, 0.09789782f, 0.08286094f, 0.20220238f, -0.02648391f, 0.09564763f, -0.07368305f, -0.10420948f, 
    0.01166582f, 0.05561289f, 0.06044760f, -0.03774497f, 0.02645724f, -0.12442522f, 0.03914760f, 0.16075151f, 
    0.14477199f, 0.09059194f, 0.05893797f, 0.09320178f, 0.02452629f, -0.05061365f, -0.01671315f, 0.12277209f, 
    -0.09726853f, -0.14781918f, -0.02962884f, -0.01904263f, 0.05826281f, -0.02688429f, -0.08943582f, -0.02552892f, 
    0.13619189f, 0.01099444f, 0.01076467f, 0.08049514f, -0.05383576f, 0.07151061f, -0.05372939f, 0.04120883f, 
    -0.03103202f, 0.05324475f, 0.06056492f, 0.03614054f, 0.05244450f, -0.05617691f, -0.07651959f, 0.04844237f, 
    -0.25192052f, 0.03469684f, -0.07037560f, -0.07475211f, -0.06149098f, 0.01997126f, 0.00098308f, -0.01630360f, 
    0.07164670f, 0.11114209f, 0.03126378f, -0.03993399f, 0.18183820f, 0.14310396f, 0.12476517f, -0.04199433f, 
    -0.01360683f, -0.04493095f, -0.03314145f, 0.02314231f, -0.02800838f, 0.08465009f, 0.13854259f, 0.06345315f, 
    -0.11349190f, 0.13725370f, 0.08155412f, 0.00199352f, -0.06010132f, 0.03189087f, 0.01608241f, 0.10594299f, 
    0.04772501f, -0.05914386f, 0.03204648f, 0.14152074f, -0.18935490f, -0.05702791f, 0.12798299f, 0.00459689f, 
    -0.06587726f, 0.03334799f, -0.02618880f, -0.04456478f, -0.02444198f, 0.00766264f, 0.05618634f, 0.02707819f, 
    0.34019253f, -0.38826317f, 0.17472084f, 0.14106011f, -0.05165572f, -0.01686656f, 0.17792164f, 0.08670141f, 
    -0.03963326f, 0.00912365f, -0.09404756f, -0.06918883f, 0.11286686f, -0.15519024f, 0.17510600f, 0.15760385f, 
    -0.10402533f, 0.07408427f, 0.04629408f, 0.01715175f, -0.00687461f, -0.05066396f, -0.02352283f, 0.04448570f, 
    -0.27091044f, -0.03584003f, 0.26995361f, 0.12189241f, 0.15378521f, 0.10514861f, 0.03036208f, 0.09558332f, 
    0.15715171f, -0.06750195f, -0.04956346f, 0.02408591f, -0.27652583f, 0.07767457f, 0.16409601f, -0.02007534f, 
    -0.05519342f, -0.01846614f, 0.01304375f, 0.03479693f, 0.07516174f, -0.04623215f, 0.01222935f, 0.08091770f, 
    0.02638648f, -0.05060798f, -0.02520148f, 0.01254136f, -0.00991372f, -0.01820816f, 0.00079920f, -0.02406989f, 
    0.01772518f, 0.04650994f, -0.05165618f, -0.04452123f, 0.02370056f, 0.03768407f, -0.00431147f, 0.01186434f, 
    -0.04309280f, 0.03530949f, -0.03158499f, -0.01286966f, -0.00992030f, -0.01784274f, -0.05532737f, 0.00492673f, 
    -0.02539518f, -0.04894441f, 0.05473892f, 0.04805346f, 0.03135825f, 0.04079024f, -0.02213285f, -0.00661281f, 
    -0.03268694f, -0.01260465f, 0.02249672f, -0.01551022f, -0.04670855f, 0.05351512f, -0.00409891f, -0.03873865f, 
    0.03231475f, -0.02139459f, -0.01453208f, 0.03647759f, -0.03625891f, -0.01418772f, -0.04898204f, 0.03024806f, 
    -0.04138290f, -0.00752108f, 0.05106800f, -0.03940220f, -0.03475243f, 0.02772397f, -0.00716660f, 0.01191895f, 
    0.00566282f, -0.04815516f, -0.02185267f, 0.03171144f, 0.01196991f, -0.04053400f, -0.02325316f, -0.02671624f, 
    0.04091412f, 0.04312608f, -0.04758135f, 0.01029015f, 0.03387384f, 0.04135896f, -0.04949637f, -0.01226929f, 
    0.05292041f, 0.03580114f, -0.03405064f, -0.00728021f, -0.02592651f, 0.02403434f, 0.01686021f, 0.01850241f, 
    -0.00521449f, -0.01321994f, 0.03121383f, -0.05399554f, -0.01741000f, 0.04418082f, -0.04754233f, -0.02686483f, 
    0.04425839f, 0.03729348f, -0.04531965f, 0.00163506f, -0.04295337f, -0.04587842f, 0.01977151f, 0.00342219f, 
    -0.01182942f, -0.01949226f, -0.00836757f, -0.01693809f, 0.00269433f, -0.04037446f, 0.03003808f, 0.04539183f, 
    0.00206459f, -0.03465618f, 0.01448407f, -0.04410369f, -0.04425461f, -0.01852961f, -0.04811967f, -0.02316198f, 
    -0.03987588f, -0.02052107f, -0.04721004f, 0.00434680f, 0.03416047f, -0.02645111f, -0.04014261f, 0.03830359f, 
    0.02949656f, -0.03848333f, 0.01261588f, 0.03996593f, -0.03844161f, -0.02304349f, -0.03511997f, -0.02676322f, 
    -0.03067909f, 0.04292766f, 0.04432685f, -0.01683451f, 0.04310521f, -0.01532353f, 0.04104885f, -0.03643293f, 
    -0.00133920f, 0.01333825f, -0.03152768f, -0.03360261f, -0.00475527f, -0.04594496f, 0.04575618f, 0.02365834f, 
    -0.03247533f, 0.03527359f, -0.02178676f, 0.03060813f, -0.04562334f, -0.01345082f, 0.02188510f, -0.02152824f, 
    -0.03386927f, 0.00036927f, 0.02769821f, -0.04229620f, 0.02749909f, -0.05843059f, -0.01697926f, -0.03320561f, 
    -0.02110209f, -0.01716104f, -0.03491620f, 0.03966113f, 0.03907838f, 0.02326836f, 0.03397475f, -0.00550135f, 
    0.00237773f, -0.00109989f, -0.05067656f, -0.02129451f, 0.02950750f, 0.03556655f, 0.03181676f, -0.01306491f, 
    -0.01978372f, 0.03027160f, 0.03851678f, 0.04202924f, -0.02371336f, -0.01321521f, 0.03744809f, 0.02164839f, 
    0.00943993f, 0.04144837f, -0.04853705f, -0.02263940f, 0.04345505f, -0.04167492f, -0.02012013f, -0.01178029f, 
    -0.04156252f, 0.01385658f, 0.02060727f, 0.00835114f, -0.00254566f, -0.04797943f, 0.03722557f, 0.01263978f, 
    -0.01744967f, -0.02907628f, -0.00992764f, 0.02840988f, 0.01400932f, -0.00707574f, 0.00382242f, -0.03840647f, 
    -0.04801233f, 0.03898902f, 0.03346136f, 0.02195056f, 0.02250990f, -0.02538980f, 0.04013022f, 0.00147826f, 
    -0.00127666f, 0.03143344f, 0.00796746f, -0.01741053f, -0.02359924f, -0.01315926f, 0.01037075f, -0.01256035f, 
    -0.04657279f, -0.04940891f, -0.00972568f, -0.02743619f, -0.00593173f, 0.00019157f, 0.00643995f, -0.02447741f, 
    -0.03518702f, 0.03266656f, -0.04556479f, 0.00338785f, 0.03693235f, -0.04135600f, -0.01705162f, -0.04943816f, 
    -0.03163271f, -0.03431424f, -0.04287122f, 0.00139391f, 0.00273305f, -0.02557468f, -0.02391059f, -0.04322618f, 
    0.04331877f, -0.04111132f, 0.02089071f, -0.03857761f, 0.00144700f, -0.01413285f, -0.04199161f, 0.01003558f, 
    0.03426691f, -0.01406596f, 0.03564564f, -0.05403612f, 0.00696487f, 0.00613189f, -0.01843229f, -0.04251950f, 
    -0.04042016f, 0.01592166f, 0.00152917f, -0.04252712f, -0.05210171f, -0.04674509f, -0.00341589f, -0.00852099f, 
    0.04193938f, -0.04505699f, -0.04577193f, -0.00247608f, 0.00877988f, -0.00177981f, -0.00021437f, -0.02847999f, 
    -0.04664216f, 0.03695707f, -0.04243193f, -0.02433106f, 0.04534825f, -0.00168075f, -0.00921176f, -0.02134144f, 
    -0.01865251f, 0.03150965f, 0.00821932f, 0.04807051f, 0.00690727f, 0.00785270f, 0.03343427f, 0.05073048f, 
    -0.00098654f, 0.02571566f, 0.00371716f, 0.04668558f, 0.00362082f, 0.04299017f, 0.02614601f, -0.05316387f, 
    0.04132454f, 0.00218622f, 0.00871446f, 0.04452991f, -0.01494608f, 0.00473182f, 0.03454495f, -0.05561853f, 
    0.00624200f, 0.03395864f, 0.02185847f, 0.04699556f, -0.03685749f, -0.02323725f, -0.01025824f, 0.02347567f, 
    -0.02323867f, 0.02807012f, -0.02573264f, 0.00583753f, -0.05411959f, -0.04663972f, 0.02369774f, 0.05556889f, 
    0.02386107f, -0.03738169f, 0.04300766f, 0.02757409f, -0.04707562f, -0.04493489f, 0.00346810f, -0.02551275f, 
    -0.03013721f, 0.00554750f, 0.01972284f, 0.00436763f, -0.00477931f, 0.03500481f, 0.00380973f, -0.03809676f, 
    -0.04132461f, -0.03990978f, -0.03279767f, -0.00901318f, -0.01434225f, 0.01473557f, 0.03034174f, 0.01120110f, 
    0.01282705f, -0.00544279f, -0.05665101f, 0.01702142f, -0.03962149f, 0.04651779f, -0.00088984f, -0.04171807f, 
    -0.03773440f, 0.03505876f, -0.04577556f, 0.04075037f, 0.04549369f, 0.03235044f, 0.01606157f, 0.01924609f, 
    0.01070657f, -0.01428953f, 0.02084141f, -0.01977377f, -0.02076185f, -0.04815492f, 0.01553519f, -0.00877608f, 
    0.02648335f, -0.03137674f, 0.02591405f, -0.04606782f, -0.01193479f, -0.04377969f, -0.01105165f, 0.04404752f, 
    0.11499265f, 0.14367698f, 0.04711577f, -0.00509465f, -0.01730408f, -0.10772878f, -0.02940208f, 0.00812630f, 
    -0.01298283f, 0.03674132f, -0.12193903f, 0.21407171f, 0.17331502f, 0.04787293f, -0.11240449f, 0.09587329f, 
    -0.03589934f, -0.04309753f, 0.04795003f, -0.00555165f, -0.07187023f, 0.03660819f, -0.04516019f, -0.08031464f, 
    -0.39272875f, -0.03229879f, 0.09102151f, 0.13946500f, -0.01055864f, -0.01661004f, 0.11536903f, 0.06138496f, 
    0.05609743f, -0.06636240f, -0.13789971f, -0.00511018f, 0.05641340f, -0.08386581f, -0.13953973f, 0.03303548f, 
    0.13309698f, 0.05507008f, 0.00751962f, -0.05056083f, -0.04218514f, 0.00850241f, 0.06514262f, 0.03042378f, 
    -0.00095200f, 0.03930335f, 0.07318204f, -0.03697202f, -0.12229275f, 0.00296342f, 0.07784031f, 0.01578226f, 
    0.02061609f, -0.06774890f, 0.02933874f, -0.04120814f, 0.13786116f, -0.00032802f, 0.07682858f, 0.06080195f, 
    -0.16842382f, -0.06275312f, 0.02831895f, -0.06699625f, 0.02018350f, -0.01014798f, -0.09039491f, -0.06494743f, 
    -0.21566921f, -0.05145248f, 0.05115432f, 0.08468884f, 0.02282749f, 0.04273807f, 0.00956025f, 0.09312937f, 
    0.14608088f, -0.00176060f, 0.02283346f, 0.07659792f, -0.28023037f, 0.06650364f, 0.05302671f, 0.00761389f, 
    0.04427182f, -0.10292532f, 0.14986989f, -0.06053483f, -0.03955899f, -0.03613422f, 0.09274628f, 0.09174832f, 
    0.36377272f, -0.03356158f, -0.12830648f, 0.25771570f, 0.04038534f, 0.01724827f, -0.05737660f, 0.02878931f, 
    0.02176131f, -0.01643572f, -0.12051882f, 0.08804329f, 0.16355766f, -0.06633757f, -0.03864118f, -0.06455961f, 
    -0.06440506f, 0.06708740f, -0.09094623f, 0.06190364f, 0.04836505f, -0.02195524f, -0.00674479f, 0.01991743f, 
    -0.00642667f, -0.12536506f, -0.15051465f, -0.10738266f, -0.01409312f, -0.07128160f, 0.15076369f, 0.04887628f, 
    -0.01393800f, -0.03146736f, 0.05922016f, -0.05757612f, 0.10233224f, -0.11647845f, -0.03926875f, 0.10421298f, 
    -0.01615010f, 0.07689035f, 0.06762849f, 0.02245457f, -0.04264203f, -0.00096048f, 0.00673476f, -0.00849558f, 
    0.04234647f, 0.08440661f, 0.06193629f, -0.15343712f, 0.05230137f, 0.02445184f, 0.01336430f, 0.01208661f, 
    -0.02352079f, -0.01660266f, -0.07802889f, 0.01131247f, 0.18546712f, -0.13669115f, 0.21080177f, 0.09516277f, 
    -0.05961958f, 0.06929810f, 0.14828181f, 0.00571612f, 0.06008511f, 0.09428067f, -0.08482724f, -0.03361268f, 
    0.05658424f, 0.00076381f, 0.02250951f, 0.18281172f, 0.02725925f, -0.04656378f, 0.01508483f, 0.02304473f, 
    -0.02188108f, -0.00025501f, 0.03843664f, 0.05243320f, 0.06518665f, -0.10669052f, 0.00600488f, 0.25389934f, 
    -0.09781151f, 0.05680183f, 0.03635475f, 0.03523419f, -0.01829280f, -0.00267100f, -0.04970998f, 0.00627386f, 
    -0.17200193f, -0.13134924f, 0.00615854f, -0.02755867f, -0.06638329f, 0.11141667f, -0.03274080f, 0.06995241f, 
    0.08431049f, -0.01493989f, 0.04218534f, 0.06137584f, -0.10539863f, 0.14934780f, -0.07715538f, -0.10387585f, 
    0.12395534f, 0.01095044f, -0.04913784f, 0.12930344f, 0.05783258f, -0.01281904f, 0.16898918f, 0.09186805f, 
    -0.31982139f, -0.14183158f, 0.22594562f, 0.02304905f, -0.04585383f, 0.00923914f, -0.08803503f, 0.00604835f, 
    0.09746166f, 0.06669573f, -0.02051127f, 0.05251541f, 0.09637787f, 0.00701863f, -0.03053218f, 0.09535312f, 
    -0.01423685f, -0.02334668f, 0.06516723f, 0.05593237f, 0.10988265f, -0.00033974f, 0.03693236f, 0.04366751f, 
    0.23946662f, -0.02022295f, 0.05862585f, 0.24110454f, -0.04242934f, 0.12425191f, -0.11277441f, 0.00361144f, 
    -0.08682509f, 0.13314416f, 0.06704059f, 0.05143843f, 0.08707909f, 0.15977705f, -0.01821462f, -0.00057860f, 
    -0.01542737f, 0.00299936f, 0.04381206f, 0.00012271f, -0.14488922f, -0.02987522f, 0.06308491f, -0.00625662f, 
    -0.09949598f, -0.21113168f, 0.01501105f, -0.06316601f, 0.01652654f, 0.10616156f, -0.00255253f, -0.01391375f, 
    0.07472758f, 0.03475788f, 0.04675241f, 0.06498148f, -0.05675092f, 0.04280621f, -0.07071856f, -0.06883872f, 
    -0.09304065f, 0.03290825f, 0.07285979f, 0.09632068f, 0.09024827f, 0.03285734f, 0.00555912f, -0.02180530f, 
    -0.36599654f, 0.07141855f, 0.02503001f, 0.06302955f, 0.10195199f, 0.00401978f, -0.04054901f, -0.00182225f, 
    0.06316617f, 0.02944591f, 0.04025037f, -0.00309334f, 0.05425860f, 0.09344688f, -0.06102748f, 0.08972908f, 
    0.01770534f, -0.01933477f, 0.02829457f, -0.01298344f, -0.10151493f, -0.03059955f, -0.00587900f, 0.08173429f, 
    -0.06726944f, 0.05048120f, 0.00967395f, 0.01605984f, 0.02335720f, 0.16188881f, 0.10995480f, 0.08843260f, 
    -0.06303628f, -0.05142634f, -0.02664372f, 0.19256648f, -0.04677958f, 0.03569822f, -0.01523110f, -0.04698862f, 
    0.00929969f, -0.05088890f, 0.06068687f, 0.04311972f, 0.12790503f, -0.03431881f, 0.03003949f, -0.13628006f, 
    0.03394876f, 0.05805117f, 0.03481689f, 0.06104810f, -0.06783506f, 0.04205380f, 0.06978615f, -0.11584376f, 
    -0.10171189f, 0.04569099f, 0.05671681f, 0.02846815f, 0.02179945f, 0.01608996f, 0.10799327f, 0.18894850f, 
    0.00223329f, -0.06939210f, -0.02351364f, -0.08007959f, 0.00969348f, -0.01911675f, 0.07568024f, 0.13033514f, 
    -0.20958462f, -0.14436661f, 0.29948500f, 0.06568909f, 0.06074791f, 0.07516955f, 0.04157373f, -0.08924036f, 
    0.11038358f, 0.02664232f, -0.09474804f, -0.03058458f, -0.02028641f, 0.21785663f, 0.01912175f, -0.04783674f, 
    -0.12659502f, 0.03094515f, -0.06178360f, 0.01987432f, -0.04483818f, -0.04398867f, 0.03446914f, 0.02706502f, 
    0.18556304f, 0.14464048f, 0.00241791f, 0.12821740f, -0.03869994f, -0.07175088f, 0.08133021f, 0.02839024f, 
    0.03474871f, 0.00729689f, 0.02693770f, 0.15414710f, -0.08837046f, 0.17274271f, -0.03595716f, 0.19432487f, 
    -0.03664475f, 0.06128581f, 0.00942205f, -0.02522360f, -0.09270497f, 0.03553560f, 0.04898372f, 0.03785288f, 
    -0.01172052f, -0.04150868f, 0.18950218f, 0.15772614f, -0.09552646f, 0.07604080f, 0.07387802f, 0.05243337f, 
    0.00488145f, 0.06547111f, -0.12527928f, 0.00933973f, -0.17891155f, 0.01202067f, -0.13599598f, 0.01986864f, 
    -0.04416184f, -0.06160016f, -0.05654203f, 0.02233386f, 0.02575355f, -0.02870427f, -0.03106572f, -0.03057539f, 
    -0.00249991f, -0.06771332f, 0.03960509f, -0.08479239f, 0.11921354f, 0.11802757f, -0.00440715f, -0.08896450f, 
    -0.08434854f, 0.01805232f, 0.11557301f, -0.05200602f, -0.02324975f, 0.00974771f, 0.00750518f, 0.13240348f, 
    0.03176351f, 0.08389083f, -0.00987203f, 0.02859500f, 0.05085958f, -0.01355054f, 0.00352578f, 0.10066515f, 
    -0.13486013f, 0.08771485f, -0.07673936f, 0.18359666f, -0.03201124f, 0.05672610f, 0.03691212f, -0.03455320f, 
    0.00644008f, -0.05857528f, 0.02275612f, -0.02471578f, -0.21924788f, -0.02383367f, 0.02196955f, 0.17713630f, 
    -0.03522840f, 0.01655231f, 0.02982540f, -0.06737655f, 0.01367318f, -0.03272210f, 0.05259028f, -0.00329990f, 
    0.21330681f, 0.11045453f, -0.06544640f, 0.22911088f, -0.10084455f, 0.14129211f, -0.03929854f, 0.04719201f, 
    0.00411820f, -0.04235134f, -0.10317209f, -0.04653190f, -0.02384589f, -0.01906005f, 0.00865683f, -0.16911909f, 
    -0.03226851f, -0.04415407f, 0.06334318f, 0.05746225f, 0.06264670f, 0.11378349f, -0.01982439f, 0.08964607f, 
    0.01499380f, -0.18696056f, 0.16452761f, -0.25136948f, -0.02266690f, -0.12039474f, 0.12236778f, -0.12448885f, 
    -0.06123003f, -0.00596891f, -0.03793748f, -0.00134399f, 0.07152354f, 0.06531766f, -0.18920457f, 0.22470224f, 
    0.09827162f, 0.05843413f, -0.13884076f, 0.00335150f, -0.03361769f, -0.02310004f, 0.05461182f, -0.06440688f, 
    -0.08046838f, 0.03047631f, 0.01819391f, -0.07716785f, 0.04795682f, -0.06089700f, 0.03983020f, -0.00591999f, 
    0.02692294f, -0.05864807f, 0.01057177f, 0.10994583f, 0.29102951f, -0.02194824f, -0.05931906f, 0.23275410f, 
    -0.03030073f, 0.10241297f, -0.05804761f, 0.17259002f, 0.05269560f, -0.00676068f, -0.10844772f, 0.05124132f, 
    -0.01003170f, 0.13602877f, 0.04302027f, 0.02106735f, -0.07733914f, -0.02151709f, -0.06804992f, 0.07223655f, 
    -0.04896742f, -0.07124557f, 0.00739454f, -0.05620509f, 0.21995871f, 0.00521768f, -0.15289029f, 0.35631219f, 
    -0.09819753f, -0.05785124f, -0.08271364f, 0.06416836f, 0.09601007f, 0.04580334f, 0.00331142f, 0.02703340f, 
    -0.15360439f, 0.09421781f, -0.20564859f, 0.19497840f, -0.09260538f, 0.09538092f, -0.04099724f, -0.04681889f, 
    0.03066192f, 0.06053577f, -0.03001228f, 0.03523003f, 0.12811112f, -0.25209472f, 0.03757220f, -0.10761864f, 
    -0.00347571f, -0.00527052f, -0.03991996f, 0.04052635f, 0.05083980f, 0.10414108f, 0.06806442f, 0.10827535f, 
    0.10176728f, -0.11232702f, -0.10984388f, 0.24913234f, 0.15026419f, -0.04104073f, -0.04015006f, 0.00525132f, 
    -0.01044989f, -0.03065396f, 0.06390786f, -0.02079900f, 0.06391764f, 0.27328679f, 0.03085473f, -0.09654876f, 
    -0.03094304f, -0.03846376f, -0.02467566f, -0.03257001f, 0.12046136f, -0.03641912f, 0.13916653f, 0.05819281f, 
    -0.01266230f, 0.21157260f, -0.09863357f, -0.11594932f, -0.02891158f, 0.02711731f, 0.08133952f, 0.05865500f, 
    0.03793456f, 0.08167712f, 0.00043504f, -0.01002643f, -0.02128445f, 0.13489525f, 0.17330469f, -0.05275501f, 
    -0.10020448f, -0.08390113f, -0.00430915f, -0.04451376f, -0.09312592f, 0.00407445f, 0.01505039f, 0.01776935f, 
    -0.18406227f, -0.10667132f, -0.06033839f, 0.07160927f, 0.05547937f, 0.01970181f, 0.03307439f, 0.02316468f, 
    0.06387383f, -0.02368458f, -0.02108113f, -0.03724401f, 0.14659756f, 0.02922410f, -0.11755822f, 0.03890716f, 
    0.06101799f, 0.11466344f, 0.07445669f, -0.06251675f, -0.02597710f, 0.00222511f, -0.04274072f, 0.10400494f, 
    -0.18483345f, -0.11487951f, 0.07462899f, 0.05459541f, 0.07046415f, -0.05377103f, 0.09709620f, 0.02275226f, 
    -0.14320371f, 0.00468356f, 0.06071395f, -0.02658185f, 0.29312503f, -0.10146644f, -0.00852962f, 0.26164669f, 
    -0.06045616f, 0.01944992f, -0.10215323f, 0.00180788f, 0.00481273f, -0.03808844f, -0.10527022f, -0.11345675f, 
    -0.03151487f, 0.05907553f, 0.06246279f, -0.17268178f, 0.02707672f, -0.02902426f, 0.07981300f, -0.03989756f, 
    -0.00708189f, -0.00068517f, 0.09080997f, 0.02015680f, -0.11983549f, -0.09539715f, -0.06731442f, -0.00425589f, 
    0.08917469f, 0.13723668f, 0.10724558f, -0.01494924f, -0.07310431f, -0.00305013f, 0.10592838f, 0.00648363f, 
    0.06065848f, 0.27633613f, -0.14607523f, 0.27254441f, 0.07192899f, 0.12862961f, -0.06648484f, -0.00990089f, 
    0.08438927f, 0.10763767f, -0.01954003f, -0.08297418f, -0.03124953f, 0.02638779f, -0.08103736f, -0.05541186f, 
    0.05789661f, -0.00138814f, -0.03069221f, 0.03101815f, 0.15282857f, -0.06773452f, 0.10835645f, 0.06305122f, 
    0.15966193f, -0.08089288f, 0.20379700f, 0.00165182f, 0.03018856f, -0.08379771f, 0.07504445f, 0.05720398f, 
    0.04677874f, 0.06152254f, -0.00306615f, 0.14032306f, 0.08156341f, 0.08050965f, -0.01744027f, -0.07195494f, 
    0.00165353f, 0.02070764f, 0.02234684f, 0.02147628f, 0.05068540f, 0.00858043f, 0.05111911f, -0.06828890f, 
    -0.17079404f, -0.15561759f, 0.06469838f, -0.06384487f, 0.04776494f, 0.10765295f, -0.05568907f, 0.00645397f, 
    0.05140179f, -0.00508164f, -0.01400179f, -0.05398938f, 0.15980020f, -0.02969315f, 0.18498076f, -0.20609760f, 
    0.06283985f, -0.10552806f, -0.01880558f, 0.09354069f, 0.10815297f, -0.04849632f, 0.00355719f, 0.06716617f, 
    -0.03908287f, 0.28194621f, -0.17893451f, -0.20098409f, 0.02494365f, 0.03686669f, -0.08075930f, -0.03626898f, 
    -0.00833729f, 0.00302206f, 0.10876086f, 0.00704576f, 0.13793850f, 0.04071863f, 0.18098509f, 0.00245052f, 
    0.06862704f, 0.04564587f, 0.09224846f, 0.08944655f, 0.04051599f, -0.03150388f, -0.01582597f, 0.00697135f, 
    0.01297930f, -0.13386287f, -0.10679013f, 0.17263556f, 0.00675606f, -0.12224203f, -0.03807978f, 0.08159795f, 
    0.01947858f, 0.08100080f, -0.01233563f, 0.02763449f, -0.15332878f, 0.15402162f, 0.04490073f, -0.19529773f, 
    0.12695409f, 0.00728219f, -0.02300946f, 0.09199396f, -0.05243390f, 0.08787266f, -0.01117201f, -0.00993913f, 
    0.18010664f, -0.08976924f, 0.09991177f, -0.16557121f, 0.13204065f, -0.09821346f, 0.01560605f, 0.11516227f, 
    -0.05078141f, 0.02458101f, -0.06965341f, -0.01632854f, 0.47902289f, 0.08870474f, 0.01762981f, -0.00410897f, 
    -0.07386781f, -0.05717571f, 0.08659438f, 0.07848150f, 0.06090005f, 0.01850718f, -0.04189343f, -0.05511081f, 
    -0.16107759f, -0.01931900f, 0.14126500f, -0.30478951f, 0.09315559f, -0.02143049f, 0.10418657f, 0.09189325f, 
    -0.01910264f, 0.10402080f, 0.12950964f, -0.03387293f, -0.12224245f, 0.06399550f, -0.10090488f, 0.17752665f, 
    0.09206615f, -0.08043496f, -0.06250955f, -0.02392549f, -0.06559824f, -0.02805066f, 0.01263766f, 0.01350986f, 
    0.06707967f, 0.14145312f, -0.05723378f, 0.15810643f, -0.00985633f, 0.04858260f, -0.10059610f, 0.03059896f, 
    -0.00423182f, -0.00674922f, 0.09026035f, 0.10057335f, 0.04825680f, -0.15153655f, 0.10870879f, -0.16259265f, 
    0.02063994f, -0.06691483f, 0.01098495f, 0.04098630f, 0.08098986f, 0.06860362f, 0.01411489f, 0.04886593f, 
    -0.05506720f, -0.07577386f, -0.08598273f, 0.15976927f, -0.01473894f, 0.03477640f, -0.05552762f, 0.07533471f, 
    -0.08241557f, 0.03442982f, 0.04200401f, -0.11377703f, -0.18597637f, 0.08851580f, 0.03665233f, -0.16678856f, 
    0.00326105f, -0.02269146f, 0.01821567f, -0.05164634f, 0.11145546f, 0.06507346f, 0.08154023f, 0.10109918f, 
    0.06808201f, 0.05995350f, -0.08699614f, -0.00281202f, -0.02287126f, -0.08852524f, -0.04375079f, -0.06460182f, 
    0.06894465f, 0.07775617f, 0.01741889f, -0.02929530f, -0.04525955f, 0.12413479f, 0.07737219f, -0.34353203f, 
    0.09662484f, 0.16067220f, 0.02109340f, -0.01087195f, -0.00031502f, 0.14430355f, 0.14446312f, -0.05405491f, 
    0.28702110f, -0.04190416f, 0.02601522f, -0.06393401f, 0.13152352f, -0.09243338f, -0.03630217f, 0.01208217f, 
    -0.01700890f, -0.05566122f, -0.01275159f, 0.02680548f, -0.18958938f, 0.09260072f, -0.04775251f, 0.20238063f, 
    -0.07605427f, 0.02250195f, -0.09001299f, 0.06049171f, -0.09787967f, -0.05140634f, -0.13044892f, -0.02574429f, 
    0.25903359f, 0.12780240f, -0.07720697f, -0.11957361f, -0.01870970f, 0.01698873f, 0.12496530f, 0.00932568f, 
    0.08520753f, -0.00284667f, 0.07484162f, -0.02131929f, -0.00149691f, -0.01443153f, 0.07591556f, -0.03444015f, 
    0.06557036f, 0.06456798f, 0.01620535f, 0.07446915f, -0.09299123f, 0.04052482f, -0.06763531f, -0.05080548f, 
    -0.09417609f, -0.09747421f, 0.01265240f, -0.06757647f, 0.06711364f, -0.11799172f, 0.05160250f, 0.09573711f, 
    0.02398206f, -0.11695579f, 0.01580324f, 0.05117960f, 0.11960299f, -0.02591470f, 0.04242055f, -0.15094358f, 
    -0.11640625f, -0.00816260f, -0.09561486f, 0.04345162f, 0.06755131f, 0.07399889f, -0.01855070f, 0.07021555f, 
    0.22607678f, 0.01715586f, -0.01479919f, -0.04506939f, 0.07991499f, 0.08643889f, 0.07843895f, -0.00030503f, 
    -0.09576183f, 0.01818095f, 0.06298228f, -0.03521941f, 0.17916897f, -0.23106894f, 0.08173700f, -0.07698464f, 
    0.08415967f, -0.08356582f, -0.03409031f, 0.05806949f, -0.00225069f, 0.02541047f, 0.07771368f, -0.07336388f, 
    0.35219917f, 0.06295843f, -0.10843205f, 0.15681727f, -0.05787617f, 0.05796033f, -0.10871253f, 0.00156599f, 
    -0.03692733f, -0.00841451f, -0.03739884f, 0.09018999f, -0.08388470f, 0.03389287f, -0.08481453f, -0.09938915f, 
    0.02628817f, -0.01323086f, 0.12213816f, 0.02235720f, 0.04800251f, 0.03648237f, -0.02033796f, 0.02957209f, 
    0.03106945f, -0.18565238f, -0.21669167f, 0.16189219f, -0.03446253f, -0.02887989f, -0.04216176f, 0.01350925f, 
    0.05974871f, 0.00149758f, 0.04278728f, -0.00276592f, 0.08257361f, -0.05942013f, -0.05197089f, 0.05783708f, 
    0.08476263f, -0.00537150f, 0.01208598f, 0.04544555f, 0.09161540f, 0.04933784f, -0.10937295f, 0.08571103f, 
    -0.17130534f, 0.07040297f, 0.07665709f, -0.23991689f, -0.02867313f, -0.00621763f, -0.07279123f, 0.10273072f, 
    -0.01218740f, -0.00679354f, -0.00830132f, 0.14532608f, 0.02692971f, 0.08890205f, 0.08883936f, -0.11732578f, 
    0.02607976f, 0.02282521f, 0.08083707f, 0.05954727f, -0.00360810f, 0.12224060f, -0.14593950f, -0.08704162f, 
    -0.01494667f, 0.08654334f, -0.31538162f, -0.01651427f, -0.03713430f, 0.07880281f, -0.06826667f, -0.01456335f, 
    -0.12255040f, 0.06727114f, 0.06271142f, 0.02155249f, 0.16930561f, -0.25028020f, -0.09633844f, 0.14648837f, 
    0.07056874f, -0.05306616f, 0.03426771f, 0.02174862f, -0.02497519f, -0.02044228f, 0.00896307f, -0.01096409f, 
    0.14024229f, 0.10505480f, 0.07012798f, 0.08896438f, 0.02547183f, -0.10720959f, -0.00371310f, 0.07015131f, 
    0.09258018f, 0.14428282f, 0.03919305f, 0.10128349f, 0.04006537f, 0.08394901f, 0.07281120f, 0.04484924f, 
    -0.03174782f, -0.06301234f, -0.03734745f, 0.08810584f, 0.04579824f, -0.02870077f, -0.00445461f, -0.00265796f, 
    -0.05703063f, 0.00097486f, 0.25427258f, 0.01696306f, -0.08185761f, 0.00154813f, 0.07606126f, 0.01556058f, 
    0.17416671f, 0.01591909f, -0.07088903f, 0.02480758f, 0.03436081f, 0.35563719f, -0.06195156f, 0.21890438f, 
    0.00020312f, 0.09411578f, -0.02458077f, 0.12164203f, -0.03744649f, -0.09918942f, 0.09652962f, 0.02059850f, 
    -0.08775546f, -0.07106385f, -0.03190321f, 0.06538787f, 0.04439975f, 0.00697786f, 0.02378929f, -0.03891662f, 
    0.01903243f, 0.04791009f, 0.02631620f, -0.14140934f, -0.12079089f, -0.12268764f, 0.19564460f, 0.07417710f, 
    -0.00537348f, 0.14464036f, -0.02341214f, 0.13621253f, 0.05470669f, 0.01041178f, 0.09601741f, -0.06745780f, 
    -0.22868615f, 0.18889573f, 0.08082344f, -0.06649814f, -0.00902812f, 0.00367791f, -0.00485788f, 0.00723524f, 
    0.07532325f, -0.03301667f, -0.02283032f, -0.01441553f, -0.04474253f, 0.06776831f, 0.07575971f, 0.09338720f, 
    -0.02570241f, -0.00648301f, 0.08919067f, -0.02507682f, -0.07482994f, 0.05426228f, 0.03425634f, 0.00040107f, 
    0.28131795f, 0.14770815f, -0.05633172f, 0.03512936f, 0.09343998f, 0.06428925f, 0.00308981f, 0.14486787f, 
    -0.05364164f, -0.06605048f, -0.02585069f, 0.02141716f, -0.14179063f, -0.05876800f, 0.00920800f, 0.11013995f, 
    0.01292504f, 0.06603616f, -0.09828901f, -0.01915486f, 0.05377352f, 0.10737288f, 0.11485722f, 0.07496689f, 
    0.01449979f, -0.02514306f, -0.12182512f, -0.09580901f, -0.01303342f, -0.10982602f, -0.00257027f, -0.06994399f, 
    0.02865434f, -0.02675536f, 0.01380352f, -0.00539287f, 0.03363838f, 0.15069720f, 0.23790677f, -0.01507056f, 
    0.04763576f, -0.01389113f, -0.05055170f, 0.12952897f, -0.08255383f, -0.02614835f, 0.04302851f, 0.05739321f, 
    0.22988175f, -0.13308223f, -0.08158263f, -0.07155970f, -0.01407650f, 0.04776088f, 0.03118205f, -0.02410144f, 
    -0.09546125f, 0.02622221f, -0.02241277f, -0.06347039f, 0.24393408f, 0.05878671f, 0.30237883f, 0.04991541f, 
    0.03590532f, 0.09402662f, -0.09802932f, 0.07967962f, 0.18701221f, -0.04185156f, 0.09755337f, 0.05339156f, 
    -0.00254825f, -0.04559395f, 0.03253981f, -0.08110894f, 0.00700760f, -0.04643469f, 0.06042807f, -0.09115764f, 
    0.01628781f, -0.01004394f, 0.11750904f, 0.10013995f, 0.10428085f, 0.10185566f, -0.03461772f, 0.05997770f, 
    -0.05749531f, 0.08167583f, -0.05362654f, -0.03906433f, 0.07322959f, -0.05542610f, -0.10315173f, 0.02843854f, 
    -0.03095642f, 0.00763414f, -0.27591041f, 0.04279344f, -0.00463174f, -0.04079312f, -0.00043381f, 0.07469753f, 
    0.08160347f, 0.00911809f, 0.00563088f, 0.12937233f, -0.13438122f, 0.00816002f, 0.13382404f, 0.02907848f, 
    0.04681094f, -0.09053541f, -0.02686426f, -0.01235090f, -0.09780421f, -0.02702834f, 0.07622147f, 0.05253029f, 
    0.16403915f, -0.15984063f, -0.08063873f, 0.04046575f, 0.07830439f, 0.05528388f, 0.00281665f, 0.10300028f, 
    -0.04509785f, 0.03747016f, -0.00218626f, 0.04658895f, 0.07635932f, 0.12492227f, 0.02467796f, -0.06718708f, 
    -0.07824492f, -0.01713219f, 0.01398210f, -0.03211186f, 0.18518911f, 0.04393954f, 0.01647742f, -0.05493402f, 
    -0.12801999f, 0.02845979f, 0.08801500f, -0.04156898f, -0.07493870f, -0.00820567f, 0.05386031f, -0.00784354f, 
    0.01255963f, -0.03489158f, -0.05563178f, -0.01356196f, 0.09911785f, 0.15146306f, 0.07343181f, -0.02373411f, 
    -0.17621286f, -0.11852008f, -0.04029250f, -0.00098518f, -0.00766920f, 0.09098098f, 0.10298339f, -0.13458684f, 
    -0.15948279f, 0.09957579f, -0.12729940f, -0.01352283f, -0.05327661f, 0.09515610f, 0.05405933f, 0.04636900f, 
    -0.02485332f, 0.02981711f, 0.00413430f, -0.12293317f, 0.02677607f, 0.11097792f, -0.02479795f, 0.04509449f, 
    -0.02145335f, 0.02957694f, -0.03373649f, -0.01613374f, -0.10368410f, 0.00188902f, 0.08130132f, -0.02813213f, 
    0.00471552f, -0.02099474f, 0.12715894f, 0.11621000f, 0.14973085f, -0.02553459f, -0.02311944f, 0.00680545f, 
    -0.02756473f, -0.07889406f, -0.02048985f, 0.03577843f, 0.24376222f, 0.17237468f, -0.03155420f, 0.10909571f, 
    0.04822999f, -0.03083676f, -0.05616628f, -0.00859726f, -0.00499797f, -0.11811947f, -0.02937461f, -0.08947328f, 
    -0.14987150f, 0.07102332f, -0.09194198f, -0.03936008f, 0.03430986f, 0.00045944f, -0.06686816f, -0.03811889f, 
    0.06869905f, 0.00097551f, 0.03167171f, 0.04674730f, -0.07707702f, -0.13825825f, -0.14146721f, -0.03595845f, 
    0.09099009f, 0.09016721f, 0.03589821f, 0.04290783f, 0.08388627f, -0.01673491f, 0.08714624f, -0.10081714f, 
    -0.08068692f, 0.31219590f, -0.01672648f, 0.02148283f, 0.01614747f, 0.15841337f, -0.06717914f, -0.03425580f, 
    -0.01249527f, 0.12714209f, 0.06156393f, 0.07466920f, -0.05086968f, 0.20133828f, -0.11603156f, 0.09269533f, 
    -0.01246136f, 0.01390103f, -0.02003871f, -0.05403585f, 0.04263556f, 0.08670492f, 0.13240755f, 0.05053693f, 
    0.01460826f, -0.00391706f, -0.01088855f, 0.09044565f, 0.01307836f, -0.08372566f, 0.06916320f, -0.08550806f, 
    -0.06606737f, 0.11899891f, 0.06402507f, -0.06746891f, -0.00244102f, -0.14284135f, -0.21218438f, -0.09461154f, 
    0.06640707f, 0.03958034f, -0.04218988f, -0.09320240f, -0.03661576f, -0.05222170f, 0.00765558f, 0.03393206f, 
    0.27963418f, 0.27131191f, -0.13882284f, -0.07082229f, -0.09644298f, -0.09307662f, 0.01436258f, 0.01852653f, 
    0.05712872f, 0.06461431f, -0.01182599f, 0.18090060f, -0.12139349f, 0.10447706f, 0.07361213f, 0.01718056f, 
    -0.05520047f, 0.01793596f, -0.01766178f, 0.00359594f, -0.02324996f, 0.09855729f, 0.11386165f, 0.06039159f, 
    0.06167105f, -0.08995704f, 0.10864338f, -0.13294035f, -0.11501726f, 0.05062758f, -0.00876897f, 0.05096423f, 
    0.00289134f, 0.01617141f, -0.05086467f, -0.05521882f, 0.08223676f, 0.17346090f, -0.05461143f, 0.26646283f, 
    -0.06353357f, 0.05782184f, -0.09425483f, 0.08217330f, 0.06814897f, -0.00965579f, 0.11364271f, 0.09640456f, 
    -0.20966446f, 0.04997989f, -0.02272307f, -0.27520308f, -0.00891229f, -0.11976346f, -0.03684674f, 0.02544290f, 
    -0.02005860f, -0.15093040f, 0.01016981f, -0.25031790f, 0.00694171f, -0.27675980f, 0.07273302f, 0.04264042f, 
    0.17385857f, 0.17726305f, -0.05207897f, 0.07604115f, 0.04194364f, 0.02291834f, 0.07695622f, -0.09929414f, 
    -0.21985465f, -0.10213753f, 0.19517642f, 0.00170068f, 0.05196157f, 0.04718271f, 0.11389593f, 0.15273763f, 
    0.11445008f, 0.05753841f, -0.01669659f, 0.06017935f, 0.24586876f, -0.10064785f, 0.17221272f, 0.12483439f, 
    -0.06645025f, -0.07562962f, 0.04132945f, 0.04148673f, -0.02005440f, 0.09521320f, -0.01667438f, -0.05000429f, 
    -0.07622821f, 0.05305280f, 0.08357367f, -0.13753718f, -0.11460475f, 0.03567635f, 0.11525563f, 0.22663565f, 
    -0.01908766f, 0.00424273f, -0.01264518f, -0.00081964f, -0.20180987f, -0.03595648f, 0.22739100f, 0.01835951f, 
    -0.08537057f, -0.04207139f, -0.02876100f, -0.01244736f, 0.04649590f, 0.06395275f, 0.17632195f, 0.03466752f, 
    0.07661700f, -0.13900316f, -0.28404999f, -0.14115155f, 0.06306762f, -0.10942146f, -0.08321382f, 0.10080466f, 
    0.03597783f, -0.00256873f, 0.08858773f, 0.09175427f, 0.00942593f, -0.04881112f, 0.20314640f, 0.12019296f, 
    0.15343539f, 0.00867058f, -0.00016945f, 0.15151033f, -0.08870769f, 0.00573967f, -0.02623906f, -0.09615352f, 
    0.32621095f, -0.12056550f, -0.00896567f, -0.21443410f, 0.13378687f, 0.02458581f, 0.05345628f, 0.06316189f, 
    -0.06737059f, 0.02066982f, 0.02042614f, -0.00864957f, 0.00032864f, -0.12731706f, 0.03625909f, 0.08522554f, 
    -0.05085267f, 0.15272699f, -0.13010730f, -0.00842335f, 0.06950992f, -0.08921212f, -0.14628832f, 0.02027970f, 
    -0.04369375f, -0.03759149f, -0.05735848f, 0.02999674f, -0.14100416f, -0.02977940f, 0.06577568f, 0.00363579f, 
    -0.11437313f, 0.06553151f, 0.04160267f, 0.00079838f, 0.22288221f, -0.07491859f, 0.05968436f, 0.01981254f, 
    0.00825375f, 0.23858935f, -0.04304519f, 0.00923580f, 0.02856117f, 0.15265436f, 0.10596731f, 0.01830723f, 
    -0.15048744f, -0.08403677f, -0.19025797f, 0.25781655f, 0.15446188f, 0.00613072f, -0.03676308f, 0.01727170f, 
    0.18911603f, -0.05198857f, -0.02849393f, 0.14574869f, 0.21146283f, 0.04520075f, -0.20795634f, -0.03460012f, 
    0.06927576f, -0.05456363f, -0.05024424f, 0.09698387f, -0.12618987f, 0.06739397f, 0.08203234f, 0.12983036f, 
    -0.04913174f, -0.21432301f, -0.01490762f, -0.18852098f, 0.15634522f, 0.04791850f, -0.10302518f, 0.09468690f, 
    0.11029647f, -0.00092344f, 0.01885293f, 0.03573394f, 0.19359514f, 0.23576596f, -0.03606169f, -0.11836442f, 
    0.00816124f, 0.07910920f, 0.15506461f, -0.02188678f, 0.09833010f, -0.09201286f, -0.13879801f, -0.12269427f, 
    -0.08181863f, 0.11017614f, 0.31850037f, -0.02100321f, -0.09851038f, 0.11497091f, 0.10799368f, -0.03796346f, 
    -0.04979308f, -0.02968699f, 0.03512562f, -0.03373807f, 0.17843528f, 0.17533647f, 0.21511468f, 0.05702456f, 
    -0.17930146f, -0.05976471f, -0.09628573f, 0.04264263f, -0.12815312f, -0.02170119f, 0.10218506f, -0.09272012f, 
    -0.23558417f, 0.13190562f, -0.20376420f, 0.10605301f, 0.04321155f, 0.15176293f, -0.04304496f, 0.06087296f, 
    -0.02366457f, -0.00053872f, 0.08221389f, -0.12237197f, -0.17791680f, 0.10093062f, 0.02315454f, 0.05840256f, 
    0.07449632f, 0.07374341f, -0.05521964f, 0.09851808f, -0.07892741f, 0.09277101f, 0.08354267f, 0.05945177f, 
    0.11673271f, -0.08589446f, -0.18873668f, 0.08240781f, -0.06848866f, 0.02297195f, 0.03478857f, 0.07512560f, 
    -0.15632154f, 0.09365020f, -0.05761703f, -0.05109891f, 0.38674107f, 0.22327462f, -0.19649729f, -0.01922698f, 
    0.06525137f, 0.10116942f, 0.00036711f, 0.11981238f, 0.03385482f, -0.15112655f, -0.06637774f, -0.04805615f, 
    -0.20520295f, -0.08334335f, -0.17239939f, -0.01532598f, -0.02912853f, 0.02093363f, -0.01761562f, 0.01264567f, 
    0.01813961f, -0.05653573f, 0.16898300f, 0.13909481f, -0.25110093f, -0.20583244f, -0.00880283f, -0.11758757f, 
    0.15445039f, -0.01947019f, 0.06299526f, -0.04484917f, 0.04469321f, 0.14896610f, -0.01959793f, -0.08346546f, 
    0.06308496f, 0.00591747f, 0.07165977f, 0.21417484f, -0.13185893f, 0.02971294f, 0.00740797f, -0.03198110f, 
    0.01153889f, -0.02103178f, 0.07246881f, 0.10725243f, -0.16123129f, 0.16420951f, -0.10431006f, -0.07221151f, 
    -0.00010073f, 0.09864036f, 0.05900223f, -0.09608572f, 0.07679902f, 0.04974079f, 0.08415917f, 0.11403758f, 
    -0.13674115f, -0.15147641f, 0.20569614f, -0.15083657f, 0.13603725f, 0.00623981f, 0.04484200f, 0.07250500f, 
    0.14067289f, 0.11898036f, 0.03851723f, 0.02498578f, -0.18299805f, -0.10749971f, 0.10471874f, -0.32139641f, 
    -0.06729916f, 0.04762682f, -0.07694647f, -0.03374450f, 0.00117595f, -0.06586207f, 0.06802993f, -0.16608760f, 
    -0.01249459f, -0.00235980f, 0.03874091f, -0.04554662f, 0.02531904f, -0.05053224f, -0.05703470f, 0.00560247f, 
    -0.00918515f, 0.01455212f, -0.04089297f, -0.00938101f, 0.02533816f, 0.03359271f, -0.02535651f, -0.00183917f, 
    -0.00895017f, -0.03047563f, -0.03926780f, 0.00888680f, -0.02736406f, 0.01585848f, 0.00310349f, 0.00428412f, 
    -0.00439635f, -0.02094080f, -0.04249109f, -0.02985834f, 0.01172588f, -0.04680677f, 0.02664489f, -0.00568050f, 
    -0.04202074f, 0.03540557f, 0.04500542f, -0.04023958f, -0.05042009f, -0.04687940f, 0.00557085f, 0.04016853f, 
    0.00830467f, 0.03317215f, -0.03142405f, -0.04921004f, 0.03560611f, 0.01012611f, -0.03489845f, -0.05053377f, 
    0.03238573f, -0.02591204f, 0.02549862f, 0.02273061f, 0.00681215f, 0.03512200f, -0.00624578f, 0.00849786f, 
    0.00819216f, 0.03445600f, 0.00765229f, -0.02349951f, -0.01719413f, -0.01741589f, 0.02197595f, 0.00592932f, 
    0.04139182f, -0.03296651f, -0.02593128f, 0.03422426f, -0.05145557f, -0.02656109f, -0.00812855f, -0.04199681f, 
    0.01464474f, -0.05171396f, 0.01593655f, -0.03865516f, -0.04339103f, 0.03442628f, -0.01170815f, 0.01492961f, 
    -0.00727195f, -0.00658907f, -0.03965330f, -0.05535078f, -0.03390386f, 0.03121856f, -0.05670981f, 0.03560593f, 
    -0.00158401f, 0.01838000f, 0.00071109f, 0.02655332f, -0.04486930f, -0.01637268f, -0.05345881f, 0.01662933f, 
    -0.00472620f, -0.04505189f, 0.00203609f, -0.00104323f, 0.02373578f, -0.00830897f, -0.00200176f, 0.00750800f, 
    -0.03215819f, -0.04731977f, -0.03103513f, -0.01147658f, 0.02044867f, 0.04166334f, -0.00432968f, -0.05529010f, 
    0.02329951f, -0.03793589f, 0.01544077f, 0.03952156f, -0.00466446f, -0.04044377f, -0.00633910f, -0.00069762f, 
    -0.01588554f, -0.04193606f, -0.04382316f, 0.01267579f, -0.01678044f, -0.04899187f, 0.00144690f, 0.04020514f, 
    0.03020915f, -0.02111467f, -0.05597415f, 0.03714972f, -0.00783386f, -0.00310316f, -0.02299513f, 0.00422256f, 
    -0.02078229f, 0.00908576f, -0.04645984f, 0.01886493f, -0.05463370f, -0.00634889f, -0.03837169f, -0.04026673f, 
    -0.03828166f, -0.01744167f, 0.02524567f, -0.03093061f, 0.00701484f, -0.02568070f, -0.02227678f, -0.00798486f, 
    0.01994505f, -0.03232177f, -0.05509659f, 0.00696380f, 0.01253991f, 0.00667113f, -0.02115503f, 0.01556008f, 
    -0.04668920f, 0.01670665f, -0.05464985f, 0.04048682f, 0.03062863f, 0.02378444f, -0.01236800f, 0.03943233f, 
    -0.05190503f, -0.00186451f, -0.02598554f, -0.03909935f, -0.04967353f, -0.04273172f, -0.03227170f, 0.03981095f, 
    -0.03493812f, -0.04740755f, 0.02542035f, -0.00457623f, -0.04000322f, -0.00643392f, -0.05591528f, -0.03622781f, 
    -0.02017815f, -0.01679000f, -0.03307640f, 0.00791144f, 0.02445697f, 0.01251904f, -0.01396013f, 0.01918338f, 
    0.04251528f, 0.03422880f, 0.01914295f, 0.03914431f, 0.02515235f, -0.03290794f, -0.02651073f, -0.00944581f, 
    0.02278922f, 0.02936000f, 0.03248797f, 0.03669589f, 0.03512694f, -0.01976313f, 0.01328250f, -0.04704511f, 
    -0.05168590f, 0.04115411f, -0.01430056f, 0.03346765f, 0.02120215f, -0.05295982f, 0.00964054f, 0.01334329f, 
    0.02185478f, -0.04110030f, -0.01700524f, 0.01706346f, -0.05655386f, 0.02552185f, -0.02813257f, 0.03746972f, 
    -0.00720751f, -0.02252462f, -0.02201897f, -0.04263380f, -0.04395922f, 0.04379823f, 0.04945702f, 0.02795099f, 
    -0.04305141f, -0.03381595f, -0.00371697f, 0.02528702f, 0.02138629f, -0.03369734f, 0.03945702f, -0.00281227f, 
    0.03080339f, 0.02641099f, -0.05169180f, -0.01912250f, -0.04014239f, -0.04623136f, 0.03352790f, -0.01723792f, 
    0.04303503f, -0.04776782f, -0.03939877f, -0.04206799f, -0.03035853f, -0.03592962f, -0.03697579f, 0.01802826f, 
    -0.04840223f, -0.03896191f, 0.00563398f, 0.01331222f, 0.04360075f, 0.02995996f, 0.01261096f, -0.00915790f, 
    -0.00422748f, 0.02294565f, 0.01416776f, -0.05443332f, 0.01275243f, -0.05675804f, -0.02589944f, 0.00508140f, 
    0.00897122f, 0.02049303f, -0.01774360f, 0.02153909f, 0.02719792f, -0.04972389f, -0.02623526f, -0.02954162f, 
    -0.03510844f, 0.02338403f, 0.02879333f, 0.02250304f, -0.01657728f, -0.03873506f, -0.05617447f, -0.04935546f, 
    0.01853242f, 0.03884905f, -0.02982050f, 0.03257354f, -0.01929280f, 0.01354739f, -0.03956707f, 0.01010229f, 
    0.02401323f, 0.02955874f, -0.01286679f, 0.02982602f, 0.02852192f, -0.03822258f, -0.02230831f, -0.05518507f, 
    0.00069472f, 0.03055009f, -0.02805032f, 0.00008092f, 0.01661250f, -0.04305532f, 0.02971289f, -0.02100887f, 
    -0.02916791f, -0.02408623f, 0.01808965f, -0.00435483f, -0.01457866f, -0.03501103f, -0.00834156f, 0.02430133f, 
    0.02078670f, -0.01115670f, 0.04137421f, 0.04093962f, -0.03017357f, -0.01845278f, 0.02162860f, 0.01071471f, 
    -0.01971498f, -0.03971570f, -0.04000644f, -0.02438255f, -0.05054067f, -0.00260625f, -0.05365450f, 0.00755778f, 
    -0.02217467f, -0.03302454f, -0.01988916f, -0.02672730f, 0.02893186f, -0.01358556f, 0.00274544f, -0.03323099f, 
    -0.00119996f, -0.04098138f, -0.02259202f, -0.02611873f, -0.05005240f, 0.01147033f, 0.02316667f, 0.00136440f, 
    -0.05392248f, 0.04868859f, 0.03583568f, -0.01068414f, 0.03070642f, 0.00075604f, 0.03281031f, -0.01318403f, 
    0.02600732f, 0.01120423f, 0.04304787f, 0.02498767f, 0.04132948f, -0.01941236f, -0.04945305f, 0.00463775f, 
    -0.04850022f, -0.02069392f, -0.03973148f, -0.04580428f, 0.04083605f, 0.00135689f, -0.02104299f, -0.01892446f, 
    -0.00998757f, -0.02325309f, 0.00798484f, -0.04963683f, 0.04343425f, 0.00435927f, 0.03371349f, 0.04373151f, 
    0.00770451f, -0.13489667f, 0.02484026f, 0.01555610f, -0.02520959f, 0.01158110f, -0.03689877f, -0.01119249f, 
    0.05116536f, 0.09982704f, 0.03137611f, 0.12645642f, 0.21132132f, 0.01237091f, -0.10318892f, -0.13013496f, 
    -0.05360369f, -0.01083591f, -0.06367131f, -0.08246021f, -0.03654973f, 0.01179790f, -0.06126230f, 0.04567124f, 
    -0.29533386f, 0.12668049f, 0.18116802f, 0.01788405f, 0.09875344f, -0.03856006f, 0.08415066f, -0.09270947f, 
    0.00392149f, -0.10817386f, -0.02469491f, 0.01618661f, 0.08544057f, -0.30217797f, 0.05430330f, -0.31422687f, 
    0.10699661f, 0.10636035f, 0.10498061f, -0.06511660f, -0.02725741f, 0.02770087f, 0.01559176f, 0.01533901f, 
    0.32652521f, -0.07211330f, 0.12696832f, 0.25587022f, -0.22592609f, 0.18153504f, 0.05636406f, 0.03240190f, 
    0.06201015f, -0.05437822f, -0.07586580f, 0.06179095f, -0.25040257f, 0.34383956f, 0.08411715f, -0.11612041f, 
    -0.02853586f, -0.08497533f, 0.14891772f, -0.05015179f, 0.09058386f, 0.00845449f, 0.05851928f, 0.11806478f, 
    -0.05289214f, -0.19957685f, -0.14890943f, -0.05953971f, 0.00112314f, -0.04028611f, -0.05340375f, -0.10011704f, 
    -0.00822899f, 0.05275711f, 0.10256358f, 0.03782385f, -0.05392357f, 0.01635083f, -0.07912380f, -0.19925322f, 
    0.10468858f, 0.05239339f, 0.07160950f, 0.02383722f, 0.00202163f, -0.02981504f, -0.00228037f, 0.15920040f, 
    0.16649428f, -0.01218632f, -0.08711864f, 0.08899188f, 0.00377356f, -0.00034971f, 0.08192825f, 0.00512308f, 
    0.01871395f, -0.00648721f, -0.02940656f, 0.02996937f, 0.16628635f, 0.18473111f, -0.09927043f, 0.00574395f, 
    -0.07257161f, 0.02236020f, 0.08775583f, 0.14707381f, -0.10165397f, -0.02235315f, -0.03251144f, 0.05859447f, 
    -0.07040927f, 0.00610292f, 0.16405670f, 0.08255287f, -0.11647817f, 0.05363011f, 0.04969311f, -0.02173125f, 
    0.07989872f, 0.00457294f, -0.06946602f, 0.01653464f, 0.19174677f, -0.05851162f, -0.17966951f, 0.02981143f, 
    -0.07900882f, 0.01355246f, 0.03620658f, 0.05194998f, -0.06260356f, 0.02801715f, -0.09349940f, -0.01832078f, 
    -0.00952465f, -0.07980420f, 0.09163747f, 0.13024741f, -0.01313051f, 0.14030640f, 0.02627787f, -0.01437370f, 
    -0.06595203f, -0.05652919f, -0.04942029f, 0.00505811f, -0.13777599f, 0.14418979f, -0.04021608f, 0.08925426f, 
    -0.13262925f, -0.00819518f, 0.14451759f, 0.02193534f, -0.01253392f, 0.02138979f, -0.02746829f, -0.12376361f, 
    -0.09658455f, 0.09145716f, 0.05664162f, -0.01170660f, -0.03438380f, 0.00883254f, -0.01826739f, 0.05589061f, 
    0.12806049f, -0.04996339f, -0.01288303f, 0.04595387f, -0.02945442f, -0.07557733f, -0.07784410f, 0.14307378f, 
    0.06610825f, -0.01160806f, 0.08094449f, 0.08817151f, -0.05849059f, -0.04961176f, 0.00089973f, 0.03796200f, 
    -0.04384227f, 0.07167914f, -0.05995398f, -0.00997149f, -0.06905281f, -0.02433829f, 0.00032710f, 0.13308649f, 
    -0.10360932f, 0.05614925f, 0.01682885f, -0.03105965f, 0.06337040f, -0.12305512f, 0.09609231f, 0.05359631f, 
    -0.09774409f, 0.02327306f, 0.12387555f, 0.08453225f, 0.01100594f, 0.06016060f, 0.00439190f, -0.07851650f, 
    -0.09778086f, 0.12196478f, 0.14545594f, 0.08730817f, -0.03379725f, -0.09718728f, -0.08204217f, 0.03461789f, 
    -0.04367560f, 0.05220807f, -0.05248377f, -0.06554686f, 0.03881547f, -0.02478630f, 0.03526667f, 0.01580553f, 
    -0.02682977f, -0.07294674f, -0.00779808f, 0.01861420f, 0.00344766f, -0.02559486f, 0.12476940f, -0.04628235f, 
    -0.01296913f, 0.14203730f, -0.22220348f, 0.06824972f, 0.11527798f, 0.00630554f, -0.02804662f, 0.06561493f, 
    -0.10004650f, 0.08425309f, 0.00122740f, -0.02186445f, 0.03879973f, -0.00267746f, -0.06743218f, -0.02604228f, 
    0.04308092f, -0.06679825f, -0.07655613f, -0.01854018f, 0.07953765f, 0.08210642f, -0.01078616f, 0.01841816f, 
    -0.01531511f, -0.22904658f, 0.12572500f, -0.06250358f, -0.12761766f, -0.05524558f, -0.04870962f, 0.04105424f, 
    -0.06032655f, 0.01027328f, -0.08662892f, 0.03598884f, 0.42797431f, -0.19841556f, -0.06522665f, 0.03125912f, 
    -0.05166711f, -0.07905266f, 0.00656272f, 0.07304262f, -0.05818544f, 0.08949824f, -0.10368963f, 0.04235752f, 
    -0.13340056f, -0.00820509f, 0.24463198f, 0.10171776f, 0.10314226f, 0.14723566f, 0.03487773f, -0.04503495f, 
    0.03917517f, 0.08066340f, 0.03424605f, -0.01230099f, 0.19458789f, 0.08274681f, 0.11266187f, 0.16306907f, 
    0.05459954f, 0.06359515f, 0.01792031f, -0.05082149f, -0.03224086f, -0.02551244f, -0.00819016f, 0.15916167f, 
    0.18326268f, 0.10026883f, -0.03037414f, 0.05192344f, -0.11529765f, -0.01860627f, 0.12358212f, 0.10424904f, 
    0.01789682f, 0.13459374f, 0.00682168f, 0.09520471f, 0.18432960f, 0.05631491f, 0.13262132f, 0.03081156f, 
    -0.01765132f, 0.05616828f, -0.01526653f, 0.16095479f, 0.02756384f, -0.04698563f, -0.09995016f, -0.04105571f, 
    0.18490027f, -0.15751247f, -0.04137645f, 0.01558468f, -0.00566924f, -0.05382695f, 0.08243611f, 0.08326417f, 
    -0.05109210f, 0.12214581f, -0.02511580f, 0.02149622f, 0.36877513f, -0.06079925f, 0.08087680f, 0.03970008f, 
    0.03284176f, 0.01477855f, -0.05827846f, 0.10779534f, 0.02977100f, -0.02973773f, 0.06032230f, -0.02043778f, 
    -0.07097001f, 0.12654477f, -0.05669458f, 0.03497734f, 0.07943334f, 0.01657997f, 0.14301588f, 0.09279587f, 
    -0.04191387f, 0.06816714f, -0.09901266f, -0.00073083f, 0.36241588f, 0.16846302f, -0.07113552f, 0.18888079f, 
    -0.08662935f, -0.15085866f, 0.05580635f, -0.01036378f, 0.06764469f, -0.02229332f, -0.00905843f, 0.05410652f, 
    -0.00464113f, -0.04987220f, -0.01540432f, -0.01246984f, 0.02284673f, 0.00770766f, 0.02490938f, -0.00241301f, 
    -0.05784121f, 0.03585050f, 0.04092246f, -0.03707448f, -0.01592188f, -0.02248564f, -0.03505449f, -0.02402798f, 
    0.00544208f, -0.04626438f, -0.04589504f, 0.00570121f, 0.01599259f, 0.02727189f, -0.01731061f, 0.03013349f, 
    -0.03446592f, 0.01601593f, -0.02121878f, 0.01088138f, 0.00256963f, -0.05255019f, 0.01812469f, -0.03562737f, 
    0.02068769f, 0.03005784f, 0.03259319f, -0.05488553f, -0.06017100f, -0.05443669f, -0.03872712f, 0.02773101f, 
    0.00957300f, -0.04343494f, -0.05740301f, 0.00815953f, 0.00123415f, -0.00318313f, -0.02070014f, -0.04177928f, 
    -0.01744647f, 0.01193690f, -0.03891612f, -0.02321966f, 0.03776963f, -0.01379164f, 0.00661296f, -0.03887305f, 
    -0.05083401f, 0.00697390f, 0.04170896f, 0.03447356f, 0.03384275f, -0.02132891f, 0.02088397f, -0.03207949f, 
    0.03170240f, 0.00103597f, 0.00701051f, -0.03513825f, -0.01348103f, -0.05797613f, 0.03272030f, -0.02183435f, 
    0.01708752f, -0.02787574f, 0.03196397f, 0.01097629f, 0.01696081f, -0.05879565f, 0.03410397f, 0.00205442f, 
    -0.00713423f, -0.00625180f, 0.03511586f, 0.02796534f, -0.00232450f, -0.00615303f, -0.04960248f, -0.02360516f, 
    -0.01501423f, -0.05524491f, -0.05816213f, 0.01387084f, 0.02434034f, -0.05694202f, 0.02920622f, -0.04372800f, 
    0.02309878f, -0.02314794f, -0.04368759f, -0.02884016f, -0.03294962f, -0.03472166f, 0.01683053f, 0.00597271f, 
    0.03386258f, 0.01270765f, 0.03210717f, -0.03640214f, -0.03345674f, -0.03138509f, 0.02724535f, 0.00493173f, 
    -0.01841434f, -0.03905691f, -0.00346994f, 0.03934044f, -0.00016164f, -0.00283389f, 0.02157348f, 0.01753299f, 
    -0.00954130f, -0.01865613f, -0.04730604f, 0.03120726f, -0.02717497f, -0.04142352f, -0.00172902f, -0.02196553f, 
    -0.01420856f, -0.02125375f, 0.03412123f, 0.02316118f, -0.04915756f, -0.03378984f, 0.03849112f, 0.01517084f, 
    -0.00731471f, -0.03218868f, -0.03286637f, 0.00655610f, 0.04022497f, 0.02591837f, 0.03803711f, -0.05873919f, 
    0.00227790f, -0.00800626f, -0.05529995f, -0.00740931f, 0.03099879f, 0.02123028f, -0.05204973f, -0.02384707f, 
    -0.03124605f, -0.03378305f, -0.04057559f, 0.02796291f, 0.02791101f, 0.02909532f, 0.02748922f, 0.01861439f, 
    0.00146678f, 0.02071561f, -0.00436217f, 0.04642286f, -0.01421225f, -0.01709965f, -0.04028442f, -0.03518972f, 
    -0.05906635f, -0.00150689f, 0.02029137f, -0.04256733f, -0.01266950f, -0.03930340f, 0.03109130f, -0.00144230f, 
    -0.03605647f, -0.05666125f, 0.02813005f, 0.02006817f, -0.04170933f, -0.00502006f, 0.00855371f, -0.05211371f, 
    0.03959062f, 0.01954146f, -0.00850280f, -0.00873184f, -0.04645566f, 0.03186747f, -0.00505752f, 0.01609215f, 
    -0.02779850f, -0.00627019f, -0.04498015f, 0.03853616f, -0.05842878f, -0.04309793f, -0.02210079f, 0.01283317f, 
    -0.02741192f, 0.02272114f, -0.00323159f, -0.01986641f, 0.01438625f, -0.00369549f, 0.00850033f, 0.01578896f, 
    -0.04267705f, -0.02756260f, -0.00009290f, 0.00439080f, -0.05162823f, 0.01447143f, -0.02274852f, -0.05104198f, 
    -0.00310009f, 0.00896645f, 0.00645017f, -0.05724093f, -0.04220245f, 0.04071188f, 0.02722913f, -0.04478286f, 
    0.03202150f, -0.04449554f, 0.00653488f, 0.02249719f, 0.03071538f, 0.02897032f, 0.01534328f, 0.01246591f, 
    -0.02853838f, 0.01047344f, -0.01529355f, 0.00378598f, 0.00323841f, -0.01253965f, 0.03002801f, 0.02292222f, 
    -0.00846253f, 0.01114411f, 0.04088382f, -0.03002854f, -0.05358580f, 0.00398346f, -0.03115548f, -0.00980241f, 
    -0.02113531f, -0.05131037f, 0.04045466f, 0.00656623f, -0.04653591f, -0.03071752f, -0.03395851f, -0.04917592f, 
    -0.02351367f, -0.03549742f, 0.03994601f, -0.04710149f, 0.00283807f, -0.00855521f, -0.03626375f, -0.01348619f, 
    -0.03521100f, 0.01383356f, 0.03385494f, 0.02392956f, 0.00082686f, -0.05207235f, -0.02663665f, 0.02837000f, 
    0.02439364f, 0.03030220f, 0.00038341f, 0.02966576f, 0.00074846f, -0.01040068f, -0.03926062f, -0.01250521f, 
    0.03379348f, -0.01361707f, -0.05486212f, 0.02640835f, 0.03849605f, -0.01724933f, -0.01690706f, 0.00475563f, 
    -0.01454689f, 0.00032702f, 0.02566062f, -0.01920233f, -0.00435399f, -0.01807181f, -0.01323997f, 0.02696477f, 
    -0.03857848f, -0.00369918f, 0.04018813f, 0.03090713f, 0.02405714f, -0.01912666f, -0.01347559f, 0.00820302f, 
    -0.02184337f, 0.01900704f, 0.02458487f, 0.02760316f, -0.02205466f, 0.02902063f, 0.03587509f, 0.00820419f, 
    0.02908762f, -0.02107324f, -0.03063395f, -0.05780794f, -0.05609058f, -0.05696099f, -0.05533240f, 0.00329297f, 
    -0.04805185f, 0.00756503f, -0.00113663f, 0.00882305f, -0.03924328f, 0.01240875f, -0.05515381f, -0.02093760f, 
    0.01312983f, -0.02376273f, -0.00128041f, -0.05232616f, -0.00038581f, 0.01587581f, -0.02820141f, 0.04028589f, 
    0.02531783f, -0.06000336f, 0.03105487f, -0.05229031f, 0.00075314f, -0.05715275f, 0.03289879f, 0.03781882f, 
    0.00422557f, -0.02955424f, 0.04877294f, -0.00564852f, -0.04767918f, -0.01088170f, -0.03670584f, -0.04638971f, 
    -0.02327117f, -0.04335654f, 0.02329359f, -0.04232585f, -0.02665622f, -0.01066180f, 0.02123915f, -0.03991173f, 
    -0.00544608f, -0.05175869f, -0.01866123f, -0.03643241f, 0.03500906f, -0.04280793f, -0.04775346f, -0.01669455f, 
    -0.02106597f, -0.05549232f, -0.04141108f, -0.03697388f, 0.02821734f, 0.02426635f, -0.00797800f, 0.03428597f, 
    -0.04716685f, 0.03864976f, 0.01040454f, -0.01267780f, 0.01620105f, -0.04014047f, 0.02870650f, 0.00809926f, 
    -0.22326487f, -0.25974283f, -0.02943520f, -0.14029080f, 0.05994957f, 0.06380977f, 0.09550077f, -0.00221888f, 
    -0.08259861f, -0.14424275f, -0.06466113f, -0.14615519f, 0.03142779f, 0.06499548f, 0.01407414f, -0.09563795f, 
    0.16385201f, 0.02621963f, 0.03029704f, -0.04942146f, 0.01239513f, -0.12792970f, -0.11857589f, 0.02134947f, 
    -0.22665879f, 0.04640856f, 0.00819814f, 0.03923356f, 0.09072200f, 0.02681101f, -0.03864190f, -0.04141512f, 
    -0.08657391f, 0.01879062f, 0.15470383f, -0.00450790f, 0.18762025f, -0.18234813f, 0.24337676f, -0.22357880f, 
    0.04867151f, 0.03145635f, -0.00536761f, -0.05205498f, 0.01351685f, 0.04522856f, -0.10972866f, 0.01514067f, 
    0.09460492f, -0.09183904f, 0.05025245f, 0.31678087f, -0.11423253f, 0.00101216f, 0.00775615f, 0.05911247f, 
    -0.00000949f, 0.14142169f, 0.04195143f, 0.16018125f, -0.04953536f, 0.15935875f, 0.00648855f, -0.19186155f, 
    0.07783104f, -0.16216287f, -0.00124968f, -0.02326206f, -0.09187483f, 0.06162746f, -0.07145526f, 0.14620486f, 
    0.20044544f, 0.08263606f, 0.00303966f, -0.02137187f, 0.06120652f, -0.05627342f, -0.15172388f, 0.01188816f, 
    -0.06286494f, 0.09344435f, 0.01155008f, 0.10950763f, -0.04772317f, 0.15406421f, 0.11620507f, -0.06487740f, 
    0.11056568f, 0.11210898f, -0.02569320f, -0.07559063f, -0.00826606f, 0.00713865f, -0.00607350f, -0.00176354f, 
    -0.04351845f, -0.18482387f, 0.04372259f, 0.03196288f, 0.03522313f, -0.07049919f, -0.02229283f, 0.03654517f, 
    0.02423956f, -0.04331543f, 0.06207957f, 0.02030818f, 0.00057044f, -0.01979693f, 0.00513837f, 0.05012315f, 
    0.07476605f, -0.08442724f, -0.00679232f, 0.07429763f, -0.11154550f, -0.14963508f, -0.16581002f, -0.02819182f, 
    0.20576283f, 0.09190875f, 0.09159596f, 0.34817782f, -0.01970940f, 0.09151177f, 0.03719362f, -0.02104165f, 
    0.01247136f, 0.07552374f, -0.01509202f, 0.08966581f, 0.01620771f, -0.07904789f, -0.10327710f, -0.03294196f, 
    -0.10369902f, -0.02685532f, -0.04317236f, -0.07564163f, 0.05471461f, 0.04472341f, 0.03036113f, 0.09057572f, 
    0.04313958f, 0.16737635f, 0.13688077f, 0.22308803f, -0.09136228f, -0.05372766f, -0.03436274f, 0.01678323f, 
    0.02605894f, -0.03038209f, 0.09403393f, 0.03074131f, 0.06587941f, 0.11983558f, -0.17344631f, -0.21211246f, 
    -0.00283642f, -0.04616513f, 0.10463794f, -0.10963273f, 0.00052349f, 0.11921152f, 0.05514554f, -0.04714433f, 
    -0.14111376f, 0.06428947f, 0.21152799f, -0.04362694f, 0.08671243f, -0.05240230f, -0.11878721f, 0.02828840f, 
    0.18011908f, 0.01831781f, -0.01443647f, -0.07322059f, 0.00388819f, -0.14588052f, -0.10085297f, -0.19081701f, 
    -0.04648521f, 0.02344852f, 0.06449580f, 0.05819957f, -0.00055851f, -0.04428017f, 0.19891794f, 0.04867498f, 
    0.40547770f, 0.02560287f, 0.08019566f, -0.09411454f, -0.00539813f, -0.05799600f, -0.07003946f, -0.02037133f, 
    -0.09936659f, -0.07850299f, -0.01020016f, -0.05911877f, -0.28690407f, 0.20846403f, 0.01783203f, 0.10230678f, 
    -0.05638242f, 0.09344565f, 0.05810835f, 0.12273360f, 0.00290876f, 0.05953784f, -0.05806715f, -0.06586123f, 
    -0.01539300f, 0.15832898f, 0.01101713f, 0.14327149f, -0.05326886f, -0.01221964f, 0.09735974f, -0.15487382f, 
    0.11040103f, 0.00905518f, 0.05790779f, 0.02558323f, -0.18276954f, -0.12891223f, 0.03604119f, 0.06023378f, 
    0.07352272f, -0.02662297f, -0.05504748f, 0.08877218f, -0.11250135f, 0.09549382f, 0.04151060f, 0.09590177f, 
    -0.06806432f, -0.15362900f, -0.09890890f, -0.02724773f, 0.02645798f, -0.02665102f, -0.08392683f, 0.10207659f, 
    0.12696458f, -0.06421462f, -0.00809710f, -0.01796890f, -0.06079360f, -0.01294176f, 0.02865363f, -0.05369205f, 
    0.04435708f, 0.13737416f, -0.00325444f, 0.03527357f, -0.02385720f, 0.03920530f, -0.12754503f, 0.14138789f, 
    0.38217032f, -0.00478848f, 0.18174540f, -0.01776467f, -0.01858538f, -0.08225407f, -0.03080926f, -0.06318173f, 
    0.05952819f, 0.02428494f, -0.07797681f, 0.01929767f, 0.39611378f, -0.13096164f, -0.02495893f, 0.00538077f, 
    -0.11164107f, -0.05103996f, -0.11118805f, 0.06574153f, 0.19008122f, -0.04067899f, 0.02065100f, -0.00564029f, 
    -0.19131871f, 0.12421345f, 0.00862250f, 0.02144648f, -0.16450615f, 0.06765069f, -0.04451712f, -0.05165543f, 
    0.07283498f, 0.12884659f, 0.02592336f, 0.02796012f, -0.25792161f, 0.00805768f, 0.04479823f, 0.01749549f, 
    -0.03879032f, -0.07996392f, 0.04398657f, -0.04364017f, 0.07335424f, 0.09916159f, 0.03927129f, 0.11006790f, 
    0.22879839f, 0.10631635f, 0.10143903f, 0.28348026f, -0.03652222f, 0.05579832f, -0.02486024f, 0.08246663f, 
    -0.03949613f, -0.01221984f, -0.00577491f, -0.06607962f, 0.16763964f, -0.04099030f, 0.09811158f, 0.21787788f, 
    -0.04849993f, -0.14967173f, -0.05419221f, 0.04410728f, 0.09493740f, -0.03561811f, -0.11182491f, 0.06154146f, 
    0.21934634f, -0.14210603f, -0.08183898f, -0.35118908f, -0.08912781f, -0.08457198f, -0.13020480f, 0.04417524f, 
    -0.02629164f, 0.00366427f, 0.02595788f, -0.14981045f, 0.28223631f, -0.26315781f, 0.12738024f, 0.18093501f, 
    0.02348021f, -0.01629942f, -0.01087169f, -0.02695817f, -0.01156132f, -0.05162932f, -0.10758936f, -0.11222810f, 
    -0.12403742f, -0.16663536f, -0.23824896f, 0.02534204f, -0.09835905f, 0.00544408f, -0.01541357f, -0.01337828f, 
    -0.09889587f, 0.06154506f, 0.04226698f, 0.12112758f, 0.22719748f, 0.03682530f, 0.01794108f, 0.40942222f, 
    -0.03633998f, -0.08018540f, 0.10383568f, 0.05290420f, 0.06147382f, -0.01493440f, 0.04264491f, 0.03679016f, 
    0.09658265f, -0.09205052f, 0.07088313f, 0.07578845f, 0.06231840f, -0.10169938f, -0.04414503f, -0.02410953f, 
    0.10282777f, 0.10799964f, -0.00708367f, 0.18083888f, 0.40812862f, 0.11203037f, -0.12048864f, -0.03540988f, 
    -0.03280423f, 0.06178946f, 0.01578511f, -0.07108219f, -0.05734852f, 0.09811883f, -0.06043487f, -0.00177169f, 
    -0.47788990f, 0.08452173f, 0.18447289f, 0.10446496f, -0.05142826f, -0.00178135f, 0.09606645f, -0.00001046f, 
    0.06572639f, -0.03102420f, -0.09942279f, 0.05244901f, 0.01671321f, -0.01993559f, -0.04913836f, -0.05294892f, 
    0.12713453f, -0.00654709f, 0.15779568f, -0.01979705f, -0.08363517f, -0.12452310f, 0.08719657f, -0.04101999f, 
    0.27606031f, 0.01113295f, 0.04023113f, 0.11800487f, -0.19278683f, 0.07927028f, 0.08643389f, 0.10738297f, 
    0.08402838f, -0.01037871f, -0.06113769f, -0.06291655f, -0.21626543f, 0.17978792f, 0.20479007f, -0.03906148f, 
    -0.17432831f, -0.11126354f, 0.05603126f, -0.01798110f, 0.08656525f, -0.02158532f, 0.01392168f, -0.04832812f, 
    -0.17096083f, 0.03962360f, -0.16643356f, -0.09303139f, 0.03578013f, 0.06213393f, 0.02659576f, -0.10076169f, 
    0.11254119f, 0.00322677f, 0.08863581f, -0.06189935f, -0.32703865f, 0.17006685f, -0.02963473f, -0.10716832f, 
    0.06008245f, 0.00026113f, 0.12921980f, -0.02209898f, -0.03357817f, 0.05954513f, 0.01040638f, 0.21058242f, 
    0.52499157f, 0.07500456f, -0.18887977f, 0.07871690f, 0.00656275f, 0.09860891f, -0.03470946f, -0.02927794f, 
    -0.05808944f, -0.03614753f, -0.08090635f, 0.04888566f, 0.13847858f, 0.04781669f, -0.06922770f, 0.01369879f, 
    -0.03671338f, 0.04418845f, -0.06077972f, 0.08477876f, 0.04848227f, -0.02248544f, -0.00527075f, 0.11880187f, 
    -0.18162608f, -0.23655151f, -0.02804224f, -0.01113389f, -0.10901777f, -0.03746302f, 0.12107109f, -0.00025293f, 
    0.05075369f, -0.07200486f, -0.04423930f, -0.04605848f, 0.30238259f, 0.02962932f, -0.16905305f, 0.12462375f, 
    0.00210627f, 0.07278126f, -0.08010460f, -0.00538482f, 0.04627929f, -0.02926808f, -0.07482675f, 0.08756027f, 
    0.04459626f, -0.19262612f, 0.04378742f, 0.01322693f, -0.09095421f, 0.07933015f, -0.02815545f, 0.04800580f, 
    -0.09143542f, -0.04417124f, 0.01039697f, -0.04604257f, 0.19576599f, 0.08154786f, 0.23226315f, 0.02625660f, 
    -0.01129730f, 0.09128619f, 0.12586157f, -0.01320324f, 0.03604992f, 0.01185560f, -0.02074032f, 0.00131646f, 
    -0.02784168f, 0.00824742f, 0.07820383f, 0.03323267f, -0.06994858f, -0.05215287f, 0.05691621f, -0.11994307f, 
    0.02039749f, -0.14219500f, 0.04666111f, 0.11768594f, 0.00153814f, 0.05296826f, -0.00895653f, 0.08947247f, 
    -0.04784038f, 0.06954823f, -0.06108528f, 0.06223780f, 0.09954149f, -0.16481967f, -0.11158122f, 0.02607070f, 
    -0.11239342f, 0.04636367f, -0.14018275f, -0.11171219f, -0.16125964f, 0.05701154f, -0.07009923f, 0.13260750f, 
    0.09088700f, 0.04066715f, 0.10220396f, 0.02659374f, -0.13417070f, -0.05747633f, 0.17563446f, 0.05308693f, 
    0.00738559f, -0.08035383f, 0.08391999f, 0.07936647f, 0.04066917f, 0.03887809f, 0.15109840f, 0.03715880f, 
    0.05246702f, 0.02788766f, 0.07606617f, 0.13138111f, -0.02789758f, 0.00348380f, -0.09760294f, -0.01369711f, 
    -0.04734340f, 0.04776165f, -0.17959486f, -0.00568287f, -0.02297174f, 0.03395804f, 0.00851810f, -0.04646044f, 
    -0.06422704f, -0.00217900f, 0.03659866f, 0.02558135f, 0.13697855f, -0.00933935f, 0.11471267f, 0.03134638f, 
    0.00097678f, 0.04360511f, -0.03472681f, 0.17812289f, 0.05526846f, 0.00679195f, -0.03269178f, 0.03111504f, 
    -0.01705376f, 0.14987272f, 0.03416648f, -0.07223316f, 0.01499528f, 0.16499944f, -0.07636831f, -0.13102150f, 
    -0.03658409f, -0.07447365f, 0.01368114f, -0.03848924f, 0.01543310f, 0.17750803f, -0.01509345f, -0.11777145f, 
    -0.13297310f, -0.18751605f, -0.06822222f, -0.07552414f, -0.15120481f, 0.01828400f, -0.04868507f, 0.05484324f, 
    -0.09902909f, 0.02762162f, -0.01493817f, -0.01665425f, 0.11713548f, -0.03946405f, -0.11828864f, -0.05744326f, 
    -0.10669466f, 0.02007480f, 0.00717680f, -0.01668501f, -0.03140341f, 0.02751194f, -0.00553489f, 0.03509231f, 
    -0.18149880f, -0.04050576f, 0.25915691f, 0.15632729f, 0.18551193f, 0.11326733f, 0.05510073f, 0.00519685f, 
    0.03472404f, 0.00234029f, 0.04071899f, -0.04645229f, 0.14120048f, 0.08046797f, 0.03249370f, 0.11653031f, 
    -0.01828545f, -0.02254603f, 0.01985624f, -0.05780750f, 0.01353597f, -0.17598975f, 0.03072069f, 0.09382001f, 
    0.04478052f, 0.08125114f, -0.01707046f, 0.07434844f, -0.01528699f, 0.07631887f, 0.08869272f, -0.01772384f, 
    0.05553773f, 0.08972044f, -0.03706369f, 0.10374648f, 0.15118442f, 0.08562846f, -0.06983380f, -0.04643782f, 
    -0.07465556f, 0.03677845f, 0.00565903f, 0.07712599f, 0.06476751f, -0.09355078f, -0.01309075f, -0.20384710f, 
    -0.12486806f, 0.26244906f, -0.04132811f, 0.00101021f, -0.00609167f, 0.06145558f, 0.01730141f, -0.11551626f, 
    -0.00263042f, 0.10531706f, 0.08870379f, 0.11277953f, 0.20741661f, 0.11557550f, 0.19098569f, 0.18510541f, 
    0.07350239f, -0.04562828f, -0.09913610f, -0.00111942f, -0.00409523f, -0.00381276f, 0.23480275f, 0.03634909f, 
    0.00922372f, 0.14036822f, 0.06418256f, 0.09121955f, 0.04988845f, -0.10519342f, 0.08984926f, -0.11023616f, 
    -0.13157964f, 0.06437308f, -0.04281836f, -0.06229864f, 0.22369719f, 0.21424063f, -0.19876356f, -0.01056634f, 
    -0.13956584f, -0.07777710f, -0.03677504f, -0.00084825f, 0.00083858f, -0.01972275f, -0.04558411f, 0.03114502f, 
    -0.04982483f, 0.01670372f, 0.03627300f, -0.04264197f, 0.04250035f, 0.03204876f, -0.04022038f, -0.02148118f, 
    -0.02795916f, 0.03500762f, 0.04330576f, -0.04306021f, -0.00627790f, -0.05307287f, -0.01490055f, 0.04005780f, 
    -0.03808046f, -0.03375299f, -0.03097987f, -0.01660934f, -0.01106249f, -0.01144369f, -0.00689967f, 0.02737308f, 
    0.03012663f, -0.02463070f, 0.04057085f, -0.01573061f, 0.02810994f, -0.03534674f, 0.02424100f, -0.00151548f, 
    -0.04974935f, -0.04225655f, 0.03637291f, 0.04284965f, -0.00174213f, 0.02086963f, -0.04950565f, -0.01187091f, 
    -0.00047634f, 0.02443323f, 0.02194747f, 0.02595008f, -0.01199791f, -0.00543289f, -0.05461627f, -0.02926010f, 
    -0.03059213f, 0.04330862f, 0.00207096f, 0.02243855f, -0.02805286f, -0.04156370f, 0.03625917f, 0.02684410f, 
    0.02580530f, -0.03264798f, -0.05552852f, 0.00825097f, -0.03757056f, -0.05161671f, 0.04045627f, -0.05021158f, 
    0.03299586f, -0.03857851f, -0.02811881f, -0.00497074f, -0.03442198f, 0.01892068f, -0.02073038f, -0.04924215f, 
    0.03193522f, -0.01507811f, -0.03635596f, 0.03286479f, -0.03195965f, -0.03381329f, 0.00038002f, -0.01548096f, 
    -0.03217540f, 0.00691668f, -0.00001509f, 0.03439695f, -0.01703296f, -0.02716652f, -0.05467071f, 0.01133852f, 
    -0.04294227f, -0.02364599f, -0.02337892f, -0.00540997f, -0.05654218f, 0.02046532f, -0.03555389f, -0.02338381f, 
    0.03766943f, -0.00641164f, -0.04891629f, 0.02844909f, 0.03556796f, 0.00614462f, -0.02631770f, -0.05466904f, 
    -0.01634382f, 0.02812403f, 0.04149647f, -0.01359452f, 0.02670022f, 0.00946465f, 0.01997979f, 0.03509391f, 
    -0.04148212f, -0.02199075f, 0.01633563f, 0.02958684f, 0.01676711f, -0.03780473f, -0.01420501f, -0.03375211f, 
    -0.04413623f, 0.01162079f, -0.00529216f, -0.02593303f, 0.01201611f, 0.03473896f, -0.01821231f, -0.04458446f, 
    0.01732766f, 0.03296706f, -0.05512623f, 0.02985998f, 0.02075367f, -0.03435524f, 0.00809220f, -0.03897062f, 
    0.01613883f, -0.01369284f, -0.05595062f, 0.02337966f, 0.03835739f, -0.02527758f, -0.02777474f, 0.03639179f, 
    -0.03648125f, 0.01393051f, -0.04691385f, 0.00400560f, -0.01001273f, -0.04134572f, -0.04645332f, -0.01967005f, 
    -0.01707233f, 0.00196705f, -0.03464083f, -0.05368723f, 0.03846473f, 0.02479981f, -0.04789561f, -0.00304332f, 
    0.02489836f, -0.05718639f, -0.01438299f, -0.03216668f, 0.00614606f, 0.00982899f, -0.00659099f, 0.04045508f, 
    0.01215359f, -0.04129262f, -0.04260284f, 0.04162892f, -0.00264425f, -0.01247784f, 0.03727299f, -0.04314822f, 
    0.01573480f, -0.01966083f, -0.03489511f, -0.04366939f, -0.03752457f, -0.02871543f, -0.02615885f, -0.03000490f, 
    -0.05575597f, -0.04476560f, 0.02973484f, 0.03892773f, -0.01588999f, 0.02299835f, -0.01390471f, -0.01175214f, 
    -0.00398144f, -0.00154559f, -0.01781684f, 0.00371698f, -0.03505753f, -0.03070327f, -0.05853132f, 0.02050300f, 
    -0.04613397f, 0.03825886f, 0.03156303f, -0.02853795f, -0.04512285f, -0.05578607f, -0.05732112f, -0.02968126f, 
    0.02228675f, 0.04130490f, -0.00477493f, -0.01079406f, 0.01721966f, -0.04230496f, -0.02707393f, -0.02817453f, 
    -0.05578936f, 0.01189294f, -0.02713233f, 0.04117570f, -0.03160836f, -0.05856120f, 0.04112768f, 0.02366817f, 
    -0.01987897f, -0.01495952f, -0.00417243f, -0.04129986f, -0.03600010f, 0.04064245f, -0.04886721f, 0.02348500f, 
    -0.01341022f, -0.05076304f, 0.02142808f, -0.01364406f, -0.04879292f, 0.00084820f, -0.05292900f, 0.02566095f, 
    -0.00120579f, -0.01550486f, 0.04679913f, -0.04265986f, 0.03957935f, -0.00725203f, -0.03329479f, 0.00870385f, 
    0.03128185f, 0.01401386f, 0.01658294f, 0.00928649f, 0.00464392f, 0.02881697f, -0.04842823f, -0.01894442f, 
    -0.04638759f, -0.01649623f, -0.01204275f, -0.04331346f, 0.03024401f, -0.02521130f, 0.02807489f, 0.01209067f, 
    -0.04138941f, -0.00795471f, 0.01462866f, 0.03663030f, 0.01172402f, -0.02849086f, -0.00897276f, -0.00532236f, 
    0.02189299f, -0.05627891f, -0.05561229f, -0.01602203f, -0.00942826f, 0.01118284f, 0.01313205f, 0.01100152f, 
    0.03052794f, -0.01935990f, 0.00699273f, 0.02867604f, -0.03776567f, -0.01770556f, 0.04063689f, -0.00611392f, 
    -0.00895714f, 0.00258479f, 0.00021217f, -0.04024765f, 0.00934290f, 0.00033197f, -0.02087285f, -0.01520877f, 
    -0.03794581f, -0.05051694f, 0.01796415f, 0.00533829f, -0.01560141f, -0.00836986f, -0.00670955f, -0.02617099f, 
    -0.05388288f, 0.02818306f, -0.01600519f, -0.00892862f, -0.05275919f, 0.03574567f, -0.04536840f, 0.01980372f, 
    -0.02565117f, -0.00360822f, 0.02491310f, 0.03893921f, -0.01530772f, -0.03254959f, 0.02656142f, -0.03347995f, 
    -0.01390366f, 0.00637512f, 0.01055433f, -0.00877296f, 0.02331751f, -0.02696177f, -0.03246066f, 0.02900567f, 
    -0.01930015f, -0.02759150f, -0.04323636f, 0.00909553f, -0.00451616f, -0.04275094f, -0.02283371f, 0.00641109f, 
    0.03622401f, -0.04367360f, 0.00594508f, 0.04292389f, -0.00278905f, 0.02370200f, 0.04146001f, -0.01435762f, 
    -0.04436375f, -0.04027667f, 0.02332388f, -0.02932794f, 0.00027974f, -0.00367174f, 0.01223994f, -0.00994354f, 
    -0.01708514f, 0.03629127f, -0.02539840f, 0.03564003f, 0.00546151f, -0.00027773f, 0.03051555f, 0.04318735f, 
    -0.01070887f, 0.01936022f, -0.03896603f, -0.00998416f, 0.03425230f, -0.03809453f, -0.04385559f, -0.05888469f, 
    0.02214609f, 0.01268609f, 0.03697152f, 0.02388619f, -0.01116756f, -0.03905438f, -0.01698299f, 0.01212793f, 
    0.03563913f, -0.04779141f, -0.05751206f, -0.00535291f, -0.04498307f, -0.02378316f, 0.02828621f, 0.00074352f, 
    -0.10819653f, 0.03893884f, -0.13485163f, -0.08486058f, -0.10095093f, -0.03879441f, 0.01063340f, -0.06652304f, 
    0.00006660f, 0.11592731f, -0.05029498f, 0.15385433f, 0.00676665f, -0.01682774f, 0.00593774f, 0.26681831f, 
    0.02042240f, -0.03189018f, -0.08832797f, -0.00233072f, -0.17652486f, 0.12682596f, -0.00723895f, 0.10598844f, 
    0.32608065f, 0.04044763f, -0.09994055f, 0.19681349f, -0.01554362f, -0.01763115f, 0.00282342f, -0.00558056f, 
    -0.06676470f, -0.06246371f, -0.15694800f, -0.01977192f, -0.03931312f, 0.02962305f, -0.04697312f, 0.06204509f, 
    0.02371035f, 0.05317092f, -0.01127421f, 0.00455967f, -0.03499338f, -0.07900129f, 0.02465644f, 0.03377491f, 
    -0.01865368f, 0.17822075f, 0.08004480f, 0.01693229f, -0.08085643f, 0.02152715f, -0.06521672f, -0.00801790f, 
    -0.11397576f, -0.07663957f, -0.05814233f, -0.10851220f, 0.10174585f, -0.03443060f, -0.10886389f, 0.03576227f, 
    0.04293701f, 0.09479146f, 0.10960564f, 0.03144559f, -0.08452440f, 0.00169350f, 0.01789995f, -0.12675676f, 
    -0.24556237f, -0.01013773f, 0.19372658f, 0.23061167f, 0.04644034f, 0.01884289f, 0.13769752f, 0.11747609f, 
    0.10290505f, -0.00216145f, 0.06689566f, -0.09509989f, -0.09064043f, -0.00801103f, 0.14163049f, 0.23311524f, 
    0.07627749f, 0.06716210f, 0.13363798f, 0.08003326f, 0.05606597f, -0.03356912f, 0.04578416f, 0.03002747f, 
    0.09705018f, 0.19866706f, 0.02051847f, 0.23189820f, -0.01598296f, 0.05600370f, -0.00721288f, 0.05069886f, 
    -0.01898156f, 0.12523024f, -0.02861992f, -0.02415867f, -0.09845593f, -0.00158770f, -0.07479991f, -0.03370453f, 
    -0.16065978f, 0.13645016f, -0.03747271f, -0.01076337f, 0.06959128f, -0.05620577f, 0.18099117f, -0.07634560f, 
    0.33859646f, -0.10224802f, -0.10103225f, -0.00025687f, -0.00132820f, 0.00157836f, 0.02757197f, 0.08425928f, 
    0.00548127f, -0.03666623f, -0.00071257f, 0.04690463f, -0.04307178f, -0.17913410f, 0.04278009f, 0.12446546f, 
    0.01921810f, -0.05000206f, -0.00725677f, -0.06311859f, -0.12784798f, -0.01075090f, -0.05435314f, -0.07923017f, 
    0.09955082f, 0.24959725f, -0.00302846f, -0.25630409f, 0.03005401f, -0.01703193f, 0.02356258f, 0.06687775f, 
    0.02347646f, -0.00820188f, -0.04944406f, -0.00633905f, 0.35929224f, -0.06965046f, 0.19207758f, 0.08556779f, 
    -0.05154832f, 0.14209120f, 0.11441379f, -0.02410631f, -0.00504779f, -0.08364935f, -0.06149925f, -0.09336530f, 
    0.09839972f, 0.05164490f, 0.12532988f, 0.25414345f, 0.02893753f, -0.00497369f, 0.06724047f, 0.02426546f, 
    0.01466263f, -0.03954536f, -0.01357586f, 0.02665271f, -0.02753025f, -0.02222083f, -0.14024572f, 0.00571836f, 
    -0.00375054f, -0.04948369f, 0.03756721f, -0.08529794f, -0.01594355f, 0.05084265f, 0.06285368f, -0.03928990f, 
    0.05807529f, 0.08573772f, -0.01086844f, -0.06079166f, 0.05692883f, 0.06889287f, -0.11179954f, 0.08980104f, 
    0.09410302f, -0.00138940f, 0.03741602f, -0.02813448f, 0.29897135f, -0.06086854f, -0.11313175f, -0.11642347f, 
    -0.00622935f, 0.12294662f, 0.06845546f, -0.03800631f, -0.02490492f, 0.14113206f, 0.14886004f, 0.11180443f, 
    0.09418029f, -0.01160804f, -0.00221790f, -0.04682085f, 0.07861539f, -0.01714407f, -0.07124428f, -0.09153757f, 
    0.01506003f, -0.11510020f, 0.02694798f, -0.03171453f, -0.01366602f, 0.03227924f, -0.00690078f, -0.04479060f, 
    0.00888330f, 0.04518886f, 0.05641614f, 0.04200488f, 0.04840600f, -0.03160819f, -0.13544427f, -0.11261156f, 
    -0.08029032f, -0.10293199f, -0.05145242f, -0.18564111f, -0.11035571f, 0.06595253f, -0.06765524f, 0.04325911f, 
    -0.08527126f, 0.04378317f, 0.00752704f, -0.03464133f, 0.09574613f, 0.27325460f, 0.08752147f, 0.18162911f, 
    0.03264491f, -0.00009848f, -0.02418002f, 0.09447087f, -0.10246681f, 0.00266026f, 0.15801208f, -0.06839467f, 
    0.05417227f, 0.12111066f, 0.05586788f, 0.11876465f, 0.04107892f, -0.01091904f, -0.08188553f, -0.00267438f, 
    -0.03869271f, -0.03950844f, -0.01492585f, -0.12933490f, 0.07311413f, 0.24239632f, 0.08110511f, -0.06837171f, 
    -0.00534268f, 0.00243661f, 0.05890484f, 0.09906852f, -0.04355292f, 0.19030374f, 0.08951484f, -0.01811818f, 
    0.18830360f, -0.08997620f, -0.06912169f, -0.06257610f, 0.02119405f, 0.04912462f, -0.01230548f, -0.03718179f, 
    -0.01802801f, 0.05476649f, 0.06575055f, -0.08222847f, -0.13074519f, 0.03500234f, -0.08579288f, 0.14180498f, 
    0.07576837f, 0.04904324f, -0.00862084f, -0.06869368f, -0.04160263f, -0.09256668f, -0.14254312f, 0.01787121f, 
    0.17039500f, 0.06239055f, 0.12668061f, -0.00520188f, -0.00084196f, 0.19758892f, 0.08511385f, -0.03608170f, 
    -0.06232127f, 0.04821303f, 0.02206691f, 0.00156787f, 0.10009067f, 0.13868599f, -0.14104053f, 0.01210197f, 
    0.01030841f, -0.06110492f, 0.06305633f, -0.04663819f, 0.00104207f, 0.07314283f, -0.14188473f, -0.15430962f, 
    0.06712380f, 0.23806354f, -0.16014576f, 0.11682016f, -0.04862828f, -0.05714843f, 0.06790305f, -0.07089603f, 
    0.00237985f, -0.07481231f, 0.02450040f, 0.02979585f, -0.08779750f, 0.17186934f, -0.22168443f, 0.00363978f, 
    -0.07750156f, -0.04750464f, 0.05599352f, -0.02086153f, -0.10793804f, 0.02249771f, 0.07452707f, 0.06845587f, 
    0.12642039f, -0.39766645f, -0.06023563f, -0.10279308f, -0.01149892f, -0.06859692f, 0.06751396f, -0.04756758f, 
    0.09883798f, 0.20220743f, -0.05732061f, 0.00123812f, 0.14639142f, 0.23401816f, 0.13263085f, -0.01571165f, 
    -0.11488217f, 0.03620391f, -0.02764738f, -0.04759887f, -0.02651162f, -0.01701347f, 0.08239114f, -0.07884254f, 
    0.02949093f, 0.07789244f, -0.01925267f, -0.14676987f, -0.07106490f, -0.05079663f, -0.02927355f, -0.01684029f, 
    -0.00927713f, 0.09445175f, -0.06047409f, -0.00865688f, 0.13311361f, 0.10657054f, -0.06105234f, 0.00367644f, 
    -0.15459333f, -0.20387235f, -0.10252757f, 0.01203413f, 0.00925940f, -0.00536732f, -0.06704892f, 0.09548686f, 
    -0.29976240f, 0.36362404f, -0.02179307f, 0.08271246f, 0.05451974f, 0.09218637f, 0.03710247f, -0.05144647f, 
    -0.07544548f, -0.02337182f, -0.06436764f, -0.03528307f, -0.22221649f, -0.29609936f, -0.08688018f, 0.01897432f, 
    0.10281050f, 0.04666604f, 0.08005059f, 0.02585340f, -0.03371492f, 0.00354856f, -0.08614533f, 0.05253730f, 
    0.13779104f, -0.21686934f, 0.09109024f, 0.13756996f, -0.03543526f, 0.03595854f, 0.02439051f, -0.08502378f, 
    -0.00921976f, -0.06656452f, 0.06254278f, 0.03691527f, -0.05898958f, 0.22631048f, -0.07108457f, -0.19932203f, 
    0.01794912f, 0.02800980f, 0.10499796f, -0.00189735f, -0.05573182f, 0.05406431f, -0.04230153f, 0.06045284f, 
    -0.00668758f, -0.11606177f, 0.11884709f, 0.04981846f, -0.01494999f, -0.07275318f, 0.01273622f, 0.11005175f, 
    -0.01356080f, 0.01836158f, 0.02569238f, 0.04452643f, 0.24238403f, 0.05300412f, -0.00713317f, 0.13031954f, 
    -0.10444635f, -0.10412671f, 0.14134677f, 0.11676773f, -0.04690585f, -0.02359346f, 0.03957648f, -0.00978326f, 
    -0.22986656f, 0.03088288f, -0.06574042f, 0.03388777f, -0.03465182f, 0.02447565f, -0.02238340f, 0.09570517f, 
    -0.04235481f, 0.12377576f, 0.09542596f, 0.02885850f, 0.13406247f, 0.12824720f, -0.02348734f, 0.16741909f, 
    -0.03918155f, 0.12724884f, 0.05567341f, 0.09385321f, 0.01679499f, -0.01971488f, -0.09231389f, -0.04068287f, 
    -0.05471411f, -0.02308781f, -0.07287189f, -0.07515690f, -0.07655304f, -0.02029146f, 0.00384287f, 0.14243387f, 
    0.03705964f, -0.02524193f, 0.04732919f, 0.04190977f, 0.19493397f, -0.06899793f, -0.14084688f, 0.07466545f, 
    0.07399288f, -0.00002430f, 0.04111604f, 0.07336924f, -0.05990270f, -0.01378106f, -0.01187849f, -0.03516813f, 
    -0.32278484f, 0.09285138f, 0.15700267f, -0.04430100f, 0.12244076f, 0.03441782f, -0.07916760f, 0.06992234f, 
    0.03674067f, -0.01358372f, -0.03744253f, 0.03329073f, -0.28617170f, -0.02206391f, 0.04089083f, -0.19737533f, 
    -0.21749660f, -0.02194381f, 0.00509666f, 0.02742136f, -0.02291436f, 0.08694339f, -0.06412601f, -0.05469988f, 
    -0.02502679f, 0.03199337f, -0.07679443f, 0.15613727f, -0.10613280f, -0.04707651f, -0.06922456f, 0.03286491f, 
    0.10834792f, 0.13564789f, -0.11398953f, 0.06691387f, -0.09021112f, -0.12822852f, 0.01574801f, -0.04489969f, 
    0.04892894f, 0.12073883f, 0.13046278f, -0.02337932f, -0.03079360f, 0.12311317f, 0.04293138f, -0.00495588f, 
    -0.23701714f, -0.05815820f, 0.08030581f, -0.04241725f, 0.07628721f, 0.00853777f, 0.03924498f, 0.01456643f, 
    0.03542452f, 0.02627085f, 0.11140266f, 0.00367186f, 0.13426483f, 0.07005778f, -0.15457076f, -0.05430263f, 
    0.00127928f, 0.01051420f, 0.04275865f, 0.13408653f, 0.09989409f, 0.02515364f, -0.00081191f, -0.05620657f, 
    -0.31684154f, 0.10165646f, 0.20091191f, -0.07854008f, 0.08926270f, 0.00529651f, -0.01072934f, -0.02258802f, 
    0.15118486f, -0.04206879f, 0.05738857f, -0.02199797f, 0.24427341f, 0.10100729f, -0.00296161f, -0.02064970f, 
    0.07046192f, -0.08015045f, 0.06558426f, 0.03799324f, -0.04725884f, 0.01303951f, 0.00247211f, -0.01052349f, 
    0.15625721f, 0.12304986f, 0.08943157f, 0.10772071f, 0.00259809f, 0.10481851f, -0.02039642f, -0.01411095f, 
    0.01134003f, -0.02453503f, 0.03641765f, 0.08872054f, 0.12829053f, -0.15358676f, 0.01133972f, 0.03057575f, 
    -0.07873941f, -0.05871879f, -0.02273302f, 0.08362717f, -0.01293279f, -0.01190317f, -0.02754709f, 0.10222905f, 
    -0.03732469f, -0.19136156f, 0.01375808f, -0.14474286f, 0.12891358f, 0.02597321f, 0.02397089f, 0.00408754f, 
    -0.05430237f, -0.07848358f, -0.00253919f, 0.08747867f, 0.37509167f, -0.30712178f, -0.01070090f, -0.10183993f, 
    -0.04384330f, -0.19844791f, 0.00127811f, 0.10772565f, -0.01292740f, -0.00793668f, -0.04334699f, -0.02877199f, 
    -0.06526657f, -0.02501462f, 0.01800228f, 0.16696568f, 0.06077876f, 0.03838875f, 0.00248544f, 0.02054082f, 
    0.03117177f, -0.01221257f, -0.02744576f, 0.01126155f, 0.33543754f, 0.08513372f, -0.00282161f, -0.07739809f, 
    0.05192536f, 0.03055927f, 0.09670006f, 0.05465848f, -0.05360044f, 0.04581931f, -0.02996359f, 0.04696401f, 
    0.17711402f, -0.17600881f, -0.17725882f, 0.07696030f, 0.05515268f, 0.15475677f, 0.06316768f, 0.11845214f, 
    0.02642317f, 0.00084060f, 0.13746686f, 0.12109924f, -0.15228932f, -0.05470883f, 0.12911527f, 0.28287673f, 
    0.04027298f, 0.00409705f, 0.05294723f, 0.07325371f, 0.09474651f, 0.11500937f, -0.04609852f, -0.07604229f, 
    0.12033840f, -0.34451178f, 0.01094285f, -0.08577240f, -0.08061931f, -0.09212729f, 0.27055416f, 0.01709793f, 
    -0.05830418f, 0.05548101f, -0.00930407f, -0.05883051f, 0.03587880f, 0.00815186f, 0.20290893f, -0.10014288f, 
    0.09136540f, 0.03992885f, 0.05848767f, 0.06975131f, 0.05926451f, 0.11620253f, -0.05797959f, -0.01400697f, 
    -0.22259001f, 0.07204864f, -0.11968928f, -0.09545001f, 0.06457036f, 0.25173742f, 0.09740762f, 0.07893129f, 
    0.00312890f, -0.01437976f, 0.00501554f, -0.02411592f, 0.20880303f, 0.05858315f, 0.03402614f, 0.35431436f, 
    -0.04833248f, 0.07285059f, 0.05371115f, -0.02035538f, 0.10469607f, 0.07495867f, 0.03387097f, 0.02408766f, 
    0.01327443f, 0.03245916f, 0.03700203f, -0.04285579f, -0.02109071f, -0.03021429f, -0.00688586f, -0.03658579f, 
    -0.04456009f, 0.02653275f, -0.01370002f, -0.03021160f, 0.02156979f, -0.05544135f, 0.01091736f, -0.05088068f, 
    0.03655452f, 0.01302517f, 0.04055279f, 0.00411291f, 0.04067728f, 0.00522493f, 0.01401541f, 0.03128628f, 
    -0.03758901f, -0.03358970f, -0.04722329f, 0.04759356f, -0.02687125f, 0.03422501f, -0.01052119f, -0.05544634f, 
    0.01248956f, -0.03834149f, 0.00948313f, 0.01404152f, -0.03044547f, -0.04741407f, -0.03449131f, 0.01335561f, 
    -0.04486690f, -0.00160757f, -0.00826468f, 0.00008542f, 0.00158833f, -0.02758382f, 0.04313476f, 0.01491470f, 
    0.02070819f, -0.02388452f, 0.01963677f, 0.02066447f, 0.00645904f, -0.02396118f, -0.01706944f, -0.05505156f, 
    -0.01113907f, -0.04212918f, -0.01187932f, 0.01206646f, 0.03925942f, 0.03396314f, -0.01649767f, 0.04210774f, 
    -0.04040504f, -0.03622201f, 0.02150268f, -0.04528610f, -0.05373666f, -0.02743514f, -0.00149263f, 0.02761208f, 
    -0.05378370f, 0.02307127f, 0.03549873f, 0.02935020f, 0.03462790f, -0.03007162f, -0.04780492f, -0.02249022f, 
    0.02761506f, 0.03625974f, 0.02157208f, 0.04186636f, 0.02056371f, -0.04450604f, 0.02764111f, -0.01721034f, 
    -0.01418162f, -0.05607512f, -0.01053911f, 0.00658851f, 0.01403136f, -0.02229318f, -0.01037202f, -0.00218906f, 
    0.00528601f, 0.02671920f, 0.01363560f, -0.01522148f, -0.03766130f, 0.01228134f, -0.01695627f, -0.04783863f, 
    0.00950932f, 0.03982226f, 0.03541741f, 0.03893331f, 0.02542187f, -0.03770133f, -0.03074998f, 0.00376112f, 
    0.03333008f, 0.00280852f, 0.01706416f, -0.00404333f, 0.01484583f, -0.00086598f, 0.03211668f, -0.03789549f, 
    0.02108399f, 0.01179650f, -0.00786218f, -0.03116679f, 0.02218251f, -0.04271006f, 0.01639078f, -0.01647126f, 
    0.00360356f, 0.04308474f, -0.04629970f, 0.04453505f, 0.00022455f, 0.05035510f, -0.04293884f, 0.00313249f, 
    -0.02138228f, 0.01876304f, -0.03441835f, -0.01034700f, -0.01861338f, 0.02631642f, -0.01421834f, 0.00580756f, 
    -0.01516913f, -0.00685554f, 0.01817423f, 0.01506381f, -0.03971755f, -0.01777836f, -0.04533925f, -0.01486931f, 
    -0.03471575f, -0.03492403f, -0.04886695f, 0.02206862f, 0.00506025f, -0.05625595f, 0.03313672f, 0.01049051f, 
    -0.02428083f, -0.05250353f, -0.03624602f, -0.03593220f, -0.03900659f, -0.05058376f, 0.02793914f, -0.03184075f, 
    0.02587789f, -0.05140080f, 0.01882276f, -0.04094179f, -0.05016700f, 0.01013393f, 0.00087408f, -0.01411331f, 
    -0.04397362f, -0.04438066f, 0.01981642f, 0.01569065f, 0.03233710f, 0.03531521f, -0.05057879f, -0.03302000f, 
    -0.05404769f, 0.03461095f, 0.04405773f, -0.02793762f, 0.00886009f, -0.02923409f, -0.01220223f, 0.01579097f, 
    0.02836696f, -0.03394597f, 0.04355488f, -0.01838694f, -0.03344403f, -0.00499283f, -0.04923522f, 0.03039668f, 
    0.00281028f, 0.00277142f, -0.03857782f, -0.00573599f, 0.00588200f, 0.00278214f, -0.03471442f, 0.00172830f, 
    -0.01046182f, -0.00034732f, 0.01762861f, 0.01322548f, 0.03514547f, -0.02394872f, 0.00326852f, -0.02651794f, 
    -0.01281069f, 0.02084511f, -0.05243030f, 0.01989500f, 0.02651156f, -0.02062117f, 0.01130151f, -0.05121047f, 
    0.00291613f, 0.04346456f, -0.00380501f, -0.02273211f, -0.03834691f, -0.04900496f, -0.04763374f, 0.00351495f, 
    -0.00269417f, 0.01267814f, -0.04413322f, -0.02061773f, 0.01562223f, -0.05041914f, -0.04073447f, -0.02172471f, 
    0.00430241f, 0.00991204f, 0.00683418f, 0.00869479f, -0.03915358f, -0.02967706f, -0.02536406f, 0.02786163f, 
    0.00478572f, 0.01164718f, -0.03854227f, -0.00217033f, -0.03925119f, 0.01956568f, -0.03086513f, 0.03866073f, 
    0.02514560f, 0.02873994f, 0.01101087f, -0.04724871f, 0.04905168f, -0.03828756f, -0.00262114f, -0.01297791f, 
    0.03465694f, 0.01205912f, -0.04740277f, -0.00228633f, -0.00030449f, -0.00185977f, -0.04349266f, -0.00840168f, 
    -0.04659024f, 0.01377839f, 0.03912532f, -0.01942210f, 0.02125124f, -0.04192050f, -0.05001951f, 0.03879596f, 
    -0.04144046f, 0.00312053f, 0.01606925f, -0.00319696f, 0.01559871f, -0.05314893f, -0.00793902f, 0.01395854f, 
    -0.04234807f, -0.04451601f, 0.02496476f, -0.00761687f, 0.00857833f, 0.03820959f, 0.01930200f, -0.05304823f, 
    -0.04981693f, -0.05459194f, -0.04572273f, -0.04707099f, -0.01413500f, 0.02791729f, -0.01661962f, 0.01248437f, 
    -0.04704602f, -0.01238061f, -0.00594670f, 0.00912703f, -0.03825431f, -0.04675497f, -0.00021244f, -0.02074238f, 
    -0.00625249f, -0.03497666f, -0.03321325f, 0.01852756f, -0.05461343f, -0.03765412f, -0.01971647f, -0.02669896f, 
    -0.00197759f, -0.03187525f, -0.05257007f, -0.04207428f, -0.01102628f, 0.00424179f, -0.03409364f, -0.04701652f, 
    0.03581300f, -0.02137379f, 0.03356841f, 0.00394520f, 0.00456286f, -0.03529865f, 0.04073683f, -0.04528021f, 
    -0.00627655f, -0.00648103f, 0.03498893f, -0.00797096f, 0.00103084f, -0.01083731f, -0.03361002f, 0.03566689f, 
    -0.04426261f, -0.02205771f, -0.02461970f, 0.01365695f, -0.04007437f, 0.00577039f, -0.03327799f, -0.04250750f, 
    -0.02712813f, -0.00590578f, -0.03369663f, -0.04616396f, -0.01470297f, 0.00497613f, -0.04580281f, -0.00373055f, 
    -0.00101079f, 0.03677189f, 0.01086803f, -0.05253690f, 0.00260487f, 0.04173972f, -0.05575173f, 0.02915696f, 
    -0.02905491f, 0.02812942f, -0.01024175f, 0.02295158f, -0.00521679f, 0.04220049f, 0.03350393f, -0.02204778f, 
    0.03179076f, 0.00000419f, -0.03334231f, 0.02836072f, -0.05209700f, -0.02319393f, 0.01206143f, 0.02553236f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05359472f, 0.00864497f, -0.04330889f, -0.01283926f, 0.03030784f, 0.04672193f, -0.01439789f, -0.05220908f, 
    0.01555601f, -0.10691086f, 0.02274455f, 0.04982855f, 0.05113511f, 0.01201709f, -0.05487022f, -0.02366361f, 
    0.00806484f, -0.01827498f, -0.05006662f, 0.04258132f, 0.10373278f, -0.02046537f, -0.05590304f, 0.02556755f, 
    0.08502918f, 0.07709727f, 0.02211850f, 0.01766335f, 0.04396008f, 0.12698793f, -0.00150448f, -0.05068606f, 
    0.02613650f, 0.04420522f, 0.04828895f, 0.02118399f, -0.01002037f, 0.02856300f, 0.09515645f, 0.00523220f, 
    -0.02444416f, 0.06931866f, -0.00174005f, -0.00577251f, 0.02599264f, 0.03351655f, 0.00264523f, 0.00064922f, 
    0.03185078f, -0.03033518f, 0.00943330f, 0.07348417f, 0.05709592f, -0.01750692f, 0.01576039f, -0.01999124f, 
    0.01059742f, 0.00883884f, -0.01438188f, -0.02260203f, 0.00665212f, 0.00098135f, 0.03590947f, -0.03409668f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.21822779f, -0.00555653f, -0.11607501f, 0.18308242f, -0.42524233f, 0.30763251f, 0.10334808f, -0.12076193f, 
    -0.31564680f, 0.10168629f, -0.11562350f, -0.08002912f, 0.10167088f, 0.25918105f, 0.28598213f, -0.10797989f, 
    -0.10018094f, 0.05485175f, 0.25967562f, 0.00418382f, -0.32459959f, -0.04355199f, 0.19934206f, -0.11152348f, 
    0.04188943f, 0.11248268f, -0.22787818f, -0.28124774f, 0.02565533f, -0.35564041f, -0.11381930f, 0.03507711f, 
    0.10497428f, -0.18113290f, -0.13043340f, -0.21737246f, 0.00051449f, -0.03329409f, -0.49650010f, 0.18403883f, 
    -0.17207724f, 0.22696857f, 0.01841527f, 0.11487410f, -0.09246303f, -0.03721802f, 0.03666527f, -0.01961512f, 
    -0.07308230f, 0.02645285f, 0.03791206f, -0.49495035f, 0.23176278f, -0.01251900f, -0.47982576f, 0.06391081f, 
    0.20520727f, -0.07434411f, 0.29068106f, 0.33442867f, 0.04176079f, -0.14076781f, -0.14084871f, -0.06902019f, 
    0.21410379f, 0.00682484f, 0.02370136f, -0.06593084f, 0.04814101f, 0.11329092f, -0.03073304f, 0.16902830f, 
    0.08187816f, -0.06519949f, 0.03440712f, 0.33384585f, -0.34847906f, 0.12874089f, -0.32063526f, 0.03793336f, 
    -0.45317674f, 0.04124313f, 0.03528298f, -0.07893153f, -0.06433971f, -0.07943772f, 0.05973903f, -0.04561631f, 
    0.08877029f, -0.02113038f, 0.19604844f, -0.24384977f, -0.08265173f, -0.11991240f, -0.55426520f, -0.01561374f, 
    0.04575448f, 0.22712639f, 0.07582714f, 0.11621681f, 0.10893239f, 0.10763972f, -0.39086246f, 0.17487018f, 
    -0.15429021f, 0.11966811f, -0.06097656f, -0.05574576f, -0.07859593f, -0.11836880f, 0.04660727f, 0.11864828f, 
    0.11621024f, 0.02386626f, -0.21227287f, -0.29532954f, 0.24178569f, -0.34079295f, 0.00388120f, -0.03645303f, 
    0.15208556f, -0.10646262f, 0.34440544f, -0.39589572f, -0.08728144f, -0.02965117f, 0.16259106f, -0.05104435f, 
    0.12647603f, 0.08544210f, 0.11464793f, 0.02467838f, -0.26644152f, -0.28499320f, 0.12434542f, 0.15499866f, 
    -0.14443545f, 0.33756271f, 0.21804734f, -0.10056996f, 0.13161480f, -0.33118251f, 0.09529258f, -0.01804894f, 
    0.13326821f, -0.36754242f, -0.18379968f, 0.10077941f, -0.09659161f, -0.03360113f, 0.09260822f, -0.08430699f, 
    -0.00471423f, 0.06707829f, 0.07527979f, 0.47267866f, -0.03079519f, -0.22077565f, -0.25646958f, -0.01476537f, 
    -0.01266765f, -0.03921134f, -0.09254888f, -0.40602517f, -0.29796934f, -0.00250530f, -0.05821251f, -0.53447771f, 
    0.26655585f, 0.12588526f, 0.06190461f, -0.01955997f, -0.02058318f, 0.12212644f, 0.00695020f, 0.09968841f, 
    -0.24967350f, 0.01290262f, -0.24428445f, -0.17962386f, 0.16137698f, -0.12227981f, -0.24779660f, 0.03637888f, 
    -0.00197209f, 0.03963163f, -0.21362844f, -0.15236869f, -0.11382363f, 0.19454136f, 0.28638947f, 0.11371125f, 
    -0.13134958f, 0.00530811f, -0.04498916f, -0.13647653f, 0.21507251f, -0.30989745f, 0.06681809f, -0.15067954f, 
    0.04340371f, -0.08599566f, 0.17342934f, -0.29752141f, -0.33368427f, 0.08792064f, 0.18844184f, 0.10342860f, 
    -0.22481360f, 0.01278656f, 0.28385556f, -0.05291976f, -0.30759734f, -0.11576664f, -0.35850605f, -0.10809184f, 
    0.04298669f, 0.23978586f, -0.31226635f, 0.18321815f, -0.05794765f, 0.22910109f, -0.13866532f, -0.01425534f, 
    0.04126533f, -0.48610643f, -0.36014396f, -0.17163371f, -0.17745797f, -0.11335867f, 0.11712927f, 0.19937527f, 
    -0.39369947f, -0.12089527f, -0.10866571f, 0.06682309f, -0.01359586f, -0.10819948f, 0.02601403f, 0.21456833f, 
    0.15505815f, 0.12089410f, 0.03916993f, 0.14672752f, -0.00290561f, 0.27965873f, 0.15706293f, 0.03187412f, 
    0.23985386f, 0.10515307f, -0.34482577f, 0.20711979f, 0.10425889f, -0.44303009f, 0.26472509f, -0.09298071f, 
    0.00928980f, 0.10564323f, 0.00947119f, 0.10308199f, 0.31418830f, 0.03598309f, -0.36707553f, 0.04911502f, 
    0.36983868f, -0.33760238f, -0.12549323f, -0.14941025f, 0.04589195f, -0.31893897f, 0.18780892f, -0.02162695f, 
    0.23693664f, 0.27067882f, -0.09136460f, 0.10515372f, -0.36248964f, -0.07246326f, -0.24282542f, -0.07408025f, 
    -0.23372345f, 0.06119456f, 0.18300311f, -0.04191633f, -0.01630137f, -0.18338673f, -0.02159937f, -0.00989152f, 
    0.10132921f, -0.29670087f, -0.10659208f, 0.03822745f, 0.07407133f, -0.10786272f, -0.00832628f, -0.13087820f, 
    0.21855111f, 0.10306802f, -0.07229868f, -0.09773944f, -0.05486927f, 0.04014222f, -0.01765930f, 0.00419518f, 
    0.23098430f, 0.07064298f, 0.31655118f, 0.01787175f, -0.27604538f, -0.11977670f, -0.03307172f, -0.03813660f, 
    0.02990190f, -0.10095841f, 0.08922996f, 0.05919087f, -0.07509724f, 0.17490461f, 0.21546672f, -0.06980428f, 
    -0.08534151f, -0.05132241f, -0.06654407f, 0.18176039f, 0.20507702f, -0.00223908f, -0.06081610f, -0.52376962f, 
    -0.28266487f, -0.06543247f, 0.19735910f, -0.16281097f, -0.03114652f, 0.15304974f, -0.29930335f, 0.07574356f, 
    -0.04226141f, 0.33533424f, -0.32007137f, -0.08194771f, 0.18649997f, 0.08287331f, 0.20842102f, -0.03018470f, 
    0.19980110f, -0.41228053f, -0.05344852f, -0.10689795f, -0.10820419f, 0.21699487f, 0.13521209f, 0.01785637f, 
    -0.06133626f, 0.08572811f, 0.25045669f, 0.00524074f, 0.24732232f, 0.07451490f, 0.12462907f, 0.29144651f, 
    0.17691155f, -0.07470498f, -0.03697141f, 0.03173843f, -0.07799638f, 0.10561482f, -0.03203090f, 0.00635799f, 
    0.18361539f, 0.02202552f, -0.07631793f, 0.04590102f, -0.25500175f, -0.27723238f, -0.66515476f, -0.12141563f, 
    0.06340203f, -0.02900415f, 0.05095296f, -0.09351205f, 0.03662379f, -0.25508288f, -0.22759217f, -0.12027901f, 
    0.22847083f, -0.10938099f, -0.02689017f, -0.10425617f, -0.64240623f, -0.23986724f, -0.32744086f, 0.44303831f, 
    -0.21271336f, -0.00862100f, 0.05529002f, -0.34966066f, 0.25689074f, -0.05537336f, -0.19904828f, -0.11206406f, 
    0.03833595f, -0.14197876f, -0.35199806f, 0.02969068f, 0.02106814f, 0.06420385f, 0.27701321f, -0.01599089f, 
    -0.05455052f, -0.60463256f, -0.68024766f, -0.21265464f, -0.06657930f, 0.07576516f, 0.28895861f, 0.10803419f, 
    -0.01366292f, 0.28089383f, -0.56835717f, 0.12048734f, -0.10886737f, 0.10629238f, 0.17884278f, 0.04366962f, 
    -0.13304798f, 0.16435637f, -0.11069943f, 0.10753670f, -0.05721924f, 0.11375688f, 0.02186487f, -0.29339060f, 
    0.08265971f, -0.07830160f, 0.02952393f, 0.19373776f, -0.30577946f, -0.11877242f, 0.18937750f, -0.03228115f, 
    0.22064637f, -0.07739527f, -0.27556172f, 0.15183793f, -0.07117362f, 0.15605862f, -0.08318681f, 0.08984713f, 
    -0.26829833f, 0.08427341f, -0.07379533f, -0.30389100f, 0.21074936f, -0.16240823f, 0.18979171f, 0.16565368f, 
    -0.16095397f, 0.21820934f, -0.25058001f, -0.14125612f, 0.15507182f, 0.15530637f, 0.10641531f, -0.02075853f, 
    -0.16712411f, 0.09320785f, 0.12455799f, -0.03872372f, -0.05457271f, 0.06032779f, -0.02752480f, 0.07562362f, 
    -0.44444948f, 0.18058898f, -0.18863733f, 0.18769018f, -0.10758384f, -0.41805178f, 0.09891841f, 0.10656559f, 
    -0.02790689f, 0.05490541f, -0.11921462f, 0.20649287f, -0.38312629f, -0.01189695f, 0.03311382f, 0.11486488f, 
    0.35655054f, -0.34442592f, 0.03076850f, 0.08293402f, -0.06800430f, 0.05241682f, 0.11437032f, -0.14994149f, 
    0.15928559f, -0.08871941f, 0.14378996f, 0.17797557f, -0.23621702f, 0.23014022f, 0.08207212f, 0.06496747f, 
    -0.07308419f, 0.04010596f, 0.03118149f, -0.02138769f, 0.00754814f, 0.29682016f, -0.42061302f, -0.01478523f, 
    0.03564819f, 0.09682579f, 0.04570564f, -0.08218162f, -0.18143475f, -0.44190517f, 0.10443310f, 0.28804788f, 
    0.32755122f, 0.09549518f, -0.15154094f, -0.20471874f, -0.34694800f, -0.18531567f, 0.02750809f, 0.02757401f, 
    0.11246713f, -0.02449203f, 0.07139271f, 0.05795956f, 0.24388355f, 0.08574666f, 0.22768880f, 0.02247056f, 
    0.16860880f, -0.38443246f, 0.28057158f, 0.04607899f, -0.01143357f, 0.00165806f, 0.08036256f, -0.04096445f, 
    0.06223112f, 0.17640513f, 0.28354806f, -0.33797902f, 0.20906779f, 0.06726693f, -0.15036017f, 0.14654563f, 
    0.13737144f, -0.29880175f, 0.06289556f, -0.02158361f, -0.02182076f, 0.10459465f, -0.03611169f, 0.06321603f, 
    -0.32824624f, 0.10957240f, -0.47787905f, 0.18893701f, 0.13033321f, 0.08002808f, -0.10962344f, 0.07644600f, 
    -0.26353285f, -0.07305496f, 0.26055574f, -0.21378244f, 0.00628907f, -0.05665133f, -0.21752246f, -0.03249577f, 
    0.11656831f, 0.07888033f, 0.02524405f, 0.09984918f, -0.07141473f, 0.24546549f, -0.46196771f, 0.08848736f, 
    -0.58453709f, 0.18615563f, -0.00895571f, 0.28661853f, 0.21562086f, -0.17088385f, 0.04553194f, 0.11941007f, 
    0.04659552f, -0.30135018f, -0.03825973f, 0.05828320f, -0.21513897f, -0.02385417f, -0.33158812f, 0.09500774f, 
    0.09071749f, 0.05376355f, -0.34953418f, -0.09299957f, -0.02523536f, -0.39357790f, 0.28179964f, 0.06588787f, 
    -0.01242263f, 0.03732753f, -0.18081672f, 0.30248192f, 0.25521648f, 0.11003899f, -0.17270133f, -0.02177108f, 
    0.21400692f, 0.12546045f, -0.10750681f, -0.08289560f, 0.11059725f, -0.10131924f, -0.06791583f, 0.23950085f, 
    0.01993809f, -0.03986628f, -0.10805103f, -0.19528259f, 0.06414077f, 0.16648357f, 0.42685324f, 0.07590227f, 
    -0.43946511f, -0.00660549f, -0.53910279f, -0.42144021f, -0.03085960f, 0.07077452f, -0.39158311f, -0.08174177f, 
    0.12558651f, 0.05701120f, 0.00210498f, -0.20113996f, -0.02338763f, -0.46044010f, 0.19317301f, 0.00420412f, 
    0.11685673f, -0.39477271f, -0.17956424f, 0.35505658f, 0.12165610f, 0.20939781f, -0.03659367f, 0.01409811f, 
    -0.19447899f, -0.37224305f, -0.08073907f, 0.05234482f, 0.41858986f, 0.04217348f, 0.07107845f, 0.09394636f, 
    -0.09042308f, 0.21881436f, 0.09717584f, 0.04160789f, -0.03771373f, 0.26218250f, -0.13492191f, 0.11928659f, 
    -0.05855190f, -0.29503399f, 0.32870659f, 0.10964968f, -0.39555839f, -0.02261302f, 0.27662611f, 0.05795437f, 
    0.18163131f, 0.11145349f, 0.06013330f, 0.06703300f, 0.02412573f, -0.07342847f, -0.12775035f, -0.64611310f, 
    0.14909418f, -0.10860586f, 0.06694176f, -0.05475279f, 0.13146125f, -0.11144561f, 0.21365251f, 0.07769185f, 
    -0.19652599f, 0.05365943f, -0.27768597f, -0.19769894f, -0.11108153f, -0.41176414f, 0.15334672f, 0.07146709f, 
    0.11038810f, -0.12153322f, -0.03995125f, 0.17491612f, -0.38964382f, 0.19260576f, -0.03631297f, -0.37382329f, 
    -0.19722891f, 0.25496477f, -0.13182880f, -0.41574147f, 0.23234309f, -0.19084734f, -0.05267191f, -0.10335172f, 
    0.04696839f, 0.15759055f, -0.09864852f, 0.07873087f, 0.34824082f, 0.08303755f, -0.37528005f, -0.11476056f, 
    0.11509556f, 0.26535362f, 0.04115901f, -0.33505958f, -0.04270170f, 0.03297852f, -0.20073913f, -0.11465458f, 
    -0.00744756f, 0.08622007f, -0.06197402f, 0.04839846f, -0.52620846f, -0.05749525f, 0.15744650f, -0.08998018f, 
    -0.53704572f, -0.02925787f, -0.06193865f, -0.09170973f, 0.07618611f, 0.08203409f, -0.03822249f, 0.07511286f, 
    -0.39687577f, 0.07136993f, 0.07884997f, 0.28819934f, 0.07535096f, 0.17961797f, 0.04413970f, -0.02408465f, 
    0.07071237f, -0.09562126f, -0.14630225f, 0.22979614f, -0.06500878f, 0.18100753f, -0.09849054f, 0.01183423f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00177156f, 0.07151737f, 0.12961024f, -0.13003373f, -0.02851585f, 0.08679027f, 0.06120026f, -0.16530125f, 
    0.06045309f, -0.07607771f, 0.16269240f, -0.03924650f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
