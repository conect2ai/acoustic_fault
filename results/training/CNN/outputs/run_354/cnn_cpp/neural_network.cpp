#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.43893006f, -0.14941458f, 0.69431818f, 0.55597264f, 0.14173919f, 0.50366330f, -0.01289432f, 0.46953732f, 
    0.32359442f, -0.45838282f, -0.37186107f, -0.33327696f, -0.29807317f, 0.33211151f, 0.07055113f, 0.23801920f, 
    0.18009776f, -0.03242614f, 0.08294889f, 0.11504859f, 0.20530385f, 0.05264727f, 0.27960241f, 0.18215816f, 
    0.33891100f, -0.19729470f, -0.78224730f, -0.24917462f, 0.16516249f, 0.19521284f, -0.67216682f, 0.65607011f, 
    0.32930082f, -0.55060709f, 0.27992165f, -0.11389716f, -0.09984132f, -0.44370082f, -0.35191220f, -0.17816064f, 
    -0.38362598f, -0.31022692f, -0.40564305f, -0.33695510f, -0.49034879f, 0.16979142f, 0.08917215f, 0.00085492f, 
    -0.11836689f, -0.09798696f, 1.19662595f, 0.00536199f, -0.33632109f, 0.52318388f, 0.16308767f, 0.27043027f, 
    -0.47936922f, 0.10476599f, 0.57925075f, 0.05804413f, -0.07834157f, -0.12068583f, 0.07961948f, -0.23072033f, 
    0.06159762f, -0.04533150f, -0.03033896f, 0.05353672f, -0.00290837f, 0.11075957f, 0.01255736f, 0.11673967f, 
    0.08139383f, -0.36603862f, 0.03629763f, 0.95733941f, 0.05561551f, 0.36124331f, 0.42283463f, 0.08507517f, 
    -0.21914119f, 0.44573668f, -0.33492440f, 0.10927661f, 0.33824208f, 0.39605054f, 0.20577787f, 0.10482477f, 
    0.23064774f, -0.36767617f, -0.27158383f, -0.05728126f, 0.02143954f, 0.19338998f, -0.01306363f, -0.06789161f, 
    0.37135783f, 0.06566393f, 0.02161314f, -0.07436884f, 0.42857653f, 0.48142383f, 0.60459137f, 0.91737008f, 
    0.83741188f, 0.02159743f, -0.05220216f, 0.27043852f, -0.23776636f, 0.50795597f, -0.02720572f, -0.08171610f, 
    -0.17575458f, 0.12252175f, 0.16575031f, -0.07266194f, -0.00341211f, 0.30388066f, 0.29246399f, -0.11158679f, 
    0.10896056f, -0.24941234f, -0.13902579f, -0.15294820f, 0.18180840f, -1.02832639f, 0.04590967f, -0.36609468f, 
    -0.45016909f, -0.17052118f, 0.22282712f, 0.84433866f, 0.25442696f, 0.05572051f, 0.44823325f, -0.16642831f, 
    0.22420791f, 0.44215992f, 0.00800914f, 0.04342744f, -0.33736634f, 0.10627285f, 0.05979145f, 0.01004603f, 
    -0.41705880f, 0.28241277f, -0.11187831f, -0.19731192f, -0.02196796f, -0.17500459f, 1.08465683f, 0.68008304f, 
    0.10710976f, 0.43991184f, 0.68518537f, 0.38594174f, -0.16348822f, -0.47685137f, -0.35287097f, -0.26838160f, 
    0.03949108f, 0.09752930f, 0.03610989f, -0.10806569f, 0.09459320f, 0.18448895f, -0.07434371f, -0.00817744f, 
    -0.07017260f, 0.07909760f, 0.00608826f, 0.08862935f, 0.19892408f, 0.30384848f, 0.31957039f, 0.05765028f, 
    0.18985020f, 0.98831224f, 0.62116331f, -0.05646036f, 0.25820374f, 0.12038624f, -0.10007460f, -0.04805025f, 
    0.58091348f, -0.11474410f, 0.19791637f, 0.28475967f, -0.05141335f, -0.16497773f, 0.34080479f, -0.26046619f, 
    -0.23120651f, -0.04561410f, -0.28797528f, 0.16822572f, 0.13343492f, -0.23133142f, 0.10633135f, -0.06176678f, 
    0.38581735f, -0.63128024f, -0.42541105f, 0.54760516f, 0.17322402f, -0.98496014f, -0.12481788f, 0.30333677f, 
    -0.68687868f, -0.13239777f, -0.05552939f, 0.21393630f, -0.01562321f, -0.06797980f, 0.34332591f, 0.00215791f, 
    -0.00361406f, 0.03149056f, 0.09454558f, 0.20580158f, 0.21540296f, -0.11764324f, -0.15460083f, 0.20666882f, 
    0.23318841f, 0.42830998f, 0.84014732f, 0.43041280f, -0.51294082f, 0.09300341f, -1.04752219f, 0.14980173f, 
    -0.18220055f, -0.39194518f, -0.42511329f, 0.07667903f, -0.01533440f, 0.03961092f, 0.05698268f, 0.10841449f, 
    0.05029155f, 0.14093472f, 0.25743827f, 0.02041671f, -0.19578904f, -0.04454064f, -0.15651013f, -0.20768850f, 
    0.01196342f, -0.01844337f, 0.08381056f, -0.48142847f, -0.72785306f, -0.69887757f, 0.24870357f, 0.24573405f, 
    0.38940543f, 0.27420405f, 0.24295571f, 0.35755211f, -0.28948623f, 0.04810033f, -0.27199575f, -0.24497418f, 
    0.01429054f, -0.14662284f, -0.15136619f, 0.40483567f, 0.17296416f, -0.06561182f, -0.10528409f, -0.21589568f, 
    -0.08723001f, -0.07727819f, -0.08286364f, -0.85278261f, 0.08117969f, -0.91734797f, -0.07225673f, -0.33789015f, 
    0.89677685f, -0.13068846f, -0.81428486f, 0.22503933f, 0.00632314f, 0.13188155f, -0.10894693f, 0.29483485f, 
    -0.04392929f, -0.00255642f, 0.10590128f, 0.15974925f, -0.11786606f, 0.21132764f, -0.16557778f, -0.09738538f, 
    -0.23339599f, -0.03284067f, 0.03367846f, -0.22181618f, -0.83274293f, 0.70240688f, -0.13151880f, -0.53471863f, 
    0.16957657f, -0.02011686f, 0.30580768f, -0.05215583f, -0.54476440f, -0.68361008f, -0.02027521f, 0.08804976f, 
    -0.11946797f, 0.22163472f, -0.27611330f, -0.27980509f, -0.21257833f, -0.20859416f, -0.09168138f, -0.13199465f, 
    -0.22160885f, 0.09153730f, 0.14862935f, 0.40154189f, 0.23391385f, 0.11041763f, -0.12204181f, -0.62234509f, 
    -0.58289611f, -0.22110215f, -0.39459088f, -0.43165568f, 0.21334627f, 0.36018234f, -0.12364289f, -0.61536336f, 
    0.14678645f, -0.03469250f, -0.26620039f, -0.45605481f, -0.10479394f, 0.05829680f, 0.30155268f, -0.07331809f, 
    -0.14734165f, 0.07458854f, 0.21738727f, -0.18170202f, 0.04950675f, 0.08379351f, -0.19171318f, -0.81047541f, 
    0.29910806f, 0.62989938f, 0.18212365f, 0.70282650f, 0.86217546f, 0.24033396f, 0.51612282f, 0.19717126f, 
    0.06924220f, 0.39652425f, 0.27928188f, 0.32848394f, -0.05204357f, -0.07566981f, 0.02033469f, 0.06960805f, 
    0.12395006f, 0.05310184f, -0.10961391f, 0.09801704f, 0.29670849f, 0.05118638f, 0.15926102f, -0.28961006f, 
    -0.83457136f, -0.61260110f, -0.17291373f, -0.31291175f, 0.18911593f, -0.41239387f, 0.12431785f, 0.41731396f, 
    -0.19893597f, -0.17761502f, -0.06949807f, 0.26383525f, 0.13791132f, -0.44123024f, 0.06933078f, -0.04964424f, 
    0.00141224f, -0.14377169f, 0.33641890f, 0.27097479f, 0.00374485f, 0.20065869f, 0.17804433f, 0.25867245f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22309388f, 0.20326501f, 0.00754270f, 0.03629751f, -0.20726843f, 0.08772502f, -0.02885861f, 0.25592387f, 
    0.00791228f, 0.11307718f, -0.03182562f, 0.12126558f, 0.15859164f, 0.07498057f, 0.20699859f, 0.18509893f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18828763f, 0.35466868f, 0.07255382f, 0.13414250f, 0.13856836f, 0.14255601f, -0.07076578f, 0.01340187f, 
    -0.08534253f, -0.08307920f, 0.04078342f, -0.00259215f, 0.49891421f, 0.05881996f, 0.01066675f, 0.18003917f, 
    -0.18205656f, 0.10703570f, 0.08558553f, 0.08262502f, -0.08956870f, -0.05956671f, 0.26372835f, 0.26624218f, 
    -0.04358361f, 0.02320743f, 0.16698244f, 0.12306990f, 0.08941828f, -0.02176706f, 0.06297292f, 0.07150902f, 
    0.06310435f, 0.04577025f, 0.11668956f, 0.01993500f, 0.24011995f, 0.36361089f, 0.20690593f, -0.11164552f, 
    0.00562836f, -0.05949658f, -0.17362952f, 0.05050525f, 0.07761563f, 0.20769019f, 0.01925592f, 0.07870702f, 
    0.43294257f, 0.44838992f, 0.28626388f, -0.08286048f, 0.04892232f, -0.10572021f, -0.10736597f, 0.13329525f, 
    0.03555135f, 0.24535419f, -0.06342883f, 0.12494000f, 0.35133347f, -0.39339578f, -0.07079878f, 0.01854532f, 
    0.10247420f, 0.01775364f, 0.16181527f, 0.15111090f, -0.03364693f, 0.03273754f, 0.19426930f, 0.12525074f, 
    0.04228114f, 0.30510247f, 0.18618537f, -0.35307282f, -0.02322809f, -0.00893905f, -0.06928521f, 0.05874154f, 
    0.03684564f, 0.09127358f, 0.05529650f, -0.11601558f, 0.31051508f, 0.23379061f, 0.24129708f, 0.03604071f, 
    -0.12060044f, 0.04143056f, 0.04370132f, -0.01846851f, 0.00068150f, 0.04660326f, 0.23863064f, -0.11102284f, 
    0.28525642f, -0.09507582f, -0.39028329f, 0.02179379f, 0.01188792f, 0.00809335f, 0.05326541f, 0.17244385f, 
    0.05536818f, 0.03312017f, 0.02974460f, 0.07029989f, 0.18009005f, 0.18453713f, 0.05495538f, -0.26828071f, 
    0.15796834f, 0.01898191f, -0.02612630f, 0.15957092f, 0.15176676f, 0.06542128f, -0.12168779f, 0.03004034f, 
    -0.04075753f, -0.13563287f, -0.03929289f, -0.03549895f, 0.02297159f, 0.08379132f, -0.00326173f, 0.26240882f, 
    0.07082999f, 0.00644909f, 0.04537030f, 0.20771822f, -0.12826174f, -0.18504497f, 0.25928500f, -0.01831266f, 
    0.11298399f, -0.00883860f, 0.17299622f, 0.02674430f, 0.12923473f, 0.19144203f, -0.08315043f, 0.11439837f, 
    -0.08582117f, -0.22374813f, -0.36426494f, -0.19542071f, -0.09942444f, 0.19152519f, -0.04727772f, -0.00278303f, 
    0.03470716f, 0.01322757f, 0.07572249f, 0.04710576f, -0.15379675f, -0.18840697f, -0.02938440f, 0.05107787f, 
    0.07999565f, -0.06207640f, 0.16648614f, 0.33448502f, 0.15601155f, -0.00273812f, -0.05440713f, 0.05869452f, 
    0.46076772f, -0.39225441f, 0.07066825f, 0.10592061f, -0.07396659f, 0.03193169f, -0.10401932f, -0.01602884f, 
    0.08661450f, -0.04919468f, -0.06419337f, 0.07246096f, -0.26951236f, 0.05753099f, 0.23328207f, -0.03920791f, 
    0.03028027f, 0.05278056f, -0.04822110f, 0.06686047f, 0.03043800f, 0.03254472f, 0.01498859f, 0.05922542f, 
    -0.32081240f, 0.06121773f, 0.27340999f, -0.16993384f, 0.16583653f, 0.18206993f, 0.13636395f, 0.05163566f, 
    0.07191079f, 0.04888551f, -0.05668201f, -0.33370411f, 0.09304771f, 0.14580563f, -0.17998546f, 0.20723937f, 
    -0.14082262f, -0.08143172f, 0.00684196f, -0.14793092f, -0.12912646f, -0.03689126f, -0.20897210f, -0.25239137f, 
    -0.45266363f, 0.09780746f, 0.18078150f, -0.06015082f, 0.08114044f, 0.16823189f, 0.00089702f, 0.10604440f, 
    0.12391236f, -0.06849030f, -0.10721437f, -0.11135620f, -0.39501309f, 0.06968030f, 0.19446462f, 0.15250821f, 
    0.22089390f, -0.02052272f, 0.11864153f, 0.22517279f, 0.02302581f, 0.11974838f, 0.01834158f, 0.15516159f, 
    -0.40162820f, -0.25909650f, 0.19154820f, 0.03758776f, -0.09467264f, 0.12282406f, 0.05227331f, 0.02582928f, 
    0.06578512f, -0.04025935f, -0.15407383f, -0.07457105f, -0.09884102f, 0.05845217f, -0.01386825f, 0.13292684f, 
    -0.22350185f, -0.08320709f, -0.29471612f, 0.01040554f, 0.00394056f, 0.23562281f, 0.09187569f, -0.09810180f, 
    -0.28632432f, -0.26580504f, 0.07968330f, 0.26457027f, 0.07132260f, 0.20278895f, 0.10903310f, 0.19835763f, 
    0.00050267f, 0.14161819f, -0.01623784f, -0.09987389f, -0.60404384f, 0.13388148f, 0.06389699f, 0.00574320f, 
    0.09155946f, 0.09534030f, 0.17967702f, 0.05560793f, -0.02387124f, -0.00993029f, -0.14530054f, -0.05065025f, 
    -0.10210247f, 0.07738873f, 0.07090776f, -0.19965535f, 0.01138377f, 0.21648338f, 0.11767563f, 0.06376078f, 
    0.03986936f, 0.22351824f, 0.07384191f, 0.13294309f, -0.10066518f, -0.25538802f, -0.04812551f, 0.18950590f, 
    -0.04966763f, -0.24487698f, 0.10485987f, 0.03180762f, -0.16833934f, 0.10990393f, 0.00186055f, -0.05618001f, 
    -0.20641945f, -0.21785934f, 0.03576126f, 0.10590170f, -0.26924878f, -0.12268903f, -0.06804680f, -0.25893736f, 
    0.16083635f, 0.13381134f, 0.08838703f, -0.22248590f, 0.12344574f, -0.19338559f, 0.01266115f, 0.18170497f, 
    0.05409535f, -0.12796685f, -0.11479753f, -0.03965949f, -0.01330716f, 0.09038187f, -0.12877576f, -0.01682765f, 
    0.12657286f, -0.07804675f, 0.10250206f, -0.14442456f, 0.05593603f, 0.15381758f, -0.00355110f, -0.10628555f, 
    0.07573667f, -0.24514422f, 0.10518318f, -0.23802137f, -0.16313314f, -0.04085725f, -0.09010385f, -0.01478655f, 
    -0.17650244f, -0.04348094f, -0.02111351f, -0.14325194f, -0.06059883f, 0.04193641f, -0.04889309f, 0.00383883f, 
    0.14703719f, 0.04690390f, 0.06093274f, 0.03568856f, 0.07940757f, -0.22617374f, 0.07388161f, 0.04820736f, 
    -0.07196803f, 0.18874055f, 0.08183423f, 0.18986055f, -0.05659338f, 0.08156268f, 0.01547041f, 0.10904656f, 
    -0.04974993f, 0.00280440f, -0.03207839f, -0.18410124f, 0.02801512f, 0.01760753f, -0.03498558f, 0.05795036f, 
    0.04951949f, -0.03430506f, -0.02628078f, -0.03855005f, 0.03085849f, -0.08528911f, -0.04170616f, 0.05245811f, 
    -0.04266042f, -0.01004468f, -0.06268529f, -0.06450606f, -0.02989702f, -0.00633931f, -0.01730146f, -0.07132304f, 
    -0.03036487f, 0.00011932f, -0.07051344f, -0.07236455f, -0.02436833f, 0.03941811f, 0.04205529f, -0.01791414f, 
    0.00759590f, 0.06143042f, 0.02816342f, -0.03039603f, -0.03098111f, -0.08591443f, 0.06723394f, -0.06918283f, 
    -0.03416721f, 0.06457163f, 0.02786900f, -0.03104799f, 0.00063864f, -0.02940621f, -0.08806414f, -0.01871981f, 
    0.03035250f, -0.03450432f, 0.04430292f, 0.05362292f, 0.04001183f, 0.05690332f, -0.05959416f, -0.01712613f, 
    -0.01105980f, 0.06052078f, 0.03391846f, 0.06371983f, 0.03831298f, 0.04531657f, 0.01590671f, -0.05772036f, 
    -0.07520364f, 0.02815700f, -0.07011767f, -0.01858689f, 0.00989113f, 0.04397520f, 0.03067858f, -0.04943234f, 
    -0.03307094f, -0.06467423f, -0.02978659f, -0.02778680f, -0.03621716f, -0.00537262f, 0.02846510f, -0.08050867f, 
    0.01403574f, 0.00733633f, -0.00176223f, -0.00075930f, -0.02641107f, -0.00372578f, -0.03512333f, -0.07891866f, 
    0.02111304f, 0.03993003f, 0.05644729f, -0.00011026f, 0.04964059f, -0.06319845f, -0.00452351f, 0.03456571f, 
    -0.06699638f, -0.07009938f, 0.04758942f, -0.07820468f, 0.01557186f, -0.07762772f, -0.05206325f, -0.02685481f, 
    -0.04560553f, -0.05912453f, 0.03259290f, -0.05987719f, 0.00654995f, -0.00827085f, -0.00906586f, 0.01289732f, 
    -0.06849840f, 0.06268208f, 0.01369013f, 0.06125525f, 0.04481237f, -0.06070660f, -0.05856853f, 0.03873102f, 
    -0.02201676f, -0.05356008f, 0.05631088f, -0.02849644f, 0.00747490f, -0.00636439f, -0.04133628f, -0.01533589f, 
    0.01298887f, 0.05084824f, 0.05782461f, 0.02206698f, -0.00652917f, 0.01090750f, -0.06101335f, -0.03418434f, 
    -0.06847145f, 0.00660527f, 0.05916357f, 0.00405659f, 0.04538993f, -0.05562786f, -0.01783364f, 0.01061235f, 
    0.04912019f, -0.03031019f, 0.05641886f, 0.00287787f, -0.03542596f, -0.07924242f, 0.04413323f, -0.05843086f, 
    0.04912176f, 0.06929465f, -0.04777599f, -0.03821284f, -0.07544295f, -0.01777227f, 0.00742233f, -0.03105906f, 
    -0.04258552f, 0.00523658f, 0.05490055f, -0.02614648f, -0.03768665f, -0.01967302f, 0.00291906f, -0.06127671f, 
    0.03712791f, -0.04683492f, 0.01147329f, -0.03747954f, 0.06509974f, -0.04580940f, 0.04839781f, 0.02153544f, 
    -0.01038986f, -0.06673282f, -0.07130737f, 0.05837906f, -0.04243256f, -0.05166357f, -0.00295903f, 0.03063003f, 
    -0.00047808f, 0.01166296f, -0.02183958f, -0.07919504f, -0.06335239f, -0.05535676f, -0.00306775f, -0.02231369f, 
    0.05497689f, -0.02917136f, 0.04291502f, 0.03016695f, -0.01561268f, -0.01730706f, 0.04718097f, -0.06318026f, 
    -0.08001287f, -0.00269278f, 0.03234039f, -0.03421547f, -0.07169084f, 0.06330857f, -0.00833891f, -0.04187516f, 
    -0.04025509f, -0.03209331f, -0.00429571f, 0.00428318f, -0.05998375f, -0.06385749f, -0.01498478f, -0.02282648f, 
    -0.04967934f, 0.04595564f, -0.04342775f, 0.03481554f, -0.01650589f, -0.01181333f, 0.00320864f, 0.05278445f, 
    0.01578167f, -0.07875708f, 0.03122063f, 0.00947031f, -0.06009027f, -0.00160660f, -0.04175806f, 0.02396487f, 
    -0.07635862f, 0.04565807f, 0.06104591f, -0.05688879f, -0.03006783f, 0.03296179f, 0.05446934f, 0.04466123f, 
    -0.06352796f, -0.03140366f, -0.03268497f, -0.02762728f, -0.06739065f, -0.06680748f, -0.07141261f, -0.05732790f, 
    0.01793759f, 0.01458348f, 0.04725514f, 0.06047682f, -0.00435705f, 0.02822649f, -0.04605595f, -0.02357776f, 
    -0.02589888f, -0.04006103f, -0.05154017f, -0.06390618f, -0.07366677f, 0.02026552f, 0.03171805f, 0.06280264f, 
    -0.01273154f, 0.04639298f, -0.01070671f, -0.02842685f, 0.01945415f, 0.02088353f, 0.06072615f, -0.03288517f, 
    0.00220836f, 0.03922284f, -0.00829660f, -0.06766383f, -0.00227057f, 0.00246639f, -0.06376783f, 0.01896953f, 
    -0.02639984f, -0.01572521f, -0.08397689f, -0.05954084f, -0.04848016f, 0.04183761f, 0.03942356f, -0.01361663f, 
    -0.03348416f, 0.02858193f, 0.02563923f, 0.00998074f, -0.06795853f, 0.02018379f, -0.04893080f, -0.05126686f, 
    0.03587463f, -0.07373512f, 0.03287633f, -0.00569300f, -0.06875788f, -0.06193984f, -0.00760168f, 0.04534418f, 
    -0.00672873f, 0.03101373f, -0.09492055f, 0.01543787f, -0.02992788f, -0.03700076f, 0.01560668f, -0.04398968f, 
    -0.08221672f, -0.08439163f, -0.09077054f, 0.03415709f, 0.05678267f, -0.04717169f, -0.02002642f, -0.04919048f, 
    -0.07535588f, -0.07922044f, -0.01707107f, -0.06804696f, -0.05116410f, 0.01180817f, 0.04732573f, 0.00674827f, 
    -0.02457773f, -0.01550147f, 0.04130224f, -0.01300636f, -0.03725265f, -0.07850718f, -0.06714983f, -0.07694062f, 
    0.04107557f, -0.04367353f, -0.05670208f, -0.06275165f, -0.06706323f, 0.01944835f, 0.00563279f, 0.02371388f, 
    -0.06641169f, -0.05245769f, 0.00560691f, -0.07337947f, -0.02800159f, 0.01357097f, -0.07641419f, -0.02271624f, 
    0.05180021f, -0.04204799f, -0.07101885f, 0.00415167f, 0.03260740f, -0.01358157f, -0.04477636f, -0.03969964f, 
    0.02276314f, 0.05540794f, 0.04232546f, 0.00452274f, 0.00161132f, -0.05504657f, -0.03749320f, 0.04165587f, 
    -0.03146258f, 0.05239625f, 0.05882433f, -0.00953675f, -0.03971843f, -0.01581011f, -0.03140444f, 0.06472919f, 
    0.02962956f, -0.04692722f, 0.01697524f, -0.08711727f, -0.00396220f, 0.02801532f, 0.00092707f, 0.02967918f, 
    0.01069693f, -0.05511402f, 0.00061013f, -0.03144195f, -0.04951802f, -0.06357727f, -0.08843808f, -0.00045935f, 
    -0.12213030f, -0.04130848f, -0.11848661f, 0.01836169f, -0.12327148f, 0.11715613f, -0.18967944f, 0.17013015f, 
    0.00585989f, -0.10783745f, 0.08651924f, -0.14241664f, -0.04717392f, 0.39200747f, -0.34106344f, 0.33790201f, 
    0.09409308f, 0.00122873f, 0.07066882f, -0.14914952f, 0.03977174f, 0.00816249f, -0.02061114f, 0.00241643f, 
    -0.35905027f, -0.36166245f, 0.10484835f, 0.23211507f, 0.10710310f, -0.05457341f, 0.02588712f, 0.13067557f, 
    0.19652689f, 0.10529862f, 0.08721010f, 0.06922702f, 0.31271258f, -0.01625047f, -0.09283266f, 0.07460079f, 
    0.14800994f, 0.04794798f, 0.03808054f, 0.01467238f, 0.12814313f, 0.09940858f, 0.06895348f, -0.14655074f, 
    0.33718878f, -0.01890434f, -0.31174800f, 0.18397224f, 0.17692721f, -0.17293350f, -0.02123127f, 0.00646264f, 
    -0.05903588f, 0.06465140f, -0.04030555f, 0.03799069f, 0.28480279f, 0.04235436f, 0.19056162f, 0.20319147f, 
    -0.04907439f, -0.01228664f, 0.03494852f, 0.12048910f, -0.03736294f, -0.01949063f, 0.05054099f, -0.21459103f, 
    0.55900025f, -0.24971177f, 0.12408503f, 0.30039102f, 0.07822888f, -0.06887890f, 0.10572495f, -0.15471256f, 
    0.13014987f, 0.09029706f, 0.01249142f, -0.10358289f, 0.16018249f, -0.01580268f, -0.00171479f, -0.07540135f, 
    -0.08616634f, 0.14037296f, -0.06290258f, 0.00199105f, -0.07429506f, 0.06213352f, -0.01012440f, -0.00449446f, 
    0.01321649f, -0.01710056f, -0.27687055f, 0.19425069f, 0.01516185f, -0.05237656f, -0.12837763f, -0.05194274f, 
    0.03648572f, 0.10435660f, -0.08163438f, 0.12956549f, 0.12924078f, 0.32793921f, -0.07008023f, -0.24507593f, 
    -0.15336651f, 0.00019480f, -0.13547860f, -0.10991577f, 0.02458159f, 0.10441209f, -0.07646446f, -0.08457588f, 
    -0.01817870f, -0.04635803f, -0.01701673f, 0.32788381f, 0.02207521f, -0.09194347f, 0.07766718f, 0.11239388f, 
    -0.09611312f, -0.11552189f, -0.12014651f, -0.05491458f, 0.35671720f, -0.09397661f, 0.13123858f, 0.09083930f, 
    -0.06491608f, -0.16429180f, 0.01090842f, 0.03752523f, 0.09028494f, -0.07675815f, -0.06466834f, 0.02747038f, 
    -0.33989313f, 0.12605922f, -0.28202161f, -0.33000672f, -0.00306288f, 0.08081532f, 0.01139367f, -0.18993205f, 
    0.14678684f, -0.04274911f, 0.05427503f, -0.07582598f, -0.16294183f, 0.31243238f, -0.17138919f, 0.08442367f, 
    -0.07539056f, -0.03973002f, -0.05868371f, -0.13044074f, -0.01383483f, -0.02796358f, 0.11801977f, -0.04210493f, 
    -0.09426446f, 0.10568515f, 0.04326377f, 0.02586139f, 0.05180496f, 0.14696272f, 0.04043335f, 0.24225551f, 
    -0.14216730f, 0.10539038f, 0.01472942f, 0.15293755f, -0.29693723f, -0.04704816f, 0.07344337f, 0.10375731f, 
    0.00924090f, -0.00990439f, 0.01521456f, 0.17213397f, 0.03380661f, -0.01513891f, 0.13960387f, -0.02903438f, 
    -0.02571886f, 0.16367313f, -0.13061419f, 0.43920174f, -0.15524499f, -0.16669683f, 0.04130082f, -0.03226152f, 
    0.18540613f, 0.19371198f, -0.11480473f, -0.02166709f, -0.36185375f, 0.07156684f, 0.20991462f, -0.19057028f, 
    0.08473859f, 0.10420917f, 0.00781047f, 0.00080249f, 0.09163222f, -0.04189333f, -0.22060253f, -0.04262836f, 
    0.44717264f, -0.08343195f, -0.02393064f, 0.03597384f, -0.19652401f, 0.16948833f, -0.16508201f, -0.03312770f, 
    0.05992670f, -0.05161445f, -0.09355495f, -0.01690882f, 0.08637414f, -0.06211727f, 0.16727261f, 0.22402889f, 
    -0.27166748f, -0.04579684f, 0.02026279f, 0.06122281f, 0.07248627f, -0.00712543f, 0.04050467f, -0.05959134f, 
    0.29605100f, -0.03303010f, 0.31211650f, 0.42791614f, 0.01225629f, 0.23129092f, 0.06902940f, -0.03386622f, 
    0.08603744f, -0.10915837f, 0.14794201f, 0.08436048f, -0.42275298f, 0.30677614f, -0.07369737f, -0.12600188f, 
    0.00709752f, 0.08975498f, -0.00576520f, 0.14287226f, 0.18337563f, 0.06436464f, 0.09593037f, -0.00786600f, 
    0.20816256f, -0.25199568f, 0.36543393f, 0.40190029f, -0.23630768f, 0.20934504f, 0.05750497f, -0.01516305f, 
    0.12225377f, -0.11317673f, 0.02300126f, 0.19391878f, -0.24744758f, 0.08634726f, -0.07276354f, 0.30779961f, 
    0.03198249f, -0.05599206f, 0.07287684f, 0.04758607f, -0.03837060f, -0.03518954f, -0.07063932f, -0.05278584f, 
    -0.05408686f, -0.40733501f, 0.23212102f, 0.10550277f, -0.05751133f, 0.00407931f, -0.05822391f, 0.04783735f, 
    -0.04448674f, 0.04372195f, 0.00470328f, -0.07708701f, -0.27159703f, 0.17173725f, 0.00923264f, 0.23786621f, 
    0.01737612f, -0.00971399f, 0.06083615f, 0.01797196f, -0.09191876f, -0.01461925f, 0.08878905f, 0.14659002f, 
    0.05998734f, -0.13828611f, 0.01648629f, -0.30903578f, 0.11464646f, -0.02855226f, 0.01097954f, -0.07134841f, 
    0.08903964f, -0.08284075f, 0.09682821f, 0.01328907f, 0.04632359f, 0.14502111f, -0.06010311f, -0.06464746f, 
    0.16576013f, -0.01681235f, -0.04468091f, -0.08024897f, 0.12010855f, 0.00874433f, 0.07521601f, 0.06691537f, 
    0.04650990f, 0.40908861f, 0.19044913f, -0.02238288f, -0.06482084f, -0.17891254f, 0.17111358f, 0.10810221f, 
    -0.03173478f, 0.01751971f, 0.12504582f, -0.06925871f, -0.04309335f, -0.47608951f, 0.13253526f, -0.06245381f, 
    0.04401841f, 0.17616986f, 0.15923911f, 0.14174315f, 0.06844259f, -0.14708228f, 0.08315249f, 0.06468625f, 
    -0.19715141f, 0.23773856f, -0.13397239f, -0.04014648f, -0.09136379f, -0.10094070f, 0.17181739f, -0.19562480f, 
    -0.03623917f, -0.04593152f, 0.14052272f, 0.05266213f, -0.27420080f, -0.35708380f, -0.13995340f, -0.08579900f, 
    -0.08830211f, -0.04233203f, 0.23176593f, -0.02575789f, 0.09116895f, 0.05128815f, 0.09839524f, 0.14720887f, 
    0.20065513f, 0.34050080f, 0.16055858f, 0.24001300f, -0.07018780f, 0.02974849f, 0.16679661f, 0.02782731f, 
    0.12523040f, 0.21048447f, -0.18803017f, 0.02711634f, 0.01292275f, 0.12818113f, 0.06263197f, -0.11043910f, 
    0.04319232f, 0.17660668f, 0.23486996f, 0.13205433f, -0.01312101f, -0.08600976f, -0.03924424f, 0.13942927f, 
    0.31119773f, 0.06399155f, 0.03195257f, 0.05872754f, -0.01589647f, 0.00451689f, 0.01137250f, 0.01462815f, 
    0.15535544f, -0.09336609f, 0.05073730f, 0.05484196f, 0.41097343f, -0.09876693f, 0.26815030f, 0.15087946f, 
    -0.08030697f, 0.01745402f, -0.05057416f, 0.09949789f, 0.12008304f, -0.12534085f, 0.03845520f, -0.11940138f, 
    0.51576602f, 0.27657256f, 0.24378505f, 0.40001699f, 0.01993188f, 0.17721066f, 0.14480111f, 0.14235596f, 
    -0.03436788f, 0.20706250f, 0.09114234f, 0.02780397f, -0.08402433f, 0.07234790f, -0.09611845f, 0.09412452f, 
    0.09352098f, 0.08998543f, 0.08015303f, 0.18556497f, 0.06230824f, 0.15606101f, 0.28086475f, -0.20337890f, 
    0.33521011f, -0.18686911f, 0.35681456f, 0.30923355f, -0.07595226f, 0.20520888f, 0.16821539f, 0.05868369f, 
    0.08843570f, -0.00802781f, 0.01880783f, 0.09824245f, 0.10813931f, 0.16235878f, 0.15904178f, 0.06720831f, 
    -0.08856054f, -0.01617436f, 0.05298112f, 0.15731539f, 0.15730326f, 0.12281146f, 0.08258414f, 0.06075786f, 
    -0.21899165f, -0.23181094f, -0.11602470f, -0.12490079f, 0.16671503f, 0.04384090f, -0.02799179f, 0.16072911f, 
    -0.14627361f, 0.14058258f, 0.07517574f, 0.07519535f, 0.03655032f, 0.19384733f, -0.11751939f, 0.07572705f, 
    0.30986914f, 0.00235159f, 0.08877412f, 0.09711757f, 0.12986521f, 0.13539806f, 0.09153975f, 0.29434466f, 
    0.14163966f, -0.25371414f, 0.01565830f, 0.08794721f, 0.21778236f, -0.00432552f, -0.21276116f, 0.13325809f, 
    0.20425205f, -0.05145341f, 0.10139360f, 0.03150462f, -0.21632440f, 0.15841208f, 0.28423163f, 0.10662011f, 
    0.22764468f, 0.12886637f, 0.13411602f, 0.08676115f, 0.07562938f, -0.02001310f, 0.10776524f, 0.03721401f, 
    0.01818167f, 0.05765820f, -0.38823304f, -0.26116544f, -0.06920395f, 0.01617628f, 0.18074928f, 0.05794745f, 
    -0.06209750f, 0.02121484f, 0.20537123f, -0.06943166f, -0.03207898f, -0.23148753f, 0.05807019f, -0.23788598f, 
    0.07880987f, 0.10850832f, 0.06983040f, 0.20383596f, 0.15444626f, -0.22642511f, 0.11680985f, 0.17156449f, 
    0.18247220f, 0.05100869f, 0.06354596f, 0.07530243f, 0.07907627f, -0.01529834f, 0.03344163f, -0.05370007f, 
    -0.07545605f, -0.09533188f, 0.03857793f, 0.06947742f, -0.25643593f, -0.05640847f, 0.03558734f, 0.04697404f, 
    -0.01023313f, -0.01581557f, 0.08772979f, 0.13603567f, 0.13253988f, 0.02475202f, 0.09792279f, 0.13513044f, 
    -0.15511855f, 0.13484259f, -0.14816661f, -0.11608876f, 0.19518958f, 0.13929304f, 0.01507198f, -0.02382161f, 
    -0.00896856f, -0.00351737f, 0.06384834f, 0.03650029f, 0.26758006f, -0.17501289f, 0.14385790f, 0.03400787f, 
    0.02033694f, 0.10217632f, -0.07062731f, -0.11847093f, -0.12244514f, 0.27059716f, 0.05828758f, 0.28922641f, 
    -0.15648392f, -0.04255154f, 0.05656045f, 0.06225555f, -0.01333355f, -0.00028807f, 0.13199165f, -0.05325054f, 
    0.12318235f, -0.00440687f, -0.02356538f, -0.05607695f, -0.42813948f, 0.03861182f, -0.04553663f, -0.14661676f, 
    0.00447295f, 0.08841743f, 0.02040869f, 0.00465231f, 0.05441876f, 0.05196721f, -0.07390300f, 0.11147422f, 
    -0.31519324f, -0.24444759f, 0.02261926f, 0.18832232f, 0.00102416f, -0.05789115f, -0.04883320f, 0.02290749f, 
    0.09398165f, 0.13024803f, 0.02719848f, 0.06419723f, 0.24319555f, 0.07839367f, 0.13326500f, -0.03940738f, 
    -0.14838217f, 0.03261103f, 0.18508610f, 0.04838491f, -0.01951541f, 0.11601189f, -0.07923118f, 0.05606680f, 
    -0.29066429f, 0.24408402f, -0.06252605f, -0.23185010f, -0.04211780f, -0.05814774f, -0.26505128f, 0.01560587f, 
    0.02508458f, -0.01168624f, 0.09945174f, -0.07369266f, -0.39358211f, 0.04656889f, -0.11751851f, 0.02191296f, 
    0.08971000f, 0.12738061f, -0.01644966f, -0.02868455f, 0.07645781f, -0.07113320f, 0.02874686f, 0.07247061f, 
    0.56985062f, -0.07588113f, 0.06071023f, 0.11563835f, -0.19482478f, -0.06465160f, 0.02182898f, -0.00412849f, 
    0.16331136f, 0.04672900f, 0.11543864f, -0.06587788f, -0.54047728f, -0.29476568f, 0.19426936f, -0.00254079f, 
    0.05214507f, 0.06681118f, 0.10206743f, -0.10485578f, 0.04292648f, 0.05306188f, -0.09453627f, -0.12246466f, 
    -0.37605312f, -0.01239448f, 0.14657989f, 0.33763716f, -0.03446649f, -0.04027928f, 0.18770432f, 0.16941662f, 
    -0.02635096f, 0.00264739f, 0.12080285f, 0.08228848f, -0.01826898f, 0.06722399f, -0.14046587f, 0.03949405f, 
    0.20839176f, 0.00218874f, 0.16221465f, 0.21519116f, -0.13882333f, -0.05173835f, -0.02972108f, 0.02064567f, 
    0.34954390f, 0.24831288f, -0.14565280f, -0.32512316f, 0.12845396f, -0.06227690f, -0.12326504f, -0.12166920f, 
    -0.02753586f, 0.01313252f, -0.10834631f, 0.02712206f, -0.01225482f, -0.16731735f, 0.04512136f, 0.17903182f, 
    -0.07383052f, 0.03906519f, 0.10649148f, 0.15086065f, -0.07390865f, 0.25368041f, -0.11907323f, 0.07022873f, 
    0.37379205f, 0.16628686f, -0.13007167f, -0.12237029f, 0.06993916f, -0.06019377f, -0.01357453f, 0.16676335f, 
    0.01610649f, -0.05079344f, -0.07705827f, 0.01822913f, 0.09092287f, 0.10614662f, 0.11427727f, 0.14686571f, 
    0.09161948f, -0.02555462f, -0.24513716f, 0.10507662f, -0.10517042f, 0.08756023f, -0.14963442f, 0.01908427f, 
    -0.25313345f, -0.10952527f, 0.15907715f, 0.21099651f, -0.02333054f, -0.04887237f, -0.01726766f, 0.03017028f, 
    -0.02465203f, 0.24166541f, 0.10418632f, 0.01226275f, 0.21583736f, 0.01147696f, -0.17322317f, 0.14604157f, 
    -0.04568132f, -0.01611876f, 0.01481281f, 0.11946176f, 0.14253467f, -0.00500689f, -0.13544562f, -0.14829671f, 
    -0.52201086f, -0.50116289f, -0.09657062f, 0.08148404f, 0.12015834f, 0.00859027f, -0.03941871f, -0.04124203f, 
    0.08472629f, -0.02914009f, 0.15122391f, -0.00268146f, 0.09051910f, -0.12279218f, 0.02807804f, -0.03984550f, 
    0.12221571f, 0.00884730f, -0.03062002f, 0.07340401f, 0.15313749f, 0.15575504f, 0.22689918f, 0.05491817f, 
    0.12811917f, 0.27061146f, 0.03467541f, -0.32316121f, 0.10197817f, -0.09400347f, -0.32704112f, -0.08075614f, 
    -0.09877507f, -0.04171786f, 0.10815649f, 0.24787183f, 0.18092817f, 0.11987650f, -0.25161093f, -0.04260477f, 
    0.02797398f, -0.03337654f, -0.04685173f, 0.18864518f, -0.11088124f, -0.05414115f, 0.17892572f, 0.04928646f, 
    -0.05500534f, -0.34841734f, 0.04966223f, -0.05178363f, 0.08859504f, 0.06541214f, 0.16413011f, -0.03319539f, 
    0.25625172f, 0.24712747f, 0.08795492f, 0.10904761f, 0.16710985f, -0.16466941f, -0.08944230f, 0.21204533f, 
    0.09393308f, 0.10408991f, -0.06848092f, -0.07400534f, 0.01887784f, 0.12855619f, -0.03167862f, -0.03887745f, 
    0.21864019f, -0.12305675f, -0.13032407f, 0.06086878f, -0.03497317f, 0.06726095f, -0.07109611f, 0.14914322f, 
    -0.01244827f, 0.02456097f, 0.09431361f, 0.18796983f, 0.11365325f, 0.39836368f, -0.01737010f, -0.08670451f, 
    0.00593528f, 0.00543417f, -0.22461084f, 0.10191014f, -0.06002457f, 0.03045079f, 0.07457787f, 0.17926556f, 
    0.39842954f, 0.07298943f, -0.09963271f, -0.34257859f, 0.00835048f, 0.06060021f, -0.00875738f, 0.03647810f, 
    -0.03781464f, -0.07198443f, -0.14316468f, 0.08918691f, 0.20540701f, 0.13699789f, -0.10048624f, 0.05678090f, 
    -0.09636693f, -0.09280269f, 0.07891177f, 0.03661917f, 0.12836334f, 0.06410711f, 0.04415166f, -0.00872236f, 
    -0.15941396f, -0.07229067f, 0.10127898f, 0.10426087f, -0.10030689f, 0.19707668f, 0.07567708f, -0.00547852f, 
    0.14301735f, 0.10299482f, -0.06819162f, 0.04739272f, -0.14072382f, -0.02057802f, -0.03251560f, 0.06585827f, 
    0.15877952f, 0.12700245f, -0.03202813f, -0.06628092f, 0.25118065f, -0.32084364f, 0.06735660f, -0.11730168f, 
    0.26086599f, -0.17824636f, -0.01246752f, -0.01302425f, -0.03515095f, 0.10388721f, 0.11126845f, 0.09094087f, 
    0.21455945f, 0.16223462f, 0.20761776f, 0.06922500f, -0.11696172f, -0.16693152f, 0.04000176f, -0.27371734f, 
    -0.08080795f, 0.00971917f, 0.28832343f, 0.05459359f, 0.10975703f, 0.11522362f, 0.23923242f, 0.07959667f, 
    0.08127332f, -0.02650314f, 0.04857852f, -0.16678782f, -0.06694630f, 0.02648886f, 0.22291522f, 0.01774129f, 
    0.06456196f, 0.17897494f, -0.04602226f, 0.20162217f, -0.01647173f, -0.12052910f, -0.02912791f, -0.04004965f, 
    -0.04190714f, 0.02352625f, 0.03052415f, 0.09330986f, -0.03516753f, 0.04814197f, -0.21632604f, -0.13260828f, 
    -0.05492387f, 0.04497134f, -0.12580386f, -0.07162563f, -0.09256499f, -0.14228725f, -0.01663315f, -0.12333704f, 
    -0.02823856f, -0.02400278f, -0.00501494f, -0.02253707f, -0.45265967f, -0.15615739f, 0.14581880f, -0.17418841f, 
    -0.05608022f, 0.04781073f, 0.03076730f, -0.15582980f, 0.08905451f, -0.31223896f, -0.07569489f, 0.11521089f, 
    -0.30786794f, -0.05632353f, -0.01435417f, -0.15395421f, -0.05128538f, -0.04829219f, -0.00965028f, -0.00284948f, 
    -0.09345798f, -0.10042862f, 0.05806049f, -0.06326887f, -0.14152148f, 0.17095250f, 0.00774187f, 0.13770239f, 
    0.19233279f, 0.07368337f, 0.20352967f, -0.10152663f, -0.02911159f, -0.11036506f, -0.01466476f, -0.07366599f, 
    -0.46082619f, 0.15882310f, 0.07068357f, -0.13467549f, -0.04578698f, -0.09809318f, -0.07104867f, 0.03046746f, 
    0.06636827f, -0.11863253f, -0.02029736f, 0.16601332f, -0.13636126f, -0.14655706f, -0.07466136f, -0.21397181f, 
    0.24476662f, -0.05780154f, -0.08351260f, 0.13290361f, -0.02079083f, -0.09178809f, -0.02342051f, 0.14752251f, 
    -0.06487858f, -0.01458731f, 0.19877200f, 0.04808720f, -0.07691658f, 0.01887139f, -0.16264692f, 0.02542456f, 
    0.02106610f, -0.02563544f, -0.05695286f, 0.22120886f, 0.00823525f, -0.41082168f, 0.30389506f, 0.29385808f, 
    -0.08040181f, -0.04688589f, 0.06329377f, -0.06737825f, -0.01373738f, 0.05247684f, 0.08146116f, 0.04873049f, 
    0.22492194f, 0.17532004f, 0.13380270f, 0.15544911f, 0.01820141f, 0.11777291f, 0.05224790f, -0.00110651f, 
    0.04429321f, -0.06883980f, -0.02453367f, -0.06148145f, -0.39085388f, 0.22865684f, 0.10905148f, 0.16777286f, 
    0.07014797f, 0.00170151f, 0.20748462f, -0.02435695f, -0.00081847f, 0.08514617f, 0.19429749f, -0.11464185f, 
    0.18387075f, -0.19634663f, 0.23500445f, 0.46009281f, 0.14421460f, -0.00760450f, 0.14290981f, 0.08298629f, 
    0.03897084f, -0.01513621f, -0.11616033f, 0.02801638f, 0.36949903f, 0.03757757f, 0.20550461f, 0.17961866f, 
    0.33053437f, 0.26331693f, -0.03418408f, -0.00903796f, -0.12902933f, -0.01284603f, 0.09028551f, -0.20878132f, 
    -0.23907821f, 0.47623786f, -0.02053874f, -0.08924465f, 0.22716385f, 0.01299407f, -0.06090479f, 0.04432369f, 
    0.06288891f, 0.03978022f, -0.00192432f, -0.12721086f, 0.41259840f, 0.12602167f, -0.00307385f, 0.27507433f, 
    0.27174357f, 0.14622089f, 0.17916994f, -0.02226558f, 0.02069076f, 0.16295759f, -0.07981067f, -0.03688828f, 
    -0.05420653f, -0.15364626f, -0.28773126f, -0.08117530f, 0.04155904f, -0.01484435f, 0.06389411f, -0.08106992f, 
    0.11928835f, -0.09607861f, 0.10298067f, 0.08568569f, -0.03966518f, 0.00060017f, 0.10287006f, 0.08073068f, 
    0.06976786f, 0.04969999f, -0.07588683f, -0.02486541f, -0.06328513f, 0.21364188f, 0.25588000f, 0.26578695f, 
    0.52250361f, -0.06531495f, -0.06051349f, 0.03430197f, 0.00114272f, 0.08174362f, 0.12511618f, -0.04009592f, 
    0.01853446f, 0.02156030f, -0.11185035f, 0.01490519f, -0.22573708f, 0.12167959f, 0.03530671f, 0.06283198f, 
    -0.15833186f, -0.00610875f, 0.00278312f, 0.09139036f, 0.01722194f, 0.11231274f, -0.09429014f, -0.06752117f, 
    0.02723557f, -0.25404897f, -0.00374240f, 0.02798573f, -0.12987562f, 0.08152568f, 0.09311446f, -0.02822665f, 
    0.13795508f, -0.13698193f, -0.02752501f, 0.05201439f, 0.16643281f, 0.49971670f, 0.05850760f, -0.13803679f, 
    0.05984178f, 0.07325195f, 0.08820525f, 0.16870174f, 0.17480072f, 0.20257132f, -0.23928405f, 0.10834397f, 
    0.33389327f, -0.12840933f, 0.15770946f, -0.04709903f, 0.06663854f, -0.10849200f, -0.13436314f, 0.06577482f, 
    -0.18342249f, -0.15582837f, 0.16137046f, -0.16537990f, -0.40075108f, 0.19860150f, -0.30427441f, 0.05231249f, 
    -0.07618746f, 0.14068966f, 0.06455167f, -0.05514127f, 0.09190742f, -0.01034205f, -0.05294044f, 0.02321776f, 
    0.55240238f, -0.11341596f, 0.19932915f, 0.24042435f, -0.04972764f, -0.00620642f, 0.08479232f, -0.11117569f, 
    -0.07459456f, -0.11957901f, 0.12877446f, -0.15196905f, -0.33908692f, 0.16387406f, 0.12279623f, 0.01836693f, 
    -0.04275472f, 0.03102146f, 0.13164130f, 0.02587880f, -0.04948729f, 0.01776535f, -0.13027701f, -0.11990212f, 
    0.16012308f, -0.11484725f, 0.07840127f, -0.02528985f, 0.07185946f, -0.00931223f, 0.18385962f, 0.15351403f, 
    0.01802189f, 0.04764546f, 0.09935068f, 0.09253202f, 0.54437256f, 0.02516101f, -0.20615736f, 0.06600015f, 
    0.08255603f, 0.01449112f, 0.03973588f, 0.22225937f, -0.01512933f, -0.15388738f, 0.01776833f, 0.01470227f, 
    0.02877859f, 0.24085388f, 0.25989670f, -0.10368454f, 0.10880151f, -0.14821196f, -0.11196283f, 0.19013423f, 
    -0.04195303f, 0.13203119f, -0.01637987f, 0.01794733f, 0.17327622f, -0.06413485f, 0.02643183f, 0.15365203f, 
    -0.04268315f, 0.03922272f, 0.09554479f, 0.11275234f, -0.18086922f, 0.28063652f, -0.06688222f, 0.07781480f, 
    -0.06449576f, 0.38288820f, -0.25470841f, -0.10105038f, 0.03242236f, -0.03250875f, -0.05737631f, 0.07081930f, 
    -0.10745313f, 0.05724305f, -0.04245884f, -0.07304032f, 0.23974849f, -0.01742778f, -0.26739642f, 0.16669513f, 
    0.08957924f, -0.06133943f, -0.12703469f, 0.03080913f, -0.07434091f, 0.18424581f, -0.16375874f, 0.03403998f, 
    -0.32376134f, -0.05114814f, 0.21039169f, 0.03760793f, -0.00625157f, 0.10763118f, 0.06840238f, -0.07685348f, 
    -0.00335420f, -0.05146196f, -0.05447963f, 0.07046023f, 0.52600330f, -0.43959174f, 0.20441940f, -0.24079154f, 
    -0.00631955f, 0.07603251f, -0.00809544f, 0.05075841f, -0.02736696f, -0.02740680f, 0.07061053f, 0.07439783f, 
    0.04493474f, 0.22259018f, 0.00062889f, -0.25852671f, -0.05497327f, 0.10546055f, 0.11613664f, 0.06769031f, 
    -0.07515483f, -0.00504539f, -0.08829835f, -0.03385874f, -0.11601576f, 0.21038277f, 0.29424909f, -0.03546210f, 
    -0.11397360f, -0.09553173f, -0.01978179f, 0.03195142f, -0.14032526f, 0.07888938f, -0.04206507f, 0.09057582f, 
    0.00402625f, 0.16588394f, 0.37424293f, -0.43752936f, 0.09442759f, 0.22105393f, 0.08893701f, 0.11368067f, 
    0.00174145f, -0.06793894f, -0.08173836f, 0.03462952f, 0.02084753f, 0.10528801f, -0.17551604f, 0.07868309f, 
    0.00733535f, 0.00333474f, -0.02962746f, 0.00679801f, -0.04480316f, -0.07286992f, -0.09504693f, 0.08872323f, 
    -0.45247719f, -0.01079783f, -0.10783517f, -0.25528583f, 0.08436640f, -0.04040727f, 0.06909532f, 0.02507341f, 
    -0.04120202f, 0.11790753f, 0.04756254f, -0.01791149f, 0.03077988f, -0.13443148f, -0.01006765f, 0.09107098f, 
    -0.05621095f, 0.00150660f, 0.16209263f, 0.02669718f, 0.01731952f, 0.00029997f, 0.07010782f, -0.11888155f, 
    0.74707657f, 0.07696699f, 0.28338471f, -0.27258465f, -0.17628270f, -0.02188865f, 0.05847404f, -0.01343782f, 
    -0.02264648f, -0.04335044f, 0.15626025f, 0.01548080f, -0.04480596f, 0.07324643f, -0.00948251f, 0.29829165f, 
    0.25834274f, -0.04647041f, 0.24555928f, 0.01541584f, -0.03109499f, -0.00817337f, -0.05889344f, 0.08951951f, 
    0.34709159f, 0.01481637f, 0.06442095f, -0.19934750f, 0.14726587f, 0.06319749f, 0.00678997f, -0.01412196f, 
    -0.04692300f, 0.04083731f, -0.03505737f, 0.17166559f, -0.12475602f, 0.20515728f, -0.06246727f, 0.10183891f, 
    0.04379802f, 0.15307553f, -0.11285258f, 0.10625181f, -0.05164290f, 0.02299034f, 0.03159105f, -0.00396367f, 
    0.22532243f, -0.19328466f, 0.11201154f, 0.33250016f, -0.01658854f, 0.07114126f, -0.05848537f, -0.10816884f, 
    -0.15386626f, 0.14899017f, -0.05575930f, -0.05572658f, 0.10591275f, -0.07452744f, -0.00206362f, 0.10670743f, 
    0.06016161f, -0.13855797f, -0.03776267f, 0.04516478f, 0.23378664f, -0.09879145f, -0.05735528f, 0.04833033f, 
    0.42510635f, -0.54402959f, 0.23301780f, -0.00371115f, -0.17713629f, 0.07058606f, -0.00530994f, -0.14196703f, 
    -0.01097851f, -0.02530083f, -0.06849167f, -0.03314283f, 0.23781422f, 0.18127292f, 0.05180884f, -0.02330286f, 
    -0.11693070f, -0.03379843f, -0.02753230f, -0.20045529f, -0.05386679f, -0.05022994f, -0.06090360f, -0.01557800f, 
    -0.14692998f, 0.17186005f, 0.29421985f, 0.05139073f, 0.08021642f, -0.03996622f, -0.18355294f, -0.04486304f, 
    0.23266472f, -0.01044073f, -0.05102856f, -0.05075047f, -0.19240023f, 0.25525954f, -0.01224796f, 0.07022509f, 
    0.05387696f, -0.06062641f, -0.04601956f, -0.00671026f, 0.01469900f, 0.31038693f, -0.09576192f, -0.11113291f, 
    0.04166915f, 0.03695969f, 0.00294946f, -0.16700409f, 0.11331137f, 0.02733332f, -0.26641184f, -0.20957790f, 
    0.13241860f, -0.21779938f, 0.09206242f, -0.08323022f, -0.13579641f, -0.07231515f, 0.03294263f, 0.10633606f, 
    -0.17854488f, -0.21256693f, -0.05267558f, 0.08807010f, 0.05198165f, -0.14295094f, 0.02841426f, -0.03233629f, 
    -0.10965889f, 0.03903861f, 0.11592986f, 0.17011404f, -0.20421843f, -0.13372736f, -0.39968789f, -0.20809437f, 
    -0.11520351f, -0.11175459f, 0.03962154f, -0.04465310f, -0.13710134f, 0.17683959f, -0.20218872f, -0.11288726f, 
    0.07282105f, 0.05243621f, -0.02516871f, 0.06485214f, 0.04159586f, 0.06476191f, -0.04368609f, -0.03354072f, 
    0.12012357f, -0.00292807f, 0.18089224f, 0.04823117f, -0.03194750f, 0.03544996f, 0.02142378f, 0.04505740f, 
    0.14377907f, -0.11978450f, -0.04756885f, -0.21567371f, 0.02284458f, -0.05018767f, 0.17694090f, 0.15202546f, 
    0.00198057f, -0.05221806f, 0.03651737f, -0.09123596f, 0.00119462f, 0.01493725f, -0.08994688f, -0.08165156f, 
    0.35842010f, 0.07525998f, 0.12301322f, -0.09849685f, -0.08748313f, 0.04574653f, -0.04804579f, -0.00911180f, 
    -0.09254027f, 0.06974071f, -0.00777142f, -0.01569589f, 0.22674400f, 0.16492313f, 0.04822509f, 0.17825750f, 
    0.05943811f, -0.18221734f, -0.08334197f, 0.09987097f, -0.07518134f, 0.11899389f, -0.11944896f, 0.29580823f, 
    0.47029266f, 0.22514719f, -0.00784866f, -0.28808901f, 0.06613039f, 0.11712765f, -0.13412255f, -0.09888774f, 
    -0.14654206f, 0.11076274f, -0.06284603f, 0.08857992f, -0.35011673f, -0.32220039f, -0.03502995f, -0.32329503f, 
    0.08073491f, 0.15245642f, -0.07762776f, 0.02904731f, -0.14117852f, 0.09013841f, 0.20308320f, -0.18278785f, 
    0.02700904f, -0.05201509f, 0.22440282f, -0.15460011f, 0.15231954f, 0.05681562f, -0.05023009f, 0.01677264f, 
    -0.01203062f, 0.22909296f, 0.14138110f, -0.13653372f, -0.03763154f, 0.02744206f, 0.28895137f, -0.00584458f, 
    0.21065009f, 0.08433072f, -0.05144889f, -0.13338529f, 0.08154423f, 0.09660157f, -0.24877000f, 0.12226740f, 
    -0.39772239f, 0.21332304f, 0.10612249f, 0.01261516f, -0.13275842f, 0.01678307f, -0.05915546f, -0.22098961f, 
    -0.01675204f, -0.27803236f, -0.07372301f, -0.19872861f, 0.16302083f, -0.24426939f, -0.09903942f, 0.03246552f, 
    0.04720911f, 0.06838381f, -0.05047420f, -0.12234862f, 0.01556633f, -0.13550350f, -0.09856993f, 0.20999184f, 
    -0.05374766f, 0.05585712f, 0.11763667f, -0.16722092f, 0.12696362f, 0.04589752f, 0.05763001f, -0.08444582f, 
    0.06582440f, -0.08389484f, -0.05103294f, 0.06530525f, -0.04501399f, -0.13331559f, 0.20332399f, -0.22732097f, 
    0.12265801f, -0.13389397f, -0.05083426f, 0.10593750f, -0.01811393f, 0.01006258f, 0.04268060f, 0.08165610f, 
    -0.02142261f, 0.32949209f, 0.01373417f, -0.26816842f, -0.01694389f, 0.14951901f, 0.11999857f, -0.01015588f, 
    -0.08596804f, -0.01951247f, -0.04619185f, -0.09465235f, -0.38562083f, 0.08112416f, -0.01519110f, -0.12105751f, 
    -0.06381005f, 0.00331764f, 0.11362115f, -0.04295570f, -0.16152923f, -0.02949137f, 0.08154258f, 0.13379537f, 
    -0.31930420f, 0.06478766f, 0.27765954f, -0.37072408f, -0.09026311f, -0.02678920f, 0.07579272f, 0.02335086f, 
    0.12936214f, -0.05400607f, 0.04905631f, 0.11788835f, -0.37364537f, -0.09111350f, -0.03173347f, -0.00253665f, 
    0.00235040f, 0.07858358f, -0.01737459f, -0.10646164f, 0.04188332f, 0.07306258f, -0.04180170f, 0.32586101f, 
    -0.23744360f, 0.24679989f, -0.21337563f, 0.03080196f, -0.06575464f, 0.03369501f, -0.02573007f, 0.06147854f, 
    0.09202414f, -0.08644825f, 0.15237433f, 0.05214578f, -0.18367234f, 0.03460897f, 0.02685349f, 0.00559149f, 
    0.17690958f, -0.04066547f, 0.05076694f, 0.17724818f, 0.06481829f, 0.01780582f, -0.01474421f, 0.09566126f, 
    -0.10281780f, 0.02196300f, 0.13170481f, 0.10646694f, -0.10326971f, 0.01876235f, 0.05242359f, -0.02131385f, 
    0.09167908f, -0.03704157f, -0.02932216f, -0.08578227f, -0.13637391f, -0.13066001f, 0.27936435f, 0.37747800f, 
    0.02632929f, 0.05836272f, 0.02750503f, -0.01749268f, -0.06834194f, 0.01844289f, 0.08991506f, -0.11351138f, 
    -0.35515213f, -0.08119919f, -0.03289568f, 0.02210483f, 0.04775834f, -0.02372677f, 0.09822489f, -0.13428672f, 
    0.08122488f, 0.12315267f, -0.01436772f, 0.11775906f, 0.05098506f, 0.10577875f, -0.19747865f, -0.00687458f, 
    0.00587715f, 0.11198664f, 0.08302084f, 0.02124498f, -0.06983302f, 0.10872407f, 0.08486284f, 0.03676376f, 
    0.24801391f, -0.00577626f, 0.24103306f, 0.46826038f, -0.02732646f, -0.18001910f, 0.08071241f, 0.18049912f, 
    -0.00444398f, -0.07328644f, -0.05892305f, 0.08907994f, 0.13436826f, -0.20573664f, 0.15835683f, 0.15088767f, 
    0.14699554f, 0.03765102f, 0.06977537f, -0.05784298f, 0.08195294f, 0.20142098f, -0.07208151f, -0.01592111f, 
    -0.17615287f, 0.00486923f, 0.01543477f, 0.01257619f, 0.10101269f, -0.07096644f, 0.16058408f, -0.01444260f, 
    0.01393788f, 0.00251676f, -0.07395024f, 0.01374763f, 0.21180747f, 0.01450589f, -0.25042313f, -0.03077762f, 
    0.05311287f, -0.10709053f, 0.06325149f, -0.16583812f, 0.01021115f, 0.03700759f, -0.05956593f, -0.00612448f, 
    0.20314215f, 0.19198166f, -0.15960644f, -0.14973041f, 0.11262687f, -0.05025052f, 0.07551299f, -0.07654379f, 
    0.08998679f, -0.09229562f, -0.11083363f, 0.09579421f, -0.56433702f, 0.06795149f, 0.15892813f, -0.16976964f, 
    0.07029666f, -0.00285177f, -0.02778599f, 0.02582008f, -0.13559553f, 0.01820668f, 0.03389631f, 0.09994211f, 
    0.36824590f, 0.27031374f, -0.10137554f, -0.07391940f, -0.15441482f, 0.15487534f, -0.04375413f, -0.05236273f, 
    -0.02479245f, -0.01549360f, -0.09713413f, 0.01296134f, -0.19390415f, 0.19457063f, -0.01985189f, 0.03538566f, 
    -0.23618376f, -0.04000159f, 0.08961278f, -0.00749237f, -0.08700722f, -0.06470845f, -0.04544507f, 0.00221390f, 
    0.05829955f, -0.15926068f, 0.04803090f, 0.04785719f, -0.06163887f, 0.04702126f, 0.13657783f, 0.02392245f, 
    0.09522679f, 0.02469132f, 0.08217990f, -0.13717280f, -0.17733341f, 0.03440350f, 0.13656238f, 0.07992813f, 
    0.20873719f, 0.05866291f, 0.08923923f, -0.07172782f, 0.11256746f, -0.01763022f, -0.08755948f, 0.11593384f, 
    0.06215208f, 0.36081630f, 0.22180048f, 0.19236697f, -0.05762705f, -0.07542226f, -0.06152559f, 0.07410295f, 
    0.06964298f, -0.19592886f, 0.02945752f, 0.02972488f, -0.22890495f, 0.12511566f, -0.07539124f, -0.06250393f, 
    0.12587370f, -0.02201229f, -0.14552458f, 0.24099058f, -0.10651886f, 0.01509185f, 0.01362537f, 0.04799495f, 
    -0.25318396f, -0.05255485f, 0.04083192f, 0.11122565f, -0.08199063f, -0.07996353f, 0.02172035f, -0.06626276f, 
    0.06465223f, 0.06507434f, -0.04393974f, -0.12495960f, -0.02558793f, -0.21591349f, 0.21900873f, 0.23633333f, 
    -0.28398651f, -0.02070338f, -0.03312407f, -0.00730571f, 0.01711586f, 0.03255244f, 0.12371723f, -0.09612343f, 
    -0.53651154f, 0.05707515f, 0.10208934f, 0.25661895f, 0.01243469f, -0.07701540f, 0.08656716f, -0.03721859f, 
    0.11075675f, -0.08347723f, 0.07408634f, 0.10718063f, 0.07923867f, -0.16167292f, 0.13726680f, -0.02185334f, 
    -0.01975955f, 0.04807417f, 0.09545483f, -0.08359881f, -0.02404582f, 0.07896613f, 0.04066332f, -0.05007413f, 
    0.20971817f, 0.09516519f, 0.21160123f, 0.17353018f, 0.08105870f, -0.17912495f, 0.19528697f, 0.09521242f, 
    -0.02165506f, -0.18243894f, 0.01130565f, 0.10339616f, 0.21058953f, -0.00590457f, 0.11128643f, 0.17779236f, 
    0.10515086f, 0.17957249f, 0.20693186f, 0.17076927f, -0.15810326f, 0.15365539f, 0.07275286f, 0.02991766f, 
    -0.52041954f, 0.39103907f, -0.11794554f, -0.10981465f, 0.15718788f, 0.00245991f, 0.05772674f, 0.05869785f, 
    0.00321653f, -0.04194267f, -0.13304886f, -0.05088351f, -0.01967770f, 0.02310255f, -0.12658699f, 0.25692147f, 
    0.29299748f, 0.07299512f, -0.01774151f, -0.05437819f, -0.09111391f, 0.05434689f, -0.13621023f, -0.09028600f, 
    -0.08579584f, 0.03531900f, 0.00867103f, 0.03445271f, -0.06720968f, -0.01951207f, -0.02571815f, -0.03726243f, 
    0.12083869f, -0.06436415f, 0.00142261f, -0.08394166f, -0.49611595f, 0.15634258f, 0.07694822f, 0.03301854f, 
    0.15976359f, -0.02364340f, 0.03811654f, 0.02084366f, 0.01465003f, 0.00509215f, 0.15136619f, 0.12787090f, 
    0.15729408f, -0.16235140f, -0.12839007f, 0.00144090f, 0.07162958f, 0.10519327f, -0.06856237f, 0.07713342f, 
    0.09174950f, -0.03812771f, 0.02957437f, 0.09186187f, 0.01069975f, 0.01369755f, -0.00439208f, 0.08861765f, 
    -0.17013115f, -0.06581109f, -0.00043413f, 0.08981065f, 0.12826468f, 0.12398978f, -0.04822072f, -0.05709337f, 
    0.13073771f, -0.04411268f, 0.01436948f, -0.10519128f, -0.13777582f, -0.02592536f, 0.01805263f, 0.06620035f, 
    0.22401191f, -0.04394557f, 0.02679009f, 0.08174609f, -0.33989081f, 0.12310379f, 0.06601371f, -0.19921669f, 
    0.01765613f, 0.17505725f, 0.03052461f, -0.06118591f, 0.12105048f, -0.01214010f, -0.03555927f, 0.04599968f, 
    0.55651599f, -0.10822187f, 0.18892249f, 0.28783914f, -0.14280134f, -0.01402058f, 0.00850246f, 0.11263230f, 
    0.15142271f, -0.06776625f, 0.01715337f, 0.03606125f, -0.19374846f, 0.01096851f, -0.04461033f, 0.17755941f, 
    0.00921550f, -0.02340985f, -0.09383620f, 0.16249758f, -0.00040746f, 0.03112360f, 0.00941008f, 0.09952364f, 
    -0.33975762f, -0.09800518f, 0.21067604f, 0.25459215f, 0.08456126f, -0.05008079f, -0.06771535f, -0.13385552f, 
    0.10708189f, -0.02528404f, -0.02653142f, -0.02359940f, -0.00980255f, 0.36873919f, 0.21394575f, 0.24508701f, 
    -0.18948774f, -0.10348053f, -0.01800299f, -0.02239638f, 0.00409124f, 0.10643093f, 0.01904656f, -0.03540521f, 
    -0.09202471f, -0.23755363f, -0.13146049f, -0.12760851f, 0.22909425f, -0.10917745f, 0.17474090f, -0.02016894f, 
    0.12841433f, 0.02262101f, -0.08077779f, 0.02671500f, 0.59240544f, -0.12154304f, -0.13722256f, 0.10768607f, 
    0.07118317f, 0.01419234f, 0.07228143f, -0.02254704f, 0.08862479f, -0.00761904f, -0.09274375f, 0.02687347f, 
    -0.07432037f, 0.29751170f, 0.16898835f, 0.19024859f, 0.05493446f, -0.16739897f, 0.14692441f, 0.07104933f, 
    0.04797709f, 0.01785153f, 0.00675311f, 0.11323462f, 0.05251070f, 0.15542695f, -0.02135907f, 0.06405387f, 
    -0.07074856f, 0.17034252f, 0.16370669f, -0.15735996f, -0.11415690f, 0.08505843f, -0.03316507f, 0.00832788f, 
    -0.44999143f, 0.22646636f, -0.21899378f, -0.06985715f, 0.12075536f, 0.15554167f, 0.18261163f, 0.06694162f, 
    -0.04389444f, 0.01583256f, -0.06761894f, 0.02800488f, -0.03027755f, -0.14063981f, -0.40803832f, -0.14358220f, 
    0.11188087f, -0.13710847f, 0.03431261f, -0.04891605f, -0.00494285f, 0.00695219f, -0.00861302f, -0.03795904f, 
    -0.03874898f, -0.11098833f, -0.10166598f, -0.31689745f, 0.23129433f, 0.04179538f, -0.09396350f, 0.00082381f, 
    -0.14101952f, -0.17203574f, 0.07251532f, 0.10035481f, 0.21127084f, -0.14439982f, 0.01207822f, 0.09867265f, 
    0.12062040f, -0.04057607f, -0.10973316f, -0.06591615f, -0.13060360f, 0.25318027f, 0.31120780f, 0.35349706f, 
    -0.00110367f, 0.15813777f, 0.05967015f, -0.02147970f, 0.02997308f, 0.03606399f, 0.23118496f, 0.01798804f, 
    0.02093649f, -0.03380540f, 0.02452075f, 0.12262856f, -0.24906163f, 0.16740321f, -0.06160161f, -0.20335752f, 
    0.16138664f, 0.03644869f, -0.01366000f, -0.01284662f, -0.14891206f, 0.09567218f, -0.09361138f, 0.07358634f, 
    -0.27903280f, -0.09469250f, -0.06974313f, -0.12801802f, -0.00257079f, -0.10268763f, 0.11961640f, 0.01662502f, 
    0.17093144f, 0.07091141f, -0.04700184f, -0.00176754f, 0.27723941f, -0.10811544f, 0.18605031f, 0.01083899f, 
    -0.06901766f, 0.04353717f, 0.08514016f, 0.05179656f, 0.09217368f, 0.16830793f, -0.16941048f, 0.22347163f, 
    -0.02915899f, 0.33246785f, -0.22169003f, -0.28378925f, 0.20616896f, -0.13386083f, -0.13704967f, 0.00903308f, 
    -0.09205699f, -0.08892021f, 0.06116043f, -0.16850181f, -0.06958241f, 0.02445580f, 0.03249421f, -0.05283777f, 
    -0.05838313f, 0.12447618f, 0.07585297f, 0.01127528f, 0.09388066f, 0.03789021f, 0.04267887f, -0.04690006f, 
    0.33767763f, 0.16931383f, 0.11787284f, 0.17105186f, 0.03333132f, 0.03223972f, 0.23689845f, -0.08311498f, 
    0.18515156f, -0.14919199f, -0.02501042f, -0.06681065f, -0.15367708f, -0.10017779f, 0.07719816f, -0.17713919f, 
    0.02698479f, 0.04347592f, 0.11373205f, 0.00153599f, 0.14031473f, 0.00469836f, -0.08892711f, -0.15964508f, 
    -0.16057368f, 0.02734989f, 0.09828983f, 0.23924266f, -0.00439435f, 0.00893705f, 0.14427254f, 0.17824040f, 
    0.01093552f, 0.11679226f, 0.06658730f, 0.06689007f, 0.19824545f, -0.06576197f, 0.00986584f, -0.03083115f, 
    0.10438970f, 0.01044397f, 0.07630747f, 0.17585431f, 0.00506022f, 0.04536951f, 0.04335396f, 0.00950944f, 
    0.18726754f, 0.02281944f, -0.07196959f, -0.14400816f, 0.17219056f, -0.02141467f, -0.17248397f, -0.01810222f, 
    -0.06579105f, -0.01177753f, 0.11410964f, 0.12268890f, 0.02873310f, 0.22254552f, -0.10333159f, 0.15599416f, 
    -0.10621093f, -0.07682352f, -0.01993688f, -0.05240752f, -0.12032867f, 0.37565288f, -0.11546050f, 0.10561315f, 
    0.21537846f, 0.01923403f, -0.00463993f, 0.03426367f, 0.09851038f, 0.00942056f, -0.16098964f, 0.15916848f, 
    0.01306651f, -0.06110533f, -0.10628775f, -0.03543362f, 0.19774354f, 0.25215918f, 0.00630690f, 0.15517622f, 
    0.13496321f, -0.06646278f, -0.27377746f, -0.01706163f, -0.15883632f, 0.09207139f, -0.15588965f, 0.01681221f, 
    0.37161389f, 0.22784901f, 0.10755812f, -0.10793110f, 0.31797150f, 0.05753614f, -0.00339268f, -0.02039574f, 
    0.04399667f, -0.00951336f, -0.01109757f, 0.14681974f, -0.15952650f, -0.02336502f, -0.08606736f, -0.09612480f, 
    -0.04926428f, 0.01174452f, 0.05589669f, 0.12455581f, -0.04166449f, -0.01903517f, 0.07391054f, -0.01940768f, 
    0.18899684f, 0.37156343f, 0.09560912f, -0.02710318f, 0.08207682f, -0.18160684f, 0.00990958f, -0.05433915f, 
    -0.01030054f, 0.00537880f, 0.18053049f, 0.04807416f, -0.04818961f, 0.06849231f, 0.14872968f, -0.06531890f, 
    0.12534060f, 0.09370992f, 0.06238144f, -0.01690965f, -0.04197730f, -0.19574882f, 0.02238689f, 0.01773160f, 
    0.05879999f, 0.08250565f, 0.13299192f, 0.16594908f, 0.18746316f, 0.05369485f, 0.02840840f, -0.05310041f, 
    -0.14099547f, 0.18043293f, 0.19382319f, 0.04033588f, 0.05315752f, -0.66028690f, -0.06060418f, 0.05543274f, 
    0.16664699f, 0.09649521f, 0.05972179f, -0.02578796f, -0.00201744f, 0.03145594f, 0.07785085f, 0.05376121f, 
    -0.04569664f, 0.33580327f, -0.11860903f, -0.12815556f, 0.12536490f, 0.15645309f, 0.07196112f, -0.11210966f, 
    -0.04075177f, 0.01757647f, -0.09531969f, 0.15940058f, 0.30086344f, 0.12360483f, 0.28255799f, -0.27368674f, 
    0.13152845f, 0.03778628f, 0.06133424f, 0.09903917f, -0.01375803f, 0.05774551f, 0.11720692f, 0.10684667f, 
    -0.49271843f, -0.02082780f, -0.34100512f, -0.04221968f, 0.15290658f, 0.00897894f, -0.00989615f, 0.08555953f, 
    -0.17105517f, 0.01525910f, -0.01837984f, 0.05509188f, 0.48169255f, -0.18776768f, -0.06169441f, 0.00222426f, 
    0.02545632f, 0.15881991f, -0.05719671f, 0.05023541f, 0.05296141f, 0.06856870f, 0.08962473f, 0.08584293f, 
    -0.17456371f, -0.04582252f, -0.13998720f, 0.20699333f, -0.00307039f, 0.03673357f, -0.17627995f, 0.14530209f, 
    0.03512759f, -0.00790892f, -0.00867451f, -0.00649372f, -0.57662261f, -0.30305490f, 0.46887973f, -0.14912140f, 
    -0.09088449f, 0.06024814f, 0.05210347f, 0.00109773f, 0.12534668f, 0.15131466f, -0.10291039f, -0.07185113f, 
    -0.05459842f, -0.25877959f, -0.23189446f, 0.21421412f, -0.01757877f, 0.09125519f, 0.01751108f, 0.01473296f, 
    -0.06367721f, -0.04929893f, 0.19294518f, 0.09476262f, -0.04871183f, -0.08776285f, -0.04485894f, -0.04597806f, 
    0.06578779f, -0.07450803f, 0.08128294f, 0.19704953f, -0.01896428f, 0.10184567f, -0.05953634f, 0.10558975f, 
    -0.01787784f, 0.12279542f, 0.17068003f, 0.06306601f, 0.24508236f, -0.10755304f, -0.15480492f, -0.04411582f, 
    0.17573008f, -0.13715717f, -0.00106095f, 0.04430022f, -0.25268391f, -0.00227830f, 0.20594826f, 0.19984639f, 
    0.03904357f, 0.07291999f, -0.12141795f, 0.12805393f, 0.06611685f, -0.08080645f, 0.01438270f, 0.11861891f, 
    -0.03187245f, -0.36996064f, -0.04971869f, 0.07538745f, -0.22754760f, 0.03680333f, -0.11868139f, 0.01776221f, 
    -0.05274203f, 0.01240780f, 0.11667652f, 0.00790348f, -0.11728858f, 0.13721985f, -0.03652856f, 0.10054831f, 
    0.13153294f, -0.05173869f, 0.07241350f, -0.02541845f, 0.16370039f, 0.17999093f, 0.04360383f, 0.05793831f, 
    -0.00301942f, -0.10115986f, 0.06968847f, 0.05754022f, 0.15319040f, 0.09523058f, -0.01655787f, 0.17877404f, 
    -0.00662045f, 0.18492828f, 0.09650847f, -0.03499619f, 0.39258778f, -0.00990414f, -0.47393048f, 0.21075788f, 
    0.23654509f, 0.17190282f, 0.04555101f, 0.08164298f, 0.07586548f, 0.14963970f, 0.16788584f, -0.03549737f, 
    0.00869124f, -0.21425541f, -0.19448610f, 0.11571253f, 0.05427385f, -0.08059290f, -0.11388247f, -0.12852214f, 
    -0.00095707f, -0.19062799f, 0.11619941f, -0.11624741f, 0.42103466f, 0.30423781f, 0.35322517f, 0.20145591f, 
    -0.16464193f, 0.03695499f, -0.13451093f, 0.04864552f, 0.03731501f, -0.07725211f, -0.14760755f, 0.02761928f, 
    0.22293380f, -0.24284327f, -0.17907248f, 0.39266247f, 0.18851063f, 0.13767111f, -0.09726907f, -0.12868093f, 
    0.02452131f, 0.14011879f, -0.00018131f, -0.07448977f, 0.10765768f, -0.31767231f, -0.08326575f, 0.18881322f, 
    0.03716722f, 0.01191916f, 0.05616655f, -0.14656956f, 0.06096909f, 0.10555580f, -0.01339786f, -0.11116480f, 
    0.10880800f, 0.45550245f, 0.13406517f, -0.22678156f, 0.14646618f, -0.04903372f, 0.27422652f, -0.13403720f, 
    0.14935984f, 0.06378800f, -0.07653769f, 0.08116802f, 0.04455072f, 0.13437559f, -0.24671172f, -0.05244192f, 
    0.19391103f, -0.01355177f, -0.00417928f, -0.17133830f, 0.03154547f, 0.00532675f, 0.02523329f, -0.03418706f, 
    0.01391654f, 0.62209934f, 0.29167217f, -0.03726142f, -0.16493644f, 0.05594493f, -0.01405559f, -0.02710820f, 
    -0.03347459f, 0.15158401f, 0.02886262f, 0.00073287f, 0.33868626f, -0.00642857f, -0.08353066f, 0.00540683f, 
    -0.17917350f, -0.03501823f, -0.15725422f, 0.19231431f, -0.00268584f, -0.11114015f, 0.15236022f, 0.16892198f, 
    -0.17504318f, 0.15157406f, 0.24742949f, -0.05322513f, 0.18822230f, 0.05022406f, -0.14015822f, -0.11915335f, 
    -0.00169323f, -0.02509230f, 0.16520551f, 0.11578690f, -0.00436683f, 0.57966757f, -0.20970109f, -0.10100910f, 
    -0.11424959f, -0.01304249f, -0.16049801f, -0.19433692f, 0.16097042f, 0.16022685f, 0.13160695f, 0.12828475f, 
    0.04871158f, -0.21213317f, 0.21085180f, 0.14710090f, -0.09347468f, 0.04474683f, -0.06770400f, -0.01735124f, 
    0.03202209f, 0.01917991f, 0.02362572f, 0.02272487f, 0.09646114f, 0.19095086f, 0.31761661f, -0.00979256f, 
    -0.10919716f, 0.15188152f, 0.17815085f, -0.01882266f, -0.13379130f, -0.05788597f, 0.00972330f, -0.07709799f, 
    0.17551686f, -0.14337474f, -0.17728688f, -0.04964123f, -0.12435754f, 0.06399493f, 0.15686981f, 0.17253862f, 
    0.13025425f, 0.21859257f, 0.07434699f, 0.15187235f, -0.00290778f, 0.15812819f, -0.25810844f, 0.12084583f, 
    0.02181162f, 0.08597916f, 0.05073493f, 0.04226838f, 0.01900096f, 0.10160792f, -0.32692489f, -0.30695343f, 
    0.02371647f, -0.21832332f, -0.05559171f, 0.07228242f, 0.13944654f, -0.31739390f, -0.09715383f, -0.14899445f, 
    0.04410093f, -0.06886015f, -0.00446546f, 0.11313411f, 0.02358277f, -0.29358679f, 0.06999423f, 0.06488647f, 
    0.10459527f, 0.07479589f, -0.03297358f, -0.01342560f, 0.20825851f, -0.13499117f, -0.07300740f, 0.02061674f, 
    -0.04232619f, -0.15842040f, -0.35175312f, 0.20673129f, 0.04430513f, 0.12578154f, -0.06351276f, 0.00033685f, 
    -0.19979793f, -0.00094546f, 0.14430968f, -0.02396707f, 0.20957425f, 0.39906090f, 0.07302114f, 0.09799577f, 
    0.11623139f, 0.02335020f, -0.06571932f, 0.13323683f, -0.02707175f, -0.10644506f, 0.09194702f, -0.32283399f, 
    -0.02543880f, -0.29495910f, 0.03727242f, -0.04275630f, 0.12394504f, -0.03066784f, 0.10708877f, -0.12527065f, 
    -0.04146614f, 0.05178304f, -0.07052724f, 0.25774956f, 0.03782871f, -0.04858772f, -0.05728580f, -0.24266316f, 
    -0.00669108f, 0.16115528f, -0.07825276f, -0.06194011f, -0.02596165f, -0.07359675f, 0.05684625f, 0.19908179f, 
    -0.24419484f, -0.12117378f, -0.03303860f, 0.15192457f, 0.16547240f, 0.14600174f, -0.04978900f, 0.15678672f, 
    -0.10553954f, 0.02821152f, -0.03305076f, 0.20980535f, 0.01014282f, -0.19560218f, -0.16272853f, -0.21086259f, 
    -0.10251324f, 0.05736542f, 0.01560865f, -0.06327607f, -0.03673129f, -0.00936017f, 0.01413260f, 0.19248815f, 
    0.70031416f, 0.21369085f, 0.20030339f, 0.31161314f, -0.00992256f, 0.11476129f, 0.00040157f, 0.11467934f, 
    -0.08540244f, -0.12305858f, -0.00746274f, -0.28071091f, -0.17118245f, 0.30518845f, 0.22715569f, 0.18157476f, 
    0.00813332f, -0.11388892f, 0.02432962f, 0.01183843f, 0.03293249f, -0.01193873f, 0.11620072f, -0.07927016f, 
    -0.06024899f, 0.04644716f, -0.07784040f, -0.08808503f, 0.06702968f, 0.06077219f, 0.04979112f, -0.03973953f, 
    0.06379027f, -0.01315587f, -0.08564181f, 0.07249259f, 0.20899633f, 0.18056631f, 0.03331634f, -0.05585453f, 
    -0.01197305f, 0.06416090f, -0.16487828f, 0.01471178f, -0.02635166f, -0.10626695f, 0.10947561f, -0.13376401f, 
    0.03403352f, 0.50114268f, 0.07115711f, -0.13165009f, 0.16437611f, 0.06796765f, -0.10568368f, 0.10900553f, 
    -0.09509721f, 0.12195184f, 0.12267197f, 0.13064706f, 0.25843191f, 0.00406134f, 0.28416681f, 0.34780866f, 
    -0.02269281f, 0.16999954f, 0.17699528f, 0.15179200f, 0.08361565f, 0.05812337f, 0.18495242f, 0.16553272f, 
    0.17225994f, 0.01537841f, -0.33863983f, 0.17656521f, -0.05866982f, -0.08958779f, -0.01169259f, -0.13766548f, 
    0.17078835f, -0.02374842f, 0.06798951f, -0.04646665f, -0.73436069f, 0.07837122f, 0.08043897f, 0.07187250f, 
    0.06402965f, -0.02527980f, -0.06442560f, 0.01120149f, 0.06311532f, 0.03592723f, 0.15354298f, 0.07224952f, 
    0.50341713f, 0.03722416f, -0.11161484f, 0.06613681f, -0.01233506f, 0.12081962f, -0.05601726f, -0.06599377f, 
    -0.10056659f, -0.00939033f, -0.05470056f, 0.08930559f, 0.00623862f, 0.15249501f, -0.15667358f, 0.10925085f, 
    -0.20280579f, -0.14865835f, 0.08800842f, 0.06164722f, -0.01398437f, 0.01832736f, 0.02241545f, -0.04486867f, 
    0.21596472f, -0.02374745f, -0.02310915f, -0.17242286f, -0.19832006f, 0.17577317f, 0.14138721f, -0.15369627f, 
    0.25042385f, -0.15869886f, 0.17070481f, 0.03221109f, -0.09973370f, 0.16755065f, -0.02910113f, -0.31548998f, 
    0.16652754f, 0.19445176f, -0.03394315f, 0.05649235f, 0.19537379f, 0.06930909f, -0.24525075f, 0.11033795f, 
    0.47208402f, 0.04873877f, 0.15619074f, 0.05527786f, -0.05146291f, -0.04416604f, 0.04746356f, 0.12960242f, 
    -0.06324913f, -0.02128272f, -0.01643119f, -0.05086767f, -0.11004025f, 0.19889934f, -0.14932227f, 0.01838024f, 
    0.01948615f, 0.07703235f, 0.06877415f, 0.00317577f, -0.03700846f, -0.01951114f, -0.14467157f, 0.12585460f, 
    -0.17538136f, -0.10784396f, 0.16706362f, 0.39581513f, 0.02078011f, 0.04717657f, 0.01507577f, -0.11967814f, 
    -0.01225029f, -0.15142792f, -0.03194425f, -0.09641244f, 0.08931454f, 0.19418854f, 0.07613649f, 0.07749734f, 
    -0.28039363f, -0.01801902f, -0.01522490f, 0.06039215f, -0.07199770f, -0.04997681f, 0.12012391f, -0.06343236f, 
    0.00722483f, 0.04602042f, 0.05496841f, -0.32347533f, 0.11086470f, 0.09408678f, 0.29999894f, -0.05613466f, 
    -0.02474263f, 0.04979755f, -0.01500103f, 0.06978722f, 0.33611095f, -0.16858730f, -0.17732731f, -0.07390934f, 
    -0.11164951f, -0.00343878f, -0.03136605f, -0.09281645f, 0.11298875f, 0.11714837f, -0.00154169f, 0.09405760f, 
    -0.10131177f, 0.13006714f, 0.52628964f, 0.26060528f, -0.02926388f, -0.05349680f, 0.06552587f, 0.19696747f, 
    0.10515340f, 0.03336688f, 0.11994380f, 0.13642760f, 0.24813567f, 0.09345249f, 0.07718187f, 0.00921826f, 
    0.03833518f, 0.20035121f, 0.10519563f, 0.01787508f, -0.15926975f, 0.14064476f, 0.01423775f, 0.05330956f, 
    -0.55926573f, 0.30028358f, -0.16788451f, -0.09156504f, 0.13729054f, 0.04006090f, 0.11714727f, -0.03857496f, 
    0.11463510f, 0.06493124f, 0.14078197f, -0.05999330f, 0.24344949f, -0.20733121f, -0.32521626f, -0.00426171f, 
    0.19582951f, -0.06322939f, 0.12243491f, 0.02319475f, -0.10888870f, 0.05313013f, -0.00173260f, -0.03893600f, 
    -0.01525597f, 0.02038567f, -0.02565622f, -0.01964634f, -0.01615238f, 0.00326344f, -0.04561561f, 0.02998529f, 
    0.01207444f, -0.06218044f, -0.07139308f, -0.04504832f, -0.04010707f, -0.04032048f, -0.05479483f, 0.02776855f, 
    -0.02594564f, -0.07265940f, -0.01691179f, -0.04321847f, 0.01596594f, -0.06726968f, -0.01481069f, 0.02490669f, 
    -0.07467162f, 0.01405416f, -0.01249294f, 0.03552367f, 0.00796063f, -0.04808649f, -0.06002146f, -0.07306174f, 
    -0.06215352f, 0.00545694f, 0.06136894f, 0.06095763f, 0.05813841f, 0.05930959f, -0.05185973f, 0.01097501f, 
    0.06248976f, -0.02496533f, 0.01091817f, 0.00572336f, -0.06499063f, 0.04919011f, -0.07414258f, -0.05841441f, 
    0.00107143f, -0.04783431f, 0.03705125f, -0.04385868f, -0.00708590f, -0.01478126f, -0.01106151f, 0.05743640f, 
    0.03967757f, 0.02138710f, -0.02880423f, -0.07601361f, -0.02950899f, 0.00972029f, 0.04769826f, -0.06447446f, 
    0.00365493f, 0.00494428f, 0.06256122f, -0.05131376f, -0.07892629f, -0.06162306f, -0.03407428f, 0.03379297f, 
    0.00947948f, -0.05181456f, 0.00875095f, 0.00380027f, -0.00825658f, -0.07867377f, 0.02995299f, 0.04646638f, 
    0.06310327f, -0.06132501f, 0.00423889f, -0.03254992f, -0.02151802f, 0.00492713f, -0.05585716f, -0.06723230f, 
    0.01630498f, -0.06533066f, 0.00318576f, -0.00457564f, 0.04160129f, 0.06920969f, -0.06907815f, -0.01650862f, 
    -0.04085401f, 0.01876434f, 0.05418647f, 0.01075273f, 0.04411008f, -0.01009863f, 0.02045545f, -0.03560079f, 
    0.06115947f, 0.00673212f, 0.02166043f, -0.07258266f, -0.06272379f, -0.04810740f, -0.07297198f, 0.02554613f, 
    -0.03955770f, -0.00600862f, -0.03690222f, -0.02107391f, 0.02565174f, 0.00775402f, -0.00571457f, -0.05680162f, 
    -0.03651859f, 0.05943401f, 0.04672229f, 0.04270477f, -0.05060438f, 0.04458160f, -0.07524287f, 0.03300276f, 
    -0.02458220f, 0.05687789f, -0.00007442f, 0.00968867f, -0.02458179f, -0.01459904f, -0.05427863f, -0.05467645f, 
    0.01046904f, -0.06075829f, 0.05670013f, 0.02806950f, -0.04286962f, 0.02426289f, 0.01255620f, 0.06523648f, 
    -0.05933221f, -0.00112433f, 0.03476561f, 0.06000952f, -0.07578675f, 0.04982163f, -0.04484226f, -0.01237255f, 
    -0.00872567f, -0.07355822f, 0.05899362f, -0.00428613f, -0.01635150f, -0.04145866f, -0.06137398f, 0.03427648f, 
    0.02970970f, -0.05337683f, 0.02798082f, -0.03618695f, -0.05913538f, 0.04424625f, 0.02373494f, 0.04383299f, 
    -0.04968683f, 0.06035330f, 0.04143194f, -0.00124629f, 0.05226214f, -0.04037208f, -0.02228427f, 0.04837353f, 
    -0.06011131f, 0.03792158f, 0.02133970f, -0.07126728f, 0.01667613f, -0.01130783f, 0.06079695f, 0.03319734f, 
    -0.02473994f, -0.03134560f, 0.05568587f, 0.02991227f, -0.03846746f, -0.06852975f, -0.01488381f, 0.02519913f, 
    -0.03691925f, -0.03036298f, -0.07097895f, -0.06716341f, -0.04289829f, -0.06908734f, -0.06691767f, -0.01725153f, 
    0.01239606f, -0.00436077f, 0.01482563f, -0.03560038f, -0.07612329f, -0.07204219f, -0.03464710f, 0.00759655f, 
    -0.05338892f, 0.04501099f, -0.00848796f, -0.03863979f, -0.00017898f, -0.06092528f, -0.02676996f, -0.03430291f, 
    0.06048772f, -0.05437428f, -0.06872171f, 0.00559779f, -0.04614812f, -0.00159772f, -0.01201372f, 0.04222437f, 
    0.04235088f, -0.00735018f, -0.03680147f, -0.01066965f, 0.02464142f, 0.04456646f, 0.02358422f, -0.06438865f, 
    0.01422491f, 0.01412632f, -0.04923795f, 0.04940151f, 0.06510855f, 0.00669668f, -0.01955104f, 0.01556259f, 
    -0.07168849f, 0.02612118f, -0.06548996f, -0.01553915f, -0.06135653f, 0.05434215f, 0.00341689f, 0.03847495f, 
    -0.07530515f, 0.05363830f, 0.00961848f, 0.05793164f, -0.00480924f, -0.05771372f, -0.00642934f, 0.06372306f, 
    -0.03868109f, 0.03377998f, -0.04985448f, 0.05943217f, -0.02684954f, 0.05640057f, -0.03767782f, 0.03294991f, 
    -0.00213267f, -0.06506402f, -0.03884988f, -0.01313149f, -0.01608048f, 0.06007439f, -0.04408961f, 0.00705486f, 
    -0.01430142f, 0.01921764f, -0.06796411f, -0.00251557f, -0.03730858f, -0.04121587f, 0.02923532f, -0.04825348f, 
    -0.03053981f, -0.02965973f, -0.02806502f, 0.01049981f, -0.04303290f, -0.04238504f, -0.07264566f, 0.01377040f, 
    -0.05589386f, -0.00896653f, -0.03116720f, -0.06400407f, -0.00299952f, 0.03887717f, -0.03979520f, -0.04437033f, 
    -0.01270299f, -0.05051092f, 0.00451328f, 0.04803093f, -0.03582865f, -0.00719358f, -0.07641935f, 0.03229147f, 
    0.02663378f, 0.03620776f, -0.01884184f, -0.04226859f, 0.00112227f, 0.06022741f, 0.00342353f, -0.02558937f, 
    -0.06312786f, 0.06072401f, -0.01767342f, -0.06793895f, -0.07292560f, 0.00952957f, 0.04376484f, 0.03356126f, 
    0.04934328f, -0.03669777f, -0.05261522f, 0.06427388f, -0.03820438f, -0.06055921f, -0.00176969f, 0.05119689f, 
    0.05854451f, -0.03421035f, 0.00345066f, 0.01127715f, 0.01685980f, 0.04250659f, 0.01556327f, 0.04415118f, 
    -0.04843037f, 0.00800954f, 0.01708646f, 0.06638644f, -0.03596932f, 0.06648143f, -0.00111453f, -0.02486074f, 
    0.04441306f, 0.05754611f, 0.04225228f, -0.06331734f, -0.02750636f, 0.03993030f, -0.03925803f, -0.06667004f, 
    0.05224884f, -0.05528828f, -0.01961378f, -0.06050801f, 0.05288554f, -0.01224945f, -0.00537726f, 0.01046263f, 
    -0.04465104f, 0.04092683f, -0.06259944f, 0.02024151f, 0.04232891f, -0.02818142f, 0.02839919f, 0.01380234f, 
    0.01426980f, -0.03691043f, -0.02889990f, 0.00179019f, -0.03240332f, -0.04974127f, -0.04533742f, -0.02865851f, 
    0.02158050f, 0.01474621f, 0.01386515f, 0.03684555f, -0.02669228f, -0.05979972f, 0.04452657f, -0.00574935f, 
    0.18439469f, -0.13161440f, 0.00941467f, -0.27880979f, 0.13902010f, 0.06449626f, 0.13971351f, 0.24157865f, 
    0.03650288f, -0.06388805f, 0.03017315f, 0.03896761f, -0.10501456f, 0.05154642f, -0.26461709f, -0.04411332f, 
    0.05919522f, 0.05696137f, 0.11245947f, 0.19597700f, 0.04781213f, 0.01271223f, -0.14903091f, -0.12395633f, 
    -0.04664722f, 0.22752018f, -0.13995419f, -0.32538933f, 0.08152013f, -0.11077278f, 0.16205455f, -0.00779878f, 
    0.05694777f, -0.18234777f, 0.04293310f, 0.15915529f, -0.25629035f, -0.00605997f, 0.13517046f, -0.32350993f, 
    0.10746931f, 0.10087117f, 0.15636456f, -0.02262802f, 0.01141948f, -0.13030107f, -0.07170778f, -0.01843530f, 
    -0.26411355f, 0.01534044f, -0.15894318f, -0.38265505f, 0.10312174f, -0.01524679f, 0.12430585f, 0.00989124f, 
    0.00554843f, 0.03107737f, 0.04964961f, 0.10323506f, -0.19647969f, -0.19841942f, -0.21310334f, -0.07340916f, 
    0.00148459f, 0.03466525f, -0.01834937f, -0.09481993f, -0.04611850f, 0.16282819f, 0.07227580f, 0.03588860f, 
    0.03528764f, 0.12568589f, -0.25576121f, -0.22659248f, 0.09503851f, -0.00677741f, 0.14533648f, -0.09672561f, 
    -0.13280343f, -0.12964514f, -0.08659597f, 0.07600782f, 0.18368877f, 0.11677072f, 0.15566283f, -0.29250130f, 
    0.17681386f, 0.14814882f, 0.00510281f, 0.09639790f, 0.12746100f, 0.08363401f, -0.09917404f, 0.27481666f, 
    -0.65376455f, -0.04715898f, -0.08102488f, 0.07948159f, 0.34351712f, 0.04944773f, -0.00203429f, 0.12968910f, 
    -0.13525634f, -0.02654626f, -0.08210322f, 0.17408440f, 0.29138884f, -0.26843482f, 0.07177548f, 0.05474189f, 
    0.09997804f, 0.11418930f, 0.12175057f, 0.05982755f, 0.12678282f, -0.06274793f, 0.14736186f, 0.04244480f, 
    0.13685967f, -0.16983551f, -0.31233159f, -0.02525490f, 0.00854302f, -0.02356070f, -0.18599333f, 0.06100614f, 
    0.20300500f, 0.13732092f, 0.11379894f, -0.16325521f, -0.03960898f, -0.04868761f, 0.00689670f, 0.04618033f, 
    -0.05754887f, 0.16531563f, 0.05912202f, 0.03377594f, -0.05156215f, -0.05931744f, 0.10924920f, -0.03512865f, 
    -0.08096432f, -0.16200496f, 0.02342510f, 0.53995353f, -0.01942106f, 0.02500178f, 0.11892793f, 0.09436838f, 
    -0.04136314f, 0.08433723f, 0.11559647f, 0.22015095f, 0.16656250f, -0.01607029f, -0.09678192f, 0.08202506f, 
    0.03978788f, 0.08682520f, -0.06696323f, -0.11965284f, -0.11505953f, 0.15099336f, 0.00449116f, 0.01778188f, 
    -0.16991544f, 0.32406226f, 0.01629935f, -0.21700886f, 0.19828770f, 0.01156928f, -0.11162717f, 0.10437688f, 
    0.06821768f, 0.00314525f, 0.05474733f, 0.02083662f, 0.31463590f, -0.08644176f, -0.22236507f, 0.13482669f, 
    0.01203745f, -0.03084575f, -0.08192758f, 0.01860547f, 0.18188818f, 0.01728220f, 0.01897157f, 0.06959551f, 
    0.00007964f, 0.03579424f, 0.05027204f, -0.03137742f, 0.04184888f, 0.02026130f, 0.05543756f, -0.07639039f, 
    -0.06872013f, 0.04054046f, 0.04470920f, -0.06350848f, 0.04295991f, 0.00750603f, -0.06708258f, -0.01598456f, 
    -0.03286609f, -0.00923380f, -0.05083482f, -0.05342417f, -0.04650395f, 0.01141394f, 0.05885324f, 0.01541605f, 
    0.02263523f, -0.02097820f, -0.01346892f, -0.06105389f, -0.06241363f, 0.06887066f, -0.05586760f, -0.00108298f, 
    -0.07551236f, -0.02401074f, -0.04672604f, -0.05906371f, -0.00521659f, -0.06326817f, 0.04975381f, 0.02751940f, 
    -0.00169627f, 0.01300058f, 0.02243047f, 0.01707937f, -0.01012440f, -0.06764639f, 0.02866459f, -0.04810601f, 
    -0.00611407f, -0.05919293f, 0.03068478f, 0.04838210f, 0.03564410f, -0.04157152f, -0.04379727f, -0.05129356f, 
    0.04670379f, -0.05517459f, -0.00001965f, 0.05786215f, 0.03432291f, -0.07618857f, -0.03338945f, 0.02847256f, 
    -0.02168748f, -0.00950413f, -0.07495264f, -0.02670459f, 0.03074208f, -0.03221189f, 0.05712501f, 0.01432088f, 
    0.01881504f, 0.01969240f, -0.05807592f, -0.07292239f, -0.02517185f, -0.04119807f, -0.02629407f, 0.00025286f, 
    -0.07708582f, -0.07074296f, -0.06353915f, -0.03622355f, -0.02747817f, -0.04283205f, 0.02851028f, 0.01397808f, 
    -0.05379407f, -0.05005915f, 0.01247727f, -0.03907163f, 0.01400390f, 0.06285001f, -0.03857560f, -0.01639115f, 
    0.02523346f, 0.00664051f, -0.00658044f, -0.02347666f, 0.04186556f, 0.00639023f, -0.06688590f, 0.06227790f, 
    -0.06407755f, 0.04741525f, -0.01521648f, 0.01895484f, -0.02065064f, -0.06250267f, -0.01886529f, 0.01075132f, 
    -0.07887286f, -0.00119223f, 0.02185243f, -0.02850760f, -0.06233658f, -0.01967656f, -0.04854356f, 0.02527478f, 
    -0.05227416f, 0.05577054f, -0.01784928f, 0.02937729f, 0.04921963f, -0.05950126f, 0.04284102f, -0.04964988f, 
    -0.04430164f, -0.01432727f, 0.05026387f, -0.02486250f, -0.05873270f, -0.03187737f, -0.00393870f, 0.00187170f, 
    -0.01312551f, 0.03776570f, -0.05616623f, 0.01223306f, 0.04287126f, 0.04574224f, -0.00029624f, -0.04983351f, 
    -0.04768084f, -0.05539145f, 0.05144450f, -0.05674385f, -0.07055946f, 0.03687759f, -0.05563582f, 0.01408362f, 
    0.03093460f, -0.02110931f, 0.03603911f, 0.03763495f, -0.06426197f, -0.05014929f, -0.00083533f, 0.02753696f, 
    0.04537059f, 0.03100599f, 0.01466389f, -0.00802682f, 0.01947706f, 0.02025564f, 0.03382395f, -0.06051229f, 
    -0.05156677f, 0.05002637f, -0.07816225f, 0.04457971f, 0.02149772f, -0.07525201f, -0.03430392f, -0.05526902f, 
    -0.07310560f, -0.07139710f, -0.04786720f, 0.00143197f, 0.05374553f, 0.00975936f, -0.02145568f, 0.00131337f, 
    0.00553020f, -0.08376573f, -0.02390150f, -0.01040489f, -0.05517909f, -0.00668109f, 0.00427583f, -0.05454916f, 
    0.05652845f, 0.03175272f, -0.06956356f, -0.01067678f, 0.01308008f, 0.02926880f, -0.07630815f, -0.02275770f, 
    -0.07334948f, 0.01710877f, -0.07775750f, 0.03079100f, 0.04419445f, -0.05751269f, -0.01276330f, -0.03441935f, 
    -0.01623058f, 0.04938029f, -0.07785668f, 0.05064102f, -0.03456323f, -0.00126390f, -0.05717741f, -0.03089697f, 
    -0.04738079f, 0.03374566f, -0.02392754f, 0.01427886f, 0.02350000f, 0.00691456f, -0.01803979f, -0.03260173f, 
    -0.07065426f, -0.00878791f, -0.07105342f, -0.03363133f, -0.06414273f, 0.01251933f, -0.02385483f, 0.00749901f, 
    -0.00291201f, 0.04526309f, 0.01013422f, -0.05224807f, -0.02337446f, -0.03058103f, -0.05591050f, -0.05237099f, 
    0.01636061f, -0.00104127f, 0.02129551f, 0.00137344f, -0.03454334f, 0.05627351f, 0.03669877f, -0.05192025f, 
    -0.04172608f, 0.02196649f, -0.02448053f, 0.00190542f, -0.02454174f, 0.05132513f, -0.06377936f, -0.06879216f, 
    0.04885622f, 0.01347164f, 0.03653404f, -0.07077219f, -0.00479941f, -0.01655750f, 0.01418380f, 0.05597710f, 
    -0.02940698f, -0.00406712f, -0.08287569f, -0.05014917f, -0.07261888f, -0.07407144f, -0.03707657f, -0.03600629f, 
    -0.07662242f, 0.03309403f, -0.07611267f, -0.06973480f, 0.01428426f, 0.02877472f, 0.04910241f, -0.00305678f, 
    0.05094906f, -0.08082286f, -0.01536232f, -0.04160616f, 0.02347890f, 0.05344953f, -0.01198830f, -0.03216157f, 
    -0.04372412f, -0.07728682f, 0.05508117f, -0.05317037f, -0.00710849f, -0.06606887f, 0.05780193f, -0.01263828f, 
    0.04446751f, -0.05870915f, 0.05155716f, -0.00283754f, 0.02916081f, -0.02774368f, 0.06024036f, -0.04740169f, 
    -0.06515761f, -0.05817277f, 0.05889233f, 0.04055813f, 0.02301738f, -0.03705380f, 0.02077706f, 0.02874431f, 
    0.06099464f, -0.00563046f, -0.04223619f, 0.03518207f, -0.00267163f, -0.05291038f, 0.04562777f, 0.01065143f, 
    0.00394956f, 0.00166905f, 0.01957270f, 0.02427012f, 0.04385165f, -0.02076328f, -0.01047831f, -0.08204341f, 
    0.03144513f, 0.04867209f, 0.04536997f, -0.04286189f, -0.00552996f, -0.05107889f, -0.02531115f, 0.01581478f, 
    -0.01664957f, 0.06262463f, 0.03792456f, -0.04531347f, 0.00692101f, -0.00539806f, -0.05762742f, 0.03811596f, 
    -0.07621723f, -0.01174675f, 0.02064664f, 0.03300516f, -0.05658016f, -0.01403421f, -0.04723535f, 0.00975859f, 
    -0.00153818f, -0.00092726f, 0.06348416f, -0.06217818f, -0.05870300f, -0.07805694f, 0.05832369f, 0.02632253f, 
    0.04885388f, -0.00065090f, 0.05739605f, 0.01400943f, 0.04628287f, 0.02290858f, -0.00242261f, -0.07619238f, 
    0.04616652f, -0.03825375f, -0.07969198f, -0.03323204f, -0.06122128f, -0.02634904f, -0.03736816f, -0.02776326f, 
    -0.01410658f, -0.04560699f, -0.02933582f, -0.06852769f, 0.03620782f, 0.00329866f, -0.03643446f, -0.02461368f, 
    0.09044864f, 0.01445414f, -0.08761873f, 0.00048201f, -0.00412042f, -0.03958859f, -0.02835548f, -0.05408222f, 
    -0.06286604f, 0.05833245f, 0.02186253f, -0.01356086f, 0.01091978f, 0.07069149f, -0.10980326f, -0.08155322f, 
    -0.12360425f, -0.00368863f, -0.01834310f, 0.01140925f, -0.07629434f, -0.11389793f, -0.04243790f, 0.01093629f, 
    -0.07138872f, 0.06883574f, 0.08022706f, -0.04561621f, -0.08134157f, -0.03700751f, -0.02488785f, -0.06124906f, 
    0.02688860f, 0.02479060f, -0.06416875f, -0.06021024f, 0.10060402f, 0.07058890f, -0.05176063f, 0.09973411f, 
    -0.07143804f, -0.05464196f, 0.04220944f, -0.09532250f, -0.06151716f, 0.08124688f, -0.08668118f, -0.02759527f, 
    0.05654736f, 0.05534143f, 0.05381151f, 0.13113853f, -0.03295464f, -0.09787918f, -0.11369352f, 0.06055780f, 
    0.03665503f, 0.06189867f, 0.00031880f, -0.05606691f, -0.02231196f, -0.10391159f, -0.12295689f, -0.05754999f, 
    -0.04452692f, -0.06804337f, 0.02316672f, -0.08129801f, -0.01710855f, 0.06387485f, 0.06112798f, -0.01415773f, 
    0.09998508f, -0.08532400f, 0.09784134f, 0.00130250f, 0.03030550f, 0.00273079f, 0.00187168f, 0.01134299f, 
    -0.02303821f, 0.05772484f, -0.01315147f, -0.04801805f, 0.02728033f, 0.08242669f, 0.02597402f, -0.01162510f, 
    0.02285998f, -0.05382005f, 0.04597516f, 0.01392442f, 0.02980808f, -0.05199820f, 0.06012528f, -0.10720819f, 
    -0.02715889f, 0.03373742f, -0.09709758f, 0.00887946f, -0.03532474f, -0.09321474f, -0.00810292f, -0.05168862f, 
    -0.05553919f, -0.03218245f, -0.04574845f, 0.03786382f, -0.12268382f, -0.03010612f, -0.05511281f, -0.08065393f, 
    0.01842558f, -0.01725925f, -0.00598025f, -0.07862004f, 0.11525057f, -0.08998204f, 0.01490471f, -0.02101622f, 
    0.00266029f, -0.19588459f, -0.11815465f, -0.05166370f, 0.01239351f, -0.03177227f, -0.11576603f, -0.11371739f, 
    0.09964322f, -0.05621605f, -0.00578054f, -0.00530562f, -0.00719124f, -0.05406395f, -0.07364926f, -0.07029504f, 
    -0.06907208f, 0.07285948f, -0.05081902f, -0.08185910f, -0.01482690f, -0.02664536f, -0.07383563f, -0.09428286f, 
    -0.06072145f, 0.05495928f, -0.17712650f, -0.17687389f, 0.02903980f, 0.00243502f, 0.00568691f, -0.05279846f, 
    -0.04446551f, -0.07751475f, 0.03884821f, 0.00018393f, -0.13376939f, -0.06188124f, -0.10210845f, -0.10175559f, 
    -0.01990086f, -0.15024742f, -0.05370690f, 0.02731794f, 0.01419644f, 0.03129629f, -0.07209956f, 0.02821199f, 
    0.16321237f, -0.05983474f, -0.03866668f, -0.07464017f, 0.03038866f, -0.02743392f, 0.04722062f, -0.00426189f, 
    -0.03958120f, 0.02322359f, 0.01112173f, -0.04679992f, 0.00029162f, 0.00893548f, 0.04038837f, -0.09331172f, 
    -0.12476764f, 0.01663187f, -0.10126862f, -0.07037448f, 0.06384929f, 0.00421219f, -0.10287413f, -0.07998496f, 
    -0.07597019f, -0.00097041f, -0.05366702f, -0.00416167f, -0.02825833f, -0.01656839f, -0.08000198f, -0.00122381f, 
    0.02880900f, 0.01844196f, -0.06856037f, -0.06033359f, -0.08009544f, -0.04793126f, -0.01082612f, -0.07093695f, 
    0.01153523f, -0.07257287f, 0.04074524f, -0.06582899f, 0.02591185f, -0.00754963f, 0.06194410f, -0.03174770f, 
    0.04003721f, -0.01366474f, -0.08308442f, -0.04469778f, -0.02681283f, 0.04644949f, -0.03986613f, -0.02308033f, 
    0.03127684f, -0.02146652f, -0.04383073f, -0.02031979f, 0.05689260f, 0.01509398f, -0.08520443f, -0.02690889f, 
    -0.02231413f, 0.04064550f, 0.05142732f, -0.07656687f, 0.00012372f, 0.03023653f, 0.03540406f, 0.00349681f, 
    0.05033834f, 0.02752266f, -0.08410745f, 0.02594761f, -0.02301728f, -0.05042782f, -0.07026288f, -0.02884561f, 
    -0.03331692f, 0.04351141f, -0.00549816f, -0.05576930f, -0.00169275f, 0.01005132f, -0.05215629f, 0.00262314f, 
    -0.07957164f, -0.03863643f, 0.05171786f, 0.04549967f, 0.00895069f, -0.01337067f, 0.03819999f, 0.02464874f, 
    0.03844390f, 0.05944534f, -0.02848548f, -0.00058422f, -0.07991914f, -0.06354974f, -0.01196912f, -0.07894405f, 
    -0.06848301f, 0.01474946f, -0.03572880f, -0.03203854f, -0.07022788f, 0.01798830f, -0.03677952f, -0.04728476f, 
    0.02861555f, -0.05265521f, -0.03302368f, -0.08211745f, -0.00027541f, -0.02916466f, 0.01826335f, -0.05334030f, 
    -0.03013058f, -0.05216922f, 0.00125380f, -0.05999070f, -0.06385492f, -0.03370256f, -0.00066701f, -0.03068965f, 
    -0.02808282f, -0.06004896f, 0.02667909f, -0.01465139f, -0.03719617f, -0.00847989f, -0.03824547f, 0.04878888f, 
    -0.03508255f, 0.05800114f, 0.05841098f, 0.03215284f, -0.00003777f, -0.00729441f, 0.04395448f, -0.07139440f, 
    -0.00548221f, -0.00542098f, 0.05411899f, -0.02466941f, -0.01772020f, -0.04557908f, -0.06900738f, -0.07630853f, 
    0.02929986f, 0.03927770f, -0.07039143f, 0.06580588f, 0.03836108f, -0.05166005f, 0.04321572f, 0.02281218f, 
    -0.07859991f, -0.00064470f, 0.04061693f, 0.02317828f, 0.01722511f, 0.03725502f, -0.07353313f, 0.05257112f, 
    -0.06505240f, -0.01682114f, 0.03157903f, 0.03175139f, -0.06283835f, 0.05354359f, -0.00461305f, -0.00574633f, 
    -0.06815715f, -0.01618768f, -0.03984933f, -0.03667724f, -0.07386303f, -0.02050279f, -0.05695373f, 0.02777000f, 
    0.00974410f, 0.04029460f, 0.03800370f, -0.05416691f, 0.05550866f, -0.05223334f, -0.00556217f, 0.01378884f, 
    0.00317863f, 0.04469581f, 0.03600124f, -0.01641759f, 0.04946255f, 0.01305246f, -0.04708340f, 0.00195254f, 
    0.04770928f, 0.02499932f, 0.00213733f, -0.00314217f, -0.07484120f, 0.01486356f, -0.03710235f, 0.02367794f, 
    0.06041113f, 0.03542549f, 0.01440884f, 0.03187649f, -0.00059723f, 0.05216552f, -0.01132756f, 0.04867808f, 
    -0.40532023f, -0.31017125f, 0.32767326f, -0.07602096f, -0.13439994f, -0.09777430f, 0.08908532f, 0.12212572f, 
    0.08851761f, 0.14744149f, -0.06628915f, 0.02309148f, -0.05491679f, 0.13521540f, -0.23722990f, 0.07234374f, 
    0.08752187f, 0.01900694f, 0.14996752f, 0.16221848f, 0.13883509f, -0.06823174f, 0.04106421f, 0.14872758f, 
    -0.63883358f, -0.54750347f, -0.01302015f, -0.16589497f, 0.17589629f, 0.12050663f, 0.01360207f, 0.03718959f, 
    0.16674425f, 0.06290391f, -0.00292669f, -0.02490544f, -0.12613055f, -0.37176877f, 0.12192040f, -0.15171583f, 
    0.17693371f, 0.10017319f, -0.11467273f, -0.08974917f, 0.34136844f, -0.04350075f, -0.05636444f, -0.25436625f, 
    -0.13011762f, -0.03955244f, 0.15596752f, -0.33066928f, 0.00251254f, -0.10349672f, -0.13496663f, 0.18648580f, 
    0.03738776f, -0.17810121f, -0.14077058f, 0.26857981f, -0.33264402f, 0.38062987f, -0.05374645f, -0.01739141f, 
    -0.19360197f, -0.00046916f, 0.05856580f, 0.05375881f, -0.26613274f, 0.03219456f, 0.20737307f, -0.06018189f, 
    0.14830498f, -0.44695908f, -0.01905600f, 0.25008813f, 0.00837706f, 0.05682943f, 0.06581519f, -0.09310972f, 
    0.24464059f, 0.01351032f, 0.05131233f, 0.10632125f, -0.10693318f, -0.18992281f, 0.07802286f, 0.08836771f, 
    0.16719486f, 0.05882310f, -0.10074912f, 0.11096465f, 0.16318615f, 0.14869176f, 0.07308757f, 0.05051616f, 
    -0.24224798f, -0.11355666f, 0.07760145f, 0.04262878f, 0.08693794f, 0.10119969f, -0.03346600f, 0.25725445f, 
    -0.09718087f, 0.01476456f, -0.03187777f, 0.14217427f, 0.02534737f, 0.26330402f, 0.29534584f, 0.20396408f, 
    0.06860790f, -0.03698169f, 0.06450322f, 0.05184111f, 0.04277279f, 0.06315897f, -0.03528181f, 0.04412412f, 
    0.40501627f, -0.18903938f, -0.14945412f, -0.00260069f, 0.13690701f, -0.27938542f, -0.02815829f, 0.02709706f, 
    0.15834340f, 0.00341679f, -0.00055048f, -0.05846666f, 0.50003761f, 0.34779379f, -0.35920790f, 0.22396113f, 
    -0.03603710f, 0.10198103f, 0.23203592f, -0.03161923f, -0.04377531f, -0.06126703f, 0.01507178f, 0.12036719f, 
    -0.04037403f, 0.29069468f, 0.10952471f, 0.20409493f, -0.01284967f, 0.00108968f, 0.20350924f, -0.01123591f, 
    0.08413251f, 0.10919727f, -0.02689036f, 0.04376832f, -0.04190247f, 0.13231750f, -0.07798754f, -0.12718514f, 
    0.04076613f, 0.11645396f, 0.08981136f, -0.24446882f, 0.00789947f, 0.00714748f, 0.15877987f, -0.16975962f, 
    0.02179994f, -0.12679346f, -0.10526477f, 0.06283574f, 0.15548164f, 0.03163790f, 0.06500001f, 0.21143030f, 
    -0.00830555f, 0.04005898f, 0.00755575f, -0.01128819f, 0.24481200f, -0.00373135f, -0.34468916f, -0.32815391f, 
    -0.12535302f, -0.19473916f, 0.13386187f, -0.07588913f, -0.02156259f, 0.15407389f, 0.03088213f, -0.02987534f, 
    0.04351132f, -0.17359407f, 0.21323204f, -0.23296908f, 0.12682214f, 0.11720914f, -0.08722828f, -0.03697939f, 
    -0.03593211f, -0.02940578f, 0.06141128f, 0.06565060f, -0.01327035f, -0.06767824f, -0.00836781f, -0.10649607f, 
    0.18784316f, 0.02771838f, -0.08234273f, 0.02998471f, 0.07001900f, 0.05774614f, 0.00833492f, 0.12034876f, 
    -0.34769833f, 0.09107765f, 0.15229432f, -0.03461735f, 0.02168274f, -0.02803883f, 0.26805383f, 0.04516653f, 
    0.13966957f, 0.06362012f, 0.05692064f, 0.05113888f, -0.30904081f, -0.21316816f, -0.25708091f, -0.10671010f, 
    0.36821944f, 0.19463630f, 0.17498243f, -0.11237925f, 0.01260829f, -0.19266312f, -0.02936195f, 0.01454135f, 
    -0.45172569f, -0.18588997f, -0.07198976f, 0.18600856f, 0.28792062f, -0.23422980f, -0.12360722f, -0.01883446f, 
    -0.02296202f, -0.04716770f, 0.14408256f, -0.07260450f, -0.00504721f, 0.07695244f, 0.21266946f, 0.12603928f, 
    -0.16211429f, 0.07416721f, 0.16965958f, -0.02756923f, -0.07920797f, 0.03815201f, -0.01931260f, 0.19632521f, 
    -0.39475268f, 0.16810149f, -0.27377021f, 0.22606899f, 0.18524536f, 0.09630762f, -0.03843422f, -0.08543295f, 
    -0.01251758f, -0.01992786f, 0.02028099f, 0.09061126f, -0.02594788f, -0.24245362f, -0.01032213f, -0.15697847f, 
    0.33663094f, 0.06608877f, -0.13531667f, 0.15710567f, 0.06958165f, -0.02214360f, 0.05663518f, 0.14857112f, 
    -0.27565703f, 0.31067348f, 0.05807513f, -0.07257177f, 0.02910279f, -0.09432308f, 0.02399253f, -0.04953210f, 
    0.27172384f, 0.03523151f, -0.06555800f, 0.11570355f, -0.11243587f, -0.39527446f, 0.26628429f, 0.15509297f, 
    0.12781382f, 0.04884521f, -0.03917873f, -0.05199185f, 0.04709021f, 0.12657171f, 0.13432018f, -0.02047752f, 
    -0.31720757f, 0.24294031f, 0.02467437f, 0.42469266f, -0.24553019f, -0.07256837f, 0.08889259f, 0.06617867f, 
    0.03563755f, 0.00584377f, 0.05247775f, -0.05798124f, 0.06036745f, 0.07929837f, -0.05790436f, -0.04898615f, 
    -0.00721716f, 0.09169243f, 0.13277483f, 0.17711069f, -0.01632357f, -0.05982528f, 0.05983834f, 0.03835907f, 
    0.28916028f, 0.09857218f, 0.05402320f, 0.10105219f, 0.20139959f, -0.04296025f, 0.07436017f, 0.00447421f, 
    0.04869176f, 0.01311874f, 0.03863050f, 0.22508265f, -0.00371894f, 0.26597157f, 0.04994329f, 0.09380833f, 
    -0.05645445f, 0.05204611f, -0.11455216f, -0.06763761f, -0.05897091f, 0.23972028f, 0.04263527f, 0.04016425f, 
    -0.06754506f, 0.20118095f, 0.06026252f, 0.04891325f, 0.12069399f, -0.06119534f, 0.02657202f, 0.19710274f, 
    -0.01405733f, -0.00836341f, -0.07992840f, -0.05553783f, 0.19566008f, 0.25462410f, 0.07147305f, 0.10257512f, 
    0.10101554f, 0.16878465f, -0.09555528f, -0.03451568f, -0.09229302f, -0.03227589f, -0.06035308f, 0.08950555f, 
    -0.07233177f, -0.10191655f, 0.31729418f, -0.19129641f, 0.05239589f, 0.13202760f, -0.01166447f, -0.03026456f, 
    -0.15377180f, -0.21526712f, 0.14302117f, 0.00723958f, -0.08928194f, 0.01397016f, 0.04752916f, -0.14989534f, 
    0.16856198f, -0.08029046f, -0.06443096f, 0.03572372f, 0.09923423f, 0.08167268f, 0.34017786f, 0.25094643f, 
    -0.03202341f, 0.44682622f, -0.08697072f, -0.17688841f, 0.04636265f, 0.03331489f, 0.13233845f, 0.08191421f, 
    -0.03554659f, 0.03109091f, 0.11782492f, -0.04132778f, 0.04437118f, 0.34803188f, -0.10952117f, -0.20931466f, 
    0.04657475f, -0.05091735f, 0.07817460f, 0.02938091f, -0.15360957f, 0.08703457f, 0.08669467f, 0.02661770f, 
    -0.00203451f, 0.03559711f, 0.12465172f, -0.60610288f, 0.02763329f, -0.01526224f, 0.12482895f, 0.17407624f, 
    0.14304431f, 0.12822470f, -0.11897563f, 0.14195226f, -0.03270735f, -0.34050149f, -0.05881735f, 0.04172073f, 
    -0.02716009f, 0.09696831f, 0.00788923f, -0.09850660f, 0.01528449f, 0.06817555f, -0.16190176f, 0.16795047f, 
    0.10727592f, 0.40943399f, -0.17187393f, -0.04217156f, 0.20110327f, -0.10185374f, -0.02714950f, 0.05800415f, 
    -0.00944058f, 0.01347676f, -0.01151497f, -0.07494627f, 0.27563298f, -0.02613484f, 0.15031913f, 0.00402532f, 
    0.00384827f, 0.05345494f, 0.05574229f, 0.02674227f, 0.09067994f, 0.14078370f, 0.00845617f, -0.03419172f, 
    -0.00205370f, 0.43336987f, 0.07124875f, -0.05428750f, 0.15894458f, -0.10560504f, 0.24368252f, -0.10048475f, 
    -0.01491398f, -0.12253331f, -0.01976041f, -0.23246488f, 0.44508106f, 0.13585009f, 0.13324493f, 0.18814841f, 
    -0.08764531f, -0.10155462f, 0.11805350f, 0.07261862f, 0.06965891f, 0.04113057f, -0.13652588f, -0.07764229f, 
    -0.24534541f, -0.03003046f, -0.19343300f, 0.02658884f, -0.05382421f, -0.08539565f, 0.18325408f, -0.06261454f, 
    -0.02810301f, 0.19457024f, 0.02688941f, 0.22489806f, 0.40453371f, -0.35032848f, -0.09663368f, -0.05094099f, 
    -0.19401361f, 0.14712302f, 0.02622462f, -0.02249398f, -0.04166725f, 0.07598042f, -0.12087347f, 0.02707767f, 
    0.02918328f, -0.25291514f, 0.29941729f, 0.50504822f, -0.01901299f, -0.11909567f, -0.12311783f, 0.02484011f, 
    0.03714563f, 0.01899539f, 0.07289083f, 0.15394177f, 0.24394217f, 0.47138873f, -0.15564793f, 0.15617503f, 
    -0.06488108f, -0.13414554f, 0.11813118f, -0.20755780f, 0.05359915f, 0.40006968f, -0.10051654f, 0.03382082f, 
    -0.24386290f, -0.29673317f, 0.08115195f, -0.05521976f, 0.06437329f, 0.08183041f, 0.01331010f, 0.04464261f, 
    0.12376273f, -0.06568780f, -0.12830120f, -0.06797154f, 0.27084181f, 0.20553753f, -0.15415351f, -0.07150748f, 
    0.01957224f, -0.12451085f, -0.26928997f, -0.14671458f, -0.05509215f, -0.11466618f, -0.23284438f, -0.18651916f, 
    -0.06209842f, 0.02408906f, -0.00478299f, -0.04144628f, 0.02811716f, 0.00726414f, 0.04508489f, -0.04939664f, 
    -0.04842492f, 0.01570595f, -0.07772617f, 0.00597134f, -0.05801747f, 0.03829412f, 0.04037565f, -0.03581826f, 
    -0.06001510f, -0.02331266f, 0.05505210f, 0.02548946f, 0.05376305f, 0.04428194f, 0.04181582f, -0.04504945f, 
    0.01040249f, 0.06200122f, -0.07249738f, -0.01985572f, -0.01224000f, -0.04673357f, -0.05159086f, 0.04480257f, 
    0.05996701f, -0.03857081f, 0.03771984f, 0.03060728f, 0.00794651f, -0.04475317f, -0.07256415f, 0.04622006f, 
    0.00161801f, 0.01581523f, 0.01731924f, 0.01878883f, -0.08007649f, 0.03458765f, -0.03040585f, 0.04818131f, 
    -0.04722598f, 0.01318089f, -0.03545034f, -0.02020978f, -0.01813593f, 0.01807345f, -0.03988406f, -0.03581237f, 
    -0.05887419f, -0.00715454f, 0.04198695f, 0.03623290f, 0.04404342f, 0.00784728f, 0.03407331f, 0.03919140f, 
    -0.02996003f, 0.02937525f, -0.02918107f, 0.03798281f, 0.02737443f, 0.05817301f, 0.02920092f, 0.01113175f, 
    -0.01543676f, -0.04475695f, 0.03747270f, -0.02814816f, 0.05582288f, -0.03646402f, 0.01370954f, -0.00365020f, 
    -0.07568298f, -0.02491132f, 0.01727123f, -0.03381549f, -0.03541582f, -0.03471562f, -0.06549851f, 0.01045084f, 
    -0.05603894f, 0.05554134f, -0.02209606f, -0.04968393f, -0.01629417f, -0.01436800f, 0.05073480f, 0.05678222f, 
    0.00012810f, -0.04587054f, -0.03663723f, 0.06404450f, 0.02020962f, -0.04706569f, -0.05243400f, -0.02645696f, 
    0.02902748f, 0.04142532f, -0.04846257f, 0.01323339f, -0.07524063f, -0.07501090f, -0.01324567f, -0.06818570f, 
    -0.07695477f, -0.05212411f, 0.00802766f, -0.03753385f, -0.05987129f, 0.04327626f, 0.02054590f, 0.02669564f, 
    -0.01213057f, -0.07235233f, -0.03700583f, -0.03763679f, -0.07681257f, -0.05457136f, -0.01000408f, 0.02672648f, 
    -0.05228155f, 0.00913159f, -0.06716239f, -0.00629738f, 0.05898989f, -0.05008994f, -0.04514594f, -0.05725237f, 
    0.05174097f, 0.04160015f, -0.05935802f, -0.01798629f, 0.02609158f, -0.06335078f, 0.00237349f, 0.01242807f, 
    -0.06303223f, 0.03138245f, -0.06761639f, -0.06888139f, 0.05499567f, -0.07253760f, 0.05198054f, 0.02223695f, 
    -0.00273370f, -0.03778556f, -0.04770164f, -0.02174293f, -0.04368553f, -0.00752242f, 0.04078063f, -0.05357132f, 
    -0.03361528f, 0.05580028f, -0.03276013f, 0.04062741f, -0.06923580f, -0.00561629f, -0.06143767f, -0.05704639f, 
    -0.01831247f, 0.00189604f, 0.01384617f, -0.01658187f, -0.05955688f, -0.08074287f, -0.08317872f, 0.05776947f, 
    -0.00963065f, -0.07875144f, 0.04415162f, -0.01542629f, 0.01254979f, -0.07499129f, 0.01878103f, -0.00043158f, 
    -0.02304457f, 0.00529243f, -0.05147841f, 0.03262886f, -0.01096475f, -0.03193764f, -0.06879826f, -0.05442697f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02141608f, -0.12193917f, 0.03811913f, 0.00619676f, 0.03263383f, 0.01621744f, 0.08828300f, 0.02516924f, 
    0.09678857f, 0.08993377f, -0.03380893f, 0.00875548f, -0.00345527f, 0.05449883f, -0.03375425f, 0.08973777f, 
    -0.02203725f, 0.10866824f, -0.06768064f, 0.06714137f, -0.05501793f, 0.01870964f, -0.05643751f, 0.20686069f, 
    -0.02110251f, -0.01214095f, -0.09507950f, -0.07817814f, 0.31463128f, 0.17183818f, 0.00156466f, -0.03497394f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08767557f, 0.16751343f, -0.01106174f, -0.06773823f, 0.08840415f, -0.17267790f, -0.13075896f, -0.15233059f, 
    -0.01243309f, 0.13009711f, -0.08736599f, -0.20672068f, 0.14574695f, 0.10070334f, -0.15752892f, 0.03634550f, 
    0.06573253f, -0.21185721f, 0.08997297f, -0.03806184f, 0.03727502f, -0.15082258f, 0.15969647f, 0.06904856f, 
    0.08949919f, -0.12002634f, 0.08789152f, -0.15078361f, 0.05658644f, -0.16002274f, 0.05115851f, -0.08658259f, 
    -0.04936074f, 0.27819273f, -0.01144597f, 0.13076816f, -0.00868276f, -0.15780219f, -0.22588836f, 0.08301770f, 
    -0.29233870f, 0.55101168f, 0.39251035f, -0.09694555f, 0.31821215f, 0.33365214f, 0.69894141f, 0.33805376f, 
    0.33134380f, 0.10172861f, 0.08202355f, 0.29967412f, 0.54707992f, 0.01281451f, 0.07943278f, 0.35453576f, 
    -0.02590342f, 0.16647214f, -0.05952681f, -0.02585443f, -0.13302338f, 0.11092226f, 0.23219998f, 0.01098052f, 
    -0.30819175f, 0.18603379f, -0.08203655f, -0.04921447f, -0.35134634f, 0.34799659f, -0.00050142f, -0.08919327f, 
    0.22683139f, 0.28483978f, 0.20507507f, 0.31339091f, -0.00686471f, 0.68759799f, 0.46161899f, 0.32669413f, 
    -0.07160150f, -0.07367441f, 0.05776780f, -0.29724023f, 0.22917639f, -0.05427464f, -0.17317626f, 0.00984429f, 
    -0.03451918f, -0.04258272f, -0.02958531f, -0.16930956f, 0.41788521f, 0.31904018f, 0.18901867f, 0.07029591f, 
    -0.10432449f, 0.34327695f, -0.10842741f, -0.00894201f, 0.19106737f, 0.31147337f, 0.18836376f, 0.13793360f, 
    -0.22541419f, -0.31655028f, 0.21209303f, -0.58083034f, -0.13812591f, -0.25573826f, 0.17937663f, 0.47134891f, 
    0.13970494f, -0.16611883f, 0.38123059f, 0.02157620f, 0.29623383f, 0.17048250f, 0.09227989f, -0.17166287f, 
    0.05040849f, -0.01838626f, 0.11891737f, -0.04321329f, -0.08496467f, 0.02067999f, -0.15660396f, 0.00974217f, 
    0.14569797f, -0.47489777f, 0.05306844f, 0.08065118f, 0.27988401f, 0.11314288f, 0.17502448f, -0.67543972f, 
    0.07383118f, -0.20613004f, -0.10127858f, 0.32697079f, 0.23267005f, -0.18222378f, -0.34287804f, 0.13936968f, 
    -0.16464086f, 0.22524382f, 0.07560980f, 0.09370760f, -0.15602322f, -0.10265356f, -0.00667684f, 0.40672511f, 
    -0.09965335f, -0.06818976f, -0.04524848f, 0.17044452f, 0.30839610f, -0.25047770f, 0.38938934f, -0.06802712f, 
    0.25735560f, -0.17410880f, -0.01318030f, 0.10580043f, -0.17487356f, -0.08937198f, 0.13039245f, 0.68837458f, 
    -0.06450224f, 0.16948350f, -0.07465312f, -0.19686772f, -0.24996221f, 0.26219574f, -0.02048881f, -0.09207545f, 
    0.33557785f, 0.28709421f, -0.17968215f, -0.07822307f, -0.20015448f, 0.16803187f, -0.09911984f, 0.09282000f, 
    0.14957367f, 0.08618823f, 0.12394157f, 0.05515883f, -0.08014167f, 0.35414645f, -0.37900099f, -0.15685366f, 
    0.08064007f, 0.02570073f, -0.05894705f, -0.03744056f, -0.10472766f, -0.04624412f, 0.07274926f, -0.15187308f, 
    -0.21163803f, 0.10670522f, -0.14008226f, 0.12022540f, -0.13047510f, -0.01045969f, -0.00040233f, -0.17923766f, 
    -0.16873579f, -0.17084582f, -0.21439360f, -0.19500810f, 0.10563198f, 0.04007977f, 0.14910620f, 0.01384169f, 
    -0.03294618f, 0.00888996f, -0.07837136f, 0.09948277f, -0.12024914f, -0.14287212f, -0.19423211f, 0.00553637f, 
    0.26998359f, -0.36816987f, 0.12462311f, 0.09445173f, -0.17159390f, -0.09903871f, 0.23870273f, 0.42237341f, 
    -0.42555600f, -0.12269481f, 0.17044044f, 0.34187344f, -0.27357683f, -0.06328439f, 0.27361456f, -0.16412386f, 
    0.48862964f, 0.29894927f, 0.20649466f, -0.23521452f, -0.03882039f, 0.00968513f, 0.09407742f, -0.03606924f, 
    -0.08715785f, -0.15582412f, 0.01259055f, -0.03240583f, -0.47951615f, 0.00707742f, 0.19753779f, 0.00815852f, 
    0.12011021f, 0.05937817f, -0.06884570f, 0.04943084f, 0.00058053f, 0.04210940f, 0.10385345f, -0.13681500f, 
    0.29139793f, -0.08637294f, -0.13468578f, 0.26242134f, -0.05469407f, -0.07019127f, -0.15905991f, 0.08797928f, 
    -0.15570757f, 0.01347458f, 0.10718918f, -0.13133682f, -0.04011473f, -0.07464653f, -0.03895041f, -0.47090811f, 
    0.11029703f, 0.04240392f, -0.16627711f, -0.00226552f, -0.12083746f, -0.05116423f, 0.11606905f, 0.13986459f, 
    0.17036374f, -0.19708887f, -0.08670067f, -0.14418511f, 0.16082500f, 0.04806459f, 0.09570778f, -0.41839489f, 
    0.36936089f, -0.06068231f, -0.19405968f, -0.13008487f, 1.02244186f, -0.32397896f, -0.20930272f, -0.39895734f, 
    -0.06596035f, 0.47610167f, 0.41844264f, 0.27969453f, 0.27555177f, -0.10025450f, 0.03805987f, 0.00835080f, 
    0.12217856f, -0.16241936f, -0.13660283f, -0.12408336f, -0.56616622f, 0.05358549f, 0.07855695f, 0.05430517f, 
    0.38523853f, -0.11711098f, -0.03276619f, 0.14561541f, 0.34549111f, -0.35493562f, 0.18689200f, 0.02008768f, 
    0.27113739f, -0.25296715f, -0.22695573f, 0.12428156f, -0.59953189f, 0.07211115f, -0.32702464f, -0.03287969f, 
    0.20249157f, 0.13183953f, 0.01629456f, -0.19315711f, -0.47331539f, -0.10156790f, 0.14233516f, -0.05656122f, 
    -0.00042659f, -0.06814469f, 0.14815162f, 0.04938050f, 0.31746325f, 0.04636193f, 0.52635533f, 0.03725123f, 
    0.13833569f, 0.25366679f, -0.11100704f, 0.14765885f, -0.01544912f, 0.06263770f, -0.00467830f, 0.34628406f, 
    -0.19223040f, -0.40896636f, 0.55810642f, 0.08621813f, -0.69188225f, 0.37652209f, -0.04489964f, 0.35699233f, 
    0.63068467f, 0.03426675f, -0.18710005f, -0.25527564f, 0.31180090f, -0.09069833f, -0.12386575f, 0.37862682f, 
    0.11835087f, -0.13851261f, 0.00082509f, 0.13508256f, 0.21769249f, -0.04796479f, 0.43060452f, 0.04533688f, 
    -0.07492508f, 0.04113212f, -0.14169319f, -0.15538827f, 0.04820223f, -0.12401716f, -0.13850091f, -0.04429597f, 
    -0.09165294f, 0.08402532f, 0.09161292f, -0.13715973f, 0.06297756f, 0.04287605f, -0.04873759f, 0.16297433f, 
    -0.14874829f, 0.12291095f, -0.14048249f, -0.06246573f, 0.13423938f, 0.01622407f, 0.05548156f, 0.10403567f, 
    -0.14734741f, 0.15317680f, -0.10742336f, -0.04503521f, -0.04187005f, -0.17673293f, -0.13117065f, -0.16729237f, 
    0.32144812f, -0.51313978f, 0.00539178f, 0.17005515f, 0.01868949f, -0.32281849f, 0.08498066f, -0.12903273f, 
    0.26506740f, 0.18749923f, -0.32706413f, 0.32406354f, 0.10802402f, -0.12467519f, -0.43314239f, -0.49132478f, 
    0.01863238f, 0.30485007f, 0.25856808f, 0.18419500f, -0.23637591f, -0.04821630f, -0.06955773f, 0.21320793f, 
    0.13162610f, 0.16158395f, 0.19775872f, -0.14042918f, 0.16207252f, 0.01736559f, 0.01356908f, 0.05165585f, 
    -0.07562435f, 0.06584796f, 0.14479874f, -0.00461730f, -0.23638548f, -0.44358873f, -0.03842805f, 0.36363563f, 
    0.17624922f, 0.47143933f, 0.25647011f, 0.50441462f, -0.22139482f, -0.13166545f, -0.42202723f, -0.43084311f, 
    0.47420496f, -0.19667424f, 0.25147355f, 0.33861986f, -0.31822202f, -0.03997095f, 0.00133229f, 0.25850549f, 
    0.01354774f, -0.03277259f, 0.05659397f, -0.01836295f, 0.43185979f, 0.33790684f, -0.08729795f, 0.11662888f, 
    -0.23125726f, 0.04859880f, 0.08523675f, 0.09997036f, -0.04243613f, 0.29560623f, -0.00673753f, -0.01079634f, 
    0.43189448f, 0.05625515f, 0.28778481f, 0.02887419f, 0.05180215f, 0.07156687f, -0.19711882f, 0.24966373f, 
    -0.21960664f, -0.28610718f, 0.31923020f, 0.11862101f, 0.42200145f, 0.02760310f, -0.02978574f, 0.01767867f, 
    -0.04408980f, -0.08814888f, -0.14723267f, -0.00077154f, 0.33264124f, -0.11824288f, 0.05316387f, -0.07059143f, 
    -0.14845575f, -0.00110251f, 0.01038249f, -0.15237843f, -0.18497147f, -0.12799996f, -0.08105268f, -0.08556464f, 
    0.12412543f, 0.13872570f, -0.04100392f, 0.01346235f, 0.10170031f, -0.02417074f, -0.09045136f, 0.03190702f, 
    -0.09452440f, -0.16355839f, -0.03689209f, -0.04594181f, 0.05068886f, 0.08782608f, 0.11101239f, -0.04255056f, 
    0.06664471f, -0.02795414f, 0.15519293f, -0.07421976f, 0.06218019f, 0.00869120f, -0.16646552f, 0.02800332f, 
    0.25542668f, 0.03037785f, -0.04674556f, 0.05785815f, 0.10676090f, 0.12866931f, 0.30462638f, -0.19595684f, 
    0.05147111f, -0.29471460f, 0.26248026f, 0.41073218f, -0.25740162f, -0.24745286f, 0.12580980f, 0.16508469f, 
    -0.22801909f, -0.16086473f, 0.20663098f, -0.16833183f, 0.26317072f, 0.06051983f, 0.14227144f, -0.65136015f, 
    0.07986768f, 0.00878661f, 0.01738529f, -0.17088367f, -0.18419324f, -0.57116038f, 0.02700897f, 0.16018517f, 
    0.23127858f, 0.19865088f, -0.11955017f, -0.00319202f, 0.35285988f, -0.42514083f, -0.19143516f, 0.15908730f, 
    0.24591294f, -0.20378008f, 0.18204239f, -0.17835015f, -0.35741305f, -0.08940379f, 0.04195322f, 0.07692976f, 
    0.42016432f, -0.00025039f, 0.22337432f, -0.21427199f, 0.17375384f, 0.07880390f, -0.11762798f, -0.17029086f, 
    -0.04808492f, 0.07372335f, -0.03810317f, 0.12332182f, 0.12321980f, 0.12800522f, 0.41792807f, -0.05404580f, 
    0.04423277f, 0.08981470f, 0.01849766f, -0.07813045f, -0.00764237f, 0.10283738f, 0.02098452f, 0.47347075f, 
    -0.37892327f, 0.28599077f, 0.11210541f, 0.02493813f, -0.64741081f, 0.39863694f, 0.40669379f, -0.01936143f, 
    0.23831688f, -0.00123042f, 0.11654665f, -0.14316395f, -0.04074432f, 0.04489139f, 0.10653620f, -0.30993634f, 
    -0.06450060f, 0.06678458f, 0.13312851f, 0.17260666f, 0.00021238f, 0.40179130f, 0.30125427f, 0.07763626f, 
    0.16007727f, -0.37259933f, 0.03398492f, -0.00717819f, -0.50800902f, 0.19311677f, 0.02811882f, -0.21815431f, 
    0.15883337f, -0.03022483f, -0.24768542f, 0.23010579f, 0.34049806f, 0.56922638f, 0.04867817f, 0.15205002f, 
    -0.18713191f, 0.13093223f, -0.04074444f, -0.46376073f, 0.08940360f, -0.12997735f, 0.08842617f, 0.25423947f, 
    0.16272287f, -0.03734502f, -0.16126230f, -0.04704500f, 0.28139940f, 0.17993669f, 0.31295618f, 0.10714253f, 
    0.15661341f, -0.18753858f, 0.16189507f, -0.14154778f, -0.28212917f, 0.37644306f, 0.23645110f, 0.54463524f, 
    0.11345349f, 0.43861023f, 0.24453598f, 0.17789923f, 0.43719578f, 0.14795138f, 0.19004059f, -0.21619432f, 
    -0.10896205f, 0.15796451f, -0.49830896f, 0.17343330f, 0.00378630f, 0.01076304f, -0.05534395f, 0.23190908f, 
    -0.07806023f, -0.03562086f, 0.01660146f, -0.06716724f, -0.10032064f, -0.30682397f, -0.38295391f, -0.12002826f, 
    -0.16832675f, -0.13131531f, -0.07804856f, 0.11931284f, 0.07299583f, 0.03555209f, -0.16722305f, -0.15113184f, 
    -0.14883786f, -0.02886356f, -0.00240166f, -0.13448413f, 0.00223501f, 0.06835909f, -0.08974780f, -0.09120268f, 
    -0.15079165f, -0.08094206f, -0.08798689f, 0.16398968f, -0.17141332f, -0.03312194f, -0.08223604f, 0.02691137f, 
    0.00482750f, -0.01642485f, -0.03200642f, -0.02023492f, 0.05876227f, 0.14596653f, 0.16496089f, 0.10166167f, 
    0.20479713f, 0.21945339f, 0.11582606f, -0.13696449f, 0.25622582f, -0.00134891f, -0.10723694f, 0.52296877f, 
    0.40989366f, -0.34005544f, 0.39910516f, 0.13084982f, -0.26304296f, -0.02672364f, -0.33176407f, 0.01184354f, 
    0.37713787f, -0.19469009f, -0.01363941f, -0.09058163f, 0.18646932f, -0.03014935f, 0.06364892f, -0.27696612f, 
    0.07516570f, -0.13681099f, -0.04739420f, 0.11647443f, -0.09054410f, -0.36249477f, -0.08381066f, 0.07115227f, 
    -0.25414577f, 0.30141243f, 0.08628535f, -0.10893557f, 0.51083660f, -0.15554823f, 0.02750894f, 0.04280919f, 
    0.19405904f, 0.10145888f, -0.04570224f, -0.26440418f, -0.34112525f, -0.01180311f, -0.02398113f, 0.38552207f, 
    -0.14001508f, -0.20250612f, 0.27079675f, 0.27684024f, -0.06539463f, 0.09360085f, -0.02139861f, 0.35836005f, 
    0.01323784f, 0.06478257f, -0.07524395f, -0.18398431f, 0.65204233f, 0.37518212f, -0.08278889f, -0.08149640f, 
    -0.20405431f, -0.39044660f, -0.17437449f, 0.06658369f, -0.15843204f, 0.07881425f, 0.25294322f, -0.65339649f, 
    -0.18826884f, 0.30554268f, 0.19405043f, -0.20869610f, 0.60110527f, 0.13957001f, 0.32622528f, 0.37718385f, 
    -0.20826145f, 0.31339669f, -0.18469134f, 0.25107744f, 0.55451179f, -0.07592162f, -0.06794557f, 0.69314128f, 
    0.14002709f, -0.01736491f, 0.13364515f, -0.06333991f, 0.05201267f, -0.15944767f, 0.28705531f, -0.09501956f, 
    0.03742030f, 0.07954786f, 0.17930357f, -0.13849932f, -0.13897264f, -0.00606319f, -0.01260464f, 0.03957438f, 
    0.14031346f, -0.01467420f, -0.15789740f, -0.14804667f, 0.11836477f, 0.03428493f, -0.07091510f, -0.06801447f, 
    0.08811944f, -0.19699708f, -0.14478050f, 0.11288774f, 0.04299423f, 0.10159683f, -0.07564852f, -0.21072502f, 
    0.06956661f, 0.02408709f, -0.00694307f, -0.01249915f, -0.05262785f, 0.03581053f, -0.09792209f, 0.01073238f, 
    0.00143320f, 0.25483882f, 0.06220276f, -0.08240233f, 0.00538886f, 0.01459290f, 0.08336407f, -0.00205437f, 
    -0.03573839f, 0.04664480f, -0.09975231f, 0.18219352f, 0.09842484f, 0.09725352f, -0.11994679f, -0.26448289f, 
    -0.32078549f, -0.15760772f, 0.10638886f, -0.18947208f, -0.19891414f, 0.05690153f, -0.17647892f, -0.36145926f, 
    0.14336908f, -0.06770183f, -0.01846564f, -0.01211143f, -0.29182285f, -0.08367209f, -0.11092947f, -0.14571469f, 
    -0.02073096f, -0.10197035f, 0.13581683f, -0.02604134f, 0.36512938f, 0.56793541f, 0.30086440f, 0.22367822f, 
    0.17283300f, -0.16839582f, 0.26244274f, -0.10483775f, -0.00928994f, -0.41850987f, -0.04995256f, -0.07653821f, 
    -0.30202720f, 0.01088638f, 0.03594233f, 0.32086748f, -0.21044914f, -0.03780697f, -0.02986515f, -0.43055150f, 
    -0.10787274f, -0.07697290f, -0.02940794f, -0.15347624f, 0.26641569f, 0.10479590f, -0.68222654f, -0.14065035f, 
    0.22780867f, -0.16061544f, -0.02872532f, 0.05048886f, -0.11887577f, 0.38099986f, 0.15404066f, -0.31009096f, 
    0.33972025f, 0.05730883f, 0.11885288f, 0.15098657f, 0.09015118f, -0.13583185f, -0.07023813f, 0.47101513f, 
    -0.25530034f, -0.25020629f, -0.01367390f, 0.04405750f, 0.30311814f, -0.04523255f, 0.08257831f, -0.16704150f, 
    0.02324299f, 0.04088038f, 0.03947422f, -0.03035900f, 0.52695072f, -0.40967959f, -0.34613138f, -0.11270944f, 
    0.28862053f, 0.00397262f, -0.14461300f, -0.03362594f, 0.54535407f, 0.00295699f, 0.23713067f, -0.16423149f, 
    0.21499425f, 0.28038737f, -0.15870084f, -0.59724230f, 0.57600081f, -0.28195384f, 0.36327425f, 0.33738250f, 
    -0.28899541f, 0.38940406f, -0.31624258f, 0.13042083f, 0.07855238f, -0.08475163f, 0.08308534f, 0.39693302f, 
    0.16568993f, -0.06957565f, -0.07531426f, 0.06177290f, 0.15488204f, -0.15245487f, -0.21930714f, -0.13285273f, 
    -0.13986678f, -0.13284762f, -0.08827320f, 0.11475120f, -0.40083966f, -0.40817401f, -0.12895311f, 0.18605725f, 
    -0.23239151f, 0.38700679f, 0.20198609f, 0.12002780f, -0.12915808f, 0.21386123f, 0.06830172f, 0.03932220f, 
    0.02452933f, -0.34566438f, 0.14100239f, 0.24450606f, -0.05240078f, -0.02014402f, -0.02381754f, 0.16801706f, 
    0.10809550f, 0.02179146f, -0.05054582f, -0.08738349f, 0.00675006f, 0.24322380f, 0.30694914f, -0.11478215f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.18480799f, -0.11095608f, -0.10564306f, -0.13523288f, 0.17328809f, 0.10418463f, -0.07352322f, -0.02113839f, 
    -0.18090731f, 0.18064964f, 0.41055524f, 0.06909822f, -0.09105671f, 0.25773841f, 0.11500659f, 0.02631549f, 
    0.03740993f, -0.12747557f, -0.10789160f, -0.08930688f, -0.01960192f, 0.01400475f, -0.13441329f, -0.06132042f, 
    0.13523829f, -0.01354851f, -0.05696239f, -0.09105866f, 0.11143044f, 0.08623279f, 0.14785397f, -0.16863298f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.12657024f, 0.22079344f, -0.06577340f, 0.49784032f, -0.28302568f, -0.63899112f, -0.06084566f, -0.17577419f, 
    0.07630617f, 0.06118297f, -0.33345255f, -0.00725401f, -0.05730657f, -0.45453936f, -0.90801442f, 0.32031044f, 
    0.00104156f, 0.41659984f, 0.24506432f, -0.21133637f, -0.35025153f, -0.08301140f, -0.15496340f, 0.45234847f, 
    -0.28672588f, -0.02370124f, -0.12619989f, 0.16581477f, 0.07754172f, 0.28706253f, 0.15440735f, -1.07464278f, 
    0.04345935f, -0.34486929f, -0.37263554f, 0.20893985f, 0.19283888f, -0.19306858f, 0.04016825f, -0.01433378f, 
    -0.09066470f, -0.04490159f, -0.07642270f, -0.13927291f, -0.06106402f, 0.16260459f, 0.16568419f, 0.03263809f, 
    0.04235296f, 0.23481512f, -0.68560004f, -0.28902858f, -0.20275858f, 0.22653846f, -0.12464045f, -0.11448841f, 
    -0.19444874f, 0.09472093f, 0.01134526f, 0.02214448f, 0.37891781f, 0.36166784f, 0.19080439f, 0.37067017f, 
    0.01852577f, -0.27947280f, -0.46413091f, -0.16133927f, 0.16104396f, -0.10591505f, -0.15136869f, 0.31448993f, 
    -0.09297193f, 0.21321359f, 0.19893368f, 0.06422196f, 0.00529504f, 0.14151764f, 0.20360479f, -0.25808719f, 
    0.07102261f, 0.22556269f, 0.15830164f, -0.06998992f, -0.64822078f, 0.07167728f, 0.06907470f, 0.50733477f, 
    -0.25128362f, -0.73142695f, -0.13887191f, -0.18907118f, 0.08966031f, -0.32385236f, -0.04680590f, -0.87579185f, 
    -0.18584161f, 0.11507255f, 0.34208864f, 0.52655375f, -0.37305212f, -0.10170460f, 0.12940885f, -0.07342178f, 
    -0.14977713f, -0.34881908f, -0.52933103f, 0.23984860f, 0.00014728f, -0.34809843f, 0.04604246f, 0.40507045f, 
    0.02617581f, -0.36057147f, -0.09859192f, -0.01538784f, 0.00958106f, -0.18538299f, -0.05868883f, 0.11397568f, 
    0.11191637f, -0.17919077f, -0.00520494f, 0.11958647f, 0.06583974f, -0.03652453f, -0.65205342f, -0.00460732f, 
    0.10730257f, 0.24613781f, 0.17494203f, 0.41173428f, -0.28662053f, 0.17783257f, 0.13753758f, 0.12873642f, 
    -0.31773016f, -0.43925342f, -0.12072361f, 0.12411974f, 0.02218051f, -0.54076016f, -0.54849112f, -0.30620205f, 
    -0.13871695f, -0.11190913f, -0.10093479f, 0.30796036f, -0.07641854f, 0.13747825f, -0.16647190f, -0.37521693f, 
    0.01697213f, 0.03703849f, -0.09687523f, -0.24257348f, 0.17998166f, -0.12493466f, 0.24319676f, -0.45582524f, 
    0.12234349f, 0.08454073f, 0.29281461f, -0.40182292f, 0.16556767f, -0.29132241f, -0.01237663f, -0.18781553f, 
    -0.22974093f, 0.16366261f, -0.22316055f, -0.22539179f, -0.02992890f, -0.01504750f, -0.53384763f, 0.16556419f, 
    0.16229439f, -0.04915583f, -0.65267617f, -0.18618380f, 0.38833877f, 0.24563186f, -0.05475369f, -0.88600355f, 
    -0.05148133f, 0.46698856f, -0.01992546f, 0.18772864f, -0.12300578f, 0.21234770f, 0.24796510f, -1.08482897f, 
    0.11375858f, -0.29357016f, 0.22863165f, -0.53562641f, 0.10037449f, -0.03216004f, 0.02965989f, 0.16994669f, 
    0.04739599f, -0.32480279f, 0.37388006f, 0.28575525f, -0.17997994f, 0.10405480f, -0.23907281f, -0.12829840f, 
    -0.02026985f, 0.31867820f, 0.12043926f, 0.05336037f, 0.48359299f, -0.02117473f, 0.14456567f, 0.01272556f, 
    -0.45074037f, -0.24067900f, -0.12545724f, -0.16027053f, -0.46100572f, 0.10763692f, -0.20277192f, -0.48049542f, 
    0.01484915f, 0.33076006f, 0.12089662f, -0.47499540f, -0.41351426f, 0.03334802f, -0.10092881f, 0.25080329f, 
    0.04821221f, -0.15197879f, -0.43037286f, -0.09662896f, -0.09852804f, 0.07480413f, 0.33617097f, -0.14580983f, 
    0.04034216f, -0.05111299f, -0.16500194f, 0.24271895f, -0.14159821f, 0.11216911f, -0.09572076f, -0.37185785f, 
    -0.21507333f, -0.14265415f, 0.14402884f, -0.15663706f, -0.48283920f, -0.53107160f, -0.62746918f, 0.39845416f, 
    -0.13708471f, -0.41494572f, -0.20734812f, 0.22741225f, 0.00702949f, 0.11660615f, 0.14420208f, 0.07739054f, 
    0.13100600f, 0.54484171f, 0.20426209f, -0.87841511f, 0.13873951f, 0.43543240f, -0.02355896f, -0.13915919f, 
    -0.15194269f, 0.00654083f, 0.06433520f, 0.03463466f, 0.00233635f, -0.46584406f, 0.06101302f, -0.81976235f, 
    0.08366049f, -0.54348880f, -0.14866190f, -0.33133981f, 0.36543676f, -0.15058540f, 0.14751253f, -0.34706420f, 
    0.07302513f, 0.22589786f, -0.29888305f, -0.22492261f, -0.18666056f, 0.40503815f, 0.09444371f, 0.31631765f, 
    -0.76677108f, 0.20795557f, 0.04566883f, 0.15139687f, 0.00011964f, 0.24058083f, -0.02613712f, -0.55343974f, 
    0.16774815f, -0.59345645f, 0.09030646f, -0.06587990f, -0.00983630f, 0.16685492f, -0.05849916f, -0.15882777f, 
    -0.50630957f, 0.12160219f, 0.00826486f, -0.09369086f, -0.49893954f, -0.56823963f, 0.21131130f, -0.38953629f, 
    -0.10309454f, -0.08750308f, 0.02693730f, -0.31817007f, -0.30360764f, 0.15502192f, 0.14520559f, -0.73937118f, 
    0.00363797f, -0.45870763f, 0.15453714f, -0.19157237f, 0.05100149f, 0.20439114f, 0.39030671f, 0.19654065f, 
    0.05895473f, -0.63217396f, 0.10916326f, -0.21224256f, -0.29480338f, 0.07673997f, -0.12699921f, 0.15710251f, 
    0.39069319f, -0.42873096f, 0.03294361f, -0.21679933f, 0.16955848f, 0.22296378f, 0.18366675f, 0.01291381f, 
    -0.07664111f, 0.16210693f, 0.00301165f, 0.25332502f, 0.31288609f, -0.68732649f, 0.15996976f, -0.23326929f, 
    -0.21670410f, -0.08077000f, 0.13990183f, 0.13629213f, -0.14663389f, 0.01596698f, -0.19175209f, 0.10651205f, 
    -0.10122275f, -0.20772266f, 0.37483349f, -0.10826074f, -0.10238691f, -0.93592018f, -0.07781145f, -0.30000103f, 
    0.40238923f, 0.30533168f, 0.13626881f, -0.12205043f, -0.37936181f, -0.16445313f, 0.13394305f, -0.31679887f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.23863353f, -0.07683799f, -0.28996795f, 0.17070098f, -0.07634985f, 0.10778955f, -0.10004386f, -0.00627816f, 
    -0.13561659f, 0.13950558f, 0.18135746f, -0.02222949f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
