#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.43629736f, 0.24354741f, 0.15569653f, -0.10847747f, 0.06622588f, 0.16845872f, -0.02873764f, -0.21476872f, 
    0.21201728f, 0.25587797f, 0.28524420f, -0.02264577f, -0.19055367f, 0.08696891f, 0.33663025f, -0.19590707f, 
    0.28615981f, -0.18111792f, -0.09919021f, -0.36533573f, 0.09740676f, 0.16862345f, 0.32034302f, -0.00392451f, 
    -0.10827832f, 0.10133187f, -0.09611414f, 0.03776694f, 0.15937607f, 0.26658961f, 0.33686966f, 0.28269088f, 
    0.20264770f, -0.31283787f, -0.08525731f, 0.30170795f, 0.10930656f, -0.05205595f, -0.36331671f, 0.18088900f, 
    -0.39988297f, -0.15734205f, -0.04914187f, 0.05320124f, 0.37619379f, 0.13081828f, -0.12663442f, -0.39600590f, 
    0.22849621f, 0.26987523f, -0.67203283f, 0.09857060f, -0.11502230f, 0.21764912f, 0.25913826f, 0.38558739f, 
    0.31861195f, 0.12923555f, 0.19261764f, -0.10422218f, 0.03191413f, 0.26033455f, -0.00443400f, -0.10470308f, 
    0.19035855f, -0.28232002f, -0.01420208f, -0.11873766f, -0.29285014f, -0.49471572f, -0.11889207f, -0.19643354f, 
    0.27672109f, -0.13369453f, 0.12078861f, -0.69460374f, -0.41067639f, 0.40458167f, -0.09180740f, -0.02477462f, 
    -0.61848164f, -0.66029847f, -0.28889251f, -0.25753117f, -0.69003689f, 0.13400128f, 0.24321890f, -0.40468949f, 
    -0.36108345f, -0.22782575f, 0.05022259f, -0.06280936f, -0.01145879f, -0.23903656f, -0.23023465f, 0.04585754f, 
    -0.03600346f, -0.11309014f, -0.10781890f, 0.13839078f, -0.74105597f, 0.85499579f, -0.23829372f, -0.12074634f, 
    -0.11556536f, 0.03427691f, 0.17597809f, 0.53216201f, 0.06055072f, -0.34005150f, -0.21213526f, -0.17852177f, 
    0.23167568f, 0.03336835f, -0.04628948f, 0.16706951f, 0.01428083f, -0.27525210f, -0.23053741f, -0.07727809f, 
    0.02393042f, 0.04274836f, -0.11219580f, -0.22762583f, -0.39730328f, 0.23027910f, 0.24034335f, 0.50515342f, 
    0.21030033f, 0.02399337f, -0.73028356f, -0.76967269f, -0.01047439f, 0.39033589f, 0.48063892f, 0.08974241f, 
    -0.37136894f, 0.15620798f, 0.44771892f, -0.15469567f, -0.26089668f, 0.17642000f, -0.07759653f, 0.09561907f, 
    -0.45698422f, -0.06252719f, 0.13365661f, -0.10561662f, 0.29014713f, 0.19173945f, -0.01954906f, -0.58323872f, 
    -0.50122517f, -0.39100382f, -0.48218825f, 0.22621581f, 0.18503746f, 0.14228408f, 0.07029068f, 0.15304738f, 
    -0.17801894f, -0.45910701f, -0.23834482f, 0.28119269f, 0.23094197f, -0.32723704f, -0.20143589f, 0.01143726f, 
    -0.27573159f, 0.02840549f, -0.06763897f, -0.14869463f, 0.08648837f, 0.24344954f, -0.30041966f, 0.03661076f, 
    -0.01830742f, 0.08800378f, 0.53780967f, -0.35261294f, -0.06313875f, 0.05165101f, 0.14494200f, -0.19940387f, 
    0.31711370f, 0.24072866f, -0.26347974f, -0.23923513f, 0.25902361f, 0.04770766f, 0.08846584f, -0.08448702f, 
    0.03229490f, -0.17807007f, 0.01631830f, 0.07868677f, 0.01114240f, -0.18924680f, 0.22291337f, 0.36311617f, 
    0.68170261f, 0.57296455f, 0.35001457f, -0.05213634f, 0.50537688f, 0.10626414f, -0.14099331f, 0.13912380f, 
    0.19765924f, -0.10283259f, 0.08853813f, 0.20754699f, -0.06382014f, -0.09222603f, 0.17430851f, 0.19121252f, 
    -0.30545706f, -0.15567020f, 0.04870195f, 0.04076385f, -0.08048105f, 0.31549847f, 0.12880404f, -0.00650923f, 
    -0.09790914f, -0.69593209f, 0.51081264f, 0.67139602f, 0.35008633f, 0.35021400f, -0.17189410f, -0.22568880f, 
    -0.14476086f, 0.08910208f, -0.12112028f, -0.27488929f, -0.26651096f, -0.02627117f, 0.21675834f, 0.40648770f, 
    0.25209534f, -0.06948995f, -0.27635244f, 0.00423210f, -0.15713215f, 0.03627571f, 0.13469777f, -0.09818766f, 
    0.11823985f, -0.41981441f, 0.55104828f, 0.48311245f, 0.10712100f, -0.11226867f, -0.60512751f, 0.71923447f, 
    0.07862695f, -0.10067512f, -0.10817267f, 0.28682277f, -0.01285058f, -0.04490716f, 0.02117417f, -0.38188818f, 
    -0.43788147f, -0.06465267f, -0.23523021f, 0.00127433f, -0.09270676f, -0.03117988f, -0.07874504f, 0.01220564f, 
    0.20588198f, 0.18015797f, -0.01023290f, -0.00147231f, -0.10993623f, -0.41524693f, 0.05784623f, 0.23804986f, 
    -0.17499609f, 0.21608941f, 0.03833509f, -0.09525187f, -0.38299742f, -0.19623105f, 0.68454677f, -0.41118154f, 
    0.09228802f, 0.08496671f, 0.04180437f, -0.39990544f, -0.19187348f, 0.27591312f, -0.14578302f, 0.13453789f, 
    0.21333252f, 0.09032717f, 0.12157448f, 0.02816341f, -0.58876854f, -0.19109678f, -0.10157259f, -0.51067239f, 
    -0.33644769f, -0.20623451f, -0.08062143f, -0.41793209f, -0.09049938f, 0.62854803f, -0.12713043f, -0.24187458f, 
    -0.29039913f, -0.19436906f, -0.29495108f, 0.33917820f, 0.24718787f, -0.00690073f, 0.03861509f, -0.09111322f, 
    -0.22399643f, -0.24562569f, -0.19882481f, -0.14702016f, -0.12351932f, -0.47374874f, -0.48864704f, -0.07783210f, 
    -0.23455206f, 0.55038637f, 0.56365043f, -0.61276215f, 0.01798891f, -0.35784465f, 0.21890208f, -0.12846079f, 
    0.20388381f, -0.07580201f, 0.59898686f, -0.40603402f, 0.31216410f, 0.26093960f, 0.20814896f, 0.19477694f, 
    0.01330933f, 0.02136920f, -0.03125662f, 0.23257878f, -0.02105823f, -0.28963703f, -0.00607706f, -0.01849172f, 
    -0.48643962f, 0.50853485f, 0.11890009f, -0.68419307f, -0.02231121f, -0.00423169f, -0.21770744f, 0.47663358f, 
    -0.13659635f, -0.09424621f, -0.23838165f, 0.11761874f, 0.00875421f, -0.16916467f, -0.20747896f, 0.14602703f, 
    0.37157917f, -0.04042540f, 0.13026504f, -0.13291873f, 0.02774589f, 0.22953700f, 0.05474081f, 0.42097598f, 
    1.08490837f, 0.36536795f, -0.60009807f, -0.16666231f, -0.04101824f, -0.39538044f, -0.08654761f, 0.29607773f, 
    -0.85513282f, -0.14884646f, 0.10674530f, 0.10716113f, -0.05374602f, -0.06499380f, 0.19089293f, -0.01561172f, 
    0.20138937f, 0.04410519f, -0.12601078f, -0.10672474f, 0.29517761f, -0.08851390f, -0.11683900f, 0.20275578f, 
    0.03919784f, -0.70001441f, -0.16180600f, 0.81480885f, 0.47189301f, -0.00279996f, 0.39719644f, 0.01145391f, 
    -0.08814535f, -0.26937148f, -0.09275704f, -0.10172766f, -0.19502841f, -0.31815091f, 0.35277519f, -0.05332734f, 
    0.41326517f, 0.37026522f, 0.12259983f, -0.17836882f, 0.38106850f, -0.08013328f, -0.27184212f, -0.15874504f, 
    -0.34637249f, 0.35618433f, 0.24834539f, 0.12455033f, -0.07703672f, -0.00323228f, -0.41704801f, 0.71415281f, 
    -0.67236125f, 0.02763502f, 0.08072732f, -0.03905021f, -0.06038354f, -0.31405479f, -0.15909988f, 0.13763623f, 
    0.27091399f, 0.17949107f, -0.02054451f, -0.10917262f, 0.30688730f, -0.09607956f, -0.02560466f, -0.04243545f, 
    -0.14661862f, -0.25569507f, 0.96173865f, -0.21576563f, 0.17709714f, 0.35081309f, 0.67290783f, -0.20527884f, 
    -0.17982806f, -0.27405566f, -0.41757053f, -0.41744134f, -0.31739917f, -0.01234768f, 0.23863454f, -0.07977346f, 
    0.00290845f, -0.28787825f, -0.03821181f, 0.32093051f, 0.03955388f, 0.07428187f, -0.07488178f, 0.00842445f, 
    -0.06663053f, -0.09688809f, 0.12434888f, -0.94576478f, -0.35791376f, -0.11440874f, 0.28945065f, 0.14774023f, 
    0.00345646f, 0.00483541f, 0.00394340f, 0.48394322f, 0.44509193f, -0.02350887f, 0.09605986f, -0.15638575f, 
    0.05303935f, 0.14106156f, -0.31605443f, 0.07060109f, -0.10170526f, -0.14836876f, -0.48304713f, 0.05688116f, 
    0.41659489f, 0.38098285f, 0.33719113f, -0.07061988f, -0.02049585f, -0.31920922f, 0.28961155f, 0.43270159f, 
    0.27657557f, -0.70193225f, -0.35726935f, 0.70445520f, 0.14752422f, 0.12023956f, 0.19785081f, 0.09632394f, 
    0.14375818f, -0.24926004f, -0.08381564f, 0.13414596f, -0.09020115f, -0.00579900f, -0.13377975f, -0.24114409f, 
    -0.18294118f, -0.19690108f, -0.22300242f, 0.11207629f, 0.31556988f, -0.85744941f, -0.57060146f, -0.25779417f, 
    -0.51862258f, -0.47707689f, 0.80251747f, -0.21896049f, 0.26153535f, 0.29202116f, 0.65942729f, 0.26777709f, 
    -0.12916869f, -0.06390504f, 0.51396507f, 0.12131718f, 0.05752977f, -0.07910190f, 0.12816164f, -0.01530831f, 
    0.03636959f, -0.10827362f, 0.23935172f, 0.16260837f, -0.23278449f, -0.21493071f, -0.84382176f, -0.71299630f, 
    -0.05362747f, 0.23476349f, 0.45369858f, 0.59164637f, 0.40551543f, -0.40212122f, -0.40242299f, 0.51881373f, 
    -0.58718479f, -0.03461615f, 0.08419934f, -0.14955309f, -0.27323279f, 0.13336349f, 0.18033373f, -0.02831925f, 
    0.04868523f, 0.32742298f, -0.12342110f, -0.32637614f, -0.04091744f, -0.20828921f, -0.25996917f, 0.11182003f, 
    -0.20230563f, -0.16067372f, 0.42228651f, 0.35911590f, 0.03556471f, 0.03707188f, -0.07406865f, -0.10396774f, 
    -0.29086530f, 0.16879056f, -0.41091976f, -0.05973131f, 0.21346267f, -0.16883253f, 0.08800859f, 0.34431475f, 
    -0.33284307f, -0.25625598f, -0.23868813f, 0.02606786f, 0.02951225f, 0.18884073f, 0.28376371f, 0.38153392f, 
    -1.05577850f, 0.03860957f, 0.48465100f, -0.78252220f, -0.60117412f, 0.73455095f, -0.07695510f, -0.48053336f, 
    -0.19032869f, 0.14094663f, -0.16135961f, 0.06059789f, 0.15585832f, 0.20450364f, -0.13188960f, 0.13635272f, 
    -0.14678603f, -0.05711405f, -0.18680860f, 0.04208749f, -0.05316333f, 0.46480978f, 0.15358530f, -0.02031374f, 
    0.16219945f, 0.93191749f, -0.76659572f, -0.76124519f, -0.24018688f, -0.32157195f, 0.65888399f, 0.35994178f, 
    0.56945729f, -0.20572384f, -0.44732466f, 0.45049250f, 0.08211136f, 0.09102703f, -0.14480276f, -0.40510088f, 
    0.19669613f, -0.12214541f, -0.09556151f, -0.14412339f, 0.26821142f, -0.14797571f, -0.08562338f, 0.22165176f, 
    -0.06169293f, 0.03996904f, 0.42870405f, 0.30105931f, 0.33814737f, 0.26049587f, 0.30191612f, -0.18153295f, 
    0.12970273f, 0.27199683f, 0.40200070f, -0.15209959f, -0.17859311f, 0.12904394f, 0.19291873f, -0.05962140f, 
    -0.08405586f, -0.16494288f, -0.24721186f, -0.03108056f, -0.13180634f, -0.05601473f, 0.00557751f, -0.29396483f, 
    -0.23067780f, -0.27418134f, -0.23394269f, -0.28632772f, 0.06093012f, 0.17949398f, -0.19448881f, -0.61744297f, 
    -0.48163608f, -0.09490418f, -0.33805156f, 0.00449818f, -0.63307273f, 0.13163397f, -0.53231239f, 0.42393211f, 
    0.40422165f, -0.33352649f, -0.11733076f, -0.03686556f, 0.09201400f, -0.21713756f, -0.04006805f, 0.06935058f, 
    -0.05505770f, 0.12109521f, 0.00721434f, 0.62455678f, 0.26842692f, -0.30147341f, -0.06758288f, 0.68373650f, 
    0.47124875f, 0.16758728f, 0.13195643f, 0.02659452f, 0.17550066f, -0.23405302f, -0.22714119f, -0.11357287f, 
    -0.21806647f, 0.01241660f, 0.09536429f, -0.05681863f, 0.11605405f, -0.21028528f, 0.21371800f, -0.09103068f, 
    -0.18337037f, -0.19683747f, -0.19864978f, -0.41920409f, -0.51686615f, -0.03793310f, -0.40121174f, -0.23113410f, 
    0.12436917f, -0.29888922f, -0.08417525f, -0.40887466f, -0.45319793f, 0.07402611f, -0.10956946f, 0.36867869f, 
    -0.27504194f, -0.04174589f, 0.45822158f, -0.27257556f, -0.38627216f, -0.02004306f, -0.32442504f, -0.04765107f, 
    -0.13295631f, -0.10352945f, -0.37718821f, -0.10524464f, -0.00097241f, -0.67750955f, -0.12872681f, -0.06378962f, 
    -0.38278729f, 0.10499433f, -0.48006672f, -0.08944758f, -0.28391629f, -0.12211584f, -0.37345892f, 0.18384519f, 
    0.59017009f, 0.18800846f, 0.24772209f, -0.09792797f, -0.39733699f, -0.23422271f, -0.19480616f, 0.19420055f, 
    -0.35341868f, -0.36472929f, 0.17034528f, 0.18882035f, -0.34633049f, 0.36228356f, 0.06233548f, 0.55998439f, 
    -0.62499368f, -0.81108719f, -0.58742833f, -0.48598352f, 0.60988158f, 0.62724608f, 0.48792771f, 0.05406872f, 
    -0.06350698f, 0.00605592f, -0.03579960f, -0.22560658f, -0.50364459f, 0.09861578f, -0.25005978f, -0.05034165f, 
    0.08180279f, 0.11569367f, -0.24049306f, 0.01809517f, -0.17948085f, -0.15175027f, 0.04745566f, 0.24839607f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01607867f, 0.21294530f, 0.06326093f, 0.04592328f, 0.15557671f, 0.04206837f, -0.17140357f, 0.25007820f, 
    -0.02406845f, 0.00645548f, 0.11366564f, -0.02609422f, -0.14880240f, -0.07337797f, 0.03674703f, 0.14504594f, 
    -0.02487167f, 0.12007701f, 0.15625189f, 0.05958313f, 0.22543357f, 0.02848219f, 0.28580993f, -0.08806707f, 
    -0.11578324f, 0.36571050f, -0.17349577f, 0.05184812f, 0.01193687f, 0.27916846f, -0.04475722f, 0.20945795f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.15033072f, -0.02301625f, 0.03389879f, 0.07842271f, -0.06512238f, -0.08338697f, -0.13076797f, -0.15459374f, 
    0.03939629f, -0.12152549f, -0.15479657f, 0.01463736f, 0.04274252f, 0.23143916f, -0.13657889f, -0.18375933f, 
    -0.01148046f, -0.12593774f, -0.24279496f, 0.03772817f, -0.06671482f, 0.15274285f, -0.20955072f, -0.07446828f, 
    0.23534523f, 0.15269041f, -0.21377788f, 0.06770128f, 0.03268018f, -0.06107692f, -0.03818760f, -0.15587333f, 
    -0.12427104f, 0.05991559f, -0.05364709f, -0.07081263f, 0.08132967f, -0.06762592f, 0.18897980f, 0.24798410f, 
    0.15067197f, 0.04064163f, 0.02704951f, 0.07810701f, 0.02458494f, 0.02347673f, -0.04344646f, 0.10544660f, 
    0.27531940f, -0.02588483f, -0.04521442f, 0.15864366f, 0.11529721f, -0.08848308f, -0.14876319f, -0.14226212f, 
    0.04570983f, -0.00766264f, 0.09701280f, 0.11996248f, -0.18248032f, -0.34111637f, 0.35674462f, 0.26308262f, 
    0.03238490f, 0.04172733f, -0.26983798f, -0.13868243f, 0.00405430f, -0.17699216f, -0.02245341f, -0.15562396f, 
    -0.08871622f, -0.11617023f, 0.01631883f, 0.23314293f, 0.05906188f, -0.05273288f, 0.18148218f, -0.05723712f, 
    0.00313725f, 0.08025564f, 0.05434122f, -0.00522710f, -0.02014219f, -0.16606653f, -0.04522754f, -0.11367919f, 
    0.07838348f, -0.24714911f, -0.27571663f, -0.09731815f, -0.07011206f, 0.01864536f, -0.14228058f, -0.36447781f, 
    -0.04405872f, 0.06495045f, 0.01625316f, 0.16273849f, -0.04458921f, 0.00313523f, -0.39631197f, -0.12322519f, 
    0.06952226f, -0.09028292f, -0.00514791f, 0.20325163f, 0.34999639f, 0.41668895f, 0.02671922f, 0.09813026f, 
    -0.04273305f, -0.13874927f, -0.10065128f, -0.10265586f, -0.04266040f, -0.04374649f, -0.01560069f, 0.25688770f, 
    -0.18209329f, 0.01829477f, 0.15306231f, -0.05914066f, 0.14590231f, 0.28941199f, -0.00368301f, -0.00597838f, 
    -0.00873095f, -0.05806162f, 0.14272688f, -0.09549738f, 0.08309359f, -0.10763146f, -0.14463057f, -0.05422538f, 
    -0.01894949f, 0.03460637f, 0.05418604f, -0.01716837f, 0.07067940f, -0.17219336f, -0.15774056f, 0.02063349f, 
    0.07794320f, -0.16948543f, 0.02992346f, 0.08735133f, 0.12964612f, -0.00830769f, -0.00598734f, -0.06883054f, 
    0.03690906f, 0.13262165f, 0.08956292f, 0.31353635f, 0.12639415f, 0.01231023f, 0.13187750f, -0.15776359f, 
    0.01555787f, 0.00205886f, -0.05363591f, -0.29683581f, 0.13019952f, -0.04471396f, 0.07830734f, 0.06553224f, 
    -0.11294297f, -0.18879054f, -0.13289902f, -0.01034225f, -0.02573179f, 0.09811764f, -0.01211085f, -0.07468648f, 
    -0.23855966f, -0.01624369f, -0.21261273f, -0.23952800f, -0.12095894f, 0.14106576f, 0.12976368f, 0.14101264f, 
    0.03682429f, 0.05300694f, -0.13167574f, 0.03699960f, -0.22107558f, 0.02007829f, -0.09309575f, -0.29702422f, 
    0.12470382f, 0.32097623f, -0.07755474f, 0.04878000f, -0.00691900f, -0.09895495f, -0.06812537f, 0.20462869f, 
    0.20713905f, 0.16345435f, -0.16731513f, 0.03158693f, -0.13643533f, 0.08117044f, -0.30774674f, -0.23654513f, 
    0.08593874f, -0.12917726f, 0.09964151f, 0.05271010f, 0.09809659f, 0.00558117f, -0.11894560f, 0.19081834f, 
    0.20018536f, 0.18630621f, 0.43982908f, 0.06326940f, 0.07675275f, -0.00339819f, -0.10661705f, -0.06231536f, 
    -0.02159572f, -0.05694511f, -0.07577936f, -0.32593206f, 0.22378910f, -0.10408981f, -0.06144338f, 0.10762898f, 
    0.14438283f, -0.09350675f, 0.01016335f, -0.13174281f, -0.03935814f, -0.14204970f, -0.18294564f, -0.19946852f, 
    0.10385197f, 0.01397837f, 0.04619631f, 0.16127197f, -0.10404614f, -0.03082713f, -0.16456461f, -0.01403305f, 
    0.04352003f, 0.12733972f, -0.08864456f, -0.07400961f, 0.33872983f, -0.09166887f, 0.13816300f, 0.25448623f, 
    0.09558871f, 0.03106713f, -0.00860050f, -0.05602824f, 0.13631670f, -0.11613759f, 0.01506088f, 0.16785032f, 
    -0.18394718f, 0.13847731f, -0.06025040f, -0.00970988f, -0.00216841f, 0.08131338f, 0.03431707f, 0.07828207f, 
    -0.08419280f, 0.17948869f, -0.03988422f, 0.07972226f, 0.28109795f, 0.05722687f, -0.02800235f, 0.05095739f, 
    0.05271764f, -0.03834411f, -0.12257456f, 0.00071649f, -0.23773597f, -0.30307606f, 0.02608947f, -0.29511631f, 
    0.08215702f, 0.03203259f, -0.09752740f, 0.16231203f, 0.03052964f, -0.01161183f, -0.10830731f, 0.02265300f, 
    0.02257867f, 0.06377984f, -0.18787080f, -0.03954506f, -0.48186103f, 0.08300755f, 0.26058748f, -0.09002671f, 
    0.07152528f, 0.03675639f, -0.01978558f, -0.03573537f, -0.05317201f, 0.06311516f, 0.06805732f, -0.03332105f, 
    -0.00805498f, -0.15775099f, -0.05520776f, 0.11685921f, 0.00899958f, -0.01792549f, -0.22924475f, -0.15247636f, 
    0.24842320f, 0.12764333f, 0.06603029f, 0.12232894f, 0.02398020f, -0.11742063f, -0.00997274f, 0.25529832f, 
    -0.04506380f, 0.09660999f, 0.03436525f, 0.15296100f, -0.00678021f, 0.05915336f, -0.08358711f, -0.24352111f, 
    0.13918337f, 0.10188836f, -0.10155708f, 0.18076409f, -0.02835986f, -0.02101303f, -0.17430647f, 0.17133926f, 
    0.32688028f, 0.26215646f, -0.01674803f, 0.29343513f, -0.05806066f, -0.06752539f, 0.06592754f, 0.30155697f, 
    0.01682708f, 0.04527832f, 0.03293443f, 0.02761110f, 0.02640561f, 0.02751967f, 0.05764010f, 0.24604440f, 
    0.10879640f, 0.04297785f, 0.08152658f, 0.24220060f, 0.02092856f, 0.00322286f, 0.01497867f, -0.01067244f, 
    0.00715295f, 0.20181352f, 0.01954446f, 0.01878808f, -0.16944644f, 0.06900434f, 0.16167118f, 0.04943077f, 
    0.06726102f, 0.14667475f, 0.02730434f, -0.04226198f, 0.03451151f, -0.00905917f, 0.06329403f, 0.00786096f, 
    -0.10121555f, 0.05948862f, 0.00472057f, 0.05823154f, -0.04360569f, 0.11226441f, -0.14769773f, -0.04211032f, 
    0.11529148f, 0.13481648f, 0.10352149f, 0.08681163f, 0.17645642f, -0.00312318f, -0.07277779f, -0.09903420f, 
    0.04071147f, -0.02041666f, -0.01031250f, 0.18316212f, 0.26537177f, -0.01123965f, 0.08491246f, 0.21442141f, 
    -0.27743322f, -0.21923764f, 0.03317305f, 0.19589137f, -0.09832927f, 0.00565353f, -0.07045591f, -0.01345029f, 
    -0.02189467f, -0.02960167f, 0.12326396f, -0.04684219f, 0.08414020f, 0.26455313f, 0.07140374f, -0.07959305f, 
    0.08528253f, -0.02742218f, 0.02068465f, 0.15160955f, -0.01517375f, 0.02991160f, 0.05287124f, 0.11746196f, 
    -0.53309363f, 0.21524121f, 0.03720155f, 0.26578873f, 0.07956725f, -0.00446202f, -0.20892482f, -0.04561756f, 
    0.02728103f, 0.18039939f, 0.23272648f, 0.09299679f, 0.37623918f, 0.05579055f, 0.30082169f, -0.01193520f, 
    0.38147697f, -0.24894457f, -0.09609473f, 0.02040066f, 0.10709738f, -0.04153182f, 0.12032492f, 0.04195947f, 
    0.31794947f, -0.21827260f, 0.17360146f, 0.14097740f, 0.04782091f, 0.06538942f, 0.07315450f, 0.01713862f, 
    0.04484464f, -0.08576834f, 0.18597429f, 0.03839096f, -0.09906155f, -0.01249612f, -0.05258747f, 0.13441584f, 
    0.15187567f, -0.08142921f, 0.00837547f, 0.03583938f, 0.11149006f, 0.07289476f, 0.14319383f, 0.17293639f, 
    0.05434928f, 0.10130924f, 0.13844176f, 0.09904332f, 0.05216957f, 0.04769135f, -0.08531173f, -0.04884275f, 
    0.02416519f, -0.00736356f, 0.01885576f, 0.08158658f, -0.06098295f, 0.26980498f, 0.20266968f, 0.00460572f, 
    0.13334610f, -0.12220649f, 0.04564558f, -0.01959667f, -0.12584184f, 0.00015965f, 0.06493760f, -0.07111590f, 
    -0.08107191f, 0.17036985f, 0.14094092f, -0.07062665f, -0.20069262f, -0.09721673f, -0.03937845f, -0.10382079f, 
    -0.06216213f, 0.03416168f, -0.01194923f, -0.02008838f, 0.02928546f, 0.05338155f, -0.36131519f, -0.08266707f, 
    0.01383976f, -0.00454222f, 0.04059542f, 0.07629160f, -0.05543634f, 0.00886826f, -0.09506709f, 0.03600150f, 
    0.33302006f, 0.23469563f, 0.31221059f, 0.02603496f, 0.09219809f, -0.00989827f, -0.04774054f, 0.06754348f, 
    -0.08347160f, -0.19152564f, 0.00523310f, 0.02387305f, -0.07468188f, -0.19521414f, -0.25184420f, -0.24059458f, 
    0.28609747f, 0.10820274f, 0.14586577f, 0.09848087f, 0.08247784f, -0.16083604f, -0.05524447f, -0.11652083f, 
    0.48697037f, -0.01784353f, 0.14874530f, 0.02744948f, -0.02195462f, -0.02906020f, -0.11420522f, 0.21686065f, 
    -0.00565338f, -0.05785212f, 0.16812889f, -0.04268968f, -0.22378619f, -0.11291456f, 0.05226607f, -0.03157181f, 
    0.14455654f, -0.05586628f, -0.08230022f, 0.16407736f, -0.07866808f, -0.02736581f, 0.01499549f, 0.10094596f, 
    0.00737309f, 0.05497747f, -0.06257902f, -0.03900149f, -0.06968263f, -0.06467593f, 0.17011577f, 0.04891646f, 
    0.10871260f, 0.01025762f, 0.00008684f, -0.00806774f, -0.26753083f, -0.03367144f, -0.27334353f, -0.06953353f, 
    0.10461215f, 0.13651407f, 0.08878198f, 0.15457790f, 0.26204500f, 0.08635990f, -0.13383666f, 0.01835688f, 
    0.37779745f, 0.13837615f, -0.02795373f, -0.11579581f, -0.03516550f, 0.07569347f, 0.02603481f, -0.19485486f, 
    -0.02411841f, -0.00514329f, -0.14758879f, -0.08090208f, -0.11635367f, -0.34600663f, -0.03153120f, 0.23229386f, 
    -0.03037995f, -0.14593978f, -0.05019755f, -0.00849738f, 0.09533091f, -0.02420811f, 0.14617522f, 0.14108069f, 
    0.30041546f, -0.04303114f, -0.11523570f, 0.54024500f, 0.09256821f, -0.06208233f, 0.06313824f, -0.20205709f, 
    0.14554743f, 0.09695707f, 0.07985991f, 0.28806064f, -0.43266171f, -0.39820188f, -0.20500828f, -0.22393349f, 
    -0.02604910f, 0.31144878f, -0.02961692f, 0.02574433f, 0.05918836f, -0.05040963f, 0.10788511f, -0.02121002f, 
    0.05303146f, 0.16233516f, -0.01508749f, -0.02356342f, 0.05370404f, 0.07847145f, 0.11199012f, 0.10524542f, 
    0.23678793f, 0.00558588f, 0.07766258f, 0.04483975f, -0.11434598f, -0.02797017f, -0.01209548f, -0.15288222f, 
    0.08093692f, 0.03039594f, 0.04755298f, -0.18306254f, -0.01017300f, -0.09782126f, 0.06662957f, 0.03001896f, 
    -0.43532830f, -0.31504294f, 0.13096306f, 0.04975258f, 0.06107635f, 0.22766238f, -0.05592794f, 0.27781481f, 
    0.02776201f, -0.13562353f, -0.12363813f, -0.10019966f, 0.26349992f, 0.09246058f, 0.02616478f, -0.36779776f, 
    0.08981203f, 0.30851111f, 0.19768077f, 0.24478130f, 0.03386751f, 0.22323649f, 0.18650508f, -0.10345179f, 
    0.13093285f, 0.00500134f, 0.27299732f, 0.14527258f, -0.00624526f, 0.10654157f, -0.07034697f, -0.12257058f, 
    -0.03267378f, 0.14484406f, -0.02674021f, 0.03148370f, 0.08661500f, 0.09676918f, -0.03472986f, -0.05545605f, 
    0.14560036f, 0.05242947f, 0.08874221f, 0.15876447f, 0.02449221f, -0.09246097f, 0.00710661f, 0.06743081f, 
    -0.25316826f, -0.05131316f, -0.05383703f, -0.01441416f, -0.05031696f, -0.12905405f, 0.01989801f, -0.11642420f, 
    -0.05122129f, -0.03401110f, 0.05162942f, 0.07393699f, 0.20392075f, -0.14015986f, 0.20823739f, -0.03661528f, 
    0.12940195f, 0.00554647f, 0.22270773f, 0.06621098f, 0.01075021f, 0.04843486f, 0.24494284f, -0.01421517f, 
    0.00455216f, 0.01684827f, 0.02014942f, -0.08350825f, 0.08177983f, 0.09831392f, -0.04893668f, 0.23446886f, 
    0.00450375f, 0.04066435f, 0.23008326f, 0.06778075f, 0.28378177f, -0.08871455f, -0.06032792f, -0.13666657f, 
    -0.05790248f, 0.06543516f, 0.06617979f, 0.19079567f, 0.03454931f, -0.07902921f, 0.11122242f, 0.13475192f, 
    0.04414413f, -0.04659334f, -0.00890907f, 0.04329419f, -0.01159709f, 0.02121971f, -0.03404744f, -0.02044827f, 
    0.01105727f, -0.00574359f, 0.00362086f, -0.03931107f, -0.02658683f, 0.00683555f, -0.01883258f, 0.00410207f, 
    0.00948330f, 0.02328526f, -0.03322232f, -0.00031959f, 0.03494209f, -0.04553609f, -0.04583855f, -0.03178567f, 
    0.04020717f, -0.00700994f, 0.04527677f, 0.02929651f, -0.05272860f, -0.01443331f, 0.03525180f, -0.00350075f, 
    0.03594867f, -0.04499574f, 0.04099942f, 0.02562002f, -0.01805874f, -0.03408451f, 0.00207415f, 0.01673673f, 
    -0.05337922f, -0.02420342f, 0.03749412f, -0.05521941f, 0.03626170f, -0.04378915f, -0.00725790f, 0.03032003f, 
    0.01099848f, -0.00954728f, 0.01443466f, 0.00636269f, -0.04357451f, -0.03407421f, 0.01303360f, -0.01904580f, 
    -0.02724681f, -0.04348570f, -0.03332195f, -0.02287985f, 0.04062217f, 0.00400597f, -0.04097603f, 0.00573413f, 
    0.03192742f, 0.04468015f, 0.04430927f, 0.03157501f, -0.03527529f, -0.02610055f, -0.05628973f, 0.03235670f, 
    -0.01489506f, 0.02093981f, -0.02027708f, -0.02342918f, -0.02403705f, 0.04877020f, -0.02989171f, -0.02188317f, 
    -0.00132781f, 0.02811855f, 0.00600585f, -0.03735771f, -0.02288202f, -0.01017585f, 0.00264348f, -0.04443551f, 
    -0.01984745f, -0.01085533f, 0.01175055f, -0.01906933f, -0.00758883f, -0.03240851f, -0.01596405f, -0.01184360f, 
    -0.04685307f, 0.03525865f, -0.03705432f, 0.03787482f, 0.00038910f, -0.03937009f, 0.03172136f, 0.02632132f, 
    0.03117429f, -0.02205868f, 0.02271706f, 0.03726579f, -0.01226118f, -0.00327974f, 0.04476359f, -0.04050661f, 
    0.00247297f, -0.04603785f, -0.03429723f, -0.01191290f, -0.03629783f, 0.04197493f, -0.02630886f, -0.00216697f, 
    -0.02345227f, -0.02097820f, -0.02698827f, 0.03989091f, 0.00994248f, -0.05545394f, -0.03526350f, 0.03223725f, 
    -0.00591963f, 0.03747920f, -0.03761412f, 0.02566425f, -0.01496943f, -0.02806323f, 0.03203356f, 0.04387792f, 
    -0.03448945f, -0.02403940f, 0.02612650f, 0.00341831f, -0.00177647f, -0.01986757f, -0.03424501f, 0.00117520f, 
    -0.00679790f, -0.04360074f, -0.01525346f, -0.00868218f, -0.00168748f, 0.02726950f, -0.01666064f, -0.03751029f, 
    -0.02415914f, 0.02840959f, -0.01533849f, 0.04457108f, 0.02467321f, 0.01181290f, -0.03959027f, 0.03187779f, 
    -0.04711938f, 0.01835339f, 0.01695155f, -0.01007143f, 0.03881199f, -0.00960797f, -0.04482005f, -0.04878748f, 
    0.01967561f, 0.00652993f, -0.02650071f, 0.01552873f, 0.02561473f, 0.00764828f, 0.04100309f, -0.01522360f, 
    0.00066183f, 0.03171365f, 0.03408827f, 0.02179975f, -0.00624769f, -0.00594959f, 0.03406962f, 0.00002965f, 
    0.01731752f, -0.00752192f, 0.01059794f, 0.04432942f, -0.01746749f, 0.04501454f, -0.04700971f, -0.02605328f, 
    0.00657391f, 0.01126554f, 0.03902070f, 0.02068133f, -0.00479842f, -0.03917428f, -0.03405534f, -0.04344210f, 
    -0.02421860f, -0.00369430f, 0.04105376f, -0.02221384f, -0.01791611f, -0.04148427f, 0.00996511f, 0.02955514f, 
    -0.01055791f, -0.03198205f, 0.01339599f, 0.03409738f, 0.00069558f, 0.03968026f, 0.02545212f, 0.03132158f, 
    0.00361411f, 0.04161769f, 0.00853255f, -0.02856845f, -0.05271568f, 0.00825607f, -0.02710596f, 0.04360518f, 
    -0.01550782f, 0.01146795f, -0.00776195f, 0.01226234f, -0.00445482f, -0.01668514f, 0.00957302f, 0.00321022f, 
    -0.02804648f, 0.01638704f, -0.02831324f, -0.03187422f, -0.04741654f, -0.00948824f, 0.00626228f, 0.01394648f, 
    -0.03913974f, 0.04141117f, -0.04108533f, 0.01418946f, 0.03453793f, 0.03871703f, -0.05551834f, -0.03208194f, 
    0.04147372f, -0.04835070f, 0.03136051f, -0.00053613f, 0.01266536f, 0.00809060f, 0.02686075f, -0.05035906f, 
    -0.01030757f, -0.03396192f, 0.01776238f, 0.02814133f, -0.01647063f, -0.04128138f, -0.05303818f, -0.01449347f, 
    -0.04381732f, -0.04564318f, 0.01716947f, -0.03289755f, 0.02469594f, 0.04429585f, -0.02121854f, -0.00662957f, 
    0.00156458f, -0.04135496f, 0.00353526f, -0.04269534f, -0.03869180f, -0.05088117f, 0.01112710f, -0.03147549f, 
    0.02015934f, 0.02998647f, 0.03513207f, -0.02964881f, -0.01771816f, -0.02265941f, -0.02418009f, -0.01889502f, 
    0.00401517f, -0.00883061f, -0.01000742f, 0.00248178f, -0.02850566f, 0.00119041f, -0.00070277f, -0.05126645f, 
    -0.02281241f, 0.03728231f, 0.01378235f, 0.01141488f, -0.03014810f, -0.00740260f, -0.02188065f, -0.00244546f, 
    -0.02011184f, 0.00987661f, 0.01370255f, -0.02354911f, -0.05605384f, -0.02706898f, 0.00858574f, -0.03601356f, 
    0.02942392f, -0.00178481f, -0.02465138f, -0.00048736f, -0.03183157f, 0.03173967f, 0.00555240f, -0.04016026f, 
    0.03405150f, 0.02882279f, 0.02615992f, -0.02590188f, -0.01684018f, 0.02668981f, -0.02321692f, 0.02503159f, 
    -0.05366621f, -0.00699493f, -0.01950001f, 0.03626995f, 0.00822506f, -0.05066397f, 0.00298459f, 0.02196804f, 
    -0.03602036f, -0.02742267f, 0.00527341f, 0.04425934f, -0.05512062f, -0.03672113f, -0.05267985f, -0.03416043f, 
    0.00774377f, -0.01875865f, -0.05650650f, -0.01652159f, 0.03826363f, 0.00972935f, -0.02028906f, -0.02762948f, 
    -0.01832071f, -0.00551484f, 0.02166090f, -0.01648087f, 0.00524182f, 0.00967504f, -0.03839106f, 0.02904544f, 
    0.00068362f, -0.00821562f, -0.04346558f, 0.03877714f, 0.02869523f, 0.04135459f, 0.00631123f, -0.05025677f, 
    0.00926255f, -0.02280976f, -0.02127120f, 0.02956926f, 0.01240263f, 0.01247970f, 0.00883785f, 0.00930621f, 
    -0.02025150f, 0.04049692f, -0.03506332f, 0.01804115f, 0.02710059f, -0.01370737f, 0.00528466f, 0.00690035f, 
    0.03109790f, -0.04764285f, -0.13912448f, -0.17552036f, -0.00949871f, -0.05836980f, 0.11935395f, -0.07875789f, 
    -0.06776796f, 0.10922161f, 0.05114969f, 0.02469770f, 0.00855537f, -0.28416321f, 0.11725765f, -0.10067988f, 
    -0.13297528f, 0.09374226f, -0.14877065f, -0.14181086f, 0.13944721f, 0.02352161f, -0.05363184f, -0.18559682f, 
    0.29674232f, 0.19636850f, 0.04172338f, 0.35736874f, -0.13694879f, -0.18372078f, -0.17414251f, -0.21304101f, 
    0.14658222f, -0.11227644f, 0.06738770f, 0.06366596f, 0.05456499f, 0.09139671f, 0.39441815f, 0.43367964f, 
    0.13436137f, -0.01695509f, 0.27920839f, 0.03580778f, 0.04046787f, 0.02256932f, 0.04478973f, 0.03781294f, 
    -0.00570230f, 0.19878025f, -0.08863641f, 0.20738904f, -0.04309343f, -0.03047807f, -0.11734279f, -0.00231703f, 
    0.22665603f, -0.04130532f, -0.08708622f, 0.10872274f, -0.10123530f, 0.05934978f, -0.24081083f, 0.25742000f, 
    -0.08697916f, -0.04835969f, 0.05563876f, -0.17520499f, 0.01748254f, 0.05476536f, -0.04723058f, 0.00277980f, 
    0.06680001f, 0.00237306f, -0.29999837f, -0.22626778f, 0.04154154f, -0.16766456f, -0.03158760f, 0.22962886f, 
    0.01247289f, -0.10737388f, 0.02842877f, 0.01600604f, 0.23731776f, -0.06291540f, 0.11932582f, -0.18728819f, 
    -0.10055790f, 0.16365150f, -0.10177571f, -0.05077962f, -0.07297527f, 0.04322259f, -0.11036500f, -0.25560227f, 
    0.08361933f, -0.06292786f, -0.27670369f, -0.02405895f, 0.10181195f, 0.04157749f, 0.14093649f, 0.04309561f, 
    0.19899742f, -0.01615413f, 0.07028899f, 0.02106323f, 0.01932949f, -0.13248011f, 0.00442748f, -0.00706627f, 
    -0.05790653f, 0.13682474f, 0.01268064f, -0.13569233f, 0.02986959f, -0.12074263f, 0.00409195f, 0.08819016f, 
    0.34758237f, -0.06031622f, 0.03423402f, 0.40868148f, -0.01550150f, -0.01190713f, 0.06547836f, -0.08201489f, 
    -0.03432189f, -0.06408801f, -0.05294326f, 0.08227821f, -0.01390901f, 0.22362971f, 0.34279332f, -0.01647172f, 
    0.09227512f, -0.04613458f, 0.05119685f, 0.00557299f, 0.06959587f, 0.01441234f, -0.18834499f, 0.00907733f, 
    -0.35806555f, 0.03049615f, -0.01816831f, -0.05052951f, -0.00524909f, -0.02279699f, 0.12427139f, 0.10198862f, 
    0.02613220f, -0.02695117f, 0.13819738f, 0.08970372f, 0.10756875f, 0.06603510f, 0.42895052f, 0.30241197f, 
    -0.02244543f, 0.07678276f, -0.00462196f, -0.13421085f, 0.12589839f, 0.11020121f, 0.04268859f, 0.08219699f, 
    -0.12733552f, -0.09228790f, 0.06481241f, -0.03891477f, 0.05822309f, 0.04006333f, 0.08368518f, 0.02437418f, 
    -0.10009456f, 0.09038278f, -0.28139558f, -0.01893307f, -0.02266355f, 0.64251572f, -0.64166576f, 0.42342156f, 
    0.13835867f, 0.06104368f, 0.25532714f, 0.19905908f, -0.10700431f, -0.06478012f, -0.12077751f, -0.15631111f, 
    -0.01102346f, -0.39349440f, 0.17118251f, -0.37093216f, 0.09202933f, 0.08539478f, -0.00222843f, 0.14314806f, 
    -0.07990796f, 0.01957655f, -0.01251964f, -0.01482517f, -0.04996974f, 0.13173650f, -0.04106158f, -0.13349223f, 
    -0.00550413f, 0.08958510f, 0.11776128f, -0.05239530f, -0.00150600f, -0.02271121f, 0.08823506f, 0.01569942f, 
    0.49756989f, -0.29298136f, 0.19083297f, -0.38617551f, 0.16198577f, -0.04704886f, 0.00067834f, 0.21245709f, 
    -0.03579315f, -0.03377424f, -0.11944133f, -0.15067950f, 0.10520663f, 0.15841578f, 0.09404711f, 0.10828037f, 
    -0.03235033f, -0.07827925f, -0.08507740f, -0.18977349f, 0.18037677f, -0.06869331f, 0.11525740f, -0.10518182f, 
    -0.17226951f, -0.11738525f, 0.21517631f, -0.03980920f, 0.00875594f, 0.01291422f, -0.02143897f, -0.01701423f, 
    -0.02902165f, -0.11691733f, 0.07110015f, -0.11297461f, 0.39489105f, 0.27119404f, -0.20739448f, -0.00816502f, 
    -0.19570598f, -0.30802804f, -0.00082488f, -0.13233286f, 0.13018912f, -0.03181968f, -0.07088045f, 0.00739064f, 
    -0.16426331f, -0.32400253f, -0.06424715f, -0.06191809f, -0.11748677f, 0.01490334f, -0.13258027f, -0.03278354f, 
    0.12545894f, 0.01188125f, 0.03284474f, 0.06287472f, 0.12855512f, -0.07116586f, 0.14292537f, 0.00653214f, 
    -0.05649687f, 0.07122427f, -0.25704932f, 0.05419615f, -0.13391174f, -0.04831469f, -0.08430590f, -0.09535792f, 
    -0.18187952f, 0.41342095f, -0.11506159f, -0.33658260f, -0.23165698f, 0.07905842f, 0.12121248f, -0.03850143f, 
    0.17158969f, -0.06946141f, -0.05506834f, -0.11298759f, -0.02736142f, -0.53811961f, 0.20942421f, 0.00643585f, 
    0.03202482f, -0.13384545f, -0.09685352f, 0.19290441f, 0.02091263f, -0.04610195f, 0.10869898f, 0.00687332f, 
    -0.02474498f, -0.07410505f, -0.08149312f, 0.06548128f, -0.02668576f, -0.09152133f, 0.06200499f, 0.12041033f, 
    0.15614307f, 0.01936783f, 0.09284081f, 0.21176703f, -0.02884545f, 0.21481776f, 0.14480735f, 0.30779663f, 
    -0.07358585f, 0.16207425f, 0.07918825f, 0.23581608f, 0.00787061f, 0.04462884f, -0.00220741f, 0.03363496f, 
    0.11576909f, -0.28722200f, 0.14624822f, -0.17470071f, 0.04941328f, 0.15808828f, -0.06596026f, 0.04221433f, 
    0.06772939f, 0.07297136f, -0.01138417f, 0.10678755f, 0.07861575f, 0.03608971f, 0.03550778f, 0.24239022f, 
    0.02438051f, 0.13038543f, 0.02269645f, 0.10829736f, 0.08142263f, 0.14937338f, -0.09872064f, -0.03276222f, 
    0.05662345f, 0.26997930f, 0.17907244f, 0.09850366f, -0.19774485f, 0.13320734f, 0.13932435f, 0.02360879f, 
    0.07781351f, 0.17340374f, -0.06601445f, 0.01596629f, -0.01282684f, -0.43044111f, -0.03959968f, -0.32390451f, 
    -0.04331958f, -0.06567846f, -0.06834538f, 0.16126120f, -0.05604499f, 0.09787554f, 0.04398432f, -0.01475356f, 
    -0.14951977f, -0.20965326f, -0.23535272f, -0.07406291f, -0.01297882f, 0.05916530f, 0.07800841f, -0.01199179f, 
    -0.03263156f, 0.07070985f, 0.14201541f, 0.06445000f, -0.24653336f, -0.17453060f, -0.15924774f, -0.04621348f, 
    -0.05901500f, 0.07115392f, 0.02915055f, 0.07120700f, 0.01493398f, 0.03860876f, 0.09355685f, 0.09037314f, 
    0.08792987f, -0.04774582f, -0.18876007f, 0.01557365f, 0.03751606f, 0.03201556f, 0.02192816f, 0.06527069f, 
    -0.22273208f, -0.01994424f, 0.06218616f, -0.01705748f, 0.22215937f, 0.14186943f, 0.04764875f, 0.02034414f, 
    -0.04049473f, 0.01081726f, -0.00773809f, 0.15325722f, 0.04316932f, -0.04715040f, -0.08773755f, -0.08033586f, 
    -0.29221368f, -0.21415406f, -0.05537700f, -0.01502616f, 0.07058889f, -0.07103832f, 0.01015446f, -0.01883577f, 
    -0.09814336f, -0.12097963f, 0.03394169f, 0.02633664f, -0.47095808f, -0.17413642f, 0.17880420f, -0.21257460f, 
    -0.01137687f, -0.03668281f, 0.00070258f, 0.10377841f, 0.09676316f, 0.04347888f, 0.01270471f, 0.16177629f, 
    0.25415063f, 0.05912459f, -0.00673558f, -0.00712597f, 0.06573335f, -0.00855954f, -0.05769427f, -0.09571786f, 
    -0.20481773f, 0.06956666f, 0.00648832f, -0.00824255f, -0.06647586f, -0.12242067f, 0.00917278f, 0.03007158f, 
    0.08797473f, 0.06890517f, 0.02457853f, 0.08071718f, 0.05590199f, 0.01986555f, 0.07431971f, 0.17514862f, 
    -0.30748841f, -0.25694114f, -0.32132453f, -0.10955470f, 0.04050572f, 0.02157372f, 0.07837354f, -0.00213049f, 
    0.04448060f, 0.08069352f, 0.11375990f, 0.11314158f, -0.41001126f, -0.23333396f, -0.14512815f, -0.21121462f, 
    -0.04761591f, -0.13634926f, 0.07900563f, 0.05536191f, 0.13401616f, 0.02448050f, 0.01803260f, 0.06058842f, 
    0.09327170f, -0.22705558f, -0.20789638f, 0.08095921f, 0.05208557f, 0.06936787f, -0.00969908f, 0.03322339f, 
    -0.04528788f, -0.03944922f, 0.03886170f, 0.09190331f, 0.20371588f, 0.32183352f, 0.08616355f, 0.09845183f, 
    -0.06707710f, 0.13369742f, 0.09127630f, -0.00808665f, -0.02046026f, 0.03267761f, 0.00971521f, -0.04165881f, 
    0.07795724f, 0.24801297f, 0.10806162f, 0.03938646f, 0.08843545f, 0.10017738f, 0.05157590f, 0.17081913f, 
    -0.00750220f, -0.06866995f, 0.08107772f, 0.05139360f, 0.11708071f, 0.27332669f, 0.16001837f, 0.21071711f, 
    -0.11379351f, 0.05821498f, 0.05966228f, -0.03184180f, -0.03273439f, -0.03961269f, 0.04551328f, 0.07353409f, 
    0.09844460f, 0.33233684f, 0.37973604f, 0.08745184f, 0.03106702f, -0.06088817f, -0.08844613f, 0.15271963f, 
    0.03703388f, 0.02021465f, -0.02573142f, -0.03778303f, 0.01927021f, -0.03347342f, -0.10645457f, 0.03642690f, 
    -0.12353401f, -0.14897892f, -0.20041688f, -0.09524737f, -0.01831798f, 0.08458024f, 0.01774272f, 0.06271711f, 
    -0.11413866f, -0.02650576f, 0.07147403f, -0.11814601f, -0.00311717f, 0.07229026f, 0.05473711f, 0.21486829f, 
    0.15543260f, 0.05887311f, -0.05297084f, -0.02837645f, -0.17522660f, -0.00162603f, 0.02997366f, -0.07835726f, 
    -0.03071203f, -0.05017786f, -0.00496527f, -0.14100203f, -0.13104850f, 0.07414694f, 0.11745018f, -0.03713291f, 
    0.10388378f, -0.18837282f, -0.07779678f, -0.16286185f, -0.05695386f, -0.10868725f, 0.03646115f, 0.23600368f, 
    0.00982574f, 0.02505152f, 0.09168680f, 0.02559850f, -0.06125439f, 0.26800501f, 0.15715198f, -0.07375015f, 
    0.06156066f, 0.06713756f, 0.02520728f, 0.03410044f, 0.03212459f, -0.08793341f, -0.13421690f, -0.07592649f, 
    -0.34615853f, -0.28600767f, 0.20325066f, -0.09914544f, -0.04847115f, 0.02763381f, 0.09478160f, 0.10479142f, 
    -0.03153564f, -0.04091400f, 0.05067531f, 0.24884024f, 0.13521270f, 0.18761796f, 0.03063941f, 0.14955610f, 
    0.10801674f, 0.04601571f, 0.24780813f, 0.13416576f, -0.12355234f, -0.00079168f, -0.02889412f, 0.04480503f, 
    0.20951481f, 0.13529144f, -0.02188800f, 0.07035676f, -0.14705044f, 0.00112366f, 0.03063353f, -0.07586511f, 
    -0.01642060f, -0.01902476f, 0.04656285f, 0.05421865f, 0.03115869f, 0.01086843f, -0.01494265f, 0.02896108f, 
    -0.20979573f, 0.02783020f, 0.03681581f, 0.01486309f, 0.05735305f, -0.00676795f, 0.15782180f, 0.09114584f, 
    0.18223290f, 0.25232539f, 0.02707089f, 0.00498604f, -0.14376496f, -0.00519519f, 0.05532200f, 0.18325573f, 
    -0.00888962f, -0.20952900f, -0.05439571f, -0.00782530f, 0.35004097f, -0.17892180f, -0.31457070f, 0.11340560f, 
    0.08026385f, 0.04427242f, 0.01341715f, -0.08774465f, -0.00315504f, 0.10626929f, 0.13370942f, -0.08171445f, 
    -0.44734228f, -0.44011250f, -0.12807216f, -0.02093242f, -0.00118928f, -0.00157809f, 0.03921618f, 0.00906101f, 
    0.12712930f, 0.14616269f, 0.18601520f, 0.04770643f, 0.17753755f, 0.24585430f, 0.13713776f, -0.05446900f, 
    0.02124796f, 0.00692619f, 0.10371473f, 0.16487303f, -0.06598944f, -0.04625037f, -0.02226454f, -0.05227495f, 
    -0.26890343f, -0.29536948f, -0.11681585f, -0.06478363f, -0.05774782f, -0.01128600f, -0.00922802f, 0.04269680f, 
    -0.10436571f, 0.10066028f, -0.12228154f, -0.03048981f, 0.15186031f, 0.07657616f, -0.02615027f, 0.03503427f, 
    -0.09508766f, -0.05365344f, -0.14332689f, -0.06443367f, -0.18303280f, -0.02196201f, -0.12353427f, -0.03466886f, 
    0.07157461f, 0.14196344f, 0.12724541f, -0.16142128f, -0.07003765f, 0.02737311f, -0.02407892f, 0.02353217f, 
    -0.06351858f, -0.02627057f, -0.02229227f, -0.13389723f, 0.22887178f, -0.04719690f, -0.09362098f, -0.09926342f, 
    0.11317478f, 0.03748857f, -0.17890157f, -0.18444902f, -0.00242715f, 0.03008142f, -0.00215756f, 0.02659170f, 
    -0.02010377f, -0.02258923f, -0.04115938f, -0.01368389f, -0.04619121f, 0.03502317f, 0.01201893f, 0.03784749f, 
    0.01654970f, -0.04965005f, 0.02445529f, -0.04908300f, -0.05331429f, 0.02211880f, 0.01151275f, -0.05233711f, 
    0.02895411f, -0.03618028f, -0.02858615f, -0.00832092f, 0.03767752f, -0.02852617f, -0.05446230f, 0.00978835f, 
    0.02450075f, 0.02105460f, -0.01462188f, -0.00900682f, -0.04631929f, 0.03024632f, 0.00619684f, 0.00486610f, 
    -0.04668402f, 0.00137426f, 0.01970365f, 0.04539567f, -0.04822645f, 0.01210194f, 0.01574727f, 0.02079380f, 
    -0.04327988f, -0.03770293f, 0.02054318f, -0.05645050f, 0.04551855f, -0.02402745f, 0.02739191f, 0.03141221f, 
    -0.02766581f, -0.03261578f, 0.02142859f, 0.01651013f, -0.03506181f, 0.00413426f, 0.03257146f, 0.04258769f, 
    0.01507915f, 0.00771139f, -0.03158527f, -0.04874862f, 0.00066001f, -0.02199140f, 0.02712285f, -0.04814833f, 
    0.04033116f, 0.04335503f, -0.00386869f, -0.01409077f, -0.02862198f, -0.05592547f, -0.00948669f, -0.01044282f, 
    0.01690105f, -0.01487331f, -0.03868974f, 0.04097177f, -0.01697639f, 0.00395381f, 0.03926356f, 0.03142984f, 
    -0.01318692f, 0.02113098f, 0.02256889f, -0.02678896f, 0.02868810f, 0.01869141f, -0.01025774f, 0.00011905f, 
    0.02034759f, -0.00429621f, -0.00413722f, 0.03272649f, -0.01561964f, 0.02884231f, -0.04912740f, -0.01728806f, 
    0.04376696f, 0.00473431f, -0.02615834f, 0.00421125f, 0.00232703f, 0.02072432f, -0.01634812f, 0.03844544f, 
    -0.01367725f, -0.05004195f, -0.00102589f, -0.05021727f, -0.05224666f, -0.03217400f, -0.04804218f, -0.03495619f, 
    -0.03196501f, -0.02299731f, -0.01355756f, -0.02876492f, 0.01710246f, -0.02502097f, -0.04272791f, -0.00759871f, 
    0.00409300f, -0.05263886f, -0.03678129f, -0.00623129f, -0.04307534f, 0.00630172f, 0.04262920f, -0.01627155f, 
    -0.03178750f, 0.02803615f, 0.02346791f, 0.02198265f, -0.02446415f, 0.03019206f, -0.05501073f, -0.02948119f, 
    0.01388445f, 0.02615125f, 0.03513547f, -0.05360791f, 0.01162580f, -0.01291343f, 0.03747858f, 0.02832299f, 
    -0.00083287f, -0.05344728f, -0.04108529f, -0.01158067f, 0.04617018f, -0.01682283f, 0.04673900f, -0.02578361f, 
    -0.02032992f, -0.02143705f, 0.00950905f, 0.05362355f, 0.02475601f, 0.03726451f, 0.00884820f, -0.05330960f, 
    0.04258569f, -0.00522639f, 0.01280844f, -0.02504187f, -0.02163513f, -0.04501781f, -0.03187201f, -0.05338867f, 
    -0.03263852f, 0.01288588f, -0.03463470f, -0.01228194f, -0.04911518f, -0.04467496f, 0.03214243f, -0.01969426f, 
    0.01313772f, -0.05652809f, -0.00235780f, -0.01657515f, -0.02966329f, -0.00773533f, 0.03847568f, 0.02903792f, 
    0.01060438f, -0.00608741f, -0.00064979f, 0.03465426f, 0.03197650f, -0.03546780f, -0.05476705f, 0.00914351f, 
    -0.04871792f, 0.00998270f, 0.01948751f, 0.03290112f, -0.02482476f, 0.03778632f, -0.05395111f, 0.02058360f, 
    -0.02372140f, -0.05418417f, 0.00916237f, 0.01142137f, -0.01914477f, 0.00261045f, -0.04190665f, -0.04151472f, 
    -0.05013184f, -0.02012612f, 0.03860718f, 0.04348382f, 0.04393496f, 0.02399011f, 0.01610070f, -0.00952445f, 
    -0.04956418f, -0.01016251f, -0.00737559f, 0.02423667f, -0.02196635f, -0.01639100f, 0.01917889f, -0.00749812f, 
    -0.03739699f, -0.04641923f, -0.00121861f, -0.04680841f, -0.01157913f, -0.05438018f, 0.03594384f, 0.04378587f, 
    0.01685491f, -0.04732600f, -0.01747748f, -0.02287209f, -0.04233639f, 0.03229449f, 0.04267084f, -0.01894183f, 
    0.00515568f, 0.02139065f, 0.04404889f, 0.02595013f, -0.02904057f, -0.04942390f, 0.02346394f, -0.04294750f, 
    0.03867397f, -0.01864127f, -0.04560998f, -0.04552049f, -0.00969736f, -0.02729294f, -0.01845473f, -0.03350719f, 
    -0.05590959f, -0.04065159f, -0.00588644f, 0.01138195f, 0.01491321f, -0.01638933f, 0.03727142f, -0.03394028f, 
    -0.04503724f, -0.01197745f, -0.01873777f, -0.00463359f, 0.02819485f, -0.00538225f, -0.02270216f, -0.05286272f, 
    -0.04799137f, -0.03577571f, -0.01146160f, 0.02441752f, -0.01192970f, 0.01564437f, 0.03361294f, -0.03952467f, 
    0.00947510f, 0.00387579f, -0.05660911f, -0.02210000f, 0.00697326f, 0.01282519f, -0.01688813f, -0.01459437f, 
    0.02095462f, -0.00303996f, -0.03072066f, 0.01593550f, 0.03083161f, 0.01449537f, -0.03162219f, 0.03182907f, 
    -0.04799400f, 0.04038702f, -0.04316668f, -0.03518188f, -0.00819190f, 0.04421531f, -0.01311949f, 0.00870955f, 
    -0.01868665f, -0.05593681f, 0.03492984f, -0.01942150f, -0.00790733f, 0.02655721f, -0.05527619f, 0.03483363f, 
    -0.04675639f, 0.01767903f, -0.01938409f, -0.02786910f, 0.00063925f, 0.02214302f, -0.01507021f, 0.03861045f, 
    -0.00534407f, -0.03381917f, 0.04075515f, 0.02284140f, 0.02117860f, -0.05879224f, 0.01864643f, -0.01675981f, 
    0.02478145f, 0.01107961f, -0.01603175f, 0.02292622f, 0.03916413f, 0.02467946f, 0.04320267f, -0.00386569f, 
    0.02024258f, -0.03489668f, 0.03410797f, 0.01587290f, -0.02142033f, -0.05339330f, -0.02749720f, -0.04867788f, 
    -0.00804248f, -0.05529475f, -0.01780003f, -0.02161400f, 0.04369771f, -0.02402011f, 0.00092178f, -0.05095347f, 
    -0.01111426f, -0.03534802f, -0.02569488f, -0.02459021f, 0.00076984f, -0.00653739f, -0.03622950f, 0.01805102f, 
    0.01869476f, -0.00724526f, 0.02609020f, -0.00466170f, -0.00010285f, -0.01277990f, 0.00063164f, -0.01693995f, 
    0.03122692f, -0.03813565f, 0.02006264f, 0.03065982f, -0.03514633f, 0.00326541f, 0.03458574f, 0.01892493f, 
    -0.01784975f, 0.02199661f, -0.04830081f, 0.01658845f, 0.02873085f, -0.00231164f, 0.02101940f, -0.04750945f, 
    -0.14582792f, -0.32851031f, -0.17356338f, -0.13880849f, 0.07657420f, -0.06107257f, 0.04680242f, -0.06388218f, 
    0.07466997f, -0.05476058f, -0.02500094f, -0.02044054f, -0.11665829f, -0.31936330f, -0.17118280f, -0.05821349f, 
    0.07610773f, 0.02107416f, -0.07231297f, 0.02222437f, -0.17262237f, 0.00229322f, -0.13247541f, 0.02512494f, 
    0.05664419f, -0.03068333f, -0.02607936f, 0.08018266f, -0.00591712f, -0.01034455f, -0.00673970f, -0.11563737f, 
    -0.09136517f, -0.13519013f, 0.01761686f, -0.02558619f, 0.09377968f, 0.15822987f, 0.15673199f, 0.26637635f, 
    0.02620077f, -0.05857579f, 0.07664906f, 0.03419660f, 0.12934549f, -0.00863736f, 0.05800595f, -0.06226800f, 
    -0.10411604f, 0.01711084f, -0.04182057f, 0.03586321f, 0.06392697f, -0.00968123f, -0.11397082f, 0.02825319f, 
    0.16410613f, 0.06262843f, -0.01902498f, 0.16262203f, -0.55047232f, -0.17633994f, -0.11081477f, 0.32060373f, 
    -0.02198760f, -0.00118588f, -0.09620500f, -0.03623696f, 0.04499455f, -0.13373967f, -0.08798246f, -0.01280413f, 
    0.12435687f, 0.15503576f, 0.25126970f, 0.10539284f, -0.04016102f, 0.04062844f, 0.18387969f, -0.05934044f, 
    -0.05957782f, -0.09123104f, -0.00494030f, 0.07069290f, -0.06521913f, -0.21511896f, -0.08083841f, -0.10957269f, 
    0.07216421f, 0.04344081f, -0.08943050f, 0.03570433f, -0.10899848f, -0.02858417f, -0.11349189f, -0.17564648f, 
    -0.28809661f, -0.30427608f, -0.34970877f, -0.12070765f, 0.06920122f, 0.11128453f, 0.02263351f, -0.06477136f, 
    0.11712111f, 0.02121640f, 0.05561483f, 0.02838041f, -0.07336773f, -0.21839651f, -0.28556985f, 0.19745213f, 
    0.10262220f, -0.06152867f, -0.18551324f, -0.02542417f, 0.14344634f, -0.02467900f, 0.07274966f, -0.00274900f, 
    0.09060104f, -0.12583339f, -0.07124640f, -0.18302950f, 0.20771940f, 0.20459731f, 0.06596377f, 0.01232959f, 
    -0.00586156f, -0.15373760f, 0.00155957f, -0.10165456f, 0.16741246f, 0.13459782f, 0.07945736f, 0.01391871f, 
    0.02320316f, 0.15752827f, 0.17560396f, 0.21176887f, 0.14851917f, -0.08176411f, -0.27762905f, -0.04009398f, 
    -0.06154158f, 0.19247775f, 0.23643604f, 0.14967571f, 0.01873924f, 0.01879044f, 0.03206670f, 0.08579434f, 
    0.08263516f, 0.08307117f, 0.14938541f, 0.15617636f, 0.09850655f, -0.20783778f, 0.19495364f, 0.11432043f, 
    -0.20863540f, -0.04847351f, 0.05591743f, -0.11092030f, 0.15841234f, 0.09307587f, 0.08063566f, 0.05341064f, 
    -0.17822593f, 0.00249456f, 0.16553390f, 0.07843503f, 0.06106823f, 0.05366579f, 0.03183462f, 0.04925285f, 
    0.10435405f, -0.00798752f, -0.11950693f, -0.15665527f, -0.01588424f, 0.11815442f, -0.33844119f, 0.05114037f, 
    0.08132271f, -0.03443693f, 0.20690843f, -0.02589302f, 0.12820908f, -0.04580473f, -0.01891466f, -0.15342261f, 
    0.08670232f, -0.34650430f, -0.00040722f, -0.02464877f, 0.03126113f, -0.13501883f, -0.05859934f, 0.13872999f, 
    0.30890551f, -0.12049617f, -0.09098591f, 0.07633071f, -0.08426023f, 0.01994077f, -0.32151410f, -0.22442321f, 
    0.03980590f, 0.09442853f, -0.07475499f, -0.05179961f, 0.11332564f, 0.05981899f, 0.10410976f, 0.07949369f, 
    0.16647916f, -0.16561767f, 0.19268948f, -0.12144239f, 0.06579673f, -0.03014124f, 0.11518325f, 0.16702060f, 
    0.03916977f, 0.00692465f, -0.01075685f, -0.08345667f, 0.15775366f, 0.08794329f, -0.00403302f, 0.09640284f, 
    0.07281484f, -0.03042830f, 0.03906989f, 0.00309568f, 0.02704939f, -0.11752885f, -0.13161793f, -0.04988807f, 
    -0.21720777f, -0.13280676f, -0.03893035f, -0.04535346f, 0.02639517f, 0.01503052f, -0.06355330f, 0.02941712f, 
    -0.06981206f, -0.06337210f, 0.02084411f, 0.04343328f, 0.26510039f, 0.32070386f, 0.20252877f, 0.24154258f, 
    0.00443728f, -0.03035639f, 0.10857149f, 0.04247021f, 0.13596798f, -0.05590048f, 0.09537269f, 0.14012110f, 
    0.08962932f, -0.24384712f, 0.27657512f, 0.03390500f, -0.16549070f, 0.02444515f, 0.03057859f, 0.10256460f, 
    0.07542052f, 0.02735988f, 0.11237005f, 0.10766205f, 0.15350650f, -0.10249313f, 0.14898963f, 0.03577159f, 
    0.11539944f, 0.00934967f, -0.04892394f, 0.15080318f, -0.09601157f, -0.14069515f, -0.05862271f, -0.24941176f, 
    0.10792483f, 0.32286915f, -0.05920998f, 0.08972181f, -0.04483023f, 0.04937741f, 0.11069693f, 0.13932543f, 
    0.15771329f, -0.18198000f, -0.00920570f, 0.00479428f, 0.06187232f, -0.03098789f, 0.22219129f, -0.11638470f, 
    0.09713118f, 0.00482704f, 0.04629748f, 0.00000129f, 0.06667915f, -0.15355518f, -0.02269738f, 0.10811665f, 
    -0.41907099f, -0.36917034f, -0.27494472f, -0.06420105f, 0.06886713f, -0.05019360f, -0.05829311f, -0.13198750f, 
    0.12824783f, -0.07681414f, 0.09406333f, 0.09148538f, 0.07256339f, 0.25856200f, 0.12430547f, 0.19557998f, 
    -0.01892513f, -0.10391238f, 0.07972827f, 0.18690823f, 0.00129368f, -0.02393461f, -0.01912900f, -0.17871065f, 
    -0.07297112f, -0.31462395f, -0.01438591f, -0.08398964f, -0.00205192f, -0.05288510f, -0.07058922f, 0.08067045f, 
    0.13591108f, -0.04583156f, -0.00733853f, 0.27561593f, 0.17805248f, 0.18493123f, 0.20856543f, 0.05802179f, 
    0.02701611f, 0.09838350f, 0.04171732f, -0.00699663f, -0.03197721f, 0.01608606f, -0.06652671f, 0.10778795f, 
    0.10246706f, 0.22809966f, 0.25452164f, 0.09434091f, 0.06643636f, 0.07896684f, -0.01739081f, -0.02903565f, 
    0.10855740f, 0.00762975f, 0.09010434f, -0.06883913f, 0.16545285f, 0.10744604f, 0.21110937f, -0.01175043f, 
    0.10889956f, 0.03838015f, -0.01390273f, -0.03738667f, -0.08432865f, 0.04650879f, 0.01344715f, -0.01141197f, 
    -0.01522823f, 0.11493307f, -0.14256431f, 0.08960596f, -0.03605437f, 0.06128136f, 0.12001937f, -0.03772395f, 
    -0.14926459f, 0.14989927f, -0.09797436f, 0.15966639f, 0.08167206f, 0.15040469f, 0.08923642f, -0.18369788f, 
    -0.05989201f, 0.10309446f, 0.05646931f, 0.02499095f, -0.02239737f, 0.12146628f, -0.18600725f, -0.05024948f, 
    -0.33998603f, -0.17366727f, -0.17443500f, 0.10558193f, -0.00228058f, 0.01490831f, -0.04185769f, 0.02009379f, 
    0.03174785f, 0.12336553f, -0.10781339f, 0.16723219f, -0.18824962f, -0.25242007f, -0.14331439f, 0.03736653f, 
    -0.20210755f, -0.02795449f, -0.05005848f, -0.03222653f, 0.08413702f, 0.09933621f, 0.20699689f, 0.08485422f, 
    0.04326060f, -0.23341954f, 0.22252926f, -0.02470959f, 0.06581870f, -0.03208434f, 0.00272149f, 0.13937606f, 
    0.04440566f, -0.07244132f, 0.01745777f, 0.16192514f, 0.02996035f, -0.03566820f, -0.19296324f, 0.02535261f, 
    0.10357200f, 0.06970663f, 0.08979076f, 0.00204582f, 0.00602819f, 0.05507798f, 0.19121262f, -0.00936363f, 
    -0.21785928f, 0.19492228f, 0.42958158f, 0.18423599f, -0.21402518f, -0.06210812f, 0.29396191f, 0.07839826f, 
    -0.03910586f, 0.02933222f, 0.09256151f, 0.04272144f, -0.20841891f, 0.04005002f, 0.01459303f, 0.00939546f, 
    0.04826020f, -0.10352388f, 0.05627444f, 0.07071889f, 0.12510033f, -0.06665429f, 0.09877179f, -0.19125396f, 
    0.20031735f, -0.02452816f, -0.11217549f, -0.05396787f, -0.08382042f, 0.07535224f, -0.00762715f, 0.02377051f, 
    -0.15201730f, 0.05496641f, 0.00351029f, 0.13157141f, 0.22383398f, 0.36251545f, -0.53787279f, -0.29025358f, 
    0.01328906f, 0.16959774f, 0.04426518f, -0.11555605f, -0.06530947f, -0.01557439f, 0.01155213f, 0.13215676f, 
    -0.39666235f, -0.10829130f, 0.41702241f, -0.01524080f, -0.09978985f, 0.00548410f, -0.03111181f, -0.01237688f, 
    -0.12296750f, -0.03056682f, 0.00409521f, -0.07104121f, 0.19680607f, -0.26483545f, -0.07745268f, 0.09570429f, 
    -0.03389546f, 0.22649610f, -0.28378808f, 0.25024539f, 0.03146095f, -0.02365400f, 0.00568317f, -0.16881627f, 
    0.02824056f, 0.13524520f, -0.06029599f, 0.00263424f, -0.01698257f, -0.23095855f, -0.09838672f, -0.15719745f, 
    0.15232359f, 0.21071883f, 0.27310303f, 0.16342792f, -0.27323055f, 0.06064610f, -0.13511640f, 0.29469645f, 
    -0.15471040f, -0.00838856f, 0.17030507f, 0.04256304f, 0.06730843f, -0.07595830f, -0.01252769f, -0.03739865f, 
    -0.10375683f, -0.05896542f, -0.02370303f, 0.21512716f, 0.12818705f, 0.13063455f, 0.34102657f, 0.11712895f, 
    0.00204388f, -0.07552248f, 0.02000289f, -0.14056434f, 0.07106157f, -0.36499867f, 0.28174683f, -0.28621480f, 
    0.22288680f, 0.01916752f, 0.10718956f, 0.13178329f, -0.04063463f, 0.03073449f, -0.00730133f, -0.13024728f, 
    -0.22416422f, 0.16217436f, -0.35360527f, -0.11592560f, 0.00328679f, 0.19588260f, 0.10394984f, 0.18586625f, 
    0.25514281f, 0.01869778f, -0.14385602f, -0.10308974f, 0.02759529f, 0.04253470f, -0.09895208f, 0.01939493f, 
    0.00297042f, 0.06081338f, 0.15039302f, 0.07665807f, -0.04749318f, 0.17215018f, -0.16272107f, -0.01982627f, 
    0.04716231f, 0.30301785f, -0.13801692f, -0.25057119f, 0.03902243f, 0.16634697f, 0.01400157f, 0.14779195f, 
    -0.07771687f, 0.04837956f, -0.00444249f, -0.06905865f, -0.48553202f, 0.18438205f, -0.38035044f, 0.31794518f, 
    0.11086374f, 0.02078127f, 0.09222985f, -0.11105374f, -0.04549087f, -0.17706715f, -0.18882997f, 0.11302436f, 
    0.04005098f, 0.24068427f, 0.09711275f, -0.16424654f, -0.05146176f, 0.01887699f, 0.04345782f, 0.09674469f, 
    0.00499073f, -0.10677807f, 0.06365072f, -0.02456006f, -0.19949041f, 0.46823144f, 0.17106289f, 0.56992596f, 
    -0.02388190f, -0.21366379f, 0.26727220f, -0.06354235f, -0.07952892f, 0.16201101f, -0.03692067f, 0.07165811f, 
    -0.28036481f, -0.12935814f, -0.30072334f, 0.23279035f, 0.20921218f, 0.17309067f, 0.15993048f, -0.17837910f, 
    0.20474370f, 0.22059041f, 0.29187167f, 0.05892697f, -0.27718443f, -0.21382360f, -0.31601492f, 0.07161196f, 
    -0.01060594f, 0.04010613f, 0.01452342f, 0.02337903f, -0.01853500f, -0.00932233f, 0.01790440f, -0.03702648f, 
    0.25035396f, 0.11696331f, 0.16186370f, 0.50611645f, -0.10389076f, -0.13170326f, 0.05802178f, -0.00038247f, 
    -0.03803964f, 0.05168096f, -0.11495336f, 0.05811416f, -0.13335624f, -0.00474495f, 0.55721992f, 0.30281556f, 
    -0.12709439f, 0.06856836f, 0.02770864f, 0.18866293f, -0.04526845f, 0.10975604f, -0.02878531f, -0.05164647f, 
    0.05434829f, 0.05553002f, 0.00347824f, -0.15438758f, -0.14532201f, 0.04010689f, -0.09996988f, -0.01714261f, 
    -0.06475756f, -0.12586319f, -0.03873778f, 0.10526409f, -0.08050238f, -0.04292031f, 0.14591029f, -0.04831747f, 
    -0.11051138f, -0.18836266f, 0.19452447f, 0.04853711f, 0.09147622f, 0.01536573f, 0.05448097f, 0.04200228f, 
    -0.15107556f, 0.12288576f, -0.23293561f, -0.03036575f, 0.02453405f, 0.01392431f, -0.11444155f, 0.04888208f, 
    0.02146725f, 0.12683576f, 0.01649307f, 0.13717413f, 0.00662826f, 0.02210837f, -0.06693956f, 0.21530250f, 
    0.14028101f, -0.02722253f, 0.19140266f, 0.16588266f, 0.02973784f, 0.19129226f, 0.04464710f, 0.28517374f, 
    -0.08839876f, 0.00158311f, -0.27518517f, 0.22488511f, 0.00072765f, -0.25738153f, 0.10372678f, 0.11955158f, 
    0.05007563f, 0.12525727f, 0.16196886f, 0.09793063f, 0.06992557f, 0.43419513f, 0.50849766f, 0.21938333f, 
    0.01017063f, 0.05067982f, 0.04103551f, -0.01329850f, -0.15248679f, 0.14475188f, -0.01744419f, 0.01272579f, 
    -0.00246531f, 0.03585157f, -0.05087683f, -0.02318877f, -0.04740556f, 0.01074342f, -0.05626950f, -0.05107386f, 
    -0.01485664f, -0.05267248f, 0.01749064f, -0.02516244f, 0.01090389f, -0.01318442f, -0.00786837f, -0.01015012f, 
    -0.00505048f, 0.02554544f, -0.03708596f, 0.02783547f, -0.01786358f, 0.02858484f, -0.00375719f, 0.00488567f, 
    -0.04211586f, 0.04010581f, 0.03989603f, -0.01853652f, 0.03655913f, -0.01256282f, -0.03562924f, -0.03962460f, 
    0.00865310f, 0.01178646f, 0.00695455f, 0.00808349f, 0.01839950f, 0.02006737f, -0.02755938f, -0.04013948f, 
    -0.03304605f, 0.01998247f, -0.04604110f, 0.02093634f, 0.02029448f, 0.00557917f, -0.02334563f, -0.01895656f, 
    -0.02251053f, -0.02913009f, -0.04410001f, -0.00150398f, -0.04634028f, -0.04256615f, -0.00738608f, -0.00053627f, 
    0.03546122f, -0.03137476f, -0.00563664f, -0.03328244f, 0.02434997f, 0.02529320f, 0.04413639f, 0.02058977f, 
    -0.00713540f, -0.00614185f, -0.00531361f, -0.00514527f, -0.01984322f, -0.03961498f, -0.02626884f, 0.03721993f, 
    -0.02823946f, -0.03355622f, -0.01544854f, -0.00110155f, 0.03255463f, 0.02149541f, -0.02510916f, -0.00909592f, 
    0.00816989f, 0.01775294f, 0.00167000f, 0.01587392f, 0.00791307f, -0.03261541f, -0.01833277f, -0.04568538f, 
    -0.03612665f, -0.04018337f, -0.01360847f, 0.02963718f, -0.02268185f, -0.04687081f, 0.00469687f, -0.02656393f, 
    0.00206554f, -0.02167421f, 0.02584406f, -0.05510275f, 0.02025398f, -0.04327315f, -0.05580545f, -0.02405759f, 
    -0.01632906f, 0.03316646f, 0.03099226f, 0.00461940f, 0.03070676f, -0.04481515f, 0.01614242f, -0.01035647f, 
    0.01713587f, 0.03187038f, 0.01875342f, -0.03744956f, 0.03953378f, 0.02643693f, -0.03916308f, -0.04840038f, 
    -0.02944212f, 0.01194441f, -0.01883204f, -0.05495030f, -0.00561247f, -0.05472147f, -0.01188274f, 0.00633871f, 
    -0.00749460f, -0.04086483f, -0.01051087f, -0.05159963f, -0.02506498f, 0.02028552f, 0.00426289f, -0.03751159f, 
    0.03849964f, -0.03423597f, 0.03565111f, -0.02906475f, 0.03577227f, -0.01804133f, -0.04938557f, -0.05727747f, 
    -0.01282426f, 0.01859011f, -0.00997532f, -0.03136235f, -0.00508556f, -0.03580114f, 0.02852660f, -0.02957173f, 
    -0.03596211f, 0.01413841f, -0.01203708f, 0.01583658f, -0.05523057f, 0.03681262f, -0.00476739f, 0.04007164f, 
    -0.03371925f, -0.02951490f, -0.04272834f, 0.01880936f, -0.03610237f, 0.00468318f, 0.00721887f, -0.04983311f, 
    -0.02019242f, -0.04313443f, 0.01460063f, -0.05708324f, -0.02207480f, 0.01810635f, -0.01144378f, 0.03821635f, 
    0.03353850f, 0.03487334f, -0.01959411f, -0.02484372f, -0.01448441f, 0.03777934f, -0.01655749f, -0.04968866f, 
    -0.00036910f, -0.00999011f, 0.00797430f, 0.00220116f, -0.04769589f, -0.02032342f, -0.00066710f, -0.05545846f, 
    0.03878040f, -0.04827113f, -0.01928249f, -0.03602815f, -0.00667797f, -0.05155202f, -0.04140874f, -0.03928601f, 
    -0.03669943f, 0.02532788f, 0.00450565f, 0.01710303f, 0.03804934f, -0.00912105f, 0.03131228f, -0.03478133f, 
    -0.01555067f, 0.02410209f, -0.03561291f, -0.02268727f, 0.04099929f, -0.03820563f, -0.02505537f, 0.03981955f, 
    -0.04938927f, -0.04220824f, 0.01358341f, -0.02974922f, -0.02036739f, 0.03847684f, 0.03122591f, -0.04921838f, 
    -0.05656355f, -0.03879720f, -0.05802975f, -0.01908016f, 0.01182132f, 0.03549432f, 0.00374764f, -0.01217940f, 
    -0.01993646f, 0.00136515f, -0.02502768f, -0.01119992f, -0.03723882f, 0.00002851f, 0.01100743f, -0.04654985f, 
    -0.03589758f, 0.02872866f, 0.02405908f, 0.03632787f, -0.03879777f, -0.00756254f, -0.04623678f, -0.04451850f, 
    0.02678983f, -0.01539023f, 0.03717685f, -0.03184054f, 0.02347066f, 0.04153392f, -0.00796707f, -0.04165506f, 
    -0.04505444f, 0.01757543f, 0.02314746f, -0.01332063f, -0.00272215f, 0.03338766f, -0.00778475f, 0.01394312f, 
    -0.04992573f, -0.01450858f, 0.00879485f, -0.00225520f, 0.02924722f, -0.00980821f, 0.02405031f, 0.01923203f, 
    -0.04801644f, -0.04003970f, -0.04955529f, -0.00402270f, 0.03395885f, 0.03454306f, -0.03927673f, 0.04502252f, 
    0.04065998f, 0.02151536f, -0.03361508f, 0.01837309f, -0.00073918f, -0.04703464f, 0.01660693f, -0.03131158f, 
    0.03554650f, 0.02647287f, 0.01805207f, 0.01040589f, 0.01183168f, -0.03401714f, -0.05049506f, 0.02845849f, 
    -0.01229946f, -0.03717306f, -0.02644452f, 0.03084992f, 0.02577806f, -0.00256348f, -0.03735795f, -0.05483666f, 
    -0.03538112f, -0.04787588f, -0.04993584f, -0.01657284f, -0.04960063f, 0.00376901f, 0.00660539f, -0.01205584f, 
    0.00394691f, -0.03052137f, -0.00737405f, -0.02321917f, 0.00633471f, 0.00654112f, 0.03528836f, -0.03560586f, 
    0.03253471f, 0.01769219f, 0.00535296f, -0.03885258f, -0.01504207f, 0.02087902f, 0.03457029f, -0.05598072f, 
    0.01770761f, -0.01554520f, 0.00574662f, -0.04149201f, 0.03735146f, 0.03284281f, 0.03220050f, 0.01013817f, 
    -0.02932415f, 0.02790331f, -0.05486881f, -0.00958465f, -0.03760400f, -0.04265753f, -0.03434000f, -0.05346595f, 
    -0.04751705f, 0.02044540f, -0.04866446f, -0.02204790f, 0.02198088f, 0.00753585f, -0.04963217f, -0.00203095f, 
    -0.05951250f, 0.02811288f, 0.02771178f, 0.02545563f, 0.01320847f, -0.03030341f, -0.05847549f, -0.02926010f, 
    -0.01499368f, -0.05880766f, 0.00651171f, -0.01896243f, 0.02399744f, 0.02976617f, 0.02547401f, -0.04780751f, 
    -0.02885178f, -0.00809171f, 0.01313291f, 0.03040208f, -0.00184377f, -0.04349189f, 0.03790121f, -0.00853284f, 
    -0.03281540f, -0.04366159f, -0.01694138f, -0.04093286f, 0.01218899f, 0.03184972f, -0.01502445f, 0.00335336f, 
    -0.04402472f, 0.01791662f, -0.01764939f, -0.04295343f, -0.02059644f, 0.02682375f, 0.00270615f, -0.00934513f, 
    -0.05137354f, 0.02103048f, -0.02122504f, -0.00260918f, 0.02960698f, -0.02154423f, -0.00729569f, -0.02609591f, 
    0.02941699f, 0.03673068f, 0.04544194f, -0.02764308f, 0.00507305f, -0.05122078f, -0.02182458f, -0.02474255f, 
    -0.02882998f, -0.00579403f, -0.03019807f, -0.03228287f, 0.03571039f, -0.02584848f, -0.02433437f, 0.02019023f, 
    -0.01411061f, -0.03486850f, -0.02339711f, -0.04057506f, 0.04936560f, 0.02902053f, 0.02874031f, -0.02468931f, 
    -0.01384717f, 0.04036992f, -0.04225763f, -0.02242229f, -0.04739239f, -0.00609907f, 0.02645598f, -0.05311626f, 
    0.02489052f, -0.03070155f, -0.05171153f, -0.00037188f, -0.02338613f, -0.03061455f, -0.01666551f, -0.03201713f, 
    0.00938813f, -0.00340228f, -0.02622198f, 0.03030732f, -0.01428746f, -0.05049044f, -0.03127498f, -0.04597826f, 
    -0.05776851f, -0.04143267f, 0.01184144f, -0.03979720f, 0.00857702f, 0.04193332f, -0.01941317f, -0.00444268f, 
    0.01703520f, -0.03717962f, 0.01575522f, -0.01186479f, 0.02142515f, 0.01481345f, -0.03737796f, -0.00476070f, 
    0.03154405f, 0.01490406f, 0.00340593f, -0.04855996f, 0.01142494f, -0.02035669f, -0.03664849f, -0.01499954f, 
    -0.02337224f, -0.00880713f, 0.00394334f, 0.00259437f, 0.00884718f, 0.00749243f, 0.03125285f, -0.00339251f, 
    0.02689402f, 0.03928922f, -0.03016545f, 0.03168332f, -0.01182865f, 0.00099377f, -0.05092987f, 0.02445550f, 
    -0.01405408f, 0.04228107f, 0.00896771f, -0.01538749f, 0.02170788f, -0.03296042f, -0.02693160f, 0.01779528f, 
    0.03077134f, -0.03741937f, -0.00517960f, 0.03920761f, 0.03008971f, 0.01772473f, 0.01354636f, 0.00151450f, 
    0.00698269f, 0.02189985f, -0.04295774f, -0.01693951f, 0.02995234f, -0.04948498f, 0.00311618f, -0.04119261f, 
    -0.05019290f, -0.01655936f, 0.01645209f, -0.03589483f, -0.01497581f, 0.04070620f, 0.02098050f, 0.04756147f, 
    -0.02008989f, 0.00717790f, -0.03238541f, 0.02038031f, -0.05238483f, -0.03455463f, -0.02738535f, -0.04935123f, 
    -0.03800403f, -0.03563353f, -0.02059760f, 0.00669017f, 0.03165172f, -0.04051324f, 0.02301168f, -0.03698418f, 
    -0.03583616f, -0.04706683f, 0.00921220f, 0.00133852f, 0.01840277f, 0.03413182f, 0.02224429f, -0.00927499f, 
    -0.00208397f, 0.02337802f, -0.02151930f, -0.04405110f, 0.02516410f, 0.04053465f, -0.00741732f, 0.02115860f, 
    -0.05842000f, 0.03895242f, -0.05617692f, -0.01021133f, -0.01367061f, 0.00992936f, -0.02708345f, 0.01483933f, 
    -0.01149288f, 0.04243938f, -0.05787705f, 0.00956711f, 0.02526433f, 0.01404692f, -0.03260160f, -0.05409669f, 
    -0.05531303f, 0.02551621f, 0.00236812f, 0.02406558f, -0.01574844f, 0.03566922f, -0.00840254f, -0.02048493f, 
    0.02855645f, -0.05841940f, -0.02277609f, 0.03826728f, 0.03020371f, -0.02451471f, -0.02812072f, 0.00109220f, 
    -0.04978651f, -0.04433597f, -0.05704977f, 0.03807683f, 0.03635108f, 0.02711140f, 0.02926800f, -0.00526455f, 
    0.04259166f, -0.01847472f, -0.04511381f, 0.04181698f, 0.03786021f, -0.04903718f, -0.04211373f, -0.01855000f, 
    -0.01604090f, 0.02092334f, 0.02796538f, 0.00356072f, 0.03853606f, -0.02218188f, -0.02456206f, 0.00403887f, 
    0.01801669f, -0.03875084f, -0.05225620f, -0.04052992f, 0.00849909f, 0.04202444f, 0.03434387f, -0.02784823f, 
    0.01495230f, 0.04048806f, 0.01716683f, -0.03262180f, 0.01863359f, -0.05452304f, -0.05454346f, 0.03130744f, 
    -0.02451889f, -0.01406999f, 0.03552135f, 0.02840053f, 0.03722762f, -0.01180583f, -0.02720938f, -0.00695966f, 
    -0.03351386f, -0.04889528f, -0.04711105f, 0.01242172f, 0.01784069f, 0.02598320f, 0.04231703f, -0.01267055f, 
    -0.01657240f, -0.02425219f, -0.05092262f, -0.00054396f, -0.00493762f, -0.01690581f, -0.02922384f, 0.00391083f, 
    -0.01383170f, 0.03304463f, -0.01731558f, -0.04762485f, -0.01454371f, 0.04076128f, 0.03355208f, -0.00069906f, 
    -0.05391535f, -0.04821296f, -0.01129117f, -0.05339281f, -0.04757743f, 0.02178907f, -0.03075127f, 0.00943442f, 
    -0.05143241f, -0.03648439f, 0.00112152f, 0.01029733f, -0.01622976f, -0.00803635f, -0.02275059f, -0.02541234f, 
    0.00145823f, 0.01812856f, -0.00199716f, -0.00514799f, -0.01693206f, -0.05281684f, -0.04242757f, 0.01680729f, 
    0.05430224f, 0.02689026f, 0.02513313f, 0.02648005f, 0.00662851f, 0.02412958f, -0.05452263f, -0.03598252f, 
    -0.02829542f, 0.01928853f, -0.05365528f, -0.00560117f, -0.05312932f, -0.03141629f, -0.00696292f, -0.00240194f, 
    0.02572060f, -0.01398029f, -0.02526571f, 0.00807847f, 0.02228794f, 0.02355948f, -0.01251080f, -0.03179346f, 
    -0.02547494f, 0.01716940f, -0.05051346f, 0.01258957f, -0.01067758f, -0.00923139f, 0.01555040f, -0.03567809f, 
    0.02622019f, 0.01977041f, -0.03681176f, 0.03780625f, 0.02360059f, 0.00353229f, 0.04042535f, 0.04348671f, 
    -0.05724754f, -0.05240217f, -0.01291341f, 0.02698275f, -0.02592679f, 0.01834309f, -0.01215330f, -0.00139701f, 
    -0.05032879f, -0.03397724f, -0.03837584f, -0.01693877f, -0.04458159f, -0.01185155f, -0.01386062f, -0.03598249f, 
    -0.05936565f, 0.01198091f, -0.00873824f, -0.03651416f, -0.05304283f, 0.03100377f, 0.04791806f, -0.02340413f, 
    0.03747088f, 0.04018127f, -0.04405200f, -0.02314587f, 0.01161253f, 0.01426964f, -0.01339101f, -0.03387865f, 
    -0.01409750f, 0.04051298f, 0.02217354f, -0.00775603f, 0.00117399f, -0.04975742f, -0.05129535f, 0.03807468f, 
    -0.02360462f, -0.05575361f, 0.02013616f, -0.03385428f, 0.03204615f, -0.01761444f, -0.01294387f, 0.03043421f, 
    -0.10086040f, 0.01093954f, -0.17409077f, 0.01752377f, -0.18242440f, -0.10493296f, 0.04580637f, -0.02697641f, 
    0.02242777f, 0.14045647f, 0.14434697f, 0.15113993f, 0.11432198f, 0.20643887f, 0.05327709f, 0.13929123f, 
    0.06954196f, 0.00283931f, -0.06290671f, 0.00701165f, 0.06754742f, 0.07673356f, -0.02657122f, 0.10179328f, 
    -0.09813172f, 0.00682156f, 0.01078110f, -0.06919053f, -0.06487689f, -0.13285822f, 0.03444500f, 0.06643845f, 
    0.07871529f, 0.11680894f, -0.11721759f, 0.14850399f, -0.26610655f, -0.09707984f, -0.07429015f, -0.12820384f, 
    0.04873209f, 0.07061823f, -0.03252462f, 0.16115499f, -0.01708475f, 0.04227369f, -0.04376118f, 0.11254338f, 
    0.39512902f, -0.06712670f, 0.20445839f, -0.06914046f, 0.01995485f, -0.09682987f, 0.18983638f, 0.04720402f, 
    -0.08231544f, -0.03983632f, 0.07222576f, -0.10855262f, -0.17144851f, -0.07417494f, -0.15077128f, -0.15580143f, 
    -0.21365169f, 0.09866203f, 0.04281004f, -0.02268911f, 0.00756836f, 0.08408213f, -0.11409096f, 0.05470130f, 
    -0.26978144f, 0.23403688f, 0.30751845f, 0.18597096f, 0.07490332f, 0.08951385f, 0.01732944f, 0.20685253f, 
    0.08992139f, 0.07316712f, -0.10129824f, -0.21535896f, -0.10637711f, -0.03042581f, -0.01552468f, 0.05443621f, 
    0.08526465f, 0.02547710f, 0.04313500f, -0.02239521f, 0.14796950f, 0.13136026f, 0.16433883f, 0.07469027f, 
    -0.04712945f, -0.10434238f, -0.06572451f, -0.05870477f, -0.30004749f, -0.19583413f, -0.02502750f, -0.07045792f, 
    -0.07742054f, 0.09361912f, -0.09385505f, -0.05680083f, -0.13149996f, -0.06187543f, -0.05380245f, 0.02042101f, 
    -0.08516248f, -0.09361608f, -0.05708042f, 0.10510394f, -0.04140733f, -0.07033450f, -0.26453450f, -0.02480172f, 
    0.22605243f, 0.22707945f, -0.10151795f, -0.04343580f, -0.13176765f, -0.14892092f, -0.22443074f, 0.06574247f, 
    0.03825919f, 0.01089421f, 0.00635855f, 0.08720440f, 0.14022316f, -0.04989444f, 0.24335580f, 0.05205641f, 
    -0.05522998f, 0.24957597f, 0.11702975f, 0.25312376f, 0.00798772f, 0.11499107f, 0.15814558f, -0.06824607f, 
    0.09886988f, 0.00990695f, 0.05317268f, 0.17556496f, 0.13258632f, -0.07883172f, -0.01942608f, -0.03788048f, 
    0.02864768f, -0.10950433f, -0.05484794f, -0.10696626f, -0.47191027f, 0.10630833f, -0.10956909f, 0.07995682f, 
    0.07891093f, 0.09154391f, 0.12460680f, 0.28010753f, -0.05051778f, 0.17929439f, 0.13674836f, 0.08018002f, 
    -0.22034346f, -0.07399790f, 0.16667542f, 0.28848326f, 0.17834415f, 0.16983755f, 0.17053846f, 0.11387533f, 
    0.05189190f, 0.04057660f, -0.00814955f, -0.06874825f, 0.12929305f, -0.38503048f, 0.22617465f, -0.35187441f, 
    0.02359701f, 0.11834710f, 0.01505004f, 0.02743874f, -0.02071761f, 0.08800249f, -0.00873205f, -0.02012333f, 
    -0.15263732f, 0.12339220f, -0.06777196f, -0.03395267f, 0.00829996f, 0.15445778f, 0.01329061f, 0.02170695f, 
    0.02805549f, 0.06837006f, 0.08942597f, 0.00900237f, 0.09101617f, -0.08768074f, 0.24252273f, 0.04244236f, 
    -0.14872521f, -0.19458206f, -0.08246522f, 0.16492751f, 0.02136490f, 0.15688065f, 0.02805715f, -0.01942367f, 
    -0.39795861f, 0.12986070f, -0.22857077f, 0.03864571f, -0.30668777f, 0.11205573f, -0.11210893f, 0.03613298f, 
    -0.09102677f, -0.06448959f, 0.08142857f, 0.07141861f, -0.29721448f, 0.15985180f, -0.20481098f, -0.21589604f, 
    -0.19258367f, 0.05050191f, 0.01139318f, 0.02714916f, -0.02041116f, 0.09778560f, 0.08143756f, 0.08576208f, 
    -0.02691474f, 0.12879111f, 0.00782716f, 0.08381609f, -0.15070263f, -0.05512968f, -0.06058853f, -0.10245778f, 
    0.01527155f, -0.02640953f, -0.04687138f, 0.17302571f, -0.29626042f, 0.08829065f, 0.07334526f, 0.08824629f, 
    -0.01374151f, -0.20414159f, 0.07595021f, 0.16012633f, -0.09329337f, 0.20976171f, 0.11479542f, -0.00102562f, 
    -0.17628562f, 0.00414308f, 0.16105622f, -0.03357355f, 0.08690651f, -0.00537535f, 0.07226514f, 0.05794616f, 
    -0.01536238f, 0.17529464f, 0.10086158f, 0.00821386f, -0.11306474f, -0.06413415f, -0.24376157f, 0.23248035f, 
    -0.06224613f, 0.04122296f, 0.15448257f, -0.07634183f, 0.04156791f, 0.01938741f, 0.09353249f, 0.17797257f, 
    0.34452668f, 0.09279338f, 0.28209203f, 0.47721228f, 0.26701239f, -0.19365211f, 0.02013524f, 0.17877728f, 
    -0.11983587f, 0.03334694f, 0.13793828f, 0.01184840f, 0.19422439f, 0.39298415f, 0.07290239f, 0.32177401f, 
    -0.03188838f, 0.14398418f, -0.01519488f, 0.02109150f, 0.09907516f, 0.10277433f, 0.06745131f, 0.25670838f, 
    0.01864907f, 0.00082135f, 0.04464516f, -0.18553935f, -0.19883181f, -0.21154979f, -0.19984584f, -0.03236489f, 
    -0.07911970f, -0.09391768f, 0.05048932f, -0.10592378f, 0.03924143f, 0.01156628f, 0.14869092f, 0.12509489f, 
    0.11196038f, 0.11721537f, 0.20889576f, -0.15751791f, 0.00856965f, 0.00538385f, 0.08624094f, 0.07613678f, 
    -0.10300247f, 0.19577867f, -0.12944916f, -0.12033866f, -0.16842847f, -0.07702362f, -0.13509479f, -0.08828303f, 
    0.06036311f, -0.13832738f, 0.03029294f, -0.11342637f, -0.10284278f, 0.24730825f, -0.03194759f, 0.22805782f, 
    0.07376721f, 0.05971417f, 0.09012592f, -0.01468289f, -0.03476446f, 0.01959184f, 0.02055988f, -0.01581354f, 
    -0.06141878f, -0.01029514f, -0.06664991f, 0.18097329f, 0.03694192f, -0.00829702f, 0.14571428f, 0.09326413f, 
    0.03028102f, -0.14224041f, 0.07918557f, 0.05715212f, 0.25291848f, 0.67768008f, 0.33360392f, 0.33025742f, 
    0.08930069f, 0.08086393f, 0.03528635f, 0.09180550f, 0.09466411f, 0.01638119f, 0.00960361f, 0.00505901f, 
    0.19402480f, 0.17067936f, 0.15753150f, 0.09348597f, -0.07301806f, -0.00832065f, -0.10865424f, 0.02091608f, 
    -0.04670667f, -0.01728762f, -0.18809158f, -0.04583665f, 0.20305653f, 0.25671166f, 0.06639002f, 0.16338550f, 
    -0.01027576f, -0.04483480f, 0.18717930f, -0.00187780f, 0.00711255f, 0.07597635f, 0.07372683f, 0.10360191f, 
    -0.29893205f, -0.15039508f, 0.25243726f, -0.17171508f, -0.00116373f, -0.05122814f, -0.02088430f, 0.00371019f, 
    -0.00130669f, 0.11092885f, 0.03923351f, -0.01330608f, -0.22188880f, -0.26643947f, -0.22772437f, -0.21437415f, 
    -0.02001025f, 0.12118604f, -0.09728409f, 0.12385593f, -0.07790738f, 0.07488795f, -0.05499924f, -0.06826915f, 
    0.05948243f, -0.02502700f, 0.18884751f, 0.04311228f, 0.05179283f, -0.04730893f, 0.02872185f, 0.01227589f, 
    -0.08263421f, 0.03151408f, 0.19186115f, 0.19723253f, 0.39445913f, 0.22648062f, 0.22034985f, -0.21728574f, 
    -0.01526770f, -0.06984505f, -0.06249022f, 0.03345267f, 0.02580486f, 0.02579841f, -0.01857131f, -0.08649836f, 
    -0.10901666f, -0.09219369f, 0.22152269f, 0.16420867f, -0.18356524f, 0.03811985f, 0.16729474f, 0.04903978f, 
    0.00120400f, -0.03877226f, 0.11039299f, 0.08041272f, -0.08014435f, 0.11067247f, -0.00409697f, 0.05450080f, 
    -0.03579914f, -0.08287256f, 0.10209720f, -0.01181301f, -0.03167232f, -0.08015200f, -0.02603017f, -0.20701976f, 
    0.47821093f, 0.18412435f, 0.16535848f, 0.18582244f, -0.05217530f, 0.00450818f, -0.17523815f, 0.01563884f, 
    -0.14716920f, 0.03795736f, 0.01666626f, 0.01721324f, 0.17690283f, 0.49144685f, -0.24882606f, -0.10938174f, 
    -0.06534749f, -0.07296625f, -0.00021959f, 0.07952412f, -0.10427123f, 0.13716532f, 0.24572214f, -0.03145605f, 
    0.15500927f, 0.25039041f, 0.47641921f, -0.22824249f, -0.15477024f, -0.10263111f, -0.02927522f, 0.00327154f, 
    -0.13980655f, 0.14521162f, -0.00295446f, -0.07349175f, -0.03604700f, -0.21387540f, -0.18548094f, 0.21481158f, 
    0.04740765f, -0.01867404f, -0.15548709f, 0.18506147f, 0.03074149f, -0.00213892f, -0.03168537f, 0.03015044f, 
    0.23768982f, -0.16162020f, 0.04888876f, 0.00698133f, 0.09786744f, 0.03222976f, -0.06066481f, -0.10221550f, 
    0.11613132f, 0.19206467f, 0.08582543f, 0.00899454f, -0.16921735f, -0.05117095f, -0.27948517f, -0.04982114f, 
    -0.00518050f, 0.05464653f, 0.11228848f, 0.08590296f, -0.16319235f, -0.31143719f, -0.26107383f, -0.25737631f, 
    0.09044590f, -0.04693632f, -0.11292963f, 0.00940806f, 0.04928659f, 0.15375693f, 0.18160449f, -0.11107320f, 
    -0.16949144f, -0.23163556f, 0.07967155f, -0.03307664f, 0.31550369f, -0.15529811f, 0.36249882f, -0.23657662f, 
    -0.04236256f, -0.09974734f, -0.22494096f, -0.14938095f, -0.11472435f, -0.07562765f, -0.04423150f, -0.04129987f, 
    0.02457059f, 0.21697202f, -0.09602618f, 0.09626185f, -0.05496077f, 0.19322810f, 0.24199276f, 0.13985744f, 
    0.24318527f, -0.09517488f, -0.22830392f, -0.00365571f, 0.09650334f, -0.01532909f, 0.01457960f, 0.03692220f, 
    -0.11197302f, 0.07382189f, 0.03121180f, 0.01951870f, -0.00432765f, 0.09154283f, 0.00439153f, 0.05500868f, 
    0.17479327f, 0.44918177f, -0.04025226f, 0.13730973f, -0.11238994f, -0.17944898f, -0.08983690f, -0.06995275f, 
    -0.11637526f, 0.00325759f, -0.03272670f, 0.12679039f, -0.21536307f, 0.00778405f, -0.11028052f, -0.01407410f, 
    -0.01012351f, -0.05759080f, -0.01874845f, 0.07075197f, -0.21733299f, -0.08897880f, -0.02754641f, 0.05481838f, 
    0.10166503f, 0.43377981f, -0.05765898f, 0.06976762f, -0.03777151f, 0.00297927f, 0.03960011f, 0.00791510f, 
    0.08363327f, 0.20610395f, -0.07872919f, 0.17668758f, -0.11470139f, -0.15795781f, 0.13890439f, 0.03454474f, 
    -0.02665013f, 0.08488763f, 0.01944022f, 0.02818372f, -0.09098546f, -0.07169465f, 0.05037437f, -0.11596517f, 
    0.02530554f, 0.14687340f, -0.11222219f, 0.06031802f, 0.13146149f, 0.21155985f, 0.10666919f, 0.06492035f, 
    0.17395315f, 0.08934444f, 0.03158179f, 0.16301332f, 0.02839247f, 0.00477245f, 0.00431618f, 0.09210028f, 
    -0.03543670f, -0.13758528f, 0.04141594f, -0.12384096f, -0.15621336f, 0.00790951f, -0.16367459f, -0.13350452f, 
    -0.08439110f, -0.23279585f, 0.08018384f, 0.15919255f, 0.04054216f, -0.00115436f, -0.09159002f, 0.04578542f, 
    -0.21104816f, -0.06190644f, -0.05776377f, 0.00562771f, 0.13883807f, 0.32951641f, -0.04117609f, -0.03492347f, 
    0.03624175f, -0.01470834f, 0.16198322f, 0.12570518f, 0.01763180f, 0.22745956f, 0.15921649f, 0.00417642f, 
    0.14071399f, 0.05519444f, 0.12787087f, 0.07004055f, -0.12185947f, -0.01936040f, 0.01032768f, 0.00650663f, 
    0.13948464f, 0.17839888f, 0.06914602f, 0.13986841f, -0.10466582f, -0.24562249f, -0.08549171f, -0.21924122f, 
    0.14341417f, 0.01476132f, 0.12600102f, -0.10896487f, -0.11644591f, -0.04217923f, -0.08921737f, -0.10374497f, 
    -0.05090211f, 0.27707386f, -0.10036172f, 0.21143463f, -0.12273008f, 0.08760621f, 0.03631133f, 0.06494509f, 
    0.08583210f, 0.08634409f, 0.16789286f, 0.16613716f, -0.09347377f, -0.15522298f, -0.02851989f, 0.04063707f, 
    0.07033300f, -0.02212252f, 0.15531301f, 0.10473142f, 0.05837962f, 0.06892318f, 0.21212900f, 0.29048312f, 
    -0.23555873f, -0.24917924f, -0.12990277f, -0.03499237f, 0.03268960f, -0.10545372f, -0.09518779f, 0.11502858f, 
    -0.08114640f, 0.16126758f, 0.03614407f, -0.06260686f, 0.03748248f, 0.12949818f, 0.17516807f, 0.19717890f, 
    0.03114462f, -0.08086307f, 0.11036644f, -0.08631883f, 0.08115983f, 0.00400199f, 0.07590526f, 0.13785887f, 
    0.00896423f, -0.23940009f, -0.16616842f, 0.01203596f, -0.07831547f, 0.08614706f, -0.03908454f, -0.26642764f, 
    -0.24003801f, -0.11389435f, -0.07192171f, -0.04555423f, -0.15728761f, -0.11186454f, 0.02730851f, 0.05877389f, 
    -0.17492363f, -0.13662775f, 0.06492538f, -0.05640296f, 0.02550972f, -0.15083279f, 0.01616320f, -0.06732684f, 
    0.08597033f, -0.04795579f, 0.00572129f, 0.27110371f, -0.13670771f, 0.05394419f, -0.13900600f, 0.03730599f, 
    0.12288351f, 0.02208137f, 0.21536686f, 0.09024483f, 0.27814966f, 0.22385091f, -0.09117530f, -0.10401122f, 
    -0.00321766f, 0.13035646f, 0.07653990f, 0.10404485f, -0.07111992f, -0.15217370f, 0.05171482f, 0.02474439f, 
    -0.12901507f, -0.17640096f, 0.05949431f, 0.15404911f, -0.05675992f, -0.01757276f, -0.01573803f, 0.14319204f, 
    0.16107786f, 0.13559780f, 0.06733465f, 0.29492188f, -0.07640257f, 0.08593111f, 0.45972413f, -0.11188579f, 
    0.15388881f, 0.00549297f, 0.00708279f, -0.15304390f, -0.19373792f, -0.27005526f, 0.00660486f, -0.13111897f, 
    0.30732507f, -0.01936767f, 0.00778894f, 0.10352574f, 0.03966473f, 0.04356973f, 0.00440472f, -0.01204490f, 
    0.11274248f, 0.02715839f, -0.05737428f, 0.12955195f, -0.35172528f, -0.27342317f, -0.03899979f, 0.04243763f, 
    0.00138541f, 0.00993333f, -0.05162251f, -0.02949034f, -0.11637961f, -0.22146814f, -0.12426835f, -0.30115214f, 
    -0.24414946f, -0.15535524f, -0.30796987f, 0.22630811f, 0.10216776f, -0.04749897f, -0.06456435f, -0.11854689f, 
    -0.25421643f, -0.12784675f, 0.00441215f, -0.17718005f, 0.08436394f, 0.01908512f, 0.26204684f, 0.19122556f, 
    -0.01703535f, -0.09158893f, -0.07886910f, -0.20969738f, 0.01929017f, -0.04721399f, 0.08948635f, -0.08772229f, 
    -0.33952403f, -0.41873959f, -0.14743498f, 0.28275496f, -0.00834869f, 0.24050406f, -0.03960982f, -0.08763658f, 
    -0.12294401f, -0.13832860f, -0.08270698f, 0.24167068f, 0.12789521f, -0.00992580f, -0.21089487f, -0.02393120f, 
    0.11634067f, -0.00176884f, 0.02841198f, 0.09583716f, -0.17842108f, -0.23415990f, 0.00249937f, -0.07901831f, 
    0.19848682f, 0.18900120f, -0.03858113f, -0.04731244f, 0.09538943f, 0.09320705f, 0.09978086f, 0.10932995f, 
    -0.10507630f, 0.07912453f, 0.19516079f, 0.17864393f, 0.52834415f, 0.13709790f, -0.25302994f, -0.43355274f, 
    0.02001692f, 0.07648375f, 0.04568278f, -0.15394592f, -0.10811312f, -0.07920435f, -0.02206710f, 0.01889664f, 
    0.04088444f, 0.33245584f, 0.12677421f, -0.33512735f, -0.03113787f, 0.00253139f, 0.06432866f, -0.16114953f, 
    -0.03818882f, -0.16855773f, -0.09900508f, -0.04032665f, -0.15592524f, -0.18361609f, -0.44266748f, 0.32622647f, 
    -0.03191780f, -0.07311737f, -0.04147151f, 0.08987404f, 0.01691351f, -0.16963826f, -0.16739726f, -0.14740595f, 
    0.05304081f, -0.19820407f, 0.06206522f, -0.03642017f, -0.00084699f, 0.05017801f, 0.07235860f, 0.18306081f, 
    -0.00635693f, -0.02695938f, -0.04981817f, 0.11767016f, -0.44251946f, -0.02912140f, -0.14175071f, 0.06513020f, 
    -0.01350543f, 0.06099594f, 0.01193291f, -0.13624783f, -0.03405781f, 0.05903150f, 0.05315959f, 0.04736829f, 
    -0.07251234f, -0.20451082f, 0.19565646f, -0.01510775f, 0.15306352f, -0.15538666f, 0.14798780f, -0.03726947f, 
    -0.06139845f, -0.00572719f, -0.13733044f, -0.33392394f, 0.05446770f, 0.23896737f, 0.21054091f, 0.06738123f, 
    0.02831893f, -0.00293579f, -0.05265294f, -0.14128688f, -0.01100007f, -0.12664597f, -0.14358087f, -0.12908427f, 
    -0.28804988f, 0.01094903f, 0.33049294f, -0.00376638f, -0.03848873f, 0.07157277f, 0.05107339f, 0.17861122f, 
    -0.18182358f, -0.09585462f, -0.02101251f, -0.05171449f, 0.32239473f, 0.02320210f, 0.08536300f, -0.16860245f, 
    -0.10211997f, 0.08628100f, -0.20118780f, -0.23016235f, 0.17632020f, 0.17466453f, -0.02159871f, 0.08172769f, 
    0.33529294f, 0.11078887f, -0.25101340f, 0.02828906f, 0.08925532f, -0.00484042f, 0.06526536f, -0.00455220f, 
    0.12784921f, 0.15434363f, 0.08923692f, 0.16480885f, -0.20345835f, -0.11921347f, 0.03768256f, -0.16186918f, 
    0.07911755f, -0.00663017f, -0.01746125f, -0.06481128f, -0.25969809f, -0.12288689f, -0.05410700f, -0.36159658f, 
    0.16375580f, 0.13575397f, -0.22175755f, -0.11325277f, -0.00554398f, 0.14511286f, -0.02867343f, 0.09074749f, 
    0.03873884f, 0.01403634f, -0.10999217f, 0.09484687f, 0.08506821f, -0.21110563f, -0.48535952f, 0.08940095f, 
    0.08527701f, -0.00536550f, -0.00484819f, 0.14533545f, -0.01341763f, 0.01152804f, -0.02571737f, -0.01922529f, 
    -0.44480601f, -0.23562165f, -0.16933711f, 0.27959207f, -0.11251067f, -0.00834737f, -0.06225299f, -0.27735305f, 
    0.01884140f, 0.00105394f, 0.03674851f, 0.09927451f, 0.11707757f, 0.04493826f, 0.00118795f, -0.19626395f, 
    0.01196574f, -0.03546439f, -0.04814549f, 0.18279389f, -0.13903405f, -0.05905529f, 0.02925200f, -0.08902634f, 
    -0.11629578f, -0.19986819f, 0.12699655f, 0.22502983f, -0.08821187f, -0.05417897f, 0.13800509f, 0.04136973f, 
    0.12461197f, 0.17129068f, 0.06368706f, 0.22046857f, 0.17917503f, 0.10671461f, 0.05346156f, -0.04725032f, 
    0.01678869f, 0.00322309f, -0.03326421f, 0.11761878f, 0.09291253f, 0.05249877f, 0.06202386f, 0.18666482f, 
    0.16215666f, 0.19018629f, 0.03320892f, -0.10499024f, 0.08728954f, 0.23837644f, 0.02112996f, 0.08554448f, 
    0.00253564f, 0.07475322f, 0.06855155f, 0.12967032f, 0.07380713f, -0.08853010f, -0.24335423f, 0.09854366f, 
    0.02272204f, -0.01374600f, -0.02262924f, 0.00566495f, 0.06362855f, 0.03808302f, 0.01890285f, 0.07360290f, 
    -0.15427035f, 0.05462790f, 0.17072569f, -0.07928736f, -0.18849745f, -0.00780722f, -0.08449098f, -0.02043523f, 
    -0.06287308f, -0.24870908f, -0.16166358f, 0.11066654f, 0.04297230f, 0.48749194f, -0.01702535f, -0.18320282f, 
    -0.04904919f, -0.18164809f, 0.00947175f, 0.04903398f, -0.16734827f, 0.04773449f, -0.08461865f, -0.12591185f, 
    0.41037336f, 0.16821238f, -0.09974621f, -0.31775376f, 0.07699537f, -0.05398623f, 0.01238001f, -0.05501484f, 
    -0.07416366f, 0.14571272f, -0.13949727f, 0.01999405f, -0.08347908f, -0.22971785f, 0.02302143f, 0.13810918f, 
    0.09918867f, -0.00532104f, -0.01894538f, 0.08214220f, -0.04873239f, 0.03743237f, -0.09563250f, -0.04479071f, 
    0.67206782f, 0.05903871f, 0.03949047f, 0.07277831f, -0.03598186f, -0.02969293f, 0.12324077f, -0.07119209f, 
    -0.18237317f, -0.02004164f, -0.06913164f, 0.00679633f, 0.02699728f, -0.36147040f, 0.26086235f, -0.02778181f, 
    -0.24224868f, -0.02613318f, -0.05425998f, -0.05985298f, -0.02366092f, -0.00590388f, 0.00672511f, -0.05566228f, 
    -0.20990370f, -0.04371200f, -0.00131843f, 0.14990656f, 0.06233474f, -0.00328947f, 0.16678807f, -0.03962310f, 
    0.03237409f, 0.08777656f, -0.00278552f, 0.04184162f, -0.00851104f, -0.01697065f, 0.02007679f, -0.11878234f, 
    0.00679761f, -0.14624393f, -0.00931946f, -0.06877338f, 0.00103557f, 0.08239747f, 0.02742267f, -0.09064817f, 
    -0.12035650f, -0.02088014f, 0.20273392f, -0.15218578f, -0.17970662f, -0.09259806f, -0.25391719f, 0.03077779f, 
    0.10131101f, 0.01314762f, -0.09703716f, 0.06060960f, 0.25289512f, 0.23431772f, -0.03413885f, -0.11234105f, 
    -0.27943000f, -0.06254815f, -0.02944903f, -0.11590864f, 0.03434882f, -0.03438330f, -0.02837547f, 0.07937089f, 
    -0.18793546f, 0.21262108f, 0.08744251f, 0.15540218f, 0.12490028f, 0.10352559f, -0.07573891f, 0.02751425f, 
    -0.03737365f, 0.03461736f, 0.01113410f, -0.12181675f, 0.06477165f, -0.05139907f, -0.00004309f, 0.15033466f, 
    0.09884395f, 0.03974054f, -0.00091612f, 0.01854189f, 0.13261102f, -0.09972287f, 0.19521715f, -0.06536275f, 
    0.09210255f, -0.22994348f, -0.12857778f, 0.10487825f, 0.03179213f, -0.08439836f, 0.01443979f, 0.00913049f, 
    0.00678201f, 0.09550909f, -0.04858566f, 0.06161055f, 0.15741141f, 0.42763755f, 0.15612005f, 0.08406815f, 
    -0.00847204f, -0.01871823f, -0.07767847f, -0.04909456f, -0.09516690f, 0.01936648f, 0.04059453f, 0.04378256f, 
    -0.02425880f, 0.02907602f, -0.21249716f, 0.22486925f, 0.01649757f, 0.02608212f, 0.04468522f, -0.05020688f, 
    -0.06594945f, 0.06724489f, -0.03329755f, -0.02149751f, -0.07114285f, -0.04118780f, 0.46909395f, -0.16127849f, 
    -0.02231534f, 0.20747642f, -0.10374784f, 0.11071005f, -0.04778953f, -0.01256123f, 0.11264583f, -0.04482832f, 
    -0.04324291f, 0.50181013f, -0.16117582f, -0.03983169f, -0.03646741f, 0.08639511f, -0.13642226f, -0.03847800f, 
    -0.06983544f, 0.23660021f, 0.04433312f, -0.05544538f, -0.02462075f, 0.10111878f, 0.28624040f, 0.06937690f, 
    -0.13214940f, -0.23075673f, 0.00583111f, 0.01553370f, -0.00983069f, 0.02286446f, -0.03148723f, -0.04255066f, 
    -0.25771028f, 0.27033868f, 0.13773368f, 0.10611107f, -0.06757233f, -0.02083788f, -0.03341211f, 0.11759339f, 
    0.02281069f, 0.04074869f, 0.10114706f, 0.01393919f, 0.54448873f, -0.08144417f, -0.12660587f, -0.19480965f, 
    0.11440247f, 0.06528580f, 0.07391046f, -0.07405862f, 0.06918534f, 0.15620486f, -0.05702510f, 0.12954418f, 
    0.29788592f, 0.00337526f, -0.04454128f, -0.19839598f, -0.11004158f, -0.13127242f, -0.06756304f, 0.04479848f, 
    0.06367416f, 0.12833287f, -0.06286695f, -0.15501434f, 0.27890107f, -0.26705575f, 0.02404018f, 0.10988247f, 
    0.07266887f, -0.06862837f, -0.04776732f, 0.10755425f, 0.04566288f, 0.04191270f, -0.04843869f, 0.06072591f, 
    -0.04495206f, 0.21772856f, 0.00261885f, 0.00363800f, 0.08002868f, 0.02730344f, 0.08621538f, 0.03861494f, 
    -0.14170536f, 0.04784462f, -0.09894269f, 0.08592061f, 0.16965966f, 0.12687773f, -0.27421752f, -0.01937705f, 
    0.00322827f, -0.13875780f, 0.02437434f, -0.03774515f, -0.17396593f, -0.03232983f, 0.07193536f, 0.01837790f, 
    0.35544050f, -0.05210553f, 0.17886741f, 0.25193891f, 0.03225470f, -0.07568708f, -0.09113042f, 0.01097098f, 
    -0.10475190f, 0.15608747f, 0.04237261f, 0.01934036f, -0.49233744f, 0.26463237f, 0.06587442f, 0.23233609f, 
    -0.01311126f, 0.05914508f, 0.01801130f, -0.08550021f, 0.00007333f, 0.02652906f, -0.01636641f, 0.07771876f, 
    0.05083016f, -0.02102405f, -0.08388585f, -0.08353040f, -0.13422820f, -0.12603734f, -0.17309085f, -0.01497438f, 
    0.10706340f, 0.08614364f, -0.03199852f, 0.02633721f, 0.03537616f, -0.17930715f, 0.09961203f, 0.29800439f, 
    -0.03611740f, 0.21676897f, -0.01218089f, -0.08136584f, -0.05340523f, 0.08646990f, -0.04819485f, -0.12208094f, 
    0.16421790f, 0.32377568f, -0.07576586f, 0.03534493f, -0.09574132f, -0.02189520f, -0.04118277f, -0.00922629f, 
    0.06278913f, 0.15813483f, 0.12753929f, 0.00874111f, -0.19792245f, -0.06447171f, 0.02732670f, 0.20681782f, 
    -0.00832427f, 0.00313252f, 0.03411214f, -0.07067772f, -0.00179197f, 0.05287918f, -0.01593216f, 0.08027724f, 
    0.06400197f, -0.12670079f, -0.02392905f, 0.31836703f, 0.09059960f, -0.13057150f, 0.08175682f, -0.00757183f, 
    0.06955133f, 0.18598132f, 0.05443637f, -0.05056327f, -0.21219000f, 0.23494683f, 0.08289624f, 0.29212055f, 
    0.00815575f, 0.04412949f, 0.21118425f, 0.01520842f, -0.04133775f, 0.01917407f, 0.11121117f, 0.07051366f, 
    -0.04142870f, 0.00842863f, -0.02286204f, 0.12105328f, -0.08520570f, -0.02176465f, 0.00283853f, -0.06506029f, 
    0.00728631f, 0.14979209f, 0.00521140f, 0.05524037f, 0.12192349f, -0.15425220f, 0.17892946f, 0.21907511f, 
    0.01863286f, -0.00233292f, -0.02195966f, 0.00218074f, 0.12358084f, 0.09187348f, 0.13462368f, 0.06528067f, 
    0.04201500f, -0.02240900f, 0.22009593f, 0.05621287f, -0.08566777f, 0.06621133f, 0.03316447f, 0.03137622f, 
    0.00950303f, -0.01688795f, -0.10953575f, -0.08772337f, -0.03163880f, 0.08673595f, -0.07785083f, -0.12081213f, 
    -0.00664392f, 0.08918784f, 0.00249715f, 0.23831825f, -0.01277151f, 0.12924415f, 0.01933183f, 0.00989323f, 
    -0.20882373f, -0.22781183f, 0.22749846f, 0.11733039f, 0.03160313f, -0.17943293f, 0.01259173f, -0.00870449f, 
    -0.17164095f, -0.11889374f, 0.04637881f, -0.06764398f, -0.22683485f, 0.29634002f, 0.10596012f, -0.05464663f, 
    -0.04742693f, -0.08731543f, -0.01095458f, -0.09990127f, 0.07636658f, -0.01884586f, -0.03039117f, 0.06911896f, 
    0.17256440f, 0.05578467f, 0.17398414f, -0.02457599f, -0.03872900f, 0.12717499f, 0.04022086f, 0.03780442f, 
    -0.03813589f, -0.01478689f, 0.01520881f, -0.19134404f, -0.06326379f, -0.09651365f, 0.04321278f, -0.04765331f, 
    0.04262323f, 0.11807733f, -0.03640415f, -0.08751374f, 0.08730355f, 0.01319887f, 0.11727104f, -0.01441959f, 
    0.13430180f, 0.15356638f, 0.02354675f, 0.09787454f, -0.05160848f, -0.14648814f, -0.01704559f, -0.03356718f, 
    -0.10657354f, 0.09761644f, -0.03233764f, 0.00210125f, 0.07605013f, -0.06402217f, -0.08712621f, 0.05883155f, 
    -0.03803663f, -0.09570745f, -0.14728044f, 0.08912719f, -0.09280810f, 0.10293818f, -0.05242617f, -0.22794768f, 
    0.38295165f, 0.21069728f, 0.00701267f, 0.07293389f, -0.14921716f, 0.02797610f, -0.06739423f, 0.02315394f, 
    -0.02816779f, -0.03854353f, -0.09650394f, -0.01005087f, 0.14622425f, -0.03736139f, -0.08984018f, 0.06637298f, 
    -0.13706228f, 0.21085180f, 0.11825878f, 0.26282388f, 0.03651405f, 0.17143163f, -0.00843721f, 0.06780982f, 
    0.37310824f, 0.18435587f, 0.14789715f, 0.13481736f, 0.25764453f, 0.06656180f, -0.16326192f, -0.13402319f, 
    0.13905093f, -0.04118605f, -0.06567997f, -0.06720823f, -0.31909969f, -0.02636699f, -0.41700992f, 0.00035337f, 
    0.07567507f, 0.10876638f, 0.15778908f, 0.18981251f, -0.03625247f, -0.04270528f, -0.03598684f, -0.04654865f, 
    -0.13402349f, 0.12928537f, 0.23132868f, -0.17384483f, 0.09663542f, 0.08444294f, -0.03618084f, -0.01989368f, 
    -0.00263060f, -0.04387593f, 0.02540184f, -0.06419188f, 0.06627331f, -0.10092233f, -0.03380644f, -0.03692166f, 
    -0.00782952f, -0.00105284f, -0.01576010f, -0.11446689f, -0.08024571f, 0.05118328f, -0.08344756f, 0.03103946f, 
    0.05486405f, -0.00687447f, 0.01241614f, 0.06939316f, 0.10117412f, 0.07545558f, 0.01960850f, 0.06575480f, 
    0.19620629f, -0.13040443f, -0.00188676f, -0.06302603f, 0.07186504f, 0.05193995f, 0.10988776f, -0.20830107f, 
    -0.02107716f, -0.00860226f, -0.14523906f, -0.00613494f, -0.07472266f, 0.07894818f, 0.02059038f, -0.04204233f, 
    0.11301666f, 0.20151509f, -0.21334036f, -0.04841627f, -0.15149869f, -0.10581800f, -0.07572578f, -0.01852005f, 
    -0.01845096f, 0.00174330f, 0.00120916f, 0.11081270f, -0.06827183f, 0.12296765f, -0.09307159f, -0.18464941f, 
    -0.01491258f, 0.03617357f, 0.09298509f, -0.04455936f, -0.02452191f, -0.05523882f, 0.08434466f, 0.22539806f, 
    -0.17367411f, 0.18543611f, 0.20358072f, 0.08665439f, -0.12084755f, -0.06283667f, -0.03758201f, -0.16501214f, 
    -0.00776110f, -0.03936431f, -0.15550114f, 0.10182036f, -0.15302770f, -0.10160963f, -0.18604676f, -0.19230275f, 
    0.03695466f, -0.04216600f, 0.04560290f, -0.04244106f, -0.16891977f, 0.19679011f, 0.04585494f, -0.07879421f, 
    0.15695029f, -0.02126209f, -0.04813578f, -0.01737330f, -0.00305330f, 0.13310486f, -0.01869923f, -0.06340707f, 
    0.19721274f, 0.02246914f, 0.05114032f, -0.05729375f, -0.11284259f, 0.01651442f, 0.02679688f, 0.20924017f, 
    0.00500561f, 0.04971553f, 0.15508524f, -0.04324739f, 0.05235805f, 0.04715130f, 0.01777256f, 0.02917570f, 
    0.12021625f, 0.07769658f, 0.07212137f, 0.35296586f, -0.04049889f, 0.01935342f, 0.04275904f, 0.21124376f, 
    -0.20808275f, 0.01847353f, 0.17471801f, 0.07266228f, 0.66786641f, -0.03883869f, -0.42423069f, 0.05784900f, 
    0.05753177f, -0.05321348f, 0.07807518f, 0.10349431f, 0.04946925f, 0.10764232f, 0.00426204f, 0.06331398f, 
    -0.01334716f, 0.04039225f, 0.16783805f, 0.10756308f, -0.15634662f, -0.08647744f, -0.12055117f, -0.08968820f, 
    -0.01329152f, -0.06976918f, 0.02743072f, -0.07374608f, 0.11110236f, 0.08310232f, 0.13240968f, -0.12755586f, 
    0.09942292f, -0.04691378f, 0.14453839f, 0.05657015f, -0.00950147f, -0.03606840f, 0.08136212f, -0.01917943f, 
    0.14032033f, 0.13194218f, 0.15635437f, 0.10755047f, -0.08056846f, -0.02844159f, -0.15436578f, -0.15252241f, 
    -0.21554442f, -0.15427712f, 0.00279219f, -0.17219217f, 0.25093126f, 0.18488297f, -0.12791671f, -0.03337008f, 
    -0.01760801f, -0.05392376f, 0.08147328f, 0.09739656f, -0.01736687f, -0.07930597f, -0.06231684f, -0.20482965f, 
    -0.05545522f, -0.03525483f, -0.01884379f, 0.03545249f, 0.07125425f, 0.17365845f, -0.12935440f, 0.12434856f, 
    0.02678258f, -0.12618037f, 0.13651277f, 0.07639484f, 0.43565559f, 0.10521404f, -0.07819060f, 0.03102553f, 
    0.03824579f, 0.06721233f, -0.10793112f, -0.05333778f, 0.17753813f, -0.01617188f, -0.11503886f, -0.06410925f, 
    -0.17346223f, -0.12277143f, 0.12849635f, -0.13432281f, 0.01992665f, -0.16864230f, -0.15080114f, 0.03344374f, 
    0.06278221f, -0.08765508f, -0.07360432f, 0.13574442f, 0.04610534f, 0.19100727f, 0.14141192f, -0.02589621f, 
    0.07235067f, 0.00056080f, 0.08588698f, 0.17630334f, 0.10290729f, 0.00041022f, 0.05806251f, -0.13539217f, 
    0.47480425f, 0.29988781f, 0.21786456f, -0.16379304f, -0.05250931f, -0.15360217f, 0.02455259f, 0.00827631f, 
    0.12109579f, 0.09768916f, 0.01221175f, 0.02345452f, -0.22800282f, -0.08385837f, -0.13904083f, 0.11596650f, 
    0.20900400f, 0.01600291f, 0.01821975f, 0.19468227f, 0.05507362f, 0.08217174f, 0.02465220f, 0.07253229f, 
    0.46644002f, 0.36230901f, -0.11778793f, 0.23733819f, -0.03720667f, -0.02868691f, 0.20809382f, -0.17842062f, 
    0.09425548f, 0.08488373f, 0.02381974f, 0.02184540f, -0.16578214f, -0.04373709f, -0.33915797f, -0.10335730f, 
    -0.22246084f, -0.05432909f, -0.12428507f, -0.27041310f, 0.00892831f, 0.00691759f, 0.10535740f, 0.02412422f, 
    -0.19570079f, -0.10762582f, -0.11211701f, 0.11864991f, 0.06044456f, -0.07692277f, 0.00823432f, 0.01949054f, 
    0.08051115f, 0.03853286f, 0.02694685f, -0.05858698f, 0.02225083f, 0.09185541f, -0.03269885f, -0.12751274f, 
    -0.09997496f, -0.01452003f, -0.16454382f, 0.07230756f, 0.05288527f, 0.06995051f, 0.10434126f, 0.33560538f, 
    -0.36810124f, -0.16588680f, 0.18801743f, -0.26456046f, 0.00664014f, -0.38210821f, 0.03524715f, -0.11371237f, 
    0.08358938f, -0.13751869f, -0.14265016f, 0.03700326f, -0.15043430f, -0.01109315f, 0.15638125f, 0.10520616f, 
    -0.26535961f, -0.13625468f, 0.06521345f, -0.10868985f, 0.01001354f, -0.11568191f, -0.05113961f, 0.16047531f, 
    0.02213923f, 0.12796336f, 0.04478044f, 0.17844005f, -0.09279076f, -0.18992823f, -0.16946770f, 0.08754872f, 
    0.14806286f, 0.04776326f, 0.08021211f, 0.01226041f, -0.14678456f, 0.03446947f, 0.19051823f, -0.20747098f, 
    0.15538970f, -0.05052056f, 0.21360911f, -0.01723003f, -0.06636757f, 0.06870414f, 0.03879426f, 0.04985044f, 
    -0.15077496f, -0.25259009f, -0.03158215f, 0.02022709f, -0.11344367f, -0.00170718f, 0.00821297f, 0.11341904f, 
    -0.05237020f, -0.09851272f, -0.09502140f, -0.03824328f, 0.13402973f, -0.03070487f, -0.10799823f, -0.28075033f, 
    0.26186743f, 0.06877384f, -0.13901061f, 0.25929680f, 0.09015761f, 0.00894943f, -0.02667450f, 0.19390917f, 
    0.00170801f, -0.10473446f, -0.19217233f, 0.08342597f, 0.01431139f, 0.07575125f, 0.09831618f, 0.03547177f, 
    -0.02088333f, -0.02785912f, 0.03090808f, -0.03691531f, -0.66745907f, 0.36346623f, 0.00301312f, -0.13247085f, 
    0.09686233f, 0.08018297f, -0.00639769f, 0.18029518f, 0.05155009f, -0.07432081f, 0.08555023f, 0.11779663f, 
    -0.06146350f, 0.05423975f, -0.10086020f, -0.35519236f, -0.10094884f, 0.00972517f, -0.12351700f, -0.23944677f, 
    -0.23145050f, -0.00527934f, 0.08308046f, -0.15207557f, -0.30449858f, -0.22440076f, 0.25438523f, -0.27968669f, 
    0.04296862f, 0.09784026f, 0.04101221f, 0.04438220f, 0.02952878f, -0.03507269f, -0.00574471f, 0.00229018f, 
    -0.46269086f, -0.19621453f, 0.05789585f, 0.09087863f, 0.03380138f, -0.00205223f, 0.09311890f, 0.00182276f, 
    0.06881569f, -0.05447539f, 0.03296712f, 0.11081684f, 0.60375214f, -0.15480478f, 0.05504053f, -0.12189174f, 
    -0.24375640f, 0.08316571f, -0.03027025f, 0.00321273f, 0.16208689f, 0.02413155f, 0.10570773f, 0.13403016f, 
    0.27468899f, 0.03265921f, -0.25856873f, 0.19827621f, 0.03682595f, -0.08690950f, 0.15682688f, 0.01843753f, 
    0.21389556f, 0.06715103f, 0.12761755f, -0.04866083f, 0.33212847f, -0.17905025f, 0.00067965f, 0.00946543f, 
    -0.02064787f, -0.00694400f, -0.03642531f, 0.12412895f, 0.07024652f, 0.01871221f, 0.06371848f, 0.21681266f, 
    0.07715316f, 0.06269524f, 0.13985068f, -0.02824289f, 0.05065652f, -0.07493920f, -0.07391565f, 0.20293565f, 
    -0.02426777f, 0.07014824f, 0.09555118f, 0.01657401f, 0.12486339f, 0.00896747f, 0.00357855f, -0.31108809f, 
    -0.00166796f, -0.07961968f, -0.07697427f, -0.05868001f, -0.02591905f, 0.11357673f, -0.08735678f, 0.28197297f, 
    0.01672808f, -0.26281044f, 0.14775108f, -0.08186848f, 0.12549552f, 0.07631146f, -0.03627580f, 0.12555559f, 
    0.04228041f, 0.13310933f, -0.01066442f, -0.00614632f, -0.24753328f, 0.27796265f, 0.20255157f, 0.07236154f, 
    0.13749394f, 0.07074322f, -0.00781397f, -0.08156487f, 0.08272730f, 0.15395285f, -0.05663031f, 0.14330652f, 
    -0.08201884f, 0.09226797f, -0.05400889f, -0.00757651f, -0.03163232f, -0.22132261f, -0.07618384f, -0.03372140f, 
    0.02638127f, 0.01184779f, -0.06864587f, 0.05532980f, -0.08728117f, -0.11874643f, -0.16590822f, 0.13717008f, 
    0.08799541f, 0.26423943f, -0.05754140f, 0.03006735f, -0.00237660f, 0.02973668f, 0.00453746f, 0.16578384f, 
    -0.00311362f, 0.02772960f, 0.02553936f, -0.16404755f, -0.07944883f, -0.04669042f, 0.00886273f, -0.12617098f, 
    0.05122910f, 0.04135266f, 0.14051822f, -0.09000507f, -0.12282369f, -0.01248119f, 0.09321096f, 0.02786959f, 
    0.07311240f, 0.12047544f, 0.07367050f, -0.04430236f, 0.07924587f, 0.00328821f, 0.12587702f, -0.18265752f, 
    0.04503956f, -0.19220820f, -0.06420830f, 0.03695105f, 0.07499640f, 0.19238360f, 0.11344045f, 0.10107345f, 
    0.05543936f, -0.02363362f, 0.06074998f, 0.01785586f, -0.13118690f, 0.04703286f, 0.12214517f, 0.21313123f, 
    0.03652513f, -0.06566931f, 0.07826176f, 0.05599018f, 0.10524847f, 0.04010202f, 0.13401499f, 0.14310017f, 
    -0.02685529f, 0.21742497f, 0.19750364f, -0.03019550f, 0.00912786f, 0.04533199f, -0.01140421f, 0.02652460f, 
    -0.01535033f, 0.01786940f, -0.00663531f, 0.16364205f, 0.21837150f, 0.27496096f, 0.07217795f, 0.24549906f, 
    -0.00226344f, -0.01413594f, -0.03112852f, -0.08537755f, 0.14693755f, 0.08451731f, -0.04850319f, -0.11055905f, 
    0.22913809f, -0.06030898f, -0.24853042f, -0.23559128f, -0.02062421f, -0.05042091f, -0.00060017f, -0.01788050f, 
    0.13958231f, -0.03660493f, -0.20787010f, -0.08554485f, -0.10955951f, -0.20532958f, 0.24587904f, 0.28169778f, 
    -0.11805811f, -0.04775022f, 0.06158483f, 0.14616792f, -0.04517724f, 0.15447657f, -0.00851742f, 0.02061684f, 
    0.17987257f, -0.18204717f, 0.14530647f, -0.02070293f, -0.00616145f, -0.00643986f, -0.04486994f, 0.07314216f, 
    -0.19580302f, -0.19390608f, -0.12878479f, -0.13260789f, 0.17631522f, 0.01073673f, 0.38887504f, 0.15164886f, 
    0.02952730f, -0.13338543f, -0.01349680f, -0.00634490f, -0.01286873f, 0.04362665f, 0.01976260f, 0.02998780f, 
    -0.12434635f, -0.07920232f, 0.01841475f, -0.08858707f, 0.03587656f, -0.06715484f, 0.23671621f, 0.21042891f, 
    0.05873178f, -0.01725284f, -0.12919094f, -0.06670102f, -0.01545582f, 0.07103253f, 0.13062227f, 0.02847115f, 
    0.04565335f, 0.09729040f, 0.01506665f, -0.05432071f, -0.00846265f, -0.02732978f, 0.05332470f, -0.01917404f, 
    0.25631770f, 0.27320915f, 0.15235075f, 0.06603899f, -0.03277195f, 0.00207804f, -0.12202795f, 0.03968819f, 
    0.01081950f, 0.07508776f, 0.07273564f, 0.04484524f, 0.46017578f, 0.09223361f, 0.13442388f, -0.11605774f, 
    -0.08867223f, -0.04519380f, 0.00324356f, 0.00908104f, -0.05834167f, 0.10850766f, -0.04896292f, -0.01694674f, 
    0.11505336f, 0.30933708f, 0.13819963f, 0.31278452f, 0.02284293f, 0.02680678f, -0.09024962f, 0.03665849f, 
    -0.06578682f, -0.03350909f, -0.03323141f, 0.04694281f, 0.18682979f, -0.11083434f, 0.00960957f, 0.22958215f, 
    -0.05896499f, 0.11009505f, 0.03634973f, 0.21039006f, 0.04671459f, -0.00054151f, 0.12926325f, 0.04671099f, 
    0.16465767f, -0.06700829f, -0.01551493f, 0.09966537f, 0.01655655f, -0.10488775f, -0.10187226f, -0.15756115f, 
    0.03754697f, -0.00951496f, -0.10580093f, 0.03702831f, -0.08805583f, 0.13975307f, 0.01387615f, 0.02625134f, 
    -0.07783806f, 0.05846675f, 0.04919795f, -0.02875324f, -0.16352892f, -0.00124036f, -0.02484123f, -0.06790406f, 
    -0.08303232f, 0.03902138f, -0.03130893f, 0.13983534f, 0.10362334f, 0.08428552f, -0.07201916f, -0.12029514f, 
    -0.05835863f, 0.08619488f, 0.03609779f, -0.05555390f, 0.11910598f, 0.08316588f, 0.09784821f, 0.06264533f, 
    0.22227670f, 0.08852921f, 0.03073595f, -0.07548586f, -0.07607916f, 0.05255548f, 0.01697329f, -0.02759252f, 
    0.03524421f, 0.09923624f, 0.03028958f, 0.01372618f, 0.02743118f, 0.05198193f, 0.09201379f, 0.03649796f, 
    -0.04378853f, 0.01043504f, 0.02018966f, -0.04347313f, 0.14515084f, 0.11941887f, 0.22526768f, 0.00339992f, 
    -0.16960311f, -0.08138275f, -0.09791061f, -0.06303594f, -0.14869283f, 0.17027904f, 0.06893296f, -0.09454039f, 
    0.36562398f, 0.32867572f, 0.04731963f, -0.13973582f, -0.17359434f, -0.13918832f, -0.17863296f, 0.01496743f, 
    -0.03118602f, 0.01198125f, 0.04613989f, 0.02206833f, 0.32432657f, 0.13506310f, -0.16255440f, -0.30796731f, 
    0.02685973f, -0.01404061f, 0.17607526f, 0.09969880f, -0.07443433f, 0.09935653f, 0.21966982f, -0.11701792f, 
    0.22012593f, 0.09870195f, 0.19968085f, -0.15490802f, -0.05266003f, -0.07862563f, -0.11829750f, -0.13669029f, 
    0.02557121f, 0.04412586f, 0.05110507f, 0.04140403f, 0.06619857f, -0.23038827f, -0.28446296f, -0.18809152f, 
    -0.04877882f, -0.16250998f, 0.06711909f, 0.09988523f, -0.26316279f, 0.05712078f, -0.08439265f, -0.30367494f, 
    -0.02823788f, 0.00584022f, -0.16509469f, -0.12508370f, 0.09577461f, 0.04428240f, -0.02971460f, 0.04796032f, 
    -0.08762842f, -0.24206486f, -0.28964397f, -0.06268883f, 0.08253685f, 0.19114082f, 0.07547589f, 0.16029575f, 
    -0.05416656f, 0.04304919f, 0.09423535f, -0.07003411f, 0.03828856f, -0.05173047f, -0.00228906f, 0.02284671f, 
    0.07044099f, 0.21127486f, 0.21348269f, 0.28113559f, -0.09785487f, 0.01439618f, 0.14646904f, 0.02418991f, 
    -0.16361009f, 0.07008556f, 0.08652718f, -0.04441516f, 0.15455750f, -0.23483919f, -0.12132543f, 0.22893904f, 
    -0.17786637f, 0.04084090f, 0.33911854f, 0.13356610f, -0.10321622f, -0.04416947f, -0.01799047f, 0.24005535f, 
    0.18412635f, 0.11926713f, 0.06147319f, 0.00302657f, -0.06827891f, 0.01581790f, -0.03741015f, -0.01356700f, 
    0.06523784f, 0.07624208f, 0.15781127f, -0.01662101f, 0.05170590f, 0.05330040f, 0.36826780f, 0.39550215f, 
    0.00424052f, 0.10232961f, 0.11202630f, 0.02085715f, 0.04172235f, 0.04238566f, 0.06644001f, 0.09939571f, 
    0.15986478f, 0.11135585f, -0.01210249f, -0.05765628f, -0.01862314f, -0.01172456f, -0.05849100f, -0.11545993f, 
    0.03362168f, 0.06818905f, 0.13119131f, -0.07923582f, -0.02723921f, -0.02464696f, -0.02425432f, 0.25433448f, 
    0.04016783f, 0.04394437f, 0.09923432f, 0.07612055f, 0.05462020f, 0.10463104f, -0.04779872f, -0.03744102f, 
    -0.13597409f, -0.13381253f, -0.07134330f, 0.38474879f, -0.04626180f, -0.12539043f, 0.03531273f, -0.04615030f, 
    -0.01177947f, -0.00692082f, 0.18393959f, 0.10896830f, -0.00871090f, -0.19094345f, -0.28363344f, 0.13933390f, 
    0.00696196f, 0.03011557f, 0.23264331f, 0.08519758f, -0.03817259f, -0.07585155f, -0.06232255f, -0.03382332f, 
    -0.05719053f, -0.02922734f, -0.04946106f, 0.02743629f, -0.02971101f, 0.03703630f, -0.05387403f, -0.04014779f, 
    -0.02541494f, 0.00636495f, 0.04163091f, -0.05833164f, -0.05622419f, -0.03501028f, -0.02730161f, -0.01790004f, 
    -0.04813570f, 0.02650156f, -0.04339766f, 0.01751684f, -0.05438288f, -0.04442120f, 0.04255819f, 0.01170356f, 
    -0.03397121f, -0.04788049f, 0.02199098f, -0.03330561f, 0.00067141f, -0.03263734f, 0.02459859f, -0.01168612f, 
    0.01559795f, -0.01956431f, 0.01750345f, -0.01112754f, 0.00478389f, -0.04071977f, 0.02630427f, -0.03293088f, 
    -0.03641448f, -0.01158796f, -0.00301400f, 0.01303444f, -0.05209136f, -0.00741216f, 0.03912770f, -0.00320644f, 
    -0.02507216f, -0.04475372f, -0.00086445f, 0.02279961f, 0.02984398f, 0.04165597f, -0.00516843f, -0.00439524f, 
    0.02875075f, 0.00133385f, -0.02039241f, 0.00368106f, -0.00280473f, 0.00613016f, -0.00374153f, -0.03546354f, 
    -0.04891510f, -0.03369786f, 0.01668258f, -0.01993102f, -0.01779338f, -0.03793298f, -0.01691353f, -0.04061076f, 
    0.00630415f, -0.03637462f, -0.02338830f, 0.00341519f, -0.02689903f, 0.00231585f, -0.00881995f, 0.00050879f, 
    -0.05883104f, -0.02181754f, 0.03665918f, 0.00352642f, 0.02775222f, 0.04663424f, 0.03658324f, -0.04133245f, 
    -0.03858598f, 0.02576280f, -0.05189790f, -0.01428608f, 0.03912921f, -0.00535765f, 0.02076437f, 0.02361026f, 
    -0.01728688f, -0.02133982f, -0.01452950f, -0.04538868f, -0.05473783f, -0.03868809f, 0.02709752f, 0.04056510f, 
    -0.00864962f, -0.05360883f, -0.03070775f, 0.03430560f, 0.02504906f, 0.01407378f, 0.04351033f, -0.02268411f, 
    0.01894391f, -0.01862167f, -0.00431012f, -0.02588136f, 0.00387696f, -0.02224110f, 0.00448946f, 0.01900861f, 
    -0.03686382f, 0.00364566f, 0.00680401f, 0.03051816f, -0.02576080f, -0.01553636f, 0.02293848f, 0.03392514f, 
    -0.02100538f, 0.00087544f, 0.03993718f, 0.01982781f, 0.00620392f, -0.02717865f, -0.01614568f, -0.01021871f, 
    0.03371711f, -0.05282251f, -0.02324144f, -0.05384185f, 0.01882657f, 0.01322164f, 0.00888606f, 0.02612665f, 
    -0.05357564f, 0.01411473f, -0.05294080f, -0.03098494f, -0.02790765f, 0.00527461f, -0.02826019f, 0.02317292f, 
    0.00903636f, 0.04104766f, 0.03591729f, 0.02186702f, 0.01529499f, 0.04914933f, 0.04967229f, 0.02134286f, 
    0.01060628f, 0.03879236f, 0.01034873f, -0.03090278f, 0.02779914f, 0.03486304f, -0.00672630f, 0.03902001f, 
    0.01982648f, 0.02974476f, -0.04944898f, 0.01825858f, 0.03027921f, 0.01604806f, -0.05121403f, -0.01609707f, 
    -0.03993219f, 0.03816163f, -0.01869968f, -0.04719651f, 0.01073473f, -0.00694374f, -0.03592063f, -0.01196573f, 
    -0.04743072f, 0.04007426f, 0.01564765f, 0.00717607f, -0.04966719f, 0.04107120f, -0.03503566f, -0.00560096f, 
    0.05016832f, 0.01295250f, 0.02981005f, -0.04276557f, 0.00620289f, -0.04806407f, -0.04581810f, -0.03610631f, 
    0.03209234f, 0.03788684f, 0.04314192f, 0.03108846f, -0.04827201f, 0.04684852f, 0.01868145f, -0.04660354f, 
    -0.02058775f, 0.00513258f, -0.01076859f, 0.01302053f, -0.01829785f, -0.05439904f, -0.00445105f, -0.01179038f, 
    -0.02507709f, -0.05573859f, 0.02123741f, -0.00107060f, -0.00082053f, -0.05174129f, -0.00843906f, -0.03288359f, 
    0.02847012f, -0.03854635f, 0.00608705f, 0.01402369f, 0.03561947f, 0.01151675f, -0.05420509f, -0.01425911f, 
    0.02021196f, 0.00556616f, -0.05054006f, 0.01515655f, -0.00263006f, 0.03176491f, 0.01878328f, 0.03981351f, 
    -0.03870937f, -0.02251711f, -0.01132793f, -0.05016041f, -0.01584223f, 0.02439628f, 0.01411619f, -0.01278948f, 
    -0.01815470f, 0.01686649f, 0.02945234f, 0.03367376f, -0.02778677f, -0.00791316f, 0.04755433f, 0.03334824f, 
    0.03119473f, -0.01957222f, -0.04980691f, 0.00137093f, 0.00751071f, 0.02552287f, 0.01394039f, -0.04901974f, 
    -0.04941998f, -0.04726957f, 0.00837314f, -0.05011888f, 0.01024477f, -0.00512699f, -0.02319657f, -0.02524980f, 
    -0.05539845f, -0.00518285f, -0.02583155f, -0.01677894f, -0.03616137f, 0.03879536f, -0.04086811f, 0.03170420f, 
    -0.04196036f, 0.03190979f, -0.01691059f, -0.00730054f, -0.01713178f, -0.03511677f, 0.02527754f, 0.00871563f, 
    0.03170909f, -0.03775718f, 0.02770560f, -0.05242933f, -0.03992615f, -0.00217583f, -0.05818274f, 0.01074580f, 
    -0.00563470f, 0.02392974f, 0.02144284f, 0.00176343f, 0.03047712f, 0.01144884f, -0.05483190f, -0.00530199f, 
    -0.04123878f, 0.03415873f, 0.03346548f, -0.01910427f, -0.00861695f, 0.02204244f, -0.04292661f, -0.00257363f, 
    -0.02417370f, -0.02750584f, -0.00327909f, -0.03331649f, 0.04352969f, 0.00807140f, -0.00830800f, -0.02902598f, 
    0.02154441f, -0.03061442f, -0.03598638f, 0.01238090f, 0.02468971f, -0.01627887f, -0.04223147f, 0.00492080f, 
    0.01034308f, -0.02658811f, -0.02694784f, -0.03262730f, -0.00512652f, 0.02883320f, 0.01735663f, 0.01542958f, 
    0.00641969f, -0.00383249f, -0.03302665f, -0.02887828f, -0.02657337f, 0.03660990f, -0.02450526f, -0.05872902f, 
    0.01529479f, -0.04606358f, 0.03975416f, -0.01306157f, -0.01309999f, -0.03896499f, -0.01834488f, 0.03060692f, 
    -0.05800746f, -0.04789304f, -0.00752287f, -0.02502538f, -0.04558545f, -0.01961104f, -0.01902149f, 0.00712003f, 
    -0.03084965f, 0.03111578f, -0.04570610f, 0.02391714f, -0.04091102f, -0.05225097f, -0.03466438f, -0.00888144f, 
    0.03115384f, -0.03684461f, 0.01378247f, -0.00015451f, -0.03074336f, -0.03104704f, -0.02376077f, -0.01233207f, 
    -0.04328632f, 0.00444230f, -0.03620904f, -0.01594317f, 0.02443784f, -0.00484390f, 0.01792369f, 0.02413777f, 
    -0.10430509f, 0.19301808f, 0.10300469f, 0.05037416f, -0.09231542f, 0.08741129f, -0.02657724f, -0.00106794f, 
    -0.05635212f, 0.11962776f, 0.00958383f, 0.20991333f, 0.06043433f, 0.32091579f, 0.06942419f, -0.12862179f, 
    -0.07762233f, -0.04552879f, 0.06749763f, 0.08504013f, 0.10827171f, 0.03371993f, 0.01284317f, 0.02089708f, 
    -0.12791882f, -0.12220716f, -0.23474769f, -0.15682083f, -0.00553116f, 0.05760316f, 0.01474489f, -0.08122739f, 
    0.04119203f, 0.08057023f, -0.03253495f, 0.11948144f, 0.02151637f, -0.12277628f, -0.05380271f, -0.13662940f, 
    -0.03276183f, 0.01362154f, -0.08925080f, 0.07946213f, -0.03357622f, 0.07331415f, -0.09315884f, 0.02714224f, 
    0.12713787f, -0.05161143f, 0.03511625f, -0.10377961f, 0.05870000f, 0.07225530f, -0.01267493f, 0.02379909f, 
    -0.24171495f, 0.02464735f, -0.04070440f, -0.04492673f, 0.47680640f, -0.06674676f, 0.30739081f, -0.15862584f, 
    0.19097437f, -0.16106719f, -0.05769089f, -0.01109476f, 0.03798409f, 0.06594845f, 0.24820572f, 0.07173596f, 
    -0.09387627f, -0.19619094f, -0.06006690f, 0.15420848f, 0.04626289f, 0.00891379f, 0.04944068f, 0.02889491f, 
    0.05839745f, 0.05844350f, 0.00872111f, 0.02481610f, -0.12012479f, 0.05188324f, -0.05417439f, 0.07807864f, 
    0.09112551f, -0.13296834f, 0.13096194f, 0.04383544f, 0.11780386f, 0.10365359f, 0.19460034f, 0.22303241f, 
    0.05282929f, 0.17774336f, 0.12463311f, -0.06631153f, -0.07629601f, -0.03838187f, -0.07469054f, 0.00687510f, 
    -0.08573333f, 0.01520846f, -0.00131528f, 0.13923274f, 0.22024624f, 0.37978658f, 0.11306674f, -0.33412671f, 
    -0.12962371f, -0.06617976f, 0.04447384f, -0.04182800f, -0.04273874f, 0.04796882f, 0.02713526f, 0.03206041f, 
    -0.53573924f, 0.13861638f, 0.20879239f, 0.07250386f, -0.24192935f, -0.11461981f, -0.24599531f, -0.13156463f, 
    -0.13193907f, 0.13578221f, 0.03001733f, 0.03663461f, 0.10865643f, -0.12896229f, -0.15128274f, 0.10022569f, 
    0.00571171f, 0.15849052f, -0.14811333f, 0.09845030f, 0.01488861f, -0.05115640f, 0.24076052f, -0.04987661f, 
    0.24531388f, -0.06732701f, -0.09754793f, -0.10007022f, -0.01408175f, -0.07352359f, 0.01947943f, -0.09088425f, 
    -0.08241192f, -0.06408179f, -0.09180980f, -0.09218207f, -0.00177832f, 0.26617700f, -0.18920672f, -0.07167988f, 
    0.14815027f, -0.02326426f, 0.10678405f, 0.19243908f, -0.07999413f, -0.13241461f, -0.01825611f, -0.17976098f, 
    0.47338665f, 0.11420573f, -0.07030660f, 0.24469702f, -0.03889523f, 0.04342935f, 0.04509486f, 0.05620712f, 
    0.01055063f, -0.02312720f, 0.18560615f, 0.01178986f, -0.08938277f, -0.21323574f, 0.39753649f, -0.07525524f, 
    0.10394406f, 0.05292004f, -0.14495116f, 0.15942371f, -0.05505687f, 0.02110114f, 0.11948584f, 0.00673679f, 
    -0.18922967f, 0.36636162f, -0.25664943f, 0.00604614f, -0.01668838f, 0.05036609f, 0.21291146f, -0.15895592f, 
    -0.10254768f, 0.12982728f, 0.14705251f, -0.03879358f, -0.13200071f, 0.02177827f, 0.11899597f, 0.13962346f, 
    0.02956719f, -0.01562794f, 0.06943466f, 0.01652295f, -0.05148264f, 0.12394521f, -0.06920629f, -0.06391151f, 
    -0.02250008f, 0.27158424f, 0.01691490f, 0.05581799f, -0.10802942f, 0.12429383f, -0.08571873f, -0.01569250f, 
    0.03090524f, 0.01239253f, -0.06526976f, -0.03676302f, 0.03547841f, -0.10920765f, -0.23649848f, -0.07864860f, 
    0.10991387f, 0.06153032f, 0.03670442f, -0.04342236f, 0.06140989f, 0.15888967f, 0.07454104f, 0.15649372f, 
    0.42308092f, 0.09399819f, -0.02596531f, -0.00242820f, -0.02613047f, -0.14462169f, -0.01794961f, -0.11753368f, 
    0.12568578f, 0.07673552f, 0.05545079f, -0.00644383f, -0.21017101f, -0.32893664f, -0.11036307f, -0.05514459f, 
    0.13790722f, 0.14950988f, 0.14882398f, 0.19162370f, 0.03944317f, 0.01909867f, -0.04990285f, -0.05002024f, 
    0.13681148f, 0.46301681f, -0.22591469f, -0.00308151f, 0.17953789f, 0.10134664f, 0.24281964f, 0.05564130f, 
    -0.07488625f, -0.01103169f, -0.14291869f, 0.00411539f, -0.11592042f, 0.11539918f, -0.19771516f, -0.06243460f, 
    0.04587880f, -0.05047199f, 0.06363550f, -0.12187846f, 0.01869751f, -0.02301299f, 0.16978277f, 0.17960405f, 
    0.05253129f, -0.27619761f, 0.18391475f, 0.17285077f, 0.06171834f, -0.03790862f, -0.03148403f, 0.10344221f, 
    -0.24751572f, 0.17587207f, -0.15659733f, -0.13086979f, -0.28092858f, 0.17370890f, 0.05384973f, 0.22679619f, 
    -0.01226272f, 0.23226811f, 0.19294752f, 0.16264732f, -0.07033095f, 0.12617081f, 0.00366730f, 0.00289573f, 
    0.09389169f, -0.09078144f, 0.05960605f, -0.25120643f, -0.01848730f, -0.00019872f, -0.05065545f, -0.07153049f, 
    -0.15316747f, 0.08205764f, -0.07380427f, -0.07530399f, 0.05535449f, -0.16049309f, 0.02760134f, -0.03595908f, 
    0.07800390f, 0.07156765f, 0.03300206f, -0.08428942f, 0.06030478f, 0.07848535f, -0.04946911f, 0.02512851f, 
    -0.22187525f, 0.18891217f, -0.35984284f, -0.11904556f, -0.11146130f, -0.10300314f, -0.03013971f, -0.20668258f, 
    -0.09731600f, -0.01296367f, 0.03751873f, -0.13954389f, -0.03609817f, -0.13744761f, -0.02001930f, -0.00221737f, 
    0.02934922f, 0.00355125f, 0.11694672f, -0.00104540f, 0.01387665f, -0.11690610f, 0.02080316f, -0.07844792f, 
    -0.03365510f, -0.28909290f, -0.25287241f, 0.15757684f, 0.02763931f, -0.06671431f, 0.12118753f, 0.08012716f, 
    -0.02383387f, 0.10860984f, 0.17474516f, 0.05044651f, -0.12977327f, 0.08660545f, -0.09709358f, 0.28002489f, 
    0.04240417f, 0.17357916f, 0.11376053f, 0.07597980f, 0.01383290f, -0.07610639f, 0.10599795f, 0.13948137f, 
    0.01316555f, -0.00468719f, 0.00381645f, -0.11852321f, 0.07053853f, -0.04213198f, -0.13784717f, 0.01437942f, 
    0.05795041f, -0.17601137f, -0.00626467f, -0.04916680f, -0.02208114f, 0.08503746f, -0.10040598f, -0.21962550f, 
    0.02831310f, -0.01156604f, 0.08628746f, -0.00126707f, 0.02745811f, -0.14367910f, -0.04059858f, 0.00771687f, 
    0.02673175f, 0.09135439f, -0.29543927f, 0.14840828f, -0.02631180f, -0.00281607f, -0.12174588f, -0.10612240f, 
    0.04104844f, 0.00400611f, 0.17375986f, 0.09794763f, 0.14810213f, 0.03458568f, 0.42045194f, 0.34944224f, 
    0.15750334f, -0.07943689f, 0.19161201f, -0.17859218f, 0.16712271f, -0.01723072f, 0.00241362f, 0.04359746f, 
    0.01536443f, 0.39039382f, -0.23283164f, 0.11654937f, -0.04199864f, 0.10124140f, -0.00748535f, 0.03769596f, 
    0.12398264f, 0.09141173f, 0.03285926f, 0.04791574f, 0.37159941f, -0.34412116f, 0.12264317f, 0.08774762f, 
    0.04378586f, -0.14129364f, -0.07745987f, -0.00414883f, -0.03675301f, 0.05441395f, 0.02696187f, -0.03988335f, 
    0.04752215f, -0.26338008f, -0.38138935f, -0.16856617f, 0.18683252f, -0.08259566f, 0.00139380f, -0.01701421f, 
    0.10857276f, 0.01170986f, -0.00433547f, 0.23713483f, 0.06677140f, -0.08763217f, -0.03289566f, 0.00134612f, 
    -0.03122757f, -0.07448376f, 0.09528175f, -0.04180031f, -0.02146909f, 0.03617274f, -0.14476342f, -0.06128614f, 
    -0.03954578f, -0.06057901f, -0.05125187f, -0.08566675f, -0.00250359f, 0.02560235f, -0.11239127f, -0.01510599f, 
    0.14256373f, -0.13327974f, -0.01968969f, -0.04917617f, -0.08317833f, 0.11089054f, 0.24254677f, -0.05233733f, 
    -0.09505899f, 0.11998937f, 0.15971573f, -0.07598693f, 0.01603160f, -0.05243193f, 0.07834180f, 0.18710600f, 
    0.05418618f, 0.01956514f, -0.07846906f, 0.14394675f, -0.00828544f, -0.04603123f, 0.01975193f, -0.17415991f, 
    0.00419001f, 0.00890165f, -0.00516529f, -0.00824429f, -0.13752665f, 0.16981179f, 0.02528219f, 0.00902962f, 
    0.25809518f, -0.14766264f, -0.03624944f, -0.18430534f, 0.02175728f, -0.05168632f, 0.03876419f, 0.04225172f, 
    -0.22107591f, -0.13186786f, -0.02130316f, -0.07271764f, -0.13840477f, -0.02950618f, 0.16536540f, 0.09113764f, 
    -0.04450956f, 0.07752763f, 0.18979679f, 0.13701507f, 0.28373131f, -0.01062446f, 0.40680081f, -0.19110450f, 
    0.11127506f, 0.04775149f, -0.10074356f, -0.19614221f, 0.05817666f, 0.02722763f, -0.00878366f, -0.00743085f, 
    0.40157995f, -0.03589774f, -0.09641947f, 0.15484135f, 0.02050924f, -0.08223765f, 0.04061891f, 0.17566827f, 
    0.03768511f, 0.13672882f, -0.09808905f, 0.11761569f, -0.06004598f, 0.28671074f, -0.18351692f, 0.19384092f, 
    0.06183554f, 0.08693017f, 0.01832132f, 0.21899094f, 0.01159757f, -0.08788584f, -0.07042539f, -0.03094791f, 
    -0.00439572f, -0.01667427f, -0.11117251f, -0.15534426f, 0.00191835f, 0.02189200f, 0.14689916f, 0.05057140f, 
    -0.15175383f, 0.05291851f, 0.06648584f, -0.01367282f, -0.09693735f, 0.02765073f, -0.19540679f, 0.14113827f, 
    -0.03091528f, -0.00816303f, 0.22648239f, 0.14173311f, 0.25577340f, -0.01006259f, 0.00616798f, -0.02765502f, 
    0.40831906f, -0.10701428f, 0.26610789f, -0.09251156f, 0.13163188f, -0.04609988f, 0.10569969f, 0.09635486f, 
    0.08093426f, -0.00501077f, -0.08739365f, -0.10195305f, 0.16180634f, -0.33713380f, 0.02059761f, 0.18064094f, 
    0.08212895f, -0.04185503f, -0.12980761f, -0.08111052f, 0.13349727f, 0.06493672f, 0.07019991f, -0.13546999f, 
    0.28229395f, -0.21970941f, 0.02005043f, 0.10794973f, 0.17622881f, -0.09235972f, 0.04840542f, 0.05572846f, 
    -0.02458741f, 0.19567336f, 0.11843804f, -0.03582570f, 0.00806157f, -0.30389056f, -0.13138215f, -0.13992859f, 
    0.00641435f, 0.08758923f, -0.09516563f, -0.00195670f, 0.25697687f, -0.15820187f, -0.02049541f, 0.07048924f, 
    -0.17515697f, 0.14720081f, -0.02602961f, -0.06381739f, 0.04587667f, 0.08065735f, 0.09460960f, 0.20822684f, 
    -0.06208249f, -0.06116237f, 0.07548069f, 0.11316907f, 0.09843421f, -0.07580123f, 0.09292857f, -0.27205336f, 
    0.04216132f, -0.04829211f, -0.16663033f, -0.00264046f, -0.11716978f, -0.12645337f, 0.04946147f, -0.10242016f, 
    -0.39521939f, -0.07049675f, -0.06446790f, -0.51012582f, 0.03855493f, 0.08666390f, 0.05832060f, -0.04771820f, 
    0.21744724f, 0.04385328f, -0.12544692f, -0.07603921f, -0.44261384f, -0.08512334f, 0.13202170f, -0.15721518f, 
    0.08783291f, 0.23508088f, -0.04784606f, -0.01111975f, -0.08428048f, 0.03614184f, 0.24003269f, -0.05892724f, 
    0.12417436f, -0.03387952f, -0.09775321f, 0.06676181f, 0.08884593f, 0.02134723f, 0.03270717f, -0.02065555f, 
    0.09961793f, 0.12440515f, -0.07621763f, 0.07264350f, 0.02629183f, -0.03600721f, 0.06326647f, 0.35910940f, 
    0.00202899f, 0.13331658f, -0.10925214f, 0.15730242f, 0.08307593f, 0.04456959f, -0.13364202f, 0.13505544f, 
    0.01135709f, -0.16913614f, -0.03530061f, -0.00225371f, 0.04530957f, -0.03508383f, 0.21234791f, 0.14310282f, 
    0.09030066f, 0.14202176f, -0.00125940f, 0.07028122f, -0.02479590f, -0.19138484f, 0.23954798f, 0.22740091f, 
    0.03350779f, 0.16993318f, -0.05359551f, 0.03305242f, 0.11876972f, 0.14074993f, 0.13013382f, 0.09551679f, 
    0.00161641f, 0.04345471f, 0.18585090f, 0.03338600f, -0.01207002f, 0.04409028f, 0.15126051f, -0.01261539f, 
    0.05990050f, 0.34756604f, 0.04136463f, -0.11907145f, -0.35810792f, -0.38861519f, -0.36513713f, -0.17722888f, 
    -0.02539479f, -0.04604501f, 0.13258423f, 0.12014382f, -0.04835090f, 0.05919306f, 0.14149396f, 0.07072273f, 
    0.38863659f, 0.12649980f, -0.00153492f, 0.09429898f, 0.05703750f, 0.10712293f, 0.07652452f, -0.04350781f, 
    0.08042838f, -0.03061867f, -0.09067849f, -0.08285681f, 0.06802846f, -0.11161543f, 0.21867877f, 0.15320998f, 
    0.00819340f, 0.13220575f, 0.01692598f, 0.04652945f, 0.10625570f, 0.09778328f, -0.02857786f, -0.00458688f, 
    -0.13281587f, -0.00610273f, 0.26388380f, 0.43592840f, 0.04181252f, 0.01377498f, -0.09752599f, -0.00823160f, 
    -0.07350185f, -0.00093036f, 0.06756241f, 0.08084135f, -0.10374568f, -0.11603159f, 0.02085613f, 0.05809885f, 
    0.03565514f, -0.00925922f, 0.09795909f, -0.17716631f, -0.08405910f, -0.16698034f, -0.01318818f, -0.03119373f, 
    -0.19506143f, 0.16411449f, 0.16661103f, 0.12923306f, -0.01879985f, -0.00973699f, -0.03792983f, 0.00110516f, 
    0.17991756f, -0.03295478f, 0.12908716f, 0.24622740f, 0.24233526f, 0.33619851f, -0.16106866f, 0.10778573f, 
    -0.16391014f, 0.04129962f, 0.14539883f, -0.00376042f, -0.00048548f, -0.07298430f, -0.08349245f, -0.07764376f, 
    -0.07164099f, 0.02414663f, -0.09497979f, -0.13910449f, -0.18802607f, -0.21258754f, 0.05162015f, 0.05020066f, 
    -0.09999809f, -0.05370197f, 0.13447399f, 0.07305191f, 0.12450745f, 0.02293042f, -0.00501126f, 0.07761808f, 
    -0.11662405f, 0.20040852f, 0.08639868f, 0.00451716f, 0.03935792f, 0.01255177f, -0.18438189f, -0.11328314f, 
    0.44196528f, 0.11285772f, -0.11105462f, 0.23662333f, 0.07993294f, 0.02493462f, 0.08363937f, 0.02577810f, 
    0.02326918f, 0.02973796f, 0.02040145f, -0.01630694f, -0.08140231f, 0.39249763f, -0.29057837f, 0.19665574f, 
    -0.11707841f, 0.13574065f, 0.07562038f, 0.02189628f, 0.03006370f, -0.14893556f, 0.04268498f, 0.07711276f, 
    0.51715791f, -0.08513108f, 0.20553036f, -0.14319749f, 0.07220180f, -0.01159845f, 0.10474106f, -0.05743558f, 
    -0.07397857f, 0.02268670f, -0.06880049f, -0.23627241f, -0.00436105f, -0.05796929f, -0.01749710f, 0.00806366f, 
    0.09929769f, -0.14472812f, -0.12093744f, 0.13605340f, 0.04925795f, 0.00194937f, -0.09512366f, -0.02230454f, 
    -0.26372412f, 0.01297485f, -0.00503935f, -0.08261210f, 0.01431963f, 0.02165969f, 0.09080776f, -0.05722785f, 
    -0.00166053f, 0.07123790f, 0.06969674f, 0.07589637f, -0.03175902f, -0.15004675f, 0.06010133f, 0.07825675f, 
    -0.13466203f, -0.06962913f, 0.06082071f, -0.14547421f, -0.03105250f, -0.00610807f, 0.04792076f, -0.01266989f, 
    -0.26393971f, -0.02840379f, -0.09398997f, -0.10764140f, -0.07547705f, 0.08559806f, 0.20282833f, 0.08320775f, 
    -0.09220495f, -0.08570859f, 0.00855751f, -0.00173833f, 0.34255692f, 0.03646338f, -0.15190050f, -0.08669692f, 
    -0.12290797f, -0.18537304f, 0.32748148f, -0.01123813f, 0.09037116f, -0.00408131f, -0.15375462f, -0.01897826f, 
    0.06156406f, -0.06296208f, -0.15907848f, 0.12487156f, 0.13356809f, 0.27434528f, 0.11913127f, 0.15549606f, 
    0.14886874f, -0.04037543f, 0.07790352f, 0.10676862f, 0.24003473f, 0.02243272f, -0.19530995f, 0.02075104f, 
    0.01649069f, 0.09492736f, 0.19338155f, 0.10495608f, 0.18361457f, 0.01920568f, 0.10295298f, 0.14052345f, 
    0.23460580f, -0.02715939f, 0.06451806f, 0.07481956f, 0.18305917f, -0.06862895f, 0.04045091f, 0.13826653f, 
    -0.04847774f, -0.05405638f, -0.10347651f, -0.09342553f, -0.10034613f, 0.03229091f, 0.04663599f, 0.37163854f, 
    0.06096874f, 0.01706480f, -0.11857884f, -0.01889334f, 0.06362744f, -0.21986948f, -0.04464785f, 0.01909860f, 
    -0.18992577f, 0.15932113f, 0.09201593f, 0.10715382f, -0.03871449f, 0.07325993f, -0.04531531f, 0.07763125f, 
    0.00745566f, 0.01734985f, -0.08776803f, 0.02131855f, 0.16196357f, 0.37233314f, 0.18343952f, 0.09543011f, 
    -0.13848796f, -0.10646079f, -0.13198423f, -0.18175039f, 0.18237238f, 0.18687843f, 0.11901442f, 0.12267781f, 
    -0.11479016f, -0.07328780f, 0.05256401f, 0.06362730f, 0.10298416f, 0.22215697f, -0.13989350f, -0.06327277f, 
    0.08506773f, 0.07778325f, 0.19709539f, 0.20869607f, 0.10961005f, -0.18182515f, 0.19120173f, 0.05260523f, 
    -0.01702954f, 0.19046848f, -0.00412140f, 0.08441988f, -0.15962644f, -0.11799502f, -0.16123578f, -0.21045323f, 
    -0.28467661f, 0.06114412f, -0.25077999f, -0.33137226f, -0.04559189f, 0.01169290f, 0.10180143f, -0.19043434f, 
    0.14831237f, -0.06182810f, -0.03555792f, 0.00861790f, 0.09429208f, -0.21528803f, 0.39108488f, -0.10098273f, 
    0.04471016f, -0.16262956f, -0.17781663f, 0.11015134f, 0.15315191f, 0.03033982f, 0.17325723f, -0.14817391f, 
    0.02806638f, -0.01180437f, 0.06986052f, 0.15645650f, 0.01587747f, -0.07063697f, 0.07180610f, -0.02147015f, 
    0.23872446f, 0.00870632f, -0.07767461f, 0.33832705f, -0.12799494f, 0.00949795f, -0.14620541f, -0.15393558f, 
    -0.11049804f, -0.17445801f, 0.00723690f, 0.05021134f, -0.11287853f, -0.00878950f, -0.00809000f, -0.14392073f, 
    0.04275597f, 0.02291206f, 0.08891658f, 0.10416286f, 0.01981080f, 0.04115383f, 0.03327079f, 0.01223881f, 
    0.28165972f, 0.05392572f, 0.13403910f, 0.36623919f, 0.08004509f, 0.02369376f, 0.07783865f, 0.06958261f, 
    0.00295948f, 0.01963026f, -0.05773804f, 0.03876789f, 0.01930987f, 0.09213447f, 0.06507891f, 0.24880311f, 
    -0.04712875f, 0.12265194f, 0.10436469f, -0.16468309f, 0.05497758f, 0.05301297f, -0.03895529f, 0.03801682f, 
    0.02052446f, 0.06095431f, -0.06599570f, -0.06387167f, 0.03982814f, -0.07558774f, 0.22600330f, -0.18905944f, 
    -0.08063715f, -0.23576672f, -0.25077340f, -0.07767638f, 0.02344110f, 0.14934509f, 0.01859812f, -0.02433696f, 
    0.06365289f, 0.08100805f, 0.05829249f, -0.11717275f, 0.03593899f, -0.03404897f, -0.07733658f, 0.04227282f, 
    0.11208297f, 0.08452793f, -0.02580220f, -0.05634613f, 0.18435158f, -0.05673643f, 0.09791776f, 0.14285377f, 
    0.10492239f, 0.04167011f, -0.01475865f, 0.10033329f, 0.18961179f, 0.16550922f, 0.15979470f, -0.00711091f, 
    0.04492001f, 0.00874178f, 0.44377387f, 0.07405114f, -0.06378527f, -0.01695441f, -0.00295901f, -0.04626020f, 
    0.09887752f, 0.00206270f, 0.13721922f, -0.08600330f, -0.32229736f, -0.00283516f, -0.13424619f, 0.02102946f, 
    0.00677437f, -0.00502840f, -0.00477806f, 0.17373705f, -0.00879600f, 0.07591879f, 0.05469809f, 0.04596009f, 
    -0.32055497f, 0.31426635f, 0.06197787f, 0.22016591f, 0.11596938f, -0.00615155f, -0.04393434f, -0.08369871f, 
    -0.00886430f, 0.08317430f, 0.02455408f, 0.10818015f, 0.16075791f, 0.16568406f, -0.26030454f, -0.04008961f, 
    0.11351817f, -0.11402532f, -0.07307044f, -0.08832849f, 0.01992035f, -0.01463652f, 0.02470110f, -0.01500603f, 
    -0.01044394f, -0.07382143f, 0.12401257f, 0.00046503f, 0.09471272f, 0.06963425f, 0.04376531f, 0.13484254f, 
    0.01458107f, -0.04313699f, 0.15235057f, -0.07854050f, 0.04573928f, 0.02581316f, -0.10414065f, -0.11648535f, 
    -0.08358439f, 0.14603662f, -0.04822882f, 0.02454327f, 0.14342575f, 0.12528454f, 0.08012620f, 0.15091133f, 
    0.10559350f, 0.10200610f, 0.10821064f, 0.00392363f, -0.02378384f, -0.09164076f, 0.01337361f, -0.04740473f, 
    -0.00222575f, -0.00045260f, -0.09788409f, -0.13292909f, -0.05998938f, -0.00586858f, -0.00661311f, 0.08262863f, 
    -0.01446129f, -0.04291038f, 0.12852386f, 0.05106066f, -0.16877554f, -0.07545644f, -0.05593988f, -0.10981121f, 
    0.33871615f, 0.12669273f, 0.04861452f, -0.11733239f, -0.09767608f, -0.09262154f, -0.00265721f, -0.02855548f, 
    0.01467473f, 0.07995851f, 0.00653053f, -0.12164181f, -0.14261061f, 0.02004090f, -0.07770238f, -0.09982806f, 
    -0.04520984f, -0.18477358f, 0.20793259f, 0.15490437f, 0.00568033f, 0.14943342f, 0.01113534f, 0.17051034f, 
    0.05970980f, -0.02575204f, 0.12469219f, 0.07581543f, -0.06398374f, -0.03282414f, -0.12932998f, 0.01193396f, 
    0.05900812f, -0.12886889f, -0.08833604f, -0.03643385f, -0.05324646f, -0.26848027f, -0.23087662f, -0.13816190f, 
    0.18466124f, 0.11434067f, 0.06058122f, 0.31356314f, 0.09985247f, 0.04393722f, -0.08536609f, -0.02278608f, 
    0.21698788f, -0.17447144f, 0.00944428f, -0.14150600f, 0.10859376f, 0.06871841f, -0.09515374f, 0.09416628f, 
    -0.09644688f, -0.04389919f, 0.16796716f, 0.03709565f, -0.16396646f, 0.21399108f, -0.20075504f, -0.09952794f, 
    0.20555133f, 0.05085603f, 0.12080428f, 0.00284977f, -0.06478047f, -0.01038248f, -0.04489585f, 0.06133123f, 
    0.03960073f, -0.22137052f, 0.09654960f, -0.09065068f, -0.03722464f, 0.04530134f, 0.05077273f, -0.11876342f, 
    0.34601027f, -0.03710208f, 0.08077981f, 0.00442420f, -0.03877222f, -0.03688489f, -0.04946423f, -0.27458018f, 
    0.01116754f, 0.11709018f, -0.02562143f, 0.15902357f, 0.08607077f, 0.05841836f, 0.05173604f, 0.02213633f, 
    0.13028000f, -0.11438298f, -0.17672394f, -0.13430771f, 0.18207212f, 0.00237676f, 0.04595758f, -0.19246748f, 
    -0.02206179f, -0.08446722f, -0.11030752f, -0.01128586f, 0.26836336f, -0.22101578f, 0.00380996f, -0.00435383f, 
    -0.12164259f, -0.08425982f, 0.09295163f, 0.12678705f, 0.04308799f, 0.18069544f, 0.29318514f, 0.29062954f, 
    0.19747788f, 0.22375803f, -0.19287145f, 0.44520485f, 0.01698805f, -0.05955693f, -0.01464903f, -0.17136176f, 
    0.08413307f, 0.00448069f, -0.04219091f, 0.00941405f, -0.03515791f, -0.09118186f, -0.12892763f, -0.15824114f, 
    -0.12126623f, -0.02051529f, -0.13464479f, -0.14339828f, -0.02515857f, 0.02914510f, 0.23259127f, 0.02079841f, 
    0.08134497f, -0.08069555f, 0.12108964f, 0.09018667f, 0.05175348f, 0.02492646f, -0.14547722f, 0.18201365f, 
    0.27437294f, -0.05554913f, -0.05497421f, -0.08270600f, -0.16382237f, -0.07284834f, 0.00993356f, -0.28491083f, 
    -0.02642354f, 0.15806286f, 0.16605537f, -0.07173552f, 0.12189938f, 0.04216690f, -0.02635450f, -0.02237689f, 
    -0.44999263f, -0.21365792f, 0.18049911f, -0.06880262f, -0.04018540f, 0.31524280f, -0.05749859f, 0.22550322f, 
    0.03080295f, 0.00993146f, 0.05086982f, -0.10604361f, 0.44274026f, 0.12959883f, 0.28655538f, -0.26208356f, 
    0.11080956f, 0.09383059f, 0.23420005f, 0.18639876f, 0.01021615f, 0.15706883f, 0.15987363f, 0.18705969f, 
    0.05175205f, 0.11167389f, 0.08509024f, 0.12272729f, -0.03545555f, -0.03786903f, 0.01079128f, -0.00762785f, 
    -0.15016595f, -0.11477983f, -0.05284089f, -0.07160613f, -0.22419861f, 0.01488842f, -0.13168386f, -0.11928982f, 
    0.13319518f, -0.00944678f, -0.01599948f, 0.03987771f, 0.00947290f, -0.04721506f, 0.10518721f, 0.07466041f, 
    0.13555790f, -0.03103269f, 0.12076688f, -0.06735068f, -0.06956890f, -0.16321659f, -0.02580155f, -0.17575993f, 
    -0.13339888f, -0.14172697f, 0.06630918f, -0.23416954f, 0.11738586f, -0.02557559f, 0.12953177f, -0.04918053f, 
    0.03093751f, 0.10391510f, 0.22600168f, 0.16893993f, 0.04809255f, -0.04086027f, 0.07762653f, -0.25838205f, 
    -0.30014977f, -0.19888325f, 0.08220869f, -0.10690559f, 0.01382354f, -0.02994651f, -0.04019703f, 0.12308089f, 
    0.07760633f, -0.08230805f, 0.00298974f, 0.19294031f, 0.36532548f, -0.12251057f, 0.19658037f, -0.04239961f, 
    0.04705349f, 0.10845306f, 0.12410026f, 0.07155845f, 0.13013336f, -0.08207116f, -0.05041748f, -0.00704315f, 
    -0.28774592f, -0.10474996f, -0.02291222f, -0.01762990f, 0.03572203f, -0.06405125f, -0.04784205f, -0.02972662f, 
    0.13148728f, 0.12051542f, 0.03635032f, 0.13204101f, 0.01602067f, 0.06254880f, -0.01984782f, 0.04176166f, 
    -0.02448766f, 0.00789967f, -0.07041001f, 0.10548111f, 0.06544051f, -0.01180277f, 0.09234723f, 0.07965717f, 
    0.28093612f, 0.12486333f, 0.03180920f, -0.06337152f, -0.24718940f, -0.05430419f, -0.00047050f, -0.07613334f, 
    0.07853716f, 0.05683794f, 0.04765650f, -0.00149258f, 0.21510665f, 0.20708786f, 0.11581890f, -0.16514544f, 
    0.20846258f, 0.12110442f, 0.05241594f, 0.10898533f, 0.03154241f, -0.01035316f, -0.03308614f, -0.01408139f, 
    0.21960039f, 0.22834574f, -0.14029297f, 0.12080100f, -0.02576797f, -0.04479852f, 0.03168224f, -0.05662439f, 
    0.08784841f, 0.04887486f, -0.05900498f, -0.30026850f, -0.06139230f, 0.00380044f, 0.11976011f, 0.04346333f, 
    -0.02285769f, -0.08498416f, -0.03176396f, -0.03763233f, 0.03984948f, 0.00101349f, 0.10814571f, 0.13634330f, 
    -0.03049329f, -0.09677243f, -0.03998033f, 0.13511586f, 0.09842212f, 0.01352526f, -0.07928246f, -0.04319208f, 
    -0.04000350f, 0.08884765f, -0.07789041f, -0.03590678f, -0.01323258f, -0.01566095f, 0.00951070f, 0.12366126f, 
    0.05127845f, -0.08931549f, -0.00462497f, 0.16814949f, 0.10515881f, 0.09601498f, 0.13938771f, 0.33858025f, 
    -0.43122235f, -0.04081743f, 0.24511443f, -0.12454370f, -0.01631308f, -0.10473450f, -0.07460223f, -0.05575261f, 
    0.10460198f, -0.02553198f, -0.13152006f, 0.03335011f, -0.15811510f, -0.06786571f, 0.56665128f, 0.03700413f, 
    0.00477181f, -0.12108755f, -0.00294180f, 0.04372475f, -0.13221499f, -0.02839428f, -0.20316751f, 0.04047909f, 
    -0.05701401f, 0.15408640f, -0.13281578f, 0.20368752f, -0.22750533f, -0.18929458f, -0.19889525f, 0.01233815f, 
    0.16903676f, 0.00075371f, -0.09608504f, 0.04245666f, -0.03388331f, 0.08523594f, -0.04043933f, -0.20933510f, 
    -0.01210888f, 0.09551726f, 0.22771294f, -0.03256832f, 0.00576848f, 0.06769459f, 0.05681953f, -0.00136749f, 
    0.11296054f, 0.04353631f, 0.06595302f, 0.01392222f, 0.03821909f, 0.10517862f, 0.03189151f, 0.14735836f, 
    -0.08813997f, -0.26446742f, -0.18424642f, -0.14941478f, -0.12932360f, 0.04340559f, -0.07910313f, -0.27330875f, 
    0.19428243f, 0.00597831f, -0.04156094f, 0.17077319f, 0.09579265f, 0.06963187f, 0.07985137f, 0.05492218f, 
    0.22442506f, 0.06429296f, 0.06721991f, 0.13847178f, 0.05429094f, 0.09139887f, -0.08498421f, 0.24287859f, 
    -0.05610104f, 0.06181936f, 0.03675750f, -0.01472934f, -0.38785034f, -0.02616069f, 0.03518107f, 0.02857710f, 
    0.08217167f, 0.25564951f, -0.05770445f, 0.16686094f, 0.06377721f, -0.03042060f, 0.00437029f, 0.13676237f, 
    -0.12437706f, 0.08167023f, -0.09682200f, -0.16486973f, -0.01446354f, -0.06550775f, -0.02476489f, -0.09919064f, 
    -0.22087738f, 0.05407026f, 0.15086558f, -0.00795610f, -0.39019436f, -0.13026887f, 0.10493904f, -0.05424388f, 
    0.09935085f, -0.04818920f, 0.04539599f, 0.10051325f, -0.00772169f, -0.03545002f, -0.08606003f, -0.10329868f, 
    -0.28911111f, -0.13702223f, -0.03734218f, 0.07236788f, 0.03215373f, 0.11710106f, 0.05964804f, -0.04969811f, 
    -0.02618295f, -0.06976651f, 0.01887449f, 0.01805208f, 0.03075391f, -0.18084989f, -0.03380146f, -0.05947011f, 
    -0.17730010f, -0.08808746f, 0.00473688f, 0.08326417f, 0.18494681f, 0.08924910f, 0.08101952f, 0.05662881f, 
    0.28607190f, -0.09250423f, 0.03804257f, 0.13474393f, 0.07372232f, -0.09548567f, 0.03694836f, -0.01572669f, 
    0.05437912f, -0.10075962f, 0.07056054f, 0.11321665f, -0.18422602f, -0.24378961f, -0.15668653f, -0.04131279f, 
    0.03722371f, -0.04789124f, -0.03295237f, 0.05694643f, -0.01653325f, 0.07359653f, -0.03895588f, 0.10950609f, 
    0.02354563f, 0.14109455f, 0.13062964f, -0.12918396f, -0.01609935f, -0.07935405f, 0.06129723f, 0.03096178f, 
    -0.10167683f, -0.00835241f, 0.00232393f, -0.19665411f, 0.00043548f, 0.01779885f, -0.08425719f, -0.09278889f, 
    0.05196678f, -0.18226919f, 0.05262179f, -0.01995252f, 0.08326387f, 0.03184671f, 0.07468934f, 0.31293583f, 
    0.02450750f, -0.24280500f, 0.09268025f, -0.10046832f, 0.14986297f, -0.00241540f, 0.07721692f, 0.19022271f, 
    0.05310496f, -0.04251807f, -0.02648260f, 0.01020816f, 0.04315558f, 0.10863221f, -0.11454548f, 0.04691165f, 
    -0.01943549f, 0.18990491f, -0.02982548f, -0.17188059f, 0.07871523f, 0.01213882f, -0.01421495f, 0.05682670f, 
    0.01263037f, 0.06961979f, 0.03684627f, 0.06462529f, 0.09014401f, 0.01846476f, -0.07330412f, -0.05799007f, 
    -0.19029912f, -0.08143801f, -0.13581234f, -0.09227572f, 0.23156548f, 0.05135287f, 0.01577952f, 0.16746998f, 
    0.11335944f, 0.18216357f, 0.06833060f, 0.01273134f, -0.06124176f, -0.08385631f, 0.00698062f, 0.24136779f, 
    -0.12043417f, -0.06222163f, -0.00516342f, -0.18172705f, 0.03720544f, -0.05614697f, 0.00559693f, -0.08294383f, 
    -0.22170787f, -0.09873099f, -0.07810891f, -0.24281226f, 0.02289616f, 0.05826849f, 0.08163210f, -0.09192470f, 
    0.14892358f, -0.03173102f, 0.04842971f, -0.04360084f, -0.04698894f, -0.03552055f, -0.05633467f, -0.29686040f, 
    0.14926720f, -0.02496889f, -0.02946623f, -0.06291430f, 0.11070163f, 0.25447741f, 0.09938622f, 0.13921723f, 
    -0.00258540f, -0.16948406f, 0.06315077f, 0.05081020f, -0.08099282f, 0.10098492f, -0.08992418f, 0.08538269f, 
    -0.05373243f, 0.03803942f, -0.05251968f, -0.01508580f, 0.06312814f, -0.06022805f, 0.07903939f, 0.06520700f, 
    0.09651732f, -0.05446575f, -0.04503074f, 0.02896964f, 0.07736573f, -0.00187006f, -0.08947787f, 0.04219774f, 
    0.10022906f, -0.00743442f, 0.02476870f, -0.03393561f, -0.08898127f, -0.21436073f, 0.12096802f, 0.02575822f, 
    0.09078898f, -0.07319255f, -0.02700249f, 0.05600835f, 0.07838258f, -0.23783477f, 0.10608723f, 0.12199660f, 
    -0.14517708f, -0.00762250f, 0.20305115f, 0.02398304f, -0.06984148f, -0.07818242f, -0.00059048f, -0.00530263f, 
    0.13063815f, 0.17018020f, 0.22545743f, 0.20521128f, 0.13963714f, 0.22459643f, 0.03520017f, -0.18786222f, 
    0.07009766f, -0.02861556f, 0.05727249f, -0.27007499f, 0.14193557f, 0.03794937f, 0.19715692f, 0.14312035f, 
    -0.14551577f, 0.25651515f, -0.20415078f, -0.13085201f, 0.03261271f, 0.18831198f, 0.12855688f, 0.00754801f, 
    0.21887584f, 0.18922614f, 0.06671231f, -0.00328558f, 0.14714608f, 0.18367676f, -0.32415697f, 0.06933512f, 
    0.11892779f, 0.04464281f, -0.00380806f, 0.07440647f, -0.05735901f, 0.11998662f, -0.00616913f, 0.08828555f, 
    0.01584785f, -0.03208489f, -0.02083199f, -0.06137710f, 0.18801744f, 0.10500073f, -0.22162998f, 0.06679441f, 
    0.24414088f, -0.01163140f, 0.01058056f, 0.02714947f, 0.04892472f, -0.04471129f, -0.03190119f, 0.13796228f, 
    0.05140264f, -0.10335043f, 0.05489357f, 0.05511395f, -0.00757827f, 0.01923204f, 0.14016715f, 0.19035155f, 
    -0.18477857f, -0.00186998f, 0.07047803f, 0.01822192f, 0.01238514f, 0.05129527f, 0.04622695f, -0.05852361f, 
    -0.01746056f, -0.04612971f, -0.06036160f, 0.00584850f, -0.31281719f, -0.36418238f, 0.26695716f, 0.33077416f, 
    0.13981271f, 0.00227089f, -0.08859619f, 0.04535254f, -0.02710440f, -0.17079988f, -0.05617785f, 0.06395097f, 
    0.00237722f, 0.02075882f, -0.29315504f, -0.22978218f, -0.10997751f, -0.14345947f, -0.10717233f, -0.10196211f, 
    0.11728766f, 0.02146106f, 0.00955060f, 0.09051669f, -0.18190776f, 0.00806354f, 0.13016294f, -0.20205802f, 
    0.14300206f, -0.06489034f, -0.01907173f, -0.26018199f, -0.05754390f, 0.17390659f, 0.08539576f, 0.05812344f, 
    -0.31618467f, 0.01215709f, 0.12669748f, -0.15870398f, -0.20854302f, 0.08759326f, 0.09811406f, 0.09237370f, 
    -0.02336723f, -0.07541364f, 0.09073376f, -0.06935053f, -0.10391429f, -0.30463195f, 0.07770020f, -0.18949258f, 
    0.15443642f, 0.01752943f, 0.05748593f, 0.22703078f, 0.19648658f, 0.15769060f, 0.05637021f, -0.04166694f, 
    0.22352391f, -0.24661174f, 0.10794584f, 0.03440967f, 0.04013353f, 0.02826522f, 0.01900295f, 0.24462487f, 
    0.13523178f, 0.07031657f, 0.06661562f, 0.19787262f, -0.14053582f, 0.07106518f, -0.26484400f, 0.01405899f, 
    -0.01871168f, -0.02073327f, 0.05274067f, 0.01732245f, 0.05059940f, -0.04318438f, -0.03531476f, 0.15751672f, 
    -0.01929238f, -0.24385901f, -0.04372108f, 0.03464650f, 0.03987312f, -0.01097526f, 0.03776006f, -0.13787407f, 
    -0.16784838f, -0.03003969f, 0.07657218f, -0.08943264f, -0.12629288f, -0.17070709f, -0.00472437f, 0.08649494f, 
    0.13909960f, 0.13842905f, 0.08999953f, 0.09518622f, 0.13989584f, -0.11119313f, 0.05198356f, -0.04594004f, 
    -0.09002938f, -0.35209760f, -0.07714552f, 0.21693854f, 0.09270535f, 0.17508410f, 0.14146584f, -0.11697189f, 
    0.02325656f, -0.01230000f, -0.05481817f, 0.08356444f, -0.24986985f, -0.16941345f, 0.12994215f, 0.25160310f, 
    -0.06065624f, -0.18469274f, -0.11718109f, 0.01055751f, 0.25511152f, 0.25181386f, 0.14890216f, 0.05773377f, 
    0.14123113f, -0.01426741f, -0.27844009f, 0.26804763f, 0.09026112f, -0.04213230f, 0.06752529f, 0.12982859f, 
    0.04491457f, 0.10935764f, 0.22324741f, 0.01855967f, -0.49578023f, -0.17185767f, 0.03896572f, -0.18209390f, 
    -0.11061283f, 0.13294086f, 0.05158414f, 0.01037502f, 0.12333663f, -0.14695254f, 0.02563299f, 0.04641356f, 
    0.04117748f, -0.15380196f, 0.31679276f, 0.01207998f, -0.12539221f, -0.18016890f, 0.11871210f, 0.21615022f, 
    0.07574444f, 0.11242015f, 0.10289036f, -0.01711785f, -0.06540266f, -0.10517177f, 0.11735473f, -0.11008929f, 
    -0.03766003f, -0.13200334f, -0.13267311f, -0.01937728f, 0.11797748f, 0.02322671f, 0.08318417f, 0.02544774f, 
    -0.50526702f, -0.21794590f, -0.14156374f, -0.44995221f, 0.09608524f, 0.00277653f, 0.05343863f, -0.07390995f, 
    0.11040133f, 0.07720520f, -0.03103265f, 0.00439575f, 0.02301544f, 0.24552442f, 0.15125857f, -0.27340898f, 
    0.01178998f, 0.23087697f, -0.17270979f, -0.04937368f, 0.10758509f, 0.08627247f, 0.06409501f, -0.11873186f, 
    0.06904858f, 0.13655610f, 0.06594068f, 0.00950227f, 0.02514009f, 0.07983826f, 0.09024674f, 0.01904581f, 
    -0.15557602f, -0.01246046f, -0.11350315f, -0.04491622f, -0.07838891f, 0.15054856f, -0.20338295f, -0.12843519f, 
    0.05165821f, -0.03672602f, -0.09958396f, -0.05075304f, 0.09401023f, 0.07826015f, 0.10126395f, 0.15401950f, 
    -0.10529242f, -0.14600314f, 0.02786194f, -0.09656512f, -0.02316439f, -0.03569649f, 0.12671322f, -0.04145553f, 
    0.05182331f, -0.15629348f, -0.04598782f, -0.17190909f, 0.06255472f, 0.05338599f, 0.18490776f, -0.28873816f, 
    0.05878366f, 0.17412123f, 0.10750877f, -0.06952135f, 0.05874870f, -0.00072178f, 0.05532529f, -0.17286149f, 
    -0.07021292f, 0.22200993f, 0.16379941f, -0.29316178f, -0.01810158f, 0.08492751f, 0.04217155f, -0.02506090f, 
    0.04034775f, 0.03962252f, 0.00066203f, -0.06287959f, -0.00172468f, 0.04412706f, 0.08061127f, -0.03896572f, 
    -0.13476655f, 0.01333256f, 0.10087463f, 0.15400487f, 0.17732523f, 0.04597593f, 0.12425195f, 0.01117894f, 
    0.20141983f, -0.02892649f, -0.13366272f, -0.04452533f, 0.16885704f, -0.08609740f, 0.04825621f, 0.01324596f, 
    -0.00978551f, -0.02241945f, 0.10059680f, -0.05014589f, -0.03857041f, -0.01770900f, 0.07879870f, 0.08169430f, 
    0.18278682f, 0.14841154f, 0.08821371f, -0.04153137f, -0.14088301f, -0.08224422f, -0.05575810f, -0.02741525f, 
    0.05278767f, 0.23286261f, 0.18797122f, -0.01332426f, -0.02039235f, -0.23370196f, -0.05547149f, -0.12670352f, 
    0.02222774f, 0.09573407f, 0.06600161f, 0.15991715f, -0.22576806f, -0.06935893f, 0.05987075f, 0.17474382f, 
    0.07590672f, -0.04389611f, 0.14607373f, -0.15214136f, -0.02019138f, -0.04881870f, 0.05602964f, 0.07545580f, 
    0.36628696f, 0.22005929f, -0.00032377f, -0.16801754f, -0.05126173f, 0.07150284f, 0.19823572f, -0.00620970f, 
    0.31968507f, 0.10817968f, 0.11574529f, 0.10640867f, -0.10039337f, -0.03848007f, -0.50936055f, 0.12270971f, 
    -0.22861758f, 0.19206321f, 0.04543137f, 0.00283927f, -0.10796765f, 0.06986728f, -0.05224448f, -0.14553003f, 
    -0.37522611f, 0.15212801f, -0.05103374f, 0.00335964f, -0.03301755f, -0.04303151f, -0.04487725f, 0.15356429f, 
    -0.01882631f, -0.04930079f, -0.03782125f, 0.02921957f, 0.29758433f, 0.08983893f, 0.01889219f, -0.07137352f, 
    0.07607000f, 0.06517026f, -0.04464251f, -0.03635106f, -0.05058482f, 0.00239134f, -0.15875846f, -0.17805378f, 
    -0.04105107f, -0.18764678f, -0.16605748f, -0.14663260f, 0.00553967f, 0.13088512f, 0.08928499f, -0.07758981f, 
    0.14653021f, -0.03753712f, -0.01926127f, -0.08148071f, -0.12907489f, -0.13784494f, -0.06399072f, 0.28170317f, 
    0.03148993f, 0.09623128f, -0.01621393f, -0.14807431f, 0.11212057f, -0.08530232f, -0.04062498f, 0.14120294f, 
    0.17690116f, -0.07310055f, 0.06748013f, -0.13720721f, 0.19453293f, -0.08272238f, -0.03385120f, -0.11478213f, 
    0.05431978f, -0.05265135f, 0.00369237f, 0.01473869f, -0.09624828f, 0.00871996f, 0.37088588f, -0.08310558f, 
    0.07501359f, -0.09719371f, -0.02837002f, -0.13260138f, 0.06386571f, -0.08242428f, -0.10612252f, -0.08712149f, 
    -0.48726967f, -0.13641854f, -0.09881730f, 0.02576563f, -0.20385277f, -0.03149159f, 0.11570895f, 0.13323459f, 
    -0.09526023f, 0.04247412f, 0.07696464f, 0.16300584f, -0.08817849f, -0.27910265f, 0.62528551f, 0.14314184f, 
    -0.05485381f, 0.04233084f, -0.05475166f, -0.06803893f, 0.12466730f, 0.00159199f, 0.01928521f, 0.04228561f, 
    -0.22304095f, -0.29190668f, 0.00426145f, 0.29600832f, 0.01020884f, 0.08926478f, 0.20387214f, 0.08358480f, 
    0.02126769f, 0.02202978f, -0.24099547f, 0.05855031f, 0.21000928f, 0.24927622f, -0.12226972f, -0.02642419f, 
    0.12646629f, 0.05555063f, 0.12397612f, -0.04076029f, 0.03950649f, -0.18603377f, -0.01629293f, -0.16222844f, 
    -0.04569438f, -0.23864481f, 0.02228443f, -0.06326351f, 0.08120009f, -0.00160333f, -0.08427788f, 0.01931212f, 
    0.02539437f, -0.05398157f, -0.14975771f, 0.01554319f, 0.17828409f, -0.13407211f, -0.10369015f, 0.18062961f, 
    -0.01333896f, 0.08456979f, 0.10806735f, 0.21622887f, 0.21814913f, 0.01987253f, 0.12256745f, 0.20850094f, 
    -0.07704219f, -0.26761818f, 0.29671383f, 0.26328701f, 0.07238156f, 0.16758986f, 0.12401588f, 0.21604803f, 
    -0.02860950f, -0.16233894f, -0.10737986f, -0.07240608f, -0.12104208f, 0.09032807f, 0.11107650f, 0.22496045f, 
    -0.13542114f, -0.05091890f, -0.15164201f, 0.04480257f, 0.03269664f, 0.00712733f, -0.05511638f, -0.16850217f, 
    0.02945263f, 0.11398053f, -0.06297696f, 0.02647842f, 0.05491750f, -0.02638079f, 0.01643027f, 0.16786937f, 
    0.04142170f, 0.01070771f, 0.16034511f, -0.01282800f, 0.05645972f, 0.44053313f, 0.35496995f, 0.36488104f, 
    -0.01070259f, -0.20483568f, 0.10862720f, 0.17460801f, 0.06537532f, -0.13567376f, 0.03814290f, -0.00620244f, 
    -0.37302029f, -0.36453444f, 0.32460722f, 0.03921781f, -0.07231341f, -0.01422040f, -0.00555336f, 0.10096973f, 
    -0.07580832f, 0.13657622f, 0.10395546f, 0.19894628f, 0.27153048f, -0.09228226f, -0.00189507f, 0.01666166f, 
    0.07207778f, -0.03013182f, -0.32832605f, 0.02925950f, -0.07353793f, -0.08259626f, -0.18420531f, -0.15740360f, 
    -0.01497663f, 0.16038555f, -0.01607659f, -0.11301894f, 0.16082172f, -0.20752567f, 0.05921114f, -0.13980545f, 
    0.12888049f, -0.16801578f, -0.13982143f, -0.08466543f, -0.30731553f, 0.25354910f, 0.51940852f, 0.06587778f, 
    0.12061764f, 0.09516606f, -0.09805882f, -0.00689782f, 0.03865843f, -0.04962677f, 0.09857008f, 0.15124898f, 
    -0.10270056f, -0.00523450f, -0.28582537f, -0.25351444f, -0.11060031f, -0.13258141f, 0.01313784f, 0.00388859f, 
    0.19895481f, -0.01261506f, 0.01299456f, 0.16446525f, -0.12159038f, -0.03280811f, -0.03032675f, 0.16968727f, 
    -0.13307695f, -0.01166404f, 0.07717205f, -0.10218084f, -0.11567776f, -0.04770538f, -0.14985500f, 0.00424651f, 
    -0.08749790f, -0.06055680f, 0.02499104f, -0.26356500f, -0.03586639f, 0.03048568f, -0.11331739f, 0.15381356f, 
    0.32806438f, 0.13051802f, 0.05218666f, 0.27808833f, -0.16584292f, 0.04979117f, 0.04601164f, 0.15051837f, 
    0.00262301f, 0.11951280f, -0.05280254f, -0.02980612f, 0.15111066f, 0.22043248f, 0.06788207f, 0.14440209f, 
    0.00614744f, 0.17846996f, 0.13219146f, 0.08779131f, -0.13218011f, -0.04899120f, 0.08440967f, -0.03065250f, 
    0.07514162f, 0.08727562f, -0.06455129f, -0.05168011f, -0.19639191f, 0.22399279f, 0.37645334f, 0.03118548f, 
    0.05009674f, -0.01527441f, 0.04308893f, 0.08935023f, -0.00126326f, 0.09947909f, 0.03818265f, 0.05811104f, 
    -0.16392000f, -0.37951401f, -0.11642880f, 0.00190827f, -0.06316274f, 0.11068340f, -0.04949322f, -0.05133712f, 
    0.01935119f, -0.11337455f, 0.00421589f, 0.00085790f, -0.08304325f, -0.05371147f, -0.25624284f, -0.17455389f, 
    0.15097232f, -0.16964832f, 0.08603448f, 0.13518684f, -0.08312050f, 0.03050166f, -0.04061373f, 0.08975842f, 
    0.01867126f, -0.00571599f, -0.07992100f, 0.13471559f, 0.03077766f, 0.02115823f, -0.06801696f, -0.05352365f, 
    -0.20971622f, 0.08596953f, 0.04018697f, 0.00015404f, 0.29390851f, 0.22688748f, 0.10356820f, 0.11773039f, 
    0.08851267f, 0.12904872f, -0.01027859f, 0.18533319f, 0.08563074f, -0.09771326f, -0.02234764f, -0.01591075f, 
    -0.25096446f, -0.12379910f, -0.09269045f, 0.24643135f, -0.01071156f, -0.05705100f, -0.17999017f, 0.00381245f, 
    0.03575826f, 0.03048154f, 0.12696105f, 0.27337021f, -0.43283632f, -0.33087733f, 0.44251406f, 0.09107006f, 
    0.09435168f, 0.02252253f, -0.11107096f, -0.23047973f, 0.02225184f, -0.26242217f, 0.03175312f, -0.10426562f, 
    0.29443851f, 0.03011238f, 0.20713010f, 0.18159980f, 0.06856972f, 0.03558555f, 0.07931709f, -0.13368383f, 
    0.02151006f, 0.07567724f, 0.15982586f, 0.10075247f, -0.22258393f, -0.31987050f, -0.28222477f, -0.11563241f, 
    0.13773249f, -0.05472993f, -0.06620574f, -0.02037724f, 0.03640781f, -0.04302656f, 0.01130328f, -0.11119523f, 
    -0.30041817f, -0.31507832f, -0.38406357f, -0.04985958f, 0.07907010f, -0.00838096f, -0.04859476f, 0.00493063f, 
    -0.05603181f, -0.03580591f, 0.10728038f, 0.06451669f, -0.09711187f, 0.05706007f, -0.24281120f, 0.04660038f, 
    0.04153027f, -0.04080343f, -0.09968075f, -0.07664633f, 0.08220311f, 0.07591134f, 0.22901191f, -0.00111005f, 
    -0.22552033f, -0.23615499f, -0.18211505f, -0.33637670f, 0.04274463f, 0.17763156f, 0.10078985f, 0.03141030f, 
    -0.03624335f, 0.01186556f, 0.06122052f, 0.02667540f, 0.20020427f, 0.09583879f, -0.19529793f, 0.01620564f, 
    0.02258151f, -0.00193521f, 0.03063394f, 0.11143987f, 0.05345005f, -0.28636050f, -0.23457412f, -0.00217602f, 
    0.21799701f, 0.16111693f, 0.18275410f, 0.07699695f, 0.18104495f, 0.24696901f, 0.10397476f, 0.04580522f, 
    0.02564166f, 0.07636103f, 0.14767028f, 0.26322994f, 0.33537912f, -0.24993663f, 0.02998326f, -0.16798531f, 
    0.05403649f, 0.15077317f, 0.01435833f, -0.19469899f, 0.03318571f, -0.17598218f, 0.03114367f, -0.02600160f, 
    0.14922792f, 0.16704562f, 0.06978878f, -0.16783953f, -0.01553815f, -0.01022181f, -0.14231935f, -0.11834336f, 
    -0.04314047f, -0.05405113f, -0.07803377f, -0.13363387f, -0.25741914f, 0.01298170f, -0.35811168f, 0.14656560f, 
    -0.06812460f, -0.10515146f, -0.01877632f, 0.04755840f, 0.09479171f, 0.08769388f, -0.05665023f, -0.01615841f, 
    0.20225918f, -0.13805687f, 0.01948812f, 0.06347889f, 0.01682530f, -0.19929454f, 0.03851508f, 0.13881171f, 
    0.20081007f, 0.07879097f, -0.02732925f, 0.20727056f, -0.16808416f, -0.07255331f, -0.41476741f, -0.35433078f, 
    -0.00355382f, 0.05103699f, 0.05069629f, 0.01105137f, 0.12326754f, -0.00339648f, 0.06133936f, 0.21785751f, 
    0.05757869f, -0.07827590f, 0.03596474f, -0.26636866f, 0.07851287f, -0.05921688f, 0.13893729f, -0.08120884f, 
    0.05335780f, 0.03302310f, -0.09689856f, -0.19343494f, 0.26350862f, -0.00612865f, 0.28857476f, 0.11401436f, 
    0.12189049f, -0.11866745f, -0.02223313f, -0.03074121f, -0.06821608f, -0.00096936f, -0.04284167f, -0.00065247f, 
    -0.25370699f, -0.19186258f, -0.10760427f, 0.19914988f, -0.08037356f, 0.09219188f, 0.05136448f, 0.01451155f, 
    0.00978843f, 0.12837081f, -0.05126804f, 0.11533628f, 0.25914744f, -0.14005244f, 0.15713616f, 0.02470193f, 
    -0.00606440f, 0.31971464f, -0.00926741f, -0.07401421f, 0.11132800f, -0.06696711f, 0.05521308f, 0.11679988f, 
    0.27284592f, 0.11720900f, -0.08414321f, 0.04513765f, 0.15202643f, 0.19421425f, 0.10292172f, 0.09452072f, 
    0.09451595f, 0.14225085f, 0.03559277f, 0.17229192f, -0.07825283f, -0.08606637f, 0.01483182f, -0.25049672f, 
    0.11562470f, -0.05650846f, 0.09422691f, 0.01084348f, -0.14682853f, -0.08457381f, 0.08373787f, -0.22488675f, 
    0.06718082f, 0.14513589f, -0.12266601f, 0.14233486f, 0.01406696f, 0.11414691f, -0.14609540f, 0.15998986f, 
    0.08184969f, -0.12912036f, -0.16977878f, 0.08182119f, 0.05522013f, -0.05657799f, -0.26206234f, -0.15894964f, 
    0.10408712f, -0.03404717f, 0.13567384f, 0.07268503f, 0.00601887f, 0.07356758f, 0.10349013f, -0.06858987f, 
    -0.37842268f, -0.26859894f, -0.20123816f, 0.15904675f, 0.00895650f, 0.05712309f, 0.07025219f, -0.13453206f, 
    0.09546891f, 0.14860465f, 0.06191595f, 0.07791305f, 0.13863660f, 0.10327768f, 0.07659569f, -0.02448312f, 
    0.04319737f, -0.01807089f, 0.01311678f, 0.21210814f, -0.04999408f, 0.00829174f, -0.14028126f, -0.16221386f, 
    -0.05143654f, -0.15138657f, -0.03870855f, 0.04767485f, -0.04114030f, -0.16475700f, 0.06256977f, 0.11569984f, 
    0.07830419f, 0.11609028f, -0.02793982f, 0.22303359f, 0.16211903f, 0.05124118f, 0.10910346f, 0.05493925f, 
    0.05480217f, 0.01360353f, 0.06801152f, 0.08119803f, -0.05714877f, -0.03188553f, 0.12288526f, 0.22102869f, 
    0.19966614f, 0.14441496f, 0.14180011f, -0.05469001f, 0.10967837f, 0.19304682f, -0.12520730f, 0.04516403f, 
    0.01909216f, 0.15454370f, -0.07867542f, 0.10359460f, 0.14849424f, 0.02082115f, -0.00139630f, -0.07730123f, 
    0.12065089f, -0.06939135f, 0.04384897f, -0.00044226f, 0.06489593f, 0.05254377f, 0.14116679f, 0.10724103f, 
    0.03066686f, -0.00912639f, -0.03530617f, -0.03392891f, -0.02362097f, 0.01215407f, -0.02347793f, 0.03575003f, 
    0.00876778f, -0.05005642f, 0.03963963f, -0.03456709f, 0.01879584f, 0.02363987f, 0.00275952f, 0.01454179f, 
    -0.02792059f, 0.04279342f, 0.02500800f, -0.05379533f, 0.03962236f, -0.02654445f, -0.05237016f, 0.03660520f, 
    -0.04024585f, -0.05613763f, 0.00925365f, -0.03787834f, -0.03087387f, 0.01368124f, -0.00442987f, 0.01748499f, 
    -0.04955173f, -0.02962573f, -0.02540688f, 0.04648029f, 0.01448329f, 0.00645875f, -0.00208676f, -0.01209438f, 
    -0.02654964f, -0.04569787f, 0.00921239f, 0.01194620f, 0.02247513f, 0.00753338f, -0.03703241f, 0.00331218f, 
    -0.04766113f, 0.01244327f, 0.03116932f, -0.01783163f, 0.00620918f, 0.01344694f, 0.02291056f, 0.02115691f, 
    0.01952375f, 0.00919429f, 0.02524645f, -0.02057256f, -0.03497507f, 0.03936739f, 0.02188791f, 0.01792432f, 
    -0.00933397f, -0.05456822f, 0.04028171f, 0.03591283f, -0.00551199f, -0.03371113f, -0.03177312f, -0.03629534f, 
    -0.02492451f, -0.01286120f, 0.03667990f, -0.04069047f, -0.03239710f, -0.04835089f, -0.03113502f, -0.01288698f, 
    -0.00807664f, -0.00630970f, -0.00319727f, 0.04231301f, 0.00123486f, -0.01025850f, -0.05783125f, 0.01402743f, 
    -0.01463093f, -0.00557378f, 0.03411021f, -0.05318177f, 0.02522321f, 0.02893213f, -0.00301365f, -0.02277959f, 
    -0.01549031f, -0.05332647f, 0.02648713f, 0.01997361f, 0.02338155f, 0.01270713f, 0.02873670f, -0.02088855f, 
    -0.04783153f, 0.02636584f, -0.05135387f, -0.00396174f, 0.02671593f, -0.01286652f, -0.02723412f, -0.01281165f, 
    0.01462626f, -0.03565548f, 0.02555389f, -0.03415605f, 0.02304866f, 0.04747346f, -0.02438402f, 0.03394027f, 
    -0.00996053f, 0.00374305f, -0.05568336f, 0.02472364f, -0.03593561f, -0.02735508f, 0.04360320f, 0.03860460f, 
    0.03265223f, 0.04236632f, 0.03981835f, -0.04845112f, -0.03904922f, 0.00285845f, -0.02208238f, 0.01524713f, 
    0.02551020f, -0.01119838f, -0.01639358f, 0.00317319f, -0.01978931f, -0.00107286f, -0.02544506f, -0.04257638f, 
    -0.00689068f, 0.01095530f, 0.05041213f, 0.01455032f, 0.05679984f, 0.04045773f, -0.03692548f, 0.05134092f, 
    -0.02420341f, -0.04329044f, -0.00139622f, -0.01460634f, 0.00357900f, 0.01596362f, -0.03091000f, 0.02156341f, 
    0.02910370f, -0.01623854f, 0.01681946f, 0.02568990f, -0.03016922f, 0.03052558f, -0.02076679f, -0.01473822f, 
    0.00572189f, -0.03724960f, 0.03543314f, 0.00015942f, 0.00150683f, -0.03534128f, -0.01979694f, -0.00634217f, 
    -0.03099990f, -0.03584255f, -0.00017606f, -0.04158610f, -0.04759133f, -0.03675567f, 0.00867266f, 0.03078100f, 
    -0.05304742f, 0.04131094f, -0.00409088f, 0.01196892f, 0.00350983f, -0.01726164f, 0.02591860f, -0.01772728f, 
    -0.03539589f, 0.00248276f, -0.05070874f, -0.03824796f, -0.03589427f, -0.01727790f, 0.01560650f, -0.03425069f, 
    -0.05536296f, 0.01937943f, 0.01005862f, -0.00239259f, 0.01417218f, -0.05665591f, -0.02852736f, 0.02934026f, 
    -0.05141787f, -0.04421060f, 0.02293030f, 0.03580553f, 0.03396150f, -0.03797169f, -0.00868932f, 0.03809927f, 
    -0.01555882f, 0.01354292f, 0.00158227f, 0.02203394f, -0.03589245f, -0.01131957f, 0.02380196f, -0.01932254f, 
    -0.02536622f, -0.05562802f, -0.00090745f, -0.04508493f, -0.01328013f, -0.03235398f, -0.05048195f, 0.01453244f, 
    -0.04512141f, -0.00271526f, 0.02866581f, -0.03599212f, -0.02314518f, 0.00508224f, 0.01750530f, 0.03227627f, 
    0.02139095f, -0.01757649f, -0.04300410f, 0.00324619f, -0.01573245f, 0.01678235f, -0.04601534f, -0.05564759f, 
    0.01110846f, 0.01607263f, -0.04404533f, -0.03433786f, -0.05285970f, 0.00645168f, 0.00375083f, 0.00313031f, 
    -0.04034957f, -0.00188032f, 0.01982770f, -0.04312482f, -0.01348266f, 0.00901388f, 0.02400194f, 0.00353474f, 
    0.02568435f, -0.05201632f, -0.01620553f, 0.01757024f, -0.02342439f, -0.01262122f, 0.03625198f, -0.05059638f, 
    -0.03071682f, -0.02931529f, 0.02836326f, -0.04578403f, -0.02443128f, 0.03882484f, 0.03850800f, 0.03845891f, 
    -0.02616819f, 0.03991735f, -0.05025346f, 0.00788248f, 0.03707532f, -0.04851587f, -0.03579515f, 0.01972981f, 
    -0.01054018f, -0.02207322f, -0.04598077f, 0.05040885f, 0.04719872f, 0.02268055f, -0.04008675f, 0.02629769f, 
    0.02903950f, -0.05383763f, -0.04479783f, -0.04551649f, 0.01308533f, 0.01508014f, 0.03087112f, 0.03732892f, 
    0.01040758f, 0.02516648f, -0.05722910f, -0.02228725f, -0.04190113f, -0.02454599f, 0.01496875f, 0.03000036f, 
    -0.04954049f, 0.00352975f, -0.02702542f, 0.02919030f, -0.00382597f, 0.03666651f, 0.00927487f, -0.01453410f, 
    -0.02350384f, -0.01333295f, -0.03395260f, 0.04117446f, 0.00402133f, 0.04908206f, -0.01836765f, -0.00116152f, 
    -0.05751283f, -0.01169343f, 0.02135337f, 0.04425829f, 0.03634864f, -0.04905536f, -0.02092511f, -0.02214764f, 
    0.00455438f, -0.03387508f, -0.00803073f, 0.00122464f, -0.05194416f, 0.01617835f, -0.03385788f, 0.01609242f, 
    -0.02735830f, 0.02142882f, 0.02120080f, -0.02078257f, 0.03487559f, 0.02581852f, 0.04784268f, -0.03295214f, 
    -0.02105670f, 0.02467922f, 0.01599185f, -0.01694707f, -0.01085648f, 0.01072828f, -0.01686249f, 0.05150364f, 
    -0.02986104f, -0.03115748f, -0.01056963f, -0.01375930f, -0.02093627f, -0.03465692f, 0.02254651f, 0.01788086f, 
    0.00442250f, 0.04879079f, -0.05763109f, 0.00760064f, -0.00861622f, 0.03706038f, 0.01689644f, 0.01790128f, 
    0.01543752f, -0.05121881f, 0.03771937f, 0.04165056f, -0.02726215f, -0.05006876f, -0.01391480f, 0.02143903f, 
    -0.02178452f, 0.03480920f, -0.00684141f, 0.04965908f, -0.01333621f, -0.03273327f, 0.02615895f, -0.01682944f, 
    -0.03078460f, -0.02704109f, 0.02136439f, -0.02746536f, -0.03588546f, -0.01106060f, 0.00517805f, 0.03523293f, 
    0.03503679f, 0.03840915f, -0.00084109f, -0.04388175f, -0.01591029f, -0.01661687f, -0.00833552f, 0.03107762f, 
    0.00329330f, -0.03054864f, -0.00777000f, -0.00848012f, -0.04804828f, -0.01228107f, -0.02404292f, 0.00058305f, 
    0.01133937f, -0.00649089f, 0.00981914f, -0.02888632f, 0.01136992f, 0.02104733f, 0.03708252f, 0.00554191f, 
    0.02328821f, -0.01771498f, 0.02465427f, -0.00457113f, -0.05494371f, -0.05291307f, -0.04966532f, -0.06041494f, 
    -0.03131604f, 0.00765031f, 0.03681753f, -0.00190496f, -0.04217213f, -0.04031971f, 0.01976622f, -0.03276106f, 
    -0.00868819f, -0.03828364f, 0.01798848f, 0.01070471f, -0.00712347f, -0.05037475f, -0.04790908f, 0.01833782f, 
    0.02507461f, -0.04134701f, 0.03678051f, 0.00325461f, -0.01261612f, -0.04777813f, -0.01873681f, -0.01502612f, 
    -0.00485573f, -0.04179446f, 0.00373763f, -0.03820297f, -0.01891294f, 0.02007892f, -0.01365985f, 0.01151569f, 
    -0.05507021f, -0.03339176f, 0.00767876f, 0.01886783f, -0.03275759f, -0.05284357f, -0.00065566f, -0.01900610f, 
    0.03232314f, -0.00699261f, -0.00627318f, 0.03086232f, -0.05072549f, 0.03632201f, 0.00219847f, -0.02249142f, 
    -0.01637161f, 0.01072431f, -0.01051143f, -0.02456026f, -0.00286360f, 0.02653380f, -0.00751323f, -0.02096581f, 
    -0.05292799f, -0.05148812f, 0.02567093f, -0.00284199f, -0.03775496f, -0.03573154f, 0.04243246f, 0.01551462f, 
    0.00041690f, -0.04584280f, 0.03789077f, 0.04126851f, 0.02069056f, -0.04469837f, -0.04584584f, -0.05205693f, 
    0.00888277f, 0.02736955f, 0.02463486f, 0.01655740f, -0.04765908f, -0.02164868f, 0.03944112f, -0.03396642f, 
    0.04019455f, -0.03693768f, 0.00131873f, 0.03160496f, -0.02070169f, 0.03726276f, -0.02288177f, -0.00427548f, 
    -0.03237780f, -0.04649325f, -0.00973209f, 0.03385466f, -0.02541474f, -0.05056413f, -0.00741444f, -0.03104771f, 
    0.01855484f, -0.00794949f, 0.04356802f, 0.00038907f, 0.02042718f, 0.01115973f, 0.01619993f, -0.03492223f, 
    0.04254823f, 0.03430999f, -0.03442078f, 0.01690835f, 0.03057904f, -0.04263939f, -0.05063472f, -0.02489940f, 
    0.03555070f, -0.03053275f, -0.01776501f, -0.01172034f, -0.03072672f, 0.04012554f, 0.00899438f, 0.01593743f, 
    -0.03064693f, -0.02077018f, -0.01867939f, -0.00043212f, -0.01487673f, -0.04391190f, 0.01853450f, -0.02437710f, 
    -0.05557773f, -0.05125314f, -0.02275255f, 0.02697886f, 0.01439345f, -0.00630128f, -0.02705966f, -0.03202526f, 
    -0.04993816f, -0.03299385f, -0.00984041f, -0.05729464f, 0.01948179f, -0.00545673f, 0.02506774f, -0.05641497f, 
    -0.02977572f, 0.01370174f, 0.03034308f, -0.04304857f, -0.02095862f, -0.03925647f, 0.01722444f, 0.00969571f, 
    0.02801350f, 0.01621445f, -0.03466196f, 0.00831066f, -0.05435601f, -0.05006776f, -0.05378480f, 0.02101964f, 
    -0.00009484f, -0.00200680f, -0.00648250f, 0.04390606f, -0.01227808f, -0.05512365f, 0.01458978f, 0.01231592f, 
    -0.00150525f, 0.00336406f, -0.01428481f, -0.03432747f, -0.00735280f, 0.03487170f, 0.00564450f, -0.03440953f, 
    0.04164266f, -0.05170452f, 0.02097043f, -0.02747346f, -0.04494137f, -0.05620961f, 0.03684082f, -0.01142325f, 
    0.00103594f, -0.02174582f, 0.02708149f, 0.02253447f, 0.00934109f, 0.02189943f, -0.01865683f, -0.01602458f, 
    0.03033833f, -0.04584699f, -0.01073641f, -0.01211056f, -0.00418317f, -0.02230069f, -0.01989678f, -0.01730117f, 
    -0.02125386f, -0.02217063f, -0.03373211f, 0.02358131f, 0.01207770f, 0.04032909f, -0.05137261f, -0.05111261f, 
    -0.03206604f, -0.03589172f, 0.00570429f, -0.02599942f, -0.04386730f, 0.04319916f, 0.00666503f, 0.03788281f, 
    -0.00721443f, 0.00823673f, -0.05793820f, -0.04994208f, 0.03412436f, 0.01304409f, 0.01452686f, -0.02424808f, 
    0.03345683f, 0.03298226f, -0.05625458f, 0.01855312f, 0.01130600f, 0.00514826f, -0.03212842f, -0.03702730f, 
    -0.01654874f, -0.02589520f, -0.00387339f, -0.04716903f, -0.04824263f, -0.00594134f, -0.03299944f, -0.02735822f, 
    0.02772892f, -0.00725428f, -0.05405978f, 0.03029478f, 0.01017006f, -0.01192579f, -0.05760561f, -0.02505014f, 
    0.00874276f, -0.03498789f, -0.05700292f, 0.02189101f, -0.02802812f, 0.02344541f, -0.01795348f, -0.04910672f, 
    0.02375531f, 0.02166416f, -0.02978811f, -0.02920454f, 0.01661427f, 0.00762324f, -0.03152145f, -0.00637601f, 
    0.01491439f, 0.02087279f, -0.02608164f, 0.01751869f, 0.01525432f, 0.04280916f, -0.02290996f, -0.03074837f, 
    0.03673094f, -0.01500993f, 0.01925151f, 0.00503396f, 0.03630268f, 0.00685098f, -0.02486532f, 0.00020051f, 
    -0.03533299f, 0.02871003f, 0.00839734f, -0.00143882f, 0.00840726f, -0.00341908f, 0.03222089f, -0.05624695f, 
    0.03250422f, 0.02768513f, 0.01821166f, -0.05565656f, -0.04301350f, 0.01351893f, -0.01648332f, 0.03384050f, 
    -0.05549589f, -0.04557707f, 0.03720298f, 0.03626642f, -0.02417494f, 0.00958305f, 0.01519250f, -0.05246183f, 
    -0.04899984f, -0.02969523f, -0.05658030f, -0.03556076f, 0.02619863f, -0.02862771f, 0.04194032f, 0.04129995f, 
    0.02027772f, -0.04329730f, 0.04452598f, 0.03863377f, 0.03278277f, -0.03475856f, -0.00589253f, -0.01837079f, 
    -0.02047553f, 0.02378913f, 0.00354051f, -0.03982431f, -0.01324477f, 0.03680083f, -0.01588516f, 0.04297044f, 
    0.03970216f, 0.00481609f, -0.02772234f, -0.03263993f, -0.02967788f, 0.04067155f, 0.00098449f, -0.03662838f, 
    -0.05520843f, 0.01770458f, -0.04053114f, -0.03577466f, 0.03316497f, -0.05186611f, -0.04931503f, -0.04162827f, 
    -0.02153828f, 0.02120645f, 0.02750620f, 0.03705199f, -0.05684652f, 0.03168745f, 0.00042914f, 0.03627841f, 
    -0.01435503f, -0.01195987f, -0.03456541f, -0.02931865f, -0.00131080f, -0.01064758f, -0.05813198f, 0.03519483f, 
    -0.02935069f, -0.04815065f, -0.02675623f, 0.03695656f, -0.05317612f, 0.03158675f, -0.02541607f, 0.00608110f, 
    -0.04868455f, 0.00861548f, 0.02134562f, 0.00414048f, -0.01020763f, 0.00055204f, -0.03123500f, -0.03647029f, 
    -0.05657358f, -0.05295584f, -0.02226440f, -0.00392747f, -0.04996706f, 0.03064455f, 0.02137804f, 0.02928237f, 
    0.00270863f, 0.00369140f, -0.01998667f, -0.01312211f, -0.03064088f, 0.03167512f, -0.03014409f, -0.00433390f, 
    -0.02988714f, -0.01016493f, 0.01986542f, 0.04194867f, 0.02404861f, 0.00942655f, -0.05136210f, 0.00785756f, 
    0.02801337f, 0.00314620f, -0.03293962f, -0.04316858f, -0.00431819f, -0.02362949f, -0.04946492f, 0.00350425f, 
    -0.01721205f, -0.04515608f, 0.01385583f, -0.04328334f, -0.00635544f, 0.00961110f, 0.01034063f, -0.04056619f, 
    -0.04321878f, 0.04126485f, -0.00729650f, 0.03709843f, -0.05637557f, -0.01794482f, -0.05314940f, 0.01181588f, 
    -0.03886859f, 0.01895282f, -0.05294500f, -0.02781410f, 0.03361793f, 0.03861449f, -0.05414214f, -0.00078833f, 
    -0.03184670f, 0.05621478f, 0.02482963f, 0.00834014f, 0.01318373f, -0.04124612f, -0.01332469f, -0.03779667f, 
    -0.04177847f, 0.02501668f, 0.03735373f, -0.01055828f, -0.03746069f, -0.04570874f, -0.03441304f, 0.00058768f, 
    0.00335623f, 0.04200376f, 0.04102157f, 0.03859397f, -0.00884323f, -0.01578485f, 0.03105477f, -0.03294799f, 
    0.01057564f, -0.02878474f, 0.00495848f, 0.01057778f, -0.03703819f, -0.02325772f, 0.00906229f, -0.02114165f, 
    -0.00375019f, 0.00533171f, 0.00503691f, 0.00312664f, 0.01795428f, 0.03999685f, -0.03157543f, 0.00376069f, 
    0.04386064f, -0.00791123f, 0.01460753f, -0.01082481f, -0.04274848f, -0.04797562f, -0.02236669f, -0.01994955f, 
    0.01818914f, 0.03730890f, -0.03217264f, -0.00709539f, -0.01561821f, 0.02308394f, 0.01480410f, 0.01676982f, 
    0.00858463f, -0.04829002f, -0.02109552f, -0.03845378f, 0.03696378f, 0.04078143f, 0.02641656f, -0.03505818f, 
    -0.01908192f, -0.01454175f, 0.02602254f, -0.04882565f, -0.05479194f, -0.02564813f, -0.04238582f, -0.03866641f, 
    -0.04083897f, 0.03004873f, -0.04206401f, -0.02651443f, -0.00659138f, -0.00539265f, -0.02633051f, 0.01114767f, 
    0.04146712f, -0.03697517f, -0.04247527f, -0.05765207f, -0.05325105f, -0.00737150f, 0.00511433f, -0.04495383f, 
    -0.04261215f, -0.01845195f, 0.01859416f, 0.01306312f, -0.01850059f, -0.01333712f, 0.02739608f, 0.01973095f, 
    -0.02796415f, 0.03535454f, -0.01839254f, 0.02728948f, -0.01783596f, 0.00495905f, -0.03487949f, -0.02012831f, 
    -0.04932535f, 0.01815654f, -0.01329418f, -0.04864698f, -0.02240988f, -0.02212416f, -0.05044286f, -0.03204003f, 
    -0.04923692f, -0.04301683f, -0.02393696f, 0.02705892f, -0.01077006f, -0.02576936f, -0.00881386f, -0.04876981f, 
    0.00242835f, 0.02020713f, -0.00012446f, 0.01073927f, 0.00455424f, 0.02076407f, -0.05776433f, -0.04683662f, 
    -0.03746108f, 0.03432744f, 0.02857221f, 0.01084393f, 0.04325054f, -0.02162635f, 0.01404803f, 0.02898374f, 
    0.00549181f, -0.02374524f, 0.00688938f, 0.00575127f, 0.01819008f, -0.02274204f, 0.03433770f, -0.03668936f, 
    0.01818173f, -0.01911038f, 0.01921753f, 0.00669882f, -0.01129513f, -0.03602336f, -0.00485337f, -0.03593625f, 
    0.00730972f, 0.00013093f, -0.04961846f, 0.03611042f, -0.03227130f, -0.02248745f, -0.03138316f, -0.02538466f, 
    -0.03263874f, 0.01695452f, -0.00285107f, -0.03238758f, 0.00431324f, 0.01872397f, 0.02613735f, -0.05154180f, 
    -0.00890497f, -0.00695229f, 0.04214193f, -0.04035363f, 0.01432787f, 0.03076536f, 0.01079989f, 0.03240602f, 
    0.03216633f, -0.05395332f, -0.03686187f, 0.04270005f, 0.00901246f, -0.01066825f, -0.01176890f, 0.02024131f, 
    0.02346526f, -0.01254728f, 0.03164417f, 0.00140638f, -0.04503858f, 0.00480621f, -0.02386715f, 0.00089762f, 
    -0.00045865f, 0.03417952f, -0.01372371f, 0.03335528f, 0.03481647f, -0.01447391f, 0.03737179f, 0.01420645f, 
    0.02269762f, 0.03510288f, -0.02647546f, 0.03922241f, 0.01483629f, 0.01326637f, -0.03493072f, -0.03780825f, 
    0.04043768f, 0.00678039f, -0.00801266f, -0.00967676f, -0.04088343f, -0.00521998f, -0.02176125f, 0.03146989f, 
    0.04183583f, 0.02361612f, 0.04402333f, -0.01188330f, 0.03583233f, 0.03278539f, -0.01372489f, -0.03328947f, 
    0.04231576f, 0.04280771f, 0.04059647f, -0.04882311f, 0.02277574f, -0.03424803f, -0.03754392f, 0.03094119f, 
    -0.04070177f, 0.01948473f, 0.03758113f, 0.01117132f, -0.02068214f, -0.03533771f, -0.01731812f, -0.02731939f, 
    -0.05603953f, -0.04841194f, 0.03866588f, 0.00343656f, 0.03762580f, 0.00557120f, -0.00101348f, -0.01908429f, 
    0.02721397f, -0.01871307f, -0.04241073f, -0.00028203f, -0.01572336f, -0.01405751f, -0.03381801f, 0.00474997f, 
    -0.00868585f, -0.04082176f, -0.04165864f, 0.00589843f, -0.03043568f, -0.03247099f, 0.00881683f, -0.01102196f, 
    0.02356378f, -0.02035543f, -0.01616741f, -0.02849436f, 0.01844836f, -0.01134983f, 0.00221201f, -0.02910138f, 
    -0.01815802f, -0.04663684f, -0.04841259f, -0.00058115f, -0.00486653f, -0.01550935f, 0.02651577f, 0.00894291f, 
    -0.01595514f, 0.00956213f, -0.00907939f, -0.05142551f, 0.00483350f, -0.00596856f, -0.00911612f, -0.03800122f, 
    -0.08814085f, 0.04818935f, -0.09370168f, 0.02993871f, -0.05369956f, -0.09574983f, -0.00971565f, -0.07634518f, 
    -0.08138199f, 0.08593780f, 0.04794243f, 0.03004883f, -0.10583458f, -0.09068079f, 0.08292597f, 0.19724822f, 
    -0.05848270f, -0.08849527f, -0.12764516f, -0.04861778f, 0.12655625f, -0.22129898f, 0.01549180f, 0.01901712f, 
    0.05071672f, 0.05527351f, -0.26363224f, 0.29343417f, -0.05828590f, -0.08635545f, 0.02161930f, 0.03694942f, 
    0.16269295f, 0.03070928f, 0.02814760f, 0.21295361f, 0.43878829f, 0.19099770f, 0.32820454f, -0.00516823f, 
    0.03917955f, -0.04922657f, 0.10884237f, -0.19472656f, -0.02790295f, -0.03654067f, 0.14895302f, 0.13244334f, 
    0.02685156f, -0.07494976f, -0.00359281f, -0.16699527f, -0.05967786f, 0.08088527f, 0.09716215f, 0.14662564f, 
    0.06201920f, -0.01209415f, -0.07363389f, -0.24916692f, 0.22889578f, 0.29852235f, 0.26568663f, 0.00873271f, 
    -0.12437239f, 0.00633718f, 0.08430277f, -0.02269072f, -0.12463636f, 0.09568044f, -0.10888515f, 0.08480866f, 
    0.08902770f, -0.03997755f, -0.41663080f, -0.20097399f, 0.18049034f, 0.11743627f, -0.08246900f, 0.14665814f, 
    0.06909911f, 0.02078110f, -0.09943329f, 0.06555695f, -0.03788459f, -0.13290536f, 0.12055945f, 0.13245992f, 
    0.17695510f, -0.06221921f, 0.06949991f, -0.04386435f, 0.06165905f, 0.06007417f, 0.00529410f, 0.10311025f, 
    -0.19690101f, -0.00332826f, -0.09279231f, 0.00394644f, 0.03416916f, -0.00550850f, 0.04259738f, -0.02364430f, 
    -0.04889317f, -0.03749476f, -0.07353473f, -0.16927125f, -0.13003686f, -0.13001665f, 0.66250610f, 0.02196615f, 
    -0.02226493f, 0.02747245f, 0.04467816f, -0.02236002f, -0.02968159f, -0.02154759f, -0.26464155f, -0.01576033f, 
    0.09344511f, -0.05519375f, -0.31001440f, 0.50366247f, -0.05851620f, -0.11008460f, -0.14036086f, -0.09024534f, 
    0.04652273f, -0.08806705f, -0.06866197f, 0.18956392f, 0.07262745f, 0.20141006f, 0.14225270f, 0.01150394f, 
    0.14894728f, 0.23343350f, 0.08116138f, -0.13300681f, -0.02900304f, 0.13765673f, 0.02035909f, 0.01930223f, 
    -0.03154410f, 0.15583147f, -0.08978897f, -0.06906191f, 0.10611306f, 0.07341004f, 0.19574897f, 0.04028593f, 
    -0.13191724f, -0.05450772f, 0.10089879f, 0.02521554f, -0.13573638f, 0.34491068f, 0.13244362f, -0.07100982f, 
    0.26217380f, 0.03721208f, 0.15318874f, 0.01525431f, -0.17063044f, 0.03562276f, 0.09030203f, -0.10453089f, 
    0.01539801f, 0.28208628f, 0.29206339f, 0.23113947f, 0.03983241f, 0.03501288f, 0.15940155f, 0.23163320f, 
    0.05406713f, 0.06279426f, -0.07623579f, 0.05653832f, 0.09778430f, -0.14620765f, -0.16399294f, 0.18298002f, 
    0.13809901f, 0.32386315f, 0.22131009f, 0.33035281f, 0.00045945f, 0.05152772f, 0.00993336f, -0.03926620f, 
    -0.17189644f, 0.05610199f, 0.09712980f, -0.01212158f, 0.07818864f, 0.10209304f, 0.15606521f, 0.13511765f, 
    -0.20667200f, -0.00910922f, 0.04027640f, -0.05045364f, -0.14108130f, -0.00395404f, 0.10808564f, 0.30393767f, 
    0.00299589f, -0.06228185f, 0.08916751f, 0.05272410f, 0.06290039f, 0.07294630f, -0.04278889f, -0.20541099f, 
    0.09950015f, -0.09450182f, 0.15117304f, 0.14755824f, 0.06813011f, 0.18724127f, 0.02540972f, 0.26166654f, 
    0.02445887f, -0.02841989f, -0.05046134f, -0.06995873f, -0.35909015f, 0.06460090f, -0.03520265f, -0.09040345f, 
    -0.06864024f, 0.04072268f, -0.06217910f, -0.13238055f, 0.10859310f, 0.25316387f, 0.09666813f, 0.00323117f, 
    0.06081041f, -0.23410682f, 0.48782435f, -0.07148032f, -0.04662429f, -0.07217220f, 0.01325332f, 0.08802121f, 
    -0.13408484f, -0.19095774f, 0.12655202f, 0.09229696f, -0.41022646f, -0.13149154f, -0.42186075f, -0.19509391f, 
    0.14042531f, -0.07687569f, 0.14457090f, 0.03291263f, 0.00721940f, 0.03964842f, -0.20001452f, -0.14840077f, 
    -0.04543382f, 0.13016048f, 0.01152930f, -0.12538700f, 0.07502261f, 0.08047977f, 0.25639018f, -0.02681730f, 
    -0.15263721f, -0.00206879f, 0.00927644f, 0.00879656f, -0.05751705f, -0.03848968f, -0.07235444f, 0.10588182f, 
    0.08682487f, 0.02534918f, -0.11675348f, -0.05039207f, 0.01116820f, -0.05188045f, 0.08943420f, 0.12948333f, 
    0.16842741f, 0.19870760f, -0.08795115f, -0.20867331f, 0.19436809f, -0.17273885f, 0.15492480f, -0.16266327f, 
    -0.07443662f, -0.05462205f, -0.05411084f, -0.04272904f, 0.23027577f, -0.41240576f, -0.41211480f, 0.22737932f, 
    0.12125307f, 0.12110475f, -0.14968178f, 0.09268967f, 0.01741923f, 0.06131213f, 0.09000944f, 0.02530690f, 
    0.05677941f, -0.06820986f, 0.03585853f, 0.00980688f, -0.00016582f, 0.00262567f, -0.11765867f, 0.01425158f, 
    0.02759332f, -0.03255551f, -0.08396647f, -0.09667493f, 0.35906383f, 0.21741337f, 0.28559321f, 0.19669278f, 
    -0.08749901f, 0.03326310f, 0.03889829f, 0.08385972f, -0.02647538f, -0.00140292f, 0.01599420f, 0.28259984f, 
    -0.20967419f, -0.06527335f, 0.03970549f, -0.20325710f, -0.00788321f, 0.04043506f, 0.01809385f, -0.03532524f, 
    -0.06777193f, -0.08281026f, -0.07646970f, -0.14622851f, 0.10700101f, 0.16821165f, 0.01375506f, 0.05347095f, 
    0.14138536f, 0.14166416f, 0.04334887f, 0.02865799f, 0.00206119f, 0.07836198f, -0.13974686f, -0.05014619f, 
    0.12980911f, 0.23075511f, -0.00594972f, 0.07085174f, 0.04569841f, 0.31194377f, 0.19963610f, -0.05395092f, 
    0.03746824f, 0.07084406f, 0.19059905f, 0.01476323f, -0.12516744f, -0.18184307f, -0.52306974f, 0.04211913f, 
    0.12231281f, 0.13728359f, -0.03305053f, 0.31316575f, -0.00423317f, 0.10046506f, 0.02615156f, 0.08511835f, 
    -0.04973798f, -0.05691703f, 0.03630640f, 0.02285044f, -0.04877935f, -0.03382344f, -0.05216774f, -0.02083153f, 
    0.04294986f, -0.01111164f, 0.02986130f, -0.00398843f, -0.05098452f, 0.01491693f, 0.03932714f, -0.01676397f, 
    0.01510771f, -0.05527927f, -0.00704478f, -0.01854247f, -0.02914222f, -0.05772889f, -0.02693130f, -0.02299588f, 
    -0.03532606f, -0.04999136f, 0.00030660f, -0.01484460f, -0.01662951f, 0.00772739f, -0.03513641f, -0.00452051f, 
    -0.02949969f, -0.03419411f, -0.03770046f, 0.02188693f, -0.05829530f, 0.03689000f, -0.04141225f, 0.03453008f, 
    -0.00393318f, -0.01627247f, 0.00339115f, 0.03168640f, -0.01932598f, 0.00709503f, 0.00351495f, -0.00714100f, 
    -0.02916110f, -0.04716755f, 0.01308677f, -0.02675089f, -0.05161032f, 0.01794661f, 0.01280974f, -0.03172928f, 
    -0.03469042f, -0.05870866f, 0.03105407f, -0.03817387f, -0.00328667f, -0.03968279f, 0.00118617f, 0.01888939f, 
    -0.03833806f, -0.01021922f, -0.02213170f, -0.03112132f, 0.00571910f, -0.04450767f, 0.01300291f, -0.03593192f, 
    -0.03329955f, -0.00716566f, -0.04627741f, -0.01905648f, 0.03792194f, 0.02267109f, -0.01213253f, -0.04318850f, 
    0.04140183f, 0.00712142f, -0.05390497f, 0.02259009f, 0.04201916f, 0.01730194f, -0.01743638f, 0.02425701f, 
    -0.05231827f, -0.01068000f, -0.03387910f, 0.01451862f, -0.01413205f, -0.03141942f, 0.02245346f, -0.02164301f, 
    0.01206250f, -0.03224415f, -0.02162991f, 0.01853278f, 0.00233604f, 0.02484050f, -0.00998498f, 0.01298158f, 
    0.00653407f, -0.03866026f, 0.01476414f, -0.00134565f, 0.00626070f, -0.03614787f, 0.01046965f, 0.01139562f, 
    0.04224703f, -0.01884429f, 0.02519983f, 0.01590369f, -0.01498294f, 0.01207522f, 0.01512383f, -0.00379610f, 
    -0.00067495f, -0.04063777f, -0.02120738f, 0.00830941f, -0.02725992f, -0.04518754f, 0.00468118f, -0.04288403f, 
    0.03282800f, -0.02021798f, -0.01663762f, -0.00402077f, -0.04737025f, 0.02120876f, 0.03946517f, -0.01153337f, 
    -0.03036132f, -0.00906377f, 0.02279134f, 0.04328090f, 0.02970000f, -0.04556149f, -0.03931259f, -0.00345512f, 
    0.02318555f, -0.03116432f, -0.01936783f, -0.02188607f, -0.03781907f, 0.00628440f, -0.04007298f, -0.03492579f, 
    -0.01017695f, 0.03227820f, 0.04152084f, -0.04784288f, 0.03381934f, -0.05020279f, -0.02813599f, 0.02369200f, 
    0.03838772f, 0.03566650f, -0.00402345f, -0.03082488f, -0.01721619f, -0.00502686f, 0.00699162f, 0.03655739f, 
    0.00852877f, 0.04344053f, -0.00143229f, -0.03124319f, -0.04401440f, -0.00932779f, -0.02340206f, -0.02547554f, 
    0.03062395f, -0.04328911f, -0.01696565f, 0.00787509f, 0.03057957f, 0.03996004f, -0.04966151f, -0.04441534f, 
    -0.01583220f, -0.01507542f, -0.00747982f, -0.04404829f, 0.04068127f, -0.01285280f, -0.00811092f, 0.01386369f, 
    0.02762872f, -0.04307844f, -0.04439192f, -0.04948397f, 0.02822306f, -0.00293493f, -0.05456737f, -0.01439505f, 
    0.01756775f, -0.03905309f, 0.00807769f, -0.04332767f, -0.04903052f, -0.02882635f, 0.02088075f, -0.03923212f, 
    -0.01444277f, 0.01352453f, 0.01827794f, -0.04185866f, -0.05442291f, -0.04469119f, -0.01225791f, -0.02167736f, 
    -0.02612534f, -0.00726410f, -0.04762152f, 0.02958643f, -0.03945720f, 0.01515378f, 0.01015619f, 0.00730642f, 
    -0.04731572f, -0.00649381f, 0.00576414f, 0.02407167f, -0.00847285f, -0.03693494f, -0.03216657f, 0.00757764f, 
    -0.04761044f, 0.01224749f, -0.02711121f, -0.02878240f, 0.02427412f, -0.05492570f, -0.03714053f, -0.02305339f, 
    0.03360630f, 0.00709052f, 0.02794025f, -0.04062761f, -0.02040916f, -0.03428119f, -0.05506417f, 0.02680185f, 
    -0.01311654f, 0.04321276f, -0.04911194f, -0.03464775f, -0.05430108f, 0.02842979f, 0.00148126f, -0.00995146f, 
    -0.01369597f, 0.02042923f, -0.02397903f, 0.01521286f, 0.02778330f, 0.03021620f, -0.02637339f, 0.03955299f, 
    -0.01038272f, 0.02666376f, -0.01506991f, -0.02502198f, 0.03813673f, 0.02822216f, 0.04012300f, -0.01309416f, 
    -0.04565638f, -0.00186389f, -0.02250139f, 0.04309977f, -0.03181420f, 0.00863304f, -0.02228528f, 0.02310846f, 
    0.02429236f, -0.00720938f, -0.01364224f, -0.02983249f, -0.05093724f, 0.00102557f, 0.02863011f, -0.00398470f, 
    0.01873887f, 0.02415870f, -0.01072301f, -0.04598332f, -0.05689747f, -0.04079020f, 0.02450503f, 0.02294964f, 
    0.04132211f, -0.01433999f, 0.01881723f, 0.02899488f, -0.02694826f, -0.00831972f, 0.01664639f, -0.04121043f, 
    -0.02167163f, 0.03583594f, 0.01836319f, 0.01694446f, 0.00960301f, -0.02976094f, 0.03365068f, -0.02436121f, 
    -0.02374093f, 0.03556084f, -0.05681505f, -0.03294486f, 0.02440484f, 0.02209224f, -0.02947821f, 0.03657958f, 
    -0.01220017f, 0.01075843f, 0.01418878f, 0.04603813f, -0.01594884f, -0.03142127f, -0.04358550f, -0.01185129f, 
    -0.01363697f, -0.03304814f, -0.01412928f, -0.01153460f, 0.01042537f, -0.02767604f, -0.01093570f, -0.01570355f, 
    -0.05098017f, 0.02298657f, 0.03901396f, -0.01061127f, 0.04058068f, 0.00789707f, -0.00783366f, -0.01380703f, 
    -0.03058745f, -0.04989996f, 0.04662802f, -0.05149909f, -0.04155139f, -0.02406853f, 0.04139577f, -0.00701721f, 
    0.00107063f, 0.02653425f, -0.00374081f, 0.03777754f, 0.01680005f, -0.04384543f, -0.05656761f, -0.01549598f, 
    -0.05736949f, -0.03061042f, -0.02767571f, -0.05212587f, -0.02613213f, -0.02895914f, 0.02136143f, 0.02863479f, 
    0.01307358f, -0.02127130f, 0.01523859f, 0.01652029f, -0.02089914f, 0.01840375f, 0.03715871f, -0.05644047f, 
    -0.01760075f, 0.03178663f, -0.05442658f, 0.01448438f, -0.00491413f, -0.05431626f, -0.03810151f, -0.03099857f, 
    0.19139008f, 0.16926607f, -0.09771217f, -0.02974799f, 0.00033347f, -0.00836212f, -0.08319218f, 0.03722283f, 
    -0.07104418f, -0.25080213f, -0.15341696f, -0.14153428f, -0.09584197f, 0.23353204f, 0.07796693f, 0.04362129f, 
    0.04115682f, 0.03934819f, 0.23085132f, -0.08147246f, -0.14259209f, -0.02934027f, 0.05230784f, 0.04843644f, 
    -0.36204019f, -0.03717177f, 0.05218337f, -0.05382411f, -0.04493087f, -0.08049059f, -0.14867884f, -0.04516472f, 
    0.02637872f, 0.19008483f, 0.09750655f, 0.23227389f, -0.10825315f, -0.20981865f, -0.01435348f, -0.02596839f, 
    -0.07965600f, -0.03941866f, 0.00962593f, -0.22549543f, 0.00655886f, -0.01447900f, -0.00478142f, 0.04410401f, 
    0.17226417f, 0.04702556f, 0.09690843f, -0.33267248f, -0.10352200f, 0.18732011f, 0.04739852f, 0.08305132f, 
    0.08153206f, 0.21431786f, 0.20033623f, 0.22696052f, 0.63760555f, -0.05708887f, -0.19531967f, -0.24920370f, 
    0.06514309f, -0.04082077f, -0.01068036f, 0.16532417f, -0.08240392f, 0.00058865f, 0.00579636f, -0.11092962f, 
    -0.14056903f, 0.00625587f, 0.01482258f, 0.08841531f, 0.00749555f, 0.02562575f, -0.06529560f, 0.06041057f, 
    0.06688876f, -0.04154291f, -0.02174964f, 0.28092551f, 0.04701474f, 0.03773388f, -0.01942120f, 0.02334327f, 
    0.06125563f, -0.24249242f, 0.25244784f, -0.01211738f, -0.12231257f, -0.16173150f, -0.15476081f, -0.15219535f, 
    0.24333680f, -0.00691330f, 0.00369722f, -0.07332221f, -0.01503770f, 0.13983725f, -0.03573536f, -0.06508934f, 
    -0.04154091f, -0.11626884f, -0.03442832f, -0.08808554f, 0.12886450f, 0.25062311f, -0.06694148f, -0.23649113f, 
    -0.05428266f, 0.06542331f, -0.00931976f, -0.08997081f, 0.09980512f, 0.05863450f, 0.10297345f, 0.12111613f, 
    -0.38260052f, -0.03791847f, 0.34843811f, -0.15125489f, 0.03530328f, -0.13675252f, -0.00926938f, -0.11570393f, 
    -0.17428653f, 0.06921218f, 0.01145483f, -0.04884544f, -0.08674015f, -0.17645146f, 0.04749653f, 0.12279576f, 
    0.19448334f, 0.01764646f, -0.20102768f, -0.09648447f, -0.05324233f, -0.18874612f, 0.17064543f, -0.15074171f, 
    -0.14168285f, -0.23574018f, -0.11814107f, -0.09681392f, -0.06815529f, -0.07693613f, 0.14715166f, -0.04408659f, 
    -0.04215458f, 0.22329198f, 0.08249604f, 0.10857192f, -0.10534073f, -0.06279851f, 0.16600695f, -0.12572980f, 
    0.04738107f, -0.11594612f, -0.10169614f, -0.04597443f, -0.08414730f, -0.08437376f, -0.14185086f, -0.16380756f, 
    0.18200879f, -0.20180304f, -0.16288492f, 0.19746092f, 0.06365444f, -0.02067367f, 0.18767317f, 0.09511065f, 
    0.08742590f, -0.13826074f, 0.00435215f, 0.13865902f, 0.22197080f, -0.32629719f, 0.41128492f, -0.29265791f, 
    0.01048267f, 0.06779480f, -0.06310344f, -0.04436662f, 0.00244822f, -0.04107831f, -0.01610313f, -0.13777103f, 
    -0.30194077f, 0.18947893f, -0.32098714f, 0.21317421f, 0.03728086f, 0.07800150f, 0.08063553f, -0.15027127f, 
    -0.00582825f, -0.02294125f, -0.14386751f, 0.08310808f, 0.11135930f, -0.09768504f, -0.21920818f, 0.33824849f, 
    0.00345113f, -0.00594857f, 0.24957460f, 0.11830095f, 0.14701451f, 0.03914955f, 0.10639980f, 0.02446913f, 
    -0.07307031f, 0.13891633f, 0.19212095f, 0.27136916f, 0.03674929f, 0.14476338f, 0.09412050f, -0.06001601f, 
    -0.05973593f, -0.10264749f, -0.12663426f, 0.00012166f, -0.17547436f, 0.01171399f, -0.04508828f, 0.17647178f, 
    0.01386268f, 0.05035760f, -0.09135425f, 0.03622505f, -0.07097521f, 0.10248860f, -0.14259574f, -0.07713295f, 
    0.35000262f, 0.23644587f, -0.15621279f, -0.20905171f, 0.02566426f, 0.01504659f, 0.02639079f, 0.08464582f, 
    0.02258209f, 0.24311042f, 0.19870371f, 0.09508787f, -0.25503492f, 0.09616971f, 0.30871883f, 0.11578010f, 
    0.05352881f, 0.00778025f, 0.04188145f, 0.09300437f, 0.00295089f, -0.12497519f, -0.04852739f, -0.00071805f, 
    -0.12509030f, 0.16559535f, 0.00346093f, 0.01576905f, 0.17509222f, 0.06765551f, 0.27459449f, 0.04914103f, 
    0.00478303f, 0.09558427f, 0.04377443f, 0.27276373f, 0.08359851f, -0.14969787f, -0.09162726f, -0.11814918f, 
    0.02033518f, 0.02229036f, -0.21490034f, -0.10942674f, -0.10378370f, -0.09440194f, -0.10250358f, -0.13536355f, 
    -0.15430644f, -0.17258963f, -0.06961755f, -0.00166765f, 0.08806308f, -0.10081833f, -0.06876045f, -0.19533432f, 
    -0.00206508f, -0.03118932f, -0.11939215f, -0.09281349f, -0.51570153f, 0.29321936f, 0.35393703f, 0.21409114f, 
    -0.05455969f, 0.12620915f, 0.00044094f, 0.04993708f, -0.01301205f, 0.06803241f, 0.08747865f, -0.03168860f, 
    -0.02283015f, -0.06279879f, -0.09968384f, -0.31199944f, -0.08126558f, -0.01502053f, -0.00516388f, -0.11811019f, 
    0.00489806f, 0.16373345f, 0.02234833f, 0.11469419f, -0.09409790f, -0.28196073f, -0.15218435f, -0.08648253f, 
    -0.02151381f, -0.08420841f, -0.04233213f, -0.10627271f, -0.04356445f, 0.00290337f, -0.11546978f, -0.08994298f, 
    -0.27604997f, 0.10016330f, -0.28110138f, -0.01891368f, 0.00263844f, -0.04128354f, 0.01829237f, -0.03488285f, 
    0.28940359f, 0.13299009f, 0.21202503f, 0.34869596f, -0.11406168f, -0.18092221f, 0.06248184f, 0.09619017f, 
    0.06798925f, -0.02496023f, -0.04743953f, -0.07543482f, 0.17543510f, 0.09404252f, 0.15123866f, 0.24170455f, 
    -0.09098278f, -0.05661951f, 0.04076154f, 0.07573114f, 0.01884147f, -0.33188063f, 0.12238423f, -0.07091343f, 
    -0.05799543f, 0.22151251f, -0.14312097f, -0.08357809f, -0.39512566f, 0.20544218f, 0.17224644f, 0.37514618f, 
    -0.02281716f, -0.02841532f, 0.16967288f, 0.08058880f, -0.02416394f, 0.08015904f, 0.21396679f, 0.11176532f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02697504f, 0.15962671f, -0.04373854f, -0.04194473f, -0.00135072f, -0.04282462f, 0.01776557f, 0.11878943f, 
    -0.03517857f, -0.02555804f, 0.21118905f, 0.18825354f, -0.03246733f, -0.04686185f, 0.02607553f, 0.08782212f, 
    -0.00650765f, -0.00657493f, 0.08100998f, 0.02059672f, 0.08730900f, 0.20028827f, 0.12597801f, 0.15441535f, 
    0.13827819f, 0.02341836f, -0.02847348f, -0.04630200f, 0.00325813f, 0.08936013f, 0.02627269f, 0.06569823f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.35558021f, 0.36470231f, -0.00203978f, 0.20700659f, 0.18152361f, 0.03604402f, 0.02278912f, -0.08483014f, 
    -0.08504868f, -0.03556503f, -0.31480172f, -0.05027606f, 0.13832833f, 0.12582779f, 0.11286533f, 0.10146165f, 
    0.32937080f, 0.01621255f, 0.30013546f, 0.39096498f, -0.13623151f, 0.17889307f, 0.10982218f, -0.08589190f, 
    -0.47436824f, 0.37157854f, -0.15848623f, -0.06350921f, 0.02548752f, 0.11959081f, 0.12065251f, -0.18817131f, 
    -0.26415050f, 0.25850797f, 0.14519161f, 0.35396644f, -0.19080178f, 0.07855768f, -0.23559566f, 0.21969455f, 
    -0.01991875f, -0.13978240f, -0.21870047f, 0.16214250f, -0.19071649f, -0.26347736f, -0.21262725f, 0.12503661f, 
    -0.18441451f, -0.01423895f, 0.08201324f, 0.33736798f, 0.10349449f, 0.15513000f, -0.50354517f, 0.06681000f, 
    0.23629205f, -0.09623786f, 0.06623734f, 0.07997590f, 0.11041032f, -0.35406330f, 0.04461413f, 0.34608027f, 
    -0.35866037f, 0.23306434f, 0.16891181f, -0.17660724f, -0.23472665f, 0.04359622f, -0.43039313f, -0.09912853f, 
    -0.06040063f, -0.04231701f, -0.05842884f, -0.07030454f, 0.09498708f, -0.07059256f, -0.12317509f, 0.24477586f, 
    0.11153290f, -0.14497370f, 0.27589172f, 0.44324031f, 0.02753737f, 0.10714984f, 0.34024993f, 0.18749347f, 
    -0.19810666f, -0.28179798f, -0.16504768f, 0.04579518f, -0.11070506f, 0.23499711f, 0.05728113f, 0.38723025f, 
    -0.15022475f, -0.10334708f, 0.05962342f, -0.10603257f, 0.20879078f, 0.10606738f, 0.18028486f, -0.00136204f, 
    -0.04124975f, -0.04047282f, -0.20026045f, -0.23733160f, 0.08285552f, -0.09736560f, -0.25140941f, -0.15219985f, 
    -0.11795143f, 0.13248304f, 0.04152703f, 0.38418955f, -0.07352437f, -0.18554430f, 0.08861281f, -0.19648062f, 
    0.17248926f, -0.41089177f, 0.14491212f, -0.06442001f, -0.02853356f, -0.07976758f, -0.09082479f, 0.05096626f, 
    0.11539447f, 0.27723795f, 0.02328065f, -0.47904763f, 0.22401915f, -0.12656258f, -0.06867858f, 0.18038274f, 
    0.13122185f, 0.03516578f, 0.20510468f, 0.28039095f, -0.07626956f, -0.07728861f, 0.25015613f, -0.10185329f, 
    -0.07014028f, 0.06538825f, 0.39876881f, -0.22139435f, 0.10190000f, -0.08793264f, 0.26865393f, -0.16980429f, 
    -0.37259996f, -0.02792111f, -0.14826453f, -0.11157367f, -0.13591510f, -0.13619153f, 0.06218570f, -0.05042668f, 
    0.15833177f, 0.08662134f, -0.14494193f, -0.02020509f, -0.07496435f, 0.04599097f, 0.26123241f, 0.12391328f, 
    0.00362191f, -0.09576575f, 0.10773836f, 0.43290579f, -0.10501877f, -0.10458989f, 0.21828458f, -0.17151812f, 
    0.12589011f, -0.02788982f, -0.17575885f, -0.17138009f, 0.15945217f, 0.16273627f, -0.21702094f, -0.26249719f, 
    -0.01132706f, 0.31564063f, 0.09912441f, -0.10715869f, -0.04992757f, -0.39764246f, -0.07519746f, 0.12750311f, 
    -0.11369456f, 0.24403119f, -0.04794428f, -0.20804885f, -0.00672777f, -0.13622671f, 0.11000078f, -0.01951424f, 
    0.13166596f, 0.01521458f, 0.10387514f, -0.13262293f, 0.04858148f, -0.33477035f, 0.18210869f, -0.18499342f, 
    -0.06573711f, 0.11962357f, 0.05152722f, -0.24250868f, -0.33500877f, 0.19483054f, 0.08500189f, 0.05259436f, 
    -0.30341747f, 0.28571042f, -0.16263843f, 0.07600617f, -0.03644652f, -0.03726241f, -0.14864871f, -0.19881514f, 
    0.24078462f, -0.13228938f, 0.10250423f, 0.27786630f, 0.27088496f, 0.13911277f, 0.23568650f, -0.01034096f, 
    -0.17244700f, 0.08807161f, 0.29906154f, -0.53264540f, -0.22815214f, 0.10593029f, 0.04226904f, -0.09386533f, 
    0.11296366f, -0.01151202f, -0.15050817f, 0.00675991f, -0.19860202f, -0.16930704f, 0.38556319f, 0.18579270f, 
    0.36675605f, 0.08811687f, 0.10620047f, 0.02057158f, -0.16305624f, 0.26584077f, -0.01759033f, -0.39693362f, 
    -0.36566284f, 0.12845550f, -0.17081735f, 0.34526446f, 0.22013268f, 0.04421606f, -0.06008455f, 0.30772135f, 
    0.13628778f, -0.05684276f, 0.23191468f, -0.04511182f, 0.12325732f, -0.45109102f, 0.34736082f, 0.03671474f, 
    0.02263345f, 0.10279509f, 0.12612450f, -0.25689211f, -0.10441430f, 0.00680595f, 0.00662731f, 0.14311135f, 
    -0.15973896f, -0.31450614f, 0.08487608f, 0.14921653f, -0.17235370f, 0.20081191f, -0.07733961f, -0.11997966f, 
    -0.50186187f, 0.01394241f, 0.01549774f, 0.25988528f, 0.04829619f, -0.11860111f, -0.21648961f, -0.08108839f, 
    0.02098270f, 0.14909907f, 0.26455972f, -0.20061138f, -0.39494145f, -0.42509460f, 0.23259549f, 0.28099415f, 
    0.03009736f, -0.13840672f, 0.05373066f, 0.03057324f, -0.06453221f, 0.28976262f, 0.26615521f, 0.21332042f, 
    -0.04439045f, -0.12770580f, 0.00542548f, -0.00044173f, -0.01222677f, 0.27854669f, -0.10854691f, -0.34530297f, 
    -0.09623104f, -0.05103266f, 0.04060292f, -0.17151476f, -0.16670837f, -0.14483891f, 0.09088250f, 0.13984016f, 
    -0.02647276f, 0.09936801f, 0.17705633f, 0.09872387f, -0.31690338f, 0.38433081f, 0.34088299f, 0.42202079f, 
    0.17595269f, -0.10146275f, -0.06046668f, -0.43753937f, -0.25441095f, 0.10551954f, 0.09289807f, 0.00440481f, 
    0.13896343f, -0.22357813f, -0.04890281f, 0.09288084f, -0.03915103f, 0.02020501f, 0.12890176f, -0.05166999f, 
    0.40625721f, 0.07179597f, -0.13481998f, 0.27047396f, -0.11917776f, 0.14955604f, 0.23152287f, 0.15165165f, 
    0.01235379f, 0.14019577f, 0.22642234f, -0.16870815f, -0.33401325f, 0.18370506f, -0.31993940f, 0.46870491f, 
    -0.21963912f, -0.00413444f, -0.22307183f, 0.21038309f, 0.10346481f, 0.21338296f, -0.00642641f, 0.03335272f, 
    0.57228154f, 0.01556792f, 0.00334190f, -0.03024597f, -0.12771955f, -0.28073412f, 0.05837924f, 0.03625559f, 
    0.10408495f, -0.11098056f, 0.05439388f, 0.03160489f, -0.11311248f, 0.09485403f, -0.13058300f, 0.13790181f, 
    0.00234468f, 0.06600909f, 0.03477882f, 0.12176006f, 0.20158309f, -0.21357416f, -0.19454288f, 0.16087383f, 
    -0.28243452f, -0.02419822f, -0.20165394f, -0.06507771f, -0.00759699f, 0.41887039f, -0.39808118f, 0.06963775f, 
    0.20191523f, -0.00230297f, 0.04083722f, -0.03021791f, -0.05363116f, -0.13137056f, -0.11668038f, 0.15452836f, 
    0.26728690f, -0.02997709f, 0.02223913f, -0.34819975f, 0.09526352f, 0.09680902f, 0.18405722f, 0.32122034f, 
    0.00917189f, 0.13376832f, 0.22350594f, 0.08748534f, 0.02284312f, 0.22800525f, -0.29775175f, -0.40236300f, 
    -0.14806730f, -0.14771067f, 0.36927906f, 0.10801268f, 0.17159644f, -0.20672213f, -0.09264598f, 0.19500309f, 
    0.24683121f, 0.23127775f, -0.02947064f, 0.13311267f, 0.06298573f, 0.17397030f, 0.06441277f, 0.64530009f, 
    -0.04108198f, 0.04979839f, 0.02361473f, -0.21574502f, 0.12062220f, -0.07089913f, 0.14338514f, 0.26935762f, 
    -0.06455176f, -0.06081286f, -0.00975275f, 0.10355024f, 0.04475873f, -0.05887260f, 0.05476280f, 0.08801010f, 
    -0.18941079f, -0.07418298f, -0.03346521f, -0.13853200f, -0.28174967f, -0.10978213f, -0.05835666f, 0.02980568f, 
    0.10111902f, 0.08043268f, 0.08439238f, -0.07726695f, -0.04117266f, -0.16563806f, 0.04158781f, 0.10055538f, 
    -0.02813672f, 0.22876233f, 0.12241506f, -0.28037727f, 0.08803003f, -0.13571389f, 0.03904467f, -0.01721968f, 
    0.14081235f, -0.12501310f, 0.15216595f, 0.10641234f, -0.33021960f, -0.13887784f, 0.19114378f, 0.05429032f, 
    0.01983209f, -0.12875715f, -0.02857090f, -0.01327529f, -0.26911113f, 0.04824898f, 0.43203709f, 0.28751725f, 
    -0.08368951f, 0.04341244f, -0.05239094f, 0.16498683f, -0.04916289f, -0.08028525f, -0.13652511f, -0.24810824f, 
    -0.30390969f, -0.10014194f, 0.00526351f, 0.07797296f, -0.10740250f, -0.00483504f, 0.08379326f, -0.31581494f, 
    -0.11276840f, 0.03637547f, 0.09441469f, 0.27249256f, -0.56680423f, -0.21594486f, 0.10565346f, -0.06922736f, 
    0.28273129f, -0.16586410f, -0.14400712f, 0.19318531f, 0.34338194f, -0.01938908f, -0.16883402f, 0.04207353f, 
    0.24519895f, -0.40717331f, -0.01656238f, -0.14928944f, 0.10491513f, 0.08320821f, 0.06742337f, 0.27927777f, 
    -0.20005678f, 0.20654497f, -0.14178957f, 0.19069384f, 0.11688200f, -0.01141900f, 0.22674049f, -0.18244483f, 
    0.14005661f, -0.09710570f, -0.03354514f, 0.05585847f, 0.11085072f, -0.67375427f, 0.10876069f, -0.09411941f, 
    -0.27916881f, 0.07378466f, -0.28971654f, 0.18413226f, 0.19111638f, 0.35507166f, 0.00192081f, 0.33764625f, 
    -0.09427775f, 0.26980525f, -0.05750417f, 0.07057527f, 0.05976066f, 0.05675371f, 0.01404959f, -0.25490308f, 
    -0.07133788f, 0.08071101f, 0.12760204f, 0.10594197f, 0.00472048f, -0.07000617f, -0.00177210f, 0.29622376f, 
    -0.15897182f, -0.09263833f, -0.12896076f, -0.12661283f, -0.06972036f, -0.27205226f, 0.03157642f, -0.08350214f, 
    -0.19804020f, 0.16776858f, -0.28272459f, -0.24261725f, -0.16919096f, -0.13263330f, -0.13604489f, -0.01042563f, 
    -0.15636271f, -0.07040521f, 0.01555259f, -0.03234168f, 0.15785955f, -0.03443413f, -0.04832067f, -0.02019747f, 
    0.11403173f, 0.09176677f, -0.15719371f, -0.08839102f, -0.13840997f, 0.13184918f, -0.05442625f, -0.07411769f, 
    0.12262151f, 0.01045722f, -0.03375513f, 0.02043258f, -0.05487751f, 0.01447509f, -0.17846568f, 0.06644834f, 
    -0.14379425f, 0.04207806f, -0.10975695f, 0.09968068f, -0.19178097f, -0.13959192f, -0.10684312f, -0.16108190f, 
    -0.15929514f, -0.13088284f, -0.11432786f, 0.08189487f, 0.12368515f, 0.04008174f, -0.07152331f, 0.02411981f, 
    -0.01427246f, 0.13965073f, 0.05497914f, 0.44619149f, 0.21846139f, -0.16508001f, 0.29687083f, 0.06958443f, 
    0.14828455f, 0.00823119f, 0.25167850f, -0.44720247f, 0.54837126f, -0.01898937f, 0.29847246f, 0.05635412f, 
    0.08615393f, -0.04326155f, -0.27462453f, 0.06262575f, -0.33344129f, -0.35100594f, 0.19834110f, -0.11783025f, 
    -0.03801977f, 0.29862505f, 0.01615199f, -0.09414985f, -0.06613206f, 0.24712276f, 0.08206030f, -0.38207987f, 
    -0.20062706f, -0.10795435f, -0.17604418f, -0.27735770f, 0.30762511f, -0.02822248f, -0.10904633f, 0.04475617f, 
    0.07445484f, 0.02577012f, 0.17764014f, 0.54788530f, 0.26061803f, -0.24108943f, 0.37674665f, -0.18237785f, 
    -0.06880845f, -0.11081942f, 0.05987921f, -0.42018303f, 0.07399747f, 0.11498900f, -0.09338470f, -0.20696995f, 
    -0.36604211f, 0.19459079f, -0.16897620f, 0.05193629f, 0.11344778f, 0.02853895f, 0.13106553f, -0.21069753f, 
    -0.00010426f, 0.06679608f, 0.02792034f, -0.18510485f, -0.05507943f, -0.18187812f, 0.02542721f, -0.08154672f, 
    0.10756112f, 0.12362078f, -0.06065680f, -0.11126010f, 0.56290102f, -0.05938985f, 0.09990156f, -0.10751797f, 
    -0.37596709f, -0.00313010f, -0.00729553f, -0.04448297f, -0.04922951f, -0.34575185f, 0.18292452f, -0.06549677f, 
    -0.15045407f, 0.24119668f, -0.01498567f, 0.13350007f, -0.00437338f, 0.17007051f, -0.13481320f, -0.16562568f, 
    0.19378924f, -0.02424355f, 0.12941606f, -0.04213721f, -0.01197816f, 0.04007697f, -0.24184747f, 0.08934234f, 
    0.07479914f, 0.04666629f, 0.25835481f, 0.31085747f, -0.01866016f, 0.70949548f, 0.29417035f, -0.08713954f, 
    0.32140461f, -0.12385819f, 0.36176559f, 0.16061966f, -0.07502270f, 0.07370402f, -0.16439721f, -0.60161424f, 
    -0.42005768f, -0.01582444f, 0.04217341f, 0.10127955f, 0.03200335f, 0.07578407f, -0.14003545f, -0.18378606f, 
    0.12093569f, -0.05489076f, -0.03704562f, 0.06756275f, -0.10320961f, 0.16446579f, -0.16894902f, 0.00498017f, 
    -0.14082712f, 0.12373606f, -0.38807255f, -0.26217303f, 0.10690507f, 0.19865656f, -0.14612517f, 0.36773109f, 
    0.27572370f, 0.14887322f, 0.20416051f, -0.10146892f, 0.04940234f, 0.21059455f, 0.18916997f, 0.01791090f, 
    -0.31850556f, -0.17909016f, 0.02033615f, 0.01113046f, -0.17600924f, -0.08908165f, -0.04768853f, -0.16972858f, 
    0.31025535f, 0.18117043f, 0.11546601f, 0.36307850f, 0.10941515f, 0.03463844f, 0.29639864f, 0.10266171f, 
    0.15847147f, -0.07949283f, -0.08988128f, 0.04237884f, 0.47056586f, -0.42961296f, 0.10564993f, -0.34821931f, 
    -0.06489148f, -0.06853109f, -0.32807639f, 0.07334710f, 0.21302512f, 0.03991073f, -0.18880431f, -0.12160826f, 
    0.24757388f, 0.31013426f, 0.14506397f, 0.00007554f, -0.00491459f, 0.25037801f, -0.02075599f, 0.00570283f, 
    0.03523299f, -0.11545768f, 0.14630605f, 0.19716962f, -0.12830830f, 0.10686115f, 0.06433085f, -0.13741033f, 
    -0.11971506f, 0.01387223f, -0.18537723f, -0.14070345f, 0.09252503f, 0.21031433f, -0.04498690f, 0.11046494f, 
    0.08152419f, -0.08654566f, -0.04312004f, 0.16727003f, 0.02785411f, 0.18337041f, -0.03795047f, -0.14936674f, 
    0.12729624f, 0.13581100f, -0.17058858f, 0.08334698f, -0.13142194f, 0.01697967f, -0.11536041f, -0.17835248f, 
    -0.03109624f, 0.31186891f, 0.16263068f, -0.53034830f, -0.09473035f, 0.02127465f, 0.06154656f, -0.01582186f, 
    0.06770280f, 0.11817332f, 0.12257805f, 0.03149038f, -0.20156078f, -0.14610228f, 0.28535944f, 0.27827394f, 
    -0.15445128f, 0.05254607f, 0.11830765f, -0.29318452f, 0.06228729f, 0.06937528f, 0.01606039f, 0.35974884f, 
    0.00598418f, 0.13263421f, -0.02274418f, -0.16995855f, -0.13599482f, -0.16722807f, -0.13037075f, -0.02748968f, 
    0.10346832f, 0.16534083f, 0.04111129f, -0.32112122f, -0.13537137f, 0.13313413f, -0.23932424f, -0.01657059f, 
    -0.12002979f, -0.11089987f, 0.25873950f, 0.20606004f, -0.13548055f, 0.35182047f, -0.25936738f, 0.36104986f, 
    -0.33307651f, 0.05274834f, 0.32267877f, 0.15637887f, -0.24252056f, 0.12006610f, 0.23555218f, 0.22020596f, 
    0.10413537f, 0.03503408f, 0.11746227f, -0.06791805f, 0.06188141f, 0.05690766f, 0.08817400f, 0.45246759f, 
    0.06455262f, -0.14173189f, -0.08601378f, -0.06233590f, 0.15214980f, -0.16283849f, -0.11686129f, -0.01137315f, 
    0.08602684f, -0.05118418f, -0.14442602f, -0.11980258f, 0.41800472f, 0.47898895f, -0.04336139f, 0.23052657f, 
    -0.01063698f, 0.10837898f, 0.22254182f, 0.12304159f, -0.27346542f, -0.19638766f, 0.09857623f, -0.03393327f, 
    -0.14162207f, 0.08797786f, 0.01846521f, -0.14411341f, 0.09743711f, 0.23991664f, 0.09904329f, 0.15205635f, 
    -0.48516157f, 0.24298753f, -0.02101284f, -0.17959082f, -0.08050419f, 0.12344997f, -0.06823663f, 0.29862925f, 
    -0.14670806f, -0.04672414f, 0.13228787f, 0.19852027f, -0.44196087f, -0.14422567f, 0.20372514f, -0.43324822f, 
    0.10640346f, 0.03191596f, 0.31419489f, 0.01788546f, -0.15786830f, 0.07762953f, 0.02426837f, 0.08214597f, 
    -0.00760190f, -0.30676398f, -0.06073468f, -0.09592792f, -0.02184009f, 0.29111013f, 0.10946896f, 0.19676279f, 
    -0.02642094f, 0.07544260f, 0.15613359f, 0.10641450f, -0.09091802f, -0.16578200f, 0.03767618f, -0.13331628f, 
    0.00732301f, -0.01535437f, 0.03679093f, -0.05956903f, -0.00282509f, -0.08274546f, -0.21827027f, -0.21445124f, 
    -0.19107468f, -0.16326162f, -0.01649220f, 0.01245090f, 0.02611248f, 0.08123268f, 0.07591148f, -0.12545048f, 
    -0.16910204f, 0.02806290f, 0.03024532f, 0.09639421f, 0.12158582f, -0.01062942f, -0.09686612f, -0.10334626f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10713256f, 0.15472253f, 0.15713795f, 0.06081959f, 0.21860500f, 0.03856554f, 0.05265252f, 0.04592577f, 
    0.24615675f, 0.10027640f, 0.13679408f, 0.08490910f, 0.09237249f, -0.03465718f, 0.01687662f, 0.14680038f, 
    0.04141707f, 0.04454536f, 0.12071852f, -0.17303619f, 0.09275735f, -0.00303453f, -0.07486197f, -0.09253331f, 
    0.06320697f, -0.01068413f, -0.03360824f, 0.11642116f, 0.19653560f, -0.16920966f, 0.02230418f, -0.11373979f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.15425344f, -0.14922106f, -0.26975515f, -0.07555141f, -0.01839938f, -0.16141625f, 0.27431977f, -0.03997043f, 
    0.07596218f, -0.20376444f, -0.51459503f, -0.47774255f, -0.06781463f, -0.06653366f, -0.06036206f, 0.00311787f, 
    -0.36173642f, 0.16121146f, -0.20332593f, -0.16512899f, 0.24399059f, 0.36673227f, 0.32641414f, -0.08102104f, 
    -0.31230968f, 0.21809067f, -0.10221191f, -0.14296272f, -0.29593512f, 0.26899073f, -0.29453647f, -0.04835225f, 
    0.01567540f, -0.16847670f, -0.10095846f, -0.25955045f, 0.19052894f, 0.28070977f, 0.39554760f, 0.03006753f, 
    0.09499481f, 0.14547104f, 0.17043200f, -0.35541755f, -0.22524789f, -0.36734599f, 0.17271411f, 0.19943963f, 
    0.25969779f, 0.14371450f, 0.08587085f, -0.20907147f, 0.04779091f, 0.34145311f, -0.69420779f, 0.14485797f, 
    -0.15416272f, -0.11826299f, -0.18197013f, 0.25038910f, -0.24845682f, -0.41638455f, 0.27122498f, -0.12891527f, 
    -0.32076752f, -0.15226948f, -0.67071295f, 0.03726721f, 0.36723650f, 0.28608131f, -0.17611502f, -0.11757989f, 
    0.10299698f, -0.27179709f, 0.27669066f, 0.26294920f, -0.11699922f, 0.16799422f, -0.00268170f, 0.27325249f, 
    -0.25843349f, -0.09925181f, 0.03208572f, 0.09080856f, -0.61716104f, 0.27571309f, -0.23707891f, -0.07964429f, 
    -0.20107634f, -0.17202358f, -0.31392109f, 0.42829916f, 0.19132128f, -0.22214231f, -0.24783967f, 0.00609263f, 
    0.13077603f, -0.44847891f, -0.10537244f, -0.51983100f, 0.14330845f, 0.08652963f, -0.17630579f, -0.02665722f, 
    -0.19876327f, -0.32532993f, 0.10984288f, -0.09449964f, -0.23928927f, 0.15713333f, -0.04280800f, -0.03949024f, 
    -0.38930017f, -0.37276018f, -0.25673264f, 0.12160520f, 0.04433542f, -0.00191172f, -0.07286943f, 0.38686571f, 
    -0.53697932f, -0.06349467f, -0.09142479f, -0.03601958f, 0.24408624f, 0.31262639f, -0.24247970f, -0.03126499f, 
    -0.12668404f, -0.45448619f, 0.04802712f, 0.17297466f, -0.35127228f, 0.12914440f, -0.32342660f, 0.23091295f, 
    -0.00682794f, -0.43258217f, -0.14586926f, 0.04468571f, -0.18789652f, 0.14542241f, 0.06047493f, -0.15028617f, 
    0.25500664f, 0.06745791f, -0.08191473f, 0.03219121f, 0.22987096f, -0.47807163f, -0.26236808f, -0.10366951f, 
    0.28199980f, 0.24453327f, -0.04469563f, -0.36349860f, -0.32791525f, 0.00368790f, -0.17441024f, -0.09217796f, 
    0.18064040f, -0.28298125f, 0.29525790f, -0.41608307f, -0.06125585f, -0.46157101f, 0.08906488f, 0.27500075f, 
    0.02073054f, 0.29304084f, -0.11663000f, -0.08191126f, -0.29300913f, -0.14983977f, -0.40893891f, 0.29516941f, 
    -0.25196683f, 0.25897413f, -0.31136146f, 0.00230549f, 0.19560431f, -0.52779490f, -0.35490832f, -0.19756407f, 
    -0.07993821f, -0.04880308f, -0.13653275f, 0.06360901f, 0.11254889f, -0.34643292f, 0.03682115f, 0.18951829f, 
    -0.88433337f, 0.19695187f, 0.29728746f, -0.39384335f, -0.32384154f, -0.12812667f, -0.15873362f, -0.60635716f, 
    -0.25144655f, -0.04075344f, 0.06505193f, 0.05755989f, 0.09665689f, 0.25331399f, -0.28066316f, -0.46084851f, 
    0.21355984f, 0.00222339f, -0.11344718f, -0.09936283f, -0.49965572f, -0.09044994f, -0.00349803f, -0.45719662f, 
    0.01132732f, -0.25828603f, -0.49183309f, 0.16437294f, 0.40949219f, -0.24508156f, 0.18033974f, 0.11159979f, 
    0.33756909f, 0.18910977f, 0.12516922f, -0.12180190f, -0.53544468f, -0.08359525f, 0.04788096f, -0.13813028f, 
    -0.51666850f, 0.09614715f, 0.01026832f, 0.23950146f, 0.10876311f, -0.64775372f, -0.42444453f, -0.23147798f, 
    0.11201337f, -0.01512708f, 0.00260046f, 0.02013013f, -0.21140696f, -0.06285885f, 0.07525679f, 0.25630087f, 
    0.35454002f, -0.35020548f, 0.12347937f, -0.48930180f, 0.08812167f, 0.09594614f, -0.42697001f, -0.15777388f, 
    0.21462917f, -0.06652076f, 0.40463030f, -0.12322973f, 0.14028613f, -0.31195158f, 0.19732453f, -0.37764734f, 
    0.17971279f, 0.19596528f, 0.11559515f, -0.36265391f, 0.24655648f, -0.12876309f, -0.13547002f, 0.16207117f, 
    -0.53817666f, -0.16064380f, 0.06027396f, -0.09410072f, -0.57339215f, -0.33072850f, -0.15859516f, 0.06015502f, 
    0.15548410f, -1.00150251f, -0.25392321f, 0.19663869f, 0.17591324f, 0.02944098f, 0.26614293f, 0.03631260f, 
    -0.08032981f, 0.23801473f, -0.35424665f, -0.31176728f, -0.31005040f, 0.32588017f, -0.16700746f, -0.26009873f, 
    0.14867602f, -0.04816449f, -0.43501517f, 0.23743694f, 0.23274641f, -0.07569108f, -0.37771869f, -0.27513599f, 
    -0.12355137f, 0.41617328f, -0.08038220f, -0.17155403f, -0.16491708f, -0.45201373f, -0.67685670f, -0.41262573f, 
    -0.14232509f, 0.29201895f, -0.03862279f, -0.02002200f, -0.17095841f, -0.40383300f, -0.45303917f, -0.04770192f, 
    -0.48046252f, -0.32395673f, -0.20869963f, -0.54527003f, 0.02753730f, -0.40741503f, -0.47258177f, 0.24001461f, 
    0.34882376f, 0.45033553f, 0.57347310f, 0.02955720f, -0.41197941f, -0.12570617f, -0.43511352f, -0.08800954f, 
    0.00838098f, -0.81490022f, -0.55950749f, -0.06219272f, 0.22029029f, 0.04928150f, -0.32944590f, 0.34908178f, 
    -0.59246999f, -0.22056951f, -0.11926804f, -0.43895656f, -0.06965071f, -0.17779040f, 0.33018446f, 0.11055574f, 
    0.10173998f, 0.14577928f, 0.00411987f, -0.28263137f, 0.17622103f, 0.02633053f, -0.16953355f, -0.42937890f, 
    0.06665790f, -0.31900576f, -0.44570398f, -0.21130119f, -0.32257533f, 0.45122936f, -0.48853287f, -0.37202504f, 
    -0.07961861f, -0.29817882f, -0.54124337f, 0.10446432f, -0.36893490f, -0.26655203f, -0.09372955f, 0.26225832f, 
    -0.68670076f, -0.03962760f, -0.20146944f, -0.43281028f, 0.06180625f, -0.38760787f, 0.47516799f, -0.00895367f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.33567756f, 0.00543848f, 0.20031825f, -0.03506605f, -0.12106372f, 0.16885851f, 0.18899685f, 0.11075580f, 
    -0.01805040f, 0.05078963f, 0.16978569f, -0.17250320f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
