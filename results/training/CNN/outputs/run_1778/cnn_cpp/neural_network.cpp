#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.48343185f, -0.24461378f, -0.28871399f, -0.36899841f, -0.06479539f, 0.45840546f, 0.26898161f, -0.14512174f, 
    0.38046330f, 0.25644198f, 0.07817573f, -0.27123186f, -0.16100207f, 0.47063595f, -0.19246463f, -0.25366452f, 
    0.71349472f, -0.42775688f, 0.06160161f, 0.23213159f, 0.15529174f, 0.17732437f, -0.22023517f, -0.02713485f, 
    0.32164901f, 0.06401213f, -0.17024641f, 0.07889939f, 0.34534180f, -0.19951889f, -0.15205833f, -0.05691387f, 
    -0.02828434f, 0.01838219f, -0.01845834f, 0.27318531f, -0.17995192f, 0.26015702f, 0.15573889f, 0.13131642f, 
    -0.65197313f, -0.63885701f, -0.20486526f, 0.34999278f, -0.23535603f, -0.31814399f, 0.59642518f, -0.21934426f, 
    0.20660043f, -0.21487853f, -0.18184675f, 0.01072027f, 0.02754147f, 0.30875599f, 0.25036037f, 0.77235371f, 
    -0.65346295f, -0.17144209f, -0.10965391f, 0.32928774f, -0.27895078f, 0.11573599f, 0.16348168f, 0.16877128f, 
    0.10204291f, 0.07579881f, -0.71640110f, 0.85363126f, -0.19028325f, 0.10108992f, -0.31694317f, 0.05904884f, 
    -0.04772470f, -0.17663574f, -0.05902576f, -0.36676148f, -0.26047772f, -0.35337076f, -0.14672872f, -0.31777248f, 
    0.59525663f, 0.26485917f, 0.33534303f, -0.02751226f, 0.13389790f, 0.31169370f, -0.45418787f, -0.08569009f, 
    -0.16714738f, -0.01157607f, 0.13106249f, -0.17302877f, 0.11957876f, -0.37759101f, -0.11997112f, -0.01271001f, 
    0.69714713f, -0.56148899f, -0.35493723f, 0.17070709f, -0.02366091f, -0.25274754f, 0.52212983f, -0.34404111f, 
    0.07403167f, 0.35325786f, -0.03913674f, 0.16653186f, -0.43552256f, -0.03589435f, 0.11165597f, -0.65288556f, 
    -0.14552872f, 0.61427850f, 0.06702880f, 0.32338780f, -0.11298741f, -0.05741189f, 0.27924129f, 0.44354132f, 
    -0.70851630f, -0.25123489f, 0.53649777f, 0.14192213f, 0.28579900f, 0.08124240f, -0.62546211f, 0.02838732f, 
    -0.07274909f, 0.88026780f, -0.11883974f, -0.31300622f, -0.33346960f, -0.41240835f, -0.15501052f, -0.74594766f, 
    0.12912661f, 0.71942693f, -0.01444381f, -0.10867017f, 0.47068670f, -0.38832179f, -0.31519961f, 0.03829330f, 
    -0.56102180f, -0.48232713f, 0.39407811f, 0.29139796f, -0.35354686f, -0.23496532f, 0.23372494f, 0.41736734f, 
    -0.06266439f, 0.21650964f, -0.43245649f, 0.13955803f, -0.32519007f, -0.09189716f, -0.52339798f, -0.35989866f, 
    0.42759004f, -0.45666444f, -0.33619398f, 0.22659217f, 0.42541927f, -0.22796680f, 0.17732897f, 0.58115047f, 
    0.30243641f, -0.68823308f, -0.06708971f, 0.80388594f, 0.49340540f, 0.47084206f, -0.48357725f, -0.27161521f, 
    -0.25998932f, -0.05148197f, 0.02879191f, 0.15141368f, 0.23357221f, 0.25466296f, 0.16594362f, -0.10895625f, 
    -0.26901543f, 0.30904377f, 0.42216063f, -0.50567871f, 0.41852498f, 0.14161591f, -0.26590353f, 0.31006542f, 
    0.36664033f, 0.60860002f, 0.43745509f, 0.14937186f, 0.28247562f, -0.20756201f, -0.39583716f, -0.51533979f, 
    0.15799281f, -0.19831108f, -0.42159823f, -0.27583271f, -0.20991758f, 0.29444864f, 0.21144173f, 0.65367067f, 
    -0.94397020f, 0.48212525f, -0.04070261f, -0.05803555f, -0.15862501f, 0.36378169f, -0.14885545f, 0.25553268f, 
    0.28243223f, 0.32898337f, 0.35138774f, 0.12508930f, 0.32443389f, 0.43894750f, 0.03307647f, 0.27623865f, 
    0.15636751f, -0.28905594f, -0.46562314f, -0.45690984f, -0.15831949f, -0.19735989f, 0.33898455f, 0.33038005f, 
    -0.03130185f, -0.12593511f, 0.15900140f, 0.08421354f, 0.23731995f, -0.10062583f, 0.05479907f, -0.00642268f, 
    0.36006624f, -0.08785526f, -0.40252528f, 0.20135406f, -0.39464131f, 0.43987364f, 0.10804038f, 0.60686231f, 
    -0.10023574f, -0.19822170f, -0.19819264f, -0.38713282f, -0.74750447f, -0.62934643f, -0.98170388f, 0.58705539f, 
    0.76160979f, 0.41180077f, -0.01768390f, 0.21023560f, -0.27127719f, -0.32621711f, 0.22566192f, 0.15508629f, 
    -0.46615037f, -0.16054037f, -0.65929824f, 0.65495104f, 0.20542185f, 0.24969651f, 0.44509789f, 0.34939128f, 
    -0.28050777f, -0.23761328f, 0.46834376f, -0.52184939f, 0.05239727f, 0.07974666f, 0.10474595f, -0.80792516f, 
    0.69393760f, 0.06002229f, -0.37239796f, -0.01600843f, -0.23095985f, -0.15916170f, 0.15258209f, -0.43301323f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.14718801f, 0.01331733f, 0.06556152f, 0.15435836f, 0.00371159f, -0.06113786f, 0.23450518f, -0.17862709f, 
    -0.30949765f, 0.16371273f, -0.32862705f, -0.08837493f, 0.19177969f, -0.03701629f, -0.03334663f, -0.10946887f, 
    0.05538442f, -0.28640541f, -0.09799916f, -0.07178918f, -0.35523701f, -0.28202680f, -0.07154681f, -0.13632607f, 
    -0.21181077f, -0.11232820f, -0.04114436f, 0.13300405f, -0.10691615f, -0.17874873f, 0.09936767f, -0.32351178f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06999158f, 0.06606279f, 0.03830146f, 0.03393273f, 0.13064764f, -0.01974591f, 0.06044692f, 0.07371125f, 
    -0.13123251f, 0.12777016f, -0.02219261f, 0.15327917f, -0.09641280f, 0.17084315f, -0.14161935f, 0.12564033f, 
    0.15185204f, 0.08229437f, 0.19683157f, 0.04402786f, 0.11518358f, 0.02368778f, -0.06744329f, -0.01722221f, 
    0.04779148f, -0.05730003f, 0.03272356f, 0.23968408f, 0.05306330f, 0.00144997f, 0.02175104f, -0.04408075f, 
    0.03488884f, -0.04520412f, 0.12380990f, 0.05582798f, -0.15621105f, 0.04676811f, 0.03463986f, 0.04322058f, 
    -0.00350663f, -0.14119698f, 0.03026122f, -0.04502590f, 0.14203514f, -0.06704333f, -0.09630263f, -0.03913621f, 
    0.02585111f, -0.15137495f, 0.02452055f, 0.04396366f, -0.05190882f, -0.05382581f, 0.22599001f, -0.03630284f, 
    0.03064245f, 0.18883219f, -0.07103533f, 0.12643462f, -0.08722393f, 0.15530328f, -0.14031322f, 0.00733627f, 
    0.09256226f, 0.05456766f, -0.00948197f, -0.08434843f, 0.00326668f, -0.06702380f, 0.15222000f, -0.07577302f, 
    0.03606401f, -0.08797614f, -0.02789498f, -0.09720711f, -0.18581942f, -0.07792848f, 0.04592096f, 0.05798683f, 
    0.08754772f, 0.05018771f, 0.17258245f, -0.05156834f, 0.02088769f, -0.16409743f, -0.03992098f, -0.03504963f, 
    0.02608670f, 0.11315032f, -0.07283647f, -0.11044954f, -0.16950330f, -0.45567074f, 0.12323864f, -0.21301489f, 
    -0.12196408f, 0.02139135f, 0.05328397f, -0.08189560f, 0.06599400f, 0.00792311f, -0.12686653f, 0.06957132f, 
    0.01933017f, 0.19301516f, 0.03642986f, -0.12952709f, 0.10099588f, -0.18318227f, 0.12108645f, 0.04050693f, 
    -0.03603862f, -0.04465608f, 0.07014330f, 0.05035440f, 0.13856226f, 0.31251541f, -0.12642257f, 0.10416819f, 
    0.01482424f, -0.00071374f, 0.06082717f, 0.04328290f, 0.05670796f, 0.08041722f, 0.16472566f, 0.04305893f, 
    0.01498121f, -0.04754114f, 0.01272493f, -0.04058724f, 0.13494855f, 0.04937491f, 0.04385154f, 0.29827523f, 
    -0.03792230f, 0.11865744f, 0.09912140f, -0.11227771f, 0.10141784f, 0.14564905f, -0.17206623f, 0.03305700f, 
    -0.08819398f, -0.19533069f, -0.04748049f, -0.10413837f, 0.09164914f, 0.04615612f, -0.03593118f, -0.17006698f, 
    0.14449601f, 0.22426531f, -0.12772669f, -0.18749644f, -0.09204312f, -0.03842534f, -0.22395644f, -0.10809295f, 
    -0.00008430f, 0.15333942f, 0.27070752f, -0.10564943f, 0.09416216f, -0.14397125f, -0.09443505f, -0.07576883f, 
    0.05492374f, -0.01515776f, 0.13488191f, 0.45208687f, 0.11069196f, 0.21323265f, -0.02615893f, -0.11106382f, 
    -0.08577210f, -0.16639338f, -0.04944046f, 0.09960303f, 0.16693509f, 0.08068813f, 0.08585028f, -0.25220427f, 
    -0.08201942f, -0.05051712f, 0.03511407f, -0.02775369f, -0.01530169f, -0.06884499f, 0.00452888f, -0.20215930f, 
    -0.12583734f, 0.07544503f, -0.01719700f, 0.02076611f, 0.12352820f, 0.11500043f, -0.00912405f, -0.19219552f, 
    -0.04293557f, -0.04887293f, 0.03756781f, -0.03672674f, 0.02140046f, -0.04930038f, 0.08511376f, -0.18795443f, 
    -0.10015167f, 0.06097798f, -0.20603457f, -0.08716073f, -0.14467005f, -0.08932159f, -0.07884768f, -0.06089546f, 
    0.12983482f, 0.09703813f, -0.06213930f, -0.07670805f, 0.03920965f, -0.12350936f, 0.04850389f, -0.02347258f, 
    -0.03576283f, -0.03182359f, 0.07590072f, 0.09283011f, -0.09231140f, -0.02056597f, -0.21069750f, -0.20920414f, 
    0.02564713f, 0.03453985f, 0.16195500f, 0.03508473f, 0.25086671f, -0.26421326f, 0.11583058f, -0.15137400f, 
    -0.04032741f, 0.01411185f, 0.19090550f, 0.01354839f, -0.10941398f, -0.08245879f, -0.06555168f, -0.03339865f, 
    -0.00809972f, 0.03067235f, 0.10916954f, 0.11522957f, -0.11966421f, -0.07925612f, -0.05805504f, 0.13445146f, 
    0.10628597f, 0.13100393f, -0.31030980f, -0.24200960f, 0.14846039f, -0.23610602f, -0.38335389f, -0.02985609f, 
    -0.08095138f, -0.11117713f, -0.09981872f, 0.11402392f, -0.06500883f, 0.11716108f, 0.13037999f, 0.03885742f, 
    -0.02755035f, 0.09027756f, -0.09062115f, -0.12857826f, -0.07849361f, 0.12885076f, 0.06316171f, -0.14858499f, 
    -0.15276015f, -0.01378324f, -0.18722858f, 0.03730007f, -0.11428688f, 0.13185710f, -0.19329995f, 0.16880222f, 
    0.23404418f, -0.08521003f, -0.01064728f, 0.05838729f, 0.08011846f, 0.12298569f, 0.04866210f, 0.02277424f, 
    -0.06532293f, 0.10069251f, 0.04366326f, 0.16481623f, 0.10230879f, -0.16538416f, -0.06452059f, 0.08095774f, 
    0.19447458f, 0.01887641f, 0.16299286f, -0.03251280f, 0.01436004f, 0.12897377f, 0.00630294f, -0.07290661f, 
    0.08588485f, 0.08253069f, -0.03530014f, 0.02921410f, 0.01518540f, 0.01116859f, -0.07914577f, 0.08896246f, 
    0.03303415f, -0.01599768f, -0.01384100f, 0.04119755f, -0.44290811f, -0.24720746f, 0.01614840f, -0.13381924f, 
    0.10320670f, -0.08801518f, -0.04103085f, 0.01776585f, -0.01041399f, 0.18990849f, 0.15579902f, -0.10988344f, 
    -0.06267259f, 0.12442720f, 0.14216051f, -0.03938761f, -0.04466909f, 0.08686339f, 0.06113390f, -0.09509820f, 
    -0.16356461f, -0.01565979f, -0.01251094f, 0.28263542f, 0.00554834f, -0.00455524f, -0.05283706f, 0.05247802f, 
    0.01126102f, -0.02279173f, -0.00798151f, -0.01850650f, 0.23664041f, 0.06227320f, 0.08897573f, 0.00305682f, 
    -0.11904839f, -0.05163949f, -0.10786185f, -0.09660161f, 0.04708148f, -0.11565072f, 0.02997387f, -0.16005316f, 
    0.16092423f, 0.09414114f, 0.04797886f, 0.09104203f, 0.07293869f, 0.09006216f, 0.00897473f, -0.03296702f, 
    -0.16237086f, 0.08999165f, -0.12605718f, 0.00756635f, 0.28189427f, 0.12927920f, -0.06498593f, -0.05713844f, 
    -0.15924217f, 0.12795730f, 0.01274903f, 0.20978844f, 0.04563843f, -0.06747524f, 0.00179012f, -0.30285197f, 
    -0.02330168f, 0.12839362f, -0.12676366f, 0.06287552f, -0.47275025f, -0.19429789f, -0.09861910f, -0.29499799f, 
    0.11213757f, -0.07466069f, -0.03844121f, 0.01302330f, -0.02342265f, 0.00016792f, -0.05994362f, 0.05442568f, 
    -0.01146284f, 0.00207334f, 0.24989671f, -0.03032841f, 0.05621384f, -0.08074593f, -0.35753578f, -0.08582169f, 
    -0.02237506f, 0.07644133f, -0.11390842f, 0.08636645f, -0.07413202f, -0.02136751f, -0.01993937f, -0.17380823f, 
    0.14020079f, -0.02245496f, -0.02538124f, -0.16735482f, -0.04008304f, -0.01530045f, 0.19931571f, 0.08132380f, 
    -0.44350046f, -0.00272478f, 0.05041648f, 0.07061559f, 0.00978559f, -0.05239833f, 0.08470996f, 0.06703833f, 
    -0.06842815f, -0.03808746f, -0.07863347f, -0.07825410f, -0.06194213f, -0.01304035f, -0.00812389f, -0.00266274f, 
    -0.00719800f, -0.06040690f, 0.04508401f, 0.30256921f, 0.04055762f, -0.16491282f, -0.19598512f, 0.17281753f, 
    0.12792334f, 0.14593023f, -0.03776072f, 0.08690681f, -0.37156463f, -0.26085547f, 0.12500119f, 0.16252941f, 
    0.02306025f, 0.17766023f, -0.24848279f, 0.10401435f, 0.21326174f, 0.01206707f, 0.04955409f, 0.14288606f, 
    0.07926353f, -0.06897461f, 0.00054794f, -0.03299665f, 0.05475364f, 0.10844485f, 0.11654560f, -0.04911215f, 
    -0.08934516f, -0.36185852f, -0.21680951f, 0.09672658f, -0.13520846f, -0.08789019f, -0.32766744f, 0.10936941f, 
    -0.22157651f, -0.03799678f, 0.03315219f, -0.06352704f, 0.06387839f, -0.17849289f, -0.06731346f, 0.29057738f, 
    -0.09877631f, -0.03089659f, 0.10024581f, 0.03359697f, -0.02180270f, 0.03230326f, 0.00092138f, 0.05575388f, 
    0.20052037f, 0.10119906f, 0.00186536f, 0.14831813f, -0.06567395f, -0.04570497f, -0.02561156f, -0.07797407f, 
    0.01911505f, -0.02174808f, -0.35822657f, -0.19932920f, -0.16376410f, 0.03541791f, 0.08979335f, 0.11998439f, 
    -0.05862553f, -0.14457233f, 0.07022999f, -0.08124045f, -0.07125673f, 0.14594990f, 0.02858600f, 0.03902887f, 
    -0.10844571f, -0.05037643f, 0.03233815f, 0.03017488f, 0.15567821f, 0.04626778f, 0.10181969f, -0.23374684f, 
    0.01131499f, -0.06093613f, -0.02624013f, 0.11190164f, 0.08680879f, -0.38070965f, -0.43789738f, -0.16250636f, 
    0.06966259f, 0.07071412f, 0.08487513f, 0.03007922f, 0.05393435f, -0.28494343f, -0.08463112f, 0.16840188f, 
    0.03148893f, 0.03459695f, 0.00081368f, 0.01063007f, 0.16620050f, 0.03072892f, 0.17537899f, 0.09768882f, 
    0.18356955f, 0.18823931f, 0.05951898f, 0.05830000f, 0.20784186f, 0.02586470f, 0.00835774f, -0.40652514f, 
    -0.21116416f, -0.17187080f, -0.05487501f, 0.08754043f, -0.23891701f, -0.13504231f, -0.05230225f, -0.00353389f, 
    -0.20653418f, 0.09998794f, -0.12149924f, 0.09777217f, -0.07233217f, 0.05231105f, 0.04380892f, 0.07365084f, 
    -0.03667985f, -0.14450032f, -0.27749822f, 0.43417904f, 0.28451651f, 0.04457392f, 0.24149899f, 0.03217532f, 
    0.12436280f, 0.04363715f, 0.05603496f, 0.17701085f, -0.04879246f, 0.05274605f, 0.08205428f, 0.05489595f, 
    0.10296401f, 0.00227274f, 0.02507835f, -0.01409372f, 0.32220113f, -0.20839527f, 0.00298510f, 0.08685057f, 
    0.13298285f, 0.08318685f, 0.11830303f, 0.04659462f, -0.12379284f, 0.21715233f, 0.23269200f, -0.03844616f, 
    0.06485774f, -0.19715984f, 0.17087312f, 0.06340541f, 0.03393921f, -0.26578388f, 0.12278064f, -0.19484042f, 
    0.03952096f, -0.03547446f, 0.10378142f, 0.16382906f, 0.02331671f, 0.04353284f, 0.18973042f, -0.01815288f, 
    -0.18603112f, -0.00932500f, 0.06304609f, 0.09250109f, 0.18497021f, 0.00299504f, 0.05846110f, -0.27339962f, 
    -0.27239779f, 0.28785062f, 0.20068108f, -0.06154727f, -0.20471987f, 0.00422589f, -0.08983736f, -0.05661457f, 
    -0.04562812f, 0.20935400f, 0.24604274f, -0.21918198f, -0.14488363f, -0.11985594f, 0.02590360f, -0.01786184f, 
    -0.06002177f, 0.19915423f, 0.00486254f, -0.14592788f, 0.06566104f, -0.02857913f, -0.13279088f, 0.12744567f, 
    0.05980374f, -0.01857849f, 0.03337582f, -0.41139549f, 0.38646021f, -0.07213155f, -0.17117156f, 0.02154050f, 
    -0.06862818f, 0.16716307f, -0.01684659f, -0.28837991f, -0.08636513f, -0.01299326f, 0.07258447f, 0.08292318f, 
    -0.09125002f, 0.01778658f, -0.01410102f, 0.09724031f, -0.17809948f, 0.37492028f, -0.01194273f, 0.08079841f, 
    -0.17139028f, 0.06776183f, 0.07887423f, 0.09011361f, 0.03292768f, -0.15158971f, -0.01243491f, -0.17016985f, 
    -0.03335537f, -0.08022628f, 0.02246462f, -0.00822143f, 0.15815294f, 0.01468941f, -0.27465343f, -0.01932676f, 
    0.20673309f, -0.10441722f, 0.03655207f, -0.07791062f, 0.05939206f, -0.19214058f, -0.07822604f, -0.69450957f, 
    0.13527761f, -0.15021692f, 0.09037122f, 0.03772609f, -0.13271481f, -0.03908104f, -0.09115039f, 0.16360241f, 
    0.04019911f, -0.03389459f, 0.08774409f, 0.03068702f, 0.13999216f, -0.05325264f, -0.08529259f, 0.07830839f, 
    -0.02048917f, 0.11588404f, -0.07487601f, 0.30538699f, 0.03877410f, 0.05838663f, -0.02269655f, -0.18811524f, 
    -0.07148523f, -0.00952446f, -0.23549634f, 0.08924402f, 0.14432001f, 0.07926137f, -0.35944766f, -0.07573375f, 
    -0.02927577f, -0.09566859f, 0.08511730f, 0.32400340f, 0.47166559f, 0.00428175f, 0.00339377f, 0.09334828f, 
    0.21263409f, -0.02602215f, 0.02884683f, -0.04796663f, -0.31618029f, 0.43711480f, -0.18613407f, -0.14089985f, 
    -0.30354810f, -0.03807891f, -0.19156201f, -0.17978765f, -0.10249293f, -0.02983542f, -0.25678828f, -0.18480635f, 
    -0.12384094f, 0.00833958f, 0.12115655f, 0.16709037f, -0.05976048f, -0.04490878f, 0.08005433f, 0.04821436f, 
    0.18946365f, -0.00377777f, -0.08032866f, -0.05950425f, 0.07862400f, -0.05169225f, -0.05732155f, 0.17729765f, 
    -0.66518140f, 0.12544531f, -0.04013738f, 0.06308581f, -0.01575936f, -0.06117906f, 0.10347784f, -0.09215266f, 
    -0.02579838f, -0.03634620f, -0.12918855f, -0.08013831f, -0.17522469f, -0.16906069f, 0.04193665f, 0.05999134f, 
    0.01436157f, -0.06360986f, -0.01206637f, -0.01210486f, -0.03898536f, -0.05531204f, 0.02519650f, 0.15609646f, 
    0.03073386f, -0.06373680f, 0.10495310f, 0.21837234f, 0.16624787f, -0.00035327f, -0.04174722f, 0.01694199f, 
    0.10236440f, 0.18730436f, -0.01455676f, -0.06032425f, -0.09089001f, 0.00125645f, -0.12466764f, 0.04645201f, 
    -0.11855985f, 0.01788712f, -0.17393868f, 0.08975231f, -0.32303670f, -0.32833767f, -0.35052758f, 0.02085837f, 
    0.01515322f, -0.03888627f, -0.07463407f, 0.09761320f, 0.14332829f, -0.24210607f, -0.20791912f, -0.03250983f, 
    -0.06946154f, 0.03296908f, -0.33414596f, 0.09535495f, -0.02802461f, 0.03518774f, 0.14642005f, -0.12474684f, 
    0.00249236f, 0.21065453f, 0.01348823f, -0.02695634f, -0.01573115f, 0.07421057f, -0.00007631f, -0.19183542f, 
    -0.07406937f, -0.16778642f, -0.15205435f, 0.07969916f, -0.04573047f, -0.05085909f, 0.13348570f, 0.14093764f, 
    0.04289723f, -0.03054457f, 0.01401210f, -0.01697356f, 0.04322774f, -0.03969218f, -0.03319417f, 0.02633696f, 
    -0.03911487f, -0.03710851f, 0.03007352f, 0.03649443f, -0.00252980f, -0.04059453f, -0.00701134f, 0.02890537f, 
    0.02661659f, -0.04379588f, -0.01295440f, 0.01517515f, -0.02369245f, -0.04065043f, -0.00270980f, -0.02137274f, 
    -0.05674848f, -0.02169834f, 0.03840234f, -0.03249819f, -0.05459006f, -0.01457114f, -0.01712520f, 0.01797272f, 
    -0.06063675f, -0.05197673f, -0.02335789f, -0.03647528f, -0.02626377f, -0.07668220f, -0.04597396f, -0.02117298f, 
    0.00985591f, 0.03459227f, 0.02318801f, -0.03384229f, 0.00750861f, -0.06863280f, 0.03581698f, -0.03553045f, 
    -0.02850056f, 0.03213567f, 0.03921010f, -0.07704902f, 0.04059480f, -0.04937815f, -0.01723810f, -0.02803406f, 
    -0.02640109f, -0.00949379f, -0.02919017f, 0.00523694f, -0.05642488f, -0.06841434f, -0.01886068f, 0.02106286f, 
    0.03927285f, 0.01538296f, -0.04065570f, -0.05353867f, -0.04372342f, -0.02752950f, 0.01488082f, -0.00764850f, 
    -0.08713163f, 0.03594571f, -0.01351465f, -0.03168853f, 0.02976536f, -0.01546317f, -0.04699086f, 0.01532783f, 
    -0.01963138f, -0.03277899f, -0.03266007f, -0.03461763f, 0.01327602f, 0.01595365f, -0.01985172f, 0.03670041f, 
    0.00935907f, -0.03344851f, -0.01456165f, -0.00498856f, -0.02855441f, -0.02030172f, 0.01834143f, 0.00939411f, 
    0.04753414f, -0.05930294f, -0.05598341f, -0.04821173f, -0.04852394f, 0.05215865f, 0.00981589f, -0.04610156f, 
    -0.03015181f, -0.05344125f, -0.02057919f, -0.03200013f, -0.00619325f, -0.06565618f, 0.01051347f, -0.04234591f, 
    0.02027615f, -0.06716111f, 0.03429913f, 0.02245045f, 0.00248054f, -0.05648761f, 0.03626363f, 0.03975893f, 
    0.00580006f, -0.01144151f, -0.06769285f, 0.02396619f, -0.01798169f, 0.02142365f, -0.07701461f, -0.07094358f, 
    -0.00521733f, -0.04645360f, -0.05810044f, -0.02454596f, -0.02756885f, 0.02461851f, -0.03198141f, 0.01436404f, 
    0.01423665f, -0.00748441f, 0.00700072f, 0.05318650f, -0.01179681f, -0.02868343f, -0.04743090f, -0.02816156f, 
    -0.02448799f, 0.03844386f, -0.02637265f, -0.00837074f, 0.03442318f, -0.00494077f, -0.06821677f, 0.01948797f, 
    -0.00043397f, 0.03367109f, -0.04241184f, 0.01672993f, 0.03930413f, 0.06037263f, -0.05686128f, -0.02676024f, 
    0.04677138f, -0.01125792f, 0.04609984f, 0.05698265f, -0.06576750f, -0.01567206f, 0.03058889f, -0.04643808f, 
    0.02747673f, -0.00491264f, -0.08143427f, 0.02176892f, -0.04048152f, -0.01871780f, -0.01525722f, 0.01125870f, 
    -0.04938415f, -0.05050820f, -0.01192065f, 0.02486191f, -0.01426706f, 0.02984529f, -0.01164616f, 0.01550742f, 
    -0.04398630f, 0.02170282f, -0.04067123f, -0.06628076f, -0.01544547f, -0.04363338f, -0.02313997f, 0.01464959f, 
    -0.00258622f, -0.03102821f, -0.02503907f, -0.01756544f, 0.01231701f, -0.01004986f, -0.01673320f, -0.03625380f, 
    -0.06488971f, -0.06092133f, 0.02268542f, -0.02810841f, -0.05376146f, 0.01409369f, -0.06068815f, 0.03972735f, 
    0.00449704f, -0.05204371f, 0.03378168f, 0.03095041f, -0.03102752f, 0.02163288f, 0.02226754f, 0.02793632f, 
    -0.03075946f, -0.03528555f, 0.01682788f, 0.04354434f, -0.01224303f, -0.03342387f, -0.07255356f, -0.02819070f, 
    0.03795874f, -0.06424820f, -0.01294879f, -0.01354879f, -0.03547336f, 0.03131026f, -0.02579738f, -0.01728213f, 
    -0.02815335f, -0.02775065f, -0.05222620f, -0.03239148f, -0.03015004f, 0.01356596f, -0.05832421f, -0.02837404f, 
    0.02155041f, 0.00510472f, -0.02453282f, -0.03774537f, 0.03109262f, 0.01012381f, -0.00719737f, 0.04198633f, 
    -0.03314435f, -0.03029995f, 0.01910567f, -0.03045398f, -0.07386297f, 0.02042180f, -0.01621338f, 0.01614926f, 
    0.01928473f, -0.01028613f, -0.01181722f, 0.00315459f, -0.03427185f, -0.09794955f, -0.05504809f, -0.01469657f, 
    -0.04598329f, -0.06993326f, -0.03262998f, -0.07765509f, -0.02948395f, -0.02020708f, -0.02932202f, -0.04628540f, 
    -0.05060055f, -0.02270585f, -0.05461904f, -0.04534149f, -0.02542185f, 0.00769817f, -0.06227527f, -0.04358532f, 
    -0.05174798f, 0.01154745f, -0.05048499f, -0.00951202f, 0.04048930f, -0.05860811f, -0.04387390f, -0.02572421f, 
    -0.10957602f, -0.04508565f, -0.16808397f, -0.15599930f, 0.02487786f, -0.11509655f, 0.00549845f, 0.01937503f, 
    -0.03485819f, -0.25414509f, 0.17388132f, -0.28207776f, 0.09175358f, 0.00233209f, -0.09138140f, 0.01178875f, 
    -0.05016073f, -0.17185946f, -0.00114439f, 0.00437586f, 0.09255821f, 0.08934705f, 0.13517167f, -0.08797617f, 
    0.03655970f, 0.05380695f, 0.03232084f, 0.21405214f, 0.02767789f, -0.06144129f, -0.03128903f, -0.02780776f, 
    -0.05615640f, -0.01591151f, -0.02362660f, 0.01895481f, 0.01427271f, 0.17195529f, -0.01126830f, -0.17018300f, 
    0.00972819f, -0.06464770f, -0.01024950f, -0.09171156f, 0.00082483f, 0.28876922f, -0.06056106f, -0.24891029f, 
    -0.01917203f, -0.06008151f, -0.01734096f, 0.11186533f, -0.02746515f, -0.01919103f, 0.03481806f, -0.08368637f, 
    -0.15451501f, -0.13872865f, 0.04616223f, -0.11177642f, 0.07636545f, -0.01141575f, -0.00348806f, -0.15278575f, 
    0.08734796f, -0.10666894f, 0.08573525f, -0.00271071f, -0.07197502f, 0.00965403f, 0.08157896f, 0.10910966f, 
    0.26731202f, -0.02172322f, 0.05040501f, -0.14466463f, -0.15383251f, 0.01213191f, 0.05064536f, -0.03897597f, 
    -0.03020995f, -0.13199791f, -0.04322074f, -0.01788257f, 0.03045168f, 0.05599738f, -0.00484884f, 0.12392730f, 
    -0.16790421f, -0.12779944f, 0.06639551f, 0.23183042f, -0.03244843f, 0.07306474f, -0.08565722f, -0.09743563f, 
    0.00587102f, -0.01093105f, 0.11282519f, 0.01150969f, 0.16708887f, -0.14956205f, 0.04515652f, -0.20859230f, 
    -0.07247829f, 0.02890926f, 0.08876182f, 0.08196301f, 0.02070414f, -0.14476347f, 0.17089958f, -0.13036199f, 
    0.02964120f, -0.18120769f, -0.09428517f, 0.03371092f, -0.00961446f, 0.17464660f, -0.07524160f, 0.30191028f, 
    -0.00232426f, 0.11721554f, -0.11163688f, 0.03492114f, 0.04247995f, -0.07402830f, -0.00110960f, 0.21370433f, 
    -0.29986262f, -0.06112719f, 0.00459258f, 0.01195921f, -0.08057237f, 0.04088714f, -0.03462889f, 0.26561883f, 
    -0.04527054f, 0.38451579f, -0.01779753f, -0.09047687f, -0.05098264f, 0.07274821f, -0.08035967f, 0.05867616f, 
    0.14828400f, 0.24636661f, -0.03312076f, 0.02999240f, -0.24779579f, -0.00155042f, -0.02330307f, 0.03172931f, 
    0.11135160f, -0.05997488f, 0.04685703f, 0.10522001f, -0.15580672f, -0.16632923f, 0.06506946f, 0.04791448f, 
    0.06657871f, -0.04290684f, 0.11046344f, 0.10024309f, 0.19952275f, -0.04247352f, -0.16519806f, -0.20034358f, 
    0.06449407f, -0.12994187f, -0.01097129f, -0.07078715f, -0.19230281f, 0.25240645f, 0.10939154f, 0.11521901f, 
    -0.06096040f, 0.01689152f, 0.13313632f, 0.02664989f, 0.12331351f, -0.12021042f, -0.00731119f, 0.04471597f, 
    -0.01697676f, 0.04847717f, 0.01883383f, 0.00136731f, 0.04055047f, 0.13818139f, 0.20048386f, 0.18699001f, 
    -0.20321745f, -0.33080894f, -0.23573065f, 0.06935416f, -0.02580181f, 0.05047858f, 0.23991972f, 0.29405242f, 
    -0.06161456f, -0.12557624f, -0.12018653f, 0.00620492f, 0.09297941f, 0.00355640f, -0.00019232f, -0.46541986f, 
    0.07154452f, -0.02124212f, 0.02032855f, 0.03580613f, 0.04785411f, 0.00993324f, 0.13315140f, -0.06119703f, 
    0.10964813f, 0.10085156f, 0.18632014f, 0.17409143f, 0.00795518f, 0.06943016f, 0.07754229f, 0.08213608f, 
    0.13390312f, 0.23514825f, 0.21254672f, 0.09559897f, -0.04925929f, 0.02653872f, 0.00101806f, -0.05114684f, 
    -0.00250005f, 0.13585533f, -0.15080974f, -0.03936514f, 0.14012103f, 0.07546011f, 0.04884293f, -0.02408865f, 
    0.09873422f, -0.08665583f, -0.02919129f, -0.01098616f, 0.11476631f, 0.18991192f, 0.05287027f, -0.12649877f, 
    0.05639141f, 0.03399027f, -0.13387109f, -0.07463388f, 0.37854326f, -0.02055365f, -0.02738858f, -0.14390394f, 
    -0.23463705f, -0.02154095f, -0.00035411f, 0.01993229f, 0.01769666f, 0.19536583f, 0.18504962f, 0.30059004f, 
    -0.24899660f, 0.14048080f, -0.10918741f, 0.01802363f, 0.09423146f, -0.06032415f, 0.00062015f, 0.01533155f, 
    -0.16912435f, 0.01588639f, 0.07652209f, 0.04137990f, 0.10577834f, -0.02184337f, -0.05674099f, -0.17259522f, 
    0.07903624f, 0.06437174f, -0.10465042f, -0.03232212f, -0.16046931f, 0.06254402f, 0.16655552f, -0.06851178f, 
    -0.11136302f, 0.06672836f, -0.08412046f, 0.07392649f, -0.03464269f, -0.06226017f, -0.14436737f, 0.01371908f, 
    -0.28627899f, -0.24185111f, 0.07171177f, 0.04961620f, -0.04711528f, 0.04470190f, 0.25871813f, 0.16277784f, 
    0.03840465f, 0.18792763f, 0.06038377f, 0.08316404f, 0.01434113f, 0.01897541f, 0.10545643f, 0.07594693f, 
    -0.10416805f, -0.11983979f, -0.02538182f, -0.05512692f, 0.24510325f, -0.02882476f, 0.08792238f, 0.05969709f, 
    -0.11217912f, -0.00833425f, -0.06686082f, -0.08981661f, 0.29975024f, 0.02469995f, 0.28079239f, 0.17450482f, 
    0.01237722f, 0.02185169f, 0.11873709f, 0.10902781f, 0.16225730f, 0.12643874f, 0.18044978f, -0.05266772f, 
    0.07509395f, -0.01540591f, -0.04632610f, -0.02949250f, -0.03837792f, -0.09107634f, -0.08132585f, 0.27726895f, 
    -0.04261218f, -0.02977286f, 0.13692734f, 0.01883602f, 0.11131915f, 0.06871676f, -0.04070722f, 0.07228685f, 
    0.40485963f, -0.17726611f, 0.22572048f, -0.11215839f, 0.12820551f, 0.16179526f, -0.02936720f, 0.12971249f, 
    0.02823223f, 0.02095913f, 0.30127716f, 0.28928521f, -0.07931745f, -0.03864208f, -0.19158781f, -0.09562212f, 
    -0.21885607f, 0.23745833f, 0.20439738f, 0.23851798f, -0.00124717f, -0.08375124f, 0.06094320f, 0.02579443f, 
    0.12294969f, -0.01750026f, -0.12396204f, 0.11702358f, 0.19054429f, 0.13854806f, 0.07616017f, 0.23072194f, 
    0.06672186f, -0.09131400f, 0.21728043f, -0.01073047f, -0.04048583f, -0.07498890f, 0.00413596f, 0.03039788f, 
    0.09380652f, -0.19018494f, -0.14904299f, -0.17786659f, 0.05783837f, 0.04176889f, 0.00784303f, 0.10965826f, 
    0.04110599f, 0.17059591f, 0.10530246f, 0.05770407f, -0.05622236f, -0.08411008f, 0.00845996f, -0.33133531f, 
    0.07197832f, 0.05327781f, -0.08362066f, -0.11690113f, 0.01542242f, -0.14307626f, 0.04518717f, 0.02714119f, 
    0.12595461f, 0.04629824f, -0.10527591f, 0.13468564f, 0.19562127f, 0.12178570f, 0.31258854f, 0.07839929f, 
    -0.12656328f, -0.04789589f, -0.10141982f, 0.00520342f, 0.07265246f, -0.03042095f, 0.14394799f, -0.07485060f, 
    0.10748772f, -0.11927131f, 0.18705656f, 0.19049366f, 0.05480716f, 0.25056663f, 0.06667612f, 0.05667203f, 
    0.04150773f, -0.01668009f, 0.08417874f, 0.39993700f, 0.06824368f, 0.05568288f, 0.08253096f, -0.00149466f, 
    0.00801699f, 0.08574558f, 0.18144360f, -0.01745697f, -0.01533080f, 0.00104471f, 0.15330341f, 0.02479924f, 
    -0.00795872f, -0.01443591f, -0.00603548f, 0.14896706f, 0.29802153f, -0.24208646f, 0.00983425f, -0.23733194f, 
    -0.07497112f, 0.01941045f, -0.02517238f, 0.01439002f, 0.07179856f, 0.05912253f, -0.05968007f, 0.03466694f, 
    0.06126773f, -0.04516665f, -0.04328010f, 0.23405004f, -0.06034956f, -0.15002593f, -0.16393508f, -0.11315101f, 
    0.09221442f, 0.03474114f, -0.10998425f, -0.17122154f, -0.31892776f, -0.10697283f, 0.08700328f, 0.04504543f, 
    0.29728773f, 0.13327305f, 0.03779221f, 0.07204904f, -0.01003320f, 0.02393839f, -0.11081409f, 0.16163550f, 
    0.00732538f, 0.03530776f, 0.24744861f, -0.31806573f, -0.06927580f, -0.00516247f, -0.09646881f, -0.12707408f, 
    0.10585907f, 0.04367077f, -0.09618241f, -0.04085077f, -0.04921056f, 0.01597958f, -0.11282987f, -0.19545089f, 
    -0.18246104f, -0.05482465f, -0.13211645f, 0.14675957f, 0.06329380f, 0.10426856f, 0.08167457f, 0.08647709f, 
    -0.03974797f, 0.09110427f, 0.09049237f, 0.26439622f, -0.03883777f, 0.03247495f, 0.12160822f, 0.01242670f, 
    0.14334881f, 0.04728325f, 0.08744732f, 0.03082778f, -0.00325473f, -0.14873914f, 0.14910716f, 0.07144836f, 
    0.12535511f, 0.17001384f, 0.06121769f, 0.20584072f, -0.41157103f, -0.38467947f, 0.21198192f, 0.08703376f, 
    0.09606237f, 0.07460678f, 0.02802846f, 0.04911664f, 0.17770115f, 0.20489445f, -0.00747711f, 0.09995183f, 
    0.22993456f, -0.15374346f, 0.08073287f, -0.18730623f, -0.20524932f, -0.53134149f, 0.08069599f, 0.29037783f, 
    0.09297732f, 0.00935122f, -0.21982095f, 0.07068934f, 0.06264080f, -0.20651110f, -0.00255299f, 0.36809999f, 
    0.18212582f, 0.08256048f, 0.00803461f, 0.10634018f, 0.01805065f, 0.04622978f, -0.05415441f, 0.30991840f, 
    0.04082873f, 0.00224298f, -0.00852897f, 0.01484377f, -0.00390086f, -0.02904159f, -0.01941232f, -0.00167387f, 
    0.01609243f, 0.05243310f, -0.01169287f, -0.00927971f, 0.04618155f, 0.05344855f, -0.06599333f, 0.03473232f, 
    0.04112124f, -0.04539644f, 0.02798364f, 0.04002124f, 0.00543039f, -0.04780137f, 0.00781340f, 0.01069003f, 
    -0.04641365f, -0.01848017f, -0.02160292f, 0.00682381f, 0.00422725f, 0.01520320f, 0.00257211f, 0.03274446f, 
    0.02737089f, -0.02383976f, 0.01345619f, 0.03063299f, -0.05378590f, -0.06792805f, 0.00835616f, -0.06540748f, 
    0.00932463f, -0.00171628f, -0.05092394f, -0.00166972f, -0.00977011f, 0.03192418f, 0.03272571f, -0.05067976f, 
    -0.04237602f, 0.02329566f, -0.04573002f, -0.02133369f, -0.00358825f, 0.04006762f, -0.00805438f, -0.00958579f, 
    0.04029305f, 0.05238491f, 0.00951077f, -0.05308443f, -0.00264485f, 0.02526369f, -0.06297382f, 0.00749722f, 
    0.02005476f, 0.03645092f, -0.01658586f, -0.06239837f, -0.03479385f, -0.04083591f, -0.03734295f, -0.02406821f, 
    0.01751840f, -0.06935266f, 0.02515423f, -0.04611465f, 0.00649835f, -0.00405384f, 0.01934782f, 0.01395495f, 
    -0.05311116f, -0.04328386f, 0.00360508f, -0.00931582f, -0.00224330f, 0.03460307f, -0.01490694f, 0.04734646f, 
    0.04223723f, -0.02176378f, 0.03150475f, -0.00044169f, 0.05106522f, -0.07464241f, 0.04933131f, -0.06584857f, 
    -0.00315946f, 0.01804143f, 0.00052318f, -0.01336817f, -0.06177509f, -0.03182514f, -0.04622934f, -0.04051410f, 
    -0.05623645f, 0.00750115f, -0.06124278f, 0.02926092f, 0.03421259f, 0.02764645f, -0.05357938f, 0.00301307f, 
    0.02169258f, -0.00714770f, -0.01141879f, 0.01999191f, -0.05621801f, 0.01400627f, 0.02660813f, 0.00595995f, 
    -0.00154607f, -0.04461512f, -0.05592841f, 0.05432082f, -0.04031451f, 0.03619898f, 0.03782508f, -0.01973400f, 
    -0.04883986f, -0.00701042f, 0.01941963f, -0.00389825f, 0.05012019f, 0.03813985f, -0.03640469f, -0.01585225f, 
    0.03635979f, -0.01459428f, -0.06594737f, 0.03961975f, 0.00671803f, 0.04363638f, -0.02745977f, -0.04243037f, 
    -0.04695726f, -0.02218869f, 0.00768831f, -0.06306988f, 0.04516612f, 0.02588656f, 0.03147399f, -0.02694091f, 
    -0.05583987f, -0.03217612f, -0.01097995f, -0.02947893f, 0.03982042f, -0.06540664f, -0.02629736f, -0.00806443f, 
    -0.00645603f, 0.02671253f, -0.05484892f, -0.06172203f, 0.02491087f, 0.05206535f, -0.01254901f, -0.03942800f, 
    0.04883544f, 0.02557461f, -0.01266090f, -0.07051497f, 0.02148530f, -0.01769803f, -0.01857849f, -0.05077261f, 
    -0.03172937f, -0.00136087f, 0.00942115f, -0.03153595f, -0.02282240f, -0.04902530f, -0.03426212f, -0.05592239f, 
    0.03098368f, -0.00992531f, 0.04391838f, 0.00074757f, 0.00517566f, -0.00966812f, 0.01194183f, -0.07358009f, 
    0.02785090f, 0.05447828f, -0.03448815f, -0.02358686f, -0.03009987f, -0.06203553f, -0.01333489f, -0.05122834f, 
    0.05334391f, 0.00710191f, 0.01865282f, -0.05804188f, 0.02701920f, -0.06193006f, 0.03098597f, 0.01233364f, 
    0.00650570f, 0.03887719f, 0.03841450f, -0.03094481f, -0.00528961f, -0.04358847f, -0.01170107f, -0.05230442f, 
    -0.01186526f, 0.04123883f, 0.02621622f, -0.04241214f, -0.06027862f, 0.01789940f, 0.01412919f, -0.04403495f, 
    -0.03439556f, -0.06308310f, 0.02481940f, 0.00123349f, -0.03989878f, 0.00817656f, 0.01609205f, -0.05187253f, 
    0.02958061f, 0.05334422f, -0.06276045f, -0.05532406f, 0.01101885f, 0.00608441f, -0.02111419f, 0.03243140f, 
    -0.01037940f, -0.06074434f, 0.01219849f, 0.03481089f, -0.03779734f, 0.01889150f, 0.01596385f, -0.01174245f, 
    -0.01411028f, -0.00950049f, -0.01837036f, -0.04694704f, -0.03656089f, -0.01874949f, -0.04474173f, 0.05317369f, 
    0.03351963f, -0.04935152f, 0.00237812f, 0.00038840f, 0.00105540f, 0.01651384f, 0.02779444f, 0.00300102f, 
    -0.05082957f, -0.02650466f, -0.02379281f, -0.02335585f, -0.06847807f, -0.01457641f, -0.00084286f, 0.00030282f, 
    -0.00035210f, 0.03064552f, -0.01093393f, -0.06677227f, -0.05183514f, 0.02644803f, -0.05896409f, 0.00248452f, 
    -0.01159888f, -0.04841937f, 0.03694390f, -0.01491646f, -0.04485046f, -0.01833340f, -0.06003104f, 0.03929484f, 
    0.03672259f, -0.03656638f, -0.01018059f, -0.03201095f, -0.04664370f, 0.04612922f, -0.04096831f, 0.01110992f, 
    0.02332935f, 0.01369859f, 0.03284434f, -0.04152826f, -0.02562287f, -0.00305554f, 0.01482422f, -0.05305000f, 
    -0.06786099f, 0.00878028f, -0.01358863f, -0.00656396f, -0.04236830f, 0.02787886f, -0.00946151f, -0.06225748f, 
    0.02991090f, -0.03400537f, -0.02822682f, -0.02925597f, -0.01808991f, -0.00497698f, -0.06025416f, -0.06085563f, 
    -0.02363635f, -0.05353211f, 0.04544184f, 0.01144248f, -0.03064101f, -0.03841966f, -0.02726053f, 0.02539846f, 
    0.00201051f, 0.02120211f, -0.01154056f, -0.06253444f, -0.05374527f, -0.03505015f, 0.00290987f, -0.02338160f, 
    -0.05684156f, -0.01389107f, -0.00727567f, -0.06103534f, -0.04393824f, -0.00966367f, 0.02430482f, 0.04635121f, 
    0.00366505f, 0.02673570f, 0.05228502f, -0.05865435f, 0.00537509f, 0.01619110f, -0.05817953f, -0.03344497f, 
    0.00274670f, 0.03213837f, -0.04128208f, 0.00596403f, -0.04976928f, -0.04675366f, 0.02646998f, -0.02652697f, 
    -0.00525667f, -0.05874080f, 0.06307133f, 0.01874855f, -0.03025789f, -0.05963975f, -0.01057818f, -0.03439448f, 
    0.00601836f, 0.00745396f, -0.02437337f, 0.04760744f, -0.03462439f, 0.03637573f, 0.02084574f, 0.01441381f, 
    -0.03465313f, -0.01155815f, -0.02209809f, -0.02737742f, 0.02667198f, -0.02456409f, 0.00191250f, -0.02793511f, 
    -0.02065192f, 0.03216301f, -0.02551368f, -0.05397932f, -0.05317732f, 0.02472497f, -0.01203211f, -0.03473334f, 
    0.04159961f, 0.01097466f, -0.04479581f, -0.02264943f, -0.01219755f, 0.04612886f, -0.04118527f, -0.03933340f, 
    -0.02368754f, -0.03926659f, -0.00119121f, -0.01640491f, 0.02914553f, -0.01095846f, 0.03782953f, 0.02404820f, 
    -0.00195088f, 0.03302357f, -0.01521568f, -0.03219702f, 0.03091580f, 0.05045213f, 0.00466144f, -0.03697461f, 
    0.04747648f, -0.05020217f, 0.02794455f, 0.01430358f, 0.01373256f, -0.05787798f, -0.03841972f, -0.00241462f, 
    0.03570327f, 0.04383356f, -0.00261520f, 0.01750549f, -0.00813058f, -0.00826032f, -0.02883300f, -0.02517051f, 
    -0.02600829f, 0.00574280f, 0.04877265f, -0.06367706f, -0.03809756f, -0.04386842f, -0.02703928f, -0.02527304f, 
    -0.04444008f, 0.04595122f, -0.04641720f, -0.00250071f, -0.00873030f, -0.05895463f, 0.02856982f, 0.03518143f, 
    0.03809229f, 0.02086353f, -0.00651237f, -0.00382353f, 0.03203773f, -0.02034032f, -0.03956365f, -0.01837804f, 
    -0.03812328f, 0.02158889f, -0.06745036f, 0.04968694f, 0.00791022f, -0.05329036f, -0.04620155f, 0.04241582f, 
    -0.05488149f, -0.01202440f, 0.04974541f, -0.05426360f, -0.03715071f, -0.02634199f, -0.03770950f, 0.02138678f, 
    0.01266486f, 0.02702747f, 0.03548279f, -0.01477110f, -0.04075712f, -0.04933240f, 0.03553660f, 0.00354644f, 
    -0.05047171f, -0.02526120f, 0.03414232f, 0.02749277f, -0.04994079f, -0.02658932f, 0.04620034f, 0.02759759f, 
    -0.00908535f, -0.01894515f, 0.03865515f, -0.01469543f, -0.06077459f, -0.01985510f, -0.05676045f, 0.03928757f, 
    0.01509641f, -0.04790160f, 0.03660143f, -0.06316980f, -0.00520806f, -0.06218909f, -0.04042471f, -0.00760152f, 
    0.02475626f, 0.05268206f, 0.02753836f, 0.01067276f, 0.00703750f, -0.00669295f, 0.04134013f, -0.01639694f, 
    -0.05458151f, 0.04544817f, 0.04547536f, -0.03298327f, -0.05089393f, 0.02918165f, -0.01789099f, 0.04245138f, 
    0.02983551f, -0.00075111f, 0.00193787f, 0.04296167f, -0.04498209f, -0.06404086f, -0.04736125f, 0.04531844f, 
    -0.01567727f, 0.03618742f, -0.04225400f, -0.01700916f, -0.00999561f, 0.02590063f, -0.00850139f, 0.00944968f, 
    0.03073310f, 0.01099027f, -0.04598620f, 0.03136426f, -0.00964360f, 0.03058205f, 0.01025623f, 0.04195441f, 
    -0.04011144f, 0.01731266f, -0.03448630f, -0.05853001f, 0.01410354f, 0.00177496f, -0.04661422f, -0.02544777f, 
    -0.04885282f, -0.04254279f, -0.06711996f, 0.02635987f, -0.02384122f, -0.00336335f, -0.04310161f, -0.05565634f, 
    -0.03594700f, -0.04173666f, -0.00737322f, 0.00725214f, -0.00293065f, 0.00214350f, -0.06576696f, -0.04411484f, 
    -0.05509423f, 0.05674058f, -0.00566104f, 0.00791058f, -0.01668806f, -0.03877389f, -0.06257376f, -0.05279313f, 
    -0.15261300f, -0.23038010f, -0.06749543f, 0.00484631f, 0.08939402f, -0.01772780f, -0.06165599f, -0.02157758f, 
    -0.03145406f, -0.24378355f, -0.19815783f, 0.18129472f, 0.05725628f, 0.15078600f, 0.08845787f, -0.15543930f, 
    0.09563210f, 0.15160616f, -0.12925002f, 0.11764716f, 0.08115038f, -0.00895180f, 0.07488068f, -0.00483404f, 
    -0.05283868f, 0.05392079f, -0.12725131f, -0.09116202f, 0.00035771f, -0.02967692f, -0.06258365f, 0.00329176f, 
    0.05778772f, -0.06695489f, 0.11140351f, 0.06208520f, 0.12443440f, 0.07073006f, 0.26013970f, -0.06658080f, 
    0.00683994f, -0.08003167f, -0.01021742f, 0.00784362f, -0.02542279f, 0.15475221f, -0.04142223f, -0.08578195f, 
    -0.01482099f, -0.01056601f, 0.00672674f, 0.05201016f, 0.00104175f, 0.07466212f, -0.27888876f, 0.01906998f, 
    -0.18224850f, 0.00956712f, -0.08664436f, 0.19553415f, -0.00191546f, 0.07481205f, 0.03291501f, -0.46729043f, 
    -0.12539299f, 0.05984080f, -0.06298226f, 0.16959529f, -0.01462913f, 0.16334292f, -0.08281071f, 0.01557384f, 
    -0.05559787f, 0.01636292f, -0.25865415f, -0.01229499f, 0.04247155f, -0.11244489f, -0.04409265f, -0.06715281f, 
    0.28167212f, -0.14320146f, 0.06332016f, 0.14855424f, -0.00271503f, -0.09930415f, -0.04662210f, 0.07670938f, 
    0.04324550f, 0.03684387f, -0.07773188f, -0.14516963f, 0.35600626f, -0.10962532f, 0.08056494f, -0.03397801f, 
    -0.16990134f, 0.17989825f, -0.01969823f, -0.22677802f, -0.10151719f, -0.09790886f, 0.01150655f, 0.06728686f, 
    -0.02532187f, 0.06388963f, 0.04719428f, -0.15101311f, 0.40432563f, -0.12261765f, -0.25736830f, 0.01326844f, 
    -0.04675777f, 0.04390060f, 0.02967189f, -0.00599845f, 0.00036990f, -0.11059928f, 0.00498931f, -0.20107196f, 
    0.01003749f, 0.09287705f, 0.05785121f, 0.07478885f, 0.09772255f, -0.19786091f, 0.14323281f, -0.40041327f, 
    -0.05825804f, -0.04875194f, 0.04472538f, -0.07219160f, 0.09997206f, 0.06274819f, 0.18837433f, 0.18766014f, 
    0.05874920f, -0.18376258f, 0.02890669f, 0.05528999f, 0.07237462f, 0.07637476f, 0.26775703f, 0.10355258f, 
    0.26381600f, -0.02253561f, -0.01636845f, -0.01060020f, -0.01444049f, -0.19563906f, 0.17450143f, -0.02787991f, 
    -0.06677482f, 0.23888510f, 0.11278803f, 0.09033012f, 0.04185609f, -0.15866904f, 0.11501303f, -0.00851731f, 
    0.07336700f, 0.04036899f, -0.15328132f, 0.20381267f, 0.20786767f, -0.17273556f, -0.04049654f, 0.05490865f, 
    -0.09261391f, -0.09527366f, -0.02764532f, -0.10492384f, 0.15733601f, 0.02981679f, 0.06959424f, -0.00120173f, 
    0.05844667f, 0.01358328f, 0.12416491f, -0.04552936f, -0.05035983f, -0.00753554f, -0.12237006f, 0.11221702f, 
    -0.03320635f, -0.11145981f, -0.03087439f, -0.02355483f, -0.00186548f, -0.03261366f, 0.02917475f, 0.06386758f, 
    0.02667349f, 0.09444652f, -0.03754792f, -0.11461755f, 0.03637202f, -0.04156156f, 0.08682386f, 0.07904952f, 
    0.10174708f, -0.07784945f, -0.13293956f, -0.03471094f, 0.07153925f, 0.00983607f, -0.18497421f, 0.19624875f, 
    -0.59239697f, 0.24922425f, -0.17229801f, -0.11399029f, -0.15399858f, 0.20185772f, 0.07702031f, -0.07386389f, 
    -0.00964244f, 0.22552614f, 0.04329690f, -0.11679922f, -0.03442325f, -0.07117157f, 0.03737477f, -0.07079309f, 
    -0.00598688f, 0.43185988f, -0.26698634f, -0.36754751f, -0.03740703f, -0.03486309f, 0.06108658f, 0.01846623f, 
    0.00034024f, -0.01812284f, -0.20935008f, 0.11405083f, 0.14500226f, -0.10315463f, 0.01153202f, 0.01053916f, 
    -0.04848132f, 0.10502093f, 0.00857551f, -0.08027221f, -0.18984792f, -0.18493900f, 0.05052621f, -0.05936190f, 
    0.09770101f, -0.02022314f, -0.02542752f, 0.11444976f, 0.50785291f, -0.42750052f, -0.51209122f, 0.01656581f, 
    0.06261986f, 0.04653693f, 0.00972899f, -0.05654458f, 0.12804797f, -0.30258876f, -0.21811964f, 0.09930409f, 
    0.07421453f, 0.02453776f, -0.05551948f, 0.06381010f, 0.13901314f, -0.05463676f, -0.38110650f, 0.06955361f, 
    0.18109111f, 0.10076717f, -0.02134470f, -0.04607128f, 0.02268008f, 0.07437997f, -0.05047504f, 0.59095252f, 
    -0.02572076f, -0.55182534f, 0.05827443f, 0.06267724f, -0.17674926f, 0.08735093f, -0.01990011f, 0.00663389f, 
    0.18560651f, 0.01544965f, 0.01616032f, -0.02296751f, -0.13050346f, 0.04403211f, 0.08609833f, 0.03267423f, 
    0.19593710f, 0.02093142f, -0.18499687f, 0.34025040f, 0.13930075f, 0.11421861f, -0.04517586f, -0.02492231f, 
    0.13141198f, -0.08477262f, 0.06366112f, 0.08581288f, 0.05275600f, -0.05914175f, 0.04200976f, -0.13743000f, 
    -0.11813096f, 0.08407308f, -0.00225768f, 0.02011996f, 0.04943463f, -0.00057216f, -0.02710130f, -0.01459753f, 
    0.13888428f, 0.07377186f, 0.02951067f, 0.14839175f, -0.05951825f, -0.12080288f, -0.07515197f, 0.08368487f, 
    0.05219229f, 0.01936017f, -0.05072644f, -0.06761326f, 0.08363526f, 0.04156669f, 0.26094621f, 0.00149336f, 
    -0.03791354f, -0.00179541f, 0.07231897f, 0.06970628f, 0.17221096f, 0.06621917f, 0.08247769f, 0.20737761f, 
    0.10834144f, 0.12283637f, -0.12367293f, 0.02139694f, 0.08821727f, 0.10069999f, 0.10438856f, -0.17881089f, 
    0.04397535f, 0.18485710f, 0.13728900f, -0.01861797f, -0.02315284f, -0.11698256f, 0.12939043f, 0.09198496f, 
    -0.00652776f, -0.21591854f, -0.25681370f, -0.03741437f, 0.15513305f, -0.02791884f, 0.07470196f, -0.10253528f, 
    -0.05428646f, -0.07952555f, 0.06309738f, 0.07653748f, 0.04103526f, 0.00862513f, 0.06433178f, 0.27822703f, 
    -0.08559287f, -0.04468429f, -0.07447219f, -0.09267353f, -0.05574318f, -0.16157511f, 0.05661139f, 0.06786089f, 
    -0.21826994f, 0.14266405f, -0.16562580f, -0.12967578f, 0.15557671f, -0.01925288f, -0.00705776f, 0.02814224f, 
    0.09689912f, 0.04558391f, 0.02807261f, 0.06457312f, 0.24265736f, -0.11291555f, 0.03020059f, 0.00887348f, 
    0.01283918f, -0.07262717f, 0.08753149f, 0.09207541f, 0.03765136f, 0.09863421f, 0.10972368f, 0.03414499f, 
    0.00159626f, -0.04667664f, -0.16136800f, -0.01272403f, 0.09917714f, 0.13422336f, 0.05819248f, 0.13258956f, 
    -0.06774342f, 0.04243748f, -0.07377519f, -0.08123983f, -0.04519913f, -0.19273344f, -0.07786560f, 0.06871195f, 
    0.04779322f, -0.03371781f, 0.11416353f, -0.03504921f, -0.03635300f, 0.08278018f, -0.07203600f, -0.11569773f, 
    0.10596363f, -0.03362561f, 0.09238093f, 0.06379636f, 0.03955294f, 0.01138768f, -0.07951090f, 0.00492772f, 
    -0.11111803f, -0.06546833f, -0.62671131f, -0.22138786f, 0.19155243f, -0.02507878f, -0.12479046f, 0.05559430f, 
    0.06105600f, -0.07686038f, -0.11232297f, 0.10078363f, 0.05207887f, -0.00056515f, -0.06027796f, 0.12145738f, 
    -0.17942874f, 0.10981085f, -0.04486752f, -0.23949023f, 0.02827561f, 0.11515041f, -0.05936383f, 0.07294637f, 
    -0.04432520f, -0.06730366f, 0.01504250f, 0.19793844f, -0.19574438f, 0.08966295f, -0.02595265f, -0.02312078f, 
    -0.15593587f, -0.04269474f, -0.10391139f, 0.01512859f, -0.04548529f, 0.00370012f, -0.06309494f, -0.12238830f, 
    -0.01389925f, 0.04793939f, 0.00580983f, 0.04619019f, -0.04781252f, -0.19565049f, -0.02030589f, -0.19421460f, 
    -0.05714402f, 0.08042651f, 0.08282160f, -0.02846562f, -0.01288570f, -0.15074877f, -0.06811976f, 0.11386456f, 
    0.27725250f, 0.23709139f, -0.09186647f, 0.18829659f, -0.00470400f, -0.03516146f, 0.14016271f, 0.46328506f, 
    -0.13568091f, 0.02220311f, -0.07547044f, -0.09828862f, -0.15439919f, -0.11198450f, -0.06654456f, -0.12704335f, 
    -0.00298202f, 0.04727443f, -0.06626221f, -0.19156864f, -0.15815438f, -0.05509461f, -0.01600223f, -0.06919487f, 
    -0.02102095f, -0.01492485f, -0.09184358f, 0.08011069f, 0.08632874f, -0.05586633f, 0.06486336f, -0.05516036f, 
    -0.18335417f, -0.04827731f, -0.06589138f, 0.03973643f, -0.03978233f, -0.02663965f, 0.08182684f, 0.01505324f, 
    -0.11880691f, -0.07008425f, -0.12844455f, -0.24709581f, 0.07930645f, 0.03377137f, 0.01130693f, 0.04505020f, 
    -0.01915178f, -0.19278660f, 0.02259192f, -0.14959934f, -0.05618921f, -0.21145771f, 0.01610018f, 0.15244113f, 
    -0.05849893f, -0.09732194f, 0.16337426f, 0.04770313f, 0.32695642f, 0.20987460f, -0.32817650f, -0.10661100f, 
    0.03064823f, 0.20340821f, -0.02261385f, 0.01087251f, 0.12809063f, 0.02027337f, 0.13920505f, -0.01920535f, 
    -0.02662359f, -0.04126500f, 0.07321529f, -0.13031079f, 0.08848758f, -0.01071297f, -0.41032872f, -0.27436286f, 
    -0.08604912f, 0.03050573f, -0.03644633f, -0.02381312f, -0.01053206f, -0.03172776f, -0.01983633f, -0.03155266f, 
    -0.08176448f, -0.04003559f, 0.00575294f, 0.08151992f, 0.03645232f, -0.03491572f, 0.01659628f, -0.00725800f, 
    -0.04161840f, -0.01506780f, -0.00411553f, -0.02425513f, 0.00669367f, -0.05982065f, 0.01481818f, -0.01996727f, 
    -0.04944713f, 0.02384112f, -0.04404346f, -0.01792932f, -0.00841139f, -0.07446301f, -0.03920320f, -0.04396872f, 
    -0.03589212f, 0.01629580f, 0.03959274f, 0.03199466f, -0.06473066f, -0.01531252f, -0.01928844f, -0.05106878f, 
    -0.00493930f, -0.05179255f, 0.01880791f, -0.05044919f, -0.00777428f, -0.03726270f, -0.05228674f, -0.08125246f, 
    -0.07122225f, -0.00728580f, -0.00787078f, -0.07253926f, 0.00028040f, -0.01266562f, 0.00486388f, -0.03665749f, 
    -0.03296610f, -0.02434489f, -0.08140343f, -0.05118117f, -0.02273647f, -0.05769557f, -0.07296321f, -0.04548757f, 
    -0.00442195f, -0.00495428f, -0.02202909f, 0.04174391f, -0.01903946f, 0.00257107f, -0.04349513f, -0.04461926f, 
    -0.05213668f, -0.00703316f, 0.01234227f, 0.00476383f, -0.07107313f, 0.01579681f, -0.06474669f, 0.01814480f, 
    -0.02054374f, 0.00040334f, -0.02755732f, -0.04150160f, -0.03735251f, -0.07721597f, -0.08385488f, -0.01857471f, 
    0.02942594f, -0.00553349f, 0.05724477f, -0.04073825f, -0.03911882f, -0.07986183f, -0.06569916f, 0.01257600f, 
    -0.02016478f, -0.01066885f, -0.06486201f, 0.00384920f, 0.03311776f, -0.00528753f, -0.01578258f, 0.00180103f, 
    0.06195050f, 0.06970984f, -0.01916349f, 0.04480386f, -0.02810543f, -0.02874938f, -0.01638345f, 0.02699426f, 
    -0.00685646f, -0.07662278f, 0.02850563f, -0.03946394f, -0.01468079f, -0.01370288f, 0.02967693f, -0.06612185f, 
    0.03388681f, -0.05144681f, -0.03309846f, -0.01376357f, -0.04183687f, 0.01562379f, -0.01342119f, -0.04386462f, 
    -0.04481540f, -0.01054913f, -0.06570423f, 0.00783746f, -0.09015282f, -0.01534792f, 0.02459910f, -0.06548180f, 
    -0.02094270f, -0.07924038f, -0.06645104f, -0.03708652f, 0.01189687f, 0.00862930f, 0.02536507f, -0.08348083f, 
    -0.07782151f, 0.01325194f, -0.02672511f, 0.00007268f, 0.00132530f, 0.01998988f, -0.02264662f, 0.03940581f, 
    0.00230686f, -0.02434343f, -0.03199553f, 0.03122497f, -0.06781796f, 0.00875249f, -0.08676625f, 0.02202702f, 
    -0.06263785f, 0.03433470f, -0.03377608f, -0.06274124f, -0.00691992f, -0.09591081f, 0.01308318f, -0.06883880f, 
    0.05976627f, -0.02980270f, -0.02096891f, 0.00315928f, 0.03026513f, -0.03486177f, 0.00024130f, 0.00148029f, 
    -0.00618664f, -0.07975564f, 0.00004098f, 0.02770744f, -0.06723500f, -0.01349401f, -0.01864676f, -0.04807747f, 
    -0.00102784f, -0.05325540f, 0.06554655f, -0.05112930f, 0.03910247f, 0.01224311f, 0.05783379f, 0.00172090f, 
    0.07078802f, 0.05907688f, -0.05703220f, -0.00064723f, -0.06290039f, 0.01084217f, -0.04281052f, 0.00157578f, 
    0.03148929f, -0.06993707f, 0.00759107f, -0.02323934f, -0.02468412f, -0.04475074f, -0.01968685f, -0.01383545f, 
    -0.03222199f, 0.01354517f, -0.00545679f, -0.02701991f, 0.02122722f, -0.04998145f, 0.00518248f, 0.03753284f, 
    -0.05130716f, 0.00595475f, -0.04201414f, -0.02090812f, 0.02183637f, 0.04586984f, 0.04204372f, 0.02394828f, 
    -0.06152136f, 0.00179503f, -0.00686742f, -0.07009939f, 0.03441407f, 0.00609555f, -0.00069376f, 0.01698240f, 
    0.01985640f, -0.04997588f, -0.05146145f, -0.02435232f, 0.00905979f, -0.02132161f, 0.02021665f, -0.03556611f, 
    0.01109036f, 0.01714952f, 0.00017240f, -0.05318806f, -0.01508009f, -0.02164484f, -0.01758530f, -0.07409986f, 
    -0.05364854f, 0.01798328f, -0.06806189f, -0.00683501f, 0.00297857f, 0.00436669f, -0.04789755f, 0.04712049f, 
    0.03997098f, 0.02178821f, -0.04422154f, -0.01484022f, -0.01570885f, 0.01336951f, 0.02110001f, -0.03408413f, 
    0.01269836f, 0.04469714f, -0.03022261f, -0.01814522f, 0.00281602f, 0.04219266f, -0.02723640f, -0.05497757f, 
    -0.01253290f, 0.02521773f, -0.02950166f, -0.03012666f, -0.05639503f, 0.01196373f, -0.03104152f, -0.07459050f, 
    -0.00983417f, -0.04448857f, -0.06382494f, -0.03772237f, 0.05042436f, -0.07844220f, 0.01888380f, -0.06496794f, 
    0.04811928f, -0.04655465f, 0.12368566f, -0.06622611f, 0.01593907f, 0.06476992f, 0.12168805f, -0.11370179f, 
    0.02968521f, 0.11289544f, -0.09216592f, 0.30721688f, 0.05691195f, 0.10549513f, -0.04137845f, 0.04049312f, 
    -0.06707831f, 0.11027095f, -0.01200392f, 0.04678171f, -0.14723481f, -0.06473090f, 0.12290399f, -0.04029998f, 
    0.04811603f, 0.00807712f, 0.06530758f, 0.08022228f, -0.13708128f, 0.06710593f, -0.03308219f, 0.15347946f, 
    0.10176600f, -0.02674337f, -0.02597226f, 0.04453772f, -0.10425250f, -0.11283258f, 0.11752675f, 0.14824481f, 
    0.09755170f, -0.09753893f, 0.11539917f, 0.03073457f, 0.15789212f, 0.05518079f, -0.24088012f, -0.02548056f, 
    -0.01164980f, -0.01187116f, 0.10861627f, 0.11928709f, -0.06506338f, 0.07953724f, 0.44709367f, -0.07456063f, 
    -0.11528746f, -0.08532441f, 0.09004570f, -0.01551638f, 0.02842153f, 0.14900646f, 0.07227281f, -0.00738039f, 
    -0.42966822f, -0.11281604f, -0.12121707f, -0.11119425f, -0.14289722f, -0.01017677f, 0.03094684f, -0.08833695f, 
    -0.13217758f, -0.16461395f, 0.11769733f, -0.17577420f, 0.01974774f, 0.00190478f, 0.01549492f, 0.04884420f, 
    0.17905490f, 0.16621169f, -0.05454605f, 0.06141840f, 0.06881910f, 0.01857672f, -0.05703717f, 0.10346941f, 
    0.18662818f, 0.05017836f, -0.06853659f, -0.10507125f, -0.23363145f, 0.03168741f, -0.10956474f, -0.04782706f, 
    0.04165239f, -0.05970363f, 0.15372139f, -0.18028416f, 0.06412850f, -0.03306159f, -0.12391829f, 0.07211975f, 
    0.08608147f, 0.00282285f, -0.01865587f, -0.03810494f, 0.06347567f, -0.02304082f, -0.06312892f, -0.04286051f, 
    0.04231559f, 0.13223915f, 0.09686439f, 0.10289308f, 0.01372221f, 0.03912002f, -0.24567303f, -0.35607794f, 
    -0.11506820f, -0.03846540f, 0.11283725f, -0.06317696f, 0.08056642f, 0.04039615f, -0.08648933f, 0.00811616f, 
    0.04340253f, 0.03117956f, -0.05158447f, 0.11918209f, 0.07372350f, 0.07613391f, -0.03519137f, 0.22689450f, 
    -0.11059161f, -0.23788585f, -0.08101308f, -0.09482218f, 0.13503173f, -0.01951726f, -0.10841625f, -0.01386776f, 
    0.05785168f, -0.03765345f, -0.04461407f, 0.03790656f, 0.14735314f, -0.05429495f, -0.11526751f, 0.09112528f, 
    0.09351949f, 0.02525903f, -0.11469351f, 0.18602119f, 0.07028441f, 0.03584627f, -0.03362578f, -0.00913230f, 
    0.00899298f, -0.01098226f, 0.20437071f, -0.05784556f, -0.14822952f, -0.08486883f, -0.26521820f, -0.06793152f, 
    0.07523738f, 0.05195314f, -0.14560023f, -0.01312299f, -0.16439533f, -0.11519723f, -0.10499395f, -0.02161718f, 
    0.01213889f, -0.13949120f, -0.00676265f, -0.01228332f, 0.02026370f, 0.07963695f, 0.07889411f, -0.07368708f, 
    -0.22336894f, -0.08383749f, -0.11273291f, -0.15338400f, 0.05054106f, -0.04336492f, -0.01127060f, 0.10269753f, 
    -0.16427071f, 0.12466718f, -0.07615897f, 0.08875842f, 0.00282453f, -0.08528229f, -0.09388232f, -0.19284230f, 
    0.08860414f, -0.04482219f, 0.00819316f, -0.06851063f, -0.05501585f, 0.02398252f, 0.13131697f, 0.46994200f, 
    -0.04228695f, -0.49196911f, -0.11009117f, -0.22889902f, -0.15321289f, -0.05791980f, -0.05173271f, 0.10742604f, 
    0.04554033f, -0.03272980f, -0.09319682f, -0.11955756f, -0.13493514f, -0.41246480f, 0.03195986f, 0.11651222f, 
    -0.07512597f, -0.21672235f, -0.07905753f, 0.09781367f, -0.01328763f, 0.02290030f, 0.08146034f, -0.02984395f, 
    -0.00199519f, 0.11902352f, 0.01132894f, -0.04047302f, -0.03920837f, -0.06958053f, 0.01943668f, -0.15295736f, 
    0.09916621f, 0.04198798f, 0.09066842f, 0.04504223f, 0.07253820f, 0.00115856f, -0.02402714f, 0.01684421f, 
    0.04342930f, -0.00070045f, 0.04138997f, -0.08854325f, -0.34198007f, 0.18126836f, 0.19822699f, 0.05063625f, 
    0.12426639f, 0.12871756f, 0.12336609f, 0.07691721f, 0.01429832f, -0.27738383f, -0.33224961f, -0.12368823f, 
    -0.04878871f, -0.08848426f, -0.04259006f, 0.02028961f, 0.07102689f, -0.15915807f, -0.01972258f, -0.21988034f, 
    0.13034905f, 0.12081225f, 0.08387298f, -0.14517683f, 0.06003499f, 0.00925409f, 0.03146704f, -0.09887091f, 
    0.01844232f, 0.29757342f, -0.07177917f, 0.05462641f, -0.02266419f, 0.03485685f, -0.06596866f, 0.20643967f, 
    0.08030499f, -0.04231654f, -0.00795957f, -0.01753422f, 0.14178926f, -0.02175016f, -0.00066073f, -0.06567405f, 
    0.05638037f, 0.18690409f, 0.02109948f, 0.19096768f, 0.00148286f, -0.07912214f, -0.00872725f, 0.02576530f, 
    -0.13381447f, 0.25528648f, -0.08050725f, 0.05179063f, -0.00839214f, -0.14907975f, -0.11143951f, 0.08229201f, 
    0.00796355f, 0.02010632f, 0.21704477f, -0.05882068f, -0.12316173f, 0.08138398f, 0.08166692f, 0.15717547f, 
    0.06723572f, -0.07352616f, 0.07316834f, 0.11596020f, -0.09545568f, -0.01858995f, 0.15183130f, -0.03101035f, 
    0.03789595f, 0.09856301f, 0.04164586f, -0.08928763f, 0.03364283f, -0.01906398f, -0.15162699f, 0.13127409f, 
    0.00182654f, 0.12809989f, 0.12308502f, 0.03823036f, 0.06782115f, 0.20413575f, 0.16846699f, 0.12576388f, 
    0.07364585f, 0.03843634f, 0.20297909f, 0.09468761f, 0.10016482f, 0.01217827f, 0.31885064f, 0.07630262f, 
    -0.34969759f, 0.00795994f, -0.19042552f, -0.08931398f, 0.15561007f, -0.07049990f, -0.02024793f, -0.01844754f, 
    -0.33696988f, 0.09787301f, -0.04125795f, -0.09340616f, 0.04015180f, -0.07862144f, 0.09506965f, 0.00330256f, 
    -0.36843997f, 0.11418837f, 0.03704295f, -0.09419143f, -0.04747053f, -0.10918876f, -0.04168842f, 0.16231920f, 
    -0.04848297f, 0.02013925f, 0.16157097f, 0.03333973f, -0.16703606f, 0.03102435f, 0.04849232f, -0.01452523f, 
    -0.02295932f, -0.17145236f, -0.27416933f, -0.12929930f, -0.01343144f, -0.13010420f, -0.06027989f, 0.01606374f, 
    0.07472688f, 0.00655717f, -0.10310768f, 0.05995870f, -0.04312845f, -0.04726019f, 0.01799108f, 0.10594948f, 
    0.10945451f, 0.03990278f, 0.07195982f, 0.03792742f, 0.05658207f, -0.03963066f, -0.25987616f, -0.00191699f, 
    -0.00782972f, -0.04082137f, 0.01612710f, -0.07951394f, 0.10178889f, 0.15092497f, 0.10184979f, 0.09293462f, 
    0.26328135f, 0.08475710f, 0.08464014f, -0.00405023f, 0.14254747f, -0.00160032f, -0.19417423f, -0.15779024f, 
    -0.20893252f, -0.04147238f, -0.14998402f, -0.03560468f, -0.27801418f, 0.16210958f, 0.05577010f, -0.09265841f, 
    0.16428515f, -0.00909094f, 0.23720503f, -0.00753345f, -0.00841881f, 0.16371289f, -0.01160770f, 0.03819428f, 
    -0.10304314f, -0.08272845f, 0.02947955f, 0.02892061f, 0.03432650f, 0.02529847f, -0.02452981f, -0.02775260f, 
    0.00045039f, -0.12582433f, -0.17143996f, -0.25887576f, 0.04919260f, -0.15262306f, -0.00422947f, -0.05060419f, 
    0.03071748f, -0.06906692f, 0.15581089f, -0.36915141f, -0.30011189f, -0.23394623f, -0.27839556f, -0.08708641f, 
    -0.05689699f, 0.00468741f, 0.09591424f, 0.03173224f, 0.02898593f, -0.01158000f, -0.20629625f, -0.35844555f, 
    0.01862039f, -0.19813840f, 0.10193370f, -0.05599419f, 0.03141643f, -0.23413457f, -0.28355253f, -0.07623637f, 
    -0.20748676f, -0.07599693f, -0.27681458f, -0.06515739f, -0.03768183f, 0.06400511f, -0.10719860f, -0.00283949f, 
    0.15248278f, -0.03085308f, 0.05825933f, 0.02073707f, 0.10882165f, 0.08668891f, -0.19561812f, 0.00104531f, 
    0.37631154f, -0.34506908f, -0.09526916f, 0.19205238f, -0.11978792f, -0.13050704f, 0.00470746f, 0.17355014f, 
    -0.15282701f, -0.28268537f, -0.11743753f, -0.16035481f, -0.11791032f, -0.31888101f, 0.02812166f, -0.00168502f, 
    0.05785811f, -0.25732744f, -0.00419198f, -0.14761694f, -0.04825976f, 0.05366664f, -0.03452865f, 0.15261568f, 
    0.09714187f, -0.12348571f, 0.17611814f, 0.05682205f, -0.08701527f, -0.08235002f, -0.02830273f, 0.14137776f, 
    -0.09158557f, -0.14560628f, 0.14848551f, 0.14051990f, -0.03238608f, 0.18199043f, 0.04708798f, 0.21979114f, 
    -0.17239201f, 0.06490270f, -0.03441856f, -0.04896662f, -0.28892323f, 0.21816680f, 0.00674496f, -0.09096335f, 
    0.02981446f, -0.11827639f, 0.10125037f, 0.02743285f, -0.04093676f, -0.12495755f, -0.17265290f, 0.03274641f, 
    0.10742749f, -0.05502590f, -0.05347265f, -0.21791629f, -0.07451952f, 0.02709161f, -0.31558120f, -0.14285006f, 
    0.10457429f, -0.01261007f, 0.04014327f, 0.05352803f, -0.03597314f, 0.08896577f, 0.13192531f, -0.02289458f, 
    0.21080823f, 0.36682466f, 0.02718358f, -0.10500055f, 0.11676212f, 0.17775293f, -0.17880543f, -0.18429646f, 
    -0.06231518f, -0.04307324f, -0.01875090f, 0.00400452f, -0.02479123f, -0.04500266f, -0.05840607f, -0.02291051f, 
    0.01784363f, 0.04271907f, -0.01015968f, 0.01368202f, 0.02121301f, -0.02978959f, -0.07614864f, -0.02148345f, 
    -0.04633238f, -0.05829035f, -0.03141694f, 0.03082105f, -0.04437437f, -0.05372413f, -0.05466053f, -0.03280887f, 
    -0.05845270f, 0.00075125f, -0.06866716f, -0.03319921f, 0.02619563f, -0.02108808f, -0.04246482f, -0.02570772f, 
    -0.07717992f, -0.01565708f, -0.06417464f, -0.08861381f, 0.02110513f, -0.03481177f, -0.01851914f, 0.00851819f, 
    0.01931575f, 0.00585692f, -0.05217495f, -0.04923934f, -0.07064886f, -0.05229305f, -0.02282094f, -0.05355364f, 
    -0.05857375f, -0.06711832f, 0.02143623f, -0.08351779f, -0.02483240f, 0.01735092f, 0.03149015f, -0.07792987f, 
    -0.03876587f, -0.02590157f, -0.06233991f, -0.00522054f, -0.10108148f, 0.01067688f, 0.00439960f, 0.05035842f, 
    0.00600488f, -0.04733772f, -0.02995252f, -0.04407091f, -0.04400161f, -0.06510419f, -0.07119533f, 0.00568621f, 
    0.02163720f, -0.02984029f, 0.00925975f, -0.04785066f, 0.05183192f, 0.00137459f, -0.03578560f, 0.03766625f, 
    -0.06735811f, -0.02264103f, 0.02789130f, -0.00001956f, -0.02640835f, -0.06303478f, -0.07459829f, -0.09576460f, 
    -0.04629077f, -0.03353722f, -0.00548187f, 0.04087907f, 0.01148605f, -0.03832169f, -0.04809621f, -0.03157911f, 
    -0.00801547f, 0.01589448f, -0.03799646f, -0.02026818f, -0.01366886f, -0.07642698f, 0.01154494f, -0.04404579f, 
    0.01771852f, -0.05411850f, -0.06595341f, -0.08080754f, -0.04162222f, -0.09037632f, -0.07127573f, -0.00437117f, 
    0.02830363f, 0.01740921f, -0.06576654f, -0.06672378f, 0.02020347f, -0.07880069f, -0.07819790f, -0.05308777f, 
    -0.01081149f, -0.01234400f, -0.04112273f, -0.07269983f, -0.06567508f, -0.05136060f, 0.00777814f, 0.04013041f, 
    0.01345703f, -0.00054956f, -0.04585350f, 0.02469484f, -0.03704967f, -0.05474061f, -0.05708603f, -0.02543119f, 
    -0.05314107f, -0.04509844f, 0.01136949f, 0.04538609f, -0.06515823f, -0.05539927f, 0.03846163f, 0.00909237f, 
    -0.04269765f, -0.00659791f, -0.04479989f, -0.04134409f, -0.03851129f, -0.01300632f, -0.05853146f, -0.01487463f, 
    0.03320004f, -0.04738943f, -0.08136704f, -0.02614488f, -0.01014856f, 0.01711118f, -0.03841807f, -0.02834637f, 
    0.06144299f, -0.00351673f, 0.03628282f, -0.04744868f, -0.03820814f, 0.01143984f, -0.01520735f, -0.05777517f, 
    -0.02580871f, 0.03083162f, 0.01245352f, -0.01096709f, 0.00397032f, -0.01746772f, 0.01341905f, 0.03660393f, 
    0.00430299f, -0.02201898f, -0.08858980f, -0.02910585f, -0.02488219f, -0.05012421f, -0.02145917f, -0.06520315f, 
    -0.05841537f, -0.02384329f, -0.07055093f, -0.10633612f, -0.07205465f, -0.06118656f, 0.00548747f, 0.02169789f, 
    0.00866915f, -0.00848067f, 0.02279450f, -0.04818496f, -0.01928214f, -0.06357557f, 0.01882192f, -0.07278775f, 
    -0.01005944f, 0.02334365f, 0.00604926f, -0.04140868f, -0.00224363f, -0.02699658f, -0.00247202f, -0.06410861f, 
    -0.08332742f, -0.05673959f, -0.05203376f, -0.02181125f, -0.03439451f, 0.03084416f, -0.07536314f, -0.04574109f, 
    0.03077325f, 0.01699709f, -0.05928387f, -0.10231327f, -0.05814368f, -0.08628408f, -0.05185740f, -0.07086985f, 
    -0.01232869f, -0.00222009f, -0.03354481f, -0.04681328f, -0.03599604f, 0.02395359f, -0.05035143f, -0.03398883f, 
    0.05193782f, 0.03627329f, -0.00906667f, -0.04879837f, -0.03371425f, 0.02177107f, -0.04629797f, -0.05323635f, 
    -0.05991769f, 0.01174166f, -0.01229081f, 0.00432008f, 0.02885410f, 0.03505086f, 0.01403402f, -0.01322557f, 
    0.02413772f, -0.05260107f, 0.01152519f, -0.04888759f, 0.04333710f, -0.03109295f, 0.02784974f, 0.01859978f, 
    -0.07864849f, -0.04629119f, 0.01431373f, -0.02346800f, -0.05398160f, -0.01553738f, -0.02343028f, -0.04262576f, 
    -0.03647408f, -0.00713209f, 0.03246970f, -0.02055099f, -0.06821611f, 0.02109868f, -0.00374761f, -0.03151561f, 
    -0.02269753f, -0.06292269f, 0.02332888f, 0.00614434f, -0.03992914f, -0.06870823f, -0.06162019f, -0.00890691f, 
    -0.07563195f, 0.05711048f, 0.02127517f, 0.05489761f, -0.06596906f, 0.03331403f, 0.05719501f, -0.04832983f, 
    -0.05521858f, 0.02538751f, 0.01484018f, -0.00047964f, 0.04059448f, 0.04100491f, -0.01660199f, 0.03761449f, 
    0.04735077f, -0.03832886f, 0.01599290f, -0.00599927f, -0.02652596f, -0.03399118f, -0.01087508f, -0.06356146f, 
    -0.03275469f, 0.03974648f, -0.00785448f, -0.01419037f, -0.01558806f, 0.01783614f, -0.02293594f, -0.01903064f, 
    0.03933540f, -0.03793782f, -0.00722653f, 0.04890963f, -0.06382398f, -0.00277333f, 0.04376427f, 0.05021044f, 
    0.03618475f, -0.00974528f, 0.01494661f, -0.02865762f, -0.00774710f, -0.04571251f, -0.03596256f, -0.00972065f, 
    -0.04354998f, 0.04376525f, -0.05743824f, -0.03388277f, -0.03625397f, -0.03444440f, -0.02805641f, 0.03427332f, 
    -0.02744360f, -0.00695862f, 0.03128860f, -0.05221595f, -0.02588983f, -0.01295908f, -0.01605393f, 0.02964713f, 
    -0.00942512f, -0.01232736f, -0.04082405f, -0.05263599f, -0.01827760f, 0.02026473f, -0.01697512f, -0.02721906f, 
    -0.03732128f, 0.03858809f, -0.04530723f, -0.01650455f, -0.00271046f, -0.06431352f, -0.01937933f, -0.05648240f, 
    0.02075456f, -0.05465003f, -0.04971692f, 0.00093284f, 0.02180273f, 0.00791882f, -0.00937766f, -0.04119330f, 
    -0.00562236f, -0.06013341f, 0.01305968f, -0.05274903f, -0.05880554f, 0.04881679f, -0.04979525f, -0.02276987f, 
    -0.01624382f, -0.05416315f, 0.04033283f, 0.00432784f, 0.02934380f, 0.03643680f, -0.00697483f, -0.01823690f, 
    0.03528191f, 0.03143466f, -0.04836520f, -0.02660087f, 0.00462403f, 0.03434293f, -0.00701347f, -0.00985464f, 
    0.04818754f, -0.06134189f, 0.01770635f, 0.02052846f, -0.00710246f, 0.04045445f, -0.02740134f, 0.00036160f, 
    -0.01034972f, 0.00885583f, -0.03702611f, -0.03875094f, -0.03817406f, 0.04890958f, -0.00282931f, 0.02316872f, 
    -0.04681280f, 0.01592386f, -0.02385361f, -0.04261390f, -0.03878014f, 0.05143494f, -0.06031468f, -0.05261725f, 
    0.00703154f, -0.05260236f, -0.02438786f, 0.01263837f, -0.02285215f, -0.04500983f, -0.04017352f, -0.03796601f, 
    -0.04390182f, 0.00677229f, -0.05470576f, -0.04994153f, 0.00723324f, -0.03465396f, 0.01867076f, -0.03364625f, 
    -0.05512330f, 0.00488414f, 0.04941431f, 0.03047134f, -0.04674943f, -0.04362889f, 0.00671051f, -0.02546199f, 
    -0.01860072f, -0.03317720f, -0.04160695f, -0.00011379f, 0.01966980f, 0.03910768f, -0.03634755f, 0.00286541f, 
    -0.04186590f, -0.00680538f, 0.02029845f, 0.04485941f, 0.01849242f, -0.06283998f, 0.04938434f, -0.05585545f, 
    -0.03652615f, 0.03514346f, -0.02450555f, -0.00129865f, 0.02611550f, -0.00962885f, -0.02428900f, 0.04264603f, 
    -0.05366596f, -0.06091421f, 0.02387869f, -0.03134183f, -0.04951688f, -0.01142847f, 0.01769163f, 0.00753116f, 
    0.05155187f, 0.00545046f, 0.05280451f, 0.05042031f, 0.01256032f, -0.01253119f, -0.03720535f, -0.04001460f, 
    -0.02903920f, 0.05032773f, -0.05365650f, -0.03658083f, -0.03697300f, 0.03527953f, 0.01575686f, 0.02697205f, 
    -0.02484854f, 0.00450083f, -0.01094998f, 0.04938792f, 0.02381809f, -0.00261061f, 0.00584213f, -0.03960760f, 
    -0.02619236f, 0.00541060f, -0.05736615f, -0.00310395f, 0.01272169f, 0.05151420f, 0.02436736f, 0.04383965f, 
    -0.03761698f, 0.05228940f, -0.04403627f, 0.02282234f, 0.01073377f, -0.06007368f, 0.02824297f, -0.02082896f, 
    -0.05740452f, -0.03508659f, -0.02025253f, 0.03691315f, -0.03662496f, 0.04373355f, -0.06218297f, -0.05149232f, 
    -0.05920935f, 0.00971832f, -0.05307942f, 0.03774791f, 0.00294141f, -0.01340588f, 0.00680001f, -0.06202973f, 
    -0.05232929f, 0.02567385f, 0.01069825f, 0.03724561f, -0.01414310f, 0.00429973f, -0.05285817f, 0.05028953f, 
    -0.01579130f, -0.02630106f, 0.03244863f, -0.03452342f, 0.00108372f, 0.03166505f, -0.06052086f, -0.00577858f, 
    -0.05377484f, 0.05166279f, 0.04461219f, 0.00955404f, -0.00403526f, -0.00079476f, -0.04289374f, 0.01263564f, 
    0.00445955f, -0.05337710f, -0.02806115f, 0.03768741f, -0.04352262f, -0.04182423f, 0.02447861f, 0.02542376f, 
    -0.04018191f, -0.00741454f, -0.04315694f, -0.04050646f, -0.00435881f, -0.06268524f, -0.01637351f, 0.04347101f, 
    0.00621587f, 0.04618894f, 0.03263420f, 0.03052298f, 0.01775053f, 0.02476875f, 0.04025731f, 0.02097837f, 
    -0.01790593f, -0.06726281f, 0.03740490f, 0.01380641f, 0.04673623f, -0.05255291f, -0.02302245f, -0.01924566f, 
    -0.05422417f, -0.00990893f, -0.02738737f, 0.04841243f, 0.02930716f, 0.04625376f, -0.03392975f, -0.04561426f, 
    -0.03182943f, -0.04722834f, 0.03099071f, -0.03385985f, 0.04051868f, 0.02945856f, -0.03257774f, 0.01138587f, 
    0.01304178f, -0.04884931f, 0.04474306f, -0.00935197f, 0.01960453f, -0.06161058f, 0.03598488f, -0.06471439f, 
    0.01214080f, -0.02259782f, -0.04472251f, 0.00027002f, -0.02414268f, -0.03557558f, -0.01357403f, -0.04005443f, 
    0.03687443f, 0.01083768f, -0.06684165f, -0.05672698f, -0.02742458f, -0.01252989f, -0.06580162f, 0.01237719f, 
    -0.02504858f, -0.05082848f, 0.03657328f, -0.00517982f, 0.03946807f, -0.05176499f, 0.00856961f, 0.01762295f, 
    0.04809663f, 0.04281227f, -0.04489392f, 0.04803566f, -0.02760893f, -0.04045741f, -0.01879710f, -0.03015417f, 
    -0.00468862f, 0.01299080f, -0.01912389f, 0.02223480f, 0.04716685f, -0.05673794f, -0.01909856f, -0.04694554f, 
    0.01754429f, -0.01622218f, -0.04994328f, 0.05440108f, -0.05316893f, -0.06386489f, -0.04719553f, 0.00659474f, 
    0.02575176f, 0.00220678f, 0.01877632f, 0.04313955f, -0.03447657f, -0.03737868f, 0.04410417f, 0.00757972f, 
    -0.03459617f, -0.04664787f, -0.03514352f, 0.04260112f, -0.02843260f, -0.03617295f, 0.02774014f, 0.05297966f, 
    -0.05433728f, -0.01725210f, -0.06228088f, -0.01833349f, 0.03630996f, 0.04010628f, 0.00591767f, -0.02155693f, 
    0.01590681f, 0.03131066f, 0.05280982f, 0.03925880f, -0.02637816f, 0.02823604f, 0.04485338f, -0.04157952f, 
    -0.04094474f, 0.01106849f, -0.06415805f, -0.05101167f, -0.04633056f, -0.02605709f, -0.05081163f, 0.02305054f, 
    -0.06236761f, -0.06067280f, 0.02468175f, -0.05414823f, -0.05937627f, 0.03292348f, -0.04347062f, 0.03171650f, 
    -0.03772097f, -0.05211594f, -0.01517892f, -0.06311049f, 0.04404126f, -0.02838486f, 0.01962852f, 0.00751487f, 
    0.00817913f, 0.03552403f, -0.00222053f, -0.05762211f, 0.01951630f, 0.02197801f, -0.01108581f, -0.03785862f, 
    -0.05406056f, -0.04254806f, 0.03516418f, -0.02627452f, 0.04005767f, 0.04522656f, 0.01035957f, -0.03096026f, 
    0.01261437f, -0.00370191f, 0.00483415f, 0.02554996f, -0.05007060f, -0.01383680f, -0.01137221f, -0.04238218f, 
    0.04759037f, -0.05019613f, 0.05097000f, 0.05063521f, 0.02085729f, 0.00964088f, -0.04836152f, 0.02546436f, 
    0.00320322f, -0.05489431f, -0.03797658f, 0.03592233f, -0.03992375f, -0.01025810f, 0.02878066f, 0.02922675f, 
    -0.03173853f, -0.01372064f, -0.03888137f, 0.03769965f, -0.01417913f, 0.03274527f, -0.01131458f, -0.00079125f, 
    -0.00177406f, 0.04636448f, -0.01736163f, 0.05068004f, 0.00605982f, -0.02354636f, -0.02875628f, -0.06098509f, 
    -0.04584694f, 0.00620307f, 0.04332844f, 0.04044209f, 0.02059507f, 0.02368674f, 0.00466120f, -0.01876794f, 
    0.02385528f, -0.04598970f, 0.00177236f, 0.00200522f, 0.04168451f, -0.00828501f, -0.02565554f, 0.03960479f, 
    -0.02908485f, 0.02792716f, -0.01613383f, -0.03194753f, 0.03242958f, -0.03688220f, -0.04340158f, 0.01765044f, 
    -0.04154946f, 0.04469708f, -0.00820933f, -0.00751667f, 0.01515651f, -0.03248574f, -0.01869329f, 0.02036588f, 
    -0.04210941f, -0.02978119f, 0.03975824f, -0.03144318f, 0.02307714f, -0.01405140f, 0.00942497f, -0.06546181f, 
    0.02815472f, -0.06164243f, -0.02651271f, -0.02567469f, -0.01075980f, 0.04227377f, -0.04428966f, 0.02001783f, 
    -0.04955626f, -0.04766032f, -0.02976839f, 0.00386652f, 0.04900097f, -0.03305409f, -0.00270550f, -0.03852426f, 
    -0.05804180f, -0.06702800f, -0.00957334f, -0.06325229f, 0.05257924f, -0.06206802f, -0.04807893f, -0.02689898f, 
    0.04056752f, 0.00052155f, -0.05452259f, -0.03816813f, -0.01985872f, -0.02172971f, -0.01533909f, -0.03100376f, 
    -0.05482927f, -0.00657759f, -0.03613380f, 0.01925788f, 0.01922791f, 0.00791544f, 0.02702013f, -0.06586014f, 
    0.03957199f, -0.00300170f, -0.03224732f, -0.05581299f, -0.05582365f, -0.03397427f, -0.04910995f, 0.05513524f, 
    0.01642372f, 0.02469757f, -0.00249049f, -0.02789526f, -0.05171647f, 0.00769897f, 0.03773082f, 0.01840884f, 
    -0.13876645f, 0.01073242f, 0.07863436f, 0.02162083f, -0.30749929f, 0.17584057f, -0.01674310f, 0.08426499f, 
    0.00717962f, -0.02590829f, 0.22642684f, 0.15800220f, -0.01380986f, 0.05088176f, 0.20011550f, -0.26775578f, 
    0.20596717f, -0.12470283f, 0.02302515f, 0.10724915f, 0.02912860f, 0.02910274f, 0.09633107f, -0.04793536f, 
    0.10069625f, 0.07701962f, -0.17021844f, 0.02141324f, 0.03018688f, 0.09382553f, -0.00314640f, 0.13781083f, 
    -0.06147225f, -0.08014175f, 0.02842854f, 0.07396049f, 0.00172138f, 0.12560953f, -0.02545875f, -0.07717548f, 
    0.13326700f, -0.05615644f, -0.07238597f, 0.00841928f, -0.14707606f, -0.02759336f, 0.04440504f, 0.02952231f, 
    0.07635209f, 0.22367270f, -0.10094782f, -0.06178648f, 0.14961392f, 0.13440919f, -0.11336026f, -0.14037532f, 
    -0.00185526f, 0.15153007f, 0.14446799f, -0.03028879f, -0.18296833f, -0.00514453f, 0.10235900f, -0.26066592f, 
    0.25329792f, 0.15761222f, 0.00703729f, -0.11973729f, 0.03215550f, -0.08859527f, 0.24755913f, 0.22098593f, 
    0.15883717f, 0.35191071f, -0.00277247f, 0.11295091f, -0.02220817f, -0.03731825f, 0.04674301f, 0.05079511f, 
    -0.15908828f, -0.27579942f, -0.05742637f, 0.00184518f, -0.02362558f, -0.06279418f, -0.10654964f, -0.07160265f, 
    -0.01075961f, -0.07801081f, -0.06085289f, 0.12373696f, 0.27365977f, -0.03916817f, -0.07792018f, -0.05618635f, 
    0.02397480f, -0.03483624f, 0.05828962f, -0.11269141f, 0.03932092f, 0.10644054f, 0.17971675f, -0.04749590f, 
    -0.15721361f, 0.10058451f, 0.01333818f, 0.02409174f, 0.17078514f, 0.08222969f, 0.06775264f, -0.05006723f, 
    -0.07520526f, 0.02706837f, 0.22622058f, 0.10052460f, 0.05644090f, 0.06538092f, 0.24173290f, -0.01590254f, 
    0.01801060f, -0.07848575f, -0.14756846f, 0.03313555f, 0.12869480f, 0.02627952f, -0.03538899f, -0.14052825f, 
    -0.19608250f, 0.14388034f, 0.02222267f, 0.17955957f, -0.02446366f, -0.12380386f, -0.12382799f, -0.10129233f, 
    0.18093000f, -0.00381411f, 0.02954898f, 0.06494676f, 0.18104409f, -0.01105574f, -0.16185056f, -0.31763694f, 
    0.13267615f, 0.12059873f, -0.14399666f, 0.04045539f, 0.05103055f, -0.11826991f, 0.01877593f, 0.16517761f, 
    -0.01234019f, 0.07519434f, 0.38104483f, -0.04405954f, -0.00349735f, 0.04277181f, 0.12321234f, 0.00899885f, 
    0.14079249f, -0.10997421f, -0.20229319f, 0.12842067f, 0.17245470f, -0.17889331f, -0.02752783f, -0.11555187f, 
    -0.06770324f, -0.20931043f, -0.11338256f, -0.27975291f, -0.01745348f, 0.06521478f, 0.07825873f, 0.06769464f, 
    0.08195014f, -0.05476134f, 0.00607507f, -0.01176649f, -0.03825318f, 0.23625529f, -0.05260786f, 0.11725298f, 
    -0.09738848f, -0.01060928f, -0.14389144f, -0.12953149f, 0.06440332f, -0.05818915f, -0.06448949f, -0.02917640f, 
    -0.09663920f, -0.05804029f, -0.12336510f, -0.01537734f, -0.10987772f, 0.07778705f, 0.14053459f, 0.18165509f, 
    -0.18505447f, 0.10511997f, -0.07703721f, -0.08770718f, 0.06161686f, 0.05449454f, -0.00473308f, 0.19349352f, 
    0.09121971f, -0.01936513f, -0.08556655f, 0.15653257f, 0.24685979f, 0.06293663f, -0.18125044f, 0.08529873f, 
    0.04405940f, 0.10784558f, -0.00999213f, 0.02040646f, -0.00690131f, -0.11300557f, -0.06335960f, 0.04688520f, 
    0.05217155f, -0.00280705f, -0.04620769f, -0.00904822f, -0.00893459f, -0.21738322f, -0.06762680f, 0.11346892f, 
    -0.05750431f, 0.07261541f, -0.10177696f, 0.18433866f, 0.20606014f, -0.03390786f, 0.09242401f, -0.07372939f, 
    -0.09512299f, 0.10295615f, -0.04516805f, -0.15909778f, 0.00002713f, -0.10446482f, -0.03861935f, 0.12839982f, 
    0.04146357f, -0.40874219f, -0.23787569f, -0.20926383f, 0.02852634f, -0.24044694f, -0.16472986f, -0.16601284f, 
    -0.12542184f, -0.08582866f, -0.03491506f, -0.04630041f, -0.01134212f, 0.12223714f, 0.18239196f, -0.05454990f, 
    0.05351496f, 0.16426849f, -0.05121025f, 0.02613128f, 0.13680710f, 0.07358322f, -0.39445224f, 0.12936798f, 
    -0.02289675f, 0.00518016f, 0.09360077f, -0.03045070f, 0.10758446f, 0.05226808f, 0.14965992f, 0.17582600f, 
    0.06475323f, 0.05528397f, 0.12550394f, 0.13893931f, 0.06203143f, -0.04912955f, 0.07004951f, -0.17123771f, 
    0.20447886f, 0.22925584f, 0.03577944f, -0.02849631f, 0.13298342f, 0.04197539f, 0.10780133f, 0.15265542f, 
    -0.02681169f, 0.06177859f, -0.11807173f, 0.19765480f, 0.28895140f, 0.01778754f, -0.02730950f, 0.07114130f, 
    -0.10178120f, 0.08829198f, 0.26627320f, -0.07944681f, 0.04054388f, 0.03004822f, -0.03481314f, -0.03838527f, 
    -0.04496296f, 0.04333338f, -0.05573289f, 0.07521228f, 0.04192660f, 0.06391461f, 0.03085301f, 0.08315876f, 
    -0.01900672f, 0.11579697f, -0.09837137f, -0.02475140f, -0.25486588f, 0.02018872f, 0.01889056f, 0.07542795f, 
    0.07478682f, -0.11258005f, 0.14214286f, -0.00035968f, -0.04024071f, -0.18967505f, -0.01526717f, 0.03031785f, 
    0.03131232f, 0.08006558f, 0.11741847f, 0.02169979f, -0.15139796f, 0.02815058f, 0.17464182f, 0.01434187f, 
    0.04195158f, 0.08600876f, 0.07372934f, -0.01719757f, 0.08315882f, 0.07791001f, -0.00856961f, -0.11181296f, 
    -0.12153634f, 0.21061964f, -0.00747485f, -0.05740039f, 0.16548583f, 0.04082756f, 0.04959505f, 0.04394290f, 
    -0.22920938f, -0.24459836f, -0.21001260f, 0.02524580f, -0.09407859f, -0.14010455f, 0.04557029f, -0.15205349f, 
    0.03224693f, 0.00457246f, -0.02869355f, 0.08857242f, 0.03734898f, 0.00982432f, 0.00055063f, 0.02513779f, 
    -0.04549332f, 0.07264651f, -0.19344182f, -0.10494612f, -0.03951747f, -0.10812752f, 0.09115063f, -0.02868078f, 
    -0.02033865f, -0.01467812f, 0.17908807f, -0.02198594f, 0.05010815f, 0.07195362f, -0.01901447f, -0.08080816f, 
    0.11092204f, 0.08849076f, -0.03607913f, -0.01227644f, 0.01234763f, -0.15179746f, 0.15494612f, -0.13525623f, 
    0.08773320f, -0.01045020f, 0.03560884f, 0.00422279f, -0.12588421f, 0.33359602f, -0.01645201f, -0.16946413f, 
    -0.06603910f, 0.01969170f, 0.03399098f, -0.03713804f, -0.02259945f, 0.03599348f, 0.02074892f, -0.10134198f, 
    0.02127520f, -0.05372636f, -0.04458844f, -0.05538999f, -0.03678256f, 0.09064445f, 0.04221465f, 0.09573791f, 
    0.20150431f, -0.27871656f, -0.16221675f, 0.20277770f, -0.27072263f, -0.02149418f, 0.04778438f, 0.04340170f, 
    -0.13883907f, -0.22369365f, 0.03690295f, 0.01443944f, 0.05701540f, -0.03143165f, 0.06861040f, 0.05618942f, 
    -0.08310503f, 0.20135300f, -0.19896328f, -0.24738652f, -0.01977095f, -0.11741962f, -0.06734479f, -0.11163975f, 
    -0.18538432f, -0.02476670f, 0.17743646f, 0.17616758f, 0.01729917f, 0.08996772f, 0.03109425f, 0.01319841f, 
    -0.22967675f, 0.18515408f, 0.09761328f, 0.40782025f, -0.13862349f, -0.04916077f, -0.11887183f, 0.07116435f, 
    0.13399492f, -0.00505602f, 0.12163969f, -0.06940548f, 0.22164623f, 0.10718216f, 0.10423061f, -0.10585614f, 
    -0.08757608f, -0.16261397f, -0.30869594f, 0.00992861f, -0.06811986f, -0.10850132f, -0.01631040f, -0.21525228f, 
    -0.00279168f, -0.00239867f, 0.09852741f, 0.07421338f, -0.09990380f, 0.14513630f, 0.10525780f, -0.18165000f, 
    -0.12219111f, -0.05218088f, 0.00357107f, -0.10392509f, -0.00468746f, -0.08327801f, -0.00972555f, 0.06041219f, 
    0.22211747f, -0.03456443f, -0.13647953f, 0.10984816f, 0.02828903f, 0.14515844f, 0.01313439f, -0.19424394f, 
    0.18612671f, 0.01909941f, -0.11883558f, -0.13442196f, -0.05569357f, -0.06657214f, 0.02104457f, -0.05042614f, 
    0.01485359f, -0.11295106f, 0.09888642f, -0.02805005f, -0.08343678f, 0.17206696f, -0.06530622f, 0.15276305f, 
    -0.07336749f, -0.18003985f, 0.10630360f, -0.03016209f, -0.05326210f, 0.01176797f, 0.00891316f, 0.08998460f, 
    0.00610030f, 0.07144047f, 0.25717932f, -0.19705205f, 0.08504635f, -0.02037700f, 0.03743176f, 0.05919604f, 
    -0.06031260f, 0.02896920f, -0.07373627f, 0.11660324f, -0.41751191f, -0.07519980f, 0.15672289f, -0.05128854f, 
    0.11952933f, -0.00359352f, -0.03100031f, -0.00698350f, 0.06632712f, -0.63423622f, -0.34177902f, -0.08003350f, 
    -0.32797953f, 0.04611095f, -0.11489726f, 0.05328678f, 0.06148237f, -0.00779234f, 0.26319808f, -0.05598383f, 
    0.13947614f, 0.08129237f, 0.07240283f, 0.01210707f, 0.04308080f, -0.00394282f, -0.05915646f, -0.12668335f, 
    -0.22881305f, -0.38759723f, -0.20753142f, 0.03082709f, 0.12364309f, 0.17157586f, -0.01837225f, -0.00950107f, 
    0.15009552f, 0.30199841f, -0.14236565f, 0.01734546f, -0.03737668f, 0.10515901f, 0.05552411f, 0.14823301f, 
    -0.04269359f, -0.03673385f, -0.06846590f, 0.03114255f, 0.14873727f, -0.07267730f, 0.11998583f, -0.01430727f, 
    0.06130572f, 0.07708478f, 0.12436670f, -0.16582836f, 0.00704162f, 0.03001686f, 0.18656467f, -0.04130073f, 
    0.01546183f, 0.02220753f, -0.00613182f, 0.14359613f, -0.05488843f, -0.12984210f, 0.10181758f, 0.02124812f, 
    0.11673534f, 0.10906901f, -0.12284588f, -0.07381532f, -0.07799757f, -0.32538566f, -0.41703865f, 0.03429523f, 
    0.06193206f, 0.01587512f, 0.15111601f, -0.02412141f, -0.01826435f, -0.16765586f, -0.10697751f, -0.02903132f, 
    0.07408710f, -0.00585656f, -0.03381909f, 0.06845575f, -0.25407156f, -0.17586224f, 0.10209569f, -0.05439904f, 
    0.02383029f, 0.05838255f, -0.02875815f, 0.08355926f, 0.15348855f, -0.09829919f, 0.01133222f, -0.15740582f, 
    -0.36687690f, -0.18067691f, -0.00822659f, -0.05340397f, 0.07686316f, 0.19014943f, 0.16800776f, -0.01074477f, 
    -0.16847485f, -0.06681419f, -0.10012446f, -0.08109614f, -0.12655035f, -0.09172976f, -0.06492595f, -0.04450745f, 
    0.00122543f, -0.14527978f, -0.16833121f, 0.13874555f, 0.07743959f, 0.03197674f, 0.04267254f, -0.11916801f, 
    0.02454099f, 0.08940356f, -0.27010286f, 0.03964639f, -0.14557672f, 0.06424759f, 0.01240591f, 0.00587557f, 
    0.01152879f, 0.08727034f, 0.16481481f, -0.07765117f, 0.03612311f, 0.06820049f, -0.12845434f, -0.10026324f, 
    -0.01552982f, 0.06168313f, -0.02042066f, -0.02071457f, -0.17113747f, -0.11786310f, 0.23101977f, -0.11839253f, 
    0.13655290f, 0.07833607f, 0.00666911f, -0.02406761f, 0.01689204f, 0.24497154f, -0.11444753f, -0.19217014f, 
    -0.05986498f, -0.00337118f, 0.07459074f, -0.03601017f, 0.04434232f, -0.07155096f, 0.04212783f, -0.13952376f, 
    -0.18901895f, -0.18542281f, -0.10374827f, -0.02960745f, 0.01936160f, 0.11461457f, 0.11420109f, -0.05565548f, 
    -0.04354372f, -0.19441316f, -0.05542769f, -0.09886532f, 0.04325365f, 0.02589395f, -0.07785122f, 0.16163382f, 
    -0.37301850f, -0.44280335f, 0.23365235f, -0.07270377f, 0.05454906f, -0.13884117f, 0.08847748f, 0.04517975f, 
    -0.01102494f, -0.03500178f, -0.08049952f, -0.23671925f, -0.07462803f, -0.08392533f, 0.06987597f, -0.09278207f, 
    -0.12143768f, 0.01119682f, -0.01359154f, 0.11224893f, 0.05621164f, 0.03787784f, -0.05633528f, 0.06990447f, 
    0.07569674f, 0.10788872f, 0.30436692f, 0.37190196f, -0.24721771f, -0.32002324f, 0.05536772f, 0.04005465f, 
    0.04751287f, 0.08453037f, -0.03674148f, -0.15453617f, 0.06122315f, -0.05274923f, 0.00180961f, -0.07517460f, 
    -0.14728157f, -0.10826235f, -0.04047019f, 0.01295998f, 0.04905907f, -0.05166661f, 0.04136417f, -0.02747484f, 
    -0.01445310f, -0.05247064f, -0.09780195f, 0.06869721f, -0.00958186f, 0.16923416f, -0.07732314f, -0.14249307f, 
    -0.11864841f, 0.03387064f, -0.04305628f, -0.15711685f, -0.01367490f, -0.00477297f, 0.08285737f, 0.31855401f, 
    -0.13335527f, -0.26071623f, 0.02925245f, 0.03988598f, -0.10964797f, -0.03139313f, -0.16038188f, -0.10599485f, 
    -0.01711280f, -0.02092800f, -0.09632601f, -0.02227329f, -0.04589275f, -0.02145690f, 0.00049223f, 0.01694679f, 
    -0.09524459f, 0.02773580f, 0.16581500f, 0.17581853f, -0.06746493f, 0.01421781f, 0.00737601f, 0.04791214f, 
    -0.02845474f, -0.01965879f, 0.00677934f, -0.03241694f, -0.24916865f, 0.08754025f, 0.16606762f, 0.07784861f, 
    0.04674499f, 0.01900570f, 0.20967494f, -0.00416198f, -0.01199329f, 0.04799717f, 0.06070745f, 0.06686666f, 
    0.07221879f, -0.02671663f, -0.07402545f, 0.24651581f, -0.25973418f, 0.23393659f, 0.32632580f, -0.10057989f, 
    0.01939523f, -0.00897330f, -0.01542691f, 0.01731377f, 0.09460948f, -0.10923076f, -0.38064703f, -0.17049749f, 
    -0.03700540f, 0.09997071f, -0.19674163f, -0.06965309f, -0.14729282f, -0.11951901f, 0.27596396f, -0.09410644f, 
    0.05192802f, 0.15493196f, -0.02485086f, 0.21249151f, 0.03972100f, 0.14363071f, -0.04880553f, -0.11624524f, 
    -0.30049899f, -0.53591770f, -0.19010347f, 0.00850176f, -0.15092590f, 0.06588279f, 0.00291953f, 0.12682933f, 
    -0.49254882f, 0.12773237f, 0.06849845f, 0.20786346f, -0.07788495f, 0.00617758f, -0.08936027f, 0.01539200f, 
    -0.01023791f, 0.10436715f, 0.26398331f, 0.18434745f, -0.07863529f, -0.24607798f, 0.11131133f, -0.01636170f, 
    0.24459197f, -0.20419979f, -0.14061584f, 0.06185787f, -0.18020307f, 0.15089102f, 0.09240503f, -0.06459519f, 
    0.07171482f, 0.03074656f, -0.06881009f, -0.08009309f, 0.05935044f, 0.12475743f, 0.02067450f, 0.03633052f, 
    -0.02454427f, -0.05591678f, 0.07416859f, 0.03767873f, -0.10668651f, 0.19167940f, 0.22229345f, -0.06051263f, 
    0.04207226f, -0.20719682f, -0.04247067f, 0.06459120f, 0.12562788f, -0.13434568f, -0.10679837f, 0.03769119f, 
    -0.04072174f, 0.13018714f, 0.03840128f, -0.01900424f, 0.02385802f, 0.06611892f, -0.09990371f, -0.39739677f, 
    -0.03949108f, 0.12308806f, 0.07721683f, 0.02027243f, -0.02529456f, -0.08384109f, -0.03138380f, -0.05552488f, 
    0.24397710f, 0.21097526f, 0.20011140f, -0.11691347f, -0.16955902f, 0.02836388f, -0.21317901f, 0.01380037f, 
    -0.12856823f, 0.42327544f, 0.23467791f, 0.05603568f, -0.10158706f, -0.03572316f, 0.00356906f, 0.00190102f, 
    0.06549127f, 0.07793716f, 0.30465549f, -0.04096446f, -0.00906519f, -0.11562663f, 0.02214076f, 0.01898686f, 
    0.00985543f, 0.11196794f, 0.00988061f, -0.30220085f, 0.40189865f, -0.23653139f, -0.20127079f, 0.11308521f, 
    -0.04367244f, -0.08841284f, 0.08738587f, -0.20661187f, -0.31429875f, 0.24895182f, 0.05414509f, 0.02212617f, 
    -0.11421601f, 0.05380578f, -0.09180551f, -0.06728341f, -0.01599937f, 0.22977895f, -0.06179319f, -0.02635636f, 
    -0.21413709f, 0.01142742f, 0.04049516f, 0.08521969f, 0.05842250f, -0.38002494f, 0.08950565f, -0.16353898f, 
    -0.09838198f, 0.05664599f, -0.04069123f, -0.04093035f, 0.08331033f, -0.02527817f, -0.43978578f, -0.33880469f, 
    0.16829441f, 0.00954721f, 0.15459131f, -0.10721122f, -0.05288690f, 0.02108872f, 0.05242857f, -0.65120113f, 
    0.10358916f, -0.16331029f, -0.13100258f, 0.02400406f, -0.00787473f, -0.01500258f, 0.07846829f, 0.01629378f, 
    0.11778644f, -0.04634636f, 0.17765535f, 0.10030074f, 0.06678472f, -0.12736541f, 0.05121804f, 0.08514722f, 
    0.05881012f, 0.05104137f, 0.28988498f, 0.33910725f, -0.10532670f, -0.27144468f, -0.11136352f, 0.05597211f, 
    0.08417132f, -0.09949458f, -0.52985322f, 0.04358085f, -0.08455939f, 0.13865858f, -0.14402649f, -0.15593557f, 
    0.05253311f, 0.03423951f, 0.13962315f, -0.03699722f, 0.14293927f, 0.17513211f, 0.00640887f, 0.12480578f, 
    0.06999580f, 0.04930723f, -0.07011501f, -0.02080964f, -0.29235941f, 0.07927068f, 0.04662680f, 0.16475525f, 
    -0.06484786f, -0.22570595f, -0.00296926f, -0.05886092f, 0.03553669f, 0.24681430f, -0.04957769f, 0.11284867f, 
    0.06153932f, 0.11750734f, 0.08153770f, 0.06458467f, -0.06088747f, 0.06794905f, 0.05104686f, 0.06317100f, 
    0.10224641f, 0.02563247f, -0.05302668f, -0.11886513f, 0.06549455f, 0.02309027f, 0.03433118f, -0.22498497f, 
    -0.33591893f, 0.24310468f, 0.11475044f, 0.05183448f, 0.26090643f, 0.12571618f, -0.09024253f, -0.20481822f, 
    -0.02570790f, -0.00707663f, -0.05777944f, -0.11059013f, -0.03301388f, 0.09952497f, 0.04787101f, 0.03964550f, 
    -0.00687276f, -0.01884690f, 0.21887062f, -0.02012337f, -0.05748689f, -0.22095217f, -0.07911275f, 0.12535672f, 
    -0.15434170f, -0.02441011f, -0.05570610f, 0.13611600f, -0.00350677f, -0.09865487f, -0.00306277f, -0.04218638f, 
    0.00584299f, 0.11344565f, -0.03015970f, -0.02521445f, 0.17808865f, -0.10556646f, 0.07757220f, -0.03060762f, 
    -0.09901162f, -0.07174681f, -0.04666417f, -0.08556833f, -0.16073906f, 0.19343947f, 0.02122236f, -0.00538426f, 
    -0.03193250f, -0.05525044f, 0.04616598f, -0.09265567f, 0.13664211f, -0.26669139f, -0.30120736f, 0.06123086f, 
    0.11738293f, 0.09632035f, -0.18553913f, 0.05204692f, 0.07805771f, 0.05590105f, -0.30429241f, 0.11506364f, 
    -0.03345531f, 0.07133132f, -0.11762839f, -0.02644821f, -0.14561255f, 0.08439618f, 0.01922425f, -0.24961200f, 
    -0.02529251f, 0.22918011f, -0.03191930f, 0.20524640f, -0.09205131f, -0.15516637f, -0.01951249f, 0.05094704f, 
    -0.02366270f, -0.05032492f, -0.03195086f, 0.14717697f, -0.02080274f, 0.09170627f, 0.07870191f, 0.14434911f, 
    -0.08284818f, -0.18903545f, 0.05998833f, 0.17896646f, 0.01274607f, 0.09809064f, -0.05883434f, -0.03815418f, 
    0.02545851f, 0.16846712f, -0.03202123f, 0.10971292f, -0.34274596f, -0.02703814f, -0.10289314f, -0.14104474f, 
    0.02706871f, 0.10327109f, 0.06537312f, 0.04671624f, -0.00361649f, -0.01535046f, -0.07360841f, -0.04247162f, 
    0.00525805f, -0.06221465f, 0.03807889f, -0.03712793f, 0.02994359f, 0.08873931f, 0.35536247f, 0.05797902f, 
    -0.06535058f, 0.07613710f, 0.04337041f, 0.01943029f, -0.14305004f, -0.10173502f, 0.00115707f, 0.03311102f, 
    -0.06884518f, 0.00083008f, 0.10602733f, 0.05159326f, 0.02759627f, -0.16672370f, 0.35746455f, -0.11973705f, 
    0.22977722f, -0.08822547f, -0.01246666f, 0.14999092f, 0.08260552f, 0.08992258f, 0.00131536f, -0.37310410f, 
    -0.23629527f, 0.05832553f, 0.05762046f, -0.00595895f, -0.16472708f, -0.14391969f, 0.07716416f, -0.05261048f, 
    0.19127138f, -0.05249123f, -0.04108414f, 0.08062977f, -0.15897757f, -0.16447510f, -0.04644350f, 0.03976500f, 
    0.13019794f, -0.12948568f, -0.07544685f, 0.15925524f, -0.06637192f, 0.14254823f, -0.14914675f, 0.14770840f, 
    -0.05335662f, 0.05518682f, -0.12429300f, 0.11450639f, 0.05492393f, -0.05729626f, -0.05217979f, -0.11489797f, 
    -0.11988380f, 0.12399703f, 0.04443778f, -0.04374508f, 0.03830460f, -0.09017813f, 0.10147427f, 0.05218536f, 
    -0.05486476f, 0.12125114f, 0.13679513f, -0.13104343f, 0.30269742f, -0.09923672f, 0.02185079f, -0.01018625f, 
    0.07092557f, 0.06624436f, 0.00277264f, -0.11809374f, -0.03248772f, 0.21604598f, -0.04624290f, -0.20303266f, 
    -0.09449580f, 0.01661073f, -0.05595665f, -0.02411849f, 0.07657059f, -0.07221446f, -0.08094924f, 0.10239705f, 
    0.02263588f, 0.01185322f, -0.02643454f, 0.05370475f, -0.12471415f, 0.05609745f, 0.03995703f, 0.34021690f, 
    0.01079252f, 0.21942414f, -0.02406247f, -0.00053722f, -0.17682888f, -0.00931666f, -0.17688127f, 0.09537463f, 
    -0.10400464f, 0.00291311f, -0.11830381f, 0.17953962f, 0.08205296f, 0.03641963f, 0.13106985f, 0.01548432f, 
    0.03230193f, 0.22194271f, 0.10488030f, 0.21220833f, -0.02230298f, -0.04671705f, -0.10300679f, 0.01226988f, 
    0.00705041f, 0.21420543f, 0.12405831f, 0.05257199f, -0.08308358f, 0.10079283f, 0.02796244f, -0.03339932f, 
    0.06573822f, -0.04826535f, 0.05429896f, -0.09585963f, -0.19919132f, -0.00561809f, -0.05921618f, -0.13876830f, 
    -0.26372772f, -0.02187158f, -0.01584750f, -0.00544444f, -0.26019537f, 0.01419189f, -0.28303155f, -0.00139641f, 
    -0.03469044f, -0.00175367f, -0.10988107f, 0.08089817f, 0.12618189f, 0.03999332f, -0.14536020f, -0.18354206f, 
    -0.05911389f, 0.03028987f, -0.25668761f, -0.13789450f, -0.03536988f, 0.10637044f, 0.07153548f, 0.01452002f, 
    -0.00009720f, 0.11894659f, -0.02125851f, -0.02298681f, 0.05542653f, 0.02947751f, 0.06615792f, 0.27012351f, 
    -0.27047905f, -0.39298001f, -0.02383940f, -0.14848825f, 0.00308070f, 0.01484851f, 0.02907284f, -0.05236772f, 
    0.07655633f, 0.21407023f, 0.14759390f, -0.22848520f, -0.20929706f, -0.11531585f, -0.01104913f, 0.10563432f, 
    0.04788976f, -0.09115403f, -0.09058882f, 0.03118313f, 0.07386893f, 0.14128584f, -0.05368837f, -0.16639197f, 
    -0.09807841f, -0.01998880f, -0.13478728f, -0.10245039f, -0.02542908f, 0.05533824f, -0.10230193f, -0.06058030f, 
    -0.19392730f, 0.19813041f, 0.18404892f, -0.07851144f, 0.16048688f, -0.14793761f, -0.01648743f, -0.03495254f, 
    0.00636661f, -0.05828185f, -0.02806343f, 0.04029003f, -0.43140915f, -0.03030563f, -0.19373871f, -0.02394922f, 
    0.16296102f, 0.11354943f, -0.04238705f, -0.01410152f, 0.16850178f, 0.17522314f, -0.22010882f, -0.03733847f, 
    -0.02290855f, 0.02311119f, -0.13546583f, -0.06064647f, -0.02534857f, 0.02639906f, 0.04916368f, 0.15918697f, 
    0.20439181f, -0.04282001f, -0.05572847f, -0.11500676f, 0.05829317f, 0.02671408f, -0.10907879f, 0.38219556f, 
    0.10447961f, 0.20622130f, -0.10591900f, -0.06268900f, 0.09547102f, -0.07197709f, 0.02356703f, 0.09049945f, 
    0.19582172f, -0.04382414f, 0.01405308f, 0.09200732f, 0.10506403f, 0.11579835f, 0.18590346f, -0.07078128f, 
    0.26635060f, 0.28909069f, 0.06381486f, 0.03883047f, 0.04984647f, 0.24041677f, -0.05887471f, 0.04826503f, 
    0.09107398f, 0.00675751f, -0.00010326f, 0.07881799f, -0.05987715f, 0.19965330f, -0.06479363f, -0.02862979f, 
    -0.05288231f, 0.01282195f, 0.13089128f, 0.03134141f, 0.04231630f, 0.09276960f, 0.04677388f, 0.02517423f, 
    0.11011387f, 0.17607234f, 0.09234665f, 0.05964310f, -0.03458846f, -0.03728972f, 0.24596199f, 0.18058911f, 
    -0.01512555f, 0.10743122f, 0.20450157f, -0.05509272f, -0.16012923f, -0.00347741f, 0.22888756f, 0.21733646f, 
    0.02519201f, -0.09597792f, -0.01920850f, 0.13378465f, 0.14044470f, 0.01123125f, 0.22560070f, 0.07144641f, 
    0.13203195f, -0.04229691f, 0.24308382f, 0.08804949f, 0.19835733f, -0.05235770f, 0.06861514f, 0.21000403f, 
    -0.07468881f, -0.06992609f, -0.05621387f, 0.10644832f, -0.05484625f, -0.14660951f, -0.21089552f, -0.00251718f, 
    0.00348005f, -0.20882736f, -0.10031071f, 0.11996785f, 0.12134424f, -0.09181711f, 0.18216938f, 0.18440504f, 
    -0.01053370f, -0.09233613f, -0.13207573f, -0.16030309f, 0.10252793f, 0.01287331f, 0.03261519f, -0.00589430f, 
    -0.01546931f, -0.05573694f, 0.04017499f, 0.12188918f, -0.18564305f, 0.04564625f, -0.04253015f, 0.10768881f, 
    -0.33830306f, 0.21095090f, -0.03299008f, -0.01663709f, -0.01836626f, -0.11225554f, 0.12094023f, 0.03689028f, 
    -0.05652834f, 0.05758776f, 0.28603172f, 0.18466716f, 0.27668595f, -0.03318936f, 0.19273941f, 0.09174997f, 
    -0.10590141f, 0.03708330f, 0.00504551f, 0.15979199f, 0.10809392f, 0.09199163f, -0.01500615f, 0.10665674f, 
    0.06313102f, -0.01913432f, 0.03089533f, 0.08392305f, 0.05090927f, 0.17848168f, 0.03074292f, 0.00455034f, 
    0.10802551f, -0.00023084f, 0.02623807f, 0.08948596f, 0.03863471f, -0.45916510f, -0.18924879f, 0.09625081f, 
    -0.19399138f, 0.19368440f, -0.02011227f, 0.06679305f, -0.06299607f, -0.10377035f, -0.04793629f, -0.26420778f, 
    0.01663112f, -0.02002306f, 0.15525569f, -0.07118997f, -0.00995387f, -0.02818460f, 0.07130533f, 0.07451887f, 
    -0.04106098f, -0.14338998f, -0.44393110f, -0.24041824f, 0.21970655f, -0.04738051f, 0.04843373f, -0.04120110f, 
    -0.14336503f, -0.18465887f, 0.01298586f, -0.22885397f, 0.02160305f, -0.07784042f, 0.00559688f, -0.03400318f, 
    0.05017992f, 0.01713756f, -0.17264554f, -0.02820311f, -0.14966263f, -0.07273352f, 0.07218408f, 0.05488793f, 
    -0.12543416f, 0.01396139f, -0.16656314f, -0.03491244f, -0.16726395f, -0.09882083f, -0.12801255f, 0.00302946f, 
    0.09725947f, -0.20196703f, -0.02459164f, -0.15169942f, -0.07407595f, -0.13000485f, -0.02879405f, -0.24009904f, 
    0.23487478f, 0.19099998f, 0.17407122f, -0.05909863f, -0.05855439f, -0.00512556f, 0.00296109f, -0.18038277f, 
    0.10969388f, -0.01235112f, 0.00860417f, 0.00031066f, 0.01250673f, -0.03350231f, 0.10178214f, 0.07054668f, 
    0.01252769f, -0.12114170f, -0.14145203f, 0.09747761f, 0.01871365f, -0.00821748f, 0.27065197f, 0.07872771f, 
    -0.13954148f, -0.11141179f, -0.30947635f, 0.10256135f, -0.04607346f, -0.09479310f, -0.15599951f, -0.01899409f, 
    0.02338301f, 0.01661212f, 0.04289771f, 0.14364548f, -0.07611076f, -0.34343275f, -0.11376318f, -0.14475587f, 
    0.07592969f, 0.07937680f, -0.02053564f, -0.01744255f, 0.03074625f, 0.01372245f, 0.16261891f, 0.15377305f, 
    -0.08126928f, 0.01808159f, 0.05110825f, -0.02279066f, -0.23073737f, 0.03209545f, -0.10493201f, 0.08308579f, 
    0.04780961f, 0.04245622f, -0.11675311f, -0.14810418f, -0.00768821f, 0.23072082f, 0.05222955f, 0.15748809f, 
    0.04276638f, 0.07787883f, -0.08383019f, -0.21626827f, -0.12963445f, 0.04047809f, 0.01892033f, -0.03807914f, 
    0.10466073f, -0.17199236f, 0.09649664f, 0.17277394f, 0.31048375f, 0.22193497f, -0.02439445f, 0.04562449f, 
    -0.01128158f, 0.18469983f, 0.13130844f, 0.06413756f, -0.02803996f, 0.12766176f, 0.00012752f, -0.22606829f, 
    -0.06474059f, 0.27439356f, 0.21655886f, -0.11626744f, 0.06910092f, 0.09558069f, -0.20756994f, -0.38590470f, 
    -0.11615086f, -0.11894278f, 0.03408995f, -0.00102283f, -0.02264264f, -0.01471056f, -0.00473989f, 0.14774580f, 
    0.07166909f, -0.04384349f, -0.25040388f, 0.02794721f, 0.14355500f, 0.06686220f, 0.03903382f, 0.07535439f, 
    0.21702102f, 0.02277076f, 0.04906598f, -0.21608432f, 0.04819707f, 0.06230203f, 0.00732822f, -0.14741193f, 
    -0.00337082f, 0.10968646f, 0.03289913f, -0.05690781f, -0.22835460f, -0.05416409f, -0.02345045f, -0.05762262f, 
    -0.11979084f, 0.07563525f, 0.07737190f, 0.18534841f, -0.07618779f, 0.02496026f, 0.01879302f, -0.02042238f, 
    -0.01114161f, -0.11179198f, 0.03637726f, 0.11871957f, -0.02887216f, -0.07196733f, -0.25586075f, -0.14564557f, 
    -0.06068471f, -0.09029537f, -0.03494334f, -0.01904970f, 0.00221377f, 0.02918514f, -0.20229413f, -0.14859042f, 
    -0.50980121f, 0.00350819f, 0.02988503f, 0.11803443f, 0.03597425f, -0.04951658f, 0.01142685f, -0.02640667f, 
    -0.36721656f, 0.16313432f, -0.14959221f, -0.30638954f, -0.20947120f, 0.05073523f, 0.15051639f, -0.02515234f, 
    0.08377487f, 0.19300173f, 0.23607448f, 0.01942887f, 0.06325728f, -0.00640744f, 0.02774420f, -0.07093509f, 
    0.19930072f, 0.07129359f, 0.09915375f, -0.33813030f, 0.04382376f, -0.07083015f, -0.16584665f, -0.09710968f, 
    0.10767434f, -0.10872266f, 0.13898399f, -0.01393317f, -0.05552050f, 0.05379301f, 0.00103578f, 0.13946551f, 
    -0.03993842f, 0.00057151f, -0.04526928f, 0.00963040f, -0.30313987f, -0.13595404f, -0.06495057f, -0.08620483f, 
    -0.00169536f, 0.09072725f, 0.03002140f, 0.03107097f, -0.19226854f, 0.01942827f, 0.17324825f, -0.15077668f, 
    0.04961175f, 0.02567753f, -0.04123221f, 0.06774780f, 0.07473478f, -0.44694373f, -0.01642070f, 0.09647805f, 
    -0.05314561f, -0.03820763f, 0.02015849f, -0.00650684f, 0.10243523f, 0.09108986f, 0.01883943f, 0.24802141f, 
    -0.02833508f, -0.13396168f, -0.04511870f, -0.03488584f, 0.21270593f, 0.03664085f, 0.08055774f, -0.71762568f, 
    -0.31062388f, -0.33932239f, 0.03551576f, -0.02562921f, -0.00907288f, 0.08047514f, 0.08039698f, -0.03275260f, 
    0.09546717f, 0.15701428f, 0.18975835f, -0.00633531f, 0.00670780f, 0.03499441f, -0.01793299f, 0.10630724f, 
    -0.05604378f, 0.02340543f, 0.07135160f, 0.13978611f, -0.02665211f, 0.08630134f, -0.16231896f, 0.11400434f, 
    -0.01015101f, 0.11290809f, -0.66306627f, -0.01627704f, -0.00055873f, -0.12267632f, -0.24743563f, -0.05907964f, 
    0.03067658f, -0.00196151f, -0.09228363f, 0.27727094f, -0.48191136f, -0.26969916f, 0.03952958f, -0.09546352f, 
    -0.10771457f, -0.00578380f, 0.10295673f, 0.00123431f, -0.04786209f, 0.49439648f, 0.19093254f, 0.11921590f, 
    -0.14711733f, 0.00463522f, 0.00488875f, -0.07008067f, -0.02429328f, 0.35184383f, 0.13745390f, -0.44181043f, 
    -0.26069415f, -0.22738482f, 0.13811558f, 0.14503488f, 0.05663828f, 0.07571825f, 0.24075824f, 0.20249787f, 
    0.26980108f, -0.03706856f, 0.05626674f, 0.05334489f, 0.03160027f, 0.03100726f, 0.03509838f, -0.19725540f, 
    -0.30783275f, -0.67669410f, -0.29140806f, 0.13581957f, -0.02391304f, 0.05279855f, -0.00807092f, 0.04364412f, 
    0.31714451f, -0.26574263f, -0.29439020f, -0.06639763f, -0.07455547f, -0.08151160f, 0.05363673f, -0.03155906f, 
    0.15627410f, 0.22615546f, 0.05073150f, 0.02268102f, 0.08938253f, 0.06171121f, 0.14502323f, -0.01446762f, 
    0.04213829f, -0.04229568f, 0.18685304f, 0.11310363f, 0.15168433f, -0.00855702f, 0.12148448f, -0.03790066f, 
    -0.01883455f, -0.00042598f, 0.03571922f, 0.35554132f, -0.30374116f, 0.17033254f, -0.09188168f, -0.16672018f, 
    0.00337309f, 0.05688606f, 0.05446495f, -0.10595245f, 0.07009406f, -0.26237813f, -0.24710774f, 0.03323013f, 
    0.10706317f, 0.01951691f, 0.04684552f, -0.01556904f, -0.04969825f, -0.20159331f, 0.23698257f, 0.16723874f, 
    0.00374048f, -0.17486127f, -0.15538344f, 0.09932583f, 0.11552268f, 0.13841976f, -0.25699607f, -0.37923846f, 
    -0.23311408f, 0.09328881f, -0.05099634f, -0.07606494f, 0.08747806f, 0.10735571f, 0.18591624f, -0.24916942f, 
    -0.12069258f, 0.05583978f, -0.09089600f, 0.12776072f, 0.03399304f, 0.23330928f, 0.08832736f, -0.03157241f, 
    0.14909185f, 0.04056694f, 0.16212940f, -0.04281405f, -0.02954832f, -0.01870200f, -0.04380424f, 0.01235991f, 
    0.01992203f, 0.15355083f, -0.20055018f, -0.04950051f, 0.01227331f, 0.19994083f, -0.04273916f, 0.00948515f, 
    -0.14037615f, -0.04702584f, 0.20710807f, 0.06040180f, 0.07559438f, -0.01623619f, -0.01988205f, 0.02787812f, 
    0.04579717f, -0.05895618f, 0.03846684f, 0.03656656f, -0.05382000f, 0.12089884f, 0.07331730f, 0.04917692f, 
    0.00007899f, -0.03512583f, -0.02601930f, -0.05788137f, -0.28995109f, -0.33308837f, -0.32726806f, 0.07489792f, 
    0.09870104f, -0.09582193f, 0.13964345f, -0.01726151f, -0.05189803f, -0.29589525f, -0.11268148f, 0.08316575f, 
    -0.07818279f, 0.16191059f, -0.14313251f, -0.00623236f, 0.06211716f, -0.21107729f, 0.21080980f, -0.10521448f, 
    0.08573178f, 0.06211772f, 0.04365239f, 0.03590384f, -0.06653962f, -0.07399325f, -0.01095527f, 0.17984416f, 
    -0.22740531f, -0.01639388f, 0.10990893f, 0.06692252f, 0.01826137f, 0.01008757f, 0.15949650f, -0.11017302f, 
    -0.01600243f, 0.10510366f, 0.09924303f, -0.04165030f, -0.23096558f, -0.12454782f, 0.04976241f, 0.04320125f, 
    0.17816778f, 0.09339401f, -0.09114502f, 0.01047315f, 0.00354541f, 0.17841129f, -0.00289943f, -0.07870481f, 
    0.03509393f, 0.06696653f, 0.09602771f, -0.16865177f, -0.46989229f, -0.11567516f, -0.30522111f, 0.02417649f, 
    0.15003043f, -0.13646185f, 0.23809104f, 0.05678195f, 0.02435758f, 0.17925604f, -0.12420630f, 0.14371760f, 
    0.01879591f, 0.14987756f, 0.00564107f, -0.03192191f, -0.08713440f, -0.10382172f, 0.10085933f, -0.19922961f, 
    0.00702033f, -0.02791078f, -0.05225877f, 0.04918019f, 0.03687039f, 0.20466411f, 0.06179022f, 0.18069789f, 
    -0.07691710f, 0.00100109f, 0.14244601f, -0.02870470f, 0.09110088f, -0.12287455f, 0.05860273f, -0.20323268f, 
    -0.17514358f, 0.09906871f, -0.11482505f, 0.02813460f, 0.06562357f, -0.12231688f, 0.12201527f, -0.09814866f, 
    0.06513930f, 0.20691611f, 0.04217077f, 0.12443060f, 0.21957953f, -0.00040336f, 0.05322910f, -0.04876366f, 
    -0.13835214f, -0.10211795f, -0.29229113f, -0.04667309f, 0.03050079f, 0.08614855f, 0.10654824f, -0.24596430f, 
    0.06292335f, 0.15337013f, 0.09474400f, -0.54106581f, 0.20030497f, 0.06812025f, -0.04384736f, 0.03795391f, 
    -0.02209889f, 0.06224414f, 0.19451118f, 0.06370509f, 0.19056110f, 0.00954274f, -0.03206624f, 0.03797247f, 
    0.06295158f, -0.05870205f, 0.09269863f, 0.52431828f, -0.04437272f, 0.26351985f, 0.03810898f, 0.21797961f, 
    0.10106786f, -0.08350010f, 0.12497034f, -0.02417053f, 0.16068110f, 0.07404014f, 0.40017614f, -0.07272851f, 
    0.04774788f, 0.01114239f, -0.12525031f, -0.05231105f, -0.00225766f, -0.06277234f, -0.10436795f, 0.19548595f, 
    0.16628006f, 0.15408091f, 0.14808236f, 0.00294593f, 0.13932323f, 0.27866146f, -0.14250259f, 0.05204150f, 
    -0.32884523f, 0.10841918f, -0.04105692f, -0.10313421f, 0.17775033f, -0.01447575f, 0.03672966f, -0.09041201f, 
    0.06368933f, -0.12548736f, -0.03867549f, -0.27406925f, 0.26099101f, -0.08945438f, -0.05570081f, 0.02137807f, 
    0.07545561f, 0.02838770f, 0.17946337f, 0.06233015f, 0.12567677f, -0.00147426f, -0.00834352f, 0.08726406f, 
    -0.10007761f, -0.05093003f, 0.06023544f, 0.08975635f, -0.05934449f, 0.04611691f, -0.08703032f, 0.00176301f, 
    0.15027264f, -0.04525862f, 0.18965317f, -0.01996851f, -0.04101813f, 0.05066122f, -0.14659214f, 0.02259413f, 
    0.01990841f, 0.03538578f, 0.13770416f, -0.12471775f, -0.06088236f, -0.21288219f, 0.05731773f, -0.00558628f, 
    -0.04183761f, -0.05258933f, -0.12454790f, 0.09147473f, -0.40307140f, 0.07591817f, -0.03441020f, 0.20866384f, 
    0.15077642f, -0.07930493f, -0.15211417f, 0.03610562f, -0.10006963f, -0.27361038f, -0.18758844f, -0.52282536f, 
    -0.16616835f, 0.18824328f, -0.32659596f, 0.09109408f, 0.06838554f, -0.11780997f, 0.25529909f, -0.16871946f, 
    -0.00236646f, -0.00153683f, 0.08740879f, 0.00697141f, 0.01793183f, 0.16070315f, -0.05509368f, -0.50608814f, 
    -0.11674091f, -0.28549764f, -0.04269914f, 0.09556491f, -0.07975673f, -0.01635896f, 0.25900912f, 0.00510069f, 
    -0.03705686f, 0.25163889f, -0.02060658f, 0.08452943f, 0.01135454f, 0.06626369f, 0.14785105f, 0.09845475f, 
    0.06405360f, 0.20816348f, -0.09238756f, 0.06756991f, 0.04922380f, 0.02973919f, 0.03957758f, -0.06075620f, 
    0.04303918f, 0.09747505f, -0.00445264f, 0.05856130f, -0.03029322f, -0.07177538f, 0.02638435f, -0.08944802f, 
    0.05245487f, 0.05011189f, 0.08708764f, 0.09581368f, 0.05278746f, -0.04091854f, 0.11867090f, 0.13629992f, 
    -0.05513599f, 0.16707011f, 0.11802822f, 0.07659516f, -0.05769189f, 0.08134532f, 0.11485157f, 0.13831162f, 
    0.06218085f, -0.12790294f, 0.26706889f, 0.03463136f, -0.09132554f, 0.00189680f, 0.03533372f, -0.09557090f, 
    0.04872362f, -0.08137792f, -0.01154576f, 0.15320253f, 0.06947563f, 0.01854803f, 0.11414292f, 0.08294056f, 
    0.00816100f, -0.00339848f, 0.03792083f, -0.08048959f, 0.16419466f, 0.08833190f, 0.02464593f, 0.09088156f, 
    -0.27624077f, -0.38259405f, 0.08632104f, -0.06774139f, 0.17371944f, -0.09870010f, -0.00682924f, -0.25131372f, 
    -0.17215455f, -0.27555257f, 0.01328477f, -0.01695321f, -0.03043021f, -0.03474372f, 0.06679536f, 0.01573293f, 
    0.08475339f, -0.06918049f, -0.04311273f, -0.01931602f, 0.10666139f, 0.06610595f, 0.06277651f, -0.11547200f, 
    0.06430274f, -0.28829399f, -0.28626931f, -0.25726533f, 0.05936252f, 0.08336031f, -0.16589947f, -0.11477877f, 
    0.16739033f, 0.05581995f, 0.06911768f, -0.06435984f, 0.03556564f, 0.02706237f, -0.11523332f, -0.10520939f, 
    -0.02301867f, 0.05458733f, 0.05025166f, 0.12052807f, 0.00062919f, -0.06820121f, -0.06261235f, 0.10125123f, 
    0.03934056f, 0.14069965f, 0.05913503f, 0.06394931f, 0.02450045f, -0.07037322f, 0.00277606f, -0.29535031f, 
    0.00818985f, -0.00039174f, -0.05065261f, 0.10397285f, 0.18363418f, 0.12059810f, 0.13220391f, 0.15235136f, 
    0.02078645f, -0.01034202f, -0.01822088f, -0.12960993f, 0.26771671f, 0.00853080f, -0.06702108f, 0.13755290f, 
    0.03216815f, -0.25007343f, -0.13745785f, -0.00153838f, -0.16808605f, -0.10985285f, 0.01986369f, -0.03789597f, 
    0.01498500f, -0.22464667f, -0.08921323f, -0.04542916f, -0.00941195f, -0.00310001f, 0.05959757f, -0.00993088f, 
    0.10131576f, -0.18846223f, -0.14622426f, 0.05262439f, -0.11896329f, -0.05137051f, -0.04006335f, -0.13396005f, 
    0.04802962f, 0.06534237f, 0.09564769f, -0.14724435f, -0.18781881f, -0.20379445f, 0.08894830f, -0.00352507f, 
    0.02089240f, 0.17840849f, -0.04682898f, -0.18332231f, -0.05743418f, 0.10150553f, -0.06439923f, 0.00583374f, 
    -0.08253619f, -0.02560740f, -0.06123709f, 0.04800603f, -0.06279867f, -0.04002640f, -0.12451238f, -0.04187522f, 
    -0.12476077f, 0.06637155f, 0.00686931f, 0.15712662f, 0.20591563f, 0.03239914f, -0.12310935f, -0.05529262f, 
    -0.07867678f, -0.00216092f, -0.06904238f, 0.05401540f, 0.09546367f, 0.09479212f, -0.02342638f, -0.09225911f, 
    -0.08484231f, -0.06336197f, 0.01573744f, -0.07532906f, 0.10488509f, -0.11908095f, 0.15234622f, 0.02494605f, 
    -0.16951378f, 0.01607152f, -0.04954070f, -0.04234312f, -0.18070847f, 0.05385783f, 0.01413206f, 0.17311494f, 
    -0.02313313f, -0.05944215f, -0.02571056f, -0.07190766f, -0.12564398f, -0.03441647f, 0.06950315f, 0.15169285f, 
    0.07767946f, -0.17899483f, -0.01871734f, 0.26884022f, 0.09122203f, 0.00236286f, -0.01610504f, -0.14476788f, 
    -0.00664955f, 0.00620816f, -0.12352519f, -0.11489732f, 0.04312093f, 0.02002486f, 0.13356498f, -0.13458119f, 
    0.06648079f, -0.02143605f, 0.08688739f, 0.21027933f, 0.01811134f, -0.10291038f, -0.08463787f, -0.05914052f, 
    0.06067331f, 0.16339093f, 0.05741157f, 0.08052678f, -0.10025124f, 0.03702161f, 0.39198217f, 0.02232549f, 
    0.08315102f, -0.02970353f, 0.00069985f, 0.01906995f, 0.07989636f, -0.01204482f, -0.14727315f, -0.10148573f, 
    -0.07252968f, -0.06038977f, -0.11527634f, 0.10816998f, 0.05793928f, -0.00064077f, 0.15718795f, -0.00771268f, 
    0.03822459f, 0.16706428f, -0.00439879f, 0.08205017f, -0.08559752f, 0.09957379f, -0.02592683f, -0.02271913f, 
    -0.20326218f, -0.13593805f, 0.00461938f, -0.00022225f, -0.07318569f, 0.09705407f, -0.06432732f, 0.18373780f, 
    0.08604556f, 0.05743078f, -0.12440739f, -0.03155930f, -0.04271574f, -0.05901930f, -0.04626289f, 0.04535967f, 
    0.00443628f, -0.03814027f, -0.02339360f, 0.06127028f, -0.01239734f, -0.01982779f, -0.16928850f, -0.04415296f, 
    0.21474135f, -0.12236959f, -0.15666583f, -0.03312383f, 0.03197629f, -0.07340038f, -0.06226304f, -0.00833466f, 
    -0.03850682f, 0.18551111f, 0.12919846f, -0.01225287f, -0.05028929f, -0.06636056f, 0.06940700f, -0.00668857f, 
    0.02575347f, 0.08536849f, 0.01858313f, 0.06569757f, -0.09265732f, -0.00278128f, 0.11211468f, -0.05543032f, 
    -0.02438072f, -0.07034405f, 0.04139719f, -0.01826996f, 0.08037064f, -0.01304909f, -0.07739468f, -0.23448160f, 
    0.03068097f, -0.10171909f, 0.09658584f, -0.07589258f, 0.08758413f, -0.07349578f, -0.13628514f, -0.04625276f, 
    -0.40109083f, -0.00919687f, 0.01641762f, 0.09772202f, 0.05678377f, 0.01227071f, 0.07418620f, 0.04297405f, 
    -0.38512072f, 0.36124715f, -0.17972706f, -0.16138600f, -0.03283710f, -0.13528150f, 0.05352204f, -0.07709563f, 
    0.11425038f, 0.25359368f, 0.11192662f, -0.02568060f, -0.01996382f, 0.00890932f, 0.01618074f, 0.07940911f, 
    -0.14123882f, -0.10382377f, -0.05191235f, -0.12089834f, 0.03751956f, -0.06967737f, 0.03033404f, -0.01584650f, 
    0.04565226f, -0.11362493f, 0.03280825f, 0.06584483f, -0.08978067f, 0.08639757f, -0.03308498f, 0.06083390f, 
    -0.19647026f, -0.08440865f, 0.10928095f, -0.03069403f, -0.08484087f, 0.04226431f, -0.01606584f, 0.00890565f, 
    -0.01098049f, -0.12366776f, 0.07094512f, -0.17348401f, -0.04603777f, -0.02091175f, 0.16647016f, 0.07024162f, 
    -0.01626895f, 0.09047640f, 0.06930683f, 0.06985096f, -0.02804387f, 0.00276686f, 0.07235113f, 0.06153378f, 
    -0.07734828f, 0.06888556f, -0.04055177f, -0.05117389f, 0.03862811f, 0.10004333f, 0.22830316f, 0.24269719f, 
    0.13436688f, 0.02248107f, -0.01924423f, -0.07942665f, 0.00257310f, -0.02326305f, -0.07912778f, -0.40250865f, 
    0.03550933f, 0.02616272f, 0.03416588f, -0.07890278f, -0.01228852f, 0.12720367f, 0.01189989f, 0.02375185f, 
    0.19100185f, 0.08650530f, 0.22070485f, -0.02835639f, 0.19042830f, 0.12967181f, 0.03496259f, 0.15434349f, 
    0.02923841f, 0.02074119f, -0.01282056f, -0.00070133f, 0.02445875f, -0.02861800f, 0.00608071f, 0.01096840f, 
    -0.11113016f, -0.09159897f, -0.35947815f, -0.09808357f, -0.13774268f, 0.04723402f, -0.06751574f, -0.00292058f, 
    -0.09109960f, 0.03714910f, 0.08358323f, -0.18738046f, -0.20376545f, -0.05833817f, -0.01475062f, -0.10622527f, 
    -0.00382723f, -0.00322137f, 0.04699055f, 0.14007698f, -0.03454036f, 0.05880948f, -0.09816768f, 0.06469762f, 
    -0.07528982f, -0.04093044f, -0.09359389f, -0.07683591f, -0.05227742f, -0.00814605f, -0.20628981f, 0.01622236f, 
    -0.06249717f, 0.04610545f, -0.00020136f, 0.13824084f, -0.06399411f, -0.05064286f, 0.19534901f, 0.07932061f, 
    0.26579896f, 0.03280379f, 0.11878499f, 0.10260055f, 0.09027679f, 0.14688987f, 0.02289898f, 0.06630018f, 
    0.02983944f, -0.09957504f, -0.17912437f, 0.03588029f, 0.04731896f, -0.16319449f, 0.17700966f, -0.12471680f, 
    -0.09772887f, -0.12280460f, -0.12117299f, -0.01604583f, -0.00720024f, 0.09018549f, -0.05402056f, -0.02755868f, 
    -0.07258090f, 0.18509866f, 0.06039609f, -0.10746325f, 0.07320299f, 0.06623071f, 0.19032794f, 0.06426223f, 
    0.04460741f, -0.08461118f, -0.12578024f, -0.06277329f, 0.11334042f, 0.10885351f, -0.03581431f, -0.07020080f, 
    -0.13409455f, 0.07261757f, 0.06955547f, 0.26374474f, -0.06108222f, 0.13694985f, 0.08599757f, 0.01694808f, 
    -0.04414847f, -0.04101129f, 0.08187062f, -0.06474614f, 0.14554787f, -0.07438758f, -0.10325059f, 0.17771246f, 
    0.10796541f, -0.09653550f, 0.00300996f, -0.03013787f, 0.07274349f, 0.07289086f, 0.22406389f, 0.29740980f, 
    0.02398624f, -0.19852349f, -0.04935066f, -0.10927260f, 0.14923024f, 0.13562548f, -0.34897593f, -0.14387359f, 
    -0.03795549f, -0.04621254f, -0.02441972f, 0.19572763f, 0.13687187f, 0.12990415f, 0.03402653f, -0.37935692f, 
    0.01785614f, 0.20136252f, 0.14437200f, -0.08721314f, 0.15602326f, -0.08814640f, -0.04908725f, -0.07802772f, 
    0.06976049f, -0.07656951f, -0.14604591f, 0.18483825f, 0.01234028f, 0.02039492f, 0.24640368f, -0.02221521f, 
    0.13357148f, 0.26094589f, -0.15658183f, 0.29754600f, 0.10744812f, 0.02769931f, -0.04636654f, 0.21927501f, 
    -0.05990836f, 0.09676501f, 0.21650547f, 0.02711911f, 0.12658709f, -0.09446434f, -0.14340465f, -0.03274874f, 
    -0.02033986f, 0.06484000f, 0.04953082f, 0.14966166f, 0.06587914f, -0.01621489f, 0.07113291f, -0.03056446f, 
    0.17814776f, -0.02358783f, 0.11595107f, 0.14932197f, -0.01610754f, -0.03698482f, 0.08763344f, -0.07243311f, 
    -0.10847474f, -0.02202517f, -0.14184657f, 0.10615933f, 0.06101952f, 0.11575886f, -0.07629962f, -0.10215359f, 
    0.07310410f, 0.09484379f, 0.10110821f, 0.09781861f, 0.06276864f, -0.09748464f, -0.00132556f, 0.09177169f, 
    -0.17364453f, 0.18092053f, -0.10458202f, 0.27183536f, -0.06833235f, 0.10931246f, -0.04457730f, -0.09478866f, 
    0.02251711f, 0.22483210f, -0.02952380f, -0.03595547f, -0.12616120f, 0.00506115f, 0.19707230f, -0.11579995f, 
    -0.35218927f, -0.33091098f, -0.14172730f, -0.02639213f, -0.17070231f, -0.06944927f, 0.11738472f, 0.01819254f, 
    0.00860407f, 0.25699300f, 0.11239441f, 0.12449357f, -0.02287939f, -0.04224818f, -0.02812218f, 0.14797747f, 
    0.08725083f, 0.09566454f, -0.07336302f, -0.23212790f, 0.22600877f, -0.00564007f, 0.01461682f, 0.03264674f, 
    -0.04981495f, 0.11274126f, 0.00009427f, 0.04903331f, -0.05638609f, -0.10713058f, -0.01724709f, 0.01622463f, 
    0.08144826f, 0.18918793f, 0.09152914f, -0.05035693f, -0.37166619f, -0.02833002f, -0.00415948f, -0.06963155f, 
    0.02430428f, -0.15046749f, 0.18897671f, 0.01582659f, 0.11260297f, 0.07729109f, 0.01444052f, 0.02915918f, 
    -0.04456064f, 0.03701790f, -0.08580607f, 0.04438647f, 0.08563794f, 0.04952998f, -0.02408610f, -0.32467720f, 
    0.06500196f, -0.00101066f, 0.10074199f, 0.11350509f, 0.07684358f, -0.00174139f, -0.03773323f, 0.04049477f, 
    0.05797447f, 0.01409460f, -0.19757822f, -0.02295404f, -0.09497436f, 0.25706112f, 0.01874086f, -0.09510674f, 
    -0.16279432f, -0.43333903f, 0.02608600f, 0.10968374f, 0.02594261f, 0.15121484f, -0.06221163f, 0.16308451f, 
    -0.00688576f, 0.42347169f, -0.14989613f, -0.07610036f, 0.19672196f, 0.01085824f, -0.23552294f, 0.04708076f, 
    -0.04975852f, -0.08171333f, -0.06059492f, 0.13839646f, 0.11702346f, -0.09111813f, -0.08062977f, -0.04099338f, 
    0.10481270f, 0.13921180f, -0.03984362f, 0.28396940f, -0.01247911f, -0.05871181f, -0.05135829f, -0.23136838f, 
    -0.14211968f, 0.01365725f, 0.06202110f, -0.00236675f, 0.03243680f, 0.02500623f, -0.02861864f, -0.00807045f, 
    -0.12697068f, -0.20594864f, -0.06977599f, -0.00858240f, -0.07642519f, 0.02510991f, -0.03847846f, 0.02813337f, 
    -0.14063653f, -0.04168853f, 0.03611127f, -0.05188542f, -0.04988945f, 0.15405431f, -0.17859866f, -0.25595453f, 
    0.07372914f, 0.02686849f, -0.13087133f, -0.04325431f, 0.05530230f, 0.02502325f, 0.05040440f, 0.26222989f, 
    -0.35355398f, -0.32088068f, 0.05742737f, -0.17246503f, -0.10083779f, -0.01014471f, 0.05835213f, -0.02937591f, 
    0.16285412f, 0.10062969f, 0.04822468f, -0.22367561f, -0.10893828f, -0.01541031f, -0.00520818f, -0.07852960f, 
    0.17711797f, -0.23152015f, -0.28442678f, -0.37787947f, -0.16694643f, -0.00235249f, 0.05731290f, 0.06151430f, 
    -0.13311438f, 0.15815891f, 0.10106139f, 0.02920801f, 0.29101440f, 0.08967432f, -0.04697835f, 0.03510131f, 
    0.02254888f, 0.03518399f, 0.09453985f, 0.07887948f, -0.10647321f, 0.13666314f, -0.01508066f, 0.01707872f, 
    0.03184174f, 0.14035866f, -0.07215963f, 0.01464458f, -0.42684367f, -0.65184015f, -0.61216700f, -0.04988957f, 
    0.02317836f, -0.03694821f, -0.17240056f, -0.12428771f, -0.03573892f, -0.43791687f, -0.38030729f, 0.10688308f, 
    -0.07754290f, 0.03553450f, -0.25209266f, -0.01162076f, 0.06818998f, 0.10918161f, 0.05379172f, 0.01157249f, 
    -0.00166591f, 0.17808254f, -0.11541482f, -0.11260328f, 0.08548487f, 0.05132421f, 0.06148259f, -0.33456793f, 
    -0.32442972f, -0.44174871f, -0.00297039f, -0.19577758f, 0.16585952f, 0.01953652f, 0.10632721f, -0.11438967f, 
    -0.09745592f, -0.10489251f, 0.03344538f, -0.05639068f, 0.06053376f, -0.01944897f, -0.16734862f, -0.01391011f, 
    -0.14258479f, -0.04177240f, -0.00341150f, 0.24211600f, 0.11945089f, -0.04508543f, 0.04298737f, -0.12178130f, 
    0.11866558f, 0.02678812f, 0.15258151f, 0.12996835f, 0.02739560f, -0.01423728f, -0.01470895f, 0.01811184f, 
    0.03449347f, 0.01697011f, -0.13481545f, -0.03490411f, 0.14852764f, -0.04945129f, 0.12001208f, 0.05530140f, 
    0.02846447f, -0.04748765f, -0.05085742f, -0.24328002f, 0.06588149f, -0.05218945f, 0.05363677f, -0.01847347f, 
    -0.02704580f, -0.17659770f, -0.09212013f, 0.07238380f, 0.16718103f, 0.02271439f, 0.21192627f, 0.02222680f, 
    0.09576219f, -0.09695613f, 0.11094719f, -0.10019879f, -0.10165837f, 0.16255543f, -0.04048917f, 0.00959442f, 
    0.01713469f, 0.10625193f, -0.08962237f, 0.12336463f, 0.07969060f, -0.03966500f, -0.02353483f, 0.14747746f, 
    0.17358194f, 0.24501710f, 0.03833261f, -0.06174065f, -0.05518427f, 0.05023767f, 0.08680636f, -0.02444089f, 
    -0.16291860f, 0.23585831f, -0.07887515f, -0.03064705f, -0.03018554f, 0.10729651f, -0.05372116f, -0.09054925f, 
    -0.07719549f, 0.08380364f, 0.23661873f, 0.23022197f, -0.00935283f, 0.00407136f, -0.00745820f, 0.02034609f, 
    0.15664874f, 0.04918127f, -0.12642661f, -0.07025743f, 0.41701058f, -0.05749932f, 0.00763360f, -0.12055481f, 
    -0.13852213f, 0.01238986f, 0.05036150f, 0.07727911f, 0.19440615f, 0.05600154f, 0.10551298f, -0.01227643f, 
    0.03149993f, -0.12237451f, -0.09864906f, -0.14823520f, -0.01432989f, 0.10030257f, 0.02121124f, 0.01201818f, 
    -0.00807288f, 0.10036780f, -0.07643141f, -0.01593484f, 0.06024848f, 0.03075087f, 0.00217437f, -0.09716283f, 
    0.10275122f, 0.04790467f, 0.05230558f, 0.00621413f, -0.08519104f, -0.21337514f, 0.07150594f, -0.08253417f, 
    0.02619374f, -0.04302742f, 0.11722229f, -0.01881718f, 0.03279557f, 0.08401687f, 0.30431262f, 0.02267583f, 
    0.28192729f, -0.05150076f, 0.13089997f, 0.01263035f, 0.11024786f, 0.08134665f, -0.01609743f, -0.05503662f, 
    -0.03208793f, -0.04057943f, 0.06803711f, 0.00860785f, 0.03213435f, -0.24465464f, 0.01620194f, -0.01681415f, 
    -0.05522071f, -0.03992500f, 0.13822177f, -0.09852675f, 0.14077204f, 0.05176328f, 0.15391605f, -0.10643286f, 
    -0.02901687f, 0.10862485f, 0.09351899f, 0.19336520f, 0.25982398f, 0.03809493f, 0.04752946f, -0.05717158f, 
    -0.00498594f, -0.16277424f, -0.13056967f, 0.06090623f, 0.21263136f, -0.00526924f, 0.06710156f, -0.07454730f, 
    -0.03294750f, 0.12631978f, 0.03744872f, -0.18633683f, 0.10068385f, -0.09418686f, 0.10966709f, 0.10647404f, 
    0.00661797f, -0.03193974f, 0.08139833f, -0.07437207f, -0.19932927f, 0.07177472f, 0.07691779f, 0.08603863f, 
    0.13568379f, 0.02164930f, 0.00863592f, -0.14851475f, -0.04674280f, -0.15830833f, -0.16580915f, 0.04958197f, 
    0.09470528f, -0.02676182f, 0.04171211f, -0.12244857f, 0.23030579f, -0.05205438f, -0.06117593f, -0.05530679f, 
    -0.21380520f, 0.20094524f, -0.12284202f, 0.01403206f, -0.17467201f, -0.07560013f, -0.05063250f, -0.17375031f, 
    0.02857454f, 0.08215494f, -0.04923828f, 0.06947862f, 0.15562075f, 0.08412337f, -0.05915184f, -0.09690680f, 
    -0.20946416f, 0.27077404f, -0.12051396f, -0.02522781f, 0.13180371f, 0.01912202f, -0.06155123f, 0.09953084f, 
    0.11424042f, -0.03340529f, -0.06443309f, 0.21391733f, 0.15889758f, -0.02308291f, -0.05790601f, -0.17233235f, 
    0.03520616f, 0.02006876f, 0.02108134f, 0.07009956f, -0.03395284f, 0.00018268f, -0.03250383f, -0.04452645f, 
    -0.11675497f, -0.05385565f, 0.24372233f, 0.18751742f, 0.31202880f, -0.15701312f, -0.22301370f, 0.01575771f, 
    -0.16236828f, -0.11374309f, 0.02560500f, 0.04174535f, 0.07666325f, -0.17264751f, -0.12783773f, 0.00694204f, 
    0.14543009f, 0.01088549f, -0.15510273f, -0.22723025f, -0.30093032f, -0.22000381f, 0.17746443f, 0.20110670f, 
    0.22400133f, 0.03130024f, 0.01938074f, 0.06905831f, -0.06281469f, 0.04968700f, -0.14813671f, -0.07862348f, 
    0.05006813f, -0.17768431f, 0.08470169f, 0.00865524f, -0.05410525f, 0.04714011f, 0.04227165f, 0.03715949f, 
    0.05546084f, -0.12788264f, 0.08263260f, -0.07136455f, 0.05209128f, -0.04703207f, 0.03426847f, -0.06520113f, 
    0.03612264f, 0.01384616f, 0.10014929f, 0.12184011f, 0.10054909f, -0.06831984f, -0.10717016f, 0.05784579f, 
    0.01573055f, -0.02778734f, -0.06068845f, 0.05529439f, 0.17850117f, 0.06463556f, -0.08378085f, 0.04964318f, 
    0.01590861f, 0.03870740f, 0.01881120f, 0.01916694f, 0.03629972f, 0.19460665f, -0.05331995f, -0.03649985f, 
    0.08410116f, 0.02509867f, 0.08022304f, 0.05702340f, 0.07763865f, -0.07479728f, 0.01305183f, -0.04131731f, 
    0.01651490f, 0.13529153f, -0.15415792f, -0.16933183f, 0.05694455f, -0.10328771f, -0.02665020f, 0.08532766f, 
    0.05777544f, 0.05103508f, 0.08793057f, 0.05103672f, 0.09226776f, 0.06410152f, 0.01984874f, 0.08855213f, 
    -0.04062917f, -0.26635170f, 0.10888512f, 0.07496954f, 0.04524339f, 0.01995986f, 0.13529511f, -0.01032997f, 
    -0.03777214f, 0.17054480f, -0.12600900f, -0.29727378f, -0.10473803f, -0.04951604f, 0.00132801f, 0.15421641f, 
    0.13835596f, 0.03578759f, -0.03072298f, 0.02642353f, -0.11689773f, -0.29335335f, 0.01465475f, 0.13016197f, 
    0.02659432f, -0.03841857f, -0.15970385f, 0.11622418f, -0.04768422f, -0.02830425f, 0.02090158f, 0.09417991f, 
    -0.06237606f, 0.09658314f, -0.01888517f, 0.00016992f, -0.25254896f, 0.14177009f, -0.12122462f, -0.00398782f, 
    -0.09967820f, -0.10259558f, 0.00147158f, 0.09725218f, -0.20049736f, -0.01264280f, 0.01159903f, 0.05248991f, 
    0.03840168f, -0.10827129f, 0.13942157f, 0.15926020f, 0.11593668f, 0.05629343f, -0.13129133f, 0.06608377f, 
    0.10021716f, -0.15067551f, 0.11708119f, 0.00170452f, -0.06720418f, -0.08045936f, 0.16979140f, -0.03097041f, 
    -0.08386739f, 0.02465678f, -0.22016503f, 0.10955448f, 0.06960575f, 0.17658192f, 0.51231843f, 0.05776499f, 
    -0.08783618f, 0.06933235f, -0.03803496f, -0.05981852f, -0.08527699f, 0.17107578f, -0.17858627f, 0.07846384f, 
    0.03016838f, -0.15193255f, -0.02192976f, 0.14937794f, -0.11203245f, 0.02711211f, 0.01006663f, 0.08641440f, 
    0.25588134f, 0.03556250f, -0.15528722f, -0.07117572f, -0.01827611f, 0.05155528f, 0.17549889f, -0.01115312f, 
    -0.00957687f, 0.12960006f, -0.18988748f, -0.14946076f, -0.18156968f, -0.18318118f, 0.02054003f, -0.15816627f, 
    -0.00821918f, 0.00413848f, -0.19142659f, -0.06943430f, -0.13538961f, 0.04912209f, -0.15820779f, -0.24443834f, 
    0.01683808f, 0.09289750f, 0.25494170f, -0.36070454f, -0.14237830f, 0.16811186f, -0.22106054f, -0.07829754f, 
    0.10360675f, 0.13628842f, -0.05081707f, -0.07460774f, 0.09729897f, -0.37795281f, 0.08892395f, -0.16798389f, 
    0.09880106f, -0.28006941f, 0.06236187f, -0.01603325f, 0.09636839f, 0.04792605f, -0.08705719f, -0.16627449f, 
    -0.05390102f, 0.10506042f, -0.14834128f, 0.06398140f, 0.05592558f, -0.03399812f, 0.13350098f, 0.03966465f, 
    -0.16626957f, -0.02775726f, -0.00815860f, -0.04515420f, 0.06927656f, -0.06617474f, -0.04098377f, -0.26421273f, 
    -0.04152629f, -0.14159538f, -0.02999737f, -0.00172421f, -0.06908046f, -0.13303395f, 0.01130476f, -0.03667622f, 
    0.10282605f, -0.16153193f, -0.08332336f, -0.07340015f, -0.06176615f, -0.15604699f, -0.00365780f, 0.06987038f, 
    0.17408243f, 0.11180292f, -0.16112636f, -0.00090194f, 0.03515245f, -0.04447098f, -0.10268211f, 0.00567909f, 
    0.13866977f, -0.20410430f, -0.14362110f, 0.10602435f, 0.10319494f, 0.06638195f, -0.16214930f, -0.09215725f, 
    0.13214712f, 0.01396228f, 0.08296382f, 0.02023306f, 0.07652181f, 0.12367022f, 0.13684104f, 0.15015252f, 
    0.12903002f, -0.00520953f, -0.00915384f, 0.00373044f, -0.10436036f, -0.22618829f, 0.08496339f, 0.15992039f, 
    0.11402338f, -0.09419947f, 0.08388017f, -0.07321805f, 0.00057343f, 0.08691750f, 0.18070343f, -0.02558139f, 
    0.10623761f, -0.07394727f, -0.10604652f, -0.11141454f, -0.08544435f, 0.17198125f, -0.30124485f, 0.00059803f, 
    0.14304139f, -0.05913290f, -0.04853335f, 0.10760480f, -0.07436647f, -0.04470680f, 0.02775010f, 0.26206395f, 
    -0.06257454f, -0.11304791f, 0.12820390f, -0.01323590f, 0.03222290f, -0.11730696f, -0.20189336f, -0.07440752f, 
    0.05290962f, 0.02696454f, -0.03966251f, -0.01123746f, 0.03553320f, -0.02388643f, -0.00224950f, 0.02799455f, 
    -0.05222603f, 0.00958753f, -0.03265395f, -0.05454059f, -0.00730396f, -0.00695195f, -0.00968116f, 0.01591148f, 
    -0.02769568f, -0.02082749f, -0.04206502f, -0.02212755f, 0.03965463f, -0.01601476f, -0.05033254f, 0.01968311f, 
    0.02875137f, -0.03951084f, -0.02627269f, -0.00893661f, -0.05708500f, -0.03272449f, -0.01206483f, -0.04483178f, 
    -0.04148016f, 0.02728309f, -0.05655555f, -0.05337262f, 0.00487003f, -0.04177660f, 0.03877700f, -0.03869352f, 
    -0.05384544f, 0.04238869f, -0.02536808f, 0.00719805f, -0.06352799f, 0.00961983f, -0.02507965f, -0.02676657f, 
    -0.03945189f, 0.00209073f, 0.00088182f, 0.01315435f, -0.02939648f, -0.05679119f, 0.03475080f, 0.02250581f, 
    0.03166721f, -0.02888064f, 0.02487114f, 0.05007550f, -0.01197730f, 0.01058519f, 0.02684593f, -0.01834881f, 
    -0.01940861f, -0.04025850f, -0.00733261f, 0.04559162f, -0.02987645f, 0.02460330f, -0.06733692f, 0.03150338f, 
    -0.01694981f, 0.00346684f, 0.00871042f, 0.03751874f, 0.02981739f, -0.06127285f, -0.05977207f, 0.01866343f, 
    0.04096276f, -0.02090515f, 0.02289023f, 0.00322559f, 0.03410355f, -0.02388165f, 0.00293728f, -0.04052639f, 
    -0.05880612f, -0.03004490f, 0.02658330f, -0.02398159f, 0.03513437f, -0.01748290f, -0.00720325f, 0.01743728f, 
    -0.04224259f, 0.02967672f, -0.04535517f, -0.01741037f, 0.00709595f, -0.06172695f, 0.02068752f, -0.06188727f, 
    -0.00876278f, 0.01546132f, -0.03329536f, 0.01480821f, 0.00400588f, -0.04879111f, -0.01118422f, 0.03082816f, 
    0.04763420f, -0.04595098f, 0.02402242f, 0.03760984f, -0.00503540f, -0.06012249f, -0.05415076f, 0.05513101f, 
    -0.05572801f, -0.00534655f, -0.05305137f, -0.01780950f, 0.01727330f, -0.03385426f, -0.03242544f, 0.02237005f, 
    -0.05972924f, -0.00623128f, 0.03816158f, 0.00019639f, -0.05511196f, 0.04411863f, -0.00656345f, -0.01718361f, 
    0.00392162f, -0.02835930f, -0.05787510f, -0.05351413f, -0.00268608f, -0.01180193f, 0.02604193f, -0.00236460f, 
    -0.01678727f, 0.00346104f, -0.02250209f, -0.01870886f, -0.06532895f, 0.03850685f, -0.06842466f, 0.03178165f, 
    -0.03878541f, 0.04046528f, -0.06203281f, -0.00609921f, -0.00698948f, 0.00867520f, -0.04486445f, 0.04705225f, 
    -0.04752588f, -0.05430122f, -0.04468840f, -0.03687991f, 0.03016318f, -0.05538054f, 0.01902153f, -0.00217557f, 
    -0.03555510f, 0.04768903f, -0.05009957f, 0.00912635f, -0.04385992f, 0.00166308f, 0.01606925f, -0.03946879f, 
    0.02333650f, -0.04994801f, -0.00892164f, -0.05250073f, 0.03891512f, 0.01913037f, 0.05237376f, -0.00859618f, 
    0.05274925f, -0.00556282f, 0.04718112f, 0.04202779f, 0.00713617f, 0.01550516f, -0.02441060f, 0.01442570f, 
    -0.06197914f, 0.03908120f, 0.03388740f, 0.02250032f, 0.04443619f, 0.03451262f, 0.03331792f, -0.04691497f, 
    0.03814483f, -0.00541274f, 0.00432984f, -0.00457162f, 0.04432318f, 0.02354008f, -0.03521727f, 0.01717028f, 
    -0.02790030f, -0.01140124f, -0.03385324f, -0.01682493f, 0.01283379f, -0.02210441f, -0.02142971f, 0.03486067f, 
    -0.00606276f, 0.04692446f, -0.02569969f, 0.02836093f, -0.01569548f, -0.04735317f, -0.02459525f, 0.00798774f, 
    -0.06380483f, -0.02398072f, 0.01356076f, -0.00527567f, 0.02640807f, 0.02454174f, 0.00087503f, -0.05122121f, 
    -0.04842671f, 0.02645967f, -0.03472811f, 0.03143128f, 0.01792890f, -0.04151078f, 0.03319763f, 0.03604340f, 
    -0.00690044f, 0.02452754f, -0.06315049f, -0.00191067f, -0.02429788f, 0.03432957f, 0.03420097f, -0.00519025f, 
    -0.04578399f, -0.01686690f, -0.03600216f, 0.03097659f, -0.06128190f, -0.01648024f, 0.03373705f, 0.01699616f, 
    0.01653021f, 0.02645646f, -0.06240616f, 0.05029553f, 0.03339048f, 0.04542672f, -0.04510793f, -0.00848330f, 
    -0.00119300f, -0.00660393f, 0.02569576f, 0.01205338f, -0.04449555f, -0.03997175f, 0.01297804f, -0.03912718f, 
    0.03694194f, 0.03548723f, -0.01508962f, 0.01746661f, -0.02669367f, -0.06163835f, -0.00945399f, -0.05948857f, 
    -0.07241995f, 0.00123624f, 0.00026537f, -0.03237180f, 0.05403663f, -0.01430691f, -0.06322893f, -0.05311092f, 
    -0.03694916f, 0.01383751f, -0.07648532f, -0.01542231f, -0.13683486f, 0.00170608f, 0.01050417f, 0.08385861f, 
    -0.02024102f, -0.22811347f, -0.00774032f, 0.13169934f, 0.09711877f, 0.11162311f, -0.01699341f, -0.03693951f, 
    0.16201560f, -0.14711468f, -0.18260585f, -0.05908305f, -0.14303668f, -0.00053503f, 0.10941324f, 0.03592762f, 
    0.01160276f, -0.10414652f, 0.18560211f, 0.14518803f, -0.01174879f, -0.23762365f, -0.00866800f, 0.03639786f, 
    -0.03986796f, 0.03830464f, 0.03034430f, -0.11706083f, 0.02164014f, -0.01251307f, 0.09185667f, 0.05376890f, 
    -0.02990523f, -0.06663521f, -0.07154311f, -0.13684894f, 0.02130980f, 0.09618380f, -0.05829751f, -0.30970976f, 
    -0.00122535f, -0.06091353f, -0.01617539f, 0.04421755f, 0.10274020f, -0.07095923f, -0.07491129f, -0.10417249f, 
    -0.39396626f, 0.00097470f, -0.01635265f, -0.07761730f, 0.13847040f, 0.06023268f, -0.12596096f, -0.19052900f, 
    -0.03691254f, 0.00770763f, -0.06702261f, -0.37793508f, 0.10789640f, -0.10259564f, 0.04304417f, 0.04152825f, 
    0.11409920f, 0.23363975f, 0.30164522f, -0.04719393f, 0.17542446f, -0.19079262f, 0.02696358f, -0.12168942f, 
    -0.16991334f, -0.06012288f, -0.07989598f, -0.01995657f, 0.09760378f, 0.00245925f, 0.02806414f, -0.03548794f, 
    0.03307964f, 0.06186593f, -0.23679598f, 0.14910999f, -0.03290544f, -0.00513128f, -0.06735145f, 0.10521036f, 
    -0.10842347f, -0.13284332f, 0.05841745f, -0.12569152f, 0.10495537f, -0.18222839f, 0.03530035f, 0.08366685f, 
    0.10727062f, -0.05672635f, -0.01259269f, 0.02204642f, 0.01360042f, 0.12890051f, 0.09525664f, -0.02587923f, 
    0.07377166f, -0.12764505f, -0.02946011f, 0.07523715f, 0.12057230f, 0.07763854f, -0.13400090f, -0.18512629f, 
    0.07078631f, -0.03343059f, -0.16848525f, 0.03417490f, 0.04140458f, -0.09210943f, 0.27092174f, -0.00219855f, 
    -0.06322140f, -0.19349276f, -0.11410522f, -0.02399600f, -0.00179587f, -0.13714026f, 0.17643483f, 0.00949292f, 
    -0.12762280f, -0.32283792f, -0.02928391f, -0.09346767f, -0.08315556f, 0.16044134f, 0.13415167f, 0.21643861f, 
    0.10294303f, 0.10794903f, 0.14829674f, 0.03125175f, -0.11808535f, -0.00779658f, -0.01385754f, 0.14079589f, 
    0.03049936f, -0.10894816f, 0.18502389f, 0.32031259f, 0.02374073f, 0.16041236f, 0.02108493f, -0.00205623f, 
    0.06722372f, -0.08165766f, -0.03195605f, -0.21594582f, -0.23871343f, 0.15539752f, -0.15509874f, 0.14282440f, 
    0.13839637f, 0.10045458f, 0.11255083f, -0.28002399f, -0.06909245f, -0.09967161f, -0.01087635f, 0.11498410f, 
    0.02931473f, -0.03520369f, -0.18128042f, 0.07392084f, -0.09015042f, -0.05753277f, -0.26628822f, 0.15196326f, 
    -0.02605738f, 0.12917210f, -0.07162016f, 0.06060832f, -0.01553604f, 0.04271546f, -0.10267486f, -0.22472307f, 
    -0.16431165f, -0.04123455f, 0.12163543f, -0.01873828f, 0.06455801f, 0.08387207f, 0.13871205f, 0.13112296f, 
    0.11867375f, 0.03342749f, -0.00214801f, 0.00423443f, 0.16376062f, 0.13101299f, -0.06453102f, -0.21186009f, 
    0.18483546f, 0.09747276f, -0.04691119f, 0.11473466f, 0.05695732f, 0.16732574f, -0.17179754f, -0.09617136f, 
    0.04214970f, -0.15137491f, -0.18547566f, 0.16543992f, -0.04753613f, 0.03142764f, 0.02407255f, 0.10672326f, 
    0.16349313f, 0.02425132f, 0.19393206f, 0.13556887f, 0.09023394f, 0.13561606f, 0.09849068f, -0.13780399f, 
    0.02834756f, 0.15808460f, -0.06912731f, 0.02741251f, 0.09037654f, 0.09962546f, 0.03465335f, -0.01278830f, 
    0.13745314f, -0.05690253f, 0.00200457f, 0.11936706f, -0.09022264f, -0.05355316f, 0.12133736f, 0.03094370f, 
    0.10368715f, -0.05298996f, 0.01466146f, 0.13348174f, 0.05633284f, -0.12482619f, 0.10132881f, -0.05392526f, 
    0.08405382f, 0.16366199f, -0.06131381f, -0.02153741f, 0.22262579f, 0.26427966f, 0.23765427f, 0.13931361f, 
    -0.04150206f, -0.17691915f, -0.04462602f, -0.03523527f, -0.06186199f, -0.05332676f, 0.04171296f, -0.19815825f, 
    -0.16594979f, 0.00790180f, -0.02427044f, -0.01532459f, -0.02871023f, -0.05121093f, -0.05433371f, 0.22672750f, 
    -0.05335149f, 0.29841036f, -0.17547289f, 0.03668082f, -0.05766886f, 0.00037539f, 0.06455854f, -0.04581439f, 
    0.18766578f, -0.01916423f, -0.08740553f, 0.05623928f, -0.03311798f, -0.09162262f, 0.00630763f, 0.10935935f, 
    0.11535486f, 0.18377003f, -0.00610693f, 0.21907371f, 0.30608305f, -0.07960414f, 0.12631008f, 0.05781075f, 
    0.04266789f, 0.05506830f, -0.02045410f, 0.08696105f, 0.20505579f, -0.04809904f, -0.07226505f, -0.11941456f, 
    0.04506071f, 0.14836331f, -0.02771966f, -0.09890705f, -0.01520443f, 0.12967476f, 0.12636009f, -0.07471771f, 
    0.10153351f, 0.00503315f, 0.01671605f, 0.17449363f, -0.03796284f, -0.16426516f, 0.10554628f, 0.06942245f, 
    -0.01031337f, 0.06806979f, 0.13884506f, -0.02644414f, 0.03275655f, -0.13937974f, 0.04102020f, 0.06786338f, 
    0.00098127f, -0.03706459f, 0.17839897f, 0.10661612f, 0.05881676f, 0.04306777f, -0.02087554f, 0.12784827f, 
    0.04293304f, 0.14056012f, -0.05538002f, 0.23519412f, 0.12345303f, -0.18114199f, 0.08895820f, -0.07462699f, 
    0.07658497f, 0.29604542f, 0.03607910f, 0.05540774f, -0.10394414f, -0.19671857f, -0.07344040f, -0.16935246f, 
    -0.10921316f, 0.12388054f, -0.19366001f, -0.13856767f, 0.01915052f, -0.24254353f, 0.01574096f, 0.11983417f, 
    0.09179627f, -0.06163789f, 0.01675459f, 0.15391621f, -0.00173131f, 0.11082876f, 0.02064814f, 0.05034157f, 
    -0.09163356f, 0.13132365f, -0.00692651f, 0.19039965f, -0.45848805f, 0.06547415f, 0.06537556f, 0.16488847f, 
    0.03144839f, 0.03817623f, -0.03535263f, -0.01504968f, 0.00295559f, 0.12939233f, -0.00471853f, -0.00155660f, 
    0.17328665f, 0.04957805f, -0.04866502f, -0.03695535f, -0.04426869f, -0.16622950f, -0.15815231f, -0.12839046f, 
    0.01410436f, -0.03226530f, 0.02620505f, 0.00315014f, 0.08443280f, -0.00748060f, 0.05782342f, 0.20493989f, 
    -0.04499194f, -0.13292582f, 0.05200717f, 0.13407935f, -0.05053288f, 0.07242660f, 0.03146768f, -0.07421613f, 
    0.05065165f, -0.02573416f, 0.03393327f, -0.03847508f, 0.11356325f, -0.21248987f, -0.01056133f, -0.10273486f, 
    -0.03141106f, 0.10180863f, 0.01999636f, 0.05082964f, 0.04303723f, 0.08043849f, 0.01538169f, -0.03268848f, 
    0.09882107f, 0.03929087f, 0.06104108f, 0.05217592f, -0.00671581f, 0.09804267f, 0.08829962f, 0.01160716f, 
    -0.02365484f, 0.22963896f, -0.02304613f, -0.36340761f, -0.02333822f, 0.00724631f, -0.16988964f, 0.02546039f, 
    0.07490665f, 0.07871031f, -0.03965748f, 0.04968052f, -0.00963539f, 0.04615600f, 0.07276487f, 0.03090415f, 
    0.06554306f, -0.07859068f, 0.24706967f, -0.02681104f, -0.10908506f, 0.03340316f, -0.14524981f, 0.00156886f, 
    -0.05110527f, 0.04185335f, -0.10099318f, -0.04134616f, -0.08771102f, 0.12889890f, 0.06031180f, -0.26196006f, 
    -0.04988556f, -0.06784017f, 0.03065401f, -0.07151242f, 0.01148674f, 0.13398252f, 0.01139759f, 0.09587441f, 
    -0.24444886f, 0.08753983f, -0.11119006f, -0.01294206f, -0.10460722f, 0.03178740f, 0.03855124f, -0.00282909f, 
    0.00880081f, -0.06978358f, 0.09454338f, -0.01316279f, -0.01575837f, 0.02819218f, -0.06243516f, 0.14209458f, 
    0.34940472f, -0.28354096f, -0.07989030f, -0.06625108f, -0.03066310f, -0.15012743f, 0.04321399f, 0.06246777f, 
    0.03456569f, 0.11960467f, 0.07146870f, -0.24869557f, -0.23117611f, -0.23148634f, -0.02309553f, -0.09806586f, 
    0.04357086f, 0.04091313f, -0.09089147f, -0.45756888f, -0.29793599f, -0.01221635f, -0.27365521f, -0.03046136f, 
    -0.02354173f, -0.03138345f, -0.06650517f, 0.06267430f, 0.07764552f, 0.08804276f, 0.11972617f, 0.02445428f, 
    0.02596561f, 0.08328339f, 0.19155569f, 0.11190626f, -0.04244456f, 0.04620137f, 0.08490834f, 0.12553778f, 
    0.02950154f, -0.19848442f, -0.22606237f, -0.08123478f, 0.12815857f, 0.13775741f, -0.14171237f, -0.14587896f, 
    -0.02104600f, -0.15147258f, 0.00831477f, -0.18815164f, -0.01428244f, -0.51980680f, 0.05267284f, 0.11927980f, 
    -0.01579463f, -0.10602900f, 0.05804364f, 0.01904199f, 0.25897744f, 0.12207579f, -0.29007530f, -0.16000573f, 
    0.19334859f, 0.15078698f, -0.01360171f, 0.12619559f, 0.04915793f, 0.11270037f, 0.03328523f, -0.18457380f, 
    -0.04407690f, 0.13154727f, 0.06100674f, -0.03816647f, 0.18204059f, 0.00754810f, -0.13709915f, -0.11625055f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.17776306f, -0.07408696f, 0.10698837f, -0.02572152f, -0.13893200f, 0.14866865f, 0.00387197f, -0.05535160f, 
    -0.00303356f, 0.02739714f, -0.01904666f, 0.09435482f, 0.19480167f, -0.01201035f, -0.03399800f, -0.03700976f, 
    -0.07876034f, 0.04193909f, 0.20749424f, 0.00041464f, 0.09212231f, 0.10138594f, 0.05612545f, 0.08277773f, 
    0.11667244f, 0.06026578f, 0.16312431f, -0.03340418f, 0.07177033f, -0.01714843f, -0.00300987f, 0.13147503f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.17046422f, -0.06054311f, 0.10360986f, 0.05782630f, -0.17878802f, -0.04975601f, -0.14259470f, 0.11897618f, 
    -0.11037435f, 0.04886045f, -0.00899629f, 0.38882315f, 0.16120845f, -0.03977232f, 0.08493528f, 0.05681056f, 
    -0.09106013f, 0.21400556f, 0.39984444f, 0.42297229f, -0.00977031f, 0.10203373f, -0.27930993f, 0.19661297f, 
    0.17403148f, 0.01072587f, -0.35375038f, 0.19754399f, -0.34400254f, -0.09522813f, 0.03181128f, 0.02701219f, 
    -0.17055948f, -0.01353537f, -0.12325177f, -0.06230014f, 0.08306347f, -0.15244146f, -0.11968303f, -0.08889314f, 
    0.02800458f, -0.00618225f, -0.00783695f, -0.02147651f, -0.07570384f, -0.11224947f, -0.02902542f, -0.01125106f, 
    0.06179941f, -0.08560181f, -0.05464565f, -0.16975133f, -0.18916582f, -0.10317457f, -0.01766860f, -0.10467029f, 
    0.05723657f, -0.18245934f, -0.16111481f, -0.15360826f, -0.00561636f, 0.06886061f, 0.13047382f, 0.13306104f, 
    0.12256385f, 0.07231473f, 0.45068690f, 0.06877780f, -0.30714414f, 0.08785778f, -0.16212176f, -0.14996877f, 
    0.14939986f, -0.00908210f, -0.05751980f, 0.09533653f, -0.36962184f, -0.07057694f, -0.11252350f, -0.04117567f, 
    -0.17348973f, 0.26204821f, 0.28246480f, 0.08180673f, -0.02924794f, -0.12102263f, 0.24276701f, 0.00593892f, 
    0.01468824f, 0.12904386f, 0.06955844f, 0.14198571f, -0.39881894f, -0.02047951f, 0.08726326f, -0.25881228f, 
    0.38783890f, -0.42078948f, 0.79670620f, 0.09604637f, -0.03404599f, 0.10520599f, -0.11018617f, 0.06089104f, 
    0.01127051f, -0.15857770f, 0.03565904f, 0.03911244f, -0.21907829f, 0.09686375f, -0.01343912f, 0.04206546f, 
    0.22289066f, -0.02455909f, -0.43112528f, -0.29792219f, 0.21896347f, 0.04086003f, -0.12562810f, 0.10330462f, 
    0.20013216f, -0.11216913f, 0.26023480f, -0.18364069f, -0.07688800f, -0.07262816f, 0.19074106f, 0.06408876f, 
    0.16697036f, -0.24204318f, 0.15025464f, 0.17769459f, -0.17798127f, 0.03275895f, 0.14351881f, -0.09376901f, 
    -0.33517286f, 0.16023621f, 0.08101568f, 0.34554234f, 0.34030294f, 0.07874121f, 0.14220998f, -0.11085223f, 
    0.03735772f, -0.12820561f, 0.00625099f, -0.02876344f, -0.20375448f, 0.05160924f, 0.03908525f, 0.18894643f, 
    0.10410069f, 0.07946612f, -0.06279037f, 0.00930472f, -0.18448871f, -0.02812355f, -0.03342707f, 0.25665343f, 
    -0.13662449f, 0.05478028f, -0.45275000f, -0.02684811f, -0.25235909f, 0.19157661f, 0.09376179f, -0.00487882f, 
    -0.44588310f, -0.02728899f, 0.08958299f, 0.14322814f, 0.36359414f, 0.11763119f, 0.14260040f, 0.10914455f, 
    -0.39535683f, -0.04922450f, 0.53461432f, -0.39631119f, 0.00982036f, 0.11165823f, 0.16303261f, 0.20038772f, 
    0.16957945f, -0.08122467f, -0.17810471f, -0.14675839f, -0.00624775f, -0.02266965f, -0.13043036f, 0.22848743f, 
    0.04215363f, -0.27112564f, 0.43678886f, -0.02189032f, 0.33896452f, 0.09125193f, -0.04778976f, 0.11685756f, 
    0.05287540f, -0.16622472f, -0.00578302f, -0.22134088f, -0.08728446f, 0.13984673f, -0.00026114f, 0.03365830f, 
    0.04778335f, -0.21363963f, 0.08678576f, -0.05731729f, 0.06855083f, -0.01966846f, 0.37366575f, -0.05648972f, 
    0.11513966f, -0.01437654f, -0.18721379f, 0.28727376f, 0.05238236f, 0.01752168f, 0.34367222f, -0.36978272f, 
    -0.15834922f, 0.13562427f, 0.04424067f, -0.05941602f, 0.03122200f, 0.06896300f, -0.14473642f, -0.09456732f, 
    0.14526354f, -0.11379297f, 0.09237269f, 0.12648387f, 0.11155544f, 0.16800721f, 0.08028924f, 0.16360269f, 
    0.04240352f, -0.01408825f, -0.52060497f, 0.17228198f, -0.03482532f, 0.01567264f, 0.42674521f, -0.16451043f, 
    -0.22033867f, -0.01810636f, 0.54403383f, 0.03393614f, -0.07153000f, -0.12900946f, 0.18203416f, 0.02648404f, 
    0.03520799f, -0.23824465f, -0.40102431f, -0.10070231f, -0.25689113f, -0.03247723f, 0.15282625f, -0.16320246f, 
    -0.08213931f, 0.01144634f, 0.08639761f, 0.34591454f, 0.27868563f, 0.03639143f, -0.12741420f, -0.08131900f, 
    -0.02751838f, 0.28520486f, 0.58811480f, -0.38699868f, 0.26969668f, 0.16966955f, -0.08976482f, -0.16699125f, 
    0.05101625f, 0.08312058f, -0.13546623f, -0.13687162f, -0.08420315f, 0.01384156f, -0.25872108f, 0.11843778f, 
    0.17858194f, 0.20702618f, 0.30079114f, 0.01960880f, -0.22159004f, -0.14284478f, -0.08870350f, -0.05792414f, 
    -0.21778026f, -0.02912582f, -0.10961247f, -0.00555490f, 0.11125713f, 0.21915570f, 0.03954815f, -0.05584573f, 
    -0.10760647f, 0.25946692f, 0.13478135f, 0.31486356f, 0.07212185f, 0.16457903f, -0.06393390f, -0.00111624f, 
    0.07575049f, 0.00249612f, 0.39972484f, 0.24054858f, -0.26316887f, -0.14971069f, 0.01324566f, 0.13344400f, 
    -0.07278559f, 0.11069632f, 0.11823713f, 0.15932193f, 0.22803138f, 0.23024252f, -0.02187933f, -0.02663251f, 
    0.45393589f, 0.17341876f, -0.04185834f, -0.02509598f, -0.08191549f, -0.01688149f, -0.05901915f, 0.08144496f, 
    -0.19077511f, 0.13002069f, -0.37201455f, -0.00832058f, 0.41039890f, -0.09970488f, -0.42576820f, -0.35126108f, 
    0.12995487f, -0.14756310f, -0.00716025f, -0.06004776f, 0.05394726f, 0.01424352f, 0.07348471f, 0.07896262f, 
    0.02732824f, 0.04989863f, -0.09736388f, 0.16693144f, -0.13059586f, -0.00438674f, 0.13908431f, 0.10005921f, 
    -0.17426541f, -0.15411456f, 0.09740200f, -0.09587394f, 0.08932094f, -0.03904865f, -0.00759895f, 0.00854340f, 
    0.07061312f, -0.05559583f, -0.10600838f, -0.14889166f, -0.09505032f, -0.16678560f, -0.09395987f, 0.01403751f, 
    0.10217272f, -0.10943935f, -0.04695890f, 0.04712124f, -0.17316684f, -0.09209278f, 0.03488856f, -0.06023912f, 
    0.12880175f, 0.02032935f, 0.26538554f, 0.02343189f, -0.16305466f, -0.20576739f, -0.16913071f, -0.14796509f, 
    0.20990020f, 0.21584432f, 0.15509193f, -0.03835931f, 0.13295279f, 0.13852410f, 0.14588313f, 0.10475585f, 
    0.29024032f, 0.16146505f, -0.42436150f, 0.36371073f, -0.12943971f, 0.26772407f, -0.20811778f, 0.01034489f, 
    -0.09595796f, 0.10271250f, 0.36680970f, 0.05724961f, -0.04456532f, -0.02931912f, -0.09985213f, 0.08035560f, 
    -0.13867234f, 0.03110957f, 0.00066080f, 0.04816468f, -0.03750643f, -0.17237549f, 0.14208809f, -0.04620036f, 
    -0.02622220f, 0.00381498f, -0.00787316f, -0.04952764f, 0.11168780f, 0.02665567f, -0.15301777f, 0.01626542f, 
    -0.01118677f, -0.09813159f, 0.12205774f, 0.09938080f, 0.01673314f, -0.04784368f, -0.16050604f, -0.16224144f, 
    -0.15014282f, -0.07224766f, 0.07801063f, 0.02706210f, -0.17094520f, 0.16872777f, 0.08198284f, -0.12629759f, 
    0.08696067f, -0.07253055f, 0.03674946f, 0.09547094f, -0.28931686f, -0.05102944f, -0.09379578f, -0.05389711f, 
    -0.55371022f, -0.17264508f, -0.11764044f, 0.12336093f, 0.07060322f, 0.15554836f, 0.01610663f, -0.15549044f, 
    0.03578588f, 0.06758304f, 0.18449324f, -0.27627277f, 0.10647666f, 0.18401884f, 0.60055679f, 0.11157293f, 
    0.03429086f, 0.11765821f, 0.30839124f, 0.00491050f, 0.00233212f, -0.16549565f, 0.15433045f, 0.22524406f, 
    -0.11560509f, -0.06997201f, 0.11960921f, -0.13252787f, 0.08734956f, -0.04663670f, 0.02700448f, -0.16282494f, 
    0.09630457f, 0.04541419f, 0.11633170f, 0.14737016f, -0.14150500f, 0.11455389f, 0.06316078f, -0.09718688f, 
    -0.10998385f, -0.09335544f, -0.02709711f, -0.16798355f, -0.07486274f, -0.02549644f, 0.10878252f, -0.03678288f, 
    -0.09641098f, -0.11208591f, -0.13392253f, -0.12735897f, 0.08289590f, -0.09531257f, -0.13265041f, -0.02964810f, 
    0.19841200f, -0.29381531f, 0.41216013f, 0.11408656f, 0.08042957f, 0.03622672f, -0.14819069f, -0.15514825f, 
    0.26314631f, -0.15981512f, -0.04676643f, 0.13758719f, -0.18039395f, -0.09937287f, -0.10438190f, -0.00932564f, 
    0.22554095f, -0.04636145f, -0.09640656f, -0.01830814f, 0.30832255f, 0.18387505f, -0.32292935f, 0.19316940f, 
    0.22635281f, -0.21598150f, -0.30809739f, -0.08383844f, -0.33507606f, 0.11797274f, 0.07564888f, -0.28021443f, 
    0.09191161f, 0.07231115f, 0.14503559f, -0.01134119f, -0.09153825f, -0.24374564f, -0.13079081f, -0.06728622f, 
    0.15975276f, -0.06318156f, 0.01031251f, -0.05908374f, -0.02723658f, 0.10358378f, -0.04597342f, 0.02380856f, 
    -0.11195678f, -0.00145255f, 0.10144927f, -0.04992053f, 0.18362145f, -0.12219987f, -0.08421046f, 0.14304617f, 
    -0.10170409f, -0.00580341f, 0.19881032f, -0.24876495f, -0.22266467f, -0.11200822f, -0.17127620f, -0.17534946f, 
    0.08234018f, -0.34018838f, 0.52543187f, 0.13029723f, -0.20281595f, 0.11181516f, -0.04329626f, -0.00721854f, 
    0.12628342f, 0.06480492f, -0.10225599f, 0.28649244f, -0.05367650f, 0.05594489f, 0.06918260f, 0.13671429f, 
    0.01312042f, 0.37411657f, 0.19615668f, 0.38913336f, 0.07178335f, -0.06567153f, -0.02051647f, 0.01062623f, 
    -0.00046602f, -0.19053802f, 0.11250163f, 0.09715649f, -0.23220690f, -0.14045115f, 0.10238166f, -0.24769545f, 
    -0.21973495f, 0.04644433f, -0.32477060f, -0.06312080f, 0.43600518f, 0.03581930f, 0.00352190f, -0.03259091f, 
    -0.00042565f, 0.05561323f, -0.17105003f, -0.27304170f, 0.01031603f, -0.17420252f, 0.01210963f, 0.07353611f, 
    0.08184113f, -0.19171210f, 0.18462349f, -0.26934943f, -0.10737214f, -0.04688102f, 0.15564418f, 0.23614609f, 
    0.01899281f, 0.19905883f, 0.33706596f, 0.15601179f, 0.03862209f, 0.13191225f, -0.08781967f, 0.29352850f, 
    -0.10931765f, 0.19162843f, -0.46845046f, -0.01230843f, 0.00163583f, 0.08934966f, 0.16174418f, 0.00898471f, 
    0.27392560f, 0.19660963f, -0.01885300f, -0.17104733f, -0.11283007f, 0.02684953f, -0.03164520f, -0.08365306f, 
    0.11703616f, 0.09428914f, 0.19797273f, -0.16448148f, 0.49573597f, 0.05268854f, -0.27759993f, -0.27027130f, 
    -0.02120211f, -0.02839471f, 0.26951730f, -0.02542787f, 0.23663376f, 0.00444265f, -0.13119802f, 0.15401725f, 
    0.11913850f, 0.14417076f, 0.50053024f, 0.09815003f, 0.17900649f, 0.06547410f, -0.11025063f, -0.02233006f, 
    0.41068313f, 0.07128412f, 0.12960383f, 0.08801189f, 0.07704085f, 0.14173277f, -0.06992498f, -0.11778409f, 
    0.26949915f, 0.26519951f, -0.34614867f, 0.48168957f, -0.05920314f, -0.24357170f, 0.33419147f, -0.19162998f, 
    -0.13115714f, 0.00491223f, 0.28614807f, 0.31057060f, 0.00053708f, -0.13014126f, 0.16577612f, -0.09815419f, 
    -0.00702571f, -0.06819119f, 0.00960340f, -0.03245341f, 0.08871865f, 0.01886865f, 0.06116338f, -0.15899700f, 
    0.06865177f, 0.14179821f, 0.18501882f, -0.31797463f, -0.14650613f, -0.00423342f, 0.09806298f, -0.14769000f, 
    -0.26109904f, 0.15156981f, 0.04924460f, 0.00375267f, -0.31343627f, 0.03891403f, 0.44852859f, -0.00457038f, 
    -0.09711571f, 0.33236611f, 0.18946098f, 0.10053178f, 0.25063765f, -0.03981522f, 0.20570025f, -0.21286774f, 
    -0.09527467f, 0.00783662f, -0.03651241f, 0.15732853f, -0.11403089f, -0.07003216f, 0.17684133f, 0.11179263f, 
    0.17273173f, 0.16102360f, 0.03108197f, 0.13268724f, 0.15247391f, 0.04903749f, 0.14964491f, 0.11297842f, 
    0.17422605f, -0.16728337f, -0.35312188f, -0.44340006f, 0.25856915f, 0.17866699f, -0.11929513f, -0.28223637f, 
    0.13844641f, 0.07664549f, 0.51048994f, -0.25283492f, 0.23713073f, -0.11817217f, 0.16959783f, 0.22890759f, 
    -0.00814051f, 0.19215724f, -0.21234207f, 0.06077454f, 0.30913475f, 0.19450803f, -0.05647457f, -0.14826466f, 
    0.16791350f, -0.20156495f, -0.09931849f, -0.39364380f, -0.14017747f, 0.14671111f, 0.05974629f, 0.11536859f, 
    0.15223591f, -0.23593745f, -0.16735837f, 0.28127876f, -0.14711855f, -0.11155267f, 0.31031644f, -0.16998459f, 
    -0.08933028f, 0.15053257f, 0.01277831f, 0.13338007f, 0.06937764f, -0.03045972f, 0.25787890f, 0.08264309f, 
    0.29808986f, -0.35120928f, -0.12076212f, -0.09159678f, -0.23404303f, 0.14702219f, 0.13251211f, 0.01534953f, 
    0.18645029f, -0.06755783f, 0.13494906f, 0.15343152f, 0.05148998f, 0.15079096f, -0.01260559f, 0.07491160f, 
    0.20252609f, 0.30817050f, 0.44238794f, -0.09785076f, 0.33377314f, -0.09602943f, -0.35734761f, -0.30354825f, 
    0.07372776f, -0.11905629f, -0.24099261f, -0.03080074f, 0.04132474f, -0.02502392f, -0.01648477f, -0.00159339f, 
    0.11557344f, -0.01543666f, -0.37429065f, -0.02807575f, 0.07253642f, 0.20302613f, 0.14944670f, -0.13664865f, 
    0.31553912f, -0.26048085f, -0.12768462f, -0.14931564f, 0.04363003f, -0.08924793f, 0.08807494f, -0.06497540f, 
    -0.28343999f, 0.19459319f, 0.35059986f, 0.09431630f, 0.16912493f, -0.18985021f, -0.45833242f, -0.40321550f, 
    0.21759692f, -0.20540114f, -0.01681389f, 0.25129309f, 0.16700841f, -0.08601716f, 0.21348007f, -0.07504690f, 
    0.01315816f, 0.03810175f, 0.27840587f, 0.19565500f, 0.27627954f, 0.08187360f, -0.02741061f, -0.14864890f, 
    0.27663687f, -0.17864233f, -0.04886018f, -0.34870467f, 0.10582446f, -0.01299438f, 0.02435654f, -0.14969715f, 
    0.21721926f, -0.40048003f, 0.03860411f, -0.44080636f, 0.20229429f, 0.20759696f, 0.21910575f, -0.37978548f, 
    -0.04802014f, -0.01270288f, 0.11941243f, 0.27063620f, 0.01788577f, 0.07577925f, 0.06028173f, -0.13118152f, 
    -0.03340113f, 0.21256332f, -0.23337136f, 0.08560712f, 0.17109835f, -0.06262734f, 0.09052799f, -0.05813649f, 
    -0.01617957f, 0.13317311f, -0.16679135f, -0.17251626f, 0.08439527f, 0.10292148f, 0.02401816f, -0.11149281f, 
    -0.19127625f, -0.20356791f, -0.14146192f, -0.02725638f, 0.01947050f, -0.05406626f, 0.20915028f, -0.07902199f, 
    -0.10158364f, 0.25220218f, 0.25588387f, 0.17093629f, 0.16519615f, 0.12276673f, 0.30142042f, 0.06457730f, 
    0.09459686f, -0.17015125f, -0.06536665f, 0.18980977f, 0.17040101f, -0.03280417f, -0.16990443f, 0.00675101f, 
    -0.23662388f, 0.11233009f, -0.20528173f, 0.16372395f, 0.11910227f, 0.06653325f, -0.05146237f, 0.13906293f, 
    0.24854334f, -0.29793358f, -0.29627019f, -0.12463574f, 0.05640021f, 0.26920208f, 0.43097678f, 0.01766487f, 
    -0.11292735f, 0.22113645f, 0.20832288f, -0.25526538f, 0.05131721f, 0.08453412f, -0.17181614f, 0.25962251f, 
    0.11825090f, 0.08676296f, -0.18814990f, -0.07583127f, -0.00802546f, 0.26862508f, 0.09754714f, -0.15740575f, 
    -0.68937081f, -0.15099423f, 0.13563070f, -0.15576355f, 0.23707685f, 0.05114921f, 0.00041523f, 0.10840804f, 
    -0.16245894f, -0.16068974f, 0.25113398f, -0.35973394f, -0.13648669f, -0.04109900f, 0.52877408f, -0.10863716f, 
    0.28097948f, 0.12658565f, 0.08796706f, -0.23301615f, 0.15563978f, -0.04497641f, 0.36760622f, 0.05991267f, 
    0.03865442f, 0.23163347f, -0.12745951f, 0.07065926f, -0.24935441f, 0.10872180f, -0.01688652f, -0.13276263f, 
    0.49124077f, 0.04250864f, -0.10728087f, -0.02036375f, -0.17791197f, 0.03027373f, 0.08079456f, 0.11519581f, 
    -0.15787449f, 0.43053925f, 0.27217466f, -0.19376530f, 0.26689470f, -0.02989804f, -0.29382905f, -0.25231493f, 
    0.09194490f, 0.13831422f, 0.44414380f, 0.20733301f, -0.23500870f, 0.18079044f, -0.11254601f, 0.01559772f, 
    0.12701751f, 0.23086508f, -0.03348978f, 0.14086215f, 0.16725007f, -0.13095446f, -0.01686522f, -0.08832369f, 
    0.31868622f, -0.10765879f, 0.05662300f, -0.22502330f, 0.20080155f, -0.03019010f, -0.16846575f, 0.08590379f, 
    0.28039891f, -0.02487715f, -0.11089706f, -0.68639272f, 0.22676161f, 0.29466304f, 0.34198794f, -0.10215808f, 
    -0.10463741f, 0.32902277f, 0.45132825f, -0.19932827f, 0.06157435f, -0.02544910f, -0.09460930f, -0.03954062f, 
    0.07450114f, 0.02102675f, 0.08604001f, 0.13579337f, -0.02676244f, -0.13313287f, -0.14377354f, 0.11124171f, 
    0.04772589f, -0.01053923f, 0.08718240f, 0.06901674f, -0.03187480f, -0.03285084f, -0.10139202f, 0.13166551f, 
    -0.14517991f, -0.10428953f, 0.17598176f, 0.07762653f, 0.03284475f, -0.13523673f, 0.17531396f, -0.17642978f, 
    0.14979888f, -0.07587117f, 0.08780094f, -0.15172683f, 0.01608215f, -0.05803522f, -0.07692870f, -0.16855964f, 
    -0.09676409f, -0.19604763f, 0.00557602f, 0.04354127f, -0.16203815f, 0.16214180f, 0.03416681f, 0.14299370f, 
    -0.16116360f, -0.18398969f, -0.01696179f, 0.03864003f, 0.13158444f, -0.05923615f, -0.02122604f, 0.02326936f, 
    0.11316003f, -0.17883712f, -0.29648009f, 0.07820363f, 0.13433008f, -0.03655873f, -0.10441643f, -0.13389753f, 
    0.04654822f, -0.12838037f, -0.20755811f, -0.05027976f, -0.09970237f, 0.09254611f, 0.04752408f, -0.24165545f, 
    0.26583463f, -0.19151451f, 0.53527021f, -0.13771588f, -0.28602055f, 0.06592952f, 0.13742611f, -0.14212158f, 
    -0.35952646f, -0.25587434f, -0.08993886f, 0.14730802f, 0.02408420f, 0.11405921f, -0.05719006f, -0.11497127f, 
    -0.18319985f, -0.03471040f, 0.12481301f, 0.01973212f, -0.18329783f, 0.02207897f, 0.13975234f, 0.24335544f, 
    0.18412319f, 0.03490007f, -0.03919904f, 0.14919201f, -0.06352487f, 0.04820381f, 0.03427850f, 0.13203676f, 
    -0.09929971f, -0.04682619f, -0.31681603f, -0.11054064f, -0.16336940f, 0.23723692f, 0.16961408f, -0.12076472f, 
    -0.20826611f, 0.16820534f, 0.06684592f, 0.22379871f, -0.15209557f, -0.00980338f, -0.01243033f, -0.00863455f, 
    0.06013096f, 0.27318829f, 0.36848611f, -0.07963447f, 0.24494995f, 0.18174979f, -0.15964946f, -0.02773129f, 
    -0.12263831f, -0.15352397f, -0.25927588f, -0.00650898f, -0.43489552f, -0.02598863f, 0.02330635f, 0.05351706f, 
    -0.19353408f, -0.18978003f, -0.06263621f, 0.07614016f, -0.15081711f, 0.04214076f, 0.15268153f, 0.16758025f, 
    -0.14569889f, -0.22387248f, 0.00017133f, -0.15223935f, -0.02371637f, -0.12494096f, 0.02295762f, 0.08172405f, 
    -0.02271451f, 0.05216748f, 0.10083380f, 0.02790088f, 0.01334051f, -0.04565416f, -0.03161574f, 0.11414219f, 
    -0.12718470f, -0.12292290f, 0.03759924f, -0.09201823f, -0.14980228f, 0.09869245f, -0.02076051f, -0.21397069f, 
    0.04275620f, -0.44941762f, -0.41194797f, 0.09866847f, -0.44169888f, 0.09171194f, 0.15340330f, -0.16719839f, 
    -0.35587528f, 0.10853385f, -0.05766360f, 0.22450499f, 0.16303949f, 0.05036426f, -0.13956483f, 0.00519810f, 
    -0.70300734f, -0.06098705f, -0.02863471f, -0.48533791f, -0.14590387f, 0.17538407f, 0.21151221f, -0.17661254f, 
    0.30255467f, 0.30035731f, -0.28002471f, -0.03500989f, 0.21301454f, 0.13922253f, -0.08518708f, -0.00302193f, 
    0.27700937f, -0.12191108f, 0.00330866f, -0.15714404f, -0.26514572f, 0.20555146f, -0.09896622f, 0.05239607f, 
    -0.40753677f, -0.01790670f, -0.02697656f, 0.04269642f, 0.29561844f, 0.08868274f, -0.05164231f, 0.01240945f, 
    -0.28350946f, 0.10870124f, -0.18675499f, -0.23355450f, 0.35890305f, 0.21374574f, -0.04794586f, -0.06287520f, 
    0.23255563f, 0.13910188f, -0.02760420f, -0.35864243f, 0.21658602f, 0.10757931f, 0.25003892f, -0.03059442f, 
    0.35365981f, -0.32861614f, 0.34755540f, -0.13599946f, 0.18567868f, 0.23306204f, 0.13791040f, 0.06853202f, 
    0.25180498f, -0.00602645f, 0.00531722f, -0.10314865f, -0.02094361f, 0.10318457f, 0.15466978f, 0.05846086f, 
    0.06900726f, 0.14815176f, 0.10632292f, -0.23054561f, 0.44459894f, 0.18369995f, -0.36637199f, -0.26822406f, 
    0.14452095f, -0.26782030f, -0.12072289f, 0.04284682f, -0.35203177f, -0.03760510f, -0.14592804f, -0.18207842f, 
    -0.13482770f, 0.16751149f, 0.28730255f, 0.02578400f, -0.04395021f, 0.26660755f, 0.07390103f, 0.07237960f, 
    0.18646191f, -0.09158409f, -0.05623599f, 0.06713378f, -0.17959644f, 0.02294264f, 0.16503935f, -0.09158237f, 
    -0.13693583f, -0.07666162f, 0.31559202f, 0.00833559f, 0.36560276f, -0.01526557f, -0.28757945f, 0.02284268f, 
    0.25598553f, -0.29272401f, -0.31637210f, 0.14226055f, -0.20962380f, -0.03798434f, -0.03211694f, -0.03150165f, 
    0.01268114f, -0.19641435f, 0.00553669f, -0.10023478f, -0.11167365f, 0.02868309f, 0.10692132f, 0.16779684f, 
    -0.07266672f, 0.18110447f, 0.08742826f, 0.48934475f, 0.01106416f, 0.13082692f, -0.05670170f, -0.02211050f, 
    0.11648086f, -0.20604777f, 0.06173252f, 0.53242368f, -0.19128560f, 0.22309695f, -0.30547911f, 0.04864670f, 
    0.25411138f, 0.02854449f, -0.47403768f, -0.02908470f, -0.22980632f, -0.01268663f, 0.03078071f, 0.03829502f, 
    0.18463425f, -0.60578084f, -0.15418141f, 0.12731281f, -0.30235001f, 0.25296721f, -0.02324970f, -0.07966862f, 
    -0.08739125f, 0.05383839f, -0.00692505f, 0.25368580f, 0.28909373f, 0.13094704f, -0.10649525f, -0.13744070f, 
    -0.04441408f, -0.07101799f, -0.33511090f, 0.26641181f, 0.21026428f, 0.10191787f, -0.31034487f, -0.37901819f, 
    0.32502788f, -0.21349590f, -0.17197080f, -0.14755593f, 0.26544815f, 0.06929315f, -0.03724955f, -0.17846312f, 
    -0.11207577f, 0.13064075f, -0.07096229f, 0.00222865f, 0.20744428f, 0.04183570f, 0.11269406f, 0.07345625f, 
    0.20025200f, -0.24291915f, -0.11033687f, -0.04620280f, 0.00563188f, 0.12667291f, 0.17444113f, -0.14603092f, 
    0.01223517f, -0.10968928f, 0.23948248f, -0.45010024f, 0.01269077f, 0.13727997f, 0.09000580f, -0.14658059f, 
    0.23605068f, 0.08799423f, -0.23447104f, 0.21705845f, 0.00464862f, 0.08524486f, 0.09933874f, -0.29510817f, 
    -0.04136064f, -0.13660976f, -0.08868789f, -0.14369780f, -0.01895442f, -0.13730881f, -0.08775800f, -0.09610118f, 
    0.08726202f, -0.07868960f, -0.16094436f, -0.03934135f, 0.09795250f, -0.07195457f, -0.10847115f, 0.15270039f, 
    -0.12741977f, -0.18702266f, -0.10658078f, 0.12393256f, 0.03102372f, 0.10692353f, -0.09520684f, -0.16566369f, 
    -0.09871838f, -0.13145746f, -0.17873327f, -0.21295118f, 0.02320230f, -0.06384036f, -0.09773707f, 0.12129666f, 
    0.02931941f, -0.17686206f, 0.01622070f, -0.16407335f, 0.04132221f, -0.23416120f, 0.14889455f, -0.01561330f, 
    0.22196043f, 0.27682877f, -0.06471018f, 0.04821548f, -0.01781639f, 0.07162348f, 0.05541495f, -0.07347033f, 
    0.30039144f, -0.01614604f, -0.06353869f, -0.51321870f, 0.23018958f, 0.37651071f, 0.17035875f, -0.25287020f, 
    0.17549530f, 0.36599374f, 0.30219075f, -0.58041477f, 0.04400438f, 0.05884570f, -0.17355067f, 0.08220353f, 
    0.05842569f, -0.26697132f, 0.07835939f, -0.13647635f, -0.48890698f, 0.10884377f, -0.17018285f, -0.00727357f, 
    -0.02303265f, -0.02247429f, 0.16502239f, 0.31150979f, 0.14282490f, 0.03746327f, 0.04062318f, -0.05395910f, 
    -0.02643891f, 0.31666991f, 0.37853390f, 0.24531804f, 0.10953491f, 0.22680561f, -0.24180378f, -0.06719358f, 
    0.30271018f, -0.21979567f, -0.11803956f, -0.08890105f, -0.08259414f, -0.15364745f, 0.06019701f, -0.04647956f, 
    0.06197345f, 0.00078185f, 0.34309399f, -0.12023105f, -0.14334090f, 0.20471990f, -0.02872621f, -0.13423905f, 
    -0.44839367f, -0.00074986f, 0.04137728f, -0.08017094f, -0.02192109f, -0.08388174f, -0.16132315f, -0.06545245f, 
    -0.05210944f, 0.11760657f, 0.30427077f, 0.19048703f, -0.15339288f, -0.19959691f, 0.53144968f, 0.06929599f, 
    -0.11199119f, 0.23705114f, -0.14173609f, 0.04539022f, 0.09770291f, 0.01768421f, -0.00495326f, 0.08977741f, 
    0.21928842f, 0.11166199f, 0.26013184f, 0.07571904f, -0.24656235f, -0.00092560f, 0.01111324f, -0.12184807f, 
    0.33662957f, 0.22448556f, -0.02808074f, 0.03580020f, 0.20200638f, 0.09841211f, -0.08204922f, 0.12683959f, 
    0.18130207f, 0.40135863f, -0.16673179f, 0.30368859f, 0.09989894f, -0.15817541f, -0.32144231f, 0.02976673f, 
    -0.07426082f, -0.08843914f, 0.31102777f, 0.13105319f, -0.09440151f, 0.11673420f, 0.01978954f, -0.01705883f, 
    0.12901396f, 0.22592625f, -0.06622209f, -0.04514363f, 0.28301451f, -0.06145988f, 0.02039932f, -0.16913790f, 
    0.25786665f, 0.11064374f, -0.03692750f, -0.03184930f, -0.19895467f, -0.04977635f, 0.04338293f, 0.00969362f, 
    0.11715984f, -0.21408629f, -0.10886053f, 0.20054340f, -0.10436390f, 0.06696715f, 0.02015728f, -0.16970620f, 
    -0.12579997f, 0.12330459f, 0.02154751f, 0.00565583f, 0.21255022f, -0.08071539f, 0.14557110f, 0.16334486f, 
    0.28564128f, -0.19057238f, 0.41629684f, 0.13695505f, -0.24008960f, -0.14595799f, -0.16323055f, 0.03388578f, 
    -0.01299287f, 0.26829156f, 0.02939571f, -0.05608824f, 0.08363958f, 0.08305622f, -0.05910965f, -0.15092261f, 
    0.19875893f, 0.06260692f, -0.37470448f, 0.04566604f, -0.02724942f, 0.28902507f, 0.47548756f, -0.06008614f, 
    -0.13537696f, 0.29065397f, 0.21499787f, -0.11654736f, -0.00709156f, -0.06896290f, 0.08109669f, 0.26888737f, 
    0.18983889f, -0.13149644f, -0.32914257f, -0.12006362f, -0.14045469f, -0.13783656f, 0.01227560f, -0.00470684f, 
    -0.15489513f, 0.29508314f, 0.13854693f, 0.07722820f, 0.41041493f, 0.07704259f, 0.14713588f, -0.04753918f, 
    0.23271179f, -0.25122920f, -0.28979287f, 0.30821401f, 0.01856286f, 0.22278933f, 0.09580822f, -0.26025757f, 
    0.16659492f, 0.18899967f, 0.11561016f, -0.19834878f, 0.12314267f, -0.01770075f, 0.09423617f, 0.27834126f, 
    0.25530982f, -0.03333831f, 0.44036484f, -0.03484710f, -0.30140001f, 0.13022342f, 0.06639168f, 0.05328122f, 
    0.26693317f, -0.05751976f, 0.14822389f, 0.17697787f, -0.28988901f, 0.03570376f, 0.06499784f, -0.13767831f, 
    0.23488796f, 0.16447680f, -0.31332758f, 0.40928951f, 0.05087896f, 0.19422340f, -0.32817984f, 0.04378213f, 
    0.07408147f, -0.04540392f, 0.11998457f, 0.07155380f, -0.37710485f, -0.00965680f, 0.05321702f, -0.18858723f, 
    -0.21700338f, 0.12913445f, -0.02976123f, 0.01387210f, 0.15011674f, 0.19279647f, 0.13485523f, 0.12299140f, 
    -0.05998995f, 0.10761509f, -0.07028741f, -0.00762177f, 0.14850241f, -0.06014745f, 0.05154207f, 0.14856672f, 
    -0.06559566f, -0.30045459f, -0.22186257f, 0.18541330f, -0.05776162f, 0.00390671f, 0.06745232f, -0.19087291f, 
    -0.19964479f, 0.28456584f, 0.35699612f, -0.03591566f, 0.14467590f, 0.01525289f, 0.18928447f, 0.17521583f, 
    -0.02724193f, -0.16729981f, -0.00722314f, 0.01562683f, -0.20218536f, 0.10373564f, -0.12895648f, -0.13111147f, 
    0.30109325f, -0.49360555f, -0.10615520f, 0.18345411f, 0.03080748f, 0.02140419f, 0.00187065f, 0.15090239f, 
    0.29374200f, -0.52415776f, -0.31616968f, 0.34763417f, -0.09018966f, -0.20629002f, 0.28452915f, -0.16968460f, 
    0.01510317f, 0.00688027f, 0.23815006f, 0.22021936f, 0.18930632f, -0.05076335f, 0.27394018f, -0.40972859f, 
    0.01097333f, -0.25246483f, 0.15892403f, -0.14381301f, 0.29236218f, 0.12003148f, -0.09150450f, -0.02898300f, 
    0.00349566f, -0.17104024f, 0.00649004f, -0.16700140f, 0.19820824f, 0.07999568f, -0.00974981f, -0.06460050f, 
    0.10613421f, -0.34884122f, -0.13494621f, 0.18036158f, 0.10162694f, 0.02613121f, 0.15735477f, -0.01897273f, 
    -0.01754550f, 0.16081582f, 0.11968638f, -0.00063894f, 0.26466343f, -0.07655919f, 0.40545052f, -0.15294822f, 
    0.24700934f, -0.03875726f, 0.12395369f, -0.02682276f, 0.09903916f, -0.32900500f, 0.01841549f, 0.15227151f, 
    0.27643040f, -0.29225242f, 0.12044311f, -0.02060205f, 0.32467908f, -0.12328797f, 0.12079459f, 0.09514274f, 
    -0.13045563f, 0.15278229f, 0.45393407f, 0.01775253f, -0.21217000f, 0.03027006f, -0.09597319f, 0.13640372f, 
    -0.46088749f, -0.45357004f, 0.44909266f, -0.03237585f, -0.08910134f, 0.10714322f, -0.21646555f, -0.13165435f, 
    -0.14244230f, -0.19241716f, -0.05767121f, -0.07134563f, -0.62787503f, -0.06043086f, -0.08588263f, -0.05290414f, 
    -0.39572811f, 0.33538723f, -0.04534734f, 0.27510053f, 0.51160693f, 0.11167744f, -0.10270217f, -0.15436594f, 
    -0.01912339f, 0.02668410f, -0.19798858f, 0.01403667f, -0.09989635f, 0.23671860f, 0.23279519f, -0.31644538f, 
    0.13532813f, 0.14863002f, -0.30541253f, -0.10332977f, 0.38121966f, -0.10322114f, 0.05218320f, 0.25015992f, 
    0.08082513f, -0.03173628f, -0.08340558f, -0.08875340f, 0.02226285f, -0.16265520f, 0.09747019f, 0.07130575f, 
    -0.13413288f, -0.04119783f, 0.03964853f, -0.17738776f, 0.01581535f, -0.04303467f, -0.07413401f, -0.10260954f, 
    -0.16772415f, 0.13143490f, -0.05479720f, -0.11453614f, 0.12375145f, -0.08694820f, 0.15010558f, -0.06935445f, 
    -0.13202155f, -0.10049456f, -0.08392349f, -0.21100970f, -0.05032648f, -0.08916374f, -0.09814682f, 0.12899558f, 
    0.05450824f, 0.00245707f, -0.25679412f, -0.11726854f, -0.35596269f, 0.00807914f, -0.05614479f, -0.12903774f, 
    0.55253345f, -0.07701295f, -0.06407385f, 0.04334202f, 0.07296284f, 0.13436179f, -0.07933845f, 0.03342150f, 
    -0.13612282f, 0.34960753f, 0.24165939f, -0.14057581f, 0.28558478f, 0.08918150f, -0.43268025f, -0.02083591f, 
    -0.09608027f, 0.08468245f, 0.44496351f, 0.04444812f, 0.01178858f, 0.08652031f, 0.03658770f, 0.16953973f, 
    0.03496862f, -0.21233481f, 0.35986379f, 0.00381958f, -0.45980400f, -0.03138749f, -0.00845145f, 0.02259601f, 
    -0.21725251f, -0.00683646f, -0.06742313f, 0.25844601f, 0.35414621f, -0.10656233f, -0.09787729f, -0.13739194f, 
    0.03007440f, 0.32949570f, -0.27542749f, 0.34162080f, -0.24472348f, 0.02677415f, 0.17270827f, 0.07851872f, 
    -0.01260134f, 0.11575998f, 0.15809973f, 0.12024880f, -0.03236864f, -0.04587658f, -0.14494610f, 0.01002186f, 
    0.05976086f, -0.60690892f, 0.20224620f, -0.13124107f, -0.26062331f, -0.05942039f, 0.09944036f, -0.10380765f, 
    0.09952947f, 0.36281264f, -0.06779195f, 0.13151214f, 0.31970343f, 0.15340392f, 0.12623581f, 0.08304432f, 
    0.15721016f, 0.09431130f, -0.34092498f, 0.45097306f, -0.08284307f, 0.26817453f, -0.13459367f, -0.14242716f, 
    0.22633320f, -0.12920970f, -0.26030672f, -0.24190661f, 0.21381502f, 0.14594695f, -0.08330490f, 0.05962803f, 
    -0.14795947f, -0.29952964f, -0.00108841f, 0.16341037f, 0.32285774f, 0.27940020f, 0.07444887f, 0.01280220f, 
    -0.19151928f, 0.04408941f, 0.04182533f, -0.20804445f, 0.21921574f, 0.06901085f, -0.13293742f, -0.10838777f, 
    0.05861520f, -0.24888587f, -0.24649888f, 0.05153176f, -0.15997075f, 0.09893434f, -0.09271443f, -0.23077580f, 
    0.20536113f, 0.09418527f, -0.27522731f, 0.19311590f, 0.28237098f, -0.09748906f, 0.32762277f, -0.01623649f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.22890058f, 0.08150236f, -0.15608792f, 0.12256990f, -0.01973413f, 0.20898965f, 0.13350157f, -0.06716342f, 
    0.10328961f, 0.04235540f, 0.00937390f, -0.11068922f, -0.13187930f, 0.16484444f, -0.04134915f, 0.00982794f, 
    -0.05078664f, -0.00172994f, 0.21973667f, -0.13058473f, 0.07945266f, -0.07791947f, -0.04467559f, 0.23293169f, 
    -0.06610319f, 0.19856885f, 0.13082179f, -0.01245403f, -0.00047849f, -0.01318024f, 0.20027648f, 0.20209011f, 
    -0.12279212f, -0.04359634f, -0.13845739f, 0.39004165f, 0.21162497f, -0.14905907f, 0.36111107f, 0.33556926f, 
    0.09888647f, 0.13976227f, 0.18573904f, 0.19552143f, 0.20084311f, -0.02333742f, -0.00229798f, 0.14843421f, 
    0.21429971f, 0.02867149f, -0.16596654f, -0.04863669f, -0.07021710f, 0.09139565f, 0.09512609f, -0.25495571f, 
    0.26109529f, 0.20499900f, 0.04615458f, -0.13578318f, -0.02398937f, 0.27092263f, 0.19809890f, 0.09309167f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.04184642f, -0.07636464f, -0.09865768f, -0.22811912f, -0.01324997f, 0.17476900f, 0.01027428f, -0.07486205f, 
    0.20638701f, -0.11254434f, -0.60460198f, 0.07566379f, -0.12523618f, -0.07963134f, 0.12412655f, -0.09131852f, 
    -0.50179422f, -0.01866925f, -0.46088418f, -0.15051028f, -0.35127172f, -0.18415679f, 0.24587354f, -0.06711720f, 
    -0.08096112f, -0.48683733f, -0.11276788f, 0.19256715f, 0.21484919f, 0.15084958f, 0.30032951f, -0.30382118f, 
    0.16013572f, -0.09443655f, 0.03202435f, 0.05355021f, -0.10780361f, -0.07876922f, 0.31322479f, 0.11335000f, 
    -0.42910710f, -0.35253844f, -0.12658857f, -0.13300420f, 0.13795240f, 0.08310705f, 0.15141658f, -0.16663112f, 
    0.12556040f, -0.45860136f, -0.08601486f, 0.22728409f, 0.08489656f, -0.02905660f, 0.02975966f, -0.07527177f, 
    0.16204625f, 0.06332497f, 0.33163744f, -0.05779894f, -0.10526545f, 0.09865720f, -0.09777576f, 0.13522293f, 
    0.08507001f, 0.09639908f, 0.04749952f, -0.04946759f, -0.04564421f, -0.11521743f, -0.07283983f, -0.02610030f, 
    -0.04462793f, -0.12238338f, -0.05455060f, -0.07500114f, 0.02365236f, -0.09085228f, 0.07979193f, -0.01390719f, 
    0.09959713f, -0.04480122f, -0.13480888f, 0.00760860f, 0.06872673f, 0.02139339f, -0.00403415f, -0.03196015f, 
    -0.10228624f, -0.00938883f, -0.09072019f, -0.02841906f, 0.05999123f, -0.04764862f, -0.12980802f, 0.09610786f, 
    -0.14616364f, 0.00413801f, -0.03301722f, -0.09530190f, -0.00704214f, 0.04662834f, -0.09156508f, -0.00889719f, 
    0.09110333f, -0.09789297f, -0.04502293f, 0.01437662f, 0.02993386f, -0.06256674f, -0.11832427f, -0.01559229f, 
    -0.07486965f, -0.02067628f, 0.05709184f, 0.09557971f, 0.04469381f, -0.12384269f, -0.01942704f, -0.09342504f, 
    -0.05316568f, 0.08379777f, -0.00228322f, 0.05492876f, 0.08133746f, -0.05639657f, 0.10314605f, 0.02690206f, 
    -0.07060378f, -0.06505836f, -0.38927922f, 0.16833548f, 0.12088484f, 0.08169662f, -0.20231377f, 0.07794648f, 
    0.16359271f, -0.14860910f, 0.17208630f, -0.08359784f, -0.10157121f, 0.02562505f, 0.00078379f, 0.07171384f, 
    0.01050279f, 0.01579532f, -0.08127454f, -0.00008705f, 0.24526583f, 0.03699526f, -0.28085393f, 0.27080423f, 
    0.10091720f, 0.03197943f, -0.12846869f, -0.15687972f, -0.05753721f, 0.22685339f, 0.04260473f, -0.22708803f, 
    0.02021159f, -0.00082959f, 0.04088019f, -0.12283485f, 0.06809378f, 0.05616447f, -0.24057604f, 0.19837859f, 
    -0.07590220f, -0.11057749f, 0.13652791f, 0.16072012f, -0.15348879f, 0.06790798f, 0.29449469f, 0.20239900f, 
    -0.24447338f, 0.09046812f, -0.09073171f, 0.14878562f, 0.34906733f, 0.03972710f, 0.10058510f, -0.06526861f, 
    0.13535073f, -0.43077698f, 0.07839235f, -0.09300037f, -0.01791386f, -0.04957927f, 0.10740601f, 0.08905625f, 
    -0.01158248f, 0.00334109f, 0.26801232f, -0.05073247f, -0.03107978f, 0.35681185f, 0.26411870f, 0.13360563f, 
    0.10587414f, -0.00971245f, 0.12953557f, 0.05938127f, -0.19382085f, -0.00736338f, 0.18134294f, -0.04365526f, 
    -0.21514347f, -0.14579077f, 0.16128345f, 0.04066506f, -0.03397223f, -0.00387108f, 0.00946168f, -0.01154353f, 
    0.04077465f, 0.16773745f, 0.30941874f, 0.11901273f, 0.22402389f, -0.17974855f, 0.63610345f, 0.05405332f, 
    -0.13105443f, -0.13806345f, 0.00938546f, 0.02956944f, 0.18347487f, -0.03201178f, 0.31427544f, 0.14631593f, 
    -0.12077788f, 0.21840248f, -0.14938597f, 0.09643849f, 0.13010582f, 0.04889166f, -0.28826487f, 0.04138115f, 
    0.36110336f, 0.11768333f, -0.10972163f, -0.09749795f, -0.14179070f, 0.02345071f, 0.04368870f, 0.26248422f, 
    0.14279112f, -0.38854617f, -0.00020263f, 0.09329002f, -0.18896295f, -0.05104187f, -0.08382478f, 0.08915993f, 
    0.03007711f, -0.05944389f, -0.09073853f, -0.07955424f, -0.03654440f, 0.02044761f, -0.06280783f, -0.08085567f, 
    0.05298142f, -0.05038033f, -0.08448169f, 0.10834612f, -0.06793417f, -0.02311493f, 0.04083246f, -0.04747526f, 
    -0.00050142f, 0.00990172f, -0.08197762f, -0.00982790f, 0.05950890f, -0.11461507f, -0.11888489f, -0.10701822f, 
    -0.05503665f, -0.06665882f, 0.00310552f, -0.03898008f, -0.11665741f, -0.06310935f, 0.05128038f, -0.05412205f, 
    -0.07787968f, 0.02039061f, -0.05932418f, 0.01533720f, 0.03857724f, 0.08922836f, -0.00058997f, 0.03284581f, 
    -0.00702414f, -0.11512779f, 0.07532696f, -0.00481246f, -0.02010445f, -0.03411825f, -0.03457449f, 0.00305586f, 
    -0.11115968f, -0.08116145f, -0.05743703f, 0.10457066f, -0.04036295f, -0.09172134f, -0.00078662f, 0.01558127f, 
    -0.07380717f, 0.11224717f, 0.01877436f, -0.09382907f, -0.11126891f, -0.12411505f, -0.08278763f, -0.09064250f, 
    0.02869437f, -0.09807680f, -0.01771346f, 0.07244869f, 0.08241867f, 0.24172792f, -0.35789326f, 0.01722213f, 
    0.13720873f, 0.07006434f, -0.12292042f, -0.09696048f, 0.00250880f, 0.02998094f, 0.14123671f, 0.11019325f, 
    -0.03670846f, 0.33009261f, -0.09175287f, 0.06094176f, 0.18893778f, -0.20198372f, -0.20284691f, 0.21678351f, 
    -0.33225352f, -0.07216774f, -0.12158522f, -0.05662844f, -0.03268480f, 0.12985124f, 0.13246106f, 0.17418213f, 
    0.11016203f, 0.12651384f, -0.12707442f, 0.19719417f, 0.05022642f, 0.05431443f, 0.52471691f, 0.16493730f, 
    -0.10896195f, -0.08204104f, -0.04418194f, 0.08578987f, 0.03108438f, 0.11337892f, 0.43214050f, 0.20735472f, 
    0.05177514f, -0.02667681f, -0.23166835f, 0.22758444f, 0.11847469f, 0.07760353f, -0.01681935f, -0.29065514f, 
    -0.12140244f, 0.51236445f, 0.07119792f, 0.07757001f, 0.25504923f, 0.24211799f, 0.15133950f, -0.07065297f, 
    0.03822490f, -0.01086953f, 0.00684596f, -0.08289649f, 0.21315408f, 0.25244907f, -0.20557861f, 0.19332159f, 
    0.35737300f, -0.07792699f, -0.27189431f, -0.08456554f, -0.02713044f, 0.09588915f, 0.33277154f, -0.00156043f, 
    -0.04435439f, 0.27063116f, -0.17097597f, 0.03615065f, 0.22794041f, -0.12005458f, 0.07756189f, 0.25295779f, 
    0.17505807f, 0.19346696f, -0.23978007f, -0.06266857f, 0.00670074f, 0.24252722f, 0.15909436f, 0.08401781f, 
    0.26558635f, 0.02387845f, -0.04644128f, -0.05340924f, 0.32610816f, -0.03185655f, 0.10772940f, 0.13817199f, 
    -0.20540121f, 0.03190117f, -0.04441948f, 0.00658067f, -0.01142698f, -0.10484257f, 0.41697514f, 0.07461847f, 
    0.11624551f, -0.12356025f, -0.05412550f, 0.09524886f, 0.33412459f, 0.02614779f, 0.18270244f, 0.08266392f, 
    -0.08319931f, 0.27283520f, 0.23258984f, -0.09836787f, 0.15923055f, 0.09306260f, 0.00647280f, -0.14399892f, 
    0.05756896f, -0.03791635f, 0.04186366f, -0.05972343f, 0.03459237f, -0.00424559f, 0.00270017f, 0.01101164f, 
    -0.13168904f, -0.13003324f, 0.00659292f, -0.09438966f, 0.00303936f, -0.09944344f, -0.02488354f, -0.05388503f, 
    -0.07895523f, -0.09540173f, -0.09023096f, -0.10723279f, -0.11135793f, -0.10260193f, -0.08628869f, -0.15212196f, 
    -0.00994388f, -0.03844872f, 0.08766518f, -0.04961922f, -0.02742317f, 0.08436063f, 0.03250010f, 0.04146815f, 
    0.02608906f, 0.08290753f, -0.11429109f, -0.14294043f, -0.05005347f, 0.11680050f, -0.04662532f, 0.05836743f, 
    0.09953295f, 0.02488704f, 0.00725095f, -0.02891974f, 0.04357647f, -0.00042278f, -0.09446131f, -0.01176269f, 
    -0.10544200f, -0.14415379f, -0.13499051f, -0.12769893f, 0.05423452f, -0.13234814f, 0.04549906f, -0.08450110f, 
    0.01239402f, -0.09837030f, -0.01506746f, -0.09066500f, 0.01454949f, 0.06916615f, 0.05026205f, 0.00034823f, 
    0.01604709f, -0.11794053f, 0.38187677f, 0.10661192f, -0.01573459f, -0.15539046f, 0.34666184f, 0.11318370f, 
    -0.25187385f, 0.10097644f, 0.12468387f, -0.09709825f, -0.05951728f, 0.02876524f, 0.03568995f, -0.04279694f, 
    -0.01848591f, 0.22430386f, 0.38491243f, -0.22746938f, -0.02128501f, 0.35915995f, 0.30804676f, -0.11544407f, 
    0.08916748f, -0.08503428f, 0.01643597f, 0.18314318f, 0.04383542f, -0.16015868f, 0.14558078f, 0.29072633f, 
    -0.30577198f, -0.04685163f, -0.07126733f, 0.14031272f, -0.04736082f, 0.03688398f, -0.36292219f, -0.05110711f, 
    -0.02600512f, 0.13742314f, -0.07824127f, -0.58021712f, 0.10234133f, 0.10107711f, -0.45422113f, -0.04660663f, 
    0.03216619f, 0.21133226f, -0.14992197f, -0.05329576f, -0.37809712f, -0.05741440f, 0.11145151f, 0.07822391f, 
    0.05208716f, 0.01599420f, -0.43426678f, 0.05622687f, -0.01489819f, 0.16067962f, -0.45317507f, 0.04674297f, 
    -0.03995792f, -0.04878560f, 0.07230585f, -0.16788869f, -0.00569890f, 0.12757966f, 0.15091640f, 0.02525841f, 
    0.13958903f, 0.15736069f, 0.20381266f, -0.04530676f, -0.02377916f, -0.01032276f, 0.01587733f, -0.11603804f, 
    -0.10726960f, -0.10345043f, 0.12915047f, 0.00169420f, 0.22832277f, 0.18965951f, -0.22450309f, -0.08170395f, 
    -0.01367857f, 0.08402763f, 0.44884083f, 0.23494984f, 0.05806662f, -0.24244998f, 0.18682082f, 0.21455482f, 
    -0.04899982f, 0.07802903f, -0.04964873f, -0.07762671f, 0.27230078f, 0.13001990f, -0.19011018f, -0.09751057f, 
    0.19701484f, 0.20265734f, 0.01838401f, -0.14334030f, 0.25460279f, 0.10123631f, -0.31326249f, 0.00910505f, 
    0.07998261f, 0.06460980f, 0.01026254f, -0.28861529f, -0.38772541f, 0.13464497f, 0.14185973f, -0.51779157f, 
    -0.01038115f, -0.09188724f, -0.53018451f, 0.09688505f, -0.01272799f, -0.21953459f, -0.44607207f, -0.16521512f, 
    -0.12468690f, 0.10437064f, 0.01039704f, -0.06948351f, -0.06990828f, 0.05851898f, -0.09838232f, -0.07174375f, 
    0.01972171f, 0.01147211f, 0.01031226f, 0.00670028f, -0.01673602f, -0.12384263f, -0.03085383f, -0.01703653f, 
    -0.11221088f, 0.01739964f, -0.12226104f, -0.08828948f, 0.02474373f, 0.05998595f, -0.07679933f, 0.07882798f, 
    0.04250250f, -0.04937134f, -0.01608562f, -0.03632018f, 0.00903114f, -0.13736500f, 0.04309335f, -0.01513323f, 
    -0.06800111f, -0.06635484f, -0.03714199f, -0.04501889f, -0.11356983f, 0.03903820f, -0.10514279f, 0.02171106f, 
    0.00235795f, 0.06328272f, -0.04174237f, -0.04950010f, -0.01287858f, 0.04213318f, 0.10044393f, -0.02045608f, 
    0.04692183f, -0.02923225f, -0.11896463f, -0.10613084f, 0.05993161f, -0.07283326f, -0.12840131f, -0.05191797f, 
    -0.05932974f, -0.00302219f, -0.06900340f, -0.03263101f, -0.10448930f, -0.02677757f, -0.06388748f, -0.11382612f, 
    0.02296019f, -0.02900484f, -0.01932033f, -0.08115713f, -0.00221921f, -0.11932055f, 0.08257127f, -0.09780400f, 
    -0.03729475f, 0.03359548f, -0.08854008f, 0.03947267f, -0.10322056f, -0.04006571f, -0.00978369f, -0.01674978f, 
    -0.05244449f, 0.02612525f, -0.01768028f, 0.01750908f, 0.04189809f, 0.10326158f, -0.09242954f, 0.09427897f, 
    -0.05994197f, -0.04739824f, 0.05199535f, 0.08127999f, -0.11017662f, -0.02347923f, -0.06561999f, -0.11079165f, 
    -0.13034880f, 0.07562251f, -0.09068435f, -0.11987121f, 0.01278208f, 0.08051653f, 0.02970018f, -0.10827087f, 
    -0.02208208f, 0.07147034f, -0.02924073f, 0.01905934f, -0.14851534f, 0.01658797f, -0.08796506f, 0.07592734f, 
    -0.15195037f, -0.13064985f, -0.09209629f, 0.01542781f, 0.12544569f, -0.09042023f, -0.07825790f, -0.03392854f, 
    -0.10827446f, 0.15723436f, 0.03736172f, 0.03454152f, 0.00957636f, -0.11085650f, 0.12311064f, -0.11768346f, 
    -0.19065791f, 0.13045484f, 0.08136450f, 0.14345767f, -0.13800496f, -0.10836999f, 0.26281056f, 0.15292840f, 
    -0.05141382f, -0.09661663f, 0.36498755f, 0.02959416f, -0.02781773f, -0.09793504f, 0.10749305f, -0.07881472f, 
    -0.13327400f, 0.26525542f, -0.17083530f, -0.07565583f, 0.08822885f, -0.01803952f, 0.31693387f, 0.24756221f, 
    0.25155559f, -0.00327139f, 0.37600869f, 0.39182690f, 0.18413118f, -0.10176294f, 0.30336758f, 0.15168099f, 
    0.33002993f, -0.10247128f, 0.18258788f, -0.14173739f, -0.03810756f, -0.06732256f, 0.16423741f, 0.10461026f, 
    0.08722730f, -0.07030471f, -0.16660352f, -0.04485459f, 0.36294022f, 0.11103477f, 0.07582049f, -0.18844126f, 
    -0.11673456f, -0.05649403f, 0.05716398f, 0.05301299f, 0.01800615f, 0.08662207f, 0.16640329f, 0.37522858f, 
    0.26171848f, -0.13494062f, -0.11488587f, 0.09899479f, 0.13915715f, -0.05300336f, -0.35988683f, 0.16439286f, 
    0.03522580f, -0.04967036f, -0.16608891f, 0.12076969f, -0.15177096f, -0.16064063f, 0.23486978f, 0.12119534f, 
    0.00348310f, 0.05719359f, 0.24462886f, -0.03292457f, 0.07726087f, 0.04381669f, -0.06431715f, 0.08791798f, 
    -0.06900232f, -0.23484626f, -0.15733674f, 0.07667920f, 0.02118710f, 0.27932629f, -0.16099408f, 0.02652453f, 
    0.12978867f, -0.18820661f, 0.02205330f, 0.41414866f, 0.09254545f, 0.04388585f, 0.09134231f, 0.02905895f, 
    0.06055777f, -0.06056586f, 0.05793834f, -0.15396346f, 0.01788472f, 0.01559989f, -0.27751231f, 0.08912991f, 
    0.07803895f, 0.13136503f, -0.03155489f, 0.10673624f, 0.05080109f, 0.09988651f, 0.01701557f, -0.11766128f, 
    0.01626061f, -0.04464885f, 0.19208847f, -0.00196038f, 0.08747936f, 0.12192698f, 0.17586829f, 0.04337152f, 
    0.25170240f, -0.57071650f, 0.00250308f, 0.04268358f, -0.02462439f, -0.02628619f, 0.01667008f, 0.33562830f, 
    -0.00408716f, 0.11046925f, 0.04913303f, 0.02031146f, 0.08198921f, -0.12383155f, -0.05917067f, -0.08854663f, 
    0.01869033f, -0.05347053f, -0.09448379f, 0.01776081f, -0.09218535f, -0.09679067f, -0.05398817f, -0.05786590f, 
    0.00973745f, -0.06953909f, -0.09521521f, -0.02577875f, 0.01722468f, 0.02821226f, 0.08047135f, -0.01054404f, 
    -0.04218909f, 0.08882879f, -0.12199104f, -0.10687570f, -0.13548893f, -0.11855289f, -0.08308924f, -0.02499706f, 
    0.06433975f, -0.11115083f, -0.02717541f, 0.08158344f, 0.07614064f, -0.00513501f, 0.09253061f, -0.08554231f, 
    -0.04941593f, 0.10175397f, -0.14732404f, -0.07010706f, -0.04779873f, -0.05743128f, 0.03224329f, 0.09662291f, 
    -0.06622343f, -0.09235263f, 0.01024234f, 0.03396235f, 0.10682583f, -0.09554040f, -0.03995885f, -0.00497663f, 
    0.07789508f, 0.14649554f, 0.03291462f, -0.12471461f, -0.08308926f, -0.06091960f, -0.06984645f, 0.08981334f, 
    -0.03246313f, -0.02735414f, -0.05651290f, -0.15892564f, -0.10444574f, 0.03259564f, 0.03242015f, -0.03847155f, 
    -0.06620067f, -0.10447713f, -0.06051826f, -0.01984882f, -0.03553023f, 0.03643855f, 0.02243595f, -0.05364161f, 
    -0.07311025f, 0.10215983f, 0.06045319f, -0.16483620f, 0.09239612f, -0.12348698f, -0.12748648f, -0.01531194f, 
    -0.12334828f, -0.00396168f, -0.10361163f, -0.03108776f, -0.03918522f, -0.05066012f, -0.01729574f, -0.08260906f, 
    0.02356629f, 0.07593551f, 0.04790276f, -0.07192496f, 0.00320254f, -0.02768406f, 0.08341140f, -0.00155838f, 
    -0.04575106f, -0.08958635f, 0.01119834f, 0.04794241f, 0.07391986f, -0.05818605f, 0.01298435f, -0.03240185f, 
    0.04855765f, -0.11470427f, -0.06577326f, -0.11107473f, 0.02314798f, -0.09054745f, -0.00275954f, -0.06328941f, 
    0.04230687f, -0.10842411f, 0.00378223f, 0.08316499f, 0.04165538f, 0.08311174f, 0.02419669f, -0.09543431f, 
    -0.03400357f, -0.04448631f, 0.04585388f, -0.05531037f, 0.08301855f, -0.07233665f, -0.01663696f, 0.01883328f, 
    -0.02737295f, -0.13168871f, 0.10539475f, -0.10726283f, 0.01709040f, -0.08559301f, 0.01004399f, -0.05096795f, 
    -0.01311633f, -0.03556079f, 0.09298363f, -0.02750612f, 0.03527952f, -0.01278643f, -0.11781204f, 0.10915531f, 
    -0.09864312f, 0.03342801f, 0.09056664f, -0.01787040f, -0.08652288f, -0.00097853f, 0.03887967f, -0.05597075f, 
    -0.06857672f, 0.06003775f, 0.02007844f, 0.01549762f, -0.04979043f, -0.07302685f, -0.13165401f, -0.13797189f, 
    -0.08947296f, -0.04205038f, -0.03132504f, -0.09684236f, 0.10167425f, 0.04519032f, 0.15098713f, -0.11780533f, 
    0.07641436f, -0.07731967f, 0.02496796f, 0.03032378f, -0.00986692f, -0.08542827f, 0.03134368f, 0.04730924f, 
    -0.08350845f, 0.07424826f, -0.04038677f, 0.11674342f, 0.10039393f, -0.10850985f, 0.02059666f, -0.14071131f, 
    -0.20393582f, -0.02874452f, 0.09174820f, 0.17580214f, -0.07229605f, -0.12960686f, 0.44049037f, 0.23162819f, 
    -0.09561609f, 0.06126606f, 0.03989208f, 0.05510515f, -0.16676104f, -0.10137285f, 0.19934054f, -0.02322796f, 
    0.05770158f, -0.00214490f, 0.20328608f, -0.11023230f, -0.08542850f, 0.05946991f, 0.06101852f, 0.09481636f, 
    0.17152172f, -0.19265050f, -0.16888075f, 0.39669213f, -0.08083040f, 0.13963427f, 0.34659401f, -0.12704515f, 
    0.18544136f, 0.07384934f, -0.03264715f, 0.25789243f, -0.05535193f, -0.02356835f, -0.07703767f, 0.15185627f, 
    0.09410337f, 0.11974629f, -0.19971548f, -0.03132173f, 0.17401268f, 0.03854669f, -0.12265722f, -0.01657930f, 
    0.30183309f, -0.20311837f, -0.07212356f, 0.07861900f, 0.01698619f, 0.03479772f, 0.19764294f, 0.47031948f, 
    0.32520571f, -0.32930234f, -0.01799097f, 0.06735177f, -0.24891676f, -0.07067576f, -0.20788771f, 0.22598465f, 
    0.00216848f, 0.10796711f, 0.08853832f, -0.10719145f, 0.00274380f, -0.07873961f, -0.02528306f, 0.02149415f, 
    -0.01402823f, -0.06561673f, -0.01751236f, 0.02485940f, 0.06343220f, -0.07885103f, 0.07401886f, -0.10084403f, 
    -0.00960967f, -0.05611153f, 0.03069871f, -0.12466930f, 0.09220815f, -0.07634073f, 0.04786749f, 0.09136274f, 
    -0.11275356f, 0.00826149f, -0.12919562f, 0.03585092f, 0.04211506f, 0.06631345f, 0.04123746f, -0.12398587f, 
    0.00983743f, -0.09181346f, -0.07211198f, 0.09687162f, -0.12393137f, 0.03195508f, -0.06970213f, 0.07634499f, 
    0.06653287f, 0.09398548f, -0.07591505f, 0.05565974f, -0.10206075f, 0.06481589f, 0.07031404f, -0.03343891f, 
    -0.00348984f, -0.13661963f, -0.12858869f, -0.13104048f, 0.01864222f, -0.08538397f, -0.02761305f, 0.10919591f, 
    -0.00725594f, 0.00533595f, -0.12845245f, 0.02970068f, 0.01943062f, -0.09505993f, -0.02041548f, -0.09710781f, 
    -0.17355901f, 0.00677835f, -0.30840251f, -0.23163618f, 0.08874526f, 0.29209426f, -0.17585251f, -0.05076663f, 
    0.09371677f, -0.07428100f, -0.24889937f, 0.10545778f, -0.12071738f, 0.09718205f, 0.19995543f, 0.01262686f, 
    -0.15711868f, 0.04283965f, -0.64423734f, -0.11017770f, -0.12960580f, -0.53553510f, 0.21313183f, 0.20746742f, 
    -0.18622737f, -0.36885202f, -0.15970051f, 0.13291116f, 0.05911126f, 0.22644781f, 0.17558336f, -0.31341645f, 
    0.31232774f, 0.04627731f, -0.11146443f, -0.05524385f, -0.23172718f, -0.08486637f, 0.37743813f, 0.16000593f, 
    -0.21631300f, -0.41003877f, -0.23947513f, -0.02789139f, 0.10086429f, 0.04767505f, 0.57826179f, -0.09990564f, 
    -0.20777220f, -0.28013864f, -0.06152058f, 0.21641988f, 0.21391913f, -0.29073408f, 0.14396761f, -0.36893225f, 
    0.01469804f, 0.24819434f, 0.23306718f, -0.08770315f, -0.11969409f, -0.14583325f, 0.00194330f, 0.14557256f, 
    -0.14123897f, -0.09135690f, -0.16258636f, 0.18102443f, 0.21448728f, -0.03246387f, 0.32994843f, -0.06295560f, 
    0.08092867f, -0.16484457f, -0.10680468f, -0.09909815f, -0.17413720f, -0.08250695f, 0.13445097f, -0.07604875f, 
    -0.10669264f, 0.01416565f, 0.12886186f, -0.01366094f, -0.18877877f, 0.03891458f, 0.20709266f, 0.04784011f, 
    -0.00391864f, -0.11587024f, 0.06875638f, 0.13975313f, -0.14172189f, -0.04297490f, 0.33450097f, -0.12710454f, 
    -0.02236930f, -0.04156959f, -0.09001678f, 0.18401203f, -0.05149313f, -0.02890173f, 0.31785014f, 0.08519476f, 
    0.07902490f, -0.16269436f, -0.01965213f, 0.13464794f, 0.20899643f, 0.11866435f, -0.35449016f, 0.02100520f, 
    0.11452344f, -0.10534596f, -0.17914012f, 0.11649512f, -0.10755429f, 0.08354361f, 0.14940417f, 0.09002794f, 
    0.08528917f, -0.23927088f, 0.26909938f, 0.04530998f, -0.17495629f, 0.28038222f, 0.14464071f, 0.25141799f, 
    0.05386165f, -0.06945834f, 0.27034435f, 0.14827134f, -0.02648314f, -0.13710222f, -0.33303091f, -0.19606610f, 
    0.30555293f, -0.10956517f, 0.04968679f, 0.10964927f, 0.09748805f, -0.03169143f, -0.05541997f, 0.05147255f, 
    0.04593414f, -0.06200977f, 0.29647642f, -0.53931189f, -0.01792460f, 0.06317301f, -0.36483425f, 0.06597117f, 
    -0.55954248f, 0.44147912f, 0.09492135f, -0.35100174f, -0.42644876f, 0.00980883f, -0.14736994f, 0.07245103f, 
    -0.08411736f, -0.01519642f, -0.07187860f, -0.05915641f, 0.17086357f, 0.09299007f, 0.05753038f, 0.13471197f, 
    0.15784246f, -0.03679782f, 0.05139517f, 0.26491681f, -0.23116526f, -0.08873865f, 0.52363026f, 0.15939046f, 
    -0.06403311f, 0.06667288f, -0.12990963f, 0.22497389f, 0.02555073f, 0.13840941f, -0.16470283f, -0.29901737f, 
    -0.32319292f, 0.50609279f, 0.14294226f, -0.07681929f, 0.29731497f, 0.18827920f, 0.26657841f, -0.18653797f, 
    -0.17048240f, -0.06419080f, -0.10827154f, 0.12558573f, 0.03937920f, 0.16607127f, 0.14881377f, 0.04458222f, 
    -0.06053388f, -0.20086779f, 0.23169537f, 0.02196458f, -0.09429640f, 0.03368811f, 0.11858037f, -0.08854870f, 
    -0.00214264f, 0.06456866f, -0.22379993f, -0.03383913f, 0.11129937f, 0.02306068f, 0.09009882f, 0.32609275f, 
    0.07052341f, 0.05335426f, 0.15138195f, 0.28058049f, 0.16048881f, 0.26334345f, 0.23466149f, -0.07046678f, 
    0.24604772f, 0.03946225f, 0.00529120f, 0.03617134f, -0.05876872f, 0.01150268f, 0.27281874f, 0.27339667f, 
    0.11732245f, -0.15824179f, -0.21002993f, 0.27260932f, 0.08081244f, -0.02233800f, 0.33620346f, -0.12316365f, 
    -0.12913729f, 0.05413925f, 0.06936957f, 0.20232381f, 0.05745510f, -0.08507055f, 0.34858841f, 0.11326376f, 
    0.31362036f, 0.06532784f, 0.29224628f, 0.04924097f, -0.07859350f, 0.04900708f, 0.01031559f, 0.30488938f, 
    0.18709676f, 0.09468799f, 0.04186426f, 0.10456890f, -0.01998699f, -0.21687165f, 0.06439960f, -0.06801223f, 
    0.19796643f, -0.06360380f, 0.19899976f, -0.01510363f, 0.01418786f, -0.02671126f, 0.08158012f, 0.10627631f, 
    0.33726028f, 0.15770616f, 0.11907502f, -0.24230523f, 0.05059647f, -0.07659160f, -0.21048144f, -0.07800461f, 
    -0.09235641f, 0.24821141f, 0.13456775f, 0.30451104f, -0.14246856f, -0.11369698f, -0.36760405f, 0.15276168f, 
    -0.11755697f, 0.10970639f, -0.11785226f, 0.01314106f, 0.22730717f, 0.12348527f, -0.27153689f, 0.01058993f, 
    0.47245324f, 0.24230558f, 0.34521917f, -0.06756056f, 0.16425179f, -0.08912662f, 0.26630172f, 0.24059819f, 
    -0.18232596f, 0.06895222f, -0.19448882f, 0.02410240f, -0.01378515f, 0.19457538f, -0.12212375f, -0.41003451f, 
    -0.11495017f, -0.28464243f, -0.05069014f, 0.04843534f, -0.04715312f, -0.00630074f, 0.12663040f, -0.07333285f, 
    0.02857384f, 0.05507141f, -0.01206096f, 0.07331572f, 0.01163059f, 0.01146531f, 0.05373708f, 0.02049240f, 
    -0.13589445f, 0.02113702f, 0.01301019f, -0.12116775f, -0.04844945f, -0.04759028f, -0.12057059f, 0.00931644f, 
    0.05115350f, 0.03572990f, 0.08308721f, -0.01800873f, -0.08757072f, -0.00012942f, -0.02332779f, -0.02451588f, 
    0.04226776f, -0.01029322f, 0.02523875f, 0.01086628f, -0.15902768f, 0.04401287f, -0.13493919f, 0.00486991f, 
    -0.03730634f, 0.07906735f, -0.00329061f, -0.12472917f, 0.04270669f, -0.02253450f, 0.00059124f, -0.05017211f, 
    -0.04611313f, -0.06848354f, 0.00553594f, 0.11192122f, -0.16533896f, -0.03840764f, -0.00790918f, -0.09469058f, 
    -0.14256650f, -0.07252792f, -0.02590158f, -0.09846496f, 0.04027988f, -0.12270819f, 0.08294360f, -0.11184277f, 
    0.07784078f, 0.05980088f, 0.00721625f, 0.09438266f, -0.06197255f, -0.09218558f, 0.03271969f, -0.12588532f, 
    -0.13198061f, -0.08826933f, -0.11716381f, 0.30294204f, -0.04245175f, 0.01433099f, 0.40090841f, 0.07858489f, 
    -0.14719501f, -0.14886358f, 0.14493226f, 0.05300763f, -0.20638488f, 0.10108081f, -0.02140948f, 0.06800257f, 
    0.21614769f, 0.01820440f, -0.11198596f, -0.04111004f, -0.11359420f, 0.09858967f, 0.01141926f, 0.12044009f, 
    0.29775757f, 0.13684194f, 0.10708077f, 0.17417815f, 0.00468584f, 0.09644753f, 0.28203911f, -0.07443720f, 
    0.01822060f, -0.01565336f, 0.06156124f, 0.14385483f, -0.13450781f, 0.11525334f, -0.10211413f, 0.11134055f, 
    0.22636600f, 0.19981974f, -0.15522893f, 0.34092668f, 0.22624162f, -0.11704009f, -0.03826393f, -0.15832976f, 
    -0.07014657f, -0.19479235f, -0.06932543f, 0.00415578f, -0.05647566f, -0.09558868f, -0.00675968f, 0.59239680f, 
    0.34469795f, -0.42373106f, 0.00421725f, 0.03521389f, -0.17234807f, -0.15203306f, -0.05908857f, 0.34627366f, 
    -0.00660046f, -0.06342776f, 0.17355706f, 0.02151634f, -0.31772065f, -0.60385692f, -0.10140650f, 0.13323419f, 
    -0.21499106f, -0.00450654f, 0.40032008f, -0.01222514f, 0.03602657f, -0.01788043f, -0.21049696f, -0.03240322f, 
    0.02306124f, 0.04519502f, 0.28328136f, -0.47573933f, -0.10096228f, 0.15957361f, -0.04019787f, 0.05991531f, 
    -0.04889989f, 0.26477817f, 0.52629358f, 0.11724149f, -0.11076115f, -0.22306143f, -0.17442070f, -0.00787343f, 
    -0.10762985f, 0.08739238f, 0.24155752f, 0.00311541f, -0.17933103f, -0.00853740f, -0.09512836f, 0.04399848f, 
    0.20386985f, -0.02332461f, -0.04225319f, 0.24968030f, -0.00031551f, 0.04632154f, -0.41874439f, 0.15748674f, 
    -0.26370680f, 0.24260338f, -0.08551435f, -0.02420062f, 0.04272806f, 0.00214981f, 0.13992421f, 0.24686050f, 
    0.12734050f, 0.23952270f, 0.02031151f, -0.01006221f, 0.15846711f, 0.04451872f, 0.26058370f, 0.14104092f, 
    0.14324200f, -0.01453760f, 0.02004542f, -0.10840017f, -0.16389009f, 0.04416415f, -0.24935371f, -0.08531848f, 
    0.22915892f, -0.03930734f, 0.24988192f, -0.12555496f, 0.15047424f, 0.00085093f, -0.07101285f, 0.04013124f, 
    0.08669788f, 0.31695390f, 0.07304074f, -0.03829873f, 0.25546798f, -0.15155891f, -0.05725875f, 0.29276475f, 
    0.00989944f, 0.06019447f, 0.31122765f, 0.12616181f, -0.06216428f, -0.03052021f, 0.01628075f, 0.25930834f, 
    0.17490838f, -0.03347118f, 0.07636623f, -0.03676623f, 0.01248791f, -0.05873957f, 0.10060092f, 0.16794562f, 
    0.34417960f, 0.16025774f, 0.06258731f, -0.09608480f, 0.19166347f, 0.09074844f, 0.51909131f, 0.11528264f, 
    -0.20883468f, 0.08891677f, -0.02491882f, -0.05387757f, 0.06855545f, 0.04437506f, 0.12396286f, -0.31670621f, 
    -0.09736860f, 0.00838603f, 0.02694779f, -0.05073425f, 0.18741202f, -0.15803982f, -0.04551051f, -0.10792653f, 
    0.12789460f, -0.11081137f, 0.16295837f, 0.05400189f, -0.02578786f, -0.35406509f, 0.11204205f, 0.10874490f, 
    -0.17259224f, 0.18218203f, -0.06246126f, -0.01219710f, 0.12993900f, -0.06506373f, -0.01370093f, 0.02072324f, 
    0.08645449f, -0.13756621f, 0.27680641f, 0.00902197f, -0.34369254f, 0.32061175f, 0.13567467f, -0.07670699f, 
    0.03448825f, -0.32491636f, -0.31350148f, -0.07665599f, 0.10959493f, -0.19950134f, -0.10522764f, -0.10977569f, 
    -0.30176657f, -0.01399260f, 0.03219299f, 0.08027056f, -0.19674878f, 0.10879163f, -0.10386955f, 0.00836098f, 
    -0.16335356f, 0.06330905f, -0.06642548f, 0.06100013f, -0.02509065f, -0.07027528f, -0.35370311f, 0.05004954f, 
    -0.02419388f, 0.26889813f, -0.03477129f, 0.14944707f, 0.06218085f, 0.17463139f, -0.00645223f, 0.14458920f, 
    0.23520017f, -0.26860175f, -0.03101153f, -0.09653493f, -0.14138526f, 0.28881639f, 0.17769119f, 0.02295872f, 
    -0.43644997f, -0.02936240f, 0.06407034f, 0.04748559f, -0.44526631f, -0.50492620f, 0.10820701f, 0.24070136f, 
    -0.24480766f, -0.47864994f, 0.32486978f, -0.03022753f, -0.27307484f, -0.09830222f, 0.01333081f, 0.09972529f, 
    -0.01170624f, 0.09913067f, 0.06687892f, -0.19270812f, 0.12936190f, 0.27813998f, 0.09674238f, 0.08057501f, 
    0.30342382f, 0.37696221f, 0.30120122f, 0.43137249f, 0.00652546f, 0.12965047f, 0.12823676f, 0.04173980f, 
    0.25928771f, 0.09173040f, 0.12419617f, -0.20494643f, 0.02443968f, -0.02862792f, -0.16505899f, -0.07224526f, 
    0.10356054f, 0.09005085f, -0.26391110f, 0.20643425f, 0.08347782f, 0.01298066f, -0.01446811f, -0.27806446f, 
    0.03743616f, 0.10460594f, 0.24840988f, 0.02294703f, 0.04916558f, 0.02396643f, 0.19955423f, 0.50465876f, 
    0.17401162f, -0.17198570f, -0.02570813f, -0.07923755f, 0.05127381f, -0.15321434f, -0.07899090f, 0.22944282f, 
    0.10347904f, -0.01805117f, -0.04377809f, 0.31646171f, 0.13588554f, -0.28789702f, -0.06142630f, 0.13890205f, 
    -0.10183422f, 0.15663932f, 0.17127110f, 0.04662072f, 0.44947824f, 0.08087379f, 0.19377084f, 0.11644047f, 
    0.01433105f, 0.30860627f, -0.13073334f, -0.08893660f, 0.14986865f, -0.01075831f, -0.05366897f, 0.33908623f, 
    -0.19733322f, -0.31572193f, -0.32615650f, 0.29047379f, -0.09305146f, 0.04097030f, -0.29148534f, 0.15119649f, 
    0.25302815f, 0.13180402f, -0.18315956f, -0.01796585f, 0.00801251f, -0.09268644f, -0.13791198f, -0.02976477f, 
    0.07032020f, -0.11946311f, -0.06089773f, -0.18369888f, -0.11672714f, 0.11031915f, 0.59596235f, 0.00141484f, 
    -0.13337602f, 0.21868597f, 0.05213117f, 0.31046015f, 0.17928424f, 0.15468483f, 0.09945375f, -0.29805738f, 
    0.04350430f, 0.36405745f, 0.15128829f, -0.11474746f, 0.22479150f, 0.01650643f, 0.21120991f, -0.03131702f, 
    0.10046080f, -0.06424104f, 0.08472018f, -0.06844702f, 0.12768891f, 0.27084088f, 0.03806153f, -0.21158890f, 
    0.30198202f, -0.00716479f, 0.26493680f, 0.04203643f, -0.16448902f, -0.03682160f, -0.03753787f, 0.04484393f, 
    -0.04164466f, -0.11211352f, 0.11366560f, -0.37832016f, 0.07043957f, -0.03594798f, -0.00917996f, 0.11186343f, 
    -0.27399600f, 0.48685327f, 0.51208550f, -0.06377913f, -0.24499398f, -0.40873715f, 0.17863551f, 0.20135696f, 
    -0.62295300f, -0.03663408f, 0.01381228f, 0.11548228f, 0.00450434f, 0.01038251f, 0.48118597f, 0.22933757f, 
    0.07159894f, 0.16629776f, -0.02512104f, 0.46939489f, 0.08853702f, -0.02931397f, -0.60245812f, 0.31704596f, 
    0.25215247f, 0.01279598f, -0.45358947f, -0.24270841f, -0.18350415f, -0.06287592f, -0.10392106f, 0.09748229f, 
    0.08971900f, -0.14512444f, 0.07445117f, -0.00053467f, 0.19415762f, 0.20862056f, 0.10437376f, 0.31362534f, 
    -0.14122786f, 0.03630403f, -0.02274629f, 0.02824127f, -0.25638327f, -0.09133610f, 0.07652553f, 0.09448753f, 
    0.06523118f, 0.12140208f, -0.07403873f, -0.09825184f, 0.10901692f, 0.03337312f, -0.10662754f, -0.02752749f, 
    -0.23391964f, 0.02625667f, -0.01901791f, 0.11222426f, 0.12217829f, 0.19336772f, 0.23007838f, 0.01109347f, 
    0.26667467f, -0.17106521f, 0.24826647f, 0.18967353f, 0.27267095f, 0.03585979f, -0.01214627f, 0.15652996f, 
    0.27740324f, -0.00093399f, 0.09971507f, -0.16316865f, -0.04174245f, -0.16690309f, 0.00549370f, 0.08396871f, 
    -0.18793787f, -0.18476965f, -0.29343605f, -0.30092594f, 0.04295958f, 0.01382882f, -0.07301509f, -0.23587120f, 
    -0.01793341f, 0.01482022f, 0.17034182f, 0.06066779f, 0.08477383f, -0.04395103f, 0.17140113f, 0.26178282f, 
    0.16452700f, 0.00344271f, -0.12400191f, 0.01769551f, 0.23668671f, 0.01866476f, -0.23510274f, -0.00092660f, 
    -0.08185464f, -0.04428603f, 0.09086049f, -0.01454676f, -0.09890960f, -0.01433238f, 0.03322265f, -0.05132657f, 
    0.05096956f, -0.12207948f, 0.01645795f, 0.06126980f, 0.08945891f, 0.00021156f, -0.14155853f, 0.09406944f, 
    0.03210931f, 0.01081158f, -0.00429515f, -0.04244646f, -0.01127473f, 0.00317973f, -0.05669105f, -0.12163371f, 
    -0.11792338f, 0.07602997f, 0.05367365f, -0.00532275f, 0.07570629f, 0.01131675f, 0.03114683f, 0.06366846f, 
    -0.11244824f, -0.11311214f, 0.03910023f, -0.10072786f, -0.11363201f, -0.04374072f, 0.08805233f, -0.02889617f, 
    0.04126118f, 0.01583882f, 0.00890123f, -0.04511019f, -0.10151437f, 0.07921550f, 0.06737460f, 0.05789002f, 
    0.04078306f, 0.04835944f, 0.07288630f, -0.03164994f, 0.07427108f, -0.07068274f, 0.04009555f, -0.02260175f, 
    0.01936435f, 0.07283060f, -0.12053284f, -0.10382547f, -0.11122990f, 0.00138838f, 0.07666844f, -0.14116155f, 
    0.22306231f, 0.09912483f, 0.23475413f, 0.06182316f, 0.27411571f, -0.32508868f, 0.11492402f, 0.11541551f, 
    -0.06533273f, 0.20473717f, -0.37494338f, 0.05718873f, 0.33673561f, -0.01389268f, 0.11897998f, -0.02739826f, 
    0.14321522f, 0.14915757f, 0.18766533f, -0.11112972f, -0.29690871f, 0.33331406f, 0.16616349f, -0.10643950f, 
    0.12910634f, -0.44760904f, -0.23406795f, -0.15143120f, 0.00241390f, 0.06430753f, -0.17677318f, -0.02109286f, 
    -0.10925627f, -0.10930756f, -0.10064597f, 0.21026959f, 0.00342973f, 0.01138913f, -0.26909348f, -0.09644461f, 
    -0.09330104f, -0.15186457f, 0.19974239f, -0.14645568f, -0.08918482f, 0.04527251f, -0.31648019f, 0.07005917f, 
    0.22420825f, 0.20620333f, 0.09100727f, 0.30503184f, 0.08966551f, 0.16440196f, -0.03434268f, 0.16514795f, 
    0.03941132f, 0.11465973f, -0.02063141f, 0.06714354f, -0.13047653f, 0.33836767f, 0.24139659f, 0.00951411f, 
    -0.08496217f, 0.00619768f, 0.03610462f, 0.23966235f, -0.03182322f, 0.17068121f, -0.05270572f, 0.01241264f, 
    0.14565676f, -0.11008192f, 0.10470912f, 0.00732701f, -0.01902685f, -0.06044832f, -0.06912535f, 0.06432699f, 
    0.09208193f, 0.02446641f, 0.11185679f, -0.21461727f, 0.08816373f, -0.24119224f, 0.00595386f, 0.16515566f, 
    -0.23793468f, 0.39063480f, 0.31607637f, -0.03706314f, -0.11485767f, -0.18299860f, 0.24986336f, 0.26675087f, 
    0.08417444f, 0.06593899f, -0.08590103f, 0.17756344f, 0.22923927f, 0.09062219f, 0.44292992f, 0.24625666f, 
    0.20275739f, 0.14327386f, -0.04577921f, 0.19057907f, 0.13359012f, -0.07604016f, 0.22304988f, 0.28569996f, 
    -0.14307310f, 0.02284429f, -0.38607749f, -0.15287891f, 0.07275222f, -0.05112903f, -0.09104035f, 0.01752891f, 
    -0.09811568f, 0.26209715f, 0.05376680f, 0.06648056f, 0.08237081f, 0.04095478f, 0.22036095f, -0.09274323f, 
    -0.00460128f, -0.09475128f, -0.08948626f, 0.20950787f, 0.06874749f, 0.16272551f, -0.07112341f, 0.13950284f, 
    -0.21997592f, 0.12193077f, -0.23433602f, -0.09139650f, -0.04975323f, 0.10221085f, -0.11415169f, -0.03304823f, 
    -0.04829983f, -0.09501167f, -0.07765011f, 0.18806657f, -0.04945372f, -0.22703019f, 0.06426420f, -0.37351775f, 
    0.06755690f, -0.29873830f, -0.35279337f, -0.25220570f, 0.20870835f, 0.11466771f, -0.32681006f, -0.28209254f, 
    0.09573652f, 0.05740349f, 0.08257729f, -0.07029398f, 0.08482023f, 0.09225392f, 0.03768812f, 0.06525048f, 
    -0.05219603f, 0.09798912f, -0.14713085f, -0.00220529f, -0.08031765f, 0.11180131f, -0.31178659f, -0.08945400f, 
    0.02040036f, -0.13250755f, 0.14318419f, -0.00147542f, -0.14902841f, 0.11970299f, 0.11420205f, -0.01750826f, 
    -0.06942463f, -0.49284279f, -0.04517940f, -0.02678843f, -0.10210064f, 0.07148056f, 0.15171713f, -0.27703801f, 
    -0.15669237f, -0.10720552f, -0.00588934f, 0.23304653f, 0.10819100f, -0.23811504f, -0.17889932f, 0.10374328f, 
    -0.26279655f, 0.14155169f, 0.04134869f, -0.09015626f, 0.11318395f, 0.03216583f, 0.15171160f, -0.06453078f, 
    -0.00912958f, 0.02810006f, 0.07245985f, -0.23666073f, -0.04394967f, 0.16097440f, -0.27177361f, 0.16294985f, 
    -0.28686631f, -0.37729013f, -0.53097767f, 0.11857505f, 0.03071791f, 0.01825624f, 0.02618171f, 0.12081174f, 
    0.08176010f, 0.16477960f, -0.06318054f, 0.07214136f, -0.22032504f, -0.01239194f, -0.08532684f, 0.08371455f, 
    -0.05302440f, 0.07172709f, -0.01133226f, 0.01153067f, -0.10864002f, -0.07250798f, 0.11327370f, -0.00584113f, 
    0.07633194f, 0.12094284f, -0.12278986f, 0.37788460f, 0.13922037f, 0.13532346f, -0.08157811f, -0.30257723f, 
    -0.08296891f, 0.17454095f, 0.05625040f, -0.09160026f, 0.01450215f, 0.31324452f, 0.22360526f, 0.04224381f, 
    -0.04115656f, 0.07977536f, 0.11291210f, 0.21157664f, -0.00553098f, -0.42228103f, 0.02606084f, 0.05222265f, 
    -0.12400938f, -0.00926249f, -0.05480183f, 0.08411169f, 0.16373393f, 0.07706863f, 0.08229084f, -0.03214969f, 
    0.14582057f, 0.03862857f, 0.19237769f, -0.37957987f, -0.10433808f, 0.18764281f, -0.12787974f, 0.11969943f, 
    -0.05878830f, 0.01174635f, -0.46501729f, 0.04907788f, -0.14829396f, 0.15606870f, -0.29710546f, 0.05107629f, 
    0.07252540f, -0.01431535f, -0.16583389f, -0.06924091f, 0.06547294f, -0.00881374f, -0.27534357f, 0.07223372f, 
    0.19522567f, -0.10373718f, -0.03670507f, -0.02161688f, -0.08959534f, -0.02856705f, 0.26596770f, 0.00684788f, 
    -0.05899678f, 0.16973346f, -0.01791990f, 0.37713706f, 0.03271792f, 0.24072129f, -0.10022432f, 0.26033768f, 
    0.10972105f, -0.28376564f, 0.05145964f, -0.09055847f, 0.06211066f, 0.15227173f, 0.37524486f, -0.08068386f, 
    0.00114188f, -0.09148775f, 0.09429060f, 0.36355746f, 0.02773195f, -0.19972111f, 0.41720366f, -0.03819511f, 
    -0.17371434f, -0.09409400f, 0.04360934f, -0.09803956f, -0.00364733f, -0.06620926f, -0.05158124f, -0.01209317f, 
    0.34287441f, -0.20365164f, 0.17903276f, -0.11695964f, 0.02708638f, 0.19470435f, 0.24373393f, -0.14852658f, 
    0.09172641f, -0.21647726f, -0.21877506f, 0.17019634f, 0.07666075f, -0.00053346f, 0.02960051f, -0.16317098f, 
    -0.26565439f, 0.12060720f, 0.04188344f, 0.22026512f, -0.16478460f, -0.07037298f, -0.17678542f, 0.18223685f, 
    0.07625546f, -0.12635626f, 0.00400295f, 0.06567737f, -0.09827549f, 0.06600440f, -0.25923344f, -0.02970659f, 
    0.09165216f, -0.02842307f, 0.04307048f, 0.24548216f, -0.04757662f, 0.00579888f, 0.11807737f, 0.46684489f, 
    0.32728100f, -0.03491486f, 0.09872246f, 0.04521737f, 0.00218939f, 0.17019275f, 0.10628923f, 0.36368671f, 
    0.06355580f, 0.00724970f, 0.11737020f, 0.09633755f, 0.26104537f, 0.14197201f, -0.09369322f, 0.17615597f, 
    0.02802693f, 0.11889973f, -0.23924576f, 0.07680579f, 0.02927113f, 0.12202117f, 0.18669714f, -0.03254555f, 
    -0.18557666f, -0.13315091f, 0.20917250f, -0.08119146f, -0.21551047f, 0.11382107f, 0.18653446f, -0.00852700f, 
    0.03775992f, -0.12421010f, -0.37204933f, -0.21368611f, -0.07270484f, 0.12378915f, 0.14312030f, -0.13174687f, 
    -0.18229763f, -0.02784792f, -0.05432670f, 0.23923729f, 0.13361476f, -0.13483338f, 0.01596236f, 0.08346070f, 
    -0.27068532f, -0.14527556f, 0.16697457f, 0.02067526f, -0.13320479f, -0.03255284f, -0.14483082f, 0.20381516f, 
    0.10791235f, 0.13408467f, -0.05197425f, 0.28027597f, 0.15861323f, 0.13073611f, 0.08219577f, -0.13114072f, 
    0.05386112f, 0.38284534f, 0.22128943f, -0.09496634f, 0.09596677f, 0.44000188f, 0.04688589f, -0.05684352f, 
    0.13968858f, -0.08011597f, 0.00920201f, 0.06403906f, 0.16812186f, 0.20224863f, 0.04701565f, -0.13391648f, 
    0.16330567f, 0.03287555f, -0.02256848f, 0.07605863f, -0.15448745f, -0.10920472f, 0.08206910f, -0.09792777f, 
    0.13307187f, 0.04493490f, 0.24353634f, -0.26282802f, -0.05246899f, -0.19740573f, -0.13126798f, -0.07731055f, 
    0.03704641f, 0.37919641f, 0.41327739f, -0.09579772f, -0.12495980f, -0.11399516f, 0.08724932f, -0.07584468f, 
    -0.39510623f, 0.11082888f, 0.11168706f, 0.20472759f, 0.23757918f, 0.00103422f, 0.13293083f, 0.16668802f, 
    0.19520679f, 0.10047805f, 0.30167037f, 0.38394734f, 0.04966193f, 0.05830789f, -0.49737132f, 0.33170238f, 
    0.15096997f, -0.02097176f, -0.12562551f, -0.16057996f, 0.06317590f, 0.19477670f, -0.02472186f, 0.21471547f, 
    -0.06311748f, 0.26651680f, 0.09815196f, 0.07334130f, -0.13442336f, 0.08022234f, 0.22654365f, 0.11290038f, 
    0.09982513f, -0.06435090f, 0.12466611f, -0.04524927f, -0.02436660f, 0.23330060f, -0.22438659f, 0.16009229f, 
    0.19909944f, 0.05524700f, -0.17551558f, -0.09393331f, 0.03270155f, 0.09034450f, 0.17631941f, 0.06768423f, 
    -0.27979925f, -0.16964284f, 0.10526668f, -0.14791760f, -0.02003990f, 0.06457585f, 0.06272159f, 0.03418543f, 
    -0.09357206f, -0.16114859f, -0.16808270f, -0.17203625f, 0.03574802f, -0.00266647f, 0.26695055f, 0.15436968f, 
    -0.03114525f, -0.14107877f, -0.09277097f, 0.18146347f, 0.00516062f, 0.07228619f, 0.15498602f, 0.01641597f, 
    -0.18851680f, -0.24794771f, -0.13348351f, -0.12785061f, -0.07452608f, -0.07463422f, 0.09315937f, 0.14040966f, 
    0.24054188f, 0.11932091f, -0.18643610f, 0.16911450f, 0.06098876f, -0.11956066f, 0.13237071f, 0.02472473f, 
    -0.15434936f, 0.52197003f, 0.24637854f, 0.02665928f, 0.17032205f, 0.30548814f, 0.03091053f, -0.07673302f, 
    -0.06818126f, 0.04800586f, 0.09802011f, -0.27863440f, -0.02066988f, 0.06232352f, -0.09148294f, 0.02960606f, 
    -0.10010149f, -0.03346970f, -0.48389792f, 0.08551212f, 0.11435924f, -0.08470319f, -0.05985730f, -0.10454611f, 
    -0.26825923f, -0.08341094f, -0.19342099f, 0.11194296f, -0.06049723f, -0.16641563f, 0.13545808f, -0.15680596f, 
    0.08780440f, -0.46766996f, -0.11049195f, -0.08663498f, 0.15081920f, 0.03840930f, 0.14795880f, -0.22569044f, 
    0.08961257f, -0.03930496f, 0.13553619f, 0.01917209f, -0.06412715f, 0.02792422f, 0.32544383f, -0.09822154f, 
    -0.34525242f, -0.15706621f, 0.23799479f, -0.03649525f, 0.02693383f, -0.02839484f, 0.14434658f, -0.12532088f, 
    0.04361269f, -0.10607625f, 0.17642863f, 0.03240797f, 0.24925226f, -0.20125228f, 0.07030839f, -0.17449328f, 
    0.16640440f, 0.61095530f, 0.11137053f, -0.06546170f, 0.09492204f, 0.15679981f, 0.03414954f, 0.26747897f, 
    0.09246095f, -0.01003549f, -0.17031834f, -0.06738758f, 0.20212983f, -0.16981246f, -0.11861328f, 0.03766899f, 
    0.01320315f, -0.08849695f, 0.19024605f, -0.07567039f, 0.12637110f, 0.01955207f, -0.11936384f, 0.04482473f, 
    -0.07114091f, 0.08180498f, 0.15547346f, -0.20707375f, 0.03549874f, 0.04827691f, -0.34036034f, 0.04771002f, 
    -0.16722330f, 0.05609666f, 0.00753751f, -0.58923876f, 0.07239347f, 0.11121632f, 0.03945468f, -0.23963809f, 
    -0.54269058f, 0.11772511f, -0.00533744f, 0.06518266f, 0.12673248f, 0.02070773f, 0.11250485f, 0.10586128f, 
    -0.02358857f, -0.18708491f, 0.20802644f, 0.36458257f, -0.28661618f, 0.03617908f, -0.22304502f, 0.10885333f, 
    -0.09572166f, 0.10023098f, 0.07725289f, 0.10643136f, 0.24254358f, -0.07532434f, 0.12716916f, 0.01782633f, 
    0.16779836f, -0.23537566f, 0.32183534f, 0.11568458f, -0.15746173f, 0.02009401f, 0.35619438f, 0.28244725f, 
    -0.09072959f, -0.03120453f, 0.26574755f, 0.04855383f, -0.19980234f, -0.28676587f, -0.02431973f, 0.08891065f, 
    0.09493298f, 0.15994115f, 0.14913650f, -0.09779549f, 0.13794059f, -0.11201449f, -0.01915997f, -0.10092422f, 
    0.08186296f, -0.27084175f, 0.27897233f, -0.13601109f, 0.27594507f, 0.29745567f, 0.18676209f, 0.04768718f, 
    0.00188800f, 0.07850059f, 0.43507087f, 0.53355879f, -0.00364626f, -0.06229016f, -0.32681513f, 0.40703896f, 
    0.35874289f, 0.05149771f, 0.02619018f, -0.01256245f, 0.10224053f, -0.05239267f, -0.17629741f, -0.07950604f, 
    0.27763891f, -0.09762938f, 0.02128208f, -0.51856971f, 0.20576607f, 0.02478111f, 0.25761649f, 0.08789954f, 
    -0.08136813f, 0.12368323f, -0.01917516f, 0.16368736f, -0.25434995f, 0.14773758f, 0.11304753f, 0.10141420f, 
    0.02575501f, -0.36247769f, -0.49935868f, 0.03473629f, 0.36805406f, 0.05523951f, -0.20615923f, -0.32190815f, 
    0.04003868f, -0.05637766f, 0.03154510f, -0.00823905f, -0.31555843f, -0.29099485f, -0.14990991f, 0.10553883f, 
    -0.09688971f, -0.02741542f, 0.27982581f, 0.07897830f, 0.21897122f, -0.04269555f, -0.19312492f, -0.09760427f, 
    -0.12422481f, -0.08622305f, 0.09078870f, -0.18252504f, 0.24550793f, 0.12508616f, 0.18694857f, 0.12644559f, 
    0.05854042f, 0.04875623f, 0.52379084f, -0.07751416f, 0.16847493f, -0.11353500f, -0.40377033f, 0.31292856f, 
    -0.10537983f, 0.04458367f, 0.19364946f, -0.26390824f, -0.07675529f, 0.12038150f, -0.21037097f, 0.06853667f, 
    -0.02919113f, 0.02332305f, 0.03536748f, -0.01400433f, -0.06585219f, 0.03242915f, -0.18698332f, 0.05764247f, 
    -0.10413948f, 0.29978192f, 0.15969603f, -0.07435804f, 0.10751985f, 0.16599709f, 0.06732761f, -0.04645519f, 
    0.13411617f, -0.34083599f, 0.02007519f, -0.05825043f, 0.34191075f, 0.12836882f, 0.16486214f, 0.13110645f, 
    0.13663085f, -0.10690407f, -0.13346344f, 0.12982251f, -0.11578897f, 0.10629133f, -0.05938664f, -0.12380374f, 
    0.10608525f, 0.09827763f, 0.15592940f, 0.05902932f, -0.06358390f, -0.09141346f, -0.11760905f, -0.07048719f, 
    0.40645394f, 0.04286667f, 0.22398804f, -0.04469945f, 0.08861724f, -0.16330542f, -0.18789281f, 0.03026466f, 
    -0.17664520f, 0.34507111f, 0.31885904f, 0.07693356f, 0.04808453f, -0.07342509f, -0.04231806f, 0.00050385f, 
    -0.03884187f, -0.01004949f, 0.05652406f, 0.09692579f, 0.18384916f, 0.11300312f, 0.08360856f, 0.14614670f, 
    0.58043993f, 0.29599836f, 0.15233026f, 0.41141418f, 0.09743176f, -0.06421927f, 0.17813878f, 0.17614026f, 
    -0.12328997f, 0.11266596f, -0.11702296f, -0.06611720f, 0.04587783f, 0.16398321f, -0.16214585f, -0.12374932f, 
    0.02239648f, -0.16476789f, -0.03601976f, 0.00013181f, 0.09273578f, -0.03830476f, 0.04516029f, 0.11025141f, 
    -0.05837566f, -0.02065906f, 0.07092199f, -0.00989948f, -0.07229251f, 0.04059106f, 0.25828120f, -0.11769873f, 
    -0.04372724f, -0.05497881f, -0.27267811f, 0.06491138f, 0.09483331f, -0.11943752f, 0.23509464f, -0.00660527f, 
    -0.21348619f, 0.38891011f, -0.07819719f, -0.00312776f, -0.21377933f, 0.04645108f, 0.45964205f, 0.10879739f, 
    0.10350914f, -0.43309680f, -0.01905480f, 0.22135934f, 0.05151277f, 0.26158533f, 0.30439106f, -0.32779601f, 
    0.05479026f, -0.03172079f, -0.01346074f, 0.13020481f, -0.06565617f, -0.07824252f, -0.07220390f, 0.19266930f, 
    -0.24574658f, -0.36600831f, 0.03563414f, -0.08988394f, 0.09263153f, -0.06437310f, 0.19302019f, 0.01232857f, 
    0.17372586f, -0.19983588f, 0.17509879f, 0.15268904f, 0.29516444f, -0.16523512f, 0.02973547f, 0.11094022f, 
    0.13150175f, 0.16213699f, 0.20089860f, -0.07558252f, -0.27974963f, 0.10024828f, 0.01745211f, 0.20207204f, 
    -0.16295820f, -0.09572838f, 0.01722104f, 0.07424050f, -0.01969641f, -0.20157138f, -0.10552764f, 0.13104326f, 
    0.14103024f, -0.11241115f, 0.10033237f, 0.05702885f, 0.15237029f, -0.01049548f, -0.05029760f, -0.07424310f, 
    0.10984050f, 0.24683651f, -0.25180066f, 0.07039795f, 0.27289796f, -0.01059836f, 0.19445485f, 0.34228683f, 
    -0.12120568f, 0.00124861f, 0.13412534f, 0.20309563f, -0.00071987f, 0.00041402f, -0.05262429f, 0.31011808f, 
    0.46874118f, -0.05772984f, 0.03242952f, -0.00100685f, -0.15840903f, -0.08094686f, 0.05409681f, 0.09988410f, 
    0.08967400f, -0.17011534f, -0.21045868f, -0.08746893f, 0.13540639f, -0.02503102f, 0.66975045f, -0.13477936f, 
    -0.33914277f, 0.13285039f, 0.07340740f, 0.27005160f, 0.07489876f, -0.01023358f, 0.09264342f, -0.18699475f, 
    0.03159723f, 0.47563028f, -0.01321609f, 0.08383167f, 0.35308808f, 0.05579582f, 0.17677252f, -0.07758181f, 
    -0.01812030f, -0.03190977f, -0.35449311f, 0.05272556f, 0.03942794f, 0.09102889f, -0.02222365f, -0.22344854f, 
    0.08662572f, 0.04448651f, 0.18953732f, -0.12110478f, 0.01944955f, 0.02133223f, -0.04010128f, 0.10300475f, 
    0.19644469f, 0.14925055f, -0.10695139f, -0.01970173f, 0.06292558f, -0.29336765f, 0.04290432f, 0.12749204f, 
    -0.23010275f, 0.24943900f, 0.19681427f, 0.02943352f, -0.07827561f, 0.15866505f, -0.12870294f, 0.17667636f, 
    -0.05185955f, -0.03098458f, 0.09170552f, -0.07242522f, 0.05240376f, 0.05618780f, 0.18628633f, -0.05757260f, 
    0.24138446f, -0.05857314f, 0.33111730f, 0.31590483f, 0.01193833f, -0.00192811f, 0.38850227f, 0.09465359f, 
    -0.37716702f, 0.03673843f, 0.05242484f, -0.14867163f, 0.12866941f, 0.13159001f, -0.09868666f, -0.09385935f, 
    0.02957628f, 0.19586787f, 0.11599607f, 0.04965313f, 0.12139133f, -0.03191699f, 0.21950194f, 0.20638476f, 
    -0.60804898f, 0.04872437f, -0.16811241f, 0.02963975f, -0.35835493f, -0.02486077f, 0.17614518f, 0.03030852f, 
    -0.20106108f, -0.45878261f, -0.23057175f, -0.10170025f, -0.13919282f, -0.09493005f, 0.12580602f, -0.09731044f, 
    -0.54739046f, -0.03364530f, -0.45412415f, 0.23983514f, 0.06156938f, 0.19743606f, 0.24536780f, 0.10360733f, 
    0.19407207f, -0.32804450f, -0.08475795f, 0.26466775f, 0.15681617f, 0.03409114f, -0.02061502f, -0.12854196f, 
    0.14009644f, 0.02646017f, -0.13873848f, -0.26287639f, -0.45543328f, -0.03495803f, -0.15342821f, -0.11564265f, 
    -0.34013781f, -0.53567171f, -0.57264757f, -0.26235548f, 0.06993808f, -0.07677884f, 0.11109574f, -0.61574543f, 
    0.12097334f, -0.37429938f, 0.12904379f, 0.21675257f, 0.07892521f, -0.17147261f, 0.07710779f, 0.09417473f, 
    0.07809637f, -0.20960808f, 0.04233076f, 0.03359670f, -0.33947480f, -0.04611101f, -0.16034092f, 0.14581580f, 
    0.01615369f, -0.01840638f, 0.25105733f, -0.02181051f, -0.09614617f, 0.04703337f, 0.35194114f, -0.06468390f, 
    -0.17321801f, -0.10897748f, 0.04196553f, -0.01852320f, -0.27117750f, -0.09850910f, -0.17324272f, -0.03933625f, 
    0.10092539f, 0.19173290f, 0.25705570f, -0.15032329f, -0.11810473f, 0.05140599f, 0.12930204f, -0.14809728f, 
    -0.04034904f, -0.05967787f, 0.39050043f, -0.00379787f, -0.01809889f, -0.11184512f, 0.27202997f, 0.11069818f, 
    -0.60517645f, -0.13420145f, 0.00016890f, 0.02699032f, -0.04023189f, -0.03434725f, 0.18583533f, 0.14131221f, 
    0.03519759f, 0.16604525f, 0.11792314f, 0.27325615f, 0.18367188f, 0.09841943f, -0.80875361f, 0.07874646f, 
    0.19659574f, -0.10089639f, -0.04950612f, -0.22630577f, -0.21209523f, 0.11049773f, 0.08368438f, 0.06678648f, 
    0.02235431f, -0.18739735f, -0.14802727f, 0.12278460f, -0.20338953f, 0.12258641f, -0.07755478f, 0.14195113f, 
    -0.12171233f, 0.05348547f, 0.01317063f, -0.01436083f, -0.09902881f, -0.09542464f, -0.08837776f, 0.06663510f, 
    0.06172924f, 0.01024307f, -0.08940661f, 0.11478372f, 0.01965332f, 0.03122120f, -0.10757023f, -0.09069972f, 
    0.04516825f, 0.08098736f, -0.04829881f, 0.01206276f, -0.10381162f, -0.06742254f, -0.02831881f, -0.05299021f, 
    -0.02007677f, 0.09011298f, 0.01971893f, 0.08003135f, 0.00855082f, -0.01619394f, -0.06973675f, -0.05194508f, 
    0.03753747f, 0.07648540f, -0.12305243f, -0.09056155f, 0.04621361f, -0.01099493f, 0.05302864f, -0.08703569f, 
    0.03128041f, 0.03232045f, -0.06509860f, -0.04301070f, 0.10248469f, -0.12384501f, -0.12085862f, -0.02781746f, 
    -0.08784488f, -0.08529887f, -0.00442170f, 0.03585695f, 0.09714906f, 0.08178504f, -0.02575535f, -0.09027250f, 
    0.03837641f, -0.06747440f, 0.12242572f, 0.09995510f, -0.11950813f, -0.10750294f, 0.03409627f, -0.06799853f, 
    0.21775316f, 0.11764903f, 0.07674491f, 0.30569682f, 0.19990796f, 0.20754442f, 0.27778074f, -0.20457602f, 
    0.14255263f, -0.04268714f, -0.13431057f, -0.07107703f, 0.10411517f, -0.07578190f, 0.16181085f, -0.03451715f, 
    0.34341604f, 0.28921035f, 0.12103946f, -0.02361665f, -0.06367734f, -0.19254696f, -0.12529776f, -0.12861764f, 
    -0.21117759f, 0.01997652f, -0.10224381f, 0.08152732f, -0.13867208f, -0.06753551f, 0.01022534f, 0.09045344f, 
    -0.11253281f, 0.10568006f, -0.16955699f, 0.35484904f, 0.16482785f, 0.06558266f, 0.10185262f, 0.03898142f, 
    0.41962922f, 0.06079122f, 0.06810725f, 0.31948987f, 0.14204530f, 0.02857877f, -0.02278493f, 0.26306322f, 
    0.08120169f, -0.03701859f, -0.26213396f, -0.10702813f, -0.08772750f, 0.11298423f, -0.20603152f, 0.01640987f, 
    0.15526642f, -0.02726059f, 0.04923485f, 0.02970694f, -0.03471329f, 0.08763755f, 0.22678337f, 0.09056298f, 
    0.09263016f, 0.06059512f, -0.11809842f, -0.24644157f, 0.09718991f, -0.02491668f, -0.44248530f, 0.20854132f, 
    0.16741720f, 0.17884661f, 0.27397865f, 0.00433905f, 0.11545181f, -0.06590431f, -0.06549361f, -0.03375612f, 
    -0.25685978f, -0.09931139f, -0.19723152f, 0.00149458f, 0.26394871f, 0.24878921f, 0.11587226f, 0.11491252f, 
    0.18519513f, -0.12843505f, 0.28996393f, -0.17483193f, 0.15145290f, 0.17481022f, -0.02901829f, 0.17484742f, 
    -0.06399811f, 0.08713290f, 0.19056256f, -0.22238116f, 0.01250856f, -0.06535204f, 0.02981926f, 0.03805164f, 
    -0.25500056f, -0.14195907f, 0.16173522f, -0.02076521f, -0.03635171f, -0.01678199f, -0.15749997f, -0.06756796f, 
    -0.20196767f, 0.15119073f, 0.29883939f, 0.06099852f, 0.37277362f, 0.07643039f, 0.38550633f, -0.36412486f, 
    0.01944713f, 0.19643512f, 0.25207096f, 0.07106347f, 0.10002598f, 0.01160589f, 0.13850577f, 0.22307971f, 
    0.08321727f, -0.00300853f, 0.19853592f, 0.13161430f, 0.07517778f, -0.02667557f, 0.08323311f, 0.00463065f, 
    -0.01349665f, 0.21458867f, -0.05595745f, -0.13826710f, 0.23899862f, -0.10409497f, 0.14608085f, -0.01377484f, 
    0.03102655f, 0.18694769f, 0.12610891f, -0.03069988f, 0.14880186f, 0.04224385f, 0.06268938f, 0.10248004f, 
    -0.22098395f, -0.35404348f, -0.30333966f, 0.13947019f, 0.00238818f, 0.09529986f, -0.01917055f, 0.14860760f, 
    0.32033393f, -0.07957777f, 0.04444357f, 0.15179202f, 0.08603749f, 0.00521121f, 0.10920680f, 0.10188135f, 
    0.23888899f, 0.01903193f, 0.04142716f, -0.32287490f, 0.16962479f, -0.11906212f, 0.49656799f, -0.00733898f, 
    0.05731513f, -0.00850102f, -0.01185002f, 0.11743714f, -0.09731154f, 0.17579643f, -0.14955595f, -0.48164642f, 
    -0.17212535f, 0.42540622f, -0.07982715f, -0.03718917f, 0.18216529f, 0.02374809f, 0.09867558f, -0.16969980f, 
    -0.04662395f, -0.05075256f, 0.22770150f, 0.15205504f, 0.09941647f, 0.09976780f, 0.14850116f, 0.05411787f, 
    0.17244436f, 0.22282125f, -0.18837869f, 0.04496390f, -0.07232825f, 0.06430842f, 0.22344936f, 0.03450138f, 
    0.22272602f, 0.17568834f, -0.00154420f, -0.02098053f, -0.03010273f, 0.08406768f, -0.04400590f, 0.03100375f, 
    -0.24426149f, 0.01908780f, -0.22514127f, 0.20224716f, -0.12859549f, -0.02953508f, 0.01349310f, 0.03012034f, 
    0.04835925f, 0.05131445f, -0.28056750f, 0.28788924f, 0.21736845f, 0.06986970f, -0.06408777f, -0.02783619f, 
    0.13511388f, 0.00543055f, -0.03407740f, -0.34419134f, 0.03406928f, 0.08379096f, 0.35700813f, -0.01670873f, 
    0.15388440f, 0.20721930f, -0.16749771f, 0.15932053f, -0.06821728f, 0.05799646f, -0.21581437f, -0.02341952f, 
    -0.01445943f, 0.26634738f, -0.16016538f, -0.01020175f, 0.06254940f, -0.01827332f, -0.19558555f, -0.06137665f, 
    0.01071541f, 0.01386120f, -0.18032984f, 0.19568859f, 0.18968010f, -0.08274586f, -0.23652871f, -0.04980798f, 
    0.15648921f, 0.04530022f, -0.14988548f, -0.02451947f, 0.25671527f, -0.06058600f, 0.01788513f, 0.06911717f, 
    -0.03558016f, 0.16057833f, 0.07031973f, -0.00518773f, 0.04353229f, 0.00844392f, -0.03199003f, 0.16579022f, 
    0.01327092f, -0.20694879f, -0.50228494f, 0.03660331f, -0.01393978f, 0.36842620f, -0.18125346f, 0.04106447f, 
    0.04607660f, 0.05007672f, -0.19047865f, 0.17492907f, -0.01040110f, 0.12401040f, -0.15926187f, 0.15622412f, 
    -0.02327906f, -0.20229915f, 0.09108290f, -0.09861222f, -0.32412624f, -0.02020726f, 0.39031547f, 0.00935326f, 
    0.01898937f, 0.04560915f, 0.11060108f, 0.34458756f, 0.37506381f, 0.19080600f, 0.11452661f, -0.07004754f, 
    0.12880930f, 0.15061602f, 0.12393871f, 0.07785253f, 0.08862253f, 0.26444858f, 0.30696547f, 0.15211029f, 
    -0.06037511f, 0.09591386f, -0.03031272f, 0.02936133f, 0.15241738f, 0.48999390f, -0.36745554f, 0.05677032f, 
    0.31479329f, 0.12752259f, 0.00607940f, 0.08181930f, -0.01797605f, 0.02656411f, 0.25601596f, -0.10052922f, 
    -0.27857259f, -0.17317255f, -0.04300165f, -0.24241759f, 0.12072546f, -0.22148362f, -0.18957925f, 0.34239334f, 
    -0.44455159f, 0.10407664f, 0.09632286f, -0.39756745f, 0.01187168f, 0.02551382f, 0.13375787f, 0.04225040f, 
    0.08314811f, -0.07852436f, -0.05319582f, 0.11837925f, 0.21881554f, 0.05739238f, 0.36221737f, 0.20881467f, 
    -0.19450864f, -0.16884570f, -0.00864427f, 0.14471585f, 0.05617083f, 0.08174348f, 0.20134473f, 0.24814765f, 
    0.03452821f, 0.03989809f, -0.31969616f, 0.06301890f, 0.28496805f, -0.12715563f, 0.00484881f, -0.45866188f, 
    -0.18068303f, 0.13559705f, 0.18923484f, 0.03017109f, 0.18655299f, 0.27803963f, 0.24281821f, -0.13583702f, 
    -0.09106865f, -0.01223822f, -0.05291633f, -0.15049042f, -0.09891106f, 0.04132978f, 0.08154405f, -0.09641288f, 
    0.10878919f, -0.11362152f, -0.06923927f, -0.06921269f, 0.05404890f, 0.00402535f, -0.03566834f, -0.11189336f, 
    -0.10018050f, 0.03604335f, -0.17299969f, -0.01936007f, 0.02570783f, -0.06731588f, 0.00891955f, 0.01954204f, 
    0.01315495f, -0.06764152f, -0.03937188f, 0.03371358f, -0.12245698f, 0.02695702f, -0.01801842f, -0.10601464f, 
    -0.07371502f, -0.02369218f, -0.15317228f, -0.09701476f, 0.06740288f, -0.10119393f, -0.02926725f, -0.07111349f, 
    0.04603767f, -0.08704098f, -0.00181249f, -0.11901169f, 0.01331023f, 0.00041802f, 0.11582147f, -0.04739836f, 
    -0.16223608f, 0.06682456f, 0.09095167f, -0.03832632f, -0.06106572f, -0.05003745f, 0.11580027f, 0.05808137f, 
    -0.02728407f, -0.06282520f, -0.04154456f, -0.06311356f, -0.04734715f, -0.05399873f, 0.11081979f, -0.00328276f, 
    0.12638269f, -0.10008508f, 0.22369382f, 0.23889361f, -0.03578929f, -0.17089836f, 0.31159252f, 0.06475825f, 
    -0.03079428f, 0.17789388f, 0.04361805f, -0.09321307f, 0.06964022f, 0.09450497f, 0.14742692f, 0.05623305f, 
    -0.13092378f, -0.23571928f, 0.27375627f, 0.04812384f, 0.18867174f, 0.25764796f, 0.36441213f, 0.03326487f, 
    -0.14746130f, 0.10856258f, 0.05047352f, 0.01604783f, 0.07158717f, -0.08244957f, 0.21962899f, 0.31354365f, 
    -0.03195061f, 0.02346545f, -0.05022230f, 0.05742849f, -0.06135739f, 0.04960324f, -0.44839823f, 0.11525740f, 
    -0.03956453f, 0.13800566f, -0.04863933f, -0.60113490f, 0.08216961f, -0.06285775f, -0.26224607f, 0.11953485f, 
    0.12402017f, 0.20951775f, -0.06965145f, -0.04200572f, -0.48387334f, 0.05368926f, -0.11755907f, -0.46834370f, 
    0.11609182f, 0.21171054f, -0.64055961f, 0.12115018f, 0.20178819f, 0.00344248f, -0.30738199f, -0.15160125f, 
    -0.10442681f, 0.04843231f, -0.26338893f, 0.19654645f, 0.09639590f, -0.04969831f, 0.14253436f, 0.04726202f, 
    -0.03032632f, -0.09102275f, 0.01817383f, 0.06385556f, -0.07827230f, -0.04457206f, 0.13316846f, 0.10899378f, 
    0.13235901f, -0.02717271f, -0.18527949f, 0.02908792f, 0.02252360f, 0.04011564f, -0.09680399f, 0.27724609f, 
    0.10695732f, 0.02133512f, 0.14472599f, -0.02323807f, 0.05349759f, 0.12751693f, 0.15721317f, -0.00355438f, 
    -0.13699803f, 0.01326784f, -0.01351624f, 0.04095796f, 0.01709756f, -0.07620078f, 0.33251151f, 0.16808341f, 
    -0.03969514f, -0.15781337f, 0.19290319f, 0.53960991f, -0.01747959f, 0.03137354f, 0.21483988f, 0.15064403f, 
    -0.09387744f, -0.08262867f, -0.08459380f, 0.11416776f, 0.18177347f, -0.00303730f, 0.14474176f, -0.16630518f, 
    0.29005626f, -0.28495643f, 0.18111533f, 0.06911597f, -0.01734724f, -0.00266904f, 0.21379930f, 0.40660596f, 
    -0.00785723f, -0.07227568f, 0.00546290f, 0.02356076f, -0.12053656f, 0.10852066f, -0.02888148f, 0.08595444f, 
    -0.01852383f, -0.05641017f, 0.07727341f, 0.02776213f, -0.13146593f, 0.04140407f, -0.03749587f, -0.08368871f, 
    0.06192556f, 0.06858785f, -0.04342109f, -0.14162831f, -0.11306071f, -0.02360175f, -0.14221980f, 0.05095870f, 
    -0.06181834f, -0.04468201f, -0.14784782f, 0.08541777f, -0.12565303f, 0.08541644f, -0.06184661f, -0.04036177f, 
    -0.04614412f, -0.04690947f, -0.06474064f, -0.04680411f, -0.10091864f, 0.01153414f, -0.02381174f, -0.06732149f, 
    -0.00808714f, -0.10879299f, -0.04292597f, -0.07196350f, -0.13323851f, 0.06534702f, 0.08870203f, -0.09735494f, 
    0.11174034f, 0.04623951f, -0.06767046f, -0.03010774f, -0.03524339f, -0.03888141f, 0.06370340f, 0.08882842f, 
    -0.06765111f, -0.11314207f, 0.04990993f, 0.09516366f, -0.06449401f, -0.04978807f, 0.10372907f, -0.08892654f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02549671f, -0.11890709f, -0.10014616f, 0.07855747f, 0.09022664f, 0.14727890f, 0.08991934f, -0.06401912f, 
    0.22805148f, 0.27673122f, -0.01043350f, 0.03099260f, 0.18216479f, 0.17478281f, -0.13790400f, -0.10019669f, 
    -0.12829198f, -0.01427950f, -0.13014966f, -0.11920451f, 0.23813762f, -0.08232147f, 0.33246052f, 0.11424775f, 
    0.09893898f, 0.14707285f, -0.06302020f, 0.13921256f, -0.13498119f, -0.05740110f, -0.17999449f, 0.15900713f, 
    0.12319062f, -0.09124571f, 0.16120706f, 0.19097190f, -0.30677834f, 0.04838655f, -0.05901786f, 0.14816551f, 
    0.01478033f, 0.08657873f, -0.07100978f, 0.07652824f, -0.05098767f, -0.07211269f, -0.00449823f, 0.21923611f, 
    0.12242687f, 0.01112229f, 0.14016050f, -0.20831187f, 0.05015979f, 0.02755511f, 0.26695964f, 0.09449749f, 
    0.23323692f, 0.08186061f, 0.01150383f, 0.14611892f, -0.02840492f, 0.13253678f, 0.26308376f, -0.12963644f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.16300347f, -0.12251943f, -0.10489407f, -0.00071391f, 0.02773379f, -0.27493992f, 0.15448390f, -0.04366341f, 
    0.11474714f, -0.02255373f, 0.02683825f, -0.22535419f, 0.08261219f, 0.09443866f, -0.02835978f, -0.07895537f, 
    -0.00591755f, 0.17303385f, 0.10922797f, -0.05382593f, 0.09131020f, 0.01754477f, 0.16376249f, -0.17503130f, 
    -0.07095604f, 0.07032353f, -0.23387364f, -0.18276890f, -0.20336834f, 0.27738634f, -0.08915092f, -0.64999819f, 
    0.15927196f, -0.05326806f, -0.12121405f, -0.43832013f, 0.08366118f, -0.07129461f, 0.00811295f, 0.13801530f, 
    -0.20860010f, -0.62981373f, -0.17020766f, 0.12062932f, -0.13826288f, 0.10377409f, 0.08124981f, -0.36717618f, 
    0.15196395f, -0.10375782f, -0.41455221f, 0.66950130f, -0.21384101f, 0.03059769f, -0.44623095f, 0.00739983f, 
    -0.34796304f, -0.10177877f, 0.01500912f, -0.40561888f, -0.03162979f, -0.13084573f, -0.07740409f, -0.08867865f, 
    0.51144803f, -0.11393924f, 0.00561951f, -0.06449766f, 0.11555962f, 0.18761775f, 0.18681270f, -0.06572344f, 
    0.24167894f, 0.03728470f, -0.02173676f, -0.00956089f, 0.01033039f, -0.11390176f, -0.01912301f, 0.00872331f, 
    0.09779444f, -0.11286120f, -0.05079805f, 0.49335864f, -0.00604462f, -0.32578927f, 0.12116672f, -0.40711004f, 
    -0.04131213f, -0.25427875f, -0.26725778f, -0.01525429f, -0.13010411f, -0.53407633f, 0.12621619f, -0.19878170f, 
    0.11246940f, -0.09782514f, -0.01158956f, 0.01825048f, -0.12902893f, 0.16054916f, -0.15793580f, -0.16074914f, 
    0.17021416f, -0.17957726f, 0.33209816f, 0.34046161f, -0.11432167f, 0.06772476f, 0.10166712f, -0.25266823f, 
    0.19185804f, 0.11128966f, -0.05192749f, -0.36887035f, -0.27804604f, 0.00148451f, -0.15382756f, 0.20280001f, 
    0.09929740f, 0.03607858f, 0.05389724f, 0.22745784f, -0.04980102f, 0.15385477f, 0.06867204f, 0.11454258f, 
    -0.18254295f, -0.09435798f, -0.03059699f, 0.03651391f, -0.11410576f, 0.17100583f, 0.09612749f, 0.06560321f, 
    -0.49410567f, -0.10517152f, 0.09398943f, -0.11266063f, -0.31571051f, -0.11949803f, 0.00700247f, 0.09078553f, 
    -0.03559215f, -0.45281702f, 0.04555410f, -0.23564406f, 0.12170781f, 0.25321352f, 0.02237385f, -0.02841242f, 
    -0.01089608f, -0.03964367f, -0.02958810f, -0.03544406f, -0.36499131f, -0.63133889f, -0.30068102f, 0.34034112f, 
    0.06111706f, 0.05020134f, -0.17452446f, 0.22293380f, 0.29783213f, -0.23573434f, -0.28869355f, -0.15834184f, 
    0.04917577f, 0.22058824f, 0.08825034f, 0.13739699f, 0.23231953f, -0.44355035f, -0.01289007f, 0.13947037f, 
    -0.66099894f, -0.25463241f, 0.22543480f, -0.04383234f, 0.09136666f, 0.11407971f, 0.06012098f, 0.03157627f, 
    -0.11259593f, -0.17641701f, -0.09168951f, 0.24745131f, -0.02038788f, -0.29555845f, 0.13380823f, 0.10883229f, 
    -0.15643609f, -0.08430168f, 0.17428434f, -0.01737214f, 0.02587532f, -0.15277694f, -0.06682947f, -0.05874354f, 
    -0.30112836f, -0.46787727f, -0.11517604f, -0.02477933f, 0.18952607f, 0.12715030f, -0.06352223f, -0.08031696f, 
    0.09286700f, -0.00354710f, 0.00116321f, 0.11346781f, -0.03028116f, -0.12489576f, 0.20065072f, -0.13343915f, 
    -0.09554652f, 0.19369932f, 0.26717404f, 0.01662044f, -0.15854263f, 0.16867729f, -0.03293560f, 0.05964245f, 
    0.07584290f, 0.00856097f, -0.47337309f, 0.06088632f, -0.38184726f, -0.17246915f, -0.19588093f, 0.06651924f, 
    -0.43647039f, 0.10453238f, -0.44684783f, -0.19473922f, -0.03618569f, -0.21221237f, 0.07466552f, 0.09734985f, 
    -0.05206464f, 0.11212294f, 0.16890246f, -0.03412810f, 0.02382463f, -0.05701572f, -0.09230098f, 0.06403143f, 
    -0.18429290f, -0.20236473f, -0.11676288f, -0.24224852f, 0.04807758f, -0.62493658f, 0.15128504f, 0.08397678f, 
    0.03903111f, 0.08288445f, 0.02756919f, 0.14259477f, 0.09899545f, -0.37653729f, 0.00373685f, -0.01122944f, 
    0.06669053f, -0.10216126f, -0.03925798f, 0.01474125f, 0.09510773f, -0.00715008f, 0.05651449f, 0.07531700f, 
    0.10842506f, 0.13161567f, -0.12943870f, -0.23094077f, 0.11754824f, -0.55110514f, 0.04531555f, -0.36101127f, 
    0.08733828f, 0.19195820f, 0.10548227f, -0.37607127f, 0.30534962f, 0.01164887f, -0.33958873f, -0.40613168f, 
    0.11517534f, 0.00602484f, 0.21410783f, -0.28008449f, -0.08504856f, -0.16926840f, -0.00897826f, 0.14396769f, 
    0.14591172f, 0.16203979f, 0.01006633f, 0.07658720f, 0.04560101f, -0.25506309f, -0.15806030f, -0.22190194f, 
    0.16301773f, -0.50046450f, -0.27738553f, -0.51423150f, 0.21984516f, -0.09208532f, -0.08876242f, 0.03874219f, 
    -0.22689965f, -0.05185247f, -0.09993958f, -0.43925536f, 0.03397314f, 0.16509436f, 0.08501285f, 0.05855509f, 
    -0.23216915f, 0.10580342f, 0.16463433f, 0.03242119f, 0.07656246f, 0.08874477f, 0.17407139f, -0.02073376f, 
    -0.19523016f, 0.01153401f, -0.05224493f, -0.01413285f, -0.05426756f, 0.04173427f, -0.10544455f, -0.05167751f, 
    0.07311542f, 0.19096290f, -0.02342562f, 0.01675209f, 0.01906177f, 0.14562458f, 0.15699175f, -0.03462723f, 
    -0.06460832f, 0.11592831f, -0.42048177f, -0.09123373f, 0.04330784f, -0.05639586f, 0.15764567f, -0.48168090f, 
    -0.08966975f, 0.01901555f, -0.00759184f, 0.06412154f, 0.06514297f, 0.20749977f, 0.19219576f, 0.05400614f, 
    0.08612991f, 0.01084663f, 0.07060696f, -0.31730056f, -0.01961952f, -0.31335205f, -0.51509702f, -0.02115810f, 
    0.03453251f, -0.09375624f, -0.11126568f, -0.28753647f, -0.31184724f, 0.09443763f, 0.06992432f, -0.05408267f, 
    0.07678349f, 0.17178009f, 0.11716026f, -0.02193020f, -0.11591537f, -0.09683689f, 0.14573075f, -0.11264522f, 
    -0.23824327f, -0.08345535f, -0.36271966f, 0.21433365f, 0.07218099f, 0.07827424f, 0.04383714f, -0.01750993f, 
    0.07682269f, 0.15020241f, -0.11663457f, 0.00572270f, -0.47377974f, -0.60220665f, -0.03316705f, 0.00424610f, 
    -0.09447230f, -0.49988970f, -0.03728944f, -0.22881024f, -0.61752230f, 0.27035412f, -0.80798000f, 0.15791294f, 
    0.09602212f, -0.55189633f, -0.14795649f, 0.06004194f, -0.36812913f, -0.79101014f, -0.26926664f, 0.39151075f, 
    -0.42293370f, 0.02447615f, -0.13108918f, 0.29205114f, 0.17932297f, -0.44074839f, -0.38414413f, -0.64836824f, 
    0.09215230f, 0.21246752f, 0.16536647f, 0.04080175f, -0.48203573f, 0.09869507f, -0.17524150f, 0.10810868f, 
    -0.16922486f, -0.24989459f, -0.06721700f, 0.03661565f, 0.05900868f, -0.04306997f, 0.07845590f, -0.31707719f, 
    -0.00645311f, 0.13707505f, -0.52977002f, 0.30121177f, -0.00404023f, 0.08524254f, -0.78547603f, -0.12710653f, 
    -0.17298947f, -0.01573184f, -0.37099057f, -0.01651545f, 0.00238402f, -0.29002139f, -0.21244420f, 0.07526262f, 
    0.10551822f, 0.18135825f, -0.15928307f, -0.02409157f, 0.17028598f, 0.03972894f, -0.08712563f, -0.08051902f, 
    0.10961130f, -0.20211075f, 0.10722757f, -0.29807478f, -0.52077669f, 0.02187259f, -0.27163789f, 0.09463261f, 
    -0.05128731f, -0.16101168f, 0.32743964f, 0.12715910f, -0.00989387f, 0.22189237f, 0.24350081f, -0.49681473f, 
    0.23027433f, -0.02011080f, -0.00200226f, -0.00167754f, -0.07840753f, -0.03267206f, -0.01843933f, -0.33728471f, 
    -0.20947616f, -0.28359821f, -0.28182679f, -0.08485843f, -0.17757271f, 0.30282202f, 0.29795551f, -0.08604369f, 
    -0.43190926f, 0.11519907f, -0.04425959f, -0.34972703f, 0.13336855f, -0.02090129f, -0.41603547f, 0.16896065f, 
    0.01692464f, 0.00293720f, -0.19064760f, -0.37505433f, 0.05361079f, 0.05133263f, -0.32979697f, 0.02070866f, 
    -0.34249818f, -0.13384758f, 0.12181429f, -0.52303791f, -0.12355879f, 0.19083805f, 0.16021390f, -0.03507864f, 
    -0.33205646f, -0.12841257f, 0.05966314f, 0.03145612f, -0.20795712f, -0.17668009f, 0.08639841f, 0.05822030f, 
    -0.08393565f, -0.50311691f, -0.02562076f, 0.03492252f, -0.46162525f, 0.27626887f, -0.10334739f, 0.19501291f, 
    -0.05061159f, -0.07764659f, -0.01403736f, 0.14542875f, -0.24383903f, -0.49020833f, 0.22319110f, -0.58827853f, 
    -0.09934356f, 0.02837486f, 0.05394045f, 0.06834992f, -0.04600310f, -0.04843408f, 0.30786797f, -0.16554074f, 
    -0.06980172f, -0.02786674f, -0.12690352f, -0.36771950f, -0.21085627f, 0.27354985f, 0.09259500f, 0.11352042f, 
    -0.54746199f, 0.40122864f, 0.27202612f, -0.09326904f, -0.64141762f, -0.06335171f, 0.14273931f, -0.14851467f, 
    0.17820676f, 0.22099154f, 0.11085404f, -0.13086975f, 0.10574067f, -0.22697751f, -0.01985065f, 0.02154935f, 
    -0.21763337f, 0.09138404f, -0.15774439f, 0.07184764f, 0.03701463f, -0.04466422f, -0.19309866f, -0.12685105f, 
    0.19979694f, 0.25758067f, 0.04192499f, -0.09969129f, 0.00624495f, 0.08025920f, 0.05974739f, 0.03097438f, 
    0.01686829f, 0.05223304f, -0.02584911f, -0.14583893f, 0.05231462f, -0.42658859f, -0.09934805f, 0.22294334f, 
    0.01957432f, 0.15211906f, -0.18545131f, 0.11128514f, -0.17339632f, -0.50675267f, -0.22437100f, 0.09368388f, 
    -0.41099721f, -0.11615018f, -0.00994852f, 0.07666583f, -0.20776683f, -0.37747100f, -0.47592637f, -0.04558417f, 
    -0.16125730f, 0.18435808f, -0.24790500f, -0.35737485f, -0.24609926f, -0.10908579f, -0.17160343f, 0.18460959f, 
    -0.19575705f, -0.30691028f, 0.14461906f, -0.11760518f, 0.27412894f, -0.10177098f, 0.19417334f, -0.07517233f, 
    0.13744704f, 0.11408097f, -0.28519899f, -0.26181698f, 0.02388269f, 0.01889702f, 0.00637872f, -0.04222417f, 
    -0.39143726f, -0.06024692f, 0.20995280f, -0.58298498f, -0.04606694f, -0.06035376f, 0.01798730f, -0.06590077f, 
    -0.34711590f, -0.36520168f, 0.05169546f, 0.04984483f, -0.58134490f, 0.12736882f, 0.04908277f, -0.04960405f, 
    -0.04196066f, -0.31275970f, -0.09857535f, -0.26062679f, -0.17639582f, 0.18364745f, -0.09484041f, 0.03357439f, 
    0.08140489f, -0.25974563f, 0.21270922f, -0.01721460f, 0.22138992f, -0.39825711f, 0.15937133f, -0.00171559f, 
    -0.24970596f, 0.11643465f, 0.30420494f, -0.10434203f, -0.74133456f, 0.18904480f, 0.17181277f, 0.08244007f, 
    0.16334958f, 0.06295667f, -0.05001795f, 0.20861943f, 0.27607319f, -0.34057191f, 0.22836709f, -0.04478507f, 
    -0.00203957f, -0.23807000f, 0.14333577f, -0.34820104f, -0.35151774f, -0.10325427f, -0.10791398f, 0.37637252f, 
    -0.15596451f, -0.18903832f, 0.28389603f, 0.08373044f, -0.08466575f, -0.75362140f, 0.09467319f, 0.01975368f, 
    -0.17880744f, 0.05227607f, -0.45338646f, -0.33349913f, 0.03454003f, -0.07304583f, -0.67678988f, -0.02815437f, 
    0.17225702f, -0.16707176f, 0.07450221f, -0.00113825f, -0.34564894f, -0.26631919f, 0.03366484f, -0.08408998f, 
    0.05484062f, -0.06979334f, -0.01722997f, -0.20075041f, -0.06544688f, 0.13442314f, -0.20673971f, 0.10633898f, 
    -0.10769835f, -0.03403780f, 0.15287483f, -0.07940049f, 0.31850883f, -0.49414861f, 0.19759727f, 0.00033903f, 
    -0.37095591f, 0.02381241f, 0.27192014f, 0.10724406f, -0.20028512f, 0.38622966f, 0.29132700f, 0.22028384f, 
    0.18507569f, -0.04305402f, -0.07929929f, -0.25773731f, -0.22405848f, 0.07433137f, -0.15705445f, 0.02179370f, 
    -0.26971906f, -0.02750329f, -0.04423119f, -0.04867942f, 0.05710763f, 0.04000197f, 0.18372469f, -0.46792844f, 
    0.17529418f, 0.09649252f, -0.03049541f, -0.22235560f, 0.03656746f, 0.00176326f, -0.22116190f, 0.00955490f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.10823993f, 0.17678334f, 0.08096194f, -0.03325590f, 0.07049284f, -0.16008501f, -0.03372800f, -0.15927805f, 
    -0.08232016f, 0.37500486f, 0.09415506f, -0.06925607f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
