#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.40865889f, -0.42960936f, 0.25247434f, -0.05706070f, 0.15701272f, 0.05945199f, -1.03393042f, -0.56741440f, 
    0.42241690f, -0.25478822f, -0.12157808f, -0.00381980f, -0.18865255f, -0.03780580f, -0.48368323f, -0.33905125f, 
    -0.02448798f, 0.01306849f, -0.54824752f, -0.17564256f, 0.20661984f, 0.21804805f, 0.27227309f, -0.35797554f, 
    -0.30437088f, 0.54130024f, 0.17193228f, 0.22061329f, -0.14034832f, -0.36596110f, -0.16516334f, 0.29433048f, 
    0.08961867f, -0.15023090f, 0.40683264f, 0.03992252f, 0.16228703f, 0.11507187f, -0.17685132f, -0.16782151f, 
    -0.08020649f, 0.02048099f, -0.13361901f, 0.00753654f, -0.00395813f, 0.04595631f, 0.00420295f, -0.02738131f, 
    -0.10822989f, 0.15862517f, 0.76684910f, 0.62766242f, -0.34326926f, -0.40494290f, -0.53085858f, -0.17476118f, 
    0.14206074f, 0.26553601f, 0.02072221f, -0.41070411f, -0.23372085f, 0.05875956f, 0.17004493f, -0.23915580f, 
    -0.11188275f, 0.01357482f, -0.00004409f, 0.06424727f, -0.21346432f, -0.38912717f, -0.39231834f, -0.38351676f, 
    -0.52745575f, -0.60722500f, -0.60900557f, -0.12716322f, -0.14812292f, -0.36930534f, 0.08320197f, 0.29023421f, 
    -0.09685516f, -0.16468674f, -0.06234233f, 0.19058071f, 0.27651638f, 0.20083916f, -0.19984560f, -0.15719527f, 
    -0.28021467f, 0.36927915f, -0.43983880f, 0.20467129f, -0.04238235f, 0.15491001f, -0.34422311f, 0.08520844f, 
    0.13249685f, 0.16470277f, 0.17731044f, 0.31491977f, -0.23883271f, -0.13235684f, 0.41301963f, -0.26214197f, 
    -0.85081202f, 0.73398101f, -0.39259467f, 0.10508887f, 0.14678417f, -0.02392282f, -0.10047612f, -0.17883997f, 
    -0.07758008f, -0.13144457f, -0.23797247f, 0.13798834f, 0.28191906f, -0.07170361f, 0.05418221f, 0.22576554f, 
    -0.01927543f, -0.01310482f, 0.06672705f, 0.02921812f, -0.01097271f, 0.29736635f, 0.50075704f, 0.31067976f, 
    0.37288406f, 0.24126793f, -0.08581486f, -0.33710891f, -0.41134182f, -0.24132924f, -0.25084797f, -0.09635954f, 
    -0.19981940f, -0.05783702f, 0.08683809f, -0.15571266f, 0.27563956f, 0.42440432f, -0.01961858f, -0.01099518f, 
    -0.11916722f, -0.11633696f, 0.08457475f, -0.21200606f, 0.02791531f, -0.17043684f, -0.08870788f, 0.39133808f, 
    -0.18250065f, -0.11584361f, -0.07523908f, 0.34316444f, 0.37363088f, -0.14260860f, -0.20120178f, -0.32740957f, 
    0.41473293f, 0.02420580f, -0.02924108f, -0.16278058f, -0.02872433f, -0.19020288f, -0.09747689f, 0.41366071f, 
    -0.13908660f, -0.30699620f, 0.36988726f, 0.05290798f, -0.44822153f, -0.28095400f, -0.39175549f, -0.02226052f, 
    -0.23553714f, -0.71185321f, -0.88022256f, -0.77543449f, 0.31433368f, -0.13059202f, 0.35676646f, 0.12253600f, 
    0.10546177f, 0.29650152f, 0.13056412f, 0.43756327f, -0.47155973f, -0.25618887f, -0.29420915f, 0.04701590f, 
    0.07997649f, -0.10048661f, 0.23083767f, 0.05774949f, 0.32603911f, -0.32380643f, -0.31398079f, 0.33860075f, 
    -0.57870793f, 0.22290079f, -0.04441912f, 0.18117125f, 0.27791017f, 0.02971543f, 0.07623088f, -0.05713062f, 
    0.47810602f, 0.06426673f, -0.10315088f, 0.11246269f, 0.43748420f, -0.53099769f, 0.06392130f, -0.30615851f, 
    -0.00558406f, 0.09358285f, -0.37466446f, 0.16160375f, -0.18166913f, 0.24221121f, -0.32245919f, 0.16596329f, 
    0.28621367f, 0.62043411f, -0.46456084f, -0.55185467f, -0.08524416f, -0.21917570f, 0.34121436f, -0.11749398f, 
    -0.14274240f, 0.09063777f, -0.14290199f, 0.02107292f, -0.19716895f, 0.07518790f, 0.26252007f, -0.25759345f, 
    -0.36955383f, -0.16775438f, 0.02097780f, 0.01681990f, -0.42831820f, 0.18863644f, -0.11017087f, -0.01048895f, 
    0.15460707f, 0.39980188f, 0.22190592f, 0.52034801f, 0.05923039f, 0.13281046f, 0.26041925f, -0.18758756f, 
    -0.08070793f, 0.14841719f, 0.09018881f, 0.14287418f, 0.09820085f, 0.11432711f, -0.06972882f, -0.09945156f, 
    -0.15032378f, 0.03808871f, -0.15112038f, -0.11818078f, -0.04573655f, -0.12492599f, -0.32543463f, 0.08222299f, 
    -0.14427969f, -0.14151385f, -0.38316402f, 0.29512715f, 0.50138360f, 0.45498893f, -0.28399101f, -0.34711039f, 
    -0.17826028f, 0.02432630f, 0.12964241f, 0.16712031f, -0.28863421f, -0.00545652f, -0.46440473f, 0.29629651f, 
    -0.08012985f, 0.04008844f, -0.05640225f, 0.11284599f, -0.15240404f, -0.18832526f, -0.25715357f, -0.41779652f, 
    -0.40201378f, -0.45176518f, -0.54576808f, -0.44751945f, -0.82184809f, -0.53551579f, -0.34162214f, 0.46143654f, 
    0.39693803f, 0.24217907f, 0.10390118f, 0.21419819f, 0.14196286f, -0.13404697f, 0.32232213f, -0.09374932f, 
    -0.22982062f, 0.43088353f, -0.49182037f, -0.27052775f, -0.01842573f, 0.03465547f, -0.19451500f, -0.23845260f, 
    -0.06231784f, -0.28181368f, 0.17773877f, -0.29825512f, -0.42655748f, -0.05339965f, 0.05373156f, -0.23275033f, 
    -0.05772057f, -0.25134578f, 0.20049652f, 0.11582828f, 0.23838781f, 0.28091589f, -0.44061688f, -0.54378986f, 
    -0.36335689f, 0.08382411f, 0.39156702f, -0.01376952f, 0.27188882f, 0.02786393f, 0.04853569f, 0.17124717f, 
    -0.24577232f, -0.12948091f, -0.21442217f, -0.30048335f, -0.05753256f, 0.10737683f, -0.25522035f, -0.95696759f, 
    0.26033166f, 0.47024977f, 0.68408555f, -0.41763264f, -0.66468662f, 0.67220545f, -0.45797652f, 0.04944892f, 
    -0.12267148f, -0.01255078f, 0.09915024f, -0.30082256f, -0.10305364f, -0.02634031f, 0.07525124f, 0.02598323f, 
    0.08725896f, 0.13476714f, -0.33903855f, 0.13234736f, -0.03958964f, 0.09626604f, 0.20683230f, -0.05672036f, 
    -0.52745044f, -0.56598121f, -0.70493108f, -0.36764890f, -0.70628673f, -0.86800098f, -0.15898328f, -0.23432037f, 
    -0.42951390f, 0.08568629f, 0.29219767f, 0.27098599f, 0.15788941f, -0.18243599f, 0.28546077f, 0.13277613f, 
    -0.16468811f, 0.24473140f, 0.21799710f, -0.06843120f, -0.16810904f, -0.13357794f, 0.27438685f, 0.09662505f, 
    -0.63844693f, -0.53942764f, -0.51040179f, 0.33179092f, 0.37327385f, -0.18750291f, -0.36300412f, -0.76934940f, 
    -0.36640769f, -0.41389537f, -0.23014858f, 0.30419609f, -0.40646210f, -0.22435382f, -0.18666749f, 0.15159416f, 
    -0.06159185f, 0.12986684f, 0.19311728f, 0.37353256f, 0.15758091f, -0.33270124f, -0.26828220f, -0.41302866f, 
    -0.10778166f, 0.80306220f, 0.22650911f, -0.19724040f, -0.39018536f, -0.59455454f, 0.13653082f, 0.29510877f, 
    0.24074848f, 0.08708722f, -0.15385987f, -0.06008796f, 0.46292806f, -0.22171737f, -0.09345710f, 0.06258052f, 
    -0.07881712f, -0.08833465f, 0.15573914f, 0.05458229f, -0.14923902f, 0.01291419f, -0.05655358f, -0.31165671f, 
    0.18721445f, 0.19438641f, -0.50468481f, -0.50985509f, -0.00696112f, 0.10042375f, 0.37427536f, 0.11151182f, 
    -0.06470016f, -0.32883021f, -0.04907978f, 0.36312026f, 0.21734516f, -0.14382754f, 0.12629727f, 0.15000233f, 
    -0.26088297f, -0.17051804f, 0.03627882f, 0.14706844f, -0.23764898f, 0.00696769f, -0.23595940f, 0.23613866f, 
    0.39120534f, 0.28197068f, -0.10286903f, 0.23160143f, -0.33461708f, 0.19508645f, -0.20797382f, 0.03902204f, 
    0.40233803f, 0.04146516f, -0.32838401f, -0.55251253f, 0.55436850f, -0.16130754f, 0.15616985f, -0.35015363f, 
    0.00611216f, 0.25113365f, 0.17332824f, -0.00413515f, -0.15159796f, 0.01256593f, -0.52304369f, 0.23620830f, 
    0.03768471f, 0.15506177f, -0.15875697f, 0.17299236f, 0.38236973f, 0.06276151f, -0.22316095f, -0.01134573f, 
    0.31294137f, 0.48137698f, -0.05475349f, -0.18802601f, -0.38396794f, -0.04486164f, -0.32730114f, -0.02582008f, 
    -0.14277764f, -0.10097145f, 0.04121872f, 0.00580136f, -0.28545830f, 0.19005316f, 0.22930355f, -0.36758322f, 
    0.09315073f, -0.22043031f, -0.17575626f, 0.26013759f, 0.31324783f, -0.23774843f, 0.07753048f, 0.19213748f, 
    0.28986448f, 0.06157143f, 0.21873869f, -0.57342589f, -0.52010024f, -0.42443547f, 0.10983980f, 0.25867498f, 
    0.31580895f, -0.23894306f, -0.24135314f, 0.56412899f, -0.22153305f, -0.12267523f, -0.05132872f, -0.01138777f, 
    0.17930351f, -0.22146934f, 0.36587471f, -0.18492724f, 0.35663384f, -0.34912369f, -1.15128624f, -0.91765040f, 
    0.17389840f, 0.37399784f, 0.33998334f, 0.01231578f, 0.30305746f, -0.08747971f, -0.26351628f, -0.25443992f, 
    0.47305000f, 0.01204945f, 0.11820216f, 0.48199609f, -0.33262819f, 0.10996136f, -0.13390724f, -0.30522403f, 
    0.27438352f, -0.15433653f, 0.04954701f, 0.00052564f, 0.06820864f, -0.09450424f, -0.01856074f, -0.21654728f, 
    -1.12306583f, 0.46103129f, 0.54835904f, 0.87325150f, 0.70550722f, -0.16993089f, -0.44961533f, -0.24561885f, 
    0.12328985f, 0.01856543f, -0.22501178f, 0.26431027f, -0.42100435f, -0.17198637f, -0.11586166f, -0.09174017f, 
    0.19950180f, 0.12444066f, -0.03102050f, 0.09877542f, -0.21902725f, -0.30884132f, 0.12494665f, -0.10999841f, 
    -0.26367122f, -0.35752964f, -0.50608343f, -0.44307888f, -0.38337365f, 0.04875460f, -0.48301712f, -0.34322077f, 
    -0.37435219f, -0.24369748f, -0.31624967f, -0.14746213f, -0.22554389f, -0.31145084f, 0.14110045f, -0.11572561f, 
    -0.07311485f, 0.13560517f, 0.15896064f, 0.13195491f, 0.16031395f, 0.22805259f, -0.00314843f, 0.23427360f, 
    0.26682648f, -0.55716217f, -0.29476401f, -0.57992131f, -0.07502957f, -0.21890412f, 0.20099662f, -0.17163335f, 
    0.27414593f, 0.37244269f, -0.46031848f, -0.42073300f, -0.28984597f, 0.08511277f, 0.22063097f, -0.45944560f, 
    0.32888612f, -0.02094771f, -0.19939680f, 0.28286546f, 0.14746703f, -0.06308745f, 0.34662479f, 0.04553689f, 
    0.16392528f, -0.11923498f, 0.36748052f, 0.82304895f, 0.55667037f, 0.08561472f, -0.14606716f, -0.29733109f, 
    -0.31653041f, -0.28001907f, -0.31051946f, -0.03547286f, 0.19749324f, -0.18292926f, -0.04379997f, 0.13912453f, 
    -0.27557144f, -0.09143012f, 0.02821744f, 0.12417375f, 0.29106039f, 0.16714513f, 0.03981062f, 0.21634729f, 
    -0.11468497f, -0.33924425f, -0.27245593f, -0.18126635f, -0.52921003f, -0.76079857f, -0.73613024f, -0.12691687f, 
    0.63728017f, 0.10816883f, 0.25925463f, -0.28558257f, -0.08474961f, -0.30758086f, -0.03896699f, -0.00998361f, 
    0.29970559f, -0.04028272f, 0.33015001f, 0.00422136f, 0.23917592f, 0.01017029f, -0.27864194f, -0.34468085f, 
    0.11983781f, 0.10456678f, -0.32845068f, -0.18343095f, -0.33484569f, -0.31515336f, -0.52029228f, -0.27136981f, 
    -0.64945769f, -0.26879314f, 0.13497873f, -0.20118605f, -0.30232471f, -0.01518504f, 0.17070924f, -0.13066223f, 
    -0.20172787f, -0.28301123f, -0.31936225f, -0.14997660f, -0.06058373f, -0.21959926f, 0.23637916f, -0.11352286f, 
    -0.35107654f, -0.24461897f, -0.33282816f, 0.11468676f, -0.22001731f, -1.33940768f, 0.78207397f, -0.29431033f, 
    -0.91645461f, 0.58532614f, -0.03914548f, -0.07111770f, 0.70279628f, 0.05589168f, 0.18473011f, -0.28094855f, 
    -0.26048121f, 0.10371032f, -0.48088562f, 0.00220086f, 0.50406480f, -0.26734453f, -0.40970883f, -0.28765193f, 
    -0.14851825f, -0.05501565f, -0.11791861f, -0.13741009f, -0.31772089f, -0.44590750f, 0.10931036f, -0.20131914f, 
    -0.66224051f, -0.65159124f, -0.59123099f, -0.07508107f, -0.07394111f, 0.07539680f, -0.35403419f, -0.22123261f, 
    0.41852453f, 0.45430514f, 0.42622566f, -0.08177695f, 0.37372315f, -0.11014597f, 0.07484008f, -0.00448621f, 
    -0.27213284f, -0.10721432f, -0.08316822f, -0.18889029f, 0.07841697f, -0.12395302f, -0.22090544f, -0.48882151f, 
    -0.67271453f, -0.18818802f, 0.74266690f, 0.42394054f, -0.62657911f, -0.07731739f, -0.25331104f, 0.64750361f, 
    0.31600654f, 0.11432250f, 0.31227145f, -0.20933908f, -0.18678708f, 0.22719686f, -0.10400435f, 0.13542968f, 
    0.07229008f, -0.34167492f, -0.25539124f, 0.13226295f, -0.04694522f, -0.26467240f, 0.14905301f, 0.52603132f, 
    0.89581609f, -0.57957184f, -0.24837478f, 0.34230077f, -0.43576697f, 0.65186632f, 0.75311315f, -0.34388578f, 
    -0.28547287f, -0.18644989f, -0.16227855f, -0.03333490f, -0.00013498f, -0.24969602f, -0.15675765f, 0.05502049f, 
    -0.07200190f, 0.20536160f, -0.00184243f, -0.15206690f, 0.01670457f, -0.08365028f, -0.07561371f, 0.14498158f, 
    0.01100053f, 0.55612099f, 0.05790951f, -0.01540902f, 0.19640818f, -0.10321636f, 0.06455602f, -0.35735947f, 
    -0.37359723f, -0.42595714f, -0.37728322f, 0.13600226f, -0.10867362f, 0.06513713f, 0.26634791f, 0.03167146f, 
    0.15842523f, 0.21379845f, 0.19260114f, 0.08081672f, 0.18934137f, -0.06643556f, -0.08399047f, 0.00580011f, 
    0.27560261f, -0.14782973f, 0.24329285f, 0.10517530f, 0.20162527f, -0.02917091f, 0.40800381f, -0.11632422f, 
    -0.35654080f, -0.55539089f, -0.26605093f, 0.49348587f, -0.15125608f, 0.05122792f, -0.07112187f, 0.01180014f, 
    0.11122103f, 0.22169213f, 0.16791949f, 0.21978858f, -0.11678278f, -0.20131248f, -0.04055963f, 0.00602848f, 
    -0.05939900f, 0.03672216f, 0.24215266f, -0.92755359f, -0.37192094f, -0.03179519f, -0.85848278f, -0.77146202f, 
    -0.00855443f, 0.27277967f, 0.14562294f, 0.00354957f, 0.22307137f, -0.18303005f, -0.33361846f, -0.49549744f, 
    -0.68517625f, -0.28158197f, 0.05827219f, 0.17423809f, -0.30502394f, -0.28089717f, -0.48687950f, -0.05831139f, 
    -0.17135295f, 0.05912798f, -0.12867785f, -0.14830758f, -0.53889823f, -0.41698346f, -0.68050182f, -0.47722778f, 
    -0.41927889f, 0.51378268f, 0.46496454f, 0.43386695f, 0.15304212f, 0.36247733f, 0.13587463f, 0.26824105f, 
    0.19727667f, -0.19677445f, 0.05418058f, -0.20617111f, -0.09894882f, -0.11213160f, 0.06673910f, 0.01511194f, 
    0.04095226f, -0.12115984f, -0.11988487f, 0.04479231f, 0.02302748f, 0.26263142f, -0.32567328f, -0.18216516f, 
    -0.36436003f, -0.13084389f, 0.25382775f, 0.26859447f, 0.25435653f, 0.29334071f, -0.14469494f, 0.02085598f, 
    0.45056516f, -0.01282412f, -0.35618323f, 0.23131698f, -0.48275298f, -0.17087401f, -0.13762397f, -0.12547708f, 
    -0.15371631f, 0.39758939f, 0.16238229f, 0.12859279f, -0.02311123f, 0.10073019f, -0.05389765f, -0.40778345f, 
    0.20555879f, -0.10909748f, -0.54678136f, 0.34586570f, -0.42570248f, -0.27597028f, 0.20504023f, 0.38816503f, 
    0.19792916f, 0.04344057f, 0.05411356f, -0.12669057f, 0.52901864f, -0.29801291f, 0.15898766f, -0.21110781f, 
    0.01965819f, 0.21443614f, -0.08308288f, -0.44282594f, 0.09861646f, 0.41674304f, -0.34869421f, 0.10210828f, 
    0.11907432f, 0.07737006f, 0.27247933f, 0.11032347f, 0.02877179f, 0.39584816f, 0.25152153f, 0.12646829f, 
    -0.08770557f, 0.13661170f, 0.03833785f, 0.14425662f, 0.09587557f, -0.08627029f, 0.04687035f, -0.17304581f, 
    -0.01264961f, 0.09242419f, -0.06352638f, -0.07416496f, -0.11641686f, -0.02213361f, 0.12342066f, -0.07755559f, 
    0.41480947f, 0.29255745f, -0.43521872f, -0.14368835f, -0.16904505f, -0.73673505f, -0.47135216f, -0.24994820f, 
    0.40864721f, 0.44485015f, 0.04449655f, 0.23263064f, 0.14364082f, 0.11294811f, -0.20175867f, 0.00993470f, 
    -0.11649010f, 0.04034651f, -0.28537297f, -0.06885621f, -0.21588922f, -0.16618454f, -0.06470179f, -0.03500701f, 
    0.15656285f, 0.45079830f, 0.39424735f, -0.23898539f, 0.19078650f, -0.00518438f, -0.38508964f, -0.49884018f, 
    -0.76704854f, -0.53884047f, -0.52432102f, -0.31280109f, -0.08660487f, -0.29875997f, -0.24459510f, -0.20081341f, 
    -0.17334634f, 0.02319016f, 0.02090374f, -0.27525476f, -0.01992644f, -0.24202062f, -0.04595302f, -0.15856607f, 
    -0.22536790f, 0.00216724f, -0.31991100f, -0.51381922f, -0.63072354f, -0.70295644f, -0.35823080f, -0.30779821f, 
    0.04028556f, 0.16085607f, -0.22212552f, -0.47297388f, 0.12516293f, 0.28791848f, -0.37582266f, -0.43513587f, 
    0.00402276f, -0.60469615f, -0.26444766f, -0.13431635f, -0.30317333f, -0.50854802f, -0.12817784f, 0.42772982f, 
    -0.09107748f, 0.13332538f, 0.29468137f, 0.76436847f, 1.11628282f, 0.11023878f, -0.38924667f, -0.75684315f, 
    0.01624626f, -0.52119601f, -0.00009960f, 0.11412639f, -0.62710893f, -0.01621218f, -0.13224486f, 0.24464509f, 
    0.10852331f, -0.02882861f, 0.26235124f, 0.24906720f, -0.01822450f, 0.07250977f, -0.53192925f, 0.07275293f, 
    0.10599747f, -0.18397194f, -0.00488829f, 0.14628227f, -0.33178931f, 0.08810423f, 0.11049264f, 0.31582370f, 
    0.28611812f, -0.08047062f, -0.45955509f, 0.06712054f, 0.59036958f, 0.03467028f, -0.31273821f, -0.24855132f, 
    -0.16033581f, 0.26107293f, 0.15376706f, 0.24447547f, 0.04811234f, -0.06412347f, -0.23481649f, -0.24307778f, 
    -0.14077404f, 0.18301056f, 0.03745896f, -0.15261173f, -0.11931206f, 0.38229215f, 0.05225350f, 0.19877236f, 
    0.20605336f, 0.19657479f, 0.09423416f, -0.06767467f, 0.30253446f, 0.20153020f, -0.10387299f, -0.04214898f, 
    0.01137875f, 0.09444601f, 0.04954481f, -0.02532360f, 0.21412374f, 0.10767829f, 0.09720809f, -0.12870540f, 
    -0.21940759f, -0.16057801f, 0.29110962f, -0.10255674f, -0.06423549f, -0.04782153f, 0.86399311f, 0.12231356f, 
    -0.33264622f, 0.16530241f, 0.49204960f, -0.03380053f, 0.35715133f, -0.13852508f, -0.37093398f, -0.61089736f, 
    -0.24872001f, -0.02618249f, -0.08406924f, -0.14197785f, -0.05596185f, -0.19559428f, 0.14414312f, 0.14200844f, 
    0.03054705f, 0.13053524f, 0.14924112f, -0.17013361f, -0.24609488f, -0.14406203f, -0.06633073f, 0.55627471f, 
    -0.52927768f, -0.92702436f, -0.12905931f, -0.74608654f, -0.09238154f, 0.26698953f, -0.08917969f, 0.06295305f, 
    0.40127680f, -0.05154248f, -0.02125045f, -0.45306686f, 0.17074770f, 0.45307973f, -0.13383918f, -0.08053099f, 
    -0.29260811f, -0.03657884f, -0.41837555f, 0.05855587f, -0.26101518f, -0.05333268f, 0.10487646f, -0.22469039f, 
    -0.78119224f, -0.17047140f, -0.35920915f, -0.47303951f, -0.06326310f, 0.54318964f, -0.10015884f, 0.05318737f, 
    0.24353857f, 0.29521859f, 0.13878331f, 0.08991266f, -0.12533523f, 0.12655286f, 0.04559645f, -0.23794612f, 
    -0.26706505f, 0.26219362f, 0.27726164f, 0.06313416f, -0.02248899f, -0.00770275f, 0.07751328f, -0.14375900f, 
    0.14159843f, -1.56952429f, -0.79314160f, -0.23931104f, -0.49477938f, -0.53850204f, 0.64351696f, 0.30842927f, 
    -1.12735963f, -0.81318599f, 0.65400469f, -0.21658441f, -0.33379340f, -0.11830260f, -0.41247779f, -0.42262825f, 
    0.22224694f, 0.20529409f, -0.20985045f, -0.08861873f, 0.00003014f, -0.03135639f, -0.19871007f, -0.15185428f, 
    0.03776210f, 0.10214469f, -1.26898897f, 0.15034071f, 0.45953986f, -0.76138830f, -0.29630435f, -0.01401815f, 
    0.45001155f, 0.22151498f, 0.50623339f, 0.50733358f, 0.06141329f, -0.01523475f, 0.07385851f, -0.20162739f, 
    -0.23405720f, -0.01725434f, 0.10470617f, -0.31987181f, -0.14302006f, 0.03052581f, -0.06120651f, 0.03346751f, 
    0.21606989f, -0.06519632f, -0.12138924f, -0.33479708f, -0.60542047f, -0.48700005f, -0.39052147f, 0.13888387f, 
    -0.01675801f, 0.15085199f, 0.43920389f, 0.38026610f, 0.08665229f, 0.07692892f, 0.36118624f, -0.04725625f, 
    -0.09991483f, -0.11731426f, -0.15141970f, 0.04893588f, -0.12427646f, -0.24869658f, -0.41977021f, -0.07068293f, 
    0.25082368f, 0.12331142f, 0.14180508f, 0.21500130f, -0.06846483f, 0.22498766f, -0.12082762f, -0.51909560f, 
    0.10418193f, -0.25362813f, -0.08123649f, 0.05704033f, -0.11587777f, -0.10857182f, 0.36472678f, 0.22914313f, 
    0.26753193f, 0.13144761f, -0.08908716f, -0.04485038f, -0.20692860f, -0.17162122f, -0.17073204f, -0.13635816f, 
    -0.06187766f, -0.23016748f, -0.11025953f, -0.28470802f, -0.39748073f, -0.39845431f, -0.41713664f, 0.25937495f, 
    0.25798228f, -0.16146542f, -0.90646476f, -0.79176348f, 0.07615619f, 0.06262381f, -0.67777288f, 0.27805027f, 
    -0.19572459f, 0.06365696f, 0.71770644f, -0.22925477f, 0.26416981f, -0.06749056f, -0.11068663f, -0.56233811f, 
    -0.53545731f, -0.23782498f, 0.00295056f, -0.06406102f, -0.24126683f, 0.41062033f, -0.13109843f, 0.12413292f, 
    0.04887828f, 0.06381422f, 0.14427410f, -0.04591037f, -0.20607546f, 0.06292137f, 0.11613125f, -0.24451523f, 
    0.25568691f, 0.02767112f, 0.25358310f, 0.10841549f, -0.19699755f, 0.25478983f, -0.20994122f, 0.17472678f, 
    -0.08545038f, -0.08796313f, -0.03767244f, 0.19446991f, -0.01674215f, 0.20394500f, 0.32378957f, 0.76867282f, 
    -0.41485876f, -0.07880901f, -0.31513456f, -0.52891707f, 0.24733083f, -0.05495749f, 0.31783959f, -0.26941130f, 
    0.25752386f, -0.06540637f, -0.27391928f, 0.27698472f, -0.20372678f, -0.06308281f, 0.05085951f, -0.02396893f, 
    0.14411822f, 0.12973878f, 0.04323568f, -0.41219550f, -0.16532673f, 0.00312815f, 0.09671146f, 0.12512945f, 
    -0.50473696f, -0.39028439f, -0.52697736f, -0.75043792f, -0.42355329f, 0.63652265f, -0.00638651f, 0.10673638f, 
    0.04936457f, 0.00041444f, -0.52268928f, -0.18440349f, 0.20014250f, 0.25507188f, -0.02949087f, 0.00466959f, 
    -0.47807628f, -0.19357012f, -0.15333267f, -0.10867836f, -0.06159113f, 0.32706922f, 0.30882794f, 0.05666109f, 
    -0.09845041f, -0.84489882f, -0.67593455f, -0.37174043f, 0.08362722f, -0.24080586f, 0.49719644f, 0.13570499f, 
    -0.02699044f, 0.26950580f, 0.41705388f, 0.30819955f, 0.16697627f, 0.36234501f, 0.14823778f, 0.08356124f, 
    -0.00406223f, -0.19439499f, -0.05096924f, -0.03384378f, -0.05984775f, -0.02899259f, 0.11865994f, 0.03555971f, 
    0.03887016f, -0.20445448f, -0.21024373f, 0.25722411f, 0.34772292f, -0.00255697f, -0.23403299f, -0.67350197f, 
    0.14759605f, 0.25264609f, -0.10694007f, 0.23595098f, -0.24962129f, 0.36002883f, -0.33403742f, 0.30433044f, 
    -0.33760950f, -0.29952565f, -0.18677461f, 0.05285956f, 0.23535022f, 0.31021243f, -0.04585746f, -0.06234086f, 
    0.04405022f, -0.01898613f, 0.32462668f, 0.35146949f, -0.20590113f, 0.19993025f, -0.21057703f, -0.13758506f, 
    0.04577535f, 0.36457521f, 0.39099747f, -0.11373056f, -0.03692131f, -0.13477004f, -0.20452225f, 0.39686051f, 
    -0.36486217f, -0.35167027f, -0.12980631f, 0.16590643f, -0.39846852f, 0.08833169f, 0.21297187f, -0.09714171f, 
    -0.28859809f, 0.06043156f, 0.10347535f, 0.34223351f, 0.43156838f, 0.05233040f, 0.04233016f, -0.17945215f, 
    0.10215911f, 0.02583512f, -0.11698742f, 0.09074195f, 0.18438424f, -0.07824808f, -0.06837014f, -0.20888808f, 
    0.00846659f, -0.21867196f, -0.03663407f, 0.29971993f, 0.17319475f, -0.05875500f, -0.18074080f, -0.27334851f, 
    0.16406670f, -0.07640500f, 0.32361156f, -0.08598327f, -0.39024276f, -0.59108168f, -0.89001554f, 0.15967995f, 
    0.11259172f, 0.45530787f, -0.78352773f, -0.69015437f, 0.01312400f, 0.25491950f, -0.03785919f, 0.44432569f, 
    0.46537304f, 0.24549834f, 0.06435540f, -0.26729715f, -0.26806834f, -0.05365610f, -0.33517963f, -0.21086940f, 
    -0.08220313f, 0.29703495f, -0.08848815f, -0.08454500f, -0.00995103f, -0.11125351f, -0.66450047f, -0.59247535f, 
    -0.22764030f, 0.05565744f, 0.40096369f, 0.23757169f, 0.36112827f, 0.00687670f, -0.05173990f, 0.56548250f, 
    -0.25738832f, -0.37238172f, -0.48338786f, -0.20415981f, -0.14736813f, 0.34257323f, 0.08278465f, -0.00958437f, 
    0.15677412f, -0.09313592f, -0.01362334f, -0.49695349f, -0.25372064f, -0.43964440f, -0.15444888f, -0.18295369f, 
    -0.00675801f, 0.43646309f, -0.12172280f, -0.30378321f, -0.11226118f, 0.06497983f, 0.02159914f, 0.02707972f, 
    0.20327240f, -0.17474276f, -0.17284121f, 0.13361038f, 0.39841822f, -0.26106092f, -0.23853880f, 0.06241961f, 
    -0.00726106f, -0.07479804f, 0.37561494f, -0.04276440f, 0.31933260f, 0.19064225f, -0.37451571f, -0.07092331f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29167283f, 0.21632488f, -0.03775253f, 0.24744137f, 0.22609603f, 0.02122044f, 0.23891406f, 0.45534164f, 
    0.27930799f, 0.32969055f, 0.09280799f, -0.00532926f, 0.00428632f, -0.10255216f, 0.16425796f, -0.14235365f, 
    -0.12811640f, 0.48691997f, 0.06763900f, 0.28065795f, 0.33128563f, 0.20991053f, 0.26718935f, 0.48977321f, 
    -0.30303994f, -0.41209611f, 0.18516529f, -0.25954366f, -0.03479673f, 0.04099515f, 0.15541451f, 0.38022834f, 
    0.24754560f, 0.07795445f, -0.04079090f, -0.44643307f, 0.08380856f, 0.31523854f, 0.09594925f, -0.09011684f, 
    0.48295611f, 0.01600691f, 0.07876561f, 0.42069942f, 0.46850201f, -0.04209256f, -0.03836375f, 0.21303612f, 
    0.39236996f, -0.34585398f, 0.16962141f, 0.05550397f, 0.01503983f, 0.26143172f, 0.15603761f, 0.17456460f, 
    -0.12147433f, 0.18291257f, 0.08198329f, 0.24048208f, 0.45105335f, 0.18276416f, 0.00150222f, 0.15217352f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13321531f, 0.12492165f, 0.11177468f, -0.24919970f, 0.05882567f, 0.17941937f, -0.06628289f, 0.01610470f, 
    -0.04917464f, -0.03357227f, -0.04954743f, -0.08714010f, -0.15831527f, -0.10198130f, -0.01283269f, 0.02211794f, 
    -0.01677893f, 0.05952302f, 0.00495192f, 0.03944739f, -0.10935362f, -0.02769400f, -0.03980512f, -0.19605391f, 
    -0.06294484f, -0.30331361f, -0.04971317f, 0.09143624f, -0.01816303f, -0.03559812f, -0.16162354f, -0.07495698f, 
    -0.05867400f, 0.11109695f, -0.00792974f, 0.13582902f, -0.04134044f, 0.02316986f, -0.01135520f, 0.01592225f, 
    -0.14993709f, 0.01583759f, -0.06119023f, -0.09182443f, -0.06083805f, -0.10551571f, -0.08388210f, -0.06658117f, 
    0.04303937f, 0.07407939f, 0.05598015f, -0.34639984f, -0.09872900f, 0.25801390f, -0.05835332f, 0.02175608f, 
    0.03609615f, 0.06910306f, 0.02331312f, -0.07029121f, -0.10751387f, -0.04144644f, 0.04239622f, 0.05366991f, 
    0.03093376f, -0.07901243f, -0.03457075f, 0.02893169f, -0.03536250f, 0.00950755f, 0.04076688f, 0.04233181f, 
    -0.10044466f, -0.15525532f, -0.39446664f, 0.03197680f, -0.04361546f, 0.00032198f, 0.01655515f, -0.00261427f, 
    -0.24001804f, -0.07963244f, -0.16599885f, 0.12190615f, 0.14644124f, -0.08001334f, -0.10894145f, -0.12314740f, 
    0.03396909f, -0.01626930f, -0.03800817f, -0.05785517f, 0.05800239f, 0.00350816f, 0.09571875f, -0.02005676f, 
    -0.33266133f, 0.16276744f, 0.15178089f, -0.19520488f, -0.01659970f, 0.01190547f, 0.04005281f, 0.02413003f, 
    -0.05559883f, -0.08810554f, 0.03663703f, -0.29592818f, -0.07787757f, -0.02892296f, -0.37379310f, -0.02911384f, 
    0.11611256f, -0.01875160f, -0.07175367f, -0.20127951f, -0.05190279f, -0.20601764f, -0.17014855f, -0.12969244f, 
    -0.38674021f, -0.08640110f, -0.06189735f, 0.05907880f, 0.03492576f, 0.03897117f, -0.00650740f, -0.02309474f, 
    -0.07605109f, -0.02679640f, -0.00788491f, 0.07941759f, -0.26679352f, -0.39602053f, 0.11252786f, -0.02265066f, 
    0.00097826f, 0.02919478f, -0.08941783f, 0.03198939f, -0.04374615f, -0.08718818f, 0.07383154f, 0.16827270f, 
    0.33763441f, -0.10484356f, -0.04244822f, 0.00254159f, -0.01107495f, 0.06808954f, 0.02570847f, 0.00106039f, 
    0.03908770f, 0.00193142f, -0.15396196f, 0.00999852f, -0.13123310f, -0.25484395f, 0.21181831f, 0.05194296f, 
    -0.13569178f, 0.05503652f, -0.10472062f, 0.02773862f, 0.02250248f, 0.09169139f, 0.09867427f, -0.08707499f, 
    0.27570349f, 0.09758331f, 0.29661745f, -0.40672106f, 0.06785425f, -0.01568443f, 0.12832439f, -0.24190113f, 
    -0.04430783f, -0.11312050f, -0.03465009f, -0.01873575f, 0.32118940f, 0.24634677f, -0.08830931f, -0.12343400f, 
    0.16133074f, 0.00553787f, -0.07974290f, 0.01179466f, 0.03611210f, 0.01998636f, 0.07330676f, 0.06992593f, 
    0.32632205f, 0.17765400f, -0.01868416f, -0.12471609f, 0.11843461f, 0.06461935f, 0.21455133f, 0.02992355f, 
    -0.00829708f, 0.02571768f, 0.01797856f, -0.04886547f, -0.16929372f, -0.52821332f, -0.33534339f, 0.08553495f, 
    -0.00062465f, -0.00671118f, -0.12267186f, -0.07227355f, -0.11134464f, -0.13136424f, -0.29817972f, -0.21718338f, 
    0.09525712f, 0.24931094f, 0.15790740f, -0.06628965f, 0.09597300f, 0.00998228f, -0.03219980f, -0.18748447f, 
    0.00786130f, -0.06533125f, -0.12711348f, -0.07213304f, 0.04065123f, 0.12023152f, -0.18243423f, -0.07732962f, 
    -0.05053457f, -0.14730760f, -0.01157975f, -0.18638270f, -0.08058053f, -0.00755669f, 0.00148078f, -0.17412965f, 
    -0.21768351f, 0.05143725f, -0.50764817f, 0.13136411f, -0.03757141f, -0.06952922f, -0.01078460f, -0.02667096f, 
    -0.02214168f, -0.06902875f, -0.03193991f, 0.05133844f, -0.05900015f, 0.12410922f, -0.03366075f, -0.30733255f, 
    -0.10291000f, -0.12703703f, -0.15744355f, -0.01970802f, -0.04718570f, -0.03596287f, 0.01160818f, -0.11010253f, 
    0.42387211f, 0.17788370f, -0.11524964f, -0.25893417f, -0.06413487f, -0.01013112f, 0.08075644f, 0.00139067f, 
    -0.11207055f, -0.05755791f, -0.20207104f, -0.00223800f, 0.38477695f, 0.05619802f, -0.14169884f, -0.17357107f, 
    -0.02406677f, -0.05588458f, 0.02202448f, 0.01578279f, -0.02334397f, -0.10188738f, -0.01437071f, 0.03257379f, 
    0.25478360f, 0.17954271f, -0.12330493f, -0.14455815f, 0.10334901f, 0.12406171f, -0.05942334f, 0.12443998f, 
    -0.02489366f, -0.00587531f, 0.01344713f, 0.00491027f, 0.24752446f, 0.09435577f, 0.11256717f, -0.10141982f, 
    0.05944223f, 0.16038923f, 0.09448361f, 0.05732594f, -0.03127680f, -0.00874291f, 0.02391601f, 0.02677847f, 
    -0.10360117f, -0.04006635f, 0.00813467f, -0.00289356f, 0.00699122f, -0.02910655f, 0.00539249f, -0.17035289f, 
    0.00333184f, 0.03182479f, 0.03091831f, 0.01246923f, 0.27138075f, -0.05084177f, -0.21703030f, 0.02134819f, 
    -0.01711941f, 0.21618785f, 0.20975463f, -0.00238249f, 0.00126819f, 0.11013746f, 0.02400227f, 0.07228895f, 
    0.15113682f, 0.16234067f, -0.04506561f, -0.00726892f, 0.18525128f, 0.05594550f, -0.10091181f, 0.06096879f, 
    -0.07586264f, -0.16543922f, -0.03870184f, 0.00373917f, -0.45053020f, 0.13381404f, -0.00685895f, 0.05174419f, 
    -0.02022069f, 0.10862481f, 0.05820365f, 0.02303111f, 0.04601043f, 0.03892059f, 0.09875437f, 0.02832221f, 
    0.27353829f, 0.11357686f, -0.20037267f, -0.09163840f, 0.05194072f, 0.07288932f, -0.09897642f, -0.04174814f, 
    -0.00133683f, 0.04188329f, 0.04053036f, 0.01807066f, -0.13645399f, 0.32130304f, 0.20896280f, -0.34056932f, 
    -0.06145187f, 0.05778286f, 0.09530552f, -0.02288622f, -0.03795711f, -0.16094352f, 0.03395344f, -0.08689317f, 
    0.09464497f, -0.29129943f, -0.41420242f, -0.02037420f, 0.05099551f, -0.01323594f, 0.02902789f, -0.01288565f, 
    -0.10730809f, -0.05217575f, -0.13854809f, 0.04408737f, 0.01716696f, -0.02336465f, -0.01071390f, -0.02602174f, 
    -0.08220463f, -0.07216815f, -0.11617655f, -0.01961794f, -0.03387392f, 0.05421951f, 0.01013450f, 0.00408516f, 
    0.08483851f, 0.14805417f, -0.01897676f, 0.04807936f, 0.00490978f, -0.17136146f, -0.04850305f, 0.00064874f, 
    -0.04144105f, -0.02115293f, 0.03840771f, -0.00088499f, 0.14818160f, 0.20187964f, -0.01872079f, -0.10839066f, 
    -0.00140126f, 0.25187358f, -0.05579257f, 0.13345534f, -0.06649227f, 0.03970463f, 0.01812562f, -0.03355011f, 
    0.03140975f, -0.10301273f, -0.14041305f, 0.06977268f, 0.10970961f, 0.07942282f, 0.01159220f, 0.00792906f, 
    0.00489380f, 0.08247821f, -0.04777285f, -0.02274443f, -0.07779129f, -0.30846763f, -0.45408279f, 0.03925253f, 
    0.00278343f, 0.01909400f, -0.02232574f, -0.01215523f, -0.20302543f, -0.07355580f, -0.24093759f, -0.12722889f, 
    0.12799007f, 0.02388541f, 0.01348663f, -0.09134327f, -0.02558358f, -0.05590034f, -0.03311563f, -0.04328268f, 
    0.00305978f, -0.15918414f, -0.03658853f, 0.00592596f, 0.00668259f, -0.01058020f, 0.03507966f, 0.01428778f, 
    0.04880681f, 0.04629448f, -0.00174747f, 0.01842148f, -0.14765064f, -0.08609074f, 0.02572046f, 0.01980670f, 
    0.04641157f, -0.00614073f, -0.08911794f, -0.26765278f, -0.08520867f, -0.06907728f, -0.00853444f, -0.19772910f, 
    -0.18986177f, -0.17256357f, 0.05282837f, 0.00802517f, 0.03909869f, 0.15103090f, -0.12114493f, -0.06890118f, 
    -0.05704218f, -0.14767286f, -0.08735098f, -0.04075968f, -0.08203002f, -0.01114006f, 0.01626588f, 0.07274175f, 
    0.22295614f, 0.06266692f, -0.13595089f, -0.05169212f, 0.09149056f, 0.12572451f, -0.09826180f, -0.12559120f, 
    -0.07436132f, -0.07730528f, -0.03928633f, -0.04212249f, -0.00742480f, -0.47441617f, -0.18041539f, -0.04539607f, 
    -0.27299255f, -0.07299972f, 0.00005949f, -0.12353884f, 0.02312834f, 0.00489794f, -0.06426905f, 0.06636392f, 
    -0.50225198f, -0.11959887f, 0.27806297f, -0.12021520f, -0.06967220f, -0.07347316f, 0.01506990f, 0.01569994f, 
    0.00739699f, 0.03757771f, -0.08083030f, -0.17548423f, -0.06780370f, -0.06601623f, -0.02753621f, 0.04092497f, 
    -0.00735975f, 0.00289392f, 0.02972014f, 0.03417076f, -0.00903847f, 0.06775334f, 0.00498024f, -0.07691728f, 
    -0.05007707f, -0.59858495f, -0.45087340f, 0.08006524f, 0.00564465f, -0.07567213f, 0.03980158f, -0.00232904f, 
    0.03160719f, 0.02121386f, 0.02568897f, 0.02069303f, 0.12089449f, 0.10660652f, -0.08658174f, 0.02405311f, 
    0.04558311f, 0.03191175f, -0.18293333f, -0.14307351f, -0.00135650f, -0.10180832f, -0.05905559f, 0.08246693f, 
    0.06733431f, 0.07300710f, 0.02698794f, -0.07709460f, -0.01032306f, 0.10523060f, -0.06578672f, 0.01792022f, 
    0.02717577f, 0.01480956f, -0.01759674f, -0.04065706f, 0.46731958f, 0.26051536f, -0.14299510f, -0.27108392f, 
    0.08530875f, 0.10460619f, 0.17418195f, 0.17210242f, -0.04886735f, -0.02240337f, 0.05377897f, -0.09754536f, 
    -0.43915230f, -0.16378707f, 0.16011266f, -0.01697763f, -0.01829253f, 0.10131391f, 0.06731195f, 0.14624824f, 
    -0.11693977f, 0.15709268f, -0.09994316f, -0.06929839f, 0.01648063f, 0.03173636f, -0.01944137f, -0.00543746f, 
    0.08151390f, 0.09704305f, 0.07147877f, -0.31075057f, -0.13721786f, -0.10735634f, 0.03956394f, -0.02660159f, 
    0.01443900f, 0.06144431f, -0.10648083f, 0.03164627f, -0.01138801f, -0.00004423f, 0.00835881f, 0.07272737f, 
    0.04218754f, 0.18143453f, 0.03771004f, 0.04556874f, 0.10489418f, 0.16202949f, 0.13907050f, -0.27841288f, 
    -0.06670050f, 0.02760945f, 0.07522284f, 0.06506735f, -0.02952853f, -0.01315847f, -0.12393431f, -0.14494438f, 
    -0.06736151f, 0.00451186f, 0.05239109f, 0.04142052f, -0.13993141f, -0.12683527f, -0.07093559f, -0.03205424f, 
    -0.06488467f, -0.05948887f, -0.03386337f, -0.09226269f, -0.12186027f, -0.04793471f, -0.03260440f, 0.00723180f, 
    0.02266190f, 0.05752698f, -0.01348789f, 0.01410350f, -0.00642705f, 0.07965390f, -0.08486111f, 0.10475062f, 
    0.18364333f, 0.01853790f, -0.07697368f, -0.07933308f, 0.04048946f, 0.15763098f, 0.01916551f, -0.08185958f, 
    -0.01496551f, 0.05965998f, 0.02623556f, 0.08414364f, 0.18037459f, 0.15487896f, 0.06189813f, 0.00648520f, 
    0.05691636f, 0.06955995f, 0.01681924f, 0.00712146f, 0.01197842f, 0.05004335f, -0.09467074f, 0.06299487f, 
    -0.12193273f, -0.02520444f, 0.14248158f, 0.02226697f, -0.27670342f, -0.14102010f, -0.06961127f, 0.06652316f, 
    -0.05175266f, -0.01282765f, 0.02267170f, -0.03466773f, -0.19227411f, -0.03316743f, -0.15755458f, -0.05869610f, 
    -0.05090311f, 0.01581273f, 0.06529625f, 0.04006337f, 0.05848739f, -0.03880123f, -0.12521906f, -0.14339882f, 
    -0.39749366f, -0.42437693f, -0.16389018f, 0.15113370f, -0.03491674f, -0.04723861f, -0.05533289f, -0.03555754f, 
    -0.05227099f, -0.04192011f, -0.10629810f, 0.02272160f, 0.09501852f, 0.29993734f, 0.25844544f, -0.34127420f, 
    -0.15340070f, 0.05788177f, 0.04572524f, 0.00754767f, -0.10275446f, -0.15556359f, -0.02000902f, 0.01357765f, 
    0.23611055f, 0.13474742f, -0.11741962f, -0.08517811f, 0.09322240f, 0.06159813f, 0.09000716f, -0.02606249f, 
    0.01185030f, 0.12766960f, 0.11112660f, 0.08611505f, -0.17186956f, -0.11577426f, 0.06855143f, 0.01860800f, 
    -0.00640000f, -0.14683260f, -0.15247162f, 0.01043424f, 0.08423768f, -0.05629871f, -0.04805012f, -0.08594656f, 
    -0.28854963f, 0.19839108f, -0.38442361f, 0.04254043f, 0.09635065f, -0.18962385f, 0.11224616f, 0.31634787f, 
    -0.00259353f, -0.00769457f, 0.02637356f, -0.12953924f, 0.17959790f, 0.01864571f, 0.18770316f, 0.01688980f, 
    -0.00788514f, 0.03245988f, -0.05077343f, 0.00157155f, 0.05067319f, 0.02980126f, 0.06232481f, -0.14270192f, 
    0.19353355f, -0.12807144f, 0.09215769f, -0.19712956f, 0.02049848f, 0.02612417f, -0.08899615f, 0.03321612f, 
    -0.28620759f, -0.27086720f, -0.36137816f, 0.11253557f, -0.09953337f, 0.10042666f, 0.02365944f, -0.00512906f, 
    0.09452108f, 0.08359359f, 0.00250864f, 0.01633897f, -0.07266881f, -0.00915825f, -0.03275017f, -0.11878812f, 
    0.04785196f, 0.14733802f, -0.06886771f, -0.45766133f, -0.02761120f, 0.06457090f, -0.05950236f, 0.09483103f, 
    -0.01477590f, 0.00956598f, -0.05940642f, -0.11530462f, 0.01432100f, 0.13602816f, -0.12959492f, -0.02767609f, 
    0.02217990f, 0.00782150f, -0.02132288f, 0.04550951f, 0.00854461f, 0.00767691f, -0.05263367f, 0.05163280f, 
    0.08800319f, -0.14339472f, 0.10351986f, -0.00459983f, 0.02935347f, -0.07033769f, -0.01801728f, 0.03659281f, 
    -0.15572211f, -0.13157794f, 0.02915865f, -0.11094867f, 0.01285549f, -0.12487005f, -0.18438230f, -0.19425802f, 
    -0.03470043f, 0.12656200f, -0.07468525f, -0.13361052f, -0.02007566f, 0.07130133f, -0.05324997f, -0.08305505f, 
    -0.21150067f, 0.10760423f, -0.07759439f, 0.36604780f, 0.02536359f, 0.05454643f, -0.00020135f, -0.00999714f, 
    0.08448267f, 0.08923700f, -0.15136500f, 0.11097737f, 0.23214424f, -0.00314649f, -0.08609689f, -0.07405250f, 
    0.00817665f, 0.18065991f, 0.08139263f, 0.09225474f, 0.03490893f, 0.03459498f, 0.16095038f, -0.03384187f, 
    0.00622343f, 0.10310686f, 0.18501346f, 0.12475427f, 0.03790577f, -0.01348872f, 0.01331241f, -0.00021486f, 
    0.01769990f, 0.11039080f, -0.11152076f, -0.13187799f, 0.07678708f, -0.01296889f, 0.11518690f, -0.05322318f, 
    -0.03268927f, -0.00061006f, 0.00446435f, -0.03778299f, -0.18186560f, -0.15146141f, -0.36210811f, -0.00259587f, 
    -0.09021871f, -0.18147124f, -0.13525882f, -0.07570933f, -0.04979302f, -0.01997446f, 0.01025027f, 0.01508574f, 
    -0.10049529f, -0.18750431f, -0.18401980f, -0.13183548f, 0.09918230f, -0.15176930f, 0.02328405f, 0.03033887f, 
    0.08978855f, -0.11864493f, 0.02111295f, -0.24406704f, 0.15172781f, -0.16047239f, -0.07188212f, -0.11770979f, 
    -0.56503749f, 0.04928494f, -0.52696878f, -0.12516589f, -0.15595189f, 0.03694046f, 0.07836368f, -0.00987103f, 
    0.06890389f, 0.08080710f, -0.07365978f, 0.07164648f, 0.06122898f, 0.06122923f, 0.08454104f, 0.20920205f, 
    -0.16167308f, 0.06403786f, -0.03910814f, -0.19227529f, 0.01492709f, -0.08260033f, 0.00626321f, 0.01572591f, 
    -0.01982315f, 0.04918505f, -0.15494201f, -0.09240233f, -0.14208439f, -0.10040328f, -0.04975583f, -0.09361705f, 
    0.08006070f, -0.05231742f, -0.04542827f, 0.02615772f, 0.46609730f, -0.08245384f, 0.06641533f, -0.07265733f, 
    -0.00623234f, -0.03118027f, 0.14243425f, -0.02581437f, 0.16353251f, 0.25979096f, -0.00384509f, 0.05863853f, 
    -0.09652035f, 0.06130108f, -0.15898702f, 0.01201529f, 0.01040422f, -0.05843499f, 0.15210503f, 0.20156147f, 
    -0.09938429f, -0.02580090f, 0.02271269f, -0.06413873f, 0.17556393f, -0.21716036f, 0.03639359f, 0.06390034f, 
    0.13580228f, 0.02507918f, 0.00812920f, 0.13764532f, -0.04607397f, 0.00644530f, -0.03563388f, -0.04205253f, 
    0.32967645f, 0.04288545f, 0.05702924f, 0.29017889f, -0.05163159f, 0.01659965f, -0.02422014f, -0.08762628f, 
    0.02315486f, -0.03481417f, 0.02172384f, 0.03467689f, -0.02550111f, 0.01912270f, -0.15711501f, 0.07402917f, 
    0.03641284f, -0.03923358f, 0.07350165f, 0.11046757f, -0.13191475f, -0.01088393f, 0.04337743f, 0.02695167f, 
    -0.34116432f, -0.35297546f, -0.08593077f, -0.00471092f, -0.13246372f, 0.11649909f, 0.24617806f, 0.09763599f, 
    -0.02080377f, -0.03455234f, 0.17488958f, 0.03934925f, 0.18083891f, 0.06927143f, -0.18774264f, 0.28682959f, 
    -0.06346565f, -0.03386831f, -0.00360487f, 0.02557747f, 0.02823174f, -0.01364748f, 0.00851526f, -0.00390491f, 
    0.16721129f, 0.26283789f, 0.15875921f, 0.07270117f, -0.06283223f, 0.01248684f, -0.04051293f, 0.06526043f, 
    -0.02239083f, -0.02105411f, -0.05560347f, -0.02044727f, -0.04408274f, 0.30865750f, 0.11073736f, 0.15666038f, 
    -0.15978864f, -0.15581290f, 0.00434010f, -0.00642571f, -0.02895757f, -0.10448124f, -0.01060653f, -0.14640075f, 
    0.09788426f, 0.08365112f, 0.01465507f, -0.07630061f, -0.02254140f, -0.08535962f, -0.10602950f, 0.09193800f, 
    -0.02998685f, -0.06202151f, 0.03793451f, -0.00374342f, 0.04662704f, 0.12300897f, 0.01049637f, 0.21960545f, 
    0.07275175f, -0.10757580f, -0.06127634f, -0.26619953f, -0.02740567f, -0.00865595f, -0.04011002f, -0.10445043f, 
    0.23495339f, 0.03744172f, 0.09279912f, -0.02744235f, -0.01779633f, 0.03774265f, -0.10095977f, -0.11664861f, 
    -0.01145335f, -0.00933177f, 0.00732616f, 0.06474941f, -0.50871879f, -0.23451659f, -0.10206424f, 0.10405330f, 
    0.03856907f, 0.00212876f, -0.08655728f, -0.02755424f, -0.11015704f, 0.04017322f, -0.15412253f, -0.21731600f, 
    -0.09696504f, -0.16321270f, 0.04242280f, -0.11402936f, 0.09640576f, 0.11693507f, -0.00619852f, -0.00991503f, 
    0.13169618f, 0.15314178f, 0.00125711f, 0.03118055f, -0.55102080f, 0.26886496f, -0.17309673f, -0.10692097f, 
    -0.14918986f, 0.15885760f, -0.08570748f, -0.01819460f, 0.05559332f, 0.04696590f, -0.11559986f, 0.06434190f, 
    0.93644720f, -0.41503495f, -0.09831623f, -0.00800217f, -0.09461807f, -0.14135271f, -0.05446405f, 0.00658637f, 
    -0.01717626f, -0.00457784f, 0.10947058f, 0.28890565f, -0.03006013f, 0.07919319f, -0.07751907f, -0.14271298f, 
    -0.02502858f, -0.03172841f, 0.08126771f, 0.05585715f, 0.01270726f, 0.01962597f, -0.04081170f, 0.01049548f, 
    -0.05475895f, 0.00448391f, -0.04226972f, 0.00125873f, 0.13168164f, -0.01253014f, -0.12205926f, -0.01011052f, 
    -0.04213864f, -0.01091173f, -0.00061845f, 0.01418642f, 0.29453120f, 0.23632054f, 0.14417443f, -0.09156885f, 
    0.02117787f, 0.01410184f, -0.16193855f, 0.10501853f, -0.03241985f, 0.13204959f, -0.13680598f, 0.06004295f, 
    0.12764217f, -0.14657849f, -0.30922017f, -0.14031121f, -0.04906203f, 0.02266150f, -0.04035282f, -0.09198418f, 
    0.10588156f, 0.05719626f, 0.06147690f, -0.02258754f, 0.23866668f, 0.05571168f, -0.00941065f, 0.12053923f, 
    -0.05412721f, 0.01880500f, 0.00432094f, 0.10176218f, 0.03919668f, 0.22113402f, -0.19438244f, -0.13688338f, 
    -0.12614132f, 0.01618826f, 0.00234554f, -0.23598424f, -0.07186813f, -0.01876362f, 0.09129994f, -0.04607862f, 
    -0.07830977f, 0.10438794f, -0.01035717f, -0.14187600f, 0.08610674f, 0.03584369f, 0.14392065f, 0.06123332f, 
    -0.01016443f, -0.01216439f, -0.02873742f, -0.00178716f, 0.12028544f, -0.00183946f, 0.03742152f, 0.03715521f, 
    -0.29253694f, -0.17672954f, 0.15911712f, -0.04543926f, 0.12012695f, 0.12451909f, -0.04951556f, -0.02811244f, 
    0.27011567f, -0.05324475f, 0.04533789f, 0.15914930f, 0.10975502f, -0.11725333f, -0.45454398f, -0.43390575f, 
    0.03532512f, -0.03861386f, -0.14839046f, -0.01212882f, -0.02317088f, 0.00388753f, 0.00655778f, 0.08653107f, 
    -0.13997167f, 0.20265897f, -0.01922326f, -0.10096037f, 0.08867700f, 0.12285594f, 0.05278619f, 0.25814292f, 
    -0.02096603f, 0.06180636f, -0.23667343f, 0.00129931f, 0.20161444f, -0.15961896f, 0.14879353f, -0.22164071f, 
    0.09892003f, -0.05284107f, 0.05929826f, -0.19132207f, -0.03192805f, 0.02151773f, -0.00746684f, 0.04707093f, 
    -0.02306269f, 0.30322126f, 0.10186599f, 0.06716262f, 0.02314776f, -0.03696563f, -0.02771816f, 0.04359314f, 
    -0.07751104f, 0.13942666f, 0.03690912f, 0.09316914f, 0.15726984f, 0.08859337f, 0.13303581f, 0.07232167f, 
    0.02450980f, -0.02462596f, -0.03934225f, -0.00903493f, -0.05665787f, 0.10252843f, -0.12008032f, 0.14732298f, 
    0.37209794f, 0.20774324f, 0.00854603f, 0.04153026f, -0.01649147f, -0.09164280f, -0.08090088f, -0.18484053f, 
    -0.02927843f, -0.02389601f, 0.00665896f, 0.05463182f, 0.13507590f, -0.17311358f, 0.05183238f, -0.23430909f, 
    0.04495265f, 0.03276826f, -0.11980046f, 0.01300996f, 0.11116366f, -0.05552616f, 0.14997013f, -0.06824020f, 
    -0.12138119f, 0.09921230f, -0.21133240f, -0.17324097f, -0.04774103f, 0.00250933f, -0.00856445f, 0.16480692f, 
    -0.05990047f, 0.06091554f, 0.02488982f, -0.07106140f, 0.65294546f, 0.19858558f, 0.14381938f, 0.13860816f, 
    0.05245719f, 0.12211490f, -0.01030411f, -0.17476578f, 0.04315402f, -0.01435463f, -0.05256827f, -0.00966791f, 
    0.01659240f, -0.01063968f, -0.04425431f, -0.15489367f, 0.00957661f, -0.01628055f, -0.08867445f, -0.07508042f, 
    -0.02268962f, -0.13608377f, -0.03779691f, 0.06561322f, -0.17036928f, -0.03281642f, -0.22908695f, -0.10849227f, 
    -0.05658707f, 0.06853024f, 0.03208265f, 0.06188450f, -0.11077425f, 0.07193194f, -0.01444265f, -0.04451704f, 
    -0.09257331f, -0.15878612f, -0.07789913f, -0.03921207f, -0.00132689f, 0.01590915f, 0.03353213f, 0.05034522f, 
    0.08557681f, -0.18964240f, -0.15095004f, -0.07918648f, -0.36385411f, 0.01673358f, -0.14324498f, -0.06962434f, 
    0.07129122f, 0.02396790f, 0.26731503f, 0.05108573f, -0.01481174f, -0.00074425f, -0.04766577f, 0.05521525f, 
    -0.04758815f, 0.00229598f, 0.03752861f, 0.01342469f, 0.04162104f, 0.04648202f, -0.03880817f, 0.01749254f, 
    -0.06527176f, 0.01793453f, 0.01701334f, 0.02817898f, 0.30203819f, -0.08602044f, -0.00089401f, -0.04321227f, 
    -0.04122655f, -0.06726285f, -0.01092306f, -0.09364556f, 0.19990824f, 0.00473959f, 0.00354973f, 0.02267363f, 
    -0.07528696f, 0.19184969f, 0.19987948f, 0.16547287f, -0.13288976f, -0.00586354f, 0.04349840f, 0.03766757f, 
    -0.05768118f, -0.04064646f, 0.05535648f, -0.11666519f, -0.02101517f, -0.01842113f, -0.18610871f, -0.03407768f, 
    -0.03371136f, -0.01391504f, 0.05256671f, 0.04872667f, -0.15682192f, -0.03833167f, 0.13747191f, -0.03616484f, 
    0.00125559f, -0.01603523f, 0.04221001f, -0.16149320f, 0.15634567f, 0.14729840f, 0.00949052f, -0.05173856f, 
    -0.01493291f, -0.07910573f, 0.01051432f, 0.01220659f, 0.31102443f, -0.07589193f, 0.14956430f, 0.21551196f, 
    -0.12677781f, 0.02604845f, 0.07760802f, -0.07203653f, 0.13387626f, -0.00997119f, -0.07373791f, -0.02746598f, 
    0.24544910f, 0.17915818f, 0.21743730f, 0.23156056f, 0.00620340f, 0.02114340f, -0.04300950f, 0.03426376f, 
    -0.05637254f, 0.19243415f, -0.07597560f, 0.02832950f, -0.82049376f, -0.15505964f, -0.34100869f, 0.14011702f, 
    -0.06675262f, 0.02228764f, -0.04894365f, 0.01079680f, 0.03451656f, -0.00138993f, -0.06688377f, 0.12952879f, 
    0.00026558f, 0.03475143f, -0.06681893f, 0.09381406f, 0.03162021f, 0.05795686f, -0.18035348f, -0.29042652f, 
    0.17697465f, -0.04169311f, -0.25862294f, -0.06326727f, 0.03000524f, 0.08647013f, -0.03352955f, -0.07071054f, 
    -0.04603916f, 0.00165734f, -0.07844092f, -0.00554645f, -0.16928308f, -0.07371860f, 0.10449623f, 0.02529570f, 
    -0.06235047f, 0.16265950f, -0.12640151f, -0.02084781f, 0.06048802f, -0.00773797f, 0.03151302f, 0.03988528f, 
    0.04022127f, -0.03341416f, 0.02368621f, 0.03604214f, -0.22503500f, 0.03160308f, 0.04577763f, -0.12312073f, 
    0.01929284f, -0.03380734f, -0.05168818f, 0.02561554f, 0.04647920f, -0.13392593f, -0.03822774f, 0.08927584f, 
    -0.06083602f, 0.04348700f, 0.00399629f, -0.02608477f, -0.05279823f, 0.00201708f, -0.01774714f, -0.18217014f, 
    0.06626207f, 0.02663884f, 0.06789899f, 0.08011770f, -0.10125238f, -0.04404027f, -0.03271763f, 0.11213248f, 
    0.06788094f, 0.13662514f, -0.03404722f, -0.07346945f, -0.01864876f, -0.06641226f, -0.01249693f, 0.03765196f, 
    0.06085164f, 0.15510887f, 0.06485153f, 0.08928467f, 0.07893832f, -0.05396996f, 0.06065048f, 0.02423560f, 
    0.03697836f, 0.06717572f, -0.05564157f, 0.07754704f, -0.25532627f, 0.06243669f, 0.05463395f, -0.18321271f, 
    -0.01063974f, -0.03348974f, 0.02050992f, 0.06398545f, 0.02018816f, -0.05631647f, -0.00217076f, 0.03155363f, 
    0.10628521f, -0.02958720f, 0.02625795f, -0.17085747f, 0.07359780f, -0.06472076f, -0.08770340f, 0.08891518f, 
    0.09793020f, 0.13683367f, 0.08279316f, -0.08917910f, -0.06541338f, 0.39326730f, -0.15637632f, 0.27717879f, 
    0.01505525f, 0.11286914f, -0.03418094f, -0.01326442f, 0.05621983f, 0.05726603f, 0.02498502f, 0.00622444f, 
    -0.05142687f, -0.13432764f, -0.25312835f, 0.20908557f, 0.06911442f, 0.00736697f, -0.00987473f, 0.03167918f, 
    -0.06409094f, -0.03660976f, -0.00173404f, -0.08841880f, -0.23652351f, 0.26881453f, 0.17329544f, -0.30606413f, 
    -0.06672497f, 0.16219757f, 0.00651694f, -0.03421887f, -0.05557315f, -0.11175579f, 0.06524217f, -0.10661797f, 
    0.03396690f, -0.16862758f, 0.03319558f, 0.01385344f, -0.02348757f, -0.00124761f, -0.03061766f, -0.01167988f, 
    -0.01707671f, -0.13644367f, 0.01134646f, 0.22716656f, -0.04790268f, -0.00898124f, -0.08686574f, -0.08435473f, 
    -0.00282967f, -0.06973050f, -0.01018651f, -0.06580589f, 0.07953364f, 0.08420280f, 0.11654890f, 0.04634161f, 
    -0.10119644f, 0.01246403f, 0.09901115f, -0.02055878f, -0.01625917f, -0.05277725f, 0.05817995f, 0.05650161f, 
    0.04655606f, 0.03003196f, 0.00752649f, -0.03998091f, -0.11935674f, -0.01142886f, -0.03702568f, 0.01285884f, 
    -0.04277271f, -0.01792664f, 0.01972499f, -0.08398256f, 0.04823741f, -0.05655222f, 0.08215900f, -0.09128855f, 
    0.10781193f, 0.19021465f, -0.82597488f, 0.29177472f, -0.22822674f, 0.06584126f, 0.09691361f, -0.01454322f, 
    -0.07093906f, 0.03931017f, -0.01782978f, -0.04058689f, -0.37788776f, -0.12931547f, -0.59291506f, -0.14930356f, 
    -0.13013020f, -0.02606470f, 0.17260650f, -0.12429830f, -0.02632756f, 0.02330017f, 0.01498946f, -0.02163517f, 
    -0.50257355f, -0.39995921f, -0.25207821f, -0.15804790f, -0.01058382f, -0.04574550f, -0.01879750f, 0.12366633f, 
    0.03701328f, 0.03480373f, -0.00388218f, 0.03687834f, -0.16906093f, 0.20700385f, 0.11711326f, -0.16135634f, 
    0.02720112f, -0.01590117f, -0.04113633f, 0.04958757f, 0.01936331f, -0.00850949f, -0.11119983f, 0.13464820f, 
    -0.08829830f, -0.10160815f, 0.01951686f, 0.12032479f, -0.04588485f, -0.16485685f, -0.08227864f, 0.05911524f, 
    0.01139183f, -0.17627183f, 0.00741115f, -0.06474815f, 0.03303932f, -0.14881368f, 0.00546927f, 0.17440899f, 
    0.13579842f, 0.07284625f, -0.14949042f, 0.05420752f, 0.04515681f, -0.06550314f, -0.19415537f, 0.12074321f, 
    -0.10376850f, 0.03158468f, -0.02469783f, -0.10167395f, -0.00932383f, 0.00890343f, 0.01182943f, 0.05017562f, 
    -0.01209702f, -0.01933188f, 0.07754942f, -0.10532506f, -0.08969505f, 0.05861603f, -0.05617681f, -0.20836480f, 
    0.07060884f, -0.09853627f, -0.12492329f, 0.08910908f, 0.01114997f, 0.02864215f, -0.07362207f, 0.04759013f, 
    0.18638591f, -0.08653413f, 0.16440018f, -0.12064861f, 0.10013577f, -0.06912196f, -0.09759506f, 0.16156539f, 
    0.04151547f, -0.07913180f, 0.15060997f, -0.07861734f, -0.07552993f, 0.28039810f, -0.28931582f, -0.06624291f, 
    0.06823970f, -0.03777630f, -0.02573302f, 0.12319601f, -0.05402902f, -0.05374935f, 0.10914669f, -0.13691790f, 
    -0.59357756f, -0.31724164f, -0.15214452f, -0.22457559f, -0.12692559f, 0.10696615f, -0.03693614f, 0.01503997f, 
    -0.02197186f, -0.01328898f, -0.04212053f, -0.05517768f, -0.24916068f, -0.09427699f, 0.03190263f, 0.25962365f, 
    -0.09507316f, -0.21984608f, 0.15922932f, -0.12386958f, 0.02775781f, 0.01094749f, 0.06257150f, -0.00404730f, 
    -0.13947119f, -0.02222609f, 0.08985008f, -0.28338185f, 0.05025642f, -0.00413102f, -0.20300464f, 0.04850154f, 
    0.02475751f, -0.06995126f, 0.00687397f, 0.05553228f, -0.21666075f, 0.01646266f, 0.48602283f, 0.01627161f, 
    0.12989525f, -0.11447845f, 0.18022144f, 0.01131065f, 0.09293567f, -0.03724160f, 0.02562037f, 0.02272139f, 
    -0.07293680f, 0.08149492f, 0.10673141f, -0.14707211f, 0.05969925f, -0.01215673f, 0.09124832f, -0.00485155f, 
    -0.02086560f, -0.01847495f, 0.03753391f, -0.03873467f, 0.17335963f, 0.04058501f, 0.02107241f, 0.24969940f, 
    -0.02928850f, 0.01341270f, 0.05127314f, -0.09338754f, -0.01439033f, 0.08926125f, -0.09300973f, 0.11441038f, 
    -0.05549316f, 0.04172034f, 0.16674256f, -0.11544263f, -0.11259887f, -0.08378635f, 0.09198073f, -0.20926604f, 
    0.02943327f, 0.13301747f, -0.04544965f, 0.03447830f, -0.02391767f, -0.20620279f, -0.27832365f, 0.13185203f, 
    0.05908168f, 0.04761467f, -0.03006686f, 0.06021519f, -0.08280766f, 0.07730357f, -0.09701589f, 0.14782715f, 
    -0.40858194f, 0.20822215f, 0.03210387f, -0.30962735f, 0.07621415f, -0.02463875f, -0.05352693f, -0.02882258f, 
    0.00226151f, 0.02554975f, 0.14216225f, -0.05168373f, -0.20795591f, -0.02801140f, -0.01547758f, -0.01051073f, 
    -0.15173265f, -0.20394707f, -0.01521103f, -0.14767724f, 0.01104686f, -0.04911254f, 0.04415449f, 0.01404914f, 
    -0.17856307f, -0.03810109f, 0.15264860f, 0.04616267f, -0.08107159f, 0.03081908f, -0.12585361f, 0.17382489f, 
    0.00934728f, -0.02114665f, -0.00556161f, -0.00862667f, -0.17108710f, 0.27397010f, 0.36082774f, 0.03329787f, 
    -0.00439840f, -0.07304572f, -0.02226493f, -0.12755215f, 0.01755420f, -0.06028957f, -0.25015530f, -0.00548625f, 
    -0.02618044f, 0.19152543f, 0.29700530f, 0.19480246f, -0.07936196f, -0.04477620f, 0.02466171f, -0.00726467f, 
    -0.04937634f, -0.07314672f, -0.05499420f, 0.00314890f, -0.01314241f, -0.00290907f, -0.02276606f, -0.03052989f, 
    0.01838532f, 0.05489894f, 0.06398909f, -0.00279328f, -0.01546966f, 0.05526999f, -0.26015878f, -0.02019351f, 
    -0.03736534f, 0.06672474f, 0.02802183f, 0.14644966f, -0.05112576f, 0.01199969f, 0.04029239f, -0.22448470f, 
    0.12802450f, 0.17227353f, -0.12328997f, 0.05759837f, -0.06219965f, -0.05624499f, -0.08578278f, 0.01830937f, 
    -0.05429869f, -0.00012056f, 0.00846246f, 0.06643419f, -0.09276803f, -0.04817692f, 0.10278807f, 0.07339451f, 
    -0.16793436f, 0.18296687f, 0.02927242f, 0.09516614f, 0.09351687f, 0.05899979f, -0.02611287f, -0.12711665f, 
    0.11815280f, 0.09706745f, -0.07263289f, 0.19205007f, -0.48315528f, -0.10199621f, 0.14546977f, -0.24557444f, 
    -0.04383582f, 0.02304577f, -0.19713122f, -0.08072116f, 0.00458943f, -0.02494629f, 0.00998178f, -0.01054085f, 
    -0.22398689f, 0.19019111f, 0.14693077f, -0.27865306f, -0.09398410f, 0.04508638f, -0.09652099f, 0.04866419f, 
    -0.03680184f, 0.02539259f, -0.07927622f, -0.02847474f, -0.25405630f, -0.11377224f, 0.29513764f, -0.22544320f, 
    0.01110019f, -0.16556635f, -0.31244761f, -0.02564958f, 0.05474149f, -0.05994819f, -0.01987036f, 0.02396189f, 
    -0.09802342f, 0.01490439f, -0.25888640f, 0.13529047f, 0.02151115f, 0.00980997f, 0.02982242f, -0.01146854f, 
    -0.02463007f, -0.00912163f, -0.02941796f, 0.02216313f, -0.15232433f, -0.09746420f, -0.11102837f, 0.03546027f, 
    -0.05452089f, -0.02320899f, 0.01131313f, 0.05001248f, -0.03308733f, -0.10853271f, 0.07954523f, 0.00098410f, 
    -0.16901185f, -0.00297370f, -0.11370561f, -0.13693802f, -0.01792593f, -0.07055963f, -0.01091934f, 0.16856496f, 
    -0.01722353f, -0.03290259f, -0.03261864f, -0.04397469f, -0.17168368f, 0.31954983f, 0.36563340f, -0.19259690f, 
    -0.04293487f, 0.03050332f, 0.01929595f, -0.19891712f, -0.02666989f, 0.03068844f, 0.00433156f, 0.05912744f, 
    0.02031380f, 0.20104365f, 0.16696939f, 0.12578423f, 0.03500185f, 0.01888023f, 0.03985671f, 0.09414990f, 
    0.01078376f, 0.05586384f, 0.06744470f, -0.04041140f, -0.14180276f, -0.59322518f, 0.47109985f, 0.47581086f, 
    -0.03722744f, -0.13596836f, -0.22067161f, 0.08348044f, 0.02248652f, 0.02188068f, -0.04682274f, 0.04129824f, 
    0.40509203f, 0.30668858f, -0.04040090f, 0.18352503f, 0.01955291f, 0.00423994f, 0.05542516f, -0.03026989f, 
    -0.00865606f, -0.03193101f, -0.00933290f, 0.16047588f, -0.01066680f, 0.24476641f, 0.13535601f, -0.05515495f, 
    -0.07117483f, 0.09960229f, -0.01832148f, -0.10686243f, -0.04635386f, -0.17123927f, -0.08920961f, 0.06062790f, 
    0.03061511f, -0.03590534f, -0.03283408f, 0.05704537f, -0.00661095f, -0.07769277f, 0.03465425f, -0.01418954f, 
    0.00499656f, 0.03460383f, 0.06089130f, 0.11313666f, -0.33893391f, -0.17644978f, -0.44978112f, -0.14364088f, 
    0.07622402f, -0.00775422f, -0.02029790f, -0.14544092f, -0.00968207f, -0.06025675f, 0.02094099f, 0.03564004f, 
    -0.05776796f, -0.04511528f, -0.05790826f, -0.02013270f, -0.01533551f, 0.00526059f, -0.03103191f, 0.08244842f, 
    -0.06466907f, 0.00510542f, -0.00082904f, -0.06790455f, -0.17701320f, 0.19829841f, 0.00819365f, -0.07606461f, 
    -0.13188086f, -0.03463815f, -0.02111436f, -0.30340511f, 0.06680372f, 0.01214670f, 0.10344145f, -0.02701977f, 
    -0.18097024f, 0.07887404f, 0.43335152f, 0.32470804f, 0.04215273f, -0.00359424f, 0.09977829f, 0.00660486f, 
    0.06085585f, -0.06177471f, -0.02356478f, -0.01907582f, 0.14298677f, 0.05923365f, 0.21684515f, 0.17493986f, 
    0.00026733f, -0.03018185f, 0.04668026f, 0.01051921f, -0.09701671f, -0.12147336f, 0.14632657f, 0.00356762f, 
    0.08326432f, 0.07878104f, -0.03128684f, -0.13230008f, -0.01569104f, 0.04731971f, -0.05500992f, 0.09522982f, 
    -0.07389385f, -0.01560392f, 0.03213222f, -0.04109816f, -0.00920246f, 0.06144659f, -0.04907895f, -0.17418128f, 
    -0.00840770f, 0.00368474f, 0.00479008f, 0.03252711f, -0.05681344f, -0.00081993f, -0.07848151f, -0.13950118f, 
    0.02314747f, -0.04634278f, 0.08785165f, 0.09617624f, 0.01155660f, 0.06513673f, 0.09305201f, -0.02123610f, 
    0.05659240f, 0.04357741f, 0.03912304f, 0.08147062f, 0.07765748f, -0.07626191f, -0.74464041f, 0.14977694f, 
    0.04878317f, 0.04846043f, -0.09290316f, 0.07924274f, 0.02266882f, -0.04872690f, -0.13448150f, 0.08019381f, 
    -0.06155760f, -0.16919740f, 0.14767201f, 0.07445199f, -0.04008124f, -0.00975312f, -0.04199575f, 0.08001274f, 
    0.08902861f, -0.01166961f, -0.02418760f, 0.00005424f, 0.17749850f, -0.00812659f, -0.00042029f, 0.09772319f, 
    -0.04048694f, -0.03815806f, 0.03469589f, 0.06812448f, 0.12877484f, -0.00104651f, 0.15464050f, -0.05488408f, 
    0.00170642f, -0.09897128f, -0.05033020f, -0.06511995f, 0.00532652f, -0.03776439f, 0.04983334f, 0.03077048f, 
    -0.10330445f, -0.02529726f, -0.19370830f, -0.01891008f, -0.50145942f, -0.26452038f, -0.44369766f, 0.17717564f, 
    -0.04610001f, -0.25182351f, -0.09207779f, -0.04308043f, -0.07356150f, 0.02555925f, -0.13570635f, -0.01019040f, 
    -0.04174924f, -0.11624452f, 0.17967457f, 0.12509689f, -0.05002686f, 0.00775011f, -0.12459562f, 0.03410009f, 
    0.09674014f, 0.07831784f, -0.05233450f, 0.11618434f, 0.11411066f, 0.02848526f, 0.06377379f, -0.10505743f, 
    -0.22221482f, -0.16352180f, 0.03003880f, -0.19684087f, 0.10929826f, 0.01201448f, 0.15045631f, 0.03258757f, 
    0.15970677f, 0.01439556f, 0.21959688f, 0.10995927f, 0.01367406f, -0.00817925f, -0.05061663f, 0.09252068f, 
    -0.08730809f, -0.00295160f, -0.03374374f, 0.11092932f, 0.02630353f, 0.08671355f, 0.20985788f, 0.11914458f, 
    -0.20571975f, 0.01575439f, 0.04362110f, 0.15132852f, 0.01375137f, 0.11978328f, 0.08507717f, 0.14215544f, 
    -0.07468240f, 0.03538004f, 0.00132746f, 0.09758987f, 0.01696741f, 0.12765786f, -0.16732472f, -0.03185430f, 
    -0.07282611f, 0.01836787f, -0.00331178f, 0.08925323f, -0.00214670f, -0.11061288f, -0.03481212f, 0.22227994f, 
    0.03575298f, -0.03494535f, -0.08286368f, 0.03687420f, 0.00186831f, 0.05182859f, -0.02110728f, 0.03972496f, 
    0.14076661f, -0.08925385f, 0.06746450f, -0.35396847f, 0.10326798f, -0.08408022f, -0.18143742f, 0.03934428f, 
    -0.20858139f, 0.19758743f, -0.07556960f, -0.06852420f, -0.11078808f, -0.01823311f, 0.05695093f, 0.29862624f, 
    0.11357591f, -0.09714201f, -0.04670253f, -0.13307907f, -0.09173589f, 0.09316017f, 0.06054067f, 0.01519017f, 
    -0.51945233f, 0.00155595f, -0.03292979f, -0.22067438f, -0.08381883f, -0.05111498f, -0.18093960f, 0.10458467f, 
    -0.03878581f, 0.12617432f, -0.00150965f, 0.06644824f, 0.11546272f, -0.06496023f, 0.15316147f, -0.08618097f, 
    -0.11470287f, 0.02383072f, -0.07156788f, 0.04468790f, 0.07045005f, 0.12569636f, 0.10740990f, -0.13649786f, 
    0.00732025f, 0.05772474f, -0.08898605f, -0.17665090f, 0.11922638f, 0.14845265f, -0.02730776f, -0.02337935f, 
    -0.22226927f, -0.04625378f, -0.02865756f, 0.05169626f, 0.25356337f, 0.05757774f, -0.09867907f, 0.22667837f, 
    -0.03263647f, -0.00922792f, -0.04572623f, 0.11567649f, -0.06929734f, 0.04168886f, -0.05744447f, -0.00469974f, 
    -0.28380412f, 0.46937671f, -0.42222235f, -0.10176855f, -0.01318730f, -0.14242315f, -0.03541828f, 0.04117114f, 
    -0.04963152f, -0.11844002f, -0.11508228f, 0.05104330f, -0.07724395f, -0.11620130f, -0.12883942f, 0.15820897f, 
    0.06055804f, -0.00831245f, 0.10977002f, -0.13473678f, -0.03075962f, -0.11676208f, 0.03439998f, -0.06069477f, 
    -0.00832368f, 0.05141155f, -0.17745411f, 0.07198718f, -0.00859356f, 0.01377163f, -0.01723614f, 0.04969471f, 
    0.03739620f, -0.07888877f, -0.01203278f, 0.06176668f, -0.34765536f, 0.05333357f, -0.00590232f, 0.32916731f, 
    -0.08742871f, -0.19264989f, -0.01016629f, -0.08273698f, 0.01541481f, -0.09009023f, 0.13325106f, -0.05242616f, 
    -0.07623246f, -0.05028936f, -0.05222270f, -0.15598066f, 0.19465154f, 0.22577925f, -0.13705678f, -0.02004185f, 
    0.07828624f, 0.03567296f, -0.07651953f, 0.03007424f, -0.28778836f, -0.12173039f, -0.31481922f, 0.05905164f, 
    0.14597046f, -0.07725406f, -0.04862370f, -0.08740243f, -0.15495561f, -0.21271975f, -0.06755701f, 0.12838745f, 
    -0.05570630f, 0.15405530f, 0.02970207f, 0.35037628f, 0.04542709f, -0.08766293f, 0.00940213f, -0.09182610f, 
    -0.11814547f, -0.07691009f, -0.09585337f, -0.08787813f, -0.09437465f, -0.17932606f, -0.14328222f, -0.10105343f, 
    0.01540663f, -0.10837363f, -0.05103322f, 0.08566358f, 0.00317037f, 0.09153029f, -0.04018492f, 0.03778881f, 
    -0.30611485f, 0.32576045f, -0.14688277f, -0.27905026f, 0.02304550f, 0.10790548f, -0.18221252f, -0.03941805f, 
    -0.16633780f, -0.03938976f, -0.02400063f, 0.00034668f, -0.85654598f, 0.71013528f, -0.20320314f, -0.12322138f, 
    -0.00042310f, -0.06277568f, -0.03432105f, -0.19807282f, -0.17161727f, -0.03676046f, 0.05721650f, 0.02181522f, 
    0.04034823f, -0.06146519f, -0.00920771f, 0.18639669f, -0.03105765f, -0.03837178f, -0.01123150f, 0.05420240f, 
    -0.01084102f, -0.05719304f, -0.05879060f, -0.01658466f, 0.20159051f, -0.08699699f, -0.07651382f, 0.07550353f, 
    0.04925847f, 0.00432544f, -0.12474075f, 0.17320870f, 0.03646323f, 0.00025964f, 0.14223844f, 0.07796379f, 
    -0.29566956f, 0.00580110f, 0.32571277f, -0.03324731f, -0.15372889f, 0.09688018f, -0.03680927f, 0.01343675f, 
    0.10623271f, -0.03495900f, -0.00339952f, 0.11293176f, 0.07818471f, -0.02364986f, -0.19809507f, 0.18663739f, 
    0.09639238f, -0.01507107f, -0.14326702f, -0.06444194f, -0.01470500f, 0.02496856f, 0.00315929f, 0.04471437f, 
    -0.11742893f, -0.08388272f, 0.01927140f, 0.15300198f, 0.03329951f, -0.02054724f, 0.07496496f, -0.08328342f, 
    0.03611448f, 0.08206009f, 0.03664412f, 0.00002112f, 0.69333202f, -0.20769069f, -0.22243209f, 0.05895784f, 
    0.13603775f, -0.07195283f, 0.00367666f, -0.14503635f, -0.14505233f, 0.00508026f, 0.06171841f, 0.19482626f, 
    -0.15235350f, -0.23512180f, -0.06878995f, 0.31333423f, 0.09707332f, 0.03857721f, 0.05286422f, 0.05753512f, 
    0.02088130f, -0.01049832f, 0.01149192f, -0.00250796f, 0.12452880f, 0.11723197f, -0.04449765f, -0.47473583f, 
    -0.04988537f, -0.20441833f, -0.00290288f, -0.00920169f, 0.00855198f, 0.27308950f, -0.09176546f, -0.03430421f, 
    -0.70268261f, 0.70754957f, -0.14820482f, 0.19359732f, 0.15263194f, 0.02641685f, 0.14716630f, -0.05594128f, 
    -0.05807990f, 0.07177614f, 0.02231364f, -0.15959939f, 0.06237756f, -0.12862860f, 0.07142878f, 0.36244175f, 
    -0.08898138f, -0.09759851f, 0.05019908f, -0.07967300f, 0.00781632f, -0.00718263f, -0.13040201f, 0.05968018f, 
    0.13797088f, 0.02067034f, 0.01563248f, 0.04963034f, -0.31035283f, -0.14034836f, -0.02570940f, -0.17793109f, 
    -0.09275585f, 0.11364030f, -0.06361130f, 0.02378763f, 0.28226700f, -0.18869106f, 0.13675989f, 0.21448435f, 
    0.06440181f, 0.01691916f, -0.06469347f, -0.03812293f, -0.00946465f, 0.03499370f, -0.01833733f, 0.14703785f, 
    0.05427102f, -0.14350119f, -0.10264521f, 0.20099843f, 0.21589831f, 0.08258273f, 0.13255711f, -0.04210856f, 
    -0.06855834f, 0.00805737f, 0.00093956f, 0.02468163f, -0.13776085f, 0.19818258f, -0.08733162f, 0.21676905f, 
    0.06093944f, -0.01170501f, 0.13715373f, -0.01242377f, -0.04075191f, 0.03318963f, -0.06612967f, 0.01310521f, 
    -0.22538574f, -0.30416766f, 0.02476643f, 0.03336148f, 0.10235917f, -0.07196575f, 0.04044280f, -0.06365857f, 
    0.02141788f, 0.11644281f, -0.10494529f, 0.11315395f, -0.53668535f, -0.34159347f, -0.29448432f, -0.21801832f, 
    0.06519128f, -0.16719666f, 0.03221443f, -0.02475697f, 0.04063786f, 0.07805822f, 0.05366036f, -0.10655660f, 
    -0.09189545f, -0.03111244f, -0.07382033f, 0.00589395f, -0.13136983f, -0.03586049f, -0.06332131f, 0.01342715f, 
    -0.10990456f, -0.10133295f, -0.11090235f, -0.07788081f, -0.00855721f, -0.10531019f, 0.05206329f, 0.16670929f, 
    -0.16069621f, 0.09368234f, -0.00417349f, 0.05382765f, -0.02058567f, 0.08780526f, -0.09043512f, -0.06361748f, 
    0.02963465f, -0.04241491f, 0.02208128f, 0.17941511f, 0.09056731f, -0.07414006f, 0.08562736f, 0.01767166f, 
    -0.06578667f, 0.07625753f, 0.00548533f, 0.00013029f, -0.35727367f, -0.19288741f, 0.47817761f, 0.07308974f, 
    -0.18641038f, 0.13151580f, -0.15324079f, 0.05266177f, 0.08395226f, 0.19564602f, -0.03454399f, -0.03871158f, 
    0.19184591f, 0.14366512f, -0.14026000f, -0.45057288f, -0.33269772f, -0.10015149f, 0.06952624f, 0.09204581f, 
    -0.07410960f, 0.01635116f, 0.06873450f, -0.06697835f, -0.42433482f, -0.34378874f, -0.10841277f, -0.28089929f, 
    -0.06711552f, -0.03045767f, -0.01170322f, -0.04727571f, -0.11411746f, 0.13406084f, 0.00585227f, 0.00032968f, 
    0.24836248f, 0.42924261f, 0.41649777f, 0.66690499f, -0.09066942f, 0.10452010f, 0.04201488f, -0.07689420f, 
    0.11809351f, 0.07388035f, 0.00200280f, 0.03284008f, -0.20594817f, -0.05669622f, 0.02468188f, 0.29593343f, 
    0.00479476f, 0.00442403f, -0.05671217f, -0.11038214f, 0.04874510f, 0.06630182f, 0.04163062f, 0.12233842f, 
    0.29935434f, -0.19041008f, -0.16323942f, -0.00905497f, 0.15879849f, 0.01979650f, -0.01886323f, -0.08331690f, 
    -0.08184380f, -0.11294200f, -0.00736551f, -0.10126274f, -0.14441173f, -0.02282106f, 0.00417791f, 0.10884924f, 
    0.06420936f, 0.02735764f, -0.02419984f, -0.12552999f, -0.07723450f, 0.08031525f, -0.06887347f, 0.08969527f, 
    1.01405406f, -0.10947732f, 0.15961459f, 0.02203746f, 0.19602977f, 0.08725941f, -0.07536077f, -0.05059482f, 
    -0.16015093f, -0.03469770f, -0.05834946f, 0.01022242f, 0.08635721f, 0.11635760f, -0.07679085f, 0.16960892f, 
    0.12569578f, 0.02834532f, 0.15028642f, 0.06392568f, -0.01114028f, 0.09448105f, -0.13991547f, 0.12377816f, 
    0.01174414f, -0.04166979f, 0.07337730f, -0.03471687f, 0.05732105f, -0.01254042f, 0.02163281f, 0.02817829f, 
    -0.09282693f, 0.06429034f, 0.00165680f, 0.07335160f, 0.08894849f, -0.14730486f, -0.01756410f, 0.02343048f, 
    -0.08973211f, -0.00785612f, -0.04615715f, 0.05340756f, 0.02570504f, 0.07870586f, 0.04367638f, -0.15292068f, 
    0.02271127f, -0.23329496f, -0.04371785f, -0.04636655f, -0.00969560f, -0.11867063f, -0.15751590f, -0.10628297f, 
    0.07997866f, 0.17488690f, 0.15054785f, -0.04859316f, -0.74622619f, -0.01136472f, 0.03943155f, 0.15650122f, 
    -0.07685065f, -0.04427664f, 0.04236823f, -0.10228845f, 0.06904916f, -0.14756307f, -0.01612712f, -0.02177052f, 
    0.12940182f, -0.10045181f, 0.00248091f, 0.14858356f, 0.02668684f, 0.05395557f, -0.05102039f, 0.03269580f, 
    0.04553603f, 0.03436051f, -0.00019109f, 0.00117253f, -0.12821078f, -0.09192881f, 0.01374700f, 0.02876411f, 
    0.17388099f, 0.07586847f, 0.03900539f, 0.02089621f, -0.02605234f, -0.08085465f, -0.03114813f, -0.03799475f, 
    0.26670560f, 0.16427709f, -0.11969784f, -0.36910239f, 0.00190537f, -0.08219633f, -0.01490623f, -0.29689449f, 
    -0.18126689f, -0.13072284f, 0.01598143f, -0.15372691f, -0.42326584f, 0.16604610f, 0.00729053f, 0.02083132f, 
    0.12635396f, -0.01892226f, -0.03629191f, -0.00331784f, 0.05698102f, -0.02100385f, 0.04285045f, -0.03693789f, 
    -0.08989460f, -0.03038288f, -0.13794832f, -0.23970588f, -0.09020782f, 0.03305621f, 0.05097241f, 0.01034007f, 
    -0.13089734f, 0.14881030f, -0.00347555f, 0.06903709f, 0.04977669f, -0.04389979f, -0.15552759f, -0.19163361f, 
    0.00910817f, -0.03305972f, -0.05902915f, 0.03978717f, -0.10889356f, 0.05056890f, -0.13448919f, -0.03769619f, 
    0.10540987f, 0.20320840f, -0.18134299f, -0.05740282f, 0.13806836f, 0.02661683f, 0.08806270f, 0.03718396f, 
    -0.22626038f, -0.00345570f, 0.06159845f, -0.04204230f, 0.12557074f, -0.16889921f, 0.07556108f, 0.03469956f, 
    0.01718001f, 0.05549424f, -0.11865062f, -0.15384465f, 0.00440512f, 0.18117484f, -0.06532866f, -0.11881448f, 
    -0.05302777f, 0.00428344f, 0.09210419f, 0.04984333f, 0.00290001f, 0.13293798f, -0.02576524f, -0.19617873f, 
    -0.02146657f, -0.15243900f, 0.02898993f, 0.01152222f, 0.01810307f, -0.09483258f, -0.10521048f, -0.03371108f, 
    0.03542785f, 0.03395879f, -0.00028636f, 0.03357218f, 0.02414241f, 0.09518217f, -0.13825117f, -0.10455097f, 
    -0.05186430f, 0.17900716f, -0.02965529f, -0.00938668f, 0.01038593f, -0.06860673f, 0.06878641f, -0.08654334f, 
    0.09542027f, 0.04085765f, 0.16093017f, 0.26844597f, 0.09098948f, -0.02715124f, 0.00908276f, -0.03232093f, 
    0.08609941f, -0.04481783f, 0.00753524f, 0.14388843f, -0.14169320f, -0.02798180f, -0.14799741f, -0.08809140f, 
    -0.08462240f, -0.13963032f, -0.11542182f, 0.15869839f, -0.03088710f, -0.27738443f, 0.03327646f, -0.03667194f, 
    -0.02596962f, 0.01337985f, 0.00073546f, -0.03253787f, 0.27938047f, 0.10206213f, 0.03234394f, 0.25402680f, 
    0.01103739f, 0.06998768f, 0.01290614f, 0.02199033f, 0.09313639f, 0.02164152f, 0.00101136f, -0.01463366f, 
    0.08157455f, -0.13740987f, -0.13228163f, 0.11691362f, 0.05404567f, -0.08322328f, 0.03856807f, -0.09023798f, 
    0.08729135f, -0.03038855f, 0.06449711f, -0.04151862f, 0.13517749f, 0.12838513f, 0.10851709f, 0.00752873f, 
    0.01020408f, 0.02079164f, -0.01863130f, -0.06899016f, 0.07531073f, -0.10683941f, -0.02574600f, -0.01949101f, 
    0.03133297f, -0.01808023f, -0.36442739f, -0.07382995f, 0.07692560f, -0.07716879f, 0.04134350f, 0.01813687f, 
    -0.09178157f, -0.10710372f, -0.18766738f, -0.19958743f, 0.01456719f, -0.17748427f, 0.08328477f, 0.11711097f, 
    -0.12076107f, 0.01203053f, -0.10002404f, 0.02028463f, -0.10163282f, -0.06936165f, -0.09721050f, -0.03096517f, 
    0.14281788f, -0.19243866f, -0.08415122f, -0.07080099f, 0.01762483f, 0.00465268f, -0.00585763f, -0.06924759f, 
    0.10900119f, 0.00540311f, 0.12183154f, 0.12423564f, 0.00416007f, 0.21573985f, -0.11098874f, 0.12905698f, 
    0.03121164f, -0.10518454f, -0.03360105f, -0.13891827f, -0.03982105f, -0.03945236f, 0.09939071f, 0.32474330f, 
    -0.16280459f, -0.24284025f, 0.16352981f, -0.06710149f, -0.12426669f, -0.07245620f, -0.02556609f, -0.04117353f, 
    -0.00100326f, 0.08259977f, 0.00226137f, 0.03485485f, -0.24159589f, 0.10122765f, -0.05972956f, -0.18821950f, 
    -0.03484652f, 0.05222201f, -0.14563803f, 0.02774613f, -0.17385046f, 0.09487750f, -0.04961801f, 0.12685455f, 
    -0.13100861f, -0.37876523f, 0.33606318f, -0.03010118f, -0.29048771f, -0.05272445f, -0.07503930f, 0.10040210f, 
    -0.06252588f, -0.09528588f, -0.01064436f, -0.09282491f, 0.07089561f, 0.11495660f, 0.25193599f, 0.18551458f, 
    -0.09925518f, -0.05806254f, 0.01269210f, 0.08869727f, 0.08975229f, 0.06474329f, 0.00355693f, -0.03376445f, 
    0.05067129f, -0.06758174f, 0.26030388f, 0.15645453f, -0.00079021f, 0.10206935f, -0.16863371f, -0.03712747f, 
    -0.00740504f, 0.05011373f, 0.01901624f, -0.06654441f, -0.09643113f, -0.03007493f, -0.04525052f, -0.07392924f, 
    0.10382555f, -0.06713792f, -0.04949206f, -0.03737015f, -0.10661817f, 0.04177115f, 0.01556571f, -0.14412625f, 
    0.13096935f, 0.13037688f, -0.10295790f, 0.04252065f, -0.14295627f, -0.03468471f, 0.06111808f, -0.26409101f, 
    0.03300091f, 0.06501517f, -0.00871203f, -0.08709726f, 0.13400733f, 0.02849558f, -0.18965641f, 0.04189053f, 
    -0.13806051f, -0.00254806f, 0.11012235f, -0.00142403f, 0.05309788f, -0.02740569f, 0.09078547f, -0.28021011f, 
    -0.13243236f, -0.19391394f, -0.09406647f, -0.16456234f, 0.06611990f, 0.02311510f, -0.01696659f, 0.09786310f, 
    -0.02704640f, 0.07068355f, -0.06010574f, -0.06282864f, -0.15819721f, 0.10262807f, 0.01432340f, 0.18127064f, 
    0.01723249f, -0.01773051f, -0.04408978f, -0.07851332f, -0.14465769f, -0.08010136f, -0.03431513f, 0.09155001f, 
    0.18755558f, -0.26524496f, 0.08447267f, 0.22277990f, -0.10205866f, -0.13689743f, -0.00928738f, -0.17747179f, 
    -0.09617760f, 0.02975656f, -0.22965959f, 0.08429736f, 0.27234748f, -0.59643120f, 0.07971478f, -0.07115849f, 
    0.02783578f, 0.05168013f, 0.04623065f, 0.06886172f, -0.05997156f, 0.02759914f, -0.02504042f, 0.00601056f, 
    -0.05909928f, 0.00229501f, 0.11773174f, 0.09583538f, -0.06641448f, 0.10422359f, 0.04439361f, -0.02864736f, 
    0.02000168f, 0.00533574f, -0.03282321f, 0.01823541f, -0.13898310f, -0.10898746f, 0.10638522f, 0.14224887f, 
    -0.13665235f, -0.02859207f, -0.15831885f, 0.06922322f, 0.05063702f, 0.07480749f, -0.04123136f, 0.00412507f, 
    0.28285605f, -0.04480072f, -0.04478268f, 0.39826700f, 0.05752838f, -0.02469302f, 0.00471832f, -0.17357108f, 
    0.08190668f, 0.00956625f, -0.01494298f, 0.01543814f, -0.26142752f, 0.13077880f, 0.29120189f, 0.04834001f, 
    -0.17460781f, -0.02351292f, -0.12624842f, -0.06774503f, -0.01185436f, 0.00993705f, 0.02690689f, 0.03295244f, 
    -0.06315161f, 0.08186287f, 0.01242685f, 0.07252450f, 0.07913365f, -0.02224364f, 0.06370716f, 0.10785605f, 
    0.04112945f, 0.03134433f, -0.01895209f, 0.09871523f, -0.01122297f, -0.23317967f, -0.00063047f, 0.04488296f, 
    -0.00013825f, -0.03905509f, -0.03116411f, 0.08104646f, 0.13594712f, -0.02472853f, -0.00837217f, 0.03787790f, 
    0.15666765f, 0.09959494f, 0.13818735f, 0.15562452f, 0.02773312f, -0.11061458f, -0.00497603f, -0.08942042f, 
    0.18461506f, 0.05889033f, 0.08302379f, -0.00326799f, 0.02933917f, -0.03585043f, 0.03085396f, 0.13261773f, 
    -0.07394461f, -0.06341081f, -0.08090268f, -0.09012869f, -0.33571926f, -0.14979558f, -0.22986500f, -0.13026568f, 
    -0.05264931f, -0.37339064f, -0.09006533f, -0.02750262f, 0.08126040f, 0.06818981f, 0.04079309f, 0.01916077f, 
    -0.06376853f, -0.03569962f, -0.05229170f, 0.00586798f, 0.09413525f, 0.23059025f, 0.13986982f, 0.09948480f, 
    0.16489193f, 0.10113148f, -0.06743982f, 0.15393384f, 0.05182842f, 0.00604288f, 0.02189454f, -0.04693301f, 
    -0.01520718f, -0.08914067f, -0.02324739f, 0.18781132f, -0.15166709f, 0.03896474f, 0.16305231f, 0.01854360f, 
    0.01850364f, 0.02230139f, -0.02324776f, 0.00581045f, -0.19324827f, -0.09864634f, -0.03789059f, 0.18393856f, 
    -0.00380226f, -0.06831158f, 0.07671558f, -0.13639076f, 0.02930995f, -0.07317536f, 0.13033733f, 0.05419995f, 
    0.22756824f, 0.20870031f, 0.09829438f, 0.00717851f, 0.01712594f, -0.02547584f, 0.01789607f, 0.05872235f, 
    -0.02199720f, -0.12638658f, -0.12202188f, 0.02717561f, 0.12108652f, -0.02151956f, 0.06508432f, -0.00146005f, 
    0.01614597f, 0.05050275f, 0.03314921f, -0.00756741f, -0.03380330f, -0.30339095f, -0.34609336f, 0.05698778f, 
    -0.20701866f, 0.17896102f, -0.15030098f, 0.05631334f, 0.02131801f, -0.05152213f, 0.00019838f, 0.01381731f, 
    -0.22636074f, -0.28940183f, -0.27027714f, 0.04138364f, 0.03650848f, -0.02213231f, -0.01863409f, -0.02829858f, 
    0.07068343f, 0.03591962f, 0.04364476f, 0.02603340f, 0.01638528f, 0.04799025f, -0.01240232f, 0.04582762f, 
    -0.30028060f, -0.06013487f, -0.10863645f, 0.08006169f, -0.00322751f, 0.03866345f, -0.20840690f, -0.22840594f, 
    -0.08305497f, 0.06233745f, -0.01360820f, -0.17605208f, 0.07231719f, 0.20482266f, 0.13294914f, 0.11340526f, 
    0.22750735f, 0.06494424f, 0.02879787f, 0.10925166f, -0.00408100f, -0.03578325f, -0.00192821f, -0.03708412f, 
    0.04665323f, 0.01109445f, 0.14099212f, 0.11509684f, -0.00648826f, -0.01017234f, 0.00771420f, -0.22708480f, 
    0.00116251f, 0.01056530f, 0.04851866f, -0.09966498f, 0.07777072f, 0.25647053f, -0.34954092f, 0.12055623f, 
    0.10457881f, -0.04001053f, -0.08091742f, -0.06516725f, -0.04992015f, -0.06680479f, -0.03430077f, -0.08998831f, 
    -0.24987260f, -0.32206094f, -0.13331331f, -0.06186117f, 0.04169895f, 0.05413799f, -0.04322729f, -0.02226959f, 
    0.04838549f, -0.08129385f, -0.04221125f, 0.04151360f, -0.01339118f, 0.02878143f, -0.01287302f, -0.06003118f, 
    0.03148193f, 0.06686861f, -0.01645178f, 0.04975838f, 0.13484438f, -0.02439545f, -0.00513889f, 0.08476781f, 
    0.08388895f, 0.01874448f, -0.06495506f, -0.26074886f, 0.11818299f, 0.12142971f, -0.02576464f, 0.13595560f, 
    0.05268661f, -0.01781077f, 0.04533286f, 0.01788776f, -0.07438006f, 0.09165772f, -0.03889060f, 0.06161968f, 
    -0.10913656f, -0.15352446f, 0.10285281f, -0.04005950f, -0.03381608f, -0.02690715f, -0.18022622f, 0.13645266f, 
    -0.05097784f, 0.09122267f, 0.00534577f, 0.10090604f, -0.11495329f, -0.04463689f, -0.08124227f, -0.04239753f, 
    -0.09873463f, -0.06222828f, -0.14396983f, 0.00977690f, -0.10995575f, -0.07967107f, -0.05282637f, 0.14281672f, 
    -0.05623859f, -0.03209871f, 0.10222702f, -0.12537386f, -0.03101267f, -0.01680909f, 0.03907623f, 0.01363350f, 
    -0.16821545f, 0.07814162f, -0.14030828f, -0.05912027f, -0.03296501f, -0.05088591f, 0.05312185f, -0.04455395f, 
    0.08758343f, -0.11608204f, 0.14006893f, 0.01489569f, 0.20593154f, 0.02043256f, 0.08499126f, 0.05574044f, 
    -0.05580914f, -0.00308728f, -0.07426812f, -0.08253011f, 0.09990247f, -0.15012722f, 0.00276711f, -0.04198865f, 
    -0.00694070f, 0.06294648f, 0.04339166f, 0.16063103f, 0.08588482f, -0.06065717f, 0.00081668f, -0.04658463f, 
    0.29472053f, 0.04715258f, 0.12777196f, 0.09355064f, 0.11444334f, 0.12727909f, 0.16479518f, 0.20429990f, 
    -0.10218228f, -0.02136870f, -0.10829749f, -0.03799614f, -0.03506557f, -0.05637024f, 0.06568271f, -0.04497411f, 
    0.03441565f, 0.07510761f, 0.04352891f, 0.02434377f, 0.02386938f, 0.01177436f, -0.01939293f, 0.06401738f, 
    -0.02129885f, -0.12485286f, -0.07174649f, -0.05703586f, -0.00848756f, -0.08134969f, -0.07391974f, -0.04924888f, 
    0.16217500f, -0.03601148f, -0.06240940f, -0.02651405f, -0.19820008f, -0.01761695f, 0.01975655f, 0.08297364f, 
    0.01860208f, 0.07902089f, 0.12574612f, 0.14918680f, -0.05397385f, -0.08133388f, -0.00959041f, 0.01147864f, 
    0.05995148f, -0.04663628f, 0.00091269f, 0.02823822f, 0.15666261f, 0.03243319f, -0.05450469f, 0.06068716f, 
    -0.03987063f, -0.02355671f, 0.01818248f, 0.02867466f, 0.16478992f, 0.02547796f, -0.08508026f, 0.10672934f, 
    -0.00522296f, -0.07852408f, 0.01619709f, -0.05261972f, 0.01146391f, -0.01076907f, -0.08698145f, 0.14909913f, 
    0.07930138f, -0.02869389f, -0.05455066f, -0.00049034f, -0.02408061f, -0.00746826f, -0.18995266f, -0.30795431f, 
    0.05197699f, 0.00082007f, 0.00842591f, 0.11563235f, -0.12411071f, -0.01370295f, -0.05531153f, -0.33943409f, 
    -0.10075381f, -0.09964825f, -0.05516136f, -0.33597851f, 0.02943574f, -0.04212693f, -0.02906179f, -0.02111506f, 
    0.08524324f, -0.15899025f, 0.04417785f, -0.05187679f, 0.06234064f, 0.17014952f, 0.20271033f, 0.15554984f, 
    0.01187152f, -0.03169324f, -0.12014636f, -0.19225524f, -0.01412580f, 0.07411613f, 0.06650296f, 0.04288332f, 
    -0.22200944f, -0.12676811f, 0.11996341f, -0.05314554f, -0.08293636f, 0.06861430f, -0.01608900f, 0.04493730f, 
    -0.00383470f, 0.09917534f, -0.01255224f, 0.09554365f, 0.06609354f, 0.02796433f, -0.06128720f, -0.13521837f, 
    -0.03905512f, 0.05298506f, -0.13627437f, -0.07378552f, -0.07933470f, -0.29898396f, -0.17032126f, -0.05990404f, 
    0.26471594f, 0.05693263f, 0.37282604f, 0.03012914f, -0.10610083f, 0.04105082f, 0.15033336f, -0.06828989f, 
    0.02431773f, 0.10414484f, -0.00293688f, 0.05418463f, -0.03033894f, -0.17005666f, -0.30648443f, 0.09867798f, 
    0.06474952f, -0.05587870f, 0.00427344f, -0.02522711f, 0.13282812f, -0.11140849f, -0.01200749f, 0.24212961f, 
    0.12882492f, -0.02895769f, -0.26807928f, 0.01211772f, -0.00493918f, 0.08354784f, 0.07389587f, 0.03723013f, 
    0.06125076f, -0.39305341f, -0.05531800f, -0.65586227f, 0.01214507f, -0.09280292f, -0.01257411f, -0.03055446f, 
    -0.23244952f, -0.05067506f, -0.00630213f, -0.01324489f, 0.11008813f, 0.06043665f, 0.10030384f, 0.13567387f, 
    0.04766194f, -0.05151338f, -0.20221230f, -0.09472442f, 0.07748432f, -0.02612717f, 0.03048767f, -0.11417083f, 
    0.03517688f, -0.03357103f, 0.08587541f, 0.11733074f, -0.12594572f, -0.13983417f, 0.12278951f, -0.02899913f, 
    0.03712021f, -0.01322781f, -0.06134326f, -0.07253120f, 0.01690563f, -0.03117374f, 0.01347154f, -0.09074662f, 
    0.03335883f, 0.22903883f, -0.14978306f, -0.13118772f, -0.02445969f, 0.00552316f, -0.06076586f, 0.06649734f, 
    0.08457749f, -0.13585536f, -0.02712748f, 0.07865047f, -0.09800417f, -0.10523056f, 0.02595370f, 0.02985188f, 
    -0.01229825f, 0.04148868f, -0.01940440f, 0.14626931f, -0.13456315f, 0.02380559f, 0.07669783f, 0.11564381f, 
    -0.14024001f, -0.20726186f, 0.02219692f, 0.13435157f, -0.15163665f, -0.00561003f, -0.00988514f, 0.04914851f, 
    -0.02479125f, -0.15194578f, 0.26478097f, 0.27182564f, 0.08647397f, 0.15744898f, 0.00248688f, -0.13928309f, 
    -0.16359647f, -0.03081678f, -0.06272646f, 0.00171426f, 0.12069181f, -0.02871627f, -0.03918288f, 0.00226332f, 
    -0.02309686f, -0.05560906f, -0.08276441f, 0.10541780f, 0.06302262f, -0.00237288f, 0.01004294f, 0.05405104f, 
    -0.01505683f, -0.06003799f, 0.07041850f, -0.20711271f, 0.02548563f, -0.08056996f, -0.25872210f, 0.08228492f, 
    0.05040661f, 0.11744183f, -0.00751841f, -0.00159483f, 0.09762977f, -0.16803722f, -0.16149361f, -0.53712457f, 
    -0.00668437f, 0.13612153f, -0.12658057f, 0.01403653f, 0.06840873f, 0.00869540f, -0.03101441f, -0.03636362f, 
    0.09759012f, 0.01390915f, 0.05051269f, -0.03264849f, -0.01792257f, 0.05756660f, -0.17180084f, -0.22510163f, 
    0.04198446f, 0.03804589f, -0.05642086f, -0.05127307f, -0.03451740f, 0.04185717f, -0.01262963f, 0.02804826f, 
    0.43704799f, -0.22373450f, 0.32937685f, 0.09487622f, 0.37879464f, 0.02898401f, 0.01578209f, -0.15378670f, 
    0.04143559f, 0.05678489f, -0.00744673f, -0.06809753f, 0.09954556f, 0.09678490f, 0.01846731f, -0.08111963f, 
    0.22439058f, 0.23544477f, -0.06454586f, 0.07918809f, -0.01741530f, 0.00622642f, -0.01709590f, 0.08121891f, 
    -0.06855006f, 0.09945928f, 0.23218346f, 0.02017922f, 0.12553406f, -0.06425530f, 0.03075343f, 0.08698722f, 
    -0.06717491f, 0.00054381f, 0.08931040f, 0.03896646f, -0.08411945f, -0.00504173f, -0.33469757f, -0.07853208f, 
    0.01541656f, 0.07906998f, -0.18014482f, 0.06569209f, 0.14807469f, -0.21220052f, -0.02934258f, 0.14030449f, 
    -0.02042557f, -0.19087656f, 0.18031108f, 0.02188797f, -0.01885933f, 0.14652568f, 0.05594207f, -0.09805772f, 
    0.15523908f, 0.02068230f, 0.03051705f, 0.07781865f, -0.03861584f, 0.15847111f, 0.08320378f, -0.22659910f, 
    -0.11766511f, 0.01763602f, -0.02079643f, 0.13734429f, 0.13544112f, -0.03864188f, 0.01739201f, 0.15013969f, 
    -0.16714741f, 0.09685522f, 0.03069270f, -0.39190400f, 0.00952506f, 0.01376600f, -0.04916119f, 0.07211049f, 
    0.09257373f, 0.04360613f, 0.03999158f, 0.13432281f, 0.03053564f, -0.03328814f, 0.30481499f, -0.07680442f, 
    -0.08817203f, 0.17324769f, 0.02069713f, -0.01408352f, 0.31544495f, -0.01384065f, 0.01036738f, 0.00057490f, 
    0.01381047f, 0.17185351f, 0.08401099f, -0.10674443f, 0.22593836f, -0.06569825f, -0.00582974f, -0.03375289f, 
    0.17272945f, 0.02228561f, -0.02718927f, 0.00521927f, 0.03655907f, -0.10900742f, 0.44613954f, -0.06958402f, 
    -0.07440792f, -0.04813068f, -0.06388164f, 0.03121863f, 0.10219830f, 0.09443650f, 0.01117656f, -0.00725973f, 
    -0.01475414f, 0.07357454f, 0.10094533f, -0.05584868f, 0.16473119f, 0.03534348f, 0.01276544f, -0.01299908f, 
    0.03437662f, 0.05876115f, 0.07603375f, 0.06699894f, -0.09459326f, -0.01772919f, -0.20511192f, -0.24115926f, 
    0.24000637f, 0.11828267f, 0.17557003f, -0.22602932f, 0.02179826f, 0.06053934f, 0.04511144f, 0.06533802f, 
    -0.09842661f, -0.09827407f, -0.09899829f, 0.14947242f, 0.08410358f, -0.08019873f, 0.05413384f, 0.13843550f, 
    -0.02863793f, 0.06291661f, -0.08012086f, -0.02638238f, -0.02881410f, 0.06260315f, -0.07755877f, -0.45433059f, 
    0.09030617f, -0.01152845f, 0.02484648f, -0.01900246f, -0.00506435f, -0.11026045f, -0.02870962f, 0.03231984f, 
    0.00086327f, 0.11377721f, -0.04424043f, -0.06272040f, -0.09548678f, 0.05645629f, 0.03524329f, -0.03105508f, 
    -0.00372980f, 0.01060003f, -0.11690131f, -0.00460505f, -0.33435908f, 0.37262639f, 0.23052558f, -0.21888997f, 
    0.00693837f, -0.03150712f, 0.05194279f, 0.04349152f, -0.02813924f, -0.23799457f, -0.18328439f, -0.15604171f, 
    0.12688653f, 0.12812954f, -0.15154400f, -0.15832262f, -0.01055039f, 0.02496929f, 0.05660425f, 0.00990060f, 
    -0.20263354f, -0.18096285f, -0.08844650f, -0.02041912f, 0.16213714f, -0.42645323f, 0.28185707f, 0.17437723f, 
    0.05758457f, -0.06587981f, 0.13883173f, 0.14988811f, 0.11428852f, -0.11957190f, 0.13743739f, 0.11110125f, 
    -0.03556604f, 0.30379227f, -0.12886660f, -0.44285977f, -0.11249849f, 0.04693024f, -0.06019180f, -0.08235103f, 
    0.14782780f, -0.04980208f, -0.19567986f, -0.32472953f, -0.03526150f, -0.07428893f, -0.10455891f, -0.09664472f, 
    0.01228322f, 0.13829723f, 0.05988316f, -0.01853004f, 0.00376752f, 0.07231887f, 0.04305153f, -0.05962799f, 
    -0.05862316f, 0.01417553f, -0.00454209f, -0.22097541f, 0.01861149f, -0.04367942f, -0.16567568f, 0.04406846f, 
    0.06795781f, -0.05167401f, 0.06703470f, 0.03021631f, -0.12585267f, 0.09500877f, -0.11317059f, -0.23534185f, 
    -0.12770326f, -0.20288067f, 0.15518908f, 0.08485064f, 0.04773709f, -0.18141975f, -0.08880465f, -0.02200596f, 
    -0.40418178f, -0.22725999f, -0.26122570f, -0.14998327f, -0.02443965f, 0.00422609f, 0.00848598f, 0.03791814f, 
    0.08000237f, -0.00255555f, 0.06019802f, -0.06054294f, -0.06339237f, -0.27390414f, -0.10115433f, -0.26948512f, 
    -0.05864446f, -0.03761830f, -0.13165693f, -0.06228120f, 0.09048803f, 0.04074918f, 0.42171934f, 0.02063571f, 
    0.02831872f, -0.20911853f, 0.01617260f, -0.00135341f, 0.02635941f, 0.06311687f, -0.09772892f, 0.23018695f, 
    0.10096145f, 0.14842394f, 0.26316807f, -0.12094850f, -0.00280054f, -0.04027030f, -0.06579071f, 0.05391178f, 
    0.03921395f, 0.00715999f, -0.05597523f, -0.04054606f, -0.16288905f, 0.01363663f, -0.07745285f, -0.04022644f, 
    0.44274330f, 0.12288730f, -0.02425386f, 0.03525339f, -0.13929197f, -0.11023988f, 0.11809250f, 0.17240162f, 
    -0.07103597f, -0.11058798f, -0.16520870f, -0.03978466f, 0.13272871f, 0.12432978f, 0.18412217f, 0.09128374f, 
    -0.07762693f, 0.02180115f, 0.12531947f, 0.07184754f, 0.05746246f, -0.06601655f, -0.01793749f, -0.05667247f, 
    0.15811965f, 0.01421824f, -0.04274442f, 0.04035623f, -0.07649804f, 0.06116730f, 0.06257268f, 0.00841731f, 
    0.10450548f, -0.07411674f, 0.14629719f, -0.02278201f, 0.14102913f, 0.05806074f, -0.51526326f, 0.12906604f, 
    0.10419659f, 0.27987161f, -0.05816273f, 0.18214308f, 0.03524055f, -0.05604653f, 0.16894569f, 0.03631342f, 
    -0.13825771f, -0.38389644f, 0.20954959f, 0.13361371f, 0.02515928f, 0.07710800f, -0.04261563f, -0.06231843f, 
    0.07083748f, 0.00373396f, 0.05513490f, -0.04184942f, -0.03213402f, -0.16130774f, -0.10531233f, 0.01433810f, 
    -0.00838992f, -0.01769792f, -0.02711253f, -0.07279840f, 0.07778032f, -0.15526608f, 0.18509592f, -0.08421245f, 
    -0.23244704f, -0.17609690f, -0.20945433f, -0.18228103f, -0.04050037f, 0.02521184f, 0.00054607f, 0.03693347f, 
    -0.01044437f, -0.04497792f, -0.01699542f, -0.11993686f, 0.18341735f, -0.14466502f, 0.02943709f, -0.11838399f, 
    0.05814209f, -0.02766429f, 0.04693290f, 0.12837863f, -0.07512654f, 0.00818677f, -0.03471154f, -0.39065057f, 
    -0.41098213f, -0.16209017f, -0.00223817f, -0.19691198f, -0.02750977f, 0.04272041f, 0.05327698f, -0.13947369f, 
    0.10545314f, 0.03077656f, 0.05516562f, 0.05465690f, -0.46113846f, 0.02360662f, 0.18889105f, -0.24553384f, 
    0.04707410f, 0.00573935f, -0.10459860f, 0.18575831f, 0.02738350f, -0.00546711f, -0.01741096f, 0.06681983f, 
    -0.84273529f, -0.27008078f, -0.23885441f, 0.13638194f, 0.00435077f, -0.03772440f, 0.02916900f, 0.09706289f, 
    0.03069551f, 0.01814981f, -0.04171344f, 0.00523208f, -0.07362415f, -0.26551807f, 0.03416069f, -0.09399659f, 
    -0.03677784f, -0.09839492f, -0.00476889f, -0.02036490f, 0.23920271f, -0.07499032f, 0.04397487f, 0.03635610f, 
    -0.00776343f, 0.15633129f, -0.00443574f, -0.02744449f, 0.01349259f, -0.00217027f, -0.04883050f, -0.00690800f, 
    -0.31858909f, -0.08090097f, 0.11211234f, 0.09648577f, 0.16981292f, -0.00034953f, 0.14354081f, 0.13883385f, 
    0.06573167f, 0.16615559f, -0.05682717f, -0.05441975f, 0.11517169f, -0.02261610f, -0.10807871f, 0.09690426f, 
    -0.04145848f, -0.05578219f, -0.09477522f, -0.00742078f, -0.05770911f, 0.10554509f, 0.14403485f, -0.06654208f, 
    0.10188954f, -0.11462221f, 0.03064772f, 0.06652866f, 0.11393695f, -0.10178603f, -0.13145347f, -0.09825997f, 
    -0.00847053f, 0.03979963f, -0.17104264f, 0.01968609f, -0.04948927f, -0.05059185f, -0.14356600f, -0.02589086f, 
    -0.03284993f, -0.03753167f, -0.13339554f, -0.33861327f, 0.21120901f, 0.01042262f, -0.05694337f, -0.15831399f, 
    0.02994166f, 0.07934786f, -0.09630479f, -0.03176298f, -0.28937480f, -0.21449567f, -0.01544595f, -0.08889459f, 
    -0.04670903f, -0.03489550f, -0.03677685f, 0.03282557f, 0.06500345f, 0.08036958f, -0.06431663f, -0.13439888f, 
    -0.17934431f, -0.11096253f, -0.11068299f, 0.40923747f, -0.08628537f, -0.25490338f, 0.06133467f, -0.04992271f, 
    0.01049945f, 0.08575086f, -0.10461780f, 0.08439332f, 0.04797169f, -0.22668073f, -0.25976497f, 0.10986745f, 
    0.02534292f, 0.01493680f, -0.09179601f, -0.07521866f, 0.00228343f, 0.04468265f, -0.00832366f, 0.35506260f, 
    0.02284683f, -0.04600836f, -0.09878584f, -0.13667676f, -0.02862730f, 0.08730730f, 0.03414882f, 0.00218240f, 
    -0.05154324f, -0.16566931f, 0.11773507f, -0.09596614f, 0.42689702f, -0.07799304f, 0.32017022f, -0.07732324f, 
    -0.03121988f, 0.01591692f, 0.10707122f, 0.13830723f, -0.05265617f, -0.09502907f, 0.08531115f, -0.15750481f, 
    -0.18883328f, -0.09047657f, 0.13697657f, -0.19670475f, -0.11676174f, -0.07415671f, -0.01152125f, 0.08982363f, 
    -0.18602565f, -0.33232367f, -0.15402892f, -0.05616741f, -0.16664794f, -0.30244759f, -0.00625198f, 0.19984247f, 
    0.03718901f, 0.03742923f, 0.25620696f, 0.13108909f, 0.03319145f, 0.14352445f, -0.04179711f, 0.12309805f, 
    -0.18279842f, -0.32547569f, -0.42479953f, -0.23660564f, -0.01738610f, 0.07087377f, -0.22142813f, -0.10346754f, 
    0.03859147f, 0.00341024f, 0.12648113f, -0.09695326f, 0.21426937f, -0.05175842f, -0.04475153f, -0.01353585f, 
    -0.03108936f, -0.06285593f, 0.10367925f, -0.03139021f, -0.07798794f, 0.08781597f, -0.06674480f, -0.08273006f, 
    0.12136612f, 0.03784038f, -0.04302296f, -0.09861283f, -0.05195247f, -0.01479089f, 0.08553047f, 0.04802357f, 
    0.13210857f, 0.18793023f, 0.17411463f, 0.12647097f, -0.00443241f, -0.02808896f, -0.08267729f, 0.09184100f, 
    -0.00997045f, -0.05749780f, -0.04139767f, 0.13569063f, 0.03976794f, -0.10686040f, -0.00867682f, -0.03838896f, 
    -0.04866914f, 0.02851711f, 0.30883357f, 0.19426794f, 0.18194076f, -0.10104374f, 0.03208328f, -0.08324549f, 
    0.02579359f, -0.02246033f, 0.05189442f, -0.00611872f, -0.15919718f, -0.36187622f, -0.17966327f, -0.14486811f, 
    0.01413882f, 0.10453314f, 0.00734335f, -0.14114325f, -0.02747512f, 0.03117154f, -0.02184159f, 0.04332887f, 
    0.05647374f, -0.04859142f, 0.14235957f, -0.08808113f, 0.07252902f, 0.06186613f, 0.07435190f, -0.06024105f, 
    0.04906217f, 0.10540123f, -0.14411807f, 0.12734991f, -0.14097941f, 0.25477806f, 0.28200153f, 0.37064454f, 
    -0.08630880f, -0.15056041f, -0.01980387f, -0.00647991f, -0.01986142f, -0.00477382f, -0.15677291f, -0.01918063f, 
    -0.08402431f, -0.03487249f, 0.29701340f, 0.07113671f, -0.00117896f, -0.05802083f, 0.00955901f, 0.07210770f, 
    0.00026780f, 0.08096947f, 0.16549891f, 0.16156626f, -0.04609636f, 0.29101929f, 0.02540937f, -0.17425530f, 
    0.05603161f, -0.22284180f, 0.07443993f, -0.00521755f, 0.09281036f, 0.14229505f, -0.12618378f, -0.00145626f, 
    0.06078501f, 0.01446818f, -0.17553036f, -0.11942522f, -0.02247689f, -0.00018403f, 0.00582279f, 0.07045384f, 
    -0.05625242f, 0.06142128f, -0.00953855f, -0.14758669f, 0.12684514f, 0.02960210f, -0.03435983f, -0.14081645f, 
    -0.01433479f, -0.01819309f, 0.00718251f, 0.02631710f, 0.01677711f, 0.24900356f, 0.11326059f, 0.07261298f, 
    -0.23973931f, 0.11017886f, 0.17336148f, -0.14807461f, -0.02629589f, 0.03533086f, -0.03999219f, 0.03923037f, 
    -0.00632130f, 0.06896582f, 0.10305507f, 0.03717097f, -0.06471273f, 0.12215828f, 0.22382797f, -0.16533929f, 
    0.01697834f, -0.07880312f, 0.07974605f, -0.09516438f, 0.05223605f, 0.05795564f, -0.02279173f, 0.22321187f, 
    0.26289663f, -0.04447558f, 0.01152877f, 0.42287561f, -0.01550310f, -0.21484172f, 0.00416208f, 0.16289335f, 
    -0.08499389f, -0.01848677f, 0.04118149f, 0.03858960f, -0.46072853f, -0.34375107f, -0.42867601f, -0.30007827f, 
    -0.14502183f, -0.08895831f, -0.26061943f, -0.02187474f, 0.07805401f, -0.03550726f, -0.03657492f, -0.04371189f, 
    -0.33087504f, -0.24061571f, -0.67806649f, 0.40110978f, -0.11820704f, -0.00609219f, 0.08430952f, -0.20398015f, 
    -0.02534499f, 0.00996094f, 0.07438206f, -0.03809766f, 0.29766360f, 0.12434658f, -0.03865044f, 0.02966830f, 
    0.05628524f, -0.05918167f, 0.13536455f, -0.05994188f, 0.03516831f, -0.00100986f, 0.00913747f, -0.00409688f, 
    -0.01512613f, -0.38109767f, 0.09204397f, 0.01397737f, -0.09310648f, -0.29087919f, -0.31364837f, 0.16881056f, 
    -0.11916173f, 0.02374334f, 0.00975587f, -0.08410679f, 0.05449934f, -0.09920106f, -0.03248337f, 0.07724655f, 
    0.08563228f, -0.00410730f, 0.27346170f, 0.08056770f, 0.00710892f, 0.08810802f, 0.12253282f, -0.02782261f, 
    -0.11035799f, -0.22692795f, 0.00417667f, 0.00396032f, 0.09855680f, 0.02853601f, -0.04673462f, -0.03386041f, 
    -0.01064144f, 0.01659240f, -0.05727827f, 0.05894902f, -0.14071482f, -0.26408908f, 0.00975531f, 0.32400927f, 
    0.06955212f, 0.22620369f, 0.14963438f, -0.09004172f, 0.06384607f, -0.11980384f, 0.08479808f, -0.00565347f, 
    -0.69891959f, -0.11490781f, 0.59031689f, -0.35467821f, -0.10824653f, -0.07598045f, -0.06519821f, -0.12052783f, 
    -0.07296933f, 0.12229033f, 0.02780601f, -0.04519726f, 0.12171176f, -0.15221958f, 0.08041817f, 0.16853733f, 
    0.13348348f, 0.05506373f, -0.04161069f, 0.14837630f, 0.03384153f, 0.04686882f, -0.03332214f, 0.00675307f, 
    -0.35775191f, -0.40044892f, -0.35058707f, -0.17313613f, -0.07470728f, -0.23938832f, -0.12798005f, -0.30149618f, 
    -0.03342094f, -0.02537849f, -0.03869392f, -0.02074802f, -0.25607002f, -0.44305313f, -0.25058985f, -0.20193970f, 
    0.12790160f, -0.11025208f, -0.17317399f, -0.11213962f, -0.00851448f, 0.05973295f, -0.04095209f, 0.03237930f, 
    0.12503457f, -0.22080183f, -0.17806685f, -0.08402997f, -0.02139884f, 0.15680720f, 0.14667110f, 0.12196035f, 
    0.00576474f, -0.00028160f, 0.03050365f, 0.00472640f, -0.31198147f, -0.06718000f, 0.16800037f, -0.42514983f, 
    0.04653515f, 0.10315569f, 0.01153208f, 0.10485983f, -0.02134454f, 0.05738329f, -0.02488529f, -0.01090745f, 
    -0.42974469f, -0.44096419f, 0.00359388f, -0.00307023f, -0.13276853f, 0.08937429f, -0.05003279f, -0.11156252f, 
    -0.02059190f, 0.03182624f, 0.01126910f, -0.01472942f, 0.21100111f, 0.03151377f, 0.06131411f, -0.12764218f, 
    -0.03886987f, -0.05607040f, 0.05358632f, 0.12691589f, 0.09808101f, 0.20047963f, 0.22691672f, 0.06883015f, 
    0.13032745f, 0.30397660f, -0.01952912f, -0.39722019f, -0.04789151f, -0.00734705f, -0.21672110f, -0.02270246f, 
    -0.00390479f, -0.04724514f, 0.04774593f, 0.02661089f, -0.05840669f, -0.10534000f, -0.13891256f, 0.10571091f, 
    -0.06054222f, -0.08440637f, 0.03263960f, 0.17622995f, 0.07265710f, 0.05979320f, 0.04858840f, -0.08909102f, 
    -0.16208445f, -0.02960120f, 0.01319287f, 0.02398538f, 0.07459830f, -0.02415933f, 0.08643964f, -0.04728205f, 
    0.00316541f, 0.07355372f, -0.00425015f, 0.03537882f, -0.00530361f, -0.06687203f, -0.06585791f, 0.05415878f, 
    0.00778588f, 0.03424789f, 0.03240716f, -0.19005598f, 0.04319942f, -0.12165315f, -0.05485056f, 0.00788018f, 
    -0.02508275f, -0.25104803f, -0.27039242f, 0.02136960f, -0.16410273f, 0.15532377f, 0.09576752f, 0.06807145f, 
    -0.02113683f, -0.07164699f, -0.11238284f, -0.04495049f, -0.44135430f, -0.56637007f, -0.13171050f, -0.02437932f, 
    -0.05236239f, 0.01007926f, 0.02133822f, -0.05041520f, -0.03832741f, -0.04649644f, 0.14030720f, -0.02222675f, 
    -0.39484644f, 0.36513695f, 0.33234167f, 0.10566120f, -0.04884315f, -0.07918134f, -0.00987837f, -0.03348170f, 
    -0.11130871f, -0.07070241f, -0.11162357f, 0.14759548f, -0.06563472f, 0.14040150f, 0.06344453f, -0.02952408f, 
    0.01987988f, -0.06017331f, 0.04011890f, -0.00451986f, -0.06228325f, -0.06063472f, 0.06965604f, 0.16202804f, 
    0.14732163f, -0.06010983f, -0.02632215f, 0.13555725f, -0.00919326f, -0.04761624f, -0.03235095f, 0.18637405f, 
    0.06311285f, -0.13430758f, 0.08267099f, 0.05952202f, -0.05661912f, 0.00044001f, -0.02560001f, -0.13609114f, 
    0.01437432f, -0.05029014f, 0.04466467f, 0.02643703f, -0.12942758f, -0.01703094f, -0.21680787f, -0.06571479f, 
    0.42934677f, 0.13122992f, -0.40111974f, 0.05954986f, -0.03363302f, -0.03013854f, 0.19330768f, 0.24361855f, 
    0.02527591f, 0.12548342f, -0.11240187f, -0.14943416f, -0.66974229f, -0.75947976f, -0.27254990f, -0.02134313f, 
    -0.02951632f, 0.04410880f, 0.09427264f, -0.16337271f, 0.02199055f, 0.02874678f, -0.01109195f, 0.13359579f, 
    -0.67847019f, -0.25032574f, 0.03333396f, -0.10206126f, -0.10637634f, -0.26946121f, -0.12198795f, -0.23624192f, 
    -0.02427532f, -0.05170074f, 0.07341310f, -0.01932794f, 0.44011536f, 0.01143996f, 0.08961434f, -0.52117497f, 
    -0.09629088f, -0.08166491f, 0.20520744f, -0.05049318f, 0.10658924f, 0.08159587f, -0.05496388f, 0.00882387f, 
    0.04255084f, 0.12620753f, -0.05543463f, -0.05368248f, -0.00596933f, 0.02450989f, -0.05577001f, 0.04791784f, 
    -0.05624602f, -0.03438545f, -0.01216283f, -0.01417044f, 0.03424328f, -0.00113521f, -0.02128023f, -0.15474527f, 
    -0.00965402f, -0.00503316f, -0.02244604f, 0.00382931f, -0.04262762f, -0.05311335f, -0.06543973f, -0.10134603f, 
    -0.46101791f, -0.30455548f, 0.06553074f, 0.21986899f, 0.08110655f, 0.08851683f, 0.01174349f, -0.28575957f, 
    0.03081366f, -0.05728630f, 0.03483810f, 0.05958249f, 0.28653866f, 0.32336661f, -0.28109697f, 0.27506763f, 
    0.02623280f, 0.05969000f, 0.00701681f, 0.21748948f, 0.17037797f, -0.02105785f, 0.15355393f, -0.05697378f, 
    -0.52105534f, 0.19206372f, 0.31133100f, 0.18076479f, -0.12155786f, -0.11920667f, 0.04937364f, -0.09205116f, 
    -0.08828832f, 0.01572901f, -0.01641252f, 0.05827859f, -0.63183528f, -0.68033910f, -0.07185835f, -0.14199947f, 
    -0.12196110f, -0.14232817f, -0.00055196f, -0.14031018f, -0.07220974f, 0.01528198f, 0.00363990f, -0.01008467f, 
    -0.11015221f, -0.11194522f, 0.22238593f, 0.17078134f, -0.01480492f, 0.00459696f, -0.05763752f, 0.04610486f, 
    0.02338279f, 0.13952193f, 0.08896449f, 0.01094455f, -0.22166409f, 0.14896725f, 0.19377370f, 0.00759256f, 
    -0.09622864f, -0.18505849f, -0.06358556f, 0.20048687f, -0.04192831f, 0.16708578f, 0.05918271f, -0.09704456f, 
    0.02018208f, 0.05900224f, 0.08019900f, -0.11039759f, 0.01374402f, 0.00745727f, 0.02309342f, -0.00370604f, 
    0.02242062f, -0.02917814f, -0.04786425f, -0.01785064f, -0.53408110f, -0.39909363f, -0.46476087f, -0.75604981f, 
    -0.18757917f, -0.32430235f, -0.02857893f, -0.27261975f, -0.07755097f, 0.02685757f, 0.02091930f, -0.02426686f, 
    -0.01820950f, -0.07873403f, -0.02667410f, 0.00162454f, -0.05520355f, -0.12084311f, -0.06255204f, -0.04403026f, 
    -0.05500030f, -0.03917397f, -0.06367294f, -0.08508669f, 0.17415601f, 0.15867320f, 0.04155482f, 0.14724986f, 
    0.00802229f, -0.02641477f, 0.11628835f, 0.19426118f, 0.06888621f, 0.09963537f, -0.06487988f, -0.05558577f, 
    -0.39545190f, 0.01831869f, 0.04643805f, -0.29986760f, 0.09013205f, -0.05713587f, -0.17469141f, 0.02722193f, 
    -0.05515558f, 0.08014984f, 0.01924355f, 0.14344633f, -0.37170246f, 0.27659819f, 0.24662966f, -0.09957148f, 
    -0.03770729f, 0.04022274f, -0.05185230f, 0.06233278f, 0.05479077f, -0.00626554f, 0.01103659f, 0.03738951f, 
    -0.05273315f, -0.10558025f, -0.04000304f, 0.11480563f, -0.05459462f, -0.03840970f, 0.11782367f, 0.02610263f, 
    -0.03420764f, -0.06155036f, -0.03924229f, 0.01670450f, -0.10677055f, 0.07420790f, 0.13420334f, 0.11061075f, 
    -0.00940953f, -0.07374673f, -0.03518356f, 0.02358035f, 0.01116142f, -0.06187424f, -0.01519148f, 0.01198123f, 
    0.09275658f, -0.02756471f, -0.01436438f, -0.11276520f, 0.00209975f, 0.04569375f, 0.00637942f, 0.06551486f, 
    0.04506383f, -0.05793288f, 0.02156854f, -0.07737246f, -0.12161081f, -0.05617665f, 0.00738336f, -0.19139519f, 
    -0.09453992f, 0.10174511f, -0.03479307f, 0.04314555f, -0.07226551f, 0.02251714f, 0.16316877f, -0.09264817f, 
    0.00646348f, -0.11090206f, -0.02069326f, 0.06742357f, -0.01403788f, -0.04580281f, 0.17088558f, 0.16468962f, 
    -0.02059387f, 0.04628658f, 0.11882982f, 0.02661129f, 0.08735258f, -0.08266804f, -0.00086326f, -0.03603245f, 
    0.06712062f, 0.14906755f, -0.11909803f, -0.04341837f, -0.01670974f, -0.07363726f, -0.00505646f, 0.08469576f, 
    0.10914136f, -0.16749854f, 0.40085050f, 0.13406928f, -0.20225990f, 0.05818632f, -0.22311823f, 0.01582603f, 
    0.03493747f, -0.08426727f, -0.00580170f, -0.09417993f, -0.04023885f, 0.03642991f, 0.01437858f, 0.03533939f, 
    0.03667814f, 0.00785419f, -0.01091435f, -0.00477347f, 0.06034194f, -0.05253371f, -0.02349897f, -0.02852148f, 
    -0.15674041f, 0.11753652f, -0.20508493f, 0.18516050f, -0.07398976f, -0.04187185f, 0.08274822f, -0.01213081f, 
    0.07255761f, 0.14327542f, 0.11666925f, -0.07286769f, 0.10567699f, -0.06365044f, -0.01183919f, -0.04528038f, 
    -0.01816437f, 0.05920078f, 0.02858519f, -0.01447143f, 0.00209183f, 0.03442362f, -0.00211194f, -0.01989151f, 
    -0.06487944f, 0.10418996f, 0.09363604f, 0.15010485f, -0.24202338f, 0.02362016f, -0.14970987f, 0.00793621f, 
    0.05550468f, -0.02345848f, -0.03282964f, -0.05642980f, 0.12101065f, -0.12313029f, -0.04391541f, -0.03782128f, 
    0.02179875f, -0.06683607f, -0.03161293f, -0.02765054f, 0.02590886f, 0.01989727f, 0.06621002f, 0.02740488f, 
    -0.07549635f, 0.10881333f, 0.04562445f, -0.06551371f, 0.00031056f, 0.05567230f, -0.04583541f, 0.00961388f, 
    0.00741260f, -0.03599389f, -0.01086006f, -0.13669169f, -0.57083005f, -0.43065646f, -0.34824130f, -0.27606779f, 
    -0.15197498f, -0.12244089f, 0.06392206f, -0.14490978f, 0.08444673f, -0.09266111f, -0.00943053f, 0.03063586f, 
    0.33643684f, -0.03228730f, -0.18751526f, -0.38503182f, -0.01260305f, 0.00658887f, 0.04561502f, -0.06875587f, 
    -0.06952017f, 0.00308924f, -0.07994385f, -0.35493147f, -0.16817744f, -0.17699039f, 0.39256659f, -0.17833602f, 
    -0.03550126f, -0.06150607f, 0.11528269f, -0.03115018f, -0.10339683f, 0.02915697f, -0.06148802f, 0.05882844f, 
    0.06350681f, 0.03452369f, 0.04187198f, -0.07315005f, -0.00682342f, -0.01153232f, -0.02004277f, 0.00455684f, 
    0.08135243f, -0.11278165f, -0.02287814f, -0.12585160f, -0.00621300f, 0.08598237f, -0.00168179f, 0.11200506f, 
    -0.01756964f, -0.01419384f, 0.00311809f, 0.01694435f, 0.13439639f, 0.07785526f, 0.01074266f, 0.01534984f, 
    0.29908669f, 0.24078442f, 0.00916992f, -0.37962618f, 0.00254541f, 0.02019945f, -0.04401768f, -0.05587517f, 
    0.15151878f, 0.13316424f, -0.03452377f, -0.12926686f, -0.09320700f, -0.01316752f, -0.02084415f, 0.16105427f, 
    -0.06242609f, 0.12054288f, 0.16976663f, 0.02023060f, -0.06393140f, 0.05318952f, 0.01584780f, 0.03345187f, 
    0.21883394f, -0.30363977f, -0.23638202f, -0.05224861f, -0.04078403f, -0.11893276f, -0.10844699f, -0.02076833f, 
    -0.04185755f, 0.04718529f, -0.01215593f, -0.06550699f, -0.32671520f, -0.24004717f, -0.16034968f, 0.18735653f, 
    0.02729308f, 0.06688588f, 0.12292872f, 0.14845131f, 0.02330512f, 0.06068588f, -0.03894858f, 0.02216169f, 
    -0.00489546f, -0.28927550f, 0.23714848f, -0.25478470f, 0.03299869f, 0.12791958f, 0.01595905f, 0.25062299f, 
    -0.02908325f, -0.06888080f, -0.12327664f, -0.00997589f, -0.05817615f, 0.08989791f, -0.06213568f, 0.03191571f, 
    0.02503575f, 0.00845837f, 0.00945830f, 0.01271935f, -0.14501755f, -0.05282192f, -0.00947854f, -0.08650867f, 
    0.23724480f, -0.02922835f, -0.00921854f, 0.00219992f, -0.22930349f, -0.00621972f, 0.06903684f, 0.10347275f, 
    0.00196431f, 0.04463021f, 0.08212646f, -0.03585496f, 0.04957937f, -0.00044691f, 0.20329076f, -0.16936642f, 
    -0.09528073f, -0.05091051f, -0.01146579f, 0.00826996f, 0.01109702f, 0.03567017f, 0.04074397f, -0.12548049f, 
    0.14705013f, 0.01207198f, 0.07611549f, -0.07489248f, 0.09824317f, -0.03295741f, -0.01586331f, 0.02599978f, 
    -0.04435104f, 0.00946995f, -0.02441472f, -0.03995278f, -0.04458116f, -0.26568660f, 0.11321044f, -0.00807668f, 
    0.02034924f, -0.04434326f, 0.03730797f, 0.02362063f, 0.02587625f, 0.00964711f, 0.00034424f, -0.08694082f, 
    0.44039351f, 0.27133641f, -0.01475674f, -0.29263410f, 0.07443582f, 0.04744091f, -0.03758763f, 0.01678560f, 
    -0.01083427f, -0.00110229f, -0.00795959f, -0.01354607f, 0.03372576f, -0.05924376f, 0.05971088f, -0.40216622f, 
    0.04383699f, -0.02673757f, -0.03973844f, -0.06087499f, -0.02252424f, 0.00728912f, -0.02001518f, -0.04055942f, 
    -0.20053175f, -0.19694598f, -0.11253701f, -0.04523239f, 0.05600100f, -0.00924007f, 0.01222745f, 0.02349161f, 
    0.02503661f, -0.02274185f, -0.00768749f, -0.05538313f, -0.26205966f, -0.12581657f, -0.21979579f, -0.12745273f, 
    0.10285298f, 0.07713472f, 0.03869436f, 0.13076052f, 0.05043227f, 0.01548876f, -0.04208405f, -0.00107225f, 
    -0.01633974f, 0.06076779f, -0.00594643f, -0.05442965f, -0.02023151f, -0.00489343f, -0.05547603f, 0.18568191f, 
    0.02709199f, 0.06845264f, 0.06754650f, 0.03153416f, -0.38675481f, -0.05461637f, -0.09177418f, -0.20771669f, 
    -0.13050780f, 0.06429909f, 0.12310240f, 0.12562500f, 0.08792967f, 0.01638918f, -0.01250953f, -0.01624930f, 
    -0.17029017f, -0.21202959f, -0.03805726f, -0.02416861f, -0.07220493f, -0.12897745f, 0.08329109f, 0.18381079f, 
    -0.09298999f, -0.06261556f, -0.02017322f, -0.03726330f, 0.35782567f, 0.04285314f, -0.54707479f, 0.17580131f, 
    -0.03259325f, -0.02474978f, 0.02397251f, -0.07073893f, 0.22518696f, -0.03516969f, -0.02420558f, 0.04241958f, 
    -0.41328132f, -0.08884373f, -0.25056681f, 0.08031864f, 0.06487071f, 0.03194409f, 0.05612890f, 0.02936668f, 
    -0.03843359f, -0.04293162f, 0.05644459f, 0.02895038f, 0.34853700f, -0.51230788f, -0.03367633f, -0.20487767f, 
    0.06593574f, 0.08711560f, -0.00460000f, -0.05830538f, -0.05611248f, 0.09539199f, 0.08722663f, -0.09179433f, 
    0.17868136f, 0.09314927f, 0.36446100f, 0.15874971f, 0.03215073f, 0.13416481f, 0.08773386f, 0.02693295f, 
    -0.02292595f, -0.13379605f, 0.06579901f, 0.00841256f, 0.00722518f, 0.00358955f, 0.05280660f, -0.02379874f, 
    -0.09852431f, 0.01222794f, -0.15046324f, 0.03957405f, -0.04565240f, 0.04167546f, 0.05796957f, 0.05747376f, 
    -0.06889146f, -0.03223612f, 0.09685606f, -0.10907796f, 0.02821606f, -0.11557702f, -0.18982469f, -0.07270280f, 
    0.06668290f, 0.00317057f, 0.01880468f, 0.03915772f, -0.08227535f, -0.32004881f, -0.22902195f, -0.01610171f, 
    -0.02253959f, 0.04962370f, -0.04436885f, 0.15802155f, 0.10178683f, -0.01620701f, 0.06811619f, -0.03526272f, 
    0.30803317f, -0.39235452f, -0.25066435f, -0.08677238f, 0.00114620f, -0.03931353f, -0.00108605f, -0.02937211f, 
    0.04827670f, 0.00626420f, -0.02665028f, 0.01950334f, 0.05842660f, 0.06100630f, -0.07256770f, -0.09799599f, 
    -0.00916871f, -0.03568655f, 0.01619338f, 0.00186060f, -0.14863709f, -0.16938256f, 0.01786193f, -0.07868157f, 
    0.03408236f, -0.08271120f, 0.01634242f, -0.05791862f, -0.02407933f, -0.03451338f, -0.17799549f, 0.02821969f, 
    0.07589263f, 0.00815138f, 0.00095142f, 0.02653621f, 0.02516945f, 0.06183761f, 0.02102954f, -0.03391787f, 
    -0.01588789f, -0.01480504f, 0.01037201f, -0.02766954f, -0.06284746f, -0.05408786f, -0.06690566f, -0.09298894f, 
    -0.27983811f, -0.36381784f, 0.01305522f, -0.07816590f, -0.07079551f, -0.09182405f, -0.08251382f, -0.00924765f, 
    -0.06207960f, -0.07908036f, 0.05651389f, -0.12954541f, -0.11660136f, 0.21582721f, 0.22812782f, 0.06040639f, 
    0.06342836f, -0.12202566f, 0.04505000f, 0.06599361f, 0.02018744f, -0.08154693f, -0.00514268f, 0.01895404f, 
    -0.26202211f, -0.11939956f, -0.33379015f, 0.17942575f, -0.03243873f, -0.14051715f, -0.02085035f, -0.05855150f, 
    0.01896823f, 0.01252889f, 0.08178578f, 0.02284952f, -0.20753945f, 0.26426095f, 0.00242849f, 0.13320123f, 
    -0.14247127f, -0.04759688f, 0.05831920f, 0.07961886f, -0.02604169f, -0.08679087f, 0.03621094f, 0.02087099f, 
    0.05699202f, -0.09062140f, 0.07135553f, -0.09165394f, -0.00316242f, -0.03645716f, -0.05738812f, -0.03204855f, 
    0.01134042f, -0.03713231f, -0.07995066f, -0.05757853f, 0.04976390f, 0.00293765f, 0.00555213f, 0.00304652f, 
    -0.02440457f, -0.01882192f, 0.01942166f, -0.00329650f, -0.00332175f, -0.05602488f, 0.00270239f, 0.01415750f, 
    0.02383607f, 0.03587781f, 0.19910608f, -0.11897023f, 0.05161166f, -0.05314330f, 0.00523225f, -0.03004261f, 
    0.06078849f, 0.02220539f, 0.09385739f, 0.03705059f, -0.37789592f, -0.41313010f, -0.42495275f, -0.22151160f, 
    -0.07986952f, -0.10549997f, 0.01390054f, -0.16772486f, -0.10190089f, -0.02562827f, 0.01374821f, 0.00978351f, 
    0.49060589f, -0.24395943f, -0.22923405f, -0.23326099f, -0.03856934f, -0.04482055f, -0.13702105f, 0.08175159f, 
    0.07748386f, -0.12435617f, -0.02159763f, 0.00425149f, 0.36207387f, -0.46432531f, 0.25880361f, -0.31167766f, 
    -0.06164502f, -0.09104708f, -0.10927305f, 0.39706582f, 0.00984828f, 0.03346591f, -0.05500416f, -0.06319065f, 
    0.39047170f, -0.12654276f, -0.13052569f, -0.04699281f, -0.00385586f, -0.00895111f, -0.08016937f, 0.01132500f, 
    0.01867477f, -0.04914323f, -0.09920881f, -0.13932854f, 0.17330840f, -0.07335085f, -0.12316488f, -0.10772049f, 
    -0.09340373f, -0.05613764f, 0.03969992f, 0.09349911f, 0.01332787f, 0.07532736f, 0.10846844f, 0.00459007f, 
    0.11665790f, 0.07030386f, -0.15169583f, 0.09933221f, 0.03772495f, -0.00557909f, 0.03485385f, 0.03212643f, 
    0.11456276f, 0.10031600f, 0.05464787f, -0.16590473f, -0.42604193f, -0.14149947f, 0.08992064f, 0.57280058f, 
    -0.22717217f, 0.04142512f, 0.03374570f, -0.06056710f, -0.09763891f, 0.04949020f, -0.04682249f, -0.02863275f, 
    -0.00040577f, 0.06653789f, -0.03201592f, -0.03916280f, -0.01011773f, 0.03393709f, -0.00662942f, 0.00813620f, 
    -0.07475581f, -0.03768265f, -0.00551803f, 0.01441715f, -0.04852130f, 0.13895850f, 0.00528352f, 0.01115930f, 
    -0.07092226f, 0.09825657f, 0.19542758f, -0.00146654f, -0.11286146f, -0.01835084f, 0.02821451f, 0.00588070f, 
    -0.04440144f, -0.24700543f, -0.17545111f, -0.32544106f, 0.05521907f, 0.09341922f, 0.10617319f, 0.18476854f, 
    -0.03972983f, -0.00182797f, 0.06711289f, 0.05751329f, 0.46694857f, -0.48053691f, -0.17919442f, -0.21459767f, 
    0.03275546f, -0.02122773f, -0.02556908f, 0.02483661f, 0.09787409f, -0.01356243f, 0.07819685f, 0.04621811f, 
    -0.02449598f, 0.03028281f, -0.17821956f, 0.00481399f, -0.17453097f, 0.08871993f, -0.04074193f, -0.15705539f, 
    -0.00715291f, 0.11189587f, 0.03804795f, 0.02146612f, -0.16226055f, 0.17289604f, -0.24124026f, 0.03156472f, 
    -0.00592219f, 0.07148495f, 0.07173773f, -0.02998613f, -0.09416235f, 0.08125107f, -0.05680931f, -0.14336836f, 
    -0.06540929f, 0.01657252f, 0.00639680f, 0.01547647f, 0.04986892f, -0.06785521f, -0.01483109f, -0.05116785f, 
    0.02949237f, -0.13205080f, -0.02223883f, 0.01093408f, 0.12213514f, -0.17867476f, -0.01680567f, 0.42613003f, 
    0.02874904f, 0.07477646f, 0.08056929f, -0.11317650f, 0.00585863f, 0.01841723f, 0.00407221f, 0.03290709f, 
    0.12770119f, -0.28952605f, -0.17604424f, -0.04959335f, 0.01129174f, -0.10159796f, -0.01929685f, 0.05718548f, 
    0.02863689f, -0.02508193f, 0.06491093f, -0.02507281f, 0.03066775f, 0.03388317f, -0.08555509f, -0.00968075f, 
    0.04535931f, 0.09193803f, -0.03768282f, -0.05561556f, -0.06748774f, 0.05632477f, 0.02764080f, -0.00590047f, 
    0.33431756f, -0.15328524f, 0.02881158f, -0.22267647f, 0.03200348f, -0.06801993f, -0.08197740f, 0.03337098f, 
    0.05472089f, 0.10148442f, -0.01500561f, 0.13071840f, -0.16708601f, 0.06553087f, -0.02580738f, 0.00480020f, 
    -0.06038269f, 0.06130210f, -0.07675342f, -0.00947341f, 0.02636399f, 0.02018932f, 0.07353069f, 0.10695498f, 
    -0.27396598f, -0.01732093f, 0.05038289f, 0.14199570f, 0.02182983f, 0.08266357f, 0.01362827f, 0.08251627f, 
    -0.41672143f, -0.06606799f, -0.23179351f, -0.31664413f, 0.03729592f, 0.00350078f, -0.07702973f, -0.05320383f, 
    0.09301449f, 0.01330279f, -0.01540405f, 0.03776390f, -0.00127943f, 0.01057449f, 0.08166905f, 0.17294417f, 
    -0.24974540f, 0.02620040f, -0.03453846f, 0.29544038f, 0.08229402f, 0.03043017f, 0.08061603f, 0.04613879f, 
    0.04464984f, 0.00892819f, 0.07459853f, -0.04087425f, -0.43125814f, 0.16593815f, 0.14232942f, -0.01804221f, 
    -0.06701065f, -0.11816004f, -0.04393306f, -0.12065252f, -0.05742107f, -0.04159454f, -0.11206564f, -0.08060891f, 
    -0.16120805f, 0.09344415f, 0.05314844f, 0.02706397f, -0.00917343f, -0.08939145f, -0.02769450f, -0.02323134f, 
    -0.03542997f, 0.22917636f, -0.27237031f, -0.03642017f, -0.15601067f, -0.34574223f, -0.25087303f, 0.38894674f, 
    0.05366704f, -0.01524278f, 0.16855176f, 0.13426735f, -0.14560321f, 0.01019037f, 0.00520519f, 0.04313560f, 
    0.16725384f, -0.10108296f, -0.20635509f, 0.03547545f, 0.04473061f, -0.01745789f, 0.13780855f, -0.02131412f, 
    0.12184101f, 0.00042193f, 0.11527672f, 0.09189761f, 0.02946520f, -0.16885740f, 0.04491121f, 0.05931390f, 
    0.21262227f, 0.08646929f, 0.07550903f, 0.03578078f, 0.10459157f, 0.07996901f, 0.15386312f, 0.16070464f, 
    -0.14405809f, 0.08667237f, -0.18098763f, -0.18122862f, -0.02093151f, -0.03253241f, 0.03072168f, -0.06937401f, 
    -0.18740334f, -0.16689284f, -0.20430072f, -0.13409507f, -0.22779098f, -0.00899076f, -0.03846503f, 0.13287221f, 
    -0.00365355f, 0.00188488f, -0.04790722f, 0.04219230f, -0.19428211f, 0.00332325f, -0.15508349f, -0.32439581f, 
    0.00797585f, -0.08386613f, -0.18708324f, -0.26653895f, 0.06211428f, 0.04896574f, 0.11932035f, 0.00509996f, 
    0.00754359f, -0.09398455f, -0.03054105f, -0.16169639f, -0.09221206f, -0.09255957f, -0.00059296f, 0.02964608f, 
    0.04151302f, 0.13535300f, 0.05880316f, 0.03084645f, -0.05245034f, -0.05749824f, 0.08731209f, -0.15957686f, 
    0.60752058f, 0.27966946f, -0.33646801f, 0.02703237f, -0.00252996f, -0.05549820f, 0.10916918f, -0.20290880f, 
    0.19399488f, 0.12210145f, 0.13293718f, 0.12665638f, -0.03203871f, -0.31403691f, -0.10662077f, 0.10767562f, 
    -0.10634786f, -0.05854755f, -0.02299850f, 0.10422440f, 0.00626036f, -0.12062339f, 0.06068498f, -0.05879747f, 
    0.29173979f, 0.11903256f, -0.29536670f, -0.08224282f, -0.05370051f, -0.07534091f, 0.11597438f, -0.26057613f, 
    -0.04625310f, -0.06685105f, -0.08357558f, -0.11844239f, -0.34155965f, 0.05390207f, 0.17951734f, 0.07422170f, 
    -0.06228840f, 0.05978092f, 0.01445652f, 0.02205635f, 0.03594263f, 0.01041487f, 0.07934120f, 0.10089001f, 
    -0.03250510f, -0.05098404f, -0.11834966f, -0.08661704f, 0.07908178f, -0.15048072f, 0.03335871f, 0.03127831f, 
    0.10430791f, 0.10628612f, 0.09664404f, 0.17432937f, 0.02036203f, -0.28586757f, 0.13949984f, -0.06762043f, 
    -0.02466850f, 0.07414986f, -0.07259845f, 0.03295090f, -0.00796719f, 0.11059009f, -0.04724430f, 0.03834781f, 
    -0.00266141f, 0.08396629f, 0.11719432f, -0.04311849f, -0.12409373f, -0.03651536f, -0.00592392f, -0.05228244f, 
    0.05723526f, -0.02941627f, 0.09194462f, 0.05183055f, 0.21623884f, -0.07585596f, 0.11114292f, -0.20652471f, 
    -0.10639110f, -0.00427982f, -0.17783670f, -0.05862953f, -0.13550955f, 0.06348741f, -0.03136135f, 0.00726698f, 
    0.17184773f, -0.26139343f, -0.67736381f, -0.31101388f, -0.21275663f, 0.08927923f, -0.03692427f, 0.11887296f, 
    0.04729429f, -0.02177666f, 0.04682929f, 0.02400702f, 0.34986123f, 0.18534204f, 0.00436403f, -0.26443815f, 
    -0.07615653f, -0.12678793f, -0.06123624f, -0.06232003f, 0.05609168f, -0.05267727f, 0.04447285f, 0.07967349f, 
    -0.12801227f, -0.29216284f, -0.32991803f, 0.04047083f, 0.03746396f, 0.03667772f, 0.06244696f, -0.08787788f, 
    -0.01210489f, -0.03656301f, 0.08433925f, 0.03505722f, 0.22613180f, -0.34440145f, -0.31273660f, 0.00121138f, 
    -0.11128129f, 0.17902581f, 0.13718237f, -0.01117307f, 0.01979870f, 0.00319140f, 0.06512362f, 0.04691017f, 
    -0.18124159f, 0.11012613f, 0.04250364f, 0.04140872f, 0.01316438f, 0.00793663f, -0.10606086f, -0.01660597f, 
    -0.23513608f, -0.03321439f, -0.05856683f, -0.10476904f, 0.07939766f, -0.38433534f, -0.41105732f, 0.07223970f, 
    -0.04805305f, 0.12823190f, -0.01556111f, 0.08719944f, -0.02770785f, -0.10463562f, -0.05639553f, 0.00958763f, 
    -0.03003771f, -0.19146092f, -0.27135378f, -0.14644022f, -0.02128681f, 0.02030381f, 0.06082303f, -0.10604864f, 
    0.02866219f, -0.09825069f, 0.01539296f, -0.15286456f, 0.04962289f, -0.20965777f, -0.23553464f, -0.08622947f, 
    -0.00858491f, 0.03090803f, 0.03392189f, 0.00145402f, -0.13979144f, 0.09430319f, -0.06057594f, -0.22589965f, 
    -0.22048472f, -0.22197047f, -0.21171598f, 0.02052147f, -0.02360788f, 0.10009285f, -0.04579566f, 0.15098721f, 
    -0.09038799f, -0.20145966f, -0.12181367f, -0.09617614f, 0.28905070f, -0.14028631f, -0.36928672f, -0.23014827f, 
    0.19230679f, -0.05342234f, 0.05742234f, -0.02163963f, 0.17150806f, 0.08972435f, 0.10949514f, 0.15715677f, 
    -0.34706268f, -0.14838974f, 0.17432740f, 0.31106919f, -0.15089837f, 0.02187367f, -0.08626309f, -0.01923689f, 
    0.16023484f, 0.07441416f, 0.06537455f, 0.12466439f, -0.11694910f, 0.03027498f, -0.04446399f, -0.00765559f, 
    0.14848197f, -0.02087720f, 0.03371724f, -0.08208157f, 0.04225119f, 0.03852176f, 0.00891538f, 0.01727992f, 
    0.06181389f, -0.02995947f, 0.11375184f, -0.03269279f, 0.15809435f, -0.04723651f, 0.05440058f, -0.01060207f, 
    0.05351952f, 0.03679524f, 0.06426988f, -0.03395673f, -0.23806036f, -0.27191940f, -0.17693959f, -0.10347000f, 
    -0.05845597f, 0.03590456f, -0.04302351f, 0.08133978f, -0.03376276f, 0.07934158f, -0.15660691f, -0.14582112f, 
    -0.28738806f, -0.35124865f, -0.12739722f, 0.06921913f, -0.03507130f, 0.09857082f, 0.11709186f, 0.03142004f, 
    0.13528866f, -0.05126592f, 0.12517469f, -0.08075256f, -0.26033103f, -0.10012142f, 0.13628696f, -0.01064973f, 
    -0.02526992f, 0.06008561f, 0.02320392f, 0.03100074f, 0.08083837f, 0.05554573f, 0.13532835f, 0.16134419f, 
    -0.00866635f, -0.14484079f, -0.07913335f, -0.01221779f, 0.02269499f, 0.07060710f, 0.08268003f, 0.01183542f, 
    -0.07372686f, -0.36784980f, 0.08511430f, -0.10151415f, -0.09560826f, -0.07622609f, -0.04316108f, -0.12804469f, 
    -0.05250699f, 0.01978545f, -0.03215218f, -0.03328754f, 0.00333943f, -0.08571140f, 0.04734494f, 0.04214128f, 
    0.20234062f, 0.13053845f, -0.01773410f, -0.02745192f, 0.20779490f, -0.02837006f, 0.14918211f, 0.02048791f, 
    -0.11148172f, 0.02976513f, 0.18318936f, 0.12516442f, -0.30937144f, 0.08089285f, 0.00269579f, -0.10520549f, 
    0.00854991f, -0.01312485f, -0.03667767f, -0.26654884f, 0.03149292f, -0.01966113f, 0.08583375f, 0.02275435f, 
    -0.27051651f, -0.55931187f, -0.38770470f, -0.02905193f, 0.09072731f, 0.13017905f, 0.06709585f, 0.06388438f, 
    0.02957626f, 0.02498409f, -0.01598194f, 0.11923190f, -0.55429530f, 0.05131592f, 0.21830574f, 0.24735013f, 
    0.15449050f, -0.06698702f, -0.15908062f, 0.12370458f, -0.02351635f, -0.03280661f, 0.08884069f, -0.06897366f, 
    0.23257300f, 0.14160243f, -0.00366635f, -0.24044034f, 0.09896436f, -0.07611617f, 0.05098726f, -0.04245334f, 
    -0.04051785f, -0.03655151f, 0.05353915f, 0.03451952f, -0.21517634f, 0.01230296f, -0.03001425f, -0.04557813f, 
    -0.00715622f, -0.04831317f, 0.00057015f, -0.06196058f, -0.05494072f, -0.03022658f, -0.01689755f, -0.00220211f, 
    -0.51748449f, -0.04036478f, 0.00573126f, 0.07716206f, -0.12098829f, -0.05383841f, -0.03512918f, -0.35762221f, 
    -0.12176608f, -0.13121945f, -0.05340014f, -0.01780614f, -0.26173943f, -0.47285414f, 0.22498026f, -0.09024610f, 
    0.01971777f, 0.25116906f, 0.13828157f, 0.02286026f, 0.06111169f, 0.01422144f, 0.02240440f, -0.02156698f, 
    0.04592692f, -0.20780204f, -0.19730602f, 0.05770550f, 0.09793732f, -0.00931115f, 0.15234059f, 0.07076782f, 
    0.04367686f, 0.08614052f, 0.02505036f, 0.00364378f, -0.12946463f, -0.09409301f, -0.44806975f, -0.23001203f, 
    0.01314843f, -0.07625709f, 0.20801604f, -0.09967563f, 0.00617119f, -0.05163223f, -0.00487891f, 0.00534819f, 
    -0.26165798f, -0.03525618f, -0.18498720f, 0.03216756f, -0.09453170f, 0.07840533f, -0.03284438f, 0.08665948f, 
    0.18523781f, 0.06737541f, 0.05054939f, -0.07178400f, -0.22611463f, -0.17050166f, -0.23384336f, 0.02825888f, 
    0.05194877f, 0.08432581f, 0.09074045f, 0.06115667f, 0.07780983f, 0.08777047f, 0.04019024f, 0.10013940f, 
    -0.07944316f, -0.07345326f, -0.06546923f, -0.03536225f, -0.03558004f, -0.03919295f, 0.03046121f, 0.02999269f, 
    -0.20739624f, 0.02930384f, -0.31918755f, -0.30704033f, 0.28784087f, 0.04556701f, -0.14797872f, -0.16300553f, 
    0.23994437f, 0.04354398f, -0.05000388f, 0.25188762f, 0.19694287f, 0.04991884f, 0.03928570f, 0.09834866f, 
    0.00443126f, -0.02365124f, -0.00806504f, -0.02893515f, 0.04316819f, -0.04372661f, 0.02333888f, -0.04525407f, 
    0.10579563f, 0.11425307f, 0.05473567f, 0.08114953f, -0.11052784f, -0.29252911f, 0.06206978f, 0.09132358f, 
    0.03845357f, 0.01712834f, -0.10992682f, -0.07753656f, 0.01654958f, 0.05206226f, -0.01904506f, 0.12805651f, 
    -0.02251044f, -0.59863567f, -0.26606035f, 0.08337404f, -0.04515067f, 0.21100186f, 0.17905045f, -0.01514871f, 
    -0.05702941f, 0.06054529f, -0.01362615f, -0.02529412f, -0.26497003f, -0.28580546f, -0.29673821f, -0.10799889f, 
    0.01696198f, 0.06907517f, 0.07799024f, 0.02696758f, 0.04899344f, -0.04270128f, -0.07668933f, -0.10776033f, 
    0.24235751f, 0.13589536f, -0.06934115f, -0.03218938f, -0.03472665f, -0.01994851f, -0.00842633f, 0.13835910f, 
    0.15658239f, -0.11345241f, 0.14058591f, 0.02457715f, -0.02737770f, 0.00541719f, 0.09352820f, 0.02049306f, 
    -0.06774499f, -0.08506269f, -0.08967930f, -0.04994327f, 0.13506646f, 0.06608430f, 0.14456490f, 0.16054145f, 
    -0.19920179f, 0.00046087f, 0.07468403f, 0.04406438f, 0.01846658f, -0.06123216f, -0.04716334f, -0.00787518f, 
    -0.00933456f, -0.01661967f, -0.05160137f, 0.01904925f, 0.57197458f, -0.22051033f, -0.34249130f, -0.08141733f, 
    0.03705040f, -0.01382623f, 0.06636074f, -0.09786573f, 0.06299757f, 0.05287885f, 0.20946549f, -0.08726416f, 
    0.11239561f, -0.12893966f, 0.02281479f, 0.01775145f, -0.03408313f, 0.02033454f, 0.02758225f, 0.12790491f, 
    -0.01886458f, 0.03575766f, -0.07353520f, -0.44959128f, 0.04555874f, 0.03623763f, 0.04118973f, -0.03029318f, 
    0.05621614f, 0.00548092f, -0.00287921f, 0.08074421f, -0.00074472f, -0.03517732f, -0.01246332f, 0.03726722f, 
    -0.06349117f, -0.25206634f, -0.10198598f, 0.19420040f, -0.08327293f, -0.02324568f, 0.05462245f, -0.11002874f, 
    -0.02482265f, 0.02250136f, -0.03572577f, 0.03245760f, -0.25688243f, 0.08956092f, 0.00761528f, -0.11622373f, 
    0.03872576f, 0.09185109f, 0.12288017f, -0.06277704f, 0.07718902f, 0.06837212f, -0.04055290f, 0.01119858f, 
    -0.19125423f, 0.21913812f, 0.17394248f, -0.20441236f, 0.05481504f, -0.10170889f, 0.05107661f, 0.07626785f, 
    0.06569528f, 0.17030071f, 0.09555167f, 0.14249285f, 0.26805049f, -0.09681781f, 0.20197292f, -0.09353220f, 
    0.13691027f, -0.17728885f, 0.04041260f, 0.00202450f, -0.07027594f, -0.06115535f, -0.09452650f, -0.09555840f, 
    -0.30574924f, -0.09703121f, -0.48847258f, -0.54323810f, -0.15554747f, 0.01421117f, -0.00302169f, -0.01774700f, 
    0.04460148f, -0.09434128f, -0.01895087f, -0.04329575f, -0.02412790f, -0.07551327f, -0.18296555f, 0.15240547f, 
    0.14238773f, 0.08236755f, 0.15047993f, 0.12242223f, 0.05158250f, -0.00773000f, 0.02182713f, -0.04052469f, 
    -0.09086432f, 0.00171560f, 0.11819688f, 0.15101184f, -0.08863565f, 0.07166938f, -0.01928142f, -0.08741899f, 
    0.06430004f, 0.12933002f, 0.02794692f, 0.01623754f, 0.09431669f, 0.31902128f, 0.23641504f, -0.81914401f, 
    0.07972183f, -0.18611948f, 0.08363862f, -0.00897649f, 0.00094626f, -0.02729498f, 0.04181543f, -0.02822835f, 
    -0.11156737f, 0.14804980f, -0.12246458f, 0.19947053f, 0.04699435f, -0.15686458f, -0.11257233f, -0.15826231f, 
    -0.05011407f, -0.06921662f, -0.27042615f, -0.02366713f, 0.27396920f, -0.18621141f, -0.02460708f, -0.30751011f, 
    -0.07716583f, -0.12222505f, -0.02490904f, 0.00988629f, -0.18410583f, 0.04563674f, -0.08528482f, 0.02116068f, 
    -0.10627060f, -0.10409815f, -0.00642659f, 0.16167498f, 0.08245820f, 0.13581085f, 0.04602035f, -0.12603554f, 
    0.16740163f, 0.04120323f, 0.12631412f, 0.05017374f, -0.13161632f, 0.12906364f, -0.20953082f, 0.03050913f, 
    0.00409391f, 0.00668398f, 0.09362424f, 0.06070797f, 0.11211106f, 0.04434998f, 0.14289664f, 0.19905883f, 
    0.06428633f, -0.05127154f, 0.18838227f, 0.53602916f, 0.00577457f, -0.05333326f, -0.11934496f, -0.07433014f, 
    0.01050990f, 0.01838505f, 0.11505402f, 0.09252264f, 0.12231702f, -0.03672954f, -0.35673425f, 0.18140493f, 
    0.06273431f, -0.10478745f, 0.11187017f, 0.07383688f, 0.03021087f, 0.03124016f, 0.05236386f, -0.01410707f, 
    -0.76665264f, -0.43791267f, -0.41264871f, -0.16981101f, 0.12915325f, 0.01831949f, -0.01557135f, 0.01731877f, 
    -0.03167246f, -0.06056311f, -0.03396038f, -0.11330843f, -0.24550281f, 0.17327598f, 0.48830536f, -0.29959530f, 
    -0.10384487f, -0.29894078f, 0.16314840f, 0.06949838f, -0.07118435f, 0.00717794f, 0.02747797f, -0.03932402f, 
    -0.25036219f, -0.17736332f, 0.23253904f, -0.20166452f, -0.12188566f, -0.05643226f, -0.03638088f, 0.01118482f, 
    0.07193280f, 0.07845455f, 0.02523085f, -0.00057530f, -0.09129103f, -0.00033267f, 0.16884604f, -0.37988296f, 
    -0.02562601f, -0.02433758f, 0.09021835f, 0.00380433f, -0.16201669f, 0.01783601f, -0.11026215f, -0.06258204f, 
    0.04986428f, -0.21501300f, 0.17519844f, 0.13038495f, -0.00796793f, -0.01320885f, -0.12369811f, -0.01760243f, 
    -0.09063021f, -0.22828695f, -0.13997918f, 0.02688421f, 0.15614551f, -0.35806692f, 0.22551690f, -0.28604659f, 
    -0.09860987f, 0.10084953f, -0.26396203f, -0.17096092f, -0.03765023f, 0.06284953f, -0.18383139f, -0.15457609f, 
    -0.01153941f, -0.41850302f, 0.10258596f, -0.07902904f, -0.00665529f, 0.04730726f, 0.12796456f, 0.09435990f, 
    -0.11376782f, -0.01929106f, -0.07568030f, -0.04387303f, 0.28790444f, -0.54530698f, -0.11672188f, -0.11020464f, 
    0.01824799f, 0.01535531f, -0.21360135f, -0.09750051f, -0.03391885f, -0.05610470f, -0.03898328f, 0.03237460f, 
    -0.35503584f, -0.29048735f, -0.10242533f, 0.51057380f, -0.01181302f, 0.08299444f, -0.27797773f, 0.02305737f, 
    0.03239833f, -0.21191522f, -0.04266128f, -0.01227265f, -0.21759669f, -0.69587517f, 0.22455107f, -0.03151342f, 
    0.00595008f, 0.10808603f, -0.01458270f, 0.01281969f, -0.18013477f, 0.05947531f, 0.00516273f, 0.05565596f, 
    0.08565443f, -0.20754978f, 0.08586516f, -0.14620154f, -0.09656535f, -0.08333702f, -0.01081836f, 0.06411410f, 
    0.01698007f, -0.04736613f, 0.03550939f, 0.04294014f, -0.34282506f, 0.19113418f, -0.18484041f, -0.13433547f, 
    -0.15579922f, 0.09349898f, -0.07251097f, 0.08884985f, 0.00538905f, -0.08852135f, 0.01550976f, 0.01324020f, 
    -0.00847938f, 0.04733326f, -0.34246579f, 0.01783656f, 0.06213597f, 0.12834951f, 0.18461783f, -0.01845291f, 
    -0.01086354f, 0.00046252f, -0.05427495f, 0.02154296f, 0.24481355f, -0.20413291f, -0.19238658f, 0.01004561f, 
    -0.15834607f, -0.02568523f, -0.05837248f, 0.12988248f, 0.06743799f, 0.00495929f, 0.05042021f, 0.07361366f, 
    -0.06806012f, 0.11304317f, 0.13300876f, -0.19755575f, 0.02344045f, -0.03674165f, 0.02229372f, 0.09760936f, 
    0.02614755f, 0.06913238f, 0.06293411f, -0.01254904f, -0.30440885f, 0.16276428f, 0.01799598f, 0.28905621f, 
    0.04763052f, 0.01897997f, -0.07529032f, -0.10356708f, 0.02643464f, 0.11815929f, 0.06304529f, 0.04402821f, 
    -0.04643982f, 0.20633776f, 0.15719777f, -0.21565211f, 0.02436653f, -0.15126176f, 0.00281851f, 0.07069023f, 
    -0.05717533f, -0.01249279f, 0.01006370f, -0.00647655f, 0.12185558f, 0.07503346f, 0.41151235f, 0.21327244f, 
    0.04988027f, -0.14349465f, -0.06394407f, -0.07518735f, -0.05409633f, -0.04221495f, 0.02126671f, 0.06216041f, 
    -0.00580277f, -0.60263783f, 0.02203267f, -0.31926119f, 0.02704341f, -0.04219953f, -0.16187572f, 0.08280365f, 
    -0.02820189f, -0.05733752f, -0.05907746f, 0.03110916f, 0.28934154f, -0.02245993f, -0.05570731f, -0.15131256f, 
    0.01919599f, 0.01687990f, -0.01463471f, 0.03729014f, -0.02549219f, -0.00517287f, -0.13912798f, -0.08260882f, 
    0.08210234f, -0.23162600f, 0.06074636f, -0.02632883f, 0.11532821f, 0.03377119f, 0.15845963f, -0.09876779f, 
    -0.00673412f, -0.03172285f, -0.06364345f, -0.03569551f, -0.13124676f, 0.15573964f, -0.08884650f, 0.02628178f, 
    0.11968249f, 0.07782419f, -0.00813199f, 0.00300923f, 0.06374015f, 0.03873382f, 0.06582745f, -0.00547598f, 
    0.27597085f, 0.12612145f, 0.26120579f, -0.09839050f, 0.08504853f, -0.12553106f, -0.14559604f, -0.08934666f, 
    -0.08400141f, 0.05052434f, 0.07533795f, 0.06612272f, 0.08911480f, 0.03855231f, 0.25627965f, -0.06968825f, 
    0.13604575f, -0.12823604f, -0.15599927f, -0.12887646f, 0.08619240f, 0.06479302f, 0.03856309f, 0.01461265f, 
    0.29237899f, 0.00167606f, 0.10121225f, -0.27380157f, -0.16928872f, -0.04504463f, -0.10539844f, -0.12015002f, 
    -0.19577563f, -0.06635658f, 0.09363569f, 0.05134220f, -0.02693170f, -0.08803560f, 0.09534975f, 0.11232292f, 
    0.15959707f, 0.07048544f, 0.01942150f, 0.07158576f, 0.13008092f, 0.06783947f, 0.04529436f, 0.05372366f, 
    -0.10026640f, 0.15850131f, 0.25257161f, -0.12933932f, -0.00828626f, -0.13665175f, 0.02075531f, -0.07391547f, 
    -0.02979354f, 0.09770272f, 0.17846051f, 0.02613566f, 0.32169467f, -0.16426712f, -0.11943529f, 0.02093363f, 
    0.08365178f, 0.00638167f, 0.09138776f, 0.11944890f, 0.02607829f, 0.04373764f, 0.04348822f, -0.04481296f, 
    0.07259628f, 0.09450014f, 0.14335951f, -0.18400955f, 0.06736187f, -0.13551660f, -0.02204437f, 0.05845761f, 
    -0.00152117f, 0.01125096f, -0.02635924f, 0.00800082f, -0.33846790f, 0.46038133f, -0.74855173f, 0.15910500f, 
    0.02561016f, -0.15854122f, 0.22495243f, -0.02387668f, 0.07801184f, 0.00452761f, -0.06232164f, -0.00369095f, 
    -0.09020587f, 0.06014717f, -0.17126366f, 0.17704701f, 0.10099924f, 0.04646823f, 0.08610880f, -0.04981964f, 
    0.15653463f, -0.04912133f, 0.05226618f, 0.05034413f, -0.02733636f, -0.08232515f, 0.00056667f, 0.02870751f, 
    0.12717733f, 0.04455291f, 0.06662726f, 0.04672090f, 0.12957069f, 0.03267638f, 0.08132236f, -0.00994506f, 
    0.04770438f, -0.38325214f, 0.05570334f, -0.37473670f, 0.03492088f, 0.04082581f, 0.10389979f, 0.17952587f, 
    0.00393322f, -0.00288225f, -0.06100236f, 0.06717633f, 0.21618164f, -0.27974051f, 0.25855532f, -0.14740284f, 
    -0.07125793f, -0.10854501f, -0.08925115f, -0.07692044f, -0.15546018f, -0.01489386f, 0.03814049f, -0.00549109f, 
    0.12422134f, -0.23278461f, 0.20350032f, -0.04911957f, 0.10232338f, -0.11310461f, -0.15863214f, -0.12954681f, 
    0.11243130f, -0.05563742f, -0.03842208f, 0.10626568f, -0.39246356f, -0.26902860f, -0.37327719f, -0.26795775f, 
    -0.24574305f, 0.15131007f, -0.01650217f, 0.05579802f, 0.14794533f, -0.00931550f, 0.01691096f, -0.02684834f, 
    -0.29238847f, 0.33698198f, 0.01006691f, 0.14043228f, -0.04300810f, -0.12120342f, -0.15029369f, -0.07852264f, 
    -0.00376732f, -0.02948493f, 0.04606061f, -0.10859212f, 0.31199986f, 0.17480624f, 0.31228477f, 0.18740241f, 
    0.20482655f, -0.22710562f, -0.12228268f, -0.03852672f, -0.25871059f, -0.01576420f, -0.06964152f, -0.04043945f, 
    -0.04256651f, 0.15056507f, 0.15854959f, 0.01648507f, 0.00320658f, -0.00875261f, 0.01620056f, -0.04259880f, 
    0.16632557f, 0.09979921f, 0.03964968f, -0.01976362f, -0.19264804f, 0.18310735f, -0.38960803f, 0.22445387f, 
    0.03322581f, -0.16967754f, 0.01554317f, 0.14863367f, 0.07121382f, 0.02769789f, 0.08738652f, -0.10730193f, 
    -0.04405012f, -0.02026774f, -0.00404547f, 0.09046242f, 0.09495889f, -0.04280815f, 0.07778984f, 0.00250762f, 
    0.07834891f, -0.03448416f, -0.08007573f, -0.08817223f, 0.02795856f, -0.07057654f, -0.02664507f, -0.39534405f, 
    0.17565502f, -0.11077107f, 0.07782864f, -0.05992663f, -0.17883421f, -0.01573550f, 0.01681550f, 0.02980705f, 
    0.04052031f, 0.11245456f, -0.18721470f, -0.22240259f, -0.22431444f, -0.04677057f, -0.04420816f, 0.02060073f, 
    0.03606525f, -0.04975776f, 0.06214115f, -0.00564184f, 0.17541909f, 0.05511187f, 0.18371964f, 0.15233956f, 
    -0.10859216f, -0.03946218f, -0.13141246f, -0.15594794f, -0.02407742f, -0.01150858f, 0.01870836f, 0.09515952f, 
    -0.29714337f, 0.00547106f, -0.36893979f, -0.13556780f, 0.08611535f, 0.12684296f, 0.02849256f, -0.02819332f, 
    -0.04147415f, -0.09190255f, 0.00133275f, 0.00146408f, -0.02094501f, -0.02018782f, -0.07038727f, -0.17463680f, 
    0.17621922f, -0.00814554f, 0.04737771f, -0.02255843f, -0.16841146f, 0.02594316f, -0.02110913f, -0.05260973f, 
    -0.04997457f, 0.02287075f, -0.16006951f, 0.05468231f, 0.07916197f, -0.07140761f, 0.12059582f, -0.05191966f, 
    0.02388458f, 0.01322945f, 0.05600618f, -0.02458004f, -0.27993193f, -0.02137084f, 0.26865733f, 0.30661315f, 
    0.05738600f, -0.20927341f, -0.03282215f, -0.04726672f, 0.12879512f, 0.03853256f, -0.04453889f, 0.04677789f, 
    0.06304611f, 0.03467567f, 0.19021323f, 0.22228383f, 0.03168566f, 0.03181611f, -0.13612790f, -0.03974979f, 
    0.18061543f, 0.07153609f, 0.10417423f, 0.07232861f, -0.31459144f, 0.28391382f, -0.23167482f, -0.08304249f, 
    0.06369452f, -0.05117743f, -0.06817682f, -0.00086382f, 0.15806784f, -0.17739998f, -0.20248613f, 0.15174688f, 
    -0.14347859f, 0.14932914f, -0.20897900f, 0.08971930f, -0.00820889f, -0.09225354f, 0.03425444f, -0.02981333f, 
    -0.03734284f, 0.16127762f, -0.12476819f, 0.02186993f, -0.15385714f, 0.07909891f, 0.04445838f, -0.25726050f, 
    -0.19957079f, -0.12248152f, 0.00418199f, 0.05478596f, -0.11670980f, -0.08106784f, 0.13088010f, 0.09561928f, 
    -0.00598368f, 0.03930214f, 0.02337124f, 0.01821078f, 0.08503717f, -0.11380754f, 0.01082736f, 0.12521330f, 
    -0.18417734f, -0.34844336f, -0.40798825f, -0.32660353f, -0.06672764f, 0.20577279f, -0.19355185f, 0.06561779f, 
    0.01754014f, 0.00881814f, 0.08358829f, 0.02641247f, 0.04492807f, 0.11548406f, 0.06306482f, 0.26140314f, 
    0.18975694f, -0.16999935f, 0.09662227f, 0.37587178f, 0.07476795f, 0.13700932f, 0.03264692f, 0.01316956f, 
    -0.13334043f, -0.00603640f, -0.02062150f, -0.07011483f, -0.07093341f, -0.12647857f, -0.27508742f, -0.04538802f, 
    -0.21719472f, -0.07293382f, -0.05700737f, -0.24436969f, -0.10028148f, -0.03438855f, -0.02117670f, -0.10529183f, 
    0.18867545f, -0.08411417f, 0.09938339f, 0.11808195f, -0.06272238f, -0.01319148f, 0.11505400f, 0.05597785f, 
    -0.06155932f, -0.24501635f, -0.12771820f, -0.11967018f, -0.01226059f, -0.13909023f, 0.28381869f, 0.18908608f, 
    -0.09972060f, 0.00523919f, 0.16228075f, 0.10693558f, 0.07566521f, -0.03950633f, 0.05692791f, -0.10685920f, 
    0.01010459f, 0.08444441f, 0.39535001f, -0.30094537f, -0.23648894f, 0.06626738f, 0.16581009f, 0.00740058f, 
    0.17617624f, -0.06939533f, 0.13577381f, -0.01703071f, -0.03636265f, 0.06811240f, -0.18750018f, 0.14117792f, 
    -0.03172125f, 0.03831970f, 0.13988587f, 0.09836385f, 0.04011563f, 0.01113223f, 0.01870087f, 0.09725074f, 
    -0.21327661f, 0.12364957f, 0.01573766f, -0.18843351f, -0.13810442f, -0.06749260f, 0.02483692f, -0.01011507f, 
    -0.06279368f, -0.01203128f, -0.15649165f, -0.13222438f, 0.15741858f, -0.00536644f, 0.15865916f, 0.09116266f, 
    -0.07038902f, -0.10274015f, 0.08003517f, 0.09736849f, -0.15519468f, -0.15293053f, -0.24480365f, -0.23062257f, 
    -0.26116920f, 0.39358038f, -0.11610793f, 0.09405637f, -0.03787717f, 0.05741067f, 0.03928135f, 0.02125503f, 
    0.03815984f, -0.17306605f, -0.12291971f, -0.13957576f, 0.09305975f, 0.18829590f, 0.09510528f, 0.07173292f, 
    -0.01529787f, 0.05414126f, 0.04321494f, -0.02203878f, 0.10011363f, -0.00454899f, -0.11119568f, -0.06199100f, 
    -0.56181639f, -0.09814004f, 0.44587877f, 0.22137983f, -0.13275371f, 0.12217396f, -0.07709327f, 0.28303671f, 
    -0.06671873f, 0.01739404f, 0.15386416f, 0.05560110f, -0.20893151f, -0.23152061f, -0.11440811f, 0.01010442f, 
    0.07564805f, 0.05612679f, -0.04940460f, -0.00984930f, 0.00737950f, 0.06931716f, -0.04311827f, 0.04239568f, 
    -0.16836835f, -0.06358862f, -0.11650512f, -0.01394547f, 0.07692276f, 0.13337573f, -0.24160083f, -0.07219110f, 
    -0.07967167f, 0.03789986f, -0.04484958f, -0.12295225f, 0.07164406f, 0.03050070f, 0.19829667f, 0.09040266f, 
    -0.02416992f, -0.01103614f, -0.09745476f, 0.04898934f, 0.07240739f, 0.04756320f, 0.16043729f, 0.03953819f, 
    -0.16231185f, 0.28088757f, -0.11392721f, -0.07811317f, 0.04894213f, 0.00898042f, 0.11780218f, -0.06170995f, 
    -0.13470538f, 0.18727703f, 0.01320762f, 0.24186690f, -0.16285579f, 0.27789962f, 0.04353036f, 0.19396314f, 
    0.06316244f, -0.14687246f, 0.14353153f, -0.09105007f, -0.08523183f, 0.10219821f, 0.09726170f, 0.15003003f, 
    0.01295737f, -0.02237880f, 0.00283956f, 0.17090015f, -0.03789819f, 0.01670372f, 0.06991469f, 0.07140898f, 
    0.10326451f, -0.04337101f, 0.01475101f, 0.07270332f, -0.26449591f, -0.03426633f, -0.08546448f, -0.03808412f, 
    -0.08118026f, 0.14325386f, 0.11097198f, -0.08545326f, 0.00964122f, 0.16497463f, 0.12655845f, 0.03938346f, 
    -0.16956620f, 0.47096002f, -0.00502711f, 0.11180639f, -0.01891427f, 0.11685877f, 0.02226005f, 0.01178767f, 
    -0.03127498f, 0.12535611f, -0.07760701f, 0.11963488f, -0.47968534f, -0.01547550f, -0.24151348f, 0.13684201f, 
    -0.07001179f, 0.05568646f, 0.10171877f, -0.08227395f, 0.02797485f, -0.14295307f, -0.00460765f, -0.06666108f, 
    -0.11066974f, -0.01775055f, -0.14325579f, 0.18006469f, -0.01591504f, -0.13488588f, 0.12947229f, 0.04767755f, 
    0.05752754f, 0.06095574f, 0.08528935f, 0.07017034f, 0.01770734f, 0.21918999f, -0.00050000f, 0.01761268f, 
    -0.18803400f, 0.11177404f, 0.15140215f, 0.02037668f, -0.13052818f, 0.13569465f, -0.12967214f, -0.06449483f, 
    -0.00577492f, -0.17441042f, -0.18585865f, -0.01494154f, -0.14327817f, -0.27685103f, 0.01475809f, -0.15539604f, 
    -0.04085997f, 0.13414046f, -0.16780439f, -0.16382867f, -0.15773554f, -0.17661466f, -0.15022971f, 0.20320639f, 
    0.01576657f, -0.20808671f, 0.04214331f, 0.09463588f, -0.07067347f, 0.05637032f, 0.04199938f, -0.11201056f, 
    -0.06727438f, -0.25533214f, -0.04487335f, 0.08625669f, 0.04027285f, -0.00364092f, -0.16551982f, -0.06907141f, 
    0.06376830f, 0.02806808f, -0.11734532f, -0.23353599f, 0.42971569f, 0.02552353f, 0.26737374f, -0.18653935f, 
    -0.05530051f, 0.05390376f, 0.01010085f, 0.01370290f, -0.06444889f, -0.19789259f, -0.40492725f, -0.26300138f, 
    -0.22286522f, -0.10987822f, 0.10181204f, 0.22606251f, -0.09398989f, 0.03122755f, -0.08943692f, 0.11842598f, 
    -0.02992400f, -0.06731503f, -0.06798702f, 0.02924910f, -0.47442600f, 0.22841644f, -0.13055731f, -0.03306664f, 
    0.03032724f, 0.12608716f, -0.11931682f, 0.02134182f, 0.00600317f, -0.10802357f, 0.11128611f, -0.12211668f, 
    -0.28961769f, 0.24725081f, 0.27030662f, 0.22642460f, 0.05004257f, 0.03028486f, -0.09914479f, 0.08928890f, 
    -0.09990420f, -0.00995280f, -0.04870987f, 0.21197958f, -0.04275025f, -0.18829514f, -0.22022922f, 0.07791284f, 
    0.01354871f, 0.07136271f, -0.10401151f, 0.03650997f, -0.07912141f, -0.03434926f, 0.00568861f, -0.04038106f, 
    -0.14965117f, 0.17366134f, -0.30169332f, 0.06217095f, -0.13835073f, 0.11453656f, 0.27636811f, -0.02724310f, 
    -0.08672535f, 0.00240360f, 0.04783500f, -0.01781760f, 0.06181103f, -0.55480224f, -0.12160133f, -0.12254520f, 
    0.02485639f, 0.02075520f, -0.03999740f, 0.09336295f, -0.00999481f, -0.00886229f, -0.12819006f, -0.35535201f, 
    0.09586275f, 0.03046289f, 0.16298144f, -0.09081323f, 0.05696734f, -0.03342904f, -0.15677948f, 0.01520008f, 
    0.01539852f, 0.09351721f, -0.00373106f, -0.17694964f, -0.05454281f, 0.22453107f, 0.21531892f, -0.02655723f, 
    -0.07494754f, -0.05597854f, 0.08961288f, 0.07293031f, 0.06458622f, -0.01160581f, 0.12766838f, 0.07929368f, 
    -0.35835153f, 0.29628354f, -0.10312108f, 0.21421131f, 0.10533258f, 0.14762318f, 0.03862298f, -0.01688651f, 
    0.02224525f, 0.09836563f, 0.04611192f, -0.02237389f, -0.23452711f, -0.16591769f, -0.06141147f, -0.19448951f, 
    -0.11409799f, -0.00200252f, -0.15929106f, -0.07131274f, 0.18546286f, -0.02123228f, -0.19821423f, 0.05420405f, 
    -0.11772729f, 0.06757762f, -0.11580584f, -0.07424171f, -0.02295993f, -0.04432839f, 0.14012414f, -0.00069621f, 
    0.05071719f, -0.05984956f, 0.10838665f, 0.06277309f, -0.10755482f, -0.00383855f, -0.15014590f, 0.08590757f, 
    -0.07773428f, 0.04554340f, 0.11410417f, -0.03272083f, 0.10663583f, 0.04917827f, -0.00372486f, -0.00453977f, 
    -0.03621114f, -0.12563775f, 0.05263038f, 0.06440679f, -0.15062125f, 0.02961594f, 0.06119979f, 0.13066004f, 
    0.09596868f, 0.00202848f, 0.03678016f, 0.10578881f, -0.00933963f, -0.18550780f, -0.07309263f, 0.16520432f, 
    -0.05886812f, -0.01751415f, 0.18048735f, -0.09390367f, -0.22586560f, 0.03811156f, -0.15630388f, -0.04891904f, 
    -0.11087214f, 0.21984580f, -0.16382952f, 0.03939213f, -0.17443550f, -0.01086213f, 0.07759114f, -0.03447840f, 
    -0.03212630f, -0.13907668f, -0.13570724f, -0.00804885f, -0.17311113f, -0.07260959f, -0.22456412f, -0.17827055f, 
    -0.22868203f, -0.11017098f, 0.03493815f, 0.01543287f, -0.15178566f, 0.03963384f, 0.03173539f, -0.04685826f, 
    -0.10950230f, 0.22292137f, 0.06184669f, -0.08512685f, -0.11499302f, -0.02331204f, -0.28747126f, -0.06906589f, 
    -0.03074006f, -0.08130553f, 0.03450959f, -0.00456738f, -0.18186529f, 0.34163693f, -0.05130310f, 0.12638335f, 
    0.11261946f, 0.09130858f, 0.12136921f, 0.04253422f, 0.00225688f, -0.01844874f, -0.28134292f, -0.36263376f, 
    0.15316798f, -0.00276849f, -0.12972851f, 0.15745531f, 0.05387100f, -0.02496280f, 0.08950469f, 0.05396700f, 
    -0.02260471f, 0.12722728f, 0.01739359f, -0.11755030f, -0.20050977f, -0.19351833f, -0.43396667f, 0.10507694f, 
    0.02796456f, -0.19871512f, -0.02070317f, 0.00517537f, -0.06835768f, 0.05884184f, 0.11514281f, 0.00887990f, 
    0.38171718f, -0.02225193f, 0.31159025f, -0.42078516f, 0.02940000f, -0.09883944f, 0.01056498f, -0.02286428f, 
    -0.09887905f, 0.01646700f, -0.10340232f, -0.15776391f, 0.01559703f, 0.15932611f, 0.03219761f, -0.11829840f, 
    -0.10096400f, 0.01945974f, 0.02534869f, -0.03520083f, 0.08590756f, 0.02046683f, 0.09532336f, 0.00920913f, 
    -0.00486020f, -0.16732660f, 0.00914482f, 0.03233996f, -0.00498602f, 0.03352504f, 0.06629126f, 0.02663471f, 
    -0.13689370f, -0.31186715f, -0.31838813f, -0.18677612f, -0.19271667f, 0.35400307f, -0.07741428f, 0.01182350f, 
    -0.03066555f, 0.07425537f, -0.04579341f, 0.08529087f, -0.10107889f, 0.22812892f, -0.11373830f, 0.03110841f, 
    -0.06650452f, 0.04806666f, -0.03198451f, -0.08027794f, -0.13720727f, 0.07439604f, 0.09565356f, -0.03848930f, 
    0.07601113f, 0.12440733f, 0.12195599f, 0.11331537f, -0.11628372f, 0.08352230f, 0.08957301f, 0.36290127f, 
    0.07267126f, -0.13398167f, -0.18612888f, 0.20519415f, -0.02367222f, 0.04701369f, 0.03951636f, -0.02926038f, 
    0.02985396f, -0.02778942f, -0.02844357f, 0.11956704f, 0.00419029f, -0.05740713f, 0.00031981f, 0.12467204f, 
    -0.01906461f, 0.11752472f, -0.10834371f, -0.15294772f, -0.17427811f, 0.08149187f, -0.03943095f, -0.07975420f, 
    0.10248760f, 0.05837479f, -0.00179167f, 0.01404133f, -0.12103507f, 0.03697574f, -0.07287516f, -0.06649152f, 
    -0.02779019f, 0.01377285f, 0.38092095f, -0.17101173f, -0.10807517f, -0.05327489f, -0.04327090f, 0.11430845f, 
    0.10733075f, 0.12026741f, 0.21060556f, 0.03459423f, 0.00302384f, -0.24518304f, 0.27503747f, 0.00106850f, 
    -0.10524639f, -0.04068761f, 0.00704485f, 0.08807841f, 0.17386492f, -0.01990842f, 0.12694858f, 0.20662433f, 
    -0.01745213f, 0.10249804f, -0.09630747f, 0.04453343f, -0.07548823f, -0.17427452f, -0.01057070f, 0.08353467f, 
    -0.08111840f, -0.08032637f, -0.12709044f, -0.02565992f, -0.58391249f, 0.11819592f, -0.00833528f, -0.10496094f, 
    -0.04636217f, 0.08000358f, 0.01367301f, -0.00164350f, -0.01618545f, 0.00792814f, -0.06893303f, -0.05473502f, 
    -0.20649908f, 0.01238362f, -0.04873023f, -0.13447087f, 0.05200532f, 0.06992325f, -0.07434194f, -0.06482274f, 
    -0.09373039f, -0.04376233f, -0.09256452f, -0.33142713f, -0.08887894f, 0.26566705f, -0.03800354f, 0.04198340f, 
    -0.16322294f, -0.29453361f, 0.16639765f, -0.04431659f, -0.08713818f, 0.19870061f, -0.15236533f, -0.06393328f, 
    -0.12242746f, -0.47051138f, 0.14436348f, 0.29412788f, 0.06297577f, -0.18470687f, 0.02200448f, -0.17768961f, 
    0.07629471f, 0.01624226f, -0.02970917f, 0.08554526f, 0.02041478f, 0.07962473f, 0.21410014f, -0.04159734f, 
    -0.02781126f, 0.00638072f, 0.06587661f, 0.06371064f, -0.30695593f, 0.06434163f, 0.14807267f, -0.00248287f, 
    -0.04930156f, -0.01692087f, 0.09313717f, -0.08241751f, 0.00110387f, 0.06806848f, -0.08338795f, 0.00802384f, 
    -0.03183287f, 0.20741539f, 0.08201560f, -0.02856292f, 0.05260985f, 0.05240406f, -0.10041469f, 0.01053730f, 
    0.00315637f, 0.01972213f, 0.04974841f, 0.07260869f, -0.06229851f, -0.07218000f, 0.00597214f, -0.20248507f, 
    0.03248554f, -0.17386824f, 0.37206736f, 0.34418646f, 0.01588120f, 0.06524905f, 0.08714018f, -0.10469658f, 
    -0.04375613f, -0.09661536f, 0.00421143f, -0.02704529f, 0.38820824f, 0.29634947f, 0.18959835f, -0.21936984f, 
    -0.00532482f, -0.00636039f, -0.07842404f, 0.03062863f, -0.07452447f, 0.01552571f, 0.05177448f, -0.07814057f, 
    -0.19335142f, 0.19503437f, -0.10386154f, 0.04170303f, -0.09605751f, 0.08968037f, 0.01068196f, -0.03925126f, 
    -0.02522079f, 0.18480100f, 0.29345354f, 0.02560503f, 0.14537330f, 0.12613270f, 0.07765940f, -0.26011235f, 
    -0.09980070f, -0.06039428f, 0.01481888f, 0.00041198f, 0.00727495f, 0.11576390f, -0.01381118f, -0.15160014f, 
    -0.04788681f, -0.12010267f, 0.13869679f, -0.19636419f, 0.07355394f, 0.03411185f, -0.09968235f, 0.12325538f, 
    -0.01243644f, 0.09624613f, -0.03623083f, -0.20747097f, -0.35511860f, -0.15192208f, 0.07892917f, 0.26371360f, 
    0.03908836f, -0.16624427f, 0.08744082f, 0.13127361f, -0.08792775f, -0.01592517f, 0.00388505f, 0.08157647f, 
    0.21163420f, 0.08792691f, 0.07567640f, -0.05123331f, -0.07150156f, 0.12819397f, -0.15177536f, 0.06162691f, 
    -0.09010062f, 0.05420506f, 0.02359167f, 0.11893629f, 0.16210523f, -0.06909731f, 0.19144505f, -0.15180454f, 
    0.04072348f, 0.06805176f, -0.02466021f, 0.04073494f, 0.14501578f, 0.12950206f, 0.11164416f, 0.03525705f, 
    -0.25663102f, -0.15847027f, -0.25198615f, 0.34634933f, 0.14635882f, 0.06934806f, 0.03545815f, -0.02753745f, 
    0.00881890f, 0.07748181f, 0.21662745f, 0.16783187f, 0.24576657f, 0.07741598f, 0.25866902f, 0.06842540f, 
    -0.02134786f, 0.04489342f, 0.09902424f, 0.13337994f, -0.00219124f, 0.00488449f, 0.01008844f, 0.03561110f, 
    0.02958778f, 0.04464739f, 0.39161137f, -0.20893289f, 0.08396398f, 0.25266847f, -0.14390360f, 0.04804828f, 
    0.01910733f, 0.01099996f, 0.03706616f, -0.05946124f, 0.18827370f, -0.18649788f, 0.20175225f, -0.36714944f, 
    0.00036459f, -0.18002364f, -0.09748115f, -0.00075279f, 0.03036311f, -0.04627220f, -0.10756916f, -0.02662432f, 
    0.05060032f, -0.31683645f, -0.18070573f, 0.10385223f, -0.23428702f, -0.14830190f, 0.09556134f, -0.05638651f, 
    0.00155799f, 0.03030024f, -0.01446534f, -0.00360104f, -0.11206109f, -0.07714254f, 0.00945517f, 0.23401029f, 
    -0.16009957f, 0.08935683f, -0.03199902f, 0.12913156f, -0.32096234f, -0.05102774f, 0.06321558f, 0.05070154f, 
    -0.26252535f, 0.10302395f, -0.14561307f, 0.16419317f, 0.13117881f, 0.06489469f, -0.00398663f, -0.10179694f, 
    -0.04194489f, -0.11650485f, -0.10839898f, -0.20589302f, -0.59715903f, 0.49152327f, -0.24087808f, 0.13867120f, 
    -0.00004693f, -0.03423030f, 0.14856581f, -0.29847094f, -0.12720504f, 0.00676796f, -0.02137421f, 0.03943964f, 
    0.07075448f, 0.15629429f, -0.02362660f, 0.00685305f, -0.06144290f, -0.03857088f, -0.04863995f, -0.03901638f, 
    -0.10385678f, 0.03845472f, -0.06859548f, -0.00654693f, 0.09348891f, 0.57296628f, -0.18949033f, 0.02995760f, 
    -0.06439728f, -0.14279500f, 0.07823501f, -0.05652623f, -0.03505799f, 0.07755326f, -0.04174723f, 0.01216876f, 
    -0.32054794f, -0.19308972f, -0.22531232f, 0.53624541f, 0.06838747f, -0.04229210f, -0.00298407f, -0.12434237f, 
    -0.05527937f, -0.07164509f, 0.09006485f, 0.02365360f, -0.51780784f, 0.13005359f, -0.28624544f, 0.05253414f, 
    -0.08025020f, -0.09519798f, 0.13399068f, -0.19520576f, -0.00272681f, -0.02075310f, 0.01676437f, 0.03049174f, 
    0.06103010f, 0.01325769f, -0.14591025f, -0.28198507f, 0.01096692f, -0.13482860f, 0.01543658f, -0.05901264f, 
    -0.02142440f, 0.03242109f, -0.12444029f, -0.13306849f, 0.22885311f, -0.25006399f, 0.36887765f, 0.02841528f, 
    0.32658839f, -0.01620172f, -0.15571509f, 0.07079758f, 0.02201163f, -0.08200067f, 0.00426836f, 0.13505305f, 
    0.20299301f, 0.11951623f, 0.36025488f, -0.07389875f, -0.10414228f, -0.00616376f, -0.05701626f, -0.10943486f, 
    -0.11598305f, -0.05859999f, 0.01286242f, 0.00316760f, -0.00392024f, 0.22702214f, 0.19292647f, 0.07932383f, 
    -0.15142302f, -0.06091730f, 0.00775234f, 0.13549143f, -0.11014901f, -0.06404617f, -0.07312396f, -0.12088706f, 
    -0.10260735f, -0.21674056f, -0.21052535f, 0.01860290f, -0.05379597f, -0.09143882f, -0.14714895f, 0.06385057f, 
    0.07324290f, 0.09457973f, 0.02941023f, 0.13132314f, -0.29167792f, -0.07599067f, 0.13770308f, -0.50416756f, 
    0.05592836f, 0.05142298f, -0.10851391f, 0.03373919f, -0.05994306f, -0.01878746f, 0.15594307f, 0.11781055f, 
    -0.32799929f, -0.35157898f, -0.04081928f, -0.12918998f, -0.20249456f, -0.02049073f, -0.03891720f, -0.01668283f, 
    0.01465187f, 0.09402691f, -0.04375946f, -0.10515767f, -0.10913932f, -0.01892552f, -0.32443506f, 0.25390881f, 
    0.20711003f, -0.10517184f, 0.05731849f, 0.05669870f, 0.17825939f, 0.05838838f, 0.08261025f, -0.19891135f, 
    -1.04376388f, 0.36412635f, -0.20584087f, 0.36002478f, -0.01313179f, -0.03376723f, 0.04771902f, 0.10356937f, 
    -0.16655566f, -0.02695189f, 0.01368740f, -0.03100166f, 0.18452564f, 0.00054013f, 0.20992693f, 0.07753919f, 
    -0.07236054f, 0.02391718f, -0.03081747f, 0.01000792f, -0.09769665f, -0.09639011f, -0.03537697f, -0.01615757f, 
    0.34458020f, 0.29343528f, 0.07906424f, 0.05590107f, 0.06980436f, 0.00360243f, 0.08537163f, -0.07165254f, 
    -0.13187911f, 0.02613170f, -0.05471528f, -0.18889031f, -0.36011401f, 0.08918591f, -0.19087844f, -0.24150130f, 
    0.07208319f, 0.01324100f, -0.03922685f, -0.11080150f, -0.02520427f, 0.02320801f, 0.09005711f, 0.04302189f, 
    -0.39834836f, -0.01129294f, -0.20717579f, -0.12893130f, -0.01290186f, -0.04229378f, -0.06879164f, 0.04319182f, 
    -0.11514377f, 0.03488453f, -0.01318741f, -0.03378887f, -0.20362724f, -0.08920018f, -0.12933019f, 0.15633763f, 
    -0.04939441f, 0.10938253f, 0.03351489f, -0.10341536f, -0.18119250f, -0.08228292f, 0.00236643f, -0.04496271f, 
    0.10512695f, 0.01095145f, 0.10113754f, 0.26431012f, 0.09398700f, -0.00795118f, 0.01974060f, -0.11093639f, 
    0.16800518f, 0.23201130f, -0.30838576f, 0.02731438f, 0.05059096f, -0.04560887f, -0.09962689f, -0.05250166f, 
    -0.03005593f, -0.01637178f, 0.01483096f, 0.01110931f, 0.00798273f, 0.04954557f, 0.00984387f, -0.04074577f, 
    0.27700323f, -0.29505616f, 0.21684441f, 0.14429013f, 0.19221501f, 0.18555310f, 0.06656134f, 0.10649636f, 
    -0.12210111f, 0.08345309f, 0.06130698f, 0.02763155f, -0.05282078f, -0.11810493f, 0.11077780f, 0.05984502f, 
    -0.10301263f, -0.10523321f, -0.13643356f, -0.17395070f, 0.03640554f, 0.08956219f, 0.08233523f, -0.00105872f, 
    -0.16744033f, -0.14766669f, -0.15627480f, -0.14976403f, -0.11185138f, -0.07638378f, -0.26749808f, -0.04043503f, 
    -0.08376952f, 0.05286765f, -0.02739324f, 0.03270332f, 0.33987325f, -0.34163395f, 0.48469713f, 0.01154475f, 
    0.02942534f, 0.04780731f, -0.11648568f, 0.06733208f, -0.01457287f, 0.10981553f, 0.07214576f, 0.11445354f, 
    0.25955260f, -0.14963141f, 0.05566777f, 0.10360082f, 0.00306777f, -0.04003824f, -0.07430253f, 0.04368274f, 
    0.04968253f, 0.01864899f, 0.09544567f, -0.00281836f, 0.10695291f, 0.05346342f, -0.11021465f, -0.06577817f, 
    -0.00281061f, -0.01898796f, -0.03600816f, 0.11346506f, -0.05505430f, 0.06815749f, -0.01482729f, -0.11842281f, 
    0.21483788f, 0.22392702f, -0.16227749f, 0.06560542f, -0.10935902f, 0.21002918f, -0.02002119f, 0.09690568f, 
    -0.01003904f, 0.07110227f, -0.09552401f, -0.05225774f, -0.35176849f, 0.08251422f, -0.34586591f, 0.05275531f, 
    -0.01832254f, -0.11605494f, 0.17147356f, 0.25876725f, -0.09513860f, -0.03550893f, -0.08702340f, 0.23875022f, 
    -0.07007998f, -0.05943293f, -0.04395453f, 0.10717493f, 0.08747935f, -0.07097466f, -0.01345635f, 0.02623814f, 
    0.00541217f, -0.05012207f, 0.09712881f, -0.03608990f, -0.33236334f, 0.39848158f, -0.46880442f, 0.22100212f, 
    -0.10789777f, -0.01484906f, 0.21097007f, -0.05593790f, -0.00891334f, 0.02981976f, 0.01516222f, 0.00514385f, 
    -0.27974916f, -0.07975772f, -0.17963178f, -0.43310779f, 0.11419453f, 0.03231467f, 0.09432928f, -0.17147323f, 
    0.00542512f, 0.12120008f, 0.09345826f, -0.06955209f, -0.15175079f, -0.11553065f, 0.02127445f, -0.14446080f, 
    -0.03714345f, -0.00658633f, -0.04764493f, 0.09394704f, -0.29082519f, -0.00693066f, 0.00297405f, -0.20624806f, 
    0.03052744f, -0.19844590f, 0.04142249f, -0.16437639f, -0.08790453f, 0.08618889f, -0.08258677f, -0.04699705f, 
    -0.06322332f, 0.00818014f, -0.02163083f, 0.06742166f, 0.10110223f, -0.43724909f, 0.35766721f, 0.17865813f, 
    0.14481443f, -0.29581144f, -0.07619730f, -0.02881060f, 0.06347265f, -0.02467028f, 0.08889386f, 0.12809464f, 
    0.13217919f, -0.00266682f, 0.06946715f, -0.08399528f, 0.01807246f, 0.02181757f, -0.05411723f, 0.04641370f, 
    -0.03464894f, 0.02944999f, -0.01951301f, -0.15349010f, -0.18350145f, 0.17802872f, 0.26076895f, -0.03866205f, 
    -0.08237648f, -0.02276883f, 0.08292671f, 0.16756529f, -0.05475045f, 0.10326953f, 0.04639697f, -0.17727965f, 
    0.06115470f, -0.13807541f, 0.11726223f, -0.37135282f, -0.06763087f, -0.14948648f, -0.01033985f, -0.01380773f, 
    0.02493639f, -0.09535014f, -0.06628823f, -0.03606906f, -0.26178694f, -0.14096624f, -0.18273914f, 0.17746164f, 
    -0.03484835f, -0.11459355f, -0.00549325f, -0.11449789f, -0.03629205f, -0.01800841f, -0.03516251f, -0.06930052f, 
    0.23546693f, -0.05285110f, 0.19336474f, 0.01729004f, 0.08107948f, 0.09319394f, 0.12144485f, -0.07112675f, 
    -0.15718766f, 0.17680173f, -0.07903631f, -0.01172353f, -0.13060623f, 0.01296319f, 0.28302735f, -0.31518757f, 
    0.09235689f, 0.08075695f, -0.16965570f, 0.00198648f, -0.28368923f, 0.11789744f, 0.12174426f, 0.09156222f, 
    0.13801047f, -0.11057321f, 0.01268908f, -0.01091704f, -0.08096189f, 0.04403611f, -0.05318505f, -0.05825745f, 
    -0.06495238f, 0.06578736f, 0.04421671f, -0.05270737f, 0.02428159f, -0.44331965f, -0.06222167f, -0.11748812f, 
    0.11373929f, -0.00159876f, 0.04086392f, 0.00870098f, 0.04713472f, 0.03073226f, 0.07026120f, 0.00594794f, 
    -0.05565422f, 0.25730392f, -0.26910716f, 0.07540264f, 0.04300990f, 0.01781829f, 0.18813711f, -0.11227079f, 
    -0.04479832f, 0.02808283f, 0.26247001f, 0.18731436f, 0.03364171f, -0.12956068f, 0.31060171f, -0.06413237f, 
    0.01116171f, 0.07804343f, 0.20804483f, -0.04224808f, 0.11456218f, 0.05826185f, -0.02931625f, -0.02989199f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17410560f, 0.08118615f, 0.05797439f, -0.07879272f, -0.09585158f, 0.07958435f, 0.01316227f, -0.09269076f, 
    0.04475598f, 0.03273783f, 0.03288161f, -0.01717529f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
