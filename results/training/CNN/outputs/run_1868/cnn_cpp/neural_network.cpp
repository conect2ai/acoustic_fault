#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.56104493f, 0.58716756f, 0.08300203f, -0.19496983f, -0.30201635f, -0.27630380f, 0.15233074f, 0.09027670f, 
    0.00934610f, -0.12713361f, 0.37250289f, -0.22861302f, -0.23304194f, -0.30546239f, 0.05482213f, -0.14647502f, 
    0.13713154f, -0.01910638f, 0.02638936f, -0.43546534f, 0.09959930f, 0.01577318f, -0.32504174f, -0.25932685f, 
    -0.60469157f, 0.34952551f, -0.02446968f, 0.08671361f, 0.31760165f, 0.10464225f, 0.07009923f, 0.44865650f, 
    0.34951925f, -0.16549055f, 0.12191717f, 0.20765382f, 0.13771145f, -0.01235404f, -0.34859321f, 0.01110750f, 
    0.12482762f, 0.09423581f, 0.15245520f, 0.00576906f, -0.31634441f, 0.24041101f, -0.05282224f, -0.13283853f, 
    -0.12550335f, -0.14762171f, -0.36841121f, -0.73373389f, -0.72879589f, -0.32343978f, -0.39617494f, 0.77108574f, 
    -0.01315650f, 0.32919234f, 0.20930754f, 0.67830616f, 0.11538308f, 0.24602938f, 0.01716644f, 0.13741344f, 
    0.03075416f, -0.04012968f, -0.11746398f, -0.01645440f, 0.02746685f, -0.15187207f, -0.07987666f, -0.07296061f, 
    0.19017556f, -0.10665181f, -0.01856896f, -0.22668724f, -0.25244761f, -0.03986456f, -0.51423931f, -0.19847478f, 
    0.08373939f, 0.24055015f, 0.10752402f, 0.16738415f, 0.55008173f, -0.01253560f, -0.01684731f, -0.42268184f, 
    -0.35890085f, -0.08860870f, -0.07154687f, 0.34152362f, 0.16663253f, 0.17197944f, -0.02721836f, -0.21186024f, 
    -0.14556155f, -0.18149027f, -0.36047342f, -0.09796075f, 0.49555579f, 0.59365034f, 0.16785309f, 0.35752663f, 
    -0.35419959f, -0.30822897f, -0.23218347f, 0.38977289f, -0.16201496f, -0.01662689f, 0.16320123f, 0.21461459f, 
    -0.18029127f, -0.16414531f, -0.15900372f, -0.07868418f, 0.05264231f, -0.23555115f, -0.12638956f, -0.15800847f, 
    0.04336281f, 0.20094807f, 0.18879980f, 0.06388337f, 0.07285578f, 0.82369930f, -0.52220047f, 0.18341905f, 
    -0.12618575f, -0.59962904f, -0.09027801f, -0.11316611f, -0.06488820f, 0.61256665f, -0.34178466f, 0.37532839f, 
    -0.38982683f, -0.04739444f, 0.19493309f, -0.18652181f, -0.17021552f, 0.20458829f, 0.16693127f, 0.01378517f, 
    -0.15893789f, 0.11936990f, 0.06473488f, 0.14883576f, -0.20417134f, -0.18554653f, -0.45966798f, 0.11771598f, 
    0.09420456f, -0.31136465f, 0.03778524f, -0.25989237f, -0.31690994f, 0.37774363f, 0.58268332f, -0.24961364f, 
    -0.34059477f, -0.00927318f, -0.13369857f, -0.31607783f, 0.06277598f, -0.05098673f, -0.13985579f, -0.40332523f, 
    -0.35702300f, 0.67557132f, 0.05165390f, -0.11063319f, 0.19448601f, -0.30039129f, 0.19951470f, -0.08334721f, 
    -0.19070479f, 0.43300581f, -0.32259497f, -0.33881551f, 0.49141166f, 0.10382216f, -0.15865222f, 0.04181445f, 
    0.17040700f, 0.01685105f, 0.23002368f, -0.25834990f, -0.19026530f, 0.22136328f, -0.35309574f, 0.25107393f, 
    -0.38196215f, -0.00157228f, -0.13793761f, -0.00413994f, 0.08482423f, 0.05288491f, 0.27379307f, 0.02688180f, 
    -0.55882549f, -0.24657474f, -0.10546348f, -0.29840779f, -0.10978558f, -0.36695099f, -0.12630506f, 0.21040009f, 
    0.35858595f, -0.07457561f, 0.03241705f, -0.15266071f, -0.33770958f, -0.15504859f, 0.09555742f, 0.10321436f, 
    -0.14825185f, -0.09030687f, -0.28007296f, -0.29492533f, -0.24725176f, 0.22722811f, 0.32452428f, -0.16477184f, 
    0.41755694f, -0.10780332f, -0.26181337f, 0.15986620f, 0.11315972f, 0.38020706f, -0.28411609f, 0.06001882f, 
    -0.16440880f, 0.14733817f, -0.07001011f, -0.02768679f, -0.14071710f, 0.20684820f, 0.24040745f, 0.04013462f, 
    0.06366577f, 0.24337465f, -0.49437284f, -0.31573719f, 0.08948462f, 0.11669265f, 0.24244830f, 0.33606160f, 
    0.16223539f, 0.28611973f, 0.53535593f, 1.09844530f, 0.79250020f, -0.79484141f, -0.30366209f, -0.33917162f, 
    -0.47378683f, -0.33817470f, -0.29250234f, -0.61914229f, 0.18084535f, 0.01674905f, -0.06389846f, 0.04522544f, 
    0.10599242f, 0.04079968f, -0.03655014f, -0.05754042f, 0.12819108f, 0.02469773f, -0.00780843f, 0.13043222f, 
    0.06840844f, -0.06743174f, -0.00121838f, 0.17732421f, -0.08582080f, -0.33837181f, -0.06488942f, -0.11652582f, 
    -0.29660031f, -0.25188929f, 0.32695082f, -0.29055148f, 0.02482911f, 0.05368773f, 0.00139175f, 0.45387155f, 
    -0.29932171f, 0.20489340f, 0.10917785f, -0.09768525f, -0.35696635f, -0.31966525f, -0.30986419f, 0.05526885f, 
    0.15109921f, -0.09740418f, 0.21025336f, 0.29811200f, -0.45867559f, -0.43168762f, -0.35349151f, -0.15856685f, 
    -0.01433949f, -0.41072741f, -0.35049054f, -0.23571800f, 0.12633587f, -0.42332208f, 0.09557235f, 0.01268195f, 
    0.23709598f, 0.27409819f, -0.31711283f, 0.18150657f, 0.05713773f, -0.13744758f, 0.29085121f, 0.37259343f, 
    0.09056228f, -0.09764902f, -0.28767815f, -0.05008809f, 0.24766889f, 0.56436026f, 0.09663795f, -0.15061045f, 
    0.02119072f, 0.19171749f, -0.08304847f, -0.03482034f, -0.08733309f, 0.20370772f, 0.16909772f, 0.47242078f, 
    -0.15722930f, -0.28700542f, -0.16758519f, 0.51714551f, -0.17235388f, 0.10428892f, -0.14033179f, 0.01481191f, 
    -0.06896271f, -0.17264178f, 0.18168366f, 0.15363233f, -0.22088435f, 0.22853214f, -0.60325032f, 0.41192132f, 
    0.49032980f, 0.17544219f, 0.11061697f, -0.72479802f, -0.47706413f, 0.32263884f, 0.32372603f, 0.44105476f, 
    0.14572802f, -0.35611427f, 0.27948302f, 0.30763564f, -0.26915395f, 0.03716465f, -0.03486777f, -0.02031388f, 
    0.15472165f, -0.47084978f, -0.11880916f, -0.20025197f, 0.23008680f, -0.12010524f, -0.16379617f, -1.02981067f, 
    -0.30260238f, 0.34429306f, -0.31812939f, 0.35637113f, 0.57449329f, -0.43610615f, -0.70927322f, -0.24294081f, 
    -0.31401044f, -0.18261425f, -0.13179965f, -0.26758564f, -0.42864650f, -0.30722451f, 0.13686337f, -0.08736760f, 
    -0.18662570f, 0.05917589f, -0.10926373f, 0.00677832f, 0.02769450f, -0.13826977f, -0.12149253f, 0.00086560f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09807107f, 0.03396969f, 0.13355169f, -0.12680410f, 0.22660603f, 0.08892834f, 0.28410658f, 0.06532218f, 
    -0.08387132f, -0.15573800f, 0.24373338f, -0.08905363f, -0.12244841f, 0.04533561f, 0.14291890f, -0.24795946f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18192475f, -0.04310853f, 0.24309659f, 0.08947038f, -0.04390695f, 0.00321257f, 0.09690989f, 0.14155677f, 
    -0.15197040f, -0.09405317f, -0.18344434f, -0.09007584f, 0.07205290f, 0.07621437f, 0.20457304f, 0.10669895f, 
    -0.08528019f, 0.01138239f, -0.00339539f, -0.08501535f, 0.13421859f, -0.14228866f, -0.10136751f, 0.19719794f, 
    0.16609313f, -0.48985848f, -0.43515053f, -0.31073391f, 0.02162128f, -0.00429895f, -0.16791484f, -0.02691347f, 
    0.03935447f, -0.02802229f, 0.00966761f, -0.18336084f, -0.21513340f, -0.13780585f, -0.08575204f, -0.22167057f, 
    -0.00017997f, -0.09308876f, -0.23919372f, -0.00676193f, 0.05554047f, -0.15161027f, -0.02626409f, -0.13230807f, 
    0.23074354f, 0.27995697f, 0.22686584f, 0.26563594f, 0.09141748f, -0.00346840f, -0.04916385f, 0.04357043f, 
    0.08512427f, -0.03900132f, -0.02577241f, 0.00884701f, 0.23819084f, -0.16936214f, -0.00480301f, 0.04374447f, 
    0.14372505f, 0.01792900f, 0.10445841f, 0.12418075f, -0.02629438f, 0.02400553f, 0.07555427f, -0.16411240f, 
    -0.20950840f, 0.10984480f, -0.01021385f, 0.01214272f, -0.05153523f, 0.02325740f, 0.00420381f, -0.06854936f, 
    0.00637230f, 0.06474413f, -0.01967437f, 0.07968690f, 0.02348678f, 0.01709189f, -0.09460547f, -0.01442062f, 
    -0.20850331f, 0.10666652f, 0.15466155f, 0.11977778f, 0.18706597f, 0.01496969f, 0.03030603f, -0.11636469f, 
    -0.22051661f, 0.00621450f, -0.01194386f, -0.12097885f, 0.06714576f, 0.10806850f, 0.08089768f, 0.15721294f, 
    0.07089385f, 0.02946299f, -0.14876260f, -0.11010747f, 0.03303859f, 0.05710758f, 0.14466774f, 0.05890984f, 
    -0.04879563f, -0.01394436f, 0.05597289f, 0.07598814f, -0.07728750f, 0.10564268f, 0.04309114f, 0.08711993f, 
    0.04578488f, 0.25211665f, -0.37962127f, 0.46722397f, -0.06414115f, -0.13252604f, 0.02730621f, 0.17726500f, 
    -0.14419831f, 0.07342582f, 0.01749292f, 0.01106432f, -0.07069010f, -0.23430549f, 0.01919246f, 0.11547789f, 
    0.14404951f, 0.14217642f, 0.01000692f, 0.07902759f, 0.07367197f, -0.18822512f, 0.19209239f, 0.04004009f, 
    0.14659227f, 0.16924320f, 0.08472344f, -0.02304589f, -0.02849426f, 0.13453320f, -0.04392735f, 0.21806546f, 
    -0.05658940f, -0.09513605f, 0.02437720f, -0.06176650f, 0.03034877f, 0.08938682f, 0.22143993f, -0.06368794f, 
    0.04571913f, 0.04710171f, -0.02256629f, 0.04166162f, 0.01658511f, 0.17481121f, -0.08942929f, 0.09750980f, 
    0.05191440f, 0.23967208f, 0.24401219f, -0.08805562f, 0.04264415f, -0.04724472f, 0.09125499f, 0.01473143f, 
    0.00695833f, -0.09272882f, -0.03606909f, 0.21797538f, 0.31620055f, 0.27036548f, -0.06642687f, -0.22963691f, 
    0.01592852f, 0.13793351f, 0.14692557f, 0.21327384f, 0.11384641f, -0.06804031f, -0.09405235f, -0.08588645f, 
    -0.23254676f, 0.09048007f, 0.09706749f, 0.12701528f, -0.09967812f, -0.09645372f, -0.02760418f, 0.03491194f, 
    -0.14603309f, -0.16066281f, -0.14668465f, -0.12664779f, 0.10663807f, -0.23454581f, -0.10128431f, -0.02731426f, 
    -0.08658256f, 0.01645228f, -0.14084208f, -0.01876482f, 0.08292224f, -0.02735017f, 0.03426878f, 0.11654177f, 
    0.22073245f, -0.19451000f, -0.04647032f, -0.23057191f, 0.06259032f, 0.05636228f, -0.16930957f, -0.23034212f, 
    -0.00888859f, 0.05147001f, 0.09713477f, -0.03189154f, 0.07047996f, 0.02421128f, 0.14435825f, -0.14170338f, 
    0.08941368f, -0.04497780f, -0.10571885f, 0.05974983f, 0.03836266f, -0.03883344f, 0.02013963f, 0.03344683f, 
    -0.21209477f, -0.20060410f, -0.02736985f, 0.22114260f, -0.03192514f, 0.07527251f, -0.13988797f, -0.01689389f, 
    -0.02022290f, -0.04866140f, -0.00330845f, 0.01311290f, 0.11558609f, -0.03852561f, -0.20327081f, -0.08226947f, 
    -0.03080052f, -0.00553089f, 0.05042246f, 0.23173958f, -0.01154965f, 0.01790187f, -0.02238491f, 0.01117807f, 
    -0.08890153f, 0.11405836f, -0.09749263f, 0.03265944f, 0.01285383f, 0.03924764f, 0.03383906f, 0.06776530f, 
    -0.01903878f, 0.07347806f, -0.11970370f, 0.12412611f, 0.24391878f, -0.12087972f, 0.09342117f, -0.23091464f, 
    -0.08898682f, -0.03863951f, -0.04916209f, 0.14481150f, 0.11430889f, 0.10902597f, 0.17857134f, -0.02258951f, 
    0.00549280f, 0.28759849f, 0.12513943f, -0.02070478f, 0.19329660f, 0.13781433f, 0.01473861f, 0.21793261f, 
    -0.11621826f, 0.00372833f, -0.06455196f, 0.12754896f, 0.04220904f, 0.01732669f, 0.00939711f, -0.02112098f, 
    0.19234504f, 0.02108825f, 0.16127494f, -0.03993064f, 0.24002804f, 0.09412593f, 0.11313082f, 0.14303948f, 
    0.03903793f, 0.26811332f, -0.44661719f, 0.09654292f, -0.00977616f, -0.02269770f, 0.20398064f, 0.23351748f, 
    0.05525303f, -0.02253928f, -0.10252196f, 0.05452529f, 0.17033447f, -0.00447192f, 0.06154840f, 0.07061811f, 
    0.08612604f, 0.21778032f, 0.14352456f, -0.10149805f, 0.02885111f, -0.08929299f, 0.02853081f, 0.06530079f, 
    0.13809282f, 0.18607959f, 0.08596914f, -0.06531209f, -0.02668701f, 0.16065125f, 0.09742717f, 0.11901385f, 
    0.05362507f, -0.01187891f, 0.06014548f, 0.03702600f, -0.20876019f, -0.21440299f, 0.04752854f, -0.23694967f, 
    0.00007220f, -0.04350819f, 0.12599239f, -0.19927552f, 0.06023583f, 0.24175407f, -0.06410798f, 0.09920839f, 
    -0.46954337f, -0.00560452f, 0.09892590f, 0.23484373f, 0.02428466f, -0.14209270f, -0.02019831f, -0.21844441f, 
    0.08611687f, -0.00659187f, -0.14376715f, -0.08966065f, 0.12418388f, 0.46319079f, -0.08217575f, -0.17186342f, 
    -0.03193333f, 0.09904797f, 0.03974650f, 0.24207881f, 0.05561959f, -0.04626129f, -0.11043962f, -0.14695644f, 
    -0.27510583f, 0.01148035f, 0.21752559f, -0.22769651f, -0.08298328f, -0.15316243f, -0.20034502f, 0.09047016f, 
    -0.23682557f, 0.06501137f, -0.06221017f, -0.04978874f, 0.13288882f, 0.02246126f, 0.00553570f, 0.17403953f, 
    -0.01332447f, -0.01784287f, -0.03842944f, 0.04074540f, -0.03690834f, -0.05692476f, 0.07454427f, -0.09870043f, 
    -0.00103036f, -0.27758199f, -0.31538877f, -0.20987816f, 0.05233389f, 0.14571460f, 0.13150734f, -0.07324094f, 
    0.02221950f, -0.03147351f, 0.05493171f, -0.18056764f, 0.06954680f, 0.07098579f, -0.05809423f, -0.05352683f, 
    -0.00679703f, 0.12981726f, 0.02104225f, -0.03310727f, -0.00739804f, -0.08709943f, 0.08092675f, 0.06103170f, 
    0.08404453f, 0.20667067f, 0.17863615f, 0.07240012f, 0.14147370f, -0.09823178f, -0.11123360f, 0.04943248f, 
    -0.03523930f, 0.04855321f, -0.11597552f, 0.11790761f, 0.03975264f, -0.20787247f, -0.04235783f, -0.14350787f, 
    -0.12287376f, 0.32461348f, -0.01633707f, -0.05657410f, -0.01383405f, 0.08669299f, 0.04536351f, -0.15172125f, 
    0.13233911f, 0.10251871f, 0.10797974f, -0.06858438f, -0.01855798f, 0.13165079f, -0.12363935f, -0.01596577f, 
    -0.12151116f, -0.00816560f, -0.15193614f, 0.09309569f, 0.06959856f, -0.31434855f, -0.01221032f, -0.07110123f, 
    -0.00122705f, 0.08735330f, 0.02940872f, 0.08962956f, 0.09847922f, -0.10707171f, -0.17219834f, -0.02577730f, 
    -0.01789780f, 0.14681956f, 0.07761749f, -0.04584535f, 0.19477859f, 0.19734573f, -0.10306244f, -0.15630810f, 
    0.02129410f, 0.07079237f, -0.03142870f, 0.06732921f, 0.07822816f, 0.01166665f, 0.08226983f, 0.11168853f, 
    0.00326169f, -0.13789643f, 0.11109958f, -0.19696808f, -0.05543987f, -0.04476178f, -0.00158407f, 0.00726496f, 
    -0.02370625f, -0.00462899f, -0.02080067f, -0.13859269f, -0.07325312f, 0.01384589f, -0.12499364f, 0.12974659f, 
    -0.01451238f, 0.11236556f, 0.05046046f, -0.01725752f, 0.13433228f, 0.01439955f, -0.09408120f, 0.03620737f, 
    0.11138258f, 0.07344386f, 0.03418765f, -0.17334658f, 0.01788465f, -0.01905539f, 0.05238264f, -0.06916863f, 
    0.43505508f, 0.05677192f, 0.03675709f, -0.08500098f, 0.12066348f, 0.17909627f, 0.11043241f, -0.05773393f, 
    -0.00056300f, -0.13530721f, -0.00491383f, 0.04759876f, 0.02754893f, 0.10015738f, 0.13597380f, -0.05406276f, 
    0.00684738f, 0.12736593f, -0.10353077f, 0.01743763f, 0.02292115f, 0.16448641f, 0.04510779f, 0.07077511f, 
    -0.07821577f, -0.15277432f, 0.46178171f, -0.06467912f, 0.16501209f, -0.00577894f, -0.00291729f, 0.14676757f, 
    0.21851659f, 0.04985138f, -0.01471911f, -0.08715088f, 0.14811827f, 0.57790697f, 0.12317149f, -0.30698690f, 
    -0.04897776f, -0.16483410f, -0.04805627f, 0.18525828f, -0.02274120f, -0.01368769f, -0.07681555f, -0.11972839f, 
    0.26613426f, -0.01130149f, -0.13265727f, -0.07228056f, -0.05038650f, 0.09829469f, -0.00572556f, -0.05290142f, 
    0.03643099f, 0.03098368f, -0.02060868f, -0.22647940f, -0.12985040f, 0.02836559f, -0.00542453f, -0.14376324f, 
    0.06744365f, -0.02366190f, 0.00027876f, 0.13802025f, -0.08592837f, 0.09816793f, 0.13016376f, 0.04772509f, 
    -0.59889233f, 0.36392274f, 0.18080093f, 0.22208813f, -0.04082817f, -0.02657503f, 0.03264935f, 0.17523442f, 
    0.12452785f, 0.12341737f, -0.06839913f, -0.12518997f, -0.08488537f, 0.10484487f, -0.23842025f, -0.08358279f, 
    0.04142988f, -0.10388896f, 0.12685269f, 0.08156750f, -0.12731701f, 0.12778758f, -0.06709123f, -0.15979613f, 
    0.11283882f, 0.00699656f, -0.09284194f, -0.14829578f, -0.04632539f, 0.07142739f, 0.17957158f, -0.08350624f, 
    -0.07213033f, 0.03653419f, 0.09376056f, 0.14713283f, 0.09813997f, 0.38214761f, -0.05551733f, 0.16926581f, 
    0.08754241f, -0.02515126f, -0.00543509f, 0.21586870f, 0.03217709f, 0.05455222f, -0.03837474f, 0.01805735f, 
    0.29928175f, -0.10636297f, 0.20998093f, 0.26343805f, 0.05626766f, 0.02903458f, 0.14553241f, 0.04199028f, 
    0.02400445f, -0.15339567f, -0.00041187f, -0.01142580f, -0.19977327f, 0.09512258f, 0.04175794f, 0.25771931f, 
    -0.01111600f, -0.09376306f, 0.08391917f, -0.04995306f, 0.11953904f, 0.11442058f, 0.18845187f, -0.01345730f, 
    0.02381098f, -0.22251542f, -0.12758566f, -0.03360614f, -0.08095703f, -0.11158960f, 0.07374207f, -0.03884215f, 
    -0.01532282f, -0.04080125f, -0.09456887f, 0.01259392f, -0.07889010f, -0.08581693f, -0.23102991f, -0.10500626f, 
    0.04510486f, 0.11724205f, -0.03629972f, -0.02370838f, -0.09948576f, 0.09772870f, 0.06370883f, 0.01594496f, 
    0.11570463f, -0.59940225f, 0.49628636f, -0.01841584f, 0.24022742f, 0.10484044f, 0.12595972f, -0.03841376f, 
    0.00484949f, 0.01651378f, -0.13149349f, -0.04230309f, -0.02712409f, -0.01329576f, 0.09116525f, -0.11125819f, 
    -0.02796774f, -0.09563157f, -0.08141819f, 0.14070888f, -0.08568228f, -0.08506077f, -0.04494934f, 0.04079524f, 
    -0.28483167f, -0.08098933f, -0.17309558f, -0.02782315f, 0.04693180f, 0.00927123f, -0.12276682f, -0.20196560f, 
    -0.13689072f, 0.01123350f, 0.01358653f, -0.25218296f, 0.07054754f, 0.24306600f, -0.20199825f, 0.24353132f, 
    -0.04281678f, 0.07968450f, 0.05722629f, 0.12647198f, -0.01858587f, -0.01883644f, 0.25350842f, 0.10528690f, 
    0.23133156f, 0.21585374f, -0.15379389f, -0.11527376f, -0.19693682f, -0.09068818f, 0.02789246f, 0.01169753f, 
    -0.04942649f, 0.10765973f, 0.07407933f, 0.18009891f, -0.17084832f, -0.34008297f, -0.08056446f, 0.01781215f, 
    0.18647704f, 0.13346484f, 0.21950810f, -0.15424114f, -0.16533010f, 0.08535031f, 0.00470245f, 0.09040882f, 
    -0.15336736f, 0.07267576f, -0.06546580f, -0.00608549f, 0.04347787f, 0.04154643f, 0.09694009f, -0.06796774f, 
    0.22634053f, 0.00629623f, 0.10311060f, -0.00256540f, -0.00134300f, -0.12696449f, -0.10883452f, -0.12876289f, 
    -0.01403861f, 0.11824719f, -0.03655896f, 0.12630503f, 0.16343634f, 0.10926142f, 0.09378891f, 0.15253609f, 
    -0.07734933f, 0.36326322f, 0.29361704f, 0.14996924f, -0.15438445f, -0.19751793f, 0.01864363f, 0.13786201f, 
    0.04567294f, 0.02999057f, 0.15281256f, 0.06359027f, -0.15653564f, 0.08339956f, 0.10431819f, -0.03216850f, 
    -0.10344894f, 0.00518356f, -0.14919975f, -0.10859475f, -0.04877120f, 0.09633433f, -0.05914778f, 0.14764260f, 
    0.27950448f, -0.08433522f, -0.19848093f, -0.14151976f, -0.12913504f, -0.01217344f, 0.07959976f, 0.02813561f, 
    0.04476392f, -0.05512151f, -0.03251741f, -0.08681902f, 0.22854242f, 0.27783853f, 0.11240719f, 0.05659270f, 
    0.07650358f, -0.08273282f, 0.05305212f, 0.03087050f, 0.01514653f, 0.13863793f, 0.03031948f, 0.06547728f, 
    -0.23787911f, 0.20208031f, -0.06351851f, 0.35970467f, 0.14161558f, 0.05513973f, 0.13044199f, 0.05648106f, 
    0.13903393f, -0.02495670f, 0.08432043f, 0.01123178f, -0.10592215f, 0.09279120f, -0.05219128f, 0.12856792f, 
    0.11053646f, 0.04584528f, -0.00309721f, -0.18483314f, -0.01191691f, 0.18842661f, 0.13700673f, 0.15137388f, 
    -0.26593146f, -0.02379742f, 0.04309445f, 0.12907293f, -0.01465983f, -0.06166829f, 0.07998580f, 0.12414008f, 
    0.09082592f, -0.02081065f, 0.05352145f, -0.06639248f, -0.10328151f, 0.12793508f, -0.11706773f, 0.06873043f, 
    -0.04568662f, 0.15573010f, -0.08924781f, 0.11986154f, 0.00427590f, 0.00465056f, -0.03428765f, -0.04068846f, 
    0.38519499f, -0.00742278f, -0.07962759f, -0.05084058f, -0.01398989f, 0.00496565f, 0.13858846f, -0.06336315f, 
    -0.00926681f, -0.05429115f, -0.03004022f, 0.10466649f, -0.15932661f, -0.09355453f, 0.09449387f, -0.07483561f, 
    -0.12108378f, 0.03264249f, -0.05413889f, 0.19910054f, 0.03283617f, -0.05350363f, 0.06309405f, 0.01087918f, 
    -0.37841401f, -0.00808271f, 0.08316704f, 0.05324664f, -0.00111827f, -0.05993181f, -0.00809981f, -0.11291227f, 
    0.03374441f, 0.00905408f, -0.02079915f, -0.06401425f, 0.14967635f, -0.07772107f, -0.09654627f, 0.16108559f, 
    -0.00568454f, -0.03645571f, -0.00124664f, 0.10838702f, 0.12847495f, -0.02610988f, 0.03805633f, -0.09328612f, 
    -0.19612214f, 0.06615548f, -0.41217762f, 0.10152628f, -0.04025430f, -0.09115766f, 0.02217804f, -0.18780114f, 
    0.01011207f, 0.14556094f, -0.03411364f, 0.06836459f, -0.35357541f, -0.50715888f, 0.20299187f, 0.26513740f, 
    0.12882084f, 0.03336936f, 0.12702571f, -0.13549978f, 0.05242993f, 0.05457747f, 0.05244821f, 0.10027221f, 
    -0.01181636f, 0.02914123f, -0.10009497f, 0.01690695f, -0.04375578f, -0.01018113f, -0.01636544f, -0.09248658f, 
    -0.01641612f, -0.12017412f, -0.06106756f, -0.12245202f, -0.02215791f, -0.05608831f, 0.02212878f, -0.02115808f, 
    -0.04033477f, 0.03198432f, -0.00186183f, -0.08405013f, 0.00475703f, -0.07316387f, 0.00938084f, 0.00206986f, 
    -0.06293539f, 0.01108200f, 0.01743004f, -0.00018248f, 0.03368030f, 0.05692967f, -0.02300749f, -0.03520195f, 
    -0.03714815f, -0.06556229f, 0.00412847f, -0.01911154f, 0.00079466f, 0.01192225f, 0.02756511f, -0.08096927f, 
    -0.04695704f, -0.07636936f, -0.04072953f, -0.09400701f, 0.00429121f, -0.04358711f, -0.07025895f, -0.02878496f, 
    -0.07394527f, -0.06399107f, -0.00203198f, -0.10343178f, -0.02776907f, -0.07487550f, 0.04729761f, -0.02397447f, 
    -0.05118195f, -0.03359924f, 0.01681369f, 0.00289460f, 0.00869981f, 0.03008388f, 0.00207170f, -0.11482014f, 
    -0.03374887f, -0.00199085f, 0.01080429f, -0.07973413f, 0.03558995f, -0.10049736f, 0.03170118f, -0.00160273f, 
    -0.00323983f, -0.02620497f, -0.00002431f, -0.06236587f, -0.08478672f, -0.09107898f, -0.07383481f, 0.00861421f, 
    -0.05346335f, -0.03531939f, -0.09335476f, -0.12895043f, -0.09878186f, -0.04385780f, -0.12088805f, -0.04466813f, 
    0.02391813f, -0.07595085f, 0.05422526f, -0.04360978f, -0.01990203f, 0.00468972f, -0.01186145f, -0.00381762f, 
    -0.04846013f, 0.05968618f, 0.04793551f, 0.02604433f, -0.10673879f, -0.00284487f, -0.09450899f, 0.00936397f, 
    -0.07921865f, 0.02888354f, -0.00105747f, -0.01844909f, -0.02913009f, -0.07962074f, -0.09237098f, -0.02766240f, 
    -0.10007443f, -0.06747203f, -0.06158420f, -0.03891381f, -0.04075078f, -0.01457634f, -0.10886000f, 0.00005875f, 
    -0.04328907f, 0.00417113f, -0.01169846f, -0.05375535f, -0.07355762f, -0.07366008f, -0.01276574f, -0.03725037f, 
    0.03242509f, -0.08203518f, 0.05283730f, -0.07929244f, -0.00200952f, -0.04147194f, 0.04594842f, -0.04186065f, 
    -0.09977353f, 0.03348134f, -0.13200305f, -0.10330863f, 0.01968919f, -0.08469085f, -0.05499426f, 0.02870829f, 
    0.00772438f, -0.05348756f, -0.04003842f, -0.06363584f, 0.01144536f, 0.00101467f, 0.06286276f, -0.05336677f, 
    0.00096893f, 0.05134762f, 0.01281443f, -0.04246837f, 0.00810940f, -0.00059424f, -0.10183773f, -0.10340812f, 
    -0.09591819f, -0.00794117f, -0.10287067f, -0.01285318f, -0.04396754f, -0.07130098f, -0.00415183f, -0.07540401f, 
    -0.07156414f, -0.13449191f, 0.00145423f, -0.07291472f, -0.07194133f, -0.01337401f, 0.06724729f, -0.05846144f, 
    0.06824820f, -0.10786302f, -0.05657019f, -0.07235458f, 0.01416287f, -0.00610495f, -0.04188959f, 0.00067247f, 
    -0.03519343f, -0.03838633f, 0.03119845f, -0.02808703f, -0.01798942f, -0.01510904f, 0.01740107f, 0.01260391f, 
    -0.12624428f, 0.26120427f, -0.04938607f, 0.05163152f, 0.08135063f, -0.08409295f, -0.02185311f, -0.03673736f, 
    0.16604760f, -0.01519436f, -0.16114829f, -0.10766776f, 0.03620182f, -0.16818139f, -0.46038294f, -0.08559965f, 
    -0.08529466f, -0.45045942f, -0.49512491f, -0.19923641f, -0.05102548f, 0.02729241f, 0.14298239f, 0.06118613f, 
    0.02146381f, 0.29802731f, 0.43497360f, 0.01709343f, -0.29235250f, -0.05561995f, 0.00901973f, 0.08039929f, 
    0.04534607f, -0.07930449f, 0.00115305f, 0.03228444f, 0.04404762f, 0.14939623f, -0.02764399f, 0.00965158f, 
    -0.12769601f, -0.04734346f, -0.03003599f, -0.02300460f, 0.03957727f, 0.04121039f, -0.00994027f, 0.15866542f, 
    -0.14841144f, -0.11662181f, 0.08675978f, -0.05822197f, 0.02299906f, -0.16469127f, -0.21390831f, -0.04785704f, 
    -0.06746275f, -0.06687205f, -0.13222659f, -0.06520063f, -0.14967188f, 0.32488784f, 0.12987062f, -0.12425120f, 
    0.04484214f, 0.27450603f, 0.04220811f, 0.03065657f, 0.10260589f, 0.01103760f, 0.17859977f, 0.02564400f, 
    0.17419349f, 0.21169525f, -0.00077243f, 0.42113620f, 0.13486435f, 0.21301989f, 0.03600143f, 0.02338602f, 
    0.15147242f, 0.12999870f, -0.27462462f, 0.09438612f, 0.17771244f, -0.08170445f, -0.00374074f, -0.04198412f, 
    0.02565255f, -0.18721823f, -0.03737441f, 0.06121271f, 0.07264291f, -0.07419159f, -0.17716290f, -0.04171784f, 
    -0.02515483f, 0.30532321f, 0.25504360f, 0.32793286f, 0.07491371f, 0.27725208f, 0.12413532f, 0.05708409f, 
    -0.00429820f, 0.02899656f, -0.17657773f, -0.06314266f, 0.05547481f, -0.43690243f, -0.31272629f, 0.14010802f, 
    0.05495924f, 0.01839724f, 0.25544930f, 0.06572518f, 0.14305681f, 0.06863594f, -0.24657457f, 0.04879714f, 
    -0.33971518f, 0.25440454f, 0.19176228f, -0.16562377f, 0.18920505f, -0.01539457f, -0.15946032f, -0.12924603f, 
    0.08326928f, -0.01075509f, 0.03397072f, -0.03371798f, 0.13433298f, -0.02333715f, 0.19132970f, 0.04032425f, 
    -0.02299155f, 0.14359790f, 0.12576096f, 0.00261412f, 0.08476533f, -0.02863066f, -0.13925625f, 0.12102690f, 
    0.07232414f, -0.03015933f, 0.03267088f, 0.30879301f, -0.05026458f, 0.18142897f, -0.01576978f, 0.06378164f, 
    -0.03762274f, 0.05907725f, -0.02171782f, 0.21489441f, -0.32673982f, -0.15636890f, -0.08426911f, -0.12560666f, 
    0.08520727f, 0.04398068f, -0.10260933f, 0.08009791f, 0.17980829f, 0.03572176f, -0.14187299f, 0.05942322f, 
    -0.35782623f, -0.28062367f, -0.00354992f, 0.02713756f, 0.13597997f, -0.04791035f, 0.09187116f, 0.07779728f, 
    -0.03366195f, 0.06024238f, -0.04131868f, -0.02083751f, -0.39800206f, 0.13083941f, 0.41754878f, 0.16541353f, 
    0.00969958f, -0.08505448f, -0.07223208f, 0.20856623f, 0.11684297f, -0.03337073f, -0.13520040f, 0.05707898f, 
    -0.28690001f, 0.22026578f, -0.11462164f, -0.02608193f, -0.05360675f, 0.06133310f, -0.03961400f, 0.04320058f, 
    0.13311327f, -0.01933769f, 0.07334738f, -0.10516550f, 0.14292280f, -0.08574419f, 0.02043463f, 0.19182362f, 
    -0.00460516f, -0.00475555f, 0.01164308f, 0.05430240f, 0.01844020f, -0.06527194f, 0.02968080f, -0.00885231f, 
    -0.00038753f, 0.19401126f, 0.26192847f, -0.08656937f, -0.09074856f, -0.14322418f, -0.02260562f, 0.03080163f, 
    0.03350013f, 0.09906872f, -0.05554605f, -0.11445966f, -0.01961225f, 0.17174783f, 0.10897285f, -0.08593511f, 
    -0.03540411f, -0.05589887f, 0.00053111f, 0.18559568f, 0.11571622f, -0.00071850f, 0.10402928f, -0.06296042f, 
    0.12215915f, -0.23587915f, -0.27361301f, 0.01471369f, -0.01950440f, 0.06470609f, 0.09124313f, 0.09047525f, 
    -0.01553338f, -0.08336552f, 0.16245538f, -0.08000240f, 0.23255649f, 0.09637093f, -0.15742698f, -0.27267388f, 
    0.03436796f, -0.07361757f, -0.01355674f, 0.01984340f, 0.04535327f, -0.02559454f, -0.03079591f, 0.00625737f, 
    -0.30540526f, 0.24447833f, -0.11935949f, 0.18872227f, 0.04947502f, 0.01180576f, 0.10970339f, -0.03010968f, 
    0.10311217f, -0.08321486f, 0.25900465f, 0.03636906f, 0.09539751f, -0.06846906f, -0.07983132f, 0.02896689f, 
    0.00989964f, -0.10603794f, 0.09999859f, -0.03161073f, 0.02924875f, 0.11124141f, 0.22928461f, -0.11553179f, 
    -0.27930605f, 0.15874003f, 0.04660856f, -0.01692335f, 0.07865568f, 0.07120986f, 0.08058307f, 0.08912893f, 
    0.18811154f, -0.01571307f, -0.02951760f, -0.24262513f, -0.14190541f, -0.03528601f, 0.06731518f, 0.25044701f, 
    0.01464230f, 0.13744660f, -0.03544378f, 0.10461070f, -0.10270474f, -0.08541238f, 0.03174837f, 0.02644916f, 
    0.23232168f, 0.06229653f, -0.63117009f, -0.16443682f, 0.11992968f, 0.07089386f, 0.22698426f, -0.03233346f, 
    -0.03849886f, -0.06192106f, -0.06648477f, -0.05391639f, 0.06996110f, 0.03802659f, 0.08584033f, -0.10866103f, 
    -0.01673755f, 0.03025208f, -0.14515543f, 0.02291884f, 0.01390256f, -0.08095831f, 0.06954112f, 0.04241201f, 
    -0.15941140f, 0.27127662f, 0.11788824f, -0.02553215f, -0.09075376f, 0.14358419f, 0.01715447f, -0.05327853f, 
    0.09254067f, 0.13014396f, 0.03029461f, -0.00004071f, 0.17898323f, -0.06931291f, 0.04917324f, 0.15565263f, 
    -0.00787599f, -0.15584843f, 0.11364722f, 0.00253432f, -0.04230398f, -0.01239902f, -0.06712149f, -0.01266188f, 
    -0.50053585f, -0.07439570f, -0.09089335f, 0.49052840f, -0.00396137f, -0.00851754f, 0.12340686f, 0.22214052f, 
    0.04914932f, 0.16018978f, -0.12689282f, 0.11978038f, -0.09733547f, -0.17966214f, 0.09636810f, 0.00834514f, 
    0.04367763f, -0.03454352f, 0.19666189f, -0.02771318f, 0.01530740f, -0.03667865f, -0.04114106f, 0.01811020f, 
    -0.02819803f, -0.03435996f, -0.01352659f, 0.02273280f, -0.04685675f, -0.03613186f, 0.02847942f, 0.04754594f, 
    0.02148887f, -0.03380076f, -0.01195181f, -0.06957008f, 0.05226472f, -0.03367015f, -0.07516434f, 0.02612901f, 
    -0.01546983f, -0.01612915f, -0.04818439f, -0.04514418f, 0.02315531f, -0.04867534f, -0.06054013f, 0.00849073f, 
    -0.00411829f, -0.01824528f, -0.03075350f, -0.02085184f, 0.01063310f, 0.01109614f, 0.01292996f, 0.05489433f, 
    -0.05034206f, -0.02577263f, -0.02773373f, 0.01073671f, -0.00965879f, 0.07201029f, 0.00519064f, -0.02641769f, 
    0.00493593f, 0.06150980f, 0.00636253f, -0.02233366f, 0.03403907f, 0.00352520f, -0.00484913f, 0.03211895f, 
    -0.00346749f, 0.03904733f, 0.06207250f, -0.07340585f, -0.01092724f, 0.06088805f, 0.04947978f, 0.02590324f, 
    0.04308494f, -0.00533551f, 0.00086010f, -0.06634519f, -0.01359103f, -0.07149871f, -0.03565803f, -0.02758989f, 
    -0.01189685f, -0.02309324f, -0.06716589f, 0.02788581f, -0.06516602f, -0.04376395f, -0.00170499f, -0.07056592f, 
    -0.02729460f, -0.01570108f, 0.03002055f, 0.03018469f, 0.04848375f, 0.06506211f, -0.00834798f, 0.05450931f, 
    0.05203956f, -0.00576191f, -0.05596271f, -0.07441244f, -0.04484005f, -0.01898197f, -0.01076971f, -0.01204945f, 
    0.00672089f, 0.02957778f, -0.06727660f, 0.02707134f, 0.00722473f, 0.07043032f, 0.02941085f, 0.06640863f, 
    0.05315347f, 0.04902238f, -0.07284887f, 0.00735002f, 0.04588125f, 0.04692753f, 0.02126177f, -0.05344800f, 
    -0.02488133f, -0.07338802f, 0.06532468f, -0.06332394f, -0.01358395f, -0.02679284f, -0.06924699f, -0.03910840f, 
    -0.01995820f, -0.05549894f, 0.00960517f, -0.03537467f, -0.01883569f, 0.01526878f, -0.04555438f, -0.04861886f, 
    -0.03844504f, -0.05263191f, -0.02272618f, -0.00420516f, 0.04367527f, 0.00790582f, -0.01557118f, -0.00415132f, 
    -0.02204488f, -0.05445526f, -0.00836323f, 0.04009160f, 0.03266177f, 0.00349721f, 0.02395904f, -0.02985654f, 
    0.04340452f, -0.06412539f, -0.02992430f, -0.06834183f, -0.04258747f, 0.06111887f, 0.05856287f, -0.04238183f, 
    0.01580060f, 0.00487964f, 0.04842807f, -0.06384914f, 0.00334460f, -0.01078065f, 0.00492498f, -0.06254065f, 
    0.02892387f, -0.02415258f, 0.01102647f, -0.03457237f, -0.04519651f, 0.05007465f, -0.06519216f, -0.06951639f, 
    -0.00734841f, -0.02766668f, 0.03985760f, 0.00610315f, 0.03349333f, 0.03250600f, -0.00835282f, -0.06003462f, 
    -0.04837549f, -0.06927039f, -0.04059885f, -0.08013612f, -0.02606535f, -0.03184856f, 0.02018852f, -0.03097471f, 
    -0.01777622f, -0.06597608f, -0.02915142f, -0.05563021f, 0.03757861f, -0.02129635f, -0.07457282f, -0.01763434f, 
    -0.00039289f, -0.01608567f, 0.02069923f, -0.00799085f, -0.05813717f, -0.02133929f, -0.06113709f, -0.03410515f, 
    -0.10551050f, 0.01042176f, -0.02293631f, 0.11080303f, 0.08063576f, 0.06240816f, 0.00645268f, 0.03745819f, 
    0.23745948f, 0.02165964f, 0.07595251f, 0.21663395f, -0.01484230f, -0.25202000f, -0.16244024f, 0.01157372f, 
    -0.01954846f, 0.15347415f, -0.01602655f, -0.11635467f, 0.19646965f, -0.06987148f, -0.01023431f, 0.04507963f, 
    0.28837082f, -0.08113685f, -0.04379318f, 0.00517235f, -0.05766734f, -0.01517360f, 0.00076047f, -0.17218672f, 
    0.14501610f, -0.12048244f, -0.08911267f, 0.16343282f, 0.07279904f, 0.02532812f, -0.04712544f, 0.02873562f, 
    -0.00345543f, 0.11431997f, 0.02341422f, 0.02730420f, 0.17326455f, 0.15652552f, 0.01212052f, 0.12018292f, 
    -0.24464826f, -0.21331526f, 0.01546503f, 0.20824905f, 0.02905089f, 0.07308067f, -0.08094382f, 0.01623011f, 
    -0.12327452f, -0.20712939f, -0.11814424f, -0.16678534f, -0.22210351f, -0.19732058f, 0.03320508f, -0.08064014f, 
    0.04023597f, 0.06722676f, 0.10414594f, 0.06927902f, 0.07366527f, 0.05690201f, 0.02142010f, 0.14530377f, 
    -0.11271508f, 0.14980491f, -0.06850463f, -0.12827535f, -0.09574874f, 0.00502897f, -0.06327467f, 0.02870392f, 
    0.14950712f, 0.00633647f, 0.07397233f, -0.03408330f, 0.20089862f, -0.08816820f, -0.09776311f, -0.25770184f, 
    0.02545442f, 0.02946104f, -0.10986380f, -0.11713816f, -0.10666214f, 0.00197740f, -0.03005933f, -0.07423728f, 
    0.06243888f, 0.19135155f, 0.12808748f, -0.01645044f, 0.10447185f, 0.17141028f, 0.11700611f, -0.01944165f, 
    0.00235680f, 0.00427051f, -0.09329677f, 0.16388433f, -0.04615574f, -0.17384130f, 0.07602711f, 0.08580071f, 
    0.06780510f, 0.06015123f, 0.16598417f, -0.15828145f, -0.01677415f, -0.17081770f, -0.07352848f, -0.02057249f, 
    0.00513880f, 0.44454363f, -0.04079275f, 0.13714409f, 0.09361829f, 0.05336148f, -0.01440198f, 0.17302105f, 
    -0.03531822f, -0.02483805f, -0.01820633f, 0.01250768f, 0.16671725f, -0.01577066f, -0.04280790f, 0.05796483f, 
    -0.02715684f, 0.07963136f, 0.11099399f, -0.13023536f, -0.10672737f, -0.04142148f, -0.07179411f, -0.05500690f, 
    0.13822104f, 0.14689812f, -0.04687268f, 0.04084560f, -0.04356265f, -0.00852410f, 0.12649600f, 0.17979942f, 
    0.03870689f, 0.00809771f, 0.07112658f, 0.02820768f, -0.23548973f, -0.25107846f, 0.05020105f, -0.11963574f, 
    -0.05706270f, 0.05983032f, 0.06151928f, -0.11723999f, -0.10669065f, 0.05734199f, -0.19329301f, -0.13137488f, 
    -0.24979037f, -0.19034185f, 0.30051997f, 0.33828533f, 0.12399185f, 0.13460244f, -0.06975059f, -0.26326606f, 
    0.07451174f, -0.06997172f, -0.11836954f, -0.04058723f, 0.23027422f, 0.26353800f, -0.16978417f, -0.12361486f, 
    -0.11220588f, 0.05187051f, -0.01200446f, 0.04502708f, 0.13879539f, -0.01386224f, 0.03141308f, -0.12046434f, 
    0.29374593f, 0.05306423f, 0.03142573f, 0.04115649f, 0.08829979f, -0.03164754f, 0.01991904f, -0.03712536f, 
    0.03944848f, -0.09038498f, 0.02124049f, 0.18383583f, 0.01777781f, 0.10093628f, -0.10766738f, -0.01498536f, 
    0.15068626f, 0.05947715f, 0.00189073f, 0.08309031f, 0.13639301f, 0.14051579f, 0.02667613f, 0.08088170f, 
    -0.13018903f, 0.42377952f, -0.15187278f, 0.18561041f, 0.01073040f, -0.11300281f, 0.12164024f, 0.10529701f, 
    -0.05139817f, -0.01412794f, 0.02981229f, -0.04612285f, -0.07593895f, 0.11813924f, -0.26739258f, -0.14255081f, 
    0.07180955f, -0.09585245f, -0.17000444f, -0.20904176f, -0.03020336f, -0.01498414f, 0.07581231f, 0.04100398f, 
    0.07888043f, -0.02673903f, 0.16598259f, -0.05394119f, -0.06396598f, -0.04872100f, 0.16122091f, 0.01304571f, 
    -0.10523672f, -0.07257349f, 0.03080152f, -0.00697953f, -0.12596065f, 0.04427256f, 0.33037570f, 0.16336644f, 
    -0.00816483f, -0.08055510f, 0.11508750f, 0.00222382f, -0.02790044f, 0.04050135f, 0.07675447f, 0.04520357f, 
    0.07790102f, -0.19357449f, 0.18088818f, -0.05355012f, -0.02702809f, -0.02037577f, -0.02438493f, 0.12125151f, 
    0.14725117f, -0.11707851f, -0.10070526f, -0.12546228f, -0.07738547f, 0.35675761f, 0.02786138f, 0.22833574f, 
    0.23654351f, -0.01202420f, 0.22977585f, -0.24082164f, -0.21052557f, -0.05513855f, -0.03264799f, 0.04958401f, 
    0.06050035f, -0.00494538f, -0.02012812f, 0.05303442f, -0.18766858f, 0.04156809f, 0.10633332f, 0.11107503f, 
    0.04136770f, -0.13554575f, -0.01917159f, 0.02406634f, -0.01017140f, -0.01119693f, 0.02086419f, 0.07330197f, 
    0.02323279f, -0.01256816f, -0.08546650f, 0.14340140f, -0.02152501f, -0.17913164f, -0.02155576f, -0.17304353f, 
    0.42811888f, -0.07820298f, 0.58091229f, 0.05304472f, 0.13361169f, 0.00255536f, -0.05401346f, -0.11141489f, 
    -0.03785970f, -0.09234123f, -0.05506158f, 0.11253121f, -0.03776793f, 0.07766825f, 0.31876558f, 0.18364894f, 
    -0.16447476f, 0.10606196f, 0.08893277f, 0.21514282f, -0.00462485f, -0.04976517f, 0.03623923f, -0.13710806f, 
    -0.07102861f, 0.02753598f, 0.08299243f, 0.19273388f, 0.04924159f, -0.08356111f, -0.22458549f, -0.03981216f, 
    -0.18590522f, -0.00246027f, -0.01202375f, -0.10770705f, 0.07595173f, 0.12142066f, 0.06465685f, 0.09744767f, 
    0.03185996f, 0.07956226f, 0.00439427f, 0.08391527f, -0.05711523f, -0.06522979f, 0.13935646f, 0.04918619f, 
    -0.17698845f, -0.13444236f, 0.18138765f, -0.06453115f, -0.11618030f, -0.01529222f, -0.07744997f, -0.07350057f, 
    0.00518508f, 0.17367443f, 0.07059307f, 0.03058379f, -0.21626854f, -0.37099442f, 0.08940160f, 0.37223750f, 
    0.13045868f, 0.06331331f, 0.21626249f, -0.20672408f, -0.07590094f, 0.12429658f, -0.13055936f, -0.11650962f, 
    0.07972357f, 0.27404726f, -0.19318466f, 0.14632361f, 0.08993194f, -0.01558564f, 0.22905058f, 0.03408499f, 
    0.13813433f, -0.12409228f, -0.08523662f, -0.29405263f, -0.27281776f, -0.13757044f, -0.09060546f, -0.17201079f, 
    0.09763490f, -0.01458358f, 0.01644365f, 0.12746052f, -0.06211977f, 0.12157503f, 0.12077059f, 0.11745597f, 
    -0.29441330f, -0.13866554f, 0.41325256f, 0.15305838f, 0.12848817f, -0.08433577f, 0.05102872f, 0.23983915f, 
    0.11703835f, -0.00921700f, 0.05591280f, -0.01209448f, -0.16030645f, -0.17810655f, -0.02222775f, 0.06121594f, 
    -0.01559459f, -0.03917544f, 0.20531476f, 0.27762327f, -0.05804480f, 0.03268313f, 0.09199132f, 0.03171135f, 
    -0.14630410f, 0.07530223f, -0.24417958f, 0.05551687f, 0.04457705f, 0.00835629f, -0.01086341f, 0.15749508f, 
    0.08095220f, -0.05608430f, 0.16167863f, -0.08119250f, 0.15365428f, 0.17227615f, -0.18318033f, 0.09448122f, 
    0.04711648f, 0.04490137f, 0.16309018f, -0.00955887f, -0.05505597f, 0.01955557f, -0.02810749f, -0.09161848f, 
    0.31392851f, -0.15434536f, 0.09021895f, 0.12193494f, 0.03977946f, -0.08683481f, 0.03505919f, 0.00955509f, 
    -0.03976576f, -0.12455395f, 0.00717274f, 0.07413386f, -0.27024251f, -0.02260977f, -0.13357043f, 0.08710413f, 
    -0.15696256f, -0.02410971f, -0.14772072f, -0.02104304f, 0.25154734f, 0.16335513f, 0.14771259f, 0.15907742f, 
    0.21143815f, -0.26170820f, -0.06806123f, 0.22028218f, -0.00182807f, -0.08033186f, 0.00834923f, 0.06629512f, 
    0.06343779f, -0.09424277f, -0.07346296f, -0.17038481f, 0.01588087f, -0.07408146f, 0.08248352f, -0.01132431f, 
    0.01932966f, 0.24351816f, -0.12351909f, -0.02240817f, 0.16604081f, 0.24565545f, -0.06426550f, 0.06377275f, 
    -0.28925216f, 0.28407258f, -0.11263350f, 0.36684904f, 0.09365900f, 0.13154775f, 0.17623951f, 0.08524152f, 
    0.03310250f, -0.05679843f, -0.05974599f, -0.18248215f, -0.01174807f, 0.09239148f, 0.10590017f, 0.10300484f, 
    0.16591850f, -0.08286540f, -0.11934578f, 0.02742095f, -0.01611183f, 0.07533794f, -0.08151720f, 0.09457944f, 
    -0.03710288f, -0.02979706f, 0.11527834f, 0.11224326f, 0.10462541f, 0.05224665f, -0.10574341f, 0.02635775f, 
    0.00034096f, 0.07061239f, -0.12650006f, 0.00271726f, -0.06676655f, -0.09234614f, -0.06192074f, -0.10888145f, 
    -0.02624056f, -0.04698002f, -0.08344124f, 0.07398523f, 0.07434177f, -0.01609061f, 0.01178554f, 0.06237151f, 
    0.40973222f, 0.13016805f, -0.32921916f, 0.10903705f, -0.15173540f, -0.11299328f, 0.03133722f, -0.10591526f, 
    -0.06141875f, -0.03358360f, 0.10051294f, 0.11028393f, -0.29766038f, -0.20121843f, 0.33519247f, 0.02544775f, 
    0.03222645f, 0.04538277f, 0.07741241f, -0.07034779f, -0.00759945f, 0.01663284f, -0.02692263f, 0.06496184f, 
    0.20531558f, 0.12716796f, 0.11310393f, -0.04633972f, 0.02010142f, 0.04324520f, -0.08302391f, 0.03519286f, 
    0.02015165f, 0.10959107f, 0.16395192f, 0.06700853f, -0.05677704f, 0.18904012f, -0.00564688f, 0.02455302f, 
    0.05421549f, 0.07869358f, 0.08829531f, 0.17589027f, 0.13281390f, 0.08696445f, 0.15421267f, -0.00315572f, 
    -0.58174282f, 0.35389993f, -0.42466176f, 0.19791856f, -0.18622945f, -0.00942578f, 0.01996692f, 0.00924853f, 
    -0.03468088f, -0.00845574f, -0.03995182f, 0.01503592f, -0.14680587f, 0.34729078f, -0.35640633f, -0.18355876f, 
    -0.01338131f, -0.07976465f, 0.08345118f, -0.10968363f, 0.05991906f, 0.18909338f, 0.07516430f, 0.11260141f, 
    0.28927034f, 0.09322318f, 0.11041987f, -0.04169728f, -0.08589554f, -0.04030990f, 0.07698087f, 0.02322725f, 
    -0.13946378f, -0.00603132f, -0.00070962f, -0.07737492f, 0.01717639f, -0.00421992f, 0.36338249f, 0.29214725f, 
    0.00096271f, -0.03133364f, 0.11807247f, 0.15376145f, -0.07343008f, 0.09882851f, 0.25199860f, -0.00441144f, 
    0.11830206f, -0.17584714f, 0.31983659f, -0.07288844f, 0.18611820f, 0.05672664f, 0.00714609f, 0.11275665f, 
    0.11018670f, 0.00034276f, 0.14121011f, 0.05753162f, -0.19152738f, 0.08519248f, -0.15416953f, 0.04917539f, 
    0.10248529f, -0.08645906f, 0.20283598f, -0.26264516f, -0.24424879f, -0.03337974f, -0.18758313f, 0.13403441f, 
    -0.13246740f, -0.15877016f, -0.04162954f, -0.26786950f, -0.21832852f, 0.06846136f, 0.09829109f, -0.12719066f, 
    0.04307580f, -0.06651226f, 0.01046753f, 0.06944352f, -0.05472588f, -0.06666200f, -0.07347207f, -0.06865507f, 
    0.02661470f, -0.00081815f, 0.12780492f, 0.03523969f, 0.07037864f, -0.18761490f, -0.12453238f, -0.14684276f, 
    0.61877364f, -0.35141072f, 0.60503602f, -0.19963773f, 0.07861565f, -0.07405546f, -0.09609209f, -0.00596639f, 
    -0.15575437f, 0.01778037f, -0.09395884f, 0.00746312f, -0.11393403f, -0.11837019f, 0.28412992f, -0.26090798f, 
    -0.06144616f, 0.01099762f, -0.05172914f, 0.03380848f, 0.07719855f, -0.04944278f, 0.09838487f, -0.01803577f, 
    0.08542357f, 0.15447760f, 0.09015723f, -0.09112962f, 0.18936503f, -0.17544703f, -0.11030748f, -0.03472899f, 
    0.01606220f, -0.02271477f, -0.08856919f, -0.08629370f, 0.08491618f, 0.33451799f, -0.07918376f, 0.36285383f, 
    -0.10964569f, 0.25836402f, -0.00028277f, 0.07638560f, -0.09471882f, -0.12991019f, 0.03727451f, -0.09576617f, 
    0.04339699f, -0.15603286f, 0.33752939f, -0.06981437f, 0.12904496f, -0.13147670f, 0.07320969f, -0.10589349f, 
    -0.07782140f, 0.05321783f, 0.12519433f, 0.05655644f, -0.07427880f, -0.30842435f, -0.16978091f, 0.03754011f, 
    0.07497143f, -0.00491031f, 0.23406386f, -0.19927287f, -0.00755722f, 0.05639380f, 0.08870642f, -0.00190478f, 
    -0.22419254f, 0.32086533f, -0.09068093f, 0.10174317f, -0.00615086f, 0.01653369f, 0.13500752f, 0.01888632f, 
    0.11240409f, -0.10033105f, -0.00305577f, -0.10308053f, -0.04707314f, -0.09204429f, 0.04837145f, 0.05840606f, 
    -0.04874166f, 0.05110342f, -0.03297776f, 0.07769748f, 0.07165676f, 0.08262897f, 0.11088784f, 0.18845271f, 
    -0.10390434f, -0.30989969f, 0.06333055f, -0.07074353f, 0.01791877f, -0.03848412f, -0.01271911f, 0.14245424f, 
    0.03094408f, -0.04712322f, 0.06117747f, -0.05117733f, -0.25593558f, -0.27775180f, -0.20547912f, -0.20965585f, 
    -0.19756420f, -0.16138479f, -0.09824175f, -0.04787849f, -0.00686210f, 0.05795353f, 0.15548480f, 0.02303083f, 
    0.23656103f, 0.09895035f, -0.22071151f, 0.05227930f, 0.11729515f, -0.10352597f, 0.03111782f, 0.08583912f, 
    0.03248978f, -0.15742812f, 0.05098131f, -0.02151286f, 0.49684414f, 0.02523058f, -0.05728301f, 0.10161744f, 
    0.21450736f, 0.11628707f, 0.10428404f, -0.16739134f, -0.09999484f, -0.00487883f, 0.20002283f, -0.08090829f, 
    -0.01663679f, -0.03771156f, 0.08915723f, 0.23325810f, 0.06600929f, 0.11083563f, 0.15704191f, -0.07977555f, 
    -0.01191751f, -0.01628602f, 0.06082669f, 0.11537344f, -0.35614368f, -0.09137549f, -0.27794936f, 0.03035041f, 
    -0.08452174f, 0.14912669f, -0.04943545f, -0.09417210f, 0.39863181f, 0.20544137f, 0.17983925f, 0.21221404f, 
    -0.18359742f, -0.21047109f, -0.07764782f, 0.08653931f, -0.04443718f, -0.08139590f, 0.05908341f, 0.12334594f, 
    0.07406900f, -0.19773041f, 0.02106071f, -0.25222126f, -0.01967367f, -0.06395256f, 0.07658344f, -0.03344543f, 
    0.08073755f, 0.15731707f, -0.10553482f, -0.15840423f, -0.15399860f, 0.00093273f, -0.17966042f, -0.04563170f, 
    -0.03100119f, 0.31758860f, -0.44204625f, 0.18070424f, 0.17888875f, 0.01189739f, 0.20678492f, -0.01637797f, 
    -0.09173879f, -0.05464954f, 0.10461920f, 0.04036807f, -0.03632673f, -0.10996761f, 0.10339815f, -0.15357952f, 
    0.09485782f, 0.02169396f, -0.06102942f, 0.18233378f, -0.00235673f, -0.01988713f, -0.06237052f, -0.14402689f, 
    -0.03502240f, -0.03205796f, 0.27316898f, -0.07325705f, 0.00140231f, -0.02296023f, -0.11563309f, 0.13074324f, 
    -0.08496351f, -0.13783991f, -0.12036385f, 0.04411208f, 0.17702140f, 0.00467574f, 0.05833600f, 0.02759411f, 
    0.11946898f, -0.13036996f, 0.00919679f, 0.07598886f, -0.04131562f, 0.01309737f, -0.00018724f, -0.01327367f, 
    0.25056428f, 0.25853360f, -0.15875795f, 0.26405865f, 0.00161806f, -0.00769268f, 0.20144662f, 0.03245003f, 
    0.11286177f, 0.05948925f, 0.21176839f, 0.19242668f, -0.28172323f, -0.12872358f, 0.44139850f, 0.02595344f, 
    -0.00210477f, -0.04820571f, 0.22878818f, -0.07550199f, 0.00562156f, -0.10778354f, -0.01288049f, 0.02913863f, 
    -0.12471683f, 0.17238793f, -0.01100376f, 0.01904210f, 0.04293938f, -0.06665591f, -0.07342963f, 0.03231055f, 
    -0.06145075f, 0.03033515f, 0.01789228f, 0.04509570f, 0.00429079f, -0.21159679f, -0.18775345f, -0.03085447f, 
    -0.29896888f, -0.03327969f, -0.25894958f, -0.17665452f, 0.09570534f, 0.02137517f, 0.06178633f, 0.05390897f, 
    0.28876457f, 0.14467476f, 0.04409041f, 0.05011699f, -0.09595162f, 0.01425272f, -0.04403293f, -0.10431831f, 
    0.09271577f, 0.07143006f, 0.02551780f, 0.05218140f, 0.33546647f, 0.19270587f, 0.26471645f, -0.01042524f, 
    0.00817076f, 0.11310562f, -0.12104943f, -0.07076192f, 0.10368834f, -0.05787361f, 0.02609618f, 0.02826245f, 
    -0.45341787f, -0.30663607f, -0.09632773f, -0.07037479f, -0.00433223f, 0.05819165f, -0.05449286f, -0.11597729f, 
    -0.12003179f, -0.02494534f, -0.02577071f, 0.09711963f, -0.09638032f, 0.16565636f, 0.22765295f, -0.06981384f, 
    -0.01296217f, 0.05055172f, 0.07622761f, 0.12730037f, 0.05329855f, 0.06814764f, 0.04823258f, 0.04216765f, 
    -0.17266275f, 0.35453752f, -0.03218459f, -0.01000072f, 0.13905402f, 0.08201232f, 0.14914377f, 0.00255961f, 
    0.04148594f, -0.00069748f, -0.12400918f, 0.10823254f, 0.24720113f, 0.01093406f, 0.17150590f, -0.25480199f, 
    0.03097639f, -0.05765657f, -0.02527232f, 0.01811051f, -0.20301098f, -0.00408487f, -0.06859728f, -0.11434219f, 
    -0.03871337f, 0.50832272f, 0.21979329f, 0.10461752f, 0.23001185f, 0.14418560f, 0.05003227f, 0.02077237f, 
    -0.03315854f, 0.05455342f, -0.08100568f, 0.11280834f, -0.02973571f, -0.09480943f, -0.11398876f, 0.02965025f, 
    -0.01290577f, -0.14691319f, 0.15527631f, 0.12663029f, 0.03289979f, 0.02602684f, 0.13719136f, 0.11382181f, 
    0.06493601f, 0.15045339f, -0.02348345f, -0.17297271f, -0.08089039f, -0.04405841f, -0.03213554f, 0.17246245f, 
    -0.13287349f, 0.03420935f, -0.04193233f, 0.07652655f, 0.12685791f, 0.08171121f, 0.14829187f, 0.26068231f, 
    -0.13829997f, 0.11038993f, 0.19862163f, -0.04249848f, -0.04409191f, 0.03688005f, 0.02149414f, 0.07602885f, 
    0.03847454f, 0.20685434f, 0.12886833f, 0.17248240f, 0.03260003f, 0.10645597f, 0.14918292f, 0.14084718f, 
    0.03740610f, -0.01133440f, 0.03520258f, 0.03478105f, -0.37985873f, -0.29097894f, -0.09788586f, -0.16782990f, 
    0.04049076f, 0.16221087f, 0.03683302f, -0.13481027f, 0.12714028f, 0.10805592f, -0.03275825f, -0.04562959f, 
    -0.50809705f, -0.33225948f, 0.08524360f, 0.08143517f, 0.03993398f, -0.01069087f, -0.12510110f, -0.06909636f, 
    0.14300135f, 0.02094851f, -0.07340302f, -0.05296917f, 0.13857225f, 0.24531703f, 0.06792410f, 0.24181947f, 
    -0.11181998f, -0.06925511f, -0.16310094f, 0.16567244f, 0.05874043f, 0.01067012f, -0.12454090f, -0.05451954f, 
    0.33653039f, -0.12348063f, 0.10001583f, -0.02872557f, -0.02009857f, 0.09080400f, -0.05218894f, 0.06819911f, 
    -0.09277126f, -0.00007639f, -0.22967662f, -0.16654374f, -0.10345592f, -0.05455590f, -0.08094903f, -0.12976457f, 
    -0.03447779f, -0.04014699f, -0.04066433f, -0.05032186f, 0.00319153f, 0.20090039f, 0.19111791f, 0.10704127f, 
    -0.25620535f, -0.04373905f, -0.26436087f, 0.04222119f, -0.01335285f, 0.02518998f, 0.10497171f, 0.07704023f, 
    0.02677671f, 0.02051210f, -0.04389986f, -0.18361248f, 0.05075511f, 0.13417654f, -0.14165169f, -0.05647580f, 
    0.11548587f, -0.05216888f, -0.02161643f, -0.08800493f, -0.11808836f, -0.10093654f, -0.13923623f, -0.21068950f, 
    -0.15630186f, 0.07457406f, 0.13631964f, -0.14222549f, -0.05608396f, -0.09936181f, -0.10130414f, -0.01801171f, 
    -0.01793481f, 0.12719488f, 0.13793193f, 0.08077738f, -0.30112162f, 0.14459829f, 0.04898749f, 0.26428199f, 
    0.03126865f, 0.00032553f, 0.04222805f, 0.21269907f, -0.13831924f, -0.03298609f, 0.02456115f, 0.04079945f, 
    0.37085319f, -0.09373281f, 0.23393184f, 0.01745093f, 0.10041816f, -0.06861038f, 0.02984593f, 0.18969749f, 
    0.04409724f, 0.04019749f, 0.00322832f, 0.01480079f, -0.06061328f, -0.00455857f, 0.17002846f, 0.15296431f, 
    0.02227597f, -0.02611518f, 0.06168590f, 0.00080038f, 0.10183357f, 0.14664073f, 0.06980342f, 0.03505636f, 
    0.17674667f, -0.01848825f, -0.10279265f, -0.03347442f, 0.09392239f, 0.12508205f, 0.16256790f, 0.09024753f, 
    0.08980186f, 0.00110899f, -0.11558961f, 0.13345513f, -0.07797559f, -0.08948583f, -0.09125083f, -0.22131617f, 
    0.13726258f, 0.03595336f, 0.07070258f, -0.04403901f, 0.00537085f, 0.10641602f, 0.14490132f, 0.14684798f, 
    0.03903710f, -0.38623771f, 0.59511793f, 0.01816571f, -0.07345082f, -0.19695388f, -0.08685984f, 0.07382973f, 
    -0.07512909f, 0.09137886f, -0.04558857f, 0.03964442f, -0.01861815f, -0.05202040f, 0.09170197f, 0.16969681f, 
    0.04187798f, -0.02944331f, 0.03546478f, 0.05460721f, 0.08655989f, -0.05757751f, 0.05799781f, 0.02822362f, 
    0.11748060f, -0.04239651f, -0.12126169f, 0.07478770f, 0.01932376f, -0.00989506f, -0.08035561f, -0.12390319f, 
    -0.14382869f, -0.14718302f, -0.02526223f, -0.11091448f, -0.26042229f, 0.24710344f, -0.07384312f, 0.11043513f, 
    -0.06433219f, 0.08039080f, -0.11050091f, 0.06905445f, 0.04951554f, 0.04915974f, 0.14470138f, 0.20454514f, 
    0.32469812f, 0.12107726f, -0.04976377f, -0.20436330f, -0.12248046f, -0.18003315f, -0.16442803f, -0.07889201f, 
    0.08022628f, -0.04928588f, 0.04035144f, 0.01429830f, 0.15130088f, 0.04394547f, -0.15193689f, 0.00528316f, 
    0.03952476f, 0.02154931f, -0.00556064f, -0.02889855f, -0.04150219f, 0.04539271f, 0.00432037f, 0.08321381f, 
    0.04803504f, -0.08074894f, 0.01921214f, 0.06470322f, 0.01729168f, 0.00815262f, 0.01100180f, -0.05233341f, 
    0.00793517f, 0.01391533f, -0.07625493f, 0.02098841f, -0.00054264f, -0.05038780f, -0.03806792f, -0.05217894f, 
    -0.05006750f, 0.01715021f, -0.02108073f, -0.10630948f, 0.00718397f, -0.03609992f, -0.01349752f, 0.00498300f, 
    -0.03653948f, 0.05721615f, 0.05737297f, 0.01433182f, -0.10307369f, -0.09460343f, -0.06041642f, 0.01986496f, 
    0.02338579f, -0.10702221f, -0.07179898f, -0.04201686f, 0.00476196f, 0.01045978f, -0.00913166f, 0.03272896f, 
    -0.00942386f, -0.04638361f, -0.06892572f, -0.00027853f, -0.07552642f, -0.06176485f, -0.04241567f, 0.01868778f, 
    -0.06864371f, -0.01818489f, -0.09303477f, 0.01837539f, -0.06764819f, -0.00452572f, -0.06674457f, 0.03172181f, 
    -0.06491543f, -0.00105810f, 0.03015661f, -0.04394036f, 0.00009273f, 0.01316455f, -0.02354298f, -0.00540240f, 
    -0.06566462f, -0.01537171f, 0.00256058f, -0.06316587f, -0.04705470f, -0.06325019f, 0.03797290f, 0.01256954f, 
    -0.03557160f, 0.00461986f, -0.04025624f, -0.01606932f, -0.06498695f, -0.00285485f, -0.05661744f, 0.01021804f, 
    -0.03909940f, 0.03769233f, -0.02001033f, 0.06110255f, -0.07664872f, -0.05401989f, 0.01145410f, 0.05485620f, 
    -0.00685645f, 0.02173549f, -0.02231081f, 0.00621584f, 0.01501711f, 0.01171357f, -0.11258785f, -0.01748238f, 
    0.00879312f, -0.04986510f, 0.02003497f, -0.06812817f, 0.00961638f, -0.07704169f, -0.04055019f, 0.01598054f, 
    -0.02351212f, 0.04995912f, 0.03276879f, -0.00803987f, -0.06263422f, 0.00796738f, -0.08817546f, -0.07881012f, 
    0.03206916f, -0.01555244f, -0.07152042f, 0.01881407f, -0.00692443f, -0.05356785f, -0.10494926f, 0.00533439f, 
    -0.06662119f, -0.00765254f, -0.00655257f, -0.05018037f, -0.05903433f, 0.00684557f, 0.02301762f, -0.04587702f, 
    -0.04960772f, -0.02121772f, 0.02879202f, 0.01308746f, -0.06545349f, 0.05743368f, -0.06920496f, 0.03321623f, 
    0.01410029f, -0.07347144f, -0.02178768f, -0.07258949f, 0.02698466f, -0.04833768f, -0.06633352f, -0.06950018f, 
    -0.03972648f, 0.03884646f, 0.01116098f, -0.02044101f, -0.02065322f, -0.06018739f, -0.07745181f, 0.03433506f, 
    0.03091536f, -0.03061078f, 0.00511713f, 0.02856071f, -0.08438453f, -0.04289598f, -0.04363719f, 0.03235481f, 
    -0.05284974f, 0.02536216f, -0.03290525f, -0.06256863f, -0.09522886f, 0.00977416f, -0.05694837f, -0.05838644f, 
    -0.01815361f, 0.05407366f, -0.06767043f, -0.07161698f, -0.03413991f, -0.03952441f, -0.01189031f, 0.03051335f, 
    -0.06899788f, -0.00291830f, -0.05402547f, -0.05806160f, 0.05395640f, 0.02604295f, -0.05324150f, -0.04812634f, 
    -0.06624582f, -0.01960001f, 0.01846442f, -0.06880409f, -0.05973543f, -0.06461150f, -0.04058052f, 0.05949700f, 
    0.10501690f, 0.03207609f, 0.00147506f, 0.13534188f, 0.02218794f, 0.05907325f, -0.06642109f, -0.01540789f, 
    0.02639320f, -0.03576684f, 0.06394585f, 0.08640596f, -0.06316410f, -0.07248548f, 0.01613340f, -0.05268874f, 
    -0.21313445f, 0.02788596f, -0.21481261f, -0.00278399f, 0.11144087f, 0.03383869f, -0.03239247f, 0.03091484f, 
    0.23379983f, 0.37050208f, 0.07690420f, 0.17612989f, -0.08750749f, -0.20162827f, -0.00846308f, -0.11547315f, 
    -0.05202536f, 0.10889167f, -0.01976953f, -0.01957103f, 0.11306778f, 0.28834867f, 0.13674219f, -0.05601185f, 
    0.16371895f, -0.06371067f, 0.03441686f, 0.09212799f, 0.13933651f, 0.05867155f, -0.08408659f, -0.02387452f, 
    -0.33274597f, -0.17034620f, -0.02543095f, 0.15232943f, -0.02603191f, 0.12819946f, -0.16543032f, -0.09679193f, 
    -0.11744928f, -0.02612091f, 0.10683782f, 0.09784001f, -0.19817588f, 0.12794942f, -0.05995961f, -0.04014974f, 
    -0.01957720f, -0.27416018f, 0.06435625f, 0.29888621f, 0.12761168f, -0.07741646f, -0.07127915f, 0.12605819f, 
    -0.19366524f, 0.08527137f, -0.01407960f, -0.16220391f, 0.10435671f, 0.00139177f, 0.01010613f, 0.08663967f, 
    0.01837275f, -0.04158181f, 0.10419273f, 0.03008453f, 0.30544809f, 0.22719967f, 0.11246350f, -0.02349942f, 
    0.03513359f, -0.20716165f, 0.00014926f, -0.05759712f, -0.14479122f, 0.08152159f, -0.00240198f, -0.11823834f, 
    0.14265783f, 0.21695253f, 0.11330693f, -0.08548002f, 0.00299244f, -0.00595269f, 0.07228918f, 0.06837419f, 
    -0.05956904f, -0.03631165f, -0.07695091f, 0.24823451f, -0.00233087f, 0.32421285f, -0.05596777f, 0.00329542f, 
    -0.07796630f, -0.11730844f, -0.02281066f, 0.00125498f, 0.01641381f, -0.02161434f, -0.07987568f, 0.08556753f, 
    0.07659926f, 0.03791516f, -0.01004669f, 0.17290457f, 0.08186693f, 0.02597082f, 0.11434115f, -0.02523252f, 
    0.11420234f, 0.02098630f, -0.01528951f, -0.05252527f, 0.17743891f, 0.06281023f, 0.10906695f, 0.11127943f, 
    0.02634917f, 0.03490372f, 0.03938769f, -0.05429067f, 0.02436577f, -0.10115395f, -0.00358704f, 0.20526525f, 
    -0.15525426f, 0.12186704f, -0.00149243f, 0.10842212f, -0.06623198f, -0.10679572f, -0.01153639f, 0.08476390f, 
    -0.08910538f, 0.11618438f, 0.06980440f, -0.21330677f, -0.38326201f, -0.10113326f, -0.01235168f, -0.06865227f, 
    -0.06199041f, -0.01865376f, 0.13266432f, -0.11533397f, -0.07710753f, -0.07896467f, 0.01234102f, -0.02899659f, 
    -0.32674944f, -0.10370395f, -0.10577013f, 0.36337718f, -0.07793075f, -0.00923972f, -0.06994982f, -0.23129214f, 
    -0.09019988f, 0.09358358f, -0.03503218f, 0.11836295f, 0.23005992f, -0.04116974f, -0.24714807f, 0.16359986f, 
    0.03374705f, 0.02136435f, -0.08639840f, 0.06411686f, -0.01003325f, -0.03636249f, -0.07573604f, -0.11040687f, 
    0.06724492f, -0.03697297f, -0.00938140f, 0.04229161f, -0.05914575f, -0.05073652f, -0.00869124f, 0.02151618f, 
    -0.02391328f, 0.02800878f, -0.02980277f, 0.03548684f, 0.03527712f, 0.03252308f, -0.04874744f, 0.05361124f, 
    0.05053299f, 0.06197484f, -0.02963702f, -0.07562128f, -0.00901952f, -0.07083751f, -0.02927691f, -0.06306753f, 
    -0.02515316f, -0.06219902f, -0.00824715f, -0.07629089f, 0.03744923f, 0.00646279f, 0.06139933f, 0.04042227f, 
    -0.03005100f, -0.02590533f, 0.04822044f, 0.06238541f, -0.01328290f, -0.07781329f, -0.00315869f, -0.00672386f, 
    0.05748684f, -0.00957754f, 0.06629211f, 0.06042795f, -0.04812796f, 0.01115198f, -0.03372715f, -0.01950316f, 
    -0.07560300f, 0.01062992f, -0.07992277f, -0.03125558f, -0.08576994f, -0.07061306f, 0.03422020f, 0.05897832f, 
    -0.06805370f, 0.03919307f, -0.07280497f, -0.04443138f, -0.05140666f, -0.05312772f, 0.05874360f, -0.03509030f, 
    -0.03984469f, -0.02924376f, -0.03647218f, -0.02889801f, 0.02764495f, 0.02216976f, 0.05416228f, 0.04937438f, 
    0.06077102f, -0.04437520f, 0.00303433f, -0.00381295f, -0.05569648f, -0.05567070f, -0.04955013f, -0.01127634f, 
    0.03292212f, -0.01825691f, -0.05064471f, 0.05627475f, -0.01337961f, -0.03934836f, -0.01268540f, 0.06742103f, 
    -0.04175820f, 0.05624738f, -0.06579472f, 0.04544923f, 0.00686568f, -0.06288122f, -0.06503578f, 0.04151652f, 
    -0.02340215f, 0.03421653f, 0.01219049f, 0.02805501f, -0.07057509f, -0.00536862f, -0.02963257f, 0.00556122f, 
    -0.02250245f, 0.01014126f, -0.01540543f, 0.02500096f, -0.01344352f, 0.00635344f, 0.02633941f, -0.04822337f, 
    -0.01206781f, -0.03501561f, 0.04324706f, -0.00730524f, -0.05686091f, 0.05821305f, -0.00477529f, 0.01349580f, 
    -0.00901716f, -0.03551735f, -0.07465348f, -0.05338322f, 0.05593614f, -0.00081942f, -0.00957365f, -0.04193260f, 
    0.02054119f, -0.03781413f, -0.01417788f, -0.03903941f, -0.06234597f, 0.00095404f, 0.01907774f, -0.02755050f, 
    -0.07561205f, -0.00421711f, -0.01150741f, -0.01583745f, 0.00491470f, 0.05582215f, -0.05902281f, -0.00462170f, 
    0.04295511f, 0.05689570f, 0.01621213f, -0.05537508f, -0.00091211f, -0.03747076f, 0.02674146f, -0.00662167f, 
    0.01065850f, -0.00392497f, 0.03061284f, -0.01818312f, 0.02675454f, 0.00680354f, -0.04563427f, -0.01870495f, 
    0.03424211f, -0.03835861f, -0.04049752f, 0.01213961f, 0.02018506f, 0.02052463f, 0.05694886f, -0.04799915f, 
    -0.06328313f, -0.03379020f, -0.02514485f, 0.00976616f, -0.06344926f, 0.03205401f, -0.04955724f, -0.03012038f, 
    0.05014469f, -0.04476251f, -0.02394196f, -0.04267187f, -0.02683028f, 0.01157434f, 0.03214844f, -0.06242401f, 
    -0.06958126f, -0.01136228f, -0.01004628f, 0.00146181f, 0.05506996f, 0.05302267f, -0.05657503f, -0.04461548f, 
    0.14692663f, -0.11954544f, 0.06115564f, -0.03172860f, -0.02978097f, 0.05307700f, 0.10322460f, 0.08510318f, 
    0.16916879f, 0.13377559f, 0.13145496f, 0.22415519f, 0.02519625f, 0.03249030f, -0.02522165f, -0.07036427f, 
    0.08411253f, 0.01489957f, -0.02424523f, -0.03127696f, 0.12001580f, 0.17714319f, 0.07903254f, -0.06668075f, 
    -0.18249995f, 0.09155647f, 0.31866989f, 0.20575142f, -0.11161463f, -0.14627992f, 0.03272597f, 0.17517912f, 
    0.03096018f, 0.06982283f, 0.03530725f, 0.06375655f, 0.02311398f, -0.06738295f, 0.11066630f, -0.04052547f, 
    0.05861220f, 0.15854350f, 0.03638813f, -0.02378192f, -0.02950488f, -0.01518909f, 0.06864688f, 0.17925991f, 
    0.15928300f, 0.08166137f, -0.01343254f, -0.18058564f, -0.21644685f, -0.12954484f, 0.05533251f, -0.06115815f, 
    0.04825058f, -0.04048891f, -0.09548140f, 0.01950475f, -0.26662591f, 0.24394700f, 0.06851941f, 0.15162948f, 
    -0.11013417f, 0.08812772f, 0.16858864f, 0.05641174f, -0.05101325f, 0.22322552f, 0.05675584f, 0.14177977f, 
    0.22567701f, -0.07817727f, -0.00265296f, 0.10763328f, 0.10296161f, 0.05959485f, 0.14671178f, 0.15121870f, 
    0.15048254f, 0.17970255f, 0.02634104f, 0.09463470f, 0.01514715f, 0.19890806f, 0.18686374f, 0.06998978f, 
    -0.00148749f, -0.11434673f, 0.02744245f, 0.05962191f, -0.02533652f, 0.21771620f, 0.04784445f, 0.12432323f, 
    -0.07667123f, -0.12832528f, -0.04688900f, 0.05064920f, 0.03187769f, 0.01418723f, -0.11221898f, -0.06798370f, 
    -0.07590359f, 0.06054015f, 0.08511095f, 0.09045228f, 0.06446794f, -0.08006036f, -0.24422513f, -0.10390376f, 
    -0.01714065f, -0.11127105f, -0.04417524f, -0.04764205f, -0.20761514f, -0.27529317f, -0.03873095f, -0.19953212f, 
    0.10572862f, -0.16382015f, 0.45524058f, -0.09379987f, -0.11280756f, 0.11095846f, 0.03455835f, 0.11083494f, 
    0.04459883f, -0.02207788f, -0.11751150f, 0.09107105f, -0.24260564f, -0.01299640f, -0.15849623f, 0.02575688f, 
    0.01892025f, 0.02067736f, 0.08631521f, 0.04572677f, -0.01742088f, 0.13085948f, -0.00533505f, -0.05124761f, 
    -0.42226261f, -0.27447206f, -0.20010330f, -0.09867901f, 0.14642249f, -0.16842641f, 0.02171220f, -0.09093989f, 
    -0.09749956f, -0.08330552f, -0.00916377f, -0.11483179f, 0.15026230f, 0.15020889f, -0.04535248f, 0.18552433f, 
    -0.13651089f, 0.11759453f, -0.19264220f, 0.02098647f, 0.10640589f, -0.08129913f, 0.00972807f, -0.12052057f, 
    0.19381565f, -0.04074012f, -0.07021412f, -0.18352436f, -0.27754292f, -0.00789039f, -0.15771249f, -0.00032026f, 
    -0.06056949f, 0.02780828f, 0.11718447f, -0.08019123f, -0.23188260f, -0.24849685f, 0.06121784f, 0.19434738f, 
    0.11620656f, 0.06265005f, -0.04803697f, -0.04424295f, -0.20161083f, -0.02328483f, 0.01702519f, 0.08964142f, 
    0.11486622f, -0.05269049f, 0.18246564f, -0.17534800f, -0.01294166f, -0.03018633f, -0.12768340f, 0.04289871f, 
    -0.17352067f, 0.02825299f, -0.26784208f, -0.14179380f, -0.00061027f, -0.00641590f, 0.05478271f, 0.02886380f, 
    -0.18206051f, -0.16022535f, -0.26298493f, -0.22075957f, -0.05953681f, -0.01123727f, 0.00797805f, -0.09878860f, 
    -0.25931129f, -0.18813147f, -0.18557961f, 0.06654213f, -0.02173046f, 0.14777072f, -0.04873719f, -0.13988982f, 
    -0.04383219f, 0.10154154f, 0.12210692f, 0.02402513f, 0.29015094f, 0.03748497f, 0.02905283f, 0.12854274f, 
    -0.02335213f, 0.03323393f, -0.06455687f, 0.03381668f, -0.00762566f, -0.13177179f, -0.16332875f, -0.04777408f, 
    -0.12498044f, 0.21880694f, 0.10254748f, 0.03045825f, 0.06202279f, -0.08385776f, -0.25252780f, -0.08354297f, 
    -0.15034088f, -0.01344895f, -0.12270239f, 0.25520569f, -0.19038554f, 0.18546489f, -0.07204692f, 0.00243602f, 
    0.09177769f, 0.24379966f, 0.03840956f, 0.21112131f, 0.04543629f, 0.07781536f, 0.07845076f, -0.08529750f, 
    0.35079923f, 0.08137779f, 0.09025668f, 0.02290495f, 0.07405245f, 0.08821482f, 0.20510009f, 0.20649382f, 
    0.02422957f, 0.12346759f, 0.01839816f, 0.01686758f, 0.02969810f, -0.18821886f, 0.30439496f, 0.17577550f, 
    0.01153883f, -0.05404615f, 0.00961047f, 0.24257362f, 0.11872226f, 0.19184718f, 0.07041349f, 0.08723536f, 
    0.00082387f, 0.07848855f, 0.03708026f, 0.00439424f, 0.10826494f, 0.12932003f, 0.07853909f, 0.03557632f, 
    -0.05999323f, 0.20474185f, -0.14150213f, 0.11199723f, -0.07038830f, -0.20398383f, -0.26735929f, -0.07084316f, 
    -0.10948221f, -0.28809023f, 0.07544583f, 0.05821336f, 0.02247814f, 0.11377414f, 0.10113464f, 0.22496317f, 
    0.00905838f, -0.21785924f, 0.27934763f, -0.19856824f, 0.00414469f, -0.01604250f, -0.14417624f, 0.28965747f, 
    -0.00334328f, 0.08331551f, -0.02079526f, 0.11729627f, 0.02592447f, -0.09534874f, -0.18694344f, 0.00156168f, 
    0.19339271f, 0.01060227f, 0.27792922f, 0.03793967f, 0.07937391f, 0.10155941f, 0.04940636f, 0.03891271f, 
    0.11304548f, -0.15095432f, -0.26114771f, -0.09617019f, 0.10130921f, 0.02757855f, 0.09625459f, -0.07720976f, 
    -0.03027562f, -0.19695263f, -0.00247560f, -0.09100486f, -0.22194047f, 0.18947975f, 0.01294959f, -0.07908863f, 
    -0.06491003f, 0.07037916f, -0.11276288f, -0.25333214f, 0.00839272f, 0.04035909f, 0.04645133f, 0.21059215f, 
    0.34197041f, 0.11437609f, 0.34650168f, -0.04926293f, 0.05209059f, -0.09149285f, -0.09235606f, 0.17142329f, 
    -0.01564300f, -0.04246133f, 0.20149064f, -0.07967118f, 0.10408793f, 0.44829416f, -0.16986141f, -0.31024450f, 
    -0.05426717f, -0.08024275f, 0.03385766f, 0.11291727f, -0.10908981f, 0.04983661f, -0.14300300f, 0.05612773f, 
    -0.09662353f, 0.34605050f, -0.11224454f, 0.19884464f, 0.04182720f, -0.01921983f, -0.01503067f, 0.03723826f, 
    0.05908519f, -0.20493072f, 0.01628481f, -0.15011713f, -0.21602528f, -0.29656333f, -0.32231539f, -0.16070361f, 
    -0.00728060f, -0.15815064f, -0.06805211f, 0.07890828f, -0.05642558f, -0.07260109f, -0.00930065f, 0.04265017f, 
    -0.00666252f, -0.07000446f, -0.02023640f, -0.13416192f, 0.01855621f, -0.13044916f, -0.08696380f, 0.03245693f, 
    0.08421042f, -0.04622427f, -0.03969568f, -0.09186382f, -0.16102727f, 0.03557298f, -0.08516353f, -0.14463921f, 
    0.14558512f, -0.08085237f, 0.13336784f, 0.21984591f, -0.10343205f, 0.05717758f, 0.13220376f, -0.15238541f, 
    -0.05186319f, -0.31481078f, -0.21508774f, 0.21683407f, 0.00519144f, 0.03416073f, -0.08427375f, -0.09109688f, 
    0.10218621f, -0.04435454f, 0.19792409f, -0.14665268f, 0.34653154f, 0.04868695f, -0.12454452f, -0.11736576f, 
    0.02058220f, 0.05867900f, -0.00592278f, 0.12855558f, 0.06736243f, -0.00305551f, 0.00165042f, -0.00806881f, 
    -0.04806959f, -0.05337587f, 0.10510565f, 0.05868869f, -0.02144701f, -0.01355863f, -0.08324853f, 0.05701033f, 
    -0.01765064f, -0.03359527f, 0.11915403f, 0.14492880f, -0.13575780f, -0.09343495f, -0.32991955f, -0.06362702f, 
    -0.08046383f, -0.06618230f, -0.16193128f, -0.18199262f, 0.12741213f, 0.16364415f, 0.16298468f, -0.02548677f, 
    0.23677024f, -0.03649972f, 0.09971283f, 0.11695642f, -0.06118906f, -0.01159335f, -0.01324910f, 0.04079560f, 
    0.00022803f, -0.07261734f, -0.06348846f, -0.07196996f, -0.01388570f, -0.01403714f, 0.16565956f, -0.02017075f, 
    0.09317417f, 0.05329400f, -0.02959849f, -0.09986510f, 0.10600600f, 0.17391044f, -0.01093121f, -0.05598634f, 
    -0.06143588f, 0.30122066f, -0.51927102f, 0.30163649f, 0.15121384f, 0.17159386f, 0.21371217f, -0.05833400f, 
    0.01975591f, 0.02866532f, -0.01579971f, -0.10604518f, 0.24091810f, 0.26013792f, 0.31712902f, 0.00038486f, 
    0.14942066f, 0.14317696f, 0.05658454f, 0.18503381f, -0.07147513f, -0.11918436f, -0.01227281f, 0.04294228f, 
    0.25280306f, 0.31663436f, 0.26358092f, 0.13775264f, -0.01311344f, 0.11492591f, -0.09467008f, 0.05973420f, 
    0.02007538f, 0.01490381f, 0.01788367f, 0.08006608f, -0.11287687f, -0.19282970f, -0.24947642f, -0.13114364f, 
    0.00520747f, -0.19569956f, 0.04901839f, 0.00313861f, -0.03680796f, 0.04152130f, -0.01677603f, 0.06211216f, 
    -0.40624252f, -0.12763782f, -0.15828031f, 0.29630744f, 0.07713899f, -0.14819309f, 0.02765211f, -0.08901840f, 
    0.02372892f, 0.04443848f, -0.22706300f, 0.14006193f, 0.02387106f, 0.02233035f, 0.22888038f, -0.11303934f, 
    0.01008885f, 0.15748897f, 0.12175578f, 0.04863480f, 0.05275975f, -0.06086187f, 0.08690683f, -0.00685034f, 
    -0.03215900f, 0.03815388f, -0.07341741f, -0.08070882f, 0.00792931f, -0.02118012f, -0.02103954f, 0.00941544f, 
    0.00768291f, 0.02522788f, -0.04301955f, 0.00959921f, 0.00626638f, 0.01603299f, -0.04906883f, 0.01382304f, 
    -0.05929976f, 0.01090901f, -0.05381944f, -0.07829998f, -0.00951436f, 0.00905603f, -0.02927033f, -0.06327906f, 
    -0.07710096f, 0.03705753f, -0.05728002f, 0.05120521f, -0.01012511f, -0.05906325f, 0.00738197f, -0.08027415f, 
    0.01583006f, -0.02612249f, 0.05682353f, -0.03001086f, -0.04114903f, 0.03790803f, -0.04599696f, -0.06164581f, 
    0.01497967f, 0.04916561f, 0.00094796f, 0.03291372f, -0.00923221f, -0.01224951f, -0.00438167f, 0.01283889f, 
    -0.06725668f, -0.04554703f, -0.03508579f, -0.05929415f, -0.07356072f, -0.00370460f, 0.01119300f, 0.05652775f, 
    -0.03320442f, 0.03134355f, -0.05926701f, -0.02431252f, 0.04115002f, 0.01661609f, -0.02854504f, -0.04376935f, 
    -0.02485926f, -0.03618388f, -0.01502382f, 0.06267607f, 0.05161797f, -0.07440156f, -0.06086362f, -0.02873853f, 
    -0.01386047f, -0.04856703f, 0.00025681f, -0.01519038f, -0.00788126f, 0.05017918f, -0.05619764f, -0.07557824f, 
    -0.07703792f, 0.02759637f, -0.00515523f, -0.00774903f, 0.03848518f, -0.03701362f, 0.03548664f, 0.02150204f, 
    -0.00872369f, -0.03494721f, -0.02068020f, 0.00849585f, -0.08125301f, 0.04178077f, 0.01331932f, 0.06057870f, 
    -0.02887313f, 0.04059401f, -0.02284272f, 0.00614030f, -0.05164358f, 0.03767597f, -0.04026488f, -0.01264886f, 
    -0.06868844f, -0.05042710f, -0.02875171f, -0.02150443f, 0.01469893f, 0.01070317f, -0.00193724f, -0.04367124f, 
    -0.07414085f, -0.03292332f, -0.06452087f, -0.01617478f, 0.01743189f, -0.06593367f, -0.06895716f, -0.00526306f, 
    -0.05789787f, 0.03804908f, 0.02949476f, 0.00980694f, -0.01784918f, -0.01345935f, -0.01338371f, -0.06282970f, 
    -0.04501531f, 0.06210160f, 0.02266864f, -0.04728912f, -0.05219566f, 0.05729705f, -0.05072138f, -0.05385811f, 
    0.05691514f, 0.05930475f, -0.03605511f, -0.05393927f, -0.00971281f, -0.00084948f, 0.03049361f, 0.01541903f, 
    -0.03655916f, 0.02420736f, -0.05469799f, -0.02101819f, 0.00667570f, 0.01963034f, 0.04913811f, -0.04418413f, 
    0.05991478f, 0.02146921f, -0.02153464f, 0.03723674f, -0.01571582f, -0.00979102f, -0.00309535f, 0.06072851f, 
    0.05287987f, 0.04206512f, -0.04394183f, -0.02905042f, -0.05752877f, -0.00622450f, 0.00874209f, 0.00473054f, 
    0.05286158f, -0.06069423f, 0.03010977f, -0.05182532f, 0.05407794f, 0.05011624f, 0.03749916f, -0.05107103f, 
    -0.00374632f, -0.01378023f, 0.04709774f, 0.01874292f, -0.04555435f, 0.06133405f, 0.04638224f, -0.02941583f, 
    -0.07399476f, 0.01315833f, 0.00870063f, 0.01660990f, 0.01685367f, 0.00696954f, 0.02176498f, -0.00002833f, 
    -0.14909430f, -0.03741295f, -0.01340162f, -0.17384012f, -0.03082954f, 0.07478351f, -0.03504563f, 0.15349224f, 
    0.15528777f, 0.05290926f, 0.18324459f, 0.08212939f, 0.27460411f, -0.03033301f, 0.00632758f, 0.06456432f, 
    -0.02002684f, -0.06849951f, -0.03412561f, 0.05507999f, -0.04999180f, 0.02732873f, -0.07396424f, 0.08994509f, 
    0.02151356f, 0.29327542f, 0.40098312f, -0.05262244f, -0.17102425f, -0.04398881f, -0.01383460f, -0.12153567f, 
    0.12323330f, 0.07154562f, 0.03351019f, 0.14306164f, 0.03268106f, -0.03716438f, 0.21704639f, 0.10982029f, 
    -0.12752424f, -0.06037116f, -0.01260988f, 0.01885669f, 0.05903830f, -0.04002935f, 0.05623468f, 0.13019180f, 
    0.03463946f, -0.16397740f, -0.18170267f, -0.10277470f, -0.10119171f, 0.03972897f, -0.02877301f, -0.02326527f, 
    0.04271170f, -0.07790083f, -0.15478873f, -0.07496650f, -0.03461194f, 0.30369544f, -0.07159978f, -0.31481957f, 
    0.06891163f, -0.02208507f, 0.00537453f, -0.08487379f, 0.22028396f, -0.00210228f, -0.06198704f, 0.04411434f, 
    -0.23848537f, 0.33483380f, -0.24314030f, 0.09287476f, 0.03739603f, 0.20264667f, 0.08715331f, 0.04514954f, 
    0.12377971f, 0.00512932f, 0.15700310f, -0.00886808f, 0.11430227f, 0.05172460f, 0.14149298f, 0.13784650f, 
    0.10907379f, -0.13741559f, -0.10230429f, 0.03588585f, 0.04586997f, -0.04337054f, 0.06100673f, -0.02589593f, 
    -0.22782762f, 0.34549275f, 0.03633678f, 0.09608158f, 0.16086026f, 0.06488094f, 0.10815247f, 0.01597781f, 
    -0.02187608f, 0.11700259f, 0.08585405f, -0.16911496f, -0.03534891f, -0.18830056f, 0.06194941f, 0.17796001f, 
    0.01564127f, -0.00375296f, 0.08953541f, 0.14725912f, -0.03357989f, -0.12972867f, 0.04396149f, -0.05583676f, 
    0.21162727f, -0.14351036f, -0.32577121f, -0.49481726f, 0.16210963f, 0.03852532f, -0.01927399f, -0.09510782f, 
    0.08313660f, -0.09902292f, -0.06502639f, 0.00707344f, 0.12230822f, 0.04895230f, -0.20706271f, -0.05730417f, 
    -0.12182894f, 0.06314665f, 0.05169607f, 0.08212505f, 0.17404188f, 0.11713386f, -0.06883606f, -0.02034268f, 
    -0.50179714f, -0.16077337f, 0.08461411f, 0.03952022f, -0.00445168f, 0.05401710f, 0.21181914f, -0.20314822f, 
    0.14583310f, 0.00958284f, 0.04009906f, 0.07416309f, 0.22559871f, -0.09966975f, 0.04805631f, -0.00005016f, 
    0.16030429f, -0.05558774f, 0.10089073f, -0.04165968f, 0.04034637f, -0.01624145f, -0.02980024f, -0.07887828f, 
    -0.15925154f, 0.10270402f, -0.08152059f, 0.23601566f, -0.15204947f, 0.15601397f, -0.07011544f, 0.04320486f, 
    -0.01627952f, 0.03743042f, 0.06315290f, -0.21608062f, -0.25131813f, -0.23647892f, 0.03192750f, 0.18894021f, 
    0.18758461f, -0.02635722f, -0.00301730f, -0.10101891f, -0.00600932f, 0.03494621f, 0.09279421f, 0.02181071f, 
    -0.03503470f, 0.19028370f, -0.16703838f, 0.19090314f, 0.09159847f, 0.02753414f, 0.05107084f, 0.06673854f, 
    0.19103251f, -0.02760604f, 0.03039077f, 0.04916665f, -0.06533679f, -0.17946786f, -0.20558709f, -0.11446379f, 
    -0.04443170f, 0.06420931f, -0.14978667f, -0.05612056f, 0.00385126f, -0.15451936f, -0.06419165f, 0.07430847f, 
    0.16866311f, 0.24601120f, 0.25669423f, 0.15455915f, 0.00710819f, -0.11038124f, 0.01795170f, -0.01581638f, 
    0.02459570f, -0.01285454f, -0.16488479f, 0.01008214f, -0.07942390f, 0.22431399f, 0.00361777f, 0.07038510f, 
    0.05520592f, -0.03819317f, 0.02365558f, 0.16725652f, 0.09571293f, -0.00057371f, 0.08906440f, 0.02857050f, 
    -0.20462471f, -0.24005550f, -0.08142867f, 0.07124437f, -0.01674698f, 0.12982787f, 0.03946686f, -0.00912118f, 
    -0.07545930f, -0.13295344f, 0.07161794f, -0.16019128f, 0.21152373f, 0.02084247f, -0.10720365f, -0.23152891f, 
    0.06651141f, -0.13072678f, -0.03229360f, 0.18089674f, 0.18340100f, 0.02605931f, 0.06856728f, 0.05568043f, 
    -0.15037270f, 0.14548956f, -0.03455996f, -0.00199948f, -0.01237796f, 0.08432407f, -0.00561723f, -0.01519782f, 
    0.07636728f, -0.00139178f, 0.11990292f, 0.03666754f, 0.05946857f, 0.01763281f, -0.15423429f, -0.00997544f, 
    -0.07591513f, -0.08880430f, -0.13683669f, -0.14362828f, -0.07888695f, -0.07031918f, 0.02342230f, -0.05409820f, 
    -0.00773818f, 0.01961013f, 0.01395583f, -0.04593012f, -0.01015994f, -0.03545700f, 0.17353883f, 0.15674706f, 
    -0.02737661f, -0.09939568f, -0.13249397f, 0.12297177f, -0.04672055f, -0.06112532f, -0.00309146f, 0.04721621f, 
    0.13336001f, 0.03337507f, -0.00938836f, -0.09585381f, -0.08935543f, -0.05993261f, -0.26149812f, 0.03242692f, 
    0.08737310f, 0.19275433f, -0.33883196f, 0.16892537f, 0.15757273f, 0.06117370f, 0.03741699f, -0.04142552f, 
    0.06945033f, 0.14224339f, 0.04431857f, -0.19713779f, 0.22590125f, 0.13245025f, 0.09625821f, -0.09067666f, 
    0.11095638f, 0.14884159f, -0.08746068f, 0.00890958f, -0.05597407f, -0.04056897f, -0.04622935f, 0.11870041f, 
    0.09171827f, 0.22723097f, 0.11309227f, 0.04142853f, -0.00364757f, 0.12202112f, -0.13320881f, 0.08207054f, 
    0.09359560f, 0.05948208f, 0.01790416f, -0.03617116f, -0.30912173f, -0.26263386f, -0.12429535f, -0.13922684f, 
    -0.02987027f, -0.04871846f, 0.21588664f, 0.08668418f, -0.10242894f, -0.09308091f, -0.06436724f, -0.08880538f, 
    -0.29672086f, -0.19329971f, -0.11154363f, 0.28878069f, 0.04242446f, -0.05347979f, 0.11160607f, -0.04183638f, 
    -0.05463981f, 0.03428518f, -0.04705828f, 0.09631649f, 0.11654815f, 0.04441851f, -0.06887697f, -0.07185137f, 
    -0.09251460f, 0.01439785f, 0.10410807f, 0.01063299f, 0.14613013f, -0.09817162f, -0.01963213f, 0.07052997f, 
    0.06785778f, -0.09272098f, 0.14283410f, -0.20278019f, 0.03481570f, 0.00058396f, 0.00457760f, 0.01220689f, 
    0.06505784f, 0.12450741f, -0.04835023f, 0.06297268f, 0.25873110f, 0.10063717f, 0.13469434f, 0.15758821f, 
    -0.06415875f, -0.07463724f, -0.04192094f, -0.00380376f, 0.14030637f, 0.01557647f, 0.11421151f, 0.04374648f, 
    -0.28342593f, 0.18919827f, 0.21841718f, 0.04447930f, -0.15457079f, -0.01017771f, 0.12387654f, -0.02617118f, 
    -0.08343500f, 0.01765935f, -0.00398703f, -0.03929825f, 0.01489917f, -0.09096309f, -0.10767961f, -0.12779462f, 
    -0.07276572f, 0.09146150f, -0.12199898f, -0.05421257f, -0.02697839f, -0.09203745f, -0.07299332f, 0.14373618f, 
    0.33153602f, 0.13877058f, 0.12637438f, -0.11668052f, -0.04462597f, 0.00425730f, -0.05966251f, -0.02401837f, 
    -0.06794224f, -0.03688112f, -0.15245065f, 0.09128348f, -0.15703081f, 0.44576028f, 0.08771659f, 0.02902125f, 
    0.07560070f, 0.18662907f, 0.11048479f, -0.10806690f, 0.02552989f, 0.12233084f, 0.08916654f, 0.03343584f, 
    0.10255694f, 0.27247223f, -0.05950100f, 0.28510386f, -0.01696011f, 0.19500935f, 0.10784749f, 0.05774907f, 
    0.13406946f, 0.02137311f, -0.02500092f, 0.07665693f, 0.19182925f, -0.04866334f, 0.25251350f, 0.24900582f, 
    -0.02191854f, -0.11608426f, 0.11318419f, 0.09105117f, 0.16980186f, 0.13126062f, -0.07638668f, 0.10854026f, 
    -0.31785339f, 0.17492644f, 0.06247208f, 0.03647693f, -0.00757423f, 0.13401625f, -0.03306901f, 0.06376583f, 
    -0.06420999f, -0.01438367f, -0.06452961f, 0.04676853f, 0.07940079f, -0.04557301f, -0.19424005f, 0.03982383f, 
    -0.15346751f, -0.17439340f, -0.05806818f, 0.06599965f, -0.14841667f, -0.07547811f, -0.03396083f, 0.07865141f, 
    0.12021831f, -0.17111062f, 0.49761245f, -0.28126568f, 0.04257635f, -0.05940661f, -0.16412283f, -0.15863127f, 
    0.02328495f, 0.02636568f, -0.01698648f, 0.05581467f, -0.11700486f, -0.12377933f, -0.21568155f, 0.04067784f, 
    -0.07773598f, 0.06825884f, 0.04699062f, -0.17994796f, 0.07851595f, 0.04257351f, -0.08153092f, -0.04492039f, 
    -0.41730684f, -0.14211082f, -0.24322481f, -0.09423979f, 0.06236812f, 0.06727142f, 0.09997152f, -0.05719416f, 
    -0.17744817f, -0.05719931f, -0.06604549f, -0.09035815f, 0.21321572f, 0.04912189f, 0.13919923f, 0.19490044f, 
    0.12933427f, 0.07338476f, -0.08421886f, 0.00400910f, 0.14056949f, 0.02282544f, -0.06225048f, 0.11095370f, 
    0.24426422f, 0.10578266f, 0.08583315f, -0.06278995f, -0.10888638f, 0.06616292f, -0.09104652f, 0.12026811f, 
    -0.07606144f, -0.01493351f, 0.16596687f, -0.01905986f, -0.26614934f, -0.11346999f, -0.01016593f, 0.11986533f, 
    0.10133970f, -0.06440176f, -0.12916128f, 0.06118681f, -0.01866690f, 0.00917648f, -0.14771114f, -0.01268127f, 
    -0.11250686f, 0.41765654f, -0.11909667f, 0.02403347f, 0.12324119f, 0.05939839f, 0.07661588f, 0.04929245f, 
    0.27713126f, -0.03667372f, 0.06539887f, 0.12351254f, -0.12784979f, 0.01448299f, -0.11633532f, -0.08499292f, 
    0.06340533f, -0.01565635f, -0.00143980f, 0.02575969f, -0.04749527f, 0.03343808f, 0.14831491f, 0.04662411f, 
    0.13254662f, 0.06697733f, 0.43085289f, -0.01383109f, -0.13725671f, -0.18880308f, -0.01323386f, 0.07049120f, 
    0.13479289f, -0.07717277f, 0.00366104f, 0.11265285f, -0.09924567f, -0.09290931f, 0.00287160f, -0.12834379f, 
    -0.09796049f, 0.01179899f, -0.01456909f, 0.08453858f, -0.07433681f, 0.02936091f, 0.20684659f, 0.27451488f, 
    0.08164302f, -0.00318664f, -0.07307194f, 0.14141661f, -0.01376933f, -0.20732218f, -0.05067847f, 0.02329801f, 
    0.00141392f, -0.07873503f, -0.07188415f, -0.28363431f, 0.08905325f, 0.14673688f, 0.20122312f, -0.04368551f, 
    0.02548986f, 0.22144181f, 0.15192421f, -0.23834755f, 0.09882706f, 0.03556072f, 0.14296076f, 0.04582391f, 
    0.08881006f, 0.06096479f, 0.10751028f, 0.31829029f, 0.10466678f, 0.15087630f, 0.01105097f, -0.18356276f, 
    0.10283639f, 0.05756503f, -0.14800979f, 0.21393022f, -0.09122132f, -0.08176608f, -0.17655861f, -0.11177056f, 
    0.00906196f, 0.07166524f, -0.15133597f, -0.09050879f, 0.04725000f, -0.03845033f, -0.06833655f, 0.11303608f, 
    -0.12543370f, -0.03424476f, 0.17373215f, 0.18363638f, -0.09813921f, 0.05222035f, -0.00656806f, -0.11768250f, 
    0.14582594f, -0.18120684f, -0.17081389f, -0.09088590f, 0.14436598f, -0.29479662f, -0.04005631f, -0.02392573f, 
    0.11475296f, 0.01904495f, -0.07568978f, -0.26334593f, 0.16120647f, -0.07373606f, -0.39420345f, -0.16880845f, 
    -0.35125253f, 0.52307302f, -0.02221251f, 0.12754877f, 0.09196809f, 0.00381552f, -0.01076134f, -0.13689934f, 
    -0.00700259f, -0.02604344f, 0.04665769f, -0.19467783f, 0.06912176f, -0.08044793f, 0.13685811f, -0.09621452f, 
    0.06137717f, 0.07171532f, -0.04284096f, 0.04658869f, -0.09296828f, 0.01023781f, -0.09033490f, -0.11278912f, 
    0.13249989f, 0.03893239f, 0.26576614f, 0.21276389f, 0.06062918f, 0.15131560f, 0.04808568f, 0.16757371f, 
    0.01617720f, -0.01491003f, -0.05917411f, 0.25199708f, -0.02296508f, -0.15008789f, 0.05634361f, -0.08907835f, 
    -0.02086812f, 0.01356796f, -0.05933448f, 0.06091283f, 0.02731711f, -0.01417127f, -0.07816644f, -0.11201916f, 
    0.07029247f, -0.18162066f, 0.01090579f, 0.15196934f, 0.06875114f, -0.04292542f, 0.09445586f, -0.04781918f, 
    0.01457777f, -0.01040946f, 0.09797745f, 0.01533695f, -0.38132954f, -0.14626718f, 0.51866704f, -0.00376247f, 
    -0.03539363f, -0.17808586f, -0.00901574f, 0.04529466f, 0.04863650f, -0.03186291f, -0.00933737f, 0.06012088f, 
    0.25635940f, 0.04208726f, -0.00342150f, 0.24756008f, 0.14589210f, -0.01087616f, -0.00748867f, -0.05098676f, 
    0.15424526f, 0.11266877f, 0.31326032f, 0.21497314f, -0.29374182f, -0.14225051f, -0.36293426f, -0.05414010f, 
    -0.02498646f, -0.11486436f, 0.07858442f, -0.18319355f, 0.12090262f, 0.05273566f, -0.05156238f, 0.15965804f, 
    0.11040346f, -0.05991405f, -0.18889210f, 0.22911447f, 0.02150116f, 0.07416836f, -0.12053321f, -0.35243428f, 
    -0.02492362f, 0.01434325f, -0.00576111f, 0.21318676f, -0.04271686f, -0.01782650f, -0.16114938f, -0.04065558f, 
    0.14629735f, 0.06049104f, 0.05034560f, -0.02763441f, 0.03709244f, 0.12164662f, 0.26152241f, 0.16320181f, 
    -0.27431902f, -0.20586662f, 0.03574096f, -0.03356259f, 0.03026241f, -0.04380226f, -0.09987341f, -0.17691705f, 
    -0.27806133f, -0.32129851f, -0.15128127f, -0.26608765f, -0.04024984f, -0.29651678f, 0.15302558f, 0.00148307f, 
    0.10727692f, -0.02252938f, -0.02542570f, 0.10662682f, 0.13353170f, 0.15522726f, 0.04695203f, 0.00490640f, 
    0.09896889f, -0.09576294f, 0.09900565f, -0.19783287f, -0.04045306f, -0.04712028f, -0.10632920f, 0.15414590f, 
    -0.07652627f, 0.01981577f, 0.02754247f, -0.05813435f, -0.33159208f, -0.07912190f, -0.18918988f, 0.16730164f, 
    0.02354496f, -0.03295267f, 0.04513901f, -0.24907972f, -0.14417012f, -0.28301659f, 0.11991529f, 0.00337793f, 
    0.32965970f, 0.05940552f, 0.10902469f, 0.08400647f, -0.07164112f, 0.04311747f, 0.03578908f, 0.00409564f, 
    0.05934447f, -0.19374928f, 0.07688666f, 0.13911612f, -0.03677570f, -0.06636645f, 0.15873250f, -0.19302601f, 
    -0.06805558f, 0.07436071f, -0.05282744f, -0.09631703f, -0.16920453f, -0.23381430f, -0.21984991f, -0.32990065f, 
    0.08459409f, 0.18869889f, -0.01558889f, 0.47087553f, 0.19708450f, 0.11149412f, 0.03622947f, -0.15864387f, 
    0.07235968f, -0.14467452f, 0.01192342f, -0.13811445f, 0.18690982f, 0.11114615f, 0.04583624f, 0.19541669f, 
    0.10039674f, 0.11834718f, -0.01125884f, 0.07152051f, -0.13666043f, -0.04024842f, -0.08387069f, 0.01235151f, 
    0.26200023f, 0.09141324f, 0.04862904f, -0.07891080f, 0.08451826f, 0.05510177f, 0.06153697f, 0.04201220f, 
    0.06316346f, 0.07978223f, 0.09975697f, -0.19515061f, -0.48782408f, -0.30438849f, -0.26340929f, -0.28243464f, 
    -0.09928251f, -0.09932280f, 0.01145760f, -0.12809043f, -0.16285926f, -0.14138256f, -0.08396880f, -0.12286670f, 
    0.10564130f, 0.17029621f, 0.11597630f, 0.03208683f, -0.29408213f, 0.04134097f, -0.19906914f, -0.34872940f, 
    -0.17886400f, -0.01542926f, 0.20837145f, -0.03777559f, 0.32872492f, 0.19930743f, -0.08945327f, -0.12028117f, 
    0.12157483f, 0.20591049f, 0.20576301f, 0.02658617f, -0.06739540f, -0.05595274f, 0.13315156f, -0.04358734f, 
    0.05152345f, 0.27633289f, -0.09602906f, 0.12440695f, 0.00276276f, -0.04358195f, -0.15427510f, 0.06783497f, 
    -0.12104605f, -0.16344216f, -0.12861320f, -0.25331819f, -0.01869928f, -0.03180179f, -0.12997788f, 0.06002790f, 
    0.09180621f, -0.14541794f, -0.19166391f, 0.07212156f, -0.16710073f, 0.04532115f, -0.02257023f, -0.04848207f, 
    -0.56383669f, 0.08316531f, 0.00701365f, 0.02395546f, -0.08559243f, -0.12043992f, -0.14528863f, -0.02738530f, 
    -0.11452227f, 0.04439753f, 0.03571360f, -0.09689327f, -0.01840132f, 0.23363219f, -0.21433297f, -0.15968615f, 
    0.00641165f, -0.13114677f, 0.08116316f, 0.14084603f, -0.03873931f, -0.09282871f, -0.00415056f, -0.12689619f, 
    0.09466247f, 0.02210357f, 0.03060047f, 0.27759650f, 0.08624108f, 0.09855251f, -0.06907042f, 0.02113533f, 
    0.09015188f, -0.02156556f, 0.10106530f, 0.06412252f, 0.24026585f, 0.18098789f, -0.20996195f, 0.04135805f, 
    0.02799549f, 0.01487969f, 0.02711877f, 0.23508340f, -0.03365141f, 0.00333816f, 0.06463831f, -0.04928385f, 
    0.52566683f, -0.31650558f, 0.18865785f, 0.12343644f, 0.08508238f, -0.00902141f, -0.08368659f, -0.02513851f, 
    -0.01002852f, -0.08309717f, 0.00821027f, 0.12814239f, -0.18658888f, -0.04136663f, -0.03952397f, 0.13123599f, 
    -0.11760410f, -0.05931174f, 0.06313321f, 0.05896263f, 0.33275950f, 0.29530123f, 0.11853002f, 0.10547026f, 
    0.14376269f, -0.13805273f, 0.09324300f, -0.04516597f, -0.00708023f, 0.18547387f, 0.09705060f, 0.01515806f, 
    0.00829699f, 0.02076392f, -0.23845635f, -0.08724037f, -0.01671626f, -0.09447663f, -0.13152169f, -0.10543186f, 
    -0.10497505f, -0.01519972f, -0.02459212f, -0.14555454f, -0.00346749f, 0.08654863f, -0.03316116f, 0.09141400f, 
    -0.06841596f, -0.15165484f, 0.18814307f, 0.02967580f, 0.19802001f, 0.08718183f, 0.01283650f, 0.15392232f, 
    -0.01244270f, 0.03598744f, 0.01572317f, 0.04463185f, 0.18729380f, 0.08486357f, 0.36225268f, -0.05696908f, 
    0.09982608f, 0.13789950f, 0.06935481f, -0.01236611f, 0.06208090f, -0.08365676f, 0.02489900f, 0.16659340f, 
    0.06530240f, 0.14806519f, 0.10519380f, 0.07801028f, 0.11015823f, 0.13092719f, -0.25697553f, -0.02656751f, 
    -0.09731104f, 0.08569930f, 0.05413273f, -0.04214724f, -0.25225821f, 0.26939884f, -0.14984737f, 0.14554985f, 
    -0.05212476f, -0.04359979f, 0.06223391f, -0.08535567f, -0.01059499f, 0.05196701f, -0.00348190f, 0.16369513f, 
    0.05837373f, 0.03126544f, 0.10967843f, 0.08172052f, 0.14596915f, -0.27450091f, 0.13350441f, 0.13641241f, 
    -0.00974379f, 0.03328242f, -0.00214459f, 0.09500065f, -0.24244665f, 0.11750766f, 0.15924041f, -0.16592689f, 
    0.07044710f, 0.04182270f, 0.17057188f, -0.10952386f, -0.09729338f, -0.00570748f, -0.05844383f, 0.02679049f, 
    0.00046724f, 0.05941261f, -0.04516149f, -0.04683892f, -0.06181403f, 0.00778965f, -0.04111485f, -0.04501878f, 
    0.02869894f, -0.06580147f, -0.05825187f, 0.03152485f, 0.02616408f, -0.04092057f, -0.06683923f, -0.00904701f, 
    -0.00407491f, 0.04665222f, -0.02184475f, -0.02845023f, -0.03757154f, 0.03570470f, -0.05160347f, 0.04624910f, 
    0.06035214f, -0.00389336f, -0.01763189f, -0.05759409f, 0.05791261f, -0.04177463f, -0.06579652f, -0.06569331f, 
    0.04191222f, -0.06784418f, -0.02355089f, 0.05124218f, -0.05439191f, -0.05106869f, 0.05976510f, -0.02669546f, 
    -0.03284085f, 0.03734781f, -0.03619239f, -0.07158946f, -0.03957281f, -0.02450047f, -0.06927570f, 0.00133404f, 
    0.05725547f, 0.06237012f, 0.02325125f, -0.06589562f, 0.01193895f, -0.06994855f, -0.07002321f, 0.00992946f, 
    -0.01636126f, -0.02014806f, -0.07561826f, -0.00932496f, -0.03568545f, 0.01493713f, -0.06736396f, 0.00444969f, 
    -0.03350501f, -0.04968616f, 0.02360303f, -0.00039680f, -0.06059942f, 0.00662033f, 0.02679053f, -0.01635710f, 
    -0.00986759f, -0.00868741f, 0.02955994f, 0.05511608f, 0.04624207f, -0.04968701f, -0.05592685f, 0.00020473f, 
    -0.03962942f, -0.07441387f, -0.01288611f, 0.06531184f, 0.03612522f, -0.02166759f, -0.04703593f, -0.03934146f, 
    0.05059341f, -0.02651513f, -0.04070720f, -0.01698531f, 0.02547517f, -0.00493828f, -0.05183030f, -0.03006027f, 
    -0.00294448f, -0.02118777f, -0.00326773f, 0.00535857f, -0.04080763f, -0.00870927f, 0.05848344f, 0.06369225f, 
    0.03447660f, -0.01278672f, -0.04262415f, -0.04592693f, -0.02521887f, 0.03072188f, -0.03676366f, 0.04442138f, 
    0.00300495f, -0.04923861f, -0.02990672f, 0.00007207f, -0.03668743f, -0.02743412f, 0.02240319f, -0.07591788f, 
    0.05005829f, -0.00572519f, 0.02098384f, 0.01718083f, -0.01202415f, 0.01348345f, 0.04665195f, 0.03758560f, 
    -0.05147462f, -0.02375406f, 0.04522328f, -0.05103575f, -0.06693987f, -0.03710316f, 0.02492772f, -0.05719544f, 
    -0.07217312f, -0.00451466f, 0.00001800f, 0.01422475f, -0.04487258f, -0.05889354f, -0.02264170f, -0.03318368f, 
    0.05094046f, 0.01936715f, 0.03620347f, 0.01865793f, 0.03543271f, -0.04057014f, -0.05662814f, -0.00980206f, 
    -0.00816944f, -0.00556553f, 0.05158571f, -0.00254627f, -0.01764073f, -0.07702801f, 0.02799919f, -0.07094109f, 
    -0.04347260f, -0.04973268f, -0.06311160f, 0.03257928f, 0.03769088f, 0.00227722f, -0.01328477f, -0.07628400f, 
    -0.06919708f, -0.07709440f, 0.04439706f, 0.03899144f, -0.04288545f, 0.04426060f, 0.05589071f, 0.03118290f, 
    -0.03792331f, -0.06069812f, 0.00867164f, -0.03524886f, 0.06224620f, 0.05172858f, 0.00629459f, 0.00305149f, 
    0.04971379f, -0.03013902f, 0.01869963f, -0.03111089f, 0.03709749f, 0.04008288f, 0.02490996f, -0.04707957f, 
    0.31083921f, -0.07862403f, 0.06811245f, 0.15522589f, 0.06200626f, 0.08783476f, 0.08217347f, 0.01550809f, 
    0.07542093f, -0.04937297f, -0.00325516f, 0.17659509f, -0.15244827f, -0.09624675f, -0.21282966f, -0.30357310f, 
    0.06047455f, 0.05490063f, -0.10795512f, -0.08578043f, 0.19288267f, -0.01891857f, -0.03597872f, -0.05968463f, 
    0.13266498f, 0.32497919f, -0.09773992f, 0.12331481f, 0.03288408f, 0.02826444f, 0.09636834f, 0.16905010f, 
    -0.13096930f, 0.04957927f, 0.02327878f, 0.01939967f, 0.06622798f, 0.09255822f, 0.02969182f, -0.02410176f, 
    -0.00596180f, -0.01294911f, 0.00775806f, 0.10551077f, -0.05103554f, -0.00321480f, -0.08965477f, -0.18703681f, 
    -0.26098880f, -0.25345150f, 0.15299770f, -0.22683798f, -0.10430700f, 0.00351765f, 0.03688151f, -0.09027568f, 
    0.00545914f, -0.00816400f, 0.08914390f, 0.02783697f, -0.22253703f, 0.37311491f, 0.21400377f, 0.20256913f, 
    -0.03479495f, -0.13881798f, -0.03283379f, 0.24042177f, -0.07866885f, 0.00054845f, -0.06698977f, 0.08962979f, 
    -0.04852549f, 0.01658876f, 0.09263282f, -0.22296479f, -0.13805889f, -0.08663687f, -0.00452344f, 0.17659049f, 
    -0.09095023f, 0.03159517f, -0.08611573f, -0.09136692f, 0.23828372f, 0.32850841f, 0.25275320f, 0.05274066f, 
    0.13429034f, -0.06851412f, 0.21075708f, -0.07025097f, -0.18175228f, -0.01455505f, 0.01043121f, -0.11057148f, 
    0.10576992f, 0.23263638f, -0.07021748f, 0.05284360f, -0.12774561f, 0.07290173f, 0.19180223f, 0.22168693f, 
    -0.15143248f, -0.09794038f, 0.07790098f, 0.19665967f, -0.03420102f, 0.06459931f, -0.12780200f, -0.10721021f, 
    -0.06779871f, -0.01476652f, 0.05734447f, 0.23164968f, -0.01634417f, 0.00879106f, 0.09457284f, 0.02517452f, 
    0.17532663f, -0.19023354f, 0.37450793f, 0.20664729f, -0.05598500f, 0.09411818f, 0.01077491f, -0.12300945f, 
    0.11307804f, 0.02344638f, -0.09330869f, -0.08089571f, -0.03740735f, 0.14325146f, 0.14301334f, 0.31701097f, 
    -0.09098239f, 0.12354785f, 0.11154824f, 0.18343179f, 0.00607416f, -0.06975934f, 0.05156158f, 0.04703332f, 
    -0.23568210f, 0.17841271f, 0.09992936f, 0.33444500f, -0.17696190f, -0.10380420f, -0.08861007f, -0.00392971f, 
    -0.05000403f, 0.01465453f, 0.00407668f, -0.11659632f, -0.24938467f, -0.13984406f, -0.07633404f, 0.05121319f, 
    -0.15510410f, 0.06173823f, 0.02475057f, -0.04354167f, -0.10714298f, -0.00919812f, 0.09025158f, 0.05073427f, 
    -0.37259504f, -0.08587344f, -0.18539196f, -0.07746345f, -0.19488557f, -0.21062040f, -0.05477818f, -0.07266758f, 
    -0.03258878f, 0.11077817f, -0.08680892f, 0.02978637f, 0.05253307f, -0.47289202f, -0.14338250f, 0.44897550f, 
    0.05295880f, -0.03496867f, -0.02144512f, 0.03391598f, -0.00388753f, 0.11897318f, -0.17641050f, -0.05869322f, 
    -0.04745820f, -0.05008537f, -0.06851859f, -0.06200616f, -0.04768391f, 0.01711777f, -0.01101091f, 0.03095006f, 
    0.06242771f, -0.01685758f, -0.04135461f, 0.05700286f, 0.02287030f, -0.05743469f, -0.07720425f, 0.00773817f, 
    0.02913039f, 0.03794217f, -0.03117502f, -0.03475840f, -0.01536121f, -0.04629024f, 0.00556493f, 0.00846224f, 
    0.00065870f, 0.06693432f, -0.06751525f, 0.02162386f, 0.00398948f, 0.01875002f, -0.01416079f, -0.02808682f, 
    0.03513271f, -0.06934155f, 0.02137145f, -0.05773446f, 0.06150900f, -0.01059031f, -0.06933435f, -0.06277788f, 
    0.04258259f, -0.07179661f, -0.01928902f, 0.00184965f, 0.03516407f, -0.04792809f, -0.07200418f, 0.02655368f, 
    -0.05801440f, -0.03479992f, -0.07453626f, 0.01599631f, -0.02843396f, -0.03469654f, -0.05562500f, -0.03295215f, 
    0.01398434f, 0.01603821f, -0.03884063f, -0.00203603f, -0.06944192f, -0.04726772f, 0.01536051f, 0.06648033f, 
    0.00555507f, -0.02326988f, 0.00482608f, -0.07600877f, 0.00200528f, 0.02602101f, 0.01850810f, -0.05261701f, 
    -0.06529889f, -0.03332598f, 0.03992564f, 0.02744323f, 0.01947365f, -0.02091273f, -0.01274534f, 0.04212100f, 
    0.02948443f, -0.02374756f, -0.05315167f, 0.00885649f, 0.02715006f, 0.06361744f, -0.04495479f, 0.05345475f, 
    0.02195275f, -0.01117395f, 0.04190573f, 0.06169960f, 0.05729897f, 0.06463286f, -0.05332033f, -0.06417535f, 
    -0.06656163f, 0.04002190f, 0.03465695f, -0.01412363f, 0.00309937f, 0.05622177f, -0.02565807f, 0.06405138f, 
    -0.02565411f, 0.00876881f, 0.05976791f, -0.01812639f, 0.04216992f, 0.05468217f, -0.01603231f, 0.00900252f, 
    0.05414224f, -0.02203218f, 0.00040748f, -0.06537776f, -0.03236629f, -0.05042876f, 0.04587510f, -0.07499639f, 
    -0.05203471f, -0.05864715f, -0.05413413f, 0.04119814f, -0.03717848f, 0.04795199f, -0.04877545f, -0.07474940f, 
    -0.05147824f, -0.01470818f, 0.04011781f, -0.04980366f, 0.05072048f, 0.01798319f, -0.06669240f, 0.05165828f, 
    -0.05342710f, 0.00408881f, -0.04892197f, 0.06327133f, -0.03621049f, -0.02642050f, 0.00392895f, 0.01554971f, 
    0.02427801f, 0.03408570f, -0.04021071f, 0.02752180f, 0.05526175f, 0.04336916f, 0.03544774f, 0.01666043f, 
    -0.03415645f, 0.03534240f, -0.01600713f, 0.04353912f, -0.07696187f, 0.03479330f, -0.00230940f, -0.00430137f, 
    0.00433288f, -0.06306834f, -0.02891511f, -0.00678150f, -0.02549377f, 0.02385971f, 0.02081739f, 0.05551141f, 
    0.01019682f, 0.04888381f, 0.05491609f, -0.05595884f, -0.00424469f, -0.06570152f, 0.03652384f, 0.01603131f, 
    -0.07479675f, -0.00912216f, -0.06145318f, -0.01786874f, -0.05125256f, -0.06904903f, -0.05316440f, 0.06120580f, 
    -0.04702940f, -0.05807536f, 0.01935561f, -0.03278248f, 0.04943858f, -0.02654842f, 0.05094222f, -0.01159391f, 
    0.13563503f, -0.11751688f, 0.18711355f, -0.02013781f, -0.10333568f, -0.03585964f, -0.06400563f, -0.15865979f, 
    0.00480295f, 0.12027248f, -0.05868721f, 0.22796266f, -0.06790538f, -0.03136660f, 0.25025514f, -0.02083559f, 
    -0.01455984f, 0.05021081f, -0.05234155f, 0.04754993f, 0.27547628f, 0.09645166f, 0.19378373f, 0.10557073f, 
    0.53696859f, 0.37797782f, 0.38886809f, 0.22613338f, -0.10882983f, -0.10863955f, 0.11143229f, -0.03019812f, 
    -0.11703375f, 0.12983568f, 0.10408615f, 0.10067895f, 0.20625082f, -0.00355890f, 0.32132730f, 0.00545503f, 
    0.00331439f, -0.00525446f, -0.20468445f, -0.10372654f, 0.16460587f, 0.02030217f, -0.25575978f, 0.14019336f, 
    -0.59498686f, -0.15958658f, -0.02672288f, -0.05897703f, -0.12111627f, 0.14134094f, -0.09702514f, 0.03835947f, 
    0.09027918f, -0.00817965f, -0.07831878f, 0.11796558f, -0.56131440f, 0.26168081f, -0.06964362f, 0.05597194f, 
    0.03376764f, -0.09973827f, 0.09528374f, 0.12514889f, -0.03372101f, 0.28220394f, -0.02345443f, 0.08355037f, 
    0.00961438f, 0.25995934f, -0.09882823f, -0.13847129f, -0.03114267f, 0.11911603f, -0.06897385f, 0.07233924f, 
    -0.06431495f, 0.11689001f, -0.21422897f, 0.01680245f, 0.48619711f, 0.29641515f, 0.37831748f, -0.04860526f, 
    -0.07267843f, 0.04599714f, -0.00876293f, 0.16794561f, -0.24951674f, 0.18670049f, -0.15929602f, 0.01423874f, 
    -0.01025216f, 0.38584614f, 0.06035267f, -0.02668816f, 0.11512781f, 0.06710412f, 0.14392164f, 0.12195743f, 
    -0.21409309f, 0.03609305f, -0.06441696f, 0.17436329f, 0.08497473f, 0.18062611f, -0.03170913f, -0.13607135f, 
    -0.07943011f, -0.03740571f, 0.12348583f, 0.02148380f, 0.04815532f, 0.15227386f, 0.07324819f, -0.01085944f, 
    -0.06326984f, -0.04029433f, 0.37569228f, -0.06825839f, -0.25727388f, -0.16508819f, 0.00897313f, 0.22706519f, 
    0.12410240f, 0.01720027f, 0.04262281f, 0.04048869f, -0.13462168f, -0.06888367f, -0.23862846f, 0.22239761f, 
    -0.12043020f, 0.08546737f, 0.13440771f, -0.06976473f, 0.08328522f, -0.05064066f, -0.10003325f, 0.00975812f, 
    -0.18737780f, -0.05581339f, -0.17865527f, 0.11281439f, 0.02004742f, -0.26318252f, 0.07035355f, 0.05294062f, 
    -0.15357523f, -0.01978316f, 0.09779742f, -0.12282525f, -0.32891428f, -0.12754011f, -0.06806734f, -0.02416630f, 
    0.03165141f, 0.16249189f, -0.01927035f, -0.12945320f, 0.04043014f, 0.19343354f, 0.04710427f, 0.14017899f, 
    0.14826636f, 0.17208828f, -0.20771942f, -0.04603495f, 0.02494425f, 0.11996689f, -0.00168751f, -0.23881215f, 
    0.09451924f, -0.23189253f, 0.07941427f, -0.09388000f, 0.12964399f, 0.14558868f, -0.40155029f, 0.11263211f, 
    0.02104895f, -0.13225986f, -0.31862578f, 0.16182190f, 0.04456614f, -0.05412227f, -0.24585149f, -0.14975946f, 
    -0.17709747f, 0.22646502f, -0.10412116f, 0.15252095f, 0.07802995f, 0.11883050f, 0.03409965f, 0.08453177f, 
    0.24932514f, 0.04947460f, 0.20817539f, 0.15899335f, -0.04026925f, -0.20529622f, -0.06137509f, -0.01240031f, 
    -0.09589074f, 0.15530221f, 0.07893194f, 0.12182883f, 0.08985154f, 0.11534488f, 0.10212741f, 0.15567662f, 
    0.06827838f, 0.05073346f, 0.20134619f, 0.07729582f, -0.01230719f, -0.07487401f, 0.07714933f, 0.04216335f, 
    0.09003855f, 0.00137063f, -0.00485327f, 0.10662978f, -0.09081313f, 0.02180225f, -0.00507206f, -0.04470404f, 
    0.10910185f, 0.02352437f, 0.11453321f, 0.09971322f, 0.06023084f, 0.11646528f, 0.20646550f, 0.31021595f, 
    -0.11023883f, -0.02323214f, -0.08362541f, 0.28341067f, -0.07172131f, 0.07606252f, -0.17880096f, -0.01459907f, 
    -0.11197912f, -0.21316536f, -0.12365449f, -0.12028290f, -0.04961225f, -0.16798003f, -0.14644237f, -0.08946568f, 
    0.09534396f, -0.10156560f, -0.06064547f, -0.02188503f, 0.14582361f, -0.08313567f, 0.10878444f, 0.08711191f, 
    0.04875713f, -0.12348136f, -0.03181734f, 0.03804191f, -0.04588104f, 0.03915121f, -0.04150523f, -0.12052520f, 
    0.05451332f, -0.00882597f, 0.09157144f, 0.12392168f, 0.09579889f, -0.11788215f, -0.10130180f, -0.10103051f, 
    -0.03959339f, -0.05831951f, -0.21821809f, -0.12036026f, 0.05203475f, -0.00064888f, -0.01860590f, 0.00670481f, 
    0.19678758f, 0.06247641f, 0.06009189f, 0.00560174f, 0.07694203f, 0.05489890f, -0.07087621f, -0.10009695f, 
    0.01821020f, -0.07493741f, 0.00844200f, 0.06012372f, 0.03512354f, 0.09572214f, 0.03885837f, 0.13583510f, 
    0.10930558f, 0.13790406f, -0.06725577f, -0.30043972f, 0.15721695f, -0.22442804f, -0.39544180f, -0.27039316f, 
    -0.04966674f, 0.37131822f, -0.07696972f, 0.02948829f, 0.06106326f, -0.00304769f, 0.05171910f, -0.07650945f, 
    0.06405685f, 0.09709421f, 0.09174550f, -0.14374915f, 0.28046948f, 0.10479186f, -0.04857270f, -0.14493854f, 
    0.06894144f, 0.04969107f, 0.00456739f, -0.05464092f, -0.03782347f, -0.03260744f, -0.17510083f, 0.05702067f, 
    0.14810310f, -0.05412022f, 0.08651496f, 0.04223619f, 0.13727073f, 0.06064867f, 0.12211699f, 0.12615545f, 
    0.05038491f, -0.03452680f, 0.02684109f, 0.03774725f, -0.17270587f, -0.22030342f, -0.15897177f, -0.07410782f, 
    -0.02093890f, -0.17613539f, 0.04051631f, -0.08947821f, -0.05138063f, -0.17823286f, -0.13417642f, -0.19936204f, 
    -0.15171759f, -0.03229411f, 0.05714867f, 0.35454160f, 0.05219979f, 0.03200314f, 0.03477038f, -0.05022586f, 
    0.00564398f, -0.08361796f, 0.04557574f, 0.08786545f, 0.15930557f, 0.16326460f, -0.12277360f, -0.23907368f, 
    0.00942913f, 0.07214653f, -0.10903861f, 0.01341398f, -0.00463518f, -0.14250869f, 0.04767465f, 0.05967960f, 
    0.03298798f, 0.01189316f, -0.04251893f, -0.05647206f, 0.01997688f, -0.05731103f, -0.01009560f, -0.06260112f, 
    -0.04166912f, -0.01886271f, -0.02848443f, 0.04262193f, -0.06749789f, -0.06036897f, -0.03717394f, -0.05015051f, 
    -0.01271330f, 0.05084289f, 0.00777704f, 0.00918881f, 0.06593576f, -0.04923278f, 0.05943606f, 0.03968455f, 
    -0.07303616f, -0.04160414f, -0.03776751f, -0.02058272f, -0.01027649f, 0.05851925f, 0.00846196f, 0.05301695f, 
    -0.02798114f, -0.00417020f, -0.00649661f, 0.05429894f, 0.05801123f, -0.00749248f, -0.03489070f, 0.00187174f, 
    0.03817449f, 0.05553020f, 0.00678207f, -0.03343497f, -0.06780617f, -0.05594712f, 0.01243209f, -0.06622518f, 
    0.02079924f, -0.06996400f, 0.00829511f, -0.03264022f, -0.02624818f, 0.00372442f, 0.01597993f, -0.00448006f, 
    -0.03459211f, -0.01839169f, 0.00632915f, 0.05859243f, -0.01025570f, -0.05888689f, -0.00878034f, -0.07491714f, 
    0.00152788f, -0.02469540f, 0.05306563f, -0.02862622f, -0.05758538f, 0.04716688f, -0.04167690f, 0.00524623f, 
    0.00802583f, 0.04086661f, -0.05661884f, 0.06166289f, 0.01484985f, -0.03950391f, 0.03200570f, 0.00223044f, 
    -0.06160412f, 0.00625219f, 0.00555947f, 0.03030982f, 0.04189643f, 0.00600304f, 0.00516057f, -0.01938799f, 
    0.00164424f, 0.03663712f, 0.04953678f, 0.01210870f, 0.04652106f, -0.04353296f, 0.02763583f, -0.04029682f, 
    0.02271171f, 0.04919365f, 0.01325165f, -0.03338716f, 0.04951128f, 0.02196957f, -0.03776856f, -0.03576212f, 
    -0.04018428f, 0.02064814f, -0.03331650f, -0.01851711f, -0.03087096f, 0.03579215f, -0.01324581f, 0.04479579f, 
    -0.04651248f, -0.07077044f, -0.02925529f, -0.01930811f, -0.06483065f, 0.03804750f, 0.01086551f, -0.05957938f, 
    -0.05622660f, -0.05570725f, 0.01887520f, 0.01687306f, -0.07577483f, -0.02686741f, -0.03044925f, 0.02052394f, 
    -0.03566897f, 0.02818274f, -0.02574867f, -0.03925619f, 0.03548485f, 0.02088702f, 0.02859642f, -0.05881543f, 
    -0.02560408f, -0.03722495f, -0.03283978f, -0.00025125f, 0.00285564f, 0.03804842f, -0.03923327f, 0.00201281f, 
    -0.01023084f, 0.05984112f, -0.02558049f, -0.03492418f, 0.05221267f, -0.05644684f, -0.05541687f, 0.01929650f, 
    0.05957743f, -0.04085666f, 0.00791784f, -0.02971907f, 0.06266517f, -0.01531591f, -0.05712394f, -0.04948796f, 
    0.05951378f, -0.00154779f, -0.04462083f, -0.07714603f, -0.02907698f, 0.03128772f, -0.00983837f, -0.05659763f, 
    0.04960053f, -0.03465670f, 0.00437021f, -0.01132187f, 0.00927874f, -0.05952492f, -0.02484247f, -0.07105595f, 
    -0.07308397f, 0.02415068f, -0.05743754f, -0.06029613f, 0.06442660f, 0.05218523f, -0.01221377f, -0.07026647f, 
    0.04010819f, -0.06823166f, -0.03538285f, -0.06261457f, 0.00524222f, -0.04349865f, -0.06815449f, 0.00320669f, 
    0.00948033f, -0.08148358f, 0.10323890f, 0.21592392f, 0.00633888f, 0.09930124f, 0.14417781f, 0.04077742f, 
    -0.24417412f, -0.01681357f, -0.17443167f, -0.25370955f, -0.02817959f, -0.17867012f, -0.01012064f, 0.02301980f, 
    -0.29812780f, -0.06647678f, -0.14782247f, -0.14989552f, 0.01040197f, -0.06278555f, 0.03648337f, -0.01932578f, 
    0.02000286f, -0.15578997f, -0.20132990f, 0.03529264f, 0.00188608f, -0.11666278f, -0.24828029f, -0.18086670f, 
    -0.00924189f, 0.09173272f, -0.00785948f, -0.03034686f, 0.09295879f, 0.00408501f, -0.02133886f, -0.09722589f, 
    0.03064701f, -0.03440058f, -0.09440482f, 0.01767334f, 0.14647293f, -0.02471301f, -0.15137762f, -0.23168200f, 
    -0.28655973f, -0.11909154f, -0.09472661f, -0.04563454f, 0.01045210f, 0.08987780f, -0.06928448f, -0.06186093f, 
    -0.04160098f, -0.02432001f, 0.24486995f, 0.17092068f, 0.17087612f, 0.21409598f, -0.17074104f, 0.11408677f, 
    -0.07699842f, -0.03099625f, 0.09090161f, 0.39652056f, -0.11028077f, 0.01649974f, 0.00743182f, -0.11661268f, 
    -0.05154736f, 0.20131676f, -0.01781139f, -0.03365481f, 0.09292302f, -0.01365047f, 0.14626344f, 0.20067412f, 
    0.07560850f, 0.03675864f, 0.19170749f, 0.05204694f, 0.14435321f, -0.02836891f, 0.17896697f, 0.00862638f, 
    -0.21947736f, -0.06423252f, 0.13985032f, 0.10321133f, 0.06202817f, 0.13725191f, 0.12738344f, -0.08771860f, 
    -0.10040655f, 0.14918530f, 0.04916841f, -0.09734001f, 0.07681952f, 0.06058984f, 0.06325993f, 0.25075534f, 
    -0.09478543f, -0.06166847f, -0.18741903f, 0.24333954f, -0.12256128f, -0.03833660f, -0.29887360f, -0.22556955f, 
    0.11601097f, -0.02945810f, 0.04513518f, 0.05487306f, -0.00107091f, 0.20989941f, 0.18814836f, 0.18862353f, 
    0.14485881f, -0.24566287f, -0.20362782f, 0.07404397f, -0.11938499f, -0.05590535f, 0.24757825f, 0.22867192f, 
    -0.02843556f, 0.10411306f, -0.06769964f, 0.06320750f, -0.10123129f, -0.09009124f, 0.08183537f, 0.06175730f, 
    0.15211873f, 0.07353576f, 0.14685233f, 0.01598247f, -0.00608434f, -0.04800896f, 0.12067467f, 0.22138673f, 
    -0.07170340f, 0.25188965f, -0.04574746f, -0.11968518f, -0.00815373f, -0.06125071f, 0.04894287f, 0.23756574f, 
    -0.13232625f, -0.04778181f, 0.10150906f, -0.00275455f, -0.21810929f, 0.07187248f, -0.05665882f, -0.02997478f, 
    -0.14838155f, -0.11636870f, 0.03559238f, -0.13135281f, 0.04208056f, 0.11126868f, 0.00920135f, 0.08441932f, 
    -0.14112744f, 0.21557911f, -0.03718948f, 0.16163377f, 0.00170530f, 0.05245156f, 0.07706108f, -0.01241821f, 
    0.08760018f, 0.05239921f, -0.12753877f, 0.07313549f, 0.27906385f, 0.23502418f, -0.21440308f, -0.06165117f, 
    -0.10130744f, 0.12703748f, 0.02615547f, 0.10330524f, 0.14467509f, 0.08063001f, -0.02217070f, -0.05320046f, 
    -0.18226108f, 0.06793953f, -0.05898705f, 0.06296879f, 0.04706025f, 0.00891916f, -0.03844099f, -0.09340069f, 
    0.12733331f, 0.04160173f, 0.25088176f, 0.25730956f, 0.06594297f, -0.14968349f, 0.07815927f, 0.05596209f, 
    0.01719061f, 0.17696299f, 0.13018163f, -0.02591958f, 0.18532771f, 0.04877060f, 0.05901870f, 0.16557875f, 
    0.45184121f, 0.35329288f, 0.35524359f, 0.08082487f, -0.15603584f, -0.18872221f, -0.14799899f, -0.10555550f, 
    0.03572268f, 0.08924303f, 0.07762980f, 0.20902139f, 0.03210267f, 0.05290208f, 0.21118654f, 0.07954502f, 
    0.01583840f, -0.00036861f, -0.10582146f, -0.12832764f, 0.20916341f, 0.16861384f, 0.02074569f, 0.13644418f, 
    -0.11837713f, -0.10364184f, -0.23029901f, 0.00255749f, -0.06160113f, 0.09493098f, 0.06106438f, 0.04761491f, 
    -0.08431187f, 0.01332444f, -0.11861825f, -0.06187475f, 0.04433046f, -0.14680810f, 0.11558672f, 0.03124999f, 
    0.08538055f, -0.09876229f, -0.00613441f, -0.07113145f, 0.00545202f, 0.09639917f, 0.01348501f, -0.01505038f, 
    -0.41616386f, 0.21258174f, -0.20088127f, 0.04181621f, 0.10935543f, -0.06431101f, 0.06346859f, 0.09156781f, 
    -0.00090559f, 0.10905476f, 0.04086315f, -0.02014065f, 0.05261857f, 0.09861583f, -0.00903928f, -0.03441179f, 
    -0.05986300f, -0.02572052f, -0.16350929f, -0.17284830f, -0.24203159f, -0.16258833f, -0.05249808f, 0.00616877f, 
    -0.06954837f, 0.25607285f, 0.10039327f, 0.03026803f, 0.14180763f, -0.20240140f, 0.04925674f, 0.06085961f, 
    0.07046664f, 0.02533610f, 0.06801421f, -0.14320587f, -0.10976981f, 0.20077880f, 0.02927718f, 0.06031543f, 
    0.12463987f, 0.08667228f, -0.00099083f, 0.22667912f, 0.04792431f, -0.10147809f, -0.00117299f, -0.14246179f, 
    0.18529886f, 0.32265666f, -0.21991938f, -0.01424994f, -0.06954157f, 0.18389414f, 0.21248646f, 0.06828724f, 
    -0.08161716f, -0.04441562f, 0.03068770f, -0.01033531f, 0.13575755f, 0.03182683f, -0.04463134f, -0.08130565f, 
    -0.17950130f, -0.05833761f, -0.01780855f, 0.05303423f, -0.10971713f, -0.01617165f, -0.00001996f, -0.08219701f, 
    -0.23302960f, -0.07154189f, 0.16856056f, 0.07777956f, -0.09949346f, -0.20816757f, 0.19774422f, 0.12417882f, 
    0.00683529f, -0.07056534f, 0.00358708f, -0.08116253f, 0.18145740f, -0.18210867f, 0.10773191f, -0.13152823f, 
    0.07570066f, -0.02521668f, 0.08455014f, 0.04837279f, 0.02404422f, -0.01222265f, -0.06554925f, -0.18583480f, 
    -0.32370505f, -0.04557094f, -0.30413824f, 0.19563445f, 0.08777824f, 0.10201737f, -0.03961924f, -0.25871086f, 
    0.17320414f, 0.04707252f, 0.02094111f, -0.00457981f, 0.01867277f, -0.20552072f, -0.00817772f, 0.22651325f, 
    -0.11145506f, -0.01287128f, -0.08998004f, -0.08468689f, 0.11956171f, -0.02298344f, 0.02969269f, -0.07990858f, 
    0.23298740f, -0.05921843f, 0.13601762f, 0.16074231f, 0.06508797f, 0.11718368f, 0.21687296f, 0.14719860f, 
    0.12785473f, 0.04127464f, -0.01029853f, 0.28074980f, -0.00632413f, 0.04505044f, -0.04818585f, -0.01314878f, 
    -0.06102018f, 0.01580686f, -0.07809908f, -0.14761364f, 0.03428736f, 0.01001917f, -0.01798999f, 0.01824537f, 
    0.44921780f, -0.59116107f, -0.04677443f, 0.01563247f, 0.11050887f, -0.12408573f, -0.04049737f, -0.19914427f, 
    0.22752583f, 0.04963521f, -0.00287986f, 0.07633796f, 0.14238374f, -0.42891917f, 0.14296733f, -0.05927683f, 
    -0.05491173f, 0.07162838f, -0.05976759f, -0.20167869f, 0.15363231f, 0.18613999f, 0.05275867f, 0.18689546f, 
    -0.11065805f, 0.16033299f, 0.02968538f, 0.19871745f, 0.05220730f, 0.03566587f, -0.04857764f, -0.04427629f, 
    -0.02996498f, -0.24088594f, -0.25518283f, -0.30970266f, -0.14011361f, -0.12895568f, -0.03434997f, 0.27901438f, 
    -0.02003137f, 0.07294964f, 0.12189285f, -0.00844915f, -0.16612142f, -0.04705763f, -0.12186041f, 0.11021245f, 
    0.31202978f, -0.21281610f, 0.08568645f, -0.19610485f, 0.14012799f, -0.02370790f, -0.04366668f, -0.04798415f, 
    -0.01502236f, 0.17563418f, -0.08113357f, 0.01006446f, 0.01171438f, 0.16222140f, 0.05713335f, -0.12701881f, 
    -0.30273631f, 0.15036303f, -0.17998341f, -0.12638538f, 0.02411078f, 0.15408933f, -0.08890564f, 0.10135775f, 
    0.17128284f, -0.02985831f, 0.05817546f, 0.21079575f, 0.13284692f, 0.10403687f, 0.07406614f, 0.07365675f, 
    0.00522687f, 0.02718508f, 0.02274172f, 0.17231885f, -0.02946927f, -0.16215955f, -0.03986441f, -0.35278112f, 
    0.02513145f, 0.06320807f, -0.15261699f, -0.11258601f, -0.15726060f, -0.27319559f, -0.20909935f, -0.39211670f, 
    -0.40473142f, 0.45516494f, 0.11236624f, 0.36169553f, -0.16773006f, 0.05902235f, 0.12133448f, 0.21592635f, 
    0.00353977f, -0.06649349f, -0.02064303f, -0.02088143f, -0.24734680f, -0.08255185f, -0.03716367f, 0.36777359f, 
    0.07143542f, -0.00084336f, 0.18893433f, 0.02017923f, -0.06926932f, -0.00335802f, -0.23837680f, -0.05344015f, 
    0.05808651f, -0.06281541f, -0.15244770f, -0.10835026f, 0.18872829f, 0.07409701f, 0.14690425f, 0.34913182f, 
    0.00296149f, -0.03986113f, 0.02150995f, -0.03223446f, -0.06038322f, -0.02488667f, 0.14652056f, -0.25377962f, 
    -0.23052208f, -0.09586436f, -0.22568467f, -0.26663911f, -0.13317584f, -0.00200581f, -0.15259022f, -0.15983012f, 
    0.21431652f, 0.12059619f, 0.16074820f, 0.16316837f, -0.19393383f, 0.11959823f, -0.18150283f, -0.28092301f, 
    0.08735433f, 0.06463352f, 0.03206686f, -0.01368534f, 0.07401615f, 0.19622289f, 0.30794382f, 0.03801751f, 
    0.08019105f, 0.19741042f, -0.08586412f, 0.23928350f, -0.07406764f, -0.02779365f, 0.03153980f, -0.00997375f, 
    0.16532192f, 0.01212466f, -0.15075204f, 0.05456452f, 0.00499733f, 0.21498413f, -0.06746528f, -0.05379173f, 
    -0.11102086f, 0.21375540f, 0.01349651f, -0.27507874f, -0.17211480f, -0.06996673f, 0.12266660f, -0.06794426f, 
    -0.06980883f, -0.14928085f, -0.00153169f, 0.01341266f, -0.14407548f, -0.01596097f, -0.05801399f, 0.02995895f, 
    -0.27185589f, 0.23080960f, 0.33451644f, 0.28108653f, 0.04724326f, 0.01539779f, -0.05417027f, -0.03144099f, 
    0.02461322f, 0.21759167f, 0.06031289f, 0.28757578f, 0.01644265f, -0.01103378f, 0.12959461f, 0.20112242f, 
    0.09856775f, 0.00395556f, 0.14300208f, 0.24362159f, -0.02175316f, 0.12300202f, -0.12294350f, -0.05981796f, 
    -0.17674518f, -0.05426345f, -0.23339945f, -0.06004508f, 0.15376930f, 0.20776589f, 0.09115070f, -0.03418253f, 
    -0.08472639f, 0.00895696f, 0.04264982f, 0.07168529f, 0.08200400f, 0.40691671f, -0.39802989f, -0.09408962f, 
    0.13312303f, 0.12885754f, -0.05201796f, 0.20322292f, 0.14468127f, 0.08418848f, -0.12418148f, 0.04416795f, 
    0.16870253f, 0.05282687f, -0.06768282f, 0.24486111f, -0.06853837f, -0.08129480f, 0.10740868f, 0.16579075f, 
    0.01323187f, -0.25529194f, 0.29171678f, -0.13896619f, 0.01658175f, -0.08498520f, 0.10342383f, 0.31588048f, 
    -0.03369595f, 0.00362173f, -0.16222110f, 0.10453972f, 0.15498067f, 0.08330183f, 0.41595560f, 0.07118366f, 
    0.21938148f, -0.32771921f, -0.39412749f, -0.25523233f, -0.11257466f, -0.22445291f, 0.07903095f, 0.04997486f, 
    -0.12296659f, -0.08687373f, -0.06760696f, 0.10584820f, -0.11273077f, 0.01929606f, -0.03493195f, -0.12564583f, 
    0.02191302f, -0.01711152f, -0.07762087f, -0.07353587f, -0.04635635f, 0.02862549f, -0.07698718f, 0.11839821f, 
    -0.12771632f, -0.48851681f, -0.14355311f, 0.02554741f, 0.15729336f, 0.18120416f, 0.02344550f, 0.01286717f, 
    -0.00323072f, 0.10404822f, 0.05145968f, -0.05499911f, 0.14940926f, 0.27517503f, -0.22804743f, -0.21161363f, 
    0.16675916f, -0.21073729f, -0.07861711f, -0.00362731f, -0.09467202f, 0.15685058f, -0.05525278f, 0.06981687f, 
    -0.05536517f, -0.06726903f, -0.29953969f, -0.12145515f, -0.01424074f, -0.03026993f, 0.08167681f, -0.10800231f, 
    0.03934443f, 0.02752148f, 0.02794621f, 0.00830661f, 0.03167700f, -0.04384666f, -0.20189025f, 0.01391289f, 
    0.00305765f, -0.11828574f, 0.04999134f, -0.09313051f, -0.02100975f, -0.17604324f, 0.18072551f, 0.05083450f, 
    0.34841338f, 0.33954251f, -0.27424762f, 0.05878197f, -0.03000051f, 0.00298854f, -0.07510423f, 0.30241773f, 
    -0.03922868f, 0.10350683f, 0.02656133f, 0.21287195f, -0.02529325f, -0.10607444f, -0.40367147f, -0.39248386f, 
    -0.23665151f, 0.00289243f, -0.06666084f, -0.21754730f, -0.01277337f, 0.10541918f, 0.04875079f, 0.11252169f, 
    -0.26848632f, 0.24727432f, 0.01586610f, 0.08292826f, -0.05707825f, 0.08297894f, -0.00345885f, 0.10647018f, 
    0.01602883f, -0.01861565f, 0.12053110f, 0.08329632f, -0.10940377f, -0.06816834f, -0.09670859f, 0.02988414f, 
    -0.01565940f, 0.13141623f, 0.04143753f, -0.00559832f, 0.08446281f, -0.01813847f, 0.10238358f, -0.05132526f, 
    0.46562129f, -0.29221347f, -0.30345950f, -0.10933243f, 0.03957002f, 0.00027714f, -0.07848483f, -0.10318687f, 
    -0.04420724f, 0.04145528f, 0.08053850f, -0.06103524f, -0.00094166f, -0.04453377f, -0.05940896f, -0.05049073f, 
    0.01599345f, 0.06607102f, -0.00754335f, -0.05853860f, -0.01794170f, 0.04724742f, 0.13752480f, -0.00098168f, 
    0.04637159f, -0.00405421f, -0.11305129f, 0.06663212f, 0.09852970f, 0.04861809f, -0.04873804f, 0.06757362f, 
    -0.07371227f, -0.00141423f, 0.02523889f, -0.12618069f, 0.41003865f, -0.45299315f, 0.15329552f, 0.04835925f, 
    0.05851640f, -0.03028076f, 0.08055577f, -0.01405737f, -0.05903508f, 0.04998099f, 0.01846725f, -0.14414157f, 
    -0.26520205f, 0.00294601f, 0.02849149f, -0.10287815f, -0.00138189f, -0.12813532f, -0.06250668f, -0.03527965f, 
    -0.03311411f, 0.05183642f, 0.08124162f, 0.10421781f, -0.15279305f, -0.02454791f, -0.17209437f, -0.18949021f, 
    -0.03842321f, 0.06232348f, 0.01485159f, -0.14410748f, -0.12313764f, -0.08221724f, 0.00109523f, 0.13965462f, 
    -0.03190674f, 0.13113365f, 0.18165904f, -0.05831794f, 0.11216322f, -0.03844877f, -0.01139787f, 0.07186799f, 
    0.06673848f, -0.07306150f, 0.07624137f, -0.08252608f, -0.04409160f, 0.03024092f, 0.16193882f, 0.01175081f, 
    0.22863145f, 0.06684957f, 0.03036180f, 0.05753314f, 0.02085256f, -0.08827879f, -0.04851234f, 0.01284177f, 
    0.17517331f, 0.62978691f, -0.37531424f, 0.17739338f, -0.08157581f, 0.00863772f, 0.12387063f, 0.21047918f, 
    -0.09092301f, 0.01816513f, -0.01474750f, -0.04946559f, 0.04679763f, 0.15003325f, 0.18659343f, -0.00483491f, 
    0.02142498f, -0.01714162f, -0.03444281f, 0.08958719f, -0.12552924f, 0.01707119f, 0.01588746f, -0.03274907f, 
    0.49896848f, 0.19885591f, 0.36103976f, -0.05292644f, 0.06432318f, -0.12383092f, 0.03576333f, 0.12085446f, 
    -0.00818385f, -0.06265869f, -0.07708642f, 0.08090436f, 0.01409086f, -0.14828680f, 0.08411420f, -0.12773436f, 
    -0.03774340f, 0.07616728f, 0.01933075f, 0.07023600f, 0.03018071f, 0.04946579f, -0.07310620f, -0.09674823f, 
    -0.23711009f, -0.16068029f, 0.09025154f, 0.11266138f, 0.05616497f, 0.01610997f, 0.02701154f, -0.05582492f, 
    0.09357524f, -0.00673572f, -0.13779853f, 0.07235404f, 0.17855357f, 0.14173236f, 0.09501370f, 0.01417564f, 
    -0.10199536f, 0.13384520f, 0.00356585f, 0.08891665f, 0.08428611f, -0.05267409f, 0.10942876f, -0.05718164f, 
    -0.06191012f, -0.05979424f, -0.01057553f, 0.04511147f, -0.00256306f, 0.03548995f, 0.02628646f, 0.03285151f, 
    -0.03857595f, 0.16435501f, 0.02620915f, -0.04631582f, -0.02248318f, -0.20312499f, -0.01341903f, -0.09268112f, 
    -0.12920442f, -0.14146318f, -0.09552884f, -0.10682809f, 0.09677228f, 0.03728187f, 0.02626766f, 0.05726624f, 
    0.11812167f, 0.22027706f, 0.23943944f, 0.23853092f, -0.04206140f, -0.06724276f, -0.06697184f, -0.04974782f, 
    0.11728517f, 0.03060443f, -0.10465363f, -0.01078894f, -0.13921028f, -0.04879848f, 0.06132189f, 0.03378607f, 
    -0.07970272f, -0.08069913f, -0.17341366f, -0.12958224f, 0.12188226f, 0.15098418f, -0.19452865f, -0.11698651f, 
    -0.30858278f, -0.20904109f, -0.26092383f, -0.31252116f, 0.13491443f, 0.06019161f, 0.05041063f, -0.02712720f, 
    -0.06151363f, -0.01699158f, 0.08802893f, 0.07447720f, 0.07139076f, 0.42915624f, -0.02376533f, 0.05241954f, 
    0.24822241f, 0.03021458f, 0.08220160f, 0.10098128f, -0.08659291f, 0.05627792f, 0.03902808f, 0.08174468f, 
    -0.22900949f, 0.57299995f, -0.10692391f, 0.30322868f, 0.10568099f, 0.00730711f, 0.15164217f, 0.14547694f, 
    0.05476354f, -0.01404454f, 0.10038017f, -0.05414698f, 0.10376860f, 0.07031099f, 0.25722969f, -0.02664839f, 
    -0.05062378f, 0.12155618f, 0.05899851f, 0.01166633f, -0.00759038f, -0.00851571f, 0.13640963f, -0.09421305f, 
    -0.27305606f, 0.14637299f, -0.00101246f, 0.04821954f, 0.07095418f, -0.02546338f, 0.11384872f, 0.19042154f, 
    0.01625846f, 0.06187168f, -0.04814727f, -0.06307445f, -0.17703670f, -0.01187088f, -0.29815820f, -0.04515817f, 
    0.02451026f, -0.13809305f, -0.07873293f, 0.11504304f, -0.21024221f, 0.15420422f, 0.00034190f, 0.11217122f, 
    0.04816455f, -0.19939263f, -0.26108399f, -0.03577308f, 0.09622611f, 0.00636231f, 0.07187732f, 0.01047630f, 
    -0.00005188f, -0.02478964f, -0.08259495f, 0.00883173f, -0.06122816f, -0.06768814f, -0.10713401f, -0.03094639f, 
    0.04672119f, 0.00932658f, 0.12523749f, 0.13295405f, -0.06609125f, 0.02042031f, 0.11227454f, 0.05675150f, 
    -0.24094734f, 0.08132277f, -0.01887142f, 0.01875973f, -0.19142725f, 0.11047067f, 0.20297553f, 0.08157540f, 
    0.06939762f, -0.06799948f, -0.02918708f, -0.04487932f, -0.04748013f, -0.15334973f, -0.02656951f, -0.11539637f, 
    0.05453601f, -0.06977072f, 0.08019477f, -0.07528713f, 0.09186571f, 0.08821865f, 0.13380602f, 0.05590113f, 
    -0.01179858f, 0.06088489f, -0.31685171f, -0.17450973f, -0.05913955f, -0.00882587f, -0.11165959f, -0.03772135f, 
    0.05813635f, 0.15617211f, -0.02604105f, 0.15309164f, 0.03715323f, -0.20281312f, -0.12132349f, 0.30227688f, 
    -0.02708664f, -0.09303395f, -0.05810307f, 0.20507275f, 0.08067077f, 0.06444675f, 0.03745201f, -0.01813390f, 
    -0.05500276f, -0.25496143f, 0.18221714f, -0.11448722f, -0.00422177f, -0.02608551f, -0.03297689f, 0.02781013f, 
    -0.10317054f, 0.09663028f, 0.12049841f, 0.20594345f, -0.18105936f, -0.15281211f, -0.24387205f, -0.12953168f, 
    0.00432412f, -0.06164670f, 0.01849112f, -0.06253697f, 0.04412802f, -0.03402553f, -0.02857444f, -0.05723498f, 
    0.33615845f, -0.01279474f, -0.33695102f, 0.07231522f, 0.17182711f, 0.15287140f, 0.05599376f, -0.11543359f, 
    -0.02958803f, 0.06188796f, -0.01298908f, 0.02484818f, 0.26216269f, 0.16553435f, 0.07801761f, 0.20054822f, 
    0.20388047f, 0.17178608f, 0.10747118f, 0.01469187f, 0.16051657f, 0.09220578f, 0.00868399f, -0.14653105f, 
    -0.29989579f, -0.21778367f, 0.05756516f, -0.18129946f, -0.06515871f, -0.02148600f, -0.07148267f, -0.03396823f, 
    -0.03286841f, 0.07056749f, -0.05378688f, 0.05994705f, -0.06392412f, -0.25034785f, 0.11517288f, 0.03724953f, 
    -0.09683097f, 0.06518899f, -0.00140302f, -0.01397020f, -0.14531872f, 0.01611439f, 0.01062820f, -0.05740267f, 
    0.00142858f, 0.12766583f, 0.02093857f, -0.25134674f, -0.04687034f, -0.00447871f, -0.12452414f, 0.10821865f, 
    -0.06984236f, -0.00633946f, 0.06525222f, -0.14416908f, 0.13687526f, 0.00553277f, 0.18479101f, -0.08363903f, 
    0.05004131f, -0.04184015f, 0.00031390f, -0.02079652f, -0.24391338f, -0.17559800f, 0.08249740f, -0.03888139f, 
    0.20156166f, 0.28681526f, 0.02328337f, -0.08176692f, 0.24144916f, 0.08534948f, 0.10108590f, -0.06365730f, 
    -0.03113427f, 0.12569596f, 0.19008489f, 0.06211602f, 0.00434307f, 0.18689486f, 0.09920205f, 0.05066334f, 
    0.10505192f, -0.07324740f, 0.08414628f, 0.03744315f, 0.02274758f, -0.03728146f, 0.09323759f, -0.13433763f, 
    0.17052175f, -0.07006614f, 0.10252824f, 0.09226609f, -0.24931328f, 0.08357175f, 0.02769844f, 0.09479849f, 
    0.03377036f, -0.00766871f, 0.10985324f, 0.01306384f, 0.17428784f, 0.31059065f, -0.01400581f, 0.22228105f, 
    -0.02869513f, -0.01912050f, 0.13639985f, 0.03773699f, -0.06258620f, 0.05590202f, 0.09373713f, 0.03377840f, 
    0.28956750f, 0.20492187f, 0.05590851f, 0.10428660f, 0.07659393f, 0.02653405f, 0.10137311f, -0.05120147f, 
    0.03448129f, -0.15772714f, -0.00526717f, 0.05846038f, -0.19172971f, -0.16400458f, -0.07319369f, -0.25697622f, 
    -0.12938210f, 0.03814375f, -0.01480728f, -0.02549553f, -0.02685994f, -0.00304046f, 0.03855714f, -0.14349952f, 
    -0.55441135f, -0.28011128f, 0.16436432f, -0.42207971f, 0.02520901f, 0.04927467f, -0.04720356f, 0.08070807f, 
    0.17203221f, 0.02647314f, -0.16222259f, -0.04621652f, 0.41838223f, 0.35662633f, -0.21785723f, 0.05095793f, 
    -0.05742007f, -0.05194614f, -0.05611518f, 0.07143908f, 0.00859054f, 0.02523135f, -0.03468505f, 0.08800352f, 
    -0.05748325f, -0.01481696f, 0.24106579f, 0.02382534f, -0.13974588f, 0.06788217f, -0.03549265f, 0.06453957f, 
    -0.26475796f, -0.10104416f, -0.16395129f, -0.10488807f, 0.17998902f, 0.03433366f, 0.05461506f, 0.13385652f, 
    -0.01316642f, 0.09543720f, 0.00948357f, 0.07031097f, 0.04880360f, 0.05908766f, -0.02680724f, 0.06717208f, 
    0.01344097f, 0.08294441f, -0.40680116f, -0.27743396f, -0.05088963f, 0.02129865f, -0.02324077f, -0.09615045f, 
    -0.19847643f, 0.03113285f, 0.02222125f, -0.14677887f, 0.08450982f, 0.22728622f, -0.03994616f, -0.31430748f, 
    -0.08919157f, -0.12031872f, -0.37385923f, -0.16853248f, 0.11526278f, -0.11551058f, -0.21396269f, -0.00143732f, 
    0.22034007f, -0.05712895f, 0.09911052f, 0.10178507f, -0.05297154f, 0.04809251f, 0.00790043f, -0.11160541f, 
    -0.14712450f, 0.00722937f, 0.05970111f, 0.07107691f, 0.06894061f, -0.05306171f, 0.00689982f, -0.04084042f, 
    -0.10243750f, -0.10813957f, -0.02200880f, 0.25208467f, 0.04743867f, 0.12641349f, -0.04602489f, -0.13965046f, 
    -0.20968013f, 0.20026129f, 0.00599633f, 0.06010528f, 0.00132117f, 0.11430725f, 0.05800615f, 0.14440982f, 
    -0.00424378f, -0.04509095f, -0.01374537f, -0.09322707f, 0.15363696f, -0.06668036f, 0.06153838f, -0.08800539f, 
    -0.01850203f, -0.10778733f, 0.08362869f, -0.08807804f, 0.06495710f, 0.17868944f, -0.04033914f, -0.13973515f, 
    -0.15323113f, 0.20427063f, 0.04771414f, -0.04786735f, 0.08306362f, 0.19684666f, 0.25334924f, 0.17729622f, 
    -0.01777651f, -0.03939686f, -0.04669467f, 0.17051150f, -0.12144831f, 0.11359452f, -0.06082096f, 0.02315596f, 
    0.04576389f, -0.05992066f, 0.00338206f, 0.01073741f, -0.07536501f, -0.06854530f, 0.11051003f, -0.00223669f, 
    0.55667460f, -0.26626956f, 0.03915910f, -0.04822664f, -0.08365106f, -0.13547808f, 0.15279374f, 0.08688539f, 
    -0.20926608f, -0.10906527f, -0.05987893f, -0.03319659f, 0.05077470f, -0.08328260f, 0.12559126f, 0.01454293f, 
    0.04541768f, 0.01625420f, 0.02688917f, 0.07300936f, 0.09776153f, -0.23157158f, 0.04774734f, -0.01567443f, 
    -0.12050144f, 0.22428450f, 0.14102241f, -0.04213535f, 0.01110665f, 0.07022734f, -0.03706188f, -0.08183754f, 
    -0.17276923f, -0.12622403f, 0.02791763f, -0.14894186f, 0.13758604f, 0.12394480f, 0.13803802f, 0.04877180f, 
    0.05820499f, -0.04081038f, 0.17207858f, -0.03876529f, 0.07286912f, 0.14576603f, 0.00653746f, -0.00608068f, 
    -0.30502871f, 0.08240020f, 0.14562058f, -0.01511889f, 0.07523505f, 0.00771498f, -0.05237504f, -0.05475089f, 
    0.14108522f, 0.08038711f, -0.01561652f, 0.14020981f, 0.28497910f, 0.14921866f, -0.20497344f, 0.11115694f, 
    0.09998369f, 0.06437381f, 0.14293623f, 0.03038177f, 0.04526369f, -0.05596516f, -0.04388318f, -0.13092433f, 
    -0.00424570f, -0.22676294f, 0.05889259f, -0.02639590f, -0.12121446f, 0.10170043f, 0.13657580f, 0.05380079f, 
    -0.03440028f, 0.23958705f, 0.12016563f, -0.01273816f, 0.01614091f, 0.07226092f, 0.14638349f, -0.06645623f, 
    -0.07765852f, 0.00484693f, 0.02986589f, -0.07507027f, -0.07176366f, 0.17883706f, 0.06356541f, 0.11801613f, 
    0.22156301f, -0.14189227f, -0.04030309f, -0.23948155f, -0.14238118f, -0.11493198f, -0.05668290f, 0.16369952f, 
    0.08974282f, -0.00447959f, 0.06223036f, -0.01151335f, -0.03034547f, -0.21598573f, 0.03199845f, 0.05325182f, 
    0.00796325f, 0.13544717f, 0.08058025f, 0.02147815f, 0.14108877f, 0.15173180f, 0.10016593f, -0.02288030f, 
    0.08135099f, 0.12654932f, 0.01062268f, -0.01431636f, -0.14589457f, -0.01432219f, 0.11377030f, -0.01737235f, 
    0.01848079f, 0.06622200f, -0.11793534f, -0.00623086f, 0.30866936f, -0.17634547f, 0.08915871f, 0.22240040f, 
    0.05409262f, 0.09810999f, 0.10168345f, -0.21407567f, -0.01469090f, 0.04288828f, -0.09807196f, 0.10298651f, 
    -0.01719913f, 0.03519507f, 0.11550384f, 0.03052576f, -0.08182433f, -0.02880452f, 0.07642642f, -0.04174289f, 
    -0.03496163f, 0.06446627f, 0.12823744f, 0.06858663f, -0.14674884f, 0.13268119f, -0.06375952f, 0.14073247f, 
    -0.01459603f, 0.00862256f, -0.02506597f, 0.06131970f, 0.14877950f, 0.01747323f, 0.20035651f, 0.14791583f, 
    -0.05099257f, -0.27695999f, -0.12406451f, -0.08240057f, 0.07161810f, -0.16060761f, -0.07088138f, 0.10258496f, 
    -0.01983301f, 0.05944009f, 0.09809562f, -0.14800623f, 0.01368660f, 0.06012855f, 0.01530113f, -0.12910432f, 
    0.17483114f, 0.13750859f, -0.02394777f, 0.12122693f, 0.03839067f, -0.03864242f, 0.01672912f, -0.00624717f, 
    0.12623508f, 0.16488124f, -0.13143472f, 0.01795519f, -0.06627181f, 0.05512630f, 0.23289570f, 0.16499683f, 
    -0.04614384f, 0.02090758f, 0.08088494f, 0.02580572f, -0.24599072f, 0.13153128f, -0.26109308f, -0.17928746f, 
    0.09934794f, -0.17335892f, 0.03543428f, 0.16280341f, 0.06281325f, 0.11181358f, 0.09018060f, -0.06091055f, 
    -0.15404204f, -0.29857227f, -0.07187512f, -0.22279331f, 0.08735248f, -0.15683019f, 0.26816362f, 0.02663933f, 
    0.02820796f, -0.07317825f, -0.06669712f, 0.02367717f, 0.19587843f, -0.00641828f, -0.01284579f, -0.10926484f, 
    0.09190380f, -0.03575944f, 0.02825851f, 0.11042383f, 0.09423403f, -0.14706078f, 0.02416302f, -0.16025856f, 
    0.49283522f, 0.28470656f, -0.22717090f, -0.14210369f, 0.03414537f, 0.09820434f, -0.14712000f, -0.02886459f, 
    -0.04885105f, -0.03595009f, 0.11314767f, 0.13576250f, 0.09521321f, -0.04994832f, 0.01661364f, -0.11477790f, 
    0.02491760f, 0.00941288f, -0.00446983f, -0.04616028f, -0.00711970f, -0.00307610f, 0.09056265f, 0.01526804f, 
    0.01622387f, 0.05573740f, 0.01682895f, -0.05089603f, -0.02535403f, -0.05829277f, 0.17000799f, -0.02674739f, 
    0.04227933f, 0.02007824f, -0.22516321f, -0.12342425f, -0.00209303f, 0.04823387f, 0.07175121f, -0.06568626f, 
    -0.04650635f, -0.03993804f, -0.13066353f, -0.15272814f, -0.05309677f, 0.04742878f, -0.04352377f, 0.03182495f, 
    0.07414214f, -0.51424915f, 0.03594739f, -0.22741981f, -0.06367073f, -0.02892165f, -0.03888445f, 0.05402644f, 
    0.08089918f, -0.02519612f, 0.03016910f, 0.07637194f, 0.01775134f, -0.24530518f, -0.02906028f, 0.01431204f, 
    -0.08413579f, -0.03659647f, 0.06018900f, 0.08566131f, -0.07637026f, -0.13245401f, 0.06707831f, 0.01129902f, 
    -0.01484790f, 0.24924217f, -0.03887377f, 0.23082986f, 0.06917770f, -0.15576605f, -0.11812384f, 0.02258873f, 
    0.06217972f, -0.06879126f, -0.11380772f, -0.09037764f, 0.09650154f, 0.01844120f, -0.09984341f, 0.09914488f, 
    0.05878185f, 0.08257240f, -0.02172999f, -0.23791437f, -0.06344795f, 0.02321746f, 0.10437759f, 0.00544846f, 
    0.24962728f, -0.09113718f, 0.01861008f, 0.14021914f, 0.00903352f, 0.16784653f, 0.09142213f, -0.02749116f, 
    -0.10769242f, 0.04074509f, -0.09449624f, 0.12864424f, -0.09974413f, -0.14488624f, -0.01413267f, -0.01376471f, 
    -0.02410712f, 0.20231920f, -0.14776865f, 0.18328333f, 0.26412395f, 0.03976387f, -0.02436283f, 0.23902938f, 
    0.00481295f, -0.16511166f, 0.02350504f, 0.18771887f, 0.07241259f, 0.02351741f, -0.05200478f, 0.03524178f, 
    0.07749333f, 0.05947828f, -0.04524695f, 0.00831069f, 0.11697461f, -0.12089667f, 0.05453313f, -0.08436452f, 
    -0.02018167f, 0.10913116f, -0.02644307f, -0.11617268f, 0.05575015f, 0.13134451f, 0.00081227f, 0.03080203f, 
    -0.41006550f, 0.34900200f, -0.00564930f, 0.17068531f, 0.06399333f, -0.06062001f, 0.01739758f, 0.09556814f, 
    0.04950267f, 0.05263157f, -0.00382707f, -0.04561361f, -0.01468225f, -0.06036347f, -0.07848346f, 0.09986327f, 
    0.08181245f, -0.02686192f, 0.00633270f, -0.04439813f, 0.07106791f, 0.17663866f, 0.07198748f, -0.01303405f, 
    0.12408412f, -0.18005516f, -0.06781109f, 0.01214495f, 0.09298287f, -0.04426062f, -0.01022841f, 0.12598367f, 
    0.07749321f, 0.01844805f, -0.09307678f, 0.15570594f, -0.04682576f, -0.00352119f, 0.07968913f, -0.13092434f, 
    0.10926764f, -0.09761410f, -0.11457979f, 0.03458092f, 0.09463969f, 0.02795208f, -0.02876432f, 0.00993351f, 
    0.51915276f, 0.17737827f, 0.00257857f, -0.11650050f, 0.04374767f, -0.13412376f, -0.00870742f, -0.13985187f, 
    0.09026577f, -0.06386556f, 0.15396613f, 0.00265782f, -0.21302693f, 0.12679882f, 0.37401965f, -0.15128012f, 
    -0.05504900f, -0.05470074f, -0.10472836f, 0.03882002f, 0.01155498f, -0.06954896f, 0.01690231f, 0.07446474f, 
    0.28522867f, -0.03685589f, -0.03624202f, -0.02898457f, 0.07248459f, 0.07293553f, -0.02236155f, -0.01170198f, 
    0.08326045f, 0.18422237f, 0.27544603f, 0.34578127f, -0.19461438f, 0.06058981f, -0.17303890f, 0.02453113f, 
    0.19982243f, 0.13198760f, 0.28594226f, 0.05884030f, 0.10431227f, 0.16030104f, 0.07728162f, -0.08020991f, 
    -0.00582675f, 0.21663050f, 0.12175889f, 0.17035595f, 0.02126730f, -0.04517993f, 0.03754360f, -0.20180167f, 
    0.02197855f, -0.03697594f, 0.01157674f, 0.07736982f, 0.04504050f, -0.02487045f, -0.05734220f, -0.06758782f, 
    0.16444941f, 0.12400907f, 0.05728247f, -0.05868754f, 0.11933414f, 0.17284553f, 0.18074726f, 0.25730845f, 
    -0.05485183f, 0.00693766f, 0.19795512f, 0.11018925f, -0.01213353f, -0.01323701f, -0.07781126f, -0.09997091f, 
    -0.36860344f, -0.29138175f, -0.31039631f, -0.24910857f, -0.37519950f, -0.23002739f, 0.28292516f, 0.05120122f, 
    -0.09845578f, -0.04647887f, -0.02379020f, -0.00983316f, -0.00664779f, 0.08972038f, 0.04150312f, 0.16702235f, 
    0.33997774f, -0.15730347f, 0.13302599f, -0.15315899f, -0.02480136f, 0.09973510f, -0.12939048f, 0.09236608f, 
    0.02421986f, 0.02249867f, 0.04705162f, -0.06453771f, -0.05844003f, 0.20565972f, 0.04019265f, 0.15977634f, 
    0.04570247f, -0.10222240f, 0.11554623f, -0.04049058f, -0.23292810f, -0.09000050f, -0.10314327f, 0.11420131f, 
    0.22270000f, -0.01515989f, 0.05700307f, -0.02442373f, 0.05156680f, -0.00941027f, -0.10842153f, -0.13663314f, 
    -0.00718674f, -0.19915655f, 0.09700330f, 0.08139915f, -0.18037142f, 0.04390374f, -0.00161141f, -0.22874063f, 
    0.10798918f, -0.14178360f, -0.04201284f, 0.09212903f, -0.03370560f, -0.32169461f, -0.12232909f, -0.43568325f, 
    0.09821665f, 0.06812755f, 0.46299824f, -0.03535100f, 0.05130957f, 0.06068045f, -0.20689903f, -0.04543710f, 
    0.03581118f, 0.00996069f, -0.01861111f, 0.01469833f, 0.02375584f, 0.08539298f, -0.04011830f, 0.02890128f, 
    -0.09090503f, 0.01576639f, 0.08064810f, 0.00536957f, -0.00633717f, -0.02202338f, -0.06512503f, -0.11354047f, 
    0.26269531f, -0.00410451f, -0.09062359f, -0.14863037f, 0.21742482f, -0.04120266f, -0.02000510f, 0.03082418f, 
    -0.05297740f, 0.05124913f, 0.10443082f, -0.22498618f, -0.13975643f, 0.19924963f, -0.14781635f, 0.21176714f, 
    -0.19215550f, 0.13174304f, -0.11763562f, 0.04109059f, -0.09530377f, -0.18437366f, -0.03396031f, -0.10395227f, 
    0.22419696f, -0.07933328f, 0.44137934f, 0.08361568f, -0.07921644f, 0.20671810f, -0.06989838f, 0.04280994f, 
    -0.17343692f, 0.02651355f, 0.16061287f, 0.06570824f, 0.25483835f, 0.12424354f, -0.28282502f, -0.13106444f, 
    0.02102980f, 0.04860758f, -0.06427884f, -0.09433300f, -0.25915951f, -0.00527914f, 0.06598686f, -0.14070562f, 
    0.12057699f, 0.07628026f, 0.17174637f, 0.09211802f, 0.11398812f, 0.06805084f, 0.08967885f, 0.00706129f, 
    -0.02531631f, -0.07972854f, -0.10488377f, -0.09107713f, -0.22110744f, -0.16371328f, -0.14148664f, -0.06741361f, 
    0.12468501f, -0.12757671f, -0.05949956f, -0.06422351f, -0.11093977f, 0.13344207f, 0.06642450f, 0.02723507f, 
    -0.32758284f, -0.44212860f, -0.19314180f, -0.09112237f, 0.08596864f, -0.02127687f, 0.00365310f, -0.03786649f, 
    -0.06374134f, -0.09136849f, 0.07352008f, -0.03924337f, 0.15028305f, -0.18172020f, -0.15696627f, -0.00902391f, 
    0.00590111f, -0.04149788f, 0.08726934f, 0.07780847f, -0.18651304f, -0.14254834f, 0.00102846f, -0.04607756f, 
    -0.08493324f, 0.15417090f, 0.03643220f, 0.22005995f, 0.14180516f, -0.14589052f, -0.07738552f, -0.05035169f, 
    0.00752027f, 0.04830831f, -0.01263397f, 0.02792649f, -0.07843713f, 0.00343572f, 0.09013540f, 0.13084334f, 
    -0.04729140f, 0.06439153f, 0.04804220f, -0.00779917f, -0.09347130f, 0.09051731f, -0.01053789f, -0.06613795f, 
    0.41650110f, -0.27521372f, 0.15588637f, 0.01743483f, 0.09109332f, -0.00270652f, -0.10724018f, 0.09423794f, 
    -0.03050165f, 0.03900720f, -0.09677987f, 0.12180663f, -0.10469823f, -0.06300043f, -0.00509582f, -0.02805713f, 
    0.03622701f, 0.02260948f, -0.11402376f, 0.15647270f, 0.25534618f, 0.18071631f, 0.02340857f, 0.17166686f, 
    0.22677186f, -0.00453922f, 0.16089708f, 0.19380502f, 0.08399070f, 0.15160432f, 0.03240512f, 0.08648611f, 
    0.08582551f, 0.10018824f, -0.08979156f, 0.16542512f, 0.00899206f, -0.13882083f, -0.02309623f, -0.16645996f, 
    -0.01701346f, -0.07621226f, -0.03128233f, -0.10615522f, 0.06118647f, 0.12399765f, 0.12797615f, 0.10776234f, 
    -0.18256819f, 0.23532759f, 0.22026893f, 0.22312041f, 0.09332608f, 0.02879635f, -0.07172900f, 0.08480734f, 
    0.01240062f, -0.02131732f, -0.02403454f, -0.01690530f, -0.01879969f, 0.00660130f, 0.15087660f, 0.24611026f, 
    0.02445858f, 0.02989871f, 0.11713494f, 0.03558389f, 0.13401850f, 0.09678803f, 0.02629568f, 0.07000501f, 
    0.26129547f, -0.05341770f, 0.06918603f, 0.10707316f, 0.12911795f, 0.02829568f, -0.05963875f, -0.10371704f, 
    -0.12224951f, -0.06943365f, 0.00587356f, 0.04808736f, -0.21142252f, 0.05568403f, -0.02884967f, -0.21868165f, 
    0.00442239f, 0.02210687f, -0.06510478f, 0.01982963f, 0.02280609f, 0.05938990f, 0.00541992f, 0.14479697f, 
    0.08101002f, 0.00879015f, 0.05616307f, -0.02452503f, 0.08119555f, -0.19750141f, -0.01953394f, -0.13720685f, 
    0.11453674f, 0.06558716f, 0.13738874f, 0.02581940f, -0.12065792f, 0.18732622f, 0.23836620f, -0.16911443f, 
    -0.02906194f, 0.01579746f, 0.07000697f, 0.01921190f, 0.01630867f, -0.02185826f, -0.04515878f, 0.10631032f, 
    0.10819058f, 0.14122249f, -0.07140194f, 0.10256855f, 0.07774942f, -0.02295447f, 0.00710696f, -0.12512760f, 
    0.16235024f, -0.00349651f, 0.16058099f, 0.20611067f, -0.00878284f, -0.12717614f, -0.14929464f, -0.01864813f, 
    0.11291747f, 0.01125522f, 0.00416023f, -0.01505448f, 0.05006909f, -0.03745799f, 0.02982275f, -0.01428246f, 
    0.37669134f, 0.28133741f, 0.19694889f, 0.16444765f, 0.03313886f, 0.02349393f, 0.03332854f, 0.03817336f, 
    -0.00364276f, -0.06982242f, -0.02390999f, 0.16854931f, 0.01773837f, 0.05143732f, 0.14890485f, 0.06623038f, 
    -0.03328102f, -0.01352518f, -0.05398119f, -0.11152423f, -0.00599467f, 0.09339693f, 0.00723895f, 0.04696316f, 
    -0.37178415f, -0.15424997f, -0.03020441f, -0.11799689f, 0.07732277f, 0.04884771f, 0.03870174f, 0.03928687f, 
    0.06540868f, -0.03906962f, -0.06694449f, -0.05262482f, -0.32256114f, 0.00505022f, 0.11512610f, -0.19672556f, 
    0.15600614f, -0.09106916f, -0.05950756f, 0.04740987f, -0.03744119f, 0.01887826f, 0.00477770f, -0.01510134f, 
    -0.28126732f, 0.05393504f, -0.09310441f, -0.15463640f, -0.05885842f, -0.06735058f, -0.04772281f, 0.11688931f, 
    -0.08523854f, -0.06714050f, -0.15419467f, 0.01637007f, 0.17133716f, 0.11815462f, 0.04633025f, -0.04642355f, 
    0.05839578f, -0.09771493f, 0.00467828f, -0.02791042f, -0.28562438f, -0.18617535f, 0.04413728f, -0.06411967f, 
    0.01124328f, 0.14627668f, 0.05889751f, 0.13925847f, 0.03257784f, -0.09479643f, 0.07284549f, 0.10308032f, 
    0.04593144f, -0.06925536f, -0.00696180f, 0.12851298f, 0.15723279f, 0.02531154f, -0.00307004f, 0.10530784f, 
    -0.02668180f, -0.02813744f, -0.02443208f, 0.04921148f, 0.06839342f, -0.06821895f, 0.00686219f, -0.12197194f, 
    -0.07907671f, 0.33333269f, -0.07064331f, 0.19112797f, 0.14590612f, 0.06353014f, 0.02336934f, -0.02278375f, 
    0.15276954f, -0.02905544f, -0.00468339f, -0.09289166f, 0.14821085f, 0.09423118f, 0.11575998f, 0.19993903f, 
    -0.18348877f, 0.10261395f, -0.02804199f, 0.07812507f, 0.09100464f, -0.04337587f, -0.15259558f, 0.01839576f, 
    0.07895987f, 0.14241746f, 0.25748613f, 0.36517152f, -0.13594261f, -0.07895339f, 0.05179164f, 0.07512563f, 
    0.07865708f, -0.00154540f, 0.05004430f, -0.03679916f, -0.31718612f, -0.30795959f, -0.09470161f, -0.15206528f, 
    0.06117203f, 0.05939659f, 0.16120479f, 0.00098513f, 0.04147343f, 0.08993950f, -0.10422173f, -0.04740766f, 
    -0.34742036f, -0.08856686f, -0.24906230f, 0.09541196f, -0.06527875f, -0.00090971f, -0.02463458f, -0.06425415f, 
    0.12349208f, -0.09693751f, -0.09194959f, 0.02668359f, -0.06670219f, -0.14798482f, -0.07416563f, 0.24130929f, 
    -0.04885177f, -0.08919456f, -0.12672766f, 0.07843871f, 0.05517584f, 0.01388012f, 0.00848180f, 0.00844455f, 
    -0.19604023f, 0.14323317f, -0.13747299f, 0.10922626f, 0.01982973f, 0.07580482f, 0.05502346f, 0.15765618f, 
    0.05195462f, -0.05116239f, 0.05709646f, -0.10213029f, 0.02713402f, 0.03023838f, 0.10024336f, 0.02161997f, 
    -0.07354321f, 0.11615788f, 0.07798933f, 0.09689052f, 0.05080144f, 0.09591985f, 0.04224482f, 0.14151952f, 
    0.06209673f, 0.26814219f, 0.04796601f, -0.05352459f, -0.09223880f, -0.17881010f, -0.18768173f, 0.05614378f, 
    -0.15400429f, -0.02941782f, -0.08238767f, -0.15949899f, -0.20543942f, 0.17252401f, 0.00256572f, -0.18201083f, 
    -0.06518741f, -0.09728494f, -0.08829101f, -0.09136439f, 0.04973558f, 0.12271451f, -0.07301832f, -0.04909353f, 
    0.33064011f, -0.10427526f, -0.03860154f, 0.06319930f, -0.11870354f, 0.05573412f, 0.10220176f, 0.03290912f, 
    0.04943761f, -0.00591094f, 0.13874836f, 0.00258906f, 0.51974225f, -0.06379724f, 0.05783414f, 0.18439889f, 
    0.13796920f, -0.20623255f, 0.05446123f, 0.05600568f, -0.13781679f, -0.16987482f, 0.00572894f, -0.04439116f, 
    -0.34988397f, 0.12530878f, 0.17551580f, 0.13999337f, 0.14868177f, 0.00920008f, 0.15298526f, -0.08574986f, 
    0.18182838f, -0.08292878f, 0.32142168f, -0.06368581f, -0.19041461f, 0.11873330f, -0.17892542f, -0.05321791f, 
    -0.13699798f, 0.11879319f, 0.17833780f, -0.12622090f, -0.06209433f, 0.08791313f, 0.14434670f, 0.01327673f, 
    -0.22842425f, 0.04167445f, 0.01692018f, -0.16601039f, -0.07273778f, -0.07612010f, 0.02884807f, 0.16750573f, 
    0.14341156f, 0.03478974f, 0.10946949f, -0.22475666f, -0.23126204f, 0.13736857f, 0.00693070f, 0.03048492f, 
    -0.04105121f, 0.22447059f, -0.13375114f, 0.03569005f, -0.02520938f, -0.14187796f, 0.00920566f, 0.03043688f, 
    0.37411126f, 0.01097430f, -0.23418690f, 0.13343568f, 0.06776641f, 0.06581007f, 0.24508150f, -0.02635493f, 
    -0.12243119f, -0.00724257f, -0.01973442f, 0.02550437f, -0.03369200f, 0.00826655f, 0.25498757f, -0.25660342f, 
    0.02085277f, -0.02078164f, -0.11371525f, 0.16752422f, 0.01922225f, -0.04214697f, 0.08071366f, 0.01196930f, 
    -0.09680714f, 0.19910643f, 0.24233532f, -0.00859503f, -0.01483583f, -0.09861834f, -0.06299713f, -0.00387635f, 
    0.09827439f, 0.05301400f, -0.09196085f, -0.09907513f, 0.23338522f, 0.16153063f, -0.05254321f, 0.22058943f, 
    -0.09823738f, -0.12582213f, -0.00229357f, 0.10007748f, -0.06971446f, 0.07722392f, -0.00273919f, -0.05363149f, 
    -0.21670197f, 0.04296798f, -0.10250008f, 0.27757266f, 0.06087915f, 0.04608824f, 0.05840586f, -0.01351484f, 
    -0.05765225f, 0.10649294f, -0.05379651f, 0.19297987f, 0.00034974f, -0.18244374f, 0.06923226f, 0.09433444f, 
    0.04217557f, 0.09230587f, 0.24028529f, -0.08965840f, 0.21911186f, 0.05429522f, 0.03736095f, -0.05457854f, 
    0.14220361f, 0.12029152f, 0.09540602f, 0.15124401f, 0.07132908f, -0.05920767f, 0.08211919f, 0.00491252f, 
    0.09597681f, -0.03298658f, 0.00048579f, 0.10655746f, -0.20419443f, -0.02833833f, -0.23444267f, -0.11413403f, 
    0.01582672f, -0.07425559f, -0.14803685f, 0.05893010f, 0.10337760f, 0.17372133f, 0.13249852f, -0.09162613f, 
    -0.14395265f, 0.13013877f, 0.17965086f, 0.06884190f, -0.13286187f, -0.18696764f, -0.11646825f, -0.01320667f, 
    -0.10515989f, 0.00632977f, 0.18306519f, 0.04616206f, 0.11340697f, 0.11242610f, -0.08392647f, -0.11188491f, 
    0.04514689f, -0.02863260f, -0.13304225f, -0.11462981f, 0.03849006f, 0.00262799f, 0.08818679f, 0.13281028f, 
    0.09653705f, -0.04239976f, 0.05790912f, 0.05733940f, -0.15016092f, -0.14296998f, -0.13511573f, -0.01858823f, 
    -0.00127934f, -0.09764004f, 0.02102119f, -0.04837050f, -0.08462156f, 0.05592273f, 0.21171571f, 0.36518797f, 
    -0.03756688f, 0.05047607f, 0.25542134f, 0.18172404f, -0.05446732f, 0.14128615f, 0.18440720f, 0.01829700f, 
    0.34347561f, -0.17295335f, 0.19277693f, 0.12365539f, 0.27729419f, 0.13866544f, 0.03656804f, 0.17238687f, 
    0.12591462f, 0.09976187f, 0.00805787f, 0.15311269f, -0.06347794f, 0.22699939f, 0.03000444f, 0.05331177f, 
    0.02734978f, 0.00698463f, 0.07012868f, -0.17451034f, 0.14806354f, 0.27987593f, 0.02970033f, 0.25171006f, 
    0.06287263f, 0.04166330f, 0.05041020f, 0.23365042f, -0.03870542f, 0.09758639f, 0.03528054f, 0.12297596f, 
    0.08222861f, 0.02642180f, 0.01962294f, 0.02665030f, -0.03888905f, -0.15052721f, -0.14465481f, -0.23396417f, 
    0.05839217f, -0.08353218f, 0.12169670f, 0.04006395f, 0.08845460f, -0.03868535f, 0.01596935f, -0.10984907f, 
    0.19176802f, -0.04517299f, 0.49720445f, 0.01130116f, -0.02765870f, 0.02159985f, 0.09814205f, 0.10975684f, 
    0.05582169f, 0.04383334f, 0.01180685f, 0.16666585f, 0.00765900f, 0.00685198f, 0.31208441f, 0.10480368f, 
    0.01734810f, 0.03160892f, 0.09608076f, 0.05147576f, 0.07827450f, 0.06859405f, -0.01284381f, -0.00881235f, 
    -0.17831840f, 0.07527604f, 0.09778801f, 0.03855871f, 0.14234069f, -0.05615710f, -0.15835474f, 0.00675629f, 
    -0.12147127f, 0.00823091f, -0.01402379f, -0.03984478f, -0.13572131f, 0.20187096f, -0.10920551f, 0.17911014f, 
    -0.12851599f, 0.24207781f, -0.27621531f, 0.07453100f, -0.01745519f, 0.03096523f, 0.05564313f, 0.09089239f, 
    -0.10616799f, -0.12516105f, 0.07208571f, -0.06362984f, -0.04912800f, -0.16723925f, -0.03393704f, -0.29230115f, 
    -0.01443839f, 0.16268697f, 0.11866581f, -0.01300234f, -0.27642161f, -0.12568802f, 0.23371510f, 0.33801395f, 
    0.03366457f, 0.00301125f, 0.19543698f, 0.05078287f, -0.10170144f, 0.03503318f, -0.15978098f, -0.03040368f, 
    0.12981342f, 0.01160999f, 0.02060712f, 0.03916261f, 0.07184607f, 0.10587989f, 0.06104371f, 0.01182756f, 
    0.09324574f, 0.03548912f, -0.04977940f, -0.02156309f, -0.24875730f, 0.06794210f, -0.04376147f, -0.20200458f, 
    -0.10844194f, -0.13237835f, -0.02308589f, -0.03071634f, -0.26929733f, 0.05842291f, -0.01067872f, -0.07017273f, 
    -0.12385008f, -0.33367050f, 0.17553246f, -0.03652505f, 0.05360961f, -0.09233101f, 0.05696752f, 0.05393901f, 
    -0.05957970f, 0.02265951f, -0.00224101f, 0.09094258f, 0.13054469f, -0.14120929f, -0.09095983f, -0.01111212f, 
    0.01804841f, 0.00970173f, 0.00336544f, 0.11874633f, 0.01329029f, 0.00237659f, 0.10086699f, 0.03667695f, 
    -0.02332334f, 0.24710663f, -0.05685226f, 0.19194859f, 0.06663015f, -0.12708357f, -0.04944133f, 0.02654457f, 
    0.11414050f, -0.14005551f, -0.09157201f, -0.06642950f, -0.04564802f, 0.05705526f, -0.05682400f, 0.19873220f, 
    0.10331433f, 0.02893081f, 0.05331396f, -0.02277426f, -0.03609518f, 0.11814225f, 0.01718068f, 0.04190954f, 
    0.31704870f, -0.21157929f, 0.18083198f, 0.02735646f, 0.04938369f, -0.00402286f, 0.07253049f, 0.08493259f, 
    0.10652933f, 0.13683784f, -0.02934284f, 0.03434806f, -0.15987948f, -0.09478153f, 0.07046850f, 0.00488997f, 
    -0.18606149f, 0.10116851f, -0.05865429f, 0.05108546f, 0.25208637f, 0.17566390f, 0.01607900f, 0.18921910f, 
    0.05616801f, -0.28945854f, -0.11296912f, 0.11160630f, 0.01001637f, 0.00775963f, -0.00054431f, -0.03727929f, 
    0.10053041f, 0.02823746f, -0.06747180f, 0.06064222f, 0.00632753f, -0.25701210f, -0.13600786f, -0.28927219f, 
    0.08638701f, 0.06857889f, -0.02593584f, -0.06913871f, 0.10001746f, 0.09851924f, -0.02990450f, -0.10323104f, 
    -0.32584384f, 0.13239565f, 0.22463430f, 0.13214891f, 0.03636402f, 0.09740955f, 0.07661849f, 0.14220922f, 
    0.12908025f, 0.05813370f, 0.03273627f, 0.09189453f, -0.11423936f, -0.06326710f, 0.02023116f, 0.00973652f, 
    0.17355061f, -0.06259281f, 0.06785150f, 0.04029562f, 0.17554048f, 0.07623506f, 0.00828740f, 0.09045517f, 
    -0.14609081f, -0.19305500f, -0.21062100f, -0.10813890f, 0.17318359f, -0.08329508f, 0.01797853f, 0.12632293f, 
    -0.10738567f, 0.03155065f, 0.02217834f, 0.05599994f, -0.04715775f, 0.20883863f, -0.04016182f, -0.05285701f, 
    -0.18746780f, -0.01381562f, -0.25217479f, -0.04057594f, -0.11008218f, -0.08738907f, -0.00674728f, 0.14988840f, 
    0.72583640f, 0.33275211f, -0.07549853f, -0.00999070f, -0.07451750f, -0.02912021f, 0.10089859f, -0.04172144f, 
    0.08957899f, 0.00981879f, 0.11865973f, 0.12255791f, -0.21649079f, -0.09739601f, 0.12610641f, -0.08745353f, 
    -0.02961445f, 0.10511238f, -0.01322747f, -0.04160970f, 0.03285559f, -0.08134015f, -0.11307243f, 0.05940804f, 
    -0.09013893f, 0.05790159f, -0.01944413f, -0.08638721f, -0.03181348f, -0.07929056f, -0.04921154f, -0.06617172f, 
    -0.05847683f, -0.07448766f, -0.07361261f, -0.01734869f, 0.00266611f, -0.08415727f, -0.08698393f, -0.03881579f, 
    -0.00027048f, -0.04281523f, -0.06976760f, -0.03108397f, 0.03415360f, -0.01115671f, -0.01471930f, 0.04792994f, 
    -0.08627760f, -0.03098078f, -0.02446011f, 0.01612952f, 0.03573811f, 0.01484145f, 0.00997769f, 0.04216695f, 
    -0.09369601f, 0.02520979f, -0.04098583f, 0.01195885f, -0.10904828f, -0.02629107f, -0.03938299f, 0.03111836f, 
    -0.02028213f, 0.04676749f, 0.02581185f, 0.01300644f, -0.05430404f, 0.02998054f, -0.05511949f, -0.01933914f, 
    -0.02532162f, 0.00399079f, 0.04742004f, -0.08811466f, 0.00068206f, -0.08537479f, -0.07335848f, -0.02056992f, 
    -0.00378873f, 0.01242621f, -0.05176257f, -0.05780584f, -0.08189353f, -0.03720342f, 0.02666229f, 0.04048220f, 
    0.03247122f, 0.02520353f, -0.08280710f, -0.05196844f, -0.04183963f, -0.02653451f, -0.09407185f, -0.10135292f, 
    0.00489897f, 0.04865443f, 0.01211363f, -0.00250835f, -0.06886203f, 0.03663685f, -0.07982850f, -0.03008293f, 
    -0.09728774f, -0.07317170f, -0.06779347f, -0.08217296f, -0.00312703f, 0.05653017f, -0.06706529f, 0.02485389f, 
    -0.06626730f, -0.07435079f, -0.06839278f, -0.01425633f, 0.04601230f, -0.00696496f, 0.03788861f, -0.05256709f, 
    0.00179583f, -0.02743155f, -0.00558334f, -0.00598690f, -0.03737792f, -0.01993325f, -0.10222689f, -0.03252348f, 
    -0.03171870f, -0.07091907f, -0.10013220f, -0.10108660f, -0.02138202f, 0.03714192f, -0.06813393f, 0.02903217f, 
    -0.01714675f, -0.04824672f, -0.01555176f, -0.01127931f, 0.01850083f, -0.00787221f, -0.03966954f, 0.00290105f, 
    0.00130702f, -0.02241206f, 0.03398151f, -0.03653820f, 0.02806886f, -0.06328744f, 0.04267500f, -0.00381225f, 
    -0.01422333f, 0.03746184f, 0.03020132f, -0.06557564f, 0.01907779f, -0.00839195f, -0.02453100f, -0.01351096f, 
    0.00071719f, -0.04213148f, 0.06518883f, -0.00976018f, -0.03792341f, -0.03588981f, -0.00357627f, -0.00738737f, 
    0.02278593f, -0.00548372f, -0.03246868f, -0.08819129f, -0.02185235f, 0.02979561f, -0.08584516f, -0.10079445f, 
    -0.03239854f, -0.11162762f, -0.08955559f, -0.01140374f, -0.05547092f, -0.04017085f, -0.03282075f, 0.04459462f, 
    0.01379999f, -0.09211826f, -0.06906886f, -0.05189608f, 0.06037880f, -0.07121265f, 0.03506202f, 0.02422960f, 
    -0.08552852f, 0.05078659f, -0.03838547f, -0.03967252f, 0.02577298f, -0.10180181f, 0.04135919f, 0.04209872f, 
    -0.04594231f, -0.07220960f, 0.05618702f, 0.04135549f, -0.03614065f, -0.02826616f, 0.00187373f, -0.06760631f, 
    -0.02381183f, -0.00313882f, -0.05321396f, -0.11050349f, 0.03263928f, -0.08190727f, -0.09534113f, -0.01926656f, 
    0.17675398f, -0.21424527f, 0.18093556f, 0.02197775f, 0.06477571f, 0.01974412f, -0.05072890f, 0.10698156f, 
    -0.22776021f, 0.09171598f, -0.08981109f, -0.22458108f, -0.29679605f, -0.10808055f, -0.00825182f, -0.12035207f, 
    -0.09839281f, -0.12618087f, -0.11123851f, -0.15262744f, 0.00529347f, 0.17665605f, 0.02220631f, -0.07564547f, 
    -0.12066987f, -0.07602429f, -0.28129193f, -0.03809104f, 0.13964260f, 0.13659300f, 0.00994939f, -0.01598572f, 
    -0.08866379f, -0.02999026f, 0.08145178f, -0.01879587f, 0.13167976f, -0.05445829f, -0.04482234f, 0.17980458f, 
    0.11494230f, 0.05154745f, -0.08996941f, -0.00298396f, 0.01817115f, -0.09516093f, -0.12623264f, -0.14395422f, 
    -0.29329744f, 0.13238373f, -0.00776664f, 0.06244430f, -0.04248895f, -0.05902330f, -0.08012766f, -0.11794975f, 
    -0.01338040f, 0.15756217f, 0.15369065f, 0.09309449f, -0.24083970f, -0.05336564f, -0.04282559f, 0.08246236f, 
    -0.03711545f, -0.05204377f, 0.02376532f, 0.08092072f, -0.01797832f, -0.01003078f, -0.19434032f, -0.12874398f, 
    0.32868937f, -0.06965585f, -0.00349065f, -0.02743154f, 0.04505173f, -0.12811010f, -0.02286124f, 0.15569708f, 
    0.06306344f, -0.03965699f, -0.05285738f, -0.06384531f, 0.02862945f, 0.05065168f, 0.14277358f, 0.20594534f, 
    -0.01308064f, -0.09699825f, -0.10701805f, 0.12275316f, 0.12665832f, 0.12385590f, 0.11900961f, 0.00676004f, 
    0.16517901f, 0.07496820f, -0.00471835f, -0.01654206f, 0.02465001f, 0.00784111f, 0.04181477f, 0.18741170f, 
    0.03063992f, -0.01201915f, -0.00174871f, 0.11917778f, -0.13507301f, 0.05410963f, -0.06365772f, -0.13070096f, 
    -0.08731228f, -0.06483204f, -0.10747100f, 0.00475981f, 0.00559801f, 0.14731453f, 0.08843402f, 0.07925557f, 
    -0.12199367f, -0.36211953f, 0.34964237f, -0.01006839f, -0.03201001f, -0.02513311f, 0.01948652f, 0.20548758f, 
    0.02259681f, 0.02721113f, 0.01397941f, 0.11317362f, 0.00570282f, 0.04290922f, 0.04667681f, 0.17986405f, 
    -0.03628713f, 0.03025628f, 0.11908594f, 0.06474202f, 0.01385118f, 0.12474871f, 0.11085549f, -0.05597283f, 
    0.06627612f, -0.13241765f, -0.02985985f, 0.11346120f, -0.07231966f, -0.06948731f, 0.06621713f, -0.13768849f, 
    -0.04734446f, -0.12148580f, 0.02783406f, -0.01661564f, -0.17215079f, 0.06875160f, -0.02681202f, -0.30580643f, 
    0.00637410f, 0.03113109f, -0.07697870f, -0.02146497f, -0.02387100f, 0.01090841f, 0.05353058f, 0.06228297f, 
    0.29477724f, 0.20392241f, -0.08577436f, -0.31735936f, -0.01337568f, -0.10513359f, -0.04694880f, 0.06000520f, 
    0.15589917f, 0.17071204f, 0.13720159f, 0.06697740f, -0.03122893f, 0.06063509f, -0.03907996f, 0.11758090f, 
    -0.03290803f, -0.16148363f, 0.04027925f, -0.03245866f, 0.04359630f, 0.19029050f, -0.00847145f, 0.08204044f, 
    -0.16792305f, -0.18963711f, 0.14249425f, 0.01233104f, 0.01769151f, 0.04631453f, 0.21302232f, 0.24674535f, 
    -0.17009476f, -0.16927892f, 0.10072540f, -0.08807836f, 0.16750014f, -0.07779442f, 0.13039681f, 0.11407471f, 
    -0.01251238f, -0.04498523f, -0.02151400f, -0.08907601f, 0.16764732f, 0.08732567f, -0.02181956f, 0.07746641f, 
    0.19937629f, -0.17992859f, -0.03504323f, -0.30753934f, 0.11430599f, -0.07800200f, -0.16221502f, -0.13968715f, 
    -0.04993813f, 0.15518373f, 0.08365530f, 0.06510958f, -0.08653328f, -0.23666756f, 0.02059515f, -0.22797340f, 
    -0.12904476f, -0.14956154f, -0.15751639f, -0.17482345f, 0.04330062f, -0.22345665f, 0.06652913f, -0.05506874f, 
    0.22436108f, 0.20285901f, 0.22353989f, 0.32841372f, 0.03239748f, -0.00318352f, -0.10368093f, -0.11897008f, 
    -0.06901035f, -0.06553981f, 0.01260662f, 0.06396636f, -0.03127378f, -0.42948705f, -0.49555349f, -0.46586466f, 
    -0.03285475f, -0.17361690f, 0.10577951f, 0.14912596f, -0.06498445f, 0.12625717f, 0.05083539f, -0.06363903f, 
    -0.47354171f, -0.05376220f, -0.51217502f, -0.18011698f, 0.00268838f, 0.00982642f, -0.00995760f, 0.02604881f, 
    0.08533885f, -0.07537162f, 0.04222433f, 0.06918034f, 0.22723900f, 0.07750429f, 0.07002927f, 0.22874013f, 
    -0.03130646f, -0.15142769f, -0.09935639f, 0.03601494f, 0.24979970f, 0.22442584f, 0.30401933f, 0.01723115f, 
    -0.60915363f, 0.00386158f, -0.14160660f, -0.22842912f, 0.10281355f, 0.19744188f, 0.04944057f, 0.37668350f, 
    -0.04506046f, 0.03471983f, 0.14064211f, 0.05534295f, 0.05185591f, 0.07219413f, 0.12860996f, 0.02001728f, 
    0.09161913f, 0.02927503f, -0.19991982f, -0.13855743f, -0.07748969f, -0.14803776f, -0.08426557f, -0.04142137f, 
    0.31356484f, 0.05149633f, -0.27121261f, 0.34604189f, 0.01205895f, 0.26895958f, 0.25263548f, 0.11982591f, 
    -0.01474310f, -0.13908291f, 0.07866789f, 0.09028534f, -0.05862762f, -0.16941974f, -0.09421382f, 0.06009307f, 
    0.16456518f, 0.25989437f, 0.18910973f, 0.09532542f, 0.07941059f, -0.16077149f, 0.03556823f, 0.03004853f, 
    -0.47505057f, 0.37125778f, -0.28343478f, -0.50961047f, -0.11037602f, 0.03603965f, 0.01960845f, -0.06014766f, 
    0.02914845f, -0.09532295f, 0.09877975f, -0.11640346f, 0.03367618f, 0.09263059f, 0.12624283f, 0.01258106f, 
    0.00629822f, -0.10825848f, -0.06381950f, -0.06593756f, -0.08946115f, 0.09207858f, -0.16088793f, 0.03534844f, 
    -0.08697029f, 0.39879388f, 0.09480162f, 0.35232139f, -0.06243367f, -0.07792067f, 0.09785463f, -0.08993563f, 
    0.09694292f, -0.06144501f, 0.16603601f, 0.11013707f, -0.26972473f, -0.23747046f, -0.31352785f, -0.43897009f, 
    0.15828501f, -0.04364633f, 0.14811315f, 0.05233877f, 0.14411697f, 0.06772371f, 0.09255309f, 0.01164168f, 
    0.03461662f, -0.05044013f, -0.02580894f, 0.05200798f, -0.07261543f, -0.04477943f, 0.03296758f, -0.04187080f, 
    0.03629420f, 0.01669804f, -0.04746521f, -0.07818061f, -0.03210562f, -0.07812863f, 0.03779354f, -0.02323201f, 
    0.04710460f, 0.01335121f, 0.00341183f, -0.01518557f, -0.03626464f, 0.05452720f, 0.01034681f, -0.02994378f, 
    -0.05041914f, 0.01701360f, -0.03750488f, 0.00966472f, 0.01763416f, 0.05499043f, -0.00115109f, -0.07313513f, 
    -0.06053697f, 0.03467534f, -0.07453348f, -0.06554934f, 0.02355456f, -0.07574712f, -0.05383413f, 0.05442291f, 
    0.01071190f, 0.03112258f, -0.04071098f, 0.02783592f, 0.00156885f, -0.05929475f, -0.03664179f, -0.00658879f, 
    0.03154026f, -0.07630532f, 0.00985336f, -0.03205416f, -0.01899085f, 0.00751648f, 0.02809236f, -0.02845039f, 
    -0.04875472f, 0.05697171f, -0.02498771f, 0.05507858f, 0.02829125f, -0.02825152f, -0.02864139f, -0.07897089f, 
    0.03567697f, -0.02073942f, 0.02172428f, -0.07210193f, 0.01642369f, -0.07353492f, 0.01103522f, -0.05931348f, 
    -0.04808054f, -0.04622274f, 0.02530083f, 0.01584607f, -0.01018891f, 0.03458882f, -0.01603281f, -0.07189756f, 
    -0.02218509f, -0.02279825f, -0.00224841f, 0.04355487f, 0.06287858f, -0.03413989f, -0.02953843f, -0.02858742f, 
    -0.07763940f, -0.03181654f, 0.00907610f, -0.08065929f, 0.02607167f, -0.01223909f, -0.07848228f, -0.01937302f, 
    -0.06489615f, -0.05723668f, 0.00635807f, 0.00880348f, -0.01916007f, -0.00463001f, -0.00336512f, 0.05494986f, 
    0.04036367f, -0.04274097f, -0.00828373f, -0.05759256f, -0.00933760f, 0.01154751f, 0.00860754f, -0.05549781f, 
    -0.03813731f, 0.02591605f, 0.01460417f, -0.04254340f, -0.01213832f, -0.07612314f, 0.04119000f, -0.06483936f, 
    -0.05650934f, 0.03733196f, 0.02036526f, -0.06714331f, -0.06715052f, -0.07693790f, -0.02489611f, -0.07562786f, 
    -0.03896847f, -0.02489538f, -0.04553093f, 0.02261278f, -0.00606319f, 0.03720837f, 0.01487308f, -0.05700601f, 
    -0.00810572f, -0.02844460f, -0.00394719f, 0.01307285f, 0.00169055f, 0.00355767f, 0.02253356f, 0.00183268f, 
    0.00972458f, -0.01012553f, -0.03165463f, 0.05968132f, -0.03925941f, -0.04599107f, -0.01083394f, -0.00009488f, 
    -0.02351076f, -0.03230945f, -0.04417765f, -0.01861903f, -0.01178022f, -0.00027988f, 0.02880273f, -0.04364539f, 
    0.01727113f, 0.04320977f, 0.00369191f, -0.00600741f, 0.02668684f, 0.05720617f, 0.02209712f, -0.07974830f, 
    0.02553366f, 0.05640915f, 0.00337779f, 0.00935676f, 0.02620270f, -0.04424934f, 0.03426958f, -0.03900731f, 
    -0.00627867f, -0.05382675f, 0.01822672f, 0.04882364f, -0.07458792f, 0.04445428f, -0.07652622f, 0.01899478f, 
    -0.01118382f, -0.05877049f, 0.06192579f, 0.00311832f, 0.02231628f, 0.04861250f, 0.05805457f, 0.05499442f, 
    0.21428987f, 0.07755764f, -0.12140523f, 0.12121664f, 0.06441198f, -0.00743524f, 0.11251464f, -0.00140437f, 
    0.29894572f, 0.09350801f, 0.23365562f, 0.30933961f, -0.18130009f, 0.03100407f, -0.10379015f, -0.17657852f, 
    0.10131937f, 0.13366912f, 0.20595707f, -0.00461374f, 0.13154142f, 0.06690738f, 0.03435968f, 0.04179606f, 
    0.26488012f, 0.15195820f, 0.30516893f, 0.17598119f, 0.02447076f, -0.12464266f, -0.01309220f, 0.18957210f, 
    0.15191799f, 0.07491287f, -0.05248991f, 0.12903602f, -0.00102374f, -0.20140697f, -0.02118823f, 0.14166136f, 
    0.03412408f, 0.25858319f, 0.16433850f, 0.05037770f, 0.09844852f, 0.22047195f, 0.14519387f, 0.23755702f, 
    -0.07900957f, -0.05626350f, -0.00217755f, -0.04962089f, -0.01565966f, 0.07679408f, 0.01999651f, -0.25081503f, 
    -0.19434653f, -0.12288447f, -0.23149739f, -0.28831211f, -0.04565424f, -0.04407465f, 0.23613247f, -0.00304095f, 
    0.11405013f, 0.02786736f, 0.06096027f, -0.14384419f, 0.02209751f, 0.05463856f, -0.06703753f, 0.14374502f, 
    0.02943964f, -0.08531901f, -0.01074252f, -0.09113756f, 0.04080389f, 0.02385071f, -0.01032579f, 0.01453149f, 
    -0.03201806f, 0.02148446f, -0.03559999f, -0.04320405f, 0.05775505f, 0.17979053f, 0.01059338f, 0.18056166f, 
    -0.09784414f, -0.00563517f, -0.14894900f, -0.18429360f, -0.15899067f, -0.05794062f, 0.00351703f, 0.11628751f, 
    0.24804030f, -0.05502415f, 0.07547767f, 0.15798597f, -0.07146236f, -0.21346898f, -0.15013056f, -0.06695062f, 
    0.09643378f, -0.08135610f, 0.20034575f, 0.07149116f, -0.02308362f, 0.03436276f, 0.07303517f, -0.00253441f, 
    0.12137733f, 0.09758402f, -0.21154246f, -0.11367749f, -0.18687689f, -0.46131054f, -0.38666308f, -0.41213527f, 
    -0.13014250f, 0.40568352f, -0.06758408f, 0.19057085f, 0.09704228f, 0.12898725f, 0.14795643f, -0.03515052f, 
    -0.08609399f, -0.10598498f, 0.02303668f, -0.22480920f, 0.14425428f, 0.26086906f, -0.03661146f, 0.13030978f, 
    -0.12935458f, -0.09444157f, 0.00164599f, 0.13301733f, -0.08844050f, 0.20503303f, -0.13487194f, -0.14766321f, 
    0.04584171f, -0.10650321f, -0.03747750f, 0.01045537f, 0.04340086f, -0.14233036f, 0.03922388f, 0.10756781f, 
    -0.03438686f, -0.08823534f, -0.10687862f, -0.18336727f, 0.12695870f, -0.12383056f, -0.07543356f, -0.08939568f, 
    0.02586109f, 0.03264898f, -0.10293657f, 0.01596658f, -0.09468526f, -0.33154950f, 0.01216689f, -0.20961143f, 
    0.23553513f, -0.06678879f, -0.05445442f, 0.15282589f, -0.31516057f, 0.18777266f, -0.05815694f, -0.11732449f, 
    0.03269018f, 0.10952228f, 0.20641118f, 0.16270468f, 0.06228884f, -0.27609786f, 0.10015757f, 0.19299546f, 
    0.12699188f, -0.01686874f, -0.10629312f, 0.00977431f, -0.14850089f, -0.06635164f, 0.14058542f, 0.06375188f, 
    -0.04147780f, 0.00980497f, 0.06923858f, 0.06459234f, -0.02474401f, -0.03982280f, 0.00454268f, 0.02519581f, 
    -0.00273567f, -0.00655714f, -0.00359852f, 0.03788483f, 0.04639888f, -0.00897471f, -0.01315845f, 0.04549810f, 
    -0.00365882f, 0.03666534f, -0.06089325f, 0.00866788f, -0.08490505f, -0.09320718f, -0.14978696f, -0.04276322f, 
    0.01128596f, -0.06738459f, -0.01043435f, -0.08159599f, -0.10705578f, -0.00571288f, -0.07727139f, -0.05962117f, 
    0.00992512f, -0.03716810f, -0.05004638f, 0.00467818f, -0.05343703f, -0.02325381f, 0.00023517f, -0.05334701f, 
    0.02308850f, -0.02801392f, -0.08747728f, -0.07297117f, 0.03232890f, -0.05958594f, -0.11440954f, -0.04673577f, 
    -0.07427908f, -0.08259856f, -0.03358615f, 0.03268230f, -0.02679761f, 0.02815025f, -0.02387884f, -0.03771384f, 
    0.00310768f, -0.12346248f, -0.09935881f, -0.06798662f, 0.01914346f, -0.06253488f, 0.04741644f, -0.00885966f, 
    -0.01084774f, 0.00992322f, 0.01337325f, 0.06256147f, 0.01249150f, -0.04485909f, -0.09355887f, 0.01885747f, 
    0.00085449f, -0.01367540f, 0.01920925f, -0.02538207f, -0.02580709f, -0.01720054f, -0.01224046f, -0.03091232f, 
    0.04396042f, -0.05487694f, -0.00754398f, -0.00640625f, -0.01885033f, -0.06633592f, -0.00968040f, -0.06913592f, 
    0.05831227f, 0.01806232f, 0.04227616f, 0.00940141f, 0.03705503f, -0.10715387f, 0.00769929f, -0.04673241f, 
    0.00565030f, -0.04162280f, -0.06163660f, -0.08384384f, 0.06983699f, 0.01465155f, 0.08006324f, 0.07854216f, 
    0.01427404f, -0.04388031f, 0.04877944f, -0.01514964f, -0.07371440f, -0.02942182f, -0.11312357f, -0.06191820f, 
    -0.05068406f, 0.02636185f, -0.05453687f, -0.12209157f, -0.03093393f, -0.01948952f, 0.00905581f, 0.01909288f, 
    -0.03491887f, -0.04478341f, -0.04122008f, -0.00841817f, -0.06456732f, -0.02895284f, 0.03920455f, -0.04019184f, 
    -0.08377403f, -0.02418485f, -0.05897439f, -0.03621863f, -0.10206913f, -0.05070937f, -0.12844171f, -0.01908782f, 
    -0.01878161f, 0.04202454f, 0.01950651f, 0.06261954f, -0.03767217f, -0.02146983f, -0.07684765f, -0.07768005f, 
    -0.05718155f, 0.02307756f, -0.04689697f, -0.00193541f, -0.13424860f, -0.05218016f, -0.07996866f, -0.04420258f, 
    0.05498551f, -0.04170209f, -0.03623451f, 0.01599208f, 0.02701144f, -0.09562667f, -0.04641509f, -0.04114811f, 
    -0.06928760f, -0.09034075f, -0.05452804f, 0.01934172f, -0.02328041f, -0.11663853f, -0.07557564f, 0.02564680f, 
    -0.02860789f, 0.00449822f, 0.01134564f, -0.00501934f, 0.00355508f, -0.02497195f, -0.02330334f, -0.06496317f, 
    -0.07864946f, -0.02357327f, -0.04699348f, -0.12599267f, -0.00578144f, 0.00897180f, -0.00795345f, 0.02439654f, 
    0.01836704f, 0.05702333f, 0.05916952f, 0.07539351f, -0.01991820f, 0.02270073f, 0.06823014f, 0.03678077f, 
    -0.03697033f, -0.07067974f, 0.01050169f, -0.01129857f, 0.05310655f, -0.01157097f, -0.04306132f, 0.06176650f, 
    -0.06751863f, 0.04809169f, 0.03509771f, -0.05263365f, 0.01239935f, 0.01755656f, -0.03006875f, -0.07860926f, 
    0.06159987f, 0.06289391f, -0.00033953f, 0.04138976f, -0.02643673f, 0.01580596f, 0.05969505f, -0.06003135f, 
    -0.06501687f, -0.05184489f, -0.00370853f, 0.04417482f, -0.00621015f, -0.07734662f, 0.02515573f, 0.04955607f, 
    -0.03343820f, 0.03140844f, -0.00847523f, -0.04034616f, 0.00862643f, -0.06097076f, 0.04078246f, -0.05938415f, 
    0.06110417f, -0.04439578f, 0.00978809f, -0.01048058f, -0.06934020f, 0.02318720f, -0.04644704f, -0.00186736f, 
    0.00017374f, 0.02791329f, -0.05657414f, 0.03761605f, -0.00974670f, 0.03419455f, -0.04574471f, 0.00633519f, 
    0.03145438f, -0.00647637f, 0.02840121f, -0.04485188f, -0.07252240f, -0.07311544f, -0.04117575f, 0.04934765f, 
    -0.06582627f, -0.03215049f, 0.02361093f, -0.06951832f, 0.06474631f, -0.05777313f, -0.08158289f, -0.03869353f, 
    -0.01210122f, -0.01760202f, -0.04015862f, 0.05609785f, -0.02892113f, -0.00911205f, -0.04873908f, -0.01176238f, 
    0.00712979f, 0.05640267f, 0.03887879f, 0.04356548f, -0.02224648f, -0.03008187f, -0.04073805f, -0.06796074f, 
    -0.01033686f, 0.00731086f, 0.01195181f, 0.00730416f, 0.00774546f, 0.02193561f, -0.02357115f, 0.00619293f, 
    -0.04527316f, 0.04500939f, -0.01757739f, -0.03737402f, -0.04477413f, 0.01131804f, -0.03063648f, 0.00800189f, 
    -0.06628757f, -0.00115771f, 0.00408056f, 0.04577532f, -0.08128954f, 0.01119801f, -0.03130568f, 0.06098033f, 
    -0.06151166f, -0.07434164f, 0.02204011f, -0.00837678f, 0.01983748f, -0.04177043f, 0.02794186f, -0.05937247f, 
    0.01035356f, 0.02628156f, -0.07297901f, -0.03031157f, -0.05106770f, -0.02447205f, -0.06953114f, 0.01415610f, 
    -0.00351405f, -0.02442358f, -0.07294339f, 0.04552097f, -0.00588671f, 0.03650784f, 0.04331476f, 0.01925499f, 
    0.02539819f, -0.07387183f, -0.02622447f, 0.01407248f, -0.05347110f, -0.02074369f, -0.02146685f, -0.00368931f, 
    0.04929980f, 0.03874250f, 0.02940299f, -0.07175596f, 0.01364894f, -0.04145448f, -0.05306377f, 0.00525846f, 
    -0.00122121f, -0.03513166f, 0.03492079f, -0.06364062f, 0.02109600f, -0.07492747f, -0.05532334f, 0.00554111f, 
    -0.04038491f, 0.00094465f, -0.04765989f, -0.06335507f, 0.04230034f, -0.03746206f, -0.01754969f, -0.07344981f, 
    -0.03743411f, -0.04232570f, -0.03037249f, -0.00506736f, -0.07218933f, 0.04070308f, -0.04461346f, -0.03693357f, 
    -0.00869366f, 0.00699734f, 0.00231591f, 0.05815420f, 0.03250819f, -0.08349612f, -0.04631672f, -0.05229857f, 
    -0.00377013f, -0.02841237f, -0.00668129f, -0.06113875f, 0.05233804f, 0.00465825f, -0.05839348f, 0.02760815f, 
    0.19856179f, -0.05418887f, -0.02247673f, 0.05816246f, -0.02019521f, 0.03160328f, 0.07734772f, -0.01473165f, 
    0.26810408f, 0.14392892f, 0.16217604f, 0.14554065f, 0.08678818f, 0.18337800f, 0.00230805f, 0.01653571f, 
    0.06197847f, 0.08112347f, 0.13651267f, 0.01470431f, 0.14094982f, 0.04982494f, 0.03436199f, -0.08374843f, 
    -0.19506253f, 0.14037961f, 0.12197217f, 0.05657999f, 0.00442208f, -0.00703240f, -0.05326736f, 0.08825291f, 
    0.07836533f, -0.01652839f, 0.17333934f, 0.09847543f, -0.14971636f, -0.09141631f, -0.09218463f, 0.02945585f, 
    0.01881552f, -0.03670563f, 0.02309464f, -0.08796699f, -0.08079421f, 0.14840896f, 0.12696071f, 0.12727755f, 
    0.29814190f, 0.19487080f, 0.12346216f, 0.00323828f, -0.06611162f, -0.01940574f, 0.19042856f, -0.00921041f, 
    0.02769500f, 0.06788151f, -0.17796716f, -0.23813245f, 0.00883843f, -0.05092584f, 0.40534884f, 0.26780352f, 
    0.04023589f, 0.08607336f, 0.05543622f, -0.20059298f, 0.12099371f, 0.09909528f, 0.09141747f, 0.10953730f, 
    0.18218847f, -0.13389473f, 0.12676235f, 0.03110653f, 0.02845543f, -0.04294847f, -0.06432175f, 0.00923499f, 
    0.14155748f, 0.03543419f, -0.03166002f, -0.06767162f, -0.22402470f, 0.21616758f, -0.02034399f, 0.20968817f, 
    0.17079225f, 0.01268191f, 0.02086840f, -0.12360130f, -0.08357359f, -0.14138512f, -0.16897996f, 0.25933611f, 
    -0.08349872f, -0.21924603f, -0.12319178f, 0.01672962f, -0.12852828f, -0.07510278f, -0.14490660f, -0.11243635f, 
    0.06090805f, -0.04014653f, 0.12097657f, -0.12007867f, 0.10346537f, -0.04717389f, 0.03093723f, -0.07292613f, 
    0.05101554f, 0.09378553f, 0.03479157f, 0.13061143f, 0.09259406f, -0.11645568f, -0.13015652f, -0.22196178f, 
    0.10231610f, 0.03514247f, 0.40609556f, 0.05179429f, -0.02177459f, 0.12507477f, -0.07369109f, 0.00000140f, 
    0.02022164f, 0.06285658f, -0.03026696f, 0.05327262f, -0.08286326f, 0.05202226f, 0.13379745f, -0.07665400f, 
    -0.05090231f, -0.11081860f, -0.07707050f, 0.21578704f, -0.00584050f, 0.08099733f, 0.17170307f, -0.09887763f, 
    -0.08908998f, -0.32245165f, 0.14289483f, 0.14130512f, -0.01955273f, -0.14562869f, -0.03719263f, -0.12005810f, 
    0.08248109f, -0.08789659f, -0.15125538f, 0.07209440f, 0.15068159f, 0.19387424f, 0.04256162f, 0.14854012f, 
    -0.00292450f, 0.09836589f, -0.05345875f, 0.05296392f, 0.06455442f, -0.05502181f, 0.03639684f, -0.10488591f, 
    0.18912090f, -0.10999627f, 0.05029531f, -0.20767194f, -0.07183349f, -0.03890361f, -0.07108892f, -0.00781779f, 
    0.03120059f, -0.04737787f, 0.03189916f, -0.02162589f, -0.27139074f, -0.39522612f, 0.22071648f, 0.24471912f, 
    0.15093042f, -0.01353351f, 0.05104538f, -0.17615572f, -0.16064303f, -0.05892222f, 0.01110810f, 0.02491729f, 
    -0.15546939f, 0.28193066f, 0.02879944f, -0.09955566f, 0.12843552f, -0.02612283f, -0.09311014f, 0.16715419f, 
    -0.06862437f, -0.03316363f, -0.23147427f, -0.20938246f, -0.15717345f, 0.04646958f, -0.14583977f, 0.06657812f, 
    0.01502221f, -0.03602059f, 0.05192390f, -0.01330488f, -0.10763654f, 0.13066059f, 0.06120411f, 0.07378421f, 
    -0.60025400f, -0.40294904f, -0.11669186f, -0.12093640f, 0.01913048f, 0.11132465f, 0.10712214f, -0.00184531f, 
    0.09172075f, -0.02343904f, 0.06115079f, -0.12114756f, 0.08711504f, -0.00711137f, -0.13443445f, -0.01511544f, 
    -0.02502731f, -0.02263401f, 0.03330844f, -0.01125052f, -0.13737781f, -0.13940740f, 0.04245946f, -0.00634465f, 
    0.06296348f, 0.12801294f, 0.00728395f, 0.23660342f, 0.13438000f, -0.10675096f, -0.11587835f, -0.05599835f, 
    -0.09831939f, 0.02478932f, -0.05593915f, -0.03924865f, 0.06212642f, -0.20443764f, 0.04701222f, 0.12449434f, 
    0.09306704f, 0.28753886f, 0.03293991f, -0.14704923f, -0.06722620f, -0.08521139f, 0.07907379f, 0.00186848f, 
    0.46718255f, -0.14464825f, 0.16067748f, 0.15166888f, 0.21635444f, 0.16466367f, 0.11965597f, -0.02735591f, 
    0.05019597f, -0.05012266f, 0.04626092f, 0.13411061f, -0.43887740f, -0.31625989f, -0.10122468f, 0.06036106f, 
    0.01467453f, 0.05781072f, -0.01497132f, 0.12818338f, 0.27816811f, 0.15618159f, 0.01649548f, 0.09000106f, 
    0.08381301f, -0.10221492f, 0.03801733f, 0.00183218f, 0.10894746f, -0.01051917f, -0.04284027f, -0.11032587f, 
    0.20556757f, 0.04899752f, -0.00279515f, 0.02381179f, -0.11828874f, -0.24379759f, -0.01599959f, -0.08924686f, 
    0.13512552f, 0.05043590f, 0.07346754f, -0.10533655f, 0.09931117f, 0.11832512f, -0.04443238f, 0.19759549f, 
    -0.12125225f, 0.01973022f, 0.30126575f, -0.10163662f, 0.16681693f, 0.00143338f, -0.03489961f, 0.00827765f, 
    -0.05562339f, -0.07559960f, 0.07865829f, -0.03906037f, 0.04383855f, -0.06956201f, 0.11837815f, -0.19083136f, 
    0.08450518f, -0.02069795f, 0.03327017f, -0.01147701f, 0.06650888f, 0.00012451f, -0.08766032f, -0.11417289f, 
    0.28771314f, -0.00563754f, 0.03913721f, -0.05529248f, 0.13320972f, 0.12696210f, -0.02292818f, -0.08797232f, 
    -0.04395182f, -0.10568843f, 0.03087056f, 0.01865014f, -0.10026385f, 0.22402626f, 0.01158363f, -0.02146469f, 
    0.00138446f, 0.07686270f, -0.08839243f, -0.04929573f, 0.02485317f, 0.10042896f, 0.08341774f, 0.21413852f, 
    0.46161765f, -0.03844337f, 0.26277581f, 0.03981852f, 0.16137759f, -0.15948172f, 0.00714294f, 0.06910086f, 
    0.06304014f, 0.00593343f, 0.26512030f, 0.03758895f, -0.20498081f, 0.20657600f, 0.36816004f, -0.25928080f, 
    -0.08732123f, -0.12017126f, 0.12594439f, -0.01327950f, 0.03638868f, 0.03742699f, 0.10736167f, 0.09529682f, 
    -0.02435370f, 0.16572627f, 0.23459192f, -0.11815817f, -0.14040130f, -0.04280693f, -0.08423206f, 0.13652854f, 
    -0.16067554f, 0.05872607f, -0.17421789f, -0.09101088f, 0.10761429f, 0.04084529f, 0.06604307f, 0.15781491f, 
    -0.06325532f, -0.05338709f, -0.00043104f, -0.14642560f, 0.01747144f, -0.03144769f, 0.07257729f, -0.02977375f, 
    -0.17900121f, -0.32585433f, -0.30708873f, -0.17987338f, 0.03102521f, 0.10507091f, -0.03542154f, -0.08378854f, 
    0.04188051f, -0.04284493f, 0.07450717f, -0.03374479f, 0.07363115f, -0.05569150f, -0.11608147f, 0.03351456f, 
    0.05431227f, -0.05294558f, -0.00352794f, -0.08769781f, -0.00585355f, -0.12645088f, -0.00118086f, -0.12616159f, 
    -0.03028101f, 0.18885538f, 0.26792866f, 0.21865900f, 0.02572398f, -0.07605900f, -0.08586540f, 0.02009525f, 
    -0.02798021f, 0.08069663f, -0.11551555f, 0.07456848f, -0.05705758f, -0.10107701f, 0.13914847f, 0.08531529f, 
    0.10300951f, 0.23639530f, -0.02260207f, 0.01871833f, -0.05926732f, 0.07576163f, 0.05969974f, -0.05589695f, 
    0.16064426f, 0.09209165f, 0.12306834f, 0.08505514f, 0.06062521f, 0.05822925f, -0.02840048f, 0.03890292f, 
    -0.05982120f, 0.07965418f, -0.07802740f, 0.08622427f, -0.05981028f, -0.23494279f, 0.04120745f, 0.02785149f, 
    0.00765338f, 0.01573882f, 0.05310879f, 0.16931772f, 0.07431716f, -0.08374556f, -0.19457710f, 0.05762984f, 
    -0.06711762f, 0.13997141f, 0.04869803f, -0.06593870f, 0.08725339f, 0.20773870f, 0.15991186f, 0.00163805f, 
    0.07088421f, -0.04234373f, -0.11269105f, 0.18095882f, 0.02945998f, -0.18386492f, 0.00072128f, -0.00849495f, 
    0.03347332f, -0.11153921f, 0.13392426f, -0.16994610f, 0.00608075f, 0.09821907f, 0.13534886f, 0.09312468f, 
    -0.08548896f, -0.03130630f, 0.23125342f, -0.09304588f, 0.02746760f, -0.14705122f, -0.14163202f, 0.09269514f, 
    0.01981159f, 0.03111617f, 0.03952839f, 0.09799273f, 0.06722154f, -0.11312883f, -0.07937618f, -0.02300833f, 
    0.09841046f, 0.08575141f, 0.08939855f, -0.04543312f, 0.07358459f, -0.03744433f, -0.00984642f, -0.10001139f, 
    0.41495499f, 0.04378543f, 0.03133459f, 0.01014302f, 0.02200998f, 0.16180106f, 0.13767852f, 0.04256636f, 
    -0.03894596f, -0.24946442f, -0.02625047f, 0.00902651f, -0.06450618f, 0.12507159f, 0.07145545f, 0.01372823f, 
    0.07913137f, 0.11817224f, -0.01193979f, -0.00717440f, 0.05436350f, 0.23434548f, 0.03836344f, 0.13345218f, 
    0.16030194f, -0.01256905f, 0.34954059f, -0.20869151f, 0.07664185f, -0.17074069f, -0.11320505f, -0.04302504f, 
    0.12506850f, -0.10798130f, 0.04690177f, -0.01314853f, 0.18759651f, 0.58938497f, -0.01288154f, -0.32114559f, 
    -0.04670726f, -0.10956776f, -0.06457403f, 0.21604794f, -0.04636461f, -0.11215512f, -0.13579021f, -0.01895677f, 
    0.03204668f, -0.06897239f, 0.00712634f, -0.03785443f, -0.03015087f, -0.05410417f, -0.05266497f, -0.02871705f, 
    -0.00563564f, -0.01618790f, -0.00533051f, 0.04973032f, -0.01779739f, 0.05496038f, -0.07705293f, 0.03117793f, 
    0.01648362f, 0.03564074f, -0.03111191f, 0.00278052f, -0.01969016f, 0.02557615f, -0.00522856f, -0.01767779f, 
    -0.00872655f, -0.02033924f, 0.04586151f, -0.03004789f, 0.00258594f, 0.01651071f, 0.06072085f, 0.04509588f, 
    -0.06822366f, 0.05691735f, 0.03044042f, 0.06121718f, -0.07272957f, -0.03465401f, -0.06211186f, 0.03666473f, 
    -0.04492929f, -0.06793740f, -0.07912934f, 0.05672113f, 0.06111814f, -0.01730340f, -0.00773120f, 0.00593112f, 
    -0.06996608f, -0.03604418f, -0.05615679f, 0.04311710f, -0.02637130f, 0.03071180f, 0.01454306f, -0.01099351f, 
    -0.01150628f, -0.01263034f, -0.07125306f, 0.00923849f, 0.06183851f, 0.04448003f, 0.04337045f, -0.06501468f, 
    -0.04325845f, -0.05490699f, -0.05963704f, -0.00857606f, -0.04970225f, -0.05149624f, -0.07601666f, 0.01253367f, 
    0.00523464f, 0.00139287f, 0.04582702f, -0.01597326f, -0.03645068f, 0.01201564f, -0.03672920f, -0.00415062f, 
    -0.05811479f, -0.00632899f, -0.00348043f, -0.01228108f, -0.00416340f, 0.01127574f, -0.02849104f, -0.02350512f, 
    0.03071607f, -0.04449489f, -0.03917953f, 0.02509887f, 0.00341770f, -0.05100501f, -0.02213896f, 0.05018046f, 
    -0.00418810f, -0.04912873f, 0.00501644f, -0.05503760f, 0.02261197f, -0.04255087f, -0.05586363f, 0.01568125f, 
    -0.01419777f, 0.05638046f, -0.00294355f, -0.01151225f, -0.03104767f, -0.01149987f, 0.04012665f, -0.03071774f, 
    -0.02162479f, -0.06806720f, -0.01798389f, -0.01828782f, 0.05982318f, 0.04179503f, 0.03351803f, 0.05165884f, 
    -0.02360718f, 0.04414515f, 0.02228651f, -0.05339181f, 0.01684882f, -0.01372924f, 0.00540594f, -0.02725569f, 
    -0.01003810f, -0.07012206f, -0.02485686f, -0.00772252f, -0.00596614f, -0.06931959f, -0.02564986f, -0.01683151f, 
    -0.03414059f, 0.05990434f, 0.01802471f, -0.07497671f, -0.03872949f, -0.06470335f, -0.07151625f, 0.04615469f, 
    0.02449623f, 0.05761129f, -0.07297591f, -0.04779719f, 0.01523796f, 0.05562147f, 0.00640056f, -0.02317362f, 
    0.02207655f, -0.04044864f, -0.00350945f, 0.01732667f, -0.05599189f, -0.03980581f, -0.01573391f, -0.05399745f, 
    -0.02967738f, -0.07519174f, -0.02631576f, 0.01847542f, 0.00502303f, -0.07107470f, -0.02307228f, -0.03240047f, 
    -0.06558493f, 0.02124806f, 0.01946688f, 0.04030450f, 0.04882194f, 0.03916929f, 0.01384372f, -0.04969566f, 
    0.01581510f, -0.03866434f, 0.03659875f, -0.06321016f, 0.03838531f, -0.01372739f, -0.01073094f, 0.01009236f, 
    -0.05407498f, 0.04121789f, 0.03705416f, -0.01112450f, -0.00094375f, 0.04264192f, 0.05766051f, -0.04940410f, 
    -0.23235123f, -0.10017540f, 0.17707889f, -0.16128488f, -0.12261855f, -0.05919501f, 0.19435208f, 0.16809873f, 
    -0.05095901f, 0.08208668f, -0.05291145f, -0.16079010f, 0.14707625f, -0.08562952f, 0.02908248f, -0.00145669f, 
    -0.07720648f, -0.09229000f, -0.11640260f, -0.17639917f, -0.01365844f, -0.05723447f, -0.00772387f, 0.10584696f, 
    0.01749356f, -0.16210169f, 0.13901396f, -0.10451684f, -0.01850097f, 0.00757223f, -0.01931694f, -0.16792992f, 
    0.07515285f, 0.12407973f, 0.06530964f, -0.08581799f, 0.03059522f, -0.16558501f, 0.13856868f, -0.03420844f, 
    -0.06495982f, 0.04325959f, -0.17948276f, 0.00405828f, -0.02273122f, -0.05651044f, -0.10370246f, -0.04667577f, 
    0.11446401f, 0.05154842f, -0.14534864f, -0.08355990f, -0.03306535f, -0.14799795f, -0.09349789f, -0.05441635f, 
    0.09944654f, -0.00917958f, -0.00717495f, -0.00070899f, 0.22973721f, 0.18525168f, -0.07682985f, -0.07321683f, 
    0.05893379f, 0.13968885f, 0.11571498f, -0.02652908f, 0.00298356f, 0.16128866f, 0.02313474f, 0.00733230f, 
    -0.05819069f, 0.39333165f, -0.15233439f, 0.31294653f, 0.03837067f, 0.07677722f, 0.12162525f, 0.02148338f, 
    0.12645267f, 0.10334339f, 0.08775313f, 0.09816693f, 0.17239086f, -0.14352699f, 0.10700217f, -0.01384489f, 
    -0.12847652f, -0.09205934f, -0.08538967f, 0.19439997f, 0.41732663f, 0.17751774f, 0.11355380f, 0.00096342f, 
    -0.24493337f, 0.13830170f, -0.01922452f, 0.10049400f, 0.16354103f, 0.17122282f, -0.01416303f, 0.24624850f, 
    0.02504943f, 0.10247502f, -0.10225099f, -0.12768187f, -0.04241385f, -0.16736996f, -0.05442835f, -0.01072966f, 
    0.08300047f, -0.07191301f, -0.01660406f, 0.04300168f, 0.02766283f, 0.16744664f, 0.08889808f, 0.18026522f, 
    0.11988557f, -0.08243501f, -0.12354306f, -0.06867450f, -0.13609165f, -0.01121830f, -0.06176352f, 0.12560044f, 
    -0.07904338f, -0.07492524f, -0.02510733f, 0.08142827f, -0.19513726f, -0.17568214f, -0.19637707f, -0.08928046f, 
    0.16487263f, 0.11018990f, 0.14405979f, 0.02248870f, 0.11379191f, 0.09754978f, 0.04301610f, -0.01156005f, 
    -0.21874128f, -0.07645150f, -0.11240867f, -0.14499854f, 0.02362186f, 0.09531565f, 0.18710543f, -0.03614424f, 
    -0.05829659f, -0.06907246f, -0.08031151f, -0.00945548f, 0.13649254f, -0.11182544f, 0.03394383f, -0.00841612f, 
    0.05601079f, -0.11810521f, -0.11982746f, -0.11961216f, 0.16587441f, 0.18403649f, -0.02010152f, -0.00167672f, 
    0.14282851f, 0.22006664f, -0.16472247f, -0.07989103f, -0.13651647f, 0.01965802f, -0.12899673f, -0.02285257f, 
    0.00861676f, -0.00434795f, -0.01628732f, -0.22579923f, -0.13177581f, 0.16671088f, 0.24238823f, -0.06722255f, 
    0.12045975f, -0.04939111f, -0.13949092f, 0.15250134f, 0.14651994f, 0.08521792f, -0.01604478f, 0.03623207f, 
    0.17841525f, -0.09980053f, 0.01295664f, 0.02107118f, 0.07744095f, -0.01126858f, 0.16866866f, -0.03291373f, 
    0.08772819f, 0.06809752f, -0.01130630f, 0.16316585f, 0.13689369f, 0.21598911f, 0.08610993f, -0.04489800f, 
    0.06185848f, -0.06938842f, 0.05191311f, -0.09509402f, -0.12626395f, 0.02530419f, -0.00246980f, -0.05953726f, 
    0.15082057f, -0.26545250f, 0.10313878f, -0.17506994f, -0.02587516f, -0.16776012f, -0.04631915f, 0.11851264f, 
    0.00998395f, 0.02505034f, 0.02567643f, 0.17223258f, 0.17009602f, -0.29314259f, 0.00681441f, -0.01402432f, 
    0.10749765f, 0.04589631f, 0.18941432f, 0.11727350f, -0.00376842f, -0.00710683f, 0.09193910f, 0.15403211f, 
    0.13821417f, 0.34791964f, 0.22091684f, 0.03221959f, 0.04205316f, -0.07870719f, -0.05136595f, -0.10831761f, 
    0.03767352f, 0.00534148f, -0.02330977f, -0.08327385f, -0.19053492f, -0.00438904f, 0.07883124f, 0.07714807f, 
    -0.01173435f, 0.08763473f, 0.02328798f, -0.17122123f, 0.12845758f, 0.01608579f, -0.04538563f, 0.03917114f, 
    0.25232878f, -0.21223472f, -0.04907453f, -0.05632519f, 0.09282412f, 0.13551050f, -0.02442788f, 0.15465684f, 
    -0.09891723f, 0.12959591f, -0.03117295f, -0.04229392f, -0.01659673f, 0.24331015f, 0.23158662f, 0.12245648f, 
    -0.01210130f, 0.04723182f, -0.05500017f, 0.09639458f, 0.01766245f, 0.05786330f, 0.04600862f, 0.15328161f, 
    0.06462570f, -0.19709793f, -0.00085591f, 0.18672417f, -0.01543609f, 0.06694707f, -0.07040477f, 0.01968805f, 
    -0.03479522f, 0.15153381f, 0.14010423f, 0.05884767f, 0.16298525f, -0.08572272f, -0.02727856f, -0.06052535f, 
    -0.07010052f, 0.07784933f, -0.03145132f, 0.02354278f, -0.04164943f, -0.00912342f, -0.03620350f, -0.08512163f, 
    -0.35132480f, 0.16060723f, 0.17882232f, 0.14287174f, -0.02307335f, 0.07701004f, -0.05630007f, 0.06390078f, 
    0.00644178f, 0.07822789f, 0.06394336f, -0.05801951f, -0.14580737f, -0.03534506f, -0.03323210f, 0.12070359f, 
    0.09140349f, -0.11949960f, 0.13439161f, -0.02374708f, 0.14832909f, 0.24180539f, 0.12546667f, 0.04991338f, 
    -0.27151239f, -0.30265471f, -0.14880335f, -0.00426081f, 0.11557225f, -0.04197853f, 0.00075777f, 0.00918364f, 
    0.08186743f, 0.10161928f, 0.03866162f, 0.16881430f, 0.17683746f, 0.00812585f, 0.13016941f, -0.10508061f, 
    0.06412499f, 0.07369010f, -0.12042698f, 0.00166170f, -0.02494090f, -0.05859803f, 0.02758004f, -0.10873779f, 
    0.53466660f, 0.18435682f, -0.13280009f, -0.06912667f, -0.12398838f, 0.04682413f, -0.08120893f, -0.08518822f, 
    -0.20250966f, 0.14059363f, 0.14233486f, -0.02905022f, -0.16589768f, -0.14849524f, 0.30930880f, 0.07750165f, 
    0.14752336f, -0.03697578f, -0.01384124f, 0.00371139f, -0.15109198f, -0.04246555f, 0.09577058f, 0.16460004f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12978251f, 0.02428982f, -0.00186001f, 0.17460440f, 0.21266708f, -0.13430129f, 0.15778627f, 0.13584666f, 
    0.05223019f, -0.09450209f, 0.04775802f, 0.04389937f, 0.01016076f, 0.22552414f, 0.06604566f, 0.08023870f, 
    -0.02799368f, 0.02305850f, -0.07217915f, 0.21082596f, 0.07538629f, -0.07519709f, 0.05103226f, 0.19450343f, 
    0.06746342f, 0.24857071f, 0.04698821f, -0.09872858f, 0.09995344f, -0.03747922f, -0.04612824f, -0.06611934f, 
    0.01969941f, -0.01204821f, -0.03251598f, 0.19509663f, 0.06610592f, -0.15284634f, 0.09935867f, -0.04754903f, 
    0.25954172f, -0.14731935f, 0.14418648f, 0.05115264f, 0.03908670f, -0.09038554f, 0.00927346f, -0.04152600f, 
    0.19344276f, 0.13740954f, 0.01316262f, -0.01480736f, 0.03196179f, 0.22918227f, -0.04373966f, -0.03631223f, 
    -0.00702235f, -0.00078487f, -0.05399000f, 0.04073144f, 0.04127800f, -0.07324155f, 0.32251623f, -0.13084522f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10690407f, -0.30913669f, 0.05969765f, 0.03768578f, -0.08999839f, -0.06192482f, -0.00813729f, -0.01363202f, 
    0.11480862f, 0.02979748f, -0.08601566f, -0.08690704f, 0.12867999f, -0.08223528f, -0.12863180f, 0.10783425f, 
    -0.03197515f, -0.12338693f, -0.11327049f, -0.23867647f, -0.06641082f, -0.16070704f, 0.10466007f, -0.09022092f, 
    -0.06773256f, -0.21130671f, -0.04541806f, -0.18351607f, -0.04452779f, -0.01525353f, 0.01619971f, 0.02125010f, 
    -0.22154583f, -0.12300981f, -0.02382474f, 0.13973019f, -0.15707754f, 0.15869080f, 0.08386413f, -0.08785272f, 
    0.08509292f, 0.08019998f, -0.29246941f, 0.01125401f, -0.06228091f, 0.07786646f, 0.18735364f, 0.00773267f, 
    0.19991557f, -0.30536762f, -0.10148120f, 0.08337346f, 0.20162416f, -0.13635699f, 0.02142327f, -0.04910794f, 
    0.07556091f, 0.02660942f, -0.06599139f, 0.19476520f, -0.32616076f, 0.01203062f, -0.05942760f, 0.13894001f, 
    0.03005431f, -0.13262646f, -0.14806436f, 0.04351471f, 0.16726413f, 0.00524628f, 0.08602198f, -0.09706490f, 
    0.01793796f, 0.09239248f, -0.15672576f, -0.05574229f, -0.05158146f, -0.08265404f, -0.07247302f, 0.15445949f, 
    -0.03796899f, -0.05877440f, -0.04293784f, 0.08162761f, -0.03071600f, 0.04656969f, -0.09418860f, 0.06395736f, 
    -0.06407381f, -0.08564401f, -0.00478488f, 0.01168280f, 0.02577175f, -0.07651599f, 0.15431446f, 0.01853007f, 
    -0.07059308f, -0.03289641f, -0.03320600f, -0.11121555f, -0.04538895f, -0.06736177f, -0.04515336f, -0.11391270f, 
    -0.02051446f, 0.09573648f, -0.02797334f, 0.10035887f, -0.13706791f, -0.15452802f, -0.05623145f, 0.01238005f, 
    0.10119485f, -0.00681166f, -0.11789187f, 0.04999630f, -0.11996686f, -0.11336268f, -0.05284055f, -0.17896552f, 
    -0.07517935f, -0.07100995f, -0.08773498f, -0.12773398f, -0.10826059f, -0.05259240f, 0.06644962f, -0.10387866f, 
    -0.01678516f, -0.01777068f, -0.15019017f, -0.02197336f, 0.09598788f, 0.10332195f, 0.06664951f, -0.04737436f, 
    0.00785936f, 0.07319491f, 0.02326793f, -0.06685074f, -0.09942069f, -0.09740993f, 0.06765241f, -0.05778495f, 
    -0.08024857f, -0.09339412f, 0.12156168f, 0.07133870f, -0.07012445f, 0.01756459f, 0.10948172f, -0.00963678f, 
    -0.07793789f, -0.04874302f, -0.09633537f, -0.07830709f, -0.12533285f, 0.04185127f, -0.08022898f, 0.04049239f, 
    0.04919932f, 0.00465624f, 0.04930933f, 0.09023041f, -0.09310917f, -0.09015571f, -0.09831712f, -0.09325143f, 
    -0.02156754f, 0.04936542f, 0.08726513f, -0.05114703f, 0.03632297f, 0.03305089f, -0.07035688f, -0.01592317f, 
    -0.04821659f, -0.08555804f, 0.07887257f, -0.01786993f, 0.03798910f, -0.11484208f, 0.08734062f, -0.08440182f, 
    0.07116178f, 0.01229920f, -0.10990357f, 0.00222832f, -0.03785864f, 0.04263256f, 0.08643216f, -0.10761143f, 
    -0.04443782f, 0.04806332f, -0.21317530f, 0.20123006f, -0.00107046f, -0.02842680f, -0.15759856f, 0.16688570f, 
    -0.06387776f, -0.18945283f, -0.10561066f, 0.34165373f, -0.42246726f, 0.26392627f, -0.24164282f, -0.05188902f, 
    -0.00984436f, -0.14436805f, 0.02992953f, 0.02361196f, -0.09409779f, 0.32842073f, 0.10515470f, -0.17739764f, 
    0.04668732f, -0.17981282f, 0.09325043f, 0.16412695f, 0.18796434f, 0.00642064f, -0.12956198f, -0.01206391f, 
    -0.30560550f, -0.10621302f, -0.07332474f, 0.25868323f, -0.05645024f, 0.26032397f, 0.14404663f, 0.01810064f, 
    0.21644892f, -0.17858343f, -0.24205293f, 0.18141013f, 0.02746092f, -0.18839072f, 0.17549177f, -0.16775666f, 
    0.22593158f, 0.10481933f, 0.23550375f, -0.02268127f, 0.08747169f, 0.00522447f, 0.04545125f, 0.09932860f, 
    0.07063512f, 0.04793521f, -0.14794172f, 0.05810628f, -0.13661481f, -0.04141102f, 0.16561852f, 0.08363400f, 
    0.12508479f, 0.07441523f, 0.17220153f, -0.33271658f, 0.02485075f, 0.00760387f, 0.23058484f, 0.11914900f, 
    -0.09153427f, 0.18248665f, -0.09163074f, 0.10827868f, -0.26090869f, 0.12549512f, 0.07888100f, -0.15510833f, 
    0.08341213f, -0.19764693f, -0.04924747f, -0.11643708f, -0.34269488f, 0.36311844f, 0.07609230f, -0.04315260f, 
    -0.05096489f, -0.27274856f, 0.32664609f, 0.32273683f, 0.12795407f, -0.10033754f, -0.07424619f, -0.01884820f, 
    -0.06982849f, 0.21123499f, 0.04607881f, -0.20802766f, 0.24384440f, 0.43448472f, -0.33173218f, 0.36815050f, 
    -0.15340613f, -0.03313795f, -0.33530578f, 0.06522565f, 0.23151815f, -0.20340359f, 0.06740565f, 0.14354098f, 
    0.09555298f, 0.12832284f, 0.06665196f, -0.00754874f, -0.10904295f, 0.05099639f, 0.09424202f, 0.11603864f, 
    0.01769024f, -0.02273927f, 0.10861398f, 0.19857484f, 0.14577182f, -0.07582195f, -0.02274743f, 0.12533887f, 
    -0.03263407f, -0.01287259f, 0.09148314f, 0.17642939f, 0.21010633f, -0.06964845f, 0.03301915f, 0.18799624f, 
    0.03869861f, 0.09012727f, 0.05289363f, 0.06653854f, 0.11848777f, 0.12884259f, 0.17786627f, -0.16952300f, 
    0.01455596f, -0.02674766f, -0.10922618f, -0.04255168f, -0.24908862f, 0.16079073f, 0.00058467f, 0.33429843f, 
    0.27993932f, 0.10819874f, 0.14303818f, -0.09009352f, 0.10870484f, 0.01062751f, 0.07711387f, 0.02698585f, 
    -0.28043011f, -0.01175807f, -0.08111803f, -0.20801732f, 0.24005872f, -0.46137467f, -0.05970205f, 0.07054808f, 
    0.02384967f, 0.01081642f, 0.07292920f, 0.11830179f, 0.09413832f, -0.20468107f, -0.13100892f, 0.04791169f, 
    0.13171245f, -0.09761617f, -0.28937650f, 0.02995068f, 0.00546198f, 0.24796399f, 0.12470998f, 0.10499311f, 
    -0.00331789f, -0.07421853f, 0.17244618f, 0.01034223f, -0.13938145f, 0.11825605f, 0.01291064f, 0.01862836f, 
    -0.09667087f, 0.14366752f, -0.21450862f, 0.09335909f, 0.15243331f, -0.07441971f, 0.03961855f, -0.09263144f, 
    0.12681781f, 0.00767163f, 0.16501169f, 0.24299400f, -0.17144848f, -0.17415211f, 0.20889354f, 0.27053583f, 
    0.07967262f, 0.03912623f, -0.07349644f, 0.06495828f, -0.15539549f, 0.21803039f, 0.01090591f, -0.23395006f, 
    -0.01214982f, -0.25748971f, -0.18085834f, 0.09050298f, 0.09332403f, -0.08150084f, 0.45813316f, 0.11066175f, 
    0.11488762f, -0.19669838f, -0.08585038f, 0.15832217f, -0.01141148f, -0.05211997f, -0.03615825f, 0.14456423f, 
    -0.04393541f, 0.17135572f, 0.17388676f, -0.10712564f, -0.12600581f, -0.30294228f, 0.23751760f, 0.21755277f, 
    -0.08145776f, 0.20210743f, -0.13472918f, 0.04655343f, 0.23611714f, 0.19601883f, 0.00323453f, -0.11096383f, 
    -0.05158188f, -0.02345888f, 0.00853004f, -0.13743055f, -0.18246628f, -0.01139310f, -0.05962594f, -0.00947225f, 
    -0.35198694f, -0.23189791f, -0.38035214f, 0.33308411f, 0.23932646f, 0.01699079f, -0.06342567f, -0.09055635f, 
    -0.06425966f, -0.05656218f, 0.13757588f, 0.14258029f, 0.44395477f, -0.12824562f, -0.13703187f, 0.20345256f, 
    0.02943546f, 0.11885490f, 0.04791673f, 0.36834347f, -0.07039465f, 0.02969448f, -0.10950167f, 0.01785969f, 
    -0.04021161f, 0.07445682f, 0.07435488f, 0.08984760f, 0.07591639f, 0.07661918f, 0.29503459f, -0.04548807f, 
    0.06226614f, -0.06168031f, 0.09672510f, 0.02410572f, 0.03333194f, 0.06309745f, -0.01681621f, -0.12341157f, 
    0.15221395f, -0.14225022f, 0.02898476f, 0.05619637f, -0.22508666f, 0.25326884f, -0.08858762f, -0.06158570f, 
    0.09097978f, 0.20643300f, 0.09743869f, 0.07200906f, 0.05140648f, -0.37398624f, 0.04087115f, 0.10159879f, 
    0.00186222f, 0.09195333f, 0.26377580f, -0.10690032f, -0.24563453f, -0.10898753f, -0.09117160f, 0.12824892f, 
    -0.10776158f, -0.11792894f, -0.29505891f, 0.29545775f, 0.23497257f, 0.01619856f, -0.32676843f, 0.13699239f, 
    0.00357849f, -0.06698933f, 0.20374353f, 0.03392524f, 0.52216899f, 0.05151255f, -0.02886351f, 0.06127251f, 
    -0.03387342f, 0.29025432f, 0.04880808f, 0.09199618f, -0.15893343f, 0.05169028f, -0.00655724f, 0.02984873f, 
    0.23607799f, 0.06060793f, -0.22444986f, -0.05180760f, 0.14251052f, -0.01400745f, 0.23793893f, -0.02018669f, 
    0.16846961f, 0.16143538f, 0.10925236f, 0.11036346f, 0.14676850f, -0.30563378f, 0.08109917f, -0.06330531f, 
    -0.08958463f, -0.06856161f, 0.27666444f, -0.00446424f, -0.24104148f, 0.28836489f, -0.12798604f, -0.03286222f, 
    0.35645244f, 0.02692454f, -0.07717976f, 0.08092612f, -0.24137087f, 0.09657001f, 0.08463888f, 0.10753045f, 
    -0.01779422f, 0.09393537f, 0.13183795f, -0.15248759f, -0.27819592f, 0.03958030f, -0.09759822f, -0.07327257f, 
    0.31051892f, 0.30562189f, 0.14664131f, -0.13323961f, -0.23586462f, -0.10037202f, -0.04350745f, 0.08396009f, 
    0.12502512f, 0.31890592f, -0.00835015f, 0.10251273f, -0.21023303f, 0.00935232f, 0.03027000f, -0.03503515f, 
    -0.15839930f, 0.27120784f, 0.04452361f, -0.14497581f, -0.14898193f, 0.32388857f, 0.00395351f, -0.15838034f, 
    0.08653831f, -0.12376634f, -0.10216696f, 0.48983467f, -0.02950553f, 0.10470151f, 0.20268357f, 0.10769482f, 
    0.24603924f, 0.14531943f, 0.11765142f, 0.02248445f, -0.05944832f, 0.42270985f, 0.12000879f, 0.04429875f, 
    0.08461371f, 0.24760726f, -0.05758238f, -0.06306377f, 0.10836537f, 0.17937475f, 0.00012084f, 0.07912367f, 
    0.01725776f, 0.06140374f, -0.06994136f, 0.10522571f, -0.08691208f, 0.23596366f, 0.07157592f, 0.18692622f, 
    -0.00344943f, 0.05735797f, 0.07127554f, -0.09844770f, 0.07091659f, 0.00231826f, -0.19935618f, -0.03407252f, 
    -0.04280983f, -0.07511719f, -0.04167235f, -0.05222502f, -0.04989766f, 0.06723950f, 0.00110412f, -0.12663233f, 
    0.02897955f, 0.09711561f, -0.03771346f, -0.09274832f, 0.00712311f, -0.22406928f, 0.01488713f, 0.01579187f, 
    -0.10679138f, -0.01929009f, -0.09935391f, -0.08940072f, 0.10847798f, -0.08117621f, 0.07356785f, -0.24768896f, 
    0.12439725f, -0.05564050f, -0.14853388f, 0.05117486f, 0.06832462f, -0.02423652f, 0.00111926f, 0.01088300f, 
    -0.13845387f, 0.16465113f, -0.10459624f, 0.00562918f, 0.09154543f, 0.01973246f, 0.09083218f, -0.07351224f, 
    -0.13760059f, 0.08202825f, 0.13058510f, -0.11626361f, -0.15057331f, 0.05792018f, 0.13102145f, -0.03475441f, 
    0.03281392f, -0.08941207f, -0.13913564f, -0.15091489f, 0.09583987f, -0.21727569f, -0.04212621f, -0.04684438f, 
    0.04978491f, -0.00435817f, -0.02843838f, -0.06776434f, -0.05073276f, -0.11979185f, 0.05021179f, -0.15210758f, 
    -0.18166466f, 0.08515484f, -0.02225416f, 0.16950575f, 0.22379246f, 0.15240636f, 0.43876547f, 0.21374337f, 
    -0.08908306f, 0.02556546f, 0.04945003f, -0.12600242f, 0.33578849f, -0.13656911f, 0.10112504f, -0.02281945f, 
    -0.03732641f, 0.09464668f, -0.09286766f, 0.11668622f, 0.03732884f, 0.04044196f, 0.08081574f, 0.07640225f, 
    0.20946561f, 0.06738972f, 0.04176301f, -0.18870911f, 0.23397601f, 0.03827901f, 0.08631622f, -0.11945490f, 
    -0.05667827f, 0.05194390f, -0.05203317f, -0.07255901f, -0.08167912f, -0.45614439f, 0.04777456f, -0.29165885f, 
    0.01751137f, -0.11483877f, 0.14581288f, -0.22760291f, -0.19263716f, -0.04414559f, -0.05955679f, -0.00607732f, 
    -0.12384616f, 0.13183923f, -0.12965590f, -0.11350454f, -0.16205965f, 0.06156254f, 0.09177679f, -0.18338732f, 
    -0.09504265f, -0.00280566f, 0.10205276f, 0.10373223f, -0.06200227f, -0.05874625f, 0.05567290f, -0.06713033f, 
    0.17989917f, -0.00085879f, -0.03368449f, 0.21115032f, -0.10101258f, 0.05764027f, -0.15492553f, 0.01321921f, 
    0.11453187f, -0.07285386f, -0.11953979f, 0.24370432f, 0.09391788f, 0.09281046f, -0.03015238f, 0.01890540f, 
    -0.03016219f, 0.01802053f, -0.04387383f, -0.10379115f, 0.15135637f, 0.16622831f, -0.04031597f, -0.41742790f, 
    0.07248067f, -0.06910460f, 0.08300902f, -0.00758040f, 0.26460475f, -0.09291278f, -0.09832799f, -0.06710894f, 
    0.00958201f, -0.03852627f, -0.01746281f, 0.25283459f, 0.02260064f, -0.15763846f, 0.19793241f, 0.14110415f, 
    -0.06205750f, -0.31365228f, 0.03493034f, -0.05822219f, 0.07939707f, -0.01006664f, 0.06758390f, -0.16979326f, 
    -0.00907789f, 0.07600125f, 0.28201240f, 0.01667360f, -0.09646757f, 0.07500380f, -0.01412821f, -0.13298365f, 
    -0.13770632f, -0.05777018f, -0.08532397f, 0.20501940f, 0.12112734f, 0.02438051f, -0.19108112f, -0.28097674f, 
    -0.29395249f, 0.33230898f, 0.13259640f, -0.22980741f, 0.02732894f, 0.01329191f, 0.06938881f, 0.01420455f, 
    0.02144597f, 0.36708012f, -0.01130176f, -0.02900775f, -0.09644219f, -0.09418276f, 0.32205567f, -0.12680544f, 
    -0.10623374f, 0.19866641f, -0.03513787f, -0.01169805f, 0.15122198f, 0.24844038f, 0.09284822f, -0.07963490f, 
    0.01238880f, -0.12916321f, 0.16342725f, -0.05512368f, 0.00392436f, -0.05207545f, 0.04152795f, 0.07128194f, 
    0.26685682f, 0.23479487f, -0.02727325f, -0.05170204f, 0.33262727f, -0.04564819f, 0.05580684f, 0.33074614f, 
    -0.03732035f, 0.18884777f, -0.04809808f, -0.04232112f, -0.05999605f, 0.18238951f, 0.12462290f, 0.22985856f, 
    -0.22409585f, 0.16190450f, -0.11082360f, -0.03371909f, -0.08962134f, 0.00950607f, -0.08060170f, 0.17330767f, 
    0.05541453f, -0.05042968f, -0.14873414f, 0.18198179f, 0.09088770f, -0.11278687f, -0.06074936f, -0.33184993f, 
    0.00094149f, 0.12846750f, -0.05382585f, -0.13199744f, 0.17381296f, -0.08849761f, 0.11565201f, -0.01394026f, 
    -0.08417325f, -0.14286098f, 0.06983113f, 0.11386281f, -0.03371095f, 0.21008879f, 0.00330639f, 0.12984788f, 
    -0.07352665f, -0.17253065f, -0.07290519f, 0.02836165f, 0.17741913f, -0.06266209f, -0.05430996f, -0.11768058f, 
    -0.17417179f, -0.06495602f, 0.16870153f, -0.46721044f, 0.14869660f, -0.10776895f, -0.26872498f, -0.00015381f, 
    0.05591040f, -0.19077688f, -0.00263900f, 0.10270561f, -0.01552086f, 0.16211906f, -0.17608546f, 0.15361473f, 
    0.05716178f, -0.18168752f, 0.17678945f, -0.02283348f, 0.15870385f, -0.32699507f, 0.22613452f, -0.10973846f, 
    0.25946447f, 0.12011508f, 0.22476539f, -0.00003056f, 0.17645474f, 0.24673480f, 0.00683448f, -0.27573156f, 
    0.09763075f, -0.04764260f, -0.01508276f, 0.24167730f, 0.01651673f, -0.05305748f, 0.21021278f, 0.07165088f, 
    -0.24649313f, -0.19872245f, -0.32448629f, 0.25886640f, 0.36991370f, 0.03351886f, -0.01468970f, -0.14135933f, 
    0.05353964f, 0.01373273f, 0.27226532f, 0.02716870f, 0.44745040f, 0.08510298f, 0.06928332f, 0.03474471f, 
    -0.08365314f, 0.14251505f, 0.10966199f, 0.27499864f, -0.03054730f, -0.22891782f, 0.03848620f, 0.05767975f, 
    0.02781021f, 0.01796381f, 0.08374906f, -0.23961551f, -0.10372601f, 0.09147258f, 0.18957645f, 0.07204318f, 
    0.17214502f, -0.07875528f, 0.10956467f, 0.03726948f, 0.40171421f, -0.14875850f, -0.00489512f, -0.08644172f, 
    0.10217532f, -0.07026703f, 0.14261064f, 0.21168019f, -0.08121090f, 0.00972546f, -0.04796363f, -0.05500411f, 
    0.26736748f, 0.14703964f, 0.03298049f, -0.02106115f, 0.08201066f, -0.22590381f, 0.00988681f, 0.04714324f, 
    -0.07809797f, -0.09605720f, 0.20133153f, 0.16185385f, -0.04704347f, -0.02776114f, -0.00575290f, -0.08719487f, 
    0.00243221f, 0.11490168f, -0.19030941f, 0.10599516f, 0.25528646f, -0.03068843f, 0.09194258f, 0.18620554f, 
    -0.08786207f, -0.10455668f, -0.03760178f, 0.08810682f, -0.23449101f, 0.12748966f, 0.07731745f, 0.03495820f, 
    -0.00689127f, -0.05199829f, 0.10532143f, 0.28884757f, 0.09187994f, -0.20537274f, -0.07282348f, 0.25390556f, 
    -0.04641266f, 0.22798058f, 0.17424126f, -0.42383391f, 0.04334614f, 0.13049971f, -0.19105928f, -0.03482875f, 
    0.27483508f, 0.00105169f, -0.01721215f, 0.09525920f, 0.06849156f, -0.14880952f, 0.07780749f, -0.10728151f, 
    0.25669840f, -0.24826959f, 0.01317563f, 0.06990986f, 0.09472993f, -0.08286926f, -0.16754435f, -0.07604131f, 
    -0.01516041f, 0.11168152f, -0.00730808f, 0.05118234f, -0.04745788f, -0.06059579f, 0.03501366f, 0.17545964f, 
    -0.09728920f, -0.10536121f, 0.05474642f, 0.01607480f, 0.09282109f, 0.04660970f, 0.31683880f, -0.14822350f, 
    -0.18379265f, -0.18009983f, -0.41272962f, -0.07426441f, 0.26703227f, 0.14175209f, -0.05191809f, 0.15224041f, 
    -0.10794768f, -0.06777109f, 0.03617212f, 0.13347290f, -0.35508201f, 0.19121300f, -0.14577442f, -0.40170935f, 
    0.02340792f, 0.13595568f, -0.00311777f, 0.00160717f, -0.49736911f, 0.08632256f, 0.05699491f, 0.36783850f, 
    0.17990974f, 0.12329207f, -0.00468365f, 0.18222676f, -0.22387828f, -0.11361253f, 0.16912183f, 0.03515109f, 
    0.08845355f, 0.27787080f, -0.06500784f, -0.07056066f, 0.36169380f, 0.08177468f, 0.08440720f, -0.07603350f, 
    0.17580234f, -0.10801915f, -0.17560992f, 0.09275415f, 0.03701745f, 0.02047133f, -0.06873799f, 0.18251421f, 
    0.03091335f, 0.00170283f, -0.00314388f, -0.07890749f, -0.02715471f, 0.09903312f, -0.01566147f, 0.35197970f, 
    -0.07093594f, 0.10142221f, 0.01909380f, -0.25493422f, -0.33958626f, 0.05526789f, -0.04144860f, 0.12460609f, 
    0.23251776f, -0.13580649f, 0.06591521f, 0.05138086f, -0.06085473f, 0.14938125f, -0.47431630f, 0.04369718f, 
    -0.11629891f, -0.01454135f, 0.10315359f, 0.05731021f, 0.16299546f, 0.12835233f, -0.44136566f, 0.26541778f, 
    -0.10528226f, -0.68987465f, 0.06111771f, 0.08008175f, 0.06290322f, -0.69481391f, 0.11255901f, -0.13401338f, 
    -0.34734330f, 0.12203833f, 0.01142534f, -0.16246127f, -0.03754156f, 0.06862168f, 0.05505189f, 0.08958487f, 
    0.21943384f, -0.14635666f, 0.00073287f, -0.03109061f, -0.29089600f, 0.10022504f, -0.24351437f, 0.04021036f, 
    -0.04358922f, -0.21160728f, -0.21651982f, 0.10828253f, 0.11939815f, 0.14530616f, 0.11453654f, -0.29451856f, 
    0.03921020f, 0.03944583f, 0.13897637f, 0.00821659f, -0.06176693f, -0.14975484f, -0.09977351f, -0.15107310f, 
    -0.10663710f, -0.03961737f, 0.19114739f, 0.04672574f, 0.22583207f, 0.08919972f, 0.11334638f, -0.10391239f, 
    0.01706903f, 0.08917244f, -0.26630667f, -0.11008761f, 0.03145478f, 0.11369217f, -0.20565800f, -0.15510516f, 
    0.02180134f, 0.07297855f, 0.05918107f, 0.17705612f, -0.29030636f, 0.12725188f, 0.01523755f, -0.19059418f, 
    0.07039567f, 0.10801065f, 0.01624800f, -0.00327122f, -0.07122580f, 0.22308366f, -0.10285639f, -0.09101497f, 
    0.21898496f, -0.39990658f, 0.11461158f, 0.57625866f, -0.11332513f, -0.06775185f, -0.14478460f, 0.09059551f, 
    -0.15002146f, 0.10086108f, -0.04366915f, 0.05258850f, 0.31420463f, 0.37579834f, 0.17340021f, 0.27816617f, 
    -0.01238936f, 0.16044892f, -0.30634937f, 0.08564726f, 0.06059144f, 0.33709827f, 0.07395165f, 0.03767314f, 
    0.03670678f, -0.10891356f, 0.16255346f, -0.04829613f, -0.05138989f, 0.16033845f, -0.09715565f, 0.37188959f, 
    -0.16469416f, -0.08911448f, -0.06777193f, -0.07452360f, -0.21398096f, 0.08381414f, -0.04495516f, 0.15637083f, 
    0.09714418f, 0.07315682f, -0.00019438f, 0.17306027f, -0.11722418f, 0.10232760f, -0.19099408f, -0.41185498f, 
    0.09537112f, -0.07273873f, 0.12554340f, 0.09553261f, 0.24592094f, -0.05585140f, -0.07114913f, 0.33084804f, 
    -0.07004799f, -0.10701592f, -0.08385676f, 0.11152281f, 0.17061625f, 0.01325110f, -0.03805403f, -0.28859568f, 
    -0.19136959f, -0.13529557f, -0.01150135f, 0.11676746f, 0.20341234f, -0.05126544f, 0.04196420f, 0.01364307f, 
    -0.09250424f, -0.11401688f, 0.08103432f, -0.07612375f, -0.11194719f, 0.24562830f, -0.04103949f, 0.09749620f, 
    -0.14033347f, 0.34895176f, -0.08993001f, -0.06477230f, -0.08256976f, 0.28812253f, 0.18404835f, 0.14719613f, 
    -0.21454620f, 0.18316950f, 0.03506902f, -0.06054879f, 0.39601836f, -0.01886723f, -0.03080314f, 0.17777829f, 
    -0.08295574f, 0.10589350f, 0.14442399f, 0.25938240f, 0.22070426f, 0.01178705f, -0.25174844f, 0.01422848f, 
    0.00787477f, -0.14279503f, -0.12410959f, 0.00574037f, 0.08093385f, 0.12017572f, -0.03804626f, -0.02488845f, 
    -0.03362509f, 0.05522916f, -0.04956851f, 0.03426488f, 0.00406454f, -0.01800450f, 0.02838239f, -0.09435958f, 
    -0.01903823f, -0.12159009f, -0.05651699f, -0.03707446f, -0.12755920f, -0.08152554f, 0.10584489f, -0.01852314f, 
    -0.07624546f, -0.03790668f, -0.08419457f, 0.05370105f, -0.06895561f, 0.12169781f, -0.08720890f, -0.01973705f, 
    -0.01312819f, -0.11040065f, 0.00184794f, -0.12054419f, -0.10309669f, -0.04036330f, -0.01768941f, -0.04679874f, 
    -0.02585243f, 0.05558725f, 0.01923514f, -0.02664121f, -0.08998380f, -0.06817285f, -0.06244868f, -0.12660515f, 
    0.02463062f, -0.03261769f, -0.00868403f, -0.11310115f, 0.00517265f, 0.06673973f, -0.02977425f, -0.02234644f, 
    0.05483861f, 0.06959688f, 0.00474288f, -0.10389232f, 0.00804523f, 0.01874602f, -0.14797120f, 0.03419863f, 
    0.02529524f, -0.08848166f, -0.08027562f, -0.08766650f, -0.01334639f, 0.00095186f, 0.00255819f, 0.02601744f, 
    0.10253568f, -0.06655020f, -0.25601271f, -0.04427952f, -0.22129203f, 0.01739710f, -0.03756239f, -0.03281035f, 
    0.11526752f, -0.19272454f, 0.08125822f, -0.06558926f, 0.28855348f, -0.11724104f, -0.00254318f, 0.19778830f, 
    0.10853393f, -0.13014743f, -0.03157570f, -0.18852215f, 0.14118227f, -0.03237863f, -0.20006868f, -0.04969352f, 
    -0.21953145f, -0.14347489f, 0.05908561f, 0.29400960f, -0.08329903f, 0.06537851f, 0.24619298f, -0.12043362f, 
    -0.06432900f, 0.04807340f, -0.09517597f, 0.08405618f, 0.00793239f, -0.17253023f, -0.07476851f, -0.04701891f, 
    0.16381814f, -0.09282667f, 0.06659710f, 0.04018019f, 0.20712303f, 0.01577117f, 0.05604386f, -0.12785861f, 
    0.08380133f, 0.01189005f, -0.02644490f, 0.15082024f, -0.11277362f, 0.01679090f, 0.00802158f, 0.12196057f, 
    -0.07176663f, 0.00093435f, -0.11252087f, -0.06254104f, -0.11230841f, -0.06926759f, 0.01195802f, -0.11960078f, 
    0.04287134f, -0.10767817f, -0.07669231f, -0.10571311f, -0.10898627f, 0.00025046f, -0.01631922f, 0.06592217f, 
    0.08834423f, 0.12366511f, 0.09254695f, -0.01530847f, -0.07713126f, 0.05053712f, 0.09580675f, -0.01170656f, 
    -0.09596781f, -0.00475129f, -0.06213637f, 0.10657595f, -0.03648745f, -0.09207191f, -0.14719760f, -0.08516657f, 
    0.00368338f, -0.02600820f, 0.09723277f, 0.03632744f, 0.03414460f, -0.12077552f, 0.04387792f, 0.08719668f, 
    -0.06616426f, 0.07581383f, 0.04786041f, -0.15023850f, 0.04336609f, -0.00180918f, -0.08799657f, -0.04707263f, 
    -0.10170796f, 0.00176115f, -0.10147983f, -0.04673263f, -0.09678205f, -0.09475793f, 0.12005572f, -0.10615623f, 
    -0.02338791f, -0.03379832f, -0.16559131f, -0.06398631f, -0.11386970f, 0.05708803f, -0.04366097f, -0.10087617f, 
    0.22735609f, 0.27509874f, 0.13573772f, -0.22804542f, -0.04523784f, 0.00578664f, 0.14778447f, -0.00678809f, 
    0.10022616f, 0.26404339f, -0.24218658f, 0.13054113f, -0.22147809f, 0.07626286f, -0.03449687f, -0.03573902f, 
    -0.07237934f, -0.08957250f, -0.02951917f, -0.02541685f, -0.01188209f, 0.22172944f, -0.02734593f, -0.11319902f, 
    0.10333256f, -0.03131833f, 0.32049298f, -0.08087067f, -0.02813556f, -0.03343775f, -0.14301594f, -0.01752967f, 
    -0.08600805f, 0.17236337f, 0.08644450f, 0.04939534f, 0.08494405f, 0.51145226f, -0.29435050f, 0.15064894f, 
    -0.07259599f, 0.15697147f, -0.00379208f, 0.01054804f, 0.14156911f, -0.14777972f, 0.17007935f, -0.13361354f, 
    -0.00765707f, 0.11629423f, 0.04921562f, 0.05568480f, -0.20417893f, 0.32276705f, -0.03626198f, -0.02698816f, 
    0.03014840f, -0.05998984f, -0.15883124f, 0.14604291f, 0.23231798f, -0.05199353f, 0.25462452f, 0.09271525f, 
    0.04857586f, 0.00369231f, -0.05513313f, 0.06305387f, -0.00321131f, -0.02377338f, 0.10632496f, -0.33563626f, 
    0.09726916f, -0.09304501f, 0.04186904f, 0.06064461f, 0.18549585f, 0.03793224f, 0.11930934f, 0.35107484f, 
    -0.04924237f, 0.14479922f, 0.07296015f, -0.00955841f, 0.55658603f, -0.12088469f, -0.04132862f, -0.19531038f, 
    -0.02112580f, 0.25332543f, -0.04834903f, -0.17266202f, 0.18435198f, 0.08951940f, 0.07916728f, 0.00707189f, 
    0.17062347f, 0.02293674f, -0.12035492f, 0.13354510f, -0.16831987f, 0.13953632f, -0.08532147f, -0.14881420f, 
    0.15291019f, -0.06730893f, 0.02013491f, -0.22143207f, 0.12159920f, -0.09960815f, 0.24700415f, 0.01759523f, 
    -0.21298181f, 0.05866247f, 0.26054591f, 0.07704312f, 0.35262048f, 0.07004286f, 0.03775707f, -0.20263547f, 
    -0.12750365f, 0.00847543f, -0.07741258f, 0.14296430f, 0.17274594f, 0.10780282f, -0.00949796f, 0.04185975f, 
    0.27386230f, 0.06814037f, -0.36742285f, 0.18799934f, 0.18021207f, 0.03347375f, 0.05924632f, 0.27327958f, 
    -0.02636595f, 0.05930374f, 0.21782818f, -0.01676658f, 0.23888463f, 0.07341689f, 0.05151181f, 0.05841811f, 
    0.02014876f, 0.19696289f, 0.02316008f, -0.15002088f, -0.27954477f, 0.02299275f, 0.03526976f, -0.05567490f, 
    0.04432088f, -0.16006503f, 0.09968551f, 0.15619497f, 0.10415330f, -0.04263788f, 0.21386255f, -0.10098414f, 
    -0.10777003f, -0.14016022f, 0.08321539f, 0.00586464f, -0.04675662f, -0.09455083f, -0.05904335f, -0.10087606f, 
    0.02448872f, 0.00620022f, 0.06257126f, -0.20880818f, -0.03177663f, -0.13839422f, -0.03692548f, 0.17894170f, 
    0.26915774f, 0.10144522f, -0.22070393f, -0.03446870f, 0.08873681f, -0.23052676f, -0.05994816f, 0.01791335f, 
    -0.01986351f, -0.00781734f, -0.13870697f, -0.05135912f, 0.00853474f, -0.03481872f, -0.15563478f, -0.15268762f, 
    -0.07387032f, 0.17124905f, -0.00760178f, 0.12323017f, 0.33128178f, -0.10683353f, 0.18704121f, 0.27207750f, 
    -0.03413194f, 0.00122750f, 0.03268126f, -0.08730003f, -0.04118054f, 0.19896466f, 0.10599910f, -0.19297926f, 
    -0.09982750f, -0.18526943f, 0.10926522f, 0.19069466f, 0.08517176f, -0.02251069f, 0.06760202f, 0.28549525f, 
    -0.09742390f, 0.19377688f, 0.14652935f, -0.54129809f, -0.05651323f, 0.07389089f, -0.22852020f, -0.06603777f, 
    0.12967315f, -0.09983250f, -0.01435421f, 0.16828173f, 0.26930368f, -0.28302222f, 0.01297823f, 0.11477086f, 
    0.09779427f, -0.05177565f, 0.09243911f, -0.08713999f, -0.08538219f, -0.28765810f, -0.06642988f, -0.11240182f, 
    0.19888034f, 0.17344221f, -0.07763574f, -0.09218398f, -0.13695771f, 0.29414219f, 0.03122485f, -0.12264018f, 
    0.12420604f, -0.03915909f, -0.12695999f, 0.00819042f, -0.08054952f, -0.05042565f, 0.32622388f, -0.23439556f, 
    0.08260461f, 0.03386001f, 0.21546556f, -0.08426131f, -0.25771767f, 0.06559049f, -0.10165278f, 0.07372243f, 
    -0.11159054f, 0.10556403f, -0.22034433f, -0.12680922f, 0.04547042f, -0.32626370f, -0.07037531f, 0.01421148f, 
    -0.01728704f, -0.05454770f, 0.04574304f, -0.19046970f, 0.08356662f, 0.08911686f, -0.06430732f, -0.04937932f, 
    0.07871063f, -0.22220099f, 0.01407909f, 0.23438655f, -0.00728308f, -0.07263493f, -0.18477769f, -0.05948016f, 
    0.05379321f, 0.14617682f, -0.03129189f, 0.00655313f, -0.06322303f, 0.12435557f, 0.00424728f, 0.18282858f, 
    -0.06153411f, 0.08070642f, 0.01386872f, -0.17545773f, -0.10245897f, 0.16318768f, -0.07122727f, 0.01569781f, 
    -0.11341889f, -0.15789661f, -0.08079010f, 0.05755312f, -0.07964634f, 0.12838812f, 0.05579179f, 0.04555793f, 
    0.09118731f, -0.06176236f, -0.06943647f, -0.12647927f, -0.01558177f, -0.05646257f, 0.01926533f, -0.15891699f, 
    0.40369117f, 0.14695597f, 0.17512415f, -0.12528200f, 0.05375076f, 0.10549495f, 0.22057791f, 0.03503295f, 
    0.09011406f, 0.02729953f, 0.02787164f, -0.17281768f, -0.12311144f, 0.15701956f, 0.20595901f, 0.07010093f, 
    0.01775126f, -0.14824341f, 0.09984969f, 0.04983679f, 0.16104577f, -0.16471504f, -0.08133077f, -0.12742898f, 
    -0.12459664f, 0.22546236f, 0.13970104f, -0.45979923f, -0.10662306f, -0.04022063f, 0.00138212f, 0.09403433f, 
    0.01864388f, -0.33641049f, 0.05011934f, 0.25057563f, -0.22864604f, 0.08556693f, -0.43774438f, 0.03301866f, 
    0.09997311f, -0.18028565f, 0.27552217f, -0.02677499f, 0.00900811f, -0.35007820f, 0.18259798f, -0.08599750f, 
    -0.12163569f, -0.01108788f, -0.03857515f, 0.09549867f, -0.01099230f, 0.29255953f, 0.00459774f, -0.21526255f, 
    -0.10098761f, -0.10072939f, -0.00859598f, 0.03781439f, 0.25620013f, -0.08589040f, 0.16790386f, 0.07388366f, 
    0.01446119f, 0.04719539f, -0.00356061f, 0.05337594f, 0.17899421f, -0.03852189f, 0.17526624f, -0.07506069f, 
    0.04909751f, 0.03668196f, 0.04659099f, -0.04342839f, -0.22650781f, 0.11753247f, 0.21308759f, -0.11848696f, 
    -0.01571754f, -0.09431586f, 0.08741032f, 0.22186337f, -0.08923285f, -0.11829891f, 0.06325040f, 0.24231361f, 
    -0.02016318f, 0.22238821f, 0.37268519f, -0.27172092f, -0.18888234f, 0.09253978f, -0.03506391f, 0.06560607f, 
    0.24384423f, 0.00540586f, 0.05061022f, -0.25311783f, 0.10140955f, -0.01331270f, -0.21299444f, -0.09406473f, 
    0.22869056f, 0.00094776f, -0.21380529f, -0.11679447f, 0.02696816f, -0.11971122f, -0.09341593f, 0.09156837f, 
    -0.02906880f, -0.02510055f, 0.06647640f, -0.06978092f, -0.10414730f, 0.09057369f, 0.09584957f, 0.06909637f, 
    0.02291433f, -0.02735617f, 0.05619757f, -0.05040306f, 0.06647894f, -0.03800213f, 0.19019073f, 0.02918867f, 
    0.07029618f, -0.06790660f, -0.00276145f, 0.18581183f, 0.07120561f, -0.01392899f, -0.08953498f, 0.25419959f, 
    -0.09022894f, -0.14219685f, 0.05540848f, -0.08417506f, 0.16501200f, 0.09434018f, 0.12510774f, 0.00920004f, 
    -0.03749622f, 0.06245606f, 0.09721057f, -0.09419577f, 0.25031433f, 0.05230885f, 0.07347018f, -0.05243726f, 
    0.15701732f, 0.10534759f, -0.21671437f, -0.15522563f, 0.16402869f, -0.05519535f, -0.05764997f, -0.11024833f, 
    -0.05348019f, 0.07704750f, 0.12301533f, 0.24106103f, -0.03011150f, -0.34658203f, 0.31077364f, 0.03436243f, 
    0.16602060f, 0.12970316f, 0.36707142f, 0.07065389f, -0.01664343f, -0.17801505f, -0.08668480f, -0.16160703f, 
    0.12236153f, 0.04090124f, -0.09573256f, -0.11124645f, 0.08065928f, 0.40674844f, -0.05683098f, -0.12952068f, 
    -0.07579211f, 0.08659431f, -0.10319339f, 0.14633240f, 0.12707409f, -0.07839784f, 0.13709821f, -0.24154530f, 
    -0.05923576f, 0.03555507f, -0.21123269f, 0.26354700f, -0.01169546f, 0.06516327f, 0.00038583f, -0.06704832f, 
    0.06982362f, -0.04080413f, -0.04374734f, 0.38352141f, 0.12874421f, 0.32647157f, -0.07433095f, 0.03777013f, 
    0.05132146f, -0.12372992f, 0.04341138f, -0.02155808f, 0.01839050f, -0.00327682f, -0.01175618f, -0.15280735f, 
    0.03961855f, -0.02169163f, 0.18175413f, -0.03898113f, 0.27642500f, -0.01075178f, -0.18528947f, 0.00298572f, 
    -0.12711903f, 0.15732189f, 0.00079884f, -0.05902057f, -0.07279053f, -0.09646904f, 0.30526793f, -0.06760445f, 
    -0.08477349f, -0.33613378f, -0.24194312f, 0.03252084f, 0.11261310f, -0.00986573f, -0.00359937f, -0.18406126f, 
    0.14620383f, 0.18374236f, 0.41609421f, -0.01913078f, -0.15537685f, -0.28325769f, 0.07493804f, 0.13999853f, 
    -0.15377694f, 0.11540154f, -0.05556029f, 0.18593384f, -0.09357703f, 0.01090732f, -0.10308187f, -0.01324698f, 
    0.24033904f, -0.08985702f, 0.10288565f, -0.04111947f, -0.18245681f, -0.07002559f, -0.32071060f, -0.03091942f, 
    0.05304209f, -0.24905743f, -0.11117239f, 0.16842978f, -0.07074504f, -0.14627920f, 0.15731844f, 0.25201610f, 
    0.10726094f, 0.14055642f, 0.03473613f, -0.29673466f, 0.15779422f, -0.18202367f, -0.05946637f, -0.14849783f, 
    0.00369177f, 0.12294213f, -0.32434595f, -0.17735264f, -0.01550423f, -0.07198148f, 0.29896814f, 0.03340473f, 
    0.16117017f, -0.33378294f, 0.00467411f, -0.01021316f, -0.44738305f, -0.53702462f, -0.01997101f, 0.09684902f, 
    0.15458916f, 0.16336572f, -0.11091382f, 0.04104108f, 0.21737941f, -0.31288260f, 0.35399884f, -0.03626899f, 
    -0.21605884f, -0.13472416f, 0.06730225f, -0.12445427f, 0.36894986f, -0.23273554f, -0.07348911f, -0.08787107f, 
    -0.02011201f, 0.06798367f, 0.07846072f, 0.05863786f, 0.23939846f, -0.02393818f, -0.11188149f, -0.08188532f, 
    -0.04083419f, 0.01748250f, -0.32533374f, -0.10094224f, 0.11987401f, -0.00951883f, -0.04066519f, -0.07416657f, 
    -0.03756456f, 0.13469891f, 0.05748280f, 0.33315128f, -0.60209274f, 0.20503658f, -0.10532866f, -0.18295699f, 
    0.01264800f, -0.02476623f, 0.03034988f, 0.04324542f, -0.27172220f, 0.08297707f, 0.01315612f, 0.04590409f, 
    -0.11278915f, -0.09930314f, 0.32051447f, 0.11470363f, -0.20339316f, 0.10710744f, -0.13738278f, -0.05506013f, 
    0.25284830f, -0.03561331f, -0.08726259f, -0.05964281f, 0.33404180f, 0.36602014f, 0.14237741f, 0.07878474f, 
    0.20192574f, -0.25177947f, -0.35565826f, 0.00112466f, 0.10194132f, -0.08357962f, 0.00383913f, 0.19988565f, 
    -0.08148914f, 0.07490630f, 0.35824695f, 0.04411317f, -0.19806497f, 0.11434063f, -0.10736364f, 0.29879749f, 
    -0.18127735f, 0.05304489f, 0.03554456f, -0.10040112f, -0.22703704f, -0.08903624f, 0.04936948f, 0.26625839f, 
    -0.05861015f, 0.05856229f, 0.00283008f, 0.19432390f, -0.01888651f, -0.00732660f, 0.13861085f, 0.03705327f, 
    -0.06555634f, -0.09547094f, -0.02244495f, 0.20623666f, -0.36778298f, -0.18402679f, -0.01314146f, 0.03443899f, 
    -0.08952104f, 0.14207713f, 0.10008406f, 0.14076804f, 0.24793564f, 0.08361999f, -0.11704859f, 0.15530284f, 
    0.11674190f, 0.09452249f, 0.16688667f, 0.15472673f, 0.12133475f, 0.05830574f, -0.07207895f, -0.00114898f, 
    0.10234176f, 0.09016312f, 0.04443229f, -0.12347849f, -0.22896603f, 0.15379201f, 0.36658442f, -0.05037391f, 
    -0.10832126f, -0.00801499f, -0.25011295f, 0.10347013f, 0.03899196f, 0.01068888f, 0.01385363f, -0.11785855f, 
    -0.27071792f, 0.00654376f, 0.23478495f, 0.08575952f, -0.08581804f, -0.14237201f, -0.00357660f, 0.14802919f, 
    0.10957217f, 0.07511897f, -0.07146605f, 0.16087885f, -0.02992078f, -0.00797057f, 0.12456395f, 0.15973172f, 
    0.13588859f, -0.21526848f, -0.07782234f, -0.09737294f, 0.07951995f, -0.02358634f, -0.54097152f, -0.02164911f, 
    0.04723238f, 0.04881768f, 0.13235810f, -0.41557440f, 0.58612382f, 0.21108565f, -0.25172824f, -0.10203672f, 
    -0.04178127f, -0.30294082f, 0.04690112f, 0.05051149f, -0.03409104f, -0.18016300f, -0.10362580f, 0.11033658f, 
    -0.15898809f, 0.05395129f, -0.05463289f, 0.09456986f, 0.03627921f, 0.06861478f, -0.28146768f, 0.06707473f, 
    -0.29508117f, -0.19940940f, -0.03702191f, -0.09368311f, -0.19668913f, 0.26324511f, -0.45383587f, 0.05714591f, 
    -0.14470138f, 0.11139634f, 0.26525250f, -0.02919523f, -0.03533031f, 0.18820663f, 0.09633798f, -0.30169210f, 
    0.25630045f, 0.13336073f, 0.15573974f, -0.15896392f, -0.25928193f, 0.15846050f, -0.08724562f, -0.08566530f, 
    0.01301617f, -0.00328370f, 0.05991717f, 0.05266179f, -0.06844705f, -0.06471232f, -0.07115134f, 0.08620173f, 
    0.06169635f, 0.22657856f, -0.18605734f, -0.08492117f, 0.00842196f, -0.02650867f, 0.12349100f, 0.03740707f, 
    0.09365959f, 0.32765722f, -0.02470592f, 0.06858083f, 0.28176001f, -0.19400127f, 0.07649166f, 0.09243614f, 
    0.07524660f, 0.36188668f, -0.03045682f, 0.15352215f, -0.19448794f, 0.12717776f, 0.09659132f, -0.15128188f, 
    0.17929119f, -0.00199074f, -0.01691193f, 0.19455691f, 0.20495494f, -0.11359086f, 0.17755626f, -0.03104400f, 
    0.02775948f, 0.06860302f, 0.03683741f, 0.29917935f, 0.07005255f, 0.20778161f, -0.31960487f, 0.00231112f, 
    0.03256722f, -0.04993233f, 0.33762312f, -0.17952712f, -0.23790456f, 0.29715008f, 0.02386540f, 0.12321700f, 
    0.24749570f, 0.13496625f, 0.02737470f, -0.03173186f, -0.19555582f, 0.07790442f, -0.10177899f, -0.10272570f, 
    -0.10745004f, 0.06743605f, -0.16202874f, 0.01574948f, -0.16514151f, -0.01135755f, -0.05754156f, -0.14827186f, 
    0.03053008f, -0.21924774f, 0.07506318f, 0.18218943f, 0.21730989f, 0.04537882f, -0.02473933f, 0.22635621f, 
    0.08551856f, -0.15003149f, 0.05597121f, -0.12494561f, 0.51005977f, 0.09540932f, 0.04768260f, 0.00573903f, 
    -0.08498305f, -0.03238760f, -0.06750032f, 0.07523329f, -0.28713590f, 0.12011413f, -0.07951044f, 0.21782178f, 
    0.01696139f, -0.14132074f, 0.15536980f, -0.15365021f, 0.06371742f, -0.07728066f, 0.11390793f, 0.00890160f, 
    -0.33181116f, -0.08617292f, -0.09235390f, -0.34463924f, 0.02166328f, -0.32962087f, 0.01636480f, 0.06648608f, 
    0.04352511f, -0.00957895f, -0.14309970f, -0.10035860f, -0.11643932f, 0.02585599f, -0.05327749f, -0.12579185f, 
    0.21352929f, 0.10461494f, -0.02524732f, -0.02291860f, -0.19859341f, 0.00184549f, -0.06582022f, -0.02196356f, 
    0.11102005f, -0.09997370f, 0.16677953f, 0.03174856f, -0.02282866f, -0.02088231f, -0.09820259f, -0.00263760f, 
    -0.29954338f, 0.11234140f, -0.22997002f, 0.25011984f, 0.18257314f, -0.04266636f, 0.27534100f, 0.14730541f, 
    0.12228583f, 0.11767793f, 0.21972470f, -0.04669598f, -0.09083192f, -0.25892922f, 0.21534039f, 0.01402758f, 
    -0.12060049f, 0.35155988f, 0.01143105f, 0.28320283f, 0.12298673f, -0.12451962f, -0.03563613f, 0.34402281f, 
    0.27945232f, 0.11875022f, -0.01145439f, 0.12014752f, 0.18546636f, 0.12447713f, 0.34628662f, 0.09714940f, 
    0.14257897f, 0.09666469f, -0.02067633f, 0.06442145f, 0.15992399f, -0.10043327f, 0.00844563f, -0.32807329f, 
    0.04341424f, -0.00107727f, 0.03536416f, -0.17195508f, -0.28561029f, 0.11360966f, 0.12126069f, 0.15411313f, 
    -0.08206668f, 0.16448252f, 0.08142416f, 0.12844898f, 0.07725284f, 0.06182639f, 0.10253066f, 0.04052547f, 
    0.02747367f, -0.02160987f, -0.07699878f, -0.20146562f, -0.28698984f, -0.03109830f, 0.11374850f, 0.06514013f, 
    0.01067516f, 0.10021652f, -0.03720434f, 0.01661827f, -0.14133237f, 0.06791462f, 0.02356072f, -0.25839746f, 
    -0.02310823f, -0.07941440f, 0.08652678f, -0.10775093f, 0.05846752f, -0.05325777f, 0.17340422f, 0.07634017f, 
    0.05981695f, 0.04102351f, 0.09017645f, 0.06496289f, 0.28143561f, 0.05521073f, 0.09830656f, -0.02518634f, 
    -0.14211987f, 0.13267234f, -0.15898941f, -0.12392218f, 0.05150120f, 0.06060064f, 0.16150482f, 0.09479722f, 
    0.09315619f, -0.27049842f, 0.02912726f, 0.16055015f, -0.06392183f, -0.07320737f, -0.23662722f, -0.15852080f, 
    -0.01792074f, 0.15591934f, 0.22478618f, 0.12070029f, 0.14919755f, -0.19661316f, 0.18154809f, -0.14440237f, 
    0.00733456f, 0.15768127f, 0.24790071f, 0.05100273f, 0.22338615f, 0.53866845f, -0.10035323f, -0.27013913f, 
    0.05866829f, -0.05887447f, -0.19047970f, 0.14063984f, 0.08204404f, -0.00334235f, 0.26023138f, 0.25095236f, 
    -0.13715488f, -0.19845380f, -0.01009151f, 0.16660942f, 0.08220001f, 0.01271567f, -0.12231743f, -0.10105561f, 
    -0.03498452f, -0.01794079f, 0.00186710f, -0.00145282f, 0.13831778f, -0.12194679f, -0.08006284f, 0.04443556f, 
    0.09414202f, -0.04168322f, -0.07034822f, 0.33042499f, 0.15348721f, -0.36942214f, 0.04801653f, -0.02495230f, 
    -0.22404200f, 0.19689718f, 0.09610449f, 0.02985292f, -0.06719100f, -0.10697152f, -0.07816298f, -0.05090727f, 
    0.19916421f, 0.09553337f, 0.04218254f, -0.12296013f, 0.11112353f, 0.32200003f, 0.10184520f, -0.12621890f, 
    -0.06962559f, -0.16683555f, -0.23334931f, 0.29838666f, 0.11081843f, 0.34968469f, -0.04226995f, 0.00201558f, 
    -0.18764716f, 0.10188869f, 0.27558574f, 0.04153726f, 0.08083203f, -0.53861272f, 0.06005558f, 0.33537346f, 
    0.07036884f, 0.09316320f, 0.23365110f, 0.05134168f, -0.01183841f, -0.07386967f, 0.00677560f, 0.23406857f, 
    0.33361223f, 0.00829715f, 0.03238161f, -0.11294494f, 0.11597677f, 0.16590966f, -0.69693017f, -0.01916769f, 
    0.08805734f, -0.25995848f, 0.16585864f, -0.02525873f, 0.44350269f, 0.31658465f, -0.39471006f, 0.06821035f, 
    -0.11918778f, -0.33798316f, -0.04839426f, 0.04663641f, -0.15577972f, -0.07729407f, -0.03648114f, 0.01343574f, 
    -0.09977731f, 0.07695530f, -0.10880345f, -0.05731881f, -0.20785810f, 0.11120813f, -0.10623493f, -0.11943221f, 
    -0.01524814f, 0.01683484f, -0.03341906f, -0.12052038f, 0.04830916f, 0.35879129f, -0.24181345f, -0.00372898f, 
    -0.09713159f, 0.01347893f, 0.26089701f, 0.28425878f, 0.19943757f, -0.07656744f, -0.10320289f, -0.26766324f, 
    0.14368781f, 0.06992571f, 0.11944591f, 0.00399103f, 0.01210652f, 0.35851246f, 0.08473742f, 0.04084972f, 
    0.02680671f, 0.09096003f, 0.27547345f, 0.14262834f, 0.01207059f, 0.12448199f, 0.18555690f, 0.13331251f, 
    0.25122041f, 0.41106272f, -0.12353230f, -0.07527085f, 0.12928139f, -0.07296322f, 0.12448443f, 0.14763404f, 
    -0.09480573f, 0.33471254f, 0.05026991f, -0.04715364f, -0.15681149f, -0.00062131f, 0.33149821f, -0.08595014f, 
    -0.07924131f, 0.39137676f, -0.02099682f, 0.11416364f, -0.09832343f, 0.08941586f, -0.06302902f, -0.00233467f, 
    0.07073212f, 0.04525098f, 0.00156175f, -0.07524513f, 0.23180383f, 0.02508660f, 0.23866604f, 0.01080087f, 
    0.29617721f, -0.03849059f, 0.08924156f, 0.43855527f, 0.09486286f, 0.25891706f, -0.26936486f, 0.10661042f, 
    0.05709741f, 0.13738668f, 0.02120498f, -0.16026856f, 0.09592049f, -0.13010404f, 0.07164526f, 0.09997103f, 
    0.13017645f, 0.09793184f, -0.03639020f, -0.11290504f, -0.16663407f, 0.24175671f, 0.05770498f, -0.10324137f, 
    0.06390418f, -0.08340038f, -0.20914589f, -0.20139632f, -0.07416748f, -0.11612819f, 0.06706797f, -0.18194489f, 
    -0.09582084f, 0.02102962f, 0.14743380f, 0.17976671f, -0.06520782f, -0.05270167f, 0.37591574f, 0.13217494f, 
    -0.07335339f, 0.02707261f, 0.16420107f, -0.03783954f, 0.32198080f, 0.14157663f, 0.14847891f, 0.11368944f, 
    0.03334788f, 0.03969499f, -0.11461218f, -0.00564640f, 0.42165014f, 0.10395890f, -0.02621781f, 0.09686004f, 
    0.06281628f, 0.08100820f, 0.14339788f, -0.27078778f, 0.31435791f, 0.11904058f, -0.00447274f, -0.04993680f, 
    -0.22626951f, -0.05263406f, -0.02932124f, 0.03322519f, -0.26594946f, -0.24211800f, 0.03642325f, -0.15425582f, 
    -0.07049842f, 0.08684594f, -0.02391387f, -0.11814842f, 0.17453414f, -0.09254278f, 0.24187575f, 0.02702494f, 
    -0.07981502f, 0.03796456f, -0.00124233f, -0.01467658f, 0.16920474f, -0.05028692f, 0.03141875f, -0.15952185f, 
    -0.04636898f, -0.02139665f, -0.00286472f, 0.39912051f, 0.22665529f, 0.04683927f, -0.07194900f, -0.01698638f, 
    0.06899215f, 0.17755762f, -0.01262442f, 0.07277346f, -0.10426148f, -0.01309736f, -0.00469706f, -0.32067227f, 
    -0.00508497f, -0.01391425f, 0.08736672f, -0.05511570f, -0.03060529f, 0.07493263f, 0.07191711f, 0.26633134f, 
    -0.03242737f, 0.10284008f, 0.10307132f, -0.06510963f, 0.43509024f, 0.05219317f, 0.03400555f, -0.27540550f, 
    0.03919595f, -0.08169859f, -0.24552016f, 0.03605159f, 0.16365737f, -0.08851841f, 0.18616976f, -0.02102717f, 
    0.02653281f, -0.14414628f, 0.12304571f, 0.40282139f, -0.13796067f, 0.03245892f, 0.08129545f, -0.06419406f, 
    0.13231893f, 0.30425581f, 0.26900455f, 0.09666475f, -0.03631336f, 0.00603279f, 0.22125036f, -0.18868226f, 
    -0.07665724f, 0.01799470f, 0.14422990f, 0.02605502f, 0.32387584f, 0.21967322f, 0.05983967f, -0.17545867f, 
    -0.03273289f, 0.06429305f, -0.12825939f, 0.15098043f, 0.17940460f, 0.10317826f, 0.01715724f, -0.07741886f, 
    -0.21033576f, -0.21996273f, -0.22658329f, 0.07926267f, 0.16294987f, -0.10035219f, 0.11186399f, -0.17243144f, 
    0.03233492f, -0.04879113f, 0.28837132f, 0.02241479f, 0.31048927f, 0.14348397f, -0.17309968f, 0.05065601f, 
    -0.11518026f, -0.12902816f, -0.00429987f, 0.24200225f, -0.26391703f, -0.19478375f, 0.09097089f, 0.00179099f, 
    -0.09112370f, 0.24508774f, 0.15624222f, 0.13373362f, -0.13352910f, -0.05708138f, 0.22694148f, 0.00940435f, 
    -0.05580350f, 0.01234439f, 0.12569734f, -0.33459195f, 0.19723897f, 0.06331563f, -0.24129193f, 0.00438442f, 
    0.02658867f, 0.01658569f, -0.23301145f, 0.22413091f, 0.08747128f, 0.25457218f, 0.07236505f, 0.09836196f, 
    0.03578902f, 0.16492756f, 0.08787109f, -0.00672348f, -0.00977020f, -0.30762124f, -0.11649267f, 0.37832844f, 
    0.06849924f, -0.01540235f, 0.25489387f, -0.00250239f, -0.13971202f, -0.01521973f, -0.14755495f, 0.31142369f, 
    0.01906807f, 0.14320068f, -0.22664252f, 0.20093600f, 0.03040849f, -0.04640720f, 0.04174301f, 0.07463074f, 
    -0.06858271f, -0.16300373f, -0.14638539f, 0.01364196f, -0.06001120f, -0.10344304f, 0.16788080f, 0.19878022f, 
    -0.00268101f, 0.03476391f, 0.12674244f, 0.24925162f, 0.35557559f, -0.07874624f, -0.04333052f, 0.27185366f, 
    -0.06220721f, 0.30133340f, -0.06093390f, -0.70155382f, -0.05609005f, -0.09944054f, 0.13647589f, 0.02314171f, 
    0.12616459f, -0.14919922f, -0.06292066f, 0.40918234f, 0.06050278f, -0.47029886f, 0.33687726f, -0.35614902f, 
    0.40093383f, -0.01463396f, 0.19511029f, -0.09514331f, -0.14198306f, -0.18561579f, -0.06215918f, 0.03719017f, 
    -0.04909639f, 0.16251172f, 0.00811807f, 0.02140452f, 0.03231137f, 0.25057858f, 0.02338357f, -0.13461746f, 
    0.09258987f, 0.02124288f, -0.21982606f, -0.16194288f, -0.04632785f, 0.03114772f, 0.32251242f, -0.11577435f, 
    -0.06282058f, 0.12748542f, -0.09004050f, -0.09231053f, -0.04789854f, -0.01190513f, 0.12736996f, 0.06357592f, 
    -0.04224779f, 0.15943202f, -0.00839465f, -0.17234433f, 0.12549271f, -0.20166978f, 0.12721977f, 0.06496904f, 
    -0.05174136f, 0.05640112f, -0.04259019f, -0.18326673f, 0.01493849f, 0.12969415f, -0.03298013f, -0.19218804f, 
    0.18350524f, -0.24065921f, 0.11656747f, 0.11273874f, -0.09343034f, -0.04866356f, 0.18549502f, 0.08755803f, 
    -0.04567436f, 0.05826928f, -0.12273741f, 0.18784007f, 0.29010943f, -0.07253004f, -0.14115135f, 0.19661237f, 
    0.28277096f, 0.03272012f, 0.23100539f, -0.08780660f, -0.29694781f, -0.08092210f, -0.11874600f, 0.05167444f, 
    0.11722825f, 0.05964389f, -0.37679985f, 0.02555242f, 0.02003093f, -0.00265245f, -0.04457382f, 0.18697055f, 
    0.02121030f, -0.06244482f, -0.12132670f, -0.03571151f, -0.01193111f, 0.11440021f, -0.09381747f, -0.20918709f, 
    0.06144897f, -0.01232704f, -0.14795330f, 0.01257494f, -0.10264432f, 0.07936741f, 0.01351249f, 0.00419680f, 
    0.09347585f, 0.13546248f, -0.08746321f, 0.11500987f, -0.11103807f, 0.02333761f, 0.00460671f, -0.11197477f, 
    -0.03856781f, 0.01003571f, -0.05130365f, 0.01251871f, -0.05433974f, 0.17693359f, -0.02808687f, -0.14162238f, 
    0.06950435f, 0.05017440f, 0.02570798f, 0.10184975f, -0.08225691f, -0.01132321f, -0.13159038f, -0.03194776f, 
    -0.01813383f, 0.15844521f, 0.00013237f, 0.08533406f, 0.10522206f, 0.11494799f, -0.10748260f, -0.02765471f, 
    -0.09433129f, -0.01107595f, 0.08862942f, -0.07720580f, 0.02243681f, -0.01075960f, -0.01671226f, 0.07371125f, 
    0.06708606f, -0.11030997f, -0.01373674f, -0.04833139f, 0.02250613f, 0.09577801f, 0.07317460f, 0.01217905f, 
    -0.03729300f, 0.05401610f, -0.08796889f, 0.09408500f, 0.05202119f, 0.02052654f, -0.08659769f, -0.15996645f, 
    -0.35125980f, 0.14875658f, 0.01596200f, -0.19859798f, -0.15661441f, 0.02982522f, 0.29362386f, -0.15923104f, 
    -0.04553879f, 0.39276633f, 0.12585908f, -0.11635704f, -0.11961342f, -0.35873356f, 0.35285637f, 0.00933688f, 
    -0.01201118f, 0.14720973f, -0.00409092f, 0.04950792f, 0.20455161f, -0.11840346f, -0.09363066f, 0.20343763f, 
    0.20390049f, 0.01213223f, 0.26353770f, 0.20563428f, -0.10358036f, 0.01255575f, 0.14797072f, 0.00110595f, 
    0.35856515f, 0.17444289f, -0.00931483f, -0.00366244f, 0.30678764f, 0.05976177f, 0.05734503f, -0.10681786f, 
    0.18890908f, 0.31561956f, -0.16843401f, -0.19179963f, -0.18092448f, 0.27328321f, 0.16294970f, 0.26378179f, 
    -0.28660390f, 0.04086747f, -0.19838765f, -0.08548583f, 0.19471659f, -0.31412950f, -0.04845845f, 0.25754675f, 
    0.13414426f, 0.03412911f, -0.21071209f, 0.08854411f, 0.12322151f, 0.08397099f, -0.06400597f, -0.04032548f, 
    0.18576689f, 0.22744253f, -0.01697022f, -0.02647843f, 0.26103479f, -0.00547075f, -0.02888590f, 0.26712483f, 
    -0.08858656f, -0.05764806f, 0.04557006f, -0.00308625f, -0.16063422f, 0.32318479f, 0.10787396f, -0.19173148f, 
    -0.14214987f, 0.00177094f, -0.03898500f, -0.02496261f, -0.33405426f, 0.12281565f, -0.03786635f, 0.18642534f, 
    0.17726918f, -0.08334044f, -0.04549344f, -0.08664764f, -0.04256883f, 0.01255161f, -0.26120058f, -0.04219432f, 
    -0.16775896f, 0.09048258f, 0.00690149f, 0.21068226f, 0.35476670f, -0.08920112f, -0.24720500f, 0.26036042f, 
    0.02302069f, 0.09281378f, 0.15003362f, 0.20953803f, -0.07148325f, -0.37429264f, 0.02417633f, 0.10232721f, 
    0.09979421f, 0.02614168f, -0.02962336f, 0.04697084f, -0.09960411f, 0.56142199f, -0.10294528f, -0.18242556f, 
    -0.00061401f, 0.11415437f, -0.06462666f, 0.02996874f, -0.04191450f, 0.07817449f, 0.07464324f, -0.16088533f, 
    0.04514254f, -0.11456809f, 0.10353227f, 0.21807376f, -0.09631301f, -0.03694965f, -0.34095728f, 0.10447764f, 
    -0.03096203f, 0.21629809f, 0.10581942f, -0.02548273f, 0.05267030f, 0.18871747f, -0.15130633f, -0.37274492f, 
    -0.15379253f, 0.03137760f, -0.06611965f, 0.08856997f, -0.20555426f, 0.06494587f, 0.00114712f, -0.11303920f, 
    0.05789352f, -0.12326247f, -0.18635070f, -0.06008312f, -0.15902050f, -0.06955960f, -0.14510159f, -0.00129320f, 
    0.34912729f, 0.17459790f, 0.06017798f, -0.11314999f, -0.13094163f, -0.13204746f, 0.12866098f, 0.05794279f, 
    0.04972741f, -0.05713708f, -0.12204587f, -0.05299001f, -0.41607413f, -0.03936679f, -0.08165900f, 0.04513047f, 
    -0.04449163f, -0.04468599f, -0.25862801f, 0.09232709f, -0.02397096f, -0.12879257f, 0.12453231f, -0.06239057f, 
    0.06397081f, 0.05064571f, 0.06864560f, -0.06898948f, -0.18814774f, 0.07736339f, -0.13036415f, -0.52953720f, 
    -0.08217527f, -0.11765721f, 0.02015411f, -0.06986435f, -0.10789167f, 0.10228087f, -0.12152818f, -0.06998094f, 
    -0.02969472f, 0.08122557f, -0.06812636f, 0.02639551f, -0.05139032f, -0.04905353f, -0.03424919f, 0.07077783f, 
    0.02763628f, -0.12072969f, 0.05397690f, -0.08071779f, -0.07625253f, -0.10189353f, -0.11957707f, -0.10913423f, 
    -0.03759616f, 0.02034375f, 0.05708982f, 0.07586166f, -0.02143066f, 0.10905668f, -0.03331705f, 0.05692838f, 
    -0.13289149f, -0.09796965f, 0.05880129f, -0.02414105f, -0.01981814f, 0.04643544f, -0.01952906f, -0.04448826f, 
    -0.05649596f, -0.01594482f, -0.03883569f, 0.03550879f, -0.10380487f, 0.06264135f, -0.06861482f, -0.01130705f, 
    -0.02084471f, -0.04447363f, 0.01422458f, 0.00957785f, -0.07938737f, 0.02403395f, -0.10911355f, -0.11532199f, 
    0.07140437f, 0.05155573f, -0.02833891f, -0.03918883f, -0.05807320f, 0.11534540f, 0.05136089f, -0.04419155f, 
    0.03960059f, -0.06409222f, -0.10497064f, -0.11553054f, -0.05997026f, 0.10271183f, 0.08608718f, -0.19432223f, 
    -0.07349455f, -0.13922395f, -0.21222378f, -0.05898384f, -0.03948067f, 0.11873767f, -0.08413502f, 0.15852478f, 
    0.00109450f, -0.08234575f, -0.07137861f, -0.13300747f, 0.10986783f, -0.18378609f, -0.01934234f, 0.12906347f, 
    -0.18423206f, 0.02852095f, 0.06439248f, -0.05057568f, -0.01625657f, 0.08419167f, -0.05568467f, 0.01239860f, 
    -0.07514765f, 0.03403322f, 0.08172321f, 0.11029670f, -0.19929522f, -0.06038192f, 0.07648249f, 0.07880632f, 
    0.06104757f, 0.06739952f, -0.24836478f, 0.11664112f, 0.15081970f, -0.17383336f, 0.18184298f, 0.07753913f, 
    0.10309290f, -0.06815650f, 0.10323294f, 0.07856234f, 0.19587460f, 0.06801698f, 0.11791742f, -0.06614354f, 
    -0.12437755f, -0.07406256f, -0.04154050f, -0.04070331f, 0.14584336f, 0.07395219f, 0.11086332f, -0.07027679f, 
    -0.20749611f, 0.08108950f, 0.08481549f, -0.09359369f, -0.11059326f, 0.03767457f, 0.40314069f, -0.17859896f, 
    -0.07233047f, 0.16838557f, 0.14642428f, 0.06310909f, 0.38849273f, -0.00832686f, 0.24799924f, -0.11258106f, 
    0.05515295f, 0.08527634f, 0.02854034f, -0.05672888f, -0.10627066f, 0.13918008f, -0.07953972f, -0.02692561f, 
    0.27649972f, 0.17263497f, 0.40299293f, 0.21772505f, 0.16456378f, 0.06733610f, -0.06127111f, -0.01483466f, 
    -0.01747683f, 0.34790227f, -0.05754848f, -0.09457492f, -0.01642427f, 0.01614527f, -0.28284609f, -0.02167326f, 
    -0.23078924f, 0.03477592f, -0.37243676f, -0.06174673f, 0.08200244f, 0.38025001f, 0.08123670f, 0.13156328f, 
    -0.15542114f, 0.24497916f, -0.14407946f, -0.10624970f, -0.13115346f, -0.40756014f, 0.00660926f, 0.10931611f, 
    -0.13281557f, 0.06839553f, 0.10949857f, 0.19612601f, 0.19816606f, -0.11284824f, -0.15326583f, -0.12034082f, 
    0.12705624f, 0.04439324f, -0.06277601f, 0.12003849f, 0.11093700f, -0.04039808f, 0.26622587f, 0.10277037f, 
    0.06878170f, -0.24267720f, -0.07663345f, 0.05034353f, -0.17595746f, 0.26263607f, 0.21973944f, 0.01464058f, 
    -0.01854241f, -0.04834091f, 0.08314843f, -0.06683850f, 0.14714980f, -0.02778650f, -0.10764704f, 0.25963143f, 
    -0.09188051f, 0.11905603f, 0.06163631f, -0.19345537f, 0.07230408f, -0.01398903f, 0.00684792f, 0.08099606f, 
    -0.21632107f, -0.18017215f, -0.04572980f, -0.03890717f, -0.02092070f, -0.52460176f, 0.10487767f, -0.00461738f, 
    0.23604620f, 0.05253037f, 0.03945386f, 0.12640178f, 0.19118175f, -0.50209832f, 0.02954711f, 0.08427139f, 
    0.01740088f, 0.01469460f, -0.15148117f, -0.03666344f, 0.08435428f, 0.41827819f, -0.10554390f, -0.08251500f, 
    -0.07568576f, 0.05209708f, 0.08044384f, 0.11481937f, -0.00823676f, 0.03569916f, 0.27365884f, -0.02966524f, 
    0.00422848f, 0.02026098f, -0.05102713f, 0.14648952f, -0.03535121f, -0.01085677f, -0.27529323f, -0.28988281f, 
    -0.06267811f, 0.01677977f, 0.00598853f, 0.01233989f, 0.09950537f, -0.13605772f, -0.04864303f, 0.33973524f, 
    -0.05057929f, -0.06525392f, 0.02674146f, 0.01787993f, 0.34462205f, -0.15361375f, -0.03182028f, -0.24144122f, 
    -0.18041822f, -0.01713846f, -0.14086221f, -0.05140741f, 0.03354863f, -0.10733011f, 0.06158244f, 0.12117805f, 
    0.08015711f, 0.02143688f, -0.09982766f, 0.12431744f, -0.10625225f, 0.38878545f, -0.12257611f, 0.12432883f, 
    -0.17469096f, 0.15761083f, 0.15468080f, 0.03321537f, 0.02524876f, 0.09074885f, 0.07366026f, -0.04370089f, 
    -0.13271405f, 0.06000570f, 0.21873170f, 0.11003394f, 0.31837371f, -0.21420345f, 0.07364763f, 0.01626514f, 
    -0.08912769f, 0.07034618f, 0.02520021f, 0.17410913f, 0.09182262f, -0.07348192f, -0.06695072f, 0.03067153f, 
    -0.02322235f, -0.07818076f, -0.08454937f, -0.05907923f, 0.00788759f, 0.07078049f, -0.11203503f, 0.02239496f, 
    0.06139146f, 0.05626257f, -0.12766960f, 0.06464827f, -0.02057443f, -0.14263991f, 0.03385131f, -0.00664227f, 
    0.10597333f, -0.08113001f, 0.02690557f, -0.13668738f, 0.09966069f, -0.00581686f, -0.04399507f, 0.01762032f, 
    -0.09098424f, -0.03455573f, -0.11414022f, 0.11434816f, 0.01883126f, -0.00764783f, 0.06126615f, -0.00110061f, 
    -0.09102102f, 0.03839133f, -0.01263644f, -0.01365891f, -0.05927295f, 0.07340381f, 0.02611517f, -0.01938495f, 
    -0.10974156f, 0.00934530f, 0.01388214f, 0.04931244f, 0.03895948f, 0.05819277f, -0.05125870f, -0.04586245f, 
    0.02076757f, -0.00438129f, -0.02741413f, -0.10841187f, -0.09431864f, -0.06652741f, 0.06933223f, 0.05622631f, 
    0.01727308f, 0.07873567f, -0.01466842f, -0.05731546f, 0.02027484f, 0.04165146f, -0.03212553f, -0.10032017f, 
    0.04159241f, 0.11607020f, 0.00420254f, -0.07454620f, -0.06942443f, 0.04166681f, -0.06813020f, -0.13926683f, 
    0.11431183f, 0.06467905f, 0.09271719f, 0.01558124f, -0.05122887f, -0.07237969f, -0.00146697f, -0.01180823f, 
    -0.06004767f, 0.06537987f, -0.12034568f, 0.01729178f, -0.12471342f, 0.00398025f, -0.09175487f, -0.14607635f, 
    -0.00093223f, 0.04234389f, -0.12132967f, -0.11331000f, 0.11602361f, 0.11858635f, 0.07092267f, 0.06555617f, 
    -0.15763171f, -0.06333852f, -0.07295460f, 0.08017126f, -0.03779616f, -0.04884179f, 0.00642962f, -0.09921259f, 
    -0.06536695f, -0.11940426f, 0.08117286f, -0.14017823f, -0.06759737f, 0.10175066f, -0.03683696f, -0.07233907f, 
    0.03943438f, -0.08034920f, -0.13242729f, -0.07533536f, -0.12176647f, -0.07473897f, -0.01959379f, -0.09044778f, 
    0.08879156f, -0.00179530f, -0.13497435f, -0.11461804f, -0.09098436f, 0.02539428f, 0.08413007f, 0.01586820f, 
    0.04881556f, -0.16176870f, 0.02656538f, -0.08425806f, -0.15589114f, -0.09663057f, -0.17984936f, 0.11982541f, 
    0.06250484f, -0.02270648f, -0.21871045f, -0.14765045f, 0.17356390f, 0.05017908f, -0.09501573f, -0.08370635f, 
    -0.07803514f, -0.13322049f, 0.00410983f, -0.06393132f, -0.19950892f, -0.25979421f, 0.08776239f, 0.03669878f, 
    -0.06226584f, -0.02181643f, -0.21305661f, -0.07200688f, -0.02130914f, -0.02860259f, -0.00886655f, 0.02489304f, 
    -0.31660274f, 0.16505884f, 0.08791251f, -0.21420063f, -0.21557128f, -0.14932171f, 0.05290623f, 0.07003351f, 
    -0.15257771f, 0.05903680f, -0.01622935f, 0.02520473f, -0.11224734f, -0.15541703f, -0.00527456f, 0.01437151f, 
    -0.01048230f, -0.00343941f, 0.06672662f, -0.03553708f, -0.03901745f, 0.23927349f, 0.01398466f, -0.11273275f, 
    0.11469064f, 0.07628823f, -0.01594912f, -0.00942344f, -0.10832663f, -0.04593873f, -0.42168021f, -0.10332267f, 
    -0.15356588f, 0.08796147f, 0.01069542f, 0.24172373f, -0.04663561f, -0.03983325f, 0.14329168f, -0.21978426f, 
    0.00510328f, -0.03112525f, 0.02435588f, 0.23989034f, -0.10863055f, 0.07125381f, -0.14183244f, -0.00419722f, 
    -0.05706951f, -0.17390448f, 0.04409469f, 0.25189307f, 0.08599778f, 0.02848317f, 0.04393840f, 0.05148605f, 
    -0.14069057f, -0.04973149f, 0.01883261f, -0.08134359f, 0.14992866f, 0.07672379f, -0.18007641f, 0.11785336f, 
    -0.11840628f, 0.16707155f, -0.00964202f, -0.04888865f, -0.13988677f, 0.11436296f, 0.16087955f, -0.21296765f, 
    0.03564475f, -0.07380833f, -0.12768516f, 0.07687046f, 0.21519478f, -0.01026209f, -0.00258854f, -0.14457367f, 
    -0.23154095f, 0.06266894f, 0.26004589f, -0.03023630f, 0.07557732f, -0.37014151f, 0.06261117f, 0.11519834f, 
    -0.04085078f, 0.02071595f, -0.01062114f, 0.17075187f, 0.03657762f, -0.06618646f, 0.23724481f, 0.22465202f, 
    -0.04371120f, -0.07840999f, -0.16180752f, 0.34753278f, 0.15756066f, 0.05799281f, 0.18403904f, 0.01883945f, 
    0.09783524f, -0.21878104f, 0.23327367f, 0.32822680f, 0.23557571f, 0.16979261f, -0.03755033f, 0.11292440f, 
    0.10723700f, 0.06638066f, 0.01581880f, -0.10219795f, 0.04444280f, 0.20587654f, -0.11675008f, -0.21673481f, 
    0.15242252f, -0.07971203f, 0.11578825f, -0.12467008f, 0.31765684f, 0.07697009f, 0.13268949f, -0.10666326f, 
    -0.10842518f, -0.16236313f, -0.03771003f, 0.05848408f, -0.19365959f, -0.18248883f, 0.20514122f, -0.04407820f, 
    0.14926344f, -0.20847985f, -0.05143573f, -0.20340987f, -0.00753124f, -0.20799841f, 0.13650759f, 0.09960084f, 
    0.08462720f, 0.00710020f, 0.23016872f, 0.04959285f, 0.12598811f, -0.28371307f, -0.09021596f, -0.08469105f, 
    0.02558651f, 0.00891800f, 0.04234283f, 0.24322638f, 0.00888372f, 0.09538678f, -0.07568386f, -0.13826756f, 
    -0.07227366f, 0.01938789f, -0.18786480f, -0.09183925f, 0.12870216f, -0.18129429f, 0.13884939f, 0.11208784f, 
    -0.08361286f, -0.08406259f, -0.10901579f, 0.43396637f, -0.20178746f, 0.32645744f, -0.04437265f, -0.04633149f, 
    -0.05234019f, -0.09256574f, 0.11426345f, 0.07582915f, -0.16487645f, 0.22649950f, 0.11973616f, -0.02425594f, 
    0.07475594f, -0.07773583f, 0.35335991f, 0.04416688f, 0.09248044f, 0.02418458f, 0.10791007f, -0.11159579f, 
    -0.03297706f, 0.11377025f, 0.02099042f, -0.14279391f, -0.04601498f, 0.32583347f, 0.06413279f, -0.08521066f, 
    -0.10607298f, -0.29370201f, -0.28168315f, -0.06068934f, 0.19732821f, -0.14794178f, 0.23939787f, 0.09350334f, 
    -0.06571189f, -0.00816842f, 0.26026335f, 0.01733775f, 0.00137458f, -0.11194803f, -0.03560391f, 0.10880058f, 
    -0.16935782f, -0.00673579f, 0.03568764f, 0.19006966f, -0.19595313f, 0.08408022f, -0.04470574f, 0.18655258f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.12786688f, -0.13317692f, -0.08763391f, -0.03034377f, -0.01679339f, 0.21106958f, -0.13039450f, 0.12439913f, 
    0.11917346f, -0.02331473f, -0.14511652f, 0.20355634f, -0.04097832f, 0.08486212f, 0.08066126f, 0.12516533f, 
    0.11497148f, 0.14084935f, 0.09257734f, -0.18657641f, -0.13252254f, -0.06486296f, -0.05423034f, -0.07413095f, 
    -0.04225810f, -0.00680214f, -0.05650166f, 0.23880450f, -0.06635141f, 0.14741272f, 0.34359151f, 0.06459308f, 
    0.16282244f, 0.06330852f, -0.07358414f, 0.07761236f, 0.00129885f, -0.05028230f, -0.01579127f, 0.15966259f, 
    0.15072648f, 0.01224831f, -0.04688276f, 0.18044589f, 0.03395244f, 0.16267657f, 0.06100699f, 0.10995777f, 
    -0.05815439f, -0.09877661f, 0.05693142f, 0.11175942f, 0.04266163f, -0.15509017f, 0.00184333f, 0.03001702f, 
    0.16491877f, -0.25708228f, -0.10453846f, -0.03498753f, -0.00588886f, 0.07532472f, 0.08689082f, -0.03921833f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.07058087f, -0.06005457f, 0.07134500f, -0.41357267f, 0.03946845f, -0.10737954f, -0.10037920f, -0.41726515f, 
    0.12948291f, 0.25659245f, 0.05374555f, -0.04365567f, 0.06473330f, 0.23789042f, -0.39347756f, -0.42515677f, 
    -0.21013276f, -0.22194834f, -0.24849221f, 0.16447717f, 0.06567694f, -0.13589931f, -0.32994702f, -0.11166573f, 
    0.06122044f, -0.15857388f, -0.04896898f, -0.08278054f, 0.19505738f, -0.43557993f, -0.28938845f, 0.04584767f, 
    -0.31575003f, -0.01041257f, -0.23495106f, 0.01862768f, -0.38237199f, 0.11788119f, -0.14433984f, 0.01783612f, 
    -0.23053855f, -0.31675458f, -0.13009538f, 0.13938835f, -0.02336881f, 0.10583403f, -0.61303705f, -0.23540860f, 
    0.26134363f, 0.16964307f, 0.20727257f, -0.08611302f, 0.26439652f, 0.02040686f, -0.12761402f, 0.11833066f, 
    -0.34076396f, 0.04699777f, -0.12300323f, 0.10852835f, -0.06837817f, -0.28640229f, -0.41012898f, -0.41597193f, 
    -0.05338449f, -0.04901851f, 0.10929781f, -0.43639693f, -0.06735516f, 0.10984550f, 0.10531142f, -0.32540268f, 
    -0.16529824f, -0.14336745f, -0.13386001f, 0.10391954f, -0.12151119f, 0.15356274f, 0.13059476f, -0.02716579f, 
    0.00938678f, -0.25172079f, 0.00996295f, -0.63511211f, -0.09483071f, -0.06412662f, -0.11673946f, -0.09830128f, 
    -0.00830499f, -0.00321362f, -0.02885672f, 0.22158444f, -0.09707307f, 0.27383834f, 0.01228316f, 0.11731250f, 
    -0.51240307f, -0.15921378f, -0.60756940f, -0.16512200f, 0.35730094f, -0.03417620f, -0.00539828f, 0.06734529f, 
    0.23704615f, -0.35785294f, 0.23979399f, 0.21926102f, 0.06646935f, 0.11184361f, -0.03882912f, 0.19182356f, 
    0.25490707f, 0.00397394f, 0.16860068f, 0.24022742f, 0.17019953f, -0.05906484f, -0.05979784f, -0.05575714f, 
    0.18369177f, -0.19960803f, -0.09272607f, -0.15636259f, -0.11512411f, -0.33682334f, -0.17687498f, -0.54960269f, 
    0.02586245f, 0.03058705f, -0.09337103f, -0.42057574f, -0.16325469f, -0.10950043f, -0.63473731f, 0.12234294f, 
    0.01156280f, -0.19954391f, -0.15838222f, 0.21510409f, -0.06275680f, 0.03865063f, 0.01243312f, 0.04191980f, 
    0.21058221f, 0.01924834f, -0.05433496f, -0.36796111f, -0.44318408f, -0.01235417f, -0.06768432f, -0.02901313f, 
    -0.13102564f, 0.12726727f, -0.26446363f, 0.17224997f, 0.03069976f, -0.09569940f, 0.12384355f, -0.15703519f, 
    0.16135509f, -0.02745657f, -0.05965054f, 0.16798781f, -0.19498210f, 0.04246813f, -0.03909807f, 0.21684647f, 
    -0.13945898f, 0.23255479f, -0.68588114f, 0.02912895f, 0.08156524f, -0.31774428f, 0.04343330f, 0.18083560f, 
    -0.43886545f, -0.18562254f, 0.12888327f, -0.38876250f, 0.04034629f, -0.03092163f, -0.00051779f, 0.18274379f, 
    -0.05925906f, -0.35079169f, -0.09325023f, 0.04339700f, -0.05772015f, 0.14972676f, -0.06463695f, 0.07422421f, 
    -0.52722567f, 0.05873087f, -0.03953810f, -0.12389343f, 0.03468460f, -0.23697720f, 0.13127737f, 0.04246239f, 
    -0.21258976f, 0.04211892f, 0.00848932f, -0.03928822f, -0.09551831f, 0.04839178f, -0.13015336f, -0.19080682f, 
    -0.26910135f, -0.19635092f, -0.78063148f, -0.00823702f, 0.28980997f, 0.10520069f, -0.52017206f, -0.11335043f, 
    -0.04899468f, 0.09738857f, -0.28883821f, -0.48707044f, -0.41186908f, -0.23813497f, -0.17873539f, -0.16172960f, 
    -0.09543719f, 0.17921978f, 0.00906997f, 0.13485032f, 0.02985893f, -0.02537894f, -0.23336290f, 0.15002541f, 
    0.22377826f, 0.24691482f, -0.17912191f, -0.01597516f, 0.07980739f, 0.20981236f, 0.19533028f, -0.19702686f, 
    -0.20914601f, -0.13309564f, 0.13589127f, -0.35133684f, -0.71938097f, 0.09266283f, -0.17355259f, 0.07029979f, 
    -0.09834194f, 0.27443513f, 0.10497301f, 0.07726059f, -0.09506669f, 0.16092058f, -0.16049051f, -0.00526656f, 
    0.01545336f, 0.00797850f, -0.08609740f, -0.10304164f, 0.15457791f, 0.16605867f, 0.13545987f, -0.00789304f, 
    -0.02332767f, 0.09258239f, -0.02036885f, 0.05229511f, -0.05472554f, -0.01750685f, -0.26229948f, -0.07128773f, 
    -0.22446501f, 0.25494882f, 0.17262217f, 0.06450100f, 0.09542794f, 0.11242033f, -0.04241297f, -0.09637345f, 
    -0.10214611f, -0.16394393f, 0.25567853f, -0.40083426f, -0.11826444f, 0.11999461f, -0.08882455f, -0.25225967f, 
    -0.07194620f, 0.31291991f, 0.13779123f, -0.05147723f, -0.02111834f, 0.01632785f, 0.20188996f, 0.11855958f, 
    -0.38717812f, -0.31861338f, 0.12677483f, 0.04079942f, -0.01007243f, -0.08564441f, 0.16122137f, -0.14710595f, 
    0.10773388f, -0.02913688f, 0.08400989f, -0.06684891f, -0.53955632f, -0.00383045f, 0.01900198f, 0.13373542f, 
    -0.06020598f, -0.29479471f, 0.00203725f, 0.07180255f, -0.12297884f, -0.24937165f, 0.12756489f, 0.11498298f, 
    0.09685825f, 0.05026734f, -0.00623247f, 0.29639804f, 0.21457326f, 0.10757176f, -0.06052936f, -0.35095939f, 
    -0.32085866f, -0.04665692f, -0.10152288f, 0.11175958f, 0.12712066f, 0.06676865f, 0.19566649f, -0.28478667f, 
    -0.08662809f, -0.32519132f, -0.52184451f, -0.16337861f, -0.10433270f, -0.07353801f, -0.01867642f, -0.03637946f, 
    0.24384803f, -0.03851252f, -0.01777625f, 0.08180059f, -0.06206501f, 0.05775027f, -0.09554989f, -0.00532246f, 
    0.22317477f, -0.30980951f, -0.00895309f, 0.10631351f, -0.12258210f, -0.00960418f, 0.15965551f, -0.08469283f, 
    0.03362581f, -0.42170051f, -0.19434409f, 0.08474061f, 0.21489686f, 0.01055865f, -0.52660662f, -0.18531880f, 
    -0.11067504f, 0.12191103f, -0.14541569f, 0.25283629f, -0.11618377f, -0.02846998f, -0.04079764f, 0.10430175f, 
    0.14871618f, -0.16817267f, -0.02167076f, -0.04785604f, 0.12066585f, 0.20907114f, 0.23705946f, 0.25785461f, 
    -0.22616194f, 0.00268202f, 0.04273158f, 0.18445829f, -0.26196930f, 0.31066814f, -0.73770303f, 0.30334345f, 
    0.17479342f, -0.52507961f, -0.00657760f, 0.07186852f, -0.28894386f, -0.63199866f, -0.16573393f, 0.17359240f, 
    0.18794537f, 0.17030612f, -0.15369539f, -0.02671737f, -0.26817939f, 0.05377931f, -0.03293841f, 0.05523257f, 
    -0.59406984f, -0.47339535f, -0.20578343f, 0.20566946f, 0.21771938f, -0.17671314f, -0.01356955f, 0.13339058f, 
    0.18708691f, -0.12600103f, -0.12682988f, 0.08865606f, -0.22692254f, -0.37885788f, 0.20954405f, 0.06680471f, 
    -0.22096443f, 0.16480048f, -0.07726674f, -0.81285650f, -0.21912706f, -0.36862895f, 0.17324162f, 0.10320184f, 
    -0.09065483f, -0.12363790f, -0.73451298f, 0.05917592f, -0.35530806f, 0.00013823f, -0.02950353f, -0.35879004f, 
    0.18876329f, -0.44360790f, -0.10701205f, 0.01414142f, -0.02818838f, 0.14222302f, -0.02282491f, -0.09665088f, 
    -0.18168166f, -0.09877221f, -0.02127439f, 0.17272700f, 0.23117635f, -0.24034840f, -0.34921712f, -0.19425327f, 
    -0.63860154f, 0.05376342f, 0.05924983f, -0.60514110f, -0.43411487f, -0.22716834f, 0.08790632f, -0.17977639f, 
    0.05204863f, 0.05239147f, 0.03830634f, 0.26232892f, -0.07427569f, -0.08104195f, -0.39883170f, 0.04271975f, 
    0.24648464f, -0.15567204f, -0.18487069f, 0.01688540f, -0.02498183f, 0.18439655f, 0.06066630f, -0.38867760f, 
    -0.08057483f, 0.13974507f, 0.35071504f, -0.00987121f, 0.04018576f, -0.17046069f, -0.41735333f, -0.63222378f, 
    0.01492118f, 0.22164126f, 0.19087341f, 0.12273852f, -0.32488677f, -0.27922434f, 0.16842780f, -0.60884833f, 
    -0.04886569f, 0.10977160f, -0.28225547f, -0.06715063f, -0.11333094f, 0.03417974f, -0.02245087f, -0.35367265f, 
    -0.09494075f, 0.18250704f, -0.15238215f, -0.06652814f, 0.02750843f, 0.12390063f, -0.47432259f, 0.15758479f, 
    0.20907854f, -0.05018413f, -0.00224563f, 0.24156664f, -0.27772599f, -0.26047504f, -0.53080690f, -0.30951595f, 
    -0.39314583f, -0.18478312f, -0.04698679f, -0.29282740f, 0.27484637f, -0.34546646f, 0.17950311f, 0.01339061f, 
    0.08717614f, 0.05760933f, -0.06154700f, 0.11224128f, 0.14175023f, -0.08118267f, 0.23271891f, 0.08287236f, 
    -0.16462682f, 0.16728181f, -0.03550340f, -0.08706212f, -0.33362824f, 0.05407107f, -0.13020867f, 0.17244497f, 
    0.26055926f, 0.10619836f, 0.07653744f, 0.07251259f, -0.15376821f, -0.75829440f, -0.44792715f, -0.43724856f, 
    0.13201727f, 0.06108810f, 0.00948175f, -0.34576097f, 0.10611029f, 0.26172876f, -0.16936916f, 0.13693357f, 
    -0.21666658f, -0.04261699f, -0.20023938f, -0.15797375f, -0.13681951f, -0.06229606f, 0.23796806f, -0.60598207f, 
    0.10174026f, 0.18738744f, -0.07180743f, 0.10152141f, -0.13228723f, 0.04881774f, 0.20588537f, -0.02403048f, 
    -0.24784060f, 0.06631725f, 0.02137239f, 0.16712429f, 0.20736796f, 0.07418418f, -0.32583973f, -0.00793438f, 
    0.21162440f, -0.07198508f, -0.28611070f, -0.21306741f, 0.05397066f, 0.07021928f, 0.05395496f, 0.11007204f, 
    0.03897886f, 0.33395040f, -0.21757853f, 0.30453989f, -0.59702814f, -0.07403596f, -0.10799213f, 0.02134507f, 
    -0.04580637f, -0.40170023f, -0.23167986f, 0.14250666f, -0.32634279f, -0.36095667f, 0.02260883f, -0.13961159f, 
    0.05315270f, -0.28834474f, 0.29076493f, -0.03301249f, -0.30825192f, 0.03772597f, -0.07301615f, 0.03710313f, 
    -0.09049174f, -0.07360337f, -0.06587403f, 0.13629347f, -0.48791739f, -0.46624747f, -0.08862111f, -0.17975163f, 
    -0.15046866f, -0.11101070f, -0.23574297f, 0.36195603f, -0.62579358f, 0.09095077f, -0.11489709f, -0.19516543f, 
    -0.04279699f, -0.39377594f, -0.02500981f, -0.01489364f, -0.42197874f, -0.23082539f, -0.38451642f, 0.09621153f, 
    0.13886303f, 0.08552705f, -0.11006675f, 0.24780013f, -0.63237435f, -0.24956723f, 0.20574044f, 0.33654588f, 
    0.31026205f, 0.01955058f, -0.09266196f, 0.09779102f, 0.12743244f, -0.27085078f, -0.03297350f, 0.03627046f, 
    -0.04753174f, -0.24239102f, -0.26228032f, -0.49931201f, -0.09369137f, -0.07437167f, -0.04124528f, -0.01073888f, 
    -0.43401915f, 0.08911194f, 0.32945734f, -0.09883953f, -0.69083184f, 0.06666571f, -0.30736589f, 0.16364858f, 
    0.04180376f, -0.16925277f, -0.31573945f, -0.00753398f, -0.50987798f, 0.22501877f, -0.08776896f, 0.24041937f, 
    0.15654166f, -0.24932303f, -0.33310246f, 0.26149264f, -0.07929925f, 0.25988892f, -0.32345670f, 0.32336831f, 
    0.10504754f, -0.04807166f, -0.30511224f, -0.25188640f, -0.60284519f, 0.05214232f, -0.20116876f, -0.44249299f, 
    -0.07765727f, 0.05665481f, 0.05712950f, -0.04380063f, -0.16153297f, -0.19404958f, 0.24811909f, -0.19760919f, 
    -0.09006198f, -0.17008315f, 0.03585348f, -0.07994680f, -0.00291611f, -0.11415955f, -0.11560647f, 0.29840612f, 
    0.24668175f, -0.53400457f, -0.00776844f, 0.01875288f, 0.10569327f, 0.01961317f, 0.11360032f, 0.24778050f, 
    -0.08881662f, -0.31915838f, 0.02740465f, -0.14510699f, 0.15330257f, -0.07699890f, 0.13687997f, 0.04629484f, 
    -0.27329478f, -0.09117229f, 0.09172043f, -0.00846599f, -0.59797543f, -0.15095378f, -0.13772935f, -0.09140046f, 
    0.19892173f, -0.40931216f, -0.39257208f, -0.17786659f, 0.21326776f, 0.07821655f, 0.36440805f, -0.27083620f, 
    -0.07177193f, 0.19599943f, 0.10289752f, -0.32765731f, 0.05016015f, -0.14059244f, 0.28433782f, -0.38583446f, 
    -0.17064042f, -0.11436816f, -0.36506456f, -0.15101892f, 0.04994373f, -0.08284201f, -0.14299025f, 0.10272999f, 
    -0.14874597f, 0.19556665f, 0.03390804f, 0.08836135f, -0.11642256f, -0.05015543f, 0.19276439f, -0.11869578f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.04240638f, 0.05425471f, 0.05684108f, 0.03102638f, -0.00961040f, 0.10076941f, 0.10610574f, -0.12159479f, 
    0.11063444f, -0.03716201f, 0.08868656f, -0.06187258f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
