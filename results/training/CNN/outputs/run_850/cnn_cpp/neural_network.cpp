#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.38267574f, 0.85776192f, -0.16313429f, -0.17898130f, -0.54577506f, 0.29964039f, 0.22291864f, -0.88813162f, 
    0.44167581f, 0.33596233f, 0.19911601f, -0.33791211f, -0.17635046f, 0.26730439f, -0.27786079f, -0.07394250f, 
    0.35056552f, -0.16285054f, -0.10317581f, -0.09185854f, -0.15338409f, -0.09100217f, -0.06513128f, 0.26221967f, 
    -0.17403904f, -0.20142606f, 0.48635578f, 0.63614541f, 0.47533706f, 0.31821012f, 0.54958904f, 0.36528212f, 
    -0.29124171f, -0.66166222f, -0.46078461f, 0.15551010f, -0.18369101f, 0.39210242f, 0.05294067f, -0.11284412f, 
    0.03247461f, -0.03167722f, 0.27326858f, 0.17091420f, 0.24505951f, 0.25686613f, -0.06459547f, -0.04681070f, 
    -0.20309040f, -0.13469484f, -0.70951289f, -0.52162445f, -0.25706241f, -0.15054180f, 0.61092055f, 0.43308192f, 
    -0.15805450f, -0.03274293f, -0.61780250f, -0.49522215f, -0.22858596f, 0.44238400f, 0.27589232f, 0.17523877f, 
    0.27291182f, 0.20265658f, -0.26993817f, -0.01874598f, 0.37405738f, 0.04996891f, 0.06469318f, -0.21438487f, 
    -0.17268425f, -0.16305324f, -0.29295605f, -0.63021994f, 0.61695343f, 0.63175184f, -1.01910424f, 0.62316912f, 
    0.49699941f, -0.30921781f, -0.04666668f, -0.82949167f, -0.12082233f, 0.31845644f, 0.20886016f, -0.14970240f, 
    0.00583890f, -0.27025139f, 0.22674175f, 0.07070948f, 0.00410983f, 0.00883905f, -0.06262052f, 0.01120539f, 
    -0.02190123f, 0.00495749f, -0.04718697f, 0.36884749f, -0.41746977f, -0.46735910f, 0.32099143f, 0.59268796f, 
    -0.34650996f, -0.40431723f, -0.04569079f, 0.79763615f, -0.16538560f, 0.06077798f, 0.27856228f, -0.01438251f, 
    0.38816905f, -0.33058721f, 0.14558774f, -0.38528064f, -0.08902528f, 0.25017968f, 0.39231914f, -0.29164669f, 
    -0.28563860f, -0.18071401f, 0.03568930f, -0.14225407f, -0.03038068f, -1.06747139f, 0.82252914f, 0.30259901f, 
    -0.78425860f, -0.82334483f, 0.57489020f, -0.00166493f, -0.19526775f, -0.24854943f, 0.22814520f, -0.17993401f, 
    0.33203626f, -0.18259665f, 0.41939822f, 0.23354045f, -0.40272173f, -0.02812030f, -0.27289426f, 0.00909468f, 
    0.03331963f, 0.05317411f, 0.11805112f, 0.13738766f, -0.07980464f, 0.23732100f, 1.00313294f, 0.25957447f, 
    -0.09356401f, 0.53038996f, 0.56735438f, 0.28114685f, 0.39208192f, -0.17795119f, 0.19707718f, -0.35939142f, 
    -0.34789729f, 0.17160255f, 0.03655703f, -0.20248224f, -0.17254135f, 0.04203112f, -0.10546223f, 0.28058133f, 
    0.04301535f, 0.03220548f, 0.23038693f, 0.27152750f, 0.40088329f, 0.22428828f, 0.20930822f, -0.13250865f, 
    0.24534063f, -0.71647418f, -0.59576249f, -0.48415703f, -0.50306660f, -0.14837155f, -0.15192975f, 0.39327520f, 
    -0.09057180f, 0.26008072f, -0.26920655f, -0.09344219f, 0.04338903f, -0.10651677f, 0.37372014f, 0.36464313f, 
    -0.05061631f, 0.34217522f, 0.23732397f, -0.33077493f, -0.02757957f, 0.25517011f, -0.12852739f, 0.19076875f, 
    -0.25768766f, -0.62091672f, 0.69727749f, 0.01747796f, -0.44967094f, -0.31849799f, 0.77048033f, 0.40155941f, 
    -0.30702633f, -0.41089481f, 0.31998411f, 0.22624430f, 0.30666277f, 0.33864912f, 0.23801616f, 0.10033470f, 
    -0.24454066f, -0.26889145f, -0.20737217f, 0.03772141f, -0.16859998f, -0.12599228f, -0.11720525f, -0.06948033f, 
    0.50688583f, 0.57526243f, 0.61506349f, 0.50325739f, -0.12240914f, -0.38682282f, 0.01941035f, 0.04039523f, 
    0.24618335f, 0.26084012f, 0.61567551f, 0.07421622f, 0.43419701f, -0.18575174f, -0.17552076f, -0.31958437f, 
    0.29729551f, 0.00768249f, 0.35748518f, 0.17618327f, -0.07788312f, -0.07838000f, -0.12139029f, -0.36206439f, 
    -0.36801803f, 0.31730801f, 0.63880777f, 0.79338461f, 0.72963142f, 0.44847137f, 0.34257594f, -0.13980523f, 
    -0.42609984f, 0.14044002f, -0.67762369f, 0.02379787f, -0.21728733f, -0.24311386f, 0.29265806f, 0.17018054f, 
    -0.05376790f, -0.30869094f, 0.11688218f, 0.16122669f, -0.19935100f, -0.09825821f, 0.12775335f, -0.17643811f, 
    0.13505632f, -0.02671964f, 0.06019150f, 0.55651206f, -0.13188955f, -0.60150224f, -0.62049001f, -0.23711208f, 
    -0.21433942f, -0.10020302f, 0.15730515f, 0.01780456f, -0.09510339f, 0.02381732f, -0.36034986f, 0.51221007f, 
    0.11361559f, 0.03961353f, -0.41882321f, -0.13178948f, -0.37780169f, 0.20010021f, 0.19346112f, -0.38426772f, 
    -0.20601419f, -0.37573248f, -0.24867365f, -0.08141989f, -0.08115773f, -0.85744274f, 0.13071415f, 0.74743438f, 
    0.84906614f, 0.10322089f, 0.12440141f, 0.00259739f, 0.33208650f, -0.08481936f, 0.35517547f, 0.27614391f, 
    0.00677130f, 0.17244610f, -0.21498300f, -0.26440558f, 0.11117832f, 0.36286989f, -0.11135208f, 0.28945073f, 
    0.12620734f, 0.26320255f, 0.38028237f, -0.21803102f, -0.01577974f, -1.17555833f, 0.24219966f, 0.16944070f, 
    -0.24869244f, -0.56121635f, 0.10527240f, 0.45956424f, -0.14710949f, 0.50782400f, 0.03271909f, -0.37952569f, 
    -0.05804939f, 0.17552745f, -0.21638556f, -0.11628153f, 0.16789840f, -0.02438348f, -0.05719643f, -0.23957083f, 
    -0.34977219f, 0.25284109f, 0.34338060f, 0.21695369f, 0.11601754f, 0.40885732f, -0.30124438f, -0.12356894f, 
    -0.64449704f, 0.21015176f, 0.27144521f, 0.19749802f, -0.46390969f, -0.67977673f, 0.41689825f, -0.57371682f, 
    0.05900789f, 0.17269745f, 0.01010225f, 0.31885621f, -0.18325807f, 0.21822225f, -0.10152338f, 0.35149696f, 
    -0.00166415f, 0.40151751f, 0.31227478f, 0.16892993f, -0.41729757f, 0.20868197f, 0.17140719f, -0.65529180f, 
    0.47873634f, 0.27597207f, -0.45716175f, 0.48557496f, -0.68120879f, -0.23788299f, 0.37278038f, -0.08376057f, 
    0.46428570f, -0.30291960f, 0.32465968f, -0.35651526f, -0.06561043f, 0.05911244f, -0.28845733f, -0.40409601f, 
    -0.31565973f, -0.21609670f, 0.07101561f, 0.30661374f, 0.15151228f, 0.08602533f, -0.18936671f, -0.25980839f, 
    -0.11998452f, -0.25667396f, 0.70184237f, -0.34033245f, -0.32520077f, -0.36989883f, -0.52125931f, 0.08143585f, 
    0.39511865f, -0.33516747f, -0.16097209f, -0.06319861f, 0.00168745f, 0.21407783f, -0.00233034f, 0.16423717f, 
    0.50392300f, -0.01669174f, 0.03766251f, -0.54827535f, -0.03444489f, -0.41479132f, -0.25819242f, -0.40032300f, 
    -0.02157738f, -0.60099185f, -0.11801241f, 0.62157190f, 0.40281788f, -0.18829501f, -0.89559197f, -0.30631885f, 
    -0.42021492f, -0.52084500f, -0.18281902f, -0.26623192f, 0.45398381f, 0.09625641f, -0.28255641f, -0.26673892f, 
    -0.48309129f, -0.27431741f, -0.13693185f, -0.00871014f, -0.17375629f, 0.12387760f, -0.00836362f, -0.26389527f, 
    0.06303185f, 0.32926711f, -0.11236607f, -0.37153080f, 0.01263058f, 0.96283591f, -0.52707988f, 0.04818238f, 
    -0.63293147f, -0.35194263f, 0.12087657f, -0.00165760f, -0.01827478f, -0.25602728f, -0.17549315f, -0.05697849f, 
    -0.39524549f, -0.28693530f, -0.16144079f, 0.33270016f, 0.03674760f, 0.25788927f, 0.32126212f, 0.20635256f, 
    -0.01375323f, 0.20116577f, -0.24750100f, -0.34108761f, -0.89703268f, 0.58446902f, -0.31352946f, -0.63614726f, 
    0.28465590f, 0.32158995f, 0.44926146f, -0.28202212f, 0.19297430f, -0.53781933f, -0.45309803f, -0.09732986f, 
    -0.22159483f, -0.32463312f, 0.08946519f, -0.01907394f, 0.10342091f, -0.22442222f, 0.02832930f, 0.11997157f, 
    -0.07643680f, -0.06166767f, -0.00122350f, -0.06160210f, 0.01569652f, 0.23576491f, -0.75493407f, -0.29446378f, 
    0.14975549f, 0.20649415f, 0.76199114f, 0.16620126f, -0.21036714f, 0.00796260f, 0.53907335f, -0.42507431f, 
    -0.01005410f, -0.35056835f, 0.36031395f, -0.43771091f, -0.45866024f, -0.01851386f, 0.06032563f, 0.11091956f, 
    -0.13745391f, 0.14172870f, -0.03342061f, 0.14876464f, 0.04687502f, 0.68664742f, 0.14548676f, 0.67650729f, 
    -0.21005829f, 0.06076192f, 0.63021016f, 0.20763637f, 0.34038249f, 0.16333462f, -0.13518974f, 0.22379936f, 
    0.44171536f, 0.19657797f, 0.15221946f, -0.13715637f, 0.12581177f, -0.01997490f, -0.18773463f, -0.20128709f, 
    0.24493060f, -0.35235485f, -0.33699515f, 0.12799673f, 0.08788865f, 0.12316397f, 0.36416677f, 0.37008160f, 
    -0.02949361f, -0.04645547f, 0.72905952f, -0.01729138f, 0.17436591f, -0.11816253f, -0.12262431f, -0.04977471f, 
    0.44643518f, 0.08936142f, -0.35904548f, -0.39043114f, 0.25090447f, 0.44762093f, 0.39253908f, 0.06757823f, 
    0.23665318f, 0.14247456f, 0.32920262f, 0.27972701f, -0.08406685f, 0.55423820f, 0.37053570f, 0.57161814f, 
    -0.82032114f, -0.60982060f, -0.53185040f, -0.03391463f, 0.59948957f, 0.62889713f, 0.05100986f, 0.42844093f, 
    0.24069814f, -0.12474024f, 0.01590969f, -0.40760478f, 0.01414268f, -0.32789674f, -0.04184451f, 0.19747421f, 
    -0.17205136f, 0.20001288f, -0.03600727f, -0.05421541f, 0.22681178f, -0.10701396f, 0.04171627f, 0.27453482f, 
    -0.47214523f, -0.57999438f, -0.39996895f, 0.51271063f, 0.24714874f, -0.53013527f, -0.46205959f, -0.72889775f, 
    0.05080591f, -0.45544186f, 0.27994749f, 0.26889464f, -0.10124446f, 0.10321477f, 0.00355096f, 0.21039686f, 
    0.06025213f, -0.13714594f, -0.26897880f, -0.16932805f, -0.17703508f, 0.23896217f, 0.16924986f, 0.16635701f, 
    0.15282643f, 0.70161963f, 0.55039704f, 0.66681659f, 0.56542736f, 0.61062908f, 0.72096872f, 0.13634290f, 
    0.03973010f, -0.09367342f, 0.00653914f, 0.08454715f, 0.35328943f, -0.09859999f, 0.00498094f, 0.26220748f, 
    0.35108098f, -0.09658733f, -0.15128426f, -0.00655760f, -0.06638983f, -0.22459616f, -0.06918337f, 0.45164487f, 
    -0.28311878f, -0.12928420f, 1.01251221f, -0.49979460f, 0.27631614f, 0.98730797f, 0.36419389f, -0.05367922f, 
    0.05401947f, 0.22340974f, 0.33981305f, -0.07481069f, -0.02729786f, -0.04888425f, -0.45453182f, 0.19530931f, 
    0.01352381f, 0.14330505f, 0.10093940f, 0.17888772f, 0.27295080f, 0.32635322f, 0.08289879f, -0.01545127f, 
    -0.09144104f, -0.23975284f, -0.20679504f, -0.43551803f, 0.67952597f, -0.39855465f, -0.91105336f, 0.47234422f, 
    -0.22399355f, -0.29547834f, 0.60715461f, 0.51036781f, -0.51059246f, -0.33654734f, -0.17456967f, -0.35858485f, 
    0.23842007f, 0.06853918f, 0.37768883f, -0.04727544f, 0.28318566f, 0.24232651f, 0.10026904f, -0.05586651f, 
    0.09843791f, 0.22510168f, 0.01339037f, 0.18237285f, 0.92070955f, 0.38911286f, -0.42804739f, 0.85617304f, 
    0.52794486f, 0.64098215f, 0.41774693f, -0.14501821f, 0.53940541f, 0.30380267f, -0.25590381f, -0.12853348f, 
    -0.04833021f, 0.12660085f, -0.23155570f, -0.10115962f, 0.04804292f, 0.00085886f, -0.08609897f, -0.21538642f, 
    -0.16979231f, -0.32924259f, -0.14770618f, -0.13077959f, 0.06921582f, -0.70683151f, -0.76840782f, -0.74425757f, 
    -0.13901877f, -0.00624575f, -0.44630748f, -0.36414373f, 0.27858591f, 0.18213761f, 0.11595866f, -0.17137279f, 
    0.38824794f, -0.00145885f, 0.06042183f, -0.33516914f, -0.20733699f, 0.18171164f, -0.23828092f, 0.20998368f, 
    -0.31215838f, 0.03822980f, -0.32466647f, 0.58525532f, -0.08533103f, -0.11146247f, -0.05658206f, 0.52036715f, 
    0.16937070f, 0.80056596f, 0.27223271f, 0.21997270f, 0.26861241f, 0.66163021f, 0.22168390f, 0.43875346f, 
    -0.51025271f, -0.04791520f, -0.53665435f, -0.35086402f, -0.21415606f, -0.54257065f, -0.09443095f, -0.28004313f, 
    -0.16708367f, -0.25861418f, 0.03504378f, -0.12543248f, -0.22013438f, 0.09116524f, 0.01099436f, 0.99741662f, 
    0.44750172f, 1.02925014f, -0.15180820f, -0.48524955f, 0.18082091f, -0.79256278f, 0.01021838f, 0.13856593f, 
    0.49573174f, 0.35009632f, -0.13465200f, -0.09643099f, -0.08566324f, -0.32606989f, -0.23618919f, -0.11403986f, 
    -0.09301211f, -0.22258362f, -0.37303019f, 0.31062916f, 0.16375403f, 0.22939970f, -0.08616762f, 0.01124757f, 
    -0.59321481f, 0.30438057f, -0.06727134f, -0.16546817f, -0.73109084f, 0.09230001f, -0.71395093f, -0.12918139f, 
    -0.17357610f, -0.07943135f, 0.12973544f, -0.07099740f, 0.12128406f, 0.25545585f, 0.36192310f, -0.23691170f, 
    0.36731997f, -0.15905781f, 0.16411205f, 0.15700634f, 0.31148496f, 0.58667403f, 0.03130103f, 0.31459385f, 
    -0.21107477f, -0.69788915f, -0.33563080f, -0.37952957f, -0.31066748f, -0.37985572f, 0.55362761f, 0.05967954f, 
    0.06622379f, 0.72673631f, 0.72292250f, 0.38543761f, -0.27394798f, 0.01837156f, 0.09427529f, 0.39564615f, 
    -0.01817392f, 0.05805692f, -0.08022614f, 0.07463984f, 0.17785135f, -0.32383144f, -0.13654900f, -0.09043645f, 
    0.15748513f, -0.06279571f, -0.09740911f, -0.75597751f, -0.39623156f, 0.31031367f, -0.13447861f, 0.52669632f, 
    0.27420834f, 0.34051305f, 0.54474747f, -0.61982411f, -0.55076969f, -0.13405234f, 0.39974901f, -0.17763239f, 
    -0.05469476f, -0.22389802f, -0.04291422f, -0.24194314f, 0.04043940f, 0.14645718f, -0.23404773f, 0.47900131f, 
    -0.08088177f, -0.00217346f, 0.02813355f, -0.52440631f, -0.91076231f, -0.74093032f, -0.47222978f, -0.45090726f, 
    -0.00380185f, 0.57904196f, 0.47367850f, 0.00996761f, 0.52526134f, 0.09709246f, -0.05235801f, 0.01139923f, 
    -0.33784476f, 0.13622081f, -0.10009267f, 0.18779495f, 0.13865654f, 0.24706125f, -0.11907259f, -0.17224702f, 
    -0.17789102f, -0.18808109f, -0.00458196f, 0.12923053f, -0.35276973f, 0.48702705f, -0.14022902f, -0.63066781f, 
    0.36382324f, 0.24764144f, -0.07813939f, 0.17607945f, 0.16734384f, 0.56397605f, 0.05630828f, -0.08799638f, 
    0.31629413f, -0.55639839f, 0.18048881f, -0.02385283f, -0.31510061f, -0.14333551f, -0.38031048f, -0.27057981f, 
    -0.46330151f, -0.18883540f, -0.29931983f, -0.03387407f, -0.22029452f, 0.90327579f, 0.45495120f, 0.40741885f, 
    0.45574728f, 0.54570323f, -0.13791862f, -0.04129981f, 0.16510922f, 0.14901504f, 0.16503124f, -0.52747375f, 
    -0.14025609f, 0.19017689f, -0.06103989f, 0.32597271f, 0.28415158f, 0.12762049f, 0.40485364f, -0.13617235f, 
    0.01293717f, 0.22205265f, -0.06152236f, 0.15933137f, 0.17285527f, 0.37197992f, 0.81220323f, 0.20217420f, 
    0.61407119f, 0.89415407f, 0.42473787f, -0.82474583f, 0.25833911f, -0.54019362f, 0.30166826f, 0.03683532f, 
    0.56759363f, 0.09376495f, 0.17486404f, -0.26626903f, -0.26470017f, 0.17015216f, -0.11182744f, -0.01495200f, 
    0.04460004f, 0.05138532f, -0.12132752f, -0.03599180f, 0.08487821f, -0.01879956f, 0.13110988f, -0.29610509f, 
    0.15659849f, -0.21385165f, -0.75259358f, -0.26158753f, -0.01879843f, -0.49601698f, 0.27059281f, 0.08703773f, 
    -0.57101446f, 0.20918643f, -0.11120764f, -0.09593844f, 0.11079436f, -0.58922404f, -0.23962215f, 0.31366441f, 
    -0.02345297f, -0.15481299f, 0.16814961f, 0.10440103f, 0.44734123f, 0.02242066f, 0.39579567f, 0.05855023f, 
    0.92010647f, 0.54857951f, -0.14366515f, -0.48071659f, -0.02028283f, -0.10140201f, -0.25252375f, 0.19601905f, 
    0.54806274f, 0.24209225f, 0.15196846f, -0.08470648f, -0.32067513f, 0.42243949f, 0.07714701f, 0.24994576f, 
    -0.05306495f, -0.11079238f, -0.27429220f, 0.18813959f, -0.39637956f, 0.54956329f, -0.15598632f, 0.20563285f, 
    0.16720438f, -0.43592459f, -0.33198842f, 0.32329392f, 0.61602747f, 0.03861547f, 0.40894833f, -0.13362578f, 
    0.10551201f, -0.59521627f, -0.42191797f, 0.06603621f, -0.35138479f, -0.45925987f, 0.46120977f, -0.11646670f, 
    0.09676617f, -0.38323128f, -0.53174716f, 0.21713445f, -0.24338138f, 0.00192594f, 0.06405881f, 0.23011504f, 
    0.32189089f, 0.06831064f, -1.16112733f, 0.93165922f, 0.81371069f, 0.07526790f, 0.28205889f, 0.80017751f, 
    -0.21738026f, -0.60763615f, 0.16868508f, -0.36896324f, -0.16068059f, -0.27372995f, -0.08428665f, -0.05045689f, 
    -0.28861246f, -0.00185568f, 0.09688693f, -0.22052339f, -0.29041633f, -0.08735133f, -0.07941205f, -0.01341238f, 
    -0.11961379f, 0.03806902f, -0.35340783f, -0.81344354f, -0.44354415f, -0.28954998f, -0.72522849f, -0.57613075f, 
    0.08521799f, 0.13831219f, -0.18738471f, -0.09191433f, 0.18625276f, 0.13403274f, -0.05086664f, 0.08427098f, 
    0.04825260f, -0.04113302f, 0.12376259f, 0.21601759f, -0.23183598f, 0.04899741f, -0.09284701f, -0.24975489f, 
    0.12282801f, -0.00815364f, 0.13472702f, 0.10462759f, 0.92368227f, 0.54413462f, 0.05266548f, 0.45348424f, 
    0.01044494f, -0.48137665f, -0.66183573f, 0.36461973f, 0.27914885f, 0.14104664f, -0.03562686f, -0.19618215f, 
    0.19649139f, -0.31665802f, -0.26235381f, -0.25098389f, -0.14414027f, -0.07464120f, 0.35635179f, -0.01723198f, 
    0.53024834f, 0.26897761f, -0.18858097f, -0.19266814f, -0.00788807f, 0.62011749f, 0.70285606f, -0.04900830f, 
    0.31667048f, -0.17759341f, 0.45453408f, 0.47866070f, 0.43995377f, 0.50728858f, 0.44327056f, -0.13406791f, 
    0.43200752f, 0.21449330f, -0.19310999f, 0.09186752f, -0.02641444f, -0.29573920f, -0.25537285f, 0.18793711f, 
    0.04016878f, -0.16502742f, 0.15615305f, -0.12799017f, 0.26057026f, 0.12524801f, -0.20890307f, -0.01437222f, 
    0.46030298f, -0.22648430f, -0.60616034f, 0.40981948f, -0.16870290f, 0.37072614f, 0.45062581f, -0.34452522f, 
    -0.07091572f, -0.25689197f, 0.06814887f, -0.06340814f, -0.28083950f, -0.55879080f, -0.06759156f, 0.18468054f, 
    -0.13913640f, 0.04303639f, 0.56144851f, 0.25991866f, 0.00966073f, 0.17435992f, -0.31976777f, -0.15382257f, 
    -0.75016117f, 0.35635194f, -0.03253916f, -0.14495359f, 0.28879547f, -0.63560379f, -0.33739454f, 0.29603809f, 
    -0.13871981f, 0.36487874f, 0.39654422f, -0.02651121f, -0.08340319f, 0.44615877f, 0.40253550f, -0.43959233f, 
    0.10261607f, -0.07469290f, -0.31286621f, -0.16953826f, 0.32010308f, -0.13588861f, 0.05555960f, -0.10182866f, 
    0.70810372f, 0.27625865f, -0.53203362f, -0.98560905f, -0.51438737f, -0.02626422f, 0.57612175f, 0.42110994f, 
    -0.25417683f, 0.03865112f, -0.01982976f, 0.18202803f, -0.21319306f, -0.02979332f, 0.04880386f, -0.05474928f, 
    0.14461547f, 0.25843075f, 0.10602291f, 0.14388986f, 0.28105849f, -0.34276161f, 0.28881580f, -0.24374425f, 
    0.04789820f, 0.89311707f, 0.73463207f, 0.43841034f, 0.09519387f, -0.22606532f, -0.21908170f, -0.29247424f, 
    0.13116972f, 0.04212603f, 0.24540079f, 0.09865274f, 0.22821788f, 0.01991525f, 0.24615228f, 0.27151367f, 
    0.15819637f, -0.06989528f, 0.26112226f, -0.24913456f, 0.17521925f, -0.14377032f, 0.46252361f, 0.12814902f, 
    0.03358121f, -0.08809750f, -0.30084807f, -1.06637037f, -0.12949459f, 0.20858623f, -0.30324188f, 0.01940116f, 
    0.04797347f, 0.77984989f, -0.70416343f, 0.03824241f, -0.00977237f, -0.02586955f, 0.47283006f, 0.17289688f, 
    0.31673238f, -0.22526740f, 0.07788923f, -0.07564980f, -0.31188574f, 0.11549239f, 0.25290790f, 0.07565796f, 
    -0.24695496f, 0.01729519f, -0.22837839f, 0.05384351f, 0.22354676f, 0.14237355f, -0.16540584f, -0.66145873f, 
    -0.06091478f, -0.27656999f, 0.11527155f, 0.35036665f, -0.41237253f, 0.24162151f, -0.48525906f, -0.48991048f, 
    -0.26695615f, -0.16711330f, -0.00673526f, -0.25689322f, 0.03105648f, -0.18746619f, 0.15200524f, -0.21403241f, 
    -0.25667101f, -0.10749950f, -0.31492981f, -0.37298012f, 0.69577980f, 0.38977399f, -0.18237492f, 0.98831582f, 
    0.79630911f, 0.50995344f, -0.04806221f, -0.10587554f, 0.14351347f, 0.11890621f, 0.02719443f, -0.09347944f, 
    -0.17295153f, -0.08475893f, -0.06419481f, 0.00104671f, -0.21699861f, 0.17009188f, -0.36743915f, 0.03314624f, 
    0.31615618f, 0.34310955f, 0.23265892f, 0.02915387f, 0.03555145f, -0.71643794f, -1.06209326f, -0.61001158f, 
    0.28453508f, 0.24816222f, -0.01025741f, 0.81316829f, 0.45759892f, -0.19086893f, -0.08879337f, 0.17277832f, 
    -0.19444905f, 0.28885713f, -0.34017831f, 0.05778652f, -0.28662366f, 0.29108453f, -0.18683550f, -0.26308119f, 
    -0.05620801f, -0.09580396f, -0.25913149f, -0.05839863f, -0.03802665f, 0.06216630f, 0.08807008f, 0.14510007f, 
    -0.82683873f, -0.87357420f, -0.45799145f, 0.43425819f, -0.28012821f, -0.06753775f, 0.48587143f, 0.28574362f, 
    -0.41194883f, -0.47961932f, 0.01556605f, -0.00295918f, -0.15402973f, -0.07437431f, 0.01974961f, 0.14460424f, 
    -0.04823529f, 0.09213489f, 0.17510788f, -0.09160145f, 0.09202089f, 0.05694063f, 0.07115618f, 0.82574791f, 
    -0.12084050f, -0.39681834f, -0.79816824f, 0.16054866f, 0.58250427f, -0.46483997f, -0.59688419f, -0.46108261f, 
    -0.10567051f, -0.52136916f, -0.08625029f, 0.04705797f, -0.10565585f, -0.17413981f, -0.39913511f, -0.02525670f, 
    0.04815254f, -0.17033656f, -0.25415629f, 0.36270225f, 0.25371316f, -0.02155501f, -0.15984531f, 0.39370161f, 
    -0.41690764f, -0.71435946f, -0.51002485f, -0.35846430f, -0.47779727f, -0.16148658f, 0.79787308f, 0.45329660f, 
    -0.05379031f, 0.45708993f, -0.39029488f, 0.08153128f, -0.26257840f, -0.12077545f, -0.08289358f, -0.13320556f, 
    -0.01727084f, 0.00152984f, -0.00136097f, 0.04643240f, 0.16154061f, -0.07474548f, 0.19038919f, -0.09988231f, 
    0.34832138f, -1.18127775f, 0.47167510f, -0.71270603f, 0.51458335f, -0.54072654f, 0.17726928f, 0.96735489f, 
    -0.67329013f, 0.32401741f, 0.36213252f, -0.10069018f, -0.20754440f, 0.28208545f, -0.27937186f, 0.15343818f, 
    0.16147108f, 0.08797862f, 0.12129699f, 0.21873672f, -0.11970248f, 0.19807494f, -0.00040219f, -0.04321272f, 
    0.02144890f, 0.05243133f, 1.06852114f, -0.29568884f, -0.65579176f, -0.56976163f, -0.35144567f, -0.21039534f, 
    0.31571800f, -0.04999249f, -0.20424908f, -0.15748832f, 0.03325810f, 0.28469035f, 0.17019056f, -0.23532590f, 
    0.00523445f, -0.14599377f, -0.08738236f, -0.14772363f, 0.11346930f, -0.14319724f, 0.20901012f, -0.00750953f, 
    0.23152208f, -0.33465958f, 0.11093938f, -0.72675228f, 0.34603438f, 0.54733860f, 0.03361302f, 0.04274590f, 
    -0.89525867f, 1.07749629f, -0.32273132f, -0.57045615f, 0.01673284f, -0.38891923f, 0.15583430f, 0.22581419f, 
    0.28263229f, -0.05576404f, 0.09124832f, -0.28646764f, -0.10509542f, 0.16249047f, 0.03521731f, -0.06015900f, 
    0.12539929f, 0.28657529f, 0.46759397f, -0.20884725f, -0.59275538f, 0.78294510f, 0.04817775f, -0.83162618f, 
    -0.50617760f, 0.74824297f, 0.34270987f, -0.71652400f, 0.49543846f, 0.01955898f, 0.10171509f, -0.01675065f, 
    -0.24349307f, -0.06909486f, 0.03784167f, -0.02870304f, -0.04471598f, 0.15177941f, -0.14319865f, 0.01999701f, 
    0.05908867f, -0.33739063f, -0.14913298f, 0.04257375f, -0.26563135f, 0.53859234f, 0.17463760f, -0.27721083f, 
    -0.06081881f, 0.46465135f, 0.77189070f, 0.29786959f, -0.76452267f, -0.02162297f, 0.02858141f, -0.44180435f, 
    0.14572866f, -0.15001062f, 0.24193440f, 0.21067472f, -0.28180167f, -0.02234972f, -0.11228719f, 0.16032863f, 
    0.14538643f, 0.26794285f, 0.02559852f, 0.02289844f, -0.34128946f, -0.04151379f, 0.02316019f, 0.39906693f, 
    0.64071071f, 0.48863411f, -0.23144276f, -1.15057361f, -0.19132529f, -0.60585833f, -0.64569545f, -0.49907246f, 
    0.63564861f, 0.35918811f, -0.35662076f, -0.00161243f, -0.13024813f, 0.12734547f, -0.49430442f, -0.21237694f, 
    -0.01504707f, -0.33925167f, 0.04998876f, 0.02615596f, 0.04490207f, -0.07043056f, -0.39772928f, -0.11154686f, 
    -0.52122849f, -0.40768749f, 0.71116543f, 0.10335568f, 0.66482657f, 1.09398580f, 0.18294640f, -0.22166362f, 
    0.25159571f, 0.07531030f, -0.30712464f, -0.07529429f, -0.16787392f, -0.04534514f, -0.21794456f, 0.20017529f, 
    -0.32533431f, 0.17383222f, -0.06085070f, 0.22317572f, 0.19636039f, -0.12708260f, -0.03449930f, -0.10750481f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.04452198f, -0.03087372f, 0.30636752f, 0.17745844f, 0.06510318f, 0.11236010f, 0.14726451f, 0.15765017f, 
    -0.02149102f, 0.24321415f, 0.15304329f, -0.08735057f, 0.25607085f, -0.01898020f, 0.18717556f, 0.32924595f, 
    0.19962123f, 0.11806164f, 0.27887523f, 0.09609211f, 0.02562128f, 0.18539362f, 0.15521125f, 0.15045856f, 
    0.22339143f, 0.17037274f, -0.02897225f, 0.06636692f, 0.12333627f, 0.12975846f, 0.09789801f, 0.20731154f, 
    0.11266604f, 0.12675022f, 0.10904766f, 0.11943961f, -0.00605235f, 0.34603652f, -0.12706266f, 0.25527638f, 
    0.28561988f, 0.20465903f, -0.03315137f, 0.04085688f, 0.03271950f, -0.11277118f, 0.15142781f, 0.09729681f, 
    0.12136079f, 0.25655079f, 0.20519908f, -0.11956601f, 0.19466785f, 0.09217575f, 0.14788434f, 0.12657836f, 
    0.20028760f, -0.10997369f, 0.01484176f, 0.12886699f, -0.08514599f, 0.12288878f, 0.21546447f, -0.00639419f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05749409f, 0.04307321f, -0.08014784f, -0.06326419f, -0.01706839f, 0.04447680f, -0.04625113f, -0.01885470f, 
    -0.06033729f, 0.10025787f, 0.00655819f, 0.01252815f, -0.08020764f, 0.10154804f, 0.01055169f, -0.00654001f, 
    -0.08368973f, -0.01139799f, 0.02595995f, -0.04991684f, 0.02863129f, -0.05671399f, -0.00863097f, 0.00301671f, 
    -0.33033597f, -0.10917285f, 0.05333072f, -0.01221435f, 0.08363598f, 0.08237833f, -0.08458684f, -0.00171289f, 
    0.03828460f, -0.02120779f, 0.00349647f, -0.08158775f, -0.63431102f, 0.09660460f, 0.18726394f, -0.35461083f, 
    0.01031872f, -0.03011097f, 0.02842041f, -0.00428060f, 0.07346586f, -0.02585239f, 0.08805513f, 0.01456938f, 
    -0.26693603f, 0.03281672f, -0.11211081f, 0.14851698f, 0.01422161f, -0.02635631f, 0.07496180f, -0.01017919f, 
    0.11474226f, 0.03959131f, -0.04439748f, 0.08305866f, 0.10237764f, 0.11012213f, 0.08097003f, -0.09523346f, 
    0.02737244f, 0.01172119f, 0.00052919f, -0.01480897f, 0.02554084f, -0.09270543f, -0.00019744f, 0.06684748f, 
    0.13513954f, 0.04961671f, -0.05258692f, 0.06158514f, -0.02792656f, -0.02179015f, -0.05300415f, 0.05733119f, 
    -0.13839081f, -0.00561748f, 0.03839471f, -0.07283008f, 0.02225286f, -0.07017718f, 0.07323354f, -0.22278699f, 
    -0.10407048f, -0.07771098f, -0.02023888f, 0.00422826f, 0.04244429f, -0.01664864f, -0.00690594f, -0.01382414f, 
    -0.17795227f, 0.01589006f, 0.11857441f, 0.13311662f, -0.08059361f, 0.06498117f, 0.03406182f, 0.01815663f, 
    0.09206513f, 0.09577867f, -0.02345988f, 0.06024731f, -0.00339459f, 0.07546166f, -0.04573143f, -0.07492707f, 
    0.02731501f, -0.00401883f, 0.01255238f, 0.00907176f, -0.00518749f, 0.04543120f, -0.12207799f, -0.06272577f, 
    0.03586739f, 0.08891080f, -0.01318803f, -0.11028067f, -0.13760714f, -0.11152910f, 0.03994284f, 0.02331068f, 
    -0.08046317f, -0.04367455f, -0.08699599f, 0.02923334f, -0.22579505f, -0.23428170f, 0.09626946f, -0.21558169f, 
    0.04632590f, 0.02465362f, 0.02256785f, 0.00963552f, -0.00565374f, -0.05843700f, 0.02123245f, 0.17787535f, 
    0.02924923f, 0.06787845f, -0.25868860f, 0.09096786f, 0.06851026f, 0.04437967f, 0.00706794f, 0.08209436f, 
    -0.06717292f, 0.10752378f, -0.10044410f, -0.09478282f, 0.50479543f, 0.15885757f, 0.05306857f, -0.01844933f, 
    -0.00126017f, 0.06781226f, -0.02510573f, -0.05106000f, 0.11099628f, -0.01794708f, -0.06889830f, -0.02462685f, 
    -0.26230747f, -0.03749076f, 0.09403572f, 0.04029952f, -0.04761560f, -0.05766783f, 0.11884503f, 0.00688902f, 
    0.15304448f, -0.05778060f, -0.04666730f, 0.07541028f, -0.15354185f, -0.06517734f, 0.03366886f, -0.01416625f, 
    0.05230948f, -0.00595129f, -0.02612270f, -0.06145639f, 0.00863341f, -0.15704808f, 0.11579297f, 0.07256513f, 
    -0.09921753f, 0.01403163f, -0.08756835f, 0.13398845f, -0.08137426f, -0.04820371f, 0.13314441f, -0.02890612f, 
    0.02450372f, 0.07068003f, 0.01766762f, -0.11611919f, -0.17159703f, 0.08065325f, -0.06767602f, 0.24813110f, 
    -0.13858105f, 0.04374603f, -0.00173832f, -0.14017755f, -0.03662402f, -0.03233123f, -0.12468816f, 0.04867411f, 
    0.03194400f, -0.00566379f, -0.25771981f, 0.21872124f, -0.02815011f, 0.06094805f, -0.02953544f, -0.04084708f, 
    0.02637540f, -0.08864072f, -0.04153735f, 0.02242389f, 0.01858161f, 0.09777735f, 0.10457067f, -0.00725035f, 
    0.03327445f, 0.03013710f, 0.00551053f, 0.01898758f, -0.06643787f, 0.06624210f, -0.09208985f, -0.00657399f, 
    -0.06246178f, 0.10884934f, 0.09195050f, -0.15967841f, -0.08967741f, 0.02136414f, 0.10553595f, 0.00951987f, 
    0.06330370f, 0.01962402f, -0.02732068f, 0.06662529f, -0.02977654f, -0.06050229f, 0.00990071f, -0.14433698f, 
    -0.06266144f, 0.01983554f, -0.02686473f, 0.03375886f, 0.05588259f, -0.03910567f, -0.00855277f, 0.00269039f, 
    -0.00214079f, -0.00754675f, 0.07655159f, -0.09820928f, 0.02844643f, 0.01815959f, 0.00389559f, 0.06773538f, 
    0.08450162f, -0.01323935f, -0.00900273f, 0.00260684f, 0.07536788f, 0.08509721f, 0.03551972f, -0.21483201f, 
    0.08614346f, -0.03441370f, 0.11803448f, -0.10206233f, -0.11293780f, 0.07646379f, -0.00369326f, -0.00899276f, 
    -0.13803130f, -0.22312860f, -0.04721729f, 0.14965770f, 0.03698197f, -0.08262283f, -0.01360536f, 0.02832764f, 
    0.00868554f, -0.10867991f, -0.01195792f, -0.10122397f, 0.07036550f, -0.08982275f, -0.02279725f, -0.01938385f, 
    -0.19832943f, -0.00680070f, 0.00698983f, 0.10708924f, -0.04995735f, -0.03335868f, 0.01007172f, -0.08295610f, 
    0.25119224f, -0.09716846f, -0.18354879f, 0.32321757f, -0.10932814f, 0.05209987f, 0.00936619f, 0.06007893f, 
    -0.01552620f, -0.04773721f, 0.04545588f, 0.07288953f, -0.01030774f, 0.12259627f, 0.02779444f, -0.22814988f, 
    -0.02689918f, -0.06430814f, -0.05334017f, 0.03477169f, -0.03573394f, 0.05732004f, 0.08137525f, -0.02043424f, 
    0.01860111f, -0.04032783f, 0.03648187f, 0.30179140f, -0.18964712f, 0.03986296f, 0.05043082f, 0.06820872f, 
    -0.02461147f, 0.04320261f, -0.03082005f, 0.02368043f, -0.25143272f, -0.03824046f, -0.13676077f, -0.02435579f, 
    -0.01607171f, -0.02681298f, 0.10226302f, 0.03942576f, -0.03057115f, -0.00823791f, 0.00544269f, -0.13989523f, 
    0.02118128f, 0.07271428f, 0.00659425f, 0.13109915f, -0.11688609f, 0.04794533f, 0.03395752f, -0.03893847f, 
    -0.04733116f, -0.08972403f, 0.00600419f, 0.06699283f, 0.02708990f, -0.01966533f, -0.01698068f, -0.07814121f, 
    -0.10284735f, -0.12693714f, -0.00338174f, -0.07436838f, -0.15008964f, -0.00977407f, -0.03638843f, -0.06437398f, 
    -0.23363045f, -0.05448119f, -0.13715492f, 0.05862090f, -0.06023884f, 0.12674391f, 0.02187520f, -0.00813726f, 
    0.04377228f, -0.00616784f, 0.05852043f, 0.00618289f, 0.23558743f, -0.04321075f, -0.16161703f, -0.14687315f, 
    0.08006425f, -0.00883268f, 0.03243792f, -0.01630704f, -0.07855109f, 0.02020515f, -0.03984946f, 0.10740711f, 
    0.02451303f, 0.11154301f, -0.15865304f, 0.02052442f, 0.03179926f, -0.00635370f, 0.15665469f, -0.03033682f, 
    0.04047681f, 0.00151509f, 0.03697364f, -0.07966854f, -0.01067058f, 0.07694003f, -0.01584243f, -0.35706320f, 
    0.09167644f, 0.07177126f, 0.00460584f, -0.00136410f, 0.05645119f, 0.01751612f, -0.04955339f, 0.06990659f, 
    0.17005157f, -0.14980599f, 0.05648760f, -0.10182222f, -0.12145425f, -0.03583595f, 0.10414212f, 0.01616307f, 
    0.01390228f, -0.03618314f, -0.00854495f, -0.02756507f, 0.10766198f, -0.00724171f, -0.12840895f, 0.07578905f, 
    -0.08484527f, -0.10037176f, 0.01133442f, 0.04402231f, -0.03599025f, 0.07514707f, 0.01706747f, -0.06130114f, 
    0.19183929f, 0.01950508f, -0.06886100f, 0.33997062f, -0.15888466f, -0.05465124f, -0.07866876f, 0.10796086f, 
    0.11949213f, 0.07157503f, -0.05784649f, -0.12151879f, -0.26310694f, -0.06212613f, -0.02698732f, -0.08704491f, 
    -0.09774172f, 0.10942150f, 0.08959875f, -0.05686031f, 0.00512338f, 0.00180289f, -0.00785478f, -0.09391868f, 
    0.08985800f, -0.14343391f, 0.02483523f, -0.31609327f, -0.06457561f, 0.00210082f, -0.02621373f, -0.03370107f, 
    -0.03660681f, 0.00187436f, -0.03059317f, 0.00618112f, -0.08301178f, 0.05861783f, -0.07648025f, 0.06980311f, 
    0.03008960f, 0.05809570f, -0.01507576f, -0.05968917f, -0.02174810f, -0.06734718f, 0.09750323f, -0.08972993f, 
    -0.19336841f, -0.03017928f, 0.15757711f, 0.11355025f, -0.04112133f, -0.17852640f, 0.07155883f, -0.18487608f, 
    0.03716568f, -0.00654205f, -0.04507873f, 0.09665581f, 0.08684874f, -0.09790286f, -0.00803180f, -0.18444118f, 
    -0.04910340f, 0.11305771f, -0.02903945f, 0.03328265f, 0.02641924f, 0.00028596f, -0.07544612f, -0.03454465f, 
    0.10443378f, 0.01656184f, 0.09441418f, -0.01154981f, 0.04344196f, 0.01190908f, -0.08456231f, 0.00385413f, 
    -0.08105128f, -0.10478098f, -0.02193738f, 0.06494863f, 0.03823008f, -0.04084625f, -0.12950310f, 0.01555277f, 
    0.02270895f, -0.02404895f, 0.06777963f, 0.01672984f, -0.07115616f, 0.01383974f, 0.07901505f, 0.02672991f, 
    0.01343941f, -0.03398167f, -0.03380708f, 0.11384660f, 0.05472443f, 0.07759116f, -0.05762663f, -0.09639847f, 
    -0.12366667f, -0.03224361f, -0.06132673f, 0.09326513f, -0.08683725f, -0.15500923f, 0.02173636f, 0.11260927f, 
    0.02513066f, -0.02255961f, -0.05385161f, -0.09501413f, -0.06482050f, 0.00455825f, 0.00448460f, -0.07867977f, 
    -0.19301124f, 0.03662737f, 0.05529990f, -0.37553301f, -0.03742381f, 0.01265522f, 0.00926487f, -0.01991843f, 
    -0.08105762f, -0.06164785f, 0.02897629f, 0.08392680f, 0.14099324f, -0.00389206f, -0.05828739f, -0.19904599f, 
    -0.14694321f, -0.06781815f, -0.12792568f, 0.05641773f, -0.07089869f, 0.00893436f, -0.11361853f, 0.02105402f, 
    -0.29862961f, -0.01100557f, 0.01275692f, 0.05087596f, 0.01489361f, 0.01684846f, -0.14876854f, -0.05818677f, 
    0.02739422f, -0.12557715f, -0.00736699f, -0.04691318f, 0.11633325f, 0.05152836f, -0.11183126f, 0.12438691f, 
    -0.21687786f, 0.10487213f, -0.07395931f, 0.00262293f, -0.00479596f, 0.02594919f, 0.02163238f, -0.04804642f, 
    0.14419043f, 0.04532664f, 0.08234601f, 0.29176807f, -0.18147545f, 0.10382564f, 0.00283279f, -0.00088362f, 
    -0.09732249f, 0.01969351f, -0.00763433f, -0.10056218f, -0.24982831f, 0.22249781f, -0.05836417f, -0.00810928f, 
    0.05604349f, 0.03543768f, -0.00139464f, 0.05794355f, -0.02079288f, 0.08126114f, -0.04301415f, -0.01631964f, 
    0.21558981f, -0.07568746f, -0.13785224f, -0.32972029f, -0.00136262f, 0.08349490f, 0.09840634f, -0.03162704f, 
    -0.03256998f, 0.05258755f, 0.05795179f, 0.04196786f, 0.11822319f, -0.16961581f, 0.15956549f, -0.31439111f, 
    0.04398509f, -0.04178165f, 0.07686536f, 0.07761925f, -0.13544343f, -0.01456593f, -0.00838555f, 0.02540138f, 
    0.02640963f, 0.02872539f, 0.00132112f, -0.33615953f, -0.00274937f, 0.08322095f, 0.05932226f, 0.03155063f, 
    0.05787224f, -0.02152834f, -0.00379045f, 0.08334578f, 0.77741838f, 0.18587390f, 0.09482411f, -0.11197684f, 
    0.02377476f, 0.02818097f, -0.08921079f, -0.09058432f, 0.12272144f, 0.00740842f, -0.08597971f, 0.04514263f, 
    -0.36648852f, -0.16069818f, 0.16837510f, -0.17278981f, -0.10498421f, -0.09133581f, 0.05396961f, -0.06024541f, 
    -0.06492130f, 0.03132125f, -0.03629963f, -0.01165380f, -0.06501748f, -0.01863766f, 0.09440271f, 0.13941488f, 
    0.06616104f, 0.01739430f, -0.09222747f, 0.02529553f, 0.01352349f, -0.01115568f, -0.01587339f, -0.03016786f, 
    0.42800775f, 0.06754949f, 0.01969505f, -0.13380679f, -0.10016214f, 0.06928214f, 0.11718596f, -0.02482792f, 
    -0.02424610f, 0.06646281f, 0.01166635f, -0.02675396f, 0.01799607f, -0.12898725f, 0.09885269f, -0.03696822f, 
    -0.02852678f, -0.05985888f, -0.00722228f, 0.04966870f, 0.03993824f, 0.01266291f, 0.01589903f, 0.08308211f, 
    0.00942155f, 0.18017572f, -0.12692101f, 0.23633011f, -0.03751210f, -0.15970729f, -0.03637062f, -0.08817931f, 
    -0.04450359f, -0.02841053f, 0.03612774f, -0.12737291f, -0.02481295f, 0.30650926f, 0.09097248f, 0.09666084f, 
    -0.03130466f, 0.08346481f, -0.06258912f, -0.08239353f, 0.01980232f, 0.07546008f, -0.03173069f, 0.03077911f, 
    -0.13144921f, 0.02431815f, 0.01892912f, -0.10232963f, -0.11554153f, -0.10325082f, -0.01361743f, -0.12727161f, 
    -0.10204131f, -0.00613253f, 0.03334410f, -0.05246657f, 0.04236856f, 0.09527461f, -0.01728773f, 0.15395063f, 
    -0.04570302f, 0.06652516f, -0.04370427f, -0.08221847f, -0.02189499f, -0.01956960f, 0.05264882f, -0.00662110f, 
    0.27497602f, 0.10092852f, -0.08056349f, -0.07347067f, -0.02509192f, -0.00139144f, -0.03433084f, -0.04905894f, 
    -0.04446935f, 0.01651254f, 0.01314107f, 0.10495964f, 0.27886999f, 0.00693950f, -0.25880903f, -0.27199155f, 
    -0.09506476f, 0.04894770f, 0.01040692f, 0.04638755f, 0.02891015f, 0.16915493f, -0.02967301f, -0.00858442f, 
    -0.09969129f, 0.03079098f, -0.08831801f, 0.08430459f, -0.09599870f, -0.08291552f, -0.15108328f, -0.03558840f, 
    -0.07481142f, -0.17271568f, 0.06435598f, -0.01426237f, -0.50954032f, -0.00270992f, -0.15214819f, -0.06630315f, 
    -0.05033769f, 0.06812415f, 0.08462088f, -0.06031881f, 0.03110957f, 0.11581964f, -0.04358363f, -0.12987299f, 
    0.20882660f, -0.03457122f, 0.17920806f, 0.20364472f, -0.15832022f, 0.00139415f, 0.02424669f, 0.00691179f, 
    -0.00538615f, 0.05938721f, 0.02401444f, 0.13031144f, 0.01406163f, -0.04497698f, -0.04934272f, -0.15663220f, 
    0.04268824f, 0.03255736f, 0.04531460f, 0.12166537f, 0.01978576f, 0.03703360f, 0.04164939f, 0.09216895f, 
    -0.26418763f, 0.11054138f, 0.00475836f, -0.01388820f, -0.10307793f, -0.04993539f, 0.01411202f, -0.03425599f, 
    0.02074095f, -0.13040113f, -0.05709838f, -0.09683061f, 0.12679857f, 0.04342378f, 0.03312954f, -0.00856013f, 
    -0.03828231f, -0.16825344f, -0.02736630f, -0.06653363f, 0.05053034f, -0.08922035f, 0.10839584f, -0.02305897f, 
    0.25135025f, 0.03966711f, -0.04081462f, 0.20476395f, -0.05773767f, -0.03735507f, 0.04909735f, -0.02377990f, 
    0.06497823f, -0.06744435f, 0.03110547f, -0.03483535f, 0.23362763f, -0.17480046f, 0.03120542f, -0.09529939f, 
    -0.00989216f, -0.19143969f, -0.07821819f, -0.13417427f, -0.15925756f, -0.01299717f, -0.00755063f, -0.08207555f, 
    0.14764942f, -0.07669654f, 0.04718623f, 0.10854869f, 0.00970430f, 0.05936383f, 0.01586038f, 0.05613197f, 
    -0.02371013f, -0.04547528f, 0.18193386f, -0.03894779f, -0.58370996f, -0.16178156f, -0.08547694f, -0.12675580f, 
    0.09684907f, -0.03325541f, 0.02932663f, 0.09987187f, 0.07943421f, -0.14551795f, 0.08342207f, 0.02188942f, 
    -0.00129241f, -0.15251182f, -0.08572981f, -0.06083708f, 0.03184499f, 0.07205360f, 0.00785063f, 0.13415594f, 
    -0.06472751f, 0.10082097f, 0.03576471f, -0.05582605f, -0.02523773f, -0.00634226f, 0.01723991f, -0.20043048f, 
    0.08944622f, 0.03554251f, 0.04074784f, 0.09668538f, 0.00030046f, 0.00401180f, -0.14576054f, -0.12442627f, 
    -0.25122949f, 0.08178851f, -0.02859247f, 0.07156006f, 0.01404752f, 0.07786600f, -0.07740937f, -0.04955320f, 
    0.00681446f, 0.00511075f, -0.05590101f, 0.05131387f, -0.19114944f, -0.18198895f, -0.21253525f, -0.15993044f, 
    0.03308673f, 0.06746607f, -0.11205895f, 0.12118328f, -0.04018775f, 0.06060772f, 0.05538188f, -0.22001350f, 
    -0.33826318f, 0.04390686f, -0.26263297f, 0.05901379f, 0.09430366f, -0.08941434f, 0.11155488f, 0.14748943f, 
    0.05819437f, -0.00656179f, -0.01660326f, -0.00539915f, -0.25407115f, 0.07336224f, -0.06192773f, 0.14976646f, 
    0.09971686f, -0.01474063f, -0.06377405f, -0.02912320f, 0.06409293f, 0.10985424f, -0.01238251f, 0.05771125f, 
    0.30807838f, 0.01957764f, -0.08105221f, -0.15894870f, -0.12513001f, 0.04663521f, -0.00159294f, -0.03161338f, 
    -0.02661937f, -0.17531526f, -0.11310018f, -0.03305737f, 0.02285167f, 0.10070243f, 0.08335122f, 0.02265228f, 
    -0.11195651f, -0.07144822f, 0.02053807f, -0.11899127f, -0.04083596f, -0.01444374f, 0.01362130f, -0.04506095f, 
    0.12560274f, 0.06574365f, -0.05541574f, 0.04232518f, -0.18671174f, 0.00024282f, -0.06689039f, 0.00019277f, 
    0.03857535f, 0.11485147f, -0.01564879f, 0.05398150f, 0.27584907f, -0.36225548f, 0.05064007f, -0.17621684f, 
    0.09591641f, 0.01222647f, -0.19624025f, 0.06659330f, 0.10059131f, 0.02494175f, 0.00814279f, -0.01501139f, 
    -0.00821470f, -0.02235642f, -0.09567459f, -0.12390672f, 0.11463062f, 0.07380846f, 0.02589839f, 0.10012491f, 
    -0.04334078f, -0.00196253f, 0.10121252f, 0.11553787f, 0.13627326f, 0.06280558f, 0.18606475f, 0.09851594f, 
    -0.07116087f, -0.03060655f, -0.00905893f, -0.04248445f, 0.01929957f, -0.07416128f, -0.05330353f, 0.11873666f, 
    0.29120025f, -0.09875592f, 0.11405387f, 0.13298711f, -0.06528559f, -0.05721314f, -0.02433208f, 0.00855118f, 
    0.07215253f, 0.09954844f, -0.05244488f, -0.00739682f, -0.34835279f, -0.03185811f, -0.00099979f, -0.30111718f, 
    -0.00150569f, 0.05088856f, 0.00851799f, 0.10341101f, 0.11074621f, -0.00579323f, 0.00015425f, 0.03217591f, 
    0.21032566f, -0.08809327f, -0.03914175f, 0.06287231f, 0.04707106f, -0.00380216f, -0.15947828f, 0.01586755f, 
    0.03610618f, -0.02229043f, -0.00289411f, -0.02084406f, 0.17098014f, 0.03823213f, 0.06557741f, -0.02011453f, 
    -0.03766110f, -0.23965156f, -0.01660042f, 0.13191897f, 0.02930068f, -0.20328863f, 0.01808026f, 0.10638791f, 
    0.17649353f, 0.09911851f, -0.01098022f, 0.24891539f, 0.08103431f, 0.05433427f, 0.02982105f, -0.01909302f, 
    0.06829364f, 0.10920684f, 0.04664949f, -0.09735015f, 0.03391117f, 0.13747124f, 0.11538712f, 0.08429925f, 
    -0.09516633f, 0.05180575f, 0.09092999f, 0.04925621f, -0.00955733f, -0.16038395f, 0.06365260f, -0.03702844f, 
    -0.24001390f, 0.04641669f, 0.02322857f, 0.02103620f, 0.13020299f, -0.11559269f, -0.03364395f, 0.05203360f, 
    0.02086144f, 0.01581526f, -0.10057371f, 0.05498420f, -0.09424717f, 0.05632763f, 0.02555840f, -0.06118809f, 
    0.14930008f, -0.08027562f, -0.04846711f, 0.04240781f, -0.02353099f, 0.02145846f, -0.03083259f, 0.12069172f, 
    -0.09402092f, -0.03585842f, -0.14371996f, 0.00808778f, -0.01914834f, -0.00695026f, -0.04493933f, -0.09925113f, 
    -0.02419416f, 0.08774223f, 0.06439444f, 0.03047475f, 0.28195760f, -0.08568893f, -0.07611090f, -0.04870133f, 
    -0.03373374f, 0.04584124f, 0.05810353f, 0.01122373f, 0.01293528f, -0.02155863f, -0.00347794f, 0.01993096f, 
    0.00875303f, 0.07376654f, 0.06670639f, -0.10516565f, 0.01553036f, 0.04569519f, -0.10094099f, 0.03786713f, 
    0.03591814f, -0.10802168f, -0.10461228f, 0.04499871f, 0.19928659f, 0.02131151f, 0.04774356f, 0.16014327f, 
    -0.08538520f, 0.02847412f, -0.01448422f, 0.05054382f, 0.06561466f, -0.07524675f, -0.08401208f, -0.00533067f, 
    0.31963339f, -0.22224055f, -0.01104235f, 0.23610696f, -0.00879561f, -0.04905300f, 0.03686060f, -0.04868983f, 
    -0.00161985f, 0.00726679f, -0.03794220f, -0.05086706f, -0.07366151f, -0.08632874f, -0.09962424f, -0.25474790f, 
    -0.02422453f, -0.06549866f, -0.01700669f, 0.04679972f, 0.12164982f, -0.02418906f, 0.01615796f, 0.00768839f, 
    0.16421956f, -0.03540705f, -0.04969985f, -0.02254708f, 0.17034200f, -0.11263991f, -0.00873224f, 0.01609437f, 
    -0.05778859f, 0.02248755f, 0.07885098f, 0.05805331f, 0.06605729f, 0.05804023f, -0.18931973f, 0.22800292f, 
    -0.05635557f, 0.10743876f, 0.03893539f, 0.01950410f, -0.11609709f, 0.09835251f, -0.31694812f, 0.02829341f, 
    0.01606157f, -0.05571197f, -0.18517444f, -0.01756312f, 0.01012476f, 0.17194991f, -0.02610854f, -0.18803547f, 
    -0.01266843f, -0.03814530f, 0.01039249f, -0.05626226f, -0.04961173f, 0.09044056f, 0.03498039f, 0.06707259f, 
    -0.00997189f, -0.04323086f, 0.13262837f, 0.06275420f, 0.03336008f, 0.04784959f, -0.04212085f, -0.02534543f, 
    0.03349260f, -0.05860141f, 0.03591007f, 0.25962064f, -0.09052518f, -0.05450999f, 0.06737285f, 0.05791103f, 
    0.10413039f, -0.07117525f, -0.19138807f, 0.05488115f, 0.21818760f, 0.05749658f, 0.17777707f, 0.06219933f, 
    0.14996673f, -0.05298638f, -0.04171574f, -0.00215822f, -0.01082538f, 0.05200388f, -0.07750427f, 0.04769228f, 
    -0.28407320f, -0.04391688f, -0.04202725f, 0.10380647f, 0.06355941f, -0.04002093f, 0.06372341f, 0.03427973f, 
    0.16440558f, -0.05253682f, -0.15216275f, -0.11382484f, -0.21254641f, 0.00768846f, 0.00265985f, -0.07286017f, 
    0.03634898f, 0.05575546f, -0.03098063f, 0.00018790f, -0.01366960f, -0.04333048f, -0.01263490f, 0.17280090f, 
    0.26755682f, -0.02617445f, 0.03116752f, -0.34177125f, 0.08478043f, -0.03044371f, 0.00139325f, 0.07081749f, 
    0.00335402f, 0.03733185f, 0.04442363f, -0.04610156f, 0.08808266f, 0.03604059f, 0.14556335f, 0.17708966f, 
    0.03151526f, -0.03205031f, 0.09397340f, -0.03534307f, 0.07852876f, 0.01792934f, -0.02877730f, 0.12172180f, 
    -0.02096295f, 0.07299256f, -0.07013807f, 0.22494861f, -0.06173227f, 0.01720596f, 0.00331530f, -0.03291933f, 
    0.10620995f, -0.04202128f, 0.00874266f, -0.05886720f, -0.18700112f, 0.04935153f, 0.03251474f, -0.10776642f, 
    0.07282683f, -0.06503959f, 0.06000406f, -0.10333262f, -0.00864863f, -0.11587268f, -0.06384465f, 0.02935389f, 
    0.09000331f, -0.13784449f, 0.16107394f, 0.16005892f, -0.02031665f, 0.01268968f, -0.01455011f, 0.03170257f, 
    0.02231931f, 0.07762732f, 0.03640174f, 0.13672422f, 0.34379339f, 0.08971857f, -0.19697493f, 0.01330067f, 
    0.07967556f, 0.11245164f, -0.06242839f, -0.02928189f, -0.02431862f, -0.03857175f, 0.13404767f, -0.04782269f, 
    -0.08707001f, -0.19689932f, 0.16525075f, -0.35780057f, 0.03492108f, -0.09666386f, -0.01510832f, 0.07124998f, 
    0.04640326f, -0.08511031f, 0.01986603f, -0.03434487f, 0.16077977f, -0.03342104f, 0.11416961f, -0.31249279f, 
    -0.08982127f, -0.00834582f, 0.06529105f, -0.01276573f, -0.09274272f, -0.13016555f, 0.07004900f, -0.07412130f, 
    0.13086870f, -0.06501164f, -0.13295001f, -0.12777632f, 0.07009600f, -0.12485643f, 0.01322981f, -0.04325376f, 
    0.04059232f, 0.03203742f, -0.06107830f, -0.01248210f, -0.28509486f, -0.06832135f, -0.19164260f, -0.06687319f, 
    0.05024022f, -0.06881043f, -0.00779604f, 0.09991554f, 0.00089293f, 0.03562435f, 0.00953146f, -0.01176652f, 
    0.35155791f, -0.32756540f, -0.03970806f, -0.27908370f, 0.04136488f, -0.10409611f, -0.07809691f, 0.13845314f, 
    -0.04668009f, 0.00387102f, -0.02373754f, -0.10795390f, -0.25604460f, 0.13835725f, -0.21741804f, -0.15058663f, 
    -0.09037146f, 0.07555573f, -0.03436190f, -0.05840275f, 0.09647882f, 0.04536269f, 0.11359582f, -0.01405124f, 
    -0.60007584f, -0.16081178f, 0.07886370f, -0.11406912f, -0.03030120f, -0.09619620f, -0.06037998f, -0.03802906f, 
    -0.00039247f, -0.03444086f, -0.06823464f, 0.00453573f, 0.22062725f, -0.09536806f, 0.05258616f, -0.12247747f, 
    -0.11687409f, -0.14703214f, -0.03152804f, -0.02602561f, -0.13870275f, 0.05657462f, -0.02847509f, -0.03016571f, 
    -0.27253529f, -0.24600859f, -0.27163857f, 0.01189389f, -0.06878674f, -0.00638655f, 0.07922046f, -0.04248939f, 
    -0.01678443f, 0.07544617f, -0.06623269f, 0.04111207f, 0.02367650f, -0.12155271f, -0.20227772f, 0.11706377f, 
    0.04717469f, 0.04800352f, 0.01720800f, 0.07349199f, 0.06881777f, 0.08758709f, -0.01349429f, 0.04813967f, 
    0.08809136f, -0.08773255f, 0.06517702f, -0.08164085f, 0.04993201f, 0.09168077f, 0.06784784f, -0.05150108f, 
    0.00453086f, 0.13452312f, 0.07078531f, -0.02898536f, -0.04282811f, -0.07476207f, 0.00297037f, -0.04510009f, 
    0.03771011f, 0.01117823f, -0.01131171f, -0.00432051f, 0.04471834f, 0.03694614f, -0.03250495f, 0.00689706f, 
    -0.03603644f, -0.05679746f, 0.10908087f, -0.12227292f, -0.06707243f, 0.00195762f, -0.01749107f, -0.00452812f, 
    -0.09395000f, 0.02410742f, -0.05359934f, -0.06581552f, 0.18877797f, -0.19765562f, -0.09061448f, 0.02253867f, 
    0.03805805f, -0.12472798f, 0.06004562f, -0.06327141f, -0.03175829f, -0.01169300f, -0.09744705f, -0.04708976f, 
    0.26710913f, -0.05436862f, -0.03569365f, 0.09423001f, -0.07194561f, 0.03316005f, 0.06564346f, -0.01168634f, 
    -0.06562828f, 0.03198106f, 0.07534068f, -0.18321176f, 0.27637008f, 0.15039879f, -0.13936643f, -0.37037712f, 
    -0.04291916f, 0.02134418f, -0.06643558f, 0.01112776f, -0.06869454f, 0.01963598f, -0.00526049f, 0.01774866f, 
    0.00240705f, -0.04258871f, -0.01493512f, 0.00555173f, 0.06129162f, -0.03266178f, -0.02724330f, 0.04573904f, 
    -0.00815430f, -0.01220324f, -0.05071226f, -0.04417216f, -0.25153506f, -0.08569016f, 0.05171367f, 0.10527093f, 
    -0.05801682f, -0.03518826f, 0.06236130f, 0.06768318f, -0.09726395f, 0.01453396f, 0.03923561f, -0.04322229f, 
    0.25849780f, 0.02398438f, -0.18624383f, -0.14105842f, 0.09576897f, -0.02258228f, 0.04985431f, 0.09333642f, 
    0.00857884f, 0.03049995f, -0.07059170f, -0.21792763f, 0.01189269f, 0.01838696f, 0.08709397f, 0.02004032f, 
    -0.09005094f, 0.03736603f, 0.11965654f, 0.00710942f, -0.03784942f, -0.05517825f, 0.01840233f, -0.12037510f, 
    -0.17106146f, 0.06238484f, -0.13073936f, 0.03091583f, 0.09939340f, 0.09965450f, 0.01952021f, -0.04044635f, 
    -0.00048170f, 0.06246852f, -0.07350220f, 0.04223593f, -0.38406861f, 0.02247513f, -0.03033972f, -0.04827146f, 
    -0.05024632f, -0.08042967f, 0.10388449f, 0.01994215f, -0.06946190f, 0.07539060f, -0.00363777f, -0.06898435f, 
    0.03868111f, -0.19276865f, 0.01763575f, 0.10630123f, -0.06443103f, 0.06301685f, -0.12267658f, -0.10688787f, 
    -0.01416700f, -0.04305043f, -0.05230263f, 0.05777151f, 0.34412500f, -0.01693239f, -0.09531388f, 0.11259658f, 
    -0.10486190f, -0.05647761f, -0.05449989f, -0.02609245f, 0.04099512f, 0.02175772f, 0.01330385f, 0.00867717f, 
    -0.14317454f, -0.22889103f, -0.13637748f, -0.09205995f, -0.01811550f, -0.17316012f, -0.00759317f, 0.00854598f, 
    -0.07404119f, -0.00693348f, -0.03859731f, 0.00816025f, 0.19574802f, -0.04900403f, -0.15077825f, -0.01733009f, 
    0.02567526f, 0.04109171f, 0.01106068f, -0.11969361f, -0.00715591f, -0.01581953f, 0.01055107f, 0.03568384f, 
    -0.16356508f, -0.06394900f, -0.26017234f, 0.01685224f, 0.00995167f, -0.04351789f, 0.01006568f, -0.02555589f, 
    0.03558674f, -0.00995584f, -0.11419712f, -0.08580539f, 0.24779633f, -0.07915123f, -0.24012275f, 0.05763899f, 
    -0.08184826f, 0.02944710f, 0.05934562f, 0.00529723f, 0.05506459f, 0.17963566f, -0.07969701f, 0.00011028f, 
    -0.38910201f, -0.25245774f, -0.03747161f, -0.06555983f, -0.13749258f, 0.08981001f, -0.13188790f, -0.05980182f, 
    -0.08443335f, 0.03164928f, -0.01790494f, 0.08255475f, 0.01780141f, -0.08759195f, -0.05857122f, -0.00352012f, 
    -0.05585681f, -0.08350234f, 0.09471039f, -0.03462388f, 0.06987961f, 0.01831295f, 0.01223999f, -0.07010589f, 
    0.06430328f, -0.00225829f, 0.14827661f, -0.01835518f, 0.02678847f, -0.02981020f, -0.05694057f, -0.01226912f, 
    0.02497984f, -0.06558278f, 0.09638713f, 0.12152573f, -0.03410484f, 0.07024053f, 0.03673887f, -0.00280960f, 
    -0.01862211f, -0.01941708f, 0.03306483f, 0.02553978f, -0.07492603f, -0.00153681f, 0.00300037f, -0.01626056f, 
    0.09104051f, -0.04418761f, -0.01593966f, -0.05383587f, 0.09756801f, -0.01236330f, 0.00955095f, -0.00239056f, 
    0.03138336f, -0.12954433f, 0.01745355f, -0.09965772f, -0.05553500f, 0.01363492f, 0.09584216f, 0.16657040f, 
    -0.06212275f, -0.10771789f, 0.02927953f, 0.03343903f, -0.05060672f, -0.08441987f, -0.05817876f, 0.07440434f, 
    0.20885547f, -0.27930763f, -0.15634768f, -0.17729415f, -0.02378907f, -0.03119978f, -0.12071461f, -0.00960939f, 
    -0.05069987f, -0.02283558f, 0.01294821f, -0.11274103f, 0.03877154f, -0.05664364f, -0.00195504f, 0.00683879f, 
    0.04805421f, 0.07171804f, 0.03453904f, -0.01595273f, -0.01141540f, 0.00580266f, 0.02870943f, -0.08052290f, 
    -0.21789685f, 0.03618851f, -0.10040260f, -0.01291654f, 0.11322287f, -0.01198302f, -0.11402047f, 0.12267244f, 
    0.00976953f, -0.03858320f, -0.00216124f, -0.04118479f, -0.34436464f, -0.02698919f, -0.27695858f, 0.05053513f, 
    0.01286311f, 0.06561420f, 0.02938568f, -0.01701154f, -0.01679605f, -0.02170817f, -0.09263553f, 0.08020366f, 
    0.21536526f, -0.28320387f, 0.05648202f, -0.08588152f, 0.16489895f, 0.05122919f, 0.03752235f, 0.09290280f, 
    -0.08153364f, 0.14495629f, -0.02188173f, -0.02073576f, 0.15268366f, -0.29240060f, -0.07480887f, -0.04191257f, 
    -0.16116628f, 0.02510341f, -0.03396276f, 0.04016067f, 0.00329366f, 0.02267978f, -0.02986828f, -0.03006094f, 
    0.03756954f, -0.09837884f, -0.18076681f, -0.05940621f, 0.04064380f, 0.02163790f, 0.00326037f, -0.06404689f, 
    -0.03036517f, 0.02838317f, 0.08753297f, 0.00558578f, -0.26465023f, 0.08691545f, 0.04480447f, -0.01101193f, 
    0.03065672f, 0.06391439f, 0.04649993f, -0.00995450f, -0.02380697f, 0.02464039f, 0.00479482f, 0.02419480f, 
    -0.32500044f, 0.12372348f, -0.08685878f, -0.34669885f, -0.09267878f, -0.02970491f, -0.05643050f, 0.00474434f, 
    -0.07840994f, -0.09038921f, -0.03243751f, 0.09948090f, 0.29028225f, 0.19465184f, 0.14831959f, 0.12932311f, 
    -0.09127905f, -0.00292861f, -0.05237085f, 0.11432382f, -0.11859101f, -0.00664890f, -0.08063733f, -0.08688717f, 
    -0.06764223f, 0.01815026f, -0.02087780f, 0.06563188f, -0.13904458f, -0.02614132f, 0.01692943f, 0.03121760f, 
    -0.04391019f, -0.03315834f, -0.06383989f, -0.03075803f, 0.22783957f, 0.03641940f, 0.15416165f, 0.23591958f, 
    -0.16051966f, -0.12098805f, 0.01346116f, 0.11142136f, -0.00743313f, -0.02712464f, 0.02198376f, -0.05555599f, 
    0.25794569f, 0.00867205f, -0.02948478f, -0.09842423f, -0.05571340f, 0.02818918f, -0.04275554f, 0.09726756f, 
    -0.04553128f, 0.14007263f, 0.05605518f, -0.03490383f, -0.11334687f, 0.00123090f, -0.03176768f, -0.02206586f, 
    0.12368575f, 0.04255199f, 0.05548130f, 0.01436180f, -0.01044377f, 0.00998537f, -0.03844978f, -0.02447018f, 
    0.10994617f, 0.20578109f, -0.08291931f, 0.03313804f, 0.07072505f, 0.02751629f, 0.00009464f, 0.00467142f, 
    -0.03576269f, -0.02979091f, 0.01770970f, -0.15893477f, -0.35213026f, -0.04618701f, -0.04983529f, -0.09804308f, 
    -0.03037114f, 0.00717342f, -0.04973065f, -0.04027284f, -0.01311546f, 0.01399822f, -0.03527085f, -0.02394547f, 
    -0.13625591f, 0.02115825f, 0.08879553f, 0.09772258f, 0.04772864f, -0.04303799f, 0.04250580f, 0.00689404f, 
    -0.03461238f, -0.02531217f, 0.07312103f, -0.03705709f, 0.05991032f, -0.02631948f, -0.20000276f, -0.15657713f, 
    -0.00615652f, 0.04988366f, -0.13951308f, -0.05560742f, 0.15584393f, -0.08700411f, -0.00087080f, -0.07031211f, 
    0.33959389f, 0.04924578f, -0.10391842f, 0.06537671f, -0.02762490f, 0.08206215f, 0.04498826f, -0.05499420f, 
    -0.03988984f, 0.06900404f, 0.02394195f, 0.01224718f, 0.25404143f, -0.06530377f, 0.12789735f, -0.04967110f, 
    0.04142210f, -0.02832101f, -0.07766078f, 0.01904134f, 0.01310343f, 0.02826908f, 0.02190131f, -0.03897725f, 
    -0.14221226f, 0.14927678f, -0.10050289f, -0.04006217f, 0.09376214f, -0.09416750f, 0.17147730f, -0.02855690f, 
    0.00433064f, 0.02154746f, 0.06400351f, -0.04387913f, 0.20335616f, 0.02722868f, 0.03445351f, -0.02251845f, 
    -0.00474557f, 0.00591005f, 0.01751899f, -0.06586648f, -0.05695640f, 0.09614325f, 0.18450294f, 0.00785633f, 
    -0.14433043f, 0.10926750f, 0.04525516f, 0.00364699f, -0.11835640f, 0.03234334f, 0.00419337f, 0.01880516f, 
    -0.05215633f, 0.04307718f, 0.03644413f, 0.12300472f, 0.06588049f, -0.06429694f, 0.03020218f, -0.17968728f, 
    -0.07072923f, 0.07679783f, 0.05727816f, -0.00221549f, -0.02275684f, -0.02750121f, -0.04605785f, -0.06108296f, 
    0.01771848f, 0.08260252f, 0.00397265f, 0.07867298f, -0.08449943f, -0.10435279f, 0.11155134f, -0.03164279f, 
    -0.03791146f, -0.04514939f, -0.01158882f, 0.00471041f, -0.10484064f, 0.05836805f, 0.00488792f, -0.10562784f, 
    -0.03036579f, 0.02479813f, 0.00917689f, 0.00878687f, -0.01810244f, 0.01443706f, 0.01220219f, -0.06293628f, 
    0.38732028f, 0.00278891f, -0.02205687f, -0.00586980f, -0.18797295f, -0.05750372f, 0.00723758f, 0.09565969f, 
    0.05058710f, -0.07890642f, 0.01289229f, -0.05666513f, -0.20099890f, -0.04381661f, 0.01523499f, -0.12287243f, 
    0.03130735f, 0.09746169f, 0.06311625f, 0.09663427f, -0.04317272f, -0.05543980f, 0.12153740f, 0.00015337f, 
    0.08174704f, -0.14029828f, -0.04892585f, 0.02073921f, 0.07402404f, -0.07255236f, -0.01175419f, -0.06376994f, 
    0.11510399f, 0.02809270f, -0.01268481f, -0.03266864f, 0.32395160f, -0.15636942f, 0.11837820f, 0.04574506f, 
    -0.17878975f, 0.00682917f, -0.04559174f, 0.06008021f, 0.08722794f, 0.01443677f, 0.00356487f, -0.01292843f, 
    -0.07004942f, 0.04965006f, 0.04006339f, 0.27478883f, 0.03637189f, 0.02160248f, -0.00988147f, 0.00806182f, 
    -0.08162727f, 0.01778831f, -0.04964017f, -0.01695530f, -0.44438374f, -0.17261861f, 0.00193282f, -0.26234058f, 
    0.06474083f, -0.05945466f, 0.00103282f, -0.14539586f, 0.02327995f, 0.10393345f, -0.07449912f, 0.08190250f, 
    0.29418653f, 0.04950269f, 0.02504392f, 0.26545021f, -0.16768931f, -0.05915074f, -0.04714610f, -0.01419880f, 
    -0.00171441f, -0.06198917f, -0.03022410f, -0.01611056f, 0.21473065f, -0.01580600f, 0.06054239f, -0.08274256f, 
    0.09215283f, -0.02778227f, -0.04642896f, 0.10134243f, -0.02242928f, 0.10319072f, -0.01583615f, -0.01617710f, 
    -0.08782087f, 0.01266293f, -0.00942420f, -0.15320086f, -0.09768470f, -0.00900901f, 0.10019290f, -0.05996549f, 
    -0.08055964f, 0.05002945f, -0.00233838f, -0.02695428f, 0.30038726f, 0.04947511f, -0.23811203f, -0.17549931f, 
    -0.01984052f, 0.04791245f, 0.00823205f, -0.04036614f, -0.01756605f, 0.00021693f, 0.06648322f, -0.05748691f, 
    0.24258953f, 0.06168576f, -0.01320843f, -0.12848449f, 0.03310603f, -0.00561811f, 0.05918535f, -0.01728148f, 
    -0.04798217f, 0.01382326f, 0.07957144f, -0.02832025f, -0.07374074f, -0.22788978f, 0.06475547f, -0.17330660f, 
    0.05609401f, 0.04722191f, 0.03038767f, -0.09847056f, 0.00381331f, -0.03615170f, -0.07258734f, 0.01220470f, 
    0.06435290f, 0.06730996f, -0.19894953f, -0.08112767f, 0.03244350f, 0.16474152f, 0.00865112f, -0.06047555f, 
    0.01262116f, -0.06754744f, -0.01468594f, -0.04811101f, 0.05007367f, -0.17629662f, 0.18473448f, -0.00185210f, 
    -0.00498818f, -0.00007161f, -0.03059370f, -0.05957155f, 0.07803120f, 0.01658528f, 0.03280763f, 0.03644470f, 
    0.20048162f, 0.00364210f, -0.14690633f, -0.04521609f, -0.02684302f, 0.05380549f, -0.05348979f, 0.07919199f, 
    0.00034197f, 0.02404842f, 0.02330576f, 0.05515015f, 0.01803643f, -0.26051953f, 0.28172031f, 0.30098245f, 
    0.03273504f, -0.00960911f, -0.00856723f, -0.00006238f, 0.04140142f, 0.00407014f, -0.05762499f, 0.03554913f, 
    0.03156827f, 0.05072811f, 0.01983045f, 0.07320615f, 0.01593276f, 0.08585455f, -0.00890520f, -0.00229380f, 
    0.08487021f, -0.08402378f, -0.02973826f, -0.00003508f, 0.18312432f, 0.01665666f, 0.17301558f, 0.10862837f, 
    0.05907333f, -0.05221318f, -0.01281673f, -0.00262920f, 0.02794707f, -0.10266217f, -0.10864502f, -0.07217938f, 
    0.11293934f, -0.05334487f, 0.07718350f, -0.13863337f, -0.02902180f, 0.13396457f, -0.03589486f, -0.08607011f, 
    -0.04338983f, -0.02318246f, -0.00303572f, -0.01446778f, 0.15352452f, 0.12127779f, 0.14706430f, -0.10764268f, 
    -0.00092962f, -0.03633758f, -0.01350422f, 0.06266674f, 0.02115772f, -0.05200522f, -0.03168635f, 0.01464483f, 
    -0.12138908f, -0.20554228f, -0.17744936f, -0.07577935f, 0.02947183f, -0.05037452f, -0.04753861f, 0.05659391f, 
    0.00868765f, -0.07597782f, -0.00322981f, 0.06777938f, 0.07168137f, 0.04226041f, -0.04684104f, -0.08495349f, 
    -0.13337927f, 0.06218986f, 0.08541130f, 0.02767267f, 0.09798884f, 0.00072855f, 0.00553791f, 0.04516163f, 
    0.04054891f, 0.11212844f, 0.14918293f, -0.04151065f, 0.01995850f, -0.09303606f, 0.04358821f, -0.05486916f, 
    -0.02108989f, -0.02462971f, -0.05034291f, 0.04539142f, -0.25605586f, 0.00952884f, -0.18217325f, 0.02433587f, 
    -0.06818157f, -0.00732304f, 0.02676580f, 0.02719625f, -0.03771456f, 0.09247532f, -0.04140995f, 0.01363002f, 
    0.04377165f, -0.66255438f, -0.09331087f, 0.21373107f, -0.05306935f, 0.01440731f, 0.06166891f, -0.05046869f, 
    0.07001419f, -0.09912353f, 0.00529396f, 0.04635018f, 0.10036533f, -0.07449636f, -0.07323512f, 0.03158535f, 
    -0.08162961f, -0.03555307f, 0.08140070f, 0.12879646f, 0.06900209f, 0.01897420f, 0.10263448f, 0.11361210f, 
    -0.11717217f, 0.09441578f, 0.07437885f, 0.10361779f, -0.01408661f, 0.09450030f, -0.01658926f, 0.02893414f, 
    -0.06603698f, 0.04782659f, 0.00001268f, -0.03325539f, -0.18218210f, 0.13779822f, 0.11291747f, -0.11787137f, 
    -0.12183233f, 0.08388373f, 0.03318108f, -0.04996802f, 0.02341736f, -0.05563523f, -0.04498956f, -0.01244938f, 
    0.26511744f, 0.08109799f, -0.02162438f, -0.02522675f, 0.00225517f, -0.11507773f, 0.00773427f, -0.06413406f, 
    -0.08344086f, 0.03502201f, -0.04184875f, -0.06281532f, -0.05219622f, 0.13661471f, 0.07447848f, 0.03232867f, 
    0.03407224f, 0.01826470f, -0.02783650f, -0.11010858f, 0.00906451f, 0.02961243f, 0.06819623f, 0.03511443f, 
    -0.02814369f, 0.11090585f, 0.14200012f, 0.09181960f, 0.04350143f, 0.01214189f, 0.08582674f, 0.04287565f, 
    0.07183234f, 0.06544909f, -0.02629760f, 0.07179334f, -0.25542772f, 0.32591724f, 0.11415382f, 0.13480431f, 
    0.04731195f, -0.02580476f, 0.00475234f, -0.01664157f, -0.02445787f, 0.01171959f, -0.10083025f, 0.12662235f, 
    0.21387351f, 0.07368393f, -0.02421798f, 0.11473987f, 0.11044964f, 0.00659422f, 0.07747365f, 0.13126715f, 
    0.03046529f, 0.04625966f, -0.03420990f, 0.01640705f, 0.13954100f, -0.07270793f, 0.06866413f, -0.12178853f, 
    0.04238687f, -0.00044368f, 0.04877993f, 0.05631701f, -0.06630170f, 0.00529588f, -0.01341231f, -0.08181593f, 
    -0.11060166f, 0.08218854f, 0.07493356f, -0.07745682f, -0.00963043f, -0.02562997f, 0.06093751f, 0.07291323f, 
    -0.00845773f, -0.07868508f, 0.00799051f, 0.07494941f, -0.13801880f, -0.27024734f, -0.12965439f, -0.03655374f, 
    -0.07550773f, -0.12082587f, 0.04103327f, 0.06598528f, 0.01326327f, 0.06157815f, 0.02320910f, -0.00493932f, 
    -0.21797636f, -0.05508463f, -0.13024180f, 0.02977442f, -0.07272745f, -0.04235545f, 0.05261076f, 0.00759743f, 
    -0.07381887f, -0.03239582f, 0.05684368f, -0.02843422f, -0.01139878f, 0.00224526f, -0.10035341f, 0.08114880f, 
    -0.16248615f, 0.00026430f, 0.04978820f, -0.04680767f, -0.12169769f, 0.04282529f, -0.00885060f, 0.07895230f, 
    0.12295357f, 0.12174630f, 0.03727937f, 0.12366118f, 0.02787553f, -0.03337567f, -0.01167719f, -0.06313112f, 
    -0.02601934f, 0.02385591f, 0.05531276f, -0.16089907f, -0.39755270f, -0.35944739f, -0.04354920f, 0.11425545f, 
    -0.05833422f, -0.00606745f, -0.08851240f, 0.01236383f, -0.03523174f, -0.05188299f, -0.03351340f, -0.02976984f, 
    -0.04354682f, -0.32167912f, 0.13776903f, -0.13260557f, -0.07501904f, 0.10178869f, 0.08481328f, -0.00984152f, 
    0.05162803f, -0.04560499f, 0.09892768f, -0.07223733f, -0.03437813f, -0.03862069f, 0.09819666f, -0.01956823f, 
    -0.08828950f, 0.03634583f, 0.04884861f, -0.02739771f, 0.05528178f, -0.00731218f, 0.00071790f, 0.01647886f, 
    -0.05158809f, -0.22719790f, -0.26232690f, -0.04059457f, -0.03873187f, -0.00635775f, 0.08202839f, -0.05446798f, 
    0.08069814f, -0.09789896f, 0.03579521f, 0.04719824f, 0.10535406f, 0.08966383f, -0.01997931f, -0.00311811f, 
    -0.11676065f, -0.12392450f, -0.02025003f, 0.04425649f, -0.08857597f, -0.03327995f, 0.04838684f, 0.00800019f, 
    -0.36121520f, -0.25739881f, -0.09475067f, -0.00867030f, -0.12237763f, -0.09388857f, 0.07046664f, 0.03100420f, 
    0.03347825f, 0.06078672f, 0.09051935f, 0.12183663f, -0.15593258f, -0.31803340f, -0.43894613f, 0.11855050f, 
    -0.04239791f, -0.03423677f, -0.00332171f, -0.03801319f, 0.00506603f, 0.14666566f, -0.05100230f, -0.02688132f, 
    0.17564388f, 0.17912246f, -0.00801237f, -0.07647532f, -0.03246517f, 0.03302037f, -0.07594122f, 0.06866015f, 
    -0.01439824f, -0.03691505f, 0.02486835f, 0.03576057f, -0.05071051f, 0.10153910f, -0.09793383f, -0.28675443f, 
    0.00383404f, -0.03935666f, -0.11664308f, -0.09197617f, 0.11481447f, -0.13749667f, 0.04219797f, -0.00292364f, 
    0.07176998f, -0.03115335f, -0.02001587f, 0.01582525f, -0.08789355f, -0.08649748f, 0.00433796f, -0.00448491f, 
    -0.06796212f, -0.06974698f, 0.07670078f, -0.02470413f, 0.06785946f, -0.16643631f, -0.00058106f, -0.14602755f, 
    -0.13472135f, -0.03681615f, -0.03464680f, -0.04098264f, -0.07837013f, -0.08653488f, 0.00942295f, 0.03033085f, 
    0.00624614f, 0.21085574f, 0.02498532f, -0.01368048f, 0.05881929f, -0.06868495f, -0.12544070f, 0.07254938f, 
    0.08129974f, 0.09972745f, 0.03149661f, 0.00994121f, -0.20004700f, -0.39710525f, -0.20162925f, 0.00777861f, 
    -0.01048126f, -0.04678411f, 0.01560327f, -0.06956100f, 0.05795757f, -0.11505150f, -0.03125595f, -0.02924646f, 
    -0.26551023f, -0.06852670f, -0.11361219f, 0.07867718f, -0.03522108f, 0.12921993f, 0.05535047f, 0.07556386f, 
    -0.06169097f, 0.04347952f, -0.05407660f, -0.00563496f, 0.04714684f, -0.01306266f, 0.00655110f, 0.00192532f, 
    -0.02417634f, -0.03964565f, 0.00947376f, -0.02795352f, -0.05300098f, 0.10084498f, -0.02406457f, 0.04596847f, 
    -0.06655335f, -0.14386168f, -0.08136025f, -0.15636030f, -0.05279246f, -0.00185875f, 0.03879096f, 0.10703231f, 
    -0.02594225f, 0.03595442f, -0.04090045f, -0.08317755f, 0.00421020f, -0.01444599f, 0.08733467f, 0.09104674f, 
    0.00860134f, -0.03657258f, 0.00664440f, -0.04893879f, 0.06110112f, -0.13540016f, 0.04162572f, -0.00494470f, 
    0.61880577f, 0.04622653f, -0.14926559f, 0.15703547f, 0.09386656f, 0.00865342f, 0.02446282f, 0.21061152f, 
    0.01281254f, 0.07388292f, 0.03912235f, -0.03736818f, 0.08603931f, -0.00073134f, -0.06783341f, -0.15780246f, 
    -0.12565678f, -0.12071534f, -0.04900090f, -0.05673878f, 0.01614929f, -0.08495071f, -0.03559351f, -0.03054314f, 
    0.21008457f, -0.31034103f, -0.22072156f, 0.07174083f, 0.00409339f, -0.01471214f, -0.02810336f, -0.05433842f, 
    -0.03431896f, 0.04025625f, -0.02781480f, 0.03561914f, -0.19968325f, -0.37267843f, -0.12022302f, -0.23330650f, 
    0.01097281f, -0.14332107f, 0.03157529f, 0.07014291f, -0.06663936f, 0.07812269f, -0.00474664f, -0.03009671f, 
    -0.11033321f, -0.08914922f, 0.08634033f, -0.05721856f, -0.04753280f, -0.02433644f, 0.03501525f, -0.02021516f, 
    0.04241680f, 0.04138790f, 0.05559913f, 0.07308766f, 0.07218515f, -0.04004887f, -0.02675261f, 0.03968010f, 
    -0.04382484f, 0.06263743f, -0.01222092f, -0.06028450f, 0.06275649f, 0.09953561f, 0.00589503f, -0.10965195f, 
    -0.13530867f, -0.18807723f, 0.00913061f, 0.03999910f, -0.02256594f, 0.10175177f, 0.02651314f, 0.07326569f, 
    -0.06047568f, -0.03321682f, 0.01629508f, 0.08251419f, -0.19500837f, -0.43967414f, -0.23787940f, 0.02340894f, 
    0.00554481f, 0.00776664f, -0.07453096f, 0.07162425f, -0.00003920f, -0.01035594f, -0.02485909f, -0.09095386f, 
    0.30408254f, -0.08607974f, -0.02091077f, -0.11999554f, -0.01421946f, 0.05466412f, -0.00526406f, -0.08347601f, 
    -0.12248538f, -0.06864974f, 0.06069382f, 0.06804711f, 0.04421791f, 0.01329766f, -0.17651185f, -0.05258529f, 
    -0.08930630f, 0.11325507f, -0.01956476f, 0.10739047f, 0.09618516f, -0.01861629f, 0.05486953f, -0.00081312f, 
    -0.07689421f, -0.11766703f, -0.28065214f, 0.15440074f, -0.05419345f, 0.03819219f, -0.01467973f, -0.03378424f, 
    0.00630600f, -0.05853604f, 0.06012403f, -0.09498817f, 0.09609575f, -0.08347488f, -0.02037884f, 0.05089422f, 
    -0.06420724f, -0.03201010f, 0.16530505f, -0.00313441f, -0.07569268f, 0.07348813f, -0.05749819f, -0.01131990f, 
    -0.04062391f, 0.05981835f, -0.01325625f, -0.07313052f, -0.14474653f, 0.02252692f, 0.01007141f, -0.06115964f, 
    0.00657558f, -0.01032218f, -0.06407441f, 0.01338807f, -0.00673758f, 0.03698941f, 0.12872854f, 0.09704451f, 
    0.06388386f, -0.09397514f, 0.00894849f, -0.03127652f, -0.01408401f, 0.05701582f, -0.15997450f, -0.00357190f, 
    0.00519596f, -0.01406389f, 0.03207187f, -0.07296903f, -0.03851522f, 0.00548673f, 0.04494252f, -0.06319505f, 
    -0.04747908f, -0.04572285f, -0.01094839f, 0.01352728f, -0.04803249f, 0.32055917f, -0.12713131f, -0.08308003f, 
    0.02920697f, -0.06410120f, 0.00382478f, 0.06348558f, 0.07368683f, -0.12422723f, -0.07927660f, -0.01387341f, 
    0.09253696f, -0.01439518f, 0.00074661f, 0.14372128f, 0.02961178f, 0.03918920f, 0.02575566f, 0.04973674f, 
    -0.10560969f, 0.06772003f, 0.03448260f, 0.05164985f, -0.31564689f, 0.39026940f, 0.24912558f, 0.11035550f, 
    0.06058052f, -0.02475753f, -0.01968041f, 0.08975188f, -0.12244018f, -0.01437823f, -0.04904809f, 0.03282950f, 
    0.23668680f, 0.11505282f, 0.07945049f, -0.12175975f, -0.02813558f, 0.11038269f, -0.10088593f, 0.04944725f, 
    -0.06466313f, -0.05822241f, 0.02293665f, 0.03536254f, 0.20045890f, -0.13679942f, 0.06977289f, 0.13132070f, 
    0.01017513f, 0.00488692f, -0.08493112f, -0.03388042f, -0.03674873f, -0.06379192f, 0.00850559f, -0.01360647f, 
    -0.28541997f, 0.27559853f, -0.09231780f, 0.16607836f, 0.13480785f, 0.11513527f, -0.02651983f, -0.01353422f, 
    -0.06555848f, 0.07118016f, -0.03262327f, -0.10313406f, -0.17736438f, -0.14216283f, -0.15890826f, 0.02212169f, 
    -0.10222840f, -0.08017756f, 0.09611607f, 0.05655024f, -0.06095474f, 0.01544027f, 0.01290971f, -0.09725459f, 
    -0.08597463f, -0.12857001f, -0.02362594f, 0.10607632f, 0.01195069f, 0.01700874f, 0.01490198f, 0.09882946f, 
    -0.02649228f, -0.06164376f, 0.01895154f, 0.03842548f, -0.24324468f, 0.23454432f, -0.08892407f, -0.16061489f, 
    0.07498956f, 0.03529117f, 0.08141392f, 0.08690467f, -0.09617142f, -0.01456246f, 0.01406655f, 0.04173297f, 
    -0.24254195f, 0.06752613f, -0.04734486f, -0.05155973f, -0.00443265f, -0.01120764f, 0.08643794f, -0.03263370f, 
    0.12959540f, -0.11826939f, -0.03338329f, -0.00346726f, 0.11087195f, 0.16074823f, 0.00654646f, -0.11484341f, 
    0.01192121f, -0.11934210f, -0.05173529f, -0.03777555f, -0.08477322f, -0.00843688f, 0.06141658f, -0.10830823f, 
    -0.09786361f, -0.01924434f, 0.01625068f, -0.08978541f, 0.02301645f, 0.03939219f, -0.00657610f, 0.08372962f, 
    -0.03078823f, 0.12048653f, -0.05805220f, -0.04273663f, 0.31432685f, -0.16101865f, -0.01915006f, -0.14968525f, 
    0.08987006f, -0.09251800f, -0.03200155f, 0.04632219f, 0.02475544f, -0.00875143f, -0.00138422f, -0.03589180f, 
    0.32752603f, 0.08075808f, 0.03784411f, -0.06775325f, -0.05939346f, 0.00604996f, -0.04155847f, -0.01706452f, 
    -0.03078042f, -0.04525658f, -0.07993270f, 0.01699915f, 0.15500608f, 0.01181294f, 0.02804997f, 0.11990159f, 
    -0.02075702f, -0.01713297f, 0.09322269f, 0.08227316f, 0.04571222f, 0.03515496f, 0.06214850f, -0.04990183f, 
    -0.19057222f, -0.09965448f, -0.02473326f, -0.21068235f, 0.09123256f, 0.02346770f, -0.00524254f, -0.01600606f, 
    -0.18493554f, -0.04044808f, 0.12078739f, -0.05332433f, -0.15121022f, -0.19114622f, 0.06496619f, -0.17320374f, 
    -0.06115932f, 0.01190971f, 0.10839148f, 0.09390520f, -0.01361959f, 0.05997347f, 0.01838915f, 0.01093665f, 
    0.00856525f, -0.00142551f, 0.15861776f, 0.19445965f, -0.10777423f, 0.03977598f, -0.02066427f, 0.06189225f, 
    0.03648575f, 0.02985707f, 0.01117698f, 0.00239219f, 0.13143593f, 0.02033309f, 0.06384000f, 0.11626115f, 
    -0.08860980f, 0.08419751f, 0.05236734f, 0.10509195f, 0.03472209f, 0.01348262f, 0.10278174f, 0.06540664f, 
    -0.24911955f, 0.04481040f, -0.14866115f, -0.13283993f, 0.04128806f, 0.01497772f, -0.00701420f, -0.08612080f, 
    0.05832135f, -0.04324787f, -0.15064175f, -0.02414818f, 0.12031777f, -0.00671125f, -0.14565811f, -0.14065449f, 
    0.00441004f, -0.09290063f, 0.03202624f, 0.03481694f, -0.00489815f, 0.00705200f, -0.13605049f, 0.00409146f, 
    -0.08104654f, 0.09394530f, -0.04556616f, 0.02400635f, 0.12209920f, 0.04459187f, -0.11687512f, 0.06024473f, 
    0.10773531f, -0.17422719f, 0.12141960f, -0.02006738f, 0.17283069f, 0.04537684f, 0.00796088f, 0.17451547f, 
    -0.18015979f, -0.00231615f, 0.03670449f, -0.06860855f, -0.05085985f, -0.02550447f, 0.02731470f, 0.03274638f, 
    0.22031735f, -0.06992043f, -0.00733492f, -0.12857197f, -0.03811586f, 0.04455132f, -0.00800905f, 0.02481316f, 
    -0.10805673f, 0.00520011f, -0.05848835f, 0.02521944f, -0.18390955f, -0.21737617f, 0.19801138f, 0.01789871f, 
    -0.02799463f, 0.00694709f, -0.07434054f, -0.00332405f, 0.02929562f, -0.05678402f, 0.06032609f, 0.00580111f, 
    0.01217116f, 0.04921496f, -0.00867468f, -0.03582183f, 0.01299197f, 0.13757108f, -0.13176031f, 0.09961219f, 
    -0.02429651f, -0.11911274f, 0.01042448f, 0.04058294f, -0.10192171f, -0.13927740f, 0.08381584f, -0.00190779f, 
    -0.00979749f, 0.05813895f, -0.07353560f, 0.05492513f, 0.04327810f, -0.05892478f, 0.00166718f, 0.16637625f, 
    -0.07106105f, -0.04207002f, -0.07718104f, -0.03585962f, 0.02908944f, 0.06568528f, -0.02056560f, -0.11875965f, 
    -0.06733662f, -0.07130444f, 0.01196019f, 0.07614910f, -0.12035097f, 0.05873650f, -0.13591318f, -0.13200147f, 
    0.00507109f, 0.03668452f, -0.09057021f, 0.08445482f, 0.01140649f, -0.05424415f, 0.10612040f, -0.04186862f, 
    0.07109574f, -0.08560295f, 0.06532209f, 0.02262897f, 0.04446039f, -0.09711244f, -0.04333340f, -0.00810809f, 
    0.00398987f, -0.05217641f, -0.06063525f, -0.17956792f, -0.54128510f, 0.12520681f, 0.10183492f, 0.24066615f, 
    -0.02326748f, -0.05510684f, -0.04047146f, -0.11081062f, -0.06948829f, 0.01089281f, 0.04520385f, -0.02640559f, 
    -0.09183147f, -0.05511302f, 0.11083147f, 0.11230029f, -0.05881182f, 0.01685573f, -0.12184341f, -0.08913152f, 
    0.01333065f, 0.11086638f, -0.06184069f, 0.04653754f, -0.02244851f, 0.05386261f, -0.10357273f, -0.00939618f, 
    0.04331524f, -0.10835992f, -0.08908501f, 0.14788729f, 0.03453349f, -0.08521810f, 0.04184106f, 0.03674524f, 
    -0.05918795f, 0.23286371f, -0.04611794f, -0.02357209f, 0.06553899f, 0.08274917f, 0.14208648f, 0.02975850f, 
    0.06076731f, -0.00631995f, 0.00738494f, -0.02520232f, 0.35334665f, 0.07275517f, -0.31213647f, -0.05202308f, 
    -0.07924493f, -0.12208693f, 0.03331765f, -0.15221435f, 0.07228854f, -0.08661932f, 0.00712450f, 0.00814792f, 
    0.19063123f, -0.01249062f, -0.15675989f, 0.08715197f, -0.10853717f, -0.01195837f, 0.07588055f, 0.08317740f, 
    -0.19733697f, 0.05262681f, 0.05605340f, 0.04971532f, 0.07345455f, 0.06646226f, -0.00044820f, 0.07755379f, 
    0.11879924f, 0.04307125f, 0.00318735f, 0.09298616f, -0.02023864f, 0.15739636f, 0.03249709f, -0.06283524f, 
    0.12168694f, -0.02739141f, 0.19632185f, 0.07648870f, 0.08365733f, 0.03325453f, 0.15754303f, 0.14816394f, 
    -0.02218540f, 0.00080835f, 0.04944840f, 0.07758264f, -0.28864974f, -0.10358140f, 0.12209173f, -0.05669536f, 
    -0.01245361f, 0.00653422f, -0.04310612f, 0.01382974f, 0.10273412f, 0.02931342f, -0.06738006f, 0.10582533f, 
    0.18964705f, -0.29455328f, 0.05119053f, -0.12783180f, 0.03430977f, 0.11018500f, 0.03312256f, 0.01929741f, 
    -0.04760800f, -0.07248194f, -0.06047001f, 0.02521709f, -0.00107981f, 0.05052840f, -0.00129841f, 0.20168014f, 
    0.03222306f, 0.10538334f, -0.01592668f, 0.14190739f, 0.02770454f, -0.10327581f, 0.08899933f, -0.00157973f, 
    -0.30678582f, 0.05134057f, -0.21355432f, -0.14099251f, -0.00590720f, 0.08386993f, -0.04081484f, 0.06427692f, 
    -0.00700571f, 0.00586179f, -0.00976421f, 0.08376268f, -0.40883863f, 0.00308247f, 0.04801541f, 0.26471066f, 
    0.01833546f, -0.00282049f, 0.02829827f, 0.08180282f, -0.01108746f, 0.00562210f, 0.12003428f, 0.05812597f, 
    -0.03051510f, 0.03942639f, -0.15910748f, 0.15197742f, -0.01193991f, 0.00069292f, 0.05379568f, 0.05492446f, 
    -0.09761393f, 0.12824669f, 0.03353784f, 0.06964390f, 0.18020958f, -0.00797574f, 0.01726100f, 0.06308366f, 
    -0.16666895f, -0.01960572f, 0.02871308f, -0.02290641f, 0.03280909f, 0.09211607f, -0.05056313f, -0.03690476f, 
    -0.28026462f, -0.03169984f, 0.07192343f, 0.05101143f, -0.09493364f, 0.08029652f, 0.05579390f, -0.00302476f, 
    -0.02519967f, 0.13094339f, -0.05046636f, -0.17375763f, 0.22956574f, 0.06840974f, -0.06744054f, -0.06892468f, 
    0.01966941f, -0.06433585f, 0.12602049f, 0.01167131f, -0.03176324f, -0.00985905f, 0.07317649f, 0.03779337f, 
    0.07078510f, -0.15284723f, -0.01926069f, 0.01307333f, -0.13570048f, 0.00349755f, -0.01356320f, 0.00824309f, 
    -0.02018256f, -0.01006443f, -0.07117753f, 0.02768314f, -0.12702760f, 0.10056058f, 0.10965743f, -0.12602541f, 
    -0.00686754f, -0.05679836f, -0.11738673f, 0.07788415f, 0.03125619f, -0.00562155f, 0.07656377f, -0.02105677f, 
    0.14568533f, 0.43594825f, -0.18359810f, -0.31846869f, 0.08676189f, 0.13181618f, -0.00532359f, 0.08179560f, 
    -0.01841503f, -0.02529372f, -0.03532124f, 0.04925202f, 0.11357279f, -0.09538158f, 0.00763157f, 0.12454169f, 
    0.05737815f, -0.00226751f, 0.02811765f, 0.11976108f, -0.08399439f, -0.04290784f, 0.03956285f, -0.05558874f, 
    0.00219972f, -0.16492771f, 0.11833578f, 0.11657323f, -0.18718258f, -0.01192202f, 0.06076231f, -0.10586724f, 
    0.04591720f, 0.07059350f, 0.11598318f, -0.10290551f, -0.28071705f, -0.04858922f, -0.06142788f, 0.05891014f, 
    -0.11661944f, 0.00857204f, -0.00470723f, 0.09048657f, -0.03717643f, -0.02549876f, 0.01715219f, -0.05201431f, 
    0.14086349f, 0.19213291f, -0.00789053f, -0.16054057f, 0.07240526f, 0.07615110f, 0.00840249f, 0.03618395f, 
    -0.08692057f, -0.09153344f, 0.07066025f, 0.00822736f, 0.03086897f, -0.04086508f, 0.06256215f, -0.02033869f, 
    0.03709396f, 0.02175109f, -0.04447458f, -0.08222353f, 0.01004029f, -0.19152007f, -0.03364866f, -0.10392604f, 
    -0.12294775f, -0.18854572f, 0.19990137f, 0.07509741f, 0.00059735f, 0.06816381f, -0.01819072f, -0.07869970f, 
    0.01772873f, -0.07166758f, -0.05690697f, 0.03347382f, -0.10151202f, -0.23674099f, -0.00855593f, 0.01501852f, 
    -0.13927259f, -0.03924422f, -0.02385334f, -0.07107177f, 0.02987617f, 0.06854927f, 0.06718309f, -0.00455964f, 
    -0.16342638f, 0.06706759f, 0.00679673f, -0.09084705f, -0.05082535f, 0.02275148f, -0.12545146f, 0.03559835f, 
    0.01432156f, 0.08435836f, -0.08199392f, 0.06308237f, 0.04699035f, 0.03801050f, 0.09337586f, -0.12100489f, 
    -0.11504701f, -0.12016453f, 0.07895909f, -0.01686464f, -0.04219187f, -0.02847156f, 0.01670386f, 0.07440053f, 
    0.25744066f, 0.06071407f, -0.14464858f, 0.07526726f, 0.01990355f, 0.08726668f, 0.03766839f, 0.00043899f, 
    -0.02799747f, -0.04966436f, 0.04443132f, 0.01422923f, -0.57967937f, -0.00926040f, -0.19580606f, -0.02819880f, 
    -0.01676778f, -0.10796905f, -0.02038108f, 0.04966159f, 0.05101989f, -0.06986869f, 0.03226308f, 0.06321823f, 
    -0.06131374f, -0.29152980f, -0.00844931f, 0.29325813f, -0.01184156f, -0.05608520f, 0.10764742f, 0.06133476f, 
    -0.02669294f, 0.05949353f, -0.00699982f, 0.04984282f, -0.13156986f, -0.13645077f, -0.01172632f, 0.14242753f, 
    -0.01358269f, -0.00674450f, -0.05866367f, -0.04508321f, -0.08454051f, -0.00984970f, -0.01971434f, 0.03647226f, 
    -0.64112693f, 0.08577195f, 0.15949006f, 0.21090654f, 0.05901723f, 0.05200880f, -0.03509383f, 0.04968961f, 
    -0.10112417f, 0.02022823f, -0.00399782f, -0.00445839f, -0.42236009f, -0.25320157f, 0.11372696f, -0.12591304f, 
    0.01379930f, 0.10946196f, 0.00689387f, -0.12907639f, 0.02686642f, 0.04182375f, -0.06438380f, -0.10216642f, 
    -0.03602255f, 0.02862457f, 0.08418076f, -0.11665402f, -0.08276735f, 0.16423197f, 0.03092143f, -0.08234773f, 
    -0.04418813f, 0.01705966f, 0.04716526f, -0.05273048f, -0.49898750f, 0.10324097f, 0.09715223f, 0.09756050f, 
    0.01905476f, -0.09996775f, 0.03144869f, -0.00442497f, -0.02964048f, -0.01785485f, -0.04112666f, 0.02809196f, 
    0.05842334f, 0.17874153f, 0.06751002f, 0.05196239f, 0.08077631f, 0.02575771f, 0.08149268f, -0.02607745f, 
    -0.03224147f, 0.04675283f, -0.00771398f, 0.03030418f, -0.00429273f, -0.01292129f, -0.05981486f, 0.01209572f, 
    0.01264703f, -0.01181967f, 0.08429109f, 0.03234617f, -0.06000520f, -0.00552533f, -0.10038823f, -0.00782482f, 
    -0.34239078f, -0.29111528f, 0.27839875f, 0.11574347f, 0.07481442f, -0.06270369f, -0.00705399f, -0.08794950f, 
    0.01963244f, -0.00882396f, -0.02229784f, -0.02374459f, -0.38814154f, 0.11861334f, -0.10482334f, 0.06742141f, 
    -0.02425439f, 0.03261257f, 0.14749293f, -0.07995789f, -0.06298734f, 0.03198879f, 0.11637615f, 0.00512944f, 
    0.14474544f, 0.05374543f, -0.06561505f, -0.10369723f, 0.01301416f, -0.08643091f, -0.02662738f, 0.00092090f, 
    0.00799162f, -0.10903087f, -0.15822829f, -0.02825478f, -0.11530285f, -0.04274644f, 0.15710679f, 0.02174632f, 
    0.02766277f, -0.04559808f, -0.02732819f, -0.02351247f, 0.02617221f, 0.09918027f, 0.06340247f, -0.02481761f, 
    -0.20009798f, -0.15910251f, -0.07811747f, -0.04652142f, 0.12565182f, 0.03072992f, -0.08280453f, 0.00901219f, 
    -0.09255959f, 0.16871540f, 0.20270245f, 0.07906024f, -0.32561252f, -0.19227597f, 0.22872365f, 0.27682647f, 
    -0.08831298f, 0.06806932f, 0.02525445f, 0.02171108f, -0.01509421f, -0.04342207f, 0.01737043f, 0.10356977f, 
    0.05792910f, -0.04315135f, -0.12492561f, -0.06137943f, 0.03782544f, -0.00463951f, -0.08389790f, -0.04845648f, 
    0.00595905f, -0.15056400f, 0.09067925f, -0.06846813f, -0.39511198f, -0.15402585f, 0.07014954f, 0.08575096f, 
    0.07746685f, -0.01016922f, 0.06397208f, -0.01008031f, -0.11716980f, -0.02513017f, 0.09057250f, -0.06199973f, 
    0.02248923f, -0.02825275f, 0.08399654f, -0.06679387f, 0.00137082f, 0.02795342f, 0.00818432f, -0.01629730f, 
    0.19855030f, 0.03893551f, 0.06083486f, 0.00081427f, -0.09707678f, -0.16223636f, 0.04685372f, 0.04707390f, 
    0.10618746f, 0.05912089f, -0.04647345f, -0.12198090f, -0.14354512f, -0.04002600f, -0.11307012f, 0.10839871f, 
    -0.03828563f, -0.05362866f, -0.01937117f, 0.06901985f, -0.04967620f, 0.06628446f, 0.01990826f, 0.04514014f, 
    -0.04196700f, 0.01975484f, 0.04106953f, 0.18250625f, 0.22151648f, 0.06452230f, -0.03349124f, -0.00507387f, 
    -0.01309030f, 0.10810651f, -0.14958547f, 0.02849328f, -0.03252441f, -0.07855810f, 0.08311222f, 0.16938452f, 
    -0.00793678f, -0.01744237f, 0.06705560f, 0.13165015f, -0.00584029f, 0.00873957f, 0.04705884f, 0.04361746f, 
    -0.08311418f, -0.06026838f, 0.09597661f, 0.07252117f, -0.03083971f, 0.05753398f, 0.05545627f, 0.08246056f, 
    0.05370092f, 0.05143739f, -0.18163629f, -0.02683803f, -0.13489519f, 0.09994166f, 0.01524442f, -0.01822862f, 
    -0.33171156f, -0.01108600f, 0.12295487f, -0.30098680f, 0.14217849f, -0.07891994f, 0.05367881f, -0.08845434f, 
    0.12599675f, 0.07279129f, 0.04691925f, 0.15510638f, -0.26128197f, -0.09337752f, -0.06856778f, 0.22201602f, 
    0.06944004f, 0.03195876f, 0.05690457f, 0.00393144f, 0.04963467f, -0.01857595f, -0.01571114f, 0.05204224f, 
    -0.03756718f, -0.07167744f, -0.03484372f, -0.09208425f, -0.04485409f, -0.01390947f, 0.01671018f, -0.09242062f, 
    -0.01550429f, 0.04790679f, 0.12380344f, 0.20771623f, -0.04847567f, 0.09480385f, -0.01578660f, -0.01465196f, 
    -0.02990840f, -0.12009369f, 0.00105788f, 0.07295466f, -0.05923540f, 0.01366242f, -0.18709889f, -0.13251090f, 
    0.01136414f, -0.04691121f, 0.06900461f, 0.03913336f, 0.21485364f, -0.05808505f, -0.08892220f, 0.05187564f, 
    -0.04157636f, -0.08179957f, 0.11999200f, 0.15680216f, 0.17105852f, 0.02605482f, -0.10241225f, 0.21205963f, 
    -0.04772026f, -0.00535146f, 0.05543781f, 0.04966788f, -0.10420265f, -0.03117658f, 0.05545048f, 0.01502729f, 
    0.03826424f, -0.02642906f, 0.01982340f, -0.00881983f, -0.01998178f, -0.05365730f, 0.00362324f, -0.01236058f, 
    0.05217971f, 0.13317694f, 0.06144725f, -0.07106677f, 0.00092502f, 0.05513823f, -0.21477866f, 0.02329922f, 
    0.00814402f, -0.11658628f, 0.00528735f, -0.01259010f, -0.02879362f, -0.09587111f, -0.03288497f, -0.18153612f, 
    -0.19159073f, 0.04904110f, 0.03495777f, -0.07791275f, 0.06316651f, -0.23717749f, 0.02008899f, -0.04421811f, 
    -0.03665286f, 0.10655086f, -0.03430029f, -0.11234863f, -0.02037415f, 0.07869911f, 0.14435835f, 0.16823186f, 
    0.04260748f, 0.09511188f, 0.03478350f, -0.02743472f, 0.01182040f, -0.04596443f, -0.09733187f, 0.01250790f, 
    -0.10918331f, -0.01929668f, 0.16299078f, -0.08895101f, 0.07906803f, 0.12841976f, 0.06227524f, 0.00786876f, 
    -0.00211930f, 0.06518487f, -0.03638853f, 0.15650894f, -0.01842399f, -0.08340506f, -0.20273398f, -0.07399424f, 
    -0.02444857f, 0.04572571f, 0.03372952f, -0.03928499f, 0.05503448f, -0.00411884f, -0.10265181f, 0.08068161f, 
    0.04043910f, 0.05975219f, 0.12132882f, -0.03584835f, -0.03012781f, 0.05441478f, 0.02184293f, 0.06142956f, 
    -0.00743499f, 0.04438910f, 0.01913274f, 0.18575235f, 0.09335572f, 0.06600038f, 0.17868124f, 0.10132144f, 
    -0.03612403f, 0.07217084f, 0.07598449f, -0.08853599f, -0.00875465f, 0.11490823f, -0.06595640f, 0.05338647f, 
    -0.29053226f, 0.08703975f, -0.00321466f, 0.04072457f, 0.01124079f, -0.15575896f, -0.13402793f, -0.07500093f, 
    -0.01733551f, 0.11198540f, 0.03750407f, 0.10666899f, 0.21138124f, -0.03940240f, 0.18770477f, 0.14963299f, 
    0.01258905f, 0.02269854f, -0.03406282f, -0.04941585f, -0.00377037f, 0.07995238f, 0.04394789f, 0.17085785f, 
    0.03316918f, 0.08416138f, 0.24291554f, -0.22014740f, 0.02256670f, -0.07094914f, -0.01363540f, -0.18931037f, 
    -0.00790186f, -0.07972641f, -0.06214312f, -0.02102653f, -0.26375031f, -0.26177078f, -0.23940043f, -0.09547719f, 
    0.12385186f, 0.10248622f, 0.14115699f, -0.17526895f, 0.06969354f, 0.04673201f, -0.07497095f, 0.02095479f, 
    0.05233328f, 0.09132267f, 0.14837153f, -0.16536920f, -0.03065336f, 0.01987875f, -0.05111155f, 0.02603545f, 
    -0.07260223f, -0.04562916f, -0.06251272f, -0.29225630f, 0.07174016f, -0.05999374f, -0.08949266f, 0.17852880f, 
    0.09504702f, -0.08211291f, 0.01166560f, 0.05588584f, 0.12322324f, -0.17536303f, -0.05640440f, -0.01962315f, 
    -0.13687553f, -0.10442937f, 0.18410845f, 0.22832763f, 0.10323726f, -0.05343706f, 0.00610052f, -0.03826755f, 
    0.10077284f, 0.07475451f, 0.01821772f, -0.10263944f, -0.18012063f, -0.05811505f, -0.13902602f, 0.01640671f, 
    0.01376466f, 0.07156510f, 0.05293660f, -0.27004334f, 0.02531817f, 0.09742223f, -0.05990884f, -0.11646359f, 
    -0.08082201f, 0.14959170f, -0.07629902f, -0.03170928f, -0.06896964f, 0.15010212f, -0.08160193f, -0.01548841f, 
    -0.08862007f, -0.04439256f, -0.07404283f, -0.19990426f, -0.35759923f, 0.00788790f, -0.28240135f, -0.05411344f, 
    0.09296534f, 0.13966066f, -0.08276344f, -0.05642503f, 0.02215381f, 0.04922642f, 0.06978940f, -0.00213940f, 
    -0.09911145f, -0.22739238f, 0.04189997f, -0.09342599f, 0.11885594f, -0.07094915f, -0.04219326f, -0.21323533f, 
    -0.17597891f, -0.20064519f, -0.02891385f, -0.17241564f, 0.12800412f, 0.04251717f, 0.07098431f, -0.07203914f, 
    0.07732310f, 0.01449117f, -0.05336438f, -0.00568955f, 0.03501137f, -0.01796828f, 0.07228341f, 0.15664668f, 
    -0.10116351f, 0.03020892f, 0.12427985f, -0.10931415f, 0.00945443f, -0.05150112f, 0.10045736f, -0.05955445f, 
    0.12353198f, -0.14666620f, 0.05293283f, 0.14726852f, -0.01820170f, -0.19765975f, 0.06284806f, 0.33038539f, 
    0.10554102f, -0.01136291f, 0.01847262f, 0.03105652f, 0.00726967f, -0.05232800f, -0.10625330f, 0.03252609f, 
    0.08318779f, 0.06694475f, -0.00688722f, 0.00626022f, -0.09584335f, 0.02828706f, 0.12171261f, -0.16099402f, 
    -0.07442388f, -0.04481195f, 0.07662300f, -0.01075152f, 0.01137698f, -0.06511606f, 0.14150113f, -0.04416827f, 
    -0.09159412f, 0.03621843f, 0.24868704f, 0.01150962f, 0.02121945f, -0.01415021f, -0.04868553f, 0.07340350f, 
    -0.32806146f, -0.19321030f, 0.41208309f, 0.21997210f, -0.08066287f, -0.14887542f, 0.02336052f, -0.03610089f, 
    0.02472978f, 0.04381364f, -0.13835885f, -0.11147578f, -0.27518192f, -0.16044906f, -0.10339613f, -0.00723451f, 
    0.14286911f, 0.14060487f, -0.10884421f, -0.16694508f, 0.14339949f, 0.06942409f, 0.01840686f, -0.00192514f, 
    0.19206868f, -0.03391806f, 0.12771846f, -0.03715586f, -0.07800363f, -0.03144787f, -0.03003358f, 0.14313734f, 
    0.01836371f, 0.04374247f, -0.02363603f, -0.08222129f, 0.15864053f, 0.00989347f, 0.03238954f, -0.15192015f, 
    -0.16956346f, 0.06839740f, 0.04926695f, 0.00011997f, -0.06589533f, -0.06415505f, 0.01089766f, 0.04128250f, 
    -0.03139391f, -0.26087463f, -0.05076958f, 0.03106691f, -0.05470745f, -0.11239153f, -0.11702871f, 0.07594752f, 
    -0.04283304f, 0.01086357f, 0.15090714f, -0.10704859f, -0.12643458f, -0.10618058f, -0.11593865f, 0.22347949f, 
    -0.13707411f, -0.11085243f, -0.00023751f, 0.25289541f, 0.14263438f, 0.08657390f, 0.06627941f, 0.03358396f, 
    0.04782784f, 0.00692944f, -0.13306382f, -0.00960365f, -0.00579989f, 0.03004733f, -0.02546117f, 0.03043422f, 
    0.12592930f, 0.08093866f, -0.06060049f, -0.10752252f, 0.10034611f, 0.11955165f, -0.02984348f, 0.00718195f, 
    -0.01080060f, -0.07448588f, 0.02885927f, 0.05494378f, 0.00965953f, -0.07336675f, 0.10065135f, 0.00338757f, 
    -0.45793065f, -0.23057167f, -0.13447316f, -0.09357122f, 0.18710840f, 0.00069964f, -0.06205773f, 0.16324665f, 
    -0.09553854f, 0.10762764f, 0.03289288f, -0.04864322f, 0.13174972f, -0.04250386f, -0.05914452f, 0.21450789f, 
    0.08182505f, -0.07750033f, 0.05074298f, 0.05399269f, -0.02939010f, 0.09278063f, -0.02862922f, -0.09842271f, 
    -0.04266904f, -0.01575414f, 0.05383472f, -0.22888537f, 0.01897092f, -0.02469903f, 0.02276863f, 0.02831464f, 
    0.06525793f, 0.11971994f, -0.06510205f, 0.08433887f, -0.55075562f, 0.10125950f, -0.11422712f, -0.24873978f, 
    0.05776653f, 0.09791526f, -0.07491905f, -0.08178030f, -0.03519882f, 0.01309097f, -0.11945069f, -0.05861554f, 
    0.22419190f, -0.07071736f, -0.24447089f, -0.12361608f, 0.10804789f, 0.07586884f, -0.02902218f, 0.04027079f, 
    0.04528222f, -0.04724308f, -0.01835303f, -0.09862757f, 0.03486710f, -0.14884017f, 0.01655614f, 0.10176108f, 
    -0.01444194f, -0.05071038f, 0.05712342f, 0.17014997f, 0.23266611f, 0.01675500f, 0.08915246f, -0.13401434f, 
    -0.11217581f, -0.03663990f, -0.30089450f, -0.05499164f, 0.10401747f, 0.08462884f, 0.02622074f, 0.07510998f, 
    0.12361179f, -0.00252471f, -0.02140306f, 0.00266575f, -0.64469147f, 0.10646596f, 0.09304705f, -0.05261226f, 
    -0.01252277f, 0.02763013f, -0.02829768f, -0.06948245f, 0.05752740f, -0.15054558f, 0.22866760f, -0.06903087f, 
    0.08206341f, -0.06465835f, 0.09275309f, 0.19448364f, -0.03628454f, -0.10336909f, -0.00476041f, 0.11668406f, 
    0.18966676f, -0.06005813f, -0.07840367f, -0.08517911f, 0.10118455f, -0.13512129f, -0.04048302f, -0.06042910f, 
    0.02504888f, -0.02526084f, 0.07877427f, 0.08070411f, 0.00360018f, 0.08813509f, 0.00900957f, -0.00153906f, 
    -0.01447577f, -0.30222386f, -0.03173282f, -0.02445863f, -0.00037641f, -0.15606263f, -0.12651400f, -0.02314690f, 
    0.00242807f, -0.00228036f, -0.00330464f, -0.16735727f, -0.04882133f, -0.13502184f, 0.04573550f, -0.00694200f, 
    0.08203675f, 0.02950140f, 0.05397604f, -0.00030230f, 0.00762732f, -0.00444634f, 0.14937332f, -0.03508389f, 
    0.19095114f, 0.17444050f, 0.11634733f, 0.09410752f, -0.07225114f, -0.08682014f, -0.07948085f, 0.11948254f, 
    -0.01135909f, -0.04202087f, -0.07355809f, 0.05658243f, -0.13500074f, 0.34039983f, 0.14625381f, -0.19052206f, 
    0.05029368f, -0.01151046f, -0.21091628f, 0.09653669f, -0.06051195f, -0.08392058f, 0.09863552f, -0.13141890f, 
    -0.01767781f, 0.11215532f, 0.05993097f, 0.22628085f, 0.11553863f, 0.12582107f, 0.06112137f, 0.13412605f, 
    -0.00495154f, 0.09391762f, 0.13265082f, 0.08748876f, 0.28592595f, -0.15547568f, -0.02617059f, -0.15315527f, 
    -0.00733037f, -0.03040786f, 0.00989072f, 0.07060890f, -0.05088164f, -0.17673197f, -0.09883979f, 0.02610228f, 
    0.04459689f, -0.03773424f, -0.03421093f, -0.19569464f, -0.03801122f, 0.02368340f, -0.04251351f, 0.01569926f, 
    0.09105929f, -0.18485999f, -0.14767735f, -0.02717281f, 0.03282721f, 0.10013505f, -0.23077133f, 0.09698617f, 
    0.08160711f, 0.00636183f, 0.13781928f, -0.07677542f, 0.03403590f, -0.07825132f, -0.05176900f, -0.03721005f, 
    -0.06445125f, -0.37619483f, 0.18700935f, -0.05629597f, -0.00158562f, 0.01802392f, 0.04571754f, 0.04735614f, 
    0.08703048f, 0.03504432f, -0.17710730f, 0.06738508f, 0.33967194f, 0.02106368f, -0.03222606f, 0.17799757f, 
    -0.12954004f, 0.02445259f, -0.05458536f, 0.06183580f, -0.07945304f, 0.02510632f, 0.00198714f, -0.01710511f, 
    -0.14110939f, -0.01499249f, -0.03318891f, -0.06457383f, 0.09875620f, 0.03161189f, 0.03229706f, 0.02078961f, 
    -0.08771797f, -0.03927020f, -0.00361227f, -0.01167388f, -0.20357727f, 0.06086195f, -0.04633025f, 0.19535869f, 
    0.06159520f, 0.01146980f, -0.00199445f, -0.01460555f, 0.13249338f, -0.05892234f, 0.10309823f, -0.05556585f, 
    0.13360362f, -0.21103141f, -0.13440256f, 0.09902877f, 0.00949051f, 0.04082663f, -0.01830505f, -0.05790865f, 
    0.09201239f, -0.11179006f, 0.13174295f, -0.15753382f, -0.19769169f, 0.14284177f, 0.01531435f, 0.28145581f, 
    0.02780220f, -0.12292117f, 0.05390652f, 0.06839994f, 0.06073444f, -0.03069378f, -0.01075313f, -0.19495569f, 
    -0.04088501f, 0.20362288f, 0.12574817f, -0.25046250f, 0.09045316f, -0.02758881f, -0.10762609f, 0.03481196f, 
    0.02829281f, 0.09818289f, -0.07260206f, 0.01614213f, -0.23061620f, 0.03227879f, -0.18181819f, 0.02261914f, 
    0.03874320f, 0.11838146f, 0.02314577f, -0.15156817f, 0.08794752f, -0.13644521f, -0.06283282f, 0.08943759f, 
    0.34786150f, -0.02874174f, 0.05851802f, 0.04718497f, -0.09024978f, 0.03510809f, 0.00689710f, -0.02989986f, 
    -0.03947539f, -0.02432194f, -0.02346537f, -0.17620148f, 0.31233406f, -0.00929641f, 0.04045621f, -0.07372689f, 
    -0.18671191f, 0.01178089f, -0.09827204f, -0.03051662f, -0.24873587f, 0.09962789f, 0.00678745f, -0.08294635f, 
    -0.13760979f, -0.06690010f, 0.02815036f, 0.09763942f, 0.09297200f, 0.12231652f, 0.02748021f, -0.13178255f, 
    0.01549218f, -0.04616588f, -0.18596447f, -0.17962697f, -0.14182687f, 0.13246334f, -0.01565243f, 0.00394638f, 
    -0.03792374f, 0.02062204f, 0.03754165f, -0.00406234f, 0.04218968f, 0.02264204f, 0.14462346f, 0.18449339f, 
    0.00141603f, 0.08624858f, -0.13072586f, -0.01037198f, 0.02812701f, -0.06300808f, -0.02533921f, -0.00997352f, 
    0.10440878f, -0.02343713f, -0.09181837f, -0.16980429f, 0.05631245f, -0.13126828f, -0.02634071f, -0.24898079f, 
    0.09500194f, 0.06584916f, 0.07499446f, -0.06791253f, 0.12804629f, -0.03430322f, 0.01079334f, -0.01182943f, 
    0.11072771f, 0.07829592f, 0.13806820f, -0.31809744f, -0.05280695f, -0.00125972f, 0.04223810f, -0.09947039f, 
    -0.08959290f, -0.10832072f, -0.02775491f, 0.02789232f, 0.00588025f, -0.29057699f, -0.22865915f, 0.02873288f, 
    -0.11467313f, 0.09169578f, -0.09194539f, -0.06287671f, -0.00404757f, 0.01911809f, 0.15742610f, 0.13488476f, 
    -0.15854131f, 0.04466522f, -0.18199207f, 0.28986752f, 0.02658930f, 0.02100525f, 0.04844444f, 0.06542582f, 
    0.06104896f, -0.02935716f, 0.03429150f, 0.01043996f, -0.08128203f, -0.03237495f, -0.08609078f, 0.21438868f, 
    -0.07725672f, 0.00918699f, 0.01224109f, -0.06085757f, 0.03622775f, 0.07682237f, 0.00153775f, 0.00864556f, 
    0.02041596f, 0.03825741f, -0.00416179f, -0.07606547f, 0.11004844f, -0.07301621f, 0.06390052f, 0.01620854f, 
    -0.02093058f, -0.03802533f, -0.03655631f, -0.15989798f, 0.03399986f, -0.02819762f, -0.06010336f, -0.15558380f, 
    -0.10296035f, -0.09571493f, 0.03493582f, -0.03044129f, -0.04428120f, 0.03836515f, 0.02863573f, 0.05007793f, 
    -0.01300689f, -0.00271408f, -0.13525388f, -0.09980764f, 0.03483687f, -0.00564106f, 0.03213397f, -0.12784061f, 
    -0.00560915f, -0.12777840f, 0.03522446f, -0.13804513f, -0.11449667f, 0.12492362f, 0.09218572f, -0.15355565f, 
    -0.14217253f, -0.02428402f, -0.01621076f, 0.12188923f, 0.02072624f, 0.05963148f, 0.02968938f, -0.13356146f, 
    0.27641821f, 0.08168135f, 0.20689273f, -0.32006815f, -0.08323371f, 0.17078362f, 0.03385422f, 0.08401206f, 
    -0.12460987f, -0.07209431f, -0.09742382f, -0.12066320f, -0.33621705f, 0.02161812f, 0.10300125f, 0.03004558f, 
    0.03570460f, -0.00809249f, 0.05241163f, -0.08907457f, -0.07017255f, 0.02588549f, -0.16810900f, -0.07191328f, 
    -0.35429075f, 0.03900231f, 0.02523125f, -0.11301578f, -0.08305644f, 0.02541659f, 0.10210225f, 0.08837346f, 
    0.13545232f, 0.00907363f, -0.01072137f, 0.04044059f, -0.26317260f, 0.10268525f, 0.02932743f, -0.20174567f, 
    0.00882372f, 0.02502509f, -0.04671788f, 0.08137285f, 0.05152516f, -0.02127522f, 0.03701387f, -0.00878034f, 
    -0.01062015f, 0.08475918f, 0.03330871f, -0.17161715f, -0.13997258f, -0.01418029f, 0.03358290f, -0.01634675f, 
    -0.00283144f, -0.05453993f, 0.10247470f, 0.18077932f, -0.38175899f, 0.24883772f, 0.02484505f, 0.29690900f, 
    -0.03516543f, 0.00730448f, 0.03370188f, 0.07339844f, -0.07152732f, 0.12987797f, 0.10974099f, 0.05436519f, 
    0.01095807f, 0.05437754f, -0.07952538f, 0.17225897f, -0.07386301f, 0.05247381f, -0.03466170f, 0.19869483f, 
    -0.11980788f, -0.01749254f, 0.13089480f, -0.00693183f, -0.10408472f, -0.19821061f, -0.02210042f, -0.19456485f, 
    -0.15922117f, 0.05404646f, -0.02635610f, -0.01176187f, -0.12212144f, 0.10252210f, 0.03997569f, 0.00622555f, 
    0.11245171f, -0.27532819f, 0.09136699f, -0.11648049f, 0.04505185f, -0.13312191f, 0.03682522f, -0.01714430f, 
    0.13573100f, -0.01779946f, -0.08297595f, 0.19548824f, -0.26878816f, -0.24211727f, -0.18158515f, -0.24520338f, 
    -0.01197666f, -0.05241056f, -0.09235637f, -0.02001476f, 0.03120599f, 0.01343291f, -0.00883224f, 0.06731674f, 
    -0.41264939f, 0.09359543f, 0.04960591f, -0.00213834f, -0.04374941f, 0.02767498f, 0.07712315f, 0.00111311f, 
    -0.09470753f, 0.15154763f, 0.08704856f, 0.22891913f, -0.13278361f, 0.18960820f, 0.20836921f, -0.11337195f, 
    -0.04507243f, 0.00633293f, 0.01320545f, 0.01652560f, -0.02633325f, -0.01533044f, -0.02941993f, -0.09999551f, 
    0.13474773f, 0.29448235f, 0.25713745f, -0.35802430f, 0.05326623f, 0.03543042f, -0.06912967f, -0.05032381f, 
    -0.00200670f, 0.01577152f, 0.08876539f, -0.02855789f, -0.10697756f, -0.06882841f, -0.18427365f, 0.01623492f, 
    -0.07441606f, -0.02862565f, -0.04723934f, -0.08607956f, -0.05446896f, -0.01880997f, -0.09780882f, 0.06400091f, 
    -0.51889676f, 0.17554644f, -0.10837267f, 0.20875452f, 0.06553270f, 0.07240935f, -0.15769930f, -0.01049922f, 
    0.03382153f, 0.03530072f, -0.05861222f, -0.02264803f, 0.03602033f, -0.11038812f, -0.03010469f, -0.20647785f, 
    0.10877834f, -0.13158965f, 0.01830745f, -0.13538836f, -0.03412635f, 0.02839896f, 0.12236329f, -0.15167610f, 
    0.37639093f, -0.09912492f, -0.06659216f, -0.14170811f, 0.02996995f, 0.01988927f, 0.07833499f, 0.16275349f, 
    0.02387460f, 0.06130818f, 0.06625311f, 0.05117890f, 0.04978204f, 0.12014697f, -0.24098326f, -0.23152491f, 
    -0.15929519f, 0.03274509f, -0.08860099f, -0.10932560f, -0.04795324f, 0.00630939f, -0.03689616f, 0.02255797f, 
    -0.13993588f, 0.22125013f, 0.02152682f, -0.22369367f, 0.03176853f, 0.16450785f, 0.12359452f, -0.05775332f, 
    -0.15196864f, 0.05513304f, 0.09990916f, 0.03381939f, -0.35048655f, 0.18213975f, 0.00573052f, 0.11335586f, 
    -0.02465758f, -0.06093996f, -0.02545235f, -0.00592917f, -0.05237203f, 0.13030829f, -0.07831909f, -0.04200960f, 
    -0.03390849f, 0.00924161f, -0.04863790f, 0.07882386f, -0.06010151f, -0.03996500f, 0.06590663f, -0.07275283f, 
    0.05304248f, -0.01481262f, -0.00757701f, 0.18742469f, -0.20204543f, -0.03345174f, 0.04352812f, -0.07228611f, 
    0.12581579f, 0.02926357f, 0.04183442f, -0.10565916f, -0.13143119f, 0.04959270f, 0.08470523f, -0.06464430f, 
    -0.07240988f, -0.03764069f, -0.17938587f, 0.23372667f, 0.10069966f, -0.11575624f, -0.04151956f, -0.00015567f, 
    0.01578779f, -0.05692242f, 0.08644941f, -0.01626699f, -0.32917035f, 0.19733469f, 0.01268026f, 0.19566318f, 
    -0.04935738f, 0.02095466f, -0.02865091f, 0.07419950f, 0.00690881f, 0.05299950f, -0.06590216f, -0.09085311f, 
    -0.15136327f, -0.17808169f, 0.19379134f, -0.05960490f, -0.02546298f, -0.03430995f, 0.13365287f, -0.09535521f, 
    0.03261163f, -0.00891994f, 0.03649323f, 0.07730091f, -0.26101294f, -0.04184374f, 0.03897177f, 0.20263049f, 
    0.04488480f, -0.06606072f, -0.00628222f, -0.14696383f, 0.06910647f, -0.07807637f, -0.00378774f, 0.15452281f, 
    -0.08486392f, 0.08522735f, 0.00638103f, -0.17897175f, -0.12602219f, 0.00311568f, -0.06092504f, -0.01649016f, 
    -0.02777432f, -0.08564410f, 0.05950355f, -0.00088744f, 0.02580472f, -0.41097298f, 0.06305658f, 0.00042693f, 
    -0.01093958f, -0.05219214f, 0.12020522f, 0.06979778f, 0.10261334f, 0.03937800f, 0.05499559f, 0.19646361f, 
    -0.21367656f, 0.17038029f, -0.01802109f, 0.13136233f, -0.07960443f, 0.05872741f, -0.00323852f, -0.08317273f, 
    -0.07964573f, 0.07887038f, -0.03262988f, 0.01490715f, 0.03495928f, -0.12135220f, -0.25577497f, 0.03638432f, 
    -0.05652551f, 0.08010644f, -0.02384071f, -0.06511775f, -0.01990060f, 0.02194011f, 0.06565657f, 0.00810695f, 
    0.03048790f, -0.28635225f, -0.12182139f, -0.19244991f, -0.05052013f, -0.04948181f, -0.01873720f, -0.14143421f, 
    -0.05559286f, -0.09356641f, 0.05761375f, 0.11391512f, 0.15027592f, 0.04359870f, 0.18817522f, 0.28875950f, 
    -0.08885895f, 0.08145719f, 0.19389363f, -0.04852421f, -0.09866224f, 0.05349906f, -0.07525810f, 0.00139844f, 
    -0.03856400f, -0.23392704f, -0.09556582f, 0.01518961f, 0.05625719f, -0.02234817f, 0.00992833f, -0.08246839f, 
    -0.03663520f, -0.05182331f, 0.02677061f, 0.03849380f, 0.10563462f, -0.23149413f, 0.03252099f, 0.06731223f, 
    0.13744709f, 0.05363808f, 0.10541235f, 0.02214154f, -0.01383962f, 0.05500450f, -0.03533240f, -0.01338120f, 
    0.18316923f, -0.08955181f, -0.18011473f, 0.23425475f, -0.00649509f, 0.14634705f, 0.05051119f, 0.02446437f, 
    0.01791002f, 0.10105281f, -0.04019636f, 0.01206874f, -0.11580386f, -0.09664085f, -0.03593959f, -0.06521389f, 
    -0.09258609f, 0.04877990f, -0.08496597f, 0.12075513f, 0.08214143f, -0.08802877f, -0.01597762f, -0.03207677f, 
    -0.00398594f, 0.04950564f, -0.06661100f, -0.26699942f, 0.05250250f, 0.11267792f, 0.05057897f, 0.13526146f, 
    -0.05321475f, 0.00585859f, -0.01190589f, 0.04952594f, 0.19850065f, -0.60144168f, 0.02768032f, 0.05894376f, 
    0.02051813f, 0.10310747f, 0.05082550f, -0.01027335f, 0.10161894f, -0.00194379f, 0.04267874f, 0.14386997f, 
    -0.35924247f, 0.06738427f, -0.14295700f, 0.03846122f, -0.04492376f, -0.02005750f, -0.05627039f, 0.04732920f, 
    0.00568267f, 0.05683801f, 0.02120080f, -0.00066821f, -0.05178673f, -0.08238604f, 0.02408807f, 0.05662248f, 
    -0.05491681f, -0.07060748f, 0.01797722f, -0.03375195f, 0.01376796f, -0.02764139f, 0.06977337f, -0.04067228f, 
    0.03561706f, -0.03253532f, 0.04120158f, 0.00255249f, 0.00048002f, -0.03040893f, 0.00039815f, -0.04503552f, 
    -0.03305145f, -0.01585696f, -0.04852860f, -0.06676012f, 0.15920088f, -0.00256927f, 0.04725480f, 0.23563267f, 
    -0.01986822f, -0.06745410f, -0.02458346f, -0.02096488f, -0.01469899f, -0.02597346f, -0.07869420f, -0.09008612f, 
    0.19529876f, -0.01577277f, -0.00044156f, -0.08451372f, -0.01022300f, -0.04673334f, 0.05639915f, -0.04454667f, 
    -0.11126792f, 0.03475932f, -0.07238480f, -0.02083393f, 0.26969028f, 0.02888637f, 0.02331736f, 0.19536117f, 
    0.10073724f, -0.03933553f, 0.07209893f, -0.00722629f, -0.05070253f, -0.00080463f, -0.07735372f, -0.05843876f, 
    -0.08033493f, 0.10319583f, -0.10138758f, -0.10642137f, -0.05886960f, -0.02933675f, -0.00040227f, -0.05182302f, 
    0.00300004f, 0.04987628f, -0.01265048f, -0.06762647f, 0.03511633f, 0.19755770f, 0.00222172f, 0.10961196f, 
    0.11903302f, -0.02982070f, -0.10250942f, -0.00209141f, 0.03475687f, -0.02543181f, 0.06365577f, -0.06429004f, 
    0.26749668f, -0.13444634f, 0.08331614f, -0.05357850f, -0.06659758f, 0.07280575f, -0.05490730f, 0.05795669f, 
    0.04521183f, -0.06846103f, -0.05748077f, 0.03517255f, -0.13565809f, -0.02478591f, -0.03137446f, -0.15954316f, 
    -0.00088851f, -0.01638196f, 0.02586415f, -0.00286362f, 0.03938893f, -0.07388312f, -0.04628570f, -0.01873598f, 
    -0.21914224f, -0.10439125f, -0.12002403f, -0.07172403f, 0.04097451f, -0.03952956f, 0.03497943f, -0.06095294f, 
    -0.13593085f, 0.01623421f, 0.01086565f, -0.01410227f, 0.04891550f, 0.11470081f, 0.03194334f, 0.08412367f, 
    -0.00154611f, 0.04353777f, 0.01313459f, 0.13625365f, -0.04596817f, -0.04588872f, -0.00670282f, -0.04017841f, 
    -0.17437918f, -0.07140456f, -0.00565781f, -0.18587872f, -0.00685301f, 0.05794277f, 0.01238602f, -0.07593174f, 
    -0.13665649f, -0.06917748f, -0.01542361f, -0.07217267f, 0.14634898f, 0.05088269f, 0.09416916f, 0.15848114f, 
    0.12667727f, 0.07482916f, 0.05892964f, -0.00966516f, -0.03986654f, 0.02489541f, 0.01076670f, -0.03130032f, 
    -0.05818875f, 0.14618763f, 0.03581209f, -0.03191950f, 0.01751599f, -0.01550663f, 0.04509773f, -0.03831023f, 
    -0.00863977f, 0.01893338f, 0.01543623f, -0.03166719f, 0.03455660f, -0.17719077f, -0.00643369f, 0.06500368f, 
    -0.05066919f, -0.05365619f, -0.02612562f, -0.08127087f, -0.09624387f, -0.04393152f, -0.01050781f, -0.09551360f, 
    0.05974825f, -0.05457728f, 0.02583321f, 0.08220955f, 0.01934811f, -0.08352339f, 0.01345155f, -0.02433769f, 
    -0.07516161f, -0.09801826f, -0.05438019f, 0.00721747f, 0.14430790f, -0.24389087f, 0.01790748f, 0.02671834f, 
    0.01383437f, -0.01190467f, -0.03046632f, -0.08852004f, -0.00314514f, 0.01785480f, 0.00963473f, -0.04034398f, 
    0.06501901f, 0.07494491f, 0.01486171f, 0.06104381f, -0.02576214f, 0.06385174f, -0.01667526f, -0.06163521f, 
    0.00807318f, -0.03326757f, 0.02685869f, -0.14469120f, 0.02781804f, 0.10174955f, 0.01293594f, 0.13706614f, 
    0.08152270f, 0.03467463f, -0.00820762f, -0.01331486f, 0.01743406f, -0.05873562f, -0.01542394f, 0.00494544f, 
    -0.23296036f, 0.01011794f, 0.05138963f, 0.09821480f, -0.09699347f, 0.00064316f, -0.00240916f, -0.00427779f, 
    -0.04110127f, 0.04445255f, 0.00137807f, -0.06850074f, -0.10341591f, -0.05423766f, 0.00559062f, -0.07379396f, 
    0.00576214f, -0.01157165f, -0.06148418f, -0.00787683f, -0.03354920f, -0.06308067f, -0.03112838f, -0.04320976f, 
    -0.24367774f, -0.07237937f, -0.10952865f, -0.15509707f, -0.02113942f, -0.03827981f, 0.01233788f, -0.06867801f, 
    0.07597032f, 0.03230490f, 0.04958313f, 0.01252869f, -0.03271231f, 0.14281896f, 0.05852019f, 0.01706785f, 
    -0.03745681f, 0.03958246f, 0.04573775f, 0.05706386f, -0.02865659f, 0.05661072f, 0.01479578f, -0.02175279f, 
    -0.02886087f, -0.04986474f, 0.05990783f, -0.07418423f, 0.00089715f, -0.06717946f, -0.05033855f, -0.05148145f, 
    -0.10371146f, 0.00729300f, 0.06132674f, -0.06771866f, -0.12378202f, 0.07898453f, -0.06705164f, -0.08218052f, 
    -0.05336538f, -0.01957589f, -0.00001708f, -0.04872915f, -0.00767484f, -0.03279553f, 0.00988779f, -0.08311989f, 
    0.08511130f, 0.19692071f, -0.07654775f, 0.01362690f, -0.03482904f, 0.06011518f, 0.02085571f, -0.05115767f, 
    -0.03546537f, -0.08392929f, -0.03266102f, -0.08537044f, 0.15242454f, 0.12125622f, -0.02976799f, 0.19755006f, 
    0.08072051f, -0.02667725f, -0.01640534f, -0.02164593f, 0.02554403f, -0.02266454f, -0.03364495f, 0.00435935f, 
    -0.19078489f, 0.17124838f, 0.00577826f, -0.07467810f, -0.11479910f, -0.01348913f, 0.00138338f, -0.07452697f, 
    -0.12905453f, 0.01606102f, -0.07473475f, -0.11117091f, 0.12291238f, 0.00453567f, 0.19913633f, 0.09091713f, 
    0.07206973f, 0.09480211f, -0.00688396f, -0.02695034f, -0.08437328f, 0.04032362f, -0.05368688f, -0.07842821f, 
    0.06553359f, -0.02244514f, -0.12392388f, -0.21886076f, -0.06973904f, -0.04180334f, -0.03773364f, -0.08061081f, 
    0.05848302f, -0.06995906f, -0.01992170f, -0.05790330f, -0.22495237f, -0.20460235f, -0.18575436f, -0.35308465f, 
    0.03030786f, -0.02213535f, -0.00203408f, -0.05232771f, -0.07707126f, 0.05428707f, -0.01799393f, 0.00907124f, 
    0.15984860f, 0.05353761f, 0.07372693f, 0.18184143f, 0.03856920f, -0.04426955f, 0.01301186f, 0.00969599f, 
    -0.06445817f, -0.03117657f, 0.01296485f, -0.06707058f, -0.22516420f, 0.11276914f, -0.03938454f, 0.07909671f, 
    0.06457994f, 0.00428881f, 0.00985849f, -0.05111834f, -0.01523504f, -0.02170690f, 0.04573261f, -0.10327046f, 
    0.20029061f, 0.07163277f, 0.12597661f, -0.01022291f, -0.03436594f, -0.05317267f, 0.08747955f, -0.03046479f, 
    0.00231714f, -0.00537606f, 0.03344961f, -0.03798462f, 0.07890256f, 0.13450901f, 0.17619656f, 0.15323725f, 
    0.06026492f, 0.08415967f, 0.07821367f, -0.07972555f, -0.07814639f, 0.05247314f, 0.01777543f, -0.03312164f, 
    -0.12146214f, -0.05797007f, -0.04965696f, 0.13280393f, 0.01415547f, -0.05837196f, 0.02813225f, 0.04892646f, 
    -0.02240913f, -0.06255648f, -0.09782629f, 0.00049704f, -0.16056229f, 0.01077489f, -0.09843314f, -0.18119475f, 
    0.00710702f, -0.05341274f, -0.01893030f, -0.09614645f, -0.03796634f, -0.07654465f, 0.00351350f, -0.02739462f, 
    0.09079015f, -0.00447043f, -0.23807302f, -0.17758729f, -0.12288925f, 0.00846143f, -0.05671346f, -0.03488396f, 
    -0.06568404f, -0.08346749f, 0.04679287f, -0.08432829f, 0.07241213f, 0.18100128f, 0.07388268f, 0.21081880f, 
    0.12343129f, -0.06942068f, 0.00819127f, 0.01353813f, -0.06829722f, -0.04153074f, 0.01321828f, -0.09977730f, 
    -0.13727064f, 0.00210308f, -0.16985793f, 0.00927441f, 0.03561269f, -0.00885172f, -0.08465069f, -0.06455436f, 
    -0.04141562f, 0.04558117f, 0.07124817f, -0.06106740f, -0.04678917f, 0.01357859f, 0.05316577f, 0.05992117f, 
    -0.07982662f, -0.05033147f, -0.07051644f, -0.12528940f, -0.03164496f, 0.01743513f, 0.03939865f, -0.08724872f, 
    -0.14852147f, 0.10426240f, 0.07875948f, 0.08724920f, 0.08514841f, -0.07123017f, -0.02077906f, -0.04523554f, 
    -0.08074430f, 0.02828867f, 0.05504470f, -0.06141955f, 0.03432108f, 0.16786459f, 0.11796605f, 0.19164273f, 
    0.17528547f, 0.08189031f, 0.01993783f, -0.00812032f, 0.00423950f, -0.01338175f, 0.01413787f, -0.09922878f, 
    -0.04357715f, 0.08619391f, -0.14539205f, -0.17025477f, -0.03037598f, -0.04017783f, -0.06367522f, -0.08796732f, 
    -0.09174145f, -0.03110147f, -0.00609159f, -0.00168538f, -0.05346800f, 0.11628326f, 0.03354087f, -0.06291270f, 
    -0.03424648f, 0.00420248f, 0.04062992f, -0.00479922f, -0.01352614f, 0.01634159f, -0.00064302f, -0.06407821f, 
    0.10959176f, 0.08965874f, -0.00988343f, 0.03590810f, 0.08034462f, 0.03902124f, 0.06816364f, -0.03219527f, 
    -0.01747608f, -0.04142178f, -0.06053511f, -0.01029923f, 0.01121609f, 0.01911967f, -0.01412209f, 0.02428954f, 
    -0.12934348f, -0.00062510f, 0.00258791f, -0.04531403f, -0.01504662f, -0.04090009f, -0.05853190f, -0.10542125f, 
    -0.01161729f, 0.07724404f, -0.01687010f, 0.01135923f, -0.01100190f, -0.08333311f, -0.00256295f, -0.07474004f, 
    0.02426155f, 0.01060460f, -0.01361519f, -0.08037794f, -0.21046010f, -0.06164600f, -0.13525979f, -0.17646311f, 
    -0.00024751f, 0.03925661f, -0.02040350f, -0.00524497f, -0.12320571f, 0.03065970f, 0.02367450f, -0.05727010f, 
    0.09793974f, -0.01892677f, 0.10128453f, 0.10119271f, -0.09117445f, -0.03033658f, -0.00265884f, -0.00493580f, 
    0.00475179f, 0.05867160f, -0.01064245f, 0.03997238f, 0.12988064f, 0.08526471f, -0.02418768f, 0.19545262f, 
    0.00673984f, 0.03319064f, -0.06362460f, -0.04231510f, -0.08709364f, -0.00313514f, -0.04255613f, -0.09909871f, 
    -0.29686099f, 0.13199776f, -0.08871114f, -0.12567990f, -0.04578871f, -0.03048414f, -0.05803122f, -0.09571220f, 
    -0.05933690f, -0.07011335f, -0.01412883f, -0.07996501f, 0.10597812f, -0.01747923f, 0.15392298f, -0.02831249f, 
    0.00109374f, 0.06433465f, -0.02397487f, -0.04604099f, -0.09077752f, 0.11254653f, -0.03422772f, -0.02084922f, 
    0.15370780f, 0.19494428f, -0.06388903f, 0.17807123f, 0.11634496f, 0.00850922f, -0.09512878f, 0.05489954f, 
    -0.01961602f, 0.01674565f, 0.01425564f, -0.00271536f, 0.08736280f, 0.03821871f, -0.21850757f, 0.09851813f, 
    -0.02045492f, 0.04079136f, -0.03659352f, 0.01248086f, -0.06838148f, 0.04101223f, 0.05603577f, 0.07091638f, 
    0.14774531f, 0.08468264f, 0.17182630f, 0.09378500f, 0.09091816f, 0.04858391f, -0.00369245f, -0.02736922f, 
    -0.03594438f, 0.02458602f, -0.04417350f, -0.03035315f, -0.19272290f, 0.04729421f, 0.00650482f, -0.05154570f, 
    0.08418878f, -0.19322158f, -0.00884470f, 0.09369174f, -0.08678444f, -0.00265087f, 0.08936061f, 0.01324657f, 
    0.03426252f, 0.06157340f, 0.04156191f, 0.08972351f, -0.04175165f, -0.04615612f, -0.07778611f, -0.00257813f, 
    0.03193769f, 0.05867308f, -0.06760266f, -0.00151347f, 0.25424954f, -0.23859918f, 0.11202551f, -0.00852325f, 
    0.01598717f, -0.02070637f, -0.03405631f, -0.01775617f, -0.03519887f, -0.00487500f, -0.03391853f, 0.00102719f, 
    0.00479595f, 0.12503488f, -0.17845228f, 0.15860036f, 0.12818322f, -0.09201534f, 0.06898213f, 0.00579023f, 
    0.00946125f, -0.08811491f, 0.01792075f, -0.03270211f, -0.11150282f, 0.17990230f, -0.26497519f, -0.08088336f, 
    -0.11831459f, -0.03741625f, 0.05870312f, -0.02645301f, 0.02393473f, -0.01139778f, -0.02119533f, -0.02207337f, 
    0.11417554f, -0.31193671f, 0.00660278f, 0.06742141f, -0.10525132f, -0.13553798f, 0.01469956f, -0.05635577f, 
    -0.06859237f, -0.11262061f, 0.06247206f, -0.01321787f, -0.06320276f, 0.00296955f, 0.13088454f, -0.12676366f, 
    -0.03581697f, 0.01441618f, 0.00547934f, 0.05182597f, -0.06256213f, 0.03997191f, -0.01916659f, -0.03058818f, 
    0.18901125f, -0.04403930f, -0.28583050f, 0.03361573f, 0.05750317f, -0.02842307f, -0.04804043f, -0.07435843f, 
    0.03700808f, -0.08789482f, -0.06589664f, 0.10076762f, 0.06538671f, -0.11054717f, -0.10510827f, 0.12788628f, 
    0.04558518f, -0.10257833f, -0.03756484f, -0.01950735f, -0.01544030f, 0.07408045f, 0.04397824f, 0.02635596f, 
    -0.23985836f, -0.10513701f, -0.05754535f, -0.02810442f, -0.03538669f, -0.03178252f, -0.01400874f, 0.01850570f, 
    -0.00475755f, -0.00027667f, 0.04843387f, -0.00935243f, 0.04734054f, 0.12350261f, -0.13272978f, -0.04366320f, 
    -0.00731835f, 0.02200596f, -0.11835305f, -0.04375792f, 0.01782580f, 0.01716890f, 0.04711483f, 0.00945101f, 
    0.07473692f, -0.12464760f, 0.13101558f, -0.04373581f, -0.11699416f, -0.00437939f, -0.01627338f, -0.04952041f, 
    -0.11911529f, -0.01597635f, 0.09837113f, 0.04859266f, 0.05735562f, -0.01740033f, -0.08169270f, -0.09198561f, 
    0.03332638f, 0.00363951f, -0.02058709f, 0.01284750f, -0.01825832f, 0.01004871f, -0.01337811f, -0.06380890f, 
    0.06992321f, -0.09239995f, 0.04644227f, 0.06244507f, 0.02510803f, 0.03150784f, 0.02041344f, -0.09714469f, 
    0.05354650f, 0.00760118f, 0.01558112f, 0.02260347f, -0.15613343f, 0.12315019f, -0.16662605f, -0.12533863f, 
    -0.03329863f, -0.09658159f, -0.15732387f, -0.06363403f, -0.01896949f, -0.07107083f, -0.00306385f, 0.08091030f, 
    0.16414280f, -0.09867132f, -0.03579356f, -0.12471055f, 0.12209435f, 0.05049693f, 0.04554341f, -0.08491661f, 
    0.00615239f, 0.06963176f, -0.01352802f, 0.04850114f, 0.16167635f, 0.09674155f, -0.11165620f, 0.11330493f, 
    0.01933253f, -0.00906252f, -0.08976538f, -0.04121988f, -0.04730599f, 0.05933200f, 0.05949867f, 0.07025385f, 
    -0.07758390f, -0.10807724f, 0.01479348f, 0.09744135f, 0.05271722f, 0.01632482f, -0.05761660f, 0.00846471f, 
    0.08029307f, -0.03430780f, 0.12694994f, -0.20752642f, -0.12457464f, 0.20196000f, -0.17270376f, -0.14652431f, 
    0.06590544f, 0.09071028f, -0.03300175f, -0.00241368f, 0.01977594f, 0.00616566f, 0.12457724f, -0.12902042f, 
    -0.05722981f, -0.12347630f, 0.13026607f, 0.09137096f, -0.08425418f, -0.01179609f, 0.02469749f, 0.08458262f, 
    0.06500828f, 0.02993330f, -0.02347199f, 0.06579169f, -0.02599316f, -0.17853343f, 0.08056815f, -0.03177065f, 
    -0.03056883f, 0.10275760f, 0.05523784f, -0.02694613f, 0.08195642f, -0.08121981f, -0.01069211f, 0.04809124f, 
    -0.25465542f, -0.18065281f, 0.03658662f, -0.16023967f, -0.06110182f, -0.05679856f, -0.14727591f, 0.03353029f, 
    -0.04146837f, 0.00858905f, 0.08214443f, 0.10368611f, -0.00311922f, 0.00010584f, 0.05947363f, 0.11321121f, 
    0.00772768f, 0.01373365f, -0.07025389f, 0.00400676f, 0.03865096f, -0.00135280f, -0.21112785f, -0.06914360f, 
    -0.20596929f, -0.23475540f, -0.04974756f, -0.17374061f, -0.00557532f, 0.10810443f, -0.07798425f, -0.01515895f, 
    -0.02122208f, -0.01648635f, -0.00432884f, 0.01053215f, -0.06877408f, -0.09960122f, -0.01784989f, -0.29799643f, 
    -0.04092053f, 0.02651656f, 0.00616304f, -0.04431397f, 0.01094410f, -0.06413166f, -0.02062701f, 0.07815098f, 
    -0.07583003f, -0.21394446f, 0.15886752f, -0.08902856f, -0.05945569f, -0.18126932f, 0.01801279f, 0.12126525f, 
    0.01751012f, 0.10579173f, 0.03337557f, -0.11013583f, -0.04801786f, 0.00329805f, 0.13093182f, -0.19851235f, 
    -0.03607916f, -0.03450645f, 0.05905655f, -0.01293525f, 0.00266841f, -0.06720223f, 0.01082953f, -0.07496335f, 
    -0.01177430f, 0.08002639f, -0.19027060f, 0.03605528f, 0.00579790f, -0.04630793f, -0.05856376f, -0.06074787f, 
    -0.11711148f, 0.06722990f, 0.00499934f, -0.00744746f, 0.16555773f, 0.10625146f, -0.03168582f, 0.05206917f, 
    0.05225853f, 0.01564056f, 0.00232633f, -0.09910761f, -0.08627024f, 0.01797312f, 0.02273620f, 0.04209421f, 
    -0.06254668f, 0.03773182f, 0.02330364f, 0.01769682f, -0.01749005f, -0.00022534f, 0.01201631f, -0.00190924f, 
    -0.01104563f, -0.07367365f, 0.09084719f, 0.14577688f, 0.01426466f, 0.17037547f, 0.03264666f, 0.11430503f, 
    -0.18943459f, 0.00073469f, -0.01558546f, 0.07604358f, 0.07230806f, -0.08714905f, -0.01525952f, -0.01035974f, 
    -0.21074410f, 0.02237753f, 0.02226859f, -0.18906240f, -0.07566360f, 0.04616714f, 0.02402479f, -0.00011881f, 
    0.06517500f, -0.02233840f, -0.02260391f, 0.05083150f, 0.09069629f, 0.07566483f, -0.02570590f, 0.13481253f, 
    0.15262257f, 0.03767296f, 0.03825548f, -0.11725759f, -0.01937513f, 0.02721155f, -0.04366625f, -0.03964444f, 
    0.00546922f, 0.00238549f, 0.10323558f, 0.23574351f, 0.06707098f, -0.01528133f, 0.01487907f, -0.03639874f, 
    -0.00023967f, 0.13379021f, 0.10702053f, 0.01784583f, -0.15776019f, -0.04322777f, -0.17038789f, -0.15257759f, 
    0.01149755f, 0.04731232f, -0.08819576f, 0.05377639f, -0.05554939f, -0.00877582f, 0.05953669f, 0.04495476f, 
    0.19723696f, -0.04493058f, 0.15912908f, 0.11912487f, 0.03959624f, -0.01024571f, -0.03658647f, -0.09186994f, 
    0.02174518f, -0.10436261f, 0.06419291f, -0.13658489f, -0.23442520f, -0.03040799f, 0.19509414f, -0.02919412f, 
    0.03290964f, 0.05338746f, 0.02442447f, -0.13688761f, -0.01051050f, -0.15516536f, 0.00211568f, 0.20171134f, 
    0.21033993f, -0.02571728f, -0.01460595f, 0.14605257f, 0.08697288f, -0.12025092f, -0.06985632f, -0.06160117f, 
    -0.02711190f, -0.04164198f, -0.20482688f, -0.11720213f, 0.05216152f, 0.07422547f, -0.06572009f, 0.02115070f, 
    0.11424002f, 0.06129770f, -0.00438123f, -0.00874689f, 0.05820745f, 0.05704358f, -0.04216690f, -0.03659222f, 
    0.09776159f, -0.02731842f, -0.07552277f, -0.30376336f, -0.01458874f, -0.08443308f, 0.07177187f, 0.07247832f, 
    0.01462173f, 0.09628932f, -0.01602370f, 0.09331156f, -0.01889495f, -0.01572148f, 0.14913291f, 0.16522902f, 
    -0.05467061f, -0.07892285f, -0.01374204f, 0.00278123f, -0.05691172f, 0.07607802f, -0.03546689f, -0.05240907f, 
    0.01088960f, -0.04974763f, 0.17454910f, 0.00137613f, 0.00466003f, -0.10303190f, 0.05365472f, 0.14341116f, 
    -0.03019270f, 0.02521175f, 0.06048265f, -0.15232572f, -0.16625178f, 0.03875849f, 0.07864473f, 0.06458265f, 
    -0.18819599f, -0.02418362f, -0.09568039f, -0.06645325f, 0.01139703f, -0.04442702f, -0.01340190f, -0.04686261f, 
    -0.02486688f, 0.15019482f, -0.02466600f, 0.09203212f, 0.04666285f, -0.08556338f, -0.20076524f, -0.11160166f, 
    -0.10300783f, 0.00216928f, -0.10511406f, -0.04757701f, 0.07385941f, -0.07104777f, 0.05227408f, 0.07768430f, 
    0.05850834f, 0.03426940f, -0.03395125f, -0.02130998f, -0.00068134f, -0.02200308f, 0.05135780f, -0.01225559f, 
    -0.02014173f, -0.24224488f, 0.03519730f, 0.08211442f, 0.14637238f, 0.02980521f, -0.03293533f, -0.09911469f, 
    -0.15356173f, 0.01230841f, 0.04709420f, 0.08523370f, -0.10382956f, 0.23054834f, 0.03048860f, -0.25862631f, 
    -0.00086306f, -0.06887066f, 0.01657165f, 0.08948722f, -0.00728258f, -0.04168176f, 0.11316812f, 0.03505515f, 
    -0.04489337f, 0.13124430f, -0.04987196f, -0.01620655f, -0.01752565f, -0.01123074f, 0.01176617f, -0.02518114f, 
    0.03075429f, -0.07168648f, -0.14035262f, 0.06285954f, -0.19759080f, -0.14658138f, 0.02804770f, 0.04353522f, 
    -0.06975427f, -0.00751801f, 0.02456773f, -0.06869850f, 0.03690468f, -0.02934240f, -0.03777411f, 0.09222364f, 
    -0.09669074f, -0.08970444f, 0.03122557f, -0.00144184f, 0.11447183f, -0.21845102f, -0.09820109f, -0.01270183f, 
    0.16471873f, -0.04195217f, -0.02730468f, -0.02956049f, -0.13544312f, 0.02636100f, 0.15078868f, 0.00464356f, 
    -0.01696685f, -0.07033694f, 0.10649271f, -0.09361721f, -0.04390159f, -0.13033301f, 0.01256346f, 0.08985066f, 
    0.00729307f, -0.11181878f, -0.05689016f, -0.04359524f, 0.06082663f, -0.10169183f, -0.07677031f, 0.10940426f, 
    0.03537417f, 0.04013129f, 0.05686586f, -0.14656126f, 0.20382467f, 0.07938711f, -0.09415494f, 0.12543225f, 
    0.04076308f, 0.00854258f, 0.00202965f, -0.03156500f, 0.00232223f, -0.03672922f, 0.03025599f, -0.00137254f, 
    0.10970904f, 0.03201363f, -0.00885691f, -0.12631889f, -0.07139520f, -0.02069668f, 0.07481845f, 0.13597387f, 
    -0.02575915f, 0.00766663f, 0.04883517f, -0.16663156f, -0.14067651f, -0.03661431f, 0.10849407f, -0.11943020f, 
    -0.03478589f, 0.04731939f, -0.06846768f, 0.02120734f, 0.00026972f, 0.10363226f, -0.00539941f, 0.03309399f, 
    0.04766246f, 0.23578364f, -0.19189192f, 0.05415596f, -0.07259218f, -0.00079279f, -0.02094164f, -0.10327933f, 
    0.03844319f, 0.07107862f, -0.05019525f, -0.04043672f, 0.15389445f, 0.06706696f, -0.08443106f, 0.00986906f, 
    0.13227080f, 0.06336018f, 0.00389656f, -0.02459640f, 0.06309666f, 0.03443226f, -0.00063500f, 0.04031195f, 
    0.01996543f, -0.01639944f, 0.07507440f, -0.17486541f, -0.02181239f, -0.00932337f, 0.08913569f, 0.02016422f, 
    0.07352088f, 0.04021874f, 0.02366949f, 0.01939861f, -0.03634092f, -0.05886309f, -0.13889483f, -0.21160130f, 
    0.08677304f, -0.08868454f, -0.17183529f, 0.05596818f, -0.12749672f, 0.15575740f, -0.11349598f, -0.07019746f, 
    0.10316057f, -0.04449781f, 0.08560218f, 0.18808168f, 0.06973777f, -0.02990519f, -0.02056153f, 0.04321489f, 
    0.10479879f, 0.00883273f, -0.04892389f, -0.07414728f, -0.25471923f, -0.07857698f, 0.24622725f, 0.00602490f, 
    -0.16568880f, -0.08689727f, 0.09731960f, -0.11212141f, -0.00152229f, -0.02974562f, -0.13987258f, -0.09358229f, 
    -0.24427575f, 0.17459938f, 0.01511199f, -0.01189026f, -0.00846203f, -0.00547640f, -0.07467741f, 0.04572416f, 
    0.00975944f, -0.06692266f, -0.05937402f, -0.16759180f, -0.15439411f, 0.09888414f, -0.07870673f, -0.12117127f, 
    -0.03954156f, 0.04633403f, -0.04392654f, 0.03874823f, 0.10924079f, 0.01301788f, -0.03128158f, -0.11946880f, 
    -0.00395340f, -0.00263052f, 0.06394645f, 0.14590630f, -0.06628826f, 0.06718756f, -0.01052207f, -0.04653322f, 
    -0.00227468f, -0.02098232f, -0.09779906f, -0.06436758f, 0.12769945f, 0.02243707f, -0.08994953f, 0.04839792f, 
    -0.00190315f, -0.11196689f, -0.10459976f, -0.04682024f, 0.09312658f, -0.08989435f, 0.04948703f, 0.03149296f, 
    -0.10133361f, 0.32169756f, -0.24390863f, -0.16432706f, -0.07509369f, 0.03719439f, -0.03123048f, 0.02507892f, 
    0.11624083f, 0.07049885f, 0.00144427f, 0.07694143f, 0.00237378f, -0.07093801f, -0.21275318f, 0.02934614f, 
    0.00919044f, -0.00411024f, 0.08385779f, -0.17893016f, 0.04213403f, -0.02815593f, 0.04727382f, -0.06260705f, 
    0.18790898f, 0.13981721f, -0.27471557f, -0.01188980f, 0.04183620f, -0.06840755f, -0.06249330f, -0.01321993f, 
    -0.03983850f, -0.07044473f, -0.08977830f, 0.06514522f, 0.09978519f, 0.03329320f, -0.03130720f, 0.04808918f, 
    -0.02108889f, 0.02878861f, -0.03826739f, -0.12596017f, 0.07118731f, 0.00204499f, 0.01479327f, -0.15581194f, 
    -0.01535667f, -0.13329230f, -0.18210618f, -0.17594907f, 0.01488686f, -0.11605195f, 0.03097371f, 0.01502223f, 
    0.06739288f, 0.04827087f, -0.02206340f, 0.05794065f, 0.25908223f, 0.05618496f, 0.00168482f, 0.05917296f, 
    -0.06012677f, -0.19387235f, -0.00236046f, 0.06093790f, -0.03264932f, -0.02732568f, -0.23539062f, -0.03498531f, 
    -0.27587226f, 0.03012899f, 0.31280217f, -0.06856328f, 0.00931255f, -0.04066979f, 0.02328938f, 0.07006497f, 
    0.11539724f, -0.03224625f, 0.04849236f, -0.07330865f, 0.13713622f, 0.09910677f, -0.13797125f, -0.18621249f, 
    0.01386296f, 0.04301710f, 0.04467044f, 0.07717820f, -0.03303885f, 0.02226979f, -0.27677962f, -0.00684226f, 
    0.21884280f, 0.02510538f, -0.33880684f, 0.22568128f, 0.05169641f, -0.04165319f, 0.08337808f, 0.02399988f, 
    0.03586372f, 0.03674057f, -0.06808987f, -0.08674666f, -0.11391766f, -0.15637706f, -0.03331861f, -0.37508720f, 
    -0.01215707f, -0.07448500f, -0.06491298f, 0.01412955f, -0.10946075f, -0.01723813f, -0.06358080f, -0.03684120f, 
    0.03862065f, 0.14726216f, -0.09510729f, 0.13851239f, 0.04161865f, 0.08870289f, 0.05665305f, -0.01014297f, 
    -0.00517633f, 0.05171063f, 0.08085626f, 0.01430663f, -0.28584579f, -0.08678906f, 0.09422276f, -0.16806112f, 
    0.06683541f, -0.09763128f, -0.01799408f, -0.06093542f, 0.07619717f, -0.04202157f, 0.02374398f, 0.16971378f, 
    -0.40960199f, 0.27407098f, -0.27780044f, -0.09420071f, 0.11751677f, -0.01502267f, 0.08229999f, -0.02728946f, 
    -0.05140574f, -0.08091897f, -0.04661830f, -0.12038248f, -0.14097573f, -0.26019883f, 0.06509016f, -0.02328097f, 
    -0.03183301f, -0.01584296f, -0.07271174f, 0.15258789f, -0.04822331f, -0.04199421f, -0.06283213f, -0.12327480f, 
    0.18215521f, 0.06284317f, -0.04380266f, 0.03456619f, -0.05389541f, -0.03714199f, -0.03493359f, -0.05569505f, 
    -0.03152551f, 0.16540006f, -0.01645065f, 0.12459002f, 0.11073800f, -0.09785790f, 0.15595604f, -0.03255899f, 
    -0.00925341f, 0.00672086f, 0.06303629f, -0.02837461f, -0.08440306f, 0.10807005f, -0.00859039f, 0.00383220f, 
    -0.07270853f, -0.12363074f, -0.15497805f, -0.30848569f, -0.05518045f, 0.06831677f, -0.01505949f, 0.02508808f, 
    0.00480028f, 0.04830734f, -0.06323349f, -0.03028098f, -0.20427144f, 0.10548618f, 0.11178933f, 0.17233633f, 
    0.00113302f, -0.05670767f, -0.00726862f, 0.06054443f, 0.05838463f, 0.09046204f, -0.07574903f, -0.01620060f, 
    0.06917910f, 0.26170611f, -0.02233292f, -0.02781092f, -0.01665013f, -0.10724550f, -0.03436709f, -0.02333168f, 
    0.03222920f, 0.06376015f, -0.02886796f, -0.03884204f, 0.05707461f, -0.17169137f, 0.12111755f, 0.17486423f, 
    0.10911290f, -0.17747180f, -0.00744979f, -0.11052006f, 0.05000014f, 0.06716037f, 0.05490578f, 0.14753725f, 
    -0.08606763f, 0.12298433f, 0.01409308f, 0.16374779f, -0.08419045f, -0.05253466f, 0.05546592f, 0.03691547f, 
    -0.01521700f, 0.04978950f, -0.12576903f, -0.01819999f, 0.12981170f, -0.45122227f, 0.04522343f, -0.08139309f, 
    0.10540494f, -0.03857043f, -0.02485348f, -0.09394962f, 0.03500375f, 0.04486209f, 0.17985792f, -0.07073007f, 
    0.22476086f, -0.07522623f, 0.09288539f, -0.03446402f, -0.14584368f, 0.01338850f, 0.10202824f, 0.02830298f, 
    0.04091545f, 0.03680940f, 0.06763081f, 0.05563210f, -0.07832639f, -0.00521419f, -0.00198982f, -0.12395920f, 
    -0.03008486f, -0.14072007f, 0.07241305f, -0.01865586f, -0.05810930f, -0.05928769f, -0.00800506f, 0.05503990f, 
    -0.00597973f, 0.06435026f, 0.06529425f, -0.00405834f, 0.01167273f, 0.03630278f, 0.01116547f, -0.07743461f, 
    -0.10077712f, 0.02179587f, -0.08949916f, 0.00553948f, 0.34833020f, 0.08743279f, 0.05777314f, -0.17558882f, 
    0.11120100f, -0.00652096f, 0.02547820f, -0.01739537f, -0.09600800f, 0.09819963f, 0.03450123f, 0.04127327f, 
    -0.17388570f, -0.11627702f, 0.12153896f, 0.00418907f, 0.08346135f, 0.04369552f, -0.17228369f, 0.14432563f, 
    -0.04725514f, 0.07240611f, 0.00496019f, 0.02824024f, 0.22761025f, 0.04393885f, -0.01723436f, -0.07316778f, 
    0.10290907f, 0.03550585f, 0.00299763f, 0.11274771f, 0.12421570f, -0.00185500f, 0.08119785f, 0.03698530f, 
    0.03170816f, 0.10118104f, -0.17356630f, -0.07335195f, 0.05814486f, -0.07669020f, -0.14143488f, -0.13136287f, 
    -0.01731970f, -0.07004038f, 0.03109027f, -0.28239307f, -0.00853000f, 0.14259468f, 0.06554558f, 0.10144686f, 
    0.24000925f, 0.05518632f, -0.05798431f, 0.15901776f, 0.01869491f, 0.02621065f, -0.00464966f, -0.01794654f, 
    -0.23951243f, -0.03038971f, -0.10687742f, 0.25424445f, -0.17537419f, 0.05832911f, 0.03559826f, -0.04087389f, 
    0.02709357f, 0.05627699f, -0.01687931f, -0.08216422f, -0.09479578f, 0.21442309f, -0.13176943f, -0.27775973f, 
    0.15146415f, 0.06585535f, -0.05101605f, -0.10806135f, -0.06974445f, 0.03768300f, 0.03057851f, -0.04207433f, 
    0.06244400f, 0.17960835f, -0.11274444f, -0.12830949f, 0.00886776f, 0.00299924f, 0.17259215f, -0.04630840f, 
    0.00090492f, -0.09471660f, 0.06908032f, 0.00147824f, 0.03866827f, -0.39827660f, -0.03533274f, 0.18246356f, 
    -0.09445237f, -0.04000613f, -0.00743395f, 0.13806449f, -0.00729303f, 0.01517665f, 0.04991891f, -0.17668882f, 
    -0.47682503f, 0.35375381f, -0.06201147f, -0.13094869f, 0.07892855f, -0.08121377f, -0.02448947f, -0.01274598f, 
    0.13826649f, 0.05645859f, 0.06455233f, 0.01928866f, -0.15882188f, -0.18259937f, -0.01735666f, 0.25313324f, 
    -0.08421694f, 0.02214370f, -0.09565569f, -0.03777674f, -0.10661389f, 0.08776158f, 0.05513442f, -0.06252027f, 
    -0.11740648f, -0.10362023f, -0.00118704f, 0.09551362f, -0.04097635f, -0.04621133f, -0.03892434f, -0.23038107f, 
    0.01636404f, 0.09971286f, -0.00069186f, 0.15724425f, 0.36531749f, 0.07696682f, 0.14037351f, -0.25579718f, 
    -0.07319034f, 0.04429639f, 0.10654947f, -0.10028604f, -0.04421593f, 0.05794611f, 0.00446187f, 0.02107442f, 
    -0.05514913f, -0.01688137f, 0.00171442f, -0.06302232f, 0.01806744f, -0.00759138f, 0.00482045f, -0.16569404f, 
    -0.02839257f, -0.09220872f, 0.16637242f, -0.04015376f, -0.15850636f, -0.12904641f, -0.07570567f, -0.25896588f, 
    0.05076009f, -0.11574602f, 0.07769121f, 0.01873880f, 0.13367075f, -0.11610942f, 0.03815645f, 0.00592221f, 
    0.06867029f, 0.14312924f, 0.09321139f, 0.17321968f, 0.14965276f, -0.10097326f, -0.01523022f, 0.01768546f, 
    -0.08320438f, -0.03812231f, 0.00245919f, 0.06539305f, -0.13735732f, -0.27796295f, -0.00872725f, -0.13664021f, 
    0.00070116f, 0.01620995f, 0.03635021f, 0.04670204f, -0.03052195f, 0.02239963f, -0.10049064f, -0.12721442f, 
    0.14478762f, -0.21316320f, 0.00196720f, -0.15302595f, -0.05038988f, 0.03147008f, 0.15594168f, 0.05599572f, 
    0.17396884f, 0.02048554f, 0.14673294f, -0.08072999f, -0.08630458f, 0.05589642f, -0.13947597f, -0.08826768f, 
    0.02018453f, 0.04992497f, -0.06821447f, -0.06033212f, -0.03337525f, -0.03864905f, -0.02679656f, -0.08458988f, 
    -0.37337351f, 0.10376475f, 0.09268982f, -0.19442296f, -0.04221014f, -0.04322695f, -0.07333629f, 0.03140651f, 
    -0.02804435f, -0.04280329f, -0.05362190f, 0.11131375f, -0.05205108f, -0.14225937f, 0.05227055f, 0.00689036f, 
    -0.06688437f, -0.03839926f, -0.00492087f, 0.10861553f, -0.01670828f, 0.03120305f, 0.05213772f, 0.00294109f, 
    0.07130094f, 0.15049972f, 0.23438367f, -0.00491012f, 0.06739308f, 0.05886782f, 0.01022800f, 0.00834894f, 
    0.03703840f, -0.09264760f, 0.06429638f, -0.03923040f, 0.18858518f, 0.01854696f, -0.31363612f, -0.10289821f, 
    0.07848700f, -0.04233501f, -0.15748981f, 0.08787280f, -0.05244953f, -0.02610144f, -0.00597764f, 0.18661043f, 
    -0.19889319f, -0.12745559f, -0.04382350f, -0.12074856f, -0.11076598f, 0.00299976f, 0.01613879f, 0.07791360f, 
    -0.03557797f, -0.03447108f, 0.07381607f, 0.07467127f, -0.29456317f, -0.27227762f, -0.06712364f, 0.01274030f, 
    0.06200369f, -0.03488379f, -0.08527885f, 0.04910180f, 0.00163656f, 0.00397711f, 0.08924254f, 0.00739085f, 
    -0.21883079f, -0.03479735f, 0.05421658f, 0.06188417f, -0.02055452f, -0.02620725f, 0.04138483f, -0.02213678f, 
    -0.07876733f, 0.00868833f, -0.06100626f, 0.08655979f, 0.04692581f, 0.08212122f, 0.08762374f, 0.00686307f, 
    -0.02145780f, 0.04898798f, 0.09414154f, -0.06612042f, 0.21930675f, 0.02367664f, -0.07066246f, 0.01446385f, 
    0.19937257f, 0.05138085f, 0.08471768f, 0.06756298f, 0.02822821f, -0.05807495f, -0.00323942f, -0.11495598f, 
    -0.04234036f, 0.07935910f, -0.00309354f, 0.02141302f, 0.22200440f, 0.12252915f, -0.15405773f, -0.06806680f, 
    -0.09439354f, -0.07771409f, 0.08148938f, -0.06700607f, 0.00340477f, 0.05136596f, -0.05050309f, -0.13928819f, 
    -0.15830146f, 0.01455989f, 0.13173750f, 0.18099850f, 0.00483016f, 0.06491809f, -0.05432668f, 0.13412167f, 
    -0.00130875f, -0.04860983f, 0.02090228f, 0.02921600f, 0.08913635f, 0.02404027f, 0.17296691f, -0.11977008f, 
    0.07890045f, 0.11210280f, 0.08213251f, -0.12710385f, -0.11224974f, -0.06615978f, 0.04825466f, -0.01309872f, 
    0.10781197f, 0.06845008f, -0.15665963f, -0.01752941f, 0.10027558f, -0.00033346f, -0.02736444f, -0.09477369f, 
    -0.12682705f, 0.10488441f, -0.10692124f, -0.02747362f, 0.13662046f, 0.12538771f, 0.05177129f, 0.04436835f, 
    -0.14192799f, 0.02949769f, 0.09910133f, 0.17190921f, 0.16822900f, 0.04095581f, 0.10585716f, -0.08189026f, 
    -0.47786880f, 0.30338603f, -0.12790084f, -0.22742127f, 0.06221564f, 0.06856830f, 0.02441222f, -0.07868996f, 
    -0.11348768f, -0.06074082f, 0.01406220f, -0.11307383f, 0.17642467f, -0.08652742f, -0.04562895f, 0.18962392f, 
    0.03599160f, 0.04148371f, -0.09475268f, 0.03060444f, -0.08520485f, 0.03590701f, 0.01578879f, -0.06179303f, 
    -0.26737419f, 0.08333849f, 0.26021019f, -0.10731054f, -0.04811819f, -0.05969906f, -0.06542831f, 0.07211773f, 
    0.10244425f, -0.06962248f, 0.03649842f, 0.12620482f, -0.11839369f, 0.44745880f, -0.01419007f, 0.05496090f, 
    0.06539932f, 0.03960364f, 0.02239282f, -0.10197123f, -0.15094160f, -0.03551775f, -0.11116198f, 0.15171787f, 
    -0.12590414f, -0.15686455f, 0.04391985f, -0.11159459f, 0.01453693f, -0.03892032f, -0.02517956f, 0.01107312f, 
    -0.03555226f, 0.09983922f, -0.03241047f, -0.06952748f, 0.10461237f, -0.46156690f, 0.13718492f, 0.01920532f, 
    -0.01626241f, -0.00944882f, 0.09862977f, -0.00746971f, 0.00134445f, 0.06490813f, -0.15344207f, 0.12987201f, 
    -0.21612975f, 0.18998292f, -0.11503356f, 0.23007105f, 0.09498972f, 0.04784565f, 0.00829184f, 0.00727503f, 
    -0.10956581f, -0.01715120f, 0.10153812f, 0.03635778f, 0.35221598f, -0.31881234f, 0.03837668f, -0.20532139f, 
    -0.09975153f, 0.05802741f, -0.12208662f, 0.08349536f, -0.03977624f, -0.01423701f, -0.15090057f, 0.03216914f, 
    -0.49315450f, -0.09098608f, 0.20761564f, -0.08275665f, -0.07870663f, -0.00947588f, -0.02313350f, 0.12385355f, 
    0.06089829f, -0.03736988f, 0.12731020f, 0.04930475f, -0.37436932f, 0.45672360f, -0.00714571f, 0.06885511f, 
    0.13182972f, 0.04344528f, 0.00335006f, 0.04751319f, -0.08099207f, -0.03457825f, -0.04503732f, 0.07220487f, 
    -0.02393484f, 0.01369121f, 0.02427494f, -0.26837543f, -0.12337869f, -0.02362453f, -0.05080614f, -0.05537629f, 
    0.12844633f, 0.04259757f, 0.08839805f, -0.05207221f, 0.00531437f, -0.00118300f, -0.12088481f, -0.01426453f, 
    0.08876207f, 0.05763912f, -0.06002682f, -0.09061350f, -0.02040373f, -0.03767918f, -0.02095304f, 0.02031611f, 
    -0.44446659f, -0.11509167f, 0.11712774f, 0.11668649f, 0.08461836f, -0.01052873f, 0.02247868f, -0.05818542f, 
    0.02277681f, -0.03272095f, -0.03168688f, 0.02521206f, -0.29426697f, 0.02761410f, -0.22630827f, -0.29464403f, 
    0.02367004f, -0.09212301f, -0.14607573f, 0.04886588f, 0.05845322f, -0.07654340f, 0.13854386f, -0.04143786f, 
    0.25979248f, 0.04468916f, 0.04664827f, 0.07240694f, -0.05614820f, -0.06823719f, 0.07418627f, 0.07726999f, 
    -0.07847521f, 0.03950116f, -0.03870299f, 0.02874290f, -0.03589525f, 0.16574723f, -0.05836273f, -0.13304719f, 
    0.09831556f, 0.08180282f, -0.01852056f, 0.05153691f, 0.08784171f, 0.05865419f, 0.07281365f, 0.11015298f, 
    0.00945522f, 0.13788426f, 0.07758677f, 0.06404841f, 0.02117341f, 0.00433179f, -0.10507668f, 0.01349249f, 
    -0.01549073f, -0.01315225f, 0.02425218f, 0.02078188f, -0.25823528f, -0.00413768f, -0.20317976f, 0.09906885f, 
    -0.00828529f, 0.01309796f, 0.02189923f, 0.01831794f, 0.07772354f, 0.08284361f, 0.00375721f, -0.09982207f, 
    -0.28680769f, -0.26578498f, 0.03981293f, -0.09342171f, 0.00196946f, 0.04054857f, 0.10010965f, 0.02666850f, 
    0.03360682f, 0.09300507f, 0.11790407f, 0.00836414f, -0.01783551f, -0.08162484f, 0.14548932f, -0.11649215f, 
    0.08123796f, -0.01830853f, 0.02646162f, -0.14609514f, -0.08430949f, -0.02884962f, -0.08464387f, 0.02736408f, 
    -0.09051190f, 0.02708586f, -0.01373835f, -0.02737414f, 0.00381258f, 0.02861890f, 0.04416768f, 0.03103915f, 
    0.08038784f, -0.01589511f, -0.04985631f, 0.02541050f, -0.28487492f, -0.01407828f, -0.07154021f, -0.04198371f, 
    0.11448468f, 0.00507427f, -0.14166890f, -0.06259523f, 0.03672634f, -0.00952752f, 0.00239269f, 0.11174554f, 
    -0.43864813f, 0.06969700f, 0.03315651f, -0.23994234f, 0.07707711f, 0.00472527f, -0.03575423f, 0.02911145f, 
    0.01977491f, 0.05368010f, 0.06278958f, -0.04898945f, -0.02670752f, -0.08147650f, -0.07870688f, -0.17487621f, 
    -0.02405384f, 0.10108194f, -0.04435507f, -0.10583317f, -0.00871074f, -0.10421274f, -0.15473330f, -0.16793057f, 
    0.13899204f, 0.02638435f, -0.05795557f, -0.05012670f, 0.02291405f, -0.05147338f, -0.01368009f, 0.14206195f, 
    0.08599374f, 0.06301938f, 0.14645877f, 0.06067381f, 0.01439226f, 0.04174075f, -0.09664560f, -0.07968135f, 
    0.05903570f, -0.03121497f, -0.01801389f, -0.01847414f, -0.04310796f, 0.03451899f, 0.14870261f, -0.07490440f, 
    0.18352382f, 0.02273845f, -0.01746262f, 0.03630173f, 0.03499429f, 0.13401546f, -0.01107059f, 0.18111514f, 
    0.04491250f, 0.04831007f, 0.12043457f, 0.06143808f, -0.03455838f, 0.19583003f, -0.00329253f, -0.08652932f, 
    0.05264254f, -0.00234985f, 0.01447153f, 0.09886460f, 0.04474173f, 0.14054050f, -0.12056750f, 0.02784527f, 
    -0.00887231f, 0.05216730f, 0.07398339f, -0.06321508f, 0.00025387f, 0.09931523f, -0.04265809f, 0.00790471f, 
    -0.12775815f, -0.06465766f, 0.07952215f, -0.07482030f, 0.31787938f, 0.26616108f, 0.05614125f, -0.08740409f, 
    0.06220394f, 0.08391336f, 0.00297835f, 0.08420181f, 0.03204355f, -0.03205341f, 0.09389688f, -0.12173583f, 
    0.11099765f, 0.11947609f, 0.14298591f, 0.02368677f, -0.07671098f, -0.03429610f, 0.02865392f, -0.02211492f, 
    0.04945261f, 0.08678155f, 0.04492273f, 0.09550099f, 0.08902247f, 0.01454725f, -0.00117429f, 0.12648751f, 
    -0.14501944f, -0.00354950f, -0.02390297f, -0.01482971f, 0.01858219f, -0.06016323f, 0.01818140f, 0.01760793f, 
    0.27164218f, -0.05278426f, -0.06978291f, 0.13593172f, -0.03696619f, 0.04111245f, 0.00256712f, -0.06592913f, 
    0.08659967f, 0.05428790f, -0.18050289f, -0.04207292f, -0.22454029f, -0.10102048f, 0.04424342f, -0.08916789f, 
    0.05280314f, 0.06073944f, -0.06390995f, -0.05442487f, 0.10391418f, -0.00146296f, 0.05643161f, 0.05256740f, 
    -0.05160262f, -0.09352502f, -0.03700859f, 0.05112951f, 0.03002330f, 0.04682881f, 0.04057771f, 0.12377570f, 
    0.05031589f, 0.16913931f, 0.09639441f, 0.17563240f, 0.06640235f, -0.01931368f, -0.03030099f, 0.00205914f, 
    -0.04194642f, 0.02595008f, 0.01799418f, -0.00745998f, 0.09550205f, -0.07804039f, 0.01881893f, -0.05889490f, 
    0.28858715f, 0.09702887f, -0.04205497f, 0.03363263f, 0.07413305f, 0.01032823f, 0.10691551f, 0.13540949f, 
    0.00703288f, -0.12540054f, -0.00403496f, 0.06745834f, -0.39036053f, -0.17064852f, -0.15369405f, -0.22405337f, 
    0.03506165f, -0.05032368f, -0.03752683f, -0.05649615f, 0.06245615f, -0.00810027f, 0.04748333f, 0.07924528f, 
    -0.50638866f, -0.35579127f, -0.03568133f, -0.20634359f, 0.07911099f, -0.18489899f, -0.07514016f, -0.05223925f, 
    -0.11416675f, 0.10362635f, -0.06582560f, 0.01229917f, 0.06826282f, -0.09121919f, 0.17781959f, -0.15150632f, 
    0.07775801f, 0.08059996f, -0.00545721f, -0.00285587f, -0.08837470f, 0.12586439f, -0.02811758f, -0.07545365f, 
    -0.35182536f, -0.20127802f, -0.13027713f, -0.09361645f, 0.07689280f, -0.06650911f, -0.05051105f, -0.03946334f, 
    0.09162854f, -0.10778401f, 0.00384406f, -0.01916802f, 0.16050272f, 0.03269368f, -0.00605388f, -0.01183027f, 
    -0.03336911f, -0.00184699f, 0.09629782f, 0.04534826f, 0.00244974f, -0.08071606f, -0.01637003f, -0.03957856f, 
    -0.18800598f, 0.04609665f, -0.12468489f, -0.22216447f, -0.01142295f, 0.03217252f, -0.10382162f, 0.01435273f, 
    -0.03067357f, -0.10160822f, -0.23304763f, -0.14298311f, -0.52948195f, -0.15411782f, 0.13961768f, 0.02399297f, 
    0.17387605f, 0.03581799f, 0.02224958f, -0.02231456f, -0.04696363f, -0.09525154f, -0.00941305f, 0.06207958f, 
    0.02626285f, 0.07154078f, -0.02417195f, 0.02963348f, -0.01424670f, 0.03817292f, 0.09640202f, -0.14392477f, 
    -0.00196915f, 0.23794971f, -0.01036250f, 0.07575219f, 0.09196170f, 0.05166814f, 0.02244108f, 0.07373933f, 
    -0.08524748f, -0.04310400f, 0.02201997f, -0.04486126f, 0.06908609f, 0.08918745f, -0.08203631f, 0.12094060f, 
    0.15168923f, -0.05979596f, 0.05396016f, -0.06825657f, 0.03238267f, 0.01790386f, 0.05765539f, -0.03302554f, 
    0.04359917f, 0.08071872f, 0.05612009f, -0.02895170f, 0.16495816f, 0.06414927f, 0.02314365f, -0.13101281f, 
    -0.12831964f, -0.03651809f, -0.08191693f, -0.04607736f, -0.02773051f, -0.04120220f, -0.07750056f, 0.00616631f, 
    -0.00007343f, 0.04870772f, -0.11539847f, 0.04918833f, -0.09499601f, -0.06398885f, -0.09678449f, -0.11232293f, 
    0.01141529f, -0.24732895f, -0.08526517f, -0.14565341f, -0.42545703f, -0.27900738f, -0.00093212f, -0.01247185f, 
    -0.01162403f, -0.01073769f, -0.01830257f, 0.07656443f, 0.02950013f, 0.08768287f, 0.08159546f, 0.11205458f, 
    -0.35928699f, -0.34885958f, -0.02626280f, -0.15340787f, 0.12271939f, 0.03852763f, -0.02311742f, -0.04417868f, 
    -0.00016680f, -0.01762319f, -0.03000533f, 0.07900757f, -0.00385221f, 0.04415286f, 0.13277601f, -0.02019378f, 
    0.04934596f, 0.10824544f, -0.06717376f, 0.03183774f, 0.16724215f, 0.08407492f, 0.08099606f, -0.04687627f, 
    -0.19221032f, -0.24520330f, 0.03229834f, 0.19073895f, 0.02655211f, 0.04147847f, 0.04885446f, -0.05125935f, 
    0.13400066f, -0.01578278f, -0.02253480f, 0.11248057f, 0.12469669f, 0.11317827f, 0.06596982f, 0.06121961f, 
    0.07189499f, 0.01274998f, -0.05596261f, 0.08437732f, 0.10177829f, 0.06825236f, -0.13315405f, -0.03224858f, 
    -0.59664690f, 0.09148214f, -0.21510154f, -0.12467532f, 0.13651682f, -0.12639679f, -0.15004840f, -0.10429867f, 
    0.09561405f, -0.08519517f, -0.03051222f, -0.10955300f, 0.01056137f, 0.07819377f, -0.09752820f, -0.02633270f, 
    -0.06567895f, -0.07841942f, -0.02297211f, -0.01487976f, -0.06005915f, 0.00531922f, 0.07634643f, 0.02597280f, 
    -0.43935293f, -0.24675342f, -0.01737639f, -0.07601150f, 0.08715120f, 0.02602851f, -0.07210448f, 0.00636946f, 
    0.00342876f, -0.04023165f, 0.05568713f, 0.08422123f, -0.18415758f, -0.15862192f, -0.05917972f, -0.07501346f, 
    0.00469984f, 0.05309483f, -0.01018200f, -0.09850921f, 0.08222634f, -0.08810257f, -0.07420503f, 0.07002829f, 
    0.11906565f, -0.04614395f, 0.03620580f, -0.09235913f, -0.05507310f, -0.01889423f, 0.05384784f, 0.04866244f, 
    0.08389024f, 0.12695722f, -0.04192540f, -0.02179596f, 0.14716429f, 0.21917133f, -0.04121526f, 0.01179987f, 
    0.07415147f, -0.09665132f, 0.01752650f, 0.02210495f, -0.05674844f, 0.00112012f, 0.11697924f, 0.16588886f, 
    0.00872276f, -0.06473567f, 0.04932228f, 0.01466616f, -0.07991695f, -0.03483206f, -0.06799155f, 0.02500282f, 
    0.07648865f, 0.09489042f, 0.05110028f, -0.04264901f, -0.34625158f, -0.14814635f, 0.08863343f, 0.03208929f, 
    0.02069421f, 0.02433081f, 0.03180707f, -0.11433543f, 0.05544185f, 0.08453757f, 0.01382217f, 0.14439055f, 
    -0.02935228f, 0.03153791f, -0.05090348f, 0.16213717f, -0.04294100f, -0.02031989f, 0.08052008f, -0.05053870f, 
    -0.05123281f, 0.00380294f, -0.00451537f, -0.02915215f, -0.17523646f, -0.04725664f, 0.22757456f, -0.10717139f, 
    0.01175772f, -0.05775790f, -0.04627153f, -0.20348267f, -0.15710151f, -0.02904753f, -0.31843933f, -0.01039788f, 
    -0.19360407f, -0.22841680f, -0.08273067f, -0.22376613f, -0.01816935f, -0.12368347f, 0.07632542f, 0.07907939f, 
    0.03583049f, 0.06156572f, 0.05797402f, 0.16200976f, 0.21188217f, 0.10163689f, -0.02086478f, 0.07915603f, 
    -0.04274556f, -0.15836760f, -0.09956814f, -0.01231321f, 0.00604235f, -0.04325384f, -0.15280494f, -0.03755976f, 
    -0.08010820f, -0.18227015f, 0.00360710f, -0.01006793f, -0.04169121f, 0.06603384f, -0.03928433f, -0.03448287f, 
    0.07195798f, 0.07913333f, -0.01379835f, -0.03952105f, -0.21474643f, -0.08443689f, 0.13246903f, -0.01172623f, 
    0.06335229f, 0.05436053f, 0.02693634f, 0.05412532f, 0.09419963f, -0.08772389f, 0.10140552f, -0.05581297f, 
    0.24773383f, 0.05459841f, -0.05406934f, -0.08220478f, -0.16399322f, -0.03983914f, -0.06572372f, 0.01250562f, 
    0.13436686f, 0.08261080f, -0.02511283f, -0.03251757f, 0.11074107f, 0.06525557f, -0.12604466f, 0.23509181f, 
    -0.07301996f, -0.01253070f, -0.01650484f, 0.00315008f, -0.00611442f, 0.01855736f, 0.14724874f, 0.00250091f, 
    -0.21187457f, -0.17785002f, 0.08459207f, -0.03330447f, 0.03511951f, -0.00874891f, -0.05225459f, 0.06266797f, 
    0.09639839f, -0.04080042f, 0.04340492f, -0.04633788f, -0.12141966f, 0.00893543f, -0.17508233f, 0.00880433f, 
    -0.06552552f, -0.04586694f, 0.00248422f, -0.04336476f, 0.11356380f, 0.01938393f, 0.01629484f, 0.01693591f, 
    -0.16121584f, -0.10906295f, -0.16821837f, -0.06844446f, 0.02784913f, -0.03746128f, -0.03666024f, -0.00116080f, 
    0.04835793f, 0.04895535f, -0.04874735f, -0.16441384f, -0.23724589f, -0.11293732f, 0.04191054f, -0.01312611f, 
    0.06863955f, -0.02531736f, 0.12540610f, -0.03689834f, 0.09056959f, 0.07407209f, 0.10672432f, 0.00824681f, 
    0.08042236f, 0.20313391f, 0.21835856f, -0.09503635f, 0.02825366f, -0.01059651f, 0.02750452f, 0.03442597f, 
    -0.05735052f, -0.16598962f, -0.03255472f, 0.02904856f, 0.30298293f, 0.03974353f, -0.15860051f, 0.06075743f, 
    -0.01798302f, -0.10487378f, 0.05128678f, 0.09619636f, -0.05757372f, -0.01421975f, -0.06912896f, -0.06346737f, 
    0.34780371f, -0.05891481f, -0.08711826f, -0.09149856f, -0.06659560f, -0.08930748f, -0.04592596f, -0.03844580f, 
    -0.04596415f, 0.03424133f, -0.03326897f, 0.07150191f, 0.13314272f, -0.16196571f, 0.03644646f, 0.10824274f, 
    -0.03780472f, 0.05569042f, 0.00687020f, -0.08832617f, -0.08103485f, -0.01966424f, 0.04067600f, 0.04540373f, 
    0.03771403f, 0.08059454f, 0.15368220f, 0.09426172f, -0.00661161f, -0.03383439f, 0.02360739f, 0.09956111f, 
    -0.05148380f, -0.03164287f, 0.02492413f, 0.13113667f, 0.07280489f, -0.20412579f, 0.00243069f, 0.36015043f, 
    -0.05328538f, 0.10695728f, 0.12801184f, 0.09800564f, 0.01341478f, 0.07436456f, 0.07346521f, -0.10979979f, 
    -0.43024006f, 0.26820943f, -0.00379788f, -0.10121267f, -0.01122124f, -0.06329246f, 0.11918501f, 0.06321335f, 
    0.04922082f, 0.09306987f, 0.03805572f, -0.00501892f, -0.08857211f, -0.10603024f, 0.04653673f, 0.13639300f, 
    -0.09337760f, 0.05874932f, -0.08960497f, -0.04625659f, 0.13140926f, 0.02280079f, 0.11679929f, 0.09045867f, 
    -0.00542873f, -0.07435136f, 0.02265322f, -0.05865500f, 0.10743960f, 0.08686747f, -0.06090515f, -0.03302035f, 
    0.01122344f, -0.05076174f, -0.11081228f, -0.10585140f, 0.21259716f, 0.06053776f, -0.00849680f, 0.04730479f, 
    -0.05602214f, -0.02840620f, -0.12075406f, -0.20227838f, -0.00858099f, 0.06717636f, -0.07591752f, -0.03068002f, 
    -0.36129963f, 0.10851058f, 0.13733248f, 0.09360838f, 0.06704354f, -0.10426856f, -0.02591477f, 0.06021249f, 
    -0.07509738f, 0.08271571f, 0.00151664f, -0.01121282f, 0.17270774f, -0.02987070f, -0.05476515f, -0.13138820f, 
    -0.03250036f, 0.03474705f, 0.05493482f, 0.06093498f, 0.02610278f, 0.00961549f, -0.05236237f, -0.00242870f, 
    0.30120713f, 0.15674961f, -0.10923871f, -0.21298036f, -0.00697094f, 0.01237462f, -0.03402184f, 0.03272627f, 
    -0.04294530f, 0.08498690f, 0.04056701f, 0.00482612f, -0.04620736f, 0.08978362f, -0.15552397f, 0.00946299f, 
    0.00213376f, -0.07621007f, 0.00029792f, -0.02820962f, 0.12049605f, 0.07783727f, -0.01061374f, -0.08176962f, 
    0.02436423f, -0.01211340f, 0.02525781f, 0.02908208f, -0.05913760f, -0.03944033f, 0.07176878f, 0.03664764f, 
    -0.07994702f, -0.01484493f, 0.00618793f, 0.04800824f, -0.19910140f, 0.12065586f, 0.02652692f, -0.19590612f, 
    -0.21031396f, 0.02988447f, -0.04311421f, -0.07148059f, -0.09914592f, 0.10439514f, -0.02164334f, -0.00042546f, 
    0.19705366f, -0.00661014f, 0.06353614f, 0.09366976f, -0.03157485f, 0.01035347f, 0.04487318f, 0.00507793f, 
    0.00916734f, -0.01321878f, -0.04790734f, -0.11111090f, -0.12547971f, 0.06275040f, -0.06862756f, 0.10328969f, 
    -0.04644193f, 0.09050545f, 0.02089385f, 0.10336620f, 0.06335935f, -0.01312128f, 0.09176619f, 0.03915980f, 
    -0.01106304f, 0.07441761f, 0.05722844f, -0.09223804f, -0.16572160f, 0.03079996f, 0.03499351f, -0.03159919f, 
    0.03354295f, -0.04041037f, 0.04704753f, -0.01375835f, 0.00887813f, 0.05565891f, -0.04593473f, -0.00602594f, 
    0.03132240f, -0.11623944f, -0.04096475f, 0.08167749f, 0.06420977f, -0.01199340f, -0.02477095f, 0.02793587f, 
    0.07428086f, -0.09937865f, -0.02724577f, -0.12822312f, 0.11302564f, 0.02703874f, -0.00823496f, -0.09897521f, 
    0.04491685f, -0.01249134f, 0.00857908f, -0.02903086f, -0.30265337f, 0.04997764f, 0.08172639f, -0.03215035f, 
    -0.08332061f, -0.01268655f, 0.00271108f, 0.05363789f, 0.00454428f, 0.01502965f, 0.05894353f, -0.09060592f, 
    -0.00968710f, -0.36819816f, 0.00269770f, 0.10980444f, 0.00309017f, 0.17112637f, -0.01363125f, -0.09406610f, 
    0.00477502f, 0.02647969f, 0.10399869f, -0.05128488f, 0.01373494f, -0.35330260f, -0.09529652f, 0.02214473f, 
    0.04562039f, -0.03141550f, 0.01932224f, 0.01760934f, -0.06792007f, -0.06162530f, -0.04064818f, -0.01595243f, 
    0.17251121f, 0.02245180f, -0.00711705f, 0.27107167f, 0.01119508f, 0.00490812f, 0.01825735f, -0.05816510f, 
    -0.09516656f, -0.03059824f, -0.08070302f, -0.19188738f, -0.06418842f, -0.15838751f, -0.10020791f, -0.02184048f, 
    -0.06022515f, -0.04624533f, 0.06870049f, 0.02602119f, -0.03852564f, -0.00829473f, -0.00939128f, -0.07973022f, 
    -0.14217316f, 0.06265673f, -0.05550060f, -0.19151922f, 0.09795370f, -0.15884688f, 0.13952510f, 0.07569642f, 
    -0.01446946f, 0.01454905f, -0.01365422f, -0.05413083f, 0.33519366f, -0.26899430f, -0.18152691f, 0.04385249f, 
    0.00808238f, -0.04468522f, 0.04444645f, 0.04917472f, 0.04161004f, 0.02700279f, 0.03414684f, -0.01986999f, 
    -0.25759655f, -0.21115771f, -0.01675105f, -0.24387772f, 0.06757330f, 0.10669036f, -0.00711465f, 0.05862906f, 
    -0.00179161f, -0.04249699f, -0.06379385f, 0.02994548f, -0.09444085f, 0.18567167f, 0.02993716f, 0.22648911f, 
    0.11522710f, 0.10301369f, 0.04039754f, 0.10062178f, 0.01761755f, -0.07729235f, -0.05001238f, -0.05343571f, 
    -0.14226520f, -0.24723865f, -0.06687834f, -0.12337084f, 0.00593145f, 0.00312669f, 0.10150866f, 0.04873198f, 
    0.04041846f, 0.07618689f, 0.05726685f, 0.00808057f, 0.10815340f, 0.24202482f, -0.20070168f, -0.20759790f, 
    -0.12732719f, -0.02542013f, -0.15460731f, -0.07643371f, -0.00282896f, 0.14767240f, -0.00134622f, 0.00484763f, 
    -0.35425892f, -0.13167599f, -0.11621544f, -0.37196264f, 0.03881507f, -0.12307484f, -0.01985727f, 0.11922839f, 
    0.05102412f, -0.02706465f, -0.04521719f, 0.06591852f, 0.61180443f, -0.02462608f, -0.13618325f, -0.36001134f, 
    0.01488420f, -0.07636278f, -0.15931247f, 0.09459548f, 0.04623556f, 0.09863529f, 0.06620295f, 0.03912414f, 
    -0.01120098f, -0.07853366f, -0.04147228f, -0.07166295f, -0.26128188f, 0.02103437f, -0.23015554f, -0.01108405f, 
    0.01696002f, -0.07105365f, -0.08904724f, -0.11810187f, 0.08437206f, -0.23121959f, 0.01153569f, 0.02633780f, 
    -0.00558289f, 0.04464820f, 0.02268727f, 0.12028693f, -0.08853451f, -0.05753363f, -0.04201122f, -0.08131970f, 
    -0.02659702f, -0.21880005f, 0.17602116f, 0.04954799f, 0.06483430f, -0.00197853f, -0.04254916f, 0.06089219f, 
    0.10828412f, -0.09059739f, -0.02292996f, 0.04506737f, -0.04353287f, 0.04024423f, -0.05907401f, 0.06622895f, 
    -0.03640638f, -0.02334185f, -0.02217912f, 0.01858201f, 0.00229902f, 0.01075610f, 0.01269466f, -0.09669866f, 
    -0.08482403f, -0.10161264f, 0.02276081f, 0.11122967f, 0.03036491f, 0.21449181f, 0.00656933f, 0.02377909f, 
    0.12306119f, 0.13588861f, -0.09370681f, 0.01275352f, -0.07666893f, 0.18186747f, -0.08488092f, -0.15566541f, 
    0.04417370f, -0.00876924f, 0.02031389f, 0.01223782f, 0.03009726f, -0.03715062f, -0.04899611f, -0.03285445f, 
    0.17140432f, 0.00039455f, -0.21214132f, -0.20912339f, 0.08056822f, 0.01382180f, -0.07399249f, -0.00449427f, 
    -0.01523788f, 0.02555561f, 0.06079731f, 0.01108088f, 0.16177677f, 0.03512025f, 0.04290543f, 0.06013088f, 
    -0.10467634f, 0.10851669f, -0.08642298f, -0.18463221f, -0.06062167f, -0.04681894f, -0.13375798f, -0.04370917f, 
    0.17368253f, 0.06627313f, -0.00126999f, 0.04428035f, 0.13477691f, -0.01677387f, 0.06402295f, 0.10945421f, 
    0.05265923f, 0.05633951f, 0.00186600f, -0.00892788f, -0.06238896f, -0.10379097f, 0.11812628f, 0.08460826f, 
    -0.04828371f, 0.01876158f, -0.05195460f, -0.09181286f, 0.03019311f, 0.03520879f, 0.07698570f, 0.04118130f, 
    -0.28235713f, -0.19614349f, 0.01477630f, -0.03236802f, -0.08709963f, 0.09080757f, -0.06216262f, -0.01942516f, 
    -0.03644355f, -0.13843580f, -0.01326937f, 0.09139016f, 0.06188477f, -0.06126667f, -0.06051929f, 0.02067929f, 
    -0.07381640f, -0.04016709f, -0.01247089f, 0.04903571f, -0.01155796f, 0.02329273f, 0.03505097f, 0.00607178f, 
    0.21136191f, 0.40430024f, -0.29678366f, -0.20779282f, 0.09453654f, 0.05375368f, -0.11904807f, -0.01321494f, 
    0.10854172f, -0.07421942f, 0.07364836f, 0.02452165f, -0.37634394f, -0.27597651f, -0.02641862f, -0.09744099f, 
    0.09272596f, 0.03182216f, -0.09263070f, 0.03116929f, 0.02724776f, -0.08385622f, -0.09997050f, -0.15150724f, 
    -0.17026369f, -0.05136177f, 0.01622655f, -0.09794569f, 0.07814182f, 0.01921269f, -0.08690772f, -0.04520969f, 
    -0.01527737f, -0.05368740f, -0.06870167f, -0.02299090f, 0.06717929f, 0.00682369f, -0.04522780f, 0.00970015f, 
    0.09182042f, 0.05482783f, -0.00451951f, 0.09677771f, 0.05603581f, -0.08852125f, -0.05582698f, 0.09874604f, 
    -0.07596856f, 0.04131102f, -0.12150275f, 0.04429292f, 0.07824991f, -0.00022013f, 0.04602094f, -0.14721793f, 
    -0.11201004f, -0.07095066f, -0.06245859f, 0.01693005f, 0.31655833f, 0.06298480f, -0.04975018f, -0.08714120f, 
    0.06158286f, -0.02900460f, -0.03111118f, 0.06477886f, 0.04177551f, -0.06017876f, 0.02681799f, -0.00165795f, 
    -0.14416920f, 0.05777935f, 0.03176210f, 0.00227473f, -0.02217391f, 0.02133018f, 0.02710496f, -0.09738663f, 
    0.12006579f, -0.12812525f, 0.04313471f, 0.01076939f, -0.04616126f, -0.39475814f, 0.06259455f, -0.09912273f, 
    0.00790577f, 0.05100822f, -0.13619152f, 0.01250180f, 0.00462591f, 0.00149555f, -0.08135703f, 0.04247401f, 
    0.12600312f, -0.13725612f, 0.05300335f, -0.04600253f, 0.03722818f, -0.06155818f, 0.02633580f, -0.04189592f, 
    0.01109159f, -0.03949818f, -0.04128483f, 0.00281341f, -0.05076659f, 0.01977558f, 0.13188355f, -0.06543034f, 
    -0.01810106f, -0.09014089f, 0.05299966f, -0.08432647f, -0.00105475f, -0.00566107f, 0.13742626f, -0.02319988f, 
    0.16277780f, 0.05657702f, -0.19990741f, 0.10477097f, 0.01893632f, -0.07784317f, -0.16147126f, -0.14874090f, 
    -0.04665443f, 0.03359157f, -0.02581194f, 0.08295299f, 0.19977684f, 0.05610558f, -0.20359971f, 0.21095723f, 
    -0.03862424f, -0.08342110f, 0.00952422f, 0.00626781f, 0.03983703f, 0.03180213f, 0.00092218f, 0.06648944f, 
    -0.17936145f, 0.14497846f, -0.00930258f, 0.11775669f, -0.04166210f, -0.00116223f, -0.04978165f, 0.00970535f, 
    -0.03985118f, -0.01769140f, 0.07955617f, -0.13280605f, 0.12243008f, -0.04023100f, -0.18040007f, 0.03632816f, 
    -0.08244435f, 0.03092513f, -0.02143087f, 0.14736503f, -0.15953971f, 0.05687150f, -0.07741830f, 0.00251155f, 
    -0.13228306f, 0.27280360f, -0.21464355f, 0.00781161f, 0.15617359f, -0.04748835f, -0.03010342f, -0.17511137f, 
    0.03644260f, 0.05270910f, 0.01775086f, 0.11793955f, -0.00718210f, 0.16119683f, -0.01161984f, 0.05346647f, 
    -0.00230406f, -0.02828840f, -0.06105854f, 0.06192637f, -0.07862077f, -0.01428642f, -0.00222328f, -0.01250222f, 
    -0.02884592f, -0.21986854f, -0.05434743f, 0.12874526f, -0.00531526f, 0.05271741f, -0.05615171f, -0.01247187f, 
    -0.00163550f, 0.03212175f, -0.00551363f, -0.00548507f, 0.16270897f, -0.08332749f, -0.09748143f, 0.21181834f, 
    -0.04660577f, 0.10806385f, 0.02481708f, -0.09173197f, 0.07135878f, 0.04857930f, 0.02601109f, 0.00408999f, 
    0.48858678f, -0.03973705f, -0.15023182f, -0.05348815f, 0.05761369f, 0.00711357f, 0.03088044f, -0.00379410f, 
    0.03656809f, -0.02207826f, 0.03809865f, -0.04252398f, -0.08919791f, -0.25463438f, 0.10187628f, -0.00177143f, 
    0.02825350f, 0.02533103f, 0.07477355f, -0.10419613f, 0.01049236f, -0.05381290f, -0.05432334f, 0.03398073f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04161429f, 0.00822116f, -0.06354553f, -0.01757642f, 0.00638043f, -0.00747182f, -0.01487204f, -0.06123999f, 
    -0.05046292f, 0.00265158f, 0.03704438f, 0.02599565f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
