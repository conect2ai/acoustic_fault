#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.66252279f, -0.67533416f, 0.17640622f, 0.21212630f, 0.86715949f, 0.31054243f, 0.28989747f, 0.31705841f, 
    0.56132537f, 0.21665712f, -0.10844030f, 0.01824314f, -0.20298104f, 0.28811416f, -0.09320880f, -0.17104962f, 
    0.04840922f, 0.04299663f, 0.24981944f, -0.47727162f, 0.37815416f, 0.16479124f, -0.17559735f, -0.14125523f, 
    0.48527196f, 0.35450098f, 0.52213711f, 0.78880519f, -0.29208064f, -0.33665445f, -0.68203413f, -0.28863654f, 
    0.28257969f, -0.15466578f, -0.08875568f, -0.47498259f, -0.48366624f, -0.13735211f, 0.37852871f, 0.46561199f, 
    0.26740178f, 0.00044072f, -0.37854138f, -0.08668100f, 0.08555881f, 0.19911312f, -0.42803001f, -0.14315134f, 
    0.30447757f, 0.13683434f, -0.49948680f, 0.80541843f, 1.01805604f, -0.70141786f, -0.32323956f, 0.49433523f, 
    0.28747070f, -0.01151821f, 0.00385159f, -0.35313162f, -0.37911192f, -0.19968081f, -0.08563342f, -0.22077206f, 
    -0.21266276f, 0.22600044f, -0.21630491f, 0.18989156f, 0.05055153f, 0.39524519f, -0.02851028f, 0.32369524f, 
    0.05994788f, -0.31666052f, -0.67719597f, 0.46528754f, 0.44572529f, 0.20332529f, -0.21017823f, -0.20036256f, 
    0.31143627f, -0.26295316f, 0.08099787f, 0.43017381f, 0.14267686f, 0.18023044f, -0.50282288f, -0.11628288f, 
    -0.15289368f, -0.25383592f, -0.09293145f, -0.05901170f, -0.22786447f, -0.32337880f, -0.31698707f, -0.73463744f, 
    -0.39056602f, -0.41209155f, -0.59035748f, -1.05388033f, -1.39593303f, 0.55440688f, 0.05659114f, 0.51954472f, 
    0.16950761f, -0.40284246f, 0.28249982f, 0.81673700f, 0.55419236f, -0.14881952f, -0.11004975f, -0.02861810f, 
    0.51201534f, 0.40937188f, -0.25260025f, -0.05221761f, -0.52325511f, -0.41803476f, -0.10554764f, 0.24396239f, 
    -0.03873084f, 0.01045242f, 0.18617587f, -0.03178090f, -0.14488241f, -0.78267777f, -0.94477409f, -0.98830163f, 
    -0.60281169f, -0.33514819f, -0.91665083f, -0.97432321f, -0.88690263f, -1.26977348f, -1.52502835f, 0.60044765f, 
    -0.24916688f, 0.34872559f, 0.91877639f, -0.36030087f, 0.17001404f, -0.04143240f, 0.23080495f, -0.03736891f, 
    -0.00789558f, -0.32590145f, 0.27787358f, 0.27498803f, 0.01603745f, 0.49539161f, -1.63353252f, 0.00628668f, 
    -0.81752557f, -1.86438119f, -1.13131964f, 0.20968752f, 0.34245905f, -0.21136054f, 0.36208031f, 0.38590169f, 
    -0.44116986f, -0.43159467f, 0.07230604f, -0.68875271f, -0.25358704f, 0.40317076f, 0.33460316f, -0.25902069f, 
    0.09687269f, -0.01186263f, -0.08063529f, 0.28602391f, 0.12617716f, -0.31118661f, -0.33538043f, 0.76710600f, 
    -0.03898153f, -0.04335946f, 0.25303078f, 1.00821471f, -0.30587849f, -0.02633488f, -0.21247825f, -0.45161119f, 
    -0.62230873f, -0.28342599f, -0.13207126f, 0.39267328f, 0.23588985f, 0.02620572f, -0.22473837f, 0.20675097f, 
    0.46163267f, 0.36903247f, 0.09921549f, 0.29116556f, -0.25566128f, -0.02556039f, 0.36290449f, -0.23665868f, 
    0.88900107f, -0.73976249f, -0.42963931f, -0.41893730f, -0.88835412f, 0.42899716f, -0.62105483f, -0.02744617f, 
    0.71562332f, -0.43586144f, 0.58549082f, 0.36532414f, 0.28657699f, -0.08168997f, -0.00897051f, -0.28168005f, 
    0.10190954f, 0.03216066f, -0.08843271f, -0.15329048f, -0.47970629f, -0.21820560f, -0.02602762f, -0.22062780f, 
    -0.86395913f, 1.02001667f, 1.37037241f, -0.02303637f, -0.89429271f, -0.88281775f, 0.20417218f, -0.15386237f, 
    -0.29278409f, -1.17528021f, -1.07728457f, 0.07378382f, 0.11113110f, -0.21066795f, 0.10338828f, -0.10874385f, 
    0.06018950f, -0.20251715f, 0.08269446f, -0.23850393f, -0.18973158f, -0.20646097f, -0.08484586f, -0.32991520f, 
    0.06230039f, -0.16821681f, 0.49493080f, 0.09771723f, 0.41262245f, 0.16274340f, 0.31099311f, -0.10954137f, 
    -0.87286800f, -0.12515223f, -0.08244339f, -0.37286106f, 0.21509442f, -0.40799192f, -0.03307645f, 0.36618930f, 
    -0.04720556f, -0.42314079f, 0.06376185f, 0.22774225f, 0.21616024f, -0.17347845f, -0.43781295f, -0.05655493f, 
    -0.36149219f, -0.33722880f, -0.24990410f, 1.45953977f, -1.07163692f, -1.21756124f, -0.61249632f, -1.09962380f, 
    1.17581403f, 0.90527076f, 0.62881404f, -0.18181989f, 0.12602380f, -0.03076373f, 0.47676280f, 0.14360018f, 
    0.07777738f, 0.13126038f, -0.12247027f, -0.15343700f, 0.06512576f, -0.13453475f, 0.03815086f, 0.24725996f, 
    -0.30068812f, -0.25419793f, 0.34896353f, -0.05534837f, -1.54665470f, -0.55888104f, -0.39819178f, -0.64434206f, 
    0.44483423f, 0.93279868f, -0.52026570f, -1.22772241f, -0.63561147f, 0.24879831f, -0.72595739f, -0.67138696f, 
    -0.59433031f, -0.04712619f, -0.39816678f, 0.18628058f, 0.11835513f, 0.07867090f, 0.33299914f, -0.15913896f, 
    -0.01999933f, -0.26396668f, -0.53553975f, -0.04325909f, -0.25148490f, 0.87213624f, 0.67718852f, 0.46441734f, 
    0.34378305f, -0.59991533f, -1.05049348f, -0.77388048f, 0.07097127f, 0.29959783f, 0.42720205f, 0.12988582f, 
    0.15474276f, 0.30644521f, 0.69639260f, -0.04265846f, -0.01545030f, 0.09582037f, 0.29833826f, -0.27903259f, 
    -0.26940578f, 0.13695413f, 0.05618459f, 0.10445593f, -0.12148217f, -0.07280689f, 0.47866213f, 0.18870747f, 
    -0.75705570f, -0.98848718f, -1.01680875f, -0.19997817f, -0.11963709f, 0.39333037f, 0.63506144f, 0.39467800f, 
    0.07108217f, -0.14045759f, -0.09815426f, -0.23941925f, 0.06437209f, -0.26374048f, -0.41871235f, -0.59311444f, 
    0.40219691f, -0.01028512f, -0.17635635f, 0.21797191f, -0.26096749f, 0.10252125f, 0.61230445f, 1.01811552f, 
    1.17983520f, 0.21390472f, -0.37715077f, -0.56598997f, -0.38457158f, 0.36634618f, 0.00856456f, 0.09448693f, 
    -0.11397300f, -0.14445019f, 0.31378755f, -0.20105086f, -0.14060302f, -0.58371121f, 0.27338123f, -0.37495172f, 
    0.11296037f, -0.18168579f, -0.21328285f, 0.11169714f, 0.01649346f, -0.08691897f, -0.35361227f, 0.27351478f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.49622542f, 0.57125968f, 0.19815820f, 0.13152163f, 0.89038289f, -0.14911768f, -0.17398535f, 0.38621056f, 
    -0.12785833f, 0.37985227f, 0.30034229f, 0.55331463f, 0.19797251f, 0.30100524f, 0.77335733f, 0.89103699f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06855003f, 0.16657692f, 0.07781339f, -0.02660090f, -0.02799015f, 0.05101217f, 0.10138762f, 0.01641019f, 
    -0.21695991f, -0.01259166f, -0.24553628f, -0.19965227f, -0.06741571f, -0.02825736f, 0.11183026f, -0.17358263f, 
    -0.04997014f, -0.00521326f, -0.21349172f, 0.08912790f, 0.00655775f, 0.00858428f, -0.03711465f, -0.00024757f, 
    -0.79487085f, -0.31439897f, -0.53162909f, -0.03855247f, 0.11604096f, 0.16235435f, -0.14585358f, -0.02094933f, 
    -0.06911546f, 0.13052949f, -0.01732000f, 0.01990756f, -0.73498732f, -0.33526897f, -0.14798830f, 0.01059352f, 
    -0.00669219f, -0.03670309f, -0.10560910f, 0.01618009f, -0.05538148f, -0.11514141f, 0.00993080f, 0.30563551f, 
    -0.50165766f, -0.59091938f, 0.34016258f, -0.05473465f, 0.01747187f, -0.03194172f, 0.08100524f, -0.02948469f, 
    -0.02013472f, -0.26398796f, 0.15416557f, -0.08889975f, 0.71326393f, 0.35541520f, -0.37230954f, -0.48596343f, 
    0.14353850f, 0.06922580f, 0.03213318f, 0.02804422f, -0.01749928f, 0.03300153f, 0.03409174f, -0.10247070f, 
    0.22050795f, 0.25728843f, -0.13172725f, -0.09508532f, 0.17832267f, 0.60767239f, 0.06442519f, 0.18584606f, 
    0.08110536f, 0.16883875f, 0.09739731f, 0.06429084f, -0.03293571f, -0.06188639f, 0.08147895f, 0.07856200f, 
    -0.14232594f, -0.50231165f, -0.13661617f, -0.13400066f, -0.01982673f, 0.09119335f, 0.01095292f, -0.01187930f, 
    0.34755221f, -0.32926726f, -0.18338175f, 0.14495869f, 0.13726471f, -0.05742268f, -0.06226310f, 0.06789929f, 
    -0.00457574f, 0.19543338f, 0.13544491f, 0.26304007f, 0.11751019f, -0.15531300f, -0.51886207f, 0.00268337f, 
    -0.17609355f, -0.28176096f, -0.41719443f, -0.12715955f, -0.15848352f, 0.11843114f, -0.01649456f, -0.00863522f, 
    -0.09239156f, 0.11086822f, 0.02076927f, -0.12507607f, -0.04160407f, -0.07621911f, -0.12423000f, -0.15642792f, 
    -0.00149057f, 0.01721045f, -0.06038061f, -0.01086374f, 0.07789353f, -0.21647191f, -0.54995018f, 0.38822731f, 
    0.09122692f, 0.04693899f, -0.09426174f, -0.02789727f, 0.03812688f, -0.05092981f, -0.03890559f, -0.02732438f, 
    0.67647743f, 0.41055113f, -0.25092235f, -0.19212048f, 0.17895761f, 0.37346521f, 0.08487576f, 0.16455238f, 
    -0.05602969f, 0.03434712f, 0.06563806f, -0.20281909f, -0.05496012f, -0.13707529f, 0.23559393f, -0.00411611f, 
    -0.19907565f, 0.00022886f, 0.07230847f, 0.02947843f, -0.08014417f, -0.01776486f, -0.02546558f, 0.05017864f, 
    -0.20795231f, -0.36935574f, -0.15967664f, -0.04956374f, 0.30480349f, -0.15265884f, -0.39252353f, -0.24366494f, 
    0.02326544f, -0.40261087f, -0.21967366f, -0.16238198f, -0.49499485f, -1.16650760f, -0.55738914f, 0.16113053f, 
    0.01074001f, 0.02542813f, -0.01299336f, -0.08747004f, -0.16837317f, -0.13321143f, -0.13329773f, -0.11816705f, 
    0.02333986f, 0.06735125f, 0.00962283f, 0.20527877f, -0.14340372f, 0.06746404f, -0.15214589f, -0.04381117f, 
    0.06496590f, -0.05657465f, -0.18869852f, 0.06739476f, 0.21754760f, 0.02789618f, -0.06899915f, -0.01528849f, 
    0.08572394f, -0.07626013f, 0.11357373f, -0.22681090f, 0.04589682f, 0.02599627f, 0.10417009f, -0.11189818f, 
    0.15071340f, 0.11922059f, -0.11641964f, -0.01215925f, -0.21166377f, -0.17368360f, -0.16012512f, 0.17753845f, 
    -0.10651812f, 0.07990116f, 0.24885966f, -0.23765886f, 0.09097479f, 0.33986184f, 0.29091316f, 0.02534896f, 
    -0.03238466f, -0.00421471f, -0.10959953f, 0.07445479f, -0.41496989f, 0.03579384f, -0.36926645f, -0.66727901f, 
    -0.22006130f, -0.28406435f, 0.14711857f, 0.13649464f, -0.05549845f, -0.16779482f, 0.05117445f, 0.01671003f, 
    0.01723146f, 0.15393656f, -0.09203162f, 0.10864481f, -0.17038900f, -0.14211252f, 0.24096128f, 0.15099798f, 
    -0.13834459f, -0.03263584f, 0.49144015f, -0.31983361f, -0.04788059f, 0.02010540f, 0.04311906f, 0.01721310f, 
    0.14149098f, 0.39479312f, 0.15941936f, -0.03822875f, -0.08599908f, 0.09162078f, -0.41972688f, -0.28269014f, 
    -0.14920156f, -0.09706166f, -0.04983268f, -0.13095805f, 0.10299039f, 0.26473483f, -0.08223697f, 0.07836390f, 
    0.17059727f, -0.30584151f, 0.07459550f, -0.21719803f, -0.05419302f, -0.13167970f, 0.12938337f, 0.02614342f, 
    -0.15821898f, -0.22357738f, 0.00669150f, -0.21804699f, -0.02339349f, 0.11021651f, -0.02151618f, 0.06726826f, 
    -0.06242077f, -0.10530362f, -0.15716521f, 0.05506964f, 0.29437980f, -0.68359727f, -0.11588105f, -0.35889986f, 
    -0.20604862f, -0.15243615f, 0.14882495f, 0.09361885f, 0.01554912f, -0.04782423f, -0.23473838f, 0.15822513f, 
    0.04955310f, 0.22405496f, -0.12367789f, -0.72557008f, -0.01980131f, 0.03762249f, -0.09365609f, 0.15992640f, 
    -0.17986482f, -0.01277336f, 0.09562866f, 0.12599070f, 1.13596559f, -0.76198733f, -0.40690073f, -0.18621774f, 
    -0.03508600f, 0.05852701f, 0.05749249f, -0.13338940f, 0.12114966f, 0.09291789f, 0.03752163f, 0.01308598f, 
    0.26395971f, -0.06498567f, -0.08099080f, 0.26010054f, 0.18995993f, -0.11526509f, -0.29806378f, -0.03003101f, 
    0.08962782f, -0.05481898f, -0.00408429f, -0.02083703f, -0.00217583f, 0.05045783f, 0.14727311f, -0.19071509f, 
    -0.06471647f, 0.05199927f, -0.14577220f, 0.02848061f, 0.11108887f, 0.02862279f, 0.13496931f, 0.01317334f, 
    -0.26271778f, -0.03592158f, -0.09348219f, -0.38751820f, 0.12119980f, 0.36407799f, 0.05297038f, 0.01650306f, 
    0.00006229f, 0.25935942f, -0.17236632f, -0.12652291f, 0.76136434f, 0.15563294f, 0.68957508f, -0.18130814f, 
    -0.10572802f, 0.03096296f, 0.00662242f, 0.03164676f, -0.02192868f, -0.06860289f, -0.05553035f, 0.11648098f, 
    -0.06271029f, -0.10125355f, -0.10148441f, 0.09348146f, -0.06846488f, 0.06071317f, 0.02859624f, 0.17447652f, 
    -0.11617532f, 0.10444100f, -0.04884159f, 0.02474694f, -0.28044808f, -0.12549554f, -0.01011140f, 0.05167482f, 
    -0.10175181f, 0.07352250f, 0.05025391f, 0.10708950f, -0.03284827f, -0.02087520f, -0.12455646f, 0.00780141f, 
    0.30731404f, 0.17161982f, -0.12369715f, -0.34405816f, 0.19029418f, -0.01776883f, -0.17001003f, 0.15432735f, 
    0.07421828f, 0.20652294f, -0.03423582f, -0.06465884f, -0.11261152f, 0.04228287f, 0.02111427f, -0.09395619f, 
    -0.01042354f, -0.07585938f, 0.09547019f, -0.04175022f, 0.18664990f, 0.07629953f, -0.03406043f, 0.26630494f, 
    0.02884439f, 0.07985506f, -0.47379583f, 0.36659017f, 0.00855242f, -0.00255780f, 0.12637214f, 0.02324061f, 
    -0.12955418f, -0.03679636f, 0.04060790f, -0.02153264f, -1.17716038f, -0.89737797f, -0.32562363f, -0.52897924f, 
    -0.12466462f, -0.19610073f, 0.09329933f, 0.12007080f, -0.01577802f, -0.05977163f, 0.08935315f, -0.08332478f, 
    0.16189523f, 0.75788182f, 0.38544521f, 0.76287431f, -0.09928561f, -0.05562261f, 0.12407303f, 0.06926845f, 
    0.06317771f, -0.03437478f, -0.01837280f, 0.10488337f, -0.21986793f, 0.12616816f, -0.12706220f, -0.06512619f, 
    -0.07728322f, -0.26312554f, 0.47360450f, 0.38496539f, -0.07590172f, -0.01481605f, 0.01982198f, -0.10520194f, 
    -0.14909457f, 0.28650388f, -0.01919414f, 0.10802468f, -0.05965769f, -0.07726569f, 0.01606835f, -0.23239297f, 
    0.20653981f, 0.00542531f, 0.10367469f, 0.30520472f, -0.51980168f, -0.46696717f, 0.28761086f, -0.99013019f, 
    -0.03037518f, -0.22544499f, -0.54414356f, -0.48702940f, 0.05102358f, 0.07803215f, -0.05151898f, 0.08501564f, 
    -0.24663970f, 0.02069661f, 0.08774348f, -0.08393182f, 0.11461713f, -0.03594636f, -0.23585929f, -0.06906537f, 
    0.03916831f, -0.11287557f, -0.02057187f, -0.04070798f, -0.16461979f, 0.62563443f, 0.60435486f, 0.16677570f, 
    -0.14849296f, -0.02143792f, 0.12768079f, -0.16666761f, -0.03337100f, -0.03293009f, -0.11136066f, 0.09019156f, 
    -0.46660647f, -0.44862989f, 0.50475174f, 0.28144616f, 0.04403457f, -0.08754961f, -0.08292603f, 0.17306004f, 
    0.02041482f, -0.03522547f, -0.00123165f, -0.02634772f, -0.55651331f, -0.02443440f, 0.13082150f, 0.11958023f, 
    -0.17390348f, 0.02722718f, -0.21483244f, -0.22839561f, 0.10752672f, -0.13400976f, 0.03254860f, 0.03484532f, 
    0.12256978f, 0.76790518f, -0.09192065f, 0.24865563f, 0.10593838f, 0.16273901f, -0.13015386f, 0.17139806f, 
    -0.00940759f, 0.01829759f, -0.40593380f, 0.07829390f, -0.19712968f, -0.40024823f, 0.44452444f, -0.76686203f, 
    0.03634615f, 0.06433744f, -0.20893317f, 0.09969362f, 0.08509860f, -0.13472857f, 0.10525671f, -0.03536064f, 
    -0.38126215f, 0.31691715f, -0.11779787f, -0.63194799f, 0.45707008f, 0.18030211f, 0.19673695f, -0.11268166f, 
    -0.31762397f, -0.10584834f, -0.17479318f, 0.06017621f, -0.00513926f, -0.35612684f, 0.29734787f, -0.15401478f, 
    -0.49420404f, -0.18816234f, 0.06690982f, -0.11916118f, -0.05815238f, -0.08839750f, -0.10614492f, -0.10282300f, 
    1.12621808f, 0.21816009f, 0.70595288f, 0.24602407f, -0.11104409f, 0.41354051f, -0.10842949f, 0.09696993f, 
    0.04478825f, 0.04954593f, 0.12844069f, -0.15293470f, 0.14579317f, -0.20731086f, 0.14291599f, -0.11480130f, 
    -0.23410758f, 0.12493988f, -0.27151304f, 0.02417603f, -0.00033925f, 0.09524319f, 0.01120710f, 0.13440223f, 
    0.43869907f, -0.20213513f, -0.29253730f, -0.73193514f, -0.12477844f, -0.01593269f, -0.28990412f, 0.03834343f, 
    -0.15811102f, -0.16733778f, -0.05720798f, -0.14828895f, -0.19790691f, -0.33966771f, -0.19233598f, 0.18281645f, 
    0.04661435f, 0.07554036f, -0.25259092f, 0.09292410f, 0.09393995f, 0.01799508f, -0.02813688f, -0.21753334f, 
    0.96991616f, -0.29021409f, 0.07154512f, 0.36584035f, 0.08535824f, -0.09354939f, -0.10078148f, -0.12601079f, 
    0.14576536f, 0.27248564f, 0.04433206f, 0.37758607f, 0.27381751f, 0.02225593f, 0.17744213f, 0.92575055f, 
    -0.03995993f, -0.01465220f, -0.10050336f, -0.36393216f, 0.13971418f, 0.01511910f, 0.03174469f, 0.14808647f, 
    -0.59055662f, -0.35514748f, -0.20713221f, 0.19728267f, 0.10507251f, 0.25987333f, 0.15553443f, -0.13985783f, 
    -0.10252719f, -0.01140619f, -0.16649716f, 0.15105224f, -0.24973141f, -0.04595299f, 0.48401618f, 0.31165892f, 
    0.10138503f, -0.10594521f, -0.01483047f, 0.16519238f, 0.04199789f, -0.06854887f, 0.02719531f, -0.11080512f, 
    -0.14034930f, -0.50006080f, 0.39672020f, 0.02006060f, -0.13937005f, 0.08235911f, -0.12932305f, -0.03018692f, 
    0.07690897f, -0.04826405f, 0.07977473f, 0.18995886f, -0.75474882f, 0.23500748f, -0.04857294f, 0.51257092f, 
    0.35129842f, 0.17051277f, 0.17378712f, -0.05651178f, -0.07340733f, -0.09176040f, 0.09975434f, -0.00371779f, 
    0.03830395f, 0.05230390f, -0.06109481f, -0.02904501f, 0.04910105f, 0.04336752f, -0.12498719f, -0.15465072f, 
    -0.29649797f, 0.04126267f, 0.02554381f, -0.02557155f, 0.00731412f, 0.01469069f, -0.06415533f, -0.33361682f, 
    -0.38496611f, -0.08465710f, -0.10948825f, -0.27857801f, 0.06109756f, 0.03059993f, -0.04835435f, -0.13034371f, 
    0.10124484f, 0.19516481f, -0.24829398f, 0.54509294f, 0.05909538f, -0.16909282f, -0.23684831f, -0.05487632f, 
    -0.15481493f, 0.08237233f, -0.02941170f, -0.13548616f, -0.41891679f, -0.20520854f, 0.18590266f, -0.12838119f, 
    -0.07451993f, -0.05369913f, -0.59815550f, -0.12638560f, -0.32071719f, -0.04575134f, 0.18235257f, -0.03347610f, 
    0.23012219f, 0.11678822f, 0.13327321f, 0.06862110f, 0.10176156f, -0.01419883f, 0.00595309f, 0.02732116f, 
    0.12255841f, -0.00892486f, -0.16503923f, -0.25693297f, -0.26474369f, 0.01839743f, -0.21795540f, 0.14448433f, 
    -0.17822702f, 0.15893058f, -0.40457880f, 0.21910350f, -0.05198746f, 0.03176894f, -0.23862605f, -0.12881546f, 
    0.39392713f, -0.35501701f, -0.29729381f, 0.12844498f, 0.15456663f, -0.17517653f, 0.14727092f, -0.35595670f, 
    -0.10206912f, -0.21707544f, 0.05748262f, 0.06142267f, 0.02395954f, -0.02601705f, -0.31144032f, -0.00453358f, 
    -0.00718954f, -0.15392934f, -0.08379637f, -0.09133909f, 0.15365757f, 0.04756447f, 0.13879533f, 0.43535694f, 
    -0.08306225f, -0.30073097f, -0.04953571f, -0.45944273f, -0.14340629f, 0.01077679f, -0.08321330f, 0.06923290f, 
    -0.19333136f, -0.28400829f, -0.32688767f, 0.04887728f, 0.29640231f, 0.30067834f, 0.42826414f, 0.35978150f, 
    -0.11617683f, -0.02029288f, -0.23936833f, 0.22642653f, 0.00647307f, 0.02214807f, 0.05673313f, -0.09338147f, 
    -0.33946538f, -0.09654646f, 0.11602362f, 0.17749138f, -0.13603750f, -0.24585864f, -0.13165228f, -0.04987991f, 
    0.09938172f, -0.03510262f, 0.19228491f, 0.05238613f, 0.20996310f, -0.00943400f, 0.24636108f, 0.11849512f, 
    0.09127266f, 0.21558611f, 0.14855427f, 0.15224153f, 0.04653341f, -0.15380752f, -0.08031841f, -0.00493815f, 
    0.07542861f, -0.08411958f, 0.24402335f, 0.05149711f, 0.13088448f, 0.00746821f, -0.06002502f, -0.17727453f, 
    0.33395964f, 0.22272183f, 0.01127716f, 0.10559998f, 0.09529290f, 0.68735439f, -0.31680602f, 0.35083172f, 
    0.31397730f, 0.14193375f, 0.11484782f, -0.04490571f, -0.07548329f, 0.14065890f, 0.08928355f, -0.25331008f, 
    0.26845801f, 0.27303407f, 0.00361388f, 0.20968612f, -0.09645071f, -0.10747152f, 0.08293881f, -0.11699073f, 
    0.04439114f, 0.14936018f, -0.04788310f, 0.09995936f, -0.14616260f, 0.00954124f, 0.16777582f, 0.01649854f, 
    0.05568817f, -0.19654730f, -0.04771804f, 0.03932504f, -0.12422463f, -0.11551403f, -0.04410208f, 0.09890598f, 
    -0.31834328f, -0.18990998f, 0.29429099f, 0.09754455f, -0.07762861f, 0.00634034f, -0.11900694f, -0.05947011f, 
    -0.06813487f, -0.04704846f, -0.00606570f, 0.12857963f, -0.08498389f, -0.10311315f, -0.11713126f, 0.21268702f, 
    0.12894365f, 0.17393419f, 0.01399148f, 0.02087786f, 0.05802061f, 0.10533708f, -0.06838518f, -0.06826629f, 
    -0.59313887f, -0.00370400f, 0.05580200f, -0.17640172f, -0.27364972f, -0.21045110f, -0.17608468f, 0.03998952f, 
    -0.20300840f, -0.24230167f, -0.03585996f, -0.10493831f, -0.30616164f, -0.07440674f, -1.12959123f, -0.13850145f, 
    0.04560036f, 0.02062649f, -0.00397010f, 0.07257895f, 0.15045705f, 0.05510431f, -0.08345372f, -0.16099310f, 
    -0.11356350f, -0.31691393f, 0.17673789f, 0.09670768f, 0.00048582f, -0.13144000f, -0.04571264f, -0.11536573f, 
    0.08036223f, -0.07928844f, 0.38211915f, 0.12986183f, -0.30372939f, -0.04965037f, -0.03029955f, 0.27598402f, 
    0.20245817f, 0.00731278f, -0.27702275f, 0.11041811f, -0.10862842f, -0.00593058f, 0.04432273f, 0.14982633f, 
    -0.74554491f, 0.14557964f, -0.14312562f, -0.01628691f, 0.02810530f, -0.06516413f, 0.11858847f, 0.06583141f, 
    0.27260843f, -0.08360302f, -0.41604924f, -0.13357359f, 0.14000171f, -0.32583910f, -0.41949907f, 0.01156428f, 
    0.10760017f, 0.18020883f, 0.11024705f, 0.00097953f, 0.21161178f, -0.65586406f, -0.50985253f, -0.41628879f, 
    -0.46020746f, -0.00417713f, -0.13739580f, 0.58020175f, 0.21014582f, -0.07281468f, -0.10176076f, 0.03096759f, 
    0.18340838f, 0.12688114f, 0.12930299f, -0.15243806f, 0.01704746f, 0.28106841f, 0.19659676f, -0.12109667f, 
    0.27417433f, 0.25643170f, 0.10173999f, -0.06522527f, 0.06379352f, 0.06774213f, -0.00510855f, 0.10987522f, 
    -0.56802577f, 0.22168176f, -0.18044274f, -0.27887785f, 0.33374804f, -0.21176998f, 0.27405715f, 0.04008677f, 
    -0.10341822f, -0.12179036f, 0.08043882f, 0.01311096f, -0.10358659f, -0.40653896f, -0.00022790f, -0.17412826f, 
    -0.14303070f, 0.19351245f, -0.07612307f, 0.25952408f, -0.01376619f, 0.07534685f, 0.03193194f, -0.10742129f, 
    0.19894907f, -0.00152184f, -0.17774178f, -0.23356389f, -0.01572218f, 0.08983193f, -0.08449202f, 0.02488958f, 
    -0.15196855f, -0.46566358f, 0.40967429f, -0.36314437f, 0.13331796f, 0.33792683f, -0.42298105f, -0.10666541f, 
    -0.12605545f, 0.17247947f, 0.02827008f, -0.03070426f, 0.01081520f, -0.16647647f, 0.02128912f, -0.20136546f, 
    0.14886443f, -0.13905181f, -0.00915496f, 0.20369625f, 0.04256396f, 0.06038786f, 0.10982087f, -0.09402478f, 
    0.10444293f, -0.05080632f, -0.09027082f, -0.17265500f, -0.43149641f, -0.27850595f, -0.42721403f, -0.35953447f, 
    0.06738301f, 0.14153941f, -0.09399022f, 0.01344144f, 0.18527985f, 0.09487820f, -0.05553201f, -0.32684889f, 
    -0.32714048f, 0.25254399f, 0.26824975f, -0.29231375f, 0.05235104f, -0.13506582f, 0.06870779f, 0.06298762f, 
    -0.09193742f, -0.02168445f, -0.05387549f, 0.12189059f, -0.00030183f, -0.22723615f, -0.14914514f, 0.17670648f, 
    -0.04673826f, -0.06258240f, 0.04970868f, -0.05562631f, -0.07913233f, 0.14700626f, -0.10529918f, -0.11616387f, 
    0.42831638f, -0.37377745f, -0.01685625f, 0.16327272f, -0.10886823f, 0.02001958f, -0.01998792f, 0.00085219f, 
    0.15378386f, 0.04362530f, 0.10130510f, 0.21257271f, 0.31226259f, 0.26715553f, -0.77241814f, 0.63843387f, 
    0.15922938f, 0.03360541f, 0.13692671f, -0.04293702f, 0.22592516f, -0.02534762f, 0.04221273f, 0.13862751f, 
    -0.13653415f, 0.07321128f, 0.10486335f, -0.01020492f, 0.21011083f, -0.03442578f, -0.04843501f, 0.02667666f, 
    -0.20942712f, -0.02891182f, 0.16790330f, 0.14026435f, 0.30587932f, -0.22550960f, -0.19794813f, -0.09853347f, 
    -0.26844937f, 0.18266650f, 0.34300891f, -0.07992255f, -0.13386253f, -0.18881866f, -0.20315157f, -0.00107265f, 
    -0.01676480f, -0.32015529f, 0.23071150f, -0.21979779f, 0.06929981f, 0.37563869f, -0.04052482f, -0.15365110f, 
    0.05250611f, 0.00463451f, 0.17190276f, 0.05692922f, 0.25876969f, 0.10136528f, -0.00060376f, -0.13588233f, 
    -0.04781691f, -0.01149745f, 0.06687439f, 0.17898896f, 0.02165466f, 0.29826194f, 0.41732174f, -0.03412885f, 
    -0.36736172f, 0.02677328f, 0.05454962f, -0.18159412f, 0.08234723f, 0.03291157f, 0.10213169f, -0.00633370f, 
    -0.12930292f, 0.13995756f, 0.42691222f, 0.19673295f, -1.39326656f, -1.35959232f, -0.49346164f, -0.38105386f, 
    -0.34959078f, -0.50416440f, -0.41340369f, -0.57933187f, -0.03187910f, -0.06763325f, -0.05292422f, -0.04396676f, 
    -1.47732604f, -0.36062500f, 0.17115870f, -0.03519810f, -0.08364115f, 0.39132020f, -0.09900723f, 0.17384410f, 
    -0.04844717f, 0.10111882f, 0.03693318f, 0.02354719f, -0.36688539f, -0.37640971f, -0.17466003f, 0.19615997f, 
    -0.04358844f, -0.11707016f, -0.27646843f, -0.05067602f, 0.06947362f, -0.11786965f, -0.19392486f, 0.08035067f, 
    0.08219504f, 0.34249943f, 0.03377695f, -0.11896069f, -0.04161127f, 0.04976137f, 0.01638252f, -0.28062713f, 
    0.05042046f, 0.16084392f, 0.12227082f, 0.00280373f, 0.20821485f, -0.79743040f, 0.22070155f, -0.58496869f, 
    0.16649224f, 0.04173233f, 0.05550957f, -0.16603594f, 0.03705574f, 0.09136402f, 0.01011926f, 0.13543205f, 
    -0.16006976f, -0.18581116f, -0.03214800f, 0.13240401f, 0.04573531f, 0.23927885f, 0.08172885f, 0.22945274f, 
    -0.10701608f, -0.03538484f, 0.08561049f, 0.12735169f, 0.15320295f, 0.89881790f, 0.10439876f, 0.03910791f, 
    -0.07339935f, -0.07347196f, 0.01484536f, -0.17597443f, 0.00368999f, -0.04840240f, 0.13245650f, 0.23648334f, 
    -0.65228403f, -1.38460577f, -0.53687990f, -0.08446403f, -0.39163470f, -0.10308515f, 0.26346108f, -0.06582627f, 
    -0.11545378f, 0.08139692f, -0.01881061f, -0.16559705f, 0.55286038f, 0.03584201f, -0.63470316f, -0.22723089f, 
    -0.19580194f, 0.05380267f, 0.20737448f, 0.19227090f, -0.07356285f, 0.13121751f, -0.29102141f, -0.13431679f, 
    0.52020472f, 0.46921238f, -0.24563950f, 0.97043997f, 0.13965382f, -0.48073667f, 0.22461115f, 0.08795135f, 
    0.17839241f, -0.09076247f, 0.03939136f, 0.07794069f, 0.17813864f, -0.18524636f, 0.21378827f, -0.69033390f, 
    0.06820221f, -0.10400452f, 0.41166079f, -0.11670119f, -0.05015613f, 0.04718325f, -0.12167729f, -0.21010657f, 
    0.34759173f, 0.17238437f, -0.12790391f, -0.27188036f, 0.01052763f, 0.08706355f, 0.00147750f, -0.01355295f, 
    0.04660682f, -0.00712468f, -0.12724426f, -0.16598764f, -0.11547661f, 0.29551592f, -0.06914838f, -0.00981924f, 
    -0.07819378f, 0.18880798f, -0.05611344f, -0.09008553f, 0.01901936f, 0.14618425f, -0.07563021f, 0.04137073f, 
    -0.07191546f, 0.44075453f, -0.04970922f, 0.50593185f, 0.12625474f, 0.12784773f, -0.22757453f, 0.07476054f, 
    -0.17962113f, 0.23478182f, 0.21982732f, 0.11352861f, -0.02853820f, -0.15697473f, 0.33704999f, -0.10217249f, 
    -0.05491394f, -0.06069235f, -0.04585476f, -0.00053437f, 0.26527223f, 0.06359191f, -0.06317560f, 0.23050129f, 
    0.77621484f, 0.43399808f, -0.44009307f, -0.16041391f, 0.11393531f, 0.06680693f, -0.05535525f, -0.21639964f, 
    -0.24893358f, 0.07220782f, -0.35553601f, -0.29084930f, -1.06654775f, -0.67535174f, -0.27751470f, 0.43486303f, 
    0.26867247f, 0.09329929f, -0.05322656f, 0.19136485f, 0.02350672f, -0.00440318f, -0.09251480f, -0.03253117f, 
    0.34330937f, -1.05273187f, -1.07829869f, -0.88591337f, -0.05437158f, 0.23451474f, 0.29750761f, 0.12499350f, 
    0.23366831f, -0.01546909f, -0.23280670f, 0.01721149f, 0.01715765f, 0.04591482f, 0.01966500f, -0.20629834f, 
    -0.10133675f, -0.10514805f, 0.06853785f, -0.03902242f, 0.02077482f, 0.17732443f, 0.09732903f, 0.05291318f, 
    0.04300742f, 0.02424733f, -0.01607762f, -0.18438511f, -0.00306722f, -0.07602597f, 0.12845924f, 0.01377303f, 
    0.21127485f, 0.12528156f, -0.01768471f, -0.07696699f, -0.64224529f, 1.12745166f, -0.02871295f, 0.23183286f, 
    -0.24656463f, -0.39566135f, 0.04383572f, 0.30262485f, -0.02797722f, -0.15802789f, 0.26714459f, 0.00534128f, 
    0.02819380f, -0.04258931f, -0.16789751f, -0.11518539f, -0.19082762f, -0.05678166f, -0.02675652f, -0.08964920f, 
    -0.07464034f, -0.09475059f, 0.04977347f, -0.07117592f, -0.52153271f, -0.28473136f, -0.19351487f, -0.10564291f, 
    -0.02893649f, -0.02892312f, 0.15206997f, 0.01404598f, -0.20088664f, -0.07499692f, -0.01339308f, 0.05710711f, 
    0.42251220f, -1.25145590f, 0.66039103f, -0.63820368f, -0.06992877f, 0.17158388f, -0.07863810f, 0.20406941f, 
    0.00172248f, -0.05564536f, -0.14767647f, -0.05915040f, -0.05350916f, -0.18378279f, -0.03731868f, 0.02115314f, 
    -0.11388796f, -0.02053037f, 0.06352381f, 0.02781048f, 0.05703221f, -0.00780868f, -0.02607945f, 0.08590400f, 
    -1.00174677f, -0.36889604f, -0.92341179f, -0.36707458f, -0.30014166f, -0.00748973f, 0.17274702f, -0.18819094f, 
    -0.12987773f, -0.05385778f, 0.15462247f, -0.03764516f, -0.46139333f, 0.04929730f, -0.18126898f, 0.08018216f, 
    0.00983641f, 0.02122523f, 0.02150089f, -0.03068735f, 0.00034646f, 0.04775047f, 0.02872695f, 0.05784712f, 
    0.02438928f, -0.08278383f, -0.16550574f, -0.26796311f, -0.18229136f, -0.15224341f, -0.07977791f, -0.12456148f, 
    0.12397733f, 0.17615785f, 0.17361608f, 0.26272559f, -0.25484931f, 0.09184156f, 0.29967541f, 0.21637546f, 
    0.14311086f, -0.35371083f, -0.06063850f, 0.00397610f, 0.22193907f, -0.10555805f, 0.32198182f, 0.02679982f, 
    -0.20702761f, 0.00181609f, 0.19673425f, 0.07371879f, -0.18757369f, -0.23674744f, -0.48149195f, 0.13655680f, 
    -0.25220969f, 0.27544475f, -0.16487455f, 0.04958156f, -0.37096468f, 0.01333478f, -0.05233229f, -0.06723195f, 
    0.05260290f, -0.03783163f, 0.02550336f, -0.03652258f, -0.32575685f, -0.10835142f, -0.33855674f, -0.67311293f, 
    0.57761729f, -0.24888945f, -0.19570163f, -0.45250538f, -0.09180396f, 0.26311818f, 0.16259909f, 0.01169102f, 
    0.24728605f, 0.11280325f, 0.11072877f, 0.12332279f, -0.29582289f, -0.92672646f, -0.35835329f, -0.04471106f, 
    -0.02529873f, -0.08601680f, 0.00035447f, -0.01443275f, -0.05311369f, 0.01130536f, -0.03848361f, 0.25711048f, 
    -0.39714357f, -1.43918109f, -1.09699726f, 0.11531985f, 0.10100339f, 0.44700155f, 0.13622536f, -0.15671852f, 
    -0.18244612f, -0.02500946f, -0.09971838f, -0.01775160f, -0.23769781f, 0.12844221f, 0.16237406f, 0.07410901f, 
    0.06383346f, -0.01598467f, 0.17047463f, -0.22275487f, -0.02867378f, -0.01263893f, -0.04853750f, 0.04823391f, 
    -0.33116660f, -0.26479653f, -0.27459717f, 0.03931402f, 0.16756976f, 0.10720249f, -0.03793849f, 0.11088314f, 
    -0.24805109f, -0.49444133f, -0.60316658f, -0.36630893f, -1.03017747f, -0.07733286f, 0.03328928f, 0.08501887f, 
    0.21659857f, 0.09690196f, -0.31323805f, 0.20425290f, 0.06667166f, -0.08872753f, 0.00540033f, -0.04756028f, 
    -0.06124997f, 0.40349600f, 0.08936083f, -0.04870954f, 0.15461899f, 0.08535416f, 0.19323836f, -0.05451892f, 
    -0.26421899f, -0.02385820f, -0.05250471f, -0.27124733f, -0.60204077f, -0.61442506f, 0.21538022f, 0.02066225f, 
    -0.04008327f, 0.29921672f, 0.27905786f, 0.23244271f, 0.17075972f, 0.08650083f, 0.09945895f, -0.06740890f, 
    0.47847334f, 0.62341267f, -0.42183736f, -0.24192172f, 0.14360268f, -0.23355266f, 0.11327597f, 0.03132084f, 
    0.14645299f, -0.06632740f, 0.01193205f, 0.02038158f, -0.20575221f, 0.45979294f, -0.06876204f, -0.03839001f, 
    0.15598796f, -0.33998573f, -0.18043111f, -0.19337590f, -0.18854815f, -0.00124963f, 0.12069093f, 0.03608521f, 
    -0.05719245f, 0.23800375f, 0.23397763f, 0.48755553f, 0.15267867f, 0.12871921f, 0.16915345f, 0.17337511f, 
    0.02480873f, 0.06228739f, 0.26234215f, 0.27262014f, -0.80841780f, 0.46530116f, 0.14321834f, 0.41162360f, 
    -0.07824754f, 0.02208640f, -0.22648337f, 0.11020693f, -0.31958231f, -0.03201485f, 0.03325927f, -0.05252379f, 
    0.11099803f, -0.19059025f, 0.05991271f, 0.48961154f, 0.31290010f, -0.02451239f, -0.11926737f, 0.07354461f, 
    0.03588779f, -0.19897330f, -0.14622287f, -0.03691437f, -0.35977179f, 0.28887737f, -0.73254412f, -0.16629693f, 
    0.23780797f, -0.14446872f, 0.03345067f, 0.01297958f, 0.02170652f, -0.24378638f, -0.03032759f, -0.00120021f, 
    -0.81026578f, 0.03141489f, -0.37797591f, -0.15270571f, -0.18563023f, 0.05568614f, -0.04674520f, 0.08725261f, 
    0.09663039f, -0.05505348f, 0.12864158f, 0.26719546f, 0.00894534f, -0.14679775f, 0.01354742f, 0.20333114f, 
    0.04194525f, 0.10308911f, 0.32990402f, -0.11292683f, 0.06831291f, 0.22077708f, 0.31094190f, 0.20776910f, 
    -0.80966413f, 0.45350114f, -0.04294286f, 0.78147864f, 0.14993945f, -0.12572083f, -0.41787124f, -0.16738737f, 
    0.07122317f, -0.13453855f, 0.01567683f, 0.05978042f, -0.45195112f, 0.05866045f, -0.04754879f, -0.39056629f, 
    -0.21418883f, -0.16754127f, 0.04042312f, 0.39462426f, 0.02952942f, -0.05243724f, -0.00023773f, -0.11364311f, 
    -0.40124485f, 0.25586787f, 0.04969339f, -0.60876584f, -0.33863163f, -0.07826181f, 0.10161392f, -0.21486516f, 
    0.12049068f, 0.12645212f, 0.10158581f, 0.02580046f, 0.16025513f, -0.61297226f, 0.02964961f, -0.34878293f, 
    0.12789321f, 0.17758210f, 0.27444139f, -0.09263069f, -0.00516834f, -0.06123649f, -0.34239540f, 0.00513532f, 
    0.32708535f, 0.05882648f, 0.64828336f, -0.24121575f, -0.20850854f, -0.22428274f, -0.10255302f, 0.04107143f, 
    0.07318829f, 0.17710967f, 0.04842124f, -0.07870463f, 0.19568534f, 0.18151245f, 0.03201676f, -0.13602491f, 
    -0.17679740f, -0.03381994f, 0.22433287f, 0.22294319f, 0.16282137f, 0.04364398f, -0.03421089f, -0.04564997f, 
    0.03538268f, -0.28251886f, -0.35092935f, 0.04605303f, -0.02229785f, 0.12082448f, 0.39769042f, 0.04538978f, 
    -0.20584169f, 0.29163086f, -0.08524477f, -0.11175532f, 0.27410552f, 0.06796687f, 0.73888940f, -0.56640220f, 
    0.08450949f, -0.31334773f, -0.27898946f, -0.15029064f, -0.05603730f, 0.10390284f, 0.02704625f, 0.16504526f, 
    0.37383679f, -0.14777827f, 0.01408149f, 0.23332486f, -0.23876026f, 0.08984613f, -0.10960459f, -0.00198411f, 
    0.20322944f, 0.02915841f, -0.07618293f, 0.16468447f, -0.14940493f, 0.58837807f, -0.38584375f, 0.25960174f, 
    0.25509506f, 0.21309441f, 0.21299812f, -0.13664782f, 0.17847469f, -0.19927922f, 0.05376917f, 0.03440299f, 
    0.19823028f, 0.08007628f, 0.34150887f, -1.14356697f, -0.09767945f, -0.39843294f, 0.13166445f, -0.22275673f, 
    -0.31227326f, 0.11877794f, -0.00400602f, -0.02506309f, -0.54946387f, 0.35275459f, -0.88273776f, -0.34644046f, 
    0.07595501f, -0.08032978f, 0.26168862f, -0.12716848f, 0.04105690f, 0.11558315f, -0.27344593f, -0.14439918f, 
    -0.32613385f, 0.31488535f, -0.14407870f, -0.11393439f, -0.08879197f, 0.12252606f, 0.36337969f, -0.09420104f, 
    0.43533188f, 0.20221527f, 0.23871331f, 0.17364334f, 0.08428828f, -0.25244579f, 0.10536402f, -0.24563292f, 
    -0.28059638f, 0.11280690f, -0.07215666f, 0.18113624f, -0.18633792f, 0.23088691f, 0.09089980f, -0.23369788f, 
    0.91977006f, -0.44175860f, 0.01879161f, 0.15788877f, -0.10286584f, -0.57576805f, 0.14559716f, -0.12728164f, 
    -0.10857629f, -0.13199812f, -0.34193635f, -0.01788917f, 0.03457836f, 0.49812707f, -0.07530202f, 0.18183312f, 
    0.03403067f, -0.19752297f, 0.07331473f, 0.03190615f, -0.32903400f, -0.24061705f, -0.66715884f, -0.55139995f, 
    0.19790806f, 0.42301312f, 0.53185463f, -0.59888059f, -0.15740941f, 0.11658844f, 0.16929713f, 0.36072132f, 
    0.05899625f, -0.02701766f, -0.09691819f, -0.10718651f, -0.44460610f, 0.35405359f, -0.59960026f, 0.30543488f, 
    0.01112929f, -0.09772691f, 0.18531741f, 0.27386099f, -0.09180419f, 0.20404562f, 0.15072626f, 0.20911069f, 
    0.31495750f, -0.80559808f, 0.34244058f, -0.08622414f, -0.13400766f, -0.22779804f, -0.11588804f, 0.18147041f, 
    -0.15127470f, 0.16859303f, -0.20237148f, -0.49574268f, -0.43426162f, -0.28617349f, -0.54981071f, -0.06858531f, 
    -0.03285736f, 0.40471897f, -0.34212673f, 0.07011662f, -0.03959766f, 0.00102188f, 0.23442461f, -0.04396935f, 
    -0.62096012f, 0.61010939f, -0.45238024f, 0.24737178f, 0.03586925f, -0.02217742f, 0.06545378f, 0.28997657f, 
    -0.48047203f, -0.74837881f, -0.38541245f, -0.38147730f, 0.42308441f, -0.55126208f, 0.15180071f, 0.00707346f, 
    -0.09221824f, 0.05816187f, 0.25231469f, -0.19446473f, 0.00007934f, -0.17035751f, -0.25718069f, -0.24629281f, 
    -0.26574025f, 0.18475288f, -0.33788753f, 0.29559290f, -0.30176532f, -0.11166946f, 0.11327180f, 0.09580612f, 
    0.04783007f, 0.08872071f, -0.28780597f, -0.43446434f, 0.07010160f, 0.36873454f, 0.10181551f, 0.15968572f, 
    0.08838040f, 0.20905839f, -0.36472136f, 0.15936525f, -0.12352066f, 0.11192591f, -0.03684707f, -0.22089210f, 
    -0.18697672f, -0.09839280f, -0.71295738f, 0.22859982f, -0.01426296f, 0.21644330f, 0.17732231f, -0.24255322f, 
    -0.09345998f, 0.02075789f, -0.03741776f, -0.23223269f, -0.75242478f, -0.61417079f, -0.67489278f, -0.09142943f, 
    0.02545882f, -0.27642697f, 0.24097751f, 0.02756393f, -0.20391890f, 0.01059979f, -0.22209567f, 0.05409938f, 
    0.37432063f, 0.35181713f, 0.24955735f, -0.07493233f, -0.22251405f, 0.12917228f, 0.26990539f, -0.01597704f, 
    0.36090422f, 0.02705484f, 0.27098340f, -0.08363603f, 0.13386549f, 0.11617269f, 0.41404793f, -0.06744651f, 
    -0.32419103f, -0.18966602f, 0.37534183f, 0.07489564f, -0.00613949f, 0.14255789f, 0.27569127f, 0.16148728f, 
    -0.46026647f, -0.34304348f, -0.25180164f, 0.16998962f, 0.08837126f, 0.07251196f, 0.10134362f, -0.10643460f, 
    -0.04034857f, 0.00940954f, 0.09209950f, -0.00094556f, 0.59090602f, -0.10540179f, 0.43041888f, -0.24975567f, 
    0.16592973f, -0.21236603f, 0.36554262f, -0.00343036f, -0.04367921f, -0.09515020f, -0.05254144f, 0.07338990f, 
    -0.07556331f, -0.16569304f, 0.28927228f, -0.51069456f, -0.06947856f, 0.16364640f, 0.42676014f, -0.12314686f, 
    -0.13445498f, -0.03359928f, -0.14524400f, 0.14918011f, 0.12549463f, 0.06932637f, 0.01329088f, 0.07960657f, 
    0.05576643f, -0.01085322f, -0.16471900f, -0.01223845f, 0.02781346f, 0.15125670f, 0.31924003f, 0.17335437f, 
    -0.19427682f, -0.46985999f, 0.14350767f, -0.36571869f, 0.01156526f, 0.02382286f, -0.11991937f, 0.08550714f, 
    0.11657672f, 0.21752837f, 0.24727635f, 0.02603145f, -0.20052949f, -0.63293242f, 0.37078717f, -0.02681674f, 
    -0.21266750f, -0.28184777f, -0.47525421f, -0.42436719f, -0.03117101f, -0.14760633f, -0.08449952f, -0.25422955f, 
    -0.28443947f, 0.38162974f, -0.11449047f, -0.97296029f, -0.17778663f, 0.00450646f, 0.00814227f, -0.03234321f, 
    0.12409839f, 0.10473943f, -0.10600518f, -0.19556226f, 0.55840492f, 0.24551958f, 0.07612965f, -0.27986848f, 
    -0.06941642f, 0.16786587f, -0.31538630f, 0.11127898f, -0.09420562f, -0.08509038f, -0.36325434f, -0.12266884f, 
    0.04852461f, -0.52688140f, 0.17655917f, 0.46614510f, -0.06829458f, -0.10898010f, 0.24252227f, 0.02797263f, 
    -0.09248299f, 0.24568419f, -0.01197401f, -0.12265319f, -0.23456782f, -0.28391913f, 0.41660991f, -0.24212807f, 
    0.04022552f, 0.31465638f, -0.23750952f, -0.11610069f, 0.07762146f, 0.19696680f, 0.15920717f, 0.30812582f, 
    0.25734389f, -0.12499664f, 0.35038581f, 0.38060328f, 0.06578708f, -0.01689252f, -0.29639429f, 0.12170283f, 
    0.26924199f, 0.01200353f, 0.14978449f, 0.22545838f, -1.04698205f, -0.08696707f, -0.10649848f, 0.07061671f, 
    -0.18338920f, -0.08249567f, 0.09889947f, 0.38303974f, -0.25407374f, -0.04900895f, -0.17714722f, -0.07538945f, 
    -0.35981035f, 0.12780055f, -0.24069738f, 0.28298697f, -0.14175320f, -0.28876027f, 0.28640124f, -0.04887896f, 
    -0.13892165f, 0.04789953f, 0.05831310f, 0.09590533f, 0.72384155f, -0.25845584f, 0.62218004f, -0.13038138f, 
    0.23675516f, 0.05849245f, 0.02175079f, -0.06133917f, -0.20673080f, -0.04383192f, 0.14144805f, 0.04713298f, 
    0.44861782f, -0.65056616f, 0.49661779f, -0.66724044f, 0.10488525f, 0.19967778f, 0.09956101f, 0.17792363f, 
    -0.27097604f, -0.11630762f, -0.03206581f, 0.01333694f, 0.48195422f, -0.36607236f, 0.71448112f, 0.07878103f, 
    -0.00895731f, 0.15466301f, -0.29920793f, -0.04326072f, -0.22980776f, 0.11160493f, 0.02985061f, -0.16357115f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.22189642f, 0.13076095f, 0.15535580f, -0.28541240f, -0.14812928f, 0.22041352f, -0.04975510f, -0.25563362f, 
    0.29253361f, 0.07754091f, 0.08604300f, 0.03258003f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
