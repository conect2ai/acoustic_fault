#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.91144907f, -0.64204842f, -0.78396297f, 0.39698681f, 0.28235221f, 0.30754998f, 0.10636860f, 0.38397747f, 
    -0.18722276f, -0.91342777f, -0.14353502f, -0.22165485f, -0.30839172f, 0.95175892f, 0.39235049f, -0.45322677f, 
    -0.23823960f, -0.35849372f, -0.06610646f, 0.79604310f, -0.21807992f, -0.60284543f, -0.28777787f, -0.62731934f, 
    -0.07874811f, -0.01670676f, 0.93134832f, -0.66814214f, -0.72259992f, -0.62211835f, 0.57914275f, 0.76955509f, 
    0.57631409f, 0.17860031f, -0.42113543f, 0.10765928f, -1.11422610f, 0.18432879f, -0.59858972f, 0.18307158f, 
    0.31564772f, -0.73822212f, 0.00535322f, -0.00097374f, 0.53985906f, 0.48961058f, -0.31768072f, 0.48149562f, 
    0.92732388f, 0.71189559f, 0.23692991f, -0.09166668f, 0.43744344f, 0.31529105f, 0.77226382f, -0.68267483f, 
    0.60220486f, 0.14368013f, -1.14663124f, 0.83095932f, -0.23190041f, 0.10864780f, -0.14562036f, 0.80388230f, 
    0.64117825f, 0.59419894f, 0.53946954f, 0.03343818f, 0.10395905f, 0.12383930f, 0.54952371f, -0.04490345f, 
    -0.88524586f, -0.80754137f, 0.06689708f, 0.03073793f, -0.23787999f, -0.91866565f, 0.30282739f, 0.20192623f, 
    -0.26674417f, 0.68938822f, 0.57160527f, 0.81166464f, 0.08850829f, -0.75790548f, -0.80190021f, 0.01736954f, 
    -0.39008728f, 0.09304609f, 0.44735390f, 0.39390531f, 0.61888355f, -0.16746551f, -0.73368764f, 0.36321470f, 
    -0.35715050f, 0.14509279f, 0.52038652f, 0.70760006f, 0.66637301f, -0.90434629f, -0.34040639f, -0.29706585f, 
    0.56785429f, 0.33016065f, -0.38036311f, -0.10607751f, 0.31320065f, -1.03292978f, -0.35861468f, 0.31341669f, 
    -0.41393325f, 0.49426314f, 0.30822685f, -0.30294901f, -0.92885786f, 0.28888118f, -0.05537161f, -0.70599520f, 
    -0.18539393f, -1.01556802f, -0.39766920f, -0.33254933f, 0.03867598f, 0.12448318f, 0.68525255f, 0.23380668f, 
    0.66464329f, 0.36393353f, 0.25148156f, 0.43317068f, -0.42710677f, -0.30574822f, 0.06963484f, -0.03065177f, 
    -0.63884628f, -0.75732625f, 0.32677069f, -0.42361742f, -0.02309694f, -0.59195346f, -0.34758416f, -0.34780526f, 
    -0.57374698f, -0.30947888f, 0.77053505f, -0.83450913f, -0.78111047f, -0.75212556f, 0.25199375f, 0.43692696f, 
    0.28937241f, 0.76418310f, -0.55915684f, -0.13384229f, -0.22950041f, -0.76389873f, -0.45383453f, 0.22302803f, 
    0.33515579f, 0.13012914f, -0.77153450f, -0.53295958f, 0.25455204f, 0.72720844f, 0.60539377f, 0.03128567f, 
    0.22149433f, -0.34854963f, -0.59801048f, -0.70813090f, -0.90418875f, -0.92039162f, -0.52668273f, 0.02336131f, 
    0.38454005f, -0.00839810f, 0.51299298f, 0.40600437f, -0.60651869f, 0.92840803f, -0.07708342f, -0.10334481f, 
    -0.25459164f, -0.84119225f, -0.54163736f, -0.45209649f, -0.23522486f, 0.78790957f, 0.83473557f, 0.69130152f, 
    -0.61082798f, 0.37848794f, -0.41517574f, 0.51159638f, 0.13708319f, 0.14097808f, -0.92079198f, -0.84827018f, 
    -0.11943450f, 0.43268070f, -0.95549369f, 0.48929200f, 0.12893763f, -0.34856927f, 0.23948424f, -0.45061415f, 
    1.11290348f, -0.14325912f, 0.81065494f, 0.32971752f, -0.67740029f, 0.11385412f, 0.46539977f, -0.15361965f, 
    0.04043123f, 0.60461259f, 0.09509475f, 0.89493668f, -0.17439042f, -0.04365731f, 0.62228322f, 0.30161777f, 
    0.35935122f, -0.66056460f, 0.69354129f, 0.44972274f, 0.74590272f, 0.57388449f, 0.46859562f, -0.14360689f, 
    -0.26737526f, -0.33778131f, -0.95099312f, 1.04932547f, -0.28942865f, -0.25627336f, 0.17215984f, 0.07512279f, 
    0.11817405f, 0.24017435f, -0.23215924f, -0.35726020f, -0.35434029f, -0.55654818f, 0.51026469f, 0.21144803f, 
    0.93662244f, -0.16445626f, 0.21766137f, -0.69000417f, -0.37465832f, 0.43743321f, 0.69680661f, -0.70871985f, 
    0.38970125f, 0.75267124f, 0.32702211f, -0.22888194f, 0.58408600f, 0.72214234f, 0.84682816f, 0.23800254f, 
    -0.02171433f, -0.43348849f, 0.03146271f, -0.53738856f, 0.17824812f, -0.62290531f, 0.18674767f, 1.03527939f, 
    -0.72780621f, -0.00815483f, 0.71908635f, -0.59020859f, 0.00269940f, 0.06760091f, 0.19302940f, 0.51127207f, 
    -0.77059448f, -0.61455071f, -0.71048206f, 0.00042827f, -0.58927739f, 0.21283320f, 0.03998320f, 0.47649223f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05589306f, 0.23747538f, -0.09970625f, 0.16391870f, 0.20007862f, 0.22157006f, -0.04276366f, 0.18433502f, 
    0.24444894f, 0.03599096f, 0.06050683f, -0.05287189f, -0.00320313f, 0.16940622f, 0.16028421f, -0.12183390f, 
    -0.02920314f, -0.02864642f, -0.09155758f, -0.07472517f, -0.13039055f, -0.11194930f, 0.24935386f, -0.09740453f, 
    -0.27586952f, -0.20731293f, 0.00897180f, -0.08266406f, -0.12190948f, 0.13983822f, -0.06992672f, 0.19596002f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04622576f, 0.04500170f, 0.01737402f, -0.01544615f, -0.00123573f, 0.01839797f, -0.05653908f, 0.01094083f, 
    -0.03288086f, -0.04030646f, -0.04780100f, -0.05243010f, 0.01051496f, -0.01983183f, 0.01042660f, 0.03542513f, 
    -0.00452039f, 0.03793366f, 0.03057100f, -0.00935586f, -0.00578721f, 0.02173377f, -0.01476811f, 0.02886200f, 
    0.02889493f, 0.03955055f, 0.05119249f, 0.03949654f, 0.04407369f, 0.03919543f, -0.01554746f, -0.04526168f, 
    -0.05184204f, 0.03903868f, -0.03041601f, -0.06384343f, 0.01189490f, -0.02954569f, -0.03816068f, -0.02575850f, 
    -0.05473348f, -0.05883102f, -0.02122951f, 0.01418658f, -0.05973770f, 0.01466827f, -0.03718719f, -0.05610617f, 
    0.00344895f, -0.01516081f, -0.03610504f, 0.05280542f, 0.00294333f, -0.04634175f, -0.01374591f, 0.00320877f, 
    0.01485655f, -0.04318955f, 0.03720652f, 0.01770475f, -0.04949637f, -0.04604253f, -0.05593721f, 0.04792908f, 
    -0.02038192f, 0.03209490f, -0.03582570f, 0.05123996f, 0.03075512f, 0.04747540f, -0.00496960f, -0.02242556f, 
    -0.02206624f, 0.01410992f, -0.05193106f, 0.03021113f, -0.03097641f, -0.04190919f, 0.03740431f, -0.05189968f, 
    -0.05106418f, -0.02740472f, -0.05603914f, 0.02335018f, 0.00355445f, -0.04663697f, 0.03541641f, -0.01056040f, 
    0.04858634f, 0.02242812f, 0.03468833f, -0.03584269f, -0.02422944f, -0.00308795f, 0.04515821f, 0.02556942f, 
    0.01548565f, -0.02634552f, 0.01448466f, -0.03562623f, -0.06135061f, 0.00269771f, 0.01840511f, -0.01907852f, 
    0.02250646f, -0.05622656f, 0.01678173f, 0.03616494f, -0.00339882f, -0.00758728f, 0.00974496f, 0.03325035f, 
    -0.04085662f, -0.04442928f, 0.01356911f, -0.01992584f, -0.02526349f, 0.01368184f, -0.01520341f, 0.00465996f, 
    0.02478473f, -0.01408266f, 0.01480643f, 0.00031937f, 0.05757538f, 0.02629386f, 0.01546632f, 0.00779132f, 
    0.02295399f, -0.03355236f, -0.00517653f, -0.04742003f, -0.03617821f, -0.03330541f, -0.03111516f, -0.02975996f, 
    0.01505569f, -0.04343820f, 0.02344339f, -0.05030278f, -0.03714902f, -0.04346494f, -0.01343087f, -0.05756047f, 
    0.01340132f, 0.00649053f, -0.05073015f, -0.00762831f, 0.05009772f, -0.00149169f, -0.01084916f, -0.03935560f, 
    0.00357214f, -0.01486830f, 0.01187530f, -0.00437671f, 0.03383139f, 0.05067675f, -0.05701450f, -0.04807687f, 
    -0.05877128f, 0.02370499f, 0.00174071f, -0.04109982f, -0.00729700f, 0.00239987f, 0.03565750f, -0.01897904f, 
    0.05102824f, -0.03817019f, -0.03909041f, -0.03979074f, -0.05988028f, -0.04340852f, 0.00767052f, 0.03325574f, 
    0.03004366f, -0.03593506f, -0.03624329f, -0.02702196f, 0.03467486f, -0.04803023f, 0.02292121f, 0.01433121f, 
    -0.04732572f, 0.03858918f, 0.05070496f, 0.01678831f, -0.05245423f, -0.05265539f, -0.05557537f, 0.02924509f, 
    0.02828216f, 0.01597822f, -0.01442627f, -0.01124744f, -0.00347155f, 0.01015512f, -0.05821920f, -0.02698470f, 
    0.00397574f, -0.02375629f, -0.05051984f, -0.01409948f, -0.03155344f, -0.05056547f, 0.03816709f, -0.00511989f, 
    0.03048658f, 0.03336187f, 0.04548278f, 0.01752331f, -0.05211158f, 0.01961443f, 0.00307678f, 0.02618580f, 
    -0.05659252f, -0.01350764f, 0.03336795f, 0.00761320f, 0.01931565f, 0.01412822f, -0.01464868f, 0.02997605f, 
    0.01296438f, 0.03629192f, 0.01791410f, 0.02003980f, 0.03721418f, -0.00728955f, 0.04456341f, 0.01939098f, 
    0.02023608f, -0.05875117f, -0.05910572f, -0.04311340f, -0.01794345f, -0.06640819f, 0.02115402f, 0.04908684f, 
    0.00064501f, -0.04503657f, -0.03776899f, -0.06810952f, 0.02188415f, -0.01087826f, 0.02298658f, -0.05965644f, 
    0.04204148f, 0.03722313f, -0.01463402f, -0.06236183f, 0.00597540f, -0.01909475f, -0.01654675f, -0.01931364f, 
    -0.02101403f, -0.06036532f, -0.01798438f, 0.04137074f, -0.03025705f, -0.02732484f, -0.01830077f, -0.03980191f, 
    0.01176679f, -0.03785503f, 0.03318222f, -0.01938430f, -0.03143480f, 0.05298617f, -0.02741857f, 0.03808647f, 
    -0.05361105f, -0.03587030f, -0.01901993f, -0.02768918f, 0.02918261f, -0.03744740f, -0.02070228f, -0.00587322f, 
    0.02695849f, -0.04657895f, -0.06223669f, -0.04003407f, 0.00103866f, -0.03281870f, -0.02209564f, -0.05711867f, 
    0.27506429f, -0.10608643f, -0.03283256f, 0.07436351f, 0.00654872f, -0.13582973f, 0.02862097f, 0.13598531f, 
    0.22621924f, 0.17139979f, 0.19219775f, -0.07298848f, -0.11290214f, -0.15774220f, 0.09562819f, -0.08256340f, 
    0.07935044f, 0.08818956f, -0.24060684f, 0.08855644f, 0.10805070f, 0.16791724f, -0.20041041f, -0.10681717f, 
    -0.10661585f, 0.19877397f, -0.04931090f, 0.12735857f, 0.10631154f, 0.12061488f, -0.09560101f, -0.03463397f, 
    -0.00697611f, 0.22253563f, 0.00517393f, 0.12511025f, 0.19332273f, 0.00315549f, 0.19737512f, -0.03069636f, 
    -0.05678245f, -0.10621755f, -0.19983852f, -0.01736843f, 0.17288032f, -0.29910287f, -0.09403826f, -0.08069278f, 
    0.10361487f, 0.26511303f, -0.11653470f, 0.05292615f, -0.00125067f, -0.30415705f, 0.02587151f, 0.24084339f, 
    -0.37722850f, -0.28821653f, 0.03326123f, 0.13783064f, 0.08051864f, -0.04603576f, -0.11986601f, -0.24417384f, 
    -0.08520567f, 0.05066771f, -0.03525990f, 0.05917496f, 0.11765433f, -0.11823825f, -0.03348858f, -0.15017411f, 
    0.09533552f, -0.26071072f, 0.28428382f, -0.00959117f, -0.03661722f, -0.05455572f, -0.24766135f, -0.15318963f, 
    -0.01517983f, -0.08926117f, -0.36861426f, 0.09914383f, 0.01172117f, 0.09571635f, -0.01511751f, -0.01502781f, 
    0.07914072f, 0.01752206f, -0.15515211f, -0.07808962f, -0.15929037f, -0.14433166f, 0.17655897f, 0.03917682f, 
    -0.03133324f, -0.03320835f, -0.14821106f, 0.03392777f, -0.03842768f, -0.05115980f, -0.17736466f, 0.07827964f, 
    0.01553279f, -0.03676776f, 0.20187153f, -0.19981472f, -0.10042285f, 0.16448757f, 0.05441618f, -0.13668609f, 
    0.04701367f, -0.12985462f, 0.07432307f, 0.03445949f, 0.14058897f, 0.03413932f, 0.10330462f, -0.01803676f, 
    -0.17999749f, 0.19708587f, -0.07083247f, -0.01699159f, 0.04888550f, -0.10301323f, -0.58109754f, 0.06521546f, 
    0.00954747f, -0.15658334f, 0.27143958f, 0.13303676f, 0.02114863f, -0.03489407f, -0.19018553f, 0.07142726f, 
    -0.01579181f, 0.23005302f, -0.21414061f, 0.09899928f, 0.10560114f, 0.12818314f, -0.02075419f, -0.04259553f, 
    -0.13561383f, 0.08366847f, 0.17593704f, 0.02142824f, -0.00199412f, -0.16310899f, 0.04688755f, -0.12823543f, 
    -0.01652353f, 0.05713142f, -0.06985918f, -0.00366624f, -0.17193808f, 0.02544324f, -0.15690023f, 0.06364444f, 
    0.10982714f, 0.07701980f, 0.33118087f, 0.23446764f, 0.11915099f, -0.04176075f, -0.27206153f, 0.06447188f, 
    0.13131398f, 0.20294940f, 0.04875282f, 0.29413375f, -0.16074353f, 0.16238673f, -0.00282206f, -0.06182392f, 
    0.05751010f, 0.09820304f, -0.11072636f, 0.15216112f, 0.13220377f, -0.17520253f, 0.23970287f, -0.01631184f, 
    0.08198725f, 0.06348660f, -0.00036656f, -0.12270126f, 0.14660764f, -0.17904860f, -0.12026097f, -0.03126489f, 
    -0.06502840f, -0.05182588f, 0.06264174f, -0.04384012f, 0.00516359f, 0.00699800f, 0.07219668f, -0.04691787f, 
    -0.07263744f, -0.02288914f, -0.00332201f, -0.24697031f, 0.02429994f, -0.11890785f, -0.15156998f, 0.36253929f, 
    -0.00730104f, 0.07807866f, 0.02685341f, 0.07294744f, 0.03085755f, 0.00632642f, 0.04248035f, -0.02883846f, 
    -0.00851697f, 0.24679333f, 0.16701123f, 0.22004099f, 0.00185729f, 0.23542009f, -0.18117526f, -0.19414265f, 
    -0.11031818f, -0.08008488f, 0.10337137f, -0.00993237f, 0.04786875f, 0.15493520f, 0.16429420f, -0.03451622f, 
    0.06406637f, -0.15690160f, 0.32190463f, -0.07732808f, -0.26959971f, -0.08324513f, -0.10103492f, -0.12351995f, 
    0.25146848f, -0.00332747f, -0.15596959f, 0.14639303f, 0.12578167f, 0.18963921f, 0.05524917f, -0.05541495f, 
    0.26567581f, -0.05897673f, -0.04705918f, 0.21132383f, -0.07083119f, 0.13340075f, -0.29750085f, -0.02972095f, 
    0.09997171f, 0.10437412f, -0.12113780f, -0.07467917f, -0.02531874f, -0.07469211f, -0.10935180f, -0.10347186f, 
    -0.03649900f, 0.07936942f, 0.19733818f, 0.01108745f, 0.03446496f, -0.08344036f, 0.06135558f, 0.22604118f, 
    0.23021115f, 0.09301403f, -0.14414836f, -0.00302519f, 0.08873682f, -0.04536986f, -0.06253804f, 0.18818521f, 
    -0.02397269f, -0.03902054f, -0.11166789f, 0.06422950f, 0.02821436f, -0.09867758f, 0.06521572f, 0.13120151f, 
    0.26754978f, 0.07234792f, 0.00776879f, -0.01571979f, -0.04465795f, 0.02701621f, 0.12730843f, 0.11324101f, 
    -0.02735653f, 0.15234593f, -0.02154600f, -0.16100423f, 0.01623618f, 0.15982115f, -0.02707297f, 0.06728132f, 
    0.09060969f, -0.09632044f, 0.17695923f, -0.08126788f, -0.05870307f, 0.04105978f, 0.09051400f, 0.16954884f, 
    -0.28162667f, -0.23399013f, 0.12798381f, 0.38608858f, 0.25958976f, -0.09124771f, 0.02148331f, 0.09936423f, 
    -0.14230616f, 0.02518410f, 0.15143269f, 0.03977466f, 0.08422412f, 0.01111086f, -0.14785689f, 0.01734148f, 
    -0.01271650f, 0.07039992f, -0.01015076f, -0.04793844f, 0.02481616f, -0.10900390f, 0.08210216f, 0.18734646f, 
    -0.04566958f, 0.08201404f, -0.07809290f, 0.05433942f, -0.09612871f, 0.17135154f, -0.71529418f, 0.12038532f, 
    0.06138545f, 0.03922684f, -0.08919872f, -0.12429915f, -0.08897749f, 0.03020323f, 0.04181029f, -0.43432346f, 
    -0.03026310f, -0.01096775f, 0.01378549f, 0.11707562f, 0.16940296f, -0.03117512f, -0.07198469f, 0.11300502f, 
    0.07033680f, -0.05626588f, -0.14013238f, -0.03804068f, -0.08772474f, 0.13467894f, -0.02510335f, 0.04983326f, 
    0.08770285f, -0.13932857f, -0.04964828f, 0.06420907f, 0.02708378f, 0.11632919f, 0.19376735f, -0.16360101f, 
    -0.11385604f, -0.17338586f, 0.03706067f, -0.02458277f, -0.45435527f, 0.09876680f, 0.13902813f, 0.08824062f, 
    -0.04282799f, -0.11727976f, 0.26158625f, -0.01930790f, -0.19347054f, -0.18929109f, 0.02497661f, -0.13745475f, 
    0.08811758f, 0.13519241f, -0.09540509f, 0.10435186f, -0.22156532f, 0.05537258f, -0.01151798f, 0.04162449f, 
    -0.00366989f, 0.04973999f, -0.00311263f, 0.12475948f, -0.08591542f, -0.05790112f, -0.33664823f, 0.01833346f, 
    0.15360747f, 0.02970376f, 0.16796571f, -0.29148629f, -0.03515856f, -0.09610280f, -0.26594016f, -0.09690223f, 
    -0.09314688f, 0.03176855f, 0.06890204f, 0.11555254f, -0.05498440f, -0.11305744f, 0.21665296f, -0.10690783f, 
    -0.05146790f, -0.27642789f, -0.01403728f, 0.02749354f, -0.00619621f, -0.05689976f, 0.16180365f, -0.02044845f, 
    0.04168935f, 0.27946118f, -0.15732221f, -0.06145931f, -0.11440418f, 0.12953302f, 0.08129136f, 0.03310047f, 
    -0.01154137f, -0.10948553f, 0.09658237f, 0.15908052f, 0.12292523f, 0.03913967f, 0.11376344f, -0.00944124f, 
    -0.08830810f, -0.07994668f, 0.14899419f, 0.03764185f, -0.08379932f, 0.23431742f, 0.10652403f, -0.18214875f, 
    0.05310275f, 0.03312182f, -0.04428405f, 0.27138865f, -0.00997351f, 0.11013187f, -0.10545187f, 0.01968451f, 
    -0.00455298f, 0.09886103f, 0.05342500f, 0.14154406f, -0.02686894f, -0.41470921f, -0.08761455f, 0.06488361f, 
    0.07480880f, 0.01230781f, -0.24722755f, 0.05740568f, -0.25921509f, -0.04509478f, -0.00784812f, -0.21047130f, 
    -0.01811246f, -0.11346971f, 0.18113394f, -0.14295492f, 0.06977405f, -0.14251915f, 0.07392073f, 0.27306733f, 
    0.17159793f, 0.00318256f, -0.18341245f, 0.23783204f, 0.05322270f, 0.15061112f, -0.10127920f, -0.21411949f, 
    -0.35554412f, 0.11916325f, -0.14197066f, -0.09466825f, 0.14693582f, 0.04028210f, 0.10240658f, 0.01173637f, 
    -0.26728511f, 0.01407922f, 0.10011379f, -0.01607834f, -0.16152507f, 0.12075908f, 0.11403131f, 0.07067477f, 
    0.01705636f, -0.11935748f, -0.08663828f, -0.04934559f, 0.03974577f, 0.02994512f, -0.10213006f, 0.11623378f, 
    0.04403580f, 0.09538314f, -0.20184520f, -0.05589663f, -0.30988839f, 0.32686925f, -0.11456049f, 0.07097114f, 
    0.19263612f, 0.16655450f, -0.01570185f, 0.18418682f, 0.10133658f, -0.01541559f, 0.03892347f, 0.12670200f, 
    -0.19317713f, 0.08860800f, 0.09955879f, -0.26590344f, -0.08189730f, 0.22283149f, -0.46079516f, 0.15877077f, 
    0.00857945f, 0.28541151f, 0.01456568f, -0.23217818f, 0.01200716f, 0.12823735f, 0.03967041f, -0.15586048f, 
    0.08903195f, -0.00769938f, 0.08602159f, 0.05305094f, -0.15804529f, -0.12630618f, 0.12322772f, -0.24140532f, 
    -0.03993121f, -0.15306440f, -0.06292201f, -0.03720166f, -0.19972719f, 0.21171145f, -0.08197095f, 0.15787612f, 
    -0.28329638f, -0.04967183f, -0.00312941f, 0.11443990f, 0.14702989f, 0.05816144f, -0.01107069f, -0.14491746f, 
    -0.06818040f, 0.03746787f, 0.00205987f, -0.01919285f, 0.01474325f, 0.04835047f, 0.00557448f, -0.02254388f, 
    -0.00223351f, 0.03429424f, -0.03121311f, 0.04267408f, 0.03468662f, 0.03314396f, 0.04383909f, 0.04739045f, 
    -0.01303543f, -0.01890866f, 0.05348559f, -0.03763797f, 0.00136041f, -0.05992149f, -0.04558223f, -0.04366950f, 
    -0.06614432f, -0.05525176f, 0.00846939f, 0.04244315f, -0.06302902f, 0.02300264f, 0.03513703f, -0.06553966f, 
    0.03068585f, 0.01046541f, -0.01378554f, 0.01749076f, -0.02808714f, -0.05817911f, -0.05852848f, 0.04536733f, 
    -0.04099103f, -0.06443683f, -0.01089776f, 0.02482817f, -0.00574016f, -0.03298207f, 0.02308785f, 0.02972597f, 
    -0.02312064f, -0.00484775f, -0.01343302f, -0.02776809f, -0.04601369f, 0.04949534f, -0.02072177f, 0.00949884f, 
    0.04586791f, 0.03687216f, 0.02466379f, -0.03384040f, -0.01093137f, 0.00410477f, -0.06268935f, -0.04994673f, 
    -0.03802826f, 0.03278347f, -0.02810041f, -0.01028335f, 0.01452011f, -0.02738295f, -0.04100515f, -0.03432655f, 
    -0.00753903f, -0.05513598f, -0.06007018f, 0.03198742f, -0.04669970f, 0.04191421f, -0.02835389f, 0.00609151f, 
    -0.01217272f, -0.02086520f, -0.05663633f, -0.04690761f, -0.04771653f, -0.02079412f, -0.03144402f, -0.00891133f, 
    -0.03972358f, 0.01107835f, 0.02798960f, -0.03085448f, 0.01219225f, 0.03138906f, 0.01329768f, -0.03110224f, 
    0.00395837f, -0.00738415f, 0.03559816f, 0.04335341f, -0.02191966f, -0.03951443f, -0.00668553f, 0.02355597f, 
    -0.00253857f, -0.03487800f, 0.04429778f, -0.04792402f, -0.03816977f, -0.00829514f, -0.00194088f, 0.02731845f, 
    0.04364840f, -0.05244913f, -0.01643889f, 0.00341823f, 0.01358496f, -0.06022688f, 0.04921434f, -0.04567729f, 
    0.02197569f, -0.05181530f, -0.04642431f, -0.01348286f, 0.02380508f, -0.03676141f, -0.00025944f, -0.00225823f, 
    0.03442764f, 0.00328667f, 0.02316991f, 0.04874014f, -0.02891402f, 0.01679178f, 0.04258544f, -0.04244516f, 
    0.00205392f, 0.04487615f, 0.03503418f, 0.02500224f, -0.04540143f, -0.03532317f, -0.06451828f, 0.03029519f, 
    0.03891960f, 0.04448672f, -0.01488709f, -0.03100287f, -0.02156189f, 0.02506067f, 0.00377938f, -0.02108321f, 
    0.01947337f, -0.05927338f, 0.02080324f, -0.05824179f, 0.04149708f, 0.04316754f, 0.02520081f, -0.01696783f, 
    -0.05118970f, -0.03712938f, 0.02353647f, 0.05078180f, -0.05057690f, -0.05382037f, 0.01362585f, -0.04274810f, 
    -0.00436492f, -0.06414707f, -0.04601958f, -0.04554141f, 0.01728006f, -0.05153521f, -0.00391667f, -0.02755759f, 
    0.02173937f, -0.04272549f, -0.02584171f, 0.03960360f, 0.04851535f, -0.05436023f, -0.05016655f, -0.05255582f, 
    -0.00364574f, -0.01851073f, 0.02793931f, 0.00464978f, -0.02759151f, 0.03754636f, 0.00969142f, 0.04727903f, 
    0.04812058f, 0.01641907f, 0.04932760f, -0.03543163f, -0.00628557f, -0.02189671f, -0.05800019f, 0.00815420f, 
    0.04222633f, -0.01243436f, -0.03764328f, -0.06005771f, -0.00924633f, 0.02374522f, -0.00558257f, -0.05344792f, 
    -0.03336066f, -0.02713321f, -0.01604585f, 0.00154209f, -0.02277637f, 0.02807389f, 0.00313969f, 0.01025492f, 
    -0.02242098f, 0.04189513f, 0.03782193f, -0.04068188f, 0.01749982f, 0.02607352f, 0.02685026f, 0.00930208f, 
    -0.03460962f, 0.04741436f, 0.02103101f, -0.01410701f, -0.01748282f, -0.03721708f, -0.02680407f, 0.00552445f, 
    0.03085794f, -0.03065162f, 0.02191031f, -0.01349269f, -0.05909048f, 0.00458695f, -0.04607788f, -0.03688043f, 
    0.02366645f, 0.03962024f, -0.01662490f, -0.03398654f, -0.06321383f, 0.00607004f, -0.04882931f, -0.04349117f, 
    0.00704761f, 0.04131164f, 0.04552252f, -0.05314759f, -0.05148835f, 0.03967378f, -0.02279270f, -0.06348778f, 
    0.00587821f, 0.00876802f, 0.01619809f, 0.01879598f, -0.02580298f, -0.04307518f, 0.02571393f, 0.00107122f, 
    0.02963268f, 0.02563918f, -0.02904148f, 0.02245370f, 0.00867039f, -0.03383829f, 0.02480761f, -0.02189669f, 
    -0.03542283f, -0.03631814f, -0.01346580f, -0.01445698f, -0.04445037f, -0.00708072f, -0.01799636f, 0.02912166f, 
    -0.05517152f, -0.00177142f, 0.00532111f, 0.02052656f, 0.04411391f, 0.03679537f, -0.05718718f, 0.04103214f, 
    0.00369947f, -0.18992299f, 0.35605952f, -0.01222251f, -0.07644103f, -0.02917152f, 0.00732607f, 0.06991102f, 
    -0.14793149f, -0.45293477f, 0.07608117f, 0.18516999f, -0.00432576f, 0.01678142f, 0.01178604f, 0.00655813f, 
    0.07243762f, 0.25220999f, -0.02152150f, -0.13708207f, -0.22958611f, 0.06689701f, 0.09451910f, 0.15291649f, 
    0.17280252f, -0.18148491f, -0.10305724f, -0.15836479f, -0.28113341f, 0.29070112f, -0.04291135f, 0.03063405f, 
    0.13424216f, -0.10423794f, 0.15638515f, 0.09265435f, -0.23030737f, -0.09386901f, 0.18656051f, -0.03227293f, 
    -0.02200582f, 0.13074754f, 0.10750350f, -0.17241435f, 0.11419740f, 0.07501049f, -0.61489969f, 0.00564581f, 
    -0.02170227f, 0.03504603f, 0.15229553f, -0.09927675f, -0.01782811f, 0.23277761f, 0.10270669f, -0.18901752f, 
    -0.11294386f, -0.05393232f, 0.22462375f, 0.17012525f, -0.05079529f, -0.02837070f, -0.00715341f, 0.36735424f, 
    0.08988002f, -0.05706938f, 0.00510934f, 0.16414762f, -0.02471048f, 0.14089836f, 0.00514176f, 0.17173523f, 
    -0.15096235f, -0.16264014f, 0.00733828f, 0.05396347f, 0.05641540f, -0.03960506f, 0.12695830f, -0.07241353f, 
    0.10147361f, 0.39955810f, 0.37106672f, -0.51884580f, 0.02010749f, -0.21222575f, 0.03851764f, 0.16656202f, 
    -0.04296237f, -0.06099588f, 0.00799726f, 0.14769673f, -0.10785672f, 0.08495706f, 0.04166280f, -0.04793165f, 
    0.02730785f, -0.00803664f, -0.02315595f, 0.06345922f, 0.33104184f, 0.11994870f, 0.00078786f, 0.02314715f, 
    -0.00594866f, 0.13953684f, 0.20449774f, 0.03425966f, 0.04125934f, -0.17846452f, 0.12399695f, -0.05660290f, 
    0.18479770f, 0.03736631f, -0.24199429f, 0.18477522f, 0.04266560f, 0.03291164f, 0.14179449f, 0.12367827f, 
    0.06752553f, -0.02250742f, -0.15463923f, 0.02401335f, -0.03755779f, 0.00449721f, 0.04876824f, 0.21732533f, 
    0.11479388f, 0.01373866f, -0.07700026f, 0.11078665f, -0.06182675f, 0.03071765f, 0.11468449f, 0.10944621f, 
    0.01972440f, -0.17736834f, -0.10554665f, 0.07657661f, 0.05229095f, -0.18153629f, 0.16737755f, 0.26629418f, 
    -0.15261462f, -0.02182097f, -0.22081231f, 0.09252364f, 0.09336470f, -0.15355287f, 0.14033374f, -0.06909859f, 
    -0.03350985f, 0.17982239f, -0.21207598f, -0.14690711f, -0.00286251f, -0.13200250f, -0.22829975f, 0.17296132f, 
    -0.03806189f, -0.03880536f, -0.34790415f, -0.30217016f, -0.01851095f, -0.01512435f, -0.11398234f, -0.09322718f, 
    -0.04638353f, -0.00278093f, -0.11486076f, 0.08688726f, -0.10622492f, 0.34077841f, -0.02936840f, -0.05929220f, 
    0.09224494f, 0.14536172f, -0.08296441f, -0.11299280f, -0.26553977f, 0.00986068f, -0.32127774f, -0.12998745f, 
    -0.00941606f, 0.15487726f, -0.08946303f, -0.08214068f, 0.14810584f, 0.05116505f, 0.32768211f, -0.17268333f, 
    0.07748342f, -0.16217552f, -0.27541983f, 0.08726052f, 0.10813092f, -0.17726079f, -0.03755153f, -0.12441053f, 
    -0.15176083f, -0.04114779f, 0.13889077f, -0.00226876f, -0.06350731f, -0.02758885f, 0.10252286f, 0.15264560f, 
    -0.01362295f, -0.29124373f, 0.01299529f, -0.20197065f, 0.08779315f, 0.02136541f, -0.02872935f, 0.05860125f, 
    0.12599468f, -0.15351470f, -0.31650561f, -0.12697999f, 0.07229134f, 0.10141136f, -0.09857950f, 0.08616984f, 
    -0.18261254f, -0.26717001f, -0.21722679f, -0.12450615f, 0.07652729f, -0.01964043f, -0.03115610f, -0.05029032f, 
    0.05006721f, 0.01031739f, -0.61076152f, 0.03548723f, 0.20571986f, -0.03107959f, -0.03795422f, -0.00041762f, 
    -0.03403444f, 0.02279586f, -0.11953980f, -0.05930207f, -0.20729101f, 0.28100967f, 0.00844645f, 0.11523150f, 
    0.17556794f, -0.01818069f, 0.00983031f, -0.12012278f, -0.28356919f, 0.23172382f, 0.08573838f, 0.02855110f, 
    -0.20659795f, -0.02461406f, 0.09222696f, -0.02274821f, -0.06414814f, 0.33364055f, 0.18912369f, 0.05941717f, 
    0.12012736f, 0.13640814f, -0.05856219f, 0.08438293f, -0.01269322f, -0.05957222f, 0.02928260f, 0.41089398f, 
    0.23280749f, -0.00619536f, 0.05665212f, -0.09662925f, 0.03939761f, -0.10186761f, 0.05018640f, 0.09538999f, 
    -0.22827886f, -0.02407672f, -0.04975816f, 0.02748238f, 0.06296877f, 0.07891164f, -0.00884014f, 0.04753755f, 
    -0.07148426f, 0.10568051f, -0.14247118f, 0.00518591f, 0.14601596f, -0.13715313f, 0.03367084f, -0.09897250f, 
    -0.10795529f, -0.19907506f, -0.16254953f, -0.07305751f, -0.10056666f, 0.12270471f, 0.07195057f, -0.13511881f, 
    -0.02161294f, 0.16373254f, 0.08848783f, -0.05965849f, 0.20551872f, 0.13564964f, -0.01445741f, -0.07095864f, 
    0.06748812f, 0.01749704f, -0.14012836f, -0.19395876f, -0.10472338f, -0.08779848f, 0.18488355f, 0.03067276f, 
    0.00097241f, -0.11558399f, 0.06108208f, -0.00393767f, 0.14371036f, 0.09337781f, -0.00979003f, -0.13133231f, 
    -0.09947499f, 0.19552243f, 0.17612182f, 0.07663292f, -0.11671440f, -0.09101208f, -0.42568704f, -0.13849057f, 
    0.27621678f, 0.02286297f, 0.02476924f, 0.00921133f, 0.10783871f, -0.07770589f, -0.08481684f, -0.20701548f, 
    0.04963576f, 0.04621065f, 0.13724281f, 0.07834998f, -0.01656857f, 0.10427259f, -0.03798106f, -0.26092446f, 
    0.24238199f, 0.09541769f, 0.22191544f, 0.02115982f, 0.07916570f, 0.10859653f, -0.00613611f, -0.03574645f, 
    0.42819449f, 0.14163695f, -0.15696213f, -0.13256329f, -0.22074437f, -0.07129887f, 0.12024610f, 0.05123196f, 
    -0.01364637f, -0.00063978f, 0.05465291f, 0.13449001f, -0.04952050f, 0.18551518f, -0.12317295f, 0.08801018f, 
    0.17401095f, 0.05145240f, -0.04671707f, -0.05938584f, 0.15160853f, 0.02744550f, 0.08476811f, -0.09135601f, 
    0.07139756f, 0.04065390f, -0.01875749f, -0.09119852f, -0.13666487f, 0.02526382f, 0.00050751f, 0.05257574f, 
    -0.08486684f, 0.11488063f, 0.04413958f, -0.10792877f, 0.05647815f, -0.23771045f, -0.17464261f, -0.10220545f, 
    -0.04373302f, 0.07093117f, -0.13998713f, -0.02652510f, -0.12952569f, 0.22191322f, -0.32506830f, 0.05832971f, 
    0.03556954f, -0.15121247f, -0.20278116f, -0.03406843f, 0.24813336f, 0.07891892f, -0.21593121f, 0.34539908f, 
    0.11425944f, 0.21510519f, 0.15123540f, 0.04613538f, 0.22562380f, -0.05490726f, 0.05816599f, -0.18666427f, 
    -0.14754885f, -0.00828977f, -0.20526792f, -0.10127371f, -0.02271122f, 0.08320946f, 0.17143811f, 0.16609524f, 
    0.01393294f, -0.15444085f, 0.00774761f, 0.23246823f, -0.28252736f, 0.01609397f, 0.05819602f, -0.08467420f, 
    0.07182021f, 0.11592980f, -0.10756478f, -0.06718240f, -0.17464037f, -0.17890964f, -0.01123871f, 0.06375096f, 
    0.11898308f, 0.04033847f, 0.14247692f, -0.29595998f, -0.51725811f, -0.14332017f, -0.08641661f, -0.09132627f, 
    -0.02090169f, 0.05675853f, 0.12233737f, 0.00158883f, -0.04898421f, -0.07285287f, -0.02118634f, -0.00498395f, 
    0.02614386f, 0.11771881f, 0.02274250f, 0.01775254f, 0.30575454f, -0.07686604f, 0.20574476f, -0.25492981f, 
    -0.11062668f, -0.11022464f, 0.09280670f, 0.12302227f, 0.15529394f, -0.01660417f, 0.37013218f, 0.32207617f, 
    0.32376513f, 0.11552460f, -0.05551534f, 0.06163037f, 0.01036884f, -0.03098883f, 0.02099245f, -0.22776319f, 
    -0.00912061f, 0.18812309f, 0.05040944f, 0.05323924f, 0.01417228f, 0.02100671f, -0.18176289f, -0.03522547f, 
    -0.01423710f, 0.03934051f, 0.07839906f, -0.11260051f, -0.11702126f, 0.18208233f, -0.06205670f, 0.14375722f, 
    -0.03451273f, -0.23462987f, -0.28776705f, 0.03565285f, -0.00519448f, 0.12786134f, -0.25693768f, -0.15732732f, 
    -0.00997806f, 0.22799124f, -0.11609865f, -0.12507334f, 0.19549973f, 0.14930539f, 0.11819483f, 0.20621888f, 
    0.02042334f, 0.00685164f, 0.11498534f, 0.11636969f, 0.28238720f, -0.32465824f, 0.09126864f, 0.11637099f, 
    -0.05371498f, -0.09215134f, 0.18654418f, -0.23187308f, 0.10573853f, -0.10943143f, 0.07185122f, 0.06403781f, 
    -0.04614906f, -0.14138041f, -0.05472988f, -0.18250091f, -0.01627334f, 0.06351292f, 0.12661853f, 0.16136292f, 
    -0.15971707f, 0.00423379f, -0.04153301f, -0.07702105f, -0.23381229f, 0.02425696f, 0.21425921f, 0.06738302f, 
    0.11965862f, 0.24654181f, 0.02788387f, 0.17308633f, -0.02002544f, -0.02336219f, -0.36812103f, 0.09410704f, 
    0.19833982f, 0.25435367f, 0.03984155f, 0.01368918f, 0.01531725f, -0.06555611f, 0.08619054f, 0.09170431f, 
    0.05796413f, -0.17026450f, -0.00022157f, 0.01631722f, -0.14298244f, 0.09668088f, 0.14641154f, -0.01185079f, 
    0.02993561f, 0.14848784f, 0.07763433f, 0.12942746f, 0.13385412f, -0.12341052f, -0.19285837f, -0.09606540f, 
    0.09512962f, -0.05555290f, 0.09233142f, -0.06684324f, -0.07945497f, 0.01339899f, 0.16288738f, -0.18690021f, 
    0.05508899f, 0.16510166f, 0.08103450f, 0.04452163f, -0.07070665f, 0.08373292f, 0.14926556f, -0.26629293f, 
    0.01194039f, 0.07391544f, -0.10203168f, -0.17524916f, 0.04058070f, 0.04748031f, 0.28478816f, 0.00545760f, 
    0.10968081f, 0.00797504f, -0.05504442f, 0.00185523f, 0.16277653f, -0.13419400f, -0.05059451f, 0.05121872f, 
    0.02547367f, 0.13473468f, 0.02332468f, -0.04849854f, 0.01184551f, -0.23243880f, -0.42289934f, -0.31813008f, 
    0.07115260f, 0.00071451f, 0.11730538f, -0.05593479f, -0.01360277f, -0.21653050f, 0.00885231f, -0.17701387f, 
    -0.18041082f, -0.10586727f, -0.15424713f, -0.03349631f, -0.10493346f, 0.15253934f, 0.09766904f, 0.16462439f, 
    -0.10291746f, 0.04976159f, -0.04090499f, -0.00752668f, -0.03172831f, 0.19490790f, -0.10120525f, -0.00525021f, 
    -0.07730027f, -0.15090157f, 0.07327440f, 0.02133888f, 0.04920017f, -0.02789436f, -0.09896775f, -0.20346147f, 
    0.02163093f, 0.46083599f, 0.17966647f, 0.02891872f, 0.11277004f, 0.09351885f, 0.00034345f, 0.12440104f, 
    -0.01695371f, -0.17704287f, 0.01823575f, 0.11643101f, -0.01511979f, -0.01661465f, 0.09960453f, -0.14666975f, 
    0.05988380f, -0.18566729f, -0.04579000f, 0.08059288f, 0.38234821f, -0.09637554f, -0.00457577f, 0.35794780f, 
    -0.11240025f, 0.23127793f, 0.09206195f, -0.29418665f, 0.10193811f, 0.13562806f, -0.05729850f, -0.15892561f, 
    -0.11125388f, -0.01729566f, -0.21356584f, 0.05020390f, 0.06747615f, 0.16287075f, 0.07408842f, 0.02494453f, 
    0.14267506f, -0.07671219f, -0.09437662f, 0.02529835f, -0.00059606f, 0.04812068f, -0.26144788f, 0.18646501f, 
    -0.15833358f, 0.03002079f, 0.02833859f, 0.01578988f, 0.05745864f, 0.10798465f, -0.10471676f, 0.08131381f, 
    0.10590190f, 0.01949821f, -0.08993587f, -0.07265611f, -0.00576137f, 0.07201666f, 0.02425496f, 0.16357049f, 
    -0.13377470f, -0.22360225f, -0.12847266f, 0.13937363f, -0.01817681f, -0.12658897f, -0.08002202f, -0.16960301f, 
    -0.09771664f, 0.03802191f, -0.05391499f, -0.22804768f, 0.14728801f, -0.17898738f, -0.18866687f, 0.04796879f, 
    -0.05695280f, -0.01805497f, -0.15008549f, -0.04994568f, -0.05687829f, 0.03884468f, 0.13497135f, 0.00951297f, 
    -0.01425890f, -0.12854350f, 0.06799560f, 0.05105871f, 0.19228606f, -0.13381532f, 0.15382911f, 0.05362563f, 
    -0.13047537f, -0.09301716f, -0.11568079f, -0.01893381f, 0.20179825f, -0.13205774f, -0.20882219f, 0.16162004f, 
    0.11304566f, -0.10218894f, 0.17013778f, 0.00510067f, -0.00743644f, 0.40996692f, 0.12534761f, 0.16308589f, 
    -0.04100897f, -0.21193245f, -0.11111681f, -0.02506664f, 0.18097353f, 0.07280058f, 0.21940440f, 0.09192465f, 
    -0.16139066f, -0.05892479f, -0.06446652f, -0.12273592f, 0.04865117f, -0.20033240f, -0.14721562f, 0.31762618f, 
    -0.02915293f, 0.03042182f, -0.00481063f, -0.01820032f, 0.01252240f, -0.02409914f, 0.11019488f, -0.04026162f, 
    0.23975743f, -0.17680569f, 0.02952866f, 0.06832495f, -0.03276626f, 0.09985077f, -0.32045993f, -0.01035457f, 
    -0.27655748f, 0.06840855f, -0.19232592f, 0.10440433f, 0.15238169f, 0.23927680f, 0.19086680f, -0.00048960f, 
    0.03914248f, 0.02231163f, 0.18678142f, 0.08926366f, -0.02868020f, -0.31775439f, -0.01474677f, 0.00686187f, 
    -0.18901196f, 0.08113028f, 0.01672583f, -0.16888793f, 0.02459838f, 0.05693655f, 0.09722508f, 0.17128387f, 
    0.22725433f, -0.13939132f, -0.14168341f, 0.30641884f, -0.10061914f, -0.18872119f, 0.09896776f, -0.04163956f, 
    0.07180074f, 0.16180034f, -0.09512824f, -0.05131601f, -0.26395434f, 0.46623075f, 0.32307053f, 0.18893698f, 
    0.12960555f, -0.05339435f, 0.02559020f, 0.12297151f, 0.05700054f, 0.20557553f, 0.07188085f, 0.00799096f, 
    -0.02290152f, -0.14058611f, 0.16657013f, 0.00238690f, -0.12990527f, 0.09970737f, 0.03825387f, -0.01938641f, 
    0.09006155f, -0.15183859f, 0.18627614f, -0.03396453f, -0.29246855f, 0.02039721f, 0.01277117f, -0.14609750f, 
    -0.04458287f, -0.00053047f, 0.01653512f, -0.05904789f, 0.00645459f, -0.06375278f, 0.00829128f, -0.00300682f, 
    -0.02604941f, -0.02201027f, 0.01464332f, 0.04674372f, -0.05915102f, -0.01626844f, 0.01164489f, 0.04654337f, 
    -0.06245230f, -0.05582700f, -0.05855147f, -0.01589371f, -0.01404320f, 0.03096817f, 0.00613567f, -0.01338929f, 
    0.00504607f, -0.00252168f, -0.06408373f, -0.04399322f, -0.02786053f, -0.02126286f, 0.02964212f, -0.04380106f, 
    -0.04479669f, -0.03181088f, -0.03308222f, -0.01528303f, -0.05993425f, 0.00273352f, -0.02815505f, -0.02585438f, 
    -0.00492670f, 0.03620446f, -0.01033284f, -0.03853538f, -0.02591110f, -0.03163679f, -0.05043669f, -0.04822816f, 
    -0.02806070f, -0.05148456f, 0.00173382f, -0.05044280f, -0.01309227f, -0.01365252f, -0.02106478f, 0.01326517f, 
    -0.06017467f, 0.03873483f, 0.01083010f, -0.00252585f, -0.06308753f, -0.00928436f, 0.00383553f, -0.05522085f, 
    -0.00868458f, -0.05351572f, -0.01398439f, -0.05694158f, 0.00435036f, 0.05832603f, 0.04157789f, 0.03112711f, 
    0.03918505f, 0.01370704f, -0.03732296f, 0.03098298f, -0.00950031f, -0.05166094f, -0.03266326f, -0.05933214f, 
    -0.05216924f, 0.04301585f, -0.07439427f, 0.01420738f, 0.02053931f, -0.03063608f, -0.01466903f, 0.03470068f, 
    0.03920982f, 0.05735224f, -0.00431610f, -0.04678785f, -0.02966842f, -0.06409235f, -0.01434242f, -0.03017373f, 
    -0.05695124f, 0.05336897f, -0.05302872f, 0.02113889f, 0.02918034f, -0.00789476f, 0.02063406f, 0.04044138f, 
    0.01308755f, -0.04931622f, 0.01134859f, -0.03708800f, -0.01650276f, 0.01909344f, -0.03309725f, -0.06208456f, 
    -0.02064698f, 0.02502781f, -0.02635884f, -0.00993469f, 0.00580704f, 0.02244794f, 0.03060239f, 0.03804514f, 
    -0.03516520f, -0.00833000f, 0.02881938f, 0.00257048f, 0.00765180f, 0.00829360f, 0.02722510f, -0.03314762f, 
    -0.04459081f, -0.01149628f, 0.04740808f, -0.04037811f, 0.03016827f, 0.01619798f, 0.04471255f, 0.02804203f, 
    0.04320124f, 0.02551870f, -0.01481485f, -0.03820274f, 0.02834859f, 0.00577793f, 0.00524508f, -0.03412173f, 
    -0.02079148f, 0.02981209f, 0.04844467f, 0.05909660f, -0.05096433f, -0.01152263f, -0.05118582f, -0.03181578f, 
    -0.06842122f, -0.00620024f, 0.04092285f, 0.01024338f, 0.01736683f, -0.02685319f, 0.04330937f, -0.03271831f, 
    -0.06116798f, -0.07100654f, -0.06497742f, -0.00788101f, -0.02661908f, 0.02112335f, -0.05968700f, -0.05271953f, 
    -0.04408288f, -0.04485183f, -0.06421911f, -0.01939145f, -0.01497187f, -0.00505473f, 0.01242272f, -0.03802200f, 
    -0.02974644f, -0.01418064f, -0.01608440f, -0.03383415f, 0.03090801f, 0.01250471f, -0.07317063f, -0.05457757f, 
    -0.01471483f, -0.06349341f, 0.01993794f, -0.03667688f, -0.01166972f, 0.02080457f, 0.01347104f, -0.02595614f, 
    0.04347953f, -0.02192144f, -0.00062526f, -0.00116183f, 0.04507471f, 0.01854296f, -0.04384797f, 0.02157708f, 
    0.05541477f, -0.01679075f, -0.02739517f, -0.06399830f, -0.02119044f, -0.04250325f, 0.01187315f, -0.04543452f, 
    0.03789326f, 0.02108879f, 0.05292140f, 0.03246215f, 0.02289639f, 0.04194520f, -0.04434343f, 0.04906522f, 
    0.03062598f, -0.04299178f, 0.04299583f, 0.02549227f, 0.01526637f, -0.03512351f, 0.04514688f, 0.00665485f, 
    0.03769646f, -0.03485071f, 0.03449220f, 0.02805615f, -0.01644249f, -0.01968808f, -0.04189303f, 0.00909271f, 
    -0.03450840f, -0.06340430f, 0.00870049f, -0.01797578f, -0.04469705f, -0.00958319f, 0.00250980f, 0.00577407f, 
    -0.06873502f, -0.04625249f, -0.03801046f, 0.00218945f, 0.04541222f, 0.02416574f, -0.02385456f, 0.01267620f, 
    -0.00943159f, -0.00726101f, 0.04892422f, -0.02727567f, -0.03881801f, 0.05389814f, 0.04853345f, -0.00442575f, 
    -0.01943045f, 0.03550994f, -0.00284843f, 0.01830564f, -0.01792462f, -0.04848411f, 0.04095768f, -0.04305508f, 
    -0.05615043f, 0.00435795f, -0.05243360f, -0.02150293f, 0.04388056f, -0.01998167f, 0.03979682f, 0.01008435f, 
    0.03635103f, 0.00032174f, -0.05844432f, -0.01154587f, -0.03389165f, 0.00759377f, 0.00158297f, 0.00125273f, 
    0.04060329f, -0.00811072f, -0.05619161f, -0.04479833f, 0.04030339f, 0.03865714f, 0.02690681f, -0.03966191f, 
    0.01584217f, -0.00234377f, -0.02704956f, -0.01059624f, 0.02743713f, 0.01750690f, -0.05016302f, -0.06925497f, 
    0.04211768f, 0.01514660f, -0.00680837f, -0.03107999f, -0.01368129f, 0.01451289f, -0.06382547f, 0.03293555f, 
    -0.00686790f, -0.02334515f, 0.00129595f, 0.02276920f, -0.04483040f, -0.00454963f, -0.05101221f, 0.02613637f, 
    -0.02817303f, -0.01764465f, -0.00660828f, 0.00365170f, -0.00150843f, -0.00564282f, -0.06162195f, 0.03159811f, 
    -0.04729310f, -0.04532071f, -0.00257731f, 0.00762126f, 0.00093877f, -0.03326577f, 0.03024932f, -0.04597410f, 
    0.03091994f, -0.05966467f, 0.02469415f, 0.00842590f, -0.04087205f, 0.02577237f, 0.03346404f, -0.03402835f, 
    0.01464649f, 0.03594789f, -0.04156789f, -0.06217290f, 0.01567761f, -0.05693305f, 0.01616198f, -0.00090222f, 
    -0.02053854f, 0.03462728f, 0.00155003f, 0.01598745f, -0.07616030f, 0.04442892f, 0.03968664f, 0.02237704f, 
    -0.05059401f, -0.03067276f, -0.03322562f, -0.01096633f, -0.00773502f, -0.00490814f, 0.03380584f, -0.01408084f, 
    0.02429662f, 0.04471597f, 0.03629494f, -0.05899475f, 0.03154998f, -0.00638376f, -0.03752436f, -0.01756779f, 
    0.02664500f, 0.00725457f, -0.02827402f, -0.01256632f, 0.02753407f, 0.03235581f, 0.00882507f, -0.03616246f, 
    -0.06286475f, -0.04183118f, -0.07071669f, 0.05338919f, -0.03345415f, -0.00299261f, -0.04876119f, -0.00381212f, 
    0.05175571f, 0.03723918f, -0.05573770f, 0.02750783f, 0.01682498f, -0.05784743f, 0.01119170f, 0.00276363f, 
    -0.01896421f, -0.03108571f, 0.02226658f, -0.03851241f, 0.04084466f, 0.01359988f, 0.01502392f, -0.04827426f, 
    -0.07223317f, 0.01111826f, 0.00956153f, -0.06293651f, 0.03611275f, 0.02618693f, -0.00612482f, -0.04286235f, 
    -0.05067335f, -0.01610840f, 0.02904383f, 0.02102728f, -0.01661648f, -0.06897720f, -0.02074192f, -0.02801261f, 
    -0.05333244f, 0.04892570f, 0.01928062f, 0.04690398f, -0.03492749f, -0.03437177f, 0.03896492f, -0.01143989f, 
    -0.05292390f, 0.00002385f, -0.00795121f, 0.03134885f, 0.03354424f, 0.01063275f, 0.03371253f, 0.00760653f, 
    -0.05085051f, 0.04039844f, 0.00560354f, 0.03702751f, -0.07122353f, -0.02109607f, -0.04321070f, -0.02264170f, 
    -0.03365289f, -0.00419932f, 0.00268365f, -0.02885502f, -0.02590071f, 0.01143563f, -0.03933292f, -0.06396589f, 
    -0.02419589f, 0.03795107f, -0.06876731f, -0.06233603f, -0.02899503f, 0.01803374f, -0.03257589f, -0.00634320f, 
    0.00887444f, 0.04623265f, -0.00984279f, -0.03012110f, -0.04367271f, -0.04056160f, -0.02162620f, 0.03008173f, 
    0.03655109f, -0.01570227f, 0.00286331f, -0.01562861f, -0.06041926f, -0.01902458f, 0.01784118f, -0.04866549f, 
    -0.01349185f, 0.02905183f, 0.01431016f, 0.01407399f, -0.00653778f, -0.01103361f, -0.02953474f, 0.04622865f, 
    0.03600507f, 0.05517068f, -0.02035693f, -0.00975874f, -0.02328551f, -0.06462613f, -0.03016003f, -0.02116931f, 
    0.01941571f, -0.05336651f, 0.02406623f, -0.06483245f, -0.05071800f, -0.03326575f, -0.06784879f, 0.01047568f, 
    0.02401072f, -0.06173011f, -0.04389302f, -0.02641463f, -0.04561555f, 0.01272376f, -0.05934953f, -0.05736589f, 
    -0.01807072f, 0.05272146f, 0.00092323f, -0.06383453f, 0.00996361f, 0.00286215f, -0.01313494f, -0.01176353f, 
    -0.01235224f, 0.01937808f, 0.00389919f, 0.01630292f, -0.02784786f, -0.05191547f, 0.05568559f, -0.02182885f, 
    0.02427073f, 0.04724699f, -0.04602920f, 0.02305913f, -0.01693115f, -0.05826154f, 0.01742727f, -0.02984188f, 
    0.04519278f, 0.04385807f, -0.01893195f, 0.02871352f, -0.01520814f, -0.05041448f, 0.04272716f, 0.00900466f, 
    0.04649732f, 0.01050550f, -0.06090250f, -0.02842266f, -0.03756183f, 0.05249317f, 0.00822363f, -0.00306241f, 
    0.00192227f, -0.00282474f, -0.02913286f, 0.03509255f, -0.02468250f, -0.03443374f, -0.03030100f, 0.01954278f, 
    -0.03213618f, -0.02436220f, -0.06031853f, -0.04568883f, 0.01509420f, -0.05048901f, -0.04589722f, -0.03472307f, 
    0.03068524f, -0.01700968f, -0.04118939f, 0.01817924f, -0.01231342f, -0.02289030f, -0.05269676f, -0.02340716f, 
    0.02696450f, 0.02350650f, -0.00506408f, 0.00691607f, 0.03362023f, 0.02327628f, 0.03250215f, 0.03813137f, 
    0.01303333f, -0.06714138f, 0.01926405f, 0.02562243f, -0.02994054f, -0.03384844f, -0.05440707f, -0.07131986f, 
    -0.04205273f, -0.04221934f, -0.05821021f, -0.04946404f, -0.05906553f, 0.00719728f, -0.05933040f, -0.02689239f, 
    -0.04413911f, -0.01433797f, 0.04271503f, 0.03533547f, 0.03143693f, -0.05770086f, 0.01137855f, -0.03301523f, 
    0.00184174f, -0.04697832f, 0.03186294f, -0.00347180f, -0.07768408f, -0.05129658f, -0.05929335f, 0.00450745f, 
    0.01271395f, 0.03793174f, -0.04859337f, -0.00496347f, 0.03023766f, -0.03563328f, -0.02120157f, -0.07868756f, 
    0.00312159f, 0.02283455f, -0.02395468f, -0.03001557f, 0.01049865f, -0.01407389f, 0.01265718f, 0.00261424f, 
    -0.01607801f, -0.02758979f, 0.05291618f, -0.02065651f, -0.05442066f, -0.00060704f, 0.03542329f, 0.02562481f, 
    0.00412423f, -0.07632877f, -0.01567784f, -0.03017075f, -0.07552349f, 0.01312823f, 0.05792581f, -0.05785623f, 
    -0.05860104f, -0.03997453f, -0.07001160f, -0.04145819f, 0.04283572f, -0.01275624f, -0.01203561f, 0.02098707f, 
    0.05486495f, -0.03428283f, -0.08092276f, 0.00517360f, -0.00810077f, -0.05288341f, -0.08313940f, -0.02505406f, 
    -0.01787401f, -0.03292413f, -0.01443528f, -0.03199150f, 0.00044522f, -0.05019446f, -0.02579109f, -0.05806043f, 
    0.04732561f, 0.00790938f, -0.07112528f, -0.06658866f, -0.01838188f, -0.07489379f, -0.04951361f, 0.05704412f, 
    -0.07176284f, 0.00908842f, 0.01379031f, 0.03612411f, -0.07489013f, 0.03536648f, 0.01794023f, -0.04607569f, 
    -0.07119034f, -0.05843094f, -0.00080169f, 0.04622993f, -0.05533953f, -0.02693569f, -0.05712093f, -0.04744190f, 
    -0.07038987f, -0.04321839f, 0.01219086f, 0.00119482f, 0.02705656f, -0.04557308f, 0.01897917f, 0.00630881f, 
    -0.03627845f, 0.00347834f, -0.00871966f, 0.01734500f, 0.01577107f, -0.03854344f, 0.01152723f, -0.05577002f, 
    0.02354433f, -0.00251740f, 0.01472549f, -0.04826241f, 0.01918141f, -0.04462754f, 0.01863364f, 0.05205771f, 
    0.01804046f, -0.07396378f, -0.03050952f, -0.04181128f, -0.05494571f, 0.03898437f, 0.00238515f, -0.04899402f, 
    0.01694843f, 0.00758610f, -0.05711921f, -0.07166652f, -0.07436325f, 0.06124319f, -0.05287625f, -0.04839877f, 
    0.05501423f, -0.00091850f, 0.03078803f, -0.07119383f, 0.02596185f, -0.01565730f, 0.00567764f, 0.02193267f, 
    0.03078970f, -0.08626279f, -0.01535278f, -0.07301777f, -0.08974671f, -0.01138915f, -0.06294306f, -0.06010901f, 
    -0.01453446f, -0.09339686f, 0.04386995f, -0.06665982f, -0.07759238f, -0.05240707f, -0.01126990f, -0.06034457f, 
    -0.04082043f, -0.01970054f, 0.02773090f, -0.02777786f, 0.01641438f, 0.02484269f, -0.04384895f, 0.01193743f, 
    -0.04187378f, -0.00003242f, 0.00145895f, -0.00498640f, 0.01752505f, -0.03663763f, -0.07743499f, -0.02672978f, 
    -0.04122771f, -0.00883800f, -0.01270643f, -0.03096361f, 0.04007063f, -0.03493842f, 0.02204632f, 0.01677190f, 
    -0.06903746f, 0.03905787f, -0.02106753f, -0.01173038f, 0.00654447f, -0.04734964f, -0.07901224f, -0.03700204f, 
    -0.00543646f, 0.04488657f, -0.05768841f, 0.01620165f, -0.02837318f, -0.06950217f, -0.04697430f, 0.05939019f, 
    0.01053110f, -0.03414595f, -0.04005688f, 0.00268920f, 0.02355676f, -0.02105417f, -0.03188635f, -0.05461601f, 
    0.01422878f, 0.02569542f, 0.00253195f, -0.06426689f, -0.00386541f, -0.01932225f, 0.02228071f, 0.00364786f, 
    -0.00863210f, 0.00248691f, 0.02319831f, -0.08602770f, -0.00187687f, 0.03687778f, 0.02657285f, -0.02085359f, 
    -0.00557845f, -0.08177457f, 0.02289147f, -0.07469477f, 0.02693533f, -0.11212645f, -0.05142892f, -0.06366803f, 
    0.01460417f, -0.00080915f, -0.03339675f, 0.05545060f, -0.07220799f, -0.06046903f, 0.03200655f, -0.02141688f, 
    -0.04027282f, 0.02002296f, -0.08449747f, -0.03050252f, 0.05335179f, 0.02122438f, 0.02695647f, -0.06524140f, 
    -0.02052099f, 0.00687667f, -0.02865143f, -0.01672211f, -0.01594718f, 0.01205209f, 0.03479632f, -0.03062733f, 
    0.03351152f, -0.00635148f, 0.04438749f, -0.08296518f, -0.02008757f, 0.01453027f, 0.06309621f, -0.06619617f, 
    -0.03935541f, 0.02020870f, -0.06137120f, -0.03973357f, -0.03783775f, -0.01965662f, -0.07572549f, -0.05404074f, 
    0.03722478f, 0.04892452f, 0.02185804f, -0.05725452f, -0.06505770f, 0.03453221f, 0.02862785f, 0.00505614f, 
    -0.04216099f, 0.03166867f, 0.01109587f, -0.01284499f, 0.00718406f, 0.04157683f, -0.06329229f, 0.02550204f, 
    -0.04013651f, 0.02875427f, 0.02316445f, -0.05051093f, 0.02092303f, -0.00304475f, 0.01800528f, -0.02131010f, 
    -0.05593411f, -0.02191732f, 0.01109984f, -0.00489593f, 0.00629947f, 0.00793735f, -0.04981418f, -0.01623874f, 
    0.01427574f, -0.01698846f, -0.06058916f, -0.00745023f, -0.05141361f, -0.05577838f, 0.00051362f, 0.05024060f, 
    0.03940747f, 0.01038177f, -0.02668149f, -0.05216052f, -0.05486691f, 0.05283590f, -0.01165896f, -0.01458974f, 
    0.02691758f, -0.03275457f, -0.00204687f, -0.05322578f, 0.02151592f, 0.00702431f, -0.00912561f, 0.04163898f, 
    -0.06572554f, 0.02673970f, 0.04209040f, 0.01303993f, 0.05095640f, -0.00688328f, -0.02018392f, -0.02892666f, 
    0.00147563f, -0.04685229f, -0.04894776f, 0.02224878f, -0.00634193f, 0.00039622f, -0.00323791f, -0.02023644f, 
    0.02364906f, -0.00600032f, -0.00974068f, -0.04994856f, -0.05499744f, 0.04467157f, -0.00622314f, -0.02927137f, 
    -0.05201399f, 0.01301096f, -0.03053042f, 0.01684297f, 0.04568265f, -0.05411222f, -0.01183277f, -0.04774072f, 
    -0.03991726f, -0.02381201f, 0.01031378f, -0.03913735f, -0.05268878f, -0.05613424f, -0.06399946f, -0.06406242f, 
    0.04662374f, -0.00830136f, -0.05440856f, 0.05022562f, -0.05659401f, -0.02367493f, -0.00440831f, 0.03328446f, 
    -0.02708628f, -0.01782617f, -0.01952517f, -0.02123484f, 0.04533615f, 0.01546852f, 0.02673359f, 0.03635532f, 
    0.03625960f, 0.00546497f, -0.00746651f, -0.03403168f, 0.04011404f, -0.05523230f, -0.01443306f, -0.02281714f, 
    -0.06727480f, -0.06227654f, -0.05295498f, 0.02037190f, 0.03965358f, -0.01688285f, -0.05097389f, -0.00809973f, 
    -0.00950257f, -0.00544715f, 0.00444631f, -0.01477537f, -0.04436050f, -0.00476489f, -0.01225266f, -0.00284131f, 
    0.01267167f, 0.00306485f, -0.06485149f, 0.04462995f, 0.02406538f, 0.03065203f, -0.00041754f, 0.01665063f, 
    -0.05454135f, -0.05756800f, 0.03461010f, 0.03861608f, 0.01675648f, 0.03830161f, -0.00219029f, -0.04605737f, 
    0.03563983f, -0.02975261f, -0.02865209f, -0.02551832f, -0.00928203f, 0.00083988f, 0.02832103f, 0.00792841f, 
    -0.05417972f, -0.00075946f, -0.00163700f, 0.02182568f, -0.00223370f, -0.06312323f, -0.03640992f, -0.00911069f, 
    -0.04571812f, 0.00023946f, -0.04585253f, -0.04700064f, 0.02724122f, -0.02122482f, -0.00380851f, 0.04675635f, 
    0.00936220f, 0.01123189f, -0.06888140f, 0.03465524f, 0.02608216f, -0.03968138f, -0.01835428f, 0.02374209f, 
    -0.01740218f, 0.04129196f, -0.06467307f, -0.06245630f, 0.03996437f, 0.05519513f, -0.05174435f, -0.01282720f, 
    -0.03121064f, -0.01323345f, -0.04748058f, -0.05818840f, 0.03917105f, 0.00936444f, 0.01247405f, -0.05583849f, 
    -0.01744306f, -0.02446357f, -0.05398161f, -0.00204273f, 0.04331776f, -0.04376827f, -0.02215798f, 0.00528063f, 
    -0.02622445f, -0.02740643f, 0.00391141f, 0.02101222f, -0.06052555f, 0.01673979f, 0.02111298f, -0.02749919f, 
    -0.02489052f, -0.05976178f, -0.01212717f, -0.02768731f, 0.06179061f, 0.03981705f, -0.04862588f, -0.00595649f, 
    -0.02186467f, -0.03071419f, -0.03247980f, 0.03334981f, -0.01990229f, 0.00889056f, -0.00379074f, 0.04535514f, 
    -0.01038351f, 0.02690174f, -0.05345625f, 0.05529575f, -0.02961867f, 0.02744468f, -0.04569003f, -0.04949275f, 
    0.05653420f, 0.01435740f, -0.03735508f, -0.00420338f, -0.04362699f, 0.02107989f, -0.00794428f, -0.03170952f, 
    -0.06794335f, -0.00362710f, -0.03230645f, 0.00861581f, -0.03833592f, 0.02340931f, 0.02342907f, 0.05074599f, 
    0.04810702f, -0.02824244f, -0.04379315f, 0.02895483f, -0.05387371f, 0.03102135f, -0.03546847f, -0.03448201f, 
    0.00214414f, -0.02806502f, -0.02990609f, 0.03977998f, -0.00002296f, 0.03507544f, 0.03734275f, 0.02348451f, 
    -0.01550345f, 0.03661825f, -0.04285023f, -0.01332548f, 0.01907725f, 0.04821233f, -0.03609225f, 0.03826497f, 
    -0.01779186f, 0.02450595f, -0.01313002f, 0.02594894f, 0.03937572f, -0.03519538f, -0.01927448f, -0.04363037f, 
    -0.05521331f, -0.03947106f, 0.04008012f, 0.01475143f, 0.03983251f, 0.04950658f, -0.04768863f, 0.02870530f, 
    -0.02662318f, 0.00273156f, -0.01047291f, 0.05343131f, -0.04300812f, 0.04794025f, 0.02769930f, 0.02613995f, 
    0.00602236f, 0.05443925f, -0.00141933f, 0.00617877f, -0.01811075f, 0.00619866f, -0.01960309f, -0.00889668f, 
    -0.01735709f, 0.00009154f, 0.01814813f, 0.02634345f, -0.05818054f, 0.03904581f, -0.03654988f, -0.05071374f, 
    -0.00347052f, -0.00061881f, -0.02894666f, 0.05082489f, 0.00807230f, 0.01081283f, -0.02517006f, -0.05159958f, 
    0.02683313f, 0.04595583f, -0.03814523f, 0.03952059f, -0.03758203f, 0.00192245f, 0.02276690f, -0.04189665f, 
    -0.01748489f, 0.01906307f, -0.00237899f, 0.02628670f, 0.04583737f, -0.04784480f, 0.04028775f, -0.03515449f, 
    -0.01501757f, -0.04790200f, -0.03243902f, -0.04484242f, 0.01765906f, 0.01197695f, -0.03788898f, 0.03957730f, 
    -0.05330640f, 0.01182371f, 0.01331830f, 0.00186273f, 0.03337737f, -0.04241343f, 0.01685392f, 0.00472394f, 
    -0.02303357f, -0.01061895f, -0.03021991f, 0.00981880f, -0.02333987f, 0.05473692f, -0.05860447f, -0.04736924f, 
    -0.05860468f, -0.01834254f, -0.05476897f, -0.01319820f, 0.02464123f, -0.05660424f, -0.05965068f, 0.04740393f, 
    0.03462419f, 0.02606504f, -0.05452562f, 0.00235884f, -0.04408498f, 0.00408466f, -0.02039883f, -0.05871861f, 
    0.01511040f, -0.01325712f, 0.00441251f, -0.01261906f, -0.01452507f, -0.04515772f, -0.06046224f, -0.04096959f, 
    -0.00573745f, -0.05598228f, -0.03458694f, -0.06699003f, 0.05423633f, 0.03647329f, -0.03629027f, 0.03264419f, 
    -0.00237728f, 0.00585454f, -0.05804949f, 0.00776398f, 0.03109893f, 0.02733599f, -0.04667928f, -0.00959988f, 
    0.02793279f, 0.02998791f, 0.04486942f, 0.02264475f, 0.03131207f, 0.04079287f, 0.00658270f, 0.02090069f, 
    -0.04916115f, -0.00247855f, 0.00162210f, -0.02973845f, -0.02605836f, -0.02102123f, 0.01504584f, 0.04468888f, 
    0.01689902f, 0.00544788f, 0.00250138f, -0.05754567f, -0.04257904f, 0.02134523f, -0.04376708f, 0.02122932f, 
    0.00544436f, -0.01511869f, -0.05392263f, -0.05991051f, -0.04072240f, -0.04966839f, -0.05370545f, 0.02507400f, 
    -0.02691173f, -0.02441138f, 0.01457084f, 0.05378718f, -0.04415465f, 0.02925518f, -0.02784207f, -0.00150296f, 
    -0.02214694f, 0.02623105f, -0.03552031f, 0.04279139f, 0.04510305f, 0.01619533f, 0.02377682f, -0.06366552f, 
    0.03890769f, -0.01640045f, 0.02419917f, 0.00372046f, -0.03720818f, -0.06188374f, -0.00199566f, -0.05982237f, 
    -0.02128703f, 0.04375916f, -0.01922076f, 0.04268333f, 0.04348233f, -0.03156798f, -0.02842028f, -0.05124340f, 
    0.02719973f, 0.03323705f, -0.03772648f, -0.02054589f, -0.05293522f, -0.00980845f, 0.04881462f, -0.05830654f, 
    0.02224637f, -0.04162636f, -0.06023778f, -0.00670929f, 0.02390157f, 0.01533920f, 0.03119477f, -0.00355483f, 
    0.03213180f, -0.04307437f, -0.00875898f, -0.04065133f, 0.03068083f, -0.00111406f, -0.04994544f, -0.06568669f, 
    0.00701353f, 0.03054127f, -0.01785766f, 0.04776037f, 0.05092648f, -0.04865619f, 0.02900695f, -0.02795261f, 
    -0.01514154f, 0.00234364f, -0.02492656f, -0.00081740f, -0.01313559f, 0.01789190f, -0.00217276f, 0.02093295f, 
    -0.02291939f, 0.03804645f, -0.02210464f, -0.02711857f, -0.05833095f, -0.03496998f, 0.01459937f, 0.00883664f, 
    0.05022056f, 0.02431194f, -0.03950857f, 0.01166874f, 0.01899478f, 0.04606026f, 0.02660133f, -0.03057825f, 
    0.05360907f, 0.00835757f, -0.00774668f, -0.03924002f, -0.05472992f, -0.02788571f, -0.02586376f, -0.01065681f, 
    -0.02635125f, 0.00342408f, -0.02806554f, 0.04114167f, 0.05409103f, 0.00333697f, -0.00307282f, -0.03887056f, 
    0.02315028f, 0.03834494f, -0.01772129f, 0.02432465f, 0.03260338f, -0.03870649f, 0.02590160f, -0.01629963f, 
    -0.05238827f, -0.06115838f, -0.03261891f, -0.03927098f, -0.03193855f, -0.01537005f, -0.02908169f, -0.00749162f, 
    0.02670128f, -0.05004762f, -0.05272152f, -0.00975261f, -0.02977265f, 0.01121725f, 0.01935504f, -0.06554142f, 
    0.01326128f, -0.00933571f, -0.06249192f, -0.01949261f, -0.05576480f, 0.03961618f, 0.04326755f, -0.02243836f, 
    -0.02358445f, 0.00129451f, -0.05583543f, -0.01991948f, -0.04956187f, -0.02436422f, 0.01198150f, 0.00612279f, 
    0.02857557f, -0.02578112f, -0.03804313f, -0.02517078f, -0.05173105f, -0.01171709f, -0.04740054f, 0.00898945f, 
    -0.03260432f, -0.02974591f, 0.05558688f, 0.03980987f, -0.03966679f, 0.04205449f, 0.05178604f, 0.02614453f, 
    -0.04535479f, -0.03933865f, -0.02900159f, -0.07041682f, -0.09194706f, -0.06768841f, 0.04446321f, 0.02225310f, 
    -0.07551017f, 0.01284581f, 0.02412875f, 0.03118738f, -0.05660094f, -0.05646124f, -0.00532362f, 0.02159341f, 
    -0.03299044f, 0.03389797f, 0.01027643f, -0.02267455f, -0.02629928f, -0.03477510f, 0.01133233f, 0.02406843f, 
    -0.05399162f, 0.02630994f, -0.02103052f, -0.06041854f, 0.01799962f, -0.03568337f, -0.04488734f, -0.02492087f, 
    0.00394174f, -0.03534323f, -0.01582912f, -0.04598862f, -0.04481645f, -0.00941774f, -0.05457985f, -0.07879167f, 
    -0.03307772f, -0.04317198f, 0.00108780f, -0.02238092f, -0.01215439f, -0.05517881f, -0.00269260f, 0.02357497f, 
    0.01112844f, 0.03995024f, -0.02818850f, -0.04703413f, -0.05619950f, 0.00141174f, -0.00984699f, -0.03334772f, 
    -0.00961245f, -0.00866463f, 0.01336494f, 0.04056424f, 0.00205359f, -0.03477050f, -0.04430538f, -0.08668602f, 
    -0.05959350f, 0.02214161f, -0.06806450f, -0.02694241f, 0.05893411f, 0.01915259f, -0.08531623f, -0.03925404f, 
    -0.03087743f, -0.01319237f, 0.05840502f, -0.07248896f, -0.05359188f, -0.01370205f, 0.02065844f, -0.06159541f, 
    0.01891923f, -0.09114726f, 0.05551263f, 0.04462123f, 0.00812982f, 0.00526662f, -0.00887073f, -0.05500346f, 
    -0.05338381f, 0.00717746f, -0.05179321f, -0.01096656f, 0.01419465f, -0.00964596f, -0.01498314f, -0.08516801f, 
    -0.03551007f, -0.07402730f, 0.03543204f, -0.03120480f, 0.02460500f, -0.02776699f, -0.02961825f, 0.01219801f, 
    0.04871257f, -0.01518232f, -0.07890556f, -0.00370000f, -0.07576487f, 0.02517034f, 0.01585227f, 0.04144010f, 
    0.03429789f, -0.01714188f, 0.04893705f, 0.01603308f, -0.04187198f, -0.05503120f, 0.01201302f, 0.00448603f, 
    0.01412672f, -0.02531830f, 0.04548559f, -0.06008579f, -0.05829259f, 0.01482118f, 0.04779688f, 0.00375504f, 
    -0.00357317f, -0.05643974f, 0.00191826f, -0.05812487f, 0.04040460f, 0.02949405f, 0.00135277f, -0.04685082f, 
    0.00137746f, -0.05819182f, 0.01866549f, -0.00888024f, -0.09258687f, -0.01552717f, -0.01936375f, 0.00245341f, 
    0.01864742f, -0.02214842f, -0.05957604f, -0.01382350f, -0.09955442f, -0.03792379f, 0.02494762f, 0.04372955f, 
    -0.00079439f, -0.03004455f, -0.02190725f, 0.04554933f, 0.08180188f, -0.04107263f, -0.05734267f, -0.03068534f, 
    -0.04303023f, -0.02353668f, -0.01257932f, 0.04192013f, -0.05633097f, -0.05070111f, -0.00225816f, 0.02543886f, 
    0.03296290f, -0.08294672f, -0.02211134f, -0.08392096f, 0.03395583f, -0.02791618f, -0.05286011f, -0.00045866f, 
    0.00941753f, -0.03055067f, -0.03836348f, -0.02928022f, 0.03073745f, -0.01073315f, -0.04081894f, 0.03049356f, 
    0.01088768f, 0.02933365f, -0.07965843f, -0.06051525f, -0.05521620f, -0.03363399f, -0.03564897f, -0.06645395f, 
    -0.08522910f, -0.07077076f, 0.03990103f, -0.06252395f, -0.05950164f, -0.05241549f, -0.01180484f, -0.03408320f, 
    0.00917487f, -0.03887887f, -0.02467288f, -0.01810259f, 0.00341851f, -0.05449268f, -0.05588789f, 0.03189011f, 
    -0.04086489f, 0.03694441f, 0.02834933f, -0.03133260f, 0.05021932f, 0.01159804f, -0.01742472f, -0.01176277f, 
    -0.02533445f, 0.03529990f, -0.05579685f, -0.08863807f, -0.01846898f, -0.01254972f, 0.02689032f, 0.01400986f, 
    -0.03735882f, -0.08513973f, -0.00216642f, 0.02225084f, -0.06657066f, 0.02554890f, 0.05486141f, -0.00237657f, 
    0.00344750f, -0.02147370f, 0.00999531f, -0.07970332f, -0.02573188f, -0.01712088f, 0.02734281f, 0.02468411f, 
    -0.01828341f, -0.07439935f, -0.02456932f, -0.00907256f, 0.00697585f, -0.03397067f, -0.02406319f, -0.05645710f, 
    -0.01726761f, -0.01483236f, 0.03359777f, 0.00255201f, -0.02506216f, -0.03138933f, 0.02391070f, -0.01773576f, 
    0.02768402f, -0.04409640f, -0.00320880f, -0.00580398f, -0.06567150f, -0.07035840f, -0.05443405f, -0.03007019f, 
    -0.17659117f, -0.11635676f, -0.05812227f, -0.11779033f, 0.07662196f, -0.03446552f, -0.02466168f, -0.05045117f, 
    0.10912947f, 0.22396795f, -0.26384741f, -0.04244215f, 0.00973760f, -0.01443230f, -0.12974155f, -0.00789971f, 
    0.09761725f, 0.04749547f, -0.13798413f, -0.08725157f, -0.43895832f, 0.03108333f, -0.03903969f, 0.06432384f, 
    -0.15795639f, 0.28090656f, -0.17185175f, 0.19270340f, -0.07056157f, 0.02274499f, -0.14711757f, 0.00718194f, 
    -0.05110613f, 0.05266057f, -0.03282478f, -0.04263026f, -0.12533714f, -0.17876916f, 0.03010198f, 0.11438762f, 
    -0.17544551f, 0.05133210f, -0.09397867f, 0.09754096f, 0.03127259f, 0.20929295f, 0.21185696f, -0.03176708f, 
    0.23061258f, -0.02969061f, -0.00256363f, 0.01821377f, -0.00805364f, 0.03183634f, 0.41859004f, -0.04567655f, 
    -0.06055177f, 0.02123618f, -0.03242625f, 0.16985707f, 0.03719085f, 0.13135876f, 0.10662619f, 0.40982622f, 
    0.15991154f, -0.05556894f, 0.10764164f, 0.13323306f, -0.04634003f, 0.01266169f, -0.00965701f, 0.06990184f, 
    -0.42153844f, -0.15306289f, 0.28230906f, 0.00793326f, 0.00690599f, -0.00320769f, -0.05953150f, 0.06168103f, 
    0.09453218f, -0.06149999f, 0.01110329f, -0.10182797f, -0.04534843f, 0.04057905f, 0.00451620f, 0.12770608f, 
    0.03531766f, 0.09365125f, -0.00762709f, -0.10979079f, -0.02679768f, -0.08616827f, 0.09899215f, 0.05692162f, 
    0.05476410f, -0.03352763f, -0.13604027f, 0.00671637f, 0.34603533f, 0.13919269f, -0.10182699f, 0.11641438f, 
    -0.05206049f, -0.02119291f, 0.00659056f, 0.12606914f, 0.48960552f, 0.04264338f, 0.03006892f, 0.09990391f, 
    -0.16464315f, 0.03802435f, -0.04719035f, 0.11640919f, 0.05068970f, -0.05898090f, 0.08795713f, -0.16135684f, 
    -0.02927841f, 0.11132392f, 0.06690202f, -0.05270828f, -0.01537994f, 0.04836784f, 0.07817435f, 0.02629558f, 
    0.07888418f, 0.00808477f, 0.06092360f, 0.01428065f, -0.08275317f, 0.18068378f, -0.01181865f, 0.08574417f, 
    0.11075599f, -0.20220402f, 0.04187207f, 0.18737216f, -0.01958086f, 0.10689300f, -0.15819627f, -0.08501821f, 
    -0.10003611f, 0.17406140f, 0.18890664f, 0.20592573f, 0.03547794f, 0.03544829f, 0.02248891f, -0.00530322f, 
    -0.01459301f, 0.25979197f, 0.07741860f, -0.09262888f, 0.18036528f, 0.17198172f, 0.05663594f, 0.02986949f, 
    0.01712916f, -0.06321867f, 0.03730931f, -0.10405616f, 0.03717353f, -0.12671961f, 0.01561306f, -0.10863275f, 
    -0.02048942f, -0.14523548f, 0.09246111f, -0.24829917f, -0.07851172f, 0.12652834f, -0.16703334f, -0.07015274f, 
    0.07752368f, -0.10410727f, 0.02770692f, -0.01259184f, -0.43563271f, -0.26040474f, -0.16275960f, 0.13999549f, 
    -0.12486258f, 0.01475969f, -0.07926405f, 0.22317468f, -0.00539456f, 0.30992836f, -0.03781634f, -0.10165136f, 
    0.00749603f, -0.01458267f, 0.05208480f, 0.11133640f, -0.12616007f, -0.03424809f, 0.17854136f, 0.13134897f, 
    0.00961607f, -0.04803629f, 0.07745451f, 0.18617575f, 0.09632771f, 0.14858153f, 0.01381714f, -0.14287280f, 
    0.07006519f, -0.26898435f, -0.34630197f, -0.06337768f, -0.10920222f, -0.00341645f, 0.19275415f, 0.18578930f, 
    0.17461555f, 0.31888670f, 0.06867683f, 0.01891342f, -0.17006208f, -0.14995991f, 0.09726688f, -0.14996418f, 
    0.23587912f, 0.11029439f, -0.17085610f, -0.09729238f, -0.21568212f, -0.15154721f, -0.08848597f, 0.04707014f, 
    -0.10091531f, 0.01375726f, -0.24443556f, -0.73044860f, -0.66247600f, -0.03250086f, 0.04199749f, 0.06825757f, 
    0.04899965f, -0.10927449f, -0.09516857f, 0.02521307f, -0.05245138f, -0.16097462f, -0.01532303f, -0.06087018f, 
    -0.10203981f, -0.13306494f, 0.19835170f, 0.10619450f, 0.15811205f, -0.03631222f, 0.16416287f, -0.17061423f, 
    0.13485694f, -0.12599060f, -0.16106184f, 0.16822207f, 0.05603124f, 0.47594744f, -0.01927682f, -0.04302340f, 
    0.21300004f, 0.03660149f, 0.02853333f, 0.00687681f, 0.07097735f, 0.01664230f, -0.03387476f, 0.01020609f, 
    -0.42529902f, 0.05580133f, -0.07369798f, 0.05713904f, -0.30229750f, 0.22073443f, -0.04823379f, -0.08086828f, 
    -0.08898887f, 0.02756895f, 0.18189502f, 0.05664182f, -0.06602149f, -0.09265536f, 0.07737684f, -0.16157909f, 
    -0.58008832f, -0.13394658f, 0.09143774f, 0.15397339f, 0.06443262f, 0.00996316f, -0.06426007f, -0.06327075f, 
    -0.03319586f, 0.06643625f, 0.13476472f, 0.02238900f, 0.04243426f, 0.07657035f, 0.07380582f, -0.06639457f, 
    -0.01937448f, 0.17166221f, -0.00753852f, 0.15939128f, 0.12803265f, -0.05903317f, 0.01778986f, -0.04978121f, 
    -0.28510219f, -0.02973434f, 0.03973959f, -0.39912775f, 0.00623713f, -0.01533411f, 0.16273393f, 0.08103354f, 
    0.07163005f, 0.10657096f, 0.02407005f, 0.20793776f, -0.42173272f, -0.20639552f, 0.16776253f, 0.07441558f, 
    0.09841787f, 0.00642617f, 0.06597455f, 0.06468154f, -0.06069867f, -0.10887461f, 0.05646230f, -0.14463453f, 
    0.00336925f, 0.04369379f, 0.08404555f, 0.08527449f, 0.09300610f, 0.04369340f, 0.11740570f, -0.40601572f, 
    -0.11893409f, -0.20086963f, 0.01214911f, -0.04076707f, 0.19851631f, -0.17368078f, -0.01808385f, -0.35669032f, 
    0.19227256f, 0.03739333f, 0.04994539f, 0.15860055f, -0.00110194f, -0.24229144f, -0.04387592f, -0.05165503f, 
    -0.06241037f, -0.07006615f, 0.02687813f, 0.17516977f, 0.02562264f, -0.08018396f, 0.15584223f, -0.06615999f, 
    0.05216831f, 0.01802479f, 0.08777685f, 0.08756527f, -0.03389803f, 0.04341292f, -0.18490842f, 0.12541600f, 
    0.02645770f, 0.17932282f, -0.07699573f, -0.02388574f, 0.28859341f, 0.07602238f, -0.00602620f, -0.05373139f, 
    -0.11378162f, 0.08686082f, -0.07597004f, -0.14658846f, -0.28537917f, -0.08692515f, -0.14199135f, -0.01476530f, 
    0.01838633f, 0.22292177f, -0.08998635f, -0.03457630f, -0.02316169f, -0.10322028f, -0.03202786f, 0.01316201f, 
    0.17672455f, -0.02934709f, -0.05206342f, 0.01162771f, 0.01507319f, -0.05118281f, -0.06630621f, 0.21119905f, 
    -0.04953390f, -0.10222378f, -0.05184777f, 0.00931227f, 0.02978914f, 0.22847414f, 0.14786352f, 0.03748216f, 
    0.07623786f, 0.10891753f, 0.05643609f, -0.00796257f, 0.08415168f, -0.02793160f, 0.12726527f, 0.14157516f, 
    -0.00459028f, 0.17935513f, 0.00090677f, -0.19240235f, -0.16310963f, 0.12375454f, -0.00603301f, 0.07080343f, 
    0.19832703f, -0.04466467f, 0.05845831f, 0.13244922f, -0.09115764f, -0.04509497f, 0.05972474f, -0.01082001f, 
    0.12773678f, 0.13934059f, -0.03273697f, 0.09629153f, -0.39739645f, -0.06830141f, 0.03775661f, 0.12161511f, 
    0.10662506f, 0.07831024f, -0.08696090f, -0.03256372f, -0.13178653f, -0.08936893f, 0.05039980f, 0.04558398f, 
    -0.00734041f, -0.18869099f, 0.08053233f, -0.59009135f, -0.04625437f, 0.06939402f, 0.34221569f, 0.07523350f, 
    -0.00535114f, -0.15663649f, -0.11312500f, 0.00839975f, 0.24809219f, 0.07525077f, 0.35822040f, 0.30806735f, 
    0.07851548f, -0.14547944f, 0.01879781f, 0.06920668f, 0.07373648f, -0.47359276f, 0.20412289f, 0.14981763f, 
    0.07640300f, -0.06057643f, 0.12910293f, -0.11593992f, 0.05795220f, -0.09977212f, -0.40572923f, -0.06850989f, 
    0.01851036f, 0.17426014f, 0.15651080f, -0.00733042f, 0.15201733f, 0.17292280f, -0.14131676f, 0.13266231f, 
    -0.04870492f, -0.08497445f, -0.03939106f, 0.01714235f, -0.04129883f, 0.09317716f, 0.03054000f, 0.00563164f, 
    -0.16571657f, -0.11976364f, -0.29123580f, -0.13077980f, 0.10184407f, -0.02381936f, -0.10421834f, -0.02672211f, 
    0.06273860f, 0.48032290f, 0.12848802f, 0.04999788f, -0.20183797f, 0.01497491f, 0.19300403f, 0.09299939f, 
    -0.01361785f, 0.01011345f, 0.19738086f, -0.13750359f, 0.17997417f, -0.10410810f, -0.09890730f, -0.16684245f, 
    0.05165309f, 0.10232082f, 0.10484547f, 0.06159870f, 0.26396912f, 0.22713102f, 0.03422365f, 0.01096976f, 
    -0.01838494f, -0.11569136f, 0.03113967f, 0.00892324f, -0.29177496f, -0.13903174f, -0.11442138f, -0.19392756f, 
    -0.04115218f, 0.02827118f, 0.21244384f, -0.13312133f, -0.01638556f, -0.01515259f, 0.15911224f, 0.17708410f, 
    0.01494932f, 0.03300403f, 0.05300347f, -0.19913708f, 0.17124896f, 0.03400125f, -0.28162327f, 0.10084894f, 
    -0.05969476f, -0.10350765f, -0.06943180f, 0.03507663f, -0.00655446f, -0.06357964f, -0.26074743f, 0.08078709f, 
    0.22841983f, 0.12285767f, -0.11136415f, -0.11232176f, 0.19200544f, -0.16442773f, 0.11721182f, 0.00344917f, 
    -0.03595995f, 0.00548363f, 0.04891830f, 0.00756064f, 0.01131405f, -0.02701577f, 0.04772925f, -0.03237492f, 
    0.04776170f, -0.03284738f, -0.01530998f, -0.04673174f, -0.02122166f, 0.00228068f, -0.05905453f, -0.01142886f, 
    0.01959253f, -0.06408459f, -0.03722201f, -0.04675239f, 0.03865207f, -0.06961474f, -0.00729951f, -0.04285319f, 
    -0.04722219f, -0.05160111f, -0.03871115f, -0.04101992f, 0.03790474f, 0.01179364f, -0.04716448f, 0.04793525f, 
    -0.02278547f, -0.00472977f, -0.00127411f, 0.00372814f, 0.05165030f, -0.02725594f, -0.05341263f, -0.00387388f, 
    -0.00683401f, 0.00991794f, 0.02428115f, -0.06169829f, -0.00496476f, 0.00618592f, -0.06010215f, -0.01586465f, 
    0.03379830f, -0.01944079f, -0.06350141f, -0.03913786f, 0.01461918f, -0.04298611f, -0.03671040f, -0.01601142f, 
    0.04145175f, -0.01166358f, 0.04490600f, -0.02203067f, 0.04331240f, -0.01750090f, 0.03601957f, -0.02225647f, 
    -0.05832918f, -0.02566535f, -0.05691243f, -0.02380105f, 0.04663631f, -0.02593918f, -0.06046867f, -0.01550584f, 
    0.02499275f, 0.01606226f, -0.01322449f, 0.01053426f, -0.04924722f, 0.05023815f, -0.05541604f, -0.00860486f, 
    0.03255016f, 0.00739024f, -0.03846908f, -0.04249807f, -0.05869322f, -0.00709226f, -0.04106466f, 0.04680167f, 
    0.01617133f, -0.00745489f, -0.04834801f, -0.04461318f, 0.04301744f, -0.03827319f, -0.06010839f, 0.03579719f, 
    0.00485931f, -0.03959217f, 0.02604129f, -0.02796787f, 0.03849009f, 0.03214734f, -0.01243429f, -0.02662919f, 
    0.05462031f, -0.00782526f, -0.05948354f, -0.01091009f, 0.00388665f, -0.06295419f, 0.04557742f, -0.00108381f, 
    -0.04069882f, 0.05137062f, 0.02610363f, 0.04842851f, 0.02139425f, 0.04706278f, 0.03921380f, 0.00507015f, 
    -0.05731514f, -0.02597642f, 0.03456192f, 0.00100908f, 0.01560516f, 0.04755225f, -0.03746393f, 0.02553512f, 
    -0.03291006f, -0.00169667f, -0.05966284f, -0.02225119f, -0.06076857f, -0.04715003f, 0.02688148f, -0.05962112f, 
    -0.04333100f, -0.05544775f, -0.06135621f, 0.03534444f, -0.04669622f, -0.00656614f, -0.02306624f, -0.05687394f, 
    -0.01942575f, -0.05798527f, -0.04823627f, 0.02289492f, 0.03388383f, -0.06216149f, -0.03765012f, 0.03411350f, 
    0.02374211f, -0.02807612f, 0.04103029f, -0.05038282f, -0.00612544f, -0.06206792f, 0.02843608f, 0.05463802f, 
    -0.05343831f, -0.02269002f, 0.02028886f, -0.00497784f, 0.01792174f, -0.01816925f, -0.03421571f, 0.02429430f, 
    -0.03953166f, -0.01331978f, 0.02759824f, -0.03592343f, 0.04349684f, -0.01734498f, -0.03668561f, 0.02627830f, 
    -0.03315316f, -0.03396063f, -0.05376561f, -0.04532802f, -0.04933352f, -0.06256098f, -0.02268841f, -0.01954157f, 
    0.05101104f, 0.00313668f, 0.04021103f, -0.03368901f, 0.03514691f, 0.03080268f, -0.06508995f, -0.05470027f, 
    0.03356128f, -0.05141938f, 0.03586376f, 0.03258615f, -0.03351686f, -0.05327115f, -0.01751098f, -0.03807556f, 
    -0.00762848f, -0.03207285f, -0.00145746f, 0.01923772f, 0.03618528f, -0.03190247f, -0.00617500f, -0.02127735f, 
    -0.03086632f, 0.01841453f, 0.03692189f, 0.01219901f, 0.04490750f, -0.05048360f, -0.04806012f, 0.03342051f, 
    -0.00887854f, -0.00736739f, -0.00339207f, -0.04137745f, -0.01572042f, -0.04479111f, -0.02244627f, 0.02136327f, 
    0.05524288f, -0.03626889f, 0.03921191f, -0.06575826f, -0.04482093f, -0.03367702f, 0.04287326f, -0.04889238f, 
    -0.01857760f, -0.04047090f, -0.00809216f, 0.03116618f, -0.03375121f, 0.04304128f, 0.00036223f, 0.04554034f, 
    0.00498317f, 0.02341207f, 0.04207039f, -0.02044160f, -0.04839785f, -0.04493121f, -0.04224428f, 0.03321191f, 
    0.02540295f, -0.00454325f, -0.03493598f, -0.02273426f, 0.00578832f, -0.02357486f, -0.05842359f, 0.01793809f, 
    -0.04758124f, 0.05512057f, -0.03954732f, 0.04183333f, -0.05014441f, -0.01342952f, -0.00003546f, -0.03997685f, 
    -0.05626858f, -0.00220588f, 0.00786142f, -0.05497359f, -0.05474523f, -0.05288877f, 0.01095074f, -0.04317532f, 
    -0.05489160f, 0.02283850f, -0.04226076f, 0.04662371f, 0.00225787f, -0.06247731f, -0.00509146f, 0.02160345f, 
    0.05431905f, 0.01294504f, -0.03723458f, -0.03585554f, 0.00625414f, 0.03887266f, 0.02288686f, 0.01930963f, 
    -0.03051156f, 0.00994283f, 0.04322668f, -0.00499038f, 0.00016242f, -0.02277872f, 0.02346403f, -0.04425333f, 
    -0.00608741f, 0.03648520f, 0.00626426f, 0.04568035f, -0.01379374f, 0.00804741f, -0.04069197f, -0.05378028f, 
    -0.01222887f, -0.06027888f, -0.04992001f, -0.06425998f, -0.04941366f, 0.02240741f, -0.03350410f, -0.00135030f, 
    0.00855711f, -0.01832081f, -0.02981870f, 0.03770720f, -0.05733584f, 0.02164623f, -0.00281293f, 0.01097027f, 
    0.01566305f, -0.03978270f, 0.04890932f, -0.04474386f, -0.04394434f, 0.02744485f, 0.00158159f, 0.03279220f, 
    -0.01940623f, -0.02136580f, 0.02409529f, -0.06596569f, -0.02648169f, 0.03346323f, -0.02840781f, -0.03079202f, 
    -0.04616188f, -0.00241029f, 0.02952961f, 0.03700212f, -0.01425983f, -0.05173217f, 0.00264887f, -0.01894080f, 
    -0.03145707f, -0.05945863f, 0.01057997f, -0.02711538f, -0.02553985f, -0.00151068f, 0.02123347f, 0.01441837f, 
    0.03996294f, -0.05116049f, 0.04703951f, -0.06724174f, 0.03627630f, -0.03371393f, -0.03141820f, 0.04731267f, 
    0.03022913f, 0.00011994f, -0.06693426f, -0.03945699f, -0.06310765f, 0.00391549f, -0.06768468f, -0.03376428f, 
    0.01820476f, -0.03897605f, -0.03223414f, -0.02178904f, -0.00152317f, -0.04879896f, -0.03421666f, -0.00552939f, 
    -0.06219972f, 0.00825105f, -0.05061822f, 0.00117768f, 0.00127414f, -0.06490947f, -0.00309261f, -0.04234247f, 
    -0.02713030f, -0.05314817f, -0.01886582f, -0.02128845f, 0.01142534f, -0.06384914f, -0.02033617f, 0.00065249f, 
    -0.03425222f, -0.04292471f, -0.01383473f, -0.03356725f, 0.04642730f, -0.00446013f, -0.06672409f, -0.04663401f, 
    0.00053723f, -0.03105522f, -0.00896058f, -0.03353577f, 0.01344212f, -0.02358398f, 0.04963433f, -0.01762810f, 
    -0.06722654f, -0.00778531f, 0.03583038f, -0.02619345f, 0.01680583f, -0.00458219f, 0.00528467f, 0.04517740f, 
    -0.04983627f, -0.02782340f, 0.02340410f, 0.04042898f, 0.01025768f, 0.01886838f, -0.05110734f, -0.01141388f, 
    -0.00405945f, -0.00180549f, -0.01217167f, -0.03152782f, -0.05081343f, 0.04457851f, -0.02118284f, -0.03356546f, 
    0.04280535f, 0.03442309f, -0.05003834f, -0.05994991f, -0.00610704f, 0.03498758f, 0.04972394f, 0.02986018f, 
    -0.01125450f, 0.02440970f, -0.00505388f, 0.04431381f, -0.02025587f, -0.01758861f, -0.05871565f, -0.05249470f, 
    -0.06131806f, -0.00696471f, -0.02676042f, 0.02956412f, -0.01667922f, -0.04804707f, -0.06805081f, 0.04009890f, 
    -0.02956661f, 0.00178596f, 0.00729097f, 0.01181212f, -0.05791232f, -0.03056012f, 0.01207881f, -0.06746349f, 
    -0.03297986f, 0.02385749f, 0.03089339f, -0.02608157f, -0.01766242f, 0.02494351f, 0.01049641f, -0.06796549f, 
    -0.01250576f, -0.04840492f, -0.02710571f, 0.02508140f, 0.04423545f, 0.03004355f, 0.03273651f, -0.05544694f, 
    -0.00569233f, -0.05493227f, 0.04180676f, -0.01754747f, -0.04638572f, 0.02641179f, 0.00688193f, -0.02632811f, 
    0.03995661f, 0.02788133f, -0.06560078f, -0.04006415f, 0.02800713f, 0.04267019f, 0.01150383f, -0.02150618f, 
    -0.00076233f, 0.04481257f, -0.04802650f, 0.04953769f, -0.05685377f, 0.01016476f, -0.04707128f, 0.04278811f, 
    0.01089317f, 0.00822952f, -0.04159462f, 0.01866723f, -0.02191503f, 0.00237491f, 0.04965426f, -0.04241249f, 
    -0.05790972f, 0.03700750f, 0.04755505f, 0.02857696f, -0.03327947f, -0.02923151f, -0.03781388f, -0.04914887f, 
    -0.01698351f, -0.02920314f, -0.02093248f, -0.05486728f, -0.03440630f, 0.01195268f, 0.04640665f, -0.05218801f, 
    0.02883757f, -0.01130101f, 0.02691108f, -0.00450755f, -0.04722808f, 0.00426071f, 0.01614461f, -0.01003337f, 
    -0.01129145f, 0.02645389f, 0.02863962f, -0.00705687f, 0.01660680f, -0.01317275f, -0.01754310f, 0.03818991f, 
    0.02487475f, -0.03915045f, 0.04852697f, -0.05670265f, -0.00101424f, -0.00083566f, -0.03215442f, 0.00645359f, 
    0.01646091f, 0.03433029f, 0.01549726f, 0.00096999f, -0.00104740f, -0.04607187f, 0.03754959f, 0.00494908f, 
    -0.00877840f, 0.00614836f, -0.06416050f, -0.01385477f, 0.02559060f, 0.03854974f, -0.00094893f, 0.01360364f, 
    0.02266422f, -0.03838979f, -0.02697427f, 0.02692933f, -0.02450897f, -0.00264642f, -0.04731362f, -0.05080263f, 
    0.11809051f, 0.15025236f, 0.07453883f, 0.19592185f, 0.14247823f, -0.13703099f, 0.02115439f, 0.12210935f, 
    0.07857995f, -0.01070625f, 0.17517315f, -0.08104461f, 0.09276197f, -0.18214448f, 0.19218686f, -0.05963138f, 
    0.00505190f, 0.11140557f, 0.05971415f, -0.09392750f, 0.07703000f, -0.03167532f, -0.12174962f, 0.00693207f, 
    0.02507752f, -0.14905494f, -0.15376893f, 0.13380867f, 0.03991972f, 0.14158787f, 0.15312454f, 0.07744819f, 
    0.10239843f, -0.15939614f, 0.09864525f, 0.10561053f, -0.06957908f, 0.08860916f, 0.10541634f, -0.11389612f, 
    0.07397271f, -0.05016198f, 0.02620387f, -0.07718157f, -0.10437799f, -0.37865552f, -0.32399383f, -0.17628898f, 
    0.09907541f, 0.08306447f, 0.17844780f, 0.15719867f, -0.03027075f, -0.12102713f, 0.13693316f, -0.41687807f, 
    -0.42276207f, -0.18472192f, 0.07770009f, 0.11876575f, -0.01326798f, -0.11540604f, -0.04279451f, -0.09453054f, 
    -0.20431887f, -0.02583958f, -0.00647033f, -0.04814756f, 0.01965284f, -0.00510580f, 0.00476494f, -0.05680797f, 
    -0.01168458f, 0.18960929f, 0.18244416f, 0.07531174f, -0.02706510f, 0.09105531f, -0.08166917f, 0.00103231f, 
    -0.06737698f, 0.09784674f, -0.20217307f, -0.28880182f, -0.18190968f, 0.00815608f, 0.13065836f, -0.01115331f, 
    0.02118753f, -0.03898130f, 0.09555504f, -0.29468018f, -0.25267836f, -0.30466780f, 0.11694295f, -0.05792843f, 
    0.03102832f, -0.06677411f, -0.12380240f, 0.30472302f, 0.13852556f, -0.39750779f, -0.13884553f, -0.17325720f, 
    0.02019309f, -0.00205895f, 0.16178806f, -0.17122264f, 0.09679884f, 0.04657190f, 0.00883265f, 0.14278619f, 
    0.15714929f, 0.01569141f, -0.03396599f, 0.00431881f, -0.08396281f, 0.29549664f, 0.11988402f, -0.00230755f, 
    -0.18442601f, -0.09018558f, -0.11931928f, 0.10771928f, -0.06966797f, 0.03041567f, -0.28271016f, 0.07079507f, 
    -0.26009190f, -0.04417676f, 0.07329559f, 0.14708233f, -0.03683397f, 0.24276738f, -0.04043564f, 0.46459070f, 
    0.18038043f, 0.20603634f, 0.16708906f, 0.02261190f, -0.12131593f, -0.12610841f, 0.22309843f, 0.20567617f, 
    -0.33969066f, 0.11365694f, 0.07170590f, -0.21116941f, -0.06172521f, -0.02502339f, 0.00220459f, 0.02322860f, 
    0.07318560f, 0.13914672f, -0.18131343f, 0.14731883f, -0.11393938f, -0.12782851f, -0.09404578f, 0.22495705f, 
    0.13695534f, -0.08273493f, 0.35502970f, 0.03672386f, 0.22140265f, 0.22675137f, 0.01480709f, -0.04276115f, 
    -0.16637817f, 0.25852075f, 0.06682852f, -0.06300160f, 0.28627774f, -0.07039638f, 0.13819566f, -0.03546230f, 
    -0.14124636f, 0.22929239f, 0.04838648f, 0.02850214f, 0.09821456f, -0.21819548f, 0.24812180f, -0.00755097f, 
    0.04973629f, -0.02390391f, -0.11428075f, -0.22580656f, -0.03118943f, -0.18227951f, -0.22236344f, -0.04554249f, 
    -0.01075895f, -0.08352485f, 0.12120259f, -0.05114615f, 0.11502551f, -0.11657069f, 0.36460295f, -0.06003746f, 
    0.12005588f, 0.12384354f, -0.00760354f, 0.19895102f, 0.04406231f, 0.09974454f, -0.15032434f, 0.48057994f, 
    0.16695328f, -0.10263149f, -0.11252408f, -0.02545932f, -0.02453193f, 0.03315902f, -0.16148889f, -0.05765506f, 
    0.06255405f, 0.27354658f, 0.05114638f, 0.18159755f, 0.02454543f, 0.16381922f, -0.03552140f, -0.06130420f, 
    -0.02899579f, -0.21350189f, 0.18357748f, 0.05323954f, 0.08856373f, 0.15929775f, 0.10676606f, -0.14383565f, 
    0.23276038f, 0.21227087f, 0.03799370f, 0.16754940f, -0.05109945f, -0.25368223f, -0.02821623f, -0.07068878f, 
    -0.02253238f, -0.08035441f, 0.12251035f, 0.04075192f, 0.28210217f, 0.01305561f, 0.20548861f, 0.08036308f, 
    -0.08698791f, -0.09737334f, 0.02641439f, 0.19717303f, -0.33140031f, 0.00856601f, 0.06210311f, -0.08129761f, 
    -0.02914476f, -0.08958821f, 0.11329333f, -0.06153922f, 0.02839945f, 0.13197006f, -0.17743160f, -0.04739021f, 
    -0.14675540f, -0.05067439f, 0.07867830f, -0.17068771f, -0.21542297f, -0.08342480f, 0.16937934f, 0.23485473f, 
    0.03045612f, 0.25837925f, -0.17993857f, -0.04108791f, 0.04447373f, -0.04499109f, -0.06060697f, -0.07218705f, 
    0.09048103f, 0.01861513f, -0.02850916f, 0.02060403f, -0.09404175f, -0.05430343f, 0.09829248f, -0.20493738f, 
    0.09925325f, 0.26199073f, 0.10675303f, -0.07754090f, -0.00190184f, -0.10456482f, -0.06646254f, 0.07513867f, 
    -0.00990819f, -0.03311614f, 0.02108988f, 0.20277803f, -0.24350345f, -0.08050871f, -0.07091223f, -0.07650987f, 
    0.07398717f, 0.00911870f, 0.20491022f, -0.19548666f, 0.09936079f, 0.05615423f, -0.08905277f, 0.06798833f, 
    0.01753818f, 0.12683518f, -0.02284362f, 0.01644886f, 0.05221779f, 0.06489659f, 0.07738821f, 0.18272935f, 
    0.04635115f, -0.03867504f, 0.10368741f, -0.03371032f, -0.07673487f, 0.07271943f, -0.17070782f, -0.07218197f, 
    -0.11906643f, -0.08844182f, 0.04379717f, 0.05238244f, -0.03041156f, -0.21233799f, -0.22593668f, 0.00470069f, 
    -0.04840317f, 0.07516218f, 0.04983632f, 0.00529495f, 0.18327035f, -0.26646006f, -0.28887078f, -0.04551179f, 
    -0.12180458f, 0.12304267f, 0.11977715f, -0.00152021f, 0.22360216f, -0.10183277f, -0.03508689f, -0.12617014f, 
    -0.43598261f, -0.08749551f, 0.01821066f, 0.07346629f, 0.05522907f, 0.14932442f, -0.06692268f, -0.07451737f, 
    -0.40778667f, 0.37590498f, -0.07258336f, -0.02609627f, 0.00121297f, -0.13572615f, -0.02312046f, -0.03310159f, 
    0.00024636f, 0.16181932f, -0.23963252f, 0.22136249f, 0.16149206f, 0.08218320f, 0.04441370f, -0.01028777f, 
    0.04208588f, 0.07932261f, -0.05027148f, -0.11906977f, 0.18969722f, 0.22928970f, 0.07595488f, 0.08687177f, 
    0.13193367f, 0.11888395f, 0.00815567f, 0.14065635f, -0.07821336f, -0.16631560f, 0.01900644f, -0.02390820f, 
    -0.05742730f, 0.05760363f, -0.08319158f, 0.04437259f, -0.05041207f, 0.08575435f, -0.12487049f, 0.05995307f, 
    -0.10762997f, 0.06231655f, 0.01200999f, 0.10775410f, -0.06202664f, 0.42961437f, -0.01124969f, 0.02457534f, 
    0.06173364f, 0.03444740f, 0.05733177f, -0.04736462f, 0.01938956f, 0.00896887f, -0.17942765f, 0.24841966f, 
    0.04638753f, -0.02063803f, 0.00978650f, 0.03264649f, -0.04265927f, 0.26702952f, -0.14321035f, -0.07830843f, 
    -0.18620068f, -0.29696232f, 0.03513419f, 0.02629722f, -0.09332172f, 0.02992732f, -0.06731270f, 0.04207981f, 
    0.00520346f, 0.23952587f, -0.09953557f, 0.04063770f, -0.00202202f, 0.05995248f, -0.00596812f, 0.05778277f, 
    0.05132929f, 0.15979925f, 0.24523139f, -0.11792872f, -0.08651624f, -0.25170678f, 0.15893725f, 0.18111652f, 
    0.10624094f, 0.02138232f, -0.46761525f, 0.10182871f, 0.11415319f, -0.08620424f, 0.09895925f, -0.12329854f, 
    -0.00725084f, 0.06603307f, 0.16871241f, 0.26489344f, 0.20468187f, -0.01136895f, 0.10894933f, -0.34054986f, 
    -0.08373386f, 0.00206336f, 0.15463264f, 0.09639698f, -0.12394186f, -0.19970521f, -0.09826411f, 0.16184546f, 
    -0.11655967f, -0.10089251f, -0.13686329f, -0.23124048f, 0.01438057f, 0.11366197f, -0.51908320f, 0.09822518f, 
    0.12373549f, 0.11417748f, 0.13856991f, 0.09128603f, 0.01397997f, 0.07393698f, -0.00405789f, 0.28749040f, 
    -0.26050228f, -0.12981848f, -0.04247872f, 0.06967238f, -0.21279308f, 0.03411851f, 0.09348746f, 0.32881939f, 
    -0.27200523f, -0.07735895f, -0.16939077f, -0.27403936f, -0.06819778f, -0.19412039f, 0.14475822f, 0.14137776f, 
    0.13867947f, -0.03049677f, 0.01113265f, 0.14047846f, -0.02344843f, -0.01264487f, -0.04437125f, 0.13080886f, 
    0.11447964f, -0.15893978f, 0.20482008f, 0.06451260f, -0.08636116f, -0.14382391f, 0.08123983f, 0.05998510f, 
    0.03270643f, -0.07376358f, -0.03825369f, -0.01574059f, 0.23193970f, -0.22953711f, -0.03673881f, -0.08485456f, 
    -0.01879433f, -0.16220891f, -0.10962441f, 0.09738401f, 0.06688420f, 0.08504517f, -0.03033929f, 0.07110818f, 
    -0.03329232f, -0.15467584f, 0.10153683f, 0.05055139f, -0.36996850f, -0.02516579f, -0.06557871f, -0.06605095f, 
    -0.08893545f, 0.01679032f, 0.12081189f, 0.12886401f, -0.02470897f, 0.15935031f, -0.28253764f, 0.08103444f, 
    0.29469177f, 0.03416662f, -0.02048459f, 0.07640591f, -0.07011001f, -0.04652679f, 0.03363366f, -0.44977626f, 
    0.13688806f, 0.11838894f, -0.22821091f, -0.05063232f, -0.19762729f, 0.03868312f, 0.01938276f, 0.25259817f, 
    0.08798493f, -0.19461691f, -0.16632181f, -0.05629924f, -0.03513587f, 0.13142067f, 0.08897697f, 0.01124566f, 
    -0.06459779f, -0.02194541f, -0.01206228f, 0.01210015f, 0.00430479f, 0.00795431f, 0.02841727f, 0.01712321f, 
    0.03449413f, 0.02140928f, -0.00289758f, 0.01083504f, -0.05784238f, -0.00223083f, 0.04078320f, 0.04152229f, 
    0.03652214f, -0.01405944f, -0.05758567f, 0.02066277f, -0.01478890f, 0.00050920f, -0.04516682f, 0.01964003f, 
    -0.05339290f, -0.06779777f, 0.02856996f, 0.01503111f, 0.00032781f, -0.01259657f, 0.02564629f, 0.02453716f, 
    -0.00511058f, 0.02256573f, -0.06018697f, 0.02966915f, 0.03434911f, 0.03866229f, -0.01508303f, -0.04458032f, 
    0.00050293f, -0.03090073f, 0.01371000f, 0.00463112f, 0.01233025f, -0.04184990f, -0.05116105f, -0.02719951f, 
    0.04909647f, -0.01270738f, -0.04466139f, 0.04101261f, -0.01337780f, 0.00352185f, -0.02491836f, -0.00258365f, 
    -0.04724425f, 0.00228474f, -0.00248376f, 0.05344189f, -0.06359325f, 0.01326934f, 0.00424197f, -0.02179496f, 
    0.02159493f, -0.00838161f, -0.04976875f, 0.04571356f, 0.03838376f, 0.02948470f, 0.04549520f, 0.03009492f, 
    -0.06429024f, -0.03620826f, -0.02103489f, -0.03186185f, -0.05516908f, -0.00028318f, 0.00168412f, -0.05715514f, 
    0.01842438f, 0.00181800f, -0.04927262f, 0.00912625f, 0.00923756f, 0.02287185f, 0.00395984f, -0.02992214f, 
    -0.05172452f, -0.04830389f, -0.05195095f, 0.00534309f, -0.02158042f, 0.02815132f, 0.03976290f, -0.02917447f, 
    0.00003419f, 0.03947034f, -0.03262950f, 0.03249249f, -0.06552344f, 0.03180398f, 0.02082033f, 0.03719241f, 
    -0.01433331f, 0.01399067f, -0.00346702f, -0.04950149f, 0.04875589f, 0.04140287f, -0.05443446f, -0.02478224f, 
    -0.05996723f, -0.05872881f, -0.00292545f, -0.01295903f, -0.04955230f, -0.04176106f, -0.06096013f, 0.02022609f, 
    0.03682242f, -0.02187267f, 0.02095007f, -0.06550385f, 0.01623286f, 0.03887323f, 0.00912478f, 0.01879283f, 
    -0.04939476f, -0.06082477f, -0.05369074f, -0.02948795f, -0.04941417f, -0.01955412f, -0.02874717f, 0.03021276f, 
    0.04562001f, -0.00245511f, -0.00453483f, 0.05275501f, -0.01657209f, -0.06510119f, -0.04996246f, 0.01498451f, 
    0.03622374f, 0.03675552f, -0.00773582f, 0.03733990f, -0.00375780f, 0.04167225f, 0.00801273f, -0.01758626f, 
    -0.04522075f, 0.01755807f, 0.05214345f, -0.04030431f, 0.01167980f, -0.00343945f, -0.03606778f, -0.06340285f, 
    -0.00923961f, -0.02529951f, 0.00262756f, 0.04098232f, 0.01248622f, -0.06043778f, -0.00240901f, -0.04504487f, 
    -0.03057708f, 0.03044750f, 0.03981656f, 0.05643371f, 0.02134343f, -0.06768361f, 0.01284500f, -0.06306452f, 
    -0.04115761f, 0.02531079f, 0.02142900f, -0.04948112f, 0.01289684f, 0.00400623f, 0.02290511f, 0.03831616f, 
    0.02975740f, -0.05323857f, -0.02507645f, -0.02989490f, 0.01148067f, -0.01939971f, -0.00706618f, -0.01657636f, 
    0.04831992f, -0.04794286f, 0.03199784f, 0.04531305f, 0.02877164f, 0.02747452f, -0.05754366f, -0.05219817f, 
    -0.02381512f, 0.00860182f, -0.00330689f, -0.05871531f, 0.00142358f, -0.05180107f, 0.02446249f, 0.05437990f, 
    -0.01475373f, 0.03188977f, 0.03699353f, -0.05158539f, 0.03789884f, -0.02474128f, -0.00121953f, -0.02806924f, 
    -0.01848058f, -0.00213848f, -0.06444108f, -0.04371772f, -0.03942477f, 0.03624839f, -0.03200271f, 0.02641210f, 
    -0.03855001f, -0.00842832f, 0.00468370f, 0.04790716f, -0.01975739f, -0.00497395f, -0.03323307f, -0.03454980f, 
    0.01546336f, 0.03296993f, -0.01147702f, 0.03748740f, 0.02916861f, 0.00485005f, -0.00763199f, 0.02398952f, 
    0.03651256f, -0.04594579f, -0.02044025f, -0.06343766f, -0.05942597f, 0.04535856f, 0.04511791f, -0.02858038f, 
    0.02752458f, 0.02067558f, -0.05228587f, -0.01025476f, -0.05807488f, -0.04479647f, -0.04887124f, -0.00720792f, 
    -0.06184993f, 0.00020599f, 0.02043553f, 0.03041734f, -0.03233978f, -0.01646904f, -0.03261217f, -0.03755230f, 
    -0.02183328f, -0.04271516f, 0.02152025f, -0.03830545f, 0.05415074f, 0.04861702f, -0.05317216f, 0.01285658f, 
    0.03037687f, -0.06528508f, 0.03597895f, 0.03182823f, 0.01665437f, 0.01955343f, 0.01614848f, -0.05281553f, 
    -0.02219664f, -0.01244634f, -0.01621469f, -0.00677433f, -0.04727690f, 0.00028590f, 0.04899634f, -0.05761245f, 
    -0.05917091f, 0.03914443f, -0.01512690f, -0.00899149f, -0.00258049f, -0.04974074f, 0.02906851f, 0.03428229f, 
    -0.05861655f, 0.01573024f, 0.04096012f, -0.04935081f, -0.01881436f, -0.04411075f, -0.06080402f, 0.04960454f, 
    -0.04330020f, -0.00775048f, 0.03713251f, 0.01446360f, -0.02299304f, 0.02422153f, -0.01868415f, 0.04497397f, 
    -0.02694018f, 0.04515792f, -0.05909752f, -0.00069830f, 0.00063287f, 0.02075327f, 0.01517630f, 0.00408956f, 
    -0.00252877f, 0.01529805f, -0.00858231f, 0.01354260f, 0.03483437f, -0.04201291f, 0.03693165f, -0.03678236f, 
    -0.02298012f, -0.02795090f, 0.04412114f, -0.06094125f, 0.00838807f, -0.04813336f, 0.02415099f, -0.02716525f, 
    -0.00381277f, 0.02440830f, 0.00536416f, -0.04668346f, -0.03674405f, -0.05739670f, -0.05262690f, 0.03494044f, 
    0.01454585f, 0.04869607f, -0.00603893f, -0.00296349f, -0.00867082f, -0.04162150f, 0.00654175f, -0.01552952f, 
    -0.00460576f, 0.05103299f, 0.01041409f, -0.01225407f, 0.04100542f, -0.00376143f, 0.01127062f, 0.04737796f, 
    -0.05147367f, 0.00557767f, 0.02177605f, -0.04674156f, -0.03596301f, 0.01581519f, -0.03100758f, 0.01963259f, 
    -0.04352951f, -0.05230850f, -0.01541121f, 0.02997382f, 0.03137506f, 0.01445684f, 0.05191827f, 0.03281092f, 
    0.05082437f, 0.01004396f, 0.00141519f, 0.04250929f, 0.04912881f, -0.01567866f, 0.04165902f, -0.05461898f, 
    0.03105075f, -0.01874198f, -0.05102425f, -0.05869739f, -0.05570222f, -0.06184642f, -0.04183296f, -0.03682826f, 
    -0.05343184f, -0.01007256f, 0.01892800f, 0.00205359f, -0.05263869f, 0.04583595f, -0.03210323f, -0.03378309f, 
    0.01299193f, 0.03995883f, 0.02132910f, -0.05018807f, 0.02578526f, 0.00649850f, -0.04897026f, 0.04439818f, 
    -0.02934944f, -0.04550721f, 0.00567868f, -0.03914677f, -0.04941533f, 0.04287456f, -0.03416094f, -0.03894977f, 
    -0.05562890f, 0.02726415f, -0.06276975f, 0.01354423f, -0.05646367f, -0.01304120f, 0.00846510f, 0.00024506f, 
    0.03367035f, -0.02477098f, 0.03976529f, 0.03491260f, -0.04246689f, 0.01017622f, -0.05150126f, -0.02820402f, 
    -0.02101440f, -0.06346810f, -0.02458034f, -0.01257190f, -0.01305668f, -0.02772566f, 0.00731488f, -0.05502990f, 
    -0.06151945f, -0.04330280f, 0.01392456f, 0.05331248f, -0.03841642f, -0.02677344f, 0.01274953f, -0.01579707f, 
    -0.03135261f, 0.04471197f, -0.00727615f, -0.01892838f, 0.03074300f, 0.01517864f, -0.05760558f, -0.06004936f, 
    -0.03605133f, -0.02596118f, -0.03892567f, 0.01654985f, -0.03981510f, -0.05924605f, 0.02725594f, -0.01632523f, 
    -0.01688112f, 0.03511338f, 0.03147764f, 0.04778019f, -0.05446360f, -0.04361088f, 0.04141696f, 0.02719502f, 
    0.03867658f, -0.01498197f, -0.00176658f, -0.00246117f, 0.01880353f, -0.02615947f, -0.04938238f, 0.00340364f, 
    -0.01573209f, -0.02628636f, -0.00993258f, -0.00737972f, -0.04164574f, -0.03578392f, -0.02103409f, -0.06223669f, 
    0.02437306f, -0.04114563f, 0.00862607f, -0.00857088f, 0.02477546f, 0.05085366f, 0.00687386f, -0.00249546f, 
    -0.04706417f, 0.00712397f, 0.01319555f, -0.02043172f, 0.00313411f, -0.00329716f, -0.03802671f, 0.04218856f, 
    -0.06065082f, 0.01997211f, 0.04896202f, 0.06102185f, -0.05234374f, -0.05304424f, -0.03662804f, -0.04763107f, 
    0.03462784f, -0.04524393f, 0.02327557f, -0.01262885f, -0.01379952f, -0.03568211f, -0.02806504f, -0.06199485f, 
    0.02181346f, -0.06272399f, -0.03268094f, -0.03794345f, -0.06319501f, -0.03464099f, 0.03100918f, -0.04944317f, 
    0.02622578f, -0.06006952f, 0.02207496f, -0.02127114f, 0.01839432f, -0.06432028f, -0.04643560f, -0.00481514f, 
    -0.05208359f, 0.03978164f, -0.01732053f, -0.00189264f, 0.05246774f, 0.01075956f, -0.05029427f, -0.00195389f, 
    -0.00064297f, -0.03442398f, -0.01626286f, -0.01111007f, 0.01075222f, 0.04401277f, 0.00860208f, -0.03278155f, 
    -0.01358895f, -0.01998979f, 0.02532037f, -0.04682439f, 0.03494017f, -0.04801244f, -0.00868170f, -0.05925828f, 
    0.04644598f, 0.00003581f, -0.05074221f, 0.03953535f, 0.03938356f, 0.04159983f, 0.02796342f, -0.05012685f, 
    -0.02564157f, 0.00969491f, 0.05045910f, 0.02354363f, 0.01335381f, 0.04907943f, -0.00209884f, -0.00939354f, 
    0.02106898f, 0.15241997f, 0.18320876f, -0.02333616f, -0.04804865f, 0.13996246f, 0.00469088f, 0.04467405f, 
    -0.12042342f, 0.11361893f, 0.12890939f, -0.09645935f, -0.03900726f, -0.14618728f, 0.09773762f, -0.09412612f, 
    -0.05137989f, 0.03531200f, -0.16076493f, -0.17724761f, -0.04424577f, 0.18221539f, -0.03056045f, -0.05342682f, 
    0.08753941f, 0.03907504f, -0.28028622f, -0.00312963f, 0.23553517f, 0.19396365f, -0.12611982f, -0.03882416f, 
    0.00420382f, 0.04900770f, 0.05271765f, -0.17274652f, -0.09365907f, -0.00736718f, -0.15840830f, 0.24955495f, 
    -0.09783361f, 0.10359287f, 0.00973203f, 0.12795429f, -0.00471560f, 0.02743923f, 0.11101662f, 0.18057284f, 
    -0.07439883f, -0.16841662f, -0.11305933f, -0.05069204f, 0.12413676f, 0.00743341f, -0.21717717f, -0.05511972f, 
    -0.15014482f, 0.20901771f, 0.06649370f, -0.08414897f, 0.10522797f, 0.03993214f, 0.13058579f, -0.06339091f, 
    -0.03132877f, 0.06837866f, -0.08011914f, -0.00394274f, -0.00471564f, 0.04019351f, 0.07964907f, 0.10577418f, 
    -0.08293574f, 0.05141950f, -0.14661902f, -0.01236163f, -0.08268894f, -0.26003742f, 0.04711575f, -0.11718594f, 
    -0.02960815f, -0.19884044f, -0.04332922f, 0.19980302f, 0.12926102f, 0.11863929f, -0.07713617f, -0.13231893f, 
    0.01879465f, -0.14616756f, -0.51183033f, 0.16748394f, -0.04245584f, 0.07902327f, -0.02127578f, 0.00200682f, 
    -0.04518681f, -0.01863319f, 0.19508940f, 0.05897029f, -0.05025756f, -0.37776014f, 0.00685151f, -0.11742772f, 
    -0.08950516f, -0.03247638f, -0.18746436f, 0.09989880f, 0.00544134f, 0.37057424f, 0.06844775f, 0.03871286f, 
    -0.12819231f, -0.11366601f, 0.19995916f, -0.09008105f, 0.11368720f, -0.41744882f, -0.21654287f, -0.28161937f, 
    0.12677591f, 0.03150166f, 0.07035981f, -0.04048171f, 0.21947888f, -0.13472490f, -0.01750588f, 0.12985480f, 
    0.10315615f, 0.11729121f, -0.27320418f, -0.02343231f, -0.08234966f, 0.12702803f, 0.14624257f, -0.05577247f, 
    0.08261877f, -0.03272160f, -0.04172866f, 0.02302931f, 0.02699989f, -0.09932189f, 0.18508510f, 0.12520479f, 
    0.00813789f, -0.00591062f, -0.23883080f, -0.08887500f, -0.08056857f, -0.04275514f, -0.05974117f, -0.02236417f, 
    0.01850178f, -0.20872357f, 0.13188118f, -0.11820327f, -0.20797490f, 0.07711525f, -0.11528943f, 0.19806647f, 
    0.02219942f, -0.07517062f, 0.22856195f, 0.05378506f, -0.02962421f, -0.02368389f, 0.08591834f, -0.06815244f, 
    0.09116906f, 0.01353275f, 0.05536260f, 0.40848088f, 0.19191672f, 0.22088772f, 0.10230321f, -0.06547050f, 
    -0.13227870f, -0.13808620f, 0.05959138f, 0.06096749f, -0.15224509f, -0.24086531f, -0.01267486f, -0.08603107f, 
    0.14862010f, -0.01829188f, -0.01046835f, 0.11883746f, -0.02790733f, -0.09507489f, -0.08469132f, 0.03839790f, 
    0.17743637f, 0.07983805f, -0.01177916f, -0.06740180f, 0.09353885f, -0.20744617f, -0.13551322f, 0.15638059f, 
    0.22616446f, -0.01121950f, 0.07877447f, -0.31769711f, -0.03987540f, 0.02645940f, -0.04531144f, 0.06939831f, 
    -0.20063847f, -0.03838022f, -0.05913486f, 0.00787305f, 0.12976487f, -0.14976975f, 0.01989094f, 0.00119818f, 
    0.28180200f, 0.12164740f, -0.00492639f, 0.07375252f, 0.10413302f, 0.17287369f, -0.13594879f, 0.03507919f, 
    0.03111283f, 0.48601705f, 0.27287737f, 0.01170988f, -0.06692102f, 0.01340367f, 0.11230329f, 0.18047528f, 
    0.09121325f, 0.08994301f, 0.17369084f, -0.13458198f, 0.00751034f, 0.06380849f, -0.09713896f, -0.06515378f, 
    -0.21504110f, -0.21005283f, 0.06127334f, 0.12894958f, 0.08640238f, 0.08406354f, -0.00387701f, -0.01094278f, 
    0.02478221f, 0.08051114f, -0.22237265f, 0.11440426f, -0.08635990f, 0.19743091f, -0.16363791f, -0.22462976f, 
    -0.12536493f, -0.01297074f, -0.00685592f, 0.07169232f, -0.34089610f, -0.14658870f, 0.02624939f, 0.21509519f, 
    -0.00421251f, 0.04146801f, -0.00312942f, -0.03270868f, 0.19294882f, 0.03170433f, 0.15669721f, 0.07827868f, 
    -0.13468802f, -0.09424511f, -0.14149600f, -0.18628748f, 0.07007203f, -0.09819563f, 0.02322066f, 0.41802183f, 
    0.08820470f, -0.21996458f, -0.01475052f, 0.12342896f, -0.02804507f, -0.00555086f, -0.16156821f, -0.01380884f, 
    0.29316309f, 0.06508121f, -0.36515942f, -0.09424765f, 0.22624274f, -0.00267383f, 0.02487184f, -0.17863603f, 
    -0.07643912f, 0.30291045f, 0.30396008f, 0.10503047f, 0.01178596f, 0.07570209f, 0.23840599f, -0.00356558f, 
    0.10408474f, 0.08772050f, -0.03620917f, 0.08194963f, -0.14979582f, 0.09056111f, -0.04670993f, -0.00515224f, 
    -0.03298252f, 0.14492890f, -0.23638505f, 0.21974558f, 0.30942771f, -0.31912002f, 0.18076597f, 0.05239527f, 
    -0.00841880f, -0.02364209f, -0.01743895f, -0.13124214f, 0.72450542f, -0.07982736f, -0.05696011f, 0.10499352f, 
    -0.26410303f, -0.02249448f, 0.09262701f, 0.08653019f, -0.03423617f, -0.00027969f, 0.04894865f, 0.01295210f, 
    -0.04464279f, 0.13860072f, 0.17349400f, 0.09724230f, 0.07007337f, -0.01434213f, -0.04536667f, 0.01408998f, 
    -0.07309728f, -0.00016990f, -0.00345992f, -0.17581013f, 0.00022464f, 0.15576878f, -0.17986432f, 0.02646403f, 
    0.02757260f, 0.04830918f, 0.05784614f, -0.05456690f, 0.00366394f, -0.13939427f, -0.00463070f, -0.17101388f, 
    -0.30007881f, -0.34314138f, 0.03903731f, -0.00270994f, -0.08052524f, 0.07809822f, -0.01433999f, 0.05387906f, 
    0.11372627f, -0.02582401f, 0.02575606f, 0.03095984f, -0.16056791f, -0.10507134f, -0.11971821f, 0.08344064f, 
    0.23021440f, -0.18165630f, -0.07519366f, 0.17058453f, 0.00003826f, 0.02021777f, -0.06243025f, -0.01910400f, 
    0.07265208f, -0.02713871f, -0.25082827f, -0.00314592f, -0.27514678f, 0.08154091f, -0.12371695f, 0.06604794f, 
    0.00451573f, 0.05059026f, 0.16887265f, -0.00390331f, 0.44630736f, -0.14158881f, -0.25520575f, -0.07232568f, 
    -0.12716627f, 0.11531511f, -0.01794350f, -0.07890884f, 0.10454009f, 0.04259780f, 0.09114850f, 0.31822166f, 
    0.04133365f, 0.18867493f, -0.12819821f, -0.12343516f, 0.06688108f, 0.13402140f, -0.04902897f, 0.14695108f, 
    0.13781789f, -0.15447919f, 0.05559966f, 0.02092368f, 0.33249831f, 0.07487780f, 0.08488732f, -0.12022883f, 
    -0.36263198f, -0.14283560f, -0.13551652f, 0.08410715f, 0.11720925f, 0.10151779f, 0.01995699f, 0.25083986f, 
    0.05949296f, -0.03797268f, -0.19641288f, 0.04478081f, -0.12045960f, -0.09460128f, 0.23409106f, 0.24878119f, 
    0.18561062f, 0.21815437f, -0.16696699f, 0.22925279f, -0.00092054f, 0.25715232f, -0.00521555f, -0.07888757f, 
    0.20053269f, -0.20968281f, 0.02770606f, 0.19041181f, 0.07275190f, -0.08731579f, -0.08062144f, 0.01368530f, 
    0.02900457f, -0.03729993f, 0.09631651f, 0.11178321f, 0.05575376f, -0.35384414f, -0.09758700f, -0.05049816f, 
    0.04795319f, 0.00249032f, -0.11669574f, -0.07607174f, -0.08313344f, 0.17157446f, -0.00185622f, -0.07675338f, 
    0.06543174f, -0.10518151f, 0.45092243f, 0.01678771f, 0.04566438f, 0.10936488f, 0.13568199f, -0.11314310f, 
    -0.08292412f, -0.02153110f, -0.16611294f, -0.15003602f, -0.02587795f, -0.04751746f, -0.25521749f, 0.21161012f, 
    -0.29605260f, 0.13937728f, 0.11314812f, -0.03361493f, -0.17767823f, 0.01914580f, -0.07154734f, 0.36803383f, 
    0.01025405f, -0.05353021f, -0.10376058f, -0.17794184f, 0.16881219f, 0.00712804f, -0.00221845f, -0.04142847f, 
    -0.29720992f, -0.14994299f, -0.21504356f, -0.24480532f, 0.09371950f, 0.02656510f, 0.22689979f, -0.02217859f, 
    -0.18840504f, 0.37431315f, 0.05504728f, 0.15083276f, -0.33963698f, -0.22176631f, 0.27341452f, 0.04662463f, 
    0.00532716f, -0.02262073f, 0.32390305f, 0.08069066f, -0.23249233f, -0.21136656f, -0.04434258f, 0.14214818f, 
    -0.11514898f, 0.05733525f, 0.00499000f, 0.14166874f, 0.11660428f, -0.42209646f, -0.28760836f, 0.12861568f, 
    0.23438396f, -0.16423647f, -0.10684953f, -0.03643022f, -0.32331535f, -0.04325505f, -0.25674137f, 0.17811018f, 
    -0.01356873f, 0.23851453f, 0.09301525f, -0.03202377f, -0.15417525f, 0.11720882f, 0.37857220f, 0.20979825f, 
    -0.01396683f, -0.06332726f, -0.19201046f, 0.01593130f, 0.10955313f, 0.08498041f, 0.21749572f, 0.10719730f, 
    -0.01154264f, -0.02967338f, 0.12801306f, -0.00933747f, -0.03220384f, 0.06081627f, 0.03040567f, 0.06462880f, 
    -0.19820258f, 0.02362843f, 0.20287651f, 0.25180179f, 0.08851036f, 0.03400003f, 0.04464399f, -0.32136345f, 
    -0.12282506f, -0.16546653f, 0.22329542f, -0.12570843f, 0.02991453f, 0.15408601f, -0.03083635f, -0.04928720f, 
    -0.02363511f, 0.08008963f, -0.00860927f, 0.14364222f, -0.08669694f, 0.03912500f, -0.09074132f, -0.04909279f, 
    0.14159846f, 0.06670929f, 0.13156012f, 0.09310771f, -0.05754248f, 0.24202085f, -0.01483205f, -0.01529976f, 
    -0.05883857f, -0.04763854f, -0.05238955f, -0.10528484f, -0.02727355f, 0.42716795f, -0.07208331f, -0.06259892f, 
    0.08696272f, -0.04044965f, 0.02038527f, 0.00490441f, -0.12823503f, -0.20397766f, 0.08793996f, 0.11459056f, 
    -0.06930116f, 0.17631157f, 0.06053220f, 0.08062016f, 0.14637920f, -0.05526111f, 0.00897786f, -0.02982147f, 
    0.03580033f, -0.02308323f, 0.06036718f, -0.19617571f, -0.01131579f, 0.00445607f, 0.14614749f, 0.05842291f, 
    -0.33221748f, 0.16279261f, 0.24944900f, 0.07236044f, 0.12938695f, 0.03676591f, -0.06627887f, -0.03283352f, 
    -0.00197830f, -0.16920646f, 0.05497039f, 0.08851749f, 0.14236347f, 0.01763970f, -0.18713142f, -0.12552799f, 
    -0.06932750f, -0.10481898f, 0.05675958f, 0.08669780f, -0.05952419f, 0.08986688f, -0.08000893f, 0.15708731f, 
    0.01882439f, 0.19132510f, 0.09054891f, -0.21311706f, 0.02916483f, -0.05363064f, -0.09652197f, -0.06457015f, 
    -0.03644739f, -0.21371675f, 0.11826935f, 0.17818619f, -0.07412765f, 0.06571712f, 0.05107144f, -0.04095570f, 
    0.10866094f, -0.02364380f, -0.00888853f, -0.29357484f, 0.09577117f, -0.07136055f, 0.04931328f, 0.16391924f, 
    0.06208166f, -0.08923761f, -0.02396722f, -0.12106156f, -0.10852151f, -0.01076217f, 0.20571047f, -0.04640543f, 
    0.17872262f, 0.02188087f, 0.07217598f, -0.06358234f, -0.04334950f, 0.06042344f, -0.05805059f, 0.08281887f, 
    0.06079543f, 0.00463141f, -0.06465688f, 0.05874728f, -0.06785687f, -0.06359794f, 0.03300402f, -0.05570181f, 
    -0.16261257f, 0.05338825f, 0.05823328f, 0.12477055f, -0.22792524f, -0.18369257f, -0.20850328f, 0.37632051f, 
    -0.13521154f, 0.47329032f, -0.03074005f, 0.04842346f, -0.11523727f, -0.02848453f, 0.10907716f, 0.07180195f, 
    -0.00086113f, 0.11119825f, -0.01233891f, 0.03418294f, -0.02564240f, -0.21482573f, -0.01209590f, 0.03799335f, 
    0.12390009f, 0.14858256f, 0.03938885f, -0.01245026f, -0.01579167f, -0.05016207f, -0.18315494f, -0.08338995f, 
    0.14436145f, -0.07504843f, 0.04555143f, -0.09638231f, 0.00350200f, 0.05618935f, -0.13025884f, 0.00267491f, 
    0.14787374f, 0.07210087f, -0.04514668f, 0.02193975f, -0.12882990f, 0.23627903f, -0.10469730f, -0.07533110f, 
    0.15298784f, 0.01090822f, -0.20603584f, 0.04806247f, 0.07286794f, 0.13352035f, -0.12032177f, 0.13227591f, 
    0.04118065f, 0.08866287f, -0.20045878f, 0.03761110f, 0.08052687f, -0.04383960f, 0.05288718f, -0.27272248f, 
    0.14875036f, -0.04216538f, -0.03598992f, -0.02917078f, 0.00768387f, -0.08697436f, -0.14932078f, -0.16392499f, 
    0.07323952f, 0.15269360f, -0.05711860f, 0.01430071f, -0.00257811f, 0.06411026f, 0.02976164f, 0.05167148f, 
    0.06385054f, -0.10039557f, -0.05307780f, -0.33771357f, 0.08041936f, 0.12179166f, -0.17813489f, 0.16440445f, 
    0.31945348f, 0.03785696f, 0.05353811f, -0.21746065f, -0.13774602f, 0.18360947f, -0.02582895f, -0.11148936f, 
    -0.01580140f, -0.01989524f, 0.14066228f, -0.16949704f, 0.05184235f, -0.09665173f, 0.22239915f, -0.00612036f, 
    -0.16043927f, -0.10025186f, 0.01905671f, 0.20250896f, -0.10575975f, -0.14244694f, -0.00361867f, -0.18033792f, 
    -0.15158518f, 0.10706836f, 0.03874064f, -0.09927344f, 0.09610885f, 0.28186002f, -0.11345933f, 0.14742687f, 
    0.18630075f, -0.00914384f, -0.19767362f, -0.19355048f, 0.05636175f, 0.06971044f, -0.00914790f, -0.22687303f, 
    -0.06273111f, 0.17365886f, 0.25919715f, -0.11688356f, 0.02401245f, 0.07301784f, 0.16234592f, -0.07967481f, 
    0.02812360f, 0.11268698f, -0.08613769f, -0.06974290f, 0.01703222f, -0.22668456f, -0.17873073f, 0.23665938f, 
    0.09976249f, 0.00274007f, 0.02282429f, -0.05325152f, -0.15080827f, -0.05696108f, -0.01181811f, 0.18060714f, 
    0.03031775f, -0.05123338f, -0.04554293f, 0.02093104f, 0.01566133f, -0.02845087f, -0.01833784f, 0.04181614f, 
    -0.08343524f, -0.09337760f, -0.00825144f, -0.17296539f, -0.01573949f, 0.14002548f, -0.10743653f, -0.03190396f, 
    -0.07957133f, -0.22703330f, -0.09760857f, -0.01887036f, 0.14202347f, -0.03839476f, 0.01959738f, -0.14177489f, 
    -0.03413763f, -0.17553952f, 0.05106171f, 0.09299511f, -0.44752446f, 0.26044923f, 0.01781214f, -0.02309287f, 
    0.13074882f, 0.00821932f, -0.01753388f, -0.04781644f, -0.07706780f, -0.14525193f, -0.06805765f, -0.11303537f, 
    0.02337409f, -0.07236781f, -0.06063763f, -0.10723578f, -0.18945049f, -0.11895842f, 0.05222365f, -0.01804109f, 
    0.09197234f, 0.16872561f, -0.07378650f, 0.12951702f, -0.05291681f, -0.03726184f, -0.01086200f, 0.22386977f, 
    -0.02492609f, 0.00339609f, -0.12569261f, -0.03403738f, 0.06109774f, 0.11293960f, 0.10505324f, 0.31235760f, 
    0.09950431f, 0.27299729f, -0.05165711f, -0.01490288f, 0.00367283f, -0.01768776f, 0.09778343f, 0.23483302f, 
    0.23629740f, 0.02369850f, 0.24449022f, 0.02746806f, -0.10719534f, -0.09613781f, 0.20119879f, 0.09189328f, 
    -0.04055057f, 0.09483573f, 0.02330472f, 0.03732512f, 0.02989668f, 0.21546267f, 0.01734621f, -0.04559807f, 
    0.07536940f, 0.12777244f, 0.08067644f, -0.04972844f, 0.15123509f, -0.01561156f, 0.12168133f, -0.13135964f, 
    0.03742797f, -0.11068664f, 0.14214617f, 0.07865725f, 0.01869187f, 0.12156458f, 0.03774391f, -0.10207220f, 
    0.04307603f, 0.10970662f, 0.14901818f, -0.14216040f, 0.19236317f, -0.06417535f, 0.16341670f, 0.07287478f, 
    -0.09402505f, -0.01636868f, -0.10742068f, 0.00476169f, 0.02076030f, 0.08842609f, -0.08627461f, 0.15717086f, 
    0.09050024f, -0.00664772f, 0.00850967f, 0.24802384f, -0.15352198f, 0.13123281f, 0.09891231f, -0.18237633f, 
    0.14373322f, 0.15965469f, 0.18105341f, -0.00112059f, -0.09412794f, -0.31112456f, 0.11347367f, 0.17342767f, 
    0.18459187f, 0.16453278f, -0.07639655f, -0.16295932f, -0.10935617f, 0.13400318f, 0.04682491f, 0.08653852f, 
    0.00156083f, -0.07236490f, 0.08683082f, 0.06936619f, -0.07647182f, 0.03910301f, 0.05081233f, -0.12579153f, 
    -0.08536831f, 0.14561072f, -0.12298460f, -0.00282560f, -0.06169531f, 0.17817278f, 0.09947836f, 0.04639889f, 
    -0.04903561f, 0.08391465f, 0.05620006f, 0.04102991f, 0.34269759f, -0.14513682f, 0.31326547f, 0.11391021f, 
    0.00276535f, 0.00687832f, -0.00528090f, -0.24136825f, 0.00169194f, -0.12433136f, -0.17457399f, -0.04549521f, 
    -0.07116102f, -0.01634914f, 0.14126624f, -0.25153509f, 0.18875206f, -0.14669614f, -0.02923650f, 0.11696564f, 
    0.12926197f, -0.16190454f, 0.15385325f, 0.02340790f, -0.16491114f, -0.12872550f, -0.16847898f, 0.06521476f, 
    0.14375050f, 0.27595061f, -0.02880548f, -0.05325453f, -0.23343073f, 0.51357752f, 0.25614312f, 0.05353362f, 
    0.27498412f, -0.09760020f, 0.00813658f, 0.03030434f, 0.02496661f, 0.19671638f, 0.08563536f, 0.09868844f, 
    0.14385261f, -0.04964209f, -0.04617432f, 0.09201304f, 0.12197796f, 0.16556211f, 0.18657315f, 0.02061531f, 
    -0.23315431f, -0.04730260f, 0.00568234f, -0.11622819f, -0.03149065f, 0.06036179f, 0.06590700f, 0.05695359f, 
    0.07920017f, 0.04238992f, 0.01801448f, 0.07230344f, -0.03299006f, -0.17303176f, -0.07523007f, -0.07437899f, 
    0.12846594f, -0.06329985f, -0.16428864f, -0.00056069f, 0.01373464f, -0.19504100f, -0.21009043f, 0.01225647f, 
    -0.09967602f, 0.06032442f, -0.41858530f, -0.31524080f, -0.13919035f, 0.03483137f, 0.05045967f, 0.12214882f, 
    0.06972588f, -0.07594527f, 0.32924676f, -0.17746565f, 0.05003194f, -0.16063212f, -0.17556871f, 0.05282700f, 
    -0.26364875f, 0.17726798f, -0.05583845f, -0.27317232f, 0.14845385f, -0.10726054f, -0.04803510f, -0.00953072f, 
    0.12459803f, -0.08089723f, 0.14812408f, 0.07631247f, 0.17512701f, 0.02986182f, 0.01192665f, -0.24449441f, 
    0.28374410f, 0.08614508f, 0.21579157f, 0.12034545f, 0.11100867f, -0.00639738f, 0.02386703f, 0.04147442f, 
    -0.18598197f, 0.06570490f, -0.08866376f, -0.06767381f, 0.17379054f, -0.13937454f, 0.23411384f, -0.06797648f, 
    0.11770491f, -0.18741243f, 0.22439913f, 0.09222227f, 0.14522730f, 0.13446422f, -0.00259630f, -0.06704054f, 
    0.32050836f, 0.26296321f, 0.11228140f, 0.06187832f, 0.08842749f, -0.03801720f, 0.22511607f, 0.02266649f, 
    0.06417341f, -0.05643439f, 0.13382582f, -0.15760413f, 0.20276067f, -0.06766628f, 0.09969278f, 0.09302764f, 
    0.03700368f, -0.12988506f, -0.18310513f, -0.08141306f, -0.23082097f, -0.05907629f, -0.10550752f, -0.01156111f, 
    -0.22546752f, -0.21053882f, 0.23114936f, 0.24968293f, 0.07327007f, -0.10618357f, 0.07478264f, 0.16021775f, 
    -0.03957052f, 0.05391168f, -0.02745050f, -0.12037779f, 0.22950542f, 0.23284559f, -0.13138182f, -0.03554378f, 
    -0.12350810f, 0.10606661f, 0.07824835f, -0.18125924f, 0.18857752f, 0.02835665f, -0.00058717f, 0.19124053f, 
    -0.15258959f, 0.13991852f, -0.04362245f, 0.08575787f, -0.10593029f, -0.09778899f, -0.25538117f, -0.24136761f, 
    -0.04078446f, -0.10051800f, -0.07055332f, 0.16470024f, 0.07188173f, -0.09871569f, -0.00980394f, 0.15192609f, 
    0.11680172f, 0.24096708f, -0.01981801f, -0.18324299f, -0.11780380f, -0.06997887f, 0.07028998f, 0.06815412f, 
    -0.07150609f, 0.07172457f, -0.09161144f, 0.04253682f, 0.04737525f, -0.08509081f, -0.07402898f, -0.00186802f, 
    -0.08368000f, -0.11607796f, -0.02427449f, 0.09980489f, -0.17873840f, 0.08421033f, 0.21149567f, -0.15127738f, 
    0.06466095f, 0.16764493f, 0.12716228f, -0.09999654f, 0.04611536f, -0.13731185f, -0.11583073f, 0.12283422f, 
    0.04594986f, 0.04356859f, -0.00851737f, -0.05659718f, -0.09412467f, -0.16346435f, -0.04140056f, -0.20103103f, 
    0.10517014f, 0.12697130f, -0.13631478f, 0.11669946f, -0.09425989f, 0.15580413f, -0.07068069f, 0.08196241f, 
    0.00833270f, 0.06891824f, 0.02652322f, 0.01904210f, -0.07381082f, -0.06702767f, -0.04581174f, -0.21080075f, 
    -0.16512713f, 0.07131381f, 0.00751092f, -0.04512523f, -0.00477888f, 0.14150375f, 0.13974641f, 0.26173952f, 
    0.02587212f, -0.15660621f, 0.04555145f, -0.00665769f, 0.01703618f, 0.14417060f, -0.03278142f, 0.19544443f, 
    0.17627510f, -0.18999003f, 0.12697361f, 0.03215029f, 0.04361249f, 0.07324352f, 0.11738972f, 0.01438059f, 
    -0.69021630f, -0.33635622f, -0.01800243f, -0.12467714f, 0.01022489f, 0.18049017f, 0.00647886f, -0.02105019f, 
    0.12047230f, -0.21053508f, -0.21473959f, 0.22773276f, -0.01521980f, 0.00480585f, 0.12023897f, -0.05855342f, 
    0.04217184f, -0.00575099f, -0.04926231f, 0.26644057f, 0.18918021f, -0.01873948f, 0.01904109f, 0.05540876f, 
    0.08963914f, 0.04975405f, -0.00597537f, 0.20958003f, 0.38589165f, 0.12620793f, -0.13220930f, 0.15472616f, 
    -0.01467534f, 0.16927414f, 0.03550411f, 0.07406873f, 0.05074099f, -0.03295322f, -0.20088282f, 0.01878054f, 
    0.22279611f, -0.19571818f, -0.08772290f, -0.08516519f, 0.00999570f, 0.24786939f, 0.09759539f, 0.12979254f, 
    -0.12702176f, -0.19882673f, 0.05073021f, -0.02092393f, 0.14569412f, 0.02540837f, 0.12713945f, 0.30804640f, 
    0.10693739f, 0.17748390f, -0.02766830f, 0.05194807f, 0.08777598f, -0.03802582f, -0.15926586f, -0.39205083f, 
    -0.20019124f, 0.25287828f, -0.20238605f, -0.10404810f, -0.19119178f, 0.21907373f, 0.04665710f, 0.11619808f, 
    -0.20841029f, -0.49084523f, 0.11807010f, 0.17793594f, 0.26204318f, -0.00923808f, 0.00278805f, -0.05666184f, 
    -0.07064547f, 0.02952107f, 0.24286637f, 0.25765312f, -0.18293066f, 0.18151948f, -0.12240013f, -0.04229574f, 
    0.12863420f, -0.10855202f, -0.11801149f, 0.01201261f, -0.13453989f, -0.02312370f, -0.00835702f, 0.02058945f, 
    -0.24260195f, -0.04191628f, 0.01272190f, 0.00410870f, -0.11728468f, -0.01527883f, 0.13787085f, -0.10156409f, 
    0.19030252f, 0.26343313f, 0.10147022f, -0.02862584f, -0.35809824f, 0.13756834f, -0.27363473f, 0.01393396f, 
    0.02943604f, -0.15496905f, -0.17835890f, 0.05582850f, -0.07223158f, 0.18335837f, -0.00847675f, 0.00176139f, 
    -0.16155271f, -0.18443395f, 0.01571054f, 0.22436027f, -0.03937165f, -0.09656063f, 0.01927465f, -0.11119844f, 
    -0.19094566f, -0.10113733f, -0.02984452f, -0.26045161f, -0.12701876f, 0.02699997f, 0.06972411f, -0.11180052f, 
    -0.01794033f, 0.05964354f, 0.01745002f, 0.12928092f, 0.08780880f, -0.10668071f, -0.09448257f, -0.07012326f, 
    -0.32555988f, -0.06694082f, -0.39381936f, 0.07896316f, 0.09968682f, -0.01977544f, 0.07765709f, -0.02617381f, 
    -0.10930420f, 0.20735994f, -0.21274295f, -0.25373614f, 0.05002371f, 0.14590324f, 0.00223710f, -0.02298870f, 
    -0.04392064f, -0.00371546f, 0.42584741f, -0.07622198f, 0.07970353f, -0.07717821f, -0.26191199f, -0.10378965f, 
    0.12418259f, -0.15744336f, 0.18756157f, 0.00071825f, -0.18682061f, -0.24520105f, 0.18741328f, 0.14045447f, 
    0.17366660f, -0.07586373f, -0.10580470f, -0.14696150f, -0.15264612f, -0.28714517f, 0.01519199f, -0.12768529f, 
    -0.03675048f, -0.13370518f, 0.01196966f, 0.03386738f, -0.03258204f, 0.06832160f, -0.08039396f, 0.23181009f, 
    0.06097601f, 0.08185275f, 0.05139439f, 0.03507689f, -0.08551054f, 0.01594049f, 0.13746920f, 0.23565277f, 
    -0.08739983f, -0.04698590f, 0.04992443f, 0.00464124f, -0.13255429f, 0.12182876f, 0.05221229f, 0.32435274f, 
    0.24632911f, 0.23571125f, 0.15625291f, 0.04070982f, 0.23849708f, 0.06972791f, 0.07373928f, -0.10775813f, 
    0.19707298f, -0.02803138f, -0.35102242f, 0.15336321f, 0.07765289f, -0.06812368f, 0.08308462f, 0.12201911f, 
    -0.07832399f, 0.17330274f, 0.21792193f, -0.03258747f, 0.07666624f, 0.08687779f, -0.02454122f, 0.12438167f, 
    0.04393109f, 0.18485561f, 0.21202947f, 0.31726345f, 0.08690027f, -0.08896466f, 0.11223068f, 0.16361068f, 
    0.00916496f, 0.14831011f, 0.09536334f, -0.09388317f, 0.11723082f, 0.27304766f, -0.13704087f, -0.10086486f, 
    0.09335520f, -0.01126935f, 0.02255036f, -0.03826489f, 0.31305954f, 0.03216879f, -0.41105896f, -0.13638406f, 
    0.10259674f, 0.05443737f, 0.28203481f, 0.05631128f, 0.02332359f, -0.01413858f, 0.05089017f, -0.06767040f, 
    -0.17909665f, 0.14725310f, -0.02811057f, -0.03262538f, 0.03023648f, 0.15549737f, 0.23634414f, 0.25833994f, 
    0.14256118f, 0.17150769f, 0.11257593f, -0.13711447f, 0.06658477f, -0.07864792f, -0.06932683f, 0.06963182f, 
    0.22685412f, -0.08039881f, -0.14901707f, -0.01915228f, -0.12819527f, -0.12254751f, 0.14196262f, 0.01323507f, 
    -0.04890167f, 0.26640522f, -0.13086887f, 0.15092778f, 0.14772806f, 0.04924692f, -0.17090069f, -0.03742445f, 
    0.10502522f, 0.05829412f, 0.05585542f, -0.25538400f, 0.00968331f, 0.04799977f, 0.06923412f, 0.02576949f, 
    0.03853026f, -0.02762423f, -0.06402106f, -0.22931919f, -0.22250858f, -0.01213306f, 0.03355934f, 0.03501116f, 
    0.01375982f, -0.01227078f, -0.00952140f, -0.42517751f, 0.04221009f, -0.33644187f, 0.09424099f, 0.09795840f, 
    -0.09956378f, -0.07136995f, -0.00712684f, -0.13624302f, 0.12369434f, 0.03561251f, -0.14967212f, -0.18150210f, 
    -0.05334667f, -0.21258962f, 0.01972312f, 0.07751242f, 0.20475242f, 0.30473632f, 0.32532236f, 0.08846290f, 
    0.04256808f, 0.11372077f, 0.09664267f, 0.01696090f, 0.01339763f, -0.10096858f, -0.25730553f, -0.10442004f, 
    -0.41217184f, 0.05648405f, 0.15244541f, 0.15550491f, -0.09476790f, 0.01257805f, 0.14899221f, -0.33667335f, 
    -0.08267008f, 0.12344614f, 0.04631735f, 0.13526691f, 0.00784115f, -0.03330960f, 0.05301007f, 0.00824796f, 
    -0.00534973f, -0.33951899f, -0.13335459f, -0.05073418f, 0.10390400f, -0.13967973f, 0.04870938f, 0.00262812f, 
    -0.10780317f, -0.10675322f, -0.07286706f, 0.11656076f, 0.24667273f, 0.04965930f, -0.00992221f, 0.05425908f, 
    -0.04268388f, -0.04606631f, -0.28744379f, -0.27530968f, -0.11702412f, -0.13384619f, -0.16542907f, -0.23963119f, 
    -0.05806459f, 0.06083179f, -0.02585964f, -0.00578237f, 0.09509251f, -0.00925373f, 0.06863251f, 0.19731221f, 
    0.08376417f, -0.05568081f, -0.14384322f, -0.21830481f, 0.04359374f, 0.05607371f, -0.00990916f, 0.05598499f, 
    -0.09583758f, 0.13679989f, 0.10319763f, 0.05313472f, -0.12517792f, 0.19683447f, 0.12073899f, 0.09540194f, 
    0.07381913f, -0.06592174f, -0.05683059f, -0.16797267f, 0.15490128f, 0.17398024f, -0.01462685f, -0.10733620f, 
    0.18724315f, 0.10036074f, -0.08494180f, 0.10247897f, 0.08901163f, -0.03781490f, -0.00339363f, -0.14899744f, 
    0.04400760f, -0.18500619f, 0.03728357f, -0.17438956f, 0.07626865f, -0.09435763f, -0.03115596f, 0.11736045f, 
    0.23915845f, 0.00952170f, 0.19758037f, 0.15804595f, 0.02443466f, 0.05476379f, -0.01839655f, -0.01625985f, 
    0.27913728f, 0.18784706f, -0.00813238f, 0.01659951f, 0.00994199f, -0.01012916f, -0.01653433f, -0.12031695f, 
    0.09872654f, 0.00483020f, -0.28827998f, 0.03793650f, -0.03397585f, 0.09328739f, -0.15370230f, -0.05141541f, 
    -0.01822385f, 0.12228736f, 0.01182513f, 0.16819619f, 0.16617277f, 0.00701731f, 0.01345189f, -0.05508134f, 
    0.17440017f, 0.16273901f, -0.00087974f, -0.04699920f, -0.04585729f, -0.13074008f, 0.00042948f, 0.07793368f, 
    -0.10559437f, 0.36100939f, -0.02675115f, 0.10436225f, 0.05260529f, -0.04849897f, 0.09102484f, -0.18439397f, 
    0.00653917f, 0.11438327f, -0.09743398f, 0.25217742f, 0.15037398f, -0.10607553f, -0.00962237f, 0.11431973f, 
    -0.08706035f, 0.05767040f, 0.08654886f, -0.18698257f, -0.00860858f, -0.01992731f, 0.00242136f, -0.15299360f, 
    0.12458801f, -0.20292850f, 0.03732008f, 0.08185913f, 0.04609501f, 0.11789516f, 0.07760718f, -0.00306148f, 
    0.04364239f, -0.09304333f, 0.14310138f, 0.01396540f, 0.02064920f, 0.21943031f, -0.14541517f, -0.00606569f, 
    -0.15151638f, -0.36977181f, 0.23132384f, -0.57509750f, -0.07829520f, 0.02836111f, -0.07018200f, -0.05718679f, 
    -0.04944701f, -0.09459946f, -0.01512510f, 0.10324672f, -0.38107041f, 0.06559681f, -0.01632363f, -0.21454872f, 
    -0.14336495f, -0.03621103f, 0.11144860f, -0.40972301f, -0.00472030f, -0.12912442f, -0.27121025f, 0.07307705f, 
    0.04449923f, 0.06678199f, 0.07784960f, -0.09630342f, -0.06096217f, 0.08618870f, 0.09871186f, 0.09973137f, 
    0.05741744f, -0.04845372f, 0.04267299f, -0.07252056f, -0.14858767f, 0.09830792f, 0.10588918f, -0.02003825f, 
    -0.26577905f, 0.06155831f, -0.12233818f, -0.04343846f, 0.01553995f, 0.07634847f, 0.04794613f, 0.04908056f, 
    -0.17228030f, 0.11330504f, 0.19975390f, -0.00631459f, -0.03221437f, -0.10236623f, -0.30782849f, 0.57191777f, 
    0.42838874f, 0.23000643f, -0.20373014f, -0.10427230f, -0.23821807f, 0.07923005f, 0.01799187f, 0.04880036f, 
    0.20546092f, -0.06246467f, -0.23194526f, -0.24624644f, -0.36917779f, -0.00240155f, 0.03804641f, 0.24794780f, 
    0.05914130f, -0.00692031f, 0.05766033f, -0.18694697f, -0.14716552f, -0.11516270f, -0.11647552f, 0.14577956f, 
    0.05051969f, 0.13316731f, 0.22315605f, 0.35652575f, 0.06148701f, 0.14986649f, 0.11282252f, -0.05007670f, 
    0.14350745f, 0.01817205f, -0.20940679f, 0.11955916f, 0.03928548f, 0.20125616f, 0.34367248f, 0.05768653f, 
    -0.14326021f, -0.04099096f, -0.09092300f, 0.15976351f, -0.26610157f, -0.01233535f, 0.09888261f, 0.24446411f, 
    -0.05010523f, -0.09443074f, -0.06823756f, -0.10529977f, -0.17928362f, -0.05827100f, -0.06002262f, -0.30069676f, 
    -0.03059920f, 0.00444394f, -0.11580253f, -0.12406824f, 0.03498770f, 0.15273841f, -0.03589574f, 0.25058874f, 
    -0.10256387f, 0.08428064f, -0.08271212f, -0.03798361f, 0.03934427f, -0.02019724f, -0.10884515f, -0.44144642f, 
    0.22851324f, -0.29762372f, 0.18608795f, -0.02121665f, 0.03872502f, 0.12366439f, 0.20696540f, 0.07391774f, 
    -0.29206732f, 0.12782662f, -0.07574753f, 0.09656982f, 0.15915617f, -0.04950475f, 0.21936277f, 0.27788308f, 
    0.21529575f, -0.10316974f, 0.09179755f, -0.23092957f, 0.06865162f, 0.12768798f, -0.01155605f, -0.06105436f, 
    -0.00960542f, -0.18673167f, -0.11943206f, -0.21845217f, 0.30752102f, -0.11109551f, -0.09561679f, -0.27484092f, 
    0.11872389f, 0.09617859f, 0.24655543f, 0.56105989f, 0.08075225f, 0.12468309f, 0.02331332f, -0.00325741f, 
    0.01361258f, -0.07365306f, -0.08502150f, 0.03004417f, -0.18148865f, -0.17884476f, -0.06451336f, -0.18288092f, 
    -0.02441888f, 0.14173277f, 0.19666138f, 0.08655480f, 0.05392817f, -0.12206303f, 0.23918048f, -0.16091041f, 
    -0.18535779f, 0.11570659f, 0.00327383f, 0.05949938f, -0.19970594f, -0.33111116f, -0.66728860f, 0.29835480f, 
    0.31064934f, 0.13658221f, -0.13761041f, 0.04567434f, 0.17484224f, -0.06835699f, 0.02510540f, 0.09380121f, 
    0.10142139f, -0.07181627f, -0.15062591f, -0.07551187f, 0.02166451f, -0.09885108f, 0.01534968f, -0.06217707f, 
    0.04040516f, -0.06427304f, 0.01008712f, -0.02484209f, 0.03612951f, 0.05569931f, -0.00672194f, -0.04977570f, 
    0.03456540f, -0.01362861f, -0.04473798f, -0.05059746f, -0.01152917f, 0.02267241f, -0.01020543f, 0.02401549f, 
    -0.04573236f, -0.03378375f, -0.01818781f, 0.02267485f, 0.04421255f, 0.00689471f, -0.00867479f, -0.03447541f, 
    -0.06437082f, -0.04028537f, 0.05041678f, -0.01331923f, -0.03644962f, 0.05234013f, -0.02898836f, 0.01203335f, 
    -0.01004337f, 0.04639909f, -0.01659995f, 0.00888253f, -0.00312385f, -0.06304597f, -0.05635030f, 0.04289301f, 
    -0.02668721f, -0.03611842f, -0.03379415f, 0.04598528f, -0.02850787f, -0.05495135f, -0.05001197f, 0.04179303f, 
    0.00602893f, 0.01254944f, -0.05386303f, -0.06008657f, -0.02793525f, -0.02938261f, -0.00835550f, -0.05613877f, 
    0.00791295f, -0.03951285f, -0.02646751f, -0.00262896f, -0.02619035f, -0.05162753f, 0.04196504f, -0.02580700f, 
    -0.00838018f, -0.01821589f, -0.04166738f, 0.04146519f, -0.02679601f, 0.03340983f, 0.01957172f, 0.02692089f, 
    -0.00833877f, 0.03090479f, -0.04198984f, -0.05605651f, -0.06029326f, 0.01109079f, -0.04965530f, 0.05137293f, 
    -0.03242625f, -0.00295104f, -0.05740626f, 0.04948159f, -0.04961473f, 0.04158979f, 0.04914453f, -0.05834843f, 
    -0.00251305f, 0.01188238f, -0.01372628f, -0.01066395f, 0.04602384f, 0.04902161f, 0.02188470f, 0.03535029f, 
    -0.04119515f, -0.01990848f, 0.05087966f, -0.04235642f, -0.04276909f, -0.03454261f, -0.00723526f, 0.01034218f, 
    -0.06254497f, -0.05197798f, 0.02913047f, 0.03235970f, 0.01365581f, 0.01441685f, 0.01582197f, -0.05844261f, 
    -0.00443854f, -0.05439111f, -0.04460099f, 0.01084410f, -0.06853051f, 0.02048566f, -0.03211331f, 0.01445056f, 
    -0.03502009f, -0.03181944f, 0.01481834f, 0.03541220f, -0.00846615f, -0.00639947f, 0.03762590f, 0.00714772f, 
    0.04293879f, -0.01098230f, -0.02221274f, -0.05987939f, 0.01541839f, 0.02381728f, 0.02627554f, -0.05792938f, 
    -0.00875519f, 0.05405388f, -0.01909602f, 0.01624680f, 0.04607996f, -0.05279590f, 0.00997630f, -0.05665283f, 
    0.01645723f, 0.03627567f, 0.00557110f, 0.00156481f, 0.04855031f, -0.02932006f, 0.00840201f, -0.05441082f, 
    -0.02775119f, -0.05693318f, 0.00890433f, -0.03138376f, -0.02928778f, 0.01778805f, 0.01163532f, -0.04433506f, 
    -0.01831693f, -0.03987505f, -0.00444039f, 0.00170171f, -0.02777875f, 0.04177375f, -0.06065350f, -0.04255603f, 
    0.04844012f, -0.01577611f, 0.01623521f, -0.03648373f, 0.00584128f, 0.02259292f, 0.02763899f, 0.01800670f, 
    -0.05310731f, 0.03536805f, 0.01257548f, -0.02649382f, -0.03092808f, -0.05898988f, -0.02405523f, -0.01676486f, 
    0.04204027f, 0.00754696f, -0.01850611f, -0.05477749f, 0.00971200f, -0.05801113f, 0.00551031f, 0.03427878f, 
    -0.06132283f, -0.02709316f, 0.03798527f, -0.01450354f, 0.03356702f, -0.06341681f, 0.00249398f, -0.02258514f, 
    -0.03556667f, -0.05929701f, -0.04065650f, -0.03453205f, -0.00613203f, -0.05933013f, -0.02476628f, -0.04902678f, 
    -0.03142146f, -0.01529549f, -0.00179302f, -0.01965966f, 0.02459108f, -0.00345440f, -0.04955656f, -0.04947369f, 
    -0.00872146f, -0.06087853f, -0.00306917f, -0.02800862f, 0.05504252f, -0.04009354f, -0.05568880f, -0.00854236f, 
    0.00621140f, 0.02631447f, -0.03764163f, 0.04789485f, -0.02413044f, 0.01476366f, -0.04464870f, -0.04154828f, 
    -0.03183487f, -0.03977972f, -0.03525665f, 0.02624297f, 0.01760135f, -0.02082431f, -0.00578977f, -0.04945889f, 
    0.00043909f, -0.02332474f, -0.04295446f, -0.01174071f, 0.02090274f, 0.01863105f, 0.01091265f, -0.00785075f, 
    -0.03330594f, 0.04679783f, 0.00845184f, 0.04916603f, 0.04782603f, -0.01311812f, -0.00504113f, -0.03868845f, 
    0.03745436f, 0.04778546f, 0.01840378f, -0.04348031f, -0.01403402f, 0.02349848f, 0.01136740f, 0.00743632f, 
    -0.05402348f, -0.01096519f, -0.04364953f, 0.03825775f, 0.04759869f, -0.03571886f, 0.04714693f, -0.02127731f, 
    -0.04144921f, 0.01313764f, -0.04419368f, 0.03205653f, 0.01502003f, 0.02104435f, -0.00435373f, 0.04771702f, 
    0.02760978f, 0.02166685f, 0.02802338f, -0.05312018f, -0.02862871f, 0.00603759f, -0.02948797f, 0.04130032f, 
    -0.01132056f, 0.05154482f, 0.12604344f, -0.17915174f, -0.14901233f, 0.09099401f, 0.14092045f, 0.10023402f, 
    -0.01185753f, 0.04318010f, 0.02977566f, 0.16477536f, -0.05042125f, -0.10443380f, 0.07082224f, -0.09571656f, 
    0.11225516f, -0.09992126f, -0.13021235f, 0.03810203f, -0.13341898f, 0.32753700f, 0.03711901f, -0.07129277f, 
    0.03899029f, -0.19084691f, -0.07071555f, 0.06638534f, 0.11846962f, 0.31993362f, -0.22602546f, 0.00761183f, 
    -0.03870808f, 0.07082140f, -0.00631243f, -0.11725485f, -0.15336053f, -0.10939898f, -0.28542522f, 0.18992841f, 
    -0.07616565f, 0.16659436f, 0.01640188f, 0.11822865f, 0.10379862f, 0.26294416f, 0.23587961f, 0.02680521f, 
    0.07118183f, -0.17211676f, -0.09203874f, 0.20643064f, 0.21449052f, 0.13493657f, -0.21586691f, 0.01468578f, 
    -0.13196401f, 0.11408129f, -0.04627293f, -0.05693577f, -0.11723465f, 0.09135611f, -0.26194033f, 0.19438545f, 
    -0.13147996f, -0.13864578f, 0.27516174f, 0.00603683f, -0.08028162f, -0.03944242f, 0.02350560f, 0.09914414f, 
    -0.14202666f, -0.34716076f, -0.00870795f, -0.16035944f, 0.00799566f, 0.00652669f, 0.10060954f, 0.04085673f, 
    0.02529879f, 0.21044849f, -0.00791585f, -0.14265597f, 0.12625057f, 0.07667024f, -0.15678249f, 0.02724713f, 
    0.03834557f, -0.12774307f, -0.26821223f, 0.09762958f, -0.02917193f, 0.16809201f, -0.16914533f, 0.08365146f, 
    -0.01948807f, 0.15213928f, 0.15828055f, -0.12966330f, -0.11411816f, -0.04915096f, -0.07620238f, 0.18900678f, 
    -0.07594711f, -0.03314970f, 0.08637059f, 0.05153753f, -0.20689632f, 0.06955017f, 0.21199882f, 0.08118712f, 
    0.05084681f, -0.10462824f, 0.05487410f, -0.09855112f, 0.03746761f, -0.04927024f, 0.01187598f, -0.11955532f, 
    0.06789645f, 0.06700718f, 0.23895320f, 0.11623608f, 0.29029593f, -0.01162297f, 0.12622832f, 0.09118299f, 
    -0.18841037f, 0.13499838f, -0.03347827f, 0.11131786f, 0.08245057f, 0.25818589f, 0.19192164f, 0.02278595f, 
    -0.34764543f, 0.35334992f, 0.04315534f, 0.28196847f, 0.01762891f, -0.00595818f, -0.01352272f, -0.02223279f, 
    0.07184152f, -0.01325770f, -0.13217989f, -0.11430254f, 0.10882360f, -0.12247773f, 0.05624053f, -0.01446604f, 
    0.07500174f, -0.09470977f, -0.03185756f, 0.05509217f, -0.09683380f, 0.03884657f, -0.01213652f, -0.03872688f, 
    0.14077227f, -0.02340047f, 0.00419853f, -0.12160022f, 0.15590404f, 0.02744328f, -0.02102829f, -0.14875886f, 
    0.14736615f, -0.00186719f, 0.07828831f, 0.16610976f, -0.17209570f, 0.07384922f, -0.07321727f, -0.34512120f, 
    -0.09688792f, 0.04643452f, 0.23290239f, 0.08054542f, -0.20679951f, -0.19407442f, -0.18296374f, 0.04769310f, 
    -0.04239617f, -0.01010331f, -0.06868185f, 0.03889235f, 0.07454018f, 0.26286080f, -0.29488730f, -0.28364113f, 
    0.11373546f, 0.14491668f, -0.02854070f, 0.00335100f, 0.13162138f, -0.03983187f, 0.08039455f, -0.14672518f, 
    -0.03252158f, -0.07132049f, 0.01123748f, -0.22660206f, 0.05238578f, 0.04160527f, -0.04807910f, 0.04681683f, 
    -0.03498751f, -0.18494371f, 0.04879326f, -0.02091783f, 0.10913095f, 0.21859443f, -0.13741732f, -0.00269898f, 
    0.38116676f, 0.26018259f, -0.06163537f, -0.07452578f, 0.01339673f, 0.06399357f, 0.08459560f, -0.09160247f, 
    0.21816647f, 0.29754937f, -0.04883762f, 0.02847063f, 0.14817834f, 0.03810633f, 0.12570149f, 0.20975569f, 
    0.28400561f, 0.20849924f, -0.02249004f, 0.11707412f, -0.04303920f, 0.06445935f, -0.09332114f, 0.00024047f, 
    0.07225093f, -0.08336980f, -0.12419808f, 0.11529106f, 0.11642084f, 0.32568592f, -0.13820456f, 0.06411318f, 
    -0.01709625f, 0.07659389f, -0.11898275f, 0.08584113f, -0.06156442f, -0.09083273f, 0.04997819f, -0.02923954f, 
    0.12392357f, 0.13351341f, 0.04722577f, 0.19120370f, 0.12193465f, -0.08220533f, -0.08019030f, 0.14231311f, 
    0.07669739f, 0.18953896f, 0.07016501f, 0.23985952f, 0.07837591f, 0.01277374f, 0.19889390f, 0.04164294f, 
    -0.10284760f, 0.17680168f, -0.14611995f, -0.05796472f, -0.09605622f, -0.07064242f, -0.28947175f, -0.07622536f, 
    0.03167368f, -0.18248548f, -0.08878165f, 0.03352479f, 0.02890393f, 0.27823907f, -0.02121489f, -0.04477373f, 
    -0.06317660f, -0.00547681f, -0.29035681f, -0.01616376f, -0.00642860f, 0.07718296f, 0.01198704f, -0.03781837f, 
    0.02488947f, 0.09077441f, 0.06361919f, -0.33695808f, 0.18015891f, 0.02298992f, 0.09262787f, 0.10773171f, 
    -0.08241361f, 0.02274652f, 0.04756919f, 0.12203774f, 0.11726186f, -0.15641718f, -0.09369270f, 0.19439943f, 
    -0.02237175f, -0.04549729f, 0.17097256f, 0.06817487f, 0.11706304f, -0.32119149f, 0.06585457f, -0.03138413f, 
    0.08213011f, 0.27943096f, -0.08555628f, -0.02410282f, 0.06414510f, 0.11172724f, -0.06003281f, -0.05002363f, 
    0.10045782f, 0.05956273f, 0.25677562f, 0.02652975f, 0.25182950f, 0.00967250f, 0.04188852f, -0.02849824f, 
    -0.00749037f, 0.07811697f, -0.00246120f, 0.14624847f, 0.10294636f, 0.10346286f, -0.54478067f, -0.03113552f, 
    0.02982129f, 0.31672117f, 0.02932019f, -0.17146054f, -0.18528639f, -0.00451217f, 0.01333241f, 0.18947868f, 
    0.14592724f, 0.18459179f, 0.03607889f, -0.13559346f, 0.00803835f, -0.00673725f, 0.14372413f, -0.01904202f, 
    -0.26730263f, 0.14464410f, -0.13428611f, 0.02160782f, 0.18096724f, -0.08614285f, 0.08754137f, 0.09966695f, 
    -0.02318389f, 0.00171938f, 0.05196525f, 0.31605214f, -0.02904817f, -0.13635367f, -0.16244978f, 0.02988771f, 
    0.09105330f, 0.14642888f, -0.03862442f, 0.22696123f, 0.07770433f, 0.18802060f, -0.10983387f, -0.24672717f, 
    0.09146482f, 0.05360916f, 0.06367717f, -0.33735886f, -0.26226696f, -0.01394248f, -0.06399287f, -0.04621082f, 
    -0.04758433f, -0.09172000f, 0.05181802f, -0.00207999f, -0.15749647f, -0.26639462f, 0.12171981f, -0.02220653f, 
    -0.01206656f, 0.05829182f, 0.06321903f, -0.05537946f, -0.00393514f, -0.36153409f, -0.15728848f, -0.00687987f, 
    -0.08065984f, 0.16473933f, 0.19049065f, 0.06620723f, 0.04731369f, 0.12757884f, 0.26583400f, 0.12819998f, 
    0.14572504f, -0.14359598f, 0.04174896f, -0.13745561f, 0.18357539f, 0.17531344f, 0.20295078f, -0.30054730f, 
    0.00596205f, 0.09967972f, -0.02157743f, 0.12395947f, -0.04080160f, -0.00289291f, 0.00791838f, 0.05047974f, 
    -0.17207204f, -0.16636227f, -0.01525748f, -0.13026068f, 0.04724777f, -0.03813279f, 0.17195480f, 0.14176407f, 
    0.17348982f, -0.35908452f, -0.29676113f, -0.05221127f, -0.10928281f, 0.19655362f, -0.03320646f, -0.02642653f, 
    0.03796088f, 0.10703973f, 0.00278289f, 0.14645678f, -0.23853651f, 0.03726616f, -0.06242203f, 0.04947903f, 
    0.11385038f, -0.20019707f, 0.02222900f, -0.25083545f, -0.15038826f, 0.05049787f, 0.07265157f, 0.08239522f, 
    -0.02197910f, -0.04061886f, 0.09135440f, 0.06742565f, 0.09849708f, -0.01706919f, -0.02824729f, 0.27532768f, 
    0.03104603f, 0.08497722f, 0.23793456f, -0.01344835f, 0.04295588f, -0.05108598f, 0.29791892f, 0.21425009f, 
    0.00087383f, -0.13651052f, 0.07508801f, -0.12470030f, -0.04926897f, 0.12124696f, -0.31749332f, 0.10050349f, 
    0.13029529f, 0.23190771f, 0.16191503f, 0.05720996f, -0.00336037f, -0.07906640f, -0.08104714f, 0.00625036f, 
    -0.14238459f, -0.20340052f, 0.16178565f, 0.11520083f, 0.00723420f, 0.00400485f, 0.03356361f, 0.09385931f, 
    -0.18201731f, -0.39411268f, -0.32199889f, -0.13484977f, 0.15188715f, -0.04347240f, -0.15683591f, 0.18028152f, 
    -0.30358171f, 0.37983230f, -0.03071803f, 0.21942887f, 0.06172106f, -0.01064405f, -0.30484396f, 0.25695062f, 
    -0.02595150f, 0.05185889f, -0.04983352f, -0.07486633f, -0.42752543f, 0.04637697f, 0.12227084f, 0.13350043f, 
    -0.02856078f, -0.03463607f, 0.09263351f, -0.14909375f, -0.11977869f, -0.20872793f, -0.05351349f, -0.14223722f, 
    0.11865745f, 0.24318786f, -0.13572253f, 0.12991251f, -0.12880404f, -0.04810913f, -0.27752930f, -0.09296060f, 
    0.03518525f, -0.28041133f, -0.03839682f, 0.23296954f, 0.12658101f, -0.01025710f, 0.16986232f, 0.33038116f, 
    -0.08775698f, -0.11704306f, -0.05442183f, 0.08327674f, 0.01095501f, -0.01663871f, -0.14298375f, -0.09213843f, 
    -0.06913749f, 0.00480786f, 0.12663965f, -0.02003984f, -0.15557386f, -0.02851106f, 0.13954160f, -0.16264915f, 
    -0.26577765f, 0.18412143f, -0.10270528f, 0.27086389f, 0.05463605f, 0.06989021f, -0.09603565f, -0.00607959f, 
    0.20372766f, 0.15700442f, 0.08781604f, -0.09311246f, 0.09922870f, -0.05032615f, 0.07022727f, 0.13181095f, 
    0.05210213f, 0.06339097f, 0.10178030f, -0.01692364f, 0.08162110f, 0.02683077f, -0.00166564f, 0.09150845f, 
    0.07500960f, 0.13917497f, 0.23100139f, -0.33685744f, 0.04687009f, 0.05848256f, 0.18098143f, -0.08149920f, 
    -0.15972304f, -0.08382427f, 0.01968940f, 0.46858647f, 0.18838139f, -0.04498797f, 0.01197869f, 0.00889915f, 
    0.09637576f, -0.02894762f, 0.09407683f, 0.01973870f, 0.14552276f, 0.01289283f, 0.07047000f, -0.06109461f, 
    -0.10612559f, 0.28913155f, 0.02519848f, -0.05194752f, 0.13208658f, -0.13247456f, -0.20046034f, 0.02172268f, 
    -0.08355871f, 0.04028347f, -0.06459774f, 0.25904581f, 0.31520072f, 0.06723096f, -0.30120948f, 0.06282481f, 
    0.23339510f, 0.13997434f, 0.08573572f, -0.15740523f, 0.02364776f, 0.04984213f, -0.07178038f, -0.52664030f, 
    -0.33618531f, -0.17303221f, -0.00711156f, -0.06921886f, 0.06856348f, -0.00845969f, 0.09319387f, -0.05001348f, 
    -0.02444664f, 0.11508094f, 0.13093269f, -0.10222389f, -0.15156913f, -0.03851159f, -0.08462306f, -0.03151366f, 
    0.00044099f, -0.28878698f, -0.06284012f, 0.13874407f, 0.05805520f, -0.04202502f, 0.19646205f, 0.01904625f, 
    -0.13663629f, 0.08522923f, -0.21770146f, -0.48507941f, 0.35257050f, 0.03105829f, 0.01213602f, -0.07097171f, 
    0.17319110f, 0.21476951f, 0.19615886f, 0.02474853f, -0.30759662f, -0.25742143f, -0.17899328f, 0.16259913f, 
    -0.12526336f, -0.07890317f, -0.00789094f, -0.04639232f, -0.01661697f, -0.22691758f, -0.19451796f, 0.06700706f, 
    0.00242063f, -0.09328705f, 0.10414612f, 0.20637864f, -0.09364483f, 0.26706770f, 0.10382317f, 0.11310806f, 
    0.13205208f, -0.02326785f, 0.00360974f, -0.12200685f, 0.00675515f, 0.12990943f, -0.31095535f, -0.12207701f, 
    0.08755969f, -0.00895141f, 0.14903559f, 0.04416583f, 0.15273058f, -0.07448035f, 0.07217345f, -0.09996137f, 
    -0.02256860f, -0.25986403f, 0.22096334f, 0.14009130f, 0.05087456f, 0.05472571f, -0.14314264f, 0.00811411f, 
    0.33096474f, 0.26111159f, 0.25236222f, 0.08078746f, -0.07771282f, 0.04830812f, -0.13864312f, 0.11004405f, 
    -0.01596593f, 0.33103088f, 0.09857062f, -0.05381025f, -0.03423873f, -0.04841525f, 0.13398410f, 0.05162178f, 
    0.03905564f, 0.10581340f, -0.00746769f, -0.01154214f, -0.00358428f, -0.08323143f, 0.15339296f, 0.01397848f, 
    -0.10956810f, 0.08396821f, 0.15399984f, -0.02268793f, 0.09333734f, -0.03490474f, 0.10361431f, -0.10432874f, 
    -0.06515606f, 0.07830793f, 0.25948822f, -0.01665718f, 0.27429378f, -0.13541350f, 0.11693531f, 0.13811937f, 
    0.00380798f, -0.09309366f, -0.27982399f, 0.01061343f, -0.27003261f, -0.53388065f, -0.50961095f, 0.25559485f, 
    0.16366114f, 0.10036010f, 0.01250100f, 0.00690173f, 0.02577351f, 0.02715489f, 0.00850201f, 0.06379743f, 
    -0.09540573f, -0.05912530f, 0.18936484f, 0.08138550f, -0.01062900f, 0.00988484f, -0.04173324f, 0.26248619f, 
    0.08373956f, -0.34174690f, 0.12305190f, 0.04315060f, -0.08889955f, -0.10071935f, -0.03018837f, -0.00307063f, 
    -0.02838674f, -0.00703980f, -0.16797511f, -0.00359660f, -0.18590742f, -0.23794247f, 0.18398051f, -0.09222333f, 
    0.01608988f, -0.29587486f, 0.19752310f, 0.06949820f, 0.21480887f, 0.04205102f, -0.13696691f, -0.15059257f, 
    -0.16645664f, 0.07040367f, 0.20031245f, 0.19523028f, -0.06723051f, 0.11948492f, 0.12395950f, 0.03585078f, 
    -0.03947532f, -0.05193833f, -0.00571320f, 0.17292936f, -0.17670235f, 0.11091054f, 0.10035845f, 0.28379801f, 
    0.04580309f, 0.03557924f, 0.03190146f, 0.06818455f, 0.00638711f, -0.23479633f, -0.07613739f, 0.03695773f, 
    -0.04844578f, -0.00674060f, 0.02375434f, -0.09480458f, 0.03296277f, -0.61467141f, -0.26379725f, 0.39552507f, 
    0.14017776f, 0.00915506f, -0.17116252f, -0.10584276f, -0.16460451f, -0.16489936f, -0.13684209f, 0.01649762f, 
    -0.51678020f, -0.09724714f, 0.18538949f, 0.08263157f, -0.05304069f, 0.10477360f, 0.12861228f, 0.08738220f, 
    0.12327995f, 0.13286147f, 0.22504091f, -0.01275843f, 0.19556607f, -0.03905624f, -0.16408576f, -0.15778778f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.01737989f, -0.10190664f, 0.11810048f, 0.01807450f, 0.09127121f, 0.10149086f, -0.03870153f, -0.03150138f, 
    -0.05865130f, -0.03364515f, 0.00490725f, -0.03793948f, 0.03080813f, 0.04184498f, -0.02296269f, -0.04467501f, 
    -0.01233474f, -0.17436740f, 0.04788978f, 0.04737078f, -0.04488173f, 0.02878598f, 0.12379327f, -0.06909458f, 
    0.11398426f, -0.05164446f, 0.16874924f, -0.09215963f, -0.05596939f, 0.03138891f, 0.23400001f, 0.10894120f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.05517804f, 0.26409900f, -0.05881291f, 0.15971273f, 0.57801867f, -0.07432329f, 0.15669297f, -0.02993272f, 
    -0.10606907f, -0.04885104f, 0.11079508f, 0.07255019f, -0.11319739f, 0.21827741f, 0.28977230f, -0.16988151f, 
    0.12949882f, -0.01616137f, 0.21536146f, -0.13828541f, -0.00772200f, 0.34686038f, -0.01003154f, 0.64281875f, 
    -0.10082328f, -0.42172614f, -0.21055481f, 0.14755997f, -0.15148330f, 0.23967661f, -0.25505960f, -0.18416180f, 
    -0.12193946f, 0.07802279f, -0.32491678f, -0.09687924f, -0.14437337f, 0.52986479f, 0.35785866f, 0.05205660f, 
    0.10374510f, 0.06210411f, -0.14184314f, -0.02564465f, -0.13809714f, -0.30073920f, -0.38597894f, -0.14228970f, 
    0.12856223f, 0.14952436f, 0.52801234f, -0.12226754f, -0.00236269f, -0.14924483f, 0.17415580f, 0.04172041f, 
    0.02138748f, 0.10553150f, -0.49110976f, -0.06501658f, -0.18061741f, 0.14523061f, 0.20151287f, 0.40003106f, 
    -0.09627829f, -0.08959953f, 0.34023818f, 0.11123788f, -0.31423163f, 0.13552070f, -0.23933607f, 0.14504907f, 
    -0.11944927f, 0.00545241f, 0.17509699f, 0.12094281f, -0.05827543f, -0.02936337f, 0.29246899f, -0.03392736f, 
    0.11624406f, -0.07273430f, -0.16797605f, -0.08803670f, -0.10122301f, 0.13094339f, 0.07295749f, 0.00430024f, 
    0.02406465f, -0.18631597f, -0.10143176f, -0.28860343f, 0.02582887f, 0.17714104f, 0.26840305f, 0.41202763f, 
    0.15308055f, -0.22516051f, -0.03819002f, 0.11456110f, -0.08725391f, 0.10748419f, -0.02801912f, -0.00959241f, 
    0.06027561f, -0.16410363f, -0.10240620f, -0.10898459f, -0.06475955f, -0.28049928f, -0.06456730f, 0.04178902f, 
    -0.16286933f, -0.07588895f, 0.51653874f, 0.09393139f, 0.02670047f, -0.08730609f, -0.01216861f, -0.11177660f, 
    0.37214002f, 0.06249858f, 0.15866032f, -0.41926903f, -0.07782257f, -0.03110377f, 0.45063087f, 0.42232421f, 
    -0.15408649f, 0.17479034f, 0.58035290f, 0.01414521f, -0.36401367f, 0.10711154f, 0.39392078f, -0.08189157f, 
    0.13731083f, -0.00419175f, -0.02061037f, -0.18421365f, -0.17537394f, 0.12739919f, -0.50003445f, 0.00017191f, 
    -0.04976478f, -0.09674010f, -0.25297001f, 0.14598134f, -0.13573036f, 0.11269448f, 0.29647380f, -0.30585575f, 
    0.18273027f, 0.27495751f, -0.15052734f, -0.27753207f, -0.01296467f, 0.06349187f, 0.04988329f, 0.31484485f, 
    -0.07416851f, -0.13984819f, -0.08970530f, 0.15703298f, -0.13038419f, 0.01615491f, -0.16001703f, 0.03858239f, 
    0.09361085f, 0.10850152f, 0.07039559f, 0.02256175f, 0.02548331f, -0.09809262f, -0.03577241f, -0.04741203f, 
    -0.13192050f, -0.05998734f, -0.07088543f, 0.07443073f, 0.04654835f, -0.04559117f, 0.02454645f, 0.04292784f, 
    -0.16836423f, 0.02753398f, -0.01164433f, 0.12194865f, 0.16158456f, -0.04611684f, 0.13926953f, -0.17691836f, 
    -0.15141931f, 0.08631241f, -0.72920632f, 0.00374468f, -0.07046749f, 0.41351816f, 0.11585587f, 0.08969710f, 
    0.05633662f, -0.10328910f, 0.00518837f, 0.09650546f, -0.01889307f, -0.31728098f, 0.50996292f, -0.14872447f, 
    0.09447697f, 0.53459477f, 0.02923930f, 0.03532040f, 0.02432290f, -0.37775615f, 0.21562643f, 0.25645229f, 
    -0.29233333f, 0.20901114f, 0.06627414f, 0.25432867f, 0.06448755f, 0.11789802f, 0.20606010f, -0.17242256f, 
    -0.00291625f, -0.05546859f, 0.47279218f, -0.12183741f, -0.25715262f, -0.28735843f, 0.13425528f, 0.05351794f, 
    -0.09526964f, -0.13254191f, -0.10125268f, -0.14152911f, 0.07387617f, 0.46615672f, -0.17903996f, 0.13968360f, 
    0.17352812f, -0.26420593f, -0.09843483f, 0.05499605f, -0.14811498f, 0.49895298f, 0.19043075f, 0.02315909f, 
    -0.02880872f, 0.12608346f, -0.45174640f, 0.21236423f, -0.01294060f, 0.48641935f, 0.15945931f, 0.14752713f, 
    0.05442289f, 0.07296833f, 0.06926478f, 0.06867465f, 0.00261733f, 0.09874838f, -0.13786282f, 0.02790655f, 
    0.17222722f, -0.06360025f, 0.13778371f, -0.16234146f, 0.07907409f, -0.08474728f, -0.12205423f, 0.11655313f, 
    0.00295531f, 0.05640285f, -0.04864581f, -0.07773868f, 0.10378757f, 0.05802917f, -0.09106451f, -0.17213659f, 
    -0.19837485f, 0.01543461f, -0.18703997f, -0.00792739f, -0.05013388f, -0.14136457f, 0.03169729f, -0.15225941f, 
    -0.04140473f, -0.15804681f, -0.11349422f, 0.08384123f, -0.54956418f, -0.53083575f, -0.14328773f, 0.11610579f, 
    -0.05912114f, 0.10699969f, 0.14390819f, 0.05457558f, -0.15177271f, 0.33993608f, 0.29498306f, 0.16826716f, 
    -0.02994285f, -0.05084278f, -0.06784849f, -0.04612557f, 0.17585044f, 0.10595319f, 0.25912395f, -0.28102577f, 
    0.04532604f, 0.65148741f, 0.10323033f, 0.30638215f, 0.12591211f, 0.18837436f, 0.44474462f, -0.25407535f, 
    0.07327028f, 0.15352845f, 0.46577325f, -0.09046078f, 0.00533943f, -0.32590422f, -0.02680053f, 0.00634083f, 
    -0.16800793f, 0.06745206f, -0.10322601f, 0.02563415f, -0.17957024f, 0.50034946f, -0.45936650f, -0.04689872f, 
    -0.06792129f, -0.14513144f, 0.09513221f, 0.04503408f, 0.04261234f, 0.25200507f, -0.06812180f, -0.08152184f, 
    0.21977380f, 0.46394277f, -0.19539565f, 0.29758161f, -0.02229619f, 0.04451605f, -0.15623710f, 0.28709480f, 
    -0.03237979f, -0.07806874f, 0.05616818f, -0.11601985f, -0.20477985f, 0.14397207f, -0.15421422f, -0.00012365f, 
    0.13971521f, 0.03413567f, -0.16824071f, -0.12910783f, -0.14167459f, -0.10236207f, 0.35668308f, -0.07167973f, 
    0.03026784f, -0.26415515f, -0.64445400f, -0.11617730f, -0.02808830f, -0.16824386f, 0.16308524f, -0.25078380f, 
    0.04782866f, -0.02387702f, 0.14955120f, 0.59167194f, -0.09217855f, 0.02603027f, 0.44713521f, 0.23107497f, 
    0.14984316f, -0.03163124f, 0.49386626f, 0.04255763f, 0.22165476f, -0.31055722f, 0.09914161f, -0.11788337f, 
    0.06850449f, 0.10675629f, -0.00245482f, 0.15139943f, 0.00057244f, 0.40733710f, -0.16961546f, 0.03518424f, 
    0.13674654f, 0.09825558f, -0.31913158f, -0.00536700f, -0.09439143f, -0.60272056f, 0.24387707f, -0.34265825f, 
    0.25885266f, 0.35645777f, 0.31645021f, 0.08693843f, -0.00280703f, -0.09013860f, -0.05191212f, -0.24619909f, 
    -0.13285382f, -0.62771368f, -0.33561671f, 0.03113259f, 0.47650439f, 0.08191231f, -0.24882877f, 0.05774122f, 
    -0.09013364f, 0.17802396f, 0.12721187f, 0.06043684f, -0.07212150f, 0.46540412f, -0.06477722f, -0.18103836f, 
    0.13258462f, -0.06789926f, -0.27176911f, 0.15872641f, -0.10771888f, -0.20665124f, -0.14531164f, -0.07234123f, 
    0.38175735f, -0.00510286f, 0.22580579f, -0.43846646f, 0.10577521f, 0.24938124f, 0.28124833f, -0.25382477f, 
    0.04067104f, 0.14713140f, 0.02553030f, 0.01071634f, -0.01017777f, 0.23734036f, 0.39864662f, -0.13538969f, 
    -0.01833686f, 0.15136564f, 0.04859127f, 0.04091238f, -0.04393187f, 0.15723722f, 0.17160569f, -0.12925881f, 
    -0.06403957f, 0.29710922f, -0.17425647f, 0.14006931f, 0.15331404f, 0.05900847f, -0.02947961f, 0.00377536f, 
    0.03162306f, 0.27308801f, 0.48937842f, 0.06512333f, 0.00080921f, 0.05959575f, -0.39199859f, -0.46180758f, 
    0.13264036f, 0.16750777f, 0.34462446f, -0.06095123f, -0.29646635f, 0.10494514f, -0.07331243f, 0.15830667f, 
    0.03793957f, -0.15349489f, -0.07439001f, -0.11019281f, -0.10769577f, -0.12199453f, -0.11703537f, -0.14275856f, 
    0.08756728f, 0.11265647f, 0.28730729f, 0.12918900f, -0.01217236f, 0.03063335f, -0.00626104f, 0.04784174f, 
    0.14295354f, 0.30303147f, -0.04115197f, -0.53141713f, -0.05810072f, -0.05698356f, -0.08064391f, -0.13658474f, 
    -0.00470154f, -0.06239652f, 0.23211683f, -0.08788810f, 0.23233280f, 0.05794952f, 0.01422541f, 0.03343758f, 
    -0.16973121f, 0.14693293f, 0.14306912f, 0.12339169f, 0.09921672f, 0.26442969f, -0.11717054f, -0.03257225f, 
    -0.06941696f, -0.08772095f, -0.17097899f, -0.13062650f, 0.10920005f, -0.00259418f, 0.20884320f, -0.25566766f, 
    0.12558711f, 0.06430580f, -0.16187702f, 0.17483822f, 0.01267282f, -0.23513305f, 0.01871903f, -0.07619326f, 
    0.15217301f, -0.01573098f, -0.25699654f, -0.15459271f, -0.39258325f, 0.10162964f, 0.23323363f, 0.09129784f, 
    -0.04418234f, -0.16072589f, 0.12905233f, -0.18825547f, -0.14803654f, 0.21790826f, 0.33644137f, 0.09783483f, 
    -0.16717760f, 0.19749810f, -0.13991894f, -0.13386378f, 0.15177239f, 0.02727296f, 0.14854860f, -0.19105983f, 
    -0.05614510f, 0.72729486f, 0.41096565f, -0.22675098f, -0.00994927f, -0.11400928f, 0.46000385f, -0.15704393f, 
    -0.03656454f, 0.28001827f, -0.38553131f, 0.10680849f, 0.91518378f, 0.23371775f, 0.32006052f, -0.12395436f, 
    -0.14970119f, 0.14416429f, -0.14061132f, 0.08178712f, 0.03747911f, 0.11050082f, 0.17418703f, 0.05583688f, 
    0.01357224f, -0.10436681f, 0.01126270f, -0.04262220f, -0.16064686f, -0.43836191f, 0.38121793f, 0.10134403f, 
    -0.14289260f, -0.50001854f, 0.35594183f, -0.09380879f, 0.07630688f, -0.21310115f, -0.04883847f, 0.00817388f, 
    -0.11368793f, 0.13639887f, -0.09156946f, -0.12098970f, 0.24923013f, -0.44596368f, 0.29905686f, 0.16398816f, 
    0.06180715f, -0.00606986f, 0.16119418f, 0.11177617f, 0.09477898f, 0.32381552f, -0.18026930f, 0.09075761f, 
    -0.12917681f, -0.12116088f, 0.52093017f, 0.16176069f, 0.16727597f, 0.43649998f, 0.32318804f, 0.26288241f, 
    0.22697826f, -0.20962341f, -0.15158938f, -0.29000452f, 0.07345641f, 0.27903494f, -0.15610977f, -0.16541669f, 
    0.10339148f, 0.52150679f, 0.29217583f, -0.16494752f, 0.10220965f, -0.06000040f, 0.10417176f, 0.13578685f, 
    0.14609943f, 0.08322395f, 0.03037143f, -0.06097940f, -0.11765471f, 0.54259634f, -0.03236955f, -0.14847244f, 
    -0.07515091f, -0.42092797f, -0.43120795f, 0.13845670f, 0.01960363f, 0.15642461f, 0.40320382f, 0.32458931f, 
    -0.30821294f, 0.13780779f, -0.21388079f, -0.00020442f, 0.02435900f, 0.08030283f, 0.10353857f, -0.13863313f, 
    -0.15934603f, 0.35968363f, -0.19045965f, -0.14804405f, 0.03968688f, 0.33384544f, 0.11671808f, -0.05234655f, 
    -0.05800020f, 0.10823816f, 0.15582365f, -0.02963290f, -0.12695765f, 0.02730389f, 0.15154669f, 0.03332793f, 
    0.06180461f, 0.40485516f, -0.00387647f, -0.03105670f, 0.06253512f, -0.14178489f, 0.26586089f, 0.32128161f, 
    -0.30584380f, -0.12648003f, -0.27984232f, 0.29394275f, -0.11883315f, 0.19580576f, -0.29526666f, -0.15581234f, 
    -0.10085484f, -0.02723471f, -0.04086253f, 0.00767140f, -0.16649114f, -0.03020118f, -0.12503417f, -0.08791432f, 
    0.15707551f, 0.16885972f, -0.15300547f, 0.16870534f, 0.09442405f, -0.16957720f, -0.10593633f, -0.03636240f, 
    -0.15617551f, 0.11666527f, 0.11349698f, -0.00758470f, -0.13872932f, -0.06651841f, -0.07869139f, 0.14885418f, 
    -0.11472580f, -0.04473519f, -0.13263375f, -0.04721344f, 0.02957328f, -0.12826997f, 0.15007943f, -0.09779088f, 
    -0.07346929f, 0.09684715f, 0.36555603f, 0.07887961f, -0.59591073f, -0.33602068f, -0.40545022f, 0.07967021f, 
    -0.09889995f, -0.16669714f, 0.07711020f, 0.05404615f, -0.10440399f, -0.02428376f, -0.00557590f, 0.04909587f, 
    -0.13951065f, 0.34578130f, 0.10036258f, -0.03082672f, -0.10482942f, -0.15581997f, 0.11545847f, 0.08009191f, 
    -0.14607275f, -0.00183530f, 0.25143307f, 0.37195489f, 0.16999020f, -0.01839778f, -0.04742363f, 0.52150178f, 
    -0.11481762f, 0.19553068f, 0.00912275f, -0.06314581f, 0.02807492f, 0.14394987f, 0.03755416f, 0.02923331f, 
    0.14386621f, 0.18531013f, -0.04704904f, 0.15883535f, -0.08313833f, -0.27909741f, 0.24308743f, 0.05851433f, 
    -0.17001756f, 0.57248455f, 0.05629472f, 0.15942560f, 0.08076145f, 0.00100842f, -0.45134440f, 0.53627968f, 
    -0.21809569f, -0.09741531f, -0.23039378f, 0.24628642f, 0.14976525f, -0.03371222f, -0.08228057f, 0.28297064f, 
    -0.11592577f, -0.12892772f, -0.11181469f, -0.14979908f, 0.02341091f, 0.13498488f, -0.11307643f, 0.05365117f, 
    0.04563066f, -0.00673462f, -0.12374753f, -0.16018820f, -0.00870648f, -0.10000607f, 0.14771070f, -0.07777162f, 
    -0.03368054f, -0.18642107f, -0.13146895f, 0.00751792f, 0.01179294f, -0.10695138f, -0.16956876f, 0.15522721f, 
    0.12873262f, -0.11464895f, -0.10998019f, 0.01130505f, -0.10121723f, -0.06594591f, -0.17890173f, -0.16677159f, 
    -0.16184241f, -0.15885936f, -0.07014599f, -0.08960806f, -0.11726183f, -0.09429120f, -0.10347907f, -0.14099179f, 
    0.10420226f, -0.15417840f, -0.11029666f, 0.10847646f, -0.09012941f, -0.12591477f, 0.03449353f, -0.13354552f, 
    -0.06447216f, -0.13747120f, -0.16068438f, 0.03534938f, 0.01786908f, -0.05775334f, 0.03806853f, 0.10797106f, 
    -0.12955910f, 0.08850139f, -0.10806607f, -0.04211351f, -0.10336470f, -0.02410945f, -0.12673628f, -0.12135327f, 
    -0.15660663f, 0.07096422f, -0.02847962f, 0.11511341f, 0.72658211f, 0.42856824f, 0.38255876f, -0.06113534f, 
    0.14981447f, 0.12688665f, 0.06991871f, -0.03152886f, 0.11739504f, 0.06546054f, -0.14520189f, 0.06149967f, 
    0.12767355f, -0.01167534f, 0.28905571f, 0.06642044f, -0.02863701f, -0.74475551f, 0.38660768f, -0.17142004f, 
    0.15802844f, -0.14948958f, 0.14086923f, -0.24063620f, -0.11827262f, -0.27997741f, -0.08651822f, 0.19514063f, 
    -0.05515229f, -0.18284516f, -0.19146030f, 0.06849280f, 0.03241707f, 0.11383432f, -0.17745212f, 0.08838175f, 
    -0.10203979f, -0.10564870f, -0.11495732f, -0.01721317f, -0.12133342f, -0.19706769f, 0.02492499f, -0.01531033f, 
    0.16038458f, 0.05125289f, -0.03706918f, -0.03924746f, -0.13666657f, -0.07487079f, -0.02017169f, -0.13058108f, 
    0.00428062f, -0.20296738f, 0.04912760f, -0.05330623f, 0.03302760f, 0.10540731f, -0.15468220f, -0.13184507f, 
    0.10298239f, 0.39294493f, 0.15755095f, 0.10655625f, 0.10283799f, 0.25947344f, -0.03265159f, -0.14215548f, 
    0.13675301f, 0.13211983f, -0.07421441f, -0.00821874f, -0.07923394f, 0.25819263f, -0.05212570f, -0.02623744f, 
    0.01100941f, 0.27949411f, -0.00599652f, -0.03619493f, 0.05496375f, -0.27328727f, -0.17372404f, 0.55350530f, 
    -0.29232201f, -0.26189685f, -0.44663665f, 0.43156788f, -0.05854092f, 0.14775226f, -0.21042114f, 0.40414935f, 
    -0.13794997f, -0.07230272f, 0.11567999f, 0.12755486f, 0.20053817f, 0.11385351f, -0.01106895f, 0.05776293f, 
    0.05319518f, 0.13568425f, -0.13708223f, -0.17174982f, 0.10797818f, -0.20543163f, 0.31791565f, 0.03427034f, 
    -0.03537945f, -0.38933787f, -0.13222408f, -0.13533238f, 0.07119694f, 0.84377700f, -0.18140805f, -0.05620297f, 
    0.33029273f, 0.04370510f, 0.45606896f, 0.11952304f, -0.08328826f, 0.18545130f, 0.33616656f, -0.10527083f, 
    -0.03493137f, -0.23073946f, 0.40528932f, 0.00795981f, 0.03035002f, 0.07605573f, -0.20372511f, 0.12620890f, 
    0.04005174f, 0.00986096f, 0.12175032f, -0.03373199f, -0.05392543f, -0.03297725f, -0.12896283f, -0.13518040f, 
    0.01757044f, 0.19942373f, 0.56912088f, 0.12261625f, 0.08896376f, 0.28669438f, -0.40463659f, 0.27041617f, 
    0.53204322f, -0.35151693f, 0.15155056f, 0.01207037f, -0.05880386f, 0.21533377f, -0.25756648f, 0.36269537f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.12874156f, 0.23742610f, 0.37184158f, 0.23309451f, 0.17223625f, -0.12413660f, 0.25019273f, 0.30156124f, 
    0.13557306f, 0.04929321f, 0.02885292f, 0.27533105f, 0.23015758f, 0.11135594f, -0.00134964f, -0.01984386f, 
    0.09938433f, -0.08395088f, 0.18368115f, 0.13034046f, -0.05765057f, 0.14518076f, -0.16635759f, -0.14319117f, 
    0.00250358f, 0.05032130f, 0.07230987f, 0.01477594f, -0.10494076f, -0.08871981f, 0.21062060f, 0.26771018f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.28339776f, 0.11455055f, -0.08105742f, -0.27311763f, 0.18946992f, -0.02015913f, 0.29578039f, 0.44737720f, 
    -0.00810130f, 0.51882917f, 0.00905787f, 0.35118634f, 0.14382331f, -1.12622643f, -0.22425222f, -0.37272826f, 
    0.00780475f, 0.15257424f, -0.04994933f, 0.04248140f, 0.49044156f, 0.13594256f, 0.04205023f, 0.04946177f, 
    -0.72538835f, -0.11724912f, -0.06833635f, -0.19759873f, -0.08790066f, -0.17651872f, -0.24680954f, -0.86529499f, 
    -0.78591335f, -0.22132234f, 0.10430875f, 0.06756154f, 0.36459768f, -0.05015231f, -0.55866247f, 0.23854771f, 
    -0.14718045f, 0.18426563f, 0.42928907f, 0.17670105f, 0.48517603f, 0.23758815f, -0.03948424f, 0.44718862f, 
    0.15430787f, 0.22790185f, -0.43001956f, -0.21391262f, 0.19521326f, -0.49553221f, -0.14122123f, 0.00017676f, 
    -0.00817090f, -0.08420285f, 0.12516364f, -0.07614829f, 0.02450487f, -0.17640218f, -0.00229342f, -0.22642806f, 
    0.44737065f, -0.69114548f, 0.11455272f, -0.48786440f, 0.29481092f, 0.13623703f, -0.70601946f, 0.38363373f, 
    0.15244386f, -0.11282198f, 0.04468133f, -0.22108856f, -0.06167005f, -0.57753170f, 0.28081387f, -0.40210623f, 
    -0.13099299f, -0.11889634f, 0.07070386f, 0.37280411f, 0.63554388f, 0.00442410f, 0.01717364f, -0.35682896f, 
    -0.55965394f, 0.02682035f, 0.00214660f, -0.32602441f, -0.19838630f, -0.31499654f, 0.23133470f, -0.13820627f, 
    -0.05769267f, 0.43726861f, 0.32673833f, 0.37611711f, 0.04517411f, 0.10289700f, -0.00474996f, -0.17858535f, 
    -0.13412751f, -0.78974807f, -0.18312265f, -0.63800877f, -0.90538698f, -0.53671074f, -0.71290982f, 0.53334391f, 
    -0.16369340f, -0.38014647f, 0.08304425f, 0.10339046f, -0.31363040f, 0.10604923f, -0.14076827f, 0.24845913f, 
    0.20858625f, -0.13126078f, -0.03072727f, 0.29652339f, 0.10506908f, 0.20884775f, -0.69137049f, 0.20933278f, 
    0.10861349f, 0.27408874f, 0.24233095f, -0.11175328f, -0.30341664f, -0.10145707f, 0.30167675f, 0.11573775f, 
    0.14804517f, -0.08153172f, -0.66021770f, 0.30543911f, -0.83329463f, -0.14320879f, -0.12039269f, 0.11290319f, 
    -0.37962791f, 0.06141649f, -0.01589049f, -0.16583082f, 0.21283856f, 0.20127019f, 0.05597599f, -0.46333504f, 
    0.39891976f, -0.18562934f, 0.09845464f, -0.21976545f, -0.12132972f, 0.02692635f, 0.21481027f, -0.29233894f, 
    -0.67602706f, -0.39140108f, 0.35033792f, 0.18235834f, -0.24752945f, -0.00861444f, 0.13456343f, -0.22878093f, 
    -0.04383291f, 0.31053540f, -0.59867764f, 0.43294948f, 0.05570528f, 0.59869671f, 0.12475999f, -0.48803779f, 
    -0.42550203f, 0.22984853f, -0.32539591f, -0.33660010f, -0.80257571f, -0.25565448f, -0.06569229f, 0.57770908f, 
    0.04646545f, -0.15818173f, 0.11890279f, -0.39947513f, 0.02000611f, -0.44888669f, 0.24267274f, 0.17523821f, 
    -0.47670305f, 0.09384815f, -0.11866221f, 0.30991814f, -0.06786737f, 0.10325176f, 0.20658232f, -1.15795243f, 
    0.15675691f, -0.21433625f, -0.54528499f, 0.12836216f, -0.03130174f, -0.30337709f, 0.14920342f, -0.41308314f, 
    -0.04704471f, 0.24601567f, 0.35248333f, -0.24814042f, -0.34249777f, -0.34931722f, 0.06832959f, -0.29035568f, 
    -0.33587658f, -0.06949314f, -0.09831011f, 0.44882232f, 0.07271281f, -0.76129526f, 0.30683884f, -0.20334485f, 
    0.28813154f, -0.05853616f, -0.38684547f, -0.65056974f, -0.23008104f, -0.02871255f, 0.30121449f, -0.12644346f, 
    -0.09800938f, -0.08238557f, 0.21934666f, -0.23669219f, -0.24737111f, 0.01420111f, 0.38782194f, 0.22613430f, 
    0.01775810f, -0.12431154f, -0.66360337f, -0.47353852f, 0.01551204f, 0.40516356f, -0.16983140f, 0.25973779f, 
    0.42872819f, -0.13383423f, -0.13787146f, -0.67674965f, 0.06063537f, 0.38375893f, -0.17938033f, -0.01585447f, 
    0.25743324f, -0.05474272f, -0.27287149f, 0.30291235f, -0.39854965f, 0.05508957f, -0.38532043f, 0.27473170f, 
    0.08886520f, 0.31755123f, 0.30432087f, -0.73653615f, -0.29317337f, 0.31585088f, -0.13155597f, 0.02967757f, 
    -0.13350703f, -0.08737459f, -0.53528494f, 0.48072481f, -0.70328176f, -0.46469942f, -0.12582205f, -0.14939259f, 
    0.03475852f, -0.06316730f, -0.08589652f, -0.45126471f, 0.00606450f, -0.58398646f, 0.40205699f, 0.42077935f, 
    0.36094818f, -0.52410644f, -0.35662648f, -0.41371831f, -0.82244956f, 0.10957046f, 0.04127498f, -0.54901731f, 
    0.01354462f, -0.17112836f, -0.24461687f, 0.02897487f, 0.47491074f, 0.30546769f, 0.22112988f, -0.80023789f, 
    0.10262558f, -0.22946045f, 0.46787706f, 0.01534409f, 0.17631392f, 0.24047053f, -0.07129321f, 0.18563606f, 
    0.00490569f, 0.11688919f, -0.15882133f, 0.30555645f, -0.14170156f, -0.02481305f, -0.12994230f, -0.10745620f, 
    -0.06280968f, 0.15429015f, 0.25848925f, 0.08238208f, 0.16710152f, 0.05155115f, -0.68050718f, 0.47821653f, 
    0.02689258f, -0.39325652f, 0.45528382f, 0.41747394f, -0.11566427f, -0.56469971f, -0.75725693f, -0.34172004f, 
    -0.05477233f, -1.05227840f, -0.34744823f, -0.16930878f, -0.20305887f, -0.14968447f, -0.02478182f, 0.26521942f, 
    -0.01802761f, 0.15355401f, 0.08373833f, -0.12332880f, -0.20379451f, 0.14621378f, 0.18056393f, 0.47276944f, 
    -0.09979416f, 0.44440275f, -0.36670500f, -0.05530521f, 0.41969112f, 0.01372445f, -0.06897134f, 0.08498836f, 
    0.16106567f, -0.39796454f, 0.04709606f, -0.52816921f, 0.23049356f, -0.73481458f, 0.41064718f, 0.28554505f, 
    -0.01713585f, -0.17701505f, 0.00481921f, 0.14864688f, -0.44280556f, 0.24715421f, -0.14610511f, -0.59102720f, 
    -0.26425329f, -0.10441998f, 0.07498704f, 0.39782345f, -0.17255774f, -0.21738972f, -0.24786162f, 0.10099282f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.00727711f, -0.15779687f, -0.02524805f, -0.10119681f, 0.27365223f, 0.12827326f, 0.18578357f, -0.20166472f, 
    -0.34043166f, 0.06669896f, 0.25371557f, 0.27230006f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
