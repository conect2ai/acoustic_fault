#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.50916082f, -0.35525781f, -0.54787523f, -0.36761230f, 0.09034011f, -0.54761869f, -0.46693230f, 0.15391618f, 
    -0.15437575f, 0.35714492f, 0.20161010f, 0.18211563f, 0.23812516f, 0.16859190f, 0.01115526f, 0.24493361f, 
    0.00058039f, -0.07280742f, 0.40543529f, 0.33924133f, 0.16148400f, -0.08341206f, 0.02162920f, 0.10862515f, 
    0.26755136f, -0.14371419f, -0.31516230f, -0.45597163f, -0.26622385f, -0.21592094f, 0.24086036f, -0.84741777f, 
    -0.15004846f, 0.27304047f, -0.20203087f, -0.46132836f, -0.13942917f, 0.11961855f, 0.07778627f, 0.04548271f, 
    0.06876793f, -0.11937762f, -0.08436042f, 0.13793537f, 0.33825260f, 0.40093303f, 0.20608257f, 0.27002555f, 
    -0.22100459f, -0.43611664f, -0.34318969f, -0.58963412f, 0.03264488f, 0.18910679f, 0.45527878f, -0.12063980f, 
    0.39688826f, -0.20167069f, -0.22962807f, 0.12082624f, 0.38086382f, 0.29091287f, 0.11084667f, 0.12437676f, 
    -0.04339752f, 0.12157732f, -0.05555676f, -0.07847992f, 0.00928993f, 0.21645100f, 0.18097241f, 0.04619332f, 
    0.04332362f, 0.09211428f, 0.10974868f, -0.08457356f, -0.68869227f, -0.35632476f, -0.27674404f, -0.35634986f, 
    -0.55479902f, 0.58064294f, 0.53414530f, -0.12256189f, 0.26926789f, -0.14616777f, -0.01241012f, -0.16035229f, 
    -0.02423319f, -0.38411862f, 0.07544678f, 0.17029160f, -0.00754567f, -0.08025192f, -0.02481166f, 0.05802482f, 
    0.05310125f, 0.09612866f, -0.03431490f, 0.32183626f, 1.10233796f, 0.12325966f, -0.73496294f, 0.74738371f, 
    -0.29226816f, -0.34453863f, 0.03941657f, 0.08256727f, 0.55204022f, -0.13798620f, -0.09007938f, -0.24163365f, 
    0.12554413f, -0.19337381f, 0.07277357f, -0.04335502f, -0.15729627f, 0.15496626f, 0.15386143f, 0.09779348f, 
    0.21382034f, 0.15699464f, 0.14653806f, -0.02377728f, 0.03308752f, -0.33898279f, -0.22411956f, -0.43092042f, 
    0.13246378f, -0.32406548f, 0.00596707f, 0.52144134f, -0.26454365f, -0.46311629f, -0.42512456f, -0.10862792f, 
    -0.05991573f, -0.06184677f, 0.49220788f, 0.41161042f, -0.58321691f, -0.41765258f, 0.06946250f, -0.00872350f, 
    -0.14726205f, 0.01048661f, 0.19525518f, -0.29946038f, 0.17305112f, 0.17618105f, 0.05952956f, 1.03350019f, 
    -0.57217097f, -0.30169803f, 0.19443373f, 0.20110761f, 0.03995928f, -0.33575782f, 0.18009278f, 0.10580430f, 
    0.34413961f, -0.16535641f, -0.23408191f, -0.00512163f, -0.01157164f, 0.13923435f, 0.34638223f, 0.19276837f, 
    0.04168865f, -0.16328856f, -0.38649219f, 0.05859195f, -0.02587291f, -0.23525338f, 0.35395840f, -0.77997708f, 
    -0.96582603f, -0.84153497f, -0.21705331f, 0.32506558f, -0.08774050f, 0.48665118f, 0.42931676f, 0.32132024f, 
    0.51213479f, -0.05629019f, -0.07901713f, 0.15398411f, 0.07176128f, 0.26728067f, -0.21611401f, -0.19220454f, 
    0.23318774f, -0.07105518f, -0.18326077f, 0.09953752f, 0.01505849f, -0.27912125f, -0.13650753f, -0.18889940f, 
    0.47071314f, 0.00380525f, 0.46741906f, 0.27938315f, 0.21022630f, 0.56735706f, 0.45947763f, 0.24738465f, 
    0.36851418f, 0.25984097f, -0.21756715f, 0.38984793f, 0.11307626f, 0.21569517f, 0.12044256f, -0.00629151f, 
    -0.06842075f, -0.02752664f, -0.19458371f, 0.09597068f, 0.23802514f, -0.06959891f, 0.12033366f, -0.00276384f, 
    -0.11864968f, -0.16908632f, -0.16846476f, 0.13918997f, 0.18249457f, -0.00867085f, -0.55041814f, 0.20803823f, 
    -0.15292801f, -0.10432655f, -0.04030666f, 0.32082808f, 0.23582713f, 0.21665494f, 0.17068093f, 0.04990749f, 
    -0.15684403f, -0.32675052f, 0.39863244f, 0.32731819f, -0.30813426f, 0.19303077f, 0.08467413f, 0.08518976f, 
    0.05735772f, -0.04585565f, 0.87380230f, 0.70446628f, 0.34988946f, -0.02163905f, 0.10630487f, -0.22636986f, 
    -0.29263878f, -0.26753432f, -0.03244690f, 0.03859223f, -0.13952768f, -0.11468080f, -0.07863872f, 0.01897532f, 
    0.05366448f, -0.04034535f, -0.11929385f, -0.27470353f, 0.09381241f, 0.26398531f, -0.25038406f, 0.20856777f, 
    -0.12356841f, -0.26002949f, -0.09302868f, -0.66818750f, -0.40188551f, 0.43622810f, 0.38908696f, 0.17244229f, 
    0.26121074f, 0.24525532f, 0.13358596f, 0.07133768f, 0.11585122f, 0.02513977f, 0.13239057f, 0.14574945f, 
    0.43405029f, 0.06974389f, -0.11510502f, -0.14316067f, -0.20756924f, -0.27186951f, -0.13357620f, -0.16851093f, 
    -0.13087882f, -0.10443003f, -0.09216198f, -0.27797097f, 0.43559781f, 0.09787739f, 0.42857400f, 0.53245002f, 
    -0.03980993f, 0.18228735f, -0.68321174f, 0.36171702f, 0.33121565f, 0.07175608f, 0.14835104f, 0.08387993f, 
    0.15244435f, -0.30362082f, -0.14900550f, 0.17234264f, -0.11404954f, -0.21128868f, -0.39852378f, 0.18494032f, 
    -0.07987184f, -0.17299211f, 0.39967048f, 0.30780512f, 0.19006222f, 0.23601267f, -0.16313703f, 0.59032565f, 
    0.52605689f, 0.29195672f, 0.27298737f, 0.08566257f, 0.31400004f, 0.00081577f, 0.34477791f, -0.18770903f, 
    -0.23938800f, -0.36807692f, 0.04198292f, -0.03307105f, -0.00542596f, -0.21884675f, -0.26783347f, -0.10141285f, 
    -0.26028112f, 0.07866181f, -0.54496914f, -0.33825964f, -0.17117783f, -0.29900715f, 0.46234426f, 0.30038968f, 
    0.39405715f, 0.67831379f, 0.34355596f, -0.53755635f, 0.17226559f, -0.50693476f, -0.00412017f, 0.46891952f, 
    -0.09972581f, -0.21325143f, -0.22999035f, -0.02569441f, -0.23144408f, -0.25670570f, 0.03732080f, 0.42965403f, 
    -0.11730618f, -0.16254431f, 0.07149944f, -0.07158627f, 0.02303875f, 0.03303191f, 0.25545970f, -0.12508962f, 
    0.09408069f, -0.25228292f, -0.55289030f, 0.14330876f, 0.72519583f, -0.37232131f, 0.45772353f, 0.25134122f, 
    0.06948391f, 0.33697966f, -0.10313279f, -0.04137114f, 0.20313089f, 0.25100878f, 0.01580412f, -0.05629425f, 
    -0.10416295f, 0.20100772f, 0.07584493f, 0.36901179f, 0.38493344f, -0.22230434f, 0.19638620f, 0.14976750f, 
    0.42732111f, 0.53815609f, 0.57606190f, 0.42707476f, -0.56396335f, -0.24852735f, -0.05203455f, 0.09933717f, 
    -0.42010975f, -0.34276289f, 0.01440530f, 0.01646114f, -0.00530859f, 0.37781680f, 0.10880150f, -0.05662210f, 
    0.05649256f, 0.14020123f, 0.14116523f, -0.27424023f, -0.22186549f, -0.14843927f, -0.00525111f, 0.05531725f, 
    -0.02926883f, 0.32401055f, 0.07107850f, -0.04629018f, 0.40684295f, 0.54673749f, 0.20065886f, -0.22611164f, 
    0.39370576f, 0.33952349f, 0.04105295f, -0.50255775f, -0.18337575f, -0.50107265f, -0.19142206f, -0.15529411f, 
    0.16674900f, 0.22345084f, 0.08177522f, 0.18400230f, 0.15881291f, -0.00821527f, 0.22399268f, 0.27537778f, 
    -0.11359122f, -0.23717588f, 0.02470358f, -0.95449489f, 0.02067509f, 0.57716668f, 0.13077715f, 0.33046427f, 
    0.89550883f, 0.37349439f, -0.31541651f, 0.23105784f, -0.26309973f, -0.02090697f, -0.12386708f, -0.24431811f, 
    -0.17255203f, -0.26752487f, -0.11640925f, -0.31035608f, 0.11301697f, -0.19450241f, -0.09409884f, 0.19260095f, 
    0.18235934f, -0.04924402f, 0.01319305f, 0.60846430f, 0.07371370f, 0.52465117f, 0.62925917f, 0.56989771f, 
    0.63852751f, -0.20950207f, -0.28711334f, -0.46951649f, -0.40231165f, 0.26238120f, 0.16077954f, 0.16183490f, 
    0.16023071f, 0.08398618f, 0.02757138f, -0.08366929f, 0.19269218f, 0.07357221f, -0.02420703f, 0.08161180f, 
    0.28960350f, 0.34139743f, -0.04958602f, 0.19533950f, 0.54611552f, -0.31159696f, -0.73911238f, -0.55457026f, 
    0.07935577f, 0.46022177f, -0.15847901f, 0.23235257f, 0.19703887f, 0.00706132f, -0.46697170f, 0.04294942f, 
    0.17159574f, 0.11306954f, -0.33476630f, -0.11038134f, -0.04276394f, -0.02444405f, 0.15827212f, -0.05346375f, 
    -0.06659326f, -0.05330439f, -0.12861811f, -0.09370409f, 0.19540039f, 0.69406742f, 0.17954338f, -0.16060093f, 
    -0.86072719f, 0.10036612f, -0.13120702f, 0.72382337f, 0.18180250f, -0.20283335f, 0.20646156f, 0.03421711f, 
    0.05701260f, -0.30631438f, -0.22142495f, -0.23514599f, -0.07013011f, 0.11894676f, 0.20978920f, 0.27372500f, 
    -0.05110476f, -0.31435987f, -0.03899629f, -0.03185495f, -0.40169054f, -0.30524632f, 0.48253113f, -0.40942344f, 
    -0.00222816f, -0.69885069f, -0.09445545f, 0.42662773f, -0.28858683f, 0.71900380f, 0.60642767f, 0.10501561f, 
    -0.07230566f, -0.08227202f, -0.00483730f, -0.14666003f, -0.50515801f, 0.10244694f, 0.28573453f, 0.30511528f, 
    -0.01342406f, -0.27774486f, -0.13634962f, 0.22955079f, 0.16005319f, -0.06903476f, -0.28786033f, -0.19960621f, 
    0.54902011f, 0.83635259f, 0.25989893f, -0.02993396f, 0.32968712f, -0.55694777f, -0.04180712f, -0.59790337f, 
    0.30214509f, 0.20395498f, 0.02071592f, -0.07257921f, 0.22228122f, 0.10047784f, 0.32106492f, 0.28402552f, 
    -0.00120673f, 0.25614494f, 0.12050054f, 0.04869459f, -0.18263212f, -0.10499873f, -0.09460036f, 0.06929297f, 
    -0.29517567f, -0.60256982f, 0.28663367f, 0.21197636f, -0.55600709f, 0.52955425f, 0.37794894f, 0.50168270f, 
    0.22231053f, -0.36950076f, -0.16444755f, -0.01263448f, 0.07705416f, 0.25105795f, -0.19560988f, -0.19680563f, 
    0.10414453f, -0.12121062f, -0.23956506f, -0.12225062f, -0.06228250f, 0.07335282f, -0.01136320f, -0.19365215f, 
    -0.10275283f, -0.28479207f, -0.51578081f, 0.12629838f, -0.26230448f, -0.38892040f, -0.25540206f, -0.05461616f, 
    -0.50399649f, -0.29645813f, 0.15792650f, -0.21637402f, 0.05111513f, -0.34851551f, 0.08975559f, -0.39539090f, 
    -0.26211959f, -0.10843546f, 0.07468105f, 0.00270836f, 0.09840652f, -0.11659801f, 0.28630406f, -0.20297287f, 
    0.14329113f, -0.09745348f, -0.44076949f, -0.65032977f, -0.61531305f, 0.06838100f, -0.35442206f, -0.10273443f, 
    -0.11546235f, -0.23491539f, 0.32456839f, 0.26099300f, 0.37466356f, 0.03642658f, -0.31079420f, 0.25874850f, 
    -0.21634464f, -0.05459047f, 0.26857385f, 0.11200652f, -0.32084981f, -0.14783184f, -0.00546781f, 0.08035284f, 
    0.14017542f, 0.36528262f, 0.04090484f, -0.25560281f, 0.11256076f, 0.21529062f, 0.42494330f, 0.49193048f, 
    0.17358766f, 0.44153622f, -0.21964453f, 0.50844097f, -0.06993499f, 0.32132080f, 0.26172373f, -0.41115239f, 
    -0.18442234f, -0.15584406f, 0.12901242f, -0.11301285f, -0.28930518f, -0.04991781f, 0.27182901f, 0.23977341f, 
    -0.06351011f, 0.27956596f, -0.25939590f, 0.38035932f, -0.01451760f, 0.26204991f, 0.44158632f, 0.77867806f, 
    0.31340322f, -0.58533728f, 0.21472895f, 0.44464251f, 0.13801633f, 0.14266591f, -0.50096136f, -0.29437533f, 
    -0.17319337f, 0.18174660f, 0.20300546f, 0.24031435f, 0.23009527f, -0.01535905f, -0.03483586f, 0.20927159f, 
    0.22456580f, -0.02819027f, -0.21412037f, 0.03074454f, -0.20549268f, 0.36730167f, -0.01294291f, -0.37003368f, 
    0.66924685f, 0.44273737f, 0.70091116f, 0.03898276f, -0.46514550f, 0.24169379f, 0.20017190f, -0.17918034f, 
    0.36977142f, 0.09104219f, 0.23362842f, -0.34954566f, -0.11275808f, -0.21028158f, -0.13052979f, -0.09832029f, 
    -0.33917943f, -0.02687197f, -0.00863717f, -0.12422991f, -0.06319936f, 0.11167730f, 0.63888657f, 0.75777858f, 
    0.06629646f, 0.41597667f, 0.48660952f, -0.60427350f, 0.07344789f, -0.27797008f, -0.05954818f, 0.09301068f, 
    0.29281002f, 0.23221084f, 0.04769184f, -0.05890630f, 0.00285044f, -0.00733530f, -0.00476138f, -0.01020025f, 
    0.12429933f, -0.10727461f, -0.11400725f, -0.10699052f, 0.21027438f, 0.11803140f, 0.17399116f, -0.47791442f, 
    -0.33579308f, -0.12916376f, -0.33130866f, 0.34259951f, -0.60961181f, -0.29036132f, -0.36263087f, -0.77571541f, 
    0.02071394f, 0.12873821f, 0.32842955f, 0.05709759f, -0.26722553f, 0.31859791f, 0.03005647f, 0.07923717f, 
    0.01911424f, 0.01332420f, 0.28261817f, 0.14571401f, -0.18837087f, -0.05257231f, 0.19953655f, -0.27366379f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02313103f, -0.06999546f, 0.18061872f, 0.03789119f, 0.07610802f, 0.00975222f, 0.12337921f, 0.20896833f, 
    0.15178961f, 0.17202899f, 0.14675550f, 0.20525488f, 0.03075458f, 0.11958797f, -0.06980435f, 0.02889506f, 
    0.14580332f, -0.11519944f, 0.07186921f, -0.00849601f, 0.09914358f, 0.04223314f, 0.12532051f, 0.14534949f, 
    0.11792259f, -0.06986685f, 0.02716428f, 0.20221435f, 0.09486676f, 0.38170242f, 0.16130005f, 0.09739933f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21036118f, 0.08769701f, 0.17655547f, -0.09957363f, 0.13553388f, 0.02530452f, 0.04270105f, 0.07471078f, 
    0.02116318f, -0.12029328f, 0.08073498f, 0.20166592f, -0.30638245f, -0.06964619f, 0.13090289f, -0.05685884f, 
    0.06957366f, -0.02850660f, -0.01671598f, -0.17342281f, 0.08699871f, 0.11824270f, -0.00017512f, 0.03982518f, 
    0.24746665f, -0.05022927f, 0.00104377f, 0.09501980f, 0.02348762f, -0.01455975f, 0.04950271f, 0.09616975f, 
    0.01104063f, -0.02294164f, 0.01790723f, 0.02051375f, 0.08484884f, -0.03075462f, -0.22374035f, -0.09646851f, 
    -0.00311164f, -0.00569838f, 0.05219913f, 0.00226570f, 0.05931296f, -0.03861192f, -0.08147069f, 0.04070324f, 
    -0.38490969f, -0.10396218f, 0.01287572f, 0.25560322f, 0.01023436f, -0.12958293f, 0.00722145f, 0.16910258f, 
    0.05758444f, 0.05750113f, -0.03622965f, 0.07078205f, -0.03084607f, -0.04823243f, -0.17820728f, 0.06621467f, 
    -0.02295346f, 0.05238009f, 0.07465030f, 0.01320727f, -0.02396914f, 0.10754476f, 0.01787794f, -0.20984280f, 
    -0.03405566f, -0.13561223f, -0.07019926f, 0.04948657f, 0.09540162f, -0.01556496f, -0.04644275f, -0.11219126f, 
    -0.01959880f, -0.06131023f, -0.02183610f, 0.13260522f, -0.07079326f, -0.11613625f, -0.01320364f, 0.00729745f, 
    0.13247672f, 0.07046862f, 0.01724848f, 0.07461283f, 0.05412146f, 0.05526344f, -0.00045597f, -0.12658109f, 
    0.23740618f, 0.03409123f, 0.10631276f, 0.03545574f, -0.05891433f, 0.10583881f, -0.07846364f, -0.04340309f, 
    -0.06408583f, -0.00093023f, 0.08624609f, 0.00288600f, 0.29439011f, 0.03854749f, -0.07868537f, 0.05684780f, 
    -0.03942976f, 0.13623394f, 0.04251000f, 0.14132746f, -0.01691804f, 0.08620454f, 0.05338922f, 0.06701263f, 
    -0.04063889f, 0.10437667f, 0.02863507f, -0.11408119f, 0.09111519f, 0.02165947f, 0.06887046f, -0.06497176f, 
    -0.04308287f, 0.07993391f, 0.02509759f, 0.04452316f, 0.00499415f, -0.06867333f, 0.05091912f, 0.02732719f, 
    -0.03574417f, 0.04502342f, 0.02742993f, -0.05533767f, -0.06248719f, 0.02679185f, 0.08065025f, -0.07499758f, 
    -0.12055692f, 0.04794206f, 0.12435849f, -0.01537364f, 0.06223987f, -0.03827278f, 0.07206011f, -0.07756623f, 
    -0.01409559f, -0.06291800f, -0.02029351f, 0.09900876f, 0.17287521f, 0.12085243f, 0.18532048f, 0.07061917f, 
    0.04241629f, -0.04859633f, -0.15226097f, -0.02086079f, -0.03054293f, -0.10439205f, -0.02156096f, 0.00032382f, 
    0.00935584f, 0.00299450f, 0.06229080f, -0.03604958f, 0.06041738f, -0.07045862f, 0.03719137f, -0.00435612f, 
    0.00950931f, -0.08279280f, 0.11758451f, -0.08584148f, 0.07276360f, 0.04407677f, 0.08945342f, 0.03071115f, 
    -0.07867126f, 0.01584311f, 0.07724088f, 0.07054403f, 0.19060266f, 0.20045690f, -0.03897570f, 0.11750910f, 
    0.02835015f, 0.02603764f, -0.08365280f, 0.06270260f, -0.04386937f, 0.02702815f, -0.05466478f, -0.10942082f, 
    -0.04682677f, 0.10442172f, -0.04187151f, 0.04340633f, -0.22676656f, -0.02071903f, 0.21418683f, -0.01972719f, 
    -0.00566658f, -0.19484071f, 0.01216627f, 0.08932197f, -0.07890005f, 0.05495519f, -0.03094037f, 0.01795778f, 
    0.28954908f, -0.11666265f, -0.00022806f, -0.00262801f, -0.02617584f, -0.08112153f, 0.01115118f, 0.02979403f, 
    0.04847594f, -0.06333785f, 0.02971834f, 0.00559720f, 0.20839623f, 0.06724524f, -0.07462021f, -0.03784130f, 
    0.07160623f, 0.11011942f, 0.05653655f, -0.05842349f, 0.07271567f, 0.05117070f, 0.06443028f, 0.07349379f, 
    -0.23075967f, 0.01818702f, 0.12367141f, -0.16268450f, 0.02078628f, 0.04971583f, -0.06299959f, 0.00455208f, 
    0.03882771f, -0.11856143f, 0.02845566f, 0.03532473f, 0.29406479f, 0.19996567f, -0.27173638f, 0.01033629f, 
    0.09067187f, -0.01869749f, -0.08064683f, 0.04220821f, -0.01285295f, -0.12080482f, 0.04548855f, 0.00580291f, 
    0.00986079f, 0.08497539f, -0.05204497f, 0.04566899f, 0.04498778f, -0.01217767f, 0.11017676f, 0.08136588f, 
    0.03591882f, -0.13273975f, 0.00373356f, -0.02649248f, 0.02421024f, 0.19489497f, 0.10914613f, -0.02611810f, 
    0.01777933f, 0.02811483f, 0.01549042f, 0.00371280f, 0.04865958f, 0.01570332f, 0.11924081f, 0.10331701f, 
    0.07211715f, 0.05683728f, 0.12453060f, -0.08142219f, -0.01016387f, -0.07565463f, 0.01202067f, -0.00419688f, 
    -0.01398717f, 0.01357524f, 0.10602481f, -0.16546606f, -0.19929901f, -0.22944546f, -0.17109570f, -0.05776094f, 
    0.12329439f, -0.02159245f, 0.03721159f, -0.16717245f, -0.00145389f, 0.13591808f, 0.06821092f, -0.15971230f, 
    -0.20598052f, -0.16680339f, 0.19250983f, -0.12296526f, 0.14563751f, -0.00697100f, 0.09465259f, -0.03070262f, 
    -0.07430167f, -0.01585694f, -0.01121546f, 0.01851304f, 0.08162446f, -0.16208731f, 0.02410286f, 0.08634324f, 
    0.10407846f, -0.01246994f, 0.04357734f, 0.03646772f, 0.18099976f, 0.01420861f, -0.09269939f, 0.11993819f, 
    -0.02725999f, -0.13805591f, 0.04652300f, 0.07081128f, 0.10297655f, -0.06034656f, -0.16326603f, -0.05260755f, 
    0.02296071f, 0.04624170f, 0.05172336f, -0.05741427f, -0.03152359f, -0.05487027f, 0.11043525f, 0.00279541f, 
    0.13922854f, 0.06378794f, 0.00476323f, -0.00618156f, 0.02476059f, 0.15512155f, 0.05942991f, 0.05010987f, 
    0.27207929f, 0.17345405f, -0.27788979f, 0.04309066f, 0.12323189f, 0.00636773f, 0.07736415f, -0.06040965f, 
    0.07751200f, 0.04054190f, 0.01490031f, 0.09058084f, 0.09843454f, 0.03397577f, -0.15012494f, -0.26044935f, 
    -0.01625036f, 0.03556407f, 0.11048926f, 0.00359994f, -0.08948524f, 0.04544053f, 0.08532044f, 0.00410941f, 
    -0.09582051f, 0.05031065f, 0.05865084f, -0.05488070f, 0.10989562f, 0.09344305f, 0.04426630f, -0.03223313f, 
    -0.06317104f, -0.02416500f, 0.01552348f, 0.10865665f, -0.36296567f, -0.10569390f, 0.16757084f, -0.05823025f, 
    -0.10370619f, 0.05157100f, 0.04509915f, -0.10363635f, 0.02558351f, 0.01658960f, -0.02244410f, -0.03959390f, 
    0.11357967f, 0.00216147f, 0.01359672f, 0.14906797f, -0.06529822f, 0.03519340f, -0.06221046f, -0.00557874f, 
    0.02517370f, 0.01466827f, -0.01119196f, -0.03947886f, 0.39381817f, -0.15512396f, 0.00250821f, -0.04472145f, 
    -0.02412107f, 0.01419011f, 0.10632802f, -0.08674844f, 0.02870830f, -0.00628021f, 0.00306011f, 0.01490321f, 
    -0.21867302f, -0.10310155f, -0.09533405f, 0.25891787f, -0.05936766f, -0.07925007f, 0.05137421f, 0.06970283f, 
    -0.02438861f, -0.01370298f, 0.09570049f, 0.12967050f, 0.14416650f, 0.08112252f, -0.15840113f, -0.06064538f, 
    0.00530434f, 0.03479289f, 0.06141992f, -0.15527573f, 0.03413257f, 0.01068347f, -0.14979057f, -0.06645049f, 
    0.00758141f, -0.02349638f, -0.05041553f, -0.14187008f, -0.11441083f, 0.04606092f, -0.01204093f, 0.05750249f, 
    -0.02822409f, -0.00413390f, -0.04804643f, 0.00749430f, 0.24825612f, -0.05744299f, 0.11474519f, 0.05404518f, 
    0.05870079f, -0.02252082f, 0.01254214f, 0.12941699f, 0.01336944f, 0.01069255f, -0.03184343f, 0.03083218f, 
    0.22534892f, 0.03387361f, -0.04603941f, 0.01022016f, 0.07262778f, 0.06342057f, 0.00276282f, -0.02228390f, 
    0.11079831f, 0.08361220f, 0.04849645f, -0.08117951f, 0.14087245f, -0.07655080f, -0.11930226f, 0.06701005f, 
    -0.05677176f, 0.10806871f, 0.02690214f, 0.08518527f, 0.00057485f, 0.02891744f, -0.00112643f, 0.06002913f, 
    -0.24426055f, -0.06547499f, -0.02646920f, -0.17462938f, -0.04136955f, -0.00890622f, -0.04041447f, 0.03274278f, 
    -0.04711725f, -0.01010478f, -0.10690850f, -0.00553076f, 0.21794032f, -0.09297978f, -0.08516697f, 0.14197783f, 
    -0.09724317f, 0.01135664f, 0.00920705f, 0.00258116f, 0.06127889f, -0.02028552f, 0.04627528f, -0.02246274f, 
    0.07018167f, -0.00286623f, -0.00385689f, 0.10492487f, -0.00073738f, -0.01232884f, 0.04872025f, 0.01422763f, 
    0.01620246f, -0.05972369f, 0.11900594f, -0.09256903f, 0.05293908f, -0.00020576f, 0.07550193f, 0.06289288f, 
    0.02672653f, 0.07471287f, -0.01402284f, -0.02416994f, 0.08702441f, -0.05404562f, 0.08482686f, -0.10048024f, 
    -0.10841043f, -0.02998199f, 0.01741617f, 0.22358617f, -0.01563780f, -0.11383389f, 0.01197151f, -0.07615916f, 
    -0.02288816f, -0.03236163f, -0.02050549f, 0.05393879f, -0.01049930f, 0.25209400f, 0.12620427f, -0.12648147f, 
    -0.08108746f, -0.02026257f, 0.08577136f, -0.00496962f, 0.06356942f, 0.06531917f, 0.07402544f, 0.12112261f, 
    -0.32619762f, -0.02280531f, -0.09512499f, 0.04846624f, -0.03155683f, 0.03945702f, -0.02638397f, -0.05255467f, 
    -0.03445920f, 0.06348326f, -0.01707873f, -0.09330755f, -0.02614085f, -0.02116089f, -0.02103491f, 0.25948033f, 
    -0.10481017f, -0.01577188f, -0.06266215f, 0.01905750f, 0.07634418f, 0.01098767f, 0.00499175f, 0.02308368f, 
    0.35800433f, -0.04054165f, 0.03480033f, 0.19349371f, 0.00098070f, 0.02468697f, -0.03554104f, -0.08409575f, 
    0.02110437f, 0.00630713f, -0.01886619f, 0.12757149f, 0.06775424f, 0.15364635f, -0.23675552f, -0.15478183f, 
    0.12101805f, 0.07687061f, -0.02751748f, -0.07780677f, -0.01249190f, 0.05215224f, -0.07025132f, -0.03353071f, 
    -0.15426540f, 0.11174503f, 0.14228401f, 0.01706002f, 0.07407956f, -0.04740049f, -0.01949465f, 0.10660733f, 
    -0.07185738f, -0.01832029f, -0.01345204f, 0.09826694f, -0.00368962f, 0.15511000f, -0.07824706f, -0.12085020f, 
    0.07846619f, -0.00416679f, -0.04762414f, 0.10739382f, -0.09565742f, -0.08042474f, 0.12954982f, -0.06846961f, 
    0.16558243f, 0.20785186f, 0.05457413f, 0.07386652f, 0.00307747f, 0.08127543f, -0.00472864f, 0.05508465f, 
    0.03605973f, 0.20059840f, -0.03852661f, 0.02702825f, 0.01851459f, 0.28218970f, 0.01880148f, 0.04690169f, 
    -0.07021890f, 0.01011665f, 0.03588498f, -0.01979897f, 0.03939108f, -0.07656413f, 0.03427246f, -0.03858660f, 
    0.49257120f, 0.15418342f, 0.12330316f, 0.03438242f, -0.01250765f, 0.04049553f, 0.02324601f, 0.05694342f, 
    0.09083854f, 0.03199719f, 0.06995543f, -0.08804454f, -0.09569823f, -0.18777294f, -0.04175527f, -0.36985862f, 
    -0.08686778f, -0.05029210f, -0.01337535f, -0.01511185f, 0.03526140f, 0.13800231f, -0.05181571f, 0.04644896f, 
    -0.18290371f, -0.19233683f, 0.07259787f, 0.02538162f, 0.06186766f, -0.12343748f, -0.03525684f, -0.02323849f, 
    0.03715783f, 0.04960601f, 0.03749274f, 0.09177623f, -0.07737809f, -0.06062764f, -0.00111295f, 0.25752437f, 
    0.00756499f, -0.06647556f, -0.00726131f, -0.09759469f, 0.04776349f, 0.19034928f, 0.06527741f, 0.05506597f, 
    0.07573377f, -0.05979710f, -0.02341252f, 0.35935721f, 0.09280854f, 0.06809260f, -0.06809923f, -0.05695841f, 
    0.07987329f, -0.01163226f, 0.07149167f, -0.07321110f, -0.05898971f, 0.13574679f, -0.09917385f, 0.27506888f, 
    0.02380177f, 0.03101348f, 0.00143723f, -0.01828277f, -0.04760515f, 0.03746745f, -0.00656216f, 0.02954072f, 
    0.11763618f, 0.02482708f, -0.10745240f, -0.11101615f, 0.00473462f, -0.11650924f, -0.01610172f, -0.01767278f, 
    0.00407552f, 0.04484701f, 0.01861374f, 0.00407872f, 0.23100986f, 0.08346322f, 0.04276365f, -0.14203566f, 
    0.04036539f, 0.09808517f, -0.06359980f, -0.03606255f, 0.03650320f, -0.02862582f, 0.01902331f, -0.11245742f, 
    0.01018424f, 0.15925539f, 0.01805797f, -0.15042594f, 0.21135324f, 0.00554356f, 0.02827168f, -0.00504668f, 
    -0.06568924f, -0.05734238f, -0.05724974f, -0.10120631f, -0.20923039f, 0.06819420f, 0.09017733f, -0.14272216f, 
    -0.12195908f, 0.03228015f, 0.04221797f, -0.10599317f, -0.03839002f, -0.12670742f, 0.07660641f, 0.11362579f, 
    0.45084286f, -0.09627787f, 0.03576371f, 0.14657904f, 0.08831301f, 0.04334025f, -0.07796578f, 0.03435626f, 
    0.03222387f, -0.09657261f, 0.00683514f, -0.06305093f, 0.29206535f, 0.18564808f, -0.14920181f, 0.04155767f, 
    -0.08551471f, -0.15018295f, 0.00686376f, -0.18055758f, -0.10310482f, -0.08174528f, 0.05240508f, 0.03952342f, 
    -0.33580595f, 0.11974189f, -0.01343815f, 0.15561131f, 0.07716223f, -0.01443365f, 0.11428948f, 0.11720744f, 
    -0.01170968f, -0.01063517f, 0.03157466f, 0.10440460f, 0.19167489f, 0.06758004f, -0.06385462f, 0.04026420f, 
    0.04327542f, 0.03678052f, 0.05856640f, -0.10014073f, -0.01348196f, -0.15089056f, -0.01322367f, 0.02514374f, 
    0.00677340f, -0.22306179f, -0.12251285f, 0.21249449f, 0.00886762f, 0.05482575f, 0.07565641f, 0.01906421f, 
    0.08421881f, 0.03551004f, -0.03081323f, -0.06569189f, 0.16521041f, -0.13882254f, 0.09852926f, 0.02106870f, 
    -0.05631802f, -0.02868597f, 0.09578168f, 0.20896354f, 0.03316663f, 0.05690049f, 0.03558978f, 0.05528989f, 
    -0.01848569f, -0.07266927f, 0.01935141f, 0.04218337f, -0.02749420f, 0.10588691f, -0.05606553f, -0.01028654f, 
    -0.10179123f, -0.06505512f, 0.08301861f, 0.03576734f, 0.21090288f, -0.00215557f, -0.06187182f, 0.01768541f, 
    0.06564030f, 0.17845844f, -0.02986924f, 0.01854410f, -0.04463999f, 0.03453252f, -0.14508982f, 0.01366841f, 
    -0.14412734f, 0.30228248f, -0.03853604f, -0.13434459f, 0.03185474f, 0.10365990f, 0.03931307f, 0.04928487f, 
    0.05431203f, 0.00192729f, -0.05603097f, 0.01992427f, 0.32156920f, -0.12776589f, 0.04157912f, 0.06386836f, 
    -0.03356351f, 0.04090713f, -0.02321586f, 0.02518593f, 0.02479261f, 0.06311817f, 0.05192693f, 0.03376340f, 
    -0.17862341f, 0.10035992f, 0.09362674f, -0.06259251f, -0.10264987f, -0.02723924f, -0.07216328f, 0.10954657f, 
    -0.08710479f, 0.15956062f, 0.18980329f, -0.03871684f, 0.02289872f, -0.10514944f, 0.03833058f, -0.24711767f, 
    -0.05794302f, -0.01294200f, -0.04671486f, 0.01141723f, 0.01528080f, -0.04018025f, 0.11352067f, 0.12319841f, 
    0.13427158f, 0.18273604f, 0.03008036f, -0.23939298f, 0.15003775f, -0.05209162f, 0.01175531f, -0.01445802f, 
    -0.04572999f, 0.06061142f, -0.15058440f, 0.06010300f, 0.03302739f, 0.08544254f, 0.05940316f, 0.11441151f, 
    -0.03512329f, 0.01916461f, 0.01772867f, -0.03944611f, -0.12983938f, -0.07878649f, 0.01465795f, -0.09962480f, 
    0.04082631f, -0.02630227f, -0.03594214f, -0.00500084f, 0.12452458f, -0.04199075f, -0.08872036f, -0.03872623f, 
    0.04542777f, 0.13574775f, -0.17676087f, 0.04409270f, -0.22733271f, 0.01663753f, 0.01177694f, -0.11229999f, 
    0.06233574f, 0.02339440f, -0.03712369f, 0.13033237f, 0.03962104f, -0.13436493f, -0.01214141f, 0.08780836f, 
    0.29771981f, -0.47786662f, 0.07764162f, 0.00895544f, 0.10930755f, 0.00374112f, -0.03745768f, -0.00271795f, 
    0.05127834f, 0.11076963f, 0.03315721f, 0.18439136f, 0.11327716f, -0.05788977f, -0.03103466f, -0.18032166f, 
    0.10344651f, -0.01650952f, -0.11928730f, -0.08236432f, 0.06770721f, 0.02540612f, -0.09749594f, -0.03976534f, 
    -0.12517121f, 0.01774368f, -0.05529886f, -0.07324008f, -0.00094283f, -0.15309672f, 0.14332432f, -0.03480576f, 
    0.02700327f, 0.02220403f, -0.12231038f, 0.05725527f, 0.00841929f, -0.01086052f, -0.08206601f, 0.16756645f, 
    0.10242643f, -0.00800655f, 0.04464223f, 0.14137046f, -0.12105704f, -0.13420780f, 0.01501994f, -0.00523971f, 
    -0.23169453f, 0.04831330f, -0.06875799f, 0.22120421f, 0.03703336f, 0.01913378f, 0.05377454f, 0.00501060f, 
    -0.10181967f, 0.14678490f, -0.06377950f, -0.01638194f, 0.27585962f, 0.19681293f, -0.00983356f, 0.08180960f, 
    -0.03350477f, 0.13138042f, -0.00791382f, 0.02076522f, 0.07225157f, -0.06113935f, -0.03109266f, -0.13615623f, 
    0.15382251f, -0.06558226f, 0.15698172f, -0.22157298f, 0.02993692f, 0.00625183f, -0.00406902f, 0.02490789f, 
    0.03451940f, 0.01622209f, 0.07954443f, 0.01540155f, -0.32422161f, -0.21150140f, -0.12550983f, -0.18358791f, 
    -0.00813834f, -0.03051986f, -0.01297068f, -0.23211330f, 0.00153751f, 0.02308229f, 0.06529161f, 0.11385714f, 
    0.04697744f, 0.00870785f, -0.04129990f, -0.30739653f, -0.06231468f, -0.00985254f, 0.00167986f, -0.04834028f, 
    -0.01504548f, 0.09582667f, 0.00836106f, -0.05908027f, 0.17326811f, -0.16672644f, -0.06148514f, 0.14328685f, 
    -0.00442424f, -0.05243169f, -0.00465879f, 0.03624956f, 0.02045037f, -0.06940877f, 0.18373428f, 0.02388169f, 
    -0.16446897f, 0.00695673f, 0.01152413f, -0.02598912f, 0.07754900f, 0.10436363f, 0.02039417f, -0.02881221f, 
    -0.00596879f, 0.00244226f, -0.06110369f, 0.02292519f, 0.03425170f, -0.11940886f, 0.05806128f, 0.02996389f, 
    0.07372348f, 0.00563534f, -0.00855120f, 0.07649855f, 0.10207034f, 0.11424477f, -0.01126247f, 0.00233795f, 
    0.21116319f, 0.35463730f, -0.18687467f, -0.11129655f, 0.14398980f, 0.00919288f, -0.05694443f, -0.00907993f, 
    -0.03451300f, 0.09478746f, -0.00748242f, 0.05203021f, 0.20821793f, 0.05032548f, -0.09598003f, -0.28885084f, 
    0.03416366f, 0.10390904f, -0.05662345f, 0.07306487f, 0.00782682f, -0.07643383f, -0.03074759f, -0.14276622f, 
    -0.00992803f, 0.03742760f, -0.00890474f, -0.04581637f, -0.05028881f, 0.04488567f, -0.02798330f, 0.03852948f, 
    -0.00340528f, -0.04773806f, -0.03073026f, 0.04053387f, -0.04180141f, -0.01093486f, -0.04378084f, -0.01251256f, 
    -0.03605178f, -0.02730098f, 0.00847536f, 0.01693809f, 0.03984877f, 0.02350893f, 0.00294250f, -0.01165696f, 
    0.03912283f, 0.03254856f, -0.02998033f, -0.05256557f, -0.00192813f, -0.01206315f, 0.00710723f, -0.05421877f, 
    -0.02420360f, 0.03764243f, 0.01035691f, -0.04513937f, -0.02968463f, -0.02234787f, -0.03710415f, 0.04421861f, 
    0.03281412f, 0.01882250f, 0.03283465f, 0.01889033f, -0.01864732f, -0.03911509f, 0.02115632f, 0.02540131f, 
    0.01168593f, -0.00503860f, 0.01510987f, 0.00492024f, -0.02306962f, 0.03568938f, -0.04607444f, -0.01529311f, 
    -0.04409435f, 0.00320926f, -0.01472883f, 0.01384548f, -0.04114025f, -0.05106790f, -0.04689404f, -0.02256272f, 
    0.03743179f, -0.01814066f, -0.05095055f, -0.00460425f, -0.03534864f, -0.00328927f, -0.03655900f, -0.00179094f, 
    -0.03529187f, 0.04143583f, -0.04569541f, -0.03786655f, 0.03797457f, -0.03738166f, 0.00721285f, -0.03146673f, 
    -0.02779842f, 0.03534206f, 0.00098911f, 0.03109977f, 0.03929316f, -0.03724193f, -0.02683171f, 0.03103910f, 
    -0.00725826f, -0.01611718f, -0.04957052f, -0.03106006f, 0.02174789f, 0.04459819f, -0.05652754f, -0.00136643f, 
    -0.01610849f, 0.02555156f, -0.02701430f, -0.01591081f, -0.01267792f, -0.02269873f, 0.04264932f, -0.02980373f, 
    0.02789007f, -0.01343168f, -0.02990391f, -0.00778525f, -0.05288650f, 0.04309438f, -0.02991709f, -0.04126805f, 
    0.00647248f, -0.01601838f, 0.02810211f, -0.03263033f, -0.02057465f, -0.00894339f, 0.03878348f, 0.02689065f, 
    0.01658697f, -0.03680621f, 0.03874344f, 0.01464084f, -0.03828498f, -0.01977845f, -0.00135160f, -0.05473814f, 
    0.01622915f, -0.03050721f, -0.02963220f, 0.01048564f, 0.04462326f, -0.03242282f, 0.01864510f, 0.02558109f, 
    -0.03624208f, -0.05322698f, -0.05461131f, -0.01055166f, 0.00721513f, -0.05381153f, -0.01500739f, -0.03270129f, 
    0.01688357f, -0.05303675f, -0.05070979f, 0.04271161f, -0.02447957f, 0.01223948f, 0.03201627f, 0.04264133f, 
    -0.05322308f, -0.00252977f, 0.01295038f, -0.04203241f, -0.05528423f, -0.00670100f, 0.03208702f, -0.01884315f, 
    -0.04587219f, 0.02035085f, -0.02303271f, -0.02717609f, -0.05287619f, -0.04831700f, -0.01858463f, 0.01355816f, 
    -0.01425062f, -0.02126839f, -0.05674039f, -0.04665672f, 0.02626481f, -0.03565076f, -0.02383729f, -0.04646146f, 
    -0.01988999f, 0.00162060f, 0.02805523f, -0.02397944f, -0.00286696f, -0.05362149f, -0.05423870f, -0.01725779f, 
    -0.05600713f, -0.04302179f, -0.01226276f, 0.00718457f, 0.00911203f, -0.04743741f, -0.01637975f, -0.01574505f, 
    0.00019172f, -0.03594745f, -0.04469916f, -0.00317942f, -0.02522168f, -0.01991236f, -0.05542500f, 0.04088217f, 
    -0.02599125f, -0.00717389f, -0.02015248f, -0.02673759f, -0.00580541f, -0.01419279f, 0.01670347f, 0.02325431f, 
    -0.04776333f, -0.03649000f, 0.02079410f, -0.00820976f, -0.04323785f, -0.05489410f, -0.05449123f, 0.00227861f, 
    -0.04719211f, 0.03621637f, 0.03876020f, 0.03888962f, -0.05430481f, -0.00500030f, 0.02007104f, -0.01006501f, 
    0.03023929f, -0.00066970f, -0.02051278f, 0.03980434f, 0.00436048f, 0.02619189f, -0.02546155f, -0.00462638f, 
    0.00542428f, -0.04662808f, 0.03758105f, 0.01649738f, -0.04367739f, -0.04588036f, 0.02520951f, 0.04165107f, 
    -0.00766964f, 0.00813266f, -0.05627281f, 0.03627307f, -0.05280881f, 0.03709053f, -0.00743896f, -0.05357699f, 
    0.02237204f, -0.03315387f, -0.02033067f, -0.03676225f, -0.02440334f, 0.02735250f, -0.01959962f, -0.04126694f, 
    0.00986796f, -0.04356838f, -0.02504322f, -0.01162940f, -0.05449657f, -0.03899762f, 0.03967457f, 0.03974481f, 
    0.04465360f, 0.03078604f, 0.01034101f, -0.01383754f, -0.02514604f, -0.04244825f, 0.01666492f, 0.00546637f, 
    0.00393559f, -0.00782986f, -0.03760402f, 0.03988433f, 0.04176266f, 0.01560469f, -0.02913706f, -0.03357974f, 
    -0.03926802f, 0.02328219f, 0.01132293f, -0.01935507f, 0.02754113f, -0.01631410f, -0.04342508f, -0.00305158f, 
    0.03105098f, -0.02965938f, -0.02223154f, 0.00448119f, -0.04005590f, -0.03030545f, 0.04481805f, -0.05582973f, 
    0.04233408f, 0.01340760f, -0.04643619f, 0.02624943f, 0.01653263f, 0.00422837f, -0.01413374f, -0.03249814f, 
    0.03717655f, -0.02233473f, 0.00834290f, -0.05410993f, 0.04124240f, 0.00607093f, 0.01716370f, 0.01893992f, 
    -0.05411209f, 0.03249941f, 0.02946649f, -0.04199838f, 0.00497036f, -0.01097174f, -0.02124103f, -0.03911706f, 
    0.03063706f, -0.00105635f, -0.03677469f, 0.04161219f, -0.04118093f, 0.01130517f, -0.03355853f, -0.04189622f, 
    -0.03944300f, 0.02238933f, -0.03575542f, 0.02278237f, 0.03170510f, -0.03392790f, -0.05536095f, 0.00181142f, 
    -0.01995281f, -0.04613948f, 0.01994988f, -0.01300115f, -0.01527270f, -0.01486435f, -0.00024761f, 0.01936609f, 
    0.04435405f, -0.02466806f, 0.02591432f, -0.01237384f, 0.02289539f, 0.04250048f, 0.02594345f, 0.02983218f, 
    -0.02967106f, -0.05354593f, -0.03957091f, 0.01890854f, -0.01986692f, 0.00486961f, 0.03642984f, 0.00924244f, 
    0.04421068f, -0.04424589f, -0.05281724f, 0.00452487f, -0.05323234f, 0.04065465f, -0.05346824f, 0.03821458f, 
    -0.00849706f, 0.00496220f, -0.00940758f, -0.00378835f, -0.00294407f, 0.04342886f, -0.03705700f, -0.04578416f, 
    -0.01888636f, -0.00153887f, 0.03230590f, 0.03467644f, 0.02670462f, -0.02047821f, -0.01648975f, 0.01448621f, 
    0.16586736f, -0.29765397f, 0.13796809f, -0.09345024f, 0.20505002f, 0.12076508f, 0.06301408f, 0.07974099f, 
    -0.04164681f, 0.00452947f, 0.05526302f, 0.03106926f, -0.12195123f, -0.01598429f, 0.17539907f, -0.01030003f, 
    -0.04825189f, -0.09384090f, 0.10361781f, -0.15596269f, 0.02093934f, 0.11993677f, 0.05234031f, 0.11296140f, 
    0.22456707f, -0.01939193f, -0.02396720f, 0.08406860f, -0.02060593f, 0.00434508f, -0.08694959f, -0.03353111f, 
    0.09721386f, -0.02252884f, 0.03489954f, -0.01479632f, 0.40399438f, -0.02920631f, -0.03123646f, -0.12739284f, 
    -0.15445203f, -0.01882504f, 0.04783534f, -0.05317845f, 0.07661289f, -0.05062255f, 0.11387923f, 0.03718593f, 
    -0.07550834f, -0.39503235f, 0.01406187f, 0.30679965f, -0.00343923f, -0.05756202f, 0.11734300f, 0.04450462f, 
    0.00912557f, 0.02735310f, 0.00902130f, 0.22271977f, 0.28380132f, 0.05176235f, -0.29616171f, 0.14391729f, 
    -0.12988295f, 0.01477742f, -0.04310272f, -0.00920952f, 0.08499243f, 0.04074253f, -0.15958765f, -0.05085450f, 
    -0.05624273f, -0.24081473f, -0.10522987f, -0.20453019f, -0.01200532f, -0.13847892f, 0.14764556f, -0.03615690f, 
    0.12213945f, 0.04936446f, 0.06060086f, -0.08382151f, 0.55514246f, 0.08096419f, -0.02474635f, 0.09529445f, 
    0.08892499f, -0.03522590f, 0.05436029f, 0.11112492f, 0.02340330f, 0.00335740f, -0.07347411f, 0.14448930f, 
    0.10565882f, -0.00038090f, -0.05384831f, -0.03496969f, -0.12025183f, -0.00174597f, 0.04334713f, 0.00086144f, 
    -0.00305138f, -0.04214711f, 0.03442657f, -0.00595288f, 0.13239729f, -0.02370097f, -0.19522005f, 0.01788508f, 
    0.02617688f, 0.15755236f, -0.03790895f, 0.13144265f, 0.10018004f, 0.09475310f, -0.00867297f, 0.08930855f, 
    -0.21407688f, -0.04064954f, 0.09606718f, -0.19965781f, -0.05191793f, -0.05490690f, 0.12956728f, -0.00185386f, 
    -0.05663070f, 0.00289024f, -0.03729861f, 0.05404268f, 0.13814613f, 0.19559772f, -0.11235657f, 0.10160960f, 
    -0.05801481f, 0.06109576f, -0.04459230f, -0.00321013f, -0.07974610f, -0.08795147f, -0.06331991f, -0.02297069f, 
    -0.15655756f, 0.06918302f, 0.06229224f, 0.07710634f, -0.06556741f, -0.03775784f, 0.00790660f, 0.00390072f, 
    -0.09607331f, 0.01259154f, 0.06350285f, -0.04476809f, 0.07831022f, -0.05199414f, 0.06775285f, 0.01391527f, 
    -0.01715798f, 0.03313253f, 0.01620298f, 0.08311451f, -0.05102368f, -0.01875513f, -0.06060140f, -0.10533451f, 
    0.11300214f, -0.00182417f, 0.02726277f, -0.03772033f, -0.03969905f, 0.06320298f, 0.02856066f, -0.00635632f, 
    -0.05321173f, -0.13967086f, -0.00956130f, 0.05847459f, 0.04240163f, 0.04772737f, 0.08962917f, -0.15129013f, 
    -0.08356650f, 0.00113032f, -0.00142205f, -0.10326845f, 0.03950650f, 0.07561242f, 0.04731823f, 0.01284628f, 
    -0.56075013f, 0.01636551f, -0.05819101f, -0.01030470f, -0.10345726f, 0.03978249f, -0.01053536f, -0.06509618f, 
    -0.06862313f, 0.07033812f, 0.00182065f, 0.12079408f, -0.04326793f, -0.16492774f, -0.09124643f, 0.03911716f, 
    -0.10755897f, 0.00398660f, -0.04898553f, 0.02592860f, 0.00671699f, -0.10407399f, -0.00296835f, -0.02138630f, 
    0.26855761f, -0.06402893f, -0.03769136f, 0.18520869f, -0.00878393f, 0.07523235f, -0.02682068f, -0.01298783f, 
    -0.01242128f, 0.01077530f, -0.01131634f, 0.08195302f, -0.25147644f, -0.01476142f, -0.10864956f, -0.31170687f, 
    0.03203389f, -0.06673715f, -0.01044198f, -0.03204225f, -0.05500105f, 0.14110705f, 0.03997344f, -0.02576402f, 
    0.08285808f, -0.19314668f, 0.12351217f, -0.11672004f, 0.09452530f, -0.00582421f, 0.08611327f, 0.15806393f, 
    0.01478009f, -0.10863421f, 0.06000109f, -0.07058998f, 0.18865830f, 0.01909357f, 0.08437074f, -0.24283691f, 
    -0.00649123f, -0.09733932f, 0.10882498f, -0.02023333f, -0.08032452f, -0.14694762f, 0.07296327f, -0.09366021f, 
    -0.06565131f, 0.11905546f, 0.02206236f, 0.01894327f, 0.08416767f, 0.06178910f, 0.02244741f, -0.07112493f, 
    0.09501849f, 0.05698908f, 0.05744408f, -0.13180171f, -0.11986230f, 0.24050830f, -0.00454754f, 0.01624965f, 
    0.04754236f, 0.03078268f, 0.00952762f, -0.05800893f, -0.06971724f, 0.03844829f, -0.06862349f, 0.09518669f, 
    0.16212152f, 0.06791360f, 0.01910502f, 0.07397629f, -0.03501210f, 0.01704323f, 0.02552808f, -0.00331249f, 
    0.08728746f, 0.00768926f, -0.02348455f, 0.04612175f, -0.11965038f, -0.09382211f, 0.02056431f, -0.13297042f, 
    0.05576782f, 0.05325824f, 0.04412196f, 0.06485202f, -0.02267022f, 0.16902409f, 0.01102556f, -0.00826090f, 
    0.13676473f, -0.04983849f, -0.06440850f, 0.13502811f, 0.05645498f, -0.12416333f, 0.02527744f, -0.04016956f, 
    0.05190266f, -0.04108356f, 0.08242194f, 0.12783353f, -0.00696484f, -0.05351960f, -0.05964072f, 0.19822006f, 
    -0.01817956f, -0.02501541f, 0.08390138f, -0.06140089f, -0.07451762f, 0.02088590f, 0.14781378f, 0.06180625f, 
    -0.05011411f, -0.10976476f, -0.22545543f, 0.06676818f, -0.01812940f, 0.04988449f, -0.06145823f, -0.04428713f, 
    -0.02028404f, -0.04352923f, -0.00329413f, 0.04949026f, 0.04776011f, -0.08431280f, 0.02555073f, 0.08582892f, 
    0.01849971f, 0.07592537f, 0.02075000f, 0.00388068f, -0.03576430f, 0.02187664f, -0.08507636f, -0.06582543f, 
    0.07859270f, 0.07440656f, -0.07351135f, -0.05361116f, -0.04027303f, -0.04493936f, -0.05157776f, 0.08787907f, 
    -0.00117893f, 0.15639108f, 0.00275556f, 0.04336349f, 0.45435765f, -0.07804456f, 0.03185707f, -0.15724853f, 
    -0.02052624f, 0.04958195f, -0.07502656f, 0.01192407f, 0.07325509f, 0.04351046f, 0.03160112f, -0.03082646f, 
    0.04309958f, -0.05020351f, 0.13791077f, -0.04219382f, 0.09249710f, 0.03889603f, 0.09536823f, 0.16765910f, 
    -0.01877726f, 0.19887960f, 0.07221152f, 0.13380042f, -0.19924086f, -0.21183851f, 0.15827116f, 0.08200159f, 
    -0.05057342f, 0.02602048f, 0.15255480f, -0.00690831f, 0.10287173f, 0.23906974f, -0.04308222f, 0.01912735f, 
    0.01250594f, 0.05500986f, -0.02673400f, -0.01070047f, -0.07663999f, 0.01398748f, 0.03025116f, 0.06704734f, 
    0.05072755f, 0.04371185f, -0.00842079f, 0.15182871f, 0.16840456f, -0.05147162f, 0.06563324f, -0.01559564f, 
    -0.03737770f, -0.09383678f, 0.00742369f, 0.15504977f, 0.02293961f, -0.02025138f, -0.04443335f, -0.06137795f, 
    0.10231280f, -0.52166212f, 0.04640749f, 0.21524508f, -0.03396343f, -0.10166068f, 0.01604375f, -0.00420833f, 
    0.05565908f, 0.13396847f, -0.00331207f, 0.21773662f, 0.25600240f, -0.05207938f, -0.27339876f, -0.00497083f, 
    -0.10266289f, -0.00327243f, -0.07270131f, 0.05909016f, -0.00728055f, 0.09037086f, -0.13399427f, -0.05054137f, 
    0.11128961f, -0.02384412f, -0.11190519f, -0.14654781f, -0.13711233f, -0.03717779f, 0.00089943f, -0.07073404f, 
    -0.01234168f, -0.06961502f, 0.01900821f, 0.05367487f, 0.46637121f, 0.17254496f, -0.02095960f, 0.25809342f, 
    -0.01202507f, -0.09694611f, 0.07677662f, 0.13365175f, -0.04943689f, 0.09940846f, -0.06515124f, -0.09893800f, 
    0.24854241f, 0.11308794f, -0.13651882f, -0.04253625f, 0.04219083f, 0.01031158f, 0.01354751f, -0.02344605f, 
    0.04022768f, 0.06541987f, -0.02738095f, 0.10646948f, 0.00165811f, 0.06422940f, -0.11111568f, 0.02831133f, 
    -0.04722797f, 0.07526525f, 0.00504797f, 0.12784573f, 0.11894713f, 0.07889845f, 0.15690999f, 0.03824502f, 
    -0.18235365f, -0.34385189f, 0.11593714f, -0.10454510f, 0.08899231f, -0.06809591f, 0.06630962f, -0.05568531f, 
    0.03397809f, 0.06915943f, -0.02114161f, 0.10826218f, -0.07973685f, 0.18126126f, -0.00198329f, 0.02647928f, 
    -0.03434135f, 0.01445259f, -0.06345023f, 0.02206220f, -0.05028642f, -0.05797172f, -0.00489477f, -0.02497537f, 
    -0.13207693f, -0.10812586f, 0.00014619f, 0.08817961f, 0.03698163f, 0.04029995f, 0.07235290f, -0.00357929f, 
    0.07708985f, 0.02930205f, 0.03325152f, 0.03290918f, -0.05796481f, 0.01396798f, -0.03254855f, 0.19744056f, 
    0.12964250f, -0.00954583f, -0.00301952f, 0.04856120f, 0.08795291f, 0.08551794f, -0.01587050f, -0.04147068f, 
    -0.06873290f, -0.03276889f, 0.02157349f, 0.30679715f, -0.05443449f, 0.03096834f, 0.08037361f, 0.04739949f, 
    0.05786498f, -0.09752363f, 0.15018176f, 0.07711123f, 0.12029838f, 0.13108557f, 0.04113491f, -0.08198541f, 
    0.01323354f, 0.01830220f, -0.04422144f, 0.05932398f, 0.19039783f, 0.15071248f, -0.03415751f, 0.19435421f, 
    -0.47526640f, -0.10726970f, -0.08951434f, -0.04383016f, -0.04660989f, 0.07456326f, -0.07785347f, -0.08404388f, 
    0.00302297f, -0.00887056f, 0.11286316f, -0.02342851f, 0.07318445f, -0.22276717f, -0.20559564f, 0.27571446f, 
    -0.11473703f, -0.10093635f, -0.05840960f, -0.02861289f, 0.09326061f, 0.14760441f, 0.06291502f, -0.05662354f, 
    0.13359758f, 0.24129808f, -0.16803208f, 0.23823503f, -0.05505279f, -0.06463981f, 0.00186625f, 0.10912368f, 
    -0.00973092f, -0.00341008f, -0.03226414f, 0.05301354f, -0.18597606f, 0.08195133f, 0.00155288f, 0.02921749f, 
    0.09065380f, 0.04492842f, -0.02335058f, -0.02978259f, 0.09271805f, 0.10663608f, 0.03624418f, 0.07713125f, 
    -0.19470599f, -0.12339552f, 0.10231998f, 0.14850001f, 0.02023785f, 0.06584215f, -0.04279773f, 0.16819622f, 
    -0.10668713f, -0.12397031f, 0.03141697f, -0.00909295f, 0.04857546f, 0.12258814f, 0.02758115f, -0.24864361f, 
    0.11038355f, -0.01146734f, -0.03302230f, -0.09874418f, -0.00159536f, -0.02699715f, 0.11279601f, -0.03257478f, 
    0.02903471f, 0.11706693f, 0.18459892f, 0.05373536f, 0.03155015f, 0.05170130f, -0.05509638f, 0.05540568f, 
    0.11105806f, 0.03330650f, 0.10900225f, -0.00781702f, -0.21342212f, 0.10519250f, 0.10159761f, 0.01008525f, 
    0.02218026f, -0.01105974f, 0.03528750f, 0.00101156f, -0.04130405f, 0.03604072f, 0.05550209f, 0.12482961f, 
    0.27571124f, 0.20451856f, 0.00130772f, -0.00490500f, 0.07749999f, -0.03773737f, 0.11784168f, 0.05022212f, 
    0.06719054f, 0.01598924f, 0.05098185f, -0.12745437f, -0.04948573f, -0.09209751f, 0.16820922f, -0.06221331f, 
    -0.03413333f, 0.06106678f, 0.04314348f, 0.20004760f, 0.08171739f, 0.03264201f, -0.03659609f, -0.14852360f, 
    0.14678966f, -0.06382772f, 0.15068577f, 0.21023756f, 0.05794934f, -0.05967343f, 0.03943219f, 0.12122366f, 
    0.08036460f, -0.13535213f, 0.13947664f, 0.18741943f, 0.05638070f, 0.04405728f, -0.11726179f, 0.07747509f, 
    -0.01830551f, 0.07597113f, 0.02561598f, 0.07919248f, 0.06465483f, 0.12889387f, 0.02349500f, 0.09184855f, 
    -0.04514097f, -0.07029086f, -0.25721875f, 0.22536705f, -0.04852424f, -0.04820718f, -0.17463523f, 0.00781873f, 
    -0.02327440f, 0.02582146f, 0.05932156f, 0.13057849f, 0.19383954f, -0.06405344f, -0.08809659f, 0.18956728f, 
    0.12511514f, 0.04825603f, 0.00390043f, 0.07322382f, 0.10329027f, -0.05808571f, 0.00773976f, 0.03719927f, 
    0.09202331f, -0.09694473f, -0.11051413f, 0.12334392f, -0.00343956f, 0.01181644f, 0.02667265f, -0.02589375f, 
    0.09733015f, 0.10569645f, -0.02074305f, 0.01558071f, 0.27520901f, 0.10061567f, 0.05865075f, -0.04732408f, 
    -0.03659874f, 0.04996871f, -0.01379720f, 0.01384187f, 0.07745734f, 0.08225788f, 0.09983193f, 0.05670545f, 
    0.17328532f, 0.10167320f, -0.03504924f, 0.09294066f, 0.10634978f, 0.01666387f, 0.03500481f, -0.08986139f, 
    0.12005027f, 0.07946566f, -0.07686181f, -0.13253137f, 0.53735161f, 0.26064178f, -0.10570628f, 0.10540885f, 
    0.00753677f, 0.10082268f, 0.09278931f, -0.01540719f, -0.09675059f, -0.06164244f, 0.01406400f, 0.01561839f, 
    0.03537633f, 0.12949936f, 0.14246079f, 0.11817645f, 0.03725562f, 0.14274202f, -0.00169467f, 0.05727093f, 
    0.06688257f, -0.07952492f, 0.10529856f, 0.04588958f, 0.05756835f, 0.27231950f, 0.19921692f, 0.06121833f, 
    -0.07109433f, 0.13384043f, 0.02976860f, -0.03718893f, 0.04265860f, -0.03258890f, 0.16069455f, -0.18443324f, 
    -0.03788297f, 0.14842236f, 0.08281168f, -0.05739277f, 0.15033902f, 0.10201091f, -0.02243817f, -0.07936893f, 
    0.01443128f, -0.01312607f, 0.10942636f, 0.02150691f, 0.20125504f, -0.03208870f, 0.20601715f, 0.07404895f, 
    -0.06380641f, -0.02672302f, -0.02964659f, -0.07582888f, 0.12350442f, -0.14333902f, 0.13204287f, 0.19517089f, 
    0.10743673f, -0.07895857f, 0.04723468f, 0.11442932f, 0.02157686f, 0.02490779f, 0.20506805f, 0.07123956f, 
    0.14271586f, 0.12701355f, 0.00866099f, -0.09944296f, 0.18782271f, 0.17563404f, 0.04726337f, 0.04778643f, 
    -0.06060535f, -0.04737653f, 0.17547356f, 0.00299618f, -0.06922934f, -0.01039696f, 0.04125949f, 0.09536500f, 
    -0.29899499f, -0.22385347f, -0.25700912f, -0.04236273f, 0.07299262f, -0.00949228f, 0.05639837f, 0.03051274f, 
    -0.04271881f, -0.05272294f, 0.02718661f, -0.03705247f, -0.11066650f, 0.17402180f, 0.01789941f, 0.06821246f, 
    0.06671166f, 0.04008695f, 0.05082523f, -0.06985354f, -0.06527162f, -0.00723860f, -0.02957076f, -0.02891815f, 
    0.18812056f, 0.06306174f, -0.06485344f, 0.03857946f, -0.02319176f, -0.04675098f, -0.15196741f, 0.01301479f, 
    0.19253981f, 0.01017520f, -0.01334641f, 0.03222907f, -0.04342321f, 0.14575514f, -0.00900235f, 0.04393562f, 
    0.10228209f, 0.03889181f, -0.04770217f, 0.14365780f, 0.07482293f, -0.03750356f, 0.03785871f, 0.12047199f, 
    0.02591601f, -0.16866271f, -0.05180979f, -0.17780505f, 0.00339968f, -0.04456017f, -0.14816448f, 0.15811956f, 
    -0.10807743f, 0.08231994f, -0.00974736f, -0.00463610f, -0.12010493f, -0.23223506f, -0.11919978f, -0.13681097f, 
    -0.01214215f, -0.07672380f, 0.10306105f, -0.04648919f, -0.02626286f, 0.00523430f, 0.05139280f, 0.10519201f, 
    0.11420886f, 0.02342672f, -0.16089852f, -0.11328159f, 0.03404756f, 0.05480840f, 0.02642573f, 0.10145491f, 
    -0.05163874f, 0.10535646f, -0.14546873f, 0.07018479f, 0.17010240f, -0.11862957f, 0.00842930f, 0.07728522f, 
    0.13723193f, 0.12049575f, 0.00558727f, -0.03702060f, -0.06773281f, -0.08448948f, 0.03767454f, -0.05380559f, 
    0.09458591f, 0.04469534f, 0.01370526f, -0.05228708f, 0.01176384f, -0.02145712f, 0.08927661f, -0.04378602f, 
    0.04636282f, 0.03453362f, -0.04224454f, 0.06241861f, -0.04063633f, -0.15432464f, -0.14299317f, -0.06204267f, 
    -0.00908963f, 0.05516992f, 0.04365380f, -0.06564222f, 0.02251682f, -0.06439588f, 0.11345322f, 0.02237743f, 
    -0.11077696f, 0.00604355f, -0.02411899f, 0.09340648f, 0.01175642f, 0.01558664f, 0.06844132f, 0.00800965f, 
    -0.00554369f, 0.04895489f, -0.05072865f, -0.04934712f, -0.06730911f, -0.26410106f, -0.01459619f, 0.02963789f, 
    -0.04582836f, -0.17471768f, 0.00361870f, 0.04972887f, 0.02422689f, 0.01977042f, 0.01806098f, 0.02624661f, 
    0.14337344f, 0.11174990f, -0.10661901f, 0.15299116f, 0.00968431f, -0.03272212f, 0.17237563f, -0.04163859f, 
    0.02666038f, 0.05550167f, 0.00057164f, -0.00764075f, -0.29621196f, -0.09660811f, 0.08511584f, 0.00817411f, 
    0.09237699f, 0.10205304f, 0.20305181f, -0.05891839f, 0.04365669f, 0.03280478f, 0.03303667f, 0.06061533f, 
    -0.01945210f, 0.13778561f, 0.08887342f, -0.02598002f, -0.01728755f, 0.02572167f, -0.05100597f, 0.02049314f, 
    -0.06818546f, 0.07647955f, -0.02291319f, -0.10223718f, -0.08214649f, -0.23934579f, -0.03054591f, 0.11256023f, 
    0.08804108f, 0.04119692f, -0.01339881f, 0.03779035f, -0.05516918f, -0.06454825f, -0.03881295f, 0.06030801f, 
    0.08594775f, 0.00709192f, 0.04686870f, 0.05068966f, -0.07497018f, 0.10582653f, 0.07976391f, 0.07002233f, 
    0.01378165f, -0.04096233f, -0.06888498f, 0.02687731f, 0.06609491f, 0.19620502f, 0.06644762f, 0.06790745f, 
    -0.04427646f, 0.07546606f, -0.06014963f, 0.07250785f, 0.05034607f, -0.09377380f, -0.08789089f, 0.02507866f, 
    0.34376138f, 0.18152443f, -0.10675431f, -0.15135922f, -0.05893689f, 0.02853377f, 0.01711683f, -0.00080528f, 
    0.05826282f, 0.02379229f, -0.04151848f, -0.09232344f, 0.09197071f, 0.04733050f, -0.07404395f, -0.11466453f, 
    -0.08670741f, 0.04497260f, -0.06632366f, 0.05133418f, 0.00848911f, -0.00744972f, 0.16799615f, 0.01681385f, 
    -0.27560082f, 0.06611834f, -0.16763939f, -0.09646437f, -0.03655437f, -0.04214290f, -0.00840570f, 0.08426646f, 
    -0.01018863f, -0.01222332f, -0.03243081f, 0.14004685f, 0.16770238f, -0.05488309f, 0.02198452f, -0.03437627f, 
    0.03401159f, -0.04775618f, 0.09401635f, -0.00977023f, -0.01070896f, -0.11315671f, -0.01912022f, 0.00175524f, 
    0.00483926f, -0.06210674f, -0.03619390f, 0.06542738f, 0.04487153f, 0.06100598f, -0.06568835f, 0.05293446f, 
    0.01850920f, 0.03854994f, 0.02704994f, -0.03729874f, 0.05919448f, 0.11821920f, 0.01059288f, 0.21721379f, 
    0.10519294f, -0.00379894f, 0.05663735f, 0.09983707f, 0.00940085f, -0.06134409f, -0.02125477f, -0.09218911f, 
    -0.18906844f, 0.10194608f, 0.00191394f, 0.16001992f, 0.02684298f, -0.07181536f, -0.02535864f, 0.00786623f, 
    0.08155219f, 0.03979608f, 0.00466562f, 0.25646570f, -0.27082849f, -0.06251103f, 0.04036520f, 0.23782061f, 
    -0.02599038f, -0.05917613f, -0.08652963f, -0.06669687f, 0.08647194f, 0.21120691f, -0.14588457f, 0.16179535f, 
    0.29365009f, 0.01717816f, -0.01472071f, 0.02930635f, 0.01331115f, 0.01152712f, 0.04932307f, -0.08100913f, 
    -0.10989150f, 0.08192451f, 0.03792841f, 0.08941100f, 0.26949427f, 0.11366735f, -0.16610788f, 0.21665590f, 
    -0.12412812f, -0.13352422f, 0.04638359f, 0.13612664f, -0.01690729f, 0.02505873f, -0.12773976f, 0.03053474f, 
    -0.28581947f, 0.11369858f, -0.18343778f, -0.21901873f, 0.01447141f, -0.08314998f, -0.03585892f, 0.00503691f, 
    0.01335176f, 0.07937492f, -0.02891124f, 0.09582974f, -0.09345655f, -0.13942426f, -0.06963124f, 0.05760279f, 
    0.07770656f, -0.07093696f, 0.02048129f, 0.19202405f, -0.02035075f, 0.08909626f, 0.06627176f, -0.07925987f, 
    0.13682942f, -0.40530530f, 0.27491009f, -0.11092086f, 0.13096185f, -0.01141163f, 0.05757345f, -0.09989872f, 
    -0.20509152f, -0.08494981f, 0.16525148f, 0.11433316f, 0.46697122f, -0.05416559f, -0.10512473f, 0.32575649f, 
    -0.10733391f, -0.07245173f, 0.00785157f, 0.02416966f, 0.11937290f, 0.04478593f, -0.00902065f, -0.12440983f, 
    0.07802075f, 0.18290092f, -0.11066276f, -0.28039524f, 0.22608805f, 0.08936901f, 0.03254620f, 0.06328838f, 
    0.02142232f, -0.02294705f, -0.10505982f, -0.05758587f, 0.19271111f, 0.18169700f, -0.01169746f, 0.15461427f, 
    -0.01308537f, 0.01525416f, -0.07644607f, -0.05028761f, -0.07560976f, 0.00123265f, 0.21001421f, 0.02073149f, 
    0.13264607f, -0.03214363f, -0.07755375f, -0.10155249f, 0.18765448f, -0.00361243f, 0.22784688f, -0.15837029f, 
    0.07278525f, 0.01765583f, 0.03521831f, -0.02419725f, 0.29552144f, 0.20009951f, -0.08856333f, -0.12971230f, 
    0.02083950f, 0.14292951f, -0.06420431f, -0.08118805f, 0.06187402f, 0.23632561f, -0.09488483f, 0.14111143f, 
    0.12800160f, 0.04378701f, -0.23472530f, -0.24740557f, 0.23737293f, -0.00541092f, -0.04081158f, -0.04241096f, 
    -0.01556891f, -0.07536809f, -0.02262668f, 0.01345995f, -0.12345816f, 0.17449839f, -0.17023161f, -0.25770125f, 
    0.28156322f, 0.10050025f, -0.05190621f, -0.11973900f, -0.03046681f, 0.05668166f, -0.08378727f, 0.04521322f, 
    -0.17927724f, -0.25468069f, -0.23990814f, -0.30737513f, 0.06156074f, 0.16624390f, 0.00626334f, -0.04560285f, 
    -0.01316307f, -0.10732386f, 0.14495523f, 0.07453515f, -0.00321103f, 0.32575229f, 0.27893311f, 0.11371455f, 
    0.23311375f, -0.07431065f, 0.14015399f, 0.22732383f, 0.08806892f, -0.04115048f, -0.18640259f, 0.07239735f, 
    -0.13515598f, -0.00837013f, -0.21269664f, -0.17398874f, 0.03341918f, 0.26492950f, 0.09373755f, 0.00911229f, 
    -0.05676682f, 0.04851937f, 0.08263963f, -0.01039713f, -0.11973339f, 0.06804959f, -0.28038400f, 0.09832945f, 
    0.14248586f, -0.08738496f, 0.06609771f, -0.02672247f, -0.03748376f, -0.03019317f, -0.03256623f, 0.03623533f, 
    -0.04988680f, 0.13910387f, -0.11666325f, 0.07101305f, 0.22880028f, -0.05231953f, -0.04562660f, 0.02534005f, 
    -0.07339453f, -0.04968924f, 0.03295162f, -0.15021688f, -0.01023574f, 0.09414019f, -0.15075471f, -0.25852960f, 
    0.40765467f, -0.05311993f, 0.00819718f, -0.03125639f, 0.12157743f, -0.14505439f, 0.03023878f, 0.14356454f, 
    -0.41063410f, 0.38955560f, 0.28500766f, 0.37831193f, 0.01004419f, -0.10362933f, -0.24077664f, 0.18757789f, 
    0.06252446f, 0.00329198f, -0.05325720f, 0.01103557f, 0.07449973f, 0.01542374f, 0.01182354f, -0.04184435f, 
    0.08770299f, -0.04499141f, -0.00419497f, -0.09517473f, 0.01911800f, 0.03710052f, 0.11345329f, -0.07327972f, 
    -0.03554209f, 0.14987573f, 0.07002038f, 0.14774556f, -0.03456440f, -0.16005059f, -0.03918603f, 0.25297803f, 
    0.06746948f, -0.18039395f, -0.13755968f, 0.02612789f, 0.18484361f, -0.22355723f, 0.06223763f, -0.19498591f, 
    -0.08041701f, 0.24496354f, -0.02470562f, -0.06344408f, -0.11405974f, -0.03313697f, -0.01220261f, 0.14783859f, 
    0.04299505f, 0.37173849f, 0.04581957f, -0.01949349f, 0.05467301f, -0.06060429f, -0.08893950f, 0.06996185f, 
    0.09626746f, 0.10305230f, -0.10446718f, -0.07902169f, -0.15971094f, -0.12453869f, -0.21027067f, -0.05645944f, 
    -0.00563150f, 0.02164102f, -0.12371222f, 0.19029087f, 0.11577476f, 0.12443840f, 0.03333815f, 0.12992184f, 
    0.16402768f, -0.22287485f, 0.22497688f, 0.09343746f, -0.16411810f, -0.10151053f, -0.00558513f, 0.04059887f, 
    0.04339701f, 0.05887771f, 0.08474461f, 0.03600255f, 0.16068086f, -0.08062174f, -0.01491829f, -0.15795928f, 
    0.11906087f, 0.05099382f, 0.13785228f, 0.01654666f, -0.07610039f, 0.18124406f, -0.10074745f, 0.02022949f, 
    -0.01417174f, -0.09068137f, -0.38153183f, -0.20046836f, 0.06861190f, -0.02138714f, -0.02854918f, -0.07138056f, 
    0.12017912f, -0.08765244f, -0.03398399f, 0.19120261f, -0.15467258f, 0.15691423f, -0.01409370f, -0.12139086f, 
    0.32009158f, -0.02465582f, -0.00071684f, 0.07175874f, 0.11512247f, 0.22381072f, 0.10162584f, 0.20561896f, 
    0.17653799f, -0.07533980f, -0.25563157f, -0.07011213f, 0.21663205f, 0.03734247f, 0.11810357f, -0.16743731f, 
    0.15038976f, -0.03512831f, 0.09965867f, -0.08766113f, 0.19340824f, -0.27079433f, -0.21430644f, -0.13860674f, 
    -0.06119641f, -0.01674009f, -0.01619647f, -0.02311365f, 0.00648021f, 0.06670537f, 0.11497342f, -0.12321232f, 
    -0.09063563f, 0.20244262f, -0.11024273f, -0.07126713f, -0.15950893f, 0.08350787f, 0.02542011f, -0.02531880f, 
    0.24188575f, 0.08170803f, -0.00703844f, -0.05966731f, -0.19764675f, -0.02548977f, -0.12034269f, -0.18517299f, 
    -0.17257728f, 0.12552880f, 0.05593907f, 0.10757298f, -0.02282668f, 0.00048155f, -0.05044787f, -0.13951957f, 
    -0.04587976f, 0.08016472f, 0.07678849f, 0.09625266f, 0.06471843f, 0.01849320f, -0.12422327f, -0.00726268f, 
    0.13128193f, 0.04386312f, -0.14555901f, -0.07709566f, 0.12310065f, -0.08476660f, -0.02991436f, 0.01061482f, 
    0.09128964f, -0.19142802f, -0.07130755f, 0.00304158f, -0.08455038f, 0.03316908f, -0.03079271f, 0.11458546f, 
    0.35848320f, -0.30339876f, 0.03108064f, -0.20007129f, -0.05985568f, 0.06073319f, 0.06997371f, 0.05910848f, 
    0.08899191f, -0.02731306f, 0.08194889f, -0.00307645f, 0.25002295f, 0.09843623f, 0.03379849f, -0.24656765f, 
    0.08208857f, -0.06111570f, 0.03830903f, 0.03415931f, -0.11171459f, 0.12782386f, -0.00732077f, 0.23056538f, 
    0.25883448f, 0.32038996f, -0.12677272f, -0.09618992f, -0.16088258f, 0.11075351f, -0.07391635f, -0.00434546f, 
    0.02774089f, -0.11876047f, -0.04157013f, 0.05487631f, 0.07042116f, 0.04335674f, 0.13944411f, 0.09435248f, 
    -0.20826268f, -0.04678154f, -0.00021269f, 0.00866012f, -0.02581269f, -0.01717415f, -0.02175876f, 0.02513117f, 
    -0.02309414f, -0.10766263f, -0.01951580f, -0.07544684f, -0.14109884f, -0.07058230f, -0.01933426f, -0.05286629f, 
    -0.01180960f, -0.03099579f, -0.05643926f, -0.06726682f, -0.19712543f, 0.01488580f, 0.14110221f, 0.01887493f, 
    -0.01695828f, -0.02881618f, -0.05954585f, 0.03845280f, -0.00834621f, 0.07313164f, 0.04556448f, 0.13806409f, 
    -0.21108283f, -0.11952218f, -0.08082651f, 0.16296996f, 0.05822860f, 0.15608649f, 0.03462393f, 0.09529360f, 
    -0.08492007f, 0.02913441f, 0.08496203f, -0.05057042f, 0.23965581f, -0.06196686f, 0.11653712f, 0.04782078f, 
    -0.09134917f, 0.07225456f, 0.02947000f, -0.10280340f, 0.18124385f, 0.10551614f, 0.02426275f, -0.02884618f, 
    0.12042757f, -0.07923883f, 0.02078417f, 0.14533798f, 0.01160510f, 0.08106481f, 0.00307551f, -0.07517566f, 
    -0.03422646f, 0.16076346f, -0.02008575f, 0.04189432f, -0.18593399f, -0.06461067f, 0.02801309f, 0.13473588f, 
    -0.06882687f, 0.06572544f, 0.09294304f, -0.05680677f, 0.15134420f, 0.07198779f, 0.10958208f, -0.04434813f, 
    -0.20747061f, -0.02714463f, 0.03584545f, 0.35924810f, 0.03231030f, -0.00508047f, -0.09813071f, -0.04301076f, 
    0.02119136f, -0.04789819f, 0.05979287f, 0.04324735f, -0.04779620f, 0.40709323f, -0.02285841f, -0.01977812f, 
    -0.15680906f, -0.11159008f, 0.06338120f, -0.07913715f, -0.23128103f, -0.11042085f, -0.04134041f, -0.08240290f, 
    -0.17905232f, -0.18215382f, 0.01549637f, 0.03696865f, 0.03362701f, 0.01416128f, 0.06218159f, 0.02240510f, 
    -0.04353414f, 0.00272784f, -0.11540934f, -0.00529932f, -0.20248649f, -0.10694171f, -0.21643920f, 0.19663510f, 
    -0.06569292f, -0.13871299f, 0.08302510f, -0.09260586f, -0.05877718f, 0.09514185f, -0.02565673f, 0.05483117f, 
    0.23659582f, -0.16128500f, 0.13448274f, 0.07487323f, -0.03087131f, -0.01815571f, 0.00431946f, 0.03060420f, 
    0.06177614f, -0.02224346f, 0.11389870f, 0.02512616f, -0.13407476f, -0.07155809f, 0.12994891f, 0.21460111f, 
    0.07077275f, 0.11761463f, 0.01550339f, -0.12716763f, 0.06644022f, -0.21291472f, -0.08255476f, 0.00499329f, 
    -0.37691721f, 0.13831815f, -0.09277605f, 0.17110522f, -0.09994067f, -0.01246189f, 0.15958847f, 0.06154364f, 
    -0.13899413f, 0.13395685f, -0.05087768f, 0.06975592f, -0.28791255f, 0.17026184f, -0.10966242f, -0.08223011f, 
    0.01692911f, -0.05268079f, -0.07561558f, 0.10527935f, 0.04589986f, 0.05715520f, 0.07506727f, 0.02317924f, 
    -0.22815101f, 0.10133120f, 0.02230597f, 0.09765334f, -0.08758141f, -0.01439956f, 0.02056253f, 0.13983977f, 
    -0.03901019f, 0.17196782f, -0.14373727f, 0.18074334f, 0.09869902f, -0.13573687f, -0.09919390f, 0.34283751f, 
    -0.01479217f, 0.02710317f, 0.10199355f, 0.05623811f, 0.06839459f, -0.09219485f, 0.00012010f, -0.10126435f, 
    0.30071652f, 0.00198145f, 0.15365003f, -0.14418000f, -0.08946522f, 0.00653712f, -0.07243082f, 0.14803579f, 
    0.14670543f, 0.00538305f, -0.07718195f, 0.02098776f, 0.06490847f, 0.09418467f, 0.19066662f, -0.24487369f, 
    0.01735360f, -0.01837623f, -0.02803717f, 0.10962042f, 0.12909816f, -0.08764798f, 0.08504327f, 0.14467877f, 
    0.02797155f, -0.00432421f, 0.15349621f, -0.04474474f, -0.11006190f, -0.06172304f, -0.18681532f, -0.03898062f, 
    0.14416707f, 0.16381699f, 0.11365293f, 0.22114445f, 0.19449286f, 0.07289485f, -0.03139406f, 0.11985486f, 
    0.00779593f, -0.03475173f, -0.04235435f, -0.04886808f, -0.11950815f, 0.11376971f, 0.11450367f, -0.06756583f, 
    -0.15815412f, -0.01003191f, 0.15798324f, 0.24009521f, 0.00993527f, -0.05204052f, 0.07508549f, -0.00031133f, 
    -0.17918999f, -0.08391616f, 0.09482554f, -0.03839698f, 0.26935357f, -0.01320510f, -0.12440893f, 0.20079443f, 
    -0.02481060f, 0.08985216f, -0.00825468f, -0.03082102f, 0.05628135f, -0.09438462f, -0.04053138f, 0.02870091f, 
    -0.17177756f, -0.14162999f, -0.08233825f, -0.06464586f, 0.08221554f, 0.10240675f, 0.01955945f, -0.03321934f, 
    -0.06330204f, -0.02860563f, 0.00613802f, -0.04748615f, 0.03085464f, 0.18955801f, 0.14672559f, 0.09202093f, 
    0.04022006f, 0.02817219f, -0.08576294f, 0.00267455f, 0.21174015f, 0.07127780f, -0.08515708f, -0.05317950f, 
    0.00976998f, -0.00378790f, 0.03094176f, -0.00222775f, -0.00756689f, -0.04756284f, -0.03130716f, 0.01644135f, 
    -0.01743965f, -0.01683747f, -0.02286289f, -0.03090576f, -0.02132222f, -0.04389118f, -0.01824080f, -0.00691846f, 
    -0.02730046f, -0.02518561f, -0.03930094f, 0.01339020f, 0.03966620f, -0.04817754f, 0.04057878f, -0.05255250f, 
    -0.00587499f, -0.05903076f, 0.03346067f, -0.03320623f, -0.05160533f, -0.05189517f, 0.01772662f, -0.03341006f, 
    0.02228128f, 0.01723668f, 0.02855380f, -0.05186562f, 0.00597369f, -0.01930121f, 0.00479984f, 0.01485240f, 
    -0.05837068f, -0.03918623f, -0.03767486f, 0.00410628f, -0.01560604f, -0.04047452f, -0.02111073f, 0.04754250f, 
    -0.04533765f, -0.01015015f, 0.02518006f, -0.03985506f, 0.01702016f, 0.01989457f, 0.00726042f, -0.05408359f, 
    0.00462248f, 0.02503978f, 0.01428383f, -0.04483844f, -0.05261371f, -0.03349743f, 0.01967980f, -0.00128677f, 
    -0.04974766f, 0.01224041f, 0.02189145f, -0.03551530f, 0.00231161f, -0.03010249f, 0.01286225f, -0.02619844f, 
    -0.02910199f, 0.04148424f, 0.01153649f, -0.04287161f, -0.02326955f, -0.03850700f, 0.01793129f, 0.00878117f, 
    -0.02294723f, 0.01769705f, -0.05505039f, 0.00834374f, 0.00911795f, -0.01450601f, -0.01360823f, -0.05869972f, 
    0.00412767f, -0.04780144f, 0.03610245f, -0.05791294f, -0.02931123f, 0.02939121f, 0.00986321f, 0.02192674f, 
    0.00541712f, -0.01794851f, -0.03985889f, 0.01145926f, 0.00166566f, -0.03588813f, 0.01212327f, -0.02094038f, 
    0.02336472f, -0.00469755f, -0.05311137f, -0.04992146f, 0.01405604f, -0.05838022f, 0.01390449f, -0.00172995f, 
    0.03616155f, -0.01533987f, 0.03007501f, -0.01202994f, -0.04585171f, -0.02387340f, -0.05939697f, -0.03715087f, 
    -0.00308578f, -0.04209207f, -0.00671986f, 0.00801610f, -0.05464249f, 0.02608954f, -0.01239786f, 0.01472971f, 
    0.00313227f, -0.03682245f, -0.02336033f, -0.04266564f, -0.04571418f, 0.00804980f, 0.02585991f, 0.03952187f, 
    0.01505498f, 0.03752675f, -0.03120332f, 0.00495888f, 0.02755612f, 0.00334987f, -0.00517090f, 0.01527220f, 
    0.03917369f, -0.04785376f, -0.02714411f, -0.03943997f, -0.03092431f, 0.03028998f, -0.00987788f, -0.02197861f, 
    -0.00612268f, 0.03899740f, -0.01533505f, -0.01945218f, 0.03156231f, 0.02421406f, -0.02907511f, -0.01416768f, 
    -0.00562171f, 0.01121891f, -0.02123732f, 0.03225577f, 0.01768572f, -0.04496118f, 0.04297573f, -0.03227062f, 
    -0.04143751f, -0.04013688f, -0.05289969f, 0.00371634f, -0.00984327f, 0.03618645f, -0.02488102f, -0.01846282f, 
    -0.04600568f, 0.00171149f, -0.01341132f, 0.02435356f, -0.02610666f, 0.00671842f, -0.01479412f, 0.00465339f, 
    0.01798217f, -0.03666377f, -0.00580644f, 0.02627122f, 0.02711316f, 0.00025916f, -0.00178305f, -0.00471989f, 
    0.01375815f, -0.03574459f, -0.02755576f, -0.02663771f, -0.04383148f, -0.05059764f, 0.00879304f, -0.01241929f, 
    -0.01525694f, 0.01813934f, 0.02469950f, -0.02434713f, -0.00755527f, -0.04456818f, -0.04945443f, -0.05707332f, 
    -0.05854837f, 0.04644951f, -0.05748861f, -0.04069250f, -0.02815599f, 0.01818052f, -0.04831080f, -0.03649412f, 
    -0.00836304f, 0.03097547f, -0.02659696f, 0.02766967f, 0.03334144f, 0.02368701f, 0.03891795f, 0.02314723f, 
    -0.02589517f, -0.02948154f, 0.02134370f, 0.03027133f, -0.05494184f, -0.03430756f, 0.04152869f, 0.03808128f, 
    -0.02768026f, 0.00044034f, 0.04914417f, -0.01053436f, 0.02187280f, 0.01610685f, -0.00119764f, 0.00162104f, 
    -0.01675663f, 0.01885306f, -0.05878193f, -0.05236677f, -0.04776514f, 0.01790346f, -0.05493585f, -0.05158518f, 
    0.04375200f, -0.01825131f, -0.02353298f, -0.02146823f, -0.03912122f, 0.01686939f, -0.02619916f, -0.04793935f, 
    -0.02098422f, -0.02127801f, 0.00963841f, -0.02686289f, -0.00578338f, 0.00230572f, -0.01870315f, 0.02666460f, 
    0.01422711f, -0.00931471f, 0.01528630f, -0.01056377f, 0.02321293f, 0.03535961f, -0.04887585f, -0.00670898f, 
    0.00669746f, 0.02726146f, 0.02776456f, 0.03387208f, -0.03607753f, -0.01710648f, -0.00157226f, -0.04193706f, 
    0.03387207f, -0.05799346f, -0.04371562f, 0.01608158f, 0.02651218f, -0.01406471f, 0.03216046f, 0.00790882f, 
    0.00760849f, -0.00264848f, 0.01431091f, -0.01388766f, -0.04072787f, 0.00460692f, 0.03077568f, -0.03509853f, 
    0.01476682f, 0.03409725f, -0.01527537f, 0.03903545f, -0.00287965f, -0.02512114f, 0.02374358f, 0.03306114f, 
    -0.01522933f, -0.03598469f, 0.00282935f, -0.03195244f, -0.01940605f, 0.03452923f, -0.05375996f, -0.03124619f, 
    -0.02069093f, -0.05320938f, 0.04310840f, -0.03735039f, 0.01518981f, -0.04890381f, -0.01301835f, -0.00096196f, 
    -0.04031452f, 0.04269323f, -0.05420054f, 0.03252326f, -0.01365967f, 0.00382852f, -0.01361752f, 0.04167156f, 
    0.03565246f, 0.00614806f, -0.02016841f, -0.05584748f, 0.02389144f, -0.00489014f, -0.04343431f, -0.00353832f, 
    0.03535858f, 0.02645187f, -0.00255789f, 0.01724909f, -0.00761636f, -0.01989703f, -0.00442981f, -0.01147662f, 
    0.02552268f, 0.03726384f, 0.02777541f, -0.05003710f, 0.02662261f, -0.04205905f, -0.00696903f, 0.04112612f, 
    0.04739179f, -0.02247136f, 0.00363020f, 0.02091554f, -0.05859661f, -0.04024738f, -0.03893287f, -0.01440146f, 
    -0.01292017f, 0.03263498f, -0.00757650f, 0.01216697f, -0.02337502f, 0.04052579f, -0.00307225f, 0.00347789f, 
    0.00450364f, -0.01430687f, -0.05240643f, -0.01956014f, -0.02540093f, -0.00618074f, 0.02939872f, -0.00231512f, 
    -0.04072221f, -0.00134946f, -0.02958219f, -0.04621614f, 0.03158233f, -0.03451394f, -0.01162548f, -0.01210711f, 
    0.03640274f, 0.03220851f, -0.01614237f, -0.03170915f, 0.03787591f, 0.04477448f, -0.04467071f, 0.00099594f, 
    0.03249544f, -0.04531270f, -0.02315002f, 0.02907737f, -0.02546767f, 0.01372122f, 0.00430524f, -0.01528448f, 
    -0.03096314f, -0.04353877f, -0.01778564f, -0.01264680f, -0.00401679f, 0.01715562f, -0.02912397f, -0.05269193f, 
    0.02922998f, -0.03980443f, 0.01524761f, -0.03695186f, 0.03721299f, 0.04292113f, -0.02647388f, 0.03445987f, 
    0.00208172f, 0.01239134f, -0.04445570f, -0.03627582f, -0.01707218f, -0.00755406f, 0.00803117f, 0.02045888f, 
    -0.02183524f, -0.04684272f, -0.01487941f, -0.00999694f, -0.01788426f, -0.05084604f, -0.04975848f, -0.02579488f, 
    -0.01139649f, 0.03550485f, -0.02172694f, -0.03389106f, -0.01621028f, -0.02362341f, 0.02226470f, -0.03011323f, 
    0.00198979f, 0.02572090f, -0.04660892f, -0.02943025f, 0.03818434f, 0.01640585f, 0.05306591f, 0.02617683f, 
    0.00268756f, -0.02856863f, -0.04986591f, -0.04102388f, 0.00240795f, -0.03091867f, -0.03603784f, 0.03635900f, 
    -0.05242910f, 0.03608013f, 0.04632845f, 0.04184436f, 0.00675574f, 0.04239500f, 0.03599607f, -0.04286485f, 
    0.02769541f, 0.04069598f, -0.05289640f, 0.01014723f, -0.03360512f, -0.05248454f, -0.04587229f, -0.04530270f, 
    -0.03100570f, 0.03024351f, 0.02780830f, 0.04839531f, 0.01216528f, 0.01642299f, -0.04810176f, -0.04424353f, 
    -0.03859406f, -0.03041619f, -0.01334676f, -0.04950564f, -0.04727433f, 0.02422545f, -0.01119784f, -0.00728771f, 
    0.02680809f, 0.03684149f, -0.04186761f, -0.01092277f, 0.02169998f, 0.00946933f, -0.04522351f, 0.01193383f, 
    -0.04799726f, 0.04284679f, 0.00400844f, -0.03624377f, 0.02704158f, -0.00412429f, 0.00254163f, -0.05135794f, 
    0.01062483f, 0.02041129f, -0.04946217f, 0.00024100f, 0.00073205f, -0.02243416f, 0.00897060f, -0.00467380f, 
    -0.05141190f, 0.04912504f, -0.02553546f, 0.02368589f, 0.00245911f, 0.04199585f, 0.00349431f, 0.02177433f, 
    0.04428287f, -0.00544484f, 0.04589356f, -0.02584978f, -0.03217755f, 0.01919493f, -0.01757198f, -0.03733737f, 
    -0.04827010f, 0.04872387f, -0.03934007f, -0.03319923f, -0.04341553f, -0.02077833f, 0.02281092f, 0.03821789f, 
    -0.01833817f, -0.04103298f, 0.02910919f, 0.04226729f, 0.00794334f, 0.00323925f, 0.00307118f, 0.01611928f, 
    -0.05422401f, 0.03182532f, 0.04469962f, -0.03182525f, 0.03392247f, 0.01336264f, 0.00915888f, -0.02355711f, 
    -0.03437607f, 0.02396415f, -0.04007162f, -0.02884459f, -0.03559145f, -0.01585962f, 0.04422322f, 0.03913971f, 
    -0.00874084f, -0.03410678f, 0.03912892f, -0.02165021f, -0.00353115f, 0.01875924f, 0.03559023f, 0.01523313f, 
    -0.02106537f, -0.00299668f, -0.03200571f, -0.02610335f, -0.01638788f, 0.00208465f, -0.02412847f, -0.03910543f, 
    0.03976457f, -0.05331178f, 0.00427196f, 0.02426286f, 0.00046999f, -0.02111994f, 0.01577655f, 0.03195887f, 
    -0.00682043f, 0.01248772f, -0.03702010f, -0.01060636f, 0.03711968f, 0.03790820f, -0.02955578f, -0.01021531f, 
    -0.03501079f, -0.04610143f, 0.04632863f, -0.02885664f, 0.02756568f, 0.03709175f, 0.03693731f, 0.01301866f, 
    -0.03182985f, 0.02383902f, 0.00743918f, 0.03775363f, -0.01034140f, -0.01143993f, -0.05120603f, -0.03483973f, 
    0.02899949f, 0.01682264f, -0.05285343f, 0.02090833f, -0.03274073f, -0.02471533f, -0.04419505f, -0.01866177f, 
    0.01433514f, -0.03038193f, -0.03673491f, -0.04321039f, 0.00786778f, -0.04097231f, -0.00496558f, -0.00650511f, 
    0.03209740f, 0.01926441f, 0.00583710f, 0.02535029f, -0.00148152f, 0.02787133f, -0.01506755f, 0.04120253f, 
    -0.00190297f, 0.01068789f, -0.04982639f, -0.00883478f, -0.04149313f, 0.04482267f, -0.04001553f, 0.02658944f, 
    -0.05151759f, 0.02689845f, 0.02884643f, 0.00019752f, -0.03667656f, 0.01492703f, 0.00990776f, 0.00068778f, 
    -0.01070505f, -0.00383688f, -0.04208440f, 0.01631132f, -0.04215281f, 0.01087024f, -0.01637002f, 0.00361420f, 
    0.04468771f, -0.02610748f, -0.04515419f, 0.02116593f, -0.01446005f, 0.03554671f, -0.02583145f, 0.03906395f, 
    -0.00863953f, 0.03501979f, 0.01706745f, -0.02884447f, 0.00125915f, -0.03376110f, -0.02051913f, -0.00770222f, 
    -0.04816549f, 0.04514008f, 0.01811310f, 0.05065264f, 0.03922066f, -0.00410372f, -0.00557619f, 0.04453094f, 
    0.02540482f, 0.01079236f, 0.01044439f, -0.05172605f, 0.02225000f, -0.04126598f, -0.04209119f, -0.02358727f, 
    0.00937462f, -0.00103674f, 0.02072826f, 0.01499084f, -0.00907079f, -0.00208979f, -0.01424293f, 0.00262718f, 
    -0.05254425f, 0.01562015f, 0.01489994f, -0.03972479f, 0.04603286f, -0.04584187f, 0.02650770f, -0.05080302f, 
    0.00488119f, 0.02560589f, 0.03049459f, 0.00351455f, -0.04439373f, -0.00070429f, 0.02091239f, -0.04284798f, 
    -0.04206368f, -0.01390892f, -0.01671003f, 0.00244784f, -0.04368242f, 0.04757288f, 0.02306852f, 0.02237858f, 
    -0.01773578f, 0.00516266f, 0.04811122f, 0.03502803f, -0.03903520f, 0.02473278f, 0.00833696f, -0.00631938f, 
    -0.04028905f, -0.03703258f, -0.03435303f, 0.01418444f, -0.03331699f, -0.03762409f, 0.03587655f, -0.04731031f, 
    -0.02278291f, 0.03584575f, -0.03298915f, -0.01204127f, 0.04504026f, -0.04936041f, 0.04334455f, -0.03938289f, 
    0.00101142f, 0.01254710f, 0.00021102f, -0.00704677f, -0.03721680f, -0.02906693f, 0.01904290f, -0.04384783f, 
    -0.02113244f, 0.00486499f, -0.00519326f, -0.00163472f, 0.01140105f, 0.01307520f, 0.00234748f, 0.04424077f, 
    0.03174950f, 0.01189392f, 0.03792812f, -0.00531713f, -0.05601703f, 0.00617963f, -0.00659675f, 0.00349226f, 
    0.03657830f, 0.18130572f, 0.00931902f, 0.11574548f, -0.02913553f, 0.05993304f, -0.06873822f, -0.10571987f, 
    0.06396192f, -0.08833689f, 0.02471386f, 0.01170356f, 0.35160059f, 0.24813432f, -0.04610172f, 0.23859011f, 
    0.05179124f, 0.10217047f, -0.08175368f, 0.13978158f, -0.05964540f, 0.03463978f, -0.01376743f, 0.11222176f, 
    -0.18535976f, 0.10681749f, 0.03273677f, 0.00696346f, 0.05173320f, -0.04315548f, 0.01591213f, -0.03748384f, 
    -0.02640484f, 0.10991613f, 0.00905932f, -0.00792886f, 0.15486294f, -0.04991613f, 0.19598438f, 0.02986141f, 
    0.18669191f, 0.25125757f, 0.09244024f, 0.17919946f, -0.02012010f, 0.11417650f, 0.03735935f, 0.09114787f, 
    0.10303158f, 0.33769074f, 0.04689409f, -0.25745830f, 0.10944083f, -0.02007449f, -0.06109917f, -0.13021708f, 
    -0.04433552f, -0.02976047f, -0.01445262f, -0.08060656f, -0.00427144f, 0.05136796f, 0.18360563f, 0.15093891f, 
    -0.02340363f, 0.09604031f, 0.11876886f, 0.04167166f, 0.02334921f, 0.04981373f, -0.03313897f, 0.13116455f, 
    -0.14508636f, 0.19537643f, 0.20756683f, 0.06213937f, 0.03486786f, 0.00133156f, -0.05055153f, 0.08481744f, 
    0.04266211f, 0.13029158f, 0.08440480f, 0.01831382f, -0.09254703f, -0.10153852f, 0.15126210f, 0.02600484f, 
    -0.02985819f, 0.13334395f, 0.08845469f, -0.04360570f, 0.02134132f, -0.02142009f, 0.08737295f, 0.03962362f, 
    -0.13708360f, 0.05835394f, 0.01050855f, -0.04204822f, 0.14844051f, 0.07843286f, -0.01694008f, 0.00201721f, 
    0.10170128f, 0.02970312f, -0.04796888f, -0.07638173f, -0.07218299f, 0.01240121f, 0.03700392f, 0.03561777f, 
    -0.00890804f, -0.09522890f, 0.02429320f, -0.13615832f, 0.05180600f, -0.02478925f, -0.01926806f, -0.05915800f, 
    0.06786993f, -0.12400031f, -0.01997135f, 0.16771239f, 0.00956453f, 0.00937346f, -0.06412368f, 0.02475501f, 
    0.04231009f, 0.02520323f, 0.03427970f, 0.05172932f, 0.00025516f, -0.11396445f, 0.01991528f, 0.01784754f, 
    0.13399835f, 0.06572329f, 0.02431894f, 0.05935452f, 0.11673087f, 0.03544074f, 0.02627989f, 0.11808897f, 
    0.31683418f, 0.08545021f, -0.12646231f, -0.19332322f, 0.09668911f, 0.01476231f, -0.04083800f, -0.02068984f, 
    0.07392594f, 0.00005272f, 0.07500059f, 0.01724138f, 0.07879426f, 0.02797987f, -0.04181775f, -0.07686591f, 
    0.06352671f, 0.10784659f, 0.11474811f, -0.04953087f, 0.02287539f, 0.01469359f, 0.06777007f, 0.11854549f, 
    -0.15444104f, -0.12140016f, 0.10814200f, 0.03236898f, 0.01354362f, -0.03271245f, -0.05827533f, 0.03876741f, 
    0.03168081f, 0.01726925f, 0.04029957f, -0.01352409f, -0.10064614f, 0.01631488f, 0.02635772f, 0.02539352f, 
    0.10504302f, 0.01442171f, 0.07458514f, 0.05302854f, -0.04064091f, -0.04311392f, 0.00044167f, -0.00961221f, 
    0.11487085f, -0.07117144f, 0.16941912f, 0.03969281f, -0.03556454f, 0.05846124f, 0.03858187f, 0.01253811f, 
    0.02107572f, -0.01734330f, 0.04526060f, -0.02141959f, 0.15665467f, 0.17933930f, 0.07372446f, -0.00579219f, 
    -0.03470898f, 0.06693870f, 0.00985807f, -0.14889197f, -0.01290412f, 0.09691008f, 0.17395896f, 0.03984827f, 
    0.00618038f, 0.08582769f, 0.02007522f, -0.05920045f, 0.11603997f, 0.01500060f, 0.03664568f, -0.05134658f, 
    -0.04825640f, 0.03491893f, 0.10673117f, 0.01396239f, -0.06428058f, 0.10119315f, -0.19795319f, -0.07314950f, 
    0.06766720f, 0.03004710f, 0.04407303f, 0.05073912f, -0.07263947f, -0.04115131f, -0.03068262f, 0.00432660f, 
    0.20672847f, 0.30352327f, 0.12310702f, 0.19136918f, 0.05136786f, 0.10307120f, -0.04970151f, 0.14124213f, 
    0.08983520f, 0.14489056f, 0.09727053f, 0.07097659f, -0.08969066f, -0.14271921f, -0.00506587f, 0.32989442f, 
    0.03228241f, 0.05565396f, 0.14084685f, -0.03890565f, 0.06724804f, 0.20961531f, 0.02447961f, 0.04860973f, 
    0.31321648f, 0.03981664f, -0.06103095f, 0.02718138f, 0.00508913f, 0.09703727f, 0.00485208f, 0.07547328f, 
    0.00707179f, 0.05683904f, 0.09141369f, 0.03777420f, 0.04439925f, -0.10467107f, 0.03867844f, 0.02825091f, 
    0.04073528f, -0.04336832f, 0.01203860f, 0.02856753f, -0.02309502f, -0.04844992f, 0.01312466f, 0.04535027f, 
    0.29248095f, 0.08086966f, 0.06797727f, 0.25228488f, 0.08574346f, 0.07903765f, -0.00005604f, 0.04995988f, 
    0.00528340f, 0.09447756f, 0.04667407f, 0.18859507f, 0.28751442f, 0.27703306f, 0.08551418f, 0.16086148f, 
    0.08959110f, 0.10918612f, 0.04752521f, 0.15708417f, 0.00396893f, 0.01735438f, -0.04583732f, 0.18987907f, 
    -0.01591247f, 0.20156865f, 0.16973332f, 0.05551325f, 0.00542158f, -0.02440486f, 0.05724625f, 0.03378345f, 
    0.02931824f, 0.15824555f, 0.03217389f, -0.09371860f, -0.28558812f, 0.10520156f, 0.13123170f, -0.05636034f, 
    0.13808942f, -0.01086719f, 0.01948843f, -0.01614142f, 0.03656718f, -0.00651302f, 0.04696621f, -0.02647657f, 
    0.09933802f, 0.02772226f, 0.10549668f, -0.00397718f, 0.03641432f, 0.01546239f, 0.16325055f, -0.01705634f, 
    0.05667286f, -0.10181329f, -0.00774984f, -0.01466815f, -0.17176679f, 0.38672769f, 0.02913542f, 0.01610122f, 
    0.02306793f, 0.00346670f, 0.04306711f, -0.01925669f, -0.04873037f, 0.03129150f, 0.08296937f, 0.12629153f, 
    -0.17188449f, -0.12786697f, 0.14554903f, -0.02928182f, 0.06635722f, 0.00216528f, -0.06869653f, -0.05155051f, 
    0.02966957f, -0.08121350f, 0.08568071f, -0.07234178f, -0.01085530f, -0.00852607f, 0.14147310f, 0.18553261f, 
    0.11406697f, 0.01424432f, 0.05157454f, -0.06764708f, 0.10441728f, -0.07550602f, -0.05576715f, -0.02058209f, 
    0.00875937f, -0.05452383f, -0.00555034f, -0.01322528f, -0.04216716f, 0.01401364f, -0.04311754f, 0.02866062f, 
    -0.04846066f, 0.02381735f, 0.03916085f, 0.02360395f, 0.02499362f, -0.01177229f, -0.00559407f, 0.00914579f, 
    0.03872384f, 0.00805338f, 0.04934210f, -0.05677284f, 0.03430023f, -0.00696368f, 0.01498041f, 0.00082431f, 
    -0.03161134f, -0.04934345f, -0.04338507f, 0.02497872f, -0.03762326f, -0.01847811f, -0.00218737f, -0.03875089f, 
    -0.03430527f, 0.03271173f, -0.01498363f, -0.04746865f, -0.04137162f, -0.02835578f, 0.01099791f, -0.03085798f, 
    0.04059612f, 0.00375588f, -0.00557973f, -0.03967127f, 0.02327714f, -0.00943292f, -0.02539785f, 0.02456042f, 
    0.03785561f, 0.05288954f, -0.03608517f, 0.01920176f, -0.03674350f, -0.02648677f, -0.01558532f, -0.02237735f, 
    -0.00341662f, 0.03920034f, 0.02268033f, -0.04177754f, -0.01027447f, 0.02857411f, -0.05406546f, -0.05312884f, 
    -0.03668591f, 0.01360711f, 0.00454238f, -0.00926950f, -0.00053636f, 0.02783902f, 0.00003236f, 0.03822038f, 
    0.03243647f, 0.02589371f, -0.02695986f, -0.02821715f, -0.00730152f, 0.00243491f, -0.03189172f, 0.00595607f, 
    -0.03667997f, 0.03123774f, -0.00034028f, -0.03975732f, 0.02645427f, 0.03976521f, 0.01925270f, 0.01800875f, 
    0.01508118f, -0.04292606f, -0.00645264f, 0.04185055f, 0.02902190f, -0.04460806f, 0.00964680f, -0.04746591f, 
    -0.00739221f, 0.00135372f, 0.04153474f, -0.00399202f, -0.05527694f, 0.00841358f, -0.02312721f, 0.00510372f, 
    -0.05328247f, -0.01349181f, -0.05382966f, -0.05030965f, -0.01356330f, -0.05130074f, 0.01001150f, -0.04844211f, 
    -0.05227563f, -0.03302966f, -0.02919374f, 0.00543343f, -0.02948947f, -0.00183503f, 0.02515173f, -0.04363627f, 
    -0.03040694f, 0.02231972f, 0.00498793f, 0.01898281f, -0.05313804f, -0.02902934f, -0.04309900f, -0.02571994f, 
    -0.05379221f, 0.00259706f, -0.02190669f, 0.01802851f, -0.02033302f, 0.04095066f, -0.02166659f, 0.01598980f, 
    0.00885308f, 0.01460242f, -0.00576291f, -0.01026164f, 0.04181074f, 0.01874892f, -0.01465663f, -0.03007135f, 
    0.01887960f, -0.03217423f, -0.03558273f, 0.02942222f, 0.04121049f, -0.05017835f, 0.02661214f, -0.01536461f, 
    -0.03617435f, 0.03318822f, -0.01875411f, 0.04148270f, 0.00831319f, -0.05394982f, 0.03329949f, -0.00227558f, 
    -0.00809170f, -0.01732191f, 0.00161089f, 0.01767419f, -0.01325427f, 0.01624901f, -0.04621082f, 0.03215444f, 
    0.00336280f, 0.03923285f, -0.04632293f, 0.02272968f, 0.04282022f, -0.00201471f, 0.00387566f, -0.01499899f, 
    0.02263824f, -0.01822067f, -0.01762056f, -0.04093239f, 0.02479224f, -0.01313073f, -0.01761774f, 0.01814683f, 
    -0.01248944f, -0.03695304f, 0.01242372f, -0.04273553f, 0.04082218f, -0.04463772f, -0.02536320f, 0.01789968f, 
    0.04549812f, -0.05411751f, -0.03476629f, 0.03331184f, 0.04583301f, -0.02105031f, -0.00443597f, -0.04780786f, 
    0.01682034f, 0.02142676f, -0.00466153f, -0.00362335f, 0.05158334f, 0.02619410f, -0.04323027f, -0.01816237f, 
    -0.04543040f, 0.00035563f, -0.01579763f, 0.00140612f, 0.03398490f, 0.01785887f, -0.01321870f, 0.00070012f, 
    -0.04913698f, 0.02678230f, 0.02876759f, -0.03423372f, 0.02928786f, 0.00238582f, 0.03266528f, 0.02474904f, 
    0.00190988f, -0.03043137f, -0.03207594f, -0.04463133f, 0.00462039f, -0.03848644f, 0.02518743f, 0.02253957f, 
    0.04720005f, 0.03638475f, 0.03223087f, -0.01880771f, -0.00545268f, 0.04533763f, -0.01261094f, 0.03304783f, 
    -0.01468876f, 0.01233500f, -0.00018326f, 0.00591477f, -0.02177104f, 0.01852760f, -0.02707923f, 0.02525675f, 
    0.02570591f, 0.00566155f, -0.01409330f, -0.02235863f, -0.03614425f, 0.04086533f, -0.04405321f, -0.02435347f, 
    -0.03361617f, -0.03555794f, 0.01582370f, -0.03504203f, 0.03227953f, -0.02718802f, 0.04909397f, 0.02132863f, 
    -0.01216863f, 0.00350259f, 0.03673244f, -0.00901829f, -0.02075945f, -0.03098879f, -0.04386060f, 0.02096599f, 
    0.02812507f, -0.03080525f, 0.03043308f, 0.01452044f, -0.00610751f, 0.03676869f, -0.00193188f, -0.02145667f, 
    0.04071762f, 0.00938994f, -0.00524911f, -0.05035009f, -0.04265896f, -0.01633344f, -0.01142214f, 0.01680438f, 
    -0.00736966f, -0.05089257f, -0.02518398f, -0.02416950f, 0.03418796f, 0.01156656f, 0.03673519f, 0.04705867f, 
    -0.03721108f, -0.03482747f, -0.01667434f, -0.03361982f, 0.03465025f, -0.04967075f, 0.03519584f, 0.03342714f, 
    0.00498270f, -0.01064158f, 0.02482452f, 0.01897103f, -0.00621222f, -0.05062449f, -0.05688341f, -0.05083419f, 
    0.02635657f, -0.00836821f, 0.05669333f, 0.02590947f, 0.02311001f, -0.01788381f, -0.02810626f, -0.02158850f, 
    0.04595396f, -0.03560654f, -0.00727203f, 0.02558096f, 0.02782376f, 0.00930788f, 0.02122940f, 0.02073949f, 
    0.03506135f, 0.00661251f, 0.01512801f, 0.04249133f, 0.04183608f, -0.04363208f, -0.04520737f, -0.03940134f, 
    -0.00647405f, 0.03959502f, 0.03941348f, -0.03965679f, 0.01758105f, 0.00797729f, -0.05140280f, 0.01157305f, 
    -0.01247382f, -0.00389140f, 0.00630851f, 0.04979692f, -0.01535285f, -0.00109143f, -0.02311939f, -0.03354840f, 
    -0.03579507f, -0.04372512f, 0.00500941f, -0.05096466f, -0.03192293f, 0.00171978f, -0.04946279f, 0.02891379f, 
    -0.02298408f, -0.03041059f, -0.02110947f, -0.00266300f, -0.01189577f, 0.00969275f, -0.04528223f, -0.03735135f, 
    -0.05561540f, -0.00846313f, -0.03571688f, -0.04884205f, 0.01649952f, 0.02416621f, -0.03468965f, 0.02066316f, 
    -0.01231849f, 0.02365207f, 0.04531503f, 0.02680382f, -0.02838203f, -0.02329784f, -0.04906267f, -0.03206004f, 
    0.03497304f, 0.14505190f, -0.06702536f, 0.02239235f, 0.16926359f, -0.00501234f, 0.10303194f, -0.00778591f, 
    0.06266344f, 0.15767011f, -0.11231264f, -0.01940368f, 0.22935680f, 0.04101640f, 0.00335279f, -0.00436769f, 
    -0.02345927f, 0.03331355f, 0.13337253f, -0.03095523f, -0.05241103f, -0.07792249f, 0.05354111f, 0.02550696f, 
    0.13444522f, 0.21461692f, -0.00881312f, 0.08395302f, 0.00621610f, 0.11221495f, 0.02230506f, 0.00170266f, 
    0.03376877f, -0.01101535f, 0.08594956f, 0.00653253f, 0.09964345f, 0.18836272f, 0.04214589f, 0.17730044f, 
    -0.10639798f, -0.01225930f, 0.03443630f, -0.08725584f, -0.01417561f, -0.05598041f, 0.13609996f, -0.13492577f, 
    -0.22568266f, -0.01546298f, 0.02376077f, 0.01174432f, 0.13963857f, 0.01349122f, 0.00721698f, -0.03557315f, 
    0.03101917f, 0.06145240f, 0.05724205f, 0.04372557f, 0.15393004f, -0.07147400f, 0.04831709f, 0.01224779f, 
    0.00397794f, 0.02908385f, 0.00860218f, -0.06299285f, 0.06048837f, -0.13344625f, 0.07631513f, 0.24862806f, 
    0.27105314f, -0.31086734f, 0.00893912f, 0.03014510f, -0.07813142f, 0.04016289f, 0.15901107f, 0.10738920f, 
    0.01018505f, -0.01586635f, -0.03840465f, -0.07443085f, 0.47849232f, 0.08501078f, -0.04711446f, 0.29941449f, 
    -0.04942889f, -0.13185667f, 0.24883808f, 0.11300633f, -0.00306950f, -0.00899556f, 0.01249491f, 0.07653006f, 
    -0.24151151f, -0.16384788f, -0.21603730f, -0.15989493f, 0.05557350f, 0.05892975f, 0.01970570f, 0.05531669f, 
    -0.05336320f, -0.06859843f, 0.00431163f, -0.01363072f, -0.15261433f, 0.12688023f, 0.02331123f, 0.10456111f, 
    0.10725889f, 0.12794007f, 0.04280087f, 0.02520637f, -0.02612683f, -0.00870649f, -0.01546694f, 0.06525378f, 
    0.10119125f, 0.07820442f, -0.09973229f, -0.08867718f, 0.07289798f, 0.05072074f, -0.10073546f, 0.02180246f, 
    0.29515126f, 0.00697021f, -0.04248981f, -0.00348011f, 0.09409636f, 0.33990598f, -0.10263957f, 0.07030525f, 
    -0.00828273f, -0.05580509f, -0.06286164f, 0.10315274f, 0.07804205f, -0.00441993f, -0.04998976f, 0.12507837f, 
    -0.04398469f, -0.11824755f, -0.09692179f, -0.17525025f, 0.08128599f, -0.09572165f, -0.12035960f, 0.10132610f, 
    -0.00656026f, 0.11689132f, 0.13316549f, 0.00999134f, -0.03752798f, -0.16970812f, -0.11216160f, -0.22654569f, 
    0.13822578f, -0.07230879f, 0.11929072f, -0.00628352f, 0.01592872f, -0.01184024f, 0.08147860f, 0.13821922f, 
    0.01000456f, 0.04174067f, -0.14018650f, -0.10808001f, -0.02532074f, 0.01969025f, 0.00072464f, 0.04755076f, 
    0.01983566f, 0.12731344f, -0.19452950f, 0.13778526f, 0.16409236f, -0.01601657f, 0.05370604f, 0.03129593f, 
    0.12789617f, 0.09201229f, -0.02583139f, -0.00204789f, -0.11167744f, -0.11541852f, -0.04122584f, 0.00361282f, 
    -0.07359366f, -0.05858804f, -0.05567941f, -0.13575508f, 0.15781379f, 0.06358964f, -0.00348560f, -0.12968755f, 
    0.07242785f, 0.07657709f, -0.11577041f, 0.01359388f, 0.00813543f, -0.15403920f, -0.22639960f, 0.03436011f, 
    -0.00503161f, -0.03774013f, -0.07874443f, -0.00075053f, 0.13748811f, -0.04950016f, 0.01019183f, -0.06253684f, 
    -0.05501460f, -0.06586895f, -0.05753050f, 0.15648554f, 0.10279060f, -0.02193939f, 0.05393849f, -0.02700255f, 
    -0.01241486f, 0.07381073f, -0.00563427f, 0.03696973f, -0.12035194f, -0.16054873f, -0.13951673f, -0.11139828f, 
    0.10850594f, -0.12456115f, -0.10857403f, -0.00669421f, 0.11337063f, -0.06018638f, 0.01417078f, -0.07645071f, 
    -0.18505278f, 0.17034122f, -0.04498380f, 0.32458594f, -0.00966651f, -0.13329327f, 0.11632733f, -0.00401846f, 
    0.04290438f, 0.05214737f, -0.03995329f, 0.05002359f, -0.31968659f, -0.02549429f, 0.11221483f, 0.08864173f, 
    0.18260556f, 0.03711416f, 0.11578294f, 0.03307575f, -0.03967055f, -0.04143558f, 0.05617585f, -0.02581415f, 
    -0.20760526f, 0.14591336f, 0.12933485f, 0.07638882f, 0.01189310f, -0.00624913f, -0.13256483f, 0.02256090f, 
    -0.00210515f, 0.14067556f, -0.07645612f, -0.03493572f, 0.14800023f, -0.20440833f, -0.05335048f, 0.09025789f, 
    -0.04374963f, 0.19264898f, -0.07565639f, -0.01131029f, -0.07732115f, -0.14242746f, -0.01424459f, -0.02606552f, 
    0.11561852f, -0.00154301f, 0.06391728f, -0.15194333f, 0.08502092f, 0.03696184f, 0.00301934f, 0.17126964f, 
    0.09961854f, -0.06518684f, 0.00679844f, -0.01297203f, -0.11958138f, 0.03713681f, 0.07361443f, -0.11191807f, 
    -0.19726717f, 0.03543878f, 0.01427166f, 0.11377133f, 0.09409765f, 0.00495024f, 0.00286052f, 0.10324357f, 
    0.50033480f, 0.00197386f, -0.13160437f, -0.14842822f, -0.05738749f, 0.01518710f, 0.08636749f, 0.02059969f, 
    0.06791938f, 0.05875325f, 0.03579656f, 0.01551837f, 0.11492349f, 0.12433200f, -0.16493662f, -0.05674680f, 
    -0.07996678f, 0.08558129f, -0.06687994f, 0.02838662f, -0.11115125f, 0.04101172f, 0.20701541f, -0.04364385f, 
    -0.24464673f, 0.05006763f, -0.20621499f, 0.00430079f, 0.02514754f, -0.03717486f, 0.00202479f, 0.10810833f, 
    -0.06908461f, -0.09046927f, -0.06561179f, 0.12509000f, 0.21661253f, 0.01035658f, -0.03662920f, 0.09914923f, 
    0.12760323f, -0.12740164f, 0.00268646f, 0.04514660f, 0.13714978f, 0.00411224f, -0.04014880f, 0.05945344f, 
    0.14846545f, -0.02709669f, -0.13741417f, 0.08661801f, 0.09091608f, -0.03913501f, -0.00333350f, 0.02819215f, 
    0.02348296f, 0.19941822f, 0.07969765f, -0.04663956f, 0.23032881f, 0.10050728f, -0.03602257f, 0.08579204f, 
    0.06512183f, 0.15164740f, 0.06004946f, 0.08863455f, -0.01400414f, -0.04825822f, 0.01461329f, -0.10854603f, 
    -0.02177362f, -0.00137829f, 0.03590840f, -0.00841834f, -0.01956524f, -0.05107830f, 0.01543174f, 0.02299017f, 
    -0.01449920f, -0.03271410f, 0.00672169f, -0.04361437f, 0.03427434f, -0.02831135f, -0.02170346f, -0.03943487f, 
    -0.04226859f, 0.02886809f, -0.01254902f, -0.04068405f, 0.03004305f, 0.03895424f, -0.03756043f, -0.05230373f, 
    0.00503882f, -0.01656513f, 0.02895054f, -0.02532772f, -0.00968280f, -0.03524849f, 0.03178962f, -0.01856241f, 
    0.02224773f, -0.05402797f, -0.01210369f, 0.02403704f, 0.01507293f, -0.03266700f, -0.01482349f, 0.03168793f, 
    -0.02449017f, -0.02345186f, 0.00005851f, -0.00960348f, -0.05444981f, 0.04299523f, -0.05473352f, 0.02018462f, 
    0.03072791f, -0.01818855f, 0.02930953f, -0.01618437f, -0.02802986f, 0.04681047f, -0.03989746f, 0.00055593f, 
    -0.02763531f, -0.00926715f, 0.04324130f, -0.01863261f, -0.04476625f, -0.03351556f, -0.02470008f, -0.00251555f, 
    0.00157587f, 0.02070848f, -0.05322110f, 0.03788611f, -0.01810441f, 0.00594671f, -0.02955472f, -0.05566524f, 
    -0.02308035f, 0.02913517f, -0.01426214f, 0.01764240f, -0.02177374f, -0.03488275f, -0.00454429f, 0.01272875f, 
    0.00220432f, -0.04206747f, 0.00200209f, 0.00920238f, -0.01315602f, 0.01751942f, -0.00688080f, -0.01790867f, 
    -0.05512175f, -0.04525134f, 0.00146131f, 0.03882065f, 0.03296012f, -0.03574374f, 0.01692481f, 0.01276335f, 
    0.02719224f, 0.04435082f, 0.00202933f, 0.03993902f, -0.05842566f, 0.02471589f, 0.01467753f, 0.00958175f, 
    -0.01147253f, 0.03554720f, -0.01737472f, 0.01705571f, 0.02518544f, 0.03327915f, -0.03626407f, 0.02986692f, 
    -0.04747306f, -0.05270356f, 0.02885631f, -0.03491346f, -0.01503798f, 0.00024857f, 0.03178171f, 0.02098238f, 
    0.02192008f, -0.04401762f, -0.01472411f, 0.04117675f, -0.02877015f, -0.01719918f, -0.02871927f, -0.03845923f, 
    -0.04301582f, -0.03103122f, -0.01805784f, 0.01442465f, -0.03565147f, 0.01749381f, -0.04989109f, -0.03721442f, 
    0.03942739f, -0.03503236f, -0.00392289f, -0.05044934f, -0.01191160f, -0.01165274f, 0.00685760f, 0.00447073f, 
    -0.05423763f, 0.02007546f, 0.02959561f, -0.01875762f, 0.04305204f, 0.04488368f, -0.03728195f, -0.05410487f, 
    -0.03283957f, 0.02952795f, 0.02601674f, -0.03960409f, 0.01275859f, -0.03349673f, -0.00103497f, 0.03752790f, 
    0.01359192f, -0.00995098f, 0.03557064f, -0.01055444f, 0.00723213f, -0.01408419f, -0.00148577f, -0.03702818f, 
    0.02412446f, 0.01195161f, 0.01993316f, -0.03040952f, 0.00896139f, -0.01268131f, -0.03813999f, -0.01354117f, 
    0.00088444f, 0.01821812f, -0.01217307f, -0.01423012f, -0.02272574f, 0.05549774f, -0.05566049f, -0.03184053f, 
    0.01376310f, -0.02424527f, -0.05632726f, 0.02554863f, 0.03120197f, 0.02972330f, -0.03375459f, 0.00542527f, 
    -0.04734436f, 0.01585556f, 0.02698346f, -0.04982313f, 0.03808983f, 0.00936778f, -0.03463306f, -0.00156278f, 
    0.01118490f, -0.02889360f, 0.03274645f, -0.05769241f, 0.02442197f, -0.02643210f, 0.02547302f, 0.03838088f, 
    0.02122142f, -0.04544742f, -0.05278639f, 0.00090801f, 0.00086233f, -0.02030794f, 0.01909651f, 0.00663595f, 
    -0.03529165f, 0.01499179f, -0.00871577f, 0.04525870f, 0.03875151f, -0.03840232f, 0.02063783f, 0.01097879f, 
    -0.01896825f, 0.01905326f, -0.04371689f, 0.00586039f, -0.01763329f, 0.02843500f, -0.00644360f, -0.00428700f, 
    0.01416148f, 0.00712480f, -0.05190035f, -0.01556557f, 0.01118468f, -0.00514384f, -0.04183878f, -0.00836941f, 
    0.02285280f, -0.03420029f, -0.04836314f, 0.01420338f, -0.04715106f, 0.02968094f, -0.02075846f, -0.02815134f, 
    0.04058860f, -0.03836535f, -0.04314404f, 0.02656760f, -0.04424679f, 0.00883347f, 0.01125782f, -0.00972997f, 
    -0.05891749f, 0.02504753f, -0.00571506f, 0.00803524f, 0.04204953f, 0.00513672f, 0.00696903f, -0.00289902f, 
    0.01803385f, 0.04516723f, 0.00466669f, 0.03554426f, -0.03105981f, -0.01998129f, -0.01983444f, -0.03392156f, 
    -0.01473004f, -0.02669451f, 0.00612754f, 0.01052426f, -0.04592172f, 0.01336123f, 0.02543074f, 0.01388873f, 
    0.01327948f, 0.01576652f, 0.02333535f, -0.02027045f, 0.01652755f, -0.01223220f, -0.00981399f, -0.00473508f, 
    -0.02281915f, 0.01958732f, 0.01987463f, -0.01753238f, -0.05935685f, -0.01172251f, -0.02966790f, -0.02827149f, 
    -0.02024767f, -0.01915175f, -0.04958661f, 0.03553616f, -0.04970549f, 0.00442580f, 0.02545733f, -0.00836285f, 
    -0.01226991f, -0.04043636f, -0.02846494f, -0.02821606f, -0.00262005f, 0.03242360f, 0.03382649f, -0.02346495f, 
    -0.04676753f, 0.00054994f, 0.00409736f, -0.03309339f, 0.03127189f, -0.05538682f, -0.02007384f, -0.02559991f, 
    0.03644959f, -0.00742824f, -0.00337215f, -0.00124387f, -0.03202926f, -0.00622183f, 0.03529759f, 0.00938725f, 
    -0.01096422f, -0.05824484f, -0.03295747f, 0.02804978f, -0.04387011f, 0.00411354f, -0.00901465f, 0.01681869f, 
    0.02972191f, 0.04091143f, -0.01196181f, -0.04586177f, 0.02765277f, 0.00540688f, -0.01602889f, 0.02465693f, 
    0.02601642f, -0.00340422f, -0.00985875f, 0.03755523f, 0.04126324f, -0.01373815f, -0.02399071f, 0.01544335f, 
    -0.02587028f, -0.04233885f, -0.01444695f, 0.00948904f, 0.03522390f, -0.02175552f, -0.03386158f, -0.04984443f, 
    0.00054733f, -0.04213654f, 0.03809112f, 0.03630758f, 0.03160420f, -0.04288509f, -0.05454127f, 0.02321555f, 
    -0.01399180f, -0.05649091f, -0.01104420f, -0.03455400f, -0.05198624f, -0.04605060f, 0.00401002f, -0.05180836f, 
    -0.05121725f, 0.03790419f, 0.00166077f, 0.00708839f, 0.03221895f, -0.00682296f, 0.03495912f, -0.03058294f, 
    0.07650915f, 0.02037318f, -0.02239013f, -0.18627630f, 0.00212438f, 0.04069679f, 0.02915007f, 0.07426299f, 
    -0.00958930f, 0.14355025f, 0.02921134f, -0.04446811f, -0.05187105f, 0.09053180f, 0.03996179f, -0.07125787f, 
    -0.19872428f, 0.04943385f, 0.03774717f, -0.00753413f, 0.05367845f, 0.20745425f, -0.09370810f, -0.04944207f, 
    0.09569408f, 0.06964559f, 0.05967789f, -0.03825751f, -0.01159911f, 0.00069980f, -0.00695481f, 0.00886170f, 
    0.03217737f, -0.09126204f, -0.13720192f, -0.01731307f, 0.31767327f, -0.10312556f, 0.00772843f, -0.02352284f, 
    -0.01945308f, -0.01211000f, -0.06553937f, 0.03676922f, -0.02574590f, 0.03044027f, -0.02945930f, 0.06655229f, 
    0.48880878f, -0.40371743f, 0.15616842f, -0.05608504f, -0.03288317f, -0.05015699f, 0.10561486f, 0.04574976f, 
    -0.02180741f, 0.06230135f, -0.07669859f, 0.07099079f, 0.41759035f, 0.04086733f, -0.11484221f, 0.07289588f, 
    0.07236226f, -0.11537441f, 0.00551026f, 0.14113899f, -0.04596543f, 0.04051172f, -0.00349543f, 0.14652991f, 
    -0.11797065f, 0.32330379f, -0.20269296f, 0.05113143f, -0.08103161f, -0.07207015f, -0.07439053f, -0.06045178f, 
    0.10209354f, -0.04657429f, 0.03989356f, 0.04322400f, 0.35379660f, 0.00988170f, 0.08692495f, -0.03932067f, 
    0.00933167f, 0.00158538f, 0.07630718f, 0.06524049f, -0.00263786f, 0.03481617f, -0.01951077f, 0.01059753f, 
    0.20195962f, -0.12358773f, 0.10538186f, -0.07159580f, -0.14738357f, -0.04292151f, 0.01112657f, -0.09303049f, 
    0.06616067f, -0.06788646f, 0.00070082f, 0.02413737f, -0.02414853f, 0.09493560f, 0.09528395f, -0.00171876f, 
    0.02883581f, 0.04776556f, -0.07768080f, 0.08344956f, 0.02749308f, -0.04641700f, 0.08404998f, 0.04045303f, 
    -0.14045244f, -0.05145655f, -0.00116619f, 0.15707956f, 0.04581865f, 0.02742478f, 0.08302899f, -0.04697343f, 
    -0.05370964f, 0.08725825f, 0.10572808f, 0.05174706f, 0.09245294f, -0.00856670f, 0.13280906f, -0.04450028f, 
    -0.07553425f, 0.01846643f, -0.09515934f, -0.06785014f, -0.07633463f, 0.00538208f, -0.01218902f, -0.05656293f, 
    -0.24809383f, 0.01814551f, 0.06603450f, 0.09812113f, -0.05359657f, -0.00528604f, 0.16545884f, -0.05392194f, 
    0.05082442f, 0.15213643f, -0.00374858f, 0.11766793f, 0.02886976f, -0.01221196f, 0.19058149f, 0.00596492f, 
    -0.08123615f, 0.01681465f, -0.12646301f, -0.00653953f, 0.07132532f, 0.08639652f, 0.04088786f, 0.00240034f, 
    0.08002298f, 0.14830981f, 0.00051246f, 0.02961063f, 0.04575718f, 0.05640197f, 0.03976173f, -0.03337562f, 
    0.12235442f, -0.11851860f, 0.12712589f, 0.06863614f, -0.09334137f, 0.26512122f, -0.12592745f, -0.00419705f, 
    -0.09803295f, -0.00015725f, 0.03143014f, -0.05194428f, -0.11607041f, 0.08882623f, 0.03192484f, -0.02712431f, 
    -0.24464843f, -0.18313560f, -0.01463712f, 0.10287207f, 0.03461134f, 0.03470280f, -0.02720465f, 0.03469895f, 
    0.08629387f, -0.02406884f, 0.02684694f, 0.21277930f, -0.01288867f, -0.06408518f, -0.03090764f, 0.03271014f, 
    -0.13103674f, -0.07229996f, 0.02147629f, -0.06177035f, -0.00826605f, 0.13504238f, -0.07208813f, 0.04736423f, 
    0.37138066f, -0.24723735f, 0.07254910f, 0.01773456f, -0.10497163f, -0.06168432f, 0.01654734f, 0.15181111f, 
    0.03820626f, -0.01109346f, 0.08895255f, 0.13340624f, -0.20625752f, -0.06193306f, 0.23381065f, 0.21315171f, 
    -0.03224162f, -0.01383710f, 0.05171746f, -0.09213085f, 0.11401915f, 0.01384163f, 0.02407366f, -0.01784299f, 
    0.01560957f, -0.23570500f, -0.02338551f, -0.14787151f, -0.14561538f, -0.00060591f, 0.11814757f, 0.03876409f, 
    -0.01169820f, 0.01779438f, 0.12990807f, -0.01369103f, 0.17944291f, -0.04770229f, -0.01840866f, 0.00269679f, 
    -0.04646751f, -0.09787843f, -0.07033916f, -0.05148301f, -0.02478376f, -0.00080611f, 0.01833445f, 0.13685426f, 
    -0.28090861f, -0.08048625f, -0.06130154f, -0.01116579f, 0.02424158f, 0.04158926f, 0.04639614f, -0.01361714f, 
    0.10968493f, 0.10913990f, 0.00553906f, 0.07293610f, 0.13310663f, -0.06256565f, -0.02077432f, 0.20629044f, 
    0.08920699f, 0.07786265f, 0.08258166f, -0.01309933f, -0.03621182f, 0.05257753f, -0.03137086f, 0.02363154f, 
    0.03921444f, -0.10523985f, 0.04973176f, -0.11365644f, -0.04408200f, -0.01576366f, 0.06872827f, 0.09829807f, 
    0.03822062f, 0.01649906f, 0.03799405f, 0.02039125f, 0.07174124f, 0.16040494f, 0.11117504f, 0.09541951f, 
    0.08369324f, -0.02531378f, 0.13755620f, 0.10771693f, 0.06635418f, -0.03592838f, 0.09588081f, 0.03231593f, 
    0.15675937f, 0.15739806f, 0.10687497f, 0.10581538f, 0.00078509f, 0.01008010f, -0.02078923f, -0.02965853f, 
    0.13695405f, -0.00490566f, 0.12291886f, 0.20336296f, 0.21232015f, -0.04509430f, -0.05558759f, -0.04932340f, 
    0.02046242f, 0.00455829f, -0.00301611f, 0.09542871f, -0.05104730f, 0.12544535f, 0.05402863f, 0.13502176f, 
    -0.10768808f, 0.07678454f, 0.06491688f, -0.10657480f, -0.05596313f, -0.02148867f, -0.06370717f, -0.02931344f, 
    -0.04373286f, -0.00210673f, 0.08138403f, -0.02275701f, 0.30993852f, -0.19739842f, -0.08119992f, 0.00046416f, 
    -0.03859498f, 0.07234714f, 0.03374951f, 0.01560695f, 0.16453920f, 0.02781276f, 0.01212561f, -0.03644197f, 
    -0.09375081f, 0.02686786f, -0.05945894f, -0.09054077f, 0.04758098f, 0.06211637f, 0.03885829f, -0.05904421f, 
    0.02987983f, 0.05560164f, 0.00283487f, 0.09606291f, 0.22428705f, 0.21122470f, 0.03391965f, 0.02704725f, 
    0.04104035f, -0.00392298f, -0.01401452f, 0.01386407f, 0.01511086f, 0.10653377f, 0.01336352f, 0.10397704f, 
    -0.22828773f, 0.28344327f, -0.05804760f, 0.13330783f, -0.03994884f, -0.06474519f, -0.09830458f, -0.05798014f, 
    0.17151077f, -0.08368687f, 0.08179772f, 0.02982494f, 0.24815471f, 0.10196804f, -0.18072805f, 0.06127039f, 
    -0.00028772f, 0.08939876f, -0.06686025f, 0.07619030f, -0.09253559f, 0.07692437f, 0.12131999f, 0.02291289f, 
    -0.04923176f, 0.19095729f, -0.00096975f, 0.00862676f, 0.09405401f, -0.04394671f, 0.05281271f, 0.02753795f, 
    0.03643395f, 0.05311965f, 0.02531119f, 0.10308332f, -0.10642347f, 0.06683955f, 0.01284058f, -0.01644855f, 
    0.06101128f, 0.11735359f, 0.06262972f, 0.01482971f, 0.06947652f, 0.15045467f, -0.03186405f, 0.07201461f, 
    -0.20769313f, 0.19148260f, 0.25056335f, -0.24697325f, 0.13133241f, 0.04466961f, 0.00598811f, -0.05714952f, 
    0.03473254f, -0.04191991f, -0.01211508f, -0.11817068f, 0.01081774f, -0.18051946f, 0.14616609f, 0.07001545f, 
    0.07595181f, -0.01348190f, 0.08189145f, 0.09573864f, -0.03501070f, 0.13392220f, 0.17891951f, -0.02248733f, 
    -0.08773200f, 0.24915384f, 0.03866239f, 0.31710246f, 0.04364135f, 0.08943202f, -0.08889467f, 0.03374302f, 
    0.00574077f, 0.05434649f, 0.03156191f, 0.13387120f, -0.33745930f, -0.10137617f, 0.15642664f, -0.07224897f, 
    -0.01867064f, 0.04380030f, 0.05600854f, -0.09001575f, 0.03733382f, -0.03066534f, 0.09489818f, -0.01644248f, 
    -0.19656153f, -0.10105836f, 0.02911017f, -0.07574451f, 0.11175480f, -0.04820500f, -0.08046135f, 0.08510091f, 
    -0.01944225f, -0.04089320f, -0.03664621f, -0.04585721f, 0.04032779f, 0.17122158f, 0.18985052f, -0.05714507f, 
    -0.01864153f, 0.00566258f, 0.05768033f, 0.03895912f, -0.07074827f, -0.01314810f, 0.01509386f, 0.00405936f, 
    -0.12934305f, -0.04808507f, -0.10167573f, 0.19953372f, 0.06819367f, 0.09224067f, -0.13090883f, -0.04103426f, 
    0.03906845f, 0.04265000f, 0.12873234f, 0.04538152f, -0.04728273f, -0.20974115f, 0.11918148f, -0.01626886f, 
    0.10253868f, -0.04331008f, 0.08131826f, 0.07957475f, 0.08782080f, 0.05622346f, 0.04031080f, 0.06785280f, 
    0.06351648f, -0.03626711f, -0.11439386f, -0.20855367f, 0.13990538f, 0.00346088f, -0.03363167f, -0.10574802f, 
    0.01470729f, 0.01453610f, -0.08542605f, 0.12721775f, -0.11067110f, -0.03143635f, 0.01434735f, -0.06884038f, 
    0.02579000f, 0.02103470f, -0.02387266f, -0.03848476f, -0.12606999f, -0.05638127f, 0.02034264f, 0.15063754f, 
    -0.15665001f, -0.03794998f, 0.01254076f, -0.13083124f, 0.14259173f, -0.03527239f, -0.07582652f, 0.09517214f, 
    0.10863794f, 0.00013130f, 0.13184254f, -0.06643531f, -0.06552079f, 0.02131428f, -0.10398730f, 0.15419714f, 
    0.08794881f, -0.04691847f, 0.11714680f, 0.15413938f, -0.01182690f, 0.01865631f, -0.02458524f, 0.02986556f, 
    0.14050755f, -0.12770259f, 0.21700643f, -0.01862227f, 0.03455947f, -0.03004744f, 0.00861669f, -0.02495604f, 
    -0.00251001f, -0.00101130f, 0.03187771f, -0.00299282f, -0.16379754f, -0.06275059f, 0.02407137f, -0.11927934f, 
    0.02810081f, -0.08696888f, 0.10541824f, -0.02616549f, -0.04118450f, 0.06633288f, 0.05995477f, 0.19277392f, 
    -0.11693665f, -0.02428611f, -0.03011017f, -0.20632471f, 0.09619436f, -0.09088217f, 0.04548346f, 0.08079022f, 
    0.07033432f, -0.08336934f, -0.01262325f, -0.07145416f, 0.03807598f, -0.04876084f, -0.11059669f, 0.02018941f, 
    0.06710131f, 0.05069768f, 0.04892087f, -0.02522805f, 0.12089934f, -0.06441817f, 0.07584748f, 0.00999069f, 
    -0.18269046f, 0.34957045f, -0.07534461f, 0.16932724f, -0.09069742f, 0.08060540f, 0.00210213f, -0.00595690f, 
    0.14003518f, 0.04174954f, 0.01463110f, 0.01286172f, -0.34141624f, -0.01179327f, -0.11194120f, 0.35971341f, 
    -0.02110084f, 0.08566183f, 0.02584236f, 0.00473285f, 0.21248116f, 0.12696765f, 0.04864722f, 0.09202138f, 
    -0.01930672f, -0.00179398f, -0.04766732f, 0.02619360f, -0.09225818f, -0.04546627f, 0.08207861f, 0.11677641f, 
    -0.04815813f, -0.06988759f, 0.05499723f, 0.09618632f, -0.03400416f, -0.24079840f, 0.10562975f, 0.08340470f, 
    0.10080013f, -0.05304099f, -0.01826354f, 0.12165857f, 0.03088237f, 0.01379046f, 0.04324863f, -0.01608888f, 
    0.07356972f, -0.06474254f, 0.04607147f, -0.01879637f, -0.00539852f, -0.01963779f, 0.04845912f, -0.00380728f, 
    -0.00881696f, 0.11283892f, -0.04912522f, 0.08041154f, 0.13163604f, 0.21660696f, -0.13240808f, 0.05889293f, 
    0.00691496f, 0.08560130f, -0.00892557f, -0.01755556f, -0.01784276f, -0.08544514f, 0.10089503f, 0.08094052f, 
    0.00907276f, 0.15532249f, 0.27197713f, -0.23062265f, -0.04835909f, 0.00224817f, 0.04647231f, -0.06628795f, 
    -0.05433002f, 0.10098263f, 0.02306515f, 0.01764082f, 0.08426494f, 0.09832322f, 0.07308318f, -0.17240128f, 
    0.16894080f, -0.04570263f, -0.09450673f, 0.07117634f, 0.06807143f, 0.04753610f, -0.12331112f, -0.02239168f, 
    -0.18809731f, -0.05507463f, 0.15905501f, -0.12184312f, 0.12220485f, -0.10892227f, 0.01799087f, 0.04891979f, 
    0.05018144f, 0.01605385f, 0.05513520f, 0.01426383f, -0.00468064f, 0.06526127f, 0.04319525f, -0.11333901f, 
    0.10780576f, -0.03815611f, 0.09588442f, 0.02760394f, 0.06057755f, -0.00497555f, 0.07274006f, 0.12076207f, 
    -0.23338757f, -0.10862697f, -0.10391725f, 0.01801587f, 0.14244623f, 0.07001361f, -0.04528289f, -0.05170641f, 
    0.02220478f, -0.02789498f, 0.07586918f, 0.01684393f, -0.10542586f, 0.24146314f, 0.01488478f, 0.07188906f, 
    -0.00603563f, -0.03123405f, 0.19088534f, 0.05716322f, -0.01918389f, 0.04536432f, -0.08419849f, 0.09001141f, 
    0.02973087f, -0.27956554f, 0.09475731f, 0.00935504f, 0.00842359f, 0.02105003f, 0.11332413f, 0.11981947f, 
    -0.11666402f, 0.05969356f, 0.06763519f, 0.08382875f, -0.22185247f, -0.22127654f, 0.08944279f, -0.07055937f, 
    0.27074283f, -0.06829943f, 0.08232161f, -0.01970660f, 0.06582003f, -0.05003347f, 0.03120400f, 0.09542858f, 
    -0.30563864f, -0.15382431f, -0.04626227f, -0.02220567f, 0.00218935f, -0.00445430f, -0.02903364f, 0.09011735f, 
    0.05791859f, 0.09427311f, 0.08053721f, 0.04676254f, -0.42195413f, -0.15586337f, -0.13911827f, -0.10143802f, 
    0.06631253f, -0.00811506f, 0.09262574f, 0.00928877f, 0.13270544f, -0.03519981f, 0.02941248f, 0.06425317f, 
    0.11271468f, 0.11021055f, 0.00080184f, 0.32086393f, -0.00063678f, 0.04099393f, -0.01326366f, 0.00068434f, 
    0.01091092f, -0.00163717f, 0.01928020f, 0.05923624f, -0.39581701f, 0.05702342f, 0.05966476f, -0.03533189f, 
    0.06757526f, 0.09322181f, 0.04656626f, -0.01264554f, 0.13318402f, -0.03033525f, 0.02588256f, -0.04093274f, 
    0.21560013f, -0.13729019f, 0.10840397f, -0.11858781f, 0.01425557f, 0.09731136f, 0.07996820f, -0.01461831f, 
    0.06338425f, 0.07571230f, -0.00245568f, 0.08308709f, -0.23932686f, 0.05524029f, -0.23796013f, -0.10894516f, 
    0.20732597f, 0.10149167f, -0.06688561f, 0.02955283f, 0.01177645f, 0.03605145f, 0.00948344f, 0.07163350f, 
    0.14766584f, 0.19425274f, 0.06384834f, 0.23753881f, -0.02570862f, 0.04097692f, 0.08054934f, 0.07486269f, 
    0.01846961f, 0.10420773f, 0.04806073f, 0.15816259f, -0.03762317f, -0.16062628f, -0.08728959f, 0.03226520f, 
    0.13742110f, -0.04267872f, 0.05169361f, 0.09396200f, 0.11654542f, 0.07736932f, -0.02524793f, 0.02188297f, 
    0.27534261f, 0.15874894f, 0.19470409f, -0.03402410f, -0.02024285f, -0.06620437f, 0.05253766f, 0.06379355f, 
    -0.01195054f, -0.02089224f, -0.05625774f, 0.16099054f, -0.25658479f, 0.13748640f, -0.02721234f, 0.07156827f, 
    0.03806866f, 0.02689158f, 0.13134821f, 0.06823914f, 0.00739667f, 0.07364082f, 0.06761892f, -0.01110509f, 
    0.16826570f, 0.11588675f, 0.15947625f, 0.33804920f, -0.07003886f, 0.08785114f, 0.04956904f, 0.02771091f, 
    0.11028612f, -0.05212737f, -0.04324066f, -0.02697138f, 0.17606503f, 0.18679196f, 0.11952391f, 0.24084879f, 
    -0.00414668f, -0.03601772f, 0.02516632f, 0.13473523f, 0.05050922f, 0.09371742f, 0.02051500f, -0.11334157f, 
    0.20877090f, 0.09306455f, 0.19382846f, 0.25044677f, -0.09230736f, 0.07405134f, 0.06670767f, 0.04106013f, 
    0.02482193f, 0.05070604f, -0.00821612f, 0.01745463f, 0.12578773f, -0.20008661f, 0.02105585f, -0.10289160f, 
    0.09294315f, -0.01429529f, -0.05708636f, -0.06120452f, 0.19206583f, 0.01327600f, 0.09461933f, 0.08396342f, 
    0.24263601f, 0.35165063f, -0.02908234f, 0.10851288f, -0.02937213f, -0.08483064f, 0.03251209f, 0.14383397f, 
    -0.05551956f, 0.00554453f, 0.16873486f, 0.02627472f, 0.28670138f, 0.17286463f, 0.14784595f, 0.10476390f, 
    0.12904820f, 0.06076884f, 0.03109011f, 0.12624274f, 0.08236417f, 0.06456381f, -0.01901810f, -0.11587053f, 
    -0.26574221f, 0.33856332f, 0.10491993f, 0.05063042f, 0.01299504f, 0.11770660f, 0.05760345f, 0.06896199f, 
    -0.05041463f, 0.05962531f, 0.08613960f, -0.02611822f, 0.25294253f, 0.21725348f, 0.15223153f, 0.08529355f, 
    -0.13016124f, 0.09916707f, 0.06566294f, 0.08223524f, -0.08652312f, 0.10786112f, 0.03305360f, 0.09160072f, 
    0.01617957f, -0.25692528f, -0.08181098f, -0.18133409f, 0.13639435f, 0.07159191f, -0.01570922f, -0.02970868f, 
    0.02272785f, -0.01714509f, 0.04779961f, 0.05484382f, 0.26873556f, 0.16010088f, 0.08414757f, -0.20050290f, 
    -0.08583974f, 0.14169122f, -0.03181804f, 0.10645726f, 0.01799125f, -0.04768768f, 0.02770524f, 0.01033092f, 
    0.14878443f, -0.00120045f, 0.03082060f, -0.11419275f, 0.15729922f, -0.05490676f, 0.02246565f, -0.04262026f, 
    0.00432513f, -0.05889450f, 0.00640282f, 0.03473808f, -0.18367292f, 0.32610884f, 0.09325968f, -0.13400972f, 
    -0.10362056f, -0.07268771f, -0.00791716f, 0.01300197f, 0.11687609f, 0.09021699f, 0.07662218f, 0.08577505f, 
    -0.25086471f, 0.09560125f, -0.12031908f, 0.11016510f, 0.06697159f, 0.07025068f, -0.02165333f, -0.02596912f, 
    -0.01418884f, 0.07406705f, 0.09509497f, -0.02908260f, -0.01104381f, -0.24609576f, 0.02752201f, 0.09967396f, 
    0.07472640f, -0.00109901f, 0.12667032f, 0.06431208f, -0.01382719f, 0.05108064f, 0.05033280f, -0.09713483f, 
    -0.22418253f, -0.18484150f, -0.27529293f, 0.14053398f, 0.14801343f, 0.12799919f, 0.09020431f, 0.13510196f, 
    -0.02687857f, -0.09168172f, -0.06070603f, 0.05757277f, -0.09674037f, 0.01499275f, 0.17036861f, 0.15976751f, 
    0.02588575f, -0.05716685f, 0.09248050f, -0.03873211f, 0.09972587f, -0.04783078f, -0.11690529f, -0.01577939f, 
    0.36370263f, 0.14061224f, 0.13836539f, 0.19572368f, 0.01552149f, 0.11488425f, 0.04899579f, 0.00686334f, 
    0.09431032f, 0.10987076f, 0.09521049f, 0.00290258f, -0.04473192f, 0.05552322f, 0.12407449f, 0.11853485f, 
    -0.09170267f, 0.09468654f, 0.02674523f, 0.07020017f, -0.01009777f, 0.04486075f, 0.06637196f, 0.02530656f, 
    0.23071802f, 0.09860374f, 0.24687164f, 0.14957115f, -0.11785684f, -0.08606156f, 0.01151784f, 0.06539995f, 
    0.01941916f, -0.08882508f, 0.02402639f, 0.08958379f, -0.34067103f, -0.19595261f, -0.02533407f, 0.01783593f, 
    0.05304578f, 0.05169649f, 0.06268403f, 0.09470369f, -0.00749751f, 0.02226211f, 0.02724043f, 0.14298673f, 
    0.04262325f, -0.01490107f, -0.05097731f, -0.03255683f, -0.02608443f, -0.04730533f, 0.00542111f, -0.05342761f, 
    -0.05697411f, -0.00487542f, -0.04579776f, -0.05391526f, -0.00942218f, 0.04583113f, -0.04683418f, -0.03741239f, 
    -0.04933333f, 0.01357887f, -0.02823141f, 0.00096403f, -0.05910297f, -0.03383592f, 0.01603964f, 0.03319123f, 
    0.01175190f, 0.02561651f, -0.02958080f, -0.04610418f, 0.02744412f, -0.01677028f, 0.03238365f, 0.01713584f, 
    -0.05362141f, -0.03335042f, -0.02599489f, -0.03854828f, -0.02453647f, -0.01234916f, -0.01133609f, -0.03346818f, 
    0.00864171f, -0.00840632f, -0.01089694f, 0.01537364f, -0.01182384f, -0.00462413f, 0.01364940f, -0.00442640f, 
    -0.01194667f, 0.02771719f, -0.04912281f, -0.01166204f, -0.04467442f, -0.04217095f, 0.01614246f, 0.04118940f, 
    -0.01472836f, 0.00962493f, 0.01236847f, -0.02004818f, 0.02902141f, -0.02630130f, 0.04755737f, -0.05082295f, 
    -0.03361892f, 0.03478319f, -0.03762958f, 0.01629024f, -0.05553156f, 0.02374131f, 0.01485518f, 0.03759904f, 
    0.02790108f, -0.00404489f, 0.00042297f, -0.00846850f, 0.03973923f, 0.02790200f, 0.00444264f, 0.02278962f, 
    0.03838778f, -0.04096664f, -0.02895418f, 0.01995196f, 0.04095314f, -0.03776378f, -0.04718713f, 0.02279217f, 
    0.04106056f, -0.04176429f, -0.05841112f, -0.00618785f, -0.00041974f, -0.04298942f, -0.04249581f, -0.02068584f, 
    0.03160850f, -0.03178753f, 0.03048866f, -0.04738365f, -0.02015999f, -0.05878993f, 0.04084913f, -0.00768082f, 
    -0.00973361f, -0.00409094f, -0.04577968f, 0.01852335f, 0.02984232f, 0.03144033f, 0.00406530f, 0.04063565f, 
    -0.01458666f, -0.03691280f, 0.03378526f, -0.03337952f, -0.04818549f, 0.02737372f, -0.00318549f, 0.02226317f, 
    -0.00735881f, -0.05367058f, -0.00403167f, -0.01150830f, 0.01611998f, -0.05360785f, -0.04129051f, -0.03072009f, 
    0.02301827f, 0.03548701f, 0.00909926f, -0.00530454f, 0.02447920f, -0.02118541f, -0.01894163f, -0.02200862f, 
    0.00394862f, 0.04094598f, 0.01174151f, 0.03719837f, -0.04259770f, 0.02630121f, -0.00502881f, 0.00482067f, 
    -0.04573944f, -0.01969485f, 0.03872717f, -0.00695880f, -0.01307646f, -0.03865822f, 0.02247100f, 0.02662351f, 
    0.04095031f, 0.01472034f, 0.01130234f, -0.00997468f, -0.03737975f, -0.03021550f, -0.04245075f, -0.03250006f, 
    -0.02689170f, 0.02686381f, 0.01342480f, -0.04043587f, 0.00020468f, 0.03986295f, -0.00793258f, -0.02848327f, 
    0.01565270f, 0.03127935f, -0.02510319f, 0.01140907f, 0.02092787f, 0.03496779f, -0.00575351f, -0.04824327f, 
    0.01501947f, -0.00246461f, -0.01114157f, -0.00711504f, 0.03880142f, -0.02482628f, 0.02372401f, 0.03084188f, 
    0.03683375f, 0.00783382f, -0.04965597f, -0.01412749f, 0.02712963f, 0.03346426f, -0.02061480f, -0.05008410f, 
    -0.04345097f, 0.02308807f, 0.03574529f, 0.00216715f, -0.05409950f, -0.03539521f, 0.03813836f, -0.01884976f, 
    0.00404741f, -0.01082435f, 0.03194484f, 0.01349442f, 0.02518166f, 0.02496976f, -0.02196442f, -0.00137972f, 
    0.01221735f, -0.04390111f, -0.01740295f, 0.00325467f, 0.03574394f, 0.01799398f, 0.00588315f, -0.02053531f, 
    -0.05184735f, -0.01496599f, -0.04196081f, -0.04937940f, 0.00273305f, 0.00413025f, 0.03291728f, -0.04192455f, 
    -0.03131995f, -0.03979516f, -0.05022919f, 0.02258922f, 0.01116322f, -0.00678365f, -0.04301148f, -0.05531212f, 
    -0.05797595f, 0.03274736f, 0.02643951f, 0.02561296f, -0.05151899f, -0.01105260f, 0.03319134f, 0.01266093f, 
    0.01625858f, 0.01208597f, 0.01917888f, 0.03994228f, -0.00865100f, 0.03178743f, -0.04754618f, 0.04066349f, 
    0.00588204f, -0.01214870f, -0.01304419f, -0.01972254f, 0.00788455f, -0.05024775f, -0.03021800f, 0.02781891f, 
    -0.04234496f, 0.04483486f, -0.02162817f, -0.02330578f, 0.04020608f, -0.05534792f, -0.04318610f, 0.04105043f, 
    0.02695588f, -0.04623470f, -0.04144824f, -0.01820695f, 0.02131656f, 0.01468470f, -0.00996920f, 0.00582115f, 
    0.00081282f, 0.02663514f, -0.01828698f, 0.03971334f, 0.01443541f, -0.04377393f, -0.03610095f, 0.00841663f, 
    -0.02895301f, -0.04673003f, -0.04307840f, -0.05792364f, 0.00248835f, 0.01795160f, 0.02028552f, -0.03431960f, 
    0.00590986f, 0.00297344f, -0.01923449f, 0.01180996f, -0.03739712f, -0.00017808f, -0.00591093f, 0.04220579f, 
    -0.05912812f, 0.01891759f, -0.01698554f, 0.03931499f, -0.04517250f, 0.04558640f, -0.01154767f, -0.01373871f, 
    -0.01131730f, -0.05663054f, -0.01819436f, -0.01847306f, -0.04412734f, 0.03932364f, -0.04733503f, -0.00389129f, 
    -0.03550704f, 0.05728009f, -0.03971928f, -0.05349721f, 0.02445566f, -0.02081130f, 0.00620721f, -0.01280588f, 
    0.03957764f, -0.03331256f, 0.03338361f, -0.02058753f, -0.04879672f, -0.00657972f, -0.02094222f, -0.01597525f, 
    -0.00550367f, -0.00480375f, 0.03511586f, 0.03105068f, -0.05579463f, 0.00118632f, 0.01364738f, -0.05375431f, 
    -0.05842930f, -0.00572994f, -0.01658077f, 0.02465057f, -0.00745562f, -0.02723780f, 0.01878937f, -0.02514447f, 
    -0.01710710f, 0.02973766f, -0.03233979f, -0.01738651f, -0.01194705f, -0.02812748f, -0.01048066f, 0.00981669f, 
    0.04073283f, 0.02289086f, -0.03972929f, -0.03093164f, 0.00860208f, -0.03344557f, -0.02648358f, 0.01728451f, 
    -0.04351743f, -0.01865013f, -0.02669329f, -0.05030428f, 0.03916464f, -0.03612526f, 0.02577966f, 0.01441660f, 
    0.00071907f, -0.02600123f, -0.05441353f, -0.01179307f, 0.02243094f, -0.04374188f, 0.04088174f, -0.00866303f, 
    0.03591098f, -0.02075093f, 0.00962898f, 0.02264225f, -0.00605225f, 0.03315825f, -0.03205199f, -0.00601172f, 
    -0.00206689f, -0.03719881f, -0.04430531f, -0.00548200f, -0.00741839f, 0.03864534f, -0.00555973f, 0.04294069f, 
    0.02283641f, -0.05547181f, 0.03046782f, 0.00808676f, 0.00033198f, -0.02938742f, 0.02169405f, -0.03249888f, 
    0.03189348f, 0.02892975f, -0.02333350f, -0.05036078f, -0.00849103f, -0.05182482f, 0.00774556f, -0.03056602f, 
    -0.01147151f, 0.03363683f, 0.03105913f, 0.02363447f, 0.02591837f, 0.02294861f, 0.03494258f, -0.01804592f, 
    -0.06007878f, 0.01132942f, -0.04144340f, -0.02706028f, 0.01025925f, -0.04859557f, -0.05680921f, 0.04568972f, 
    -0.02785353f, 0.03040670f, 0.00071804f, -0.02143507f, -0.04088162f, 0.02062098f, -0.02685908f, -0.01563152f, 
    0.03925134f, -0.01456904f, -0.00073971f, 0.03609809f, 0.04499404f, -0.04033689f, -0.01173149f, -0.01575432f, 
    0.00819862f, -0.01512428f, 0.02671794f, -0.02937764f, 0.00676140f, -0.03448780f, 0.03237255f, -0.01328314f, 
    -0.03216974f, 0.00794044f, 0.01263551f, -0.00643848f, -0.01115490f, 0.00689940f, 0.02346542f, 0.05254951f, 
    -0.04745471f, 0.02120223f, -0.04780562f, 0.01774917f, -0.02206892f, -0.00717431f, -0.05043672f, -0.04354697f, 
    0.03202764f, -0.01257806f, -0.04027814f, -0.04382122f, 0.03681048f, 0.03214135f, 0.00891434f, -0.04528601f, 
    0.00596488f, -0.04606484f, -0.00162079f, 0.02002702f, -0.05080309f, 0.00981591f, -0.01121632f, 0.00316055f, 
    0.00539391f, 0.02546046f, 0.03159311f, -0.01992678f, -0.01331543f, -0.02075023f, -0.03516646f, -0.00730339f, 
    0.03535696f, -0.03021770f, 0.01545637f, -0.01729912f, 0.02241561f, -0.05853215f, 0.01223734f, -0.05635040f, 
    -0.02867176f, 0.02574811f, 0.02902241f, -0.01447503f, -0.03017046f, 0.01899320f, -0.05863152f, -0.00222187f, 
    -0.02598180f, -0.02594371f, -0.03293680f, -0.02553806f, -0.00408232f, -0.02405939f, 0.03438416f, 0.00996399f, 
    0.03411034f, -0.02314927f, -0.02237466f, 0.02433805f, -0.01397820f, -0.01911870f, 0.01377131f, -0.01347251f, 
    0.04703330f, -0.01196673f, 0.00495197f, -0.01828507f, -0.03502117f, 0.02369041f, 0.00570472f, -0.03001276f, 
    -0.04933590f, 0.00828842f, -0.00746125f, 0.04183129f, 0.01207604f, 0.02352500f, 0.03556027f, -0.01307349f, 
    -0.01716051f, -0.02339949f, 0.04139384f, -0.03194053f, 0.02247820f, -0.05641608f, 0.03478821f, -0.01502921f, 
    -0.05598902f, -0.00292969f, 0.00989105f, 0.02195155f, 0.01348408f, -0.02337252f, -0.02004716f, 0.00354936f, 
    -0.02596732f, -0.03332392f, -0.05460305f, -0.00885072f, -0.05572465f, -0.03377675f, -0.01558042f, -0.05249748f, 
    -0.01985508f, -0.00112999f, -0.03474208f, -0.04750711f, -0.05688157f, 0.01757259f, -0.00569869f, -0.01245143f, 
    -0.00897213f, -0.00767946f, -0.03373985f, -0.05901134f, -0.03981236f, 0.00646227f, -0.02964603f, 0.00866824f, 
    0.00867867f, -0.02790130f, -0.01667068f, 0.04291501f, 0.02727610f, -0.02938733f, 0.01578138f, -0.01344137f, 
    -0.06057877f, -0.03302261f, -0.00576234f, -0.02135430f, -0.02838789f, 0.01245691f, -0.00941356f, -0.05426958f, 
    0.02937707f, -0.05037964f, 0.00421834f, -0.02466671f, 0.03334071f, -0.03700827f, -0.01690351f, -0.02822635f, 
    0.03130064f, -0.02498069f, -0.00040945f, -0.01712794f, 0.03872452f, -0.00811914f, 0.00002304f, -0.02349609f, 
    -0.02241885f, -0.03146408f, -0.02123977f, -0.01125175f, 0.03414727f, -0.00799109f, -0.02618027f, 0.02295505f, 
    0.00426023f, 0.01253508f, 0.01942188f, 0.03990568f, -0.01738032f, -0.03553158f, 0.02289261f, 0.00901571f, 
    0.01281324f, 0.04004966f, -0.03829886f, -0.05207507f, -0.00582281f, 0.00486642f, 0.00388856f, -0.03327990f, 
    -0.03050067f, -0.05060849f, -0.00885995f, 0.02046017f, -0.06124501f, 0.01080519f, -0.03343435f, 0.00728042f, 
    -0.01930823f, -0.00483331f, 0.02110148f, -0.05529870f, 0.02484504f, -0.01456143f, 0.03950983f, -0.00645637f, 
    -0.05988970f, -0.03750035f, -0.04339907f, 0.03841750f, -0.05165581f, -0.04943575f, -0.04234312f, -0.03561385f, 
    0.03242968f, -0.05036565f, 0.04023319f, -0.05194611f, -0.03528726f, -0.00499607f, 0.00675414f, -0.00247190f, 
    -0.04805180f, 0.04042644f, -0.03040702f, 0.00715346f, -0.04619352f, 0.03827411f, -0.05122987f, 0.01383437f, 
    0.00574345f, -0.02157104f, -0.01116675f, 0.00149109f, -0.00809586f, 0.02265703f, 0.02770153f, 0.03829364f, 
    -0.04152656f, -0.03970830f, 0.03592421f, -0.04589251f, -0.03729590f, -0.02228866f, 0.01777037f, 0.00875666f, 
    0.04373289f, 0.01529266f, -0.01473052f, 0.03546946f, -0.00369649f, 0.03018837f, -0.00480619f, 0.05096180f, 
    -0.03051374f, -0.04730857f, 0.03615022f, -0.04486773f, -0.03195317f, -0.05287185f, -0.01025689f, -0.04867851f, 
    -0.02159247f, 0.02709020f, 0.00671999f, -0.05087151f, -0.01970819f, 0.00576576f, 0.01674701f, -0.00382159f, 
    -0.03085765f, -0.02439644f, 0.00275879f, -0.00695516f, 0.03285133f, -0.04415372f, -0.01918770f, 0.01825945f, 
    -0.03999823f, -0.02559119f, 0.02624806f, 0.01745045f, -0.05689337f, -0.02858218f, -0.06562170f, 0.01205727f, 
    -0.03070315f, 0.01699980f, 0.01138039f, -0.02242707f, 0.03743595f, -0.03713189f, -0.05430140f, 0.03740073f, 
    -0.01411934f, 0.00336883f, 0.02950569f, -0.04261950f, -0.02578981f, -0.01314895f, -0.04340653f, 0.02504543f, 
    -0.00429444f, -0.01671292f, -0.04077690f, 0.01196435f, -0.04808583f, -0.03507577f, -0.00722145f, -0.04145461f, 
    -0.00634730f, -0.00932665f, -0.02225946f, -0.02489702f, -0.04684829f, -0.00717684f, -0.05752077f, -0.04946137f, 
    0.04460344f, -0.02526281f, -0.04007110f, 0.00948667f, -0.02580741f, 0.01550839f, -0.03309204f, -0.00375550f, 
    0.03523267f, -0.01495482f, -0.00742745f, -0.04085298f, 0.04139288f, -0.00174899f, -0.04374071f, -0.02293648f, 
    -0.00182276f, -0.05089825f, -0.01131241f, -0.05122158f, -0.05536622f, 0.02195375f, -0.00023172f, 0.02486664f, 
    -0.04548525f, -0.02559929f, 0.00094741f, -0.03120138f, 0.02664614f, 0.00816834f, -0.03572277f, 0.01561953f, 
    -0.04733271f, -0.04676956f, -0.03665894f, 0.01662283f, -0.04466598f, 0.03383730f, -0.02290057f, -0.01317104f, 
    0.00978138f, 0.03813571f, 0.03240545f, -0.05552338f, -0.05364293f, -0.00490745f, -0.01535111f, -0.02866171f, 
    -0.03547338f, 0.01898294f, -0.03560749f, -0.02201622f, -0.05600930f, -0.03394392f, -0.01095973f, -0.03279159f, 
    -0.01969355f, 0.03915025f, -0.04904541f, 0.03851509f, 0.03696041f, -0.03058976f, -0.00574073f, -0.04607511f, 
    -0.03605652f, 0.03293106f, -0.01987576f, -0.02376761f, -0.01961002f, -0.02834886f, -0.05213705f, 0.01352031f, 
    -0.01426347f, -0.01755489f, 0.02724468f, -0.04734019f, 0.04551604f, -0.04007051f, -0.04964240f, 0.00400032f, 
    0.02109358f, -0.00042628f, 0.01568572f, -0.01482305f, -0.03960904f, 0.02869112f, 0.03366436f, 0.03353699f, 
    0.04550051f, -0.05328086f, -0.00349728f, 0.00201628f, -0.04724609f, 0.04316828f, -0.04112688f, -0.00126258f, 
    0.03311781f, -0.01982739f, -0.01605380f, -0.02926010f, -0.05301894f, -0.04132072f, -0.05048211f, 0.03322026f, 
    0.01797830f, 0.02803635f, 0.01301969f, 0.03841221f, -0.05281911f, 0.01977477f, 0.00520037f, 0.00132138f, 
    -0.02303088f, -0.03228572f, -0.01719845f, 0.02952842f, 0.01278909f, -0.01817000f, 0.02877027f, 0.02213630f, 
    -0.04559027f, -0.02564113f, -0.04599083f, 0.01699876f, 0.02540058f, -0.00959827f, -0.01193767f, 0.03170631f, 
    -0.03465667f, -0.04071286f, 0.00882407f, 0.03223163f, -0.01509222f, 0.00831541f, 0.03975621f, 0.02873206f, 
    -0.04921254f, -0.04897170f, 0.03315793f, 0.00281728f, -0.05363707f, 0.02660963f, 0.00641245f, -0.00142892f, 
    0.01218865f, -0.05355755f, -0.00934281f, -0.04099482f, 0.01330950f, -0.04721079f, 0.03515059f, -0.00339148f, 
    -0.01032911f, -0.00692825f, -0.04978411f, -0.02326420f, -0.00402954f, 0.02693216f, -0.00920657f, 0.04429582f, 
    0.02669731f, -0.03426082f, -0.03175468f, 0.04438604f, 0.03655071f, -0.03064250f, -0.04741659f, 0.03073694f, 
    0.03456253f, 0.01093077f, -0.04578161f, 0.02396334f, -0.01269154f, 0.03416419f, -0.04440043f, -0.02012794f, 
    0.01554382f, -0.02702388f, -0.04363317f, -0.03861289f, -0.04566041f, 0.00695831f, 0.00172249f, 0.02931430f, 
    0.00713034f, -0.02701570f, -0.03325764f, -0.01847939f, -0.02365592f, 0.02502137f, -0.03563751f, -0.00549469f, 
    -0.04681490f, 0.02535350f, -0.04498158f, -0.03307701f, -0.03012418f, 0.01260488f, -0.00149075f, -0.05345929f, 
    0.01018501f, -0.04737661f, 0.03125560f, 0.04203443f, 0.03741390f, 0.02438401f, 0.01841406f, 0.02731607f, 
    0.03342455f, -0.03730671f, 0.02604247f, -0.02080075f, -0.02469599f, 0.03943466f, 0.00750005f, 0.00902183f, 
    -0.05107426f, -0.00013832f, 0.02740510f, 0.02813633f, 0.01926055f, -0.04663988f, 0.02562293f, -0.03758128f, 
    -0.03412941f, 0.04323180f, -0.03348141f, 0.02118964f, -0.03492686f, 0.01351503f, -0.03064833f, 0.02965356f, 
    -0.04821943f, -0.04546386f, -0.05256056f, -0.03263869f, 0.02637887f, -0.04967176f, -0.01776840f, -0.00264290f, 
    -0.01727492f, -0.02848337f, -0.00111488f, -0.04240188f, -0.03690223f, -0.04060546f, -0.01434602f, -0.04632732f, 
    -0.04220114f, -0.04566128f, -0.01663078f, 0.01166028f, -0.02113965f, -0.00600362f, -0.02037968f, -0.01527746f, 
    -0.00731734f, -0.03686346f, 0.04501881f, 0.01953654f, 0.02037394f, 0.00774526f, -0.02592678f, 0.04420100f, 
    -0.05169421f, -0.01238622f, 0.03475730f, -0.03088360f, 0.00725515f, -0.00655684f, 0.00412031f, 0.00971009f, 
    0.01641429f, 0.00811000f, -0.04575227f, -0.02463980f, -0.02796013f, 0.01856535f, -0.02038731f, -0.02766865f, 
    -0.04362789f, -0.03291024f, -0.00753788f, 0.04041491f, -0.02616932f, 0.01681943f, -0.05635694f, 0.01858423f, 
    0.01280060f, -0.00642863f, 0.00179904f, -0.02331442f, -0.03108620f, -0.05143499f, 0.01923266f, 0.02353141f, 
    -0.03758683f, -0.02199714f, 0.04312846f, 0.01440800f, -0.02226639f, -0.00827953f, -0.05050643f, -0.03769680f, 
    -0.05160053f, 0.00204902f, 0.03443971f, -0.03958388f, 0.03606708f, 0.01621241f, -0.02544631f, -0.03129905f, 
    0.03648091f, -0.03077465f, -0.04838270f, -0.00342563f, 0.03713633f, -0.01052188f, -0.00210692f, 0.01521046f, 
    -0.04880792f, 0.00824559f, -0.04835101f, -0.04094778f, 0.03451864f, -0.04235173f, -0.00369071f, 0.02186199f, 
    0.02548112f, -0.04642563f, -0.04291219f, 0.02335731f, 0.01427084f, -0.03042829f, 0.02969642f, 0.01020766f, 
    0.04313027f, 0.03437886f, -0.02688707f, -0.01322731f, -0.03197246f, -0.00080091f, -0.02905316f, -0.04553642f, 
    -0.03945154f, -0.02855773f, -0.03405920f, -0.02647883f, -0.04302733f, -0.05070194f, -0.05580234f, -0.05608819f, 
    0.03549282f, -0.05363458f, 0.04225777f, 0.01310973f, 0.04422656f, -0.05611229f, -0.01202779f, 0.01795444f, 
    -0.00849186f, 0.03922195f, -0.01485800f, -0.00262166f, -0.02364429f, 0.03853536f, 0.01707020f, 0.04096787f, 
    -0.05399904f, 0.01143680f, -0.01793009f, 0.01890458f, 0.01288910f, -0.02676371f, 0.00159152f, -0.01461797f, 
    0.00656647f, -0.00196037f, 0.03909645f, -0.03942467f, -0.04106422f, -0.01212223f, -0.00269259f, -0.03066403f, 
    -0.03697342f, -0.03570837f, -0.02753534f, -0.02583054f, -0.01500172f, 0.02506409f, -0.03401010f, -0.02334393f, 
    -0.02216412f, -0.07574984f, 0.01744754f, -0.05170787f, 0.10678593f, 0.02024924f, 0.05110943f, 0.05793226f, 
    0.06750663f, 0.05847180f, 0.02028244f, -0.02226110f, -0.02084668f, -0.09816127f, 0.03492314f, -0.11762612f, 
    0.04573905f, -0.04196043f, 0.05369279f, -0.03151094f, 0.02189344f, 0.04711431f, 0.15122753f, 0.04752148f, 
    0.12503169f, 0.07624955f, -0.01109524f, 0.05122178f, 0.07142487f, 0.11129938f, 0.11082808f, 0.14919087f, 
    0.08614015f, -0.08329055f, 0.06054598f, 0.01459966f, -0.25251636f, 0.11254893f, -0.36611754f, -0.02204824f, 
    0.02285379f, -0.07378179f, 0.00219584f, -0.05735073f, 0.13733771f, -0.02563256f, 0.04379710f, 0.01953703f, 
    -0.02368585f, -0.07415379f, 0.04631089f, 0.12529081f, 0.07731782f, 0.03524247f, -0.00841144f, 0.08917660f, 
    0.09700327f, 0.08729393f, -0.03843664f, 0.05423665f, -0.03502566f, -0.00864642f, 0.03376905f, 0.11238626f, 
    0.07829732f, 0.02666069f, -0.02647531f, 0.12985957f, 0.00814913f, -0.03349846f, 0.19263120f, 0.05791219f, 
    0.20414519f, -0.11175918f, -0.11681119f, 0.14709689f, 0.05032574f, 0.06024434f, 0.05573875f, -0.12913717f, 
    0.08422723f, 0.05879006f, -0.03411342f, 0.09820270f, -0.00678551f, 0.09037425f, -0.12665062f, -0.16227873f, 
    0.07321434f, -0.00960727f, 0.04006470f, 0.07804903f, 0.05029656f, 0.05138675f, 0.04055704f, 0.02502704f, 
    -0.00419467f, -0.21228026f, 0.10161276f, 0.01919229f, -0.08634848f, 0.02239931f, 0.07379791f, 0.08088586f, 
    -0.04100755f, -0.05046131f, 0.02450102f, 0.09809126f, 0.06632692f, 0.17797755f, 0.00827710f, -0.00581899f, 
    0.11489806f, 0.10381696f, 0.07679174f, 0.11396457f, 0.05488136f, 0.03917905f, -0.04053908f, 0.09738701f, 
    0.33986500f, 0.39440680f, -0.01148422f, 0.06565994f, 0.01576179f, 0.00408072f, 0.00395874f, -0.03014218f, 
    0.16881126f, 0.00600611f, 0.12221120f, 0.10649245f, -0.08657866f, 0.09289931f, 0.09915929f, 0.07353187f, 
    0.01954857f, 0.05802806f, -0.01877946f, 0.13615370f, -0.08809800f, 0.05050427f, 0.07806271f, 0.04079063f, 
    -0.23057245f, -0.05689783f, 0.15580700f, 0.07653493f, 0.03472505f, -0.05553627f, 0.09716225f, 0.13740921f, 
    -0.02273498f, 0.03340654f, -0.01110954f, 0.13351752f, 0.08025689f, -0.08602411f, 0.22822033f, 0.09687846f, 
    -0.06525472f, -0.09595235f, -0.10802528f, 0.10112976f, -0.10616373f, 0.07347307f, 0.02213685f, 0.06158992f, 
    0.35312256f, 0.16123420f, -0.05157437f, -0.13135330f, 0.12197367f, 0.05063548f, 0.07648926f, 0.03424263f, 
    0.08697466f, 0.03356556f, -0.01575566f, 0.01164853f, 0.08298722f, -0.20456101f, 0.03153053f, 0.05513288f, 
    -0.00811758f, 0.04091215f, -0.05844808f, 0.01054789f, 0.01601589f, 0.12602684f, 0.03436622f, -0.10265113f, 
    0.37492871f, 0.12400383f, -0.11624616f, 0.10178334f, 0.10541946f, -0.01682373f, -0.06855310f, -0.01084600f, 
    0.03163163f, 0.09748942f, -0.03512473f, 0.20608367f, -0.24145591f, -0.04699768f, 0.17616446f, -0.18544596f, 
    0.03189047f, -0.06060832f, -0.00848166f, 0.16206004f, 0.01481796f, 0.03001935f, -0.05054311f, 0.05653442f, 
    -0.01774659f, -0.15141001f, 0.05664450f, 0.00039989f, 0.07374904f, -0.05011122f, -0.01211380f, 0.11292652f, 
    0.13274887f, 0.00287105f, 0.03065079f, 0.04739960f, 0.33994955f, -0.25031391f, 0.26511252f, 0.19619055f, 
    -0.12132192f, -0.04537795f, 0.02883428f, 0.04406067f, 0.13140032f, 0.09964915f, 0.10988147f, 0.04962802f, 
    -0.06379021f, -0.22748896f, -0.16479884f, -0.29523310f, 0.07076842f, -0.03005560f, 0.14773421f, -0.13972406f, 
    0.13552444f, -0.02448282f, 0.07625695f, 0.04191666f, 0.18742411f, 0.09357113f, -0.10099373f, 0.01629519f, 
    0.08456980f, -0.01044930f, 0.02863025f, 0.05888381f, 0.07815662f, 0.00960484f, 0.05713382f, 0.14373942f, 
    -0.23571278f, -0.22760054f, -0.05842525f, -0.09204168f, 0.11278462f, -0.00034243f, 0.05163990f, 0.04443791f, 
    0.01463284f, -0.04709905f, -0.02007945f, -0.03076060f, 0.18332270f, -0.00550834f, 0.14805256f, 0.02684698f, 
    -0.01650913f, 0.14877464f, -0.04704589f, 0.00964420f, 0.08138236f, 0.05778769f, 0.09873585f, 0.08673441f, 
    -0.44616032f, -0.27137446f, -0.02662911f, -0.13530561f, 0.07532707f, 0.11386041f, 0.04150326f, 0.01390577f, 
    0.07527788f, -0.04108348f, 0.05528956f, -0.07573542f, -0.12857823f, -0.01639403f, -0.07993460f, 0.00405669f, 
    0.00949940f, 0.04419284f, 0.05554022f, 0.01926157f, 0.01352342f, 0.07668265f, 0.16369128f, -0.14447473f, 
    0.20805088f, -0.08587936f, -0.25988927f, -0.21916837f, 0.06370783f, 0.05689281f, 0.08950065f, 0.02570253f, 
    -0.00255479f, -0.05848567f, -0.03590332f, 0.02755658f, 0.34663635f, -0.03744835f, -0.02702285f, -0.04377099f, 
    -0.01528195f, -0.00322857f, -0.00865803f, 0.18616100f, 0.14632910f, 0.05228929f, -0.02349057f, 0.06227721f, 
    -0.23108631f, 0.02391254f, 0.07032459f, -0.13739710f, -0.00007087f, -0.01609067f, -0.02082217f, 0.02623190f, 
    0.03576063f, 0.08026899f, 0.02062415f, 0.01996765f, 0.21215144f, -0.34343302f, 0.24248315f, -0.08323532f, 
    0.10660301f, 0.04767094f, 0.14446828f, 0.03345696f, 0.10455995f, 0.05275661f, 0.02290783f, 0.09184904f, 
    0.32436374f, 0.16818501f, -0.15297683f, 0.15871103f, 0.09759532f, 0.16731019f, 0.09827624f, 0.02868469f, 
    0.06213719f, 0.11655559f, -0.04028210f, 0.11218525f, -0.11469613f, 0.07245171f, -0.05713707f, -0.08999115f, 
    0.04340869f, -0.00295123f, 0.15105909f, 0.21837176f, -0.19600941f, 0.16952455f, 0.13458799f, 0.13366768f, 
    0.34751830f, -0.07784691f, -0.09617582f, 0.01820647f, -0.04583805f, -0.05237270f, 0.04389849f, -0.01665280f, 
    -0.13090581f, 0.10551553f, -0.15673308f, -0.26674485f, 0.02509534f, 0.09078481f, -0.03608468f, -0.19912523f, 
    -0.08503828f, -0.03670907f, 0.10137928f, 0.00129789f, 0.01081305f, -0.21576089f, 0.05206718f, 0.14251240f, 
    0.10778215f, -0.01347391f, -0.02541854f, 0.00964166f, 0.00608546f, 0.07540679f, -0.07710946f, -0.05609279f, 
    -0.00833119f, -0.12641668f, -0.05784985f, -0.11515028f, -0.14338751f, 0.05288931f, -0.00085695f, 0.21920846f, 
    -0.03665778f, -0.12703936f, -0.07686072f, -0.13726515f, -0.12471004f, -0.00339261f, 0.13184926f, -0.02299725f, 
    0.25328887f, 0.16291431f, -0.07781240f, -0.00473318f, 0.06613700f, 0.10101868f, 0.08747847f, 0.03079049f, 
    -0.06718843f, -0.03202789f, -0.01498059f, 0.00764100f, -0.10466942f, 0.20460692f, 0.07682463f, -0.00872818f, 
    0.14722282f, 0.05696200f, -0.02085069f, -0.13779201f, 0.03879582f, -0.21177980f, 0.07121866f, 0.30243805f, 
    0.18434629f, -0.13351223f, -0.03156513f, -0.02474189f, -0.06516752f, 0.01397289f, 0.00718076f, 0.13652499f, 
    0.06701867f, 0.04603300f, -0.07343754f, -0.17312668f, 0.21751709f, -0.04214934f, -0.09700929f, 0.07442483f, 
    -0.03858958f, -0.01589566f, 0.10176401f, 0.12615487f, 0.04424104f, -0.01354193f, 0.13609214f, 0.22548801f, 
    -0.10315657f, -0.06728283f, 0.01489705f, 0.05173616f, 0.02116486f, 0.04637974f, -0.00145988f, 0.02339282f, 
    0.01138687f, 0.00442790f, 0.06517359f, 0.05995623f, -0.19405514f, -0.09082922f, 0.06944685f, 0.10295725f, 
    0.20789056f, 0.02298144f, -0.09650118f, -0.06277732f, 0.04146576f, -0.01784873f, -0.16667353f, -0.02086130f, 
    0.20488320f, 0.30895340f, -0.06785197f, 0.00629111f, -0.01768081f, 0.01464281f, 0.12856321f, 0.13531354f, 
    0.10922562f, -0.09027757f, -0.02509923f, -0.01573534f, 0.16133074f, 0.15481515f, -0.05194406f, 0.08291758f, 
    -0.04718824f, -0.01703778f, 0.04132558f, -0.00952651f, 0.03571925f, 0.06914624f, 0.07171360f, 0.10337665f, 
    -0.04586069f, 0.15950772f, 0.07730374f, 0.13442883f, -0.13171490f, 0.02486955f, -0.10518349f, 0.22770336f, 
    -0.03084094f, 0.12179632f, 0.09473538f, -0.14154606f, 0.00471970f, -0.12140575f, -0.00640328f, -0.09296998f, 
    0.01683943f, 0.04602051f, 0.20855603f, 0.07823356f, 0.08221755f, 0.04462299f, 0.16759634f, 0.12419007f, 
    0.17462248f, 0.15670599f, 0.03557322f, -0.17699665f, -0.01926993f, 0.18683858f, 0.01310449f, -0.01798976f, 
    -0.09723854f, 0.10864869f, -0.21216099f, 0.05100480f, 0.00223909f, -0.04270150f, -0.02097105f, 0.02037140f, 
    -0.00942135f, 0.10071261f, -0.12132312f, -0.15327777f, -0.25933191f, -0.16936935f, 0.02043949f, -0.16035825f, 
    0.16843733f, 0.04584362f, -0.06373570f, -0.06903249f, 0.13559282f, -0.05945250f, 0.08160587f, 0.16537315f, 
    0.09914339f, 0.03992964f, -0.17772865f, 0.06683792f, 0.07006302f, 0.05696753f, -0.10521873f, -0.00903080f, 
    0.11711648f, 0.22302637f, -0.09788792f, 0.07736878f, 0.13703966f, -0.13478310f, 0.01066151f, -0.01380617f, 
    -0.06392521f, -0.25321186f, 0.04840071f, 0.10938028f, 0.03238719f, 0.15262930f, -0.00537359f, -0.00684240f, 
    0.03071989f, 0.11747358f, 0.09920160f, 0.14827399f, 0.03468283f, -0.01591962f, 0.12333809f, -0.11499649f, 
    -0.05798524f, -0.04672657f, -0.01991445f, 0.03690194f, -0.01791689f, 0.03814346f, -0.09484838f, -0.14410567f, 
    0.05922879f, -0.19330138f, -0.15249325f, 0.03184408f, 0.04617229f, -0.21097264f, 0.17412633f, -0.06474986f, 
    -0.07121017f, 0.11348726f, 0.01755890f, 0.05790402f, -0.01401273f, -0.02701927f, 0.19651711f, -0.00876230f, 
    0.09109413f, 0.07430200f, 0.07425805f, 0.20803864f, 0.00287720f, -0.06288090f, 0.04220868f, 0.08043616f, 
    -0.19313926f, -0.08525191f, -0.04393782f, 0.07148340f, 0.06675567f, -0.00851873f, -0.11435341f, -0.02224089f, 
    -0.05864072f, 0.19094639f, -0.10209512f, 0.02989112f, 0.36247495f, 0.02999575f, -0.09786437f, -0.00346695f, 
    -0.01197760f, 0.11003693f, 0.03811891f, 0.04293228f, 0.02537765f, 0.02180633f, -0.07998575f, -0.14614095f, 
    -0.16156352f, -0.22794528f, -0.04542992f, 0.03523385f, 0.07858894f, 0.06378231f, -0.06250522f, 0.06040283f, 
    0.05363477f, -0.00152742f, -0.01672681f, 0.14091499f, -0.11195447f, 0.01002523f, 0.10206448f, -0.08251517f, 
    -0.15604931f, -0.02298244f, 0.10126719f, -0.01400264f, 0.03593343f, 0.03947222f, 0.10150224f, 0.26914033f, 
    0.21149246f, 0.02278830f, -0.38938415f, -0.07264774f, -0.10364707f, 0.11049078f, -0.02225404f, -0.00552045f, 
    0.00028760f, 0.07727144f, -0.07267638f, 0.01506339f, 0.16487142f, 0.01327534f, 0.01226715f, 0.08992888f, 
    -0.14301135f, 0.03299826f, 0.05824240f, -0.03078783f, -0.15190639f, -0.03909171f, 0.19683149f, -0.06054378f, 
    0.09659997f, 0.05947257f, 0.01240301f, -0.05380541f, -0.04260059f, 0.14801863f, 0.12969524f, 0.04786851f, 
    -0.06214835f, -0.05384872f, -0.08416974f, 0.01692859f, 0.05037208f, -0.03221076f, 0.01021663f, 0.07894781f, 
    -0.02348940f, -0.00301485f, -0.10682711f, 0.10943640f, 0.02723258f, 0.02025933f, -0.07771380f, -0.01584334f, 
    0.04999734f, 0.22296171f, 0.18163040f, 0.01048414f, -0.08264340f, 0.04456457f, 0.01538105f, 0.10312430f, 
    -0.08503702f, 0.11546362f, -0.05609397f, -0.01920769f, -0.07419657f, -0.06560716f, 0.11937537f, 0.00192603f, 
    0.00225354f, 0.05791674f, -0.02470705f, 0.05106726f, 0.04582813f, -0.09363358f, 0.01708111f, -0.02625139f, 
    -0.17247896f, 0.17525409f, -0.10738245f, 0.13475621f, 0.00181415f, -0.02963053f, -0.08254871f, -0.02608936f, 
    0.00816580f, -0.13008581f, 0.04174866f, 0.00698876f, -0.16524856f, -0.02001951f, 0.02843632f, 0.06278080f, 
    -0.05343065f, 0.00514115f, -0.09162561f, 0.06809381f, 0.04859814f, 0.05313345f, 0.06958505f, 0.05507904f, 
    0.34669960f, -0.09333299f, -0.06206474f, -0.03224522f, 0.13421075f, -0.05883055f, 0.04019345f, -0.01265487f, 
    -0.03231959f, -0.01963003f, 0.01298553f, 0.01743139f, 0.06350354f, -0.10744023f, 0.07717264f, 0.23270567f, 
    0.05906352f, 0.02482494f, -0.00172965f, -0.07428696f, -0.12938192f, 0.04605069f, 0.00324015f, 0.13485095f, 
    -0.29216701f, 0.27459711f, 0.03008468f, -0.12100933f, -0.03495526f, -0.01037657f, 0.08795443f, -0.00452763f, 
    0.03169274f, -0.00604845f, 0.02252195f, -0.00376099f, -0.05392777f, -0.08978652f, -0.01184083f, 0.06931093f, 
    0.11400051f, 0.08662383f, 0.15130034f, 0.04348764f, -0.11037078f, 0.12961309f, 0.04651317f, -0.03534358f, 
    -0.23875523f, 0.02802299f, 0.02059566f, 0.25355342f, 0.14847305f, 0.01702454f, -0.01910157f, 0.04813882f, 
    -0.03758508f, 0.04980976f, -0.01432438f, 0.02740447f, -0.23585467f, -0.26042309f, 0.15251547f, 0.22562493f, 
    -0.09640782f, 0.03213651f, -0.05851557f, 0.14878558f, 0.02083675f, -0.01826366f, 0.06270265f, 0.01131829f, 
    0.00248692f, 0.10750502f, 0.15863021f, 0.04593630f, 0.02962263f, 0.10929903f, -0.14885613f, -0.05022752f, 
    -0.00894521f, 0.01048134f, -0.00483824f, 0.03385947f, 0.25376818f, -0.11525102f, 0.07139341f, -0.00998673f, 
    -0.02513311f, 0.06260691f, 0.01391505f, -0.01624787f, -0.02297345f, -0.03956040f, 0.05494350f, 0.02711727f, 
    -0.45312637f, 0.04537690f, 0.04369100f, 0.02859789f, 0.03916145f, 0.12901877f, -0.02276883f, -0.05090320f, 
    -0.03209824f, 0.05989122f, -0.01324890f, -0.06455060f, 0.37455204f, -0.26414949f, 0.01477665f, -0.11531513f, 
    0.04740018f, -0.02888354f, 0.01096535f, 0.03163137f, 0.05574683f, 0.11490536f, -0.04056178f, 0.04164730f, 
    -0.10337439f, 0.11951879f, 0.09157176f, -0.14873350f, 0.05293275f, 0.05615228f, -0.03081003f, -0.07043958f, 
    0.03556518f, -0.03623735f, 0.09457258f, 0.01330747f, 0.05714715f, 0.21503088f, 0.07725919f, -0.15939288f, 
    0.09700823f, 0.00609088f, -0.01126417f, -0.01797879f, -0.04578390f, -0.12631935f, 0.00006468f, 0.19802900f, 
    -0.17047839f, 0.15882537f, 0.17243727f, -0.20516972f, 0.12649533f, -0.04243413f, -0.01161867f, 0.05646615f, 
    0.08525039f, 0.02966443f, 0.09045173f, 0.01092692f, -0.12583241f, 0.17917542f, 0.01906310f, 0.14531818f, 
    0.01048874f, -0.06399713f, 0.03294363f, 0.16744968f, -0.02624311f, -0.04469152f, -0.01429133f, -0.10435177f, 
    -0.09831160f, -0.18481933f, 0.18774988f, -0.10069147f, 0.07563090f, 0.03826625f, -0.02689273f, -0.02714606f, 
    0.03404894f, 0.13429716f, -0.09863592f, -0.07347972f, -0.13989505f, 0.11127932f, 0.08092159f, -0.10299861f, 
    0.11134183f, -0.07870312f, 0.01918000f, 0.00829118f, -0.04901101f, -0.01822666f, -0.00810046f, 0.21972087f, 
    0.23519512f, -0.26543364f, 0.07519650f, -0.17422596f, 0.06686804f, -0.04562848f, -0.12396223f, -0.01590361f, 
    0.06424293f, 0.01024428f, 0.02568508f, 0.11514627f, -0.09191556f, 0.31961665f, -0.16065349f, -0.29580036f, 
    0.19874221f, 0.04107245f, 0.00956804f, 0.03284029f, 0.12303670f, -0.06777073f, -0.03222881f, -0.02434745f, 
    -0.16455382f, 0.26453313f, 0.04620980f, 0.21208324f, -0.13572109f, 0.06470888f, 0.02030242f, -0.00371204f, 
    0.06773874f, 0.06631625f, -0.01546493f, 0.07106547f, -0.06962498f, -0.11341507f, -0.11694477f, 0.35139239f, 
    0.05729335f, -0.02885716f, -0.06057265f, 0.10785745f, 0.07972554f, 0.03075158f, 0.00241591f, 0.02849082f, 
    0.02369709f, 0.06544435f, -0.04581235f, 0.36311072f, -0.02656012f, 0.00963549f, 0.02328683f, 0.07785214f, 
    0.01865145f, -0.12590848f, 0.06812735f, 0.09894216f, 0.12593481f, 0.02463521f, 0.10687853f, -0.09444559f, 
    0.13911541f, 0.05852929f, -0.10118408f, 0.07278002f, 0.07108301f, -0.00328781f, -0.05324139f, 0.00231659f, 
    0.13045003f, 0.05812003f, 0.25035152f, 0.01721870f, 0.05557882f, -0.03451580f, -0.04095186f, -0.02373145f, 
    0.05801281f, 0.11041480f, 0.04075498f, 0.09110903f, -0.05947076f, -0.11365742f, -0.18046877f, -0.10690821f, 
    -0.02804248f, 0.05964613f, 0.02079379f, -0.16542292f, -0.06087359f, -0.01275095f, 0.11599644f, 0.18551496f, 
    -0.28549126f, 0.06820778f, 0.39476514f, -0.05143438f, 0.01359871f, -0.04038037f, 0.07635652f, -0.00298720f, 
    -0.04829488f, 0.09288158f, 0.03940814f, -0.00987447f, 0.04284053f, -0.06289274f, 0.00265213f, 0.03863097f, 
    0.12249550f, 0.01104159f, 0.01282193f, 0.11743467f, 0.01828410f, -0.09276798f, 0.00034396f, 0.03481514f, 
    0.14477941f, -0.01523841f, 0.18492457f, -0.08830924f, 0.17099449f, -0.00917142f, -0.01181697f, 0.04039295f, 
    -0.00337258f, 0.07491374f, -0.03997019f, -0.00969167f, -0.28104630f, 0.14677922f, 0.05089469f, -0.11484124f, 
    0.06190496f, -0.03861436f, -0.05765871f, 0.03704543f, 0.03828233f, 0.09456039f, 0.04766244f, 0.01813632f, 
    -0.22695576f, 0.13410896f, -0.01592184f, -0.08907486f, 0.13487722f, 0.04134920f, -0.06451974f, -0.00559195f, 
    -0.02897391f, -0.02819783f, 0.09526114f, 0.04605928f, 0.20850798f, -0.00882700f, -0.02981000f, -0.18070437f, 
    -0.01102152f, 0.07158487f, 0.02121658f, 0.04710726f, 0.02124468f, -0.02920012f, -0.02824636f, -0.02877142f, 
    0.07845115f, -0.08902082f, 0.00645986f, -0.02760984f, 0.03362490f, 0.01118673f, -0.10895084f, -0.08397336f, 
    -0.15574501f, -0.21627146f, -0.00691683f, -0.03669129f, -0.19265889f, 0.01171445f, 0.07549664f, 0.05381962f, 
    -0.09618153f, -0.02087080f, 0.03599342f, -0.03609612f, -0.01079985f, -0.06612390f, 0.01125872f, 0.09643022f, 
    0.33050659f, -0.15007369f, -0.12370607f, 0.07487497f, 0.03193251f, 0.06212714f, -0.05909406f, -0.09819175f, 
    -0.01196871f, 0.01854762f, -0.04532349f, -0.20974629f, 0.29854438f, -0.23458095f, -0.05091803f, 0.09291371f, 
    -0.01989614f, -0.03299410f, 0.04184801f, -0.09090360f, -0.05188806f, -0.01858089f, 0.00722627f, 0.18132691f, 
    -0.25748411f, 0.10336354f, -0.02029796f, 0.05277594f, -0.03225989f, -0.01555311f, 0.12403452f, 0.02792881f, 
    -0.10491525f, -0.03167164f, 0.04612101f, 0.01184377f, 0.00209533f, 0.13137279f, -0.06805684f, 0.05949763f, 
    0.08237337f, 0.09972870f, 0.11409165f, -0.06767289f, -0.05142238f, 0.03568885f, -0.03835448f, 0.02966302f, 
    -0.24626616f, -0.13899937f, 0.08573496f, 0.09338699f, 0.00668146f, 0.02050180f, 0.03496395f, 0.04566044f, 
    0.02983769f, 0.03684415f, 0.01565080f, -0.16294460f, 0.07547323f, -0.29868317f, 0.00113525f, -0.04628337f, 
    -0.01026910f, 0.07791618f, -0.06747835f, 0.18461271f, -0.01512250f, -0.01077010f, -0.02229539f, 0.12933831f, 
    0.02325144f, 0.13276732f, 0.17618382f, 0.02180292f, -0.02855231f, 0.02571548f, -0.04464357f, -0.07659630f, 
    -0.01197757f, 0.03603185f, 0.06819704f, 0.02564926f, 0.18604741f, -0.12281214f, -0.05315182f, 0.02594802f, 
    -0.00504403f, 0.04076925f, -0.00453431f, -0.07804026f, -0.02768086f, -0.01914969f, -0.11558527f, -0.09968890f, 
    -0.41705415f, 0.09900366f, 0.02989802f, -0.16650663f, -0.06627925f, 0.08779415f, 0.11550236f, 0.01857658f, 
    -0.10298549f, -0.00968407f, -0.05792738f, -0.00072556f, 0.38727599f, -0.18463792f, -0.07670422f, -0.05218263f, 
    -0.05614788f, 0.02062699f, -0.01049407f, -0.06862073f, 0.10684691f, 0.00283746f, 0.00067467f, 0.04821946f, 
    -0.05210026f, 0.24860054f, 0.10024796f, 0.04480224f, -0.11114107f, -0.00283828f, 0.08552442f, 0.06689949f, 
    -0.00394168f, 0.03152248f, 0.13934097f, -0.07512565f, 0.10586362f, 0.14741924f, 0.14889431f, -0.16819020f, 
    -0.02609762f, 0.09149564f, 0.10636926f, -0.02021840f, 0.00860482f, -0.00704685f, 0.05369164f, 0.11479298f, 
    -0.09164576f, 0.10582532f, 0.17209962f, -0.30256942f, 0.05447118f, 0.01183400f, -0.02001498f, -0.03709739f, 
    -0.04081002f, 0.04178017f, 0.00236531f, 0.04854595f, -0.11282515f, 0.11255898f, 0.05027856f, -0.05222224f, 
    -0.08369569f, -0.04800083f, 0.02534076f, 0.00351908f, -0.04713479f, -0.01996279f, 0.02863491f, -0.12343670f, 
    -0.14952619f, -0.02953091f, 0.07286511f, -0.06452315f, 0.03115475f, 0.03958165f, -0.01172576f, 0.09333425f, 
    0.03026400f, 0.05712450f, -0.11152059f, -0.03498257f, -0.12175475f, 0.13000558f, 0.15973836f, -0.03997467f, 
    0.01694183f, 0.07363035f, -0.04107697f, 0.03028489f, -0.01524986f, -0.07449610f, -0.01104299f, 0.07708932f, 
    0.40760702f, -0.29472592f, 0.03634701f, -0.04484912f, 0.04708833f, 0.09432007f, -0.11657461f, -0.06743000f, 
    0.04893679f, 0.11398929f, 0.12004983f, 0.14429368f, 0.00332783f, 0.25976983f, -0.09248535f, -0.41388366f, 
    0.07447436f, 0.03958744f, 0.02732552f, -0.00252112f, -0.06415909f, 0.00826386f, -0.06281347f, -0.05366298f, 
    0.14018367f, 0.01223845f, 0.19346075f, -0.00482781f, 0.01576119f, 0.02660364f, -0.02111367f, 0.13978824f, 
    0.03034289f, 0.03550633f, -0.00385000f, 0.07696140f, 0.16778296f, -0.13601090f, -0.00742713f, 0.15366639f, 
    0.01444098f, 0.01702044f, 0.00888786f, 0.22622488f, -0.04156153f, -0.13686025f, 0.01967920f, 0.01930177f, 
    0.06714017f, -0.07862941f, -0.12865418f, 0.20702660f, 0.05718863f, 0.04634933f, 0.06935553f, 0.00484636f, 
    0.06550663f, -0.01418809f, 0.03039248f, 0.03481854f, 0.12740727f, 0.29805011f, -0.00753688f, -0.02765883f, 
    0.05593310f, 0.03431346f, -0.00598650f, 0.01687807f, 0.05748316f, -0.04820632f, -0.04010632f, -0.09549150f, 
    0.20567852f, -0.00965798f, 0.12386353f, 0.08691597f, 0.03419897f, 0.01286743f, -0.04089639f, -0.06389526f, 
    0.06426504f, 0.05827515f, 0.04371018f, 0.03543200f, -0.02358374f, -0.11293595f, -0.08616762f, -0.13094808f, 
    0.00119310f, 0.04114758f, 0.06533734f, -0.16935840f, -0.05749030f, 0.11125810f, 0.09877558f, 0.18022995f, 
    -0.30000365f, -0.06050479f, 0.03020039f, 0.03225810f, 0.06956945f, -0.06245967f, 0.06631542f, -0.04961311f, 
    -0.01933406f, 0.08871916f, 0.02248996f, -0.03124743f, -0.09891753f, -0.03545262f, -0.00920778f, 0.18542825f, 
    -0.00370657f, 0.00516325f, 0.00855750f, -0.01246541f, 0.02235856f, -0.00729578f, 0.09183817f, 0.03970819f, 
    0.16613439f, -0.02932332f, 0.14487840f, -0.04599202f, 0.13313480f, 0.13129969f, 0.12980419f, -0.02498027f, 
    0.02157710f, -0.01087203f, -0.07954907f, -0.12626345f, -0.22847526f, 0.13402084f, 0.03829472f, -0.07771670f, 
    0.03012861f, 0.02225957f, -0.04198637f, 0.12252611f, 0.01793120f, 0.10039132f, 0.09085482f, -0.02635964f, 
    -0.07459071f, 0.21808265f, 0.09751875f, -0.26890650f, 0.00202520f, -0.01842577f, -0.00350200f, 0.04215565f, 
    -0.11259635f, -0.03995126f, 0.04902314f, 0.01267491f, 0.26275247f, -0.09413929f, 0.02446097f, -0.13413578f, 
    -0.01795145f, 0.12199268f, -0.08205885f, -0.07731068f, 0.01532033f, -0.07041618f, -0.06071902f, 0.00145871f, 
    0.03715203f, -0.12410891f, 0.16537781f, -0.12263905f, 0.05901007f, 0.00004846f, 0.05516344f, 0.17510347f, 
    -0.05659565f, 0.11249392f, 0.07776642f, 0.12890586f, -0.20251818f, 0.03335764f, 0.12734441f, -0.01152635f, 
    0.05686190f, -0.03048256f, 0.01105950f, -0.05267751f, 0.08895817f, 0.20156203f, -0.07386639f, 0.00252641f, 
    0.00791293f, -0.05323892f, 0.06754718f, -0.01682342f, -0.01343491f, -0.01318066f, 0.12733872f, 0.02494179f, 
    -0.01292595f, 0.06524932f, 0.02963121f, 0.13532688f, 0.04054097f, 0.02998500f, -0.21364601f, -0.14157131f, 
    0.04486633f, 0.03548613f, -0.05062704f, 0.12150930f, 0.15538545f, -0.08243362f, -0.11929765f, 0.03783312f, 
    0.20916626f, -0.13997498f, -0.03230143f, 0.08367086f, 0.01566413f, -0.07378712f, 0.08010743f, 0.07501099f, 
    0.03099803f, 0.06616405f, -0.13409881f, 0.04421930f, 0.01067957f, -0.11547212f, -0.11500920f, 0.15963629f, 
    -0.04311456f, 0.00206666f, -0.05918143f, 0.11779099f, 0.02085290f, 0.07449874f, -0.02490225f, -0.18479288f, 
    -0.11295548f, 0.04366449f, -0.03701121f, -0.07411201f, 0.13144495f, -0.02816275f, -0.07519580f, -0.15636908f, 
    0.06050566f, -0.02439253f, 0.03262728f, 0.18440245f, 0.07165188f, 0.17121130f, -0.02197084f, -0.16272405f, 
    0.14475852f, 0.05916172f, -0.03460438f, 0.00383757f, -0.01130673f, 0.06154799f, 0.02699206f, -0.09204159f, 
    0.36297742f, 0.12660129f, 0.18136233f, 0.06379899f, -0.08789907f, -0.02262975f, 0.09790819f, -0.00127626f, 
    0.02535871f, 0.03864725f, -0.00767186f, 0.06985552f, 0.20209470f, 0.08180303f, -0.09367009f, 0.03087866f, 
    -0.03554218f, -0.01175766f, -0.01624829f, 0.14588222f, 0.07684199f, 0.06972280f, 0.18662624f, 0.12066267f, 
    0.27611241f, 0.05045268f, -0.03534830f, 0.02250181f, 0.11314461f, -0.09183019f, 0.04355051f, -0.07625043f, 
    -0.10583243f, 0.06203661f, 0.10795420f, 0.10826478f, -0.14620993f, 0.06117534f, 0.14833596f, -0.02055467f, 
    0.04473326f, 0.05508469f, -0.03706291f, -0.08916532f, -0.17466585f, -0.02884367f, 0.09612525f, -0.02980170f, 
    -0.02267260f, 0.04862236f, 0.04861668f, 0.05060593f, 0.10060085f, -0.02753431f, 0.13397416f, -0.01558162f, 
    0.02950174f, -0.04253069f, -0.00843761f, 0.09258852f, 0.26845336f, 0.12930778f, 0.14740171f, 0.20556223f, 
    -0.04503925f, 0.01667789f, -0.23287193f, -0.10602482f, -0.07727211f, 0.07316114f, -0.13614310f, -0.08272520f, 
    0.20950887f, -0.02916519f, -0.12962510f, 0.08293913f, 0.08177900f, 0.04049405f, 0.12485555f, 0.02505310f, 
    0.05695262f, -0.19301637f, 0.16366184f, -0.04879560f, 0.02705161f, 0.05638999f, 0.06320818f, -0.06771705f, 
    -0.05568071f, -0.00166649f, -0.02279167f, 0.08817725f, 0.28165254f, 0.21667460f, 0.05039040f, 0.04193806f, 
    0.23601612f, -0.02077444f, -0.17676473f, 0.16546208f, -0.02024501f, 0.01840790f, -0.00822454f, -0.00251379f, 
    -0.00258476f, 0.00416407f, 0.15930741f, 0.18788527f, 0.07558454f, 0.09999290f, 0.20554504f, 0.06719396f, 
    0.01861475f, -0.08177923f, 0.02323273f, 0.10163993f, 0.00439079f, 0.07166883f, -0.04036358f, -0.03938543f, 
    0.10256348f, 0.11336728f, 0.14614657f, 0.05633058f, -0.05203684f, -0.09154083f, -0.00491081f, -0.02113426f, 
    0.03450512f, -0.11644210f, -0.00709441f, -0.13286778f, 0.17006612f, -0.09014297f, 0.22304638f, 0.29452068f, 
    -0.08988278f, 0.05745248f, 0.13886036f, 0.00738522f, -0.02884270f, 0.15676923f, 0.09270432f, 0.07341976f, 
    0.20852003f, -0.26868019f, 0.14496329f, -0.34806859f, -0.00148775f, 0.15189509f, -0.04705961f, 0.07166290f, 
    0.10952771f, -0.08008587f, 0.11831305f, -0.04643434f, 0.49132606f, 0.07961118f, -0.04268989f, -0.06714604f, 
    -0.05233338f, -0.01585753f, -0.08928058f, -0.03974909f, 0.02254668f, 0.06734929f, -0.07698356f, 0.00919404f, 
    0.16000591f, -0.09343609f, -0.00814592f, -0.08976108f, 0.15806521f, -0.04676107f, 0.07483621f, 0.12663105f, 
    0.08053069f, -0.21458621f, 0.11269613f, -0.07451809f, 0.03356998f, 0.05698138f, 0.09311045f, 0.00244387f, 
    -0.02367044f, 0.03313174f, 0.02516199f, -0.12235119f, -0.03421095f, 0.10192927f, 0.08537950f, 0.12796943f, 
    -0.21739577f, 0.05150122f, -0.08121295f, 0.01164447f, -0.04504229f, -0.03745497f, 0.05281646f, -0.04935519f, 
    -0.02538741f, -0.04400264f, 0.05401487f, -0.10574830f, -0.09003966f, -0.05441706f, -0.12577847f, 0.12620603f, 
    0.22926490f, 0.01136599f, 0.07046345f, 0.04311995f, -0.02562327f, 0.01998378f, -0.03729222f, -0.23467457f, 
    -0.16587144f, -0.03161388f, 0.09650384f, 0.13696837f, 0.12306014f, 0.00655112f, 0.08284220f, 0.03908234f, 
    -0.00513737f, -0.05794725f, 0.05893800f, -0.00749012f, 0.09760808f, -0.13352770f, 0.09864926f, 0.03980023f, 
    0.02073956f, -0.01389299f, 0.09495506f, -0.01313363f, 0.07593028f, 0.04489093f, -0.21969180f, 0.04745376f, 
    0.08642914f, 0.07839026f, 0.03816445f, -0.00922108f, 0.01801209f, -0.06005957f, -0.08782412f, -0.04266001f, 
    0.07435226f, 0.02280242f, 0.07280575f, 0.00539570f, 0.11211178f, -0.09591731f, 0.12182905f, -0.03383829f, 
    0.05475326f, 0.12839420f, 0.01377207f, -0.03987871f, 0.05071022f, 0.07093404f, 0.05727324f, -0.08857311f, 
    0.30975819f, 0.04829942f, -0.11177714f, 0.14885248f, 0.07512353f, 0.11375125f, 0.08190820f, -0.05078784f, 
    0.04172449f, -0.04326270f, 0.01967917f, 0.15855730f, -0.14433721f, -0.04340163f, -0.06896171f, -0.10576540f, 
    0.01759056f, -0.05498570f, 0.06027532f, -0.01190218f, -0.19513226f, 0.17896900f, 0.15082864f, 0.15383987f, 
    0.04523934f, -0.02825950f, -0.09080040f, 0.18899363f, -0.03812416f, 0.06753153f, 0.01484003f, -0.04574923f, 
    0.07836878f, -0.07244405f, -0.01846976f, -0.04627860f, 0.28212941f, -0.04595784f, -0.11500990f, 0.16440772f, 
    0.09249205f, 0.16464262f, 0.06183137f, 0.19852978f, -0.01390032f, -0.19324362f, 0.01843857f, 0.03981059f, 
    -0.22380991f, 0.07585147f, -0.05411877f, -0.06540015f, 0.04588103f, -0.01712076f, -0.00052192f, 0.07288204f, 
    0.08818278f, 0.04861190f, 0.01731774f, -0.00949425f, -0.21984841f, -0.06927160f, 0.23883158f, 0.18052676f, 
    0.16743051f, 0.16746727f, 0.11373003f, 0.04866857f, -0.05725566f, 0.06672080f, 0.09414116f, 0.09731073f, 
    0.00995539f, 0.15616527f, 0.04563911f, -0.01571678f, 0.01854669f, 0.15525097f, -0.03560342f, -0.12860219f, 
    0.03109107f, -0.03324538f, 0.12007012f, 0.01232399f, -0.19719571f, 0.11555766f, 0.17807205f, -0.13707104f, 
    0.09108054f, 0.02780034f, 0.12791665f, -0.04844310f, -0.01350604f, -0.01628312f, -0.00286681f, 0.08942377f, 
    0.04859067f, 0.04953771f, 0.16646953f, -0.01669960f, -0.04760699f, 0.07760946f, 0.18494573f, 0.15785874f, 
    0.04693765f, 0.08377185f, 0.03002462f, -0.10303785f, -0.13511547f, 0.00910859f, -0.03835605f, 0.22259662f, 
    0.04167158f, 0.09637716f, 0.06683231f, 0.05233230f, 0.07233834f, -0.05441647f, 0.05925248f, 0.13440846f, 
    -0.25863528f, 0.12556133f, -0.10348261f, 0.04483305f, 0.13195911f, 0.01633144f, 0.06460362f, 0.12576868f, 
    -0.00839399f, 0.03741062f, 0.02300481f, 0.08242194f, -0.06697595f, -0.10031077f, 0.04722956f, 0.00854300f, 
    0.09851177f, -0.02477712f, 0.05283016f, -0.02988801f, 0.03817258f, 0.01576415f, -0.08212599f, -0.05542685f, 
    -0.03807727f, -0.05769709f, 0.18214701f, 0.05435054f, -0.05436453f, 0.00558668f, -0.08646140f, 0.10354657f, 
    0.03573198f, -0.05077187f, -0.02035256f, 0.00844100f, 0.01648425f, 0.02419398f, -0.19467141f, -0.02384612f, 
    0.11270502f, 0.02832828f, 0.11476889f, 0.10489226f, 0.14474569f, 0.05562349f, -0.01237099f, -0.00669223f, 
    0.17640582f, 0.01298041f, -0.06255177f, 0.07871786f, -0.02891623f, 0.14201923f, -0.16127564f, 0.04443801f, 
    0.01432754f, 0.06720405f, 0.05867086f, -0.01200222f, -0.08223503f, 0.11865828f, -0.13508905f, -0.03725151f, 
    0.16624786f, -0.00145906f, 0.19312936f, 0.14737432f, 0.10541195f, -0.01290042f, 0.14342895f, 0.04359280f, 
    -0.10646835f, 0.02324939f, 0.22602674f, 0.12130979f, -0.12111765f, 0.01776323f, -0.12714076f, 0.00735233f, 
    0.04434218f, 0.15493740f, -0.05233612f, 0.03517426f, 0.11779206f, -0.03968516f, -0.00846962f, 0.00559929f, 
    0.19169919f, 0.00576766f, 0.05290366f, -0.03625518f, -0.07694515f, -0.12077296f, 0.01318908f, 0.03621170f, 
    -0.14194258f, 0.11867501f, 0.27358684f, -0.03796986f, 0.02496546f, 0.03876901f, 0.05232573f, 0.02286261f, 
    -0.02412636f, -0.00283954f, 0.09612757f, -0.06892923f, 0.17561434f, 0.06498750f, -0.04619764f, 0.09464572f, 
    0.02243925f, 0.15118128f, 0.03584273f, 0.00813538f, 0.09312585f, 0.02877280f, 0.12373041f, -0.03389990f, 
    -0.29644671f, 0.36447975f, -0.05419549f, -0.07579444f, -0.02074670f, 0.07913338f, 0.03665634f, 0.05557299f, 
    -0.04246183f, 0.13003552f, -0.02840316f, 0.02440367f, -0.12708835f, 0.20679539f, -0.07371052f, -0.11158533f, 
    0.03553634f, -0.01252878f, -0.00413570f, 0.03649761f, -0.06529289f, -0.05554490f, -0.04462868f, 0.03983355f, 
    0.03113507f, 0.19356780f, 0.03501533f, 0.39581695f, 0.04733569f, -0.02301037f, 0.06277619f, 0.11396782f, 
    -0.01370769f, 0.10238777f, -0.00870769f, 0.06267153f, -0.34324056f, -0.08862891f, 0.30004007f, 0.02043085f, 
    -0.07559803f, 0.08176691f, 0.08278766f, 0.08412936f, 0.11729728f, 0.02243921f, 0.03093145f, -0.06960528f, 
    0.18035790f, 0.09014510f, 0.10841026f, 0.09715948f, -0.07546178f, 0.11024442f, -0.01052965f, 0.00009946f, 
    -0.01402607f, 0.11397848f, -0.00782105f, 0.13329543f, -0.19444463f, 0.07465484f, -0.07299244f, -0.06451023f, 
    0.06135075f, -0.02601071f, -0.00095125f, 0.08644170f, 0.00398790f, 0.04387891f, -0.03295994f, -0.06137335f, 
    0.06682659f, 0.18016313f, 0.03300104f, 0.07814494f, 0.08958630f, 0.07812683f, -0.01250110f, 0.07851046f, 
    -0.03449052f, 0.03651788f, 0.04557163f, 0.20903125f, 0.22652020f, 0.14412862f, 0.21888076f, 0.11496315f, 
    0.04270630f, 0.12917393f, -0.04657540f, 0.03111546f, -0.03472599f, 0.04927072f, -0.01189587f, 0.24507123f, 
    -0.06432690f, -0.03317867f, 0.03423695f, 0.18544321f, 0.07469226f, 0.13764508f, -0.01600118f, 0.09302963f, 
    -0.01727229f, 0.02498385f, 0.02736031f, -0.00763754f, -0.08440217f, 0.21996346f, 0.08980347f, -0.08228203f, 
    0.04203984f, 0.03327579f, -0.05132884f, -0.01525026f, -0.07268273f, -0.00794466f, 0.11191806f, 0.00140972f, 
    0.19898903f, 0.09869605f, 0.05326745f, 0.09386291f, 0.03407180f, 0.06996626f, 0.10747744f, 0.06049657f, 
    0.01656756f, 0.04407028f, 0.03452860f, 0.08712574f, -0.11182185f, 0.26427922f, -0.00914171f, 0.06763014f, 
    -0.02341314f, -0.06790148f, 0.01081071f, 0.06051748f, 0.02397039f, 0.01834887f, 0.04822323f, 0.14454249f, 
    -0.20816852f, -0.10612187f, 0.35702863f, -0.05803975f, -0.13688850f, -0.07246286f, -0.08686548f, -0.01464416f, 
    0.05593026f, -0.00384589f, 0.05846702f, -0.02468566f, 0.04209371f, -0.14943482f, 0.11674070f, 0.20447022f, 
    0.16550043f, 0.11843313f, 0.03067332f, 0.03078172f, 0.22214630f, -0.09524848f, -0.08948737f, 0.01804718f, 
    -0.16045401f, 0.11360290f, 0.02817282f, 0.02508726f, 0.11189931f, 0.02020283f, -0.09349773f, -0.09498505f, 
    0.04958888f, -0.14145154f, -0.03645168f, 0.02710363f, 0.37000048f, 0.17796139f, -0.09667726f, 0.18862712f, 
    0.09812746f, 0.01398818f, -0.10474407f, 0.01239455f, 0.01274552f, 0.10001819f, 0.06856991f, 0.07279494f, 
    0.07628724f, -0.00199128f, -0.04861761f, 0.02013078f, 0.05867616f, 0.00850271f, 0.08747417f, -0.08735810f, 
    -0.03181927f, 0.05702759f, 0.12768123f, -0.05968169f, 0.24197714f, -0.05186171f, 0.00807544f, -0.16118693f, 
    0.05565367f, 0.20136374f, 0.10039579f, 0.06262995f, -0.02586066f, 0.11902679f, 0.02758125f, 0.03345275f, 
    -0.37661362f, 0.30842686f, 0.08887321f, -0.17846815f, 0.08048408f, 0.04853853f, -0.04956334f, -0.12984392f, 
    -0.08202028f, -0.04540619f, 0.10222194f, 0.02901451f, 0.02671863f, -0.00360554f, 0.20709983f, 0.21406758f, 
    -0.04118935f, 0.06047874f, 0.12597129f, 0.05490858f, 0.09337374f, 0.11887138f, -0.02223244f, -0.06827979f, 
    -0.33886981f, 0.06675396f, 0.27556041f, 0.22312403f, 0.06866630f, -0.00865445f, -0.03505330f, 0.09923794f, 
    -0.01478967f, 0.13658756f, 0.02682962f, 0.04202670f, -0.13195407f, -0.26823395f, 0.06061238f, -0.18959787f, 
    0.03628182f, 0.13466865f, 0.06994568f, -0.05716528f, 0.00067821f, -0.00356653f, 0.06592271f, 0.00327100f, 
    -0.17874832f, 0.02003606f, 0.06523208f, -0.06365614f, 0.00353263f, 0.07941427f, 0.01557654f, -0.06050214f, 
    -0.02219233f, -0.05942884f, -0.02771157f, -0.08143054f, 0.04456530f, 0.05851971f, 0.03952599f, -0.05004754f, 
    -0.00964249f, -0.00683982f, 0.11023676f, -0.08560593f, -0.02325591f, 0.07046759f, -0.03833001f, -0.07337693f, 
    -0.05213610f, 0.07814895f, -0.02523598f, -0.04635028f, -0.04542659f, 0.10473743f, -0.09497775f, -0.00497043f, 
    -0.06438782f, -0.02283085f, -0.06517065f, 0.03932320f, 0.05684063f, -0.15359356f, -0.02563942f, -0.10537399f, 
    0.14700985f, 0.04927180f, 0.07274602f, 0.04534417f, 0.12897570f, -0.02413332f, 0.02848364f, 0.06363040f, 
    0.18653458f, 0.11021057f, -0.15383683f, -0.28188694f, 0.10138045f, -0.09445161f, -0.03368888f, -0.17817713f, 
    -0.05482264f, -0.00441150f, 0.05998597f, 0.02940685f, 0.05812665f, -0.02260919f, -0.06844593f, -0.12860321f, 
    -0.03131550f, -0.03338865f, -0.01246592f, -0.17641945f, -0.01648533f, -0.15435515f, 0.05766878f, 0.15759635f, 
    -0.10807446f, -0.07529568f, 0.06224129f, -0.23925035f, 0.01897024f, -0.09242234f, -0.06207575f, -0.02120247f, 
    -0.12059885f, 0.04618066f, 0.11856689f, -0.00810154f, -0.19123870f, -0.14110479f, 0.07012911f, -0.11756423f, 
    -0.00072665f, 0.08804930f, 0.16036524f, 0.05521118f, 0.05296084f, 0.01267951f, 0.00573241f, -0.02063443f, 
    0.14238982f, -0.10787874f, 0.24261157f, 0.11095011f, -0.05064848f, -0.05229968f, 0.02754422f, 0.06410017f, 
    0.00309352f, -0.01966909f, 0.05059956f, -0.04730188f, -0.08675850f, 0.18285470f, 0.18313751f, -0.19045204f, 
    -0.07604197f, 0.01516004f, 0.02039782f, -0.15886578f, -0.13039704f, 0.02648705f, 0.10771091f, 0.15980986f, 
    0.18499455f, -0.17361180f, 0.03806178f, -0.18883710f, 0.11461321f, 0.05508591f, 0.02284773f, -0.05786481f, 
    0.03294531f, -0.03335048f, 0.05203814f, -0.04921451f, 0.07808871f, -0.03723407f, -0.38029644f, -0.29705158f, 
    0.04420749f, -0.04225715f, -0.04762147f, 0.01003955f, -0.01456037f, 0.01861559f, 0.04963749f, 0.00745516f, 
    0.14874217f, 0.29618698f, 0.13511379f, 0.05300050f, 0.05600140f, 0.14952233f, -0.02218596f, 0.02022970f, 
    0.15099455f, 0.07023986f, 0.00580382f, 0.08106132f, -0.09330354f, -0.15877873f, -0.15839155f, 0.32363462f, 
    0.00994339f, 0.04746287f, 0.10091221f, 0.02307133f, 0.09636135f, 0.12670831f, 0.03477963f, 0.01676044f, 
    0.22665486f, 0.06574945f, -0.11955138f, -0.02224758f, -0.01425369f, 0.04602121f, 0.07217340f, 0.13064387f, 
    -0.06534145f, -0.02770235f, 0.07564321f, 0.02430825f, -0.09927683f, -0.04094982f, 0.01115375f, -0.04116254f, 
    0.13208568f, -0.06449846f, 0.08057472f, 0.05150625f, -0.06699382f, -0.05571770f, 0.01035592f, 0.04648422f, 
    0.26399946f, 0.06636231f, 0.08272709f, 0.14852640f, 0.07093013f, 0.04036726f, 0.03364035f, 0.03616372f, 
    0.04037857f, 0.06273160f, 0.05376350f, 0.13031775f, 0.11274865f, 0.12060959f, -0.12448338f, 0.03619530f, 
    0.12578425f, 0.12952884f, -0.02483772f, -0.02221793f, -0.04915600f, 0.10067970f, 0.00004283f, 0.13087660f, 
    -0.05831601f, 0.12115500f, 0.06773926f, -0.14938851f, 0.06513324f, -0.10309404f, 0.07548998f, -0.04139429f, 
    -0.00573280f, 0.21393394f, -0.00894962f, -0.23917316f, -0.25500867f, 0.04278130f, 0.08516908f, -0.10500116f, 
    0.11035066f, -0.01057261f, -0.06119512f, -0.08682163f, 0.01146412f, -0.02595005f, 0.04717487f, -0.03909781f, 
    -0.04237669f, -0.07136483f, 0.09052366f, -0.19663264f, 0.03773894f, -0.03433770f, 0.06483934f, 0.00189423f, 
    0.06843168f, -0.08756205f, 0.02581559f, 0.00272481f, -0.15441093f, 0.28763586f, -0.01457419f, -0.09514365f, 
    0.06965388f, -0.02997421f, 0.00229197f, 0.01251420f, -0.00573429f, 0.10564138f, 0.08481866f, 0.10903160f, 
    -0.11979158f, 0.01830385f, -0.01478895f, -0.15399572f, 0.05737645f, -0.08637371f, -0.11019178f, -0.00997841f, 
    -0.08421268f, -0.03031302f, 0.13364682f, -0.02502804f, 0.07285818f, 0.01489234f, -0.09657471f, 0.06461844f, 
    0.07839363f, 0.02958826f, 0.05648441f, 0.02115297f, 0.05016806f, 0.01948621f, -0.02298607f, -0.09670482f, 
    0.00842979f, -0.01151775f, 0.03685648f, -0.04165001f, -0.05596277f, -0.04448925f, -0.05779009f, 0.00137960f, 
    -0.00344834f, -0.01662850f, 0.02896118f, 0.00696862f, 0.02995754f, -0.04266710f, 0.03641057f, 0.01848679f, 
    0.01125797f, 0.01638529f, 0.01861922f, 0.04310015f, 0.00312651f, 0.03682383f, 0.01057936f, 0.01101067f, 
    0.02523330f, -0.03383666f, 0.01207353f, -0.04245037f, -0.02596049f, -0.01833859f, -0.03097806f, 0.01815841f, 
    -0.05155165f, -0.05043729f, -0.03541783f, -0.03304752f, -0.02580781f, 0.03552983f, 0.00498725f, 0.01706625f, 
    -0.03055670f, -0.01548615f, 0.03588309f, -0.05155496f, -0.01853576f, 0.04215920f, -0.05650751f, 0.03961851f, 
    -0.02037937f, 0.03324464f, -0.03399040f, 0.03554497f, -0.00151712f, 0.01659542f, 0.00076010f, -0.01272089f, 
    0.00016040f, 0.00844966f, 0.03848968f, 0.01807411f, -0.00079992f, -0.06000140f, -0.03277449f, 0.01472375f, 
    -0.05594943f, 0.02768770f, 0.02104284f, -0.03836875f, 0.02307378f, 0.03398789f, -0.02467676f, -0.01410168f, 
    -0.05427085f, -0.01460158f, -0.04607593f, 0.01320066f, -0.02449776f, 0.03228643f, -0.00804573f, 0.03707860f, 
    -0.00715531f, 0.01213683f, -0.03537298f, 0.01078888f, -0.04060106f, -0.02047793f, -0.05588588f, 0.01402603f, 
    0.00771510f, 0.03832544f, -0.04465086f, 0.00226354f, 0.00444203f, 0.03954244f, -0.04176608f, 0.01005630f, 
    -0.01221270f, 0.02076834f, -0.00873974f, 0.02559919f, -0.01167016f, 0.02908950f, -0.05414787f, 0.00822373f, 
    0.00931129f, 0.01410437f, 0.01490894f, 0.03757689f, -0.05069547f, -0.03094747f, -0.04258717f, 0.01810035f, 
    -0.01792989f, 0.00444469f, -0.00869212f, -0.00522676f, -0.05465248f, 0.01552016f, 0.00610971f, -0.01163781f, 
    0.00545227f, -0.01385663f, 0.03780678f, 0.02344358f, 0.00495907f, -0.04672725f, -0.01471577f, -0.02662570f, 
    0.00328006f, 0.00970634f, -0.05524787f, 0.03713747f, 0.03775648f, 0.02121419f, 0.01767701f, -0.02718156f, 
    0.00679824f, -0.05929039f, 0.02484343f, -0.00813251f, 0.01995455f, 0.00554651f, -0.03250244f, 0.02724568f, 
    -0.05715240f, -0.01711873f, -0.05295337f, 0.00884959f, 0.01022778f, 0.03369927f, -0.00753575f, -0.02842531f, 
    -0.03029803f, -0.05343937f, 0.03406056f, -0.04919948f, -0.00912938f, 0.01398796f, -0.01921760f, -0.02696672f, 
    -0.04513075f, -0.01650280f, -0.03373667f, 0.03767730f, 0.02190429f, -0.02134802f, 0.02799896f, 0.01725612f, 
    -0.00623967f, -0.01673412f, -0.00672808f, -0.05429984f, -0.04580290f, 0.02317316f, -0.02063894f, -0.05788124f, 
    -0.04073950f, -0.04983264f, -0.05840130f, 0.03054504f, 0.03406610f, 0.00649568f, -0.05785289f, -0.05691275f, 
    -0.01836122f, -0.01911080f, -0.04696644f, 0.00834686f, 0.01619266f, -0.03663905f, -0.05287960f, 0.01980739f, 
    -0.02194718f, 0.00408281f, -0.00645568f, 0.00169291f, 0.00327735f, -0.04428880f, 0.02993734f, -0.04931147f, 
    -0.03828453f, 0.02793965f, -0.03245971f, -0.05057585f, 0.05253246f, 0.00128050f, 0.03986727f, -0.00999229f, 
    0.02719622f, 0.03939584f, 0.03736667f, -0.03667650f, 0.02499520f, -0.03295010f, 0.01010568f, -0.05226309f, 
    0.01262052f, 0.03911075f, 0.03982359f, -0.03523699f, -0.04490925f, -0.01787437f, -0.00368199f, -0.01975634f, 
    -0.01583337f, 0.04267703f, 0.01712102f, 0.03788442f, 0.01021230f, 0.00721479f, -0.00645182f, 0.03223781f, 
    0.00846699f, -0.00482515f, 0.03481745f, 0.03641212f, -0.02317142f, -0.03339474f, -0.04343206f, -0.03345902f, 
    -0.04806955f, 0.01007827f, -0.01671245f, -0.02395182f, -0.05816499f, -0.01024895f, -0.00815803f, -0.05205798f, 
    -0.02409511f, 0.01439736f, -0.04501797f, 0.01652466f, 0.03256741f, -0.02860242f, -0.02070639f, 0.00169880f, 
    0.01629127f, -0.04090877f, 0.03533073f, -0.00415812f, -0.05681590f, -0.02036622f, -0.05331993f, -0.01218142f, 
    0.03930236f, -0.04503299f, 0.03311850f, -0.03893372f, 0.03500316f, -0.00486758f, 0.01087810f, -0.04806021f, 
    -0.02146935f, -0.03986922f, -0.02135550f, 0.02793103f, 0.00099158f, -0.00904416f, -0.04747573f, 0.03308095f, 
    0.00306747f, -0.04256284f, -0.04025961f, -0.05210034f, -0.03950425f, -0.03655484f, 0.03305877f, -0.01568452f, 
    -0.05732133f, 0.03653016f, -0.01583801f, 0.00139460f, -0.04561316f, -0.00429129f, -0.00353116f, -0.05563505f, 
    0.02516681f, -0.05316303f, -0.04432434f, -0.04893850f, -0.03990298f, 0.04055236f, -0.00583059f, 0.00042591f, 
    -0.00046529f, -0.02767517f, 0.02482069f, 0.01923355f, -0.02344394f, -0.06009636f, 0.01161152f, -0.01238863f, 
    -0.00225694f, 0.04568992f, 0.04032182f, 0.04647591f, -0.04675901f, -0.01642268f, -0.05417799f, -0.03909639f, 
    -0.03649361f, 0.03239036f, -0.00978336f, 0.00839041f, 0.00438627f, -0.04413643f, 0.03066909f, 0.03608794f, 
    0.03716540f, -0.01271886f, -0.01826968f, 0.03677865f, -0.04861972f, 0.03051824f, -0.03394434f, 0.02730526f, 
    0.03186369f, -0.00293270f, -0.04719006f, -0.02148899f, -0.04755375f, -0.02231739f, 0.02965465f, -0.00844071f, 
    0.01807382f, -0.03471969f, -0.05542666f, -0.02485452f, 0.00717913f, -0.01498884f, 0.03417143f, -0.02107386f, 
    -0.01282798f, -0.04863173f, 0.00799622f, 0.01032639f, -0.01051380f, 0.00700882f, -0.01460638f, -0.01836959f, 
    0.00901493f, -0.03604083f, -0.01376748f, 0.01080287f, -0.01304604f, -0.03103743f, -0.05747912f, 0.02593011f, 
    0.00337623f, 0.03015692f, -0.00939661f, -0.03215207f, -0.05018079f, 0.02107036f, -0.00069230f, 0.03628371f, 
    0.00084754f, -0.02074409f, -0.02734686f, -0.01145260f, -0.04739676f, 0.00945402f, 0.03918695f, 0.02894707f, 
    0.15625025f, -0.15587610f, -0.01926667f, 0.12541902f, -0.09078891f, 0.05091341f, 0.11992012f, -0.05727086f, 
    -0.02692160f, -0.01934768f, 0.02514239f, -0.05786765f, -0.05283087f, -0.27275017f, 0.00813839f, -0.00762502f, 
    0.07051317f, 0.07760286f, 0.04762322f, 0.00951401f, 0.00978289f, -0.22880127f, 0.03598438f, 0.13539892f, 
    -0.24272749f, 0.04557335f, 0.14224266f, -0.01351447f, -0.02546446f, -0.09469378f, -0.12996721f, -0.07746772f, 
    0.02651945f, 0.07723401f, 0.10702615f, -0.10240962f, -0.43272203f, -0.07957442f, -0.16614424f, 0.01194170f, 
    0.00198837f, 0.09432726f, 0.09279822f, 0.11410119f, -0.04912462f, 0.03926791f, 0.10671421f, 0.03520292f, 
    0.13840061f, -0.11998617f, -0.07918780f, 0.19983520f, 0.08240179f, -0.07765166f, 0.06683415f, -0.26650506f, 
    -0.02839887f, -0.04201930f, 0.13247401f, 0.00928005f, -0.25035256f, 0.15054597f, 0.13122739f, -0.32236493f, 
    -0.05656893f, 0.00434339f, -0.00672422f, -0.11842804f, 0.08308524f, -0.05434418f, 0.07698572f, 0.17675336f, 
    0.33669934f, -0.11518089f, 0.18216117f, -0.40337133f, 0.00284117f, -0.00712675f, 0.06019828f, 0.15346956f, 
    0.10000735f, 0.09349369f, 0.02898219f, -0.08028361f, -0.19955504f, 0.02227331f, -0.26478729f, -0.03271418f, 
    0.04309854f, 0.05526264f, 0.14382067f, 0.10558680f, 0.11275423f, -0.01530913f, 0.01891554f, 0.14820096f, 
    -0.15084057f, 0.04470830f, -0.31684646f, -0.02054075f, 0.08932458f, 0.11157041f, -0.03742555f, 0.04586438f, 
    0.04625666f, 0.03449028f, -0.05607367f, 0.14156844f, -0.06156528f, -0.15785731f, 0.00708501f, -0.00512197f, 
    0.11830365f, -0.08379881f, 0.03373714f, -0.11966085f, 0.01956321f, 0.09470238f, -0.07827034f, -0.12130016f, 
    0.15771879f, 0.00254872f, 0.12473503f, 0.02212970f, 0.07007805f, 0.09344993f, -0.13131644f, -0.07536743f, 
    -0.01984574f, -0.11181664f, -0.00129727f, 0.07188439f, -0.02836381f, 0.09583233f, -0.06029545f, 0.09966847f, 
    0.15764350f, -0.02050490f, -0.00069396f, 0.06591360f, 0.08592542f, 0.08515903f, -0.00572564f, -0.07359751f, 
    0.27360636f, -0.03102780f, -0.16786908f, 0.19093260f, 0.02091063f, 0.04349823f, -0.22098212f, -0.01760759f, 
    -0.05495317f, 0.05752341f, -0.02389880f, 0.00899878f, 0.09329867f, -0.07587605f, -0.27520740f, 0.12307735f, 
    0.23747021f, 0.03117794f, 0.05000026f, 0.11548880f, 0.07138579f, -0.03267857f, 0.14208077f, 0.02434108f, 
    -0.00756969f, -0.17070450f, 0.08014762f, 0.28002071f, -0.03658092f, 0.00365079f, -0.13140474f, -0.19248964f, 
    -0.04085457f, 0.20874430f, -0.13422060f, 0.16591035f, 0.24028781f, -0.21520141f, -0.06045521f, -0.37560561f, 
    0.00934857f, -0.03080407f, -0.03796786f, -0.10840942f, -0.06530485f, -0.17024635f, 0.02087746f, 0.06472877f, 
    0.10291562f, 0.29341412f, -0.07379256f, 0.01798728f, 0.00917734f, 0.11281078f, 0.01147156f, -0.01858630f, 
    -0.06589273f, -0.06019143f, 0.12616166f, -0.07257048f, 0.26663786f, -0.01451077f, -0.13991462f, 0.14152077f, 
    0.16635942f, -0.05120343f, -0.04769400f, -0.17034282f, 0.06332057f, 0.04014043f, 0.05224665f, -0.00899419f, 
    -0.34947288f, 0.28533238f, -0.09954958f, -0.00715124f, 0.00874055f, 0.05715511f, -0.00149227f, 0.02141281f, 
    0.05090149f, 0.05887614f, 0.08567365f, 0.12299927f, 0.18425097f, 0.19245395f, 0.03117820f, -0.02353219f, 
    0.10070164f, 0.03550320f, -0.19553745f, -0.07391007f, -0.07565958f, -0.09230141f, -0.08553841f, 0.03214797f, 
    -0.02992488f, 0.00030681f, -0.08352279f, 0.06570995f, 0.02735143f, -0.05968025f, 0.13850726f, 0.00410988f, 
    -0.00627662f, 0.05568946f, 0.05956132f, 0.14450522f, -0.31584373f, 0.16075578f, 0.12061024f, -0.10697131f, 
    -0.01153834f, 0.14838815f, 0.14037508f, -0.03166001f, 0.11646315f, -0.04199186f, 0.11383718f, -0.02996973f, 
    0.14977925f, -0.04636564f, -0.02074484f, -0.21868426f, -0.01422269f, 0.00673417f, 0.10331289f, 0.09786259f, 
    0.01102261f, 0.08018402f, -0.05462530f, 0.13848773f, 0.01354334f, 0.21461010f, -0.04889733f, -0.03535359f, 
    -0.03273680f, 0.04609704f, 0.00515580f, -0.01279159f, -0.01917449f, 0.02641978f, 0.10636188f, 0.06024409f, 
    -0.10589436f, 0.23964493f, -0.17495646f, -0.10937992f, 0.10513128f, 0.13828628f, -0.08423846f, 0.13575126f, 
    -0.00159088f, 0.04429810f, -0.04399920f, 0.13623630f, -0.05822880f, -0.23185422f, 0.16442686f, -0.03164110f, 
    -0.09097162f, 0.01162401f, -0.07744018f, 0.02834435f, -0.01700456f, 0.06049553f, -0.04291100f, 0.18322752f, 
    -0.00983405f, -0.31188586f, -0.17869726f, -0.06531499f, 0.07363904f, 0.01765191f, -0.04410096f, 0.12509675f, 
    0.02833494f, 0.13058899f, -0.13938305f, -0.02022014f, -0.13729490f, 0.09100153f, 0.10497432f, 0.08842181f, 
    0.09842875f, -0.06782907f, -0.09888947f, -0.13529038f, -0.10863605f, 0.05473652f, 0.08074502f, -0.08208919f, 
    0.29497722f, 0.09656734f, -0.00687641f, 0.33149788f, 0.15218322f, 0.04081557f, 0.01862587f, -0.04658309f, 
    -0.02061221f, -0.00156357f, 0.10787218f, 0.14694339f, -0.03445755f, 0.15837194f, 0.02404960f, 0.04077558f, 
    -0.11555351f, -0.04216968f, 0.03550801f, 0.02075017f, 0.06449160f, -0.00131583f, 0.03786352f, 0.10600020f, 
    0.10163189f, 0.00108461f, 0.30007309f, 0.02441521f, -0.07933999f, -0.02434747f, -0.14992891f, -0.05222978f, 
    0.02023075f, -0.11463234f, 0.07618193f, -0.04753342f, -0.21957831f, -0.26559761f, 0.16048497f, -0.01869912f, 
    0.05345946f, -0.15426712f, 0.01222878f, -0.04805619f, 0.15483327f, -0.02255565f, 0.05187761f, 0.06277651f, 
    0.01144742f, 0.04850602f, -0.08865596f, -0.00841396f, -0.07196324f, -0.10072884f, -0.03879337f, 0.11491603f, 
    0.01629490f, 0.16372055f, -0.00680355f, -0.09269659f, -0.21837069f, -0.02232565f, -0.09215958f, -0.07478050f, 
    -0.05490578f, 0.06994585f, -0.05317480f, 0.11952490f, 0.03277180f, -0.02477240f, 0.02893361f, -0.05694454f, 
    0.09346511f, -0.02473575f, -0.08165047f, -0.13797034f, 0.11420075f, 0.00063785f, 0.01311703f, 0.07734627f, 
    -0.03440753f, -0.05100730f, -0.07914139f, -0.01553313f, -0.32083410f, -0.02084065f, -0.11336374f, 0.34808779f, 
    0.03898292f, -0.10251343f, -0.09225582f, -0.01260641f, -0.01816399f, -0.04108106f, 0.04772181f, 0.01896982f, 
    0.33232850f, 0.03608171f, 0.10212314f, -0.23238190f, -0.02837770f, 0.09985787f, 0.06313508f, 0.07413540f, 
    0.01544050f, 0.01205796f, -0.15897533f, -0.02013970f, -0.11074568f, -0.01709999f, -0.02267862f, -0.02024583f, 
    0.26388314f, -0.00225377f, -0.01717422f, 0.14180985f, -0.14955959f, 0.08130470f, 0.12154133f, 0.10474933f, 
    0.05697967f, 0.09438953f, -0.20172186f, 0.11766940f, 0.03808788f, 0.06917781f, -0.05320990f, -0.12912108f, 
    0.03290539f, -0.09545029f, 0.01226799f, 0.02066357f, -0.21848787f, -0.09897988f, -0.09626643f, 0.07950273f, 
    -0.02674288f, 0.05223000f, -0.07404272f, 0.05424576f, -0.00064998f, 0.02265075f, 0.08742579f, -0.02847996f, 
    0.06136895f, -0.01040428f, 0.28065351f, -0.00529089f, -0.12342449f, -0.00900713f, -0.06437878f, 0.07830876f, 
    -0.04285166f, -0.07623742f, -0.07938965f, 0.09286751f, 0.04024189f, 0.03618697f, 0.17171255f, 0.03866894f, 
    0.04322067f, 0.06536049f, -0.11295445f, 0.04952194f, -0.05232067f, -0.06004585f, 0.02740789f, 0.09111647f, 
    -0.08331256f, 0.23769458f, 0.09458312f, 0.29346153f, 0.09662879f, 0.16730757f, 0.08902430f, -0.06420685f, 
    0.00260598f, 0.07008048f, 0.19699399f, -0.05629306f, 0.09793676f, -0.01331689f, 0.06103282f, -0.15342651f, 
    0.05929479f, 0.01791315f, 0.07932866f, 0.01264419f, -0.06009135f, 0.17591776f, 0.00796413f, -0.02346564f, 
    -0.28809270f, 0.15836756f, 0.26085728f, 0.02705866f, -0.05967460f, 0.08250612f, 0.01121224f, 0.05733689f, 
    -0.01327048f, 0.12235945f, 0.02504321f, 0.15239519f, 0.07434618f, 0.18022497f, 0.09800188f, -0.11540867f, 
    -0.06698978f, 0.02799095f, -0.06061569f, 0.07736748f, 0.00955342f, 0.09614549f, -0.02463507f, 0.09816471f, 
    0.11539099f, 0.17413394f, 0.09718426f, -0.09576253f, 0.12957665f, 0.16673410f, -0.05197870f, 0.02484667f, 
    0.06444407f, 0.03577569f, 0.09857377f, 0.06053122f, -0.09030554f, 0.11068439f, -0.23660140f, 0.24859263f, 
    0.05854493f, 0.00572014f, -0.01589317f, -0.01660276f, -0.05044353f, -0.02663842f, -0.06116734f, -0.21522602f, 
    0.15341635f, -0.03427460f, 0.11795226f, 0.03286136f, 0.13894948f, 0.08164061f, 0.10125664f, 0.07783999f, 
    0.04876910f, 0.01619101f, -0.07440159f, 0.16626535f, -0.06487148f, 0.15381448f, -0.01061323f, -0.19713464f, 
    0.17437622f, 0.01939207f, 0.01922010f, 0.06235056f, 0.01061710f, -0.01446557f, -0.12874685f, 0.11336146f, 
    -0.06784263f, -0.14749989f, 0.03301026f, -0.15998706f, 0.13636659f, -0.08782988f, -0.00712048f, 0.16913082f, 
    0.05768312f, 0.01117439f, 0.06546409f, 0.05991738f, -0.01523774f, 0.08973213f, 0.52221483f, 0.27762616f, 
    0.00754134f, 0.06096592f, 0.00205346f, 0.01426455f, 0.09810591f, -0.11924469f, 0.08023559f, 0.03066253f, 
    -0.27707046f, -0.21985826f, -0.20316206f, -0.00473250f, -0.07272018f, -0.04930198f, -0.03824350f, -0.06624827f, 
    -0.03125932f, -0.00308386f, -0.00518934f, -0.01328156f, 0.02087594f, 0.02608435f, 0.00412174f, 0.26193058f, 
    -0.06088997f, -0.03590233f, -0.06669242f, 0.04444598f, 0.16597223f, 0.02003891f, 0.02986679f, 0.11389520f, 
    -0.43544608f, -0.19700512f, -0.08147369f, 0.18641065f, -0.02836586f, -0.08885697f, -0.06226136f, 0.01856750f, 
    0.01087837f, -0.11259391f, -0.04253416f, 0.06459211f, 0.37431037f, -0.13441871f, 0.14267990f, 0.06557477f, 
    -0.01451587f, 0.12097788f, -0.08520897f, -0.00279313f, 0.00232215f, 0.11436466f, 0.03230734f, -0.03212551f, 
    -0.50952548f, -0.20570777f, -0.04654666f, -0.13742064f, 0.02412788f, 0.03140902f, -0.01843335f, 0.01255707f, 
    0.01503964f, -0.00746590f, -0.04858273f, 0.08121230f, -0.04051322f, 0.09514599f, 0.01891171f, 0.23561461f, 
    0.05026835f, 0.01863163f, 0.08584239f, -0.02809147f, -0.00416164f, -0.08500189f, 0.21483564f, 0.07165817f, 
    -0.01933076f, 0.07381956f, 0.08498447f, 0.04903880f, -0.01111545f, 0.14229965f, -0.04372607f, 0.06083641f, 
    0.02809410f, -0.03090251f, 0.09069867f, 0.04235843f, 0.49921480f, 0.00574237f, -0.01473382f, -0.13533968f, 
    0.04713284f, 0.01148550f, -0.00378248f, 0.18484375f, 0.01845071f, -0.10715970f, -0.00604312f, -0.04177195f, 
    0.02974093f, 0.20761508f, 0.15073699f, -0.17022422f, 0.06913643f, 0.02660695f, -0.00433455f, 0.02086614f, 
    -0.10355103f, 0.05952690f, -0.03520508f, 0.01313608f, 0.05761011f, -0.23653373f, 0.09075102f, -0.24965633f, 
    -0.00887164f, 0.08995844f, 0.01233849f, 0.08149733f, 0.14278550f, 0.02618209f, -0.03032168f, 0.01442496f, 
    -0.07457254f, 0.20618249f, 0.12415956f, 0.16818537f, 0.01619506f, 0.09598832f, 0.11184318f, -0.05989885f, 
    0.03609176f, 0.06559280f, 0.04567546f, 0.09036698f, -0.08002416f, 0.07985143f, 0.01305285f, -0.00382835f, 
    -0.01686238f, 0.03211801f, 0.06817526f, 0.08661643f, -0.03534222f, 0.13689074f, 0.04767482f, 0.13628723f, 
    0.05462505f, -0.06369389f, -0.01746037f, -0.02534568f, -0.01982896f, -0.03897829f, -0.01545189f, -0.00383897f, 
    0.03374168f, -0.03226675f, 0.00405718f, -0.01364148f, -0.00409725f, -0.02589872f, -0.01582905f, -0.04563181f, 
    0.04186087f, 0.01857642f, 0.02397822f, 0.02093151f, 0.04153777f, -0.02827200f, -0.03407320f, -0.01337492f, 
    -0.04121555f, -0.01862409f, -0.00648366f, -0.05056169f, -0.03922328f, 0.00351670f, 0.03953294f, -0.03564125f, 
    0.01492286f, 0.01289567f, -0.03262443f, 0.03535872f, 0.04592777f, 0.02545380f, -0.01868162f, -0.03282233f, 
    -0.03475456f, -0.00815435f, -0.01956602f, -0.02118878f, 0.03097869f, 0.03446981f, 0.00893455f, 0.00586474f, 
    0.00350895f, 0.01211735f, -0.01718433f, -0.05735487f, -0.00360105f, -0.01963387f, 0.02427083f, 0.01374610f, 
    0.01351621f, 0.04073694f, -0.05942144f, 0.04608428f, 0.03311445f, 0.04970975f, -0.00431971f, 0.01225232f, 
    -0.03232674f, 0.01109156f, -0.03232069f, -0.03392976f, -0.03330494f, -0.00412344f, -0.03887505f, 0.01559285f, 
    -0.03211876f, 0.02641299f, 0.00085116f, 0.03714584f, -0.02532688f, -0.01001784f, -0.01891551f, 0.03395666f, 
    -0.04169740f, 0.04434156f, 0.03246211f, -0.04325623f, 0.03398776f, -0.04621146f, -0.00212607f, -0.03114826f, 
    0.03991611f, -0.02867303f, 0.03251431f, -0.02224345f, 0.01986761f, -0.02533627f, -0.03524514f, -0.02703612f, 
    0.03874790f, -0.00861750f, 0.02516723f, -0.00506715f, 0.02558265f, 0.00442732f, 0.00678421f, -0.02964895f, 
    -0.04142813f, -0.03753227f, -0.00365536f, 0.02319835f, -0.03319352f, -0.01813583f, -0.01164210f, 0.02637247f, 
    -0.04071239f, 0.01716151f, -0.05762557f, 0.01595605f, -0.04891961f, -0.00009820f, -0.02945060f, 0.02886591f, 
    -0.01819707f, -0.01598196f, -0.02882745f, 0.00501956f, -0.00744336f, 0.01670741f, 0.03200759f, -0.02252088f, 
    -0.04360054f, 0.01742093f, -0.04370203f, -0.01367736f, -0.04590702f, -0.01461420f, 0.03376132f, -0.00103323f, 
    -0.03369718f, 0.01413194f, 0.04029546f, -0.03427138f, -0.04276071f, 0.03959595f, -0.03518501f, -0.03113548f, 
    -0.03822031f, -0.04867481f, -0.03763663f, -0.03446285f, 0.01905719f, -0.01862242f, -0.03693355f, -0.01845874f, 
    -0.01670875f, -0.01496298f, -0.05431882f, -0.01185097f, -0.02318575f, 0.00977339f, -0.02049971f, -0.04740540f, 
    -0.04014570f, -0.02168383f, 0.02148232f, 0.00982963f, 0.02526339f, 0.02602750f, 0.01004884f, 0.04764316f, 
    -0.02997375f, -0.00292808f, -0.02989173f, -0.04036388f, 0.02168684f, -0.03282768f, -0.03910425f, -0.01130153f, 
    0.01108424f, 0.04016723f, -0.03582628f, -0.03646930f, 0.00100647f, 0.02160057f, -0.04998068f, -0.05826673f, 
    -0.03108616f, 0.02986844f, -0.01615046f, 0.02613761f, 0.00907254f, -0.01755515f, -0.02599155f, -0.05832898f, 
    0.01508893f, -0.01856597f, 0.01750764f, -0.02437237f, 0.01293806f, -0.03273979f, 0.00613092f, -0.01310557f, 
    0.03655015f, 0.00449954f, -0.04677490f, 0.04423235f, 0.02209244f, 0.02141817f, -0.01268671f, 0.00934110f, 
    -0.04014988f, -0.01437997f, 0.02534904f, -0.01953560f, 0.03296722f, -0.00397153f, 0.04146697f, 0.00905621f, 
    0.03674820f, -0.00288237f, 0.03865879f, -0.03500523f, -0.05699535f, 0.04541002f, 0.03301333f, 0.00502845f, 
    -0.05684679f, -0.04502526f, 0.03147902f, 0.02162563f, -0.04501268f, 0.04514433f, -0.01539813f, -0.05961543f, 
    -0.05691749f, -0.01599619f, -0.05180509f, 0.04105102f, -0.02034953f, -0.00479090f, 0.00413106f, -0.05118929f, 
    0.01788287f, 0.00398558f, 0.05622473f, 0.03169747f, -0.03707448f, -0.04991575f, 0.00314568f, 0.03227188f, 
    -0.03980267f, 0.05516569f, -0.03022080f, -0.02168643f, -0.02540176f, -0.04545709f, 0.00270637f, -0.00127441f, 
    -0.03399836f, -0.05095956f, 0.01745710f, 0.01003653f, 0.00548137f, -0.00715368f, -0.04340446f, -0.02348562f, 
    -0.05315394f, 0.03678161f, 0.03548376f, 0.01397526f, -0.05660098f, -0.04503855f, -0.00128457f, -0.02158047f, 
    -0.01699772f, -0.04112166f, 0.01757368f, 0.00449751f, 0.03536333f, -0.01076887f, -0.03232260f, 0.04846187f, 
    -0.03675789f, 0.04370276f, 0.01361801f, -0.03376142f, 0.04366795f, -0.04436324f, -0.04437866f, 0.04246116f, 
    -0.02814922f, 0.00326197f, -0.00926857f, -0.00028197f, -0.00232648f, 0.01036256f, 0.02074844f, 0.01132228f, 
    0.00052244f, -0.02713937f, 0.02449922f, 0.04600422f, 0.00929767f, 0.05164880f, 0.02656632f, 0.00155153f, 
    -0.01782093f, 0.02088865f, -0.03876068f, -0.01273748f, -0.03818830f, 0.02732868f, -0.00481904f, 0.01054152f, 
    0.02174265f, 0.01726330f, 0.05087806f, 0.00573516f, 0.01175683f, 0.02528120f, -0.01619797f, 0.00980714f, 
    -0.02205405f, -0.01560523f, 0.02289201f, 0.04269058f, 0.04371014f, -0.04940431f, -0.03440594f, 0.00225859f, 
    -0.04499596f, -0.05933842f, -0.00868294f, -0.03859637f, -0.00545743f, -0.00604367f, -0.04694270f, 0.03434376f, 
    0.01219069f, -0.05022388f, -0.04127614f, 0.03287011f, -0.05108557f, -0.05056289f, -0.00836213f, -0.02339107f, 
    -0.02287937f, 0.01233778f, 0.03037340f, 0.02338063f, 0.03664454f, 0.03940409f, -0.00933548f, -0.00047617f, 
    -0.02648561f, 0.00298312f, -0.02060979f, 0.03380636f, -0.01632911f, -0.01913353f, -0.01531095f, -0.00750326f, 
    -0.02658172f, -0.02101039f, -0.04362283f, 0.03365279f, -0.00330361f, -0.04679475f, -0.00649549f, -0.03074000f, 
    -0.03842922f, 0.01094045f, -0.00395953f, 0.02382846f, 0.00762374f, -0.00989521f, -0.01287212f, 0.05002911f, 
    -0.01431814f, -0.05210781f, -0.00290177f, -0.01164042f, -0.00874369f, 0.02940146f, 0.02329113f, -0.05065595f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.07534780f, 0.00361827f, 0.04753323f, -0.00326436f, -0.01667878f, 0.11246912f, 0.00663600f, 0.12607491f, 
    0.00736945f, -0.05142287f, -0.04578028f, 0.05159070f, 0.03763214f, 0.12183748f, -0.01715349f, 0.07168231f, 
    0.04023926f, -0.00886565f, -0.01115735f, -0.04336333f, 0.03435507f, 0.09801871f, -0.02859228f, 0.01179753f, 
    -0.03022981f, 0.04914054f, -0.02789773f, 0.05742034f, -0.04830266f, 0.07122914f, 0.05340605f, -0.03118615f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.16951343f, 0.06553011f, -0.36811626f, -0.15356632f, 0.52024072f, 0.27467743f, 0.27759820f, -0.11930186f, 
    -0.10700008f, 0.04638006f, -0.05690689f, 0.27454108f, 0.03756215f, -0.00886978f, 0.05971888f, 0.32557362f, 
    0.10442378f, -0.32156852f, 0.03792898f, -0.14548486f, -0.08467399f, -0.01678753f, -0.17784113f, -0.07521499f, 
    0.18770246f, -0.06124166f, 0.09578867f, 0.07465865f, 0.12964515f, -0.59132189f, -0.31669357f, -0.14806716f, 
    -0.13725327f, 0.06129320f, -0.15141757f, -0.10537696f, -0.14457068f, -0.17106894f, 0.14215489f, 0.09491626f, 
    -0.12344824f, -0.01398222f, 0.16102359f, 0.02111356f, -0.11367186f, 0.08267894f, -0.10253201f, 0.05643400f, 
    -0.18387641f, -0.15398055f, 0.02278903f, 0.13914141f, -0.10556059f, -0.09715150f, -0.06526098f, 0.10951389f, 
    -0.04499424f, -0.11865164f, -0.02928842f, -0.05014894f, -0.07498845f, -0.01923432f, -0.15113738f, -0.17150870f, 
    -0.08843059f, -0.03889520f, 0.37163618f, 0.13137147f, -0.25429368f, -0.20465277f, 0.02748182f, 0.03670019f, 
    0.13935171f, -0.03206237f, 0.13240257f, 0.13202679f, 0.05300044f, 0.13129561f, 0.06952555f, -0.11219478f, 
    0.32515827f, -0.17209515f, -0.02926476f, -0.09916633f, -0.16463712f, -0.01151791f, 0.25494266f, 0.70536411f, 
    0.36978328f, -0.36076477f, 0.27037194f, 0.02469674f, 0.11807802f, 0.01159328f, 0.30281365f, -0.00035882f, 
    0.30089599f, 0.12649436f, 0.37896892f, 0.01990441f, -0.05602546f, -0.12392748f, -0.26434028f, 0.22095588f, 
    -0.28500298f, 0.05558587f, -0.05108087f, 0.10389785f, -0.10841592f, -0.22172828f, 0.06851029f, -0.12506968f, 
    -0.02243377f, 0.21402025f, -0.06468354f, -0.10207772f, -0.05981711f, 0.18255889f, 0.19954535f, 0.02736043f, 
    0.20915186f, 0.39172027f, -0.21028562f, 0.00594610f, 0.11181817f, 0.01280978f, -0.04770024f, -0.00474145f, 
    0.27083620f, 0.18753482f, -0.08589235f, -0.08319677f, 0.20555545f, 0.03137055f, -0.37129891f, -0.49037817f, 
    -0.34572580f, -0.02625606f, 0.12749083f, -0.04525074f, 0.07865004f, -0.48715603f, 0.17442438f, 0.14247276f, 
    -0.27353698f, 0.46101716f, 0.08492287f, -0.00036070f, -0.09214810f, 0.17958345f, -0.04607211f, -0.16090924f, 
    0.43561089f, 0.40634385f, 0.09957126f, -0.01596974f, -0.11628765f, 0.33112815f, 0.17122938f, -0.18337959f, 
    0.02814120f, -0.16178603f, 0.04095220f, 0.15527412f, -0.14966322f, 0.12927984f, -0.00855264f, -0.01451336f, 
    0.10878095f, 0.04338961f, -0.14194074f, -0.14395185f, -0.12028320f, -0.04359311f, -0.07862715f, -0.04108081f, 
    0.14740896f, 0.00036571f, -0.01032682f, 0.11263960f, -0.12754676f, 0.03861472f, -0.04893935f, 0.01809767f, 
    -0.04156051f, -0.07793672f, -0.05795781f, -0.17093058f, -0.11274897f, 0.15102006f, -0.09242840f, -0.14758164f, 
    0.06925851f, 0.00006221f, -0.11253435f, 0.15160830f, -0.03910491f, -0.09910244f, 0.42543092f, 0.25243810f, 
    -0.10526804f, -0.11387279f, 0.15928307f, 0.29715466f, 0.09711470f, 0.38766658f, -0.11009400f, -0.04943928f, 
    0.03780030f, -0.20683277f, 0.08753494f, 0.14312679f, -0.03202074f, 0.07665882f, -0.10253917f, -0.34687886f, 
    -0.25946450f, 0.26996225f, -0.10147700f, 0.45102406f, 0.00840120f, -0.26346672f, -0.25252095f, 0.12566262f, 
    0.13029514f, 0.50842655f, 0.38395455f, -0.09140150f, 0.53826094f, 0.29933757f, -0.21395746f, 0.17054334f, 
    0.46217108f, 0.00255236f, 0.06257924f, -0.02579591f, 0.02821205f, 0.41332895f, 0.06781135f, 0.12000109f, 
    -0.31547663f, 0.04159621f, -0.07288031f, -0.01074767f, -0.17774571f, -0.14641055f, 0.32359529f, 0.14978749f, 
    0.39543897f, -0.22178678f, -0.04051710f, -0.06966901f, -0.06870416f, 0.02104933f, -0.04066242f, 0.16501294f, 
    0.03288059f, 0.38100892f, 0.52188319f, -0.07222306f, -0.09459361f, -0.00922357f, -0.00204070f, 0.13611171f, 
    0.49200726f, 0.11113181f, -0.14314209f, 0.20179778f, 0.13100287f, 0.13011964f, -0.15271018f, 0.15350422f, 
    0.24871296f, -0.34446427f, -0.06361426f, 0.10210361f, 0.15985949f, -0.16815595f, 0.02577976f, 0.26684180f, 
    0.35306659f, -0.26306000f, 0.14912418f, 0.32690695f, 0.17893726f, -0.07343999f, -0.07987296f, 0.12915561f, 
    -0.21262956f, -0.11513682f, -0.01515114f, 0.05523378f, 0.25429556f, 0.16164848f, -0.04384774f, -0.12749748f, 
    0.01244171f, -0.17327243f, 0.00673923f, -0.17997284f, 0.07125144f, -0.04474472f, -0.02603320f, 0.29736295f, 
    -0.39880627f, 0.26166293f, 0.00421419f, -0.14640476f, 0.15299138f, 0.06342839f, 0.23004223f, -0.18819420f, 
    -0.15405612f, 0.26172239f, 0.10991772f, -0.46364355f, 0.00454349f, 0.18955924f, 0.19933985f, -0.13881502f, 
    -0.17311108f, -0.17798960f, 0.15860035f, 0.13271283f, 0.09287167f, -0.13823961f, -0.12248927f, 0.09645760f, 
    0.04464833f, -0.05288921f, -0.12873703f, -0.14011747f, 0.07653756f, -0.12102564f, 0.16861135f, -0.12964709f, 
    -0.10411109f, 0.09044852f, -0.01454755f, 0.16611090f, -0.03187275f, -0.02253970f, -0.00441166f, -0.08693125f, 
    -0.07054809f, 0.03961577f, 0.02632027f, 0.16710466f, -0.16625029f, 0.17235416f, -0.17036398f, 0.13489182f, 
    -0.13945390f, 0.01908427f, 0.08199704f, 0.09456996f, -0.01722999f, 0.08579311f, 0.00976989f, -0.08641114f, 
    0.13600506f, -0.00864459f, -0.16688652f, -0.06964382f, -0.02419682f, 0.00483055f, 0.09700760f, -0.02071036f, 
    -0.02056438f, -0.04563671f, 0.11000741f, 0.16718589f, 0.12662573f, -0.18948111f, 0.06954508f, 0.00607925f, 
    0.14838992f, -0.04563399f, -0.17600246f, -0.01079454f, -0.15518571f, -0.04678841f, -0.04789942f, 0.07706987f, 
    -0.64820361f, -0.05267158f, -0.35648859f, -0.07128672f, -0.09887286f, 0.04397028f, 0.14932211f, 0.04910542f, 
    0.03838564f, -0.12944311f, -0.15737452f, 0.28991205f, 0.03800885f, 0.04366230f, -0.02557305f, 0.23633383f, 
    -0.19089288f, -0.19866216f, -0.11976028f, 0.05834728f, -0.01598908f, -0.23622020f, 0.29713002f, 0.05577854f, 
    0.08095056f, 0.14524363f, 0.06953507f, 0.00437063f, -0.10053305f, -0.13511403f, -0.24772474f, 0.14517207f, 
    -0.01236168f, -0.27148002f, -0.21529266f, -0.06601681f, -0.18637908f, 0.24863972f, 0.13428141f, 0.40944290f, 
    0.30549839f, 0.11846277f, 0.06864598f, -0.05348698f, 0.10813141f, 0.33434677f, -0.16188514f, 0.30417618f, 
    0.29333213f, -0.16129492f, -0.03452394f, -0.09950149f, -0.14376119f, 0.29646513f, -0.00777964f, -0.10126849f, 
    -0.52198964f, 0.12069831f, -0.17448631f, -0.24323039f, -0.12526263f, -0.18648578f, 0.39811480f, -0.08633926f, 
    -0.24871393f, 0.08603237f, -0.81295484f, 0.00258280f, -0.16290790f, 0.14451568f, -0.07303628f, -0.06547110f, 
    0.33755836f, 0.15507430f, -0.06035597f, 0.35383219f, 0.12498730f, -0.22369997f, 0.06121917f, 0.30383185f, 
    0.13455985f, 0.10396930f, 0.06726039f, -0.10544165f, -0.10706138f, -0.28879625f, 0.06619407f, -0.19690762f, 
    -0.12614676f, -0.07977079f, 0.31004512f, 0.05332586f, 0.11028836f, 0.23036653f, 0.00159997f, 0.19147080f, 
    -0.21683231f, 0.01716677f, -0.51449102f, -0.02467504f, -0.25891793f, 0.16157788f, 0.05579521f, -0.25213957f, 
    0.42697334f, 0.03236551f, -0.04859057f, -0.01377322f, -0.01171404f, 0.09121283f, 0.14321339f, -0.01842684f, 
    0.01978566f, 0.32350385f, -0.00834421f, -0.17712368f, 0.13707742f, 0.25603852f, 0.03929697f, -0.44306892f, 
    -0.37414598f, -0.08021636f, 0.33362132f, -0.14400432f, 0.09572468f, 0.69494414f, -0.01864750f, 0.16021621f, 
    0.16357417f, -0.14144394f, 0.03101207f, 0.16171375f, 0.06959265f, -0.10698576f, 0.03671575f, -0.09622364f, 
    0.03050124f, 0.06054642f, -0.13573828f, -0.13205017f, 0.17016587f, 0.10883351f, 0.10519899f, -0.10374114f, 
    0.05202610f, -0.08165624f, 0.03099344f, 0.08854627f, 0.08428606f, -0.13195969f, 0.11489122f, 0.12419586f, 
    -0.07787906f, 0.04918094f, -0.16767888f, 0.13723288f, 0.11058486f, -0.01313179f, -0.11587615f, -0.08487058f, 
    0.34439793f, 0.36178464f, 0.60626018f, -0.09454568f, 0.54227722f, 0.25989518f, 0.13027398f, -0.15213034f, 
    0.18008159f, 0.09656736f, 0.05111597f, -0.21711546f, -0.08831244f, 0.15570661f, -0.05992064f, 0.38315555f, 
    -0.17613386f, -0.01247420f, -0.07568619f, 0.14697284f, -0.10022141f, 0.24959251f, 0.03572621f, 0.07531350f, 
    0.15911153f, 0.10876444f, -0.18015043f, -0.05755758f, -0.15014993f, -0.51690698f, -0.04269408f, 0.06627987f, 
    -0.22611980f, -0.20738101f, 0.17526305f, 0.00263692f, 0.18969534f, 0.15443790f, 0.28254619f, -0.18290456f, 
    -0.27553204f, -0.00610790f, 0.01748006f, 0.02203702f, 0.04143476f, 0.28771642f, 0.11175829f, 0.17238313f, 
    0.31027201f, -0.15882584f, 0.07095438f, -0.03252723f, -0.07158754f, -0.12300496f, -0.09747402f, 0.26183313f, 
    0.03167344f, -0.25047114f, 0.23974039f, 0.37162668f, 0.11143723f, -0.36006337f, 0.07150155f, -0.05027733f, 
    -0.06958337f, -0.02977885f, -0.05486333f, 0.05747736f, -0.07389885f, -0.09827109f, -0.07801329f, -0.11420371f, 
    -0.08692069f, -0.11068662f, 0.14428015f, -0.03836758f, 0.13191187f, -0.12692136f, 0.13834295f, 0.10594203f, 
    -0.06208793f, -0.03165108f, -0.07249753f, -0.07926975f, 0.09696539f, -0.08902913f, -0.09151176f, -0.14735144f, 
    0.10497271f, -0.09767671f, -0.05361515f, 0.01969602f, -0.06782488f, 0.06007300f, -0.00012109f, 0.04649642f, 
    -0.12972930f, -0.34215215f, -0.02041889f, 0.01627157f, -0.40795183f, -0.19298890f, 0.12712093f, 0.28761873f, 
    -0.15792970f, -0.15058136f, -0.03811007f, 0.02372648f, 0.01511591f, 0.06896055f, 0.02831084f, -0.15460885f, 
    0.10613693f, 0.17475957f, -0.02442697f, -0.03592309f, 0.05530655f, 0.03578737f, 0.25301740f, -0.05655985f, 
    0.08442325f, -0.02747053f, 0.22284608f, 0.01557252f, -0.14693750f, 0.09577907f, 0.26104897f, 0.13195138f, 
    0.40839657f, 0.29770127f, -0.14261995f, -0.12116648f, 0.22217739f, 0.20663191f, -0.27823034f, 0.57885921f, 
    -0.23794077f, -0.03808855f, 0.09213455f, -0.14265865f, 0.12645306f, -0.15144186f, -0.00726568f, -0.03316904f, 
    0.22488452f, 0.10759254f, 0.07942716f, -0.15575494f, 0.13528235f, 0.02841228f, -0.54592001f, 0.35458645f, 
    0.20188411f, 0.14208812f, 0.02040395f, 0.24507584f, 0.10560548f, -0.09963719f, -0.14630353f, -0.16999930f, 
    -0.04489128f, -0.16705234f, -0.10038561f, 0.11792800f, 0.12592417f, -0.10063765f, -0.03510600f, 0.03999103f, 
    -0.11215845f, 0.04011575f, 0.02311917f, -0.15778132f, -0.04449158f, -0.05277606f, -0.16359723f, 0.07127284f, 
    0.10186872f, 0.02681747f, 0.15017433f, 0.11701204f, 0.02156547f, 0.09846690f, 0.02309394f, 0.00365391f, 
    -0.17105359f, -0.02889962f, 0.06320786f, 0.03554770f, 0.07648780f, -0.05378919f, -0.10275728f, -0.11741561f, 
    -0.04179830f, -0.07574887f, 0.10986701f, 0.06634229f, -0.01752609f, -0.24928449f, 0.26854691f, 0.20889266f, 
    -0.34011716f, 0.16063403f, 0.00608543f, 0.13036525f, -0.02565591f, 0.32211038f, -0.10933758f, -0.32540578f, 
    -0.21789540f, 0.13763317f, -0.00600385f, 0.01738961f, -0.09616891f, 0.15911460f, 0.37573230f, 0.13209806f, 
    0.32143807f, -0.19261044f, 0.21781632f, 0.13806613f, 0.11312477f, 0.52804214f, 0.15981171f, 0.01002160f, 
    0.11355322f, 0.09324297f, -0.02150206f, 0.04205634f, 0.17515516f, 0.29562899f, 0.25751245f, 0.30374712f, 
    0.44443280f, -0.00341758f, -0.02464857f, -0.01056075f, -0.17060000f, 0.14737862f, 0.03766773f, 0.42764869f, 
    0.04741152f, -0.18510599f, -0.09737112f, -0.06453677f, -0.13577196f, 0.03855885f, -0.19600230f, -0.17458956f, 
    -0.34353811f, 0.22433336f, -0.10774357f, -0.20947267f, 0.16939647f, -0.29975191f, 0.27054235f, -0.13329515f, 
    0.29694542f, -0.02756135f, -0.47132942f, 0.09835631f, -0.27966893f, 0.27541417f, -0.36841753f, 0.42813051f, 
    -0.23835048f, 0.04047006f, -0.07173429f, 0.25062391f, 0.12623803f, -0.17503491f, 0.14102659f, -0.11325333f, 
    0.16662733f, -0.03027385f, -0.10121202f, -0.07125971f, 0.05798384f, -0.01899355f, -0.48862520f, 0.31727314f, 
    0.01345310f, 0.34666288f, 0.08104305f, 0.07522488f, -0.13371012f, -0.24560337f, 0.14980958f, -0.05207719f, 
    -0.11656170f, -0.01331870f, -0.16360240f, 0.05224618f, 0.03121436f, -0.05763775f, 0.25747180f, 0.13742024f, 
    -0.56729561f, 0.12550622f, 0.13148662f, 0.32717249f, 0.05509607f, -0.08045519f, 0.11879955f, -0.34436160f, 
    0.13158476f, 0.20587268f, -0.04195466f, -0.03430105f, -0.04394519f, -0.17311794f, -0.01699648f, 0.01498062f, 
    0.00907871f, -0.04236975f, 0.26513329f, 0.48383904f, -0.06232868f, 0.30015430f, -0.19972695f, -0.09946414f, 
    0.14628398f, -0.20034210f, 0.22635467f, 0.15719132f, 0.23594639f, 0.03785699f, -0.20185035f, 0.09945039f, 
    -0.27167326f, -0.08239798f, 0.06858502f, -0.06582087f, -0.14200631f, -0.14805040f, 0.05632816f, 0.28092840f, 
    -0.29990211f, 0.01261789f, 0.03000775f, 0.04655302f, -0.06422655f, 0.22915673f, 0.31467783f, -0.07999658f, 
    0.35469222f, 0.21582119f, -0.21608588f, -0.12988871f, -0.05330388f, -0.35053819f, 0.33864087f, -0.01935384f, 
    0.06851462f, -0.14473498f, -0.06684776f, -0.15597329f, -0.07480268f, 0.06758539f, 0.09781557f, -0.09409433f, 
    0.03892245f, -0.15105613f, 0.13963014f, -0.18866262f, -0.11879113f, -0.06524158f, 0.07374420f, -0.12692121f, 
    0.06077081f, -0.19348443f, -0.04127224f, 0.01055787f, -0.05043555f, -0.01102910f, 0.08227370f, 0.09303138f, 
    0.13123162f, 0.09773601f, 0.05976836f, 0.15367651f, 0.12998514f, 0.01714959f, -0.20002019f, 0.14990319f, 
    0.12170836f, -0.03925420f, -0.03406160f, -0.12552686f, 0.00251178f, 0.20499226f, 0.29280707f, -0.21428432f, 
    -0.32749939f, 0.13739461f, 0.11324894f, -0.05738348f, 0.15221272f, 0.32731768f, -0.09224831f, -0.22410373f, 
    0.09239650f, 0.26731852f, 0.08873741f, 0.09463923f, 0.16977839f, 0.33927074f, 0.25649229f, -0.37763214f, 
    -0.42343783f, 0.01775265f, 0.10918632f, -0.24707714f, -0.07707152f, 0.22902143f, -0.09041382f, -0.07800574f, 
    -0.09834217f, -0.31281692f, 0.09214886f, 0.03037064f, -0.16990735f, -0.25884828f, 0.16835909f, -0.02064411f, 
    -0.02209233f, 0.16422373f, 0.15557003f, 0.05514764f, -0.10004067f, 0.14339592f, 0.16793323f, 0.25952303f, 
    0.37015197f, -0.18648233f, -0.05129866f, 0.03410628f, -0.08784069f, 0.37110007f, 0.14198606f, -0.01694844f, 
    -0.07032970f, 0.06088066f, -0.03036316f, 0.31245774f, 0.03521777f, -0.21945016f, 0.17871454f, 0.15393032f, 
    0.21972309f, -0.15462741f, 0.08926146f, -0.10341545f, -0.55156797f, -0.27607000f, -0.08520480f, -0.30998054f, 
    0.22210766f, 0.17283648f, 0.16735230f, 0.15405245f, 0.14687721f, -0.42344198f, -0.14197919f, 0.27780929f, 
    0.47584733f, 0.13105179f, 0.10490835f, -0.09588779f, 0.09107449f, 0.18842576f, -0.08934939f, 0.32359305f, 
    0.06803429f, 0.14679445f, -0.19839495f, 0.31615531f, -0.05016552f, -0.32567108f, 0.34755477f, -0.09541366f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01076839f, -0.05831634f, 0.03080111f, -0.00719261f, -0.07291447f, -0.09824785f, 0.06611782f, 0.00013888f, 
    0.00039908f, 0.06610296f, 0.02722682f, -0.08858163f, 0.07746591f, 0.13796754f, 0.10760924f, 0.23892929f, 
    -0.13570148f, 0.10560040f, -0.03997253f, -0.03749634f, 0.11797092f, 0.18376146f, -0.11765836f, 0.18075702f, 
    0.01086685f, 0.14540642f, 0.07927164f, 0.14971545f, -0.08372574f, 0.05383597f, -0.07840287f, 0.08471160f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.59413397f, -0.06153327f, -0.66288447f, 0.10626028f, 0.31418553f, 0.06252205f, -0.06684212f, -0.03366580f, 
    -0.33047140f, 0.14231396f, 0.07878007f, -0.01553697f, -0.25677767f, -0.49368793f, 0.13586107f, 0.36947685f, 
    0.02791091f, -0.09485466f, -0.64047205f, -0.13854092f, -0.00093416f, -0.08237319f, -0.16906089f, 0.14951833f, 
    -0.31476310f, -0.31395090f, 0.31011394f, -0.29084644f, 0.01511178f, 0.34878328f, -0.58423311f, -0.45308495f, 
    0.12761450f, -0.10460640f, -0.49763727f, 0.19752036f, 0.27585337f, 0.14184996f, -0.21018434f, 0.13145374f, 
    -0.55113637f, 0.40435031f, 0.11164676f, 0.06650863f, 0.33730426f, 0.07500563f, -0.03969230f, -0.10894970f, 
    0.09206188f, 0.12918322f, -0.11413266f, -0.08658387f, -0.16377047f, -0.08892515f, -0.08291110f, -0.03759806f, 
    0.13699397f, -0.09291222f, -0.41952714f, 0.42044130f, 0.00516625f, -0.04581571f, -0.22084944f, -0.23033476f, 
    -0.78250587f, -0.19392762f, 0.18965010f, -0.02435209f, -0.11940617f, -0.06499742f, -0.50472230f, 0.38530409f, 
    0.29946113f, 0.10968328f, 0.00712419f, 0.01289528f, -0.45449635f, -0.10850812f, -0.50371158f, -0.33070403f, 
    0.01278147f, 0.34714031f, -0.39512709f, -0.15962219f, -0.04135520f, 0.04394469f, 0.12812379f, 0.07683156f, 
    0.22215497f, -0.22364259f, -0.42214051f, 0.23041214f, -0.10832792f, -0.27235290f, -0.35059866f, -0.48972580f, 
    -0.02861656f, -0.17808810f, -0.12965956f, -0.65576541f, -0.60108298f, -0.03280792f, -0.00612541f, 0.08000611f, 
    0.24906588f, -0.07564639f, -0.05502890f, 0.13750702f, -0.03123123f, 0.28124115f, 0.38162553f, 0.34335378f, 
    -0.04267754f, -0.21826497f, -0.06077695f, 0.15834038f, -0.02854969f, -0.47773769f, -0.13277534f, -0.20221120f, 
    0.31532252f, -0.44290864f, -0.24067563f, -0.34237581f, -0.14728391f, -0.20519608f, 0.22947949f, 0.00089661f, 
    -0.55860049f, 0.05113223f, 0.40863603f, -0.39781874f, -0.17620522f, 0.06566093f, -0.61843580f, -0.13131289f, 
    -0.16346911f, 0.21551584f, -0.16684206f, 0.14514409f, -0.11481765f, 0.03872549f, 0.24402833f, 0.26387691f, 
    0.08782876f, -0.41940063f, 0.00022296f, 0.09814911f, 0.27594233f, -0.32822904f, 0.13945262f, 0.22765572f, 
    -0.06461017f, -0.08339675f, 0.03490805f, -0.27049869f, 0.07673907f, 0.14878258f, -0.18255468f, -0.04958174f, 
    0.09649668f, -0.04431735f, -0.15947202f, 0.09880240f, 0.19089079f, -0.03725408f, -0.10649586f, -0.47007787f, 
    -0.50012529f, -0.00265460f, -0.00114973f, -0.17279746f, -0.25501746f, -0.01764329f, -0.03890442f, -0.05138543f, 
    0.14848387f, -0.34347668f, -0.61170202f, -0.08858147f, 0.34022608f, 0.24996898f, -0.08691128f, -0.02294932f, 
    -0.07285410f, 0.31298044f, 0.03445821f, 0.15701330f, -0.00777535f, -0.15803102f, 0.17262004f, 0.32889330f, 
    0.05131229f, 0.05524094f, 0.38946375f, 0.06659859f, 0.16061082f, -0.06077842f, -0.72899610f, 0.01107393f, 
    0.19046910f, -0.23245105f, -0.09685633f, 0.16667485f, 0.11032498f, -0.34086728f, -0.54710728f, -0.23502760f, 
    -0.13102992f, 0.24257785f, 0.03578814f, 0.08310421f, 0.06481804f, -0.24774471f, 0.12252116f, 0.08050230f, 
    -0.38155434f, -0.48611921f, -0.23763263f, 0.23758288f, -0.19125544f, -0.16123284f, 0.29022944f, 0.37635070f, 
    0.36042970f, -0.04015905f, 0.11604741f, 0.06130225f, -0.20575646f, -0.16103086f, 0.29111403f, -0.21827078f, 
    0.16108352f, 0.01899238f, 0.10822211f, -0.16845471f, 0.34458548f, -0.37142292f, 0.25405118f, -0.52696174f, 
    -0.08308475f, -0.27892101f, 0.32337716f, 0.06804261f, -0.12758632f, -0.16058943f, 0.14248431f, 0.03794930f, 
    -0.06212272f, 0.04365624f, 0.23130517f, -0.04272059f, 0.10609937f, -0.62883145f, -0.08258513f, 0.01133802f, 
    -0.44955564f, 0.09352306f, -0.09978915f, 0.11559083f, 0.06736977f, -0.10921914f, -0.15889521f, -0.03022065f, 
    0.04196596f, -0.28839880f, 0.10656698f, 0.11034444f, -0.13798988f, 0.06567799f, -0.00017975f, -0.11503883f, 
    0.03307173f, 0.16403341f, -0.23190747f, -0.01127401f, -0.53093320f, 0.35607868f, 0.15445121f, -0.69565290f, 
    0.24550617f, 0.45480621f, -0.50328523f, -0.22968821f, -0.11160440f, -0.23913534f, -0.28158629f, 0.33487448f, 
    -0.26205322f, 0.14466418f, 0.26785177f, 0.17881687f, -0.06246417f, -0.15593661f, -0.18577933f, 0.24923976f, 
    0.25115556f, -0.74547768f, -0.04898148f, 0.17840973f, -0.11074237f, -0.36316034f, -0.09531023f, -0.08882491f, 
    0.10956673f, -0.33109143f, -0.08582349f, -0.15370089f, 0.05118817f, 0.33892009f, -0.03116989f, 0.27321896f, 
    -0.56426960f, 0.16106346f, 0.31683028f, -0.26290092f, -0.01755142f, -0.26072976f, -0.30350736f, -0.26756430f, 
    0.37951466f, 0.12526728f, -0.20564766f, -0.40467057f, -0.24426945f, 0.02588367f, 0.08392482f, 0.07480446f, 
    -0.04889115f, -0.30269253f, 0.08310472f, 0.02792374f, -0.69966352f, 0.07222115f, -0.25113136f, -0.26938808f, 
    -0.01222462f, 0.32038239f, 0.40825483f, -0.00051438f, -0.40417084f, 0.29108736f, -0.17299277f, -0.27002102f, 
    0.25508946f, 0.08191982f, -0.07321727f, -0.00032272f, -0.14508082f, 0.04578580f, -0.04837947f, -0.31469136f, 
    -0.59464586f, 0.11254845f, 0.04406704f, 0.06648245f, -0.53935224f, 0.08376055f, 0.30369616f, -0.26056087f, 
    -0.14289962f, -0.29346851f, 0.13271514f, 0.16434853f, -0.50224400f, 0.28010216f, -0.64534503f, -0.06178690f, 
    0.09080303f, -0.04967937f, 0.01989261f, 0.12569079f, 0.24194279f, -0.31812751f, 0.18536676f, 0.24651967f, 
    0.15437655f, -0.33099103f, 0.00971165f, 0.05936887f, 0.08726010f, 0.35291728f, 0.29949763f, -0.00336667f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.07185444f, -0.19283715f, -0.25915924f, -0.01844708f, 0.16909458f, 0.08816435f, -0.10311730f, -0.14469811f, 
    0.04239839f, -0.04590847f, 0.17519887f, -0.06655031f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
