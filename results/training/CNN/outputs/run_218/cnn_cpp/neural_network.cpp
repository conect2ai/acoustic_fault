#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.28493643f, 0.62793899f, 1.04678941f, 0.67719686f, -0.48033789f, 0.17028838f, 0.08309249f, 0.65871465f, 
    -0.13780698f, -1.79058766f, 0.54125184f, 0.16558380f, 0.32263547f, 1.31050003f, 0.61477035f, 0.00389888f, 
    -0.16474056f, -0.35026646f, -0.67026168f, 0.93252552f, 0.53157097f, 1.01717317f, -1.36928296f, -0.29467162f, 
    -0.36766374f, -0.77396268f, -0.14234810f, -1.04942787f, -0.46825194f, -1.34468710f, 0.79199111f, -0.23791227f, 
    0.50813210f, -0.14949074f, -0.28288993f, -0.71456218f, 1.16013026f, 1.28136384f, -0.18410502f, -0.98573977f, 
    -1.13153148f, 0.34139967f, -0.18503045f, -0.03143825f, -0.30923477f, 0.80229038f, -0.46471745f, -0.04456649f, 
    -0.90200120f, -0.98182839f, -1.46900558f, -0.79806161f, -0.22042817f, -0.28887537f, 0.90731066f, 0.18767066f, 
    -0.24333599f, 1.48984683f, -0.34279355f, 0.81575167f, -0.49383691f, 0.58891022f, -0.13509482f, 1.05539238f, 
    0.92544234f, 1.18946278f, -0.72989148f, 0.80333346f, -0.63270444f, 0.02761715f, 0.20994405f, 0.07298263f, 
    0.59267706f, 0.64811307f, 1.13387394f, -0.13091452f, 0.02091967f, 0.89199513f, 0.43946233f, -0.15739220f, 
    0.48546314f, -0.34072375f, 0.10640584f, 1.05685425f, 0.98625445f, 1.24812853f, -0.33080781f, 0.21297850f, 
    0.40640587f, -0.06434415f, 0.45914263f, 0.31729889f, -0.57349759f, -1.33033729f, -0.48635107f, -1.15813112f, 
    0.51321715f, 0.50928986f, 0.64522743f, -0.71937203f, -1.11425853f, -0.75126392f, -0.73484933f, 0.60676306f, 
    -1.10735238f, -0.03759833f, 0.10362406f, 0.34409872f, -1.32205892f, -1.56439602f, -0.76757461f, -0.28024220f, 
    -0.33332828f, -0.28530025f, -0.08708672f, -0.32669920f, -0.17712599f, -0.92840141f, -0.77918482f, -0.43977177f, 
    1.02773678f, 1.22248542f, 0.59051603f, 0.39025274f, -0.19308504f, 0.45946726f, 1.02458954f, 1.00944090f, 
    -0.03797251f, 0.78445673f, 0.72637117f, -0.45564127f, -0.37373492f, -0.21720225f, 0.08352280f, -0.69119108f, 
    -0.87998867f, -0.32683071f, -0.76138622f, -0.77236974f, 1.11774385f, 0.17344867f, 0.00004696f, -0.08209936f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16608998f, -0.01066719f, -0.35997406f, 0.03736117f, -0.09498326f, 0.18164498f, -0.33082238f, 0.20658095f, 
    0.63220263f, -0.08007479f, 0.24108760f, -0.24357033f, -0.17193161f, -0.11935572f, 0.55835181f, 0.04978710f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.80806309f, -0.20448786f, -0.12640841f, -0.04357524f, -0.02115812f, 0.02404303f, 0.22283167f, 0.00320593f, 
    -0.04643208f, 0.21981314f, 0.01905362f, -0.00925675f, 0.05540190f, 0.16877158f, -0.10627700f, -0.04218048f, 
    -0.09361579f, -0.04490492f, 0.02990794f, 0.16425595f, -0.57164890f, -0.00284434f, 0.22542119f, -0.00740261f, 
    -0.17458239f, -0.02950099f, 0.25452363f, 0.52698189f, -0.08295708f, -0.14702836f, -0.03964071f, 0.50217986f, 
    0.03091105f, -0.13030833f, -0.10734064f, -0.02029340f, -1.06318617f, 0.18730348f, 0.16012275f, -0.00839984f, 
    -0.05846082f, -0.15812375f, -0.01248667f, -0.15526806f, 0.17330025f, 0.19310389f, 0.48873159f, 0.24462205f, 
    0.13009806f, -0.05388613f, 0.35813355f, 0.03658402f, 0.16178568f, -0.04671665f, -0.70429724f, -0.12111661f, 
    0.02161018f, 0.13957611f, 0.52434212f, -0.00743701f, -0.21670648f, -0.35129890f, 0.11661181f, -0.46826643f, 
    0.29741079f, -0.15132803f, 0.12902705f, 0.11251778f, 0.24848539f, 0.00224614f, 0.00957921f, 0.16594352f, 
    0.00427210f, 0.01145845f, 0.22038876f, -0.01294038f, 0.02443365f, 0.01296275f, 0.07674863f, 0.16164337f, 
    0.03300076f, -0.33132663f, -0.00984782f, -0.31054330f, -0.01068845f, 0.14204128f, 0.03864273f, 0.27947092f, 
    0.13781920f, -0.02124269f, 0.03878744f, -0.04551945f, 0.10091840f, 0.09970009f, 0.25010261f, 0.08327577f, 
    -0.31783360f, 0.03457696f, 0.33268824f, 0.17133908f, -0.12698561f, 0.18242645f, 0.23180790f, -0.11669803f, 
    0.56636888f, 0.02156259f, 0.17720649f, -0.04124384f, 0.14563279f, -0.10806483f, 0.21412717f, -0.22254121f, 
    -0.11469205f, 0.01011125f, -0.14858007f, -0.12739469f, 0.13424680f, 0.69085532f, 0.22263768f, -0.17034127f, 
    -0.04750611f, -0.18864399f, 0.10925798f, 0.09836431f, 0.07323688f, -0.04315582f, -0.41562718f, -0.22517444f, 
    -0.16070732f, 0.01686867f, -0.04119429f, 0.24805105f, 0.12160757f, -0.07734346f, 0.08196936f, -0.11537243f, 
    -0.30209321f, -0.20316117f, 0.16218214f, -0.01334463f, 0.12704989f, 0.17200826f, 0.11333349f, -0.04311183f, 
    0.22173740f, 0.44069105f, 0.22609109f, -0.27368662f, 0.07535907f, 0.05083172f, 0.05889381f, 0.07615289f, 
    0.14128995f, 0.45788965f, -0.46708640f, -0.37000170f, -0.02957242f, 0.13381751f, -0.05403904f, -0.07626224f, 
    -0.15995559f, -0.07554476f, 0.08132236f, -0.17300950f, -0.09514201f, -0.20719372f, 0.00052470f, -0.14883864f, 
    0.02476912f, 0.14500687f, 0.01199361f, -0.24704917f, -0.03601877f, -0.24685007f, -0.07882835f, 0.03540187f, 
    -0.10353637f, 0.07489379f, -0.29105410f, 0.19989878f, -0.02010234f, 0.52941537f, 0.49996716f, -0.06602865f, 
    -0.16331311f, 0.03670279f, -0.13412495f, -0.04008398f, 0.31505558f, 0.20837466f, 0.24049751f, -0.01342181f, 
    -0.12813449f, 0.30516794f, 0.25147375f, -0.19179069f, 0.18487635f, 0.04316255f, -0.30166954f, 0.21237561f, 
    0.33944735f, -0.06734207f, 0.11654133f, 0.15106775f, 0.07754264f, -0.05225139f, -0.20099452f, 0.30238697f, 
    0.40410691f, 0.30545288f, 0.08555555f, 0.00290116f, 0.08650006f, -0.39915457f, -0.03588522f, 0.02907360f, 
    -0.11505339f, 0.17488281f, 0.37820047f, 0.11322563f, -0.11440510f, 0.13289168f, 0.16794139f, 0.26098374f, 
    0.05399771f, -0.47973922f, -0.80385131f, -0.16052680f, 0.06676818f, 0.28703117f, 0.16412896f, -0.03141855f, 
    -0.04211024f, -0.26558617f, 0.20145378f, -0.13940883f, -0.04677679f, 0.08080897f, 0.16336194f, -0.11804174f, 
    0.17274979f, -0.10755026f, -0.07220399f, -0.62617135f, -0.11385212f, -0.73023200f, 0.01305956f, 0.03239724f, 
    0.19209364f, -0.03322949f, 0.03165176f, -0.20088679f, -0.29786059f, 0.13638666f, -0.27503359f, 0.20615122f, 
    -0.06149871f, 0.08531104f, 0.11458728f, 0.24112454f, -0.09259883f, -0.04394023f, -0.58777583f, -0.64348054f, 
    0.15996233f, 0.08892958f, 0.26169091f, 0.15753192f, -0.10278165f, -0.18752432f, -0.18009563f, 0.32016909f, 
    0.24556279f, 0.09693874f, 0.13107798f, 0.04545382f, 0.04366705f, 0.15386601f, 0.19193114f, -0.49709541f, 
    -0.48032278f, -0.22999729f, 0.04859351f, 0.07251584f, 0.23808278f, 0.08580075f, -0.10913265f, 0.00816299f, 
    0.01144710f, 0.01330445f, 0.35330096f, -0.33386371f, -0.10839792f, -0.05775633f, -0.22782132f, 0.13582513f, 
    -0.10503781f, 0.54984248f, 0.42418736f, -0.51409274f, 0.02495138f, 0.14527658f, 0.08310022f, 0.03681459f, 
    0.07493012f, -0.11385349f, 0.03361442f, 0.04911396f, 0.09349348f, -0.13461736f, 0.55206472f, -0.15935157f, 
    0.18505867f, 0.16741373f, -0.26475850f, 0.43787602f, -0.44296119f, -0.69247234f, -0.08514957f, 0.11821864f, 
    0.32450908f, 0.01975375f, 0.13727823f, -0.00037523f, -0.26333320f, -0.14639282f, 0.08094903f, 0.02151654f, 
    -0.21351977f, 0.04434199f, 0.09088809f, 0.05598808f, 0.10487656f, 0.23536450f, -0.07725293f, 0.19445218f, 
    -0.20447327f, 0.00098052f, -0.08480667f, 0.08382004f, 0.11466675f, 0.03761751f, 0.02660146f, -0.37221432f, 
    0.04774595f, -0.11817422f, 0.20221408f, 0.07414350f, -0.10030276f, -0.26678738f, -0.19963503f, 0.28263709f, 
    0.28797561f, 0.11303499f, -0.42467776f, 0.05749555f, 0.03933984f, -0.13577329f, 0.04235090f, -0.15894753f, 
    -0.22307542f, 0.16886574f, -0.04356913f, -0.12916927f, 0.07068229f, -0.29590675f, 0.23563036f, -0.33337095f, 
    0.02991199f, -0.21147875f, 0.15459514f, 0.58170187f, -0.09656852f, 0.02705867f, -0.01639538f, 0.16312703f, 
    0.12504347f, 0.02445555f, -0.26220226f, -0.21410869f, -0.14261660f, 0.15036544f, 0.18239041f, -0.06045673f, 
    -0.11558454f, -0.04949624f, 0.12967812f, -0.14424746f, -0.12020595f, 0.16843058f, 0.00060640f, 0.21802382f, 
    0.25154117f, 0.30700463f, -0.45821992f, -0.01777163f, 0.05680969f, -0.33875191f, 0.55032855f, -0.21395366f, 
    -0.27024677f, 0.04683188f, 0.11321654f, -0.17704706f, 0.09333663f, 0.77070099f, 0.25515699f, -0.10732619f, 
    0.02718616f, 0.14188978f, 0.08067154f, 0.23176071f, -0.06054554f, -0.02974201f, 0.41678646f, -0.14049388f, 
    0.10817601f, -0.36499175f, -0.17728992f, 0.33887190f, 0.14851156f, -0.13592280f, 0.00916698f, -0.18126729f, 
    -0.02349610f, -0.07422711f, -0.49470016f, -0.03788067f, -0.13666983f, -0.04566874f, -0.02288222f, 0.24797797f, 
    -0.79790395f, -0.77244955f, -0.09019686f, -0.10594213f, -0.00389714f, 0.23888396f, -0.05991294f, -0.05835620f, 
    0.00908271f, -0.01896668f, 0.20565507f, 0.09903105f, 0.23188150f, 0.01251921f, -0.14168134f, 0.04840159f, 
    0.09447275f, 0.19988482f, 0.76641071f, -0.21750975f, 0.32658207f, 0.10332318f, -0.29327211f, 0.06474538f, 
    -0.05144672f, -0.25563133f, 0.04003937f, 0.41123626f, 0.30229220f, 0.38009930f, 0.25553250f, 0.29062894f, 
    0.03736048f, -0.20751071f, 0.31711054f, -0.05422110f, 0.00011393f, 0.03846741f, -0.21116379f, -0.16911282f, 
    -0.03331086f, -0.02625725f, -0.07489789f, 0.03490191f, -0.34241524f, 0.13323684f, 0.05241375f, 0.57422841f, 
    -0.04829298f, -0.08427570f, -0.00682277f, 0.09272113f, -0.36945882f, -0.11237303f, -0.21305963f, 0.12630025f, 
    0.00681586f, -0.14857639f, -0.09245666f, 0.01882554f, 0.18721867f, 0.12532641f, -0.05123260f, -1.01877189f, 
    -0.40176794f, -0.08947832f, 0.18353659f, 0.25068775f, 0.06468096f, -0.16896036f, -0.14946516f, 0.12403856f, 
    -0.69952202f, -0.26660290f, 0.05374571f, 0.35573837f, 0.04066749f, 0.12221915f, -0.12960592f, 0.19297521f, 
    -0.08611944f, 0.22623983f, -0.05491072f, -0.22218661f, -0.02562189f, -0.10251150f, -0.18131712f, 0.14912854f, 
    0.31525701f, 0.13642819f, 0.35725254f, -0.13919950f, -0.01353503f, -0.18992271f, -0.17054030f, -0.27088666f, 
    -0.12538357f, 0.01871160f, 0.03493558f, -0.13264656f, 0.31490904f, -0.11683824f, -0.07628348f, -0.14689106f, 
    0.31385225f, 0.07987395f, 0.24824791f, -0.10995419f, 0.10393757f, 0.36653167f, -0.03982444f, -0.16338854f, 
    -0.10946835f, -0.33694941f, -0.15627417f, 0.08231913f, 0.09238186f, 0.51412690f, 0.12902577f, 0.24132760f, 
    -0.01109505f, -0.10825668f, 0.01023452f, -0.03359286f, 0.38128439f, -0.05700864f, -0.07222184f, -0.04184151f, 
    -0.53120387f, 0.01542513f, 0.00716185f, -0.17166388f, -0.08441594f, 0.04698157f, -0.21985078f, -0.05576263f, 
    0.03504766f, 0.19703276f, 0.12508561f, -0.12783848f, -0.48586124f, 0.29565457f, 0.22992264f, -0.31147152f, 
    0.02369152f, -0.01436934f, 0.00578207f, -0.08476639f, -0.09329422f, -0.00018239f, -0.00745035f, -0.01761026f, 
    0.06768866f, -0.05983292f, -0.09319533f, -0.08431167f, -0.00009288f, -0.01819852f, -0.07411992f, -0.04493365f, 
    0.03101290f, -0.02503623f, -0.05439554f, -0.05048984f, 0.04566654f, 0.05637236f, -0.05799522f, 0.00977590f, 
    0.06259294f, -0.05550832f, -0.00519680f, 0.03267990f, -0.07324655f, -0.02108596f, -0.09623262f, -0.00201260f, 
    0.04266712f, -0.08092378f, -0.03291123f, 0.01038559f, -0.05852642f, -0.07010289f, -0.03181183f, -0.03174080f, 
    0.02778293f, 0.01777991f, 0.02376819f, -0.01869422f, 0.00641956f, 0.04531875f, 0.02067656f, -0.08530161f, 
    -0.07694885f, 0.03976294f, -0.05271218f, -0.09150928f, 0.01555454f, -0.06650863f, -0.03998957f, -0.06685717f, 
    0.06231125f, -0.08558591f, -0.00377722f, 0.06950241f, -0.00988731f, -0.06732651f, 0.05978881f, -0.02825955f, 
    -0.04498121f, 0.05375348f, 0.06411567f, 0.07172801f, -0.06618458f, 0.04758174f, -0.00012826f, -0.05701939f, 
    -0.02147479f, -0.04573722f, 0.03914644f, -0.01975841f, -0.02900790f, -0.05365318f, 0.02569180f, -0.01292755f, 
    0.03641815f, -0.08810602f, 0.02398074f, 0.01348917f, 0.05856797f, -0.02063971f, -0.07707250f, -0.02992960f, 
    -0.02811742f, 0.00165705f, -0.09646327f, 0.04873705f, -0.06536698f, 0.05757460f, 0.02881054f, 0.02136236f, 
    -0.04087370f, -0.07720968f, 0.02016712f, 0.04151296f, -0.03172541f, -0.05068425f, 0.02910688f, 0.05153768f, 
    0.00599978f, -0.06153322f, -0.01439244f, 0.04228466f, -0.00491373f, -0.05245632f, -0.06314184f, -0.06963693f, 
    0.04128146f, -0.06622300f, 0.06061292f, -0.02311000f, -0.00065358f, -0.02056667f, -0.05866781f, 0.00902315f, 
    -0.02463489f, 0.05844481f, 0.03222609f, 0.02779397f, -0.06602386f, 0.02534149f, 0.00457287f, -0.02307096f, 
    -0.04048234f, 0.03410781f, 0.04514251f, -0.05874780f, 0.02884352f, 0.05335611f, 0.03220269f, -0.06325364f, 
    0.05840373f, 0.05980451f, -0.03633461f, 0.06754636f, 0.04487165f, -0.01884878f, 0.05872518f, -0.09489688f, 
    0.23510163f, 0.29281056f, -0.14808694f, -0.02295542f, 0.08082879f, 0.15372017f, 0.06783246f, 0.05374469f, 
    -0.28397959f, -0.07461177f, 0.20525934f, 0.30451778f, -0.08641800f, -0.26882261f, 0.10213968f, 0.06566793f, 
    0.06711475f, -0.04589470f, -0.57799864f, -0.08331176f, -0.41714802f, -0.00246437f, -0.11981590f, 0.11211266f, 
    0.20937090f, -0.11125562f, 0.08469717f, -0.15424366f, 0.10669424f, 0.33825132f, 0.26987603f, 0.03099683f, 
    0.09048577f, -0.09897456f, -0.06941259f, -0.11567841f, -0.60738564f, -0.01089722f, -0.24574558f, -0.14054446f, 
    0.11697959f, -0.11643291f, 0.13134001f, 0.28131554f, -0.16367558f, -0.21022116f, -0.16295889f, -0.23820221f, 
    -0.11897639f, -0.16721465f, -0.00625625f, -0.03338390f, -0.00987152f, 0.13726500f, 0.06980915f, -0.32392532f, 
    -0.07204740f, -0.01880492f, 0.28533572f, 0.10710332f, 0.22725251f, 0.13009422f, 0.15870968f, -0.29656067f, 
    0.15177298f, -0.56746465f, 0.32497194f, 0.14496139f, 0.14113730f, -0.34337381f, -0.16085078f, 0.21016985f, 
    0.05853501f, 0.32097843f, -0.02373795f, 0.33774003f, -0.16450530f, -0.02440111f, -0.09867388f, -0.03337480f, 
    0.09953967f, 0.25275779f, 0.04630049f, 0.02769853f, 0.16947757f, -0.29913846f, 0.01848357f, 0.10844418f, 
    -0.00152009f, 0.27195847f, -0.42685512f, 0.16884613f, -0.44908211f, -0.05272179f, 0.13045320f, -0.20444590f, 
    0.10921177f, 0.02814961f, -0.10201232f, 0.01924661f, -0.18590088f, -0.01104960f, -0.09898372f, 0.04981041f, 
    0.38967362f, -0.03078022f, -0.02855959f, -0.01659734f, 0.21524511f, 0.03216286f, 0.73784441f, 0.28639096f, 
    0.04909622f, -0.12623674f, -0.24383177f, 0.19214951f, 0.22010258f, 0.33131540f, -0.11978631f, 0.37351832f, 
    -0.06623700f, -0.09093798f, 0.08307321f, 0.05077969f, -0.24206603f, 0.37498385f, 0.09800115f, 0.01398126f, 
    -0.26411539f, -0.02340732f, -0.09151474f, -0.02118577f, 0.08989011f, 0.35388547f, 0.21282271f, -0.23067307f, 
    -0.25046709f, -0.02875096f, 0.18115221f, 0.04362107f, -0.16654296f, 0.07203293f, 0.03649663f, 0.15169288f, 
    -0.10235131f, 0.31050259f, 0.07937182f, -0.27639440f, 0.19891199f, -0.02477288f, -0.29748297f, 0.08931085f, 
    0.29418007f, 0.27551442f, -0.00451239f, -0.47605070f, 0.20313877f, -0.09110869f, -0.14823316f, 0.32322568f, 
    -0.11734726f, -0.08676465f, -0.22741370f, -0.28215444f, -0.11841842f, 0.11632780f, 0.04426814f, 0.06559698f, 
    -0.09322377f, 0.14417346f, -0.03663700f, -0.17386231f, 0.30433744f, -0.21293615f, 0.22859398f, -0.25192690f, 
    -0.32010373f, 0.10049947f, -0.10300296f, -0.30953169f, -0.14794044f, -0.10513049f, -0.40219539f, 0.14391148f, 
    -0.10432372f, 0.30009422f, 0.11592944f, 0.14522766f, -0.16237365f, -0.78536302f, -0.36009645f, -0.44501883f, 
    0.14237259f, 0.35540658f, 0.27831653f, -0.33258885f, 0.03725574f, 0.01248019f, -0.41299680f, -0.34531054f, 
    0.23562431f, 0.00962071f, -0.11487032f, 0.00944077f, -0.09099522f, 0.13597308f, 0.06440365f, 0.17105126f, 
    0.33302176f, -0.44651404f, 0.00811552f, -0.00600457f, 0.13838767f, -0.14379595f, 0.24409363f, 0.10487296f, 
    -0.08800764f, 0.25458544f, -0.00602753f, 0.05078604f, -0.01530136f, 0.05927603f, 0.06680479f, 0.02089307f, 
    0.43780896f, 0.18135816f, -0.21709426f, 0.12421773f, -0.26842475f, -0.19332206f, 0.07289906f, 0.03451819f, 
    0.09869339f, 0.07631844f, 0.24819931f, 0.02932281f, -0.28930622f, 0.04581396f, 0.21892732f, 0.32166040f, 
    0.11060291f, 0.05132429f, 0.04034207f, 0.22253373f, -0.63060868f, -0.43877095f, -0.05058594f, -0.13561028f, 
    0.40824383f, -0.08660476f, 0.02571000f, -0.03419296f, 0.16278163f, 0.18466397f, 0.18099624f, -0.08797117f, 
    0.11502215f, 0.10525760f, -0.13974814f, 0.11178855f, 0.01034579f, 0.39354703f, 0.17153017f, 0.10428488f, 
    -0.31723180f, -0.38304353f, 0.12503703f, -0.03330705f, -0.11922996f, -0.00117321f, 0.18395922f, -0.10198587f, 
    0.11337205f, 0.05062587f, -0.28908366f, -0.07198230f, 0.02294302f, 0.14164761f, 0.18898278f, 0.15979831f, 
    -0.00628537f, 0.41812634f, 0.16205364f, -0.01788941f, -0.03755509f, -0.00036061f, -0.02299854f, 0.02430171f, 
    0.30283687f, 0.04428398f, 0.17396092f, -0.18825258f, 0.02287797f, 0.07856061f, 0.23502392f, -0.38014427f, 
    -0.10625006f, 0.74228418f, 0.19100159f, 0.41470402f, 0.04802363f, -0.05396334f, -0.25598508f, -0.05663288f, 
    -0.13539822f, 0.07566663f, -0.30026701f, 0.07512213f, 0.13520744f, -0.01409788f, 0.02598158f, 0.13319591f, 
    -0.12422542f, -0.05938034f, -0.11419532f, 0.11923626f, 0.14702040f, 0.12446130f, 0.33120185f, 0.22396410f, 
    -0.05436120f, 0.24351068f, -0.07495224f, 0.09161247f, 0.11957020f, 0.12260680f, 0.05656154f, -0.43877408f, 
    -0.13140586f, 0.05313663f, -0.37419125f, -0.04914270f, 0.29818979f, 0.51795995f, -0.26760966f, 0.17215428f, 
    -0.13916530f, 0.08935848f, -0.24407467f, -0.07109814f, -0.00705312f, 0.11496740f, 0.66649413f, -0.51210165f, 
    -0.41824359f, -0.07582313f, 0.05691313f, 0.01328967f, -0.06711773f, 0.16753052f, -0.03422321f, -0.34674931f, 
    -0.03940017f, -0.11896972f, 0.04208354f, -0.12052390f, -0.12301385f, -0.19045450f, 0.27262756f, -0.04963122f, 
    -0.00682185f, 0.07945694f, -0.56165349f, -0.28825510f, -0.21600096f, -0.17473494f, -0.24432260f, 0.03191620f, 
    -0.05141819f, -0.39723811f, 0.26935437f, 0.41296491f, -0.11990982f, 0.04154131f, -0.12632494f, -0.01688464f, 
    -0.06530797f, 0.28384891f, -0.16763695f, 0.05726763f, 0.25938985f, 0.01450743f, -0.04276460f, 0.01807632f, 
    -0.10872085f, -0.01322134f, 0.04642040f, -0.05296433f, -0.07737000f, -0.03280886f, 0.11021768f, -0.13730584f, 
    0.13870509f, -0.24504597f, 0.03699634f, -0.56215191f, -0.40502587f, 0.16840392f, -0.00205746f, 0.23469187f, 
    0.00980113f, -0.10781802f, -0.03445794f, 0.12598075f, 0.05785805f, 0.16489148f, 0.34392411f, -0.04502033f, 
    0.24439794f, 0.20126246f, -0.00486666f, 0.08891623f, -0.00332589f, -0.01762413f, -0.13278818f, 0.12714691f, 
    0.06246474f, -0.20143828f, 0.02983886f, -0.26020360f, -0.07096861f, 0.07386189f, 0.07819979f, -0.33057895f, 
    -0.08709961f, -0.61269504f, 0.08407327f, 0.16921593f, -0.17954096f, 0.11871981f, 0.03246296f, 0.15287538f, 
    -0.22539523f, 0.20090927f, 0.21741340f, 0.17450801f, 0.22515339f, -0.05876118f, 0.08651618f, -0.02454004f, 
    0.08092900f, 0.15130857f, 0.28230372f, 0.38291147f, 0.07420766f, 0.05527687f, 0.22720502f, 0.08273131f, 
    -0.22878307f, 0.18092762f, 0.04262095f, -0.40847120f, 0.22963524f, -0.20535329f, -0.03113143f, 0.35855126f, 
    0.18828464f, 0.11412422f, 0.04419014f, -0.07366750f, -0.15027168f, -0.18270837f, -0.01348128f, 0.07788093f, 
    -0.13774462f, -0.29984963f, -0.10827378f, 0.04445998f, -0.11399501f, -0.34374151f, 0.08328026f, -0.14017630f, 
    -0.11630442f, -0.39907545f, 0.30142134f, -0.03288173f, -0.00807134f, 0.32397422f, 0.01333017f, 0.13241380f, 
    -0.17504472f, 0.09064625f, -0.11591396f, 0.33492196f, 0.16901614f, 0.37427866f, -0.26852572f, -0.10221134f, 
    0.04599060f, 0.09982455f, -0.18619260f, 0.04266438f, -0.17235884f, -0.23137173f, -0.38456413f, -0.34762433f, 
    0.24545324f, 0.48408163f, -0.18512669f, 0.19322528f, 0.36847368f, -0.12005787f, 0.09719492f, -0.04022113f, 
    -0.11874442f, -0.09071559f, 0.12368555f, 0.10124955f, -0.00165053f, 0.10013583f, 0.03995012f, 0.09070925f, 
    -0.07945065f, -0.48481655f, -0.30948970f, -0.23909663f, 0.32559836f, 0.03858937f, 0.01598384f, -0.00883246f, 
    0.00339080f, -0.04625955f, 0.00647049f, 0.19163597f, 0.21273005f, 0.06800386f, -0.34286776f, 0.02577742f, 
    -0.00721916f, 0.11832319f, -0.04336385f, -0.52844894f, -0.01180966f, 0.10801043f, -0.01882469f, -0.01611571f, 
    0.05205208f, -0.03941303f, -0.27601534f, 0.11905099f, -0.39960068f, -0.06740584f, 0.29732499f, 0.35818183f, 
    0.09295436f, 0.00295615f, 0.37250584f, -0.21056369f, 0.14822428f, -0.79193968f, 0.06099849f, 0.11797018f, 
    0.16218276f, 0.07742507f, -0.04995135f, -0.13871382f, 0.10375590f, 0.02582213f, 0.07262599f, 0.02520454f, 
    0.05960266f, 0.03523730f, -0.20431104f, 0.16128953f, 0.10655146f, 0.02570908f, 0.21897686f, -0.27355778f, 
    -0.41762224f, -0.31454611f, 0.27485189f, 0.23228572f, 0.18812926f, 0.03822149f, -0.08300979f, -0.05066312f, 
    0.11169778f, 0.05999747f, 0.00188676f, 0.01335286f, -0.24129342f, -0.02691612f, 0.05688363f, -0.09467875f, 
    0.22856432f, 0.02685178f, 0.31503248f, -0.30692291f, 0.27808705f, 0.24829757f, -0.12316024f, -0.13810107f, 
    0.04752186f, 0.24328831f, -0.15370379f, 0.03826642f, -0.21646675f, 0.04664730f, 0.02500288f, 0.16203320f, 
    -0.41506618f, 0.16368841f, 0.05196416f, 0.25640586f, 0.38927251f, 0.11484394f, 0.22673874f, 0.23054360f, 
    -0.24790393f, 0.18956649f, 0.18830033f, 0.13856378f, 0.43222991f, -0.21933667f, 0.10157090f, 0.02503454f, 
    -0.36439118f, -0.02980454f, -0.16553505f, -0.01839946f, 0.06959514f, 0.08675455f, -0.01520729f, -0.21642841f, 
    -0.09243222f, -0.07168528f, 0.31273577f, -0.26714942f, -0.02431662f, -0.31816864f, -0.02655257f, 0.08843744f, 
    -0.15816581f, 0.30699909f, 0.20470291f, -0.21855935f, 0.15997939f, -0.26926088f, -0.14367242f, -0.05487631f, 
    -0.35227445f, 0.27310255f, -0.03117738f, 0.05513548f, 0.28996232f, 0.05342437f, -0.05022522f, 0.13577096f, 
    -0.15921223f, -0.01926640f, 0.00942003f, 0.05267993f, -0.00637219f, -0.01316690f, 0.12599513f, 0.16584715f, 
    -0.01052049f, 0.09058782f, 0.20164493f, -0.14541440f, -0.09483397f, 0.01926367f, -0.06659839f, 0.08100651f, 
    -0.07092110f, 0.04512428f, 0.08391812f, -0.45786265f, 0.26554191f, -0.20901667f, 0.16445282f, 0.18181944f, 
    0.08541282f, -0.28594482f, -0.25793418f, -0.16401407f, 0.31240624f, 0.02911487f, 0.17640406f, -0.05815467f, 
    0.11872400f, -0.12307259f, 0.04814827f, -0.43287307f, 0.55125481f, 0.68606889f, -0.15270707f, -0.04868502f, 
    0.14331518f, -0.06696465f, 0.01776638f, 0.11977487f, -0.04300056f, -0.20712760f, 0.10118044f, 0.08371761f, 
    -0.12744336f, 0.11917331f, -0.05900783f, 0.21291953f, 0.00557226f, -0.09441057f, 0.04002816f, -0.24333228f, 
    -0.23705198f, -0.23612721f, 0.21417795f, 0.00022000f, 0.10962501f, 0.00595026f, -0.07808227f, 0.05254478f, 
    0.30601555f, -0.03368259f, 0.07568396f, -0.14162692f, 0.14559492f, -0.01158469f, 0.10347781f, -0.48716223f, 
    -0.49833620f, 0.00632023f, 0.15054443f, -0.03995917f, 0.08215645f, 0.23890546f, -0.31372458f, 0.03283869f, 
    -0.22938940f, 0.99713337f, 0.15074086f, -0.34193781f, -0.50399196f, -0.33182210f, 0.08398885f, -0.17319858f, 
    0.13896804f, 0.25556991f, -0.02978003f, -0.17465416f, 0.04936337f, 0.05854494f, 0.20807582f, -0.12764302f, 
    -0.18236670f, -0.21179026f, -0.08686176f, -0.36778256f, 0.11469892f, 0.25860894f, -0.07124237f, -0.12641546f, 
    0.12342111f, -0.08209350f, -0.02739316f, 0.22814958f, 0.03285382f, 0.22934724f, 0.02471253f, 0.02249983f, 
    0.15568528f, 0.23292525f, 0.11568896f, 0.05918123f, 0.01003691f, 0.04872453f, 0.37017372f, 0.37110946f, 
    -0.09755931f, 0.08857757f, -0.28008139f, 0.15038873f, 0.05761316f, 0.08650714f, -0.05678561f, 0.07943127f, 
    0.18129683f, 0.17137668f, -0.06066342f, 0.00253345f, -0.03495362f, 0.13379711f, -0.37763938f, -0.13281617f, 
    0.42349520f, -0.02962210f, 0.07445102f, 0.17351648f, 0.19226703f, 0.07141782f, -0.22731759f, 0.05604119f, 
    -0.52999258f, -0.13628562f, -0.09405361f, 0.02928844f, 0.01022759f, 0.10643592f, -0.00507001f, 0.16007277f, 
    -0.30442384f, 0.54091644f, -0.43255478f, 0.01794229f, -0.03293208f, 0.05228711f, 0.24790733f, -0.05866544f, 
    0.27044570f, 0.07659411f, 0.55842656f, 0.29425725f, -0.28093940f, 0.14912474f, 0.08481862f, -0.04637852f, 
    -0.01331979f, 0.19123863f, -0.19210558f, 0.01679513f, -0.10047536f, -0.47925955f, -0.04877960f, -0.09761390f, 
    -0.34401557f, -0.09392419f, -0.19179294f, 0.13319848f, 0.05662509f, -0.11873299f, -0.02973661f, -0.35945475f, 
    0.19350986f, -0.20247057f, 0.13142635f, -0.11834078f, -0.07530797f, 0.47615016f, 0.05360320f, 0.27605295f, 
    -0.20370507f, -0.40123349f, -0.00449335f, 0.20007028f, -0.07485829f, 0.03064698f, -0.12051021f, -0.48438236f, 
    0.01058745f, -0.15988700f, 0.00363424f, 0.10337505f, -0.04148367f, 0.12166991f, 0.15466370f, 0.23234265f, 
    -0.03556247f, -0.29647517f, -0.29237062f, 0.01085524f, -0.09436422f, -0.21028407f, -0.04541343f, 0.09390328f, 
    -0.05708874f, 0.00373873f, -0.21547009f, 0.10669596f, 0.08290052f, 0.03729613f, -0.33017275f, 0.18910374f, 
    -0.30674312f, -0.06969772f, 0.06696865f, -0.00890415f, 0.08374685f, 0.01000357f, 0.10012259f, -0.15980197f, 
    0.08249122f, 0.06600358f, 0.35290098f, 0.08094002f, -0.80992693f, -0.42227459f, 0.04683952f, 0.06333545f, 
    0.01977593f, 0.24537589f, 0.21108688f, -0.42780527f, -0.01321789f, 0.44776198f, 0.08691014f, 0.05401746f, 
    0.14559779f, -0.21832876f, -0.06226354f, 0.36506343f, -0.17260785f, -0.07304671f, -0.00887280f, 0.02376961f, 
    0.02713166f, -0.22256270f, -0.08581176f, -0.01834509f, 0.01299127f, 0.50904107f, 0.05259052f, -0.15957268f, 
    -0.08830170f, 0.07498550f, -0.16712578f, -0.15584180f, 0.02790375f, -0.17971885f, 0.37578085f, 0.02941836f, 
    0.22081973f, -0.29093227f, 0.20510668f, 0.09419599f, -0.05164720f, -0.23124748f, -0.13760145f, -0.10358283f, 
    0.11473943f, 0.10312042f, 0.11944516f, -0.20134863f, 0.09317543f, 0.17482655f, 0.11791839f, -0.16372247f, 
    0.00105481f, 0.16502151f, -0.06038610f, -0.06210632f, -0.32830715f, -0.10342075f, 0.06746445f, -0.10469995f, 
    -0.01045818f, -0.00132225f, 0.05025302f, -0.23487471f, -0.02648127f, -0.02545927f, 0.05994471f, 0.06054254f, 
    -0.15269144f, 0.10205924f, 0.39953372f, -0.20537584f, -0.47998929f, 0.30629751f, -0.04940295f, -0.10940208f, 
    -0.15049684f, -0.04882616f, -0.02102483f, 0.16301884f, -0.01868727f, 0.54054344f, -0.02511862f, 0.07029287f, 
    0.09149475f, 0.30843434f, -0.16973016f, -0.06699546f, 0.22862658f, -0.01238117f, 0.61044145f, 0.05099698f, 
    0.00265171f, -0.09784574f, -0.11886072f, 0.07519470f, 0.14676727f, -0.24211213f, -0.46846366f, 0.56266135f, 
    -0.01980572f, 0.03740197f, -0.12499357f, -0.12148421f, 0.09458783f, 0.03887776f, 0.42818505f, 0.27598244f, 
    0.12352490f, -0.08846231f, -0.17933924f, 0.27474016f, -0.23947306f, -0.09505152f, -0.03890274f, 0.08713292f, 
    -0.53587097f, 0.35576335f, -0.05215746f, 0.03461332f, -0.01713085f, 0.05577028f, -0.03963974f, 0.07028996f, 
    -0.00584397f, -0.08107369f, 0.01785345f, -0.05339666f, 0.04912819f, 0.04888535f, -0.00314692f, 0.03927260f, 
    -0.09643501f, 0.00399587f, -0.04499584f, 0.02866598f, 0.02772372f, 0.00228985f, -0.04278391f, -0.00133514f, 
    0.01752202f, 0.05990561f, -0.06169885f, -0.07650580f, -0.02771705f, 0.03710783f, 0.02906073f, -0.06779908f, 
    0.02132327f, -0.09035479f, -0.06214024f, 0.07047705f, -0.03449198f, 0.00769179f, -0.11226907f, -0.06119644f, 
    -0.02080628f, 0.04338966f, -0.05458923f, -0.05360323f, -0.07068729f, -0.01863040f, -0.06871415f, -0.11622567f, 
    -0.04070234f, -0.03458305f, -0.03550598f, 0.07857014f, 0.03131011f, -0.09228635f, 0.00694686f, 0.05404507f, 
    0.00453847f, 0.02222873f, -0.03091306f, -0.03115177f, 0.04383322f, -0.06040749f, -0.07148395f, -0.09789900f, 
    -0.05334423f, -0.01470450f, -0.03008613f, -0.07839375f, -0.09306108f, -0.04782414f, -0.01210838f, -0.01436366f, 
    -0.03654019f, 0.00709025f, 0.05359222f, -0.04064287f, -0.02109332f, -0.06458719f, 0.04802860f, -0.06823585f, 
    -0.07955564f, -0.04419404f, -0.03852352f, 0.06110017f, 0.03922812f, -0.01338459f, 0.00818079f, 0.02961088f, 
    -0.00911868f, 0.01910615f, 0.06826327f, 0.01897865f, 0.02236728f, -0.07336116f, 0.04177671f, 0.01634718f, 
    0.00821720f, 0.00787686f, -0.03347313f, 0.01883988f, 0.00983114f, -0.02265010f, -0.02176357f, -0.08269603f, 
    -0.06035038f, -0.05795214f, 0.05660250f, -0.01560265f, -0.02370420f, -0.04090339f, -0.07521007f, -0.07797736f, 
    0.04110048f, -0.06240409f, -0.00627483f, 0.05270081f, -0.04315692f, -0.00405278f, -0.00462877f, 0.03278267f, 
    0.03141529f, 0.00951980f, -0.06148750f, -0.06574424f, -0.04771834f, -0.07127222f, 0.01373644f, -0.08126400f, 
    0.00905060f, -0.04694490f, -0.01290160f, 0.01822146f, -0.08514150f, -0.03663455f, -0.09360170f, 0.05962532f, 
    -0.02339921f, -0.07479759f, -0.07980423f, 0.04092516f, 0.03418259f, 0.04912231f, -0.02261959f, 0.03252484f, 
    0.06564181f, -0.01847433f, 0.05834270f, 0.00411957f, -0.05600380f, 0.01793204f, -0.00504184f, 0.04878022f, 
    -0.46765727f, -0.29366997f, 0.01727862f, 0.24381822f, 0.06519196f, 0.04797455f, -0.14022833f, -0.26379305f, 
    0.16276586f, 0.10521025f, 0.20966324f, 0.30004746f, -0.15248999f, -0.02806744f, 0.00435270f, 0.40384886f, 
    0.02227866f, -0.08245415f, -0.11829959f, -0.54195237f, -0.39104640f, 0.17962956f, 0.08211044f, 0.07600219f, 
    -0.08339728f, -0.08430882f, 0.02711765f, 0.05891606f, 0.16623421f, 0.04481857f, -0.08801521f, 0.08813266f, 
    -0.18466215f, 0.18766890f, 0.16190903f, -0.12763396f, -0.27900410f, -0.57564789f, -0.16141754f, -0.00437584f, 
    -0.12787192f, -0.15320562f, 0.07273637f, -0.42322445f, -0.04545289f, 0.42511418f, -0.53585166f, 0.16735528f, 
    0.00251497f, 0.06462373f, 0.11424533f, -0.19837494f, -0.11908300f, 0.07871142f, 0.03596982f, 0.12254033f, 
    0.06460924f, -0.03321440f, -0.06118220f, -0.02595179f, 0.23721498f, 0.20504762f, 0.17387964f, -0.21077250f, 
    -0.40309751f, -0.01953773f, 0.06451075f, 0.09458189f, 0.00141579f, -0.07332606f, 0.04705905f, -0.03476065f, 
    -0.10461731f, 0.21854538f, -0.08608457f, -0.01047891f, -0.02689499f, 0.17968951f, -0.07754375f, -0.20387483f, 
    -0.11720049f, -0.05649448f, 0.14931729f, 0.10875019f, -0.21435356f, -0.07958771f, -0.00463616f, 0.23036918f, 
    -0.10609242f, 0.01620838f, 0.35529241f, -0.71382159f, -0.02910689f, -0.19061680f, -0.06224901f, 0.08864890f, 
    0.07160996f, -0.05291874f, 0.11864224f, -0.30176276f, 0.10213546f, -0.10772585f, 0.13324529f, -0.18821232f, 
    -0.04977220f, 0.14560935f, 0.03481836f, -0.07437565f, -0.22652425f, 0.21766147f, 0.21392889f, 0.21333137f, 
    -0.10646269f, -0.01962646f, 0.03471639f, 0.05522037f, -0.14110757f, 0.35686225f, 0.45788136f, 0.33371592f, 
    -0.20596689f, 0.15950815f, 0.02035401f, -0.23083955f, 0.15750358f, 0.02556784f, -0.00069826f, -0.04476023f, 
    0.34090340f, 0.15193105f, -0.05215403f, 0.30233538f, -0.11349873f, 0.16525373f, 0.07518332f, -0.19403513f, 
    0.22245033f, 0.11581288f, -0.06932172f, -0.28481880f, 0.19593260f, 0.22063883f, 0.28423521f, 0.20810805f, 
    -0.07006705f, -0.62086380f, -0.39580411f, 0.15951927f, 0.12242905f, -0.04936596f, 0.19772831f, -0.05888985f, 
    0.09593198f, -0.23753855f, -0.13807909f, -0.11965778f, -0.14788310f, 0.10500026f, 0.19996396f, -0.26767421f, 
    0.24938697f, 0.01940768f, -0.59482139f, -0.81039208f, 0.12500843f, 0.04050447f, -0.12377052f, -0.02721331f, 
    -0.22694799f, 0.00983020f, -0.25441089f, 0.22377321f, 0.02338687f, 0.12856995f, 0.20785172f, -0.12975650f, 
    0.13648252f, -0.30042860f, 0.14225134f, 0.18888204f, 0.66160882f, 0.43790674f, 0.08224847f, -0.16403058f, 
    0.09795144f, -0.15836513f, -0.01552769f, 0.05378984f, -0.12415816f, 0.19949898f, 0.01540262f, -0.23975262f, 
    -0.23730157f, 0.08549387f, 0.01197885f, 0.14469677f, 0.03060990f, 0.16425565f, 0.08267954f, -0.17531434f, 
    -0.31378540f, 0.24872383f, 0.03837505f, 0.37435216f, 0.26956218f, 0.13783833f, -0.40639350f, 0.49996397f, 
    -0.25688860f, -0.01982772f, 0.20664681f, -0.00115897f, 0.06094725f, -0.09761570f, 0.18905392f, 0.09298722f, 
    -0.04909721f, -0.13378857f, -0.34426486f, 0.37823096f, -0.08937608f, 0.27291515f, -0.00197325f, -0.07673842f, 
    -0.31826851f, 0.22171815f, -0.06252132f, -0.19338937f, 0.19968697f, 0.04631295f, -0.06075012f, 0.10180621f, 
    0.11145470f, -0.19420081f, 0.22329448f, 0.24684495f, 0.16396883f, -0.04374141f, -0.07026061f, 0.01569987f, 
    0.06227201f, 0.23856510f, 0.02376893f, 0.13549788f, -0.19803376f, 0.17595989f, -0.34592894f, 0.11333847f, 
    -0.18754385f, -0.07212939f, 0.04469067f, 0.18962853f, 0.44006664f, 0.00907802f, 0.00155100f, -0.08962618f, 
    0.09264468f, -0.08781808f, -0.13268727f, -0.05221235f, 0.14753209f, -0.33344835f, -0.22684874f, 0.21960641f, 
    0.28619534f, 0.19965211f, 0.12384097f, -0.13417241f, 0.11033736f, 0.13228267f, 0.24341346f, -0.28609315f, 
    0.28161401f, 0.12378227f, 0.12455488f, -0.07249397f, 0.16070575f, -0.04993550f, 0.15481704f, 0.33853254f, 
    -0.14433208f, -0.25194949f, 0.17236179f, 0.03359728f, 0.15664701f, 0.39355293f, 0.39024860f, -0.15564917f, 
    -0.48251399f, 0.25077459f, 0.28211865f, 0.24662249f, 0.11333454f, -0.19571523f, -0.01041749f, 0.01730368f, 
    -0.07367386f, -0.09945270f, 0.11621602f, -0.15953155f, -0.30473667f, -0.02746206f, -0.12815036f, 0.09846206f, 
    0.01033209f, 0.02307019f, 0.38276318f, -0.32014710f, 0.07327518f, 0.14679869f, -0.02337400f, 0.23149592f, 
    -0.02208303f, -0.11699738f, 0.05081398f, -0.02221712f, 0.23178540f, -0.32693043f, -0.13330010f, -0.05554752f, 
    0.12012263f, 0.08115349f, 0.09396090f, -0.14906634f, 0.23249407f, -0.57971537f, -0.20351402f, 0.17811154f, 
    0.01400917f, 0.13330007f, 0.19689409f, -0.34028107f, 0.02341938f, 0.11927647f, 0.38885012f, -0.15415965f, 
    -0.06248490f, 0.02852588f, 0.14473383f, 0.08927970f, 0.02744047f, -0.21640947f, 0.03642607f, -0.09256507f, 
    0.32603535f, 0.09546909f, 0.04400608f, -0.18447831f, 0.05032795f, -0.14132802f, -0.05413853f, 0.37509954f, 
    -0.06606038f, 0.07760234f, 0.11836916f, 0.24195530f, -0.05049438f, 0.06187240f, 0.07177439f, 0.03008022f, 
    -0.12612760f, 0.23480271f, -0.00216745f, 0.20885088f, -0.17547323f, -0.14241141f, 0.19175349f, 0.23868364f, 
    0.03834365f, -0.17313103f, -0.08911645f, -0.16164331f, -0.14123499f, 0.04990549f, 0.13256682f, -0.05882338f, 
    0.02829117f, 0.21868646f, 0.32513118f, -0.05586402f, -0.42895773f, 0.10921211f, -0.09311395f, -0.04227536f, 
    -0.10762987f, 0.03673590f, 0.23199099f, -0.28046697f, 0.33846956f, -0.42296386f, -0.09312247f, -0.01629876f, 
    0.03471331f, 0.02563694f, -0.03452126f, -0.06582090f, -0.29602027f, 0.50337672f, -0.25126931f, -0.15268098f, 
    -0.02794585f, 0.01722596f, -0.05926703f, 0.13259339f, 0.00011132f, -0.25668392f, -0.06794592f, -0.21930686f, 
    -0.26100460f, 0.08028398f, 0.14378184f, 0.09561299f, 0.12089238f, 0.13821581f, -0.03612361f, -0.38430238f, 
    0.04088512f, -0.06724916f, -0.08065324f, -0.19597462f, -0.24210615f, 0.08203564f, 0.16919313f, -0.30455142f, 
    0.13364613f, 0.08364468f, -0.10138582f, -0.18506822f, -0.31316191f, 0.22922492f, 0.17261980f, 0.40129951f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.34094614f, 0.14045529f, -0.07376295f, -0.19666286f, -0.01586613f, 0.04858780f, 0.12565205f, -0.33549190f, 
    0.29038277f, 0.04140950f, -0.01779068f, -0.22837569f, 0.06578183f, 0.21521941f, 0.07850578f, -0.01124182f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20647831f, -0.40216973f, 0.57732940f, -0.30260345f, 0.10669594f, -0.04123078f, -0.26263410f, 1.05496430f, 
    0.03026380f, -0.31120816f, -0.15801719f, -0.39201081f, -0.17133078f, 0.16354622f, -0.07583040f, -0.61047035f, 
    0.26571900f, 0.12132813f, 0.71464008f, -0.37446126f, -0.11443464f, -0.36591226f, 0.38290152f, -0.24649304f, 
    -0.38708824f, 0.31110162f, -0.55605227f, -0.25508133f, 0.05458674f, 0.12597333f, -0.28962001f, -0.04549721f, 
    0.13873708f, -0.17168625f, -0.01369853f, -1.02318978f, -0.21642561f, 0.08064979f, 0.69522971f, -0.06088878f, 
    -0.36113781f, -0.63234848f, 1.16797662f, 0.40602943f, -0.23434933f, -0.43289712f, -0.42908642f, -0.62910026f, 
    0.29661471f, -0.77522427f, 0.26774871f, 0.45571324f, -0.22055179f, -0.26918378f, -0.73571646f, -0.81251329f, 
    0.01239879f, -0.14785376f, 0.27762762f, 0.14359784f, 0.01681408f, 0.11316618f, -0.17322056f, 0.78692508f, 
    0.16507748f, -0.15818557f, -0.00194700f, -0.28777671f, 0.08606794f, 0.13467583f, -0.54652625f, -0.28758302f, 
    0.53706932f, -0.22398190f, 0.06646821f, 0.35956559f, -0.07775941f, -0.04071547f, 0.05710093f, -0.36057138f, 
    -0.12083393f, 0.32718629f, -0.00694278f, 0.15931663f, -0.03357110f, 0.04841387f, 0.09307256f, 0.25845581f, 
    0.62247318f, 0.43932095f, -0.63744038f, -0.91942477f, -0.01443991f, -0.61117113f, -0.21573837f, -0.20859194f, 
    0.04773273f, 0.76937300f, -0.06015555f, -0.37095869f, 0.03315748f, -0.70104498f, -0.44702938f, -0.58002603f, 
    0.31526130f, -0.26546153f, -0.02631672f, -0.20900039f, -0.16820402f, -0.38095328f, 0.10791483f, 0.08264163f, 
    -0.46270788f, -0.53394222f, 0.00112991f, 0.72319978f, -0.12922210f, 0.56444854f, -0.39834303f, 0.35090354f, 
    -0.50314146f, 0.05839773f, -0.21130762f, 0.63631028f, -0.14626814f, 0.31147671f, -0.15640648f, -0.04043676f, 
    -0.65387762f, -0.28452867f, -0.75130153f, -0.47605571f, 0.10490207f, 0.86175781f, 0.24863596f, 0.34441248f, 
    -0.46284807f, 0.38853431f, -0.06417502f, 0.03171914f, -0.21398264f, 0.45764589f, -0.28358305f, 0.72213084f, 
    -0.22384958f, 0.34999228f, -0.18273108f, -0.19621164f, -0.08046447f, 0.45805302f, -0.32691970f, 0.04003235f, 
    0.19006282f, -0.45667905f, -0.03443675f, 0.64753193f, 0.10755453f, -0.57825583f, 0.14646648f, -0.39411035f, 
    0.93500197f, -0.54040170f, -0.86841279f, 0.32948214f, 0.02984086f, -0.18092296f, 0.27874655f, -0.55872518f, 
    -0.62318808f, -0.33543164f, 0.16911072f, -0.55549479f, 0.05887160f, 0.68882990f, -0.11870357f, 0.23953250f, 
    -0.37409434f, -0.43441579f, -0.12741786f, -0.57461596f, -0.01248138f, -0.68919665f, -0.16027044f, -0.67282939f, 
    -0.09148513f, 0.48480859f, 0.34915623f, -0.22484009f, -0.13037141f, 0.39445874f, 0.87946695f, -0.02901872f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.35319892f, 0.10777977f, -0.25894287f, -0.18979836f, 0.11935454f, -0.01525792f, 0.18724827f, -0.89835387f, 
    -0.09110601f, 0.23108180f, 0.13000268f, 0.04440854f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
