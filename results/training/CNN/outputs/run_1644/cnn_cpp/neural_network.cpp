#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.30304506f, -0.13400103f, -1.05068624f, -0.55314922f, 0.32003742f, 0.03441305f, -0.95394641f, -0.22027384f, 
    0.04586306f, -0.95571625f, -0.27604800f, 0.64312494f, -0.06423377f, -0.02000489f, 0.11910976f, -0.22318919f, 
    -0.35765633f, -0.06313764f, -0.12320117f, -0.10100197f, 0.32513839f, 0.42280656f, -0.00048189f, -0.01607026f, 
    0.62073684f, -0.64655870f, -0.24485427f, -0.20147562f, -0.36353558f, -0.30588976f, -0.89528227f, -1.04685688f, 
    -1.08481383f, -0.45861459f, -0.71721786f, 0.03766381f, 0.31291988f, -0.15567896f, -0.76379502f, 0.02826395f, 
    -0.24507387f, 0.07519504f, -0.06606197f, -0.38478795f, -0.18943429f, -0.25045156f, 0.17432535f, -0.12339928f, 
    -0.30640244f, -0.06524207f, 0.34355003f, -0.03222724f, -0.69838428f, -0.24609506f, -0.09243097f, -0.57985055f, 
    0.78917128f, 0.06270682f, 0.45976308f, -0.46606979f, 0.14500137f, 0.10077312f, 0.19320185f, -0.02646193f, 
    -0.58992678f, -0.42657968f, -0.44608280f, 0.43771893f, -0.03039492f, 0.02380104f, -0.02680446f, 0.20875135f, 
    0.05089211f, -0.09784271f, 0.30613080f, 0.32707658f, -0.25769430f, 0.28728852f, -0.26349020f, 0.34682336f, 
    -0.50547194f, 0.12542401f, 0.79322338f, 0.06146979f, -0.08515103f, -0.02949347f, 0.36273083f, -0.31072491f, 
    -0.66510963f, 0.77209473f, -0.12296658f, 0.23421299f, -0.29938278f, -0.37872443f, 0.19638042f, 0.12985483f, 
    0.10945373f, -0.07447084f, -0.07888188f, -0.27090958f, -1.45335782f, -0.80098701f, 0.26969066f, 0.23040253f, 
    0.00231212f, 1.12716341f, 0.66177285f, 0.36441416f, 0.11192565f, -0.13349932f, 0.22774750f, 0.15171646f, 
    -0.18480042f, 0.38734937f, -0.26185310f, 0.06564389f, -0.19444118f, -0.13100328f, -0.22550368f, -0.12862729f, 
    -0.11636151f, 0.06558970f, -0.01725707f, 0.24311404f, -0.11468124f, 0.81470895f, 0.44638348f, -0.45940661f, 
    -0.43921319f, -0.05868574f, -0.03157001f, -0.47662595f, -0.25544998f, 0.09724212f, 0.39456895f, 0.07045020f, 
    0.17269112f, -0.14297713f, 0.04658246f, 0.07646711f, 0.30485383f, 0.04811594f, -0.27803236f, -0.00558134f, 
    -0.23009899f, -0.50800097f, -0.28156701f, -0.32796654f, -0.42903611f, -0.58720028f, 0.74530220f, -0.00517807f, 
    0.44364363f, -0.46596840f, -0.75048113f, 0.53193367f, 0.06328593f, 0.16541046f, 0.07453199f, 0.00406606f, 
    0.19729413f, -0.02442754f, -0.28944924f, -0.13887906f, -0.42272851f, -0.15079650f, -0.12873146f, 0.13924986f, 
    0.10684600f, -0.42251140f, -0.32022172f, 0.05121379f, -0.26375231f, -0.41001520f, -0.57381731f, 0.69756377f, 
    0.75797164f, 0.24297695f, -0.47239587f, -0.21143362f, 0.33402178f, 0.59644556f, 0.61009443f, -0.13831216f, 
    -0.33619601f, -0.07833225f, 0.18344381f, 0.10036358f, 0.18125145f, 0.01012558f, -0.09305226f, -0.15560947f, 
    -0.54056120f, -0.34446216f, -0.20293796f, 0.26494202f, 0.11965198f, 0.09429534f, 0.27907521f, 0.44287890f, 
    0.45839405f, 1.14705539f, -0.08402727f, -0.84679258f, -0.79290307f, -0.48291051f, -0.24427731f, 0.00991244f, 
    -0.05848829f, -0.67414635f, 0.25246391f, 0.39954954f, 0.58182162f, 0.53726649f, -0.00528339f, 0.01971543f, 
    0.30524981f, -0.08700360f, 0.07065987f, -0.04480778f, 0.16986094f, 0.19845308f, -0.21133970f, -0.27244225f, 
    -0.20855880f, 0.47257915f, 0.70169580f, 0.43803206f, -0.40429598f, 0.28154886f, -0.55874866f, -0.51560682f, 
    -0.50303531f, 0.10538968f, 0.31365064f, -0.15636736f, 0.42440602f, -0.07341377f, -0.09242455f, 0.57060856f, 
    0.02287074f, -0.41390410f, -0.08951034f, 0.16261221f, 0.23224019f, -0.34235430f, 0.18780480f, 0.45503497f, 
    -0.48428804f, 0.19271877f, 0.98577124f, 0.63926637f, 0.06210436f, 0.60948664f, -0.24842758f, -0.38415125f, 
    -0.53920203f, -0.03629633f, 0.62340313f, -0.31231284f, 0.25564626f, 0.20240034f, -0.31382936f, -0.48915023f, 
    0.00033099f, -0.14045385f, 0.07618563f, 0.02419616f, -0.01329129f, -0.04877608f, 0.28290382f, -0.23754863f, 
    -0.11628981f, 0.14786334f, -0.19405557f, -0.25162542f, -0.97783744f, -1.15943801f, -0.96183431f, -0.71514010f, 
    0.56708390f, 0.31753948f, 0.12174992f, 0.15356596f, 0.28308839f, 0.04819681f, 0.01875334f, -0.11416200f, 
    0.25710899f, -0.31228441f, -0.19704472f, -0.06136838f, 0.33308145f, -0.02752358f, -0.21941103f, -0.39868075f, 
    -0.17712329f, -0.02772946f, -0.31688201f, -0.28717515f, 0.42068714f, -0.26479211f, 0.10035158f, -0.19959815f, 
    0.25696629f, -0.04611694f, 0.70648026f, -0.39986280f, 0.20340040f, -0.26040769f, -0.00263245f, 0.02786446f, 
    0.15577663f, -0.12466272f, 0.23815569f, 0.24340509f, 0.07669941f, -0.30445057f, 0.09789050f, 0.17915210f, 
    0.07278414f, 0.09160005f, 0.32594830f, 0.05545980f, 0.17666031f, -1.01165068f, -0.66831142f, -0.18128324f, 
    -0.89201897f, -0.77027023f, 0.65540951f, 0.16161308f, -0.26105389f, -0.22435801f, -0.29804635f, 0.00185378f, 
    -0.17821343f, -0.03783496f, 0.38506112f, 0.53971249f, -0.11972130f, -0.08475952f, -0.20462474f, -0.69709373f, 
    -0.51967835f, -0.02060075f, -0.35603216f, 0.63177693f, -0.08725573f, 0.22050655f, -0.77586466f, -0.50526482f, 
    0.04289900f, 0.87437260f, 0.62822312f, 0.54030567f, 0.10616508f, -0.25785699f, 0.17902596f, 0.20939708f, 
    -0.42643610f, 0.29862198f, -0.09453729f, -0.37799594f, -0.66235054f, -0.16580336f, 0.39104658f, 0.06735460f, 
    -0.27490997f, -0.02583989f, 0.02961778f, -0.01779052f, 0.11115674f, 0.02105442f, 0.06371675f, 0.92874247f, 
    0.08186871f, 0.26778924f, -0.32345134f, 0.84137666f, -0.62570959f, 0.41047809f, -0.57579994f, -0.23872712f, 
    -0.53593862f, -0.23512757f, 0.15578252f, 0.04249381f, -0.38714916f, 0.16329080f, 0.01864764f, -0.14816931f, 
    0.12227143f, 0.13395792f, 0.15698384f, -0.13982901f, 0.23673923f, -0.11834732f, -0.05876029f, 0.12355933f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26425084f, -0.02196907f, 0.25495484f, 0.49115688f, 0.54414338f, 0.03547870f, 0.31343865f, 0.08024038f, 
    0.27037743f, 0.19372590f, 0.25397307f, -0.02562433f, 0.44779709f, 0.15665808f, 0.24832408f, 0.32447159f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13058451f, 0.03439195f, 0.36306569f, 0.26296300f, -0.08522891f, -0.05114117f, 0.27908981f, 0.12435104f, 
    -0.07520128f, -0.01213692f, 0.00902821f, 0.07965136f, -0.19594739f, -0.02492081f, 0.34750286f, 0.37563020f, 
    0.06436092f, 0.11737273f, 0.00385774f, 0.21005234f, -0.00745812f, -0.03701030f, 0.05891666f, 0.01538640f, 
    -0.08291931f, -0.12252882f, -0.18762110f, -0.29629084f, 0.17550774f, -0.04773893f, 0.16167973f, -0.16502549f, 
    0.15806980f, 0.18076062f, 0.02658476f, 0.23592624f, 0.27422404f, -0.24062397f, -0.01323536f, 0.21733290f, 
    0.14663707f, -0.14249267f, -0.15568633f, -0.12542515f, 0.13916147f, 0.13950206f, -0.34579650f, -0.06509219f, 
    0.36045837f, 0.24608094f, -0.18511738f, -0.02933712f, -0.06388967f, -0.03488246f, -0.06527580f, -0.00743544f, 
    -0.09909540f, -0.05639280f, -0.04936149f, 0.10541902f, -0.10483151f, -0.09897599f, 0.17775206f, -0.14854616f, 
    0.04627765f, -0.01732399f, -0.02137708f, -0.17231312f, 0.15221626f, 0.05965063f, -0.12455695f, -0.06903853f, 
    0.35527655f, 0.14904118f, 0.07210433f, -0.19385625f, -0.07453588f, -0.01830772f, -0.12824044f, -0.09102532f, 
    0.01139987f, -0.18643902f, -0.26264060f, -0.07845471f, 0.18929364f, 0.10782075f, -0.07833512f, 0.32091549f, 
    0.04685850f, -0.04904558f, -0.00778817f, -0.04272890f, 0.14926770f, 0.07344506f, -0.11138824f, 0.10138308f, 
    -0.43153542f, 0.09345557f, -0.18269369f, 0.01158065f, 0.16999689f, 0.11497698f, -0.06202625f, 0.19772850f, 
    -0.10101247f, 0.04406533f, -0.01264719f, 0.01026020f, -0.14892220f, -0.01592951f, 0.27048060f, -0.09540571f, 
    0.27768534f, 0.00878609f, -0.06075278f, -0.17866759f, 0.12349120f, 0.04814021f, -0.10417966f, -0.06172080f, 
    -0.09822097f, 0.09833078f, 0.12831473f, 0.26726082f, 0.08317714f, -0.00986642f, -0.11904667f, 0.03028989f, 
    0.12110333f, -0.07853577f, 0.05556903f, 0.13042900f, -0.04997672f, -0.09680390f, 0.14840579f, -0.02934281f, 
    -0.29349670f, -0.23214708f, -0.04356028f, -0.24864919f, 0.03082330f, -0.33774477f, -0.05028983f, -0.04300443f, 
    0.20569088f, -0.06011430f, 0.00912376f, -0.00537070f, 0.03804506f, -0.00082056f, -0.00817135f, -0.04878166f, 
    0.08188649f, 0.03712375f, -0.06243768f, 0.03146555f, -0.03145783f, 0.03655301f, 0.16023599f, 0.18679269f, 
    0.06690793f, -0.10957809f, 0.12574348f, 0.26117101f, 0.08459949f, -0.01816235f, -0.01969080f, -0.21882080f, 
    0.01923720f, -0.12956449f, 0.31183836f, 0.21633425f, -0.02969030f, 0.09777112f, 0.02651592f, 0.14829962f, 
    0.07637563f, -0.20335187f, -0.06602965f, -0.04497305f, 0.69259506f, 0.18880659f, 0.03888568f, -0.43758690f, 
    0.16213536f, -0.20427254f, -0.10014530f, -0.02283751f, 0.06301790f, -0.07863093f, -0.07571422f, -0.05998256f, 
    -0.32130083f, -0.27548286f, 0.24023525f, 0.04705730f, -0.04690234f, -0.38139176f, 0.07007094f, 0.05528506f, 
    -0.01950413f, 0.06692354f, -0.03847242f, 0.05841764f, -0.41554645f, -0.37277821f, -0.16548020f, -0.02367840f, 
    -0.22233984f, -0.11351144f, 0.17318225f, -0.14923012f, 0.06874387f, 0.12346514f, 0.11724659f, 0.03146733f, 
    -0.42993414f, -0.04398336f, 0.46240690f, 0.06741782f, 0.09536909f, 0.18101776f, 0.03206786f, 0.16356698f, 
    -0.07349714f, 0.04312590f, -0.01996341f, -0.01797416f, -0.02090167f, 0.38180959f, 0.03744442f, -0.28055859f, 
    0.07253152f, 0.21174186f, 0.09158614f, 0.01724214f, 0.14598815f, -0.15410849f, 0.40303442f, 0.24170166f, 
    0.03050342f, 0.29126915f, 0.40379182f, 0.28661117f, -0.01345067f, -0.03019141f, -0.06613468f, -0.08735322f, 
    0.16037810f, 0.20966607f, 0.22006036f, 0.10858545f, 0.17370985f, 0.09403899f, -0.08208603f, -0.11342023f, 
    0.06331819f, -0.04585271f, 0.07744282f, -0.04405947f, 0.14715374f, 0.28591153f, 0.34970167f, 0.02292161f, 
    0.01958615f, 0.40153646f, 0.25365168f, 0.15242839f, -0.06700958f, -0.04054658f, 0.18642092f, -0.09291632f, 
    0.24046066f, 0.34973487f, 0.27545363f, 0.17860121f, -0.23942178f, -0.11171415f, -0.07513640f, -0.40553316f, 
    -0.04079205f, -0.14793406f, 0.08265524f, -0.01980482f, -0.01503631f, 0.00212388f, -0.08365396f, -0.13232760f, 
    -0.28609338f, 0.31229889f, 0.08819807f, -0.15483335f, 0.26070809f, 0.04001612f, 0.19709194f, -0.06166034f, 
    0.03428450f, 0.09162903f, -0.05704934f, -0.06033083f, -0.01219998f, -0.27274770f, -0.25872183f, 0.01226827f, 
    -0.17004064f, 0.02620218f, 0.40378594f, -0.07109886f, -0.06883916f, -0.04579062f, 0.21611756f, 0.02413544f, 
    0.08747724f, -0.11278078f, -0.32966074f, -0.29719248f, -0.01998109f, -0.01053509f, 0.11496126f, 0.01735190f, 
    0.04059753f, -0.05233011f, -0.04291984f, -0.17995870f, -0.28373131f, 0.16423880f, 0.44387165f, 0.11524804f, 
    -0.11749253f, -0.23585126f, 0.13508722f, 0.35761163f, 0.05890262f, 0.17538168f, -0.02648950f, 0.14387366f, 
    -0.10774594f, -0.03125506f, 0.06564633f, -0.11622095f, -0.03720294f, 0.18148941f, -0.02336364f, 0.12875506f, 
    0.20761247f, -0.08650181f, 0.07909013f, -0.03011931f, -0.11645187f, 0.08108629f, 0.04550784f, 0.03619036f, 
    -0.04435083f, -0.13437262f, 0.17967142f, 0.12419838f, 0.15126015f, 0.03155734f, 0.03520558f, 0.09103063f, 
    -0.09544939f, -0.46257052f, -0.00144520f, -0.00625936f, -0.04290450f, 0.09021032f, -0.22581981f, -0.00129984f, 
    -0.02112776f, -0.03446230f, 0.13441609f, -0.05110601f, 0.00425773f, 0.03847596f, 0.20475654f, -0.18141349f, 
    0.09821143f, 0.22239381f, 0.38611257f, 0.28188851f, -0.02216000f, -0.06447826f, -0.03206097f, -0.03220046f, 
    0.04848323f, 0.01487845f, 0.12303397f, 0.14966404f, 0.13064325f, 0.04663914f, -0.14160511f, 0.17826587f, 
    -0.03841289f, -0.19819154f, -0.30316219f, -0.34254768f, 0.17868121f, -0.29905960f, 0.05319752f, 0.10068695f, 
    0.08850326f, -0.05291814f, 0.12606868f, 0.21120162f, 0.06463291f, 0.05166755f, -0.14613664f, -0.11744047f, 
    0.17592530f, 0.15804407f, -0.26267275f, -0.00640105f, 0.25138620f, -0.16405062f, -0.07013244f, 0.15094844f, 
    -0.16649196f, 0.21901719f, 0.22690015f, -0.44826448f, 0.03577716f, 0.06098698f, -0.15412937f, 0.15117182f, 
    0.02988389f, 0.09177332f, -0.18242043f, -0.16356671f, -0.09742197f, 0.20478542f, -0.26784620f, 0.26634181f, 
    -0.00841519f, 0.40626240f, -0.15233196f, -0.06089004f, 0.17426270f, 0.12726650f, -0.05844203f, 0.17828076f, 
    -0.09982451f, -0.03602594f, 0.09303331f, -0.02451097f, -0.24267578f, 0.01376004f, 0.27333838f, 0.06304992f, 
    -0.16948330f, 0.08033663f, 0.03388272f, 0.10582571f, -0.01209692f, 0.21943586f, 0.19826168f, 0.47311354f, 
    -0.37024361f, 0.03185479f, 0.14852263f, 0.15626183f, -0.16421753f, 0.09662024f, 0.02402912f, -0.17813255f, 
    0.29306060f, 0.33638230f, 0.30313426f, 0.15669677f, -0.21031249f, 0.27448526f, -0.05333270f, -0.04821328f, 
    -0.08126919f, 0.02512827f, -0.12600406f, -0.31030044f, -0.25159946f, 0.02772075f, -0.18611389f, -0.28459421f, 
    -0.12458963f, 0.19022878f, 0.39706281f, 0.16270176f, 0.18047395f, 0.10999095f, -0.02562673f, 0.20735976f, 
    0.17669572f, -0.25783220f, -0.06944542f, -0.07284945f, 0.10118950f, 0.16713154f, 0.37854895f, -0.09262056f, 
    0.12400334f, 0.20345978f, -0.32053298f, -0.32426977f, -0.12240662f, -0.20182264f, -0.04500097f, -0.09249882f, 
    -0.22473197f, 0.08013936f, 0.39076650f, 0.10684886f, -0.21018316f, -0.04406516f, -0.06548618f, 0.00431766f, 
    0.09851336f, 0.14204128f, -0.34459960f, 0.14953405f, 0.08966663f, -0.17477280f, -0.01805859f, 0.33454013f, 
    0.15330495f, -0.05334396f, 0.12088109f, 0.11545932f, 0.23771895f, 0.12869754f, 0.14814578f, 0.30994841f, 
    -0.18680501f, 0.22068207f, -0.40907133f, -0.53548688f, 0.09927292f, -0.18197702f, -0.18507642f, -0.06996354f, 
    -0.33798599f, -0.42290893f, -0.42335814f, -0.51420665f, 0.15902887f, -0.04711667f, -0.05707554f, 0.31793305f, 
    0.09353647f, 0.14270951f, 0.04695029f, -0.01885110f, 0.11145938f, 0.07978407f, -0.13436304f, 0.08702525f, 
    -0.06746373f, 0.25404301f, -0.07316754f, -0.27914670f, 0.18882802f, 0.06660757f, 0.02224450f, -0.04231658f, 
    -0.07150117f, 0.10746203f, -0.16712596f, 0.06763750f, 0.12444925f, 0.54976588f, 0.67236477f, 0.17209238f, 
    -0.01392129f, 0.06439906f, -0.05713343f, 0.06232645f, -0.04339635f, -0.08339060f, -0.11253892f, -0.16836104f, 
    -0.00366467f, -0.01629536f, 0.02956261f, 0.00267539f, -0.03130954f, -0.04540103f, -0.01168883f, -0.02184381f, 
    -0.06916696f, -0.01758338f, 0.02227171f, -0.04183242f, -0.05330002f, -0.06070187f, 0.03899173f, -0.00914695f, 
    -0.07701499f, -0.04561407f, -0.04634956f, 0.05221454f, 0.01802950f, 0.00236180f, 0.00626102f, -0.04843597f, 
    0.05713919f, -0.04177165f, -0.07838474f, -0.00435792f, -0.05407599f, -0.06013583f, -0.00888890f, 0.01389041f, 
    0.02310838f, 0.05483083f, -0.02629098f, -0.05583860f, 0.05180150f, 0.05770511f, -0.05066335f, 0.02365357f, 
    -0.01963285f, -0.05435148f, 0.03033261f, 0.02447167f, -0.06432154f, -0.03625076f, 0.02415921f, 0.06130827f, 
    0.03159068f, 0.03634365f, 0.05290180f, 0.03776531f, -0.07405129f, 0.04100669f, 0.00329401f, -0.06729220f, 
    0.00419644f, 0.02381912f, -0.04823998f, 0.04322063f, -0.06389218f, 0.02431334f, -0.04840134f, -0.06488252f, 
    0.00999127f, 0.02039043f, -0.02485075f, 0.05684743f, -0.04659015f, -0.05688163f, 0.04082941f, -0.07432609f, 
    -0.06595346f, 0.03848125f, 0.06070111f, 0.03913823f, 0.03090424f, 0.04808850f, -0.07718381f, -0.01817647f, 
    0.04883404f, -0.05908381f, 0.00979127f, -0.03209297f, -0.00841041f, 0.01302169f, -0.02518729f, -0.07455144f, 
    -0.07406171f, -0.02559535f, 0.01160570f, 0.00517646f, -0.07943197f, -0.07001777f, 0.05651648f, 0.02076814f, 
    -0.02956208f, 0.01766475f, -0.04961525f, -0.02300546f, -0.06684976f, 0.04782137f, -0.02494928f, 0.00646754f, 
    -0.06011620f, -0.00888226f, -0.00252007f, 0.03452193f, 0.00409037f, -0.04145438f, -0.06357057f, -0.07894067f, 
    -0.02493102f, 0.00718076f, -0.05839111f, 0.04657586f, -0.00862989f, -0.07196816f, -0.07102870f, -0.04499196f, 
    -0.00950935f, -0.04404590f, -0.05536821f, 0.07964655f, -0.01499571f, 0.05897376f, 0.04191754f, 0.00142115f, 
    -0.02544799f, 0.05870903f, 0.02929839f, -0.04199844f, -0.07173306f, -0.04347769f, -0.04363596f, -0.06294603f, 
    -0.04746997f, -0.04498426f, 0.03692298f, 0.02078006f, -0.04984106f, 0.00481780f, -0.06478196f, 0.04947479f, 
    -0.08059958f, -0.07744674f, -0.04948698f, 0.05059709f, 0.04696004f, 0.05208101f, -0.02621016f, 0.00066196f, 
    0.05467430f, 0.02937211f, 0.04843988f, -0.00072759f, 0.05700295f, -0.00385644f, 0.04320196f, -0.00989109f, 
    -0.00622956f, 0.00993193f, -0.02335211f, 0.04212178f, 0.00584036f, -0.00167852f, -0.04614311f, -0.03664516f, 
    -0.00340685f, 0.00570760f, -0.04054239f, -0.05994473f, 0.01336485f, -0.02897534f, 0.03466126f, 0.04419310f, 
    0.04101032f, -0.05344152f, 0.05822388f, 0.00927303f, 0.05115546f, -0.03837371f, 0.00523053f, -0.05396491f, 
    -0.02903458f, -0.00468298f, -0.01132395f, 0.04072195f, -0.03727727f, -0.02019080f, 0.04966489f, 0.05686570f, 
    -0.05263064f, 0.13479562f, 0.02687119f, 0.31816310f, -0.11453991f, -0.02586894f, -0.09618811f, 0.18163376f, 
    -0.04817251f, -0.12597454f, -0.12475340f, -0.10329466f, -0.09647400f, 0.21653686f, -0.06158777f, 0.06032731f, 
    -0.21065849f, -0.01352186f, -0.15522489f, -0.02854530f, -0.10915375f, 0.09845740f, 0.10475534f, 0.13354491f, 
    -0.02407584f, -0.31907678f, 0.23581301f, -0.02436520f, -0.07982066f, 0.20892687f, 0.15448968f, 0.06545243f, 
    0.03305412f, -0.05749979f, -0.08475380f, -0.08612785f, 0.26348883f, 0.34198946f, 0.31631950f, 0.00093738f, 
    -0.05289669f, 0.22316232f, 0.23627676f, 0.00272396f, 0.14824301f, 0.03296114f, 0.06694461f, 0.10076062f, 
    0.14329304f, -0.56961393f, -0.04282077f, 0.05856215f, -0.05801357f, -0.15637732f, 0.11489016f, -0.06137006f, 
    -0.00208101f, -0.02551294f, 0.16737594f, 0.01049165f, -0.00095943f, -0.01743177f, -0.11786918f, 0.16669506f, 
    0.02504708f, 0.12804759f, -0.25576958f, 0.00510369f, 0.09500368f, -0.02198225f, -0.01058364f, 0.15279830f, 
    0.39754176f, 0.12914523f, 0.25544897f, -0.14390530f, -0.08969361f, -0.18627101f, 0.02265255f, 0.04205983f, 
    -0.14639054f, -0.01439443f, 0.06843608f, 0.19670716f, 0.34020174f, -0.09121874f, 0.10973027f, -0.06497183f, 
    -0.11666369f, -0.01330286f, 0.08416658f, -0.01552686f, -0.08369886f, -0.13127059f, 0.03120716f, 0.02221574f, 
    -0.07852478f, -0.37399724f, 0.13114010f, -0.05802088f, 0.10845006f, 0.06619651f, -0.14875491f, -0.16099258f, 
    -0.01272012f, 0.01213740f, -0.09474497f, 0.00390964f, 0.71023619f, -0.06507367f, -0.06593504f, 0.25283381f, 
    0.07367887f, -0.02993084f, -0.10505420f, -0.16816621f, -0.10596664f, 0.07296572f, -0.09565865f, -0.16534023f, 
    0.45192137f, 0.36922616f, 0.20497699f, 0.21839568f, -0.13853048f, -0.13054356f, 0.01952401f, 0.01094119f, 
    -0.12667345f, -0.07823447f, 0.03079451f, 0.09043080f, 0.04358902f, 0.27107990f, -0.13905688f, -0.16010378f, 
    -0.21218786f, -0.06676647f, 0.11239173f, -0.01045600f, 0.16402557f, 0.05701176f, -0.10666237f, -0.06389514f, 
    0.20985526f, 0.03794117f, 0.15895309f, 0.22924186f, -0.12617381f, 0.18752679f, -0.03239397f, -0.07299399f, 
    -0.09020147f, -0.24233180f, 0.04947871f, -0.12471773f, -0.08902020f, 0.06142438f, 0.46021089f, 0.01278473f, 
    0.13397937f, -0.09446955f, 0.21850421f, -0.00729336f, 0.12287477f, -0.05171793f, 0.10619669f, -0.11382730f, 
    0.00837631f, -0.15142711f, -0.12030428f, 0.13511094f, -0.18522647f, 0.03200035f, -0.02416862f, 0.12341259f, 
    0.17961682f, 0.05847196f, -0.07550211f, -0.10472713f, 0.91184038f, 0.16860156f, -0.32292086f, -0.13043980f, 
    -0.35689041f, 0.04108086f, -0.32840735f, -0.10278594f, -0.17708056f, 0.02851418f, 0.05368381f, -0.05432999f, 
    0.20911066f, 0.48484269f, 0.08343682f, -0.09139946f, 0.01652954f, 0.00531589f, 0.10075148f, -0.10401325f, 
    0.03939854f, -0.17792834f, -0.09505484f, 0.05232276f, 0.15807250f, 0.51290572f, 0.26917556f, 0.04572054f, 
    0.00340679f, 0.07441807f, -0.11570574f, -0.11692344f, 0.03822722f, -0.10865516f, 0.09812988f, 0.11184430f, 
    0.23066206f, -0.11471204f, -0.23440230f, 0.20699635f, 0.16344975f, 0.13190864f, 0.02376606f, -0.00039936f, 
    0.14546441f, 0.08945212f, -0.27140898f, 0.06211703f, 0.09159647f, -0.35150427f, -0.31220376f, 0.30480385f, 
    -0.05822591f, -0.20531437f, -0.03764277f, 0.17289065f, -0.01637812f, -0.12078654f, 0.33888060f, -0.01374302f, 
    -0.14119919f, -0.28800672f, 0.30257097f, 0.09241938f, 0.11159012f, -0.00040212f, 0.07962409f, 0.06097062f, 
    0.12452149f, 0.14949468f, -0.09646464f, 0.13230796f, 0.22252133f, -0.09457133f, -0.26602161f, -0.11073700f, 
    -0.09540499f, 0.12136929f, 0.00692381f, -0.08315866f, 0.07171027f, -0.00674062f, 0.03953283f, 0.11523701f, 
    0.20293319f, -0.10307861f, -0.37283087f, -0.26615047f, -0.13055634f, 0.07097254f, -0.01749673f, 0.09203553f, 
    -0.04734359f, -0.16726442f, 0.14706990f, 0.28154597f, 0.33375335f, -0.21939403f, -0.23557508f, 0.01717872f, 
    0.13564894f, -0.07259638f, -0.12244350f, -0.12950997f, -0.09147596f, -0.06393132f, -0.03282073f, -0.03336953f, 
    0.56778067f, 0.18758181f, -0.18153334f, 0.00614411f, 0.23737638f, 0.27329883f, -0.00392404f, -0.02879204f, 
    0.07474205f, 0.14755604f, 0.02342940f, -0.02247850f, -0.09064883f, -0.26196590f, -0.40686235f, 0.12037787f, 
    0.02448061f, -0.00809279f, -0.00885122f, 0.18379933f, 0.04946056f, 0.00525507f, -0.03464045f, -0.03701511f, 
    0.22174212f, -0.28781426f, -0.38159764f, 0.06952770f, 0.02004168f, -0.06026880f, 0.06682835f, -0.05276864f, 
    0.11369824f, 0.08636962f, 0.04200752f, 0.11510880f, 0.03903067f, 0.31876191f, 0.29880401f, -0.05666266f, 
    0.07484175f, 0.28999913f, 0.03765623f, -0.01579343f, 0.09402503f, 0.00176709f, 0.09790120f, 0.16265334f, 
    -0.02710670f, -0.28487709f, -0.17343867f, 0.28346974f, 0.11025237f, -0.01703928f, 0.11130638f, -0.02491336f, 
    0.03973118f, 0.07284950f, 0.00723273f, -0.06575371f, 0.23633920f, 0.29545996f, 0.24459104f, -0.12437010f, 
    0.09211721f, 0.12007628f, -0.00236698f, -0.01741175f, 0.10107137f, -0.06350940f, -0.05749866f, -0.15373908f, 
    0.04154160f, -0.29131207f, 0.20527886f, 0.30106598f, -0.02705943f, -0.06229761f, 0.00874338f, 0.12716134f, 
    0.09130669f, 0.02103895f, 0.03242990f, -0.09477127f, -0.09191421f, -0.47071850f, -0.40486458f, 0.03159258f, 
    0.10536497f, -0.11527976f, 0.05339048f, 0.06351119f, -0.03316263f, -0.05525876f, 0.06454704f, 0.03929278f, 
    0.03644604f, 0.00734527f, -0.02648470f, 0.02542909f, -0.00567215f, -0.01283731f, 0.01824954f, -0.06821784f, 
    0.04458255f, 0.03772152f, -0.04967227f, -0.02438761f, 0.01279102f, -0.01722184f, -0.02566457f, -0.00745347f, 
    -0.06039122f, -0.00618990f, 0.00899440f, 0.06165265f, 0.02811847f, -0.06615002f, -0.06806795f, 0.04676465f, 
    0.06089801f, -0.05344537f, 0.04676765f, 0.03694334f, 0.05941078f, 0.03182679f, 0.01457623f, 0.04640730f, 
    0.04109522f, -0.02920064f, 0.01483323f, -0.07707805f, 0.04740890f, -0.02923093f, 0.00084162f, 0.04650012f, 
    -0.06084843f, -0.02207192f, -0.02946944f, 0.05145140f, -0.04095489f, 0.05135781f, 0.03535683f, -0.06718808f, 
    -0.03104708f, -0.06556917f, -0.04439827f, -0.04268437f, -0.08192919f, 0.00374876f, -0.00455112f, -0.04565025f, 
    0.02242888f, -0.02903331f, -0.02717497f, 0.04368323f, 0.04996262f, -0.00821493f, 0.05955500f, -0.04066854f, 
    -0.03022007f, 0.02230274f, 0.03279082f, 0.02713957f, 0.00851728f, -0.08232333f, -0.02598571f, -0.03782383f, 
    0.05822378f, 0.04717153f, -0.04491669f, 0.05204462f, -0.03731876f, 0.05335592f, -0.08191773f, -0.06952722f, 
    0.00393326f, 0.00492519f, -0.07484921f, -0.02325106f, -0.02134759f, 0.00144923f, -0.07939451f, -0.07164509f, 
    -0.08221948f, -0.02322582f, -0.00325206f, -0.01225902f, -0.01629481f, 0.02736502f, 0.00225129f, 0.01009496f, 
    -0.03869902f, -0.00347491f, -0.04732040f, -0.02932429f, 0.05012231f, 0.01277611f, -0.05335120f, -0.04466049f, 
    0.04066956f, -0.04269392f, -0.01430241f, 0.02901839f, 0.04384773f, 0.03217863f, -0.08023198f, 0.03204110f, 
    -0.07544284f, -0.02402321f, 0.02819774f, -0.06420641f, 0.03351243f, 0.04078123f, -0.03806048f, 0.02352733f, 
    -0.07846025f, 0.04495302f, 0.04987792f, -0.00126962f, 0.01821281f, -0.05051086f, 0.04291755f, -0.05188506f, 
    -0.04359549f, 0.05181586f, -0.02200284f, -0.06247658f, -0.08109380f, -0.06848727f, 0.04170072f, -0.01058542f, 
    0.01826337f, -0.04034143f, -0.04828386f, 0.01301242f, -0.01052334f, -0.04540623f, -0.07416284f, -0.07525034f, 
    0.03190427f, -0.03947704f, -0.01705802f, 0.01333725f, 0.03453793f, -0.00305543f, 0.02066426f, -0.03676543f, 
    0.00463473f, 0.03711014f, -0.06756330f, 0.05814933f, -0.06308267f, 0.01141766f, 0.02047485f, 0.01633267f, 
    0.05917436f, -0.05825382f, -0.04120059f, -0.06949328f, -0.00816034f, 0.00617157f, -0.04885489f, -0.08118418f, 
    -0.00436372f, 0.01486896f, -0.02528795f, 0.03341503f, -0.03124239f, -0.02025369f, -0.00940235f, -0.00555019f, 
    -0.00855416f, 0.04072944f, 0.05625462f, 0.02540309f, 0.03203613f, 0.02351732f, -0.00771649f, -0.03390970f, 
    -0.07166617f, -0.04526715f, -0.03994076f, 0.04661114f, -0.04892587f, -0.06489959f, -0.01856171f, 0.01406171f, 
    -0.12606664f, -0.21799757f, 0.19252472f, 0.29914945f, -0.02158157f, -0.01078941f, 0.05889034f, 0.06959864f, 
    -0.06040377f, 0.02241320f, 0.00853700f, 0.02358549f, -0.45120573f, -0.51594019f, -0.12840003f, 0.16557722f, 
    -0.00764508f, 0.13206314f, -0.11519327f, 0.05239515f, -0.05732791f, -0.09065720f, -0.11638916f, -0.06515921f, 
    -0.08847389f, 0.24560715f, 0.07445982f, 0.09046997f, -0.00097415f, -0.09207873f, -0.01804802f, -0.05837788f, 
    0.02676239f, 0.25851935f, 0.36173302f, 0.03804540f, 0.31162921f, -0.20040882f, -0.25571668f, -0.12590362f, 
    0.07781336f, -0.06449126f, -0.00632560f, 0.00311268f, 0.10140740f, 0.31005058f, -0.25228187f, 0.29359534f, 
    0.11278877f, 0.41231057f, 0.49717554f, -0.49282891f, 0.12170642f, 0.05800071f, -0.00329661f, 0.20670544f, 
    -0.14787923f, 0.11647438f, 0.00965075f, 0.10731971f, -0.10646893f, 0.02243323f, -0.14240117f, -0.01823924f, 
    0.00322875f, -0.02290966f, -0.03572124f, -0.08489117f, 0.01138340f, 0.08369510f, 0.16976827f, 0.08698064f, 
    0.08725579f, 0.43531927f, 0.16173801f, -0.01337420f, 0.04779305f, 0.07011990f, -0.13429120f, 0.03690875f, 
    0.24341320f, 0.13516153f, 0.16553652f, -0.08300486f, -0.03600915f, 0.06035018f, 0.03354238f, 0.07628296f, 
    0.04460263f, -0.27772024f, -0.11162920f, -0.03031220f, -0.08523245f, -0.18640274f, 0.11523371f, 0.04982216f, 
    -0.04336283f, -0.24194795f, 0.07662702f, 0.05537215f, 0.14485092f, 0.08423012f, 0.04543925f, 0.02429200f, 
    0.15336692f, -0.19228540f, -0.02404880f, 0.06561875f, -0.22492634f, -0.36902994f, 0.25612801f, -0.45840842f, 
    0.16425139f, 0.21995051f, -0.18849078f, -0.15827535f, 0.02382560f, -0.09794821f, -0.00890846f, 0.00570992f, 
    -0.35289058f, -0.06879250f, 0.33618337f, -0.47605690f, -0.11997966f, -0.14944248f, -0.12934589f, -0.12982386f, 
    -0.03194872f, 0.10694737f, -0.18663779f, 0.18077470f, -0.33471730f, 0.13333459f, 0.35472661f, 0.45363966f, 
    -0.04486955f, 0.01603703f, 0.04278178f, -0.05047363f, 0.08592653f, -0.03421844f, 0.01790426f, -0.05524780f, 
    -0.12442294f, -0.09806737f, -0.19799383f, -0.04954296f, -0.06320930f, 0.03346939f, 0.02272087f, 0.09019388f, 
    0.05721153f, -0.03503649f, -0.04682290f, -0.03776669f, 0.04146534f, -0.14242926f, 0.34901920f, 0.34527549f, 
    0.23184714f, 0.05049256f, 0.13789633f, 0.25097936f, 0.06643188f, 0.17287382f, 0.02572412f, -0.04121047f, 
    -0.28610861f, 0.19422095f, -0.23724976f, -0.61654788f, -0.07150645f, 0.02173005f, 0.12974024f, 0.18478303f, 
    -0.10424430f, 0.18808009f, -0.09166364f, 0.23907326f, 0.03763825f, 0.14685805f, 0.51485193f, 0.39985928f, 
    -0.26071164f, -0.10375254f, -0.05193413f, -0.01233870f, 0.00686783f, 0.01626384f, -0.03669934f, 0.13389201f, 
    -0.05799305f, 0.01058907f, -0.02665629f, 0.07428395f, -0.10893538f, -0.06394625f, 0.14478482f, 0.02385132f, 
    -0.10102244f, 0.13403960f, 0.00330064f, 0.17296517f, -0.10410578f, 0.21570393f, -0.10302614f, -0.02386139f, 
    -0.12316809f, 0.00363850f, -0.01415106f, -0.05246366f, 0.09307656f, 0.25571740f, 0.20905146f, 0.10667435f, 
    -0.23191248f, 0.06468932f, 0.44249776f, -0.03184069f, -0.20387062f, 0.09067965f, 0.13567629f, 0.05564198f, 
    0.34255275f, -0.25467199f, -0.18768032f, 0.33459681f, -0.08085349f, 0.11363401f, 0.38303459f, 0.02682083f, 
    0.05516353f, 0.08284647f, 0.23911817f, 0.01081864f, 0.25594878f, -0.03500722f, 0.37341094f, -0.03579242f, 
    0.33635688f, -0.24135253f, 0.36531484f, 0.38352427f, -0.20861250f, -0.09078202f, -0.08575349f, -0.02319020f, 
    0.19696775f, 0.15904108f, 0.08466930f, 0.18067838f, -0.03036601f, -0.02710807f, -0.07733049f, -0.14204881f, 
    0.08065347f, -0.07705814f, 0.07403991f, -0.14091197f, 0.15168719f, -0.05525114f, -0.20934001f, -0.23572706f, 
    0.43457657f, 0.13104942f, 0.03158969f, -0.12499066f, -0.05859712f, -0.09227031f, 0.00779371f, 0.09971723f, 
    -0.04358014f, 0.02810186f, -0.15362772f, 0.07744029f, 0.11714261f, -0.29966760f, -0.01318598f, -0.25356534f, 
    -0.22719587f, -0.15652296f, -0.05580015f, -0.22370633f, 0.09594412f, -0.08715072f, 0.07135052f, 0.04142829f, 
    -0.19738141f, 0.09357210f, -0.30810410f, -0.18423583f, 0.06368730f, 0.06571024f, 0.16651335f, -0.04423510f, 
    -0.27694899f, 0.07871395f, -0.16746484f, 0.11798213f, 0.09200756f, -0.25175452f, -0.21528195f, 0.01719366f, 
    -0.01346155f, -0.24195889f, 0.32610884f, 0.06034662f, 0.00530308f, 0.10726012f, 0.06368173f, -0.00820305f, 
    0.07292689f, 0.18412401f, -0.28114602f, 0.16100354f, 0.15856645f, 0.17362615f, -0.04543607f, -0.06963650f, 
    -0.14508958f, -0.12559737f, 0.08819138f, -0.15530944f, -0.00778522f, 0.37727088f, 0.09807990f, -0.09559838f, 
    -0.10002047f, -0.05443320f, 0.04039550f, 0.03347092f, 0.05519826f, -0.12308985f, -0.22496966f, -0.21777278f, 
    0.11696585f, -0.16364259f, 0.26912114f, 0.00598808f, -0.03934348f, 0.06846265f, -0.00682208f, -0.03046485f, 
    0.20405047f, 0.03996389f, 0.23695523f, 0.15593776f, -0.06782363f, 0.17443618f, 0.21455581f, -0.14241967f, 
    0.07088446f, -0.10010050f, 0.12370446f, 0.10223170f, 0.03398944f, -0.03402294f, 0.12456720f, -0.02305472f, 
    0.09550774f, -0.17134991f, 0.15151711f, 0.60322231f, -0.31153461f, 0.02020968f, -0.16974199f, -0.01787202f, 
    0.19139554f, -0.18659969f, 0.03314155f, 0.15169568f, 0.22173660f, -0.31860924f, -0.20974168f, -0.19058694f, 
    0.10366920f, 0.14598632f, 0.28220850f, 0.05749709f, -0.11404705f, 0.12480415f, 0.02040206f, -0.08928601f, 
    -0.02821595f, 0.02485418f, -0.06367602f, 0.05486687f, -0.05980096f, 0.04424715f, -0.04465133f, 0.00175727f, 
    -0.05279599f, -0.05992751f, 0.00143293f, 0.04606069f, -0.04035310f, -0.06139350f, 0.01055331f, -0.06980792f, 
    0.00712911f, 0.00474206f, 0.02787435f, 0.04312882f, -0.01998245f, -0.06626829f, -0.02836775f, -0.06031895f, 
    0.04746382f, 0.03431274f, -0.03017108f, -0.03198644f, -0.01355189f, -0.07056634f, 0.01809319f, 0.04106139f, 
    0.01175896f, 0.00084385f, -0.06161572f, -0.04247177f, 0.05468665f, -0.05372967f, 0.05093331f, -0.04837586f, 
    0.00187502f, 0.02616021f, -0.00798797f, 0.01035131f, -0.00426490f, 0.02500563f, 0.06196485f, -0.05860092f, 
    -0.03670754f, -0.05083521f, 0.00613537f, -0.02683018f, 0.06844394f, -0.05755387f, -0.02519200f, 0.00611531f, 
    0.03537076f, -0.00592084f, -0.01524302f, -0.01838610f, -0.02351414f, -0.05762822f, -0.00955071f, -0.06556297f, 
    -0.04856098f, -0.00236288f, 0.04117967f, 0.06413775f, -0.00921058f, -0.00761517f, 0.00819197f, -0.03054534f, 
    0.00699195f, -0.06177679f, -0.01893691f, -0.06304097f, 0.00851434f, -0.00923039f, -0.03548189f, -0.04313205f, 
    -0.05999326f, -0.06880993f, 0.04560264f, 0.02000154f, -0.03185416f, 0.02238682f, -0.03494497f, -0.04132628f, 
    0.00852468f, -0.03717198f, -0.06153493f, -0.01178222f, -0.00932581f, 0.05647101f, -0.05868870f, -0.01490452f, 
    -0.04360352f, -0.00577718f, -0.03552561f, 0.03667009f, 0.00273211f, -0.03873813f, -0.03258444f, 0.04649440f, 
    -0.04391601f, -0.00805943f, -0.06953479f, 0.03396956f, -0.07170287f, -0.01515060f, -0.06544382f, 0.05625240f, 
    0.06769074f, 0.06565979f, 0.02224762f, 0.01893280f, 0.00583922f, 0.00280017f, -0.02703207f, 0.05273259f, 
    0.02907860f, -0.02148377f, 0.00734525f, 0.01526032f, 0.04056936f, 0.06192593f, -0.03883745f, -0.05971872f, 
    -0.03451351f, 0.02297958f, 0.01903745f, 0.02347445f, 0.04867092f, -0.05346256f, -0.02746523f, -0.06724682f, 
    -0.01034272f, -0.07003178f, 0.01358960f, -0.03960882f, -0.00601482f, -0.04973869f, -0.05122574f, 0.02711862f, 
    -0.06450889f, -0.05831179f, -0.02339057f, 0.02192634f, -0.03777802f, 0.01764603f, 0.05289093f, -0.04457174f, 
    0.05475286f, 0.06780638f, 0.00183773f, 0.00424130f, -0.02269058f, 0.02032796f, -0.00234920f, -0.06414655f, 
    -0.05300467f, 0.01748616f, -0.00548572f, 0.02240197f, 0.07071284f, 0.06926630f, -0.01923228f, -0.04427752f, 
    0.03810519f, -0.00223982f, -0.02860358f, 0.02128686f, -0.05323464f, -0.05227552f, -0.07184763f, -0.00369602f, 
    0.02429185f, 0.07026960f, -0.06673164f, -0.03148581f, 0.00543622f, 0.06012053f, -0.01770513f, -0.03397599f, 
    -0.00629812f, -0.02706669f, 0.03534973f, 0.00371543f, -0.04029967f, -0.01815706f, 0.03045939f, -0.04021605f, 
    0.09651915f, 0.14415340f, 0.21996780f, -0.00369665f, 0.20698838f, 0.23494369f, 0.28829944f, 0.01506914f, 
    -0.06006357f, -0.20370977f, -0.09738513f, 0.00283948f, 0.04998258f, 0.06799731f, 0.26622629f, 0.18102011f, 
    0.18209311f, 0.31375620f, 0.09773322f, 0.34859908f, 0.16656414f, 0.11487737f, 0.12765929f, 0.01948118f, 
    -0.34615785f, 0.43877032f, 0.03559020f, -0.29280239f, 0.04321642f, -0.10047347f, -0.07564948f, -0.16486402f, 
    0.10160805f, -0.11765418f, -0.14003704f, -0.18965682f, 0.14797641f, -0.08467323f, -0.08839161f, 0.07045539f, 
    0.01224740f, -0.24154665f, 0.18307474f, -0.13009340f, 0.02910473f, 0.17974003f, 0.03218402f, 0.32679453f, 
    0.58726233f, 0.51185924f, 0.20851947f, 0.09778252f, -0.23451081f, -0.24955218f, -0.25602371f, 0.02121758f, 
    0.20237774f, -0.02530575f, -0.07401439f, 0.02421976f, -0.05244423f, 0.08068214f, -0.04506918f, 0.09372109f, 
    -0.10111621f, -0.07581591f, 0.24993679f, -0.30629292f, 0.37540302f, -0.05681572f, 0.10057571f, 0.29783288f, 
    0.10283248f, -0.14948004f, -0.16698378f, 0.06061396f, -0.07707237f, -0.20146382f, 0.09113135f, -0.02614737f, 
    0.20067555f, -0.05785329f, 0.02106216f, 0.20151804f, 0.26513416f, -0.00079975f, -0.46312386f, 0.25486794f, 
    -0.13577567f, -0.15799691f, -0.04998669f, -0.13464709f, 0.09515417f, -0.11702076f, -0.09827317f, -0.21087976f, 
    -0.25948510f, 0.43301246f, -0.32776591f, 0.29741275f, 0.08910640f, 0.05017399f, 0.01018975f, 0.03196775f, 
    0.18870176f, -0.02065065f, -0.09429760f, -0.14757524f, -0.85840505f, -0.02773670f, -0.20190252f, -0.09484245f, 
    -0.01407867f, -0.16108219f, 0.00027484f, -0.08067408f, 0.05104323f, -0.01621645f, -0.12195386f, -0.14872397f, 
    -0.42767280f, -0.08676558f, -0.09072323f, -0.06755063f, 0.02195091f, 0.13871141f, -0.23270246f, 0.21279837f, 
    0.07031415f, -0.16200447f, 0.08546388f, 0.08695757f, -0.06051347f, 0.11075509f, 0.30142096f, 0.08494135f, 
    -0.10365323f, -0.14245324f, -0.10414895f, 0.12778327f, 0.21265890f, -0.01601502f, 0.06486155f, 0.27035680f, 
    -0.08850574f, 0.08436729f, 0.10136469f, -0.35377389f, 0.07107316f, -0.19084850f, 0.16119806f, 0.06733385f, 
    0.03812565f, -0.04445296f, -0.17607142f, 0.04786305f, 0.61683989f, 0.33364812f, -0.08337352f, 0.10771403f, 
    -0.25006673f, 0.07814445f, -0.09502941f, 0.21691446f, 0.15641907f, -0.04177529f, -0.08279705f, 0.18029617f, 
    0.02572557f, -0.13968235f, 0.52168012f, 0.20622891f, -0.00648133f, 0.21389265f, -0.15831035f, 0.01543873f, 
    -0.05478211f, -0.04130768f, 0.11180412f, -0.21639688f, -0.48760626f, 0.01920433f, 0.32721967f, -0.21111540f, 
    0.41103601f, -0.13727170f, 0.24221464f, 0.31995946f, 0.10818527f, -0.11843505f, -0.00645937f, -0.04479476f, 
    0.28837544f, 0.03107134f, 0.28304854f, 0.64097279f, -0.00570734f, 0.18965539f, -0.21483727f, 0.30050462f, 
    0.05647139f, 0.08502650f, 0.02921965f, 0.02058593f, 0.08594333f, -0.18820649f, 0.14085679f, 0.27282768f, 
    -0.05903376f, -0.27179608f, 0.01358294f, -0.04914688f, -0.03771075f, 0.13283949f, 0.02423530f, 0.09246631f, 
    0.42814508f, -0.05645962f, 0.11523400f, 0.52417701f, -0.10123803f, 0.14815049f, -0.02570783f, 0.10294019f, 
    -0.10931428f, 0.23420984f, 0.21793264f, -0.06102764f, 0.07398292f, 0.22241956f, 0.26284137f, -0.20299487f, 
    -0.07782965f, 0.00293328f, -0.03699281f, 0.05630301f, -0.09453729f, 0.30951867f, 0.01557769f, 0.21534720f, 
    0.11207590f, -0.13990720f, -0.26415983f, -0.30289865f, 0.09441602f, -0.04013634f, 0.20154177f, -0.05626093f, 
    -0.05995736f, 0.11728796f, 0.24648637f, 0.03100170f, -0.21983281f, -0.16826794f, -0.20344517f, 0.09628715f, 
    -0.05696393f, 0.13801731f, -0.15158829f, 0.08485129f, -0.17947114f, -0.14744669f, -0.17934510f, 0.01754114f, 
    -0.13425238f, 0.06182663f, -0.03023907f, 0.20798376f, -0.04327976f, -0.10931733f, 0.01020287f, 0.10347560f, 
    0.00247127f, -0.00680892f, -0.16755214f, -0.15500894f, 0.03209788f, -0.06764912f, 0.02053616f, 0.02509417f, 
    0.07347435f, 0.13476972f, 0.05030142f, 0.08186813f, -0.05895436f, -0.04584846f, 0.21014601f, 0.20814754f, 
    -0.05456904f, -0.49985880f, 0.53603595f, 0.13910261f, 0.18524037f, 0.18587033f, -0.10871753f, 0.12444883f, 
    0.01731537f, 0.16290098f, -0.11964086f, 0.04627991f, 0.16208014f, 0.17255607f, 0.17466500f, 0.00153082f, 
    0.05890587f, 0.16627820f, -0.19918565f, -0.15908277f, -0.13898776f, 0.01894812f, 0.01245202f, 0.05187697f, 
    0.22854666f, 0.32647234f, 0.38932911f, 0.11673061f, -0.12759203f, -0.20440574f, -0.08053182f, 0.02477452f, 
    -0.08675309f, -0.05089504f, -0.07861212f, -0.03723203f, -0.16853192f, -0.08737103f, -0.43247476f, 0.18702292f, 
    0.14940590f, 0.01917714f, -0.06064659f, 0.07467683f, 0.01777886f, 0.00363298f, -0.04601058f, -0.16407581f, 
    -0.00672034f, 0.07928986f, 0.02591663f, 0.00204356f, -0.00002678f, 0.19909470f, -0.07928463f, -0.06259126f, 
    -0.13215879f, 0.06543220f, -0.00149079f, -0.05890587f, -0.07798233f, -0.03575700f, 0.06220949f, 0.26771140f, 
    0.33967811f, 0.08828312f, 0.22609735f, 0.14675879f, 0.21528660f, 0.05194331f, -0.10276289f, -0.01492354f, 
    -0.38120690f, 0.25312325f, -0.16523096f, -0.32208985f, -0.07164425f, 0.04859019f, 0.02826542f, -0.12505548f, 
    -0.07492410f, 0.14124393f, 0.01443039f, 0.30734250f, 0.37856901f, 0.54402685f, 0.27507246f, 0.39904106f, 
    -0.35116643f, 0.00525533f, -0.15851608f, -0.07236581f, -0.11816473f, 0.07130282f, -0.01991940f, -0.03353567f, 
    -0.73185748f, -0.48273906f, -0.48139688f, -0.00546483f, -0.19144867f, -0.25142968f, -0.00583475f, -0.00266590f, 
    -0.10888675f, -0.02726964f, 0.10785338f, 0.04854175f, -0.38319829f, -0.46774539f, -0.39690194f, 0.14813124f, 
    0.08732271f, 0.13085333f, 0.07375889f, 0.24368097f, 0.05855300f, -0.11594429f, -0.05205224f, -0.04916590f, 
    -0.33992386f, -0.09920906f, 0.41089305f, -0.10544872f, 0.16921134f, -0.10143007f, 0.44705448f, -0.23862781f, 
    -0.04313178f, 0.39357421f, -0.19693024f, 0.27727494f, 0.18235566f, 0.11970565f, 0.14957999f, 0.03435827f, 
    0.02838143f, -0.11004666f, 0.02872202f, -0.05081947f, -0.07306550f, 0.01098385f, 0.16818938f, -0.23772185f, 
    0.52519768f, 0.31152159f, 0.29371756f, -0.10884576f, -0.11570974f, -0.13867533f, -0.16747482f, -0.04081218f, 
    0.07782586f, 0.10059471f, 0.06901518f, 0.11034942f, 0.06639323f, 0.02933419f, 0.01524629f, -0.07274565f, 
    0.04337997f, -0.01836329f, 0.04747745f, 0.19280995f, 0.00153602f, -0.00206474f, 0.15313815f, -0.00117206f, 
    0.21125947f, -0.08908984f, 0.12936048f, 0.01325741f, -0.01823287f, 0.01171126f, -0.03195019f, 0.13026260f, 
    -0.09302548f, 0.03360556f, 0.13589926f, -0.05388593f, 0.25652570f, 0.28044716f, 0.07833552f, 0.15585996f, 
    -0.00680553f, -0.03509640f, 0.09886637f, -0.03572948f, 0.07501242f, 0.00577109f, -0.05582938f, -0.10010469f, 
    -0.00526268f, 0.20009512f, -0.32874009f, -0.15225303f, 0.21731719f, 0.19713670f, 0.47148883f, 0.57104301f, 
    -0.03385781f, 0.11041340f, 0.07646214f, 0.12257270f, -0.03496367f, -0.02351275f, -0.10390355f, -0.02065546f, 
    0.06096976f, -0.06718428f, 0.10939676f, 0.32923654f, -0.06810176f, -0.06422737f, -0.01801017f, -0.12345961f, 
    0.46254754f, 0.06974008f, 0.11092955f, -0.11859000f, 0.06196984f, -0.02046567f, 0.06217195f, -0.14777684f, 
    0.02535101f, 0.08081167f, -0.01568708f, -0.08425969f, -0.35511717f, -0.36709994f, 0.00902482f, -0.22364263f, 
    -0.06545795f, -0.05479918f, -0.10560081f, -0.13080674f, 0.01919966f, 0.02420306f, -0.04259037f, 0.03544643f, 
    -0.04202525f, -0.00401839f, 0.00300209f, -0.01409165f, -0.03591125f, 0.05448845f, 0.09073359f, -0.07771416f, 
    -0.02349930f, -0.03461364f, 0.04630793f, -0.02205936f, -0.59144324f, -0.37680182f, -0.73117268f, -0.62921715f, 
    0.19091377f, 0.01868487f, -0.19517444f, 0.09428154f, 0.00635244f, 0.10292924f, 0.13124663f, -0.07299495f, 
    0.45530415f, 0.25902537f, 0.49747905f, 0.14145499f, -0.02729313f, 0.11020441f, -0.08122005f, -0.01101382f, 
    -0.11247059f, 0.03495213f, -0.19026086f, 0.16152385f, -0.03374619f, 0.04572759f, 0.07175315f, 0.25160000f, 
    0.14535446f, -0.05901380f, 0.13453837f, -0.12053745f, -0.01401968f, 0.00286740f, -0.02094169f, 0.05198761f, 
    0.02512330f, 0.03640684f, 0.03546816f, 0.02346886f, 0.02477242f, 0.05259312f, 0.01878361f, -0.00366484f, 
    -0.07160330f, 0.05125054f, -0.07869674f, -0.02705891f, -0.03805206f, -0.00314126f, -0.06995133f, 0.02011094f, 
    -0.04542383f, -0.03062998f, -0.07015763f, 0.01144333f, 0.03116512f, -0.01662087f, 0.06396072f, -0.01540116f, 
    -0.06360840f, 0.05688120f, 0.00669878f, -0.06259804f, -0.07383128f, 0.05008293f, 0.03356161f, -0.04046792f, 
    -0.07314943f, -0.07847916f, 0.03197248f, -0.04591587f, 0.01300767f, 0.02155236f, 0.03051589f, 0.00540265f, 
    -0.05806540f, 0.00592374f, 0.00208424f, 0.04621213f, -0.03614232f, 0.00288393f, 0.01063441f, 0.02487100f, 
    -0.05444343f, -0.02428825f, 0.01013668f, -0.05426528f, 0.03057233f, 0.01872840f, 0.05958942f, -0.06385958f, 
    -0.05909145f, 0.03386241f, -0.07092275f, 0.03457824f, -0.04933204f, -0.05987433f, -0.02225742f, -0.03038949f, 
    0.00592929f, -0.05584159f, 0.05041916f, 0.00739288f, -0.06624735f, -0.05491895f, 0.00932173f, 0.04996360f, 
    -0.02886861f, -0.05061469f, 0.00681836f, 0.03363191f, -0.02404067f, -0.03005530f, -0.07267827f, -0.04975524f, 
    -0.05003134f, -0.04340935f, 0.06349552f, -0.01249213f, -0.01344178f, -0.02039474f, -0.03644944f, 0.04643835f, 
    -0.01290399f, 0.01814087f, 0.04023366f, -0.04320573f, -0.02692678f, 0.05778036f, -0.03561022f, -0.05730943f, 
    -0.06990734f, 0.00419953f, 0.02136272f, 0.01981615f, -0.06191305f, -0.06212205f, -0.00803085f, -0.06198459f, 
    0.03531947f, 0.04810930f, 0.05351379f, 0.01170494f, 0.04834855f, 0.04694010f, -0.00537934f, 0.04615889f, 
    -0.02621218f, -0.03569592f, -0.07237162f, 0.06055798f, 0.03974488f, -0.00537136f, -0.03635090f, -0.00860784f, 
    -0.00828403f, -0.02359746f, 0.03112422f, 0.02136379f, 0.02957473f, 0.03526520f, -0.06244719f, -0.06996090f, 
    0.05007419f, -0.01331273f, 0.00292716f, -0.01737994f, -0.07175305f, 0.00551058f, -0.00204534f, -0.02401706f, 
    -0.01505264f, 0.04727617f, -0.07173873f, 0.05559832f, -0.06038059f, -0.01044885f, -0.06930827f, -0.05939250f, 
    0.05685604f, -0.01899572f, -0.05482168f, -0.02305497f, -0.03889094f, -0.05771485f, -0.04813577f, 0.01647921f, 
    -0.06885076f, 0.04908200f, 0.04083541f, 0.03019977f, -0.04513220f, 0.01863171f, -0.00378704f, -0.01933576f, 
    0.05678955f, -0.06933066f, 0.01822746f, -0.07173111f, 0.02100183f, 0.04302529f, -0.04873238f, 0.01016805f, 
    0.01410158f, 0.01934260f, 0.06211648f, -0.05094900f, -0.07707660f, 0.01014038f, 0.01765633f, -0.00058752f, 
    0.04702344f, -0.05390857f, 0.00215131f, -0.04100094f, 0.06482979f, 0.04307540f, 0.04005674f, -0.03187527f, 
    -0.00195429f, 0.03852235f, -0.06753300f, -0.07616781f, -0.05878074f, -0.05346543f, 0.01450602f, 0.00810228f, 
    0.09216557f, -0.00375841f, 0.24325733f, 0.42596561f, 0.02107868f, -0.13294044f, 0.03635953f, 0.31993946f, 
    -0.04700447f, 0.14245361f, 0.11468937f, 0.02429558f, -0.12819439f, -0.18619323f, 0.03800046f, 0.20436077f, 
    0.10925099f, -0.17433111f, 0.00709020f, 0.10663077f, -0.04632674f, 0.20965652f, 0.03531580f, -0.02418625f, 
    0.37174964f, 0.01071318f, 0.21788967f, -0.20805052f, 0.04041111f, -0.12142162f, 0.07447072f, 0.02206808f, 
    0.03410796f, -0.02266720f, 0.22849353f, 0.18381323f, -0.22585696f, 0.23144615f, 0.32095909f, -0.07229606f, 
    0.03926085f, 0.13791773f, -0.10953718f, -0.19743758f, -0.15078391f, 0.10563278f, -0.12497167f, -0.03444712f, 
    0.10685202f, 0.45569506f, -0.14697374f, 0.43947676f, 0.07510830f, -0.08013443f, -0.07967714f, -0.03873239f, 
    -0.11826625f, 0.01131721f, 0.03907233f, 0.10398772f, -0.17168139f, 0.22189835f, 0.38574955f, -0.24583763f, 
    0.00786233f, -0.07972644f, -0.11280573f, 0.02447946f, 0.07637179f, -0.03065840f, -0.15541087f, -0.09791522f, 
    0.19097558f, 0.04094410f, 0.17917855f, 0.00396055f, -0.18961041f, -0.13839923f, 0.03132266f, -0.03539765f, 
    0.01215222f, -0.01200781f, -0.15272468f, 0.02504228f, 0.12624389f, -0.01442060f, 0.18571062f, -0.00021602f, 
    -0.14134918f, -0.22066766f, -0.07552680f, -0.13000967f, 0.06593804f, -0.06351536f, 0.13598740f, 0.13643932f, 
    -0.43787116f, 0.08297679f, 0.14273734f, -0.04557310f, 0.16009751f, -0.02831304f, 0.07856108f, 0.08859023f, 
    -0.15476012f, -0.02869987f, -0.00238290f, 0.01865689f, 0.32786977f, -0.06592180f, 0.24662563f, -0.28153524f, 
    0.24224471f, -0.03203572f, -0.04300927f, -0.20805082f, 0.01296622f, 0.03493430f, -0.08782912f, -0.14662932f, 
    -0.21555783f, 0.12227703f, -0.20000395f, 0.29559863f, -0.05034582f, 0.05876184f, -0.10912136f, 0.00851415f, 
    -0.13010347f, -0.08596394f, -0.09222715f, 0.02084706f, 0.01470465f, -0.13427675f, -0.22022182f, -0.00114772f, 
    0.05390294f, -0.22683980f, -0.14371464f, -0.11634406f, 0.05673667f, -0.05927591f, -0.01552788f, -0.11277995f, 
    0.13985747f, 0.13993858f, -0.11101986f, -0.20970149f, 0.07238745f, -0.07506918f, -0.10585912f, 0.00238823f, 
    0.06024709f, 0.00369489f, 0.07639190f, -0.12915409f, -0.09426490f, 0.31637329f, 0.08988393f, 0.24755019f, 
    0.19107659f, -0.08953270f, 0.16118683f, 0.18112013f, 0.01673522f, 0.12896468f, 0.06353793f, -0.15740560f, 
    -0.49882087f, 0.08375575f, -0.06319705f, 0.08623909f, -0.11903448f, 0.13780491f, 0.02329708f, 0.17125461f, 
    0.09318145f, -0.07514766f, -0.25355199f, 0.00345800f, 0.72946978f, 0.32568070f, 0.19226921f, -0.31968695f, 
    -0.13164043f, -0.01199243f, -0.01431460f, 0.06866940f, -0.05335230f, -0.04491326f, -0.04039667f, 0.00102580f, 
    -0.03921863f, 0.03920203f, 0.04818792f, -0.06897347f, -0.04912978f, -0.00754592f, 0.05274638f, -0.01687953f, 
    -0.01625278f, 0.05147128f, -0.06581154f, 0.06256338f, -0.07988963f, 0.02956221f, 0.01071463f, 0.02394726f, 
    -0.00686409f, -0.07436721f, -0.02837867f, -0.06163372f, 0.01151336f, 0.01193481f, -0.01522062f, -0.01186105f, 
    -0.07257618f, 0.00917786f, 0.05963151f, 0.03822149f, 0.05948738f, -0.00931557f, -0.06195710f, -0.02565075f, 
    -0.01319729f, -0.05431752f, -0.05076453f, -0.00846237f, -0.07226758f, -0.02439741f, 0.00375157f, -0.00762728f, 
    -0.06187072f, 0.02323125f, -0.02852724f, -0.05939963f, 0.03723125f, -0.01051677f, -0.04876105f, -0.04686612f, 
    0.01432758f, -0.04165346f, -0.00736650f, -0.05110044f, -0.05236802f, -0.03812044f, -0.03647958f, -0.05788106f, 
    0.06043351f, 0.02774695f, 0.04689809f, 0.03707294f, -0.07388210f, 0.04540408f, 0.00980219f, 0.03905201f, 
    -0.07846971f, -0.01551619f, -0.03606591f, 0.01297319f, 0.01264920f, -0.00688492f, -0.02735858f, -0.04602614f, 
    -0.05076182f, -0.07367751f, 0.04858832f, -0.05333550f, -0.05157202f, 0.04003850f, 0.02068648f, -0.02348701f, 
    -0.03419131f, 0.03635132f, -0.02517662f, -0.07160293f, 0.04365796f, -0.00748429f, 0.02657077f, 0.05663037f, 
    0.02652597f, -0.03132943f, -0.00645044f, -0.02730021f, -0.07170167f, 0.06283684f, -0.03640148f, -0.04823435f, 
    0.05769906f, -0.05094570f, 0.01308908f, 0.04510063f, -0.04842508f, -0.06611364f, -0.07501408f, 0.05239784f, 
    -0.03764590f, -0.07926995f, 0.01676196f, 0.01988124f, 0.04536305f, -0.03647732f, 0.04943717f, -0.06605008f, 
    0.01121174f, 0.06395271f, 0.01472642f, 0.00291634f, -0.02170753f, -0.06958949f, 0.03449045f, -0.03792565f, 
    0.02555489f, 0.01827961f, -0.04438765f, 0.00654526f, -0.03100469f, 0.06190087f, 0.04897217f, 0.06268840f, 
    0.04655252f, -0.02871471f, 0.02217926f, -0.02550143f, 0.01897429f, -0.05056608f, 0.03366881f, -0.01399153f, 
    -0.03983348f, 0.00034470f, 0.02490427f, -0.04421834f, 0.01109281f, 0.05626427f, -0.06114877f, 0.06203105f, 
    0.01757642f, 0.01462111f, -0.02790072f, -0.05922037f, -0.06192141f, -0.01995665f, 0.01650592f, 0.04699269f, 
    -0.02965170f, -0.03465969f, 0.03555393f, -0.00856241f, -0.05852148f, -0.02274002f, 0.04984509f, 0.02331658f, 
    -0.03319462f, -0.07427251f, -0.07400531f, -0.06681956f, -0.00497323f, -0.02783189f, 0.04300406f, -0.04198825f, 
    -0.07234234f, -0.04781719f, -0.01879598f, 0.00865303f, -0.05106286f, -0.01920438f, -0.05913470f, 0.02372384f, 
    0.00450419f, 0.03450882f, 0.05589915f, 0.00723105f, 0.04564017f, 0.05740128f, -0.06577299f, -0.03606620f, 
    -0.04280517f, -0.03723878f, -0.02804738f, 0.00691667f, 0.01721733f, 0.02533339f, 0.03739091f, -0.02279022f, 
    -0.11604643f, 0.00486202f, 0.34075189f, 0.00591355f, 0.15666914f, 0.03216485f, 0.12565868f, -0.05549712f, 
    0.16104208f, -0.03990490f, -0.08265704f, 0.10426750f, 0.01470164f, 0.14696556f, 0.44163990f, 0.12816499f, 
    -0.03180954f, -0.15233536f, 0.33151713f, -0.03400053f, 0.13235234f, -0.01655801f, 0.18417300f, 0.00439080f, 
    -0.03022365f, -0.14324777f, 0.04500760f, 0.16935180f, 0.08899162f, 0.30599740f, 0.02220996f, -0.01274943f, 
    -0.01255761f, -0.00499891f, 0.11521396f, 0.08466134f, -0.10277403f, 0.02241773f, -0.27946371f, 0.14897528f, 
    0.05536877f, -0.07996330f, -0.00150237f, 0.13659731f, -0.04850637f, -0.18803960f, 0.27178654f, -0.00879968f, 
    -0.36094370f, 0.11267909f, -0.21678610f, 0.20087950f, 0.06595640f, 0.00384475f, -0.13937911f, -0.10466295f, 
    0.05316728f, -0.00317699f, -0.00291712f, -0.01398738f, 0.29755160f, -0.09649736f, -0.07598164f, -0.49673364f, 
    -0.07532483f, 0.09988811f, 0.05249185f, -0.18571438f, 0.07747725f, 0.12211664f, 0.13685879f, -0.05273220f, 
    0.17698278f, 0.10336835f, -0.31180969f, 0.04140737f, -0.00712874f, 0.11988292f, 0.23228116f, -0.21853587f, 
    0.08946246f, -0.01394347f, 0.22020911f, 0.02335895f, -0.23747782f, 0.09958906f, -0.39231890f, -0.28055349f, 
    0.08707489f, 0.15672486f, -0.21384910f, 0.01284380f, -0.02357514f, 0.17378815f, 0.11621045f, 0.02039921f, 
    -0.07796109f, 0.45165116f, -0.22695969f, 0.10148134f, 0.15607294f, 0.30674499f, -0.00203823f, -0.01750598f, 
    -0.26184535f, -0.07425879f, -0.00147457f, -0.29519463f, -0.32212570f, 0.23142919f, -0.30504879f, 0.38599259f, 
    0.11145334f, 0.22013395f, 0.16359685f, 0.07808486f, 0.04694837f, 0.02304405f, -0.03854378f, 0.26717421f, 
    0.53994447f, -0.06960825f, -0.48696324f, 0.12274694f, 0.16391046f, 0.07673216f, -0.04633492f, 0.28789452f, 
    -0.03770996f, -0.00702114f, 0.01053750f, -0.18828675f, -0.25967723f, -0.27418372f, 0.14223310f, -0.21303773f, 
    -0.23168720f, -0.20220855f, 0.07315361f, 0.20669958f, -0.05648215f, -0.16325268f, 0.04615533f, 0.21987425f, 
    -0.09475315f, 0.06206872f, -0.09558297f, -0.17091051f, 0.24334158f, 0.10716067f, -0.09079707f, 0.11040310f, 
    0.07813842f, 0.01109558f, -0.06900681f, 0.01766892f, -0.10816961f, 0.12163347f, -0.21587187f, 0.00879249f, 
    -0.26447070f, -0.01341754f, 0.03643311f, -0.00164704f, 0.10466678f, -0.02230039f, -0.11161888f, 0.03095689f, 
    -0.32228872f, -0.68394583f, 0.32714266f, 0.23447204f, 0.03966002f, -0.28151235f, -0.21429861f, -0.09179209f, 
    -0.19605984f, -0.12050354f, 0.21427065f, -0.14626928f, 0.14501666f, 0.20274399f, -0.11713844f, -0.37483656f, 
    0.50959390f, 0.26928511f, 0.16552712f, 0.19895399f, 0.08268040f, -0.11319955f, -0.02107268f, 0.10295056f, 
    0.28708217f, 0.19977319f, -0.09108058f, -0.17396952f, 0.26300174f, 0.31698963f, 0.20129776f, -0.05543026f, 
    0.10245073f, 0.10532346f, 0.04703030f, 0.10867162f, 0.50896835f, 0.53163934f, 0.36331293f, -0.12451082f, 
    0.22175542f, 0.06254715f, 0.00862304f, 0.06791410f, 0.05239911f, -0.06390376f, 0.10940325f, 0.05025855f, 
    0.37324858f, -0.16648260f, -0.37613520f, 0.11931100f, 0.11564562f, 0.10490683f, -0.09525558f, 0.08421820f, 
    0.16547501f, 0.09473101f, -0.02669542f, 0.13726205f, -0.16951752f, -0.38958043f, -0.19815843f, 0.34314379f, 
    0.09554184f, -0.06162020f, -0.07075790f, 0.08321764f, -0.05559669f, -0.13920896f, 0.04356087f, -0.00708572f, 
    -0.64332300f, -0.29718530f, -0.48221117f, -0.25386366f, 0.02829160f, 0.02186535f, 0.04656969f, -0.05771093f, 
    0.34260893f, 0.17277680f, 0.06344263f, 0.11555900f, -0.08937272f, -0.22577418f, 0.00810990f, -0.02633296f, 
    0.05170343f, 0.07664183f, 0.08195995f, -0.04786266f, -0.02665754f, -0.13144159f, -0.09809983f, -0.19306661f, 
    -0.18965553f, -0.16502342f, -0.30265310f, -0.05268066f, 0.03617954f, 0.16626179f, -0.02431395f, 0.02984348f, 
    0.01727667f, -0.12273771f, 0.01556084f, -0.15102138f, -0.30469766f, 0.02248273f, -0.02294191f, 0.21538728f, 
    0.02436983f, 0.06761261f, -0.23776484f, -0.04533136f, -0.04958194f, 0.10144945f, 0.19357878f, 0.22109428f, 
    0.19300669f, -0.05595407f, -0.13616496f, 0.10146292f, 0.01948742f, 0.25118425f, -0.16356468f, 0.03984145f, 
    -0.22213277f, -0.05315013f, 0.03329439f, -0.02440256f, -0.14859040f, 0.14661515f, 0.16910602f, 0.00997599f, 
    -0.03650187f, -0.09982837f, -0.34786093f, 0.17457601f, 0.00939630f, -0.05911386f, -0.07289303f, 0.11300001f, 
    0.07696921f, -0.10266892f, 0.10630772f, 0.20324752f, 0.05030471f, -0.06704243f, 0.00101934f, -0.14815755f, 
    -0.02275750f, 0.03450031f, 0.09020639f, 0.00376644f, 0.20667131f, -0.26335034f, -0.29018357f, -0.16658059f, 
    0.21893016f, 0.42728448f, -0.00091459f, -0.15566809f, -0.05032627f, -0.20923240f, 0.10407738f, -0.01180094f, 
    -0.07227786f, -0.06509598f, -0.13465081f, -0.01183827f, 0.05551986f, -0.08862417f, -0.11017608f, -0.06108705f, 
    0.07482032f, 0.04940665f, -0.04666672f, 0.09474967f, -0.02270775f, -0.00858215f, -0.18469273f, -0.06220583f, 
    0.03764453f, 0.27607131f, -0.04441099f, 0.13907714f, 0.23694603f, -0.10302191f, -0.04622072f, -0.03777212f, 
    0.20663710f, 0.33177030f, 0.16708946f, -0.09788396f, -0.08181095f, -0.07062341f, 0.06747755f, -0.05759818f, 
    0.03504880f, 0.11601509f, 0.07141931f, 0.12854412f, -0.17159936f, -0.14603314f, -0.18847699f, 0.35809946f, 
    0.11089145f, -0.10515971f, -0.24279568f, -0.03927515f, 0.01330929f, -0.00323629f, 0.02505241f, 0.06068227f, 
    -0.69282258f, -0.08784851f, -0.08689607f, -0.15412399f, 0.11238691f, -0.20940489f, -0.10646930f, -0.03992619f, 
    -0.10385337f, -0.09258921f, -0.21036807f, -0.07464173f, -0.59004849f, -0.44415492f, -0.05473008f, 0.15622714f, 
    0.16400830f, 0.08764182f, -0.01865630f, -0.28820682f, -0.02732634f, -0.05425140f, -0.01074623f, -0.02329176f, 
    -0.12365258f, 0.07617273f, 0.30581537f, -0.03511282f, 0.01486872f, -0.04349915f, 0.04662414f, -0.13601367f, 
    -0.09140929f, 0.30277276f, -0.07337084f, -0.07275592f, 0.63220310f, 0.22593762f, 0.06772196f, 0.32107210f, 
    -0.00419163f, -0.11910152f, 0.19573565f, 0.11164030f, 0.18196148f, 0.28206739f, 0.05008160f, 0.03170126f, 
    0.00540449f, -0.17588092f, 0.32748336f, 0.24263299f, 0.01813487f, -0.07823654f, 0.01746618f, 0.05319630f, 
    -0.15453178f, -0.13150144f, 0.05312115f, 0.07294727f, 0.25421181f, 0.14636903f, 0.05190415f, 0.07050256f, 
    0.04026383f, 0.10879439f, -0.01304138f, -0.02663746f, 0.30118734f, 0.22531472f, 0.25603402f, 0.07566552f, 
    0.24079199f, -0.02796862f, 0.20544313f, -0.24090867f, 0.00393488f, 0.07002902f, -0.07549419f, 0.04552893f, 
    0.10103232f, 0.00316632f, 0.20205526f, 0.07503072f, 0.43009531f, -0.01755266f, -0.01077407f, -0.05752283f, 
    -0.09649949f, -0.04191096f, 0.07848985f, -0.01607539f, -0.06251698f, -0.14929178f, -0.05281040f, -0.22475547f, 
    0.19183037f, 0.00941118f, -0.05583395f, -0.15655227f, 0.15835236f, -0.18115447f, 0.15355563f, 0.01315054f, 
    0.12716824f, 0.03593180f, -0.03098893f, 0.08966491f, 0.17372790f, 0.04249059f, -0.04894989f, 0.23195785f, 
    -0.21703567f, 0.11350077f, 0.14524893f, 0.01718462f, -0.09731736f, -0.09359691f, -0.02686711f, -0.08346285f, 
    0.35053614f, 0.06018249f, 0.10285407f, -0.11905210f, -0.02167347f, 0.09284201f, 0.17002834f, 0.07093634f, 
    0.03635040f, -0.00901891f, 0.01788725f, 0.09531065f, -0.68342054f, 0.18064858f, 0.39868206f, -0.10644013f, 
    -0.17367798f, 0.01278178f, 0.16933347f, 0.01053883f, -0.08544122f, -0.02974991f, 0.03895392f, 0.00519861f, 
    0.15635981f, -0.00224881f, 0.07180199f, 0.12977029f, -0.03381541f, -0.07995562f, 0.13874885f, 0.01835934f, 
    -0.08754664f, -0.03729072f, 0.02686280f, -0.06711601f, -0.28999695f, -0.23486163f, 0.30117416f, -0.28110182f, 
    0.10889257f, -0.00791928f, -0.04181553f, -0.16571015f, -0.22035401f, 0.02985980f, -0.01777705f, -0.01717251f, 
    -0.04124187f, -0.02683878f, 0.22534628f, 0.27309093f, -0.07695019f, -0.01028166f, -0.09591999f, 0.22711603f, 
    0.13517728f, 0.09393180f, -0.06605560f, -0.06120332f, 0.36766461f, -0.15728828f, 0.12968488f, 0.21080978f, 
    0.06817350f, 0.07921866f, 0.14033216f, 0.01506548f, -0.08680541f, 0.01334686f, 0.03063026f, 0.14706056f, 
    0.21425100f, 0.23562942f, 0.06642316f, 0.00040545f, 0.11494624f, 0.00143981f, 0.16340260f, 0.09882344f, 
    0.11387385f, -0.17462645f, -0.02254000f, -0.04791661f, 0.59008729f, 0.63598531f, 0.27764457f, 0.02081036f, 
    0.06505395f, 0.23084271f, 0.17485549f, 0.25338683f, 0.07177056f, -0.00664493f, 0.19768959f, 0.12933066f, 
    -0.01916214f, -0.56412226f, -0.11442964f, -0.31045377f, 0.24982850f, 0.10644884f, -0.03386076f, 0.07974178f, 
    0.13228518f, -0.20883936f, -0.44164139f, -0.20180158f, -0.17268284f, -0.09726502f, -0.36699152f, -0.03328576f, 
    0.00803889f, 0.00199753f, -0.12821698f, -0.11493408f, -0.10789407f, -0.24936783f, 0.08121108f, -0.05525593f, 
    -0.16208166f, -0.10058512f, -0.05093339f, 0.39757705f, -0.15442336f, 0.03090269f, -0.16654450f, -0.20786972f, 
    -0.05265589f, 0.04851653f, 0.03448781f, 0.03868742f, 0.18327279f, -0.02813787f, -0.05463698f, -0.00642131f, 
    -0.02648968f, -0.02338484f, 0.08542123f, 0.08212358f, 0.22362742f, 0.09997784f, 0.20338564f, 0.24998322f, 
    0.16171266f, -0.29738343f, -0.10318315f, 0.00101356f, -0.09889697f, 0.00502786f, 0.12330157f, -0.03188523f, 
    0.02624092f, 0.09962943f, 0.27040628f, 0.35089839f, 0.25344232f, 0.07012627f, -0.08240251f, 0.14713830f, 
    0.01969887f, 0.04912452f, -0.03966964f, -0.08063173f, -0.01241707f, 0.03911145f, -0.07523183f, -0.21340813f, 
    0.14655878f, 0.60430473f, -0.18665799f, -0.18164337f, 0.09427708f, 0.01749517f, 0.15076630f, 0.30905265f, 
    0.20993763f, 0.16428111f, 0.05850849f, -0.04372611f, 0.31821507f, -0.07266051f, -0.59835011f, 0.08719555f, 
    0.13316971f, 0.05903685f, 0.05733113f, 0.19391969f, -0.10076288f, -0.19116876f, -0.25350338f, -0.35566226f, 
    0.49135348f, -0.41585496f, -0.41864839f, 0.34787145f, 0.06692405f, 0.08670825f, 0.26164290f, -0.08490886f, 
    0.09481079f, -0.06809657f, 0.07601941f, -0.02787787f, 0.28926778f, -0.01679796f, 0.11842953f, -0.00054976f, 
    0.08264169f, 0.18032451f, -0.00143970f, -0.04720032f, 0.05956020f, 0.11309188f, 0.18912636f, 0.53263664f, 
    0.08469035f, -0.27347395f, -0.22957213f, 0.01498615f, 0.32703725f, 0.04773662f, -0.02642536f, -0.10479893f, 
    0.02439614f, -0.14366832f, -0.20404656f, -0.20515336f, 0.06427965f, 0.18629949f, -0.21307072f, -0.11201227f, 
    -0.00325623f, 0.18038596f, -0.00521266f, -0.07205642f, 0.02906070f, -0.04614325f, 0.16594872f, 0.13094454f, 
    0.26056552f, -0.29763791f, 0.49343124f, 0.40514714f, 0.12054255f, 0.08545845f, -0.05989424f, 0.04009132f, 
    -0.05593946f, -0.08022597f, 0.00822459f, -0.20224613f, 0.34580442f, -0.15476947f, -0.52986836f, -0.21684888f, 
    0.31575269f, 0.01370369f, 0.11430041f, 0.02497014f, -0.00099770f, -0.21585009f, -0.09813653f, -0.03395057f, 
    0.14437583f, 0.07468830f, -0.03562832f, 0.11147041f, -0.16515945f, 0.12477886f, 0.05036307f, 0.12998514f, 
    -0.02272726f, -0.12816472f, -0.00811265f, -0.05680614f, 0.13795604f, 0.28639981f, 0.05202341f, 0.08234143f, 
    0.01765865f, 0.21045865f, -0.10940152f, -0.00138515f, -0.01848425f, -0.06585038f, 0.17515819f, 0.18194716f, 
    -0.36570656f, -0.06146323f, -0.07321946f, 0.02936235f, -0.11766389f, -0.06080451f, 0.07050105f, -0.18188700f, 
    0.13126343f, -0.32673693f, -0.01130560f, -0.28285447f, 0.16868207f, -0.15260282f, -0.01773764f, -0.19887294f, 
    -0.18905851f, 0.02783574f, 0.19593757f, -0.13215819f, 0.22968252f, 0.04665492f, -0.04391303f, 0.24221322f, 
    0.68131542f, -0.34402698f, 0.39067277f, -0.22913675f, -0.14113289f, -0.21733299f, 0.13086747f, 0.06836349f, 
    0.00257077f, 0.01826564f, 0.04147419f, -0.13658144f, -0.21894066f, 0.05712643f, -0.40828606f, 0.37592474f, 
    0.04810182f, 0.06272066f, -0.21140401f, -0.17525162f, 0.05540144f, 0.10313958f, 0.17314151f, 0.35100684f, 
    0.03052154f, 0.33320495f, -0.09359573f, 0.03848306f, 0.18024927f, -0.15645210f, -0.20793054f, -0.04184673f, 
    -0.06740556f, 0.01424298f, 0.00404899f, 0.26509762f, 0.27054608f, -0.10437711f, -0.03923598f, 0.00626723f, 
    0.02520791f, 0.08514376f, 0.08982640f, 0.14914274f, -0.19590227f, -0.18764715f, -0.08528384f, -0.23228802f, 
    0.12134685f, -0.56129122f, -0.12279883f, -0.09793387f, -0.08259250f, 0.13315357f, -0.06978800f, 0.02310233f, 
    0.28547856f, -0.01977701f, 0.16014647f, -0.00663604f, -0.14562149f, -0.63339490f, -0.07870590f, -0.06446896f, 
    0.18761179f, -0.07605310f, 0.05790172f, -0.04065604f, -0.09064223f, -0.20075825f, -0.17402136f, -0.21427329f, 
    -0.34764484f, 0.25186807f, 0.45151612f, -0.30694386f, 0.12197426f, -0.11773405f, -0.01344125f, -0.02447626f, 
    -0.09874469f, 0.00150738f, 0.09629084f, 0.11703023f, 0.05407408f, 0.43295789f, 0.15680848f, 0.24868971f, 
    -0.22258191f, -0.00793813f, 0.08955052f, -0.09803258f, 0.23231176f, 0.00532315f, -0.01528337f, 0.08107308f, 
    0.13092768f, -0.27169886f, 0.05323781f, 0.35675022f, -0.19954859f, 0.01385274f, 0.17338184f, 0.06821505f, 
    -0.20838006f, -0.17739563f, 0.00315496f, 0.06754373f, 0.29918835f, -0.00434888f, 0.30512384f, 0.10395231f, 
    0.12208872f, -0.01451634f, 0.04081495f, 0.11449496f, 0.34624967f, -0.06285561f, 0.21590093f, 0.10236116f, 
    0.40958750f, -0.20449579f, 0.09131758f, -0.21141757f, 0.01838963f, -0.11275762f, 0.08847296f, 0.20152923f, 
    0.02369698f, 0.24555850f, -0.11110998f, -0.07048123f, -0.12056586f, 0.07885773f, -0.19227254f, -0.08115707f, 
    -0.04870079f, 0.09595779f, -0.18758813f, -0.11526448f, -0.17469138f, -0.01281805f, 0.01563040f, 0.00413139f, 
    0.13601616f, 0.25940076f, -0.22020502f, 0.08708721f, -0.15873876f, -0.03145098f, 0.07595711f, 0.23170117f, 
    -0.07332185f, 0.05233235f, -0.00894274f, -0.09465511f, 0.08974041f, 0.22533379f, -0.24412234f, -0.14457290f, 
    -0.04451693f, 0.09370781f, -0.07567641f, 0.22541714f, -0.00663485f, 0.08839332f, -0.12357037f, -0.08522110f, 
    -0.03847917f, 0.08418247f, -0.33544114f, -0.50246245f, 0.08932053f, -0.12656289f, -0.02377293f, -0.32066184f, 
    -0.12989929f, 0.10298228f, -0.16708207f, -0.32332921f, -0.11030356f, -0.25663245f, -0.04055080f, 0.20589162f, 
    0.04108835f, 0.13666137f, -0.07015806f, -0.12484933f, 0.33634666f, 0.16145784f, -0.23911086f, 0.09132024f, 
    0.04980912f, 0.18420161f, -0.08071347f, 0.21969214f, -0.13110919f, -0.01355275f, 0.03821655f, 0.20712356f, 
    -0.11917533f, -0.02968261f, 0.20763461f, 0.11889590f, -0.13035201f, -0.09717443f, 0.19456153f, 0.00578044f, 
    -0.04155650f, -0.01498287f, -0.03438675f, 0.01969336f, 0.00243754f, 0.14971755f, 0.14576718f, 0.26241177f, 
    -0.10765778f, -0.07048360f, 0.11057086f, -0.30887172f, -0.03683454f, -0.06572213f, -0.16495368f, -0.01505084f, 
    0.03587270f, 0.29304138f, 0.20100796f, 0.15577166f, -0.25378433f, -0.12813644f, -0.13099261f, 0.02406438f, 
    0.00532198f, 0.04429647f, -0.00671070f, 0.06035006f, -0.08624255f, 0.08148236f, -0.03241105f, 0.28410500f, 
    0.01115167f, 0.22420576f, 0.01511064f, 0.03270536f, 0.02909264f, 0.05147802f, 0.00335912f, -0.01499158f, 
    0.00973445f, 0.04557510f, 0.04229360f, 0.11702062f, 0.19023050f, -0.25130749f, 0.14195625f, -0.06353860f, 
    0.31701192f, -0.01283144f, -0.00991436f, 0.08063228f, 0.00457975f, -0.03901371f, -0.03620652f, -0.02339020f, 
    -0.85882145f, -0.63785434f, -0.28836107f, -0.02918067f, 0.01701826f, 0.10704838f, 0.10313240f, 0.06549310f, 
    0.08632571f, -0.00267368f, -0.04913914f, 0.23027505f, 0.62542266f, 0.36318886f, 0.25238249f, 0.14088289f, 
    0.05336694f, 0.07291841f, 0.05083397f, -0.00859970f, 0.16789378f, -0.07165434f, 0.15261413f, 0.23148961f, 
    0.03107468f, -0.11038499f, -0.07692370f, 0.05267458f, 0.04805632f, -0.02947419f, 0.14545101f, 0.01365274f, 
    -0.13772649f, 0.13268009f, 0.12729254f, 0.10211970f, 0.18354590f, 0.02531623f, 0.33463496f, -0.02588334f, 
    0.01057556f, 0.14942457f, -0.13752750f, 0.14877829f, 0.08367465f, -0.01608052f, 0.08072768f, -0.16654411f, 
    -0.16485794f, -0.10346439f, -0.06556541f, 0.03492441f, -0.03384496f, 0.05897451f, 0.08014486f, 0.16447391f, 
    0.05439187f, 0.12174600f, 0.02662676f, 0.15863386f, -0.19217557f, -0.71593040f, -0.64071554f, -0.47613317f, 
    0.02992340f, -0.11823799f, -0.07042754f, -0.11770929f, -0.08215619f, 0.09352092f, -0.01925814f, -0.00970565f, 
    -0.21126805f, -0.24666321f, 0.20023236f, -0.18788110f, 0.21038604f, 0.11374684f, -0.03098786f, 0.07211008f, 
    0.15935479f, 0.02425508f, -0.09899687f, 0.07089262f, -0.36563957f, -0.34436449f, 0.02580403f, -0.00896301f, 
    -0.07615150f, -0.14968461f, 0.13986552f, -0.23405728f, -0.00314677f, -0.09064533f, 0.12581140f, 0.07718729f, 
    0.24757388f, -0.00171711f, 0.04985052f, 0.30886641f, -0.11966833f, 0.38862038f, -0.37455285f, 0.43765932f, 
    0.18663912f, -0.18512927f, 0.21026364f, -0.08264841f, 0.30251026f, 0.16152976f, -0.23976812f, 0.15244608f, 
    -0.07454655f, 0.18227056f, -0.04548489f, 0.17163576f, -0.00003635f, -0.09333745f, 0.05546748f, 0.41341740f, 
    -0.64980632f, -0.21930668f, 0.27043584f, 0.01234648f, 0.13988374f, -0.02884884f, -0.00784845f, 0.02883388f, 
    0.14088348f, 0.17072760f, 0.05129570f, 0.17530116f, 0.11591917f, 0.04554173f, -0.06402451f, -0.07672128f, 
    -0.04760268f, 0.05802215f, -0.04318311f, -0.17600322f, 0.20803796f, 0.18790455f, 0.34819627f, 0.18630947f, 
    0.05698853f, 0.39755800f, -0.09055287f, -0.00450167f, 0.02051447f, -0.00407705f, 0.15754075f, -0.08075652f, 
    0.34277034f, 0.13673715f, 0.26904866f, 0.07455109f, -0.10997517f, -0.10220139f, -0.00348108f, -0.08880036f, 
    -0.04161075f, 0.00608326f, -0.13032033f, 0.05802547f, -0.08930437f, 0.09383403f, 0.06028435f, 0.03815626f, 
    0.16859391f, -0.02811325f, 0.09501781f, 0.03710268f, -0.13728325f, 0.13314679f, -0.13650626f, -0.29183868f, 
    0.08866552f, -0.03261007f, -0.15984640f, -0.15985118f, -0.03435454f, 0.09239818f, 0.06532411f, 0.20291774f, 
    -0.06968905f, 0.17668673f, 0.16299915f, 0.00235327f, 0.08658332f, -0.06001224f, -0.08634165f, 0.25906211f, 
    0.24686685f, 0.17771150f, 0.10125034f, 0.14456521f, 0.04598214f, -0.09848772f, 0.12760897f, 0.01824579f, 
    -0.00981278f, 0.05844349f, -0.10001398f, -0.00244662f, -0.53872424f, 0.12215848f, 0.40993476f, 0.12124230f, 
    -0.12791210f, 0.00591312f, 0.25858793f, 0.24721302f, -0.00662226f, 0.20040807f, 0.13173288f, 0.00883662f, 
    -0.11197335f, -0.01601041f, -0.11502656f, -0.00197836f, 0.07150640f, 0.08363090f, -0.07401057f, 0.07784051f, 
    0.21911170f, -0.05658501f, 0.03068209f, 0.02110450f, -0.30424574f, -0.06623325f, 0.27660638f, 0.30051273f, 
    -0.22775093f, -0.08480286f, 0.35361299f, -0.09330892f, 0.12081023f, 0.00744988f, -0.13163081f, 0.13974488f, 
    -0.35691181f, -0.12994188f, -0.21290857f, -0.01458528f, 0.09146322f, -0.04139682f, -0.08271775f, -0.09560551f, 
    -0.02276077f, -0.05827925f, 0.05538215f, -0.06265386f, 0.01136633f, 0.08830795f, 0.36511028f, 0.39895642f, 
    0.20048401f, 0.20837548f, 0.18669489f, 0.24699634f, 0.10788902f, -0.07902240f, -0.13931087f, 0.07311584f, 
    -0.53786486f, -0.37038490f, -0.31192365f, -0.22244108f, 0.08316646f, -0.14605421f, 0.03658700f, 0.06450017f, 
    -0.01175841f, 0.14955917f, 0.00853130f, 0.00849313f, -0.24827932f, -0.50508678f, -0.45837709f, -0.23765413f, 
    0.03429853f, 0.23485285f, 0.21639132f, 0.00683195f, 0.17889048f, 0.06484532f, -0.04148094f, 0.15413646f, 
    0.12482698f, 0.21900415f, 0.25870180f, 0.33845547f, 0.20975250f, 0.20249771f, 0.14887410f, 0.07315236f, 
    -0.04519466f, 0.28157485f, 0.15010090f, 0.06307699f, 0.19128251f, 0.49697730f, 0.10558715f, 0.27334169f, 
    0.01099108f, 0.22207984f, 0.06501771f, 0.08563317f, 0.26832694f, -0.00365034f, 0.39920837f, 0.17928641f, 
    -0.25834078f, 0.28462276f, 0.27970091f, 0.21693310f, -0.02142099f, -0.01307684f, -0.14640917f, 0.08776985f, 
    0.08448835f, 0.23343723f, 0.24520570f, 0.06587334f, 0.03137625f, -0.08942587f, -0.09119987f, -0.19607104f, 
    -0.04675663f, 0.04809082f, 0.04053191f, 0.14030299f, 0.00448856f, 0.25432140f, 0.16644885f, 0.12140941f, 
    -0.00548735f, 0.20057693f, 0.34875360f, 0.19568479f, -0.04825519f, 0.04790020f, 0.14534935f, 0.03556225f, 
    0.27294695f, 0.39715153f, 0.42887303f, 0.18623041f, -0.35741246f, 0.06428523f, 0.11680719f, -0.23406623f, 
    -0.11178497f, -0.12904307f, -0.17884879f, -0.07898221f, -0.12275200f, -0.03657557f, 0.02548748f, 0.17812097f, 
    -0.18525952f, -0.03401853f, -0.04585797f, -0.05867448f, 0.00352211f, 0.06623909f, 0.03642400f, -0.10455500f, 
    -0.13326937f, 0.04162892f, -0.11440330f, 0.02836109f, 0.29525393f, -0.05719254f, -0.06936277f, -0.04662589f, 
    0.21503049f, 0.27847376f, -0.09336828f, 0.05850669f, -0.20237736f, -0.05010039f, 0.08992971f, 0.13051267f, 
    0.22675590f, 0.00681278f, 0.06161249f, -0.06093511f, -0.09304483f, -0.12540333f, -0.02545783f, -0.17674287f, 
    -0.09458044f, -0.07820386f, -0.08157293f, -0.12931897f, 0.01862960f, 0.01684319f, 0.07974404f, -0.10586880f, 
    -0.08575346f, -0.12044705f, 0.18917193f, 0.41628167f, 0.03021214f, 0.05201977f, 0.05502937f, 0.07358208f, 
    -0.17051728f, 0.05781608f, -0.09480399f, -0.01252997f, -0.11098868f, -0.00843079f, -0.04920698f, -0.05468247f, 
    -0.00081030f, 0.01617713f, 0.05429404f, -0.10611348f, -0.39606896f, -0.18550324f, -0.06254823f, -0.17691112f, 
    -0.07198329f, 0.16834031f, 0.11032879f, 0.17473614f, 0.17197539f, -0.02432096f, -0.02714903f, -0.03117147f, 
    -0.13054596f, 0.30921671f, -0.33415732f, 0.00945515f, -0.09555957f, -0.08393168f, -0.20875324f, -0.07158260f, 
    0.09754315f, 0.21858102f, 0.06886327f, -0.04774491f, 0.11362530f, -0.16800468f, 0.06544427f, 0.14376940f, 
    0.03906984f, 0.05116726f, -0.05409123f, -0.06092459f, -0.16660796f, 0.01302563f, -0.10261332f, -0.04250934f, 
    0.11118922f, 0.26439753f, 0.18708584f, 0.00283859f, 0.12539384f, 0.45219627f, 0.16313754f, -0.06894947f, 
    0.04297837f, 0.13641620f, 0.12880634f, 0.27378958f, 0.06639414f, 0.30076054f, 0.14668305f, -0.02968798f, 
    0.06319136f, -0.13872162f, 0.03765200f, -0.10039342f, -0.05867735f, -0.00184016f, -0.07662813f, -0.00526883f, 
    0.38305268f, 0.27402514f, 0.04755898f, 0.33853605f, -0.04407056f, 0.29560524f, 0.19971038f, 0.10017685f, 
    0.09253083f, 0.16716968f, 0.15699200f, 0.32275206f, 0.27797592f, 0.24446478f, 0.46825436f, 0.36120918f, 
    0.03251050f, -0.23476116f, -0.08274459f, 0.29931933f, 0.03368854f, 0.07789654f, 0.28837115f, -0.07573736f, 
    -0.36932695f, -0.07414912f, -0.03596097f, 0.14441484f, -0.04143183f, -0.11993521f, 0.03861892f, -0.15536034f, 
    0.35365877f, 0.12379950f, 0.17140180f, 0.29812020f, 0.08161815f, -0.11600011f, 0.11198649f, -0.22086462f, 
    -0.11706398f, -0.13385920f, -0.06374846f, 0.00473708f, -0.14801116f, -0.29614717f, -0.25412565f, -0.53010374f, 
    0.34043404f, -0.05502897f, 0.03476720f, 0.15558958f, 0.10083985f, 0.18562001f, 0.01577142f, 0.14032964f, 
    -0.17113471f, -0.29812321f, -0.33994335f, -0.32841039f, -0.16728203f, -0.23984616f, -0.19122015f, -0.14868535f, 
    -0.29521224f, -0.17672808f, -0.33713904f, -0.06348774f, 0.17641288f, 0.13247968f, -0.05376655f, 0.04540636f, 
    -0.02036785f, -0.33825675f, -0.14402959f, -0.15161440f, -0.08903223f, 0.00453145f, 0.14238892f, 0.07290310f, 
    -0.45183095f, 0.18451126f, 0.00484278f, 0.19054599f, -0.30096757f, 0.47849497f, 0.02065105f, 0.04926643f, 
    -0.22583871f, -0.10852519f, 0.26422939f, 0.15051152f, -0.00596129f, 0.17044899f, -0.08767536f, 0.13137063f, 
    0.36745706f, 0.04030771f, 0.04213444f, 0.35108438f, -0.00299267f, 0.10390520f, -0.21154104f, 0.09466802f, 
    -0.03395550f, -0.15852417f, -0.03751823f, -0.16689830f, 0.08536054f, 0.05131138f, -0.28683576f, -0.49884155f, 
    0.14505231f, 0.11596864f, -0.03527460f, 0.11118557f, -0.25260442f, -0.11681779f, -0.06990521f, -0.28129745f, 
    -0.22013994f, -0.03388399f, -0.04136729f, -0.10645156f, -0.02628431f, -0.03225959f, -0.07964553f, -0.08419850f, 
    0.22455792f, 0.37294918f, 0.17029420f, 0.11797717f, -0.30204341f, 0.06454066f, -0.10359475f, -0.11829384f, 
    0.04904559f, 0.05634139f, 0.20064111f, 0.06847084f, -0.09240542f, -0.17046329f, -0.10113735f, 0.17546229f, 
    -0.16657932f, -0.01198579f, 0.00267883f, 0.63909900f, -0.20507951f, -0.15276693f, -0.10567289f, -0.38159740f, 
    0.01461143f, -0.34069261f, 0.15706286f, 0.15619695f, -0.17162949f, -0.23717263f, -0.18137117f, 0.17058262f, 
    0.03964490f, 0.03454345f, 0.20073819f, 0.14584832f, -0.00237414f, -0.00282686f, -0.07369690f, 0.04183691f, 
    0.38016278f, -0.01453471f, 0.17533965f, 0.36536485f, 0.07174929f, 0.28804216f, 0.30900642f, 0.24990411f, 
    0.07145568f, 0.12276495f, 0.14442006f, 0.12485219f, 0.16602224f, -0.08533208f, 0.16571312f, 0.07583892f, 
    0.14648604f, -0.08753485f, 0.15322478f, 0.21466017f, 0.08394719f, 0.20484969f, 0.14721535f, 0.05134602f, 
    0.10104308f, -0.09040121f, -0.08662350f, 0.11192092f, 0.02473437f, 0.04105430f, 0.01701088f, -0.04926363f, 
    0.25735241f, -0.07288909f, 0.14822087f, 0.34977707f, -0.31132951f, -0.10733192f, 0.28128502f, -0.15696357f, 
    0.00520616f, -0.02834839f, -0.12074878f, -0.03330631f, -0.13323581f, -0.02284806f, 0.01347933f, 0.29697815f, 
    0.30082431f, 0.04000036f, -0.35221958f, -0.19604194f, -0.09840783f, 0.00052056f, 0.02470482f, -0.00347087f, 
    0.16088162f, 0.20226476f, 0.10707892f, 0.03387853f, -0.33497283f, -0.06115098f, 0.05164180f, -0.02886073f, 
    -0.05315694f, -0.10350826f, -0.12704223f, -0.05300404f, -0.26972362f, -0.20813291f, -0.13188525f, 0.00540360f, 
    -0.20757845f, 0.04178246f, -0.12967446f, 0.23383400f, -0.00757004f, -0.14115559f, -0.13072203f, -0.06718847f, 
    -0.00125261f, -0.04076631f, -0.28979379f, -0.11906891f, -0.35885572f, -0.05869570f, 0.00182057f, 0.06110276f, 
    -0.04678635f, 0.01792366f, -0.09363578f, -0.08926646f, 0.01803161f, 0.06904422f, 0.14122047f, 0.12066936f, 
    -0.19701591f, -0.23279004f, 0.06874324f, 0.21110085f, 0.12686057f, 0.18080413f, -0.06752014f, 0.13144098f, 
    -0.20587875f, 0.06092545f, 0.07308342f, -0.12573890f, -0.34058669f, 0.13665932f, 0.29912886f, -0.08408038f, 
    0.05079766f, -0.21897593f, -0.05393716f, -0.22744566f, 0.05190811f, -0.00794659f, 0.01963014f, -0.00873506f, 
    -0.29307187f, 0.26728383f, 0.14871062f, 0.09671959f, 0.00303540f, -0.05791106f, -0.24307227f, -0.02037781f, 
    -0.05237466f, -0.00096182f, 0.10090244f, -0.11446072f, -0.00796749f, -0.20021555f, -0.33429772f, 0.28150067f, 
    0.14495997f, -0.00849300f, -0.06018659f, -0.03695739f, 0.11279514f, -0.06766638f, 0.07581583f, -0.12659167f, 
    -0.04708297f, 0.00042625f, -0.08845068f, -0.12998064f, 0.01748605f, 0.02177314f, -0.03271023f, -0.05233763f, 
    0.03942401f, 0.05919391f, 0.06714945f, 0.10589767f, 0.16398296f, -0.13806747f, -0.43415609f, 0.32746822f, 
    0.24385308f, 0.13123295f, 0.12996276f, 0.22744443f, 0.28935280f, 0.05057843f, 0.02815471f, 0.08052638f, 
    0.22000678f, 0.17627080f, 0.12935993f, -0.10234907f, -0.08013166f, 0.03701955f, -0.08645380f, -0.16402949f, 
    -0.01653230f, -0.17596433f, 0.01147000f, 0.09620513f, -0.00967567f, 0.55421263f, 0.46009216f, 0.00568136f, 
    0.02473494f, 0.02148677f, 0.03311093f, -0.03950621f, 0.02371828f, 0.05886786f, -0.06209116f, -0.14252760f, 
    0.42215925f, 0.36421010f, -0.01323737f, 0.22895083f, 0.00347075f, 0.05892194f, 0.07338910f, -0.00156639f, 
    -0.04245640f, -0.15213919f, 0.08150309f, -0.01351052f, 0.48076475f, 0.24076712f, 0.00058934f, 0.02212792f, 
    0.16363886f, 0.08604968f, 0.18245384f, 0.30873442f, -0.07793422f, -0.03232115f, 0.05191367f, -0.12935357f, 
    -0.18028153f, 0.28924075f, 0.09897926f, -0.07033402f, 0.06667311f, -0.17894892f, -0.23704845f, -0.18573956f, 
    0.12383509f, -0.39541537f, -0.00247246f, 0.26135778f, -0.60092849f, 0.17076501f, 0.21270949f, -0.27633885f, 
    0.05721805f, -0.05228441f, 0.11220466f, -0.08572041f, -0.02612822f, -0.07652192f, 0.21318190f, -0.32221857f, 
    0.74070281f, 0.62301040f, 0.16375323f, 0.02146772f, 0.04586441f, 0.00995918f, 0.04448879f, -0.01674533f, 
    -0.19323957f, -0.01243201f, -0.04936862f, -0.11082780f, -0.19816351f, 0.06536268f, 0.00885966f, 0.02905788f, 
    -0.12789361f, -0.07252097f, 0.07588290f, 0.06151223f, -0.18330437f, -0.10400860f, -0.13978654f, 0.00755590f, 
    -0.27950981f, -0.54293752f, -0.23843648f, 0.02620311f, 0.02324946f, -0.17835464f, 0.14743952f, 0.02871482f, 
    -0.12130032f, -0.01759982f, -0.27889654f, 0.00287087f, 0.15295333f, 0.04152141f, 0.03641851f, 0.09148768f, 
    0.09854777f, 0.01978538f, 0.11051992f, -0.03017540f, 0.13060151f, -0.01166090f, 0.08764652f, -0.05515959f, 
    0.14098313f, 0.08882987f, 0.00752150f, 0.23281975f, 0.32563770f, 0.11579456f, 0.31709653f, 0.00321483f, 
    0.03286246f, 0.23762353f, 0.02622969f, -0.15705052f, -0.26112333f, -0.06648691f, -0.21100929f, -0.25699875f, 
    0.07738661f, -0.12593806f, 0.26949382f, 0.07581577f, 0.08570144f, 0.10006736f, 0.10117638f, -0.03324671f, 
    -0.65509492f, -0.04994463f, -0.53618187f, -0.15781049f, -0.01113396f, 0.06242873f, -0.21821670f, 0.14726700f, 
    -0.03501088f, -0.06046930f, 0.05951626f, -0.02715634f, 0.27985585f, 0.13080333f, -0.26453015f, 0.18283656f, 
    0.19185838f, 0.00934061f, -0.19783601f, 0.21502671f, -0.16896386f, 0.11649437f, -0.02683585f, -0.06911972f, 
    -0.01996335f, 0.15042847f, 0.11288240f, -0.10829671f, 0.06130404f, -0.06090948f, -0.00226935f, 0.00018980f, 
    -0.00980715f, 0.03257157f, -0.00397210f, -0.00117303f, 0.68165243f, 0.37365770f, -0.34519312f, 0.06046633f, 
    0.06410980f, 0.03532764f, -0.11353726f, 0.16407251f, -0.22433136f, -0.07702140f, 0.02778626f, 0.07073660f, 
    0.26911327f, 0.07175328f, 0.33042920f, 0.14610440f, 0.02140264f, 0.10533403f, 0.14234866f, -0.01328228f, 
    -0.21430252f, 0.01357651f, 0.11832916f, -0.08669434f, -0.56364644f, 0.19211997f, 0.41197190f, -0.07393372f, 
    -0.21192713f, -0.00566121f, 0.19935609f, 0.33689040f, 0.00303818f, 0.03083349f, 0.08456573f, -0.05022067f, 
    -0.04497621f, -0.05077031f, -0.07705978f, 0.01271585f, -0.02393337f, 0.05036918f, 0.00162026f, -0.02027818f, 
    0.05491785f, -0.02731196f, -0.00978086f, -0.02871170f, 0.06252743f, 0.02957117f, -0.00353905f, -0.03403031f, 
    0.03597812f, -0.03807291f, -0.03899467f, 0.01802518f, 0.00154555f, -0.04484093f, 0.02417370f, 0.03510230f, 
    0.05039578f, 0.02327483f, -0.02160681f, 0.03251342f, 0.05445006f, 0.04353342f, -0.01267113f, 0.02369354f, 
    -0.01013181f, -0.01579097f, 0.01915319f, -0.03799289f, 0.05630308f, 0.04571187f, 0.02488667f, -0.04030876f, 
    -0.01953454f, -0.02964198f, 0.05459422f, -0.00266804f, 0.05483118f, 0.05628343f, 0.04806080f, 0.06346601f, 
    -0.00071745f, -0.02851267f, -0.01778566f, -0.04458730f, -0.05382458f, -0.03323637f, 0.04109602f, 0.02253085f, 
    -0.03438035f, 0.01866118f, -0.03002422f, 0.04273664f, -0.02306112f, 0.03606843f, -0.07241286f, 0.01912380f, 
    0.02828953f, -0.06049844f, -0.06426612f, 0.06144748f, -0.03182619f, -0.01085537f, -0.01596660f, -0.04484301f, 
    -0.04893682f, -0.01882818f, -0.02765705f, -0.07437984f, 0.03700107f, 0.05497262f, 0.01511625f, 0.03963211f, 
    -0.04784057f, -0.06125966f, -0.04042734f, -0.00803069f, -0.05655797f, -0.06670942f, -0.06546698f, 0.01118052f, 
    -0.04091591f, -0.02810070f, -0.01304707f, -0.01611957f, -0.01923735f, -0.03370189f, -0.03132519f, -0.05220885f, 
    -0.06006424f, 0.06340305f, -0.03544918f, 0.01452508f, -0.00719264f, 0.00026672f, 0.00004108f, 0.00705729f, 
    0.04204679f, 0.01686027f, -0.03937240f, 0.04622185f, -0.06893327f, 0.03177410f, 0.02707587f, 0.02611044f, 
    0.04310745f, -0.05000990f, -0.05311926f, -0.04449903f, -0.05604409f, -0.01983434f, 0.03597698f, -0.07125143f, 
    -0.06545191f, 0.05538547f, -0.03601413f, -0.06297401f, 0.02032644f, -0.02380403f, 0.05760583f, -0.04236887f, 
    0.05447451f, -0.02562645f, -0.03058627f, 0.00712864f, 0.04383310f, 0.03634502f, 0.01107258f, -0.01576031f, 
    0.02037475f, -0.06186303f, 0.01469477f, -0.03502236f, -0.00479114f, -0.02445521f, -0.07412791f, -0.00290392f, 
    -0.04168202f, -0.03346168f, -0.02112991f, -0.04512061f, -0.03063627f, -0.03973444f, 0.05471518f, -0.06687264f, 
    -0.00392156f, -0.05442853f, -0.04182479f, 0.00925910f, -0.02970480f, -0.00532634f, -0.04841674f, -0.02878966f, 
    0.05513793f, -0.07721908f, -0.06539647f, 0.04996015f, 0.00716565f, -0.04907836f, -0.01885280f, -0.00248163f, 
    -0.01234189f, -0.06379521f, 0.00952527f, 0.05932405f, -0.00997397f, 0.03058279f, 0.02362605f, 0.02176341f, 
    0.03810487f, 0.06900921f, 0.00410173f, -0.02466884f, -0.06570916f, 0.05296103f, -0.02243434f, -0.00513138f, 
    0.02051874f, 0.05175970f, -0.04767243f, 0.03610678f, -0.06549563f, -0.06480500f, -0.04195259f, -0.06225332f, 
    -0.03307505f, 0.38178533f, 0.05985948f, -0.06789827f, 0.10333852f, 0.27212667f, 0.24319278f, -0.07534815f, 
    0.04427049f, 0.14314315f, 0.09461223f, 0.11235567f, 0.09281933f, 0.36612535f, 0.23617889f, 0.10661726f, 
    0.13214420f, -0.02355417f, -0.11514246f, 0.05829122f, 0.06374238f, -0.05301453f, 0.06795752f, 0.01984838f, 
    0.07226733f, 0.21640521f, -0.18630908f, 0.08097576f, -0.01203271f, 0.16909796f, 0.18185146f, -0.10987841f, 
    -0.02111880f, 0.22650298f, 0.02356950f, 0.34248343f, 0.41978195f, 0.05055420f, 0.15875480f, 0.38999489f, 
    0.00213411f, -0.28355467f, -0.00090181f, -0.05109864f, 0.04620524f, 0.05512230f, 0.09907530f, -0.26840374f, 
    0.12956557f, -0.20181975f, -0.37620136f, -0.33361122f, -0.16120341f, -0.10325317f, -0.00811540f, 0.03872447f, 
    0.44644871f, -0.01096584f, 0.05910191f, 0.30771342f, 0.03247430f, -0.09634684f, 0.25265956f, -0.05761134f, 
    -0.14555515f, -0.15969157f, 0.04365425f, -0.05088045f, 0.11019679f, -0.30297497f, -0.24403392f, -0.34105822f, 
    0.34906375f, -0.04080020f, 0.21865383f, -0.06063003f, -0.10667794f, 0.09882330f, -0.16642916f, 0.15901342f, 
    0.00095780f, -0.27974945f, -0.25354794f, -0.08411804f, 0.23262382f, 0.05206122f, -0.30317736f, 0.15689701f, 
    -0.18809347f, -0.05195002f, -0.13089447f, -0.09762593f, 0.15556036f, 0.05737348f, -0.11175906f, 0.03597222f, 
    0.01185099f, -0.22362009f, -0.14592242f, -0.00017645f, -0.10636416f, -0.02876946f, 0.10911082f, 0.03879371f, 
    -0.21742328f, 0.15533629f, 0.06943640f, 0.02338350f, -0.22118565f, 0.18038963f, 0.19347575f, -0.00419567f, 
    -0.15713382f, -0.28346622f, 0.00143995f, 0.11131331f, 0.12735093f, 0.05663079f, -0.22816038f, -0.00941849f, 
    0.31273678f, 0.02045257f, 0.22125356f, 0.08676924f, 0.00996222f, -0.09480990f, -0.14773723f, 0.07726265f, 
    -0.03024227f, -0.04145744f, -0.05124941f, -0.04289448f, 0.31467593f, -0.10074504f, -0.34687173f, -0.56069320f, 
    -0.00807946f, 0.08713827f, 0.15189439f, 0.08710720f, 0.01452178f, -0.05900492f, 0.13108510f, -0.05592215f, 
    -0.08937245f, -0.03807851f, -0.11377371f, -0.10689388f, 0.08219716f, -0.03735461f, 0.01793970f, -0.15641738f, 
    0.06393578f, 0.14175481f, 0.02227529f, 0.12167497f, -0.05966948f, 0.02454386f, 0.01279612f, -0.26460797f, 
    0.12219423f, 0.11505885f, 0.15957424f, 0.14126422f, 0.12977900f, 0.02396451f, 0.10647639f, 0.07895227f, 
    0.25712398f, 0.09109826f, 0.21850340f, 0.33562893f, -0.07758025f, -0.01980227f, -0.03151182f, -0.11838154f, 
    0.25516418f, -0.29506692f, 0.15958320f, -0.16387670f, 0.04429718f, -0.20772830f, -0.41721761f, -0.07489668f, 
    -0.11446204f, -0.26326394f, -0.18892781f, 0.06356928f, -0.00648127f, 0.02515945f, -0.04027713f, -0.03071415f, 
    0.20287007f, -0.02160088f, -0.27882957f, 0.14720787f, -0.01705990f, -0.06689208f, -0.00510501f, 0.09891039f, 
    -0.13015622f, 0.06532221f, -0.05634091f, -0.08577821f, 0.27926156f, 0.24037299f, -0.25306627f, -0.20698254f, 
    0.06488799f, -0.08913818f, -0.05092189f, -0.00894109f, 0.05021281f, 0.12365525f, 0.00333550f, 0.13562484f, 
    0.23401058f, -0.23141928f, 0.01306063f, -0.31098241f, 0.14153314f, 0.15247507f, 0.24812445f, 0.26608756f, 
    0.08616744f, 0.04933967f, -0.25843090f, -0.10883033f, -0.13319071f, 0.09403209f, 0.08644518f, -0.07825226f, 
    -0.00365764f, 0.28218925f, -0.11106566f, -0.09345748f, 0.12006256f, -0.07169437f, -0.09512039f, 0.11483380f, 
    -0.03661763f, -0.23165646f, -0.17672606f, 0.38559166f, -0.17448907f, 0.10708121f, 0.05942609f, 0.04662577f, 
    0.15247113f, -0.00196048f, 0.20241097f, -0.03409806f, -0.44203195f, -0.18059184f, -0.04575471f, 0.04146358f, 
    0.02466915f, 0.03944601f, -0.09876338f, -0.01271992f, 0.01285313f, 0.19036655f, -0.08874401f, 0.09572922f, 
    -0.04643198f, -0.04706749f, 0.12423410f, -0.15772752f, -0.08379292f, -0.16445592f, -0.01887490f, 0.14902842f, 
    -0.05051823f, 0.29713091f, 0.08425454f, 0.06979223f, -0.13815236f, 0.07038333f, 0.13089520f, 0.09100233f, 
    0.01021552f, 0.10407834f, -0.01763253f, 0.00518894f, -0.12745897f, 0.04934722f, 0.02702010f, 0.11502635f, 
    -0.25694332f, 0.06584564f, 0.10704622f, -0.16236046f, 0.17256540f, 0.21190082f, -0.05709197f, 0.31539416f, 
    0.21620189f, 0.10609987f, -0.21105720f, -0.08031540f, 0.45142457f, 0.24611051f, 0.19662958f, 0.08327962f, 
    0.18762210f, 0.18927288f, -0.28389400f, -0.04369321f, -0.09356815f, -0.02366684f, 0.03911176f, 0.03281687f, 
    0.03995819f, 0.14366944f, 0.12726763f, 0.36178386f, -0.12377992f, 0.10148466f, 0.22354983f, -0.10291447f, 
    -0.12797870f, -0.10632733f, 0.02480050f, 0.07404421f, 0.39828050f, -0.09014133f, -0.06459161f, 0.01407990f, 
    0.02250272f, 0.11639424f, 0.03102251f, 0.00012958f, -0.08453801f, -0.05031507f, -0.02491237f, 0.11823021f, 
    0.15288904f, -0.07611352f, 0.07172198f, 0.07114648f, 0.19814806f, 0.14446469f, 0.05955509f, -0.00103152f, 
    -0.01422816f, -0.06419744f, -0.12220426f, -0.05057851f, -0.30456480f, -0.23856005f, 0.06841703f, -0.07844482f, 
    0.08186317f, 0.00331896f, 0.02731841f, 0.10687509f, 0.08117364f, -0.23262636f, 0.02964580f, -0.07867336f, 
    0.38724896f, 0.09032583f, -0.06103418f, 0.10805020f, -0.06857737f, -0.05710387f, -0.03008340f, 0.05648025f, 
    0.14994811f, 0.18322924f, -0.00083123f, 0.03212570f, 0.66903532f, 0.20181137f, -0.09075251f, -0.01767075f, 
    0.11799129f, -0.06877322f, -0.08346554f, -0.20877092f, -0.21225950f, -0.02945381f, -0.16509296f, -0.06914067f, 
    -0.03959997f, -0.03237616f, -0.00950188f, 0.09175958f, 0.22812544f, 0.14107056f, 0.19989347f, -0.11281703f, 
    -0.03015641f, 0.06646827f, 0.21293800f, 0.00374495f, 0.12216280f, -0.10470265f, -0.03146909f, 0.06835220f, 
    0.27137443f, 0.10841998f, 0.07798213f, 0.24629933f, -0.00849544f, -0.00654924f, -0.16938964f, -0.02870694f, 
    0.19752292f, 0.24609764f, -0.10039496f, 0.06483012f, 0.08949284f, -0.06833491f, 0.11268791f, -0.09775123f, 
    -0.00940610f, 0.37388951f, 0.16648462f, 0.26210591f, 0.05582376f, -0.06561481f, 0.09716301f, 0.20256457f, 
    0.09032812f, -0.14547828f, -0.20538943f, -0.13322952f, -0.16213241f, 0.11636070f, 0.05235247f, 0.04073548f, 
    -0.22228183f, 0.62387127f, -0.01094156f, -0.29219109f, 0.00276651f, 0.07038359f, -0.07269944f, 0.07227784f, 
    0.27500847f, 0.13748689f, 0.15895440f, 0.15729453f, -0.22252490f, -0.10011075f, 0.22988084f, -0.14367393f, 
    -0.00979823f, -0.18285376f, -0.01486508f, 0.05645042f, -0.16668525f, -0.22882208f, -0.10329960f, -0.13555317f, 
    -0.08273708f, 0.06638967f, 0.26667580f, 0.16597535f, -0.12265093f, 0.06586266f, -0.14611498f, 0.04159509f, 
    0.16108689f, 0.05687700f, -0.05447506f, -0.18536600f, -0.25998291f, 0.33849183f, -0.06426380f, 0.11210933f, 
    -0.11555635f, -0.19177215f, -0.01889148f, -0.07374842f, 0.15298368f, 0.06314400f, 0.06355982f, 0.22798571f, 
    -0.11265433f, 0.01785840f, -0.03883124f, 0.27799961f, -0.10560513f, 0.04956095f, 0.11971004f, 0.18341231f, 
    -0.17071381f, -0.22204043f, 0.04455531f, 0.06677620f, -0.25053078f, 0.19257139f, 0.28863248f, -0.31221613f, 
    0.01103930f, 0.04317979f, 0.04147475f, 0.31276804f, 0.01003902f, -0.04269666f, -0.05353956f, 0.11310043f, 
    -0.12891264f, -0.20083703f, 0.10830632f, -0.18882960f, -0.05442370f, 0.01659985f, -0.06619905f, -0.06187591f, 
    0.02827810f, 0.01613512f, -0.05893610f, -0.09391247f, 0.14386502f, -0.40376261f, -0.26420915f, -0.16160922f, 
    0.18877131f, 0.13768786f, 0.01618713f, 0.03263563f, 0.05009588f, 0.03662228f, 0.13240571f, 0.01369858f, 
    -0.14443330f, 0.01440220f, -0.14866662f, -0.26926857f, 0.09417421f, -0.13773388f, 0.07890836f, -0.00520405f, 
    0.13903078f, 0.22024214f, 0.09738531f, 0.07363690f, -0.12088276f, -0.11163818f, -0.21131524f, -0.10413957f, 
    0.17402695f, 0.22227861f, -0.01839269f, 0.14725268f, -0.02622659f, 0.28570220f, 0.02367540f, 0.12320101f, 
    -0.02906264f, 0.47726494f, -0.19901906f, -0.35623088f, -0.09562171f, -0.01735374f, 0.01963268f, -0.14986664f, 
    -0.10559417f, 0.01145338f, -0.08938048f, 0.11514760f, -0.48490947f, -0.15379937f, 0.14334342f, 0.14432208f, 
    0.09131534f, -0.25304791f, -0.01198450f, -0.03111213f, 0.03904540f, 0.09028317f, -0.03196275f, -0.01170445f, 
    0.13650170f, 0.17558631f, -0.06708640f, 0.14504924f, 0.03046247f, 0.15426591f, -0.05334135f, 0.33334526f, 
    -0.05865170f, -0.02164399f, -0.06721991f, -0.02977226f, -0.17878312f, -0.09575742f, -0.33986709f, -0.17498782f, 
    0.05224665f, 0.06853590f, -0.00046249f, 0.01174036f, -0.04087240f, 0.23823135f, -0.09379132f, 0.11026870f, 
    0.40898421f, -0.05197849f, -0.04933373f, -0.10328262f, 0.03222356f, 0.07970546f, -0.10786784f, 0.14440827f, 
    0.16329372f, -0.10206184f, 0.16668755f, 0.03861341f, 0.08100963f, 0.09251893f, 0.28419742f, 0.17654693f, 
    -0.22430308f, 0.08606461f, -0.11062489f, 0.03345068f, 0.03547196f, 0.10461319f, -0.25973842f, 0.15099739f, 
    -0.02460989f, 0.03178209f, 0.15421492f, 0.36408156f, 0.15413947f, -0.07161833f, 0.10027617f, 0.04307089f, 
    -0.19631229f, -0.22707307f, 0.01311056f, 0.07659169f, -0.15953556f, 0.22653532f, 0.05186750f, 0.06909615f, 
    -0.06014987f, 0.00917951f, -0.09572375f, -0.04908121f, 0.01887758f, -0.02939442f, -0.07963976f, 0.02179193f, 
    0.12109674f, 0.00761917f, 0.23705928f, -0.21056557f, -0.09129059f, -0.10773284f, -0.02750692f, 0.02591256f, 
    0.02384000f, -0.04997375f, 0.01378308f, 0.04205647f, 0.41268459f, -0.33794981f, 0.04422480f, -0.06886981f, 
    -0.10596197f, -0.18562210f, -0.07713848f, -0.10263710f, 0.02174045f, 0.04250937f, 0.00168016f, 0.13980655f, 
    0.06717724f, -0.72236693f, 0.11451747f, -0.36186403f, 0.10087772f, -0.00749186f, 0.03549686f, -0.05584910f, 
    0.20181088f, 0.06565123f, -0.03032576f, 0.11494436f, 0.53272736f, 0.02238521f, 0.15792787f, 0.11667499f, 
    0.02000200f, 0.18470709f, -0.09295201f, -0.14103746f, -0.03072312f, 0.15821354f, -0.12283531f, -0.14089528f, 
    -0.20065321f, 0.17355767f, 0.06702748f, 0.45200405f, -0.35128126f, -0.14323260f, -0.09585560f, -0.01731957f, 
    -0.02034045f, -0.01337584f, -0.21966328f, -0.05091299f, 0.18376362f, 0.42249522f, 0.07409792f, 0.13458703f, 
    0.26016700f, -0.04113748f, -0.01705911f, -0.12929401f, 0.11458933f, 0.14000210f, 0.03255871f, -0.18260945f, 
    0.25637972f, -0.01933616f, -0.10170152f, 0.01249132f, -0.05861082f, 0.01703508f, 0.01985458f, 0.05120615f, 
    -0.02289422f, -0.11609171f, 0.13641015f, -0.03327101f, -0.05302386f, 0.11923577f, 0.49123821f, 0.11083264f, 
    0.23509201f, 0.04358319f, 0.20590657f, -0.07303824f, -0.09479258f, 0.11155096f, 0.06898411f, -0.08968111f, 
    -0.39514688f, -0.01939802f, -0.25105113f, 0.27764937f, -0.10400521f, 0.13162884f, 0.13412945f, 0.02417530f, 
    0.02648079f, -0.09673025f, -0.26345268f, 0.05433458f, 0.48436323f, 0.15633154f, 0.06840742f, 0.10127553f, 
    -0.44117397f, 0.08782035f, -0.23202483f, 0.10628442f, -0.09218933f, 0.07163385f, -0.10408241f, -0.11607053f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06276265f, 0.11412080f, -0.14684305f, -0.06806578f, 0.09869836f, 0.13964921f, -0.06758401f, 0.13498889f, 
    0.27938214f, -0.07066152f, 0.01662502f, -0.02575567f, 0.10305439f, 0.01518828f, -0.01984443f, 0.01737043f, 
    0.08396214f, 0.11582778f, 0.15168346f, -0.12052177f, 0.00160722f, -0.01038922f, 0.21030444f, 0.20917568f, 
    0.30753174f, 0.06029097f, -0.10177508f, -0.04500026f, 0.15392785f, 0.07064144f, 0.03130810f, 0.06315944f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.68100494f, -0.71086228f, 0.02063663f, 0.07660350f, -0.30337402f, 0.16171037f, 0.09105091f, -0.67076111f, 
    -0.23632264f, 0.06915956f, 0.22701453f, -0.21650840f, -0.21847090f, 0.09865479f, -0.75425088f, -0.07063087f, 
    -0.85121137f, 0.16381395f, 0.07415406f, 0.33272484f, 0.30736727f, 0.26822096f, -0.41389856f, -0.33977589f, 
    -0.17081523f, -0.12918103f, 0.34232557f, -0.08066587f, 0.15996134f, 0.27032495f, -0.07965012f, 0.00429366f, 
    0.26285991f, -0.36171988f, -0.99093235f, 0.04055058f, 0.54594344f, 0.08489138f, -0.08803067f, 0.01719988f, 
    0.20061575f, 0.12199146f, -0.30965611f, 0.03108230f, 0.18419977f, -0.14600864f, 0.30817631f, 0.02955041f, 
    -0.70505524f, 0.05526341f, 0.20375127f, 0.04804106f, 0.19641466f, 0.35908374f, -0.26006752f, -0.29527137f, 
    0.05560518f, -0.12982592f, -0.22459896f, -0.05517915f, 0.27853128f, 0.22718038f, -0.18804204f, 0.34604880f, 
    0.13134429f, 0.01461025f, 0.13780856f, -0.15095356f, -0.04079195f, -0.06547912f, 0.09720054f, 0.65470678f, 
    0.11468185f, -0.12910956f, 0.20031388f, -0.30807695f, -0.58063459f, -0.13905282f, -0.18710312f, -0.18081245f, 
    -0.51245362f, -0.27795687f, 0.26715499f, -0.54927671f, 0.31659871f, 0.21370301f, 0.31483090f, 0.02178040f, 
    -0.41544542f, -0.21727873f, -0.23014723f, -0.02889078f, -0.30479646f, -0.18441038f, -0.35740492f, 0.50934166f, 
    0.00417410f, -0.26804066f, 0.47268984f, 0.05116208f, -0.71454853f, -0.12099051f, -0.06626527f, 0.63667470f, 
    -0.86380357f, -0.10379542f, 0.10280202f, 0.24498050f, -0.31214485f, 0.15798080f, 0.16858970f, -0.05285886f, 
    -0.25931293f, 0.04533489f, -0.89315224f, 0.02648756f, -0.07227546f, -0.17019948f, 0.08796594f, 0.16719152f, 
    -0.48340225f, 0.10726842f, 0.09348635f, -0.10705520f, -0.58355725f, -0.29293364f, 0.25408071f, 0.06011993f, 
    0.28961548f, 0.14750750f, -0.10490590f, 0.16813749f, -0.02074727f, 0.10938238f, 0.00997350f, -0.08117197f, 
    -0.09249887f, 0.02946889f, 0.24428740f, 0.02150659f, 0.06515326f, -0.16967005f, -0.19367509f, -0.06410005f, 
    0.44748539f, -0.04907913f, 0.11955670f, 0.29775167f, 0.37083724f, -0.31714648f, 0.02194916f, -1.21222830f, 
    -0.57170284f, 0.06334570f, 0.06983256f, -0.00632206f, -0.43178129f, -0.11611084f, -0.80373555f, -0.23974220f, 
    0.13451794f, -0.34731087f, -0.52437949f, 0.11979622f, -0.50950509f, 0.17075370f, -0.13870794f, -0.41685721f, 
    -0.00196792f, -0.07574195f, 0.08413232f, -0.16337804f, -0.08652120f, 0.00342429f, -0.25560015f, -0.06549860f, 
    0.78913116f, 0.38651544f, 0.05023087f, 0.13183644f, -0.34669802f, -0.36432216f, 0.10853592f, -0.14099005f, 
    0.61624575f, 0.00112932f, -0.20081975f, -0.11176220f, 0.44240543f, -0.27996424f, 0.13768356f, -0.23589715f, 
    -0.75642979f, 0.31757110f, -0.52890998f, 0.05085945f, -0.00713615f, 0.19385760f, -0.01552092f, 0.42352894f, 
    0.23164605f, 0.14503343f, -0.23476353f, -0.54009491f, 0.22023563f, 0.06182450f, -0.73713464f, 0.14488958f, 
    0.03144230f, -0.18758884f, 0.30805689f, 0.15327300f, -0.02746268f, -0.69062442f, 0.19167838f, 0.38392931f, 
    -0.20945151f, -1.06069529f, -0.39935589f, 0.05530519f, -0.54338068f, -0.14424494f, -0.13635576f, -0.43042862f, 
    0.29637399f, 0.05484263f, 0.45311818f, 0.07115477f, -0.10926334f, -0.58519775f, -0.13380612f, 0.30153316f, 
    -0.50344795f, 0.08750308f, 0.24374872f, -0.12654343f, 0.35846153f, 0.08764241f, -0.22942571f, 0.01910154f, 
    0.08688749f, -0.37148035f, 0.14571671f, -0.26297274f, -0.03293508f, -0.51409626f, -0.31351328f, 0.04352389f, 
    -0.58951402f, -0.07443339f, 0.11655306f, -0.14984007f, 0.39023140f, -0.41090867f, 0.33851549f, -1.21530616f, 
    -0.07101957f, -0.01179204f, -0.16410896f, 0.01456934f, -0.34307435f, -1.11293697f, -0.12872903f, 0.12732074f, 
    0.16354108f, -0.09393690f, -0.77875227f, 0.22774091f, 0.00405671f, -0.10655048f, 0.00219704f, 0.13335669f, 
    -0.34982854f, 0.30557683f, -0.52490878f, -0.80281830f, -0.12014274f, -0.17752208f, -0.06315931f, 0.23196240f, 
    0.27448919f, 0.46011499f, -0.22641529f, -0.07709832f, -0.04350402f, 0.44898444f, 0.38104743f, -0.46759960f, 
    0.28875360f, 0.31864950f, 0.04801702f, -0.01323267f, -0.41112930f, -0.14569345f, 0.08904396f, -0.46410841f, 
    0.20964965f, -0.16014323f, 0.12302518f, -1.04524302f, 0.08951755f, -0.04896630f, 0.57591879f, -0.13776134f, 
    0.42504352f, -0.24691510f, -0.01703671f, 0.48759529f, -0.85254955f, 0.45605972f, -0.20230180f, 0.04836956f, 
    -0.56218052f, -0.44452131f, -0.03762266f, 0.12643056f, -0.42625105f, 0.31007305f, -0.04474810f, -0.19223163f, 
    -0.17405201f, 0.25939134f, -0.65083688f, -0.10992444f, -0.10489192f, -0.37907776f, -0.16255309f, 0.00433154f, 
    0.56423974f, -0.17411868f, 0.21723528f, 0.25813359f, -0.30486929f, 0.08061603f, 0.57935351f, -0.09785389f, 
    -0.14410180f, -0.57042438f, -0.37192619f, -0.76661789f, -0.27378175f, -0.69950765f, -0.22382212f, -0.15265322f, 
    0.48694199f, 0.30998790f, 0.52494043f, -0.12358887f, -0.00475354f, -0.87835491f, -0.07287685f, 0.18956193f, 
    -0.54942995f, 0.08776347f, 0.36522037f, 0.13173071f, 0.43424129f, -0.13651912f, 0.10049468f, -0.43923706f, 
    -0.30807209f, -0.15138857f, -0.78072196f, 0.37376294f, -0.38255545f, -0.04872690f, 0.15718086f, -0.08821820f, 
    0.43475184f, -0.39395618f, 0.06409439f, -0.14663181f, -0.77289540f, -0.35638654f, 0.28580385f, 0.26171574f, 
    0.19464129f, -0.40268996f, -0.64461344f, -0.13049993f, -0.23768789f, 0.24167253f, -0.40458429f, 0.59257549f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07311592f, 0.17212318f, 0.27200916f, 0.08434254f, -0.03493906f, 0.10605019f, -0.04109061f, 0.02418239f, 
    0.19887561f, 0.10798258f, -0.15557083f, 0.00314483f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
