#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.01590450f, 0.40734008f, 0.37070113f, 0.17921245f, 0.43203846f, 0.45473990f, -0.13130078f, -0.49049601f, 
    -0.11494848f, 0.25591919f, 0.69258142f, -0.23640196f, 0.13325700f, -0.36572555f, -0.37858525f, 0.16867061f, 
    -0.44159633f, 0.67791915f, 0.59893167f, 0.06464120f, 0.00473800f, -0.62432545f, 0.69768268f, -0.73475736f, 
    -0.20301087f, 0.22329322f, 0.48107260f, 0.39160910f, 0.04015475f, 0.06398455f, 0.41735840f, -0.64566851f, 
    0.53460813f, -0.39206004f, 0.13660550f, -0.39550877f, -0.27632290f, 0.22387084f, -0.30059722f, -0.90894711f, 
    -0.27802312f, -0.31169227f, 0.37021738f, -0.37800354f, -0.40746394f, 0.28460580f, 0.11242298f, 0.12967150f, 
    0.50695574f, 0.54858232f, 0.04086658f, 0.30599302f, 0.01321640f, -0.03981855f, 0.41802052f, 0.13806348f, 
    0.35103336f, -0.24015790f, 0.37917244f, 0.36009294f, 0.17051466f, 0.23731482f, -0.28962547f, 0.50176007f, 
    -0.75681144f, 0.73623502f, -0.12756464f, 0.04646708f, 0.10230795f, -0.14657079f, -0.01194517f, 0.43491146f, 
    -0.71946239f, 1.37777829f, -0.83969116f, 0.34024569f, -0.08315489f, -0.06390902f, 0.00795428f, 0.00522061f, 
    -0.04674760f, 0.65607840f, 0.64762002f, 0.48828119f, -0.24183983f, -0.61082631f, -0.41134241f, 0.29114720f, 
    -0.34316614f, -0.23697266f, -0.92130035f, 0.03126237f, -0.43375015f, -0.41354194f, 0.08238271f, 0.15538135f, 
    0.24205926f, 0.61281890f, -0.34154198f, -0.37013242f, 0.10211065f, -0.00269032f, -0.21329685f, -0.26271030f, 
    0.36458507f, 0.16850206f, 0.38168645f, 0.47066113f, 0.43642175f, -0.73984039f, -0.87347764f, 0.53461450f, 
    0.41841677f, 0.52251810f, -0.10976890f, 0.00894223f, -0.42159039f, -0.14381142f, 0.34110346f, -0.23682849f, 
    -0.33075297f, -0.08291827f, -0.61158442f, 0.62442636f, 0.30705854f, 0.44312733f, 0.26042476f, 0.11000984f, 
    0.13317056f, -0.65826440f, -0.35167637f, 0.52055514f, -0.00830300f, 0.02291351f, 0.53622627f, -0.70253378f, 
    -0.71627760f, -0.36087796f, -0.09671653f, 0.39850575f, -0.44890550f, 0.03501531f, -0.27129701f, 0.46945375f, 
    -0.56756222f, -0.25805360f, -0.25948375f, -0.10427976f, -0.29731295f, -0.52214754f, -0.34652269f, -0.04027846f, 
    -0.20343672f, -0.05177077f, 0.36542040f, -0.61910212f, 0.25879431f, -0.45952913f, -0.34311512f, -0.32552248f, 
    0.48898262f, -0.52177429f, 0.37069422f, -0.21299207f, -0.05833675f, -0.24056472f, -0.18524866f, 0.02827328f, 
    0.51685768f, 0.41700140f, -0.13831176f, -0.39316010f, 0.26044956f, 0.66910410f, -0.08145019f, 0.18061599f, 
    -0.03479622f, -0.04533989f, -0.43848899f, 0.00838878f, -0.23239717f, 0.32567072f, 0.22046530f, 0.37768394f, 
    0.30093580f, -0.22353728f, 0.15198186f, 0.22785330f, 0.51044142f, -0.27432081f, 0.04227963f, 0.84459031f, 
    0.50746661f, -0.60277241f, -0.31709042f, 0.07935438f, -0.13327819f, 0.26218894f, 0.35937536f, -0.02274137f, 
    -0.21010400f, 0.27730447f, -0.34327635f, 0.03386308f, 0.23194869f, -0.48780835f, -0.15561576f, 0.10884210f, 
    -0.66631281f, -0.82402831f, 0.16938992f, -0.17238194f, 0.28249770f, 0.19681033f, -0.00434611f, 0.39163929f, 
    -0.29448631f, -0.25963393f, 0.05139948f, 0.06552354f, 0.72139037f, 0.68586415f, -0.31073657f, 0.25043759f, 
    0.06162510f, -0.26098222f, -0.14350861f, 0.24726744f, -0.49823391f, -0.55680746f, -0.72937578f, 0.48639071f, 
    -0.20350650f, 0.30211994f, -0.73967242f, -0.39050782f, -0.05843016f, 0.63873243f, -0.28065276f, -0.54279441f, 
    0.35228735f, 0.16022144f, 0.12417033f, -0.67141205f, -0.05020250f, -0.35465705f, 0.83380973f, -0.06348167f, 
    -0.01755268f, -0.44250384f, -0.32094932f, -0.40953922f, 0.51425374f, -0.61932838f, -0.36441299f, -0.64399898f, 
    -0.25943905f, -0.57177520f, -0.22686876f, 0.57279408f, -0.18468675f, 0.47886661f, -0.42370218f, -0.33716083f, 
    0.03865843f, -0.64504492f, -0.18760997f, -0.20658119f, -0.49290287f, 0.45632076f, -0.12847890f, 0.31578046f, 
    -0.60963869f, -0.63577491f, 0.52955019f, 0.15719998f, -0.58147901f, 0.65380782f, 0.02984894f, 0.01656959f, 
    -0.44676644f, -0.35843018f, -0.04466166f, 1.01727331f, -0.27038249f, 0.43925151f, -0.49876010f, -0.32855359f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.26215401f, -0.14688355f, -0.01190970f, -0.09329864f, -0.21331155f, 0.02066188f, -0.09005211f, -0.03166576f, 
    0.02790091f, -0.02056333f, -0.11626186f, 0.20717463f, 0.06379317f, -0.28752950f, 0.19606259f, -0.20733464f, 
    -0.54979688f, 0.21047258f, 0.11985695f, 0.20110933f, 0.10828862f, 0.11476828f, 0.26051196f, 0.28337029f, 
    -0.07979385f, 0.24370000f, 0.08136352f, -0.30906501f, -0.16371606f, -0.10479149f, -0.07393417f, -0.04361076f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.07434230f, 0.04237147f, 0.00307409f, -0.04373595f, -0.13916431f, -0.10224711f, -0.00238278f, -0.06287642f, 
    0.25254279f, -0.14094800f, 0.03160912f, -0.03288016f, 0.05176748f, -0.00552770f, -0.26950303f, 0.09826882f, 
    -0.04155429f, -0.07132477f, -0.23141518f, 0.04128535f, -0.31784219f, 0.16061355f, 0.01301014f, 0.02532888f, 
    -0.09725690f, -0.01908980f, -0.01864655f, -0.21053421f, -0.09201372f, 0.07019027f, -0.04018776f, -0.06496117f, 
    -0.29363751f, 0.18886305f, 0.16049029f, -0.00378896f, 0.07330029f, -0.03175461f, 0.19716057f, -0.07234196f, 
    0.04710000f, -0.21072657f, 0.08014334f, 0.02928896f, 0.14377522f, 0.04375207f, 0.22940075f, 0.18316278f, 
    -0.19488403f, -0.17138343f, -0.10054649f, 0.11036340f, 0.00756821f, 0.07064453f, -0.05530144f, 0.10278747f, 
    -0.02921051f, 0.10564534f, 0.03997406f, 0.00598585f, 0.21358395f, 0.01923006f, -0.03332568f, -0.21418451f, 
    -0.24955870f, -0.11254338f, 0.07225912f, 0.01895332f, 0.26877302f, 0.18867245f, -0.11326613f, -0.04403275f, 
    -0.35363066f, -0.34563187f, -0.09716822f, -0.03115203f, 0.14949723f, 0.12115389f, -0.04274473f, 0.01519488f, 
    0.11829992f, 0.01754091f, -0.43573341f, -0.04625324f, 0.14220834f, 0.07328619f, -0.14137731f, -0.02143057f, 
    -0.14052680f, -0.02538894f, -0.01401691f, 0.18388218f, 0.17072703f, -0.06978955f, -0.11423449f, -0.01745676f, 
    0.00300696f, -0.04046128f, -0.01522583f, 0.04385987f, 0.18346509f, 0.00502956f, -0.01607629f, -0.04408300f, 
    0.06219916f, 0.21060245f, -0.05788634f, 0.01983231f, 0.08085005f, -0.04352858f, 0.01774450f, -0.07250135f, 
    -0.09310166f, -0.02816950f, 0.09724847f, 0.07568169f, 0.08659808f, 0.14165877f, -0.03546414f, -0.03935790f, 
    0.02118028f, 0.07670330f, 0.02133542f, 0.12665848f, 0.08545187f, -0.00959565f, -0.15820159f, -0.12147944f, 
    -0.08129089f, 0.18134621f, 0.05621765f, -0.02737969f, -0.06935365f, 0.04973011f, -0.01972726f, 0.19917390f, 
    0.19709876f, 0.04917326f, -0.06760578f, -0.15343097f, -0.19565135f, -0.08965479f, -0.02305515f, -0.03420725f, 
    -0.04677383f, 0.14064355f, -0.02235045f, -0.02402586f, -0.09990938f, -0.05229738f, 0.10582015f, 0.17791100f, 
    0.13994148f, -0.08279866f, -0.05054142f, -0.06334122f, 0.01278243f, 0.11793999f, 0.00446685f, -0.01759557f, 
    0.04851717f, -0.13702074f, 0.01188465f, 0.06282061f, -0.12403906f, 0.12739260f, 0.07590684f, 0.10311290f, 
    0.21642756f, 0.08976962f, 0.02141295f, -0.31752527f, -0.28699830f, -0.09463882f, 0.18403722f, -0.01566208f, 
    -0.03260401f, -0.03642352f, 0.02727898f, 0.28200886f, -0.02611914f, 0.05945889f, -0.04051927f, -0.18741551f, 
    0.05178485f, -0.13312888f, 0.10126493f, 0.01168192f, 0.10031536f, -0.25895476f, -0.40858603f, 0.07055399f, 
    -0.04549027f, 0.02996261f, 0.15593734f, 0.12123244f, -0.06790173f, -0.00687969f, -0.07997220f, -0.07158635f, 
    -0.01029982f, 0.09413642f, 0.07484383f, 0.12182634f, 0.17289229f, -0.02769063f, 0.06146960f, 0.19509372f, 
    0.20314036f, 0.06019444f, -0.13749525f, -0.11624498f, -0.06148614f, 0.07785309f, -0.02414641f, 0.10388010f, 
    0.16096467f, 0.25750184f, 0.01393142f, -0.33512607f, -0.35736895f, -0.34025338f, 0.20035237f, -0.04221031f, 
    0.06232915f, 0.14571530f, 0.09821818f, 0.14339153f, 0.00595162f, -0.01848805f, -0.10045945f, 0.03356237f, 
    -0.08337690f, 0.08429218f, 0.04767941f, 0.04127063f, 0.00655565f, 0.07014406f, -0.07789293f, -0.18211247f, 
    -0.06930555f, 0.07190317f, 0.09798636f, -0.22952971f, -0.15334785f, 0.11425302f, -0.10348862f, 0.02661396f, 
    0.01114243f, 0.04622785f, 0.01635498f, 0.04530546f, 0.11601987f, 0.18877578f, 0.04800519f, -0.05854962f, 
    -0.14000624f, -0.06720615f, 0.00573382f, 0.01783765f, -0.05174074f, 0.01536712f, 0.14600314f, -0.10347195f, 
    -0.07846683f, -0.01920562f, 0.12459671f, 0.08982389f, -0.11916159f, 0.02920567f, -0.20016080f, 0.23196788f, 
    -0.30814973f, -0.13691024f, -0.03034648f, 0.04046150f, 0.05873754f, 0.01825820f, -0.13440299f, -0.00545216f, 
    0.06081652f, 0.32200477f, -0.16650699f, -0.23604827f, 0.04755364f, -0.01575179f, -0.04638238f, 0.18172078f, 
    -0.06169122f, 0.01641668f, -0.11038172f, -0.09127682f, -0.22288808f, -0.06560165f, -0.00402558f, 0.02133977f, 
    0.01896641f, 0.21211365f, -0.28104275f, 0.16337411f, 0.11029646f, -0.00988303f, 0.07275507f, -0.08927964f, 
    -0.04698825f, 0.03652360f, -0.36314222f, -0.39876056f, 0.32111934f, -0.00031344f, -0.07259003f, -0.27501866f, 
    -0.13663402f, 0.10155582f, -0.04077764f, -0.05937096f, -0.01945837f, 0.02347502f, 0.06842677f, 0.02092511f, 
    -0.11258132f, 0.13785546f, -0.16598241f, 0.23652440f, -0.57323706f, -0.44965234f, -0.36392447f, -0.00783509f, 
    0.01095845f, -0.00610146f, 0.01967077f, -0.13342221f, -0.03839867f, -0.03668505f, 0.03091219f, 0.11032802f, 
    -0.12359840f, -0.03080913f, -0.06970687f, 0.03861309f, 0.06065353f, 0.08849183f, 0.03955971f, 0.00462704f, 
    -0.02924408f, -0.05899949f, -0.11573721f, -0.12798160f, -0.01812737f, -0.00464652f, 0.16737382f, 0.29473409f, 
    -0.06373316f, -0.02325047f, 0.02687499f, -0.07344867f, 0.02382710f, -0.15600394f, -0.06009316f, 0.13870496f, 
    0.46936792f, -0.19136156f, -0.25208303f, -0.08525566f, -0.10768308f, 0.11629082f, 0.09790242f, 0.06848341f, 
    0.14981033f, 0.02951000f, -0.04038633f, -0.14294191f, 0.04674610f, 0.11445228f, -0.06624641f, -0.03945954f, 
    -0.00175219f, -0.09640809f, 0.05725535f, 0.12559251f, 0.42732438f, -0.10091870f, 0.04342011f, 0.01516881f, 
    -0.08427631f, 0.03974071f, -0.11121948f, -0.01434143f, 0.00342268f, 0.00167817f, -0.13560760f, -0.07226815f, 
    0.07351477f, -0.00328595f, 0.12046762f, 0.07869705f, -0.16650523f, 0.21293816f, 0.25148571f, 0.01757492f, 
    -0.04315034f, -0.02674814f, 0.03785039f, 0.07944795f, 0.09805251f, -0.41049230f, -0.75107980f, -0.23782621f, 
    -0.11108245f, 0.00757181f, -0.04354650f, -0.05904311f, 0.06453989f, -0.17247814f, -0.06769467f, -0.11315503f, 
    0.04815489f, -0.01760715f, 0.03391631f, -0.13129888f, 0.04755876f, 0.13368459f, 0.17524365f, -0.34121031f, 
    0.22904147f, 0.34191006f, -0.04670242f, 0.05244821f, -0.05412123f, -0.01417839f, -0.00277779f, 0.03854132f, 
    -0.25625238f, -0.17854363f, -0.34270388f, -0.20169818f, -0.15662846f, -0.12281380f, -0.06070905f, -0.15398385f, 
    -0.05763020f, 0.20475306f, -0.13541169f, 0.27267781f, -0.02150397f, -0.04091176f, 0.00407764f, 0.03559104f, 
    0.03182836f, 0.26979959f, 0.00288542f, 0.05783398f, -0.12426896f, -0.02120917f, 0.12300686f, -0.10004462f, 
    -0.01792844f, -0.00340678f, 0.03961850f, 0.28588954f, 0.10170319f, -0.01613122f, 0.07376711f, -0.08255779f, 
    -0.00887355f, 0.06475686f, -0.04099766f, 0.08296771f, 0.01518905f, 0.05015533f, -0.07666729f, -0.14017743f, 
    -0.28284752f, -0.03742311f, -0.05963372f, 0.09866551f, 0.03597675f, 0.29066211f, -0.16498762f, -0.02874286f, 
    0.15366252f, -0.08210103f, -0.11318813f, 0.21279538f, 0.06273451f, 0.05304893f, 0.02105856f, 0.18550703f, 
    0.09027677f, 0.15377814f, 0.02278247f, 0.04364974f, 0.23191328f, 0.08732264f, 0.12693474f, -0.03511087f, 
    0.19017856f, -0.01363424f, -0.00665139f, 0.13899744f, 0.00098234f, 0.02299139f, 0.01601150f, 0.06025652f, 
    -0.01777174f, 0.06585604f, -0.02791022f, -0.06679464f, 0.08568497f, 0.17276274f, 0.02171705f, 0.07160427f, 
    0.06661534f, -0.36916986f, -0.35875306f, -0.09163319f, 0.10981862f, -0.02717908f, -0.09826392f, 0.03966634f, 
    0.01165030f, 0.04407719f, -0.14497931f, 0.19467989f, 0.35349220f, 0.05191363f, -0.00060816f, 0.02274604f, 
    0.03129394f, 0.03631169f, 0.05394855f, -0.28243348f, -0.08876504f, 0.10433922f, -0.10393567f, -0.12463347f, 
    -0.02492451f, 0.09827292f, 0.20378630f, -0.01473657f, -0.55445886f, -0.39977115f, -0.28574499f, 0.07278096f, 
    -0.03127234f, -0.18611556f, -0.14677766f, -0.05973070f, 0.00714531f, -0.46911341f, 0.02397167f, -0.01997814f, 
    0.00318220f, -0.07160915f, 0.00653278f, 0.02612503f, -0.11390643f, 0.05907397f, 0.12855667f, -0.17309563f, 
    0.16623271f, 0.08270708f, 0.05442428f, 0.06319104f, -0.04136405f, 0.05452701f, 0.02135909f, -0.41911674f, 
    -0.01210758f, 0.25339216f, -0.00497371f, 0.09853345f, -0.10712446f, 0.08654927f, 0.03623844f, 0.09672952f, 
    0.14300124f, 0.12683636f, 0.10174408f, 0.06306458f, 0.07108989f, -0.14372490f, -0.12824075f, -0.20119143f, 
    -0.02823910f, 0.04528704f, 0.39546716f, 0.02806639f, 0.10878828f, -0.05190020f, -0.10441437f, 0.08754275f, 
    0.14422928f, 0.00333417f, -0.01154122f, 0.54707688f, 0.08857173f, 0.10385102f, -0.06838517f, 0.01563401f, 
    0.12970933f, 0.08521798f, -0.06842873f, 0.08300382f, 0.04492770f, 0.12431620f, -0.09478688f, 0.15725499f, 
    0.09529116f, -0.05599543f, 0.08414710f, -0.09471899f, -0.42853883f, -0.30021831f, 0.33425450f, -0.07098744f, 
    -0.13361594f, -0.14541307f, 0.07461777f, 0.02895941f, 0.11235468f, 0.14878358f, 0.19334325f, 0.08086380f, 
    -0.24525373f, -0.28516883f, -0.28521168f, 0.02058752f, -0.05587497f, 0.00005009f, 0.06254388f, 0.21999040f, 
    0.11422092f, -0.06569354f, 0.03946078f, -0.04665370f, 0.05036623f, -0.02897461f, 0.07406928f, 0.03083694f, 
    -0.07400781f, 0.07589474f, -0.11043168f, 0.04911983f, -0.16859309f, 0.17191781f, -0.02820369f, 0.09430404f, 
    0.07669139f, -0.09308827f, -0.23575301f, 0.09085190f, 0.23937473f, 0.13754050f, -0.04895592f, 0.00779370f, 
    0.04318668f, 0.11759403f, 0.11176774f, 0.03670914f, -0.01550563f, -0.01468435f, -0.05183384f, 0.03215452f, 
    0.03526416f, 0.04533514f, 0.06429632f, -0.50951827f, -0.64649379f, -0.12161486f, 0.00572642f, -0.17520826f, 
    0.10512968f, -0.09267592f, 0.03928997f, -0.04364125f, -0.20765154f, -0.03395756f, 0.04124202f, 0.04948371f, 
    -0.04387553f, 0.08314808f, -0.00424736f, -0.06019941f, -0.10973436f, -0.25766984f, -0.08905792f, -0.09035534f, 
    0.14107440f, 0.03167328f, 0.02536172f, -0.06703041f, 0.03198751f, -0.16820273f, 0.27193397f, 0.44382790f, 
    0.02248905f, 0.05997532f, 0.04185564f, 0.03031224f, -0.02410381f, 0.02996572f, -0.13184372f, 0.05817672f, 
    0.14557460f, 0.08000079f, -0.07933973f, -0.02709379f, 0.02658447f, 0.04008662f, 0.04066704f, -0.19862731f, 
    -0.27893180f, -0.43694320f, -0.12810978f, -0.03495095f, 0.01785817f, 0.05549376f, -0.01056418f, -0.05827872f, 
    0.19013125f, 0.35318309f, -0.47990736f, -0.07073133f, -0.21057512f, -0.12013835f, 0.12276468f, 0.03851879f, 
    0.09032281f, -0.14817385f, 0.29040003f, -0.09765665f, 0.03640062f, 0.10601816f, -0.13603763f, -0.02623044f, 
    -0.11462276f, 0.05893811f, -0.13668174f, 0.14469871f, 0.09397158f, 0.10089096f, 0.05273870f, 0.00764593f, 
    -0.03021055f, 0.08745650f, 0.08813213f, 0.13296883f, 0.02315934f, 0.05076913f, 0.11116102f, -0.06103047f, 
    0.05622872f, -0.02118983f, -0.21928181f, 0.08844588f, 0.30161455f, 0.06605559f, 0.07107211f, -0.07352575f, 
    -0.03103664f, 0.03161782f, 0.01906309f, -0.00321722f, 0.04854501f, 0.04826651f, 0.05973295f, -0.03755501f, 
    0.03599434f, -0.12621504f, 0.02320744f, 0.23299681f, 0.00033426f, -0.02124225f, 0.02948697f, 0.03800433f, 
    -0.04962838f, 0.05194546f, 0.16136087f, 0.12311480f, 0.07865309f, -0.20037912f, -0.01119393f, -0.62894046f, 
    -0.32262611f, -0.48391420f, -0.00325070f, 0.07541609f, -0.01897902f, 0.05204500f, -0.02571701f, -0.04519362f, 
    0.21332349f, -0.11433510f, -0.07367709f, -0.25810382f, -0.09036227f, -0.26143083f, -0.03914481f, -0.06261151f, 
    -0.06713216f, -0.08665647f, 0.29945740f, 0.47064298f, 0.04843524f, 0.09380405f, 0.03584444f, 0.08774265f, 
    0.08209881f, -0.05795016f, -0.01423617f, 0.25996634f, -0.59322006f, 0.12792271f, -0.01979213f, 0.09845240f, 
    0.17398000f, 0.03972839f, -0.04370887f, -0.31296515f, -0.04610331f, -0.14425467f, -0.04631240f, -0.14700347f, 
    0.07286206f, -0.06491560f, -0.03457494f, -0.07094908f, 0.31006536f, -0.15571924f, 0.13579370f, -0.08941223f, 
    0.05454731f, 0.04197081f, 0.13786194f, -0.13640757f, 0.04915692f, -0.22412863f, 0.18071160f, -0.24737063f, 
    -0.06657857f, 0.02571147f, -0.00788970f, -0.01816479f, -0.02146985f, -0.05574144f, -0.24495761f, -0.41742176f, 
    -0.01721521f, 0.08715655f, 0.08932638f, -0.13004075f, 0.04688074f, -0.06333248f, 0.05094281f, -0.20137367f, 
    0.20922528f, -0.22746195f, -0.03413344f, -0.05925488f, 0.11506064f, 0.05845056f, -0.22656360f, 0.17033106f, 
    -0.29501584f, -0.10903291f, -0.31229031f, 0.20481496f, -0.21295613f, -0.13233419f, 0.04406377f, 0.05767500f, 
    0.00818393f, -0.06825253f, 0.06589294f, -0.10839597f, -0.13602334f, -0.23613419f, 0.25343996f, 0.04545780f, 
    0.23929259f, -0.02934481f, 0.01294199f, -0.05248978f, 0.04806488f, -0.09871405f, -0.11298480f, 0.10890348f, 
    0.07313156f, -0.02584628f, 0.11909138f, 0.41220134f, 0.17922072f, 0.05406240f, -0.07614167f, 0.18778768f, 
    -0.08591578f, -0.02376710f, 0.02297689f, -0.05857930f, 0.02216997f, 0.12326700f, 0.15293817f, -0.03851368f, 
    -0.10796984f, -0.21692470f, -0.06157584f, -0.02868974f, 0.08231596f, 0.06715208f, -0.73758161f, -0.43479165f, 
    -0.07400125f, 0.01780470f, -0.03077577f, 0.00673121f, 0.04976979f, -0.02152738f, -0.04150213f, -0.23204368f, 
    -0.14670561f, -0.00201361f, 0.00681584f, -0.09841899f, -0.09280547f, 0.00096317f, -0.05184301f, 0.16592057f, 
    -0.07115558f, -0.10534798f, 0.02035817f, 0.30039212f, -0.08792070f, 0.16143608f, -0.02311551f, -0.01905094f, 
    -0.31875625f, 0.08702777f, -0.12996532f, 0.02183373f, -0.16203123f, 0.02153531f, -0.03831787f, -0.04640906f, 
    -0.02535167f, -0.59066600f, 0.28747299f, -0.11921841f, -0.09199462f, -0.16213951f, 0.10945563f, 0.03366196f, 
    0.01310331f, 0.10283536f, 0.04193428f, -0.13706131f, -0.08486907f, 0.20078506f, 0.09688752f, -0.02663982f, 
    0.04350302f, 0.05490145f, 0.01635345f, -0.06361137f, -0.11714116f, 0.25659031f, 0.02676638f, -0.00004619f, 
    -0.03570018f, 0.02496898f, 0.05069494f, 0.05379864f, 0.57899320f, -0.17006068f, -0.32900408f, -0.10110798f, 
    0.01055942f, 0.14918762f, 0.05633413f, 0.03318311f, -0.03718716f, 0.10557459f, 0.17403923f, 0.14202574f, 
    -0.11469077f, -0.13723508f, 0.00642998f, -0.06372862f, 0.01343117f, 0.02621032f, 0.14407182f, 0.16541520f, 
    0.11885965f, -0.02708161f, -0.09893848f, -0.05607918f, 0.07606325f, 0.09290463f, -0.03873296f, 0.28465292f, 
    0.16619228f, -0.02483907f, 0.10255138f, 0.08783492f, 0.28217247f, -0.00877337f, 0.11837191f, -0.02030652f, 
    0.40518862f, 0.25951308f, -0.04482931f, -0.00463630f, 0.09220159f, 0.30479255f, 0.06958314f, -0.13971472f, 
    -0.12161034f, 0.05504335f, 0.13157682f, -0.09711906f, -0.02056513f, -0.00319940f, -0.04479484f, -0.06638721f, 
    -0.08735936f, 0.05336335f, -0.07347807f, -0.01908783f, 0.00890162f, -0.05954807f, 0.03620382f, -0.08166783f, 
    -0.13111222f, 0.11542633f, -0.06366065f, -0.24849275f, -0.06450505f, 0.07222977f, -0.08048578f, -0.14140335f, 
    -0.14445329f, 0.01112230f, 0.21797794f, -0.01434284f, 0.07273076f, -0.53021985f, -0.06810557f, 0.01602910f, 
    -0.11987188f, -0.12984699f, 0.03936287f, 0.07070945f, -0.04149212f, -0.18554322f, 0.22211699f, -0.15787174f, 
    -0.19558449f, 0.07208277f, -0.03263803f, -0.01905203f, -0.01432538f, -0.00807073f, 0.07838728f, 0.02793287f, 
    0.06636675f, -0.08554026f, 0.03615543f, -0.02765998f, -0.15531959f, 0.11541929f, -0.09712222f, 0.16907415f, 
    0.14143899f, -0.17629844f, -0.00868095f, 0.01585926f, 0.04805198f, -0.01671204f, -0.04014774f, 0.06769197f, 
    -0.51349765f, -0.49764973f, -0.08110454f, 0.07549997f, -0.27424616f, -0.20200326f, 0.14922459f, 0.18555576f, 
    0.08301897f, 0.03638741f, 0.19522987f, 0.04919946f, -0.19293006f, -0.13376349f, -0.11204402f, -0.11415589f, 
    0.07232469f, 0.03257852f, 0.22681762f, 0.16506137f, 0.01296360f, -0.06219978f, 0.09866752f, 0.02362901f, 
    -0.02931009f, -0.03776013f, 0.15154976f, 0.32869586f, 0.40366638f, 0.02658985f, -0.01854429f, 0.07468534f, 
    0.13914241f, 0.01302467f, 0.12192357f, -0.12160136f, 0.21363311f, 0.17504328f, 0.00823670f, -0.02463507f, 
    -0.14779970f, -0.01648440f, -0.01423381f, -0.01130117f, -0.01884022f, 0.14184411f, 0.14403982f, 0.02581725f, 
    -0.00209737f, -0.01881327f, -0.03387609f, 0.10475197f, 0.00748914f, -0.11428888f, -0.04960253f, -0.16487880f, 
    -0.16172707f, 0.10006693f, -0.08254651f, 0.13284422f, 0.02196228f, 0.10711788f, -0.11061095f, 0.13278651f, 
    -0.25990397f, -0.11385075f, -0.01894020f, 0.12102992f, 0.02575409f, -0.10581809f, 0.10903036f, 0.07817619f, 
    -0.18248187f, -0.13758649f, -0.01105668f, -0.08630079f, -0.06717126f, -0.14852874f, 0.11894648f, 0.01689608f, 
    -0.13607922f, -0.10417779f, 0.28962320f, -0.17502528f, -0.01999157f, -0.05571032f, 0.26911983f, 0.11992107f, 
    0.11680438f, 0.06203613f, 0.17110871f, -0.06161417f, 0.05881955f, 0.08995677f, -0.05413342f, 0.11292563f, 
    0.09590776f, 0.15072295f, 0.10765371f, -0.08975033f, 0.25748226f, 0.23254260f, -0.13404943f, -0.23317970f, 
    -0.08129670f, 0.11883146f, -0.02969471f, 0.15321903f, -0.04467500f, -0.22751628f, -0.16172719f, -0.25504023f, 
    0.14884661f, 0.06595057f, -0.02090149f, -0.02475254f, -0.09327050f, -0.04217869f, -0.12819187f, -0.06300532f, 
    0.04125733f, 0.03838505f, -0.05098571f, 0.13989180f, 0.10550378f, 0.03293649f, 0.01628309f, 0.12861937f, 
    0.08523812f, -0.08167849f, -0.07528643f, -0.11935373f, -0.06612607f, 0.15698852f, 0.07092819f, 0.28920576f, 
    0.07264332f, -0.15449226f, -0.13487178f, 0.13516000f, 0.05840394f, 0.08890154f, 0.06279074f, -0.04240346f, 
    -0.08592325f, -0.20309916f, 0.02781871f, 0.10562661f, -0.08157492f, 0.29671016f, 0.08048835f, -0.11085987f, 
    -0.07572013f, -0.11943808f, 0.10909882f, -0.00261192f, -0.05215860f, -0.18730189f, -0.24590017f, -0.07397347f, 
    0.01968980f, -0.05036773f, -0.08446184f, -0.13696434f, -0.14084506f, 0.00487646f, 0.06791812f, -0.09293867f, 
    -0.09680806f, -0.02757777f, 0.03355252f, -0.11639052f, 0.00047320f, -0.17822921f, 0.14994843f, 0.00593322f, 
    0.11274190f, 0.26432255f, 0.22517869f, 0.04751290f, 0.05853934f, -0.06562953f, -0.13045272f, 0.13424429f, 
    0.01007532f, 0.06330981f, -0.26288000f, 0.00698830f, 0.01617730f, -0.18045314f, -0.16403110f, -0.13922998f, 
    -0.06390157f, 0.04604032f, 0.04811382f, 0.11894499f, 0.15085413f, -0.00806611f, 0.15365469f, 0.26441425f, 
    -0.16079693f, 0.07150140f, 0.03088853f, 0.03917354f, 0.12144449f, 0.18936081f, 0.15807836f, -0.05462968f, 
    -0.02623121f, 0.11152859f, -0.06958862f, -0.07603591f, -0.18516971f, -0.03299072f, 0.13769098f, -0.01521637f, 
    -0.05144923f, -0.11372484f, 0.04815329f, -0.03440554f, -0.14455405f, -0.17027411f, -0.00748793f, 0.15593898f, 
    0.01455979f, 0.00040201f, 0.10236827f, 0.24296646f, 0.04345649f, -0.09375704f, -0.03148121f, 0.09498956f, 
    -0.03750295f, 0.15792866f, 0.04366407f, 0.00581978f, -0.04751695f, -0.02451790f, 0.11182039f, -0.09968387f, 
    0.02208900f, -0.05285989f, 0.19344236f, -0.00819217f, -0.04394358f, 0.25066140f, -0.00744271f, 0.03803837f, 
    -0.03436599f, 0.08432710f, 0.13354507f, 0.10168973f, -0.11631539f, -0.04988800f, -0.08256219f, 0.09500138f, 
    0.03611274f, -0.08609860f, 0.07011906f, 0.16300024f, 0.03785079f, -0.09529160f, -0.00079279f, 0.26633114f, 
    -0.13799104f, -0.01127639f, -0.08061570f, -0.00227962f, 0.23422758f, -0.00542690f, 0.01062909f, -0.02408155f, 
    0.10571841f, -0.05241482f, 0.03601236f, 0.00071094f, -0.04141573f, 0.05431191f, 0.05626728f, -0.18601137f, 
    0.04159536f, -0.04648482f, 0.03239181f, 0.08828977f, 0.08172932f, 0.10980440f, 0.12581684f, -0.06058260f, 
    -0.29124027f, -0.36293581f, -0.09404813f, 0.13494274f, 0.06313774f, 0.00723862f, -0.07924430f, -0.14466885f, 
    0.11385965f, -0.07363223f, -0.20913731f, 0.15722463f, -0.11899150f, 0.01088045f, -0.08179162f, 0.04650490f, 
    0.15677261f, 0.08131425f, -0.14807275f, 0.04892875f, 0.28872293f, -0.00439218f, -0.03408666f, -0.09612402f, 
    -0.30593976f, 0.23324391f, -0.04889307f, -0.07273363f, -0.08148294f, 0.01629004f, -0.00699912f, 0.07056936f, 
    -0.08410148f, -0.09005093f, -0.14214221f, 0.07166149f, 0.01679339f, -0.22671165f, -0.00870831f, -0.15135168f, 
    0.09716932f, -0.04001664f, 0.07785371f, -0.02557243f, 0.17594260f, -0.06984816f, 0.00415990f, -0.15719514f, 
    -0.21545795f, 0.05161021f, 0.09362792f, 0.08883983f, 0.02379564f, 0.01361794f, 0.10241684f, -0.19183755f, 
    0.29461113f, 0.01697599f, -0.01431606f, -0.12055237f, 0.06065091f, 0.05977842f, 0.29360408f, -0.05166003f, 
    -0.13375509f, 0.18579450f, 0.14940952f, 0.05210938f, -0.05477621f, -0.11614540f, -0.03413112f, 0.05710021f, 
    -0.02740444f, 0.10137719f, -0.12850210f, -0.06288394f, -0.01731133f, -0.08155029f, 0.01708649f, -0.00964009f, 
    0.10598260f, 0.37324536f, -0.22587039f, 0.05550199f, -0.03901694f, -0.09942524f, 0.13559131f, 0.10714349f, 
    -0.11968753f, -0.09325294f, 0.29827765f, -0.20569868f, -0.07439873f, 0.18939330f, -0.01425288f, -0.07329781f, 
    0.00138283f, 0.02309285f, -0.08507119f, -0.07335915f, -0.00756760f, 0.06511895f, 0.01336350f, -0.05054375f, 
    0.07554151f, -0.02770402f, -0.17019127f, 0.00449902f, -0.27756456f, 0.04869771f, -0.21686751f, -0.14119330f, 
    0.07332434f, -0.12446793f, 0.06223792f, 0.02448047f, 0.10464130f, 0.00373480f, 0.14041133f, 0.04418060f, 
    0.02178826f, 0.07742652f, 0.13766377f, -0.01818476f, -0.03790037f, -0.01084702f, 0.25401756f, 0.04660918f, 
    -0.16214834f, -0.06488198f, 0.08456450f, -0.03987770f, -0.00211500f, -0.12009897f, -0.02769354f, 0.25820529f, 
    0.10784470f, -0.14765042f, 0.02379991f, 0.00427586f, 0.07036988f, -0.04613052f, -0.02217170f, 0.00487529f, 
    -0.09529623f, -0.16081746f, -0.13667881f, 0.18933196f, -0.03176339f, 0.18437037f, 0.19895643f, -0.02671121f, 
    0.02917211f, 0.19361654f, -0.44266555f, -0.08082099f, -0.07139349f, 0.09066864f, -0.06579090f, 0.07827637f, 
    -0.08135079f, 0.05267346f, -0.47707370f, -0.05560192f, 0.29895422f, -0.16903618f, 0.10008597f, -0.04389664f, 
    0.05601198f, -0.04286251f, -0.04750024f, -0.05776117f, 0.02555595f, -0.02712883f, -0.16263530f, 0.04575261f, 
    0.02716756f, 0.07680524f, 0.01476287f, 0.15226789f, -0.21384716f, 0.11071239f, 0.23064996f, -0.05387621f, 
    0.09572469f, 0.07749418f, 0.07006156f, 0.05932774f, 0.17274109f, -0.12907968f, -0.25383735f, -0.39361450f, 
    -0.31463659f, 0.03023178f, -0.16151182f, -0.02327961f, -0.07712624f, 0.02185839f, 0.49179196f, 0.09115247f, 
    -0.13873032f, 0.00552016f, -0.05536865f, 0.21943896f, 0.04858521f, 0.00689173f, 0.13821144f, -0.22207893f, 
    0.01068524f, 0.40596747f, 0.17694269f, 0.05849386f, -0.09950990f, -0.02343243f, 0.03703383f, -0.00810921f, 
    -0.09041337f, -0.17492543f, -0.07880442f, -0.13769352f, -0.07680470f, -0.23728250f, -0.01454537f, -0.08233581f, 
    -0.01223861f, -0.03256724f, -0.14254256f, -0.14314450f, 0.15478441f, -0.08903722f, -0.15049511f, 0.07524287f, 
    0.04896941f, 0.05445599f, 0.29584309f, 0.11916137f, -0.05933664f, 0.01862916f, 0.11658138f, 0.06442699f, 
    -0.01519219f, -0.05181799f, 0.10062351f, 0.01833849f, 0.01331309f, -0.07093152f, -0.02009800f, 0.10735092f, 
    -0.07351365f, -0.02786733f, 0.04349068f, 0.16477522f, 0.00359213f, -0.05586760f, -0.05123103f, -0.04136733f, 
    0.01240030f, -0.01271544f, 0.03743012f, 0.02814154f, 0.01182974f, -0.05595722f, -0.08407899f, 0.23199220f, 
    0.03174848f, 0.10108821f, -0.05686623f, 0.20434710f, 0.10602048f, 0.01267348f, -0.03913111f, -0.00132233f, 
    0.14243867f, 0.01421609f, 0.12338912f, -0.02404071f, 0.12314794f, 0.01266381f, 0.19457568f, -0.29463542f, 
    0.38166085f, 0.16489629f, 0.02804434f, 0.12267590f, -0.02571874f, 0.02177639f, 0.07340448f, 0.02520230f, 
    -0.09546601f, -0.02057820f, -0.08321653f, -0.01706875f, 0.13217327f, 0.04393824f, 0.13501541f, 0.05687431f, 
    -0.03188941f, -0.24819058f, -0.19264221f, -0.09683334f, -0.06197613f, 0.03238748f, -0.07735097f, 0.18027914f, 
    0.07534847f, 0.10670452f, -0.50413048f, -0.02200648f, 0.25686076f, -0.12559357f, 0.05938373f, -0.07693537f, 
    0.02482616f, 0.08971044f, 0.00862098f, -0.02254265f, 0.01216623f, 0.04979878f, -0.08552306f, -0.10815709f, 
    0.00680004f, -0.02738069f, -0.08039951f, 0.01978293f, -0.09778598f, -0.08387891f, -0.36868763f, 0.05567347f, 
    -0.00515890f, -0.08152518f, -0.08421246f, -0.06455646f, -0.05189499f, -0.06694132f, 0.02815270f, 0.02267716f, 
    0.11909223f, -0.11082936f, -0.19707103f, 0.08684708f, -0.09516907f, 0.04796517f, -0.16002777f, -0.04364711f, 
    0.01105495f, 0.04806155f, -0.01346433f, 0.02118952f, -0.16714954f, 0.02304947f, -0.05882542f, -0.10055737f, 
    -0.03408341f, 0.17973097f, 0.06785925f, -0.00431647f, 0.00433238f, 0.06572314f, -0.07912374f, 0.24877669f, 
    -0.00575943f, -0.04631705f, 0.02102721f, 0.04544571f, 0.03494158f, -0.01041865f, -0.06505951f, 0.04192476f, 
    -0.04748643f, -0.03163901f, 0.02292673f, -0.02557220f, -0.00654939f, 0.00449290f, 0.01942176f, 0.00104704f, 
    0.01350103f, 0.04780339f, -0.01981120f, -0.03281801f, 0.03495362f, -0.06283977f, -0.04329843f, 0.01702071f, 
    -0.06584644f, -0.04159361f, 0.03721953f, 0.03476436f, -0.05438662f, -0.01272643f, -0.05293461f, -0.06745345f, 
    0.02890790f, 0.01149792f, -0.03840312f, 0.04222162f, 0.00875619f, -0.01236916f, -0.02558639f, -0.03371266f, 
    -0.04225158f, -0.04046323f, 0.03073768f, 0.04168741f, -0.03853853f, 0.01316979f, -0.03487105f, -0.05552566f, 
    -0.06673231f, 0.04702019f, -0.00895263f, 0.02756794f, -0.00413507f, 0.00524576f, -0.04386183f, 0.03261373f, 
    -0.04994832f, 0.04235720f, -0.00714415f, -0.02416305f, -0.00350696f, 0.03932177f, 0.03654249f, 0.03145488f, 
    -0.03960947f, 0.03336760f, 0.04621712f, -0.03580200f, -0.03562002f, 0.04500228f, 0.01741289f, -0.05015656f, 
    -0.04759299f, -0.05974610f, 0.01870557f, -0.00740237f, -0.00644534f, -0.04501525f, -0.02210279f, -0.01816058f, 
    -0.01085113f, 0.04981452f, 0.02436044f, 0.00447853f, -0.05311918f, 0.00903110f, 0.00307263f, 0.04148485f, 
    -0.01658786f, 0.00483425f, 0.02050356f, -0.01828037f, 0.04608804f, -0.06655607f, 0.00544334f, -0.02100127f, 
    -0.03099440f, -0.01431143f, -0.05182419f, -0.06234944f, -0.01279245f, -0.01726819f, 0.03954276f, 0.00313549f, 
    -0.06136626f, -0.00787703f, 0.04583331f, -0.02436528f, -0.02907234f, -0.06455916f, -0.04938884f, -0.06113551f, 
    0.03659183f, -0.04097175f, -0.00311184f, -0.03172112f, 0.03131130f, 0.04801657f, -0.00979714f, 0.03447351f, 
    0.00631764f, -0.04798960f, 0.04056056f, -0.01028688f, -0.03525256f, -0.03067490f, -0.03615990f, -0.02309473f, 
    0.00044486f, -0.04155857f, 0.01901744f, -0.04571284f, 0.04773461f, -0.01548736f, 0.01336985f, 0.04356381f, 
    -0.02417425f, -0.03403584f, -0.04541884f, 0.04977323f, -0.03438115f, 0.01604716f, -0.01426004f, 0.04994434f, 
    -0.00049261f, -0.02803903f, -0.02136336f, -0.04588178f, 0.02591117f, -0.04382345f, 0.02564068f, -0.04314295f, 
    -0.01426787f, -0.06391659f, 0.01379729f, 0.05074153f, 0.02217855f, -0.00003841f, 0.01097461f, -0.05007178f, 
    -0.02415062f, -0.03708414f, 0.00176571f, 0.01906290f, -0.02181468f, 0.00718366f, 0.03600468f, -0.01394027f, 
    0.03800337f, 0.03400993f, 0.02373234f, -0.00245793f, 0.00965769f, 0.02059317f, 0.03658315f, -0.04486357f, 
    -0.00241311f, 0.01978783f, -0.02248292f, -0.05735947f, -0.06055095f, -0.05749162f, 0.00111207f, -0.02428060f, 
    -0.03452576f, -0.04062961f, -0.05209782f, -0.00250846f, -0.03377901f, 0.02481413f, -0.06533580f, 0.01638952f, 
    -0.05611376f, -0.05933345f, 0.01270285f, -0.01141379f, 0.03863562f, -0.05945133f, -0.03762646f, -0.02990825f, 
    -0.04056811f, 0.02959206f, -0.05387773f, 0.04747578f, 0.02387230f, 0.00640124f, -0.02147875f, -0.02324549f, 
    0.00674550f, -0.01511221f, -0.02591129f, -0.04878334f, -0.00753635f, 0.02306135f, -0.05839423f, -0.02915159f, 
    0.03567513f, 0.04890313f, -0.05477070f, -0.06297357f, -0.00816295f, 0.01328963f, 0.05247675f, 0.01529448f, 
    -0.01093499f, -0.00495545f, -0.00710297f, 0.04303253f, 0.01398835f, 0.00233079f, -0.06206472f, 0.01671062f, 
    0.02096373f, -0.06242856f, -0.03214502f, 0.00944391f, -0.01922090f, -0.01603610f, -0.03763525f, 0.02282307f, 
    -0.01447895f, -0.05150752f, 0.00950630f, 0.03255360f, -0.02019911f, -0.03161325f, -0.06633172f, -0.01928365f, 
    -0.05389488f, -0.03246672f, 0.02426380f, 0.03695405f, -0.03680609f, 0.00915857f, -0.05313884f, -0.02206080f, 
    0.02924159f, -0.04884006f, 0.03302496f, 0.04891196f, 0.03043629f, -0.05143448f, -0.06037376f, -0.05071935f, 
    -0.00282777f, -0.04176637f, 0.05060802f, -0.03314440f, 0.04480831f, -0.01394274f, 0.03426394f, -0.06519841f, 
    -0.01351590f, -0.00738593f, -0.03308962f, 0.01712134f, 0.03066396f, 0.01875747f, 0.03446163f, -0.00596670f, 
    -0.00659140f, -0.03667951f, -0.00924403f, -0.04624567f, 0.03547247f, -0.06061752f, 0.00340418f, -0.04331813f, 
    -0.18980464f, -0.23702303f, 0.03493911f, 0.07859917f, 0.04819572f, 0.04840028f, -0.02329154f, 0.06833201f, 
    0.09109655f, -0.20345742f, -0.11121827f, -0.14802985f, -0.00335209f, 0.16608766f, -0.03515046f, 0.17125079f, 
    0.25108600f, -0.18481207f, -0.37269521f, 0.40898025f, -0.30312550f, 0.03230620f, 0.08689494f, 0.13650151f, 
    0.07769337f, 0.01694735f, -0.09933782f, -0.23120260f, -0.18135357f, -0.13755342f, 0.03989887f, 0.12416822f, 
    0.02581006f, 0.09649749f, -0.05652736f, 0.14572342f, 0.02144605f, -0.11268449f, 0.10272807f, 0.11572603f, 
    -0.01672384f, 0.11557525f, -0.16969728f, 0.10489926f, -0.05231730f, -0.11868219f, 0.06959184f, -0.02443186f, 
    -0.09438122f, 0.00894298f, -0.00611351f, 0.07084747f, 0.00550272f, 0.27967089f, -0.21436842f, -0.06372709f, 
    -0.00152757f, 0.04444746f, 0.04143891f, -0.11918758f, -0.05647109f, 0.11552281f, 0.28568369f, -0.07369615f, 
    -0.25822923f, -0.51666856f, 0.02315460f, 0.04769549f, -0.16628325f, 0.07029366f, 0.24123059f, -0.11656646f, 
    -0.01320505f, -0.07405524f, 0.08260190f, -0.00547266f, 0.09195186f, -0.04374948f, -0.02910057f, -0.12895301f, 
    0.02979644f, -0.44289091f, -0.05281517f, 0.06919515f, 0.17788409f, -0.17530209f, 0.04122235f, 0.11354805f, 
    -0.01631239f, 0.02557881f, 0.32380557f, -0.26054379f, -0.05017592f, 0.07410250f, -0.02346743f, 0.03066326f, 
    -0.06132737f, -0.02030952f, 0.03912812f, 0.16013125f, -0.20286857f, -0.12459767f, -0.11838201f, 0.02844488f, 
    -0.02606690f, 0.14917982f, 0.22391084f, 0.03663194f, 0.05647648f, -0.02336943f, 0.01147670f, -0.01349565f, 
    0.04340127f, 0.09513118f, -0.05231966f, 0.01223853f, 0.14744106f, 0.15526950f, 0.09009462f, -0.08289848f, 
    0.01429693f, 0.03379932f, 0.12050053f, -0.04059779f, -0.14134248f, -0.17865941f, -0.09278794f, -0.01534643f, 
    -0.16843636f, 0.05123080f, -0.00910298f, -0.05914227f, 0.23687091f, 0.23931925f, 0.01206223f, 0.05510459f, 
    -0.19277033f, 0.07431392f, 0.10756467f, 0.08005899f, -0.13800725f, 0.07105268f, -0.06176103f, 0.00194672f, 
    0.08208844f, 0.00232410f, 0.08421192f, -0.07405171f, -0.06170480f, -0.14451936f, 0.04103582f, -0.04288558f, 
    0.01426735f, 0.00806651f, 0.04685383f, 0.19209594f, -0.03900445f, -0.02665900f, 0.06224357f, 0.22570004f, 
    -0.04222379f, 0.15654118f, -0.08992989f, -0.06001780f, -0.12809791f, 0.09986830f, -0.07900114f, 0.08614956f, 
    0.23299333f, -0.03507628f, -0.01518272f, 0.31964687f, 0.11077914f, 0.09252165f, 0.05273978f, -0.06086143f, 
    -0.16141896f, -0.01472181f, 0.00892698f, 0.00885869f, 0.04735243f, -0.11319100f, 0.03435251f, -0.03728218f, 
    0.00510766f, 0.02692765f, 0.08979487f, 0.05477951f, -0.02819162f, 0.23559561f, -0.12251408f, -0.03021076f, 
    -0.09327372f, 0.06436191f, 0.00888608f, 0.20168371f, 0.08891299f, -0.22450666f, -0.05094000f, 0.07719064f, 
    -0.07234070f, -0.06378514f, -0.07691627f, -0.03424999f, 0.21423762f, 0.13773443f, 0.14071836f, -0.04712970f, 
    -0.10070272f, 0.18241897f, 0.09172876f, 0.10558775f, 0.03059631f, -0.04184825f, 0.07799406f, 0.02064380f, 
    0.08075725f, -0.18355173f, -0.12518719f, 0.17233959f, 0.11131287f, 0.00283726f, -0.13180089f, -0.10243807f, 
    0.10595459f, 0.13799880f, -0.07895939f, 0.06007588f, 0.17914893f, 0.09665792f, 0.18334527f, -0.02917007f, 
    0.09662560f, -0.15664917f, -0.04545324f, -0.00462597f, -0.12274136f, 0.08827482f, -0.01048868f, -0.00489088f, 
    0.21321958f, -0.00600813f, 0.06542657f, 0.10700677f, 0.05416803f, -0.23600693f, 0.06308034f, 0.06867825f, 
    0.08459139f, 0.14685777f, -0.08062150f, -0.09185441f, -0.01729322f, -0.05983864f, 0.11364185f, -0.02767635f, 
    0.06036150f, -0.01235874f, 0.20056093f, -0.08950057f, -0.13127759f, -0.02559870f, 0.03153172f, 0.12151258f, 
    -0.10341909f, 0.09502312f, -0.18648463f, 0.11591835f, -0.05013138f, -0.01203074f, 0.16723023f, -0.23692231f, 
    0.08882128f, -0.16564235f, -0.21883148f, 0.02679597f, 0.05486562f, 0.08231229f, 0.13301528f, -0.05856315f, 
    0.10458266f, 0.17830457f, 0.01804478f, -0.02149704f, 0.02393307f, 0.04993299f, -0.10497191f, -0.01259038f, 
    -0.00905819f, 0.10465556f, 0.06546379f, -0.24200718f, -0.08417349f, -0.16496761f, 0.15664826f, 0.06269917f, 
    0.05843937f, 0.30731675f, -0.13342752f, 0.18852556f, 0.09026007f, -0.03648134f, 0.17912272f, 0.03923995f, 
    -0.01789810f, -0.00234662f, 0.24264295f, 0.02921463f, 0.15321398f, 0.07989215f, 0.05302535f, 0.05946454f, 
    0.13460265f, 0.09589368f, 0.03069589f, -0.04943810f, -0.06124844f, 0.33554626f, 0.02551396f, -0.01479176f, 
    -0.05546943f, 0.05765881f, 0.03491157f, 0.03030013f, -0.10977522f, -0.40157035f, -0.35538578f, -0.02609736f, 
    -0.01735412f, 0.02180286f, 0.02388436f, 0.04744483f, -0.00455970f, 0.01118200f, 0.06625662f, 0.20147862f, 
    0.08651306f, -0.10731067f, 0.01388605f, 0.04040387f, -0.07566713f, -0.06867234f, 0.07982217f, 0.14367522f, 
    0.10445046f, 0.02224530f, -0.16219509f, 0.02404907f, 0.04365308f, -0.16842403f, -0.12787734f, 0.09434403f, 
    0.28145573f, -0.04216779f, -0.05326995f, 0.10422633f, 0.31364790f, -0.00569260f, 0.03302789f, -0.23418477f, 
    -0.29107958f, 0.02395446f, 0.01450936f, 0.01564630f, -0.10588060f, 0.10059783f, 0.17999277f, 0.04313053f, 
    0.02154104f, 0.33320281f, -0.33048910f, -0.20832647f, 0.03312127f, 0.09255902f, 0.02237867f, 0.13814329f, 
    -0.16887520f, -0.02132689f, -0.32070088f, 0.12755804f, 0.25606096f, -0.10044761f, 0.12240528f, -0.04020424f, 
    0.05292023f, -0.08668206f, 0.11647537f, -0.12001669f, 0.18746600f, 0.13664559f, -0.01710495f, 0.03609121f, 
    -0.03807687f, -0.08151289f, 0.00653030f, 0.01867622f, -0.05689904f, -0.12523007f, -0.24479596f, -0.04589321f, 
    0.06309985f, -0.11112849f, 0.15383692f, 0.06845921f, -0.05472969f, -0.01460839f, -0.18642259f, -0.14515498f, 
    -0.02659063f, 0.11973304f, 0.05968497f, 0.00577908f, -0.14909600f, -0.19162457f, 0.42399806f, 0.15653509f, 
    -0.04324042f, -0.07484934f, 0.08446482f, 0.21240978f, 0.02236613f, 0.09422398f, -0.14073671f, -0.11125416f, 
    0.09834815f, 0.02846267f, 0.05175831f, 0.10493401f, -0.10493495f, 0.00590763f, -0.07370644f, -0.12287374f, 
    0.03192559f, 0.20276557f, -0.14082476f, -0.00895282f, 0.02211161f, 0.01745449f, -0.03934333f, -0.02197052f, 
    0.10788321f, -0.09272942f, -0.17249070f, -0.34537518f, 0.08858268f, -0.00608720f, 0.01963488f, 0.04706177f, 
    -0.05388950f, 0.10351072f, 0.31382534f, -0.05533873f, 0.10444965f, 0.13043989f, 0.09958422f, 0.02104730f, 
    0.00021123f, 0.04953081f, -0.08809989f, -0.01006541f, 0.04688143f, 0.00421535f, -0.13227333f, 0.07929143f, 
    -0.04961925f, 0.04792411f, 0.12451871f, 0.38431376f, -0.12124053f, 0.10203097f, -0.01532553f, -0.03693922f, 
    0.06183935f, 0.13463379f, -0.03975742f, -0.07232232f, -0.02451815f, -0.16308592f, -0.11251767f, 0.08743557f, 
    0.02719956f, 0.22040871f, 0.05933254f, 0.07374901f, -0.01827612f, 0.03257618f, 0.08537631f, -0.01232009f, 
    0.22023702f, 0.05893546f, 0.07777186f, -0.05374904f, -0.01929893f, -0.16562031f, 0.07728431f, -0.13928972f, 
    0.27561766f, 0.00143099f, -0.01241420f, 0.00135250f, -0.12025452f, -0.01690574f, 0.01265397f, -0.05803639f, 
    -0.07876860f, 0.02381507f, 0.05510557f, 0.01691259f, 0.01496530f, -0.03889850f, -0.00150438f, 0.03016774f, 
    -0.10338172f, -0.42481285f, -0.50101131f, -0.36304769f, 0.06573652f, 0.04502527f, -0.07425757f, 0.02244226f, 
    -0.12295368f, -0.10222502f, -0.40696993f, -0.05237984f, -0.00021493f, 0.01059093f, -0.10146766f, 0.01594780f, 
    0.03465110f, -0.08912750f, 0.01338315f, 0.19676113f, -0.04040237f, -0.09748667f, 0.11071436f, -0.01737634f, 
    0.02482813f, 0.16822152f, 0.03139025f, -0.00007050f, -0.40279442f, -0.09611621f, -0.47804976f, -0.07721607f, 
    0.04603259f, -0.11352608f, 0.08945560f, 0.06228797f, 0.01296948f, -0.19792914f, -0.32662132f, -0.22132164f, 
    0.03279499f, 0.04743054f, -0.10936416f, 0.08265648f, 0.01630383f, -0.04895004f, -0.05801931f, 0.26984718f, 
    -0.04013994f, 0.06790628f, 0.07233322f, 0.05236347f, 0.17034897f, 0.08071148f, 0.04758343f, -0.34543037f, 
    -0.17605254f, -0.25632173f, -0.05870475f, 0.25714630f, -0.24228102f, 0.29697278f, -0.07176042f, 0.06825881f, 
    0.24277894f, 0.06419982f, -0.30766866f, -0.10579077f, -0.25119388f, -0.13815887f, -0.03746330f, -0.14578193f, 
    0.12983643f, 0.41755015f, -0.30779859f, -0.33024272f, 0.04879509f, -0.08699241f, -0.06820400f, -0.07814008f, 
    0.02472469f, 0.08827410f, -0.11452818f, -0.33025447f, -0.07731448f, -0.02189943f, -0.03422790f, -0.06326550f, 
    -0.09913312f, -0.08901958f, 0.02168278f, -0.00343907f, 0.20854081f, -0.17746949f, -0.20313752f, -0.28717190f, 
    -0.14558458f, 0.14597644f, -0.16053188f, 0.07741208f, -0.04851424f, 0.20689812f, 0.16746822f, -0.05382468f, 
    -0.09373806f, 0.06308591f, 0.09989338f, -0.01570750f, 0.00411223f, -0.02334170f, 0.01442293f, -0.53649026f, 
    -0.13568997f, -0.11331143f, -0.15750675f, 0.03646598f, -0.01039673f, 0.10245547f, 0.20522200f, -0.17213586f, 
    -0.33689249f, 0.16113955f, -0.09272645f, -0.08255243f, 0.00947279f, 0.13260870f, -0.06975415f, -0.23041171f, 
    0.06649933f, -0.25371948f, 0.07852060f, 0.05453196f, 0.10776248f, 0.13909118f, 0.01299205f, 0.03995687f, 
    0.02506011f, 0.03888500f, -0.77901548f, -0.08648137f, -0.16075024f, 0.06129938f, 0.05501050f, 0.00259445f, 
    -0.02602384f, 0.24540584f, -0.22047859f, -0.25587079f, -0.10826467f, 0.06846938f, 0.10360944f, 0.00962664f, 
    -0.01668111f, 0.04048006f, -0.18445365f, 0.01954601f, 0.14043857f, -0.20149006f, -0.03906405f, 0.17293032f, 
    0.04624190f, 0.07765853f, 0.08626550f, -0.05330868f, 0.02300506f, 0.14785814f, 0.06354213f, 0.05342509f, 
    -0.05986748f, 0.01256954f, -0.05652286f, -0.07507941f, 0.02899176f, -0.45529801f, -0.20613477f, 0.00524266f, 
    0.06152409f, 0.04269422f, 0.19751750f, -0.01877056f, -0.03474714f, 0.14077285f, 0.09451412f, 0.02394541f, 
    0.04916624f, -0.03118869f, -0.00830392f, 0.09595654f, 0.00474216f, -0.17023079f, -0.10508993f, -0.24103658f, 
    -0.15375835f, -0.00517694f, -0.00839110f, -0.14238390f, -0.04072082f, 0.01900966f, 0.00867952f, -0.05115416f, 
    0.07047942f, 0.18971652f, -0.11749679f, 0.08660492f, 0.18596216f, 0.05049251f, -0.10762963f, 0.11662234f, 
    0.03627232f, 0.10155160f, 0.34808674f, -0.25571159f, -0.04136782f, 0.01313771f, 0.26639578f, 0.05819017f, 
    0.11055645f, -0.13451345f, 0.11199708f, -0.03678548f, -0.06260008f, 0.12529390f, -0.00335461f, 0.06132414f, 
    0.06262787f, -0.05958986f, 0.17934799f, -0.11780664f, -0.08231683f, 0.00612472f, 0.00341198f, 0.03181735f, 
    -0.00060833f, 0.02076431f, 0.10632324f, -0.36764312f, -0.40858275f, -0.13378187f, 0.01102047f, -0.18441361f, 
    0.04440494f, 0.09920280f, -0.05063792f, 0.09730901f, -0.07718970f, -0.04185678f, -0.31072780f, 0.17902520f, 
    0.05025753f, 0.06986584f, 0.12755640f, 0.03516582f, 0.10178136f, -0.35427865f, -0.38670617f, -0.33687648f, 
    0.02461846f, -0.05887632f, 0.18016458f, 0.00978943f, 0.04780487f, -0.00312707f, 0.17857400f, 0.13062067f, 
    -0.06055957f, 0.10978600f, 0.15833566f, 0.16098319f, 0.10902475f, -0.02298706f, 0.00128598f, 0.12147189f, 
    0.02479152f, 0.01946234f, 0.06418245f, 0.18045902f, 0.03743515f, -0.00052179f, 0.01672652f, 0.01624884f, 
    -0.20746395f, -0.27438903f, -0.40246668f, -0.11323631f, -0.03189059f, 0.03307875f, -0.00429449f, 0.18106656f, 
    0.13496231f, -0.01174814f, 0.24492222f, 0.13585243f, -0.04681361f, -0.01530337f, -0.10343040f, 0.03297521f, 
    0.03302053f, 0.00301113f, 0.16087256f, 0.13835549f, 0.22581103f, -0.08359946f, -0.01451908f, -0.04566641f, 
    0.05063454f, -0.02160365f, 0.06335033f, -0.17518581f, 0.02736524f, 0.20935261f, -0.14031033f, 0.03249108f, 
    -0.03803265f, 0.28268158f, 0.02434210f, -0.02042290f, 0.09046553f, 0.19583452f, 0.16453741f, -0.01285553f, 
    0.04110165f, -0.02322651f, 0.13270831f, 0.01286985f, -0.02934313f, 0.21148542f, 0.27645752f, 0.22467573f, 
    -0.04693247f, 0.10782857f, -0.06792584f, -0.00030784f, -0.02861962f, 0.04445858f, -0.48508337f, -0.06889394f, 
    -0.21495232f, 0.21652563f, 0.27574429f, 0.10394007f, -0.02265010f, 0.11439040f, -0.01387549f, 0.06303642f, 
    -0.26936954f, 0.03608391f, -0.00754036f, -0.07417375f, 0.06961694f, 0.19997123f, 0.07300480f, 0.06230426f, 
    0.01219745f, 0.00409925f, 0.00969644f, -0.04089899f, -0.05161801f, -0.00397200f, -0.00204219f, -0.05682954f, 
    -0.05584019f, -0.04670804f, -0.03812110f, 0.04335650f, -0.01064155f, 0.03473315f, 0.00538765f, -0.03563140f, 
    0.00657774f, 0.00738018f, -0.05598806f, -0.02899385f, -0.01532632f, -0.00945204f, -0.04219706f, -0.02155847f, 
    0.04495944f, 0.02491719f, -0.01011494f, -0.00326006f, -0.04891033f, -0.03644152f, 0.01763187f, -0.04379066f, 
    0.03809676f, 0.00485450f, -0.04752034f, 0.02169794f, 0.03425511f, -0.05188025f, -0.04561446f, -0.05173483f, 
    -0.00862017f, 0.02266626f, 0.02663224f, -0.01849891f, -0.03970296f, -0.00272407f, 0.01026125f, -0.02062379f, 
    0.02328407f, 0.00627182f, -0.02219171f, -0.05901056f, 0.04112603f, 0.03325479f, -0.00901665f, -0.00542990f, 
    0.02791567f, -0.01325953f, -0.01850699f, -0.02876848f, -0.03015486f, 0.05161685f, -0.01571476f, 0.04224864f, 
    0.04619786f, 0.03214101f, 0.02136031f, 0.02256489f, -0.00920417f, 0.00192075f, -0.05154383f, -0.02942523f, 
    0.04773389f, -0.00778641f, -0.02706372f, -0.00856601f, 0.03085289f, 0.02803341f, 0.02761001f, -0.01923667f, 
    0.01392334f, 0.04269727f, -0.05987786f, 0.02532338f, 0.01813424f, 0.02669956f, -0.04811468f, -0.01485233f, 
    -0.03246300f, -0.01262475f, -0.04849119f, 0.01113067f, -0.04409157f, -0.05757752f, 0.00902279f, -0.00193991f, 
    -0.04289443f, -0.04783046f, -0.01754736f, -0.01530238f, -0.06108124f, 0.05518985f, 0.01596706f, -0.04314951f, 
    0.02926395f, -0.00934678f, 0.04277162f, -0.01832770f, -0.03114096f, -0.05859891f, -0.05592666f, 0.00836306f, 
    -0.00885531f, 0.00820334f, 0.02722801f, -0.05816865f, -0.05687219f, -0.04594714f, -0.03568418f, -0.02284336f, 
    -0.00805991f, 0.00415192f, 0.02624924f, 0.02903678f, 0.00094178f, -0.06213934f, 0.00880358f, 0.00515987f, 
    -0.01042189f, -0.02448922f, -0.02181341f, 0.00284880f, 0.01549986f, 0.04153766f, 0.02687303f, -0.00289719f, 
    -0.03336219f, 0.02665436f, 0.01668074f, 0.01134357f, -0.02622924f, -0.05002499f, -0.00587080f, -0.01554270f, 
    -0.03676002f, 0.02635768f, -0.04741003f, -0.03556936f, -0.02791279f, -0.04800149f, 0.04172850f, -0.03434195f, 
    0.02054706f, -0.04915336f, 0.04847490f, 0.01341782f, -0.02760218f, -0.03990064f, 0.05061057f, 0.01542473f, 
    0.00394131f, 0.03631123f, 0.01845122f, 0.03288498f, 0.02177214f, 0.05020071f, -0.04783522f, -0.04980817f, 
    -0.05859024f, -0.04034561f, -0.04785847f, -0.03838899f, 0.03366470f, 0.04107055f, 0.04246085f, 0.03977501f, 
    -0.05800397f, 0.00295763f, -0.04521118f, 0.03174508f, -0.00793726f, -0.03994730f, -0.05343986f, -0.00701125f, 
    0.01473607f, -0.02339090f, 0.01549932f, 0.01048780f, -0.03650049f, 0.02476824f, -0.00074443f, 0.05350099f, 
    0.04004854f, -0.02209139f, -0.02474743f, -0.01809413f, 0.00791658f, -0.02022684f, -0.02582910f, 0.03143783f, 
    -0.01497256f, 0.04276363f, -0.03071434f, -0.01628508f, 0.01179981f, 0.00699346f, 0.00865834f, 0.03419796f, 
    0.05505821f, -0.00708678f, 0.04109361f, 0.02256427f, -0.03149205f, 0.04585611f, -0.06024187f, -0.05213150f, 
    -0.02743060f, -0.04014527f, 0.03052574f, 0.04507379f, -0.06488959f, -0.00776279f, -0.00412393f, 0.01303084f, 
    -0.03145209f, -0.02221542f, -0.06045334f, -0.04951484f, 0.02355672f, -0.00947898f, 0.03827768f, -0.03212614f, 
    -0.00976773f, -0.04751857f, 0.00843150f, 0.03425297f, 0.03335345f, -0.04376069f, 0.01449795f, -0.05737239f, 
    0.00201495f, -0.04381955f, 0.01235493f, -0.04874029f, -0.04761541f, 0.04006138f, 0.05842543f, -0.02959724f, 
    -0.05470264f, 0.00648406f, -0.05748231f, -0.04757988f, -0.01782054f, -0.01577506f, -0.05045336f, -0.04181627f, 
    0.04000679f, 0.01676762f, -0.00405283f, -0.01900744f, 0.01266177f, -0.04048686f, -0.05447415f, 0.04414278f, 
    -0.01613958f, -0.05378444f, 0.00266314f, 0.01187516f, -0.03908093f, -0.02708153f, 0.03898114f, -0.05104631f, 
    0.04152133f, -0.03996856f, -0.06295137f, -0.05190906f, -0.05806087f, -0.04278255f, 0.03817540f, 0.00841916f, 
    -0.04957339f, 0.05220740f, -0.03050429f, -0.04673337f, -0.01167778f, 0.04748165f, 0.00974972f, 0.03177911f, 
    -0.13801317f, -0.03468270f, 0.05382502f, 0.04679838f, 0.17647053f, 0.02715775f, 0.16056171f, -0.03234287f, 
    -0.10879000f, 0.08433729f, 0.02168683f, -0.06051210f, 0.06031359f, 0.08581019f, 0.06534621f, 0.08020474f, 
    0.13558121f, -0.25114855f, 0.08002416f, 0.20195182f, 0.04429667f, 0.20734736f, 0.05620513f, 0.04078979f, 
    0.12497814f, -0.02507490f, 0.00558386f, 0.06000789f, 0.13791516f, -0.11183722f, 0.07982873f, 0.07816735f, 
    0.14701442f, 0.23014714f, 0.20022331f, 0.04343378f, 0.07289016f, 0.00760970f, 0.08134759f, 0.11155404f, 
    0.03250036f, 0.02706967f, 0.08797043f, 0.05619835f, 0.09101287f, -0.08503990f, 0.05111188f, 0.03744529f, 
    0.02638107f, 0.06548104f, 0.10060900f, -0.12011755f, 0.02908341f, -0.01257474f, 0.16664636f, 0.00941166f, 
    -0.08725782f, 0.06106558f, -0.00790404f, -0.02044422f, 0.05669693f, -0.17589110f, 0.00371101f, 0.08831427f, 
    -0.03345914f, -0.01514335f, 0.07695127f, -0.02105502f, -0.02524239f, 0.06862722f, -0.00808060f, -0.17214078f, 
    0.05230704f, 0.10375149f, 0.03980994f, 0.12143521f, 0.12121894f, -0.11656107f, -0.11374503f, 0.08536513f, 
    0.13786358f, 0.03022435f, 0.45880312f, 0.08104811f, 0.02382096f, 0.01799328f, 0.04525268f, 0.11480770f, 
    0.09893925f, -0.06014141f, -0.06721402f, 0.04346022f, -0.16347665f, 0.14724001f, 0.20229496f, -0.08201928f, 
    0.13616560f, -0.00967763f, 0.11220125f, -0.13948922f, -0.00769695f, -0.02492586f, 0.03659022f, 0.04084437f, 
    -0.10315035f, -0.29229173f, -0.27129316f, -0.28998980f, -0.20538685f, 0.08756619f, 0.16665825f, -0.08174697f, 
    0.07425036f, 0.15666670f, 0.16164352f, 0.23827824f, 0.14648330f, 0.04778137f, -0.00984084f, -0.05262651f, 
    0.14389417f, -0.03662466f, -0.21712266f, -0.23102921f, -0.34017077f, -0.40417379f, 0.10605197f, 0.17645369f, 
    -0.02783995f, 0.02263629f, 0.01830400f, -0.28623214f, -0.01577139f, -0.05448328f, -0.21780646f, 0.02337498f, 
    0.03603823f, -0.08449920f, 0.08093003f, 0.07463165f, 0.10627389f, 0.03828087f, -0.02308816f, -0.06926183f, 
    0.15618390f, -0.01150496f, -0.01727059f, 0.07552527f, -0.10396119f, 0.12479965f, -0.13639653f, -0.00620381f, 
    0.03776552f, 0.15013318f, -0.03786308f, 0.04538486f, 0.04087324f, -0.01628753f, -0.14370640f, 0.08225574f, 
    0.04926638f, 0.09323917f, -0.01766854f, 0.02454620f, -0.01539348f, 0.02879265f, 0.01646054f, -0.03463911f, 
    -0.15804009f, -0.12571906f, -0.22499433f, 0.23139247f, -0.04719256f, -0.05005026f, 0.00693202f, 0.13634263f, 
    0.06954131f, 0.12831560f, -0.02251906f, -0.08309494f, -0.02283311f, -0.04190674f, 0.04977719f, 0.02667943f, 
    0.01745643f, 0.04185820f, -0.11354990f, -0.13525584f, -0.46539447f, 0.32465664f, 0.05288211f, -0.00447138f, 
    0.05874948f, -0.08876770f, 0.22350684f, 0.04585287f, 0.14291242f, -0.17840235f, -0.07157268f, -0.00788208f, 
    -0.00581682f, 0.02596896f, -0.02755785f, 0.06055904f, 0.01903580f, 0.19126046f, 0.01726125f, 0.06122029f, 
    0.02923973f, 0.07345471f, 0.01813006f, -0.05112338f, -0.13703375f, -0.03534169f, -0.00131400f, -0.12262159f, 
    -0.09187722f, 0.04920193f, 0.07282560f, 0.05259928f, 0.07969826f, 0.05597203f, -0.16285205f, -0.29042169f, 
    -0.10332420f, 0.11841710f, -0.08159026f, -0.13504669f, 0.18971065f, 0.09761177f, 0.01230354f, -0.07235247f, 
    -0.06652331f, -0.15417762f, 0.01231409f, -0.15626827f, -0.11859695f, 0.09594990f, -0.09629954f, 0.19594648f, 
    0.16607425f, 0.04732873f, -0.01737053f, 0.08532379f, -0.01331937f, -0.06316749f, 0.02930608f, 0.03084343f, 
    0.04891956f, 0.09483352f, 0.29157257f, 0.25414246f, -0.14252268f, -0.04855628f, 0.02706142f, 0.13145661f, 
    -0.02346591f, -0.01398964f, 0.04251991f, 0.03165300f, 0.00079342f, -0.03690439f, -0.02918942f, 0.20620437f, 
    0.13354360f, 0.07214737f, 0.05738909f, -0.07437748f, 0.03850332f, -0.14934793f, -0.20281833f, 0.03430889f, 
    0.08764995f, 0.02883762f, 0.10742916f, -0.08851632f, -0.09185001f, 0.13512173f, 0.07638220f, 0.07602180f, 
    0.08325181f, 0.02284232f, -0.14564125f, 0.11934029f, -0.00152948f, 0.01377657f, 0.08332802f, 0.19796102f, 
    0.02142534f, -0.02587544f, -0.04824394f, -0.04231769f, -0.04045987f, -0.01917696f, 0.09788283f, -0.09320664f, 
    -0.17630473f, 0.19139767f, 0.17210200f, -0.26682180f, -0.00062333f, 0.05097265f, 0.12287254f, 0.01886917f, 
    -0.11859525f, 0.09999251f, -0.09166064f, -0.03537522f, 0.08302469f, -0.07122010f, 0.07182888f, -0.02684430f, 
    0.19532830f, 0.13662876f, 0.07141621f, -0.00389696f, -0.16364767f, 0.00411839f, -0.00000637f, -0.14953591f, 
    -0.00112648f, -0.04173455f, -0.05839942f, -0.05037508f, 0.01460378f, 0.29548115f, 0.04076387f, -0.00454302f, 
    -0.11157919f, -0.00951954f, -0.00295146f, -0.15179598f, -0.13098469f, -0.02537295f, -0.08258263f, 0.01088562f, 
    -0.21281010f, -0.23209591f, -0.25083590f, 0.07438628f, 0.06674411f, -0.09213161f, 0.00347308f, 0.03854457f, 
    0.01898463f, 0.03585114f, 0.04131303f, 0.00134176f, -0.07494258f, 0.17110787f, -0.07813763f, -0.14036056f, 
    0.13795142f, 0.18002313f, 0.00797280f, 0.01055641f, -0.00380428f, -0.00779850f, 0.17460044f, 0.10366557f, 
    0.19960922f, 0.12650533f, -0.33125782f, -0.17725523f, -0.18465818f, 0.22943631f, -0.06027136f, 0.34552845f, 
    -0.06611994f, 0.12219225f, -0.10835725f, -0.18975861f, 0.12932889f, 0.03138806f, 0.04826962f, -0.20747229f, 
    -0.11241348f, -0.03619686f, 0.01319172f, 0.06018804f, 0.27578548f, -0.30363053f, -0.06020047f, -0.09983367f, 
    0.05077941f, 0.03914685f, 0.06101669f, 0.03591857f, 0.15876612f, 0.06828086f, 0.00627271f, -0.02230647f, 
    -0.13296364f, -0.01148382f, -0.01148616f, -0.01421546f, -0.08918260f, -0.35021824f, -0.17100181f, 0.14585149f, 
    0.10782786f, -0.02462691f, 0.09718210f, -0.10187632f, -0.05183927f, 0.09455245f, 0.25756666f, 0.01521925f, 
    0.04993153f, 0.00130342f, 0.15754274f, 0.01327781f, 0.08747177f, 0.11683644f, -0.36755133f, -0.06576218f, 
    0.01986573f, 0.06886875f, 0.08799797f, -0.15707910f, -0.06415581f, 0.09080636f, -0.00092289f, 0.13305506f, 
    0.19119610f, 0.04863339f, -0.13585633f, -0.01024349f, -0.10915386f, 0.06327417f, 0.03640128f, 0.04077142f, 
    0.04874802f, 0.32402909f, 0.12441853f, -0.01373202f, 0.07220714f, -0.15720995f, -0.04565168f, -0.19682896f, 
    0.01243385f, 0.10242169f, 0.16937540f, 0.05511897f, 0.00669891f, 0.12722558f, -0.02020364f, -0.06338847f, 
    0.06764207f, 0.02759002f, -0.07311868f, -0.05174257f, 0.02808667f, -0.01118080f, 0.09645063f, -0.03590567f, 
    -0.02125965f, 0.01727651f, 0.18180038f, -0.19281216f, -0.17039074f, -0.03687011f, 0.04133139f, -0.04261980f, 
    0.01762371f, -0.01612112f, -0.05612260f, -0.28256863f, 0.10870983f, 0.05016535f, 0.07502207f, -0.10451628f, 
    -0.17204151f, 0.01159707f, 0.11131297f, 0.09098823f, 0.00876726f, -0.25191671f, -0.10497835f, -0.25983140f, 
    0.01950214f, -0.04074887f, 0.11532957f, -0.05973993f, 0.00457452f, 0.07422579f, 0.12882142f, 0.02906584f, 
    -0.12643746f, 0.06332625f, 0.12104941f, 0.07990491f, -0.06546654f, -0.16086286f, -0.20720080f, 0.16941455f, 
    0.08738258f, -0.11595391f, -0.17739145f, 0.01730611f, 0.02134115f, 0.11744253f, -0.10870326f, 0.00509206f, 
    0.02929177f, -0.05075777f, 0.01242016f, 0.00419964f, -0.13730259f, -0.04353381f, 0.01640356f, 0.09697182f, 
    -0.09855152f, 0.03223860f, 0.19089390f, -0.01276644f, 0.02917030f, 0.06095623f, 0.05994157f, -0.00392273f, 
    -0.06512507f, -0.07510315f, 0.11576882f, 0.22299217f, 0.05593257f, -0.02068633f, 0.00865944f, 0.00476778f, 
    0.03794600f, 0.00300942f, 0.07537414f, -0.18239561f, -0.02875926f, -0.05704922f, 0.09038691f, 0.02158671f, 
    0.04211706f, 0.02483030f, -0.15633196f, -0.10116469f, 0.07724842f, 0.16247432f, 0.01131612f, 0.00159734f, 
    0.13441819f, -0.07749153f, 0.07667390f, -0.29823408f, -0.09752360f, 0.12583259f, 0.19553040f, 0.20064405f, 
    0.02406497f, 0.07338704f, 0.07060217f, 0.07797399f, -0.05289591f, -0.09529126f, -0.09827880f, -0.08574355f, 
    0.08667938f, 0.14044949f, 0.15172571f, 0.04803277f, -0.11611584f, 0.24489023f, -0.15490800f, -0.16264932f, 
    -0.18749155f, -0.01481473f, 0.16526558f, -0.13104825f, -0.21766582f, -0.02170562f, 0.23799706f, -0.14224650f, 
    0.04485438f, -0.09686477f, -0.01209663f, 0.06594332f, -0.03230635f, 0.04363659f, 0.20139672f, 0.10136371f, 
    0.05756305f, 0.23764776f, 0.16465478f, 0.07670300f, -0.10391539f, -0.08294812f, -0.01112115f, -0.06318728f, 
    0.06523499f, -0.08627638f, -0.26944178f, 0.19978200f, 0.22272784f, 0.07031894f, -0.20555396f, 0.14011322f, 
    -0.04398051f, 0.02805667f, -0.11269586f, 0.05876158f, 0.09685174f, 0.06094792f, -0.03683907f, -0.11633237f, 
    -0.01820486f, 0.07699333f, 0.06336588f, -0.06417842f, 0.07752488f, 0.07583316f, 0.15095153f, 0.01418542f, 
    0.12082047f, -0.06687461f, 0.01537447f, 0.00005553f, 0.14743944f, 0.07170402f, -0.02413964f, 0.05159678f, 
    0.02289078f, 0.02663708f, -0.02628967f, 0.01464695f, -0.01583979f, -0.02705533f, 0.10898486f, -0.02548018f, 
    0.11731149f, 0.02671030f, 0.04730250f, -0.03410818f, 0.04223207f, 0.03125361f, 0.16075198f, -0.07587238f, 
    0.14763927f, 0.11256520f, -0.01637163f, -0.03854267f, 0.05410128f, 0.11288758f, -0.13113543f, -0.07541097f, 
    -0.15395685f, 0.15117307f, -0.28044242f, 0.03027266f, -0.16507666f, 0.13434678f, -0.01857292f, 0.12709986f, 
    -0.01551672f, 0.16887228f, 0.26742110f, 0.20917103f, -0.14979234f, 0.04724975f, -0.19903012f, 0.03637793f, 
    0.03721356f, 0.00855923f, 0.02396484f, 0.21263877f, 0.21801676f, 0.15207331f, 0.03613183f, -0.16185343f, 
    -0.02812072f, 0.01788353f, 0.18286100f, -0.11777996f, -0.04901717f, 0.05950969f, 0.07459536f, -0.05219263f, 
    0.00046906f, -0.12055861f, -0.15488014f, -0.08009406f, -0.04053126f, -0.21255927f, -0.31422967f, 0.02279801f, 
    0.06687547f, 0.01677479f, 0.19529045f, 0.17284636f, 0.07121421f, -0.02370353f, 0.17641762f, -0.07991727f, 
    -0.05895774f, -0.04584725f, -0.04366325f, -0.14177996f, -0.15158828f, -0.31139901f, -0.13679744f, 0.14062582f, 
    0.03918775f, -0.16595049f, -0.06131097f, 0.04998690f, -0.04489826f, -0.06738118f, -0.12702440f, 0.00616825f, 
    0.16439454f, -0.08614620f, 0.03205709f, 0.04900291f, 0.17660013f, -0.03397803f, -0.06017251f, 0.00902218f, 
    0.34608898f, 0.21938252f, -0.10100272f, 0.05650056f, 0.17117196f, 0.01306524f, -0.11886764f, -0.00428739f, 
    0.01166196f, -0.00516342f, 0.14037171f, -0.07042611f, 0.00193952f, 0.09246652f, 0.03611009f, 0.11441539f, 
    -0.03806706f, 0.02699187f, 0.10467333f, -0.03503185f, -0.05103633f, -0.10383082f, -0.01291401f, -0.15913647f, 
    -0.18759336f, -0.20334253f, -0.15669790f, 0.03076723f, 0.07168486f, 0.31221765f, 0.07924517f, -0.06722531f, 
    -0.01349842f, 0.04758585f, -0.06122151f, 0.11816633f, 0.06398794f, -0.10463301f, 0.00326664f, 0.02888367f, 
    -0.03476109f, 0.06899208f, -0.17314571f, 0.08740313f, 0.00395761f, -0.02703153f, 0.06923055f, 0.18305595f, 
    -0.16429633f, -0.11134785f, 0.00230825f, 0.03371204f, -0.04008973f, 0.02870224f, 0.01974396f, 0.19881910f, 
    -0.03676062f, 0.03481367f, 0.05092898f, -0.04339316f, 0.02567258f, 0.11444387f, -0.15551057f, -0.06028447f, 
    0.20054491f, -0.06863436f, 0.11317144f, -0.03246252f, 0.13614228f, 0.00670643f, 0.02960793f, -0.01379462f, 
    -0.17503355f, -0.25032410f, -0.00126428f, -0.01868990f, -0.17105024f, -0.09273670f, -0.06972369f, 0.02492617f, 
    0.07391262f, 0.01532923f, 0.11467948f, 0.01354194f, -0.04047814f, -0.01723497f, -0.15920058f, 0.01253729f, 
    -0.13146001f, -0.10512690f, 0.14138828f, 0.05509201f, -0.01954255f, 0.14394329f, -0.05359775f, 0.14227180f, 
    -0.03531945f, -0.04997191f, 0.06344613f, 0.05514840f, 0.20706049f, -0.41843361f, -0.10272470f, 0.10158832f, 
    0.01019774f, 0.07710566f, 0.21770400f, 0.03568148f, 0.00043513f, 0.28795013f, -0.03243016f, 0.03275356f, 
    -0.00350209f, 0.02858187f, 0.05436278f, -0.02542025f, -0.11504861f, -0.00870246f, 0.19213375f, -0.07152107f, 
    0.11554712f, 0.02768027f, -0.09297898f, 0.00557918f, 0.10888076f, -0.14589685f, -0.13155060f, 0.09080001f, 
    0.09322058f, -0.04413454f, 0.16786340f, 0.18878067f, 0.07167754f, 0.12387273f, -0.14598836f, 0.10129406f, 
    -0.20585547f, -0.09053164f, 0.10216775f, -0.05248195f, -0.05133465f, 0.03609965f, -0.08316009f, 0.15706594f, 
    -0.09369007f, -0.07810120f, 0.08886995f, 0.04935182f, 0.07367396f, 0.01370818f, 0.09785181f, -0.12878065f, 
    -0.09439155f, -0.13104928f, -0.13202493f, 0.37774375f, -0.06648016f, 0.18128258f, -0.03258597f, -0.01474277f, 
    -0.11941298f, 0.10261708f, -0.21771805f, -0.06068144f, 0.15821129f, 0.10705008f, 0.10748406f, 0.03757463f, 
    0.15749525f, -0.01870047f, 0.13311481f, -0.14976738f, -0.18705496f, 0.05111198f, 0.05211288f, 0.02365729f, 
    0.00140365f, -0.12513298f, -0.01031228f, -0.23642673f, -0.03428767f, 0.19017921f, 0.01943059f, 0.02435043f, 
    -0.04866963f, 0.07341626f, 0.00992514f, 0.02979261f, -0.19004439f, -0.07316740f, -0.03194074f, -0.11373487f, 
    0.06184686f, 0.03900395f, -0.04849041f, -0.15306623f, -0.07447351f, -0.06711021f, -0.05829990f, 0.02491977f, 
    0.00134840f, -0.04163808f, 0.06797493f, 0.07570741f, -0.01192799f, -0.08990744f, -0.00625612f, 0.05518943f, 
    -0.11457116f, -0.03856629f, 0.05745691f, -0.13487151f, 0.06272927f, 0.14516097f, 0.01301268f, 0.10838246f, 
    0.25073075f, 0.03435213f, 0.10723841f, -0.14440079f, -0.07995953f, 0.22994941f, -0.10740159f, 0.01913526f, 
    -0.22154725f, -0.35567987f, -0.23544016f, 0.11686914f, -0.04518951f, 0.05623200f, -0.00865657f, 0.04810161f, 
    -0.07719024f, -0.08647256f, 0.42406744f, 0.22602658f, 0.07845909f, 0.14658771f, -0.05220436f, -0.05610503f, 
    0.11526740f, 0.02237701f, 0.00340894f, 0.02483908f, 0.16481741f, 0.13566436f, 0.04743980f, -0.21050860f, 
    -0.08733314f, 0.09559349f, 0.04256412f, 0.07708329f, 0.11840480f, 0.03594522f, -0.10313805f, -0.04334161f, 
    0.02580437f, -0.00503952f, -0.09612657f, -0.17533486f, -0.06015904f, 0.09997513f, 0.19124445f, 0.28541854f, 
    0.19681770f, 0.24747358f, 0.13430840f, 0.07541281f, 0.10062014f, 0.15235759f, -0.17550337f, -0.11401563f, 
    -0.00509176f, 0.12609087f, -0.04593016f, 0.00553937f, -0.02991160f, 0.01424877f, 0.21735848f, 0.28505409f, 
    0.06908239f, 0.08638945f, -0.08067604f, 0.06210884f, -0.12754451f, 0.08295507f, 0.05089877f, 0.10827339f, 
    0.26110026f, 0.23114757f, -0.25166076f, 0.06106498f, 0.06154387f, 0.03523501f, 0.08367440f, 0.01324005f, 
    -0.08451705f, 0.02363661f, 0.13130550f, -0.03831525f, 0.02393172f, 0.12230302f, -0.03858189f, 0.03841792f, 
    -0.07687560f, 0.12611492f, -0.13101014f, -0.04271507f, 0.01765135f, -0.00059053f, 0.08995939f, 0.02772788f, 
    0.08520748f, 0.12465797f, 0.03807037f, -0.08797147f, -0.12647152f, 0.17092884f, -0.01821828f, 0.11641080f, 
    -0.02429954f, -0.05471499f, -0.06327885f, -0.25345644f, 0.00248772f, 0.01220369f, 0.04888528f, -0.12478161f, 
    -0.07578988f, -0.12495732f, 0.15423137f, 0.10475851f, -0.00299787f, -0.09644234f, -0.09702659f, 0.22363223f, 
    -0.01448311f, -0.02869993f, 0.00731700f, -0.00081047f, -0.07325405f, -0.22783428f, -0.07718426f, -0.06163838f, 
    -0.10415644f, -0.00806070f, -0.04944812f, -0.02589024f, -0.10793068f, -0.11424682f, -0.39370194f, 0.14133015f, 
    0.02751810f, 0.00181897f, -0.16659053f, -0.13919164f, -0.07067430f, 0.00294962f, -0.03263175f, -0.09433047f, 
    0.09419616f, 0.04730609f, 0.05853152f, 0.13387352f, 0.14733049f, 0.04186856f, -0.00250246f, -0.08426279f, 
    0.11382022f, -0.04040500f, 0.31630731f, 0.22744690f, 0.15461725f, 0.10109697f, 0.03602889f, 0.01089364f, 
    -0.05215983f, -0.16563046f, 0.54463899f, 0.23480332f, -0.00154424f, -0.00555125f, 0.06750639f, -0.01468536f, 
    0.06612194f, -0.00688268f, -0.01866485f, 0.12846918f, 0.07978347f, -0.03309519f, 0.11433004f, 0.02249394f, 
    0.13212360f, -0.00008058f, -0.03709001f, -0.17586693f, 0.23932186f, 0.04417955f, 0.22480378f, 0.06490201f, 
    0.13795044f, 0.07921514f, 0.06131629f, -0.06765059f, -0.24547759f, 0.10841361f, 0.09337840f, 0.19463411f, 
    -0.02234148f, 0.02520515f, 0.08676120f, -0.06315830f, -0.03623796f, -0.17557560f, 0.05900684f, 0.03959563f, 
    0.37652263f, -0.07488093f, 0.09242999f, -0.14318991f, 0.07820562f, -0.11615490f, -0.00136288f, 0.20194367f, 
    0.04290843f, 0.23405446f, -0.12837312f, -0.03179611f, -0.18152863f, -0.00111488f, 0.04809654f, -0.04687811f, 
    0.02158689f, 0.09796640f, 0.11231961f, -0.02451569f, 0.02916386f, -0.10774551f, -0.06371505f, -0.27490705f, 
    0.17281263f, -0.34636384f, -0.06724079f, 0.08905829f, -0.03436819f, 0.14561041f, 0.03985195f, 0.09062875f, 
    -0.03221118f, -0.02072941f, -0.00472614f, -0.11552966f, 0.10118212f, -0.15567631f, 0.11315083f, 0.01145176f, 
    0.05148584f, -0.10827084f, 0.11913663f, 0.10205605f, -0.00195536f, 0.10458192f, -0.05812923f, 0.02621506f, 
    -0.06748816f, -0.09717716f, 0.01732874f, -0.03716718f, 0.11100654f, 0.08212812f, -0.17741928f, 0.05634620f, 
    -0.12006081f, -0.07449983f, 0.02751084f, 0.07264096f, 0.05229498f, 0.11099344f, 0.05551766f, 0.18965825f, 
    -0.06229072f, -0.08811486f, -0.18713976f, -0.21015236f, -0.25722465f, 0.05206247f, 0.10294707f, 0.10513362f, 
    0.10367762f, -0.05796031f, -0.03430481f, -0.11128945f, -0.03594125f, 0.01896065f, 0.06448509f, 0.24912256f, 
    0.20724387f, 0.06166546f, -0.13056283f, 0.05890502f, 0.13121668f, -0.11653860f, 0.11405562f, -0.01987451f, 
    0.15424225f, -0.00282852f, 0.03283371f, 0.03244537f, 0.22376509f, 0.18487699f, -0.03009281f, -0.11776144f, 
    -0.21220285f, -0.00173151f, 0.08116472f, 0.01979067f, -0.03720494f, -0.09721000f, 0.00482025f, -0.06946424f, 
    -0.07958832f, 0.11317604f, -0.00850416f, 0.04318606f, 0.09898221f, -0.09588149f, -0.09358097f, -0.08791345f, 
    0.08321087f, -0.09542542f, 0.07515697f, -0.18021140f, 0.02136933f, -0.00906824f, 0.13215159f, 0.04493609f, 
    0.00528171f, 0.05695609f, 0.06891674f, 0.12362099f, -0.13741998f, -0.16054901f, -0.09788083f, -0.00831002f, 
    0.02351023f, -0.10399231f, -0.05942361f, -0.22111717f, -0.19667520f, -0.16987288f, -0.10691652f, 0.23403218f, 
    0.10741298f, 0.08112533f, 0.25954086f, 0.10653389f, -0.01088022f, 0.20520085f, -0.01681637f, 0.14826827f, 
    0.06897992f, 0.01363303f, -0.06161515f, -0.01137162f, -0.06818459f, -0.05522864f, 0.04511204f, 0.14574333f, 
    0.27816558f, 0.01940652f, -0.03291231f, -0.02507191f, -0.07777369f, -0.04744326f, 0.05386504f, -0.07925686f, 
    0.18330660f, 0.22755913f, 0.14267029f, -0.02054994f, 0.13003278f, -0.19282255f, -0.02517276f, 0.05742496f, 
    -0.03625869f, 0.08904859f, 0.01118416f, -0.01920801f, -0.05525838f, -0.03205045f, 0.00525703f, 0.09389959f, 
    -0.00404448f, -0.05558454f, -0.04182460f, -0.10040038f, 0.06839886f, 0.19364654f, -0.12170088f, 0.20820300f, 
    0.15361397f, 0.03290062f, 0.21403374f, -0.09412694f, -0.09219802f, 0.05198424f, 0.03296413f, -0.00653913f, 
    0.02588928f, 0.10428378f, -0.01567382f, 0.09559043f, 0.01384508f, 0.11123797f, 0.14062428f, -0.16185854f, 
    -0.00969764f, 0.02991003f, -0.05601073f, -0.05525270f, 0.04882169f, -0.06918047f, -0.23425750f, -0.03566487f, 
    -0.04868611f, 0.08421264f, 0.11611032f, -0.03342362f, 0.22575863f, 0.15508924f, 0.00950503f, 0.03631817f, 
    0.05908439f, 0.04339826f, 0.05417359f, -0.02721973f, 0.02922691f, -0.03959248f, -0.06719081f, 0.05941859f, 
    -0.06847946f, -0.30162644f, -0.04997426f, 0.00148411f, -0.10011378f, 0.01938852f, 0.00782056f, -0.05426356f, 
    -0.03473949f, 0.00207696f, 0.08305927f, 0.10617493f, -0.09416751f, -0.20185259f, -0.11289179f, -0.16299835f, 
    -0.05527192f, -0.12658818f, -0.04401458f, -0.11113255f, -0.04537823f, 0.00711564f, 0.02591441f, 0.04048729f, 
    0.14074838f, 0.12492272f, 0.25198516f, 0.20204207f, 0.02135671f, -0.08517935f, 0.03257364f, 0.04089981f, 
    -0.01971825f, 0.04813302f, -0.05478490f, 0.05721619f, 0.00862705f, 0.20802009f, -0.04906369f, -0.02162587f, 
    -0.27798757f, -0.02929007f, -0.25685522f, -0.09443635f, 0.19582264f, -0.13766873f, -0.20431438f, 0.12657422f, 
    0.04278260f, -0.02367148f, 0.05042822f, -0.07233470f, 0.14966770f, 0.05741750f, 0.17141514f, -0.13308933f, 
    -0.00296041f, 0.10156704f, -0.18088867f, 0.09494750f, 0.09113348f, -0.13609003f, -0.05784505f, 0.06596979f, 
    0.01928164f, 0.15832931f, 0.14046122f, -0.06313534f, 0.16950946f, -0.00637959f, 0.09739741f, -0.26554915f, 
    -0.11273769f, 0.11677197f, -0.07014530f, 0.03139287f, -0.01169319f, -0.02074035f, -0.11130097f, -0.07430087f, 
    -0.16154172f, -0.23225418f, -0.01125737f, -0.05532809f, 0.05758840f, -0.00137576f, 0.19311315f, -0.20901296f, 
    -0.18308051f, 0.06330801f, -0.07612690f, 0.08946726f, 0.09394689f, 0.05475246f, 0.04132235f, 0.07687359f, 
    -0.13934326f, -0.02688809f, 0.02649990f, -0.10654578f, -0.14603245f, -0.02728723f, 0.18849176f, 0.19825239f, 
    0.20576231f, -0.23518354f, 0.21396072f, 0.02229699f, -0.20912187f, -0.09400898f, 0.04198838f, 0.06640556f, 
    0.02923168f, -0.05903138f, -0.16680592f, -0.08931319f, -0.10251363f, 0.05370899f, -0.07780104f, 0.09068058f, 
    -0.05675507f, 0.23191001f, 0.10384160f, -0.10935964f, -0.30883574f, -0.08189348f, -0.19491361f, -0.12414234f, 
    0.07215024f, 0.11615774f, 0.02434796f, -0.07891560f, -0.04539307f, -0.09275430f, -0.11470935f, -0.15720081f, 
    -0.03373547f, -0.01502092f, 0.06100688f, 0.14417377f, -0.10232364f, -0.10097092f, 0.02742433f, -0.06928995f, 
    0.06922645f, 0.01980046f, -0.03346433f, 0.19330591f, -0.02665479f, 0.10612620f, -0.00675214f, 0.15219492f, 
    0.09507407f, -0.02289537f, 0.28538686f, 0.11654527f, 0.01406876f, -0.00526745f, -0.04428804f, -0.08154343f, 
    -0.15039179f, -0.16085993f, -0.40016630f, 0.14022234f, -0.01673305f, -0.07861368f, 0.01501520f, 0.01166275f, 
    0.07712560f, 0.01406789f, -0.15646733f, 0.14076589f, 0.16304952f, -0.05229190f, -0.16405201f, -0.10148936f, 
    0.04585747f, -0.02199761f, -0.06596144f, 0.00761799f, 0.01718018f, 0.11335245f, 0.02611583f, 0.02136941f, 
    -0.02179680f, 0.07747172f, 0.11254213f, 0.01461130f, 0.00757572f, 0.20749711f, -0.18330142f, 0.09736432f, 
    -0.05696641f, -0.07403308f, -0.08871114f, -0.04816836f, 0.00352230f, -0.04586904f, 0.12966231f, 0.08115528f, 
    -0.07338859f, -0.00785479f, 0.13589159f, -0.00525247f, 0.17507175f, 0.23285371f, 0.08728145f, 0.15713704f, 
    0.06088759f, 0.08052446f, 0.16110602f, 0.08287969f, -0.03766339f, -0.03219229f, 0.13786359f, -0.22558126f, 
    0.05791688f, 0.00523746f, -0.09357654f, 0.09951510f, 0.01948987f, -0.03518016f, -0.05068517f, 0.11147226f, 
    -0.30244932f, 0.02950997f, 0.01807277f, 0.08351324f, 0.04119956f, 0.15841958f, 0.16399132f, -0.19691300f, 
    -0.15505804f, 0.04047272f, 0.18086991f, 0.03368409f, -0.05805966f, 0.09137052f, 0.04703190f, 0.04399908f, 
    0.03103057f, -0.19066666f, 0.01776092f, 0.00409629f, 0.12352882f, 0.06546416f, 0.00204155f, 0.01452703f, 
    -0.11050182f, 0.08300731f, 0.00595328f, -0.08844492f, -0.24986269f, 0.14356771f, 0.07893986f, 0.08164354f, 
    0.04741108f, 0.07215127f, 0.02747481f, -0.05078910f, 0.01701557f, -0.02425542f, 0.02762240f, -0.09236173f, 
    0.00781890f, 0.13159610f, -0.05875265f, 0.10175416f, 0.10414610f, -0.01916936f, -0.01135581f, 0.16611297f, 
    -0.00285488f, -0.01931261f, 0.01951070f, 0.07691401f, 0.10242274f, 0.01983171f, 0.15193321f, 0.00491611f, 
    0.05534998f, 0.01660241f, 0.09129811f, -0.19606243f, 0.00210409f, -0.11427727f, -0.06951200f, 0.04703961f, 
    0.08588880f, 0.03442893f, -0.07918578f, -0.02498315f, -0.05158146f, -0.00471848f, -0.01569073f, -0.03576985f, 
    -0.06586257f, 0.02368122f, -0.13449785f, 0.13592827f, 0.03806131f, 0.11763459f, -0.05175050f, 0.01564779f, 
    0.02705736f, -0.02419368f, 0.13403636f, 0.00284341f, 0.00520926f, 0.03509851f, 0.06181528f, 0.05101929f, 
    0.07914966f, -0.05100881f, 0.06654253f, 0.24237686f, 0.31489024f, 0.04643812f, -0.03119714f, 0.08857716f, 
    0.10873156f, -0.01618477f, -0.08691333f, -0.13887843f, 0.16959132f, 0.08139676f, 0.11692343f, 0.05968542f, 
    -0.16761911f, -0.02793402f, -0.27470103f, -0.12376525f, -0.01993809f, -0.05080784f, -0.22968435f, 0.06764258f, 
    0.07736754f, 0.05380942f, 0.11202561f, 0.02599625f, -0.24609451f, 0.06108686f, 0.23167782f, -0.07568394f, 
    0.02174362f, 0.03850215f, -0.08682737f, 0.18981405f, -0.08836206f, -0.12448482f, 0.02171032f, -0.01450999f, 
    0.14153624f, -0.04413570f, -0.04294842f, 0.06330547f, 0.09556220f, -0.05071227f, 0.00949678f, 0.09825957f, 
    0.11600254f, 0.11687540f, -0.06420998f, -0.07103022f, -0.00670896f, -0.02984716f, 0.13434339f, -0.11128882f, 
    0.14174010f, 0.00527740f, -0.16541255f, 0.10548443f, -0.15791896f, 0.06397902f, 0.02931247f, 0.02179149f, 
    -0.10001573f, 0.04204329f, 0.37354717f, 0.08486966f, -0.10702434f, -0.00991723f, -0.06170530f, 0.04665325f, 
    0.08662429f, 0.05048759f, 0.23373008f, -0.14129572f, 0.11446898f, -0.03439774f, -0.03790620f, -0.03448252f, 
    0.07115050f, 0.19859134f, 0.27657464f, 0.12069796f, -0.17655352f, -0.00587490f, -0.05502247f, -0.08161521f, 
    -0.00941494f, -0.10455627f, -0.23702614f, -0.11108892f, -0.21487789f, 0.12997875f, -0.11415914f, 0.02588763f, 
    -0.13234998f, 0.14289136f, 0.05783293f, 0.08325975f, -0.15635990f, -0.07496657f, -0.19217958f, -0.07778339f, 
    0.02235601f, 0.09753214f, 0.07860091f, -0.00438150f, 0.05625402f, -0.21241117f, -0.04540236f, -0.09464826f, 
    0.07711063f, -0.00696482f, 0.16240695f, 0.03857545f, 0.03358605f, 0.05576464f, -0.10298421f, -0.11634177f, 
    0.35294083f, 0.24353136f, 0.11832932f, 0.00709510f, 0.09528656f, -0.04582949f, -0.26953718f, 0.20405774f, 
    -0.25361231f, 0.35716057f, 0.10747167f, 0.03224888f, -0.07271276f, -0.12348120f, -0.21371137f, 0.20912035f, 
    -0.02383091f, 0.11025538f, -0.31902608f, -0.09725032f, 0.08503041f, 0.11135643f, 0.07998263f, 0.03876805f, 
    0.04408964f, -0.02685729f, -0.25555152f, 0.31065553f, 0.12519626f, 0.09112948f, -0.01345341f, -0.21596812f, 
    -0.00141798f, 0.09869695f, -0.00160637f, -0.04009896f, 0.08639710f, 0.11888508f, -0.02358858f, -0.08716989f, 
    -0.07516239f, 0.16225097f, 0.12544762f, 0.17352028f, -0.15303384f, -0.02318413f, -0.11071059f, 0.04865598f, 
    0.05845736f, 0.00576715f, -0.19926012f, -0.05848706f, -0.18077901f, -0.14794770f, 0.20203772f, -0.24186656f, 
    -0.16214912f, -0.07244676f, 0.08643178f, 0.18408996f, 0.41175649f, -0.04186773f, 0.09094777f, 0.01376081f, 
    0.23238145f, 0.01703702f, 0.12504278f, -0.02589833f, -0.00609270f, -0.00026941f, 0.26655558f, -0.13252445f, 
    -0.19095841f, 0.04582658f, -0.09329287f, -0.00242176f, -0.14513071f, -0.03931666f, -0.04911532f, 0.09985211f, 
    -0.20319773f, -0.14819358f, 0.01875131f, 0.03318777f, -0.01353957f, -0.10037930f, 0.02538691f, 0.02034366f, 
    0.01948451f, -0.04246447f, 0.09754427f, 0.02717002f, -0.04338915f, 0.19650359f, -0.03986241f, -0.14950298f, 
    -0.09631550f, -0.01371277f, 0.06830402f, -0.06476612f, -0.01998479f, 0.01357028f, 0.10430136f, 0.12187529f, 
    -0.08447762f, 0.10234407f, 0.01546957f, -0.01030633f, 0.04045557f, 0.08986027f, 0.01380674f, -0.20341444f, 
    -0.02281081f, -0.12285598f, 0.11258742f, -0.14859068f, -0.06183200f, 0.12137651f, -0.06394981f, 0.17434464f, 
    0.09234610f, 0.07002894f, -0.10698766f, 0.03992695f, 0.06031327f, -0.24021310f, 0.11731902f, 0.08280097f, 
    0.13730194f, 0.01481666f, 0.04152809f, -0.00308871f, -0.10686025f, 0.02183170f, 0.14586338f, -0.12206751f, 
    -0.04295758f, -0.08077111f, 0.00429257f, -0.07230434f, -0.15438521f, 0.00396083f, -0.00086846f, -0.02188771f, 
    -0.08697482f, 0.07926618f, -0.02687139f, -0.03172344f, -0.05006727f, -0.01249771f, -0.05055726f, 0.09924194f, 
    -0.06842589f, -0.16478097f, -0.14836784f, 0.12271133f, 0.09706763f, 0.28898174f, 0.01036825f, 0.06936843f, 
    0.04404939f, -0.08295368f, -0.07409544f, -0.24547201f, 0.03962912f, 0.07563040f, 0.06383665f, 0.15324700f, 
    0.01289313f, 0.05052923f, -0.08132699f, 0.00519279f, -0.12804288f, 0.14034124f, 0.08780035f, -0.02945578f, 
    0.00861513f, -0.09525304f, 0.04071921f, 0.06877395f, -0.01477439f, -0.01588746f, 0.11383560f, -0.07520451f, 
    -0.04116346f, -0.22481319f, -0.22327398f, -0.22941025f, 0.11649073f, -0.08752473f, 0.00091415f, 0.17261073f, 
    0.17088802f, -0.02138580f, -0.10937817f, 0.00932487f, 0.06756274f, 0.20198704f, -0.16289501f, 0.13099325f, 
    0.01321677f, -0.03563730f, -0.16764957f, 0.07009973f, -0.03561385f, 0.19612744f, 0.25017083f, 0.29215604f, 
    0.06139758f, 0.10483169f, -0.03130652f, 0.22189328f, 0.05202438f, -0.06025416f, 0.12383628f, 0.04657875f, 
    -0.01496220f, -0.05054208f, 0.00617081f, -0.06203250f, 0.22636379f, -0.24735986f, 0.15842623f, -0.22314160f, 
    -0.18948154f, -0.19533898f, 0.04080535f, -0.25026357f, -0.00856642f, 0.05223490f, 0.08289750f, -0.02052922f, 
    -0.15612277f, -0.17503399f, 0.14914478f, 0.11968810f, -0.15996492f, -0.23579776f, -0.06985543f, -0.02420754f, 
    0.16001706f, -0.00524331f, 0.00425599f, -0.28209028f, 0.07649016f, -0.04951318f, 0.10411379f, 0.07680568f, 
    -0.16822335f, -0.13995221f, 0.14518379f, -0.03559603f, 0.02231548f, -0.18773583f, -0.09476709f, 0.05490677f, 
    0.05845606f, 0.05858917f, 0.09118952f, 0.05092473f, 0.07587513f, -0.04492619f, 0.06269230f, 0.00920190f, 
    -0.09191609f, 0.04084150f, -0.05243683f, -0.05546869f, 0.06646310f, -0.16018011f, -0.21232124f, 0.04048258f, 
    -0.03963835f, -0.17162983f, -0.10317815f, 0.05385596f, 0.14885366f, -0.04116612f, -0.24780285f, -0.09764303f, 
    0.05037078f, -0.20994982f, -0.19662671f, -0.21334565f, 0.18532681f, 0.07036850f, 0.06162698f, -0.23898639f, 
    -0.15709287f, -0.27872470f, -0.10106219f, 0.10366698f, -0.09526712f, -0.01648293f, 0.11297056f, -0.06341262f, 
    0.22164953f, 0.06391934f, 0.22132795f, 0.23626079f, 0.07461478f, -0.06342264f, 0.18357977f, 0.07145827f, 
    -0.00920062f, -0.25394869f, -0.35357806f, -0.26593173f, -0.28965145f, -0.12766966f, -0.00975359f, -0.08937953f, 
    -0.20893174f, 0.11098249f, -0.07019487f, 0.02962345f, 0.29104492f, 0.08950815f, -0.00133039f, -0.02094997f, 
    -0.02856336f, -0.09200513f, 0.01400011f, -0.06074701f, -0.18222831f, -0.03298648f, -0.03131920f, 0.15298857f, 
    0.12238166f, 0.01645987f, 0.00957813f, 0.02440480f, 0.14372747f, 0.35199535f, 0.33585379f, 0.00860758f, 
    0.00819832f, 0.07552792f, 0.22877626f, 0.06490778f, 0.13824065f, 0.03462270f, -0.09000360f, 0.10556576f, 
    -0.12958997f, -0.08737498f, -0.06675391f, 0.09077656f, -0.21634409f, -0.14984035f, 0.19307283f, 0.03698457f, 
    -0.20137489f, -0.04774924f, 0.03238339f, 0.23820986f, 0.14865550f, 0.02723785f, -0.00663006f, -0.40071869f, 
    0.02896621f, 0.36626977f, 0.04239582f, 0.13399790f, -0.06757009f, 0.04485879f, 0.04543947f, -0.02347143f, 
    -0.26360506f, 0.04616106f, 0.32401037f, 0.04038693f, -0.10031519f, -0.07328447f, -0.07763925f, -0.11654250f, 
    -0.14617144f, 0.15047789f, 0.12520936f, 0.43942213f, 0.09456565f, 0.06164016f, -0.08743859f, 0.06756282f, 
    0.02410739f, 0.21385546f, -0.12756696f, 0.08311620f, 0.06837352f, 0.07078785f, -0.07386579f, 0.08916745f, 
    0.06524610f, -0.01268089f, -0.09608836f, 0.33174905f, 0.22614513f, -0.09074768f, 0.02897887f, -0.06434320f, 
    0.06194965f, 0.11274965f, 0.16248180f, 0.13734078f, -0.25709760f, -0.24272156f, -0.01121884f, 0.01518508f, 
    0.05484249f, -0.06218815f, -0.07079887f, 0.13511193f, -0.06975444f, 0.23155212f, 0.14225054f, 0.23228826f, 
    -0.13341706f, 0.08497217f, 0.10131840f, 0.01105213f, 0.09362134f, 0.08221793f, 0.16636311f, 0.21083696f, 
    0.03717555f, 0.06349321f, 0.13394333f, -0.06773886f, 0.29086453f, 0.10875671f, 0.32813367f, -0.24779159f, 
    0.07355299f, 0.44575909f, 0.10058411f, 0.20533657f, 0.04737262f, 0.25019699f, 0.00551844f, 0.04670102f, 
    -0.43818834f, -0.37686428f, -0.30999541f, -0.12283064f, 0.03346260f, -0.11610971f, 0.11242568f, 0.07652190f, 
    -0.02855348f, 0.22856374f, -0.02144020f, 0.09882930f, -0.01599926f, -0.00724635f, 0.04078860f, 0.11631740f, 
    -0.09169229f, 0.07057595f, -0.26466587f, -0.00183217f, 0.09176327f, 0.04325834f, 0.10346563f, 0.00194146f, 
    0.01506523f, 0.15215422f, 0.04405598f, -0.08724238f, 0.02773226f, 0.00314586f, 0.23057181f, -0.03593272f, 
    -0.02655262f, 0.16990240f, -0.00620534f, -0.00739229f, -0.01438911f, 0.00937330f, 0.13640122f, -0.11819125f, 
    -0.05274032f, -0.04936855f, -0.05607649f, 0.08973172f, -0.08273743f, -0.07271724f, 0.00762288f, 0.21142375f, 
    -0.02041336f, -0.03910982f, 0.01328788f, 0.10847960f, 0.00607403f, -0.17102017f, 0.19973019f, 0.12560377f, 
    0.17537640f, -0.04265319f, -0.04144464f, -0.04066815f, 0.13693659f, -0.10119108f, 0.04846361f, -0.20646492f, 
    0.33477351f, 0.27258560f, 0.05569027f, 0.13890845f, -0.04594783f, 0.09135683f, -0.06008507f, 0.13477565f, 
    -0.06600544f, 0.04922336f, 0.04976207f, 0.05171794f, 0.03238189f, 0.01435295f, -0.02840406f, 0.04061295f, 
    0.00504175f, -0.05816123f, -0.02540294f, -0.06037368f, -0.00898319f, -0.04425499f, -0.05804442f, -0.05316496f, 
    0.04113078f, 0.02110358f, 0.00128165f, -0.03082765f, -0.01729262f, -0.01927002f, 0.03576885f, 0.02402809f, 
    -0.01407256f, 0.00804933f, -0.00460485f, -0.01885451f, -0.04398327f, -0.04111382f, 0.00136929f, -0.03258236f, 
    0.03683212f, 0.02178511f, -0.05626677f, -0.04525023f, 0.04849173f, 0.04960845f, -0.05014485f, -0.02076993f, 
    -0.01215517f, -0.05789169f, -0.02875692f, 0.04558480f, -0.05919002f, 0.02484941f, 0.03089429f, -0.02209064f, 
    0.05332087f, -0.00539136f, -0.02946241f, -0.05350829f, -0.02427002f, -0.00775634f, -0.03608550f, 0.04163624f, 
    -0.03280652f, -0.06571891f, 0.05297768f, -0.03685391f, -0.04058538f, 0.00898187f, 0.00307674f, -0.01515689f, 
    0.00803397f, -0.04632005f, 0.04549093f, 0.00311967f, 0.02549354f, 0.04724948f, -0.03566626f, 0.00163705f, 
    -0.03021639f, 0.03500737f, 0.03866424f, -0.00416357f, -0.00006222f, -0.03415681f, -0.06286954f, 0.01062999f, 
    0.04641774f, -0.01712275f, -0.01716468f, -0.02934291f, 0.03568775f, 0.01919133f, -0.02990594f, -0.01847479f, 
    -0.05751146f, -0.00175360f, 0.04128338f, 0.04941076f, 0.03081454f, 0.01019707f, -0.00530379f, 0.04781476f, 
    0.03754236f, -0.04453970f, -0.02667679f, 0.02432850f, 0.00640957f, 0.04261028f, -0.03218866f, 0.03029452f, 
    0.04857433f, 0.02326840f, -0.00442563f, 0.01135326f, -0.05600842f, -0.03565044f, -0.06548433f, -0.06410506f, 
    -0.01330195f, -0.00202523f, -0.03460097f, 0.03367499f, 0.01377083f, -0.03459119f, 0.01851518f, -0.00689740f, 
    0.03308776f, -0.02127372f, -0.03610970f, -0.04438601f, 0.01798596f, 0.03903072f, 0.02597043f, 0.02465773f, 
    -0.06346477f, 0.03405751f, -0.03387923f, -0.01834752f, -0.03754183f, -0.05519212f, -0.03072729f, -0.00483069f, 
    -0.01203914f, -0.02502571f, 0.05093255f, -0.06296062f, 0.04392374f, -0.02636595f, 0.00104071f, -0.02428021f, 
    -0.02916975f, 0.04143442f, 0.00897491f, 0.01196544f, 0.05301059f, -0.05649936f, -0.02816177f, 0.00090215f, 
    -0.04881235f, 0.03668930f, -0.00773392f, 0.01272914f, -0.01135257f, -0.00388865f, -0.03217744f, -0.04634123f, 
    -0.03663121f, -0.05509841f, 0.02986181f, 0.02661671f, -0.02133654f, -0.01641108f, -0.04653582f, -0.04927213f, 
    -0.04802831f, -0.06059758f, -0.06410658f, 0.04504892f, 0.01389608f, -0.02136429f, -0.02780833f, 0.00187531f, 
    -0.03533902f, -0.04557908f, -0.03487725f, -0.02516545f, -0.05024554f, 0.04958173f, 0.05185103f, 0.00577814f, 
    0.00835702f, 0.01039314f, -0.05559200f, 0.03538478f, 0.02455158f, 0.02891756f, -0.03548604f, -0.05265057f, 
    -0.01186194f, 0.02187986f, 0.01860439f, 0.02498907f, 0.02573026f, 0.01081378f, 0.04946361f, 0.02279937f, 
    -0.04547044f, -0.05661172f, -0.06336819f, -0.04057161f, 0.00869698f, -0.00007485f, -0.00985733f, -0.00359739f, 
    -0.04469427f, -0.05817281f, -0.03255621f, 0.02800634f, 0.03809091f, -0.03806425f, -0.00350686f, 0.02586490f, 
    0.00887392f, -0.01930924f, 0.04292709f, -0.02999197f, -0.05392503f, -0.05444139f, -0.05921016f, 0.01572504f, 
    -0.03518819f, -0.00279644f, 0.04350346f, -0.01571649f, 0.04044338f, 0.02532687f, 0.01757172f, 0.04226148f, 
    -0.04882832f, 0.04782915f, -0.01904283f, -0.02324951f, -0.01491261f, -0.03886750f, -0.03630004f, 0.02275384f, 
    -0.01931525f, 0.00918952f, -0.00654336f, -0.04816018f, 0.01098288f, 0.01175478f, -0.06636657f, 0.02594169f, 
    0.03195862f, -0.05801206f, -0.06187446f, -0.03953829f, 0.03339067f, -0.01539688f, -0.04072504f, -0.00316049f, 
    -0.04108822f, -0.03457137f, -0.02829537f, -0.03171495f, 0.03180603f, 0.00877072f, -0.00498407f, -0.03726197f, 
    0.03788855f, 0.04600060f, -0.06211131f, -0.04119746f, 0.01442613f, 0.01075907f, 0.05520072f, -0.05407036f, 
    0.02785295f, 0.02637774f, 0.01973677f, 0.00738579f, -0.01926243f, -0.03103154f, -0.04004892f, 0.04753296f, 
    -0.04831228f, -0.04085324f, -0.01284616f, -0.03221498f, -0.02783601f, -0.06427986f, 0.04179446f, -0.03153216f, 
    -0.01073522f, 0.05031763f, 0.24142516f, 0.04858459f, -0.04205785f, 0.07477806f, -0.03039464f, 0.11468681f, 
    0.02162081f, 0.07188282f, -0.04664101f, 0.02114782f, 0.18979876f, -0.03830019f, 0.00445218f, 0.01601265f, 
    0.04965098f, -0.05278759f, -0.08659262f, -0.06805497f, -0.03816625f, 0.12944314f, 0.13983938f, 0.09162589f, 
    -0.17150384f, -0.00788638f, -0.14297356f, 0.21926074f, -0.04983525f, 0.20867078f, 0.07649957f, 0.10595574f, 
    -0.04696775f, 0.16311605f, 0.19108585f, 0.01014955f, -0.01514722f, -0.04477001f, -0.52411157f, -0.14539428f, 
    -0.17912944f, -0.13759120f, 0.06764939f, 0.15594299f, 0.07223491f, 0.15610479f, -0.05872300f, 0.15329374f, 
    0.05239261f, 0.03383961f, -0.02241741f, -0.04111052f, 0.03105854f, -0.03207488f, 0.04667116f, 0.02931995f, 
    0.22059128f, 0.08284505f, -0.07599442f, 0.01502711f, 0.00345627f, 0.14053248f, -0.06766072f, 0.01331010f, 
    0.07290324f, 0.16295280f, 0.06235008f, 0.03743197f, 0.12558347f, 0.14146492f, 0.02715584f, -0.16915692f, 
    -0.24115218f, -0.08295117f, -0.18847023f, -0.16568941f, 0.12448911f, -0.07130307f, -0.12156999f, -0.16412582f, 
    -0.08350991f, 0.23316714f, -0.22925292f, 0.17751110f, 0.12744263f, 0.06333190f, 0.15684640f, 0.09561396f, 
    0.14050311f, -0.00332990f, -0.41711044f, 0.13353774f, 0.21154578f, -0.08318473f, 0.19927754f, 0.22548856f, 
    0.05949538f, -0.10664982f, 0.07606699f, -0.06236174f, 0.07315100f, 0.12285032f, -0.07272118f, -0.00515672f, 
    -0.03939620f, 0.21226063f, 0.06947574f, 0.08843279f, 0.55407089f, 0.10688737f, 0.11686438f, -0.16262811f, 
    -0.20992284f, -0.18821840f, -0.02010617f, -0.08734133f, -0.13618127f, 0.17596214f, 0.10850944f, -0.04542245f, 
    -0.04656792f, -0.02305177f, -0.10519372f, -0.00768053f, -0.05313418f, -0.08939568f, -0.02723440f, 0.12544118f, 
    0.16023518f, 0.01357122f, -0.08817867f, 0.09954065f, 0.03692084f, -0.03437476f, -0.17664540f, -0.57155794f, 
    -0.12658773f, 0.07245631f, -0.17562665f, 0.04836338f, 0.06415562f, -0.04997226f, 0.03400367f, -0.05265304f, 
    -0.24515958f, -0.10980904f, -0.24823198f, -0.24681406f, -0.38248786f, -0.21855566f, -0.04134859f, 0.07519069f, 
    0.13932356f, -0.39031717f, -0.26979715f, -0.64510792f, 0.02991127f, 0.03910131f, -0.09971847f, 0.05852687f, 
    0.15983059f, -0.13927169f, 0.17679396f, 0.14816689f, 0.07824384f, 0.03462914f, 0.16066453f, 0.02034116f, 
    0.16108377f, 0.01439493f, -0.01241351f, -0.20698363f, 0.01936408f, 0.26412615f, 0.04846767f, 0.10562770f, 
    0.11572012f, -0.04115481f, 0.11493977f, 0.02412582f, 0.05006454f, -0.10855124f, 0.16841614f, -0.06620966f, 
    0.04048226f, 0.00509048f, 0.09109984f, 0.06597191f, 0.03028692f, 0.19503228f, -0.13952295f, 0.13273761f, 
    -0.21710376f, 0.16352142f, 0.07307167f, 0.11287936f, -0.15223934f, 0.17612049f, 0.33802867f, -0.24706748f, 
    -0.03287076f, 0.06266436f, -0.12150197f, 0.03693452f, 0.16069996f, 0.04511939f, -0.11625265f, 0.15692805f, 
    0.12937200f, 0.20335379f, 0.16958499f, -0.07865001f, 0.02074371f, 0.05893619f, 0.02522881f, 0.00027014f, 
    -0.00595850f, 0.10874312f, 0.41253290f, -0.08500843f, -0.10531358f, -0.00831586f, -0.04287967f, 0.13293979f, 
    -0.21966442f, 0.27922440f, -0.01377001f, -0.07458713f, -0.03956034f, -0.12046939f, -0.02011080f, -0.00000948f, 
    -0.08140837f, 0.07805674f, -0.22208257f, -0.17716616f, -0.34853444f, -0.25107628f, -0.00239889f, -0.12335014f, 
    0.07558800f, 0.04209946f, 0.02899206f, 0.13725661f, 0.50245398f, 0.36344534f, -0.12285327f, -0.20783716f, 
    -0.07764930f, 0.11372280f, 0.04031159f, -0.10095726f, -0.34879294f, 0.02098897f, -0.22820078f, -0.14848776f, 
    -0.09258655f, -0.13466294f, -0.01395379f, -0.07607870f, 0.00223936f, -0.26113930f, -0.04826124f, -0.39146870f, 
    -0.05978057f, -0.40879115f, -0.06351654f, -0.00444549f, 0.01799356f, -0.01785044f, -0.79234606f, -0.13597974f, 
    -0.13810940f, -0.06705600f, -0.02004514f, -0.09059953f, -0.31929228f, 0.07057948f, -0.01489065f, 0.25047866f, 
    0.07680590f, -0.09605215f, -0.10026067f, -0.00901884f, -0.09491450f, 0.09276655f, -0.05079967f, -0.12020938f, 
    -0.03220129f, 0.06948852f, 0.04533918f, -0.03936533f, 0.01998707f, -0.12065408f, 0.02782608f, -0.00057127f, 
    0.09043334f, 0.24493498f, 0.29115504f, -0.17066400f, 0.05599655f, -0.03032422f, -0.09532601f, -0.02941736f, 
    0.15156618f, 0.11633033f, 0.31932220f, 0.20406643f, 0.22030000f, -0.05293834f, 0.14889121f, -0.06650568f, 
    -0.02480545f, 0.12379782f, -0.19187346f, -0.13495107f, -0.08018848f, 0.04205098f, 0.02170342f, -0.09907136f, 
    -0.07267629f, -0.00066705f, -0.04906653f, 0.02612841f, -0.03898725f, 0.04523166f, -0.04102663f, -0.06735295f, 
    -0.05140952f, 0.21604814f, 0.03169267f, -0.05392044f, 0.09217287f, -0.07340530f, 0.15408716f, -0.08346175f, 
    -0.08090037f, 0.03008726f, -0.01902968f, 0.03648502f, -0.03560369f, 0.06161831f, 0.11154732f, 0.26316890f, 
    0.06659981f, -0.04422937f, 0.02184178f, -0.02522483f, -0.01841487f, -0.06925866f, -0.02126184f, 0.38378009f, 
    -0.01010650f, -0.09825663f, 0.09353577f, 0.02268324f, 0.00512843f, 0.00287089f, -0.02865685f, -0.29462400f, 
    0.03742184f, -0.15492989f, -0.38331252f, -0.08127324f, -0.04342436f, 0.05491941f, 0.05913946f, -0.01129648f, 
    0.10350925f, 0.55045527f, 0.40455109f, 0.02398250f, -0.12299560f, -0.12480099f, -0.15166672f, -0.00538526f, 
    -0.05206680f, 0.02717775f, 0.13635539f, -0.21340296f, -0.36283630f, 0.14245565f, -0.02807679f, -0.00971974f, 
    0.12431382f, -0.11100890f, 0.06667181f, 0.01686109f, -0.03360605f, -0.19663814f, 0.16199644f, -0.00909728f, 
    -0.04909442f, -0.01613035f, 0.01903538f, 0.03371314f, -0.14327419f, -0.24394937f, -0.11719143f, -0.02228655f, 
    0.01045626f, 0.26249158f, -0.11116821f, -0.00784328f, 0.01151058f, -0.24019425f, -0.18231530f, -0.07787856f, 
    -0.07224014f, -0.02304217f, -0.15038255f, -0.21257156f, 0.07566320f, -0.17055975f, 0.19867514f, 0.11886526f, 
    -0.02574410f, 0.02444192f, -0.04017844f, 0.07656903f, -0.03614531f, 0.01832809f, 0.07192466f, 0.23783746f, 
    -0.13056915f, -0.11483610f, 0.11018208f, -0.05148181f, -0.01139476f, -0.09511922f, 0.03804666f, -0.18292144f, 
    -0.00127078f, 0.03264403f, 0.30976877f, -0.01542157f, -0.13010520f, -0.04596898f, 0.00496099f, 0.06745695f, 
    0.02569774f, -0.11876184f, 0.01686113f, 0.11621579f, 0.03889375f, -0.15277764f, 0.02804156f, 0.11129188f, 
    -0.08197077f, -0.03144381f, -0.00932290f, -0.10164122f, 0.05735356f, -0.02510640f, 0.12394250f, -0.00379041f, 
    -0.03566908f, -0.14099291f, 0.08057019f, 0.17126229f, 0.08517044f, -0.07534718f, -0.02112999f, 0.06272705f, 
    0.08163079f, 0.03476321f, 0.11370040f, 0.09844223f, 0.03559221f, 0.18166536f, -0.12475784f, -0.01256947f, 
    0.11400989f, 0.00258765f, -0.01160593f, 0.17874116f, -0.15658271f, 0.07392006f, 0.04814618f, -0.00546429f, 
    0.01935427f, -0.02430139f, 0.04589858f, 0.14540723f, 0.13435739f, -0.05841323f, -0.00736291f, 0.11590391f, 
    0.14307700f, 0.02622153f, 0.09533401f, -0.02350352f, 0.00119321f, 0.07367176f, 0.09354753f, 0.01526883f, 
    -0.20328990f, -0.09453865f, -0.10243002f, 0.00648903f, 0.04333530f, -0.08758818f, -0.00525213f, -0.31773534f, 
    0.13437052f, -0.03760771f, -0.09915588f, -0.09421101f, 0.07312196f, -0.03606352f, -0.21685547f, -0.12598503f, 
    0.03828072f, 0.05258396f, -0.24498801f, 0.28840947f, -0.02950111f, 0.00374779f, -0.11956530f, 0.10427386f, 
    -0.16216683f, 0.07471146f, 0.06152623f, -0.06643557f, 0.26331696f, 0.06274722f, 0.05885815f, 0.04801683f, 
    0.04171481f, 0.08946820f, -0.04303622f, -0.08356000f, -0.29754314f, -0.07586399f, -0.11487142f, 0.09705517f, 
    0.00155561f, -0.11094014f, -0.14555134f, 0.17595620f, -0.06581484f, -0.09449863f, 0.07982152f, 0.06069279f, 
    -0.02969732f, 0.16138066f, -0.03567073f, 0.03458557f, 0.05440555f, 0.07845226f, 0.00590178f, 0.19649144f, 
    0.00320919f, -0.03633190f, 0.08035173f, 0.04544304f, -0.04644030f, 0.03292486f, -0.16961969f, -0.19778344f, 
    0.29494363f, -0.18628003f, 0.10538936f, 0.10618769f, 0.01161921f, 0.08628315f, 0.20019142f, -0.03205818f, 
    -0.12846199f, 0.09768419f, -0.15816422f, 0.13097581f, -0.03064355f, -0.17782752f, -0.04907907f, 0.18663701f, 
    0.03471189f, 0.04581128f, -0.03510360f, -0.06033039f, -0.01948246f, 0.01270663f, -0.01845420f, -0.00862672f, 
    -0.04134844f, 0.03032855f, -0.03967930f, 0.02144484f, 0.03490518f, -0.06743742f, -0.04420152f, -0.01268575f, 
    -0.02048190f, -0.06008076f, 0.01422225f, 0.00743185f, -0.05651481f, -0.01780188f, 0.03677743f, 0.03502654f, 
    -0.05748805f, 0.03285375f, 0.02912266f, 0.03456868f, 0.03262436f, 0.03798119f, 0.03185529f, -0.01966061f, 
    -0.04340397f, -0.06575248f, 0.02119107f, -0.05397917f, 0.03542644f, 0.01318656f, -0.01266040f, 0.03387959f, 
    -0.00363323f, -0.01140727f, 0.00091499f, -0.06229583f, 0.02828949f, -0.00156365f, 0.00346364f, -0.06561203f, 
    -0.07871355f, -0.07686564f, 0.02172178f, -0.04355096f, 0.03724350f, 0.03166087f, -0.00864160f, -0.02918719f, 
    -0.04687751f, -0.05882413f, -0.06621144f, -0.05479424f, 0.03871034f, 0.02455470f, -0.05536224f, -0.02124186f, 
    0.01109871f, -0.02596201f, -0.04273252f, 0.03746416f, -0.07811014f, -0.05778822f, -0.02677337f, -0.06702203f, 
    0.03613405f, -0.01259598f, -0.02571966f, 0.01736396f, 0.03544854f, -0.03464489f, -0.02014813f, -0.02541711f, 
    -0.03216912f, 0.02316245f, -0.07154950f, -0.03306210f, -0.00322009f, -0.04192054f, 0.00445591f, 0.00584399f, 
    0.03117803f, -0.02361311f, 0.03396676f, -0.04968510f, 0.01287209f, -0.04232148f, -0.00996752f, 0.00719543f, 
    0.05516510f, 0.03149179f, -0.06329682f, -0.02958347f, -0.03641069f, -0.00549299f, -0.03136703f, 0.02552116f, 
    -0.03772457f, -0.01650656f, -0.04989683f, -0.01551651f, 0.00628251f, 0.00867940f, 0.01888360f, 0.02032658f, 
    -0.03981327f, 0.00942932f, 0.01299668f, -0.06259570f, -0.02854490f, -0.01003127f, -0.07340056f, 0.00377564f, 
    -0.05796289f, 0.04157756f, 0.02226273f, -0.01067786f, -0.02811822f, 0.01286179f, 0.01724173f, -0.02239234f, 
    0.00166169f, -0.06514720f, 0.03642435f, -0.01989897f, -0.03816990f, -0.00835329f, 0.04293415f, 0.03363921f, 
    0.00662967f, 0.01250170f, 0.01671503f, -0.01294956f, -0.03534165f, -0.04553987f, -0.03591686f, 0.03271250f, 
    0.06253061f, 0.04148844f, 0.03236184f, 0.01573459f, 0.04515107f, -0.05394498f, -0.08028600f, -0.01648173f, 
    -0.07120232f, 0.00509966f, -0.05973125f, -0.05075572f, 0.02206434f, 0.00973904f, 0.02526990f, 0.01675516f, 
    0.01052672f, -0.07638524f, -0.06092732f, -0.02982821f, -0.02382028f, -0.04047567f, -0.01188229f, -0.00676585f, 
    -0.04820140f, -0.00228560f, 0.00271311f, 0.01362311f, -0.03138465f, -0.04251024f, -0.05842914f, 0.00225613f, 
    -0.07448401f, -0.05145603f, -0.04755474f, -0.04443671f, 0.00036434f, -0.01862766f, 0.03657904f, -0.06414147f, 
    0.01061809f, 0.01559949f, 0.03541455f, -0.03769569f, -0.01785418f, 0.03349601f, -0.02026821f, -0.01071648f, 
    0.02199960f, 0.00734788f, 0.00369757f, 0.00103128f, -0.01245868f, 0.00861875f, -0.00910978f, 0.02157092f, 
    -0.08173423f, 0.01196198f, 0.00472285f, -0.06132659f, -0.00650537f, 0.04324552f, -0.07224052f, 0.05254294f, 
    0.02205378f, -0.06559642f, -0.01581837f, -0.01554692f, -0.06916595f, -0.01850649f, 0.00990610f, -0.01639822f, 
    -0.03739600f, 0.00083146f, -0.03955107f, -0.05592791f, -0.00966834f, -0.06072768f, 0.00220495f, 0.04453837f, 
    -0.00241794f, 0.05353378f, 0.04791186f, 0.02024143f, -0.00145185f, -0.04191908f, 0.01214991f, 0.03674358f, 
    0.03461959f, 0.02005097f, -0.03535889f, 0.02085990f, 0.01563877f, 0.04886157f, -0.01749145f, -0.00737243f, 
    -0.04918133f, -0.04676608f, 0.02508722f, 0.06232983f, 0.03504263f, 0.03221840f, 0.03384659f, -0.05382519f, 
    -0.03551571f, -0.05853197f, -0.04391914f, -0.03325280f, 0.05491325f, 0.02188281f, 0.01364973f, -0.04117233f, 
    0.03052024f, -0.04620802f, -0.03074757f, -0.05756952f, -0.05913499f, 0.01205360f, -0.02486745f, -0.01238782f, 
    0.00509652f, -0.01336093f, -0.04921878f, -0.06875117f, -0.06397806f, 0.02922860f, 0.00880169f, -0.01857852f, 
    0.02856555f, -0.05633960f, -0.04057823f, -0.04437286f, 0.01028111f, -0.03874062f, -0.00141260f, 0.02801724f, 
    0.01948556f, -0.00997104f, -0.02398134f, -0.06487408f, -0.05212752f, 0.04245239f, -0.06533929f, -0.04899349f, 
    0.03227989f, 0.05035431f, -0.04712631f, -0.04010336f, 0.03422229f, 0.00279946f, -0.05822195f, -0.00702467f, 
    0.02544541f, -0.01353847f, 0.01601491f, -0.02142845f, -0.00504919f, -0.01204206f, 0.02455040f, -0.06217105f, 
    0.00498858f, -0.06040522f, -0.00483925f, 0.01285619f, 0.03602939f, 0.02448381f, -0.00012663f, -0.01782862f, 
    -0.04744171f, -0.00510891f, 0.01579405f, -0.01374546f, -0.00566812f, 0.04882667f, 0.00580500f, 0.04387345f, 
    -0.01834747f, -0.06013645f, 0.01045156f, -0.06252781f, 0.01211572f, -0.01791605f, 0.00597867f, -0.03883643f, 
    -0.03982751f, -0.00456474f, -0.06086556f, -0.02326797f, -0.00682793f, 0.03635646f, -0.03748378f, -0.05323159f, 
    0.01354414f, -0.02481477f, 0.02290499f, 0.04697197f, 0.03876418f, 0.00509759f, -0.00831047f, 0.04328797f, 
    0.04529320f, 0.04980274f, -0.06226856f, 0.00041327f, 0.03630867f, 0.03161725f, 0.00878444f, -0.02855148f, 
    0.04856062f, -0.04287390f, -0.02421741f, -0.04846928f, 0.03572255f, -0.03575865f, -0.00643691f, 0.02112054f, 
    0.02028049f, -0.01480635f, -0.06146165f, -0.05574414f, -0.04950093f, 0.01605590f, -0.06453422f, -0.06311471f, 
    0.04681541f, -0.04228218f, 0.01872949f, -0.03232283f, -0.06341073f, -0.00106786f, -0.04893284f, -0.00290519f, 
    0.00486224f, -0.01386725f, 0.02322532f, 0.02680854f, 0.04399264f, 0.05080410f, 0.02761357f, -0.03107182f, 
    -0.03572795f, 0.04875511f, -0.01163256f, 0.03131910f, -0.04206814f, -0.01544048f, -0.03831738f, -0.02778802f, 
    0.03315628f, 0.00433386f, 0.04956982f, 0.00817486f, 0.01640325f, -0.01220118f, -0.06085837f, -0.03974581f, 
    0.00523814f, -0.03942060f, -0.02560890f, 0.04324694f, -0.06351171f, 0.01693575f, 0.04918400f, -0.01654738f, 
    -0.01175916f, -0.00041963f, 0.02718698f, 0.04337738f, -0.06072498f, -0.06033511f, -0.03056943f, -0.05500727f, 
    -0.04689667f, -0.05595397f, -0.01851474f, -0.05548853f, 0.00070657f, -0.04213205f, -0.01916778f, 0.04388110f, 
    0.03315000f, -0.05864577f, 0.01327965f, 0.02238022f, -0.00689890f, -0.01693190f, -0.01775708f, -0.00123161f, 
    -0.01158915f, -0.03070953f, 0.02116331f, 0.01674751f, 0.00033732f, -0.01998927f, -0.04342467f, -0.00111662f, 
    0.04683116f, -0.05448448f, 0.04495642f, -0.05346233f, -0.02076925f, -0.06101786f, 0.01621981f, -0.04408156f, 
    0.03649530f, -0.01874867f, 0.05050972f, 0.03897012f, -0.00758300f, -0.02144059f, -0.04276213f, -0.05499944f, 
    -0.04965414f, 0.04593683f, -0.03400035f, -0.06415458f, -0.02607724f, -0.00375262f, -0.06157726f, -0.00222719f, 
    -0.05630283f, 0.03447543f, 0.04761446f, 0.00406875f, 0.00740146f, 0.00256502f, -0.04015154f, -0.04316451f, 
    0.03778384f, 0.01174180f, -0.04275907f, -0.06420375f, -0.00264173f, 0.02093597f, -0.04878053f, -0.06403345f, 
    0.05020125f, -0.00064286f, -0.05364509f, 0.00585345f, 0.04983861f, 0.05094160f, -0.01033403f, 0.02019672f, 
    -0.00832249f, 0.04863603f, -0.05753576f, -0.00512830f, 0.00236349f, -0.05703897f, -0.05753896f, 0.00049862f, 
    0.00031027f, 0.05259991f, 0.05112948f, -0.06349964f, -0.02912651f, 0.04715268f, 0.02894329f, 0.03618512f, 
    -0.01499013f, -0.04195288f, 0.04563268f, -0.02043499f, -0.00076681f, -0.03068852f, 0.04967703f, -0.03613780f, 
    -0.00447232f, -0.01271027f, -0.01500641f, -0.03358795f, -0.05692174f, -0.03863882f, -0.02786289f, 0.01144960f, 
    0.04797712f, -0.00862927f, -0.02741148f, -0.01851907f, 0.03154083f, -0.05219441f, -0.04784914f, 0.02164405f, 
    -0.05491424f, -0.01815061f, 0.00698430f, -0.02719326f, -0.05285099f, -0.02889259f, -0.03211875f, -0.01266393f, 
    0.04065638f, -0.05935413f, -0.01811590f, -0.00879306f, 0.02932672f, 0.02324695f, -0.04142082f, -0.03002184f, 
    -0.03775428f, -0.06110515f, 0.03957829f, -0.02663204f, -0.05925672f, 0.04800263f, -0.02057080f, -0.02677266f, 
    -0.02188263f, -0.04962987f, 0.00997402f, -0.00483060f, -0.02016872f, 0.04110250f, 0.00970714f, 0.03340411f, 
    -0.00555037f, -0.00195275f, -0.01980923f, 0.01718092f, 0.05105070f, -0.00175270f, -0.03921034f, -0.01536639f, 
    -0.00021602f, 0.04070566f, -0.04510575f, 0.01502206f, -0.04720430f, -0.01596011f, -0.01024143f, 0.03874885f, 
    0.02203203f, -0.04279834f, 0.13904548f, -0.19510634f, -0.00673818f, -0.15118620f, 0.11992300f, 0.07905608f, 
    0.08380357f, 0.31442690f, 0.04766860f, -0.15684724f, -0.21609043f, 0.10273372f, 0.04138968f, 0.00773831f, 
    -0.01293452f, -0.15139575f, -0.03987879f, 0.26289585f, 0.14303663f, -0.06178521f, -0.03776827f, 0.00364581f, 
    0.19816697f, -0.06962831f, -0.05683951f, -0.14406592f, -0.02939835f, -0.07332257f, -0.11754654f, 0.10713241f, 
    -0.20344405f, -0.05379550f, -0.07754862f, 0.29096413f, 0.06870472f, -0.02204833f, 0.32567459f, 0.04449023f, 
    -0.15439938f, 0.16558023f, 0.09614103f, 0.04218588f, 0.06680159f, 0.08961277f, 0.20106725f, -0.03987711f, 
    -0.13165760f, -0.08319797f, -0.06768343f, 0.05313923f, 0.01157219f, 0.08810238f, 0.03271132f, 0.08717795f, 
    0.06335384f, 0.04230101f, -0.16798037f, -0.08022140f, 0.08503465f, -0.09037109f, 0.09479141f, 0.09666756f, 
    -0.30145893f, -0.14215714f, -0.11957338f, -0.21210229f, 0.11333870f, 0.16489744f, -0.21417983f, -0.25611588f, 
    0.20375100f, -0.13024759f, -0.16848868f, -0.07047737f, 0.11060145f, -0.18702509f, 0.08307740f, 0.10455260f, 
    0.16341808f, 0.39343792f, 0.30548650f, 0.16565390f, 0.05350868f, -0.06362329f, -0.00262028f, 0.01228367f, 
    0.06692158f, 0.01267276f, 0.47235548f, 0.10256951f, 0.11415739f, -0.04449804f, -0.07719658f, 0.03924351f, 
    -0.02529282f, 0.00161190f, 0.10865346f, 0.20871516f, -0.13510382f, 0.02005279f, 0.00917023f, -0.03977806f, 
    -0.03031223f, -0.09573412f, 0.01228510f, -0.02455459f, -0.36601648f, -0.11091551f, -0.04126979f, -0.14425114f, 
    0.00320440f, 0.11090475f, 0.07998027f, -0.01457267f, 0.11895999f, -0.00662813f, 0.03695909f, 0.01675737f, 
    -0.05443618f, -0.05837826f, -0.04814376f, 0.00960929f, 0.01097185f, -0.16873810f, 0.13593873f, -0.26480484f, 
    -0.18158232f, -0.04168609f, -0.09910246f, 0.03794975f, 0.01360363f, 0.02836300f, -0.05616448f, 0.14961131f, 
    -0.14487571f, 0.08545750f, 0.14866196f, -0.06325124f, -0.06548735f, 0.00336825f, -0.02989160f, 0.02004254f, 
    -0.03026319f, 0.09575590f, 0.16129424f, 0.01753284f, -0.07763743f, -0.06680751f, 0.07993204f, -0.14159870f, 
    0.09332611f, -0.05885167f, 0.20741799f, -0.02703798f, 0.00499655f, 0.19159113f, 0.01787009f, 0.07579670f, 
    -0.08254977f, 0.01914040f, -0.26342851f, 0.12610185f, -0.04287308f, 0.09398186f, -0.13951859f, 0.09436907f, 
    -0.11225098f, -0.06617025f, -0.02711747f, 0.19172569f, 0.10236212f, 0.04630024f, -0.01356226f, -0.04684160f, 
    -0.08786990f, -0.13214341f, 0.01557832f, 0.08558249f, 0.02841509f, -0.01387697f, -0.10687413f, -0.11601444f, 
    -0.17328624f, 0.08781705f, 0.02202849f, -0.02864394f, -0.09619941f, 0.07885620f, 0.24570671f, -0.01201706f, 
    0.11456553f, -0.01803533f, -0.04282207f, -0.03729969f, -0.12373204f, -0.10367102f, -0.08542044f, 0.08228999f, 
    -0.00756380f, -0.00422401f, 0.03632261f, 0.01827468f, -0.04355697f, 0.06429079f, -0.03188588f, 0.02534331f, 
    0.06114827f, 0.13471536f, 0.03993547f, -0.09480440f, -0.00076622f, 0.03648708f, 0.14068149f, -0.11053051f, 
    0.32145506f, 0.00828166f, -0.03585989f, -0.13329147f, -0.21643454f, 0.11976957f, -0.03707164f, -0.04429320f, 
    0.10101614f, 0.12698549f, 0.02602451f, 0.32707497f, 0.03627307f, -0.03987083f, 0.01103485f, -0.04555787f, 
    -0.11407713f, -0.06848414f, -0.20205115f, -0.05718431f, -0.00136747f, 0.17937495f, -0.07531749f, -0.06228881f, 
    0.05926660f, -0.14506279f, 0.04069605f, -0.26881292f, -0.36604625f, -0.20895480f, 0.09991217f, -0.12530188f, 
    0.04591197f, -0.05111091f, -0.04380321f, 0.09302555f, -0.01513883f, 0.11619979f, 0.36949754f, -0.07273348f, 
    0.04922967f, -0.02002167f, 0.04108492f, -0.17489809f, -0.05275093f, -0.09704371f, 0.17109619f, 0.08092287f, 
    -0.02424463f, -0.08444480f, 0.08192258f, -0.04413001f, -0.10179614f, -0.13513467f, 0.13928448f, 0.17972827f, 
    0.02814400f, -0.12323616f, 0.00042623f, 0.04037757f, -0.14468992f, 0.17252260f, -0.03499603f, -0.12856020f, 
    0.04521332f, -0.04122491f, 0.10325343f, 0.07619709f, 0.04784562f, -0.04359961f, 0.01406403f, 0.10857615f, 
    -0.02606360f, -0.05308630f, -0.04158662f, -0.01122832f, -0.00103739f, -0.04063855f, -0.05600272f, 0.04072979f, 
    0.00320877f, -0.04344680f, -0.03841634f, 0.02921220f, 0.03700824f, 0.02183520f, -0.02720625f, 0.02023728f, 
    -0.01636515f, -0.02922310f, 0.01711361f, 0.02151168f, -0.01997780f, -0.03348353f, 0.05079001f, -0.01587224f, 
    -0.06163689f, 0.01647911f, -0.01386963f, -0.05352864f, 0.02273214f, -0.00794396f, 0.02533874f, 0.03911230f, 
    -0.02073273f, -0.01025967f, -0.01532609f, 0.00278952f, -0.03888327f, -0.03757152f, 0.04699070f, 0.01705894f, 
    -0.01323394f, 0.02993941f, -0.04405912f, -0.00868363f, 0.02211830f, 0.02755542f, -0.02010855f, 0.01353298f, 
    -0.03412046f, -0.05859470f, -0.05948448f, -0.02670734f, -0.06824428f, -0.01998698f, -0.01765277f, -0.05669010f, 
    -0.00084036f, 0.03004462f, -0.00449602f, -0.00384904f, -0.01730249f, -0.00268736f, -0.00359911f, 0.03653564f, 
    0.04658870f, 0.00621790f, 0.04923141f, -0.02976936f, 0.04660649f, 0.02270265f, -0.05350442f, 0.01716858f, 
    -0.02243765f, 0.01765430f, -0.05267232f, -0.01151745f, 0.00114417f, -0.06598968f, -0.03159427f, 0.03478206f, 
    0.00789004f, -0.02389446f, 0.00143102f, 0.00550399f, -0.03861840f, -0.06138968f, 0.03892576f, 0.02009360f, 
    0.02824125f, 0.03995598f, 0.00942034f, -0.02461653f, -0.04746320f, 0.04715114f, 0.03525729f, 0.04488136f, 
    -0.05986080f, 0.04087507f, 0.01819589f, -0.04136539f, -0.02330051f, -0.05869107f, 0.04429125f, -0.03345379f, 
    0.01999393f, 0.04440776f, 0.04464626f, 0.02472417f, -0.02507263f, 0.03636553f, -0.04074119f, -0.05306508f, 
    -0.06342629f, -0.05822088f, -0.00202938f, 0.02049521f, -0.03050705f, -0.00531987f, -0.06202573f, 0.01537238f, 
    0.04619112f, -0.03500629f, -0.06766535f, 0.04210344f, -0.02847424f, -0.01247651f, -0.03426599f, 0.03198962f, 
    -0.04047418f, -0.03922540f, -0.06578873f, 0.02528810f, 0.01403969f, -0.03053674f, 0.03295380f, 0.01648686f, 
    0.01360405f, -0.02448292f, 0.01310008f, -0.00012225f, -0.00550106f, 0.02470003f, -0.00958059f, 0.00216056f, 
    -0.05713879f, -0.02651488f, -0.03265430f, -0.04100572f, 0.04379806f, -0.04030899f, 0.00552234f, -0.04278468f, 
    0.04123179f, 0.02027551f, -0.05280373f, -0.00406211f, -0.02320090f, 0.01338015f, 0.01022005f, 0.04480290f, 
    0.03715798f, -0.05867572f, 0.02386517f, -0.05928653f, -0.06065120f, -0.04941669f, 0.01695764f, -0.03678288f, 
    -0.05360054f, 0.01937138f, -0.02887292f, -0.01181622f, -0.06640210f, -0.02824320f, -0.02453110f, 0.04081211f, 
    -0.00350430f, -0.01825675f, 0.02547431f, -0.02103858f, 0.02218640f, -0.03228311f, 0.00538159f, -0.05771827f, 
    0.00081512f, 0.03949914f, -0.03835295f, 0.04517773f, -0.05448454f, -0.06795714f, 0.04615613f, 0.01074137f, 
    0.00352790f, 0.02199299f, -0.01083584f, -0.04268743f, 0.00308137f, -0.02156994f, -0.03858905f, 0.01135005f, 
    0.01291578f, -0.05566208f, 0.02446300f, -0.02512773f, -0.03027736f, -0.02783469f, -0.03543459f, 0.00601135f, 
    -0.01053267f, 0.02215248f, -0.05650111f, 0.00387896f, 0.01317148f, 0.02547731f, -0.06374687f, 0.01434285f, 
    -0.00587740f, 0.04985204f, 0.00426226f, -0.04329883f, 0.04641230f, 0.03537058f, -0.00165696f, 0.04719079f, 
    -0.02680647f, -0.02619570f, 0.00073294f, 0.04773861f, -0.06618996f, -0.05765821f, -0.03795171f, 0.00624645f, 
    -0.05811012f, 0.04890771f, -0.00321932f, 0.01865999f, -0.02028323f, -0.05294103f, -0.04065885f, -0.06060267f, 
    -0.05251872f, -0.04238563f, -0.05163811f, -0.05465471f, 0.02239407f, 0.04361499f, -0.06578746f, -0.00909679f, 
    0.03155242f, -0.04259432f, 0.02852268f, -0.01175903f, 0.01151621f, 0.01689805f, -0.02984027f, -0.04626318f, 
    -0.04947119f, -0.02923070f, 0.04399714f, -0.01552433f, 0.00748778f, 0.00957155f, -0.00399692f, 0.04031790f, 
    0.01298614f, 0.03760773f, 0.01703493f, -0.01964916f, -0.06042166f, 0.03588497f, -0.05568561f, -0.03203573f, 
    -0.04019788f, 0.00898929f, 0.01711228f, -0.00057623f, 0.01796256f, 0.01691980f, -0.04758872f, 0.04552215f, 
    -0.02417487f, -0.03266906f, -0.04221894f, 0.03607889f, -0.02388010f, 0.01404614f, -0.01037016f, -0.03396868f, 
    -0.02925821f, 0.19561791f, 0.06410101f, -0.12582673f, -0.00375062f, -0.02638933f, -0.03875872f, -0.00862117f, 
    0.12463883f, -0.03501116f, 0.06437336f, 0.07811610f, 0.09815224f, -0.11821762f, 0.11789386f, 0.14767954f, 
    0.03922869f, -0.19611211f, 0.26142764f, -0.01245541f, 0.25361660f, -0.05825486f, 0.06547528f, -0.29143947f, 
    -0.02500577f, 0.18676014f, -0.07459128f, -0.21373920f, 0.04437677f, 0.04856518f, 0.00417050f, 0.00950771f, 
    0.04639403f, -0.09668244f, 0.10289901f, 0.00239060f, 0.16043960f, -0.11521494f, -0.37426782f, -0.24382226f, 
    0.03562726f, -0.07413667f, 0.06567842f, 0.01192715f, -0.04641638f, -0.00558880f, 0.19590698f, 0.17814033f, 
    -0.10193413f, 0.04746034f, 0.01955327f, 0.14535403f, 0.13791151f, -0.09486548f, 0.02093074f, 0.21266200f, 
    0.14611244f, -0.16061255f, 0.01033201f, -0.04949410f, -0.02217549f, -0.05270830f, -0.00266715f, 0.50304210f, 
    0.09296373f, -0.13745548f, -0.02912308f, -0.02942308f, -0.13347533f, 0.15971424f, 0.12504441f, -0.16759665f, 
    -0.04098693f, -0.27910858f, -0.45110291f, -0.05171297f, 0.19144876f, 0.27847025f, 0.18133979f, 0.21142699f, 
    -0.03698453f, 0.13536903f, 0.24074367f, 0.09258281f, -0.07300126f, -0.08748729f, -0.11876386f, -0.06240324f, 
    -0.03785350f, 0.17841104f, -0.08034719f, -0.13387524f, -0.15359509f, 0.05792733f, 0.15315017f, -0.12054770f, 
    -0.01914758f, -0.04464577f, -0.10659903f, 0.09606970f, -0.08509866f, -0.18423641f, 0.04301248f, -0.05406157f, 
    0.16002992f, 0.11064089f, 0.07396936f, 0.00886750f, -0.24101418f, -0.49659550f, -0.37113488f, -0.03368559f, 
    0.05019166f, 0.09116087f, 0.02891655f, -0.02510429f, 0.14005500f, -0.21796954f, -0.29004574f, -0.20185007f, 
    -0.01014952f, -0.04132764f, -0.10609313f, -0.06016659f, -0.08608214f, -0.05970255f, 0.39210749f, 0.03007868f, 
    -0.13457324f, 0.05660511f, 0.03097351f, 0.05066086f, 0.06665111f, -0.10099342f, -0.07052349f, 0.26878935f, 
    -0.09326419f, -0.44420168f, -0.07959397f, 0.00104337f, 0.07334211f, -0.06710775f, -0.10392924f, -0.07094504f, 
    0.20079006f, 0.11708207f, -0.11163798f, -0.29489714f, -0.31993067f, -0.09890462f, 0.01649741f, 0.04568498f, 
    0.00660258f, -0.28300801f, -0.27518404f, -0.02757616f, 0.17377217f, 0.01629541f, 0.03240560f, 0.06194415f, 
    0.00466634f, 0.08599280f, 0.02810814f, 0.02004530f, -0.02374589f, 0.07984503f, 0.07626684f, 0.11472631f, 
    -0.00418926f, -0.02745505f, 0.09737624f, 0.16755228f, 0.11532648f, -0.00384307f, 0.06242763f, 0.12188448f, 
    -0.07241856f, 0.03699462f, 0.06359155f, 0.14964563f, 0.00360262f, 0.02820488f, -0.05424489f, -0.02603202f, 
    0.09572690f, 0.06719200f, 0.09574291f, -0.06406587f, -0.05939627f, 0.07213522f, 0.02393985f, 0.13483527f, 
    0.17547505f, -0.02373925f, 0.02047763f, 0.10930125f, 0.02016646f, -0.03606521f, -0.12454342f, 0.18785399f, 
    0.26500356f, 0.16851497f, 0.04200740f, 0.05803744f, -0.01644747f, 0.13914362f, 0.09980232f, -0.02636476f, 
    -0.20218305f, -0.43126664f, 0.14168002f, 0.12611924f, 0.09178693f, 0.10720419f, 0.01680444f, -0.08311432f, 
    -0.22252378f, -0.11900184f, -0.22727445f, -0.06436273f, 0.15791652f, -0.04630531f, -0.07092177f, -0.20870239f, 
    -0.06185074f, -0.08151239f, -0.31859833f, -0.09184004f, -0.05113648f, 0.02025337f, -0.04593653f, -0.06015217f, 
    0.04465490f, -0.01005049f, -0.18515734f, -0.24859014f, -0.07579833f, -0.05060070f, 0.07674251f, -0.06135953f, 
    -0.00462819f, 0.17028479f, 0.09905683f, 0.15424372f, -0.16582446f, -0.39219308f, -0.24584046f, -0.01620045f, 
    0.09638875f, -0.04117119f, 0.05135525f, 0.07189447f, 0.43343005f, -0.17799370f, -0.31812012f, -0.05386300f, 
    0.19214718f, -0.02798094f, -0.10827811f, -0.07538236f, -0.02101662f, 0.17846225f, -0.56616026f, -0.36148000f, 
    -0.00950245f, 0.02278617f, 0.12093011f, 0.05577783f, 0.06418006f, 0.02107727f, 0.00738451f, -0.16945513f, 
    -0.34639549f, 0.04610014f, 0.13360289f, -0.12828797f, 0.10573361f, -0.13691951f, -0.04828731f, -0.15112486f, 
    -0.17622148f, -0.22542770f, -0.12709479f, 0.13318224f, 0.02988418f, 0.11923891f, 0.11372152f, 0.15008177f, 
    -0.00404938f, -0.03751990f, -0.04786238f, 0.01280661f, 0.03771765f, -0.03235741f, 0.00111323f, -0.05099834f, 
    0.00498492f, 0.03638410f, -0.03875880f, 0.04125378f, -0.06760453f, 0.02776792f, -0.06502540f, 0.02878583f, 
    0.02573816f, 0.01852315f, -0.00378815f, 0.04754306f, -0.03281295f, -0.04205138f, -0.02321645f, -0.01847989f, 
    0.02782173f, 0.00436060f, 0.03970588f, 0.01110542f, -0.02992532f, -0.06556369f, -0.04628955f, 0.04531171f, 
    -0.01303897f, 0.04749897f, -0.04555994f, 0.00656887f, 0.04965069f, 0.03538388f, -0.00909454f, -0.03268937f, 
    -0.02163476f, -0.00264513f, -0.02828311f, 0.00520370f, -0.00078228f, 0.00416322f, -0.02445407f, -0.00807326f, 
    0.00911690f, 0.00387265f, -0.06859411f, 0.03564536f, 0.00641640f, 0.02587531f, 0.03247574f, 0.04055025f, 
    -0.01911529f, -0.00031409f, -0.06637051f, 0.00098870f, 0.02802928f, -0.07218413f, -0.05375015f, 0.00238451f, 
    -0.02775964f, -0.03198029f, 0.02980907f, 0.01865600f, 0.01201521f, -0.00067306f, 0.00249898f, -0.04110495f, 
    -0.05801332f, -0.06455772f, -0.04520860f, -0.05990344f, -0.03540400f, 0.02523351f, -0.01858794f, 0.04047025f, 
    -0.04818065f, -0.05249980f, -0.01496456f, 0.03965170f, 0.02990820f, 0.00969855f, -0.00584974f, 0.03263482f, 
    -0.05852403f, -0.04753611f, 0.01920498f, -0.04772788f, -0.06054410f, -0.04468214f, -0.01398570f, -0.05115088f, 
    -0.03848424f, 0.00763989f, 0.01409241f, 0.03867111f, -0.05931162f, -0.04386789f, -0.02490667f, -0.06258411f, 
    -0.07200485f, -0.00156708f, 0.03768462f, 0.03015373f, -0.01590256f, 0.02910140f, 0.01661226f, 0.01836069f, 
    0.02997943f, -0.02618427f, -0.04108538f, -0.01795367f, -0.01553164f, 0.01078926f, 0.04919009f, -0.04127502f, 
    0.00300947f, 0.02439338f, 0.03354836f, -0.00762692f, 0.03821494f, 0.04673721f, -0.04492573f, 0.00488541f, 
    0.04252414f, -0.03330687f, 0.03782087f, -0.01389818f, 0.03696682f, 0.02312275f, -0.00498206f, -0.03835835f, 
    0.02038343f, -0.01259199f, -0.05973347f, -0.02676502f, -0.05895052f, 0.01579123f, -0.02720397f, -0.05514353f, 
    -0.01415191f, 0.05506166f, 0.00351131f, 0.02139602f, -0.02012298f, -0.00978317f, 0.00789315f, 0.03441009f, 
    0.03587367f, -0.05798902f, 0.03752880f, -0.03613436f, 0.00325115f, -0.05656008f, 0.05002543f, -0.04398400f, 
    -0.04064905f, 0.03991062f, 0.01894355f, 0.04077540f, 0.03642612f, -0.01429439f, 0.02592459f, -0.05078292f, 
    0.03956952f, 0.04779120f, -0.04975868f, -0.03786339f, 0.02768767f, -0.01624006f, -0.05642526f, 0.04109989f, 
    -0.04405662f, 0.02758661f, -0.01800802f, 0.00731448f, 0.02563434f, 0.00764976f, -0.00316949f, 0.00346455f, 
    0.03127724f, 0.01007267f, 0.00183397f, 0.03794037f, 0.01756286f, -0.04568223f, -0.00927139f, 0.02280232f, 
    -0.05060521f, -0.02000608f, -0.03672336f, 0.04300105f, 0.00360631f, 0.03612269f, -0.04512983f, 0.02937353f, 
    -0.00303307f, -0.06233869f, -0.03922383f, 0.01294054f, -0.01463287f, -0.03526643f, -0.05499613f, -0.02217414f, 
    -0.03508417f, -0.01523857f, -0.00705708f, -0.02713296f, -0.04326443f, -0.02714150f, -0.03794612f, -0.00412208f, 
    0.03673741f, -0.06801946f, 0.02920990f, -0.00875215f, 0.00771986f, -0.07225034f, -0.05984702f, 0.03998514f, 
    -0.06845216f, -0.01616912f, 0.03234109f, 0.04110689f, 0.01342219f, 0.02485251f, -0.04482362f, 0.05008858f, 
    0.04887511f, 0.02526413f, 0.04661753f, 0.02952531f, -0.00554420f, -0.04802617f, 0.05503829f, 0.02814239f, 
    -0.05114591f, -0.02954669f, 0.01590502f, 0.03746652f, -0.05200464f, -0.00919346f, 0.04523535f, -0.01027355f, 
    0.05507988f, -0.01323202f, -0.05035330f, -0.01934475f, -0.06090711f, -0.01696469f, 0.02468284f, -0.05919978f, 
    0.04299990f, -0.00758946f, 0.01779266f, 0.02727270f, -0.02729579f, -0.05592192f, -0.05373637f, -0.03557513f, 
    -0.01682186f, -0.03242392f, 0.04860198f, -0.04788266f, -0.02518911f, -0.03121213f, 0.02192812f, -0.04347390f, 
    -0.02736510f, -0.01920686f, -0.01426620f, 0.00824664f, 0.02551361f, -0.01989071f, -0.02839916f, 0.01753204f, 
    0.04127771f, 0.00043061f, -0.02400031f, 0.02574234f, 0.00619676f, -0.01554956f, -0.00073024f, -0.03490840f, 
    0.05252337f, 0.02069853f, -0.13929491f, 0.02154960f, -0.15143918f, -0.04440289f, -0.06845389f, -0.00410929f, 
    -0.17309286f, 0.03614072f, 0.21180135f, 0.19680113f, 0.03683290f, -0.02407428f, -0.11527984f, -0.17955077f, 
    -0.08134069f, 0.03095421f, 0.24888198f, -0.14746532f, 0.29414576f, 0.16527490f, -0.02494650f, -0.09238134f, 
    -0.04684130f, 0.05550394f, 0.02516272f, -0.19982231f, 0.02257297f, 0.17500077f, -0.00500884f, -0.01286124f, 
    0.00258364f, -0.00644966f, -0.12786898f, -0.15499897f, -0.30830491f, -0.02504042f, -0.14757667f, -0.01495822f, 
    0.05048222f, -0.02691020f, -0.00804141f, 0.01304344f, 0.19129361f, 0.14514396f, -0.05428933f, 0.11633946f, 
    0.12141977f, -0.08039581f, 0.04626947f, -0.09228095f, 0.04832242f, -0.12259811f, 0.06471365f, -0.04664031f, 
    0.08940855f, 0.04151620f, 0.00044663f, 0.07444857f, -0.06135985f, 0.05021821f, -0.17436856f, -0.01243298f, 
    0.21642418f, -0.05310735f, -0.00086116f, -0.03321824f, 0.21932162f, 0.11206372f, -0.19288217f, -0.06529500f, 
    0.27736881f, 0.07961659f, 0.15048999f, 0.08635796f, -0.03359510f, 0.31115258f, 0.03086155f, 0.18676907f, 
    0.12026007f, -0.21133709f, -0.10741489f, 0.08966887f, 0.04161043f, -0.07104653f, -0.19859305f, -0.02469286f, 
    -0.04472001f, 0.01721271f, -0.19115998f, 0.00558175f, 0.04888058f, 0.04006544f, 0.04136339f, -0.00406349f, 
    0.05965937f, -0.05448708f, -0.03755177f, -0.01700916f, 0.17047438f, 0.02265409f, -0.05448864f, 0.01338432f, 
    -0.07155854f, -0.05880698f, 0.03277055f, -0.33734959f, 0.08333856f, -0.02618936f, 0.24083087f, -0.04578732f, 
    -0.06622074f, 0.22481136f, 0.06863915f, 0.13991894f, 0.18570848f, -0.07430846f, 0.03203353f, -0.20420182f, 
    -0.19401018f, 0.03936936f, -0.33069608f, -0.04902955f, 0.03788579f, -0.40879527f, 0.07107449f, 0.08387296f, 
    0.07331660f, 0.01390672f, 0.05786129f, -0.01063612f, -0.06326362f, -0.04942478f, -0.16718388f, -0.21177690f, 
    -0.24993694f, 0.03776270f, -0.09942081f, 0.05533453f, -0.04155494f, -0.16039602f, -0.01896393f, 0.02158328f, 
    -0.43974483f, -0.14037091f, -0.12046034f, -0.13092446f, 0.12207834f, 0.08660595f, -0.03118909f, 0.00903453f, 
    0.11661084f, 0.04417174f, 0.02625209f, 0.14835870f, 0.12722506f, 0.10346152f, -0.04970384f, 0.09995421f, 
    0.06193220f, 0.29099718f, 0.14179447f, 0.08476176f, -0.04355817f, 0.08027288f, 0.05707265f, 0.03936002f, 
    -0.08548690f, -0.10709015f, -0.27931586f, -0.10629345f, 0.16080695f, 0.06101215f, 0.03351527f, -0.06484021f, 
    0.05358874f, 0.02927388f, -0.02361879f, 0.03511400f, 0.07530515f, 0.03225220f, -0.15245639f, 0.01411813f, 
    -0.03343475f, 0.01874525f, -0.19250035f, 0.06482960f, -0.19511129f, -0.07933279f, 0.19329120f, 0.02922487f, 
    0.14581628f, 0.09497952f, 0.12508254f, -0.07713592f, -0.06542791f, -0.11410078f, 0.07078749f, -0.05540688f, 
    0.05935802f, 0.14325672f, 0.15522482f, 0.02238969f, 0.16438180f, -0.02593111f, 0.12008465f, -0.09400332f, 
    0.02444453f, 0.16171253f, -0.03779565f, -0.09088571f, 0.05089337f, -0.07544452f, 0.17833714f, 0.03221844f, 
    0.20287549f, 0.02833726f, 0.02387406f, -0.15465219f, 0.00921086f, 0.07396793f, -0.02423503f, -0.00796665f, 
    -0.14643796f, -0.06865396f, -0.00627688f, -0.05318507f, -0.04444197f, 0.00734750f, -0.05668499f, 0.01339703f, 
    -0.05402140f, 0.03299177f, -0.30273345f, 0.06699114f, -0.22453415f, -0.07033372f, -0.05314093f, -0.04701845f, 
    -0.18592362f, -0.02662543f, 0.10779006f, -0.07051844f, 0.14314106f, -0.12737772f, -0.15538208f, 0.09216711f, 
    0.08432201f, -0.05302456f, 0.10280771f, 0.15280573f, -0.05111792f, -0.19314231f, 0.26219645f, 0.06545716f, 
    -0.06804021f, 0.07598882f, 0.02447296f, 0.08981010f, 0.11641082f, 0.01376597f, -0.19037074f, 0.23050442f, 
    -0.06912059f, 0.04779406f, 0.19658069f, -0.02439377f, -0.03250445f, -0.05121598f, 0.24249253f, 0.02705598f, 
    0.46777767f, -0.11187126f, 0.04590479f, 0.18178898f, 0.17942727f, 0.09912073f, -0.22266223f, 0.22399633f, 
    -0.21378617f, 0.25636578f, -0.02393757f, 0.19724528f, 0.05400155f, 0.10715564f, 0.09360030f, -0.01122366f, 
    -0.06451487f, 0.02381182f, -0.02851136f, -0.05348577f, -0.10681418f, -0.11194048f, 0.12115449f, -0.08898727f, 
    -0.06744637f, -0.07862614f, 0.42038009f, 0.13339734f, 0.01467549f, -0.10049799f, -0.15018554f, -0.08400680f, 
    0.09624998f, -0.04801007f, -0.07403094f, 0.12857069f, 0.26098660f, -0.09242813f, -0.12234823f, 0.10979128f, 
    0.01598452f, 0.03162992f, 0.01387169f, -0.19748245f, 0.06097515f, 0.25267491f, 0.03332565f, -0.21857777f, 
    -0.15185229f, 0.00995155f, 0.05871117f, 0.07629545f, -0.07130826f, -0.25736430f, 0.25752056f, -0.21623288f, 
    -0.03926003f, -0.01964608f, 0.11901644f, 0.01762261f, -0.00081332f, 0.06410088f, -0.01883765f, 0.01560957f, 
    0.03128636f, -0.13391055f, -0.05748196f, 0.12698646f, -0.11065043f, -0.03380506f, 0.01949519f, 0.19629160f, 
    0.15148747f, -0.07186247f, -0.16505064f, 0.10258938f, -0.00016751f, 0.02752978f, -0.02395429f, 0.03918136f, 
    0.10408037f, -0.01410646f, -0.01640779f, 0.10808922f, 0.22687611f, -0.03224866f, -0.02663405f, -0.09592991f, 
    -0.21487437f, -0.41731450f, -0.28866938f, 0.01463250f, 0.05880503f, 0.20766382f, 0.03401362f, -0.20954898f, 
    -0.19585487f, 0.05112056f, 0.15560769f, 0.11010303f, -0.14876503f, -0.01738026f, -0.00261331f, -0.05859264f, 
    0.04231741f, -0.00978446f, 0.27734473f, 0.20178559f, -0.17404348f, -0.14916067f, -0.08847356f, 0.08845019f, 
    0.07623402f, 0.13991562f, -0.11434665f, -0.01319663f, 0.11592611f, -0.05731152f, 0.07765175f, 0.03156108f, 
    0.03018928f, 0.04488600f, 0.11495548f, 0.00929388f, -0.21611106f, -0.25532404f, -0.27082679f, 0.10434005f, 
    -0.01373863f, -0.01837041f, -0.00911805f, -0.07601517f, 0.04932858f, -0.44744337f, -0.04192506f, 0.18340889f, 
    0.00249380f, 0.15544388f, -0.17478685f, 0.10858365f, 0.15246028f, 0.11112242f, -0.42119712f, 0.16011414f, 
    -0.18148048f, 0.08277602f, -0.04705827f, 0.04890569f, -0.11005889f, 0.00674860f, 0.14700116f, 0.06317667f, 
    -0.00779611f, 0.07825754f, 0.09328907f, 0.08745152f, -0.22930448f, 0.14015354f, -0.00023106f, 0.04944786f, 
    -0.06427648f, 0.19693565f, 0.24213021f, 0.01543478f, -0.05102564f, -0.13109417f, 0.13667946f, 0.12986636f, 
    -0.08627987f, 0.03417423f, 0.27623507f, 0.10953855f, -0.04160221f, 0.09867264f, -0.04796269f, -0.10319638f, 
    0.08270324f, -0.04691577f, -0.31404695f, -0.07725430f, 0.13486537f, -0.04396178f, 0.00154202f, 0.09955005f, 
    0.04591831f, 0.25843450f, 0.04881228f, -0.25861177f, 0.03286779f, 0.12728365f, -0.00896520f, 0.06489384f, 
    -0.14725076f, -0.01615819f, -0.03307464f, -0.00342283f, 0.04699851f, 0.14085352f, -0.13084793f, 0.09011635f, 
    0.10622241f, -0.11761252f, 0.00084313f, -0.02552033f, 0.16286828f, -0.22558181f, 0.13675429f, 0.20352447f, 
    -0.13910021f, 0.25856778f, -0.17900631f, -0.00756287f, 0.13228419f, -0.04135344f, 0.03420587f, 0.04377522f, 
    0.07107048f, -0.00618661f, -0.06539991f, 0.03096065f, -0.03471258f, -0.06323911f, -0.00704825f, -0.11736488f, 
    0.02618795f, -0.01030895f, -0.05926358f, 0.17792207f, -0.03658457f, 0.05909060f, -0.07520612f, -0.01107048f, 
    0.00941286f, 0.19167140f, -0.17541513f, -0.02532314f, -0.06363312f, -0.00377267f, -0.05586722f, -0.16878484f, 
    0.03286823f, -0.19142763f, 0.00460124f, 0.29344833f, 0.02460491f, 0.02215209f, -0.16527745f, 0.04174450f, 
    0.04572356f, -0.02378315f, 0.21186732f, -0.36249593f, 0.14253972f, -0.03503814f, 0.05397222f, -0.11162734f, 
    0.07101646f, 0.09177870f, 0.03168545f, -0.49636716f, -0.37169152f, -0.02476078f, 0.09067230f, 0.10837717f, 
    -0.12869577f, -0.00004726f, -0.06507664f, 0.00472333f, 0.10016590f, 0.23640476f, 0.28680611f, -0.10499523f, 
    -0.17939034f, 0.19850260f, 0.10254860f, 0.06787138f, -0.02283433f, 0.05695252f, 0.17481495f, 0.11242050f, 
    -0.08498160f, -0.02748885f, 0.12055228f, -0.02047775f, -0.04744995f, 0.04373301f, -0.19809143f, 0.31395650f, 
    0.15480052f, 0.00877489f, -0.13665397f, -0.05095837f, 0.05737725f, 0.06889600f, 0.09236746f, 0.04839411f, 
    -0.08349188f, 0.27013555f, -0.00171241f, -0.24110314f, -0.12718487f, -0.00405719f, 0.04158180f, -0.03074891f, 
    0.12085386f, -0.06032858f, 0.04321180f, 0.03145954f, -0.06603009f, -0.05344408f, 0.15652297f, 0.07776843f, 
    0.08770128f, 0.09577549f, 0.17281064f, -0.04626531f, 0.17748874f, -0.00518173f, 0.13909310f, 0.02511028f, 
    0.06367088f, -0.07805351f, -0.06043009f, 0.24488015f, 0.13723551f, -0.10219680f, 0.02581004f, 0.11578734f, 
    -0.10301188f, -0.09980793f, -0.13245499f, 0.09887046f, 0.02741402f, 0.03468793f, -0.02315917f, -0.07599416f, 
    -0.02375875f, 0.06265008f, 0.20333457f, 0.17433804f, -0.02420659f, -0.05141582f, 0.09705565f, 0.00293968f, 
    -0.06791981f, -0.07035581f, 0.02255020f, 0.14237891f, 0.14091401f, 0.14479102f, 0.06008514f, -0.00813511f, 
    -0.05707752f, -0.15530606f, -0.12039544f, 0.06271587f, -0.15906054f, 0.06554223f, 0.14656998f, -0.09499307f, 
    -0.02238537f, 0.09274965f, 0.00407861f, -0.15804426f, -0.00874702f, -0.14471290f, -0.07092987f, -0.17451154f, 
    0.05018903f, 0.03514950f, -0.17876324f, 0.08833150f, -0.07003291f, -0.02303883f, 0.09742352f, -0.18432558f, 
    0.12372271f, 0.34644854f, -0.08066836f, 0.02082141f, -0.02357395f, 0.03015125f, -0.04141239f, -0.18019594f, 
    -0.04119935f, 0.00745115f, 0.01268727f, 0.20605519f, -0.00087248f, 0.00985234f, -0.00434123f, -0.01563290f, 
    -0.11814801f, 0.06532278f, 0.55745357f, -0.02481278f, -0.26035994f, 0.02193471f, -0.03796601f, 0.06106676f, 
    0.07745468f, -0.12809283f, -0.13126875f, 0.13023178f, -0.06048455f, -0.11505645f, -0.01164041f, 0.11332627f, 
    -0.02757339f, -0.20338434f, -0.06018038f, -0.14597327f, 0.32870612f, -0.05561739f, -0.07839606f, -0.08107582f, 
    -0.14345562f, 0.14682278f, 0.11185589f, 0.00586282f, 0.08676773f, 0.32977226f, 0.18161322f, 0.16042888f, 
    0.11398484f, -0.03751311f, 0.16412422f, -0.00619390f, -0.02325486f, 0.04263181f, -0.05190440f, -0.15319903f, 
    -0.01212237f, -0.04087640f, 0.02553691f, -0.06275822f, -0.19060943f, 0.01740539f, -0.03555092f, 0.42937657f, 
    0.15716018f, -0.26008657f, -0.01250860f, -0.03159436f, -0.06675433f, 0.02093595f, -0.02904346f, -0.15010075f, 
    0.30056903f, -0.03438246f, 0.00362776f, 0.04356474f, 0.08998703f, -0.01643591f, -0.04896228f, -0.13166022f, 
    0.17547877f, -0.11571555f, -0.24883875f, 0.07809874f, -0.13314095f, -0.15079948f, -0.03710745f, -0.13120992f, 
    0.07208909f, -0.14015190f, -0.02493921f, -0.10353095f, 0.09173235f, -0.03998421f, 0.07833522f, 0.15231276f, 
    0.06332308f, -0.09965039f, 0.05542858f, 0.05355128f, -0.03479016f, -0.00852627f, 0.04703050f, 0.07366031f, 
    0.01512705f, -0.01296270f, 0.16993159f, 0.04136816f, 0.06568613f, 0.15339665f, 0.01263257f, 0.04379376f, 
    -0.06295247f, -0.08088178f, 0.00003861f, 0.00875484f, -0.12366869f, -0.07746184f, 0.30177894f, 0.05874915f, 
    0.04091372f, 0.01614892f, 0.14714526f, 0.00425532f, 0.15066411f, -0.03201514f, -0.00436540f, -0.02858719f, 
    0.09295099f, 0.05161764f, -0.08160386f, 0.07561594f, -0.10441731f, -0.11564249f, 0.04464268f, 0.17598395f, 
    0.05775471f, -0.16362798f, -0.08347124f, 0.06958243f, 0.03777280f, -0.06759861f, 0.00826557f, -0.11776808f, 
    0.19169733f, 0.09002125f, -0.04058376f, -0.13495162f, -0.19820911f, -0.24416080f, 0.04355421f, 0.00814103f, 
    -0.08978145f, -0.24436060f, -0.05734176f, 0.17478271f, -0.01222865f, -0.03553280f, 0.00484706f, -0.12370899f, 
    -0.00443607f, -0.01278056f, 0.26103470f, 0.08396750f, 0.00740700f, 0.06961522f, 0.08848614f, -0.00400605f, 
    -0.04363311f, 0.07331809f, 0.05547116f, 0.14606057f, -0.08027440f, 0.17504427f, -0.01129269f, -0.11413681f, 
    0.05244995f, -0.02309105f, -0.08594063f, 0.24951218f, -0.12417495f, -0.18786819f, 0.07413916f, -0.08519005f, 
    -0.03257957f, 0.06993259f, 0.12975501f, 0.12660754f, 0.04392868f, -0.17857160f, -0.01111598f, 0.13873373f, 
    0.01157041f, 0.17498997f, -0.14097500f, -0.12368977f, -0.11903020f, -0.08228616f, 0.01869122f, -0.11328832f, 
    -0.46539202f, 0.04466064f, -0.00300503f, 0.04878655f, -0.11742529f, 0.08015744f, -0.23150125f, 0.09235561f, 
    -0.20489332f, 0.14111345f, -0.07533287f, -0.03076356f, 0.14438319f, 0.10893347f, -0.05675645f, 0.03160578f, 
    -0.10535853f, -0.08915093f, -0.05795732f, -0.10751396f, -0.00791371f, 0.00088838f, -0.10907733f, -0.24391823f, 
    -0.30612728f, -0.33357355f, -0.12950879f, -0.11384390f, 0.02561869f, -0.13875695f, -0.06208026f, -0.04491303f, 
    0.13388841f, -0.17006126f, 0.00315179f, -0.21391943f, 0.17407630f, -0.08925866f, -0.04854567f, 0.01951146f, 
    0.19450179f, 0.22350560f, -0.06099747f, -0.02746214f, -0.03915539f, 0.08856893f, -0.02653199f, -0.16013263f, 
    0.01593120f, 0.10793370f, -0.15573651f, -0.08635787f, -0.25017530f, 0.09513086f, 0.02749299f, -0.01136194f, 
    -0.04551603f, 0.03437902f, 0.03006457f, 0.12593773f, 0.13088216f, -0.19286759f, -0.08999355f, -0.09863812f, 
    0.17346966f, 0.09826715f, -0.08516156f, -0.03519723f, -0.15548551f, -0.04244925f, -0.18177848f, -0.03723474f, 
    0.06254456f, -0.05069197f, -0.00374992f, -0.11858860f, -0.12480219f, -0.14218380f, -0.12054666f, 0.11746164f, 
    -0.01217383f, -0.15690690f, -0.13512544f, -0.10596508f, -0.11716211f, 0.04027540f, 0.02991928f, 0.00416064f, 
    0.03640191f, 0.07799347f, -0.12276242f, 0.16745381f, 0.03980956f, 0.05679217f, -0.08670168f, 0.12066821f, 
    -0.15347296f, -0.04550263f, 0.13052416f, -0.09792782f, 0.15280114f, 0.05109848f, 0.00064984f, -0.14422944f, 
    0.02651572f, -0.20110580f, -0.02570378f, 0.00061574f, -0.02861225f, -0.12088720f, -0.02181936f, -0.17155987f, 
    0.12441107f, 0.01321346f, -0.04094922f, 0.10287175f, -0.01159549f, -0.04945344f, 0.03986208f, -0.16515124f, 
    -0.11927798f, 0.12541531f, 0.23044772f, 0.14255965f, -0.19121398f, 0.11043029f, 0.00991361f, 0.09708143f, 
    0.04806901f, 0.09263674f, -0.06825943f, -0.24687453f, -0.10956503f, -0.03146143f, -0.11205227f, -0.13280332f, 
    0.04708064f, -0.16079676f, 0.00387297f, 0.08370431f, 0.15774332f, 0.24992459f, -0.07774162f, -0.09380729f, 
    0.06218348f, 0.02108701f, 0.16847542f, 0.01707092f, 0.03685354f, 0.14392386f, -0.07966231f, -0.11550847f, 
    -0.05211914f, -0.02580506f, 0.03155417f, -0.06860916f, 0.02348422f, 0.09172235f, -0.07935327f, 0.04207251f, 
    -0.30973852f, -0.31819949f, 0.00925769f, -0.09233889f, -0.06949046f, 0.02859563f, -0.04582985f, -0.06391499f, 
    0.00971450f, 0.21793273f, 0.13911255f, 0.00010061f, 0.04181800f, 0.14460820f, 0.03227340f, 0.07569961f, 
    -0.03849834f, 0.17646167f, 0.06018654f, -0.10475817f, -0.10615994f, -0.06759783f, -0.02588887f, -0.23791662f, 
    0.12306380f, 0.26154810f, 0.07968975f, -0.01067670f, -0.07700769f, 0.01923868f, -0.03297165f, 0.02619218f, 
    0.04308667f, -0.10433476f, 0.02131163f, -0.14857933f, -0.06539654f, -0.13096581f, -0.03705794f, -0.02310089f, 
    -0.10783114f, 0.11498371f, 0.04960724f, 0.18984818f, 0.07471137f, 0.21738322f, -0.10575528f, -0.10943994f, 
    0.19170830f, -0.14538403f, 0.12951089f, -0.01895876f, -0.00582932f, 0.02299981f, 0.14174303f, 0.08712558f, 
    0.10471646f, 0.08303689f, 0.01719356f, 0.01428143f, 0.11278437f, -0.06249803f, -0.05913464f, 0.00337945f, 
    -0.17423296f, -0.06413344f, 0.02395958f, -0.01751216f, 0.05389817f, 0.04519831f, 0.15309800f, 0.10449663f, 
    -0.12584655f, 0.03096387f, -0.00742802f, 0.08554833f, 0.08686068f, 0.02635185f, 0.09995276f, 0.06895996f, 
    -0.15276401f, -0.01175962f, 0.03588761f, 0.03253054f, 0.08498441f, 0.07941863f, 0.08280744f, 0.02363340f, 
    0.20082910f, 0.23246026f, -0.02890543f, 0.04195675f, 0.05905947f, 0.12169244f, 0.05018063f, 0.14874189f, 
    0.03133732f, 0.06793238f, 0.06245124f, -0.31767711f, -0.00710474f, -0.08084618f, -0.03203730f, -0.07768238f, 
    -0.00758828f, -0.33208689f, -0.21637534f, -0.40341821f, 0.14208250f, -0.11060926f, -0.23214316f, 0.06038796f, 
    0.05008886f, 0.05890341f, 0.01111084f, 0.01659417f, 0.08405743f, -0.10278158f, -0.01097189f, -0.15676595f, 
    0.11595604f, -0.04666199f, 0.01266492f, 0.08530141f, 0.01469739f, 0.08814949f, 0.12314763f, -0.24645135f, 
    -0.02338375f, -0.02767789f, 0.05732120f, -0.07377702f, -0.03723727f, 0.01259136f, -0.04008612f, 0.02952018f, 
    0.16841070f, -0.01691433f, 0.14033678f, 0.02872752f, 0.08030817f, -0.10756844f, -0.12207986f, -0.01021966f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.05459552f, 0.15664548f, 0.07947540f, -0.07164425f, 0.06253684f, 0.24263346f, -0.02802585f, 0.14183466f, 
    0.01003136f, -0.00551671f, 0.03328705f, -0.06697058f, -0.04147431f, -0.03021733f, -0.03743275f, 0.08774830f, 
    0.02313685f, 0.04498327f, 0.29257372f, -0.05790155f, 0.05383341f, 0.04921610f, 0.00059496f, -0.03225429f, 
    0.04503685f, -0.00634879f, 0.22471429f, 0.02429748f, 0.15850201f, -0.02920669f, -0.02384177f, 0.18129855f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.44151840f, 0.14771865f, 0.03327912f, -0.06843883f, 0.26711878f, 0.00600331f, 0.01237033f, 0.15882018f, 
    -0.25335473f, -0.27524346f, -0.10077176f, -0.09234209f, 0.10964887f, -0.06372189f, 0.16235958f, -0.03613814f, 
    0.17809875f, 0.11484374f, -0.14603056f, -0.09025947f, -0.08066466f, 0.21606913f, -0.13848637f, -0.00890291f, 
    0.02791681f, 0.15733787f, -0.28315544f, 0.02484320f, 0.38795361f, 0.28831956f, -0.15557680f, -0.13375604f, 
    -0.28690425f, 0.41149691f, -0.20073460f, 0.32027182f, 0.24174778f, -0.30541646f, 0.05158346f, 0.33279297f, 
    -0.33666164f, -0.36176404f, 0.07276052f, 0.03216321f, -0.01562881f, 0.13391586f, 0.30187711f, 0.19384032f, 
    0.19629312f, -0.19906874f, 0.16257295f, 0.14041083f, -0.18791020f, -0.31654963f, 0.10378336f, 0.16118579f, 
    -0.29900697f, 0.00085650f, -0.26578176f, -0.17119287f, -0.07879788f, -0.10713264f, 0.10138022f, 0.15769339f, 
    0.12753378f, 0.16244189f, -0.30255401f, -0.41405639f, 0.03229274f, 0.09376518f, -0.12360293f, -0.08665068f, 
    0.14386337f, 0.00543840f, -0.01793635f, 0.17574912f, -0.04035668f, 0.09926077f, -0.03429032f, -0.14924850f, 
    -0.13121499f, 0.07684760f, 0.02519690f, 0.13457324f, -0.00791543f, 0.05399119f, -0.15844539f, 0.02262666f, 
    0.23054793f, -0.03397266f, -0.02624042f, -0.09507618f, 0.26958841f, 0.22181666f, -0.10161465f, -0.10726722f, 
    -0.15841009f, 0.30943310f, 0.10542077f, 0.02120598f, 0.14292987f, 0.16420761f, -0.07593762f, -0.07870486f, 
    -0.15887980f, -0.02156528f, 0.01580301f, -0.09951232f, 0.07012660f, 0.07084889f, -0.13760734f, -0.41673574f, 
    -0.11613233f, 0.23943171f, 0.15620670f, -0.04175216f, -0.07949998f, -0.01714081f, -0.05209934f, 0.03665641f, 
    0.30591837f, 0.06365869f, 0.10450313f, -0.06900400f, 0.16055684f, -0.03034312f, -0.10123429f, 0.27337372f, 
    0.06165222f, -0.13594726f, 0.06263559f, 0.25491261f, -0.01944276f, -0.15831524f, 0.09142374f, -0.20313819f, 
    0.13431567f, 0.21811542f, 0.07354032f, 0.05665614f, 0.25783280f, 0.09403875f, 0.34961963f, 0.04132671f, 
    0.01495546f, -0.16941032f, -0.04118530f, -0.16007978f, 0.02926306f, 0.10240116f, -0.10743355f, -0.01155322f, 
    -0.35402706f, 0.02450115f, 0.25471407f, -0.00534170f, 0.00169549f, -0.08707877f, -0.05364577f, 0.07622224f, 
    0.29586378f, -0.27817574f, -0.08113499f, -0.27491558f, 0.07364781f, 0.04866865f, 0.15130818f, -0.15663521f, 
    0.19454449f, 0.20687845f, -0.08812471f, 0.08210482f, -0.32272553f, 0.11894061f, -0.08682046f, -0.11636367f, 
    -0.03158851f, -0.25301266f, 0.21652064f, -0.06223047f, -0.08129403f, 0.39517093f, -0.04055334f, 0.09154196f, 
    -0.15452848f, 0.08160613f, 0.18866338f, 0.12474016f, 0.11331109f, 0.01566756f, 0.09240426f, -0.15966065f, 
    -0.11309125f, 0.00017857f, 0.26883218f, 0.00789427f, 0.07835484f, -0.22508991f, -0.04668683f, -0.04577220f, 
    -0.11752133f, 0.12476868f, 0.09000529f, -0.12327392f, -0.13278051f, -0.14487693f, -0.11253957f, 0.21265537f, 
    0.24748297f, -0.17913757f, 0.40437332f, -0.02606629f, -0.06790426f, 0.00556464f, -0.16784702f, -0.16032134f, 
    0.01504221f, -0.02673924f, 0.36814705f, 0.13801230f, -0.33443537f, 0.09964351f, 0.17103463f, 0.04440221f, 
    -0.37509093f, -0.19762538f, 0.01192119f, 0.10352177f, 0.31044838f, -0.12087946f, 0.05740226f, -0.21514355f, 
    0.16116211f, -0.07877783f, 0.00957176f, -0.00387556f, -0.12768513f, 0.13671850f, -0.22603956f, -0.13225967f, 
    -0.11777545f, -0.07479935f, 0.10927851f, 0.04524957f, 0.10564988f, 0.36381656f, 0.07526740f, -0.09519660f, 
    -0.02104337f, 0.01349801f, 0.40556401f, -0.05268116f, -0.00247412f, 0.12611789f, -0.05362762f, -0.05915093f, 
    -0.04394008f, 0.06555787f, 0.09894160f, 0.07816116f, -0.25145489f, 0.04226623f, -0.03790691f, -0.01834499f, 
    0.18793452f, -0.24625137f, 0.05077557f, -0.20269202f, -0.01733286f, -0.24834096f, -0.35348129f, -0.02221690f, 
    0.19046278f, 0.10324237f, -0.15309563f, 0.13006012f, 0.14060505f, -0.10088947f, 0.16453548f, -0.06256692f, 
    0.30079457f, 0.02709849f, -0.07408690f, 0.16091610f, -0.27313051f, -0.03481423f, -0.06984314f, -0.26910615f, 
    0.14521298f, -0.64335471f, -0.16834036f, 0.04032190f, 0.11406995f, -0.07178964f, 0.08713014f, 0.06283099f, 
    -0.21505286f, -0.04818478f, 0.10543032f, 0.07903659f, -0.25625896f, -0.22201227f, 0.04686495f, -0.10800120f, 
    0.04026298f, -0.06103812f, 0.09886570f, -0.14685822f, 0.02228964f, 0.22697717f, -0.00957059f, 0.12091079f, 
    -0.22258386f, -0.15928760f, 0.31396517f, 0.11344750f, 0.29776844f, -0.17224316f, 0.07763230f, -0.03019694f, 
    0.23427115f, 0.14625914f, 0.04247214f, 0.25861439f, 0.05432719f, -0.04351923f, -0.03635271f, -0.07760486f, 
    0.08066061f, -0.13203381f, -0.02733396f, -0.14454909f, 0.32264766f, -0.13743874f, 0.03219833f, 0.25624111f, 
    0.27086997f, 0.20919926f, -0.05739383f, -0.10340808f, -0.14605361f, -0.42263034f, 0.14817062f, 0.02757558f, 
    -0.41103241f, -0.03780111f, -0.38219315f, -0.05613617f, 0.10482998f, -0.00922576f, 0.02122044f, -0.03049152f, 
    0.03793377f, 0.01767121f, -0.20301133f, 0.01443983f, 0.09055100f, -0.06049506f, -0.08279698f, 0.20502529f, 
    -0.13102384f, 0.18659182f, 0.12318353f, 0.20372564f, -0.06943476f, 0.16393557f, -0.13612200f, -0.34782901f, 
    -0.22265664f, -0.31955174f, -0.03763399f, -0.03614674f, -0.19327427f, 0.31914431f, 0.06472687f, 0.13300984f, 
    0.52759564f, 0.12349750f, -0.33320901f, -0.06428599f, 0.29610926f, 0.41971663f, -0.07286046f, -0.01323425f, 
    0.31016180f, 0.27476677f, -0.38524547f, -0.08746106f, 0.01140180f, 0.53232276f, -0.09056096f, -0.17277238f, 
    0.19637857f, -0.14409614f, -0.02477392f, 0.35164094f, -0.30428827f, 0.05362442f, -0.35935402f, -0.35342097f, 
    -0.26179498f, -0.00116765f, 0.37100863f, 0.08572763f, -0.31766304f, -0.02467827f, -0.00568243f, -0.09996016f, 
    0.08555842f, -0.15364175f, 0.14441359f, 0.07515634f, 0.25002784f, -0.14500827f, 0.08918589f, -0.04046258f, 
    0.13376746f, -0.31411082f, -0.26264948f, 0.08964372f, 0.12966658f, 0.11490089f, -0.11162704f, 0.11882856f, 
    0.31906667f, -0.22075130f, 0.08413526f, 0.16270025f, -0.45510307f, -0.12840723f, -0.07079951f, -0.14791533f, 
    -0.34595588f, 0.03970778f, 0.17903852f, -0.02197686f, -0.31455714f, 0.17720643f, 0.06107400f, -0.10582026f, 
    -0.00385023f, -0.12191081f, 0.13537751f, -0.11910254f, 0.38880378f, 0.23055474f, -0.01572802f, -0.18264908f, 
    -0.05991749f, 0.49695024f, -0.42837149f, -0.32954827f, 0.14659342f, -0.06318070f, 0.00001251f, 0.06613364f, 
    0.20257816f, -0.01176308f, 0.07122499f, -0.07567666f, 0.10689896f, -0.03925724f, -0.15555228f, -0.31574821f, 
    0.18943016f, 0.13959403f, 0.45931756f, -0.04126095f, -0.03610117f, -0.06478247f, -0.06275164f, 0.03727245f, 
    0.00122755f, 0.13383375f, -0.29891205f, 0.13587435f, 0.10755225f, 0.35161108f, -0.15133846f, 0.05062077f, 
    -0.14197688f, -0.13219093f, 0.17209275f, 0.42087352f, 0.00235130f, -0.08889238f, 0.13311914f, -0.17455305f, 
    0.01081834f, -0.07355846f, -0.06724367f, 0.09001487f, -0.07667259f, 0.14253137f, 0.14851055f, -0.12986900f, 
    0.05763764f, -0.01458651f, -0.33104360f, 0.00815112f, 0.11955300f, -0.21651554f, -0.03750185f, 0.07809408f, 
    0.00408384f, -0.16598733f, 0.00546973f, 0.00921338f, 0.25338030f, -0.15381251f, 0.14054328f, -0.11435093f, 
    0.18198328f, 0.17441835f, -0.29942980f, -0.29335147f, 0.14439930f, -0.02388987f, 0.15476668f, -0.16418898f, 
    0.21740700f, 0.27039561f, 0.06664538f, -0.04826596f, 0.24392436f, -0.02483404f, 0.08493918f, 0.05395851f, 
    -0.07136643f, 0.12771484f, 0.01799180f, -0.05151714f, -0.15667106f, 0.08616985f, 0.14443855f, -0.15973158f, 
    -0.14036195f, 0.16692449f, -0.23553675f, -0.11040197f, 0.37104726f, 0.57493603f, 0.18027598f, -0.28640521f, 
    0.14106892f, 0.00272016f, -0.25879323f, 0.31820151f, 0.11356026f, -0.02059625f, 0.12228026f, 0.28625751f, 
    -0.10616534f, 0.15523963f, -0.10367327f, 0.28773871f, 0.02463759f, 0.18690738f, -0.11254451f, -0.29952812f, 
    -0.20969410f, -0.37776563f, 0.23481606f, -0.13518845f, 0.22582266f, 0.11393742f, 0.14401139f, -0.01948097f, 
    0.44903180f, -0.04968305f, -0.32996330f, 0.04240454f, 0.07231909f, -0.35420632f, 0.08014686f, -0.17477268f, 
    -0.03870646f, -0.04468289f, -0.14040342f, 0.06750970f, -0.03213580f, -0.09082063f, 0.02473160f, -0.18765727f, 
    0.03434166f, 0.01781303f, -0.15568781f, 0.02427236f, -0.02828803f, -0.10032539f, -0.23400871f, -0.12941828f, 
    -0.12635887f, -0.05669264f, 0.05074111f, 0.08755101f, -0.07637644f, 0.03853527f, 0.10780264f, -0.08152663f, 
    -0.10334296f, 0.12704888f, -0.02681133f, -0.15477848f, -0.08535503f, 0.10329213f, -0.19320621f, -0.07579681f, 
    -0.36851174f, 0.41862714f, -0.38240540f, -0.26496214f, 0.28378332f, 0.32854202f, 0.02367552f, -0.02380581f, 
    0.10214716f, -0.12016606f, 0.04838536f, -0.05832184f, -0.16583753f, -0.26349577f, 0.10563081f, -0.14311972f, 
    -0.03037209f, 0.15860642f, 0.17933421f, -0.05327998f, -0.49545121f, 0.34502816f, -0.04258081f, 0.10977654f, 
    0.07989678f, 0.13174875f, 0.33798245f, 0.07296433f, 0.13401236f, 0.23414703f, -0.28339222f, -0.03017048f, 
    -0.04987791f, -0.22352009f, 0.13036557f, 0.29110473f, 0.08928770f, -0.01887435f, 0.04513481f, 0.07558212f, 
    -0.05557634f, 0.38802743f, 0.08962758f, -0.17281906f, 0.16461816f, 0.09329230f, 0.02257960f, 0.04869976f, 
    0.11319452f, 0.02731659f, -0.13202415f, -0.07664183f, 0.15086728f, -0.05901857f, 0.07472090f, -0.03681725f, 
    -0.04168669f, -0.02191751f, 0.00403580f, 0.07924760f, -0.02554954f, -0.22832453f, 0.07722102f, -0.01405557f, 
    0.33359730f, -0.48769888f, 0.07667009f, -0.04491905f, 0.20653874f, -0.02171611f, -0.06423453f, -0.02394849f, 
    -0.09729547f, 0.42898336f, -0.01123710f, -0.20827736f, -0.02327618f, -0.03653716f, 0.16803473f, 0.04874101f, 
    0.21937495f, 0.07286285f, -0.10934303f, 0.03587221f, -0.15856208f, 0.30566365f, 0.10692796f, -0.02078555f, 
    0.06039193f, -0.15768313f, 0.18287401f, 0.02322326f, 0.10872640f, 0.35480121f, 0.21331945f, -0.01219066f, 
    -0.46911100f, -0.01307003f, 0.18328424f, 0.50848919f, 0.38844639f, -0.24301223f, 0.10852340f, 0.26038089f, 
    -0.14233294f, -0.04838801f, -0.05427597f, -0.27213794f, 0.03556923f, 0.21681915f, 0.15296966f, 0.13188095f, 
    -0.00239884f, 0.00792716f, 0.13976160f, 0.06594835f, -0.12757201f, 0.16791660f, 0.06087517f, -0.16687892f, 
    0.04686312f, -0.10678834f, 0.16306074f, 0.02732626f, -0.08583674f, 0.20560691f, -0.25622120f, 0.17194356f, 
    0.35655421f, 0.08986632f, 0.10071152f, -0.36723033f, -0.04765223f, -0.01514383f, 0.06138044f, -0.05959632f, 
    0.00469905f, 0.36023551f, 0.03974625f, 0.21191300f, 0.14179190f, 0.19141455f, 0.10353643f, 0.06285195f, 
    -0.22684637f, -0.03898981f, 0.00847294f, 0.11027864f, -0.01056677f, -0.18153708f, -0.15869157f, -0.16530751f, 
    0.13604525f, 0.14298269f, 0.15269579f, 0.07020421f, -0.21808855f, 0.07688501f, 0.23955902f, -0.21896274f, 
    0.35591805f, 0.02602625f, 0.26519755f, 0.24712975f, -0.17846674f, -0.11095753f, 0.04653121f, 0.12436280f, 
    -0.07123589f, 0.42023170f, -0.06424650f, -0.00743257f, 0.03405878f, 0.18438895f, 0.07837544f, -0.02133266f, 
    -0.07562508f, -0.02709812f, 0.07247531f, -0.00748550f, 0.10022864f, 0.13603224f, 0.00716606f, -0.02146421f, 
    0.09493537f, -0.04828009f, 0.09284732f, 0.09107545f, -0.28255746f, -0.29550511f, 0.10913827f, -0.07630249f, 
    0.15364160f, 0.12127858f, 0.16282578f, -0.09259456f, -0.03199364f, -0.13075975f, 0.13294080f, -0.03160940f, 
    -0.24510323f, 0.01104403f, 0.06571916f, 0.24295262f, 0.06196594f, 0.02771083f, -0.11162830f, -0.04597199f, 
    -0.23061344f, -0.37497756f, 0.05848207f, 0.00378282f, -0.65099168f, 0.36908498f, -0.00512910f, -0.06318432f, 
    0.50582904f, 0.06457770f, -0.01225632f, 0.14569014f, -0.06088861f, 0.44571736f, 0.35409087f, -0.27406770f, 
    -0.32242528f, -0.08894262f, 0.30405283f, 0.17824218f, 0.13852485f, 0.03698035f, -0.05694674f, 0.17541832f, 
    -0.35802323f, -0.02704139f, -0.14044966f, -0.21012536f, -0.01662348f, 0.11154155f, -0.01369939f, -0.16118801f, 
    0.03328888f, 0.22642477f, -0.01017214f, -0.08211734f, -0.02302276f, 0.26420662f, -0.01371454f, 0.13521026f, 
    0.31675711f, -0.12172813f, 0.16184919f, -0.01302120f, 0.19418468f, -0.21558510f, -0.26075968f, 0.15873262f, 
    0.08706167f, -0.05890789f, 0.02948929f, -0.15650919f, -0.08966599f, -0.12774923f, -0.07596308f, -0.12870200f, 
    0.02347808f, -0.02692723f, -0.10447589f, 0.00108331f, -0.16022968f, 0.02823896f, -0.23890579f, 0.09146197f, 
    0.07278343f, 0.08747635f, -0.00752318f, -0.16208401f, -0.16361627f, -0.18185277f, -0.05509695f, 0.03890449f, 
    -0.03825165f, 0.16287675f, -0.16128670f, 0.15041421f, -0.01111322f, 0.10210553f, -0.06805211f, 0.09436174f, 
    -0.07355736f, -0.19092712f, 0.04010045f, -0.11844166f, 0.03082678f, 0.18261354f, -0.03592527f, 0.23043689f, 
    -0.18733719f, -0.03236615f, -0.09684090f, 0.11938341f, -0.18643041f, 0.25389650f, -0.18380505f, -0.60186028f, 
    -0.10845731f, -0.12747656f, 0.25707838f, -0.07287613f, -0.11597557f, 0.29301357f, 0.02679497f, -0.05431990f, 
    0.44166401f, 0.08523842f, -0.34641126f, 0.16072327f, 0.23196450f, -0.25301379f, -0.01979337f, -0.06650356f, 
    -0.05131216f, -0.07702459f, -0.17581645f, 0.11670711f, -0.08188401f, 0.09669571f, -0.09899863f, -0.02009930f, 
    0.09396278f, 0.05100369f, 0.03999635f, -0.10271854f, 0.03010056f, -0.01215292f, -0.11532050f, -0.04521305f, 
    0.06828398f, -0.14109798f, -0.16600631f, -0.04494636f, -0.03859403f, 0.08557306f, 0.04372511f, -0.09294876f, 
    -0.16013703f, 0.06584424f, -0.08587015f, 0.14224227f, -0.02625198f, -0.06878375f, 0.12041438f, -0.08336760f, 
    0.22622281f, -0.07450441f, -0.35079101f, -0.24753165f, 0.00726323f, 0.26266354f, 0.10914832f, 0.11011647f, 
    -0.10177799f, 0.20814207f, 0.15086736f, 0.31226945f, -0.26534864f, -0.00362130f, -0.21801379f, -0.06413008f, 
    -0.15512776f, -0.11556178f, 0.07811377f, 0.06931884f, 0.06771320f, 0.06954116f, -0.15873978f, -0.13670373f, 
    -0.04824046f, -0.14546049f, -0.06584218f, -0.12341233f, 0.25765032f, -0.23522216f, 0.08575176f, -0.27593169f, 
    0.16598697f, -0.07225113f, -0.22716740f, -0.21973754f, -0.06716368f, -0.17617251f, 0.02192458f, 0.19432528f, 
    0.08910190f, 0.12814331f, -0.16272451f, 0.11980724f, -0.21531737f, 0.11386561f, -0.22846788f, -0.10846114f, 
    -0.02042212f, 0.03951680f, 0.11437998f, -0.03531044f, 0.11435690f, 0.07863998f, 0.11362271f, 0.04214718f, 
    0.28936407f, -0.14093275f, -0.00723500f, 0.01526918f, 0.00783854f, 0.25459450f, 0.09440209f, -0.27849862f, 
    -0.36777386f, 0.23855378f, -0.01840210f, -0.17566027f, -0.00839300f, 0.13480504f, 0.02475585f, 0.04404269f, 
    -0.27425396f, 0.09898071f, 0.13276286f, -0.19192843f, 0.21516481f, -0.03655529f, 0.12205478f, 0.08754223f, 
    0.22994064f, 0.21320172f, 0.04174316f, 0.08478873f, 0.10025530f, -0.18364213f, -0.17965832f, -0.08806852f, 
    0.05924564f, -0.15215643f, 0.18753496f, -0.03892905f, 0.18534312f, -0.09966941f, -0.23972237f, 0.28968838f, 
    -0.21400806f, 0.13665722f, 0.00790716f, 0.13475345f, 0.19657852f, -0.24846268f, -0.03605985f, 0.22033967f, 
    0.15468754f, -0.26014519f, 0.15858197f, -0.02990084f, -0.10067607f, 0.12155348f, -0.03916559f, 0.06824376f, 
    0.13565542f, -0.07839201f, 0.24968332f, 0.03353566f, 0.09219583f, -0.12006397f, -0.02826041f, -0.00858506f, 
    -0.34128365f, -0.16675572f, -0.08494942f, -0.04567459f, -0.16629517f, -0.12555906f, 0.17814018f, -0.25123248f, 
    -0.05494716f, -0.17258319f, -0.24002440f, 0.30769157f, -0.06387935f, -0.49025530f, -0.01474648f, 0.07992124f, 
    -0.42759177f, 0.15199380f, 0.00562334f, -0.17122371f, 0.31181017f, 0.27445051f, 0.06107843f, 0.11152712f, 
    -0.11458516f, -0.15707609f, -0.12063878f, 0.01435361f, -0.07512271f, -0.25815707f, 0.16367751f, -0.13590820f, 
    -0.22778662f, 0.07379517f, -0.24364144f, 0.15864919f, -0.46804702f, -0.08250397f, 0.14662968f, -0.14821441f, 
    0.32690954f, 0.11915179f, -0.14805418f, 0.20023118f, -0.10217343f, -0.15358894f, -0.10418117f, -0.11806528f, 
    0.00398022f, 0.03707325f, -0.11459496f, -0.13615720f, 0.27746642f, -0.05279703f, 0.17832284f, 0.11121809f, 
    0.26135346f, 0.23178561f, -0.18813641f, -0.12763895f, -0.13359635f, -0.13480476f, 0.07112782f, -0.14612362f, 
    -0.20495899f, 0.06557108f, -0.34796542f, -0.03249728f, 0.19395487f, 0.00785794f, 0.14370072f, 0.05800379f, 
    0.38608798f, -0.26877514f, -0.10237549f, -0.19630826f, -0.02762069f, -0.12375026f, 0.13533713f, 0.11618067f, 
    0.04711180f, -0.03975409f, 0.16995145f, 0.02430196f, 0.15337186f, 0.15701973f, 0.22437973f, -0.14987180f, 
    -0.07850425f, -0.07011135f, 0.08070195f, 0.07902127f, 0.00315901f, 0.09548958f, -0.06734659f, 0.08853254f, 
    0.01917461f, 0.06934503f, -0.26239568f, 0.05858869f, 0.07871269f, 0.60949004f, 0.27039200f, -0.23897946f, 
    -0.08898472f, -0.07209710f, -0.03237880f, 0.00607432f, -0.03024452f, 0.17647219f, 0.01281574f, 0.16045918f, 
    -0.04307399f, -0.19647102f, 0.15612917f, 0.00332589f, -0.16839473f, -0.12056513f, -0.00900770f, 0.02820741f, 
    0.15668899f, 0.11527222f, 0.33237961f, -0.16241822f, 0.07125924f, -0.12329698f, 0.06565283f, -0.02080424f, 
    -0.07770381f, 0.13208523f, 0.12541573f, 0.00502188f, 0.03990091f, -0.09494610f, -0.33419302f, 0.28306493f, 
    -0.17446670f, -0.00462137f, 0.16892850f, 0.25078824f, -0.13853322f, 0.01949658f, -0.11668488f, -0.29876411f, 
    0.04801621f, 0.00663901f, -0.11322127f, -0.05767762f, -0.14525180f, 0.18388021f, 0.17484701f, 0.04832454f, 
    -0.03608437f, 0.00899648f, -0.11307791f, 0.03794775f, 0.11189909f, -0.05314309f, -0.13417612f, -0.15424132f, 
    -0.13073485f, -0.10379705f, 0.18118049f, 0.13764283f, 0.05653816f, 0.03948108f, 0.00017937f, -0.00691484f, 
    -0.10265168f, -0.03056735f, -0.00052904f, -0.09642172f, 0.07720848f, 0.19178435f, -0.15620670f, 0.19279666f, 
    0.08135355f, 0.07747573f, 0.01560432f, -0.06321988f, -0.05881857f, -0.10175145f, 0.04579625f, -0.13142949f, 
    -0.09911592f, -0.10691182f, -0.12172023f, 0.15080813f, -0.08302721f, -0.10342588f, -0.15106174f, -0.14065781f, 
    0.16936788f, 0.06860788f, 0.21433057f, -0.04750247f, 0.01205276f, -0.03388407f, -0.19312984f, 0.09251545f, 
    0.19024365f, -0.32118148f, 0.23329264f, -0.04066463f, 0.23863974f, -0.25929889f, 0.15253618f, 0.14614289f, 
    -0.15130675f, 0.26817027f, -0.03961590f, -0.13894658f, 0.06514130f, 0.17799373f, 0.06232881f, 0.06557089f, 
    0.16844581f, 0.04297546f, -0.17532706f, 0.12030993f, -0.17750214f, 0.30003741f, -0.05528821f, -0.10276242f, 
    0.18561280f, 0.04033401f, 0.04921866f, -0.10473970f, 0.08080365f, 0.53442740f, 0.30815938f, -0.06689526f, 
    0.13466440f, 0.11379182f, -0.02804024f, 0.01363343f, 0.08131958f, 0.35209209f, 0.13260561f, -0.01523468f, 
    0.07535764f, 0.38768542f, 0.15548332f, -0.06464774f, 0.13663606f, 0.01789217f, -0.14194328f, 0.20570043f, 
    0.16432770f, -0.22552358f, 0.05933732f, 0.03977065f, -0.14811362f, -0.13505623f, 0.13580596f, -0.14627327f, 
    -0.18501781f, 0.08343964f, 0.33354133f, -0.07457708f, -0.08306009f, -0.18252632f, -0.01542865f, 0.38191918f, 
    0.01945823f, 0.08403552f, -0.09143984f, -0.39922473f, 0.13451500f, 0.21437599f, 0.07457983f, 0.01297761f, 
    0.01412951f, 0.28278631f, -0.12215926f, 0.22247404f, -0.05586703f, -0.03827217f, -0.22384045f, -0.17997919f, 
    0.06992540f, -0.22897741f, 0.19872861f, -0.11508599f, 0.07533773f, 0.13939442f, -0.06585008f, 0.13009813f, 
    0.27708358f, 0.06088243f, 0.07394696f, -0.06442030f, -0.07723014f, -0.11723563f, 0.12835394f, -0.11918034f, 
    -0.08225700f, -0.30656871f, 0.24589241f, 0.53270400f, 0.26644552f, -0.00474414f, -0.01389465f, 0.04997083f, 
    -0.08588622f, 0.14411061f, -0.12815239f, 0.06191920f, -0.07011884f, -0.16059881f, 0.20194075f, 0.01455257f, 
    0.00802274f, -0.20244181f, -0.06314127f, 0.02745432f, -0.12521204f, 0.32898745f, 0.15285091f, -0.17598048f, 
    0.20456031f, -0.13467966f, 0.47806379f, -0.00364132f, -0.28880769f, 0.08143978f, 0.23046011f, -0.08910889f, 
    -0.30338714f, -0.23969494f, 0.11825178f, 0.31446320f, 0.22887112f, -0.19146468f, 0.12794417f, -0.06010645f, 
    0.05677145f, 0.43573236f, 0.09419776f, -0.12827298f, 0.06292910f, -0.22051635f, 0.29416057f, 0.18859102f, 
    0.04364644f, 0.09668085f, -0.08709892f, -0.01131110f, 0.01300169f, 0.32053670f, -0.01612865f, 0.16415024f, 
    0.13054046f, 0.15555833f, 0.23382775f, -0.17378397f, -0.05627701f, 0.29690725f, -0.02575229f, -0.02851950f, 
    0.20866381f, 0.11199577f, 0.01562199f, -0.05421177f, -0.16320594f, -0.10874216f, -0.13591850f, 0.18656702f, 
    -0.38772315f, 0.16690804f, 0.05480830f, 0.12698950f, -0.16261876f, 0.15048358f, 0.13087460f, -0.40111810f, 
    0.12056755f, -0.25569609f, 0.04273185f, -0.02551702f, 0.27866986f, 0.07889404f, -0.01432561f, -0.09577455f, 
    0.40050340f, 0.05659457f, -0.46443263f, 0.08912142f, -0.10239398f, -0.04736498f, -0.16846433f, 0.27476025f, 
    0.13157554f, 0.20773681f, 0.25284821f, -0.36216295f, 0.12862793f, 0.08466553f, -0.03764029f, 0.13131903f, 
    -0.06480634f, -0.44515434f, -0.07822138f, -0.18565464f, 0.22894549f, -0.18559222f, 0.18567559f, 0.13376886f, 
    0.05769645f, -0.07707718f, -0.12755542f, 0.10044282f, -0.23898612f, 0.23311633f, 0.05789713f, -0.06686528f, 
    -0.15052325f, -0.07417531f, 0.01864764f, -0.11237896f, 0.02922879f, 0.64907032f, 0.14795268f, -0.04910402f, 
    0.01784239f, -0.53571856f, -0.13790271f, 0.46543923f, -0.05856473f, -0.30669591f, 0.06713704f, 0.00792244f, 
    0.11068381f, 0.28941187f, -0.07747509f, -0.06085223f, -0.04507889f, -0.08139262f, 0.30197713f, 0.05231925f, 
    0.07438796f, -0.05047296f, 0.14288568f, -0.10839794f, -0.01818941f, -0.28087014f, -0.04237817f, -0.11780518f, 
    0.03746758f, 0.00627784f, -0.34733915f, 0.10503978f, 0.06429838f, -0.34564459f, 0.26591048f, -0.00361827f, 
    -0.18774222f, 0.04970389f, 0.15545809f, 0.02514026f, 0.09295341f, 0.22775289f, 0.00319141f, 0.06913340f, 
    -0.14288995f, 0.02981881f, 0.14262488f, 0.09997381f, -0.06758186f, 0.07256051f, 0.00726031f, -0.11865024f, 
    -0.08517623f, 0.08718242f, 0.10867610f, -0.16751680f, 0.06806501f, 0.04937329f, -0.14828359f, -0.10542061f, 
    0.21415354f, -0.14537469f, 0.28960249f, -0.03940665f, -0.09081279f, -0.39208692f, -0.23039296f, 0.26467398f, 
    -0.03254309f, -0.10528394f, 0.00645705f, -0.11788522f, -0.12673436f, -0.12909262f, -0.10347889f, -0.12361917f, 
    -0.03196130f, 0.03047764f, 0.07172251f, 0.02354922f, -0.04868552f, 0.08140662f, -0.07626710f, 0.04873725f, 
    -0.15180402f, 0.05048485f, 0.08018912f, 0.15321800f, -0.08239029f, 0.13923226f, 0.13622996f, -0.05136666f, 
    -0.04663152f, -0.02530404f, -0.13528171f, 0.01693361f, -0.12729812f, 0.03102966f, -0.06064301f, -0.09385154f, 
    -0.11122635f, -0.16785896f, -0.19057748f, 0.03367526f, 0.04461794f, -0.09528439f, 0.02053047f, -0.14286053f, 
    -0.11724735f, -0.05279650f, -0.08116984f, 0.09875416f, -0.13211472f, -0.10765911f, -0.03239272f, 0.08062434f, 
    -0.16760492f, 0.06516552f, -0.18691903f, 0.01812192f, -0.03293161f, -0.08187630f, -0.03519036f, 0.13125598f, 
    0.06198363f, 0.02999361f, -0.08128588f, 0.07877242f, 0.04536590f, -0.07185291f, 0.11550322f, -0.00844515f, 
    -0.78455335f, -0.02900559f, -0.19306377f, 0.12192886f, 0.20614846f, 0.10205029f, -0.02730376f, -0.18455166f, 
    0.14335777f, -0.13794102f, 0.13632351f, 0.02033656f, -0.33143166f, -0.12415252f, 0.04352226f, -0.17016011f, 
    0.02084910f, 0.13084415f, 0.00549092f, 0.01574975f, 0.08438000f, 0.13917030f, 0.10684220f, 0.16401093f, 
    -0.04173269f, 0.06985092f, 0.07957130f, 0.06101883f, 0.28847423f, 0.09603785f, -0.03112127f, -0.04908578f, 
    0.11240983f, -0.10519820f, 0.10530074f, 0.33972427f, 0.13964207f, 0.20835081f, -0.01150894f, 0.14603142f, 
    -0.25468555f, 0.24922024f, -0.07896593f, -0.33527097f, 0.29815480f, -0.29909000f, 0.05399570f, 0.29913071f, 
    0.28793323f, 0.37259328f, -0.06107908f, -0.06543975f, -0.61096799f, -0.04485123f, -0.10995881f, -0.02920892f, 
    -0.27133903f, -0.11106582f, 0.42393577f, -0.00493220f, -0.12531380f, -0.17429501f, -0.49247259f, 0.32577643f, 
    0.16659364f, 0.19954351f, -0.06650569f, -0.22006516f, 0.14445210f, -0.25922373f, -0.09223418f, 0.01791671f, 
    -0.15199515f, 0.26062402f, -0.04517767f, -0.14289124f, 0.21407776f, 0.30574003f, -0.11399031f, -0.14563520f, 
    -0.06768067f, 0.21995917f, 0.05051422f, 0.04475855f, 0.04116378f, -0.06349897f, -0.04505524f, 0.01479095f, 
    0.44948751f, 0.01574912f, -0.48149192f, 0.03935230f, 0.28507185f, 0.31369913f, -0.07713917f, -0.05264867f, 
    -0.16711892f, 0.06275443f, 0.10454646f, -0.15586291f, -0.08642066f, 0.10515213f, 0.15829740f, -0.09238971f, 
    -0.15263678f, -0.02455254f, -0.15086916f, -0.15277778f, -0.12468148f, -0.00908867f, -0.11566845f, -0.09459669f, 
    -0.10773284f, -0.14245480f, 0.03910527f, 0.15715478f, -0.09141707f, -0.13922055f, 0.06003368f, 0.10539310f, 
    0.07711937f, -0.11368327f, 0.11371439f, -0.01627412f, 0.00563728f, -0.16612238f, 0.11352711f, -0.06277010f, 
    -0.06164873f, 0.23414366f, -0.10410552f, 0.42154312f, 0.02964732f, -0.11451396f, 0.01785484f, 0.32822582f, 
    -0.18232718f, -0.06368525f, -0.06814875f, -0.03314186f, 0.04890483f, -0.01699298f, 0.27354527f, 0.04108487f, 
    0.10379762f, -0.11432691f, -0.09268758f, -0.08326763f, -0.05123540f, -0.23347905f, 0.08652829f, -0.03375372f, 
    0.05472793f, 0.08638195f, -0.01294563f, -0.15110786f, -0.01740194f, -0.49202630f, -0.03975048f, 0.42097318f, 
    0.16315641f, 0.24219835f, 0.22275913f, -0.25733715f, -0.11073139f, -0.05308777f, -0.14868046f, -0.20274544f, 
    0.09857154f, 0.27853772f, -0.06991839f, -0.23505522f, 0.25561285f, 0.02763683f, -0.13444752f, 0.35186571f, 
    0.09400602f, -0.19965219f, 0.15813524f, -0.13627784f, -0.04846902f, 0.21928221f, 0.00438280f, -0.15138553f, 
    -0.10188451f, -0.08522204f, 0.10150330f, -0.04435002f, 0.09540851f, 0.42343879f, -0.10024704f, -0.01178102f, 
    0.26405606f, -0.10787853f, 0.12260145f, -0.34486789f, -0.14823759f, 0.07880753f, -0.12921377f, -0.15247110f, 
    -0.41154024f, 0.17224769f, -0.14709038f, 0.00509616f, 0.16917306f, 0.08141633f, 0.20511483f, -0.33404532f, 
    0.18609680f, 0.32777354f, -0.03554006f, 0.14882185f, -0.25261161f, 0.17896791f, -0.04835504f, -0.04405261f, 
    0.12235573f, -0.03355132f, 0.20205006f, -0.07759203f, 0.35515332f, 0.34391466f, -0.53961492f, 0.20514673f, 
    -0.53312570f, -0.15311813f, -0.18473104f, 0.09099621f, 0.30310601f, -0.07988518f, -0.16829620f, -0.23751140f, 
    0.29604241f, -0.11246204f, 0.14147656f, -0.11209381f, -0.54916114f, 0.17165782f, -0.11554691f, 0.02837815f, 
    0.10715519f, -0.11300167f, 0.19877703f, 0.10571028f, 0.13070320f, 0.30856609f, -0.04070386f, 0.10443099f, 
    0.06228931f, -0.15508646f, 0.30040503f, 0.16574879f, 0.17500144f, 0.40609244f, -0.05790759f, -0.06972285f, 
    -0.00714532f, -0.55936617f, -0.12743491f, 0.28797713f, 0.04164148f, -0.21798545f, -0.07617790f, 0.18982111f, 
    -0.08883997f, 0.34219196f, 0.12678269f, -0.01496357f, 0.08757717f, 0.20170064f, 0.32678619f, -0.27173823f, 
    -0.04649914f, 0.01431348f, 0.06552096f, -0.16664015f, 0.09485479f, 0.05676898f, 0.03628773f, 0.08184931f, 
    0.41592905f, 0.13495012f, 0.00163605f, 0.06323546f, 0.00786446f, 0.15268807f, 0.12478456f, -0.07324199f, 
    0.22555418f, -0.15733083f, -0.09972736f, -0.00834361f, -0.16255108f, 0.17802976f, -0.09048564f, -0.15905033f, 
    -0.08427985f, 0.19429411f, 0.16216350f, 0.09288827f, -0.09927040f, -0.19881493f, -0.12656225f, -0.01410018f, 
    -0.08456451f, 0.02610682f, 0.11966463f, -0.00990074f, -0.04282072f, 0.13843083f, -0.05483383f, 0.07853916f, 
    0.05138644f, 0.03853554f, -0.21925513f, -0.07450819f, 0.14031509f, 0.25662187f, -0.12119743f, 0.03163114f, 
    0.35019419f, 0.20325272f, -0.20156808f, -0.29200122f, -0.09862337f, 0.16421692f, 0.00335729f, -0.13687232f, 
    -0.03785878f, -0.00571030f, -0.04293280f, 0.18820253f, 0.08087296f, -0.10651579f, 0.01805017f, 0.14687556f, 
    0.11295220f, 0.13362150f, 0.08965202f, -0.04383171f, -0.17247519f, -0.17395204f, 0.02817502f, 0.12284166f, 
    -0.24684265f, -0.12474968f, -0.26722595f, -0.13666853f, 0.08902511f, 0.48521090f, 0.06402047f, -0.23438585f, 
    0.56495911f, -0.25462738f, 0.04582125f, -0.28985021f, -0.19025768f, -0.00225211f, -0.04114159f, 0.03250601f, 
    -0.11820349f, 0.20132084f, -0.04593978f, 0.20168379f, 0.08525624f, -0.10668413f, -0.00144861f, -0.12884149f, 
    0.05439482f, -0.28869495f, 0.09317830f, -0.04114665f, -0.17864910f, 0.10472590f, 0.05314149f, 0.12192672f, 
    -0.11139879f, 0.03157794f, 0.12528652f, 0.00848055f, 0.07628491f, -0.12148147f, 0.04457537f, -0.16354261f, 
    -0.33395526f, -0.39782676f, 0.07677840f, 0.24919641f, 0.25280443f, -0.01912420f, 0.14066449f, 0.07013776f, 
    0.12282197f, 0.06362196f, -0.03784155f, -0.08638003f, -0.31792817f, 0.04330371f, -0.13743155f, 0.07106217f, 
    0.00654100f, -0.17657469f, 0.33488584f, -0.00814989f, -0.10336030f, 0.29981390f, 0.01959609f, -0.08377135f, 
    0.04084692f, -0.06195588f, 0.60777116f, 0.07491229f, -0.40191215f, -0.01159918f, 0.17291473f, 0.05521578f, 
    0.05908936f, 0.39132327f, -0.42257273f, -0.13944431f, 0.08473624f, 0.51281530f, 0.11395580f, -0.04657864f, 
    0.24988222f, 0.09546655f, 0.09167772f, 0.25868383f, -0.27072948f, 0.18430297f, -0.12197617f, -0.05157751f, 
    0.15865844f, -0.38880000f, 0.27302647f, -0.05291020f, -0.12517862f, 0.03292373f, 0.02186598f, 0.11665604f, 
    -0.21476088f, 0.09271652f, 0.14620255f, -0.06517232f, 0.02130940f, -0.52879781f, 0.18235204f, -0.07569816f, 
    0.06777088f, 0.29243806f, -0.14674345f, -0.32373828f, 0.09597733f, -0.22554027f, 0.04737921f, 0.06974658f, 
    -0.33270702f, 0.06454379f, -0.00080202f, 0.08424389f, -0.04790179f, -0.31414223f, 0.33665669f, 0.00780693f, 
    0.31684336f, 0.17090344f, 0.13544320f, -0.13652854f, -0.17444369f, 0.00419965f, -0.00059215f, -0.12544362f, 
    -0.20625278f, -0.12875523f, -0.20187460f, 0.14555347f, -0.00209995f, -0.01114117f, -0.10256222f, 0.37506247f, 
    0.02922340f, -0.40388697f, -0.18201150f, 0.35784549f, -0.07157354f, 0.30823392f, -0.10814752f, 0.18194577f, 
    -0.02653785f, 0.33616620f, -0.00729418f, -0.16219819f, 0.02548433f, -0.11748767f, 0.11498824f, 0.42533675f, 
    0.32494721f, -0.10891463f, -0.15653463f, -0.03655406f, -0.61336869f, -0.52479798f, -0.15098161f, 0.16866939f, 
    -0.47616771f, -0.12004391f, 0.01772952f, -0.03465768f, -0.13526377f, -0.44267225f, 0.08534116f, 0.16167220f, 
    -0.11956412f, -0.32409912f, 0.06166023f, 0.36848399f, 0.16080771f, -0.24867129f, 0.02153287f, -0.10453822f, 
    0.13880333f, -0.11642788f, -0.03690754f, -0.15770233f, -0.08548278f, -0.11268047f, 0.38134980f, -0.06571780f, 
    0.10708977f, -0.04508773f, 0.04460821f, -0.04586294f, -0.20107237f, 0.24500883f, 0.11431588f, -0.14368065f, 
    0.01201107f, -0.16363209f, 0.41215256f, -0.08691436f, 0.08225553f, 0.52430975f, -0.04315525f, -0.06413020f, 
    0.06182479f, 0.06103015f, -0.34380186f, -0.35416475f, 0.16706333f, -0.12155669f, -0.12132426f, 0.26855409f, 
    -0.39772516f, -0.04692717f, 0.11772218f, 0.14081196f, -0.09849696f, -0.07958536f, -0.14687355f, -0.37788215f, 
    0.29101560f, -0.01073185f, 0.43971679f, -0.02560459f, 0.14365505f, -0.11439026f, -0.16416958f, -0.12429304f, 
    0.10327117f, 0.01478431f, -0.01656280f, -0.12171408f, 0.01086336f, -0.04429776f, -0.33463418f, 0.14074278f, 
    0.28163043f, -0.18257347f, -0.01723700f, -0.34993312f, 0.00139090f, 0.03256102f, -0.11040045f, 0.28450197f, 
    -0.24105440f, 0.00010221f, 0.07473163f, -0.21195327f, -0.11447306f, -0.12752379f, 0.26957098f, -0.15442763f, 
    0.02515517f, -0.01507067f, 0.18939558f, 0.03169474f, 0.10332692f, -0.09436189f, -0.08734241f, -0.11728829f, 
    0.40778887f, -0.10613693f, -0.07094015f, -0.11736144f, -0.04012730f, -0.07725348f, -0.09134749f, 0.18216683f, 
    0.24362789f, -0.06021222f, 0.12778218f, -0.15581818f, -0.21055155f, 0.24664795f, 0.02854319f, 0.19398841f, 
    -0.00530079f, 0.04128294f, -0.01788725f, 0.14210820f, 0.01558947f, 0.06508361f, 0.02627455f, -0.03236784f, 
    -0.11115233f, -0.23270136f, 0.07590644f, -0.03589198f, -0.02137415f, 0.04504333f, 0.00184147f, -0.12886325f, 
    0.20786592f, 0.03916159f, 0.20996135f, -0.08300041f, -0.30609125f, -0.14735457f, 0.00804364f, -0.10095225f, 
    0.00621097f, -0.29091108f, -0.16549583f, 0.54180509f, -0.04959271f, 0.13297899f, 0.15686537f, 0.11006222f, 
    -0.04783870f, 0.10185670f, 0.11358906f, -0.09336594f, -0.07030079f, 0.19276974f, -0.04735922f, 0.27287570f, 
    0.21403581f, 0.04506736f, -0.02016554f, 0.12485106f, -0.15617774f, -0.48458657f, 0.03991596f, -0.13373008f, 
    -0.32849637f, -0.13955288f, -0.12469761f, 0.00613384f, -0.29618424f, -0.41569999f, 0.06285663f, -0.20640706f, 
    -0.10200555f, 0.17661850f, -0.13783719f, -0.01875926f, -0.10298653f, 0.19120239f, 0.10833529f, 0.22942588f, 
    -0.04353128f, -0.23932461f, -0.15020567f, 0.12854798f, -0.03259843f, 0.12938644f, -0.12529668f, -0.21604000f, 
    0.05641944f, 0.27222458f, 0.04916704f, 0.06265702f, 0.01688779f, -0.00674898f, 0.15660925f, 0.06249789f, 
    0.31221512f, -0.15022886f, -0.16197222f, 0.02800253f, 0.05655048f, -0.30335280f, -0.25730327f, 0.37611076f, 
    0.00852032f, -0.16885607f, 0.02110693f, -0.11395712f, 0.28402904f, -0.03384177f, -0.04096081f, 0.27159339f, 
    -0.43528798f, 0.34643909f, -0.01655007f, -0.06541508f, 0.06653056f, -0.08820139f, 0.03785573f, -0.39068344f, 
    0.19460170f, 0.16378920f, 0.20324223f, 0.06982179f, 0.07490062f, 0.07499555f, 0.15009272f, 0.16957442f, 
    0.16149712f, 0.10329424f, -0.57215184f, 0.02666642f, -0.07521760f, -0.07882560f, 0.08209982f, 0.05590572f, 
    0.12248166f, -0.05416858f, -0.03266779f, 0.17771508f, 0.11586786f, 0.19157240f, 0.03714413f, 0.03826297f, 
    -0.07902170f, 0.30567458f, -0.15323342f, 0.12005978f, 0.13164486f, 0.32126230f, -0.16247527f, 0.07841451f, 
    -0.03671668f, -0.05354832f, 0.02695042f, -0.15936454f, 0.15059800f, -0.00099768f, 0.04206100f, -0.13556840f, 
    -0.03556661f, -0.13461106f, -0.01168285f, -0.15504189f, -0.20908424f, -0.21708092f, 0.04645943f, -0.16179368f, 
    -0.04603495f, 0.31133959f, 0.10381708f, -0.37939748f, 0.22163010f, 0.03237915f, 0.05022845f, -0.00038291f, 
    -0.10675304f, 0.07453616f, -0.05009752f, -0.02289892f, 0.09642915f, -0.17267802f, 0.18757427f, 0.03047664f, 
    0.06685059f, 0.08519404f, -0.06536495f, -0.15563837f, -0.27973217f, 0.13707381f, -0.15082461f, -0.11847376f, 
    0.16677000f, -0.13063808f, -0.15258139f, -0.06983599f, 0.16771285f, 0.41987857f, 0.02640260f, -0.08127265f, 
    -0.03712955f, -0.11506120f, 0.01007228f, 0.25373763f, 0.03688659f, -0.08291098f, 0.09006238f, 0.14815634f, 
    -0.19443090f, -0.24700944f, -0.17132205f, 0.02262107f, -0.13295285f, -0.03762762f, -0.05116998f, -0.02163139f, 
    -0.18903504f, 0.06056661f, -0.04646882f, 0.15480790f, 0.03264328f, -0.07494673f, -0.10684515f, 0.17145030f, 
    -0.26237708f, -0.10718902f, 0.00582846f, 0.11099558f, -0.11138094f, 0.17459638f, 0.02026756f, -0.02595647f, 
    -0.17390995f, -0.16265574f, 0.05932529f, 0.05075905f, -0.15140231f, -0.18198456f, -0.04908995f, 0.04252161f, 
    -0.09317338f, -0.14065973f, 0.06052060f, -0.17224357f, 0.04683345f, 0.03238630f, -0.11452809f, 0.15111881f, 
    0.09109148f, -0.11084015f, 0.02950342f, -0.10895970f, 0.12678258f, 0.02411183f, -0.00036676f, -0.11828454f, 
    0.10985462f, 0.11236250f, -0.09849975f, 0.16099571f, -0.10800880f, -0.08604826f, -0.08949977f, 0.05990964f, 
    -0.18324889f, -0.12642303f, -0.17809834f, 0.26043382f, 0.30074313f, 0.11067237f, -0.04141842f, -0.27248296f, 
    0.04696145f, -0.19543046f, -0.01231149f, -0.07442450f, -0.50916153f, 0.30221629f, -0.24700183f, -0.10667743f, 
    0.05567026f, 0.01892268f, -0.02475759f, -0.07030242f, 0.08168750f, 0.18739308f, 0.14022982f, 0.04910860f, 
    -0.09539761f, 0.01341049f, 0.34074959f, -0.12799616f, 0.32395178f, 0.27897611f, 0.15922391f, -0.05834409f, 
    0.09415647f, -0.25754198f, 0.17779595f, 0.02677045f, 0.03527185f, 0.16892394f, -0.11058503f, 0.09056785f, 
    0.06182529f, 0.02510797f, -0.05581480f, -0.24484573f, -0.01923466f, -0.01368697f, -0.04933584f, 0.19885170f, 
    0.20246121f, 0.16132788f, -0.03876145f, -0.15401641f, -0.27132964f, 0.13876981f, -0.09750573f, 0.11275006f, 
    -0.04159959f, -0.08838270f, 0.15583886f, -0.03374008f, 0.06048676f, 0.11453904f, 0.08459460f, 0.12075585f, 
    0.11727631f, 0.21615440f, -0.13135558f, 0.01265297f, 0.06227498f, 0.46132511f, 0.10732068f, -0.13389279f, 
    0.22571439f, 0.28142411f, 0.03722709f, 0.08529075f, 0.14370877f, 0.16903129f, -0.22532625f, 0.01877109f, 
    -0.00851362f, -0.04824318f, -0.11470894f, -0.14230166f, 0.00569733f, 0.05664755f, -0.13023792f, 0.14023532f, 
    0.00865062f, 0.11568735f, 0.11358017f, -0.07024976f, 0.24523391f, -0.02741740f, 0.14890727f, -0.27602702f, 
    -0.06915200f, 0.04733982f, 0.27472058f, 0.02602166f, 0.07430968f, 0.16511211f, 0.08070756f, -0.12433394f, 
    -0.15685545f, 0.32812953f, -0.14584476f, -0.28062311f, 0.22211356f, 0.07845675f, 0.16220972f, 0.08215304f, 
    0.07755029f, 0.35547125f, -0.18982467f, 0.00210716f, -0.27947304f, 0.23356926f, -0.16299362f, 0.11989390f, 
    0.22376175f, -0.05941559f, 0.38954842f, 0.02510118f, 0.07203927f, 0.06030628f, -0.20963383f, 0.29176477f, 
    -0.40202945f, 0.58368820f, 0.14785999f, 0.08180933f, -0.09194271f, -0.09789189f, -0.11692625f, 0.16383982f, 
    -0.01129405f, -0.29408357f, -0.00170524f, -0.03777635f, -0.12032746f, 0.04166823f, 0.11226138f, 0.21144982f, 
    0.17498064f, -0.29462835f, 0.30047399f, -0.05666461f, -0.32198542f, -0.08894178f, 0.00814333f, -0.00429131f, 
    -0.17592597f, -0.03408599f, -0.03145623f, -0.06369630f, -0.08305670f, 0.03102700f, -0.02979157f, 0.27194116f, 
    0.39199576f, -0.35444015f, -0.01554128f, 0.07076931f, 0.01819396f, -0.07522742f, 0.01679350f, 0.12905191f, 
    -0.12843585f, 0.40882957f, 0.06234485f, 0.07119264f, 0.12677424f, -0.23265238f, 0.13956572f, 0.00367819f, 
    0.15818444f, -0.09296362f, 0.11021367f, -0.09161749f, 0.09671046f, 0.10486637f, -0.05518886f, -0.16140920f, 
    -0.06186804f, -0.13072671f, -0.16861548f, -0.10053734f, 0.00613339f, -0.25445843f, 0.05701035f, 0.16329925f, 
    -0.01455967f, 0.24720643f, -0.20704156f, 0.32658100f, 0.33921924f, -0.02074260f, 0.09055278f, -0.10355360f, 
    -0.20070148f, 0.06679575f, 0.08255755f, 0.14109288f, -0.01878278f, 0.27569717f, 0.21549599f, -0.31477422f, 
    -0.42479005f, -0.25070503f, -0.11157496f, -0.11639886f, -0.63254899f, 0.45808747f, -0.06524525f, 0.05391417f, 
    0.27357310f, 0.11763483f, 0.23041624f, -0.14688696f, 0.10625213f, 0.28321701f, 0.15586454f, -0.13065560f, 
    0.12206007f, -0.10004519f, -0.47390264f, -0.11908727f, 0.12105341f, 0.26919937f, -0.12538877f, 0.10028128f, 
    0.12604053f, -0.28775680f, 0.02498539f, 0.28887939f, -0.13826051f, 0.02541944f, -0.00664748f, -0.17705069f, 
    -0.09230945f, -0.21586281f, 0.00895475f, 0.12248374f, -0.01255036f, 0.40600026f, -0.16642168f, 0.07391980f, 
    0.02984413f, 0.09619407f, 0.07314052f, -0.04226639f, 0.40824571f, -0.00978009f, -0.34026930f, -0.20478767f, 
    -0.03195391f, -0.27606484f, -0.09428035f, 0.33921254f, 0.15474638f, -0.01505631f, -0.13983953f, 0.03712876f, 
    -0.04949196f, 0.13727973f, 0.14554487f, -0.10043363f, 0.21971862f, -0.12875038f, 0.14332362f, 0.10435051f, 
    0.29530576f, -0.14773026f, 0.00203481f, 0.07582420f, -0.40218890f, -0.47802764f, 0.04001777f, 0.03515418f, 
    -0.14725260f, 0.09078999f, -0.43407509f, 0.12675074f, -0.15829171f, -0.23822317f, 0.13758652f, 0.16886474f, 
    0.14563218f, -0.09348080f, 0.03026268f, 0.02586822f, -0.10803440f, -0.00547066f, -0.10426087f, 0.08126140f, 
    -0.12427223f, -0.13369034f, 0.12728782f, 0.02215732f, -0.13756211f, -0.05923796f, -0.13254322f, -0.06675150f, 
    -0.04361695f, -0.14040522f, -0.09055123f, -0.02383739f, -0.05318479f, -0.01853153f, -0.11843566f, -0.09892303f, 
    0.09760681f, 0.03165416f, 0.07018521f, 0.05082813f, -0.01708621f, 0.06442270f, -0.06589569f, -0.13074706f, 
    0.22671212f, -0.15350872f, -0.30130115f, 0.27145305f, -0.23331343f, -0.61830664f, -0.06736258f, -0.00395502f, 
    -0.13667947f, 0.10687121f, -0.05715416f, 0.27508536f, 0.26230186f, 0.38686237f, 0.27870324f, 0.04060921f, 
    -0.16944854f, -0.50576234f, -0.15930906f, -0.09926601f, 0.15920955f, -0.08142762f, 0.09140164f, 0.12289269f, 
    0.29953694f, 0.01890539f, -0.30658388f, 0.03108433f, 0.09438802f, 0.24487408f, 0.06591757f, -0.20222662f, 
    0.16771558f, 0.48367575f, -0.07327840f, 0.01670663f, -0.08648834f, 0.25597993f, -0.04234590f, -0.01537934f, 
    -0.24478784f, 0.25512129f, 0.13539885f, -0.13760091f, 0.13189077f, 0.13253424f, -0.03200543f, -0.07684807f, 
    0.11063490f, 0.35358372f, -0.09686226f, 0.11414109f, -0.16458431f, -0.09749557f, 0.05965827f, -0.14992356f, 
    0.17840916f, 0.15798357f, -0.52349955f, 0.13026787f, 0.17623489f, 0.17548093f, -0.46956721f, 0.18744417f, 
    0.01317355f, -0.07971591f, 0.06369493f, -0.02148964f, -0.16933820f, -0.00805969f, -0.12005511f, -0.01823539f, 
    0.05593456f, -0.17793015f, -0.04200618f, -0.03649844f, 0.07471767f, -0.10779815f, 0.00002016f, -0.18265836f, 
    -0.24601933f, -0.16810718f, -0.14936969f, 0.11142848f, 0.03526351f, -0.25335386f, -0.04909791f, 0.02596265f, 
    -0.22116074f, -0.09532116f, -0.02609483f, 0.13066763f, -0.00150010f, -0.15880619f, 0.13992938f, 0.12141711f, 
    -0.24669699f, -0.05182766f, 0.34286231f, -0.06835561f, 0.38136971f, -0.25349873f, 0.01016753f, 0.34264717f, 
    -0.42640349f, 0.08381681f, 0.09106861f, -0.24313569f, -0.07779514f, 0.16694546f, -0.00703842f, 0.02940281f, 
    0.12907462f, 0.31409207f, 0.23751564f, -0.03509001f, -0.22361198f, 0.21101508f, 0.00894734f, 0.02739742f, 
    -0.04684040f, 0.07150465f, 0.13805827f, 0.07940839f, 0.19240825f, -0.11131341f, -0.36265522f, 0.27796599f, 
    -0.22878236f, 0.11817296f, -0.36427805f, 0.02399803f, 0.19320258f, 0.08449583f, -0.05298544f, 0.04710098f, 
    -0.24977243f, -0.34986013f, 0.16018221f, 0.25389513f, -0.40802744f, -0.04546216f, 0.02131847f, -0.24543445f, 
    0.04589271f, -0.24313855f, 0.22190185f, 0.15916117f, -0.38251281f, 0.26414129f, 0.07521296f, -0.09301198f, 
    -0.02663522f, -0.16477665f, 0.10486499f, -0.02129416f, 0.23418972f, 0.17416082f, 0.10521222f, 0.13018781f, 
    -0.07042126f, 0.12354639f, -0.09383050f, -0.05224190f, -0.11463766f, -0.03001463f, -0.10789660f, -0.14155704f, 
    -0.11544820f, -0.05307324f, 0.12556604f, -0.06512382f, -0.05009630f, -0.09180824f, -0.09770650f, 0.12619145f, 
    -0.09145377f, -0.11048663f, -0.11817355f, 0.08555161f, -0.09427630f, 0.09501024f, 0.08333258f, -0.04302869f, 
    0.11471730f, -0.03617499f, 0.16495185f, -0.03398041f, 0.02639546f, -0.07938145f, -0.01763598f, -0.12776516f, 
    -0.10156283f, 0.46755889f, 0.29283029f, 0.08706069f, -0.19737004f, -0.02688499f, -0.12329441f, 0.08744443f, 
    0.00967761f, -0.32400265f, -0.16612463f, -0.14559291f, -0.48220968f, -0.22746111f, 0.37363854f, 0.19655523f, 
    0.00082862f, -0.12910748f, 0.07166626f, -0.05720817f, -0.42510051f, 0.08889139f, -0.06290691f, 0.07153890f, 
    0.03745540f, -0.01677230f, 0.31672317f, -0.04039228f, 0.16525190f, -0.21269025f, 0.05928446f, 0.15222350f, 
    -0.14236814f, -0.48166037f, 0.01051096f, -0.13040806f, -0.16195770f, -0.02452321f, -0.00759785f, -0.29177961f, 
    -0.08936583f, 0.03232180f, 0.15127102f, -0.06567914f, -0.20507424f, 0.10457516f, -0.05057564f, -0.15441810f, 
    -0.08199514f, -0.06227794f, -0.46499017f, -0.07514724f, 0.08367895f, 0.42351878f, 0.16915408f, -0.12137093f, 
    0.09753239f, 0.12162784f, 0.21123286f, -0.17514038f, 0.22581117f, 0.01691480f, -0.08905098f, 0.00676956f, 
    0.15663247f, -0.17732674f, -0.07336083f, -0.10691188f, -0.12421322f, -0.09432922f, 0.01506413f, -0.34935054f, 
    0.18666323f, -0.38939488f, -0.05578799f, -0.15552060f, -0.04555977f, -0.09222793f, -0.30602601f, 0.06367338f, 
    0.04940220f, 0.19238454f, -0.12754838f, -0.11224727f, 0.09790590f, 0.05888568f, 0.13983382f, 0.06134463f, 
    0.12848711f, 0.05719448f, -0.08108260f, 0.00536610f, -0.12613681f, 0.15196748f, 0.17657241f, -0.46626344f, 
    -0.08610217f, -0.14192587f, 0.05449313f, -0.21609691f, 0.00813018f, -0.15767235f, 0.08744305f, -0.08689975f, 
    -0.08990231f, -0.18567623f, -0.06640693f, -0.06492405f, -0.16093704f, 0.12135560f, 0.04571994f, 0.11798421f, 
    0.03681341f, -0.02021316f, -0.05860949f, -0.07558963f, -0.08033342f, 0.00967058f, -0.09571958f, 0.00430229f, 
    0.07415821f, 0.15378092f, -0.09725685f, -0.13598500f, -0.04526346f, -0.10441760f, -0.01737366f, -0.19198182f, 
    -0.17007047f, 0.43217075f, -0.47767428f, -0.32197708f, 0.18955944f, -0.23774266f, -0.08911435f, 0.26226127f, 
    -0.49825227f, 0.01195275f, -0.05192158f, 0.10572331f, 0.04036963f, 0.21566984f, -0.08183893f, -0.36724874f, 
    -0.08528390f, -0.11748885f, 0.29455164f, -0.03962408f, -0.31829926f, 0.18861908f, 0.11157745f, -0.13000591f, 
    0.16290656f, -0.10261890f, -0.65281051f, -0.00696607f, 0.05616617f, 0.18204069f, -0.29811710f, -0.00535919f, 
    -0.00607420f, -0.23630129f, -0.09324042f, 0.34988740f, 0.05155303f, 0.17378211f, 0.02761815f, 0.09813461f, 
    -0.08230891f, 0.24456061f, -0.05665480f, -0.10839885f, 0.05357538f, -0.03548974f, 0.13184176f, 0.11637147f, 
    0.17942093f, 0.19246490f, -0.00346110f, -0.04742951f, -0.75438541f, -0.51653075f, -0.05734963f, 0.10676780f, 
    -0.47258851f, -0.13651943f, -0.24083200f, -0.15736617f, -0.13941059f, -0.50317800f, -0.06637867f, 0.25469992f, 
    -0.36833578f, 0.58351016f, -0.30833122f, 0.05001725f, 0.15777946f, 0.41161922f, 0.02297982f, -0.17845936f, 
    0.14880410f, 0.08269351f, 0.15637614f, -0.21601444f, 0.11653151f, 0.12543365f, -0.03842791f, 0.22411132f, 
    0.02769765f, -0.09253277f, 0.32977429f, 0.03756403f, -0.07451442f, -0.12367583f, 0.11454173f, 0.01133756f, 
    -0.31508783f, 0.04828857f, 0.36077979f, -0.06062656f, 0.07647696f, 0.01798766f, -0.41056338f, 0.16749477f, 
    0.07393358f, 0.04867327f, -0.31897232f, 0.04025917f, 0.04798780f, -0.05546310f, -0.15986264f, 0.02966441f, 
    -0.47076654f, 0.19153836f, 0.08011102f, 0.22733979f, 0.09431310f, 0.01018453f, -0.14058015f, -0.52767903f, 
    0.00248626f, -0.39802092f, 0.20487447f, 0.16825172f, -0.21103519f, 0.06418797f, 0.02436814f, -0.07269882f, 
    0.04387933f, -0.07603922f, -0.16537613f, 0.13916887f, 0.22599059f, 0.24587718f, -0.01623488f, -0.01995709f, 
    0.02286100f, -0.10417181f, 0.03982187f, 0.07837958f, 0.19365793f, -0.05711386f, -0.11674812f, -0.11505702f, 
    -0.07241637f, -0.15710609f, -0.09544262f, -0.11139385f, 0.10095009f, 0.04835948f, -0.09722201f, -0.02859884f, 
    0.00307250f, 0.09363852f, 0.12034757f, 0.06744418f, 0.01135777f, -0.13780569f, 0.10886187f, -0.13727558f, 
    -0.14961381f, 0.06258951f, -0.04376712f, 0.05421163f, -0.04292273f, 0.22619264f, 0.11325424f, -0.06322733f, 
    -0.12352873f, 0.15197556f, -0.06823704f, -0.11901645f, -0.12017516f, -0.04583606f, -0.06282949f, -0.07301993f, 
    0.05057836f, -0.12483064f, -0.06426869f, 0.01882986f, -0.13447341f, -0.17057468f, -0.08984060f, -0.06741538f, 
    -0.08220627f, 0.07064661f, -0.16218908f, 0.02130576f, -0.14683315f, 0.09604614f, -0.06767406f, -0.12146664f, 
    -0.03497207f, -0.16697192f, -0.02882535f, 0.07705689f, 0.02876707f, -0.06293714f, -0.14309081f, -0.04090870f, 
    0.18818983f, 0.07017395f, -0.39964196f, 0.00936063f, -0.03715643f, -0.13460749f, 0.04751398f, 0.05375803f, 
    -0.17801505f, 0.04075690f, 0.16674940f, -0.08266308f, 0.17128070f, 0.18496981f, 0.08862612f, 0.17519505f, 
    0.20271130f, -0.01290512f, 0.15020050f, 0.13380283f, -0.19317427f, -0.25581512f, 0.00615892f, 0.16619214f, 
    -0.10855591f, -0.12600246f, -0.68619150f, -0.06088430f, 0.21822743f, 0.24358331f, 0.33599323f, -0.16607371f, 
    -0.00750099f, -0.26666763f, -0.13911596f, -0.27305004f, 0.08765330f, -0.03531808f, 0.04123870f, -0.37667260f, 
    0.04509763f, -0.30706778f, -0.14866214f, -0.23298676f, -0.44489643f, 0.25294700f, -0.05816660f, 0.11111685f, 
    -0.04402031f, 0.10233596f, -0.05352039f, -0.13469514f, 0.12232941f, 0.30152440f, 0.16705488f, -0.05004337f, 
    0.11039495f, -0.02316203f, 0.04342037f, 0.11211483f, 0.04093045f, 0.03708349f, 0.04950437f, 0.09900740f, 
    -0.06768074f, 0.10499693f, 0.38486710f, -0.09126557f, -0.22803488f, -0.09515481f, -0.10092326f, 0.20125443f, 
    -0.19647369f, 0.31747696f, 0.12235673f, -0.06906053f, 0.03814321f, -0.02432346f, -0.05047965f, 0.16209577f, 
    0.22559746f, -0.40334406f, 0.25195593f, 0.07578874f, -0.04792696f, 0.21818849f, 0.14279942f, -0.15511033f, 
    0.14335515f, -0.18063253f, 0.34448513f, -0.12834175f, -0.26227713f, 0.11230236f, 0.12171347f, -0.13505739f, 
    0.02188389f, -0.33251897f, -0.18622768f, -0.26709270f, 0.15605786f, -0.17029451f, -0.05927708f, 0.24167876f, 
    -0.11850361f, -0.05462517f, 0.08215587f, -0.09845832f, -0.24416962f, -0.06646927f, 0.25444758f, -0.41523904f, 
    -0.01115893f, 0.21073326f, 0.04253197f, 0.05585232f, 0.13645436f, 0.32360077f, -0.12718767f, -0.15097843f, 
    0.50542933f, 0.14926961f, -0.35821956f, -0.16814081f, -0.03084367f, 0.39698905f, -0.08479936f, 0.12252443f, 
    0.22122917f, -0.04760297f, -0.16797560f, 0.02629170f, -0.11659858f, -0.04222802f, 0.06376518f, 0.20128137f, 
    -0.13317285f, 0.09618659f, -0.05693670f, 0.25653350f, 0.06478246f, 0.37261191f, -0.16407432f, -0.12966512f, 
    0.04072435f, -0.08231315f, 0.01907941f, 0.07353145f, 0.21325727f, -0.00608318f, -0.03540011f, -0.14498509f, 
    0.12176014f, -0.03650283f, -0.07134838f, -0.01745565f, 0.07767910f, -0.39243442f, -0.19582598f, 0.05659625f, 
    0.05590779f, -0.33396405f, -0.10380473f, 0.19991648f, 0.34529188f, 0.28860679f, 0.11740487f, -0.19090252f, 
    0.05518207f, 0.23055659f, -0.14723410f, -0.17651168f, 0.02100638f, 0.22114302f, -0.21457726f, -0.07461140f, 
    -0.12150163f, 0.18062168f, 0.10948922f, -0.00185987f, -0.00927797f, 0.20886363f, -0.17398654f, -0.00081226f, 
    -0.00940120f, 0.02097105f, 0.15411003f, 0.08927822f, 0.34389842f, 0.17238051f, -0.23216991f, -0.26379344f, 
    0.13256040f, -0.10925092f, -0.10837805f, -0.11930102f, -0.10188379f, -0.09999362f, -0.01386219f, -0.01891021f, 
    -0.01639825f, -0.08351032f, 0.04244502f, -0.01945192f, 0.09095702f, -0.20594941f, -0.19407643f, 0.04853636f, 
    -0.19153883f, -0.03913122f, -0.03405321f, 0.16613996f, 0.04898347f, 0.04231482f, 0.13433158f, -0.14878540f, 
    -0.02414216f, -0.04449493f, -0.05932255f, 0.02876828f, -0.10340659f, 0.01766240f, -0.03525396f, -0.04259896f, 
    -0.38326883f, 0.03352972f, -0.21384828f, -0.00991755f, 0.16626790f, 0.13318452f, 0.05345811f, 0.18594019f, 
    -0.12839885f, 0.17585315f, -0.14514013f, -0.03368808f, -0.18303771f, -0.19760340f, 0.03902538f, -0.24287927f, 
    -0.03327915f, 0.01940847f, 0.22084774f, -0.16831797f, 0.01163815f, 0.21912327f, 0.11433113f, -0.09182200f, 
    -0.07866722f, 0.04385412f, 0.02649105f, 0.12478577f, 0.25886449f, 0.31748217f, -0.35929856f, -0.12162829f, 
    -0.02532787f, 0.18431313f, 0.21773845f, 0.06907812f, 0.09912707f, 0.11198261f, -0.08041810f, -0.18563600f, 
    0.01559917f, 0.00592512f, -0.03448923f, -0.29618841f, 0.12716842f, 0.12212612f, -0.00889714f, -0.08701497f, 
    0.19455086f, 0.05913011f, 0.19257124f, 0.08260997f, 0.06288660f, -0.04398790f, 0.09396818f, -0.00543429f, 
    -0.16920686f, 0.04803833f, -0.00140943f, 0.05358114f, 0.14366129f, -0.06324910f, -0.37597546f, 0.26842940f, 
    0.04146637f, 0.16259325f, -0.06121689f, 0.22588561f, 0.01061264f, 0.14787136f, 0.15121540f, 0.06832320f, 
    0.17059623f, 0.09765302f, -0.17210466f, -0.27545005f, -0.22269346f, -0.25395727f, 0.16711096f, 0.10382058f, 
    0.19544528f, -0.10089542f, 0.03427268f, 0.02064913f, 0.18556766f, -0.18746001f, -0.04206254f, -0.14405356f, 
    -0.67659712f, -0.12354695f, 0.20345321f, -0.13745940f, -0.28727317f, -0.18964940f, 0.16819526f, 0.14309475f, 
    0.10470273f, 0.08547207f, 0.00548840f, -0.14439517f, -0.07076178f, 0.28510061f, 0.07342606f, -0.25272194f, 
    0.05543744f, 0.38130674f, -0.02968110f, -0.02583768f, 0.03999726f, -0.03282223f, 0.18719420f, -0.04619343f, 
    -0.00518380f, 0.32238588f, -0.10386263f, -0.00557639f, -0.31102610f, 0.26436925f, -0.15542543f, 0.08086283f, 
    -0.15597855f, 0.01226599f, 0.22885290f, 0.09142776f, 0.36929715f, 0.18576866f, -0.19401193f, 0.09599592f, 
    0.09527192f, 0.14719889f, -0.03995370f, 0.40371925f, 0.20666938f, -0.20787695f, -0.03455209f, 0.16307795f, 
    -0.04102204f, 0.26569968f, -0.17248188f, -0.06951973f, 0.27696827f, 0.18167652f, 0.23797350f, 0.03180161f, 
    0.05856178f, -0.06484109f, 0.33635193f, -0.00638109f, 0.12143184f, -0.38896912f, -0.14106306f, -0.15977864f, 
    -0.18031880f, 0.15255268f, -0.44419783f, 0.13948765f, -0.12201855f, -0.36364341f, 0.17725374f, -0.21413940f, 
    0.06081027f, -0.13449195f, -0.06672718f, -0.03795009f, 0.04502455f, 0.05810961f, 0.05499894f, -0.15062313f, 
    0.15370560f, 0.01317450f, -0.02422204f, -0.13140893f, 0.03358753f, -0.16665281f, 0.04063319f, -0.17597383f, 
    -0.17571145f, -0.06228248f, 0.04432722f, 0.03105969f, -0.16332443f, -0.06231035f, -0.09054746f, 0.04554683f, 
    -0.03779632f, -0.09605153f, -0.00850178f, 0.16321361f, 0.05242143f, -0.14911798f, -0.14801311f, -0.14342636f, 
    -0.40044206f, 0.31846905f, -0.38780421f, 0.37517869f, 0.26018155f, 0.04176049f, 0.12724292f, 0.00510295f, 
    0.06655508f, -0.27426830f, -0.12865116f, -0.06654648f, -0.16065110f, 0.16693717f, 0.09680544f, 0.05036214f, 
    -0.04545342f, 0.10804097f, 0.34762925f, -0.00289862f, -0.08030647f, -0.10825571f, -0.02061216f, 0.11470471f, 
    -0.32601988f, -0.04665461f, 0.18030405f, -0.09726304f, -0.03048797f, 0.02396837f, -0.04437516f, -0.09729586f, 
    0.30838525f, -0.04493424f, 0.18703341f, -0.15001062f, -0.12963133f, -0.25353026f, 0.02596232f, -0.05468612f, 
    0.03968251f, 0.19895709f, 0.03928383f, -0.02786671f, 0.22784923f, 0.07415949f, 0.12737924f, -0.00092355f, 
    0.11478640f, -0.05709101f, -0.03595806f, -0.12682822f, -0.15866782f, -0.11539803f, 0.11823940f, -0.04846723f, 
    -0.05660212f, -0.02492016f, -0.12042981f, 0.00601766f, 0.07718132f, 0.24978119f, -0.13079527f, -0.36119151f, 
    -0.29323608f, -0.11961510f, -0.15565170f, -0.04316758f, 0.31656194f, -0.04575105f, 0.17139837f, 0.10811709f, 
    -0.15769300f, 0.04280635f, -0.11798525f, -0.13659702f, -0.13641728f, -0.24368374f, 0.01592264f, -0.25401914f, 
    0.21068753f, -0.02174216f, 0.35973915f, -0.13485245f, -0.18515189f, 0.12888318f, 0.07491964f, 0.10364686f, 
    0.07398357f, -0.07344327f, 0.27301246f, 0.03585623f, 0.02944350f, 0.23187634f, -0.27668366f, 0.04580505f, 
    -0.05183597f, 0.11078916f, -0.01488739f, 0.07099640f, 0.11089645f, 0.34363961f, -0.17796211f, 0.09985671f, 
    0.20788181f, 0.16628614f, 0.15127270f, 0.20819530f, -0.13333425f, -0.09035010f, -0.19134246f, -0.18133827f, 
    0.01952541f, -0.10559557f, 0.15258035f, -0.00791495f, 0.00708367f, -0.01820694f, -0.15496427f, -0.00413300f, 
    0.07894328f, -0.16566071f, 0.19181488f, -0.14280814f, 0.08410439f, -0.27394930f, -0.15845470f, 0.25750539f, 
    0.00822735f, -0.10364021f, 0.14941379f, 0.22416563f, -0.05831787f, -0.08968062f, -0.11517546f, 0.07484760f, 
    0.10551061f, 0.38264316f, 0.18108231f, 0.12670155f, 0.42730072f, 0.23117034f, -0.12043109f, 0.27574441f, 
    0.00857512f, -0.00001072f, 0.00007495f, -0.10967118f, -0.01991228f, -0.16234119f, 0.16278915f, -0.05361305f, 
    -0.07383662f, -0.04483119f, -0.06709807f, -0.11507416f, -0.18473861f, -0.09349854f, 0.15177877f, -0.02275237f, 
    -0.24695067f, 0.05317042f, -0.16883369f, -0.33512360f, 0.05792377f, -0.21253362f, 0.10177936f, 0.21718098f, 
    -0.15892188f, -0.16980390f, -0.00793584f, 0.17423828f, 0.05217103f, 0.04798653f, 0.13408631f, -0.25010216f, 
    0.02443336f, 0.07513693f, 0.03396429f, -0.10885887f, 0.05418253f, 0.27344379f, -0.02270012f, 0.11811808f, 
    0.22857709f, -0.14352709f, -0.03473559f, 0.07912877f, 0.25604120f, -0.00188289f, -0.08618671f, 0.25641647f, 
    -0.07903841f, -0.14074278f, 0.16289559f, -0.02162884f, -0.14071421f, 0.12823282f, 0.09555768f, -0.15801784f, 
    0.16317220f, 0.03226025f, -0.16787569f, -0.04728012f, -0.05944805f, 0.00098221f, -0.29667532f, -0.01755478f, 
    0.12191728f, 0.03240732f, -0.23261873f, 0.05465111f, 0.14673512f, -0.25692493f, -0.16990419f, 0.10760135f, 
    0.67833418f, 0.07741912f, -0.11717819f, 0.07626633f, 0.09520725f, 0.19800709f, 0.06970622f, -0.05199482f, 
    0.42494980f, 0.29434049f, -0.16153625f, -0.41382566f, 0.06245688f, 0.14016312f, -0.05273751f, 0.09287103f, 
    0.12129042f, -0.02149945f, 0.01484502f, -0.11370587f, -0.04675448f, 0.15312870f, 0.06787805f, 0.07909846f, 
    0.14985546f, 0.13723044f, 0.14267093f, 0.08624668f, -0.10401691f, -0.18576537f, -0.15006505f, -0.15645108f, 
    -0.04891533f, 0.16724971f, 0.21562493f, 0.07929412f, 0.20272227f, -0.44208261f, -0.29842728f, 0.36138424f, 
    -0.23806256f, -0.27195778f, 0.05869007f, -0.04706760f, 0.29385731f, 0.17285502f, 0.06535466f, 0.20295975f, 
    0.14161998f, -0.20276235f, 0.03802439f, -0.19156197f, -0.28788248f, -0.07440417f, 0.09855422f, -0.02279193f, 
    0.10525180f, 0.10798437f, 0.22572806f, -0.12695059f, 0.01647631f, 0.33432075f, -0.05917472f, -0.02022660f, 
    -0.18421102f, 0.00315425f, 0.36162102f, -0.11804540f, 0.06547934f, 0.16665035f, -0.11872883f, -0.00213271f, 
    -0.18272908f, 0.08370434f, -0.09618085f, 0.03091037f, -0.03151261f, -0.24184348f, 0.11780975f, -0.02903807f, 
    -0.10924324f, -0.05819802f, -0.03678128f, -0.16327986f, 0.01492750f, -0.01283562f, -0.10324547f, -0.04852019f, 
    0.06954190f, 0.03191027f, -0.08876260f, 0.13097565f, 0.02467851f, -0.17753877f, 0.05397295f, 0.08278887f, 
    -0.06982381f, -0.03267701f, 0.00718174f, 0.11670219f, 0.01932125f, 0.00804085f, -0.01077390f, -0.18916032f, 
    -0.00771305f, 0.09496795f, 0.08665814f, -0.09889641f, 0.02519089f, 0.08963118f, -0.03380519f, 0.20088612f, 
    -0.03349517f, -0.36095577f, -0.06928790f, -0.18113883f, -0.25970745f, -0.35744989f, 0.28640950f, -0.03348721f, 
    0.11450426f, 0.21581472f, -0.12967677f, 0.14917791f, -0.21460228f, 0.10339740f, 0.09755825f, -0.08830239f, 
    -0.08672871f, -0.13836296f, 0.20293631f, 0.05033627f, -0.01499534f, -0.04320447f, -0.13387236f, 0.25791195f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11119475f, 0.07693590f, 0.14281911f, 0.26092449f, -0.10050112f, 0.23950456f, 0.20747724f, 0.06926619f, 
    -0.35859212f, -0.04623512f, -0.13559455f, 0.12054671f, 0.34140745f, -0.07356875f, 0.28057012f, -0.34234461f, 
    -0.05407366f, 0.32787219f, -0.02360865f, 0.09869792f, 0.02806456f, 0.00579475f, 0.20997904f, 0.19100617f, 
    0.24780257f, 0.05773500f, 0.24498145f, -0.11670258f, 0.04486548f, 0.04507766f, 0.20022829f, -0.14572619f, 
    0.15650819f, 0.08711214f, -0.34736106f, 0.17019279f, -0.08738428f, 0.18824574f, 0.03550762f, -0.06497207f, 
    0.03240511f, 0.11749237f, 0.13416982f, -0.10554660f, -0.23526347f, 0.35665092f, 0.01139613f, -0.07795300f, 
    0.01688974f, 0.11075325f, -0.09392891f, 0.04731162f, -0.07002109f, 0.12003429f, 0.13725491f, 0.22162147f, 
    -0.00939674f, -0.15061581f, 0.18467601f, 0.12975277f, -0.00449303f, -0.10258658f, 0.21830770f, 0.17118058f, 
    0.30959883f, 0.14368397f, 0.10721249f, 0.10616344f, 0.37640572f, 0.13702410f, 0.07958113f, -0.06027849f, 
    0.35015610f, 0.35403192f, -0.07241547f, -0.02591569f, -0.03340673f, 0.02756475f, 0.00176398f, 0.25841552f, 
    0.05761619f, -0.10182804f, 0.18391988f, 0.07180411f, -0.10784379f, 0.07019357f, 0.11960314f, -0.05150058f, 
    -0.07707544f, -0.18458195f, -0.23815700f, 0.28246853f, 0.00067112f, 0.09179931f, 0.03619633f, 0.08893186f, 
    0.12234026f, -0.18087849f, 0.12710042f, -0.12026732f, 0.29650137f, 0.14897145f, 0.16316448f, -0.06338092f, 
    -0.01644629f, 0.12742677f, 0.02630106f, 0.19063313f, 0.28789893f, 0.03322798f, 0.05153479f, -0.10983981f, 
    0.24199374f, -0.12991738f, 0.04899520f, 0.26483655f, 0.03567695f, 0.06443294f, -0.07494775f, 0.15951659f, 
    0.35844144f, -0.09261741f, -0.05821845f, -0.05213095f, 0.37810400f, 0.14555380f, -0.17521131f, 0.00683076f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.05984049f, 0.10356502f, -0.14960615f, -0.35374787f, 0.16501480f, -0.12086041f, -0.39357352f, -0.31376490f, 
    0.02252189f, 0.04977742f, 0.11798175f, -0.02934126f, 0.36853021f, 0.41999176f, -0.79616266f, 0.07493857f, 
    0.05581621f, 0.11395250f, -0.04159390f, -0.18170789f, 0.10334802f, 0.02198192f, 0.10472975f, 0.00452529f, 
    0.12942140f, -0.02563417f, -0.22097875f, -0.07195762f, -0.30702195f, 0.05653018f, -0.06788345f, -0.03490160f, 
    -0.23703840f, -0.04494337f, 0.50422519f, 0.21505234f, 0.01124415f, -0.26959911f, -0.05390608f, -0.00065322f, 
    0.05070307f, 0.03873818f, -0.34173572f, 0.05953876f, 0.01933814f, -0.10792249f, -0.01198968f, 0.14193624f, 
    -0.28331283f, 0.02208414f, -0.11068849f, -0.08438148f, 0.09701106f, 0.06329115f, -0.00217771f, 0.17687261f, 
    -0.08510796f, -0.02393106f, -0.09603961f, 0.11252352f, -0.34924120f, 0.01768257f, -0.01719088f, -0.27128717f, 
    -0.10015644f, -0.23223281f, 0.29535213f, 0.10005444f, -0.57672650f, -0.17117803f, -0.00368288f, 0.38853434f, 
    -0.23297416f, -0.10554512f, 0.09400462f, -0.19517595f, -0.08102850f, -0.01470533f, 0.08072206f, 0.01112712f, 
    0.00842114f, 0.04066221f, -0.21607967f, 0.05217836f, 0.29707998f, 0.07453384f, 0.16130956f, -0.05777924f, 
    0.28754619f, 0.05215317f, -0.10248327f, -0.10596748f, 0.08767676f, -0.02233999f, 0.19126691f, -0.04700064f, 
    -0.14269722f, 0.06619318f, -0.24621259f, 0.22211970f, -0.17365652f, -0.07884060f, -0.05594771f, 0.08272209f, 
    0.10119583f, -0.02424358f, -0.15195338f, -0.35895178f, 0.07129145f, -0.00043588f, -0.00323933f, -0.34076422f, 
    -0.17288572f, 0.08348051f, -0.02782981f, 0.16182521f, 0.02655332f, -0.01431088f, 0.12060061f, -0.71601796f, 
    -0.26736689f, 0.11303402f, -0.35356995f, 0.04399189f, -0.07064909f, -0.44977406f, -0.04155173f, -0.11777251f, 
    -0.39504489f, 0.06624851f, -0.09255607f, -0.09703687f, 0.04469239f, 0.16198578f, 0.33762974f, 0.05799497f, 
    -0.18351936f, 0.26849928f, 0.08729722f, -0.49107164f, -0.15376444f, -0.37388614f, -0.04623213f, -0.09465855f, 
    -0.09088220f, -0.08017618f, -0.01217863f, -0.33258170f, 0.03522541f, 0.04029067f, 0.14255100f, -0.08649068f, 
    0.05734551f, -0.63472354f, -0.03102071f, -0.01770133f, -0.18025205f, -0.02273292f, -0.14799018f, -0.11318181f, 
    0.02867581f, 0.08166613f, -0.61209989f, 0.00427273f, -0.10601504f, 0.04957388f, 0.01856641f, -0.09960687f, 
    0.01488559f, 0.22528940f, -0.06563862f, 0.08208400f, 0.07850467f, -0.24011441f, 0.02247184f, 0.18058324f, 
    0.00788680f, -0.02812541f, 0.00489605f, -0.01829959f, 0.20872438f, -0.18569842f, -0.07007529f, 0.00807964f, 
    0.24555849f, -0.46525863f, 0.41237822f, -0.05638057f, -0.07242054f, -0.12105369f, 0.00796524f, 0.32979479f, 
    0.08559148f, -0.11642548f, 0.52036822f, 0.07803625f, -0.01307454f, -0.11561555f, 0.00056566f, 0.42805916f, 
    -0.09376684f, 0.04837688f, 0.04331091f, -0.28475246f, -0.00742475f, -0.05225077f, 0.22997685f, 0.09346519f, 
    -0.02959033f, 0.08879776f, 0.12871000f, 0.05968852f, -0.70176566f, -0.60949630f, 0.36168560f, 0.07367340f, 
    -0.68869430f, -0.13091809f, -0.01382175f, 0.08851408f, -0.18281735f, 0.00159638f, -0.12810358f, 0.25599483f, 
    -0.08292720f, 0.02860693f, -0.33877924f, 0.40605614f, 0.28188455f, -0.21222058f, -0.00343175f, -0.02149446f, 
    -0.04346299f, 0.15941271f, 0.19180053f, -0.33288899f, -0.07698072f, 0.18981256f, 0.01814006f, -0.08712390f, 
    0.18444273f, 0.08905063f, -0.03760926f, 0.18559909f, -0.02066263f, 0.14261787f, 0.00208169f, -0.00693271f, 
    0.00727108f, 0.06700123f, -0.23246846f, -0.10119627f, 0.07454339f, 0.10376627f, -0.04159525f, -0.14174856f, 
    0.13795719f, 0.43637678f, -0.03384532f, -0.11961422f, -0.24143265f, -0.13839975f, -0.03857522f, -0.25792700f, 
    0.20368226f, -0.55064350f, -0.01480625f, -0.00609849f, 0.07706792f, -0.29761147f, 0.15153454f, 0.09423407f, 
    -0.24194291f, 0.08620907f, 0.07691242f, 0.13438080f, -0.04514194f, -0.58478534f, 0.00297653f, -0.05557813f, 
    -0.03656553f, -0.03220627f, -0.01685607f, 0.00232871f, -0.01805235f, 0.08067302f, 0.10995992f, -0.05687629f, 
    0.10591931f, 0.06955773f, -0.06437711f, -0.14805540f, -0.28819048f, 0.07681642f, 0.05800699f, 0.02072702f, 
    -0.31826276f, 0.06327464f, 0.07562484f, -0.23228216f, -0.23687424f, 0.21769312f, -0.00725449f, -0.72065502f, 
    0.07131703f, -0.03615715f, -0.05591960f, -0.23264886f, -0.71062124f, -0.15586394f, -0.05913803f, 0.24083471f, 
    0.06693362f, -0.21473216f, -0.59084529f, -0.74970084f, -0.10089989f, 0.00015225f, -0.05388218f, -0.26388174f, 
    0.34175545f, 0.20128070f, -0.18392175f, -0.63655168f, 0.24580669f, -0.00990512f, 0.00695625f, -0.32200816f, 
    0.18540722f, 0.02442200f, -0.02326901f, 0.06623781f, -0.05543743f, -0.04028183f, -0.33147746f, -0.15255699f, 
    0.03716428f, -0.27953535f, 0.44372001f, -0.04695246f, -0.02101017f, 0.09390558f, -0.60689688f, 0.07938033f, 
    -0.66081637f, 0.07235800f, -0.06763358f, 0.14304146f, 0.24104360f, -0.01061160f, 0.37847275f, -0.07513191f, 
    0.25228465f, -0.00185360f, 0.44003376f, -0.65228939f, 0.36445773f, 0.16956222f, 0.09234433f, 0.07727388f, 
    0.09295654f, 0.11537452f, 0.08871640f, -0.24721269f, 0.08029289f, -0.69314367f, 0.03976975f, 0.19062372f, 
    0.09570995f, 0.09380639f, -0.19352044f, 0.05042074f, 0.06722848f, 0.11449187f, -0.01822949f, -0.01475101f, 
    0.00671939f, -0.00070129f, 0.11171220f, 0.18061519f, 0.07036550f, -0.23113225f, -0.06800048f, -0.08030940f, 
    0.05976045f, 0.27341530f, -0.11547510f, -0.15911172f, -0.03661312f, -0.12284961f, 0.08548937f, -0.31108651f, 
    -0.21417791f, 0.17919472f, -0.20214312f, 0.15428582f, -0.26856565f, 0.25620595f, -0.07266331f, -0.53469640f, 
    -0.25376892f, 0.17013665f, -0.04598953f, -0.17465061f, -0.09412846f, -0.13799697f, 0.18562210f, -0.04419957f, 
    -0.03377491f, 0.21148978f, -0.07606176f, 0.04764104f, 0.13553710f, -0.05415659f, -0.10314134f, 0.09294558f, 
    -0.19463578f, 0.29201797f, 0.02008483f, -0.18240866f, 0.13211657f, 0.03289095f, -0.52548873f, 0.02221691f, 
    -0.05108446f, -0.38031507f, -0.14656557f, 0.13382864f, -0.00847736f, 0.15017736f, 0.12275929f, 0.10205201f, 
    -0.01731881f, -0.05069642f, 0.03304112f, -0.26017687f, -0.38571602f, -0.08774630f, 0.06600311f, 0.15208046f, 
    -0.54348272f, -0.36939245f, -0.20126216f, 0.17719531f, -0.13859826f, -0.24876377f, -0.09794446f, 0.19040523f, 
    -0.15718439f, -0.00882991f, -0.14731586f, 0.08558293f, 0.14169814f, 0.14370906f, 0.03583689f, 0.10546477f, 
    0.03086525f, 0.10598754f, -0.02166669f, -0.20406745f, 0.04767217f, -0.02277244f, -0.66281950f, -0.25002602f, 
    -0.81296360f, -0.48910847f, 0.17513013f, 0.02207075f, 0.16444775f, 0.18176173f, 0.05491684f, 0.04124448f, 
    0.11463791f, -0.26308450f, 0.01279845f, 0.06346982f, 0.25260714f, -0.05770705f, -0.07647191f, -0.36330527f, 
    -0.32265490f, -0.04942372f, 0.17957552f, -0.23024647f, -0.25699162f, 0.05445671f, -0.08616715f, -0.01338210f, 
    0.00810381f, -0.13137546f, -0.01192064f, 0.24312314f, 0.02234770f, -0.49392939f, 0.00912218f, 0.03030919f, 
    -0.25712338f, 0.56829244f, -0.72540742f, 0.10795884f, -0.01393656f, 0.19128805f, -0.06217599f, 0.03872787f, 
    -0.11615090f, -0.06293985f, 0.14467198f, -0.23794416f, -0.17439255f, 0.05679073f, -0.01059315f, 0.28770819f, 
    -0.11247799f, -0.12480139f, -0.01554058f, -0.33941334f, 0.11599181f, 0.05633284f, 0.02113273f, 0.05021455f, 
    -0.03815210f, -0.14925824f, -0.28099576f, 0.17079404f, -0.51901358f, -0.42182487f, -0.06154593f, 0.05859364f, 
    0.23327775f, 0.07108532f, 0.01594640f, -0.58064115f, 0.03953837f, 0.17464142f, -0.14337823f, 0.15114121f, 
    0.12100034f, 0.18433198f, -0.48327535f, 0.02442435f, -0.14917773f, -0.05580015f, 0.08283434f, 0.06708790f, 
    -0.15085375f, -0.17078918f, -0.65666729f, -0.01815167f, 0.14653221f, -0.16267656f, 0.01387650f, -0.09415273f, 
    0.09616865f, 0.04469515f, 0.12441028f, 0.08190545f, 0.11342546f, 0.16395850f, -0.23211226f, 0.05817042f, 
    -0.08494263f, -0.00498560f, -0.03609581f, -0.01684350f, -0.20117618f, 0.11937772f, -0.04942660f, -0.05578128f, 
    0.29792830f, 0.16105989f, -0.66873765f, 0.14632697f, 0.00197116f, -0.00305962f, 0.18337595f, -0.32634372f, 
    -0.00566047f, 0.10481554f, -0.33404464f, -0.01441888f, -0.00851110f, 0.15004103f, 0.07853793f, -0.62243402f, 
    -0.27910972f, 0.13470972f, 0.03636491f, 0.03559966f, -0.06721300f, -0.04263426f, -0.09779613f, -0.07772547f, 
    -0.01951416f, -0.03022127f, -0.26114979f, 0.16051686f, -0.03251549f, -0.31745622f, -0.08477569f, 0.05697421f, 
    0.14361745f, 0.01214055f, -0.12436011f, -0.12489557f, -0.66823870f, -0.09382644f, -0.09581172f, -0.35047579f, 
    -0.05144870f, -0.00864716f, 0.01151803f, -0.40190679f, -0.27346143f, 0.09981937f, -0.00906470f, 0.00695313f, 
    0.01466140f, 0.06125787f, 0.11880953f, 0.13215856f, 0.01054078f, -0.25662422f, -0.08989192f, -0.03848495f, 
    -0.17175278f, 0.04791433f, 0.15492561f, 0.04929134f, -0.01197653f, -0.49665409f, 0.12956683f, -0.17858851f, 
    -0.08355023f, 0.03133753f, 0.00125507f, -0.03986629f, -0.05509769f, -0.09869485f, -0.01979399f, -0.01996844f, 
    0.15374599f, -0.02833687f, -0.09176855f, 0.19753914f, -0.02953499f, -0.25980216f, -0.12682104f, 0.06853549f, 
    -0.36612156f, -0.36422151f, -0.10376526f, 0.00672878f, -0.63845783f, -0.66967374f, -0.04226765f, 0.09509663f, 
    -0.20765962f, -0.04773328f, -0.00428506f, 0.00833160f, 0.07766612f, 0.00714301f, 0.17202328f, -0.00731227f, 
    0.05223927f, -0.41496494f, 0.35993132f, -0.05647542f, 0.12290166f, 0.05356758f, -0.16085231f, -0.06324317f, 
    0.19992042f, -0.21163924f, 0.08245027f, -0.02275886f, -0.13188879f, 0.01912087f, 0.09216474f, -0.00137011f, 
    0.11146761f, -0.01794966f, -0.11186222f, 0.02428822f, 0.12583666f, 0.16322589f, -0.22971182f, -0.02975390f, 
    0.16615887f, -0.01493567f, 0.04678564f, -0.03657713f, 0.16712727f, 0.25254235f, 0.03071159f, 0.12418292f, 
    -0.18878913f, 0.30891711f, -0.21696448f, 0.06559055f, -0.10119495f, -0.23675075f, -0.16374651f, -0.12636326f, 
    -0.48353919f, 0.03897865f, -0.03487296f, -0.12833939f, 0.05292096f, 0.12414239f, -0.03182064f, -0.24280612f, 
    0.14007676f, 0.18274005f, 0.01160286f, -0.04074046f, -0.09345648f, -0.00846138f, 0.04272365f, 0.02896979f, 
    -0.04875458f, 0.30194014f, -0.12513207f, 0.05596320f, -0.16652411f, -0.54725409f, 0.01693276f, 0.06048165f, 
    -0.19904515f, 0.30753869f, -0.06027561f, 0.25064605f, -0.16578077f, -0.04479163f, -0.45322472f, -0.28389394f, 
    -0.72975510f, 0.01858096f, 0.08039107f, 0.07119294f, -0.04235939f, -0.08110775f, -0.01703810f, -0.00529965f, 
    -0.04594392f, -0.08663502f, -0.10246768f, 0.12632507f, 0.05901618f, 0.12678002f, 0.04930340f, 0.10428084f, 
    0.13789350f, -0.17700025f, 0.04892986f, -0.01161955f, 0.02031984f, -0.15749009f, -0.00175829f, 0.01328536f, 
    -0.04254798f, 0.07135872f, 0.06258852f, 0.01914340f, -0.01739747f, -0.05011262f, 0.02338363f, -0.12332778f, 
    -0.15620342f, -0.32468921f, 0.18004581f, 0.16662656f, -0.16756336f, 0.02124336f, -0.31325552f, -0.02442017f, 
    -0.22130309f, -0.23620443f, -0.06502355f, 0.02700776f, 0.42891631f, 0.26164481f, 0.28872880f, 0.11555131f, 
    0.14289741f, 0.01272926f, -0.05610834f, 0.36746445f, -0.25434339f, -0.63292897f, -0.95001924f, 0.02580089f, 
    -0.19495860f, -0.05009119f, -0.33725941f, 0.05343863f, 0.07118578f, -0.01813298f, 0.22546625f, 0.04268628f, 
    0.03557271f, -0.12602830f, -0.09754248f, -0.15189643f, -0.24845149f, 0.04743615f, -0.06114879f, -0.02636843f, 
    -0.74341416f, 0.17765635f, 0.14746344f, -0.25667182f, -0.24758145f, -0.42405707f, -0.37489799f, -0.26946050f, 
    0.14509095f, -0.07841621f, -0.00304812f, 0.17753749f, -0.52035683f, -0.21533987f, -0.06173810f, -0.28072131f, 
    -0.16927961f, -0.21140610f, -0.02085898f, -0.71770501f, -0.05604316f, 0.04086483f, -0.12317307f, -0.07179929f, 
    0.41442317f, -0.46802098f, -0.17049928f, -0.40167478f, 0.04765486f, -0.40688393f, 0.04072678f, -0.05376852f, 
    0.23249185f, -1.03059816f, 0.08191022f, -0.04570664f, 0.04981197f, -0.09172381f, 0.04546585f, -0.21238440f, 
    0.18102008f, -0.21178812f, -0.02275717f, -0.46778676f, 0.17922904f, 0.26896995f, -0.15731370f, 0.08230958f, 
    -0.55323195f, 0.12073597f, -0.00076167f, -0.79572642f, 0.15150338f, -0.01120368f, -0.28344005f, 0.25307891f, 
    -0.07668199f, 0.01673739f, -0.21998931f, -0.43250033f, 0.45283863f, -0.51096368f, 0.01129667f, -0.00175296f, 
    -0.45738325f, 0.04646261f, -0.51614702f, -0.32019728f, 0.07277841f, 0.10997000f, -0.01222339f, -0.03548786f, 
    0.02438936f, -0.14222726f, 0.10756605f, -0.41481453f, 0.04644492f, 0.23392296f, -0.19225878f, -0.16149725f, 
    0.21163163f, -0.09506828f, 0.03724198f, -0.06041323f, 0.17147060f, -0.04455686f, 0.05752257f, -0.11613895f, 
    0.10718518f, -0.55445844f, -0.02797503f, -0.01989201f, -0.08659608f, 0.00562174f, 0.27404648f, -0.02858113f, 
    -0.03086455f, -0.21932352f, -0.08842571f, 0.21281657f, 0.05533019f, 0.02679938f, -0.52493089f, -0.05240095f, 
    0.06186997f, -0.23306642f, -0.01721970f, 0.01756052f, -0.04419194f, 0.16480191f, -0.04813925f, 0.15909253f, 
    0.07503454f, 0.62328279f, -0.01149773f, -0.02642100f, 0.18900776f, -0.00702045f, -0.09036436f, 0.05462041f, 
    -0.17928618f, 0.02509207f, 0.05609284f, -0.04820057f, 0.12319230f, -0.13912953f, -0.03905811f, -0.04908592f, 
    0.29424503f, 0.04991456f, 0.10900629f, 0.23378541f, 0.11314417f, -0.31264478f, 0.29555371f, -0.30430147f, 
    -0.04279635f, 0.01551389f, 0.00209770f, -0.13974950f, -0.25892636f, -0.24785435f, 0.00180963f, -0.34966630f, 
    0.14200789f, -0.02233224f, -0.35472631f, -0.09963506f, -0.12323132f, 0.00493292f, 0.07759231f, 0.13042808f, 
    -0.02771088f, -0.19887201f, -0.20857947f, 0.10526277f, -0.61185509f, -0.18940878f, 0.14581530f, -0.01489396f, 
    -0.31383073f, -0.49831653f, 0.03719005f, 0.19953594f, -0.02089624f, -0.04553139f, -0.40551195f, 0.09642556f, 
    0.09611167f, 0.13837136f, 0.24843104f, -0.17826904f, 0.40389317f, -0.70388955f, -0.18684445f, -0.02611851f, 
    -0.31968814f, -0.08874685f, -0.10762624f, 0.00501495f, 0.15512955f, -0.03945615f, 0.19957985f, -0.36053383f, 
    -0.06319907f, -0.03394639f, -0.19556971f, -0.32229394f, -0.84973079f, -0.12046279f, 0.05685434f, 0.07398840f, 
    -0.71446419f, -0.23729792f, 0.31598514f, -0.05123018f, -0.39310098f, -0.05797170f, 0.03079983f, -0.18804626f, 
    -0.23199202f, 0.02108805f, -0.00349267f, -0.32098442f, 0.07175916f, -0.18344986f, 0.11472847f, -0.10876249f, 
    -0.08778618f, 0.04730080f, -0.15393612f, -0.05050042f, -0.34723067f, 0.06714831f, 0.00024522f, 0.08052993f, 
    0.05933812f, 0.08933104f, -0.02673234f, 0.06923067f, -0.06731047f, -0.02356698f, 0.01312016f, -0.07324234f, 
    0.14239463f, 0.11942198f, -0.14541572f, -0.66553450f, -0.38207054f, -0.00741984f, -0.28513849f, -0.02301106f, 
    -0.51305306f, -0.75755537f, 0.03178895f, 0.19062282f, -0.09279850f, 0.10850155f, 0.08861201f, -0.26568410f, 
    -0.10004904f, -0.14824350f, 0.23022707f, -0.03113608f, -0.38175163f, 0.04055311f, -0.20121740f, -0.23532154f, 
    0.14177260f, -0.15029559f, -0.11288596f, -0.00570263f, -0.37513497f, 0.12898473f, 0.02028654f, 0.09247513f, 
    -0.03644085f, 0.07749089f, -0.20068595f, 0.07784323f, -0.00356243f, -0.06236813f, 0.17938484f, -0.14459601f, 
    0.16111140f, 0.06780221f, -0.00997351f, 0.03120157f, 0.63239247f, -0.73247516f, 0.05904559f, 0.29364339f, 
    -0.18165830f, 0.34587693f, -0.03833899f, -0.25565168f, -0.21753119f, -0.24567713f, 0.04816734f, 0.06749279f, 
    -0.22834398f, 0.31046900f, 0.13068330f, 0.29797271f, 0.02021505f, 0.14381684f, -0.03838257f, -0.14126843f, 
    0.14359455f, -0.17684503f, -0.29068509f, 0.05529701f, 0.01222279f, -0.05025237f, 0.03948146f, 0.11023865f, 
    -0.14319415f, 0.29947719f, 0.01398264f, -0.01083656f, -0.22399299f, 0.01008165f, -0.16263792f, 0.07600979f, 
    -0.13633995f, -0.10612821f, -0.16890632f, 0.20800146f, 0.04566091f, -0.08936028f, 0.40915215f, -0.03379387f, 
    0.07997195f, -0.07612540f, -0.47843766f, -0.10343488f, 0.02795540f, -0.56483066f, -0.13928112f, -0.04495134f, 
    -0.59389049f, 0.03008202f, -0.00751744f, 0.03649789f, -0.23985846f, -0.07604155f, 0.07432257f, -0.02693222f, 
    0.05280534f, 0.03193567f, 0.13534559f, -0.41916248f, 0.07052332f, 0.06074671f, -0.06626000f, 0.14101866f, 
    -0.01188514f, -0.34570491f, 0.11588498f, 0.05359893f, 0.18016364f, 0.14246817f, -0.05781386f, 0.26357061f, 
    -0.35873467f, -0.37327495f, 0.13061945f, -0.00987386f, -0.39339560f, 0.22241305f, -0.42799106f, -0.05261629f, 
    -0.25276899f, 0.09775446f, -0.01021144f, 0.14715359f, 0.22929062f, 0.19792165f, -0.14032081f, -0.35085392f, 
    -0.13777879f, 0.17759584f, 0.08373592f, -0.36575621f, -0.17741077f, -0.00580012f, -0.49357703f, 0.07638513f, 
    0.09234505f, 0.04245227f, -0.02173307f, -0.04775012f, 0.27957153f, 0.07366850f, 0.21632308f, 0.23875497f, 
    -0.28844550f, 0.02747250f, -0.19253188f, -0.43596277f, 0.14308055f, 0.05290536f, -0.16406256f, 0.00336772f, 
    0.00115770f, -0.04570178f, 0.18258072f, -0.14827387f, -0.28234646f, 0.21208988f, -0.03496053f, -0.37363255f, 
    0.06002505f, 0.01587182f, -0.08332575f, -0.29807240f, -0.16775094f, -0.04107990f, 0.08614194f, -0.43837538f, 
    -0.06030102f, 0.20707475f, -0.15829673f, -0.10103536f, 0.14886223f, -0.06821029f, 0.32799760f, -0.03667323f, 
    0.16710539f, -0.27859247f, -0.23541497f, -0.28408548f, 0.18468067f, 0.10762472f, 0.16440259f, -0.73357266f, 
    0.17238906f, -0.00244831f, 0.12741102f, -0.11799586f, -0.00924634f, -0.08776216f, -0.12517391f, 0.10543535f, 
    0.04621247f, -0.33352304f, -0.32671985f, 0.06822221f, -0.12748457f, 0.26090339f, -0.66960776f, -0.05758249f, 
    -0.32482904f, -0.10103670f, 0.01770424f, -0.11652888f, -0.01157725f, 0.01440951f, -0.29135519f, -0.36468396f, 
    -0.39092791f, -0.06237297f, 0.11261179f, -0.08065698f, -0.44308692f, 0.13676161f, -0.00896776f, -0.07300499f, 
    -0.14630538f, 0.07744630f, -0.11518388f, 0.17040639f, 0.23468569f, 0.06719686f, 0.07961721f, -0.09443621f, 
    -0.04997290f, -0.06164651f, -0.13482778f, -0.21200183f, -0.05746925f, -0.29526180f, -0.00257471f, -0.19688267f, 
    0.05975755f, -0.09000631f, -0.01215036f, -0.00279748f, 0.15767811f, 0.08892695f, -0.02545663f, -0.27497774f, 
    0.28864896f, 0.12222833f, 0.13152137f, -0.00899337f, -0.05684667f, -0.21947272f, 0.00628796f, -0.52537519f, 
    -0.25948390f, 0.07505722f, 0.38283858f, -0.21056752f, -0.18691634f, -0.14398393f, 0.23923934f, 0.00801614f, 
    0.36595792f, -0.56659818f, -0.03705944f, 0.01578396f, -0.24633458f, 0.04494260f, 0.01415707f, -0.04667369f, 
    -0.31219098f, 0.11678936f, -0.13430171f, -0.03623088f, -0.54097301f, -0.00408354f, -0.33225244f, -0.03394950f, 
    0.17156862f, -0.00522817f, -0.16449690f, 0.29644975f, 0.21618930f, 0.02070466f, -0.39563575f, 0.04762964f, 
    0.09606476f, -0.29366392f, -0.36745483f, -0.42443630f, -0.05101432f, -0.39044356f, 0.31542447f, -0.18821633f, 
    -0.40435058f, -0.06260712f, 0.02606479f, 0.04328893f, -0.00944508f, 0.26494294f, -0.04525375f, -0.15371907f, 
    0.22431596f, 0.29211542f, -0.22808892f, -0.22108974f, -0.05596218f, 0.41590530f, -0.02485597f, -0.53207684f, 
    -0.45433140f, 0.22710876f, -0.51408607f, 0.15043105f, 0.09184559f, 0.03448752f, -0.41711828f, -0.12385453f, 
    -0.02141178f, 0.04095426f, -0.32797140f, 0.19002049f, -0.12785639f, 0.05297156f, -0.40483004f, 0.11403105f, 
    -0.35073644f, 0.07644764f, 0.08067781f, 0.03258161f, -0.31221172f, -0.22155249f, -0.10260064f, -0.04772837f, 
    -0.30543908f, 0.23517860f, -0.11096462f, 0.10946579f, -0.12363309f, -0.04684417f, 0.07119466f, -0.11104447f, 
    -0.23177665f, 0.00577593f, 0.12833276f, -0.26360339f, 0.08354284f, -0.24493915f, 0.14302161f, -0.05363551f, 
    0.22028115f, -0.21060088f, -0.42305639f, 0.10099749f, -0.31950855f, -0.07059946f, 0.01394258f, -0.08811085f, 
    0.18931493f, -0.26617423f, 0.11106749f, -0.02824699f, 0.01509040f, 0.03538341f, 0.22575431f, -0.07286922f, 
    -0.29278517f, -0.00031012f, 0.06191550f, -0.39092094f, 0.14973088f, -0.06740335f, -0.04915087f, -0.03416220f, 
    0.30218905f, -0.13308793f, 0.00695106f, -0.10956281f, -0.09782028f, 0.14715023f, -0.37495261f, 0.12629844f, 
    0.03381086f, 0.14642096f, -0.25648525f, 0.05326682f, -0.02927983f, 0.43135852f, 0.00221021f, 0.02971908f, 
    0.23572408f, -0.27862582f, -0.00149804f, 0.27608997f, -0.10241842f, 0.00129083f, 0.01122625f, -0.33060339f, 
    -0.44640315f, -0.09579982f, 0.02991059f, 0.02007130f, 0.04641745f, 0.00207829f, 0.01342759f, 0.06882382f, 
    -0.16051035f, -0.01263274f, 0.04117297f, -0.16919512f, -0.04788208f, -0.00676445f, -0.02492488f, -0.08716235f, 
    0.03550237f, -0.27106404f, -0.10854670f, -0.01759633f, 0.14807297f, -0.38858497f, -0.00450594f, -0.36714506f, 
    -0.08328277f, -0.05502835f, 0.07569044f, 0.35473099f, -0.55926943f, -0.30574942f, -0.05969357f, -0.50216478f, 
    -0.01807353f, 0.08443262f, 0.42808878f, 0.10293546f, -0.22089134f, -0.18242948f, -0.12548776f, 0.00090317f, 
    -0.10893982f, -0.16415441f, -0.09446209f, 0.20510031f, -0.12363529f, -0.20596677f, -0.37227517f, -0.60804790f, 
    -0.12842935f, 0.14106396f, -0.12768434f, 0.07805103f, 0.05675493f, -0.08213052f, 0.22023152f, -0.04470374f, 
    0.02974232f, -0.10411406f, -0.37789708f, -0.02668806f, 0.32479003f, 0.24382539f, -0.40264848f, 0.07436360f, 
    -0.53654182f, -0.34463534f, -0.14662844f, 0.04036421f, 0.13756286f, -0.06310312f, -0.18804780f, -0.09584083f, 
    -0.26721534f, 0.05379009f, -0.05047131f, -0.37223077f, 0.00124391f, 0.05973931f, -0.10081152f, -0.07136223f, 
    -0.16780801f, -0.19694015f, -0.47669339f, 0.19036283f, -0.24796833f, 0.27279130f, -0.07740899f, 0.38748902f, 
    -0.23935279f, -0.04053426f, 0.13134378f, -0.32055745f, -0.03600300f, 0.19689466f, -0.14142501f, 0.19905920f, 
    -0.07058021f, -0.19599639f, 0.06998682f, -0.05755588f, -0.28334862f, 0.17844748f, -0.03204007f, -0.19128931f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.17025805f, 0.11319103f, -0.01890411f, 0.04134832f, -0.07251178f, -0.11224378f, -0.05629053f, -0.11997492f, 
    0.03486955f, 0.22339344f, 0.00314536f, -0.17567284f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
