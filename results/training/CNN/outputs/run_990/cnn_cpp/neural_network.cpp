#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.30978739f, -0.70549512f, -0.88062614f, -0.04386393f, 0.89442718f, -0.13091080f, -0.18851146f, 1.27745998f, 
    -0.33447716f, -0.16604190f, -0.48915163f, 0.15915376f, -0.28793073f, -0.26037139f, -0.22213316f, 0.59214145f, 
    0.20511039f, 0.13870814f, 0.12532042f, -0.29306474f, -0.22375812f, 0.14269793f, -0.29911527f, -0.55100656f, 
    -0.12733778f, -0.19790117f, -0.68529278f, -0.64285988f, -0.55265170f, -0.79167885f, -1.26200736f, -0.88505059f, 
    -0.90375805f, -0.80388159f, -1.65293837f, 0.68820411f, -0.23747277f, 0.21413171f, 0.51756507f, -0.01078938f, 
    -0.31362331f, -0.27095765f, 0.10645221f, -0.39572254f, -0.49346638f, -0.27810478f, 0.04740382f, 0.12552086f, 
    0.16023596f, -0.00053244f, 0.57497030f, 0.07352643f, 0.29249871f, 0.16140409f, -0.03424411f, 0.15470627f, 
    0.48753306f, 0.67023808f, -0.18693326f, -0.31624353f, -0.35550147f, -0.10825336f, 0.89595658f, -0.51947343f, 
    -0.51290667f, -0.31210685f, -0.14985034f, -0.19455874f, -0.10862181f, -0.13607177f, 0.03851933f, 0.05136032f, 
    -0.44133836f, -0.11950412f, 0.42528868f, -0.07436246f, 1.13485122f, 0.31417081f, -0.33982694f, 0.06727078f, 
    -0.92382467f, -0.64052969f, -0.49175814f, -0.68498719f, -0.77819645f, 0.21679220f, 0.37877074f, -0.01228664f, 
    -0.05834849f, 0.26850575f, 0.50074089f, 0.34989157f, -0.12546684f, 0.21892744f, -0.21318780f, -0.06097311f, 
    0.31883293f, -0.04374444f, 0.04783256f, 0.14114520f, 0.15470104f, 1.05566502f, 0.96608162f, -0.50483108f, 
    -0.38125867f, -1.07485127f, -0.52619272f, 0.03029790f, 0.61443502f, 0.12520009f, -0.31610236f, -0.22139502f, 
    -0.29660404f, 0.33693171f, 0.23516507f, -0.07708285f, 0.46226239f, 0.26617026f, -0.41458982f, 0.03081891f, 
    0.01860504f, -0.22897215f, -0.59616458f, -0.77189404f, -0.29850331f, -0.61172628f, -0.04046977f, -0.08066371f, 
    0.19479792f, 0.24719526f, 0.57030541f, 0.01861270f, -0.14217634f, 0.37589243f, -0.12850673f, -0.09287760f, 
    -0.11919095f, -0.06355453f, 0.07741276f, -0.27317894f, 0.01592840f, -0.06065004f, 0.05618772f, -0.36856878f, 
    -0.63513792f, 0.08127270f, 0.35659739f, 0.52342308f, 0.50938201f, 0.51657504f, -1.00371265f, -0.08251602f, 
    0.35570419f, -1.32493603f, -0.55233949f, -0.30030906f, -0.17258336f, -0.64287525f, 0.11375749f, 0.78375292f, 
    -0.36396611f, -0.40209556f, -0.93754148f, -1.35791290f, 0.67180902f, 0.27007121f, 0.23946865f, -0.13875836f, 
    0.27384996f, 0.40356877f, -0.00488695f, -0.07921946f, 0.09456182f, 0.11954941f, 0.11698283f, -0.93175733f, 
    -0.19540940f, 0.30212986f, -0.17233130f, -0.12309202f, -0.71676904f, -0.42420384f, -0.09700015f, -0.05928100f, 
    0.29205793f, 0.11161437f, -0.24697876f, -0.26603845f, -0.20805581f, -0.35841119f, 0.12833431f, -0.51372641f, 
    -0.67247140f, -0.62589669f, -0.63017696f, -0.64364481f, -0.55958998f, -0.47714829f, -0.58881730f, -0.29872474f, 
    0.96033043f, -0.49701026f, -1.33141673f, -1.05884016f, -0.34590352f, 0.68724507f, 0.27666277f, 0.51982808f, 
    0.44036299f, 0.58468801f, -0.11862331f, 0.09977853f, -0.12576191f, -0.13230839f, 0.10745589f, 0.16839232f, 
    -0.46276391f, 0.25811884f, 0.22952221f, -0.40589803f, -0.20497854f, -0.06054780f, 0.00107088f, 0.15730424f, 
    0.51151794f, -1.62015915f, -1.20083332f, 0.24199529f, 0.63085914f, 1.14913154f, -0.49832034f, 0.08796491f, 
    -0.28291622f, 0.47086757f, 0.71588176f, 0.02181937f, 0.41449291f, -0.08352484f, 0.23464137f, -0.53034067f, 
    -0.25217676f, 0.17593096f, 0.27400067f, -0.27242446f, 0.05215035f, -0.09634142f, 0.01742044f, -0.02446467f, 
    -0.10906128f, 0.18565193f, 0.28276351f, 0.65546566f, 0.24100411f, -0.32464814f, -0.21799371f, -0.46037665f, 
    -0.16429333f, 0.34613925f, 0.21197279f, -0.10225947f, -0.08630898f, 0.15997699f, -0.41191420f, 1.27675724f, 
    -0.34739739f, 0.42096895f, -0.16974127f, -0.43390200f, 0.18320215f, -0.34694985f, 0.10765557f, -0.06605279f, 
    0.06243850f, 0.33010557f, 0.28702715f, 1.07492828f, 0.69599211f, 0.25584871f, -0.27784896f, -0.01278369f, 
    -0.68441176f, 0.26063040f, 0.27530316f, 0.06179591f, -0.40506476f, -0.49811700f, 0.26392794f, -0.28037933f, 
    -0.33972397f, 0.03007120f, 0.39112070f, -0.26768669f, 0.33055186f, -0.36101758f, -0.30886960f, -0.23086254f, 
    0.30517951f, -0.08766508f, 0.20865528f, -0.35749060f, 0.15220593f, 0.54385620f, -0.37984911f, 0.40574992f, 
    0.32759026f, -0.15887134f, -1.25352800f, -0.26502717f, 0.91862863f, 0.54506814f, -0.35183498f, -0.02572259f, 
    -0.00411588f, -0.45185959f, -0.52006519f, -0.14624898f, -0.17392960f, 0.26212168f, 0.09363696f, -0.37205333f, 
    -0.36961031f, 0.20701820f, -0.02317238f, 0.06379188f, 0.03918438f, 0.05414537f, 0.18149519f, 0.58520871f, 
    0.45164657f, 0.25138515f, 0.75972724f, 1.07109261f, 0.47285554f, 0.09331309f, -0.45547482f, -0.22573471f, 
    -0.09461629f, 0.06517053f, -0.07716922f, -0.01369217f, 0.20626327f, -0.47072926f, -0.48206183f, 0.18558045f, 
    -0.04027277f, -0.08775489f, 0.09305831f, 0.13542607f, 0.00690677f, -0.25671831f, -1.72146869f, 0.40948865f, 
    -0.67734259f, -1.24510801f, -0.50902641f, 0.68163741f, 0.37967068f, 0.41897383f, 0.58958477f, 0.34138587f, 
    0.33099970f, 0.21783856f, -0.03293647f, 0.08195546f, -0.22315116f, 0.00690854f, -0.16780823f, -0.24808413f, 
    -0.10761439f, -0.30527771f, -0.16712095f, 0.04855141f, -0.17034052f, -0.25751442f, -0.45947286f, -1.89655793f, 
    -1.28919315f, -0.93240774f, -0.70321703f, -0.86143571f, 1.28917682f, 0.57098722f, -1.23571181f, -1.05740201f, 
    0.26591957f, -0.30378973f, -0.32477212f, 0.00424210f, -0.43215090f, -0.28936693f, 0.19323353f, -0.00631245f, 
    -0.23471642f, -0.16405757f, -0.00887367f, -0.10982043f, -0.13399644f, -0.07515088f, -0.03708378f, -0.17380238f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02982459f, -0.10674912f, 0.32483235f, 0.63464981f, 0.18048482f, 0.06508219f, 0.06074992f, 0.16451077f, 
    0.54981279f, 0.70736349f, 0.69636774f, 0.65914643f, 0.79927671f, -0.08515958f, 0.07390459f, -0.33638418f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19555821f, 0.09201549f, 0.06088981f, -0.14515585f, 0.10115465f, 0.19318751f, 0.14659101f, -0.05253579f, 
    -0.01466842f, 0.03009249f, -0.08463110f, 0.06113411f, 0.56615686f, 0.33338225f, -0.21399240f, -0.34755173f, 
    0.26611540f, 0.05290630f, -0.06893823f, 0.13674015f, -0.06163104f, -0.12076880f, -0.07129315f, -0.04939262f, 
    -0.29893705f, -0.11741421f, -0.35189530f, 0.04332515f, 0.15087922f, -0.03596730f, 0.01612410f, 0.04226198f, 
    0.03275040f, 0.01507150f, 0.00099301f, 0.07941417f, 0.00591721f, 0.31362045f, -0.35732436f, -0.06777275f, 
    -0.32248527f, -0.04296691f, -0.26026288f, -0.02110129f, -0.02580386f, 0.21121636f, -0.00564718f, -0.03176840f, 
    -0.45973501f, -0.18873894f, 0.31829280f, 0.10140250f, 0.06674695f, 0.13915265f, -0.18231994f, 0.00662876f, 
    0.12239692f, -0.12337071f, -0.24130139f, -0.07793785f, -0.09326632f, 0.05454912f, 0.14963710f, -0.02923719f, 
    0.04659948f, -0.01150110f, 0.02710768f, 0.01284593f, -0.11278286f, -0.10131286f, -0.00719065f, 0.03236394f, 
    0.00539351f, 0.55241233f, 0.00562716f, -0.25041559f, 0.11134679f, 0.26874822f, -0.05571361f, 0.10385356f, 
    0.00324149f, 0.09065720f, 0.08097441f, -0.14639054f, 0.26248735f, 0.31552351f, 0.18197225f, -0.22546235f, 
    -0.14243278f, -0.16439746f, -0.29028413f, -0.05131606f, -0.30013001f, -0.15361646f, 0.04523218f, 0.01299317f, 
    -0.69583255f, -0.38947424f, -0.53661340f, 0.07110507f, 0.04348039f, -0.03270317f, -0.09379804f, -0.12513630f, 
    -0.10248092f, -0.29012644f, -0.14246041f, -0.12536748f, 0.29938254f, 0.57994431f, 0.43318668f, -0.60436517f, 
    -0.15326750f, 0.00852674f, 0.16474764f, -0.16263051f, -0.16002876f, -0.13284548f, -0.34071499f, -0.26049596f, 
    -0.22829877f, -0.12986766f, 0.04310487f, 0.02873096f, -0.12882675f, -0.13467239f, -0.11607830f, -0.05291463f, 
    -0.18187387f, -0.04979111f, -0.53321153f, -0.16939917f, -0.84335130f, -0.74177057f, -0.39427403f, 0.15945558f, 
    -0.09855215f, -0.07607216f, -0.02735741f, 0.03553467f, -0.00665490f, -0.03541789f, -0.05939499f, -0.10975514f, 
    -1.34195936f, 0.10476787f, -0.18363504f, -0.15902604f, 0.08445598f, -0.00278231f, 0.08039080f, 0.04970951f, 
    -0.03291686f, -0.05605599f, 0.01588843f, -0.02898862f, -0.15782732f, -0.27504668f, -0.61226070f, -0.11089624f, 
    0.03675501f, 0.03139406f, 0.15101266f, 0.04190421f, -0.03656743f, 0.03000543f, 0.04206007f, 0.20464358f, 
    -0.09438585f, -0.34069085f, -0.14098257f, -0.01947998f, 0.06294167f, 0.31876957f, 0.01130966f, 0.14351936f, 
    -0.02157789f, 0.08842702f, -0.19860606f, 0.03370058f, 0.65755624f, 0.41240546f, -0.30513996f, -0.21013775f, 
    0.14254940f, 0.29217485f, 0.19054528f, 0.09609395f, -0.07594599f, -0.01672281f, -0.04138945f, -0.02293264f, 
    -0.76023698f, -0.07989027f, -0.23908018f, 0.35496867f, -0.13500239f, -0.17575605f, -0.17858823f, -0.36352015f, 
    0.13702841f, -0.09412275f, -0.37252048f, 0.02694160f, -0.38866946f, 0.09537532f, 0.19169173f, -0.13371536f, 
    -0.15586048f, -0.10415803f, 0.19069523f, 0.10738012f, -0.01522390f, -0.01635284f, 0.07487240f, 0.04856244f, 
    0.83816719f, 0.02732747f, 0.38799503f, 0.00145019f, -0.06776520f, -0.01843492f, 0.00701238f, 0.00017171f, 
    0.11027040f, -0.11190038f, -0.14077689f, 0.21373101f, 0.06542090f, -0.11292987f, -0.13455775f, -0.21739221f, 
    -0.28164670f, -0.15490162f, -0.33514860f, -0.05370507f, -0.14680369f, 0.06450883f, 0.04605962f, 0.21798968f, 
    -0.10418110f, -0.10516232f, 0.27343944f, -0.19204532f, 0.03863613f, -0.17871112f, -0.31971082f, 0.15737507f, 
    0.16969737f, 0.12156875f, -0.04749621f, -0.00308315f, -0.17577009f, 0.03068547f, -0.02890484f, -0.01283106f, 
    0.06474490f, -0.01625191f, 0.18656319f, 0.02306699f, 0.00307357f, 0.01254362f, -0.01579562f, -0.02175261f, 
    0.30343878f, 0.32592234f, 0.03779202f, -0.30237207f, 0.06834354f, 0.22136424f, -0.26635364f, -0.11051980f, 
    -0.02060574f, -0.02096586f, -0.20669390f, -0.13607293f, 0.02489700f, 0.08731646f, 0.03073227f, -0.15741961f, 
    0.22806686f, 0.14319041f, -0.00206027f, 0.14723000f, -0.10174840f, -0.13434243f, -0.38320023f, -0.30337390f, 
    0.75282246f, 0.10971178f, -0.25400847f, -0.27908456f, -0.03282065f, 0.16586299f, 0.10771663f, -0.21629907f, 
    0.08969934f, 0.13651583f, -0.06709905f, -0.05243458f, -0.22702356f, 0.00780028f, -0.25773826f, -0.07743119f, 
    -0.26248002f, 0.10099094f, 0.08509846f, 0.05116523f, -0.07373580f, -0.11051831f, -0.06236768f, 0.18981986f, 
    0.18522973f, -0.15573454f, 0.01886077f, 0.04158671f, -0.02661798f, 0.06715033f, 0.11833816f, 0.00145460f, 
    0.15429015f, -0.27758136f, -0.01020715f, 0.07079802f, 0.60010219f, 0.09363676f, 0.71867758f, -0.11820213f, 
    -0.06694100f, -0.07704659f, 0.09641812f, -0.10110816f, -0.15409479f, 0.15775929f, -0.04298795f, 0.07054143f, 
    -0.59648305f, 0.35536915f, 0.20964003f, -0.02073053f, 0.02779225f, -0.05129328f, 0.02902921f, -0.05587035f, 
    -0.10596719f, 0.01261010f, 0.08055133f, 0.10734583f, 0.32168832f, -0.17312580f, 0.10534471f, 0.28052014f, 
    -0.18481027f, -0.11130232f, 0.11745984f, -0.03022086f, -0.03908246f, -0.02684099f, 0.26206759f, -0.08759785f, 
    -0.57820427f, -0.20949478f, -0.30498910f, -0.32667062f, 0.03307683f, 0.02580626f, -0.20995745f, -0.02311759f, 
    -0.14917877f, -0.10103472f, -0.06544592f, 0.07305493f, 0.76967263f, 0.24784307f, 0.33734965f, 0.07516874f, 
    -0.07374934f, 0.07965817f, -0.01168603f, -0.07631548f, 0.11093735f, -0.04089876f, -0.07803810f, -0.10665963f, 
    -0.28448567f, -0.01438639f, -0.13717410f, 0.12143662f, 0.22127914f, -0.20496091f, 0.09802521f, 0.05788530f, 
    0.08647143f, 0.00254369f, 0.10146976f, -0.02256644f, -1.49376106f, -0.55651265f, -0.33818591f, -0.82186824f, 
    0.00617503f, 0.10733866f, -0.01812112f, -0.20788021f, -0.05330317f, -0.08203042f, -0.00837325f, -0.04916664f, 
    -0.01352599f, 0.03108009f, -0.61706787f, -0.02585217f, -0.10552584f, -0.00675163f, 0.03185094f, 0.10224402f, 
    0.02576724f, -0.10515713f, 0.24342830f, -0.50708038f, -0.34816062f, -0.47725117f, 0.00405923f, -0.21469070f, 
    0.25272295f, -0.18617325f, -0.25446984f, -0.09745361f, 0.10858771f, -0.12795281f, -0.06838030f, 0.01354994f, 
    -0.10786895f, -0.16268218f, 0.08446708f, -0.04872012f, 0.08388904f, -0.04079610f, -0.24785210f, -0.09514596f, 
    0.05065079f, -0.10762589f, -0.26768667f, 0.08246171f, -0.08682980f, -0.15481597f, -0.09578980f, -0.12384874f, 
    -0.01434145f, -0.05280458f, 0.00865470f, -0.04406673f, -0.07335965f, -0.04400838f, -0.01271475f, -0.09403906f, 
    -0.04467275f, -0.37695500f, 0.10732313f, 0.55170304f, 0.05907558f, 0.07580763f, -0.28739160f, -0.01277701f, 
    -0.12182374f, 0.10167520f, -0.07009280f, 0.03103028f, 0.03531730f, 0.07500632f, -0.14810145f, -0.08563192f, 
    -0.03699306f, 0.00005986f, -0.13205972f, -0.04440745f, -0.14066035f, 0.10335197f, -0.06229808f, 0.16359121f, 
    -0.34785071f, 0.76308709f, 0.39123878f, 0.07640017f, -0.06588558f, 0.13754696f, 0.07890353f, -0.11343836f, 
    0.00889036f, 0.18832958f, -0.12029918f, -0.06267803f, 0.34551683f, -0.19754130f, -0.32857424f, 0.28846064f, 
    0.03970421f, 0.15821242f, -0.06046300f, 0.22123399f, 0.12796438f, 0.00854265f, -0.13617533f, 0.23306231f, 
    -0.07760634f, -0.20400546f, -0.06352616f, 0.16916645f, -0.23223339f, 0.06117598f, 0.06291074f, 0.10100865f, 
    0.04604510f, -0.28072143f, 0.04694312f, 0.09767389f, 0.09835926f, -0.29787254f, 0.24896035f, 0.08702008f, 
    -0.07393419f, 0.02505138f, 0.03751275f, 0.07017497f, 0.11873782f, 0.06759997f, -0.09385860f, 0.16079229f, 
    -0.28356099f, -0.18840176f, 0.54919732f, 0.00505165f, -0.12191191f, 0.01435626f, -0.00595497f, 0.11484534f, 
    0.02992689f, 0.01236604f, 0.16127920f, -0.09222691f, -0.02622464f, -0.18214549f, -1.05283010f, 0.02446072f, 
    -0.00991553f, -0.07501313f, 0.02867965f, -0.00567134f, -0.03604347f, 0.03101867f, 0.14837137f, 0.17242157f, 
    0.42113918f, 0.90898609f, 0.25215951f, 0.39749151f, -0.06235632f, -0.12054034f, 0.05246392f, -0.16768441f, 
    -0.04008765f, -0.15421681f, -0.08689851f, 0.20598476f, -0.30661282f, -0.28656694f, 0.99764085f, 0.78406018f, 
    -0.11900710f, -0.02072109f, 0.02711149f, 0.14597058f, 0.04323988f, -0.01840297f, 0.08461960f, -0.00646646f, 
    0.46921399f, 0.24569988f, -0.54314423f, 0.05431205f, 0.29137084f, -0.08121316f, 0.10294353f, 0.04975664f, 
    -0.14989729f, -0.07473456f, -0.11242748f, 0.21616128f, 0.04560453f, -0.31531435f, -0.01851459f, 0.39904329f, 
    0.06002503f, 0.20212032f, 0.09519698f, 0.25016055f, 0.00684132f, -0.00971254f, 0.08805842f, -0.09226529f, 
    -0.29086804f, 0.61177081f, -0.21807624f, -0.13729864f, 0.21606971f, -0.08466332f, -0.27922237f, -0.00738011f, 
    0.16161789f, 0.23404181f, 0.12005072f, -0.11206625f, -0.00250491f, -0.14409591f, 0.34587148f, 0.08925790f, 
    -0.06486010f, 0.22350252f, 0.00374332f, 0.01969124f, 0.07990309f, -0.01263519f, -0.08103408f, -0.06115196f, 
    0.29290468f, -0.37569949f, 0.56188768f, -0.34498367f, -0.29341647f, 0.19899970f, -0.00106853f, -0.00874103f, 
    0.07834727f, -0.06619921f, -0.02512389f, 0.03626809f, 0.51593447f, -0.05456806f, -0.06241415f, 0.13497022f, 
    0.02250706f, -0.00444548f, -0.11514491f, -0.15758334f, -0.31220096f, 0.21508534f, -0.14202480f, 0.18606310f, 
    0.67439610f, -0.43186936f, -0.00613186f, 0.16016224f, -0.07187767f, -0.15923767f, -0.06969824f, -0.10849762f, 
    -0.00621948f, -0.08585813f, -0.13282564f, 0.14993925f, 0.10135401f, -0.13703606f, -0.10477425f, 0.09263005f, 
    -0.00280546f, 0.10036186f, -0.09319451f, -0.24260728f, -0.09470072f, 0.16918465f, 0.07232086f, 0.00167248f, 
    0.03960150f, -0.09554832f, -0.25390950f, 0.44073406f, 0.20589577f, -0.00744430f, 0.08974195f, 0.11742049f, 
    -0.05323182f, -0.03788579f, 0.41971013f, -0.00067677f, -0.37088469f, 0.15134656f, -0.60014206f, -1.02078795f, 
    0.18178712f, -0.08422243f, -0.09029780f, -0.03359626f, -0.16996150f, 0.18521358f, -0.18534274f, -0.03524857f, 
    -0.15118556f, -0.00059230f, 0.14478090f, -0.05557234f, -0.52360147f, -0.44059387f, -0.20062466f, -0.04283013f, 
    0.13159473f, -0.23452726f, 0.17643048f, -0.36993057f, -0.33899572f, -0.21214475f, 0.89168400f, -0.21538574f, 
    -0.37097651f, -0.26404417f, -0.19522278f, -0.34599453f, -0.15973468f, 0.18418458f, 0.19465189f, 0.15851335f, 
    -0.11220440f, -0.25635752f, 0.19083713f, -0.52908796f, -0.21957253f, -0.31559014f, -0.06220948f, -0.00912732f, 
    -0.11694285f, -0.06951679f, -0.09134126f, -0.02732286f, -0.81826007f, -0.04645082f, -0.07333566f, -0.05033180f, 
    0.20367141f, 0.18716465f, -0.31148469f, 0.29704481f, -0.13212970f, -0.39409551f, 0.10180052f, -0.25361732f, 
    1.10009313f, -0.58143193f, 0.00645737f, 0.40230528f, 0.24594325f, 0.16235957f, 0.01768833f, 0.03421655f, 
    -0.11957853f, 0.08879881f, -0.05528984f, 0.14533119f, -0.44934544f, -0.17922089f, -0.20381208f, 0.31591621f, 
    0.18825836f, 0.06183702f, -0.06169724f, -0.17408173f, -0.06402857f, 0.14506815f, 0.04507912f, 0.06859078f, 
    -0.32637727f, -0.45433134f, 0.26927423f, -0.20030709f, -0.41415763f, 0.21142894f, -0.28378031f, -0.04920594f, 
    0.02984114f, -0.03107239f, 0.10986210f, -0.14630197f, 0.17881344f, 0.44067493f, 0.39555717f, 0.23520906f, 
    -0.26770443f, -0.02057712f, 0.07621041f, 0.15466756f, 0.00602477f, -0.13599226f, 0.04466667f, -0.08689070f, 
    -0.44720358f, -0.75809062f, -0.20563754f, -0.18519616f, 0.03204887f, 0.00215752f, 0.10882420f, 0.02396375f, 
    -0.02243348f, -0.02117299f, -0.04367970f, -0.31313086f, 0.20605069f, 0.39579651f, 0.17313713f, 0.43068400f, 
    0.21547882f, 0.15266882f, 0.36337352f, 0.13213716f, 0.15887392f, -0.20693788f, -0.09773928f, -0.28792667f, 
    0.02882252f, 0.01147356f, -0.51776141f, 0.26872039f, -0.02545507f, -0.04147164f, -0.05202498f, -0.30039281f, 
    0.22987521f, -0.16878919f, 0.11307648f, 0.16276957f, 0.17262402f, 0.01880698f, 0.09297723f, 0.22000605f, 
    0.17017993f, 0.16737071f, 0.00223837f, 0.01628248f, -0.04080785f, -0.20186915f, -0.09617054f, -0.25248715f, 
    -0.37862515f, 0.15412351f, -0.22752939f, 0.13187355f, -0.04067882f, 0.00547328f, 0.12273230f, -0.33728620f, 
    -0.09060363f, 0.03149633f, 0.02545432f, 0.00868811f, 0.04798638f, 0.07125990f, -0.04603675f, 0.20439832f, 
    0.08874889f, -0.01420959f, 0.08107322f, -0.05980894f, 0.23382746f, 0.16437285f, 0.21521325f, 0.21463121f, 
    -0.61320710f, 0.12207127f, -0.36120272f, -0.01649874f, -0.03221053f, 0.02731545f, -0.05454703f, 0.14190587f, 
    -0.05603208f, -0.25057358f, 0.07202659f, 0.20286548f, -0.04268796f, -0.48588476f, -0.01901221f, 0.17959660f, 
    -0.26699209f, -0.20417069f, -0.05093573f, -0.19431035f, -0.30224243f, 0.02565639f, -0.15454701f, -0.12448487f, 
    -0.02684491f, -0.01431861f, -0.09714334f, 0.04009354f, 0.20199838f, 0.12128154f, -0.23988499f, 0.14483464f, 
    -0.22684409f, -0.01075922f, -0.38335234f, -0.19281617f, -0.35715300f, 0.23183495f, -1.10435152f, 0.04887653f, 
    0.13005592f, 0.01210871f, 0.00236492f, 0.03631715f, 0.23154101f, 0.07128975f, 0.02209820f, -0.06811893f, 
    0.08546812f, -0.38985321f, -0.38792059f, -0.05356590f, -0.04595987f, 0.00940031f, 0.00609576f, 0.06490658f, 
    -0.02831230f, -0.07646333f, 0.02605608f, -0.05882354f, 0.42963359f, 0.17080548f, 0.15777545f, -0.22756550f, 
    0.19422698f, 0.09177562f, 0.12727739f, 0.02439208f, 0.00866888f, -0.03897500f, -0.22167079f, 0.02701961f, 
    0.11286745f, 0.17249645f, 0.18835139f, 0.14654025f, 0.04092731f, -0.20822008f, -0.05747535f, 0.17536578f, 
    0.25782442f, -0.17870417f, 0.03384488f, 0.11549821f, 0.03898862f, -0.15661986f, -0.00591384f, 0.15517303f, 
    -0.10265785f, -0.07349745f, 0.03595746f, -0.16721483f, -0.03320801f, -0.14291775f, 0.08475824f, 0.05000542f, 
    -0.07522111f, 0.31234282f, 0.25234124f, -0.24630745f, 0.11549029f, -0.38965946f, 0.12327877f, -0.01433261f, 
    -0.18736853f, -0.17787732f, 0.28839427f, -0.00840533f, 0.26165226f, 0.28143650f, 0.13468257f, 0.01036641f, 
    0.20896354f, 0.29067299f, -0.10528968f, -0.39163437f, 0.02543426f, 0.01177111f, -0.00351272f, 0.04483343f, 
    -0.44569319f, -0.51766336f, -0.32651153f, 0.49765763f, -0.01068285f, -0.01793488f, -0.04561498f, -0.11301640f, 
    -0.02503182f, 0.12738635f, 0.15861836f, 0.34193492f, -0.04811474f, 0.15705329f, 0.02462764f, -0.03123054f, 
    0.37805942f, -0.05697906f, 0.12132913f, 0.15469937f, -0.03659460f, -0.03028483f, 0.16576937f, 0.14060026f, 
    -0.25089538f, -0.32817808f, -0.12373452f, 0.33044365f, 0.12109087f, 0.06253668f, -0.13908640f, -0.12227967f, 
    -0.09779252f, 0.09360586f, -0.13730395f, -0.35889134f, -0.30962843f, -0.15718991f, 0.06715742f, -0.32606322f, 
    -0.09749595f, -0.03340640f, -0.12590908f, -0.20320010f, 0.12706693f, -0.06975300f, 0.11305492f, 0.27028048f, 
    -0.37028304f, 0.13682289f, 0.27290496f, 0.13331527f, 0.15688741f, -0.14952537f, -0.02059346f, 0.36213484f, 
    -0.00849843f, -0.04115351f, 0.14826687f, 0.21101627f, -0.10475867f, 0.06228561f, 0.29949564f, 0.18745309f, 
    -0.10486305f, 0.03929860f, 0.00336639f, 0.02918803f, 0.30907127f, -0.26892361f, -0.52434617f, -0.08078337f, 
    -0.11791956f, -0.75561190f, 0.06981641f, -0.39103487f, 0.06023559f, -0.12918422f, -0.16173981f, 0.11527680f, 
    0.30252039f, -0.18877843f, -0.20127502f, 0.13449024f, -0.04639994f, -0.60621852f, 0.72352898f, 0.30300477f, 
    -0.08347081f, -0.07105828f, 0.07032392f, 0.20949218f, 0.21185859f, -0.09942522f, 0.22330227f, -0.11035099f, 
    -0.30138001f, 0.13446733f, -0.09616369f, -0.08540212f, 0.05176097f, -0.04331474f, -0.09840578f, -0.19702570f, 
    0.02161073f, 0.41697487f, 0.01425855f, 0.17762093f, -0.15255001f, -0.17323028f, -0.60798341f, 0.20901707f, 
    0.14429638f, 0.19170599f, -0.01710589f, 0.13821013f, 0.09591323f, -0.19540504f, 0.01122971f, -0.08715242f, 
    0.24561177f, -0.06997840f, 0.06280562f, 0.15709707f, 0.03396068f, 0.02959986f, -0.10668602f, 0.07617424f, 
    0.15579741f, -0.03121567f, 0.06129354f, 0.08422258f, -0.03462266f, -0.14156087f, -0.11110492f, 0.26672855f, 
    0.00964156f, -0.02939167f, -0.13873874f, -0.11188415f, 0.10354094f, -0.02155763f, -0.28120878f, 0.11246555f, 
    -1.14472592f, -0.02613089f, -0.66568571f, -0.37895545f, 0.02795740f, -0.07670382f, 0.03382951f, -0.04526792f, 
    0.14712793f, -0.14046822f, -0.03356498f, -0.19898918f, -0.52884412f, 0.28222582f, 0.12228516f, -0.46759599f, 
    0.23108159f, -0.00363267f, -0.14409117f, -0.03447727f, 0.01918334f, 0.02332631f, -0.06813370f, -0.02497813f, 
    0.06704124f, 0.10069709f, 0.13693614f, -0.21547683f, -0.23658887f, -0.10181656f, 0.26101428f, 0.23131366f, 
    -0.01313371f, 0.17909412f, 0.14142385f, -0.21387507f, -1.09055877f, -1.64755797f, -0.92330021f, -0.77088070f, 
    -0.18172640f, -0.28036284f, -0.23665281f, -0.48319796f, -0.00079611f, -0.02536812f, -0.06340663f, -0.02312893f, 
    -0.46264711f, 0.13736631f, -0.16756986f, -0.51085067f, -0.01352782f, 0.00264074f, 0.03825879f, -0.12424303f, 
    0.02440531f, 0.18917869f, -0.33690760f, 0.15477720f, -0.10439406f, -1.07515490f, -0.65016711f, -0.29009393f, 
    0.02126682f, 0.04359566f, 0.31567997f, -0.12039471f, 0.00099071f, -0.07180472f, -0.01704752f, -0.03801693f, 
    0.51575321f, -0.31921667f, -0.28682849f, -0.04980888f, -0.17409042f, 0.13763176f, 0.40637717f, 0.26476249f, 
    0.08049045f, 0.17963980f, 0.07803082f, 0.10207139f, -0.27879718f, -0.29941884f, 0.00834171f, -0.18684840f, 
    -0.56454009f, -0.17723608f, -0.11089899f, 0.04882828f, 0.03518245f, 0.14343569f, -0.15065040f, -0.07943978f, 
    -0.83630186f, -0.87192965f, -0.67136651f, 0.96386391f, -0.22626202f, 0.07273549f, 0.22984582f, 0.20241816f, 
    -0.02398054f, -0.05354277f, 0.25189623f, -0.19747946f, -0.13348316f, -0.50037217f, -0.47047764f, -0.42173758f, 
    -0.19112511f, -0.08666689f, 0.18292899f, 0.11340985f, -0.04272890f, 0.29734060f, 0.31348360f, 0.25651729f, 
    0.13210265f, 0.63968587f, -0.06620704f, 0.42754033f, 0.00844574f, -0.21679431f, 0.00403782f, 0.39562818f, 
    0.09223473f, 0.20317748f, 0.23975618f, 0.06826818f, -0.42519933f, -0.07651329f, 0.63083678f, 0.29633763f, 
    -0.14290823f, -0.22280207f, 0.05511249f, 0.24497724f, 0.13208728f, 0.14583315f, 0.45879942f, 0.04610581f, 
    0.31331834f, 0.18727864f, -0.12985849f, -0.14329085f, 0.19746074f, -0.08207902f, 0.04711433f, 0.08285485f, 
    -0.13553910f, -0.06939363f, 0.05550673f, -0.24906500f, 0.07281647f, -0.28112063f, -0.02795766f, -0.30336717f, 
    -0.03757786f, 0.05877874f, 0.18924475f, -0.14701156f, -0.01866887f, 0.09633116f, 0.07415526f, -0.11141355f, 
    0.21951780f, -0.30724382f, -0.52375805f, -0.06850266f, -0.05041494f, 0.13595217f, 0.04576290f, 0.05209487f, 
    -0.04605664f, 0.09288224f, -0.04444785f, -0.05708319f, -0.30527607f, -0.07046647f, 0.04043134f, -0.13843209f, 
    0.08626492f, 0.01294225f, -0.11813829f, -0.16755247f, 0.10218707f, -0.15627287f, -0.05204342f, -0.08389325f, 
    -0.62571150f, 0.45434356f, 0.84119707f, 0.24275607f, -0.07951067f, 0.01006451f, 0.08983503f, 0.15327786f, 
    0.07658155f, 0.11746124f, 0.08661687f, 0.07496770f, -1.30712140f, -0.66081828f, 0.56991524f, -0.36747885f, 
    0.02040262f, -0.06314556f, 0.05558032f, -0.27341902f, -0.03110252f, 0.05213775f, -0.03893756f, 0.12240234f, 
    0.49887472f, -0.43701324f, -0.34064624f, 0.04559044f, -0.06111212f, 0.17952320f, 0.20542781f, 0.21089542f, 
    0.12643363f, -0.15289488f, 0.07981397f, -0.11714832f, -0.98268259f, -0.46151981f, -0.37506527f, 0.91199541f, 
    -0.06713306f, -0.07840624f, 0.08528902f, 0.15269928f, -0.00110705f, -0.06423087f, -0.08257290f, -0.02693738f, 
    0.01746980f, 0.31427827f, -0.45790282f, 0.12186376f, 0.07572257f, 0.03942920f, -0.02338126f, -0.18452214f, 
    -0.05968109f, 0.04969260f, -0.14291131f, -0.13164048f, -0.66649091f, 0.15232722f, -0.15648475f, 0.36460751f, 
    -0.25884783f, -0.33239597f, -0.04891242f, 0.03885911f, 0.00202164f, 0.06423116f, 0.00199890f, 0.01109326f, 
    0.16600557f, 0.14128335f, 0.14859834f, 0.08963565f, -0.06238163f, 0.18871000f, 0.25580412f, -0.02756869f, 
    -0.11472758f, 0.17936830f, 0.14733975f, 0.18257543f, 0.35085657f, 0.20742436f, 0.07534198f, -0.08907352f, 
    0.03076756f, 0.01084499f, 0.09568529f, 0.16821799f, 0.07920254f, 0.00848240f, -0.02847167f, -0.09662271f, 
    -0.48686859f, -0.30474442f, -0.27937385f, -0.50370127f, -0.04468705f, 0.22093715f, -0.22351900f, -0.00247679f, 
    0.08631159f, 0.01536320f, -0.03141687f, -0.18170609f, -0.20708004f, -0.68270713f, -0.35317540f, 0.56348526f, 
    -0.18270649f, -0.15058786f, -0.01880514f, 0.09669791f, 0.08315516f, 0.03849538f, 0.23055293f, -0.05781308f, 
    -0.07003378f, -0.71974343f, 0.14930613f, 0.09516677f, -0.02343320f, 0.05754775f, 0.13759172f, -0.10188536f, 
    -0.06352668f, 0.07297026f, 0.04618530f, -0.03361883f, 0.74302226f, -0.01863363f, -0.25842917f, -0.69130683f, 
    -0.00461975f, 0.07404993f, -0.32789132f, -0.12881660f, -0.37300095f, -0.07333636f, -0.23425293f, -0.23042722f, 
    -0.13112442f, 0.07425905f, -0.07799421f, 0.12345042f, -0.13036937f, 0.12068024f, -0.01158851f, -0.07770573f, 
    -0.05056822f, 0.01996781f, -0.20768391f, -0.07828300f, -0.34666318f, 0.30795473f, -0.22270286f, -0.08734718f, 
    -0.02732768f, -0.00711745f, -0.13363400f, -0.14046025f, 0.02556306f, -0.06821257f, -0.04242548f, -0.05121240f, 
    0.17979652f, -0.31168652f, 0.28443983f, -0.42778125f, 0.09341906f, -0.04674372f, -0.10001834f, -0.07472885f, 
    0.13002516f, 0.08839728f, 0.02772732f, -0.10440172f, 0.15005942f, 0.31891096f, -0.13201967f, 0.01555507f, 
    0.01385737f, 0.03196429f, 0.02376508f, -0.05444738f, -0.09389600f, 0.07267425f, -0.06932662f, -0.09430394f, 
    1.28448081f, -0.44066447f, -0.32920057f, -0.49264190f, 0.03580170f, -0.05506388f, -0.06376865f, -0.05560716f, 
    0.10402185f, -0.00088001f, -0.06346627f, 0.20504211f, 0.07146771f, -0.97386676f, 0.57028371f, -0.85447204f, 
    -0.08525878f, -0.14936464f, -0.20389479f, 0.47138432f, 0.09667262f, 0.02735347f, -0.01819815f, -0.01786221f, 
    0.23661423f, 0.02808633f, -1.17264652f, 0.31800902f, 0.04184049f, 0.06834438f, -0.08375529f, 0.07191586f, 
    -0.11059584f, -0.06739578f, -0.47303838f, -0.32811725f, -0.53031832f, -1.26477170f, -0.43499878f, -0.44066828f, 
    0.04738975f, 0.06022863f, -0.04157815f, 0.08157150f, 0.00513160f, 0.12469247f, 0.16487713f, 0.24834910f, 
    -0.05925351f, -0.05614952f, -0.03308072f, 0.08624815f, -0.26520434f, -0.10845260f, -0.08351890f, -0.17370102f, 
    0.02658338f, 0.09935294f, -0.13726427f, 0.00640982f, -0.01795201f, 0.24212302f, 0.34238902f, 0.18824820f, 
    -0.06477218f, -0.09469143f, -0.17044674f, 0.06172794f, 0.03235995f, 0.25648358f, 0.14252299f, 0.18139513f, 
    -0.68312317f, 0.33537808f, 0.13628337f, 0.12917237f, 0.27569124f, -0.04041612f, -0.04662212f, 0.08159839f, 
    -0.47141793f, -0.31612211f, -0.18246616f, -0.38895518f, -0.10978691f, 0.02329825f, -0.18752384f, -0.19380124f, 
    0.01286708f, -0.15515345f, -0.21734245f, -0.21921104f, 0.20047860f, 0.29551926f, 0.12198731f, 0.27860153f, 
    -0.17638323f, -0.32895830f, -0.28413054f, 0.47862577f, 0.28786942f, 0.32485092f, 0.20047714f, 0.25431448f, 
    0.05611131f, -0.12886488f, 0.15539034f, -0.17516524f, 0.25149095f, -0.20026222f, -0.40811872f, -0.41758093f, 
    0.14060467f, -0.03563419f, 0.02929080f, 0.04843259f, 0.22413193f, -0.07216147f, -0.23018771f, -0.42683798f, 
    -0.47426912f, -0.58636945f, 0.06674585f, 0.10638947f, 0.02125792f, 0.13002160f, 0.12669380f, -0.06987035f, 
    -0.04467375f, 0.11433798f, -0.05377576f, -0.06510027f, 0.55751055f, 0.10012058f, -0.65115190f, -0.55066168f, 
    0.11428744f, 0.04645059f, 0.17197075f, -0.07391380f, 0.35183540f, 0.06382819f, 0.33172351f, 0.29573706f, 
    -0.29173923f, 0.29781073f, 0.12221016f, -0.01951795f, 0.15677412f, -0.01659635f, -0.11323921f, 0.10565486f, 
    0.18691351f, 0.05629961f, 0.33203858f, 0.23672901f, -0.50045335f, 0.39848855f, 0.28795019f, 0.20482069f, 
    0.25094676f, -0.03458442f, -0.13837877f, -0.01452401f, 0.02339970f, -0.23211335f, -0.10439704f, -0.07715657f, 
    0.70049727f, 0.30404755f, -0.02686981f, -0.10630810f, 0.10144337f, -0.36833119f, 0.13703264f, -0.20615442f, 
    0.03981707f, 0.07035706f, 0.16412047f, 0.16976890f, -0.49537107f, 0.06475639f, 0.10747723f, -0.34593338f, 
    -0.46455437f, -0.18762667f, -0.07398158f, -0.05108822f, -0.23324075f, 0.11800151f, -0.01900086f, 0.08891403f, 
    -0.54443020f, -0.54306948f, -0.18889010f, 0.17866330f, -0.19644134f, 0.36879447f, 0.05460170f, 0.14065598f, 
    -0.47050509f, 0.22832274f, -0.29879043f, -0.41867098f, 0.32914168f, -0.49760836f, -0.86749035f, -0.03803447f, 
    -0.03982804f, 0.10728249f, 0.37061670f, -0.33512774f, -0.10650572f, -0.25025672f, 0.04466874f, 0.05993350f, 
    -0.13849165f, -0.10237838f, 0.09379480f, 0.91431975f, 0.29618821f, -0.24017218f, -0.11089028f, 0.06401560f, 
    0.21396050f, 0.19659707f, -0.06023728f, 0.07909103f, -0.05519031f, 0.33825833f, 0.19413824f, -0.19341396f, 
    -0.04403682f, -0.25593916f, 0.13033482f, 0.21268757f, -0.05583871f, 0.13017307f, -0.01806802f, -0.17440929f, 
    -0.41897538f, -0.24615233f, -0.03150347f, 0.08685733f, 0.11445959f, 0.02680791f, 0.09933076f, 0.08448073f, 
    0.01385773f, 0.02012957f, -0.14439882f, 0.11356716f, -0.06727250f, 0.51428282f, -0.66735840f, -0.09800167f, 
    0.11407355f, 0.09445109f, 0.19417194f, -0.25049371f, -0.07155707f, -0.14269930f, -0.29953840f, -0.19930720f, 
    -0.48843867f, 0.77443606f, -1.05778313f, 0.10076847f, 0.01044004f, -0.04125080f, 0.17234842f, -0.20627527f, 
    -0.04795435f, -0.02288266f, 0.08411535f, 0.20255496f, 0.17354903f, 0.14876328f, 0.03128315f, 0.16333948f, 
    0.21052213f, -0.04862213f, -0.07411040f, 0.06775836f, -0.18652260f, -0.17956880f, -0.28307998f, -0.50561213f, 
    -0.22554590f, -0.39871949f, 0.28666171f, -0.45510063f, -0.27571368f, 0.01059923f, -0.21462607f, -0.19573456f, 
    0.16321169f, -0.21891373f, 0.17845973f, 0.18754873f, -0.69338745f, -0.09013616f, -0.21366294f, 0.25631627f, 
    0.03141710f, 0.14043584f, 0.05520052f, 0.02243165f, -0.06976813f, 0.16817644f, 0.25345597f, 0.06408674f, 
    0.46463427f, -0.04876594f, 0.82210118f, -0.39748758f, -0.00562162f, -0.48284540f, 0.03440768f, -0.21727377f, 
    -0.28104684f, 0.26845482f, 0.18677446f, 0.05154832f, -0.07882208f, -0.16671491f, 0.35791290f, 0.74146742f, 
    0.25798535f, -0.18431373f, -0.14540592f, -0.08575901f, 0.01276280f, -0.04394864f, -0.18285508f, 0.01059262f, 
    -0.30742383f, 0.17216448f, -0.49594298f, 0.11263631f, -0.12596816f, -0.18459371f, 0.25961244f, -0.15615675f, 
    0.21319339f, -0.12258257f, -0.02371735f, -0.02234337f, -0.35399675f, -0.15635771f, -0.49624962f, -0.15389284f, 
    0.34425056f, -0.00204946f, 0.20923640f, -0.07071068f, 0.10728132f, -0.26194093f, -0.10297969f, -0.03940792f, 
    -0.19672802f, -0.53650123f, -0.49360505f, 0.47327936f, 0.13754654f, 0.34345207f, 0.17358454f, -0.22110368f, 
    0.01499699f, -0.16552903f, -0.08336055f, -0.09591350f, -0.54134995f, 0.17639826f, 0.50828183f, 0.17395812f, 
    0.06984312f, 0.07275648f, -0.13875380f, 0.26440632f, -0.06004143f, 0.08014822f, 0.16710199f, -0.00715021f, 
    -0.17533037f, 0.17042227f, 0.41193253f, 0.13188586f, -0.10095354f, -0.09878037f, -0.15866269f, -0.45529109f, 
    0.02617260f, 0.07741919f, 0.14953203f, 0.06031496f, -0.54056245f, -0.01207862f, -0.39130941f, -0.35729146f, 
    -0.22756207f, 0.24042152f, -0.09267677f, 0.30121517f, 0.24436733f, -0.08153311f, -0.02580876f, 0.17453055f, 
    0.09322494f, -0.29998168f, 0.67308724f, -0.15852444f, -0.04391105f, 0.14718843f, -0.26476347f, 0.14865044f, 
    -0.13789514f, -0.09515651f, -0.38634625f, -0.21144323f, -0.35075146f, -0.40272233f, -0.30155760f, 0.44948116f, 
    -0.10921871f, -0.23336604f, -0.05955562f, -0.06151940f, 0.19671775f, 0.15857637f, 0.04609763f, 0.21768022f, 
    -0.34237844f, -0.23806448f, 0.51859021f, -0.18274125f, -0.13993318f, -0.28539160f, -0.02501424f, 0.22138345f, 
    0.14443222f, -0.52168417f, 0.29034644f, 0.39248508f, 0.01561710f, -0.99259633f, 0.12825614f, -0.01204487f, 
    -0.08639684f, 0.17510511f, 0.40425304f, -0.03165695f, -0.02078335f, 0.20266955f, -0.08588639f, 0.02808586f, 
    0.10904013f, 0.05188857f, -0.28236583f, -0.17521344f, -0.17553023f, -0.47290525f, 0.17415787f, -0.02164103f, 
    -0.13217543f, -0.10437352f, -0.10549832f, -0.35226223f, 0.02581867f, 0.34225193f, -0.23939513f, 0.00190238f, 
    -0.17325202f, -0.00634799f, 0.12589253f, -0.32911766f, 0.03413620f, 0.12936860f, 0.21355847f, 0.40292490f, 
    0.00439689f, 0.09048231f, 0.03002750f, 0.05038910f, -0.07603841f, -0.11443248f, 0.61921877f, 0.12490103f, 
    0.20085734f, 0.15717676f, 0.13137308f, -0.11206682f, 0.06009360f, 0.19923799f, 0.20204893f, -0.31817514f, 
    0.10328587f, -0.02663370f, -0.00235628f, 0.23961821f, -0.09360485f, -0.19496712f, -0.46318316f, -0.37036753f, 
    0.05480411f, 0.45468685f, -0.12959079f, 0.04415675f, -0.14539051f, -0.12683655f, 0.06933695f, -0.05445117f, 
    0.16659932f, 0.00280582f, 0.02965119f, -0.15045168f, -0.91183794f, 0.58653259f, 0.01586705f, 0.20994550f, 
    0.09074605f, 0.22114444f, 0.25241983f, 0.03924486f, -0.11348397f, -0.12526533f, 0.11728918f, 0.00664028f, 
    0.16881426f, 0.28517458f, 0.23846474f, -0.47281244f, -0.39168552f, -0.03602549f, 0.05365601f, -0.02927244f, 
    -0.02677508f, 0.60696298f, 0.20693912f, 0.22726282f, -0.16566667f, 0.06615036f, 0.08037890f, 0.09339914f, 
    -0.06387952f, 0.00722652f, -0.07148179f, -0.06891046f, -0.30538860f, -0.11823244f, -0.01112924f, 0.20010270f, 
    -0.54521215f, 0.44512713f, -0.91665947f, 0.07125127f, -0.18590862f, 0.01435840f, -0.02455072f, -0.21528549f, 
    0.08223239f, 0.01809887f, 0.04881598f, 0.05402013f, 0.03710766f, -0.61762816f, 0.22482808f, -0.86638415f, 
    -0.29882580f, -0.02021809f, -0.20678601f, -0.14622456f, 0.20644130f, 0.01150080f, -0.56588078f, 0.19569033f, 
    0.99748987f, -0.08299274f, 0.06121572f, -0.11770836f, 0.00297625f, -0.29669008f, 0.05234203f, 0.20024519f, 
    -0.24679677f, 0.03120439f, -0.39776593f, -0.36171991f, -0.07686719f, -0.56361634f, -0.26726654f, 0.26772538f, 
    0.16338871f, -0.03487719f, -0.31559587f, 0.03290637f, -0.27656448f, 0.01602323f, 0.19727461f, -0.19398054f, 
    0.09261297f, -0.00831356f, 0.40873030f, -0.31551301f, -0.00445387f, 0.41002220f, -0.09743612f, 0.07367456f, 
    0.03713010f, 0.17859761f, 0.26119152f, 0.07465415f, -0.26391485f, -0.57130760f, 0.03119455f, -0.16557211f, 
    -0.28926900f, -0.21556547f, -0.15012462f, -0.05856429f, 0.01827616f, -0.02172709f, -0.04916844f, -0.08710451f, 
    0.15559033f, 0.11955231f, 0.70775598f, -0.32057694f, 0.03497900f, 0.07226471f, -0.15402141f, 0.21527170f, 
    -0.26689869f, 0.28954259f, 0.12494532f, -0.21936651f, 0.42066950f, 0.38407293f, 0.57689887f, -0.24903029f, 
    -0.30048570f, 0.03354442f, -0.58227706f, 0.10242608f, -0.15142988f, -0.09632246f, 0.13373068f, 0.09538801f, 
    0.56331182f, -0.17447802f, 0.51923782f, -0.17895290f, 0.21890159f, -0.16753237f, 0.41858232f, 0.11130142f, 
    -0.03079875f, 0.02216090f, 0.19908173f, -0.08440701f, -0.18080075f, -0.10625118f, 0.01671820f, 0.11148509f, 
    0.20731014f, -0.05812474f, -0.09683777f, 0.08099675f, -0.37535423f, -0.31538948f, -0.44459403f, -0.52351624f, 
    0.15888985f, 0.12476860f, -0.15360746f, -0.79347420f, 0.06944260f, -0.50157225f, 0.25794792f, 0.00419427f, 
    0.13061477f, 0.02664643f, -0.06618712f, 0.17202698f, -0.60595155f, -0.49825707f, -0.02143187f, -0.50744170f, 
    0.04644744f, -0.08610832f, -0.07667109f, -0.24607813f, 0.12073798f, -0.01043005f, 0.25664008f, 0.21153943f, 
    -0.71079367f, -0.15024716f, 0.14301485f, -0.11546867f, -0.01390035f, -0.17994647f, -0.09267344f, 0.46187270f, 
    -0.44750655f, -0.04534946f, -0.05466041f, -0.08764561f, -0.74848402f, -0.06659076f, -1.08814692f, 0.25240678f, 
    0.38079405f, 0.21131864f, -0.02446746f, -0.24665980f, 0.08469930f, 0.33579198f, 0.27007809f, -0.13265830f, 
    0.50343639f, -0.53715414f, 0.66901177f, 0.02790545f, 0.23379394f, 0.12574403f, 0.07281958f, 0.13899548f, 
    -0.23211525f, -0.15255430f, 0.11177842f, -0.00642592f, 0.70749295f, 0.05706104f, -0.07905030f, 0.12664497f, 
    -0.24666418f, 0.26352468f, -0.16226409f, 0.17177786f, -0.08990658f, 0.09982394f, 0.07411489f, 0.03802146f, 
    0.64361560f, 0.02977525f, 0.21593191f, 0.41840693f, -0.01651061f, 0.00614878f, -0.19549020f, 0.10852910f, 
    -0.09328096f, 0.01104286f, -0.18839502f, -0.15400790f, -0.22657953f, -0.04386075f, -0.35146782f, -0.29385367f, 
    0.07633990f, 0.05332771f, 0.04493140f, -0.03650419f, -0.00283858f, 0.02432169f, 0.19043723f, 0.04346877f, 
    -0.52125883f, -0.24724121f, -0.36005366f, -0.60787517f, -0.08602372f, -0.22203545f, -0.18648031f, 0.05328326f, 
    -0.03398092f, 0.11658817f, 0.24143848f, -0.09659889f, -0.44845766f, 0.30854613f, -0.07597622f, 0.46517083f, 
    -0.41531202f, 0.03772018f, 0.30967298f, 0.07094916f, -0.10144015f, -0.00359649f, 0.04791665f, -0.02007707f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33829325f, 0.13643306f, 0.09595246f, -0.18676636f, -0.15307271f, 0.12448827f, 0.19573073f, -0.24241222f, 
    0.25023112f, -0.03291727f, 0.07117201f, -0.11937857f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
