#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.55429316f, -0.19736254f, -0.50265419f, 0.28069523f, 0.50357425f, 0.29828510f, 0.34883162f, 0.04887808f, 
    -0.24189159f, -0.03014884f, -0.53999245f, -0.40504482f, 0.02907691f, -0.36295834f, 0.12847143f, 0.03153016f, 
    0.00062898f, -0.03399572f, -0.36846754f, -0.51928633f, 0.04654197f, 0.03495814f, -0.23380437f, -0.59079069f, 
    -0.62011534f, 0.09118604f, 0.27190930f, 0.07218246f, -0.15807384f, 0.11190149f, -0.18754075f, -0.14833577f, 
    -0.03135926f, -0.09697557f, 0.16196243f, -0.10599922f, -0.12885098f, -0.11276366f, 0.03497084f, 0.10364589f, 
    0.30644244f, 0.23234406f, -0.23188047f, 0.02631659f, -0.47029153f, -0.23466109f, 0.27424112f, 0.22202085f, 
    0.23555887f, -0.21283835f, 0.60113752f, -0.07824368f, -0.09446341f, -0.26988313f, -0.45253363f, -0.33437213f, 
    0.09717128f, 0.00838957f, 0.27882779f, 0.32912278f, -0.07042295f, 0.15158370f, -0.00235188f, 0.00779268f, 
    0.18569244f, -0.33373576f, -0.32497951f, 0.38943306f, 0.33440113f, -0.38145605f, 0.01590647f, 0.21724330f, 
    0.14898460f, -0.34518421f, 0.28833333f, 0.47871411f, 0.80884260f, 0.46064508f, -0.33400643f, -0.33071521f, 
    0.09232850f, -0.00719454f, -0.03033748f, -0.31188172f, -0.38071325f, -0.31761259f, -0.29989102f, -0.10474827f, 
    0.13116601f, -0.17283827f, 0.24820472f, 0.38498256f, 0.27273989f, -0.13648726f, 0.11453084f, -0.20101635f, 
    -0.05644185f, -0.30452469f, 0.19233260f, -0.18348336f, 0.30252767f, 0.05652981f, -0.29708979f, -0.46700513f, 
    -0.61834729f, -0.34525436f, -0.54887217f, -0.60874951f, -0.87365061f, -0.97031552f, 0.58548450f, 0.01274193f, 
    0.19451138f, -0.14434569f, -0.08558881f, 0.03452911f, -0.08973972f, 0.00280301f, -0.33328193f, -0.11922748f, 
    -0.39043340f, -0.07162490f, 0.31234097f, 0.05119829f, -0.00165128f, 0.18413629f, 0.33805665f, 0.14801140f, 
    -0.02789757f, 0.29476139f, 0.06168447f, 0.38317049f, 0.17999849f, -0.00544145f, -0.20120546f, 0.14819244f, 
    0.17487048f, 0.17626090f, 0.00191941f, -0.17372711f, -0.13472560f, -0.20193152f, -0.20555507f, -0.32276475f, 
    -0.12498376f, -0.07172310f, 0.13616236f, -0.09754258f, -0.03806279f, 0.08066574f, -1.13002002f, -0.51852548f, 
    -0.49963248f, -0.81758058f, -0.70882571f, 0.45256546f, -0.06567495f, 0.19803289f, 0.52494603f, 0.53668314f, 
    -0.08187062f, -0.21150085f, -0.02435712f, -0.08743488f, -0.04438766f, -0.11442422f, 0.19079249f, 0.00842003f, 
    -0.07470167f, -0.09250955f, -0.09542255f, 0.13073984f, 0.14077255f, -0.05715971f, -0.21440065f, -0.91958350f, 
    -0.59752965f, -0.46541613f, 0.57642514f, 0.58885491f, -0.33616909f, 0.06470107f, -0.08239273f, 0.48259041f, 
    0.04220716f, -0.13228834f, -0.13624337f, -0.05650004f, 0.41551408f, 0.10543435f, -0.22581385f, 0.21832135f, 
    -0.00479273f, -0.39427561f, -0.19497615f, 0.06628429f, 0.17525741f, 0.11828775f, 0.22764878f, 0.12838225f, 
    -0.67093337f, -0.74465662f, 0.48607308f, 0.55326533f, -0.39826840f, -0.35061881f, -0.74347478f, -0.42639759f, 
    0.14402264f, -0.27557003f, 0.71170408f, 0.16115569f, 0.41805714f, 0.08370655f, 0.24669111f, -0.31115034f, 
    -0.09053964f, -0.11943798f, -0.24474694f, -0.54027319f, 0.05701992f, 0.20444979f, -0.13463217f, -0.26471999f, 
    0.18018921f, -0.35647035f, -0.68302470f, 0.33805487f, 0.46361926f, 0.38575891f, -0.48378202f, -0.46784288f, 
    -0.16486846f, -0.08777758f, -0.26795274f, 0.02925827f, -0.35615557f, -0.17651232f, -0.06032545f, -0.22074273f, 
    -0.39448845f, -0.39632687f, -0.14606887f, -0.08002121f, 0.06802681f, -0.46490100f, -0.20433645f, -0.13694519f, 
    -0.22808772f, -0.21571542f, -0.68503141f, -0.70119214f, -0.81891298f, -0.79767942f, -0.04824769f, -0.41070908f, 
    -0.75530607f, -0.44056916f, -0.43461946f, -0.37006235f, -0.07734826f, 0.22973670f, 0.10869814f, 0.06686118f, 
    -0.10640183f, 0.21412931f, -0.15460931f, -0.04755818f, 0.28595510f, 0.01117155f, 0.02285550f, 0.28634003f, 
    0.01946252f, -0.15769637f, 0.06840819f, -0.71910071f, -0.33409014f, 0.47364467f, -0.60864455f, -0.58764833f, 
    0.32948828f, 0.16282354f, -0.62138104f, -0.28296578f, 0.09112687f, -0.26670662f, -0.02012901f, -0.14639303f, 
    -0.44872522f, 0.10679223f, -0.00538255f, 0.16324499f, -0.05202804f, 0.14617261f, -0.18237326f, 0.22443405f, 
    0.25480184f, 0.09406235f, 0.07611076f, 0.37395075f, 0.23339622f, -0.50649238f, -0.27900216f, -0.06146073f, 
    0.29567984f, 0.29032773f, 0.34693301f, 0.42238608f, -0.17416981f, -0.55423391f, 0.08516204f, -0.18252762f, 
    -0.09867845f, -0.14195804f, 0.01697293f, -0.01506650f, 0.09061560f, 0.18281671f, -0.01451491f, -0.23751967f, 
    0.00548789f, -0.24842545f, -0.17743948f, 0.31815460f, 0.25159097f, 0.46824372f, 0.23709825f, 0.27705869f, 
    0.14160277f, 0.29783633f, -0.00415199f, 0.27855447f, 0.34588340f, 0.19964014f, 0.19965807f, -0.05345829f, 
    0.02034860f, 0.14595221f, 0.13859515f, -0.13717398f, -0.01332386f, -0.12758537f, 0.12301572f, 0.05705886f, 
    -0.19387157f, 0.08979820f, 0.04395940f, 0.09637421f, 0.11645504f, -0.18815665f, 0.38212883f, 0.03546134f, 
    0.30046296f, 0.03395497f, 0.40881366f, -0.16145183f, -0.30406868f, -0.28807363f, -0.20041828f, 0.18218301f, 
    0.23692350f, 0.21671329f, -0.10804693f, -0.16925001f, 0.15921663f, 0.02369327f, -0.32564929f, -0.05775727f, 
    -0.05643471f, 0.02876039f, -0.25649190f, 0.09806893f, -0.15441611f, 0.02884726f, -0.14376476f, -0.97650856f, 
    -0.62138832f, -0.44395295f, -0.43000162f, -0.56648690f, 0.27875233f, 0.60725707f, -0.23408251f, -0.47225285f, 
    0.11991391f, 0.12343612f, -0.20319162f, -0.00118107f, -0.06263419f, -0.16716276f, -0.01192686f, -0.04448795f, 
    -0.37606767f, -0.15797114f, -0.44795612f, -0.17665496f, -0.25249583f, -0.08680981f, 0.15723386f, -0.24130335f, 
    0.22867203f, -0.18508619f, 0.18435860f, 0.12251986f, 0.17393273f, 0.24435927f, 0.05883057f, -0.41561911f, 
    -0.37700355f, 0.23863457f, 0.30981362f, -0.08778818f, 0.08067795f, -0.08477397f, 0.16903184f, 0.17800613f, 
    -0.27113563f, -0.07798638f, 0.24297629f, -0.24077167f, -0.33787528f, 0.36641443f, -0.11499854f, 0.27254397f, 
    -0.17590453f, 0.46942437f, -0.08864743f, 0.07994252f, 0.38520694f, -0.59734398f, -0.37788260f, -0.36223668f, 
    -0.32780403f, 0.50821435f, 0.29709074f, 0.15670386f, -0.27087060f, -0.02667533f, 0.33096981f, -0.14159094f, 
    -0.33691901f, 0.29799053f, 0.10134190f, -0.10821998f, -0.14155543f, -0.01516475f, -0.18057443f, -0.32532191f, 
    -0.25727376f, -0.24449992f, 0.50082678f, -0.07441527f, -0.30960190f, 0.31563261f, 0.05484114f, 0.33215895f, 
    0.21994135f, 0.10198541f, -0.07964225f, -0.05879916f, -0.18092388f, -0.19963112f, -0.14977090f, -0.09171662f, 
    0.10030621f, -0.04116942f, -0.16430663f, -0.02738364f, -0.02814327f, -0.23180583f, -0.28984842f, -0.18204768f, 
    -0.22578304f, -0.35413429f, -0.42107293f, -0.73896521f, -0.79728979f, -0.26102236f, 0.38973454f, 0.61128235f, 
    -0.72326809f, -0.74870992f, 0.25712517f, -0.44190276f, -0.13980626f, 0.36128354f, 0.07302727f, 0.36756948f, 
    0.10434816f, -0.08792204f, 0.18197222f, -0.03930438f, -0.20323311f, -0.02693751f, -0.00402482f, 0.05904841f, 
    -0.17974876f, 0.08249000f, 0.10232025f, -0.19439022f, -0.34023303f, -0.55323541f, -0.27144444f, -0.21492669f, 
    0.04373441f, 0.53252685f, 0.32651708f, -0.33543217f, -0.26039809f, 0.16264847f, 0.16754535f, 0.11321733f, 
    0.37115350f, 0.09717030f, 0.30934408f, -0.06494755f, -0.22937630f, -0.13124949f, 0.02967385f, -0.08938045f, 
    -0.20228131f, 0.21273461f, -0.06982104f, -0.12258100f, 0.04408929f, -0.45625415f, 0.15651050f, -0.25401655f, 
    -0.26577690f, 0.45427918f, 0.04000384f, -0.13342105f, 0.03883570f, -0.22648080f, -0.15533866f, 0.08125201f, 
    -0.23929760f, 0.17839479f, -0.15814598f, 0.16068780f, -0.15225632f, -0.07315101f, -0.32479876f, 0.07087443f, 
    0.11620409f, -0.20421515f, -0.30462447f, -0.43502530f, -0.41983318f, -0.61018938f, 0.19004495f, 0.15588760f, 
    0.21177645f, -0.06123690f, 0.30178791f, -0.34861803f, -0.01253964f, 0.34951541f, -0.19817618f, -0.24409528f, 
    -0.25033957f, -0.17048176f, 0.40494728f, -0.17708565f, -0.27410334f, 0.11496711f, -0.13238113f, -0.07467797f, 
    -0.07358450f, 0.09350086f, -0.08799955f, 0.08280084f, 0.02107478f, 0.27099693f, 0.12686428f, 0.06470096f, 
    -0.69124949f, -0.23455158f, 0.29253730f, -0.10633831f, -0.44319060f, -0.73637968f, -0.42617571f, -0.13289499f, 
    0.00702133f, -0.26551220f, -0.61251986f, 0.34672070f, -0.33461747f, -0.25912651f, -0.18370293f, -0.40666616f, 
    -0.24865779f, -0.05764410f, -0.28222093f, 0.32819971f, 0.09879685f, -0.14964624f, -0.25785115f, 0.01525028f, 
    0.42876247f, 0.16918896f, -0.31377426f, -0.00775441f, -0.51892281f, 0.62604499f, 0.04171200f, 0.05328396f, 
    -0.02809415f, 0.40543067f, -0.25198469f, -0.20104375f, -0.39462143f, -0.32045546f, -0.12058350f, 0.25785527f, 
    -0.38160825f, 0.09637279f, -0.06818023f, -0.34190166f, -0.12939510f, -0.00563349f, 0.12523223f, 0.15741682f, 
    0.27312148f, -0.45047709f, -0.26772112f, -0.46044561f, -0.48601931f, -0.57264060f, 0.48536095f, 0.38749117f, 
    0.26856247f, -0.05930700f, 0.30838826f, -0.04361648f, 0.53553128f, -0.28855577f, 0.29996517f, -0.20265174f, 
    -0.51895612f, -0.37846720f, -0.10644746f, -0.02778898f, -0.38519052f, 0.12862201f, 0.05976919f, 0.01289722f, 
    0.46777922f, 0.18557920f, -0.32262176f, -0.69403493f, -0.24879925f, 0.07757153f, 0.06078760f, -0.56086701f, 
    0.15121099f, -0.16022791f, -0.63866591f, -0.71556824f, -0.18516652f, -0.34188730f, -0.26986003f, 0.07490568f, 
    0.16984616f, 0.03913660f, 0.13133888f, 0.06922840f, 0.19939277f, 0.30799010f, 0.17282483f, -0.00867031f, 
    -0.08962360f, -0.15444088f, -0.18889095f, -0.40402725f, 0.33784631f, 0.07578932f, 0.03339473f, -0.27626222f, 
    0.54742014f, -0.08447970f, -0.40175354f, -0.36872077f, 0.30339003f, 0.09005101f, 0.24807531f, -0.07326078f, 
    -0.11188456f, -0.06826103f, -0.13727003f, -0.13992274f, 0.06981152f, 0.37016657f, -0.03910744f, 0.07346459f, 
    -0.08697241f, -0.20986256f, 0.18729703f, -0.19913703f, 0.46195427f, -0.46187359f, -0.29791588f, 0.27414039f, 
    0.38036025f, 0.25470892f, 0.20196773f, -0.33438903f, -0.51955628f, -0.27962670f, -0.15389811f, 0.27812797f, 
    0.03195382f, -0.45102745f, 0.13916151f, -0.00888103f, -0.00388036f, 0.29012725f, 0.33239549f, 0.12110385f, 
    -0.14662912f, -0.19962135f, 0.03171960f, -0.20498505f, -0.31491515f, 1.06964564f, 0.21979769f, -0.06495647f, 
    0.06462118f, -0.63887489f, 0.26368853f, 0.57048094f, 0.49806520f, -0.44972873f, -0.33765951f, -0.07916988f, 
    -0.08807778f, -0.35233244f, -0.32410869f, 0.18353100f, 0.06505937f, -0.20233545f, 0.12734011f, -0.15071602f, 
    -0.24213324f, 0.16055310f, -0.16183519f, -0.21213725f, 0.15497282f, 0.06098797f, 0.62965101f, 0.32336757f, 
    -0.13402370f, 0.03876001f, -0.08068366f, 0.11348039f, -0.17901777f, -0.02834188f, 0.11536889f, 0.13035969f, 
    0.00084035f, 0.27331910f, -0.15162975f, -0.29485881f, -0.25813860f, 0.18639903f, -0.17864680f, 0.18160798f, 
    0.03565270f, -0.20081271f, -0.14291163f, 0.36855954f, 0.11513370f, -0.20387286f, 0.23004805f, 0.19912751f, 
    -0.20496492f, 0.23079592f, 0.03637917f, 0.19268201f, -0.06720041f, 0.23900104f, 0.32048965f, -0.05641177f, 
    0.02707941f, -0.30710813f, -0.07969292f, 0.32226562f, -0.15645476f, -0.01916355f, -0.27269232f, 0.11441698f, 
    -0.01719657f, -0.10594549f, -0.09651162f, 0.05644622f, -0.14332733f, 0.03977424f, -0.18366671f, 0.12422762f, 
    -0.24243361f, 0.76465166f, 0.32803124f, -0.35460755f, -0.10708325f, -0.93121952f, -0.54809558f, 0.45088559f, 
    -0.00760634f, 0.12374654f, 0.10012979f, 0.12951808f, -0.10593840f, 0.23433840f, -0.18340965f, 0.16580158f, 
    -0.15559268f, 0.11806829f, -0.00727390f, 0.10420363f, 0.14193366f, -0.03216216f, -0.14926392f, -0.04617617f, 
    -0.11709911f, 0.49595040f, 0.70625925f, 0.04975960f, -0.75106728f, -0.53824210f, -0.34007508f, 0.24828446f, 
    0.28992569f, 0.04592866f, -0.00336922f, -0.46748233f, -0.26623708f, -0.03073736f, -0.12347873f, 0.29523653f, 
    0.34066516f, -0.13957119f, 0.11082693f, 0.05924034f, 0.03153708f, -0.34586796f, -0.02972967f, -0.27487743f, 
    -0.28472891f, -0.33577591f, 0.82192838f, 0.03108267f, 0.00725954f, 0.01893727f, -0.70424074f, 0.44498193f, 
    -0.26297188f, -0.07865131f, 0.26490793f, 0.01923557f, 0.13405123f, 0.00043855f, -0.02459015f, 0.04179122f, 
    -0.33695644f, -0.21724990f, -0.04127549f, -0.17720935f, -0.23418067f, -0.00453868f, -0.27964467f, -0.33105433f, 
    -0.27767563f, -0.18996817f, -0.33301917f, -0.09448436f, 0.17796008f, 0.25334099f, 0.10835527f, 0.18281259f, 
    -0.34307712f, -0.25470003f, 0.02331715f, 0.12722063f, 0.38042191f, -0.31022385f, -0.04545510f, 0.21824229f, 
    0.22732949f, -0.11176442f, -0.03054100f, -0.08948991f, -0.14150456f, -0.30499226f, 0.30313897f, -0.01556860f, 
    -0.34900245f, -0.15723784f, 0.33018097f, -0.33196917f, -1.15332305f, 0.32712406f, -0.04164869f, -0.43997172f, 
    -0.18880159f, 0.13283972f, 0.25591984f, 0.09122742f, 0.21803176f, 0.32634151f, 0.06289385f, -0.23222454f, 
    -0.07211445f, -0.35424730f, 0.17671564f, 0.13735101f, -0.08465799f, 0.08551888f, 0.04295042f, -0.05264914f, 
    -0.04446290f, -0.13263604f, -0.22140829f, -0.21047269f, -0.22912899f, -0.68936700f, 0.04528901f, -0.53486156f, 
    -0.63520640f, -0.67684019f, 0.16071466f, -0.16005421f, -0.28515932f, -0.28377396f, 0.24973729f, 0.00211956f, 
    0.21747543f, 0.27357852f, 0.26433459f, -0.19431494f, -0.03014946f, -0.06450681f, -0.04188183f, -0.04809188f, 
    0.17335065f, -0.13560504f, 0.08283143f, -0.27751854f, -0.11943176f, -0.19909443f, -0.54641145f, -0.00337401f, 
    -0.23731036f, 0.03664309f, -0.14747323f, 0.06270371f, 0.06436359f, 0.47838035f, 0.19600806f, -0.38755149f, 
    0.16765778f, -0.04618072f, 0.21698870f, 0.28604570f, -0.36579302f, -0.29140306f, -0.16840068f, 0.04495249f, 
    -0.15805420f, 0.54231429f, 0.02622311f, -0.20793882f, -0.03623502f, -0.05814600f, 0.33011460f, -1.01612937f, 
    -0.67370808f, -0.54151940f, -0.21218020f, -0.32291228f, 0.58612955f, -0.16160908f, -0.85597408f, -0.66091269f, 
    0.29969102f, -0.34552264f, -0.36001158f, -0.27388746f, -0.00827655f, -0.24582168f, 0.15482670f, 0.07705056f, 
    -0.29259858f, -0.15782970f, -0.44657746f, -0.14838003f, -0.10201288f, -0.07657839f, 0.05272791f, -0.02374259f, 
    -0.64140594f, 0.72616446f, 0.51489830f, -0.18105128f, -0.41004440f, -0.11021798f, 0.13797063f, 0.28757510f, 
    0.08107433f, -0.05362564f, -0.05648307f, -0.01368407f, -0.19484191f, 0.37496394f, -0.49121788f, -0.10124385f, 
    -0.04459752f, -0.09090116f, 0.23698437f, -0.07467211f, -0.10568894f, 0.00888769f, -0.09949800f, -0.02398571f, 
    -0.29328170f, 0.72190756f, 1.04771781f, 0.86004776f, -0.80070508f, -0.89247733f, -0.53658479f, 0.00555177f, 
    -0.20947260f, -0.25666648f, -0.39863098f, 0.12893656f, 0.27588248f, -0.13794039f, 0.16743994f, 0.23267290f, 
    0.32770476f, -0.36471406f, 0.11522008f, 0.01296741f, -0.11636476f, 0.01113260f, 0.12797518f, 0.13636631f, 
    -0.14859988f, 0.22299631f, 0.03975666f, -0.71008337f, -0.43973389f, -0.46062285f, -0.94615525f, 0.24923027f, 
    0.06500157f, -0.01589143f, 0.21557142f, 0.27444565f, -0.40128967f, -0.34681424f, -0.21888420f, 0.38343579f, 
    -0.09950962f, -0.04456724f, -0.18043497f, -0.03496841f, 0.18519154f, -0.00041529f, -0.39676183f, -0.20684591f, 
    -0.15695950f, -0.12945525f, -0.30461025f, -0.10284061f, -0.50727761f, 0.13240261f, 0.03140501f, -0.08838289f, 
    -0.25871086f, -0.26865637f, -0.58279467f, -0.11530570f, 0.55551052f, 0.27746820f, -0.12370051f, -0.24537884f, 
    0.10100662f, 0.34100005f, -0.37635961f, 0.01497024f, -0.02769322f, -0.37187293f, -0.80080557f, -0.19007622f, 
    0.22117078f, 0.11141932f, 0.50577033f, 0.00614495f, -0.47309291f, -0.00352823f, 0.48182756f, -0.24491780f, 
    0.22999549f, -0.32897177f, 0.20070839f, -0.14444895f, 0.37073818f, 0.18502903f, -0.43994537f, 0.02296649f, 
    -0.20666593f, 0.00744646f, 0.35803628f, -0.09540335f, 0.07464761f, -0.37722826f, 0.13946220f, 0.26548797f, 
    -0.17266940f, -0.19789629f, 0.36177143f, -0.06828085f, -0.15538661f, -1.07231855f, -0.87642103f, 0.19027093f, 
    0.53543621f, 0.20387921f, 0.70288712f, 0.38338140f, -0.32036290f, 0.20827329f, 0.52271193f, 0.15061805f, 
    -0.16855647f, -0.25469083f, 0.26830813f, -0.30293056f, -0.20224816f, 0.04442620f, -0.10002182f, 0.11612108f, 
    0.10193328f, -0.14265992f, -0.22187442f, -0.04965107f, 0.25654078f, -0.13124518f, 0.87205869f, -0.81433475f, 
    -0.48293936f, -0.58053511f, -0.40778077f, -0.51878339f, -0.34382275f, 0.18678001f, 0.61295277f, 0.21303184f, 
    0.09092275f, -0.04298397f, 0.46568844f, -0.31029326f, 0.16095486f, 0.29387295f, -0.29288787f, -0.19569033f, 
    -0.09422561f, -0.28775051f, -0.34500018f, 0.04177836f, -0.00852046f, -0.26229465f, 0.56972831f, 0.41767663f, 
    0.58619392f, 0.14929657f, -0.32294992f, 0.04862477f, -0.32785925f, -0.11724046f, 0.12784380f, -0.09950707f, 
    0.11589801f, 0.12524658f, 0.14002679f, -0.01900203f, -0.21898504f, -0.27533597f, -0.06300546f, 0.00688474f, 
    0.30983469f, 0.20262265f, -0.22430430f, 0.22478865f, -0.13180211f, -0.44114503f, 0.12320151f, 0.24189329f, 
    -0.41460821f, 0.39268434f, -0.02085822f, 0.20395672f, 0.26858339f, 0.02038158f, 0.15907346f, 0.31683958f, 
    0.17723499f, 0.07344949f, 0.02703829f, -0.08858861f, 0.02274743f, -0.37035888f, -0.25504053f, 0.28389016f, 
    0.17063423f, -0.13415496f, -0.29869333f, -0.08476169f, 0.11712179f, 0.05704272f, -0.16216612f, 0.23326963f, 
    -0.11506744f, 0.14127603f, 0.10399185f, 0.44856668f, -0.54615754f, 0.03861283f, -0.55387419f, 0.48387426f, 
    -0.17120966f, -0.06814905f, 0.08998336f, 0.20730050f, 0.06808703f, 0.14314361f, 0.14508724f, -0.23513523f, 
    0.31266055f, -0.25447142f, 0.16074076f, -0.20026320f, -0.10315049f, -0.06839328f, 0.15037312f, 0.03588473f, 
    -0.02662697f, 0.27374622f, -0.77060837f, 0.00512489f, 0.01915172f, -0.35789701f, -0.70217675f, 0.44960657f, 
    0.33877075f, 0.28735146f, 0.24412808f, 0.34129742f, -0.30230582f, 0.14828342f, -0.03408740f, -0.01504109f, 
    0.13036346f, 0.19026738f, -0.05568210f, 0.11965811f, -0.28001574f, 0.01083946f, 0.11343297f, -0.07436387f, 
    0.23957014f, 0.03938641f, -0.02171206f, -0.43073347f, -0.02951986f, -0.05139285f, 0.32474375f, 0.30186465f, 
    -0.20951939f, -0.25002944f, 0.08306418f, -0.23796882f, 0.17657080f, -0.02523752f, 0.10251021f, 0.24810898f, 
    -0.09154499f, -0.27550733f, -0.13872606f, 0.16325444f, 0.17235611f, -0.05870859f, -0.12967172f, -0.25594118f, 
    0.04659233f, 0.00917917f, 0.17427167f, 0.28390917f, 0.85423428f, -0.26448208f, -0.22906944f, -0.05374818f, 
    0.01331147f, 0.31333718f, 0.37349296f, -0.11364173f, -0.26231703f, -0.01553632f, 0.23936643f, -0.34404004f, 
    -0.28077993f, -0.28010410f, -0.12653451f, 0.04281696f, 0.02496142f, 0.02111031f, 0.02770405f, -0.21400842f, 
    -0.27204272f, -0.16579546f, -0.44950938f, -0.41415164f, -0.61595339f, 0.17456831f, 0.21985424f, 0.05285501f, 
    -0.26282686f, 0.08139198f, -0.42133388f, 0.06621077f, -0.01524218f, -0.04936926f, 0.23025762f, 0.20311515f, 
    -0.30491361f, 0.19004564f, 0.18878691f, -0.12422991f, -0.00581063f, 0.07615722f, -0.44050944f, -0.12379385f, 
    0.31111133f, -0.05663531f, 0.42118841f, -0.02427035f, -0.21181612f, -0.23611303f, 0.20278189f, 0.28293106f, 
    0.08548671f, 0.43871030f, 0.20707797f, 0.00082143f, 0.41979197f, -0.63892841f, -0.43389115f, -0.42783880f, 
    -0.21296053f, 0.00086910f, 0.07358654f, 0.15473264f, -0.00528999f, 0.14311239f, 0.03946532f, 0.09514403f, 
    -0.10681779f, -0.00516397f, -0.23206255f, -0.11097793f, 0.31407160f, 0.13034974f, -0.19571385f, 0.10399733f, 
    0.45632714f, -0.00942003f, -0.07203604f, -0.03669028f, -0.77669227f, -0.24120454f, -0.31248033f, -0.12485333f, 
    0.11168303f, 0.22825629f, -0.41296023f, -0.02031557f, 0.68270355f, -0.29266787f, 0.08136880f, -0.34084761f, 
    0.02996606f, 0.12092794f, -0.06233691f, -0.09769157f, 0.14857183f, -0.27204004f, 0.11439872f, 0.23313358f, 
    -0.03905145f, 0.05760431f, 0.11227377f, 0.16925927f, 0.08415996f, -0.04229295f, -0.10461707f, 0.20572360f, 
    0.30163240f, 0.03128301f, -0.18412153f, -0.33460346f, 0.01763429f, 0.15929307f, 0.13477507f, 0.20509632f, 
    0.28112799f, 0.28243226f, 0.10796120f, -0.51914597f, -0.05197588f, -0.04402452f, -0.29464939f, -0.01145006f, 
    -0.02049587f, -0.43469241f, -0.93732828f, -0.23093636f, 0.45051166f, 0.78213406f, 0.61147720f, 0.77019405f, 
    -0.25846922f, -0.45281890f, -0.21877082f, -0.12361483f, -0.31053406f, 0.09891815f, -0.16357736f, 0.20775661f, 
    0.03820913f, -0.12968329f, 0.06168957f, -0.05899728f, 0.02578324f, 0.07456297f, 0.03968611f, -0.09920131f, 
    -0.06065163f, 0.19789849f, 0.54495215f, 0.94406331f, 0.55995333f, -0.45519221f, 0.10640784f, -0.64263976f, 
    -0.40618554f, -0.10244278f, -0.22487687f, -0.34725243f, 0.14520125f, 0.11502291f, -0.07280944f, 0.16073389f, 
    -0.14122976f, -0.26230621f, 0.00332377f, 0.22404434f, 0.14844047f, 0.09879928f, 0.08989099f, 0.18287776f, 
    -0.05792789f, -0.16060576f, -0.22694260f, -0.53504974f, 0.38322061f, 0.38200396f, 0.01361382f, 0.19620843f, 
    -0.51480168f, -0.25992623f, -0.25056460f, 0.05604889f, 0.36008090f, -0.36296335f, 0.59523511f, -0.47868061f, 
    -0.22565411f, 0.20831653f, -0.03016409f, 0.08006781f, -0.00012853f, -0.16717303f, 0.24094142f, 0.03334546f, 
    -0.21344943f, -0.05030888f, -0.21124533f, -0.14335467f, -0.40966117f, 0.04077938f, 0.09959371f, -0.79044086f, 
    -0.55486631f, -0.57819140f, -0.30262977f, -0.07695565f, -0.59678310f, -0.29812524f, 0.55943465f, 0.24711896f, 
    0.03617952f, -0.22732545f, -0.35860693f, -0.33971319f, -0.20246677f, -0.24851836f, -0.24994610f, -0.31476700f, 
    0.05974616f, -0.12796749f, -0.10244708f, 0.35699272f, 0.35586274f, 0.62411773f, 0.14238483f, -0.02665357f, 
    -0.44934970f, -0.46105888f, 0.60031074f, -0.27516440f, 0.02158885f, -0.21329692f, 0.20762731f, 0.37264264f, 
    -0.43092263f, -0.21696968f, 0.13167034f, 0.26299343f, 0.03891980f, 0.08073463f, -0.05947467f, -0.13980304f, 
    -0.10473350f, 0.23681138f, 0.17606084f, -0.17254260f, -0.14901674f, -0.11127079f, 0.23648275f, 0.18018772f, 
    -0.12159657f, -0.48427126f, -0.13974212f, -0.04763119f, 0.22848886f, 0.18484347f, 0.21177070f, 0.11252481f, 
    -0.14597465f, 0.52480173f, -0.20975527f, -0.21642759f, 0.04937731f, -0.28729495f, 0.28317460f, -0.20972037f, 
    -0.04919194f, -0.08812240f, -0.11921503f, 0.23629442f, 0.20974632f, 0.20832804f, -0.24932535f, -0.64930391f, 
    -0.60839313f, -0.78038669f, -0.34250176f, -0.10423558f, 0.64512140f, 0.10614883f, 0.36532015f, 0.10868829f, 
    0.27026626f, 0.35674658f, 0.27547121f, 0.25448757f, -0.07633882f, 0.00017049f, -0.12982205f, -0.04455490f, 
    -0.19667830f, -0.22814812f, 0.05792499f, -0.20513895f, -0.01290345f, -0.05622521f, -0.14624350f, 0.12811565f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.23529494f, 0.39717081f, 0.18235677f, 0.19014513f, -0.07718480f, 0.03454723f, -0.12231191f, 0.37438816f, 
    0.27583477f, -0.01709839f, -0.44773361f, 0.06704536f, 0.29987395f, -0.07246061f, 0.01170938f, -0.11680239f, 
    0.31317481f, 0.09021011f, 0.09483337f, 0.31352988f, 0.00405500f, -0.23649998f, 0.28460485f, 0.27961656f, 
    0.18881616f, 0.23835348f, -0.08685038f, 0.16082485f, 0.12019492f, 0.36164212f, 0.18752660f, 0.51557893f, 
    0.23219107f, 0.09046859f, 0.03781188f, 0.12789103f, 0.21492930f, 0.08156921f, 0.44168803f, -0.35886860f, 
    0.25167850f, 0.33307707f, -0.23475820f, 0.10697356f, 0.35297164f, 0.30043641f, 0.45841676f, 0.17244042f, 
    0.06975888f, 0.10177404f, -0.04392627f, 0.31075379f, 0.04090776f, 0.11133473f, 0.15407684f, 0.23182072f, 
    0.19577250f, 0.26397112f, 0.19428237f, 0.11469985f, 0.15350272f, 0.22875403f, 0.32177109f, 0.20720635f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.27963111f, 0.11579578f, -0.11179040f, 0.08567563f, -0.03592341f, 0.04373562f, 0.08847852f, -0.04032706f, 
    -0.03066567f, 0.14073278f, -0.01641446f, 0.18768784f, -0.05235191f, 0.00058209f, -0.04228085f, 0.01656606f, 
    -0.11413832f, -0.06269613f, 0.01114842f, -0.07182530f, -0.10884365f, -0.07810114f, -0.15832768f, -0.04635503f, 
    -0.06942056f, -0.09484344f, 0.01362807f, -0.01661636f, 0.04265943f, -0.12465360f, -0.05664309f, -0.07874370f, 
    -0.06764158f, -0.17510571f, -0.08721134f, -0.04281207f, -0.18469709f, -0.08189819f, -0.15030439f, 0.13307972f, 
    0.06330357f, -0.02932902f, -0.20063037f, -0.02502499f, -0.00536563f, -0.03669474f, 0.01624706f, 0.06383704f, 
    0.36144009f, 0.11177180f, -0.38929012f, -0.10478298f, 0.06207228f, -0.04075482f, -0.08639356f, 0.12377311f, 
    0.00770723f, 0.06481594f, -0.01607477f, -0.00314343f, -0.16877428f, -0.09750216f, -0.25304627f, 0.08656468f, 
    0.05324382f, 0.05294790f, 0.00679646f, 0.05946407f, -0.07878263f, 0.00171916f, -0.04295735f, -0.14673337f, 
    0.16701667f, 0.06578211f, 0.08855040f, -0.13475475f, 0.11989977f, 0.32294369f, -0.00488690f, -0.03132881f, 
    -0.00997423f, 0.07229267f, 0.00894865f, 0.01643405f, 0.08278815f, 0.17110083f, 0.12073737f, -0.21703321f, 
    0.00777354f, 0.07216761f, 0.09408755f, -0.13114254f, -0.04311116f, -0.02425036f, -0.13589656f, -0.16958946f, 
    0.19296990f, 0.29285797f, 0.15859808f, -0.43260854f, -0.06464037f, 0.02064282f, 0.05535224f, -0.08188777f, 
    0.13984111f, -0.01219891f, -0.15037788f, -0.03169274f, 0.31575486f, 0.13758419f, 0.18141203f, -0.25378180f, 
    -0.10421092f, -0.10926878f, 0.02910415f, -0.12920655f, -0.11933115f, -0.11828144f, -0.09561159f, -0.02605731f, 
    0.38410121f, 0.32811034f, -0.06771025f, -0.14974333f, 0.16730481f, 0.19962056f, 0.07880166f, -0.09905773f, 
    -0.01135711f, -0.00149887f, 0.01747988f, 0.04301228f, 0.26180527f, 0.23924343f, -0.13050817f, -0.19462918f, 
    -0.06713468f, 0.12443490f, 0.09759013f, 0.01039042f, 0.00082204f, -0.00459946f, 0.00689866f, -0.00030788f, 
    0.11590903f, -0.38111809f, -0.12934503f, -0.03128742f, -0.11153439f, -0.01411040f, 0.00503891f, -0.10315886f, 
    -0.04477539f, -0.04518836f, -0.08695040f, 0.11060463f, -0.03714465f, -0.02037914f, -0.00671191f, 0.04139212f, 
    0.03207161f, 0.02745514f, 0.06004982f, 0.03865093f, -0.01708769f, -0.03067473f, -0.01681087f, -0.03665821f, 
    -0.17513333f, 0.06300359f, -0.09645259f, -0.01995006f, 0.06038727f, 0.02201875f, -0.06745522f, -0.02366290f, 
    -0.05167367f, -0.00130794f, 0.04058695f, 0.03370975f, 0.22647300f, 0.09694272f, -0.15930067f, -0.06080793f, 
    0.06675264f, 0.11763303f, 0.04411384f, 0.01072204f, -0.14704283f, -0.13908711f, -0.06069255f, 0.01609292f, 
    -0.07609025f, -0.02982355f, -0.01698495f, 0.03866605f, -0.05199909f, 0.00315928f, -0.02861000f, -0.08744173f, 
    -0.12286904f, -0.04904044f, -0.07617136f, 0.01255374f, -0.10359970f, 0.04574861f, 0.10291463f, -0.08500865f, 
    -0.00850334f, -0.02238614f, -0.06313454f, 0.06844590f, -0.01859334f, -0.21051495f, 0.02251928f, 0.02086045f, 
    -0.24427278f, -0.42291367f, -0.10437354f, 0.02469734f, -0.02003468f, 0.05892433f, 0.04457740f, -0.00498114f, 
    0.09807045f, -0.08646056f, -0.04177088f, 0.16218820f, 0.30914009f, 0.40722162f, 0.12087628f, -0.31362098f, 
    -0.04181851f, -0.02693626f, -0.10238165f, -0.00756537f, -0.00892359f, 0.01197747f, -0.04958868f, 0.03436138f, 
    0.16048932f, 0.17048033f, -0.18465424f, 0.04220313f, 0.01966214f, 0.04421966f, 0.03434192f, -0.04934290f, 
    0.00349354f, -0.12091859f, 0.01540955f, 0.01966653f, 0.11815070f, 0.02726232f, -0.08597206f, 0.03206872f, 
    0.00371583f, 0.04124022f, -0.03360404f, -0.03625917f, -0.02073456f, -0.10960841f, 0.14402363f, 0.07129045f, 
    -0.22471097f, -0.01433978f, -0.00158253f, 0.11405740f, -0.00342709f, -0.02298077f, 0.00363542f, 0.04490381f, 
    0.00630103f, 0.03917822f, 0.04007135f, 0.01884928f, 0.18420336f, 0.14538376f, 0.06762293f, -0.22597346f, 
    0.15443823f, 0.02379098f, 0.05180696f, -0.07475370f, -0.02904244f, -0.09094436f, -0.08659191f, -0.13435568f, 
    -0.29640520f, 0.09222897f, -0.42391402f, 0.11410768f, -0.00793110f, 0.03201888f, 0.00464379f, -0.00113224f, 
    0.03108055f, -0.04873269f, -0.10932638f, -0.08911674f, 0.05066828f, -0.15803783f, -0.18067652f, 0.04799897f, 
    0.13388084f, 0.16029309f, -0.12132425f, -0.13006638f, -0.10070964f, -0.07848590f, -0.09344582f, -0.04152008f, 
    0.38316506f, -0.02095393f, 0.02035883f, -0.26376152f, 0.06796361f, 0.08001780f, 0.24400198f, 0.08396520f, 
    -0.04861255f, 0.03086031f, 0.00115352f, 0.03168502f, 0.04532451f, 0.09251000f, -0.03807794f, -0.01303540f, 
    -0.03641529f, -0.02625598f, 0.07436108f, -0.04634686f, 0.00981231f, -0.12585822f, 0.03555406f, 0.06104223f, 
    0.12171302f, 0.01860378f, -0.20995161f, 0.15160391f, 0.09782258f, -0.26522672f, 0.19698165f, -0.04714020f, 
    -0.10864510f, 0.04747365f, 0.07825334f, -0.05121611f, -0.18294288f, -0.67597783f, -0.24951693f, 0.18401383f, 
    -0.00812095f, 0.07651021f, -0.00671258f, 0.00508788f, 0.00611783f, -0.04910882f, 0.01554101f, -0.06029072f, 
    -0.09095251f, -0.04706622f, -0.24743667f, 0.04764548f, -0.00890335f, 0.03301159f, 0.01102861f, 0.02053818f, 
    -0.04229935f, 0.00507233f, -0.03722387f, -0.00726944f, -0.23251449f, -0.22985682f, -0.01281375f, -0.04178526f, 
    -0.01221179f, 0.02224820f, 0.04949103f, -0.00209547f, 0.03439513f, -0.04389496f, -0.04036713f, -0.06147115f, 
    -0.07464433f, 0.10300545f, 0.14076696f, -0.03511124f, -0.22653565f, 0.05640256f, -0.06223282f, -0.09387629f, 
    0.03500336f, 0.02022572f, -0.05204032f, 0.06220105f, -0.39834106f, -0.12854514f, 0.11667338f, 0.10567288f, 
    0.04761676f, 0.10864388f, -0.12103952f, -0.07307312f, 0.09083275f, 0.03402183f, -0.04380375f, -0.06541112f, 
    -0.29407939f, -0.34840328f, -0.18464763f, -0.09105083f, -0.01168831f, 0.01733381f, 0.01626535f, -0.00120031f, 
    -0.16471508f, -0.10467337f, -0.01239918f, 0.24660365f, -0.16184428f, 0.01580635f, 0.03438840f, 0.03762712f, 
    0.02884800f, -0.02055009f, -0.00841132f, 0.03853303f, -0.11830936f, -0.03916468f, -0.03401185f, 0.12788996f, 
    -0.30476463f, 0.11888804f, 0.08467928f, 0.00538564f, -0.01896056f, 0.09174757f, 0.07471097f, 0.07041708f, 
    0.03256636f, 0.10425521f, -0.00630893f, -0.03190301f, 0.20148696f, 0.08867659f, -0.06798103f, -0.11939418f, 
    0.00131632f, 0.13174109f, -0.07432172f, -0.17030208f, 0.03303535f, -0.00655280f, 0.03932646f, 0.05761790f, 
    0.00841393f, -0.03806176f, 0.13188139f, -0.06448542f, 0.01346639f, -0.04843091f, -0.02849523f, -0.07748336f, 
    -0.13351476f, -0.26988098f, 0.00029417f, -0.18369900f, 0.36462033f, 0.25478935f, -0.07365859f, -0.12893042f, 
    0.11870451f, 0.10750778f, 0.08956638f, -0.04073134f, -0.06882725f, -0.05355060f, 0.05761464f, -0.09339374f, 
    -0.43747783f, -0.25034627f, -0.01611645f, 0.02511398f, -0.03232241f, -0.01446042f, -0.00397058f, 0.04601227f, 
    0.10013875f, -0.11264589f, -0.20773807f, 0.03842055f, 0.12496618f, -0.30616033f, 0.01628047f, 0.02669206f, 
    -0.07479157f, 0.14447713f, -0.01877166f, -0.20900387f, -0.01840678f, 0.03623018f, 0.02156645f, -0.06556554f, 
    0.19473629f, -0.00517818f, 0.05589376f, -0.07697398f, 0.17927122f, 0.06917511f, -0.07333780f, -0.09473764f, 
    0.06465489f, 0.07971393f, 0.01666727f, 0.09053587f, 0.10375419f, 0.10212389f, 0.15095867f, -0.19199306f, 
    -0.05547382f, 0.06438684f, -0.17381462f, -0.33676559f, -0.05918087f, -0.06641628f, -0.08220042f, -0.07520412f, 
    -0.33488360f, -0.02509261f, 0.06038810f, -0.07818253f, 0.01216226f, -0.05739345f, 0.00684904f, 0.00672106f, 
    -0.20672570f, -0.10005049f, -0.03614140f, -0.19342840f, 0.65286535f, 0.04402012f, 0.04956843f, -0.09514690f, 
    -0.00657116f, 0.00322534f, 0.08953277f, 0.01657160f, 0.06009050f, -0.00982928f, -0.07805957f, -0.13131870f, 
    0.04806578f, 0.09755705f, -0.06211995f, -0.13605569f, 0.08794688f, -0.09137753f, 0.02269290f, -0.24242549f, 
    -0.17370965f, -0.14926204f, -0.10320519f, 0.05960719f, -0.08638128f, -0.16268413f, -0.32424870f, 0.13196354f, 
    0.06500919f, 0.04709971f, -0.02748909f, 0.04006767f, -0.04129464f, -0.02482423f, 0.00010259f, 0.00756708f, 
    -0.09356642f, 0.06037362f, -0.15606995f, -0.10902514f, 0.00608673f, 0.01387971f, 0.04536041f, 0.05385756f, 
    -0.03600604f, -0.01749473f, -0.06334212f, -0.02807853f, -0.02705692f, 0.01073660f, 0.13688962f, -0.00388279f, 
    -0.07106853f, 0.00391655f, -0.00034836f, -0.19816817f, -0.16749053f, -0.02055300f, -0.02893542f, -0.14822803f, 
    0.00601842f, -0.22316365f, 0.03456523f, 0.02976697f, 0.04613980f, 0.11336514f, -0.04902947f, 0.04030687f, 
    -0.09274833f, -0.02065967f, -0.01190225f, 0.03128792f, -0.03565679f, 0.07282522f, 0.09521633f, -0.10157283f, 
    -0.01303193f, -0.12234133f, 0.06177193f, -0.03889982f, -0.06057635f, -0.12712213f, 0.01660872f, -0.03226536f, 
    0.08618317f, -0.22742100f, -0.23251100f, 0.05330006f, 0.01004872f, 0.04176198f, -0.12186433f, -0.11883640f, 
    -0.11329079f, 0.06870196f, 0.02813638f, 0.21714403f, -0.18794315f, 0.03426095f, 0.07846298f, 0.08563312f, 
    -0.10245252f, -0.08152024f, -0.00379985f, 0.01413435f, -0.02371603f, 0.00189297f, -0.02683998f, -0.12505230f, 
    -0.05445826f, -0.30686632f, -0.14190196f, -0.03939021f, 0.06265352f, -0.22483440f, -0.09165644f, -0.07905858f, 
    -0.04470748f, 0.04182661f, 0.05581085f, 0.02025652f, -0.05542805f, 0.16341564f, 0.03967051f, -0.24922706f, 
    0.02953326f, -0.02004853f, -0.08546056f, -0.23223443f, -0.03279812f, 0.00187294f, 0.02015995f, -0.07393926f, 
    -0.06831890f, 0.00557306f, 0.08733712f, 0.04061047f, -0.06590320f, -0.03770474f, -0.01947211f, 0.00589499f, 
    -0.04312325f, -0.03988843f, -0.05893294f, -0.07770955f, 0.50587869f, -0.00342755f, -0.24101719f, -0.13804598f, 
    -0.22292025f, -0.05577850f, 0.21260780f, -0.19467269f, -0.12373705f, -0.03042268f, -0.01742626f, -0.04789366f, 
    -0.13423355f, 0.00209119f, -0.27409062f, 0.01150795f, -0.06462009f, -0.02944507f, 0.00392998f, -0.04274462f, 
    0.03007463f, 0.02910965f, 0.00665523f, 0.05173326f, -0.35162738f, 0.29216903f, 0.15451302f, -0.25144279f, 
    -0.00630539f, -0.04210439f, -0.02541377f, -0.01294758f, -0.03989137f, 0.01458420f, -0.08985675f, 0.02264463f, 
    0.16245641f, 0.17174996f, -0.00876998f, -0.17196423f, 0.06572617f, 0.09479280f, 0.00758189f, 0.07008551f, 
    0.00181511f, -0.00619058f, -0.01836725f, -0.07353964f, 0.00905016f, -0.16461553f, -0.16272597f, 0.03798529f, 
    -0.06021620f, -0.02490548f, -0.01974682f, -0.09756692f, -0.16435416f, -0.06816126f, 0.05443524f, -0.23782644f, 
    -0.03922796f, -0.52079493f, -0.16947588f, 0.04455784f, -0.01558681f, -0.03451767f, -0.03259132f, 0.01244006f, 
    -0.11598884f, -0.21881752f, -0.21562390f, -0.14394578f, 0.20882715f, 0.11637896f, -0.11954021f, -0.00023119f, 
    0.04033153f, 0.09735857f, 0.05736559f, -0.07727499f, -0.03463653f, 0.02277875f, -0.05967529f, -0.06744218f, 
    -0.27032867f, -0.28190532f, 0.13040255f, 0.00186450f, 0.02280043f, 0.06502213f, -0.03858826f, 0.01730144f, 
    -0.08962873f, -0.21851954f, -0.26889980f, -0.12382362f, 0.03715564f, -0.04520446f, 0.08071989f, -0.02211200f, 
    0.05546520f, -0.09105694f, -0.01013563f, 0.04078345f, -0.08717148f, 0.11804835f, 0.01683152f, 0.05142866f, 
    0.12677749f, -0.01693543f, 0.12616627f, -0.17186341f, -0.04009030f, 0.15250656f, -0.08716794f, -0.01322831f, 
    -0.09792442f, 0.12915276f, -0.04251671f, -0.13436979f, 0.13096896f, -0.07877979f, -0.01741611f, -0.15485661f, 
    0.06225687f, -0.18495901f, 0.00798249f, -0.02088924f, 0.02611790f, 0.10547735f, -0.02574816f, 0.01779013f, 
    0.08189222f, -0.00618076f, 0.06520262f, -0.19217694f, -0.15496643f, -0.06437611f, -0.06503817f, 0.03139973f, 
    0.02204123f, 0.05373660f, -0.02801786f, 0.10121305f, 0.13486567f, 0.01711105f, 0.18819819f, 0.14562310f, 
    -0.02723317f, -0.02647092f, -0.02575229f, -0.03493828f, 0.08247794f, 0.04238307f, -0.12068709f, 0.09264210f, 
    0.11017175f, 0.21942380f, -0.05752224f, -0.14341219f, 0.03158690f, 0.06958705f, -0.18667462f, -0.21136612f, 
    -0.13594896f, -0.03027325f, -0.01753999f, -0.11965337f, -0.47943506f, 0.08759470f, 0.13171156f, -0.02003144f, 
    -0.00082582f, 0.03244953f, 0.14503372f, 0.00342607f, -0.04719508f, -0.08435266f, 0.06990798f, -0.05512155f, 
    -0.80809462f, -0.04191485f, -0.31469417f, -0.26768121f, -0.09406707f, -0.01294501f, 0.09711503f, 0.07072934f, 
    -0.02005867f, 0.15693085f, 0.06727570f, -0.01228629f, -0.11905664f, 0.08231916f, -0.39777732f, -0.32902700f, 
    -0.02369115f, 0.02724731f, -0.05823225f, 0.01709300f, -0.00271636f, 0.02421227f, 0.00228973f, -0.03351874f, 
    0.03175963f, 0.16795640f, 0.12116610f, 0.41773015f, -0.29027060f, 0.03583831f, -0.06430574f, -0.27003881f, 
    -0.05981605f, -0.02499941f, 0.00415707f, 0.04315221f, 0.14991142f, 0.19647186f, 0.19505486f, 0.01438196f, 
    0.02269985f, 0.03571122f, -0.04545454f, 0.23655233f, -0.01490898f, -0.02194001f, -0.01417730f, 0.00203039f, 
    0.18982840f, -0.13094814f, 0.06924729f, 0.17731446f, 0.03460160f, 0.00497160f, 0.09424164f, -0.19172177f, 
    0.18263102f, -0.00088361f, 0.03932792f, 0.01688281f, 0.11742786f, 0.09202500f, 0.09976731f, 0.12736513f, 
    -0.03022644f, -0.02022324f, -0.00138924f, -0.02956941f, -0.00131568f, 0.08385049f, 0.07242329f, 0.00392678f, 
    0.06811056f, 0.01997553f, 0.06344958f, 0.02742073f, -0.02996113f, -0.06477177f, -0.09990074f, 0.00202825f, 
    -0.00187208f, 0.04207569f, 0.01589264f, -0.05879884f, 0.42134050f, -0.06527125f, 0.17249061f, -0.08258986f, 
    0.09813099f, 0.01987411f, 0.14504094f, -0.12966572f, 0.05164482f, 0.02223274f, 0.01657413f, -0.03337096f, 
    0.10995086f, 0.01473938f, -0.11363205f, 0.07756431f, -0.05241669f, 0.00198070f, 0.03945252f, 0.04836851f, 
    -0.06192903f, -0.02005388f, 0.10284846f, -0.06462710f, -0.15476832f, 0.02212758f, 0.00542015f, -0.14785655f, 
    -0.05933221f, 0.00125648f, -0.02085820f, -0.00126187f, -0.03789154f, -0.02864823f, 0.02802872f, -0.10175356f, 
    0.28447843f, 0.10913919f, 0.12433558f, 0.08247695f, -0.03755798f, 0.03341571f, -0.08159017f, -0.03251132f, 
    -0.17076185f, -0.06987086f, -0.06378334f, -0.14538524f, -0.53934979f, 0.03225388f, -0.28077871f, 0.14694095f, 
    -0.16038488f, 0.06052164f, 0.14733817f, -0.05489304f, -0.10521065f, 0.00422934f, 0.05211323f, 0.03868498f, 
    -0.05498237f, -0.02238005f, 0.03356920f, 0.02867107f, -0.01552892f, -0.01193805f, 0.03881483f, 0.01603320f, 
    -0.16115943f, 0.04413387f, 0.13804826f, -0.00811957f, 0.00202777f, -0.07959700f, -0.08232586f, 0.03845539f, 
    0.06989878f, -0.00688621f, -0.00508679f, -0.00189447f, -0.64838219f, -0.03614696f, -0.15518641f, -0.03874191f, 
    0.13357028f, -0.03634122f, 0.07540824f, 0.03882133f, -0.11452077f, -0.08726705f, 0.02423606f, -0.04249489f, 
    -0.00330557f, 0.01428547f, 0.00211926f, 0.02709208f, -0.13923804f, 0.08933218f, -0.32963085f, 0.12017624f, 
    -0.02781978f, -0.00156076f, -0.09262214f, -0.07864974f, 0.00097518f, 0.00841082f, -0.02475540f, -0.04200057f, 
    0.39800963f, 0.39110187f, 0.21171494f, 0.00503200f, -0.01286178f, 0.00747176f, 0.03767697f, 0.01182154f, 
    0.03001203f, 0.07232631f, -0.12605987f, -0.02862169f, -0.02428488f, -0.31536710f, -0.11279009f, -0.19489184f, 
    -0.08374756f, 0.03823126f, 0.10310159f, 0.13911197f, 0.05019076f, -0.03688726f, -0.03648029f, 0.00982240f, 
    -0.05763650f, 0.01026681f, 0.28925994f, -0.21322665f, -0.07810750f, -0.15081604f, -0.07361621f, -0.11534365f, 
    -0.07386113f, -0.04365788f, 0.02802543f, -0.05174090f, -0.00315075f, 0.06464645f, 0.00626449f, -0.04468009f, 
    -0.05993040f, 0.05076463f, -0.14813726f, 0.01945776f, -0.13796136f, -0.18196264f, 0.16303669f, 0.24526159f, 
    0.16964369f, -0.00566748f, -0.13774852f, -0.09900336f, 0.02064926f, 0.06763939f, -0.08539755f, 0.08208386f, 
    0.17927600f, -0.05464477f, 0.02467868f, -0.04593914f, 0.86224854f, -0.08155513f, 0.34404418f, 0.17951806f, 
    -0.10658620f, -0.02327379f, 0.01963852f, -0.03566509f, 0.01246012f, -0.03902385f, -0.09191378f, 0.10683357f, 
    0.11675295f, 0.04386017f, 0.16459985f, -0.01721085f, 0.00987903f, -0.05242534f, -0.00427595f, -0.05133906f, 
    -0.07438758f, 0.03208190f, -0.01276717f, 0.00386225f, 0.14926530f, 0.09339480f, 0.17337556f, 0.06211687f, 
    0.00554784f, 0.02620771f, -0.01844987f, 0.00107370f, 0.07291953f, 0.03890944f, 0.01173509f, -0.00688003f, 
    -0.11246629f, -0.18221089f, 0.15162446f, -0.13346384f, 0.17298608f, 0.04411048f, 0.08835748f, 0.10291043f, 
    -0.01232008f, -0.08216566f, 0.00970146f, -0.02499178f, 0.09593248f, -0.13375454f, 0.02890136f, -0.04571247f, 
    0.08513390f, 0.00382949f, 0.03380047f, -0.10293614f, -0.09001377f, 0.10858878f, -0.18963322f, -0.10168948f, 
    0.30493444f, 0.06564473f, 0.04875043f, -0.06975338f, -0.03069882f, -0.02986362f, -0.00287814f, -0.01545764f, 
    0.00297474f, 0.00162981f, -0.11719298f, -0.47237119f, -0.06426162f, 0.10409066f, 0.09551394f, 0.01901039f, 
    0.02463058f, -0.01297202f, -0.00521903f, -0.06176008f, 0.16189967f, 0.08496877f, 0.03279912f, -0.06883565f, 
    -0.03498764f, 0.04488360f, -0.08401317f, -0.09022459f, 0.02717468f, 0.00816064f, -0.11648072f, -0.09927058f, 
    -0.11393624f, 0.00917168f, -0.20071448f, -0.12875688f, 0.00219444f, -0.01528411f, 0.05403490f, 0.22035956f, 
    0.02945935f, 0.07485706f, -0.15767398f, -0.13560046f, -0.03084014f, -0.03858693f, 0.04982439f, 0.00681844f, 
    -0.22869888f, -0.06702582f, -0.11419309f, -0.15238176f, 0.08769713f, -0.04046685f, 0.26022166f, -0.09259681f, 
    0.11420323f, 0.05173261f, 0.07099678f, 0.13322106f, 0.51243716f, 0.14603104f, 0.28319579f, 0.33213425f, 
    0.18672021f, -0.08186331f, 0.08138181f, 0.02668631f, 0.08214256f, -0.01994612f, 0.03208710f, -0.12138826f, 
    -0.03306599f, -0.31019452f, -0.00949685f, -0.07270554f, -0.00148743f, -0.10373269f, -0.01567777f, -0.01489811f, 
    0.08909427f, -0.15402745f, 0.04317381f, -0.06475476f, 0.30685788f, -0.29662520f, 0.07427440f, -0.18380630f, 
    -0.18358171f, 0.08673412f, -0.10093474f, 0.08490068f, -0.00383764f, -0.01549206f, 0.00929334f, 0.02514600f, 
    0.22660041f, 0.19163164f, 0.03417569f, 0.05396745f, 0.04246725f, 0.11155090f, -0.01348043f, -0.50579858f, 
    -0.02908020f, -0.18131158f, 0.07290280f, -0.34201276f, -0.07647160f, 0.08102217f, -0.15088990f, -0.26544464f, 
    -0.12266459f, -0.03552080f, -0.00574530f, 0.23514089f, -0.06088790f, -0.12977508f, 0.11059056f, -0.10996551f, 
    -0.04140664f, 0.16276792f, 0.04664269f, 0.00245183f, 0.02967961f, 0.01239216f, -0.06745028f, 0.02275174f, 
    0.00746472f, 0.17288354f, 0.08761584f, -0.07399686f, 0.42492378f, 0.11026392f, -0.10104500f, -0.02807709f, 
    -0.06558685f, -0.05717992f, -0.00023915f, 0.03281898f, 0.05148973f, -0.11409149f, -0.06429851f, -0.04480864f, 
    -0.02048201f, -0.02289467f, -0.23175564f, -0.21993251f, 0.06714417f, 0.24755673f, 0.08016465f, -0.32674694f, 
    0.24291401f, 0.09087043f, -0.00264312f, -0.02329235f, 0.05898098f, 0.10378493f, 0.26044244f, -0.04772520f, 
    -0.04059060f, 0.01658640f, 0.02330224f, -0.06933837f, 0.03761297f, -0.14920712f, 0.08271756f, 0.07329629f, 
    -0.07858674f, -0.07029891f, 0.17503989f, 0.05723856f, -0.00430766f, -0.04841958f, -0.00620922f, 0.00281433f, 
    0.04412444f, -0.01500628f, -0.09598225f, 0.22359776f, 0.33398297f, -0.12895355f, 0.04374260f, -0.20120856f, 
    -0.06042720f, 0.09068201f, -0.10358472f, 0.02158448f, 0.06986949f, -0.06420889f, 0.01069179f, 0.00952178f, 
    -0.12242503f, 0.12089289f, -0.00473790f, -0.10615453f, -0.04643619f, -0.02669398f, 0.00016240f, -0.02178206f, 
    -0.13224576f, -0.01463466f, -0.08282917f, -0.07341961f, -0.12385637f, 0.04446401f, -0.08204687f, 0.02541891f, 
    0.01536924f, 0.04282345f, 0.03034022f, -0.12646301f, 0.02526341f, 0.03085769f, -0.04775434f, 0.07086067f, 
    0.28058019f, 0.01771051f, 0.04018189f, -0.02543350f, 0.00640495f, -0.01091215f, -0.11233471f, -0.01327919f, 
    -0.20763572f, -0.41094115f, -0.01684198f, -0.06283791f, 0.12173257f, 0.01825383f, -0.06304954f, 0.02729583f, 
    0.04340943f, -0.02479755f, -0.16084634f, 0.11211229f, 0.05178603f, -0.02507460f, 0.01639374f, -0.06579394f, 
    0.14407182f, 0.00770172f, -0.07269758f, -0.07863016f, -0.07102003f, -0.08296968f, -0.10144454f, 0.00235485f, 
    -0.01211265f, 0.07692800f, 0.03748953f, 0.01009856f, 0.04562467f, -0.15020372f, 0.00912118f, -0.07831838f, 
    -0.02074665f, -0.00404676f, -0.02041698f, 0.13350902f, -0.06356809f, -0.08745883f, -0.00552096f, -0.03636812f, 
    -0.03596187f, 0.03134846f, 0.03497342f, 0.01452191f, 0.03559585f, -0.00691461f, 0.01071364f, -0.00362359f, 
    0.15028882f, 0.05428361f, -0.18451498f, -0.04476293f, 0.10061862f, -0.38899013f, 0.19621855f, 0.17026296f, 
    0.02645969f, -0.02911408f, 0.05661355f, 0.00066721f, 0.18881340f, -0.06914861f, 0.03687848f, 0.05362223f, 
    0.18167689f, -0.03772800f, 0.03335544f, -0.13746089f, 0.08615695f, -0.21466179f, -0.09132853f, 0.06563601f, 
    -0.04634653f, 0.01697011f, -0.00517253f, 0.06190160f, -0.19991770f, 0.02641135f, 0.00904094f, -0.15908413f, 
    0.17146552f, -0.02454855f, -0.14606909f, 0.16931450f, 0.02951797f, -0.03050482f, -0.10097647f, 0.00379249f, 
    -0.04397779f, -0.20085372f, 0.02510169f, -0.04107761f, 0.10407831f, 0.19425966f, -0.07276382f, 0.17964587f, 
    -0.00946382f, -0.01462387f, -0.04655782f, 0.09687927f, 0.24955538f, -0.09829456f, -0.12146178f, -0.00152574f, 
    0.02580435f, 0.02078772f, -0.06829771f, 0.07870520f, -0.01011981f, 0.01901188f, 0.08079584f, -0.01302405f, 
    0.09037159f, -0.07905734f, 0.04299541f, -0.06378810f, 0.05360710f, -0.05373719f, 0.02999319f, 0.04331698f, 
    0.04936447f, 0.14371185f, -0.16264234f, 0.00687623f, 0.10326880f, -0.17621720f, -0.38887960f, -0.16921209f, 
    -0.03124934f, 0.01657725f, 0.03260846f, 0.00112449f, 0.08026695f, 0.06272829f, -0.02556304f, 0.01452572f, 
    -0.04848425f, -0.12687317f, 0.00320178f, -0.05468663f, 0.01196131f, -0.05008522f, -0.01154807f, 0.08101714f, 
    0.10264535f, 0.16854683f, -0.00493990f, -0.09400922f, 0.01147711f, -0.15129690f, 0.07029468f, 0.12569553f, 
    0.01732486f, 0.07011790f, 0.08295464f, -0.05394024f, 0.00835357f, -0.14299703f, -0.00630001f, 0.14230488f, 
    -0.27210489f, 0.15478764f, 0.01262986f, 0.02628224f, 0.02820289f, 0.20608428f, -0.22721632f, 0.05716530f, 
    0.15293375f, -0.01879031f, -0.01540759f, 0.00064663f, -0.04632355f, -0.02185950f, 0.18333921f, -0.52551430f, 
    0.07112619f, -0.01744640f, 0.02771761f, 0.08773231f, 0.00567675f, 0.02727475f, 0.00812271f, 0.03174337f, 
    -0.92032528f, -0.43029150f, -0.17498685f, -0.48442656f, 0.00534666f, 0.03235887f, 0.03994380f, -0.41483080f, 
    -0.03880075f, -0.04304317f, -0.02669509f, -0.01263317f, -0.02352363f, -0.32633463f, -0.20520440f, -0.06661812f, 
    -0.00212657f, 0.00466844f, 0.00411004f, 0.01618389f, 0.00282667f, -0.08833729f, -0.04592404f, -0.11312934f, 
    0.04065594f, 0.65104836f, 0.22498222f, 0.34882998f, -0.13855985f, -0.03894434f, 0.17680040f, 0.10427937f, 
    0.01466125f, -0.00889808f, -0.00251384f, 0.04620281f, 0.01237720f, -0.27911839f, -0.01356255f, 0.15292169f, 
    -0.01881054f, 0.09187600f, 0.01758782f, -0.00080692f, -0.06447500f, -0.03712619f, 0.00847463f, -0.03600618f, 
    0.02963897f, -0.10760742f, -0.31931475f, 0.01789053f, 0.07137167f, -0.07407261f, -0.26172182f, 0.02811367f, 
    0.06704488f, -0.11593339f, -0.00243028f, 0.03863532f, -0.13358834f, 0.16244645f, -0.22085258f, 0.02723659f, 
    -0.05850644f, -0.01343100f, 0.01313705f, -0.00951969f, -0.09909396f, 0.01231424f, -0.02019924f, -0.16287315f, 
    -0.72531188f, -0.28815231f, -0.28448933f, -0.12818196f, -0.03307069f, -0.27333283f, 0.02545474f, 0.04643816f, 
    -0.00950497f, -0.00488857f, 0.00915179f, -0.01453907f, 0.02737291f, -0.19161040f, 0.08044385f, 0.17742449f, 
    0.14412685f, 0.15646660f, -0.18367009f, 0.17434737f, -0.03059142f, 0.00411130f, 0.01503474f, -0.02001026f, 
    -0.07893574f, 0.04986814f, 0.21057409f, 0.08836086f, 0.10143067f, -0.05653368f, 0.07311532f, -0.09135878f, 
    0.03129070f, 0.06103541f, 0.13471961f, -0.04711408f, -0.20451680f, -0.15917820f, -0.00108054f, 0.02085121f, 
    -0.07204179f, -0.00750470f, 0.03758954f, 0.01541200f, -0.08318851f, -0.07331398f, 0.04818504f, -0.03322095f, 
    -0.16166963f, -0.04444188f, 0.08323688f, 0.07150951f, -0.02388253f, -0.00190557f, -0.08176852f, 0.05491623f, 
    0.00197077f, 0.03007568f, -0.05011198f, 0.01594239f, 0.01970538f, 0.03116360f, 0.52760726f, 0.18212940f, 
    -0.06164602f, -0.05428072f, 0.10271923f, 0.04721614f, -0.00737498f, -0.09909707f, 0.03351241f, -0.05659709f, 
    -0.10249084f, 0.06170375f, 0.00542460f, 0.05862670f, 0.02604760f, -0.03049364f, -0.01026035f, 0.05397595f, 
    -0.05108162f, -0.08376233f, 0.08968331f, -0.03917947f, -0.14994684f, 0.18387945f, -0.05438618f, 0.02448384f, 
    0.02504050f, 0.00431497f, -0.07970230f, -0.06868475f, 0.16609675f, 0.08584922f, 0.09607514f, 0.27445304f, 
    -0.03093294f, 0.03027497f, 0.03162336f, -0.09653540f, 0.01872078f, -0.00733091f, -0.02426501f, -0.02362840f, 
    0.08179395f, 0.24318780f, 0.06860933f, 0.03110396f, -0.09781145f, -0.22961818f, -0.37038028f, 0.09414168f, 
    0.07942475f, -0.01670537f, 0.12792069f, 0.04996891f, 0.00768242f, 0.00565515f, 0.05052708f, 0.03734298f, 
    0.07245767f, -0.06288777f, 0.13863978f, 0.12810788f, -0.01282295f, -0.09245394f, -0.04422686f, 0.05976610f, 
    -0.05931832f, -0.02219975f, 0.04240787f, -0.06109475f, -0.02317258f, -0.05638013f, 0.00476677f, 0.04997271f, 
    -0.07403539f, -0.09988794f, -0.02018152f, -0.00353717f, 0.09015276f, 0.12279955f, 0.00456229f, 0.11293484f, 
    0.12661889f, -0.07612188f, -0.14365785f, -0.12632510f, -0.00303456f, -0.00386571f, 0.09825394f, 0.02931068f, 
    -0.01829338f, -0.01513262f, 0.02954169f, -0.01381475f, -0.17570627f, 0.06177139f, -0.10958376f, 0.07193422f, 
    0.03048355f, 0.01851193f, 0.00090036f, 0.02615992f, 0.01332314f, -0.05654339f, 0.07600037f, -0.05095742f, 
    -0.27811077f, 0.03905068f, 0.22360875f, -0.16884184f, -0.00893278f, -0.01963620f, -0.02389666f, 0.02775900f, 
    0.01706785f, -0.00577254f, 0.00825871f, -0.07881251f, -0.03124534f, 0.23260400f, 0.35900450f, -0.03614620f, 
    -0.02356166f, -0.02604323f, 0.01992729f, -0.03771321f, -0.15421122f, -0.20857163f, -0.12377348f, -0.00950113f, 
    -0.50229651f, -0.33750203f, -0.11752971f, -0.19985524f, -0.12065511f, -0.11649462f, -0.01618232f, 0.01665421f, 
    0.00492023f, 0.01305629f, 0.01408715f, -0.08950377f, 0.22219291f, -0.03409049f, 0.04290887f, -0.04118140f, 
    0.14191340f, -0.02811109f, -0.10163022f, 0.01527152f, 0.05291842f, 0.15536276f, 0.15102753f, 0.04053964f, 
    -0.08217627f, -0.03510484f, -0.03112615f, -0.14188665f, -0.08532406f, -0.00295846f, -0.03766412f, 0.00847623f, 
    0.09109857f, 0.02745653f, -0.02712581f, -0.08913086f, -0.23748827f, -0.05758425f, -0.01921034f, -0.24673197f, 
    0.02039511f, -0.01618927f, -0.02339342f, -0.00230115f, 0.02636252f, 0.07038093f, -0.12067688f, 0.00793826f, 
    -0.09821966f, -0.04977933f, 0.14152221f, -0.23236789f, -0.02682607f, -0.00943800f, -0.03103817f, 0.07556031f, 
    -0.00677247f, -0.04875645f, 0.02325524f, -0.00968037f, 0.09630800f, 0.03178202f, -0.18740091f, 0.09975303f, 
    -0.03099667f, -0.00659789f, 0.00269677f, 0.01210280f, -0.00179713f, -0.02740454f, 0.04459822f, -0.02779297f, 
    0.06421743f, -0.07612319f, -0.05397761f, 0.03965934f, 0.06034727f, 0.01848166f, -0.17706580f, -0.01378778f, 
    -0.00803595f, -0.04185697f, 0.00215137f, 0.00803502f, 0.05369819f, 0.05070149f, -0.00063641f, -0.10556183f, 
    0.00223652f, -0.03892585f, -0.13263188f, -0.15749931f, -0.03103057f, 0.07748612f, -0.06731991f, -0.05915320f, 
    -0.23603125f, 0.20358992f, -0.07082900f, -0.01989454f, 0.00505037f, -0.05693249f, -0.06350233f, -0.04217322f, 
    0.11435222f, 0.05110224f, 0.02940253f, 0.19922020f, -0.05610917f, 0.02315080f, -0.05740679f, 0.10423665f, 
    -0.04157817f, -0.02592769f, 0.02172980f, 0.04859147f, -0.07882518f, -0.01809091f, -0.07396787f, 0.04459967f, 
    0.22373864f, 0.03368605f, 0.07106776f, 0.12627070f, 0.02770498f, 0.01014350f, 0.02581869f, -0.03271540f, 
    -0.06161666f, 0.01549455f, 0.01271863f, 0.13965747f, 0.19674562f, 0.03154974f, 0.01150424f, 0.38764849f, 
    0.01118913f, -0.02175005f, 0.04094236f, 0.01181979f, 0.05283506f, 0.06788363f, 0.05299521f, 0.00993030f, 
    0.01498221f, 0.15817398f, -0.04705982f, 0.03704349f, 0.01021852f, 0.03115947f, -0.01437893f, 0.14723723f, 
    0.09688486f, 0.11575016f, 0.02886628f, -0.22643986f, -0.34116232f, -0.76137006f, 0.53571463f, 0.30717218f, 
    -0.06019851f, 0.02178397f, -0.10921613f, 0.06616747f, -0.03434882f, -0.03780197f, -0.01739253f, 0.02276972f, 
    0.30355555f, 0.12781039f, -0.06045144f, 0.01232889f, -0.00389937f, -0.04434568f, -0.07408964f, -0.01303208f, 
    -0.04299257f, 0.01578624f, 0.24336059f, 0.11649491f, -0.16774134f, -0.15001956f, 0.10540481f, -0.14178267f, 
    0.06243103f, -0.21545628f, -0.25019997f, -0.20189358f, 0.08106334f, -0.02286775f, -0.07512209f, 0.05200721f, 
    -0.35823873f, 0.40310764f, 0.39357406f, 0.23234650f, -0.08907815f, -0.01242373f, 0.18867585f, -0.06173236f, 
    -0.02971439f, -0.06153323f, 0.08286538f, -0.06893817f, -0.26664567f, -0.18044724f, 0.04312712f, -0.00589670f, 
    0.10507479f, -0.08183020f, -0.10294706f, -0.00585655f, 0.00399176f, 0.01826004f, -0.10422324f, 0.09128368f, 
    0.28457904f, -0.00316805f, -0.07195313f, 0.07196394f, 0.02475455f, 0.03791829f, 0.04452519f, -0.00711472f, 
    -0.00767977f, 0.12443673f, -0.02661762f, 0.05987372f, -0.13244045f, -0.07841291f, 0.19840142f, 0.06732116f, 
    0.03709387f, 0.02104530f, 0.03506958f, 0.12834662f, -0.00557762f, -0.07078164f, 0.06991249f, -0.01788896f, 
    -0.32438377f, 0.48534465f, -0.29098773f, -0.06906380f, -0.14311980f, 0.12867774f, 0.02681112f, -0.20244750f, 
    0.03403500f, 0.09355554f, -0.04635441f, 0.08832645f, 0.01888544f, -0.08229466f, 0.23161423f, -0.14351921f, 
    0.03083669f, 0.00125940f, 0.02128089f, 0.04296071f, 0.06196336f, -0.04494832f, 0.10236941f, -0.04749278f, 
    0.00541644f, -0.32874182f, -0.22434883f, 0.02981217f, 0.03451222f, -0.03231703f, 0.02040719f, -0.01901236f, 
    0.03412120f, -0.07194686f, -0.00244561f, -0.00235385f, 0.03355408f, -0.26900595f, -0.03377872f, -0.04792960f, 
    -0.04679935f, -0.10574942f, -0.08250640f, 0.02234699f, 0.05473079f, -0.00253137f, 0.03888229f, 0.06695050f, 
    0.20029655f, 0.03985122f, 0.23731305f, 0.14432114f, 0.02418754f, 0.08829682f, 0.09688848f, 0.00003916f, 
    0.02548507f, 0.04899973f, 0.06404681f, 0.07625621f, -0.00205349f, -0.02738556f, -0.03738911f, -0.00144955f, 
    -0.14195865f, 0.07569489f, 0.01125471f, 0.02269522f, -0.04278440f, 0.00839281f, 0.04170360f, -0.06613858f, 
    -0.05369363f, 0.02793617f, 0.14923780f, -0.06055563f, 0.02150543f, -0.08901838f, 0.04965990f, -0.07267772f, 
    0.12776043f, 0.02307002f, -0.00783166f, 0.22041070f, -0.00932926f, -0.09541965f, -0.02595339f, 0.06189885f, 
    0.04535257f, -0.11065088f, -0.00295277f, -0.03327774f, 0.03374381f, -0.08207557f, -0.15052456f, 0.23750499f, 
    -0.11958650f, 0.16569187f, -0.03544344f, -0.12651320f, 0.02512965f, -0.12684172f, 0.10128263f, 0.05481824f, 
    -0.03444759f, -0.01903786f, 0.02427827f, -0.01531338f, -0.20437129f, -0.45790192f, 0.07439651f, -0.16756152f, 
    0.13601878f, 0.08346277f, -0.15372853f, 0.12957089f, 0.03398646f, -0.07441162f, 0.07111393f, -0.12060916f, 
    -0.03434425f, -0.00558050f, -0.05659758f, 0.05506876f, -0.00844254f, 0.05428902f, -0.04942560f, 0.04370569f, 
    0.02521493f, -0.03214378f, 0.07647114f, -0.11507798f, 0.05824046f, -0.02621122f, 0.18894570f, 0.16756709f, 
    0.09434321f, -0.01718611f, 0.04033156f, 0.17635226f, 0.04646175f, 0.06003842f, -0.07938359f, -0.19831342f, 
    -0.15610316f, -0.19724455f, 0.38764945f, -0.28553075f, 0.03169986f, -0.16980858f, -0.29302412f, -0.08180606f, 
    0.02271785f, -0.05871523f, 0.04531940f, 0.00338183f, 0.18149874f, -0.08407422f, 0.04581440f, -0.10233006f, 
    -0.05383248f, 0.08674286f, -0.12398686f, -0.01517298f, 0.00659725f, 0.02217339f, -0.08003028f, 0.08523695f, 
    0.05916204f, 0.06188549f, -0.26931179f, -0.35470897f, 0.04364728f, -0.02806357f, -0.04930732f, -0.18862079f, 
    -0.05253008f, -0.01819349f, -0.07792918f, 0.02934155f, -0.11383473f, 0.08611729f, -0.04707652f, -0.08553460f, 
    0.11137778f, 0.04623342f, -0.22085007f, -0.03185363f, 0.07331138f, 0.04169078f, -0.10101288f, 0.17186353f, 
    0.07002439f, 0.02499007f, 0.09472369f, 0.05655387f, -0.00531975f, -0.02750024f, 0.03600092f, -0.02673917f, 
    0.02732810f, 0.04832291f, -0.24522477f, 0.14148600f, -0.00975217f, 0.13455489f, 0.22381543f, 0.25942254f, 
    -0.01086254f, -0.02721618f, 0.02146569f, 0.01571415f, -0.00145123f, -0.02623667f, -0.12445763f, 0.01762736f, 
    0.13810377f, 0.29320168f, -0.30935779f, 0.12430386f, 0.02941714f, 0.06085803f, -0.01905965f, 0.00851631f, 
    -0.22294727f, 0.09833420f, -0.03482240f, 0.02519510f, 0.05944884f, -0.07402507f, -0.02607989f, -0.11489682f, 
    -0.23932990f, -0.10818946f, -0.15709428f, -0.12012262f, -0.15006216f, -0.11922756f, -0.01581945f, -0.02071358f, 
    -0.16666459f, 0.11977955f, -0.01677298f, 0.27201623f, -0.09085529f, 0.15018867f, -0.25529262f, -0.10279806f, 
    -0.05633463f, -0.17807765f, 0.21325551f, -0.00744038f, 0.11588165f, -0.01361274f, 0.39883268f, 0.09515606f, 
    -0.33353430f, -0.10412526f, 0.04820561f, -0.02511296f, 0.07218669f, 0.17050354f, 0.07160428f, 0.09134157f, 
    -0.04770602f, -0.10568645f, 0.08057202f, 0.24504203f, 0.10074420f, 0.08302492f, 0.10865641f, 0.07466231f, 
    0.04125738f, -0.05020260f, -0.03019922f, -0.01815805f, -0.29831076f, -0.08535953f, 0.12768602f, -0.07129940f, 
    0.00000484f, -0.23622641f, -0.08249976f, -0.05982224f, -0.02598380f, -0.03194741f, -0.05937483f, -0.01766463f, 
    0.46124309f, -0.21056792f, 0.05479781f, 0.08399756f, 0.13161618f, 0.01444613f, 0.01318632f, 0.02473983f, 
    0.01079973f, -0.00538500f, -0.01482878f, 0.15807435f, 0.18588777f, 0.12567556f, -0.21821913f, -0.34404379f, 
    -0.04299036f, -0.01617235f, -0.13944758f, 0.02108649f, -0.14242692f, 0.04880759f, -0.00795242f, 0.03467010f, 
    0.03645980f, -0.00869080f, -0.06842856f, 0.03808175f, 0.12267173f, -0.03011338f, -0.04389158f, 0.11510147f, 
    -0.07150567f, -0.03181873f, -0.02451136f, -0.04482890f, -0.26395705f, 0.11061491f, -0.10297804f, 0.13455334f, 
    -0.17115955f, 0.00550174f, 0.05383981f, 0.00054956f, -0.09419288f, -0.06216862f, 0.04579589f, -0.01965988f, 
    -0.01533930f, -0.15664166f, -0.21510172f, 0.06146886f, 0.13813505f, 0.02745689f, -0.01635444f, -0.06305479f, 
    0.05685265f, -0.03614505f, -0.00550843f, 0.03877571f, 0.12227263f, -0.13191208f, 0.08364154f, 0.16004871f, 
    0.03072570f, -0.11160016f, -0.16861475f, -0.01976224f, 0.00241619f, -0.01710915f, -0.11118937f, 0.15449080f, 
    -0.09413408f, 0.68174654f, -0.26186723f, 0.04698581f, 0.16881080f, -0.05708761f, 0.06313276f, -0.06929142f, 
    -0.18995516f, -0.01638388f, -0.04759803f, -0.02448172f, -0.42307386f, -0.44193873f, -0.26417390f, -0.11129367f, 
    0.00962959f, 0.03421914f, -0.07561649f, -0.12282576f, 0.00355851f, -0.00321370f, -0.03508016f, 0.01390383f, 
    -0.29628038f, 0.04793208f, 0.04735043f, 0.00059624f, 0.01292554f, -0.15355515f, -0.03719800f, -0.03883247f, 
    -0.02330480f, 0.05946459f, -0.01185776f, 0.07920669f, -0.03618907f, -0.10099726f, 0.01131562f, 0.15435085f, 
    0.06238673f, 0.01095386f, 0.02860428f, -0.14082637f, 0.12827070f, 0.08064212f, 0.02738732f, 0.02433915f, 
    -0.55425340f, -0.02231072f, -0.02215392f, -0.10468840f, -0.03808032f, -0.10960654f, -0.08799373f, -0.05942299f, 
    -0.00132546f, -0.08384887f, 0.06346451f, -0.06363115f, -0.16958137f, -0.21987247f, -0.01808027f, 0.02617486f, 
    -0.25449392f, 0.06260087f, -0.15140954f, -0.00730459f, -0.09246016f, 0.11685620f, -0.03469869f, 0.08837725f, 
    -0.03328322f, 0.28456980f, -0.11395726f, 0.07929711f, 0.05970766f, 0.14012085f, -0.05722279f, 0.04083528f, 
    0.00570247f, 0.09506541f, 0.06411333f, -0.04656212f, 0.06742013f, 0.06955940f, -0.34682775f, -0.04900614f, 
    0.04645304f, 0.04650010f, 0.04027530f, 0.00906122f, -0.10926873f, -0.06095616f, -0.04293997f, -0.01270379f, 
    -0.45055398f, -0.00998208f, -0.37837827f, -0.01680306f, 0.13447197f, 0.02057034f, -0.03864173f, 0.03094135f, 
    -0.04853724f, -0.06523967f, -0.14229806f, -0.10971097f, 0.07547713f, -0.00219195f, -0.03091536f, 0.04084513f, 
    0.00192632f, -0.02128541f, 0.06701135f, -0.08082904f, 0.06493789f, 0.09615508f, 0.04069890f, 0.08777483f, 
    0.10428806f, 0.13433331f, -0.05873242f, 0.10191406f, -0.03014588f, -0.12789820f, -0.19027586f, -0.05642916f, 
    0.03732015f, 0.00696991f, 0.08533486f, -0.05149970f, -0.08985811f, 0.01069113f, -0.07998397f, 0.13415690f, 
    -0.02611080f, -0.08636577f, -0.05497225f, 0.07553656f, -0.09195359f, -0.04734812f, 0.01553516f, -0.07662170f, 
    -0.12568362f, -0.18675302f, 0.12179900f, 0.00615263f, 0.19121565f, 0.08416728f, 0.00056161f, -0.06457041f, 
    -0.05222697f, 0.07155307f, 0.25995421f, -0.04862009f, 0.04314720f, -0.12584114f, -0.03478894f, 0.18476346f, 
    0.15403712f, -0.05010279f, 0.13212475f, -0.07222570f, 0.00611370f, 0.04111898f, 0.01658533f, 0.02248271f, 
    -0.06076664f, 0.06185637f, -0.09434978f, 0.17220134f, -0.08234363f, 0.02159726f, -0.06192794f, 0.03365274f, 
    0.00919773f, -0.08718030f, -0.02055502f, 0.03130963f, -0.23228088f, 0.14348449f, -0.15579121f, 0.06354777f, 
    -0.00998009f, 0.12087863f, -0.07474558f, -0.15625548f, -0.09800711f, -0.18502241f, -0.02942193f, -0.02083087f, 
    -0.18693702f, 0.39361200f, -0.04569209f, 0.34793556f, 0.09535748f, -0.08044828f, 0.11875603f, -0.07826661f, 
    0.24111478f, -0.00720238f, -0.01705138f, 0.18772827f, -0.47937003f, 0.11490539f, 0.04855313f, 0.32710573f, 
    0.18729334f, -0.02150295f, 0.07603781f, 0.04783358f, -0.01376491f, 0.05171126f, -0.00197997f, -0.11110687f, 
    -0.52139509f, -0.18054609f, -0.18372278f, 0.00083893f, -0.08862271f, 0.07677139f, -0.29345715f, -0.09776610f, 
    -0.19358321f, 0.07354882f, 0.12513027f, -0.03477631f, -0.24918826f, 0.30311188f, -0.29490188f, -0.30018580f, 
    0.05529365f, -0.00443902f, -0.01345256f, -0.01017400f, 0.08936124f, -0.02222681f, -0.05998699f, -0.04200831f, 
    0.19499646f, 0.29070020f, 0.10078736f, -0.37905675f, -0.11717272f, -0.06425408f, 0.15614940f, -0.03421478f, 
    0.04150928f, -0.05514519f, 0.08227221f, -0.19264711f, 0.27211910f, -0.12563710f, 0.24556942f, 0.06213729f, 
    -0.24999318f, -0.00962698f, -0.11385215f, 0.16391814f, -0.05576845f, -0.02229197f, 0.11002550f, 0.09292565f, 
    -0.53340918f, -0.20368798f, 0.04005363f, 0.03853776f, -0.12332159f, 0.06157569f, -0.07569820f, 0.00304226f, 
    0.06913614f, 0.12351608f, -0.02284101f, 0.00705911f, -0.12303204f, 0.10541375f, -0.07197816f, -0.63939822f, 
    -0.21678321f, -0.00313428f, 0.03553115f, -0.09758372f, 0.10212573f, 0.03514194f, -0.08019317f, 0.03961133f, 
    0.73117012f, -0.04594737f, 0.04643467f, -0.02543193f, 0.14152206f, 0.04931435f, 0.05584710f, -0.15750603f, 
    -0.16819172f, -0.02539339f, 0.01339368f, -0.03725650f, -0.05604369f, -0.16199367f, -0.03331156f, 0.18619412f, 
    0.04004516f, -0.04276278f, 0.02653472f, -0.02725554f, -0.02527774f, 0.06488500f, -0.03099357f, 0.05936051f, 
    -0.01337111f, -0.23677072f, -0.18961836f, -0.04825891f, 0.08239364f, 0.02150558f, -0.05244700f, -0.08557210f, 
    0.01180501f, 0.09959874f, -0.07388539f, -0.14606090f, -0.10606047f, -0.03729456f, -0.10693437f, 0.12224360f, 
    0.06073489f, -0.00196384f, -0.04363436f, -0.08629176f, -0.06675981f, 0.08857898f, -0.06317853f, 0.13715947f, 
    0.32997730f, 0.20366639f, 0.17276238f, -0.01512281f, -0.19047497f, 0.14868765f, -0.02792581f, -0.09340051f, 
    0.06223229f, -0.02189908f, 0.10346509f, -0.09079097f, 0.03169994f, 0.00450354f, 0.39769572f, 0.01858085f, 
    -0.00454717f, 0.10857680f, -0.17521557f, 0.08686527f, -0.02747147f, -0.20106822f, 0.08409998f, -0.06064261f, 
    -0.23367132f, -0.24650852f, 0.07080315f, 0.25910854f, -0.07778403f, 0.08272233f, -0.07756996f, -0.04585415f, 
    0.11690153f, -0.06861407f, 0.15276200f, 0.02386753f, 0.09880099f, -0.06493812f, 0.07733822f, 0.13114125f, 
    -0.02490356f, -0.06292154f, 0.04282422f, 0.00506074f, 0.04202001f, 0.08197395f, 0.01132429f, 0.07534146f, 
    0.65866876f, 0.08671559f, -0.07036536f, -0.32269558f, -0.11117144f, 0.01070671f, -0.08727306f, -0.19923422f, 
    0.06969385f, -0.10620341f, -0.01868499f, 0.08627168f, -0.84149009f, 0.61293489f, -0.20840125f, -0.47286046f, 
    0.26485136f, 0.18411040f, 0.05111176f, -0.07439048f, -0.23669098f, -0.07710408f, 0.00665375f, -0.08707505f, 
    -0.23445432f, 0.07906102f, -0.06536663f, 0.17998911f, -0.06190202f, 0.05312908f, -0.14061609f, -0.02451074f, 
    -0.09423113f, 0.03582733f, 0.11237249f, -0.09117616f, -0.20686527f, 0.14569956f, 0.08179919f, -0.05248314f, 
    -0.32965055f, -0.13964388f, -0.08522802f, -0.09883929f, -0.01047652f, 0.10555997f, 0.02167094f, -0.10722081f, 
    0.30718082f, -0.17933966f, 0.00114137f, -0.34758779f, 0.18137150f, 0.13215595f, -0.04286363f, 0.17465556f, 
    -0.30896461f, 0.08176234f, 0.02324701f, 0.01705088f, 0.21751164f, 0.03111707f, -0.19006586f, -0.04178816f, 
    0.05227621f, 0.01906700f, -0.11957310f, 0.00076333f, 0.04991668f, 0.01021908f, 0.17430389f, -0.26160112f, 
    0.58703762f, -0.02382944f, 0.12500688f, 0.13883767f, 0.24195817f, 0.02435177f, 0.16666700f, 0.00005125f, 
    -0.15952435f, 0.10965691f, -0.10282747f, 0.13597527f, 0.11277742f, 0.04009582f, -0.13076903f, -0.16025546f, 
    -0.10109247f, -0.04788168f, -0.06647507f, -0.00988823f, -0.13476503f, 0.03140937f, -0.13374649f, -0.05452839f, 
    -0.20018964f, 0.28656092f, -0.08816291f, 0.12556824f, -0.06931061f, 0.03241822f, -0.00790257f, -0.04842350f, 
    0.06370799f, 0.15594569f, 0.07585505f, 0.02309221f, -0.19807328f, -0.19841592f, 0.00252402f, -0.21643604f, 
    -0.09463540f, -0.01141431f, -0.11553047f, -0.00145765f, -0.04816097f, -0.10767429f, -0.01761586f, -0.17958501f, 
    -0.12502365f, 0.36888483f, -0.03908155f, 0.41425294f, -0.09693218f, -0.06340554f, 0.13608280f, -0.01384285f, 
    -0.00520061f, 0.01706726f, -0.03520849f, 0.15052012f, 0.02142658f, -0.05377229f, -0.06989759f, -0.05078373f, 
    -0.04214998f, 0.15020657f, 0.04885127f, -0.05134467f, 0.07321101f, -0.09362397f, 0.16276814f, -0.15949091f, 
    0.26489723f, 0.13639930f, -0.04946411f, -0.08134505f, -0.15300477f, -0.13101138f, 0.01603039f, 0.12516811f, 
    -0.14269680f, 0.04590164f, -0.04226558f, 0.01029179f, -0.28364214f, 0.83716398f, -0.50115579f, -0.43945658f, 
    0.20884226f, -0.01277426f, -0.09995148f, -0.08870622f, -0.10395624f, -0.08000331f, -0.00501941f, -0.03678478f, 
    -0.36022687f, -0.33404598f, 0.64623970f, 0.04843769f, -0.22250561f, 0.14081423f, -0.24415259f, 0.03431080f, 
    0.12092535f, -0.01055439f, -0.00890937f, 0.05703381f, 0.23415066f, 0.19592723f, -0.14707369f, -0.50670332f, 
    -0.13779216f, 0.00117505f, 0.10423984f, -0.19067550f, 0.17645569f, 0.02512606f, -0.20359236f, 0.11234328f, 
    0.05746847f, 0.07458889f, 0.00960219f, 0.14272860f, 0.07935680f, -0.01778091f, -0.02584270f, -0.00210757f, 
    -0.02795639f, 0.14954273f, -0.00727733f, -0.02201612f, -0.56052256f, -0.21895948f, 0.11977032f, 0.04853089f, 
    -0.05727699f, 0.03520341f, 0.07403985f, -0.05384766f, -0.12243946f, 0.03716535f, -0.05415699f, 0.07929551f, 
    0.17254922f, 0.03830065f, -0.16738956f, 0.11666856f, -0.00475358f, -0.04071468f, -0.09445914f, -0.13228746f, 
    -0.05242360f, 0.14995231f, -0.06626751f, 0.14099577f, -0.18686223f, -0.08468184f, -0.11798265f, 0.07100125f, 
    0.19429225f, 0.04260281f, -0.00981531f, 0.10448139f, 0.01953138f, 0.04513450f, -0.09685600f, -0.00536714f, 
    -0.11947931f, -0.37913981f, 0.05600360f, -0.13677543f, -0.02880878f, 0.01594768f, -0.11872070f, 0.00252106f, 
    0.20408560f, -0.06771689f, 0.16798079f, 0.21402723f, 0.00730546f, 0.02687243f, -0.09047619f, 0.10263032f, 
    -0.08896267f, 0.07656277f, 0.03321314f, 0.00639468f, 0.01835551f, -0.08648393f, -0.15763979f, -0.10263780f, 
    -0.19170885f, -0.02906985f, 0.04000268f, 0.03698684f, 0.03025565f, -0.05637991f, 0.09391566f, 0.00743438f, 
    -0.02287348f, -0.02243028f, -0.08447073f, -0.01020753f, 0.18671861f, 0.20619020f, -0.20498218f, 0.23518322f, 
    0.08261486f, 0.08934490f, -0.05837885f, -0.01386854f, 0.04412884f, 0.01557999f, -0.08688544f, -0.03586268f, 
    0.02608554f, 0.25328839f, 0.22541530f, 0.19165629f, 0.04054844f, 0.05989321f, -0.05151709f, 0.13447896f, 
    -0.00624014f, -0.03845156f, 0.06293242f, -0.05633504f, -0.10388606f, -0.08859717f, -0.15816468f, -0.01566209f, 
    0.05817609f, 0.05239270f, -0.01298811f, 0.01716611f, 0.02464131f, 0.04828642f, 0.08469288f, -0.00541886f, 
    -0.12269323f, 0.12265781f, 0.07391164f, 0.18892752f, -0.10135666f, -0.18827951f, 0.01897488f, 0.01233285f, 
    0.06286646f, -0.03083059f, 0.02521873f, 0.06500066f, 0.06419933f, -0.22296073f, 0.01094459f, 0.02356166f, 
    -0.07971925f, -0.01634465f, -0.14295493f, -0.08952260f, -0.15679657f, -0.03940003f, -0.02436092f, -0.05699643f, 
    0.09067427f, 0.15545891f, 0.22730051f, 0.15409938f, -0.02834900f, -0.05197958f, -0.03460805f, -0.14659673f, 
    -0.19435865f, 0.17172439f, 0.04233729f, -0.03342371f, -0.02597058f, -0.02599938f, 0.15202272f, 0.01542343f, 
    0.04717179f, 0.01521679f, -0.03816845f, 0.00773079f, 0.05080786f, 0.04892597f, 0.01697388f, 0.15895028f, 
    0.02897285f, -0.00695348f, 0.22540444f, 0.07914493f, -0.15908712f, -0.13185877f, -0.10206722f, 0.14059187f, 
    0.06875364f, 0.07895841f, -0.00407229f, 0.00423111f, -0.05646817f, 0.01358540f, -0.08146592f, 0.13366486f, 
    -0.02164810f, -0.13400777f, 0.00630340f, -0.36561254f, 0.02122379f, 0.04981627f, 0.04537165f, -0.07040539f, 
    -0.09016076f, -0.27561054f, -0.01862581f, -0.10027083f, -0.08206133f, 0.05994025f, -0.11804512f, 0.05448097f, 
    -0.14254217f, 0.01425362f, -0.08175183f, -0.36149049f, 0.03096477f, 0.04045691f, -0.02171714f, -0.01667420f, 
    0.09448292f, 0.06907623f, 0.09493495f, 0.07388965f, 0.09140271f, 0.02249541f, -0.01491780f, 0.02733556f, 
    0.00175631f, -0.03367329f, -0.01345510f, 0.09807187f, -0.02634391f, 0.02671406f, 0.03161703f, -0.03845348f, 
    -0.01487931f, 0.01312581f, 0.04182734f, 0.07762063f, -0.00118574f, 0.07822138f, 0.00751779f, 0.17710666f, 
    0.00837745f, -0.15955260f, 0.02928510f, -0.08113782f, -0.04660034f, -0.00354226f, 0.02469357f, 0.06074155f, 
    0.03901060f, -0.02555902f, -0.07213356f, 0.00116187f, 0.05048749f, 0.03648526f, -0.05517968f, 0.05206287f, 
    -0.03973269f, 0.01389015f, -0.08415673f, -0.02620046f, 0.03450551f, -0.06699365f, -0.09460303f, 0.06522131f, 
    -0.02519246f, 0.06976079f, -0.10866083f, -0.12713017f, 0.02275106f, 0.00031076f, 0.01232843f, 0.23199990f, 
    -0.21746826f, -0.05889256f, -0.16751248f, -0.07422779f, 0.04665192f, -0.01413447f, -0.01578505f, -0.01742536f, 
    0.09944608f, 0.06857230f, -0.00178844f, 0.30801865f, 0.06636564f, -0.03709796f, 0.25380343f, 0.15838671f, 
    -0.22380993f, -0.08715314f, -0.20531750f, -0.05803261f, 0.00641296f, 0.00159717f, -0.00168256f, 0.05770975f, 
    0.12485907f, 0.00778783f, 0.07396175f, 0.08621801f, -0.01471294f, 0.00498344f, 0.02703588f, 0.05166999f, 
    0.20494767f, -0.01399814f, 0.06483319f, 0.07913935f, -0.00657684f, 0.02665300f, 0.06844312f, 0.06305963f, 
    0.03557154f, -0.04324465f, -0.02513440f, 0.04540742f, 0.24751845f, 0.16182072f, 0.05693890f, 0.18796183f, 
    -0.03556992f, 0.01620714f, 0.12344265f, -0.12152515f, -0.00929356f, 0.06851747f, 0.00121000f, 0.09169505f, 
    0.01744464f, -0.04307968f, -0.05992132f, -0.09175199f, 0.02946866f, 0.00132265f, 0.13421202f, -0.03304747f, 
    -0.06843465f, 0.08465029f, 0.01279312f, -0.08826986f, -0.03543033f, -0.08031760f, -0.05955454f, 0.01536002f, 
    -0.29810202f, -0.25437021f, -0.34748006f, 0.20337157f, 0.09972741f, 0.00037467f, 0.00157687f, 0.05937376f, 
    -0.14751774f, -0.13270926f, 0.06160163f, -0.02092423f, 0.20120829f, 0.31863317f, 0.07098027f, 0.20038244f, 
    -0.00773825f, -0.09159276f, 0.00415566f, -0.14953095f, -0.10780354f, -0.19396673f, -0.00063865f, -0.01139770f, 
    -0.13403559f, 0.09721602f, 0.14061229f, 0.17057812f, -0.01648325f, 0.05949337f, -0.10492180f, 0.00670238f, 
    0.07939817f, -0.03168932f, -0.02831414f, 0.01926119f, 0.12869437f, -0.04276323f, -0.13761459f, 0.09406327f, 
    0.02965487f, -0.22430259f, -0.00518680f, 0.02540137f, -0.18461719f, -0.01878908f, -0.19874318f, -0.03531826f, 
    0.11161413f, -0.09694239f, 0.15286550f, 0.03966537f, -0.08220671f, 0.07245527f, -0.10878927f, -0.17485377f, 
    -0.22138309f, -0.12398226f, -0.04410081f, 0.02129336f, -0.35441998f, 0.41637421f, -0.47788766f, -0.45026216f, 
    0.09195330f, -0.00166766f, 0.01068926f, -0.00521620f, -0.00826734f, 0.02760904f, -0.02799324f, -0.02909135f, 
    0.06101682f, -0.05785142f, -0.02712319f, 0.03556328f, 0.06621839f, -0.02273561f, 0.11673481f, 0.04414305f, 
    0.05384620f, -0.02165986f, 0.01841852f, -0.05647986f, -0.32140777f, -0.34350374f, -0.05391445f, -0.26812261f, 
    0.03297359f, -0.00649355f, 0.02805624f, 0.02294404f, -0.06219178f, -0.06478997f, -0.03104325f, -0.17253020f, 
    0.04270118f, -0.13182849f, -0.06184736f, 0.18206117f, -0.02461206f, 0.14381093f, -0.24056795f, -0.14551178f, 
    0.19571459f, -0.09454036f, 0.02797839f, -0.03477832f, 0.04544617f, 0.15888692f, -0.17176633f, -0.03487005f, 
    0.07432567f, -0.02755109f, 0.00281445f, -0.21428771f, -0.04003548f, 0.04958656f, 0.05744256f, 0.24108213f, 
    0.02690550f, -0.02337392f, 0.00661795f, 0.06473257f, 0.03782221f, 0.00121007f, -0.07371093f, 0.04174864f, 
    0.09609052f, 0.06854407f, -0.07712674f, 0.14477234f, -0.09172926f, -0.04828738f, -0.00893405f, 0.00284036f, 
    -0.01219355f, 0.03691478f, -0.05214408f, 0.00800800f, 0.03076921f, 0.05251003f, -0.01868099f, 0.00409008f, 
    -0.08861762f, -0.22948745f, -0.20459171f, 0.04026021f, -0.10188839f, -0.05012950f, -0.00223709f, -0.02061861f, 
    0.10127199f, -0.05214805f, 0.06299912f, 0.13088746f, 0.10012159f, 0.09517960f, 0.07753825f, 0.13453270f, 
    0.00468119f, -0.10887444f, -0.02058684f, -0.00180196f, 0.01117265f, 0.04696559f, -0.01398906f, 0.04681760f, 
    -0.00149559f, -0.23733662f, 0.03627782f, -0.02153663f, -0.07881380f, -0.06028030f, -0.10578209f, 0.07097149f, 
    -0.18031067f, -0.06786576f, -0.18577151f, -0.00802291f, -0.05983946f, -0.02558337f, -0.03051451f, 0.03895544f, 
    -0.09843452f, -0.01772060f, 0.02948179f, -0.01516507f, -0.00227250f, 0.01333820f, 0.05246978f, 0.08013988f, 
    0.33964267f, -0.27298927f, -0.18772197f, -0.17096126f, 0.07844280f, -0.07554327f, 0.03843229f, -0.07664121f, 
    -0.08712618f, 0.01226375f, -0.02299748f, 0.11938950f, -0.05910438f, 0.26034600f, -0.19667099f, 0.20767105f, 
    0.09805579f, 0.05231841f, 0.03287374f, -0.03678529f, 0.04041418f, 0.06510778f, -0.05843429f, -0.11981478f, 
    -0.20399146f, 0.14341441f, 0.01753850f, 0.06543443f, -0.07084810f, -0.12507580f, 0.07517026f, 0.05820519f, 
    -0.07677481f, 0.05535230f, -0.13423985f, 0.25251859f, -0.12114175f, 0.20896931f, -0.02084910f, 0.12276664f, 
    0.10016524f, 0.08094222f, 0.06260275f, -0.09318661f, -0.17566477f, -0.15656722f, -0.11746899f, -0.16144353f, 
    -0.36831972f, -0.10462571f, -0.01427445f, -0.04101462f, 0.05707204f, -0.11821443f, -0.00449078f, -0.07529677f, 
    -0.15230992f, -0.21518873f, -0.17398795f, -0.00521691f, 0.11981109f, -0.53745103f, -0.01967359f, 0.07589579f, 
    -0.13589652f, -0.06354140f, 0.08015714f, -0.07672367f, -0.14001592f, 0.09468421f, -0.16092594f, 0.01911712f, 
    -0.03688214f, -0.10752554f, 0.19797184f, 0.11720087f, -0.08180311f, -0.09403677f, -0.10373865f, 0.06440121f, 
    -0.04168243f, -0.19119625f, -0.00745722f, -0.02386571f, 0.09851697f, -0.14782353f, -0.22500682f, 0.01592982f, 
    0.02000259f, -0.00545463f, 0.05671217f, 0.06667727f, 0.08462366f, -0.02653096f, -0.02473753f, -0.08787144f, 
    0.19393900f, 0.00939843f, 0.07252323f, -0.14296204f, 0.06211041f, 0.02269875f, 0.05811513f, 0.10854590f, 
    0.10906903f, 0.03382429f, -0.15653040f, -0.12338370f, -0.12197767f, -0.00136597f, -0.07077862f, 0.18247925f, 
    0.07251205f, -0.00965653f, 0.04141821f, -0.19656822f, 0.07347844f, -0.03993221f, -0.09721079f, -0.05694913f, 
    0.09615401f, 0.05951354f, -0.03168132f, -0.04261438f, -0.02164890f, -0.15415530f, -0.01151225f, 0.03262834f, 
    0.01852072f, -0.08983327f, 0.04400850f, -0.08837440f, 0.02392566f, -0.00972020f, 0.02001517f, 0.02059860f, 
    -0.09253369f, 0.02801930f, 0.00596694f, -0.04739611f, -0.07794704f, -0.02890422f, -0.06415567f, -0.07811481f, 
    0.00490118f, -0.01262532f, -0.10296172f, -0.04907107f, 0.04043644f, -0.06680815f, -0.00760830f, 0.03703481f, 
    0.23279677f, 0.07297318f, -0.10270292f, 0.24691004f, 0.05691782f, -0.08959921f, -0.07687099f, -0.07366905f, 
    -0.06945436f, 0.09521849f, 0.00822841f, -0.03083783f, 0.08438774f, -0.10355122f, -0.11802052f, -0.09969069f, 
    0.11351466f, 0.09585016f, 0.16976428f, 0.20926329f, -0.12821156f, 0.11781391f, 0.02782392f, 0.00895029f, 
    -0.04375734f, -0.01425568f, -0.02994902f, -0.06069203f, -0.17000516f, 0.10511392f, 0.11300368f, 0.28693274f, 
    -0.11078691f, 0.00254059f, -0.23714955f, 0.04946340f, 0.02561323f, 0.05519295f, -0.11829827f, -0.09149384f, 
    -0.03380170f, 0.01083803f, -0.06636101f, -0.04145855f, 0.02498844f, 0.05896426f, -0.01305149f, -0.11748741f, 
    -0.02178638f, 0.04820964f, -0.12575909f, 0.09167945f, 0.00380240f, -0.63172346f, 0.04300649f, 0.05270982f, 
    -0.02387335f, 0.12172934f, -0.22464268f, -0.08696414f, -0.13676402f, 0.09031497f, -0.04850335f, -0.06925413f, 
    0.22697908f, 0.07528730f, -0.13187496f, 0.33718935f, 0.09960204f, 0.04892252f, 0.11629456f, -0.23641557f, 
    0.09575074f, -0.01284410f, 0.00991914f, -0.07379297f, 0.09868904f, -0.14375487f, -0.18390420f, 0.51138735f, 
    -0.01254235f, -0.13933533f, -0.09164193f, -0.20824528f, -0.02128608f, -0.09676883f, 0.02649850f, -0.01220216f, 
    0.05540067f, 0.07224621f, 0.12670331f, 0.18777245f, -0.00436363f, -0.05387147f, 0.03276068f, -0.06189887f, 
    -0.00079456f, -0.01623581f, 0.03364400f, -0.04127854f, -0.06078133f, 0.02728237f, -0.05555163f, 0.08738626f, 
    0.08203915f, -0.01659057f, -0.04688862f, -0.10332090f, 0.04503585f, 0.03006121f, -0.09971650f, -0.08743636f, 
    0.00429569f, 0.05935812f, -0.06381337f, -0.26642865f, 0.03789861f, -0.00971070f, -0.00943458f, -0.06674641f, 
    -0.17237440f, -0.36448374f, -0.05330185f, -0.16681524f, 0.29150787f, 0.05054780f, 0.13590430f, 0.11211264f, 
    0.01850694f, 0.01615376f, -0.06253725f, 0.04089916f, 0.10336504f, -0.07102093f, 0.06907762f, -0.03018412f, 
    -0.09989375f, 0.34861335f, 0.29071966f, -0.14487575f, -0.04241247f, -0.06365307f, 0.08551662f, -0.03251211f, 
    -0.03283790f, -0.24399929f, -0.04794624f, -0.55034369f, -0.07272646f, 0.04015581f, 0.00420484f, -0.07083230f, 
    0.08037341f, 0.11273136f, -0.07972139f, 0.02005025f, 0.10188170f, -0.05457442f, 0.15688366f, 0.06487124f, 
    0.08285073f, -0.22135940f, -0.13492288f, 0.10087588f, -0.01422655f, -0.10545979f, 0.01832908f, 0.04230602f, 
    0.19913231f, -0.03272780f, 0.06537440f, 0.07901117f, -0.06595889f, -0.02826224f, -0.28233254f, 0.06187303f, 
    0.04887695f, 0.07650670f, -0.00158878f, 0.02664998f, -0.04092659f, -0.03320444f, 0.11015020f, -0.06680312f, 
    0.06161106f, 0.16392387f, 0.01934201f, -0.14061762f, 0.07826951f, 0.09609260f, 0.07168057f, -0.19810750f, 
    0.01976074f, 0.00589904f, 0.03021595f, 0.02907999f, 0.02938904f, -0.00336790f, -0.17522627f, 0.13383138f, 
    -0.02537146f, 0.00909339f, -0.01203309f, -0.01343754f, -0.02102480f, 0.00471016f, 0.25257996f, 0.18540335f, 
    -0.44876310f, -0.28928047f, -0.19444945f, -0.17591333f, 0.06041471f, -0.08486453f, 0.07654165f, 0.05615012f, 
    0.05426686f, -0.08760074f, 0.03435509f, -0.05001804f, 0.04953348f, -0.16059476f, 0.15866055f, 0.13925301f, 
    -0.11017573f, -0.09702347f, 0.03789379f, 0.03599796f, 0.19610462f, -0.02240014f, -0.01033337f, 0.04912859f, 
    0.50499499f, -0.04727640f, 0.11356872f, 0.23006512f, -0.01181662f, 0.09220140f, 0.02732886f, -0.04724344f, 
    0.05474152f, -0.31095019f, -0.07865621f, -0.02074533f, 0.18087162f, -0.04121579f, 0.34980240f, 0.19612049f, 
    0.05783204f, -0.06386285f, 0.06077185f, -0.02175644f, 0.08321167f, 0.01037259f, -0.15124676f, -0.14898746f, 
    -0.01609484f, 0.02599597f, 0.12346724f, -0.20399834f, 0.31806600f, 0.18022443f, 0.16113497f, 0.06633727f, 
    0.04718557f, 0.00805883f, -0.00332761f, 0.00499326f, -0.18069661f, 0.04432454f, 0.03105548f, -0.15268983f, 
    0.10864416f, -0.04180961f, 0.07710401f, 0.15472947f, 0.03356012f, 0.05223086f, 0.06534573f, 0.06372365f, 
    0.03682080f, 0.06610627f, -0.13262637f, -0.27268368f, -0.09458297f, 0.05124886f, -0.01394601f, 0.04408029f, 
    -0.06118001f, -0.14183304f, 0.03037051f, 0.15058923f, -0.08616335f, -0.06609861f, -0.00689143f, 0.04529851f, 
    -0.03869262f, 0.01088477f, -0.04019417f, -0.04941258f, -0.05026289f, -0.04864865f, -0.01025273f, 0.00304090f, 
    -0.11942837f, 0.04975831f, -0.02961001f, 0.02920844f, 0.07464862f, -0.03806307f, 0.05143480f, -0.03654065f, 
    0.00819382f, -0.14286843f, -0.06016974f, 0.08995756f, -0.27664608f, 0.18262820f, -0.04588602f, -0.16821033f, 
    0.00663931f, 0.15459421f, -0.10602747f, -0.02747992f, 0.03787117f, -0.03442342f, -0.04484506f, -0.07868060f, 
    -0.07324390f, 0.03462576f, 0.15823416f, -0.06505913f, 0.08375455f, 0.00050893f, 0.07439338f, -0.04664410f, 
    0.23548721f, 0.03860242f, -0.21143429f, 0.21510659f, 0.18966623f, -0.16369177f, -0.02312030f, 0.08030769f, 
    0.10135122f, -0.02804443f, 0.02079906f, 0.12227140f, -0.08353157f, -0.04196083f, -0.00129557f, -0.30098397f, 
    0.02070961f, -0.16150284f, -0.06157412f, -0.14223765f, 0.05398015f, 0.00774785f, 0.10689963f, 0.01968817f, 
    -0.08321353f, -0.13212799f, -0.26819217f, -0.42372257f, 0.21041788f, 0.07161249f, 0.34713382f, -0.05624680f, 
    0.28354648f, -0.02181287f, 0.06195989f, 0.02466834f, 0.15618597f, -0.06443832f, -0.05311450f, -0.03701340f, 
    0.00718102f, 0.03393285f, -0.10143794f, -0.30397227f, -0.00731790f, 0.01985005f, 0.02807727f, 0.00819806f, 
    0.14453927f, 0.17329903f, -0.24971691f, -0.04012530f, -0.12556730f, 0.08396180f, 0.04709550f, -0.05309386f, 
    -0.01526235f, 0.02739727f, 0.00251002f, 0.09985604f, 0.03224763f, -0.22183160f, -0.08506305f, -0.31401965f, 
    -0.01183926f, -0.07198958f, -0.17502682f, 0.09616648f, 0.09708209f, 0.01029626f, -0.08739933f, -0.02328245f, 
    0.06930876f, 0.04753995f, 0.02981324f, 0.05610864f, 0.20592336f, 0.10789168f, 0.33243024f, 0.01768156f, 
    0.00935108f, 0.07948043f, 0.02056972f, 0.22343488f, 0.01818703f, 0.07443371f, 0.00265126f, 0.15181810f, 
    0.22390334f, -0.17962454f, -0.32676095f, -0.48879772f, -0.01913012f, -0.00604471f, -0.01301145f, -0.00334355f, 
    0.16234656f, -0.01151646f, -0.11096337f, 0.24581933f, -0.29110202f, -0.03254807f, -0.20537776f, -0.33861229f, 
    -0.02375679f, 0.11449521f, -0.15100878f, -0.14908849f, 0.22929901f, 0.11104872f, 0.10909161f, -0.10476955f, 
    0.13653143f, 0.15947367f, -0.07693122f, 0.17402242f, 0.18164779f, 0.04451730f, 0.05827479f, 0.13652779f, 
    -0.01884988f, 0.07978859f, 0.01164230f, 0.06578407f, -0.16032638f, -0.02149028f, 0.05170447f, -0.11258361f, 
    -0.01232997f, 0.10526815f, 0.08401497f, 0.05060438f, 0.22235832f, 0.24420135f, 0.07697968f, -0.18627203f, 
    0.01589005f, 0.02466649f, 0.08302011f, -0.23187505f, -0.05650828f, -0.07357462f, 0.03873447f, 0.15933524f, 
    -0.12280754f, 0.12938926f, -0.05385951f, -0.10383672f, -0.15210776f, -0.12993817f, -0.39339897f, -0.20372625f, 
    0.03600124f, 0.04176464f, -0.04779997f, 0.05444251f, 0.00983355f, -0.07047471f, 0.05495042f, 0.00221874f, 
    0.14368343f, 0.04293386f, -0.20869000f, 0.10091469f, -0.00027217f, -0.03421012f, -0.05960105f, 0.04385632f, 
    0.12709443f, -0.06422088f, 0.01398054f, -0.01716463f, 0.05586838f, -0.26545402f, 0.05064989f, 0.12646282f, 
    0.00851771f, -0.03080592f, 0.00039950f, 0.01355766f, 0.03926504f, 0.04376727f, 0.10780007f, 0.10140185f, 
    -0.10978907f, 0.13664035f, -0.15948963f, 0.26291898f, 0.01085241f, -0.12614994f, -0.13117543f, -0.00191524f, 
    -0.16877572f, 0.13367695f, -0.08270496f, 0.04048489f, 0.02067423f, 0.07466324f, -0.17570385f, -0.01069536f, 
    -0.03007718f, -0.04481318f, 0.03461712f, 0.14860725f, 0.18007907f, -0.20476136f, -0.01058247f, -0.24991445f, 
    0.06760852f, -0.10755717f, -0.19710119f, 0.03270871f, 0.00212391f, 0.08759142f, 0.05819176f, -0.00589429f, 
    -0.00401199f, -0.20638932f, 0.08522531f, -0.17430769f, -0.02356906f, -0.19747844f, 0.05233370f, 0.18556301f, 
    -0.01437234f, -0.01144436f, 0.02153195f, 0.05634550f, -0.23918009f, -0.12191644f, 0.04352528f, -0.14997719f, 
    -0.60232908f, 0.18426408f, 0.00097064f, -0.06312065f, -0.02985420f, -0.07584858f, 0.02693581f, 0.12260616f, 
    0.05484509f, -0.13290365f, -0.04533045f, 0.03801711f, -0.11674042f, 0.04789420f, 0.04553787f, -0.25665891f, 
    0.03799154f, 0.03694392f, -0.01353709f, 0.09075637f, -0.03601794f, -0.07359035f, -0.03798833f, -0.07575300f, 
    0.27876297f, 0.01655613f, -0.26801869f, 0.18881878f, -0.07320748f, 0.13553987f, -0.11681378f, 0.06403822f, 
    -0.03906720f, 0.07610194f, 0.03807141f, 0.11950979f, -0.37922090f, 0.03470863f, 0.14299212f, -0.28013998f, 
    -0.01738165f, 0.03649947f, -0.14830956f, 0.01584923f, -0.00154625f, -0.01626173f, -0.05912211f, 0.03126499f, 
    -0.41476321f, 0.03252414f, -0.14221036f, 0.18126869f, 0.09380729f, 0.09617632f, 0.02424153f, -0.05152194f, 
    -0.14940147f, 0.08351579f, -0.13614310f, -0.26161763f, -0.23073475f, 0.30591604f, -0.52374262f, 0.09891962f, 
    0.10734408f, -0.16712941f, 0.13173649f, 0.07822903f, -0.08929247f, 0.01040792f, -0.00448801f, 0.07526910f, 
    0.18365619f, -0.20283927f, -0.18364346f, -0.25762767f, 0.00844367f, -0.12383287f, -0.14340071f, 0.23419982f, 
    -0.11470237f, 0.01218702f, -0.18541570f, -0.12701885f, 0.10411247f, -0.14212590f, 0.25034630f, 0.01343871f, 
    -0.03221393f, -0.02080181f, 0.00518927f, 0.01083459f, 0.08861833f, 0.07171266f, -0.02436866f, 0.05874291f, 
    -0.27237830f, -0.32131523f, 0.01003860f, 0.24176635f, -0.07227512f, -0.07507000f, 0.09109071f, 0.19641513f, 
    0.05070346f, 0.05813270f, -0.21760453f, 0.07498779f, -0.68490845f, -0.37398702f, 0.11549962f, 0.07604586f, 
    -0.02619438f, -0.00932224f, -0.08019032f, 0.00679003f, 0.10334989f, 0.04312067f, 0.05447615f, 0.13510117f, 
    0.30193886f, -0.17130357f, 0.10912726f, 0.18860908f, -0.02555471f, 0.02867091f, -0.09749255f, 0.25496137f, 
    0.12112315f, -0.01038299f, -0.11520582f, 0.05178339f, 0.02758886f, -0.00101042f, -0.43322793f, 0.22690551f, 
    0.10140276f, -0.05086704f, -0.17510299f, 0.06034770f, -0.08826211f, 0.11301772f, -0.15496042f, 0.02355193f, 
    -0.13489345f, 0.21781051f, -0.19971202f, 0.32490557f, 0.05186608f, 0.00213418f, -0.05135641f, -0.07194206f, 
    -0.03592890f, -0.16979665f, 0.16481073f, -0.03647896f, -0.27134678f, 0.11809309f, -0.14728753f, 0.07564372f, 
    0.04747244f, -0.13477302f, -0.04253413f, 0.10700059f, -0.04651451f, -0.00229248f, -0.02908872f, 0.17776376f, 
    -0.31086132f, -0.16122741f, -0.34114999f, -0.13619204f, 0.06114366f, -0.02036676f, -0.19144778f, -0.06253453f, 
    0.18954915f, -0.08385577f, -0.02960449f, -0.04338104f, 0.07484155f, -0.07552885f, 0.07532563f, 0.02629337f, 
    0.10972730f, 0.02902145f, -0.01564426f, 0.11052374f, 0.12970163f, 0.02873441f, 0.07437462f, 0.02271381f, 
    -0.02532780f, -0.01666675f, -0.09020754f, -0.15316561f, 0.00035452f, 0.09547584f, 0.10081795f, 0.04143192f, 
    -0.07075459f, -0.26886350f, -0.22582732f, -0.52978504f, -0.15742934f, -0.02984322f, 0.12739585f, 0.05278366f, 
    0.09427854f, -0.03078016f, 0.10140705f, -0.06665894f, -0.02612128f, 0.09400968f, 0.07869795f, 0.31169337f, 
    -0.16355117f, -0.08558815f, -0.11431573f, -0.10594176f, -0.05789655f, 0.10547932f, 0.02627245f, 0.03170937f, 
    0.08702037f, -0.12275590f, 0.02231693f, -0.02123206f, 0.11131094f, 0.05870975f, 0.03100933f, 0.04807651f, 
    0.02412977f, 0.02953357f, 0.13186568f, -0.08906560f, -0.04661489f, 0.12836513f, 0.01629883f, 0.24544457f, 
    -0.01556017f, -0.16379766f, 0.03835135f, -0.05131356f, -0.05754980f, -0.00429023f, -0.07477384f, -0.06957524f, 
    -0.01765713f, -0.13011079f, 0.28776503f, 0.09706194f, -0.02821515f, 0.21076678f, -0.03719239f, -0.18674155f, 
    -0.18368927f, -0.13804132f, 0.00811342f, 0.08379626f, -0.01630215f, -0.06508382f, -0.13705681f, 0.10655552f, 
    -0.14407606f, -0.05963743f, -0.21429597f, 0.10296571f, 0.13277133f, -0.03795251f, 0.01252902f, 0.06490733f, 
    -0.03892362f, 0.02852173f, -0.04815753f, -0.08141062f, -0.17949568f, -0.12488935f, 0.18086228f, 0.20222820f, 
    -0.05743497f, -0.17367692f, -0.02575770f, 0.19326286f, -0.01551971f, 0.06963068f, 0.05848490f, -0.13279028f, 
    0.05195162f, 0.14643627f, 0.00681774f, 0.08173710f, -0.05952888f, 0.06542417f, -0.04106614f, -0.09703919f, 
    -0.01911257f, -0.00917021f, 0.08722667f, 0.00586130f, -0.03380299f, 0.23225045f, -0.08323499f, -0.20506126f, 
    0.01081325f, 0.04463658f, 0.09074232f, 0.07988080f, 0.13998850f, -0.03321507f, 0.04798816f, -0.05017661f, 
    -0.02499071f, -0.00951833f, -0.17055357f, 0.09531257f, -0.08528504f, 0.02627741f, -0.04090585f, 0.02689742f, 
    0.19152878f, 0.00551548f, 0.27012047f, 0.07199611f, -0.41465884f, -0.03033157f, -0.05693949f, -0.16924652f, 
    -0.03648460f, -0.01294969f, -0.02606297f, 0.01690800f, -0.01071817f, -0.08853653f, 0.08169695f, 0.02888175f, 
    0.04646625f, -0.12321711f, -0.04330699f, -0.18575779f, -0.07202543f, 0.01342055f, 0.04355473f, -0.03651935f, 
    -0.01851027f, 0.21419294f, 0.05848184f, 0.21771803f, 0.08185402f, -0.01379560f, -0.07863701f, -0.03405150f, 
    -0.07201615f, 0.08078334f, -0.04595986f, 0.11066155f, -0.03355613f, 0.05013623f, -0.00044694f, -0.14910896f, 
    0.39616838f, 0.11566639f, -0.15700279f, 0.11490256f, -0.09637055f, -0.11483885f, 0.22787681f, 0.13330039f, 
    -0.00823781f, 0.03875377f, -0.17199406f, 0.00250773f, 0.01854205f, -0.20816211f, 0.13427623f, -0.14416473f, 
    -0.02376430f, 0.11209385f, 0.09875982f, -0.11560790f, -0.00962414f, -0.02473180f, -0.01838383f, 0.05843730f, 
    -0.67177570f, -0.70110339f, 0.03065583f, -0.31973121f, -0.12540500f, -0.12391652f, -0.18586351f, -0.28856751f, 
    -0.00548531f, -0.06414600f, -0.02241700f, -0.08395546f, -0.03851777f, -0.04154176f, 0.02948984f, -0.11108885f, 
    0.05235257f, 0.05085496f, -0.00581495f, 0.03987711f, -0.06668983f, -0.06135678f, -0.12920225f, -0.08179695f, 
    -0.58088744f, 0.02834056f, 0.06310283f, 0.18931212f, -0.03590665f, 0.07580755f, -0.00157059f, 0.13638060f, 
    0.02489583f, 0.03967546f, -0.02088951f, 0.01051357f, -0.32161573f, -0.00382282f, -0.00153014f, -0.16403423f, 
    -0.14738403f, -0.06475347f, -0.14523058f, 0.15198478f, -0.09995099f, 0.08756587f, 0.01378826f, 0.07453544f, 
    -0.54390943f, -0.31370488f, 0.19019428f, -0.44645441f, -0.07709904f, -0.00335667f, -0.03357323f, -0.04732679f, 
    0.04967821f, -0.02202888f, 0.01664207f, -0.01509931f, -0.11134987f, -0.22296745f, -0.12403451f, 0.04059812f, 
    -0.00741353f, -0.00474898f, -0.08914239f, -0.03217215f, -0.09108882f, -0.04376531f, 0.13704714f, 0.13320976f, 
    -0.38331619f, -0.65050364f, -0.29474312f, -0.33557615f, -0.05290694f, -0.00209992f, -0.14171462f, -0.24341665f, 
    -0.04178319f, 0.05524224f, -0.04817702f, -0.03191233f, -0.57289737f, -0.43347836f, -0.31690112f, -0.06868466f, 
    0.00853605f, -0.35711098f, 0.03007045f, -0.41060778f, -0.01574690f, -0.04326024f, -0.01206604f, -0.04435337f, 
    -0.22626500f, 0.09406134f, 0.03176188f, -0.08880322f, 0.06724276f, -0.05609673f, -0.03959164f, 0.10432167f, 
    -0.04996691f, 0.01285615f, 0.13568866f, -0.10026796f, -0.04665374f, -0.02537247f, -0.17706858f, -0.15242936f, 
    0.01599603f, -0.01205818f, -0.02297909f, -0.00999630f, -0.13134626f, -0.06321184f, -0.21705236f, -0.03224445f, 
    -0.03683529f, -0.11144456f, -0.12964174f, 0.09912340f, 0.06788626f, 0.08383553f, 0.09466092f, 0.03078070f, 
    0.01906602f, 0.00597488f, 0.04378045f, -0.03320065f, -0.42605674f, -0.20418705f, 0.24277295f, -0.37883937f, 
    -0.23075220f, -0.15666310f, -0.05533189f, -0.04401882f, -0.05951438f, 0.05371080f, 0.01427703f, 0.01554428f, 
    -0.00488962f, 0.03360091f, 0.01475267f, 0.10233130f, 0.08204407f, 0.01526897f, 0.05185074f, 0.10593822f, 
    0.07550790f, -0.01343994f, -0.05750265f, -0.15663995f, 0.26154244f, 0.05074443f, -0.12921502f, 0.03501160f, 
    0.01181952f, 0.04619477f, 0.17886536f, 0.00370821f, 0.15827876f, 0.19692749f, -0.15115529f, -0.09913202f, 
    -0.04934854f, 0.03987636f, 0.00235717f, -0.04143846f, 0.04022248f, 0.00336283f, 0.00102188f, 0.01673924f, 
    0.08622751f, -0.00976237f, 0.18577741f, 0.10930344f, -0.72366881f, -0.22084622f, -0.25869986f, -0.06846063f, 
    -0.20999497f, -0.05683939f, -0.10467111f, -0.09409751f, 0.02835639f, 0.03740772f, 0.03701419f, -0.03087723f, 
    -0.25357002f, 0.22802800f, 0.31458366f, -0.08631685f, -0.02319034f, -0.02991755f, -0.01360865f, 0.04139349f, 
    0.02710774f, 0.01856150f, 0.05654845f, 0.17007570f, -0.07188810f, 0.02170445f, -0.00161375f, 0.07479116f, 
    -0.07691376f, -0.02135478f, 0.11750535f, -0.03474444f, 0.15899283f, 0.11225446f, 0.12160075f, -0.04265737f, 
    -0.16158941f, -0.08897686f, -0.12532000f, -0.16093977f, 0.05788416f, 0.06680873f, -0.00638704f, 0.00119556f, 
    -0.03008043f, 0.04537806f, -0.01135183f, 0.03376862f, -0.27003035f, -0.56142908f, -0.38132608f, -0.06173944f, 
    0.01571299f, -0.00984475f, 0.03854024f, -0.20642430f, -0.00683006f, 0.03618260f, -0.08489352f, 0.14286113f, 
    -0.14280343f, -0.07606924f, -0.07448712f, -0.05856758f, 0.03460622f, -0.06357238f, 0.01810927f, -0.01805723f, 
    0.03717086f, 0.03066580f, 0.09972385f, -0.03191410f, -0.33986124f, 0.16464604f, 0.51613128f, 0.52985752f, 
    -0.04135454f, -0.24997601f, -0.05640997f, 0.02754126f, -0.05972219f, 0.10166743f, 0.00198592f, 0.09003621f, 
    -0.47869453f, -0.45888647f, -0.52499366f, 0.34961808f, -0.19823200f, -0.01007985f, 0.02531505f, -0.34264058f, 
    0.00902423f, -0.02753001f, 0.02422018f, -0.03081364f, -0.02665132f, -0.07360874f, 0.05654888f, 0.09527643f, 
    0.00210358f, 0.02255059f, 0.17276531f, -0.02841919f, 0.09837495f, 0.09961569f, -0.01423891f, 0.01184163f, 
    -0.25103989f, -0.18545164f, 0.03974178f, 0.35106593f, 0.09831848f, 0.03925816f, 0.12538397f, -0.14497200f, 
    0.02868389f, -0.02337019f, 0.06787734f, 0.06815686f, 0.10234414f, 0.08925573f, 0.03919875f, -0.22908820f, 
    0.05510313f, 0.00220526f, 0.07754297f, -0.09133610f, 0.00478912f, 0.02398062f, 0.11551399f, 0.00637251f, 
    0.04253088f, -0.09649362f, -0.21933290f, -0.21050537f, 0.04294961f, 0.02792259f, 0.03489883f, 0.02925840f, 
    -0.01781222f, 0.01410133f, -0.08732542f, -0.09418298f, -0.08136283f, 0.05475503f, 0.00405888f, -0.06513491f, 
    0.01158282f, -0.00603725f, 0.03853927f, 0.09890764f, -0.01497296f, -0.00513253f, -0.09408105f, 0.11746579f, 
    0.11455041f, -0.14062195f, -0.26741415f, -0.18629007f, -0.15465796f, 0.19634122f, 0.15540245f, -0.03783656f, 
    0.03889314f, 0.04949444f, 0.03443889f, -0.08804479f, 0.26601321f, 0.00754341f, -0.06856585f, 0.00944588f, 
    -0.11436738f, 0.01639320f, 0.21582825f, 0.08233351f, 0.00965537f, 0.02167507f, 0.10363955f, 0.03059714f, 
    0.16005369f, 0.07045403f, 0.07501593f, -0.07904402f, 0.04369144f, -0.01144073f, 0.00226728f, -0.01002438f, 
    0.14899951f, 0.17159440f, 0.06003840f, 0.13594611f, 0.10814056f, -0.03235397f, -0.06262945f, -0.02984134f, 
    -0.06368812f, 0.08232758f, 0.03892205f, 0.12249358f, -0.09679999f, -0.08354446f, 0.07944722f, 0.00572344f, 
    -0.03820703f, 0.01892071f, 0.17968610f, 0.14678101f, -0.02761061f, 0.00744755f, 0.09742286f, 0.04520737f, 
    -0.00298006f, -0.00301341f, 0.15388349f, 0.05537893f, -0.42359585f, -0.08885498f, 0.24872032f, -0.00068458f, 
    -0.05210458f, 0.12282125f, 0.07074462f, 0.04145274f, -0.02855466f, 0.06471889f, -0.04896472f, 0.08426482f, 
    -0.44854176f, 0.11977157f, 0.38556483f, 0.06382783f, -0.10111355f, -0.00796151f, -0.02651643f, -0.20751263f, 
    -0.06918264f, -0.02260452f, 0.02304318f, 0.06777258f, -0.29107070f, -0.45938590f, -0.68764448f, -0.20924692f, 
    -0.16484515f, -0.17238711f, -0.09350558f, -0.12251315f, -0.07582907f, 0.04213413f, -0.02258451f, 0.02867624f, 
    0.01092342f, 0.00787136f, 0.08846565f, -0.14843865f, 0.03322088f, 0.03914599f, 0.01018933f, -0.04263806f, 
    -0.03986203f, 0.11573242f, 0.05458706f, -0.01747366f, 0.40916750f, -0.30348545f, -0.20710164f, -0.24865712f, 
    0.05392268f, -0.08987167f, 0.24581525f, -0.14033115f, 0.03998521f, -0.01131147f, -0.05743543f, -0.00493792f, 
    -0.08969388f, -0.05654082f, 0.08783629f, 0.07053973f, -0.19380283f, 0.02348273f, 0.04786311f, 0.04668254f, 
    0.00914121f, 0.02068815f, -0.01360629f, 0.07210936f, 0.09589943f, -0.42475539f, -0.50471258f, -0.17313235f, 
    -0.11988842f, -0.02086766f, -0.00384616f, 0.17955701f, 0.05355873f, 0.08894686f, 0.08172332f, -0.20993052f, 
    0.03341515f, -0.11985983f, -0.04042152f, 0.13428414f, -0.07036588f, 0.03246660f, 0.10444979f, 0.18396388f, 
    0.14043282f, -0.15122890f, 0.04594200f, 0.02756206f, -0.17157897f, -0.06529841f, 0.21433237f, 0.01624146f, 
    0.01897207f, -0.01064897f, 0.01382981f, 0.09626022f, 0.06661656f, 0.11376421f, 0.05295960f, -0.02934838f, 
    0.41107687f, 0.60538852f, -0.50217307f, 0.51884848f, -0.01494814f, -0.23543516f, 0.10548873f, 0.30789727f, 
    0.00273240f, 0.02711552f, 0.06791401f, -0.04175969f, 0.02453227f, -0.07966108f, -0.24185807f, -0.19429705f, 
    0.11067870f, 0.02572763f, 0.07738870f, -0.03750851f, 0.02541712f, 0.14421071f, -0.06960916f, 0.03508452f, 
    0.10977452f, -0.06384849f, -0.14215650f, -0.04882552f, -0.00085854f, -0.02893470f, 0.01503828f, 0.01458612f, 
    -0.06728210f, 0.07951748f, 0.06140224f, -0.29671863f, 0.23535697f, -0.03730203f, -0.07829668f, -0.06181344f, 
    -0.04097565f, -0.21212821f, 0.05210586f, -0.02697635f, 0.04276191f, 0.02211010f, 0.00411918f, -0.03414720f, 
    0.00034051f, -0.08135775f, 0.17739652f, 0.22638397f, 0.02835323f, 0.01704785f, -0.10180598f, 0.07331113f, 
    0.03180303f, 0.06534580f, 0.01538614f, 0.06828548f, 0.02607316f, -0.10121641f, 0.03187221f, 0.08033646f, 
    -0.12143677f, -0.12791099f, -0.04302146f, 0.12503375f, -0.01042213f, 0.06511138f, -0.11731444f, 0.01617100f, 
    -0.03347601f, -0.02830197f, 0.02756100f, 0.01516860f, 0.05558411f, 0.02092076f, 0.04029829f, -0.03679189f, 
    0.17032906f, 0.16935889f, 0.22911425f, 0.06966037f, 0.26798171f, 0.04518903f, -0.04847917f, 0.01958888f, 
    -0.04476789f, 0.08536240f, -0.00253295f, 0.00889287f, -0.01815809f, -0.11648832f, 0.15836684f, -0.26999828f, 
    -0.41173390f, -0.38516936f, -0.04820363f, 0.28650689f, 0.02468997f, 0.24696980f, -0.01531657f, -0.07379142f, 
    -0.02318899f, 0.04220796f, -0.02704347f, 0.08454435f, 0.16444206f, -0.11810450f, -0.65735680f, -0.24546714f, 
    0.08528046f, -0.14745536f, 0.23461035f, 0.02069300f, 0.05133564f, 0.03457745f, 0.06954952f, 0.01274668f, 
    0.06519177f, 0.07385249f, -0.02892441f, -0.04701981f, -0.03263915f, 0.06867268f, 0.03728335f, 0.04823411f, 
    -0.03703995f, 0.02799854f, 0.04687515f, 0.07973605f, -0.29145241f, -0.19516225f, 0.15067145f, 0.24181966f, 
    0.13012151f, -0.18393750f, 0.00319383f, 0.05889307f, 0.00130387f, 0.07694387f, 0.04046661f, 0.02044864f, 
    0.13981041f, -0.34921923f, -0.27727586f, -0.34012005f, 0.10633894f, 0.29672268f, 0.18029135f, 0.02202588f, 
    -0.04550953f, 0.00518830f, -0.03792828f, -0.00334019f, 0.07596281f, -0.07859010f, -0.34008017f, 0.23386337f, 
    -0.16522604f, 0.13207480f, 0.10166882f, 0.14010590f, 0.09592663f, 0.03681789f, 0.19813238f, 0.08049612f, 
    -0.54686815f, -0.46475607f, -0.02087008f, -0.56939626f, -0.14224285f, -0.27232170f, -0.07980986f, -0.18213676f, 
    -0.04753279f, -0.06905369f, -0.07491866f, -0.13256982f, 0.30621988f, 0.04452800f, 0.18136396f, 0.02896198f, 
    0.08083235f, -0.02247694f, 0.06849048f, 0.08980732f, 0.06594431f, -0.25614956f, 0.22144179f, -0.06362291f, 
    0.10635043f, 0.10673285f, 0.00139125f, 0.08045142f, 0.00217315f, -0.00173205f, 0.00600127f, 0.09715036f, 
    -0.06316057f, -0.04323186f, 0.09762759f, -0.08541898f, -0.64805961f, 0.46085835f, 0.45714670f, 0.00567613f, 
    -0.04276318f, -0.06365135f, 0.01835730f, 0.08161293f, -0.04478247f, 0.01541934f, -0.00323586f, 0.09359467f, 
    0.16012940f, -0.15141410f, 0.00298497f, 0.07710328f, 0.02629789f, -0.12938923f, -0.07915518f, -0.06569822f, 
    0.12159333f, -0.06367722f, 0.25515977f, -0.09176531f, -0.07132904f, 0.06041342f, 0.02031351f, 0.02150205f, 
    -0.12558690f, -0.00514632f, 0.00498655f, -0.00305623f, -0.00050133f, -0.07887140f, -0.04008321f, -0.04451936f, 
    -0.03027532f, -0.08125956f, 0.02571663f, -0.01845928f, -0.03594290f, -0.00309683f, -0.00564441f, -0.07667170f, 
    -0.09839943f, -0.01436677f, 0.04815036f, -0.02061879f, -0.05986252f, 0.14763533f, -0.10541374f, 0.12875666f, 
    -0.05290304f, 0.08246205f, 0.05369033f, 0.01953145f, -0.02169764f, -0.06719863f, 0.07600236f, 0.06222015f, 
    -0.34829307f, 0.22767468f, 0.15635610f, 0.37394139f, 0.03723938f, 0.01804030f, 0.02604713f, 0.01155676f, 
    -0.00392620f, -0.07110599f, -0.05067761f, -0.01911754f, -0.01612398f, 0.07561041f, -0.04216597f, -0.03743345f, 
    0.00476145f, -0.03469755f, 0.04195838f, -0.00583219f, 0.02449831f, -0.03658910f, -0.08059738f, -0.28017917f, 
    0.43360439f, -0.30509356f, -0.24297948f, -0.30241084f, -0.14549161f, -0.08975537f, -0.14777017f, 0.11297892f, 
    0.09278678f, -0.00532248f, 0.02174189f, 0.00307355f, 0.54360306f, -0.26852942f, -0.08217916f, -0.28615886f, 
    -0.16839565f, 0.09021189f, 0.00204449f, -0.01196899f, -0.04196857f, 0.13251385f, 0.03617347f, -0.06268137f, 
    -0.05361698f, -0.71086413f, 0.25810996f, 0.50889397f, 0.10808377f, 0.04930082f, 0.11491983f, -0.00167625f, 
    0.05555578f, -0.01903143f, 0.09577039f, 0.02830367f, 0.15877953f, -0.29924604f, 0.07913635f, 0.04101597f, 
    -0.00287809f, -0.14304346f, -0.08210389f, 0.06252090f, 0.05413802f, -0.00289723f, 0.02249796f, -0.01579641f, 
    -0.10671571f, -0.19371894f, -0.20553337f, -0.05022719f, 0.05823193f, 0.04921959f, -0.00292488f, 0.16845459f, 
    0.02798664f, -0.02227948f, -0.03218850f, -0.01614999f, -0.47904858f, -0.39526191f, -0.04544948f, -0.08012138f, 
    -0.11893685f, 0.14585516f, -0.17288280f, 0.03850800f, 0.04261732f, 0.02946543f, 0.03143359f, -0.03754386f, 
    0.03820213f, 0.00455116f, -0.06891481f, -0.07386554f, -0.05881465f, 0.04608560f, 0.08649978f, -0.02739936f, 
    0.00999606f, 0.07836153f, -0.18709558f, -0.00232841f, 0.00319108f, 0.03619139f, 0.00716879f, -0.03889276f, 
    -0.00287214f, 0.00060763f, -0.00389892f, -0.00657401f, 0.04633440f, -0.02229039f, 0.00419633f, 0.01419427f, 
    -0.01846179f, -0.06266557f, 0.09652518f, -0.11402477f, 0.01540626f, 0.00493338f, -0.02232505f, 0.00619611f, 
    0.08660723f, 0.01197617f, -0.00302645f, -0.06518578f, 0.00573629f, -0.37668738f, -0.10139681f, -0.27386349f, 
    -0.02145062f, -0.22209702f, 0.02034591f, 0.15197270f, -0.00334603f, 0.02117485f, -0.01567469f, 0.01500157f, 
    -0.06741284f, 0.02385852f, 0.09368269f, -0.12327693f, -0.01192120f, -0.03943277f, -0.02678050f, -0.04867335f, 
    0.01155239f, -0.01934383f, -0.03665258f, -0.04797345f, 0.06347072f, -0.19579993f, 0.15405010f, -0.07727301f, 
    -0.07194488f, 0.05356021f, 0.05153260f, -0.02532505f, 0.05704935f, -0.10712474f, -0.02007768f, 0.06739025f, 
    0.03125056f, -0.01258962f, 0.00850828f, 0.04631950f, -0.02054488f, -0.04695134f, -0.03200895f, -0.01001864f, 
    0.05158849f, -0.03946966f, 0.06143281f, 0.02890733f, 0.41845685f, -0.56692094f, -0.18707533f, 0.24326470f, 
    0.10650156f, -0.02344767f, 0.05546133f, 0.07211448f, -0.03381237f, -0.01279183f, -0.00670992f, 0.03847276f, 
    0.01435688f, -0.22399771f, 0.04073675f, -0.02976980f, 0.02343644f, 0.05455067f, 0.05440053f, -0.04983233f, 
    0.01403026f, -0.03142901f, 0.08955718f, 0.02062016f, 0.01869560f, -0.10730004f, -0.26809645f, -0.06664902f, 
    -0.01079081f, -0.11703588f, 0.04525162f, -0.03422197f, 0.12795080f, -0.07142398f, 0.02701092f, 0.05356883f, 
    -0.05904467f, 0.07879798f, -0.14543875f, 0.05464196f, -0.00938092f, -0.02691223f, 0.02812808f, -0.04617103f, 
    -0.00256791f, 0.01835913f, -0.02530389f, -0.05489523f, -0.34217507f, -0.41743797f, 0.34543043f, 0.12952724f, 
    -0.02409613f, -0.04039084f, -0.00297933f, 0.00674228f, -0.00105150f, -0.10065320f, -0.06401237f, -0.05772460f, 
    0.13199182f, 0.05053177f, 0.20828110f, 0.04117406f, 0.02400035f, 0.06881321f, 0.01657991f, 0.00641357f, 
    0.00607106f, -0.07861426f, 0.12593505f, 0.02151390f, 0.25114790f, -0.22768506f, -0.48097679f, -0.49700657f, 
    -0.10172643f, -0.03415824f, 0.11799262f, 0.08761030f, -0.02019266f, 0.06740689f, 0.03331189f, 0.06495001f, 
    -0.30703083f, 0.05215710f, -0.12943417f, -0.15729307f, 0.10896695f, -0.07440181f, 0.03969755f, 0.04394622f, 
    0.03822219f, -0.01125231f, 0.00276462f, -0.01531796f, 0.01688022f, 0.06092890f, 0.09047238f, -0.08557712f, 
    -0.00623426f, 0.01937875f, -0.07980498f, 0.04376031f, -0.04353207f, -0.04097334f, -0.00144603f, -0.04303412f, 
    -0.05319065f, 0.06428125f, 0.08683632f, -0.12107494f, 0.14424457f, -0.05229698f, 0.02293026f, 0.08720642f, 
    -0.18506801f, -0.06009333f, 0.10984351f, 0.02922486f, -0.01794231f, 0.20917684f, -0.04014039f, 0.11991677f, 
    -0.03291298f, 0.04194523f, 0.03491552f, 0.00054027f, -0.00029431f, -0.01978108f, -0.01689744f, -0.01159369f, 
    -0.06018568f, 0.04913444f, 0.12833436f, -0.09204866f, 0.06444383f, -0.04403070f, 0.06756473f, -0.05607470f, 
    0.04624626f, -0.00306769f, 0.04283450f, 0.03576342f, 0.00070582f, 0.03913001f, -0.09489555f, -0.00139545f, 
    0.02450637f, -0.02257067f, -0.01464670f, -0.03080212f, -0.01744225f, -0.04930875f, -0.05081224f, -0.16128792f, 
    0.00870758f, 0.07266832f, -0.26460186f, 0.04046807f, -0.12080535f, -0.07675426f, 0.03957498f, -0.09765704f, 
    -0.01695790f, 0.08633921f, 0.00820522f, 0.03894745f, -0.12274884f, 0.16228436f, -0.07576405f, 0.17727810f, 
    0.04275709f, 0.08355672f, 0.06511822f, -0.06318849f, -0.04318711f, -0.05278866f, 0.03370857f, 0.14205444f, 
    -0.01434297f, -0.03483630f, 0.09945224f, -0.06091859f, 0.01213865f, -0.05069748f, -0.04413831f, 0.03082054f, 
    -0.00408797f, 0.03684752f, 0.04297545f, 0.03501087f, 0.06097936f, 0.01647340f, -0.05000701f, -0.04327472f, 
    -0.01498880f, -0.01848748f, -0.00704007f, -0.01196530f, 0.00528701f, 0.00302969f, -0.01936501f, -0.08186065f, 
    0.32132241f, -0.11091838f, -0.07080566f, -0.06208227f, 0.04072506f, -0.03534516f, -0.00726314f, -0.03710982f, 
    0.08990141f, -0.12151347f, 0.01378306f, 0.01732765f, -0.09581821f, -0.25075933f, -0.13816772f, -0.16834980f, 
    0.06741401f, -0.00302099f, 0.09459791f, 0.04304838f, -0.02261173f, 0.00005032f, 0.01643001f, 0.03393946f, 
    0.13180847f, 0.20692278f, -0.23810518f, -0.09196011f, -0.00913972f, -0.05501519f, -0.08401401f, -0.02830807f, 
    -0.11742710f, -0.05576253f, -0.05978480f, 0.00785295f, 0.06832989f, -0.36363944f, 0.42523903f, -0.44438401f, 
    -0.11524070f, -0.03031964f, 0.00496896f, 0.22565982f, -0.01677464f, 0.01344803f, -0.00500609f, -0.02808505f, 
    0.05771146f, 0.19099712f, -0.03096060f, 0.05153333f, 0.00635164f, 0.03592122f, -0.03325745f, -0.01429006f, 
    -0.10111935f, 0.00169549f, -0.08078577f, 0.01810872f, -0.30285984f, 0.33794084f, -0.15182176f, 0.12045700f, 
    -0.19964796f, 0.09306177f, 0.06244288f, 0.09315872f, -0.02369999f, -0.01669822f, -0.01912468f, 0.05429158f, 
    -0.18960707f, -0.46471655f, -0.41242823f, -0.34941769f, -0.00412474f, -0.05052370f, 0.19176878f, 0.12307648f, 
    -0.01672463f, 0.11868344f, -0.06364746f, 0.15108889f, -0.07215231f, -0.66180307f, 0.32740289f, 0.52721137f, 
    -0.13130654f, 0.13665023f, -0.09312119f, -0.11960245f, 0.05675350f, -0.02598618f, -0.04364496f, -0.09862413f, 
    0.19456983f, 0.04242501f, -0.18806861f, -0.07890515f, -0.05973544f, -0.03297700f, -0.06312780f, -0.19128796f, 
    -0.11214500f, -0.04865883f, -0.05445420f, -0.06218773f, 0.25611210f, 0.06121583f, 0.00581419f, -0.35010228f, 
    0.00728608f, 0.08941158f, -0.11143759f, 0.02551911f, 0.00729129f, 0.08328725f, -0.06676292f, -0.16984710f, 
    -0.32362625f, -0.70932680f, -0.40484336f, -0.13803658f, -0.18634187f, -0.13565600f, 0.14198668f, -0.24898551f, 
    -0.08415943f, 0.13321900f, 0.04281634f, -0.05209238f, -0.00525751f, 0.01323040f, 0.02001343f, -0.02021811f, 
    -0.01984155f, -0.01948255f, -0.06426586f, -0.00542184f, -0.00651070f, 0.09168453f, 0.04499969f, 0.06259556f, 
    0.05603070f, 0.02963826f, -0.00990215f, -0.00493100f, 0.01513227f, 0.04184258f, -0.00364697f, 0.03092824f, 
    -0.01024458f, -0.05458876f, -0.05397454f, -0.06076318f, -0.21660183f, 0.03872892f, -0.02198609f, 0.18035333f, 
    -0.06380580f, -0.07157811f, -0.05149806f, -0.04812207f, -0.00619245f, -0.05885087f, -0.00781755f, 0.03662197f, 
    0.14369489f, -0.01966005f, 0.00691091f, -0.02205025f, -0.10269640f, 0.07428438f, -0.00711670f, 0.01792905f, 
    0.02781970f, 0.03688428f, 0.07283320f, -0.00053561f, 0.06833684f, -0.01174641f, 0.01240774f, -0.06286363f, 
    -0.09136535f, -0.07581592f, -0.00449928f, -0.02094447f, -0.05859441f, -0.04756837f, 0.03709870f, -0.04990923f, 
    0.00934282f, -0.05659471f, 0.12069324f, 0.02292469f, -0.01811680f, -0.07561481f, 0.05173630f, -0.03252019f, 
    -0.10964413f, 0.13479434f, 0.10950758f, 0.00367186f, -0.03423575f, -0.04234734f, -0.04239216f, -0.01582342f, 
    0.00246328f, -0.01866291f, 0.03064476f, 0.00043820f, 0.03022695f, 0.04171663f, -0.01789520f, -0.04004414f, 
    0.03246415f, 0.05629563f, 0.04557630f, -0.19711198f, -0.04025243f, -0.12980519f, -0.03963857f, 0.04189688f, 
    0.03562519f, -0.02390543f, 0.02790212f, -0.03978826f, -0.57142502f, -0.19219346f, -0.09211308f, 0.05299044f, 
    -0.19408149f, -0.02568655f, -0.06544888f, -0.02906658f, 0.01444211f, -0.00774510f, -0.01501115f, -0.01651723f, 
    0.05144781f, -0.04111726f, 0.03001720f, 0.01726535f, -0.01531335f, -0.02034459f, -0.04815668f, -0.09427849f, 
    -0.15156059f, -0.09516504f, -0.03298316f, 0.02749445f, 0.32667059f, -0.22154826f, 0.11182988f, -0.35731891f, 
    0.05250407f, 0.08778927f, 0.06929485f, 0.09078135f, -0.06423078f, 0.16046560f, 0.03621168f, -0.14084518f, 
    -0.19356874f, 0.18895596f, -0.17816064f, 0.03193961f, -0.02194990f, 0.01004007f, -0.01125875f, 0.06734475f, 
    0.09790148f, 0.06162248f, 0.06369216f, -0.00251473f, 0.20878695f, -0.21651997f, 0.04061121f, -0.07439700f, 
    0.03135620f, -0.07172135f, 0.04752264f, -0.13245073f, -0.06501956f, 0.14741743f, 0.01752181f, -0.02385283f, 
    -0.43563002f, -0.02253561f, -0.27955768f, 0.48665050f, -0.04126268f, 0.02236759f, -0.04031321f, 0.06849475f, 
    -0.02873933f, -0.02786683f, 0.00650522f, 0.05445834f, -0.11223176f, 0.06616744f, 0.19545296f, -0.02143542f, 
    -0.04501882f, 0.00540821f, 0.02164453f, 0.02108668f, -0.10743456f, 0.03970467f, -0.18868735f, -0.06896080f, 
    -0.12012894f, -0.00043631f, -0.07079843f, 0.00911535f, 0.04788524f, -0.03919510f, 0.08142909f, -0.02163939f, 
    -0.08886829f, -0.12953462f, 0.02099657f, -0.16308829f, 0.38104481f, -0.59337795f, -0.36029565f, -0.10855348f, 
    -0.03514348f, -0.02816967f, 0.02070550f, 0.02319400f, 0.06027579f, -0.00078424f, -0.09084076f, 0.04777711f, 
    0.09936265f, -0.00056349f, -0.21708724f, -0.28596720f, -0.00818086f, 0.00110573f, 0.08131535f, 0.02712266f, 
    0.05287084f, -0.00049291f, -0.19425268f, -0.41044834f, -0.07157475f, 0.06600293f, -0.00973607f, 0.01215926f, 
    0.06065895f, -0.02872157f, -0.00768494f, 0.00285081f, 0.08874525f, 0.13701560f, 0.05439261f, 0.12302196f, 
    -0.15060528f, 0.02071918f, -0.05611081f, 0.03527166f, 0.16972041f, 0.00084298f, 0.04982693f, 0.05593724f, 
    -0.00925864f, -0.02269501f, 0.08446725f, 0.18393794f, -0.46625170f, 0.03988931f, 0.05732930f, 0.10027194f, 
    0.00054394f, -0.02214469f, -0.05764998f, 0.02736914f, -0.01603732f, -0.10391069f, -0.03119742f, -0.01883781f, 
    -0.43121174f, -0.25013277f, 0.05390209f, 0.00198205f, 0.00789657f, -0.07352767f, -0.10466084f, 0.00524361f, 
    0.03328130f, 0.01204878f, 0.08149915f, 0.09954036f, -0.15404667f, 0.04845075f, -0.03934067f, -0.17220084f, 
    -0.08139002f, 0.00647361f, 0.03950591f, -0.05117949f, -0.01654434f, 0.06123647f, 0.01360292f, 0.08756140f, 
    -0.55825377f, -0.52084744f, -0.51493585f, -0.00777537f, 0.11633073f, 0.13220786f, 0.16844776f, 0.20781876f, 
    -0.09653299f, 0.05743522f, -0.06563818f, 0.03640640f, 0.14349204f, -0.06966285f, -0.28664422f, -0.29001978f, 
    0.18316416f, 0.00162820f, 0.08601778f, 0.04280348f, 0.16595450f, -0.00535599f, 0.03441618f, 0.17474581f, 
    0.47314751f, -0.22176823f, -0.41635665f, -0.33121967f, 0.07928497f, -0.00725631f, -0.00148045f, 0.08968009f, 
    -0.00682411f, 0.18941578f, 0.05846021f, 0.01773366f, 0.32663959f, 0.05450349f, -0.12756895f, -0.16607004f, 
    0.00275343f, -0.01809139f, 0.03943760f, -0.02836754f, 0.08558592f, 0.01284515f, 0.02261861f, 0.04156495f, 
    0.14759770f, -0.38988218f, -0.43533874f, -0.21411210f, -0.18817170f, -0.13105226f, 0.04022879f, 0.05073319f, 
    -0.05878840f, -0.06785517f, -0.02388667f, 0.01592528f, -0.19023065f, -0.27256513f, -0.17403097f, 0.12009794f, 
    0.12606904f, 0.14826868f, -0.07406048f, 0.00498623f, -0.01998438f, 0.00087589f, 0.00660477f, 0.05610637f, 
    0.00851912f, 0.09722026f, 0.06099221f, -0.01770770f, -0.11887480f, -0.04314836f, 0.04228416f, 0.06258302f, 
    0.09212761f, -0.03449089f, 0.10660926f, 0.13140823f, -0.14843851f, 0.08562819f, 0.02826621f, -0.09624502f, 
    -0.05239374f, -0.06063480f, -0.03254545f, -0.06451279f, -0.02410746f, -0.01166366f, -0.02668611f, 0.06505128f, 
    0.13213204f, 0.00840671f, -0.00289732f, -0.17546256f, -0.05142007f, -0.06331852f, -0.07823368f, -0.07555721f, 
    -0.13549499f, -0.03353608f, -0.10236551f, -0.13982660f, -0.29593229f, -0.35675433f, -0.33528343f, -0.25409141f, 
    0.00147368f, 0.14117882f, 0.04883498f, 0.07396770f, 0.03111162f, -0.09722550f, -0.00286307f, -0.06651845f, 
    0.09773510f, 0.04249978f, 0.05063341f, -0.01734959f, -0.04143648f, -0.00961449f, -0.06894302f, -0.03591810f, 
    0.01940969f, 0.09877310f, -0.01444434f, -0.00298852f, -0.02800223f, 0.08773497f, -0.09149726f, -0.03725718f, 
    0.12522663f, 0.04080574f, 0.06584220f, -0.06864519f, -0.23140569f, -0.17671564f, 0.04394910f, -0.24378434f, 
    -0.30477905f, -0.11928103f, 0.03340586f, -0.05510650f, -0.00127003f, -0.07487289f, -0.01864748f, -0.03806613f, 
    -0.02018493f, 0.06422294f, -0.12490533f, -0.24192746f, 0.40707469f, -0.11989193f, -0.51309109f, 0.03076283f, 
    -0.09038812f, 0.09540860f, 0.11995766f, -0.12846284f, 0.07450475f, 0.01553145f, 0.05239398f, -0.02039047f, 
    -0.06411212f, -0.16713363f, -0.12800673f, -0.10357156f, -0.07597166f, 0.02844681f, 0.02443938f, -0.01152634f, 
    0.01011370f, -0.08922110f, -0.02736440f, -0.07309414f, 0.10531834f, -0.01146254f, -0.04349193f, 0.04609627f, 
    0.06959976f, 0.02678038f, 0.02787189f, 0.01018698f, -0.24247709f, -0.09291077f, -0.19597094f, -0.48416787f, 
    0.05635392f, 0.12901382f, 0.01461579f, 0.08469808f, -0.02127616f, -0.09664798f, -0.01681428f, -0.07337700f, 
    0.05792356f, 0.03526586f, 0.04359053f, 0.08404632f, 0.47571036f, -0.32398170f, -0.28571406f, -0.08313265f, 
    0.08515501f, -0.08981737f, 0.02062234f, -0.08969107f, 0.00249798f, 0.06741948f, 0.08828051f, 0.05698079f, 
    -0.57988244f, -0.17200936f, 0.25627336f, 0.25607190f, -0.09531502f, -0.06003583f, -0.00580380f, -0.07504773f, 
    0.01731784f, 0.19982308f, 0.14228000f, 0.08747176f, -0.32908368f, -0.40136999f, -0.07747628f, 0.28865191f, 
    -0.02312773f, 0.12570448f, 0.11776976f, 0.07844525f, 0.13801843f, 0.04556351f, 0.10809521f, 0.08355272f, 
    0.23173241f, -0.12804806f, -0.20636939f, -0.09935111f, -0.04535558f, 0.09811997f, 0.01027907f, -0.09802280f, 
    -0.02966283f, -0.03482987f, -0.01863505f, 0.03855525f, 0.03032173f, -0.14822304f, -0.09410524f, -0.03268618f, 
    0.13309990f, 0.03407554f, 0.09737842f, 0.03439719f, -0.19184141f, -0.00075067f, -0.10412837f, -0.17574325f, 
    0.01213144f, -0.03759774f, -0.00570975f, 0.01053752f, -0.03009982f, 0.13857459f, -0.01951744f, -0.12168438f, 
    -0.01887109f, -0.10990717f, -0.16224575f, 0.01133354f, -0.80549055f, 0.07881448f, 0.26856479f, 0.02484810f, 
    -0.11804283f, -0.00181207f, -0.10218455f, -0.04120256f, -0.04440387f, 0.00387360f, 0.05685900f, -0.02617014f, 
    -0.23388840f, 0.09635971f, 0.05782035f, 0.01337757f, -0.06612899f, -0.03883925f, -0.06313333f, -0.04049531f, 
    -0.00124945f, 0.14032744f, -0.03145838f, 0.11151858f, 0.02321756f, 0.09960230f, 0.03161401f, -0.01664384f, 
    -0.06955706f, -0.01670299f, -0.01091568f, -0.00490159f, -0.00804165f, 0.02623988f, -0.06712106f, 0.11644341f, 
    0.23114958f, -0.00395553f, -0.05524100f, 0.12199180f, 0.08187260f, 0.00658268f, -0.10391379f, 0.14585470f, 
    -0.05363522f, -0.00406107f, 0.03196808f, 0.01701955f, -0.35216728f, -0.14322533f, 0.16506481f, 0.06788342f, 
    0.00927707f, 0.03517949f, -0.17371732f, 0.07653257f, -0.24753310f, -0.12914389f, -0.00130616f, -0.21771669f, 
    -0.38181558f, -0.02349810f, -0.02917137f, -0.03535709f, 0.00226873f, 0.01912143f, -0.06918008f, -0.01113597f, 
    -0.03786948f, -0.02914177f, -0.08841009f, -0.17093270f, 0.19318904f, -0.04925404f, -0.03564068f, -0.12824169f, 
    0.03369410f, -0.03198430f, -0.00887492f, -0.05057648f, -0.05149338f, -0.08567168f, -0.06337211f, -0.02528826f, 
    -0.00454340f, -0.17514217f, -0.10013554f, -0.06149802f, 0.06536061f, 0.04253238f, 0.02311681f, 0.06556064f, 
    -0.19000261f, 0.06619711f, -0.09362015f, -0.37045467f, 0.06304292f, -0.21709001f, -0.20234023f, 0.16367429f, 
    -0.00696718f, 0.11928763f, 0.04194301f, 0.12036295f, -0.13137387f, -0.15862601f, -0.04264233f, -0.02976457f, 
    0.17743196f, -0.05366131f, 0.02454665f, -0.07894620f, -0.01251558f, 0.05432982f, 0.20595586f, 0.04506986f, 
    0.12616812f, 0.03659376f, 0.03966064f, 0.05344231f, -0.15290825f, -0.22124429f, -0.41561046f, -0.55404168f, 
    0.02446758f, -0.21059380f, 0.12519440f, -0.07943859f, -0.00052828f, -0.08096122f, -0.02704559f, -0.04877684f, 
    0.08316366f, 0.05688894f, -0.01410385f, 0.06591783f, -0.00584048f, 0.04874791f, -0.10120855f, 0.15281963f, 
    -0.00386518f, 0.08635116f, 0.10631875f, 0.15647997f, -0.41496196f, 0.01400422f, 0.12336092f, 0.20838989f, 
    0.14557795f, -0.12222150f, -0.34145847f, 0.05979924f, -0.04424295f, 0.01957776f, 0.10287370f, 0.00711878f, 
    0.02568639f, -0.36528841f, 0.05895067f, 0.19011526f, 0.14966111f, 0.14328308f, 0.07881154f, -0.04887757f, 
    -0.11287830f, -0.11473247f, -0.08103805f, -0.46281153f, 0.32281727f, -0.21445368f, -0.13720730f, -0.18848380f, 
    0.17914754f, 0.01163221f, 0.07480089f, 0.13628004f, 0.12690775f, 0.11023118f, 0.30901730f, 0.25444284f, 
    0.19279823f, 0.03676408f, 0.02907123f, -0.17677283f, 0.08531912f, 0.00770927f, 0.01048711f, 0.08241535f, 
    0.15322956f, -0.05864898f, 0.16794620f, -0.02931329f, 0.04423147f, -0.02154601f, -0.26661733f, -0.31232035f, 
    -0.06350616f, -0.08153388f, 0.02643228f, 0.03529317f, 0.18844171f, -0.01635830f, 0.18648191f, 0.00010770f, 
    0.37681428f, -0.33753559f, -0.23572616f, 0.08567509f, 0.27871987f, -0.06237222f, 0.03273073f, 0.00495725f, 
    0.06666948f, 0.05460256f, -0.03331605f, 0.16523440f, -0.22451808f, 0.02915589f, 0.09080256f, 0.08582732f, 
    -0.09025414f, 0.02588663f, 0.00818948f, 0.06056633f, 0.02040129f, -0.06232735f, 0.05218517f, -0.01159334f, 
    0.09589864f, 0.04441490f, 0.03151952f, -0.15732622f, -0.02641517f, -0.06466812f, -0.07341982f, -0.05521983f, 
    0.03604656f, 0.02894739f, 0.04174900f, 0.01651939f, -0.03676030f, 0.02606137f, -0.03340737f, 0.01990139f, 
    0.01737160f, 0.07720817f, -0.02540963f, 0.08321875f, 0.09491556f, 0.14894874f, 0.03234131f, 0.02412724f, 
    -0.17969024f, -0.11816928f, -0.05809603f, 0.11639997f, -0.00728840f, 0.01461490f, -0.03273580f, 0.04208487f, 
    0.15154001f, 0.09437060f, 0.00949942f, 0.02037436f, 0.17094789f, 0.00106015f, -0.03803539f, 0.00901844f, 
    0.08175465f, -0.13556930f, 0.04628805f, -0.01330745f, 0.17032227f, 0.09626730f, 0.09224807f, 0.11070821f, 
    -0.13526535f, 0.04034964f, 0.10557636f, 0.01631748f, -0.01983276f, 0.04995838f, 0.03053089f, -0.01174383f, 
    -0.03251374f, -0.03682848f, -0.21044050f, -0.53174168f, -0.03124081f, 0.12684946f, 0.03467494f, -0.07794703f, 
    0.00166937f, 0.01781865f, -0.05603825f, -0.06746797f, -0.14132935f, 0.04881008f, -0.00300314f, 0.01110482f, 
    -0.10161815f, 0.15387663f, 0.16352117f, 0.05017668f, -0.03371681f, -0.05494927f, -0.01734806f, -0.10577416f, 
    0.08297690f, -0.02560526f, -0.07662661f, -0.04496564f, -0.05973190f, 0.06321449f, 0.18691848f, 0.02585459f, 
    0.14306371f, -0.06563672f, 0.12457349f, 0.02899502f, 0.06843062f, 0.05918334f, 0.16403331f, 0.02080458f, 
    -0.06970806f, -0.03358564f, -0.01582276f, -0.09857432f, 0.01030013f, -0.06260499f, 0.07692352f, 0.03141784f, 
    -0.02078583f, 0.00788961f, -0.01128990f, 0.03289517f, 0.24723844f, -0.01271799f, -0.18069394f, -0.16281120f, 
    -0.26563254f, -0.01230216f, -0.05202439f, -0.01565850f, 0.02555265f, 0.06459828f, 0.06556163f, 0.15363958f, 
    -0.20782241f, 0.13612443f, 0.09212504f, 0.09644669f, 0.05164006f, -0.05760921f, -0.05069317f, 0.00786605f, 
    -0.15758106f, 0.00693287f, -0.01028161f, 0.01209327f, 0.30140603f, 0.24399588f, 0.08138876f, -0.12413080f, 
    0.14364114f, 0.11341628f, -0.06646634f, -0.14625710f, -0.16684258f, -0.09205460f, -0.11974540f, -0.09500115f, 
    -0.21411793f, -0.32276362f, -0.32163620f, 0.00072194f, -0.03833107f, 0.01008809f, -0.02301089f, 0.05398421f, 
    0.05794456f, 0.07005233f, 0.13567616f, 0.04639560f, -0.26112789f, -0.08747289f, 0.06058409f, 0.05278017f, 
    0.05704806f, -0.01422288f, 0.00368518f, -0.02805868f, -0.00413824f, -0.05081568f, -0.01485524f, 0.00032852f, 
    -0.24334516f, 0.04381220f, 0.13411796f, 0.17654634f, -0.09419284f, 0.13431551f, -0.05180884f, -0.01901452f, 
    0.02281569f, 0.16180679f, 0.02326272f, 0.11960665f, -0.21650325f, -0.28239945f, -0.26202029f, -0.02870485f, 
    0.01701241f, 0.04866309f, 0.06895440f, -0.01789632f, -0.03088570f, -0.05565158f, -0.01292561f, -0.08308597f, 
    -0.09727523f, -0.12832098f, 0.10357055f, 0.31204638f, 0.12074534f, 0.06454612f, -0.01891984f, 0.01359862f, 
    -0.05792440f, -0.03404063f, 0.09528679f, 0.12982291f, -0.00570298f, 0.01977324f, -0.20007943f, -0.01577424f, 
    0.14228268f, -0.12356561f, 0.07114889f, -0.07582574f, 0.07831746f, -0.02367503f, -0.08963370f, -0.10164546f, 
    -0.05306830f, 0.19445157f, 0.10442857f, -0.36553091f, 0.06811181f, -0.37863016f, -0.03255789f, -0.22283839f, 
    0.03439957f, -0.04019203f, -0.05030579f, 0.07293246f, -0.22532345f, 0.16412058f, -0.24976215f, -0.02789402f, 
    0.10039529f, -0.04470517f, 0.18546656f, 0.07137743f, 0.04023675f, 0.04809882f, -0.02769463f, 0.04165203f, 
    0.28184387f, 0.16135079f, -0.11286876f, -0.38905382f, -0.01907765f, -0.02186204f, 0.24005504f, 0.33803731f, 
    -0.03953139f, 0.07619559f, -0.01055382f, -0.15447015f, -0.12915048f, 0.05818037f, 0.17846753f, 0.07230968f, 
    0.04290886f, 0.02387123f, 0.03341270f, -0.05997534f, 0.08663195f, 0.11174018f, 0.03975846f, -0.05298720f, 
    0.04838078f, -0.12186517f, 0.08355142f, -0.10459776f, -0.14694826f, -0.13398489f, -0.08284053f, -0.13892926f, 
    0.05503551f, -0.02577495f, 0.04659259f, 0.11892523f, 0.06900026f, 0.18204762f, 0.06757387f, 0.44434983f, 
    0.16178945f, -0.27180094f, -0.09370336f, 0.02899312f, -0.09439021f, -0.14060536f, 0.05718504f, -0.07731573f, 
    0.26980767f, 0.09536865f, -0.11075798f, 0.17273469f, -0.02823127f, -0.00054388f, -0.00261311f, 0.04278832f, 
    0.06396670f, 0.12435550f, 0.00838419f, 0.01573669f, -0.25818139f, -0.19912910f, -0.10622798f, 0.08193398f, 
    0.05962760f, 0.05477292f, 0.05052491f, 0.05514657f, 0.04529173f, 0.07682260f, 0.04200768f, -0.03352411f, 
    -0.46604946f, 0.02683855f, 0.37231150f, -0.05463409f, -0.21404696f, -0.14471881f, -0.00615611f, 0.19121252f, 
    0.05070328f, 0.04338789f, 0.02159210f, 0.00533549f, -0.11073398f, -0.13824382f, -0.15274090f, -0.46996337f, 
    -0.23447242f, 0.17440926f, -0.29916865f, 0.12725449f, 0.13132797f, -0.09449276f, -0.03450779f, 0.00740542f, 
    -0.02358335f, -0.12163890f, 0.05259296f, 0.03717507f, 0.11803816f, -0.04324318f, -0.06738951f, 0.21318933f, 
    -0.02823461f, 0.02341865f, -0.17435218f, -0.06571712f, -0.13157311f, -0.10603529f, 0.01529169f, 0.05430673f, 
    0.16618632f, 0.11295551f, 0.12251081f, 0.02634177f, 0.16978961f, 0.01248645f, 0.07216087f, 0.04339863f, 
    0.24558391f, -0.39085907f, -0.02990562f, -0.03546732f, 0.04493907f, 0.13804002f, 0.07465308f, -0.02147298f, 
    0.02217428f, -0.01885360f, 0.07025732f, -0.08824151f, -0.24233186f, 0.05509152f, -0.11228488f, 0.06606347f, 
    -0.02390197f, 0.00997163f, -0.01776103f, 0.09391317f, 0.03584176f, -0.00429778f, 0.05551318f, 0.03139690f, 
    0.19963790f, -0.53797936f, -0.01164697f, -0.04615492f, 0.07161514f, 0.09266942f, -0.12515987f, -0.05483955f, 
    0.00220754f, 0.02840762f, -0.08325603f, -0.11681030f, 0.10634991f, 0.09015062f, -0.05418562f, -0.04337575f, 
    -0.05897449f, 0.00190378f, -0.05404965f, -0.08258228f, 0.03312659f, 0.04434436f, 0.07707492f, 0.18442352f, 
    0.09541753f, -0.18926157f, 0.12166512f, -0.03972169f, -0.00068683f, 0.06732456f, 0.06097078f, 0.02419739f, 
    -0.07035603f, -0.02292007f, 0.18758640f, 0.13547257f, -0.27448127f, -0.10579640f, 0.08192056f, 0.17034984f, 
    0.07420941f, -0.14120778f, -0.09753306f, 0.11695356f, -0.01617220f, -0.00941735f, 0.01445471f, -0.09508207f, 
    0.25902471f, -0.02581091f, 0.09377649f, 0.01434596f, -0.09767954f, 0.02542616f, -0.12549716f, -0.22356480f, 
    -0.02338350f, -0.04291498f, 0.05926393f, 0.05267445f, -0.07671795f, 0.04919743f, 0.14156459f, -0.02289745f, 
    -0.00692615f, 0.03965007f, -0.01227719f, -0.01229258f, 0.11607800f, 0.03032818f, 0.05677935f, 0.17889999f, 
    -0.38380882f, -0.11319217f, -0.10422154f, 0.05566119f, 0.14339253f, -0.04035379f, 0.05983895f, 0.04514346f, 
    0.00031457f, -0.06623010f, -0.03521077f, -0.04590062f, 0.09247514f, -0.01358392f, -0.17307097f, -0.10487778f, 
    -0.08982459f, -0.01099262f, 0.02319377f, 0.00967140f, 0.08273415f, 0.06865390f, 0.00709792f, -0.06955078f, 
    0.17378739f, -0.23222499f, 0.15439816f, -0.17119637f, -0.06040971f, -0.01477586f, 0.02810251f, 0.00498422f, 
    -0.10060927f, -0.02837976f, -0.00217555f, -0.09773704f, 0.32694638f, 0.23529169f, 0.02846867f, -0.37142813f, 
    0.03427821f, -0.12489682f, -0.05929522f, -0.13657020f, -0.23853521f, -0.04446780f, -0.00218634f, 0.08957662f, 
    -0.21335582f, -0.16106172f, 0.09450662f, -0.08500575f, 0.08036653f, 0.05035805f, -0.03940086f, 0.13439496f, 
    0.02661161f, -0.00518750f, -0.00476133f, 0.00920283f, -0.02313136f, -0.16868325f, 0.04233243f, -0.19442807f, 
    -0.22481446f, 0.05053470f, -0.09836520f, -0.22840118f, 0.05239291f, 0.06680621f, -0.13020168f, -0.01626059f, 
    0.16055119f, -0.44541842f, 0.15793999f, -0.46953988f, 0.00563182f, 0.13230681f, -0.01320262f, 0.09567320f, 
    0.01834085f, 0.00593518f, -0.03187689f, 0.07193035f, -0.06632952f, -0.32904971f, 0.06008255f, -0.15321206f, 
    0.00846428f, 0.02439499f, 0.00267742f, 0.06230579f, 0.03778159f, -0.04333777f, -0.03575199f, -0.00162852f, 
    0.04219433f, -0.19802502f, -0.12570310f, 0.12419429f, 0.05054525f, 0.08006026f, 0.05938013f, 0.01136426f, 
    0.04104754f, -0.00238546f, -0.04514722f, -0.12033406f, 0.00610616f, -0.04429699f, 0.02155362f, 0.10993201f, 
    0.06301779f, 0.01988334f, 0.02547573f, -0.11574130f, -0.02430157f, 0.02515298f, -0.02744419f, -0.01098510f, 
    -0.40852112f, 0.49883690f, -0.38825542f, 0.16836441f, -0.05469579f, -0.05521862f, 0.07582124f, -0.25225440f, 
    0.01953636f, -0.00324002f, -0.00522259f, 0.00036357f, -0.25430623f, 0.12472907f, -0.18119746f, -0.24118073f, 
    0.02618704f, -0.10578474f, 0.02353023f, -0.01619899f, 0.01893800f, 0.03349131f, 0.14022090f, 0.23703298f, 
    0.14560020f, -0.06328392f, 0.02121682f, -0.07947156f, -0.01918998f, 0.01125262f, 0.08600718f, 0.05871798f, 
    -0.10744156f, 0.06153334f, 0.20902298f, 0.12055570f, -0.05773240f, 0.05304829f, -0.06224417f, 0.10850818f, 
    0.18497649f, 0.07840492f, -0.01702977f, -0.15267818f, 0.18299335f, -0.05471517f, -0.01597838f, 0.09438377f, 
    -0.17028111f, -0.02251818f, 0.17851317f, 0.20108816f, -0.08484589f, -0.03358448f, -0.10010841f, -0.18382719f, 
    0.14871418f, -0.01061454f, 0.02593010f, 0.02335402f, -0.17278849f, 0.24590097f, 0.11930563f, -0.57110125f, 
    -0.27423146f, -0.12731539f, 0.00813484f, -0.04000792f, 0.08206128f, -0.03890579f, 0.08578643f, 0.00892549f, 
    -0.06458429f, 0.12217593f, 0.04540650f, 0.06257411f, 0.10322005f, -0.12288414f, -0.12726444f, 0.02052357f, 
    0.01834007f, -0.13489352f, -0.00008864f, 0.14336005f, -0.04335804f, -0.23627128f, -0.12865138f, -0.03568239f, 
    -0.26019606f, 0.18323846f, 0.00220402f, 0.13851246f, 0.09910258f, -0.01183064f, 0.02629238f, -0.05003715f, 
    -0.36689913f, 0.03586929f, -0.22416717f, 0.13422199f, -0.00431155f, 0.03395792f, 0.05536768f, -0.00529644f, 
    0.01628277f, -0.09342028f, 0.01277142f, 0.12306120f, -0.02108426f, 0.55953634f, -0.43419313f, -0.06201572f, 
    -0.17768829f, -0.02102863f, 0.17417392f, 0.18211852f, 0.05667789f, -0.04516325f, -0.05034003f, -0.03212346f, 
    0.15642264f, -0.03807132f, -0.14893226f, 0.01293198f, -0.05257458f, -0.15321666f, -0.11463813f, 0.00516428f, 
    0.10703337f, -0.03274671f, 0.17050363f, 0.02092853f, 0.10807152f, -0.41823667f, 0.10775372f, -0.02084843f, 
    0.04538796f, -0.06419081f, -0.05182347f, -0.04681396f, 0.01252741f, -0.02825545f, -0.09045959f, 0.09961946f, 
    -0.22602251f, 0.25215393f, -0.07961210f, 0.00764392f, 0.04111611f, -0.01353659f, -0.33386362f, -0.09309946f, 
    -0.11856522f, -0.14995758f, 0.15741141f, 0.12045279f, -0.04569840f, -0.10262346f, 0.10492911f, 0.45841932f, 
    -0.06384168f, 0.05149582f, -0.27608296f, -0.05008470f, 0.01216246f, -0.18620376f, -0.03641987f, 0.00605774f, 
    -0.02621963f, 0.03205128f, 0.47118533f, -0.51690131f, -0.00257744f, -0.44485995f, -0.04682524f, -0.16817766f, 
    -0.18227942f, -0.03626981f, 0.08735871f, -0.10556146f, -0.10920503f, 0.05458675f, -0.19702812f, 0.07438808f, 
    -0.01920387f, 0.01977437f, 0.16390239f, -0.06589040f, -0.04327681f, -0.05661488f, -0.12178904f, -0.05672477f, 
    -0.20729604f, 0.18477604f, -0.14684726f, 0.35783055f, 0.01287422f, 0.01611621f, 0.02743758f, -0.14498894f, 
    0.10200409f, 0.10386954f, -0.11874975f, -0.13765530f, -0.24176472f, 0.25537276f, 0.02883656f, -0.20663221f, 
    0.09531950f, -0.03658828f, 0.03626981f, 0.09181226f, 0.02428094f, 0.08009674f, -0.18043435f, -0.23170441f, 
    0.03398306f, 0.27186653f, -0.24751592f, -0.04297248f, -0.20023467f, -0.10751973f, 0.05059629f, -0.11395083f, 
    0.11424879f, 0.06214989f, -0.04122875f, 0.00391465f, -0.13116342f, -0.26298961f, -0.04775158f, 0.08075888f, 
    0.15079403f, 0.06554858f, 0.03928004f, 0.00400705f, -0.07101211f, -0.15992361f, -0.00632099f, -0.12674403f, 
    0.04126766f, -0.19514404f, 0.15089595f, -0.14391772f, -0.02958576f, 0.06174868f, 0.03081593f, 0.07204977f, 
    0.12846087f, 0.10443078f, 0.12870966f, 0.16740921f, -0.21819164f, 0.24765153f, -0.23528151f, -0.31590503f, 
    0.13136058f, -0.02682950f, 0.12462768f, -0.06532995f, 0.12923513f, -0.00373717f, -0.14109181f, -0.03879765f, 
    0.23686191f, -0.30997536f, 0.07918875f, -0.26827252f, 0.20657524f, 0.04713114f, -0.04165292f, 0.09336817f, 
    0.02201040f, -0.07705928f, -0.01499661f, -0.07942706f, -0.20566438f, 0.20329882f, -0.22298172f, -0.00317413f, 
    0.01586357f, -0.09676496f, 0.05985329f, -0.06154960f, -0.00968574f, -0.07307407f, -0.10701740f, -0.00944283f, 
    0.11097653f, -0.01041144f, -0.22527146f, 0.20583977f, 0.06165604f, 0.00893246f, 0.08624883f, -0.01869812f, 
    0.09436800f, -0.04405992f, 0.01485894f, 0.04908490f, -0.28609446f, -0.33566561f, 0.15410474f, 0.05676071f, 
    0.07140464f, 0.23288736f, -0.25100225f, 0.12988538f, -0.01463210f, -0.05386311f, -0.02749785f, 0.00374867f, 
    -0.11969847f, 0.47474235f, -0.67282170f, 0.15754205f, 0.01276762f, 0.09009901f, 0.30605873f, 0.05188852f, 
    0.08125908f, -0.02978963f, -0.03322032f, -0.05269398f, -0.31930599f, -0.52845287f, -0.26076123f, -0.33285537f, 
    -0.09495185f, 0.24023513f, -0.01745180f, -0.17841756f, -0.03741112f, -0.11751211f, -0.01799426f, -0.06734615f, 
    -0.38518396f, 0.26354504f, -0.03205926f, -0.19473666f, -0.09281031f, -0.15124789f, 0.08317775f, 0.16620713f, 
    0.00531515f, 0.08115087f, 0.01734587f, -0.01156641f, 0.02703649f, -0.05000930f, -0.33035129f, -0.53468382f, 
    -0.20284128f, 0.00933680f, 0.13452859f, -0.11312266f, 0.13957958f, 0.01953086f, -0.00699467f, -0.02802663f, 
    -0.06790723f, 0.13782948f, 0.10195766f, -0.28451273f, 0.12632199f, -0.08828960f, 0.03338720f, -0.11118325f, 
    0.09566567f, 0.06442487f, -0.00436207f, -0.04350146f, 0.23637815f, 0.17908472f, 0.38126799f, 0.11448546f, 
    0.07737016f, -0.15840286f, -0.14007065f, -0.10823537f, -0.04746552f, 0.05087672f, 0.12505247f, 0.04258516f, 
    -0.06906157f, -0.00700193f, -0.28317168f, -0.10777857f, -0.06877727f, 0.09099569f, -0.05282349f, -0.07281259f, 
    -0.04755143f, -0.03656538f, -0.20464608f, -0.10701223f, 0.01403296f, 0.07698964f, -0.03910185f, -0.07443480f, 
    -0.06754261f, 0.10054275f, 0.06494004f, 0.00507922f, -0.01599138f, 0.07439717f, -0.17629825f, 0.03197146f, 
    -0.10672502f, 0.14101231f, 0.12152785f, -0.00837040f, -0.05478108f, -0.16348641f, 0.09308373f, 0.01766233f, 
    -0.07996485f, 0.03688675f, 0.05334474f, 0.12991166f, 0.19981062f, -0.22908875f, -0.06404279f, 0.13370836f, 
    -0.14971830f, 0.13177054f, 0.02851980f, -0.13887428f, -0.12811424f, -0.08929417f, -0.09726814f, -0.07028376f, 
    -0.01410786f, -0.49667048f, -0.09623384f, 0.26770166f, -0.02995062f, -0.09128918f, -0.04949735f, 0.08410757f, 
    0.05119810f, 0.03365956f, 0.05725656f, 0.05245364f, -0.00562806f, -0.27154338f, -0.09592602f, -0.10709267f, 
    -0.03926519f, -0.07135452f, 0.04059657f, -0.02681550f, 0.02660753f, -0.07815713f, -0.00707187f, 0.00488388f, 
    0.01572812f, -0.10247520f, -0.09156623f, 0.02732911f, -0.02428116f, -0.19328769f, -0.03507557f, 0.01074366f, 
    -0.13618207f, 0.10589098f, -0.14870220f, -0.16823857f, -0.17083099f, 0.36930522f, -0.21633884f, 0.18316709f, 
    0.05624748f, 0.07215368f, 0.07495657f, -0.03378260f, 0.06616056f, 0.09358031f, 0.02077067f, 0.14363784f, 
    -0.21581881f, 0.01483684f, 0.22416542f, -0.00043966f, -0.05044222f, 0.09168254f, 0.00741100f, -0.06619275f, 
    -0.25316793f, 0.02075243f, -0.01515507f, 0.06425321f, -0.25087407f, 0.08009643f, -0.11021797f, 0.01692357f, 
    -0.00799717f, 0.10451180f, 0.04041726f, 0.07613446f, -0.00223671f, 0.02054473f, -0.13590284f, -0.12855561f, 
    -0.25630531f, -0.17647898f, -0.17712994f, -0.03892831f, 0.01085714f, -0.01997768f, -0.01082859f, 0.19670604f, 
    -0.05996417f, 0.11518757f, 0.03617149f, 0.02091558f, 0.13632853f, -0.08035509f, 0.20318964f, 0.11806960f, 
    -0.02702163f, -0.05563533f, 0.34674180f, -0.01868621f, -0.01017990f, -0.00611810f, 0.20565009f, 0.10053465f, 
    -0.06953406f, 0.06136926f, 0.01427564f, 0.26023772f, 0.08083812f, 0.02996633f, -0.24866037f, 0.09095351f, 
    0.12245709f, 0.07537027f, 0.14313151f, 0.09545654f, -0.30678558f, -0.20974730f, -0.33862829f, -0.43994373f, 
    -0.27650431f, -0.04409615f, -0.12101923f, 0.03237116f, -0.02826718f, 0.21979277f, -0.02598030f, 0.04281651f, 
    -0.29837739f, 0.05081642f, -0.17928059f, -0.11552434f, -0.07247858f, 0.02938972f, 0.18429363f, 0.06395859f, 
    -0.03224757f, -0.02405936f, 0.00784605f, -0.03965916f, 0.01466500f, -0.20748234f, -0.08258998f, 0.03627586f, 
    -0.02264095f, 0.01193532f, -0.19707833f, 0.13835925f, -0.07451403f, 0.13800296f, -0.06456973f, -0.08219627f, 
    -0.12373453f, 0.07948498f, -0.05704103f, 0.12208013f, 0.02735805f, 0.11909989f, 0.02354538f, -0.04508040f, 
    -0.03070809f, 0.11579583f, 0.03509603f, 0.04126104f, -0.14282930f, 0.14546844f, -0.28347310f, -0.03949070f, 
    0.04174801f, -0.04386333f, 0.11604018f, 0.02061058f, -0.20409285f, -0.16530794f, -0.21845435f, -0.35288689f, 
    -0.14743966f, 0.22163846f, -0.07135481f, -0.11198798f, -0.09051032f, 0.06202098f, -0.04208490f, -0.04585198f, 
    0.02364455f, -0.18264934f, -0.17066272f, -0.22250897f, -0.57950234f, -0.08558340f, 0.04898832f, 0.07922123f, 
    0.05393810f, 0.22865516f, -0.16702200f, 0.07265024f, -0.06901509f, 0.10116264f, -0.08180947f, 0.06117862f, 
    -0.11679035f, 0.31523871f, -0.03955350f, -0.16918969f, 0.09407698f, -0.00436374f, 0.04892857f, -0.06270511f, 
    -0.18500483f, 0.07920094f, 0.10726450f, -0.04115156f, 0.03997399f, -0.04564366f, -0.00783072f, 0.03031414f, 
    -0.01757843f, 0.13828976f, -0.00503827f, -0.02518829f, -0.03324836f, -0.13071437f, -0.29748023f, -0.38431534f, 
    0.02353026f, -0.32144839f, 0.15396497f, 0.04552180f, -0.17728221f, 0.10897754f, 0.02681460f, 0.20312430f, 
    0.03972678f, 0.01974420f, 0.13849546f, 0.22003731f, -0.20954138f, -0.13255239f, 0.20662385f, 0.12657051f, 
    0.02121859f, 0.03918716f, -0.07836194f, 0.09640317f, -0.02777342f, 0.03144826f, 0.02849720f, 0.06725110f, 
    -0.06495980f, 0.26644918f, -0.09552930f, 0.32547912f, -0.07036623f, 0.02561152f, -0.01110144f, -0.11006602f, 
    0.16140933f, 0.03433680f, -0.27898860f, 0.04819660f, 0.18609983f, 0.13804020f, 0.24658261f, 0.00757394f, 
    -0.12205314f, 0.07237738f, -0.15418495f, 0.01059576f, 0.05846890f, 0.19141561f, 0.18605223f, -0.08696929f, 
    -0.24501601f, -0.11003757f, -0.21264556f, 0.11976932f, -0.02216070f, 0.10491811f, -0.31135285f, -0.00629870f, 
    -0.14555287f, -0.01159907f, 0.04261209f, -0.04321208f, -0.04595654f, -0.00624921f, -0.12478644f, 0.19640577f, 
    0.03798199f, 0.08231287f, 0.15412383f, 0.01831170f, 0.10917012f, -0.03394811f, -0.17199722f, -0.13915676f, 
    -0.42779011f, 0.18640654f, 0.11434326f, 0.00336242f, 0.03450391f, 0.07068130f, -0.16718599f, 0.04161905f, 
    0.01127147f, -0.23931344f, 0.01547930f, -0.08373822f, -0.03114239f, 0.02349328f, 0.19028889f, 0.12635052f, 
    0.05104716f, -0.01084376f, -0.10438512f, 0.10086815f, 0.09456828f, -0.07354642f, -0.05063829f, -0.06042872f, 
    -0.12365159f, 0.16325879f, -0.27302489f, 0.08789863f, -0.08619859f, -0.07275117f, 0.04266047f, -0.13447887f, 
    0.03505240f, -0.03906286f, 0.16779003f, 0.18754770f, -0.24363334f, 0.04926477f, 0.14284414f, -0.10210835f, 
    -0.17579183f, -0.05610488f, 0.01904623f, 0.21301425f, 0.01603872f, -0.10324464f, 0.08704760f, 0.11686811f, 
    -0.02251428f, -0.02341130f, 0.19247274f, -0.15027718f, -0.08321174f, -0.04896059f, 0.21723704f, 0.14202920f, 
    -0.12660670f, 0.15344068f, -0.00080469f, 0.11272202f, -0.09043682f, -0.06406564f, 0.07568071f, 0.06187252f, 
    -0.02047131f, -0.08944433f, 0.00542800f, -0.05648749f, -0.08822193f, -0.03633762f, -0.18034558f, -0.26279393f, 
    -0.13447167f, 0.17657046f, -0.18367803f, 0.14884228f, 0.06854019f, -0.00832663f, -0.05208886f, 0.00772256f, 
    -0.22584447f, -0.16797596f, -0.27398899f, -0.35492226f, -0.27455634f, 0.07832263f, 0.02955715f, -0.19543503f, 
    -0.13560650f, 0.16161135f, -0.11394001f, 0.03290333f, -0.01808409f, -0.04141584f, -0.00015338f, 0.04140140f, 
    0.33553612f, -0.16282229f, 0.20038328f, -0.14974125f, 0.01394585f, -0.02445875f, -0.00341396f, 0.07026378f, 
    -0.04269176f, -0.04697200f, -0.12106498f, -0.25795576f, 0.01144993f, 0.03906055f, -0.04757823f, -0.02712803f, 
    0.10905311f, -0.06693099f, 0.11903975f, 0.11704318f, -0.10919031f, -0.02128376f, -0.05561415f, -0.13555802f, 
    0.13489404f, 0.23243745f, 0.27710763f, 0.06291643f, -0.13491483f, 0.05600937f, 0.00106702f, 0.08456775f, 
    0.07032765f, 0.03133811f, 0.03975675f, -0.06683192f, -0.25801471f, 0.10209587f, -0.55148846f, 0.04254214f, 
    0.05155667f, 0.07074824f, 0.08833667f, 0.12609695f, -0.01786494f, 0.05349292f, 0.02591931f, -0.07545298f, 
    0.35857892f, 0.41065210f, 0.23131134f, -0.13143064f, -0.10693957f, -0.07241012f, 0.07931242f, 0.08008978f, 
    0.08567533f, 0.12974092f, -0.14812778f, -0.14516895f, -0.01578449f, -0.61339408f, 0.28575990f, -0.12823503f, 
    -0.02490829f, -0.05779912f, 0.14510335f, 0.02855756f, -0.12377933f, -0.02779333f, 0.07453433f, 0.07023682f, 
    -0.25990707f, 0.14387068f, -0.07818989f, -0.00651185f, 0.06589851f, -0.10320660f, -0.07340944f, -0.06395424f, 
    0.13545202f, 0.10365470f, -0.41029820f, -0.54033589f, -0.14505826f, 0.26721516f, -0.35222611f, -0.13388675f, 
    0.00361682f, 0.11731556f, 0.12536454f, -0.22556978f, -0.17984097f, 0.11066823f, -0.04987066f, 0.03630296f, 
    0.05177820f, 0.11953202f, 0.30297154f, 0.01282067f, -0.04416673f, 0.10182627f, 0.19202085f, 0.07479346f, 
    0.06907180f, 0.17761432f, 0.06866120f, -0.14297917f, -0.50530761f, 0.31890869f, 0.07665318f, -0.17138842f, 
    0.19669756f, 0.04932602f, -0.02335256f, -0.19758442f, 0.01160097f, 0.06018760f, -0.08040684f, -0.11599181f, 
    -0.40594816f, 0.04656442f, 0.21753789f, 0.09473830f, 0.04908393f, -0.01072276f, 0.07500914f, 0.29589847f, 
    -0.01437625f, -0.22827601f, 0.11609940f, -0.01512563f, 0.07311437f, 0.00995216f, -0.04284276f, -0.03276267f, 
    -0.09416772f, -0.03815715f, 0.07221402f, -0.02485425f, 0.08879768f, 0.00526890f, 0.03568311f, 0.05292369f, 
    0.14308579f, -0.31955093f, 0.01576758f, -0.37066731f, -0.23860918f, -0.01399725f, 0.07354925f, -0.21209799f, 
    0.11409970f, -0.20917553f, -0.05764603f, -0.02320146f, -0.07246828f, -0.25874424f, 0.13941489f, 0.05436283f, 
    -0.07734375f, 0.09988015f, 0.31295630f, 0.20095871f, -0.03823194f, 0.00132638f, 0.03144604f, 0.20442627f, 
    0.36570758f, -0.04782287f, 0.15061033f, 0.01174136f, 0.05538499f, 0.05313043f, -0.04163721f, 0.16390078f, 
    -0.03980658f, 0.06564228f, 0.09190440f, 0.09047911f, -0.06934620f, 0.07151006f, 0.09321425f, 0.05169111f, 
    -0.06051562f, 0.06582820f, 0.05330162f, 0.00152437f, 0.02004327f, -0.03811754f, 0.15551166f, 0.18247923f, 
    -0.07073498f, 0.11002629f, -0.02903388f, 0.14783596f, 0.07169132f, -0.03187351f, -0.11494633f, 0.07406642f, 
    -0.23066054f, -0.19144280f, -0.23773362f, -0.52243119f, 0.02429145f, -0.18026447f, -0.05589927f, 0.05403307f, 
    -0.26149374f, -0.14420581f, 0.14768726f, 0.10294373f, -0.16300502f, 0.10702169f, -0.15226598f, -0.05649113f, 
    -0.13365667f, -0.18892440f, 0.33325624f, -0.06042957f, -0.13347314f, 0.17325334f, -0.10782857f, -0.11170344f, 
    0.04701683f, 0.03982950f, -0.03506338f, 0.09935506f, 0.00487562f, 0.17124736f, -0.16488063f, -0.07570938f, 
    -0.23369677f, 0.04373173f, 0.20808256f, -0.19524489f, 0.04083041f, 0.22819328f, -0.16682392f, 0.06650229f, 
    -0.21118131f, -0.03504528f, -0.15499051f, -0.06239868f, -0.02646544f, -0.03870243f, 0.02945302f, 0.02058160f, 
    -0.12963319f, -0.06124869f, -0.04964594f, 0.00281083f, -0.37065077f, 0.29037824f, -0.02476368f, 0.07183025f, 
    -0.00256649f, 0.01958057f, 0.00619517f, -0.07929464f, 0.00407931f, 0.02804661f, 0.21959360f, 0.12561347f, 
    -0.09442446f, -0.43858138f, -0.14959961f, -0.05403113f, -0.20083970f, -0.21441831f, 0.10103676f, -0.06545548f, 
    -0.16255976f, 0.17241719f, -0.03461322f, 0.00513178f, -0.04326022f, -0.08255494f, 0.39572179f, 0.05345834f, 
    -0.14674959f, -0.24028313f, 0.20201597f, 0.05551027f, -0.21987900f, 0.02966923f, 0.19903028f, -0.05893223f, 
    0.05073526f, -0.43034112f, 0.13083917f, -0.00344012f, -0.20460789f, -0.01514037f, 0.02598291f, -0.00837006f, 
    0.14642717f, -0.03752992f, 0.09292485f, 0.09856704f, 0.12395575f, 0.16716076f, 0.13893814f, 0.48040414f, 
    -0.08805278f, -0.28996998f, -0.00284428f, -0.08525680f, -0.38915244f, -0.04472076f, -0.14497262f, -0.00415535f, 
    0.09936530f, 0.11087123f, 0.22684436f, -0.00413979f, -0.11610580f, 0.06744468f, 0.04567095f, -0.04883348f, 
    -0.03287852f, 0.09062214f, 0.20675455f, 0.03745707f, 0.06052197f, -0.03105884f, 0.05905505f, 0.03945465f, 
    -0.00212186f, -0.02486540f, -0.05541065f, -0.01321555f, -0.09401870f, -0.01849051f, -0.06346133f, -0.19148687f, 
    -0.16744883f, 0.20554131f, -0.17484602f, 0.19967888f, 0.02902375f, 0.02525896f, 0.13701651f, 0.05416840f, 
    -0.02068900f, 0.11186960f, 0.07055790f, 0.11204452f, 0.23488009f, 0.04577625f, 0.01864354f, -0.09280615f, 
    0.04054022f, 0.07194739f, -0.04590948f, 0.03720096f, -0.07255784f, -0.02453650f, 0.10499617f, -0.07235436f, 
    0.05662971f, -0.07147322f, -0.00388944f, 0.19170022f, 0.05817214f, 0.07082462f, 0.13659827f, 0.02401735f, 
    -0.12224175f, -0.00119348f, 0.08120622f, -0.07753038f, 0.20236364f, -0.10425629f, 0.31473586f, -0.13480136f, 
    -0.05915448f, -0.14109077f, -0.02414369f, 0.07370878f, -0.02753485f, 0.08658063f, 0.08931784f, -0.05062004f, 
    -0.14143701f, -0.22098127f, 0.10448071f, 0.03220574f, -0.29581079f, -0.04385373f, -0.14213194f, -0.14643705f, 
    -0.02476224f, 0.09488314f, -0.04091163f, -0.02524476f, 0.14658859f, 0.03986448f, 0.01064969f, -0.22628102f, 
    -0.02256895f, 0.08099117f, -0.06128721f, 0.04201835f, -0.07508288f, 0.01699255f, 0.02677163f, -0.00411691f, 
    0.11822759f, 0.15457770f, 0.16274388f, -0.38827014f, -0.09578717f, -0.05368997f, 0.06076790f, -0.03796429f, 
    0.04472981f, 0.04307359f, -0.00464726f, -0.13647959f, -0.16928838f, -0.27625829f, -0.06432858f, 0.16154672f, 
    0.18319671f, 0.09287708f, -0.04176971f, -0.01260441f, -0.00001966f, 0.03099359f, 0.05357709f, -0.08584937f, 
    -0.44813082f, -0.21619301f, -0.39755818f, 0.49378058f, 0.18055786f, -0.03819127f, 0.07082782f, -0.00939755f, 
    -0.04622668f, -0.07960708f, 0.10728773f, 0.01454980f, -0.19242367f, -0.59898424f, 0.01076303f, -0.05955917f, 
    0.00054952f, 0.01919900f, 0.07216168f, 0.00528311f, 0.06980509f, 0.00440415f, 0.09885420f, 0.09923949f, 
    0.17975277f, -0.17571826f, 0.05605005f, -0.08179409f, 0.16358061f, -0.11004297f, -0.11268333f, -0.15535313f, 
    0.04122498f, 0.01898285f, -0.10194273f, -0.13058247f, -0.21156549f, 0.21591519f, -0.15083364f, 0.07753199f, 
    -0.06507128f, 0.07862793f, 0.24352810f, -0.38610029f, -0.05469214f, -0.00196837f, -0.14948158f, -0.09550790f, 
    -0.29881489f, 0.15267237f, 0.07618449f, 0.09972092f, 0.06456795f, 0.04287301f, -0.06699754f, 0.10324775f, 
    -0.22105661f, 0.00090159f, -0.01908297f, -0.01112110f, 0.23275582f, -0.03343314f, -0.01798763f, -0.09863672f, 
    -0.06306598f, 0.04022375f, -0.01890519f, 0.04363252f, -0.11353284f, -0.04178879f, -0.08915143f, -0.21209125f, 
    0.23396873f, 0.25112006f, -0.01188430f, 0.06534726f, -0.12686647f, 0.10465501f, -0.05204193f, -0.02275596f, 
    -0.05964055f, 0.04009965f, 0.09122648f, 0.10199682f, -0.33480778f, -0.06752702f, -0.28006488f, 0.06896606f, 
    -0.15243647f, -0.10686304f, -0.11225519f, 0.03642623f, -0.03944335f, -0.00458374f, 0.00137288f, 0.03090267f, 
    0.01072874f, 0.21289536f, -0.08196864f, 0.03084903f, -0.04498608f, -0.05398780f, 0.10235532f, -0.01373961f, 
    -0.05965804f, -0.06054363f, 0.16385351f, -0.02299274f, 0.15029609f, -0.24148078f, 0.21312398f, 0.20507213f, 
    0.24027358f, -0.11024258f, 0.11138374f, 0.11748718f, 0.09249274f, 0.11912669f, 0.07844417f, 0.12638432f, 
    -0.08606328f, 0.07506914f, -0.16387448f, 0.06630262f, -0.01657685f, 0.01159784f, -0.01406978f, 0.00635487f, 
    0.08637292f, 0.04371932f, 0.07351188f, 0.09903359f, 0.03867509f, -0.45853764f, 0.24662779f, -0.03990218f, 
    0.07136742f, -0.03406178f, -0.05380213f, -0.09799723f, 0.00662008f, -0.03683374f, 0.01462947f, -0.03629852f, 
    -0.14334081f, 0.01760772f, -0.24298784f, 0.34726897f, -0.01609383f, -0.07460567f, -0.09607811f, 0.00820713f, 
    0.01630100f, -0.13822059f, -0.07109318f, -0.01397477f, -0.05845065f, 0.04052249f, 0.09534515f, -0.16135269f, 
    -0.09160424f, -0.03373207f, -0.10276589f, 0.05029535f, -0.00763853f, 0.09623818f, 0.04363956f, -0.04040095f, 
    0.39296243f, 0.12515005f, 0.23690227f, -0.31785515f, -0.08575612f, 0.07816347f, -0.25088957f, -0.02144609f, 
    -0.06505162f, 0.02977006f, -0.14506432f, -0.01616294f, -0.18514745f, -0.55177188f, 0.04281846f, 0.02319490f, 
    0.01983572f, -0.39739972f, -0.02071417f, -0.04071442f, -0.03028700f, 0.00367855f, 0.06000163f, -0.00599317f, 
    -0.32753089f, 0.15194628f, -0.19272952f, 0.06728790f, -0.01943908f, -0.01891582f, -0.02123947f, -0.06607085f, 
    -0.12597333f, -0.12560542f, -0.04021546f, -0.03274375f, -0.35143003f, 0.02075735f, -0.23085439f, -0.05572907f, 
    0.11372273f, -0.12511532f, 0.01016387f, 0.03051231f, -0.20875324f, -0.03915099f, -0.17344673f, -0.02459426f, 
    0.07749126f, 0.05483834f, 0.10562517f, -0.23042822f, -0.20394123f, -0.05778729f, 0.01212156f, 0.04835624f, 
    -0.02441288f, 0.00541382f, -0.02862454f, -0.04194117f, -0.16032462f, 0.06660804f, -0.06117661f, 0.07389038f, 
    -0.08611867f, -0.13232169f, 0.00769163f, -0.14808625f, 0.07596388f, -0.08124743f, -0.09738536f, 0.16762812f, 
    -0.17427006f, 0.18789268f, -0.15588756f, 0.19941534f, -0.23564011f, -0.05382271f, 0.07062010f, -0.01390206f, 
    -0.12171145f, 0.21793804f, -0.16269760f, -0.00891261f, -0.14322081f, 0.08785278f, -0.20233247f, 0.04005266f, 
    -0.02322939f, 0.00427240f, 0.03643226f, -0.03308570f, -0.19065227f, -0.04891526f, -0.00695129f, -0.01062790f, 
    -0.00276663f, 0.03909734f, 0.08508880f, 0.23802894f, -0.06449214f, 0.04162493f, -0.13989900f, 0.02180514f, 
    -0.19385022f, -0.04309775f, -0.01575488f, -0.15025638f, 0.04256317f, 0.04526008f, 0.03606637f, -0.14080504f, 
    -0.03202925f, -0.02661368f, -0.04380753f, 0.00801393f, -0.09529586f, 0.03575828f, -0.02206742f, -0.00053311f, 
    0.40522063f, -0.22570829f, 0.37721536f, -0.20715010f, 0.15576062f, -0.09835246f, 0.00435395f, 0.21997236f, 
    -0.17003825f, -0.01745431f, 0.04544176f, 0.02507342f, 0.20356147f, -0.03615147f, 0.16502309f, -0.12579110f, 
    -0.02514401f, -0.03497049f, -0.07329855f, 0.10925280f, 0.09105596f, 0.14141348f, -0.07564893f, 0.02861353f, 
    -0.05584903f, -0.10783666f, 0.11988831f, 0.17649831f, -0.00364241f, 0.00271375f, 0.07446425f, -0.01050163f, 
    -0.01464761f, 0.04553523f, 0.05170817f, 0.07851376f, 0.22639875f, -0.09386726f, 0.15433143f, -0.15584572f, 
    0.14047179f, 0.03502703f, 0.10117373f, -0.03589336f, -0.04936721f, 0.18132490f, 0.16364624f, 0.06646672f, 
    -0.18361607f, 0.02984877f, -0.17712294f, -0.27311760f, 0.02537645f, 0.06274168f, 0.02522792f, -0.01636063f, 
    0.03855875f, 0.01099871f, 0.16112582f, 0.07291242f, -0.07438737f, -0.19559821f, -0.18900093f, -0.30939764f, 
    -0.12686794f, -0.20574458f, -0.01286315f, -0.12600662f, 0.16233949f, 0.06784292f, -0.02683640f, -0.07080334f, 
    0.00655429f, -0.04414457f, 0.16841763f, 0.09092740f, 0.19641311f, -0.05286269f, -0.07319033f, 0.10008547f, 
    0.05111196f, 0.03440933f, 0.00863481f, -0.06437637f, -0.33134606f, 0.10849640f, -0.43477613f, 0.14374958f, 
    -0.15617663f, -0.14631996f, 0.08464157f, -0.14917649f, 0.02126565f, 0.01854433f, 0.02859660f, 0.10999644f, 
    0.03000785f, -0.19634680f, 0.28241149f, -0.10473680f, 0.09512686f, 0.01453425f, 0.14839010f, 0.04257384f, 
    -0.04514091f, 0.00954567f, 0.07096162f, 0.16431734f, 0.18011729f, -0.06487777f, 0.47171935f, -0.05189878f, 
    0.02477446f, 0.10732266f, -0.00390350f, -0.03669198f, -0.04038611f, -0.03052206f, 0.07116380f, 0.13515088f, 
    0.19367845f, 0.14471386f, 0.04517810f, -0.26418206f, 0.09484777f, 0.01281260f, 0.13626337f, 0.26239240f, 
    0.00191575f, 0.04336077f, 0.09894291f, 0.20113808f, -0.19608365f, 0.09099978f, -0.40978694f, 0.18871911f, 
    0.09787603f, -0.15051197f, 0.12868814f, -0.18641922f, -0.02254302f, 0.13832779f, -0.01663495f, 0.01080677f, 
    0.07223056f, -0.14371216f, -0.08990319f, -0.06942862f, 0.09812155f, 0.08144972f, 0.12056139f, -0.16995054f, 
    0.11168082f, 0.08711787f, -0.05052270f, 0.06359270f, -0.55632079f, -0.12612310f, -0.51567835f, 0.38557732f, 
    0.27172202f, -0.01831143f, 0.08482970f, -0.09895827f, -0.01408519f, 0.03023065f, 0.13356012f, 0.17755464f, 
    -0.11920691f, -0.57135457f, 0.36335394f, -0.26502043f, -0.02695084f, 0.07514009f, 0.03493271f, 0.09736184f, 
    -0.17593497f, 0.03554245f, 0.09148879f, -0.16386037f, 0.12478106f, -0.13154742f, 0.29022989f, 0.00959251f, 
    -0.03059579f, -0.01328715f, -0.12339455f, 0.07173745f, -0.27077323f, -0.02565631f, -0.05076506f, -0.08717296f, 
    -0.18646199f, -0.16340724f, -0.10438593f, -0.24032812f, -0.01523630f, -0.06387873f, -0.12940282f, 0.09425776f, 
    -0.10132673f, 0.16336477f, 0.11195300f, 0.01571390f, 0.13874030f, 0.16861565f, 0.21694320f, 0.10745731f, 
    0.04701278f, 0.11610778f, 0.20249176f, -0.14009586f, -0.08086699f, 0.01101932f, -0.10938329f, -0.15077406f, 
    -0.34711352f, -0.00685092f, -0.01248286f, -0.10432644f, 0.03147884f, -0.04700707f, 0.15516850f, -0.02659179f, 
    -0.04624594f, -0.10804027f, -0.04774635f, -0.06668664f, -0.01850783f, 0.05775922f, 0.10243425f, -0.09604816f, 
    0.09184518f, -0.04242541f, -0.13647252f, 0.03171432f, -0.10300373f, 0.02705636f, -0.03740350f, -0.24367322f, 
    -0.28157014f, 0.14086664f, -0.06337041f, 0.14497955f, -0.05825753f, 0.09642071f, 0.05138105f, 0.06471485f, 
    -0.07928333f, 0.07649495f, 0.18884301f, 0.17606673f, 0.11524107f, -0.14725515f, 0.23808724f, -0.03871548f, 
    -0.13464437f, 0.17696141f, -0.05187491f, -0.10923839f, 0.02805114f, -0.01288030f, 0.11364133f, -0.03940403f, 
    0.24671088f, 0.30250654f, -0.08526183f, 0.03073901f, 0.06057164f, 0.00017057f, -0.00244970f, -0.07485093f, 
    -0.05217835f, 0.12462281f, 0.01659912f, -0.06216897f, 0.43767235f, -0.26684460f, 0.47991219f, 0.20697871f, 
    0.12549470f, -0.04376496f, -0.23945837f, 0.02883346f, -0.05349931f, -0.02854703f, 0.03482180f, 0.00598764f, 
    0.12092724f, -0.04590773f, -0.04384097f, -0.02271221f, 0.07914588f, -0.00013618f, 0.01980574f, 0.13815591f, 
    0.11823606f, 0.14513379f, 0.05737073f, -0.14355513f, -0.92682111f, 0.23301312f, -0.44504806f, 0.27155855f, 
    0.10297306f, 0.03858754f, 0.11478586f, -0.08208013f, -0.07538103f, -0.10087398f, 0.08592103f, -0.04129733f, 
    0.44156897f, 0.04889084f, 0.54221094f, -0.13886105f, -0.10498291f, 0.04522694f, -0.21425091f, 0.05571042f, 
    -0.11489340f, -0.04562383f, 0.00856693f, -0.00776032f, 0.23332770f, 0.02059215f, -0.27728248f, 0.17327239f, 
    0.13791379f, 0.07111873f, 0.14523873f, -0.15568723f, 0.05677935f, 0.07919080f, -0.01660329f, 0.06228408f, 
    -0.08266438f, -0.18484713f, 0.05686121f, -0.09979653f, -0.04655495f, -0.15134040f, 0.12434371f, -0.03805722f, 
    -0.03266262f, 0.05676749f, -0.07930686f, -0.01656899f, -0.16057901f, 0.04038129f, 0.15737961f, 0.07865574f, 
    -0.07909799f, 0.02646367f, 0.12481923f, -0.17681772f, 0.05926204f, 0.10937278f, 0.04420681f, 0.16253704f, 
    0.05914553f, -0.04571583f, 0.00567937f, 0.04687531f, 0.07293072f, 0.18992066f, -0.04280524f, 0.01621063f, 
    -0.15611100f, -0.00862167f, 0.14333253f, -0.11036453f, -0.25908807f, -0.27252409f, -0.24649529f, -0.07827505f, 
    -0.04284246f, -0.05283428f, -0.04909290f, -0.02434861f, -0.09716231f, 0.09873259f, -0.00924508f, -0.07163000f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13234065f, 0.05327199f, 0.09022570f, -0.03865405f, -0.08255538f, 0.07366811f, 0.02774419f, -0.11602236f, 
    0.09217803f, 0.04136670f, 0.04607680f, -0.02247117f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
