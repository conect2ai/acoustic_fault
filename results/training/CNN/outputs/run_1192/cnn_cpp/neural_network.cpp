#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.39536813f, -0.47552910f, 1.35977960f, -0.73315483f, -0.64225227f, 0.23449492f, 0.41174275f, 0.50423652f, 
    -0.11035606f, 0.00508006f, -0.20167041f, 0.54167181f, -0.21223879f, -0.15807223f, 0.53225309f, -0.17965128f, 
    -0.59676033f, 0.93930423f, 0.62700903f, 0.27926487f, 0.62972915f, 0.11028636f, 0.04837873f, 0.03334189f, 
    0.06072281f, 0.65373939f, -1.11095786f, -0.28655893f, 0.13249874f, 0.82990026f, 1.09133291f, 0.93843150f, 
    0.86307645f, -0.92793781f, -0.40980476f, 0.13873570f, -0.70621103f, -0.47949398f, -0.95915753f, -0.59075564f, 
    0.29558119f, -1.65603352f, -0.07163256f, -0.42225924f, -0.28570384f, -0.22384031f, -0.05782051f, -0.17936879f, 
    -1.14978337f, -1.34607911f, -1.52776408f, 0.19644055f, 0.62596732f, 0.50293660f, -1.91196656f, -0.67524606f, 
    -0.99291301f, 0.17379478f, 0.92901379f, 0.27609941f, 0.15301529f, 0.83279407f, 0.26635993f, 0.45932224f, 
    0.14346915f, 0.47168007f, 0.73823625f, 0.08779563f, -1.27531493f, -0.17123497f, 0.23092309f, -0.05440355f, 
    0.65716499f, 0.15492746f, -0.34480739f, -0.30296800f, 1.33912826f, -0.76839036f, -0.24272595f, -0.21716034f, 
    -0.45019743f, -0.59049988f, 0.32935995f, 0.95278156f, -0.40503690f, 0.87959617f, -0.14519382f, 0.30675185f, 
    -0.48151734f, -0.19121432f, -0.14397123f, -0.03618343f, 0.25266275f, 0.43599746f, 1.15823805f, 0.10056768f, 
    0.38375202f, 0.92697650f, -0.34149584f, 1.00495708f, 1.71645176f, -0.42509833f, -1.09977961f, -0.53070223f, 
    -0.12877552f, -0.08542999f, 0.22132632f, 0.37259609f, 1.21075284f, -0.75111073f, 0.37767327f, -0.58185744f, 
    0.68465376f, -0.08705759f, -0.12420105f, 0.36657712f, 0.66917831f, -1.70168984f, -1.00895083f, -0.59344661f, 
    0.82038927f, 0.48571643f, -0.50519669f, -0.32854870f, -0.59382391f, -0.65687734f, -0.04958647f, -0.16964187f, 
    -0.50886947f, -0.24403091f, -0.10645379f, 0.30813771f, 0.92288476f, 0.74071026f, 0.77323991f, -0.15249415f, 
    -1.03140128f, -1.26183951f, 0.31713620f, 0.65611196f, 0.84827006f, -0.00002825f, -0.23740594f, -0.16403037f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.08134361f, 1.00598836f, -0.47723368f, -0.09945045f, 0.00029046f, 0.67533398f, 1.05439496f, 0.01323300f, 
    0.58522862f, 0.66401368f, 0.32799807f, 0.28940588f, 0.81426316f, -0.28219777f, 0.91744804f, 0.76871514f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.29382893f, -0.53721535f, -1.00051451f, -0.56208915f, -0.40897554f, 0.21104349f, -0.13033038f, 0.09249780f, 
    0.17240736f, 0.09569455f, 0.07450870f, 0.43496031f, 0.22008090f, 0.13647446f, 0.30411163f, 0.20124558f, 
    0.05443689f, 0.30689535f, -0.05786502f, -0.31192064f, -0.41877213f, -0.21765968f, -0.28478649f, -0.22746710f, 
    -0.11146834f, 0.08876234f, -0.05606270f, -0.34673235f, -0.13887545f, -0.10619302f, -0.15121920f, -0.15303586f, 
    -0.22563010f, 0.19402440f, -0.04169364f, -0.23937361f, -0.47676706f, 0.01530403f, 0.00545604f, 0.02051062f, 
    -0.14365816f, -0.01755651f, 0.10506175f, -0.03202895f, -0.07824808f, -0.54903680f, -0.72412062f, -0.77222013f, 
    -0.07123008f, -0.11889839f, -0.20908178f, 0.11585810f, 0.09331620f, 0.18957464f, -0.56672835f, 0.75709802f, 
    0.47172478f, 0.19421031f, 0.29857084f, -0.08059891f, 0.04540974f, 0.10832965f, 0.08492884f, -0.36661395f, 
    -0.59260023f, 0.06520094f, -0.06165082f, -0.13491680f, -0.27298322f, -0.04043877f, 0.10855271f, 0.09419627f, 
    -0.19602290f, -0.20002785f, 0.43200487f, 0.05891226f, 0.22200185f, -0.11397665f, 0.19594961f, 0.13084222f, 
    0.19259103f, 0.02072125f, -0.00756287f, -0.14547768f, -0.03023871f, -0.21014078f, -0.03356458f, 0.06298600f, 
    0.14819354f, 0.28014043f, -0.06569306f, -0.14352997f, 0.17590708f, -0.07485346f, -0.04214037f, 0.00404012f, 
    -0.08470467f, -0.04430483f, 0.18901995f, 0.08420262f, -0.75042832f, -0.53998417f, 0.00196220f, 0.14921173f, 
    0.22222611f, -0.16518450f, 0.05021461f, 0.06211272f, 0.61020058f, -0.31026307f, -0.17128678f, -0.03622958f, 
    0.23118939f, -0.05631195f, -0.01975764f, 0.01486371f, 0.18534085f, -0.37359509f, 0.19797185f, 0.32229546f, 
    0.09851684f, -0.23580772f, -0.27743742f, 0.09671446f, 0.00684106f, -0.22887431f, -0.03570228f, 0.30140182f, 
    0.10502804f, -0.08187795f, -0.00769647f, 0.14103648f, -0.01381358f, 0.07595227f, 0.08857410f, 0.06334754f, 
    0.16373949f, 0.20328866f, 0.24272701f, 0.20522685f, -0.19469161f, 0.25338182f, 0.22662531f, -0.00250155f, 
    0.01239314f, 0.07844914f, 0.54130900f, 0.08182374f, 0.02132261f, -0.28801858f, -0.07598668f, 0.15550362f, 
    0.24873519f, 0.04668440f, -0.06865293f, 0.13555808f, 0.05230789f, -0.13495024f, -0.06484735f, 0.06563973f, 
    0.27512443f, 0.06022765f, 0.03422246f, 0.62404656f, -0.02974524f, 0.14209555f, -0.06642079f, 0.36790133f, 
    -0.17026603f, -0.31812701f, 0.28124833f, 0.13685228f, -0.08059756f, 0.44894975f, 0.12832092f, -0.27834558f, 
    -0.05868221f, -0.10168488f, -0.16705976f, -0.30700934f, -0.39093232f, 0.35656536f, -0.11305529f, -0.24097550f, 
    0.02656901f, -0.02072058f, 0.16605538f, -0.14643478f, 0.33232844f, -0.43489209f, 0.28172380f, 0.32614595f, 
    0.32640445f, -0.11573310f, 0.14057869f, -0.03170949f, 0.28832367f, 0.06803785f, 0.44584262f, 0.10697804f, 
    -0.23677751f, -0.31459174f, 0.11439780f, -0.10149625f, 0.25794765f, 0.15694197f, -0.02951458f, -0.07883084f, 
    0.12919994f, 0.23001209f, -0.00546246f, -0.57765281f, -0.08278449f, 0.20830218f, 0.19675162f, -0.16164577f, 
    -0.31884071f, 0.13558973f, -0.16872574f, 0.14068633f, 0.23590289f, 0.12675701f, -0.28626642f, -0.27997962f, 
    0.16568759f, 0.17913806f, 0.04808638f, 0.08662126f, 0.02007812f, 0.21991327f, 0.09861459f, 0.01313361f, 
    -0.40603486f, 0.05428042f, 0.10434006f, 0.19895659f, 0.06551176f, -0.29812384f, -0.31381679f, -0.04811206f, 
    -0.16015355f, 0.17734151f, 0.20045619f, -0.45162159f, 0.12520027f, -0.05072055f, -0.00533616f, -0.18070430f, 
    -0.13633597f, 0.09744281f, 0.14558108f, 0.33373970f, -0.18258166f, -0.13015269f, 0.12469257f, 0.06603158f, 
    0.23814689f, -0.19667885f, 0.12673347f, 0.06045786f, 0.02945271f, -0.28111029f, 0.33620766f, -0.42817250f, 
    -0.46360874f, -0.19186278f, -0.02240224f, -0.05290632f, -0.38899609f, -0.36287594f, -0.06313029f, -0.73640805f, 
    0.06981231f, 0.03395899f, -0.11873549f, 0.01289767f, 0.23366502f, 0.21732092f, 0.23296283f, 0.12481716f, 
    -0.24500668f, -0.32968420f, -0.22490463f, 0.39867389f, -0.41030616f, -0.06050904f, 0.01632601f, -0.14177711f, 
    -0.04494356f, 0.04547657f, 0.08676711f, -0.08193941f, -0.07758544f, -0.00958776f, -0.06779163f, 0.07717066f, 
    0.05777215f, -0.02834184f, -0.00386940f, 0.07046947f, 0.05932240f, -0.06646863f, 0.07325555f, 0.05935482f, 
    0.02125208f, -0.00004066f, 0.05484707f, 0.04628533f, -0.04555340f, -0.07534398f, 0.03143828f, 0.01366560f, 
    0.00091213f, -0.05560870f, -0.02913984f, -0.07555238f, -0.02275556f, 0.03854505f, -0.06682681f, 0.03579389f, 
    -0.03269181f, -0.04413193f, -0.01030602f, -0.04460029f, -0.08478196f, -0.00815221f, -0.00813925f, 0.05481077f, 
    0.06439254f, -0.06270548f, 0.00007740f, 0.00341427f, -0.08420101f, -0.07536355f, 0.05709040f, 0.06539164f, 
    0.02679941f, -0.02168524f, -0.07049143f, 0.02883819f, 0.01009855f, 0.00459823f, -0.08646142f, -0.08184582f, 
    -0.06984555f, -0.05167184f, -0.00604554f, 0.05023979f, 0.05909647f, -0.00360159f, 0.03404840f, -0.03610679f, 
    -0.06791376f, -0.05331827f, -0.02203858f, -0.00727443f, 0.01261284f, -0.00569747f, 0.02987253f, -0.06914840f, 
    -0.01632387f, -0.06798360f, -0.06554902f, -0.08258852f, 0.04057806f, -0.08241044f, -0.01085914f, 0.01317949f, 
    -0.08342884f, -0.05045172f, 0.02615089f, -0.03657301f, -0.02887088f, -0.05915849f, -0.02362325f, 0.04192904f, 
    0.02716936f, 0.07196725f, 0.07802546f, 0.05873963f, 0.00689202f, 0.02697979f, -0.06106501f, -0.02538291f, 
    -0.00275763f, -0.04102675f, -0.02283175f, -0.03990658f, -0.05103556f, -0.00947161f, 0.03577705f, -0.05309277f, 
    0.03365527f, -0.00382905f, -0.08540237f, -0.01032979f, -0.05515921f, 0.03369573f, 0.06234150f, -0.04435953f, 
    0.04033462f, -0.03181849f, 0.00417820f, -0.04506832f, -0.04135874f, 0.05953999f, -0.08413043f, -0.05206086f, 
    -0.04044907f, -0.08768132f, -0.04102226f, -0.06822838f, 0.05433585f, -0.07511294f, -0.01422662f, 0.06864863f, 
    0.04368627f, 0.05992171f, 0.01575217f, 0.00346441f, -0.08915915f, -0.06181582f, -0.01116107f, 0.01632710f, 
    -0.01624989f, 0.02001832f, 0.04158863f, -0.01151322f, -0.09600112f, -0.06170665f, 0.05580228f, 0.05894134f, 
    0.42493626f, -0.59364557f, -0.55985647f, -0.08442035f, -0.16363375f, 0.22336824f, 0.29823342f, 0.07126820f, 
    0.06395689f, 0.58193362f, 0.24289553f, 0.41352764f, 0.25840360f, 0.27874911f, 0.18989038f, 0.36448896f, 
    0.37358093f, 0.68081886f, -0.16674100f, -0.26510566f, 0.29684767f, -0.27712741f, -0.10785187f, -0.12101956f, 
    0.14498580f, -0.19037926f, 0.08192819f, -0.27377677f, -0.56986618f, -0.47525200f, -0.10178879f, -0.03893406f, 
    -0.15044999f, -0.13749844f, -0.31503183f, -0.37504572f, -0.03300249f, -0.30779409f, 0.35829905f, -0.18816592f, 
    -0.19112220f, 0.04496139f, 0.02371779f, 0.00861906f, 0.28306696f, -0.29718113f, -0.40067491f, -0.16192114f, 
    0.03240578f, 0.07052421f, -0.05990699f, 0.13330099f, 0.24009109f, 0.22629327f, -0.12046275f, 0.03234255f, 
    0.01628696f, 0.06336114f, -0.07395805f, 0.10776849f, 0.15718926f, -0.04863844f, 0.03970409f, -0.38949162f, 
    -0.27109477f, 0.02401361f, -0.21561810f, -0.02135164f, -0.13579433f, 0.27034366f, -0.00199511f, 0.01355267f, 
    -0.08588319f, -0.32697281f, -0.11208009f, -0.05698134f, -0.01161323f, -0.06292728f, 0.12561052f, 0.09946822f, 
    -0.07255486f, 0.43470436f, -0.09826403f, 0.42301428f, 0.09777033f, -0.03918075f, -0.01555741f, -0.07492810f, 
    0.33987316f, 0.28590047f, -0.06089538f, -0.18901399f, -0.31754652f, 0.06771482f, 0.10049188f, -0.05702402f, 
    0.27874589f, 0.00471962f, 0.38511878f, 0.25225201f, -0.19063996f, 0.27348724f, -0.13929705f, 0.03760442f, 
    -0.24052526f, 0.10078884f, 0.23106371f, -0.18058711f, 0.24122846f, 0.33303192f, -0.16250730f, -0.06365605f, 
    0.21910551f, 0.29736331f, 0.32912001f, 0.35746902f, 0.56003600f, -0.41492018f, -0.13370995f, 0.24092980f, 
    -0.20055792f, 0.02259968f, 0.05488036f, -0.15063211f, -0.02036974f, 0.10026349f, -0.15011151f, -0.02362899f, 
    -0.13599865f, 0.06880820f, 0.11118343f, 0.14186393f, 0.31009969f, 0.20485164f, 0.04039899f, 0.11313464f, 
    -0.17751050f, 0.33613878f, -0.01026424f, 0.05730241f, -0.06411365f, -0.24355213f, -0.00737520f, 0.18995950f, 
    -0.44333240f, -0.05604077f, 0.40967423f, 0.17293753f, 0.13105051f, 0.20497267f, 0.10042039f, 0.21202146f, 
    0.11117151f, -0.33751363f, -0.15393920f, -0.26738682f, -0.03305851f, 0.32674634f, -0.24781054f, 0.01592499f, 
    0.04171841f, 0.22866349f, -0.32438499f, 0.02377074f, 0.29272771f, 0.40003514f, 0.12130252f, -0.24194655f, 
    -0.05883399f, 0.09815256f, -0.22690196f, 0.15301037f, -0.46704105f, -0.31333831f, -0.08208446f, 0.05540071f, 
    -0.23291671f, -0.03129208f, -0.24193718f, -0.18026745f, 0.15882002f, 0.54001969f, 0.22050333f, 0.06106585f, 
    0.14633715f, 0.19446515f, 0.17595743f, -0.13570030f, -0.07415330f, 0.27312255f, 0.82118016f, 0.80932486f, 
    -0.14382717f, 0.16286422f, -0.07660514f, 0.06658054f, -0.14168520f, 0.21043776f, 0.28843364f, -0.04992792f, 
    -0.04725221f, 0.08904973f, 0.17376791f, 0.20371670f, 0.13998125f, 0.05659664f, 0.26824987f, -0.56396282f, 
    0.12330355f, -0.25177068f, -0.31597364f, -0.12458819f, -0.24456887f, 0.26163369f, -0.08241863f, 0.11204043f, 
    -0.24021125f, -0.11319470f, -0.14733839f, -0.03731662f, -0.13202657f, 0.06398330f, 0.09804765f, 0.13541947f, 
    -0.05927889f, -0.85198957f, -0.44521761f, 0.02254816f, -0.17472985f, -0.06622379f, -0.06912422f, -0.04925791f, 
    -0.36789370f, -0.12144130f, -0.11177321f, -0.24967946f, -0.35733953f, 0.04827022f, 0.04555380f, 0.07248102f, 
    -0.07947534f, 0.19903506f, 0.10190523f, 0.16315742f, -1.12207317f, -1.31103885f, -0.23841549f, -0.07796372f, 
    0.01157208f, 0.01865591f, 0.08015886f, 0.09145283f, -0.02200411f, -0.23231204f, -0.30416086f, -0.18893805f, 
    0.01597729f, -0.01527985f, 0.11147976f, 0.22731899f, 0.45019221f, 0.29573324f, 0.28188655f, -0.02106564f, 
    0.03076705f, -0.01532977f, -0.14402211f, 0.23047648f, -0.37483668f, -0.18258007f, 0.14217731f, 0.18741275f, 
    0.24759242f, -0.00864922f, 0.12478397f, -0.04063853f, 0.14761186f, 0.28992209f, 0.38986182f, -0.14475982f, 
    -0.63952500f, -0.36561471f, 0.10468041f, 0.02061463f, -0.08958387f, 0.18580317f, 0.04602074f, 0.00313875f, 
    -0.26625177f, 0.19079231f, -0.15926912f, 0.14296468f, -0.16012383f, 0.07878075f, -0.07088836f, 0.16736105f, 
    0.06334078f, -0.08146629f, 0.09897255f, 0.30385363f, 0.18294281f, 0.05527484f, 0.02540592f, 0.13548027f, 
    0.09798390f, 0.35303941f, -0.18764113f, -0.02282949f, 0.02030528f, -0.38498026f, -0.12433925f, -0.36851740f, 
    0.05443515f, 0.07090973f, -0.05705585f, -0.12091949f, 0.20021133f, 0.43963835f, -0.01976654f, -0.07748280f, 
    -0.14960201f, 0.25204766f, -0.15472582f, -0.11534157f, -0.45701516f, -0.19478934f, -0.16728149f, -0.04844092f, 
    -0.04127485f, -0.04787052f, 0.09990025f, 0.02863138f, 0.22423741f, 0.35672948f, 0.46456465f, 0.13862316f, 
    -0.04290875f, 0.02379367f, 0.22036693f, 0.10034234f, 0.12125108f, 0.33915937f, -0.12705892f, -0.08676881f, 
    0.02459985f, 0.08131124f, -0.25660166f, -0.37197897f, 0.18577412f, 0.16660587f, -0.00070159f, 0.08151334f, 
    -0.43357840f, 0.32286841f, -0.10086720f, -0.20539945f, -0.20009156f, 0.27053401f, -0.05516763f, 0.28723937f, 
    -0.10629722f, -0.01820807f, 0.08789840f, -0.01468602f, -0.02099146f, 0.01745464f, 0.00983639f, -0.28305480f, 
    -0.26985875f, -0.52374804f, 0.29574278f, 0.20289274f, 0.09014806f, 0.10633633f, -0.12425664f, 0.06541233f, 
    0.00601514f, -0.27513209f, -0.07073300f, 0.19098327f, 0.21566689f, 0.02506495f, 0.21647653f, -0.23618083f, 
    -0.05027708f, 0.14645433f, 0.22850347f, -0.19132373f, 0.01185647f, -0.81724477f, 0.04699476f, -0.01856848f, 
    0.14163725f, -0.05123572f, 0.12509590f, 0.15199941f, 0.21806428f, -0.00220146f, -0.05429247f, 0.23574975f, 
    0.36840811f, 0.26963788f, 0.04131640f, -0.04688477f, 0.26353839f, 0.01041318f, -0.07763886f, -0.43510461f, 
    -0.06562449f, -0.04928275f, -0.10475284f, -0.05716551f, -0.24544367f, -0.09288472f, -0.10937142f, 0.12839939f, 
    0.37899476f, 0.18221274f, -0.02104270f, 0.11315547f, 0.22966003f, 0.02888662f, 0.18381839f, 0.13578169f, 
    -0.34207025f, 0.09476031f, 0.16305742f, -0.29896101f, -0.37950519f, -0.16371182f, -0.12559469f, 0.01967881f, 
    0.27159047f, -0.26165569f, -0.22384728f, 0.14750543f, 0.04946685f, -0.01878873f, 0.06107391f, 0.14615698f, 
    -0.30621344f, 0.12222277f, 0.03077716f, -0.25385752f, 0.12480987f, 0.03967628f, -0.10680716f, 0.03641354f, 
    -0.25480464f, 0.04862888f, -0.75619930f, 0.31289428f, 0.08549098f, -0.26126906f, -0.02125264f, 0.13297407f, 
    -0.02836358f, -0.03171466f, -0.18625219f, -0.13390161f, -0.06269986f, -0.35588521f, -0.09580950f, 0.09951468f, 
    -0.14597987f, -0.01827708f, 0.05913511f, 0.09495621f, 0.11361948f, -0.33704257f, -0.28384417f, 0.23912731f, 
    -0.40014210f, 0.08944495f, -0.07459922f, 0.20901057f, 0.05189242f, -0.10950641f, -0.65252227f, 0.36426997f, 
    -0.13110879f, -0.08872948f, 0.01584810f, -0.16287467f, 0.07038491f, 0.08124775f, 0.97851169f, -0.41329414f, 
    -0.33402017f, -0.09207310f, 0.07361283f, 0.04027808f, -0.02571787f, -0.24029794f, 0.08135792f, -0.23520258f, 
    0.05883741f, 0.12321926f, -0.21817805f, -0.03218649f, -0.21108717f, 0.09834762f, -0.17067759f, -0.05697718f, 
    -0.41894579f, 0.28912437f, 0.49842629f, 0.03812041f, 0.22049901f, 0.07603166f, 0.16653809f, 0.30791366f, 
    0.31851098f, 0.09190605f, 0.28093308f, 0.02964940f, -0.16080606f, 0.34272760f, -0.21737619f, 0.09214922f, 
    0.13687633f, 0.14320344f, -0.34810770f, 0.12353699f, 0.20018254f, -0.26181605f, 0.08156433f, 0.03646209f, 
    0.04086746f, -0.09451561f, 0.09644967f, -0.59874260f, 0.34985059f, 0.12377636f, -0.06177382f, 0.05583065f, 
    0.03667679f, -0.14578007f, 0.17531954f, -0.07287152f, 0.10487722f, 0.09087195f, 0.49284923f, 0.08480126f, 
    0.14433329f, -0.06331401f, 0.20220879f, -0.03069478f, -0.10910030f, 0.73652393f, -0.24950168f, -0.91478509f, 
    -0.04912607f, 0.05211695f, 0.26164383f, 0.03410548f, 0.15255903f, 0.11683351f, 0.09958330f, -0.41631687f, 
    -0.25679836f, 0.21345288f, 0.12833971f, -0.01231625f, 0.24868970f, -0.12429390f, -0.09791314f, 0.20642219f, 
    -0.69499737f, -0.05692495f, -0.16312554f, -0.06987055f, 0.34571570f, 0.05140880f, 0.03648319f, 0.02349515f, 
    0.08598704f, -1.13659835f, -0.51799959f, 0.00113040f, 0.01256357f, -0.12840506f, -0.01478513f, -0.11586867f, 
    -0.16295898f, 0.26256189f, -0.15370901f, 0.05098742f, -0.02811386f, 0.09178632f, 0.10698227f, -0.10049459f, 
    0.10270174f, 0.09578401f, -0.32320428f, -0.14181596f, -0.11268813f, 0.05645815f, -0.17062762f, -0.24267709f, 
    0.29566908f, 0.33958530f, 0.10274871f, 0.19616830f, 0.05819861f, 0.18102267f, -0.74164569f, -0.29889059f, 
    -0.17261745f, -0.02158853f, 0.16947876f, 0.10650339f, -0.58865076f, -0.09565118f, -0.07097641f, -0.13990460f, 
    -0.31973502f, -0.08699631f, 0.01472000f, 0.08657081f, -0.03474259f, 0.49805206f, 0.39364406f, 0.16121903f, 
    -0.23137861f, -0.25616059f, -0.34311417f, 0.13507850f, -0.06061358f, -0.09662478f, -0.25106746f, 0.52020401f, 
    0.44091201f, 0.16973202f, -0.04423097f, 0.05223740f, 0.04012793f, 0.03727316f, 0.30328339f, -0.53900629f, 
    -0.17763336f, 0.00670671f, 0.11007848f, -0.25221378f, -0.32867566f, 0.19226190f, 0.00210100f, -0.18735582f, 
    -0.14645121f, -0.00682741f, -0.44730932f, 0.16861631f, 0.11832651f, 0.01799312f, 0.29158831f, 0.26558924f, 
    0.05529017f, 0.12315340f, 0.09899021f, 0.02218828f, 0.05187359f, -0.16007404f, -0.13267426f, -0.05516635f, 
    0.04506069f, 0.05349718f, 0.17736995f, 0.19837590f, 0.20193222f, -0.33686325f, -0.49250877f, -0.03248695f, 
    0.25445178f, 0.14846383f, 0.01993507f, 0.43251625f, -0.56482571f, 0.16707954f, 0.08727755f, 0.17943738f, 
    -0.15183252f, -0.03914695f, -0.14390063f, -0.16137116f, -0.21922405f, -0.24034983f, -0.66694456f, -0.07868022f, 
    0.42291048f, -0.00294451f, 0.19021930f, -0.15191928f, -0.06577943f, -0.89132071f, -0.16092712f, 0.39082575f, 
    -0.14715976f, -0.15865125f, 0.12247246f, 0.09571070f, 0.12287976f, 0.17728430f, 0.26767749f, 0.49174052f, 
    -0.03912417f, 0.12006415f, 0.00815381f, 0.00887202f, 0.17004439f, -0.02125341f, 0.01867971f, -0.17129056f, 
    0.39730531f, 0.43425921f, -0.05335753f, -0.28230742f, -0.06410281f, -0.00371117f, 0.16718648f, 0.06361897f, 
    -0.40513843f, -0.00142908f, 0.75099105f, -0.12818229f, 0.19298948f, 0.10229515f, -0.27155057f, -0.23563814f, 
    -0.00278330f, 0.13824978f, 0.50168198f, -0.00396757f, 0.15178581f, 0.19358921f, -0.10602215f, 0.09606849f, 
    0.13759159f, -0.26479149f, 0.13272657f, -0.12678124f, 0.32714349f, -0.13138431f, -0.11733371f, -0.19975179f, 
    0.17035531f, 0.19611332f, 0.04404489f, -0.13500264f, 0.26146454f, -0.19694912f, -0.01144041f, 0.29708874f, 
    -0.54561722f, -0.25977075f, -0.03684215f, -0.01235385f, -0.03589959f, 0.16046382f, -0.26380989f, 0.09934350f, 
    0.08855531f, -0.07573729f, -0.08723625f, -0.02193592f, -0.00007972f, -0.31740615f, -0.27061895f, -0.71473610f, 
    -0.06492034f, -0.10944583f, -0.23575960f, 0.19057344f, -0.13637190f, 0.03068237f, -0.55971259f, 0.21688212f, 
    0.10697942f, 0.06392334f, 0.09052758f, -0.09604831f, -0.01371515f, 0.11418813f, 0.05113132f, -0.02714003f, 
    -0.06868967f, 0.16840781f, 0.03174374f, 0.08659180f, -0.19486289f, 0.22703175f, 0.21153870f, -0.13394994f, 
    0.05877519f, -0.22830325f, 0.55746078f, 0.06208606f, 0.20102413f, 0.10466465f, 0.15875444f, -0.01823339f, 
    0.34948054f, -0.06200285f, 0.23636544f, 0.34494299f, -0.02215026f, 0.12792599f, -0.39799404f, -0.00719702f, 
    0.37098938f, 0.16067831f, 0.11560660f, 0.13485502f, 0.09462380f, 0.09001952f, -0.16390193f, -0.20224398f, 
    -0.09833909f, 0.00700491f, -0.11668431f, 0.73861372f, -0.30986103f, -0.11081986f, 0.22309642f, -0.09292869f, 
    0.21020010f, 0.19826093f, -0.08675067f, -0.09586983f, 0.56020808f, 0.15574820f, -0.07273768f, -0.11564672f, 
    0.12503895f, 0.36270165f, 0.04319916f, 0.08656041f, -0.29094157f, -0.28983343f, -0.04301650f, 0.25983042f, 
    -0.04122763f, -0.22319229f, -0.31640622f, -0.31310761f, 0.13510811f, 0.60791492f, 0.07865296f, 0.41119769f, 
    -0.10665159f, 0.00122974f, 0.15897660f, 0.18056236f, 0.05470829f, 0.03990500f, -0.31637061f, -0.33803967f, 
    0.23088130f, -0.14174420f, -0.11546390f, -0.09937850f, 0.06357162f, -0.10923224f, 0.09281170f, 0.25893080f, 
    -0.09264906f, -0.04066243f, -0.06196021f, 0.02327475f, 0.06971154f, 0.02050092f, -0.09620824f, 0.05403828f, 
    0.04998808f, -0.09608480f, -0.04555547f, -0.05293388f, -0.02937284f, 0.05297490f, 0.00321728f, -0.02629682f, 
    -0.10931203f, -0.02652423f, -0.00794503f, 0.05615344f, -0.08099695f, 0.02649341f, 0.03177058f, -0.01525607f, 
    -0.09088005f, 0.02820650f, -0.01377913f, 0.03702696f, 0.06411691f, -0.08919766f, 0.05212955f, 0.02323697f, 
    0.01196668f, 0.05490452f, 0.00936791f, -0.05327129f, 0.05301182f, 0.05109857f, 0.04895605f, 0.00497108f, 
    0.01575817f, 0.00700523f, -0.08356096f, -0.05529304f, -0.04093032f, -0.07810941f, -0.05433321f, 0.00478727f, 
    -0.05634509f, -0.08553309f, -0.09085234f, 0.05463799f, -0.03864921f, -0.00452830f, -0.03933074f, 0.01219332f, 
    -0.08519305f, -0.03632510f, 0.00453371f, 0.00609754f, -0.06456952f, 0.06481304f, -0.04253780f, -0.08588645f, 
    0.00599398f, -0.00522460f, 0.00632560f, -0.10595147f, -0.08265724f, 0.02359713f, 0.01639652f, -0.09176809f, 
    0.04941639f, 0.00759236f, -0.02430342f, -0.01516207f, -0.04386841f, -0.08901896f, 0.05007438f, 0.05978649f, 
    0.02421758f, -0.02409876f, -0.04576789f, 0.04369169f, 0.02562954f, -0.00603950f, 0.00807684f, -0.08001150f, 
    0.01044538f, -0.04522882f, -0.01152330f, 0.02021139f, 0.04770977f, -0.09036398f, -0.00297231f, -0.01858246f, 
    -0.11120827f, -0.01617178f, -0.01807657f, -0.00216620f, -0.07428239f, -0.07391348f, -0.08556076f, 0.06302354f, 
    0.01724520f, -0.04010070f, -0.00591211f, 0.01544110f, 0.02683888f, 0.06307169f, -0.06071985f, -0.07387437f, 
    0.00739699f, -0.03907779f, 0.00050864f, 0.03436666f, 0.04511630f, 0.03532241f, -0.05589047f, -0.08933750f, 
    0.06956982f, -0.03106751f, 0.04409380f, -0.07893828f, -0.07834177f, 0.04462237f, 0.04544964f, -0.00323305f, 
    0.03139208f, -0.05243768f, 0.04800770f, 0.04505818f, -0.03566565f, -0.00277657f, 0.04255367f, 0.07237116f, 
    0.04833322f, -0.05727931f, 0.04646904f, -0.07246356f, -0.07922684f, -0.04315766f, -0.03121839f, -0.01546172f, 
    0.04763116f, 0.00793692f, 0.05911363f, 0.07500618f, 0.07166040f, 0.00882167f, 0.06340667f, 0.05786030f, 
    -0.07840596f, 0.03641473f, -0.02739213f, 0.00653348f, -0.00654881f, -0.01546834f, -0.04502609f, 0.04180784f, 
    0.02875744f, 0.01701410f, 0.06302509f, 0.03018908f, -0.04151004f, -0.07870542f, -0.01812976f, -0.01976301f, 
    0.00688574f, 0.01317883f, -0.08657743f, -0.02389906f, -0.07610583f, -0.07101189f, -0.00412689f, -0.08502283f, 
    0.07382167f, 0.04092499f, -0.05919344f, -0.07115949f, 0.03913812f, -0.06516273f, -0.08213814f, -0.07067907f, 
    -0.07549912f, 0.02173342f, -0.03959891f, -0.06973848f, -0.07884458f, -0.03246795f, -0.03072242f, -0.02372933f, 
    -0.02651867f, 0.07233688f, -0.00163279f, 0.01791634f, -0.03771826f, -0.02149665f, -0.00924728f, -0.04361324f, 
    -0.08019773f, -0.00493812f, 0.02780435f, -0.02349642f, -0.03429546f, -0.05050875f, 0.01219390f, -0.02334999f, 
    -0.06816150f, 0.02276374f, 0.02385740f, 0.01353676f, -0.01314590f, -0.01929294f, -0.01294665f, 0.02229043f, 
    -0.02404723f, 0.01062692f, 0.06165743f, -0.05115689f, 0.06260438f, -0.03233486f, -0.01509820f, 0.02576679f, 
    -0.08333348f, 0.00755083f, -0.02601959f, 0.06764662f, -0.04252953f, -0.06088904f, -0.08271270f, -0.07494783f, 
    -0.08806681f, -0.06043728f, 0.06300761f, 0.01406887f, -0.03509924f, 0.03836024f, -0.06949086f, -0.02586065f, 
    -0.00746713f, -0.00129881f, -0.04273512f, -0.01059919f, -0.05875032f, 0.03145223f, 0.03094377f, -0.01071180f, 
    -0.01457134f, -0.03725242f, 0.04362699f, -0.01570624f, 0.00932846f, 0.06258142f, -0.02641778f, 0.00192981f, 
    -0.02461669f, 0.06256548f, 0.00077260f, 0.02432532f, 0.05832693f, 0.01976222f, -0.07350085f, -0.03168995f, 
    -0.01839495f, -0.03096930f, -0.03876794f, -0.06975722f, 0.00215336f, 0.02724935f, -0.07424861f, -0.00687692f, 
    -0.03340156f, -0.06364421f, 0.06319639f, 0.03675192f, -0.07232123f, 0.02778938f, 0.03482268f, 0.01898891f, 
    0.06074103f, -0.05904343f, -0.02652578f, -0.06769547f, 0.05941447f, 0.01826477f, 0.02576794f, -0.03063643f, 
    -0.32148147f, -0.14669210f, 0.02822684f, 0.08956302f, 0.13388130f, -0.10015482f, 0.01293294f, -0.04072443f, 
    -0.02492830f, 0.11996400f, 0.29991323f, -0.09079517f, 0.13660383f, 0.39707080f, 0.01152192f, 0.05803666f, 
    0.27880311f, -0.26176313f, 0.19104125f, -0.02727208f, 0.18876070f, -0.43140694f, -0.14091720f, -0.33161208f, 
    0.13707279f, -0.20807026f, -0.08451637f, -0.14220084f, 0.02403161f, -0.08827591f, -0.24906531f, 0.02888318f, 
    0.02854315f, -0.00482483f, -0.40169850f, 0.06975327f, 0.05702559f, -0.04312285f, -0.83433104f, -0.12838337f, 
    -0.11437781f, -0.22145776f, 0.08218425f, -0.02788286f, -0.22315374f, -0.02144878f, -0.48571986f, -0.01857456f, 
    0.08339771f, 0.20724800f, 0.10402342f, -0.04878112f, -0.18443145f, 0.12584734f, 0.43084237f, -0.01508228f, 
    -0.31469703f, -0.01571159f, -0.17047057f, -0.09627274f, 0.21902297f, -0.18579096f, 0.10088757f, -0.33835420f, 
    -0.02377324f, -0.11207156f, 0.00046618f, -0.07469762f, 0.03433994f, 0.23057343f, 0.03745849f, 0.15512897f, 
    -0.12152573f, 0.13400652f, 0.40567365f, 0.00364969f, 0.18294574f, -0.11109205f, -0.14428149f, 0.09097561f, 
    0.24830931f, 0.31345889f, -0.13705176f, -0.10584091f, -0.13720793f, 0.19716230f, -0.13835466f, 0.02751622f, 
    0.08803271f, 0.08271937f, 0.03282885f, 0.07593603f, 0.23808129f, 0.07005511f, -0.10963316f, -0.14030135f, 
    0.22114125f, -0.34060436f, -0.34695098f, -0.32903534f, -0.38276866f, 0.19069815f, 0.00028924f, -0.01609924f, 
    0.14415516f, 0.09205698f, -0.00753599f, 0.08385075f, 0.51572526f, 0.00532763f, 0.19801629f, 0.22717014f, 
    0.31354916f, 0.21821272f, 0.34430575f, 0.28036690f, 0.22881462f, 0.12786147f, 0.08510190f, 0.03861299f, 
    -0.07183792f, 0.02762994f, -0.11080147f, -0.01985640f, -0.21091749f, -0.25661007f, 0.04830548f, -0.06073394f, 
    -0.20141342f, 0.16090019f, 0.06023242f, 0.25250939f, 0.19385228f, -0.06306147f, 0.14049852f, -0.10217534f, 
    -0.34654346f, -0.65635556f, -0.24565822f, 0.20441015f, -0.01649537f, 0.05102115f, -0.17135704f, -0.22975238f, 
    0.25390163f, -0.08998703f, 0.28858024f, 0.06843431f, 0.30726248f, -0.32176024f, 0.25868472f, 0.24643485f, 
    0.05545413f, -0.13328631f, -0.51820481f, 0.23773724f, -0.12203953f, -0.03798477f, -0.17578350f, 0.17074500f, 
    -0.09851118f, 0.08364260f, -0.10141797f, -0.27996930f, -0.38377973f, 0.04056682f, -0.01183740f, 0.21461904f, 
    0.04328176f, 0.08602969f, 0.18614063f, -0.07338963f, -0.08987805f, -0.16789635f, 0.06071043f, 0.19452745f, 
    0.05613853f, -0.04622943f, -0.27938783f, -0.10370663f, 0.63293982f, 0.38463005f, 0.12263504f, 0.16603114f, 
    -0.03593139f, 0.21211302f, 0.08641735f, -0.14855613f, -0.08443126f, 0.40187684f, 0.28625786f, -0.17729466f, 
    -0.00622814f, -0.20026697f, -0.20546310f, -0.00665363f, -0.15098496f, 0.10143914f, 0.18892072f, -0.16641599f, 
    -0.17285933f, 0.02298691f, 0.12265126f, -0.00629987f, 0.07061625f, 0.15065476f, -0.06384566f, -0.22265716f, 
    0.03495234f, 0.07520159f, -0.13311845f, 0.00597489f, 0.07329975f, 0.29715806f, 0.11895083f, -0.02682069f, 
    -0.00495423f, -0.21573605f, -0.69862425f, -0.02000715f, -0.11799420f, -0.20626459f, -0.36351478f, -0.07248610f, 
    -0.20577046f, 0.32591632f, -0.11682563f, -0.10525902f, 0.11754514f, -0.00508180f, -0.00235839f, -0.03058389f, 
    0.04664022f, -0.06189594f, 0.09386363f, 0.07719205f, 0.20219542f, 0.16113061f, 0.02573875f, 0.02797984f, 
    0.00479657f, 0.00728690f, 0.18511166f, -0.78677374f, -0.30823883f, 0.18098722f, 0.01630980f, -0.05045908f, 
    -0.09633485f, 0.08269365f, 0.25499785f, 0.16636033f, -0.43082082f, 0.13796775f, 0.14882843f, 0.01858185f, 
    -0.14751892f, 0.18475044f, -0.02346411f, 0.30635974f, -0.01116883f, 0.65660989f, 0.27786469f, -0.45967233f, 
    -0.10570192f, 0.27591583f, 0.25568384f, -0.22224402f, 0.00644282f, -0.13823925f, 0.01758018f, 0.06360449f, 
    0.03299705f, 0.00076275f, -0.03154476f, 0.05862647f, 0.05890206f, 0.39366996f, 0.14351454f, 0.39515108f, 
    -0.37964675f, -0.32318226f, 0.06301551f, 0.10652705f, 0.08756434f, 0.05322083f, -0.04176246f, 0.15468675f, 
    -0.13109989f, 0.62864929f, 0.06379105f, -0.17160404f, -0.36040977f, 0.34256640f, -0.20464575f, -0.08906405f, 
    0.06883333f, -0.28560227f, -0.48954794f, 0.16192155f, 0.00859888f, 0.03490626f, -0.18284805f, 0.20310061f, 
    -0.26634735f, 0.25754139f, -0.17866279f, 0.02803371f, 0.39758840f, 0.17796853f, 0.02742026f, 0.31391081f, 
    0.01489099f, -0.34072062f, 0.36839005f, 0.16748735f, -0.20722292f, 0.04130740f, -0.56422246f, -0.03888210f, 
    -0.14914897f, 0.11721821f, 0.06221356f, -0.06938893f, -0.02516862f, 0.04297630f, 0.73338062f, -0.05984377f, 
    -0.19362530f, -0.11561015f, -0.00387756f, -0.09787339f, -0.06697293f, -0.16720377f, 0.10925195f, 0.23399930f, 
    0.06228719f, 0.04155954f, -0.09590934f, 0.02311059f, -0.08118281f, -0.02125200f, 0.62593853f, -0.28988490f, 
    0.49381784f, -0.16300549f, 0.18263100f, -0.18487759f, -0.01633677f, 0.05296122f, 0.03428927f, 0.02442926f, 
    -0.36957851f, -0.00511809f, -0.09208964f, -0.08460113f, 0.03085817f, -0.00929014f, 0.35580835f, 0.09446362f, 
    -0.23078860f, -0.17527649f, 0.98519242f, 0.22399329f, 0.11665894f, -0.37465066f, 0.06107095f, 0.02138740f, 
    -0.26214227f, -0.20476407f, -0.40127960f, 0.48370805f, -0.11909533f, -0.09941879f, -0.07138816f, 0.17748800f, 
    0.06630766f, 0.20183566f, 0.10646863f, -0.14177504f, 0.16382122f, -0.27204499f, -0.18645418f, -0.03183192f, 
    -0.07202855f, -0.04293603f, -0.00896499f, -0.65835273f, -0.51344752f, -0.04775133f, -0.07861510f, -0.04913746f, 
    0.21770090f, -0.18151881f, 0.07191332f, 0.09794699f, -0.74748278f, 0.23903702f, 0.08479346f, 0.00709777f, 
    -0.00905482f, -0.19144666f, -0.13132530f, -0.06806216f, 0.31348342f, 0.20214035f, -0.20379050f, 0.23701884f, 
    0.14566098f, -0.00897019f, -0.13081370f, 0.16106582f, 0.08748119f, 0.05155111f, 0.15124418f, 0.19313887f, 
    0.18015856f, 0.08449259f, 0.15527859f, -0.13885768f, 0.14335836f, -0.00872388f, -0.02770994f, 0.10156646f, 
    0.05945922f, 0.45457006f, -0.03589106f, 0.07709332f, -0.39627215f, -0.04043577f, 0.19836028f, -0.08604841f, 
    0.10793974f, -0.24636185f, -0.51602042f, -0.21412422f, -0.01240019f, -0.04008317f, 0.01441749f, -0.35063943f, 
    -0.09982344f, -0.21356218f, -0.24429035f, -0.42973572f, 0.12107060f, 0.06021328f, 0.08590431f, 0.19574462f, 
    0.08093123f, 0.10545018f, 0.40771580f, 0.14650221f, -0.22133116f, 0.06076455f, 0.13609138f, -0.01480573f, 
    0.12398025f, -0.11504635f, -0.07907818f, 0.02146517f, -0.24836090f, -0.26894939f, 0.32489786f, 0.04432480f, 
    0.20904759f, -0.02459479f, 0.31953472f, 0.00902155f, 0.44314501f, -0.16233642f, 0.05937279f, 0.13930379f, 
    0.03682769f, 0.04164717f, 0.13236648f, -0.02341339f, -0.15512653f, 0.04321362f, 0.18708897f, 0.18213822f, 
    0.06313217f, -0.10895339f, 0.04464838f, -0.21286367f, -0.13108329f, -0.14936480f, -0.26251647f, -0.60182959f, 
    0.38485208f, 0.05076970f, 0.28352353f, 0.24322282f, 0.08844201f, -0.12079380f, 0.25187707f, 0.39999679f, 
    -0.11865739f, 0.33697236f, 0.04022016f, 0.00645554f, 0.11963829f, -0.16931129f, -0.04341596f, -0.15810791f, 
    0.06582519f, -0.58442569f, -0.41347536f, 0.10814001f, 0.06294085f, 0.03726137f, 0.14337313f, 0.08308744f, 
    0.25252840f, 0.48276901f, -0.25038901f, -0.45757496f, 0.11614962f, -0.09192339f, -0.04731778f, -0.08510076f, 
    0.02296893f, 0.12401626f, 0.19522922f, -0.40364853f, -0.22586821f, -0.12401572f, 0.05374489f, 0.10024040f, 
    0.01217168f, -0.13111734f, -0.11603106f, -0.62030911f, 0.45802546f, -0.26973641f, 0.08735903f, -0.34404039f, 
    -0.24427691f, 0.10863671f, -0.11098776f, -0.09977321f, -0.05187650f, -0.01988086f, -0.64904535f, 0.00458115f, 
    0.05285313f, 0.04685099f, 0.07925695f, -0.16867071f, -0.22336689f, 0.59561419f, -0.12667592f, 0.54565609f, 
    0.06923473f, 0.07939432f, 0.07429642f, 0.16786544f, 0.05351043f, 0.04262905f, 0.07230827f, 0.16829161f, 
    0.10622832f, -0.07554108f, 0.05365809f, 0.13173996f, -0.34083435f, -0.17229134f, -0.15617305f, 0.27053919f, 
    0.26688555f, 0.35733205f, -0.09766897f, 0.19616832f, -0.12456203f, 0.28200325f, 0.21082452f, 0.12629563f, 
    -0.05668932f, -0.06430731f, -0.00018434f, 0.03594845f, -0.06202587f, -0.02354256f, -0.07937105f, -0.07706028f, 
    -0.00528130f, -0.07325961f, -0.01604656f, 0.02676371f, -0.01651091f, -0.05174834f, -0.05887995f, 0.01060461f, 
    -0.07138186f, 0.04742923f, -0.06011150f, -0.07702222f, 0.04037638f, 0.00538566f, 0.06118568f, 0.04289597f, 
    0.04294666f, -0.04314026f, 0.03856999f, -0.00106440f, -0.05856824f, 0.05160535f, -0.02586620f, 0.00727729f, 
    0.02990008f, -0.02162224f, -0.01520068f, 0.03574549f, -0.03375643f, -0.00408117f, 0.05406632f, -0.07387938f, 
    -0.06924737f, -0.00588562f, -0.01835505f, 0.00524707f, 0.07347055f, -0.08609952f, -0.03274229f, 0.05933047f, 
    0.06514975f, 0.04335577f, 0.00839034f, -0.02039132f, 0.00378727f, 0.01834164f, -0.08896978f, -0.05104170f, 
    -0.05540272f, 0.03306058f, 0.01634075f, 0.01438999f, 0.04185118f, -0.02968932f, -0.07190222f, -0.05279460f, 
    -0.02070237f, -0.01571973f, -0.01933517f, -0.02048957f, -0.03158836f, -0.03478944f, -0.05449621f, -0.04710766f, 
    -0.07760605f, 0.03063845f, 0.00396711f, -0.00661060f, -0.01344543f, 0.03913042f, -0.02018305f, 0.02116266f, 
    -0.07917649f, -0.02653116f, -0.08426600f, 0.07267764f, -0.05849469f, -0.03585284f, -0.04525205f, -0.04897964f, 
    -0.08491195f, 0.03485196f, -0.00622006f, 0.03990529f, -0.04411906f, -0.08778569f, 0.00232306f, -0.02352830f, 
    -0.08385951f, -0.01955145f, 0.01016893f, -0.07681376f, -0.00205539f, -0.07401925f, -0.08808815f, -0.04359828f, 
    0.02515076f, -0.08133369f, 0.02683085f, -0.09139077f, -0.00157475f, -0.01312385f, -0.08819494f, -0.00267561f, 
    -0.07478986f, 0.01208918f, -0.03336169f, -0.06096991f, -0.01109728f, 0.00396032f, -0.03481257f, 0.04599711f, 
    -0.05340853f, -0.07769933f, 0.02267930f, 0.04402415f, -0.07391815f, 0.01319493f, 0.01139530f, 0.02479891f, 
    -0.06323481f, 0.03609237f, 0.03729375f, 0.06435192f, -0.00049116f, -0.09029916f, -0.04719829f, 0.04870886f, 
    0.05238343f, -0.01270864f, -0.05446287f, 0.06691094f, -0.04677231f, -0.03536623f, -0.04059929f, 0.07368532f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.36476761f, 0.02509445f, 0.03377825f, 0.54687333f, 0.21156824f, 0.26735744f, 0.02457026f, 0.29896951f, 
    0.13916966f, 0.05944840f, -0.01598550f, 0.10781526f, -0.32618570f, 0.21899116f, -0.08002740f, -0.02736828f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.19877209f, 0.20997323f, 0.09324839f, -0.95810133f, 0.28078318f, 0.10339960f, -0.18498743f, -0.64765388f, 
    -0.12893225f, 0.11802655f, 0.11495087f, 0.17573416f, 0.76244199f, 0.29284102f, 0.00199082f, 0.02827659f, 
    0.12088713f, 0.01112383f, -0.00146282f, -0.13262719f, 0.36314803f, 0.31660435f, -0.88091046f, -0.76107728f, 
    0.05668345f, -0.21637942f, -0.16099501f, 0.97708446f, -0.19445509f, -0.03474347f, 0.24805632f, 0.13425240f, 
    0.59940994f, 0.14380112f, -0.06538309f, 0.37409583f, -0.77800834f, -0.69236726f, -0.63377458f, 0.51552421f, 
    -0.27608556f, 0.02367646f, -0.22131793f, -0.23072417f, 0.02475056f, -0.03597146f, 0.09225269f, -0.03928732f, 
    -0.92702550f, -0.10058269f, -0.13847773f, 0.19603944f, -0.39671654f, -0.21704006f, 0.33474740f, 0.09856249f, 
    -0.66239834f, -0.19542705f, -0.11365762f, -0.10405581f, 0.52718377f, -0.03752560f, 0.48219487f, 0.05758026f, 
    -1.00719726f, 0.13115743f, 0.04708720f, -0.48031884f, 0.56319338f, -0.08663476f, -0.10833025f, 0.53260028f, 
    0.07280402f, 0.09433909f, 0.13641441f, -0.28270021f, -0.48016480f, 0.45608318f, 0.03287507f, -0.18752503f, 
    -0.15966138f, 0.33210608f, -0.02196420f, 0.28373513f, 0.43086210f, -0.04762349f, -0.56292605f, -0.26851138f, 
    -0.09179114f, -0.13222653f, 0.01480110f, -0.39027998f, 0.13585088f, -0.44016787f, -0.32488066f, 0.04513295f, 
    0.99999559f, -0.54455018f, 0.23484857f, -0.26794207f, -1.59146810f, -0.33490568f, -0.35084459f, 0.42846203f, 
    0.72765863f, 0.13727814f, -0.07484264f, -0.05886062f, -0.11861988f, -1.20447838f, 0.04557247f, -0.18276757f, 
    -0.68703139f, 0.63993073f, -0.02510769f, -0.47559437f, -0.69152963f, -0.39143726f, 0.87580979f, -0.16447499f, 
    -0.02148132f, 0.15677272f, 0.19882613f, 0.59263271f, 0.12984477f, 0.00295635f, 0.17816196f, -0.18638551f, 
    0.12761037f, 0.17525209f, -0.02781154f, 0.18669789f, -0.16264522f, 0.45710951f, 0.77703738f, -0.42315111f, 
    -0.71575886f, -0.23428117f, -0.06181414f, 0.13941741f, 0.16188473f, -0.85749048f, -1.11218703f, 0.04878584f, 
    -0.15688418f, -1.18372488f, -0.06960993f, -0.35327139f, -0.22285499f, 0.67245775f, 0.09334484f, 0.78958148f, 
    0.09149839f, -0.07109332f, 0.23359667f, -0.29724422f, -0.73772931f, -0.43379360f, 0.57407111f, 0.09129924f, 
    0.39595321f, -0.21449390f, 0.23603846f, 0.03631984f, -0.07431915f, 0.31099457f, -0.34773549f, -0.85606873f, 
    -0.35726172f, -0.13542895f, 0.16432737f, -0.05338404f, 0.05973941f, 0.86727023f, -1.21188819f, -0.01031873f, 
    -0.67585057f, -1.05061078f, 0.24440280f, 0.73700833f, -0.60988861f, 0.00185590f, -0.33220318f, -0.52738345f, 
    0.49825186f, -0.02692701f, -0.05460792f, -0.43076026f, -0.05933552f, -0.10105188f, -0.43104085f, -0.01087391f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.39852878f, -0.27283928f, 0.14369552f, 0.34680909f, 0.09926787f, 0.41484305f, -0.41894764f, -0.60021186f, 
    -0.28643116f, 0.52237517f, 0.28379869f, 0.30914563f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
