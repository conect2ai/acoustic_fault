#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.27799183f, -0.10740092f, -0.56139004f, 0.46544221f, 0.99533439f, 0.59871727f, 0.13385931f, 0.72089046f, 
    0.17076856f, 0.14899834f, -0.95858908f, 0.16271096f, -0.85600781f, -0.76282984f, -0.71968210f, -0.66356236f, 
    -0.28777719f, -0.55053145f, 0.64157718f, 0.21646214f, 1.06079233f, 0.66658986f, -0.24318984f, 0.45698991f, 
    -0.37592965f, 0.80006903f, 0.24982062f, 0.53949493f, 0.21047199f, 0.40600058f, 0.78462631f, -0.36220881f, 
    0.03639137f, 0.48434982f, -0.83208561f, -0.12605959f, -0.16317129f, -0.70694095f, -0.33447960f, -1.08663344f, 
    -0.97112602f, -1.49523890f, 0.88212270f, -0.43553737f, 1.19215691f, 0.32635507f, 0.98997295f, 0.58217692f, 
    1.04948378f, 0.38687941f, 0.50550979f, 0.53688604f, 0.14444654f, -0.03580593f, -1.35209155f, -0.96366191f, 
    -0.22331735f, -0.43472117f, 1.28571403f, -1.31550229f, -0.65754193f, -0.50482577f, -0.12840080f, 0.43961939f, 
    0.00602063f, -0.53310007f, -0.17961977f, 1.54752386f, 0.41823184f, 0.44562411f, -0.58108979f, -0.54679000f, 
    0.89202350f, 1.38169408f, -1.72997129f, -0.43006191f, -0.25011277f, -0.09792768f, -0.53152585f, 0.74803865f, 
    -0.26666436f, -1.47100461f, -0.42315701f, -0.47857216f, 0.06257584f, 0.26958576f, -0.81294775f, 0.78644228f, 
    0.95531267f, 0.57556927f, 0.41256991f, 0.64838010f, -0.14911789f, -0.72528559f, 0.17886648f, 0.38732135f, 
    -0.71114856f, -0.90225321f, -0.71376920f, -0.01855873f, 0.18981089f, 0.69874734f, -0.27834609f, 0.21339139f, 
    -0.05202949f, -0.48743197f, 1.56015396f, -1.10600984f, -0.72607672f, -0.61401236f, -1.30529499f, 0.31837288f, 
    -0.62178409f, -1.06921029f, -0.43226305f, -0.75770193f, -0.24021791f, 0.17359699f, -0.01613917f, 0.23524283f, 
    -0.14300607f, 0.03852326f, -0.09633660f, 1.18119276f, -0.67986017f, -0.46711698f, 0.25629321f, 0.20159793f, 
    0.06453334f, -0.37974477f, 1.14760566f, -0.75871176f, -0.06756739f, 0.41023135f, 0.63357824f, 0.53580660f, 
    0.18000862f, 1.53143930f, -0.17076927f, -1.21394503f, -1.03091621f, 0.05739545f, 0.02094804f, 0.04597544f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.19631144f, 0.41479462f, 0.83647144f, 0.59070832f, 0.11575864f, -0.25854176f, 0.35967755f, 0.54465652f, 
    -0.02389476f, 0.40283617f, 0.05758425f, 0.33286774f, 0.77977926f, 1.11650312f, 0.90896583f, 0.15774444f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.10355077f, -0.42962986f, -0.57556319f, 0.10092924f, -0.03822737f, -0.08452196f, 0.18718337f, 0.00929704f, 
    0.16398090f, -0.04965406f, -0.05531851f, 0.06460132f, -0.26681903f, -0.05331080f, -0.06278500f, 0.35275641f, 
    0.16303146f, 0.04549960f, 0.06583837f, 0.31757152f, -0.04052886f, -0.14940521f, -0.26154608f, 0.07460481f, 
    0.19938035f, 0.13500510f, 0.16551411f, -0.12340800f, 0.16913228f, -0.13931933f, -0.23970959f, -0.31020659f, 
    -0.10761207f, -0.01718065f, 0.06067151f, -0.09079383f, -0.57366681f, 0.09204504f, 0.57208997f, -0.47043410f, 
    -0.05449587f, -0.10116645f, -0.05016458f, 0.07782416f, 0.10147481f, 0.18290028f, 0.46103263f, -0.30409780f, 
    -0.18459477f, -0.08468435f, 0.03483486f, 0.06235524f, -0.07241039f, 0.02970513f, 0.02067493f, -0.55175889f, 
    -0.51252919f, 0.05447754f, -0.06396262f, 0.33479527f, -0.05075335f, -0.22977088f, -0.11130380f, -0.25782159f, 
    0.19356720f, -0.11706588f, 0.11372199f, -0.02209516f, -0.33203351f, -0.00789468f, 0.15599956f, -0.06861264f, 
    -0.95320064f, 0.00023401f, -0.26422021f, -0.29031375f, 0.22925253f, 0.08228873f, -0.25888228f, 0.13106367f, 
    0.00961186f, -0.36623976f, -1.26111007f, -0.17675862f, -0.24056746f, 0.03531335f, -0.08711351f, 0.07815801f, 
    0.03389238f, 0.04626675f, 0.51452512f, 0.39968348f, 0.23425643f, -0.22483176f, -0.20514080f, -0.37589356f, 
    -0.18533185f, -0.16687851f, -0.19786873f, 0.33733973f, 0.74384969f, 0.42142799f, 0.04391367f, -0.07295121f, 
    -0.10617752f, 0.17121157f, 0.14826481f, 0.37854016f, 0.15812802f, -0.04603937f, -0.89744741f, -0.30015793f, 
    0.12099885f, 0.06392110f, 0.35265473f, 0.09730138f, -0.01432201f, -0.04948297f, 0.30113316f, 0.10980397f, 
    -0.07199844f, 0.31971586f, 0.26517984f, 0.30230629f, 0.21562186f, 0.23889866f, 0.33914918f, 0.44750133f, 
    0.48995158f, 0.21015231f, -0.02587020f, -0.00337082f, 0.29125166f, -0.16986802f, 0.08052725f, -0.14633480f, 
    0.24239291f, -0.06732869f, -0.47523510f, -0.18850292f, -0.48733610f, 0.22009178f, 0.14273430f, 0.09135088f, 
    0.07765608f, 0.07659472f, 0.02240382f, 0.16298445f, 0.21670327f, 0.34402320f, 0.02612488f, 0.14899291f, 
    0.12986872f, 0.33005470f, 0.14143975f, -0.41848579f, 0.03528048f, 0.02997215f, 0.00480085f, 0.04444217f, 
    0.04041947f, -0.29026860f, -0.12844981f, -0.09750112f, 0.05170657f, -0.10099805f, -0.27988759f, -0.07709007f, 
    -0.09552062f, 0.14842570f, -0.33438221f, -0.16303121f, 0.04419288f, -0.05975283f, 0.08755953f, 0.10013386f, 
    0.19496448f, -0.24050529f, -0.17715962f, -0.15348856f, 0.35196173f, 0.27154896f, -0.27079675f, -0.07643170f, 
    -0.02908228f, -0.02146637f, 0.19341375f, 0.14889634f, 0.09084127f, -0.28425321f, -0.10430704f, -0.09147974f, 
    -0.10620175f, -0.20266087f, -0.07381286f, -0.19550420f, -0.14182837f, -0.29421932f, 0.15964991f, 0.11789069f, 
    -0.19681513f, -0.01727451f, -0.22002590f, -0.04396673f, -0.01373441f, -0.06160205f, -0.01792701f, -0.17015235f, 
    -0.22497077f, 0.00609628f, 0.38272652f, 0.21089280f, 0.07710764f, 0.02958988f, -0.35165063f, -0.20295630f, 
    -0.23011950f, 0.28197560f, -0.39689904f, 0.06432389f, 0.27107719f, -0.12644230f, -0.01199929f, 0.07697344f, 
    0.12187430f, 0.00385838f, 0.04998900f, -0.19477236f, -0.06279851f, 0.12429530f, 0.02369320f, 0.23156767f, 
    0.28342465f, 0.37346882f, -0.18516022f, 0.18468873f, 0.03297985f, -0.07133733f, -0.16692403f, 0.17166542f, 
    -0.37937018f, -0.16686150f, 0.13856693f, 0.14276241f, 0.08875982f, 0.40487587f, -0.05054544f, -0.00712155f, 
    -0.10639425f, 0.10882083f, 0.20594442f, 0.15777020f, 0.17493851f, 0.10330330f, -0.34170491f, -0.01148880f, 
    -0.00501217f, 0.08621340f, -0.06611244f, -0.04344868f, -0.08357660f, 0.34754103f, 0.18644239f, -0.10806889f, 
    0.22788084f, 0.13138945f, -0.20498402f, -0.11856634f, 0.25948915f, 0.13082515f, -0.17943874f, 0.07840761f, 
    0.24350956f, 0.17331165f, -0.01007810f, -0.09964357f, 0.39219359f, 0.20688654f, 0.01595324f, 0.08245967f, 
    -0.07510528f, -0.63722169f, 0.01135214f, 0.01718865f, 0.10410868f, 0.19211808f, -0.23460665f, 0.07686871f, 
    -0.01993474f, -0.20891540f, -0.06529833f, -0.78259248f, -0.10548910f, 0.02271687f, 0.02579589f, -0.09137923f, 
    -0.05902200f, -0.28566775f, -0.01630581f, 0.18540001f, 0.02708101f, -0.08438740f, -0.20609671f, -0.00463679f, 
    0.08521772f, 0.39356750f, -0.16884549f, 0.28514025f, -0.29636621f, -0.05639378f, -0.45411873f, -0.05299496f, 
    0.01643188f, 0.25416875f, 0.15344945f, -0.29721549f, 0.16222835f, 0.00542150f, 0.08962072f, -0.12144528f, 
    -0.02857030f, 0.04904348f, 0.15399507f, 0.15266816f, 0.04861178f, -0.30576923f, 0.48556453f, 0.15211196f, 
    0.22657531f, 0.18695191f, -0.02561675f, -0.02086703f, -0.19447890f, -0.07692225f, 0.06686983f, -0.25266284f, 
    -0.18430020f, -0.08073215f, -0.05441223f, 0.00302683f, 0.17719045f, 0.03180480f, 0.19687591f, 0.19363727f, 
    -0.11758153f, 0.01513591f, 0.03712074f, -0.16608758f, -0.10886698f, 0.20554854f, 0.05676691f, 0.03746880f, 
    0.10403641f, 0.08403344f, -0.02336563f, 0.23812558f, 0.36113548f, 0.14833927f, 0.19558193f, 0.16336004f, 
    -0.39982060f, 0.16439791f, 0.61719215f, -0.18205768f, 0.10017154f, 0.37680960f, -0.05259575f, 0.44945985f, 
    0.22028084f, 0.37289932f, -0.36211762f, 0.03004768f, 0.36497697f, 0.47169462f, -0.01075616f, 0.09672239f, 
    0.02516075f, -0.14748973f, -0.13377437f, 0.06999794f, 0.00601582f, -0.18070196f, 0.21902049f, -0.08537776f, 
    0.37953538f, 0.72292793f, 0.27972206f, 0.29795739f, 0.30430290f, -0.21465959f, -0.11122688f, -0.15460560f, 
    -0.06834995f, -0.23703156f, 0.24986522f, 0.07783996f, 0.11525865f, -0.23425514f, -0.01147955f, 0.05661000f, 
    -0.15748847f, -0.24550571f, -0.30744338f, -0.08244014f, 0.14894991f, 0.05719926f, 0.03338563f, 0.29697520f, 
    0.35291156f, 0.07670977f, 0.08492573f, 0.35613492f, -0.08462603f, 0.23662785f, 0.14061026f, 0.07028844f, 
    0.09690832f, -0.06403179f, 0.06122496f, -0.03655039f, -0.17756385f, -0.10982382f, 0.10294087f, -0.48061249f, 
    0.59005964f, 0.42116362f, 0.15367876f, 0.21931307f, -0.02520706f, -0.03685566f, -0.47335282f, -0.25525841f, 
    -0.23624954f, 0.17724627f, 0.21378408f, -0.14448525f, -0.00003624f, 0.01586035f, 0.15545300f, 0.13883781f, 
    -0.01079954f, -0.21715787f, 0.12218922f, 0.08689252f, 0.08294399f, 0.05897430f, 0.23311561f, 0.02858356f, 
    -0.10800976f, -0.00527499f, 0.06955551f, 0.26668492f, -0.01535287f, 0.10162582f, 0.08332770f, -0.22101805f, 
    0.03190525f, -0.00891291f, -0.21904545f, 0.12826873f, 0.25455633f, 0.00786881f, 0.28811154f, 0.01243118f, 
    0.06626096f, -0.04058906f, 0.18977115f, 0.04338130f, -0.27651197f, 0.06338529f, -0.26557234f, -0.01857729f, 
    0.15030900f, -0.35484308f, -0.19159567f, -0.23164974f, -0.28452232f, -0.01279686f, 0.06072075f, -0.18918310f, 
    0.10390247f, -0.08937728f, 0.08683731f, -0.12974590f, -0.10439902f, -0.09959107f, -0.56083632f, -0.23017925f, 
    -0.07769600f, 0.01087452f, 0.03779761f, 0.39464787f, 0.06272908f, -0.02791255f, 0.04302391f, 0.03962644f, 
    -0.01033036f, -0.12119262f, 0.12312753f, 0.19138916f, 0.03613910f, 0.13102047f, 0.36587954f, 0.08510025f, 
    0.60020965f, -0.84326792f, -0.02562693f, -0.50443518f, 0.20644817f, -0.14669687f, 0.20745507f, -0.05310604f, 
    -0.14590751f, -0.57327741f, -0.11126228f, 0.09575443f, -0.21300596f, 0.09663698f, -0.21848555f, -0.01569035f, 
    -0.05760363f, -0.24611735f, 0.21745674f, -0.24609426f, 0.08336466f, 0.02638364f, 0.23103324f, 0.01489660f, 
    0.04560287f, 0.42213833f, 0.20487814f, 0.04041970f, -0.17022654f, -0.09033226f, -0.09396593f, 0.05323590f, 
    -0.25864497f, -0.12371391f, -0.00825918f, -0.27847964f, -0.49652576f, 0.43074611f, 0.02680599f, 0.10742260f, 
    0.02868179f, 0.28578022f, -0.10745811f, 0.03233086f, 0.04125073f, 0.10648861f, 0.42567626f, 0.12756515f, 
    0.19231948f, 0.21502699f, 0.30919060f, 0.19006582f, 0.06118101f, -0.02601447f, 0.32739258f, 0.39298221f, 
    -0.02992265f, 0.13635421f, 0.16405106f, 0.37204847f, -0.09548558f, -0.14068772f, -0.38076004f, 0.22552432f, 
    0.02502754f, 0.51374078f, -0.13523853f, -0.05479651f, -0.32756209f, 0.08247175f, 0.11071243f, 0.19209035f, 
    0.15325996f, 0.09284714f, 0.13221680f, 0.24040028f, -0.19035761f, -0.23507057f, 0.12797660f, -0.16059512f, 
    0.20304123f, -0.17842981f, -0.21395867f, -0.24695174f, 0.11684458f, 0.06180564f, 0.31786454f, 0.11877789f, 
    0.04261922f, -0.04057553f, -0.09343066f, -0.13333522f, 0.23336588f, 0.11793134f, -0.03676685f, 0.03170605f, 
    0.19622082f, -0.17872985f, 0.07135110f, -0.25787386f, -0.00333725f, 0.10449874f, 0.13964280f, 0.09167641f, 
    -0.10245315f, 0.07183000f, 0.05349116f, 0.08844579f, 0.31640530f, 0.39390069f, -0.64617676f, -0.02482527f, 
    0.22978263f, -0.07666882f, 0.07898799f, 0.12507166f, -0.11498643f, -0.10894012f, -0.03657099f, 0.10162973f, 
    -0.08565448f, -0.13907439f, -0.14698961f, -0.06016533f, -0.17134747f, -0.04138748f, 0.05749818f, 0.01477202f, 
    -0.23380588f, -0.11060687f, -0.28248912f, 0.05256290f, -0.00534739f, -0.09674631f, -0.27200514f, 0.10174430f, 
    -0.05357112f, -0.07827224f, -0.08759142f, 0.20957769f, -0.14879704f, 0.14935316f, -0.12818672f, -0.01664644f, 
    0.12845515f, -0.17188828f, -1.09201336f, -0.15911782f, 0.24923922f, 0.27906415f, -0.08544286f, -0.05580720f, 
    0.05680898f, -0.97478765f, 0.08489432f, -0.04600109f, -0.10111881f, -0.01114575f, -0.07383194f, 0.16248389f, 
    0.17505746f, 0.16461699f, -0.40859935f, -0.76092863f, -0.47110566f, -0.20217289f, -0.16076198f, 0.04434521f, 
    -0.26738551f, -0.15358281f, 0.41794154f, -0.29201248f, 0.10040711f, -0.01374718f, 0.06481318f, -0.05845914f, 
    -0.19400415f, -0.01250644f, 0.50110829f, -0.04618856f, -0.20263554f, 0.50353020f, -0.25325632f, 0.07261273f, 
    0.00534514f, 0.07984287f, 0.04667551f, -0.04822970f, -0.03400389f, -0.02562016f, 0.20605552f, 0.19391581f, 
    0.05627624f, 0.16979331f, 0.20023650f, 0.08938470f, 0.60336959f, 0.15252514f, 0.07305008f, -0.02105921f, 
    0.03933216f, 0.40181905f, 0.15886758f, 0.21591040f, 0.09637907f, 0.26401642f, 0.29978573f, -0.39799678f, 
    -0.94554609f, 0.48626235f, 0.26978335f, 0.06598326f, 0.01997828f, 0.15116467f, -0.10251139f, 0.16190553f, 
    -0.32647282f, -0.48996758f, -0.09255737f, 0.19245711f, 0.05024453f, -0.03624988f, 0.18290897f, 0.26888654f, 
    0.19091591f, 0.10494476f, 0.14860004f, -0.14453655f, -0.19278385f, 0.04803430f, 0.02668606f, 0.02472649f, 
    0.09427740f, 0.14625861f, 0.03745257f, 0.07195394f, 0.26760608f, -0.00222620f, 0.08987063f, -0.02152901f, 
    0.21231513f, 0.00240486f, -0.07812866f, 0.18210621f, -0.06148583f, 0.55917841f, -0.01906023f, -0.06303243f, 
    -0.22442026f, 0.07784496f, 0.19268715f, 0.10710181f, -0.26400095f, 0.07410371f, 0.17940822f, -0.34285101f, 
    -0.28971285f, -0.26060945f, 0.06341496f, 0.11937264f, 0.08888811f, 0.12258516f, -0.01362739f, 0.10690938f, 
    0.15473965f, -0.07368598f, -0.18357265f, -0.30120727f, -0.00341786f, 0.06030296f, -0.32112733f, 0.03749190f, 
    0.47135684f, -0.07006719f, 0.19579025f, -0.16613293f, 0.01269676f, -0.01474587f, -0.12610334f, 0.06651705f, 
    -0.53395814f, 0.38534659f, 0.03414145f, -0.09894941f, -0.20758644f, -0.48336238f, 0.01851776f, 0.00265326f, 
    -0.51636171f, -0.34872320f, 0.73046166f, -0.01260945f, 0.20710228f, 0.05006184f, 0.08913890f, -0.07130805f, 
    0.16080150f, -0.58972502f, -0.21568574f, -0.10308018f, 0.06393474f, 0.06560863f, -0.19332255f, 0.12253442f, 
    0.25066796f, -0.16413751f, -0.22128783f, -0.04169487f, -0.10915449f, -0.07405801f, -0.27431956f, -0.25322789f, 
    -0.22453073f, -0.09162045f, 0.08652124f, -0.08000678f, 0.04985391f, 0.61407292f, 0.17460345f, -0.01764898f, 
    -0.09758888f, 0.00655948f, 0.32709125f, 0.12344803f, 0.26161060f, 0.27456728f, -0.40252161f, -0.42756772f, 
    -0.00873029f, -0.05727473f, 0.14339446f, 0.07306063f, -0.03343441f, 0.09824164f, 0.27906817f, 0.89682317f, 
    -0.21250188f, -0.05838817f, 0.06972542f, -0.21610968f, 0.30171451f, 0.32386675f, 0.12686799f, -0.16248596f, 
    0.28436822f, -0.01765341f, -0.00080641f, 0.08725806f, 0.26497018f, 0.00071851f, 0.06144190f, -0.37485430f, 
    0.20868634f, 0.07611378f, -0.21634060f, 0.26818600f, -0.19979744f, 0.14251927f, -0.04113097f, 0.12065163f, 
    -0.09802525f, -0.04227196f, -0.00381272f, -0.07222083f, 0.01637264f, 0.02409707f, -0.09522399f, -0.03621290f, 
    -0.05818644f, -0.04938893f, -0.10173021f, -0.04658685f, 0.05282184f, 0.04110579f, -0.04309211f, -0.05090573f, 
    0.04284962f, -0.08237194f, -0.05433953f, -0.08474082f, -0.05704018f, -0.09356325f, -0.07955026f, -0.02613170f, 
    -0.06722719f, 0.01924107f, -0.05222088f, 0.01304585f, 0.04305526f, 0.05121738f, -0.11002138f, -0.10167027f, 
    -0.07786127f, -0.03628174f, -0.06512274f, -0.09264798f, 0.02682292f, 0.01882566f, -0.09769638f, -0.03181994f, 
    -0.03738785f, 0.03038126f, -0.08266765f, -0.05522535f, -0.03027272f, -0.01618376f, -0.07225505f, -0.02564906f, 
    -0.07588115f, -0.05516849f, -0.08808536f, -0.02374137f, 0.04234724f, -0.08430614f, -0.00730658f, 0.00852595f, 
    -0.10212748f, -0.00081649f, -0.10543137f, -0.04218090f, -0.06936707f, -0.05148217f, -0.06553109f, 0.02989078f, 
    0.03848459f, -0.10246056f, 0.00980803f, -0.02328044f, -0.00019637f, -0.09720571f, 0.00683359f, -0.02746219f, 
    0.01163667f, -0.09867235f, 0.03592526f, -0.06511915f, 0.04747318f, -0.04333730f, 0.00794695f, 0.01611342f, 
    -0.06019323f, 0.01666314f, 0.03334023f, 0.01514725f, -0.08339278f, 0.01252946f, -0.04823851f, -0.06832759f, 
    0.01901470f, -0.00134583f, -0.04151019f, 0.05493042f, -0.08678840f, -0.08031239f, 0.03311079f, -0.03222762f, 
    -0.02039282f, -0.07841814f, 0.03668521f, -0.05558430f, -0.02296596f, 0.04724232f, -0.06757686f, -0.04533096f, 
    -0.04653523f, -0.03943419f, 0.05565628f, -0.02282039f, -0.06350735f, -0.07412811f, -0.00422367f, -0.00919512f, 
    0.03981936f, -0.08007790f, 0.00503708f, -0.07970776f, 0.01255218f, -0.08773027f, 0.01488512f, -0.05550181f, 
    -0.05631972f, 0.04681390f, -0.10895137f, -0.10084426f, -0.06634083f, -0.09958470f, -0.01953143f, -0.10143420f, 
    -0.10178106f, -0.08319017f, 0.01889174f, -0.00158450f, -0.09034165f, -0.08564819f, -0.06921577f, -0.06659620f, 
    0.02731664f, -0.04894514f, 0.04932103f, -0.07933035f, 0.02032142f, -0.01131839f, -0.01638924f, 0.03766883f, 
    -0.10375752f, 0.20274061f, 0.02912859f, -0.25297475f, 0.48723984f, 0.13684331f, -0.03422447f, 0.08488552f, 
    0.26365829f, -0.22618195f, -0.27072397f, 0.09405158f, -0.03509527f, -0.03434277f, -0.00096659f, 0.25290951f, 
    0.21478020f, -0.17484571f, -0.13511734f, -0.14880295f, -0.22766429f, -0.21106052f, 0.06870731f, 0.16104427f, 
    0.26390490f, 0.04891584f, 0.24940298f, -0.08219393f, 0.25883827f, -0.06799674f, 0.18205298f, 0.27848899f, 
    -0.02333711f, 0.23030177f, 0.22805172f, 0.22136678f, -0.56808811f, -0.65185052f, -0.05812538f, -0.06170430f, 
    -0.25414205f, -0.19155949f, 0.07291149f, 0.19168060f, 0.11180048f, -0.45913801f, -0.34844181f, -0.28506276f, 
    -0.58215553f, -0.95831174f, -0.87330091f, 0.09411734f, 0.15460904f, 0.17564422f, -0.66501850f, 0.15689301f, 
    0.49151435f, 0.08533254f, 0.04258242f, 0.08447923f, 0.08489016f, 0.06095047f, -0.33207539f, 0.01927914f, 
    0.21322569f, 0.17146419f, -0.06089640f, -0.31250438f, -0.05439129f, 0.31634313f, -0.06086496f, 0.08220324f, 
    1.02777100f, -0.40815181f, -0.26969397f, 0.04297809f, -0.42540425f, -0.37032998f, -0.09006401f, 0.27674523f, 
    0.24176759f, -0.46094692f, 0.02744263f, 0.30932528f, -0.20993462f, 0.11386919f, 0.17197573f, -0.05439656f, 
    0.15572149f, 0.09566061f, 0.22066501f, -0.13348514f, -0.13863772f, -0.23366909f, 0.00208086f, -0.06854033f, 
    0.00897730f, -0.10168935f, -0.14700688f, -0.06723618f, 0.01057827f, -0.41697770f, -0.34504682f, 0.14690955f, 
    0.20296523f, 0.19952624f, -0.10985561f, 0.46736094f, -0.36146310f, -0.01388593f, 0.45235214f, 0.09779472f, 
    0.01329514f, 0.13759302f, 0.28156114f, 0.14516518f, 0.00266083f, 0.27313948f, 0.20073640f, -0.06958545f, 
    0.20201443f, 0.50298613f, 0.28579199f, 0.28437817f, 0.44552690f, 0.64020818f, -0.32901895f, -0.08559728f, 
    -0.01714902f, -0.02805553f, 0.11706444f, 0.26417452f, 0.22056738f, 0.04219802f, 0.26109272f, -0.91349131f, 
    -0.65070349f, 0.10352717f, -0.10097547f, -0.16476266f, -0.08294537f, -0.14579464f, 0.01001235f, -0.04306043f, 
    0.00859948f, -0.08348915f, -0.07007813f, 0.06789169f, -0.02194490f, -0.05873800f, -0.06438597f, -0.06479370f, 
    0.00037218f, 0.00478696f, 0.02887248f, -0.04706777f, -0.00069903f, 0.01967945f, -0.02619313f, -0.02936016f, 
    0.05634413f, -0.03438265f, 0.05240927f, -0.03700051f, -0.01211795f, 0.02858476f, 0.05508930f, -0.06174853f, 
    -0.06629175f, -0.02981992f, 0.01617120f, -0.03879209f, -0.03098270f, 0.04060711f, 0.07368608f, -0.07714400f, 
    -0.06823163f, -0.02082434f, -0.07156517f, 0.04886398f, -0.07641610f, -0.07101092f, 0.03171757f, -0.08172193f, 
    0.02561361f, -0.00879694f, 0.01237082f, -0.05980413f, -0.08560701f, -0.04045741f, 0.00545371f, 0.06067192f, 
    -0.03054627f, -0.04508181f, 0.01751393f, -0.06079577f, 0.03278806f, 0.03326914f, -0.02853642f, -0.03044972f, 
    -0.07747284f, -0.04942134f, -0.04129398f, 0.04068726f, 0.05177880f, -0.06138940f, -0.06013490f, -0.07680549f, 
    -0.03557486f, -0.01639336f, -0.04951819f, -0.08426342f, -0.02625018f, 0.02087924f, -0.00190748f, -0.03252459f, 
    -0.05716527f, -0.07762142f, -0.00090493f, 0.00865212f, -0.00475877f, 0.05428832f, -0.04139661f, 0.00536495f, 
    0.06309346f, -0.04622568f, -0.00878725f, -0.05911838f, -0.07201032f, -0.02887052f, -0.08397385f, -0.06411348f, 
    -0.08500347f, 0.04425867f, -0.07552446f, -0.00787865f, 0.01305441f, -0.08073091f, -0.05439372f, 0.02439440f, 
    0.03109432f, -0.01186335f, 0.03351182f, 0.06857808f, 0.03521925f, 0.00195183f, 0.06758485f, 0.03184779f, 
    0.07552613f, -0.06624760f, -0.08884879f, 0.05925582f, -0.05844023f, 0.00734953f, -0.07734694f, 0.06538083f, 
    -0.04252216f, 0.01720625f, 0.03644305f, -0.06913620f, 0.00405380f, -0.02020939f, 0.07172456f, -0.05670071f, 
    0.05361050f, -0.05299022f, -0.07646461f, -0.06902147f, -0.05384609f, -0.05348596f, 0.03188504f, 0.02923895f, 
    -0.02211249f, 0.05299014f, -0.07667316f, 0.06057867f, 0.02991720f, -0.03510424f, -0.05844966f, 0.02328533f, 
    0.04334070f, -0.07459741f, -0.07926237f, 0.03525071f, 0.07184444f, -0.06367057f, -0.08621866f, -0.02830735f, 
    -0.13383171f, -0.48622569f, -1.15620387f, 0.15101266f, -0.36216989f, 0.05328862f, 0.03039186f, -0.03066103f, 
    -0.00043282f, -0.05535864f, 0.23246564f, 0.18394117f, -0.10995331f, 0.00934040f, 0.05084671f, 0.03289426f, 
    -0.43905950f, -0.37146947f, 0.44028273f, -0.69292569f, -0.57786334f, -0.21831830f, 0.28117827f, -0.24037240f, 
    -0.04074013f, 0.38521492f, -0.07071303f, -0.23546106f, 0.15739584f, -0.09177013f, 0.25725567f, 0.32255262f, 
    0.21493922f, -0.00329131f, 0.12723036f, 0.27162981f, 0.37546736f, 0.70292318f, 0.26942924f, -0.11404796f, 
    0.14992404f, -0.00603016f, 0.04216186f, -0.03569213f, -0.06452746f, 0.70220727f, 0.01321191f, 0.40314960f, 
    0.12677725f, -0.25469938f, -0.09167866f, 0.16075052f, 0.11861804f, 0.09643819f, 0.73913133f, 0.04079766f, 
    -0.04710858f, 0.10807414f, 0.24946259f, 0.15264876f, 0.26127478f, 0.13313301f, -0.11614578f, 0.16992645f, 
    -0.64760315f, -0.21638399f, 0.23859344f, -0.15380690f, -0.05822528f, -0.06924668f, 0.16268109f, 0.12795544f, 
    0.07694729f, -0.08717171f, -0.73187613f, -0.12406712f, -0.43864802f, -0.05795847f, 0.15610987f, -0.11314755f, 
    -0.14252293f, -0.01027279f, 0.37717730f, 0.05280983f, 0.28151962f, 0.03220414f, 0.02704029f, -0.02602245f, 
    -0.22641651f, -0.06535935f, -0.12863630f, 0.03107648f, 0.43281293f, 0.49401972f, 0.00718072f, 0.19443484f, 
    0.14874165f, -0.15681775f, -0.09383285f, -0.17283687f, -0.32401559f, 0.20687883f, -0.02019263f, 0.22465453f, 
    -0.29990596f, -0.08921562f, -0.15938561f, 0.34452242f, 0.55539101f, 0.27410263f, 0.21233995f, -0.09045866f, 
    0.04793447f, -0.03257617f, 0.11803635f, 0.10529686f, -0.09577245f, -0.11174820f, -0.26366213f, -0.23556514f, 
    0.15139228f, 0.18116447f, 0.14763367f, -0.03587497f, 0.01849910f, 0.28843960f, -0.38340291f, -0.28667742f, 
    0.10746119f, -0.04742122f, -0.31172711f, 0.32664782f, -0.31336159f, 0.01781922f, -0.38225254f, -0.81564778f, 
    -0.20803092f, 0.25235459f, -0.41962719f, -0.00462672f, -0.21899930f, -0.15187879f, 0.07473445f, -0.26501310f, 
    -0.17691140f, 0.34929416f, -0.02972097f, 0.10355137f, 0.02717731f, 0.06661329f, 0.07868309f, -0.16902587f, 
    0.15576580f, 0.06836203f, 0.38997805f, 0.31126583f, 0.16042168f, -0.02026476f, 0.07604811f, 0.01353072f, 
    0.03264302f, -0.06657746f, -0.30920765f, -0.11115759f, 0.50878394f, -0.09083121f, -0.06575256f, 0.13584711f, 
    0.36354178f, 0.20790766f, -0.13267456f, 0.16869384f, -0.37762985f, 0.31388006f, -0.07710607f, -0.22113816f, 
    -0.26502523f, -0.00815893f, 0.01392048f, 0.05142953f, -0.08776893f, 0.33421230f, 0.49780026f, 0.36153805f, 
    -0.09132374f, -0.16034377f, -0.18082388f, 0.02894145f, 0.13760671f, 0.03745926f, -0.12239393f, 0.28388026f, 
    0.10082676f, -0.11979473f, -0.13895957f, 0.15577891f, -0.24212030f, -0.00879388f, -0.47348475f, 0.13159716f, 
    0.23597348f, 0.14700523f, -0.23368630f, -0.10838129f, 0.09151755f, -0.06182268f, 0.03944574f, -0.14706323f, 
    0.18074599f, 0.20962499f, 0.02785108f, -0.07661624f, -0.24664548f, 0.10659576f, -0.21364060f, 0.22416925f, 
    -0.07787734f, 0.25589865f, -0.70212370f, 0.05586315f, 0.14962655f, 0.08077469f, 0.02546360f, 0.26824340f, 
    -0.11965489f, 0.54396743f, -0.23353687f, -0.21775952f, -0.26956955f, 0.00326023f, 0.14226846f, 0.30969828f, 
    0.00547223f, 0.06894637f, 0.17991884f, -0.46832469f, -0.15944207f, 0.21301129f, -0.01172658f, -0.12676215f, 
    0.25055128f, -0.05547897f, 0.30981204f, -0.24140897f, 0.97423124f, 0.31061393f, -0.30940387f, 0.06566835f, 
    -0.09215402f, -0.06726557f, 0.44250697f, 0.13835739f, -0.11728357f, 0.26956132f, -0.02416673f, -0.06207768f, 
    -0.00698259f, -0.12784946f, 0.02886302f, 0.05950315f, -0.05425785f, 0.01629389f, -0.10980399f, 0.12141210f, 
    -0.19204465f, -0.09779307f, -0.26013711f, -0.17916013f, -0.10519011f, 0.14800721f, -0.57314253f, 0.21895199f, 
    0.11480235f, 0.00829677f, -0.23538847f, -0.19966309f, -0.21295007f, -0.27218130f, 0.01452850f, -0.87929010f, 
    -0.16895396f, -0.45909601f, -0.26441735f, 0.19847356f, -0.07764155f, 0.02395892f, 0.14906612f, -0.05898429f, 
    0.08124055f, 0.08833759f, -0.51796359f, 0.05900193f, 0.15961356f, 0.01863461f, 0.15645902f, 0.10170599f, 
    0.17024931f, 0.16319439f, 0.01008388f, 0.35439986f, 0.29030263f, 0.10054968f, 0.22592542f, 0.13211912f, 
    0.02734629f, -0.20768850f, -0.78205138f, -0.57067269f, -0.23771042f, -0.12945919f, -0.04691558f, 0.02661849f, 
    -0.00313624f, -0.04107885f, 0.07258312f, -0.24745505f, -0.26264179f, 0.06542680f, 0.01474432f, -0.03659689f, 
    -0.19551033f, -0.15869363f, -0.34620813f, 0.05626947f, 0.37577540f, 0.43076861f, 0.51124054f, -0.27055627f, 
    0.05656928f, 0.01791496f, 0.15207011f, -0.07229522f, 0.10934108f, -0.09080929f, -0.04921678f, -0.30393124f, 
    0.28494629f, -0.22431506f, 0.12501508f, 0.17598915f, -0.07583984f, 0.08015543f, -0.61602128f, -0.08566267f, 
    -0.14976698f, 0.03288999f, -0.17594963f, -0.06327764f, 0.00327961f, 0.01976931f, -0.13868488f, -0.09821477f, 
    -0.18004173f, -1.04038846f, 0.00576353f, -0.30899903f, 0.16143431f, -0.04635209f, 0.18941393f, -0.28464922f, 
    0.72547477f, -0.62216783f, -0.75077456f, 0.21247365f, 0.28665090f, 0.08927061f, 0.25432026f, 0.35089299f, 
    0.09475756f, 0.18273066f, 0.06792404f, 0.51972991f, 0.18992428f, -0.08416225f, 0.20193768f, 0.19568673f, 
    0.01540300f, 0.42076010f, 0.46332577f, -0.54607654f, -0.33845019f, 0.18540244f, -0.08836624f, 0.10851330f, 
    -0.03380233f, -0.02526031f, 0.07561559f, -0.55154294f, -0.08772193f, 0.32153100f, 0.12231235f, 0.11626355f, 
    -0.27902636f, -0.11140508f, 0.33741421f, -0.07887302f, -0.21904983f, 0.05144320f, 0.12512675f, 0.07325872f, 
    -0.07857548f, 0.13379253f, 0.09500302f, -0.08999985f, -0.08485775f, 0.13287711f, 0.15895395f, 0.22410934f, 
    -0.08137238f, -0.08816474f, 0.06323282f, 0.17585568f, -0.11684999f, -0.05921465f, -0.47595206f, -0.49690899f, 
    -0.21886812f, -0.03337746f, 0.18093145f, -0.14646013f, 0.14039370f, 0.04897032f, 0.05956174f, -0.04321280f, 
    -0.24613820f, 0.13063063f, -0.04842479f, 0.05244914f, 0.06229126f, 0.03995221f, 0.13784119f, -0.11852834f, 
    -0.03259445f, 0.04340474f, -0.04816923f, -0.02744868f, -0.03103263f, 0.00639283f, 0.03678733f, -0.06709853f, 
    -0.03614014f, -0.06661751f, -0.05444831f, 0.05100680f, -0.04702832f, -0.04099239f, -0.01448314f, 0.04038355f, 
    0.06044350f, -0.02936266f, -0.00295769f, -0.09175331f, 0.02133477f, 0.03944216f, -0.05091158f, -0.01375408f, 
    -0.08299506f, -0.08753762f, -0.07113015f, 0.04512788f, 0.03413245f, -0.01179427f, -0.02460469f, -0.03628882f, 
    0.06155696f, 0.02113766f, -0.01706640f, -0.00904301f, -0.06560882f, -0.02761406f, -0.04077518f, -0.08515394f, 
    0.00720504f, 0.03600273f, -0.07543952f, 0.04353593f, 0.01399975f, 0.02182454f, -0.04817440f, -0.04765490f, 
    -0.06791570f, 0.05158271f, 0.00606086f, 0.03986782f, -0.04254317f, 0.05922160f, 0.06780885f, -0.03760460f, 
    0.03949044f, -0.04080278f, -0.02270309f, -0.00028765f, 0.00848659f, -0.02291248f, -0.07418203f, -0.03538440f, 
    0.04078493f, 0.05238346f, -0.06726521f, -0.04857187f, -0.09276987f, 0.02724361f, -0.00601031f, 0.02711334f, 
    0.06723889f, -0.04210657f, -0.05296363f, -0.06255714f, -0.08810683f, 0.06305473f, -0.02029261f, 0.07315212f, 
    0.07160939f, 0.01904012f, -0.06351855f, 0.01428979f, 0.01981252f, -0.00869143f, 0.05012993f, 0.05730738f, 
    0.01763632f, -0.00952382f, 0.00365647f, -0.03862083f, 0.04924422f, -0.04304700f, -0.00570288f, 0.04447154f, 
    -0.01149115f, -0.08931920f, 0.00963361f, -0.08689056f, -0.04236840f, -0.00479399f, -0.08156843f, -0.01873613f, 
    0.00717353f, 0.02455827f, 0.00205113f, -0.00930694f, -0.00520779f, 0.04295784f, -0.05510654f, -0.07682201f, 
    -0.06722349f, -0.06909282f, -0.07597568f, -0.05862549f, 0.02174206f, 0.00358364f, 0.01606988f, -0.06727111f, 
    -0.09495167f, -0.02855760f, 0.00691352f, 0.02095352f, 0.01002890f, -0.04204686f, 0.06163323f, -0.05530691f, 
    -0.06761439f, -0.00858980f, -0.01373601f, -0.07252153f, 0.02396303f, 0.00919733f, 0.06222622f, 0.01766061f, 
    -0.06245749f, -0.08560564f, -0.01782301f, 0.00570223f, -0.05406660f, -0.05564237f, 0.03189334f, -0.02486251f, 
    -0.04646785f, -0.15214114f, 0.02401841f, 0.01082548f, -0.08539477f, 0.10244787f, 0.05138978f, -0.09684846f, 
    -0.07812303f, 0.11724313f, 0.07176715f, -0.26228258f, -0.09204146f, 0.01477182f, -0.28259924f, -0.03609256f, 
    0.06702062f, -0.27528858f, 0.07686351f, 0.00559355f, -0.34454101f, -0.19178416f, 0.01693914f, -0.10842358f, 
    0.11159367f, -0.01098407f, 0.02445179f, -0.27895233f, -0.08404450f, -0.08309649f, -0.15451090f, -0.23616825f, 
    0.01309842f, -0.05702728f, 0.07668103f, -0.15192325f, 0.18688989f, 0.13312945f, 0.10484673f, -0.16592747f, 
    0.04701745f, -0.09813062f, 0.02710522f, 0.19178134f, 0.22258581f, 0.01700270f, 0.03366269f, 0.04299085f, 
    -0.22048709f, -0.04681031f, -0.03624993f, -0.13537581f, 0.08073291f, 0.08541191f, 0.04576372f, 0.13424659f, 
    0.24910811f, 0.06647082f, 0.20901357f, -0.06876224f, -0.00264609f, -0.02182078f, -0.36823860f, -0.68838859f, 
    -0.07118876f, 0.70460755f, -0.13879476f, -0.31256112f, 0.19578062f, -0.06662147f, -0.03607836f, -0.09525517f, 
    -1.39919245f, -0.59716386f, -1.28379500f, 0.25519443f, -0.05007623f, 0.26448008f, -0.00504288f, 0.01348941f, 
    0.08252064f, 0.27999267f, 0.17958264f, 0.23348214f, -0.11065884f, 0.23859246f, 0.09611988f, 0.10694996f, 
    0.04218723f, 0.38290861f, -0.45687234f, 0.27253962f, 0.11336260f, 0.20328826f, 0.02476580f, -0.23588437f, 
    0.19665673f, -0.01436226f, 0.02183787f, -0.09366798f, -0.17824307f, -0.05821125f, 0.05211877f, 0.04151155f, 
    -0.03989175f, 0.25208804f, -0.18555740f, 0.06088364f, 0.28093678f, 0.36552843f, 0.15730383f, 0.08140998f, 
    0.11099607f, -0.08131798f, 0.02826814f, 0.01434188f, -0.22557618f, 0.01393509f, -0.05495125f, 0.10830636f, 
    0.17231214f, -0.07867914f, 0.08184903f, -0.12155510f, -0.06931282f, 0.07969700f, -0.20174542f, -0.29599532f, 
    -0.08481424f, 0.18118784f, -0.07240678f, -0.08055937f, -0.02032137f, 0.07685710f, -0.00597256f, 0.32083556f, 
    -0.24740292f, -0.75139552f, -0.62526757f, -0.04241240f, -0.02835065f, 0.12396315f, 0.07935579f, 0.21288973f, 
    0.14300252f, 0.30030856f, 0.04588731f, -0.16064960f, -0.48984215f, -0.26826048f, 0.25073528f, -0.10773826f, 
    0.07962123f, 0.14114977f, -0.13729830f, 0.02137116f, -0.02873199f, -0.07286428f, 0.16945259f, 0.18991753f, 
    0.08951198f, 0.13087599f, -0.09995901f, 0.03430565f, -0.17631906f, 0.13707086f, 0.07023491f, 0.16826412f, 
    0.11109896f, -0.01000956f, -0.33729827f, -0.06444436f, -0.15374164f, 0.23621520f, 0.04235975f, 0.15369183f, 
    0.09560619f, -0.05543385f, 0.09035002f, 0.01936155f, 0.34965578f, 0.30368462f, 0.23481457f, -0.05140452f, 
    -0.35154918f, -0.20442715f, -0.07883617f, -0.17526212f, -0.19094463f, -0.02197995f, -0.12775007f, 0.11992941f, 
    0.01649866f, -0.08819862f, -0.16517851f, 0.23343509f, 0.35713139f, -0.07451822f, -0.21803242f, -0.26921400f, 
    -0.30459160f, -0.09698848f, 0.23283997f, -0.19561332f, 0.01705826f, 0.14070792f, 0.29362851f, 0.21178600f, 
    -0.15142076f, 0.32141879f, -0.08063060f, -0.23143582f, 0.06968394f, 0.06492522f, -0.07357857f, 0.41346630f, 
    -0.29044765f, -0.27434659f, 0.01430856f, 0.17763112f, -0.08960882f, 0.00745730f, 0.01619682f, 0.14035752f, 
    -0.02548082f, -0.36769101f, 0.09539548f, 0.41254070f, -0.13263556f, 0.05077834f, -0.23281600f, -0.07721963f, 
    -0.10570942f, -0.27618632f, -0.38866958f, -0.41191721f, -0.32214439f, -0.00641160f, 0.04431560f, 0.29056191f, 
    0.20778909f, 0.04934600f, -0.01658078f, -0.41601551f, 0.01612583f, -0.09929653f, -0.25872552f, 0.19931394f, 
    -0.07454651f, 0.16938519f, -0.18732774f, 0.13495177f, 0.15641205f, -0.57142109f, 0.07296593f, -0.04506905f, 
    0.23581615f, 0.05593564f, 0.12273441f, 0.04500052f, 0.19166961f, 0.11519474f, -0.23891056f, 0.37707880f, 
    0.10632399f, -0.07367409f, 0.23788694f, 0.22157298f, 0.12961030f, 0.22965659f, 0.03449534f, -0.14454834f, 
    0.04611921f, 0.07470847f, -0.00487779f, 0.04508523f, 0.18284982f, -0.08014078f, -0.21444778f, 0.46980128f, 
    0.41308960f, -0.35623801f, 0.03585387f, 0.02834056f, -0.17483230f, -0.04780699f, -0.14561489f, -0.10695996f, 
    0.03124410f, -0.07554192f, -0.13987777f, -0.13297549f, 0.06399710f, -0.22105372f, -0.13748632f, 0.05381632f, 
    -0.05062304f, -0.47364700f, -0.28340295f, -0.48412836f, 0.04441147f, 0.19906323f, 0.16319741f, -0.04976881f, 
    -0.09959344f, 0.05962921f, 0.18084821f, 0.04674935f, 0.13726422f, -0.22584029f, -0.08567347f, -0.02921732f, 
    -0.09499085f, -0.05049230f, -0.06737246f, 0.17418462f, 0.05871247f, 0.25314572f, 0.19943640f, -0.06623314f, 
    -0.26595387f, -0.18050824f, -0.03744057f, 0.49206197f, -0.88432556f, -0.42814073f, -0.00405629f, 0.14816786f, 
    -0.08304852f, -0.10980609f, 0.00688516f, -0.18144411f, -0.12849663f, 0.23346859f, -0.03899254f, 0.02357156f, 
    0.05441309f, -0.02059103f, -0.23200443f, -0.13504378f, -0.07637282f, -0.10732717f, -0.39337009f, -1.00674236f, 
    -0.52348930f, 0.08474271f, 0.06111223f, 0.06097164f, -0.12802035f, -0.05712686f, -0.02954786f, -0.10216915f, 
    0.14087646f, 0.13592048f, 0.00170783f, 0.18406974f, -0.12523994f, 0.02459151f, 0.24272582f, 0.28956774f, 
    0.87070191f, 0.33000112f, -0.56019610f, 0.14982651f, 0.03228364f, 0.25423706f, 0.06592591f, -0.28119376f, 
    0.09554032f, -0.92480278f, -0.17081907f, 0.60319877f, -0.09617140f, 0.00334882f, -0.09145217f, 0.07213744f, 
    0.05284597f, -0.18480001f, -0.38060912f, -0.03340680f, -0.17363660f, -0.14113274f, -0.00450974f, 0.02442515f, 
    -0.17402756f, 0.33758914f, 0.12873742f, -0.12849194f, 0.22546047f, 0.27475473f, -0.13452308f, -0.26047221f, 
    -0.12982345f, 0.08265503f, 0.09630845f, 0.28188369f, -0.00967166f, -1.18089807f, -0.70242721f, 0.11661192f, 
    0.07782472f, -0.16678809f, -0.20486866f, 0.07680701f, 0.19740391f, 0.37329945f, -0.02245055f, 0.09153689f, 
    0.35667652f, 0.15979604f, 0.07405884f, 0.18406418f, 0.12611686f, 0.53329879f, 0.04621642f, -0.00507909f, 
    0.22463106f, -0.10406773f, -0.11739253f, -0.06316220f, 0.24928813f, -0.01385445f, 0.08605485f, 0.04066567f, 
    -0.95647961f, -0.16671884f, -0.10930229f, 0.15885852f, -0.13859116f, 0.16537720f, -0.02807387f, 0.19699204f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.38697162f, -0.05552698f, -0.03222436f, 0.26154542f, 0.43505499f, 0.04406909f, -0.08584192f, 0.68204778f, 
    -0.06678480f, -0.14479937f, -0.06234814f, -0.11911885f, 0.04102998f, -0.20505556f, 0.26287633f, 0.20559298f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.64601743f, 0.37740195f, -0.32347560f, 0.01472000f, 0.07579195f, -0.14128353f, 0.21366240f, -0.99776274f, 
    -0.02586821f, 0.67211360f, -0.18014993f, -0.31976926f, 0.02239446f, 0.77927965f, -0.18869294f, 0.24703592f, 
    0.21826652f, 0.15294693f, -0.57333177f, -0.08993708f, 0.40535221f, 0.29805782f, -0.11847348f, 0.22445315f, 
    -0.04665210f, 0.07985032f, -0.23659365f, -0.01772930f, -0.07856958f, 0.78415960f, -0.32154676f, 0.42468646f, 
    -0.48198995f, -0.39160120f, 0.00680283f, 0.39437395f, -0.04790464f, -0.54441285f, 0.13893850f, 0.89041644f, 
    -0.06198226f, -0.33145353f, 0.21249853f, -1.08152199f, -0.05115226f, -0.20750140f, -0.31201228f, -0.73260260f, 
    -0.13435170f, -0.05091713f, 0.48622119f, -0.93247616f, -0.25575110f, -0.03068297f, 0.16650195f, -0.11369074f, 
    -0.10013659f, 0.37957349f, -0.31083399f, -0.02602689f, -0.13964622f, -0.81836641f, 0.27712992f, -1.72433519f, 
    -0.27192786f, -0.57349116f, -0.05611143f, 0.16272476f, -0.23991381f, 0.02941941f, -0.08746199f, -0.51548785f, 
    0.04148344f, 0.01140069f, 0.34522504f, 0.74567771f, -0.07616863f, 0.30231220f, 0.41618791f, -0.20863068f, 
    -0.03807595f, 0.36928001f, -0.54799491f, -0.10975645f, 0.06107030f, 0.35298696f, -0.15747301f, 0.23586297f, 
    -0.17450127f, 0.00614581f, 0.10618450f, 0.70104283f, -0.00547549f, -0.46486849f, -0.28546914f, 0.16529146f, 
    -0.67151636f, -0.13938190f, -0.10983700f, 0.06152033f, 0.29285666f, -0.24037677f, 0.17828529f, 0.42920136f, 
    -0.15568468f, -1.09106195f, -0.58561599f, -1.37784791f, 0.10196318f, -0.33724639f, 0.33896506f, 0.91763771f, 
    0.74703461f, -0.11536378f, 0.22932853f, 0.49096942f, -0.64570147f, -0.48318264f, -0.08810356f, -0.30276194f, 
    0.14255348f, -0.51925284f, 0.08287927f, -0.37142915f, 0.14100043f, -0.35859746f, -0.63688093f, 0.03459864f, 
    0.95006543f, 0.69511884f, -0.36698109f, -0.50736558f, 0.26824015f, 0.13123944f, 0.05510003f, 0.17443608f, 
    0.02428498f, -0.87950730f, -0.47867253f, 0.16374747f, -0.05815221f, 0.31959927f, -0.07873242f, -0.50815374f, 
    -0.31156644f, -0.61503750f, 0.05916211f, 0.29495600f, 0.89136392f, -0.72512114f, -0.11454663f, 0.04107846f, 
    0.09109113f, -0.20733699f, -0.53807157f, -0.27817836f, 0.15033272f, -0.07847502f, 0.75895679f, -0.36831316f, 
    0.16712037f, -0.05072112f, -0.12129143f, -0.93605745f, -0.10999621f, 0.37725905f, 0.15992688f, 0.29871255f, 
    -0.16384773f, -0.55162489f, 1.17849457f, -0.34440735f, -0.01303496f, -0.32811707f, -0.11067597f, -0.93717176f, 
    -0.18423851f, -0.47958657f, 0.05184461f, 0.06114936f, -0.42201528f, 0.96193129f, -0.09495136f, 0.15518612f, 
    -0.06508372f, -0.42890370f, -0.87251496f, -0.14264779f, -0.20422056f, -1.10445154f, 0.31444737f, -0.36015865f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.38962331f, -0.08631413f, 0.27237079f, 0.07404162f, -0.43183789f, -0.32629904f, -0.05470835f, -0.48942918f, 
    0.26494029f, 0.08324647f, 0.17432810f, 0.23628168f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
