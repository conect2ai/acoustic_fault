#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.84218293f, -0.45596877f, 0.22407724f, 0.10239979f, 0.31568748f, 0.64954412f, -0.67826205f, -0.08813971f, 
    -0.32290810f, -0.66656470f, -0.22068131f, 0.25411329f, -0.41624644f, -0.03764351f, -0.48190999f, 0.40210998f, 
    -0.32678166f, -0.07769328f, -0.24655178f, -0.10927691f, -0.28321868f, 0.28155845f, -0.02337944f, -0.45619783f, 
    -0.05182076f, 0.06408527f, -0.26691458f, 0.18661463f, 0.34404641f, 0.03634988f, -0.26122966f, 0.17127514f, 
    -0.15686315f, 0.22248675f, 0.48782966f, 0.59687138f, -0.41040698f, -0.15135020f, -0.23254409f, 0.44610709f, 
    -0.04232180f, -0.08976944f, -0.28868395f, 0.24462453f, 0.17539249f, -0.24193849f, -0.03274338f, -0.21475717f, 
    0.19185580f, 0.32743821f, -0.00794151f, -0.05744667f, -0.63268524f, -0.63346148f, -0.19527815f, 0.27002627f, 
    0.23738773f, 0.40092579f, -0.02974691f, -0.28135410f, 0.11754628f, -0.31421551f, -0.14471382f, 0.36706126f, 
    -0.02057998f, -0.47830048f, -0.27249020f, 0.04994760f, 0.13339339f, -0.24394034f, 0.07388571f, 0.12776577f, 
    0.27669680f, 0.26619151f, 0.01541187f, -0.83774608f, -0.58274317f, -0.19037203f, 0.37743059f, -0.07774933f, 
    0.69882280f, 0.10551259f, -0.19742920f, -0.28335768f, 0.17798141f, 0.05910217f, -0.28653675f, -0.41604251f, 
    -0.25136170f, -0.01585327f, -0.03335686f, 0.08132471f, 0.07704937f, 0.03492693f, -0.06781535f, 0.10100538f, 
    -0.18315835f, 0.20135006f, 0.25598454f, 0.20217234f, -1.17917240f, -0.45550573f, 0.06810252f, 0.43815064f, 
    0.36147591f, 0.35209179f, 0.16312997f, 0.01698262f, 0.68406957f, 0.26057371f, 0.09493621f, -0.05804061f, 
    -0.00064488f, 0.39338493f, -0.06271012f, -0.14614624f, -0.03983871f, 0.01485334f, -0.21789379f, -0.36863443f, 
    -0.01696913f, -0.08395264f, 0.34691864f, 0.01641769f, -0.06347279f, -0.44536823f, -0.16041265f, 0.48653930f, 
    0.59291577f, 0.03380910f, -0.05670838f, 0.13822222f, 0.17650533f, 0.07451107f, -0.11319774f, -0.08812406f, 
    -0.07369841f, -0.46486244f, 0.37619460f, 0.06639749f, -0.26667291f, 0.26647776f, -0.14802906f, -0.02953698f, 
    0.01026229f, -0.29096130f, 0.07521089f, -0.10805381f, 0.09212330f, 0.21065411f, 0.63419515f, 0.35610983f, 
    0.44738740f, -0.08231272f, 0.41186595f, -0.47091261f, 0.02328896f, -0.18502893f, 0.11900297f, -0.12548991f, 
    -0.02623604f, 0.20161322f, 0.00335983f, -0.46621525f, 0.03438311f, 0.02124546f, -0.21989076f, 0.11049368f, 
    -0.02699284f, 0.06962115f, 0.05818980f, 0.18835458f, -0.26064596f, 0.12646972f, -0.13059671f, -0.60967541f, 
    0.70802206f, -0.41535655f, -0.33971334f, 0.26230043f, -0.18337701f, 0.36861324f, 0.64132828f, -0.10097529f, 
    -0.53242517f, -0.25522944f, 0.23588225f, -0.21443692f, -0.10896354f, -0.10836122f, 0.34718451f, 0.25345656f, 
    -0.17661288f, -0.34195569f, -0.09684356f, -0.18091939f, -0.22777663f, 0.20071727f, 0.16402738f, 0.15763628f, 
    -0.11052385f, -0.23610599f, 0.31905788f, 0.22542268f, -0.01512680f, 0.27442819f, 0.14902762f, 0.22559083f, 
    -0.14104670f, 0.08774690f, 0.18318804f, 0.24982890f, -0.11897024f, 0.20648240f, -0.26474968f, -0.27613261f, 
    0.14110173f, 0.16285311f, 0.06736905f, 0.18998821f, 0.11322663f, 0.35353953f, 0.35104540f, 0.20616931f, 
    0.14348122f, -0.08096518f, -0.66810560f, -0.50790483f, -0.17101389f, -0.38318354f, -0.49717876f, -0.54514170f, 
    -0.27535596f, -0.43825990f, -0.84713650f, 0.33405593f, -0.18392296f, 0.16603720f, 0.18078634f, 0.08388279f, 
    -0.02420783f, -0.04324488f, 0.03206814f, 0.08907748f, 0.05919970f, -0.26651233f, 0.11968956f, 0.15922658f, 
    -0.11099205f, 0.24827822f, -0.55453789f, 0.07249448f, 0.14572769f, 0.39989266f, -0.36298171f, -0.82400167f, 
    0.28932163f, -0.54301792f, -0.10674668f, 0.65325487f, 0.16252089f, -0.33353087f, 0.48200512f, -0.29188040f, 
    -0.09314131f, 0.11162848f, -0.16918825f, 0.24359564f, -0.21352115f, 0.00734775f, -0.01101387f, 0.21071891f, 
    -0.08793309f, -0.04368887f, 0.18737610f, -0.91604763f, -0.37259266f, -0.48825994f, -0.52842015f, 0.07298297f, 
    -0.29230499f, -0.09466483f, -0.10982125f, 0.45294887f, 0.25041270f, -0.15626745f, -0.58466530f, -0.30512208f, 
    -0.01141569f, -0.09484988f, -0.06276722f, 0.12604283f, -0.02441803f, 0.17552429f, -0.27801523f, -0.23695679f, 
    -0.15245657f, -0.11902010f, -0.11791679f, -0.50822693f, 0.56149465f, -0.64575815f, -0.81485075f, -0.71657592f, 
    -0.68596518f, 0.83731025f, 0.57906783f, 0.01192714f, -0.12178361f, 0.20599188f, 0.14373666f, 0.41493958f, 
    -0.19581605f, -0.10458114f, -0.04084416f, -0.13678887f, 0.10391104f, 0.00354847f, -0.19301088f, -0.13873839f, 
    -0.11606823f, -0.17369066f, -0.26829645f, 0.21739431f, -0.27619964f, -0.13911487f, -0.53888947f, -0.09363345f, 
    0.44464248f, 0.75091773f, -0.11949734f, 0.32872692f, 0.39088461f, -0.52575487f, -0.18915239f, 0.02687051f, 
    0.04371503f, 0.36325634f, -0.60405409f, -0.07602099f, 0.12618311f, 0.01574474f, 0.10126475f, 0.16186664f, 
    -0.02897795f, 0.11785525f, -0.29049763f, 0.01553079f, 0.25253990f, -0.25257277f, 0.29696390f, 0.52564394f, 
    -0.09983960f, -0.40603277f, -0.65651017f, -0.10525034f, 0.05702533f, 0.39974821f, -0.58404005f, -0.17458746f, 
    0.21516438f, 0.14357378f, 0.19593573f, -0.12932824f, -0.22150135f, 0.08957721f, -0.15151954f, -0.30368271f, 
    -0.31952193f, -0.21262939f, 0.35985813f, 0.10006716f, 0.16978703f, 0.06682391f, 0.51153708f, 0.13277145f, 
    0.52951151f, 0.45428455f, 0.74677765f, 0.14193825f, -0.11713205f, -0.25835767f, -0.35544780f, -0.41138566f, 
    -0.47221145f, -0.02877272f, -0.02972692f, -0.06139452f, 0.00643444f, 0.22888610f, 0.08924752f, -0.26931906f, 
    -0.01948163f, 0.25972819f, -0.08699815f, 0.06931837f, 0.16623108f, 0.15868337f, -0.15270342f, -0.35603526f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.15977667f, 0.10570166f, 0.12186904f, 0.08894655f, 0.19446908f, 0.32599282f, 0.21503717f, 0.45512223f, 
    -0.16150421f, 0.12768514f, 0.11212659f, 0.05984879f, 0.28544357f, 0.25676981f, 0.16586997f, 0.12714930f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.42348573f, 0.24848574f, 0.12226429f, -0.19363327f, -0.09577220f, 0.10211004f, 0.03059639f, 0.14853258f, 
    -0.06596588f, -0.05363688f, 0.02030129f, -0.06459561f, 0.17226624f, -0.05289913f, 0.19083999f, -0.15046224f, 
    -0.07830317f, -0.04154255f, -0.10204783f, -0.24048533f, 0.06128314f, 0.04980677f, 0.01581123f, -0.01072629f, 
    -0.02448388f, 0.04515737f, -0.43674248f, -0.10384775f, -0.03071086f, 0.09310027f, 0.00873601f, -0.01438339f, 
    0.07506584f, 0.11333024f, -0.06064714f, 0.15182535f, 0.21224272f, 0.00697092f, -0.15388097f, -0.23556381f, 
    -0.08910752f, 0.14354526f, 0.00679177f, 0.18390714f, 0.10651238f, 0.03146895f, -0.02215894f, 0.08986205f, 
    0.41274536f, -0.07898577f, -0.10520120f, -0.16369040f, -0.13793939f, 0.08759450f, -0.08904137f, -0.03054705f, 
    0.10402699f, 0.08591203f, 0.16470082f, 0.15223977f, 0.20026281f, -0.02729046f, 0.17046152f, -0.09866995f, 
    -0.11902183f, -0.03027762f, 0.03568242f, 0.00722428f, -0.13459575f, 0.03824325f, 0.01434929f, -0.07696627f, 
    -0.23358393f, 0.06809559f, 0.01899133f, -0.03901878f, 0.03164600f, -0.07909843f, -0.09063528f, -0.09597494f, 
    -0.12751137f, -0.21087724f, 0.13271284f, -0.01720544f, 0.02077095f, 0.18049754f, -0.19706911f, 0.16477132f, 
    0.01554084f, -0.05502254f, 0.12477596f, 0.07684552f, 0.17465945f, -0.05370812f, 0.02643960f, 0.15148753f, 
    -0.01954866f, -0.01559205f, -0.14226785f, -0.05638285f, -0.15204778f, -0.13395992f, -0.05678352f, 0.00743630f, 
    0.11002003f, 0.07158206f, 0.11601489f, -0.02044300f, 0.28151456f, 0.05114878f, -0.14868569f, -0.06952313f, 
    0.21165632f, 0.07693400f, 0.12508875f, 0.20293318f, -0.09441482f, 0.06146136f, 0.01067534f, 0.13314797f, 
    0.24843286f, 0.14651982f, 0.21452269f, 0.06009429f, 0.33837774f, -0.11230889f, 0.12287787f, 0.26096582f, 
    -0.02035769f, -0.11655021f, -0.03227165f, 0.07488783f, 0.06653532f, -0.08350422f, -0.11854070f, -0.15232748f, 
    0.04995450f, 0.02536687f, 0.05050020f, 0.13222998f, 0.08869757f, -0.01501882f, -0.18701321f, -0.13213170f, 
    -0.24013612f, -0.36512887f, -0.17793347f, -0.17798382f, -0.06355867f, -0.01640481f, -0.09217083f, 0.09661017f, 
    0.10324115f, 0.02993073f, -0.04698135f, -0.03500908f, 0.23007832f, 0.04238853f, 0.04557269f, -0.16143711f, 
    -0.06491845f, 0.08225115f, -0.11028449f, -0.00036339f, -0.09952219f, -0.07867189f, 0.04977032f, 0.00897127f, 
    -0.13673598f, 0.17225589f, -0.17949271f, 0.37845218f, 0.13885354f, 0.03591661f, 0.02125550f, 0.06985366f, 
    0.04926070f, 0.04022054f, -0.03992408f, 0.01553710f, -0.14371100f, -0.03850153f, 0.15130110f, -0.01005397f, 
    -0.04098115f, 0.14284167f, 0.02426899f, -0.10790314f, 0.02759446f, 0.02469750f, -0.11689912f, 0.12057140f, 
    -0.14137690f, 0.11193042f, -0.18212834f, -0.02497152f, 0.13438661f, -0.05493505f, -0.02785513f, 0.13259922f, 
    0.01906363f, 0.06748898f, -0.10804257f, 0.00723613f, -0.01373002f, -0.06248131f, 0.01009161f, -0.04855449f, 
    0.01961624f, 0.09607283f, -0.10043102f, -0.00556795f, 0.13853355f, 0.02054262f, 0.13785382f, 0.12801041f, 
    -0.16449390f, 0.07317705f, 0.20451455f, -0.06739195f, -0.04625361f, -0.03242651f, 0.21497849f, 0.11028837f, 
    0.06137685f, 0.05605251f, 0.09515056f, -0.06283710f, -0.07554746f, -0.12194940f, 0.15396872f, 0.05826466f, 
    0.03557555f, 0.09528112f, 0.14058918f, 0.09517720f, 0.10258508f, 0.09746775f, -0.00455469f, -0.01477234f, 
    -0.01505121f, -0.06009118f, -0.01755190f, -0.34838647f, -0.15402316f, -0.06408129f, -0.03978099f, 0.00377676f, 
    0.09239829f, 0.20800933f, 0.09442697f, 0.12571084f, 0.15847620f, 0.44529349f, -0.04397750f, 0.05147071f, 
    0.00126021f, -0.05889233f, -0.02680251f, -0.06456842f, 0.11716625f, 0.07872855f, 0.08954603f, 0.05141576f, 
    -0.02175842f, -0.02859657f, 0.05580168f, 0.00133238f, -0.14055745f, -0.22749664f, -0.00546290f, -0.14078848f, 
    0.04322984f, 0.05322479f, -0.01170706f, 0.01150452f, 0.31170183f, -0.01087443f, 0.13625123f, 0.23118921f, 
    0.03103594f, -0.00470956f, 0.05671290f, 0.07056544f, 0.18728745f, 0.10488485f, -0.13245718f, 0.10847093f, 
    -0.05939084f, -0.11941358f, -0.12913124f, -0.05174034f, 0.06570525f, -0.12109234f, -0.00570870f, 0.01272676f, 
    0.01746329f, 0.14934330f, 0.15392923f, 0.15809362f, -0.43353012f, -0.07709511f, 0.00778073f, 0.17953616f, 
    0.08948039f, 0.07488155f, 0.06340621f, -0.15007725f, -0.01594865f, -0.11243773f, -0.04243889f, 0.00934355f, 
    0.25450927f, -0.29294246f, 0.04662293f, -0.04024106f, 0.15936203f, 0.12478320f, 0.01370216f, 0.27622515f, 
    -0.14601646f, -0.02452706f, 0.12747590f, 0.02615849f, -0.02365861f, 0.00794140f, -0.08852106f, -0.10588409f, 
    0.04188155f, -0.03521405f, 0.05564616f, 0.02387346f, -0.05339848f, -0.05923212f, -0.09698475f, -0.13248762f, 
    0.13218714f, 0.01426033f, 0.14371485f, 0.05499302f, 0.02803873f, 0.00387630f, 0.17959179f, -0.10105296f, 
    0.19912677f, 0.01891152f, 0.02703718f, -0.08324254f, 0.10913236f, 0.01424310f, -0.06454052f, 0.09620688f, 
    -0.05044080f, -0.11041303f, -0.02037152f, 0.00375792f, 0.12793374f, 0.03821009f, 0.05411560f, 0.01522138f, 
    0.09170779f, 0.02175635f, -0.08210679f, 0.00195764f, -0.05595044f, -0.05515218f, -0.04820908f, 0.00277007f, 
    0.12671694f, 0.03063112f, 0.07575954f, 0.12338470f, -0.27637175f, -0.23421988f, -0.11245546f, 0.04125207f, 
    -0.07501696f, -0.07330819f, -0.13387676f, -0.07984561f, -0.11654575f, -0.01540155f, 0.05074826f, -0.12822834f, 
    -0.23122381f, -0.38578898f, 0.11249352f, 0.21629912f, 0.09949115f, 0.01983530f, 0.08140883f, -0.14640075f, 
    0.09592719f, -0.01975700f, 0.12844230f, 0.07590418f, -0.00257273f, 0.04299755f, -0.08477466f, 0.07843263f, 
    0.01651648f, -0.00531333f, -0.02140586f, 0.12029503f, 0.01729857f, 0.02771905f, -0.07866368f, -0.05949876f, 
    0.05550752f, 0.05799517f, 0.26194000f, -0.02785610f, 0.08165419f, -0.04250877f, -0.01402261f, 0.07229377f, 
    -0.18778087f, -0.15671998f, 0.05872972f, -0.08328928f, -0.02733965f, -0.11429822f, 0.16123825f, 0.26856649f, 
    0.10439738f, -0.08803063f, 0.03708729f, 0.03515110f, -0.03035098f, -0.13079558f, 0.04246995f, -0.01162800f, 
    -0.20132831f, -0.09415342f, 0.09883594f, 0.54634678f, 0.03185993f, -0.13613810f, 0.04442633f, -0.07709949f, 
    -0.04559941f, -0.03216711f, 0.01694783f, -0.00149379f, -0.01185054f, -0.16615780f, -0.03196321f, 0.15299533f, 
    0.14899355f, -0.00342686f, 0.05595854f, 0.03224809f, 0.14715293f, -0.01159804f, -0.01302498f, 0.01969978f, 
    0.18663183f, 0.06120074f, -0.13305925f, -0.00259711f, -0.02575730f, 0.09106055f, 0.10061248f, 0.12052669f, 
    0.06123086f, 0.04246439f, -0.07696900f, 0.00014180f, -0.23152041f, 0.30849189f, 0.12749906f, 0.00017161f, 
    0.10418491f, 0.16725098f, -0.05942435f, 0.08849649f, -0.12317238f, 0.05388094f, -0.07477311f, -0.03816873f, 
    -0.07438028f, -0.05812379f, 0.03335902f, 0.06778118f, 0.05815311f, 0.15987502f, 0.05323063f, -0.04100889f, 
    -0.06210144f, -0.16227892f, -0.02829544f, -0.11266478f, -0.07334550f, 0.10492187f, 0.22847606f, -0.00012394f, 
    -0.09830987f, -0.00478263f, -0.10652963f, -0.05915080f, 0.01091663f, -0.14350647f, -0.06305397f, -0.09220903f, 
    -0.28459212f, -0.06345128f, -0.46263394f, 0.09390765f, -0.24087411f, 0.20135970f, -0.11737927f, -0.17214566f, 
    0.16028963f, -0.03920175f, -0.06761505f, -0.17455342f, -0.17970963f, 0.05173841f, 0.08823956f, 0.24640173f, 
    -0.00014827f, -0.14432649f, -0.02759979f, -0.09020121f, 0.04330586f, 0.02340099f, 0.14795001f, 0.09795751f, 
    0.19619401f, 0.06511796f, 0.14069225f, -0.16952060f, -0.10396831f, -0.01402078f, -0.07865223f, 0.08789427f, 
    0.03929617f, 0.09637177f, 0.09232056f, 0.15883403f, -0.06442231f, -0.28004169f, 0.01292706f, -0.01594387f, 
    0.03499383f, 0.12414248f, 0.06280737f, 0.14264174f, 0.16040750f, 0.13075335f, 0.01135014f, -0.02239679f, 
    -0.06267137f, 0.05817218f, 0.04540613f, -0.25027245f, 0.04036674f, -0.00064741f, -0.07871256f, 0.10660844f, 
    -0.13554573f, 0.01582048f, -0.13783084f, -0.03011455f, 0.32214767f, 0.19810314f, 0.00169772f, -0.07079435f, 
    0.03716506f, -0.00298746f, 0.07027750f, 0.07490047f, -0.07147629f, -0.01541840f, -0.00258660f, 0.00684812f, 
    0.00909730f, 0.02637384f, -0.18670700f, 0.12001686f, -0.02871995f, -0.09946831f, 0.11811963f, 0.13896307f, 
    0.11706288f, 0.04602317f, 0.02674188f, -0.12932108f, -0.13000003f, 0.02145226f, 0.01928601f, 0.06017528f, 
    -0.07865079f, 0.04273611f, 0.00865222f, -0.04748537f, 0.12661913f, -0.05484562f, 0.08519956f, 0.05418412f, 
    0.09883588f, 0.04256563f, 0.10974399f, 0.10674743f, 0.08288246f, 0.09563117f, 0.19278924f, 0.13006462f, 
    -0.11850093f, -0.07576818f, -0.01713089f, -0.09779152f, 0.20404862f, 0.15377440f, 0.14575075f, -0.16159803f, 
    0.01524925f, -0.00690578f, 0.09370586f, -0.07875845f, 0.02683404f, -0.05098162f, -0.01563386f, -0.10266706f, 
    -0.37551638f, 0.02755363f, -0.11237988f, -0.14262326f, 0.04380902f, -0.01154339f, 0.07496150f, -0.02048946f, 
    -0.02863111f, 0.06463680f, 0.00667569f, -0.11510208f, -0.11143164f, -0.01409855f, -0.06261899f, -0.09736589f, 
    -0.01831028f, -0.05616307f, -0.00096496f, -0.09130054f, 0.03227692f, -0.06643367f, -0.10090134f, 0.14204413f, 
    0.06129861f, -0.00513224f, 0.09777804f, 0.00997573f, 0.02399469f, -0.08907048f, -0.02144498f, 0.00070996f, 
    -0.08204281f, 0.00733156f, -0.04874542f, 0.06415346f, -0.10077448f, -0.33092156f, 0.16476123f, 0.02522342f, 
    0.01884359f, 0.06169183f, 0.05758693f, -0.03460670f, 0.04268618f, 0.17339794f, -0.02870863f, 0.11247879f, 
    -0.10148188f, 0.02382194f, -0.03586621f, -0.01231980f, 0.06823329f, -0.05931385f, 0.03467669f, -0.03266120f, 
    -0.17169587f, -0.06376620f, 0.01805343f, 0.04328724f, 0.10782574f, -0.00488863f, 0.03883596f, -0.03606928f, 
    -0.03231692f, 0.04122367f, 0.03153381f, -0.17982690f, -0.01985491f, -0.10685451f, 0.01143700f, -0.05660862f, 
    0.19119278f, 0.15956038f, 0.00379599f, -0.05464691f, 0.05174576f, 0.08886474f, 0.00420448f, 0.06685075f, 
    -0.00185613f, -0.00283591f, 0.05952058f, -0.13172755f, 0.26775780f, 0.15054008f, 0.06294332f, 0.05894897f, 
    0.17471312f, -0.00866927f, -0.06952734f, -0.10896751f, -0.00286819f, 0.08547577f, -0.11214586f, -0.09776688f, 
    0.25355053f, -0.07909597f, -0.28437746f, 0.05493665f, -0.02834729f, 0.04741425f, 0.04041465f, -0.11143564f, 
    -0.07444748f, -0.00966174f, -0.07225230f, 0.02488173f, -0.05090420f, -0.06152014f, -0.13595331f, 0.02380896f, 
    -0.04500307f, -0.08114955f, 0.15804738f, -0.07737080f, 0.08326917f, 0.04883700f, 0.06010142f, 0.06771109f, 
    0.09585188f, -0.16631550f, 0.10067831f, -0.14552960f, -0.03513938f, 0.18202174f, 0.03362846f, -0.03832717f, 
    -0.05596588f, -0.07166033f, -0.05949524f, 0.03450440f, -0.10279075f, 0.11846856f, -0.13745306f, -0.15943612f, 
    -0.12581275f, -0.17690992f, -0.00075755f, -0.05606883f, -0.13959266f, 0.01479212f, 0.04048450f, 0.00180780f, 
    0.05150392f, -0.05493870f, -0.05089901f, 0.01218625f, 0.04714966f, 0.00540163f, 0.02392626f, 0.03434763f, 
    -0.07585710f, 0.01565384f, -0.00227718f, -0.03141275f, 0.04536037f, -0.06408984f, 0.01428933f, 0.06405368f, 
    -0.07927343f, 0.01013177f, -0.03044358f, -0.06265214f, -0.07134172f, 0.02177683f, 0.04042464f, -0.03400601f, 
    -0.04883514f, -0.04165822f, 0.04970269f, -0.03734570f, 0.00970095f, -0.02619669f, -0.01426332f, -0.04276140f, 
    0.03154134f, -0.08171464f, -0.05314315f, -0.04213338f, -0.06714724f, -0.05025324f, 0.02738745f, -0.07864889f, 
    -0.04217260f, 0.04797268f, 0.04347798f, 0.01525844f, -0.04955022f, 0.01840222f, -0.03810503f, 0.00931787f, 
    -0.04032530f, -0.00164509f, -0.02447616f, -0.03710966f, -0.02596487f, 0.02935347f, 0.06235944f, 0.01506438f, 
    0.05394464f, -0.05655148f, -0.07824282f, -0.07562774f, -0.02800653f, -0.04528917f, -0.04858074f, -0.03092080f, 
    -0.01103136f, -0.04744847f, -0.04659390f, -0.03773362f, -0.07373243f, 0.02484264f, 0.02795866f, 0.05040944f, 
    0.06016098f, -0.04849026f, -0.04425593f, 0.05787980f, -0.02413977f, -0.05110234f, 0.05921812f, -0.00104619f, 
    -0.04455655f, 0.02513350f, -0.04890826f, -0.03605196f, -0.04290780f, 0.05438686f, 0.04431631f, -0.05911401f, 
    0.02022928f, -0.06658586f, -0.03461473f, -0.06642248f, -0.03294222f, -0.00824613f, 0.02486251f, 0.03407497f, 
    0.02154646f, -0.05960720f, 0.03053302f, -0.02858773f, -0.06418754f, 0.02132587f, -0.05949351f, 0.00048124f, 
    0.04038235f, 0.06086078f, 0.01266214f, 0.04172016f, -0.03802834f, -0.01326293f, 0.01852715f, 0.05891423f, 
    -0.04731211f, 0.03876116f, -0.06728206f, -0.05703946f, -0.01198061f, -0.02612875f, 0.05096008f, 0.00481108f, 
    0.00987302f, 0.00236817f, -0.00734717f, -0.03347449f, -0.01994934f, 0.05221326f, -0.01192673f, 0.04138493f, 
    -0.05029098f, -0.04133991f, 0.05015188f, -0.04437814f, -0.01381080f, -0.07645676f, 0.05918795f, 0.04562199f, 
    -0.06655475f, -0.05728340f, -0.02008785f, 0.06362390f, -0.04146330f, 0.05495539f, 0.01626280f, 0.01955928f, 
    -0.01140640f, -0.04115342f, 0.01043138f, -0.00292739f, 0.05056011f, 0.00840960f, -0.01619478f, -0.05917567f, 
    0.06080046f, -0.06553373f, 0.04434237f, -0.01282959f, 0.01465056f, -0.02590544f, 0.06039983f, -0.01008910f, 
    0.02105797f, 0.04733829f, 0.06007471f, 0.05486154f, 0.06292675f, -0.00474354f, -0.03906476f, -0.05453530f, 
    -0.03898631f, -0.07011945f, 0.06203819f, -0.04537927f, -0.07366753f, -0.00594672f, -0.02188220f, -0.03233998f, 
    -0.05540277f, -0.03156993f, -0.04188520f, 0.02143127f, 0.05452483f, 0.03417837f, -0.04401458f, 0.06681211f, 
    -0.04499094f, -0.03356254f, 0.01315256f, 0.01305400f, 0.03293669f, 0.00485823f, 0.03415181f, -0.07360224f, 
    0.05574478f, 0.00852124f, -0.03120099f, 0.04700218f, -0.07985357f, -0.01868371f, 0.00977097f, -0.03910454f, 
    -0.04473911f, 0.02508948f, -0.06343941f, -0.01200602f, -0.07112797f, -0.04487826f, -0.00991070f, 0.02232928f, 
    -0.03667725f, -0.06959184f, -0.05247949f, 0.04061097f, -0.04309024f, -0.04777772f, 0.03010955f, -0.02401426f, 
    -0.01974223f, -0.05764733f, -0.03056713f, 0.03114670f, -0.02330072f, -0.02028443f, -0.08182866f, -0.01414192f, 
    0.01373834f, 0.03159263f, -0.07492144f, -0.06296194f, -0.02604242f, 0.05263134f, -0.04075472f, -0.07485889f, 
    -0.01047644f, 0.02058714f, 0.00135830f, -0.03077033f, -0.00166589f, 0.05231995f, 0.03438152f, -0.06756262f, 
    -0.02197479f, -0.07891165f, 0.02745856f, -0.03917061f, -0.00930892f, 0.04890475f, -0.00574478f, -0.07933272f, 
    -0.01522548f, -0.00893264f, 0.05288179f, -0.00948775f, -0.02684204f, 0.01763857f, -0.05332447f, -0.03066740f, 
    -0.00993460f, -0.05146763f, 0.01987703f, 0.04024951f, 0.01571684f, -0.07736468f, -0.02551930f, -0.08014746f, 
    0.03993570f, -0.06524757f, 0.03197392f, -0.04646340f, 0.02675593f, 0.03029219f, 0.01676749f, -0.04997258f, 
    -0.04466059f, -0.05066644f, 0.02671392f, -0.06769682f, 0.00639657f, -0.06253012f, -0.06208985f, 0.01251541f, 
    -0.04808828f, 0.05340613f, -0.07398872f, 0.01031150f, 0.05445626f, -0.04151367f, 0.00264657f, -0.01034060f, 
    -0.05924345f, -0.04656620f, -0.00393461f, -0.00717579f, 0.02793158f, 0.01014112f, 0.00694946f, -0.04688134f, 
    0.06146080f, -0.08208293f, -0.07391523f, -0.02065132f, 0.05195152f, -0.06570644f, -0.07279997f, -0.07895131f, 
    -0.03696875f, 0.05434318f, -0.01979717f, -0.02119062f, -0.00131042f, -0.04169888f, -0.01726865f, 0.04083650f, 
    0.00099065f, 0.03650276f, 0.00979609f, -0.01933985f, 0.05415269f, 0.02360346f, 0.03572653f, -0.04834316f, 
    0.05966717f, 0.02228699f, -0.00577663f, -0.08400106f, 0.04853075f, 0.04905616f, 0.01219261f, 0.03643280f, 
    0.05156159f, 0.03917735f, -0.04854285f, 0.04565300f, -0.00807193f, 0.01416099f, 0.00738870f, 0.01733893f, 
    0.03268729f, -0.01553146f, -0.00758083f, -0.01844635f, -0.00855528f, 0.01322009f, -0.02735285f, 0.05214920f, 
    -0.04886245f, 0.05101938f, 0.01467774f, -0.02850383f, -0.00607399f, 0.06125430f, 0.02101585f, -0.05743179f, 
    -0.03217205f, 0.05333182f, -0.03247913f, -0.02375420f, -0.02666832f, 0.05677391f, 0.01579488f, -0.05424405f, 
    0.03121655f, 0.02269772f, 0.05591726f, -0.02313691f, 0.02023790f, 0.02267866f, 0.04986217f, 0.06066479f, 
    -0.01948202f, -0.03300725f, -0.01913748f, 0.00938597f, 0.04556842f, -0.06024916f, -0.05458284f, -0.03738583f, 
    -0.00745654f, -0.04530151f, -0.03725629f, -0.04184936f, 0.05613599f, -0.02213116f, -0.01318894f, -0.07865731f, 
    -0.02937008f, 0.31310588f, 0.14557573f, -0.13814005f, 0.00748561f, 0.11263920f, 0.09969784f, -0.06709211f, 
    -0.05878890f, -0.04531450f, 0.01716394f, 0.05913952f, 0.04789503f, -0.08445819f, -0.15838152f, 0.04552698f, 
    0.18097110f, -0.06549005f, -0.02903857f, 0.01897477f, -0.04880897f, 0.08278193f, 0.13806193f, 0.10902233f, 
    -0.05200318f, 0.10666375f, -0.16965397f, 0.01240967f, 0.05818048f, 0.04422006f, -0.16162975f, -0.08013706f, 
    0.07369585f, -0.10583372f, -0.00585071f, -0.09779701f, -0.20874909f, 0.14608942f, 0.00045566f, -0.11046319f, 
    0.09262699f, 0.00337328f, -0.08595702f, -0.08770813f, 0.03177015f, 0.09278880f, -0.07953800f, 0.01092797f, 
    -0.39367899f, -0.37617514f, 0.10466690f, -0.03330531f, 0.05539566f, 0.10594140f, 0.03228215f, -0.01451473f, 
    -0.06605485f, -0.06384883f, 0.00965880f, 0.00549017f, 0.03949776f, -0.01040472f, -0.01394799f, 0.05869778f, 
    0.08931694f, -0.11666607f, -0.02506871f, 0.06159616f, -0.15715292f, 0.12218837f, 0.01467093f, 0.08104777f, 
    -0.13115409f, 0.01261111f, -0.02871777f, 0.10863539f, -0.03773519f, 0.06253985f, -0.10889985f, 0.06069511f, 
    -0.04846109f, -0.05107954f, -0.08425689f, 0.02232398f, 0.12123299f, 0.08504445f, -0.17556575f, -0.02811734f, 
    -0.02133242f, -0.05751521f, -0.10266937f, -0.04432388f, 0.02918308f, -0.12336316f, -0.13678262f, 0.20099741f, 
    -0.00727534f, -0.05710117f, -0.06986294f, -0.01591651f, -0.07229807f, -0.08837040f, 0.03405335f, -0.01647144f, 
    0.17676075f, 0.04272254f, -0.10608692f, -0.23118573f, 0.19520439f, 0.08212528f, 0.01140946f, 0.01595206f, 
    0.20480031f, 0.13115428f, -0.07838892f, -0.08783499f, 0.09771003f, 0.05753901f, 0.06592555f, -0.06971420f, 
    0.00708114f, -0.05153414f, 0.11661232f, 0.00531656f, 0.04487704f, -0.16128908f, -0.02455309f, 0.24501908f, 
    -0.00112108f, 0.05604319f, 0.01275130f, 0.12082706f, 0.11058431f, 0.02933886f, 0.02968773f, -0.01438300f, 
    0.04469479f, -0.06282975f, 0.05575776f, 0.12932742f, 0.02938369f, -0.12391971f, 0.01045768f, 0.04412491f, 
    -0.35980260f, -0.10652132f, -0.11293493f, -0.03823075f, 0.16133322f, 0.10756000f, 0.13216153f, -0.03290858f, 
    0.02030792f, 0.02130931f, 0.11208631f, 0.11048239f, -0.00982206f, 0.21615902f, -0.12640828f, -0.07781002f, 
    0.04528716f, 0.15538110f, 0.15493684f, 0.21646750f, -0.15229388f, 0.14925079f, -0.05126593f, -0.08026670f, 
    0.06680023f, 0.16185324f, -0.14377213f, 0.18504921f, 0.02231722f, -0.17897604f, -0.08243384f, -0.12061876f, 
    0.04252039f, 0.07391298f, -0.00190447f, -0.09478174f, -0.03516535f, 0.12724105f, 0.21989951f, 0.07231003f, 
    0.14469688f, -0.04620017f, -0.12550463f, 0.15920174f, 0.07550418f, -0.06947602f, 0.05981652f, -0.01390194f, 
    -0.03872617f, -0.02491571f, 0.01952807f, -0.05333585f, 0.04562470f, 0.02412646f, 0.05954625f, -0.07137176f, 
    0.03113369f, 0.05492277f, 0.00538188f, -0.02840921f, 0.05096513f, 0.01828078f, 0.00222268f, -0.07403985f, 
    -0.04531452f, -0.02983113f, 0.02394963f, -0.00540913f, 0.00302177f, 0.05704878f, -0.00801688f, -0.05944088f, 
    -0.06037918f, 0.05203539f, 0.03872810f, -0.03309612f, -0.05377046f, 0.04356834f, -0.05585065f, -0.01886228f, 
    0.05505425f, -0.01069022f, -0.04460647f, -0.02611271f, -0.01999225f, 0.07807806f, -0.04677181f, -0.06279014f, 
    0.00517538f, 0.02690668f, -0.04218034f, -0.03937348f, -0.02809247f, 0.01754637f, -0.04362373f, 0.05833144f, 
    -0.04217247f, 0.05221016f, 0.03245182f, 0.04988601f, -0.04394718f, -0.05807232f, 0.05613447f, -0.01070462f, 
    -0.01905099f, 0.01630214f, 0.02437978f, 0.06122080f, -0.01016277f, -0.03602925f, -0.03980906f, -0.06777272f, 
    -0.03141508f, -0.05565717f, -0.03239913f, -0.01178781f, 0.03108091f, 0.00634262f, -0.04421293f, -0.06226375f, 
    -0.07853498f, 0.02585529f, 0.04156097f, 0.04367577f, 0.02862654f, -0.04742319f, 0.03358567f, -0.03683024f, 
    0.02866741f, -0.06896550f, 0.05163463f, 0.00691323f, -0.03511614f, 0.02428863f, 0.06261614f, -0.00962974f, 
    -0.07394738f, 0.02363739f, -0.06964396f, 0.04119981f, -0.02173225f, -0.02549211f, -0.01957779f, -0.04209653f, 
    -0.05676449f, 0.01749702f, -0.07746499f, -0.04479316f, -0.03553498f, 0.01566125f, -0.03982663f, 0.01802907f, 
    0.01576729f, 0.05570628f, 0.00105790f, -0.03127297f, 0.02035500f, -0.01060369f, -0.03998673f, -0.02758939f, 
    -0.04453024f, 0.02347346f, 0.03810965f, -0.05382974f, -0.07657328f, 0.00189606f, -0.02753018f, -0.02952856f, 
    0.01479548f, 0.05150416f, 0.01878550f, 0.02954183f, 0.05812567f, -0.05561009f, 0.01611404f, -0.00156987f, 
    0.00069534f, 0.02008251f, -0.02895158f, -0.04371281f, 0.00278211f, -0.06809676f, 0.05968814f, -0.05817879f, 
    0.03192074f, 0.01179034f, -0.00282298f, -0.04071734f, -0.00414626f, 0.02492798f, -0.00857450f, 0.01453606f, 
    0.06642213f, -0.06376800f, -0.02146432f, 0.07627080f, -0.07528962f, 0.04615774f, -0.02321931f, 0.03955770f, 
    0.00847018f, -0.01242221f, -0.05024106f, -0.07521377f, -0.00541910f, 0.02897713f, -0.02107775f, 0.05456629f, 
    -0.06415030f, 0.05683909f, -0.00354632f, -0.05531321f, 0.04496031f, -0.03301593f, -0.00990936f, 0.00484459f, 
    -0.02818235f, 0.02811056f, 0.01269520f, -0.06784499f, 0.06592698f, 0.01749643f, -0.05567628f, 0.04005951f, 
    -0.04511938f, -0.06319533f, 0.06650789f, -0.05178529f, 0.00898080f, -0.03655775f, -0.01461660f, 0.02297554f, 
    -0.05800429f, 0.04507753f, -0.06175068f, 0.05838700f, -0.00415945f, -0.05293579f, -0.00904099f, 0.05894880f, 
    -0.16041255f, -0.03546143f, -0.20212035f, 0.04872775f, 0.02546653f, -0.01600177f, -0.09342678f, 0.15681420f, 
    0.07893426f, 0.21294777f, 0.14020157f, 0.03325907f, 0.14289410f, 0.16722386f, 0.09460343f, -0.03803684f, 
    -0.14453764f, 0.04693813f, -0.00499966f, 0.02054163f, 0.26215291f, -0.12637655f, 0.26903200f, -0.06743504f, 
    0.06621420f, -0.12452269f, 0.04267968f, 0.02990854f, 0.07566685f, -0.02102012f, 0.12354942f, 0.19306841f, 
    -0.06203501f, -0.05164744f, -0.08348718f, 0.08290879f, 0.09238753f, 0.02583531f, -0.10160973f, -0.09442029f, 
    -0.04614368f, -0.07989179f, -0.02957880f, 0.07625301f, 0.06949294f, -0.03274683f, -0.00602502f, 0.00718261f, 
    0.01272234f, 0.46273342f, -0.19138624f, -0.11863685f, -0.02256987f, -0.06962194f, -0.07477560f, -0.01716105f, 
    0.12829474f, 0.11598220f, 0.14465256f, -0.02942959f, -0.06734990f, 0.15690175f, 0.03097294f, -0.09781981f, 
    -0.07897779f, 0.06535351f, 0.03276671f, 0.00798150f, 0.11152811f, -0.00559088f, 0.02677357f, 0.01939750f, 
    0.11306941f, 0.10051607f, 0.07495728f, -0.01747813f, -0.01642723f, 0.00173394f, -0.02773242f, -0.10669814f, 
    -0.09038086f, 0.03945542f, -0.04552423f, 0.06075490f, -0.08331308f, -0.15635592f, 0.18085331f, 0.05497393f, 
    0.01483045f, -0.05576925f, 0.03882423f, 0.18639563f, 0.09692287f, 0.20927809f, 0.11283097f, -0.07394471f, 
    -0.12071741f, 0.01714884f, -0.03923133f, -0.12480384f, 0.08130206f, 0.10277837f, -0.01319999f, 0.11197133f, 
    -0.11052690f, 0.07242368f, 0.07737686f, 0.22785385f, -0.09174847f, -0.12659968f, -0.14827830f, -0.21390186f, 
    -0.11444314f, -0.11331253f, 0.02506490f, 0.03433177f, -0.00517324f, -0.00447235f, -0.05489865f, -0.04321301f, 
    0.13840488f, 0.04291668f, -0.09926356f, -0.05190110f, -0.00115832f, 0.07108768f, 0.06941849f, -0.15895219f, 
    0.01040159f, -0.12369613f, -0.01023784f, 0.01629571f, 0.13917235f, -0.07509460f, -0.07425979f, 0.04427367f, 
    0.20650254f, -0.01501394f, -0.09565698f, -0.04494261f, 0.02284830f, 0.15942898f, 0.10477854f, -0.02790979f, 
    0.26018637f, 0.02561509f, 0.07189145f, 0.22044356f, -0.08762561f, 0.03144117f, 0.01756509f, 0.10440813f, 
    -0.05776813f, 0.01389999f, 0.02651665f, -0.02205315f, -0.02582489f, -0.12938052f, 0.01059182f, 0.04308300f, 
    -0.08815946f, 0.03948319f, 0.07389536f, -0.08083301f, 0.18391943f, 0.03638993f, 0.07453920f, 0.10185048f, 
    -0.23376413f, -0.12181468f, 0.00534777f, -0.03498217f, -0.03467808f, 0.07028209f, 0.10186713f, 0.10266465f, 
    -0.09859931f, 0.09389278f, 0.08078669f, 0.04238226f, 0.07919721f, -0.11873521f, -0.13287272f, -0.26414675f, 
    -0.21124028f, 0.11746620f, 0.07485645f, -0.11832306f, -0.03706633f, 0.02586415f, -0.11168133f, -0.06796625f, 
    0.00151894f, -0.02541907f, 0.05969501f, 0.04298390f, -0.01138407f, -0.00338700f, -0.03442319f, -0.05445823f, 
    -0.00755031f, 0.02236054f, 0.01749452f, -0.05699312f, -0.04587771f, 0.06695201f, -0.02036484f, 0.01681497f, 
    -0.05632978f, 0.03819294f, 0.02663992f, 0.01912658f, -0.07260376f, 0.03261555f, 0.05927533f, -0.02736268f, 
    0.01872022f, -0.03778239f, -0.07559498f, 0.03077714f, -0.06943196f, -0.04734714f, -0.05416492f, -0.03877592f, 
    -0.03498202f, -0.05511640f, 0.04424654f, -0.06366207f, 0.05592836f, 0.02425844f, -0.03470627f, 0.04140607f, 
    0.03673430f, -0.02297438f, -0.03949438f, 0.04228614f, 0.03511367f, 0.03229022f, 0.00154868f, -0.04480982f, 
    -0.07173081f, 0.05610731f, -0.05722741f, -0.05274054f, -0.01642338f, -0.04695295f, -0.00300884f, 0.05780694f, 
    -0.03365886f, -0.00545364f, -0.04213607f, 0.03508763f, -0.01148096f, 0.05529064f, -0.02196352f, -0.06669217f, 
    -0.07115592f, 0.02949560f, -0.04068387f, 0.02278340f, -0.02704903f, 0.05169813f, -0.01937801f, -0.07331778f, 
    -0.02240862f, 0.02532162f, 0.00837225f, -0.01667294f, -0.05469790f, -0.04965734f, -0.06116830f, 0.00544264f, 
    0.02240037f, -0.02392212f, 0.04657196f, -0.07432584f, -0.02030482f, 0.01101273f, -0.00016842f, 0.01194123f, 
    -0.00156028f, -0.03079350f, -0.06736415f, -0.02525122f, 0.02397707f, -0.07606684f, 0.04828033f, 0.04290020f, 
    0.05567698f, -0.02689255f, -0.06510838f, 0.02618680f, 0.03521580f, -0.00009979f, 0.01805239f, -0.00503401f, 
    -0.04127960f, -0.06357438f, 0.04850964f, -0.00244013f, -0.06873798f, 0.02029019f, -0.02088875f, 0.04564631f, 
    -0.03449592f, -0.07491992f, -0.02688253f, 0.03440308f, 0.04687067f, 0.00699017f, 0.04158257f, 0.07084092f, 
    0.02828622f, -0.00787030f, 0.00389195f, 0.02093830f, 0.01743235f, 0.06079730f, 0.05311549f, 0.05172946f, 
    -0.03594908f, 0.02794502f, 0.04738197f, -0.05165014f, 0.02465888f, 0.01292768f, -0.07045767f, 0.04184914f, 
    -0.07164834f, -0.06026590f, 0.01721529f, 0.01708113f, -0.04100954f, -0.07440872f, 0.00212718f, -0.07243142f, 
    0.04321430f, 0.01010353f, -0.07102787f, -0.01416861f, 0.00708734f, -0.04656511f, -0.02253312f, -0.03045119f, 
    -0.00718395f, -0.02560396f, -0.06417267f, 0.02422118f, 0.04958583f, 0.03037337f, -0.06108039f, -0.04985334f, 
    -0.06564242f, -0.04069628f, 0.02864658f, -0.01847067f, 0.06159564f, 0.05029459f, 0.04539147f, -0.05284817f, 
    -0.08207574f, -0.00745565f, -0.03072319f, -0.03541578f, -0.02211655f, -0.02881962f, 0.05749016f, 0.05765318f, 
    0.01820838f, -0.05642197f, 0.00399226f, -0.04540566f, 0.05641373f, -0.00264609f, -0.02071385f, -0.02583187f, 
    0.05839941f, 0.03675662f, 0.05103803f, -0.06688417f, -0.04460025f, 0.00502894f, -0.05444228f, 0.06769443f, 
    0.09290754f, -0.31202880f, 0.11671499f, -0.16114223f, 0.14539525f, 0.03974905f, 0.06190093f, -0.13923658f, 
    0.02274728f, 0.08050541f, 0.11823846f, 0.12959345f, 0.04902336f, -0.08937638f, -0.02354214f, 0.09806394f, 
    0.16683312f, -0.08603013f, -0.04595988f, -0.00676149f, -0.12934299f, -0.08013297f, -0.04176094f, 0.08026436f, 
    -0.22096154f, 0.13094944f, 0.03258765f, -0.29799852f, 0.01507367f, -0.14065883f, 0.08289560f, 0.09020761f, 
    0.18625961f, 0.15613016f, -0.07338521f, 0.03777224f, -0.13915808f, -0.29325369f, 0.05600074f, 0.06841966f, 
    -0.07021032f, -0.15635617f, -0.03291165f, 0.18829583f, 0.02233214f, 0.08521714f, 0.05612940f, -0.01104106f, 
    0.22565734f, -0.35906354f, 0.15945780f, 0.14833407f, -0.02802224f, -0.02738393f, -0.07395442f, 0.12199484f, 
    0.21855664f, 0.04792513f, 0.13083762f, 0.08818363f, 0.20928429f, 0.00495359f, -0.02324124f, 0.13032559f, 
    0.11824155f, -0.04156977f, 0.01932752f, 0.08681905f, -0.06491111f, -0.02376362f, 0.06068217f, -0.09378975f, 
    0.14671685f, -0.02647034f, 0.05072878f, -0.01732508f, 0.08007278f, 0.10748199f, 0.01907823f, -0.05447713f, 
    0.06786078f, -0.08560593f, -0.05170958f, -0.07254144f, -0.01982937f, 0.27625433f, -0.06036102f, 0.06000866f, 
    0.17401215f, -0.00864629f, -0.05131042f, 0.15877268f, 0.07050579f, 0.03922150f, 0.05286495f, -0.07990462f, 
    0.01038785f, -0.02408139f, -0.01851425f, -0.08856482f, -0.03947166f, 0.05939608f, -0.04695461f, 0.06654149f, 
    0.12459253f, -0.07318408f, -0.04281088f, -0.01292451f, -0.14935265f, 0.05010459f, 0.10233662f, -0.07268798f, 
    0.05933042f, 0.01930750f, 0.09655208f, -0.04868702f, 0.05839100f, -0.03326153f, -0.02113395f, -0.01013233f, 
    0.00053609f, -0.24272963f, -0.13528179f, 0.16304664f, 0.05834377f, 0.03613693f, 0.07142378f, 0.12346143f, 
    0.03171180f, 0.09705083f, -0.12941639f, 0.13839059f, -0.35396278f, 0.01548897f, -0.00479393f, -0.16720800f, 
    -0.14867257f, 0.14516369f, 0.10800882f, 0.18365663f, 0.01794233f, 0.02093729f, 0.13185793f, 0.04022175f, 
    0.01351317f, 0.15088563f, 0.33951071f, -0.18125100f, -0.07715761f, 0.00277502f, 0.10118546f, 0.10887487f, 
    0.10260521f, -0.00186926f, 0.10247575f, 0.02580861f, 0.26378998f, -0.05982681f, 0.07733648f, 0.03643423f, 
    0.04707159f, -0.11986378f, 0.06867165f, 0.12021450f, -0.00172703f, 0.07952473f, 0.02055408f, -0.03146164f, 
    -0.03012493f, 0.08556414f, -0.14788456f, -0.15949072f, 0.03270844f, -0.26051134f, 0.10750753f, 0.08265550f, 
    0.07072457f, 0.03587867f, -0.01169951f, 0.01620249f, -0.02292488f, -0.08498827f, 0.04069629f, 0.11289798f, 
    0.04317864f, 0.22442895f, 0.21887040f, 0.05718172f, 0.09369393f, -0.05037604f, -0.09802420f, 0.04664553f, 
    -0.05027463f, 0.00949813f, -0.05590072f, 0.03995764f, -0.04298971f, 0.00039290f, -0.00313845f, -0.01594453f, 
    -0.04603850f, -0.03657950f, -0.02113272f, 0.00017853f, -0.04749375f, -0.05452918f, 0.00535373f, -0.02316692f, 
    -0.05344051f, -0.08815367f, -0.04900772f, 0.00820028f, -0.00331688f, -0.06820485f, -0.02457798f, -0.05290685f, 
    0.02929763f, -0.00561389f, 0.01456632f, -0.00289984f, -0.02358271f, -0.03641429f, 0.03960659f, 0.00735543f, 
    0.01885205f, -0.04729265f, 0.00763734f, -0.08940789f, -0.08122798f, 0.00347524f, -0.03117217f, -0.04731337f, 
    -0.07046334f, -0.00303138f, -0.05969909f, -0.00367300f, -0.01811985f, -0.05640823f, 0.05144151f, 0.05332696f, 
    -0.07474957f, 0.01681729f, -0.00945370f, 0.00260766f, -0.03224278f, -0.08091341f, 0.00673563f, -0.07375507f, 
    -0.00333546f, 0.00618982f, 0.01506147f, -0.01871729f, -0.03552787f, -0.00260395f, -0.00279671f, 0.03260115f, 
    0.02529054f, -0.09002112f, -0.03053325f, -0.00012622f, -0.01616373f, -0.05098345f, -0.05872808f, -0.05568504f, 
    -0.02793577f, -0.08809683f, -0.06758238f, -0.05167299f, -0.07047272f, 0.04846524f, -0.06322198f, -0.08567756f, 
    0.00648429f, -0.04340881f, -0.00276591f, -0.08897865f, -0.03145463f, -0.03052312f, -0.08897156f, -0.00654730f, 
    -0.05894524f, -0.05703083f, -0.02384464f, -0.00420488f, -0.06579832f, -0.05370092f, -0.06892972f, -0.09375651f, 
    0.01297618f, 0.04666361f, -0.05146315f, 0.04810869f, -0.00038209f, 0.02638732f, 0.00215584f, 0.03416380f, 
    0.04572476f, 0.02011100f, 0.00816138f, -0.04198310f, -0.07702406f, -0.04251931f, -0.05317755f, -0.01061535f, 
    -0.03016273f, 0.02167032f, -0.05009915f, 0.05673806f, 0.03057578f, 0.00383206f, -0.06178540f, 0.00581404f, 
    -0.06957253f, -0.01635963f, -0.01443265f, 0.02107247f, -0.05069577f, -0.06099541f, 0.00098101f, 0.04502619f, 
    -0.00590522f, 0.04041733f, -0.01068486f, -0.00139587f, -0.05350545f, 0.02519662f, -0.00807296f, 0.03612991f, 
    -0.04515908f, -0.02479203f, -0.02693530f, -0.04359547f, 0.00216460f, 0.03090346f, 0.01098920f, 0.02164476f, 
    -0.04726816f, -0.06705555f, 0.02852498f, -0.03940480f, -0.02491678f, -0.06858800f, 0.00019394f, 0.01726941f, 
    -0.01385360f, 0.01982009f, 0.05183876f, -0.04501241f, -0.00155531f, -0.05581667f, 0.03147909f, 0.02668679f, 
    -0.01053401f, -0.09072061f, -0.08186096f, -0.02506700f, -0.04385942f, -0.03317746f, -0.05967610f, -0.05234299f, 
    -0.08259751f, 0.00924670f, -0.04198352f, -0.00237896f, 0.03720472f, 0.02566765f, -0.00000681f, -0.05783311f, 
    -0.09169549f, 0.03834828f, -0.00045554f, 0.01084863f, 0.02679488f, -0.07750666f, -0.08077897f, -0.03787335f, 
    -0.04120649f, -0.03555379f, -0.06282482f, -0.05561153f, 0.01237623f, -0.03022872f, 0.02612256f, -0.08062629f, 
    -0.13763544f, -0.22611760f, 0.25853568f, 0.21036261f, 0.13381992f, 0.02662785f, -0.10356092f, 0.05986185f, 
    0.13011472f, 0.14303190f, 0.06017342f, 0.09659040f, 0.04713463f, -0.14252435f, -0.17174824f, -0.23281883f, 
    -0.05429342f, -0.06260405f, 0.15224725f, 0.15427484f, -0.01273861f, 0.11406933f, -0.15948215f, -0.00430321f, 
    -0.16098274f, 0.07663799f, 0.21441288f, 0.19216840f, 0.01153183f, -0.08415792f, 0.09556659f, 0.07710033f, 
    0.00348086f, -0.06245717f, 0.09982647f, 0.00545397f, -0.09858780f, -0.16208918f, 0.04993885f, 0.14417346f, 
    0.01556400f, -0.04072345f, 0.02250997f, 0.08701523f, -0.11487329f, 0.08952164f, -0.01186010f, -0.00324964f, 
    0.13224258f, 0.01893999f, -0.14160077f, -0.05529135f, -0.04382376f, 0.03436266f, -0.03434215f, -0.09476583f, 
    0.03967442f, 0.01311228f, 0.04783242f, -0.04062414f, 0.11210539f, 0.31898811f, -0.24599443f, -0.02997379f, 
    -0.09005633f, -0.11576105f, -0.08332489f, -0.24041197f, -0.01919620f, 0.18057379f, 0.05513934f, 0.05726577f, 
    0.14147431f, 0.08917168f, 0.24302416f, -0.19009538f, 0.02619877f, -0.07103180f, 0.03637329f, -0.12597366f, 
    0.11783466f, 0.03853730f, -0.13396657f, -0.09514908f, 0.26444718f, 0.15919957f, -0.00310838f, -0.02085306f, 
    -0.04090197f, 0.12982117f, 0.02438244f, 0.06090176f, -0.01524636f, 0.05745135f, 0.09170657f, -0.16638009f, 
    -0.06136167f, -0.00820467f, -0.06522394f, -0.29217046f, 0.11531442f, 0.01200131f, -0.04020683f, -0.17820998f, 
    -0.11054995f, -0.17037746f, -0.10116361f, -0.48518956f, -0.21147375f, -0.16174012f, 0.16200168f, 0.24199045f, 
    -0.07514530f, -0.01226074f, 0.06947191f, 0.11842179f, 0.07973588f, -0.14548039f, 0.02419907f, 0.00722230f, 
    -0.10489732f, -0.09325718f, -0.18171768f, 0.31146085f, 0.06751244f, 0.08406281f, 0.05706098f, -0.12229006f, 
    -0.01011809f, 0.09859028f, -0.09130899f, -0.07350008f, -0.01118481f, -0.19655682f, -0.11477384f, 0.08525027f, 
    -0.05626332f, 0.05751982f, -0.05620903f, 0.03138305f, 0.00937853f, 0.04762641f, 0.13606226f, 0.24264860f, 
    -0.26238200f, 0.19113478f, 0.17546046f, 0.26164258f, -0.05894047f, -0.07682241f, 0.08231866f, 0.01144248f, 
    0.08710956f, -0.00219762f, 0.12356997f, 0.16944973f, -0.19016871f, 0.21738888f, -0.18366836f, -0.11107370f, 
    -0.08427259f, -0.01702578f, -0.04660754f, 0.04530348f, 0.12326449f, 0.15461318f, -0.10840134f, -0.13511837f, 
    -0.02369886f, 0.35234269f, 0.05971305f, 0.10889457f, 0.11927897f, -0.00814150f, -0.11516564f, -0.02528446f, 
    -0.21262081f, -0.09453839f, -0.09607068f, -0.28987312f, 0.18850148f, 0.29542691f, 0.04358720f, 0.17836653f, 
    0.09841889f, -0.00667472f, -0.02737336f, -0.15912898f, -0.06859087f, -0.33741093f, -0.07750684f, 0.03755920f, 
    0.09659535f, -0.17857417f, 0.32302940f, 0.08510247f, 0.12467312f, 0.04857752f, 0.03907820f, -0.16371888f, 
    0.03251386f, 0.00586334f, 0.04197418f, 0.19242658f, 0.09890784f, -0.11416767f, -0.02878325f, 0.10495208f, 
    0.07573455f, -0.12591346f, 0.09680055f, 0.17283659f, -0.08311921f, 0.14810342f, -0.04261006f, 0.13673319f, 
    -0.09498343f, 0.17198260f, 0.09818359f, -0.01182879f, -0.19626202f, -0.15100352f, -0.03544958f, -0.08812499f, 
    0.01478379f, 0.15019119f, 0.02865877f, 0.04956352f, -0.30520999f, -0.01697983f, -0.12852548f, 0.32754484f, 
    -0.03042465f, -0.10313091f, -0.01438059f, 0.04011355f, -0.18661284f, 0.08124861f, 0.03449395f, 0.04445403f, 
    0.15846734f, -0.06960902f, 0.03265212f, -0.00660949f, -0.05586755f, 0.05400994f, 0.05913977f, 0.07861055f, 
    0.12665063f, 0.04496589f, 0.07525674f, 0.21824063f, 0.29705521f, 0.32835993f, -0.00136198f, 0.06316631f, 
    -0.05977605f, -0.04119116f, 0.02758196f, -0.03421066f, -0.07980548f, 0.17782675f, 0.14042580f, 0.06955706f, 
    -0.14141497f, 0.01248252f, -0.02726789f, -0.14705019f, -0.09018704f, -0.07395632f, 0.00246822f, 0.04530789f, 
    -0.00111744f, -0.03327762f, -0.04468681f, -0.07049708f, 0.36690220f, 0.28647128f, 0.06170674f, -0.00309043f, 
    -0.03460176f, -0.01353324f, 0.04696791f, 0.05478075f, -0.00897816f, -0.01225496f, 0.01947043f, 0.10060614f, 
    -0.04771576f, -0.09157823f, 0.02370638f, 0.01554186f, 0.01065291f, -0.11794808f, -0.08860826f, 0.03670380f, 
    0.02244196f, -0.12907827f, 0.08740378f, -0.18657118f, -0.28509805f, -0.01314419f, 0.08520932f, 0.29432893f, 
    -0.06981608f, 0.02841458f, -0.03435896f, -0.00044739f, 0.08658416f, 0.02145370f, 0.00564818f, 0.01885639f, 
    0.01335676f, -0.21033467f, 0.17778291f, 0.32044357f, 0.05123774f, 0.09142370f, 0.13783927f, 0.08486671f, 
    -0.00456925f, -0.00455152f, 0.01904190f, 0.21262996f, -0.28078556f, -0.09235354f, -0.11141661f, -0.05232940f, 
    -0.13934791f, 0.10541961f, 0.17798670f, 0.15664276f, -0.03264209f, -0.03959659f, 0.09984098f, 0.06817602f, 
    -0.32223669f, 0.33222076f, 0.25790501f, 0.00307949f, 0.05574642f, -0.03431371f, 0.00782701f, 0.20367183f, 
    0.10407964f, -0.04846373f, 0.09792172f, -0.13486533f, 0.12047057f, 0.05924550f, -0.04988792f, -0.20628598f, 
    -0.02495980f, 0.09952429f, -0.07530861f, 0.10176632f, -0.08980955f, 0.03490436f, -0.11841989f, 0.03386187f, 
    0.11813351f, 0.16737649f, 0.10313295f, -0.00900739f, -0.00897919f, -0.04430847f, 0.02683771f, 0.03466205f, 
    -0.01609840f, -0.01796674f, -0.06115696f, -0.10845375f, -0.14564061f, -0.07551303f, 0.06088309f, 0.07789296f, 
    0.06168429f, 0.06578116f, 0.09918761f, -0.17356868f, 0.11660079f, -0.12555379f, -0.13538910f, 0.09188683f, 
    0.45081249f, 0.15455760f, 0.23864345f, -0.08523824f, -0.17373712f, 0.01656272f, 0.04649336f, -0.04306484f, 
    -0.08862736f, -0.02961841f, 0.11781580f, 0.12841310f, -0.03950492f, -0.00092973f, 0.02393940f, 0.02071279f, 
    -0.08111965f, -0.13105078f, 0.03903520f, 0.08420675f, 0.00252648f, 0.06413856f, -0.12394880f, 0.06400580f, 
    0.16280709f, 0.14206135f, -0.32933736f, 0.16964023f, 0.02675486f, 0.11232552f, -0.13094345f, -0.08497041f, 
    0.06237442f, 0.02518440f, -0.12839830f, 0.13621810f, 0.21334551f, 0.17109820f, -0.32774025f, -0.07116715f, 
    -0.08757833f, 0.02112687f, -0.03069932f, -0.11944461f, -0.09097107f, 0.05521069f, 0.08908901f, 0.04870350f, 
    0.08395990f, 0.17201422f, 0.07793360f, -0.19645709f, 0.05014939f, -0.03793538f, 0.01071633f, -0.03951215f, 
    0.12852481f, 0.03329682f, -0.08604040f, 0.20151536f, 0.15669395f, -0.18930878f, 0.21817209f, -0.06532502f, 
    0.08957152f, -0.05189004f, -0.05455393f, -0.04769644f, 0.04617441f, -0.11080411f, 0.07511139f, 0.05791096f, 
    -0.12383898f, 0.01973090f, -0.17802025f, 0.08861309f, 0.05128369f, 0.02183171f, -0.00576228f, 0.01748245f, 
    0.03954218f, 0.01363986f, 0.05414630f, -0.05829024f, 0.09079279f, -0.19657902f, 0.04389801f, -0.09869797f, 
    -0.23821926f, 0.02660469f, -0.07855235f, 0.35280019f, -0.06726031f, 0.03333139f, 0.33095938f, 0.08295358f, 
    0.12015390f, -0.05339860f, 0.10407902f, 0.05575352f, -0.12730418f, -0.07146520f, -0.05654723f, -0.08736325f, 
    0.06138289f, -0.00788273f, -0.07217193f, -0.08253505f, 0.43598023f, 0.22862619f, -0.10087479f, 0.19154377f, 
    0.13165183f, -0.02079714f, 0.04851791f, 0.09694725f, 0.05551090f, 0.08239147f, 0.00843662f, 0.00259594f, 
    0.12487818f, 0.14170317f, 0.47072786f, -0.07618133f, -0.01387374f, -0.12620524f, 0.38398504f, -0.03239565f, 
    -0.05071528f, 0.02584773f, -0.00997263f, 0.08967225f, -0.01582509f, 0.01442203f, 0.02632140f, -0.09273679f, 
    -0.04298493f, 0.28122142f, 0.27772722f, 0.12315041f, -0.14128226f, -0.01781265f, -0.16629580f, 0.03324416f, 
    -0.11408436f, 0.21326867f, -0.36392471f, 0.11828975f, 0.10217547f, 0.03812746f, -0.04159555f, 0.10492830f, 
    -0.01421505f, -0.04894046f, -0.02370650f, -0.11669106f, -0.05405610f, 0.07973075f, 0.17298746f, -0.07885179f, 
    -0.09820092f, 0.22556089f, -0.13820031f, -0.03300340f, -0.20746122f, -0.03533709f, -0.00886864f, 0.03135537f, 
    0.23481973f, -0.07360301f, 0.12887356f, 0.11677933f, -0.08351222f, -0.12172789f, 0.00086580f, -0.23171908f, 
    -0.04049643f, -0.00783050f, 0.16609292f, 0.00532771f, -0.16954431f, -0.33937082f, 0.33714843f, 0.29255426f, 
    0.11712607f, 0.00968208f, -0.03135754f, -0.08607449f, 0.07704662f, 0.08762271f, -0.09580032f, 0.08807834f, 
    0.02222691f, -0.14203466f, 0.17983189f, 0.11314794f, 0.22274758f, -0.00893749f, 0.09247985f, -0.16997924f, 
    0.09588877f, 0.02138347f, 0.07765357f, 0.12460928f, 0.09393657f, 0.18945611f, -0.05120113f, 0.15302917f, 
    0.06181439f, -0.13164690f, -0.07365943f, 0.01665757f, 0.03940056f, 0.15330003f, 0.14263690f, 0.09877864f, 
    -0.06952547f, -0.02167756f, -0.00990847f, -0.10844640f, -0.00891622f, -0.01850269f, -0.04347854f, 0.04563818f, 
    0.07330178f, 0.02743550f, -0.03428698f, 0.02437263f, -0.17543100f, -0.06962954f, -0.24961513f, 0.20349182f, 
    -0.12196045f, -0.05270663f, 0.02460744f, -0.01552938f, 0.06012109f, 0.00352936f, 0.01985515f, 0.04726584f, 
    -0.24680217f, -0.08857550f, -0.07439696f, 0.30153140f, -0.06291194f, -0.19177176f, -0.07304121f, -0.04405209f, 
    0.31678745f, 0.15296245f, 0.13795836f, 0.23355843f, 0.14055589f, 0.02861036f, 0.13055791f, 0.20081405f, 
    0.07035755f, -0.03970319f, -0.08008780f, -0.01471712f, 0.05577907f, 0.07888272f, 0.17444901f, 0.06284120f, 
    0.09949414f, 0.10528535f, -0.14194222f, 0.13956486f, -0.03994901f, 0.10234115f, 0.06086740f, -0.02350215f, 
    -0.06396400f, -0.03609495f, -0.09773481f, -0.02793510f, -0.00048710f, 0.25561261f, 0.19991010f, 0.11389650f, 
    0.09446881f, 0.14313911f, -0.09615962f, 0.19366258f, 0.28829700f, -0.01536382f, 0.04217945f, 0.07540947f, 
    -0.10744748f, 0.00650385f, 0.01162261f, 0.02822530f, 0.06301078f, 0.01294384f, -0.01798452f, -0.03065634f, 
    0.14872637f, 0.08389994f, 0.11315117f, 0.14033091f, -0.00606293f, 0.00703874f, 0.00974263f, 0.02062464f, 
    -0.04039219f, 0.05095648f, -0.06539974f, 0.03860404f, 0.03843572f, -0.02333585f, 0.06094497f, 0.13022417f, 
    -0.20071672f, 0.01669219f, 0.16768286f, 0.32259130f, -0.08656376f, -0.01744691f, 0.24015856f, 0.12294587f, 
    -0.04338113f, -0.04076778f, -0.07792626f, 0.09099445f, -0.30985853f, 0.02404754f, -0.04028277f, -0.09358297f, 
    -0.00734646f, 0.02835265f, 0.06465105f, 0.06415217f, 0.19654267f, -0.04555960f, -0.01520895f, -0.16010058f, 
    -0.03669674f, 0.17611994f, 0.13346736f, -0.05728310f, -0.12191201f, 0.00778469f, -0.12886472f, 0.18005142f, 
    0.05996858f, -0.04058376f, 0.13501215f, -0.09295425f, 0.10385531f, -0.30284876f, 0.26255986f, -0.17895481f, 
    -0.04181158f, 0.24740651f, -0.07250299f, 0.03296309f, -0.00022858f, 0.00591588f, -0.02990554f, 0.06330055f, 
    -0.13195227f, -0.16796447f, 0.07412720f, -0.18766117f, 0.06491628f, 0.04378534f, 0.06764572f, 0.01982575f, 
    0.02535496f, -0.07041614f, 0.01488557f, -0.05436016f, 0.05303541f, 0.00835849f, 0.11310452f, -0.21052733f, 
    0.09526919f, 0.11354802f, 0.13416916f, -0.06477432f, -0.02590123f, 0.07713547f, -0.22104198f, -0.05354802f, 
    -0.32916048f, 0.05902832f, 0.01251395f, 0.10556561f, 0.06704573f, -0.01680004f, 0.11368106f, 0.18376198f, 
    0.07998562f, -0.07597786f, 0.02131006f, 0.00551642f, -0.10124661f, 0.02300378f, -0.00552702f, -0.00224175f, 
    -0.05090611f, 0.03625000f, -0.02750963f, 0.04089710f, 0.22775429f, -0.04571224f, 0.28950959f, -0.08974465f, 
    0.07195547f, 0.12192882f, 0.08627000f, -0.04728233f, 0.11995845f, -0.02752552f, 0.10187100f, 0.05257208f, 
    0.19530112f, 0.03066450f, 0.26291931f, 0.03152585f, -0.01587243f, 0.05610325f, 0.05995671f, -0.14132164f, 
    0.09181523f, 0.11488648f, -0.05579377f, 0.15698463f, 0.11640298f, 0.00389563f, 0.07967085f, 0.00665001f, 
    -0.21153267f, 0.06553497f, -0.19583708f, -0.23587748f, 0.02713111f, 0.01427390f, -0.10775854f, -0.04315386f, 
    0.05062315f, 0.06490238f, 0.02587241f, 0.07858001f, -0.01163154f, 0.32296643f, -0.08115292f, -0.01583282f, 
    -0.11438069f, -0.05575307f, -0.02138279f, 0.01768459f, 0.03924173f, -0.03115935f, 0.11476624f, 0.10397946f, 
    0.12266017f, 0.02962149f, 0.05889223f, -0.14455146f, 0.02948808f, -0.19148572f, 0.01792950f, -0.14745638f, 
    -0.01716696f, 0.09313562f, -0.10314460f, 0.06225868f, 0.08441959f, 0.10903233f, 0.01777400f, 0.16911757f, 
    0.06772991f, -0.01215919f, 0.02406704f, -0.03356993f, 0.07783475f, 0.06344091f, -0.11049399f, 0.13128239f, 
    -0.04295953f, -0.10402478f, -0.00632483f, -0.15167387f, 0.10714221f, 0.02396525f, -0.04562561f, -0.05421039f, 
    -0.04360948f, 0.06108129f, -0.00602133f, 0.17058548f, -0.22466396f, -0.10231725f, -0.10045259f, 0.16907179f, 
    0.01898463f, 0.05146015f, 0.04846216f, -0.08561252f, -0.02445638f, -0.13741557f, -0.00242159f, -0.08130439f, 
    -0.02326670f, -0.13421799f, -0.22545315f, -0.08101717f, -0.03361490f, 0.12569828f, -0.00210986f, 0.12608302f, 
    -0.00438790f, -0.03108310f, 0.01875311f, -0.00239782f, 0.08841976f, -0.08725716f, 0.01386782f, -0.01888777f, 
    0.10514598f, -0.10101149f, -0.04020872f, -0.04402395f, 0.02459293f, -0.05312171f, -0.00661509f, -0.03340838f, 
    -0.00083941f, -0.11250353f, 0.07356053f, -0.02731821f, 0.03594250f, 0.10912040f, 0.15913700f, 0.04970532f, 
    0.00319568f, 0.07281992f, 0.03913781f, 0.00426831f, -0.18250650f, 0.16514902f, -0.16029693f, 0.09600798f, 
    0.03682301f, 0.06478833f, -0.02328805f, 0.02733529f, 0.11195026f, 0.05460564f, -0.09159019f, 0.05963008f, 
    0.03201727f, 0.23971935f, -0.10210293f, 0.13983753f, 0.00578853f, -0.07453416f, -0.07420512f, 0.04952474f, 
    0.02357443f, 0.09874915f, 0.12593161f, 0.14035147f, 0.11436378f, -0.17808275f, -0.16525491f, -0.01742870f, 
    -0.17773525f, 0.10127416f, -0.18838117f, 0.05001276f, -0.03159272f, -0.04610526f, 0.08003821f, -0.03271267f, 
    -0.30609444f, -0.62739348f, 0.06558228f, -0.15851723f, 0.03908353f, 0.18948804f, 0.00893123f, 0.12567629f, 
    0.01603174f, 0.17664434f, 0.15376768f, -0.10635022f, 0.09897583f, 0.07606994f, -0.03781699f, 0.01344709f, 
    -0.02367751f, 0.02710717f, -0.01664145f, 0.07653806f, 0.28890502f, 0.09981462f, 0.04887637f, 0.07879965f, 
    0.05718401f, -0.24603038f, 0.00592247f, -0.08866332f, 0.06012874f, -0.07437333f, 0.09689615f, 0.08180713f, 
    -0.11018579f, -0.05396798f, 0.10883570f, 0.09587581f, -0.03182925f, -0.04830126f, -0.36697179f, 0.01987431f, 
    -0.00791836f, -0.00951084f, 0.01698396f, 0.05006704f, -0.09445592f, -0.01846974f, -0.05983306f, 0.10554310f, 
    0.35971004f, 0.00709135f, -0.14838348f, -0.21525407f, -0.02926436f, -0.08773542f, -0.10799045f, -0.02787374f, 
    0.13197666f, 0.04406583f, -0.04872229f, 0.11563314f, 0.38743466f, 0.31819123f, 0.08846973f, -0.04228431f, 
    -0.06259584f, 0.01394880f, -0.07293444f, -0.00898585f, 0.09903340f, 0.05447214f, -0.03661729f, 0.16490906f, 
    0.20426379f, 0.33312953f, 0.13263479f, 0.14381053f, 0.02690732f, 0.01649516f, 0.04179060f, -0.06949408f, 
    0.02848175f, 0.01316005f, 0.05694040f, 0.08869741f, -0.10441580f, 0.02193411f, -0.19921717f, 0.18229635f, 
    -0.10109391f, -0.08278772f, -0.04435452f, 0.07451887f, 0.17327839f, 0.09217603f, 0.29232895f, -0.08928263f, 
    0.11769380f, 0.05585869f, 0.09276109f, 0.04144107f, 0.19258860f, 0.08843106f, -0.10096346f, -0.02303891f, 
    -0.04787110f, 0.05214454f, -0.09713287f, 0.07066710f, 0.09304253f, -0.33829278f, -0.06731797f, -0.02152545f, 
    -0.26272094f, -0.08572920f, -0.09415413f, 0.21461277f, -0.07784618f, -0.00731518f, -0.07884926f, -0.14169773f, 
    -0.04570974f, -0.09629488f, -0.22691597f, 0.05391588f, -0.01417670f, 0.03273994f, 0.18726020f, -0.05155746f, 
    -0.03064349f, 0.05670719f, -0.11635573f, -0.03823707f, -0.30664212f, -0.57014936f, -0.31060013f, -0.30152234f, 
    0.09608094f, 0.12769388f, 0.01362153f, 0.16492622f, -0.13860339f, -0.00222974f, -0.10177297f, 0.04781657f, 
    0.03144282f, -0.11449973f, 0.13104507f, -0.23775263f, -0.10435023f, -0.00356787f, 0.08414471f, 0.08657801f, 
    0.07441559f, -0.00813252f, 0.07987627f, 0.05718902f, 0.18143487f, 0.00670402f, 0.09490538f, 0.16085079f, 
    0.12716055f, 0.26423854f, -0.05857627f, -0.07748592f, 0.16140600f, 0.00880046f, -0.09940727f, -0.08482046f, 
    0.05132799f, 0.10179126f, 0.18244720f, 0.24001525f, 0.03877017f, -0.08750696f, 0.02602089f, -0.24065423f, 
    -0.11379014f, -0.06963266f, 0.11988438f, -0.19235827f, 0.25542605f, 0.11761677f, 0.23241177f, 0.13958092f, 
    -0.12921862f, 0.22753954f, 0.17786571f, -0.06939597f, -0.10439157f, -0.03062632f, -0.02705662f, -0.03728492f, 
    -0.04105779f, 0.12066466f, 0.02929019f, 0.13185951f, -0.09305506f, 0.17713909f, 0.07107009f, 0.09218230f, 
    0.02527897f, 0.03782998f, 0.12053071f, -0.05427122f, 0.01293052f, -0.00676262f, 0.05897711f, -0.10416593f, 
    -0.34775218f, -0.27518582f, -0.02874489f, -0.36440426f, 0.05556215f, -0.13174690f, 0.02740097f, -0.17522185f, 
    0.04672924f, -0.08779068f, -0.21765895f, 0.12016831f, 0.10781223f, 0.08108479f, -0.04835944f, 0.08757015f, 
    0.04143862f, -0.00570766f, -0.11743458f, 0.13646325f, 0.23001023f, 0.03809780f, 0.02504152f, -0.20036009f, 
    0.09819461f, 0.04872892f, -0.12199586f, 0.08384036f, -0.05991107f, -0.19374870f, 0.07898553f, -0.00629196f, 
    0.16283274f, 0.29551360f, -0.12167769f, 0.18919675f, 0.12202527f, -0.06993834f, -0.19097713f, -0.15693229f, 
    0.01397086f, 0.03539322f, 0.05138011f, 0.00160256f, -0.09881209f, 0.06886950f, -0.00516750f, -0.06337707f, 
    -0.09261501f, -0.07007139f, -0.06557538f, -0.10269659f, -0.15905206f, -0.09263168f, -0.02575831f, 0.17437889f, 
    0.13118145f, 0.16094278f, 0.09500144f, -0.10785727f, 0.14896290f, 0.09646297f, 0.01941208f, 0.05883424f, 
    -0.09618892f, 0.00033966f, 0.01018753f, -0.23045960f, -0.15577902f, -0.05897538f, -0.21488723f, -0.16556014f, 
    0.00873350f, -0.08735239f, -0.14592345f, -0.01014712f, -0.15226313f, -0.06544822f, 0.11970376f, 0.02291180f, 
    -0.11204930f, 0.00997114f, 0.04391130f, -0.23195693f, 0.00992462f, -0.00421161f, -0.05275505f, -0.17649686f, 
    -0.28075078f, -0.29965886f, -0.40979394f, -0.11610550f, 0.20601527f, -0.12025889f, -0.08404906f, -0.10993788f, 
    0.07455774f, -0.00333352f, 0.06329523f, 0.27969906f, -0.04326023f, 0.04713598f, -0.00626359f, -0.17400457f, 
    -0.11519294f, 0.22260879f, -0.15687248f, 0.08350296f, -0.00806919f, -0.07742843f, -0.00804257f, -0.05498113f, 
    -0.02918404f, 0.02213852f, -0.08260069f, -0.05673243f, 0.37590164f, -0.15509927f, 0.01269684f, 0.21460077f, 
    0.16584940f, 0.12526207f, 0.03711971f, -0.05084826f, 0.14806850f, 0.09884645f, 0.20273998f, 0.12386025f, 
    -0.22004880f, -0.12698540f, -0.17318773f, 0.02930204f, 0.03725381f, 0.08148444f, -0.12071571f, -0.19234014f, 
    0.00439693f, 0.14229885f, 0.17905392f, 0.13459517f, -0.23106359f, 0.24721979f, -0.13176504f, -0.04235306f, 
    0.18929590f, 0.27185363f, 0.02446465f, 0.09951419f, -0.00057531f, 0.08128513f, 0.05927800f, 0.08560880f, 
    -0.20034103f, 0.25679573f, 0.02831723f, 0.23573841f, 0.02997712f, 0.17653164f, -0.00700573f, 0.01659864f, 
    -0.23834135f, -0.06127106f, 0.10597028f, -0.15099187f, 0.33410376f, 0.26230520f, -0.01233583f, 0.12322006f, 
    -0.04658815f, 0.18927677f, 0.11446051f, 0.14991206f, -0.17350198f, -0.08193969f, -0.09543394f, 0.04585077f, 
    0.16706069f, 0.38353536f, 0.04977242f, -0.03808042f, -0.01792612f, 0.22011855f, 0.08142078f, 0.11718772f, 
    0.13766789f, 0.05419378f, 0.17184538f, -0.05229472f, -0.23480417f, -0.18345940f, 0.23759985f, -0.18536179f, 
    -0.08926931f, 0.05356359f, 0.00527336f, -0.28217950f, 0.10051315f, 0.02952385f, 0.04889648f, -0.09045321f, 
    0.29379055f, -0.04686318f, -0.39393687f, -0.04909188f, 0.16389757f, 0.08776242f, -0.13475379f, -0.06402783f, 
    0.06327874f, -0.09997980f, -0.18545154f, -0.03437749f, 0.17375836f, 0.15996219f, -0.02061979f, -0.17983672f, 
    -0.08881719f, 0.05667658f, 0.03336282f, -0.11593597f, 0.04873421f, -0.03684769f, 0.00697086f, 0.08387788f, 
    -0.04741118f, 0.40258265f, -0.04124352f, 0.16310047f, 0.03772301f, 0.09801955f, 0.05833608f, 0.02273190f, 
    0.01153822f, 0.06391824f, -0.02411490f, 0.10556807f, -0.16889994f, -0.45046571f, 0.16536589f, 0.01685224f, 
    -0.00512462f, 0.04820210f, -0.00006956f, -0.04195691f, -0.12224486f, -0.13920915f, 0.02424601f, -0.01962830f, 
    -0.45543015f, -0.57900983f, -0.54522347f, -0.05938524f, 0.14086546f, 0.10778213f, 0.05567215f, -0.04368680f, 
    -0.15101033f, -0.23616138f, 0.02208055f, -0.20877093f, -0.20942849f, 0.03854084f, -0.05530253f, 0.06574237f, 
    0.06316293f, -0.00919666f, -0.05640513f, 0.14709274f, 0.00408866f, 0.06570231f, 0.12245446f, 0.03975978f, 
    -0.10790680f, -0.18842544f, 0.06280128f, -0.03108525f, -0.24776500f, -0.06361853f, -0.02038017f, -0.12283594f, 
    0.08794864f, 0.11587794f, -0.10495349f, -0.05766021f, 0.34015250f, 0.27707532f, 0.08053516f, -0.07854817f, 
    0.12958360f, 0.01894376f, 0.09189646f, 0.09958878f, -0.00918278f, 0.01894368f, 0.02888625f, -0.04780626f, 
    -0.06594044f, 0.24419636f, 0.27216694f, -0.20760460f, -0.00317181f, 0.02639342f, -0.00819983f, 0.10120866f, 
    0.01614784f, 0.06096759f, 0.00963255f, -0.00962630f, 0.24897593f, 0.08396063f, 0.14299992f, 0.17753617f, 
    0.17069200f, 0.19172823f, 0.11276917f, 0.01062185f, 0.03185380f, -0.04233880f, 0.03029317f, 0.01388283f, 
    0.17300649f, -0.21590528f, -0.11225865f, -0.13483141f, 0.14060947f, 0.04770990f, -0.09229916f, 0.19463339f, 
    0.01350674f, 0.08667552f, 0.02005913f, 0.03783586f, -0.36020121f, -0.06217474f, 0.37302756f, -0.22724870f, 
    0.13889934f, 0.00586247f, -0.10923125f, 0.04250364f, -0.08691170f, 0.02268994f, 0.08198625f, 0.08277780f, 
    -0.01258398f, 0.03881314f, -0.05707177f, 0.15207557f, 0.11965986f, 0.06203444f, 0.10602549f, 0.10965622f, 
    -0.02631926f, -0.04754362f, 0.18755384f, 0.09964869f, -0.00901536f, -0.69368249f, -0.09669134f, 0.02376600f, 
    0.10734092f, 0.21710661f, -0.06868189f, -0.11262785f, 0.04793479f, 0.07382938f, -0.09293356f, 0.03646664f, 
    -0.21232243f, 0.30125728f, 0.32239777f, 0.21002191f, 0.09633768f, 0.15619028f, 0.01465845f, 0.07048342f, 
    -0.07125031f, 0.02280917f, 0.00153398f, -0.00247335f, -0.28775084f, -0.13872156f, -0.05416036f, -0.11720794f, 
    -0.00941048f, -0.01094939f, -0.06628345f, -0.22459698f, 0.02408364f, 0.20353781f, 0.02053758f, -0.06488685f, 
    0.40846911f, 0.11538421f, 0.02095346f, 0.11658250f, -0.00861277f, 0.02198953f, -0.12889121f, -0.00439753f, 
    0.12356061f, -0.00990270f, 0.17945108f, -0.01733769f, -0.08910919f, 0.36297923f, 0.04840794f, 0.03112358f, 
    -0.03428413f, 0.08197251f, 0.02328949f, 0.00214222f, -0.04048106f, 0.02163412f, 0.05390606f, 0.13898738f, 
    -0.16356310f, 0.14556383f, -0.00331640f, 0.16711524f, -0.00733396f, -0.03820909f, -0.03335254f, -0.10261145f, 
    -0.01609460f, -0.01112678f, 0.00749779f, 0.07159151f, -0.13021159f, -0.35003915f, 0.02049566f, 0.10414625f, 
    -0.12023353f, -0.05760476f, -0.04712756f, 0.11372275f, -0.03084514f, -0.01173201f, -0.07651526f, 0.00583073f, 
    -0.15310982f, -0.21643963f, -0.32455885f, -0.19940129f, -0.17147820f, -0.12463666f, -0.00592287f, 0.15548488f, 
    -0.14666361f, -0.10721772f, 0.02253928f, -0.01839517f, -0.01312927f, 0.18387663f, -0.01190547f, 0.30536115f, 
    0.10730848f, -0.05097778f, 0.06282437f, 0.01842407f, 0.05966323f, -0.01765459f, -0.08821218f, 0.17960319f, 
    -0.03622494f, -0.17614922f, -0.02136965f, -0.07878108f, 0.06038403f, 0.13470092f, 0.03836525f, 0.03429922f, 
    0.21501651f, 0.13099656f, 0.12602486f, 0.11521115f, 0.20625541f, 0.32512334f, 0.18148445f, 0.28303155f, 
    0.12078658f, 0.07775491f, -0.00331179f, 0.22590056f, -0.04354522f, -0.04061158f, 0.00399710f, -0.09775241f, 
    -0.43921921f, 0.32368785f, 0.19147930f, 0.07525411f, -0.06590997f, 0.01293808f, -0.10055707f, 0.01240150f, 
    0.03344577f, -0.03698446f, 0.14669681f, 0.08124094f, 0.07720984f, 0.09260251f, 0.13562880f, 0.18950444f, 
    0.05252503f, -0.03050022f, 0.05302604f, -0.03761195f, -0.05444961f, -0.01444550f, -0.03347993f, -0.06000360f, 
    0.10265820f, -0.34683350f, -0.09053499f, -0.36504006f, 0.06579784f, -0.12061258f, -0.09137177f, 0.11181330f, 
    0.01767529f, -0.03645172f, -0.07928570f, -0.03799466f, -0.38120160f, -0.13971165f, 0.22136818f, -0.07937445f, 
    0.09682784f, 0.11252818f, -0.07727230f, 0.14795673f, -0.11736637f, 0.02025805f, -0.00994956f, 0.15444505f, 
    0.16633089f, 0.22241110f, 0.09133834f, 0.36491263f, -0.01055776f, -0.09289914f, 0.00128618f, 0.18295120f, 
    0.08617644f, -0.06864563f, 0.12072038f, 0.15193312f, 0.13887531f, -0.15393217f, -0.08257546f, -0.37573069f, 
    -0.02982396f, 0.03187777f, -0.00424548f, 0.16797568f, -0.00932910f, 0.10119271f, 0.11385802f, 0.04711625f, 
    -0.02774346f, -0.34301308f, -0.13158457f, 0.06727919f, 0.11162910f, -0.06268610f, -0.01590264f, -0.04594848f, 
    0.08993492f, 0.22789153f, -0.03242441f, 0.02205372f, -0.02709203f, 0.20088881f, 0.04874544f, 0.20387328f, 
    -0.04634114f, 0.04184362f, 0.08443528f, 0.16459477f, 0.14413965f, -0.02894229f, 0.09190486f, 0.13706098f, 
    -0.14241146f, 0.00762195f, 0.25464052f, -0.02160166f, 0.01926957f, 0.03304486f, 0.17636122f, 0.13217346f, 
    -0.11040623f, -0.06502634f, 0.04022203f, -0.10676631f, 0.06357834f, -0.11416009f, 0.04897118f, 0.17635122f, 
    -0.06116320f, 0.04216533f, 0.10348865f, -0.15521568f, -0.17373748f, -0.13259251f, 0.00976349f, -0.05566342f, 
    -0.20466261f, -0.16659297f, 0.14069322f, 0.15777494f, -0.11666814f, -0.05642320f, 0.14584918f, 0.04346498f, 
    0.12060451f, 0.06607297f, -0.06570014f, 0.09082155f, 0.12261602f, 0.06569428f, 0.21728574f, 0.02007356f, 
    0.05174670f, 0.03228671f, -0.01363044f, -0.01747466f, 0.23595141f, -0.10562524f, 0.04978042f, 0.17302716f, 
    0.20710798f, 0.13910659f, 0.11435400f, 0.04772329f, -0.08237316f, 0.00279313f, 0.16086838f, -0.07942425f, 
    -0.03348184f, 0.04432660f, 0.00549356f, 0.07421166f, -0.07626181f, 0.01489780f, 0.24923632f, 0.13038822f, 
    0.13180387f, -0.03769840f, -0.08426242f, 0.09936096f, 0.30573139f, 0.25176105f, 0.12652560f, -0.08285177f, 
    -0.03417010f, 0.02506543f, 0.09334752f, 0.05298237f, 0.20576738f, 0.06221811f, 0.03198099f, 0.05998695f, 
    -0.07414918f, -0.00316264f, 0.00229986f, 0.06072751f, -0.03601755f, 0.06780396f, 0.14461356f, -0.03789343f, 
    -0.17909428f, -0.03527936f, 0.04996231f, -0.09871682f, -0.14838599f, -0.11879654f, -0.05854819f, -0.07806378f, 
    0.03790746f, 0.03586667f, 0.02563768f, 0.02360274f, -0.07956085f, 0.10979183f, 0.15870729f, 0.09141234f, 
    -0.12993534f, -0.06109780f, -0.14588159f, -0.08128358f, -0.20154078f, 0.13503881f, 0.12421948f, 0.04205541f, 
    -0.02611565f, 0.05460269f, 0.05099114f, 0.11601482f, -0.08066589f, 0.07052264f, -0.01302579f, -0.04709044f, 
    0.37282360f, 0.23926015f, 0.18431984f, -0.09530077f, -0.06031037f, 0.04175697f, -0.06160077f, -0.02069513f, 
    0.04126170f, -0.06698881f, 0.09391034f, 0.06415746f, 0.20027681f, -0.21349986f, 0.10669086f, 0.13271427f, 
    -0.01718023f, 0.05009704f, 0.11290191f, -0.05940377f, 0.26008075f, 0.07811023f, 0.03068966f, -0.01028427f, 
    0.17434776f, -0.19082282f, 0.07891817f, -0.25640622f, -0.00658524f, 0.08438491f, 0.01550403f, -0.11633767f, 
    -0.07947650f, -0.09790723f, -0.09402419f, -0.15816225f, 0.06244522f, 0.11748898f, -0.01859940f, -0.03821585f, 
    -0.12880896f, -0.16816410f, 0.03908153f, -0.11282555f, -0.15478949f, -0.03250542f, 0.02904182f, -0.04144321f, 
    0.21799715f, -0.12217694f, -0.14132267f, 0.11445199f, 0.01205806f, -0.07328643f, 0.02135361f, -0.04454600f, 
    0.02029721f, -0.05391876f, 0.07691772f, 0.12390621f, -0.04805845f, 0.22772716f, 0.03340641f, 0.16992772f, 
    -0.14655857f, 0.00373724f, 0.09742481f, 0.00985690f, 0.16834475f, 0.07301708f, -0.00403939f, 0.03555682f, 
    -0.05994356f, -0.00321940f, 0.14748147f, 0.19208473f, -0.14881349f, 0.01829118f, 0.13389897f, 0.01681704f, 
    -0.06857791f, 0.05177733f, -0.06109677f, -0.03508805f, 0.07801238f, 0.11457310f, -0.02934962f, 0.11320738f, 
    0.08825664f, -0.08874401f, 0.05190457f, -0.04080874f, -0.10443062f, 0.01334270f, -0.04716518f, 0.03112325f, 
    -0.21020609f, 0.07107107f, -0.07924244f, -0.08542409f, -0.02358287f, -0.01422791f, 0.15437362f, 0.10020797f, 
    0.00486523f, 0.02409971f, 0.05538171f, 0.02179898f, -0.01419025f, 0.07106552f, 0.02692689f, -0.04323498f, 
    0.02875378f, 0.05193451f, -0.03392847f, -0.03292777f, 0.11004255f, 0.01482049f, -0.03163229f, 0.13392210f, 
    0.18402448f, 0.05235774f, 0.05973762f, 0.02109087f, -0.08584643f, 0.05576263f, -0.04264725f, 0.08462384f, 
    -0.09264909f, 0.05523609f, 0.05626257f, -0.02804674f, 0.17933653f, -0.31235003f, 0.46198106f, 0.01147742f, 
    -0.08807344f, 0.10585900f, 0.09770806f, 0.22354227f, 0.05584235f, 0.09804676f, 0.03641341f, -0.03031235f, 
    -0.10532770f, 0.04399860f, 0.06061767f, 0.00708225f, 0.00497845f, -0.00410987f, 0.04262115f, 0.01619872f, 
    -0.06125068f, -0.01107018f, -0.01217088f, 0.11616758f, -0.02714617f, 0.04415756f, -0.06299466f, -0.06706224f, 
    -0.07639011f, 0.03232514f, -0.04779838f, -0.16528906f, -0.07542995f, -0.02795413f, -0.01765995f, -0.04980215f, 
    0.19383970f, 0.06837522f, 0.16536814f, 0.00109897f, 0.05823487f, 0.15473002f, 0.09845310f, -0.01713724f, 
    -0.01847180f, -0.14258374f, 0.01788110f, -0.09019970f, -0.01511754f, 0.14281051f, -0.03839347f, -0.09953624f, 
    0.04403872f, 0.09606306f, -0.00780227f, 0.09771129f, -0.02051554f, 0.06865329f, 0.02755084f, -0.11322641f, 
    0.16712202f, 0.20860787f, -0.17331252f, 0.26184773f, 0.02997764f, -0.04386679f, 0.04330346f, -0.09048118f, 
    0.03361601f, 0.02908199f, 0.01516663f, -0.02954140f, -0.03992552f, -0.03887555f, -0.04412929f, -0.00931176f, 
    0.00889231f, -0.03490466f, 0.12555605f, -0.16311064f, 0.07941426f, -0.00941820f, 0.03533333f, 0.09121383f, 
    0.17588569f, -0.41950482f, 0.17500423f, -0.40886590f, -0.01238670f, 0.14695507f, 0.05465931f, 0.12565908f, 
    -0.04941315f, -0.03171505f, -0.13674684f, 0.00041099f, -0.00425130f, 0.21744223f, -0.12251253f, -0.14955898f, 
    0.02697679f, -0.15123077f, 0.08513888f, -0.03650539f, -0.12522374f, -0.00973093f, 0.11267852f, 0.01104136f, 
    0.07097221f, -0.13667722f, 0.23233183f, 0.08247819f, -0.01026987f, 0.06473969f, -0.01418728f, -0.06418099f, 
    0.05141952f, -0.06745393f, -0.03808263f, 0.08995971f, 0.12793274f, -0.01209610f, 0.00344536f, 0.07376148f, 
    0.11809081f, -0.10051276f, 0.01150148f, 0.01580601f, -0.00186463f, 0.18651742f, -0.10926941f, 0.01993207f, 
    -0.01462062f, -0.13768166f, 0.00344950f, -0.05694038f, -0.02966619f, -0.00093408f, 0.01103030f, 0.00783245f, 
    -0.01922014f, 0.09092847f, -0.09328901f, 0.00966651f, -0.07591959f, -0.03696486f, -0.24859110f, 0.15944973f, 
    -0.04519758f, 0.06402329f, 0.01440171f, -0.03577239f, 0.02843619f, -0.03960752f, 0.06414431f, 0.06725569f, 
    0.00047818f, -0.20565392f, -0.07872585f, 0.32606491f, -0.06580926f, -0.04072506f, 0.03402704f, -0.03789184f, 
    0.21459702f, -0.01341209f, 0.05375030f, 0.03420790f, 0.15618359f, -0.19957505f, 0.10199583f, 0.08568310f, 
    -0.04953223f, -0.08346165f, -0.05956176f, -0.07367870f, 0.02941094f, 0.00691786f, 0.07457305f, -0.09516361f, 
    -0.06930891f, 0.16224816f, -0.13177894f, 0.03076575f, 0.00934208f, 0.07917131f, 0.07325116f, 0.09203399f, 
    0.02510811f, -0.17092089f, 0.04244300f, -0.05558759f, 0.02507653f, 0.40339202f, -0.08286367f, 0.02100338f, 
    0.04511798f, 0.09433257f, 0.01004294f, 0.03225296f, 0.15736520f, -0.10318432f, 0.03000032f, -0.00542412f, 
    -0.04915408f, -0.05935488f, 0.00048304f, -0.01852057f, 0.07748964f, 0.06613101f, 0.07717568f, -0.01552340f, 
    0.18874101f, 0.00134402f, 0.05201150f, 0.03649023f, 0.02991799f, 0.14934599f, 0.17663807f, 0.15806977f, 
    0.05327056f, -0.01405721f, -0.01408581f, 0.15072903f, 0.02313760f, -0.07974566f, 0.01558687f, 0.01389305f, 
    -0.24872091f, 0.20344980f, 0.09668978f, 0.37201455f, -0.06463414f, 0.04397858f, -0.01589778f, 0.05313751f, 
    -0.00038010f, 0.07826648f, -0.05097981f, 0.08089310f, -0.25497016f, 0.02433095f, -0.10900977f, -0.02845238f, 
    -0.06692394f, 0.00984811f, 0.09708454f, 0.11593831f, 0.05888797f, -0.11708476f, 0.07808705f, -0.05507926f, 
    -0.06532892f, -0.05233101f, -0.00329159f, -0.16615815f, -0.05304338f, 0.02314990f, -0.12070050f, 0.14359032f, 
    -0.00155388f, -0.03218038f, -0.02027739f, -0.08385459f, 0.10842053f, -0.30647799f, 0.30392814f, -0.21312936f, 
    -0.20428315f, 0.13121945f, -0.04891498f, 0.00645789f, -0.07865410f, 0.00057437f, -0.09385092f, 0.05379196f, 
    -0.09958787f, -0.02011631f, 0.13766454f, 0.05714470f, 0.01972633f, 0.03495954f, -0.02193356f, 0.05546224f, 
    -0.06423702f, -0.11325922f, 0.00498567f, -0.03998527f, 0.07738571f, 0.04990468f, 0.17728968f, -0.14618045f, 
    0.14050427f, -0.00020349f, 0.13418429f, -0.05499237f, 0.03311960f, 0.00366271f, -0.14298913f, 0.04854230f, 
    -0.15872841f, -0.37258211f, 0.17318985f, 0.16813460f, 0.16789071f, 0.10054573f, 0.03900144f, -0.14034683f, 
    0.03003376f, 0.06590709f, 0.17697696f, 0.11787713f, -0.09065317f, 0.10715836f, 0.06279013f, 0.18751131f, 
    0.00787616f, -0.02910065f, 0.06379684f, -0.04752273f, -0.04738206f, 0.02693710f, 0.06433795f, 0.01184403f, 
    -0.40472388f, 0.31358168f, 0.13223127f, -0.05023843f, -0.05977578f, -0.06542072f, -0.03686538f, -0.02259330f, 
    0.10288461f, 0.08323251f, -0.00980787f, -0.06623184f, -0.48726007f, -0.22086824f, 0.02810980f, 0.03109757f, 
    0.06348558f, -0.15710606f, 0.04445434f, -0.00125548f, -0.13170791f, 0.15538248f, 0.02263766f, -0.10691775f, 
    -0.27371594f, -0.00564709f, 0.26561415f, -0.09694755f, -0.00896507f, 0.00855343f, -0.00281714f, -0.02342318f, 
    -0.02524164f, 0.19346149f, 0.03942081f, 0.07236061f, 0.20652840f, 0.05088475f, 0.11066645f, 0.20588966f, 
    0.11532292f, -0.03644546f, 0.01013678f, -0.04559283f, -0.00680432f, -0.02729161f, -0.00782218f, 0.09964292f, 
    0.36747205f, 0.08871783f, 0.01703219f, 0.14491680f, 0.05525649f, -0.00390133f, 0.00361481f, -0.11500706f, 
    -0.10387048f, 0.00960123f, 0.01370781f, 0.01305490f, 0.02872903f, -0.15781336f, 0.30167872f, -0.08750831f, 
    0.12801011f, 0.00833662f, -0.00992544f, 0.38282523f, 0.08579482f, 0.10199813f, 0.08060062f, 0.10893425f, 
    -0.06002918f, -0.00754930f, -0.03067665f, 0.05434472f, -0.02292075f, -0.05736145f, -0.03869713f, -0.02507582f, 
    -0.06502745f, -0.04079865f, -0.13243780f, -0.09283762f, -0.43315688f, -0.13923682f, -0.32243186f, 0.03072905f, 
    0.06901067f, 0.18385194f, -0.12093341f, -0.26917943f, 0.03175418f, 0.01692505f, -0.00798469f, -0.05347723f, 
    -0.23451133f, -0.42313713f, 0.32930911f, 0.10673743f, -0.09705653f, 0.13073900f, 0.25415784f, 0.02578006f, 
    0.01682192f, 0.12966721f, -0.04979419f, -0.06184643f, -0.32043165f, -0.05157748f, -0.02136820f, -0.44109219f, 
    -0.18250434f, 0.06733183f, 0.10899323f, 0.11677264f, -0.07458761f, 0.11636836f, 0.04063083f, 0.12960637f, 
    -0.05043720f, 0.24453403f, -0.16805825f, 0.01997781f, 0.08489662f, -0.05551672f, 0.13901304f, 0.01582626f, 
    0.06722307f, 0.09400678f, 0.13552023f, 0.05295788f, -0.09033676f, 0.09170900f, 0.03178059f, 0.19136649f, 
    0.21391962f, -0.16533741f, 0.07551303f, -0.07792682f, 0.01433436f, 0.12315480f, -0.04974882f, -0.06669001f, 
    0.52509469f, -0.09594935f, 0.01700571f, -0.37988433f, -0.09094983f, -0.03276452f, 0.06251329f, -0.02590304f, 
    0.07679179f, 0.02453475f, 0.00330617f, 0.05884265f, 0.01036560f, -0.10670682f, -0.20071866f, 0.08251723f, 
    0.12755482f, 0.00880871f, 0.11353868f, -0.02633063f, -0.03585766f, -0.14879015f, -0.02707396f, -0.06341723f, 
    0.00934961f, 0.03607615f, -0.03646277f, -0.08274775f, -0.04399015f, -0.06672129f, 0.02586879f, -0.06302159f, 
    -0.08871728f, -0.02293690f, -0.02780822f, -0.03088452f, 0.02030560f, 0.04484438f, 0.06836686f, -0.01755813f, 
    -0.09608934f, 0.00600590f, -0.05506642f, -0.06061301f, 0.03382625f, -0.02946070f, 0.01482649f, 0.01401758f, 
    -0.00756835f, -0.05954032f, 0.02773175f, 0.00209179f, -0.02894673f, 0.00352496f, -0.04785519f, -0.06555992f, 
    -0.06830132f, 0.00524167f, -0.01203608f, -0.09507955f, -0.07913383f, -0.10590617f, -0.04983474f, 0.03948436f, 
    0.05981161f, -0.02698838f, 0.00055626f, -0.06533799f, -0.09511358f, -0.08710092f, -0.07798151f, -0.09759304f, 
    -0.00676244f, -0.04107572f, -0.07245986f, -0.05351166f, -0.03774286f, 0.04014540f, -0.03912901f, 0.03689365f, 
    -0.07134786f, -0.05098061f, -0.02263861f, 0.01691695f, -0.00932983f, 0.01000472f, -0.02543863f, -0.00650467f, 
    -0.08544276f, -0.08032372f, -0.08641706f, -0.05144422f, -0.08852852f, -0.04721009f, -0.05685314f, -0.06683929f, 
    0.05005579f, -0.05491276f, -0.01522508f, -0.04274873f, -0.09265172f, -0.02684686f, 0.00321220f, -0.02093935f, 
    -0.05239347f, -0.03243363f, 0.00294568f, -0.03508666f, 0.02228037f, -0.08067196f, -0.09347926f, -0.03628891f, 
    0.00750203f, -0.00088159f, -0.06960363f, 0.02129137f, -0.01699101f, -0.08728922f, -0.11546581f, 0.00422908f, 
    0.00731729f, -0.02571547f, -0.01611691f, -0.05221878f, 0.05176597f, -0.00942856f, 0.00211870f, -0.02678038f, 
    0.03927434f, 0.00868008f, 0.02557722f, -0.00483622f, -0.04593147f, 0.00324198f, -0.02162990f, 0.02899550f, 
    -0.01879871f, 0.06124614f, 0.01415520f, -0.04975050f, -0.03581331f, -0.10712276f, -0.02147750f, -0.08808425f, 
    -0.11384828f, -0.09455321f, -0.06183567f, -0.06521621f, 0.02966523f, 0.00082956f, 0.04474989f, 0.02609874f, 
    -0.07381530f, -0.04489995f, -0.05384419f, -0.03828831f, -0.01433649f, 0.01610466f, -0.00515792f, 0.02840518f, 
    -0.00985508f, -0.06763011f, -0.02890312f, -0.01777543f, -0.08038682f, -0.05961387f, 0.02990513f, -0.00026465f, 
    -0.03081828f, 0.02444608f, -0.02687337f, -0.01042347f, -0.03054239f, -0.02035604f, -0.00789166f, -0.06214319f, 
    -0.03671755f, -0.00296137f, -0.02720687f, -0.04714374f, -0.04742658f, -0.06819898f, -0.04315726f, -0.07677121f, 
    -0.06832156f, -0.08451733f, 0.04439360f, -0.09712360f, -0.06085758f, 0.02307389f, 0.02718828f, -0.07554181f, 
    -0.06486350f, -0.08355571f, 0.00914694f, 0.01697770f, -0.06872422f, 0.05185704f, -0.08395498f, -0.08345935f, 
    -0.09328769f, -0.10827892f, -0.07745996f, -0.11497763f, 0.00582531f, 0.04625412f, -0.02267587f, 0.01264910f, 
    0.04738097f, 0.02321405f, -0.09278966f, -0.01411627f, -0.09812702f, -0.09701985f, 0.03703985f, 0.00603997f, 
    -0.05260482f, -0.05856089f, -0.08121444f, 0.00506049f, 0.05822030f, 0.04978205f, -0.05320560f, 0.01479521f, 
    -0.05710500f, 0.06189729f, 0.03548788f, -0.07992900f, -0.04242119f, -0.01146687f, -0.03198956f, -0.04249670f, 
    -0.03684202f, 0.04721378f, -0.01964428f, -0.05710806f, 0.03377249f, -0.04491956f, -0.08273713f, -0.04394302f, 
    0.04127256f, 0.00188010f, 0.05246168f, -0.05673087f, -0.04099482f, -0.04628114f, -0.00279418f, -0.06931826f, 
    0.06486784f, -0.01732349f, -0.07801237f, 0.05762103f, -0.03228943f, 0.05423924f, 0.06140582f, 0.01511613f, 
    0.02187552f, 0.00186014f, 0.01903307f, -0.02792052f, 0.02889315f, 0.00640341f, -0.04828994f, 0.05837996f, 
    -0.01108192f, -0.07463875f, -0.05871909f, -0.00988498f, -0.01973076f, -0.00416792f, 0.00199429f, 0.01407035f, 
    -0.01613736f, -0.00914953f, -0.06711538f, -0.01508804f, -0.03486987f, -0.05335982f, -0.00029308f, 0.02632223f, 
    -0.07020775f, -0.03124049f, 0.01041575f, -0.03669637f, 0.02527078f, -0.07439926f, 0.06518812f, 0.01841837f, 
    0.03398206f, 0.05344827f, -0.00444606f, -0.03063199f, -0.00998987f, 0.05152590f, 0.04658000f, -0.04079893f, 
    -0.05326222f, 0.02735679f, -0.03844382f, 0.01438200f, 0.05251478f, -0.05737613f, -0.02070050f, -0.05542871f, 
    -0.01570480f, 0.03873318f, -0.04814897f, 0.01690529f, -0.02222581f, 0.05654291f, 0.02846720f, -0.08744586f, 
    0.01065162f, -0.04578509f, -0.01865698f, -0.02117840f, 0.01803444f, -0.01323740f, -0.04440648f, -0.01086537f, 
    0.04451251f, 0.01493672f, -0.05612378f, -0.01196343f, -0.01807207f, -0.00762172f, -0.02769789f, -0.05758291f, 
    0.05279785f, -0.07427303f, 0.03210280f, -0.00016197f, -0.02915626f, 0.01201911f, 0.03447667f, -0.02495518f, 
    -0.08192038f, 0.02425496f, 0.01997541f, 0.03760429f, 0.03580918f, 0.03767972f, 0.00251550f, -0.06912697f, 
    0.00249080f, -0.03974798f, 0.05095069f, -0.02108582f, -0.05657217f, 0.05746451f, 0.04668573f, 0.02333784f, 
    -0.02015449f, -0.01817253f, 0.05118101f, 0.03204606f, -0.07469922f, -0.05398041f, -0.00314587f, 0.05139904f, 
    -0.01046355f, -0.02086687f, 0.02200241f, -0.02635413f, -0.07206346f, -0.04055035f, -0.07208630f, -0.05380170f, 
    0.01213414f, -0.04400554f, -0.02344589f, -0.04362678f, 0.02963715f, -0.04522594f, -0.06083615f, -0.06454771f, 
    -0.07949020f, 0.06052316f, -0.00106229f, -0.08519983f, -0.01711674f, -0.01597299f, -0.04195509f, -0.06905356f, 
    -0.05897295f, 0.03711462f, -0.01824977f, -0.06082370f, 0.02612324f, -0.02979916f, 0.04034882f, 0.05152351f, 
    0.00394389f, -0.01210178f, -0.07930798f, 0.02691764f, 0.05435098f, 0.00708482f, -0.04680387f, -0.07514475f, 
    -0.03318961f, 0.04052401f, 0.02082610f, -0.01345011f, 0.05421777f, 0.01389760f, 0.04141754f, 0.04517930f, 
    -0.44369853f, -0.48215720f, 0.21188426f, -0.11341646f, 0.03591676f, 0.13634555f, -0.04478192f, 0.17742363f, 
    -0.02037876f, -0.06263850f, 0.16063663f, -0.11886732f, 0.17966467f, 0.12666656f, 0.12718631f, -0.04623793f, 
    -0.02335196f, 0.01718638f, -0.02501521f, -0.06673360f, -0.02850157f, 0.14573875f, -0.03129900f, -0.05771647f, 
    -0.05939525f, -0.17912509f, -0.38041136f, -0.09355722f, 0.12001022f, -0.05081592f, 0.15023781f, 0.17470238f, 
    -0.07696646f, 0.06222486f, 0.12242310f, 0.06698866f, -0.23612384f, -0.23951527f, -0.29945838f, -0.29996544f, 
    -0.03322950f, 0.08593544f, 0.05533578f, 0.10942941f, -0.04127923f, 0.09803282f, 0.02997219f, -0.05274567f, 
    0.46928623f, 0.00875659f, -0.11761358f, -0.22179100f, -0.01173494f, -0.01322336f, -0.12562494f, -0.07424339f, 
    -0.06584910f, 0.03986073f, 0.00122057f, -0.01834105f, 0.21663424f, 0.23146477f, 0.31056830f, 0.11207579f, 
    -0.09739476f, 0.13130641f, -0.03128700f, -0.09048271f, 0.12688912f, 0.06474346f, 0.04780914f, 0.02492481f, 
    0.38569784f, 0.29267544f, 0.28500316f, 0.29290748f, 0.01446932f, -0.06716160f, -0.09223183f, -0.02948239f, 
    0.00885308f, -0.03682258f, 0.07237470f, 0.07083426f, -0.18222326f, -0.09138398f, -0.26538485f, 0.08682154f, 
    -0.04764269f, 0.02689386f, 0.19070989f, 0.04795315f, -0.09926611f, 0.17474993f, -0.09085356f, 0.23945457f, 
    0.05669981f, 0.12779279f, 0.00851592f, 0.03533652f, -0.04395898f, -0.06195472f, -0.01097781f, -0.02895504f, 
    -0.08975697f, 0.01887924f, -0.03164320f, 0.04499885f, -0.22670220f, -0.20030543f, -0.02600586f, -0.09425002f, 
    0.10101098f, 0.18425949f, 0.14551893f, 0.18931986f, -0.09539390f, 0.06513477f, -0.01783993f, -0.00549306f, 
    -0.43784159f, -0.16502494f, -0.17859820f, 0.14959811f, 0.00963875f, -0.04749625f, 0.02260605f, -0.11793887f, 
    -0.06433190f, 0.17257434f, 0.08103232f, -0.07235450f, -0.10074733f, -0.56324816f, -0.25169876f, -0.26868576f, 
    -0.05240379f, -0.05723057f, -0.01733496f, 0.10024658f, -0.12643069f, -0.14187840f, -0.19646625f, 0.07431752f, 
    -0.23722939f, -0.53724533f, -0.33092377f, -0.33130169f, -0.07112263f, -0.05264482f, 0.02981861f, 0.10663057f, 
    0.21569127f, 0.09176714f, 0.09978800f, -0.01061430f, 0.03236938f, 0.09469920f, 0.23830383f, 0.02784336f, 
    0.11130714f, -0.01119501f, 0.05536354f, -0.05731041f, 0.04889224f, 0.07491016f, -0.02590324f, -0.00815025f, 
    0.20051272f, 0.33412674f, 0.02524179f, 0.35680848f, 0.06806106f, 0.05512576f, 0.20608172f, -0.03380905f, 
    0.03316118f, -0.03778180f, 0.05634107f, 0.16800106f, 0.26546845f, 0.29244611f, 0.19814146f, 0.16697691f, 
    -0.07745352f, -0.15290302f, 0.07554533f, -0.04912903f, 0.02351656f, 0.07315661f, 0.01489872f, -0.04383230f, 
    0.06084351f, -0.03494332f, 0.02820883f, 0.33460751f, 0.06149107f, -0.09307405f, 0.06239790f, 0.12508380f, 
    -0.00393071f, 0.06298780f, 0.02914042f, 0.04894873f, -0.45133728f, -0.05802957f, -0.07052138f, -0.29202437f, 
    -0.22167838f, -0.10082684f, -0.08499977f, -0.13519950f, 0.00073447f, -0.15813975f, -0.05726482f, -0.11598341f, 
    0.21741705f, 0.06434901f, 0.22834566f, 0.33331108f, 0.13959613f, 0.06077190f, 0.10703637f, 0.17885143f, 
    0.16900453f, 0.02665455f, 0.01729874f, 0.04056662f, 0.43165070f, 0.16028830f, 0.05497009f, 0.09819003f, 
    0.06217953f, 0.11025933f, 0.25046599f, -0.12452908f, 0.15337694f, -0.03298060f, 0.01406375f, -0.06374709f, 
    -0.12758292f, 0.22906680f, -0.16641343f, -0.25561297f, -0.02074579f, -0.02363593f, 0.20381948f, -0.00331409f, 
    0.09340583f, 0.12128085f, -0.03354099f, -0.00886707f, -0.41880047f, -0.30168009f, -0.13711271f, -0.24987602f, 
    -0.03616557f, -0.11386166f, 0.02143906f, -0.00046549f, -0.03815113f, -0.12134317f, -0.14513643f, 0.02546266f, 
    -0.15164834f, -0.60034555f, -0.25856587f, -0.42448342f, -0.09832884f, -0.15645690f, -0.09160301f, -0.20092128f, 
    -0.07441317f, 0.00918704f, 0.03328384f, -0.08077778f, -0.09212727f, -0.19004710f, 0.11121742f, 0.20702888f, 
    0.04644148f, 0.09114799f, 0.00195880f, -0.05437746f, 0.11295567f, 0.21983604f, -0.01996469f, -0.15768188f, 
    -0.11795980f, -0.11120011f, -0.09610099f, -0.10093398f, -0.00655170f, -0.04227551f, 0.02135401f, -0.03339374f, 
    -0.15376578f, -0.03993630f, -0.03932693f, 0.14412032f, 0.25538689f, 0.28764856f, 0.26388597f, 0.31402943f, 
    -0.03725514f, -0.06710610f, 0.10878636f, 0.02588063f, 0.01770675f, -0.03945988f, -0.00327560f, -0.04052307f, 
    0.05570530f, 0.37945148f, 0.10946056f, 0.09495421f, 0.04142878f, 0.09504532f, 0.04552464f, -0.10500684f, 
    0.01036371f, 0.01593379f, 0.04378830f, -0.12397730f, 0.25157320f, 0.15156886f, 0.16390803f, 0.28692544f, 
    0.17050500f, 0.17022777f, 0.00650585f, -0.03812407f, 0.05099562f, 0.17677933f, 0.02085488f, 0.11175124f, 
    0.33140859f, -0.11084715f, -0.20602061f, 0.22721988f, 0.05735009f, 0.01352284f, -0.11483572f, -0.09642094f, 
    0.10774364f, -0.06885859f, 0.06073763f, 0.08102071f, -0.39944878f, -0.17203583f, -0.04396952f, -0.05868998f, 
    -0.30737892f, -0.20319521f, -0.00370175f, -0.05324199f, 0.09600294f, -0.14493945f, -0.01233693f, 0.05670198f, 
    0.19264078f, -0.05642044f, 0.28097636f, 0.25441322f, -0.07260476f, 0.16281316f, 0.00725377f, 0.03434982f, 
    -0.13550074f, 0.03251287f, 0.06535278f, 0.05989036f, 0.07414503f, -0.45069242f, -0.22444901f, -0.19490831f, 
    -0.11241862f, -0.15331271f, -0.04602247f, 0.13938008f, -0.02224868f, 0.13435243f, 0.04493726f, 0.11489405f, 
    -0.35660776f, 0.02538146f, -0.00747341f, 0.26009506f, 0.08686011f, 0.08690397f, -0.03569631f, 0.11552171f, 
    0.21141210f, -0.01222489f, -0.02785147f, 0.03779576f, -0.05657702f, -0.02554739f, -0.12901631f, -0.01680131f, 
    -0.13104396f, 0.06978846f, -0.13465977f, -0.14211696f, -0.07191565f, -0.02076749f, -0.11272867f, -0.05020917f, 
    0.10164741f, -0.20775856f, 0.17603217f, 0.08995952f, 0.05615310f, -0.12185056f, -0.00130082f, 0.03402336f, 
    0.04235748f, -0.05122636f, 0.12132902f, 0.07119609f, -0.21219233f, -0.04989062f, 0.09840652f, 0.17311874f, 
    0.16945824f, 0.10531221f, 0.04084088f, 0.03466281f, 0.09466329f, -0.08300249f, 0.06628685f, 0.11431266f, 
    -0.06455763f, 0.30905738f, -0.02735858f, 0.38418368f, 0.00905693f, -0.05044642f, -0.11127674f, -0.13910262f, 
    -0.04430437f, -0.16729274f, -0.07414013f, 0.07521795f, -0.11558481f, 0.21002035f, -0.12584311f, 0.25514379f, 
    -0.00419099f, 0.09569009f, 0.05810361f, -0.05292036f, -0.04851670f, 0.02656044f, 0.07762545f, 0.03639301f, 
    -0.00640605f, -0.02314607f, 0.00342693f, -0.12473184f, -0.06479627f, 0.02450133f, 0.02772768f, 0.10608232f, 
    0.10594420f, 0.01333742f, 0.00703577f, -0.08251720f, -0.02707372f, 0.13805632f, 0.00026253f, 0.03118682f, 
    0.19203971f, 0.03712002f, 0.05201510f, -0.03021238f, 0.11286609f, 0.00210991f, -0.01413244f, 0.03571827f, 
    -0.09685265f, -0.02552504f, -0.05071916f, -0.11436548f, -0.01798289f, 0.00947470f, -0.03010938f, -0.08671007f, 
    -0.08012675f, -0.25172451f, 0.05558761f, -0.00578145f, -0.24386792f, -0.11815190f, 0.15553619f, 0.20912756f, 
    -0.01579786f, 0.03568745f, 0.02759258f, 0.20429668f, 0.09619457f, -0.03288734f, 0.04725056f, -0.01137302f, 
    -0.30870414f, -0.04252340f, -0.32394233f, 0.10802181f, -0.16349836f, 0.12120824f, -0.12332283f, -0.14939746f, 
    0.05889578f, 0.02086130f, 0.08034704f, -0.09749302f, -0.03732882f, -0.05726491f, 0.00632721f, 0.22540528f, 
    0.02811625f, -0.18735380f, -0.05563611f, -0.10880747f, 0.15326633f, 0.07885133f, 0.12022286f, 0.14011818f, 
    0.09057309f, 0.08156458f, 0.28440979f, -0.01173242f, -0.06577300f, -0.07793378f, -0.07102758f, 0.00500061f, 
    0.01340765f, 0.05881825f, 0.00998413f, 0.13796718f, -0.25515223f, -0.18118392f, 0.14002977f, -0.01617084f, 
    -0.01253237f, 0.17560320f, -0.09608503f, -0.05702494f, 0.19422008f, -0.09578082f, -0.07227073f, 0.08796855f, 
    -0.18014075f, 0.14413522f, 0.20168947f, 0.03098032f, -0.04368100f, 0.04519856f, -0.08274613f, 0.11497833f, 
    0.13549268f, -0.05276879f, 0.06780948f, -0.00818402f, 0.30396140f, 0.21023358f, 0.04254789f, -0.05515901f, 
    -0.03628889f, -0.07224192f, -0.19444829f, 0.16274966f, 0.09262417f, 0.02550727f, 0.03347819f, 0.04597436f, 
    -0.05387859f, -0.03348792f, 0.00287921f, 0.03052092f, -0.07133694f, 0.04346037f, -0.03301295f, -0.02103318f, 
    0.03206354f, 0.05025224f, -0.00888309f, 0.05974162f, 0.04722390f, -0.00917540f, -0.00405162f, -0.00214817f, 
    -0.04185199f, 0.00072303f, -0.00831942f, -0.05907618f, -0.05314065f, -0.01558352f, 0.03888900f, 0.03518338f, 
    -0.03925177f, -0.02138810f, -0.04936204f, 0.05543376f, -0.04944557f, -0.03380650f, 0.02136319f, 0.01342398f, 
    -0.05509728f, -0.03083554f, 0.03413992f, -0.03236626f, 0.06560450f, 0.00547002f, -0.07551002f, -0.07595591f, 
    0.05159822f, -0.00894024f, -0.03761890f, -0.04554841f, 0.02658848f, 0.04415692f, 0.00646579f, 0.01071313f, 
    -0.07067277f, -0.07157151f, -0.00430520f, -0.06643864f, -0.02016958f, -0.05693441f, -0.04263877f, 0.01954765f, 
    0.01311841f, -0.02373851f, 0.05330264f, 0.01878954f, 0.04160590f, -0.06771438f, -0.01496650f, 0.01227565f, 
    -0.04356762f, -0.03609424f, -0.01881876f, 0.00460544f, -0.05047791f, 0.02080727f, 0.00391029f, 0.05261433f, 
    0.03880817f, -0.04022479f, 0.00278940f, -0.07577347f, 0.00177667f, -0.07254017f, -0.04076270f, -0.07296424f, 
    0.00934857f, 0.00873052f, 0.06318131f, -0.02745546f, -0.07558857f, -0.05710082f, 0.02488695f, -0.00646177f, 
    -0.04178600f, -0.05059131f, -0.00604927f, 0.03956734f, -0.00463526f, -0.02799014f, 0.03556415f, 0.00697966f, 
    -0.00462061f, -0.00171973f, 0.01418087f, 0.04059495f, 0.03330937f, -0.05006417f, 0.03766445f, 0.00254400f, 
    -0.00802113f, -0.06594475f, -0.00154191f, 0.02272050f, -0.04032497f, -0.06932693f, -0.00530384f, 0.01197504f, 
    -0.01967862f, -0.01512178f, -0.05874274f, -0.02117295f, 0.05316713f, -0.03803287f, -0.03768200f, -0.06945286f, 
    -0.05632494f, 0.00866138f, 0.06566259f, 0.04975178f, -0.04313915f, -0.02751380f, -0.05409219f, -0.08113113f, 
    -0.06499255f, -0.03377398f, -0.01478107f, -0.02107395f, 0.04322002f, 0.00461233f, -0.01826693f, -0.01070980f, 
    -0.07511009f, -0.07097340f, -0.00299474f, -0.07105690f, -0.04474453f, 0.02568586f, 0.03205560f, 0.01765776f, 
    -0.02579771f, -0.05905262f, -0.02491171f, 0.04285681f, 0.04543342f, 0.05436676f, 0.03782737f, -0.00780188f, 
    -0.02004161f, 0.04721662f, -0.06193634f, -0.03339012f, -0.03278984f, -0.07417392f, 0.02407393f, -0.06685590f, 
    -0.01547042f, 0.00903052f, -0.07955805f, 0.04468703f, -0.07277737f, 0.01014950f, -0.07626761f, -0.02822225f, 
    -0.01437764f, 0.02117437f, -0.06666945f, 0.06562601f, -0.07909102f, 0.05311912f, 0.03080224f, -0.02404217f, 
    -0.02538284f, -0.04175949f, -0.06502423f, 0.00410576f, 0.01179954f, -0.05697145f, -0.02163886f, 0.05892713f, 
    0.01183492f, 0.05094984f, -0.03984316f, -0.01714870f, -0.00611006f, 0.01137959f, -0.02462120f, 0.04826381f, 
    0.03696258f, 0.02545939f, -0.06647994f, 0.01283076f, 0.02674129f, -0.05856769f, -0.02125151f, 0.06078805f, 
    0.03969572f, 0.03019256f, 0.03051183f, 0.06710166f, -0.06372074f, -0.00957741f, -0.03659009f, 0.01056287f, 
    -0.06080142f, -0.06432493f, -0.04327910f, -0.07206751f, 0.04096000f, -0.06417050f, -0.07598037f, -0.03466634f, 
    -0.03820523f, 0.05640515f, -0.05911411f, 0.01474588f, 0.00921236f, 0.00862980f, -0.05197163f, -0.06654762f, 
    0.06869482f, -0.05655845f, 0.06408720f, -0.02799872f, -0.02359303f, -0.01702425f, -0.00191784f, -0.01417592f, 
    -0.01178616f, -0.08389132f, 0.01763757f, -0.04461314f, -0.02339538f, -0.00891734f, -0.01001649f, -0.01772853f, 
    -0.07503153f, 0.06385091f, 0.01099167f, -0.03174704f, -0.01328864f, 0.04533492f, -0.01544704f, -0.04546588f, 
    -0.05957770f, -0.05504602f, -0.00768560f, -0.06123448f, -0.02053452f, -0.03647437f, -0.01492701f, -0.01236010f, 
    0.03232452f, 0.03901956f, 0.06000976f, -0.07596376f, 0.03508347f, 0.04845771f, -0.04351460f, -0.07174900f, 
    -0.04159067f, -0.05651688f, 0.06427021f, -0.02441092f, 0.02365918f, -0.02767322f, -0.01336773f, -0.01761799f, 
    -0.02163808f, -0.02483400f, 0.02386621f, -0.05114742f, -0.05697655f, 0.06623978f, -0.00912843f, -0.02447351f, 
    -0.03742594f, 0.06120525f, -0.05179524f, -0.01782108f, -0.04069008f, 0.02566887f, 0.01933570f, 0.04016130f, 
    -0.05959361f, 0.02319990f, 0.04947233f, -0.06745410f, 0.00786454f, -0.03465994f, -0.05739063f, 0.00789110f, 
    0.00244082f, 0.01437526f, 0.05953955f, 0.00736554f, 0.02006296f, 0.03760711f, 0.01640875f, 0.03981915f, 
    -0.04620173f, -0.04969117f, 0.06463846f, -0.02638520f, 0.04939942f, -0.00244843f, -0.03562228f, -0.06048181f, 
    -0.00691281f, -0.06968401f, -0.03480015f, 0.05687910f, 0.01105556f, 0.00340400f, 0.03115406f, -0.05509588f, 
    0.01136623f, 0.00794575f, -0.06753840f, -0.07675764f, -0.07357508f, -0.04057650f, 0.04371596f, -0.01409971f, 
    -0.03121544f, -0.02209548f, -0.03892372f, -0.02622727f, 0.04760439f, -0.05627140f, -0.02695673f, 0.05904436f, 
    -0.07705867f, 0.03244718f, 0.00395095f, -0.04913091f, -0.04547969f, -0.01788551f, -0.01178586f, 0.04397720f, 
    0.05695620f, 0.02044315f, 0.03139147f, 0.02662322f, -0.07102297f, 0.05124049f, -0.03041109f, -0.01454191f, 
    -0.06256013f, -0.01068329f, 0.02811084f, -0.04746515f, -0.00939599f, 0.05402705f, 0.04604190f, -0.02494586f, 
    0.05431383f, 0.00130001f, 0.07411785f, 0.06252164f, -0.06285654f, -0.05320527f, -0.07398322f, 0.06440851f, 
    0.02064195f, -0.05571551f, -0.06747191f, 0.00272191f, 0.00671320f, -0.01409283f, 0.06865901f, -0.06332116f, 
    -0.05645838f, 0.01032397f, 0.04549551f, 0.04142848f, 0.05200237f, -0.01329893f, -0.04640571f, -0.07690549f, 
    -0.10827047f, 0.17258053f, 0.29925781f, -0.10930320f, -0.04480668f, 0.13591999f, -0.01806443f, 0.11255223f, 
    0.08049662f, -0.02141778f, 0.07186314f, 0.07226855f, -0.05557876f, -0.30989772f, 0.02426914f, 0.03055299f, 
    0.21281622f, -0.13777234f, -0.06473504f, -0.20288433f, -0.07604681f, 0.17341308f, -0.04496227f, 0.07310690f, 
    0.09304309f, 0.04471378f, -0.21329232f, -0.12578051f, 0.00633198f, -0.00918781f, -0.18477133f, -0.08163553f, 
    -0.05388604f, 0.00402649f, 0.00504838f, 0.04980004f, -0.02843331f, -0.00793674f, 0.05117814f, -0.00923388f, 
    -0.12469082f, -0.02701607f, -0.07243549f, 0.11819150f, -0.04279966f, -0.07815965f, -0.13479277f, 0.07133716f, 
    0.19303663f, -0.04234605f, 0.13934442f, 0.33093399f, 0.06239423f, 0.02616780f, -0.16261593f, -0.01202880f, 
    0.06032224f, -0.01588752f, 0.12168117f, 0.05965674f, 0.10960545f, -0.24975666f, 0.11054192f, 0.11670244f, 
    -0.04744263f, 0.04812426f, -0.09373459f, 0.04570923f, -0.20510691f, 0.03133338f, 0.07006440f, -0.03503394f, 
    -0.36781645f, -0.25535989f, -0.35732108f, -0.05656754f, 0.17779525f, 0.17020369f, 0.12806886f, 0.04757182f, 
    0.11944607f, -0.17337027f, -0.05866265f, -0.12223930f, -0.06250452f, 0.42095706f, -0.31121141f, -0.00054907f, 
    0.07856213f, -0.04448779f, 0.01128685f, -0.04465872f, -0.09181295f, -0.04871367f, -0.02903104f, 0.01361623f, 
    -0.04124728f, -0.15408577f, 0.05985812f, 0.05923824f, -0.03407778f, 0.13120250f, -0.01643563f, -0.05285966f, 
    0.14968601f, 0.11847348f, -0.01379092f, -0.26847544f, 0.10081973f, 0.07544856f, 0.10315730f, 0.08862527f, 
    0.13313916f, 0.02286456f, 0.08681794f, 0.12927866f, -0.03881444f, -0.06320266f, -0.00792620f, 0.04803115f, 
    -0.20999794f, -0.06731766f, -0.10578953f, 0.03073377f, -0.00693445f, 0.01025004f, 0.02680914f, 0.10210556f, 
    0.15041350f, 0.11851683f, -0.25636265f, 0.09721643f, -0.11585354f, -0.10564027f, 0.05966732f, 0.10192931f, 
    -0.07369975f, 0.02243040f, 0.03217678f, 0.04325196f, 0.08016490f, -0.10691597f, 0.13359678f, 0.24116318f, 
    -0.21523613f, -0.14959475f, 0.22472651f, -0.44080567f, 0.12929517f, 0.09715407f, -0.05418627f, 0.12343726f, 
    0.04614212f, 0.06083684f, 0.14026882f, 0.06943044f, -0.05213064f, -0.06442267f, 0.12557873f, -0.25559601f, 
    0.05351777f, 0.13977766f, -0.12201285f, 0.21788895f, -0.07678594f, 0.07970520f, -0.12158995f, -0.03716768f, 
    0.01507628f, 0.35075939f, -0.12439153f, 0.15832645f, 0.13553883f, -0.04580245f, 0.10700618f, -0.03601769f, 
    0.09854195f, -0.00778101f, 0.01260320f, 0.01857703f, 0.01499820f, -0.27214524f, 0.08350779f, 0.34622645f, 
    0.24436498f, 0.26207122f, 0.02771566f, 0.08788849f, 0.03535695f, 0.02602481f, -0.13475417f, 0.05918416f, 
    0.04420820f, -0.02012196f, 0.26530695f, 0.15105049f, 0.00997587f, 0.08462644f, -0.02584440f, -0.18391667f, 
    0.02081265f, -0.09037813f, -0.01781658f, 0.18900585f, 0.02330822f, -0.01269877f, -0.12796648f, 0.07831480f, 
    0.09651087f, -0.19954632f, 0.18709183f, 0.02925085f, -0.03262439f, 0.20106184f, -0.11322563f, 0.06009768f, 
    -0.01197323f, 0.11148927f, 0.12920837f, 0.20752279f, -0.06690167f, 0.01639420f, -0.13667434f, -0.11288074f, 
    0.00868964f, -0.12052877f, 0.02921318f, -0.05250220f, -0.18783699f, -0.05616399f, -0.02355063f, 0.23719053f, 
    0.07112178f, 0.00805419f, -0.10915884f, -0.06611826f, -0.21645871f, -0.03009686f, -0.03688610f, 0.04956981f, 
    0.07767219f, 0.10878185f, -0.02215373f, 0.35189152f, 0.10072664f, 0.07507736f, -0.01305531f, 0.00422625f, 
    -0.01029399f, -0.13534530f, -0.01160312f, 0.02370142f, 0.03804355f, 0.13029332f, -0.08246780f, 0.11970722f, 
    0.04370126f, -0.06677192f, 0.04298437f, -0.00737173f, -0.09097327f, 0.09539597f, 0.05786355f, -0.07323431f, 
    -0.06920509f, 0.02794339f, -0.05863996f, -0.17184469f, -0.02760989f, 0.04404347f, 0.10773571f, 0.19614737f, 
    -0.01809215f, -0.02285608f, 0.02212134f, 0.00137681f, 0.37505034f, 0.27774960f, 0.20667453f, -0.17407143f, 
    0.02521062f, 0.06402364f, -0.10101555f, 0.00385367f, -0.03340467f, -0.17487122f, 0.03609568f, 0.04775529f, 
    -0.08007544f, -0.07324859f, -0.03597824f, 0.02918920f, 0.05201364f, -0.02097434f, 0.13609131f, -0.03141636f, 
    0.12036494f, -0.02733600f, -0.01532210f, -0.11900511f, -0.20536461f, 0.00870848f, 0.08297394f, 0.30946741f, 
    0.01486904f, 0.06681043f, -0.08568291f, 0.18772528f, -0.00909590f, -0.06906672f, 0.05922357f, -0.03453473f, 
    -0.15683830f, -0.04049275f, 0.21199220f, 0.35051313f, 0.08512190f, 0.00354519f, 0.01701575f, -0.02051604f, 
    0.05844466f, 0.00105521f, -0.03261774f, 0.08107334f, -0.17962104f, -0.06358796f, -0.08109590f, 0.10345257f, 
    -0.13527296f, -0.02797160f, 0.06171176f, 0.10824792f, 0.00039075f, 0.07997854f, 0.13127510f, 0.18111691f, 
    -0.49870345f, 0.32018751f, 0.12630652f, 0.09702492f, -0.01595976f, -0.12724185f, -0.16379024f, 0.06082927f, 
    -0.00459279f, 0.02903885f, 0.06010993f, 0.00960523f, -0.18686342f, 0.10265606f, 0.01162738f, -0.08574641f, 
    0.07274014f, 0.18945025f, -0.06682477f, 0.15238267f, -0.18014482f, 0.05370414f, -0.07598301f, -0.05097042f, 
    0.00181030f, 0.18002026f, 0.21193776f, -0.06511680f, 0.11249477f, 0.06161394f, 0.00010462f, 0.11666536f, 
    0.10701875f, -0.13557325f, 0.04176245f, -0.10614086f, -0.00843230f, 0.21156909f, 0.02014339f, 0.13092020f, 
    0.16330630f, 0.01819770f, 0.11292453f, 0.12229441f, 0.16685191f, -0.15028520f, -0.10489463f, -0.06471525f, 
    0.02055090f, -0.04833023f, -0.04745204f, -0.06558188f, 0.01090542f, -0.00921151f, 0.04209317f, -0.03196315f, 
    -0.01317233f, -0.05506710f, -0.06971448f, 0.02911993f, 0.00941740f, 0.03136980f, 0.05062351f, -0.02427193f, 
    0.03908078f, -0.04366287f, -0.06325080f, 0.02639920f, 0.02383584f, 0.06193247f, 0.01135979f, -0.03009964f, 
    0.05516749f, -0.02933700f, 0.00255109f, -0.00214049f, -0.01007499f, 0.02571598f, -0.06074402f, -0.03365704f, 
    0.05883002f, -0.04496745f, -0.02343355f, 0.01570108f, 0.03296014f, -0.01637434f, -0.06416091f, 0.00729934f, 
    -0.00786575f, -0.00180178f, 0.03248057f, 0.06094517f, 0.01917535f, 0.05212177f, -0.05712471f, -0.07864860f, 
    0.02629283f, 0.05187863f, -0.06900861f, 0.00836364f, -0.01439817f, -0.06001812f, -0.03609806f, -0.02262888f, 
    -0.06630285f, -0.07948879f, -0.04740802f, -0.02110003f, -0.01599760f, -0.05949568f, 0.05294768f, -0.07133351f, 
    0.01602277f, -0.08047771f, -0.08104761f, 0.03153580f, -0.03986640f, -0.03165185f, 0.01307913f, -0.03010406f, 
    -0.04670621f, 0.04281995f, 0.04750949f, -0.06747051f, -0.07582600f, -0.06375799f, 0.01792724f, -0.01779709f, 
    0.03841236f, 0.01372376f, 0.01866823f, -0.02686656f, -0.02698088f, 0.05805218f, 0.01542846f, -0.04072614f, 
    0.05325317f, -0.02739134f, 0.04205203f, -0.04871252f, -0.00869748f, 0.02601435f, 0.03946327f, 0.04761884f, 
    -0.01816026f, -0.01110661f, 0.00826566f, -0.02040634f, -0.02847956f, -0.00790376f, 0.05185101f, 0.05734227f, 
    -0.06598651f, -0.07342813f, 0.01239636f, 0.05761929f, 0.01561259f, 0.04610630f, 0.02167411f, -0.07626767f, 
    0.00778328f, -0.03458087f, 0.04174472f, -0.00736173f, 0.00427774f, -0.02099833f, 0.00316423f, 0.03224376f, 
    -0.06623542f, -0.00938106f, 0.05326377f, 0.01596908f, -0.02256028f, 0.05971331f, 0.05409224f, -0.03892102f, 
    0.01396078f, -0.04968989f, -0.05445540f, 0.01147679f, 0.05532292f, -0.01180905f, 0.02895069f, -0.03025520f, 
    -0.06171824f, 0.05207998f, -0.05939642f, -0.07132607f, -0.06087075f, 0.00847758f, -0.02926100f, -0.01289836f, 
    -0.01373320f, -0.05409775f, 0.03643704f, -0.01021619f, -0.03157486f, -0.01117829f, 0.04007922f, -0.05191660f, 
    -0.02797333f, -0.03227257f, -0.02063939f, -0.06948075f, -0.03112987f, -0.00646492f, 0.05974797f, 0.05743588f, 
    -0.08210907f, 0.00284436f, -0.06914987f, -0.01340770f, -0.04759863f, 0.00212145f, 0.04605765f, 0.03253217f, 
    -0.05531974f, 0.00257161f, -0.06743526f, 0.04467150f, -0.04249694f, -0.03374993f, 0.05517006f, -0.01163778f, 
    0.02140800f, -0.04727390f, -0.00755433f, -0.02044364f, -0.06853118f, -0.07462305f, -0.01579677f, -0.07045370f, 
    0.04193963f, 0.04043760f, 0.06252752f, 0.02756732f, -0.06405981f, 0.00301956f, 0.00621800f, -0.00390714f, 
    -0.03692802f, -0.07715423f, -0.27965897f, 0.26517406f, 0.09844964f, -0.11413221f, -0.05416346f, 0.07917454f, 
    0.05147700f, 0.13761435f, 0.01627474f, 0.01976108f, -0.28074455f, 0.21087421f, -0.15672430f, -0.24113050f, 
    -0.19760363f, 0.02736958f, -0.17510262f, 0.19362263f, -0.16275664f, -0.12530482f, -0.06081432f, 0.10284447f, 
    -0.00244450f, 0.05039418f, 0.40962142f, 0.12151100f, 0.00136668f, 0.01108613f, 0.20562437f, 0.24672879f, 
    0.08238193f, -0.05258106f, -0.02917810f, -0.03041854f, 0.21164626f, 0.00543888f, 0.12571101f, 0.20858034f, 
    0.08217584f, 0.09302101f, 0.19717140f, 0.02272349f, 0.05968441f, -0.04953983f, 0.11873049f, 0.11326818f, 
    0.18343259f, 0.23379935f, -0.01224821f, -0.10004016f, -0.00322072f, -0.15733279f, 0.20900761f, 0.07585677f, 
    -0.02206031f, -0.01971886f, -0.08487590f, -0.05277443f, -0.26700923f, 0.11355125f, -0.19395107f, -0.08886593f, 
    0.09263892f, -0.13292474f, 0.02043815f, -0.13463758f, -0.00724128f, -0.04389051f, -0.11901695f, 0.01725711f, 
    0.04145784f, -0.14710763f, 0.39953551f, -0.33311334f, -0.03753686f, -0.13488999f, -0.04823282f, -0.08022854f, 
    -0.04173100f, 0.03131508f, -0.03753040f, -0.09559745f, 0.14396596f, -0.06399021f, 0.28959396f, 0.05442476f, 
    0.12114983f, 0.03664051f, 0.10294690f, 0.07396004f, -0.04631144f, 0.15878597f, 0.05374773f, -0.14451657f, 
    -0.00839781f, 0.17913456f, -0.25836185f, -0.36213171f, 0.17781799f, -0.03159086f, 0.02531310f, -0.02010678f, 
    -0.17880985f, -0.19387512f, -0.03533053f, 0.21328805f, -0.24424006f, -0.03057900f, 0.14976536f, 0.11197872f, 
    -0.19537292f, 0.00023625f, 0.16877297f, -0.01709357f, 0.01683396f, -0.09253110f, -0.08680629f, 0.01649424f, 
    0.21692292f, 0.08412515f, -0.08831143f, -0.05863887f, -0.01635969f, 0.22209260f, -0.08214884f, -0.11488454f, 
    -0.01855616f, -0.22393399f, 0.10023692f, 0.00166945f, -0.14641625f, 0.02205318f, 0.02797841f, 0.17893443f, 
    0.04355725f, -0.03214274f, -0.01619134f, 0.00626633f, 0.07316582f, 0.10730767f, -0.11776689f, 0.02936493f, 
    0.35570872f, 0.12422881f, 0.27327406f, 0.27538544f, -0.00890562f, 0.11402778f, 0.03644705f, -0.02725331f, 
    0.05967578f, 0.00121535f, -0.01771910f, 0.08310322f, -0.05213618f, -0.18699670f, -0.15967181f, 0.08957776f, 
    -0.33595291f, -0.21342212f, -0.04163999f, -0.12441592f, 0.02460158f, 0.02226000f, 0.03476271f, 0.05063697f, 
    0.04971321f, -0.09417342f, 0.15945339f, -0.23628935f, -0.09106451f, 0.32775348f, -0.02012805f, 0.16695631f, 
    -0.21757281f, -0.17882581f, 0.07955714f, 0.11389632f, -0.24744116f, 0.04137289f, -0.20562445f, -0.17841643f, 
    -0.06273680f, -0.29070529f, -0.03204951f, -0.01370943f, -0.08342588f, -0.01728994f, -0.03876918f, 0.02058374f, 
    -0.04892319f, 0.06733459f, -0.07207160f, 0.10201555f, 0.12111514f, -0.01472055f, -0.01723021f, 0.12370840f, 
    -0.12081042f, 0.02075685f, -0.00060940f, 0.04570612f, 0.07371974f, -0.08250449f, -0.09092682f, -0.19917753f, 
    0.03955817f, 0.00853927f, -0.01986961f, -0.00699782f, 0.10021933f, -0.09728771f, 0.14368916f, 0.08604578f, 
    -0.11144995f, 0.02477481f, 0.19489442f, 0.17500083f, -0.03240394f, -0.01248618f, 0.23232248f, 0.19729686f, 
    0.07546461f, 0.03510701f, 0.03004732f, -0.02356793f, 0.00163690f, -0.09174628f, -0.01797798f, -0.01327863f, 
    0.10324572f, 0.01920355f, 0.11665560f, 0.01725650f, -0.05822483f, 0.08415677f, 0.10962717f, 0.08565699f, 
    0.16471821f, -0.09078531f, -0.10451054f, -0.46351832f, -0.07721235f, -0.03013488f, 0.00211369f, -0.04173980f, 
    0.03168745f, 0.01278171f, 0.06108141f, 0.07513967f, 0.20820542f, 0.41061252f, -0.10089386f, -0.09454626f, 
    -0.08062966f, -0.08364558f, -0.02851412f, -0.06601705f, 0.12781440f, -0.06865630f, 0.05719752f, 0.01070050f, 
    0.06256764f, 0.08877488f, 0.35699460f, -0.06147108f, -0.10230327f, -0.21405947f, -0.19720127f, -0.11235290f, 
    -0.03113677f, 0.05777276f, -0.11173233f, 0.05144172f, 0.57705569f, -0.17643385f, 0.09699907f, 0.10506399f, 
    0.00842188f, 0.01448902f, -0.02777305f, 0.00105415f, 0.06660713f, -0.10486735f, -0.02746798f, 0.14866211f, 
    -0.06535120f, -0.01155449f, -0.08429347f, -0.08840329f, -0.00718746f, -0.02638869f, -0.09721003f, -0.09447430f, 
    -0.08497124f, -0.01490384f, -0.01567619f, -0.05603504f, -0.19588235f, -0.20271118f, 0.00446471f, 0.11974657f, 
    0.02420125f, 0.16127113f, 0.05580423f, -0.08844132f, -0.00180816f, -0.03636601f, -0.00049964f, -0.00287873f, 
    0.45359555f, -0.12666683f, 0.01163074f, 0.15001118f, 0.24450649f, 0.08889676f, 0.06504953f, 0.20489460f, 
    -0.18236752f, -0.04260343f, 0.11978154f, 0.04103177f, 0.07820657f, -0.04836352f, -0.10685741f, -0.23045820f, 
    0.01671863f, -0.07098881f, 0.03011467f, 0.14822043f, 0.01714320f, 0.13917731f, -0.09991010f, -0.03487109f, 
    -0.25076386f, 0.00693222f, -0.08472114f, 0.30812776f, -0.07482158f, 0.06364900f, 0.15624534f, 0.03049775f, 
    0.08553495f, -0.05979230f, -0.00794135f, 0.01980369f, 0.22598502f, 0.27390981f, -0.19534121f, 0.13339975f, 
    -0.04237463f, -0.04015556f, 0.01243270f, -0.02879765f, 0.05548483f, -0.02067557f, 0.02142235f, -0.05066348f, 
    0.02658652f, 0.01488848f, -0.08701022f, 0.22624476f, 0.11782418f, 0.08632521f, -0.06323501f, 0.02179923f, 
    0.00923269f, 0.10235868f, 0.07261020f, 0.04153508f, -0.17173077f, 0.13867836f, 0.04020579f, 0.11931676f, 
    -0.00977937f, -0.04448448f, -0.18016636f, 0.02646978f, -0.05568710f, -0.03292999f, 0.02157407f, -0.00331438f, 
    0.19881101f, 0.26198098f, -0.03273503f, -0.04755535f, -0.13164254f, 0.09708426f, 0.07612628f, 0.06376731f, 
    -0.00357872f, -0.10964260f, -0.14265284f, -0.01882175f, -0.13638350f, 0.02805194f, 0.12916276f, 0.13622084f, 
    -0.07240934f, 0.01230531f, -0.00316205f, -0.03613417f, -0.05000376f, 0.08322577f, -0.11367236f, 0.06644343f, 
    0.07378697f, -0.04872406f, -0.17155296f, -0.04339395f, -0.05825455f, 0.13124761f, -0.12155232f, -0.15087126f, 
    -0.02940414f, -0.02077327f, -0.10316944f, -0.16655086f, 0.03569518f, 0.20277172f, -0.04667895f, -0.07861054f, 
    0.00504964f, 0.13492495f, 0.01667706f, -0.17324597f, 0.01622929f, -0.04267580f, -0.10652161f, 0.01123266f, 
    -0.30026484f, 0.16832639f, 0.28501630f, 0.22128226f, 0.01270211f, 0.05736221f, 0.12729754f, -0.00726932f, 
    0.01478798f, -0.01058227f, -0.12780704f, 0.02177391f, -0.09642825f, -0.23682667f, 0.18242329f, 0.12906058f, 
    -0.06384286f, -0.01511219f, 0.04245135f, 0.00995047f, 0.08159020f, -0.00687805f, 0.10506598f, 0.07707919f, 
    -0.16265385f, -0.19049911f, -0.26522374f, -0.03881377f, 0.05599280f, 0.01669499f, 0.05265773f, 0.10694657f, 
    0.00143468f, -0.03733461f, 0.09047431f, -0.00341853f, 0.09623167f, -0.02222547f, 0.15326180f, 0.11152180f, 
    -0.08151305f, 0.07597803f, 0.04822733f, -0.08506365f, 0.04792011f, -0.01326361f, 0.13578315f, 0.06673671f, 
    0.02179025f, -0.06698149f, 0.05347330f, 0.01107387f, -0.07366940f, -0.14762908f, 0.03650658f, 0.00245295f, 
    -0.02960841f, 0.03484198f, -0.01184339f, 0.06631666f, 0.14508839f, 0.19949110f, -0.12549046f, -0.15509266f, 
    0.25391293f, 0.12449841f, 0.09581351f, 0.09982055f, 0.05452320f, 0.03658531f, -0.03118354f, 0.06472687f, 
    -0.03748389f, 0.17183179f, 0.36042684f, -0.24202687f, 0.09414958f, 0.06097094f, 0.17704226f, 0.06745601f, 
    0.07323427f, -0.01119216f, 0.15362474f, 0.07751214f, 0.03439256f, 0.22703110f, 0.17101838f, -0.07470312f, 
    0.04740852f, 0.01211872f, 0.02231155f, -0.00950655f, 0.09551748f, -0.13395780f, -0.23744547f, 0.06846674f, 
    0.26650098f, 0.03050221f, -0.20167525f, -0.13112471f, 0.11177578f, 0.10254060f, -0.04276291f, -0.12021843f, 
    0.10622156f, 0.12215181f, 0.01327172f, -0.06211415f, -0.13365521f, -0.14972879f, 0.09521304f, -0.15054420f, 
    0.01418303f, 0.14425197f, 0.01540007f, 0.24324559f, 0.06180196f, -0.00237184f, 0.10913374f, -0.01174419f, 
    0.22898988f, -0.21470170f, -0.10402851f, -0.12385914f, 0.03432707f, 0.21211210f, 0.05213020f, -0.04732718f, 
    -0.00243082f, -0.14747132f, -0.10082372f, -0.11765473f, -0.19305097f, -0.23958352f, -0.17591254f, -0.05082395f, 
    0.06108551f, -0.15451999f, -0.12618832f, -0.01162664f, 0.02540170f, -0.00674012f, 0.03574815f, 0.04647958f, 
    -0.01961684f, -0.00120230f, -0.01948759f, -0.01353136f, 0.02145901f, -0.05400971f, -0.05135801f, 0.05145258f, 
    0.04198904f, -0.04319657f, -0.03948388f, -0.07325444f, -0.01359479f, 0.00163165f, -0.05747797f, 0.01780310f, 
    0.01677014f, -0.04259694f, -0.03504311f, 0.01573367f, 0.03206374f, 0.04492471f, 0.03657648f, 0.05295002f, 
    -0.04714882f, -0.08240838f, -0.05178177f, 0.00514734f, 0.02742618f, 0.00744065f, -0.05253857f, 0.03861918f, 
    -0.08743422f, 0.01908537f, 0.04240951f, -0.02885297f, 0.00445515f, 0.02945695f, -0.07225016f, -0.03378880f, 
    -0.03761939f, -0.00353979f, -0.08233894f, 0.00381512f, -0.05586866f, 0.00250094f, -0.09257957f, -0.00661598f, 
    -0.01417063f, 0.05588381f, 0.05369152f, 0.03916185f, -0.05283602f, 0.02668076f, -0.01414734f, -0.01475451f, 
    0.01851322f, -0.04800062f, -0.06157351f, 0.03817889f, 0.00937155f, -0.06018991f, -0.02475686f, -0.02323728f, 
    -0.08360307f, 0.04294553f, 0.00861626f, -0.01557171f, -0.06659659f, -0.07211170f, -0.05136547f, -0.07184076f, 
    -0.00333812f, -0.02679505f, 0.00999719f, -0.03940386f, 0.01983279f, -0.07143503f, -0.03560869f, -0.07005985f, 
    -0.00853165f, 0.00945987f, -0.04590315f, -0.06402496f, -0.02081667f, -0.01203216f, -0.00216778f, 0.00316616f, 
    -0.01323990f, 0.01979510f, 0.06191320f, 0.04604888f, -0.01144646f, -0.05076939f, 0.02551241f, 0.03823041f, 
    -0.01951194f, 0.02378962f, -0.03636753f, -0.04867096f, 0.04591148f, 0.01412434f, -0.08583251f, 0.00636873f, 
    -0.07315803f, -0.06853079f, 0.03795499f, 0.01022319f, 0.03893502f, -0.05658688f, -0.07239351f, 0.07295948f, 
    -0.00023693f, 0.00964537f, -0.02025438f, -0.04157636f, 0.02675088f, -0.05009958f, 0.00981344f, -0.01728946f, 
    0.04531007f, -0.01020009f, -0.03514089f, 0.05459657f, -0.06679218f, 0.04976527f, -0.04493315f, 0.02726829f, 
    -0.02798656f, -0.05217005f, 0.05707594f, 0.01314178f, -0.06085335f, -0.00160785f, -0.07838689f, 0.00546227f, 
    0.01008323f, -0.03283298f, 0.05301774f, -0.06995635f, 0.02867360f, 0.06689259f, 0.01826385f, -0.08316759f, 
    -0.01908700f, -0.08042960f, 0.02746712f, 0.04424917f, 0.02348718f, 0.02925975f, -0.07223230f, 0.05478638f, 
    -0.00562232f, -0.01509138f, 0.03037228f, -0.02095404f, -0.08521603f, -0.07359867f, -0.05541696f, -0.01666825f, 
    0.05000153f, 0.04771958f, -0.00720886f, 0.02313652f, -0.02948086f, 0.04459343f, 0.00191754f, 0.00723781f, 
    0.01606126f, -0.09118876f, -0.00492724f, -0.06845243f, 0.05491460f, -0.08566205f, 0.01809603f, -0.05181576f, 
    -0.03054422f, -0.04943513f, 0.05529936f, 0.04277089f, -0.05740326f, -0.02760091f, -0.01911703f, -0.06020983f, 
    -0.09564700f, 0.00503386f, 0.05496073f, -0.05414580f, 0.04677325f, 0.02798860f, 0.01182652f, -0.01305467f, 
    0.01858493f, 0.01821902f, 0.03553598f, 0.04438950f, 0.03887867f, -0.00662436f, -0.01235404f, -0.05343328f, 
    0.01244818f, -0.03979587f, 0.06021626f, 0.03702453f, 0.04944501f, -0.05413465f, 0.03312679f, 0.01622044f, 
    -0.02025883f, 0.06252489f, -0.01370457f, -0.00835276f, -0.06170586f, 0.04362297f, -0.04665967f, -0.03272262f, 
    0.06282365f, -0.06853145f, 0.02391445f, -0.01702683f, -0.03287372f, -0.05117388f, -0.05955285f, -0.00179585f, 
    0.01880186f, -0.06047742f, 0.02756161f, -0.04692399f, -0.06394736f, -0.06140655f, -0.04889737f, -0.02926026f, 
    0.05208993f, 0.04169547f, -0.07093396f, -0.06250590f, 0.05691008f, -0.01203325f, -0.02358702f, 0.01773197f, 
    0.02413459f, -0.02159530f, -0.05778284f, 0.01071584f, 0.01575653f, -0.03856947f, 0.05785283f, -0.06122572f, 
    -0.06529762f, -0.01601972f, -0.04450383f, -0.04507378f, -0.06510690f, 0.02001849f, 0.00942620f, 0.06128903f, 
    -0.00955554f, 0.02103771f, -0.03683666f, 0.00425914f, 0.06100412f, -0.04572441f, -0.01464049f, 0.01478363f, 
    -0.07127703f, -0.06188147f, -0.01137086f, 0.03526221f, -0.00854394f, -0.02872464f, -0.03826958f, -0.05364716f, 
    0.00690768f, -0.05608858f, -0.06718755f, -0.05451190f, -0.03373090f, -0.00778064f, -0.02655318f, 0.01339389f, 
    0.02259433f, -0.03023847f, -0.01409113f, -0.05765752f, 0.02343177f, -0.07062707f, 0.05815131f, -0.04124026f, 
    -0.02147329f, 0.01904255f, -0.05082280f, 0.03398122f, 0.05377678f, 0.05521695f, -0.05113575f, -0.05003204f, 
    0.01265181f, 0.06252778f, -0.05636531f, -0.01778892f, -0.02733673f, -0.01500349f, -0.04072864f, -0.01236374f, 
    0.05586935f, -0.03770120f, -0.00686457f, -0.02980708f, 0.06717983f, -0.04884760f, -0.05781082f, -0.05221120f, 
    0.01622983f, 0.01163356f, -0.06809758f, -0.00685561f, -0.02061996f, 0.05857725f, -0.05067281f, 0.02262640f, 
    -0.06854151f, 0.00308750f, 0.00133043f, 0.06169217f, 0.05151199f, -0.06677478f, -0.00277109f, 0.01356803f, 
    -0.02400279f, 0.07186703f, -0.03960032f, -0.00376864f, 0.06681447f, 0.01184155f, 0.04302225f, -0.05202939f, 
    -0.06135979f, 0.00135216f, 0.00559344f, -0.01093793f, 0.04546144f, 0.06284054f, -0.05667130f, -0.04650751f, 
    -0.04411482f, 0.05946555f, -0.02349109f, -0.02029019f, -0.06602209f, 0.00276594f, -0.02260849f, 0.04653139f, 
    -0.02928825f, 0.05461711f, -0.04567883f, 0.06530718f, 0.01820323f, 0.02414174f, -0.00557224f, -0.06797258f, 
    -0.05198324f, -0.00609571f, 0.01344379f, -0.05105636f, -0.02633290f, 0.01395930f, 0.03404348f, 0.01764746f, 
    -0.01692943f, 0.00693237f, -0.02607612f, 0.05811835f, 0.00302034f, -0.02790340f, -0.00451633f, 0.04568773f, 
    0.06201826f, -0.01933180f, -0.00575189f, -0.00160329f, -0.04160807f, 0.01395692f, -0.04615185f, -0.02480262f, 
    -0.15307443f, 0.05966533f, -0.06805316f, -0.15336892f, 0.18512501f, 0.08325496f, 0.11506307f, -0.02289577f, 
    -0.03637572f, -0.03858668f, -0.02123716f, -0.06780621f, 0.01120013f, 0.17534254f, -0.00843741f, 0.17230655f, 
    0.13024224f, -0.00727474f, -0.08895763f, -0.11218612f, 0.18680522f, 0.09728513f, 0.29960009f, 0.09445761f, 
    -0.10609415f, 0.11261570f, 0.00410969f, -0.30073544f, 0.01783859f, 0.03823397f, 0.09605843f, -0.02271420f, 
    0.03118026f, -0.03562038f, 0.06352054f, -0.07785416f, -0.08430205f, 0.04599013f, 0.09698691f, -0.10793584f, 
    0.06901213f, -0.02820471f, 0.00011420f, 0.14479829f, 0.13943112f, -0.04277563f, -0.02662022f, 0.02804366f, 
    -0.28268918f, -0.36593822f, 0.07569582f, -0.00296284f, -0.08915690f, -0.11398141f, -0.06605899f, -0.02499911f, 
    0.07334684f, 0.22306545f, 0.11039796f, 0.11406174f, 0.17335387f, 0.01560288f, 0.19004254f, 0.09888487f, 
    0.08434543f, 0.04546225f, 0.04372871f, -0.04669331f, 0.07079121f, 0.01804773f, 0.00947565f, 0.14736156f, 
    0.13898218f, -0.03138830f, -0.02668887f, 0.24302213f, -0.10291959f, -0.11977591f, -0.19242011f, -0.11699227f, 
    -0.10870519f, 0.00713624f, -0.13618958f, 0.04800859f, -0.01113659f, -0.01850321f, 0.04868694f, 0.20230582f, 
    0.13980688f, -0.00604112f, 0.04030780f, -0.02383980f, 0.17253566f, 0.15794978f, -0.12524374f, 0.20809917f, 
    -0.02696068f, -0.10902350f, -0.03352666f, 0.07467070f, 0.01619399f, -0.07845826f, -0.15102820f, -0.05785232f, 
    -0.04411744f, 0.03646929f, 0.12042452f, -0.02760698f, -0.04429140f, 0.02417607f, -0.06198718f, -0.13742800f, 
    0.08944912f, 0.11450218f, -0.10495688f, -0.33353475f, -0.06553648f, -0.10762817f, -0.00641657f, 0.04266182f, 
    0.04112460f, -0.09967265f, 0.01341281f, -0.02582292f, 0.18514711f, -0.00345893f, 0.16116211f, 0.37266484f, 
    -0.10459111f, 0.00647987f, 0.17591541f, 0.11349030f, 0.03325752f, 0.10565069f, 0.16254102f, -0.20711245f, 
    0.02545874f, -0.01758236f, 0.11513178f, 0.02130674f, 0.04262791f, -0.11715822f, -0.12846468f, -0.17540653f, 
    0.14518915f, -0.10496632f, -0.05753678f, -0.11604363f, -0.11264463f, 0.09164565f, 0.09533760f, 0.06548722f, 
    0.05366527f, -0.00501824f, 0.07620253f, -0.07796241f, 0.22413316f, -0.07743733f, -0.05185874f, 0.05108825f, 
    0.07021866f, -0.01758728f, 0.20510127f, 0.12115171f, 0.17514330f, -0.01949494f, 0.02817349f, -0.00408477f, 
    0.02955555f, -0.01326253f, -0.15815832f, -0.13613991f, 0.00493146f, -0.12474086f, 0.15125439f, -0.07024900f, 
    0.06409553f, 0.10198826f, -0.00660526f, 0.12649134f, -0.24635550f, -0.06727637f, -0.03390117f, -0.16559617f, 
    -0.07870276f, -0.00358833f, -0.03778933f, -0.06188615f, -0.10717539f, 0.03699218f, 0.04630074f, -0.04990537f, 
    0.19979797f, 0.00774434f, 0.04562154f, -0.05802847f, 0.14573176f, 0.05084698f, 0.15932190f, 0.00365320f, 
    0.06149969f, -0.04237352f, -0.07548434f, -0.01314240f, -0.11978354f, 0.24895571f, 0.02086483f, 0.11271754f, 
    0.15279007f, 0.03975738f, -0.21728159f, -0.26306242f, 0.04327790f, 0.03329068f, -0.01057906f, 0.06211489f, 
    -0.06390654f, 0.09546477f, -0.12681073f, -0.15282983f, 0.01374202f, 0.11752563f, 0.06082620f, 0.04752183f, 
    -0.05726508f, 0.08287893f, -0.07961828f, -0.01594505f, 0.02525792f, -0.03709310f, -0.05780192f, 0.03414327f, 
    -0.04991354f, 0.04167272f, 0.12942190f, 0.10644111f, 0.19283943f, 0.11255740f, -0.07423257f, 0.00497324f, 
    -0.21107991f, -0.28780481f, 0.03838781f, 0.12309250f, -0.03184792f, -0.06074483f, 0.03043053f, -0.16543506f, 
    0.19708893f, 0.06945563f, 0.05290564f, 0.06406967f, 0.22677134f, -0.38418290f, 0.24889736f, 0.16464996f, 
    -0.00990724f, 0.09391142f, -0.00720503f, -0.11252976f, 0.11813193f, 0.07889933f, -0.19601956f, -0.12790945f, 
    0.21799748f, -0.10415594f, -0.13854988f, 0.12341158f, -0.02187467f, 0.05850782f, -0.05164972f, 0.12438536f, 
    -0.22882961f, -0.08533482f, -0.04160518f, -0.05113643f, -0.25300685f, 0.13580343f, 0.15934579f, 0.12197319f, 
    0.03672750f, 0.10776264f, 0.25051910f, 0.09254901f, 0.12030713f, 0.18460727f, -0.14319433f, 0.17567553f, 
    -0.11215560f, -0.07910813f, -0.13226981f, 0.04122467f, -0.06392071f, 0.02314201f, -0.04944477f, -0.01886918f, 
    0.15289310f, 0.12294506f, 0.15181509f, 0.02627710f, 0.20314784f, 0.26213375f, 0.11371541f, -0.01160036f, 
    0.13918909f, 0.08586782f, 0.03485701f, -0.03647071f, -0.02280582f, 0.11932158f, -0.05121419f, -0.00794831f, 
    -0.18255962f, 0.08526149f, 0.26106149f, 0.05299323f, 0.02848593f, 0.02227200f, 0.08710162f, 0.17416736f, 
    0.01951933f, -0.05363570f, 0.11996725f, 0.05453672f, -0.16268472f, 0.17822884f, 0.08406959f, -0.05220539f, 
    -0.01357573f, 0.10085791f, 0.09451504f, 0.02977553f, -0.04958773f, -0.04991543f, -0.21312632f, -0.29741257f, 
    0.27962932f, -0.18490097f, -0.10675991f, -0.32338849f, 0.02353580f, 0.00938337f, -0.09317163f, 0.19192576f, 
    0.07166765f, -0.08708728f, 0.02422772f, -0.16494232f, 0.22877277f, -0.40182278f, 0.23620082f, -0.14687803f, 
    -0.06170473f, 0.09647613f, 0.01659524f, 0.07331506f, -0.03806071f, -0.04387168f, 0.05845885f, 0.02681795f, 
    0.00012278f, -0.19742067f, -0.00203718f, -0.19104856f, 0.01747122f, -0.02706950f, 0.18611221f, 0.10157843f, 
    0.03454013f, -0.01334404f, -0.01732037f, 0.07518958f, -0.11812027f, -0.13102108f, -0.07587698f, -0.41047099f, 
    -0.09743325f, -0.08478044f, 0.15784708f, -0.06234842f, -0.18564074f, 0.05894599f, -0.15416811f, -0.18449020f, 
    -0.03839717f, -0.01223353f, 0.03694396f, -0.02083355f, -0.04867854f, -0.09973988f, -0.05531971f, -0.06434334f, 
    -0.03719577f, 0.01661514f, 0.02889490f, -0.10089162f, -0.08234812f, -0.05987700f, 0.00330950f, 0.02014947f, 
    0.01748469f, -0.02496954f, -0.00968596f, -0.02649064f, 0.06308076f, 0.04097671f, 0.03254753f, -0.06537238f, 
    0.03524557f, -0.03740358f, -0.06285483f, -0.01982547f, -0.00390542f, -0.03280254f, -0.04538788f, -0.03661510f, 
    0.00544565f, -0.08179997f, -0.05086971f, -0.04485188f, 0.03069043f, -0.05571061f, 0.06868234f, 0.03992388f, 
    -0.04271718f, -0.06173735f, -0.07215173f, -0.09446485f, -0.09980937f, -0.09669707f, -0.04590942f, -0.03007677f, 
    0.02166196f, -0.04477238f, -0.06380026f, -0.00126189f, -0.02576151f, 0.05034135f, 0.00929061f, 0.03885734f, 
    -0.06279662f, -0.06619505f, 0.00143095f, -0.00413720f, 0.00703445f, -0.03422569f, -0.07502491f, -0.07578092f, 
    0.01466124f, -0.08226191f, 0.01301883f, 0.00742636f, -0.04131142f, -0.02081606f, -0.07637745f, 0.03104179f, 
    -0.08039642f, 0.02488356f, 0.03009489f, -0.00803537f, 0.01626644f, -0.08811240f, 0.00745477f, 0.04043438f, 
    0.01796577f, 0.01677824f, 0.03856608f, -0.01897602f, -0.02191808f, 0.00389330f, -0.04690479f, -0.05724405f, 
    0.03971393f, -0.09088502f, 0.00402509f, -0.05117321f, -0.05129300f, 0.00880310f, -0.04251424f, -0.06611588f, 
    -0.07207057f, 0.01722430f, -0.03329458f, -0.07178718f, 0.02223485f, 0.03281883f, 0.03052376f, -0.01211620f, 
    0.04401153f, 0.02456538f, -0.06157426f, -0.05439087f, -0.03384385f, -0.03322766f, -0.06430386f, 0.05973575f, 
    -0.07476380f, -0.08834983f, -0.01773568f, 0.00850460f, -0.06096498f, -0.01570040f, -0.07391934f, -0.10360199f, 
    -0.03943673f, -0.05519426f, -0.07155463f, 0.02981708f, 0.00349818f, -0.00608784f, -0.06776337f, -0.08608406f, 
    -0.05736711f, -0.06653295f, -0.08858670f, 0.00723259f, -0.01657656f, 0.00507448f, 0.01987059f, -0.01615900f, 
    0.02067098f, 0.03665940f, -0.01570484f, -0.03218709f, -0.08200997f, -0.08224931f, -0.05495700f, -0.06671082f, 
    -0.00817320f, -0.03415120f, -0.01068392f, -0.01099584f, -0.04851959f, -0.02869898f, -0.09420096f, -0.01908780f, 
    -0.02748594f, -0.07269176f, -0.00912413f, -0.06874780f, -0.07104721f, -0.05548659f, 0.01397582f, 0.03825342f, 
    -0.02366927f, 0.03999710f, -0.04320094f, -0.02286363f, -0.04966024f, -0.01608086f, 0.02146195f, 0.00763979f, 
    -0.01316652f, -0.00692409f, -0.01122671f, -0.04546081f, 0.03964158f, -0.01330339f, -0.04495058f, -0.04302505f, 
    -0.03418067f, 0.03388870f, -0.07535870f, -0.08048064f, 0.02676399f, 0.03477485f, 0.04560520f, -0.04286255f, 
    0.03793624f, -0.08389362f, -0.05264790f, -0.04031437f, 0.02740196f, -0.08026369f, 0.02687295f, -0.06603195f, 
    -0.09183819f, -0.02512076f, 0.00326875f, -0.08002620f, 0.09579539f, -0.05634376f, 0.11269052f, 0.11046133f, 
    -0.12368305f, 0.02407141f, 0.04969693f, 0.11846852f, 0.03240649f, 0.08559074f, -0.10584984f, -0.10146017f, 
    -0.05745547f, 0.05051470f, 0.02708352f, 0.05880199f, 0.15847676f, -0.10244403f, 0.14450417f, -0.05100263f, 
    -0.03405901f, 0.11794680f, 0.12524034f, 0.14992429f, 0.05163603f, 0.09469872f, 0.18993805f, 0.16488343f, 
    -0.04164624f, -0.01767434f, 0.12512191f, 0.04178462f, 0.04856198f, 0.17371260f, 0.12655526f, -0.17376700f, 
    0.17978673f, -0.05549835f, 0.08185659f, -0.01435935f, -0.02076968f, 0.07483952f, 0.00003410f, 0.01752987f, 
    -0.04394278f, -0.17371528f, -0.08951304f, -0.37322757f, 0.02479171f, 0.10296364f, -0.10327140f, -0.02854737f, 
    -0.02371521f, 0.18190864f, -0.02576257f, -0.02950502f, 0.05535366f, 0.26531100f, -0.09101020f, -0.14513084f, 
    -0.01871121f, -0.05989181f, 0.01189403f, -0.05327301f, 0.01234448f, -0.12727521f, -0.07978787f, 0.12407633f, 
    0.24446629f, 0.06592685f, 0.29533449f, 0.04852702f, -0.08684809f, -0.06209591f, -0.16740087f, -0.14149593f, 
    -0.00594015f, 0.06903764f, -0.07126202f, 0.02480067f, 0.13378663f, -0.29301104f, 0.09678687f, 0.04742402f, 
    0.00172261f, -0.04332729f, -0.10466892f, -0.03347285f, 0.07234780f, 0.07367882f, 0.08003081f, -0.01482366f, 
    -0.20301838f, -0.03159534f, -0.05353342f, -0.04526483f, -0.07741562f, -0.01298464f, -0.04476044f, -0.12300386f, 
    -0.11024380f, -0.04312262f, -0.06537143f, -0.06977480f, 0.06738339f, -0.11834544f, -0.02275368f, -0.03560966f, 
    0.00176254f, 0.01021642f, -0.02219167f, -0.23815507f, -0.01628829f, -0.14262128f, -0.13717522f, -0.02107573f, 
    0.19865483f, 0.03412097f, -0.09841940f, 0.07044379f, 0.16050521f, 0.04870197f, -0.00596854f, -0.00857447f, 
    -0.06468489f, 0.04284762f, 0.02870079f, -0.15664344f, 0.35710427f, -0.11742309f, 0.00817067f, -0.17172630f, 
    0.11778204f, 0.02945344f, -0.05422812f, -0.01507666f, -0.07831100f, 0.15155722f, 0.00074089f, 0.06340390f, 
    -0.07218052f, 0.04803834f, -0.24439949f, 0.27616206f, -0.00097760f, 0.00602820f, 0.27254570f, -0.02473753f, 
    -0.02538042f, 0.08263678f, 0.04869844f, 0.10958921f, 0.05183464f, 0.49654451f, -0.25505704f, 0.17397714f, 
    0.06924488f, -0.09237838f, 0.21189417f, -0.02365714f, 0.17404640f, 0.16360416f, 0.00156161f, 0.03794469f, 
    0.01659942f, -0.02102073f, 0.01267350f, 0.11245146f, 0.12220070f, -0.01586601f, 0.07423363f, -0.04754495f, 
    0.05572850f, 0.23428839f, -0.00278967f, 0.01527738f, 0.04494167f, 0.14516756f, -0.06113999f, 0.02867673f, 
    -0.03232646f, -0.02556090f, -0.00950728f, -0.06326810f, -0.02077908f, 0.02743020f, 0.04151158f, -0.00482183f, 
    0.29693064f, 0.00582479f, 0.21289779f, -0.22350508f, 0.11332449f, 0.09560572f, -0.08033661f, 0.04643793f, 
    0.17703523f, 0.10596214f, 0.08644807f, 0.15032904f, 0.11905932f, -0.23419426f, 0.25518337f, -0.12160841f, 
    0.19053347f, 0.13521163f, 0.04841347f, -0.11414459f, -0.08086723f, 0.22872289f, -0.07320171f, 0.16502644f, 
    -0.08510175f, 0.18152121f, -0.06305531f, -0.10870163f, -0.12051927f, -0.13107890f, -0.09099724f, -0.14804755f, 
    -0.17124188f, -0.16170391f, 0.03472842f, -0.37906766f, 0.13558148f, -0.05704932f, 0.20961946f, 0.09572202f, 
    -0.21948424f, -0.05300423f, -0.00925459f, -0.05912713f, 0.00986211f, -0.01704520f, -0.28821999f, -0.05980038f, 
    0.37810361f, 0.02275384f, 0.42940089f, 0.11469457f, -0.31837279f, -0.01610604f, -0.06544368f, 0.01811674f, 
    0.15897539f, 0.14113984f, 0.09586263f, 0.13203758f, 0.21491462f, 0.00763496f, 0.08385464f, 0.10036603f, 
    -0.22367734f, 0.10513343f, -0.05663006f, -0.18135977f, -0.18736954f, 0.21310961f, 0.06778269f, 0.01583901f, 
    -0.26351470f, -0.23813969f, -0.02755959f, 0.06288083f, 0.00698737f, -0.14420898f, 0.15396352f, -0.08853740f, 
    0.11754356f, -0.27123472f, 0.01774471f, 0.04462504f, 0.07478087f, 0.16290011f, -0.07928601f, 0.11477907f, 
    -0.02481080f, -0.00768629f, 0.25633311f, 0.00024268f, -0.00159950f, 0.05697418f, -0.07340556f, 0.07162156f, 
    0.05804883f, -0.20747058f, 0.05088764f, 0.01642580f, -0.03261383f, 0.05696618f, -0.01301951f, 0.09767211f, 
    0.12690790f, -0.04539289f, -0.20728254f, -0.46299645f, -0.00086956f, 0.02024811f, 0.07498883f, -0.10755116f, 
    0.03339096f, 0.03468005f, 0.11265266f, 0.07872487f, 0.04176119f, -0.05596275f, -0.05215766f, 0.04562962f, 
    -0.09053256f, -0.22218908f, 0.01247927f, -0.09239747f, 0.06232481f, 0.02060001f, 0.14572853f, 0.03650342f, 
    0.17342621f, -0.03728984f, -0.10442397f, 0.10125699f, -0.16387016f, 0.02282719f, 0.11635236f, -0.00006468f, 
    0.00597466f, 0.02558003f, 0.08058226f, 0.15629266f, 0.13512394f, -0.07042976f, 0.10239218f, 0.18792206f, 
    0.04083525f, 0.05412566f, 0.28500140f, -0.07982211f, -0.11156140f, -0.18795510f, -0.12681644f, -0.02232213f, 
    0.16978931f, 0.11115767f, 0.14717539f, 0.13685080f, 0.12492327f, 0.01400074f, 0.10670421f, -0.24583079f, 
    0.20049462f, -0.09295868f, -0.18560912f, 0.01067197f, -0.10672139f, -0.03522727f, 0.00001798f, 0.00694971f, 
    0.07576396f, 0.19160962f, -0.09831114f, 0.05634600f, 0.23425218f, -0.16223633f, 0.19762853f, 0.08494826f, 
    0.00790921f, -0.01734323f, -0.33103827f, -0.11455288f, -0.34255126f, -0.16219874f, 0.02712817f, 0.40702593f, 
    0.04975633f, 0.16015394f, 0.09067573f, -0.15288763f, -0.01351768f, -0.23307963f, -0.18787426f, 0.13846010f, 
    -0.46476349f, -0.80559182f, 0.00121120f, -0.04691838f, 0.29762015f, 0.15761685f, 0.09755478f, -0.04791310f, 
    0.13604122f, 0.06155850f, 0.39327797f, -0.00799321f, 0.13453704f, 0.18789120f, 0.08572064f, 0.06041931f, 
    -0.07440465f, -0.05715251f, 0.00354357f, -0.10703231f, -0.03781993f, 0.07760332f, -0.03714726f, -0.02668656f, 
    -0.19753517f, -0.27635705f, -0.31251261f, 0.08939116f, 0.24917719f, 0.02885528f, 0.02221649f, 0.10992613f, 
    -0.07585911f, -0.05504063f, 0.00471205f, 0.01750158f, -0.29774120f, -0.19044614f, -0.54022378f, -0.27835265f, 
    0.17695276f, -0.08306190f, -0.18981974f, 0.01572137f, -0.08109210f, -0.08914243f, 0.01786043f, 0.14040858f, 
    0.20569636f, -0.01210834f, 0.01146275f, 0.01939823f, -0.09603679f, -0.05237888f, -0.00152361f, -0.16464518f, 
    -0.00617922f, 0.08662274f, -0.09252799f, 0.00193169f, 0.40154621f, 0.24143036f, 0.23396634f, 0.09726643f, 
    -0.05739793f, 0.02634446f, 0.02766526f, -0.09377376f, 0.02232597f, 0.00413502f, -0.12319509f, 0.05324832f, 
    0.41187081f, 0.28242749f, 0.15458545f, 0.26153377f, 0.04126781f, 0.00956001f, 0.02129607f, -0.01430940f, 
    -0.12223277f, -0.09300029f, -0.06063872f, -0.06386795f, -0.29234117f, -0.07826713f, 0.06432815f, -0.13875055f, 
    -0.03608749f, 0.08528996f, -0.01640790f, 0.12044982f, 0.17236300f, 0.09763648f, 0.23366724f, 0.13053983f, 
    -0.05563928f, 0.06321198f, 0.01486868f, 0.05764475f, -0.02858824f, 0.04980900f, -0.04688642f, -0.18653539f, 
    -0.10581739f, -0.05258353f, -0.19849904f, -0.09759801f, -0.03841252f, -0.13512668f, -0.32208309f, -0.01347187f, 
    -0.00170317f, 0.06759872f, 0.09666365f, 0.03596517f, 0.00757365f, -0.01273074f, -0.04061683f, 0.00090834f, 
    -0.46837646f, 0.00609053f, -0.06266046f, 0.08326622f, -0.13000543f, 0.16769636f, 0.19316462f, -0.12597191f, 
    -0.02510973f, 0.14036871f, -0.03680650f, -0.15521425f, -0.14743462f, -0.51701903f, -0.40536135f, -0.47468156f, 
    -0.00467805f, 0.00227062f, -0.04595764f, 0.02118353f, -0.01526789f, 0.14451064f, 0.16584700f, 0.13768388f, 
    -0.14600420f, -0.17171434f, -0.39941972f, -0.27529436f, -0.11411113f, -0.10144449f, 0.06634777f, 0.19716550f, 
    0.30702412f, 0.11183684f, 0.11928996f, 0.11479477f, 0.08293121f, 0.07739248f, 0.10879717f, 0.03645951f, 
    0.11519887f, -0.00137519f, -0.09784755f, -0.02923593f, 0.22116379f, 0.03137134f, 0.07463837f, -0.02859664f, 
    0.24073689f, 0.01581704f, 0.12686855f, -0.03864391f, -0.09609590f, 0.08327521f, 0.13078351f, -0.00953854f, 
    -0.09521081f, -0.10015285f, -0.02623417f, 0.02185695f, 0.28017530f, 0.21927223f, 0.06224937f, 0.08912893f, 
    0.24609908f, 0.20908162f, 0.12502453f, 0.00748839f, -0.11631516f, -0.02794605f, -0.02732595f, -0.02876550f, 
    -0.25377023f, 0.06265111f, -0.31439441f, 0.08911943f, 0.08240845f, 0.04738801f, -0.04013215f, 0.15062757f, 
    0.07477222f, 0.06304258f, 0.09548246f, 0.00304943f, -0.06902781f, 0.14002405f, -0.01155098f, -0.07400240f, 
    -0.11696981f, 0.12956558f, -0.09146562f, -0.05221522f, 0.19755022f, -0.06892165f, 0.17375973f, 0.01307328f, 
    0.06950399f, -0.11501615f, 0.22372119f, 0.05034102f, 0.09054783f, -0.03029641f, 0.17831054f, 0.30631134f, 
    -0.03119020f, -0.05791689f, 0.05734527f, 0.04119053f, 0.05715634f, -0.00397650f, 0.13824873f, -0.02889070f, 
    0.11426446f, 0.15132895f, 0.06612105f, 0.09102866f, 0.07594693f, 0.00878041f, 0.01383842f, 0.03328173f, 
    0.02899996f, 0.33640197f, 0.00811188f, -0.02506395f, -0.07117417f, -0.03965687f, -0.12684564f, 0.01861901f, 
    -0.00068494f, 0.02450437f, 0.08886176f, 0.10209443f, -0.08585533f, 0.30157241f, 0.08559465f, 0.07977791f, 
    -0.00554782f, 0.07300518f, -0.08489208f, 0.03899033f, 0.13914686f, 0.00477619f, 0.03553420f, 0.08348767f, 
    0.15831973f, 0.00627616f, 0.15127602f, -0.05935423f, -0.11855002f, -0.08570889f, -0.06406721f, -0.10247239f, 
    -0.00615715f, 0.04870722f, -0.07866623f, 0.01840136f, -0.06593472f, -0.07237072f, 0.33724567f, -0.02649941f, 
    0.13608900f, -0.01210229f, 0.14266175f, 0.14304706f, 0.09060547f, 0.20844328f, -0.03278164f, 0.01913240f, 
    -0.12438906f, -0.00903469f, -0.14197870f, -0.14804794f, -0.03395860f, 0.03412072f, -0.03500197f, -0.03802558f, 
    -0.12847930f, 0.04538465f, 0.12796085f, 0.16716407f, -0.32847798f, -0.13027328f, -0.17448412f, -0.19997336f, 
    -0.07028370f, -0.14325342f, -0.02319049f, 0.00438336f, 0.00790071f, 0.01893059f, 0.02931493f, -0.04834520f, 
    0.05328144f, -0.08261599f, -0.12550500f, 0.01796071f, -0.05761253f, 0.24036554f, -0.12718186f, 0.00692434f, 
    0.08769736f, -0.05884967f, 0.21438892f, -0.04750820f, 0.03396469f, 0.10198207f, -0.02413968f, 0.13808994f, 
    0.09299868f, -0.05054519f, -0.04670155f, -0.10390016f, 0.02935716f, 0.16686097f, -0.04929627f, -0.15538248f, 
    0.23415342f, -0.01601596f, 0.09554216f, 0.01645383f, -0.03630230f, -0.02681827f, 0.04306355f, -0.03549501f, 
    -0.02348435f, 0.12595570f, -0.04899649f, 0.02608379f, -0.08457947f, -0.10555589f, 0.00313140f, 0.05783199f, 
    -0.00588974f, 0.00481034f, 0.04035823f, -0.06493769f, 0.20775923f, 0.01914238f, 0.14755321f, 0.04613756f, 
    -0.09197484f, -0.11599094f, 0.12161066f, -0.17665400f, 0.06861661f, 0.11108419f, 0.03919826f, 0.13779591f, 
    0.05024304f, -0.03024221f, 0.00150754f, 0.04056758f, 0.03426084f, -0.04029381f, -0.26450115f, -0.29189935f, 
    -0.26778132f, -0.11503536f, -0.05628828f, -0.01978123f, -0.12308402f, -0.06076894f, -0.02442844f, -0.12643573f, 
    -0.23529817f, 0.30614313f, 0.13348985f, 0.10232373f, -0.05773812f, -0.09093178f, 0.18128331f, 0.12970246f, 
    0.13938512f, 0.02006580f, -0.27463919f, -0.03923829f, -0.03813086f, 0.14273956f, 0.03934905f, 0.08357485f, 
    -0.01137166f, -0.09506492f, 0.03658973f, -0.09444945f, -0.01290992f, 0.18352377f, 0.23733433f, 0.04346671f, 
    0.09651481f, -0.14778976f, -0.08085287f, -0.17101058f, -0.01495008f, 0.30624032f, -0.04481669f, -0.06255018f, 
    0.13064837f, 0.05824910f, -0.03782816f, -0.09747144f, -0.24514267f, 0.30151448f, -0.01734200f, 0.01331943f, 
    0.07573710f, 0.09186131f, -0.05737936f, -0.08789349f, 0.13398154f, 0.04384712f, 0.08355810f, 0.04679940f, 
    -0.29801455f, 0.14898494f, 0.06336777f, 0.04692332f, -0.01526492f, -0.10852844f, 0.05419450f, -0.02073611f, 
    0.04975820f, -0.05324820f, 0.01081793f, 0.16905306f, 0.11296187f, -0.12110549f, 0.29612470f, 0.10567451f, 
    -0.02997736f, -0.07698629f, 0.01797933f, 0.05670910f, 0.03982190f, 0.15961249f, -0.01882763f, 0.14107460f, 
    0.07045563f, -0.02019543f, -0.02505540f, 0.10749590f, -0.09282079f, -0.09141462f, -0.01609947f, 0.08474710f, 
    -0.06353913f, -0.07181989f, 0.07416912f, 0.00277115f, -0.04405103f, 0.09224536f, 0.08616650f, 0.03159060f, 
    0.12272895f, 0.03440407f, 0.07880042f, -0.06292280f, 0.07358306f, 0.09420561f, -0.26979360f, 0.25624746f, 
    0.01347568f, -0.05630150f, 0.07570636f, 0.10520873f, -0.03132179f, -0.02458234f, -0.03590635f, -0.10725370f, 
    -0.05658702f, 0.07654810f, -0.03638406f, 0.05853899f, -0.04292526f, 0.31828144f, 0.06210529f, 0.04247490f, 
    0.26326242f, 0.19119215f, -0.06041422f, 0.04119197f, 0.03975939f, 0.05685759f, 0.03655753f, 0.04408851f, 
    -0.62112945f, 0.12733911f, 0.46478751f, -0.08250997f, -0.14036758f, -0.00078271f, -0.12183770f, 0.21042395f, 
    -0.07232044f, 0.09731002f, 0.14554754f, 0.06741093f, -0.23640670f, 0.18270543f, 0.06195262f, 0.02588719f, 
    -0.12994958f, -0.20443623f, -0.02871875f, -0.12704939f, 0.09445007f, -0.02673611f, -0.15377212f, -0.12539954f, 
    0.23476562f, -0.13982970f, -0.28000495f, -0.33188471f, 0.07541110f, 0.04428732f, -0.06688731f, -0.04593337f, 
    0.03326311f, 0.00295518f, 0.05371726f, -0.09930111f, -0.13230799f, -0.03912283f, 0.06497161f, -0.03340153f, 
    -0.07251481f, 0.03307589f, -0.02574364f, 0.24953648f, -0.04092545f, 0.00344390f, -0.03033886f, 0.08932880f, 
    0.15683578f, -0.04649463f, 0.04226365f, -0.00717185f, -0.12750611f, 0.04107622f, -0.04752237f, -0.01908134f, 
    -0.03287273f, -0.13677260f, -0.03174970f, 0.16338955f, 0.07487299f, -0.00875682f, 0.09155103f, -0.17164785f, 
    0.01454500f, -0.32431507f, -0.20040795f, 0.11934939f, -0.16449071f, 0.05628712f, 0.02786748f, 0.01845096f, 
    0.20689498f, 0.12817913f, 0.06259204f, -0.05381688f, -0.03059781f, 0.02272391f, 0.01366570f, -0.05150622f, 
    0.13143919f, 0.16437311f, 0.18214412f, 0.11362077f, -0.09683850f, -0.34220797f, 0.29677567f, -0.13319196f, 
    -0.04951542f, 0.05465447f, 0.13134466f, -0.08278906f, -0.01259563f, 0.12562828f, 0.09988606f, 0.09430701f, 
    0.05688698f, 0.11948001f, -0.09702875f, 0.21473223f, 0.07516623f, -0.17540629f, -0.05468373f, -0.06755059f, 
    -0.05167383f, -0.09919960f, -0.04625526f, -0.11453693f, 0.25368127f, 0.06044819f, 0.19935101f, -0.00347356f, 
    -0.11541541f, -0.05854280f, -0.06341817f, -0.19199331f, -0.19233088f, -0.02080370f, -0.16778788f, -0.05645677f, 
    0.26403698f, 0.48665631f, 0.46477830f, -0.05384777f, -0.16765259f, 0.08972839f, -0.13680030f, -0.02142634f, 
    0.16750138f, 0.11900754f, 0.00923933f, 0.08091124f, -0.04040516f, 0.16265868f, 0.04134391f, -0.10474682f, 
    -0.22184694f, -0.09123705f, -0.01868815f, -0.21227728f, -0.29476818f, -0.02911077f, 0.15624224f, -0.03229704f, 
    -0.29628021f, -0.21341641f, -0.13483173f, -0.03789449f, 0.19082285f, -0.03328641f, 0.31898299f, -0.24695119f, 
    -0.05666970f, -0.20865877f, 0.08162885f, -0.05847987f, 0.15257832f, -0.21816121f, -0.05126303f, -0.07227620f, 
    -0.13239683f, -0.12212960f, 0.00077286f, 0.05666193f, -0.06699229f, 0.05416636f, 0.09899155f, 0.01564839f, 
    -0.00009784f, -0.22099783f, 0.25386453f, 0.05803235f, 0.05971282f, -0.00280898f, -0.03506713f, 0.04891390f, 
    -0.13957696f, -0.26706687f, -0.47402573f, -0.26910618f, 0.14996564f, -0.07223032f, 0.02230204f, 0.07728476f, 
    0.08840063f, 0.03991437f, 0.04928119f, 0.15837909f, 0.12372801f, -0.01030789f, 0.08567640f, 0.01317408f, 
    0.08385023f, -0.13972762f, -0.17088412f, -0.18076971f, 0.14134811f, 0.12768254f, 0.27608857f, -0.10450861f, 
    0.09921081f, 0.13867866f, -0.29802784f, -0.06130961f, 0.15847224f, -0.12879744f, 0.07583504f, 0.15591571f, 
    0.05517548f, 0.10848516f, -0.05435376f, -0.03876239f, 0.18376392f, 0.09112678f, 0.18472874f, 0.26124540f, 
    0.04896399f, 0.22875251f, 0.11535295f, 0.27081814f, 0.00049598f, -0.08246007f, -0.17962897f, -0.05905234f, 
    -0.03147281f, 0.10136805f, 0.04144445f, 0.30288154f, -0.14761776f, 0.23782066f, 0.06267203f, -0.03911658f, 
    0.19373091f, -0.19818529f, -0.16048719f, -0.08296870f, -0.05754758f, 0.14700691f, -0.04608480f, -0.06403373f, 
    0.25207520f, 0.19872105f, -0.05076060f, 0.15365195f, 0.04525857f, 0.07588986f, 0.04082673f, 0.05085443f, 
    -0.19703916f, -0.19696572f, -0.24028426f, -0.21608920f, -0.16180564f, -0.35634422f, 0.08872610f, 0.72450763f, 
    0.23316623f, 0.28407100f, 0.15389681f, -0.20450877f, -0.11621126f, -0.27503669f, -0.19485527f, 0.23855858f, 
    0.10662938f, 0.43682301f, -0.07096634f, -0.14181034f, 0.02562762f, 0.12366255f, 0.14379515f, 0.24199986f, 
    0.01676592f, -0.01072050f, -0.11007107f, -0.11551616f, 0.10046259f, -0.05385504f, 0.12895061f, -0.13902886f, 
    -0.00539912f, -0.00518200f, -0.29343086f, -0.37297955f, -0.04285121f, -0.00611911f, 0.06509768f, 0.09597389f, 
    -0.01215301f, -0.08359587f, -0.32844076f, -0.01201431f, 0.03828511f, 0.13642472f, 0.05955502f, 0.06955651f, 
    0.17393701f, 0.15187861f, 0.05854749f, 0.16844136f, 0.13386820f, 0.15440848f, -0.11432043f, -0.21749403f, 
    0.09669435f, 0.19715670f, 0.10466377f, 0.25767562f, 0.20274952f, 0.05009645f, 0.12304448f, 0.11073843f, 
    0.29993367f, -0.01458408f, -0.06072598f, -0.17817762f, -0.07613870f, 0.04074371f, -0.00503144f, -0.03444177f, 
    0.01816255f, 0.06396888f, 0.18686454f, 0.13199817f, 0.21976368f, -0.05927306f, 0.16316460f, -0.07662454f, 
    -0.17057040f, -0.07856619f, 0.03637461f, 0.06949159f, -0.02366196f, -0.04726452f, -0.14458404f, 0.05823518f, 
    -0.14989100f, 0.13846543f, 0.06647589f, 0.06085706f, -0.13764854f, -0.05587405f, -0.19868650f, -0.03596036f, 
    -0.09418572f, -0.08236025f, -0.06546523f, -0.11168829f, 0.10807195f, -0.03139151f, -0.16882174f, 0.22525328f, 
    0.09061687f, -0.00094765f, 0.15551648f, -0.04358255f, 0.12640159f, -0.12532826f, -0.03027393f, 0.25756204f, 
    -0.09647415f, -0.08111846f, -0.25481227f, -0.19853085f, -0.23311685f, -0.22105378f, -0.09544932f, -0.21034184f, 
    0.01089877f, 0.23056620f, 0.11426458f, 0.04973733f, 0.28160363f, 0.11343489f, -0.02984226f, 0.05647194f, 
    0.22028519f, 0.12524486f, 0.12705971f, 0.14206496f, -0.06293084f, 0.07614256f, 0.00116146f, 0.10010941f, 
    0.09940048f, 0.13959849f, 0.24682136f, 0.03432103f, 0.24385676f, -0.10430343f, -0.12067265f, 0.35642007f, 
    -0.05303196f, -0.07648353f, 0.25620213f, 0.19094910f, 0.17081763f, 0.07985120f, 0.04811476f, -0.10162214f, 
    0.17180789f, -0.03346768f, 0.16444778f, 0.05643123f, 0.10270346f, 0.00423577f, -0.17995478f, -0.14907439f, 
    0.00962653f, -0.47954196f, -0.21839891f, -0.14069097f, 0.08544032f, 0.01909731f, 0.00498327f, -0.05719094f, 
    0.06109682f, 0.00227250f, -0.07059212f, -0.05965435f, 0.12958147f, 0.06669082f, 0.06906044f, 0.02840888f, 
    -0.07643728f, -0.00604487f, -0.09355596f, -0.00278183f, -0.14482835f, 0.01193310f, 0.07694829f, 0.03944181f, 
    -0.13426851f, 0.00115821f, 0.00682136f, 0.32689121f, 0.14547893f, 0.02303967f, 0.02418157f, -0.02893648f, 
    0.15396591f, 0.02687587f, 0.11574347f, 0.20432569f, -0.16914648f, 0.01551721f, 0.24140540f, -0.04152292f, 
    -0.01655334f, -0.03894945f, -0.06921480f, 0.09232366f, -0.12000696f, 0.05080768f, 0.06530014f, 0.00834866f, 
    -0.17865086f, -0.41699827f, -0.08811385f, -0.32267177f, 0.06088554f, -0.00521422f, 0.01417742f, 0.07361946f, 
    0.04001874f, 0.07109957f, 0.09386759f, -0.04456821f, 0.03179723f, 0.01109369f, 0.03529914f, 0.09331828f, 
    -0.01571763f, 0.04244796f, 0.03632685f, 0.04576016f, -0.12412669f, 0.08971953f, 0.07913922f, 0.03008334f, 
    -0.25507569f, 0.26142249f, -0.03102066f, -0.08878410f, -0.09395007f, -0.06627005f, -0.10581417f, 0.00489840f, 
    0.02450794f, 0.11981330f, 0.04655727f, 0.00898430f, -0.03327318f, -0.13502662f, 0.23619625f, -0.36006814f, 
    -0.09520082f, -0.10842963f, -0.09543814f, -0.04375659f, -0.08292694f, 0.11780647f, 0.03975336f, -0.02973234f, 
    0.02946031f, -0.22380212f, 0.04811393f, -0.12691677f, -0.13802436f, -0.09801129f, -0.03061286f, -0.00500750f, 
    -0.02993869f, 0.16700454f, -0.04174059f, -0.01154783f, 0.25543776f, 0.02789624f, 0.16308680f, 0.06883225f, 
    0.07338623f, 0.08664492f, 0.06932332f, 0.00694985f, 0.00892357f, -0.05105672f, -0.05962355f, 0.05980253f, 
    0.20674393f, 0.07833193f, 0.13332704f, 0.21836726f, 0.07473378f, -0.02606670f, 0.06781499f, -0.09594183f, 
    -0.05365716f, -0.01649265f, -0.02228564f, 0.06026497f, -0.09823298f, -0.10382753f, 0.10362796f, -0.05218734f, 
    -0.01798857f, 0.10625722f, -0.02312967f, 0.12632412f, 0.13840638f, 0.08529490f, -0.14633526f, -0.10046736f, 
    0.09175521f, -0.04800940f, -0.03560376f, 0.05080706f, 0.00849873f, -0.13476199f, -0.04436119f, -0.09306806f, 
    -0.06662276f, -0.02967335f, -0.07269742f, -0.05089999f, 0.02010691f, 0.16739188f, 0.07505748f, 0.15186656f, 
    0.00045963f, -0.00227106f, 0.20057736f, -0.16171010f, -0.02192431f, 0.05829188f, 0.05387305f, -0.02985808f, 
    -0.24156654f, -0.08971596f, 0.10964885f, -0.15668082f, 0.04114440f, 0.14619148f, 0.10491370f, 0.06899768f, 
    0.09263875f, 0.07913347f, 0.02945182f, -0.02251950f, -0.26785654f, -0.18680593f, -0.06126018f, -0.31262189f, 
    -0.14521004f, -0.02212782f, -0.01112773f, 0.15301594f, -0.03202015f, -0.03364328f, 0.15351453f, 0.19279598f, 
    -0.02175592f, -0.14046125f, -0.06043132f, -0.16772673f, 0.04878631f, 0.03664613f, 0.05818440f, -0.06784686f, 
    0.12278907f, -0.00250256f, 0.09176396f, 0.00905148f, 0.11101115f, 0.15591347f, 0.05707394f, 0.19126588f, 
    0.14761356f, 0.00098462f, -0.07713751f, 0.00439045f, 0.00781774f, 0.09025625f, -0.01190884f, 0.06814698f, 
    0.27230179f, 0.12093673f, -0.07345551f, -0.06174296f, -0.08608609f, -0.06772117f, 0.05371619f, -0.11139610f, 
    -0.05158140f, 0.01630779f, -0.15455949f, -0.02988588f, 0.11648339f, 0.08985467f, -0.00730091f, 0.37668887f, 
    0.00313495f, -0.02032063f, 0.06085858f, 0.17319816f, -0.06517184f, -0.02187994f, 0.05610401f, 0.03252229f, 
    0.05988720f, 0.07710266f, 0.11419165f, 0.08856317f, 0.05284406f, -0.02156877f, -0.01144291f, -0.01372813f, 
    -0.14876962f, -0.12027578f, 0.13729478f, 0.29342762f, 0.08140058f, 0.00509658f, -0.25177380f, -0.01345342f, 
    0.06425373f, -0.11126859f, 0.03968213f, 0.05680433f, 0.01201731f, 0.07559936f, -0.06792200f, 0.10176244f, 
    0.03556526f, 0.00085128f, 0.07782453f, 0.34727520f, -0.02828191f, 0.06068472f, 0.10024631f, 0.00067375f, 
    0.04062380f, -0.09092207f, 0.01340623f, 0.06599680f, -0.07207611f, 0.06718382f, -0.23782948f, 0.01611255f, 
    0.22445472f, 0.06934423f, 0.10244986f, -0.25012696f, -0.18854491f, -0.05713056f, 0.05290597f, 0.09826756f, 
    0.17854449f, 0.02184526f, -0.26845774f, -0.18656537f, 0.11395904f, 0.03989435f, 0.09675055f, -0.08685936f, 
    -0.14587630f, -0.07598227f, -0.12273134f, -0.11213494f, 0.04937297f, 0.21288434f, -0.10845292f, -0.01226977f, 
    0.10435465f, -0.04796812f, 0.05938611f, -0.01783444f, 0.06797000f, -0.11276089f, 0.02526371f, 0.03893631f, 
    0.02352326f, 0.20963877f, 0.23381253f, 0.03361976f, -0.05241410f, 0.00834824f, -0.02247201f, 0.06033827f, 
    0.07380118f, 0.06777117f, -0.08278102f, 0.01927415f, 0.52408916f, -0.08746064f, -0.01789832f, -0.07181948f, 
    -0.22010578f, 0.10964762f, -0.16200204f, 0.04852097f, -0.09584122f, -0.10952733f, 0.12012669f, 0.02256832f, 
    -0.04112637f, 0.03987665f, 0.05919208f, -0.01774974f, 0.09101038f, 0.04652804f, 0.05709503f, -0.03016298f, 
    0.10256244f, 0.05912016f, 0.04462188f, -0.10968308f, 0.03805099f, -0.08653587f, 0.10279177f, 0.32970220f, 
    -0.03786580f, 0.09728232f, -0.07235730f, 0.06610541f, 0.00303850f, 0.00238846f, -0.10505351f, -0.04716352f, 
    0.24515262f, 0.18923953f, 0.11425644f, 0.26689425f, 0.17255913f, -0.03500127f, 0.02266343f, -0.11743113f, 
    -0.06702115f, -0.00878747f, 0.12675135f, -0.11060350f, 0.16093349f, -0.15103436f, -0.13883586f, -0.03945588f, 
    0.02968838f, 0.05274221f, 0.01531387f, -0.02736617f, -0.04848489f, 0.08284934f, 0.08093045f, 0.16697243f, 
    -0.66568553f, 0.10015518f, -0.31283194f, 0.35653245f, 0.04598264f, -0.06598903f, 0.17696121f, 0.12896512f, 
    -0.02507427f, -0.06301296f, -0.01997551f, 0.05791096f, 0.03812215f, 0.30060852f, -0.04943270f, -0.02349680f, 
    0.01172308f, 0.20231687f, -0.06728108f, -0.01845325f, -0.14298102f, -0.00482825f, 0.03732635f, 0.02831266f, 
    -0.20593867f, 0.02512288f, 0.23671784f, 0.12491252f, -0.04357432f, 0.14701363f, -0.20923431f, 0.00559117f, 
    -0.16126536f, -0.00895738f, 0.20078388f, 0.01147248f, 0.15917484f, 0.28538808f, 0.28340194f, 0.07424848f, 
    -0.07572787f, 0.00686190f, -0.00154783f, -0.02792168f, 0.17872538f, 0.05982011f, -0.01521739f, 0.01634134f, 
    0.02712099f, -0.10436839f, 0.08288381f, -0.00395016f, 0.08623597f, -0.08909409f, 0.18310839f, -0.21092455f, 
    0.05690250f, 0.05719804f, 0.05283025f, 0.18226959f, 0.01379110f, 0.15895951f, -0.14157763f, 0.21407181f, 
    0.19867045f, -0.20864975f, 0.07618834f, 0.02224871f, 0.11582066f, -0.00598790f, 0.25889048f, 0.01520996f, 
    -0.27551344f, 0.13714351f, 0.13635792f, -0.20184506f, -0.25018817f, 0.15236638f, -0.03370567f, 0.12508114f, 
    0.05065740f, 0.09792105f, 0.05827356f, -0.15079474f, -0.46579948f, -0.00780329f, -0.05511235f, 0.15488710f, 
    0.02405239f, -0.21738763f, -0.03506812f, 0.06217771f, 0.05490213f, 0.12894917f, 0.24993002f, 0.01936567f, 
    -0.46399695f, -0.45527601f, 0.02144168f, 0.01007981f, -0.02613672f, -0.02991731f, 0.03849490f, 0.10275361f, 
    0.14841551f, 0.16654859f, 0.11339387f, 0.12326093f, 0.14185248f, 0.01280814f, 0.15926854f, 0.02014316f, 
    0.24310172f, -0.03853664f, 0.06912263f, -0.04741913f, 0.15783212f, -0.00762208f, 0.00983042f, 0.15520751f, 
    0.18033931f, 0.17802720f, 0.08474945f, 0.11677375f, -0.12592672f, -0.00101948f, 0.02736034f, 0.06084717f, 
    -0.15121807f, 0.02686254f, -0.00267018f, 0.11752009f, 0.20215034f, 0.05373514f, 0.37208498f, -0.01616621f, 
    0.10746284f, 0.08535630f, -0.07844914f, 0.24008320f, 0.30943474f, 0.02421798f, 0.00440700f, 0.26225182f, 
    -0.20597865f, -0.11756925f, -0.06473513f, -0.00935816f, -0.01256461f, -0.09268355f, -0.05171327f, -0.01982567f, 
    -0.01430638f, 0.08233614f, 0.10120312f, 0.00694388f, -0.17056619f, 0.00669248f, 0.02518447f, -0.03505488f, 
    0.07035988f, 0.07504876f, -0.00770834f, -0.27755961f, 0.03692473f, -0.07577349f, -0.00078048f, 0.02364464f, 
    -0.12184063f, -0.07117726f, 0.38356364f, 0.32634550f, 0.15022761f, -0.06715629f, 0.19190706f, 0.20761937f, 
    -0.10640122f, 0.14845063f, 0.02984958f, 0.04051192f, -0.20596838f, 0.13157238f, -0.08230643f, -0.40250987f, 
    -0.17513639f, -0.04296692f, 0.02872035f, 0.14906099f, 0.07476117f, 0.16318914f, 0.00343722f, -0.10583821f, 
    -0.17386024f, 0.24433184f, -0.10311934f, -0.05310712f, -0.02153966f, -0.00917121f, 0.21924753f, -0.06145197f, 
    0.13468514f, -0.00481623f, -0.03362858f, -0.11867511f, 0.10738986f, -0.04548627f, -0.10608102f, -0.00684186f, 
    -0.00842029f, -0.06476464f, 0.16246745f, 0.17214091f, -0.08235350f, 0.17744358f, 0.00731215f, 0.07626252f, 
    0.04562005f, -0.22128193f, 0.05091576f, -0.37393916f, 0.01572096f, -0.12211889f, 0.13259079f, 0.14348646f, 
    -0.03046495f, 0.10791861f, -0.05783826f, 0.00631938f, -0.05782003f, 0.12462458f, -0.07912923f, -0.26605079f, 
    0.02868216f, -0.03886293f, -0.03035573f, -0.01449837f, -0.12521999f, -0.00292014f, -0.04163517f, -0.06469173f, 
    0.12961824f, -0.11350834f, 0.06305356f, -0.05725098f, 0.06387021f, 0.10299592f, -0.04284884f, -0.05033270f, 
    0.13871455f, 0.05594144f, -0.09501952f, 0.09293897f, -0.07351408f, -0.05470171f, -0.28106865f, -0.31596145f, 
    0.13587709f, 0.05377049f, -0.02433741f, -0.21090922f, -0.09094775f, 0.11520007f, -0.14522824f, 0.10302833f, 
    0.02666697f, 0.23021066f, 0.02348817f, -0.12307633f, -0.16641013f, 0.00867542f, -0.03099114f, -0.09390449f, 
    -0.07666363f, -0.09237126f, -0.02142343f, -0.23958948f, 0.06980030f, 0.12005962f, 0.25433946f, 0.11949758f, 
    -0.03195473f, 0.01624708f, 0.10953353f, -0.01687199f, -0.01091806f, 0.01832652f, -0.02289819f, -0.02812464f, 
    0.05103777f, -0.35886264f, 0.31513706f, 0.18778041f, -0.10420281f, -0.08339649f, 0.07017211f, 0.00106949f, 
    0.07062007f, -0.04805136f, 0.10369607f, 0.09075360f, 0.12202962f, -0.30308148f, -0.10769820f, 0.13125011f, 
    -0.04075129f, -0.02421322f, 0.07116775f, -0.07077881f, 0.00830221f, 0.11191645f, -0.12651116f, 0.00008752f, 
    -0.17951718f, -0.14044829f, 0.02817285f, 0.07146859f, -0.26237056f, -0.07842579f, -0.28985023f, 0.11689470f, 
    0.06403185f, -0.11305781f, 0.01396823f, 0.01809310f, 0.03489759f, 0.33249649f, -0.04683365f, 0.10461593f, 
    0.13912158f, 0.12251355f, 0.07655028f, -0.08682942f, 0.05809244f, -0.00700378f, -0.03053654f, 0.08417495f, 
    0.05765498f, -0.13847277f, -0.19572473f, 0.12423127f, -0.05649325f, 0.05835901f, 0.20613645f, 0.03964818f, 
    0.15972640f, 0.05157666f, -0.05224964f, -0.34299976f, 0.14302272f, 0.27229536f, 0.21766976f, -0.07358388f, 
    0.10976665f, 0.02971382f, 0.12110450f, -0.09116270f, 0.07156073f, -0.06063990f, 0.03095343f, 0.11288757f, 
    0.06532780f, 0.11097424f, 0.03420541f, 0.07452729f, 0.07716132f, -0.09643697f, -0.03604871f, 0.15811233f, 
    0.11333236f, -0.04555320f, 0.05681216f, 0.01408009f, -0.04318928f, 0.20594256f, 0.17562784f, -0.03347275f, 
    -0.00028528f, 0.06137037f, 0.01351156f, 0.06039306f, 0.09970646f, 0.02711081f, -0.03184029f, -0.00575898f, 
    0.14118785f, -0.01777440f, 0.16163510f, -0.17224868f, -0.00814845f, -0.10556094f, -0.01055488f, 0.07797731f, 
    0.16520062f, 0.03072506f, 0.04984705f, 0.06173136f, 0.22336893f, -0.23267578f, -0.08367915f, -0.14417471f, 
    -0.01795163f, -0.16429582f, 0.01937170f, 0.21316117f, 0.07392287f, 0.21144882f, 0.10876907f, -0.09223798f, 
    0.11545475f, -0.00637578f, -0.09162657f, -0.05589261f, 0.10338894f, -0.00285181f, 0.13748717f, -0.00467634f, 
    -0.08387636f, -0.10381660f, -0.21644731f, -0.06238197f, -0.30401161f, 0.31049287f, 0.01435536f, -0.14742558f, 
    0.02304643f, -0.25938150f, -0.06530572f, -0.02871210f, -0.03569001f, -0.00958897f, 0.01774793f, -0.06175124f, 
    0.03887679f, -0.18720908f, 0.29507014f, 0.13913935f, 0.06659114f, 0.05991181f, 0.01340341f, -0.12657700f, 
    0.07000532f, -0.05139973f, 0.07748894f, -0.01625579f, -0.05904094f, -0.16366567f, 0.19706656f, 0.02978491f, 
    0.00860337f, -0.05935298f, 0.00621739f, -0.11832283f, -0.03382584f, 0.07183446f, -0.17098176f, 0.00297515f, 
    0.15459572f, 0.15991928f, -0.05023189f, -0.13323133f, 0.07087347f, -0.06455837f, -0.07801540f, 0.03324379f, 
    0.02036078f, 0.03183178f, -0.11564934f, 0.10477146f, 0.10492802f, -0.16628949f, 0.00147119f, 0.13874058f, 
    -0.21202777f, -0.02811989f, -0.04426624f, 0.13123207f, 0.02804059f, -0.00429059f, 0.01879253f, -0.05521471f, 
    0.17008780f, 0.09454333f, 0.18799326f, 0.24987443f, -0.09574960f, -0.12472299f, -0.09421001f, -0.02053020f, 
    0.11503299f, 0.01027871f, 0.08170827f, 0.07375845f, 0.20027889f, -0.31050125f, 0.11780215f, 0.16440974f, 
    0.00335185f, 0.01829477f, -0.05253870f, 0.00234474f, -0.09384434f, 0.04687347f, 0.13641907f, -0.07795767f, 
    0.03061659f, -0.15744957f, -0.20149714f, -0.05462180f, 0.14474230f, 0.01755531f, 0.10753714f, 0.01299868f, 
    0.08934721f, -0.12007473f, 0.06019417f, -0.09123724f, -0.20260485f, 0.33168221f, 0.04425674f, 0.04733203f, 
    0.05139560f, 0.04576643f, 0.07952721f, 0.18078998f, 0.01265880f, 0.15868208f, 0.14762014f, -0.13787022f, 
    0.06170341f, -0.06922793f, 0.02340641f, 0.08855319f, -0.02736822f, 0.13607281f, 0.04525489f, 0.05417723f, 
    0.12212642f, -0.11015327f, -0.07086913f, -0.01435433f, -0.04326506f, 0.23687331f, 0.08590406f, 0.00807235f, 
    0.00051270f, -0.00341788f, 0.04034022f, 0.14765279f, 0.04175622f, 0.00557462f, -0.03972609f, 0.06736332f, 
    -0.22409348f, -0.04253546f, 0.12239129f, 0.08148707f, -0.25667790f, 0.06344984f, 0.05654568f, -0.14518255f, 
    0.15403053f, 0.05333394f, -0.14999342f, 0.03982933f, -0.31787777f, -0.05607774f, 0.10514127f, 0.15448508f, 
    -0.17703094f, 0.03031452f, -0.03768095f, 0.05805167f, 0.00290196f, -0.01472124f, 0.00036233f, 0.06917784f, 
    0.07859736f, 0.05151113f, 0.21175598f, -0.31315607f, -0.06127594f, -0.04094838f, -0.17175558f, 0.09013547f, 
    0.02835048f, 0.04696864f, 0.14742886f, -0.01775762f, -0.01807258f, -0.16287456f, 0.27870852f, -0.13277163f, 
    0.06673085f, 0.02581807f, -0.21254832f, -0.02575591f, -0.04138795f, -0.09352925f, -0.03886820f, 0.03632119f, 
    0.17230870f, 0.16468751f, 0.10507502f, -0.08181911f, 0.05857654f, -0.09688284f, 0.14655887f, -0.04155637f, 
    -0.01820597f, -0.15986994f, 0.06913599f, -0.01083781f, 0.13104714f, -0.29753798f, -0.09258103f, 0.17967102f, 
    -0.04325492f, 0.20096406f, 0.24563494f, -0.09210349f, -0.02005747f, 0.01363015f, -0.19669884f, 0.04322983f, 
    -0.13990037f, 0.04040627f, 0.16359222f, 0.16010334f, 0.06930213f, 0.15875141f, -0.00499475f, -0.13547814f, 
    0.01797807f, 0.06486939f, -0.00408823f, 0.00877452f, 0.01780267f, -0.19339024f, 0.17732938f, 0.04691380f, 
    0.02534611f, -0.03352706f, -0.00353557f, 0.03601574f, -0.06811059f, -0.03911834f, -0.01359687f, 0.00899621f, 
    0.02566067f, 0.04668836f, 0.05449356f, -0.02575998f, -0.06279834f, -0.21284313f, -0.08112606f, -0.00004639f, 
    0.24372205f, 0.14090893f, -0.05895424f, 0.07854936f, -0.23950772f, -0.15682426f, 0.08391732f, 0.20987970f, 
    -0.00755359f, 0.02915867f, -0.09631062f, 0.19743524f, -0.05701167f, 0.05065360f, 0.02275440f, 0.14317366f, 
    0.11854399f, 0.37119609f, 0.33270553f, 0.11175494f, -0.07551056f, -0.04388860f, 0.00770316f, -0.01764915f, 
    0.11251012f, 0.13130751f, 0.03759577f, 0.19675705f, 0.15003851f, 0.12878771f, 0.04032683f, 0.27978629f, 
    -0.07101771f, 0.09617213f, -0.11335374f, 0.03731073f, -0.07808040f, -0.04834359f, 0.18559355f, -0.02958146f, 
    -0.03480688f, -0.11060007f, -0.04410531f, -0.01711219f, 0.03153210f, -0.03176251f, 0.11744921f, -0.09843514f, 
    0.03778153f, 0.04225178f, -0.05324367f, -0.06787588f, 0.03838588f, 0.17761505f, 0.17068383f, -0.06722843f, 
    0.20805238f, -0.00599138f, 0.05000756f, 0.17596918f, 0.10362816f, 0.05000250f, 0.18448539f, -0.05962724f, 
    0.00624325f, -0.12094800f, -0.04453547f, -0.01773889f, -0.02248662f, -0.01973539f, -0.08856853f, 0.01840760f, 
    0.12737183f, -0.04268258f, -0.03312794f, -0.05679340f, -0.34818012f, -0.06972185f, -0.08967595f, 0.14016846f, 
    -0.04791408f, 0.02344321f, -0.02680327f, 0.08230512f, 0.12370786f, 0.13244864f, 0.05734133f, 0.02319711f, 
    -0.24024411f, -0.31276470f, 0.17852126f, 0.09168755f, -0.24627411f, 0.10876804f, 0.20643976f, -0.01336920f, 
    0.03792255f, -0.07870696f, -0.09484157f, 0.27090612f, -0.36462346f, -0.08628134f, -0.07708351f, 0.05177912f, 
    -0.18920864f, 0.08493699f, 0.02444080f, 0.06042365f, 0.00403395f, 0.01183657f, 0.04745186f, 0.04780906f, 
    -0.03098889f, 0.30936950f, 0.54000407f, -0.14044029f, -0.02089478f, -0.06355926f, -0.00891420f, 0.03521934f, 
    0.07033011f, 0.06567860f, 0.15481038f, 0.00764165f, 0.01112808f, -0.05812374f, 0.25439620f, 0.00311343f, 
    0.11669489f, 0.11559307f, -0.21675438f, 0.02048082f, -0.14603160f, -0.05680611f, 0.08523714f, -0.10478401f, 
    0.10272828f, 0.02914822f, 0.03453266f, -0.06193878f, -0.12666303f, -0.22358359f, 0.18798137f, 0.11569844f, 
    0.12128612f, -0.05923009f, 0.12568405f, 0.06470537f, -0.06591327f, -0.40923464f, -0.03930057f, 0.18329534f, 
    -0.03299476f, 0.35639104f, 0.12099262f, 0.07085117f, 0.03354140f, 0.00813843f, -0.13564776f, 0.05674116f, 
    0.43838263f, 0.03999825f, -0.03004852f, -0.00562210f, -0.07310788f, -0.06437136f, -0.07532855f, 0.05971877f, 
    -0.08403056f, 0.27424899f, -0.00495671f, 0.05112363f, 0.07118183f, -0.23623399f, -0.13127580f, -0.32693887f, 
    -0.30417317f, -0.16857947f, 0.23943679f, 0.23002630f, -0.10702241f, -0.02507080f, 0.02052846f, 0.02698839f, 
    0.00743175f, -0.04306791f, 0.17876573f, 0.29235062f, 0.00899846f, 0.06823474f, 0.17619549f, 0.14356802f, 
    -0.01920734f, -0.02486299f, -0.01280242f, -0.07832236f, 0.21272080f, 0.01031259f, 0.02864202f, -0.06624478f, 
    0.09997405f, -0.01696641f, 0.17669150f, -0.13574739f, -0.34695551f, -0.00169039f, 0.12355223f, -0.01320153f, 
    0.33402845f, 0.13210584f, 0.06524601f, -0.33612436f, -0.13962495f, 0.09283055f, 0.06739648f, -0.00103755f, 
    0.00454976f, 0.04948459f, 0.00642354f, 0.01455716f, -0.06877654f, 0.17314100f, -0.16459970f, -0.24848983f, 
    -0.12923110f, -0.33617684f, 0.06496304f, 0.01529187f, -0.17652057f, -0.05808310f, -0.03258390f, 0.10708582f, 
    -0.11320632f, 0.19122501f, 0.30460250f, -0.04123859f, 0.06257249f, 0.04185826f, -0.13112645f, -0.32973257f, 
    -0.08940843f, -0.07257573f, -0.01035340f, -0.12439285f, 0.34790084f, -0.30760601f, -0.12476197f, -0.04401011f, 
    -0.05892240f, -0.07851073f, -0.10486767f, 0.08226033f, -0.01980707f, 0.03525324f, 0.23153023f, -0.13503528f, 
    0.04009709f, 0.10115246f, -0.11644135f, -0.16952872f, -0.03545665f, -0.20819685f, -0.02385636f, -0.02216171f, 
    -0.28930748f, -0.10158929f, -0.23988590f, -0.09119980f, 0.21334112f, -0.12166334f, 0.04254598f, 0.09327497f, 
    -0.04550218f, 0.06188013f, 0.10853762f, 0.08854230f, -0.00238905f, 0.01754975f, -0.01208365f, -0.11326563f, 
    0.51806641f, 0.07598276f, -0.10223161f, -0.05314402f, 0.24651109f, 0.04788691f, 0.09838044f, -0.05696632f, 
    -0.13254523f, -0.03580313f, -0.08132286f, -0.20046826f, 0.26361588f, 0.04177189f, 0.01730095f, 0.08470319f, 
    0.06949191f, 0.15720351f, -0.04566766f, 0.02951882f, 0.00999403f, 0.09092756f, 0.08104216f, 0.18959056f, 
    -0.06439639f, 0.30436119f, -0.03692871f, 0.62341410f, 0.11039926f, 0.05210784f, 0.13669716f, -0.20833586f, 
    0.05261434f, -0.01675043f, 0.01503536f, 0.08995889f, 0.23511827f, 0.43266040f, -0.43981886f, 0.15965658f, 
    -0.11890204f, -0.28084487f, 0.14748475f, -0.22031836f, 0.20937742f, 0.04891609f, -0.06520957f, 0.00549781f, 
    0.09600212f, 0.14157628f, 0.10819405f, 0.25819331f, 0.14276578f, 0.12475950f, -0.10203119f, -0.15045333f, 
    -0.17892428f, 0.04937292f, -0.20825921f, -0.28727251f, -0.23715495f, 0.32473308f, 0.28533566f, 0.34041125f, 
    0.32011914f, 0.12833835f, 0.05936725f, 0.09260584f, -0.00355151f, -0.32945895f, 0.10749358f, 0.03191631f, 
    -0.07678959f, -0.04929922f, 0.00516002f, -0.02160968f, 0.05635440f, -0.04337513f, -0.00644233f, -0.03358863f, 
    -0.06949682f, -0.03431347f, -0.04790781f, 0.02485193f, -0.01752102f, -0.05367376f, 0.04942931f, 0.01170076f, 
    -0.07409593f, 0.01743110f, -0.06727112f, -0.02794814f, -0.03231365f, -0.06002937f, 0.02835079f, -0.06226767f, 
    0.04140688f, 0.00213942f, -0.05272720f, 0.05075418f, 0.05404592f, -0.03400671f, -0.02683783f, 0.01242179f, 
    -0.07181162f, 0.06578188f, -0.07727530f, -0.04078952f, 0.01320093f, -0.06207513f, -0.03563813f, -0.02430667f, 
    -0.05308532f, -0.00024106f, -0.00444613f, 0.03304425f, -0.05042317f, 0.02502660f, -0.02794279f, -0.00078666f, 
    0.00301005f, -0.01060404f, 0.06307577f, -0.04393451f, -0.01214846f, 0.03576937f, 0.01891174f, -0.06556107f, 
    -0.02251458f, -0.03079772f, -0.00116971f, 0.01254684f, 0.03241235f, 0.02896236f, 0.04160581f, -0.02026384f, 
    -0.01870328f, -0.04840073f, 0.00226507f, 0.04643880f, -0.04536538f, 0.04498258f, -0.07615259f, 0.04393041f, 
    -0.03084146f, -0.01978309f, -0.02127458f, 0.06207124f, -0.03480233f, -0.01000221f, 0.04010647f, -0.01821590f, 
    0.05224183f, 0.04043947f, -0.01757678f, -0.05692758f, -0.04119165f, 0.01297456f, 0.04811278f, 0.04640281f, 
    0.00178144f, -0.05235107f, -0.03862492f, -0.00647802f, -0.06695969f, -0.07247861f, 0.03612003f, -0.07349585f, 
    0.02429993f, -0.01512454f, -0.00402339f, 0.03517082f, 0.02459425f, 0.03005206f, 0.05973572f, -0.06961308f, 
    -0.03092789f, 0.01983816f, 0.02030356f, -0.06096234f, -0.03053663f, 0.02988843f, 0.05250907f, -0.05480564f, 
    -0.06416160f, -0.02800990f, 0.00670745f, -0.03205741f, -0.01273910f, 0.02119320f, -0.06156850f, 0.00252504f, 
    0.05955694f, -0.01939687f, 0.03226648f, 0.02141507f, -0.07348214f, -0.03765177f, -0.02176985f, -0.04543048f, 
    -0.01234079f, 0.01811790f, -0.05708728f, 0.02209076f, 0.00314345f, 0.04385197f, -0.04371081f, -0.03799341f, 
    0.05952223f, -0.07685331f, -0.03093446f, -0.02486298f, -0.01684608f, -0.00732800f, 0.00960495f, -0.03189409f, 
    0.03042574f, -0.05178742f, 0.01964167f, -0.07027090f, 0.04356546f, -0.06700767f, 0.04134782f, -0.02589359f, 
    0.04271385f, -0.02381503f, 0.04179094f, -0.03885398f, 0.01431338f, -0.00163412f, -0.06298100f, 0.04902167f, 
    -0.04719235f, -0.05357032f, -0.02956231f, 0.01067583f, -0.03912277f, -0.03916568f, 0.04752310f, -0.04725369f, 
    -0.05077675f, -0.07287542f, -0.03664636f, -0.04579900f, 0.02224027f, 0.03568964f, 0.02415330f, 0.04875802f, 
    0.04134886f, -0.06852669f, 0.02470879f, 0.02317960f, -0.03381285f, -0.05403362f, -0.07136558f, 0.06069410f, 
    -0.01818609f, -0.05250939f, 0.02612194f, 0.00793425f, 0.00287928f, -0.03868608f, -0.07407644f, 0.07146724f, 
    0.05505578f, -0.05304377f, -0.05067739f, -0.01694667f, 0.04528489f, 0.05610841f, -0.04413838f, 0.00056634f, 
    0.01183535f, -0.04237933f, 0.01156033f, -0.02533723f, -0.07337917f, -0.03356198f, -0.04599957f, 0.05429883f, 
    -0.01370418f, -0.07260207f, -0.03482718f, 0.03831984f, -0.04220880f, -0.06515808f, -0.04077072f, 0.04564922f, 
    0.03472296f, -0.02660364f, -0.02421109f, 0.02089685f, -0.05229414f, -0.02147724f, 0.03752281f, -0.02542274f, 
    -0.00819146f, 0.01646250f, -0.07494371f, 0.05761129f, 0.00142125f, -0.06807183f, 0.06393301f, 0.06621929f, 
    0.03009982f, -0.06621828f, -0.06445341f, 0.03645740f, -0.05068296f, -0.04164102f, 0.05413134f, 0.03504208f, 
    0.01921928f, -0.02307758f, 0.02413099f, 0.01390513f, -0.03803289f, 0.05829739f, 0.01976173f, -0.04038306f, 
    -0.07443395f, 0.05455729f, 0.03666813f, 0.01732889f, 0.04713858f, -0.06513818f, -0.03786131f, -0.00020711f, 
    -0.03054462f, 0.05547449f, -0.06759905f, -0.04774920f, -0.04739141f, 0.04381301f, 0.04421998f, -0.06143914f, 
    0.03622536f, -0.01445761f, -0.01995985f, 0.00116109f, 0.05870518f, -0.06712526f, 0.02627843f, -0.01300569f, 
    -0.05174105f, -0.06351570f, -0.07207545f, 0.05842636f, 0.04352748f, 0.05526322f, -0.00215978f, -0.02688769f, 
    -0.05233363f, 0.06355764f, 0.02659948f, -0.03547202f, -0.01328871f, 0.05117512f, -0.05568813f, -0.06246339f, 
    0.01994144f, 0.03000309f, 0.00037560f, 0.00128694f, 0.06252333f, -0.00416094f, 0.00679641f, 0.04473862f, 
    -0.04064551f, -0.01162241f, 0.00932407f, -0.01182056f, -0.01465716f, -0.06609365f, -0.01433246f, 0.01873462f, 
    -0.04454312f, -0.01207996f, 0.02957922f, -0.04227061f, -0.03050530f, -0.08123966f, -0.04542146f, 0.03289249f, 
    0.06190060f, -0.00858741f, -0.06883340f, 0.01140120f, -0.07574681f, 0.04981507f, 0.01285804f, -0.07352652f, 
    0.05641220f, -0.07824999f, -0.03788609f, -0.07000490f, 0.05421989f, -0.04994287f, 0.02447456f, -0.00875919f, 
    -0.02407175f, 0.04703465f, -0.02972195f, -0.04958913f, -0.06467516f, -0.00668353f, 0.00263028f, 0.02141820f, 
    -0.00353716f, -0.07858967f, -0.02859949f, -0.06478248f, -0.06227757f, -0.04652447f, 0.00525496f, 0.03147931f, 
    0.02181305f, -0.05099243f, 0.03377222f, -0.00655632f, 0.02561551f, 0.03824319f, -0.04399519f, -0.06692606f, 
    0.03909704f, -0.00054868f, 0.00011725f, -0.00693509f, -0.04213683f, -0.07462475f, -0.06808801f, 0.02061135f, 
    -0.03484948f, 0.03984075f, 0.03190181f, 0.06357926f, -0.02393184f, -0.01491048f, 0.04994959f, -0.04580662f, 
    0.03715315f, 0.05410645f, -0.00046381f, -0.06243917f, 0.00864113f, -0.06198581f, -0.01209240f, -0.07026197f, 
    -0.05678276f, 0.05006507f, -0.00255363f, 0.01704009f, -0.00726690f, 0.03763693f, -0.07442655f, -0.04214089f, 
    -0.02213871f, 0.01029978f, -0.03370556f, 0.03096373f, 0.02814605f, 0.01157936f, -0.02316649f, -0.03475475f, 
    0.05360937f, 0.04867823f, -0.08007793f, 0.00545097f, 0.05050613f, -0.04275583f, -0.00139813f, 0.04964862f, 
    0.01615388f, 0.01598943f, -0.01834384f, -0.06051554f, 0.04642003f, -0.03913858f, -0.00815158f, -0.07188582f, 
    0.01302308f, -0.05462702f, 0.03925111f, -0.07229171f, -0.07219899f, 0.03884773f, -0.07259823f, 0.00336232f, 
    -0.06294550f, -0.04791372f, -0.05019386f, 0.02574040f, -0.01690345f, 0.05939436f, -0.02258233f, 0.00385285f, 
    -0.02536679f, -0.00227821f, -0.00585567f, -0.03608191f, 0.03869886f, -0.03351667f, 0.05398615f, -0.02790828f, 
    -0.06966155f, -0.03341017f, 0.05395194f, -0.03916601f, -0.01624995f, 0.01080759f, -0.05054974f, 0.02228297f, 
    -0.02591766f, 0.04334237f, -0.03313093f, -0.01429939f, -0.07506309f, 0.01171819f, -0.04441536f, -0.01073656f, 
    -0.06548136f, -0.05677011f, -0.00313338f, -0.01766163f, -0.01831795f, 0.05334377f, -0.07859049f, -0.06414684f, 
    -0.02473411f, -0.00276500f, -0.02351693f, -0.06638348f, 0.04222240f, 0.04949743f, 0.06043011f, -0.06693199f, 
    -0.05016426f, 0.01538693f, -0.04892825f, -0.03690691f, 0.01263418f, -0.07316642f, 0.01863941f, -0.06838077f, 
    0.05161139f, 0.04746121f, -0.00815271f, -0.07490972f, 0.01457869f, -0.00612715f, 0.01161475f, -0.06373414f, 
    0.00219952f, -0.00425619f, 0.02411172f, -0.00679560f, 0.04022552f, 0.02324752f, 0.01827599f, -0.04667350f, 
    -0.05735347f, -0.01383805f, -0.02611096f, -0.06091030f, -0.03607633f, -0.00439054f, -0.05252288f, 0.02185675f, 
    0.00347429f, -0.05527076f, -0.02860503f, -0.06218251f, 0.06083879f, -0.07431250f, -0.02234114f, 0.05831140f, 
    0.05211761f, 0.00497902f, -0.01106517f, 0.02124524f, 0.05223263f, -0.04507836f, 0.03970193f, -0.01350369f, 
    -0.01867881f, -0.01769177f, -0.03133168f, 0.04517226f, -0.01618074f, 0.00697209f, 0.04947476f, -0.04077320f, 
    0.00459772f, -0.03881343f, -0.07151639f, -0.02735353f, -0.07364525f, -0.06123327f, 0.06044805f, -0.00774749f, 
    0.04337721f, -0.07701146f, 0.06130776f, -0.07720324f, -0.05946717f, 0.06047819f, 0.05923240f, 0.04060963f, 
    -0.07326137f, -0.07705839f, -0.00194260f, -0.02108960f, -0.07830904f, -0.06408093f, 0.03923718f, 0.03715994f, 
    -0.03584695f, -0.03754031f, 0.00737034f, 0.05348183f, 0.04883875f, 0.05179595f, 0.06338105f, -0.02202811f, 
    -0.02075686f, 0.06031115f, -0.06259132f, 0.03748077f, -0.02021967f, -0.00764322f, -0.01502639f, -0.05055216f, 
    0.05506945f, 0.04332782f, -0.02772924f, 0.02599735f, -0.01584182f, 0.03288659f, -0.02835694f, -0.04384553f, 
    0.02130685f, 0.03984703f, 0.01708144f, -0.02936566f, 0.05393191f, -0.03287013f, -0.04580334f, -0.06104847f, 
    -0.02750416f, 0.35770014f, -0.08948524f, -0.10633288f, -0.08189477f, -0.05273803f, 0.07971464f, 0.34480697f, 
    -0.07107334f, -0.02025703f, -0.10618982f, -0.14117333f, -0.04015977f, -0.03438669f, 0.15796022f, -0.18378970f, 
    -0.02356086f, 0.12743935f, -0.00171247f, -0.00549991f, 0.02288326f, 0.08879802f, 0.17333172f, 0.02215659f, 
    0.09700219f, 0.05894691f, -0.09772822f, -0.08226146f, 0.14063141f, 0.16351743f, 0.07428171f, 0.06703819f, 
    -0.01967874f, 0.06879035f, 0.06919347f, 0.04805163f, 0.13414691f, 0.24609521f, 0.07724792f, -0.27819061f, 
    0.10040031f, 0.14754924f, -0.04685884f, 0.14011505f, 0.10716017f, 0.11545228f, -0.13771774f, -0.04683603f, 
    0.26709270f, 0.13867886f, 0.08769114f, -0.33167422f, -0.05107957f, 0.13773154f, 0.00815378f, 0.05567978f, 
    -0.05050831f, -0.04334960f, 0.00136890f, 0.04514599f, -0.00380282f, 0.14355315f, 0.08328848f, -0.16613036f, 
    0.00043137f, 0.05791459f, 0.03012054f, 0.05541764f, -0.05448382f, 0.16548802f, -0.07249666f, -0.04839924f, 
    -0.05222547f, -0.09922095f, -0.01723360f, 0.04648313f, 0.04162688f, -0.05300618f, -0.13820940f, -0.06950663f, 
    -0.04907722f, -0.01066453f, 0.11456343f, -0.00501262f, 0.04504465f, -0.16217925f, -0.27789652f, 0.09378140f, 
    -0.01087102f, -0.01000826f, 0.17303000f, -0.26811892f, -0.09834814f, 0.09481099f, -0.24170141f, 0.29004753f, 
    -0.01680654f, 0.03938683f, -0.06051664f, -0.03915232f, -0.08617245f, -0.15817533f, 0.05276632f, -0.03676584f, 
    -0.16179158f, 0.15291314f, 0.06682977f, 0.00455102f, 0.09107976f, 0.01243158f, -0.13039574f, -0.03525845f, 
    0.22863774f, 0.13234580f, 0.17529453f, 0.06859007f, 0.03033379f, 0.02998240f, -0.02569692f, -0.05756982f, 
    0.07551597f, 0.11382215f, 0.13818036f, -0.18628794f, 0.19719476f, 0.02691714f, -0.11620251f, 0.12082729f, 
    -0.10935485f, -0.06223636f, 0.19717123f, 0.00873471f, 0.32144150f, 0.02892496f, -0.08932995f, -0.10598838f, 
    0.17474717f, 0.00879399f, 0.07167327f, -0.01006594f, 0.02507322f, -0.02849155f, -0.25810772f, -0.10819212f, 
    0.11824960f, -0.33430052f, -0.21897297f, -0.07214088f, -0.00534693f, 0.09759805f, 0.14211659f, -0.04696102f, 
    0.05288615f, -0.00168867f, 0.02434505f, -0.04996779f, 0.01923991f, 0.13536039f, 0.03269377f, -0.01555651f, 
    -0.04113872f, -0.22196624f, 0.09759634f, -0.01845478f, 0.07122385f, 0.09172134f, -0.11527024f, 0.05443684f, 
    0.00519225f, 0.27924007f, -0.07653633f, 0.33177066f, 0.00840044f, 0.06496395f, 0.02287972f, -0.11693878f, 
    -0.09715884f, -0.06888709f, 0.03682788f, 0.22063032f, -0.13303769f, 0.01440293f, 0.01983464f, -0.04649399f, 
    -0.01086994f, 0.00689336f, -0.21327338f, 0.05367829f, -0.05002612f, 0.01039509f, 0.13002731f, -0.06724966f, 
    -0.00486209f, -0.22187443f, 0.01115924f, 0.22169806f, -0.08586922f, -0.23914038f, -0.08844078f, -0.02944843f, 
    0.07949085f, -0.03349340f, -0.00756858f, -0.00477711f, -0.13045384f, 0.04033725f, -0.08399672f, -0.05724390f, 
    -0.01450197f, 0.14941779f, -0.03005746f, -0.03763738f, -0.14116301f, 0.09684701f, -0.13268012f, -0.02425198f, 
    0.13190022f, 0.13841835f, 0.27809492f, 0.01508120f, 0.03539793f, 0.00009093f, 0.24109730f, 0.08386351f, 
    -0.14095168f, -0.01243963f, 0.07832928f, -0.05750999f, 0.18367624f, 0.05991361f, 0.21384546f, 0.18629733f, 
    0.01579060f, 0.09410027f, 0.22115365f, -0.02952327f, -0.01105012f, -0.01652301f, 0.01552765f, -0.13066022f, 
    -0.05013756f, -0.22846651f, -0.04060981f, -0.00776086f, 0.03583677f, -0.00908214f, 0.11929405f, 0.02802167f, 
    -0.07128285f, 0.01148428f, -0.06784802f, -0.13126639f, -0.07133900f, -0.33079621f, -0.14481281f, -0.09053797f, 
    0.06045005f, 0.05342932f, 0.08182976f, -0.03723669f, 0.08518389f, 0.09881502f, -0.05057552f, -0.01740005f, 
    0.22783121f, 0.00351379f, -0.03019109f, -0.04337280f, -0.06709903f, -0.07751722f, -0.02005499f, 0.09478939f, 
    -0.01111327f, 0.08173723f, 0.03774359f, 0.04938279f, -0.08039499f, 0.12051373f, 0.17250672f, 0.16801663f, 
    -0.01330252f, 0.03072150f, 0.13610685f, 0.00858908f, 0.00119608f, 0.13712774f, -0.06536505f, -0.19302741f, 
    -0.01016302f, 0.02343780f, 0.05229202f, -0.04915455f, 0.04639351f, 0.05826277f, 0.08200216f, -0.02224641f, 
    -0.10130410f, 0.03598581f, 0.00188678f, -0.00631462f, -0.01420467f, 0.22137173f, 0.29684493f, 0.06011794f, 
    -0.18335964f, -0.16378786f, 0.04362694f, -0.00441686f, -0.03273536f, -0.07173331f, -0.04231934f, 0.01018227f, 
    -0.09090390f, 0.04844230f, -0.03371799f, 0.10031121f, -0.05949076f, 0.09962640f, 0.04508118f, -0.16153717f, 
    0.01851117f, -0.06203174f, 0.08740975f, -0.21829867f, -0.05000866f, 0.06141321f, 0.11849582f, 0.15803976f, 
    -0.11135385f, -0.01329267f, -0.07436433f, 0.01475354f, -0.04417363f, -0.04733799f, -0.00773167f, 0.08701847f, 
    0.25207233f, 0.06391097f, 0.03271599f, 0.00326443f, -0.08252888f, -0.07602511f, -0.03161510f, 0.09642006f, 
    0.08429192f, 0.00757321f, 0.09165319f, 0.01038391f, -0.12847841f, -0.17270127f, -0.03922628f, 0.03234407f, 
    -0.08569519f, -0.04983743f, 0.03653399f, -0.10176396f, 0.16550472f, 0.02813587f, 0.03645631f, 0.10302076f, 
    0.06179188f, -0.02454237f, 0.14001882f, -0.14852774f, -0.02227611f, 0.18094872f, -0.00212668f, 0.06358370f, 
    -0.05791760f, -0.04763941f, -0.02166425f, 0.05593180f, 0.13001482f, 0.25199339f, -0.03252112f, -0.03465937f, 
    -0.19794536f, -0.26836249f, 0.16924141f, 0.11430414f, -0.04988388f, 0.08701590f, 0.03484075f, -0.01406609f, 
    0.06225719f, -0.03215585f, -0.03821053f, 0.01877396f, -0.02500861f, 0.01129291f, -0.01037247f, -0.07614711f, 
    -0.05415830f, -0.03484904f, -0.03116710f, -0.05576794f, 0.00696691f, -0.07148319f, 0.01242423f, 0.00103219f, 
    0.00770927f, 0.02896940f, 0.04235217f, -0.01681630f, -0.07521274f, -0.03579701f, 0.04903934f, -0.00383550f, 
    -0.04980114f, -0.04409048f, -0.04732867f, -0.07191455f, 0.03897691f, 0.05890934f, -0.05871055f, -0.06201002f, 
    0.04014432f, 0.02707167f, 0.00157712f, 0.01758018f, -0.03776637f, 0.00339621f, -0.02728377f, -0.05678702f, 
    0.04168815f, -0.03532485f, 0.06005796f, -0.06307890f, 0.02785859f, 0.05408331f, 0.02462663f, -0.00625671f, 
    0.01181177f, -0.06486905f, 0.03821509f, 0.06169000f, 0.04358416f, 0.01810069f, 0.00617737f, 0.04916729f, 
    -0.00945467f, 0.03420998f, -0.04112506f, -0.00752983f, 0.00378907f, -0.00379399f, -0.02767160f, 0.02802078f, 
    -0.01697975f, -0.02148269f, -0.02938939f, -0.06102187f, 0.01552563f, -0.06814311f, -0.00454636f, 0.02120161f, 
    -0.00840061f, 0.00849658f, -0.03359324f, -0.03334942f, 0.03610237f, 0.02739413f, 0.01343703f, -0.03967236f, 
    -0.03369904f, -0.05087546f, 0.05580771f, 0.01602952f, -0.02743471f, 0.02611011f, 0.03309504f, -0.04079474f, 
    -0.01963437f, -0.06184157f, -0.05484216f, 0.01201858f, -0.03411305f, -0.02873891f, 0.04613267f, -0.00626135f, 
    -0.06517965f, -0.02786856f, -0.06984967f, -0.05281726f, -0.02530441f, -0.07040186f, -0.01656417f, -0.02848086f, 
    -0.02336140f, -0.05735847f, 0.05883194f, 0.03095020f, 0.05957162f, 0.04656780f, 0.04360428f, -0.06639633f, 
    0.04810214f, 0.00039162f, -0.02962398f, -0.06414375f, 0.01669236f, 0.06187638f, 0.01356942f, -0.02698918f, 
    -0.06808351f, -0.00513822f, 0.02323080f, 0.03499769f, -0.07550836f, 0.01627055f, 0.01689078f, 0.00605311f, 
    0.03441171f, -0.04211138f, -0.01159560f, 0.00205654f, -0.04103509f, -0.06007476f, 0.00644011f, -0.03284818f, 
    0.05388383f, -0.06527855f, 0.01372178f, -0.00555749f, -0.02898495f, 0.01304178f, 0.02608620f, -0.03195510f, 
    0.00957052f, -0.06416900f, -0.06241499f, 0.02369178f, 0.02583305f, 0.01628849f, 0.04058011f, -0.06932986f, 
    -0.06808890f, -0.07092242f, -0.05135560f, 0.00512062f, -0.05531181f, 0.05646672f, 0.00466322f, -0.03379665f, 
    -0.04024072f, -0.04075593f, 0.04955652f, -0.07247817f, 0.05447743f, -0.04323733f, -0.06337159f, -0.00886498f, 
    0.02352735f, -0.04103213f, 0.01187849f, 0.00045331f, -0.02084237f, 0.03382420f, -0.02912264f, 0.02876816f, 
    -0.05487744f, 0.04666382f, -0.03564670f, -0.00530114f, -0.04527431f, 0.01360773f, 0.05268652f, -0.01303472f, 
    0.03510468f, 0.01722407f, -0.04737785f, -0.04299770f, -0.03170704f, -0.03701950f, -0.03169234f, -0.04746468f, 
    0.10538786f, 0.07490101f, -0.01914371f, -0.13531958f, 0.01628578f, -0.08718105f, 0.03242548f, -0.17323028f, 
    -0.02432176f, 0.05709465f, 0.12486628f, 0.07104013f, 0.06689382f, 0.02529624f, -0.10657535f, 0.03033000f, 
    -0.06748031f, -0.01300432f, -0.02505543f, -0.01685553f, 0.31240958f, -0.03695513f, 0.19059052f, -0.03948691f, 
    -0.04155878f, 0.02762685f, -0.01791889f, 0.19090746f, 0.07474728f, -0.05814473f, -0.07123192f, 0.04567298f, 
    -0.02021795f, 0.02773888f, -0.02013047f, 0.12490760f, 0.02608422f, 0.02452004f, -0.37047362f, -0.18480508f, 
    0.12101802f, -0.09899870f, -0.02125938f, -0.05660324f, -0.01016314f, -0.07119185f, 0.04599003f, 0.12297166f, 
    -0.10751946f, -0.04462087f, -0.13005511f, -0.25124028f, 0.09778100f, 0.13161148f, -0.08174907f, -0.05522746f, 
    0.12871455f, 0.19878915f, 0.15912278f, 0.14981911f, -0.05723916f, 0.23554821f, -0.03039995f, -0.22261694f, 
    0.08340955f, -0.04897382f, 0.04855568f, 0.02647513f, 0.06977686f, -0.01616457f, 0.12295547f, 0.13588475f, 
    -0.07302701f, 0.07497702f, 0.04795938f, 0.01685224f, -0.06570449f, 0.05812592f, -0.08014795f, -0.05041764f, 
    -0.03739664f, -0.02767663f, -0.09231623f, -0.08648343f, 0.18033651f, -0.16655734f, 0.06450681f, -0.09196514f, 
    -0.06275876f, 0.06036143f, -0.15597135f, 0.18645643f, -0.01411672f, -0.08137501f, 0.09838247f, 0.13075116f, 
    -0.08606317f, 0.02227252f, -0.04868698f, -0.03264543f, -0.02726504f, -0.06456215f, -0.07175458f, -0.04634378f, 
    -0.16337322f, -0.09467757f, -0.11028822f, -0.10700071f, 0.21386342f, -0.31592846f, -0.25798368f, -0.10569462f, 
    0.10961877f, 0.02076185f, -0.14021568f, -0.19912995f, 0.02036377f, -0.09396718f, -0.05393792f, 0.02140901f, 
    0.36815313f, 0.17734163f, -0.00253296f, 0.17063920f, 0.22993210f, -0.02990100f, 0.20444603f, 0.04542434f, 
    0.05020320f, 0.15823235f, -0.05937712f, 0.04223458f, 0.31841972f, -0.32004184f, -0.17024718f, -0.31970498f, 
    0.22980714f, 0.15700470f, 0.04084950f, 0.02083358f, 0.04634164f, 0.09224465f, 0.14868817f, -0.06015310f, 
    -0.53595233f, -0.02182284f, -0.32533070f, 0.32322457f, 0.01063502f, 0.13610154f, 0.17391950f, 0.15867007f, 
    -0.06681995f, 0.00611133f, -0.03622187f, 0.07215662f, 0.04434572f, 0.26095441f, -0.22686638f, -0.11126392f, 
    -0.05377278f, 0.14974761f, 0.20193511f, -0.10946891f, 0.01822420f, 0.15980464f, -0.00000507f, 0.02027894f, 
    -0.14000271f, -0.04465055f, -0.01198896f, 0.22922479f, 0.06498701f, -0.05335746f, 0.03309213f, -0.01320521f, 
    -0.07852261f, 0.20718300f, 0.04111134f, 0.03220770f, 0.04168199f, -0.06020405f, 0.11433739f, -0.05634727f, 
    0.10295224f, 0.17869180f, 0.05725205f, -0.08506819f, -0.03170076f, -0.01029610f, 0.02388407f, -0.01332935f, 
    -0.03890617f, -0.26127765f, -0.09715581f, -0.01904552f, 0.23007959f, 0.03010472f, 0.09896049f, -0.06148889f, 
    0.08963844f, -0.07929664f, 0.05759659f, 0.17814955f, -0.02692449f, 0.15202387f, -0.26100758f, 0.03994396f, 
    0.04162842f, -0.03372107f, -0.08097816f, 0.01659700f, 0.09726036f, -0.00672947f, -0.01799499f, 0.02276163f, 
    0.02189727f, -0.05109531f, 0.23948874f, -0.06196068f, -0.00254759f, 0.07672914f, 0.02760158f, 0.05172295f, 
    -0.11661543f, -0.09672637f, 0.05888079f, -0.26420325f, -0.23871075f, 0.12408391f, 0.21308927f, 0.17366835f, 
    0.17656723f, 0.01779174f, 0.06866081f, -0.19992262f, -0.06486545f, -0.13391897f, -0.10905997f, -0.10867628f, 
    -0.27011311f, -0.24176852f, 0.23525700f, 0.59615535f, 0.07499119f, -0.10146669f, 0.03573890f, -0.07459532f, 
    0.00762010f, -0.15929781f, -0.02855663f, -0.06047760f, -0.05829100f, -0.04714015f, -0.05510266f, 0.26098120f, 
    0.14874735f, -0.04432282f, -0.01714259f, 0.02242124f, 0.10429487f, -0.07677937f, -0.09151261f, 0.14045821f, 
    0.20846716f, 0.13722324f, 0.05481116f, 0.23245396f, -0.12517798f, -0.00755179f, -0.05129131f, 0.02912316f, 
    -0.07398310f, 0.00629190f, -0.10539681f, 0.02060111f, 0.00413331f, 0.13665739f, 0.27279928f, -0.04462382f, 
    0.08406052f, 0.12439939f, -0.03435222f, 0.06763435f, 0.01941963f, -0.00825796f, 0.04914543f, 0.16160227f, 
    -0.09674924f, -0.05387797f, 0.01227563f, 0.04055823f, 0.13427962f, 0.06516881f, 0.01241659f, -0.07317537f, 
    -0.03848091f, -0.08306944f, -0.06214637f, -0.07419009f, 0.02868789f, 0.16625774f, 0.26172426f, -0.13145027f, 
    0.02823110f, 0.08451197f, -0.08984035f, -0.10436253f, 0.01667218f, -0.16463692f, -0.10636616f, -0.01185434f, 
    -0.13319319f, 0.20143536f, -0.12567990f, -0.00559147f, 0.03440406f, 0.03948092f, -0.02857352f, 0.09456697f, 
    0.05570734f, -0.06028078f, 0.12676443f, -0.10957163f, -0.15943620f, 0.18391533f, 0.08699387f, 0.11811411f, 
    0.03784278f, -0.10611641f, -0.01220814f, -0.04950729f, 0.03130408f, 0.05164009f, 0.17889021f, 0.10021640f, 
    0.19960442f, 0.20483831f, 0.04471902f, -0.14691326f, -0.02056941f, -0.12718196f, -0.01489538f, 0.10220607f, 
    0.00258922f, 0.01566495f, 0.02935746f, 0.17418130f, -0.04549956f, -0.08034920f, -0.07809708f, 0.06984297f, 
    0.09686884f, 0.05918220f, 0.20660233f, 0.05614190f, 0.02683767f, 0.08161678f, 0.10090681f, 0.04297518f, 
    0.03601901f, -0.26441607f, 0.04709242f, -0.38020897f, 0.04454804f, 0.09923428f, 0.04005788f, 0.10043029f, 
    -0.02723048f, -0.04403612f, -0.20143026f, -0.12104681f, 0.06943538f, 0.32695609f, 0.07798110f, -0.00846375f, 
    0.02543580f, -0.08617169f, 0.09035645f, 0.08193255f, -0.03924195f, -0.09214068f, 0.08345264f, -0.02016790f, 
    -0.12008517f, 0.18388057f, 0.21798784f, -0.05247198f, 0.11026868f, 0.04247595f, 0.12616564f, 0.00037753f, 
    0.08186304f, -0.06813540f, 0.18397260f, 0.05830042f, 0.09190507f, -0.04045232f, 0.08016010f, 0.14114781f, 
    -0.02600341f, -0.08477051f, -0.07536655f, -0.15504868f, 0.13822378f, 0.09663009f, 0.14790842f, -0.02828521f, 
    0.01434834f, 0.12137040f, -0.12923934f, -0.16694100f, -0.04329189f, -0.05775595f, -0.15903464f, -0.26217735f, 
    -0.00948799f, -0.01261331f, -0.10048843f, 0.06714198f, -0.20116661f, 0.03289294f, -0.04392728f, 0.01933769f, 
    -0.11452232f, 0.02187009f, -0.10019708f, 0.06521608f, 0.05624517f, 0.00705781f, -0.00311328f, 0.00543624f, 
    -0.03427852f, -0.38444266f, 0.03411145f, 0.41078520f, -0.03524901f, -0.08261057f, -0.08355445f, -0.07788830f, 
    0.08354654f, 0.13056087f, 0.07537048f, 0.02695703f, 0.17608558f, -0.20028399f, 0.05448535f, 0.24944952f, 
    -0.00989317f, 0.05418722f, 0.02751625f, 0.02298014f, -0.07824221f, 0.18963717f, 0.05726250f, 0.00984683f, 
    -0.10190539f, -0.03886432f, -0.37907192f, -0.02397840f, 0.00672844f, 0.14939274f, 0.07061474f, 0.08454732f, 
    -0.06517442f, -0.04232751f, -0.01342077f, 0.01414519f, -0.15706128f, 0.48105124f, -0.15885167f, 0.02447883f, 
    0.03451764f, 0.03106881f, -0.02733087f, 0.00071395f, 0.10077819f, -0.12705995f, -0.05057894f, 0.16939132f, 
    -0.00225509f, -0.12476223f, -0.01562983f, 0.04208809f, -0.11725943f, 0.06344894f, -0.07555652f, -0.12039500f, 
    0.32313168f, 0.05029799f, 0.02266422f, -0.09549532f, 0.01409764f, 0.05712928f, 0.04763125f, -0.06671904f, 
    0.26226896f, 0.18012488f, 0.00418400f, 0.04635879f, 0.01518592f, -0.00108770f, -0.09692580f, -0.00138006f, 
    -0.27894297f, -0.02003141f, 0.02036078f, 0.28014085f, 0.08748569f, -0.11791513f, -0.00840425f, 0.17792746f, 
    0.17639850f, -0.01076927f, 0.00684981f, 0.09906695f, -0.17823918f, -0.05126025f, 0.13399905f, -0.02211314f, 
    -0.09681592f, 0.01043344f, 0.11234108f, 0.09411226f, 0.08088595f, -0.03692074f, 0.11027817f, 0.10218213f, 
    -0.19319475f, -0.17746641f, 0.11557931f, -0.63985139f, -0.07272235f, -0.01692533f, -0.02547530f, 0.21820763f, 
    -0.02578497f, 0.02806777f, 0.05341189f, -0.08485970f, -0.01664960f, -0.16585982f, 0.10800634f, -0.28216970f, 
    0.14772558f, 0.16788512f, 0.01566496f, 0.17337628f, -0.00553381f, 0.12537251f, -0.08684921f, -0.10443311f, 
    -0.11988341f, 0.19803981f, -0.19704685f, 0.04944495f, 0.02842821f, -0.14256938f, -0.05769277f, -0.04959954f, 
    0.08682135f, 0.08253698f, 0.12639540f, -0.08776128f, 0.10051795f, -0.20878045f, -0.10826886f, -0.29594868f, 
    0.13853917f, 0.15175954f, 0.05719244f, -0.09177553f, 0.00532513f, 0.08848344f, -0.04352725f, 0.03773059f, 
    -0.01945124f, -0.24697946f, -0.07786428f, 0.15468088f, 0.14694059f, 0.06503893f, -0.05637717f, -0.19206619f, 
    -0.09103590f, 0.06982384f, 0.10289825f, 0.12449137f, -0.05399167f, 0.21258257f, 0.00087509f, 0.16477460f, 
    -0.07421441f, 0.09138577f, 0.00502642f, 0.04450147f, 0.10342234f, 0.08147671f, 0.17099589f, 0.14243472f, 
    -0.10796896f, 0.15903996f, 0.28925884f, -0.00441157f, 0.01607624f, -0.06031287f, -0.03313030f, 0.09955760f, 
    0.02611954f, 0.03892674f, -0.08193336f, 0.02991490f, -0.18475424f, -0.11389940f, -0.09619031f, 0.22352464f, 
    -0.09260568f, 0.00179625f, -0.04515524f, 0.07425597f, -0.02832158f, 0.06727206f, -0.03502111f, -0.01281877f, 
    -0.19193077f, 0.11132114f, 0.10344439f, -0.14324293f, -0.11496934f, -0.09576348f, 0.02950888f, 0.01421227f, 
    0.17516594f, 0.22641404f, -0.07091753f, 0.18085539f, 0.13086981f, 0.24393481f, 0.17239396f, 0.11012086f, 
    0.12391348f, 0.04750344f, -0.07117210f, -0.12095281f, 0.14371394f, 0.04801494f, 0.06959482f, 0.14953108f, 
    0.31295639f, 0.08403676f, -0.00969569f, 0.06628568f, -0.03570407f, -0.05032472f, 0.00240130f, -0.03622268f, 
    -0.19387373f, 0.06857868f, -0.02818177f, -0.05867224f, 0.08660161f, -0.21166751f, 0.39718732f, -0.18730201f, 
    0.05341630f, 0.15844555f, 0.02102377f, 0.34460443f, 0.08316322f, 0.17428543f, 0.14886069f, 0.16974728f, 
    -0.19620897f, -0.04289045f, -0.03883497f, -0.01645063f, -0.02042672f, -0.11869290f, -0.07440108f, -0.15827900f, 
    -0.16399777f, -0.06631781f, -0.03114972f, 0.09200977f, -0.34956717f, -0.06639107f, -0.11683511f, 0.02763498f, 
    -0.14259399f, -0.07272559f, -0.08431398f, -0.31297141f, -0.02550678f, -0.01847408f, -0.09051759f, -0.02705524f, 
    0.12009801f, -0.10225505f, 0.47320303f, 0.31147906f, -0.14325891f, 0.09932992f, 0.26815695f, -0.07110339f, 
    -0.04939506f, -0.11220113f, 0.17251393f, 0.13928600f, -0.21103932f, 0.02628920f, -0.05314224f, -0.21825249f, 
    -0.05970834f, 0.13776255f, -0.02969602f, 0.11485907f, -0.10845756f, 0.15842581f, -0.00912049f, -0.10807373f, 
    0.01564769f, 0.31935188f, -0.03852293f, 0.22757809f, -0.04767516f, -0.03615007f, 0.04481760f, 0.17333123f, 
    -0.06908726f, -0.04012220f, 0.07966974f, -0.11017416f, -0.03777958f, -0.04435920f, 0.14070450f, 0.08374773f, 
    0.06558676f, 0.00995466f, 0.05019720f, -0.03390272f, 0.06912418f, 0.02563071f, 0.03148306f, 0.07476115f, 
    0.20129815f, -0.30624270f, 0.18876123f, -0.43738127f, -0.01074726f, -0.11864812f, 0.10248929f, 0.06355036f, 
    -0.06904374f, -0.10332137f, 0.08530978f, 0.13227931f, -0.19638044f, -0.28072006f, -0.22950859f, -0.19667038f, 
    -0.08313265f, -0.05925402f, 0.20199765f, -0.07256866f, 0.01873197f, -0.01573559f, -0.09748805f, -0.00464790f, 
    -0.13159096f, 0.13355249f, 0.25200126f, -0.03832716f, 0.12229086f, 0.03817401f, 0.03353604f, -0.03894073f, 
    0.10988606f, -0.02271873f, 0.04887855f, 0.08532308f, 0.16110009f, 0.09383215f, -0.25020951f, -0.00193611f, 
    0.13272996f, -0.06768905f, -0.06621655f, 0.06742828f, 0.12587804f, 0.09468625f, 0.16818240f, 0.05269794f, 
    -0.07060519f, -0.10827178f, -0.00517818f, 0.12573436f, -0.07066943f, 0.09405174f, 0.07111231f, -0.00930732f, 
    -0.00078430f, -0.08077055f, 0.05825022f, -0.02390550f, -0.22560589f, 0.07861166f, -0.26808766f, 0.08050700f, 
    0.07195340f, 0.01246294f, 0.01114601f, -0.01742655f, 0.02795459f, -0.04160762f, 0.12004086f, 0.07975685f, 
    -0.14292991f, -0.28519711f, -0.31866565f, 0.15153681f, 0.14603026f, 0.00686152f, -0.08136982f, -0.10943887f, 
    0.04305905f, 0.03811708f, 0.10544372f, 0.10155175f, -0.02878548f, 0.24793692f, -0.09337738f, -0.02355320f, 
    0.01568071f, -0.03417245f, 0.01334157f, 0.06206942f, -0.04032560f, 0.04684936f, -0.03785035f, 0.06463630f, 
    -0.09436595f, 0.06403013f, -0.00745938f, -0.00744926f, -0.10145674f, 0.15720774f, -0.10524242f, 0.08622291f, 
    -0.15047066f, 0.04413018f, -0.13166049f, -0.00333833f, 0.19429360f, 0.27677873f, -0.11827821f, 0.05042187f, 
    0.04465507f, 0.06120919f, -0.24491213f, -0.11852621f, 0.02786888f, -0.16857705f, 0.08511277f, 0.06456616f, 
    -0.03509793f, -0.07250318f, -0.06168047f, -0.00345945f, 0.05519409f, 0.07079261f, 0.02654268f, -0.04682423f, 
    0.07288808f, -0.01670023f, 0.11486318f, 0.04552565f, 0.12119540f, -0.16346389f, 0.00066872f, 0.14237277f, 
    0.04848102f, -0.00994946f, -0.12570216f, 0.01519703f, -0.00988962f, -0.08018994f, -0.01023745f, 0.01211971f, 
    -0.03539392f, 0.26508373f, -0.22982346f, 0.28558239f, 0.10008123f, -0.12670556f, -0.00417395f, 0.10815475f, 
    -0.05857093f, 0.16181943f, -0.00982728f, -0.04813125f, 0.14333642f, -0.23844996f, -0.09226759f, -0.08307654f, 
    0.14845848f, -0.12718049f, 0.12228835f, 0.05631126f, 0.16112748f, 0.08040083f, 0.18975346f, 0.07638820f, 
    -0.45345023f, -0.12748161f, -0.12657332f, 0.04156123f, -0.08730766f, 0.05417222f, 0.10263004f, 0.22611956f, 
    0.01573365f, 0.03402421f, 0.05759645f, 0.06384803f, -0.02385552f, 0.18811402f, 0.00893600f, -0.10106307f, 
    -0.03369714f, 0.17363109f, 0.04036963f, -0.02294666f, -0.05072999f, 0.10349236f, -0.06110698f, 0.02790884f, 
    -0.42135063f, 0.14071503f, -0.03968291f, 0.17015992f, 0.02124929f, 0.09700186f, -0.03791315f, 0.09762426f, 
    -0.10546646f, 0.03164173f, 0.09494723f, -0.05376066f, 0.03848788f, 0.16364625f, 0.17904375f, -0.07150455f, 
    0.18674017f, 0.18385009f, -0.03824819f, 0.00350644f, -0.03881533f, 0.02876405f, -0.05649111f, 0.06668624f, 
    -0.38290966f, -0.13719317f, -0.14042602f, 0.15388332f, 0.19714567f, 0.10796870f, -0.06244966f, 0.24665695f, 
    -0.05216857f, 0.12073804f, 0.33177060f, 0.04074029f, -0.05666293f, 0.16168787f, -0.05071261f, 0.05127832f, 
    -0.02395401f, -0.00592748f, -0.05853210f, -0.11329592f, 0.15371275f, -0.01980593f, 0.05949735f, -0.15476814f, 
    0.05713408f, -0.03087425f, -0.02506744f, -0.20558362f, 0.09846545f, -0.22895162f, -0.02737982f, 0.26905012f, 
    -0.22102477f, -0.16186850f, -0.18223327f, 0.02586392f, -0.11856253f, -0.14892562f, 0.11967444f, -0.00486323f, 
    0.01309819f, -0.01925971f, -0.29918459f, 0.39573830f, -0.22521436f, -0.20761739f, 0.13059381f, -0.09765633f, 
    0.07440215f, 0.20856433f, 0.07463692f, 0.28643581f, -0.00725468f, 0.05868415f, -0.13529368f, -0.07325239f, 
    -0.02014188f, 0.07365167f, 0.06145044f, 0.02970021f, 0.16396318f, 0.10863202f, -0.00743250f, 0.12322111f, 
    -0.06440209f, 0.10649358f, -0.05684122f, 0.07418922f, 0.06333137f, 0.08093178f, 0.14731887f, 0.16406268f, 
    0.37766293f, 0.07584590f, 0.04334122f, 0.15475333f, -0.13433184f, 0.00169316f, -0.04427512f, 0.01537529f, 
    0.08121761f, 0.08120525f, 0.05952465f, 0.04956458f, -0.17212155f, 0.05025610f, 0.16265957f, -0.21389930f, 
    0.10535211f, -0.03582318f, 0.14000547f, 0.23126687f, -0.07237728f, 0.11502486f, 0.08024719f, -0.06690028f, 
    -0.05561289f, 0.09321599f, 0.06854539f, 0.02049605f, 0.07757721f, 0.11293719f, 0.01617559f, -0.06251178f, 
    -0.17985310f, -0.20103687f, -0.10417020f, -0.13460079f, -0.29904956f, -0.16890356f, -0.28779480f, -0.24203400f, 
    -0.09612029f, -0.09074362f, 0.06323610f, 0.12369147f, -0.07378908f, -0.01158255f, -0.02531980f, 0.01028278f, 
    -0.16633141f, -0.19063944f, -0.19988188f, 0.05999523f, -0.15177821f, 0.17901203f, 0.00587513f, -0.21179102f, 
    -0.00771708f, -0.11736051f, 0.13690470f, -0.19556037f, 0.23072104f, -0.19244571f, 0.00668113f, 0.23770480f, 
    -0.03491974f, -0.12316762f, -0.04255227f, 0.10307845f, -0.01007144f, 0.10650175f, 0.21818528f, 0.08667251f, 
    0.12632090f, 0.08290526f, 0.18090288f, -0.36679652f, -0.04905706f, -0.02167252f, 0.09560478f, 0.26270106f, 
    0.02359642f, 0.19169538f, 0.14927903f, 0.05347566f, -0.13103744f, 0.10322388f, 0.05819632f, -0.01950700f, 
    0.35215178f, 0.28080454f, 0.09615275f, 0.21884353f, 0.02362316f, -0.02858313f, 0.04044814f, -0.14169720f, 
    0.04668229f, 0.11243435f, 0.14406839f, -0.24989852f, 0.01614835f, -0.07558104f, 0.34671667f, 0.03170888f, 
    0.03550234f, -0.08527419f, -0.07262103f, -0.06182470f, 0.19008288f, 0.26088339f, -0.09469953f, -0.10491729f, 
    -0.27543303f, 0.12087741f, -0.04115411f, -0.08904693f, -0.01721819f, -0.10329255f, 0.03580849f, -0.04418038f, 
    0.05271646f, -0.05567720f, -0.04663363f, 0.01308305f, 0.03785703f, 0.03310718f, -0.03586148f, 0.01626987f, 
    -0.05368319f, -0.07673645f, 0.00900350f, -0.01071359f, -0.01820634f, -0.06778727f, 0.06274043f, 0.01952322f, 
    -0.04883548f, -0.06303333f, 0.06104806f, 0.02046907f, -0.04743144f, 0.00810635f, 0.06176046f, -0.05352857f, 
    0.02358365f, 0.00916809f, -0.07595444f, -0.03157626f, -0.04332857f, -0.01455934f, -0.02471359f, -0.05615200f, 
    -0.06102341f, -0.02403752f, 0.01787072f, -0.04594563f, -0.06485892f, -0.06349090f, 0.01336156f, -0.04256935f, 
    0.06312532f, -0.00733984f, -0.06224683f, 0.01159722f, 0.00262773f, 0.00828478f, -0.07104876f, -0.04424516f, 
    -0.07769345f, 0.04259128f, -0.05105776f, -0.05173083f, 0.04987894f, -0.06841256f, -0.01904130f, -0.00050760f, 
    0.02626105f, -0.06593797f, 0.02116632f, 0.00245662f, 0.03426151f, 0.02747723f, -0.07624707f, 0.03933200f, 
    -0.07129250f, -0.04117071f, 0.03028126f, 0.02471489f, -0.00787511f, 0.01268717f, 0.04537869f, 0.01825522f, 
    -0.00069117f, 0.05531447f, -0.02151080f, -0.05174730f, -0.07198460f, -0.03574656f, 0.00501100f, -0.02856872f, 
    -0.02112313f, 0.00328082f, -0.02895015f, -0.03877447f, -0.01876840f, -0.02835893f, -0.03870533f, -0.02241524f, 
    0.00373254f, -0.01712595f, -0.05535065f, -0.04430902f, -0.06681413f, -0.01239684f, 0.02029112f, 0.01537744f, 
    -0.00084381f, -0.02190783f, -0.06523877f, -0.06679077f, -0.04626242f, 0.00812243f, 0.05075445f, -0.05244686f, 
    -0.01697638f, -0.00387043f, -0.06657268f, -0.06267297f, -0.07821370f, -0.05531854f, -0.00288293f, 0.00779776f, 
    0.01063992f, 0.02632411f, -0.01983039f, 0.04077537f, -0.04547152f, -0.02603448f, -0.03942357f, 0.02905016f, 
    0.05689457f, 0.05157891f, -0.07097694f, 0.02230820f, -0.05837055f, -0.04358063f, -0.05557982f, 0.04054733f, 
    0.04267002f, 0.03917708f, -0.00185036f, 0.04628590f, 0.05445250f, -0.01172827f, -0.04859485f, -0.06669489f, 
    0.02489723f, 0.01292469f, -0.00508981f, -0.02474434f, 0.03425792f, -0.01501117f, 0.05962624f, -0.01314492f, 
    0.02229659f, -0.08016846f, -0.00392620f, 0.04549162f, -0.03565634f, -0.06930365f, 0.01980124f, -0.04265933f, 
    0.05516000f, 0.03370057f, -0.00622625f, 0.01428712f, -0.04265315f, -0.00648887f, 0.04596924f, 0.02550274f, 
    0.00399927f, 0.01932095f, -0.04270805f, -0.05032406f, 0.04754117f, 0.04478730f, -0.00465791f, 0.01299772f, 
    -0.05445280f, -0.00291923f, -0.04679234f, 0.04016390f, -0.01725938f, 0.03155822f, 0.06232495f, 0.01386997f, 
    -0.01690656f, -0.03334975f, 0.05872679f, 0.05370538f, -0.07038567f, 0.01744062f, 0.02741114f, 0.05629886f, 
    0.00859771f, -0.06173494f, 0.05396919f, -0.03861661f, 0.03608384f, -0.02682405f, -0.00024167f, -0.03263645f, 
    0.11601810f, 0.06645295f, 0.16965620f, -0.27997428f, 0.04121864f, 0.09000624f, 0.15048763f, 0.03733831f, 
    0.06138869f, -0.10319284f, 0.12027800f, 0.01894587f, 0.04825655f, 0.00888836f, -0.06686584f, 0.00898576f, 
    0.17101988f, -0.07823689f, -0.04826759f, -0.25962523f, 0.11803760f, 0.02485293f, -0.02790255f, -0.03440919f, 
    0.06733083f, 0.08562195f, -0.32386547f, -0.24956343f, -0.01720444f, 0.09211369f, -0.13177663f, -0.12526187f, 
    -0.05271772f, -0.04532836f, -0.01503136f, -0.00718831f, -0.01967669f, 0.16379009f, -0.00306555f, -0.04269469f, 
    -0.08085061f, -0.04121481f, -0.06248223f, 0.15662290f, 0.04617635f, -0.06043959f, -0.03961066f, 0.07019933f, 
    -0.03258334f, -0.22707023f, 0.00542624f, 0.32409325f, 0.11271040f, 0.03987371f, -0.02126468f, -0.09386352f, 
    0.10326033f, 0.08811108f, 0.08309766f, 0.02408622f, 0.07023969f, -0.49320588f, 0.09122732f, 0.12412770f, 
    -0.00296389f, -0.00953819f, 0.06370746f, -0.08504583f, -0.06259844f, 0.12368410f, -0.11489600f, -0.05887971f, 
    0.03519654f, -0.09523721f, -0.24350324f, 0.19646518f, 0.03893404f, 0.17906925f, -0.02513532f, 0.25874102f, 
    -0.03529868f, -0.20981051f, -0.02537612f, -0.13116001f, -0.26055112f, 0.36751810f, -0.18358357f, 0.10390820f, 
    0.12322741f, -0.00411709f, 0.08823782f, -0.06807382f, 0.06171134f, -0.09153818f, -0.02350307f, 0.10016140f, 
    -0.03913373f, -0.02228239f, -0.00655025f, 0.10481111f, -0.19083717f, 0.10941956f, 0.06298843f, -0.18464123f, 
    0.16865368f, -0.02197289f, -0.04237646f, -0.26386884f, 0.34958652f, 0.11760594f, -0.04392100f, -0.20577125f, 
    0.17164838f, 0.17137901f, -0.01284870f, -0.01980101f, -0.06461905f, 0.04588471f, -0.04192339f, -0.00779503f, 
    -0.16834047f, 0.14315794f, 0.01116096f, 0.00053668f, 0.12011003f, -0.10713748f, -0.05345878f, 0.18468827f, 
    0.03359631f, 0.08192132f, 0.03321440f, 0.13118093f, 0.00322057f, 0.08193492f, 0.15094468f, -0.05310462f, 
    0.03675415f, 0.03609928f, 0.10887323f, 0.10236826f, 0.13106312f, -0.02503077f, 0.12584852f, 0.05395727f, 
    -0.10308196f, -0.21747085f, -0.12321950f, -0.32974252f, 0.02116118f, -0.00731706f, -0.03360201f, 0.22905442f, 
    -0.00065481f, 0.06814901f, 0.06509314f, 0.02309857f, 0.02231857f, -0.07576957f, 0.09609672f, -0.25637206f, 
    0.04370634f, 0.10063609f, 0.18570770f, 0.26785120f, -0.10546602f, 0.12899911f, 0.06488889f, -0.06341657f, 
    -0.11839448f, 0.02805119f, -0.11774690f, 0.11332052f, 0.21979100f, -0.11046587f, 0.07285876f, -0.01616574f, 
    -0.05319191f, 0.03204878f, -0.04731395f, 0.03804328f, -0.11190261f, 0.06401312f, -0.00317923f, -0.12479233f, 
    0.08186964f, 0.02486692f, 0.09991374f, 0.11076718f, 0.00730424f, 0.01171694f, -0.05559298f, -0.07628482f, 
    0.00373949f, 0.01300267f, -0.04634126f, -0.00606738f, -0.02678519f, -0.05409502f, 0.00998280f, 0.06206138f, 
    0.02423918f, -0.00535953f, -0.02481085f, 0.03726872f, -0.04047042f, -0.04605468f, -0.06329059f, 0.01803105f, 
    -0.03933929f, -0.01910709f, 0.04387206f, 0.03635925f, -0.00197155f, 0.00350055f, 0.04213540f, -0.05275548f, 
    -0.04374965f, -0.00138119f, 0.00915859f, -0.06836372f, -0.07089695f, 0.05550304f, -0.00027920f, 0.04382967f, 
    0.03129890f, -0.03396151f, 0.05519982f, -0.02408484f, -0.00806654f, -0.01298805f, 0.01049100f, -0.02008790f, 
    0.07102494f, 0.06243648f, 0.02952133f, -0.02781678f, -0.07543026f, -0.02001684f, 0.06199935f, -0.06494983f, 
    0.01565409f, 0.03138204f, 0.02946913f, -0.07615090f, -0.05530999f, 0.04370543f, -0.05852969f, 0.03988745f, 
    -0.02035398f, 0.04980873f, -0.01515964f, -0.01289732f, -0.00299386f, -0.00572256f, -0.02022870f, 0.00428321f, 
    0.02928288f, -0.05725335f, 0.05157426f, -0.07164456f, 0.01059064f, -0.02913630f, -0.00364099f, 0.05068954f, 
    -0.02403581f, -0.05623870f, 0.03544271f, 0.00215775f, 0.03875014f, 0.04045996f, 0.00373934f, 0.02387484f, 
    -0.03126131f, -0.04036431f, 0.01619426f, -0.07883871f, 0.04581207f, 0.03576291f, 0.02981528f, -0.00238460f, 
    -0.00121768f, -0.06678864f, 0.01868455f, -0.06450368f, -0.04086416f, 0.04573565f, -0.05724207f, -0.00219224f, 
    0.03587214f, 0.03287736f, -0.01288270f, 0.02358402f, 0.02410433f, -0.05323542f, -0.07817491f, 0.01157702f, 
    -0.04904021f, -0.06862966f, -0.04330654f, -0.07302552f, 0.04257052f, -0.04468633f, 0.00371722f, -0.04920390f, 
    0.00565227f, 0.01373773f, 0.06951363f, -0.05382382f, 0.02064779f, -0.04752611f, -0.05260110f, -0.08404451f, 
    -0.06807629f, 0.05700989f, -0.03985803f, 0.06579807f, 0.04600215f, 0.02198227f, 0.02458773f, -0.01727651f, 
    -0.06980155f, 0.05407401f, 0.04363866f, -0.08063769f, 0.02706192f, -0.04679483f, -0.01290193f, 0.06756260f, 
    0.05090299f, -0.00351294f, -0.07869206f, -0.04800337f, 0.00184993f, -0.07405704f, -0.06481517f, -0.02305682f, 
    -0.05338953f, -0.03802474f, 0.05476467f, 0.05926847f, -0.02119539f, 0.01476049f, -0.08453068f, 0.02268382f, 
    -0.06652901f, -0.00575867f, -0.03578977f, 0.00972701f, -0.05653047f, 0.00793095f, -0.06460752f, 0.05114167f, 
    0.05099288f, -0.06344744f, -0.07112364f, -0.03095826f, -0.04587876f, 0.03698201f, 0.05252553f, 0.05720262f, 
    0.00099917f, 0.04492619f, -0.06881653f, 0.00993125f, 0.00285219f, -0.03847129f, 0.03653500f, -0.03600304f, 
    0.01435751f, -0.06228177f, 0.04083406f, 0.04678179f, -0.04884275f, 0.02342184f, -0.06000686f, 0.05421835f, 
    0.01053104f, 0.01831451f, -0.04019681f, -0.01776628f, -0.02898310f, 0.01740401f, -0.03741880f, -0.08086137f, 
    -0.21366395f, -0.18145624f, 0.08374182f, 0.30405599f, 0.04575443f, -0.02547438f, -0.13965456f, 0.10454366f, 
    -0.01308254f, -0.00951607f, 0.00860140f, 0.09385909f, 0.01905065f, 0.06329010f, 0.00429992f, 0.00547923f, 
    -0.01250312f, 0.15440843f, -0.03839140f, -0.01145736f, -0.09322090f, 0.09736394f, -0.12126457f, 0.00854263f, 
    0.03610570f, -0.05148525f, 0.27110907f, 0.17433651f, -0.00804681f, -0.14194912f, 0.11107833f, 0.12051427f, 
    -0.00409810f, -0.06952289f, 0.12802435f, -0.00089503f, -0.01658445f, -0.11930940f, 0.11526409f, 0.14993203f, 
    0.09229309f, 0.10250348f, 0.06725768f, 0.07417253f, -0.08265448f, -0.12274110f, -0.02017633f, 0.03647039f, 
    0.36128443f, 0.22213739f, -0.03989118f, 0.17362653f, 0.06148750f, -0.00762602f, 0.01759880f, -0.05919969f, 
    -0.07250146f, -0.07263408f, -0.07366212f, -0.04634155f, -0.00831243f, 0.18104182f, -0.09917377f, 0.18656370f, 
    0.04442777f, 0.10880551f, 0.06852988f, -0.02017614f, 0.02072250f, 0.15850869f, -0.02938333f, -0.09345669f, 
    0.28958681f, 0.25612423f, 0.30435982f, -0.04557929f, -0.01123946f, 0.07398382f, 0.06282213f, 0.14593202f, 
    0.09958163f, 0.06491309f, 0.09290510f, -0.05193486f, 0.10231702f, 0.18763772f, 0.09816605f, -0.05364759f, 
    0.05395013f, 0.02687144f, -0.02584922f, -0.17610598f, -0.08426708f, -0.00692147f, -0.02985885f, -0.13722408f, 
    0.06287450f, 0.04165955f, -0.01098564f, -0.09990663f, 0.18321982f, 0.22697458f, 0.16922911f, -0.01361685f, 
    -0.03228089f, 0.01365348f, 0.01259436f, -0.01985048f, -0.35075992f, 0.03602260f, 0.11956736f, 0.23999043f, 
    -0.07474428f, -0.10718223f, 0.05661906f, 0.21562412f, -0.07355384f, -0.02815831f, -0.07964019f, -0.14159761f, 
    -0.20559660f, -0.06704120f, -0.19750766f, 0.16462722f, -0.16054606f, 0.16712721f, -0.25296366f, -0.28252897f, 
    0.03095045f, -0.14129685f, 0.06778398f, 0.00000753f, -0.02723006f, -0.01819886f, -0.06504152f, 0.25609854f, 
    -0.09639009f, -0.00741753f, -0.04808561f, -0.02340092f, -0.01002923f, 0.09689508f, -0.00160019f, 0.13295917f, 
    -0.04152746f, -0.00775232f, 0.21293063f, -0.11447275f, -0.07270370f, -0.15624577f, -0.05212191f, -0.03338017f, 
    0.07127036f, 0.06193352f, -0.01123273f, 0.10860840f, -0.12286020f, 0.00275530f, 0.04069177f, 0.12183543f, 
    0.03217807f, 0.06164706f, 0.01448664f, 0.01375830f, 0.13842097f, 0.05461056f, -0.01390007f, -0.06898446f, 
    -0.12712099f, 0.19091690f, 0.30612987f, -0.03655507f, 0.09046800f, 0.13092643f, -0.16106226f, 0.22148010f, 
    -0.04506183f, -0.16483776f, -0.08000816f, 0.06382331f, 0.33165318f, 0.34008405f, 0.00605059f, -0.05056940f, 
    -0.10670993f, -0.06686651f, 0.03749104f, 0.17596088f, 0.04130582f, 0.06159967f, 0.00063142f, -0.03708536f, 
    0.03784903f, -0.07171304f, 0.30746320f, -0.06495739f, 0.07626522f, 0.05008871f, 0.08173671f, 0.01170320f, 
    0.19621433f, 0.14217870f, 0.00973192f, -0.05296968f, 0.20690499f, -0.17306997f, -0.02326790f, 0.01502883f, 
    0.02374626f, -0.11799699f, -0.01741732f, -0.09427606f, 0.01229583f, -0.02243089f, 0.02937935f, -0.01752309f, 
    -0.04611360f, -0.03000007f, -0.10265878f, -0.28001997f, 0.05118204f, -0.00720637f, -0.02622042f, -0.04338657f, 
    -0.08788501f, 0.10909863f, 0.00970323f, 0.01134756f, -0.08645764f, -0.13796465f, -0.07473040f, 0.14423999f, 
    -0.12597413f, -0.04342563f, -0.08466949f, 0.11009105f, -0.02931968f, 0.00196870f, 0.02327925f, -0.02937106f, 
    0.11231695f, -0.27556771f, -0.18900168f, 0.34277576f, -0.03569414f, -0.11401635f, -0.08365329f, -0.06257217f, 
    0.11096974f, 0.03857193f, 0.19087957f, 0.14332496f, 0.13622692f, -0.03070212f, 0.05325333f, 0.13947110f, 
    -0.17899233f, -0.00512399f, 0.05008958f, 0.03340774f, -0.00551495f, 0.03627120f, 0.13610280f, -0.07852626f, 
    -0.13679394f, 0.01464629f, -0.31140348f, -0.07360752f, 0.06849930f, 0.01055288f, -0.03931606f, -0.05821910f, 
    -0.06728818f, -0.06156946f, 0.00154927f, -0.03934489f, -0.20566861f, 0.48519525f, -0.09847187f, 0.20598406f, 
    0.01859421f, 0.11797003f, -0.02927630f, 0.03034846f, 0.24431661f, -0.02757478f, 0.05270868f, -0.03089514f, 
    -0.07601689f, -0.00380018f, -0.04039848f, 0.05965673f, -0.03217354f, 0.02252664f, -0.02929920f, 0.06221973f, 
    0.16449930f, 0.04591050f, -0.01655970f, 0.00579635f, 0.04606958f, 0.01252109f, 0.06715668f, -0.04081643f, 
    0.06950881f, 0.10085285f, 0.13755456f, 0.10138875f, -0.08165078f, 0.00677429f, -0.04290082f, -0.01499357f, 
    -0.15400951f, -0.00581196f, -0.31641343f, 0.25097868f, 0.01216596f, 0.04635112f, 0.01265079f, 0.09168722f, 
    0.03165897f, 0.09662675f, -0.16077280f, -0.01811966f, -0.16549683f, -0.13906120f, 0.01980611f, -0.04876591f, 
    -0.01842229f, -0.01113550f, 0.08043421f, 0.19199114f, 0.10929640f, -0.08928327f, 0.09037604f, 0.05665728f, 
    -0.09838259f, -0.08944666f, 0.24159394f, -0.33078760f, -0.03923093f, 0.04344355f, -0.04795801f, 0.12240101f, 
    0.04272794f, 0.01470442f, 0.09619303f, -0.01446230f, 0.16360302f, -0.25721040f, 0.03448423f, -0.13120626f, 
    -0.02892366f, 0.13516264f, -0.05415637f, 0.12469788f, 0.00623547f, 0.00473903f, -0.00137320f, 0.00063300f, 
    -0.14411147f, 0.23918262f, -0.12458853f, 0.02988375f, 0.08418911f, -0.15540750f, 0.01670458f, -0.03621019f, 
    0.03731437f, 0.13162307f, 0.10935352f, -0.03484901f, 0.09677113f, -0.09317445f, -0.04068767f, -0.11413391f, 
    0.01856470f, 0.13582931f, 0.11429869f, -0.11776467f, -0.07194956f, 0.02882959f, -0.06386407f, -0.01539815f, 
    -0.07693239f, 0.36087567f, -0.08204619f, 0.09833947f, -0.01954664f, 0.14800484f, 0.08681691f, 0.17042127f, 
    0.09806769f, -0.08393779f, 0.00121862f, -0.11648554f, -0.09136193f, 0.08434270f, 0.19980927f, -0.06049203f, 
    -0.04384300f, 0.07405503f, -0.28196171f, -0.40051392f, 0.02219231f, 0.10716882f, -0.07633054f, -0.04156964f, 
    0.18100423f, -0.04020348f, -0.20679767f, -0.23533635f, -0.07427371f, 0.19866982f, 0.03066547f, 0.02419376f, 
    0.07222012f, -0.01547253f, -0.07245640f, -0.01378104f, 0.12860230f, 0.01043888f, 0.14179088f, -0.01073831f, 
    -0.02064912f, 0.05707018f, -0.15020800f, 0.32924202f, 0.25449464f, -0.05891378f, -0.08991990f, -0.02710310f, 
    0.07463749f, 0.24160223f, 0.07502507f, 0.12313963f, -0.00390154f, -0.01196315f, -0.18115695f, -0.17726637f, 
    0.04170923f, -0.03848961f, 0.05780060f, 0.09016058f, 0.06426325f, -0.21789911f, 0.22541955f, 0.23539583f, 
    -0.12901749f, 0.15149453f, -0.11936051f, 0.06485179f, 0.10737116f, 0.03387329f, -0.13567813f, -0.02477460f, 
    -0.07917712f, -0.03815248f, -0.00739351f, -0.02143707f, -0.03630669f, -0.03147846f, 0.02064240f, 0.14674912f, 
    0.04663161f, -0.04115228f, 0.04127036f, -0.01404626f, -0.34117636f, 0.17121564f, -0.08374957f, 0.16860504f, 
    0.09589964f, 0.04853469f, 0.29016495f, -0.05103726f, -0.03480915f, -0.03415938f, -0.14243929f, 0.12791903f, 
    0.09383169f, -0.04240911f, -0.12701432f, -0.17850003f, -0.04212160f, 0.13912059f, 0.02727749f, -0.02211083f, 
    0.09500214f, 0.13900535f, -0.01297933f, -0.03119257f, 0.03560808f, 0.24358720f, -0.01662247f, -0.01433744f, 
    0.17917854f, 0.00657877f, 0.14543538f, 0.20896943f, -0.08776264f, 0.09719252f, -0.01947651f, -0.00210767f, 
    -0.31944171f, 0.12321109f, 0.10839191f, -0.10319541f, -0.05000926f, 0.09767710f, -0.14492837f, 0.05686393f, 
    -0.04452779f, -0.09237153f, 0.11049455f, 0.18020545f, 0.03595299f, 0.15369873f, -0.03639353f, 0.11724150f, 
    0.09510367f, -0.10765379f, 0.03569661f, -0.04138096f, 0.18532440f, -0.05883730f, -0.02731299f, -0.12994890f, 
    0.29160571f, -0.33130464f, 0.14400311f, -0.52230895f, -0.10685056f, -0.14892220f, -0.14698261f, -0.03000629f, 
    0.00296137f, 0.01824403f, -0.02155249f, -0.15208960f, -0.12509410f, -0.15141408f, 0.26567715f, 0.02702150f, 
    0.02499985f, 0.09242312f, -0.09020533f, 0.13663644f, -0.08900142f, -0.01181756f, 0.02103322f, 0.04354684f, 
    -0.08966135f, 0.05156638f, 0.02853050f, 0.09615339f, -0.00343004f, -0.01566607f, -0.01090809f, 0.11007412f, 
    0.06404971f, -0.04763126f, 0.01827844f, 0.10467987f, -0.01066464f, -0.03732146f, -0.00200725f, -0.11249401f, 
    -0.08812653f, 0.05613518f, 0.02469139f, 0.04529044f, -0.07088088f, 0.05359219f, -0.05553148f, -0.07247476f, 
    0.06620125f, -0.34132105f, 0.12295264f, -0.13455513f, 0.06411114f, -0.04865830f, 0.06122962f, -0.17355128f, 
    0.12927148f, 0.19040415f, 0.06076371f, 0.03249798f, 0.03994184f, -0.07442850f, -0.14531633f, 0.02261648f, 
    0.01989602f, -0.03071738f, -0.07613924f, 0.00480800f, -0.06519809f, -0.03393450f, 0.09852780f, 0.00470993f, 
    -0.17724375f, 0.04546137f, 0.08296176f, -0.25230920f, 0.06254496f, -0.03137752f, -0.04009379f, 0.07554691f, 
    -0.01339217f, 0.05424288f, -0.10663021f, 0.03591203f, 0.03685093f, -0.21006168f, 0.08474894f, 0.07544044f, 
    -0.02563114f, -0.01938164f, -0.03101236f, 0.14374477f, -0.10490952f, -0.01032467f, 0.10490755f, -0.05181566f, 
    0.03088089f, -0.49481654f, -0.04270217f, 0.26540026f, 0.01656882f, -0.07945973f, -0.07947508f, 0.05417607f, 
    0.24157616f, 0.13537149f, 0.17649959f, 0.09896422f, 0.06994699f, -0.23421679f, 0.08030994f, 0.08601966f, 
    0.00878309f, 0.00532240f, 0.04559397f, -0.06771404f, 0.06925634f, -0.04467130f, 0.01736540f, -0.13132253f, 
    0.21785250f, 0.08047993f, -0.06406195f, 0.02817655f, 0.02361239f, 0.13438487f, -0.02048874f, -0.00440990f, 
    0.05832234f, -0.00926922f, -0.00033328f, -0.01071229f, -0.21670620f, 0.36959940f, -0.03991149f, 0.07387006f, 
    0.08364585f, 0.06328956f, -0.10797089f, 0.20599562f, 0.16974916f, 0.04143035f, 0.08878946f, -0.17493540f, 
    -0.07746899f, -0.08935685f, 0.01190258f, -0.01454975f, 0.00444525f, 0.12478237f, 0.04127983f, 0.04450022f, 
    0.10223540f, -0.09658479f, 0.01915503f, -0.07862151f, 0.01777738f, 0.12527755f, 0.11224301f, -0.10662008f, 
    -0.03935894f, -0.03604845f, 0.05675336f, -0.06635562f, 0.01631832f, -0.04342968f, 0.06285930f, -0.03101331f, 
    -0.01094589f, 0.00527849f, -0.11770706f, 0.13586400f, -0.06608159f, 0.02360838f, 0.13452250f, 0.08190292f, 
    0.13964333f, 0.19688261f, -0.15784563f, 0.06709750f, -0.18259220f, -0.03038668f, 0.06871816f, -0.01226876f, 
    -0.09214384f, -0.00886024f, 0.06315646f, 0.03789530f, 0.10675362f, 0.07374409f, 0.13296656f, 0.05289422f, 
    0.09858429f, 0.18492734f, 0.22611456f, -0.11119917f, 0.00930998f, 0.06548022f, 0.07063226f, 0.16614677f, 
    0.10627889f, 0.03375337f, 0.17746578f, 0.02902183f, 0.22036016f, -0.27372804f, 0.07899714f, -0.08629502f, 
    -0.02398264f, -0.01928809f, 0.03800953f, 0.04405275f, -0.02518491f, 0.08295044f, 0.06621823f, -0.15685454f, 
    -0.01891908f, -0.01826693f, -0.13293110f, -0.12236612f, 0.11174159f, -0.22120267f, 0.08154330f, -0.00584354f, 
    0.01862995f, 0.16782081f, -0.09859487f, -0.06105391f, 0.10154741f, 0.06183963f, -0.04487637f, -0.07006457f, 
    0.03375352f, 0.16329403f, 0.21297903f, -0.00488815f, -0.05112094f, -0.02308427f, 0.01254044f, -0.05105043f, 
    0.20542206f, 0.00512796f, 0.02169994f, -0.06313815f, 0.06041368f, -0.19778922f, 0.05633599f, 0.10364075f, 
    0.10748055f, 0.19400269f, -0.06085865f, 0.07172251f, 0.07689723f, 0.20607679f, -0.02744051f, 0.07632340f, 
    -0.08582374f, -0.01701106f, -0.00858461f, 0.03710702f, 0.09618603f, 0.04230433f, 0.08508257f, 0.14917977f, 
    0.08521675f, -0.12249853f, 0.02871518f, -0.06711266f, 0.04554478f, 0.23286450f, 0.22013122f, 0.01705672f, 
    -0.13497485f, 0.01241956f, -0.06096309f, -0.00600715f, 0.36204296f, 0.07153022f, -0.15113381f, 0.09211269f, 
    -0.10133830f, -0.02736197f, 0.13094412f, -0.09329300f, 0.17302646f, -0.11252712f, 0.02137864f, 0.06351674f, 
    0.05518636f, -0.25342917f, -0.19285531f, -0.08169486f, -0.06519805f, -0.06139144f, 0.08551920f, -0.03467278f, 
    -0.05681724f, -0.02531973f, 0.00230597f, -0.00144887f, 0.18830092f, -0.22689135f, 0.17110366f, -0.06372935f, 
    -0.01175651f, -0.08591050f, 0.05050056f, 0.00046914f, 0.20830022f, 0.06362110f, -0.00646386f, 0.15811878f, 
    0.15604323f, 0.10846049f, 0.07139336f, 0.04850669f, 0.00831636f, 0.04236671f, -0.06441648f, 0.01381297f, 
    0.02653409f, -0.07150452f, 0.06623916f, 0.07612152f, -0.18738660f, 0.04723519f, -0.11769593f, 0.19232395f, 
    -0.06838591f, 0.05148788f, -0.05170030f, 0.01750368f, 0.11961044f, 0.15799542f, -0.07090043f, 0.03756630f, 
    0.01064260f, 0.08460826f, -0.02307824f, 0.07056985f, 0.07604542f, -0.03549983f, -0.02522918f, -0.02375189f, 
    -0.04248994f, -0.10060841f, 0.03794631f, 0.03555601f, 0.29600480f, 0.24471638f, 0.25595295f, -0.06036608f, 
    -0.00464052f, -0.05990074f, 0.16882044f, 0.17217697f, 0.01565330f, 0.05267077f, 0.03538914f, 0.02000866f, 
    -0.00966457f, 0.36864078f, 0.13593926f, 0.19250639f, 0.10396466f, -0.05002137f, -0.02200067f, 0.03016516f, 
    0.01492824f, -0.02824111f, 0.03103503f, -0.04804923f, -0.02913433f, 0.18618914f, 0.04584070f, 0.01102802f, 
    0.09651578f, 0.07625356f, 0.09007504f, 0.07895628f, 0.05134660f, 0.00437675f, -0.09239104f, -0.11195535f, 
    0.31204194f, -0.26018339f, -0.24003164f, -0.07649007f, -0.03433482f, 0.01470361f, 0.09219941f, 0.13730893f, 
    0.05285811f, -0.16391987f, -0.08145437f, 0.03241014f, 0.21074539f, -0.06767865f, 0.00560755f, -0.13980499f, 
    -0.28106108f, 0.01629045f, 0.06013006f, -0.04871455f, 0.07771499f, -0.00542805f, -0.00213286f, 0.02453616f, 
    -0.15511863f, -0.06817566f, 0.02954677f, 0.04760819f, 0.07188101f, 0.24256685f, -0.14275503f, -0.10897160f, 
    -0.20088160f, -0.04585496f, -0.08157724f, -0.04202961f, 0.14378263f, 0.24402209f, 0.15354256f, -0.11922160f, 
    -0.04535521f, -0.28369924f, -0.00986410f, -0.06225923f, -0.04242991f, 0.03299814f, -0.01027250f, 0.03341369f, 
    0.00307668f, -0.05148355f, 0.04810150f, 0.05797606f, 0.01095489f, 0.01276857f, -0.00558517f, -0.06938481f, 
    0.01390587f, -0.07558961f, -0.06391594f, -0.02190957f, 0.02851251f, -0.05223235f, -0.01779659f, 0.03538653f, 
    0.03400670f, 0.02870743f, -0.04937973f, 0.05868016f, 0.02692827f, 0.04372234f, -0.04838012f, -0.01569665f, 
    -0.06357168f, -0.00014789f, 0.01107448f, -0.07901090f, 0.01727932f, 0.04461491f, -0.04382151f, -0.01517652f, 
    -0.08052239f, 0.04406858f, -0.03768116f, 0.01599493f, -0.00292799f, -0.03697556f, 0.05264032f, 0.03115443f, 
    0.02420653f, -0.07867599f, -0.05108862f, -0.06442504f, -0.04610898f, -0.00391034f, -0.02444508f, -0.02023125f, 
    0.04143304f, 0.05432438f, -0.05225674f, -0.01069793f, -0.03553423f, 0.02878692f, 0.01517808f, -0.02707937f, 
    0.00454754f, 0.01381067f, 0.04617522f, 0.03867880f, -0.06691989f, -0.05408049f, -0.06693884f, 0.02112277f, 
    0.05327887f, 0.02298189f, 0.01475273f, -0.05057985f, -0.07018133f, -0.01902387f, -0.06184548f, -0.01504177f, 
    -0.01765168f, 0.04833421f, -0.06458350f, -0.04732227f, 0.05770060f, 0.03633923f, -0.04952346f, -0.06396905f, 
    -0.07441840f, -0.04637782f, -0.02914597f, 0.01247702f, 0.05124975f, -0.01336972f, -0.01686542f, -0.03973596f, 
    -0.07752957f, -0.02794977f, 0.04964951f, 0.01349964f, -0.07127749f, 0.05081682f, -0.06694587f, 0.05788710f, 
    -0.02831332f, 0.02480127f, -0.02046158f, -0.02497811f, 0.01863080f, -0.06158232f, 0.05643234f, 0.01318705f, 
    -0.02381471f, -0.03695048f, 0.03677405f, 0.05335233f, -0.05556091f, -0.00852687f, -0.08067659f, 0.01802664f, 
    -0.04332830f, -0.05303615f, 0.04719384f, -0.04139674f, -0.04457188f, -0.00148696f, 0.03098597f, 0.03068225f, 
    0.02722610f, -0.06740747f, 0.04957349f, -0.06223932f, -0.02581166f, -0.06593496f, -0.02879278f, -0.04072916f, 
    -0.05702113f, 0.02234148f, 0.05192754f, 0.03655077f, -0.05405150f, -0.03494449f, 0.01488926f, -0.02636008f, 
    -0.01294290f, 0.03896213f, 0.02106396f, 0.00687402f, -0.00408742f, -0.06523390f, 0.06299607f, -0.02007014f, 
    0.01648170f, 0.00060321f, -0.06298844f, 0.00836803f, -0.03999330f, -0.07787389f, -0.08239108f, 0.02741489f, 
    -0.03381205f, -0.05602034f, 0.00782252f, 0.01291051f, 0.01775941f, 0.01151462f, 0.04357066f, -0.03178043f, 
    -0.00535605f, -0.05509353f, -0.00610025f, 0.02571859f, 0.00669372f, -0.01280039f, -0.05431132f, -0.03664799f, 
    -0.02069591f, 0.02827971f, 0.03514819f, 0.04782959f, -0.03270382f, 0.05483827f, -0.07992709f, 0.04098449f, 
    0.00215396f, -0.02579546f, 0.03318135f, 0.03195926f, 0.04471314f, 0.05864950f, 0.04446517f, -0.05910176f, 
    -0.07129343f, 0.01688665f, 0.01647659f, -0.06034499f, 0.05082797f, -0.05796800f, -0.07330293f, -0.05173301f, 
    0.02581481f, 0.32442078f, 0.24257687f, 0.03669089f, -0.01151648f, 0.08314217f, -0.03275740f, -0.10719755f, 
    -0.08113528f, -0.03988520f, -0.16513303f, -0.04421148f, -0.24306999f, -0.37053034f, -0.09629739f, -0.14316382f, 
    0.10263158f, -0.12679835f, 0.03154267f, -0.07927753f, -0.09109785f, 0.16781496f, -0.03406348f, 0.12658788f, 
    0.06554493f, 0.15277457f, -0.05608107f, 0.18207818f, -0.04543414f, 0.02216488f, 0.01603199f, -0.10093359f, 
    0.10930303f, -0.00083800f, 0.05858013f, -0.02110365f, -0.12648666f, 0.23820373f, 0.13424116f, 0.12883160f, 
    0.09976000f, 0.07984130f, 0.07828021f, 0.08394933f, -0.15022582f, 0.08069441f, 0.05976485f, 0.08439342f, 
    0.04947239f, -0.02607506f, 0.09518693f, 0.01835426f, -0.04008999f, 0.09682857f, 0.03118605f, 0.04472979f, 
    -0.07860488f, -0.07821112f, -0.08568864f, 0.15363480f, 0.02841949f, -0.04097081f, -0.11068075f, -0.01748129f, 
    -0.02875903f, -0.07550862f, -0.06898597f, 0.05544936f, -0.14692107f, 0.13875516f, -0.11563023f, 0.03781300f, 
    -0.47192737f, -0.24716389f, -0.04846567f, -0.12007741f, -0.20404859f, -0.09887499f, -0.04937785f, 0.04906444f, 
    0.06579555f, 0.01449682f, -0.02594945f, 0.02461191f, 0.30644557f, 0.20158926f, -0.22043109f, 0.05298367f, 
    0.01518435f, -0.08183522f, 0.04334630f, -0.17756358f, -0.14724754f, -0.11826557f, -0.07566151f, 0.13757703f, 
    -0.01426933f, -0.17466135f, 0.03414809f, -0.01038113f, 0.09508995f, -0.00548487f, 0.03973976f, -0.03532480f, 
    0.22173126f, 0.15349071f, -0.00019051f, -0.11005723f, 0.03947517f, 0.17741874f, 0.19107953f, 0.42805976f, 
    0.13856846f, 0.18892935f, 0.00569426f, 0.20870991f, 0.02000842f, 0.02781419f, -0.00915959f, -0.01993668f, 
    0.02603537f, 0.08613878f, 0.33534271f, 0.22939391f, 0.03495545f, 0.05145826f, -0.08849864f, 0.07873712f, 
    -0.05113823f, 0.08034961f, 0.03534725f, 0.07924920f, 0.02106315f, 0.02439279f, 0.03078390f, 0.02780063f, 
    -0.08412292f, -0.01417217f, 0.17222060f, 0.05144238f, 0.01096933f, -0.01483506f, -0.06984608f, 0.14291832f, 
    -0.18554033f, -0.10094666f, 0.07383884f, -0.02978569f, 0.12281084f, -0.00625477f, -0.04294713f, -0.04761919f, 
    0.02890398f, -0.03743505f, -0.03642898f, -0.00296897f, -0.08090774f, 0.17735149f, 0.05733743f, -0.00172212f, 
    0.01811839f, -0.04548423f, -0.03613053f, 0.19616404f, -0.19191951f, -0.00573320f, -0.03401543f, -0.08885632f, 
    0.17593767f, 0.22669005f, 0.19751991f, 0.45598623f, 0.03190565f, -0.06353250f, 0.00114475f, 0.04733440f, 
    0.01105426f, -0.08689009f, 0.04706601f, 0.03804378f, -0.17385493f, 0.04577287f, 0.17502575f, 0.21113072f, 
    -0.01897553f, -0.05898091f, -0.10168178f, 0.17492794f, 0.13938278f, -0.01828453f, 0.02656793f, 0.03237601f, 
    -0.04839194f, -0.03932035f, -0.00838684f, 0.05742754f, 0.01177800f, -0.04674666f, 0.00489937f, -0.01730557f, 
    0.06105175f, -0.02288869f, -0.05015838f, -0.06253947f, -0.00332728f, -0.03411419f, 0.02314870f, -0.00455158f, 
    0.03341857f, -0.01845500f, -0.05217308f, -0.03977903f, -0.05599276f, 0.01622540f, 0.05816154f, -0.05594305f, 
    -0.02623348f, -0.02012086f, 0.03153588f, 0.06232353f, -0.00657990f, 0.06553016f, -0.05157328f, 0.04067106f, 
    0.06492726f, 0.00155738f, -0.00279080f, 0.06558786f, 0.01662002f, 0.00917510f, -0.06753567f, 0.02222391f, 
    0.00035736f, -0.06158292f, -0.03673932f, -0.06837899f, 0.03279501f, -0.05947757f, -0.04100760f, 0.00607145f, 
    0.04495961f, 0.01803171f, -0.03326783f, -0.06651079f, -0.01206303f, 0.05160418f, -0.00264921f, 0.05694777f, 
    -0.05996285f, -0.03680473f, -0.07734575f, -0.01885185f, -0.02022075f, -0.07230439f, 0.05267962f, -0.07355592f, 
    0.02679470f, 0.05244401f, 0.01997654f, -0.01917505f, -0.07510699f, 0.05200103f, -0.01317762f, -0.03370618f, 
    -0.00097573f, -0.05414432f, 0.01815391f, 0.06309136f, -0.05780473f, 0.04195352f, 0.05597696f, -0.05530652f, 
    -0.01318669f, -0.00695268f, -0.02821195f, 0.01416981f, 0.03666025f, 0.01491463f, -0.06072691f, 0.06162213f, 
    -0.02131483f, -0.03081351f, -0.06087072f, -0.01418836f, 0.01801948f, -0.02337431f, -0.03016425f, -0.05496878f, 
    0.04153852f, 0.04122238f, 0.04285874f, -0.04304847f, 0.05270397f, -0.04661255f, -0.06580044f, -0.04435119f, 
    -0.03711767f, 0.02356481f, -0.06062014f, 0.02663872f, -0.04328062f, -0.03517262f, -0.07289888f, -0.02817261f, 
    0.00807486f, -0.05888833f, 0.05761203f, 0.03046237f, -0.01990654f, -0.03754156f, -0.05249681f, 0.00207468f, 
    -0.04788337f, 0.00926168f, 0.04484539f, -0.01422002f, 0.01272941f, -0.01095918f, -0.03775951f, -0.00662916f, 
    -0.07102640f, 0.02247314f, 0.00587418f, -0.03589031f, 0.00252549f, -0.07350504f, -0.02159290f, 0.04549398f, 
    -0.05821064f, -0.06137302f, -0.06303303f, 0.06035435f, -0.04516687f, -0.04253671f, -0.01567399f, 0.03422653f, 
    0.02927470f, -0.06628978f, 0.03156509f, 0.01822194f, 0.03212088f, -0.03475323f, -0.02191340f, -0.06951663f, 
    -0.03147845f, 0.01882420f, 0.01479244f, -0.04045354f, -0.04795920f, 0.05415837f, -0.05673255f, 0.00001997f, 
    -0.03099756f, 0.03214782f, 0.00389417f, -0.00501840f, -0.07123420f, -0.05036461f, -0.02170008f, 0.05507797f, 
    0.02281403f, 0.05990098f, -0.04051907f, -0.05312800f, 0.01515198f, 0.00853073f, -0.05405944f, -0.05686137f, 
    0.04213162f, 0.00541346f, -0.07035450f, 0.03060785f, 0.04302387f, 0.00478213f, 0.01564103f, -0.02964522f, 
    -0.02242448f, -0.07539352f, 0.04338107f, -0.05267458f, -0.00656788f, -0.02773185f, 0.02265208f, 0.00754235f, 
    -0.24784693f, -0.03936581f, 0.24525757f, -0.06175473f, 0.09028400f, 0.14334142f, 0.11685017f, -0.07475020f, 
    0.08424403f, 0.05568320f, -0.05903943f, 0.06385106f, -0.05469472f, -0.12113762f, -0.02076520f, 0.09060491f, 
    -0.00961252f, -0.08197861f, -0.02004276f, 0.00508513f, -0.00831391f, 0.06808549f, 0.08080482f, 0.04692028f, 
    0.02133293f, -0.00896189f, 0.00921044f, -0.29447857f, 0.11338057f, -0.09630892f, -0.15980385f, -0.02719346f, 
    -0.02843953f, -0.04735997f, 0.00029761f, -0.09688821f, -0.22046778f, -0.13045025f, 0.18175742f, 0.21056022f, 
    -0.03231903f, -0.02723895f, -0.04861822f, 0.07617699f, -0.02247598f, -0.07083421f, 0.00768590f, -0.05779717f, 
    -0.16814977f, -0.19693467f, 0.12073626f, 0.52687788f, -0.01027242f, -0.10821564f, -0.08728494f, -0.01660608f, 
    0.03882512f, 0.09973961f, 0.15095119f, 0.17655738f, -0.01141795f, -0.11906830f, 0.02457374f, 0.33879998f, 
    0.03913296f, -0.05124342f, 0.00438578f, 0.10106020f, -0.04126514f, 0.01178627f, 0.07269161f, -0.05838350f, 
    0.00743893f, -0.07518362f, -0.23049350f, 0.05559983f, 0.06942477f, 0.11183976f, 0.14085907f, -0.00257129f, 
    -0.01025188f, -0.01416767f, -0.05828450f, -0.07472360f, -0.25612447f, 0.44650027f, -0.05168647f, -0.04454092f, 
    0.19560792f, -0.00976673f, -0.02837785f, 0.02266340f, 0.08367115f, 0.03334861f, 0.13479149f, 0.00843411f, 
    -0.10612850f, -0.17097318f, -0.08006418f, 0.07528177f, 0.04647645f, 0.16662598f, -0.05717115f, 0.01072844f, 
    0.10366181f, -0.15344109f, -0.01717340f, -0.06251551f, 0.06052535f, 0.14508393f, 0.21108863f, -0.07256033f, 
    0.03959524f, 0.01440173f, -0.11938532f, -0.02848827f, 0.06986330f, 0.01609729f, 0.01650835f, -0.00015644f, 
    -0.43209130f, -0.16626522f, -0.31582740f, 0.13979535f, -0.20948371f, 0.03166608f, 0.01948796f, 0.06268869f, 
    0.11523276f, 0.12766574f, -0.19663337f, 0.04659011f, -0.27844149f, 0.04656429f, 0.20879687f, 0.17223163f, 
    -0.07871974f, -0.20049086f, -0.02688099f, 0.06182030f, 0.16772726f, -0.10116420f, 0.08857176f, 0.16446432f, 
    0.08108184f, 0.07851051f, 0.30294484f, -0.38732794f, -0.09722480f, -0.08561723f, -0.01804130f, 0.07665719f, 
    -0.08088458f, 0.10370918f, 0.16223669f, 0.18463594f, -0.00602566f, -0.13385005f, 0.09359162f, -0.08961186f, 
    0.15684900f, 0.07635539f, -0.00909077f, 0.28154510f, -0.01132829f, -0.02146197f, -0.00542698f, -0.02626431f, 
    -0.08594655f, 0.23040617f, -0.07703882f, -0.08203241f, 0.11346062f, -0.14398324f, -0.00991693f, 0.03335006f, 
    0.09410191f, 0.10569733f, -0.00665695f, -0.09240405f, 0.15363699f, -0.17044631f, -0.06812534f, -0.01480346f, 
    0.07417952f, 0.12483848f, 0.03123328f, 0.11371806f, 0.01971522f, -0.09127408f, -0.13812543f, -0.03578918f, 
    0.01902874f, -0.16741906f, 0.37024170f, 0.17200074f, -0.02099621f, -0.08884136f, 0.01138463f, -0.00375365f, 
    -0.17150062f, -0.00659703f, 0.11109994f, 0.17284578f, 0.15966836f, -0.05430821f, 0.09441588f, 0.03951509f, 
    -0.02957657f, -0.01864713f, 0.04822640f, 0.02431164f, -0.00351732f, 0.05302823f, 0.02529858f, -0.03594811f, 
    0.02358324f, 0.06451593f, -0.15226765f, 0.12684987f, -0.09602421f, -0.01377829f, 0.12583543f, 0.15007341f, 
    0.01795101f, 0.08663441f, -0.13399528f, 0.04425156f, 0.16803652f, -0.10673168f, -0.19580840f, -0.04887691f, 
    -0.07222509f, -0.02670859f, 0.15034533f, -0.05003117f, -0.08839849f, 0.05265437f, -0.01448186f, 0.04329377f, 
    0.36963820f, 0.06648587f, -0.27438325f, -0.44486529f, 0.02845849f, -0.13885245f, -0.02112378f, 0.04880702f, 
    0.22670740f, 0.19877730f, 0.01380343f, 0.09950110f, 0.21806902f, 0.07670864f, 0.16019122f, -0.02817418f, 
    0.07408652f, 0.07229000f, -0.03059714f, -0.10658253f, 0.03560150f, -0.02716044f, -0.05464800f, -0.03878225f, 
    0.25285172f, 0.16689254f, 0.07024878f, 0.06596275f, 0.02312490f, -0.03003052f, 0.05117213f, -0.12711787f, 
    -0.05959633f, 0.01261428f, 0.03083836f, -0.03937353f, 0.09981340f, -0.10654955f, 0.02721255f, 0.03553487f, 
    -0.12747902f, 0.08135352f, 0.03256723f, 0.28079963f, 0.02242010f, 0.02701044f, 0.12533186f, -0.02571228f, 
    -0.03550972f, 0.10771335f, -0.04771737f, -0.02017624f, -0.01117823f, -0.09978158f, 0.06266997f, -0.10566787f, 
    -0.10819894f, 0.02849507f, -0.02880551f, 0.07054470f, -0.07746349f, -0.06024075f, -0.05826441f, 0.25527856f, 
    -0.09392788f, -0.00147240f, 0.10888897f, 0.02411411f, -0.06414303f, 0.01829974f, -0.02496650f, 0.03949955f, 
    -0.17170934f, 0.07661487f, 0.28375316f, 0.29097012f, 0.03858640f, 0.02477100f, 0.26013073f, -0.14120238f, 
    -0.03993771f, 0.01788179f, -0.02675529f, 0.05529182f, 0.10137490f, -0.23077790f, -0.30651015f, -0.26091662f, 
    -0.20515840f, 0.11243140f, 0.04530728f, 0.10799151f, -0.07208755f, 0.15756549f, 0.01998243f, -0.10065244f, 
    -0.14008293f, 0.09698629f, -0.29313391f, 0.01024199f, -0.09494359f, -0.10655019f, 0.00023994f, 0.09574471f, 
    0.07566327f, -0.11461847f, 0.02952280f, -0.10132124f, 0.03164688f, 0.16766654f, 0.20492709f, -0.04784995f, 
    -0.07691628f, 0.10897493f, -0.09598222f, -0.12998910f, -0.03859645f, -0.06482750f, 0.00108994f, 0.00353015f, 
    0.16013747f, -0.01979276f, 0.24551909f, 0.00208017f, -0.06062960f, 0.11870405f, 0.01004842f, 0.04661196f, 
    -0.04969744f, -0.07363971f, 0.18533254f, 0.02543136f, 0.17126586f, 0.01924353f, -0.00953837f, -0.02838773f, 
    -0.03121405f, 0.03667249f, 0.02938938f, -0.01005942f, 0.04028729f, 0.00605793f, -0.15258302f, 0.04214916f, 
    -0.01021365f, -0.03830872f, 0.05781857f, -0.05645202f, -0.04714331f, 0.00899179f, -0.01622320f, -0.01010531f, 
    0.00590548f, 0.03289320f, -0.04286951f, 0.03703354f, 0.05856263f, -0.00251625f, -0.07564815f, -0.03286197f, 
    -0.00984459f, 0.02106241f, 0.03905997f, -0.02471568f, 0.00342421f, 0.02743252f, -0.00117517f, -0.06465840f, 
    -0.04055256f, -0.03211581f, -0.04623631f, 0.00493597f, -0.00990686f, 0.01656723f, -0.07449977f, -0.05637946f, 
    0.05270356f, 0.00018571f, 0.02848413f, 0.03866149f, -0.01893052f, 0.04726993f, 0.03526098f, -0.01398331f, 
    -0.06083338f, 0.04452595f, 0.01927020f, -0.02134416f, 0.00761317f, 0.06044215f, 0.00760813f, 0.06483075f, 
    -0.03433807f, -0.02045242f, -0.06208919f, -0.05158170f, -0.03277351f, -0.06046894f, -0.04954883f, -0.02404350f, 
    0.00463989f, -0.06993940f, 0.04322511f, -0.01580349f, -0.02639994f, 0.06132479f, 0.00296618f, -0.04314189f, 
    0.06040501f, 0.00865409f, -0.05100232f, -0.07054600f, -0.02621922f, -0.00787992f, 0.02202502f, 0.05034804f, 
    -0.00343909f, 0.03757661f, -0.07771639f, 0.03839829f, 0.04842792f, 0.01568106f, 0.05390478f, -0.05311491f, 
    0.04992639f, 0.02936216f, 0.03582487f, -0.02570727f, 0.05621404f, -0.01605491f, 0.02972569f, 0.03560980f, 
    0.05658100f, 0.01147569f, 0.02332124f, 0.01910401f, -0.01578814f, 0.03856798f, -0.04906017f, -0.00804219f, 
    -0.01778055f, 0.05821844f, -0.04080196f, 0.01924768f, 0.01303703f, -0.06047319f, -0.02168191f, -0.03956205f, 
    0.02379679f, 0.00338734f, 0.04238254f, -0.02557559f, -0.04265025f, 0.02644867f, -0.05379640f, 0.01035967f, 
    -0.00234041f, -0.06343621f, -0.03308082f, 0.03317257f, -0.05558731f, 0.01350616f, -0.07411514f, -0.01556753f, 
    0.02984698f, -0.05304342f, -0.07062028f, 0.03876349f, 0.01421311f, -0.03704473f, 0.03868132f, -0.05208547f, 
    -0.00148221f, -0.06491347f, -0.02429429f, -0.00571696f, 0.07337315f, 0.03843326f, 0.00916700f, 0.03491266f, 
    -0.03706298f, -0.06303664f, 0.05403632f, -0.03112326f, -0.05751559f, -0.04319052f, 0.00806958f, -0.01092367f, 
    0.05310038f, 0.00478528f, -0.06544792f, 0.05762491f, -0.07971542f, 0.03408198f, -0.00593842f, 0.04147933f, 
    -0.03276119f, 0.00307322f, -0.05504959f, -0.05007759f, -0.04051547f, -0.00201843f, -0.00553234f, 0.00069808f, 
    -0.07025683f, -0.06239513f, 0.01963933f, 0.06057686f, -0.05394978f, -0.05934760f, 0.06195883f, -0.06562723f, 
    -0.07517592f, -0.02138215f, 0.03633670f, 0.03069198f, -0.03123088f, -0.03358434f, -0.01191288f, -0.04067459f, 
    -0.01694346f, -0.02153150f, 0.07042255f, 0.00930685f, -0.06855264f, 0.01797950f, -0.01284275f, 0.01181635f, 
    -0.06495142f, -0.02258702f, -0.02976538f, 0.01726634f, -0.04756751f, 0.01501593f, -0.00747207f, -0.02048427f, 
    -0.06646795f, 0.41106260f, 0.18969755f, 0.13945191f, 0.02407948f, 0.12927474f, 0.16052537f, -0.10351750f, 
    -0.13025600f, -0.15448762f, -0.11769021f, 0.06728017f, -0.06771522f, -0.02426199f, -0.07486184f, 0.15553021f, 
    -0.05587718f, -0.22046207f, -0.01320014f, -0.03888942f, 0.13010289f, 0.13776828f, 0.05237896f, -0.01448552f, 
    0.25264961f, -0.21593398f, -0.17935786f, 0.27648702f, 0.09705036f, 0.12918730f, -0.12626791f, 0.02466697f, 
    0.01733804f, 0.01677362f, 0.02999910f, 0.01482663f, -0.35166171f, 0.33657438f, -0.34015512f, 0.15846065f, 
    0.12515970f, 0.11161897f, 0.06290062f, -0.14639035f, -0.08222985f, -0.06545183f, 0.07462699f, 0.06675860f, 
    -0.28076828f, 0.25260931f, -0.03105544f, 0.30122015f, 0.18443620f, 0.00845333f, 0.00790052f, -0.12922740f, 
    0.12229963f, 0.00939935f, -0.01397484f, 0.12505303f, -0.05735429f, 0.07348963f, 0.09919684f, 0.05349138f, 
    -0.00987999f, -0.13615629f, -0.06823311f, -0.01028133f, 0.01500483f, -0.12080623f, -0.01047257f, 0.05899430f, 
    -0.10619228f, -0.04177751f, -0.08087167f, 0.09933129f, -0.16789114f, 0.16500476f, 0.02347422f, -0.02282896f, 
    -0.09395883f, -0.09038347f, -0.09285917f, -0.08196213f, 0.12057018f, 0.01502442f, 0.05158973f, -0.11307143f, 
    -0.01818746f, -0.02751210f, -0.20875894f, -0.02609439f, 0.04655493f, -0.19391724f, -0.00748841f, 0.24555977f, 
    -0.05404445f, -0.06719334f, -0.02600060f, 0.04971715f, 0.08339921f, 0.07914272f, -0.01819984f, -0.02467967f, 
    0.18483050f, 0.12442444f, 0.00016442f, -0.00077850f, 0.20598359f, 0.16080901f, -0.05073401f, 0.22339731f, 
    0.06359410f, 0.16958170f, -0.06975459f, 0.17210792f, -0.06963231f, 0.03452414f, 0.00085097f, -0.00486574f, 
    -0.19582610f, 0.21838172f, 0.20585842f, 0.21491247f, 0.04004360f, -0.09261262f, 0.20148005f, 0.05544724f, 
    0.09528229f, 0.06795718f, -0.01293537f, 0.07580581f, -0.05080298f, 0.03808388f, -0.01899727f, 0.04500342f, 
    0.06006444f, 0.06336244f, -0.01888804f, -0.01159265f, -0.04139659f, -0.04406501f, 0.13263781f, -0.03176719f, 
    -0.36582062f, -0.05312202f, -0.19875471f, -0.04046643f, 0.17292179f, 0.09381250f, -0.14707951f, 0.06375010f, 
    -0.16263968f, 0.07904200f, 0.00361578f, 0.02481181f, -0.17667070f, 0.00085545f, 0.11877147f, -0.04845592f, 
    -0.03281981f, 0.30827793f, -0.03918462f, -0.07290947f, -0.05334883f, 0.03083443f, -0.10879032f, 0.12027626f, 
    0.06238011f, -0.01303901f, 0.24610813f, 0.17288227f, 0.00853602f, -0.00908856f, 0.04823108f, 0.08839833f, 
    0.08353568f, 0.09441270f, 0.22240697f, 0.01238897f, 0.02716568f, -0.03096747f, 0.28163415f, 0.01176111f, 
    0.16407779f, 0.07664179f, 0.05283932f, 0.04295877f, -0.02485311f, 0.04153183f, -0.04401292f, -0.03532319f, 
    0.05218957f, -0.20258406f, -0.06702448f, -0.08977536f, -0.02672972f, 0.05918835f, 0.04036221f, 0.09592205f, 
    0.10619756f, 0.00361496f, -0.03078240f, -0.09678916f, -0.02338914f, -0.22823408f, 0.09131954f, 0.09711760f, 
    -0.07296852f, 0.05096428f, -0.06999397f, 0.02328363f, 0.05494136f, -0.09772244f, -0.06167122f, -0.17675991f, 
    0.10120323f, 0.15818602f, -0.00897709f, -0.09172940f, 0.13431922f, -0.10797915f, -0.08721252f, 0.04028152f, 
    0.02165293f, 0.00617251f, 0.06099934f, 0.10471865f, 0.28107813f, -0.08547522f, 0.16884360f, -0.04790849f, 
    -0.03806740f, 0.02648389f, 0.03051662f, -0.04413176f, 0.00708212f, 0.03763678f, -0.04005666f, -0.11976131f, 
    0.09796295f, 0.17285681f, 0.31609708f, 0.12938128f, -0.06930687f, -0.02449866f, -0.11762062f, 0.00431845f, 
    0.11561093f, -0.00788015f, -0.04751451f, 0.00482600f, 0.10176204f, -0.17262530f, 0.14253001f, 0.07862532f, 
    -0.05126761f, 0.03835330f, -0.02010764f, 0.11342296f, 0.03407241f, -0.21594119f, 0.04826640f, 0.06526713f, 
    -0.13482668f, -0.12532642f, -0.11923283f, 0.05655689f, 0.18949068f, -0.02569601f, 0.10138164f, -0.14084628f, 
    0.11328228f, -0.05259455f, 0.04510986f, -0.03083414f, -0.20727088f, -0.01383720f, -0.19004835f, 0.07817858f, 
    0.14334109f, -0.11769134f, -0.03746202f, 0.07342648f, 0.08503760f, 0.09874158f, 0.16202863f, -0.15886635f, 
    0.09303054f, 0.03800967f, 0.09401574f, 0.15718724f, 0.01781953f, 0.05824422f, -0.07703404f, 0.08078302f, 
    -0.00737636f, -0.05185492f, -0.02511567f, -0.07521896f, 0.14485267f, 0.13375196f, 0.15374099f, -0.09409484f, 
    -0.08823088f, -0.13990426f, 0.05696742f, 0.04557003f, -0.02717219f, -0.05191115f, 0.00514441f, 0.08367324f, 
    0.10443649f, -0.22792473f, -0.17165849f, -0.31225529f, -0.15294047f, 0.07853090f, 0.24386816f, -0.01388323f, 
    0.08791492f, -0.07522742f, -0.21226245f, -0.02823374f, -0.10437067f, -0.08797044f, 0.24088763f, 0.29755858f, 
    0.02774217f, 0.08343051f, -0.09370408f, 0.03267156f, -0.02491884f, -0.02494001f, 0.05746480f, 0.14948580f, 
    0.38070902f, 0.07986971f, 0.28946874f, 0.03403316f, 0.08947613f, 0.01159195f, -0.10039767f, -0.02704513f, 
    0.07132421f, 0.06542958f, 0.15724546f, 0.16605291f, -0.00801089f, -0.03797571f, 0.05949279f, 0.07991467f, 
    0.00650542f, 0.04165786f, -0.12863702f, -0.05348638f, -0.00459796f, 0.00325778f, 0.06161957f, -0.00153888f, 
    0.38677564f, 0.22130217f, -0.03828738f, 0.02597279f, -0.10029067f, -0.03552953f, 0.14312777f, -0.15917414f, 
    0.05691103f, 0.17162845f, 0.02360939f, -0.13927513f, -0.00789621f, -0.36264849f, -0.16122662f, 0.44710261f, 
    0.08243799f, 0.09229438f, 0.10756507f, 0.02929629f, 0.11174076f, -0.03187467f, 0.04464986f, -0.00918049f, 
    0.04039389f, 0.03992344f, 0.04784919f, 0.02200548f, 0.05549118f, 0.02189175f, -0.07871499f, -0.07579558f, 
    -0.07422429f, 0.02712628f, 0.03603087f, -0.02072633f, 0.01179439f, -0.03139105f, 0.05363876f, -0.01992954f, 
    -0.01980519f, 0.06167576f, 0.05131315f, 0.03557805f, -0.01979099f, -0.01186457f, 0.03152703f, -0.04379540f, 
    0.04284604f, -0.06482417f, 0.05511925f, 0.05540996f, -0.04977168f, -0.05957758f, -0.08098323f, -0.03417079f, 
    0.04557866f, 0.05515635f, 0.01034659f, -0.01055699f, 0.01439072f, -0.03130057f, 0.03564041f, -0.07857330f, 
    0.02309887f, -0.00754565f, 0.05120696f, -0.01831331f, -0.02806263f, 0.03820473f, -0.04808651f, 0.05310905f, 
    -0.05813233f, 0.00478978f, 0.05952930f, 0.00952893f, -0.03736500f, -0.07401848f, -0.01079041f, -0.06178397f, 
    0.03607299f, 0.02224582f, 0.02773308f, -0.00881486f, 0.05739069f, -0.00671910f, 0.04383986f, 0.02991089f, 
    0.04464009f, 0.04583968f, -0.03141548f, -0.06624509f, 0.05639295f, -0.04476883f, -0.00064267f, -0.06379044f, 
    -0.03381063f, 0.00968165f, -0.06512592f, -0.01817888f, -0.06237189f, 0.00601302f, -0.06950627f, -0.06891377f, 
    0.02151201f, 0.03627801f, -0.06274898f, -0.02107212f, 0.03382949f, 0.00404627f, 0.00614779f, -0.03702855f, 
    -0.02773068f, 0.05244963f, 0.04270994f, -0.06887282f, -0.01847189f, 0.01441143f, -0.07565040f, -0.00035160f, 
    -0.04001483f, -0.04527649f, 0.05624506f, -0.03321193f, 0.03423614f, -0.06004072f, -0.07760637f, -0.00213084f, 
    0.06582022f, -0.03250799f, -0.07203288f, 0.05968580f, -0.03530841f, 0.05918179f, 0.04518927f, 0.00262439f, 
    -0.06022474f, -0.05650781f, 0.05457295f, -0.07654316f, 0.03185301f, -0.06195312f, 0.06411757f, 0.03667145f, 
    -0.05465999f, 0.02920263f, -0.03668791f, 0.02528406f, -0.01496616f, 0.02684196f, 0.04341936f, 0.00034954f, 
    -0.07087450f, 0.04422610f, 0.03476128f, -0.05881046f, -0.04195625f, -0.03093331f, -0.02284330f, -0.07786488f, 
    -0.02808569f, -0.03077188f, 0.04921355f, -0.07785757f, -0.06400029f, -0.08421853f, 0.05751925f, -0.04837217f, 
    -0.05416982f, -0.03639469f, -0.02437280f, 0.04434128f, -0.04106359f, -0.06441154f, 0.01460394f, 0.03172052f, 
    -0.06631166f, 0.01566980f, -0.02221669f, -0.02616603f, 0.03175098f, 0.00973455f, 0.03068168f, 0.06614795f, 
    0.01221799f, 0.00306712f, -0.00911248f, 0.00997173f, 0.02737806f, 0.02034380f, -0.05483082f, 0.03785502f, 
    0.01724051f, 0.02150858f, 0.00301098f, 0.05000743f, 0.06055638f, 0.06258041f, 0.03035812f, -0.04624321f, 
    0.00118709f, -0.07327901f, 0.01174781f, -0.04209429f, -0.06811627f, -0.07885551f, -0.03595392f, 0.03831026f, 
    -0.05077453f, -0.03559442f, -0.03963994f, -0.02890015f, -0.05678857f, 0.01130200f, 0.04927427f, -0.06349161f, 
    -0.01725415f, -0.02123840f, -0.05001050f, 0.06350555f, 0.01791691f, 0.02442398f, -0.01937458f, -0.06614418f, 
    -0.04589724f, 0.03915985f, 0.01091345f, -0.00478685f, -0.04329048f, -0.06528572f, -0.05461573f, -0.03598178f, 
    0.03337234f, -0.03918530f, 0.03642331f, 0.05923559f, -0.06757295f, 0.02834069f, -0.00175836f, 0.03658016f, 
    -0.02278829f, 0.04294583f, -0.00610434f, 0.02508759f, 0.03527352f, -0.07095688f, 0.02997199f, -0.07087404f, 
    0.05364456f, -0.05615998f, -0.02770730f, 0.05114301f, 0.04504006f, 0.04758244f, -0.07941203f, -0.05926204f, 
    -0.04066437f, 0.02071027f, -0.03754541f, 0.02461912f, 0.02106975f, 0.00206863f, -0.06616109f, -0.01230252f, 
    -0.02396182f, -0.02477062f, -0.00880273f, 0.02050488f, 0.00585324f, -0.00639059f, -0.05103984f, -0.06937740f, 
    0.02550785f, 0.00082803f, -0.07016318f, -0.00450882f, 0.00892134f, 0.04209979f, 0.00352648f, 0.05194967f, 
    0.02454169f, 0.02671758f, -0.02327664f, -0.06546699f, -0.04225907f, 0.06147699f, -0.06654885f, 0.05970622f, 
    0.03727909f, -0.01945899f, -0.07573517f, 0.02096602f, 0.04374915f, -0.02792593f, 0.01176089f, 0.00594168f, 
    -0.02238614f, -0.07515383f, 0.05241964f, -0.05269196f, -0.03793566f, -0.06022134f, -0.07593253f, 0.00403611f, 
    0.05688359f, 0.05542931f, -0.07653888f, -0.03618207f, 0.05968479f, 0.01474659f, 0.00711313f, -0.01747414f, 
    0.04010040f, -0.03787791f, 0.00984862f, -0.02658260f, -0.06746060f, 0.02326960f, -0.02757127f, 0.01027500f, 
    -0.00957978f, 0.03034453f, -0.07754526f, 0.00964100f, -0.01153662f, -0.00519616f, -0.05527898f, -0.00331344f, 
    -0.04667387f, 0.05099578f, -0.00309311f, -0.00734405f, -0.03372105f, -0.01567016f, -0.05243975f, -0.06753845f, 
    -0.05016099f, 0.03712553f, 0.03032134f, -0.00587957f, 0.03723473f, -0.00628264f, -0.02053854f, -0.03562702f, 
    0.01231570f, -0.06630657f, -0.00731636f, 0.01989990f, -0.02543109f, -0.06061142f, -0.07940892f, -0.02683551f, 
    0.01018990f, -0.01680954f, -0.01775935f, -0.05185544f, 0.05866678f, 0.01164035f, 0.00317540f, -0.00372245f, 
    0.06330699f, -0.04027827f, -0.06834377f, -0.04739898f, 0.02235379f, 0.03583609f, 0.01894676f, 0.01425304f, 
    -0.05971116f, -0.00243652f, -0.05585050f, 0.04526369f, -0.00069903f, -0.07412843f, -0.06827774f, -0.03322659f, 
    0.02231184f, 0.03330153f, -0.01663560f, 0.05401176f, 0.02086695f, -0.06848411f, 0.05325678f, -0.07944654f, 
    -0.07245066f, 0.02793504f, -0.03663027f, -0.02667275f, -0.01633805f, -0.02864273f, -0.00733402f, -0.01026030f, 
    0.02433667f, 0.01059294f, -0.07924820f, -0.06139178f, -0.01305400f, -0.04678917f, 0.04730006f, 0.00388436f, 
    0.04426794f, 0.00854098f, -0.07476927f, -0.01101408f, 0.01172846f, 0.01423054f, 0.00430366f, -0.04603520f, 
    -0.07401361f, -0.04917818f, 0.11071670f, 0.06392082f, 0.14747851f, 0.20690611f, -0.05049869f, -0.16927533f, 
    -0.09306113f, 0.01751597f, 0.09772897f, 0.04476592f, 0.05903279f, -0.18397196f, 0.13345724f, -0.05532397f, 
    0.10143251f, -0.03856849f, -0.02319062f, 0.03527238f, -0.05173271f, -0.00524003f, -0.06109402f, 0.03521013f, 
    -0.09994955f, 0.11826643f, 0.11965813f, -0.02602262f, -0.10410464f, -0.22436817f, -0.02558619f, 0.10147797f, 
    0.11674873f, 0.03842558f, 0.05243137f, 0.13697045f, -0.26381698f, -0.30165204f, -0.00153531f, 0.26603770f, 
    -0.00780878f, 0.07955141f, -0.15072313f, 0.18564652f, -0.12965029f, -0.02204483f, 0.11623736f, 0.06617164f, 
    0.31569698f, 0.22086138f, 0.13087592f, 0.10078338f, 0.04232353f, -0.04114668f, -0.04738879f, 0.03364989f, 
    0.17121944f, -0.00456861f, 0.01674645f, 0.14029302f, 0.19805571f, 0.38326156f, -0.12884435f, 0.22669721f, 
    -0.04793627f, 0.07579964f, -0.09020406f, 0.02403121f, -0.08797450f, -0.00102843f, 0.18930580f, -0.11525737f, 
    -0.16937870f, 0.00054462f, 0.09357975f, -0.10869955f, 0.01485064f, -0.03859261f, 0.12724939f, -0.02590253f, 
    -0.00638407f, -0.02073197f, -0.04987506f, -0.04248389f, 0.31563625f, 0.12636426f, 0.09096269f, -0.02534166f, 
    0.10198041f, -0.03682888f, 0.03044225f, -0.03020208f, -0.07919997f, -0.03307300f, 0.20719841f, -0.05176640f, 
    0.03352036f, 0.01606997f, -0.05450275f, -0.08531266f, 0.08014403f, 0.06664529f, -0.05028914f, -0.00370334f, 
    0.10834695f, 0.04486717f, 0.08290918f, -0.03421256f, -0.39130285f, -0.05161033f, -0.02615781f, 0.18155770f, 
    -0.02524556f, -0.05754232f, 0.01045737f, 0.15294722f, 0.07461271f, 0.04383093f, -0.02155402f, 0.04790239f, 
    -0.00814726f, -0.29993558f, -0.01930001f, 0.20626968f, -0.00453568f, 0.06714310f, 0.00925806f, 0.00820783f, 
    -0.00038837f, -0.05092004f, -0.09331507f, 0.07323274f, -0.29184258f, -0.04614636f, -0.14493494f, 0.06629700f, 
    -0.11977374f, 0.00016784f, 0.10101818f, 0.00392552f, -0.02377941f, 0.01446955f, 0.07541399f, 0.11913650f, 
    -0.14633721f, 0.31914610f, 0.49831960f, 0.08687772f, 0.00293345f, -0.03597258f, -0.09681303f, 0.06470802f, 
    0.11371367f, 0.14341167f, 0.05673818f, -0.04886279f, 0.07049894f, -0.05031201f, 0.15347366f, 0.00336496f, 
    0.17006937f, 0.09572380f, -0.06163134f, 0.10563060f, -0.02132523f, -0.00872762f, 0.00363339f, -0.06242038f, 
    -0.06176015f, 0.04042729f, 0.01574746f, -0.03535124f, -0.04684205f, -0.15961702f, 0.04568214f, 0.14701171f, 
    0.14243871f, 0.01666380f, 0.20292120f, -0.11244494f, -0.06925280f, -0.22159560f, -0.00484500f, 0.15101710f, 
    0.00295910f, 0.39832190f, 0.23232241f, 0.04473735f, 0.08034486f, 0.00822388f, -0.07430483f, 0.01734563f, 
    0.03776318f, 0.07646867f, -0.27645043f, -0.05087485f, -0.05646324f, 0.13528724f, 0.05343549f, 0.28409979f, 
    0.05807926f, -0.04795251f, -0.05167198f, -0.11107852f, 0.00837324f, -0.03182625f, 0.10063949f, -0.02879012f, 
    0.01706074f, 0.17532571f, 0.04023972f, -0.12769949f, -0.09329668f, 0.08270884f, -0.19780037f, 0.08824096f, 
    0.05944868f, -0.02591969f, -0.07409398f, -0.09757546f, 0.15836266f, 0.00043379f, 0.06227246f, -0.01160953f, 
    -0.17244107f, -0.07915474f, 0.04641248f, -0.05661581f, 0.34603125f, -0.12705083f, 0.15830122f, -0.17460975f, 
    0.05864258f, 0.18923396f, 0.03277055f, 0.01643480f, 0.09194221f, -0.00323992f, -0.18357466f, 0.02490188f, 
    0.28409442f, 0.29934329f, 0.17556624f, 0.25385857f, 0.10506035f, 0.18758629f, 0.03298802f, 0.03094015f, 
    -0.16442406f, -0.09489156f, 0.06540610f, -0.11438885f, -0.10563528f, -0.00893258f, -0.11598476f, 0.01071267f, 
    0.00704119f, 0.03851694f, 0.08404526f, -0.03393200f, -0.15029325f, 0.02113655f, -0.08720701f, -0.07193171f, 
    -0.06911635f, -0.10592344f, 0.03639292f, -0.07678802f, 0.09934917f, 0.05220217f, -0.00840477f, 0.08904437f, 
    0.03743685f, -0.01539711f, 0.02121031f, 0.02843572f, -0.33604723f, 0.02632280f, -0.13796237f, 0.08919937f, 
    -0.03251102f, -0.07943817f, 0.14411259f, -0.29528779f, -0.21723998f, 0.00826153f, 0.05765381f, -0.09433608f, 
    -0.01103849f, 0.11175748f, 0.00447863f, -0.09640666f, 0.03460106f, 0.15855503f, 0.21271774f, 0.02599289f, 
    -0.05399098f, 0.01329231f, 0.07818589f, -0.00292654f, -0.05861632f, -0.02708005f, -0.03872043f, -0.23512495f, 
    0.03713491f, 0.01252293f, 0.10410798f, 0.13413037f, -0.09238117f, 0.05385389f, -0.07088994f, 0.00266963f, 
    0.20201053f, 0.00676430f, -0.42176428f, -0.22017886f, 0.08501166f, 0.16909680f, -0.23661602f, -0.02675973f, 
    0.11202569f, -0.21266018f, 0.16011249f, -0.07165577f, 0.26944977f, 0.08559293f, 0.05277608f, 0.28328553f, 
    0.21429558f, -0.09609466f, -0.14279474f, -0.05375919f, -0.11069385f, -0.15128382f, -0.01204806f, 0.07414853f, 
    0.19647355f, -0.15596488f, 0.23942512f, -0.18729329f, -0.01612802f, -0.02136763f, -0.03545725f, -0.00244242f, 
    -0.03042325f, 0.08805989f, -0.01130316f, 0.15328947f, 0.07180149f, -0.13287215f, 0.01255058f, 0.01239435f, 
    0.08698069f, 0.10733899f, 0.02003478f, -0.00529222f, 0.24778773f, -0.03371190f, 0.10692317f, 0.09286920f, 
    -0.15769298f, 0.14399038f, -0.07308265f, 0.14208522f, 0.16783011f, 0.17880918f, -0.10006946f, 0.09446923f, 
    0.01173750f, -0.05362322f, -0.12703960f, -0.01698998f, 0.07940185f, 0.13986059f, -0.14618640f, -0.13970935f, 
    0.01983796f, 0.11687295f, 0.15230729f, 0.04395894f, -0.00627853f, -0.04840581f, 0.10672652f, 0.03211829f, 
    -0.07928156f, 0.23553190f, -0.14082897f, 0.07722867f, 0.05761352f, 0.07302029f, 0.17912957f, -0.01284601f, 
    0.11975650f, -0.10885771f, 0.04112065f, 0.04110758f, -0.10539810f, -0.00451307f, -0.05054703f, 0.11814760f, 
    -0.08329764f, -0.08493529f, 0.04277178f, -0.09219757f, 0.24364448f, 0.01253612f, 0.12521353f, 0.02828214f, 
    0.30109555f, -0.03015907f, -0.13235402f, 0.13660863f, 0.08704378f, 0.05178830f, -0.06970698f, -0.04609659f, 
    -0.08969689f, -0.05614089f, -0.08423029f, -0.05135734f, 0.09191537f, 0.25872606f, 0.08501678f, -0.04402221f, 
    0.22225323f, -0.04848338f, -0.02871042f, -0.14802407f, -0.11704931f, -0.12818472f, -0.03584117f, -0.05717614f, 
    -0.35597411f, 0.35051709f, 0.15490960f, 0.24705556f, 0.06626393f, -0.10981605f, -0.01725378f, -0.01358906f, 
    -0.02411248f, 0.15189551f, -0.00713085f, 0.03490163f, -0.06695957f, -0.06520674f, 0.12562324f, 0.13830730f, 
    0.00471294f, 0.03177825f, -0.03478462f, 0.02708338f, -0.01490817f, -0.14598958f, -0.03840326f, 0.19717209f, 
    0.06164125f, 0.04215614f, -0.04738173f, 0.15847979f, -0.04490980f, 0.08012864f, -0.01308402f, 0.04325968f, 
    0.00787565f, 0.00678746f, -0.03187266f, -0.04130786f, -0.10442302f, -0.14954877f, 0.21595454f, -0.10901745f, 
    -0.04610834f, -0.02668519f, -0.10130373f, -0.00408977f, -0.05565376f, 0.06070541f, 0.08045166f, 0.09278388f, 
    -0.05480419f, -0.06328458f, 0.07205112f, 0.06986868f, 0.13470054f, 0.06839458f, -0.02708085f, 0.00091559f, 
    0.07144960f, 0.03337218f, -0.04913247f, -0.07288462f, 0.29477856f, 0.03385528f, -0.01457455f, -0.18520263f, 
    0.06239726f, 0.01656036f, -0.03053354f, 0.01146247f, -0.01056322f, -0.06094241f, -0.00759492f, -0.03677234f, 
    -0.13943085f, 0.23668374f, 0.11918549f, -0.19490051f, -0.09462106f, 0.05088791f, 0.12712987f, -0.07410534f, 
    0.09785276f, 0.09987898f, 0.01469928f, -0.15245980f, 0.17916590f, 0.03832803f, 0.18819852f, 0.14811419f, 
    0.11533336f, 0.08169273f, -0.10685046f, -0.05920786f, 0.06914372f, -0.01725014f, 0.15262812f, 0.05348330f, 
    0.14639793f, 0.15155470f, -0.24291052f, 0.02797812f, -0.00494283f, -0.01629642f, -0.03366872f, -0.00299552f, 
    -0.19962160f, 0.04838388f, 0.03620908f, 0.08098474f, -0.28543934f, 0.03408040f, 0.10694374f, 0.02487361f, 
    0.03440032f, 0.17981252f, -0.01514958f, 0.00197436f, 0.00904797f, 0.10492362f, -0.02808434f, 0.06231994f, 
    0.28034082f, -0.09411941f, 0.11051610f, -0.04156202f, -0.01890786f, 0.22517139f, 0.07516788f, 0.00603775f, 
    -0.05298973f, -0.03597029f, 0.02218701f, -0.10009342f, 0.10412257f, -0.11687382f, -0.05568619f, 0.13324462f, 
    0.06602349f, -0.00379387f, 0.03420805f, 0.08634100f, -0.05357050f, -0.10764627f, 0.00320863f, -0.09049137f, 
    -0.59918731f, -0.17585856f, -0.29274845f, -0.17692398f, 0.20320028f, 0.27934045f, 0.16120166f, 0.10319450f, 
    0.29143849f, 0.21720782f, 0.12946773f, 0.01114427f, 0.05638562f, 0.25433588f, 0.09953711f, 0.12225246f, 
    0.01726419f, -0.12455792f, -0.02602750f, 0.01659065f, 0.06781211f, 0.07102588f, -0.06636486f, 0.00529178f, 
    0.10626248f, -0.48711222f, -0.17026395f, 0.08898958f, 0.07213811f, 0.06991464f, -0.09668606f, -0.03127986f, 
    -0.01895886f, -0.12470809f, 0.01351829f, -0.15157595f, -0.52630627f, 0.09715017f, -0.64011300f, -0.23124324f, 
    0.19288597f, 0.02956290f, -0.08157546f, -0.19494720f, -0.09473895f, -0.18483697f, -0.21055180f, 0.04750735f, 
    -0.07749541f, 0.23516038f, 0.27004957f, 0.26306218f, -0.03707954f, 0.04217294f, 0.00819346f, -0.08995800f, 
    -0.00683181f, -0.07978294f, 0.01845821f, 0.15903305f, 0.17495030f, 0.26850259f, 0.25316703f, 0.13213791f, 
    0.00868511f, -0.02960082f, -0.00927121f, 0.00207667f, -0.05024343f, -0.02154550f, 0.04614174f, 0.04233798f, 
    0.22250770f, 0.15089592f, 0.07927427f, 0.29236269f, -0.04760208f, 0.00699252f, -0.01585772f, 0.02835290f, 
    0.00254048f, -0.03138121f, -0.02148616f, -0.00191222f, -0.09720400f, -0.19615529f, -0.03809647f, 0.03588153f, 
    0.00833527f, -0.13170491f, -0.08336069f, -0.10899848f, 0.19033280f, -0.00300950f, 0.17504652f, 0.31449452f, 
    0.05995424f, 0.06707440f, 0.05560242f, 0.13447571f, 0.05370826f, 0.00823461f, -0.07308385f, -0.06781184f, 
    -0.15968937f, -0.08098469f, -0.09666885f, -0.12826309f, -0.00533645f, -0.12631550f, -0.36099309f, -0.34998664f, 
    0.09949261f, 0.17480938f, 0.02678182f, 0.23533863f, -0.09142615f, -0.04658709f, 0.00458988f, -0.13586663f, 
    -0.40845421f, 0.04597367f, -0.17905396f, -0.31393883f, -0.17703308f, 0.12058683f, 0.22437620f, 0.15326369f, 
    -0.11582492f, 0.12248071f, -0.00988525f, -0.09422899f, -0.62548375f, -0.27886707f, -0.20053667f, -0.26321667f, 
    0.02345883f, -0.13356347f, -0.11551324f, -0.16321826f, 0.13497385f, 0.03166879f, 0.02063771f, 0.12070131f, 
    0.33940393f, -0.39505464f, -0.26764035f, -0.21349090f, -0.08495979f, -0.03085892f, -0.18132623f, 0.04528119f, 
    0.22777559f, 0.17750758f, 0.13074110f, 0.11405954f, 0.10863321f, 0.07178815f, 0.15355915f, 0.10870095f, 
    0.03157192f, 0.13737209f, 0.01585149f, -0.00485737f, 0.27763644f, 0.03962580f, 0.00869849f, -0.00071054f, 
    0.25508630f, -0.08115231f, -0.10755082f, 0.12815453f, -0.11006746f, 0.13225695f, -0.01409524f, -0.18629146f, 
    -0.13251096f, -0.18162639f, -0.16219434f, -0.03151706f, 0.08524399f, 0.14531593f, 0.21689582f, 0.24266383f, 
    0.22241478f, 0.16653344f, 0.12925439f, -0.03859698f, -0.11436345f, -0.04919669f, 0.12172567f, -0.01915435f, 
    0.17179215f, 0.10178813f, -0.12516831f, 0.06949587f, -0.02930299f, -0.06037874f, 0.10207389f, -0.05407570f, 
    -0.04648989f, -0.09141163f, -0.01874838f, 0.23957382f, -0.20330615f, -0.01965818f, -0.21303043f, 0.09174252f, 
    -0.03198557f, -0.17686568f, 0.13020647f, 0.15828255f, 0.13433027f, 0.00590088f, -0.02161828f, 0.19727851f, 
    0.08713546f, 0.00413277f, 0.16821493f, 0.39592862f, 0.10854958f, 0.25397238f, 0.11693949f, 0.00293760f, 
    -0.01736107f, 0.06165392f, -0.00622570f, -0.03776926f, -0.11275617f, 0.54613125f, -0.03280978f, 0.03748690f, 
    0.26309565f, -0.07836004f, 0.12754774f, -0.23160829f, -0.16047144f, -0.03856076f, 0.00213901f, 0.01959889f, 
    -0.35589024f, -0.21578380f, -0.04553515f, -0.05873402f, 0.01013804f, -0.07164033f, 0.17668624f, 0.04098564f, 
    0.02262183f, -0.08365817f, -0.00301444f, 0.06270585f, 0.00918606f, -0.04450332f, -0.05292988f, -0.09072737f, 
    0.19275425f, -0.04433213f, -0.03821987f, -0.00973423f, 0.17270714f, -0.09229737f, -0.03467433f, 0.04405890f, 
    -0.01467547f, -0.05737054f, -0.02216301f, -0.01412061f, -0.16184759f, 0.08179846f, -0.09092855f, 0.04623153f, 
    -0.07470722f, 0.05099882f, -0.00161398f, 0.03620587f, 0.56670946f, -0.36983195f, 0.17741778f, -0.15144891f, 
    -0.01944082f, 0.08291557f, -0.18189062f, 0.04979231f, 0.04707539f, -0.09073300f, -0.07684091f, 0.16295435f, 
    -0.14139521f, -0.02191767f, -0.13659386f, -0.03280020f, 0.10648695f, -0.14790946f, 0.00158353f, 0.01230742f, 
    -0.09434450f, 0.10844275f, -0.05229367f, -0.04229816f, 0.31350473f, 0.16383351f, 0.10351019f, 0.23105213f, 
    0.11995204f, 0.25788036f, 0.03601714f, -0.10626954f, 0.10129623f, -0.04385985f, -0.02176461f, -0.00521827f, 
    0.34841004f, 0.31041875f, 0.48525116f, 0.07008285f, 0.12706257f, 0.09557718f, 0.29034361f, 0.14743413f, 
    -0.08688890f, 0.02343117f, 0.07331274f, -0.08071301f, 0.03885107f, 0.27095404f, 0.04526383f, -0.11766578f, 
    0.03775914f, 0.10124575f, 0.11709654f, 0.05259367f, -0.05442768f, 0.13613842f, 0.11485653f, 0.08701172f, 
    0.04408135f, 0.24223949f, -0.20622262f, 0.37770367f, 0.18285161f, 0.16050404f, 0.17336130f, -0.07764783f, 
    -0.02131198f, 0.05578711f, 0.09576350f, 0.10993363f, -0.01244879f, -0.05532545f, -0.02043268f, -0.10282832f, 
    -0.09173160f, 0.02482867f, 0.09971466f, -0.01465462f, -0.05352234f, -0.03461887f, -0.07731017f, 0.20416464f, 
    0.43194067f, -0.25937000f, 0.26741287f, -0.08118961f, -0.08854997f, 0.14577261f, 0.02288745f, -0.01608867f, 
    -0.10131974f, 0.04345188f, -0.00078733f, 0.00840412f, -0.18920316f, -0.08115467f, 0.08850598f, -0.03657721f, 
    0.13635477f, -0.08176669f, -0.10084961f, 0.02353891f, 0.04110032f, -0.00428752f, 0.04692404f, -0.05272291f, 
    0.06004301f, 0.04604081f, 0.06773531f, 0.01807962f, -0.10496107f, 0.06187870f, 0.02807946f, 0.11778039f, 
    -0.11912278f, 0.05590888f, 0.22090195f, 0.03184906f, -0.02494230f, -0.00834652f, -0.04280467f, -0.06609081f, 
    -0.18658133f, -0.16604358f, 0.14862613f, -0.04828909f, 0.27096012f, -0.14960647f, 0.30974242f, -0.12575260f, 
    -0.03698987f, 0.02769021f, -0.10923401f, 0.12219907f, 0.12013337f, 0.16415597f, -0.01629877f, 0.05945075f, 
    -0.03213331f, 0.05002096f, -0.02631099f, 0.02617010f, 0.18563797f, 0.13888709f, 0.02597612f, -0.11650888f, 
    0.06148654f, 0.08315294f, 0.00555644f, -0.00578436f, -0.20589659f, -0.16721159f, 0.16934377f, 0.03545818f, 
    0.08368941f, 0.10675018f, -0.12718125f, -0.03347693f, 0.09542284f, 0.03677224f, -0.10543486f, 0.05184438f, 
    -0.14972728f, 0.18509376f, 0.18280186f, 0.03196803f, -0.17304784f, -0.02225595f, 0.00696092f, -0.08144680f, 
    0.04651888f, 0.05326559f, 0.03336250f, 0.07801602f, -0.09516566f, -0.04101729f, -0.03822089f, 0.11735439f, 
    0.07964921f, 0.00099843f, 0.00608616f, 0.01838620f, 0.00271314f, 0.09635610f, -0.03428948f, -0.09862687f, 
    -0.12842594f, -0.04794455f, 0.04205962f, -0.12680429f, -0.10696210f, -0.02287091f, -0.09762759f, -0.07549731f, 
    0.00984099f, -0.15529639f, -0.05262250f, 0.04480379f, -0.03025926f, 0.01147332f, 0.15825595f, -0.12063473f, 
    -0.20514886f, -0.04719156f, -0.09775681f, -0.17194045f, -0.03729108f, 0.04657637f, -0.00444534f, -0.14442632f, 
    -0.16836394f, -0.06715243f, -0.20621410f, -0.11898926f, 0.23077537f, -0.14031938f, -0.09479405f, -0.16514206f, 
    0.08521317f, 0.04760312f, 0.00134550f, -0.03066098f, -0.15344444f, -0.06770016f, -0.17254375f, -0.19986582f, 
    0.09019723f, 0.16082780f, -0.04306064f, 0.10373817f, 0.07770754f, -0.09800572f, 0.11888444f, -0.02546952f, 
    0.05558686f, 0.06502938f, -0.05152090f, -0.04618561f, 0.37265790f, -0.18463959f, 0.02412783f, 0.09664654f, 
    -0.02978622f, 0.03094182f, 0.06323312f, 0.01001057f, -0.01674883f, 0.08312760f, 0.15785097f, 0.11138953f, 
    -0.26920739f, 0.02210704f, -0.21405841f, 0.04919202f, 0.03557166f, 0.12489472f, 0.20016263f, -0.06773548f, 
    -0.00163929f, 0.16202627f, -0.00650647f, 0.08603118f, -0.18838727f, 0.34755862f, -0.28211287f, -0.01517565f, 
    0.20874690f, 0.07221676f, 0.15472203f, 0.08320007f, 0.05791822f, 0.03439330f, -0.02195420f, -0.03870733f, 
    -0.10308327f, 0.17664066f, 0.05557062f, 0.07235432f, 0.16356158f, 0.01422886f, 0.10314745f, -0.07223170f, 
    -0.11999692f, 0.21101561f, 0.01874647f, -0.15160684f, 0.09467276f, 0.17620133f, -0.02913984f, -0.03846020f, 
    0.02228912f, 0.07844713f, -0.05881426f, -0.05495582f, -0.01440026f, -0.02738581f, 0.04794001f, 0.10165451f, 
    -0.00172823f, -0.03052212f, -0.02493156f, 0.00213613f, 0.03439186f, 0.04334985f, -0.02497021f, -0.05532164f, 
    -0.01184989f, 0.01797720f, 0.01941982f, 0.00981003f, 0.04502794f, -0.08072917f, -0.01378079f, -0.05319891f, 
    -0.07514460f, -0.01508067f, -0.02307313f, -0.01127075f, -0.03367612f, 0.02313096f, 0.03003805f, -0.07160010f, 
    -0.05055187f, 0.03186494f, 0.04479725f, 0.01327164f, -0.02876476f, -0.08401695f, -0.03571331f, 0.00167748f, 
    -0.07162660f, -0.00776881f, -0.04308726f, -0.00444565f, -0.00404582f, 0.03439270f, 0.05515208f, 0.04799041f, 
    0.02049438f, 0.03541401f, 0.02179309f, -0.05463877f, -0.01706955f, -0.00871855f, -0.00248421f, 0.05097698f, 
    -0.07664556f, 0.01118351f, -0.03265747f, 0.05526528f, -0.07173214f, 0.00701646f, -0.05249162f, 0.00240774f, 
    0.02126934f, -0.07777842f, 0.00670231f, -0.01343617f, -0.03502503f, -0.01268645f, -0.01110539f, 0.00296474f, 
    -0.00098832f, 0.04649143f, -0.07000007f, -0.02265552f, -0.03676804f, 0.04209919f, 0.04580541f, 0.04314100f, 
    0.03451356f, 0.05094819f, -0.00530092f, -0.02477683f, 0.05215888f, -0.06595122f, -0.05497802f, -0.02260622f, 
    0.02765685f, -0.07396716f, -0.03487580f, -0.01536040f, -0.07213553f, -0.02184957f, -0.03044128f, -0.03924484f, 
    -0.06560308f, -0.04523031f, 0.04954796f, 0.01804390f, 0.02609643f, 0.02805459f, 0.04458374f, 0.03237860f, 
    -0.05220623f, -0.04801862f, -0.04984506f, 0.01283065f, 0.00268753f, 0.00242064f, 0.04588750f, -0.03221807f, 
    -0.01328515f, 0.02620880f, -0.04083594f, 0.01263156f, 0.03872646f, -0.02691834f, -0.03678858f, 0.05757464f, 
    0.05179109f, -0.00213128f, 0.02759709f, -0.03398574f, -0.00425919f, -0.03556110f, -0.07825583f, -0.05841269f, 
    0.03422711f, 0.04813115f, -0.00820906f, -0.00345114f, -0.03777904f, 0.02455663f, 0.03544896f, 0.00538270f, 
    0.05819936f, 0.06451677f, 0.01750117f, -0.04552681f, -0.00518246f, 0.01011679f, -0.04267107f, 0.04174907f, 
    0.05061593f, -0.00727124f, -0.01083449f, 0.06117347f, 0.01166895f, -0.08108147f, -0.00889287f, 0.00879440f, 
    -0.03529988f, 0.00223153f, -0.04664494f, 0.00992419f, -0.03247320f, -0.06435996f, 0.02960133f, -0.07264487f, 
    -0.04379068f, -0.06678182f, -0.06023857f, 0.04030782f, -0.03178813f, 0.00558856f, -0.06522785f, -0.07775444f, 
    -0.08129687f, 0.04465131f, -0.04535905f, 0.05036262f, 0.03403343f, -0.00702262f, 0.05399526f, 0.00764973f, 
    -0.04784398f, -0.00111762f, -0.05161667f, -0.02311804f, 0.04142024f, 0.05555478f, -0.04021934f, -0.07477615f, 
    0.00265117f, -0.07099350f, -0.07818776f, 0.02994287f, 0.05858172f, 0.04983519f, 0.03300415f, 0.02169496f, 
    -0.05217658f, -0.06660911f, -0.05693047f, 0.05923441f, -0.08065414f, -0.06006223f, -0.00783168f, 0.03856947f, 
    -0.21409796f, 0.00842010f, -0.18047255f, 0.10886072f, 0.08539771f, 0.05441562f, -0.06360397f, 0.14157639f, 
    -0.01965097f, 0.03506894f, 0.09261986f, 0.06164074f, -0.03482995f, 0.06923606f, -0.19682147f, 0.02258409f, 
    -0.10435276f, 0.06927899f, -0.00309786f, 0.06853543f, 0.25114408f, 0.07257632f, 0.15919133f, -0.07315713f, 
    -0.05266405f, -0.03833774f, 0.11197107f, -0.03994682f, 0.00659381f, -0.18808311f, -0.00252521f, 0.10729348f, 
    -0.13625969f, -0.13104601f, -0.07312619f, -0.07945794f, -0.06097342f, -0.10399905f, 0.15664196f, -0.01452649f, 
    0.10312659f, 0.08122049f, -0.11540636f, 0.20104270f, -0.19239777f, -0.13274300f, 0.05451739f, -0.14140020f, 
    0.01479964f, 0.23721500f, 0.04721150f, 0.00233380f, -0.01665184f, -0.00183214f, -0.14618373f, 0.04030349f, 
    -0.10793141f, -0.01198064f, 0.07418022f, 0.05695650f, 0.08027795f, 0.26131159f, -0.09422381f, 0.14957166f, 
    0.06216943f, 0.11001556f, -0.05522706f, -0.09355611f, 0.08538459f, 0.12784852f, 0.01752375f, 0.17729029f, 
    0.39071882f, 0.09862822f, 0.30313316f, 0.12423089f, -0.20567422f, -0.10219626f, -0.03544641f, 0.00392071f, 
    0.09081105f, 0.17442089f, -0.03302649f, -0.05477368f, 0.10287011f, 0.00079066f, 0.21016784f, -0.19841270f, 
    0.02976199f, 0.00657446f, 0.04716339f, 0.03990256f, 0.01056923f, 0.07664438f, -0.02917678f, 0.00433161f, 
    -0.09516161f, -0.05839420f, -0.01710703f, -0.09722178f, -0.06748836f, 0.03858738f, -0.05191470f, -0.17635280f, 
    -0.15106185f, 0.03547456f, -0.18149589f, -0.07622107f, -0.38978186f, -0.30932108f, -0.15748739f, -0.04180118f, 
    0.01422865f, -0.06437735f, 0.17044114f, 0.03584485f, -0.02025665f, -0.10371311f, -0.09181045f, -0.12039616f, 
    -0.01173628f, -0.22308001f, -0.15724421f, 0.04698117f, 0.12328257f, 0.25763768f, 0.01292303f, 0.00292796f, 
    0.10292482f, -0.03663227f, 0.17830411f, -0.14905335f, 0.25480941f, -0.11760636f, -0.06765050f, 0.09203446f, 
    0.03376731f, -0.00952736f, 0.01394333f, 0.16248278f, -0.09412190f, 0.11629449f, 0.18838847f, 0.18318214f, 
    0.04274853f, 0.21381705f, 0.16345535f, 0.01136376f, -0.13759007f, -0.18829136f, 0.28271598f, 0.02798960f, 
    0.01777255f, 0.21243639f, 0.17949869f, 0.05611330f, -0.23125716f, 0.32683465f, -0.16559857f, 0.12841326f, 
    0.35817185f, 0.10762420f, 0.06382415f, 0.18086188f, 0.05069209f, 0.12183119f, 0.11884160f, -0.09209307f, 
    -0.02414754f, 0.12455051f, 0.09037762f, -0.05235948f, -0.05408097f, 0.04438453f, 0.17083544f, -0.16097303f, 
    -0.02189698f, -0.01634779f, -0.03571418f, -0.13345990f, 0.05248248f, 0.23638763f, -0.14514711f, -0.03258007f, 
    -0.24668987f, 0.06514652f, -0.01451956f, -0.01346466f, -0.04393525f, -0.18897000f, 0.04429398f, -0.19619215f, 
    -0.01217719f, 0.25663888f, 0.15750967f, 0.18797112f, -0.01321482f, 0.07064809f, 0.03353694f, 0.07377348f, 
    0.08084607f, 0.03220667f, -0.10273423f, -0.05197771f, -0.33274925f, -0.29073066f, -0.11366271f, -0.24262588f, 
    0.09964863f, 0.07228254f, -0.04643468f, -0.08378832f, -0.06768777f, 0.04067999f, -0.07662304f, 0.02839506f, 
    0.19479689f, 0.21658123f, 0.10198668f, -0.06665448f, 0.02659198f, 0.12802133f, 0.05824441f, -0.01254157f, 
    0.10269230f, 0.01360192f, 0.00069272f, -0.08398508f, 0.06768180f, 0.15339474f, 0.49271190f, 0.05165662f, 
    -0.02276196f, 0.08478644f, 0.09629163f, 0.10641395f, -0.02872288f, 0.01815345f, -0.05152293f, 0.01309809f, 
    -0.10034989f, -0.06448387f, 0.25403908f, 0.25859249f, -0.02654484f, 0.03290332f, 0.06444878f, -0.01795622f, 
    -0.00822894f, -0.01492996f, 0.00916604f, -0.02778582f, -0.17153139f, -0.39442018f, -0.12501715f, 0.04504029f, 
    -0.02944064f, -0.12013911f, -0.13519579f, 0.03381826f, -0.02680980f, -0.00661179f, -0.19397594f, 0.08106293f, 
    -0.37886447f, -0.42332196f, -0.11581486f, -0.13022357f, -0.17682996f, -0.10636851f, -0.00754274f, 0.04836354f, 
    0.02182488f, -0.12532777f, 0.08706559f, 0.03386759f, 0.07709689f, 0.30247563f, -0.08971003f, 0.12601797f, 
    0.07519905f, 0.06428361f, 0.09079158f, -0.13359818f, -0.04043732f, 0.08736672f, -0.17226581f, -0.01387301f, 
    -0.00779001f, -0.03354798f, -0.13217470f, -0.07743450f, 0.15445545f, 0.06465462f, 0.08963618f, 0.01889360f, 
    0.18563412f, 0.20255147f, 0.08532707f, 0.13583428f, 0.08092698f, 0.54453754f, 0.31530643f, 0.21380320f, 
    0.04942101f, 0.01900039f, 0.02932950f, 0.16355605f, -0.01435345f, -0.05349879f, -0.02262764f, -0.04381703f, 
    -0.06448124f, 0.21156988f, 0.16191565f, 0.08972165f, -0.03421544f, 0.06037124f, -0.29605344f, 0.08612585f, 
    0.10844123f, -0.04475155f, 0.09949883f, -0.07018787f, -0.02666440f, 0.29543808f, 0.16275406f, 0.20065106f, 
    0.09229967f, 0.02331943f, 0.10039096f, 0.02589583f, 0.06329975f, -0.02482646f, -0.03823923f, 0.03133621f, 
    0.39002204f, -0.08289501f, 0.20168316f, -0.21944249f, -0.12522748f, -0.02360263f, -0.11041031f, 0.12922433f, 
    -0.02000282f, 0.04677927f, 0.05558873f, 0.00778314f, -0.15558720f, -0.23251201f, 0.04528438f, -0.15628089f, 
    -0.00342591f, -0.18377025f, -0.08648195f, 0.27489832f, -0.13910170f, 0.06615321f, 0.10149749f, -0.02579543f, 
    0.19092953f, 0.17246856f, 0.10676675f, 0.05961378f, 0.02447381f, 0.10467350f, 0.11200433f, 0.16342612f, 
    0.08796414f, -0.02243376f, -0.19784042f, 0.11679573f, -0.09842507f, -0.13824454f, -0.19968544f, -0.20431766f, 
    -0.05642088f, -0.10127915f, -0.20337623f, 0.06527435f, -0.02633547f, 0.02873552f, 0.12517495f, 0.03178225f, 
    0.17762500f, -0.08775846f, 0.32576549f, -0.26493040f, 0.10677890f, -0.00455434f, 0.14356752f, -0.14807646f, 
    0.01681258f, -0.09068741f, -0.00748956f, 0.07793071f, 0.04968148f, -0.06485020f, -0.20175771f, 0.08970081f, 
    0.14793614f, -0.23241591f, 0.07214143f, 0.17295294f, 0.04849787f, 0.03189882f, 0.01183389f, 0.12827839f, 
    -0.02044945f, 0.17756973f, -0.11671204f, 0.01728104f, -0.02101806f, 0.01841178f, -0.04420602f, 0.01234349f, 
    -0.13926181f, -0.02536359f, 0.03709916f, -0.10833517f, -0.12726937f, 0.13486508f, -0.00299712f, 0.04010162f, 
    0.12365143f, -0.02898608f, 0.04131257f, -0.10259766f, -0.12003233f, -0.00104309f, -0.01051055f, -0.03234698f, 
    -0.15649161f, -0.43957788f, -0.04792606f, 0.24967003f, 0.01862537f, -0.07692841f, 0.03271540f, -0.07225885f, 
    0.08180741f, 0.00308739f, 0.08610658f, -0.03666312f, 0.09513349f, -0.14231780f, -0.08392901f, -0.07004735f, 
    0.10354858f, -0.06464526f, 0.03326920f, -0.10373777f, -0.14013316f, -0.04542108f, -0.12511945f, -0.00027541f, 
    -0.05922604f, 0.03677596f, -0.03888463f, 0.20736454f, -0.03430222f, 0.22133954f, -0.09765428f, 0.02042225f, 
    -0.01611672f, -0.16285342f, -0.19268923f, -0.07343715f, 0.15935324f, 0.16917619f, -0.08280114f, -0.09616569f, 
    0.04373417f, 0.05077169f, -0.19949716f, -0.16266353f, -0.00091837f, -0.18316907f, 0.03450460f, -0.02068979f, 
    -0.07224900f, -0.10682847f, -0.02551517f, 0.13735516f, -0.03667616f, 0.01634455f, 0.11155367f, 0.02293658f, 
    0.08971644f, 0.03469932f, 0.03469916f, -0.23479635f, 0.34639105f, 0.07884993f, 0.23407167f, 0.11520895f, 
    0.12459181f, 0.15580159f, -0.05387551f, -0.20885262f, -0.00415350f, -0.02787154f, -0.09217902f, 0.07308055f, 
    0.05675545f, 0.07840665f, -0.04740947f, 0.17787588f, 0.18685326f, -0.18372488f, 0.06739962f, 0.22805378f, 
    0.04023786f, 0.11969069f, -0.05437439f, -0.03707838f, -0.03019044f, -0.01161784f, 0.05358031f, -0.10323551f, 
    -0.03634520f, -0.04071717f, 0.05811041f, 0.08433624f, 0.02133404f, -0.08527640f, 0.17353432f, 0.12319438f, 
    -0.30517921f, 0.13563107f, -0.10841014f, 0.07717240f, 0.03616996f, -0.05488135f, 0.05160643f, 0.16336057f, 
    0.02078651f, 0.08136477f, -0.00019573f, 0.01363520f, 0.26041341f, 0.00630462f, -0.12978484f, -0.02788936f, 
    0.11099026f, -0.04257337f, 0.08607171f, 0.00292402f, 0.00971796f, 0.12602757f, -0.00466017f, 0.13073003f, 
    0.05189109f, 0.09126218f, 0.00943307f, 0.04415046f, 0.14007556f, 0.02556798f, 0.05940022f, -0.05407142f, 
    -0.03486270f, 0.04902561f, -0.10776198f, -0.06007997f, -0.09927018f, 0.20685910f, 0.10804848f, 0.08671381f, 
    0.27604347f, 0.14528023f, 0.16271698f, -0.03171283f, -0.02612248f, 0.03334180f, 0.04844295f, 0.00151736f, 
    0.18618189f, 0.21168295f, -0.26118961f, -0.06524210f, 0.00908243f, 0.03998735f, 0.16011791f, -0.01098736f, 
    -0.02847861f, -0.04772225f, -0.13361867f, 0.02453569f, -0.03301024f, 0.23247708f, 0.11574873f, 0.17832619f, 
    -0.05525729f, 0.06717128f, -0.04648416f, -0.15316635f, 0.13538171f, -0.02466921f, 0.00367685f, 0.11123367f, 
    -0.01961073f, 0.03225416f, -0.00475662f, 0.03248073f, -0.09303465f, 0.19672830f, 0.05309034f, 0.04882216f, 
    -0.04172170f, -0.10406077f, -0.06596810f, -0.16250964f, 0.12925832f, 0.17607845f, 0.05596599f, -0.07185676f, 
    0.08977148f, 0.14068300f, 0.07772390f, 0.06316068f, 0.09151611f, -0.09530879f, 0.04197940f, -0.00404366f, 
    -0.18162724f, 0.07095107f, 0.17857429f, 0.12142163f, -0.02757236f, -0.13877608f, 0.07738631f, -0.08722250f, 
    -0.02874705f, -0.03070132f, -0.00166036f, 0.00619489f, 0.07911617f, -0.10186493f, 0.20758377f, 0.18776946f, 
    0.01940033f, 0.01040760f, 0.06451634f, 0.03156426f, 0.11970274f, -0.02910322f, -0.07927173f, 0.04601881f, 
    0.16881770f, 0.11990585f, 0.18639314f, 0.31194040f, -0.10645697f, 0.07428452f, -0.08531344f, 0.03184741f, 
    -0.21439469f, -0.02576584f, -0.07138027f, -0.04930446f, -0.05114043f, -0.18761323f, 0.35001597f, -0.00638273f, 
    0.02223838f, 0.05393407f, 0.02596166f, 0.22163868f, 0.09738354f, 0.20357275f, 0.06775729f, 0.29495582f, 
    -0.14128539f, -0.00156184f, 0.02166489f, 0.00388683f, -0.13151500f, -0.07776179f, -0.07648486f, -0.08756758f, 
    -0.06772938f, 0.06979351f, -0.04244931f, 0.09230046f, 0.14847222f, 0.16472720f, -0.12677233f, -0.19984561f, 
    0.06954224f, 0.00669613f, -0.05502142f, -0.12126106f, -0.02705955f, 0.06047955f, -0.02998338f, 0.03606660f, 
    0.05661123f, 0.18968861f, 0.30237558f, -0.05597801f, 0.13854259f, 0.04237632f, 0.07979248f, 0.13206518f, 
    -0.01260476f, -0.24121916f, 0.20772019f, 0.17095992f, 0.08429649f, 0.23131074f, 0.04557942f, -0.01695654f, 
    0.22496262f, 0.12475333f, 0.15674300f, 0.00832246f, -0.07463016f, -0.01329325f, -0.11002895f, -0.14304788f, 
    0.22113483f, -0.02587698f, -0.16519351f, -0.02420177f, -0.00917089f, 0.02609606f, -0.02789158f, 0.02820387f, 
    0.00057493f, 0.03172333f, -0.10518119f, -0.02034708f, 0.13526726f, -0.14479654f, 0.00287047f, 0.08773614f, 
    0.04543165f, -0.02503798f, 0.09972719f, -0.04552906f, 0.03118745f, -0.03397495f, 0.08643170f, 0.10624661f, 
    -0.11196168f, -0.52827495f, 0.01439908f, -0.23821925f, -0.00979881f, 0.26461631f, 0.11651178f, 0.03238837f, 
    0.04016425f, -0.04517726f, 0.04353778f, 0.12885308f, -0.14925726f, 0.14905918f, 0.00307079f, -0.25801700f, 
    -0.07155478f, -0.12793492f, 0.01301317f, -0.03433359f, -0.09058721f, -0.05851819f, 0.00639980f, -0.12173697f, 
    -0.05060738f, -0.26167780f, -0.12554796f, 0.00914297f, 0.01373919f, -0.02284035f, 0.04096940f, 0.06070978f, 
    0.04781336f, -0.00025817f, -0.02283281f, -0.12836844f, -0.08088067f, 0.07362518f, -0.06215147f, 0.03017901f, 
    -0.01577814f, 0.15730749f, 0.07509467f, 0.01115923f, -0.04020956f, -0.06899176f, -0.02670864f, -0.04905134f, 
    0.14264035f, 0.04896700f, 0.16136880f, 0.00563079f, 0.20373727f, -0.07760479f, 0.05716189f, 0.11116399f, 
    -0.22701460f, 0.05280730f, 0.06167739f, -0.09545941f, 0.19131400f, 0.03307246f, 0.34741589f, -0.18410371f, 
    0.10766151f, 0.03925746f, 0.12598537f, 0.06823404f, -0.08035719f, -0.10834493f, -0.16410087f, -0.18695965f, 
    -0.04448161f, -0.07010333f, 0.18145637f, 0.15264773f, -0.07406923f, 0.01879394f, 0.00021909f, 0.06793043f, 
    -0.10364821f, -0.03660114f, 0.06368733f, -0.01507575f, -0.11468003f, -0.23723713f, 0.02836266f, 0.04860219f, 
    0.00168006f, 0.04731957f, 0.09504456f, 0.00744347f, -0.00538797f, 0.05686833f, -0.06177784f, 0.11353578f, 
    0.24937530f, 0.02475439f, -0.08362816f, 0.07598605f, -0.02034552f, 0.02267457f, 0.03894123f, 0.01022279f, 
    0.02456449f, 0.06313412f, -0.01125287f, 0.05939095f, -0.33386746f, -0.08093590f, -0.02192313f, 0.10794729f, 
    0.08392750f, 0.04653995f, 0.19570895f, -0.05199676f, -0.02215132f, 0.15397370f, -0.10078962f, -0.20215033f, 
    0.08037416f, 0.04879426f, -0.01259409f, 0.08610400f, 0.00772654f, 0.03648854f, 0.09793735f, -0.01408368f, 
    -0.14207953f, -0.01608692f, -0.08240262f, 0.03154982f, 0.10558501f, 0.02335261f, 0.09684590f, -0.24025047f, 
    0.03878671f, -0.12614141f, 0.03761153f, -0.04304949f, -0.06662412f, 0.01432037f, -0.08266186f, -0.00164833f, 
    -0.04543984f, 0.07186522f, -0.32038063f, -0.26473683f, -0.04841886f, 0.07647827f, 0.02425998f, -0.14264221f, 
    0.03502204f, 0.02588806f, -0.04950374f, -0.23996033f, 0.16908354f, 0.15464585f, 0.16286001f, 0.23224777f, 
    -0.00657755f, 0.01840477f, -0.14963253f, -0.02969765f, -0.00375127f, -0.05831926f, 0.15784055f, 0.11347050f, 
    0.36224180f, 0.00615709f, 0.00686668f, -0.01646239f, 0.02582135f, -0.09825015f, -0.04399442f, -0.07224438f, 
    0.07978100f, 0.13416201f, 0.05162332f, 0.21578395f, 0.03794193f, 0.01899026f, -0.07306729f, 0.09417995f, 
    0.11589485f, -0.14509839f, 0.10349781f, -0.02644922f, 0.17919083f, 0.12034170f, 0.02638888f, 0.05177366f, 
    0.17429058f, 0.17077328f, -0.07089345f, -0.06703112f, 0.11791530f, 0.09094956f, 0.23070204f, 0.12631842f, 
    0.08829115f, 0.07982573f, -0.16557065f, 0.01263406f, 0.14324194f, 0.17180893f, -0.27607268f, 0.03746989f, 
    -0.01328679f, -0.11795507f, 0.01317068f, 0.11708631f, -0.09912115f, -0.07739367f, 0.10305551f, -0.01677152f, 
    -0.39438692f, -0.06477663f, 0.00798940f, 0.37326488f, 0.22536705f, 0.07742369f, 0.07789920f, -0.07812797f, 
    0.00500069f, -0.17771696f, -0.12859121f, 0.06400242f, -0.10089915f, 0.17923680f, -0.21312317f, 0.05600947f, 
    0.05411715f, -0.16743691f, -0.14147356f, -0.12248225f, 0.02881313f, 0.08068171f, -0.08594905f, 0.01732215f, 
    0.08432484f, -0.02706871f, 0.14328437f, 0.07690109f, -0.08052161f, 0.17401357f, -0.07094594f, 0.01551421f, 
    0.00523646f, -0.15273334f, 0.10826387f, -0.22206818f, -0.39611107f, 0.14903989f, 0.08006441f, 0.28299496f, 
    0.22175971f, 0.13337316f, 0.07691524f, -0.02411866f, 0.01865634f, -0.09471162f, 0.02113193f, -0.05634681f, 
    -0.26216456f, 0.00455261f, -0.01472790f, 0.45346645f, 0.09145931f, -0.21785039f, 0.06214102f, -0.14082515f, 
    -0.11328143f, -0.07479084f, -0.12147312f, -0.00016453f, 0.09351714f, 0.03623378f, 0.21385399f, 0.26192892f, 
    0.18104967f, -0.01334148f, -0.08004627f, -0.05695428f, 0.22754657f, 0.06835187f, -0.13285498f, 0.01197319f, 
    0.30232039f, 0.10755889f, 0.05779483f, 0.12702574f, -0.09983056f, -0.03748548f, -0.11739330f, 0.15893026f, 
    -0.00874542f, 0.03836235f, -0.10649974f, 0.03941853f, 0.02352024f, 0.22079135f, 0.20161568f, 0.08663138f, 
    0.13161933f, 0.14468932f, -0.00735199f, -0.06767526f, 0.02661782f, -0.02048960f, -0.14912967f, 0.19363517f, 
    0.00950081f, -0.00982126f, -0.02703530f, -0.04100744f, -0.00830159f, 0.08608568f, 0.04821119f, -0.12148976f, 
    0.07072937f, 0.02543827f, 0.05323991f, -0.05484081f, -0.26487795f, 0.23837970f, 0.27164662f, 0.26618999f, 
    0.02356731f, 0.12088080f, -0.01968568f, -0.05846685f, 0.02509553f, -0.08190338f, -0.05011719f, 0.00549203f, 
    -0.52438897f, 0.04224445f, 0.14371949f, 0.18565443f, -0.16083613f, 0.21672159f, -0.02158278f, 0.13772686f, 
    -0.04581744f, -0.06067067f, 0.22330548f, 0.11507191f, -0.12338094f, 0.26162508f, 0.06233088f, 0.05907882f, 
    0.05488421f, -0.09446274f, 0.00168159f, -0.06303563f, -0.05570916f, -0.04067946f, -0.07307825f, -0.05804971f, 
    0.22773726f, -0.00800327f, -0.06097727f, -0.26565152f, -0.04643356f, -0.13139212f, -0.06958154f, 0.11130644f, 
    0.01714163f, 0.01143628f, 0.04324256f, -0.02308870f, -0.19697763f, -0.10714751f, 0.08415852f, 0.11837718f, 
    0.01994602f, 0.06213729f, 0.00837380f, -0.02303371f, -0.00580080f, -0.03556449f, 0.01062743f, 0.08505587f, 
    0.13443066f, -0.23087771f, 0.28708279f, -0.19501819f, -0.01997868f, 0.05414307f, 0.09745684f, 0.13033529f, 
    0.04108028f, 0.02004002f, -0.04210455f, 0.02556044f, 0.14476827f, 0.26014414f, 0.12362321f, -0.18378021f, 
    -0.14633062f, -0.23691367f, -0.07708862f, 0.09739469f, 0.02383207f, -0.01352403f, 0.00775539f, -0.15162145f, 
    0.22435082f, -0.10091912f, -0.18272315f, -0.02478350f, -0.11859055f, -0.00354501f, -0.03615880f, 0.00326567f, 
    -0.05136655f, 0.14351681f, -0.04498600f, -0.08268714f, -0.12750053f, 0.14365400f, 0.03306487f, -0.01634122f, 
    -0.26638132f, 0.10217115f, -0.06629216f, 0.03114583f, -0.04317053f, -0.05375142f, -0.09181649f, -0.07651187f, 
    0.03847429f, 0.03083015f, 0.09396357f, -0.06859182f, 0.01058823f, 0.05020524f, 0.03418699f, 0.11840778f, 
    -0.00694444f, -0.03558765f, -0.04475639f, -0.00316044f, 0.21373425f, -0.06693961f, 0.15952340f, 0.03044608f, 
    -0.04520414f, -0.00959780f, 0.12767883f, 0.05189160f, -0.02348254f, 0.03425347f, -0.06412008f, -0.03739833f, 
    0.11866432f, 0.14149041f, 0.16759966f, 0.19210774f, -0.15317994f, -0.07891978f, 0.09964490f, 0.03239232f, 
    0.02483125f, 0.03804441f, 0.00787658f, -0.08307415f, -0.14601022f, -0.33771524f, 0.14246082f, 0.04622440f, 
    0.01296273f, -0.13398568f, 0.01572852f, -0.04004985f, 0.06479749f, -0.05871886f, -0.05908351f, -0.05725538f, 
    0.20100465f, 0.02402508f, 0.02960848f, -0.00102832f, 0.00233147f, 0.04362915f, -0.03283468f, -0.13005133f, 
    -0.05166359f, -0.12184286f, 0.10431878f, 0.04534928f, -0.24361755f, -0.08121377f, 0.21337779f, 0.13107154f, 
    0.06175602f, 0.03346227f, 0.12550530f, 0.16591896f, 0.05354634f, 0.23337863f, -0.02063433f, -0.07784050f, 
    0.08096597f, 0.16735528f, 0.05143458f, -0.06338918f, -0.02369866f, 0.01873578f, -0.00043320f, -0.03917491f, 
    -0.05862854f, -0.14544559f, -0.10761438f, 0.09842487f, 0.12791085f, 0.20076138f, 0.06912716f, -0.02361162f, 
    0.01671027f, -0.06809502f, 0.13724177f, -0.00167098f, -0.16180257f, -0.04374908f, -0.06403517f, -0.03371782f, 
    0.02384224f, 0.14150678f, 0.10160932f, -0.23311061f, -0.13545468f, 0.16707271f, -0.05685388f, -0.12131104f, 
    -0.16000889f, -0.24353583f, 0.02547831f, 0.00139245f, 0.01760597f, 0.25548032f, 0.19597684f, 0.12044796f, 
    -0.06207912f, 0.11631098f, -0.00547115f, -0.04034118f, 0.01018755f, 0.07706156f, 0.00530129f, -0.03061196f, 
    0.46388677f, 0.03159137f, 0.14843008f, -0.03212904f, -0.09683958f, 0.01371185f, 0.03799699f, 0.07040256f, 
    0.01079114f, 0.00413068f, -0.01251683f, 0.00525120f, 0.05897057f, -0.39688271f, 0.09039871f, 0.03597896f, 
    -0.15130812f, -0.08459185f, 0.03262952f, -0.05834613f, 0.11361536f, -0.04257555f, 0.11925387f, -0.06084849f, 
    0.01934449f, -0.23787200f, 0.03512456f, -0.04356345f, 0.05047651f, 0.24101919f, 0.11066389f, 0.01746027f, 
    -0.13918282f, -0.07185113f, -0.08359256f, -0.06662757f, -0.08245730f, -0.00546330f, -0.02709791f, -0.23587327f, 
    0.01433219f, 0.01394837f, 0.20576948f, -0.10172392f, -0.13892221f, -0.03287712f, -0.02805073f, -0.10875036f, 
    0.14483787f, -0.00187706f, 0.40434968f, -0.13615733f, 0.02858445f, -0.00123972f, 0.10277783f, -0.16019805f, 
    -0.01115465f, -0.02258680f, 0.14952910f, 0.03139761f, -0.04837408f, -0.16107988f, -0.16356023f, 0.02227201f, 
    0.09095595f, -0.12882276f, -0.06898436f, 0.07056356f, -0.01666553f, -0.12881173f, 0.03951036f, 0.10418525f, 
    0.06853633f, 0.17608930f, -0.13966179f, -0.05897801f, 0.02316040f, 0.03453689f, -0.24110796f, -0.21141666f, 
    0.10167247f, 0.02703381f, -0.06044463f, 0.03173248f, -0.10500620f, 0.16718610f, -0.04733843f, -0.03791814f, 
    0.10468817f, -0.12831844f, -0.11928209f, -0.09214444f, -0.02844283f, 0.09373539f, 0.12044565f, 0.05420700f, 
    -0.19896273f, -0.48777995f, 0.25834692f, 0.20426190f, 0.02431287f, -0.03471106f, -0.02552333f, -0.02860390f, 
    0.01954888f, 0.11877076f, -0.02427318f, -0.06708813f, -0.04118415f, -0.42885613f, 0.08221888f, 0.07028152f, 
    0.12935427f, -0.07007409f, 0.04873128f, 0.01880720f, 0.01357968f, -0.03892840f, 0.12140620f, 0.02288792f, 
    0.01793305f, -0.01134769f, -0.13401119f, 0.17784336f, 0.04497323f, 0.10837767f, 0.00640092f, -0.02641181f, 
    0.07771324f, -0.01997137f, 0.05305807f, -0.01938063f, 0.07240073f, 0.20367363f, -0.09528079f, -0.07479185f, 
    0.03112245f, 0.02594623f, -0.21518722f, 0.04664939f, 0.01134219f, -0.02996984f, 0.19869818f, -0.08018207f, 
    0.01158751f, 0.00479070f, 0.03842913f, 0.07292595f, -0.05080019f, -0.07508302f, -0.03525405f, -0.12666737f, 
    0.13677010f, -0.09032201f, -0.10973943f, -0.23778246f, 0.41322643f, 0.23259473f, 0.18394500f, 0.05787773f, 
    0.22143893f, 0.19647215f, 0.03335685f, -0.00518346f, 0.00576020f, 0.02972460f, 0.05647320f, -0.05226121f, 
    -0.11735711f, -0.02943109f, 0.09499866f, 0.06900214f, 0.07892169f, -0.09936915f, 0.20779584f, 0.18136674f, 
    0.11001152f, 0.16047658f, 0.00536286f, 0.03926316f, 0.08752108f, 0.07839892f, 0.12609002f, -0.08805834f, 
    -0.13002272f, 0.14265592f, 0.11137187f, 0.08178651f, -0.13767281f, -0.02744431f, 0.12741750f, 0.18629518f, 
    -0.28334051f, 0.15740170f, -0.25384495f, -0.10777953f, 0.16715334f, 0.12970880f, 0.06071451f, -0.03366756f, 
    -0.09667838f, 0.00248971f, 0.21686950f, 0.08277965f, 0.00072883f, 0.22003029f, -0.05767885f, -0.08930881f, 
    0.00277511f, 0.02904673f, -0.14065754f, 0.19260629f, -0.23200803f, 0.03790573f, -0.00014067f, -0.18874319f, 
    0.12146602f, 0.13044339f, -0.09242131f, -0.02806217f, 0.16070803f, -0.14932579f, -0.08160856f, -0.17804337f, 
    -0.06017192f, 0.16146556f, -0.01239077f, -0.19367276f, -0.01094195f, -0.06158796f, 0.17782556f, 0.24496236f, 
    0.12147019f, -0.00434868f, -0.21896607f, -0.04946309f, 0.11552712f, 0.00747712f, 0.02816821f, 0.06362522f, 
    0.13799626f, 0.30925035f, -0.19989492f, -0.31374550f, -0.07765627f, 0.07653227f, 0.09241531f, 0.17334916f, 
    0.06163351f, 0.12925139f, -0.07697330f, -0.20547621f, 0.09000083f, -0.02084823f, 0.08376420f, -0.08309842f, 
    0.13728896f, -0.00274143f, -0.05908972f, 0.03262061f, 0.06503359f, -0.08242179f, 0.21529345f, 0.03200102f, 
    -0.13516614f, 0.01595473f, -0.12776214f, -0.15803450f, 0.01273422f, 0.00847653f, 0.08749547f, 0.10407217f, 
    -0.07207515f, -0.01216617f, 0.01545307f, -0.04537126f, 0.16796316f, -0.02997971f, 0.05099287f, -0.10504770f, 
    -0.02292640f, -0.04421907f, -0.14433219f, 0.18815427f, 0.12845601f, 0.07482846f, -0.01215023f, -0.04327564f, 
    0.17353269f, -0.02087440f, 0.12148007f, -0.07309121f, -0.09199133f, 0.08436290f, -0.07888246f, 0.03232442f, 
    0.18032680f, 0.11803450f, 0.19863848f, 0.04779436f, 0.02407564f, 0.02836607f, 0.01632793f, -0.10143086f, 
    -0.00610861f, -0.02265045f, -0.08493298f, 0.08104616f, -0.07804440f, 0.10237060f, 0.02090997f, -0.07463022f, 
    -0.12164804f, -0.11016428f, 0.04576394f, 0.00962819f, -0.00115673f, 0.01724704f, -0.16735832f, -0.03473289f, 
    0.01258011f, 0.00293500f, 0.06297212f, 0.01460939f, -0.01740979f, 0.02813026f, -0.10404595f, 0.16859898f, 
    -0.02528519f, -0.06275219f, 0.19754927f, -0.07810535f, 0.03735378f, -0.03755572f, -0.02844310f, 0.26114374f, 
    -0.07739186f, -0.00393198f, -0.06121329f, -0.00859262f, -0.12538989f, -0.08516626f, -0.00894378f, 0.13028075f, 
    -0.06535888f, 0.06622038f, 0.06038427f, 0.10042842f, 0.00155659f, -0.01285338f, -0.16089441f, -0.27493274f, 
    0.13142395f, -0.00053206f, 0.14558372f, -0.14454573f, 0.02968503f, 0.07357600f, -0.04520625f, 0.02162613f, 
    0.30816102f, 0.00593097f, -0.06269811f, -0.22519873f, 0.21823013f, -0.07059976f, 0.03012231f, 0.31472510f, 
    -0.09219171f, -0.01894090f, -0.01289272f, 0.17054555f, 0.10487275f, 0.08597409f, 0.01667597f, -0.10543491f, 
    0.10962104f, -0.07396982f, 0.09004153f, 0.06809189f, 0.10677897f, -0.13494779f, -0.24440201f, -0.13428673f, 
    0.13160434f, -0.15689757f, 0.13865809f, 0.03990480f, -0.09448417f, 0.10478970f, 0.08277173f, 0.01612362f, 
    0.16459626f, 0.04500702f, 0.01110054f, 0.00153185f, 0.18590543f, -0.00770031f, -0.11354249f, 0.00033202f, 
    0.00977199f, -0.14365049f, 0.13613985f, 0.02445818f, 0.09390172f, 0.06657241f, 0.02327344f, -0.05401524f, 
    -0.18563713f, 0.06424547f, -0.19335030f, 0.14044331f, 0.08786052f, 0.01359255f, 0.13902910f, -0.01678653f, 
    0.04363970f, 0.01142503f, -0.05901327f, -0.00587300f, -0.15960070f, -0.02715740f, 0.00022417f, -0.09609131f, 
    0.08802341f, 0.24177252f, -0.03848234f, 0.08433659f, -0.03298733f, 0.02177055f, 0.00214447f, 0.00193369f, 
    0.13101992f, -0.34643316f, 0.19089347f, 0.27905253f, 0.07411242f, 0.01607218f, -0.03860531f, -0.14073285f, 
    -0.08865361f, -0.02934170f, 0.19105792f, 0.13873446f, -0.08921577f, 0.10855316f, -0.08913147f, 0.15131480f, 
    -0.09405513f, -0.03742272f, 0.04665345f, -0.04976378f, 0.09697101f, -0.02366609f, -0.16525038f, -0.06603015f, 
    0.06333198f, -0.00819114f, 0.08619138f, 0.28861377f, 0.04033607f, 0.13925955f, 0.03516341f, 0.06449377f, 
    -0.09602262f, 0.11592160f, 0.05051405f, 0.10833896f, 0.05341038f, 0.11187782f, -0.21102980f, 0.17375949f, 
    0.06366613f, 0.01072401f, 0.18098471f, -0.17040043f, -0.06643098f, -0.09083690f, 0.12339254f, -0.01063335f, 
    -0.26012126f, -0.01001308f, -0.20448822f, -0.08339930f, 0.08121367f, -0.09474035f, 0.14396720f, -0.06502624f, 
    0.00141253f, -0.00552667f, -0.12296825f, 0.05924173f, 0.03888524f, -0.08503512f, 0.02223272f, -0.06667290f, 
    0.04557674f, -0.08417662f, -0.02918926f, -0.08593588f, 0.02242776f, -0.10990313f, -0.11294677f, -0.00074197f, 
    0.34164208f, 0.17417116f, 0.02731296f, 0.10962354f, -0.07187806f, 0.03769297f, 0.02989112f, 0.04938103f, 
    -0.10122611f, -0.03007105f, 0.01059478f, 0.03259683f, 0.04417897f, -0.26941928f, 0.23193485f, -0.14308962f, 
    -0.09472446f, 0.15302791f, -0.08308319f, 0.15450282f, 0.03532951f, 0.16274437f, 0.09418412f, -0.04118881f, 
    -0.05289603f, -0.06225822f, 0.06992984f, 0.04652469f, 0.11398198f, 0.04567597f, 0.05137705f, -0.14054632f, 
    -0.02548037f, 0.01160960f, -0.04104963f, -0.07174896f, 0.14122728f, 0.17963207f, 0.22441091f, 0.26357052f, 
    -0.15240957f, -0.05540762f, -0.06237210f, 0.00952908f, -0.01617103f, -0.05973304f, -0.06735419f, -0.05661602f, 
    -0.15186140f, 0.25461453f, 0.29528454f, 0.13895841f, -0.08987184f, 0.10314637f, 0.16543941f, -0.25424555f, 
    -0.07122578f, -0.05113098f, 0.09837986f, -0.14046708f, 0.01894654f, 0.01807876f, -0.10118372f, -0.01167181f, 
    -0.00367768f, 0.19539376f, -0.08421502f, 0.01972840f, -0.02452967f, 0.24863492f, 0.22522403f, 0.02343762f, 
    -0.02732905f, 0.32092881f, -0.42509592f, 0.29146832f, 0.10441008f, -0.02457145f, 0.07699111f, 0.06235477f, 
    -0.07055808f, 0.00066118f, -0.03975718f, 0.01664475f, -0.11637144f, 0.03957162f, 0.07649039f, 0.04031834f, 
    -0.04128950f, 0.12460157f, 0.00979275f, -0.11152919f, -0.05995940f, -0.07939651f, 0.01079126f, 0.01325163f, 
    0.29690024f, -0.24411307f, 0.27379337f, -0.26846442f, -0.14760384f, 0.06860260f, 0.08089013f, 0.11984938f, 
    -0.00805420f, 0.07446515f, 0.09895205f, -0.07796986f, 0.12015117f, 0.19623023f, 0.07148992f, -0.04153206f, 
    -0.02876346f, -0.01784474f, 0.09103547f, -0.10543485f, -0.09508970f, -0.04507995f, -0.06488492f, 0.03562314f, 
    -0.02778133f, -0.12596026f, -0.21882020f, 0.04812161f, 0.05385870f, 0.05038070f, -0.01462148f, 0.10301564f, 
    0.19092070f, 0.15073308f, 0.05279247f, 0.00662498f, -0.13290781f, -0.22895846f, 0.12150788f, -0.09958497f, 
    -0.07830281f, 0.12548356f, -0.07198024f, -0.01567282f, 0.00196041f, -0.14354581f, -0.04079586f, -0.06577574f, 
    0.12273853f, 0.04959544f, 0.15026072f, 0.13803044f, 0.13398935f, -0.01948956f, 0.15572254f, 0.09679152f, 
    0.07389846f, -0.00774690f, -0.02122714f, 0.07619601f, 0.32826591f, -0.00219670f, 0.30898798f, -0.02035212f, 
    -0.06642653f, 0.10484017f, 0.09324256f, -0.00053434f, 0.04357599f, -0.08656312f, -0.11097386f, 0.01359889f, 
    0.24111499f, 0.56225723f, 0.27642867f, 0.10395896f, -0.10993555f, 0.01039728f, -0.11306535f, -0.08659863f, 
    -0.03039985f, -0.05677730f, -0.03538077f, 0.06876196f, -0.13748012f, 0.02259857f, -0.05507649f, 0.04936180f, 
    -0.12028757f, 0.06918420f, -0.03439442f, 0.01058025f, -0.17320317f, -0.04400053f, -0.00724134f, -0.03514625f, 
    -0.19447522f, -0.26519012f, -0.11672188f, -0.19795364f, 0.12164796f, -0.09048680f, 0.08322232f, -0.01323371f, 
    0.08046413f, -0.03098147f, 0.04577873f, -0.00719942f, -0.06876822f, -0.08880582f, -0.02864660f, 0.05865473f, 
    0.13383891f, -0.04697375f, 0.12375075f, -0.03907685f, 0.01940886f, 0.24071281f, 0.15594657f, -0.17901044f, 
    0.12658814f, -0.11069638f, -0.00022826f, -0.02279095f, 0.19578001f, 0.12439064f, 0.01131763f, 0.04075738f, 
    -0.01372270f, -0.01309533f, -0.09603447f, 0.05809188f, -0.02798417f, 0.03473065f, 0.15901205f, -0.06876223f, 
    -0.10090432f, -0.14291389f, 0.06078556f, 0.25883171f, 0.06275335f, 0.07772692f, 0.06855801f, 0.01836896f, 
    0.03074415f, -0.14370787f, -0.28488714f, -0.21718284f, -0.14107729f, 0.26118386f, 0.11758667f, -0.13355623f, 
    0.06732949f, -0.06711661f, -0.05907100f, 0.00142724f, -0.06409723f, -0.00486296f, 0.16742484f, 0.33304626f, 
    0.09531116f, 0.07723455f, -0.09690973f, -0.03143390f, 0.01407254f, 0.00221209f, 0.05707114f, 0.12053520f, 
    0.48201689f, 0.14858902f, 0.37107453f, 0.13695717f, 0.03347489f, -0.03175804f, -0.13785185f, -0.00766880f, 
    0.15385553f, 0.06003664f, 0.09263019f, 0.17493179f, -0.11419477f, -0.21192390f, 0.13719307f, 0.11209274f, 
    0.05695749f, -0.05642759f, -0.13656315f, -0.04090668f, 0.12845375f, -0.08404429f, 0.09335034f, 0.00007058f, 
    0.27382949f, 0.16897482f, 0.12084725f, 0.04396674f, -0.04510828f, 0.07529336f, 0.11372101f, 0.03674696f, 
    -0.04151098f, -0.09701162f, 0.06244280f, -0.03526435f, -0.06282938f, -0.31749541f, -0.18047987f, 0.31787759f, 
    0.04783427f, 0.11437321f, 0.07224897f, -0.00645707f, 0.00166564f, -0.13460045f, -0.02220647f, -0.06040328f, 
    -0.06625561f, 0.05889643f, -0.04418031f, -0.03873712f, 0.04120637f, -0.11305017f, 0.04477283f, -0.13325869f, 
    -0.07438251f, 0.03481208f, 0.00927960f, 0.20116018f, 0.14917710f, 0.01991422f, -0.28080311f, -0.02345824f, 
    -0.00221579f, -0.06534317f, 0.10526851f, 0.21370459f, 0.19495219f, 0.04724355f, 0.24036446f, 0.10741448f, 
    -0.06487249f, -0.00907575f, 0.22364143f, 0.17657591f, -0.03567658f, -0.08487691f, -0.04584518f, -0.01097251f, 
    0.07741462f, -0.02615078f, 0.06675354f, -0.06374826f, -0.25222710f, 0.10697456f, 0.03253466f, 0.10193862f, 
    0.13782147f, -0.03514508f, -0.01695239f, -0.01778042f, -0.16780089f, -0.01792144f, -0.01811898f, 0.00848663f, 
    -0.05024782f, 0.15598315f, -0.00302334f, -0.07874339f, 0.09030289f, 0.07197151f, -0.07649957f, 0.11340497f, 
    -0.05125842f, 0.02437153f, 0.09000694f, 0.08677480f, 0.10755431f, 0.74269766f, -0.29631996f, 0.05055853f, 
    0.00147226f, -0.10257964f, 0.01858713f, 0.11101744f, -0.06926339f, 0.15498038f, 0.24919470f, 0.15609267f, 
    -0.22126447f, -0.00548394f, 0.16123356f, -0.06894428f, -0.25881958f, -0.00692709f, -0.11857487f, 0.05121140f, 
    0.04836328f, 0.12154126f, -0.19076878f, -0.03303682f, 0.47592527f, -0.04167629f, 0.16332491f, -0.15201139f, 
    -0.01238615f, 0.11741430f, -0.11399875f, -0.04174466f, 0.01199890f, -0.07059856f, 0.07028907f, 0.23812525f, 
    -0.28449130f, -0.08159622f, -0.05993896f, -0.04686747f, -0.13059609f, -0.10853310f, -0.12826775f, 0.03391979f, 
    -0.06492894f, -0.18683758f, -0.10839162f, -0.17311209f, -0.20279698f, -0.31425250f, -0.15365374f, 0.20004013f, 
    0.02488972f, -0.01446017f, -0.11884336f, -0.02796382f, 0.09345742f, -0.11220603f, -0.03623096f, -0.09013068f, 
    0.20771995f, -0.23582476f, 0.02508241f, 0.06852390f, 0.10418425f, 0.07030084f, -0.01818313f, 0.13776074f, 
    -0.02028787f, 0.07629940f, 0.15646106f, 0.11674792f, 0.03617195f, -0.06639096f, -0.09654057f, -0.01700665f, 
    -0.03163505f, -0.09424669f, 0.06324751f, 0.08119756f, 0.00209566f, 0.02172808f, 0.05126875f, 0.08758361f, 
    -0.50482130f, 0.29403651f, 0.24968033f, 0.31627032f, 0.03727837f, -0.07910980f, 0.11674831f, -0.06072458f, 
    -0.01929318f, 0.10559628f, -0.08988497f, 0.09536582f, -0.05265086f, 0.47729164f, -0.35611674f, 0.05140473f, 
    0.10647027f, 0.09237003f, 0.03704149f, 0.07410403f, 0.05625926f, 0.10723235f, 0.02120024f, -0.02428624f, 
    -0.08975677f, 0.07672106f, 0.12811454f, -0.02944629f, -0.01229258f, 0.01982310f, -0.03327569f, 0.01525426f, 
    0.07012355f, 0.15042827f, -0.00868279f, -0.04003931f, -0.34104714f, -0.04160791f, 0.03498177f, 0.19999443f, 
    0.07981859f, 0.04048244f, -0.21730877f, -0.08050384f, 0.11629847f, -0.08570605f, 0.06220326f, 0.00306710f, 
    0.01130464f, 0.23163930f, -0.17103183f, 0.17115173f, -0.05170591f, -0.15229784f, 0.05072803f, 0.24779375f, 
    0.04443104f, 0.07895377f, -0.07666114f, -0.04732736f, -0.26203731f, -0.00168194f, -0.17128140f, -0.11656158f, 
    -0.04573949f, 0.16355945f, -0.07514593f, 0.08644348f, 0.09505460f, 0.07616178f, 0.12673563f, 0.01684265f, 
    0.20540684f, 0.02066028f, 0.34205011f, 0.27821857f, -0.01764676f, 0.14605989f, 0.07967760f, -0.08421483f, 
    -0.06147083f, 0.05428049f, 0.20991082f, -0.14031562f, 0.16253330f, 0.33660892f, 0.28236002f, 0.22507966f, 
    -0.00080985f, 0.02758743f, 0.11460220f, -0.07391846f, 0.09486005f, -0.02237167f, 0.09081169f, 0.19652694f, 
    -0.12053901f, 0.11956517f, -0.12701388f, -0.09925027f, 0.00479689f, 0.06918389f, 0.16559167f, 0.03031975f, 
    -0.09828418f, -0.01693380f, -0.03483974f, -0.05856520f, -0.26295841f, -0.17871751f, -0.21939485f, -0.17470486f, 
    0.00693463f, 0.02903970f, 0.03630077f, 0.02592616f, 0.05955250f, 0.08798204f, -0.06105949f, 0.08254147f, 
    -0.13998841f, -0.18410237f, 0.02102059f, -0.22161382f, -0.11982668f, -0.13734521f, -0.01314314f, 0.08958680f, 
    0.01548351f, 0.00059864f, 0.04106597f, 0.04121782f, 0.25490749f, -0.06406410f, 0.11657358f, 0.15935211f, 
    0.03287863f, 0.01225675f, 0.09367960f, -0.07348798f, -0.01881318f, 0.15222789f, -0.11946363f, 0.01447414f, 
    -0.09525116f, -0.03783667f, -0.14533363f, -0.14541271f, 0.14851223f, 0.06206471f, 0.05948215f, -0.05495497f, 
    0.05249792f, 0.22897866f, 0.15557528f, 0.18424667f, -0.10024036f, 0.03051375f, 0.15390106f, 0.01527249f, 
    -0.10639570f, -0.02432326f, 0.00123333f, -0.02336889f, -0.11448092f, 0.03278491f, 0.05237237f, -0.03716381f, 
    0.24084695f, 0.43089941f, 0.00004943f, 0.05880293f, -0.01984886f, 0.14441949f, -0.25239453f, -0.07044729f, 
    0.01604093f, -0.12978074f, 0.19253924f, -0.01627404f, 0.22674802f, 0.36595657f, 0.04747386f, 0.16595712f, 
    -0.00910554f, -0.17197821f, -0.05904256f, 0.00419701f, -0.02792503f, -0.03294375f, -0.08450597f, -0.01441272f, 
    0.38857919f, -0.08215242f, -0.03861736f, 0.01697999f, 0.01207452f, 0.08393101f, 0.08139516f, -0.03793967f, 
    0.06979261f, 0.01906556f, -0.01128919f, -0.07091883f, -0.05496638f, -0.15901724f, -0.04740344f, -0.09627986f, 
    0.04012065f, -0.12431678f, 0.06539475f, 0.13499849f, 0.23138201f, -0.05842387f, 0.06445469f, 0.11329639f, 
    0.06364644f, 0.08436077f, 0.18707725f, -0.11667995f, 0.02373403f, 0.24755324f, -0.13537571f, 0.05876457f, 
    -0.01014917f, -0.01753567f, 0.10412245f, 0.08560147f, -0.06677899f, 0.24729793f, -0.20954873f, -0.34260368f, 
    -0.16432005f, -0.24896368f, -0.22380307f, -0.08379297f, -0.07465863f, -0.01356079f, 0.11751775f, 0.04140764f, 
    -0.21712288f, 0.17554633f, 0.02451094f, 0.22296806f, 0.04029220f, -0.10858026f, 0.04615380f, 0.12157141f, 
    0.19670416f, 0.07691496f, -0.10045085f, -0.03726719f, -0.31437367f, -0.03967736f, -0.12422600f, -0.19981603f, 
    -0.04865403f, 0.06332761f, -0.09854753f, 0.04515014f, -0.00869369f, -0.20815963f, -0.04452581f, -0.03906167f, 
    0.23897904f, 0.10000191f, 0.36651197f, 0.08172444f, 0.18354574f, 0.04276129f, 0.23008300f, 0.04878487f, 
    -0.02869718f, -0.14399894f, 0.06858633f, 0.01852812f, 0.33327326f, 0.24279961f, 0.40463001f, 0.08206723f, 
    0.11881871f, 0.01922356f, 0.14159805f, 0.03564262f, 0.17684022f, -0.04073088f, -0.05163990f, -0.02487224f, 
    0.02018201f, 0.10498381f, -0.02698604f, 0.13977411f, 0.07740163f, 0.03491256f, 0.01948875f, 0.02379399f, 
    -0.13428694f, 0.03494111f, -0.00291193f, -0.04311590f, -0.44125742f, -0.24663042f, -0.20493750f, 0.02055176f, 
    0.12836540f, -0.13731799f, 0.04775864f, 0.06697460f, -0.14212202f, -0.13713746f, -0.07142735f, 0.09793104f, 
    -0.34031150f, -0.49583477f, -0.32714713f, -0.41839683f, -0.01159035f, -0.01464545f, -0.03824548f, 0.02492083f, 
    0.06122459f, 0.11097024f, -0.00842731f, -0.00473693f, -0.11989744f, 0.14333950f, 0.00572282f, 0.15318586f, 
    0.18584158f, 0.04131101f, 0.03306963f, -0.12727392f, -0.07996970f, 0.20380461f, -0.07816470f, -0.10253580f, 
    -0.14575994f, -0.12534901f, -0.19702546f, -0.10401152f, 0.09855197f, -0.10455714f, 0.09611273f, 0.09986612f, 
    -0.11995192f, -0.16196929f, -0.05749764f, -0.00139452f, -0.06888140f, 0.03301940f, 0.31557518f, 0.11984341f, 
    -0.00151692f, -0.02621941f, 0.15036555f, 0.08103599f, 0.09359807f, -0.03694271f, -0.00036487f, -0.04363745f, 
    0.17063157f, 0.05976519f, -0.36796254f, -0.05125746f, 0.03932880f, 0.03795095f, -0.14007750f, -0.01960422f, 
    0.17898750f, 0.10605240f, -0.06515142f, -0.10584757f, 0.21806332f, 0.20367911f, 0.26001263f, 0.29770717f, 
    0.12398142f, -0.20192197f, -0.10900892f, -0.05065676f, 0.22622098f, 0.05575905f, 0.16770524f, 0.04673519f, 
    0.49380648f, 0.00627191f, 0.16486575f, 0.16526954f, -0.02453604f, 0.08219892f, 0.08332947f, -0.09518281f, 
    0.04039837f, -0.09804112f, 0.00338849f, 0.14577065f, -0.31201199f, -0.04367797f, -0.26908460f, -0.08342347f, 
    -0.17907126f, -0.42940429f, 0.07868133f, -0.12156697f, 0.06733705f, 0.02345490f, -0.04116470f, 0.13480601f, 
    -0.12486091f, 0.30176052f, 0.12040981f, 0.05409038f, -0.07662586f, 0.14200710f, -0.10607679f, 0.00339685f, 
    -0.10893638f, -0.00059266f, -0.06162129f, 0.00870609f, -0.21918970f, -0.23517065f, -0.33281973f, -0.15184800f, 
    0.04999572f, -0.12329309f, -0.19769582f, 0.10830148f, -0.02490453f, 0.04563622f, 0.18574929f, 0.01263850f, 
    0.06387080f, -0.07268770f, 0.02817949f, -0.06932724f, -0.04816215f, 0.01474550f, 0.01046469f, -0.07521522f, 
    -0.05521804f, -0.04682180f, -0.01157876f, -0.00383450f, 0.00247567f, 0.05674954f, -0.07018055f, -0.08550432f, 
    -0.05357504f, -0.05190779f, -0.05906283f, -0.03194344f, -0.06464798f, -0.02161231f, 0.04310135f, -0.04078956f, 
    -0.02913611f, -0.06830686f, -0.00796852f, -0.00287037f, -0.00456432f, -0.01326654f, 0.02910171f, -0.00848172f, 
    0.05448565f, -0.04769303f, -0.06966743f, 0.03595777f, -0.07294752f, -0.08487538f, 0.02253584f, 0.02782755f, 
    0.00970043f, -0.00435489f, -0.02716905f, -0.05927281f, 0.01193883f, -0.01669286f, -0.08280193f, -0.05405650f, 
    0.06152219f, -0.03132027f, 0.02241177f, 0.03887554f, 0.01462188f, -0.05647730f, 0.03026637f, 0.04178209f, 
    -0.02603965f, -0.03750119f, -0.07134591f, 0.05060143f, 0.04274690f, 0.05387433f, -0.01727085f, -0.07493176f, 
    -0.04438219f, -0.04316662f, 0.03390009f, -0.05601741f, 0.01885022f, -0.04474764f, -0.06738999f, -0.05635784f, 
    0.00270697f, 0.01361128f, -0.01846517f, 0.00303685f, 0.04067236f, 0.04935026f, 0.05792569f, 0.03254542f, 
    -0.03741230f, 0.05643393f, 0.01940507f, -0.07522679f, 0.01381517f, -0.03953855f, -0.02015133f, -0.02837034f, 
    0.03408174f, 0.02268143f, -0.03359425f, -0.02847959f, -0.01890064f, -0.04386557f, 0.00552761f, -0.07165559f, 
    -0.03875271f, -0.08073387f, -0.00209101f, 0.05410366f, -0.05070115f, 0.03447841f, 0.01220610f, -0.06209594f, 
    0.03797413f, 0.05031342f, -0.02918982f, 0.05799438f, -0.04288318f, 0.00465306f, 0.02425739f, -0.02545673f, 
    0.05498782f, 0.05095333f, -0.02167968f, -0.03021783f, -0.02975919f, 0.06130901f, 0.02327582f, 0.01130093f, 
    -0.03053224f, -0.01535160f, 0.04340458f, 0.04781107f, -0.05520633f, -0.01779828f, -0.05207616f, -0.05561316f, 
    -0.05953219f, -0.04539512f, 0.05339125f, 0.00234864f, -0.01778879f, 0.02663163f, -0.02537942f, 0.02116392f, 
    0.02457445f, 0.01684555f, -0.02487429f, 0.06311191f, -0.07526132f, 0.00667190f, 0.01108514f, -0.07495474f, 
    0.00788402f, -0.03078009f, -0.07222094f, 0.00236200f, 0.03295530f, -0.00098103f, 0.02909455f, -0.03765438f, 
    0.00417464f, 0.02697026f, -0.02488262f, -0.04579151f, 0.02255651f, 0.02561646f, 0.04004184f, 0.04567409f, 
    0.03322113f, 0.03588307f, 0.00750109f, -0.05643588f, 0.01366290f, -0.06230482f, 0.01577611f, -0.05753845f, 
    0.01786461f, 0.00089671f, 0.04543488f, 0.03064512f, -0.04256397f, 0.01030061f, -0.01605888f, 0.04476845f, 
    -0.01430524f, -0.01518050f, -0.07135959f, 0.05093779f, 0.01314663f, -0.05792911f, -0.03825054f, 0.02021387f, 
    -0.05744690f, 0.01532093f, -0.04373996f, 0.03504482f, -0.02486669f, -0.07339425f, -0.00687872f, 0.04685497f, 
    0.14510767f, 0.49729329f, -0.14807141f, -0.02718060f, -0.10012791f, 0.00701614f, 0.06915762f, 0.20622692f, 
    -0.11065262f, -0.09740601f, -0.00805463f, 0.00062452f, -0.17464218f, -0.05930214f, -0.06786047f, -0.12354678f, 
    -0.11427955f, 0.00034004f, -0.10404697f, 0.07298360f, 0.24575062f, -0.01197795f, 0.02350943f, -0.00786396f, 
    0.18398675f, -0.03067456f, -0.04176684f, 0.17806150f, 0.09094920f, 0.09675602f, 0.11171169f, -0.03760349f, 
    0.00692192f, -0.07778080f, -0.02695152f, 0.05346684f, 0.12695244f, 0.21641324f, -0.04158867f, -0.07448683f, 
    0.15384558f, 0.09399277f, 0.03010130f, 0.06669862f, 0.01623982f, 0.05471142f, -0.07278872f, 0.15321906f, 
    -0.13265435f, 0.34105456f, -0.13961458f, -0.14123116f, -0.01181990f, 0.16318668f, 0.12794927f, 0.08318155f, 
    -0.08996895f, 0.02503270f, -0.06399505f, 0.07324225f, -0.08528585f, 0.28146303f, -0.06604949f, -0.16204570f, 
    0.01549512f, 0.01239942f, -0.06407004f, 0.12265063f, 0.00359941f, -0.05000338f, 0.04770859f, 0.18554775f, 
    -0.40109268f, -0.19053218f, -0.04114925f, -0.21213959f, -0.04159043f, -0.03458566f, -0.01812225f, 0.01226271f, 
    -0.08679685f, 0.00888833f, 0.08252028f, -0.00964168f, 0.34439805f, -0.38182727f, 0.09283432f, 0.04535439f, 
    -0.05953246f, -0.06369505f, 0.02687998f, -0.02034066f, -0.14894071f, 0.02133622f, 0.10512107f, 0.21153013f, 
    -0.06662343f, -0.05443212f, -0.04597065f, -0.13571404f, -0.01936031f, -0.23528816f, -0.12388673f, -0.05052865f, 
    -0.07310779f, 0.16804321f, 0.07469903f, 0.07190296f, 0.04394178f, -0.04673979f, -0.16129149f, -0.03021769f, 
    0.02676220f, 0.01494557f, -0.01785339f, 0.07847347f, 0.06509478f, 0.01899933f, 0.04708609f, 0.03918077f, 
    0.42628622f, 0.17557874f, 0.13811119f, -0.01752234f, 0.02072116f, 0.10969336f, -0.00655473f, 0.09817033f, 
    0.04586237f, -0.08615260f, 0.10042392f, 0.13375716f, 0.17851643f, 0.14609542f, -0.00662087f, 0.04997128f, 
    0.16128963f, 0.05829052f, 0.02618480f, -0.00634969f, 0.05741676f, -0.05946630f, -0.10147265f, -0.01780278f, 
    0.00806784f, -0.12137995f, -0.05430367f, 0.29495111f, 0.18460715f, 0.08998153f, 0.06522133f, -0.09798665f, 
    -0.11293238f, 0.06731233f, -0.07665455f, 0.04446967f, -0.06814404f, 0.14773411f, -0.14197031f, -0.08173987f, 
    -0.07783057f, -0.04124054f, -0.10726841f, -0.08404047f, 0.02940050f, 0.05243453f, 0.00957050f, 0.02771635f, 
    0.02587811f, -0.06599402f, 0.09645521f, 0.18532883f, -0.07485761f, 0.25522327f, 0.02777742f, -0.09237109f, 
    0.00811311f, 0.09582462f, 0.32070348f, 0.08800807f, -0.42036870f, -0.28109479f, 0.00180542f, -0.07797525f, 
    0.06657198f, -0.00112836f, -0.21167281f, -0.17556907f, 0.02947456f, 0.03614815f, -0.02863291f, 0.00171696f, 
    -0.03263604f, 0.02117379f, -0.05747708f, -0.02895387f, -0.07450972f, -0.07752258f, 0.03896236f, 0.01007540f, 
    -0.06902345f, -0.04051312f, -0.03123885f, -0.04322493f, 0.00793280f, -0.02264288f, -0.06769743f, 0.03385705f, 
    -0.04073890f, 0.02480877f, -0.07263876f, 0.02782304f, -0.06385543f, -0.07906272f, 0.03287384f, -0.00608293f, 
    0.02892171f, -0.01506294f, 0.04091291f, -0.01956738f, 0.00112963f, -0.06079581f, -0.00730481f, -0.03143064f, 
    0.05980853f, -0.08141119f, -0.01060194f, 0.00913725f, 0.05840054f, -0.03525574f, -0.00510881f, -0.01469078f, 
    -0.03692913f, 0.03417436f, -0.01619407f, 0.05274032f, -0.07885114f, 0.02099740f, -0.08060979f, -0.07364773f, 
    -0.03604808f, -0.03758236f, -0.02362054f, 0.03960786f, 0.03813853f, -0.02544611f, -0.06708991f, -0.01493962f, 
    -0.04814237f, -0.05459275f, 0.00844660f, -0.01646651f, 0.02188725f, -0.04106624f, -0.07902590f, 0.05284296f, 
    0.02417994f, 0.06114964f, -0.01343086f, 0.00976212f, 0.03069313f, -0.07792113f, -0.06822746f, -0.07080562f, 
    -0.06693626f, -0.03776337f, -0.06043046f, 0.04323985f, -0.04259902f, 0.01087786f, -0.00157854f, 0.00786397f, 
    0.02406850f, -0.06915957f, -0.03801810f, -0.00931313f, 0.00075019f, -0.02954913f, -0.02118986f, 0.02920132f, 
    -0.08192778f, -0.02442903f, -0.00617115f, 0.02600530f, 0.03204529f, -0.04753973f, 0.03019898f, 0.01892607f, 
    0.02083107f, 0.03522528f, 0.04763345f, 0.01520057f, -0.06307677f, -0.01214586f, 0.06292252f, -0.03723283f, 
    0.01445230f, 0.05885806f, -0.03182865f, -0.07246941f, -0.02603453f, 0.02835191f, 0.03173913f, 0.02985935f, 
    -0.02662950f, 0.01165990f, 0.07130222f, -0.02240260f, 0.02930309f, -0.06279922f, -0.00098843f, -0.06101253f, 
    -0.08204093f, 0.05249724f, -0.04675820f, -0.03459570f, 0.00732337f, 0.05069781f, 0.03640049f, 0.04426087f, 
    0.05415946f, -0.07951419f, 0.03477757f, 0.03770955f, -0.01918442f, -0.03370574f, 0.02634923f, -0.08397345f, 
    -0.05926042f, -0.00683738f, 0.05426710f, -0.04172083f, -0.01138402f, -0.06395859f, -0.01780022f, 0.04308548f, 
    0.00111212f, -0.06747877f, -0.06495538f, -0.01950097f, -0.00615878f, 0.04202196f, 0.05095214f, 0.04058368f, 
    0.02593273f, -0.02246642f, -0.02295585f, -0.04179632f, -0.00171092f, 0.03620680f, -0.05431849f, -0.00686097f, 
    -0.02382890f, 0.00658729f, 0.04255091f, 0.04653428f, -0.06262478f, -0.00460412f, 0.00166655f, -0.07934888f, 
    -0.08527696f, 0.01522961f, 0.01657439f, -0.06231543f, 0.04173036f, -0.00316196f, 0.00062606f, -0.02247516f, 
    0.03768307f, 0.00592725f, 0.05095442f, 0.03647700f, -0.01686507f, -0.01401885f, -0.05173296f, -0.07822311f, 
    0.04724853f, -0.02148904f, 0.05376861f, 0.02302562f, -0.03630860f, -0.07427107f, 0.04361948f, -0.03559627f, 
    0.04802695f, 0.06765155f, 0.00668072f, 0.07556907f, -0.01674069f, 0.06336334f, 0.01371752f, 0.00041799f, 
    0.01955272f, 0.03514447f, 0.00755454f, 0.01059068f, -0.03813268f, 0.02847426f, -0.02308296f, -0.03882255f, 
    -0.04997049f, 0.00470655f, 0.00716272f, 0.00930060f, 0.06029049f, 0.04147637f, 0.03471881f, -0.06813931f, 
    -0.06955344f, -0.05537265f, 0.01951918f, 0.04662199f, -0.07347275f, -0.02524615f, -0.00087620f, -0.01163344f, 
    -0.08414281f, 0.00378746f, -0.03361908f, 0.05620603f, 0.01032091f, 0.01051229f, -0.05837395f, -0.01345703f, 
    0.05906582f, -0.06360531f, 0.03866999f, -0.04088680f, 0.00578593f, 0.00421724f, 0.03878397f, -0.05108175f, 
    -0.02419915f, 0.02906677f, -0.06236396f, 0.04962027f, 0.02387237f, -0.01820017f, -0.01741245f, -0.01270734f, 
    -0.08408102f, -0.06562044f, 0.01688378f, -0.05098770f, 0.01382202f, -0.02904798f, -0.02528996f, -0.03342088f, 
    -0.06945928f, 0.05115856f, -0.00496284f, -0.07025521f, 0.00243860f, 0.05775350f, -0.02738770f, -0.06682827f, 
    0.04163915f, 0.03275602f, 0.02423880f, -0.01091882f, -0.05590574f, -0.03459169f, -0.06238243f, 0.02596197f, 
    0.04186144f, 0.04330160f, -0.05040302f, 0.00447813f, 0.03928195f, -0.07313945f, -0.06774371f, 0.03276409f, 
    -0.03836693f, 0.01572805f, -0.02296704f, 0.04141906f, 0.02050141f, -0.05695941f, -0.00801408f, 0.00499353f, 
    0.02709512f, 0.03026931f, 0.05017323f, -0.03603272f, 0.03259372f, 0.05116565f, -0.04052606f, -0.07585869f, 
    -0.04050514f, -0.07516058f, 0.03030700f, -0.00522199f, -0.06445248f, 0.07433949f, -0.05139377f, 0.00314164f, 
    -0.01502066f, 0.04969331f, -0.00435330f, -0.06784406f, 0.03297265f, 0.01180835f, -0.06248118f, -0.07333851f, 
    -0.05675079f, 0.04852927f, 0.00703083f, -0.05844914f, -0.01998582f, -0.01850960f, -0.05434898f, -0.02291217f, 
    -0.02536443f, -0.04137303f, -0.02380017f, 0.00237823f, -0.06792775f, 0.00361921f, 0.04345643f, 0.03404432f, 
    0.06069594f, -0.05817914f, -0.07809076f, 0.02984338f, -0.08591017f, -0.00367901f, -0.01276316f, 0.02234120f, 
    0.08118144f, 0.02603604f, -0.01225430f, -0.06467607f, -0.01563960f, -0.07095294f, -0.07724412f, -0.01648486f, 
    0.00673040f, 0.00281950f, -0.05463233f, 0.01294405f, -0.05834352f, 0.02260019f, 0.05082833f, -0.02477034f, 
    -0.00111561f, 0.02968175f, -0.00333490f, -0.04569213f, -0.05435101f, 0.02994064f, -0.00611770f, 0.01778782f, 
    0.00015008f, -0.07989771f, 0.03211091f, -0.00778745f, 0.01203123f, 0.02621262f, 0.02757860f, 0.01192265f, 
    -0.07044116f, 0.04938200f, 0.08003942f, 0.01237472f, 0.01913684f, 0.00607738f, -0.06407092f, -0.02199681f, 
    0.05954438f, 0.06380391f, -0.05597554f, -0.01669275f, -0.09262449f, 0.04331816f, 0.00428507f, 0.04514118f, 
    0.06007436f, 0.00588108f, 0.01770559f, 0.01047746f, -0.04266328f, -0.05727008f, 0.05429785f, 0.08925048f, 
    0.00150076f, 0.03526959f, -0.03761486f, -0.00114605f, 0.02607085f, -0.04627041f, 0.01007793f, -0.01213524f, 
    0.00283473f, -0.01326940f, -0.06733114f, -0.05998220f, -0.00676707f, 0.01408321f, 0.03694834f, -0.05265571f, 
    -0.00396806f, 0.01506038f, 0.04241915f, -0.04120224f, 0.05932659f, -0.07662130f, -0.07456648f, 0.00102530f, 
    0.05112455f, 0.03457268f, -0.05856975f, -0.02962049f, 0.00973376f, -0.05823462f, 0.05457722f, 0.00123023f, 
    -0.06993167f, 0.05479696f, -0.06013658f, 0.03561049f, -0.05579157f, 0.00288915f, 0.00456719f, -0.04047870f, 
    0.05204348f, 0.02502836f, -0.01250528f, -0.10469719f, 0.01889300f, 0.02490015f, -0.02273983f, -0.11810531f, 
    0.04004475f, 0.05308190f, 0.07349466f, -0.03757986f, 0.04725360f, -0.02659862f, -0.04912680f, -0.05930831f, 
    -0.00827780f, -0.10212848f, -0.01967986f, -0.06873231f, -0.04910899f, -0.01119529f, -0.03220712f, -0.06193092f, 
    0.05660161f, 0.08278282f, 0.06000531f, -0.06678427f, -0.07394946f, -0.10500620f, -0.06547786f, -0.04972538f, 
    -0.09875137f, -0.11435241f, -0.02873634f, -0.00335638f, -0.00613122f, 0.08188628f, -0.02893876f, 0.00569358f, 
    -0.04515791f, 0.02976213f, 0.01700321f, 0.01960188f, -0.04743659f, -0.00363878f, -0.02903580f, -0.09588563f, 
    0.00273942f, 0.03456846f, -0.08587941f, -0.06745312f, -0.08590959f, 0.01489085f, -0.05694059f, -0.07705308f, 
    -0.11424035f, -0.03761156f, -0.08090397f, -0.02185243f, -0.06143907f, -0.02516249f, -0.04403999f, -0.03387508f, 
    -0.05200773f, -0.04834632f, 0.03705402f, 0.01147926f, -0.03825413f, -0.00015811f, -0.02949294f, 0.01619997f, 
    -0.00223707f, -0.02609802f, -0.04023859f, 0.05989134f, 0.01598868f, -0.03650041f, -0.02243522f, -0.02665407f, 
    0.07396702f, -0.05906333f, 0.00732520f, -0.07590281f, -0.02500248f, -0.10478930f, -0.05428571f, -0.01534128f, 
    -0.02508274f, 0.03838109f, -0.06011745f, -0.01002822f, 0.06504345f, -0.04061372f, -0.04276495f, -0.00087394f, 
    -0.00295327f, -0.06101230f, -0.06583934f, -0.03780690f, -0.02320936f, -0.05791380f, 0.00504031f, -0.07456407f, 
    0.02856953f, 0.06547732f, 0.00300179f, 0.07603506f, -0.02252679f, 0.06577409f, -0.04983860f, -0.06135547f, 
    -0.01912317f, -0.02413648f, -0.04071933f, 0.04959523f, 0.02589373f, -0.04186912f, 0.02005966f, -0.05842425f, 
    -0.03125164f, 0.06636815f, 0.04541234f, -0.00384081f, 0.02476453f, 0.04383267f, -0.07241026f, -0.05421480f, 
    -0.08845852f, -0.02844824f, -0.05205936f, -0.07727414f, -0.03371518f, 0.04020995f, 0.00838904f, -0.05115438f, 
    0.03323843f, 0.04545159f, -0.03732092f, -0.08194470f, -0.00275259f, -0.11282700f, 0.00517495f, 0.00984826f, 
    -0.23857014f, 0.25748220f, -0.14036807f, 0.14527191f, 0.04193230f, 0.01037025f, 0.00219583f, 0.04900907f, 
    0.03818342f, 0.03967330f, -0.05149185f, 0.04191055f, 0.19508895f, 0.07633672f, -0.18816972f, -0.03978085f, 
    -0.02995525f, -0.04710047f, -0.14074430f, -0.07637589f, 0.15278737f, -0.04478450f, 0.13200121f, -0.00515313f, 
    -0.00597650f, -0.22811493f, 0.27397740f, 0.10359263f, 0.00676390f, 0.07598615f, 0.06559420f, 0.16430365f, 
    0.07800355f, -0.02794741f, 0.15654792f, 0.01404209f, -0.22073391f, 0.01205610f, -0.08094081f, 0.19605981f, 
    0.15644699f, 0.13226311f, -0.04164731f, 0.20651814f, 0.04660922f, -0.00568097f, 0.15168354f, 0.06728448f, 
    0.08712798f, 0.20630814f, -0.24794953f, 0.12108237f, -0.03054716f, -0.08565255f, 0.00570886f, -0.10793865f, 
    -0.06742154f, 0.01006084f, 0.18322913f, 0.06166250f, -0.02112697f, 0.49106205f, -0.12678081f, 0.19017908f, 
    -0.08739378f, -0.02461933f, -0.07640360f, 0.06836336f, 0.09918293f, 0.09239674f, 0.10448403f, 0.00336259f, 
    -0.10871755f, 0.14526665f, 0.26437297f, -0.06448109f, -0.11696763f, -0.08252247f, -0.06400221f, 0.04067369f, 
    -0.01824407f, 0.01062952f, -0.10849679f, 0.03303562f, 0.36918378f, 0.22072437f, 0.14218050f, 0.02298680f, 
    0.02916659f, 0.02956046f, 0.00346824f, -0.05342360f, 0.14530566f, -0.02302932f, 0.06520878f, 0.14036569f, 
    -0.12967709f, -0.05411883f, -0.14935941f, -0.16510613f, -0.02731666f, -0.04087458f, -0.10544497f, -0.06484987f, 
    -0.01247430f, -0.09534267f, 0.07426903f, 0.04284486f, -0.30713078f, -0.15061638f, -0.13121894f, 0.14048940f, 
    -0.10711738f, 0.09213336f, -0.09880657f, 0.07314076f, 0.01343503f, -0.08869826f, 0.02312626f, 0.06911700f, 
    0.07696197f, 0.06927308f, -0.11846435f, 0.20612356f, 0.14094180f, 0.15067135f, -0.09277221f, 0.19522581f, 
    0.00241035f, -0.06300900f, 0.13244803f, 0.04647303f, 0.00022560f, -0.02870110f, -0.11900622f, 0.04757174f, 
    0.16813789f, -0.12978695f, 0.08694312f, -0.09802701f, 0.09334293f, 0.04229866f, -0.00690100f, -0.04454569f, 
    -0.16067992f, -0.06780916f, 0.28539953f, 0.00487742f, -0.10481858f, 0.04043487f, 0.04615142f, 0.06762229f, 
    0.08645635f, 0.00870424f, -0.13058014f, -0.04375438f, -0.13095900f, -0.01456413f, -0.18358101f, 0.05400256f, 
    -0.11015818f, 0.17882228f, 0.02842391f, -0.00943328f, 0.11666045f, -0.10323588f, -0.05901394f, -0.03952375f, 
    -0.44747314f, -0.07094706f, 0.21135594f, 0.03191730f, -0.05815472f, 0.09727208f, -0.09080770f, 0.22792377f, 
    0.08484522f, 0.10180876f, 0.06012900f, 0.05852742f, 0.05641265f, 0.19609679f, 0.07227374f, -0.25247157f, 
    -0.04596486f, -0.01248870f, -0.26697913f, 0.05536529f, 0.04930826f, 0.04113851f, -0.07099020f, 0.01799463f, 
    0.03974551f, 0.02025758f, 0.06283858f, 0.03550387f, 0.01758763f, 0.02219201f, 0.01992222f, 0.01991379f, 
    -0.00988164f, -0.02987093f, -0.05885182f, 0.04276236f, -0.01024146f, -0.05881843f, -0.01227658f, 0.02066000f, 
    0.01430761f, -0.02913406f, -0.07526163f, -0.06686672f, -0.06551131f, 0.00056693f, 0.04328617f, -0.02330135f, 
    0.05403242f, 0.01447460f, -0.02825246f, 0.00865455f, -0.00284391f, -0.06453389f, 0.03426287f, 0.04073627f, 
    0.05058024f, 0.06098237f, 0.00807056f, -0.07494331f, -0.00299602f, -0.07030593f, 0.01532670f, 0.02185933f, 
    -0.02277590f, 0.05773290f, 0.02579737f, -0.00572649f, -0.00949322f, 0.05175152f, 0.06289623f, 0.01956119f, 
    -0.01617068f, -0.00189537f, -0.02990077f, -0.02986437f, 0.03998176f, 0.01824170f, -0.06024005f, 0.02955260f, 
    -0.06878575f, -0.01095737f, -0.03204526f, 0.03281407f, -0.02742557f, 0.01008005f, -0.03622025f, -0.01850244f, 
    -0.06225222f, -0.04744346f, -0.04206733f, 0.05554178f, 0.05895231f, 0.00771223f, 0.05595504f, -0.02584910f, 
    0.02819612f, 0.03314910f, 0.00753090f, -0.02771196f, -0.01990895f, 0.02501672f, -0.01544128f, -0.01687942f, 
    -0.01348822f, -0.04681301f, 0.05813348f, -0.06040745f, -0.03461002f, -0.02812771f, 0.00014694f, -0.06994494f, 
    0.02896379f, -0.06764229f, 0.01824836f, -0.00208386f, -0.00220051f, 0.05093896f, 0.05829766f, 0.02948561f, 
    -0.04701597f, -0.00500110f, -0.00444053f, -0.07751241f, -0.02673900f, -0.05701623f, -0.06140653f, 0.06061429f, 
    0.02394645f, -0.03277249f, 0.04863473f, -0.04283494f, -0.02577913f, -0.01988144f, -0.02141854f, -0.02402137f, 
    0.04292677f, -0.04212633f, -0.07397886f, -0.01409109f, -0.00757266f, -0.06233004f, -0.06572880f, 0.00274160f, 
    0.01275838f, 0.06122705f, -0.05468222f, -0.00873521f, 0.05504543f, -0.00878777f, 0.05936358f, -0.05257245f, 
    -0.07771968f, 0.02561550f, -0.04827463f, -0.03659355f, 0.04909463f, 0.03915862f, 0.00608251f, -0.00402286f, 
    -0.00839109f, 0.02878894f, -0.04437620f, 0.00417220f, -0.06956694f, -0.02862313f, -0.01123615f, 0.02373642f, 
    0.04052332f, -0.04803931f, -0.06848942f, -0.00316753f, -0.05742854f, 0.05341559f, -0.00842319f, -0.02402790f, 
    -0.03359087f, -0.01288561f, 0.01219978f, -0.05695414f, -0.02256311f, -0.06059564f, 0.05487056f, -0.06650316f, 
    -0.04453671f, -0.07622333f, 0.01574262f, -0.04336623f, -0.02275654f, 0.05141097f, -0.02558862f, 0.05604466f, 
    -0.01456349f, -0.06162369f, -0.00706254f, 0.02916568f, -0.01849137f, 0.00142497f, -0.02082843f, 0.02957012f, 
    -0.06403939f, 0.01538773f, 0.02013136f, -0.06915152f, -0.06459593f, -0.01620374f, 0.03913796f, 0.02936664f, 
    0.01515139f, -0.04467253f, -0.01105726f, -0.05514801f, 0.02053121f, -0.00044509f, 0.04209834f, -0.06440814f, 
    0.15294367f, -0.05762677f, -0.00073600f, 0.06529608f, -0.01275969f, 0.00402254f, -0.03711082f, 0.04041684f, 
    0.06427870f, 0.30591190f, 0.14352974f, 0.17811209f, -0.04620207f, -0.21202315f, -0.08234849f, -0.25282437f, 
    -0.14612161f, -0.17901115f, 0.19875647f, 0.15756789f, 0.04508690f, 0.00109481f, 0.04804739f, -0.10674860f, 
    -0.00428447f, -0.11876810f, 0.13408613f, 0.25547460f, -0.01175079f, -0.09014712f, -0.02195116f, 0.16128841f, 
    -0.15632398f, -0.09231880f, -0.02913440f, -0.05608771f, 0.19193135f, -0.01916606f, 0.05690493f, 0.02875606f, 
    0.03331173f, -0.11396220f, 0.03244724f, -0.00015806f, -0.28916797f, -0.18736809f, 0.10802449f, -0.06628555f, 
    0.21284647f, 0.44025934f, 0.13627063f, 0.26564881f, -0.04883988f, 0.02784143f, -0.19317040f, -0.03947246f, 
    0.08969112f, 0.06221765f, 0.07404478f, 0.05265474f, -0.11601695f, 0.11025713f, -0.13517338f, -0.00506283f, 
    -0.14872046f, -0.18734176f, -0.06873803f, -0.09041672f, -0.17290059f, 0.08750625f, 0.18350311f, 0.15435600f, 
    0.02296916f, 0.00464877f, 0.15305674f, -0.06667560f, 0.06230452f, 0.09644362f, 0.06084101f, -0.06578089f, 
    0.01560539f, -0.13084196f, 0.04214284f, -0.03651373f, 0.04153612f, 0.09194934f, 0.12448023f, -0.12206046f, 
    0.04445154f, 0.04768862f, -0.03009798f, 0.08910149f, -0.11141551f, 0.00770573f, 0.20546570f, -0.15563394f, 
    -0.17016262f, 0.00771299f, -0.03201872f, -0.25761488f, 0.06582201f, 0.09445485f, 0.04028657f, -0.01694478f, 
    -0.14910997f, -0.38579264f, -0.28406313f, -0.19881444f, 0.00179146f, -0.13754573f, 0.04835484f, -0.08688996f, 
    -0.06740016f, -0.11378402f, -0.00140754f, 0.26802933f, -0.04943570f, 0.01791219f, -0.05044154f, -0.17966090f, 
    0.01570166f, -0.04896387f, -0.20470145f, 0.03913048f, 0.03704802f, 0.04539031f, 0.07888239f, -0.14851889f, 
    0.02219940f, 0.13536972f, -0.23194736f, -0.09025351f, 0.17420121f, -0.12043891f, -0.01376458f, 0.35910892f, 
    -0.00035263f, 0.12937318f, -0.07724000f, 0.00603707f, 0.09300746f, 0.14767219f, 0.33291879f, 0.30120674f, 
    -0.22376639f, 0.29117253f, 0.23946650f, 0.27370059f, -0.10469896f, 0.08474495f, 0.00307312f, -0.08188025f, 
    -0.09241211f, 0.06440093f, 0.16850577f, 0.26082519f, -0.14962484f, 0.12295895f, -0.11478506f, -0.13293496f, 
    -0.05573441f, 0.08078469f, 0.04257562f, 0.08285689f, 0.10635312f, 0.18246984f, -0.00907832f, -0.11306507f, 
    -0.09846395f, 0.13140158f, 0.04561017f, 0.08014154f, 0.06659161f, 0.07144738f, -0.05626591f, -0.01730370f, 
    -0.31784117f, -0.20311125f, -0.16237924f, -0.31315321f, 0.16848636f, 0.23949035f, 0.01283773f, 0.10216846f, 
    0.05622526f, 0.04273977f, 0.07533959f, -0.15644537f, -0.22858408f, -0.13887982f, -0.07391521f, 0.01159110f, 
    0.01858845f, 0.15648857f, -0.12997867f, -0.09389747f, 0.06372037f, -0.12548837f, 0.13604248f, 0.02643779f, 
    0.07220668f, 0.15224876f, -0.01200541f, 0.06670737f, 0.10070698f, 0.12001316f, -0.09126356f, 0.07395257f, 
    0.09986343f, -0.09058309f, 0.03117883f, 0.04653769f, 0.21018608f, -0.06056055f, 0.30888525f, 0.12897374f, 
    -0.18780059f, -0.02008646f, 0.19598864f, -0.20126913f, -0.16798638f, 0.09324304f, 0.01400753f, 0.03630506f, 
    0.08721529f, -0.05362461f, 0.09949362f, -0.19016065f, -0.32197803f, 0.11728718f, -0.03477900f, 0.12711671f, 
    0.06255910f, -0.08539320f, -0.00948877f, 0.09555896f, 0.06396950f, -0.00477004f, 0.07507712f, 0.08227433f, 
    -0.38223249f, -0.33695820f, -0.10189229f, 0.01791610f, -0.04652299f, 0.00070715f, 0.03495345f, 0.08451340f, 
    0.08033422f, 0.02828714f, 0.19320625f, 0.10513647f, 0.10615557f, 0.09670635f, 0.08455835f, -0.04618816f, 
    0.07588206f, -0.13277149f, -0.00171712f, 0.04249163f, 0.10346191f, 0.08088809f, 0.09817699f, 0.09978580f, 
    -0.05809365f, 0.01232172f, 0.05881313f, 0.09334839f, -0.11411142f, -0.06158147f, -0.08462907f, -0.05401110f, 
    -0.04124017f, 0.02879147f, -0.04595343f, 0.08307400f, 0.23797467f, 0.02059658f, 0.17945169f, 0.12758461f, 
    0.12773208f, -0.01889443f, 0.01652969f, 0.00187417f, 0.19884375f, -0.05066437f, -0.07390013f, 0.25389755f, 
    -0.06761618f, -0.00781055f, -0.00123651f, 0.06385866f, 0.09120226f, -0.06073224f, -0.19171029f, 0.03519217f, 
    -0.04393654f, 0.07998616f, 0.06497214f, -0.01409584f, -0.15548700f, -0.01451628f, -0.08461910f, -0.00624199f, 
    0.10732157f, 0.08695359f, -0.03017868f, -0.21581078f, 0.04241548f, -0.08553747f, 0.02039575f, 0.05839001f, 
    0.12504379f, -0.10901402f, 0.19063231f, 0.12925817f, 0.18328416f, -0.04417152f, 0.09629426f, 0.43481410f, 
    -0.18148394f, 0.09198804f, 0.02580086f, 0.08399919f, -0.16121021f, 0.17589372f, 0.00177935f, -0.14876643f, 
    0.02670754f, -0.16581358f, 0.04435944f, 0.08884591f, 0.15063366f, 0.07691105f, -0.04756428f, -0.19028221f, 
    -0.04974405f, -0.02594704f, 0.01792210f, -0.13321561f, 0.02385576f, 0.08526178f, 0.05245426f, -0.09658213f, 
    0.07021257f, 0.09110305f, -0.00559174f, -0.05231271f, 0.09431764f, -0.03884956f, -0.01899999f, 0.05692973f, 
    0.02302079f, -0.08052392f, 0.18485124f, 0.14079098f, 0.10966209f, 0.12285937f, -0.09038989f, -0.05883631f, 
    -0.14402245f, -0.14266203f, -0.14989884f, -0.14199451f, -0.00003654f, 0.05736407f, 0.01733034f, -0.04860036f, 
    0.00893916f, -0.08686396f, -0.14355054f, 0.03807944f, -0.06286552f, 0.08012843f, 0.03501736f, -0.18430124f, 
    0.01451207f, -0.03941238f, -0.22761673f, -0.00218568f, -0.07972375f, -0.01731317f, 0.05101472f, 0.00152409f, 
    -0.21744300f, 0.04959777f, 0.01774846f, -0.07537527f, 0.09851606f, -0.04084897f, 0.09237485f, 0.08263835f, 
    0.05258700f, -0.01870125f, 0.00530036f, 0.10994576f, 0.18725972f, 0.02562340f, -0.18345775f, -0.09550453f, 
    0.12413643f, -0.02012562f, -0.08075224f, 0.02806562f, 0.24606586f, -0.04984827f, 0.27940160f, 0.02955865f, 
    -0.15546544f, 0.12795581f, 0.17513190f, -0.04592003f, 0.07787516f, -0.08035489f, 0.07814609f, 0.02378058f, 
    0.02662647f, -0.05522276f, 0.20096567f, 0.04222540f, -0.13021624f, 0.05891650f, -0.01925191f, -0.02828482f, 
    0.11054917f, -0.01218157f, -0.05578520f, 0.11458489f, 0.09550989f, 0.05872795f, 0.00303957f, -0.01549745f, 
    -0.06538191f, -0.22735605f, -0.11594453f, -0.19272113f, -0.00294319f, 0.12482441f, -0.10773008f, 0.07489569f, 
    -0.00576018f, 0.15526566f, 0.11363308f, 0.01193643f, 0.10740524f, 0.47305575f, -0.16810127f, 0.00927236f, 
    -0.02812226f, -0.05833171f, -0.02140047f, 0.08165802f, 0.01052288f, 0.00544607f, 0.09548461f, 0.15007688f, 
    -0.17641473f, 0.00135305f, 0.04333622f, -0.04083642f, -0.15716326f, -0.13573354f, -0.11510953f, -0.07706305f, 
    -0.03350908f, 0.09252678f, -0.10033466f, 0.01255038f, 0.22221680f, 0.13970968f, 0.04068123f, 0.10392180f, 
    0.02515198f, 0.05110912f, -0.04331558f, -0.08091629f, 0.14586034f, -0.04655831f, -0.05211807f, 0.18264703f, 
    -0.20938496f, -0.15318909f, -0.11706793f, -0.12024125f, -0.08467537f, -0.01751954f, -0.09536470f, -0.05872466f, 
    -0.15286911f, -0.04147333f, 0.02672931f, -0.11336048f, -0.20991288f, -0.13564019f, -0.12153809f, -0.01258046f, 
    -0.03841533f, 0.12415470f, -0.07725746f, -0.14836122f, 0.02336301f, -0.13697492f, 0.00197370f, -0.07484309f, 
    0.23507713f, -0.09896943f, -0.24089526f, 0.13980298f, 0.18007243f, 0.04481123f, 0.07610440f, 0.16115145f, 
    0.07368626f, 0.09432732f, 0.06507179f, -0.03925848f, 0.11109650f, -0.10512763f, -0.06744339f, -0.03722246f, 
    0.14836453f, -0.14748393f, 0.05833103f, -0.00048635f, -0.01307763f, -0.03429762f, -0.00305880f, 0.02106867f, 
    -0.15125887f, -0.05903875f, 0.09314554f, 0.08573931f, -0.00863575f, 0.04299260f, 0.21192361f, 0.07247777f, 
    0.02073653f, 0.08971687f, 0.07601530f, 0.00808359f, 0.09376886f, 0.28946424f, -0.40679798f, 0.13345620f, 
    0.05421381f, 0.05941392f, 0.19743733f, 0.07423397f, 0.17570679f, 0.09754913f, 0.02767907f, -0.05869390f, 
    -0.12958406f, 0.20970139f, -0.06064624f, 0.16072120f, 0.07286315f, -0.09329565f, -0.02427279f, -0.00793617f, 
    0.06563986f, 0.24889563f, -0.02370623f, 0.08550856f, -0.06094059f, 0.08052582f, -0.08730303f, -0.02424086f, 
    0.03633856f, -0.01263575f, -0.16431794f, 0.05284014f, 0.06967411f, 0.00526290f, 0.06399105f, -0.04238520f, 
    -0.13377993f, 0.16686194f, -0.12749524f, 0.17875504f, 0.04619531f, -0.03775554f, 0.02797668f, 0.10382925f, 
    0.09037282f, 0.12519215f, -0.02646219f, 0.05470034f, 0.21975450f, 0.08854649f, -0.06658859f, -0.17167895f, 
    -0.07074784f, -0.04409629f, 0.01035104f, -0.01211004f, 0.20326138f, -0.01053077f, 0.21777628f, 0.06744595f, 
    0.13903664f, -0.09228329f, 0.09862100f, 0.28303075f, 0.08564975f, 0.03505895f, 0.09946434f, 0.09201545f, 
    0.07954308f, -0.02738430f, 0.05578122f, 0.05565193f, -0.13985188f, 0.00201001f, -0.09686650f, 0.06091276f, 
    0.00767201f, 0.06732767f, -0.02687897f, 0.06199016f, 0.08283278f, 0.01580782f, 0.08587466f, 0.11156199f, 
    0.16776899f, 0.33210286f, -0.22696730f, -0.16431327f, 0.04810141f, 0.05422325f, -0.01444030f, -0.08354761f, 
    0.02363287f, 0.01727521f, 0.00786678f, 0.09669962f, -0.02571060f, 0.48211801f, -0.10801020f, -0.07228728f, 
    -0.07886899f, 0.03009643f, -0.10498807f, -0.01565648f, -0.02268331f, 0.05975927f, 0.07568249f, -0.04717299f, 
    -0.13623773f, 0.08228187f, 0.07011390f, -0.12504405f, -0.08006068f, 0.02134347f, 0.00106248f, -0.06658989f, 
    0.01386322f, 0.02395722f, -0.09471757f, -0.03456660f, 0.28104979f, 0.01026895f, -0.00243639f, 0.03388322f, 
    0.07044432f, 0.02295621f, -0.13379827f, -0.07128638f, -0.00637327f, -0.08691859f, 0.01736370f, 0.11968307f, 
    -0.03086868f, 0.01732158f, -0.07393879f, -0.03270611f, 0.05227603f, 0.12938218f, 0.00859242f, 0.00683058f, 
    0.08988332f, 0.13713041f, 0.05565971f, 0.11454845f, -0.11123206f, -0.22586270f, -0.14350617f, 0.15022302f, 
    -0.07813109f, 0.02468913f, -0.13973740f, 0.15962486f, -0.00477583f, -0.07849981f, 0.01220559f, -0.02990502f, 
    -0.00039886f, 0.09017771f, -0.08223923f, 0.23297110f, 0.09011341f, 0.00341619f, -0.00612695f, 0.01456419f, 
    -0.03235715f, 0.02000853f, 0.03706992f, 0.06203546f, 0.06877530f, -0.19101194f, -0.20153618f, -0.00227718f, 
    0.11835436f, -0.03663578f, 0.11666074f, -0.12602970f, 0.05367621f, 0.06344797f, 0.04681563f, 0.02708989f, 
    -0.21066554f, -0.04457927f, 0.03604744f, 0.21631713f, -0.05481703f, 0.00179406f, -0.03866749f, 0.03375496f, 
    -0.04473362f, -0.06154351f, -0.03346219f, 0.00520488f, -0.16231561f, 0.10685323f, -0.11391425f, -0.01044066f, 
    0.00171103f, 0.14869997f, -0.01784114f, -0.07244238f, 0.12865205f, 0.00853549f, -0.03757317f, 0.11847225f, 
    -0.23570777f, 0.07089186f, 0.13530581f, 0.27767622f, 0.05432249f, 0.10755900f, -0.06195645f, 0.12140356f, 
    0.00299372f, -0.00233159f, 0.24198651f, 0.11549582f, 0.01700648f, -0.01219523f, 0.16050062f, -0.17931770f, 
    -0.02381330f, 0.12753424f, -0.10348056f, -0.04686212f, 0.02703616f, -0.01986335f, -0.03816772f, -0.09748786f, 
    0.10923167f, 0.33637887f, -0.08108396f, -0.03640237f, 0.05176204f, -0.01298441f, 0.06255139f, 0.14949088f, 
    -0.18658134f, -0.03810224f, 0.02872239f, 0.13031100f, 0.02159757f, 0.10166144f, -0.04832739f, -0.19171968f, 
    0.11247502f, -0.02113790f, 0.05432388f, -0.10344084f, 0.07769992f, 0.02728058f, 0.10554367f, 0.23224145f, 
    -0.07536143f, 0.07907344f, -0.04462432f, 0.08411346f, -0.01388488f, 0.22233513f, 0.15844983f, 0.02354017f, 
    0.05123483f, -0.07819921f, 0.03280398f, -0.01629978f, 0.05948135f, 0.14461724f, -0.05482331f, -0.07748451f, 
    0.09940910f, 0.06018697f, 0.06472719f, 0.08751903f, -0.03945165f, 0.02620854f, -0.05074607f, 0.04226727f, 
    0.23475923f, 0.09627016f, -0.11838175f, -0.32820871f, 0.07243531f, 0.07802062f, -0.04571350f, -0.05002619f, 
    -0.02730768f, 0.06951703f, 0.05737980f, 0.03124940f, 0.02996944f, 0.32128116f, -0.10914107f, -0.16416478f, 
    -0.01048060f, 0.02019735f, -0.04852612f, -0.02006372f, -0.00326031f, 0.17524464f, -0.04917691f, 0.03331931f, 
    -0.02937806f, 0.08220840f, 0.21546264f, -0.06667368f, -0.15393586f, 0.00306115f, -0.09070417f, 0.02949980f, 
    -0.01029983f, 0.00868815f, 0.02452815f, 0.00443568f, 0.40017986f, -0.19609822f, -0.05011158f, -0.00189177f, 
    -0.11495478f, 0.09650430f, 0.12134432f, -0.09137168f, -0.08673866f, -0.13361679f, -0.09365613f, 0.32869223f, 
    -0.12026512f, 0.08482819f, -0.03283876f, -0.12778811f, -0.03379440f, 0.00617235f, 0.10447065f, -0.05329983f, 
    -0.10651426f, 0.11643760f, 0.10985847f, 0.06862000f, -0.03244485f, -0.16607641f, -0.19263232f, 0.04400349f, 
    0.12031864f, 0.14549387f, 0.06582433f, -0.03383923f, 0.00001322f, 0.01456404f, -0.09394754f, -0.05070983f, 
    0.33495221f, 0.08617458f, 0.22966012f, 0.14550923f, 0.29873905f, -0.08709104f, -0.06227774f, 0.12121484f, 
    -0.18864819f, -0.01906698f, 0.19457781f, -0.04724840f, 0.37528774f, 0.01468667f, -0.14891911f, -0.15081000f, 
    0.12166032f, -0.03486094f, 0.12488854f, 0.12714219f, -0.06256192f, 0.10087999f, -0.03594947f, 0.01226387f, 
    -0.19082077f, -0.07916366f, -0.25747299f, 0.24591316f, -0.04100850f, 0.00073668f, 0.19857775f, 0.08632566f, 
    0.02770831f, 0.00273990f, -0.11389577f, 0.01303469f, 0.15122604f, 0.27223179f, -0.18317729f, 0.08325572f, 
    0.03384804f, -0.09473854f, 0.13980949f, -0.01021240f, -0.00418974f, 0.07298972f, -0.00181774f, -0.01789405f, 
    -0.17313278f, -0.06372190f, 0.00911594f, 0.15234010f, 0.03933332f, 0.16720714f, 0.00942801f, -0.05668197f, 
    -0.11875922f, -0.08649572f, 0.08408663f, 0.10928652f, -0.06876896f, 0.15755185f, 0.07846652f, -0.21326089f, 
    -0.00550450f, 0.03119904f, -0.03198935f, -0.02675719f, -0.01053153f, 0.13823974f, 0.09453436f, 0.02929606f, 
    -0.29004037f, 0.22622536f, -0.17816234f, -0.08672497f, 0.08701491f, 0.05162300f, 0.19189459f, 0.15593037f, 
    0.07288972f, -0.07458199f, -0.05724067f, 0.04884399f, -0.04694068f, 0.02236710f, -0.25106964f, -0.02627789f, 
    0.15247038f, 0.06880870f, -0.27273032f, -0.09293566f, 0.07752148f, -0.01355859f, 0.10802425f, 0.24791829f, 
    -0.06901469f, 0.10654008f, 0.04192571f, -0.26156262f, -0.03316956f, 0.07459362f, 0.04960821f, 0.05503653f, 
    -0.00188866f, -0.01622730f, 0.19084625f, -0.19371283f, -0.08685096f, 0.03702934f, 0.31900382f, -0.02582494f, 
    0.12578833f, 0.04119933f, 0.01699761f, 0.13891648f, 0.18990773f, -0.07494767f, -0.00724738f, 0.05062751f, 
    -0.20690668f, -0.41763246f, 0.11966889f, 0.21106896f, -0.10890798f, -0.01113526f, -0.04868584f, 0.04509810f, 
    0.04453561f, -0.02611643f, 0.14996448f, 0.09347472f, 0.15531076f, 0.11214284f, -0.07272703f, 0.24699512f, 
    -0.02939144f, -0.00705332f, -0.07167817f, 0.12653348f, 0.22064251f, 0.10789979f, -0.08375654f, 0.06385749f, 
    -0.07739508f, 0.02788121f, -0.02432183f, -0.10306296f, -0.16149677f, -0.25053251f, -0.28367725f, 0.13011236f, 
    -0.01209761f, 0.05443938f, -0.16696967f, 0.00512898f, 0.12827967f, 0.31373367f, -0.06143139f, 0.14211021f, 
    0.10479763f, 0.11798224f, 0.11126719f, -0.21762693f, 0.02289484f, 0.00245904f, -0.17203121f, 0.24164708f, 
    -0.05463941f, -0.20065799f, -0.20408511f, -0.18360393f, 0.02180055f, 0.20830098f, -0.00634375f, -0.07768160f, 
    0.12295875f, 0.18055230f, 0.06035706f, -0.07802349f, -0.11929921f, 0.00559634f, 0.04079748f, -0.08525928f, 
    0.04551742f, 0.10151625f, -0.00729469f, -0.18128318f, 0.05694390f, -0.11087002f, 0.05751787f, 0.08590084f, 
    0.03742341f, -0.14822653f, -0.02827123f, -0.02455490f, 0.04529412f, 0.05582526f, -0.16749495f, 0.28261200f, 
    0.08435892f, -0.06573655f, 0.13975574f, 0.02445557f, 0.04556792f, 0.11611944f, 0.13536607f, 0.04636014f, 
    0.09197671f, -0.11737891f, 0.05709561f, -0.02286987f, -0.02378191f, -0.02619262f, -0.03802098f, 0.00337996f, 
    0.12237317f, -0.19910754f, 0.23106886f, -0.28347069f, -0.03429145f, 0.10024612f, 0.07114990f, -0.08289305f, 
    0.10227074f, 0.03369148f, 0.11332209f, 0.00659791f, 0.15977301f, -0.07204223f, -0.20735237f, 0.10907388f, 
    0.15027459f, -0.05463584f, 0.12850136f, 0.19957426f, 0.00461324f, 0.05114356f, 0.04363994f, -0.00406025f, 
    -0.09286427f, 0.13820487f, -0.16178448f, -0.11647217f, 0.09337045f, -0.00682431f, -0.06132575f, 0.01164546f, 
    0.05877474f, 0.06663001f, -0.09245702f, 0.07030291f, -0.13155016f, 0.16947332f, -0.12010261f, -0.22736397f, 
    -0.15343171f, -0.24144499f, -0.23439665f, 0.13764106f, -0.05635073f, 0.08756477f, 0.10532587f, -0.09794195f, 
    0.46115923f, -0.04924280f, 0.15552895f, -0.18033063f, 0.00578797f, -0.05513285f, -0.00955314f, 0.00917408f, 
    0.11539618f, -0.01000934f, 0.09763352f, 0.16725859f, 0.12133759f, -0.15143529f, 0.03146696f, -0.37009004f, 
    -0.06180786f, -0.06297274f, 0.04906324f, -0.15557697f, -0.16174379f, 0.07797239f, -0.17843932f, 0.08131223f, 
    0.07524144f, 0.12448043f, -0.09732744f, 0.06612605f, -0.05350278f, 0.03984199f, 0.06744762f, -0.02617293f, 
    -0.21965714f, -0.07196705f, -0.05616629f, -0.29037550f, 0.31541809f, 0.09218232f, 0.13430557f, 0.17809147f, 
    -0.05246255f, 0.09711508f, 0.18343568f, -0.05715501f, -0.05571560f, -0.18107279f, -0.22877678f, -0.04950460f, 
    0.43445665f, 0.01510106f, 0.31186444f, 0.31181589f, -0.16986620f, -0.09707315f, 0.01024486f, -0.13775063f, 
    0.07272944f, 0.00367343f, 0.13036513f, 0.06926539f, 0.16503911f, -0.32626033f, -0.04736410f, 0.07449738f, 
    -0.29895666f, -0.20627677f, 0.00561339f, -0.20393020f, -0.06148129f, 0.08977248f, -0.09440735f, -0.12908062f, 
    -0.23043996f, 0.06083287f, 0.18264399f, 0.13290444f, 0.12228306f, 0.12104335f, -0.12519228f, -0.08393940f, 
    0.01989219f, -0.35482600f, 0.04874803f, 0.04733797f, 0.17851721f, 0.09446017f, 0.01712170f, 0.02983051f, 
    -0.01412851f, 0.07534080f, 0.04362083f, 0.05475619f, -0.00419697f, -0.06487256f, 0.18644284f, -0.04007712f, 
    0.10391956f, -0.00026678f, 0.05441298f, -0.29622197f, 0.01574465f, 0.26988676f, 0.17514990f, 0.05336691f, 
    0.19663127f, -0.17207254f, -0.19139941f, -0.54138291f, 0.21275474f, 0.05074877f, 0.16048007f, -0.06437380f, 
    -0.01507943f, 0.03548590f, 0.06847648f, 0.27282915f, 0.08212502f, 0.09875470f, -0.06091651f, -0.07144892f, 
    -0.02542684f, 0.05615747f, -0.08678746f, 0.02438428f, 0.06596433f, -0.06595305f, 0.10408355f, -0.13386475f, 
    -0.00036528f, -0.16169374f, -0.13494456f, -0.15064490f, 0.00199975f, 0.17042869f, 0.08051367f, 0.06999668f, 
    -0.06111329f, 0.14484802f, 0.05970469f, 0.01172489f, 0.07700682f, 0.04707547f, 0.16798964f, 0.27946767f, 
    0.07083916f, 0.14239068f, 0.16495341f, -0.04658780f, -0.11083484f, -0.07629158f, -0.20549116f, -0.02493931f, 
    0.17959845f, 0.10317690f, 0.10372428f, 0.22454771f, 0.34238139f, -0.10343739f, 0.05227308f, -0.30594513f, 
    0.02765824f, -0.23588325f, -0.17812926f, -0.05064057f, -0.03860123f, 0.02464339f, 0.07024300f, -0.11468717f, 
    -0.08411629f, 0.07277442f, 0.00445160f, 0.03021044f, 0.27535501f, 0.04733201f, 0.16712661f, -0.01725617f, 
    -0.11052472f, -0.21691914f, -0.43266097f, -0.32182366f, -0.24546362f, 0.45997667f, 0.17001398f, 0.21740809f, 
    0.24305941f, -0.07186709f, 0.15004303f, -0.02425982f, -0.07158986f, -0.22769174f, -0.12247381f, 0.00456588f, 
    -0.12812965f, 0.43093103f, -0.04107475f, 0.03433329f, -0.05590409f, 0.02211661f, 0.02928880f, 0.37383845f, 
    0.00335255f, 0.03232747f, -0.09495000f, -0.00046658f, -0.00957586f, 0.00742872f, 0.06962058f, -0.24026054f, 
    -0.01193914f, 0.06639543f, -0.29087490f, -0.32809582f, -0.09087742f, -0.01418856f, -0.04676582f, 0.19947731f, 
    0.01783085f, 0.11074741f, -0.24286695f, -0.12301191f, 0.10933733f, 0.23014684f, 0.20041429f, 0.00669073f, 
    0.17045653f, 0.02502682f, 0.12530380f, 0.02622193f, 0.01883349f, 0.03647175f, 0.20094618f, -0.11561676f, 
    0.02562527f, 0.37221578f, 0.13326161f, 0.25635284f, 0.31744152f, 0.02599018f, 0.03795100f, 0.17674145f, 
    0.39290807f, -0.11098846f, -0.04810835f, -0.05164794f, -0.12073972f, -0.01268014f, -0.09021607f, -0.13007000f, 
    -0.05931238f, -0.05359589f, 0.12816541f, 0.02817490f, 0.18049891f, -0.05429546f, 0.11655410f, 0.03023790f, 
    -0.22719592f, 0.02777909f, -0.09622339f, -0.06587316f, -0.01762133f, 0.10117256f, -0.26998064f, -0.07061969f, 
    -0.00530589f, 0.20611468f, 0.18660365f, 0.06667858f, -0.01423972f, -0.26058045f, -0.17668176f, 0.04016966f, 
    -0.01815247f, -0.14780220f, 0.07643903f, -0.03265068f, 0.05362110f, 0.15515742f, -0.39609030f, 0.31851026f, 
    0.06481257f, -0.01251621f, 0.23784380f, -0.20887026f, 0.01350057f, -0.07044048f, -0.18768808f, 0.20426111f, 
    0.17092104f, -0.05925549f, -0.20836294f, -0.29358417f, -0.05928191f, 0.02986659f, 0.00481438f, -0.01149816f, 
    0.22711493f, 0.27358171f, 0.08326801f, 0.01325586f, 0.14705089f, 0.31880599f, 0.12672752f, 0.09238298f, 
    0.24269891f, 0.12090766f, 0.21975195f, 0.25365871f, 0.02858427f, 0.04178669f, -0.02996339f, 0.02460954f, 
    -0.00367684f, 0.12138128f, 0.05025873f, 0.00181542f, 0.15199137f, 0.14860162f, -0.22635885f, 0.27742127f, 
    -0.06921586f, -0.08754249f, 0.23882262f, 0.16862072f, 0.04563761f, 0.07783327f, -0.06777208f, 0.04879773f, 
    0.12626046f, -0.07650365f, 0.11803121f, 0.02019552f, 0.08303829f, -0.02087742f, -0.19446672f, 0.00474307f, 
    0.16665053f, -0.49801916f, 0.01194864f, -0.41580883f, 0.08194365f, -0.07415961f, 0.07527205f, -0.08165598f, 
    0.22740379f, 0.08465430f, -0.00719151f, -0.03923601f, 0.20769665f, -0.01105028f, 0.02287701f, 0.07471284f, 
    -0.15911610f, -0.02595785f, -0.11087313f, 0.08436585f, -0.13537222f, -0.01366076f, 0.03907333f, -0.11116130f, 
    -0.14545216f, 0.24226615f, -0.09463870f, 0.50218707f, 0.06449407f, 0.12030603f, 0.02922522f, 0.03770289f, 
    0.12787254f, -0.01020920f, 0.06803183f, 0.25352773f, -0.01133834f, 0.23704393f, 0.17828088f, 0.07284687f, 
    -0.15684558f, -0.19254808f, -0.08185990f, 0.10588644f, -0.09804755f, 0.08265918f, 0.11230335f, -0.07424802f, 
    0.13713096f, -0.13846464f, 0.16817388f, -0.04098762f, -0.02797125f, -0.01554237f, 0.03506965f, -0.13516958f, 
    -0.06491014f, 0.08326090f, 0.07540981f, 0.25825146f, 0.00678186f, -0.06118673f, -0.12849851f, 0.03002858f, 
    -0.04384767f, -0.18152075f, 0.08819667f, 0.17766666f, 0.08416232f, 0.01029805f, 0.06074145f, -0.07843500f, 
    0.11855012f, -0.08357538f, 0.18683724f, 0.21652447f, 0.04822621f, -0.01916100f, -0.05490969f, 0.07261921f, 
    -0.15043099f, -0.10472950f, 0.00082026f, -0.01007723f, -0.20212704f, 0.00637271f, -0.15696526f, 0.26816395f, 
    0.07834980f, -0.09779107f, -0.03835198f, -0.25658703f, -0.29811779f, -0.08208815f, 0.11252841f, -0.08341417f, 
    -0.16124414f, 0.18286644f, 0.05508533f, 0.27133989f, 0.14491804f, -0.05000988f, -0.07517659f, -0.03865641f, 
    -0.01411179f, -0.01965036f, 0.12717444f, -0.07948326f, -0.03739572f, 0.29432097f, -0.22464342f, 0.05644802f, 
    -0.00837222f, -0.05904219f, 0.02901484f, 0.07655453f, -0.04776403f, 0.01872511f, 0.18960541f, 0.04631765f, 
    -0.14351523f, 0.04856563f, 0.00160710f, -0.11392313f, -0.08899660f, 0.12063272f, 0.01609355f, 0.02024209f, 
    -0.08701508f, -0.08135668f, -0.00761455f, -0.00179382f, 0.31178701f, 0.10260023f, 0.10224253f, -0.08963385f, 
    -0.01231404f, 0.00458361f, -0.30277282f, 0.14646211f, 0.02277776f, -0.15806380f, 0.29843482f, -0.03318592f, 
    -0.07760026f, 0.01020810f, 0.05288030f, 0.09540946f, 0.05303872f, -0.02401746f, 0.02251168f, 0.06972457f, 
    0.08604009f, -0.22381209f, -0.14586484f, -0.18085168f, 0.07207894f, -0.09869287f, 0.06899785f, 0.13929600f, 
    -0.17108442f, -0.02936104f, -0.12367935f, 0.08865640f, 0.05952102f, -0.02812296f, 0.07898377f, 0.00905271f, 
    0.08798880f, -0.07492714f, -0.08936734f, 0.19449851f, 0.03170589f, -0.07411833f, 0.24139531f, -0.18291332f, 
    0.03345605f, 0.18822581f, -0.20193595f, -0.17036012f, -0.07234677f, -0.19818281f, 0.04368010f, 0.11470468f, 
    -0.10652634f, 0.08505479f, 0.03283611f, 0.00911444f, 0.04035104f, 0.08418094f, 0.24186637f, 0.27069139f, 
    -0.38412988f, 0.47434786f, 0.30832124f, 0.36880916f, -0.07585265f, -0.00654726f, -0.08456295f, 0.15829575f, 
    -0.08515935f, 0.17178854f, 0.03025695f, 0.16779028f, -0.05566113f, 0.04552376f, -0.01416578f, -0.20993905f, 
    0.09516018f, 0.09910242f, -0.06082035f, 0.01928400f, -0.01548574f, 0.00944121f, -0.08402230f, -0.00049691f, 
    -0.07689549f, 0.05046039f, 0.14350544f, 0.03036196f, 0.12234489f, 0.02277707f, -0.01583597f, -0.03241238f, 
    0.00916430f, 0.01009611f, -0.01837911f, -0.16957240f, 0.16811843f, 0.18021910f, 0.24533328f, 0.16953097f, 
    0.23403051f, 0.08009151f, 0.19027758f, -0.11164659f, 0.04194799f, -0.06812984f, -0.08234601f, 0.04215545f, 
    0.03694984f, -0.04806852f, 0.05433108f, -0.06762744f, 0.03483749f, 0.02437627f, -0.00808623f, 0.02602544f, 
    -0.05098485f, -0.02125062f, -0.04943135f, -0.01297900f, 0.05759552f, -0.01403338f, -0.04971933f, 0.00122610f, 
    0.05210892f, 0.03855246f, -0.00245298f, -0.06415212f, -0.05447010f, 0.04342245f, 0.00419786f, 0.00360145f, 
    0.00294785f, 0.03595388f, -0.02027704f, 0.03773913f, -0.03653426f, -0.05314996f, -0.06373374f, 0.02750038f, 
    -0.02590917f, 0.05185070f, -0.04419130f, -0.05712142f, -0.00105301f, -0.07729225f, -0.06236653f, 0.06333958f, 
    0.06010171f, 0.02901647f, 0.02476320f, -0.01667520f, -0.03366446f, -0.06192285f, -0.06971146f, 0.04823723f, 
    0.00900343f, -0.03832682f, -0.06494783f, -0.02657285f, -0.02681102f, -0.07553405f, 0.02880482f, 0.05288359f, 
    -0.01755081f, 0.02093818f, -0.07305249f, 0.00772255f, -0.02755086f, 0.02189413f, -0.03393013f, 0.02464045f, 
    -0.05594682f, -0.04538937f, -0.07118525f, -0.02511524f, -0.03541461f, 0.00893244f, 0.02991066f, 0.02617990f, 
    -0.00552568f, -0.02062292f, 0.04269750f, 0.03971378f, 0.02912633f, 0.01662217f, -0.04476340f, -0.07997543f, 
    0.00934500f, 0.06442186f, 0.04699894f, 0.00855989f, -0.07924269f, 0.02544516f, 0.02201730f, 0.02295003f, 
    -0.05697037f, -0.02973774f, -0.07015072f, -0.04103627f, -0.06442393f, -0.08033093f, -0.03828081f, -0.03581769f, 
    -0.07490856f, 0.03426764f, 0.04808918f, -0.00585054f, -0.03391596f, -0.04271489f, -0.03283212f, -0.02319137f, 
    0.06803393f, 0.04038122f, -0.05621413f, -0.01453467f, -0.02780961f, 0.00075332f, -0.07186946f, -0.04811618f, 
    -0.00007008f, -0.02327711f, 0.05382374f, -0.02621399f, -0.03327164f, -0.04461190f, -0.01376992f, -0.03804253f, 
    0.05167056f, 0.00365584f, 0.04603867f, 0.00256070f, -0.05618984f, -0.00829148f, 0.05695501f, 0.05037077f, 
    -0.05385522f, 0.04521669f, -0.00288777f, -0.06049881f, -0.01223101f, 0.00900913f, -0.07598929f, -0.00805161f, 
    0.00966260f, 0.02615494f, 0.01688036f, -0.04888375f, -0.00711422f, 0.03017034f, 0.00236853f, 0.02709381f, 
    0.04593744f, 0.01897032f, -0.04486997f, 0.03579498f, -0.06812642f, -0.01108015f, -0.03424131f, -0.03866123f, 
    -0.07799403f, -0.05666956f, 0.04451016f, 0.00864919f, -0.03553858f, 0.04532064f, 0.03288132f, -0.03441758f, 
    -0.04237615f, 0.01880503f, 0.04169520f, 0.04804817f, 0.00153363f, -0.07558612f, 0.00487928f, -0.03344921f, 
    -0.05626477f, -0.02409305f, -0.01632690f, 0.04705579f, -0.01693279f, -0.00453178f, -0.07858857f, -0.01103839f, 
    -0.04342997f, 0.02570747f, -0.05305695f, -0.03976854f, -0.00762822f, -0.06564834f, -0.03190709f, 0.02910713f, 
    -0.00125198f, -0.06167886f, 0.00802048f, -0.03452408f, -0.04510584f, -0.03894683f, 0.02103699f, 0.02534740f, 
    -0.20257133f, 0.02841905f, -0.09807617f, 0.17404281f, 0.13400947f, 0.02947214f, 0.13003296f, 0.04693260f, 
    0.06401546f, 0.08237917f, 0.10358766f, 0.03580107f, 0.03372898f, 0.07962820f, 0.05946936f, 0.03744470f, 
    0.00426818f, 0.05618355f, -0.06102302f, 0.08176913f, 0.17713778f, 0.01430484f, 0.27538738f, 0.11666857f, 
    -0.09611992f, 0.01443652f, 0.32495102f, -0.06317408f, -0.05178490f, 0.03607896f, 0.12288018f, 0.08623800f, 
    0.01609887f, 0.05213594f, 0.02929436f, -0.08124987f, -0.29827863f, -0.18446372f, 0.04199056f, 0.19005896f, 
    -0.00310724f, 0.00675746f, -0.05168663f, 0.21408719f, -0.04090766f, -0.03440187f, 0.03058571f, -0.06454085f, 
    -0.22094107f, 0.14268304f, -0.02489938f, -0.16894482f, -0.03106650f, -0.02359252f, -0.08425063f, 0.09063683f, 
    0.11742755f, 0.10957772f, 0.17423390f, 0.19573133f, 0.10193498f, 0.47768500f, -0.01896922f, 0.13849232f, 
    -0.00528255f, 0.05432579f, 0.03581470f, 0.01876798f, 0.09189455f, 0.13343504f, 0.15803312f, 0.16902405f, 
    0.17398056f, 0.03957228f, 0.08974218f, 0.01487791f, -0.05738024f, -0.03131237f, 0.03796815f, 0.01339585f, 
    -0.06531354f, 0.04995833f, 0.03670859f, -0.00316815f, 0.13805662f, 0.04934458f, 0.34978858f, 0.12675519f, 
    0.16589701f, 0.12168853f, 0.02876073f, 0.07680409f, 0.15099636f, 0.19824110f, -0.10208207f, 0.11675978f, 
    -0.10405523f, -0.04196551f, -0.01180048f, -0.00943522f, 0.04074211f, 0.04021796f, -0.01422851f, -0.01103690f, 
    -0.06675984f, -0.00585206f, 0.03203534f, 0.07134722f, -0.49549633f, -0.14618447f, -0.19330697f, 0.09928874f, 
    0.00325052f, -0.05386432f, -0.01964260f, -0.11052044f, -0.01791110f, -0.08385283f, -0.05236964f, -0.05504070f, 
    0.03180190f, -0.20204903f, 0.11930856f, 0.02296649f, -0.03731970f, 0.15213002f, 0.07140546f, 0.18184219f, 
    -0.11229178f, -0.09392329f, 0.06109415f, 0.15194356f, -0.13364083f, 0.01993973f, 0.01401508f, -0.07563671f, 
    0.04079019f, 0.01449292f, 0.12835717f, 0.07205269f, -0.02587828f, 0.02981417f, -0.04916496f, -0.16392499f, 
    0.09310663f, 0.15749976f, 0.31158808f, 0.05783691f, -0.08705388f, -0.07831778f, 0.01357741f, 0.05288476f, 
    0.11403938f, 0.06076092f, 0.03543397f, -0.05838540f, -0.02546468f, -0.10553858f, -0.11333177f, 0.11020151f, 
    0.09611613f, -0.03112127f, 0.11354674f, -0.05633084f, 0.15635106f, 0.10816257f, -0.07970825f, 0.03624451f, 
    0.05370618f, -0.14518702f, -0.02302220f, -0.38404950f, -0.08587454f, -0.10049636f, 0.08008691f, 0.05356620f, 
    0.07376871f, -0.08146480f, -0.05235256f, 0.10774687f, -0.02552845f, -0.12048452f, -0.29826203f, -0.20426004f, 
    -0.15930943f, -0.01628588f, -0.02211310f, 0.00788693f, -0.11873970f, -0.03519881f, -0.03774763f, -0.09344897f, 
    -0.05691261f, 0.05517365f, 0.05468981f, 0.00441764f, 0.02355765f, -0.00238027f, -0.06820772f, 0.03484717f, 
    -0.04668947f, -0.05985852f, 0.06647210f, 0.01618478f, -0.06831212f, -0.00501483f, -0.02751968f, -0.05914462f, 
    -0.00101906f, 0.02995398f, -0.07587603f, 0.01957593f, -0.00954776f, -0.02946041f, -0.00180458f, 0.03381076f, 
    -0.02044466f, -0.07627268f, -0.06666725f, -0.03355033f, -0.06025723f, -0.05204671f, 0.02637617f, 0.04598200f, 
    0.04902465f, -0.06065430f, 0.05334916f, 0.03297797f, -0.05681948f, -0.00962843f, -0.03516097f, 0.06292272f, 
    0.04217736f, -0.01295217f, -0.04130192f, -0.01240897f, 0.03617322f, -0.01313198f, -0.00294649f, -0.06302874f, 
    0.03407694f, -0.06246028f, 0.03600838f, 0.03507231f, -0.00202354f, -0.06377048f, -0.04160696f, -0.01687048f, 
    0.00032037f, 0.04333666f, 0.04723221f, -0.02858597f, -0.00175838f, -0.00531760f, 0.02744480f, -0.00425622f, 
    -0.04521351f, 0.03435252f, -0.03233135f, -0.06180243f, -0.01391706f, -0.03224568f, -0.06476238f, 0.03871782f, 
    -0.01780828f, -0.01675282f, 0.06049471f, 0.01605214f, 0.00059210f, -0.00724447f, 0.00519106f, -0.05875455f, 
    0.03308006f, -0.06356286f, -0.01389845f, 0.06391196f, -0.03332609f, 0.05821182f, 0.01034600f, 0.03119688f, 
    0.02263307f, -0.07535461f, -0.07342963f, -0.00079970f, 0.05968794f, -0.04008871f, -0.02472966f, 0.02929159f, 
    -0.04520567f, -0.03944860f, -0.01134919f, -0.05862283f, -0.01444597f, -0.04590751f, -0.02663526f, -0.01903005f, 
    -0.04979352f, 0.04666684f, -0.02628704f, 0.04747895f, -0.05203178f, 0.06273191f, 0.03145396f, 0.00116472f, 
    -0.02623300f, -0.00601906f, -0.06030098f, 0.06363600f, 0.02231395f, 0.05873625f, -0.06206794f, -0.02630430f, 
    0.05156957f, -0.05040523f, -0.01298360f, -0.04181814f, 0.02855725f, 0.04507740f, 0.04513190f, 0.06581511f, 
    0.02465541f, 0.05601732f, 0.06208401f, -0.00093294f, -0.06646026f, -0.02534130f, 0.02876550f, -0.00938816f, 
    -0.03816370f, -0.04858528f, -0.07741299f, -0.07334432f, -0.02252624f, -0.00125895f, -0.07613790f, 0.04776242f, 
    -0.04896703f, 0.03940383f, -0.05982935f, 0.00320197f, -0.04111503f, -0.03354090f, -0.03107488f, 0.02199811f, 
    -0.03284448f, -0.04193392f, -0.05619159f, 0.02601008f, -0.07195647f, -0.00800959f, -0.03076073f, -0.02969659f, 
    0.01745615f, 0.00873942f, -0.06603888f, -0.00821402f, 0.00338056f, 0.02533600f, 0.06174937f, -0.01244165f, 
    -0.02372335f, 0.01127616f, -0.03459235f, 0.04524282f, 0.05190708f, 0.00661314f, 0.05745325f, -0.03866998f, 
    -0.06487556f, 0.04744811f, 0.03116016f, -0.01632489f, -0.04853744f, 0.02910175f, -0.02273385f, -0.01687691f, 
    0.00851067f, 0.01047032f, 0.04632169f, -0.06715230f, 0.01377129f, -0.02432593f, -0.06423035f, -0.02741141f, 
    -0.04205183f, -0.00692955f, -0.00363451f, 0.00002425f, -0.06661970f, -0.05408400f, 0.00100572f, -0.02189315f, 
    0.03302994f, 0.05604547f, -0.02529540f, -0.06884281f, 0.05590685f, -0.01713643f, 0.02975466f, 0.01641898f, 
    0.03606852f, 0.02321373f, -0.08099717f, 0.00040413f, -0.02528274f, -0.07739291f, 0.00707623f, -0.02018864f, 
    -0.01993749f, -0.01349897f, 0.01572969f, -0.02821810f, -0.06431942f, 0.01268908f, 0.05093283f, -0.04964810f, 
    -0.04029185f, -0.05367707f, 0.06123643f, -0.04443502f, -0.00465326f, -0.07154563f, -0.00174126f, 0.04230329f, 
    -0.02732325f, -0.07393522f, 0.00646789f, 0.01831308f, -0.02413200f, -0.00592110f, -0.02920404f, 0.00016574f, 
    -0.05442388f, -0.06182079f, -0.04896292f, -0.04155637f, -0.03514314f, -0.00971334f, -0.06665143f, -0.01325095f, 
    -0.00764290f, -0.04893384f, 0.05581738f, -0.06510388f, 0.03820471f, -0.04211376f, 0.02480188f, 0.02840491f, 
    0.01516653f, 0.04632353f, 0.01782527f, -0.06070750f, 0.02288374f, -0.04349665f, -0.01409259f, -0.07418427f, 
    -0.00683818f, -0.08186603f, 0.04236396f, 0.05820544f, 0.04485339f, 0.02412090f, -0.00288281f, -0.08044832f, 
    -0.00038312f, -0.02662889f, 0.03555072f, -0.01067459f, 0.02927197f, -0.00590027f, -0.07643484f, 0.02435313f, 
    -0.03446418f, 0.05788077f, 0.02201751f, -0.03832110f, -0.03246289f, -0.01402895f, 0.01900879f, -0.06520322f, 
    -0.02095571f, -0.02995268f, -0.03900325f, 0.03786314f, -0.02140925f, -0.01756085f, 0.05797810f, -0.07098687f, 
    -0.02501127f, 0.00541685f, -0.07438235f, 0.04662922f, 0.05714288f, -0.06902301f, 0.00259841f, 0.01769013f, 
    0.04217011f, 0.03552919f, 0.00747459f, -0.04016133f, -0.07185244f, -0.03103354f, -0.02677425f, -0.04525262f, 
    0.06801949f, 0.02268754f, 0.05665972f, -0.02824765f, -0.01093269f, -0.01253223f, -0.00043204f, 0.00529402f, 
    -0.04357105f, 0.04948524f, -0.05838161f, -0.05419521f, 0.00455116f, 0.06658036f, 0.01423339f, -0.07370944f, 
    -0.05880723f, -0.06508178f, 0.05809734f, 0.04673051f, 0.05463714f, -0.06725501f, -0.05434938f, 0.01928451f, 
    0.06845912f, 0.04649484f, -0.07056469f, 0.05646448f, -0.07389332f, -0.00306528f, 0.01073774f, 0.00449519f, 
    -0.02059988f, -0.03022796f, -0.03962241f, 0.06058725f, -0.00539263f, 0.03522732f, -0.02490287f, -0.02902025f, 
    0.01913708f, 0.01493950f, -0.03728832f, -0.03736838f, -0.00528657f, 0.02628417f, 0.04499156f, -0.00344033f, 
    -0.06884445f, 0.03789280f, 0.01027957f, 0.05867582f, -0.01061671f, -0.06985828f, -0.01150941f, -0.02553752f, 
    -0.01815636f, -0.01341161f, 0.04150067f, 0.02789840f, 0.04847500f, 0.03203005f, -0.07257856f, -0.07774721f, 
    -0.06160410f, -0.04811561f, 0.00521973f, -0.03843798f, 0.05151245f, -0.03737926f, -0.06665543f, 0.04893813f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07605068f, 0.15742618f, 0.20473258f, 0.02648429f, -0.01770140f, -0.07453847f, -0.06516280f, 0.00662786f, 
    0.13005972f, -0.00190624f, 0.08073500f, 0.03067586f, 0.01563926f, 0.08028081f, -0.14075336f, 0.15511544f, 
    0.12650000f, 0.10761590f, -0.10168421f, -0.09719411f, 0.06352860f, 0.18195729f, 0.07604413f, 0.03913529f, 
    0.02469195f, -0.08711047f, -0.07148207f, 0.09540814f, -0.10261734f, 0.11690509f, 0.00358479f, -0.07670195f, 
    0.07904647f, 0.00821237f, 0.04101180f, 0.06629398f, 0.08409058f, -0.00452604f, -0.02192937f, -0.03997774f, 
    0.10324869f, 0.09719829f, 0.03873445f, 0.01819400f, -0.02992296f, 0.11131739f, 0.09903233f, 0.09148702f, 
    -0.02508146f, 0.01849744f, 0.11615124f, -0.03800524f, 0.21404563f, 0.04091423f, -0.02276144f, 0.07509102f, 
    -0.10419603f, 0.00537306f, 0.03964750f, -0.06044467f, -0.03331784f, -0.00660250f, 0.05490128f, 0.01542068f, 
    0.08368164f, 0.01339912f, 0.07299332f, -0.00462363f, 0.14604084f, -0.01809779f, -0.00334016f, -0.06806371f, 
    0.01509195f, 0.12493228f, 0.07683261f, 0.16561452f, -0.00575397f, -0.00812799f, -0.06665318f, 0.02139715f, 
    0.11942410f, -0.08189782f, -0.01517000f, 0.01525513f, -0.01607077f, -0.07270539f, -0.06273781f, 0.15539409f, 
    0.01691171f, -0.00300633f, 0.25161150f, 0.05172100f, -0.14847867f, -0.04578107f, 0.13070838f, -0.02321247f, 
    -0.03881614f, 0.16641034f, -0.02757082f, 0.19318791f, 0.05549334f, -0.11319595f, 0.13815972f, 0.02631647f, 
    -0.01312750f, 0.12442699f, 0.07459310f, -0.01379301f, -0.08066683f, 0.02675054f, -0.00011043f, -0.00899403f, 
    -0.06944553f, 0.17095113f, -0.06240320f, -0.04564669f, 0.14321265f, 0.05429049f, -0.01696999f, -0.02140862f, 
    0.21106675f, -0.06223651f, 0.02537153f, -0.06830382f, 0.02616405f, 0.23468129f, -0.07306500f, 0.03888119f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.30612186f, -0.41255400f, -0.39046776f, 0.15076070f, -0.05778685f, 0.07809664f, 0.05460380f, -0.04253823f, 
    0.07082061f, -0.07044657f, -0.28417858f, 0.05278107f, -0.65143913f, -0.38174352f, 0.20296060f, -0.23532854f, 
    -0.44951391f, -0.00318471f, 0.21476457f, 0.31609625f, -0.03334498f, -0.18130915f, 0.12431034f, -0.16708578f, 
    -0.18341041f, -0.03375735f, 0.05203793f, -0.40777129f, 0.09478505f, -0.45226020f, 0.01747948f, -0.04455616f, 
    -0.04149247f, -0.27956688f, 0.00270068f, -0.18671729f, -0.22933677f, 0.20550874f, -0.03295795f, 0.07898033f, 
    -0.01441420f, 0.11187968f, 0.03976938f, 0.05021425f, 0.13153577f, -0.22441177f, -0.19183838f, -0.06056855f, 
    0.23641467f, 0.15943898f, 0.00152228f, -0.03047831f, -0.19573429f, 0.09344218f, -0.08558465f, -0.33688703f, 
    0.20207663f, 0.06865342f, 0.01918721f, -0.08534098f, 0.13045901f, -0.01692618f, -0.07967716f, 0.10428449f, 
    -0.02397225f, -0.35839966f, 0.00004416f, -0.17565833f, -0.08088335f, -0.04800870f, 0.29490083f, 0.03696364f, 
    -0.44967389f, -0.33314222f, 0.07176555f, -0.11115003f, 0.13058883f, -0.08918149f, -0.02403892f, -0.03812664f, 
    -0.28097647f, -0.16006313f, 0.05598428f, 0.03034496f, 0.09934304f, -0.03849082f, -0.02936077f, -0.34290454f, 
    0.12243698f, 0.18992917f, -0.11896199f, 0.10579633f, 0.22984496f, -0.02567335f, -0.31896117f, 0.03220545f, 
    0.08758100f, 0.30776784f, 0.11635740f, -0.29737246f, 0.25269136f, 0.10653757f, 0.07924064f, 0.01910430f, 
    0.06296660f, -0.37538099f, 0.04585565f, -0.02600698f, -0.03541813f, 0.15867127f, -0.08906612f, -0.00274262f, 
    -0.06553293f, -0.48926213f, -0.00803697f, 0.03879674f, -0.09657323f, -0.33132476f, -0.26849523f, 0.07660345f, 
    -0.36101145f, 0.27464813f, 0.03331381f, -0.05422917f, 0.07098939f, -0.34341902f, 0.07539503f, -0.08910613f, 
    -0.22760707f, 0.13746507f, 0.12321146f, 0.19083796f, 0.00939578f, 0.02428946f, -0.12121467f, -0.05083440f, 
    0.05493400f, -0.04386815f, -0.08839660f, -0.01976100f, -0.35608655f, -0.36133415f, -0.20960766f, -0.08220033f, 
    0.15711109f, 0.18406877f, 0.03400980f, -0.04418556f, 0.09523304f, 0.21308929f, 0.06323332f, -0.11310099f, 
    0.09190001f, 0.03832491f, 0.05284594f, 0.19586866f, 0.33652046f, 0.01236781f, 0.03503348f, -0.01700145f, 
    -0.39558339f, -0.41933030f, -0.01824726f, 0.49953952f, -0.00174883f, 0.02438369f, -0.01889863f, 0.08534180f, 
    0.15045558f, 0.18646595f, 0.01470273f, 0.09352750f, -0.44376910f, 0.43110636f, 0.19208239f, 0.12345085f, 
    -0.29580399f, 0.04832706f, 0.09171584f, -0.18673685f, 0.06670350f, 0.01506973f, -0.07447133f, -0.16270503f, 
    -0.18518500f, 0.04359955f, 0.01130947f, 0.07493177f, 0.10899749f, 0.19543588f, -0.05393201f, -0.30047607f, 
    0.12747438f, -0.32867047f, 0.07182989f, -0.15923059f, 0.27689499f, 0.03017128f, -0.10952396f, -0.05839562f, 
    0.02469405f, -0.18248287f, 0.14898247f, 0.00824540f, 0.13554561f, -0.06131530f, -0.06821413f, 0.02408546f, 
    -0.11945741f, 0.02162967f, -0.07915833f, -0.08540910f, -0.04895219f, 0.03099913f, 0.07413923f, -0.20595503f, 
    -0.00292754f, 0.03046058f, 0.49353921f, 0.04053150f, -0.21307501f, -0.06461669f, 0.16314994f, 0.16671707f, 
    -0.16954972f, 0.13275021f, 0.15531629f, 0.21087901f, 0.30281278f, -0.15321821f, 0.02687388f, 0.06033785f, 
    0.04329080f, -0.50233442f, 0.19179904f, 0.28888381f, -0.01588658f, -0.02551724f, -0.04773030f, -0.05507137f, 
    -0.00085982f, -0.06217498f, 0.00471679f, -0.41743597f, 0.07197092f, -0.04291642f, -0.07550459f, -0.03821002f, 
    0.12970060f, -0.51737189f, 0.17392763f, -0.63710362f, 0.02697548f, 0.03244073f, -0.07738097f, -0.01745297f, 
    -0.30465761f, 0.22786784f, 0.09303111f, -0.09125467f, -0.01487311f, 0.04211434f, 0.00654459f, 0.06121021f, 
    -0.11212626f, 0.06909625f, 0.07010549f, -0.01041266f, 0.17092107f, 0.10808033f, -0.22890194f, -0.10784775f, 
    -0.07551997f, -0.50551969f, -0.55607295f, -0.64427590f, -0.36178219f, 0.10796211f, 0.04884814f, -0.14601524f, 
    -0.04917533f, -0.05230792f, 0.01948005f, -0.63913244f, -0.76350009f, 0.06968787f, -0.05624425f, 0.00306369f, 
    -0.22911690f, 0.15518220f, -0.05213507f, 0.45547616f, 0.18058105f, 0.04337121f, -0.05864653f, 0.01374692f, 
    0.07079866f, -0.16224293f, -0.04106670f, 0.00312193f, 0.17253210f, -0.48489451f, 0.16706835f, -0.11317071f, 
    -0.12228423f, -0.07386899f, 0.02301298f, -0.04992080f, 0.03742089f, 0.34356767f, -0.14393289f, 0.05932390f, 
    0.15390556f, -0.04329347f, -0.01299621f, 0.06191621f, -0.10679322f, -0.02282779f, -0.03720679f, -0.22520243f, 
    0.26668051f, -0.23954567f, 0.04630559f, -0.08422426f, 0.06384880f, -0.01663605f, -0.13933617f, 0.02692517f, 
    0.17746729f, -0.10795561f, -0.03587151f, 0.03957098f, -0.13382128f, -0.05915896f, -0.05409959f, 0.06598558f, 
    0.00696892f, -0.27749595f, -0.04267649f, -0.34978607f, -0.02872523f, 0.07778182f, 0.01851778f, 0.19131392f, 
    0.17567754f, -0.12236297f, -0.58190888f, -0.04750179f, -0.29943147f, 0.04307378f, 0.28072733f, 0.07407503f, 
    -0.05579112f, 0.14106354f, 0.05680436f, 0.15237276f, 0.08453943f, -0.01994447f, 0.07793460f, -0.32603344f, 
    0.03070292f, 0.38963580f, 0.09529021f, 0.03794417f, 0.00892641f, -0.01874885f, 0.00669205f, 0.00923252f, 
    0.07396188f, 0.18003041f, 0.05136807f, 0.10220937f, 0.04678506f, 0.09651982f, -0.04381481f, 0.03359603f, 
    0.32170716f, 0.25482050f, 0.06429755f, 0.04682702f, 0.03816942f, 0.10479991f, 0.05736829f, -0.06812006f, 
    -0.12687108f, 0.04492638f, -0.26459607f, -0.02186176f, -0.02010290f, -0.07910839f, 0.19858740f, 0.07176377f, 
    -0.03584717f, 0.06190813f, -0.37156001f, 0.01885727f, 0.24582648f, 0.00279390f, 0.02872725f, -0.42764333f, 
    0.19697690f, -0.25957096f, 0.22633778f, -0.01995942f, 0.07318901f, -0.40331414f, -0.12219214f, -0.33392900f, 
    -0.23703499f, -0.04396337f, -0.06944972f, -0.32033545f, 0.11226673f, 0.10098794f, 0.02705894f, 0.08034134f, 
    0.01146338f, 0.12052697f, 0.00397031f, -0.03980943f, 0.24545111f, -0.06477216f, 0.07085606f, -0.05241545f, 
    -0.17019308f, -0.59694755f, -0.02778594f, 0.24485298f, -0.09825446f, -0.36792085f, -0.02240086f, -0.06992812f, 
    0.20484214f, 0.04706795f, -0.55195612f, 0.31126055f, -0.29507408f, -0.17033958f, -0.38753247f, -0.10179767f, 
    0.24331225f, -0.00865785f, -0.02282538f, 0.05426366f, 0.16643611f, -0.20506287f, 0.03388315f, 0.18119071f, 
    -0.12306619f, -0.48555318f, -0.28692013f, 0.17383419f, 0.01126602f, -0.06697345f, -0.20413209f, 0.00514243f, 
    -0.00487023f, -0.34422034f, -0.24203961f, -0.39309514f, -0.18636468f, 0.01395314f, 0.16826701f, 0.03827183f, 
    -0.26668033f, 0.00140776f, 0.06932219f, 0.14853494f, -0.00357460f, -0.08996283f, -0.03674863f, 0.01639937f, 
    -0.12561870f, 0.09377568f, 0.02290783f, 0.14081161f, 0.13423765f, -0.07732411f, 0.28103015f, -0.02587616f, 
    0.04491727f, -0.25948891f, -0.06876348f, -0.11112998f, -0.53905082f, 0.06674596f, -0.14202039f, -0.00632757f, 
    0.04739176f, 0.40949625f, 0.03977850f, 0.11207323f, -0.01814046f, 0.22290170f, -0.02223242f, -0.02836096f, 
    0.01827830f, 0.04621729f, 0.01100282f, 0.06571667f, -0.09031180f, 0.19119306f, 0.25598976f, 0.21406990f, 
    -0.12917490f, -0.14925736f, 0.04766653f, 0.11442214f, 0.04502942f, -0.11723234f, 0.04434117f, 0.02271883f, 
    -0.07525475f, -0.20448953f, 0.11084313f, -0.20909534f, -0.01262261f, 0.06923368f, -0.06468397f, -0.03454828f, 
    -0.20868489f, -0.06040068f, 0.05104279f, -0.07675076f, 0.25344512f, 0.19604725f, 0.07217073f, 0.00546087f, 
    -0.23714633f, 0.17936288f, -0.09936258f, -0.06219141f, 0.02804554f, 0.10903235f, -0.02584497f, 0.19830664f, 
    -0.24286321f, -0.04558622f, -0.01772830f, 0.12958097f, 0.12564050f, 0.02557287f, -0.00376158f, -0.03755568f, 
    0.12479716f, 0.17452091f, -0.02195462f, 0.15248121f, -0.05586373f, -0.04011483f, -0.00828708f, -0.06490591f, 
    -0.39066911f, -0.11720382f, 0.03589305f, -0.14532845f, 0.16325466f, -0.47363096f, -0.44173652f, -0.07236558f, 
    0.16258891f, -0.17589305f, 0.11344875f, 0.09534432f, -0.10775399f, 0.11203834f, 0.19981371f, -0.02430530f, 
    0.18103071f, 0.06289997f, 0.06534150f, -0.00642134f, -0.23186317f, 0.15929329f, -0.00960972f, -0.22075953f, 
    0.04473093f, -0.25554726f, -0.28521690f, -0.03099466f, -0.68697542f, -0.05942977f, -0.05319619f, -0.01707857f, 
    0.09824178f, 0.06422751f, -0.18680944f, 0.09989154f, 0.12530071f, 0.03336063f, 0.07875618f, -0.02630039f, 
    -0.03794066f, 0.14386433f, 0.06553441f, 0.01633534f, 0.10009570f, 0.06616022f, 0.03396355f, 0.03964071f, 
    -0.07689533f, -0.05207464f, -0.33463240f, 0.10292082f, -0.21061474f, 0.05833880f, -0.59249222f, 0.12018536f, 
    0.14880145f, -0.29482839f, 0.02671782f, -0.04883719f, 0.08276595f, 0.12479032f, -0.17534441f, 0.14223510f, 
    0.14090283f, -0.22887178f, -0.03932629f, 0.07726567f, 0.06204567f, -0.13955724f, 0.03510681f, -0.01125389f, 
    0.02111619f, -0.25301352f, 0.05971086f, 0.13032685f, -0.15532522f, -0.31887236f, -0.15219346f, -0.20355606f, 
    -0.38586715f, 0.27533010f, -0.03735974f, 0.20510998f, 0.05617929f, -0.18053596f, -0.08246992f, 0.05159739f, 
    0.20590021f, 0.00690085f, 0.00420421f, -0.19061507f, -0.02154123f, -0.01703815f, 0.20501633f, -0.07394584f, 
    -0.33027434f, 0.02640129f, 0.04477004f, -0.05423939f, -0.36515626f, 0.12752409f, 0.06337566f, 0.10785066f, 
    -0.00200822f, -0.40535897f, -0.53437722f, 0.05608284f, 0.17913094f, -0.16260532f, -0.15683727f, 0.18231253f, 
    0.10502790f, -0.02596496f, -0.03580482f, -0.01940378f, -0.08406658f, -0.11815359f, -0.01525358f, -0.07097431f, 
    0.32372040f, 0.00718843f, 0.04643114f, -0.43503091f, -0.12550651f, 0.05967960f, -0.03668573f, -0.00819425f, 
    0.21301068f, 0.24567266f, 0.02590685f, -0.14196259f, 0.20863950f, -0.03774729f, -0.28403375f, 0.20078984f, 
    -0.12429530f, 0.14839606f, 0.08231327f, -0.10618760f, 0.15916707f, 0.17695478f, 0.08013973f, 0.00133349f, 
    -0.46779069f, 0.04282968f, -0.05355340f, 0.05018407f, 0.05519885f, -0.16337186f, 0.05251060f, -0.05349234f, 
    0.04457529f, 0.48364645f, -0.13055910f, 0.08173045f, -0.49472255f, 0.00576255f, 0.36455086f, -0.02507454f, 
    -0.22562224f, 0.18658701f, 0.20341569f, 0.05620080f, 0.07594495f, -0.01505116f, 0.11430854f, 0.04992993f, 
    0.18552667f, -0.06627262f, -0.06148565f, 0.12678429f, -0.04798040f, 0.04356823f, 0.04656816f, -0.05121077f, 
    -0.18652077f, -0.03066627f, 0.17420715f, 0.05239040f, -0.27924070f, 0.00950279f, -0.47331819f, 0.14495456f, 
    0.20504168f, -0.01314770f, -0.10240217f, 0.13760373f, -0.21152091f, 0.20236096f, 0.04528665f, -0.13035434f, 
    -0.18007599f, -0.17069806f, -0.08235294f, -0.09021699f, -0.05342427f, -0.06232691f, 0.01444012f, 0.01008226f, 
    -0.03500507f, -0.08979575f, -0.08938935f, -0.61737567f, 0.10493298f, -0.00259925f, -0.10694742f, -0.03432500f, 
    0.16143353f, 0.00887210f, 0.18856350f, -0.19516802f, -0.07455659f, -0.04998303f, -0.03674265f, -0.04608228f, 
    -0.36289325f, 0.17914920f, 0.04077526f, -0.11234090f, 0.04450974f, 0.04682033f, -0.07706840f, -0.02887793f, 
    0.10308221f, -0.04213392f, 0.18739052f, -0.04584832f, 0.10861338f, 0.25937575f, -0.00029975f, 0.13615175f, 
    0.12667708f, 0.00711266f, -0.28004697f, -0.24323256f, -0.63574094f, 0.20301139f, 0.06916580f, -0.19696760f, 
    0.36023235f, -0.09007019f, 0.01374935f, -0.27529570f, -0.29891044f, -0.14272353f, -0.06897910f, -0.08934878f, 
    -0.04839900f, -0.03152220f, 0.04345725f, -0.12140034f, -0.05133782f, -0.07548613f, 0.04921071f, 0.08430722f, 
    0.19775490f, -0.02180876f, -0.11107317f, 0.11107275f, 0.15327066f, -0.05831759f, 0.08097623f, -0.17132597f, 
    0.19983034f, -0.60351092f, 0.10075895f, -0.29563949f, 0.23993091f, -0.42277744f, 0.16726318f, 0.23352161f, 
    -0.02167754f, -0.06674994f, -0.01556087f, 0.04315146f, -0.24542141f, -0.18769258f, -0.05385179f, 0.08609485f, 
    -0.03920149f, -0.07502323f, 0.34106204f, -0.16600752f, 0.05940012f, -0.07340436f, -0.20035821f, -0.02013676f, 
    -0.17414969f, 0.05890839f, -0.54410428f, 0.15689161f, -0.33830115f, -0.08314792f, -0.47408178f, -0.01375384f, 
    0.11809331f, 0.05248599f, 0.00726192f, -0.13512722f, 0.17778027f, -0.05557697f, -0.02753945f, 0.21832617f, 
    -0.22539860f, 0.07586037f, -0.19124450f, 0.00635262f, 0.02046513f, 0.01075537f, 0.15275098f, -0.65371031f, 
    -0.00055495f, -0.18519798f, 0.06502122f, -0.25815287f, -0.07549739f, 0.04176618f, 0.03793734f, -0.02448643f, 
    0.06181091f, 0.22989202f, -0.52815938f, -0.31324571f, -0.04186517f, -0.11698352f, -0.03282732f, 0.04190166f, 
    -0.00647618f, -0.17297110f, 0.05122147f, 0.12504318f, -0.01526588f, 0.12856160f, -0.12344734f, -0.23661762f, 
    -0.17033708f, -0.22218312f, -0.77250403f, 0.15502439f, 0.06829180f, 0.17772666f, 0.03816141f, -0.03456546f, 
    0.37489891f, 0.03374313f, -0.14569725f, -0.10026264f, -0.07066468f, 0.06170490f, -0.01167988f, -0.04770708f, 
    0.06001424f, 0.06800269f, 0.02959189f, -0.08387382f, 0.29474130f, 0.06533103f, -0.05405080f, -0.17691058f, 
    0.08973273f, 0.10730502f, 0.22543520f, -0.19557953f, -0.19784245f, -0.36734974f, -0.15316996f, -0.05024090f, 
    -0.16787452f, -0.06118118f, 0.03069505f, 0.25466111f, -0.20582025f, -0.18526681f, 0.04752059f, 0.04484982f, 
    0.03124489f, -0.10061252f, 0.06974155f, -0.07213793f, 0.07775891f, -0.14910179f, -0.03223237f, 0.08105339f, 
    -0.11434035f, 0.01868389f, -0.03076321f, 0.09084613f, 0.18863064f, 0.01060099f, 0.07858872f, -0.16770369f, 
    -0.01073541f, 0.19187896f, 0.01749823f, 0.02500817f, -0.39600033f, -0.02926818f, 0.08099694f, -0.05386635f, 
    0.04070836f, -0.04780940f, -0.02706911f, 0.00486261f, 0.26630357f, 0.12973167f, -0.08227785f, 0.02230123f, 
    -0.54695958f, 0.07657697f, -0.09297200f, -0.06407931f, 0.05078096f, -0.02717452f, 0.16030660f, -0.00883107f, 
    0.19813642f, 0.09419125f, 0.23235811f, 0.00946047f, 0.02023150f, -0.03313120f, -0.02729444f, 0.01994093f, 
    -0.20886636f, 0.18875048f, 0.05613744f, -0.48574567f, -0.08981126f, 0.07151137f, 0.00848843f, 0.04908989f, 
    0.18171011f, -0.38021061f, -0.33217916f, -0.60234016f, 0.19298193f, 0.06055704f, 0.07617645f, -0.51102477f, 
    -0.24468087f, -0.31345972f, 0.02358967f, -0.29905942f, -0.02184474f, -0.13285385f, 0.10339497f, -0.21685283f, 
    0.00414767f, -0.19302210f, -0.35261658f, -0.42219570f, 0.04110478f, -0.24471663f, 0.07497644f, -0.04688204f, 
    0.08273748f, -0.03303514f, 0.00187490f, 0.09507341f, -0.24813502f, 0.06597618f, 0.08553137f, 0.17909957f, 
    -0.06777950f, 0.09744821f, 0.35201588f, -0.38646838f, 0.01257742f, -0.04207301f, -0.08471762f, 0.01839297f, 
    0.36194462f, 0.15626343f, -0.25248259f, 0.04329411f, 0.05632890f, 0.04119629f, -0.05336921f, 0.01749468f, 
    0.27241030f, -0.05418388f, -0.00340229f, 0.04370014f, -0.28155032f, 0.04069454f, -0.06188022f, 0.16873421f, 
    0.09136640f, 0.24423814f, -0.13243161f, -0.49610519f, -0.29028562f, 0.10670674f, 0.03377528f, 0.05264487f, 
    -0.32834476f, -0.01448557f, 0.05968887f, -0.05738169f, -0.18689808f, -0.16449784f, -0.05540574f, 0.02380062f, 
    -0.41316688f, -0.31999040f, 0.02966293f, 0.01354393f, 0.27854961f, -0.41297412f, -0.02383758f, 0.01453591f, 
    0.11701163f, -0.05378845f, -0.02006700f, 0.13985406f, -0.42784888f, -0.14335957f, 0.12057757f, -0.30328298f, 
    -0.49211717f, 0.22736345f, -0.13277934f, 0.11859518f, 0.10493650f, -0.55747724f, -0.41574684f, -0.16375804f, 
    0.24968487f, -0.06440701f, 0.03695013f, 0.04999724f, 0.04003901f, -0.23609585f, -0.03136188f, 0.34631008f, 
    -0.26956594f, -0.14257015f, -0.02116243f, 0.24593627f, -0.13063584f, 0.03301299f, -0.14066122f, 0.01577700f, 
    -0.08576787f, 0.12857684f, -0.16856754f, 0.08788445f, 0.19245762f, -0.03565085f, -0.20567206f, 0.00268449f, 
    -0.31385812f, 0.06263520f, 0.06702293f, -0.05774261f, -0.16105025f, -0.00472880f, 0.00613651f, 0.01181051f, 
    -0.13532622f, -0.34641334f, -0.02612735f, 0.04809557f, 0.02392001f, -0.08452388f, -0.17416973f, -0.57404852f, 
    0.09989440f, 0.01032453f, -0.16632107f, -0.36276558f, -0.11013912f, -0.22448911f, 0.18712211f, -0.12236308f, 
    -0.16034549f, 0.17988484f, 0.05603982f, -0.02977304f, -0.03127095f, 0.21821964f, 0.07886795f, -0.01541894f, 
    -0.03240271f, 0.25313103f, 0.01578301f, -0.23564631f, 0.15210094f, 0.21398248f, 0.24017476f, 0.19305466f, 
    0.01517539f, -0.31364557f, 0.05140953f, 0.10099672f, 0.07437927f, 0.08521718f, -0.00568224f, 0.00984424f, 
    -0.33079064f, -0.26639694f, 0.33284935f, -0.14539419f, -0.03164088f, -0.00614320f, -0.21274151f, 0.00422064f, 
    0.14225551f, 0.06986680f, -0.03568431f, -0.07851916f, 0.00554422f, -0.14568515f, -0.25264448f, 0.08804436f, 
    0.07719121f, 0.02449943f, 0.30709791f, 0.29202724f, 0.21554247f, -0.05793382f, -0.30561689f, 0.08598714f, 
    -0.24004453f, 0.04016131f, 0.01559834f, -0.14293152f, -0.06977316f, 0.36530533f, -0.00824034f, -0.03009547f, 
    0.35120302f, 0.03249700f, 0.00078911f, -0.11128244f, -0.64897013f, 0.02779875f, 0.01121234f, -0.01015579f, 
    -0.20007181f, -0.21017812f, -0.04773410f, -0.39492276f, 0.01092884f, -0.10014547f, 0.16823271f, 0.00595834f, 
    0.05814589f, -0.29549631f, -0.10071354f, -0.51198173f, -0.38710204f, -0.16588788f, 0.25024307f, 0.14302222f, 
    -0.43268979f, 0.00569308f, 0.08655102f, -0.05364202f, -0.29291901f, -0.10618374f, -0.05817634f, -0.32750541f, 
    0.09065035f, 0.22441474f, -0.19222990f, 0.04113651f, 0.19521110f, -0.07855631f, 0.18593213f, 0.01676518f, 
    0.16246887f, 0.21166915f, 0.22666234f, 0.06512532f, -0.02990557f, 0.02233692f, -0.14126237f, -0.01002591f, 
    0.33718911f, -0.31996068f, 0.06267350f, 0.05333599f, 0.19855833f, -0.01350429f, -0.03035365f, 0.12008043f, 
    0.22780888f, 0.13889949f, 0.10007196f, -0.37083086f, 0.04375719f, -0.00958727f, 0.04154607f, 0.09454533f, 
    -0.18180291f, -0.27286375f, 0.10051302f, 0.02853833f, 0.05117301f, -0.16539150f, -0.01056370f, -0.40903124f, 
    0.25307253f, -0.14409672f, -0.00784713f, 0.11477418f, -0.02908414f, -0.08942198f, -0.02423958f, 0.05426610f, 
    0.04863119f, 0.10345809f, 0.07605396f, 0.27475429f, -0.15662298f, -0.07913880f, 0.05288351f, -0.57850450f, 
    0.05423771f, -0.00482111f, -0.12872601f, 0.12167297f, -0.04815333f, 0.01593872f, -0.04787060f, -0.00983350f, 
    0.01454420f, 0.09048281f, -0.41120732f, -0.06513955f, -0.03096755f, -0.00576099f, -0.39366642f, 0.05900773f, 
    0.09700304f, -0.00814774f, -0.28197983f, -0.04251855f, -0.24903046f, 0.31457916f, 0.22599365f, 0.21244204f, 
    -0.06740899f, -0.24120699f, -0.22204462f, -0.00785692f, 0.16089654f, -0.00115211f, 0.22239143f, 0.14287736f, 
    0.22807916f, 0.01136300f, -0.04515515f, -0.25723234f, 0.09195086f, 0.11569879f, -0.10225962f, 0.05543113f, 
    -0.24650478f, 0.30916640f, 0.01544289f, 0.23643771f, -0.02458900f, 0.18974909f, 0.09604312f, -0.05060606f, 
    -0.26103088f, 0.10967644f, -0.09896114f, -0.47479638f, -0.29887429f, -0.53964067f, 0.18331848f, 0.26400849f, 
    -0.14172705f, 0.07635511f, -0.36007652f, 0.07384028f, 0.05166502f, -0.47327849f, 0.13178487f, 0.31512144f, 
    -0.41954568f, 0.06835917f, 0.01361575f, 0.03861633f, -0.05594067f, -0.12518141f, 0.01913746f, -0.22380251f, 
    -0.27325529f, -0.06263629f, 0.39747095f, -0.19752066f, -0.10408724f, -0.02911371f, -0.52015918f, -0.00642951f, 
    0.10337906f, -0.18418980f, 0.22024851f, -0.39097604f, -0.06261760f, -0.06376150f, 0.09756847f, 0.01334394f, 
    -0.46886548f, 0.26633695f, 0.02869631f, 0.21590124f, -0.24338703f, -0.00754187f, -0.09105890f, 0.26930362f, 
    -0.40287456f, 0.05737112f, -0.53756207f, 0.06996869f, -0.41458049f, 0.05066736f, -0.13361831f, -0.01781880f, 
    -0.57187903f, 0.23304585f, -0.61044997f, 0.18584926f, 0.05769038f, -0.64683962f, -0.18414371f, 0.19050808f, 
    0.03020405f, 0.10280618f, 0.10430102f, -0.21361226f, -0.01409831f, 0.26245463f, 0.04122926f, 0.04451173f, 
    -0.02928090f, 0.17981641f, -0.04580594f, -0.25847799f, -0.04104885f, -0.35887429f, 0.21101128f, 0.04967579f, 
    -0.35035557f, -0.59416592f, -0.03226468f, -0.04411986f, 0.02807142f, 0.20959808f, 0.06673993f, 0.06515221f, 
    -0.33249930f, -0.27435556f, 0.25562006f, 0.09768046f, 0.02885545f, -0.06887848f, 0.07926237f, -0.06876867f, 
    0.05918577f, -0.05217623f, -0.11822109f, -0.05471307f, 0.14675824f, 0.02458048f, -0.17531145f, 0.16613925f, 
    -0.06491783f, -0.12108961f, 0.24215557f, -0.62219644f, -0.02889559f, 0.00555642f, 0.22296695f, 0.09676397f, 
    0.09141891f, 0.04484920f, -0.06513388f, -0.10520838f, -0.16411948f, 0.04988045f, 0.00080101f, -0.06153933f, 
    -0.35428360f, 0.28745639f, 0.06177629f, -0.29222864f, -0.07094352f, -0.15893291f, 0.02677472f, -0.08287993f, 
    -0.01499300f, -0.06579376f, 0.02370466f, 0.19987284f, -0.62373894f, 0.14320226f, 0.03912658f, -0.03929772f, 
    -0.54256594f, -0.30397207f, -0.12392045f, 0.29362509f, 0.32155812f, -0.10174883f, -0.23898612f, -0.26411760f, 
    -0.08301737f, 0.02443847f, -0.03395880f, 0.01317924f, -0.45238036f, 0.25632638f, 0.04663146f, 0.26330629f, 
    0.34763950f, 0.06300543f, 0.16291684f, 0.29721329f, 0.16981785f, -0.00259828f, 0.18667208f, 0.00873584f, 
    0.13503465f, -0.02127596f, -0.21682008f, 0.08889297f, -0.00763310f, 0.00664125f, -0.26723567f, 0.04990074f, 
    0.00666156f, 0.09906830f, 0.00245731f, 0.20001383f, -0.48641941f, -0.07712361f, -0.03923590f, -0.19558038f, 
    -0.20898674f, 0.12807983f, -0.14758369f, 0.10575985f, 0.31579283f, 0.08708137f, 0.17205977f, -0.26822281f, 
    0.29154113f, 0.13698412f, -0.00861000f, 0.29763290f, -0.05019646f, 0.16739069f, -0.25717461f, 0.42389861f, 
    -0.56760222f, 0.15467787f, -0.00148572f, -0.28795251f, -0.02723565f, -0.52365994f, -0.04122412f, -0.03062208f, 
    0.01293230f, 0.12233362f, -0.04008352f, 0.10086949f, -0.00654974f, 0.04550830f, 0.10300979f, 0.06197070f, 
    -0.10643029f, -0.05238501f, -0.36013070f, 0.25310916f, -0.08355324f, 0.00164145f, -0.08961005f, -0.08620607f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.05418035f, 0.02001206f, 0.07462538f, -0.02080501f, 0.03987188f, -0.01798865f, 0.00225357f, -0.10102106f, 
    -0.00566551f, -0.02609188f, 0.00961889f, -0.01704722f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
