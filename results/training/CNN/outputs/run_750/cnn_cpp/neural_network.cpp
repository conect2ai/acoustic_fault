#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.32751885f, -0.41752693f, -0.79928470f, 0.19241853f, -0.27912742f, -0.61222434f, 0.36475563f, 0.34148884f, 
    0.17513745f, -0.38381553f, 0.17841183f, -0.11708687f, -0.06695300f, 0.03940316f, 0.02016662f, 0.22008756f, 
    -0.05272315f, -0.23636135f, -0.16800074f, -0.06475003f, 0.17974769f, 0.21941333f, 0.28571305f, -0.07837196f, 
    0.01402079f, -0.23257449f, -0.64518625f, -0.54942101f, 0.06444463f, 0.37673858f, 0.32625774f, 0.25514224f, 
    0.16825292f, -0.18492211f, -0.36894855f, 0.15373966f, -0.14775851f, -0.42572486f, 0.15427947f, 0.16583537f, 
    -0.02272519f, -0.54314089f, -0.12025358f, -0.15122770f, 0.18530190f, -0.16952921f, 0.04895756f, -0.00232079f, 
    0.21757352f, -0.06076681f, 0.47880530f, 0.13020359f, -0.13988692f, 0.08987800f, 0.10706443f, -0.13746834f, 
    -0.66585249f, 0.11541647f, 0.35552213f, -0.30681223f, -0.49986756f, -0.21578214f, 0.06254753f, -0.00057341f, 
    -0.11218103f, 0.08384255f, -0.09733337f, -0.22181456f, -0.22410794f, -0.06525561f, 0.41977817f, -0.05261056f, 
    0.17003071f, -0.20265383f, -0.34913388f, 0.61514002f, 0.07616166f, -0.52496594f, 0.15941553f, 0.08468730f, 
    -0.27903599f, 0.07326255f, 0.35814184f, 0.53071481f, -0.29274195f, -0.26081100f, -0.19253001f, 0.23652889f, 
    -0.36874077f, -0.20606549f, -0.17523009f, -0.06864474f, 0.01027999f, 0.00775957f, -0.09822405f, 0.22137834f, 
    -0.03745231f, 0.11115320f, 0.21485384f, -0.17981154f, -0.36365855f, -0.47490004f, -0.50254619f, -0.31625441f, 
    -0.18694873f, -0.29596698f, 0.43515241f, 0.56922275f, -0.18680288f, 0.30200583f, 0.31348750f, 0.07856295f, 
    -0.02195342f, 0.00118444f, -0.00153067f, -0.20488316f, 0.07957370f, -0.09230280f, -0.24084063f, 0.26038972f, 
    -0.03333408f, 0.07177224f, -0.28338090f, 0.25016704f, -0.25694504f, -0.39471322f, -0.30116770f, -0.27447823f, 
    -0.24136694f, -0.15517005f, 0.17938221f, 0.56612718f, 0.41067675f, 0.26449159f, 0.49932534f, -0.17479654f, 
    -0.27038151f, 0.15381727f, -0.27190974f, 0.04344314f, 0.18848543f, -0.04853597f, 0.10527927f, 0.10940558f, 
    -0.31415585f, 0.11883388f, -0.25042433f, 0.15078408f, 0.03964073f, 0.12980230f, 0.46214953f, -0.31809059f, 
    -0.24384876f, -0.30949682f, 0.13742171f, 0.51128781f, 0.51643836f, 0.37372726f, 0.37346053f, 0.21538128f, 
    -0.36108869f, 0.15117662f, -0.27500889f, -0.05483092f, 0.12772603f, -0.15011761f, -0.17222515f, -0.18314885f, 
    -0.03567806f, 0.05154922f, -0.02509246f, -0.02244592f, 0.11592885f, 0.15033181f, -0.09182774f, 0.17126207f, 
    0.13002001f, -0.49334612f, -0.32394660f, -0.16190642f, 0.18362682f, 0.03706392f, 0.16294171f, 0.30469745f, 
    0.38669327f, 0.18421181f, -0.13046491f, -0.25835419f, -0.38283077f, 0.03470504f, 0.09621218f, 0.06563375f, 
    0.33308619f, 0.13485847f, 0.34366748f, -0.23173445f, -0.07842311f, -0.13920748f, 0.13078098f, -0.22522812f, 
    0.65774906f, 0.06662507f, -0.61381483f, -0.56534982f, -0.14469063f, 0.42033082f, 0.47393352f, -0.28242362f, 
    -0.36304545f, 0.05386629f, -0.13843928f, 0.07610814f, -0.06896254f, 0.03441422f, -0.35200348f, -0.17286095f, 
    0.07513115f, 0.01968225f, 0.23007520f, -0.03762890f, -0.06563161f, 0.08385491f, -0.07550506f, -0.29066345f, 
    0.20724414f, -0.58803266f, -0.20215558f, 0.10174207f, 0.30165479f, -0.21119431f, 0.21985935f, 0.58048862f, 
    0.07208326f, 0.29907104f, 0.26660377f, -0.24011098f, -0.00301468f, -0.07445496f, 0.23654169f, -0.15695740f, 
    0.36330697f, -0.14239949f, 0.00213569f, -0.21697241f, -0.01016032f, -0.09841093f, -0.04516301f, -0.13655201f, 
    -0.05498904f, -0.28981611f, -0.17682472f, 0.40450391f, 0.51561821f, 0.63576382f, 0.56687021f, -0.08596953f, 
    0.12000166f, 0.05335326f, 0.32727990f, 0.28857794f, -0.15740950f, -0.24041060f, 0.02723114f, -0.17685069f, 
    -0.18368988f, 0.07871372f, 0.14380495f, -0.05116411f, 0.14642653f, 0.09594665f, 0.21491627f, -0.15640140f, 
    0.05380223f, -0.08417874f, 0.00203681f, -0.90423292f, 0.44668430f, 0.00642724f, -0.12430455f, 0.16774523f, 
    0.15359406f, 0.56798732f, 0.08707300f, 0.28375629f, 0.47239304f, -0.26993081f, -0.09452840f, -0.22336332f, 
    -0.34655440f, -0.04201683f, 0.06498057f, 0.12757204f, -0.20025164f, 0.05598119f, -0.10383862f, 0.01653408f, 
    0.29348567f, 0.24908857f, 0.04108987f, -0.15200968f, 0.60933053f, -0.09380078f, 0.30518529f, 0.12503678f, 
    0.37978762f, -0.59068501f, -0.29672697f, -0.36232612f, -0.43814102f, 0.04885094f, 0.11422022f, 0.31977269f, 
    0.08098669f, 0.36205173f, -0.27643839f, -0.07867356f, -0.28828579f, -0.22952560f, -0.20021306f, -0.43503293f, 
    0.03515619f, 0.10363403f, 0.26638716f, 0.10302483f, 0.01691449f, 0.12902540f, -0.07329591f, 0.07673011f, 
    0.76940989f, -0.27425274f, 0.24750800f, -0.29238266f, 0.49150613f, 0.20202263f, 0.30936208f, -0.00930785f, 
    -0.22819367f, 0.24165671f, -0.32733345f, 0.03587869f, -0.24196017f, -0.09912190f, -0.27380714f, 0.08548458f, 
    -0.14833374f, 0.23071326f, 0.04658567f, -0.19697383f, -0.22674213f, -0.13499774f, -0.11099035f, -0.20951264f, 
    -0.15519588f, -0.22115016f, -0.49735877f, 0.39649433f, 0.54430312f, -0.11271802f, -0.15114862f, 0.29740065f, 
    0.08836447f, 0.06157201f, -0.21623139f, -0.06603450f, -0.21614608f, -0.20435955f, 0.07362612f, 0.30996388f, 
    0.23609336f, -0.25668356f, -0.06963382f, 0.11789594f, 0.07505339f, -0.19310534f, 0.22543174f, 0.05585412f, 
    0.54600114f, 0.11659153f, 0.09916812f, 0.13184339f, 0.04702832f, 0.44383761f, 0.32418299f, -0.48448607f, 
    0.52857959f, -0.25092736f, -0.16167420f, 0.05600533f, -0.26672679f, -0.12275845f, -0.29261163f, -0.19264342f, 
    0.11599783f, 0.02629680f, -0.24109314f, -0.08757272f, -0.15488560f, -0.03708145f, 0.06066285f, 0.15645213f, 
    0.07341318f, -0.53812152f, -0.10005074f, -0.11986661f, -0.20591447f, -0.00308195f, -0.38766229f, 0.23355953f, 
    0.41897213f, -0.32516259f, -0.23571789f, 0.07669955f, -0.13949929f, -0.32357427f, -0.30436268f, 0.18921918f, 
    0.26356247f, 0.26388231f, 0.04996977f, -0.19565299f, -0.06893700f, 0.19335493f, -0.29734868f, 0.35404408f, 
    -0.35389471f, -0.10048545f, 0.55717677f, 0.50133258f, 0.28375998f, -0.65002394f, -0.30244234f, -0.36479381f, 
    -0.22533405f, -0.36447111f, 0.15295009f, 0.21550839f, 0.00059723f, -0.39905697f, 0.15095589f, -0.12399033f, 
    0.08300485f, -0.20892169f, 0.28068227f, -0.28892368f, -0.23158555f, 0.19029711f, -0.14919734f, -0.22238781f, 
    -0.31542638f, -0.06216589f, 0.43541756f, -0.10247723f, -0.45659393f, -0.25785956f, 0.21145581f, 0.46224979f, 
    0.20101877f, -0.33113813f, 0.03286523f, 0.30058515f, -0.22484419f, 0.28792253f, -0.24610318f, 0.05989353f, 
    0.11833023f, 0.13405395f, 0.06845774f, -0.26311162f, -0.08661444f, 0.02029650f, -0.07983646f, -0.11876239f, 
    0.01107441f, -0.05991800f, -0.01678314f, 0.63333547f, 0.47796747f, -0.33402342f, 0.07959989f, -0.18763511f, 
    0.06094436f, 0.33268887f, -0.26204625f, 0.10125255f, 0.29166099f, 0.26489717f, -0.05046235f, 0.09113136f, 
    0.06028076f, -0.14350982f, -0.12613435f, -0.12283783f, 0.17888585f, -0.25533524f, 0.14048517f, -0.24240161f, 
    -0.30983630f, 0.35865423f, -0.12732741f, 0.11915465f, 0.51042861f, 0.37096873f, 0.34304518f, 0.26484454f, 
    0.62096035f, -0.52566630f, 0.12430794f, -0.25156373f, 0.07141348f, -0.54226929f, 0.08972692f, 0.10814424f, 
    -0.11734967f, -0.21870486f, 0.19198599f, -0.11000527f, 0.04602167f, -0.18712008f, -0.07385997f, 0.00100244f, 
    -0.33075058f, 0.12612952f, 0.11393896f, 0.01242904f, -0.11042260f, 0.79106700f, 0.16848992f, 0.08154684f, 
    0.51257342f, 0.47760445f, 0.05187524f, -0.23495559f, -0.17307580f, -0.36739993f, -0.15994531f, -0.10910051f, 
    0.21278754f, -0.03182416f, 0.09253550f, 0.00803464f, 0.23726353f, 0.06413676f, 0.11282119f, 0.27494961f, 
    0.05219601f, 0.26351187f, 0.09816085f, -0.04855889f, -0.12993707f, 0.18603575f, 0.10847675f, 0.60087442f, 
    -0.13060600f, 0.36596295f, -0.72783393f, -0.21918057f, -0.41708058f, 0.05640749f, -0.37477893f, -0.28841078f, 
    -0.22045077f, 0.20659527f, -0.15751781f, 0.31674734f, -0.15083015f, 0.12578481f, 0.08269496f, 0.01343696f, 
    0.06186271f, 0.00542960f, -0.17897142f, -0.05306826f, -0.15234926f, -0.04507057f, -0.04551977f, 0.48013091f, 
    0.11134835f, -0.23752607f, -0.17917790f, 0.02407065f, 0.47736296f, -0.38752258f, -0.38613740f, 0.21300386f, 
    -0.22550991f, 0.25846294f, 0.48152891f, 0.21135156f, 0.06389075f, -0.08689898f, -0.08370544f, -0.39247224f, 
    0.31492609f, -0.12740816f, 0.05430485f, 0.27269155f, 0.27611974f, -0.13433179f, 0.12504102f, -0.00811612f, 
    0.06024470f, -0.05161006f, 0.35262644f, 0.19244033f, 0.26998943f, 0.36806336f, -0.23316939f, 0.25763673f, 
    0.15311162f, -0.15102276f, -0.11083359f, -0.28680870f, -0.27784327f, -0.37937355f, 0.02678320f, -0.21193229f, 
    -0.25794610f, -0.08866251f, -0.26354319f, 0.03906168f, 0.04031966f, 0.45574701f, 0.40263531f, -0.03027650f, 
    0.36000565f, 0.67319852f, 0.48104864f, 0.32912371f, 0.17873432f, -0.31915820f, -0.30973187f, 0.32583201f, 
    0.16491191f, 0.37424499f, 0.32476196f, -0.22474307f, 0.08546127f, -0.05833177f, -0.36242983f, 0.11801148f, 
    0.13493674f, 0.22465999f, -0.08810820f, 0.07059726f, 0.20918092f, -0.20238048f, -0.25937921f, 0.10933824f, 
    -0.07788713f, -0.04005570f, -0.51586127f, -0.34290186f, -0.03326999f, -0.22796848f, 0.42606723f, -0.54566318f, 
    -0.14519633f, 0.03389930f, -0.42234129f, -0.53352952f, 0.01181949f, 0.07754829f, 0.03923154f, 0.34547594f, 
    0.15843488f, 0.17360270f, 0.10009722f, 0.10110102f, -0.08542998f, 0.14272307f, -0.17045696f, -0.24572057f, 
    0.08971246f, 0.24259062f, 0.32010666f, -0.42540589f, -0.36441508f, 0.59236419f, 0.54977238f, -0.53471357f, 
    -0.28501692f, -0.52507722f, -0.27410072f, 0.23418105f, -0.15317036f, 0.43361911f, 0.40767878f, 0.04690442f, 
    -0.05814998f, -0.31728002f, -0.01853043f, 0.16243929f, 0.23425518f, 0.23671341f, -0.07604845f, 0.07370969f, 
    0.00145898f, -0.13404997f, -0.05113713f, 0.07773278f, 0.38469598f, 0.62865889f, 0.35494190f, 0.43342173f, 
    -0.56576711f, -0.28214759f, -0.05191273f, -0.04194412f, 0.08424092f, 0.50666863f, 0.38026658f, -0.12650843f, 
    -0.07919009f, 0.12934260f, -0.24229752f, 0.01453179f, -0.00870831f, 0.14498851f, -0.16717817f, -0.09639013f, 
    0.27718103f, 0.21694492f, -0.09915973f, 0.24617825f, 0.05231503f, -0.20369574f, -0.59265840f, -0.52043474f, 
    -0.33130577f, -0.11997399f, -0.10677846f, 0.45890906f, 0.09100310f, 0.35581267f, 0.31998801f, 0.00111388f, 
    0.08374164f, 0.09385061f, -0.11857154f, -0.28747767f, -0.12591174f, 0.03126616f, 0.13547744f, -0.12461796f, 
    -0.15937512f, -0.21439834f, 0.09468216f, -0.05342473f, -0.23329581f, -0.12844078f, -0.47693381f, -0.40772921f, 
    -0.43553615f, -0.12136529f, -0.19441672f, 0.34617060f, 0.38174573f, 0.20250857f, -0.09541868f, 0.30991933f, 
    -0.23095125f, -0.12704639f, 0.23887916f, 0.21254162f, 0.13841528f, -0.21765959f, 0.04476178f, 0.12762627f, 
    0.12446715f, -0.05888850f, 0.38010272f, -0.09256031f, 0.18624809f, -0.19173834f, 0.08385696f, -0.27354217f, 
    -0.42348307f, 0.60944498f, 0.06957794f, -0.18311280f, 0.60918838f, 0.39207035f, 0.41406411f, -0.03102116f, 
    -0.51755619f, -0.20733808f, 0.05073956f, 0.01717992f, -0.16124387f, -0.03150450f, -0.31532362f, 0.25989074f, 
    -0.03495601f, -0.05421592f, 0.00212188f, -0.00366750f, 0.10483077f, 0.12791693f, 0.00041200f, 0.08763169f, 
    0.67175508f, -0.14770238f, -0.01784514f, 0.09934507f, -0.31541097f, 0.24742675f, -0.24027157f, 0.18273759f, 
    0.16959104f, -0.28160900f, 0.22528143f, 0.44427478f, -0.02755184f, 0.06229649f, 0.12052257f, 0.24215201f, 
    0.05896935f, -0.39988938f, 0.11080635f, 0.42255723f, -0.29551563f, -0.24872096f, -0.03905620f, 0.12878092f, 
    0.09559498f, -0.56982923f, 0.58057177f, -0.27690476f, -0.41554192f, 0.13364042f, -0.36609560f, 0.47080392f, 
    0.00260445f, 0.03638586f, -0.06630127f, -0.13917051f, -0.14596015f, 0.07185435f, -0.35426790f, 0.06283353f, 
    0.27240086f, 0.03202521f, 0.16140902f, 0.22428879f, -0.15028791f, 0.28639102f, 0.18663159f, -0.32691231f, 
    -0.04372493f, 0.33258641f, 0.16625172f, -0.58214414f, -0.49919471f, 0.24999525f, 0.47424993f, -0.55108815f, 
    -0.59231752f, -0.11072011f, -0.17248474f, 0.26188022f, 0.18684675f, 0.01171594f, -0.12810765f, 0.02116176f, 
    0.13960607f, 0.15707561f, 0.27377370f, 0.15304413f, 0.23088570f, 0.12478565f, -0.08863674f, -0.19378446f, 
    -0.09128504f, -0.11767435f, -0.28921425f, -0.45564985f, 0.12934844f, 0.31551993f, -0.12458470f, 0.10389990f, 
    -0.29759589f, 0.05606982f, -0.36270860f, -0.22479117f, -0.18917565f, -0.18575864f, -0.21284530f, -0.20991381f, 
    -0.20184307f, -0.33253157f, -0.24813706f, -0.14398465f, 0.34302172f, -0.32758957f, -0.39883745f, -0.02226934f, 
    -0.21041261f, -0.01348092f, -0.00799206f, -0.13479666f, -0.20746574f, -0.28545406f, -0.59857833f, -0.29668581f, 
    -0.24881366f, 0.24785087f, 0.14163493f, 0.14065504f, 0.36651912f, 0.38078192f, 0.22195424f, -0.08195595f, 
    0.05121160f, 0.10711132f, 0.06988169f, 0.04736974f, -0.04195748f, 0.09415065f, 0.23508064f, -0.10061482f, 
    0.12109116f, -0.01441966f, -0.17730060f, 0.18237454f, 0.23429301f, -0.72346449f, 0.05653640f, 0.46780023f, 
    -0.47532180f, -0.05663575f, 0.47294295f, 0.25582844f, -0.32854524f, 0.00639682f, -0.31493762f, 0.28222775f, 
    0.02153054f, -0.12119386f, 0.17880596f, -0.04808736f, -0.25525373f, -0.28872460f, -0.14021641f, -0.34126678f, 
    -0.15211435f, -0.06572346f, 0.32434320f, 0.26806960f, 0.12505880f, -0.01557495f, -0.25608075f, -0.43674356f, 
    -0.36940902f, -0.55895245f, -0.26980874f, 0.30125847f, -0.28338405f, -0.00150727f, 0.26712638f, -0.13235702f, 
    -0.41723707f, -0.18953910f, 0.15190542f, -0.03385269f, -0.15802619f, 0.23495333f, 0.12715551f, 0.16853110f, 
    0.06579683f, 0.26238516f, -0.08801669f, 0.12409686f, -0.19659850f, 0.01247171f, 0.29526916f, -0.18031131f, 
    -0.60104251f, 0.58548295f, 0.37656873f, 0.09740467f, 0.48106825f, 0.25512394f, -0.04302020f, 0.00086840f, 
    0.31610098f, 0.06459805f, -0.00079290f, -0.04285615f, 0.01428026f, -0.20784636f, -0.04737354f, -0.26968879f, 
    -0.20622844f, 0.14480188f, -0.21324994f, -0.34832358f, -0.18361896f, 0.05031274f, 0.08098438f, -0.20229109f, 
    -0.28503150f, 0.06837253f, -0.04305308f, -0.63604790f, 0.16672084f, 0.52131104f, -0.20157978f, 0.38293502f, 
    0.31290826f, -0.23825601f, 0.37451741f, 0.00302253f, 0.06533139f, -0.27519119f, 0.00438023f, 0.38049203f, 
    -0.00932060f, 0.13853292f, 0.00328211f, 0.15071954f, 0.01262899f, -0.16885115f, -0.07726992f, 0.08108432f, 
    -0.05034700f, 0.53611779f, -0.21192463f, -0.05468150f, 0.68309993f, 0.44719037f, 0.33431777f, 0.25387195f, 
    0.28237510f, 0.06530415f, 0.04153368f, -0.32753232f, -0.11276582f, -0.03289267f, -0.17890173f, -0.14775923f, 
    -0.26491681f, -0.12217151f, 0.21761179f, -0.12752503f, -0.19070679f, 0.37150207f, -0.22869265f, -0.07699114f, 
    -0.10951712f, -0.14091706f, -0.12918484f, 0.11934332f, -0.01658097f, -0.63560879f, 0.10077480f, -0.15804869f, 
    -0.41192824f, 0.18033990f, 0.13965723f, -0.53569442f, -0.18249224f, -0.12260333f, -0.10917383f, -0.26747361f, 
    0.14259961f, 0.05780259f, 0.00701542f, -0.04707721f, -0.13763887f, -0.05999498f, 0.20921817f, 0.12879826f, 
    0.22759368f, 0.25913510f, 0.11692812f, -0.52729201f, -0.20186661f, -0.32065785f, -0.03252127f, 0.03773678f, 
    -0.30440897f, 0.40716049f, 0.49118385f, -0.04326217f, 0.40665194f, -0.45261601f, 0.28829408f, 0.07235238f, 
    -0.03730129f, -0.12929758f, -0.01847525f, 0.00383209f, 0.03636845f, 0.36176938f, -0.28719848f, -0.25964791f, 
    -0.20106055f, -0.22745165f, -0.28121459f, 0.06994509f, 0.08838949f, 0.27872461f, -0.33210060f, 0.52495670f, 
    -0.15991721f, -0.23416124f, -0.55314940f, 0.23727857f, -0.36986092f, -0.27783874f, -0.15506952f, -0.19107005f, 
    -0.12212476f, 0.02935693f, -0.33861825f, -0.01011859f, 0.18473625f, -0.19100025f, -0.22898591f, -0.08646381f, 
    -0.11311627f, 0.09226668f, 0.02403900f, -0.10950267f, -0.29549253f, 0.40894616f, 0.34146670f, 0.35576043f, 
    0.07416399f, 0.30534735f, 0.33275446f, -0.14307962f, -0.40567741f, -0.17676154f, -0.44877857f, 0.04388317f, 
    -0.19390720f, -0.08666860f, -0.18204682f, -0.29982281f, 0.19233112f, 0.25220361f, -0.14412765f, -0.14566793f, 
    0.11682595f, 0.05281482f, -0.03750748f, 0.11165646f, 0.05142234f, 0.08320804f, -0.05219344f, 0.31326434f, 
    0.14941393f, -0.03783852f, 0.31659356f, 0.42330608f, 0.13956548f, -0.24136943f, 0.05594444f, -0.33415449f, 
    0.39767665f, 0.03059733f, 0.40529409f, 0.04877497f, -0.29440546f, -0.31580201f, 0.00282707f, -0.31755257f, 
    -0.03454553f, -0.17771867f, 0.30605385f, -0.32920313f, 0.19812867f, 0.06555205f, 0.17838171f, -0.20138723f, 
    -0.02849183f, -0.40203118f, -0.41455045f, -0.08705591f, 0.07906415f, -0.53883475f, -0.26974210f, -0.28900388f, 
    -0.38305128f, 0.11646089f, 0.23765245f, 0.13223737f, 0.16096744f, -0.12686290f, 0.35226128f, -0.02407049f, 
    -0.07450525f, 0.14084302f, -0.20805216f, -0.04086793f, 0.33677858f, 0.17678843f, -0.24759990f, 0.43579096f, 
    -0.47182685f, -0.03439940f, -0.67320698f, 0.66475588f, -0.13622341f, 0.18365683f, 0.23628141f, -0.46913025f, 
    0.54463160f, -0.05459296f, 0.19219339f, 0.10190216f, -0.05851936f, -0.04690605f, -0.26303613f, -0.02025588f, 
    0.04225320f, 0.21472298f, -0.05758738f, -0.25272945f, -0.02749741f, 0.00363320f, -0.24034472f, 0.01652750f, 
    0.00086839f, 0.50315195f, -0.31021595f, -0.46567968f, 0.45182222f, 0.16268618f, -0.46657717f, -0.37832040f, 
    -0.08175666f, 0.18694593f, 0.19315161f, 0.15853047f, -0.01602020f, 0.19807516f, -0.05990627f, 0.13002720f, 
    0.12632306f, 0.20666157f, -0.00385939f, -0.14824805f, -0.05823897f, -0.07926702f, 0.10232203f, 0.12450711f, 
    0.36906877f, 0.28056404f, 0.11206492f, 0.48680088f, 0.05223089f, 0.48856601f, 0.43935028f, 0.63468826f, 
    0.03973161f, -0.45009026f, -0.16170411f, -0.15602744f, 0.02770300f, 0.25964203f, 0.04154561f, 0.17939822f, 
    -0.34037143f, 0.16776609f, -0.03409678f, 0.05311017f, -0.01464630f, -0.25098854f, 0.00097561f, 0.07504323f, 
    0.00002323f, -0.12782101f, -0.00679216f, -0.07763017f, 0.17046504f, 0.26575339f, -0.33384919f, -0.29576209f, 
    -0.37088636f, -0.47794923f, -0.24932483f, -0.71527410f, 0.01188491f, 0.22615223f, 0.31848222f, 0.23099555f, 
    0.15193747f, -0.21774609f, -0.40287724f, -0.14731248f, -0.01584239f, -0.02849210f, 0.45272380f, 0.22816361f, 
    -0.02380038f, -0.06436881f, 0.10107677f, 0.26180252f, 0.05812782f, 0.49506712f, 0.33533141f, 0.48052475f, 
    -0.02664317f, 0.13843574f, -0.16438006f, -0.65082324f, -0.34682429f, -0.05892959f, -0.07430843f, 0.17927852f, 
    0.21957095f, 0.44525388f, -0.08559781f, 0.10322692f, 0.04684487f, 0.33261618f, 0.09268249f, -0.04144166f, 
    -0.18764839f, -0.15656249f, -0.20127453f, -0.03429148f, -0.06429995f, 0.25790188f, 0.50448281f, -0.35012245f, 
    0.33137229f, 0.07470860f, 0.54439437f, 0.13969634f, 0.22027113f, 0.01313525f, -0.15035941f, -0.37000120f, 
    -0.35340196f, -0.28270477f, -0.20489119f, -0.07005563f, -0.09083265f, 0.17745228f, -0.25681427f, 0.01506420f, 
    -0.14853449f, -0.40220779f, -0.03998384f, -0.26676810f, 0.02050058f, -0.04491545f, -0.15063734f, -0.43242079f, 
    -0.06575530f, 0.80900389f, 0.35230616f, -0.07081413f, 0.05648092f, -0.59599864f, -0.10520270f, 0.14521569f, 
    -0.15822332f, 0.13293114f, 0.17958920f, 0.11674405f, -0.03525513f, -0.27310845f, 0.08936550f, -0.16892409f, 
    0.09155191f, -0.17235337f, -0.08046773f, 0.09522552f, -0.29495880f, 0.18063450f, -0.00216567f, 0.40389425f, 
    0.33093134f, -0.05994588f, 0.06700562f, 0.41997704f, -0.23963703f, 0.27871200f, 0.31526050f, 0.26979411f, 
    0.18552324f, 0.26990128f, 0.33776414f, -0.24460660f, -0.27881652f, 0.15913624f, -0.30095574f, -0.38585663f, 
    -0.29156998f, -0.16413598f, 0.01930607f, 0.32441229f, -0.01088214f, -0.04591188f, 0.17573360f, -0.13064511f, 
    -0.12098275f, 0.12545490f, 0.41982719f, 0.45819482f, 0.31726620f, 0.11611740f, -0.24473861f, 0.09231105f, 
    -0.08186336f, -0.25862697f, 0.35420981f, -0.25849760f, 0.15754701f, 0.25632823f, -0.08099957f, 0.30588335f, 
    0.13771811f, -0.13266703f, 0.35774100f, 0.24124976f, -0.00479346f, -0.12642641f, 0.14216143f, 0.24828942f, 
    -0.21204709f, 0.12283292f, 0.51365954f, -0.01918563f, -0.32901651f, 0.65735728f, 0.28243589f, -0.65149385f, 
    -0.54052693f, -0.28305867f, -0.19921587f, -0.19776623f, 0.06998802f, 0.04254298f, 0.31790927f, -0.05078119f, 
    -0.13590868f, -0.04602068f, -0.23319918f, 0.03999700f, 0.31666592f, 0.12808481f, 0.23528682f, 0.00253902f, 
    -0.21585807f, -0.03534492f, 0.33290458f, 0.41517708f, 0.34892544f, 0.42155868f, 0.66964853f, -0.13023981f, 
    0.01196786f, 0.19052052f, -0.27229342f, 0.10127594f, 0.11573280f, -0.16847163f, 0.17223392f, 0.10457386f, 
    0.21007355f, -0.26389930f, -0.00193189f, 0.21398886f, -0.05975701f, 0.27701798f, 0.03953392f, 0.08388276f, 
    -0.17722066f, 0.38178134f, 0.03405218f, 0.38481203f, 0.50016224f, 0.40173087f, 0.12063714f, 0.38284314f, 
    0.30294403f, 0.35609850f, -0.22168611f, -0.21192572f, -0.03237661f, 0.21196343f, -0.00368736f, -0.11386406f, 
    0.02983428f, -0.12414216f, 0.21544558f, 0.08205579f, 0.19416855f, -0.26849821f, -0.02574901f, 0.03377163f, 
    0.15992877f, -0.34194362f, -0.13355787f, 0.08583102f, 0.65819246f, 0.60296929f, 0.52862304f, 0.43898195f, 
    0.29772642f, -0.45133141f, 0.23598036f, -0.32758516f, 0.19182596f, 0.16111617f, 0.17718084f, -0.09406339f, 
    -0.12582205f, 0.11629657f, -0.14364836f, -0.14853251f, -0.15665138f, 0.04745739f, 0.11567520f, -0.03451999f, 
    -0.00569342f, 0.00746830f, 0.00742388f, 0.05022005f, 0.21659350f, -0.25130197f, -0.33022121f, -0.34477526f, 
    -0.00160849f, -0.47686216f, -0.30178753f, 0.15706295f, 0.33936012f, -0.41040033f, 0.24484770f, -0.18467131f, 
    -0.24463478f, -0.32409289f, 0.03633384f, -0.13082418f, -0.15128359f, -0.30948964f, 0.01698143f, -0.20405467f, 
    0.04346597f, 0.09005225f, 0.01844399f, 0.20391522f, 0.26970270f, 0.00185875f, -0.23566918f, -0.59634835f, 
    -0.00399160f, 0.51251161f, -0.00784883f, 0.28591469f, 0.79951471f, -0.22642739f, 0.42056260f, 0.09955809f, 
    0.24737039f, 0.28224692f, 0.05018993f, 0.30425093f, -0.24111207f, -0.21231008f, -0.03010308f, 0.07539171f, 
    -0.21910298f, -0.05640204f, 0.04380020f, -0.05407088f, 0.10392052f, -0.11733737f, -0.13674837f, -0.21061289f, 
    0.31029001f, -0.31235126f, -0.48108727f, -0.24707888f, -0.51576412f, 0.44666326f, -0.10579632f, -0.51451147f, 
    0.10243565f, 0.36677906f, 0.10168015f, -0.14467791f, 0.21130899f, 0.25575325f, -0.04086904f, 0.19246314f, 
    0.25193334f, 0.02176017f, -0.17707382f, -0.07755582f, 0.05458031f, -0.07296461f, -0.15865974f, 0.09153438f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09902078f, -0.05897990f, -0.07673748f, -0.13725911f, 0.00851267f, 0.11645835f, -0.08179338f, -0.07728878f, 
    0.29855743f, 0.02114531f, -0.00987445f, 0.00363436f, 0.21498467f, 0.08703800f, 0.07089876f, 0.17956951f, 
    0.07641400f, 0.13212948f, 0.21358758f, 0.20223193f, 0.11849258f, 0.12784892f, 0.11257887f, -0.00135092f, 
    0.11672445f, -0.06767523f, 0.04953670f, 0.33525175f, 0.06068318f, 0.00026906f, 0.09288256f, -0.01509475f, 
    0.20800032f, 0.15316106f, 0.18844026f, 0.06189295f, 0.13565235f, 0.26139683f, -0.12978505f, 0.07054526f, 
    0.02652159f, 0.01581534f, 0.31109130f, -0.04478377f, -0.07718953f, 0.11276361f, 0.05940430f, 0.11117589f, 
    0.11910427f, 0.09113423f, -0.04016124f, 0.22791189f, 0.00742623f, -0.10984962f, 0.00427871f, 0.06631529f, 
    0.09653706f, 0.00871457f, 0.22859937f, 0.14722347f, 0.19272465f, -0.09993447f, 0.03035628f, 0.12005693f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.06253448f, 0.25802916f, 0.11072852f, -0.05802174f, -0.06670669f, 0.01100516f, 0.01158182f, 0.06121929f, 
    0.01038454f, 0.00321757f, 0.07202236f, 0.04901375f, -0.03249593f, -0.03377892f, -0.04484984f, 0.06584217f, 
    -0.02843595f, -0.02448500f, 0.03530487f, 0.07748938f, -0.00063360f, -0.07285845f, 0.10507680f, 0.12249653f, 
    0.17797853f, 0.07487155f, 0.01835194f, 0.06499401f, -0.04171204f, 0.06610062f, -0.09744945f, 0.02610579f, 
    0.01938723f, 0.06016850f, 0.01222623f, 0.02716856f, 0.16678768f, -0.01343933f, -0.05618335f, -0.02671744f, 
    -0.02430350f, -0.01951120f, -0.07676394f, -0.01774863f, -0.03122736f, 0.06306839f, 0.10205428f, 0.03416827f, 
    0.02998943f, 0.10362170f, 0.19965702f, 0.14590843f, -0.00223775f, 0.06449913f, 0.07490362f, 0.08700642f, 
    0.00882404f, 0.02221483f, 0.08165755f, -0.06109725f, -0.03242895f, -0.01182031f, 0.15337326f, 0.21256149f, 
    0.05671968f, -0.09200421f, 0.00921901f, 0.03396040f, -0.00334455f, 0.02521340f, -0.05969199f, -0.02746712f, 
    -0.27094796f, 0.15642576f, -0.01519212f, 0.16219206f, -0.00242369f, 0.00707722f, -0.02611299f, 0.00900416f, 
    0.04254499f, 0.00889599f, 0.03251982f, 0.04105001f, -0.11287201f, 0.01569525f, 0.12074249f, 0.19049515f, 
    -0.01309057f, 0.03415533f, 0.13817970f, 0.08760487f, -0.03523546f, 0.01192538f, 0.10663999f, 0.03735893f, 
    -0.22239429f, 0.10965277f, 0.05104372f, 0.13755842f, 0.00863530f, 0.07316238f, 0.08588728f, -0.00337758f, 
    0.05923029f, 0.04314595f, 0.01480167f, -0.03654921f, 0.09513207f, 0.03039143f, 0.09659064f, 0.03849810f, 
    -0.02494855f, -0.01530390f, 0.05872017f, 0.15353158f, 0.02872542f, 0.02504026f, 0.00446933f, 0.08054850f, 
    -0.07162281f, -0.00858625f, -0.03902834f, 0.06737515f, -0.04648171f, -0.01012260f, -0.04099727f, -0.02262167f, 
    -0.02968545f, -0.00041881f, 0.02383072f, 0.01429790f, 0.25324470f, -0.09406278f, -0.02819105f, 0.12874748f, 
    0.00237753f, 0.01664962f, -0.04572338f, 0.01848157f, -0.01455125f, -0.01721860f, 0.06605178f, 0.04601422f, 
    -0.15673590f, -0.06426644f, -0.05910984f, -0.08584705f, -0.05993744f, 0.03742249f, -0.06790106f, -0.13411340f, 
    -0.09725005f, 0.12813401f, 0.07118204f, -0.02280721f, -0.21421148f, 0.08094312f, -0.02272324f, -0.10309543f, 
    0.07188201f, 0.02545880f, 0.04251978f, 0.04821360f, -0.06226708f, 0.02819603f, 0.05990698f, 0.02007294f, 
    -0.06415155f, 0.08595388f, 0.24393706f, 0.07558010f, 0.08768529f, 0.04267529f, 0.00779545f, 0.02623052f, 
    0.00740167f, 0.11503406f, 0.00419420f, 0.11251361f, 0.16270223f, -0.20628308f, -0.05490840f, 0.02552591f, 
    0.06787179f, -0.09740004f, 0.03120915f, -0.01947407f, -0.08043659f, 0.01854964f, -0.02950496f, 0.10903917f, 
    0.06250916f, 0.16655448f, 0.04649324f, 0.07035162f, -0.05328294f, 0.01875092f, -0.01360898f, 0.11807930f, 
    -0.13496226f, 0.04278674f, 0.16789776f, -0.00066185f, -0.02237238f, -0.15133429f, 0.09106834f, -0.07770530f, 
    0.03448794f, 0.05192705f, 0.03415312f, -0.01606735f, 0.06588238f, 0.01300112f, -0.04100458f, -0.01990987f, 
    -0.19226344f, 0.21157107f, -0.08514081f, 0.16797484f, 0.12925814f, 0.04920749f, 0.05556338f, 0.07662921f, 
    0.01057834f, -0.02246307f, 0.01622149f, 0.02249581f, -0.12915157f, 0.00314578f, 0.12658930f, -0.11393471f, 
    0.12075984f, 0.02708841f, 0.02726866f, 0.01697229f, 0.04206146f, 0.04105973f, -0.03505034f, -0.01784857f, 
    -0.13388981f, -0.12271728f, -0.03834894f, -0.02098098f, 0.03783466f, -0.06219769f, -0.09513951f, -0.06191175f, 
    0.05428764f, 0.01348394f, -0.02290540f, -0.00636736f, -0.20453350f, 0.16898096f, -0.08859406f, 0.02860866f, 
    0.07815526f, -0.06400266f, 0.04358700f, -0.03839981f, -0.02202688f, 0.00192197f, -0.04278373f, -0.10240827f, 
    -0.13266982f, -0.10127187f, 0.04767434f, -0.17456335f, 0.01771468f, -0.01934110f, 0.06701355f, -0.00919810f, 
    0.01464157f, -0.02459354f, -0.01508977f, -0.09034501f, -0.10795502f, 0.24016635f, 0.05853021f, -0.11099841f, 
    0.01715476f, -0.05257234f, 0.00429417f, -0.06791227f, 0.00136946f, -0.03914343f, 0.12064111f, -0.03304308f, 
    0.06263893f, 0.03813051f, -0.09699762f, -0.16771652f, 0.16137373f, -0.03619441f, -0.11456846f, -0.09014890f, 
    -0.04000102f, -0.09343895f, -0.02048765f, 0.02696414f, -0.28751293f, -0.10306659f, 0.08032221f, -0.11545617f, 
    0.04884900f, 0.03387577f, 0.00315652f, 0.02990471f, 0.11485413f, 0.02954736f, -0.00880269f, 0.04594140f, 
    0.08249737f, -0.02375632f, -0.12188089f, 0.06009536f, 0.04494471f, 0.03331858f, 0.03020397f, 0.00811972f, 
    -0.02161983f, -0.01280575f, 0.01056757f, 0.01336194f, 0.22406207f, 0.01004125f, 0.00242724f, -0.04695766f, 
    -0.04814653f, 0.05560640f, -0.07767259f, -0.02266312f, -0.01172281f, 0.00605344f, 0.02769076f, -0.04764622f, 
    -0.14595637f, -0.10608891f, 0.19225216f, -0.14423257f, 0.02000351f, -0.04477927f, 0.07761113f, -0.04295525f, 
    0.03051032f, -0.00975989f, -0.06535430f, 0.02217645f, -0.10789736f, 0.09059805f, 0.27839854f, 0.22381312f, 
    0.01420967f, 0.03258277f, 0.07483596f, 0.11639816f, 0.01747508f, 0.07975694f, -0.01249145f, -0.06043740f, 
    0.03841414f, -0.03300258f, 0.06273638f, 0.13270287f, 0.00570304f, -0.07383773f, -0.00910557f, -0.05278209f, 
    0.03153875f, -0.05397590f, -0.03540334f, 0.03567826f, 0.24508628f, 0.08971276f, -0.07844640f, -0.18963408f, 
    0.09111277f, -0.04395322f, 0.00324590f, -0.02433286f, -0.00556163f, 0.05117212f, -0.02361377f, 0.10045854f, 
    -0.05810358f, 0.19090445f, -0.00925399f, -0.07196743f, 0.04956193f, 0.07593258f, 0.01763246f, 0.06257083f, 
    0.10179456f, -0.06305996f, 0.07165445f, -0.04535564f, 0.10519478f, -0.04023225f, 0.13292751f, 0.05877157f, 
    -0.05353517f, -0.03577609f, 0.02848990f, 0.03591004f, -0.03850140f, 0.00690146f, -0.10245722f, 0.04715014f, 
    -0.03241074f, -0.03082466f, -0.12218529f, 0.09396914f, 0.07649034f, -0.03106132f, 0.08408854f, -0.00283609f, 
    0.09606815f, 0.01562873f, 0.04930411f, -0.05515676f, 0.05553886f, 0.03739793f, 0.07662804f, -0.01432293f, 
    0.03234624f, 0.03948089f, -0.07625603f, 0.00363410f, 0.06717820f, 0.09583835f, 0.08075705f, 0.09626175f, 
    -0.12830332f, 0.09111062f, 0.17761695f, 0.18548676f, -0.01880750f, 0.02932398f, 0.01705899f, 0.12371734f, 
    -0.03860920f, -0.02979428f, 0.06335907f, -0.00475598f, 0.20823900f, 0.21345274f, -0.12956417f, -0.14637746f, 
    0.08263683f, 0.01539697f, -0.04238593f, -0.05421853f, 0.10129410f, 0.06731436f, 0.06969805f, 0.04944715f, 
    0.05758588f, 0.13001959f, 0.09083489f, 0.24002106f, 0.08584091f, -0.01388692f, -0.01217056f, 0.08867218f, 
    0.01110366f, -0.01391471f, -0.01689497f, 0.01953897f, 0.09007075f, 0.14852940f, -0.08824877f, -0.17367779f, 
    0.10254431f, 0.01652450f, -0.06651852f, 0.05562198f, -0.02917695f, 0.01159465f, -0.02389572f, 0.02376343f, 
    0.14465773f, 0.19528428f, -0.06338407f, 0.02938144f, -0.01931877f, -0.05198632f, -0.02604501f, 0.14517640f, 
    -0.04792980f, -0.07447226f, 0.02745528f, -0.11049899f, 0.00641985f, 0.08362543f, -0.14861144f, 0.02293809f, 
    0.08805272f, -0.04097460f, 0.06415839f, -0.06228603f, -0.11607822f, 0.00665745f, 0.02694721f, 0.07667705f, 
    0.16205117f, 0.06299910f, -0.10837156f, -0.03357565f, 0.03041620f, 0.06974930f, 0.02858481f, 0.07813559f, 
    -0.09135220f, -0.04261188f, 0.09877838f, 0.07035357f, 0.24201374f, -0.05489312f, 0.14260446f, 0.12863217f, 
    -0.03312650f, -0.00787014f, 0.00040959f, 0.07527048f, -0.06152741f, 0.02667656f, -0.01186348f, 0.02349486f, 
    -0.07916000f, 0.01111463f, -0.00696478f, -0.01499485f, -0.05049392f, 0.08359930f, -0.04289809f, -0.00678910f, 
    0.03571723f, 0.06483285f, 0.06211697f, -0.05593719f, -0.05661699f, 0.10462752f, 0.00775782f, -0.18766172f, 
    0.05728510f, 0.00383178f, -0.10084438f, -0.00587136f, 0.01799520f, 0.02225149f, 0.01581930f, -0.01070674f, 
    -0.06804029f, 0.11138904f, -0.11595200f, -0.08701528f, 0.00307029f, -0.02452629f, -0.04436834f, -0.03838122f, 
    -0.00248067f, 0.07525723f, 0.12844150f, -0.02539431f, 0.06201547f, 0.02232332f, 0.11451812f, -0.00308561f, 
    0.06879643f, 0.08309413f, 0.10465740f, 0.01088933f, 0.10779899f, -0.03902528f, -0.06350453f, -0.01662430f, 
    -0.14903873f, -0.10708921f, 0.11148667f, 0.10842220f, -0.03297930f, 0.02071718f, -0.04673713f, 0.07743778f, 
    -0.01969712f, 0.03705945f, -0.00478509f, 0.08350571f, -0.06822155f, 0.14862183f, -0.15012951f, 0.02430042f, 
    0.03032478f, -0.07674255f, 0.03427456f, -0.01310640f, 0.00012456f, 0.02965024f, -0.03261343f, -0.09530038f, 
    -0.15290780f, 0.22688085f, -0.16529995f, -0.13928817f, 0.09108657f, -0.07006761f, -0.01735147f, 0.00993518f, 
    0.00944215f, 0.01253048f, 0.10718653f, -0.05373459f, 0.11094934f, -0.10683379f, 0.03252003f, -0.17763337f, 
    -0.00768775f, 0.03239461f, 0.08247662f, -0.07725401f, 0.03669326f, 0.05921840f, -0.03234754f, -0.01375043f, 
    -0.28794494f, -0.00183532f, -0.06794155f, -0.18602562f, -0.03861419f, 0.00716868f, -0.02842435f, 0.00688963f, 
    0.00912297f, 0.07653782f, -0.03071657f, -0.02859244f, 0.02120005f, -0.09915023f, -0.00171796f, -0.05171995f, 
    0.14192674f, -0.06268910f, 0.00904651f, 0.05540802f, 0.03694393f, 0.02508222f, -0.02536479f, 0.09533419f, 
    -0.19898462f, 0.13238244f, -0.03919657f, 0.01281196f, 0.01223136f, -0.09707663f, -0.06150768f, 0.01976753f, 
    -0.00632246f, -0.01964937f, -0.08556593f, 0.01558290f, 0.03024058f, -0.07710981f, -0.03641619f, -0.00046597f, 
    0.05035956f, 0.02403833f, -0.00632047f, -0.09569720f, -0.04679465f, -0.00783178f, 0.18017887f, -0.00628962f, 
    -0.02833293f, -0.01077460f, -0.13324621f, -0.01875404f, -0.02338178f, 0.02808226f, -0.06721639f, 0.07289763f, 
    0.03138852f, -0.00725820f, 0.04761389f, -0.09038053f, -0.24571957f, 0.10145913f, -0.15020347f, 0.01389982f, 
    0.07625561f, 0.04723065f, -0.04932235f, 0.01544096f, 0.01101734f, -0.00816606f, -0.01000624f, -0.02108759f, 
    0.04687356f, -0.08171731f, -0.17631215f, -0.02502946f, 0.05390681f, 0.01745966f, -0.02711569f, 0.01335538f, 
    0.04675316f, 0.02002874f, 0.01741971f, -0.06801889f, -0.15595636f, -0.02254979f, -0.10848802f, -0.02914952f, 
    0.13171113f, 0.02288461f, -0.04457979f, -0.01288193f, 0.03972009f, 0.02158755f, 0.03401836f, 0.03725265f, 
    -0.17775753f, -0.00783739f, -0.03025246f, -0.08891987f, 0.02658965f, -0.03454320f, -0.04940328f, -0.01805257f, 
    -0.02332210f, 0.04125584f, -0.06700317f, 0.02634668f, 0.01228014f, 0.01976217f, 0.13032009f, 0.06907526f, 
    0.09037611f, 0.05441561f, 0.03462935f, 0.06047948f, 0.00111510f, 0.01740844f, 0.02796917f, 0.09963765f, 
    -0.09338199f, 0.10708258f, 0.06090735f, -0.02282385f, -0.04736296f, 0.01032268f, -0.02187312f, -0.01174464f, 
    0.00918418f, 0.08132502f, -0.08115107f, 0.03321785f, 0.12791307f, 0.04739727f, 0.17915224f, 0.07286076f, 
    0.05371818f, 0.00351635f, 0.04737365f, -0.03208815f, -0.01801059f, -0.06029718f, -0.04089510f, -0.01044596f, 
    -0.10115030f, 0.09360405f, -0.01010527f, -0.08254156f, 0.02815163f, 0.14112374f, -0.10553510f, 0.03159326f, 
    0.02177508f, 0.07069445f, -0.18372624f, 0.03929718f, -0.13254802f, 0.09047817f, 0.02478419f, -0.22286421f, 
    0.07626986f, 0.11383356f, 0.07043172f, 0.09203371f, 0.00709814f, 0.11534429f, -0.15087737f, 0.03057855f, 
    0.23532803f, 0.07528324f, -0.02119762f, 0.04219205f, 0.08361393f, -0.01521558f, 0.01756089f, 0.01101619f, 
    -0.01526964f, -0.03702031f, -0.13801455f, -0.02982732f, 0.31541306f, 0.22025719f, 0.06349731f, -0.11697438f, 
    -0.05388204f, 0.00577593f, -0.15052649f, -0.16572826f, 0.04310623f, -0.09902020f, 0.01997979f, -0.29303250f, 
    -0.01019114f, -0.10171807f, -0.03299876f, 0.09099311f, 0.14020669f, -0.10960647f, 0.02231339f, -0.00429373f, 
    -0.03307152f, 0.07886761f, -0.07857575f, 0.03345268f, 0.03291398f, 0.08666527f, -0.05806804f, 0.01882602f, 
    0.09268477f, 0.08609410f, 0.02295009f, -0.07259309f, 0.05221539f, -0.09791356f, 0.02416953f, 0.00930873f, 
    0.01965672f, 0.10701357f, -0.02942288f, -0.04968303f, -0.01918467f, -0.02165374f, -0.05240908f, -0.03342574f, 
    0.12515400f, 0.06727356f, -0.09267110f, 0.00449255f, 0.11441442f, 0.18458517f, -0.09083283f, -0.10910624f, 
    0.16192138f, 0.04336068f, 0.03628341f, -0.02157852f, -0.11173957f, 0.08203705f, 0.02127901f, -0.02979776f, 
    -0.00543128f, 0.04224095f, -0.00134281f, 0.08206303f, -0.00423045f, 0.01073261f, -0.12341507f, 0.07375468f, 
    0.07351776f, 0.01697859f, -0.01441104f, -0.06782012f, -0.09002464f, 0.14273994f, 0.07684960f, -0.02484475f, 
    0.13993633f, -0.10189287f, -0.00597809f, -0.15023229f, 0.00412916f, -0.06986972f, -0.09749619f, 0.01188713f, 
    -0.09445403f, -0.03462707f, 0.06769824f, -0.16949137f, 0.02851380f, 0.03447296f, -0.00008657f, 0.04273462f, 
    0.07169853f, 0.07258738f, 0.10558453f, -0.03663207f, 0.00452922f, -0.09167033f, 0.03082459f, -0.03731565f, 
    0.13115714f, -0.02159726f, 0.01496284f, -0.12553856f, 0.03746374f, 0.01353950f, 0.02014539f, 0.03734109f, 
    0.00246374f, -0.00791428f, -0.00513746f, 0.05171473f, -0.13043025f, -0.10080568f, -0.01749405f, -0.04058748f, 
    -0.08012623f, -0.21596487f, -0.01264804f, 0.02353337f, 0.26327688f, 0.15754397f, 0.03365446f, -0.21277359f, 
    0.03068016f, -0.08270818f, -0.18785393f, 0.14786416f, -0.07698405f, 0.06052377f, -0.13430403f, -0.08709279f, 
    0.02018716f, 0.22446762f, -0.17762941f, 0.12343614f, 0.13092518f, 0.05665932f, -0.07109810f, 0.02863725f, 
    0.09684242f, -0.19662431f, 0.03183107f, -0.04343922f, 0.16090104f, 0.02024187f, 0.07005900f, -0.02170255f, 
    0.02511372f, -0.02764322f, 0.04733550f, -0.02630970f, -0.00374723f, 0.01246441f, 0.01849844f, -0.10646099f, 
    0.18390945f, 0.09069870f, -0.07313000f, 0.10992046f, 0.04012195f, -0.01615277f, -0.11346914f, 0.06479190f, 
    0.04300077f, -0.15333283f, -0.03736065f, -0.17121762f, 0.04836915f, 0.11710606f, 0.01244491f, 0.16480933f, 
    0.10885233f, -0.03569229f, -0.11017561f, 0.00886714f, -0.01292372f, -0.00521218f, -0.01922589f, -0.11707386f, 
    -0.12539633f, 0.10669637f, 0.03267793f, -0.03518804f, 0.09540407f, 0.04865814f, -0.04800988f, -0.10344839f, 
    0.05723607f, 0.03005113f, -0.09228966f, -0.04511742f, -0.05001628f, 0.14986452f, 0.13776824f, -0.00839566f, 
    -0.05405538f, 0.02354425f, -0.00369353f, -0.05437881f, 0.00612898f, -0.18042700f, -0.02999771f, -0.09163525f, 
    0.01893004f, -0.07394188f, -0.05010555f, -0.01491640f, -0.06823882f, -0.11839512f, 0.07575133f, 0.01431540f, 
    -0.00925301f, -0.10087256f, -0.01617813f, 0.13907605f, -0.17785713f, 0.12784353f, -0.03917719f, -0.06846838f, 
    0.01403699f, -0.06569165f, 0.06683215f, -0.02605951f, -0.05004794f, 0.03234176f, 0.11280017f, 0.16708696f, 
    -0.10608052f, 0.07412811f, 0.04645287f, -0.07652887f, 0.02426547f, -0.02818971f, 0.05075002f, 0.03427368f, 
    -0.06283206f, -0.04271924f, 0.02828281f, 0.02616590f, -0.03020765f, 0.16309202f, -0.03644848f, 0.07281797f, 
    -0.10095810f, -0.08581899f, 0.02614453f, 0.06336197f, -0.00870589f, 0.07526714f, 0.09175474f, 0.02141098f, 
    0.01558490f, 0.01751651f, -0.03039960f, -0.10516682f, -0.03599829f, 0.03071638f, 0.10135774f, 0.13657071f, 
    0.11327894f, 0.00101727f, -0.11195790f, -0.06740384f, 0.19200057f, -0.02134622f, 0.02534313f, -0.12066492f, 
    0.05937226f, 0.08763957f, -0.01227557f, 0.01055761f, -0.03398768f, 0.01415710f, 0.04403098f, 0.05350693f, 
    0.02978801f, -0.16000800f, 0.02481579f, 0.02364279f, -0.06012385f, 0.00902011f, 0.05140418f, 0.01118844f, 
    0.03154434f, 0.08359267f, 0.14661464f, 0.18631904f, 0.07550056f, 0.15676263f, -0.04151619f, 0.03467299f, 
    -0.03680902f, 0.07243706f, -0.00138872f, 0.04402329f, 0.10724863f, -0.12525585f, 0.08953487f, 0.20021118f, 
    0.10978339f, 0.22146384f, 0.12289520f, -0.08452465f, -0.00335330f, 0.01458693f, -0.02473203f, 0.01180647f, 
    0.05835662f, -0.00753052f, 0.17500156f, 0.00514387f, -0.00744962f, -0.09775780f, -0.04746277f, 0.05496748f, 
    0.13201946f, 0.10690089f, -0.07053822f, -0.05807687f, 0.05271668f, -0.05848474f, -0.02222131f, 0.02547760f, 
    -0.15146248f, 0.07906937f, -0.05725840f, -0.01087363f, 0.08245222f, 0.10999528f, -0.05530221f, -0.06861769f, 
    0.07606695f, -0.04398102f, 0.10704555f, -0.06016533f, -0.00628964f, 0.08692361f, 0.03551983f, 0.19731370f, 
    0.17649396f, -0.03588838f, 0.06500316f, -0.10405899f, -0.00332948f, -0.00270005f, 0.03960994f, -0.04746467f, 
    0.00854575f, 0.25101957f, -0.04384316f, 0.12001537f, 0.05090380f, 0.02451908f, -0.02160176f, -0.06708405f, 
    -0.07897389f, 0.03343655f, -0.11591570f, 0.09302714f, 0.00043707f, -0.28837821f, 0.15014954f, 0.15937349f, 
    0.04030467f, -0.02283150f, -0.18735634f, -0.07451323f, 0.21809781f, 0.12882201f, 0.17245907f, 0.01499570f, 
    -0.27333346f, -0.02529760f, -0.10795192f, -0.18319285f, 0.07634880f, -0.07963129f, -0.16044873f, -0.02304867f, 
    0.08044340f, 0.11074090f, 0.07206053f, 0.00895197f, 0.00192529f, 0.01822119f, 0.13388097f, 0.32016748f, 
    0.10011526f, 0.04442415f, -0.05276263f, 0.04377127f, 0.01113933f, -0.08478788f, 0.05391290f, -0.21938255f, 
    -0.11032537f, -0.06295345f, 0.02574795f, 0.04176729f, 0.15443490f, 0.08339283f, -0.09719606f, -0.08800184f, 
    0.11480229f, -0.00814113f, 0.05594520f, 0.02453021f, -0.21724929f, -0.11588961f, 0.12588389f, 0.10745739f, 
    -0.09550651f, -0.01385462f, 0.13093610f, -0.03778085f, -0.07309213f, 0.01217934f, -0.09449156f, -0.01857045f, 
    0.16626088f, 0.17457686f, 0.05528791f, 0.17814468f, 0.22292085f, 0.14986961f, -0.06673805f, 0.01303089f, 
    0.01944452f, 0.00658412f, -0.03548397f, 0.05923730f, -0.07031703f, 0.23555785f, 0.07159440f, -0.04062544f, 
    0.09014185f, 0.00752939f, 0.04707620f, -0.11411974f, 0.05627283f, 0.03492055f, 0.05455938f, -0.09954213f, 
    0.14058490f, 0.02938540f, -0.02405570f, 0.11202183f, 0.19116005f, -0.05977065f, 0.05093337f, 0.00888989f, 
    0.06424721f, -0.01610073f, -0.01783775f, -0.02894108f, -0.02897386f, 0.29638019f, 0.06042749f, -0.13785674f, 
    0.09200868f, -0.05715933f, -0.06871025f, -0.04633451f, 0.05804347f, -0.06178204f, 0.00049816f, -0.15118469f, 
    0.02036801f, -0.05165767f, -0.00958849f, 0.26481429f, 0.02406416f, 0.05492000f, -0.05236101f, 0.08564915f, 
    -0.01539953f, -0.04255122f, -0.03461010f, 0.04598765f, 0.29393831f, -0.06225097f, 0.01241727f, -0.04211775f, 
    0.02239644f, 0.17672251f, 0.03379524f, -0.07324503f, 0.01053879f, -0.04004917f, -0.07644094f, -0.09600890f, 
    -0.04553427f, -0.01617926f, 0.14090714f, -0.11938072f, -0.09952255f, -0.09719877f, -0.03656122f, 0.03811638f, 
    -0.02168410f, -0.06060832f, -0.08015042f, 0.13128538f, -0.16631860f, 0.04624524f, -0.05006995f, 0.11160828f, 
    0.02518080f, 0.02469803f, 0.04116816f, -0.07247619f, 0.05853524f, -0.00226740f, -0.06966810f, 0.11796295f, 
    -0.35185751f, -0.04165138f, 0.17796710f, 0.04486115f, -0.06636283f, 0.08427600f, 0.00014466f, 0.04460035f, 
    -0.02985036f, -0.05866510f, -0.00820659f, -0.16046044f, -0.12476245f, 0.08249932f, 0.05390599f, 0.25551420f, 
    0.09209005f, 0.07138425f, -0.01608301f, -0.02056614f, -0.02297465f, 0.01356676f, 0.07008331f, 0.27534142f, 
    -0.62368339f, -0.00388543f, 0.26243508f, -0.01449549f, 0.03726694f, -0.02028960f, 0.07464383f, -0.09278052f, 
    -0.03364124f, 0.00490108f, 0.08192740f, -0.04636217f, -0.17015448f, 0.15838188f, -0.05072783f, -0.20584089f, 
    -0.04886485f, 0.06031092f, -0.10407442f, -0.02824072f, -0.01847581f, -0.07584009f, 0.01658081f, 0.10967746f, 
    -0.31938526f, 0.28192171f, 0.18134469f, -0.07232323f, 0.00897785f, 0.03092701f, 0.07039015f, -0.02891607f, 
    0.02750473f, -0.06340553f, 0.04634667f, 0.12172629f, 0.09742586f, -0.00645870f, -0.03037403f, 0.20717253f, 
    -0.17010759f, -0.22456583f, 0.11771062f, -0.00319413f, -0.13993433f, 0.08173694f, 0.01750175f, 0.09531899f, 
    -0.07834453f, -0.02063207f, 0.02018181f, -0.09123743f, 0.04242694f, -0.04343579f, -0.03446089f, 0.01844421f, 
    -0.19993135f, -0.04812782f, 0.17530309f, 0.07980491f, 0.06805446f, 0.42414835f, 0.32975030f, 0.00317818f, 
    0.04545262f, 0.01389175f, -0.08553904f, -0.14119913f, -0.03908076f, -0.02290260f, -0.12976839f, -0.08723964f, 
    -0.20744006f, 0.03193685f, 0.10565014f, -0.40338644f, -0.11626215f, -0.01167468f, 0.06732037f, -0.14394471f, 
    -0.06647848f, 0.14184099f, 0.19589210f, -0.01119498f, 0.03365444f, 0.06365544f, 0.02740392f, -0.12010241f, 
    -0.04125594f, -0.11895017f, -0.05571407f, 0.06387849f, -0.07961892f, 0.07090850f, -0.07455017f, -0.08331263f, 
    0.07255803f, -0.00086204f, -0.04288673f, -0.02519127f, 0.04563440f, 0.04107547f, -0.00271958f, 0.01086047f, 
    0.08545075f, 0.10807162f, 0.03946424f, 0.15922807f, -0.22691070f, 0.10836527f, -0.08244939f, 0.13094547f, 
    -0.03285597f, -0.05764943f, 0.11793354f, -0.04234235f, -0.26814911f, 0.03094100f, -0.00031295f, 0.12034373f, 
    0.00867660f, 0.05522031f, -0.02857552f, -0.10692764f, 0.02350270f, 0.07796149f, 0.05308121f, -0.03190766f, 
    -0.04519405f, 0.06419833f, 0.11581160f, 0.07082649f, 0.01970709f, 0.09557591f, 0.15141743f, 0.10982058f, 
    0.15288976f, 0.00251357f, -0.05513216f, -0.00233580f, 0.05685446f, 0.12476809f, -0.05162849f, 0.09550469f, 
    -0.08170009f, -0.07390723f, 0.00753717f, -0.10923689f, 0.00647025f, 0.02802497f, 0.00865397f, -0.02250844f, 
    -0.07403012f, -0.06144419f, 0.06536221f, 0.03086708f, 0.16585708f, 0.20127013f, -0.05254651f, 0.02034985f, 
    0.25177041f, 0.05541277f, 0.14293526f, 0.06763339f, 0.00478790f, -0.03177024f, 0.07035766f, -0.22077659f, 
    -0.51387447f, 0.14157696f, 0.09957023f, -0.02926887f, 0.01543086f, 0.01114492f, -0.00656120f, -0.03736144f, 
    -0.02169205f, -0.09071431f, -0.06421991f, -0.04238137f, 0.12004901f, -0.03485857f, 0.07482490f, 0.09052245f, 
    0.03352484f, -0.04813326f, -0.12506410f, 0.00403579f, 0.05575635f, 0.12132466f, 0.07925486f, -0.06950632f, 
    0.01646047f, -0.01996612f, 0.00430368f, -0.00182899f, -0.04012328f, -0.00306015f, 0.02539962f, 0.00083388f, 
    -0.00397146f, 0.02435703f, -0.03028253f, -0.01430961f, 0.00675597f, -0.01201385f, 0.02608230f, -0.01182787f, 
    0.02992792f, -0.00551147f, 0.02636152f, -0.00872794f, -0.00086294f, 0.02568869f, 0.02474126f, 0.02028137f, 
    -0.00066192f, 0.01088878f, 0.02960988f, 0.01840830f, -0.03202846f, -0.04055189f, -0.03505109f, -0.01814084f, 
    -0.02504712f, -0.00362296f, -0.01270107f, -0.03593782f, 0.02338459f, -0.01227683f, -0.01038550f, 0.01387839f, 
    0.01189639f, -0.02118598f, -0.02883255f, -0.02043381f, -0.02989752f, -0.00664219f, -0.03575864f, -0.03630580f, 
    -0.02237790f, -0.02839184f, 0.01534375f, 0.02268570f, 0.01517518f, 0.00409148f, -0.02570613f, -0.03309280f, 
    -0.00824381f, -0.01745178f, 0.03991655f, -0.00115049f, 0.00945435f, -0.02329908f, -0.02441557f, 0.02468399f, 
    -0.02668106f, 0.01748890f, 0.00189183f, -0.01187158f, -0.04049548f, -0.03159640f, 0.00860428f, 0.01292139f, 
    0.02365625f, 0.00416623f, -0.01429165f, 0.02970410f, -0.03714980f, -0.01712718f, 0.01193514f, -0.02394609f, 
    0.03989894f, 0.03045336f, -0.02243005f, 0.00035368f, 0.00493133f, 0.00686591f, -0.00328265f, 0.02974903f, 
    -0.01426089f, -0.03768163f, -0.02068171f, 0.00756217f, 0.00044225f, 0.01114387f, 0.00244103f, -0.04060829f, 
    0.01667285f, 0.02730117f, -0.00281853f, -0.00872937f, 0.02973198f, -0.01094035f, 0.01351531f, 0.00799587f, 
    0.00866876f, 0.02085238f, 0.01103123f, 0.02075606f, 0.02631973f, 0.02376650f, -0.03496509f, 0.01573317f, 
    0.01197547f, -0.01835965f, 0.02762307f, -0.03525935f, -0.01031640f, -0.00559701f, -0.02615718f, -0.02769569f, 
    -0.01802760f, -0.02997187f, 0.01827874f, 0.02581111f, 0.00973563f, -0.01620109f, 0.02784598f, -0.02232847f, 
    -0.01728212f, 0.02099624f, -0.01821413f, -0.00049193f, 0.00686231f, 0.00488421f, -0.01793535f, 0.01696563f, 
    -0.02838649f, -0.01607552f, 0.02968599f, -0.00499500f, -0.03594738f, -0.00827864f, -0.02342384f, -0.00190476f, 
    0.00747852f, -0.04098010f, 0.02887929f, -0.04064998f, 0.01737391f, -0.03779892f, 0.01110834f, -0.00113529f, 
    0.02747998f, 0.01398507f, -0.01164035f, -0.00942870f, 0.03769129f, -0.01307928f, -0.00759865f, -0.02554978f, 
    -0.00969518f, 0.02102551f, -0.03066279f, -0.00772294f, -0.00333624f, 0.00011502f, 0.02179734f, -0.02601973f, 
    -0.00449770f, -0.01879762f, -0.03658189f, 0.01351494f, -0.02741895f, -0.00137568f, 0.01679632f, -0.00383861f, 
    0.00225489f, -0.02977211f, -0.01546628f, 0.02554729f, 0.03855581f, 0.01273563f, 0.01607194f, 0.02052525f, 
    0.03547446f, -0.03043707f, -0.03621373f, -0.03042008f, -0.01430627f, 0.02684150f, 0.01961520f, 0.00538075f, 
    -0.00335345f, -0.00172131f, -0.03865458f, 0.01103629f, 0.01633557f, 0.01807258f, -0.01415187f, 0.01288174f, 
    -0.00350450f, 0.01952185f, 0.00623450f, 0.01091307f, -0.01344413f, 0.02108226f, 0.00202724f, -0.01132542f, 
    -0.01126884f, -0.02018756f, -0.03898252f, 0.01946789f, 0.00356911f, 0.00156098f, 0.01876535f, -0.00731359f, 
    -0.00909453f, -0.01992024f, -0.03789385f, 0.00802869f, -0.02623953f, -0.01799491f, 0.02382980f, 0.01673616f, 
    -0.01612317f, 0.02286525f, -0.03075558f, -0.00438239f, 0.00447401f, 0.01683818f, 0.03056336f, 0.00004179f, 
    -0.03629442f, 0.02644019f, -0.03609817f, -0.01812041f, 0.01975597f, 0.01294110f, -0.00316796f, -0.00720448f, 
    0.02127264f, 0.02452018f, 0.01525668f, 0.00615252f, -0.04079901f, 0.02533219f, -0.03374702f, -0.01246491f, 
    -0.03234858f, -0.03140698f, -0.00639578f, 0.01121608f, -0.00997256f, 0.01189782f, 0.02408687f, 0.00370338f, 
    0.00102174f, -0.00746013f, -0.01253773f, -0.00282945f, -0.03445447f, 0.01176583f, -0.02152658f, -0.01725199f, 
    -0.00684984f, -0.02569759f, 0.02749383f, 0.00400844f, 0.02276830f, -0.03968179f, 0.02182721f, 0.02052588f, 
    0.02017944f, 0.02645254f, 0.00111251f, -0.03188549f, -0.01196070f, 0.02658521f, -0.02006323f, 0.01334365f, 
    -0.00146825f, -0.02459603f, -0.00444152f, 0.00672312f, -0.00065285f, 0.02806542f, 0.01635090f, -0.00466498f, 
    0.01411773f, -0.02519528f, -0.03377545f, -0.03794139f, -0.03907754f, 0.01515917f, -0.02805462f, -0.00143755f, 
    -0.01166211f, -0.03006860f, -0.01374398f, 0.02734735f, 0.01431368f, 0.02604284f, 0.01028641f, -0.00004091f, 
    0.02372251f, -0.03152183f, 0.02401503f, -0.02535515f, 0.01906664f, -0.01399398f, -0.03903574f, 0.00962168f, 
    -0.02193573f, -0.00317666f, -0.00986533f, 0.01939389f, 0.03021511f, 0.00479612f, 0.00449178f, -0.01218151f, 
    0.02080966f, 0.03267446f, -0.00664145f, -0.02149585f, -0.02983497f, -0.04180899f, -0.01900399f, -0.01835993f, 
    0.02885434f, 0.01226441f, -0.02454493f, -0.02683645f, -0.01499758f, 0.02325986f, -0.04095027f, 0.01159656f, 
    -0.00510311f, 0.00244794f, -0.03993756f, 0.01296507f, -0.03097871f, -0.02021169f, -0.01988170f, 0.01907936f, 
    -0.02935172f, -0.01127519f, 0.04144559f, 0.01911268f, 0.02587912f, -0.04120294f, -0.01059436f, 0.02475555f, 
    0.02857737f, -0.03002530f, -0.03370896f, -0.02870841f, -0.02111994f, 0.00077409f, -0.02183626f, 0.01545591f, 
    -0.03172716f, 0.02355744f, -0.01716646f, 0.00920628f, 0.03124755f, 0.04242849f, -0.00748430f, 0.00882587f, 
    0.00886057f, 0.01253680f, 0.02304128f, -0.02608070f, 0.02911177f, 0.00266058f, -0.01653631f, 0.00875785f, 
    -0.01229151f, -0.00116736f, 0.02930706f, 0.00447830f, -0.00650242f, 0.00327546f, 0.00951877f, -0.00541328f, 
    0.01815091f, -0.00246135f, -0.02823818f, -0.01570709f, 0.02550189f, -0.01841101f, 0.01998840f, -0.01494592f, 
    -0.02640288f, -0.01460711f, -0.02217555f, -0.00738805f, 0.02726748f, -0.01015913f, 0.00084852f, 0.02933581f, 
    0.01054584f, -0.00253873f, -0.03389636f, -0.01317185f, -0.02517762f, 0.00856443f, 0.00700045f, -0.00551380f, 
    -0.03244579f, -0.02899748f, 0.00998632f, -0.02539093f, 0.01061823f, 0.01033420f, -0.03480064f, -0.04068413f, 
    0.04286351f, 0.00345722f, -0.02121513f, 0.03056328f, 0.00488774f, 0.02290013f, 0.00999108f, -0.01889408f, 
    -0.03535441f, 0.02626332f, 0.01262082f, -0.01826744f, -0.01284367f, 0.00757276f, -0.03873386f, 0.02419791f, 
    -0.01658022f, -0.02384091f, -0.00235187f, 0.00675455f, 0.01190384f, -0.01326069f, -0.00989875f, -0.02500420f, 
    0.02848605f, 0.02961387f, 0.02828653f, 0.01106617f, -0.00905741f, -0.01643688f, -0.00910581f, -0.00611379f, 
    -0.01735180f, 0.00107092f, 0.03093918f, -0.00016502f, -0.00234854f, 0.02957038f, -0.02236961f, -0.03184569f, 
    -0.00576626f, -0.00152474f, -0.02479032f, -0.01254762f, 0.01890149f, -0.03024828f, -0.02321600f, -0.00175154f, 
    0.00974703f, 0.02921898f, -0.03076245f, 0.00821985f, 0.01614743f, 0.01597932f, 0.01261414f, -0.02277044f, 
    -0.03473729f, 0.01959418f, -0.03470803f, 0.02307523f, -0.03159836f, -0.00747953f, -0.03865675f, 0.01084496f, 
    0.02851142f, 0.01310361f, 0.00123641f, -0.03554295f, -0.00392922f, -0.00087578f, 0.02597632f, 0.02245906f, 
    -0.02356035f, -0.00718519f, 0.02783895f, -0.01863145f, 0.01430254f, -0.02058605f, 0.03968568f, 0.02735050f, 
    -0.02791583f, -0.03843180f, -0.03875958f, -0.01943670f, 0.02768216f, -0.02180702f, -0.00484239f, -0.01242177f, 
    -0.03291574f, -0.02967631f, 0.00665893f, 0.01768979f, -0.03234328f, -0.01544801f, 0.00293635f, -0.02852145f, 
    -0.04156631f, -0.00511155f, -0.00898422f, -0.03904887f, 0.03535227f, 0.02216914f, 0.00474249f, 0.01726045f, 
    0.00628767f, 0.02226651f, 0.01410318f, 0.01421338f, 0.00359341f, -0.02745083f, -0.03096183f, 0.02804761f, 
    0.00391574f, -0.00657069f, 0.01398760f, 0.01810055f, 0.01906328f, 0.00455678f, 0.03200502f, 0.02203112f, 
    -0.02497126f, -0.01599486f, -0.01411243f, 0.00741910f, -0.01981520f, 0.01969708f, -0.00564209f, -0.03218822f, 
    -0.01326519f, -0.01261394f, 0.00377062f, -0.00424175f, 0.00520077f, -0.02377308f, 0.01165475f, -0.03175737f, 
    -0.00385083f, -0.01949588f, 0.00733465f, 0.01107166f, -0.03473243f, -0.03762702f, 0.01714314f, 0.02266204f, 
    0.02293798f, -0.04171792f, 0.02684111f, -0.00713718f, -0.03836250f, 0.00543411f, -0.00673396f, 0.02706409f, 
    0.01056176f, -0.01434152f, -0.02072199f, 0.02078199f, -0.03837264f, 0.01422735f, 0.03051831f, 0.01065144f, 
    -0.03815226f, -0.01680312f, 0.00228278f, -0.00925768f, -0.03122309f, -0.02409016f, -0.00244945f, 0.01379443f, 
    -0.00590173f, 0.00687929f, -0.03402608f, -0.01548975f, -0.01807116f, -0.03860927f, -0.02901087f, 0.00823139f, 
    -0.01389191f, 0.00085771f, -0.02512194f, 0.03951437f, 0.02689835f, 0.00038334f, -0.03224096f, 0.01652115f, 
    -0.01448083f, -0.01743245f, -0.01501440f, -0.00021727f, 0.02696169f, -0.03996253f, -0.03029129f, 0.00319511f, 
    0.01656916f, -0.04122937f, -0.00195433f, -0.02621425f, -0.02607940f, 0.02602300f, -0.03517735f, 0.02725121f, 
    0.01274532f, -0.00292100f, -0.03238169f, 0.02446483f, -0.00408673f, -0.02405302f, -0.00732893f, -0.03324631f, 
    0.01816261f, 0.02917255f, -0.02812791f, 0.03142478f, 0.01812822f, 0.00291326f, -0.01555834f, -0.02968358f, 
    0.00406421f, -0.02434695f, 0.02436773f, -0.01205246f, 0.01009010f, 0.02504604f, -0.00521649f, -0.03492004f, 
    0.02089869f, 0.01883148f, 0.00873800f, -0.02912249f, -0.02816144f, -0.03326903f, -0.02096110f, 0.01885682f, 
    -0.03881423f, 0.00861809f, -0.02255998f, 0.03214254f, 0.03421421f, 0.02999666f, -0.03968140f, -0.00046873f, 
    0.01240239f, -0.02780139f, -0.02480814f, -0.02798638f, -0.02421768f, 0.00539332f, 0.00333450f, 0.00851867f, 
    0.01567880f, -0.00586724f, 0.01423613f, -0.00977022f, 0.00211241f, -0.01799340f, -0.02517723f, -0.00076944f, 
    0.01087565f, 0.00365184f, -0.02914914f, 0.03297584f, -0.02226674f, -0.01567604f, 0.02696907f, 0.02729052f, 
    -0.01195944f, -0.00830448f, -0.03276791f, -0.03586131f, 0.00692573f, -0.01334379f, 0.02507603f, -0.01067340f, 
    0.03992281f, 0.01009368f, 0.00261013f, 0.02437969f, 0.02370774f, 0.01385133f, 0.02594358f, -0.01079441f, 
    -0.02842412f, -0.02033103f, 0.00506202f, -0.03420470f, 0.02506329f, 0.02856840f, -0.02703106f, 0.02506648f, 
    0.03176923f, -0.00836884f, -0.00024186f, -0.02476916f, -0.00146518f, -0.00262507f, -0.03172925f, -0.02792851f, 
    0.01079465f, -0.01720096f, 0.02178574f, -0.02533557f, 0.01638906f, -0.00828183f, 0.03135292f, -0.01605554f, 
    -0.02283555f, 0.02289358f, -0.03921377f, 0.00412506f, -0.01672626f, 0.02227631f, -0.02489344f, 0.02722282f, 
    0.01110806f, -0.03696235f, 0.02121829f, -0.03629136f, 0.03847141f, -0.02200150f, 0.00481315f, -0.01950850f, 
    -0.01996282f, 0.02405568f, 0.03034063f, -0.03825664f, -0.00458263f, 0.01213568f, 0.01082672f, 0.01530990f, 
    0.00935542f, -0.01498910f, -0.03421816f, -0.00976981f, -0.03183686f, 0.02859227f, -0.01689426f, -0.01793890f, 
    -0.00793551f, 0.02247252f, -0.01973589f, -0.03044287f, 0.02456794f, -0.00612524f, 0.02162182f, 0.00847384f, 
    0.00439766f, -0.01781822f, -0.00709555f, -0.03579797f, 0.03846809f, -0.03817338f, 0.01566442f, -0.03088509f, 
    -0.00789944f, 0.02878983f, -0.03802773f, -0.01027517f, -0.02238285f, -0.03595440f, 0.01305430f, -0.02592351f, 
    -0.00546364f, 0.03296611f, 0.01806363f, 0.03348388f, -0.02980132f, -0.01054070f, -0.02001116f, 0.01489422f, 
    -0.01044680f, -0.02066432f, 0.02276410f, 0.01863444f, 0.02652519f, 0.01181918f, -0.02044769f, -0.03037339f, 
    0.04279609f, 0.02891827f, 0.02564179f, -0.00640422f, -0.00437312f, 0.00157748f, 0.00825028f, -0.02434342f, 
    0.02702010f, 0.02396379f, -0.02167414f, 0.01902825f, 0.00285511f, 0.02144339f, 0.02510705f, 0.03301298f, 
    0.00965167f, 0.02354369f, -0.04675092f, -0.01330723f, 0.02783893f, -0.00393637f, -0.03508527f, 0.00139629f, 
    -0.03913647f, -0.01588982f, 0.01160279f, 0.02819562f, -0.00453422f, -0.00310842f, -0.03026082f, -0.02892982f, 
    -0.01420686f, -0.03296318f, -0.03433395f, -0.00694295f, -0.03788128f, 0.02193923f, -0.00238137f, 0.02355199f, 
    -0.03113516f, -0.02907094f, 0.02071933f, 0.02146696f, 0.00219027f, -0.00833703f, -0.00526282f, 0.00804669f, 
    -0.00673502f, 0.01137586f, -0.03471075f, 0.01001603f, 0.00672752f, 0.01617618f, -0.01138038f, 0.02583335f, 
    -0.02525251f, 0.03936463f, 0.02664659f, 0.00950527f, 0.02169637f, -0.02892747f, 0.01336968f, 0.00743644f, 
    -0.01017019f, 0.01710428f, -0.02794321f, -0.02780117f, -0.03790376f, -0.00475385f, 0.02422267f, 0.00010393f, 
    0.01281150f, 0.01027400f, 0.00195507f, 0.01974085f, -0.01134703f, 0.03298664f, 0.02141639f, -0.02523664f, 
    0.01740447f, -0.01436170f, -0.02024863f, 0.00945250f, -0.01681367f, 0.02524810f, -0.03387238f, 0.02094257f, 
    0.03254471f, 0.01869361f, 0.01198159f, 0.00476680f, -0.03431115f, -0.01787340f, 0.00292466f, 0.02473268f, 
    0.02347853f, 0.01148838f, 0.01862525f, 0.01958937f, -0.03548086f, 0.03033165f, 0.01175254f, -0.03046458f, 
    -0.04151945f, -0.01629342f, -0.04146009f, -0.02950639f, 0.03212567f, 0.00929102f, 0.01132579f, 0.03167028f, 
    -0.01108983f, 0.00367471f, 0.02446370f, 0.00751809f, -0.01658947f, -0.01372559f, 0.02813105f, 0.01538017f, 
    0.02109775f, -0.01206971f, 0.02765266f, 0.02530254f, -0.02045604f, 0.00870696f, -0.02720030f, -0.03437178f, 
    -0.01180428f, 0.00554731f, 0.01690531f, -0.01984376f, -0.02393888f, -0.00362783f, 0.00596864f, -0.00387297f, 
    -0.02787424f, 0.00149089f, 0.02870486f, 0.00735375f, 0.02834229f, 0.02498782f, -0.00303720f, -0.02032150f, 
    -0.00918813f, 0.02671828f, -0.01648769f, 0.00271113f, 0.02955198f, -0.01610867f, 0.01736097f, 0.01072943f, 
    -0.01888413f, -0.00769218f, 0.01630414f, 0.01128579f, -0.03302426f, -0.03077777f, 0.00379643f, 0.00427405f, 
    0.01835822f, -0.01707184f, 0.01842524f, -0.03846869f, -0.02748933f, -0.03349871f, 0.01761718f, -0.01969679f, 
    0.00967888f, -0.02600247f, -0.00937151f, 0.02567109f, -0.00700435f, -0.02387479f, 0.01161921f, -0.00577205f, 
    -0.01589422f, -0.02100941f, 0.01477216f, 0.02423199f, -0.01741493f, -0.02081862f, 0.01396109f, 0.00682041f, 
    -0.01004253f, -0.03286242f, -0.02979404f, -0.02154157f, -0.00603209f, -0.01776019f, -0.03676242f, -0.01962410f, 
    -0.03871424f, 0.02288384f, -0.02313923f, -0.03126753f, 0.01467615f, -0.03340019f, -0.02384232f, 0.03139520f, 
    0.00989211f, -0.02115280f, 0.02950748f, -0.02342266f, -0.00494762f, 0.03100686f, 0.00630972f, -0.02252122f, 
    0.02247582f, 0.01296484f, 0.03033589f, 0.02243900f, 0.00788113f, 0.01231272f, -0.01674190f, -0.00714467f, 
    0.01614444f, 0.03091408f, -0.02323943f, 0.01978596f, -0.02017887f, 0.00925548f, -0.02362921f, 0.02896517f, 
    0.01888268f, -0.02475528f, -0.00977956f, 0.00543148f, 0.01738976f, -0.02563165f, 0.03359534f, 0.01179093f, 
    -0.02668606f, 0.03212591f, -0.03399977f, 0.00480218f, -0.01459735f, 0.01221493f, -0.00882605f, -0.01188891f, 
    0.02724799f, -0.02920431f, -0.01363020f, -0.01078452f, 0.00833309f, 0.01097695f, 0.00281512f, 0.03471924f, 
    -0.03766716f, -0.02494913f, -0.04276112f, 0.01974276f, 0.00590536f, 0.03178608f, -0.02370476f, -0.02317280f, 
    0.01065300f, -0.01332206f, -0.00125409f, 0.00248420f, -0.00824182f, 0.01197896f, -0.03474191f, -0.02660949f, 
    -0.01138187f, 0.02051458f, -0.02851388f, 0.02518816f, 0.01715458f, -0.01385886f, -0.02961173f, 0.02063781f, 
    0.00645153f, 0.01156754f, 0.01947010f, 0.03098962f, -0.00107051f, 0.01370743f, 0.01779869f, 0.00914093f, 
    -0.02134106f, -0.00556409f, 0.01975737f, 0.01865697f, -0.02857098f, -0.04082613f, -0.00771075f, -0.03511672f, 
    -0.00952239f, 0.00110567f, -0.01924619f, 0.01146194f, 0.00578098f, 0.03452963f, 0.01236520f, -0.01151726f, 
    0.01146925f, -0.03708385f, 0.02207285f, 0.01475761f, 0.02937499f, -0.00208326f, 0.02183890f, 0.00063253f, 
    -0.00630791f, -0.01789297f, -0.00275271f, 0.00398508f, -0.00199819f, -0.01031631f, -0.01298788f, -0.03989912f, 
    -0.01615776f, -0.03125795f, 0.02648267f, -0.02502698f, -0.02682992f, 0.00631753f, 0.00565446f, 0.00606035f, 
    0.01662472f, -0.01397827f, -0.04314025f, 0.01523840f, 0.02433148f, 0.02595241f, 0.00029472f, -0.03393262f, 
    -0.02110591f, -0.02086042f, -0.01982533f, 0.03024120f, -0.03625811f, -0.03439536f, -0.01336360f, 0.01815819f, 
    -0.03779904f, -0.00475528f, 0.02334568f, -0.03026548f, 0.01882178f, -0.02814835f, -0.00221044f, 0.02055863f, 
    -0.03679311f, -0.01218938f, 0.01705841f, -0.02632865f, 0.00933816f, -0.03349968f, 0.02206532f, 0.01833728f, 
    -0.00314563f, 0.00381184f, -0.01232830f, -0.02056723f, -0.04026655f, 0.01988256f, 0.00352330f, -0.02273689f, 
    -0.00882481f, -0.03141779f, -0.01892049f, -0.04028640f, 0.00670401f, 0.00379608f, -0.01147258f, -0.02219765f, 
    -0.03604789f, -0.00571070f, -0.02331754f, -0.01956264f, 0.02887702f, -0.00650373f, -0.03451878f, -0.03011301f, 
    -0.01603203f, 0.03020069f, 0.02723536f, 0.01662785f, -0.00169412f, 0.01696006f, -0.04178253f, -0.01594661f, 
    0.02015875f, -0.00373796f, -0.02731221f, 0.00364722f, -0.01180769f, -0.02324500f, -0.03103959f, 0.03371149f, 
    -0.03330163f, -0.01314121f, 0.02054784f, -0.02394175f, 0.01740824f, 0.01899968f, 0.00231894f, 0.03883058f, 
    -0.03447064f, 0.02217388f, -0.00612226f, 0.02946848f, 0.00051969f, -0.02258419f, 0.01112690f, 0.01064605f, 
    -0.00594562f, -0.01375324f, -0.04009921f, -0.03039950f, -0.01327405f, 0.01623830f, -0.02324364f, -0.02014680f, 
    -0.03585372f, -0.00550354f, 0.02428137f, 0.00702654f, -0.02092334f, -0.00861378f, -0.04058294f, -0.02335623f, 
    -0.03608357f, -0.02192081f, -0.03481270f, -0.03875799f, 0.00365173f, 0.01564895f, -0.00438875f, -0.03295331f, 
    0.00832654f, 0.01128583f, -0.01374808f, 0.01283809f, -0.00759890f, 0.01087112f, -0.02177142f, 0.00819972f, 
    -0.02328639f, -0.04304216f, -0.00191255f, -0.00217473f, -0.02898000f, 0.02863411f, -0.03457992f, -0.02527981f, 
    0.01114506f, -0.01185700f, 0.00623899f, -0.02940493f, -0.03157509f, -0.03177473f, -0.01189258f, -0.00302913f, 
    -0.02877403f, -0.03731775f, 0.01760694f, 0.01086647f, -0.02968560f, 0.01674738f, 0.00461740f, 0.01908875f, 
    -0.00648697f, 0.02316192f, -0.01101464f, -0.02169845f, 0.02006887f, -0.02790908f, -0.01252180f, -0.01590613f, 
    -0.02551513f, 0.02767724f, 0.00740034f, 0.01039041f, 0.01067311f, 0.00207286f, -0.01306174f, 0.02047182f, 
    -0.01943218f, -0.02260766f, 0.00449568f, 0.01403147f, -0.01854301f, -0.03181515f, 0.01301433f, -0.01932166f, 
    0.02316837f, -0.02725059f, -0.03506063f, -0.03007068f, 0.03097961f, -0.01057287f, -0.00921539f, 0.02673951f, 
    -0.02465327f, 0.00823143f, -0.00689085f, 0.02874644f, 0.01986626f, 0.00225212f, 0.02134632f, -0.00473645f, 
    -0.01663600f, -0.01960359f, -0.02283785f, -0.00345702f, 0.02459104f, -0.01179005f, 0.00360803f, 0.03024660f, 
    -0.01684248f, -0.00444279f, -0.03507403f, 0.00041291f, -0.01479134f, 0.01296401f, 0.03100459f, 0.01971093f, 
    0.00336240f, -0.00997447f, -0.01567746f, 0.02683789f, 0.01245274f, -0.02592870f, 0.01098696f, 0.01027436f, 
    -0.02243259f, -0.02730605f, 0.01165066f, 0.03036804f, -0.03481876f, -0.01814926f, -0.01056904f, 0.01444113f, 
    0.01352079f, -0.02975884f, 0.02772951f, 0.00815955f, -0.02674019f, -0.01520522f, 0.01667713f, 0.03363437f, 
    0.01871010f, -0.03200253f, 0.03198799f, -0.00089903f, -0.01539128f, -0.03315851f, 0.00785345f, -0.00457839f, 
    0.01931810f, -0.02082938f, -0.04063531f, -0.01638118f, 0.03074150f, 0.01872914f, 0.02393979f, -0.01217078f, 
    0.03478057f, -0.00916542f, -0.02701746f, 0.00136897f, -0.02948952f, 0.03093663f, 0.00537197f, -0.01206922f, 
    -0.00845517f, 0.02853100f, -0.02727202f, -0.01280033f, -0.02694944f, -0.01891988f, -0.03028502f, 0.02180929f, 
    0.03286630f, -0.02932474f, -0.04064482f, -0.02168475f, 0.02363643f, 0.03127510f, -0.00053177f, -0.01130543f, 
    0.03136681f, 0.00043240f, -0.03467529f, 0.03481924f, -0.02610019f, 0.01411171f, -0.01333485f, 0.00175577f, 
    -0.00388495f, -0.03655938f, -0.04106029f, -0.03113806f, 0.02992782f, 0.00606005f, 0.00305487f, -0.01946192f, 
    -0.01462884f, -0.02376761f, -0.02743668f, -0.04576863f, 0.01035689f, -0.02205154f, 0.01399532f, 0.01704024f, 
    0.02968703f, 0.02077914f, -0.00653146f, -0.03935139f, -0.00011471f, 0.00141539f, 0.02464140f, -0.00779719f, 
    -0.02949124f, -0.01852888f, -0.00597323f, 0.00189081f, -0.01772049f, 0.00525763f, -0.01949263f, 0.03608273f, 
    0.00232438f, 0.02716349f, -0.00214830f, -0.00487374f, -0.01722291f, -0.01080291f, 0.00260433f, 0.02265224f, 
    0.01042887f, -0.04543702f, 0.01656141f, 0.01595937f, 0.00157246f, -0.00564157f, -0.02859290f, -0.01115577f, 
    0.00204036f, 0.02122808f, -0.00862607f, -0.00613158f, -0.04142888f, 0.03246352f, -0.02213868f, 0.00121377f, 
    -0.02212550f, 0.00737490f, -0.04123061f, -0.03977743f, -0.04659221f, -0.03746112f, -0.00413930f, -0.00396089f, 
    -0.02980482f, 0.01903912f, -0.02315896f, -0.02045539f, -0.00142489f, 0.00466728f, 0.00831647f, 0.02185136f, 
    -0.02328862f, 0.02856988f, 0.02347375f, -0.03336219f, 0.01834465f, -0.01275066f, -0.01962067f, -0.01343878f, 
    0.00114212f, 0.01930618f, -0.01369269f, 0.01484752f, -0.03264364f, -0.03568470f, 0.02271046f, -0.03037864f, 
    0.01431835f, 0.00358880f, -0.03995222f, -0.02518624f, -0.03499933f, 0.01309975f, -0.02575621f, 0.02493377f, 
    -0.00963414f, 0.01128377f, 0.01309874f, -0.02913363f, 0.02449195f, -0.01859017f, -0.00140525f, -0.02290707f, 
    -0.03210045f, 0.00091415f, 0.01555963f, -0.00439273f, 0.00173383f, -0.03669206f, -0.02983488f, -0.01436001f, 
    -0.02271185f, 0.02496604f, -0.03084090f, -0.00677312f, -0.00228688f, -0.00682359f, -0.00979990f, 0.02040074f, 
    -0.03194828f, -0.01349309f, 0.01998010f, -0.00874159f, -0.01079916f, 0.01271071f, -0.01937375f, -0.01004619f, 
    0.00138746f, -0.01224732f, -0.02881186f, 0.02282814f, -0.00763681f, -0.01362725f, 0.02230073f, -0.01263341f, 
    -0.02527539f, 0.00799517f, -0.02067805f, 0.02284831f, -0.00531387f, -0.01738537f, 0.00631367f, 0.01800131f, 
    0.01581064f, -0.01369931f, -0.00237377f, -0.03813133f, -0.02811734f, -0.03110444f, 0.01635504f, 0.01565066f, 
    0.06570649f, -0.07856422f, 0.00210729f, 0.14407285f, -0.13004628f, 0.09802424f, 0.04772272f, -0.00638457f, 
    0.01708161f, 0.03580418f, 0.05812280f, 0.07860819f, 0.23523392f, -0.00444349f, -0.13815625f, 0.18907990f, 
    0.01612527f, -0.08938815f, 0.00698825f, 0.11585653f, 0.09407769f, -0.01614216f, 0.05821703f, 0.04887133f, 
    -0.13551190f, -0.15759645f, -0.03866927f, 0.13232554f, 0.03717873f, 0.11835170f, -0.01379403f, 0.02129528f, 
    0.05447362f, 0.13615397f, 0.00662935f, 0.00998739f, 0.00013717f, -0.25506872f, -0.02925381f, 0.07297526f, 
    -0.08963477f, 0.07756644f, 0.02257828f, 0.08242010f, 0.03666813f, 0.05687658f, 0.01882554f, 0.05828579f, 
    0.07156207f, -0.22702764f, -0.02539653f, 0.01244610f, -0.06319100f, -0.07787931f, -0.02368756f, 0.11233293f, 
    -0.12420560f, -0.00399918f, -0.00286606f, 0.04552882f, 0.07203237f, -0.08569605f, -0.00772753f, -0.01805341f, 
    0.06103269f, -0.05721748f, 0.05428886f, 0.08458328f, 0.01380734f, 0.01926894f, -0.06942020f, 0.01748418f, 
    -0.13187999f, 0.23861088f, -0.05290322f, 0.05684604f, -0.01532208f, 0.02003882f, -0.06272993f, 0.03526798f, 
    0.12783042f, -0.06136715f, 0.02662736f, -0.05504443f, -0.21714543f, -0.09214735f, 0.13912442f, 0.02513947f, 
    0.00829608f, 0.01757380f, 0.15102339f, 0.11967257f, -0.00575331f, -0.06710878f, 0.10780000f, 0.04524552f, 
    -0.22556178f, 0.20047739f, 0.14236155f, 0.12460639f, 0.12757747f, 0.02535472f, 0.02030488f, 0.13454847f, 
    0.05760361f, 0.03438153f, 0.10463304f, 0.05106836f, 0.15092212f, -0.06781337f, -0.07928338f, 0.03257599f, 
    0.00874258f, -0.03659263f, 0.04965988f, 0.12572752f, 0.04518900f, -0.00830939f, 0.10200997f, 0.10714952f, 
    0.02926560f, -0.01856362f, -0.03747628f, -0.03626710f, 0.01746560f, -0.03337951f, -0.02427964f, -0.05009725f, 
    -0.00379577f, 0.01983980f, 0.02120457f, 0.04823067f, 0.19820628f, -0.23741500f, -0.10731224f, -0.03330919f, 
    0.03307109f, 0.01011121f, -0.06586096f, 0.05772374f, 0.02208407f, -0.01411938f, 0.06957206f, 0.01753968f, 
    -0.17748000f, 0.01044563f, 0.17367850f, -0.00706270f, -0.02027048f, 0.21099301f, -0.03373199f, -0.07664065f, 
    0.05143223f, 0.00195862f, 0.02912625f, 0.04231331f, 0.07893360f, 0.10933571f, -0.06654142f, -0.02209070f, 
    0.02176292f, 0.01448710f, 0.06232059f, -0.03080142f, -0.04112099f, 0.02465105f, -0.00240900f, 0.09632079f, 
    -0.13481364f, -0.06622361f, 0.11524781f, 0.02982685f, 0.08072698f, 0.02494155f, 0.00745871f, 0.07560216f, 
    0.08578481f, 0.02885119f, 0.08265188f, 0.11307596f, -0.05197950f, -0.18021737f, -0.02070853f, 0.02913031f, 
    0.04978500f, 0.09193079f, 0.01585112f, 0.01459733f, 0.02598184f, 0.07177712f, 0.02365791f, 0.09728070f, 
    0.03702273f, -0.02863559f, 0.03068669f, 0.16367742f, -0.06380070f, 0.00329602f, -0.01083830f, 0.18749569f, 
    0.02522485f, 0.08555865f, 0.12227609f, 0.07271784f, -0.13898975f, 0.03287823f, 0.12800702f, 0.11652680f, 
    0.06273171f, 0.04491882f, 0.05216981f, 0.07481399f, 0.01404480f, 0.08108253f, 0.03773608f, -0.02863923f, 
    -0.23334312f, 0.24573538f, -0.04546136f, 0.08979854f, 0.11190509f, 0.10894280f, -0.02656231f, 0.12886788f, 
    0.10807103f, -0.00977492f, 0.05614296f, 0.05011979f, -0.18073927f, 0.07940432f, 0.13871109f, -0.09246391f, 
    0.01466402f, 0.12630747f, 0.05108913f, 0.04450036f, 0.11392458f, 0.01638847f, 0.04843166f, -0.00548639f, 
    -0.31971207f, -0.02856542f, 0.02951337f, -0.16164500f, 0.08431163f, 0.03565383f, 0.00589204f, 0.01080514f, 
    -0.07784439f, -0.03592510f, 0.08772448f, 0.01380124f, -0.20813847f, 0.12633225f, -0.08986600f, -0.11927675f, 
    0.11032637f, -0.05598730f, 0.06483261f, 0.04251004f, 0.02513344f, 0.01430624f, 0.07503005f, -0.02858490f, 
    -0.18770978f, -0.12294905f, 0.16378045f, 0.03495365f, 0.12642936f, 0.04064177f, 0.11349253f, 0.04998539f, 
    0.02976489f, 0.08247653f, -0.03173222f, 0.10117654f, -0.08620131f, 0.25682065f, 0.12314510f, -0.04351693f, 
    -0.08923722f, 0.05843963f, 0.03023803f, -0.04496931f, 0.02295141f, 0.01848980f, 0.10358666f, -0.04071372f, 
    -0.03168154f, 0.07797571f, -0.10483991f, -0.15821880f, 0.12934536f, -0.06392228f, -0.03162967f, 0.02060879f, 
    -0.02223320f, 0.04803006f, -0.04081030f, 0.04122702f, -0.32234544f, -0.08294535f, 0.05796820f, 0.02098162f, 
    0.08908346f, 0.14890492f, 0.04136632f, -0.11263879f, 0.10537043f, -0.01881285f, 0.07310236f, 0.03638522f, 
    0.34540561f, -0.03221579f, -0.21147075f, 0.08615354f, -0.07064479f, -0.02923813f, 0.05857431f, -0.01254984f, 
    0.05214529f, 0.06551417f, 0.01745944f, 0.00673531f, 0.12393191f, 0.21651050f, 0.03760019f, 0.00585384f, 
    -0.05407409f, 0.02699518f, 0.05154781f, -0.02647079f, -0.00192658f, 0.07389828f, 0.11388219f, -0.04387871f, 
    -0.35573366f, 0.05823813f, 0.17354971f, 0.06491254f, 0.04972858f, 0.08508240f, 0.11023484f, -0.05902250f, 
    0.05757389f, -0.00116371f, -0.01938494f, 0.06427538f, -0.14848730f, -0.28616941f, 0.02361373f, 0.10987805f, 
    -0.00747213f, 0.01163470f, -0.03137051f, 0.18899375f, -0.03921418f, 0.07345221f, -0.00754792f, 0.04472497f, 
    0.08693174f, 0.01515042f, -0.10433068f, 0.00167157f, -0.00596512f, -0.08951285f, 0.03115027f, -0.00778142f, 
    0.05731195f, 0.03152834f, -0.05428794f, 0.03338436f, 0.38128510f, 0.12096450f, -0.08603827f, -0.03114541f, 
    0.15495791f, -0.03538717f, -0.01812941f, 0.00443890f, -0.03121655f, 0.04222395f, 0.09168562f, 0.08021441f, 
    0.05611896f, 0.13303363f, 0.01239797f, -0.02587191f, 0.07124911f, -0.00113918f, 0.10980630f, 0.05889923f, 
    0.13966577f, -0.07270787f, 0.11638644f, 0.07048878f, 0.09261951f, -0.25383091f, 0.04601987f, 0.05592583f, 
    -0.04715553f, -0.03187952f, 0.08608634f, 0.00990679f, 0.05794527f, 0.13910055f, -0.02182318f, 0.09376357f, 
    0.02335479f, -0.03573967f, 0.00145018f, 0.08273830f, 0.02347110f, 0.01198853f, 0.07944894f, -0.05011831f, 
    0.10074078f, 0.02105753f, 0.02782530f, -0.02036986f, 0.13640846f, 0.06816896f, 0.08198890f, -0.01320762f, 
    0.08572354f, 0.00735176f, -0.02085496f, 0.10554795f, 0.05160448f, 0.02788311f, 0.10392613f, 0.08852366f, 
    -0.11414848f, -0.12925209f, 0.12489843f, 0.05124257f, -0.00688122f, -0.08690806f, 0.00422933f, 0.03424539f, 
    -0.03902045f, -0.01707861f, -0.03338814f, 0.07858414f, 0.10369116f, 0.09876242f, -0.03551862f, -0.07618033f, 
    0.06307638f, -0.08960266f, -0.03643728f, 0.03927378f, 0.07737965f, 0.01602482f, 0.04789701f, 0.07688200f, 
    -0.19312756f, -0.13027726f, 0.04654250f, 0.00845454f, 0.00514068f, -0.03607851f, -0.03341321f, 0.08106605f, 
    -0.02210123f, -0.00622329f, -0.01117257f, 0.10342249f, 0.19573720f, 0.03154687f, -0.01029227f, -0.08607493f, 
    0.13729036f, -0.07745171f, -0.04349548f, 0.04964688f, 0.06324403f, 0.06496453f, 0.05347805f, -0.04884670f, 
    0.01470700f, -0.09665322f, -0.12976198f, 0.00303618f, -0.01611535f, -0.12451426f, -0.00220577f, 0.06937857f, 
    -0.01258646f, -0.01501300f, 0.07905764f, -0.01375874f, -0.15322708f, 0.09833699f, -0.22489852f, 0.04141740f, 
    0.04043141f, -0.08017648f, -0.02499628f, 0.02329466f, 0.03112730f, 0.08939942f, 0.01079515f, 0.08639263f, 
    0.08443829f, -0.24006060f, 0.01241971f, 0.06411953f, 0.04509972f, -0.01287018f, -0.00522945f, 0.09408433f, 
    0.03747491f, 0.08706183f, 0.09500669f, 0.11117195f, 0.23908131f, -0.26196980f, 0.03744427f, -0.06946841f, 
    -0.01318261f, 0.01653672f, 0.03157211f, 0.01733978f, -0.08836158f, 0.07186524f, -0.00557033f, 0.02780101f, 
    0.09604239f, -0.06543741f, 0.08479030f, 0.18136583f, 0.05009754f, 0.00433784f, 0.05836008f, 0.13045724f, 
    0.10661397f, 0.16669624f, 0.03219755f, 0.09568986f, -0.16374266f, 0.04824459f, -0.03176740f, -0.19418435f, 
    0.09782211f, 0.04901743f, -0.04421534f, 0.04115473f, 0.03384583f, 0.01367240f, 0.01015744f, 0.01043604f, 
    -0.02499417f, 0.21399070f, -0.11102559f, -0.15784532f, 0.07346015f, -0.04406548f, -0.05507873f, 0.09202003f, 
    0.04932225f, 0.06023737f, 0.11089204f, -0.04403043f, 0.01935734f, 0.00856261f, 0.10561201f, 0.10848049f, 
    -0.02942279f, 0.03455298f, 0.06954723f, 0.03904698f, -0.02366825f, 0.04756086f, -0.07009771f, 0.10133414f, 
    -0.14458115f, -0.09219038f, -0.00318398f, 0.28560546f, 0.04975041f, 0.02444665f, 0.01414389f, 0.13307533f, 
    0.02522059f, 0.06523921f, 0.01933632f, 0.08416889f, -0.08296780f, -0.09305210f, -0.01656092f, -0.00911338f, 
    -0.09736311f, -0.02686080f, -0.03155063f, -0.11157440f, -0.00605017f, -0.03016860f, 0.02184919f, -0.04395347f, 
    -0.05319316f, 0.15837392f, -0.16224264f, -0.11831076f, 0.13899434f, 0.01766356f, 0.00986475f, 0.06839761f, 
    0.03899940f, -0.08060665f, -0.00874080f, -0.09681348f, 0.04251842f, 0.14206421f, 0.10676885f, -0.12103190f, 
    0.08155987f, 0.00969357f, 0.05051336f, 0.01040904f, -0.03431519f, 0.02882442f, -0.04576584f, 0.05867612f, 
    -0.16191135f, 0.01519099f, 0.05309650f, -0.13916965f, 0.11494388f, 0.07128325f, -0.01554988f, 0.06616046f, 
    -0.09201721f, 0.00195757f, -0.06195264f, -0.02858375f, -0.21233128f, 0.05752727f, -0.14178120f, 0.05909242f, 
    0.07748567f, -0.03954818f, 0.00062272f, -0.00257840f, 0.06199403f, 0.03915574f, -0.03746774f, 0.09613332f, 
    -0.00698835f, 0.08069605f, -0.08495583f, 0.03388799f, -0.10092889f, -0.01912101f, 0.01376705f, 0.00359704f, 
    0.01973911f, 0.07142825f, 0.04718595f, 0.03101680f, -0.09569664f, -0.02028768f, -0.00314005f, -0.06452709f, 
    0.12571597f, 0.02236002f, -0.00945734f, -0.08900744f, -0.08307716f, 0.06789318f, 0.08245766f, -0.06185903f, 
    0.06644037f, 0.12486316f, -0.08347449f, -0.09543604f, 0.16488028f, -0.03418289f, 0.09644466f, 0.03489896f, 
    0.03104125f, 0.01504639f, 0.02595983f, 0.05742884f, -0.14219236f, 0.02520121f, -0.07769694f, -0.17189793f, 
    0.01858868f, 0.17095260f, 0.05779033f, 0.04674375f, -0.00956815f, -0.01262763f, -0.00373735f, 0.00945028f, 
    -0.11561073f, -0.03040799f, -0.04028546f, -0.16921207f, 0.05845297f, 0.06101492f, 0.02337550f, 0.02792890f, 
    0.01898065f, -0.00054409f, 0.04277107f, 0.00724433f, -0.31582418f, -0.03846892f, -0.02491795f, -0.04140015f, 
    0.12859960f, 0.04530174f, -0.08255392f, -0.01541092f, 0.01817377f, -0.03220177f, 0.00741118f, 0.05267908f, 
    -0.41034985f, -0.07974806f, 0.15858744f, -0.13711187f, 0.04171866f, 0.11444821f, -0.03290831f, -0.03860341f, 
    0.00082567f, -0.02369076f, -0.08630063f, -0.02246144f, 0.20121677f, -0.06338371f, 0.00733998f, -0.11272436f, 
    0.04113604f, 0.03205284f, 0.07066276f, 0.09776305f, -0.00908144f, 0.06024080f, 0.01712193f, 0.13480131f, 
    0.00647593f, 0.08762868f, -0.04437757f, 0.05549188f, 0.04629242f, -0.06358460f, -0.06329077f, 0.02890706f, 
    0.06062744f, 0.08345392f, -0.01390545f, -0.06266586f, -0.13995770f, -0.26238480f, 0.11640075f, 0.02593828f, 
    -0.06086666f, -0.01012325f, 0.08000691f, 0.04980000f, 0.05597278f, 0.00877125f, 0.03656866f, 0.00449647f, 
    0.11036005f, -0.29142070f, -0.08339565f, 0.06472310f, 0.01502800f, 0.03718238f, 0.03027517f, 0.15319432f, 
    0.04232343f, 0.05708298f, -0.11310744f, 0.08138635f, 0.05681130f, 0.00512963f, 0.05583246f, 0.03147272f, 
    0.07591766f, 0.08684508f, -0.08629439f, 0.09671760f, -0.04383015f, 0.19182301f, -0.20491518f, -0.08906916f, 
    -0.14583613f, -0.10895730f, 0.09638352f, 0.02399135f, 0.02935166f, -0.13734692f, 0.08263589f, 0.07767779f, 
    0.06183668f, -0.03148304f, -0.10230457f, -0.04776816f, 0.02686914f, -0.14136803f, 0.03544004f, 0.05208942f, 
    -0.02526707f, -0.00413434f, 0.05828241f, 0.07853280f, 0.05219423f, -0.09519304f, -0.06812596f, -0.04673491f, 
    0.17495972f, -0.11527020f, -0.02088232f, 0.02255013f, 0.02922773f, -0.13356858f, 0.09346806f, 0.07577991f, 
    0.08091951f, 0.00941075f, 0.00488433f, 0.06069995f, 0.13955659f, 0.02906418f, -0.00465739f, 0.04970425f, 
    0.02190490f, 0.04055853f, -0.06098462f, -0.03171873f, 0.12405015f, 0.01508151f, 0.05599634f, -0.03366431f, 
    0.29304701f, -0.04970789f, 0.11476349f, -0.00356199f, -0.00252619f, 0.00876038f, 0.05446167f, 0.00489812f, 
    0.04642621f, 0.08574544f, -0.08061964f, 0.02164929f, 0.11132357f, 0.03391666f, -0.06374842f, -0.03899977f, 
    0.04990463f, -0.04690117f, -0.06712902f, -0.02171736f, 0.09335131f, 0.02955967f, -0.10454832f, 0.01447753f, 
    0.17815137f, -0.01790796f, 0.06743089f, -0.22649577f, 0.05529163f, 0.02955407f, -0.08985731f, 0.08308851f, 
    -0.02087749f, -0.08927152f, 0.13542053f, 0.01299362f, 0.03825833f, -0.01330485f, -0.10335746f, -0.04469991f, 
    0.07605671f, -0.12790929f, -0.12144697f, -0.13769236f, -0.03716019f, 0.09310641f, 0.03731316f, -0.01128195f, 
    0.17024215f, -0.01465167f, -0.02929637f, 0.07197984f, 0.10723203f, -0.02115308f, -0.06881160f, -0.02665890f, 
    0.03783926f, 0.06981238f, 0.04227297f, -0.05369213f, -0.11115056f, 0.01385018f, 0.02180673f, 0.04602611f, 
    -0.00468801f, -0.05737282f, 0.04963544f, -0.01131266f, 0.15392049f, 0.04710071f, -0.07505499f, 0.07374884f, 
    -0.01358916f, 0.09328461f, 0.13469423f, 0.05678799f, 0.06681012f, 0.00792083f, 0.09230511f, 0.08811566f, 
    0.15490474f, -0.11438636f, -0.05208306f, 0.04773074f, 0.21413265f, 0.01124518f, 0.00243474f, 0.09114934f, 
    0.00898386f, -0.06331922f, -0.11716360f, 0.06896056f, 0.07873285f, -0.01635552f, -0.02531895f, -0.02384299f, 
    0.01183745f, 0.00542877f, -0.17737444f, 0.00092740f, -0.00869450f, -0.05562756f, 0.02319561f, 0.05566175f, 
    0.05634540f, -0.14066102f, 0.06160558f, -0.11882435f, 0.18442509f, 0.27289155f, 0.04050624f, 0.06889359f, 
    -0.03361504f, 0.11567929f, -0.06024326f, 0.03147589f, -0.00584873f, -0.00675361f, 0.10212516f, -0.14074659f, 
    -0.17432202f, -0.02770400f, -0.03511640f, -0.04905942f, 0.02262460f, 0.00076741f, 0.07631331f, -0.08593267f, 
    0.17468467f, -0.07450436f, -0.03454284f, 0.12409256f, -0.07350116f, 0.15309256f, -0.06696446f, -0.12760897f, 
    0.00742281f, -0.00463512f, -0.04629319f, 0.03445913f, 0.01293582f, -0.02191435f, 0.03478779f, 0.02070933f, 
    0.12655966f, -0.14635529f, 0.05400025f, -0.10675813f, 0.00473283f, 0.08047783f, 0.00563038f, -0.05200280f, 
    -0.00380341f, -0.01448942f, -0.00105541f, 0.05745127f, 0.22071864f, 0.05588775f, -0.04022777f, 0.01223807f, 
    -0.02892765f, -0.02003946f, 0.10999180f, -0.03456060f, 0.01772356f, -0.05562275f, 0.06663773f, 0.04117852f, 
    0.14359927f, 0.06137453f, 0.12681028f, 0.23550341f, -0.00277790f, 0.02639011f, 0.05994741f, 0.00602012f, 
    0.02229507f, 0.04622728f, -0.03294194f, 0.12014502f, 0.11636832f, -0.16140789f, 0.06307818f, 0.09051562f, 
    -0.03458399f, 0.04294128f, -0.02755427f, -0.00781362f, 0.09610416f, 0.05516488f, 0.09854641f, 0.15690252f, 
    -0.04821787f, -0.06919841f, -0.15180367f, -0.03320827f, 0.09583872f, 0.06627716f, -0.07454912f, 0.02196169f, 
    0.00995007f, 0.00471997f, 0.02320598f, 0.06286030f, 0.06498791f, -0.22926314f, 0.05744755f, -0.07380660f, 
    -0.00768701f, -0.01944095f, -0.07199495f, 0.17329778f, 0.03710696f, 0.07106764f, 0.10207057f, 0.04379408f, 
    0.03109246f, 0.11180471f, 0.05698298f, 0.17627345f, -0.08141837f, 0.04972009f, 0.17174019f, 0.01775466f, 
    0.18313560f, 0.07928797f, 0.08607678f, -0.06840653f, 0.40306535f, 0.02581289f, -0.03634220f, 0.02128374f, 
    0.05330202f, 0.02012516f, -0.00577639f, -0.06698152f, -0.04045979f, 0.01751991f, 0.00999546f, 0.03359232f, 
    -0.00303667f, -0.05999571f, 0.05354502f, -0.12929881f, -0.03120823f, 0.04894967f, 0.07658236f, 0.03700496f, 
    0.00801539f, 0.14465302f, 0.04246030f, 0.10051191f, -0.20390883f, -0.00218357f, 0.02376741f, 0.01279211f, 
    -0.03541383f, -0.01088200f, 0.04703348f, 0.16407800f, 0.09312011f, -0.02003913f, 0.09584915f, 0.16229570f, 
    0.14239855f, 0.11620540f, -0.01841142f, 0.09831757f, -0.02389049f, -0.03854321f, 0.01822434f, 0.06751914f, 
    0.00622270f, -0.04873902f, 0.07241657f, 0.10080629f, 0.07814203f, -0.15148099f, -0.12816888f, -0.01242249f, 
    0.06179199f, 0.01880938f, -0.03387785f, 0.05442850f, 0.03739190f, -0.16188335f, -0.00222694f, 0.03707378f, 
    0.00646149f, 0.05972795f, -0.02107090f, 0.04181357f, 0.05050859f, 0.03127608f, 0.04116692f, 0.00102499f, 
    0.11049907f, 0.05369339f, 0.13308656f, -0.12321161f, -0.14471716f, 0.02233012f, -0.03039170f, 0.06295146f, 
    -0.07806122f, 0.10007777f, 0.05083597f, -0.03331954f, 0.03761361f, -0.00924214f, 0.04330713f, -0.05226127f, 
    0.07262611f, -0.05514557f, 0.02151655f, 0.04814366f, 0.05226755f, -0.00173191f, 0.08869811f, -0.09327716f, 
    -0.11561864f, 0.15079854f, -0.00988811f, 0.15509224f, -0.00471176f, 0.01701393f, -0.08978339f, -0.18131131f, 
    0.02600307f, 0.13471453f, -0.07875603f, 0.01743516f, 0.13443384f, 0.03418718f, 0.19553019f, 0.00222922f, 
    -0.02259217f, -0.02279317f, -0.02692379f, -0.05114713f, 0.01709900f, -0.01738082f, -0.04808486f, 0.13914192f, 
    -0.01929301f, 0.04482776f, 0.03048562f, 0.18047118f, -0.01568163f, 0.07711911f, -0.11560926f, -0.00408211f, 
    0.02755481f, 0.03468049f, 0.07220950f, 0.02667007f, -0.03669033f, -0.16796249f, -0.02824881f, -0.17867781f, 
    0.00618415f, -0.01996304f, -0.00882489f, -0.02536653f, 0.09505967f, 0.13744494f, 0.08935817f, 0.04878058f, 
    0.12276225f, -0.00708111f, 0.05950640f, 0.04569336f, -0.24431776f, -0.14369680f, 0.01659391f, 0.00897772f, 
    0.07634502f, 0.04089728f, 0.08630710f, 0.04150818f, -0.00207848f, -0.01763593f, -0.06140363f, -0.02725107f, 
    -0.18431254f, -0.03721855f, 0.11653038f, -0.11885352f, 0.05146014f, 0.14321125f, -0.00344197f, 0.04345958f, 
    0.06699979f, 0.06142242f, 0.04746633f, -0.00691630f, -0.05136560f, 0.01880718f, 0.09114698f, 0.12530859f, 
    -0.02270448f, -0.02980995f, 0.04628238f, -0.12963508f, -0.04695375f, -0.06379387f, 0.02788290f, 0.01243285f, 
    -0.05082251f, -0.00520970f, 0.04184942f, -0.05691014f, 0.04732955f, 0.02747764f, 0.03175529f, -0.04442192f, 
    0.07966322f, 0.09343845f, -0.04130536f, 0.13039483f, 0.11419056f, 0.06663342f, 0.14881195f, 0.07846688f, 
    -0.00686783f, -0.03900713f, -0.10767215f, 0.09861057f, 0.15675540f, -0.00628508f, 0.09825309f, -0.05864564f, 
    -0.10260631f, 0.03622871f, 0.18418509f, -0.05468409f, -0.02081494f, 0.03786118f, 0.05412346f, 0.00038904f, 
    0.15540124f, 0.08665151f, -0.07478008f, 0.10029075f, 0.09012530f, 0.03624610f, 0.00227032f, 0.06418771f, 
    0.08425700f, 0.07955112f, -0.02996804f, -0.02436536f, -0.02111831f, -0.09851757f, 0.01298632f, -0.04325590f, 
    -0.12992166f, -0.00553199f, -0.04634892f, -0.02200297f, 0.05145848f, -0.09115985f, 0.06812774f, 0.06277806f, 
    0.02806088f, -0.05512969f, -0.13399598f, 0.05958555f, 0.08611014f, -0.02757220f, 0.04990798f, 0.15676454f, 
    -0.00605614f, 0.03167845f, 0.02614895f, -0.02339486f, 0.03264533f, 0.06917234f, -0.06746385f, 0.03281853f, 
    0.04913899f, 0.03968157f, 0.04970273f, 0.10048205f, 0.02861169f, 0.07153267f, 0.00186046f, 0.02483921f, 
    0.08555552f, 0.00274211f, -0.06828763f, -0.02499833f, -0.08979986f, 0.10435139f, -0.06476374f, -0.09752224f, 
    0.11712923f, 0.11136562f, 0.00366622f, 0.09249180f, -0.00232228f, 0.09399518f, 0.18898684f, 0.10701697f, 
    -0.05198035f, -0.08816200f, -0.19632368f, 0.11098071f, 0.11409407f, 0.01097207f, -0.04613381f, 0.07692258f, 
    -0.06168012f, 0.01067416f, 0.05945169f, 0.00641270f, 0.01248067f, -0.10533001f, 0.07968670f, 0.00741970f, 
    0.07299006f, 0.06766246f, -0.01927991f, 0.06718078f, 0.02233620f, 0.01164363f, 0.09128100f, 0.22482845f, 
    0.09606900f, -0.07433455f, 0.16751209f, -0.03114877f, -0.01040861f, 0.02764818f, 0.00609275f, -0.02681600f, 
    0.13695900f, -0.10767831f, 0.05186207f, 0.08314253f, -0.03167493f, 0.06782882f, 0.03881993f, 0.05677129f, 
    -0.07144495f, -0.05096366f, -0.01792609f, 0.07643381f, 0.10042841f, 0.17667548f, 0.17626180f, 0.07492907f, 
    0.09666218f, -0.08969719f, -0.07009298f, 0.04478737f, 0.02231640f, 0.04746342f, -0.02839174f, -0.05419204f, 
    -0.03175085f, -0.12383816f, 0.19043048f, 0.00550222f, 0.06968746f, 0.12572348f, 0.07641594f, 0.01161441f, 
    0.01787557f, 0.06788845f, -0.14461093f, -0.06564154f, -0.00006923f, -0.03082031f, -0.00118469f, -0.20293976f, 
    0.11439419f, -0.14299341f, -0.08128640f, -0.04722222f, -0.01056600f, 0.06788006f, 0.00943788f, 0.11072810f, 
    0.01698126f, 0.05576737f, 0.16273619f, -0.03423928f, 0.21093437f, 0.07946863f, 0.05178902f, 0.11414327f, 
    -0.05051756f, -0.00885338f, 0.07062375f, 0.10546542f, 0.08259618f, 0.06795983f, -0.16710661f, 0.07791312f, 
    -0.00213853f, 0.12403908f, 0.02733716f, 0.00296726f, 0.08731968f, 0.03344183f, 0.03306786f, -0.06066422f, 
    0.02973541f, 0.10055128f, -0.02492896f, 0.12377180f, 0.02130177f, -0.06328522f, 0.11461474f, -0.03428090f, 
    -0.00746763f, -0.07419243f, 0.08550321f, -0.02061449f, -0.06554258f, 0.11087417f, -0.01051218f, -0.00881441f, 
    0.00298947f, 0.10179032f, 0.07156584f, 0.16755307f, 0.04135422f, -0.00628417f, 0.06575049f, 0.00876725f, 
    0.03529418f, 0.05650666f, 0.10476629f, 0.16791900f, 0.18985985f, 0.06654099f, 0.10285903f, 0.02762651f, 
    0.01075574f, -0.01610181f, -0.00065840f, -0.00938837f, 0.02008370f, 0.01739557f, 0.06849290f, 0.01162859f, 
    0.22200605f, -0.07329286f, 0.02731354f, 0.16595665f, 0.04518367f, 0.07244642f, 0.02362783f, 0.02125437f, 
    0.06556790f, -0.02851472f, 0.12653950f, 0.02772095f, 0.05424625f, -0.11347995f, -0.08495731f, 0.15335737f, 
    -0.02744419f, -0.05626777f, 0.05584385f, 0.03827136f, 0.02837328f, -0.06251036f, -0.04011207f, -0.04096283f, 
    0.17815474f, -0.15945338f, 0.00144928f, 0.08997020f, 0.08218059f, 0.09383419f, 0.05149863f, 0.08950187f, 
    0.03249773f, -0.04697913f, 0.10141952f, -0.03330871f, 0.05544470f, 0.05744893f, -0.18365702f, -0.08030373f, 
    -0.03226366f, 0.10918276f, -0.01669368f, 0.15158619f, 0.08686057f, 0.08919942f, 0.09871353f, 0.02006577f, 
    -0.02663982f, -0.02018080f, 0.01033975f, 0.01046348f, -0.03674383f, -0.03185641f, -0.03131581f, 0.01702980f, 
    -0.01395475f, -0.02549219f, -0.02084990f, -0.00976794f, 0.01842794f, 0.00747884f, -0.00238300f, 0.01445005f, 
    -0.00996587f, -0.00571908f, -0.01419500f, -0.01233691f, -0.01459738f, 0.00128650f, -0.00943154f, 0.01575740f, 
    0.03580818f, -0.03536508f, -0.03639169f, 0.00697030f, -0.03365539f, -0.03906331f, 0.02513341f, 0.00169159f, 
    0.01000696f, -0.00469699f, -0.00052079f, 0.01542799f, -0.01554273f, 0.02066233f, -0.01146888f, -0.02498853f, 
    -0.03287861f, -0.01289691f, -0.01882315f, 0.01577639f, -0.01991780f, -0.02249791f, 0.01203866f, -0.03910412f, 
    -0.01955788f, -0.01300341f, -0.00619844f, -0.02556021f, 0.00538838f, 0.02649168f, 0.01698908f, -0.03619295f, 
    0.00528685f, 0.00229134f, -0.03276300f, 0.00742296f, 0.00368293f, 0.01820307f, 0.02492001f, -0.00780888f, 
    -0.02066699f, -0.04115435f, 0.00546602f, -0.03692245f, -0.03290098f, -0.03743490f, -0.02019486f, -0.01870008f, 
    -0.01043213f, -0.02610726f, 0.00891356f, -0.02742637f, -0.03362403f, -0.01897520f, 0.01363928f, -0.02681753f, 
    -0.00729450f, -0.03455187f, 0.01152945f, -0.00014483f, -0.01135357f, -0.01888150f, -0.01265765f, -0.01158451f, 
    -0.03423644f, -0.02034905f, -0.00973685f, 0.03422251f, 0.02012452f, -0.03776458f, -0.01011462f, -0.01532222f, 
    -0.01589120f, -0.03352162f, 0.01222773f, -0.01595977f, 0.00004658f, -0.02465374f, 0.02349507f, 0.01781391f, 
    0.00875228f, -0.02602272f, 0.02101470f, 0.00061502f, -0.03707225f, -0.01491640f, 0.01116685f, 0.02478588f, 
    -0.00107881f, 0.00379565f, 0.01322168f, -0.01146772f, -0.00918864f, 0.01683851f, -0.03702193f, -0.01439779f, 
    0.00051288f, -0.00921557f, 0.01857141f, 0.00428304f, -0.01921594f, -0.01184248f, -0.03034249f, 0.02312521f, 
    -0.02079499f, -0.03615735f, 0.02182713f, -0.02455601f, -0.01635400f, -0.03379348f, -0.03262816f, -0.01737471f, 
    -0.00403402f, -0.02198990f, -0.01708886f, 0.02503842f, 0.00383432f, 0.01323401f, -0.00811698f, -0.03750041f, 
    0.02323539f, -0.00746835f, -0.03078916f, -0.04116856f, -0.03997298f, -0.01822856f, -0.00193796f, -0.03655246f, 
    0.01705678f, -0.04154944f, -0.01584042f, -0.00865130f, -0.02356239f, 0.00758631f, -0.00814893f, -0.03282108f, 
    0.02810762f, -0.04022778f, -0.03510068f, 0.01633294f, 0.02290664f, 0.01851282f, -0.03050570f, -0.00495566f, 
    0.02413547f, -0.03150909f, -0.00569756f, -0.00336781f, -0.03175864f, -0.03509312f, -0.03303809f, 0.00970264f, 
    0.01442667f, -0.02509582f, -0.02281973f, 0.00046453f, 0.02386104f, -0.00652307f, 0.02336924f, -0.02773598f, 
    0.00555087f, 0.00456453f, -0.01693914f, -0.00954274f, 0.00209183f, -0.03473809f, -0.03272638f, 0.01217423f, 
    0.00407422f, -0.01469320f, -0.01552266f, -0.01202980f, 0.02615324f, 0.02236199f, 0.02342464f, 0.02554444f, 
    -0.00197167f, -0.00071237f, 0.00316745f, 0.00268054f, -0.04085741f, -0.00316567f, 0.01365429f, -0.03788701f, 
    -0.02977055f, -0.01276702f, -0.02631301f, 0.02290252f, -0.00088447f, -0.02427204f, -0.02148234f, 0.02534780f, 
    -0.03537626f, -0.00748203f, 0.00415764f, -0.00438263f, 0.01198348f, 0.01316822f, 0.00717743f, -0.00731249f, 
    0.01899367f, -0.02408987f, 0.02942664f, 0.02086317f, -0.01869371f, -0.04032861f, -0.04085023f, 0.00859051f, 
    -0.02244471f, 0.00212364f, -0.01552092f, 0.00397187f, -0.02415756f, 0.00862849f, -0.01748633f, 0.00223624f, 
    -0.03467321f, -0.02862049f, -0.01227005f, -0.02021529f, -0.02968057f, -0.00044990f, -0.01175788f, -0.03091851f, 
    0.01629489f, -0.01793198f, 0.02099428f, -0.01846382f, 0.02969095f, 0.02025645f, -0.01906001f, 0.00453485f, 
    0.02512351f, 0.00150389f, -0.01761208f, -0.02155413f, 0.02171835f, -0.03506670f, -0.00611609f, -0.00977771f, 
    0.01569253f, -0.00866191f, 0.00884278f, -0.01335443f, -0.00061016f, -0.01335707f, 0.00555584f, -0.00079940f, 
    0.02941461f, 0.02334300f, -0.02763763f, 0.00007678f, -0.00526098f, 0.01345411f, 0.01033386f, 0.00449496f, 
    0.00915377f, 0.00990475f, 0.00906844f, 0.00903391f, 0.02987417f, 0.01760214f, 0.01371744f, -0.02856808f, 
    -0.02857647f, 0.00782476f, 0.00975928f, 0.02797300f, 0.02584697f, 0.02240328f, -0.00891118f, -0.02865926f, 
    -0.03761135f, -0.02445278f, -0.00371555f, -0.00725860f, -0.01444451f, -0.02271244f, 0.02771129f, -0.00519378f, 
    -0.03719043f, -0.00443257f, 0.02681730f, 0.01646259f, -0.03452700f, 0.01225366f, -0.02438681f, 0.02877086f, 
    -0.02415809f, 0.01798296f, -0.03857159f, -0.02464801f, -0.02636790f, 0.00325072f, -0.02825214f, 0.00573676f, 
    0.01564837f, 0.00696860f, 0.02396848f, 0.00041778f, 0.00236232f, -0.02890014f, -0.00142538f, 0.01883184f, 
    -0.02808561f, 0.02315756f, -0.00409653f, -0.02548582f, 0.02032331f, -0.01906937f, 0.01893659f, 0.02090001f, 
    0.00354309f, 0.00669352f, -0.01319017f, -0.04129799f, -0.01935447f, 0.00239876f, -0.02528957f, -0.02656892f, 
    0.02326393f, -0.01337573f, -0.03378991f, -0.00352899f, -0.01788119f, -0.03538722f, -0.01128286f, -0.01635962f, 
    0.02340076f, 0.01922172f, 0.03539272f, 0.01464827f, 0.01212268f, -0.02151297f, -0.02247146f, -0.03593834f, 
    0.01469394f, 0.02779408f, 0.00501654f, -0.00662855f, 0.00833411f, -0.01131835f, 0.02103449f, 0.00817127f, 
    -0.04054313f, -0.03304681f, 0.02119310f, -0.00715779f, -0.03908794f, 0.01533518f, -0.02193439f, 0.00926659f, 
    -0.01797855f, 0.02439404f, 0.02931893f, -0.00194197f, -0.01790210f, -0.01217632f, -0.00262406f, -0.01419534f, 
    0.00424965f, 0.00572617f, -0.02981660f, 0.02559672f, 0.01205440f, 0.01357099f, -0.02955182f, 0.02235870f, 
    0.00444554f, -0.02840717f, -0.02405474f, -0.02108302f, -0.03942190f, -0.02794485f, -0.00578086f, -0.03610302f, 
    -0.03573882f, -0.02486112f, -0.00110908f, -0.01061369f, -0.03225983f, -0.02875694f, 0.01313440f, -0.01395531f, 
    -0.01038457f, -0.01408527f, -0.01727421f, 0.00243598f, -0.01321385f, 0.00555662f, 0.01067941f, 0.01322894f, 
    -0.03620763f, -0.00780744f, -0.00200551f, -0.02000618f, -0.00667592f, -0.00820029f, 0.01532342f, -0.01180227f, 
    -0.02910355f, -0.02207432f, 0.01072977f, -0.03778842f, -0.04130112f, -0.03140507f, 0.02596070f, 0.01620716f, 
    -0.04127675f, 0.02694357f, -0.03624773f, -0.01341491f, -0.00628419f, -0.03829148f, 0.00914564f, 0.01496644f, 
    -0.01808235f, 0.02292141f, 0.00865932f, -0.03550167f, -0.00915322f, -0.01522491f, 0.02697752f, -0.00653327f, 
    0.00279860f, -0.04047567f, -0.00429306f, 0.00885424f, -0.01887140f, -0.02065463f, 0.01081526f, 0.01442260f, 
    -0.02514686f, -0.02906191f, 0.01687385f, -0.00012729f, 0.00364919f, -0.03342338f, 0.02909238f, -0.02577455f, 
    0.02028237f, -0.01631864f, -0.01130541f, 0.01593893f, -0.00964824f, -0.02814065f, 0.00025143f, 0.02905424f, 
    -0.02251753f, 0.02524919f, -0.00048936f, -0.01788562f, -0.01265383f, 0.01162492f, 0.02250845f, -0.00120206f, 
    -0.02807657f, -0.00713435f, -0.03430178f, 0.02117701f, -0.04032479f, -0.01829444f, -0.00228287f, 0.00639136f, 
    -0.02218328f, -0.03307436f, -0.03373933f, -0.02957147f, -0.00419690f, 0.00851418f, 0.01937462f, -0.02610992f, 
    -0.03906411f, -0.00810611f, -0.03071867f, -0.00833414f, -0.02088692f, 0.02112888f, -0.03159064f, 0.00400132f, 
    0.01273083f, 0.01969764f, -0.00589518f, -0.03929880f, -0.00191369f, -0.02090771f, -0.01255796f, 0.00826146f, 
    -0.00137510f, -0.01856204f, -0.03780231f, -0.03124370f, -0.01727439f, -0.01420750f, -0.01963713f, -0.03017248f, 
    0.00740053f, 0.01518757f, 0.02350315f, -0.01407550f, 0.00375392f, -0.02872544f, 0.01130110f, -0.01622815f, 
    0.00531397f, -0.03531604f, -0.02606358f, -0.03970863f, -0.02713853f, -0.00876126f, -0.00184174f, -0.02263855f, 
    -0.03442571f, -0.03541201f, -0.01220721f, 0.01318672f, -0.03428885f, -0.03947710f, -0.01285087f, 0.00237625f, 
    -0.02644876f, 0.02140399f, -0.01598486f, 0.02481989f, -0.02068241f, 0.02488025f, -0.01389903f, 0.01729373f, 
    0.02780230f, 0.00804662f, 0.00149973f, 0.00680705f, -0.02385340f, 0.02264264f, 0.01927705f, -0.01450260f, 
    0.00281830f, 0.01218643f, 0.00108183f, 0.01535887f, -0.00063565f, 0.00977636f, 0.02766011f, -0.04131060f, 
    -0.00018629f, -0.01893340f, -0.00541846f, 0.02168790f, -0.02435521f, -0.03559083f, 0.02510110f, -0.01153263f, 
    -0.03597051f, -0.01980880f, -0.00999574f, -0.02749089f, 0.01294831f, 0.01609486f, 0.03006156f, -0.03643705f, 
    -0.03857122f, -0.03126970f, 0.02171048f, 0.02644865f, -0.00446861f, -0.03552399f, -0.00609885f, 0.00052153f, 
    0.02583765f, 0.01898860f, -0.02018863f, -0.01069908f, -0.01800482f, -0.02667457f, -0.04110721f, -0.02280066f, 
    0.00721561f, -0.03184512f, 0.02146758f, -0.03300861f, -0.02941181f, -0.00211729f, -0.04136468f, 0.02805637f, 
    0.00090650f, -0.00241587f, -0.01237144f, -0.03493916f, -0.01307419f, -0.03138007f, 0.02212298f, 0.03029047f, 
    0.02481611f, -0.03811637f, -0.03987358f, -0.02429590f, -0.02756615f, 0.02940276f, 0.01519175f, -0.03890603f, 
    -0.02135009f, -0.00527001f, -0.00667819f, -0.02667767f, -0.03357016f, 0.00268250f, -0.03666905f, 0.02695144f, 
    -0.01556412f, -0.00135826f, 0.01008589f, -0.03217540f, -0.03017925f, 0.02052198f, -0.03037951f, -0.03370357f, 
    -0.03752881f, 0.02332917f, -0.00463955f, 0.00206683f, -0.03255930f, -0.03795106f, -0.02302400f, -0.00993880f, 
    -0.00445462f, -0.00752841f, -0.03827289f, -0.01077889f, -0.03264892f, -0.00184854f, -0.01747261f, 0.02555574f, 
    0.03040170f, 0.02447406f, -0.02248364f, -0.03660879f, -0.00894387f, -0.02220978f, -0.00600976f, -0.01833727f, 
    -0.00648596f, -0.03849721f, 0.02464495f, 0.01549908f, 0.02542773f, -0.03984178f, 0.03047620f, -0.01400157f, 
    -0.03866291f, 0.01224318f, -0.01497141f, 0.00408896f, 0.00911153f, -0.01079396f, -0.00324177f, -0.01087981f, 
    -0.01581701f, 0.01559262f, -0.00342383f, -0.02582373f, -0.02017929f, -0.01178620f, 0.00789289f, -0.00744858f, 
    0.01709898f, -0.02402063f, -0.01674730f, -0.02343828f, -0.03314563f, -0.03155372f, 0.01741549f, -0.03826273f, 
    0.02206397f, -0.02808893f, -0.01772806f, -0.01385069f, -0.01379163f, 0.01092399f, -0.01291319f, 0.02698361f, 
    -0.02219368f, 0.02958873f, 0.00850321f, -0.03214928f, 0.02933490f, -0.03925182f, -0.03341852f, 0.00935957f, 
    -0.00566066f, -0.02553553f, 0.00717495f, -0.01774074f, 0.02532442f, 0.00705751f, -0.03861049f, 0.01579234f, 
    -0.03159734f, -0.01543259f, -0.03315623f, -0.01582179f, -0.00875757f, 0.01436130f, 0.02482678f, -0.01952715f, 
    -0.02807397f, 0.01139267f, -0.00221651f, -0.02546600f, -0.00284590f, 0.01993240f, 0.02285606f, 0.00210349f, 
    0.00332518f, -0.01361613f, -0.02499022f, 0.01818477f, -0.00869622f, 0.02668134f, -0.03371732f, -0.01936607f, 
    0.01887367f, 0.02877117f, -0.03675260f, -0.03072592f, -0.02790049f, 0.00792689f, -0.03660240f, -0.00810298f, 
    0.00217637f, 0.00601744f, 0.01108300f, -0.02417529f, -0.02785390f, 0.02198878f, 0.00095600f, -0.02186653f, 
    0.02801843f, 0.02329488f, 0.01508746f, -0.00126540f, -0.00889619f, -0.00826925f, -0.02449829f, 0.02315270f, 
    -0.01186637f, -0.01340938f, -0.03552547f, -0.01707882f, 0.01980498f, -0.04055466f, -0.02424355f, 0.02678427f, 
    0.00478139f, -0.03781307f, -0.00797343f, -0.03098528f, -0.01358115f, 0.00842258f, 0.00036120f, 0.00847516f, 
    0.02223993f, 0.02764303f, -0.00157737f, -0.01330214f, 0.00418677f, 0.02700299f, 0.00788302f, -0.00375410f, 
    0.00089786f, -0.02634360f, 0.00802014f, 0.03571159f, 0.00908616f, -0.03577662f, 0.00331663f, -0.03381706f, 
    0.01188614f, 0.02087580f, 0.01936928f, -0.03649909f, 0.00541142f, -0.01105543f, -0.03192246f, -0.03310867f, 
    0.00735709f, -0.04013508f, -0.02685109f, -0.02383075f, 0.03209463f, -0.02235637f, 0.01327100f, -0.03682026f, 
    -0.03243233f, -0.02136520f, 0.01017128f, -0.01075095f, 0.02478221f, -0.02929192f, -0.01639854f, -0.03875348f, 
    0.00639773f, 0.02216247f, -0.02048793f, -0.03179744f, -0.00976981f, 0.01096778f, 0.01861471f, -0.01668286f, 
    0.00933682f, 0.01209527f, -0.02202519f, -0.01153914f, -0.04107839f, -0.03772544f, -0.04116398f, 0.01057644f, 
    0.01245270f, -0.01742105f, -0.03325317f, -0.00333682f, 0.01503352f, -0.00263240f, 0.02953888f, -0.02936004f, 
    -0.03676658f, -0.00050783f, -0.01964692f, -0.00358637f, -0.03144946f, 0.01752819f, -0.01395223f, -0.03053096f, 
    -0.00613857f, 0.00104031f, -0.01299596f, 0.02744579f, 0.00257620f, -0.00839688f, 0.02150562f, -0.02415349f, 
    -0.00027315f, 0.00089785f, -0.00928599f, 0.00504593f, -0.00144433f, -0.02425152f, 0.00827233f, 0.02627433f, 
    0.00466064f, 0.02472283f, 0.01818983f, 0.00100482f, 0.02237600f, 0.00441175f, -0.01033952f, 0.00787128f, 
    -0.02132842f, 0.02690076f, -0.00201923f, 0.02418556f, -0.01663650f, -0.00881948f, -0.01420979f, 0.00599204f, 
    -0.01208183f, -0.03704903f, 0.01496566f, -0.03165033f, -0.03817228f, -0.01155399f, 0.02016669f, -0.01770378f, 
    -0.02303897f, 0.00687311f, -0.00843704f, -0.00333710f, 0.02391269f, 0.02592056f, 0.01596265f, 0.02058779f, 
    -0.03020154f, -0.03735987f, 0.00825791f, 0.00745704f, 0.01155490f, -0.03948613f, -0.01875772f, 0.00849162f, 
    -0.00888408f, -0.01431923f, 0.02581438f, 0.02924117f, -0.01025624f, 0.01965403f, -0.03472184f, 0.01833468f, 
    -0.02116866f, 0.01474943f, 0.00574034f, -0.00975093f, 0.02477480f, 0.01383824f, -0.02649788f, 0.02496918f, 
    0.00833084f, -0.00902274f, -0.03188659f, 0.01936139f, -0.01972244f, -0.01623073f, -0.01866968f, 0.01609508f, 
    -0.03952412f, -0.00833555f, -0.00953856f, 0.01989159f, -0.02172041f, -0.03931035f, 0.00732013f, 0.00165826f, 
    -0.02694507f, -0.01120251f, -0.02101413f, -0.03198750f, 0.01257621f, -0.01846635f, 0.01135025f, -0.03284738f, 
    -0.03318942f, -0.00992298f, 0.02085122f, 0.00589143f, -0.03692256f, -0.02380114f, 0.00865836f, -0.01586670f, 
    0.02409899f, -0.01454418f, -0.02564038f, 0.00558584f, -0.00686188f, 0.02864806f, -0.01271343f, 0.02907428f, 
    0.01334453f, -0.00545854f, -0.00692904f, -0.01827464f, -0.01148640f, 0.00806766f, 0.00945478f, -0.03071124f, 
    0.01166179f, -0.02756855f, 0.00771892f, 0.02080222f, -0.00910132f, -0.02580256f, 0.01412268f, -0.03554679f, 
    -0.00149561f, -0.01291446f, 0.01252675f, 0.00276693f, 0.03051837f, 0.01789551f, 0.00968742f, -0.02822910f, 
    -0.00980471f, 0.01378916f, -0.01416544f, -0.01895079f, -0.01034944f, -0.02748652f, -0.02622738f, -0.01966453f, 
    -0.01622377f, -0.03012596f, -0.03292910f, 0.00139534f, -0.03205858f, 0.00294850f, -0.03067326f, 0.00118884f, 
    0.02988931f, 0.01696896f, 0.02504719f, -0.03003179f, -0.00260672f, -0.00710482f, 0.01451727f, -0.03456646f, 
    0.00936109f, 0.02242217f, -0.03115999f, -0.00089782f, -0.01453567f, 0.00341725f, -0.01086736f, 0.00888502f, 
    0.01909020f, -0.03311826f, -0.02139583f, -0.03294017f, -0.03448657f, 0.02124930f, 0.01231522f, 0.00741037f, 
    -0.01546326f, -0.03275875f, -0.03596786f, -0.02512764f, -0.03935545f, -0.01796082f, -0.02129115f, -0.01563584f, 
    0.01535224f, -0.00302651f, 0.00590635f, 0.01228130f, -0.03879204f, -0.04030129f, -0.02370512f, -0.00687869f, 
    0.02046435f, -0.00996951f, 0.00971891f, 0.04199499f, 0.00453569f, -0.02163812f, -0.02949307f, -0.02288385f, 
    -0.00522242f, -0.00090960f, -0.02217884f, 0.02379785f, -0.02309531f, -0.01473726f, 0.02997518f, 0.02251144f, 
    -0.01004190f, -0.00822257f, 0.02625805f, 0.01537107f, 0.02976517f, -0.01293916f, -0.03673125f, 0.01871518f, 
    0.00149544f, 0.01492156f, -0.02099253f, -0.01532108f, 0.00209475f, 0.01877086f, -0.03057337f, 0.00631443f, 
    0.01435311f, -0.01810060f, 0.01913945f, -0.00688924f, 0.00172269f, 0.00108172f, -0.01593846f, -0.04101747f, 
    -0.01240925f, -0.01849136f, -0.03030371f, 0.01111032f, -0.04050351f, 0.02127824f, -0.02336379f, 0.00077115f, 
    -0.00579910f, -0.00021304f, 0.01131518f, -0.01912839f, -0.03142054f, -0.01719789f, -0.02991774f, -0.02358190f, 
    -0.01973841f, -0.00278996f, 0.02826163f, 0.00439918f, -0.01916755f, 0.02104090f, -0.02745176f, -0.02922122f, 
    0.00151740f, 0.02933137f, 0.00602548f, 0.03716143f, -0.01554381f, -0.02926903f, 0.01874393f, 0.01778590f, 
    -0.02835612f, 0.00623849f, 0.01905145f, 0.02397783f, -0.00746677f, 0.01895177f, -0.01874096f, 0.00953874f, 
    -0.00675592f, 0.00152804f, 0.02156837f, -0.00322925f, -0.02886986f, -0.04147157f, -0.00004255f, -0.01062781f, 
    0.01932265f, -0.03294341f, -0.01900064f, -0.01619116f, -0.01470861f, -0.03892194f, -0.01333421f, -0.01470152f, 
    0.02042868f, 0.02421741f, -0.00710660f, -0.02027257f, -0.03728880f, 0.01977533f, -0.01661887f, -0.02529015f, 
    0.01114183f, -0.01100310f, -0.00992286f, -0.00347155f, 0.01433369f, 0.00026748f, -0.00006023f, -0.02781841f, 
    -0.03405263f, -0.02559453f, 0.02816569f, -0.00068414f, -0.03794618f, 0.00753162f, -0.02398433f, -0.02402629f, 
    0.00241806f, -0.00423439f, -0.02884204f, -0.01742350f, 0.01817285f, -0.01653434f, 0.03005973f, -0.03943117f, 
    -0.04029359f, -0.03517328f, 0.00284136f, 0.00764173f, -0.01483861f, 0.02781249f, -0.02322311f, -0.00934975f, 
    -0.02982660f, 0.02822439f, 0.01461989f, 0.01192088f, -0.00138113f, -0.01487207f, -0.02322963f, 0.00639062f, 
    -0.00497492f, 0.01328314f, -0.03187455f, -0.02452307f, 0.02802800f, -0.00790222f, 0.01249403f, 0.00308973f, 
    -0.02029721f, -0.01882128f, -0.02693943f, 0.02419120f, -0.00312133f, 0.01866827f, 0.01820151f, 0.02554501f, 
    -0.03025972f, 0.00981875f, -0.00758086f, 0.01146833f, 0.00620734f, -0.04069837f, -0.02130383f, -0.01042865f, 
    -0.01552195f, 0.00293670f, -0.02609538f, 0.02883853f, -0.00353636f, 0.01570710f, -0.00258885f, -0.01366539f, 
    0.01557571f, 0.01248731f, -0.02385432f, 0.00043849f, -0.00191203f, -0.00604783f, -0.03242159f, -0.02668979f, 
    -0.00673342f, -0.02697080f, 0.00313137f, 0.01061094f, -0.03100706f, 0.00799930f, 0.00820210f, -0.04059697f, 
    -0.01388991f, -0.03255480f, 0.02336380f, -0.02561110f, -0.02250389f, -0.00821579f, -0.01798797f, 0.01587349f, 
    0.01598441f, -0.01085547f, 0.01443319f, -0.02548421f, -0.01351732f, -0.03250220f, 0.01765551f, -0.01061538f, 
    -0.02187969f, -0.02068079f, 0.02014853f, -0.02117306f, -0.04090805f, 0.00256477f, -0.00872729f, -0.02210171f, 
    -0.01991334f, 0.01496794f, 0.01125753f, -0.01272408f, -0.01513255f, 0.02868275f, -0.02825414f, -0.03863970f, 
    -0.01873489f, -0.01847800f, -0.02242102f, -0.00303637f, -0.00647658f, -0.00672481f, 0.03000356f, -0.02795097f, 
    0.02029618f, -0.01106438f, 0.00226759f, -0.01318305f, -0.01940285f, -0.03247970f, 0.00976523f, -0.01389636f, 
    -0.01439129f, 0.02622890f, 0.03322741f, -0.00863176f, 0.00681334f, 0.00206077f, -0.02609724f, 0.01305055f, 
    0.01882409f, 0.01932161f, -0.00269827f, 0.01104409f, 0.01563137f, 0.01867030f, 0.02806165f, 0.00280901f, 
    -0.03008565f, -0.00521613f, 0.03110542f, -0.02822410f, -0.02590673f, 0.01340369f, 0.00465701f, 0.01471983f, 
    0.00382000f, 0.01197982f, 0.00436781f, -0.02382078f, 0.02415508f, 0.00114241f, 0.00786391f, -0.01284791f, 
    -0.01385812f, -0.04134471f, -0.01097857f, 0.03089555f, -0.00205561f, 0.02159361f, -0.02590845f, 0.01831854f, 
    -0.00561718f, -0.00710595f, 0.02898146f, -0.02357340f, -0.02620830f, -0.02955204f, -0.01400449f, 0.00107083f, 
    -0.01156815f, -0.00955094f, 0.02425534f, 0.02051435f, 0.01939489f, 0.02322059f, 0.00320014f, 0.01651836f, 
    -0.02253870f, 0.02001847f, -0.02296697f, 0.02851385f, 0.00008110f, -0.01129325f, -0.02796770f, -0.03311964f, 
    -0.01126356f, -0.01267552f, 0.01341092f, -0.00584087f, 0.01790550f, 0.02288740f, -0.02578039f, -0.00471563f, 
    -0.02825892f, 0.01594130f, 0.00820629f, -0.00524565f, 0.01112245f, 0.03068730f, -0.01589897f, 0.01475732f, 
    -0.00951063f, -0.04145900f, 0.01571810f, 0.00260961f, -0.00941490f, 0.00163739f, 0.02547262f, 0.02152653f, 
    -0.03776523f, 0.02075244f, -0.04154302f, -0.03270226f, -0.00468948f, 0.01631898f, -0.00195328f, 0.01538489f, 
    -0.00892439f, -0.02885244f, -0.00052460f, 0.00706575f, -0.03118206f, 0.00631344f, -0.03865856f, 0.00025664f, 
    0.02144467f, 0.02761477f, -0.02719970f, -0.02033480f, 0.00045555f, -0.02593282f, -0.00743439f, 0.00371895f, 
    0.01002220f, -0.01845511f, 0.00125383f, 0.02969699f, 0.00070572f, -0.00141553f, -0.01813040f, -0.02730298f, 
    -0.01245424f, -0.02968976f, -0.01272061f, 0.02198187f, 0.02002993f, 0.02015338f, -0.03174096f, -0.02697115f, 
    -0.02205667f, 0.00433832f, 0.01547941f, -0.02230920f, 0.02728121f, -0.02873659f, -0.03555972f, 0.01990897f, 
    -0.03245556f, -0.01681433f, -0.02797615f, -0.00676677f, -0.03900702f, -0.00424458f, -0.01260643f, 0.02696556f, 
    0.02782886f, 0.00593247f, 0.02675936f, -0.02205180f, -0.01709276f, 0.02860406f, -0.01111112f, 0.02666996f, 
    -0.04044674f, -0.03497594f, -0.01830349f, 0.01749753f, 0.00959177f, -0.00175820f, -0.02620462f, 0.02844666f, 
    0.02227213f, -0.01853066f, -0.03503216f, -0.02421878f, 0.01496259f, -0.02110508f, -0.03745514f, 0.01902159f, 
    0.02915503f, 0.02976509f, 0.02110754f, -0.02707740f, -0.01161774f, 0.02087621f, 0.00424310f, 0.02231242f, 
    -0.00487071f, 0.00486631f, -0.03578200f, 0.00372083f, 0.00148242f, 0.00273317f, 0.00559511f, -0.01117126f, 
    -0.03769708f, 0.00333442f, -0.03688329f, -0.00625346f, 0.00567812f, -0.02373921f, -0.01787955f, -0.01692113f, 
    -0.01980397f, -0.03790227f, 0.00617433f, 0.01487601f, -0.01040076f, 0.02061522f, -0.03356424f, 0.01205392f, 
    0.01487764f, -0.01846979f, -0.03951714f, -0.01739441f, -0.02717217f, 0.00261698f, -0.00545242f, 0.00191227f, 
    0.00974855f, -0.02158206f, -0.03807539f, 0.01244775f, 0.00100182f, -0.03962689f, 0.00099714f, 0.01562879f, 
    0.00908737f, 0.01379794f, 0.01628751f, -0.00263505f, -0.02429806f, 0.02987708f, 0.00163450f, -0.01565544f, 
    0.00025470f, 0.00882292f, 0.01689494f, -0.02804000f, 0.01609964f, -0.03241025f, -0.02646925f, -0.01335058f, 
    -0.04051941f, -0.01920506f, -0.03810485f, 0.02383814f, -0.00640156f, 0.00791461f, 0.02206538f, -0.00493302f, 
    0.01597850f, -0.01023503f, -0.03518955f, 0.02713908f, -0.00242369f, -0.00845529f, 0.02838956f, 0.03112505f, 
    -0.07467383f, 0.19138642f, 0.13558172f, -0.21040609f, 0.14142455f, 0.05024627f, -0.04936792f, 0.02697662f, 
    -0.01681163f, 0.02022773f, -0.02618259f, 0.01703307f, -0.02375889f, -0.11531045f, 0.11820909f, -0.11368150f, 
    0.05183637f, 0.02618319f, 0.08837380f, -0.00660759f, -0.04408439f, -0.04146815f, 0.06471705f, 0.12226446f, 
    0.11067659f, 0.14795825f, -0.03758913f, -0.01403199f, -0.00769762f, -0.03139697f, 0.03913774f, 0.01919242f, 
    -0.03881161f, 0.00238398f, 0.05361182f, 0.08342827f, -0.06977197f, -0.02493709f, 0.04472657f, -0.10318965f, 
    0.03924372f, 0.02578080f, -0.02460195f, -0.05919126f, 0.03237099f, 0.10665236f, 0.04561185f, -0.08554596f, 
    -0.11223138f, 0.07024090f, 0.09000169f, 0.05329539f, 0.05844099f, 0.06598834f, 0.07722028f, -0.06731075f, 
    0.02467559f, 0.06308129f, -0.01535839f, -0.04162185f, -0.21274292f, -0.06100108f, 0.02872160f, 0.05705274f, 
    -0.09024055f, 0.00561988f, 0.03752401f, -0.02824565f, -0.07198658f, -0.04854935f, 0.03979426f, -0.03285692f, 
    -0.34656331f, -0.15462150f, -0.09896295f, 0.01396051f, 0.02304046f, -0.04154027f, 0.10559350f, 0.01548030f, 
    -0.05677611f, 0.03551519f, 0.05339319f, 0.02733933f, 0.00543023f, -0.01709418f, -0.06015776f, 0.13481063f, 
    0.04811008f, -0.00808380f, 0.03343818f, -0.05148302f, -0.02254098f, 0.05441324f, -0.04648748f, -0.05982616f, 
    -0.05065256f, -0.09742462f, -0.13047044f, 0.31693479f, -0.05238332f, 0.07652204f, 0.06112667f, -0.03965149f, 
    0.13051131f, 0.03959307f, 0.00802778f, 0.02486465f, -0.19381495f, 0.06240400f, 0.10482134f, -0.02257526f, 
    -0.07752570f, 0.00474258f, -0.02148486f, 0.10019608f, -0.04650071f, 0.07763197f, -0.02852406f, 0.06970923f, 
    -0.23723550f, 0.01325059f, -0.09720020f, -0.24189907f, 0.02480716f, -0.00796276f, -0.03479918f, 0.14531489f, 
    -0.05909134f, 0.01926368f, 0.03578804f, 0.07381687f, -0.27137032f, 0.11062592f, -0.05409091f, -0.06291968f, 
    -0.01124297f, -0.04888865f, 0.00414066f, 0.13802595f, -0.12394831f, 0.03367743f, -0.00658424f, 0.04218220f, 
    0.12674394f, -0.01223689f, -0.05510115f, -0.00651563f, 0.04053654f, -0.01736832f, 0.06316836f, -0.00434450f, 
    0.03449357f, 0.08187955f, 0.07037289f, 0.08865828f, -0.06140999f, -0.07251806f, 0.06917373f, -0.22139190f, 
    0.01227218f, -0.01149391f, -0.00052651f, 0.20538113f, 0.06153650f, 0.01835521f, -0.01153668f, -0.00157058f, 
    0.01258959f, -0.02669400f, -0.01487547f, 0.13153246f, -0.01270300f, -0.00058005f, 0.02434180f, 0.02960807f, 
    -0.05881229f, 0.09362596f, -0.01538832f, -0.03064992f, -0.10697919f, -0.12053593f, -0.10147236f, -0.04356905f, 
    0.04225463f, -0.06213335f, -0.01217485f, 0.04306610f, 0.01431387f, -0.02876300f, -0.05555534f, -0.00518395f, 
    0.10099837f, 0.10390715f, -0.00549601f, -0.01072657f, 0.06250089f, 0.03792625f, -0.06939556f, 0.11349762f, 
    -0.12339084f, 0.07942064f, 0.13993917f, -0.12586927f, 0.36058518f, -0.07649358f, 0.12676813f, 0.05543534f, 
    -0.01650811f, 0.01692472f, -0.05397465f, 0.06742888f, 0.03941799f, 0.04644581f, 0.00310457f, 0.09879795f, 
    0.00282754f, 0.00851907f, -0.07951052f, 0.21689391f, 0.11559507f, -0.04938534f, 0.14214092f, -0.03452565f, 
    0.01333304f, 0.03486715f, -0.02560274f, -0.03264517f, -0.17397216f, -0.06903589f, -0.02850346f, 0.03326075f, 
    0.18487774f, 0.06709015f, -0.06791573f, -0.01373320f, 0.07954606f, 0.00238936f, 0.02317596f, -0.00842671f, 
    0.00021653f, -0.03301080f, 0.06184936f, 0.05030301f, -0.04218633f, 0.04579834f, -0.01784639f, -0.01376398f, 
    0.02855697f, 0.02922955f, -0.01986244f, 0.06053697f, -0.14093477f, -0.01107664f, 0.01972313f, 0.05090185f, 
    0.10148163f, 0.03880702f, 0.07818981f, -0.00289489f, 0.02373187f, -0.03165943f, 0.03544653f, 0.03119492f, 
    0.09928241f, 0.05095424f, 0.15713863f, 0.02995177f, -0.05177011f, -0.02161831f, 0.06748101f, -0.02452875f, 
    0.03149103f, -0.00595215f, 0.08484158f, -0.01351518f, 0.02965254f, 0.03049060f, -0.07640039f, 0.06901933f, 
    0.18039565f, -0.04734830f, 0.06549132f, -0.00892023f, 0.05359736f, -0.02380249f, 0.05083232f, 0.07877374f, 
    0.03927363f, -0.05226301f, -0.06562441f, -0.18834300f, 0.06860350f, 0.00985489f, -0.06023549f, 0.11962604f, 
    -0.04776360f, -0.06581761f, 0.00834231f, -0.01027556f, -0.30774865f, -0.06534362f, 0.03410981f, -0.15777166f, 
    0.11010095f, 0.06347842f, 0.01194629f, 0.01468988f, 0.03939246f, -0.00926116f, -0.00468722f, 0.03711728f, 
    0.02036098f, 0.17886753f, 0.02329694f, 0.06719440f, 0.02043488f, 0.01139821f, 0.02457446f, 0.05419135f, 
    -0.08793282f, -0.09842549f, 0.09414870f, 0.04722134f, 0.21812156f, 0.12392347f, 0.17047876f, -0.15557998f, 
    0.19013968f, 0.09045179f, -0.04492782f, 0.06812737f, 0.05896433f, -0.03300042f, 0.01774929f, 0.00478274f, 
    0.13718581f, -0.18615475f, 0.03871419f, -0.25743276f, 0.05950644f, 0.04409908f, -0.10817456f, 0.07002610f, 
    0.08257589f, -0.00134107f, 0.06697135f, 0.00468225f, -0.11093362f, 0.14468253f, 0.04900845f, 0.12442419f, 
    0.03325853f, -0.02602869f, 0.02772686f, -0.06606942f, 0.00953562f, 0.02779551f, 0.11447631f, -0.08431233f, 
    -0.09423929f, -0.08703104f, 0.02082543f, 0.09728676f, -0.03047472f, 0.05973688f, 0.00303531f, -0.03575752f, 
    -0.02400585f, -0.08243751f, 0.09287616f, 0.02879900f, -0.20938830f, -0.11255129f, -0.02510627f, -0.20967749f, 
    0.04687576f, 0.09765583f, -0.07596178f, 0.02468863f, 0.01823123f, 0.00459266f, -0.01584881f, -0.05426039f, 
    -0.17007065f, 0.06995311f, 0.05037784f, 0.00769595f, 0.07424979f, 0.07178138f, -0.02899634f, -0.00682787f, 
    0.12681706f, -0.04152159f, -0.07294425f, 0.00714207f, -0.02426424f, 0.08453531f, 0.11798782f, 0.20704411f, 
    -0.04659412f, -0.02361267f, -0.01385117f, -0.02189237f, -0.02494478f, 0.03816887f, 0.08134001f, -0.02062163f, 
    -0.00867057f, 0.23253183f, -0.18660203f, 0.04294606f, 0.21099843f, -0.13095467f, 0.04761935f, 0.00355697f, 
    0.06881927f, 0.02909824f, 0.02381975f, -0.08622746f, 0.04016639f, 0.20920002f, 0.11971748f, 0.19555795f, 
    -0.02274013f, 0.01174032f, -0.04579284f, 0.05131155f, 0.07512511f, 0.11289105f, -0.01161531f, 0.04468009f, 
    -0.02391241f, 0.02093673f, 0.04988876f, 0.18646309f, -0.01064439f, 0.03853764f, -0.00210554f, -0.01212755f, 
    0.01969826f, -0.05510933f, 0.03520865f, -0.07701512f, 0.13587710f, 0.17183360f, -0.01729098f, 0.08178387f, 
    0.04747817f, 0.05469237f, 0.08526297f, 0.11274048f, 0.03743766f, 0.08259048f, 0.06311677f, -0.05951365f, 
    0.20185958f, 0.10256191f, -0.09566317f, 0.18467261f, -0.04640914f, 0.00768703f, 0.02100474f, -0.08114604f, 
    -0.01936200f, -0.06729697f, -0.04350514f, -0.10935094f, -0.08557390f, 0.08897514f, 0.03144703f, -0.11998416f, 
    0.08993212f, 0.08617699f, -0.05857535f, 0.12870991f, 0.09195320f, 0.04748994f, -0.03315208f, 0.01288596f, 
    0.16080938f, 0.12691954f, 0.07633617f, 0.09124108f, 0.04205966f, 0.02362724f, 0.00494340f, 0.07182325f, 
    -0.06641481f, -0.05973494f, -0.03617987f, -0.06670134f, 0.03403077f, -0.06594864f, -0.03711485f, -0.26604828f, 
    0.10608113f, -0.05323350f, 0.03908468f, -0.08782098f, -0.02347767f, -0.04088219f, 0.03181677f, -0.02585271f, 
    0.21386972f, 0.16047065f, 0.02015228f, 0.24597982f, 0.02907246f, 0.12334979f, -0.00944384f, 0.03291975f, 
    -0.06204147f, 0.01198591f, -0.02145410f, 0.03739162f, -0.14198390f, 0.16612396f, 0.02061826f, 0.05961066f, 
    -0.03983146f, -0.00126664f, -0.03678666f, 0.08777049f, -0.03818285f, 0.06961627f, 0.01622977f, -0.00547592f, 
    -0.02967347f, 0.21980016f, 0.10695564f, -0.10736345f, -0.01268087f, -0.01905649f, 0.02480771f, -0.03641148f, 
    -0.03333211f, -0.02165776f, 0.03431907f, 0.10991904f, 0.03787553f, 0.06378021f, -0.07313634f, 0.08058462f, 
    0.05056584f, 0.03680159f, 0.01066336f, -0.08274393f, 0.02198805f, 0.04902922f, 0.03611887f, 0.06445719f, 
    0.02693567f, -0.09160684f, -0.02354170f, -0.04856514f, -0.01007059f, 0.03718570f, 0.06179232f, 0.03590729f, 
    0.03617747f, 0.01542926f, 0.07736269f, 0.03249979f, 0.21697624f, 0.08523570f, -0.04815077f, 0.12945433f, 
    0.10305146f, 0.00714918f, 0.02884748f, -0.00407774f, 0.09161253f, -0.08090398f, 0.02683380f, 0.03010297f, 
    0.10732399f, 0.00166687f, 0.27256495f, -0.22763936f, -0.04031268f, -0.07715982f, 0.08726407f, -0.01512165f, 
    -0.01289234f, -0.02806981f, 0.09432696f, 0.04115355f, 0.00864680f, 0.20347184f, -0.10424794f, 0.00596873f, 
    0.10055756f, -0.01848239f, 0.10427012f, 0.11662414f, 0.14254595f, 0.04974842f, -0.09076449f, 0.00221362f, 
    -0.08570963f, 0.00478722f, -0.06118343f, -0.03370752f, 0.00803913f, 0.03426797f, 0.08616717f, -0.03669840f, 
    -0.00070457f, -0.02503401f, 0.12924118f, 0.09266739f, 0.25631455f, -0.02361186f, -0.01484366f, 0.12089621f, 
    -0.05623787f, -0.02064678f, 0.02999412f, 0.03196529f, -0.01094020f, -0.00912226f, -0.02390494f, -0.00623429f, 
    0.02591166f, -0.15082909f, 0.03894983f, 0.06767679f, -0.00204584f, -0.04588220f, -0.06220750f, -0.01620310f, 
    -0.00839689f, 0.00400867f, 0.08435447f, 0.06286941f, -0.02868693f, -0.03264416f, 0.07996339f, -0.13889085f, 
    0.09476472f, 0.03138160f, 0.03940389f, -0.08491316f, -0.02090266f, -0.03388773f, 0.03465111f, 0.04072335f, 
    0.08044492f, 0.19070573f, 0.13826488f, -0.10961989f, 0.11181399f, -0.04266666f, 0.03676717f, 0.07593222f, 
    0.12582517f, -0.00711992f, 0.02215853f, 0.15883029f, -0.08897790f, -0.17298177f, -0.11173926f, -0.04150588f, 
    0.00351034f, 0.09457120f, 0.07954223f, 0.04797048f, 0.02895072f, 0.03723397f, 0.04739369f, -0.02835354f, 
    -0.17415100f, -0.17652872f, 0.09350690f, -0.04380034f, -0.04875326f, -0.02821473f, -0.05287892f, 0.08215015f, 
    -0.03505312f, 0.04059901f, 0.10919031f, -0.01140066f, 0.13602664f, 0.06697249f, -0.09212021f, 0.46063426f, 
    0.11078499f, -0.03827892f, -0.07379552f, 0.02298722f, 0.10079286f, 0.01711135f, 0.01749645f, 0.07228412f, 
    -0.07627468f, -0.02268817f, -0.02002347f, -0.03643579f, 0.09651964f, 0.00308192f, 0.02891494f, -0.00794689f, 
    0.09737042f, 0.09118332f, 0.02532456f, -0.01253389f, 0.08015324f, -0.04426432f, -0.11682698f, 0.02842410f, 
    0.14420056f, 0.03426187f, -0.01622191f, -0.01497227f, 0.05140337f, -0.01799886f, 0.06091352f, 0.04397503f, 
    -0.01941329f, -0.03495915f, -0.14346711f, -0.17650117f, 0.15087524f, 0.01653109f, -0.04261809f, -0.05027164f, 
    0.07116476f, 0.02909888f, 0.03931541f, 0.00395473f, -0.03709381f, 0.01643714f, 0.07714525f, 0.12058792f, 
    0.07908026f, 0.05141345f, 0.09217910f, -0.02197279f, -0.01656911f, -0.01559867f, -0.04026049f, -0.05243365f, 
    -0.14170276f, 0.08798505f, 0.09363842f, -0.15659177f, 0.04317486f, 0.01883870f, 0.03355428f, 0.01986087f, 
    0.00035364f, 0.03612652f, -0.03208000f, 0.02651718f, 0.23950726f, 0.09812844f, 0.10065412f, 0.08237973f, 
    0.05823528f, 0.05062892f, -0.00637784f, -0.01580381f, 0.00586063f, 0.08637183f, -0.00476592f, -0.00035446f, 
    0.02339765f, 0.00963116f, 0.00071194f, -0.01659303f, 0.00392793f, 0.00129893f, -0.01902025f, -0.00099150f, 
    -0.00259289f, -0.03751470f, 0.00619235f, 0.02140748f, -0.03984223f, -0.02045861f, 0.00466704f, 0.00000490f, 
    -0.03338217f, -0.01828810f, 0.01313723f, 0.00690899f, -0.02729997f, -0.03177391f, 0.00125457f, -0.00828993f, 
    0.02411168f, 0.00998799f, 0.00261206f, -0.02122304f, -0.01354412f, 0.00778340f, 0.00684356f, -0.01199348f, 
    -0.03015216f, 0.02051383f, -0.00591222f, -0.00444366f, -0.00609451f, 0.00001048f, 0.02043925f, -0.00867705f, 
    0.02373060f, -0.01818711f, 0.01726109f, 0.03004913f, -0.03876848f, 0.03003984f, -0.02155351f, -0.02042195f, 
    0.01145235f, -0.01516153f, -0.01320512f, -0.02202304f, -0.03827247f, -0.03358035f, 0.01354318f, -0.00078414f, 
    0.00735289f, -0.02121712f, -0.01894631f, 0.00737013f, -0.00085904f, -0.01837752f, -0.00384603f, -0.03782189f, 
    0.00803068f, -0.02186319f, -0.00238715f, -0.04048846f, 0.01219507f, 0.00211723f, -0.00286292f, -0.01175368f, 
    -0.01089142f, 0.02493818f, -0.01716468f, -0.02400837f, -0.02720612f, -0.02196070f, -0.01813425f, -0.02038205f, 
    0.00214954f, 0.01797788f, 0.02924131f, -0.00128440f, -0.00410244f, 0.01070109f, 0.01194347f, -0.00406753f, 
    -0.00311502f, -0.02641457f, -0.00971443f, -0.01830985f, -0.03524521f, -0.03038099f, -0.01275052f, -0.02710236f, 
    -0.02889540f, -0.04194059f, -0.03851404f, -0.00466543f, -0.01054415f, 0.00212767f, 0.01816710f, 0.02607349f, 
    -0.03419057f, 0.01428260f, -0.00808361f, -0.00041032f, 0.02186272f, -0.02556306f, -0.02093807f, -0.02411355f, 
    0.00208989f, -0.01564174f, -0.02365880f, -0.03636964f, 0.02857447f, 0.02031207f, 0.01448865f, -0.03566667f, 
    -0.03420922f, -0.03878687f, 0.02439366f, -0.01854434f, 0.00053204f, -0.02762936f, 0.00943322f, -0.02746022f, 
    -0.03528774f, -0.01823341f, 0.01213443f, -0.03370667f, 0.01015878f, -0.03709012f, -0.03659172f, -0.00128624f, 
    -0.01058011f, -0.03679105f, -0.01233305f, 0.02284360f, -0.04062600f, -0.01371819f, -0.00075789f, 0.02901310f, 
    -0.02696626f, 0.02761708f, -0.01014327f, 0.01118487f, 0.01730174f, 0.01198553f, 0.01137795f, -0.00067758f, 
    -0.02219915f, 0.01394360f, -0.01413469f, -0.01454490f, -0.02539674f, -0.03476605f, 0.02077768f, 0.00296802f, 
    0.00952472f, 0.02685271f, 0.00113177f, 0.01739425f, -0.02122045f, -0.02959876f, -0.03750627f, 0.02242604f, 
    0.00819808f, 0.00534342f, -0.01515136f, 0.02002924f, -0.00595357f, 0.01610267f, 0.02195996f, -0.03319290f, 
    0.02982139f, 0.02572582f, 0.01932058f, -0.02848953f, -0.01670746f, 0.01802469f, -0.01514919f, 0.02366082f, 
    -0.01499608f, 0.01716817f, 0.00345423f, -0.02512825f, -0.03426586f, 0.02432417f, 0.01658825f, 0.02978986f, 
    0.01438104f, -0.03592520f, -0.02400593f, -0.02439625f, -0.03318524f, -0.02223804f, 0.02953882f, -0.01222813f, 
    -0.03908169f, 0.02493386f, -0.03293225f, -0.01241564f, 0.01834346f, 0.01438183f, -0.00469758f, 0.01925427f, 
    0.00165954f, 0.02778515f, -0.00061218f, -0.04093533f, 0.01071236f, -0.03544621f, 0.02634042f, -0.02327666f, 
    -0.02135134f, -0.02387482f, -0.03263051f, 0.02148904f, 0.02888605f, 0.02152508f, 0.01432140f, 0.02572834f, 
    -0.03521536f, -0.01849939f, -0.01261724f, -0.01867379f, -0.00296362f, -0.00413464f, -0.02333320f, 0.01917592f, 
    0.01019875f, 0.02396330f, 0.02697683f, -0.03910793f, 0.02326062f, -0.03590041f, -0.02113038f, 0.02924015f, 
    0.00390423f, 0.02136068f, -0.03234374f, -0.00847097f, -0.02451776f, -0.00578216f, -0.01798952f, -0.03198894f, 
    0.00925437f, -0.00570113f, -0.00902413f, 0.01325623f, 0.00376217f, -0.03795695f, 0.01926193f, -0.02770589f, 
    0.02578935f, -0.03924237f, -0.04181170f, 0.00448367f, -0.03272383f, 0.00456665f, -0.00767622f, -0.01541121f, 
    -0.01926255f, -0.00432468f, 0.02563164f, 0.02226486f, 0.01186826f, -0.00928375f, -0.03469726f, -0.03799440f, 
    -0.00744901f, -0.00753504f, 0.01922312f, 0.02083858f, -0.03475909f, -0.00385343f, 0.01087928f, 0.01145593f, 
    0.02918029f, -0.04116104f, 0.01605429f, -0.01006967f, -0.01803182f, -0.02838342f, 0.02927521f, -0.04091719f, 
    0.02271694f, -0.02684408f, -0.02060031f, -0.01426391f, 0.01747112f, 0.01166627f, -0.01389678f, -0.00494175f, 
    -0.00008546f, 0.02843691f, -0.02085277f, 0.02845302f, 0.00463290f, -0.02292567f, 0.01166394f, -0.00263479f, 
    0.00033200f, 0.01662260f, -0.03663167f, 0.01313595f, 0.00328233f, -0.01620582f, -0.00395729f, -0.04137183f, 
    -0.01915515f, -0.02680839f, -0.01481291f, -0.01181196f, 0.01654720f, 0.00160839f, -0.03795834f, 0.02168881f, 
    -0.00402506f, -0.00135920f, 0.01672940f, 0.00743130f, -0.02569779f, -0.03299624f, 0.00156794f, 0.00530296f, 
    -0.01284716f, -0.03252442f, 0.02096614f, -0.02283774f, 0.01543024f, -0.00474952f, -0.03047648f, 0.00054044f, 
    -0.03188318f, -0.03395354f, -0.01907573f, -0.00062381f, -0.00867131f, 0.00113873f, -0.01051804f, -0.01568286f, 
    -0.00870982f, -0.00901207f, 0.00488496f, -0.00856924f, -0.01275119f, -0.02985649f, 0.01809974f, -0.03004529f, 
    0.02700059f, 0.02612235f, -0.01077995f, -0.02785927f, -0.04139933f, -0.02028823f, 0.02331018f, -0.01108124f, 
    -0.03458280f, -0.00273283f, -0.01132979f, -0.02476533f, -0.03006125f, 0.02354811f, -0.00280072f, 0.02945691f, 
    -0.03005119f, -0.02663447f, -0.03527885f, 0.00404950f, -0.01582156f, 0.01827466f, 0.02963616f, -0.03387770f, 
    -0.00154988f, -0.01925024f, -0.00378301f, -0.02413411f, 0.02807649f, 0.02252115f, 0.01107907f, -0.03740286f, 
    -0.01940206f, -0.02989667f, -0.04134260f, -0.02508573f, -0.00770356f, 0.02472659f, -0.02609294f, -0.01590419f, 
    -0.03059069f, 0.01490319f, -0.02713506f, 0.01824211f, -0.01239882f, 0.01661842f, -0.00201833f, -0.00904242f, 
    -0.01219610f, 0.00415493f, 0.00865206f, 0.00848636f, -0.00053667f, 0.01972726f, 0.02095420f, 0.02671331f, 
    -0.03191220f, 0.01651846f, 0.00385844f, 0.02620441f, -0.02342412f, 0.01988142f, -0.00315542f, 0.01483565f, 
    0.00191331f, -0.01592509f, -0.01847462f, -0.00880590f, -0.00898075f, 0.01305976f, 0.01015149f, -0.01300616f, 
    -0.02085044f, -0.01603789f, 0.00754339f, -0.01177454f, -0.04127789f, -0.03778253f, 0.00039455f, -0.03723654f, 
    0.00753520f, -0.03340729f, 0.01268895f, -0.02964456f, 0.02584241f, 0.02690868f, 0.00799123f, 0.02711901f, 
    -0.02785750f, -0.02899356f, 0.01707173f, -0.02827228f, -0.02974473f, -0.01632021f, -0.01934282f, -0.01503053f, 
    -0.02419224f, -0.02006510f, -0.01188007f, -0.01304920f, 0.00954361f, 0.00960779f, 0.02191272f, 0.01471723f, 
    0.02761159f, -0.01800584f, 0.00852218f, -0.01800006f, -0.02021467f, -0.01750663f, -0.01269783f, -0.01689584f, 
    0.01738804f, 0.00199348f, 0.02656604f, 0.01257741f, -0.01504445f, 0.00300093f, 0.00147645f, -0.03566967f, 
    -0.01844085f, -0.00279224f, -0.01615557f, -0.02244605f, 0.00043971f, -0.00876295f, -0.03277785f, 0.02749924f, 
    -0.03739230f, 0.00931542f, -0.01332982f, -0.00573904f, 0.02281117f, 0.01315746f, -0.02488150f, -0.03200328f, 
    -0.02678098f, -0.02570552f, -0.04077962f, -0.03551270f, -0.00029661f, -0.01427799f, -0.01151509f, -0.04146742f, 
    0.01656863f, 0.02009848f, 0.00882514f, 0.02843379f, -0.00711316f, -0.00453378f, -0.03602059f, 0.02288477f, 
    0.02681369f, 0.00269474f, -0.01997149f, -0.00166955f, -0.01154357f, 0.02483471f, -0.00497342f, -0.03945274f, 
    -0.00927352f, 0.00845026f, 0.01946185f, 0.00768730f, 0.02703633f, -0.01117932f, -0.02695669f, -0.00278473f, 
    -0.00354247f, -0.01779432f, 0.01004283f, -0.03699839f, -0.01550907f, -0.02191761f, -0.02362866f, -0.03250178f, 
    -0.03736921f, 0.00116683f, -0.03409037f, -0.03536765f, 0.02973987f, -0.02443499f, -0.00516261f, -0.03531830f, 
    -0.01882088f, -0.02953276f, -0.03216434f, 0.02594810f, 0.02903015f, -0.01446514f, 0.02772512f, 0.00656385f, 
    0.02789159f, -0.03341978f, -0.02460578f, 0.00560830f, -0.02202068f, 0.00091714f, -0.01495510f, 0.01042881f, 
    0.01696572f, -0.04194136f, -0.00435238f, 0.02958771f, -0.01970243f, 0.00005087f, 0.02761598f, 0.01995990f, 
    -0.03915324f, -0.02701404f, 0.00688572f, -0.02927856f, 0.02846056f, 0.02224975f, 0.00050726f, -0.02806951f, 
    -0.00234363f, -0.00909789f, -0.03688056f, -0.01709019f, -0.02694334f, -0.00914245f, -0.00423914f, -0.03331228f, 
    0.01725953f, -0.03438739f, 0.00065013f, -0.03315261f, -0.00067129f, -0.00695072f, -0.00233346f, 0.00425661f, 
    -0.00538334f, -0.01098218f, -0.00900293f, -0.01303994f, -0.03377375f, -0.00310157f, 0.00015323f, -0.03787134f, 
    -0.03802131f, 0.02858682f, -0.03183316f, -0.03140244f, 0.00204897f, -0.01522834f, -0.03814222f, -0.03467162f, 
    0.02907852f, 0.00802460f, -0.03126238f, 0.00711298f, -0.01027513f, 0.01818720f, -0.00792254f, 0.00479631f, 
    0.01373785f, -0.01692344f, 0.02725591f, 0.02039598f, 0.02275652f, -0.01708836f, -0.01447107f, -0.02282795f, 
    -0.00153850f, -0.01032068f, -0.00037962f, -0.03596437f, -0.00523641f, -0.03866737f, -0.00692334f, -0.03167956f, 
    0.00578592f, -0.01787227f, 0.00828653f, -0.01727666f, -0.00920302f, -0.02209882f, -0.00302065f, 0.00989853f, 
    -0.00961921f, 0.02948135f, -0.02808281f, -0.02752316f, 0.01669567f, -0.00741250f, -0.00167607f, -0.03686619f, 
    -0.02328711f, 0.01863301f, 0.01483246f, 0.01388426f, -0.00650241f, -0.01118721f, -0.02783605f, 0.02299785f, 
    0.01484573f, 0.00374416f, -0.01932188f, -0.03516338f, -0.01732165f, -0.02366987f, -0.00031268f, -0.00690744f, 
    -0.04010378f, -0.00623626f, -0.00938644f, 0.00195038f, 0.01022795f, -0.03098197f, 0.01586445f, 0.02949628f, 
    -0.00349718f, -0.03492965f, -0.02266867f, 0.01572885f, -0.03467658f, -0.02028833f, 0.00409639f, 0.00723913f, 
    -0.03220358f, 0.01066153f, -0.03047805f, 0.02179695f, 0.00891912f, 0.00392929f, 0.01015337f, -0.04137308f, 
    -0.03029163f, 0.00454097f, -0.00068716f, 0.01098027f, -0.03313321f, -0.00979576f, -0.01444452f, -0.01897432f, 
    -0.01014058f, -0.04135950f, 0.02996289f, -0.04065988f, 0.00156636f, 0.00723315f, -0.00872086f, 0.00138920f, 
    -0.02207985f, 0.01445828f, 0.02742422f, -0.01051877f, 0.01254265f, -0.02331358f, 0.00722146f, -0.01180082f, 
    0.02570632f, 0.01459693f, -0.04123822f, -0.01154061f, 0.01770194f, 0.01110350f, 0.02811100f, -0.03762244f, 
    -0.03847437f, -0.01015006f, 0.00348966f, -0.03066482f, -0.02454851f, -0.00199202f, -0.02116375f, 0.02077946f, 
    0.02451248f, -0.00237381f, 0.00948266f, -0.00588898f, -0.03579485f, -0.02006662f, 0.02057347f, -0.02364577f, 
    -0.02185940f, -0.03197129f, 0.00363996f, -0.01983769f, -0.03738719f, 0.00399342f, -0.03938214f, -0.01620158f, 
    0.02922711f, -0.03961433f, -0.02865603f, -0.04053336f, 0.00675530f, -0.02199101f, 0.01748789f, 0.00989788f, 
    -0.03617935f, -0.01988810f, 0.00970448f, -0.03820019f, 0.01247997f, 0.02629860f, 0.00368157f, -0.00255403f, 
    0.02953749f, 0.02938474f, 0.01997612f, 0.02937181f, -0.00191096f, 0.01430020f, -0.02049418f, 0.01325915f, 
    0.00820081f, -0.03804088f, 0.01778918f, 0.01485490f, -0.01557424f, 0.00466132f, -0.03589977f, 0.02298269f, 
    0.04967934f, -0.17302506f, 0.00680915f, -0.11969502f, 0.01151445f, 0.05811745f, -0.02557657f, 0.14791273f, 
    0.01795345f, 0.05413724f, -0.07099088f, 0.09915983f, 0.05147364f, -0.09868409f, 0.04757633f, -0.08071069f, 
    0.05722594f, -0.00581965f, -0.04011121f, 0.08542625f, -0.02982050f, 0.14603135f, -0.22289085f, -0.04335856f, 
    -0.24365200f, -0.08285899f, 0.03169774f, -0.00937970f, -0.03175851f, -0.08050141f, 0.05317808f, 0.11289799f, 
    -0.02505860f, 0.00089769f, -0.06867973f, -0.10738294f, 0.00031196f, -0.26395699f, -0.05014357f, -0.05634978f, 
    -0.11535844f, -0.00734729f, 0.02665104f, 0.09876372f, 0.02763562f, -0.05591882f, 0.00798937f, -0.04643580f, 
    0.28024307f, -0.03557751f, 0.11694714f, 0.11495928f, 0.04147725f, -0.11359801f, 0.10051018f, 0.03763059f, 
    0.06913666f, -0.06936195f, 0.02185097f, -0.00145940f, 0.14766413f, 0.02900963f, 0.02560032f, 0.18073803f, 
    -0.10384102f, 0.00946508f, -0.01596078f, 0.00260484f, 0.00472172f, 0.00914488f, -0.00946173f, -0.03585925f, 
    0.03628493f, 0.06135034f, 0.04536014f, 0.03781752f, -0.08253421f, 0.02314890f, 0.10693726f, 0.05951313f, 
    0.01803403f, 0.05698507f, -0.08667723f, -0.01656550f, -0.07740115f, -0.00680845f, -0.03924272f, 0.18379264f, 
    0.02823451f, -0.08911063f, -0.01285923f, 0.01026265f, 0.03173576f, -0.00518839f, -0.07828561f, -0.01667142f, 
    0.05202983f, 0.01585281f, -0.00296166f, -0.07293771f, -0.01439861f, 0.05017643f, -0.01704108f, 0.00693338f, 
    0.05962406f, -0.05454421f, 0.09842446f, -0.02642856f, 0.12315903f, -0.03707368f, -0.09933974f, -0.01879448f, 
    -0.06035043f, -0.15448949f, -0.13863297f, -0.06750338f, -0.08568826f, 0.06041243f, 0.02502826f, -0.05938011f, 
    0.06317104f, -0.11296736f, -0.09953357f, 0.00335520f, 0.08557432f, 0.04620511f, -0.08807243f, 0.00161078f, 
    0.04391771f, 0.04399891f, 0.04359995f, -0.02978140f, 0.00489138f, -0.05525835f, -0.08621645f, 0.15383454f, 
    0.01480823f, -0.10640722f, 0.03708234f, -0.05776896f, 0.15783696f, 0.10533558f, -0.04789796f, 0.10498569f, 
    -0.15481582f, 0.05905872f, -0.07960661f, -0.11496080f, 0.11551636f, 0.00134573f, 0.10497653f, -0.01847936f, 
    0.09116519f, -0.07274222f, -0.03690317f, -0.04291849f, 0.06954347f, 0.03402870f, -0.04651592f, -0.01066722f, 
    -0.01512566f, -0.14451982f, -0.13376397f, 0.10150769f, 0.03676259f, 0.02071591f, -0.03120446f, -0.09019583f, 
    0.12608889f, 0.04442440f, -0.04439146f, 0.08119101f, -0.00797325f, -0.08435223f, 0.08569794f, 0.08827876f, 
    -0.02280790f, -0.12148663f, 0.14024782f, -0.10862547f, 0.21862577f, 0.10922909f, -0.07033292f, 0.06794710f, 
    0.02712341f, 0.06436222f, -0.07458217f, -0.02939599f, -0.10194667f, -0.07302907f, 0.06935774f, -0.08219759f, 
    -0.24542651f, 0.14750490f, 0.05481353f, -0.03516670f, -0.03464758f, -0.02850093f, 0.02204342f, -0.03013452f, 
    -0.00160025f, -0.07368477f, 0.02820461f, 0.05141838f, -0.05837115f, 0.03855520f, -0.00468348f, -0.19454677f, 
    0.06226327f, -0.03552183f, -0.09702203f, 0.01709702f, -0.05546611f, -0.06224191f, 0.02967652f, -0.02648475f, 
    -0.02751906f, -0.05528310f, -0.07638438f, -0.04256627f, 0.04674479f, 0.03953893f, 0.07263221f, -0.04612465f, 
    -0.01717111f, -0.02251873f, -0.05729097f, 0.06875050f, 0.06466077f, 0.02145901f, -0.02300593f, -0.07915080f, 
    0.15491204f, 0.02446483f, 0.06011318f, -0.11035760f, 0.04534124f, -0.03494362f, 0.02240327f, 0.09933276f, 
    -0.05763274f, -0.00956857f, 0.07630272f, 0.16413017f, 0.03077820f, -0.00912904f, 0.02894195f, -0.04912917f, 
    -0.02465181f, 0.00785627f, -0.03461439f, 0.10463145f, -0.19992571f, -0.02153491f, -0.00379235f, 0.05816337f, 
    0.00996087f, -0.06197046f, -0.01178740f, -0.04662286f, 0.07610095f, 0.08964421f, 0.12074363f, 0.02102261f, 
    -0.31368345f, -0.12121467f, -0.14601672f, -0.19255869f, 0.07857642f, -0.00717611f, -0.06519207f, -0.09761829f, 
    0.03599389f, 0.04958788f, 0.03059531f, -0.01326924f, -0.03698975f, -0.08046850f, 0.05565192f, -0.10010524f, 
    -0.01539009f, -0.01432046f, -0.03231249f, 0.11078737f, 0.06128262f, 0.06064689f, 0.21532020f, 0.05702046f, 
    -0.04416526f, 0.15195782f, 0.00650523f, -0.02035552f, -0.03551979f, 0.04696809f, 0.07476363f, -0.02579877f, 
    0.12870820f, 0.03921062f, 0.03254542f, -0.03770734f, 0.07610854f, -0.02585869f, -0.02570152f, -0.04074447f, 
    0.10041051f, 0.07022338f, 0.02389916f, -0.05527425f, -0.05335156f, 0.05449674f, -0.13696925f, 0.00205455f, 
    0.22728688f, -0.04569504f, -0.06945538f, -0.14439097f, -0.04665672f, 0.07908340f, -0.00256368f, -0.02206390f, 
    -0.00382223f, 0.04846356f, 0.08908106f, 0.07283258f, 0.04679149f, 0.00498987f, 0.10411708f, -0.05360297f, 
    -0.03522494f, -0.03391280f, -0.05993807f, 0.05747250f, 0.02475012f, -0.01067631f, 0.07025881f, 0.11582771f, 
    0.01807748f, 0.00417746f, 0.12448291f, -0.07179353f, 0.02083555f, -0.07153980f, 0.02931056f, 0.02836967f, 
    0.00923670f, -0.02654508f, 0.06282464f, 0.04938569f, 0.10185141f, -0.05496722f, 0.06910277f, 0.02172458f, 
    -0.05548327f, -0.03648662f, -0.05140636f, 0.10369632f, 0.07167483f, -0.16232164f, -0.07560512f, -0.00517210f, 
    0.09345330f, 0.02709269f, 0.05755855f, 0.14190269f, -0.07705516f, -0.07769348f, 0.04581510f, 0.00145188f, 
    0.07395659f, 0.00050040f, 0.08412254f, -0.13183528f, 0.01095290f, 0.01141291f, -0.07370985f, -0.18048333f, 
    -0.05320876f, 0.03671692f, 0.01234634f, 0.02741399f, 0.08949753f, 0.01152100f, 0.01668415f, -0.07226694f, 
    -0.12439425f, 0.12345356f, 0.01022625f, -0.05111318f, 0.06923107f, 0.01324152f, 0.11456388f, -0.10176810f, 
    -0.06818867f, 0.04855774f, 0.05952438f, 0.18783362f, 0.00102754f, -0.01881596f, -0.05603842f, -0.02313686f, 
    -0.06201119f, 0.07417659f, -0.19321460f, 0.02587851f, 0.13894449f, 0.10351606f, 0.19206740f, -0.06747296f, 
    -0.11518488f, -0.02411123f, -0.14028735f, -0.13404891f, 0.06439177f, -0.08381285f, -0.08032476f, 0.06834345f, 
    0.02247301f, 0.05431565f, 0.04107391f, 0.06296547f, 0.10209677f, 0.05643403f, -0.12690191f, -0.02852044f, 
    0.05577771f, 0.02692197f, 0.00176693f, -0.02602169f, 0.04429951f, -0.07357408f, -0.02995728f, -0.13457763f, 
    0.01239015f, 0.07630226f, 0.14067395f, 0.19815756f, -0.02387794f, 0.10896531f, 0.00980952f, 0.12760068f, 
    -0.00939121f, -0.01736596f, 0.05978565f, -0.00639984f, 0.00624435f, 0.07009686f, -0.14920914f, -0.07716120f, 
    0.05411451f, 0.01538701f, 0.07202545f, -0.03144379f, 0.04545339f, 0.04315265f, -0.05071837f, -0.04482301f, 
    -0.12682742f, 0.20751788f, 0.07398620f, 0.06631304f, 0.01354069f, 0.04651390f, -0.05200135f, -0.03789511f, 
    -0.00551639f, -0.05430995f, 0.06995244f, -0.04985115f, 0.08154885f, -0.01738917f, 0.06118620f, 0.01645406f, 
    -0.02645440f, 0.05713101f, -0.01947859f, -0.02653080f, -0.02636046f, -0.00898485f, -0.04724946f, -0.04399888f, 
    0.07429469f, 0.22555089f, -0.02350052f, -0.01332338f, 0.01405220f, -0.09371710f, 0.02081387f, 0.04035727f, 
    0.00446025f, -0.04225157f, -0.04398204f, 0.06856504f, 0.04238703f, 0.10011734f, 0.06708038f, -0.01494503f, 
    0.01655824f, -0.13293840f, -0.02388821f, 0.00737044f, 0.08710176f, -0.07523686f, 0.11544866f, -0.04252040f, 
    -0.08260739f, 0.05089869f, -0.04276317f, -0.11344858f, 0.00899640f, 0.10983989f, 0.01020603f, 0.03534087f, 
    0.10537293f, 0.03711982f, -0.01667670f, 0.12570249f, 0.29450178f, 0.01507481f, 0.09169633f, 0.16494845f, 
    0.04020534f, 0.01010526f, -0.03735745f, 0.00509509f, -0.09384687f, -0.09043485f, -0.00421466f, -0.02337041f, 
    -0.35332954f, 0.01945768f, -0.09459651f, -0.13000099f, 0.04200047f, -0.03209730f, 0.01552895f, -0.02640502f, 
    0.07267068f, -0.01691764f, -0.04433887f, 0.04884390f, -0.14870141f, -0.05097421f, 0.11515782f, 0.01575345f, 
    0.01881965f, 0.00297522f, -0.03003195f, -0.10683307f, 0.06711846f, 0.02350284f, -0.04636509f, 0.02932552f, 
    0.07327014f, 0.01795192f, -0.04099621f, 0.05523100f, 0.07328521f, 0.09264176f, -0.07672130f, 0.06871659f, 
    0.14994641f, 0.06051591f, 0.08593283f, -0.07046053f, -0.04288821f, 0.18926416f, -0.08361720f, -0.22433381f, 
    0.16896766f, 0.09184688f, -0.00262906f, -0.04508577f, 0.05825667f, -0.00431136f, 0.15076903f, 0.20463715f, 
    -0.11104948f, -0.21942024f, -0.00288693f, 0.04321513f, 0.01547974f, -0.03476734f, -0.16098857f, 0.05920081f, 
    -0.08887705f, -0.01467620f, 0.13085534f, 0.01446413f, -0.01717596f, -0.03578335f, -0.04364297f, -0.05668961f, 
    0.07094872f, 0.05854228f, 0.02098965f, 0.05428505f, 0.04843040f, 0.00906631f, 0.02519623f, 0.19578592f, 
    -0.04357822f, -0.01979621f, 0.03859437f, -0.10021378f, 0.06705438f, -0.07344563f, -0.02596321f, -0.07800332f, 
    0.08483382f, -0.09958479f, 0.08510695f, -0.01708605f, 0.04643688f, 0.07667068f, -0.01559406f, -0.09715980f, 
    -0.12281704f, -0.10085775f, -0.00249719f, -0.02339328f, 0.12074939f, 0.18132633f, 0.12569110f, 0.05083146f, 
    -0.11497822f, -0.13179760f, -0.14779411f, -0.11982729f, -0.00786629f, 0.03174758f, -0.14061798f, -0.14047350f, 
    0.01009931f, -0.05496122f, 0.19035041f, -0.07091378f, -0.03283590f, 0.06720903f, 0.02852746f, -0.04753162f, 
    0.12386569f, 0.00160707f, -0.15546483f, -0.10904739f, -0.07251427f, -0.09081768f, -0.06359158f, -0.11313447f, 
    0.20892730f, -0.09364492f, -0.03380333f, -0.13622248f, -0.11947914f, -0.03377167f, -0.10914771f, 0.04266948f, 
    0.07274280f, -0.03313322f, 0.00780487f, -0.06148029f, 0.18126939f, -0.00842659f, -0.03554820f, 0.10334518f, 
    0.00867050f, 0.04616392f, 0.07772671f, 0.03068843f, 0.01879114f, 0.11236811f, -0.09903567f, 0.03203516f, 
    -0.06914333f, 0.14836398f, 0.03417365f, 0.00127563f, 0.05034980f, -0.03053670f, -0.09070358f, -0.05336986f, 
    -0.06097542f, 0.08452141f, 0.06224388f, 0.11634358f, -0.17715019f, -0.06353153f, -0.07312800f, 0.04579155f, 
    0.14360829f, -0.00760224f, 0.03704964f, -0.08273275f, -0.04326080f, 0.14773419f, -0.01562116f, -0.10543625f, 
    -0.00834344f, 0.11231656f, -0.03965324f, 0.18668379f, 0.11930449f, 0.01065951f, -0.02639365f, -0.00401943f, 
    0.07796703f, 0.11807124f, 0.07095884f, 0.14734656f, 0.09002553f, -0.03444259f, 0.02829440f, 0.03683714f, 
    0.15182818f, 0.00922807f, -0.03894944f, -0.09139988f, 0.03776472f, 0.01526220f, 0.09616304f, 0.13161512f, 
    0.00929672f, -0.05935634f, -0.01108673f, 0.06975025f, 0.11688688f, 0.07820134f, -0.02597642f, -0.04684796f, 
    -0.01374458f, 0.05337238f, 0.05421572f, 0.03255266f, 0.18061392f, -0.06849542f, -0.00586385f, 0.20903972f, 
    -0.05020014f, -0.06929480f, 0.06933486f, 0.05220408f, 0.07165739f, -0.07333644f, -0.05351971f, -0.04793569f, 
    0.19539210f, -0.12916444f, 0.09746159f, -0.01164256f, -0.02020786f, 0.04854932f, -0.01324593f, 0.13948110f, 
    0.02108793f, -0.02088006f, 0.01669800f, 0.00149897f, 0.23650102f, 0.16342446f, -0.12267175f, -0.09023973f, 
    0.01634716f, 0.05078864f, -0.00005105f, 0.08330054f, -0.01987137f, 0.09022325f, 0.10289697f, 0.02966369f, 
    -0.16998005f, 0.07182732f, -0.11414389f, 0.07591151f, 0.11146748f, -0.13696188f, 0.02711388f, 0.10673612f, 
    0.00653130f, 0.04066870f, -0.01490289f, 0.07588945f, -0.18056811f, 0.01814901f, 0.04406520f, 0.08096927f, 
    0.03320531f, 0.05366198f, 0.01776105f, 0.00473538f, -0.00889252f, 0.05236699f, 0.09176718f, -0.03073227f, 
    -0.10606980f, 0.05633154f, -0.02975722f, 0.00782472f, 0.03537526f, -0.06235108f, 0.04580932f, 0.06714930f, 
    0.10017797f, 0.03978672f, 0.09451838f, -0.00254573f, -0.37147805f, 0.12201472f, -0.00130790f, 0.03253698f, 
    0.03020401f, -0.04461398f, 0.00105218f, 0.08704320f, 0.06675810f, -0.02492893f, -0.00378109f, 0.00703730f, 
    -0.17487828f, -0.04938174f, -0.03020621f, 0.01696442f, -0.00014921f, -0.09991320f, 0.03845475f, 0.02147980f, 
    0.05173214f, -0.02611106f, 0.02592825f, -0.05948119f, -0.08007994f, -0.00751150f, 0.00389259f, 0.04647126f, 
    -0.03758908f, -0.00522109f, -0.03107053f, 0.08006658f, 0.03895130f, -0.01220633f, -0.01711799f, -0.08370836f, 
    -0.11151911f, 0.03126384f, -0.03768235f, 0.01103091f, 0.08571917f, 0.00216746f, 0.07181434f, 0.09118033f, 
    -0.05045033f, -0.04459414f, 0.01912887f, 0.03892113f, 0.13758311f, 0.02221304f, 0.04366352f, 0.04610093f, 
    -0.04972750f, 0.00960838f, -0.01001965f, -0.00690168f, 0.02857452f, -0.01638240f, -0.05263973f, -0.03482221f, 
    0.16262822f, -0.00638347f, 0.06138540f, -0.05087150f, -0.04008068f, 0.05739735f, 0.00052675f, 0.01721312f, 
    0.04135784f, 0.01867737f, 0.01363691f, 0.09790538f, -0.04528726f, -0.04563999f, -0.02929688f, -0.01313420f, 
    0.00615395f, -0.02569785f, -0.02231482f, 0.01242389f, 0.03023043f, 0.09887882f, 0.01648085f, -0.06961805f, 
    0.26410037f, -0.12110373f, -0.04338314f, 0.12385342f, -0.02092272f, -0.01876577f, 0.00652846f, -0.01807310f, 
    0.01419794f, 0.00574623f, -0.01404053f, -0.02235152f, -0.08632985f, 0.00051460f, 0.00979076f, 0.04220206f, 
    -0.11011859f, -0.00117886f, 0.03190299f, 0.12295114f, -0.02059090f, 0.03115190f, -0.04078881f, -0.15394351f, 
    0.05026109f, 0.11778423f, -0.18050534f, -0.03770671f, 0.03496487f, -0.02582037f, 0.07634906f, 0.08107039f, 
    0.08166528f, 0.05551051f, -0.03791588f, 0.02418100f, 0.04016628f, -0.04872439f, 0.02706345f, 0.03436182f, 
    0.02436395f, -0.06526239f, 0.03054819f, 0.10886440f, 0.07397925f, 0.07635610f, 0.05392896f, 0.03063687f, 
    -0.03481806f, -0.22364591f, -0.06450257f, -0.09949510f, -0.02820420f, -0.03848611f, -0.02956236f, 0.06075249f, 
    0.02150640f, -0.07474462f, -0.01571213f, 0.00008630f, 0.10713591f, 0.04764254f, -0.08981030f, -0.04889185f, 
    0.01848829f, 0.07967149f, 0.01132604f, 0.06364180f, 0.02045622f, 0.05081901f, 0.04893759f, -0.01240866f, 
    -0.13418034f, 0.01814679f, -0.07389009f, -0.03980863f, 0.00652599f, -0.03135004f, 0.01611642f, 0.00543001f, 
    0.02441902f, 0.07018989f, -0.08978020f, 0.03212674f, 0.27372199f, -0.05669402f, 0.03443525f, -0.11456109f, 
    -0.09006265f, 0.02703407f, 0.03259081f, 0.12108419f, 0.11535585f, 0.03975720f, 0.08917522f, 0.10092991f, 
    0.18553399f, 0.03721510f, 0.05766683f, -0.03390214f, -0.05151445f, 0.06885641f, 0.04206577f, -0.01244125f, 
    0.04417671f, 0.04070911f, 0.03203264f, -0.02907779f, 0.37362894f, 0.15996818f, -0.02495980f, 0.06169646f, 
    0.07254643f, 0.04688260f, -0.00421776f, 0.03499409f, 0.00105445f, 0.01069312f, 0.07448488f, 0.04438321f, 
    0.19034657f, 0.02825158f, -0.08462592f, 0.04693560f, 0.05022253f, 0.02877404f, 0.05582002f, 0.00300296f, 
    0.11609628f, 0.04340469f, 0.02626060f, -0.03960706f, 0.17376077f, -0.00534273f, 0.00696233f, 0.08330022f, 
    0.10909065f, 0.06879589f, 0.05206434f, -0.02916722f, 0.01946731f, -0.02721581f, -0.02863752f, -0.05820754f, 
    0.23910917f, 0.01890382f, -0.11281786f, -0.08650381f, 0.01950619f, 0.02642582f, -0.04840677f, 0.01587630f, 
    0.05836337f, 0.03901505f, 0.05623269f, 0.05062957f, 0.13628139f, -0.02084615f, 0.16091584f, 0.03687365f, 
    0.16302663f, -0.03432252f, -0.00449832f, 0.05642515f, -0.01800158f, 0.01284288f, -0.02357482f, 0.02991282f, 
    -0.04613158f, -0.16557863f, 0.07941755f, 0.12549926f, -0.00391774f, 0.04786859f, 0.03380539f, 0.02992086f, 
    0.07455066f, -0.04061530f, 0.03882445f, -0.04536575f, 0.47356895f, 0.21448150f, -0.10553312f, -0.00905873f, 
    0.00634853f, 0.02659432f, 0.01705485f, 0.05213570f, -0.00688246f, 0.02431031f, 0.05900848f, 0.03013879f, 
    -0.21192467f, 0.05352619f, -0.04427681f, -0.03656676f, 0.00523938f, -0.17881542f, 0.00388419f, 0.02630356f, 
    -0.06018451f, -0.00834986f, 0.07183231f, 0.10137290f, -0.15776208f, -0.10315214f, 0.03319598f, -0.15041894f, 
    0.09156617f, 0.02609632f, -0.00624506f, 0.03320362f, 0.01139488f, 0.00396599f, -0.03491747f, 0.03793441f, 
    0.56748301f, -0.00640309f, -0.16706994f, -0.01809443f, 0.00146663f, 0.00700088f, 0.02456402f, 0.09356470f, 
    0.01596118f, 0.02313754f, 0.00800499f, -0.01884785f, -0.12402735f, -0.09840881f, -0.09319515f, 0.01305741f, 
    -0.01298411f, -0.10384989f, -0.00362909f, 0.10066435f, -0.00376256f, 0.07846224f, 0.02621345f, 0.05394283f, 
    -0.07578114f, -0.07037462f, -0.01440974f, -0.02266661f, -0.01951444f, 0.03005013f, 0.00064082f, -0.03746226f, 
    0.05460553f, -0.06734472f, 0.01855047f, -0.01964456f, -0.15792532f, -0.11585923f, 0.04805690f, -0.02295135f, 
    -0.07106358f, 0.00306022f, -0.02545900f, 0.03930564f, -0.10881077f, 0.02814793f, 0.02030672f, 0.05949759f, 
    0.10264263f, 0.00291265f, 0.02324067f, -0.05513865f, 0.13168325f, -0.08149774f, 0.00021895f, 0.00636062f, 
    0.03599869f, 0.03290105f, 0.01137371f, -0.04924249f, 0.01767018f, 0.07315379f, -0.03812702f, -0.00704910f, 
    -0.10986342f, -0.02595186f, 0.00080713f, 0.05678977f, -0.08375538f, -0.09111720f, 0.08606555f, -0.05023636f, 
    -0.09194398f, 0.12738830f, 0.02133625f, 0.05278059f, 0.01179361f, -0.04164920f, 0.02074219f, 0.06360735f, 
    0.01207351f, 0.05202070f, -0.01209865f, 0.02268669f, -0.09838732f, -0.12248997f, -0.12828268f, -0.10356028f, 
    0.00278129f, 0.00631292f, 0.03669418f, 0.07434506f, 0.00517015f, 0.04805762f, 0.01356984f, 0.14164636f, 
    0.03109638f, -0.04880885f, 0.04564706f, 0.01786000f, -0.05669346f, -0.06745569f, 0.00005063f, 0.06097516f, 
    -0.00485894f, 0.00252065f, -0.00029836f, -0.05303307f, -0.06473761f, -0.21813875f, 0.10363741f, 0.11754353f, 
    0.01894305f, 0.03737186f, 0.03596189f, 0.10657824f, 0.04941618f, 0.00133731f, 0.07517709f, -0.01692304f, 
    -0.10481919f, -0.18185444f, -0.05350524f, -0.09486997f, -0.22262745f, -0.06763668f, 0.01301252f, -0.08774830f, 
    0.01516239f, 0.02677991f, -0.04355063f, -0.04480525f, 0.07800050f, -0.14991842f, 0.01064393f, 0.04497423f, 
    0.08391102f, 0.05020637f, 0.01499721f, 0.08647659f, -0.01253669f, -0.00343064f, 0.16261941f, 0.07704526f, 
    -0.06842793f, -0.09822840f, 0.11038982f, 0.09418641f, 0.01234765f, 0.06403775f, 0.01398549f, 0.05434804f, 
    0.00288440f, 0.03163272f, -0.00324001f, -0.00714083f, -0.09993768f, -0.09509689f, 0.06832617f, -0.00080342f, 
    0.12217737f, -0.02786875f, 0.01634400f, 0.06154835f, 0.09503502f, 0.06086969f, 0.09361482f, 0.04904696f, 
    -0.10886408f, -0.00596788f, 0.03555100f, -0.00108903f, -0.06993679f, 0.06996141f, 0.09439171f, 0.06805497f, 
    0.01001585f, 0.02892134f, 0.00045150f, 0.06437408f, -0.19880192f, 0.11501795f, -0.09714983f, 0.18400380f, 
    0.03060032f, -0.10648932f, 0.02602303f, 0.12269719f, 0.02578717f, 0.10176485f, 0.12438286f, 0.00097310f, 
    -0.11652519f, -0.00606440f, -0.08635356f, -0.10083969f, -0.01592076f, -0.08017282f, 0.08058786f, 0.04119716f, 
    -0.01396350f, 0.06060199f, 0.03330618f, 0.10238454f, 0.22938119f, -0.13082592f, -0.08416952f, 0.19212292f, 
    0.06100224f, 0.02616641f, 0.02063861f, -0.02371956f, -0.02947246f, 0.07087556f, -0.02857783f, -0.05427502f, 
    0.39210403f, -0.03288105f, 0.01660948f, 0.17021038f, 0.07536794f, 0.05576769f, 0.03474511f, -0.03360669f, 
    0.00194055f, 0.03893474f, 0.05435140f, 0.10453737f, -0.09249954f, -0.10464396f, -0.07827832f, -0.11850096f, 
    -0.12018041f, 0.02252629f, -0.05945022f, 0.07218910f, 0.03215884f, 0.03750639f, -0.02649961f, -0.02456527f, 
    0.23632398f, -0.04889598f, -0.08218253f, 0.01228809f, -0.05654674f, -0.07991464f, 0.07654294f, -0.00330766f, 
    -0.00449031f, 0.08798489f, 0.02493650f, 0.05341433f, -0.05711857f, 0.04605031f, -0.01332539f, -0.09146999f, 
    0.10600039f, -0.03601297f, -0.00453027f, 0.06081761f, 0.03480159f, 0.09863911f, -0.04233593f, 0.08502126f, 
    0.24461055f, -0.13529862f, 0.06141083f, 0.08888846f, 0.00198976f, 0.04056015f, 0.00870529f, 0.01200264f, 
    0.02090570f, 0.02704341f, -0.04933406f, 0.07888416f, -0.06536530f, -0.00919531f, -0.00271600f, -0.06555314f, 
    0.00818689f, 0.03601066f, -0.00782230f, 0.08529962f, -0.01564035f, 0.06059556f, 0.11092559f, 0.07203449f, 
    0.31822869f, -0.14158738f, -0.11417267f, -0.05070825f, 0.02897135f, 0.08581987f, -0.04884911f, -0.02067599f, 
    0.10450934f, -0.12244601f, -0.00408155f, 0.05312404f, -0.00954425f, -0.12934035f, 0.01742162f, -0.12056014f, 
    0.11933988f, 0.06877450f, 0.00130430f, 0.01405447f, 0.00528681f, 0.03610728f, 0.16887146f, 0.08656067f, 
    -0.16947623f, -0.05655766f, 0.00274732f, 0.10395852f, 0.09115867f, -0.04579590f, 0.09929997f, 0.03647948f, 
    0.07387885f, 0.11463714f, -0.01756819f, 0.14515634f, 0.10000256f, 0.12408342f, -0.08536079f, 0.00252920f, 
    0.08127210f, 0.10491847f, 0.06708650f, 0.09066525f, 0.09513754f, -0.01157162f, 0.02941395f, -0.02820614f, 
    0.16838053f, -0.11666869f, 0.05686980f, 0.06154921f, 0.00065520f, -0.00140337f, 0.02184056f, -0.07150809f, 
    -0.05709457f, 0.03123350f, 0.00992003f, 0.01686431f, 0.08880288f, -0.12606013f, 0.01583372f, 0.22314897f, 
    -0.00116620f, 0.01797353f, -0.01085490f, -0.00590398f, 0.18408751f, 0.02480802f, -0.02390067f, 0.05400929f, 
    0.19191986f, 0.03277358f, 0.00552760f, 0.10218643f, 0.08115414f, -0.01895008f, 0.04224551f, -0.03446671f, 
    0.02082255f, 0.04460438f, -0.01918536f, -0.05607784f, 0.37250999f, 0.00148088f, -0.03886371f, 0.00508724f, 
    0.03043263f, 0.03899784f, 0.03411324f, 0.02392119f, -0.03195579f, 0.02616914f, 0.11017161f, -0.06257732f, 
    0.41565520f, 0.09758943f, -0.16559918f, 0.05451364f, 0.08024743f, 0.00156329f, -0.02851656f, -0.05007511f, 
    0.06279467f, -0.03372340f, 0.01876383f, -0.01240913f, -0.22268333f, -0.06651222f, -0.05998112f, 0.02186693f, 
    -0.09343126f, -0.07577858f, 0.01012410f, 0.02361883f, -0.05008811f, -0.07314477f, -0.06827397f, 0.01568828f, 
    0.21565205f, -0.13149223f, 0.02600490f, -0.00555186f, 0.09382124f, -0.03825693f, 0.06811395f, -0.03107022f, 
    0.03475241f, -0.02596065f, 0.04031518f, 0.00215002f, 0.04659297f, -0.01836267f, -0.04412317f, -0.06367827f, 
    -0.04694541f, -0.02036211f, -0.01683536f, 0.13671032f, -0.00838534f, -0.01323719f, 0.06366079f, 0.02188905f, 
    0.18356171f, -0.12369484f, 0.19201161f, -0.00888414f, -0.01642831f, 0.02037767f, 0.03299610f, -0.02470657f, 
    -0.04381492f, -0.00085144f, -0.04333059f, 0.02131108f, 0.19917780f, 0.02861269f, 0.11921034f, 0.16239071f, 
    -0.13422437f, -0.14928380f, 0.01992110f, 0.08387385f, 0.05044320f, 0.01028785f, -0.05822765f, 0.00718129f, 
    0.00953185f, 0.02384488f, -0.04697185f, -0.05068193f, -0.00063706f, -0.01113760f, -0.01423989f, 0.01701909f, 
    0.00411646f, 0.03682518f, 0.03578660f, 0.10093226f, 0.01957561f, -0.14310908f, 0.08233383f, -0.10942902f, 
    0.01028148f, -0.02717605f, 0.08484458f, 0.05697426f, -0.01377642f, 0.06941511f, -0.04017057f, 0.00656185f, 
    0.25376272f, 0.08947121f, 0.12224350f, -0.02604166f, -0.11182095f, -0.10353058f, 0.08455908f, -0.03119333f, 
    0.07150722f, 0.05165213f, -0.07326778f, -0.00023565f, 0.12699799f, 0.04350274f, 0.09861550f, -0.04101265f, 
    -0.12265990f, 0.01163182f, 0.07461369f, -0.01163264f, -0.07178825f, 0.03199190f, 0.03669871f, -0.07385382f, 
    0.11376815f, -0.03258296f, -0.05692083f, 0.00226050f, -0.08377214f, 0.04557011f, 0.09140833f, -0.01328052f, 
    -0.05864466f, 0.00865328f, 0.02763889f, -0.13172014f, -0.13953015f, 0.08130451f, 0.02971404f, -0.03600309f, 
    -0.07528232f, 0.03315320f, -0.00168735f, -0.08936384f, 0.04919366f, 0.04782638f, -0.11583187f, -0.02957047f, 
    -0.03838552f, 0.12039776f, -0.12980448f, 0.03742153f, -0.05146024f, -0.00202397f, -0.01736449f, -0.03805470f, 
    0.01085220f, 0.00386345f, 0.01216734f, 0.07556500f, -0.01299987f, 0.04521998f, 0.12863101f, 0.08238444f, 
    -0.05627254f, -0.04014205f, 0.01771851f, -0.02329539f, -0.00897357f, -0.04119322f, 0.01402549f, 0.05359632f, 
    -0.19201685f, -0.03441201f, -0.07267907f, -0.16525923f, 0.05277025f, -0.07824772f, -0.04972824f, -0.02547042f, 
    -0.00973264f, -0.00096318f, -0.00474486f, 0.01171254f, -0.38201332f, 0.16304737f, -0.01293338f, -0.03280361f, 
    -0.01098279f, -0.14221328f, 0.00127789f, 0.05527415f, -0.00945572f, -0.00079613f, -0.03530924f, -0.00705712f, 
    -0.04043431f, -0.06856564f, -0.09633172f, 0.05837870f, 0.08421982f, 0.10692231f, 0.06035560f, 0.03426371f, 
    0.05191465f, 0.05595262f, 0.03063572f, -0.04410320f, 0.21161105f, 0.07203507f, -0.05408982f, 0.01308423f, 
    -0.06276646f, -0.02511825f, 0.11778980f, -0.07932928f, 0.06378821f, 0.02426617f, 0.04496548f, 0.02154251f, 
    0.20357782f, 0.14537892f, 0.01209325f, 0.06268404f, -0.08908118f, -0.05546965f, -0.05443251f, 0.07150488f, 
    -0.12213993f, 0.03089178f, -0.02364756f, 0.00665578f, -0.19006194f, -0.12399564f, -0.07615305f, -0.02141068f, 
    0.02409365f, 0.00169960f, -0.05589189f, 0.03258388f, 0.05829555f, 0.01019699f, 0.09933266f, 0.02166424f, 
    0.09990956f, 0.00437562f, 0.20160513f, -0.09365181f, -0.10583896f, 0.03717997f, 0.06225428f, 0.04703560f, 
    -0.00045968f, 0.06771229f, -0.03443233f, -0.05491121f, -0.01223122f, 0.04247497f, 0.01463191f, 0.14927058f, 
    0.04730617f, -0.02780777f, -0.02291066f, -0.00847270f, -0.01923263f, 0.00507980f, 0.07911442f, 0.04531899f, 
    0.04473793f, 0.14284492f, -0.13307355f, 0.17249554f, -0.02295658f, 0.00006868f, 0.00250254f, 0.00285966f, 
    0.00318197f, -0.08458123f, 0.04787936f, 0.01125284f, -0.20771764f, -0.00698175f, -0.18236500f, 0.04139622f, 
    0.08588873f, -0.00850252f, -0.09384691f, 0.05178970f, 0.10406137f, 0.08606596f, -0.00528745f, 0.04811462f, 
    -0.30809832f, -0.14207639f, -0.05342500f, -0.00850073f, 0.06421301f, 0.14178990f, 0.06438447f, 0.05922635f, 
    -0.07108840f, -0.05533406f, 0.01090544f, -0.07992774f, -0.24124035f, -0.16448416f, -0.10651546f, -0.00577917f, 
    0.02647137f, 0.01790505f, 0.09388242f, -0.07359730f, -0.05956227f, -0.09858640f, 0.00685819f, 0.03358075f, 
    0.14944956f, -0.09765553f, 0.04233557f, 0.17626593f, 0.03303290f, -0.02129767f, -0.01672439f, 0.02362504f, 
    0.03525761f, 0.05306499f, -0.03260234f, 0.02404332f, 0.12814939f, 0.11490825f, -0.07326466f, 0.06156982f, 
    0.08446346f, 0.02315262f, -0.07762634f, 0.01796889f, -0.02656952f, 0.08237883f, -0.02284362f, 0.01467003f, 
    -0.11250217f, -0.10106731f, -0.05395063f, -0.05432979f, -0.00723966f, 0.06152759f, 0.03728341f, 0.02646104f, 
    0.07223608f, 0.07108216f, 0.09552380f, 0.06480563f, -0.13752648f, -0.09849550f, -0.19566005f, -0.03116078f, 
    0.01134898f, 0.01619847f, 0.03846496f, -0.04297911f, -0.02300589f, -0.06370057f, -0.07502586f, 0.12030967f, 
    0.08025084f, -0.01765247f, 0.13022542f, 0.03678999f, -0.01026506f, 0.01827957f, 0.02838682f, -0.09490710f, 
    0.02944814f, -0.02655296f, -0.06047183f, -0.03448933f, 0.11781902f, 0.07703085f, 0.15528731f, 0.00553024f, 
    0.00918983f, -0.00301180f, 0.02538492f, 0.04976443f, -0.05911119f, -0.04425056f, 0.02404094f, -0.01232375f, 
    -0.06609470f, -0.14141682f, -0.19246086f, -0.05546093f, 0.01194292f, 0.06256595f, -0.02100811f, -0.07824758f, 
    0.01614516f, -0.07254755f, -0.02259238f, 0.03669556f, 0.19581781f, 0.13150312f, 0.12059362f, 0.00356781f, 
    -0.17145827f, 0.01596321f, -0.00033294f, -0.07042339f, 0.04902617f, -0.01973274f, -0.05076499f, 0.01379042f, 
    0.14697191f, -0.05227670f, 0.06407420f, 0.12434589f, -0.08877634f, 0.05414105f, -0.03542376f, -0.03910445f, 
    -0.11786072f, 0.05907759f, 0.03612840f, -0.01712849f, 0.17653286f, -0.15706526f, 0.02306607f, -0.02786993f, 
    -0.05243151f, 0.02264388f, -0.04629347f, 0.15039895f, 0.04263788f, -0.03643658f, -0.03073111f, -0.05044234f, 
    0.06771860f, -0.15744692f, -0.04815638f, -0.00972509f, 0.02629005f, -0.06635791f, 0.04216425f, 0.10835358f, 
    0.05767467f, 0.03344776f, 0.02314732f, 0.13740647f, -0.13792917f, 0.11709152f, -0.00292248f, 0.08126994f, 
    0.10946946f, 0.01277259f, 0.00681028f, -0.01796440f, -0.03287815f, 0.06640232f, 0.05097977f, 0.02963982f, 
    0.00041394f, 0.20409873f, 0.04713956f, -0.08178460f, -0.07127785f, 0.03608524f, 0.03145052f, -0.04450515f, 
    -0.08736475f, -0.06572772f, -0.06510779f, -0.05313078f, 0.04552444f, 0.09928136f, 0.10292352f, 0.08484931f, 
    0.00428965f, -0.04329223f, 0.01501372f, 0.03893209f, 0.01347621f, 0.08756018f, 0.10947286f, 0.05111620f, 
    0.10396062f, 0.21626464f, 0.08471978f, -0.06123443f, -0.07863813f, -0.00346809f, 0.01610089f, -0.10468360f, 
    0.03767447f, -0.08351135f, -0.08041866f, -0.02844629f, 0.12657686f, 0.11321405f, 0.07229370f, 0.16510476f, 
    0.03558938f, -0.03929763f, -0.07334808f, 0.11413485f, 0.02455404f, 0.10029585f, 0.02547479f, -0.02071157f, 
    0.12049720f, 0.16825542f, -0.02516509f, -0.09111200f, -0.06380235f, 0.08753764f, 0.04868006f, 0.01714654f, 
    -0.02106486f, 0.01537568f, -0.06337763f, -0.12822795f, -0.10525314f, -0.05150319f, 0.07177650f, 0.04251593f, 
    0.01699971f, 0.02703056f, -0.07654046f, -0.02456385f, 0.07092489f, -0.00863057f, 0.05603892f, 0.01492409f, 
    0.01390594f, 0.08732992f, 0.13776037f, 0.02518609f, -0.02534989f, -0.03887987f, 0.06024295f, 0.01332030f, 
    -0.01988610f, 0.03194240f, -0.06488188f, 0.04018030f, -0.01937882f, -0.16419515f, -0.06767578f, -0.10284346f, 
    0.01289903f, -0.02003274f, 0.02724250f, -0.00952684f, 0.07036265f, 0.04303498f, 0.08294898f, -0.10250723f, 
    0.01686726f, 0.05747999f, 0.14398485f, 0.01723784f, 0.03625169f, -0.00977299f, -0.04392338f, 0.00698399f, 
    0.00827274f, -0.03342077f, -0.04274652f, -0.03496408f, 0.04242779f, -0.01108626f, 0.09124622f, -0.07937717f, 
    -0.07862384f, 0.02511550f, 0.02337220f, -0.01639720f, -0.01975249f, -0.01216861f, -0.03330489f, -0.01863871f, 
    0.32451093f, 0.09855512f, 0.09047577f, 0.15868388f, 0.00453592f, 0.00708374f, 0.02986977f, 0.11804269f, 
    0.00594925f, -0.03918806f, -0.02964889f, 0.04125278f, 0.04086126f, -0.11126522f, -0.18700026f, 0.03023094f, 
    0.03736001f, 0.01816172f, -0.03208198f, 0.05008394f, 0.03237353f, -0.02393944f, -0.02581728f, 0.01214990f, 
    0.06887648f, -0.02613042f, -0.10314883f, 0.00706407f, 0.02713245f, -0.07540543f, 0.00070678f, 0.07904431f, 
    0.01971438f, 0.10663237f, -0.06841873f, -0.02533326f, 0.21860057f, 0.17124765f, 0.05116584f, 0.06112887f, 
    0.01288234f, -0.08607719f, -0.02636530f, -0.04445925f, 0.02241779f, -0.01133746f, 0.05239544f, -0.05106923f, 
    0.20710373f, 0.12129518f, 0.14255522f, -0.00319523f, -0.08596229f, -0.02008235f, 0.07994480f, 0.04590354f, 
    -0.05349354f, -0.00203930f, 0.07128867f, -0.04034445f, 0.02588812f, 0.03720790f, -0.02056229f, -0.05802606f, 
    0.03288658f, 0.04343535f, 0.02339842f, -0.06381970f, 0.04800782f, -0.10723463f, -0.05752086f, 0.02804869f, 
    0.15370551f, -0.02812599f, -0.18982768f, 0.06793691f, 0.09365759f, -0.05349408f, -0.03567832f, 0.02995346f, 
    0.01542470f, -0.07347915f, 0.02200900f, -0.02598105f, 0.22566023f, 0.16832058f, 0.02229296f, -0.01044932f, 
    -0.00116963f, -0.06578040f, -0.00906111f, 0.05634987f, 0.04924098f, 0.02556692f, -0.03947600f, -0.00859901f, 
    -0.04843070f, -0.20429434f, -0.07122958f, 0.17804424f, 0.12453517f, -0.01438607f, 0.11107398f, 0.02691188f, 
    -0.04691477f, -0.02584857f, 0.05106970f, -0.07243668f, -0.11704180f, 0.03562912f, -0.02543814f, -0.01503328f, 
    -0.09667838f, 0.00914296f, 0.06135157f, -0.02763150f, 0.03517520f, -0.00230820f, 0.14333574f, -0.03293286f, 
    0.03598975f, -0.00019047f, 0.13750717f, 0.01744266f, 0.03726496f, -0.01377368f, 0.05905316f, 0.07394604f, 
    0.05538118f, 0.00160862f, 0.00635473f, 0.03731751f, -0.09757245f, -0.11913298f, -0.17276160f, 0.00233916f, 
    0.09430503f, 0.03582411f, 0.09691907f, -0.03627948f, -0.04262655f, 0.06575298f, -0.08709832f, 0.00908538f, 
    -0.12015699f, -0.16931461f, -0.00118968f, 0.04643437f, 0.07556941f, -0.04453731f, -0.00833263f, -0.01892598f, 
    0.04015975f, 0.00019231f, -0.04465451f, 0.03293113f, 0.18222176f, 0.10479352f, -0.14933421f, 0.09127502f, 
    0.11823894f, -0.00091132f, -0.11773251f, -0.01617487f, 0.05338136f, -0.00553346f, 0.00281027f, -0.07101599f, 
    -0.26319093f, -0.09236480f, -0.11802108f, -0.05090940f, 0.08728221f, 0.03071461f, 0.01791778f, -0.02225235f, 
    -0.00751234f, -0.00805027f, 0.03184875f, -0.05427307f, -0.01759616f, -0.12359923f, -0.16714676f, 0.03412285f, 
    0.01063576f, 0.03760988f, -0.05295963f, -0.09384592f, -0.01924214f, -0.05761670f, 0.08872001f, -0.03056510f, 
    -0.11290211f, -0.24565600f, -0.31893641f, -0.07842895f, 0.13552637f, 0.05127022f, 0.07349120f, -0.01610882f, 
    -0.07873282f, -0.06840608f, 0.01657689f, 0.05616492f, 0.29481229f, -0.01315466f, 0.22337681f, 0.05446095f, 
    0.02380267f, -0.01924626f, 0.02482477f, -0.05303645f, -0.01523045f, 0.01747033f, 0.05125593f, 0.09894979f, 
    0.20630117f, 0.02717812f, 0.11112663f, 0.02620366f, -0.05771668f, -0.00149084f, -0.05110326f, 0.14333303f, 
    0.10098614f, 0.06459273f, 0.06309183f, 0.00027552f, 0.11744684f, 0.09897050f, -0.02796166f, -0.02559313f, 
    0.00020690f, 0.00836985f, -0.01254961f, -0.03137136f, -0.00853674f, 0.05904232f, -0.01229869f, 0.02628141f, 
    0.09488814f, 0.14914775f, -0.07950696f, 0.03758756f, -0.04150289f, -0.10152496f, 0.05595759f, 0.07670563f, 
    -0.01808744f, 0.00573946f, 0.05747732f, 0.03867545f, -0.25606990f, 0.13154244f, -0.19171810f, 0.01437896f, 
    -0.01002980f, 0.11693393f, 0.05956296f, -0.05404372f, -0.04741709f, -0.05970633f, 0.17871632f, -0.02365323f, 
    0.13828723f, -0.04147565f, 0.00951351f, 0.08750442f, -0.08163899f, 0.04613727f, -0.01346140f, 0.05702456f, 
    0.06350096f, -0.02420967f, 0.02997133f, 0.03967683f, 0.30086091f, -0.03727923f, -0.06706411f, 0.08940151f, 
    0.07303974f, -0.02798684f, -0.07836384f, 0.07362480f, -0.11327481f, 0.03222194f, 0.03233625f, 0.21774934f, 
    -0.02883703f, 0.12295314f, 0.16186523f, 0.09429871f, 0.05134459f, 0.14056659f, -0.01216629f, 0.11887494f, 
    0.06703023f, -0.01296490f, 0.05090294f, 0.03245666f, -0.10430169f, 0.00193777f, 0.08703452f, 0.10367420f, 
    0.03824853f, 0.02982566f, 0.01996572f, 0.01354497f, 0.06410758f, 0.00182779f, -0.04203049f, 0.09938486f, 
    0.03296354f, 0.19159628f, 0.12210141f, 0.15217361f, 0.10010092f, 0.02248758f, -0.03922930f, -0.08548386f, 
    0.00103997f, -0.06780578f, 0.04887284f, 0.12694572f, -0.07866537f, 0.13992536f, 0.05052872f, 0.10731116f, 
    -0.02201476f, 0.00975513f, 0.01479414f, 0.12855919f, 0.03295472f, -0.07874894f, 0.15682290f, 0.03992052f, 
    0.09638397f, 0.12079238f, 0.07664985f, -0.10186166f, -0.04139643f, -0.00643690f, 0.02154887f, 0.02266277f, 
    -0.04741978f, 0.03875520f, 0.02198185f, 0.00654586f, 0.01232004f, -0.15171017f, 0.04759004f, 0.06973892f, 
    0.05886281f, 0.07724858f, 0.12996329f, 0.11657203f, 0.15455592f, 0.09704931f, 0.04520135f, -0.00623346f, 
    0.28441724f, 0.06530733f, 0.11881341f, 0.46085441f, -0.00243021f, 0.07847220f, 0.04723340f, -0.02123766f, 
    0.04093999f, 0.00493322f, -0.04804502f, -0.07553452f, 0.38941050f, 0.06892561f, 0.09658531f, 0.21632479f, 
    -0.01409740f, 0.11311110f, 0.03452313f, 0.00907120f, 0.03473264f, -0.05860411f, 0.02635798f, -0.03453454f, 
    -0.19046450f, 0.01736688f, -0.03730620f, -0.03547543f, -0.02045568f, -0.00056219f, -0.05419482f, -0.12937327f, 
    -0.04614490f, 0.15254365f, -0.03699897f, 0.03746580f, -0.18454809f, -0.00099460f, 0.16471803f, 0.17009109f, 
    0.10543381f, 0.14125805f, 0.07956899f, -0.11041658f, -0.03592428f, 0.03990452f, 0.13740537f, -0.00147777f, 
    -0.02782817f, -0.04732230f, 0.19422561f, -0.13464028f, 0.07051411f, 0.01829591f, 0.07072247f, 0.02918296f, 
    0.06477636f, 0.07946569f, 0.03924078f, 0.15416537f, 0.22793205f, 0.07667811f, 0.05075439f, 0.14299883f, 
    -0.00894832f, 0.00470681f, -0.00124479f, -0.01602271f, -0.07633308f, 0.02174206f, -0.02896074f, -0.00685230f, 
    -0.10967362f, 0.04147427f, 0.06079334f, 0.07042658f, -0.02053094f, -0.01012624f, 0.09754750f, 0.12735732f, 
    -0.00694454f, 0.03183438f, -0.00725645f, 0.13958335f, -0.06820746f, -0.24471509f, -0.07088953f, -0.14418128f, 
    -0.05772302f, 0.05738708f, 0.11648584f, 0.06142299f, 0.03241963f, 0.03203749f, 0.00222617f, 0.04532823f, 
    0.06013841f, 0.12232526f, 0.06349193f, -0.08264174f, -0.05923442f, 0.05916337f, -0.01057109f, 0.05826380f, 
    -0.06188742f, 0.06481302f, -0.02723938f, 0.02058397f, 0.28309056f, 0.04148563f, -0.05592472f, 0.00730071f, 
    -0.01662179f, 0.01746950f, -0.01267198f, 0.01845000f, -0.11457591f, 0.02229796f, -0.02309484f, -0.00399741f, 
    0.19884536f, 0.04415917f, 0.06347466f, 0.05608767f, 0.09581605f, -0.00500181f, -0.08339401f, -0.03660676f, 
    0.04103499f, 0.06795741f, 0.02202637f, -0.06762730f, 0.23048836f, 0.14031763f, 0.14432132f, 0.16313110f, 
    -0.01482927f, 0.02761292f, -0.04901994f, 0.03880070f, 0.01921985f, 0.00508231f, -0.06528126f, -0.10710307f, 
    0.08445373f, -0.12109250f, -0.18029380f, -0.09193347f, -0.00872281f, -0.00139182f, 0.03996050f, 0.02494790f, 
    0.04792259f, -0.01651073f, 0.01129843f, -0.03305521f, -0.03216085f, 0.17425454f, -0.00255476f, -0.12119447f, 
    -0.05020956f, 0.06132568f, 0.03699792f, -0.04271652f, -0.02834504f, -0.05598544f, -0.00533711f, -0.05555770f, 
    0.09467757f, 0.12125014f, 0.10975921f, 0.18261527f, 0.03545098f, -0.07181810f, -0.08731561f, -0.09831779f, 
    -0.03245861f, -0.01332040f, 0.02753146f, -0.00121539f, 0.29980785f, 0.10718459f, 0.04388268f, 0.15350351f, 
    0.01457463f, -0.02388221f, -0.06406222f, 0.08722521f, 0.03774981f, 0.06187300f, -0.01332388f, -0.07128951f, 
    -0.24076234f, 0.03895921f, 0.08197138f, -0.05083201f, 0.07953368f, -0.00413708f, -0.02797401f, 0.00290201f, 
    -0.03282409f, 0.03884322f, -0.02734346f, -0.04790170f, -0.09390949f, -0.39567885f, -0.04180095f, 0.05792130f, 
    -0.03942896f, -0.07337525f, -0.01701747f, 0.00598998f, 0.05826852f, 0.07056244f, -0.13709180f, -0.07517391f, 
    -0.02072303f, -0.23533124f, 0.02546698f, 0.16808735f, -0.01100245f, -0.02472310f, 0.06319031f, 0.07140493f, 
    -0.04381589f, 0.05075612f, -0.08817457f, -0.07698510f, -0.15095192f, 0.08474969f, 0.26576972f, 0.17158021f, 
    0.08014955f, 0.07960688f, 0.05426260f, 0.14348291f, 0.05123956f, 0.08802693f, 0.05711980f, 0.06713705f, 
    -0.13628732f, 0.01685059f, 0.16561763f, -0.04568264f, -0.01077378f, 0.00839703f, -0.03891387f, 0.03393489f, 
    0.02069185f, -0.05894623f, -0.10775875f, 0.01176683f, 0.19623493f, 0.13648985f, 0.00936243f, -0.06407831f, 
    -0.01853759f, -0.03539747f, 0.06136394f, -0.02490008f, -0.03082301f, 0.03253968f, -0.05291208f, 0.14597738f, 
    0.13798986f, 0.14130421f, -0.08108960f, -0.06715968f, -0.08445323f, 0.00368780f, 0.03444115f, 0.02374450f, 
    0.00527772f, 0.00596670f, 0.10129268f, -0.15918295f, -0.01567183f, 0.10211807f, -0.02068274f, -0.19815208f, 
    -0.04938298f, 0.03087539f, 0.09616058f, 0.06769416f, -0.05646122f, -0.14168139f, -0.15878700f, 0.00329624f, 
    -0.10171521f, 0.00340619f, 0.09660360f, 0.15485281f, 0.00033701f, 0.11200874f, 0.06472577f, 0.05064587f, 
    0.04519346f, -0.00157538f, 0.03734852f, 0.04077642f, -0.04303887f, -0.10012464f, -0.02948562f, -0.18908896f, 
    -0.06599478f, 0.01845960f, 0.01032942f, 0.02463645f, 0.04181417f, 0.09760965f, -0.03988881f, 0.11464245f, 
    -0.08341720f, 0.04260445f, 0.10088743f, 0.09774640f, 0.00622424f, -0.00700622f, 0.02020980f, 0.13520648f, 
    -0.07892656f, 0.07381587f, 0.00926548f, -0.00253731f, 0.14476691f, 0.07598717f, -0.13748717f, -0.15462410f, 
    0.04177962f, 0.01642495f, -0.00073348f, -0.04142837f, 0.03154412f, -0.03577826f, -0.02634134f, 0.03174469f, 
    -0.19139397f, -0.05704457f, 0.19580802f, 0.03854343f, 0.06135429f, -0.01067136f, 0.04128080f, 0.07852326f, 
    0.06147081f, -0.00224932f, 0.09198990f, 0.09624532f, 0.03903614f, -0.02191199f, -0.02329647f, -0.05129332f, 
    -0.06557036f, -0.01254276f, 0.07545323f, 0.06464649f, 0.00450885f, -0.02439362f, -0.02774626f, 0.03476554f, 
    -0.07093085f, 0.19950329f, -0.21744063f, 0.01095900f, -0.06425314f, 0.00335974f, 0.01973474f, -0.05634830f, 
    -0.03286786f, -0.07402401f, 0.06247596f, -0.03796628f, 0.31818107f, 0.05953137f, 0.04796113f, 0.36734441f, 
    -0.02045459f, 0.12329950f, 0.09301151f, 0.05238158f, -0.02923034f, 0.09034324f, 0.02825367f, 0.09848907f, 
    -0.02929304f, 0.13884202f, -0.18015401f, -0.24076751f, -0.01542655f, -0.05522869f, 0.06439869f, -0.05452321f, 
    -0.01649124f, -0.04170759f, 0.04532414f, -0.00745691f, -0.05180970f, -0.06198908f, 0.13659529f, 0.24268447f, 
    0.06611363f, -0.09033525f, 0.09213882f, -0.03666531f, 0.03653691f, 0.03876466f, 0.02395943f, 0.11131145f, 
    -0.02861738f, -0.21643767f, -0.06910437f, -0.01847165f, -0.01872566f, 0.07102306f, -0.07324594f, 0.05052769f, 
    -0.00779548f, 0.05782585f, 0.09510137f, -0.06796285f, 0.20318285f, 0.15259394f, 0.17808850f, 0.08818204f, 
    0.01271279f, 0.06518270f, -0.07339147f, 0.05386654f, -0.00757068f, 0.05314742f, 0.07920113f, -0.07021826f, 
    0.22920251f, 0.12933895f, -0.04693246f, 0.06586069f, -0.00980749f, -0.04000201f, 0.02099462f, -0.09501579f, 
    -0.04336868f, -0.00462394f, 0.02776209f, 0.09217800f, -0.09650201f, 0.08470268f, 0.07726681f, -0.11417075f, 
    -0.10338461f, 0.02448782f, 0.02532964f, 0.13727838f, 0.03750449f, -0.00489659f, -0.00312487f, -0.12927744f, 
    0.04308837f, -0.07322265f, -0.09322719f, 0.06588180f, 0.11305260f, 0.18996260f, -0.14158684f, -0.02773651f, 
    0.04940172f, 0.05639458f, -0.08155204f, 0.00024632f, 0.12328870f, 0.06604122f, 0.08982813f, 0.07339313f, 
    -0.10938972f, -0.02831535f, -0.03827320f, -0.06389845f, -0.02393912f, 0.09009890f, -0.08559068f, -0.06434125f, 
    0.14858171f, 0.05978939f, -0.00457665f, 0.18238693f, -0.00908986f, 0.04990106f, -0.06829978f, 0.07020667f, 
    0.01363234f, 0.14114583f, -0.07756033f, -0.04363406f, -0.10216836f, -0.13019164f, 0.01619000f, -0.22068463f, 
    0.05380085f, 0.13633515f, 0.01861969f, 0.00506615f, 0.02475611f, 0.01380803f, 0.05496492f, -0.07689909f, 
    0.02689595f, 0.08363203f, 0.01505572f, 0.02003786f, -0.02952848f, 0.08592749f, 0.00660822f, 0.02334765f, 
    0.16144592f, -0.04002533f, -0.07672340f, -0.05629799f, 0.29996407f, -0.10181755f, -0.15922375f, 0.20059554f, 
    0.09356449f, 0.03607138f, 0.04006825f, 0.19848250f, 0.03170132f, 0.15312260f, 0.09082150f, 0.16103372f, 
    -0.25818619f, -0.01630104f, -0.01344171f, 0.16963214f, 0.02024717f, 0.11057116f, -0.05906396f, 0.02686924f, 
    -0.05570217f, -0.03778463f, -0.10565139f, -0.06276884f, 0.18054326f, 0.02284875f, 0.13361712f, 0.16133815f, 
    0.00434947f, -0.03343777f, -0.00758460f, -0.02519762f, 0.01040126f, -0.04678287f, 0.12368015f, 0.03823624f, 
    0.09905843f, 0.02611089f, 0.08248400f, 0.11930650f, -0.03419074f, 0.02755854f, 0.01558750f, -0.04197339f, 
    -0.09502845f, -0.04647852f, -0.06484190f, -0.15909249f, -0.14319295f, 0.03365337f, 0.00205693f, -0.14464806f, 
    -0.07589272f, 0.02368160f, -0.09294689f, -0.03462640f, 0.04585294f, 0.02489780f, 0.03011594f, -0.08342968f, 
    0.23118812f, -0.00422893f, 0.14830765f, 0.21057630f, -0.03865974f, -0.06542350f, -0.01614326f, -0.06821971f, 
    -0.01181857f, -0.07824061f, -0.10315313f, -0.12218758f, 0.15472189f, 0.10735168f, 0.02007879f, 0.08926645f, 
    -0.00773043f, -0.03231383f, 0.04995835f, 0.04196994f, 0.02048630f, -0.01159951f, -0.04290164f, -0.09157322f, 
    0.22025310f, 0.14752328f, 0.10695174f, 0.32054478f, 0.00046098f, -0.02249233f, -0.03738615f, 0.03349502f, 
    0.04967673f, 0.00875069f, 0.03620315f, -0.12198570f, -0.22690871f, -0.13683587f, 0.08484138f, -0.01746629f, 
    0.02925576f, 0.06301107f, -0.04739917f, 0.08529110f, -0.11233699f, -0.01530766f, 0.02351509f, 0.13621435f, 
    0.18927021f, -0.13837047f, 0.02145599f, 0.02249357f, -0.00765236f, 0.08850048f, 0.00360041f, -0.11064850f, 
    0.03932532f, 0.10076746f, 0.01690152f, 0.03926001f, -0.00014955f, 0.13521323f, 0.05835792f, 0.03580755f, 
    0.00300288f, 0.05214189f, 0.07378855f, 0.01308314f, 0.03540350f, -0.06170861f, -0.01453506f, 0.09934555f, 
    -0.02764041f, 0.02472145f, -0.03497262f, 0.01248404f, 0.01891111f, -0.03491929f, -0.03042409f, -0.01025924f, 
    0.02673011f, 0.01716189f, -0.01614269f, -0.01747121f, 0.02481609f, 0.02436718f, 0.01328633f, -0.02632814f, 
    -0.02677597f, 0.02213122f, 0.00697845f, -0.00716175f, 0.00584928f, -0.02279524f, -0.04103923f, -0.01482967f, 
    -0.03282818f, -0.02237432f, 0.01987511f, 0.00124897f, -0.02656465f, -0.01748844f, -0.02136781f, -0.03287260f, 
    -0.00314575f, -0.01109669f, -0.01350321f, -0.02227288f, -0.01098591f, -0.02688242f, -0.00832617f, 0.02662262f, 
    -0.01283316f, -0.03605013f, 0.00360188f, 0.02639412f, 0.01834145f, -0.03457859f, -0.00217711f, -0.02059840f, 
    -0.01681883f, -0.01277445f, 0.03450328f, -0.03937620f, -0.01774412f, 0.01187922f, -0.02610019f, -0.03168744f, 
    -0.00704509f, -0.03330927f, -0.03095178f, -0.02147730f, 0.01931367f, 0.01983792f, -0.01092475f, 0.01390118f, 
    -0.02524113f, -0.01573452f, 0.00751113f, -0.02922314f, -0.02436274f, -0.03589054f, -0.02157549f, -0.01093990f, 
    0.01125176f, -0.04121270f, -0.00243574f, -0.03640205f, -0.03156120f, -0.02278082f, -0.03120908f, -0.03468104f, 
    -0.00124502f, -0.02753804f, -0.02560817f, 0.02644850f, -0.02680815f, -0.00384767f, 0.00373985f, -0.03027557f, 
    0.01366333f, -0.00114104f, -0.03877969f, -0.02491380f, -0.01373077f, -0.02064598f, 0.02767916f, 0.00218052f, 
    0.01654280f, -0.02618390f, 0.02024404f, 0.00365881f, 0.00367945f, -0.01383495f, -0.00328334f, -0.01050836f, 
    0.00226583f, -0.00927634f, -0.00632595f, -0.03992825f, -0.03724035f, 0.02379926f, -0.03433915f, 0.00141686f, 
    -0.03041468f, 0.02549813f, -0.00486686f, -0.01923810f, -0.03218146f, -0.02938297f, -0.02947468f, -0.00669168f, 
    -0.03113002f, 0.00325771f, -0.02090958f, -0.02916470f, 0.00041716f, -0.01723695f, -0.02844850f, -0.01420873f, 
    0.01003689f, -0.01432243f, -0.02247227f, 0.01640662f, -0.03858385f, -0.02474694f, 0.00917624f, -0.00318721f, 
    -0.00620827f, 0.02222030f, -0.02834364f, -0.00174898f, 0.01332809f, -0.04068498f, -0.01805854f, -0.04116110f, 
    -0.00204481f, 0.01204582f, 0.02221799f, -0.03229910f, -0.01031930f, -0.04125445f, -0.00070032f, -0.01723352f, 
    0.02141044f, 0.00873084f, 0.01448090f, -0.02427379f, -0.03739687f, 0.00873981f, 0.02937625f, -0.04059665f, 
    0.02137182f, 0.01951275f, 0.00349603f, -0.01371338f, -0.02703648f, 0.02829906f, 0.00039176f, -0.03026065f, 
    -0.01353100f, 0.02248547f, -0.00767317f, 0.00436100f, 0.02742445f, -0.02964939f, -0.04182371f, 0.01137034f, 
    0.01697930f, -0.03650574f, -0.02499667f, -0.01840478f, 0.01557870f, 0.02228191f, -0.00151349f, 0.01162869f, 
    0.01576273f, -0.00925943f, -0.00734942f, -0.01089930f, 0.00990391f, -0.01223318f, 0.00131898f, 0.02976522f, 
    -0.01201227f, 0.00876030f, 0.01217599f, -0.00282446f, -0.01330612f, 0.01480537f, -0.01443528f, -0.00947932f, 
    0.02352951f, -0.02847412f, -0.03458863f, -0.04158055f, 0.00323280f, 0.00394883f, -0.03195183f, -0.01086702f, 
    -0.04155292f, -0.02727707f, -0.01499701f, 0.01608695f, 0.00302861f, 0.01430194f, 0.02345449f, -0.00834457f, 
    -0.00448512f, -0.02470588f, 0.02590430f, 0.02249832f, 0.00971792f, -0.02041240f, 0.01951310f, 0.00229793f, 
    -0.02779965f, 0.00374306f, -0.03815486f, -0.03887650f, -0.03263870f, 0.01888349f, 0.00944937f, 0.01022412f, 
    0.00187182f, -0.04143060f, -0.00876127f, 0.00655235f, -0.02292292f, -0.00438506f, -0.00204384f, 0.02029674f, 
    0.03000616f, -0.03079624f, -0.00252431f, -0.02914126f, -0.04113526f, -0.03138135f, 0.00875593f, -0.00295812f, 
    -0.03483811f, -0.03519220f, 0.02145899f, -0.01329740f, -0.03516872f, -0.02973814f, 0.00343124f, 0.01412516f, 
    0.00052667f, 0.01644464f, -0.02052213f, 0.02240800f, 0.00553189f, 0.00796484f, -0.00124836f, -0.00151669f, 
    0.00384184f, -0.00445987f, -0.03840256f, -0.03145850f, -0.03797454f, -0.01657811f, 0.02266852f, -0.01858472f, 
    0.01465351f, -0.02952802f, -0.04020129f, 0.02218530f, -0.03466315f, -0.00464734f, 0.02186524f, 0.00168769f, 
    -0.03706820f, -0.00125586f, -0.02480959f, -0.00836303f, -0.02776196f, -0.03236543f, 0.02116305f, 0.01849422f, 
    -0.03049446f, -0.04046269f, 0.02969013f, 0.01022136f, 0.02975422f, 0.00750215f, 0.02399246f, -0.03789456f, 
    0.00660394f, 0.01347112f, 0.00895441f, -0.02655364f, 0.02777334f, 0.01605609f, -0.03501451f, 0.01313114f, 
    0.01864222f, 0.03446883f, 0.00429047f, 0.00776363f, 0.01585331f, -0.03301735f, -0.02246443f, -0.01248231f, 
    -0.03195998f, -0.01027266f, -0.00645307f, -0.01109924f, 0.00448712f, -0.01521723f, -0.01080797f, -0.00657418f, 
    -0.02633797f, 0.01594109f, 0.02845108f, -0.00532135f, 0.02152493f, 0.02353924f, -0.02663494f, -0.02784676f, 
    -0.04125961f, 0.00576020f, 0.01530411f, 0.00226103f, -0.01432896f, 0.02091165f, -0.02336910f, -0.02278079f, 
    0.00174489f, -0.02890533f, -0.01113457f, -0.00996280f, -0.00647314f, -0.03523923f, -0.00765116f, 0.01958716f, 
    -0.02721311f, 0.00123061f, -0.02655299f, 0.02893146f, -0.01476583f, -0.03107400f, 0.00332985f, -0.03169137f, 
    0.02787682f, 0.02755485f, -0.03077853f, 0.02815947f, -0.03826130f, 0.00766912f, -0.01096080f, 0.02293216f, 
    -0.00178262f, -0.00188069f, -0.03849395f, 0.02648463f, -0.00848986f, -0.03612569f, -0.02230042f, -0.02550358f, 
    0.01815612f, -0.01006586f, 0.00092317f, -0.00631384f, -0.04111219f, 0.02376462f, -0.02295528f, -0.01148916f, 
    0.00980811f, 0.02187382f, -0.00577761f, 0.02981439f, -0.04084339f, 0.00727816f, 0.03415550f, -0.01192514f, 
    -0.02332550f, -0.00738046f, -0.03562738f, 0.01706211f, -0.03034874f, -0.01067688f, 0.01243953f, 0.01510748f, 
    0.01314432f, -0.02031588f, -0.00380472f, 0.01395307f, -0.02113581f, 0.01784956f, -0.01999624f, 0.01088231f, 
    -0.01354074f, 0.02044247f, -0.01082970f, -0.00631465f, -0.00523191f, -0.00716169f, -0.02326785f, -0.03574082f, 
    -0.02688484f, 0.01311718f, -0.00653337f, 0.02988881f, -0.02164960f, 0.02647209f, -0.00259725f, -0.03983144f, 
    -0.03557477f, -0.04185589f, -0.03511792f, 0.00162315f, 0.01558183f, 0.02279739f, 0.00507066f, -0.01494515f, 
    0.01774606f, -0.02403297f, 0.00904053f, -0.03589080f, 0.02235966f, -0.02037897f, -0.00006843f, -0.00429476f, 
    0.02411796f, -0.00360513f, 0.02820116f, 0.02455815f, -0.03097725f, -0.01902060f, 0.00624131f, -0.02476442f, 
    0.01661401f, -0.01147354f, -0.04037551f, 0.00947353f, 0.00596718f, 0.02587168f, -0.01729738f, 0.02789420f, 
    0.02812757f, 0.00153601f, 0.01385939f, 0.02069667f, 0.00223222f, -0.03744045f, -0.01959878f, -0.04095106f, 
    0.00002400f, -0.03379921f, -0.03412746f, -0.03831265f, -0.01056257f, 0.02404882f, 0.02744034f, 0.02781278f, 
    -0.01540995f, -0.00904534f, 0.00620797f, 0.01430631f, -0.01009318f, -0.03385543f, 0.00941566f, -0.01041032f, 
    0.02963126f, 0.00951251f, 0.00178366f, -0.00949060f, 0.02133739f, 0.01481755f, 0.01905945f, 0.00995733f, 
    -0.02116612f, -0.04180368f, 0.02698003f, 0.02743086f, 0.00536751f, -0.01131148f, 0.00354891f, -0.01388009f, 
    0.02063325f, -0.02230117f, 0.00979208f, 0.02854513f, 0.02649404f, 0.00729302f, -0.03550400f, 0.02081264f, 
    -0.00714327f, -0.01277315f, -0.00862357f, -0.01595441f, 0.00480890f, 0.00447438f, -0.00376154f, 0.01057879f, 
    -0.00716641f, 0.02893574f, -0.04066616f, 0.01720574f, 0.01743576f, -0.00213997f, 0.02060063f, 0.00261814f, 
    -0.03190044f, -0.02539905f, 0.00645107f, -0.01247639f, 0.00181252f, 0.01805675f, -0.00268203f, 0.01135880f, 
    -0.03503225f, 0.00635430f, 0.00604122f, -0.00982196f, -0.02909124f, -0.03773645f, -0.01401202f, -0.03188516f, 
    0.01019986f, -0.01891475f, -0.03699398f, -0.02890043f, -0.01469508f, -0.02772648f, 0.02807976f, -0.00587042f, 
    -0.00344307f, -0.01910261f, -0.03446567f, 0.00982904f, 0.02806155f, 0.01100850f, 0.02194186f, 0.00567877f, 
    -0.03310443f, -0.02087125f, -0.04070709f, -0.02989575f, -0.01418454f, -0.01104428f, -0.03738286f, -0.03095370f, 
    0.00195302f, 0.02337023f, -0.00768041f, 0.01073598f, -0.04150048f, 0.01282339f, -0.02889167f, -0.01890318f, 
    -0.01184348f, -0.00863494f, 0.03110892f, -0.03965540f, -0.03245157f, 0.00037156f, -0.01994348f, 0.01942857f, 
    0.00795536f, 0.00740978f, 0.00440180f, -0.03056824f, 0.02117351f, -0.00888348f, -0.02722595f, 0.02695025f, 
    -0.03919882f, -0.03117547f, 0.02501151f, -0.03263942f, 0.02326076f, 0.01091127f, 0.00619387f, 0.02314271f, 
    0.00958335f, -0.03476022f, 0.02268256f, -0.01174226f, -0.01067768f, 0.02560682f, -0.01752772f, -0.01021597f, 
    -0.04105997f, 0.01150101f, 0.02167229f, -0.02590940f, -0.02730567f, 0.00198491f, 0.01955600f, -0.02584985f, 
    0.02133265f, -0.01529076f, 0.01708540f, 0.02299295f, -0.01199912f, -0.01485686f, 0.03194626f, -0.02409596f, 
    0.01056881f, 0.02388399f, -0.02769578f, 0.01698899f, 0.00479964f, 0.00444038f, 0.00831467f, -0.01038489f, 
    -0.02025966f, 0.00064769f, -0.00673825f, -0.00744590f, 0.01734256f, -0.03637012f, -0.02694245f, 0.01535478f, 
    -0.01027129f, 0.01145644f, -0.03753018f, -0.01856828f, -0.02209393f, -0.01850533f, -0.02865996f, -0.00748569f, 
    -0.01793971f, -0.02027053f, 0.00036122f, -0.00547253f, -0.02702126f, -0.01282600f, -0.00248217f, -0.01070753f, 
    -0.01125565f, 0.01184805f, 0.02764327f, 0.01429451f, -0.03187204f, -0.00942776f, 0.02544323f, -0.03493820f, 
    0.01016585f, 0.01142197f, 0.01124186f, -0.04128548f, 0.00417450f, 0.00181588f, -0.01441173f, -0.03592175f, 
    -0.01452604f, 0.00601350f, -0.00198758f, 0.00646040f, 0.01738708f, -0.00095575f, 0.00794462f, -0.03791391f, 
    -0.00965001f, -0.03072189f, -0.01525528f, 0.02747648f, -0.03645627f, -0.01872380f, -0.01070054f, -0.02037353f, 
    -0.03277711f, -0.02324542f, 0.01042376f, -0.00863003f, -0.00003482f, -0.02681401f, 0.00646630f, 0.01261102f, 
    -0.03776101f, -0.03255761f, -0.01875173f, -0.03352765f, -0.01444054f, -0.03667049f, -0.01286204f, 0.00065006f, 
    0.03123606f, -0.01921389f, -0.02937760f, -0.04048525f, 0.00815811f, -0.02986124f, 0.01434119f, 0.01856158f, 
    0.01542463f, -0.01282550f, 0.00458723f, -0.01080056f, 0.01123743f, -0.02547296f, -0.03666211f, 0.01613595f, 
    0.00693768f, -0.02542590f, 0.00935945f, -0.03522143f, 0.01670193f, 0.00492413f, -0.04095697f, 0.02207719f, 
    0.01350050f, 0.00033498f, 0.00374997f, 0.02733725f, 0.01592521f, -0.02637694f, -0.03506121f, -0.03906022f, 
    -0.03750318f, 0.01913333f, -0.02675292f, 0.01889912f, -0.00835724f, -0.01084550f, 0.01479253f, -0.02056257f, 
    0.02215923f, 0.02527270f, 0.00183725f, -0.00735148f, 0.00336720f, 0.00929307f, -0.03587094f, -0.02731696f, 
    -0.03813290f, 0.01477355f, -0.03639682f, -0.02796189f, 0.02292487f, -0.01763478f, -0.01388874f, 0.01854881f, 
    -0.03940338f, -0.03625273f, 0.00943804f, -0.00855428f, 0.02425675f, -0.00080747f, -0.02504919f, 0.00847103f, 
    0.00341842f, 0.01084264f, -0.00632830f, 0.00328071f, -0.02309393f, 0.01713693f, 0.02743896f, -0.01652383f, 
    -0.03252936f, -0.04128290f, -0.03042456f, -0.03900659f, -0.00228781f, 0.02903279f, 0.00876416f, -0.03017769f, 
    -0.27145344f, 0.07051276f, 0.15648651f, 0.05111062f, -0.01471825f, 0.02254848f, 0.03787636f, -0.12517078f, 
    -0.04604740f, -0.03177174f, 0.12571472f, -0.00529888f, 0.27291808f, 0.08249434f, 0.11260141f, 0.15350536f, 
    -0.03236824f, -0.08492411f, -0.02123502f, -0.01765369f, 0.06114881f, 0.02331096f, -0.04942372f, 0.06512364f, 
    -0.26111570f, 0.03732171f, 0.08087292f, -0.05839078f, -0.00708750f, 0.07717721f, -0.05345891f, 0.02229300f, 
    -0.03724330f, 0.03457575f, 0.11791208f, -0.01225066f, -0.35897428f, -0.05522059f, 0.08024736f, 0.05726955f, 
    -0.01302152f, 0.05890404f, 0.01268802f, 0.03495344f, 0.00845174f, 0.07403472f, 0.03844977f, 0.03566692f, 
    -0.11635359f, -0.06384057f, -0.02735023f, -0.21331067f, 0.03793851f, 0.07788952f, -0.00531150f, -0.07360789f, 
    -0.07588293f, 0.05120461f, -0.02573431f, 0.01635247f, 0.14314204f, -0.04795065f, 0.02503403f, -0.13144454f, 
    0.08192156f, 0.02211880f, 0.04184308f, 0.00593527f, -0.03237147f, 0.01451935f, -0.02031291f, 0.10552520f, 
    0.21597347f, 0.04542532f, -0.03995687f, 0.02240028f, -0.07344984f, 0.01150556f, -0.09754635f, 0.04592388f, 
    0.05903221f, -0.00399187f, -0.04452568f, -0.02978984f, -0.20589571f, 0.06697346f, -0.03418733f, -0.09030858f, 
    0.03726178f, 0.03294441f, 0.04645193f, 0.00600220f, 0.01826861f, -0.01268452f, 0.02430506f, -0.03837650f, 
    0.01017096f, 0.24260236f, -0.10417674f, 0.07717907f, 0.05829340f, 0.10443024f, 0.00404322f, -0.00558774f, 
    0.03767190f, 0.07296676f, -0.00601633f, 0.03139502f, 0.21208616f, -0.16261514f, 0.09292551f, 0.09769540f, 
    -0.05660045f, 0.06998798f, 0.04088547f, -0.02972289f, 0.04233114f, -0.10118870f, 0.02797843f, 0.11782152f, 
    0.02012830f, 0.01401699f, 0.24318953f, -0.00112429f, 0.01798203f, -0.08883063f, -0.01117435f, -0.03040086f, 
    0.08815486f, -0.02960097f, -0.00354965f, 0.09432667f, 0.03902666f, -0.20986949f, 0.08982433f, 0.07289628f, 
    0.11856095f, 0.01058831f, -0.01625539f, -0.03148391f, -0.03366290f, -0.05412649f, 0.06701328f, 0.02279051f, 
    0.15323587f, 0.01622737f, -0.09908257f, -0.11828668f, -0.05648199f, 0.13471971f, -0.02087332f, 0.06979407f, 
    -0.01149953f, -0.00743778f, 0.05945208f, 0.00806442f, 0.02689670f, -0.06685513f, 0.03507183f, -0.00836238f, 
    0.02093145f, -0.06522340f, 0.03613510f, -0.01831018f, -0.00397883f, -0.00481056f, 0.01625285f, 0.07962640f, 
    0.12158339f, 0.06651436f, -0.11992458f, 0.03224356f, 0.07867904f, 0.04085913f, -0.06017083f, -0.09658362f, 
    0.03135438f, 0.02136658f, -0.04082004f, 0.03914792f, 0.03040342f, 0.03640601f, -0.04636962f, 0.04814150f, 
    0.01238758f, -0.00264926f, 0.04112872f, -0.08027553f, 0.01313417f, 0.06212237f, -0.04495278f, 0.10783132f, 
    0.11024710f, 0.06721496f, -0.06674033f, 0.00970797f, -0.00332386f, -0.06352402f, 0.00278519f, 0.07561934f, 
    0.01195677f, 0.03111107f, 0.05468566f, 0.02208100f, -0.01925247f, 0.06577175f, 0.04387663f, 0.02720227f, 
    0.00755119f, -0.08841331f, -0.06590173f, 0.02410143f, -0.04660975f, 0.03889724f, 0.08913917f, -0.09194515f, 
    -0.15193407f, 0.35156891f, 0.03190170f, 0.04986285f, 0.03627554f, 0.03048346f, -0.01015903f, 0.01906771f, 
    0.08686284f, 0.06521751f, 0.07142911f, 0.04774129f, -0.16052049f, 0.24902582f, 0.10758006f, 0.17860125f, 
    0.03481940f, 0.02049388f, 0.01117384f, 0.06445716f, 0.10659567f, 0.09592211f, 0.03692087f, -0.01358883f, 
    -0.17231193f, 0.07815546f, -0.07066939f, -0.13233465f, -0.02897663f, -0.00416655f, -0.00396029f, 0.02611807f, 
    -0.05401776f, -0.01127257f, 0.05406089f, 0.00742817f, -0.06294207f, 0.16768685f, -0.13662557f, -0.18683831f, 
    -0.03207317f, 0.04781766f, 0.02634864f, 0.12476733f, -0.05449491f, 0.02466309f, 0.06096979f, -0.00650975f, 
    -0.07443769f, 0.07990529f, 0.19598049f, 0.11010879f, 0.07214347f, -0.11946452f, -0.07049000f, -0.01483346f, 
    0.03660493f, -0.00120740f, -0.04139756f, -0.00734006f, 0.02549884f, 0.34101868f, 0.04603838f, 0.01848735f, 
    -0.05966019f, 0.08441748f, -0.01595876f, -0.01783339f, 0.14519133f, 0.03241154f, -0.02116759f, 0.00937733f, 
    0.05110510f, -0.01756928f, 0.10442865f, -0.06506685f, 0.06578097f, -0.08632849f, -0.01797931f, 0.03409289f, 
    -0.03435091f, 0.00689247f, -0.08697594f, 0.00067166f, -0.12127542f, 0.01080788f, 0.05647544f, 0.26022479f, 
    0.04847956f, -0.01609545f, -0.04197780f, -0.04001888f, 0.03546149f, -0.01159073f, 0.04422154f, 0.03056017f, 
    0.03404082f, -0.15321231f, -0.26038605f, 0.01166597f, -0.07707161f, 0.13263421f, 0.03574346f, -0.03107555f, 
    0.20030242f, 0.05726530f, -0.02296989f, -0.06111098f, 0.12406617f, 0.12844855f, 0.12805606f, -0.08371454f, 
    0.02914960f, -0.06778636f, 0.04950539f, -0.04188654f, -0.03215483f, 0.05049302f, -0.00621629f, -0.01269621f, 
    0.01401905f, 0.17398474f, 0.09118586f, 0.11972445f, 0.11425600f, -0.08096066f, 0.05671639f, -0.05823711f, 
    0.02131106f, 0.00399709f, 0.02255896f, 0.05084876f, 0.00088043f, -0.08995875f, -0.05805665f, -0.20517969f, 
    0.01718987f, 0.01935500f, -0.05438865f, -0.05320628f, 0.00236387f, 0.03258386f, 0.00264021f, 0.02386406f, 
    0.08211418f, -0.03420630f, 0.02677030f, -0.11662652f, 0.03219889f, -0.02512803f, 0.01900368f, 0.03427694f, 
    0.03004316f, 0.03893575f, -0.01689545f, 0.02952275f, 0.48857734f, -0.03852166f, 0.00745101f, 0.22497709f, 
    0.10875790f, -0.01354467f, -0.02012383f, 0.00738168f, 0.00566841f, 0.00982658f, -0.03267271f, 0.07716770f, 
    0.14080691f, 0.01844927f, -0.01942229f, -0.00322277f, 0.12813844f, -0.01269337f, 0.08067728f, -0.04989800f, 
    0.07540644f, -0.01799286f, 0.02371977f, 0.07526920f, 0.06254918f, -0.18474089f, 0.07123414f, 0.07752892f, 
    0.06461860f, 0.09087508f, 0.13593067f, -0.00523586f, -0.08915155f, 0.01292936f, -0.02772113f, 0.00684692f, 
    -0.18470614f, 0.05512476f, 0.11487482f, -0.10201779f, -0.08651096f, 0.01165460f, 0.08759575f, 0.02729347f, 
    -0.08188104f, 0.00403249f, -0.00212088f, 0.03499198f, -0.04178909f, -0.19273621f, 0.02609824f, -0.06859041f, 
    0.07738800f, -0.07215088f, 0.02250489f, -0.00289101f, 0.04294407f, -0.06755422f, 0.05538193f, 0.03584332f, 
    -0.06768285f, 0.01845860f, 0.08548003f, -0.14567153f, -0.01482846f, -0.02263729f, 0.01906435f, -0.04396366f, 
    -0.08577263f, 0.07923121f, -0.00315224f, -0.03672047f, 0.01572724f, -0.16858995f, 0.04206026f, 0.12177843f, 
    0.06921490f, 0.02587096f, 0.04560689f, -0.00947329f, 0.02229990f, 0.08444320f, 0.11370108f, 0.01999312f, 
    0.07990734f, -0.06136656f, -0.01680920f, -0.28803080f, -0.04183437f, 0.05848408f, -0.00435516f, -0.06084758f, 
    0.09598679f, 0.02540746f, -0.03412699f, -0.05947013f, 0.22939062f, -0.12432890f, 0.09593287f, 0.19762206f, 
    0.01496824f, -0.00999421f, 0.07893693f, -0.15857483f, 0.04733196f, 0.02755037f, 0.03283486f, 0.00298752f, 
    0.01385122f, -0.13890792f, -0.05630361f, 0.05432118f, -0.10594887f, 0.09082597f, 0.02667629f, 0.13143168f, 
    0.06868444f, 0.05918066f, 0.11690390f, 0.09993066f, 0.00817355f, 0.01528083f, -0.00904758f, 0.10104116f, 
    -0.11674915f, -0.05151259f, -0.00381789f, -0.01350397f, -0.09013697f, 0.06893925f, -0.00083627f, 0.01158551f, 
    0.01013604f, -0.07432640f, 0.02683342f, -0.04957489f, -0.02128682f, 0.01192477f, -0.03194947f, 0.11917086f, 
    0.10144835f, 0.01757446f, 0.03707604f, 0.00196420f, -0.02029758f, -0.25703835f, -0.00385857f, -0.06214271f, 
    0.04182588f, 0.00556692f, 0.02843766f, 0.03397885f, 0.09916605f, -0.02383679f, 0.01635290f, 0.10248363f, 
    -0.06877233f, 0.11492224f, 0.12638755f, 0.08855161f, 0.08768607f, -0.05414989f, -0.04496962f, 0.02141115f, 
    0.07240719f, 0.12544590f, 0.02051093f, -0.03230173f, -0.07628982f, 0.09701349f, -0.02928039f, -0.23447306f, 
    0.01765321f, -0.04775904f, 0.00504406f, 0.03809379f, 0.03244059f, 0.00189401f, -0.05173576f, -0.07161293f, 
    -0.08654533f, -0.06322586f, -0.08601798f, 0.09062162f, -0.02849832f, -0.10353683f, -0.03773803f, 0.04104270f, 
    0.04150052f, -0.01072260f, 0.13588677f, 0.10671367f, -0.00874733f, -0.01086977f, 0.05835307f, 0.06573565f, 
    -0.00718113f, 0.12761119f, 0.04065516f, -0.00530479f, -0.11113150f, -0.05986541f, -0.08597834f, -0.07737591f, 
    -0.20671922f, -0.00729391f, 0.13106407f, 0.22778121f, -0.02403872f, 0.01626915f, 0.01510287f, 0.04337202f, 
    -0.00020374f, -0.00465710f, -0.10128191f, 0.10778034f, -0.31185588f, -0.05366894f, 0.08146557f, -0.07437017f, 
    0.00659343f, 0.04424300f, -0.02221829f, -0.06380717f, -0.06473581f, -0.04167939f, 0.10304648f, -0.00530472f, 
    -0.18123849f, 0.16400182f, -0.17370947f, -0.01663733f, 0.03268611f, -0.06457327f, -0.04262673f, 0.04581174f, 
    0.07125916f, 0.02770993f, 0.03138608f, -0.17166771f, 0.14763241f, 0.04450478f, -0.04996541f, -0.10140077f, 
    0.15797736f, 0.01505857f, -0.00425197f, 0.00973382f, 0.00431475f, -0.07676408f, -0.04245808f, 0.09239991f, 
    -0.02499500f, 0.06777005f, 0.01874990f, -0.11890504f, 0.00758699f, -0.08317522f, -0.03823545f, 0.09550333f, 
    0.03245009f, 0.06177739f, -0.09005993f, -0.06998720f, -0.09607181f, 0.10790730f, -0.03562484f, 0.01714174f, 
    -0.15764388f, -0.01455394f, -0.06790984f, -0.06452423f, 0.09143193f, 0.01812920f, -0.03336915f, -0.00293814f, 
    0.01193096f, 0.11595703f, 0.02557093f, 0.08020249f, 0.01732172f, -0.09285235f, 0.01857391f, -0.08281977f, 
    0.00554083f, 0.02563423f, 0.04623662f, 0.00310231f, -0.12212839f, 0.11295367f, 0.02652654f, 0.04636929f, 
    0.07184937f, -0.05472457f, -0.14456303f, -0.00548530f, 0.03770312f, -0.01029452f, -0.01131631f, 0.03168546f, 
    0.08982017f, -0.06081080f, -0.07622219f, -0.18365379f, -0.04179985f, -0.08861716f, 0.07263974f, 0.05233965f, 
    0.03022603f, 0.05659824f, 0.03324027f, 0.01268024f, -0.12077719f, 0.08551399f, -0.06613488f, -0.31817955f, 
    -0.03117510f, 0.06181285f, -0.03104222f, 0.05380022f, 0.08933751f, -0.01928910f, -0.02608420f, 0.03713265f, 
    0.03364049f, -0.00654165f, -0.00243000f, -0.23812033f, -0.02973865f, -0.01633362f, -0.01239964f, 0.09838510f, 
    0.00343952f, 0.01352043f, -0.00570003f, -0.04585322f, -0.14106748f, 0.18504190f, -0.06449977f, -0.00988629f, 
    -0.02397763f, -0.00371821f, -0.03783393f, 0.05321455f, -0.02782350f, 0.00811918f, 0.01851309f, -0.00467580f, 
    -0.11885988f, 0.02787567f, 0.13694166f, -0.10282676f, 0.03473349f, -0.00963839f, -0.05482815f, -0.06569599f, 
    0.00894686f, 0.02225857f, -0.12035864f, 0.09213898f, 0.02351331f, 0.10584790f, -0.02288231f, -0.26702082f, 
    -0.01897064f, 0.09462078f, 0.04328221f, -0.09249258f, 0.06064266f, 0.07156882f, 0.00000389f, -0.07195053f, 
    0.06901023f, -0.04482965f, 0.02745104f, 0.19829036f, -0.05641435f, -0.09365200f, -0.03278860f, 0.01519296f, 
    0.09017733f, -0.01157159f, -0.06344504f, 0.04454555f, -0.19919497f, -0.21175149f, -0.00392534f, 0.07575338f, 
    0.00357743f, -0.02738557f, 0.01244417f, -0.07994284f, -0.02558790f, -0.03378485f, 0.05223115f, -0.00011626f, 
    0.04942198f, 0.06894225f, -0.07702000f, 0.09076911f, -0.05123580f, 0.05302954f, -0.00145538f, 0.04604705f, 
    -0.04971153f, 0.08501730f, -0.10886095f, -0.03364864f, -0.16878243f, 0.14327154f, -0.02865607f, 0.03171366f, 
    -0.08649344f, 0.02947709f, 0.02728084f, 0.05898404f, -0.02098839f, -0.05440089f, 0.06799559f, -0.03939429f, 
    0.48245358f, -0.09500634f, 0.02077905f, 0.14423262f, 0.04586139f, 0.02381323f, -0.05627064f, -0.06727163f, 
    0.00202664f, 0.05545690f, -0.15572530f, 0.06242531f, 0.35984167f, 0.25469711f, -0.02627788f, 0.06205760f, 
    0.05659433f, 0.07951728f, 0.00484024f, -0.13569362f, -0.01386274f, 0.04476870f, 0.10097678f, 0.01120239f, 
    -0.01106430f, 0.14000458f, -0.02137214f, 0.02362503f, 0.01287792f, 0.00149032f, -0.03760489f, 0.07155764f, 
    -0.02062496f, 0.04354566f, -0.08094850f, 0.07840302f, 0.05781961f, 0.18419774f, -0.03382877f, -0.15113723f, 
    0.10835654f, -0.01702734f, 0.03778207f, 0.10620537f, 0.05041356f, 0.02562399f, 0.06637099f, -0.05655320f, 
    0.14549480f, 0.13569397f, -0.09153230f, -0.13886228f, 0.15292121f, 0.02990530f, -0.00058853f, -0.09445821f, 
    -0.03075582f, 0.02342382f, 0.10147710f, -0.05031282f, 0.25112578f, 0.10356689f, 0.07967588f, -0.21230067f, 
    -0.00567879f, 0.12268431f, 0.06034886f, -0.11079013f, 0.00535526f, 0.06845289f, 0.04182822f, 0.07233079f, 
    -0.10736567f, 0.01173009f, 0.26301754f, -0.17307003f, -0.00350336f, -0.01478271f, -0.00105625f, 0.06579693f, 
    -0.02443746f, -0.00729178f, -0.01374342f, 0.00965341f, -0.15648548f, 0.30765852f, 0.00029173f, 0.06786966f, 
    0.09829778f, -0.02062288f, 0.02000647f, -0.05370710f, -0.00789143f, -0.07225839f, -0.07403282f, -0.00561230f, 
    -0.16921391f, 0.04265217f, -0.06956152f, 0.15894739f, -0.02383764f, 0.00793968f, -0.04395160f, -0.03933458f, 
    0.00429986f, 0.04726464f, 0.01176194f, 0.09657606f, 0.00201330f, 0.24031791f, 0.07333014f, -0.09986691f, 
    0.02803394f, 0.00909249f, -0.04233770f, -0.08747631f, 0.14306182f, 0.05898980f, -0.00332313f, -0.01377788f, 
    -0.04574092f, -0.11708835f, 0.16933084f, 0.16542797f, -0.12562725f, -0.01806120f, -0.04105598f, -0.01650655f, 
    0.02623223f, 0.01749352f, 0.04260743f, -0.03972191f, 0.12978429f, 0.14234895f, -0.13347423f, 0.14319724f, 
    0.09183884f, 0.09081463f, 0.06037933f, -0.08024874f, -0.05242066f, -0.00250496f, -0.04262709f, -0.04763569f, 
    -0.03360005f, 0.14740992f, 0.21979237f, -0.10624942f, 0.08305968f, 0.03210057f, -0.04970002f, 0.08438554f, 
    0.06087871f, 0.00648841f, -0.03549595f, 0.05538914f, -0.02758922f, -0.19348362f, 0.11566471f, -0.07139964f, 
    -0.10963321f, 0.03784810f, -0.01633608f, -0.06378762f, 0.09427340f, -0.04016661f, 0.05777528f, -0.10567882f, 
    0.15400229f, -0.05788392f, 0.12083320f, 0.06601410f, 0.00461602f, 0.12774682f, 0.05388672f, -0.02470390f, 
    0.03693618f, 0.05885693f, -0.05693625f, -0.02688465f, -0.23072886f, 0.10751043f, -0.04081309f, 0.14757769f, 
    -0.04924895f, 0.01651919f, 0.06967159f, -0.04020912f, 0.04901755f, 0.02254158f, -0.01973238f, -0.02195695f, 
    0.05452968f, -0.00675345f, 0.09594302f, -0.03152535f, 0.02171813f, -0.03936397f, 0.04378438f, 0.00167707f, 
    -0.01798969f, -0.04272012f, 0.00808304f, -0.09816339f, 0.00085351f, -0.17549302f, -0.03136226f, -0.14957622f, 
    -0.21075062f, 0.00099304f, -0.06568566f, 0.01484258f, -0.01184537f, -0.05035784f, -0.06111544f, -0.04755513f, 
    -0.04601149f, -0.17485580f, -0.02937161f, -0.01501927f, -0.06422921f, -0.03055798f, -0.05896744f, 0.00354660f, 
    0.03908072f, -0.13744791f, -0.00428191f, -0.12057439f, 0.06048377f, -0.16475280f, 0.02758544f, 0.14156908f, 
    -0.05077542f, -0.06734487f, -0.01235183f, -0.04064090f, 0.03098006f, 0.04794889f, 0.05443365f, 0.10135164f, 
    0.16605408f, 0.03980443f, -0.03109996f, -0.04312623f, -0.10098524f, 0.11691074f, 0.05598499f, 0.11686562f, 
    -0.02867810f, -0.07476127f, 0.00752210f, 0.04922298f, 0.03722122f, -0.08948489f, 0.08794925f, -0.03245423f, 
    -0.03687155f, -0.03852980f, 0.06234395f, 0.06253802f, -0.05664388f, 0.05816810f, 0.03691899f, -0.02081655f, 
    0.04278528f, -0.08838251f, -0.03876295f, 0.00751683f, -0.02328489f, 0.05939602f, -0.07879860f, -0.06304324f, 
    0.04294107f, -0.01369319f, -0.00642811f, 0.07050293f, 0.15643573f, -0.08133283f, -0.26311079f, -0.10515674f, 
    -0.01401911f, -0.05051036f, -0.07510649f, -0.04401569f, 0.05161555f, 0.07115322f, 0.09529638f, 0.09192595f, 
    -0.16929741f, 0.00606902f, 0.15487511f, 0.10021295f, 0.11267138f, -0.08249293f, 0.02726006f, 0.04896375f, 
    -0.00386440f, 0.01301943f, 0.03243457f, 0.03683459f, -0.11478630f, 0.06452733f, -0.17373087f, 0.24245912f, 
    -0.11133363f, 0.06454375f, 0.05391245f, 0.03221631f, 0.02569677f, 0.04520506f, -0.01278964f, 0.04205339f, 
    -0.12760004f, -0.06047140f, -0.25807083f, 0.08810811f, -0.06638981f, 0.07754604f, -0.06809068f, -0.04103190f, 
    0.00800909f, -0.00345081f, 0.02493871f, 0.00930236f, 0.07592440f, 0.12111571f, 0.00146125f, 0.04809528f, 
    0.05534472f, 0.06159802f, 0.10151458f, 0.05831230f, -0.02067536f, 0.00451186f, -0.01785133f, 0.01448821f, 
    -0.03665005f, 0.06835375f, -0.06411383f, -0.01278421f, 0.11544520f, 0.08722224f, -0.03022580f, 0.09458916f, 
    0.07277012f, -0.02445162f, 0.03405327f, 0.02081463f, -0.14623596f, 0.31712571f, 0.12922826f, 0.08734579f, 
    0.07177211f, 0.05695238f, 0.04257574f, -0.08201425f, -0.05032454f, 0.04809640f, -0.01421697f, 0.08422679f, 
    0.14919807f, -0.11304022f, -0.08161233f, 0.04677997f, -0.05043576f, 0.04130747f, -0.03439470f, 0.11824547f, 
    0.08647083f, -0.04199780f, 0.06449464f, 0.02473001f, 0.01052442f, 0.13683654f, 0.17767902f, -0.08631551f, 
    0.09503548f, -0.07767331f, -0.01848236f, 0.08372749f, 0.04558014f, 0.04905540f, 0.02393447f, 0.07331795f, 
    0.01115470f, -0.20928432f, 0.05971785f, 0.24890774f, -0.01810499f, 0.05355659f, -0.01499683f, -0.12051717f, 
    0.01662187f, -0.01012501f, 0.01716290f, 0.04861784f, -0.14866184f, 0.09564209f, 0.17153019f, 0.27023163f, 
    -0.00766926f, 0.03667225f, -0.02921670f, 0.04632498f, -0.03425686f, -0.01106253f, 0.13978341f, -0.12239969f, 
    0.19399980f, 0.08836148f, -0.12543891f, -0.21569303f, 0.16314693f, 0.00454338f, 0.02632630f, 0.00026125f, 
    0.10701639f, -0.04334719f, 0.00919686f, 0.03410787f, -0.13715471f, 0.06354190f, 0.28324673f, -0.01557481f, 
    -0.03122456f, 0.02269550f, -0.04951828f, 0.06399168f, -0.00128985f, -0.09837112f, -0.03906500f, 0.02812090f, 
    0.14282578f, 0.01191961f, 0.07229189f, -0.03578805f, 0.26587892f, 0.11390851f, 0.07666536f, 0.17338169f, 
    0.01345770f, 0.06125235f, -0.01170884f, 0.10820522f, -0.28191170f, 0.24872728f, -0.06981947f, -0.00386898f, 
    0.07630552f, -0.03939778f, -0.09209302f, 0.02618357f, 0.03904173f, 0.02939232f, 0.03919447f, -0.09706430f, 
    0.12752603f, 0.06567309f, 0.15169455f, -0.19171593f, 0.05289345f, -0.03919070f, -0.04227220f, -0.00914621f, 
    0.03875626f, -0.04156847f, 0.04459538f, -0.00797203f, 0.00655333f, 0.12146848f, -0.17443855f, 0.17355011f, 
    0.02424430f, 0.08976619f, -0.01264582f, -0.08808037f, 0.01995721f, 0.04118642f, 0.01851885f, -0.11207512f, 
    0.12989147f, 0.02045069f, 0.15257215f, 0.02461681f, 0.08242247f, -0.03148767f, 0.00125706f, -0.03845842f, 
    0.02025172f, -0.03208492f, 0.04020747f, -0.01342670f, 0.06108113f, 0.13980900f, -0.00064245f, -0.20225413f, 
    0.04823985f, 0.05649664f, 0.01009711f, -0.07696601f, 0.06789328f, 0.03081440f, -0.08569170f, -0.04007373f, 
    0.39793608f, -0.12245172f, 0.04190503f, 0.14664325f, -0.05529651f, 0.10833944f, 0.04097615f, 0.05903072f, 
    -0.09810329f, -0.14229301f, -0.05850188f, -0.05764812f, 0.05592127f, -0.03520242f, 0.01967178f, 0.12556599f, 
    -0.04010608f, -0.00116751f, -0.00967859f, 0.01532588f, -0.00624676f, -0.01999200f, 0.01205422f, 0.10984670f, 
    -0.13573506f, 0.05411749f, 0.16338666f, -0.22172540f, 0.00145798f, 0.00000930f, -0.01315806f, -0.08778398f, 
    -0.02268379f, -0.04143923f, -0.06984328f, -0.03269595f, 0.02833095f, 0.04129057f, 0.13308190f, 0.09977847f, 
    -0.04369801f, -0.03771014f, 0.07001448f, 0.06728974f, 0.04317945f, 0.09866164f, 0.01006045f, -0.00109100f, 
    0.14764638f, 0.28523681f, -0.15637162f, 0.01776593f, 0.03500806f, 0.00905990f, 0.17274247f, -0.02609048f, 
    0.00866765f, -0.10102285f, -0.03178790f, -0.11949614f, 0.15361600f, -0.10093140f, 0.00436106f, 0.30571881f, 
    -0.01047498f, -0.05553536f, 0.05713715f, -0.01227777f, 0.11753846f, 0.00246275f, 0.10683394f, 0.03293496f, 
    0.03884539f, 0.14979260f, 0.09608031f, 0.11591227f, -0.11858547f, 0.08176292f, -0.06480543f, 0.02947751f, 
    -0.03334892f, 0.03005563f, -0.02749559f, 0.09037487f, -0.06484695f, -0.02748734f, 0.08413973f, 0.07987443f, 
    -0.03180397f, 0.02740769f, 0.09464183f, -0.00970967f, 0.02114978f, -0.01795956f, 0.01200450f, 0.11497617f, 
    -0.10898372f, 0.00728098f, 0.00377181f, 0.15745203f, -0.03505890f, -0.02152056f, 0.11041115f, 0.04730980f, 
    -0.05195563f, 0.04355196f, 0.00639680f, 0.08643898f, 0.22654752f, 0.07509067f, 0.15322062f, 0.07571843f, 
    -0.06262665f, -0.03483729f, 0.08504386f, 0.01665818f, -0.04063755f, -0.01728574f, 0.02320342f, 0.03203144f, 
    -0.24116039f, -0.04657720f, 0.00367927f, 0.15091825f, -0.00325462f, -0.03785740f, 0.04087785f, 0.05696379f, 
    -0.10995562f, 0.02993579f, 0.00244420f, 0.05268516f, -0.10536230f, -0.04065503f, -0.07697543f, -0.10057629f, 
    0.05110388f, -0.01044990f, -0.01240320f, -0.02525775f, -0.02050663f, 0.01742663f, 0.03855520f, -0.01577643f, 
    -0.07097067f, -0.01290872f, -0.06232594f, 0.16654882f, 0.07420629f, 0.09200905f, -0.07394740f, -0.03785733f, 
    0.17871399f, -0.06560868f, -0.00928265f, 0.06808037f, 0.21506427f, -0.02392197f, 0.18686812f, -0.06413663f, 
    -0.11365377f, -0.04548851f, -0.01837164f, 0.00892663f, -0.01158280f, -0.01462368f, 0.03900793f, 0.06035140f, 
    -0.09235370f, -0.13877714f, -0.08185322f, 0.09646758f, -0.14350739f, 0.01081281f, -0.05498970f, -0.07406043f, 
    -0.08942514f, -0.03979888f, 0.03454838f, -0.03795320f, -0.08510344f, -0.12764913f, 0.12175255f, -0.00071552f, 
    -0.11525058f, -0.03517349f, 0.03995895f, 0.01546094f, 0.03970673f, 0.05187266f, -0.07122722f, 0.03524274f, 
    -0.01828571f, -0.24085772f, -0.19745176f, 0.07554023f, -0.13401736f, -0.00816628f, -0.01504447f, 0.01987392f, 
    -0.01985830f, -0.04289450f, 0.04386512f, -0.08636594f, -0.03801474f, 0.05108816f, 0.06549824f, 0.05403426f, 
    0.13158551f, 0.02541819f, -0.02114931f, 0.16397624f, 0.02302003f, 0.07845864f, 0.02538870f, -0.00104964f, 
    -0.33000594f, 0.39450565f, -0.15095669f, 0.02704037f, 0.09849403f, 0.00925651f, 0.03647380f, -0.05771532f, 
    -0.03531322f, 0.06206791f, 0.01609694f, 0.02653623f, -0.12877198f, 0.01176100f, 0.13343547f, -0.10506057f, 
    -0.04086018f, 0.03247452f, -0.02130956f, -0.02285421f, 0.06172514f, 0.02774818f, 0.00853651f, 0.05953163f, 
    0.00485255f, -0.01723904f, -0.00980112f, -0.04167918f, 0.01424427f, 0.00842133f, -0.03711143f, 0.02041442f, 
    0.01274763f, -0.01547038f, -0.01364595f, 0.01048480f, -0.00905431f, -0.01303005f, 0.03765621f, -0.00639107f, 
    -0.00261041f, 0.02916538f, -0.01688171f, 0.00268834f, 0.03988721f, 0.00971959f, 0.01641420f, -0.00730211f, 
    -0.00047902f, 0.02140154f, 0.01162584f, -0.02366739f, -0.00760986f, -0.01520491f, -0.02760577f, -0.00119533f, 
    0.03891056f, 0.02526121f, 0.00287174f, 0.00304514f, -0.00303324f, -0.04142294f, 0.01082328f, -0.00686571f, 
    -0.00486467f, 0.00808614f, -0.02655271f, -0.03572064f, 0.01650896f, 0.03698429f, 0.00911660f, 0.00448405f, 
    0.02109798f, 0.02337295f, 0.02510451f, 0.01223575f, 0.00932827f, 0.02668615f, -0.00303877f, -0.03407162f, 
    0.02861018f, -0.01382289f, -0.02128714f, 0.00392904f, 0.01727543f, -0.01643344f, 0.01934120f, -0.00899733f, 
    0.00442828f, -0.02878468f, -0.02886763f, -0.02894041f, 0.01813775f, -0.00139254f, 0.01470636f, 0.02253870f, 
    -0.01628075f, -0.04499431f, -0.00954819f, 0.01822813f, -0.03679545f, -0.01120675f, -0.03262298f, -0.02338405f, 
    0.00152457f, -0.00077844f, -0.03669850f, -0.03599531f, 0.00894018f, -0.02721368f, -0.01712751f, 0.02246873f, 
    -0.01320429f, 0.02701865f, 0.02657668f, -0.00612092f, -0.01725237f, -0.00351273f, 0.00570074f, 0.00707507f, 
    0.02893419f, 0.01072457f, -0.02677250f, 0.02264827f, -0.00661144f, -0.01665471f, -0.02924146f, -0.03711814f, 
    0.03375775f, -0.03171121f, -0.03964654f, 0.02841472f, -0.02946430f, 0.00724810f, -0.01838571f, 0.00820773f, 
    -0.01001475f, 0.03216529f, 0.00944659f, 0.02809906f, -0.04562529f, -0.01893873f, -0.01170801f, -0.01844529f, 
    -0.00837437f, 0.02510180f, -0.03034704f, -0.03431872f, 0.02461963f, -0.03475426f, -0.02997245f, 0.03161482f, 
    0.00821737f, -0.01538780f, -0.00717197f, -0.03667851f, -0.01893003f, -0.00168908f, -0.02677287f, -0.03578153f, 
    0.01054908f, 0.01049469f, -0.01902442f, -0.01137165f, 0.01571487f, 0.00253896f, 0.00859992f, 0.00656826f, 
    -0.02886204f, 0.01566674f, -0.01189623f, -0.03444252f, 0.02880949f, -0.02120165f, 0.01232567f, -0.01349452f, 
    -0.03923322f, 0.01875718f, 0.02919062f, -0.04249490f, -0.02214334f, -0.00879216f, -0.02683555f, 0.02750861f, 
    -0.02181503f, 0.01663775f, -0.02827820f, -0.01156672f, -0.02235652f, 0.02760133f, -0.03007725f, -0.00398458f, 
    -0.01375005f, -0.01005249f, -0.02519777f, 0.00961148f, 0.02103312f, -0.02967445f, -0.02971718f, -0.02710918f, 
    0.01171540f, -0.03399833f, -0.00481622f, -0.03213996f, -0.03766211f, 0.01245867f, 0.01154502f, -0.03241981f, 
    -0.01765100f, -0.02321272f, 0.02700958f, 0.02516376f, -0.00005975f, -0.00738553f, 0.00164580f, -0.02968272f, 
    -0.02060995f, -0.00679255f, -0.00327803f, -0.01874652f, 0.00417677f, 0.00412715f, -0.01405098f, -0.01534901f, 
    -0.02723815f, 0.01304699f, 0.00409289f, -0.00915218f, 0.02396046f, -0.01433871f, 0.01262593f, 0.00248982f, 
    0.02287607f, 0.01208917f, 0.02485511f, 0.01218691f, -0.02581185f, -0.01821477f, -0.00607134f, -0.02695633f, 
    0.02807003f, -0.01508188f, 0.00988937f, 0.02034250f, -0.03023883f, -0.02433098f, 0.00220627f, -0.02802098f, 
    -0.01222473f, 0.00985138f, -0.00748918f, -0.03597854f, -0.01007008f, -0.00631769f, -0.00383975f, -0.02310116f, 
    0.02407389f, 0.01482571f, -0.03774871f, 0.02877600f, 0.00920116f, 0.02150941f, -0.03154302f, 0.00442161f, 
    0.02866452f, -0.03435882f, -0.03260154f, 0.02257096f, -0.03130479f, 0.01847271f, -0.03810184f, -0.00551386f, 
    0.01679390f, 0.00540487f, 0.02482010f, -0.01893424f, 0.03137962f, 0.02349095f, 0.00749994f, -0.00710981f, 
    -0.01588730f, -0.03597523f, -0.02391216f, 0.01440580f, -0.00120412f, -0.01945342f, 0.00585413f, -0.02696837f, 
    -0.00698131f, 0.04052213f, -0.00620060f, 0.02472593f, -0.04208215f, 0.00656459f, -0.00334057f, -0.03265185f, 
    0.00157106f, -0.02804843f, -0.02674560f, 0.02713772f, 0.00916178f, -0.02311702f, -0.02365162f, 0.02065731f, 
    -0.00756074f, -0.02389911f, 0.01361655f, -0.00739687f, -0.01605703f, 0.00016040f, -0.03167492f, -0.00203735f, 
    0.02417816f, -0.01043277f, -0.02826128f, -0.04132978f, 0.01883656f, 0.00262405f, 0.00874705f, -0.03657860f, 
    -0.03223255f, 0.00016755f, 0.03032807f, -0.01939056f, 0.02568363f, -0.01279017f, -0.01088733f, -0.01025134f, 
    0.01902194f, -0.03761154f, 0.01025196f, -0.00426474f, 0.02469524f, -0.02274340f, 0.02059716f, -0.03806178f, 
    -0.01465971f, -0.03081720f, 0.04311812f, -0.01848765f, 0.01356274f, -0.01533388f, 0.01739770f, 0.02928088f, 
    0.02628980f, 0.01786744f, -0.02157478f, -0.03175046f, 0.00841315f, -0.00804612f, -0.00447282f, 0.02017822f, 
    0.00957283f, -0.02007205f, 0.00507049f, -0.00844256f, 0.01862099f, 0.01801375f, -0.00408512f, -0.02359229f, 
    -0.03109670f, -0.04011011f, -0.00369883f, 0.02018610f, 0.00247003f, -0.01197966f, -0.01353599f, -0.02877374f, 
    -0.03094748f, 0.02604034f, -0.00519139f, -0.01365083f, -0.02308395f, -0.00169736f, -0.02372652f, -0.04480808f, 
    -0.01897117f, 0.00659022f, -0.00410257f, 0.01663332f, -0.01477888f, -0.00654013f, 0.00152830f, 0.02849216f, 
    0.00225564f, 0.02259065f, -0.03396168f, 0.02545832f, 0.00788885f, -0.02534243f, -0.02329469f, -0.03575739f, 
    -0.03185169f, 0.02461747f, 0.02292601f, 0.02564181f, 0.00506921f, 0.02092292f, -0.00330892f, 0.01722989f, 
    -0.02557628f, 0.00771743f, 0.00934814f, -0.02650055f, 0.00212642f, 0.03342601f, 0.00407363f, -0.00195223f, 
    -0.04089608f, -0.02384473f, -0.00306100f, -0.00147569f, -0.00926284f, 0.00115920f, -0.00801556f, -0.01601838f, 
    -0.00540600f, -0.02535300f, 0.00293652f, -0.00464944f, 0.01550096f, -0.00024522f, -0.02300893f, 0.01587544f, 
    0.02853301f, 0.02388317f, 0.02967253f, 0.02317716f, -0.02516618f, 0.02687771f, 0.00238990f, 0.02170215f, 
    -0.02387643f, 0.02155009f, -0.01804132f, 0.02314261f, -0.03084775f, -0.01843569f, 0.02598779f, -0.01692098f, 
    -0.01659774f, -0.03191987f, 0.02727534f, 0.01134412f, 0.02486113f, 0.04400248f, 0.03714412f, 0.01788883f, 
    -0.00671094f, -0.00611411f, -0.01651341f, 0.01531238f, -0.01379891f, 0.03542433f, -0.03274032f, -0.03112923f, 
    0.01592066f, -0.02349824f, 0.01504450f, -0.00403666f, 0.02325301f, 0.02547078f, -0.01111420f, -0.00860744f, 
    0.01812681f, 0.01000486f, -0.00483782f, -0.03176790f, -0.01296767f, 0.02977540f, 0.02369080f, 0.00789216f, 
    0.02190879f, -0.00851079f, -0.01463563f, 0.01175051f, -0.02064521f, -0.00510680f, 0.00611506f, 0.00227341f, 
    -0.00155535f, 0.02998709f, -0.01586618f, 0.01331695f, 0.03169657f, -0.01103836f, -0.00091124f, -0.03773540f, 
    -0.03029010f, -0.03579403f, 0.02891058f, -0.03496625f, -0.01722464f, -0.00277743f, -0.03040766f, 0.01438439f, 
    0.01461568f, 0.02611788f, -0.01353368f, 0.00270535f, -0.02098283f, -0.02365538f, 0.02180727f, 0.01360835f, 
    -0.02228992f, -0.01280351f, -0.03558283f, 0.00847429f, -0.01704644f, -0.03514714f, -0.04067361f, 0.01887955f, 
    -0.02863995f, -0.01798996f, -0.03066250f, -0.03126325f, -0.01536412f, 0.00393520f, -0.02301802f, 0.01351592f, 
    -0.01367356f, 0.01484250f, -0.02926487f, -0.00836798f, -0.03388756f, -0.00293082f, 0.02264189f, -0.01627957f, 
    0.01039986f, 0.02262128f, -0.01678139f, -0.04186734f, 0.02221740f, 0.00462746f, -0.01638152f, 0.00999015f, 
    0.01395266f, -0.01306249f, 0.00224045f, 0.00417399f, -0.01265685f, -0.00064580f, 0.01910302f, -0.00816757f, 
    -0.02949970f, -0.03943716f, 0.02541639f, 0.03420268f, 0.01050764f, 0.03689742f, 0.01391900f, 0.02413541f, 
    0.02087468f, -0.01918735f, 0.04238116f, -0.01848654f, -0.00711089f, -0.01751547f, 0.01788480f, -0.01413576f, 
    -0.02636326f, -0.03136047f, -0.02555494f, 0.01764414f, 0.02283883f, -0.02304884f, -0.02891922f, -0.01547258f, 
    0.02999275f, 0.00726532f, -0.03211785f, -0.00206778f, 0.03293137f, -0.01446381f, 0.00461812f, 0.01785896f, 
    0.01101294f, 0.00805165f, -0.03380491f, -0.03664472f, -0.00231136f, -0.03001673f, 0.01690206f, -0.03740620f, 
    0.01985973f, 0.01846569f, 0.03016911f, 0.00588466f, 0.04379347f, -0.00904318f, 0.03323821f, 0.02445849f, 
    -0.02979562f, -0.00118910f, 0.02854542f, -0.00055103f, -0.00945469f, 0.02391268f, 0.01947027f, -0.02739453f, 
    -0.00760009f, 0.02932888f, 0.03409790f, 0.01624025f, -0.02781323f, -0.03507360f, 0.00867729f, 0.02545256f, 
    0.01350109f, -0.00533207f, -0.00203738f, -0.01095268f, 0.00111687f, 0.01893484f, 0.01490392f, -0.02289862f, 
    -0.00437973f, -0.00439431f, -0.00107368f, 0.02444110f, -0.03069240f, 0.02171804f, -0.00311734f, -0.04390770f, 
    -0.03057448f, 0.00887923f, 0.01462335f, 0.00902107f, 0.01446575f, -0.01794523f, 0.02286323f, 0.03443294f, 
    -0.00901596f, -0.00924103f, 0.00468468f, 0.01271260f, -0.02339270f, 0.01291700f, 0.00951482f, -0.01795474f, 
    0.00196231f, -0.01753584f, -0.00695816f, -0.03286010f, -0.00766334f, 0.00235840f, -0.00604014f, 0.00405829f, 
    0.00268520f, -0.00939733f, 0.01877564f, -0.02969055f, 0.02521417f, 0.01395515f, -0.00465329f, -0.01138646f, 
    0.01025381f, 0.00834592f, 0.01004329f, 0.00515201f, 0.00347013f, 0.02461384f, 0.00013441f, 0.02352825f, 
    0.02239648f, -0.02058750f, -0.00892352f, -0.03895953f, -0.03936072f, 0.03225525f, -0.01847849f, 0.03069179f, 
    -0.03681464f, 0.03280675f, 0.00675700f, 0.00778166f, 0.01300715f, -0.00060862f, 0.03326523f, 0.00442911f, 
    -0.00220383f, -0.04307093f, -0.00630958f, -0.03009012f, 0.01487995f, 0.01493622f, -0.04258227f, -0.02595627f, 
    0.01158826f, 0.02644351f, 0.00906587f, 0.01532876f, 0.02304075f, -0.03418218f, -0.00807342f, 0.01047507f, 
    -0.04136677f, 0.01987295f, 0.01836550f, 0.00700609f, 0.00733854f, -0.04321715f, -0.03892797f, 0.01059780f, 
    -0.04150976f, 0.01014006f, 0.00722402f, -0.01061106f, 0.01205207f, -0.01258496f, -0.01277484f, -0.02805792f, 
    0.00561350f, 0.02871053f, -0.02580571f, 0.00693628f, -0.01690275f, 0.02380468f, 0.02103518f, 0.00182740f, 
    0.00831524f, -0.04154041f, -0.02065435f, 0.01040137f, -0.03997366f, -0.02686430f, -0.02082318f, -0.02247009f, 
    0.01352215f, -0.00839589f, -0.02776204f, 0.00318197f, 0.01237146f, 0.01165197f, 0.01775421f, -0.00526541f, 
    0.00689190f, -0.00712429f, 0.02174648f, -0.00023794f, 0.00190836f, 0.01586756f, 0.00116198f, -0.02732152f, 
    0.02300369f, -0.03458393f, -0.02807588f, -0.01384478f, 0.01691358f, -0.02902423f, -0.03074774f, -0.03542509f, 
    -0.01648203f, -0.03491925f, -0.01463218f, 0.00927642f, -0.01842243f, 0.00099455f, 0.00515307f, 0.02888167f, 
    -0.01576110f, 0.01868067f, -0.02791110f, 0.02431929f, -0.03938795f, -0.01394053f, 0.00608694f, -0.01680862f, 
    0.00956476f, 0.01134624f, 0.02138936f, 0.01167700f, -0.00165928f, -0.00095452f, -0.00751171f, -0.02052579f, 
    0.00301941f, 0.00018878f, 0.00511038f, -0.01863604f, 0.00157868f, -0.02375900f, 0.01218323f, -0.00899859f, 
    0.03052710f, -0.00835807f, -0.00564657f, 0.02354060f, 0.01160771f, 0.02397155f, -0.00198061f, -0.01584693f, 
    -0.02893408f, -0.00846928f, -0.01025493f, 0.01444242f, -0.00817980f, 0.01600605f, 0.01737628f, -0.02998073f, 
    -0.03754897f, 0.00187204f, 0.02084153f, 0.02264092f, -0.00950917f, -0.02124113f, 0.00158365f, -0.01569645f, 
    0.02570977f, -0.00931529f, 0.01542002f, -0.01584380f, 0.01143496f, -0.03781439f, 0.02844300f, 0.01049150f, 
    -0.00570569f, 0.02484414f, -0.01159918f, 0.01535251f, -0.03064002f, 0.01309392f, -0.00343069f, -0.00726608f, 
    0.00890952f, 0.02355496f, 0.02159530f, 0.02315045f, -0.01529500f, 0.00865225f, -0.03703896f, 0.02348538f, 
    -0.00229078f, -0.00765026f, -0.01444058f, -0.01121483f, -0.02077189f, -0.02324259f, 0.00622487f, -0.01335790f, 
    0.01330617f, -0.01447565f, -0.03675810f, -0.01387920f, -0.02011377f, -0.01430130f, 0.00265967f, -0.01388038f, 
    0.00028510f, 0.01855785f, -0.00663906f, 0.02345037f, -0.01795793f, -0.02279591f, -0.00041550f, 0.00067805f, 
    -0.03439534f, 0.00234017f, -0.01099418f, 0.02659359f, 0.00628485f, 0.02589070f, 0.01123474f, -0.02541985f, 
    0.02566542f, 0.03599788f, 0.02244155f, -0.02530623f, -0.01681003f, -0.03799215f, 0.01420028f, 0.00491780f, 
    -0.00834239f, -0.02016751f, -0.00366407f, -0.01144635f, 0.01413923f, -0.03848896f, 0.01430928f, 0.01304921f, 
    0.01461448f, -0.00231115f, 0.00345931f, -0.02493930f, 0.02504775f, -0.04212265f, 0.00429973f, -0.01937891f, 
    -0.01169391f, -0.00082752f, 0.01132775f, 0.00596548f, -0.02347027f, -0.02751502f, 0.00585695f, -0.00841259f, 
    -0.00980227f, 0.00747267f, 0.01324863f, 0.02152791f, -0.02552084f, 0.02385569f, -0.03484471f, -0.03713656f, 
    -0.01449070f, -0.02259061f, 0.02617656f, 0.00762096f, 0.00801354f, 0.00851890f, 0.00302230f, -0.04056157f, 
    0.02343145f, -0.04113646f, -0.01210521f, 0.00571023f, -0.01329410f, -0.00495902f, -0.00629787f, -0.00247145f, 
    -0.03936575f, 0.00863490f, -0.00506324f, -0.01393638f, -0.00220788f, 0.01794478f, -0.03526289f, 0.02741202f, 
    -0.01591037f, -0.04007742f, -0.02892407f, 0.02028978f, -0.00290211f, -0.01132559f, -0.03185342f, 0.02607962f, 
    -0.01981163f, 0.00253435f, -0.01264168f, -0.02149912f, -0.03068431f, -0.02763786f, -0.01917801f, 0.00158715f, 
    -0.02528882f, -0.02574979f, 0.00542058f, -0.01214660f, 0.02299950f, 0.02220208f, 0.01769416f, -0.02557238f, 
    0.01175998f, 0.00966670f, -0.01283661f, -0.00400503f, -0.01610982f, -0.00289987f, -0.01533359f, -0.02604781f, 
    -0.01989914f, 0.01762813f, -0.01578991f, -0.01937855f, 0.01376465f, 0.02182763f, -0.00038593f, 0.01463475f, 
    -0.02459812f, 0.02439882f, 0.00010694f, 0.00137111f, -0.00045091f, -0.03607966f, -0.00092711f, 0.00358674f, 
    -0.03992237f, -0.00672113f, 0.02384396f, 0.00097961f, 0.00845405f, -0.02666440f, -0.01259985f, 0.01288943f, 
    0.01858260f, -0.03762008f, -0.04181172f, -0.02331977f, -0.04014558f, -0.02838818f, -0.01867413f, -0.01840511f, 
    0.02661134f, 0.02634003f, -0.04036926f, -0.00694484f, -0.00542490f, -0.00467215f, 0.00409714f, -0.03843680f, 
    -0.04209539f, 0.00522680f, -0.03113778f, 0.00850283f, -0.00765824f, -0.02843901f, -0.02005806f, 0.01584580f, 
    -0.00720712f, -0.02284609f, -0.00765817f, 0.00458334f, -0.02896952f, -0.04084615f, -0.00891033f, -0.01785100f, 
    -0.00620210f, 0.02309459f, 0.02826305f, -0.01161584f, -0.01216934f, 0.02016231f, -0.02002068f, 0.00346784f, 
    0.02466025f, -0.01753203f, -0.00058955f, -0.04278584f, 0.00833598f, -0.01207187f, 0.00317651f, -0.03062696f, 
    -0.02403970f, -0.01040700f, -0.02478765f, 0.01304105f, -0.02877127f, -0.03229529f, 0.00448260f, -0.00423229f, 
    -0.00110183f, -0.03954260f, 0.02290123f, 0.01243291f, -0.01509470f, 0.00341585f, -0.01140869f, -0.03507496f, 
    -0.02496713f, -0.04033364f, 0.00608418f, -0.00756387f, 0.00762923f, 0.01216188f, -0.01531118f, 0.00589817f, 
    0.01647247f, -0.03552468f, -0.03264124f, -0.00192093f, 0.00513460f, -0.03147114f, 0.01826864f, -0.01127215f, 
    -0.03110457f, -0.01884087f, -0.01787156f, -0.02324547f, -0.04264713f, -0.04112609f, -0.03786720f, -0.00381279f, 
    0.00888159f, -0.00039629f, -0.01060987f, -0.01708043f, -0.03654617f, -0.03222155f, 0.00517771f, -0.00519960f, 
    -0.01130843f, -0.04087202f, -0.03099238f, 0.00026138f, 0.00478971f, -0.02825067f, 0.02871162f, 0.01691239f, 
    -0.04258806f, 0.02760153f, 0.00372641f, 0.01741705f, -0.02307652f, -0.00582677f, -0.00766133f, -0.00734705f, 
    -0.00679750f, 0.02174080f, 0.01765591f, 0.02036628f, -0.01735549f, -0.00932997f, 0.02819517f, 0.00261221f, 
    0.01837506f, -0.00505773f, -0.02014733f, 0.00651556f, 0.00049428f, 0.01743381f, -0.01089086f, 0.02590331f, 
    -0.03791004f, -0.02567682f, 0.02071854f, 0.00543531f, 0.01240859f, 0.02816585f, 0.00332116f, -0.01723010f, 
    -0.02088547f, 0.00827540f, -0.04384088f, -0.03563486f, 0.02146102f, -0.03594537f, -0.02055525f, -0.01825396f, 
    0.01674359f, 0.02208079f, -0.04121476f, 0.02557606f, 0.02155670f, -0.02051561f, -0.03035831f, 0.02075700f, 
    -0.02186363f, -0.02050826f, 0.02504643f, 0.02355691f, 0.00642346f, 0.00759280f, -0.00135820f, -0.02357263f, 
    -0.02842241f, -0.00804236f, -0.02327404f, -0.02750246f, -0.00190155f, -0.00725656f, -0.00591628f, 0.01064421f, 
    0.00104351f, -0.00051662f, -0.03005952f, 0.00917733f, -0.01324217f, -0.01179154f, -0.04121336f, -0.02193711f, 
    -0.01206613f, -0.02343357f, 0.01119512f, -0.03208699f, 0.03218544f, 0.02445639f, 0.01473285f, -0.00696208f, 
    0.00250993f, 0.01324270f, -0.03288390f, 0.02405402f, 0.00065795f, -0.00588869f, -0.02557231f, -0.00203720f, 
    0.00910295f, -0.01289023f, 0.02792847f, 0.00365088f, 0.02711333f, -0.01230135f, -0.03877996f, -0.03341681f, 
    -0.01270982f, 0.00484365f, -0.03763310f, 0.01119835f, -0.00782988f, 0.02644075f, 0.00007875f, -0.02339524f, 
    -0.00467332f, -0.02278990f, -0.00057288f, 0.02130053f, 0.02598932f, -0.03455736f, 0.00994587f, -0.01969150f, 
    -0.03935894f, 0.01858068f, 0.01966638f, 0.00184811f, 0.02622605f, -0.01670732f, -0.02642014f, -0.02130509f, 
    0.01576134f, -0.01870494f, -0.00408859f, -0.00046143f, -0.00818822f, 0.00192556f, 0.01120554f, -0.01499829f, 
    -0.03765488f, -0.01430990f, -0.03925424f, 0.00543579f, -0.00021823f, -0.03960894f, 0.00896770f, -0.03491420f, 
    -0.00568696f, -0.00903326f, 0.01887057f, 0.01867499f, -0.03110317f, 0.02264589f, -0.00142212f, -0.01169399f, 
    -0.02654184f, -0.01726337f, 0.02420191f, 0.01428006f, -0.00201773f, 0.00798577f, -0.02360888f, 0.01902494f, 
    0.02219972f, -0.01788438f, -0.02605836f, 0.01387893f, -0.03399604f, -0.02642126f, -0.01752544f, 0.00108129f, 
    -0.00244026f, -0.02617093f, 0.00433963f, -0.01096401f, -0.00250802f, -0.00427814f, 0.02254353f, -0.01228391f, 
    -0.02035994f, -0.03662004f, 0.01077455f, -0.02309995f, -0.03360835f, 0.00427467f, 0.02654643f, 0.01930420f, 
    0.02054064f, 0.02003474f, -0.00513612f, 0.00956486f, -0.03006564f, -0.04081050f, 0.01861397f, 0.01112298f, 
    0.01582631f, 0.02784636f, -0.03491009f, 0.01364309f, 0.00094401f, -0.02155856f, -0.02856355f, -0.03184723f, 
    0.02062859f, 0.01017564f, -0.02936468f, -0.03145670f, -0.04145010f, -0.00100986f, 0.00328718f, -0.00084003f, 
    0.00124077f, -0.02906138f, 0.01475439f, -0.01157686f, 0.01634672f, -0.02753834f, -0.01680004f, -0.01389762f, 
    0.01119183f, 0.01610268f, 0.00776485f, -0.02247667f, -0.02307567f, -0.00029348f, 0.02784482f, -0.00673253f, 
    -0.04013010f, -0.02992959f, -0.00683210f, -0.00325962f, 0.00138534f, 0.02257701f, 0.02368781f, 0.02178771f, 
    0.00767467f, -0.03783710f, -0.01771615f, 0.00353000f, 0.01139601f, -0.02480463f, 0.00891106f, -0.02461079f, 
    0.01669194f, -0.03521727f, -0.04303557f, 0.02702540f, -0.04018813f, 0.02852676f, -0.04252128f, -0.03209344f, 
    0.02812425f, -0.00315519f, 0.01446869f, -0.03527867f, 0.01785707f, -0.04107636f, -0.03502958f, 0.00033482f, 
    -0.03676728f, -0.00915103f, 0.02190161f, -0.00198791f, -0.02035086f, -0.00677334f, 0.02820058f, 0.01058502f, 
    -0.00939722f, -0.02403207f, -0.02626880f, 0.02572439f, -0.00137545f, -0.02002056f, -0.02146658f, -0.03127509f, 
    -0.01708447f, -0.02662550f, -0.04160064f, 0.01403937f, -0.00277933f, -0.00403884f, 0.01652303f, 0.00817883f, 
    -0.03450966f, 0.01767285f, -0.00526082f, 0.01733899f, -0.01977640f, 0.00976537f, 0.02146685f, 0.00367243f, 
    -0.01033100f, -0.02967111f, -0.03512412f, 0.01263618f, -0.04047447f, -0.01893200f, -0.01131789f, 0.01333966f, 
    -0.01260437f, 0.01728628f, -0.03185984f, -0.02381352f, 0.01180706f, 0.02264979f, 0.01667037f, -0.03001354f, 
    0.01587636f, -0.02648771f, -0.02885650f, -0.03120861f, 0.02519738f, -0.00125585f, -0.01018969f, -0.00099536f, 
    -0.00717458f, -0.02267255f, -0.01338669f, -0.04222596f, 0.01629132f, 0.02418563f, -0.02634981f, 0.00861134f, 
    0.00140764f, -0.02416101f, -0.00082094f, 0.00049371f, 0.01292537f, -0.02493299f, 0.02795786f, -0.04220296f, 
    -0.02395794f, 0.00875446f, 0.02707546f, -0.01445994f, 0.00024641f, -0.02103224f, 0.02751969f, -0.03708693f, 
    -0.03047876f, 0.02489449f, 0.00288174f, -0.01691314f, -0.03286299f, -0.04235940f, -0.01901987f, -0.02933409f, 
    -0.03495501f, -0.01809630f, -0.02815591f, 0.00706653f, -0.00805974f, 0.01184673f, 0.01202170f, -0.04221458f, 
    0.00149035f, -0.03452552f, -0.03488255f, 0.02371074f, -0.02038423f, 0.00482031f, 0.00834300f, -0.01683975f, 
    -0.03075710f, -0.00416361f, -0.02794078f, -0.03189274f, 0.02497918f, -0.03019202f, 0.00258982f, 0.00368056f, 
    -0.02337837f, -0.02997669f, -0.02283911f, 0.02206015f, -0.00115719f, -0.01004206f, -0.00702900f, -0.03649988f, 
    0.01258708f, -0.00355996f, -0.01015698f, -0.02368852f, -0.01148899f, 0.02325746f, 0.01326053f, 0.00360375f, 
    0.01796677f, 0.00097831f, 0.02488835f, 0.00526148f, -0.01711822f, 0.02507739f, -0.00353441f, -0.02216368f, 
    -0.00880812f, -0.01360485f, 0.00845646f, -0.03490330f, -0.00608398f, -0.03821551f, 0.01992933f, -0.02895145f, 
    -0.00413812f, -0.03429813f, -0.01075928f, -0.03473692f, -0.01449143f, 0.02691128f, 0.00311890f, 0.02474953f, 
    -0.03225434f, 0.01733406f, -0.00930503f, -0.00044787f, -0.02288079f, 0.02706554f, 0.00936982f, 0.00670681f, 
    -0.01402932f, -0.00738394f, 0.00933506f, 0.02072738f, -0.00558411f, 0.01287272f, -0.00907649f, -0.02836014f, 
    -0.01571054f, -0.01930320f, 0.00234373f, -0.02273562f, -0.02606126f, 0.01926947f, -0.02969684f, -0.00420442f, 
    -0.00202277f, -0.02708570f, 0.00499680f, -0.00889742f, 0.03084957f, -0.01038202f, -0.03582371f, 0.01563786f, 
    -0.02718074f, -0.02512411f, 0.00410309f, 0.00475016f, -0.03444033f, -0.02186999f, -0.00210661f, -0.03482520f, 
    0.01187103f, 0.01372479f, -0.03574132f, -0.01806725f, -0.01279892f, 0.00389776f, -0.01001035f, 0.00291062f, 
    -0.00987314f, -0.03849670f, -0.04234300f, 0.02322017f, -0.02885801f, -0.01229244f, -0.02474492f, -0.03743914f, 
    -0.00462444f, -0.02243112f, 0.01362513f, 0.01501630f, 0.01230680f, -0.03045745f, 0.02203025f, 0.02692073f, 
    -0.00019054f, -0.02450472f, 0.01926960f, 0.02129015f, 0.02115623f, 0.02835454f, 0.02481556f, -0.01084197f, 
    -0.14057410f, 0.20564909f, 0.10674278f, -0.18507634f, 0.10629296f, -0.02387206f, -0.01165822f, 0.00821831f, 
    -0.02194508f, -0.03257053f, -0.08142491f, 0.03975797f, -0.16257198f, 0.03510630f, -0.00509236f, -0.15125191f, 
    0.06404116f, -0.01691192f, 0.09587966f, 0.01255464f, 0.04010433f, -0.08212805f, 0.12391840f, 0.13459079f, 
    0.21167898f, 0.02997535f, -0.05267696f, 0.09755541f, 0.03247356f, 0.08909250f, -0.08356056f, -0.02693598f, 
    -0.00644508f, 0.09852032f, -0.02738226f, 0.08957047f, 0.19761926f, -0.01387723f, 0.07200041f, -0.14949165f, 
    0.01383363f, 0.00410026f, -0.04652964f, -0.09980585f, -0.02715547f, 0.09567983f, 0.12123185f, -0.07109792f, 
    -0.22377323f, 0.04055268f, 0.07907123f, 0.00070078f, 0.03526665f, 0.04002038f, 0.09188566f, -0.03031692f, 
    -0.02583231f, 0.08500703f, -0.05401603f, -0.02892573f, -0.23337725f, 0.00630029f, 0.02040445f, -0.04135145f, 
    -0.02971942f, 0.02979178f, 0.11344946f, -0.04291759f, -0.05994273f, -0.02962589f, 0.01571790f, -0.00962763f, 
    -0.26317394f, 0.05422726f, -0.16959813f, -0.01727126f, -0.07224274f, -0.03774383f, 0.05199116f, -0.09108640f, 
    0.04935744f, -0.04754226f, 0.02044471f, 0.04189399f, -0.11124706f, 0.12065842f, -0.03240294f, 0.06431087f, 
    0.05654031f, 0.03950864f, 0.07011457f, -0.03168879f, -0.03125522f, 0.00958743f, 0.09667117f, -0.03432354f, 
    -0.16015872f, 0.13467623f, -0.08186221f, 0.23190127f, -0.04545081f, 0.08804952f, 0.05203732f, 0.02653915f, 
    0.16291524f, 0.06517116f, 0.01041168f, 0.03052695f, -0.20795465f, 0.01090227f, 0.16938798f, 0.06296036f, 
    -0.00278115f, 0.06378453f, 0.10073743f, 0.10961518f, 0.04885563f, -0.03007054f, -0.03672905f, 0.08192527f, 
    -0.16301058f, 0.13315742f, 0.10744254f, -0.01146552f, -0.03879857f, -0.02995949f, -0.04530716f, 0.06574359f, 
    -0.04060243f, 0.06979281f, 0.04485466f, 0.02915761f, 0.00778671f, 0.12071537f, 0.04735954f, 0.02930056f, 
    -0.00470887f, -0.08602417f, 0.00438148f, 0.03623446f, -0.04365592f, -0.02814069f, 0.03664771f, 0.00811095f, 
    -0.07203123f, -0.13206029f, -0.02243744f, 0.10204319f, -0.06313419f, -0.04338566f, -0.05371331f, -0.10071706f, 
    -0.02574520f, 0.06168836f, 0.08159339f, 0.04869132f, 0.10111290f, -0.03680200f, 0.03880467f, -0.17508040f, 
    0.06031006f, 0.03264361f, 0.02535787f, 0.19352929f, -0.04659509f, 0.08707009f, -0.02019044f, -0.08852895f, 
    -0.11397754f, 0.04111145f, 0.04825863f, 0.04918484f, 0.01195045f, 0.12167612f, 0.00281489f, 0.01381755f, 
    0.01428518f, 0.03981043f, -0.03754034f, 0.11880611f, -0.03493010f, -0.14901258f, -0.01374093f, -0.06668109f, 
    -0.03062746f, -0.09712491f, -0.01288093f, -0.03123167f, 0.06168345f, 0.03258440f, -0.04813747f, -0.01008746f, 
    0.11676630f, 0.03622894f, 0.05159245f, -0.02250448f, -0.02225330f, -0.01681155f, -0.02903524f, 0.15462625f, 
    -0.10479553f, 0.05947267f, 0.07874046f, -0.06246698f, 0.06426848f, -0.17724802f, 0.03247963f, 0.11026108f, 
    0.03551166f, 0.06583874f, -0.01304098f, 0.05606952f, 0.03391540f, 0.07338398f, -0.05958649f, -0.00574119f, 
    -0.14037251f, 0.19698182f, -0.07269903f, 0.14406289f, 0.03738171f, -0.05002296f, 0.05660002f, -0.00789325f, 
    0.03525587f, 0.02457474f, -0.01838589f, -0.03247384f, -0.21557480f, -0.01358780f, 0.01734402f, 0.06070748f, 
    0.03196071f, 0.10465775f, -0.09929356f, -0.01102698f, 0.00898626f, 0.00365336f, 0.02133659f, -0.05074480f, 
    -0.14289494f, -0.08768025f, 0.07401321f, -0.02004083f, 0.00404873f, -0.02903907f, -0.01638042f, -0.02522092f, 
    -0.02269062f, -0.04081970f, -0.00028889f, 0.06845057f, -0.09026780f, 0.08534707f, 0.08413465f, 0.10904177f, 
    0.02047895f, 0.02848598f, 0.09667341f, -0.03623771f, -0.03037446f, -0.05688107f, 0.07759348f, 0.01722355f, 
    0.08141906f, 0.03319257f, 0.14614265f, 0.07161559f, -0.03681609f, -0.01197476f, 0.12698404f, 0.05407153f, 
    0.02166633f, 0.01032076f, 0.07373605f, 0.00880389f, -0.05373733f, 0.32628027f, -0.07832868f, 0.02131294f, 
    -0.05094945f, 0.01432019f, 0.02418667f, -0.02109764f, 0.01192308f, -0.08801763f, 0.03378721f, 0.11412224f, 
    0.10802097f, -0.05909210f, -0.05403842f, -0.13571724f, 0.14985591f, -0.04117121f, -0.04818583f, 0.05711065f, 
    -0.04544237f, -0.03274741f, -0.10493696f, -0.03790346f, -0.22165856f, -0.09576362f, 0.09125836f, -0.01185584f, 
    0.06857859f, 0.07437772f, -0.02919986f, -0.01623376f, 0.05794280f, 0.01347081f, 0.05389130f, 0.08058807f, 
    -0.21136995f, 0.01456357f, 0.05829513f, 0.06941148f, -0.00104441f, -0.04353132f, 0.03127582f, -0.04137186f, 
    -0.00223172f, -0.02427184f, 0.05905491f, 0.03092944f, 0.22150660f, -0.09520053f, 0.12855977f, -0.06637070f, 
    0.08007329f, 0.06060022f, -0.03023243f, -0.02347883f, 0.04580274f, 0.00859823f, -0.02081350f, 0.04707007f, 
    -0.07287985f, -0.19960386f, -0.02966158f, -0.13512687f, 0.02423102f, 0.02699042f, -0.05437745f, -0.00611455f, 
    0.07208634f, -0.02132574f, 0.03040862f, 0.01328114f, -0.25241551f, 0.12587187f, 0.12556857f, 0.12234234f, 
    -0.01460779f, 0.09837220f, 0.03368806f, -0.00346046f, 0.02961626f, 0.07694283f, 0.04480383f, -0.02745405f, 
    -0.26906198f, -0.08594086f, 0.05837689f, -0.00346918f, 0.01253910f, 0.04546234f, 0.02044331f, 0.01830295f, 
    -0.06685280f, -0.04022295f, 0.06318212f, -0.02264257f, 0.13117027f, 0.10589164f, -0.00992188f, -0.07983752f, 
    0.05214310f, -0.05067625f, -0.01769224f, -0.01339641f, 0.01688221f, 0.01110327f, 0.02729234f, 0.04450124f, 
    -0.01770355f, 0.19509253f, -0.05812029f, 0.03917529f, -0.05875166f, 0.10012823f, -0.06220686f, -0.02850159f, 
    0.11060026f, -0.03497679f, 0.02285315f, -0.00355195f, -0.10138186f, -0.03123000f, 0.14626469f, 0.12910061f, 
    0.04074614f, -0.03887138f, 0.02267442f, 0.02910593f, -0.02128635f, 0.02411060f, -0.01612266f, 0.02742403f, 
    -0.19074342f, 0.09220915f, -0.09980316f, 0.01541831f, 0.08475009f, -0.05866398f, -0.01054858f, -0.05124136f, 
    0.15253714f, 0.09370644f, -0.01320783f, -0.06630486f, -0.05653462f, 0.08234972f, 0.24311422f, 0.22198571f, 
    -0.02177243f, -0.00625173f, -0.08806729f, 0.04828612f, 0.04295791f, 0.11918361f, -0.04128318f, 0.06952243f, 
    -0.11595863f, 0.09466790f, 0.03300156f, 0.08715965f, 0.01457815f, 0.04920143f, -0.04950754f, -0.06665000f, 
    -0.02075372f, -0.06663886f, 0.05375489f, -0.02689268f, 0.14843780f, 0.20762724f, 0.05340045f, -0.01543780f, 
    -0.02778993f, 0.01543120f, 0.07898351f, 0.12745492f, -0.00015194f, 0.13968465f, 0.01591958f, 0.01284527f, 
    0.06966837f, 0.08029141f, -0.04685211f, 0.08856694f, 0.02607192f, 0.02485055f, -0.05818898f, 0.00315829f, 
    0.00089244f, -0.02871270f, -0.04011850f, -0.01828382f, -0.10109697f, 0.07415251f, -0.03540830f, -0.12821953f, 
    0.13224968f, -0.05774210f, -0.01383847f, 0.08013939f, 0.12338882f, 0.07746509f, -0.03446067f, -0.00506310f, 
    0.13854913f, 0.15274920f, -0.03178746f, 0.11558993f, 0.02002518f, -0.09028194f, -0.00758438f, -0.03970588f, 
    -0.00914312f, -0.06595972f, 0.04764465f, -0.00119916f, 0.13808985f, 0.02678213f, -0.02598879f, -0.13749053f, 
    0.03599434f, -0.03533233f, 0.09891713f, -0.08949016f, 0.00146954f, 0.03660155f, -0.08186355f, -0.06955986f, 
    0.21210468f, 0.05608523f, -0.05523669f, 0.13915545f, 0.03431631f, 0.02231357f, 0.03903218f, 0.06694716f, 
    -0.04494285f, -0.01394557f, 0.05897783f, -0.03506752f, -0.12181961f, -0.03573991f, 0.04126677f, 0.01591126f, 
    0.04795417f, 0.03635968f, -0.01343306f, -0.06337307f, 0.00617603f, 0.04544937f, 0.00079863f, 0.05392790f, 
    0.13584258f, -0.00317723f, 0.14333355f, 0.08983159f, -0.02527805f, 0.02407213f, -0.03180101f, -0.05766097f, 
    -0.02817510f, -0.00795402f, 0.08663461f, 0.04550516f, 0.01188370f, 0.17849171f, 0.00110761f, 0.10250243f, 
    0.03490690f, -0.01832246f, -0.02633825f, 0.02345886f, 0.05635015f, 0.05742922f, 0.09874552f, 0.11918609f, 
    -0.03410900f, 0.01990174f, 0.05730162f, -0.10055101f, -0.04732347f, -0.06976024f, 0.04210358f, 0.05433924f, 
    -0.07619213f, -0.01503500f, 0.06431842f, 0.07405408f, 0.10451855f, 0.06541841f, 0.11550894f, 0.15299723f, 
    -0.07163943f, 0.04416118f, -0.02997086f, -0.00381333f, 0.05641352f, -0.16010936f, -0.00735610f, 0.03738222f, 
    -0.02576257f, 0.08008592f, 0.37757102f, -0.12376683f, -0.06677073f, 0.04222387f, 0.10134207f, -0.04450784f, 
    0.09826209f, -0.03687945f, 0.02459336f, -0.03406254f, -0.11195954f, 0.17913485f, 0.01537499f, 0.03628762f, 
    -0.04432143f, -0.03242009f, 0.10660063f, -0.05076168f, 0.11540450f, 0.01769059f, -0.03032147f, -0.03279486f, 
    -0.08428027f, 0.08680820f, -0.05275312f, 0.11917781f, -0.02590074f, 0.01639534f, 0.09120540f, 0.07073668f, 
    -0.01243135f, -0.04570908f, 0.03319917f, 0.05944135f, 0.14333147f, -0.05705559f, -0.01652535f, 0.08122531f, 
    0.05348467f, -0.04188621f, 0.04318619f, -0.06301828f, -0.04227260f, -0.06402423f, -0.05881368f, 0.06233077f, 
    -0.05815910f, -0.09344596f, 0.07718612f, 0.13271029f, -0.01435869f, 0.01466373f, 0.03213551f, 0.04283556f, 
    0.03713768f, 0.05929911f, 0.03551804f, 0.07792719f, 0.15306593f, 0.11040397f, 0.01082416f, 0.06736252f, 
    0.01759690f, -0.06322762f, 0.06143783f, -0.03085993f, -0.05625800f, 0.04227405f, 0.00905183f, 0.11414580f, 
    -0.17613283f, 0.20177937f, 0.18627538f, -0.05214891f, 0.01954468f, -0.03527778f, 0.04109011f, -0.00636060f, 
    -0.01107665f, 0.04533514f, 0.02082502f, 0.12210906f, -0.09855454f, -0.11582919f, -0.08540902f, -0.02082342f, 
    0.01248083f, -0.00756510f, 0.00595071f, -0.08161061f, -0.04028744f, 0.00369936f, 0.03804391f, -0.06627236f, 
    -0.10207934f, -0.18777333f, 0.04520807f, 0.00565050f, -0.04848258f, -0.01181879f, 0.02173374f, 0.10609125f, 
    0.01946036f, 0.00686306f, 0.09321191f, 0.03300986f, 0.00890137f, 0.07869010f, 0.01941673f, 0.23955879f, 
    0.00198424f, 0.04534671f, -0.13068093f, 0.06629326f, 0.05882562f, -0.02093942f, 0.04200872f, 0.04036272f, 
    0.01895985f, -0.09542258f, 0.07862717f, -0.05195297f, -0.02673351f, 0.04458720f, -0.05528659f, -0.03235371f, 
    -0.00285853f, 0.08226110f, -0.02382608f, -0.12565972f, -0.08595309f, 0.01195666f, -0.03067160f, 0.16082865f, 
    0.09523981f, 0.02322065f, -0.07756045f, 0.02040046f, 0.05616734f, 0.04846728f, -0.05023677f, 0.04985360f, 
    -0.21807939f, -0.04156183f, -0.00372040f, -0.01401028f, 0.07186902f, 0.00425271f, -0.00821569f, -0.06979842f, 
    0.00545634f, 0.03691885f, 0.07024904f, -0.01723582f, -0.11131075f, -0.02319818f, 0.10265269f, -0.12664455f, 
    0.18476735f, 0.08653370f, 0.17920132f, -0.00923334f, -0.04932786f, -0.00777638f, -0.01989773f, -0.09681097f, 
    -0.25314206f, 0.13056423f, 0.13654132f, -0.05028100f, -0.06471107f, -0.07936765f, -0.01986756f, -0.00669598f, 
    0.02663099f, 0.06050620f, -0.04449792f, 0.01456205f, -0.04889537f, -0.00496608f, 0.19867986f, 0.09756824f, 
    0.13977048f, -0.00845676f, 0.03767362f, -0.03872939f, 0.04621592f, 0.04604094f, -0.03776077f, 0.05976750f, 
    -0.03548151f, -0.13622376f, 0.08380273f, 0.00149546f, 0.09912696f, 0.05586972f, 0.01239487f, 0.04622534f, 
    0.02519322f, 0.03704980f, -0.06484307f, -0.03690882f, 0.15182084f, -0.04706762f, 0.14758244f, 0.06474952f, 
    -0.02097199f, -0.01017304f, 0.01914005f, 0.00856667f, -0.02936946f, 0.10613535f, -0.07952267f, -0.03316419f, 
    -0.08448918f, 0.05902727f, 0.03839362f, -0.04675578f, 0.06319635f, -0.08062593f, 0.01891029f, 0.03014759f, 
    -0.00300812f, 0.00253675f, 0.06118593f, 0.05530941f, -0.25736281f, -0.05948145f, 0.14644296f, -0.05371209f, 
    0.03006600f, 0.00439365f, 0.10894302f, 0.02987772f, 0.10587268f, 0.01308629f, -0.02186387f, -0.02198460f, 
    -0.00443597f, -0.08804844f, -0.08185841f, -0.05584405f, 0.03591147f, -0.01678431f, 0.03962689f, -0.08122534f, 
    0.05363132f, 0.02295173f, -0.03177695f, -0.00607234f, 0.00577880f, -0.02387278f, -0.02416706f, -0.11009255f, 
    -0.04394844f, 0.07511969f, 0.01990630f, 0.04101674f, -0.01778135f, 0.04193629f, 0.09151448f, -0.05539963f, 
    0.08221174f, -0.18925124f, -0.06287312f, -0.11860055f, -0.01909852f, 0.05335912f, 0.05040241f, 0.05333327f, 
    -0.02905358f, 0.11610749f, 0.01710537f, -0.03497856f, 0.05297152f, -0.05338470f, -0.02473999f, -0.12914440f, 
    -0.04751765f, 0.06918439f, -0.09501357f, -0.15962118f, 0.07549441f, 0.09351338f, -0.09749547f, 0.00483909f, 
    0.13461444f, -0.03379649f, -0.08876786f, 0.05129679f, 0.00062981f, -0.00016995f, 0.00532065f, 0.01436557f, 
    0.03477238f, 0.00072761f, 0.01341303f, 0.05393937f, -0.16197956f, 0.03931858f, -0.03812810f, 0.02261805f, 
    -0.03356961f, -0.03993604f, -0.06902012f, -0.05585954f, -0.05988449f, 0.03090078f, 0.05633019f, 0.03271456f, 
    -0.06658712f, 0.02899088f, -0.08014970f, -0.19443735f, 0.03275454f, -0.05775311f, -0.01325465f, 0.05596692f, 
    -0.02903266f, 0.02979865f, 0.02996984f, 0.05356938f, -0.40437064f, 0.18014079f, -0.04322005f, -0.08378086f, 
    0.01548144f, -0.04971262f, 0.00237238f, 0.09209945f, 0.05016014f, 0.04148308f, 0.00649321f, -0.03558095f, 
    0.16939178f, 0.02086317f, 0.03629370f, 0.06292373f, 0.09557956f, 0.01580529f, 0.13682388f, 0.15265127f, 
    0.13623892f, -0.00214144f, 0.05495019f, 0.02339141f, 0.15029408f, -0.03007761f, -0.05323923f, 0.01770622f, 
    -0.01546295f, -0.07182621f, 0.03534542f, 0.07008920f, 0.09526978f, -0.01550069f, 0.00737662f, 0.03540067f, 
    0.06381468f, -0.03276506f, -0.14010851f, 0.00760075f, -0.08712305f, -0.02555646f, -0.01837662f, 0.07292162f, 
    -0.00898188f, -0.02478423f, 0.02367793f, -0.08959151f, -0.17540812f, 0.03774541f, -0.03168456f, -0.02834618f, 
    0.04066933f, 0.03151819f, -0.03324316f, 0.00551618f, 0.08935814f, 0.02203210f, 0.06273071f, -0.03036026f, 
    0.08842779f, -0.06667939f, 0.03435034f, -0.08824499f, 0.08425961f, 0.02529909f, 0.05151935f, -0.03094444f, 
    0.00740125f, 0.06511027f, -0.05735832f, -0.00942341f, 0.19754849f, 0.14597337f, 0.06806074f, 0.04799876f, 
    0.01157839f, -0.02370605f, -0.04745741f, 0.03009607f, 0.04166329f, -0.01901263f, 0.05812413f, 0.05751590f, 
    0.16874544f, -0.03532441f, -0.00345940f, 0.10757189f, 0.02806039f, -0.00014045f, 0.06070331f, -0.06181461f, 
    0.04768869f, 0.03936402f, 0.06300668f, 0.05941027f, -0.02325095f, -0.02035511f, -0.12472758f, 0.15285368f, 
    0.05787087f, -0.00469097f, -0.03900486f, -0.00430958f, 0.16456573f, 0.04873367f, 0.07797476f, 0.04198346f, 
    -0.03961688f, -0.01424651f, 0.02684418f, 0.09885863f, -0.02137901f, 0.09551926f, 0.08336340f, 0.05528534f, 
    0.02091558f, 0.03820505f, -0.02044037f, -0.00474775f, 0.01616203f, -0.15803091f, -0.01489808f, 0.01853237f, 
    0.04727527f, 0.03309067f, 0.06470884f, -0.02414439f, -0.00467706f, 0.00869441f, 0.04966087f, 0.11259810f, 
    0.25606179f, 0.06092276f, 0.06353410f, 0.16223262f, 0.03391164f, 0.02195809f, -0.02098602f, 0.04193468f, 
    0.05503745f, 0.05048147f, 0.04024664f, 0.09454061f, 0.19073084f, -0.14502816f, 0.02016782f, 0.13714060f, 
    0.15615019f, 0.01808483f, 0.02930845f, 0.08279113f, 0.09107685f, 0.11474565f, -0.01155796f, 0.05533379f, 
    -0.02912909f, -0.09904967f, 0.06796949f, 0.01134571f, -0.02958763f, 0.05654566f, 0.05797236f, 0.11736763f, 
    0.04620849f, 0.04711168f, 0.03401203f, 0.00327316f, 0.04196369f, 0.00578523f, -0.08893426f, -0.03007447f, 
    0.02315868f, 0.01235319f, -0.03027380f, -0.03525899f, -0.01758679f, -0.05670199f, -0.02062996f, 0.10989486f, 
    -0.04752577f, 0.05851157f, 0.08247005f, 0.01023919f, 0.01628848f, 0.04528284f, 0.06576495f, 0.02754850f, 
    0.06121429f, -0.01518854f, 0.03852075f, 0.06264034f, -0.04164821f, 0.22661819f, 0.08174857f, -0.03713031f, 
    0.11774540f, 0.03764189f, 0.06586851f, 0.12644036f, 0.03845857f, -0.03715111f, 0.08684501f, 0.08162385f, 
    0.27883467f, -0.00480210f, -0.17205489f, -0.00510276f, 0.03395530f, 0.02713535f, -0.02856278f, 0.09229097f, 
    0.00917869f, 0.00572714f, 0.08136854f, 0.05864487f, 0.08290702f, 0.03280269f, -0.16939418f, -0.13678913f, 
    -0.04527213f, -0.02754410f, -0.01560181f, -0.10599068f, -0.05232524f, -0.03156072f, 0.01325696f, 0.01547159f, 
    0.06390653f, -0.07660382f, -0.01409412f, 0.01243006f, -0.00316777f, 0.09387107f, 0.03327361f, -0.01139809f, 
    -0.02304914f, 0.05979235f, 0.13267288f, -0.03469428f, -0.17407542f, -0.15084028f, 0.04361216f, 0.03403387f, 
    -0.03858832f, 0.14926104f, -0.04467381f, 0.08231578f, 0.01694607f, 0.03602762f, 0.00134061f, -0.05129858f, 
    0.07496848f, -0.20132191f, 0.05583769f, 0.05724449f, 0.10208771f, -0.00509897f, 0.02716924f, -0.00056631f, 
    0.06086028f, 0.12610030f, -0.03943575f, 0.12495594f, -0.02405686f, 0.14117528f, -0.01382619f, 0.07699486f, 
    0.01963739f, 0.09893396f, -0.04665058f, 0.01887375f, 0.01531283f, 0.05443021f, 0.18979496f, -0.01911936f, 
    0.02147455f, 0.21280007f, -0.00346857f, -0.03427543f, 0.02011666f, -0.03960925f, 0.02187937f, 0.08218069f, 
    -0.08550014f, 0.00559519f, -0.03776057f, 0.07367573f, -0.02427448f, 0.13299729f, 0.02800806f, 0.08320991f, 
    0.00045266f, 0.00003653f, 0.02655840f, 0.02032979f, 0.02881136f, 0.01029008f, 0.00551679f, -0.00724871f, 
    0.10553351f, -0.00383444f, -0.07815682f, -0.09470595f, 0.00363157f, 0.05215077f, 0.04580060f, -0.07303634f, 
    0.11126118f, 0.01855271f, 0.01762071f, -0.04377532f, -0.09687673f, -0.03110103f, 0.14168037f, 0.23136319f, 
    0.08024264f, 0.12739794f, 0.02401012f, 0.14099988f, 0.00132487f, 0.03730521f, 0.08488318f, -0.02249388f, 
    0.11300275f, -0.03904503f, -0.11226051f, -0.13219011f, -0.11683324f, 0.06217459f, 0.01267743f, -0.03027451f, 
    0.00196468f, 0.05482313f, -0.04394767f, -0.09747497f, -0.13690466f, -0.02741577f, 0.00903605f, 0.09532964f, 
    0.08836874f, 0.03861126f, -0.00030779f, -0.00764224f, 0.04601541f, 0.01374719f, 0.05825581f, 0.08061054f, 
    -0.01936796f, -0.08911448f, 0.20184661f, -0.00774717f, 0.03177324f, 0.08000561f, 0.03032087f, -0.00016322f, 
    0.09188629f, 0.10052520f, -0.04734279f, 0.06834505f, -0.01070109f, -0.14685698f, 0.01969851f, -0.12982839f, 
    0.00552859f, -0.04329626f, -0.00641445f, 0.01907361f, 0.08732881f, 0.04413691f, 0.05074582f, -0.00254926f, 
    0.04499574f, 0.09664666f, 0.27178624f, 0.11683392f, 0.03857131f, 0.06284188f, 0.00597428f, 0.05186877f, 
    0.04880706f, 0.10192605f, 0.00329442f, 0.03358734f, -0.20008391f, 0.11045159f, -0.08156994f, -0.02346429f, 
    0.01883875f, 0.00094967f, -0.04458288f, 0.02255217f, 0.04925429f, 0.01606952f, 0.05164471f, -0.00225794f, 
    0.18593179f, 0.15295066f, 0.11552191f, 0.11889248f, 0.03290490f, -0.05562473f, 0.08529595f, 0.02617739f, 
    0.02295828f, -0.05842252f, -0.04500527f, 0.07956014f, 0.13111822f, -0.09160799f, -0.11298877f, 0.11410864f, 
    -0.01529274f, 0.04360821f, 0.04351008f, -0.03025788f, 0.00129746f, 0.05063317f, 0.01002117f, 0.03410722f, 
    0.11721794f, -0.12578939f, 0.03935322f, 0.03668451f, 0.04037204f, 0.07515915f, 0.03202338f, 0.00619056f, 
    0.03362728f, 0.02968390f, -0.07756687f, 0.08030476f, 0.18890651f, -0.00089954f, -0.05114625f, 0.04197551f, 
    0.07899615f, -0.01624068f, -0.03822023f, -0.02777240f, 0.03852465f, 0.00968450f, 0.10940538f, 0.02756819f, 
    0.23113550f, 0.15924589f, -0.01733707f, -0.03011131f, -0.02277663f, -0.07885782f, 0.12837739f, 0.00540657f, 
    0.04806667f, 0.02626515f, 0.06052095f, -0.00089985f, -0.00182745f, 0.03199758f, 0.04270134f, 0.01970412f, 
    0.11099643f, 0.07670216f, 0.05253221f, 0.03174243f, 0.07952076f, 0.00185372f, -0.00464171f, 0.09140077f, 
    0.11328303f, -0.13064802f, 0.01656001f, 0.08981545f, 0.00227829f, 0.03367833f, 0.02655833f, 0.04229259f, 
    0.07667734f, -0.03762747f, 0.03590057f, 0.09229460f, 0.19724822f, 0.05829360f, -0.00834414f, 0.13282014f, 
    0.01683953f, 0.00415181f, -0.01190913f, 0.11628725f, 0.04908802f, 0.00750631f, 0.07610787f, 0.03048018f, 
    0.16367587f, -0.17701839f, -0.06423783f, 0.16729239f, 0.04111467f, -0.08208560f, 0.05549661f, 0.00258087f, 
    0.03739186f, -0.04251581f, 0.12722778f, 0.02023072f, -0.06197610f, -0.00654361f, 0.07478511f, -0.11455686f, 
    -0.06698266f, 0.07942784f, -0.00789715f, -0.02568568f, 0.04540259f, 0.00153323f, 0.09115697f, -0.04127640f, 
    0.13494375f, 0.02072807f, 0.04960003f, 0.10114902f, 0.09486118f, -0.05102871f, 0.14878638f, 0.07415906f, 
    0.11137251f, 0.02619828f, 0.08580465f, 0.09138542f, -0.05431212f, -0.00423570f, -0.12151023f, 0.00159370f, 
    -0.01650802f, 0.09799816f, 0.03445606f, 0.03988925f, 0.11250965f, 0.03453337f, -0.12320750f, 0.01282270f, 
    -0.06536165f, -0.07932233f, 0.02821655f, 0.01147578f, 0.06089617f, -0.06307497f, -0.01647826f, 0.00434084f, 
    0.03715710f, 0.02236667f, 0.05701046f, 0.06054611f, 0.33213091f, -0.06654933f, -0.00778059f, 0.25100175f, 
    0.08553720f, -0.00650857f, -0.00504041f, -0.00129714f, 0.12297878f, 0.00232807f, 0.01277537f, 0.07870013f, 
    -0.13287586f, -0.03303156f, 0.01380438f, 0.01146224f, 0.03894027f, 0.01450929f, 0.01451175f, 0.04705273f, 
    -0.01217125f, 0.09381622f, 0.08353570f, 0.08861326f, 0.14364937f, 0.02163547f, -0.01063365f, 0.01345536f, 
    -0.04706931f, 0.07878162f, 0.00266712f, -0.03201675f, -0.00171063f, -0.01231948f, 0.07827847f, 0.02096141f, 
    0.14401141f, -0.13970546f, -0.14759715f, -0.05457293f, 0.07934871f, 0.06176751f, 0.03077229f, -0.01324023f, 
    0.05844551f, 0.01994013f, 0.05197788f, 0.09003167f, 0.00927783f, -0.02464912f, 0.05581551f, 0.05136314f, 
    -0.03297533f, -0.04285507f, 0.04828576f, -0.00316770f, 0.10551631f, -0.03079384f, -0.03217321f, 0.00725600f, 
    0.04596278f, 0.02791694f, -0.02079262f, 0.01069209f, 0.12109499f, 0.03139925f, 0.04568823f, 0.10137296f, 
    -0.01137644f, -0.02211969f, 0.10300374f, 0.03014908f, 0.07953269f, 0.07639145f, -0.08782816f, -0.05440734f, 
    0.00880248f, 0.10278506f, -0.01237393f, 0.04199098f, 0.03531763f, 0.06529113f, 0.09788509f, 0.03638132f, 
    -0.10198660f, -0.08733325f, -0.06356321f, -0.00075321f, 0.11948580f, 0.03631872f, 0.06572527f, -0.01555302f, 
    0.09114748f, 0.05297682f, -0.00550783f, 0.02056195f, -0.04480566f, 0.03726633f, -0.15587206f, -0.18747455f, 
    0.14445972f, 0.02863973f, 0.03833075f, -0.02677694f, -0.00701830f, -0.01242773f, 0.09141444f, 0.05251537f, 
    -0.10193858f, -0.00550210f, -0.06843526f, 0.08773940f, 0.02081960f, 0.04159953f, 0.09845282f, -0.02287708f, 
    0.03594286f, 0.02296184f, 0.08075786f, 0.00711973f, 0.05761261f, -0.12301626f, 0.09442939f, -0.03591916f, 
    0.04441829f, -0.00001902f, 0.01223404f, -0.05198367f, -0.00778490f, 0.01401571f, -0.07739924f, -0.04530742f, 
    -0.31253627f, -0.17570499f, -0.14552966f, -0.16668756f, 0.10299454f, -0.01752093f, 0.03605231f, -0.00612615f, 
    0.00349701f, 0.08631217f, -0.06254156f, 0.08625342f, -0.25547636f, -0.10546626f, -0.12334840f, -0.17311957f, 
    0.03291817f, 0.08375881f, 0.03379985f, -0.08959191f, -0.02353870f, -0.07648600f, 0.02716686f, 0.08807320f, 
    -0.16586816f, -0.14030389f, -0.06277110f, -0.11620286f, 0.01963628f, -0.06884300f, -0.02468508f, -0.04607452f, 
    -0.00988233f, -0.02685304f, 0.01186288f, 0.09512815f, -0.13126124f, 0.00518311f, -0.09818968f, -0.00595291f, 
    0.08152466f, 0.05402224f, -0.03064770f, 0.04278720f, 0.06158204f, -0.00510287f, 0.00757995f, -0.04165320f, 
    -0.00481822f, 0.02758842f, -0.05363305f, 0.17076333f, 0.00178381f, -0.01030694f, -0.01392046f, 0.07170661f, 
    0.14264633f, -0.04775862f, 0.04737559f, 0.06139627f, -0.22305632f, -0.20221026f, -0.02351161f, 0.01901857f, 
    0.03012892f, 0.04107779f, 0.01104959f, -0.00227682f, 0.03475164f, 0.03662697f, 0.08529246f, -0.01268037f, 
    0.11350959f, 0.13239852f, 0.20778929f, -0.10522499f, 0.01034821f, -0.00592033f, 0.02649120f, 0.02369471f, 
    0.00405885f, 0.02164696f, -0.00336923f, -0.00776926f, -0.06044608f, 0.02959588f, -0.00742428f, -0.06752594f, 
    0.00278063f, -0.04663218f, 0.04962477f, 0.06411353f, -0.06185788f, -0.00126961f, 0.03100439f, -0.01253986f, 
    0.05229948f, 0.03717736f, 0.20525286f, 0.18366657f, 0.01527445f, -0.01043774f, -0.04864421f, -0.04849878f, 
    0.10470166f, -0.12320382f, -0.01505796f, 0.12051218f, 0.22313137f, -0.10561691f, 0.18199281f, -0.10483060f, 
    0.01951202f, -0.00376659f, -0.06221577f, 0.11410565f, -0.07255246f, 0.06969496f, -0.02480869f, 0.08626596f, 
    -0.18334053f, -0.07725335f, -0.20728964f, 0.01666261f, 0.00382552f, 0.07803382f, -0.05389847f, 0.00282902f, 
    0.03705725f, -0.01661260f, 0.00153704f, 0.06296670f, -0.13451111f, 0.10439152f, 0.10710957f, 0.07976965f, 
    0.00371232f, 0.00565781f, 0.10303818f, 0.04263891f, 0.06514362f, 0.04125823f, 0.03453869f, 0.01421324f, 
    -0.04204376f, -0.23241040f, -0.12963235f, 0.02324907f, 0.07769641f, -0.05789309f, -0.00778874f, 0.09049585f, 
    0.05905416f, -0.04773389f, -0.00817266f, 0.02394166f, 0.07046609f, 0.02770515f, 0.01267169f, 0.05722957f, 
    0.05415694f, 0.05851058f, -0.01531983f, 0.08774680f, -0.00670853f, 0.08324560f, -0.00672436f, 0.05386838f, 
    -0.15663157f, 0.00520167f, 0.00179532f, -0.01337449f, 0.01375554f, -0.03542258f, 0.04000765f, -0.02511039f, 
    0.10440451f, 0.05042288f, -0.01380083f, -0.05278035f, -0.04396431f, 0.13042668f, 0.02663969f, 0.21030100f, 
    -0.00992784f, 0.00845817f, -0.02048703f, 0.03430486f, -0.00691897f, -0.10954709f, 0.07459032f, -0.02040191f, 
    0.03582890f, 0.20740364f, 0.20658049f, -0.09491844f, 0.00347115f, 0.01857307f, 0.05539890f, 0.04283927f, 
    -0.04419101f, 0.00889031f, 0.07280824f, 0.13235290f, 0.18401182f, 0.10186680f, 0.19295827f, -0.06054666f, 
    -0.01361049f, 0.08272894f, 0.04684364f, 0.01344482f, -0.00324809f, -0.04159479f, 0.02424855f, 0.07312319f, 
    0.13375217f, 0.11021082f, 0.20414865f, 0.22137257f, -0.00498317f, 0.05068845f, 0.07714473f, 0.03358203f, 
    -0.04865064f, -0.01157210f, 0.08955664f, 0.13129155f, -0.12006152f, 0.07488883f, -0.14400840f, 0.12889132f, 
    -0.08697993f, 0.08952559f, -0.00282898f, 0.02524918f, -0.00439680f, -0.04439645f, -0.03084511f, 0.01827657f, 
    0.03118780f, -0.04037006f, 0.05475974f, 0.05219003f, 0.01928593f, -0.05484676f, 0.11881137f, 0.10591092f, 
    -0.04920917f, 0.04499386f, 0.05144808f, -0.04653359f, -0.03844155f, -0.01020638f, 0.22952321f, 0.10945816f, 
    -0.06338567f, -0.02558562f, -0.01803099f, -0.07280740f, -0.08392577f, -0.00364217f, 0.09075643f, -0.00488011f, 
    -0.13704129f, -0.01447052f, 0.01163078f, 0.04627503f, -0.03667304f, -0.07574821f, 0.00375966f, -0.02634349f, 
    0.05326187f, 0.02153998f, 0.03067423f, 0.00394740f, 0.04414009f, -0.03780963f, 0.04346020f, -0.11320393f, 
    0.06287404f, 0.00134063f, 0.03176796f, 0.00773458f, 0.11982908f, 0.04094599f, -0.01070149f, 0.04551659f, 
    -0.02419777f, 0.03515409f, 0.06087485f, 0.09480157f, 0.07363161f, 0.08096594f, -0.05598304f, 0.03263966f, 
    0.02940469f, 0.01814660f, 0.13033581f, -0.04045000f, -0.30708775f, -0.19386436f, -0.20044810f, -0.15537032f, 
    0.07093809f, 0.03828003f, -0.04340329f, -0.02869292f, 0.04738427f, 0.09135444f, 0.07361312f, 0.05463476f, 
    -0.24753608f, -0.00910586f, -0.14776416f, -0.15630175f, 0.05028922f, 0.03053680f, 0.00753015f, 0.03902240f, 
    -0.04396261f, 0.03770050f, 0.10258889f, -0.00282927f, -0.02891563f, -0.04844740f, -0.03331781f, 0.20223850f, 
    0.09025414f, 0.03006867f, -0.01008321f, -0.03503838f, -0.04220382f, -0.00348112f, 0.00869084f, 0.03821616f, 
    0.07398698f, 0.12211933f, -0.00343159f, 0.16831757f, -0.05553564f, 0.00033541f, -0.00400064f, -0.11916353f, 
    0.02797469f, 0.03171335f, -0.07717802f, -0.02888865f, -0.23458718f, -0.12478571f, -0.01904121f, 0.02925452f, 
    0.06705981f, 0.01355791f, 0.11944140f, -0.00565969f, 0.10126434f, 0.01269313f, 0.02894181f, -0.02028019f, 
    -0.10601132f, 0.11057429f, -0.02892934f, -0.11251029f, -0.00931120f, -0.00368172f, -0.01238678f, 0.09970452f, 
    0.12268364f, 0.11454993f, -0.00609845f, -0.00350823f, -0.03339849f, 0.03238079f, 0.12777436f, 0.03553906f, 
    0.04823105f, 0.04581324f, -0.06229063f, 0.08342613f, 0.03103703f, 0.03951382f, -0.14668231f, 0.07981373f, 
    -0.17628755f, -0.18197909f, -0.19172615f, -0.13441411f, 0.02850950f, 0.01764393f, -0.09558757f, -0.10073764f, 
    0.01253289f, 0.03110971f, -0.01808851f, 0.01675135f, -0.04957596f, -0.09452043f, 0.09070168f, 0.04532066f, 
    -0.02193286f, -0.01712689f, 0.02663338f, 0.11860516f, -0.09017241f, 0.05533348f, 0.00420204f, -0.04288571f, 
    -0.17076199f, -0.28386006f, -0.09192318f, -0.08581258f, -0.07291612f, 0.00710270f, -0.01984963f, -0.01142409f, 
    0.00733993f, -0.00323865f, 0.00617286f, 0.02217673f, -0.02795373f, -0.02055238f, 0.00115859f, -0.01773388f, 
    0.05455837f, -0.01463799f, 0.08502054f, 0.01101434f, 0.08361913f, 0.08721387f, -0.01102791f, 0.01850993f, 
    -0.06012095f, -0.14760467f, -0.12523192f, 0.01196860f, 0.16280888f, -0.05432327f, 0.04789843f, -0.09580627f, 
    0.11546525f, 0.04946256f, 0.09643757f, 0.08094243f, 0.19362354f, 0.01376087f, 0.17198604f, -0.13111092f, 
    -0.11724104f, 0.00106438f, -0.00209341f, 0.06168702f, 0.04662166f, -0.00491410f, -0.01073913f, 0.01483500f, 
    0.04554041f, -0.15950179f, 0.04625997f, 0.20272131f, -0.05317917f, -0.03307687f, 0.04792358f, 0.01622847f, 
    -0.04827599f, 0.06166854f, -0.00565086f, -0.02593746f, -0.40023613f, -0.08813389f, -0.06139784f, -0.09265219f, 
    0.05022155f, 0.03547876f, 0.01828822f, -0.08996310f, 0.08063874f, 0.05626084f, 0.02050814f, 0.04735333f, 
    0.07828360f, -0.04180329f, 0.15984792f, 0.10144055f, 0.05533007f, -0.06798077f, 0.03880098f, -0.04171589f, 
    -0.01847406f, 0.10598755f, 0.01706085f, 0.19637804f, 0.07682600f, 0.18513495f, 0.06918634f, 0.14900315f, 
    0.01953664f, 0.02074246f, 0.02296194f, -0.00095893f, 0.07270431f, 0.05605417f, 0.04166776f, 0.03798499f, 
    -0.04869414f, 0.00841489f, 0.06024427f, 0.06724927f, -0.06023336f, -0.00382690f, 0.05636327f, 0.06460962f, 
    0.03188271f, -0.03968660f, -0.01974795f, 0.06199984f, 0.00465595f, -0.08486964f, 0.00571522f, 0.15973154f, 
    -0.04366479f, 0.05793991f, -0.05166528f, -0.02614858f, -0.12988509f, 0.02167677f, 0.05487716f, 0.00764495f, 
    -0.14153399f, 0.12138369f, 0.19168463f, -0.11211485f, 0.02243794f, 0.15012990f, 0.00802089f, 0.01250895f, 
    0.08890174f, 0.08438271f, 0.07083797f, 0.01654657f, -0.02510677f, 0.03485381f, 0.11137880f, -0.06510230f, 
    -0.15575506f, 0.06801791f, -0.02210085f, -0.07084768f, -0.02172101f, -0.02483900f, -0.03681456f, 0.00552432f, 
    0.01152281f, 0.05165048f, 0.13387597f, 0.11397467f, -0.11089055f, 0.15707536f, 0.05552201f, 0.05793271f, 
    0.04366686f, 0.04254024f, -0.02153724f, 0.06620903f, -0.07749262f, -0.13417679f, -0.03070528f, 0.22995681f, 
    0.07485012f, 0.02129303f, -0.03151417f, -0.00446792f, -0.11266197f, -0.05719968f, 0.02418157f, 0.04352435f, 
    0.18916926f, 0.12865333f, 0.21832784f, 0.05967827f, -0.04610093f, 0.11381071f, 0.01642194f, 0.05962060f, 
    -0.01194625f, -0.07809286f, 0.01768794f, 0.04924426f, 0.08233359f, 0.21252744f, 0.03695208f, 0.16991425f, 
    -0.09862625f, 0.01198304f, -0.03273123f, -0.05288415f, -0.01189433f, 0.07227693f, -0.05616995f, -0.00014556f, 
    0.03965767f, 0.19703998f, 0.03655612f, -0.17391950f, 0.02771156f, 0.11999007f, 0.01941394f, -0.05165819f, 
    0.08460455f, 0.03434411f, 0.15548413f, 0.02887294f, -0.15379317f, 0.00356316f, 0.15554474f, -0.05350043f, 
    -0.05885926f, -0.01837062f, -0.10376059f, 0.03526171f, -0.05901143f, -0.01886137f, -0.07102154f, 0.02219962f, 
    0.10803456f, -0.00804709f, 0.11168628f, -0.12347642f, 0.02210203f, -0.08357069f, 0.10838039f, 0.01644618f, 
    0.02806589f, 0.00170420f, -0.02969001f, 0.04229994f, 0.01437145f, 0.02292334f, 0.04806150f, 0.08170214f, 
    -0.11195063f, -0.03859077f, -0.00856001f, -0.00493884f, -0.02830058f, -0.03531057f, 0.01079748f, 0.06356668f, 
    0.05346543f, 0.08647179f, 0.25652772f, -0.14045539f, -0.05023720f, 0.08551201f, 0.00246604f, 0.03943061f, 
    -0.01213993f, 0.03088665f, -0.00748909f, -0.01387080f, -0.00176244f, 0.14636745f, 0.14772554f, 0.06139701f, 
    -0.01274385f, 0.09343679f, -0.05818427f, 0.09182917f, -0.02361464f, 0.03837391f, -0.00792471f, -0.06716000f, 
    -0.16185459f, 0.17847122f, 0.21515346f, 0.01231752f, -0.01489015f, 0.03901041f, 0.06213180f, -0.01225908f, 
    0.05510422f, -0.06039041f, 0.05342141f, -0.01655376f, -0.17210661f, -0.06769972f, -0.12102699f, -0.25530702f, 
    0.10397913f, -0.03871985f, 0.19909726f, -0.01518013f, -0.12538467f, -0.00566828f, -0.00265956f, -0.06104768f, 
    -0.21224794f, -0.03038359f, -0.04548495f, -0.04077962f, 0.02898132f, 0.01873437f, 0.01754972f, -0.05330355f, 
    -0.00629119f, -0.06000763f, 0.07030196f, -0.08363127f, -0.33035338f, -0.18459767f, -0.02231370f, 0.10443600f, 
    0.05900499f, -0.04483416f, 0.10204956f, 0.10805926f, 0.09844968f, 0.11309500f, -0.01929445f, 0.00931539f, 
    -0.00922965f, -0.01987104f, -0.00120225f, -0.00715278f, 0.01977964f, 0.01912637f, -0.00813695f, 0.01643586f, 
    -0.00900054f, 0.02585541f, 0.00137025f, 0.02701764f, 0.00970318f, -0.00915197f, -0.02417970f, -0.00904023f, 
    -0.04223647f, -0.03204618f, 0.01276457f, -0.00752031f, 0.00057387f, 0.02180614f, 0.02532481f, -0.04134211f, 
    -0.04332407f, -0.00348973f, -0.02807903f, -0.02113285f, 0.02508159f, 0.00858180f, -0.01313878f, -0.01801675f, 
    0.02676794f, -0.01381472f, -0.01305625f, -0.02995139f, 0.01014643f, 0.01770895f, -0.03526176f, 0.01986753f, 
    0.00130445f, -0.02823013f, 0.02275521f, -0.02014137f, 0.01468742f, 0.02952719f, -0.03301510f, -0.03511236f, 
    -0.03682486f, -0.01460602f, -0.01164290f, -0.02645406f, -0.03706239f, -0.03079814f, -0.03553943f, -0.00471062f, 
    0.01359839f, 0.00179372f, 0.02433025f, -0.03616364f, -0.00785193f, -0.00263336f, 0.00179840f, -0.00733714f, 
    -0.02797814f, 0.03399398f, -0.03572711f, -0.01859859f, 0.01188711f, 0.00639208f, 0.03315586f, 0.00258305f, 
    0.01681204f, 0.02591778f, -0.02507171f, -0.01815566f, 0.01687280f, 0.01829162f, 0.04107432f, -0.01637814f, 
    -0.00163786f, 0.01032385f, -0.00302084f, -0.00475246f, -0.00045879f, 0.03068031f, -0.02329731f, 0.00088429f, 
    0.01586607f, -0.02838196f, 0.02596421f, 0.00662594f, 0.01976723f, 0.02440811f, 0.00698628f, -0.03714221f, 
    0.01068592f, 0.00467469f, -0.04033134f, 0.02529819f, 0.01012052f, -0.00738763f, -0.00886725f, -0.02525975f, 
    -0.01994960f, 0.00666016f, -0.01724393f, 0.00112229f, -0.00727009f, -0.00751998f, -0.00238971f, -0.00207810f, 
    -0.01438165f, -0.01218074f, -0.03074363f, 0.01134852f, -0.00536311f, -0.01100741f, -0.02535728f, -0.00234684f, 
    0.00251745f, -0.03753778f, -0.01947308f, 0.02352727f, 0.02836098f, 0.00637725f, 0.01188761f, 0.03244742f, 
    -0.00201726f, -0.03147608f, 0.00244886f, -0.00850565f, 0.02357449f, 0.00434637f, -0.03831238f, 0.01388982f, 
    0.02361849f, -0.00780061f, -0.00448094f, -0.02373011f, 0.00264382f, -0.01452433f, -0.00979571f, -0.01411690f, 
    -0.04986942f, -0.04396304f, -0.03409468f, -0.03245969f, -0.01289791f, -0.04196301f, -0.01284009f, -0.00133505f, 
    -0.02053004f, 0.01081084f, -0.00245438f, 0.00850934f, -0.02428370f, -0.04516865f, -0.00208336f, 0.00400159f, 
    -0.03397787f, 0.00929642f, 0.01925946f, 0.01120871f, -0.02378858f, -0.02974764f, 0.02428393f, -0.03734978f, 
    0.02723522f, -0.00291919f, -0.02496336f, -0.03494792f, 0.01043032f, -0.01025160f, -0.00173878f, 0.00035130f, 
    -0.04628218f, 0.02604110f, 0.01365727f, 0.02933955f, 0.00298634f, -0.03434182f, 0.01213486f, 0.02178485f, 
    0.02893161f, 0.01556784f, -0.00067308f, -0.01151746f, -0.03095242f, 0.02866915f, -0.00399129f, -0.03727254f, 
    -0.00557889f, 0.01157293f, 0.00441640f, -0.00484981f, -0.01359474f, -0.03975310f, 0.01144504f, 0.03066279f, 
    -0.00463810f, -0.03296143f, -0.03567706f, -0.00247121f, 0.01369983f, -0.03184285f, -0.03370347f, -0.05448313f, 
    -0.00423439f, -0.04175850f, -0.00654318f, -0.00664730f, 0.02334001f, -0.01908617f, 0.03016368f, -0.02669146f, 
    -0.02015115f, -0.03077265f, -0.01968703f, 0.00477279f, -0.01608117f, 0.00962347f, -0.03482433f, -0.02579779f, 
    0.02109781f, 0.01451550f, -0.03487808f, 0.02670681f, -0.01110838f, 0.00976728f, 0.00966943f, -0.01731573f, 
    0.03265805f, 0.01689894f, -0.00931362f, 0.00119936f, -0.03286263f, 0.03112706f, -0.01716965f, 0.00131865f, 
    -0.00844932f, -0.03165860f, 0.00877811f, 0.00784373f, -0.00618621f, 0.03255869f, -0.04156845f, -0.00859303f, 
    -0.00534321f, 0.02970079f, -0.00859105f, -0.01736084f, 0.02114424f, -0.01481874f, -0.01345567f, 0.02976111f, 
    -0.03212474f, -0.01626774f, 0.02678048f, -0.02041959f, 0.01690387f, 0.02431468f, 0.00467841f, 0.03297190f, 
    -0.01555479f, -0.00636602f, -0.01021018f, -0.01654555f, -0.04285442f, -0.04065966f, -0.03906061f, 0.01544541f, 
    0.00015255f, -0.03360309f, -0.02808779f, 0.00626138f, -0.02956986f, -0.02089094f, -0.02775618f, 0.01904671f, 
    0.01326067f, -0.03020807f, 0.00823283f, 0.00743433f, -0.01181458f, -0.01258080f, -0.02514063f, -0.02722043f, 
    -0.00627369f, -0.01281622f, -0.00275409f, 0.00898940f, -0.03085746f, -0.03369072f, 0.01969320f, 0.03397515f, 
    -0.00326813f, -0.02458723f, -0.02461585f, 0.02078833f, -0.02045665f, -0.03352655f, 0.00308423f, 0.01373262f, 
    0.00599524f, 0.03566715f, 0.00886497f, -0.00404113f, 0.02947470f, -0.02497708f, -0.00343615f, -0.02520968f, 
    0.01794797f, 0.01807781f, -0.01370498f, -0.00845716f, 0.01140978f, -0.01827514f, -0.01041491f, -0.03720476f, 
    0.01325918f, -0.02453924f, 0.02899007f, -0.03272619f, -0.00162960f, 0.01880921f, -0.00502977f, -0.00205402f, 
    -0.04053989f, -0.00294012f, -0.02150303f, -0.00202197f, 0.01441733f, -0.04210959f, 0.00323484f, -0.00742194f, 
    -0.01192186f, -0.00998058f, -0.02628613f, -0.01237153f, 0.02140443f, 0.02372916f, -0.03251864f, -0.00609350f, 
    0.01975253f, 0.00045480f, 0.02273093f, 0.02614289f, -0.03449321f, -0.00786780f, 0.02941970f, 0.00871654f, 
    0.01159520f, -0.02365086f, -0.01883937f, -0.01704810f, -0.01149916f, -0.01252734f, 0.01653245f, 0.01727523f, 
    0.02741881f, -0.03137259f, -0.00327672f, -0.00139114f, -0.02316015f, 0.01152613f, 0.00536006f, -0.00712668f, 
    0.00558854f, -0.01010139f, -0.00757500f, -0.03198228f, 0.00370325f, -0.00536944f, 0.02565399f, -0.02891999f, 
    -0.01495059f, 0.03200980f, 0.03755572f, -0.03283392f, -0.04068215f, 0.01198296f, -0.01536625f, 0.01212574f, 
    -0.01664243f, -0.00876988f, -0.02508425f, 0.02093003f, 0.02627552f, -0.02722240f, 0.03068666f, -0.01095428f, 
    0.00903780f, -0.02300031f, -0.01612720f, 0.00832109f, 0.00184082f, -0.00732414f, 0.02477640f, 0.00426801f, 
    0.01252818f, 0.01848947f, -0.00723751f, -0.02305030f, -0.02179915f, -0.04223066f, 0.00026884f, -0.02964973f, 
    -0.00386752f, 0.00663166f, 0.01570836f, -0.03372056f, 0.00266363f, 0.01776241f, -0.04086750f, -0.01024030f, 
    0.03062966f, -0.01141796f, -0.01851189f, 0.01610778f, -0.02833733f, -0.00203921f, -0.00189500f, 0.01432587f, 
    -0.02537646f, 0.01835993f, -0.02536106f, 0.00919806f, 0.01899490f, 0.00907675f, -0.01359435f, -0.02870242f, 
    0.02813086f, 0.04553750f, 0.02210576f, -0.00770265f, 0.00181386f, -0.00351924f, 0.00199362f, -0.03407520f, 
    -0.01992458f, -0.04410266f, -0.02629995f, 0.00686046f, 0.02005712f, -0.00812766f, 0.00772251f, -0.01581342f, 
    0.00149618f, -0.00982788f, -0.03550692f, 0.01437560f, -0.02877925f, -0.02621700f, -0.00293251f, -0.00256465f, 
    -0.04076554f, 0.00545261f, -0.02492638f, 0.00805706f, -0.00023578f, 0.01122987f, -0.03270574f, 0.01582282f, 
    0.00692016f, -0.03522067f, -0.03615661f, 0.00691999f, -0.04321139f, -0.03982459f, -0.03553454f, -0.01356336f, 
    0.00419210f, -0.02797164f, -0.02003071f, 0.00759142f, 0.02944542f, -0.01259471f, -0.02115537f, -0.04462552f, 
    -0.02753559f, 0.02079436f, -0.00276389f, 0.01482391f, 0.03725269f, 0.02297669f, 0.02748564f, 0.03276530f, 
    0.00701701f, -0.03234829f, -0.02846909f, -0.03066702f, 0.02412476f, 0.01582057f, -0.01335852f, 0.02921557f, 
    0.02103373f, -0.00205435f, -0.00372264f, -0.00331998f, 0.02061151f, -0.00978484f, 0.02910256f, -0.00135672f, 
    0.02078730f, 0.00235817f, 0.02984286f, -0.02767718f, -0.02133223f, -0.04043463f, 0.00258340f, 0.02866050f, 
    -0.00770524f, -0.01920805f, 0.01975507f, -0.03707489f, 0.00619753f, -0.03970498f, -0.02909507f, 0.02446059f, 
    -0.02576100f, 0.02829633f, -0.00203728f, -0.01163630f, -0.01258276f, 0.01397242f, -0.01902368f, -0.00780990f, 
    -0.03872917f, -0.04872159f, 0.00967817f, 0.00560377f, -0.00119903f, 0.01588253f, -0.00861092f, -0.03429535f, 
    0.00978915f, 0.02161170f, -0.02446614f, 0.01799994f, -0.00855732f, 0.03030084f, -0.04331839f, -0.04433646f, 
    -0.00618307f, -0.01568442f, -0.02448987f, -0.00341449f, -0.04009390f, -0.02880026f, 0.02225402f, 0.01845355f, 
    -0.02950440f, -0.02493543f, 0.01643822f, -0.01208711f, -0.00991144f, 0.00734109f, 0.03306269f, -0.02281016f, 
    -0.00050254f, 0.02929356f, 0.00249798f, -0.02634254f, 0.01314789f, -0.00791351f, -0.04665071f, -0.03751240f, 
    -0.01586050f, -0.00608316f, 0.01008528f, -0.03233773f, 0.01299498f, -0.02838512f, -0.01075282f, 0.01358243f, 
    -0.02483354f, -0.01530662f, -0.03218704f, -0.01017837f, -0.02405951f, -0.03975349f, 0.02489335f, -0.01226516f, 
    -0.03021325f, -0.02200093f, -0.01408497f, -0.00826476f, 0.01802896f, 0.04484407f, 0.00749968f, -0.03812103f, 
    -0.02832045f, -0.00715746f, -0.03541673f, -0.01358378f, -0.02377696f, 0.02568781f, 0.00613882f, -0.00726443f, 
    -0.00414103f, -0.02424627f, -0.04344973f, -0.02802122f, -0.01806213f, 0.02357467f, 0.00710706f, 0.02539729f, 
    -0.01182778f, -0.01156387f, 0.01062530f, -0.00108600f, 0.03326412f, 0.00046356f, -0.00464991f, -0.00564832f, 
    -0.03630745f, -0.01463088f, -0.02230453f, 0.00325448f, 0.00882066f, -0.04409502f, -0.02008269f, -0.03983045f, 
    0.00510897f, -0.00192426f, 0.02598903f, 0.00542321f, -0.00422938f, -0.00558175f, -0.02833699f, -0.01407307f, 
    -0.03715221f, 0.00371540f, 0.03056326f, 0.02506359f, 0.00100983f, 0.01305650f, -0.04467084f, 0.01622796f, 
    -0.00532768f, -0.00969717f, -0.01045440f, 0.00602778f, -0.01224293f, -0.03418572f, -0.02643086f, -0.02311758f, 
    -0.04149738f, 0.02455837f, 0.00427615f, -0.02030357f, 0.03033481f, -0.04220147f, 0.02872008f, -0.03927067f, 
    0.02266842f, -0.03374987f, -0.00412606f, 0.00390445f, -0.04224249f, -0.01016094f, 0.01002486f, -0.00353385f, 
    0.00414374f, 0.01008848f, -0.01801722f, -0.01441390f, 0.00003366f, -0.02117319f, 0.03082225f, 0.00915011f, 
    0.01713064f, -0.03757674f, 0.02993365f, -0.01283978f, -0.01548603f, 0.00169900f, 0.00636274f, -0.02329415f, 
    -0.01098235f, -0.01761102f, 0.01202085f, -0.01245180f, -0.02739171f, -0.00750150f, -0.03956190f, -0.00153059f, 
    -0.02734557f, 0.01228191f, -0.03607066f, -0.01044215f, -0.00793462f, -0.01642571f, 0.01545311f, -0.00832785f, 
    0.00663670f, 0.01027444f, 0.03207039f, -0.00973963f, -0.01231248f, 0.01273407f, -0.00130289f, -0.03517704f, 
    0.01275590f, -0.02773367f, 0.02055734f, -0.00208341f, -0.00913457f, -0.02433025f, 0.02629198f, 0.01592827f, 
    -0.02096732f, -0.00523233f, 0.01801790f, 0.00829438f, -0.00418312f, -0.03263737f, -0.00600999f, -0.00368542f, 
    0.01222495f, 0.00461138f, -0.00260506f, 0.01139690f, 0.03858015f, -0.00569727f, 0.02903084f, -0.01846691f, 
    -0.01006111f, 0.01339289f, 0.02402729f, 0.02575703f, -0.01945316f, -0.00374931f, -0.02550273f, -0.02304607f, 
    0.00214720f, -0.02522689f, 0.01614494f, -0.02864897f, -0.00158647f, -0.00940325f, 0.00386931f, 0.01835798f, 
    0.02472495f, -0.02319497f, 0.03605643f, -0.02121936f, -0.00313996f, 0.01958384f, -0.02761938f, 0.03581356f, 
    -0.01582204f, 0.00634685f, -0.00707644f, -0.00458114f, 0.00650090f, -0.01970586f, -0.02721993f, -0.00203874f, 
    -0.00795253f, -0.01852100f, -0.01133222f, -0.00698569f, -0.03427259f, -0.02081670f, -0.03545624f, -0.01360303f, 
    -0.13109790f, 0.06763449f, 0.02994703f, 0.08711752f, 0.09154902f, -0.02799755f, 0.05317442f, -0.03645751f, 
    0.08363637f, 0.00995004f, 0.14862446f, 0.02590396f, 0.18365113f, -0.02055625f, 0.18350500f, 0.02607374f, 
    0.00042330f, -0.07447923f, -0.04680621f, -0.00806704f, 0.05452646f, 0.05221283f, -0.02272755f, -0.02761767f, 
    -0.37260187f, 0.09231542f, 0.09479853f, -0.09746748f, 0.15327357f, 0.03252887f, 0.04324604f, 0.00278268f, 
    -0.02086305f, -0.05839205f, 0.10993619f, -0.07346833f, -0.47000000f, 0.10788283f, -0.06904004f, 0.12116726f, 
    -0.00121379f, 0.07175983f, 0.08453030f, 0.07700901f, 0.05777143f, 0.00938356f, 0.09210654f, 0.11469279f, 
    0.00315249f, 0.02863282f, -0.04824774f, -0.08952811f, -0.00845372f, 0.09287035f, 0.02192110f, 0.01148531f, 
    -0.04705508f, 0.00452310f, 0.08774513f, -0.02777344f, 0.19053461f, 0.01513036f, 0.02579734f, 0.01874037f, 
    -0.06541632f, -0.02465774f, 0.04769401f, 0.05122138f, -0.04051827f, 0.01822614f, -0.01877121f, 0.07960107f, 
    0.12557550f, 0.00079107f, 0.00753671f, -0.04293509f, -0.06781224f, 0.02596361f, 0.06694568f, 0.14523901f, 
    -0.02923053f, -0.04010116f, -0.01823667f, 0.08023065f, 0.05578873f, -0.08323529f, -0.02633109f, 0.11314660f, 
    -0.01754466f, -0.00637925f, 0.04676053f, 0.07829012f, -0.03170251f, -0.05700193f, -0.08516233f, -0.00497241f, 
    0.04632090f, -0.00080097f, -0.09275681f, -0.08295535f, 0.06864162f, 0.06022564f, 0.05280870f, -0.04142112f, 
    0.02655452f, 0.06197703f, 0.04391309f, 0.07811897f, 0.29805461f, -0.08795194f, 0.00072740f, -0.06899454f, 
    -0.08270198f, 0.08575745f, -0.01235158f, 0.08281636f, 0.00125945f, -0.01659382f, 0.04780147f, -0.09230436f, 
    0.00308492f, -0.11582031f, 0.13600761f, -0.02139752f, -0.02667818f, -0.07853157f, 0.04710407f, -0.09719158f, 
    0.06166143f, -0.01183783f, -0.05168236f, 0.07346680f, 0.18394546f, -0.18828464f, 0.08201389f, 0.06765034f, 
    0.02716204f, 0.10459702f, 0.10103159f, 0.03715078f, -0.16041386f, 0.08146976f, 0.03873758f, 0.02005412f, 
    0.30113950f, 0.24744985f, -0.02959500f, -0.15593228f, -0.02237481f, 0.03890434f, -0.01047691f, 0.07602891f, 
    -0.05900238f, 0.10108940f, 0.00248128f, -0.02774776f, -0.11723410f, -0.14986035f, -0.09146743f, 0.03099216f, 
    -0.02135289f, 0.02433372f, -0.05429281f, 0.01348386f, 0.03195797f, -0.07980961f, 0.06958815f, 0.02636502f, 
    0.24073532f, -0.05805516f, -0.03426100f, -0.02874580f, 0.03138072f, 0.01761249f, 0.09497124f, 0.01157516f, 
    0.04683202f, 0.01392797f, 0.01885534f, -0.01216706f, 0.02451701f, 0.16786928f, -0.06651228f, -0.06485914f, 
    0.07613575f, 0.04788813f, 0.02748755f, -0.01649966f, -0.05155024f, 0.04052924f, -0.02348571f, 0.07396342f, 
    -0.06591137f, 0.11951493f, -0.06311774f, -0.05885274f, 0.00930686f, 0.03240658f, 0.02248509f, -0.09376983f, 
    -0.00743772f, -0.02762837f, -0.05778738f, 0.01160835f, 0.19936262f, 0.18534213f, 0.03243351f, -0.02028167f, 
    0.07591168f, -0.01970823f, -0.04173763f, -0.04853550f, -0.06452570f, 0.06463858f, 0.04146977f, -0.08853276f, 
    0.03397299f, -0.11551061f, 0.08073290f, -0.11526123f, -0.02477311f, 0.01834840f, 0.03680113f, 0.08086324f, 
    0.05542355f, 0.07650043f, 0.08637536f, 0.11833740f, 0.06977250f, 0.10410894f, 0.05789191f, 0.07362533f, 
    0.04449016f, -0.01084266f, 0.07249518f, 0.02844486f, -0.02747587f, 0.11878917f, 0.05605560f, 0.06271216f, 
    0.12617910f, 0.26129162f, -0.05885413f, -0.02675607f, -0.00208441f, -0.09924540f, 0.00264823f, -0.01186622f, 
    0.03107811f, 0.06514479f, 0.05266068f, -0.02370678f, 0.13109218f, 0.05949032f, -0.05812634f, -0.16839884f, 
    0.00680308f, 0.03819359f, -0.04897507f, 0.03536355f, 0.05162479f, 0.03643024f, -0.02238477f, -0.05909751f, 
    -0.13024510f, 0.27778208f, 0.10835118f, 0.03795907f, 0.11384154f, -0.00615087f, -0.11665652f, -0.01605829f, 
    -0.03342444f, -0.00975710f, -0.02583384f, -0.07384075f, 0.00256549f, -0.07853118f, 0.06036079f, -0.00349300f, 
    0.07718471f, 0.09228841f, 0.00576149f, 0.03639956f, 0.15755889f, -0.04384230f, -0.00137250f, 0.01553384f, 
    -0.05843165f, 0.01451126f, 0.08314366f, 0.02067266f, -0.02724889f, 0.04420062f, -0.00778238f, -0.00329890f, 
    -0.01787571f, 0.03206129f, -0.01166759f, 0.06168439f, -0.13024868f, 0.08759912f, 0.04875675f, 0.12787494f, 
    -0.01258756f, -0.00784869f, -0.00199992f, 0.07328366f, -0.02778192f, -0.01187052f, 0.03990271f, -0.12084135f, 
    0.20854817f, -0.00991091f, -0.14829898f, -0.10100847f, -0.03028705f, 0.08334970f, -0.01439816f, 0.06723478f, 
    0.06668866f, 0.04245104f, -0.03665852f, -0.07441209f, 0.14149776f, 0.06077607f, 0.10981328f, -0.00566972f, 
    0.05136900f, -0.00001020f, 0.11772185f, -0.04122302f, 0.01997157f, 0.05169718f, -0.04423532f, -0.05315780f, 
    0.15582594f, 0.23425841f, 0.05747432f, 0.08362970f, 0.06561366f, -0.03027470f, 0.00654264f, -0.02079961f, 
    -0.04224200f, 0.14854747f, 0.05704645f, 0.04818253f, 0.18557589f, 0.00105392f, -0.08922395f, -0.26096278f, 
    -0.02208291f, -0.10385935f, 0.06709191f, -0.02609301f, -0.03062496f, -0.01259566f, -0.00355705f, -0.02140993f, 
    0.22134501f, 0.05939605f, 0.05697121f, -0.00792202f, 0.01950229f, -0.01226388f, 0.03856541f, 0.12836030f, 
    0.01244982f, 0.01414298f, -0.02765193f, 0.05402451f, 0.02767405f, -0.12455817f, 0.08301830f, 0.05567264f, 
    -0.09953047f, 0.07226358f, -0.02289734f, 0.08179616f, 0.03258673f, 0.00532948f, 0.03922202f, 0.03351411f, 
    -0.15581305f, -0.06858419f, 0.09534106f, -0.07208990f, 0.12908019f, 0.00049634f, 0.01306776f, 0.02712415f, 
    0.00063177f, -0.06367274f, 0.04057458f, 0.00299875f, 0.08143921f, -0.00236098f, -0.04264810f, 0.17141807f, 
    0.02905297f, 0.05415253f, 0.07667691f, -0.06411830f, -0.09393172f, -0.00943626f, -0.05839507f, -0.00022339f, 
    0.19523816f, -0.08208669f, 0.13255455f, -0.10186036f, -0.01251106f, 0.01661166f, 0.05537242f, 0.03988945f, 
    -0.11087547f, -0.07717904f, -0.06224474f, 0.05369639f, 0.08918834f, -0.15709195f, -0.20818153f, -0.12901831f, 
    0.12449365f, -0.00528474f, 0.13079895f, -0.08015152f, 0.07261667f, 0.03468303f, -0.05720979f, 0.08069541f, 
    0.12616187f, 0.02442634f, -0.02481894f, -0.01178075f, -0.06953872f, -0.03820104f, 0.05851489f, 0.01494615f, 
    -0.02414872f, 0.07050703f, -0.02665883f, -0.01499457f, 0.06147145f, -0.15084103f, 0.00634085f, 0.07775187f, 
    0.03281683f, 0.04324744f, 0.04734773f, -0.04498531f, 0.10606577f, 0.02135093f, 0.12471681f, 0.04439304f, 
    0.06582020f, -0.02037782f, -0.08874081f, -0.11530326f, -0.11613735f, -0.04953409f, 0.01260280f, -0.09555614f, 
    -0.01695705f, -0.03742081f, -0.04832235f, -0.06478433f, 0.22331223f, -0.26204932f, 0.12559357f, 0.13219032f, 
    -0.10520469f, 0.05644377f, 0.05532204f, -0.00106098f, -0.03907814f, 0.05166421f, -0.03499133f, -0.01382401f, 
    -0.02625227f, -0.16593492f, 0.06461969f, 0.02762566f, -0.07509979f, 0.13797469f, 0.03785851f, 0.10447691f, 
    0.08086726f, 0.13517998f, 0.01415410f, 0.03279853f, -0.21245933f, -0.12056544f, 0.08929322f, -0.00782134f, 
    -0.05788727f, 0.05466778f, 0.01197873f, 0.07163081f, -0.04511397f, 0.00168902f, -0.02344135f, 0.09108419f, 
    -0.08158696f, -0.01209183f, -0.01479394f, -0.00689940f, 0.03660757f, 0.00366041f, -0.00155529f, 0.04389204f, 
    0.04239010f, 0.01072659f, 0.04889552f, 0.03486368f, 0.08311674f, 0.01676325f, -0.19563390f, 0.00863409f, 
    -0.02803997f, 0.01334467f, 0.02489474f, 0.17099085f, 0.03959466f, 0.02406244f, 0.03201862f, 0.03911323f, 
    -0.20083010f, 0.25541484f, 0.04064227f, -0.09425591f, 0.13143247f, -0.01170090f, -0.03811283f, -0.00350701f, 
    0.06952360f, 0.12549368f, 0.04954336f, -0.04016066f, -0.03789937f, -0.00551508f, 0.06029159f, -0.09045983f, 
    -0.02494118f, -0.04902877f, 0.02183546f, -0.01234597f, 0.07530696f, -0.00565788f, 0.01591469f, -0.07057842f, 
    0.02999055f, -0.11169033f, -0.05151011f, 0.16312633f, -0.02783643f, -0.03104272f, -0.02351876f, 0.04405467f, 
    0.13181274f, 0.03409954f, 0.12289153f, 0.10022604f, -0.09492816f, -0.14498948f, -0.14191951f, -0.08957416f, 
    0.04552768f, 0.06049729f, 0.05306332f, -0.05144246f, -0.08206578f, -0.07174802f, -0.01034008f, -0.01098583f, 
    0.12763357f, -0.04017877f, -0.04028026f, 0.02348594f, -0.07600845f, -0.04810899f, -0.04229164f, -0.00152146f, 
    0.03349752f, 0.00924249f, -0.12616701f, 0.15166214f, -0.08399419f, -0.07448743f, 0.08732527f, -0.08869176f, 
    0.07986366f, 0.06561726f, 0.02859356f, 0.08667716f, -0.01779900f, 0.02281697f, 0.06017153f, -0.01903322f, 
    -0.05871768f, -0.19687125f, 0.01692712f, -0.04882358f, 0.08907522f, -0.12973402f, 0.04679419f, -0.02875049f, 
    0.05845125f, 0.07470742f, 0.06134040f, -0.07222991f, 0.03788939f, 0.18521710f, 0.03629402f, -0.03272614f, 
    0.11564521f, 0.08675206f, -0.02437071f, 0.03962108f, 0.03213771f, -0.06509198f, 0.02415668f, -0.03130804f, 
    0.21011192f, 0.25450468f, 0.04767448f, -0.11829346f, 0.04140080f, -0.02306064f, -0.03042703f, -0.02153208f, 
    0.06162243f, 0.06863344f, -0.09550933f, -0.01470663f, -0.15708299f, -0.18670167f, -0.01172023f, -0.12442945f, 
    0.00563421f, 0.01246303f, -0.03001416f, -0.02698820f, 0.01627480f, -0.02646950f, -0.02264141f, -0.03228600f, 
    0.36165133f, -0.07945012f, 0.04218246f, 0.01586660f, 0.00718052f, -0.05085443f, -0.02952944f, -0.01973045f, 
    0.02840451f, -0.00854227f, -0.06906924f, -0.03960301f, -0.01250619f, 0.14943737f, 0.00658914f, -0.02083630f, 
    0.02469238f, 0.01054885f, 0.01231736f, 0.02704472f, 0.13058455f, 0.00134788f, 0.09364498f, 0.03554304f, 
    0.07859170f, 0.05740236f, 0.06268855f, -0.01392438f, -0.02131944f, -0.02633869f, -0.00946604f, -0.02019599f, 
    -0.00301339f, 0.06563230f, 0.06769810f, -0.05030017f, -0.04696330f, 0.02010552f, 0.11381086f, -0.13329436f, 
    0.05752876f, 0.09056614f, 0.04251087f, -0.06215217f, 0.10676043f, 0.00093289f, 0.03578658f, 0.03260013f, 
    0.04301935f, 0.17151675f, 0.05049092f, -0.09984946f, 0.04634136f, -0.00780775f, -0.00238656f, 0.04359677f, 
    0.10380046f, -0.03033212f, -0.00522407f, -0.00215701f, 0.00564322f, 0.05923875f, -0.02089047f, -0.08940317f, 
    0.03405764f, -0.07045198f, 0.09730756f, 0.03669954f, 0.04181682f, 0.00372364f, -0.01466759f, 0.03353058f, 
    0.14324547f, 0.20767997f, 0.12749784f, -0.02739962f, 0.03866793f, 0.03040342f, -0.03473001f, 0.03082135f, 
    -0.04782715f, 0.07953063f, -0.04360008f, 0.05662251f, 0.01893065f, 0.15070696f, -0.18939410f, -0.05086475f, 
    -0.15241361f, 0.00350363f, -0.10898929f, -0.11770219f, 0.04984058f, 0.06857640f, 0.07462655f, -0.05565377f, 
    0.27261332f, -0.17521189f, 0.04667701f, -0.00561142f, -0.06907527f, 0.02219048f, 0.06964335f, 0.11568610f, 
    0.09588473f, -0.07442437f, -0.01435524f, 0.03574343f, -0.04399138f, -0.04715981f, -0.13360895f, 0.06273358f, 
    0.06893218f, -0.05064245f, 0.05819228f, -0.07491508f, -0.18918411f, -0.01545636f, 0.02201945f, -0.02096782f, 
    -0.01239630f, -0.01414770f, 0.02365916f, 0.00328601f, -0.01056351f, 0.01290739f, 0.02179910f, 0.01903956f, 
    -0.00804730f, 0.01134479f, -0.00876088f, -0.00673133f, 0.02214117f, 0.00226899f, -0.00073255f, 0.01505957f, 
    -0.00271972f, 0.01600778f, -0.01783089f, -0.00083796f, 0.00986983f, 0.00233439f, -0.02333088f, -0.02111644f, 
    0.01296762f, 0.00170044f, -0.00419607f, 0.02025442f, 0.03347531f, -0.00859181f, 0.02756629f, 0.01341680f, 
    0.02141508f, 0.02964269f, -0.04579175f, 0.01642876f, -0.04431572f, 0.01808235f, 0.01099703f, -0.02575917f, 
    0.01103784f, 0.01273542f, 0.01009243f, -0.02990351f, -0.03269924f, -0.04364279f, -0.02667635f, 0.01984928f, 
    -0.00232825f, 0.03128644f, -0.01240290f, -0.03504298f, 0.02182782f, -0.03251320f, 0.02175386f, -0.01081723f, 
    0.01490958f, -0.00760333f, -0.01148271f, -0.00601530f, 0.01614391f, 0.00117343f, 0.01331821f, 0.00545204f, 
    0.03208101f, -0.01927195f, 0.02492344f, -0.02183694f, -0.02115860f, 0.01218235f, -0.01745697f, 0.00397999f, 
    0.01424605f, -0.03921926f, -0.01061117f, 0.02053617f, -0.00680722f, 0.01422453f, -0.00388531f, -0.01571624f, 
    -0.02052767f, -0.03780686f, 0.01435313f, -0.03402283f, -0.01917521f, 0.02366103f, 0.00847536f, -0.02744766f, 
    0.01589172f, -0.04077918f, 0.02569806f, 0.02966529f, -0.02788340f, 0.01473211f, 0.00239192f, -0.01249020f, 
    -0.00856218f, -0.01329136f, 0.00194834f, -0.00972196f, 0.02734093f, -0.01181582f, -0.00592649f, 0.01571954f, 
    -0.01080680f, 0.00820231f, -0.00468180f, -0.00371045f, -0.02731046f, 0.03618803f, -0.00070873f, 0.02418232f, 
    0.00619373f, 0.01502218f, -0.03876409f, -0.00522916f, 0.03518741f, -0.00304397f, 0.02532473f, -0.00515369f, 
    -0.01571794f, -0.01732033f, 0.00814715f, 0.03347591f, -0.00466399f, -0.00186388f, -0.00179716f, 0.02839936f, 
    0.00296501f, -0.00978702f, -0.00098752f, -0.00457348f, -0.01984724f, -0.03103908f, 0.00272937f, -0.03183033f, 
    -0.02885392f, -0.00399593f, 0.02038061f, -0.03378130f, -0.02250286f, -0.03518960f, -0.00300204f, -0.01540458f, 
    -0.00211434f, -0.02767615f, -0.00715022f, 0.02231185f, -0.00213373f, 0.01408926f, -0.03146840f, 0.02799596f, 
    -0.03967151f, -0.02028848f, -0.00395118f, -0.02192898f, 0.01758994f, 0.02181194f, -0.00963139f, 0.02392312f, 
    -0.02976597f, 0.02847843f, 0.00568875f, 0.02197093f, -0.02800050f, -0.02108918f, 0.00436379f, -0.02586076f, 
    0.03390090f, -0.03553490f, -0.02137378f, 0.00305893f, -0.02585015f, -0.01175389f, -0.02134517f, 0.02239503f, 
    -0.02879455f, 0.02773446f, 0.02720851f, 0.01930538f, 0.01931825f, -0.02583038f, 0.01611165f, -0.02763979f, 
    0.03003735f, 0.01354172f, 0.00641129f, -0.02663759f, -0.00727945f, 0.01235885f, -0.01934212f, -0.01625099f, 
    -0.00368765f, 0.01723550f, -0.03068102f, -0.02536397f, 0.00044450f, -0.00254370f, 0.01937120f, 0.01958421f, 
    -0.01373129f, 0.01983145f, 0.01745520f, 0.00127986f, 0.01895918f, -0.03404399f, -0.02051103f, -0.02542169f, 
    0.00804464f, -0.03864447f, -0.02944113f, 0.01204598f, -0.03511949f, -0.00422211f, 0.00697611f, 0.02464473f, 
    0.01451588f, -0.00322035f, -0.00038152f, 0.00923852f, -0.01546547f, 0.01589501f, -0.02691622f, 0.02726792f, 
    -0.01224321f, -0.01568122f, 0.01644666f, -0.03402169f, -0.03313721f, -0.01322216f, -0.01203257f, 0.01062463f, 
    0.02042279f, -0.02575069f, 0.01627258f, 0.02961251f, 0.00041065f, -0.03852565f, 0.00986317f, -0.00626232f, 
    0.02157168f, 0.02058035f, 0.01904707f, -0.00590707f, 0.01314692f, 0.00512092f, 0.00146284f, 0.03169101f, 
    -0.03647313f, 0.02620591f, -0.00781810f, -0.00603987f, -0.02216725f, 0.01541055f, 0.00675004f, 0.00979040f, 
    0.03613782f, -0.02981615f, -0.01118201f, 0.01672063f, -0.02407525f, -0.01292935f, 0.00907052f, -0.03172434f, 
    0.01223913f, 0.01425176f, -0.01955002f, -0.01499954f, 0.00511828f, -0.01002931f, -0.00573238f, -0.00591850f, 
    0.00725338f, 0.02531696f, 0.01769015f, 0.03449873f, -0.00756658f, 0.02365302f, 0.02293455f, -0.02939999f, 
    0.00430531f, -0.01047941f, 0.03051712f, -0.03223842f, 0.02622548f, -0.01254117f, 0.01608201f, -0.02734794f, 
    -0.03000478f, -0.04072956f, 0.01412572f, 0.01897573f, 0.00931925f, -0.00354718f, 0.03383841f, 0.02063154f, 
    0.00208475f, -0.04177273f, -0.00207869f, 0.02268744f, 0.01107453f, 0.03150133f, 0.02078123f, 0.00607977f, 
    0.03285414f, 0.02429602f, 0.03678626f, -0.02871867f, 0.02261096f, 0.01106341f, -0.01863038f, -0.02680818f, 
    0.00690911f, 0.00025777f, -0.01125266f, -0.00279410f, -0.00727945f, -0.04813923f, 0.01248376f, 0.03085902f, 
    -0.02470469f, 0.00175808f, 0.02675073f, -0.02148431f, -0.01437433f, -0.01992591f, 0.00016544f, 0.01668602f, 
    0.01310019f, 0.02507866f, 0.03117303f, -0.01996334f, -0.00090868f, 0.01542326f, -0.01224818f, 0.01527346f, 
    -0.01937524f, -0.02464762f, -0.00252841f, -0.02568470f, -0.01220188f, 0.03436458f, -0.00013974f, 0.01477418f, 
    -0.01278898f, 0.01570372f, 0.02645356f, -0.03007346f, 0.00565602f, -0.00235195f, 0.00806834f, 0.00648942f, 
    -0.01097277f, 0.00162827f, -0.02703649f, -0.00318424f, 0.01522292f, -0.01451085f, 0.00434845f, -0.01827620f, 
    -0.00389948f, 0.00811527f, -0.03033841f, -0.02572164f, 0.02736197f, -0.02969992f, -0.00499062f, -0.01493874f, 
    0.01324081f, 0.03315635f, -0.02224434f, 0.00151251f, 0.03318673f, 0.02365959f, 0.02929677f, -0.04086454f, 
    0.01421577f, -0.03091519f, 0.01514683f, 0.01726350f, 0.01759447f, -0.03215528f, 0.00451216f, -0.03448242f, 
    0.00697524f, 0.00045849f, 0.02277065f, 0.01450000f, 0.01620189f, -0.01545827f, 0.01830112f, -0.01974605f, 
    -0.02233793f, -0.03049295f, -0.02428435f, 0.01046956f, -0.01398201f, 0.02575381f, -0.00575849f, 0.02005237f, 
    0.02296117f, -0.00396103f, -0.00186804f, 0.02740700f, 0.00738105f, -0.03433690f, 0.01439935f, -0.02451465f, 
    0.00801307f, 0.00814044f, -0.01816765f, -0.00606769f, 0.02084314f, -0.03659296f, -0.02411081f, 0.02489541f, 
    -0.00543733f, -0.01049793f, -0.02688143f, 0.03726155f, -0.00259154f, -0.01741994f, -0.02050404f, 0.00091156f, 
    -0.00328457f, -0.02991173f, 0.03608108f, -0.00322063f, -0.03450815f, 0.01661000f, -0.01856687f, -0.03702597f, 
    -0.01105186f, -0.02161392f, 0.02351534f, 0.00731489f, -0.00290342f, 0.01677288f, -0.00648311f, 0.01120320f, 
    -0.03397687f, -0.03551525f, -0.03073401f, 0.00382414f, 0.03103953f, -0.03737691f, 0.02453274f, 0.00545000f, 
    0.01321475f, 0.00669002f, -0.02330909f, -0.01562451f, 0.01522021f, -0.03605287f, -0.00408756f, -0.01425284f, 
    0.02316729f, -0.00087719f, 0.01197810f, 0.00622145f, 0.00699810f, -0.01405961f, -0.00010943f, -0.00191599f, 
    -0.00568799f, -0.01701486f, -0.00864787f, -0.00791056f, -0.01064538f, 0.00761371f, -0.00140260f, -0.00404994f, 
    0.02106231f, 0.00847025f, -0.01309855f, -0.03066869f, 0.02869615f, -0.01470630f, -0.03453566f, -0.00513515f, 
    -0.02787022f, -0.03750242f, -0.02697689f, -0.00979374f, -0.00261825f, -0.01088385f, -0.00984398f, 0.01687127f, 
    0.02222692f, -0.02461753f, -0.00830182f, 0.01416148f, -0.00609412f, -0.00508233f, -0.03878572f, 0.00494369f, 
    0.01859523f, -0.03009513f, 0.03261917f, -0.03451711f, 0.01618927f, -0.01086836f, 0.02720209f, 0.01789049f, 
    0.02122248f, -0.01701291f, 0.02117702f, 0.00449307f, -0.01119026f, -0.03727536f, -0.01803791f, -0.03187126f, 
    0.02894166f, 0.01737139f, -0.04487299f, 0.00402834f, -0.00199967f, -0.00795227f, -0.01385682f, 0.01990236f, 
    -0.01041803f, 0.00619383f, -0.00522565f, -0.02746692f, -0.02865781f, 0.01881158f, 0.00387284f, -0.01050765f, 
    -0.00309199f, -0.00576378f, -0.01875450f, -0.02772531f, 0.01509362f, 0.02488605f, -0.02550817f, 0.02916828f, 
    -0.02463571f, 0.00383994f, -0.00373000f, 0.02125322f, 0.01898933f, 0.01758792f, 0.01281295f, 0.00817335f, 
    -0.01513090f, -0.02158002f, 0.02681977f, -0.00383334f, 0.02721930f, 0.00635133f, -0.02192091f, -0.00049641f, 
    -0.01671472f, -0.02288662f, -0.00498496f, 0.00460840f, -0.01965984f, -0.01874179f, 0.01245760f, 0.00867348f, 
    0.02417649f, -0.00896094f, -0.02875173f, -0.00158352f, -0.00317644f, -0.00771627f, 0.02551742f, -0.03879376f, 
    -0.03853717f, 0.02091833f, 0.01760605f, -0.02515503f, -0.02118351f, -0.00277658f, 0.00078659f, -0.03841548f, 
    -0.02925893f, -0.00699388f, -0.02596278f, 0.02416249f, 0.00835786f, -0.00523707f, -0.01301961f, -0.00733857f, 
    -0.01048745f, 0.01181083f, -0.00873411f, -0.02833062f, 0.01146354f, 0.01966475f, 0.00598693f, -0.01648639f, 
    -0.00751147f, -0.01228641f, -0.03618841f, 0.02357188f, -0.01192945f, -0.00532808f, 0.00204654f, 0.01442988f, 
    0.01605720f, 0.02406848f, -0.01297417f, -0.00794241f, 0.02830895f, 0.01560718f, 0.01856842f, -0.01160393f, 
    0.03046643f, -0.00487755f, 0.00752703f, -0.02195836f, 0.00016001f, 0.01058186f, 0.00391583f, -0.01665507f, 
    -0.03715391f, -0.01124084f, -0.02033477f, -0.02823391f, -0.00510365f, -0.01738896f, -0.01896314f, 0.00198057f, 
    0.02225759f, -0.00930853f, 0.00026081f, 0.01354614f, -0.02506599f, 0.01211981f, 0.02070334f, -0.02702748f, 
    -0.00146792f, -0.00551549f, -0.01801562f, -0.02351787f, -0.02646434f, -0.01205193f, -0.00214140f, 0.01657407f, 
    -0.02207800f, -0.01721106f, 0.00558985f, -0.01487501f, -0.00993736f, 0.00116684f, 0.00728654f, -0.02360194f, 
    -0.02902083f, -0.02504585f, 0.02537416f, 0.02300392f, -0.02013049f, 0.01424251f, -0.03803274f, -0.01445858f, 
    0.03087491f, -0.01771373f, 0.02667558f, 0.02162180f, 0.01566073f, 0.01643208f, 0.00626762f, 0.02711523f, 
    -0.02012641f, 0.00828769f, 0.00713758f, 0.00248333f, -0.02271370f, -0.04169374f, 0.01676578f, 0.01973564f, 
    0.03743771f, -0.02975234f, 0.00244530f, -0.01967132f, -0.01086805f, -0.02074548f, -0.02336548f, 0.00783627f, 
    0.02085856f, -0.01838280f, -0.04072713f, 0.01450904f, -0.02792940f, -0.04376881f, -0.02859003f, 0.02516157f, 
    0.00067045f, -0.00200262f, 0.01800025f, 0.01990430f, 0.02041202f, 0.02207520f, -0.02540804f, 0.02145815f, 
    -0.00747498f, 0.00376422f, -0.00565725f, 0.01029954f, -0.00770994f, -0.00104905f, 0.02671298f, 0.00196747f, 
    0.00119444f, -0.03604353f, -0.00569490f, -0.01034974f, -0.00083851f, -0.02631881f, -0.02944397f, 0.01113367f, 
    -0.00124561f, -0.00887873f, -0.01742096f, 0.02017804f, -0.01385331f, -0.00029395f, 0.00489669f, 0.00004561f, 
    0.00406551f, 0.02247036f, -0.00236245f, -0.01146770f, -0.00713277f, 0.00573038f, -0.01963488f, 0.02676945f, 
    0.00535708f, 0.01088257f, 0.02289245f, 0.00666630f, 0.00167881f, -0.05479481f, -0.04269287f, -0.00472847f, 
    -0.03476527f, -0.04791051f, 0.00675455f, -0.03042879f, -0.03013228f, 0.01832838f, -0.01216601f, -0.02580736f, 
    0.02283471f, -0.01502736f, 0.03689151f, 0.03154421f, -0.01885945f, -0.04304626f, 0.01337559f, -0.00363788f, 
    0.00847812f, 0.00754529f, 0.00119044f, 0.01752767f, 0.00261831f, -0.00855370f, -0.02734187f, -0.01194086f, 
    -0.00581002f, -0.03060211f, -0.01391525f, -0.02900826f, -0.02036217f, -0.00836589f, -0.03045130f, -0.02045137f, 
    0.31082448f, -0.20615378f, -0.00202352f, 0.20226730f, -0.13771665f, 0.07442990f, 0.10999738f, -0.01561822f, 
    -0.01595262f, 0.03537860f, 0.07457389f, 0.00945783f, 0.28094810f, 0.08940130f, 0.07990569f, 0.23644750f, 
    -0.07132304f, -0.13734299f, -0.07576165f, 0.00288304f, 0.08169763f, 0.01115936f, 0.02132561f, -0.09283213f, 
    -0.06171071f, -0.13945377f, 0.04417707f, 0.04608950f, 0.04229818f, 0.03119391f, 0.04860263f, -0.02469705f, 
    -0.01374695f, 0.06616419f, -0.04172390f, -0.00374334f, 0.03434948f, -0.10899156f, -0.06904152f, 0.18455896f, 
    0.06608479f, 0.09310688f, 0.11418293f, 0.08860347f, 0.05709158f, 0.05578775f, -0.00962145f, 0.15212570f, 
    0.31026748f, 0.11053396f, -0.04333346f, -0.07455323f, -0.11481268f, 0.05368112f, -0.06236076f, 0.08975923f, 
    0.07633956f, -0.02766439f, 0.06072482f, 0.13521388f, 0.27209470f, 0.12870273f, -0.01018093f, -0.08247551f, 
    0.02335169f, -0.05714277f, -0.02036274f, 0.12306567f, 0.09253991f, 0.08872896f, -0.01937468f, 0.03588644f, 
    0.32574987f, 0.05688801f, 0.04426219f, -0.04314729f, 0.00660904f, 0.07997268f, -0.00188858f, 0.00836888f, 
    0.06329075f, 0.03096464f, 0.06888699f, 0.00433024f, 0.06997314f, -0.13238060f, 0.13019921f, -0.12944227f, 
    -0.03341820f, 0.01494157f, 0.01665047f, -0.00129019f, 0.08947200f, -0.03179755f, -0.00850929f, 0.05076808f, 
    -0.07082761f, -0.05554517f, 0.20519216f, -0.22340454f, 0.06474618f, -0.05007642f, 0.06335928f, 0.03537618f, 
    -0.08416566f, 0.00638034f, 0.06295668f, 0.06130923f, 0.22930752f, 0.11993656f, -0.13055816f, 0.05153207f, 
    -0.00838548f, 0.02504645f, -0.05083733f, 0.05769904f, 0.01589813f, -0.01732753f, 0.06712919f, 0.02321715f, 
    0.02912981f, -0.02052522f, -0.10942535f, 0.16806109f, 0.03524254f, -0.03125732f, -0.03028852f, -0.02061732f, 
    0.04585331f, 0.01151162f, 0.00482331f, 0.05854439f, 0.02518884f, 0.01886704f, 0.04088853f, -0.04929038f, 
    0.00347412f, 0.01240385f, 0.01788308f, 0.00705689f, 0.10543001f, 0.10091386f, -0.01046254f, 0.02513294f, 
    0.01640957f, -0.00091886f, 0.17210340f, 0.04382920f, 0.05451507f, 0.10003351f, 0.00268453f, 0.05550581f, 
    0.07467371f, 0.06398199f, -0.00433334f, -0.02877189f, -0.03907315f, 0.05360936f, -0.15195304f, 0.31033751f, 
    -0.01142154f, 0.11858824f, 0.09233887f, -0.18636084f, 0.06303182f, -0.05521606f, 0.06243503f, 0.10701387f, 
    0.08528460f, 0.11769677f, 0.13014276f, -0.06990830f, -0.02760291f, -0.01819576f, 0.08594934f, 0.06575631f, 
    0.06350648f, 0.06440590f, 0.02294619f, -0.00415130f, -0.13377121f, 0.03671432f, 0.03807075f, -0.00555263f, 
    -0.01710857f, 0.11792183f, -0.02108332f, -0.06158347f, 0.03402498f, 0.04789960f, 0.08462773f, 0.06534719f, 
    0.01172744f, -0.01036150f, 0.07890458f, 0.04548516f, 0.02185141f, 0.11171739f, 0.13470729f, -0.12689610f, 
    0.10767748f, 0.06925524f, -0.03314855f, 0.16403785f, -0.28653720f, 0.15769188f, -0.04021540f, 0.05608530f, 
    0.03497161f, 0.06308933f, 0.05245187f, -0.06019372f, -0.00204095f, 0.02368321f, 0.04059512f, -0.03343064f, 
    0.07737318f, -0.15128542f, 0.11675232f, -0.06184931f, 0.02244281f, 0.04224032f, 0.00395241f, 0.08082894f, 
    0.01506117f, -0.00439745f, 0.08622359f, 0.05392636f, -0.07768946f, -0.12027162f, 0.00319599f, -0.02358015f, 
    -0.02103433f, 0.00716504f, 0.09679451f, 0.03246709f, 0.04001048f, 0.15759395f, 0.04681586f, 0.11211251f, 
    -0.06095302f, 0.07764424f, 0.01035728f, 0.07418121f, 0.00876598f, 0.02769235f, 0.00682683f, 0.09622726f, 
    -0.03907923f, -0.00529155f, 0.01839119f, -0.05820428f, 0.08847468f, -0.17003505f, 0.05743054f, -0.02214133f, 
    -0.03568223f, -0.04201007f, -0.03174337f, 0.06300400f, 0.09152670f, 0.03325190f, -0.01839282f, 0.05879642f, 
    -0.12912768f, -0.00757951f, -0.04228543f, 0.09382003f, 0.05266945f, 0.10248929f, 0.01720072f, 0.03614023f, 
    0.01153288f, 0.04523288f, -0.03404142f, 0.06914721f, -0.00742803f, -0.20164657f, 0.09626067f, -0.12753934f, 
    -0.03029415f, 0.02064523f, 0.07216296f, 0.03955218f, 0.07991304f, 0.06453110f, 0.04430026f, 0.03942120f, 
    -0.03826870f, 0.06700802f, 0.03332626f, 0.12322507f, -0.08660734f, 0.07764748f, -0.00383868f, -0.06657607f, 
    0.01570184f, 0.08905156f, 0.07810805f, 0.12018516f, -0.13994001f, -0.01183053f, -0.16133848f, 0.06594740f, 
    -0.05138396f, -0.05759877f, 0.01484149f, -0.03260298f, 0.01423852f, 0.00885477f, 0.02735280f, 0.00681471f, 
    0.29804307f, 0.02769355f, 0.01301024f, 0.05402537f, 0.08706127f, 0.05040749f, -0.00405174f, 0.07443837f, 
    0.07392761f, 0.06825148f, -0.02352211f, -0.02005600f, -0.04325557f, 0.13086715f, -0.06472426f, 0.27464357f, 
    -0.07985938f, -0.03557764f, 0.09997465f, 0.06484370f, -0.08195386f, 0.10128036f, 0.04271077f, -0.05337239f, 
    -0.35509381f, -0.01088589f, -0.05927078f, 0.21940614f, -0.05070353f, 0.00999616f, 0.04690914f, -0.05100932f, 
    -0.00219772f, 0.00108582f, -0.03360028f, 0.02960604f, 0.31966478f, 0.12157501f, 0.04530007f, -0.09134108f, 
    -0.05309072f, -0.06121508f, 0.10550507f, 0.10645328f, -0.01451017f, -0.01536667f, 0.00743509f, 0.02926302f, 
    0.29736191f, 0.14561479f, 0.03465090f, 0.00649904f, -0.04882424f, -0.06312616f, 0.05950799f, 0.10624857f, 
    -0.00476706f, 0.14153169f, -0.05581402f, 0.07816245f, -0.02338825f, 0.16910370f, 0.02266549f, -0.00339596f, 
    -0.12099610f, 0.05408728f, 0.07153794f, 0.02244679f, 0.08563530f, 0.04381147f, 0.09795807f, 0.05261737f, 
    0.05039077f, -0.23985197f, 0.01268735f, -0.01444969f, -0.01064620f, 0.01107132f, 0.09494982f, 0.11660359f, 
    0.00269726f, 0.07261492f, 0.12026939f, 0.09986421f, 0.05181561f, 0.14070927f, -0.00269942f, -0.13595858f, 
    0.09850708f, 0.05596763f, 0.08722145f, 0.05278800f, 0.01765989f, 0.03057666f, 0.01567766f, 0.11714383f, 
    0.29920962f, -0.17151302f, 0.16003054f, 0.12057305f, -0.05026594f, 0.14204545f, 0.12363596f, 0.05641353f, 
    -0.04324531f, -0.04465808f, 0.03468156f, 0.10592061f, 0.06265485f, 0.08440416f, 0.00191238f, -0.05667199f, 
    0.05996400f, -0.02812177f, 0.09727493f, -0.00355377f, 0.01252809f, -0.01595606f, 0.05714779f, 0.05140873f, 
    0.25667071f, 0.05000839f, -0.02593061f, -0.14952551f, 0.01047604f, -0.01641036f, 0.12406158f, 0.04765378f, 
    0.05608495f, 0.03782564f, -0.03091017f, 0.07784743f, 0.06334823f, 0.11779565f, 0.10874759f, -0.10526821f, 
    0.07530330f, -0.00661025f, -0.01872947f, -0.01322525f, 0.03351460f, 0.01638401f, -0.02072886f, 0.06687521f, 
    0.04914064f, 0.04841610f, 0.03919569f, -0.12688546f, 0.05073703f, 0.01261973f, 0.10626451f, 0.07465181f, 
    -0.01132798f, 0.09108146f, 0.10278035f, 0.03551377f, 0.08820900f, 0.03706405f, 0.04666448f, 0.17738432f, 
    -0.08887509f, 0.01528515f, -0.02819928f, 0.00294825f, -0.00825643f, 0.02955735f, -0.02086851f, -0.00152345f, 
    0.07162272f, -0.03685421f, 0.08749830f, -0.24123155f, -0.11131635f, 0.01009067f, 0.03357654f, 0.02811254f, 
    0.05673762f, 0.06937182f, 0.02040853f, 0.08304292f, -0.04446747f, -0.05026855f, -0.08274174f, 0.16437833f, 
    -0.10571302f, 0.08578424f, 0.01313408f, 0.02741338f, -0.03596492f, 0.06304438f, 0.04792883f, 0.07446733f, 
    0.03564471f, -0.00380029f, 0.11557671f, -0.14351979f, 0.07741954f, -0.00541812f, 0.02528055f, -0.02799033f, 
    0.07521921f, 0.08374708f, 0.04442521f, 0.06907295f, 0.14882307f, 0.05007374f, -0.00460962f, -0.11382481f, 
    -0.03267896f, -0.04717577f, 0.02479739f, 0.03701162f, 0.04738518f, -0.02498996f, 0.01385301f, 0.06520524f, 
    0.27442846f, 0.00057010f, -0.03748037f, 0.20744057f, 0.05519628f, 0.15287036f, 0.03889323f, 0.08198255f, 
    0.02403848f, -0.00807559f, 0.02056758f, -0.09028067f, -0.08194853f, -0.09242297f, 0.09828542f, -0.08911151f, 
    0.01283550f, -0.00407231f, 0.02746671f, 0.07889408f, 0.04611532f, -0.01686527f, 0.01815409f, -0.02521242f, 
    0.08041033f, 0.10442657f, 0.00004568f, -0.07136043f, 0.03013554f, -0.03552628f, -0.03373507f, -0.03421272f, 
    0.12456343f, 0.08132470f, 0.00469034f, -0.02981309f, 0.09766095f, 0.03873201f, 0.03792918f, -0.11396579f, 
    -0.03519251f, -0.01064109f, 0.05117840f, 0.06704288f, 0.02936225f, 0.09144408f, 0.00967002f, -0.02863295f, 
    0.33750936f, 0.15735355f, -0.30663151f, 0.16731246f, 0.09296051f, -0.00215310f, 0.03504498f, 0.11134965f, 
    0.01964645f, -0.01892237f, -0.04269574f, 0.00108607f, 0.18552110f, -0.23590261f, 0.04517435f, 0.19684701f, 
    0.03139429f, 0.05613511f, 0.04592034f, 0.04818458f, -0.03603817f, 0.04276597f, 0.08566672f, 0.02554082f, 
    0.16337509f, -0.08375723f, -0.00116144f, -0.00829768f, 0.04948246f, -0.05696866f, -0.08122766f, 0.02978985f, 
    -0.01928988f, 0.05523432f, -0.00922258f, -0.00016703f, -0.08164781f, 0.14765510f, 0.12719172f, -0.02197558f, 
    0.02604709f, 0.11812119f, 0.01663916f, 0.03878063f, 0.12459558f, 0.02671117f, 0.02378894f, 0.00952076f, 
    -0.09706226f, 0.06774225f, 0.01703133f, 0.08249453f, 0.02688892f, 0.00409403f, 0.10890228f, 0.03273850f, 
    0.05491448f, 0.07126449f, -0.03876962f, -0.03960603f, -0.10238015f, -0.16050886f, -0.10614017f, -0.02938184f, 
    -0.07640208f, 0.00445411f, -0.01726916f, 0.05677932f, 0.03912213f, 0.01284043f, 0.04084390f, 0.00060881f, 
    0.28828374f, -0.07341264f, -0.06222407f, 0.30891737f, -0.04421984f, 0.05350072f, -0.02044949f, 0.12204428f, 
    0.02244015f, -0.01825866f, -0.06509510f, -0.02908546f, 0.03574983f, 0.01099549f, 0.01842336f, 0.02943725f, 
    0.03089072f, -0.00337739f, 0.00446289f, 0.02508865f, 0.05169919f, 0.03882255f, 0.07703345f, 0.08437964f, 
    -0.10268801f, 0.13395341f, -0.06459070f, 0.11602958f, 0.07528804f, 0.02489685f, -0.00574332f, -0.03176995f, 
    0.08325400f, -0.03794442f, -0.02771769f, 0.05106685f, 0.16938673f, -0.05795815f, 0.17943732f, -0.36366138f, 
    0.02231419f, 0.04505118f, 0.06783853f, 0.01137721f, 0.08249791f, 0.03027729f, 0.05288177f, 0.05545990f, 
    -0.12771216f, 0.04114584f, -0.06164603f, 0.14437857f, -0.08139221f, -0.07011091f, 0.02341667f, 0.04636770f, 
    -0.02089708f, -0.00377408f, 0.05274329f, 0.09901284f, -0.18808329f, -0.12739223f, 0.07198413f, -0.14267068f, 
    -0.09532217f, -0.03001416f, 0.02950985f, -0.02839775f, 0.01271317f, 0.02017014f, 0.04620620f, -0.01589926f, 
    -0.03114827f, -0.10345551f, 0.03835275f, 0.07670519f, -0.01857240f, 0.02448684f, -0.01947036f, 0.08666836f, 
    0.00791517f, 0.08252535f, 0.01073282f, 0.04301421f, 0.22606553f, 0.03578467f, 0.05926758f, 0.14614727f, 
    -0.11391210f, 0.02711671f, -0.12953942f, 0.05650486f, 0.06627764f, 0.06621333f, 0.03236193f, 0.18387508f, 
    0.30283222f, 0.14793810f, -0.13072553f, 0.09177622f, -0.01553781f, 0.06371750f, -0.00933804f, 0.08902586f, 
    0.06530194f, 0.03866489f, 0.05980957f, 0.10400517f, -0.09805415f, 0.10806374f, -0.02128475f, -0.04065349f, 
    0.00423389f, 0.09300538f, 0.09839427f, 0.04025755f, -0.05331334f, 0.01724969f, -0.02744013f, 0.01779748f, 
    -0.03873431f, -0.03499530f, -0.01321948f, 0.02084363f, -0.03233767f, 0.01204874f, -0.01921700f, -0.02053921f, 
    0.02360788f, 0.00915428f, -0.01921062f, -0.02136847f, -0.00791531f, 0.01946034f, -0.01089710f, 0.01043129f, 
    0.02240884f, -0.02732418f, -0.01758103f, -0.02294918f, -0.01462766f, 0.01232484f, 0.01080052f, 0.00610093f, 
    0.00307905f, 0.01466980f, 0.00670608f, 0.00461510f, 0.01457639f, 0.02523746f, -0.01881490f, -0.03676770f, 
    0.00968324f, -0.02268221f, -0.02704975f, -0.04100486f, 0.03040352f, -0.01147831f, 0.02694361f, 0.00203065f, 
    -0.01150396f, -0.00188402f, 0.00256532f, 0.00253113f, -0.00193901f, -0.02605454f, -0.01973637f, -0.02052405f, 
    -0.03321477f, -0.04062991f, -0.02259514f, 0.01517596f, -0.01783855f, -0.00924617f, -0.01883126f, -0.03315892f, 
    -0.01571539f, -0.00105554f, 0.00411052f, -0.01650940f, -0.01823679f, -0.03748750f, 0.01811920f, 0.01484294f, 
    0.00999848f, -0.01208002f, -0.01556565f, -0.02665962f, -0.02279376f, -0.01112519f, 0.02378048f, -0.00469742f, 
    -0.01775384f, -0.01885761f, 0.02353589f, -0.01011837f, -0.00976073f, -0.01666834f, 0.01854343f, -0.01000682f, 
    -0.01491785f, -0.00945560f, -0.02067936f, 0.00856689f, -0.02234473f, 0.02575030f, 0.01119877f, -0.02292849f, 
    0.01879908f, 0.02785952f, -0.01837586f, -0.01696237f, -0.02149078f, 0.00372375f, 0.00980623f, -0.00660258f, 
    0.00267131f, 0.00841086f, 0.00503592f, -0.03246258f, -0.04044193f, -0.00124126f, 0.01142093f, -0.01251731f, 
    -0.00865886f, -0.01859924f, 0.00390379f, -0.01529164f, 0.00584697f, -0.01076588f, 0.01365957f, -0.00862402f, 
    -0.02587679f, -0.03936715f, -0.01492515f, -0.01011883f, 0.00642284f, -0.00494713f, 0.01015082f, -0.00424842f, 
    -0.01377860f, -0.03455630f, -0.03758105f, -0.04016538f, 0.02674244f, -0.02238559f, -0.00542661f, -0.02766310f, 
    0.01878259f, 0.01449647f, -0.00574296f, -0.01723957f, 0.02452232f, 0.01487933f, -0.01074664f, 0.00597468f, 
    0.02149979f, -0.03195404f, -0.01984598f, -0.01254011f, -0.02076596f, -0.00001086f, 0.01549844f, -0.03093130f, 
    0.00288801f, 0.02010954f, -0.01977219f, -0.02168152f, 0.01529329f, -0.03179235f, -0.02052859f, -0.02023515f, 
    0.02702012f, 0.01028209f, 0.01764544f, -0.00369492f, 0.00878130f, 0.00867965f, -0.04000730f, -0.03017849f, 
    -0.03298622f, -0.02967460f, -0.03946377f, 0.00077029f, -0.01885702f, -0.01767515f, 0.02978520f, -0.02616169f, 
    -0.02480727f, -0.01920047f, -0.01264918f, -0.01911277f, -0.02115348f, 0.02078613f, 0.03044955f, -0.01674539f, 
    -0.03869699f, 0.00469700f, -0.01698094f, 0.01237912f, -0.00854794f, -0.00430305f, -0.00030099f, 0.02922783f, 
    -0.02265345f, -0.02912734f, -0.03286627f, -0.02318896f, -0.04120088f, -0.03529504f, 0.01699994f, -0.03971402f, 
    0.02604208f, 0.02484402f, 0.02460050f, -0.00063115f, -0.01635539f, -0.01946153f, -0.03173735f, 0.02239501f, 
    -0.00632957f, 0.02588380f, 0.00555618f, 0.03085397f, 0.01662149f, 0.02564190f, -0.03404319f, 0.02445998f, 
    -0.03167182f, 0.02641898f, -0.00260786f, -0.01609152f, -0.01261834f, -0.03360078f, -0.00413116f, 0.03037779f, 
    -0.01192583f, -0.01289223f, 0.00797073f, -0.01996953f, 0.01894367f, -0.04046196f, 0.01488595f, -0.01564230f, 
    0.01975819f, 0.00511577f, 0.01210409f, -0.01903759f, 0.00686910f, -0.02369591f, -0.02051289f, -0.00790573f, 
    0.02705921f, -0.04117469f, 0.02771433f, -0.03888228f, -0.03196969f, 0.00592095f, 0.01369404f, 0.00326107f, 
    -0.03182681f, 0.02605403f, -0.02524629f, -0.02586902f, -0.03595525f, -0.02143589f, 0.01242251f, -0.03340621f, 
    -0.00640826f, 0.00069507f, 0.00725170f, -0.00960164f, 0.02938464f, -0.02668410f, 0.02360110f, 0.01006257f, 
    -0.02122224f, 0.01427829f, -0.03434559f, -0.03144592f, 0.02953492f, 0.00717734f, -0.03080365f, -0.01795051f, 
    0.02226001f, -0.00527454f, -0.02003078f, -0.01557931f, 0.00141167f, 0.01352128f, 0.02030208f, -0.03131487f, 
    0.02329898f, 0.00817272f, -0.01522805f, 0.02156508f, -0.02156860f, 0.01761623f, -0.03603728f, -0.01112658f, 
    0.00892365f, -0.01413006f, -0.03278894f, -0.00114272f, -0.01453837f, -0.03703544f, -0.01503047f, 0.03370565f, 
    0.01847207f, 0.01229122f, -0.02621005f, 0.01067019f, 0.01480006f, 0.02737495f, -0.02841812f, 0.01066703f, 
    0.02267646f, 0.02023633f, -0.00034841f, 0.02408052f, -0.00706295f, -0.01913000f, -0.00977302f, -0.00180418f, 
    0.01070972f, -0.03500741f, -0.01019698f, 0.02029319f, -0.01423044f, -0.03770898f, -0.02846973f, 0.01142918f, 
    -0.01330699f, -0.01314818f, 0.00024170f, 0.00914140f, 0.02537153f, -0.03111277f, -0.02056511f, 0.01536418f, 
    0.01684450f, -0.00691186f, -0.00365825f, 0.01571999f, 0.02250773f, -0.03643885f, 0.02978799f, 0.01509514f, 
    -0.02252774f, -0.03408805f, 0.01240629f, 0.02614282f, -0.01132397f, -0.02916601f, -0.01745580f, -0.00686207f, 
    -0.01908789f, -0.01928741f, -0.02231727f, 0.01731419f, -0.01594088f, -0.01838775f, 0.00351112f, -0.01607236f, 
    -0.00297074f, -0.02401467f, 0.00045467f, -0.02455991f, 0.03179700f, -0.03606718f, -0.03019091f, -0.02125453f, 
    0.01309815f, -0.01220968f, 0.01042455f, -0.03773458f, -0.00840983f, 0.00194991f, 0.00559543f, 0.02105120f, 
    -0.03444502f, -0.01794839f, 0.03053385f, -0.01246390f, 0.00948830f, -0.02267215f, 0.01624177f, 0.02565048f, 
    -0.00895417f, -0.00730655f, 0.00824503f, -0.01962980f, -0.03830922f, -0.02905294f, 0.01438843f, 0.02123429f, 
    0.00460942f, -0.01363731f, -0.02511155f, 0.02227524f, -0.00854100f, -0.01883139f, -0.00960338f, -0.03398209f, 
    -0.00164339f, 0.03066195f, 0.02507147f, -0.02370721f, 0.00185111f, 0.02304371f, -0.01747842f, -0.03073946f, 
    0.00542250f, -0.02093140f, 0.03002349f, -0.00665780f, -0.01815344f, 0.01047341f, 0.02810722f, -0.01517049f, 
    -0.01759649f, -0.00264466f, -0.00749077f, -0.00136999f, -0.03830368f, 0.02201852f, -0.01294380f, -0.01545310f, 
    -0.01591372f, 0.00048468f, -0.03762968f, -0.01347776f, 0.01715125f, -0.00140741f, 0.00276323f, -0.01763183f, 
    -0.02550362f, 0.00229396f, -0.01615472f, -0.02365217f, -0.02968655f, -0.03162627f, -0.00959751f, -0.00660153f, 
    0.01915244f, -0.01426628f, -0.00452131f, -0.01645612f, -0.00565559f, -0.04103299f, -0.02108655f, -0.00062535f, 
    -0.00568150f, 0.00326047f, -0.03619630f, 0.01003772f, -0.00254814f, -0.03288997f, 0.00594621f, -0.02755936f, 
    -0.03239424f, -0.03734466f, -0.03863538f, 0.01222308f, 0.01166018f, -0.02355486f, 0.02059220f, 0.00108084f, 
    0.01624675f, -0.01242839f, -0.02873746f, 0.00642248f, -0.03977419f, -0.01467903f, 0.00194192f, -0.02897744f, 
    -0.02945985f, 0.02265745f, -0.00190814f, 0.00983419f, 0.01856379f, 0.00295601f, -0.02188656f, -0.01694700f, 
    0.00522332f, -0.01403717f, 0.00627496f, 0.01337417f, -0.02650098f, -0.02325485f, -0.01730428f, -0.00895856f, 
    -0.03852525f, -0.00366798f, 0.00264223f, -0.02504524f, 0.01865892f, -0.02774766f, -0.01661182f, -0.00723020f, 
    0.02104608f, -0.01251901f, 0.00957971f, 0.00523228f, -0.02410242f, 0.00514553f, -0.00080327f, 0.00990795f, 
    -0.01247936f, -0.01842273f, 0.01488310f, -0.03122482f, 0.01582228f, -0.01488061f, -0.00000002f, -0.01774387f, 
    -0.03229425f, 0.00350116f, 0.03042746f, 0.01613370f, -0.03246851f, -0.03758399f, -0.03813533f, -0.03807658f, 
    -0.03044192f, 0.00566339f, 0.00333431f, 0.02400222f, -0.03713263f, 0.00638481f, -0.02798268f, 0.00811622f, 
    0.01858137f, -0.01231435f, -0.03894958f, -0.01343531f, -0.00401924f, 0.01174782f, 0.00611692f, -0.00637353f, 
    -0.01836268f, 0.02769759f, 0.01121375f, 0.02505665f, -0.00115686f, 0.02753336f, -0.02212711f, 0.01883737f, 
    -0.02986040f, -0.04031465f, -0.02401972f, 0.00587799f, 0.02846009f, -0.02827828f, 0.02935490f, -0.02238998f, 
    -0.01336103f, 0.02570928f, -0.03069905f, 0.02514247f, 0.01997237f, 0.01123175f, -0.03605652f, -0.01911093f, 
    0.00995953f, -0.03205188f, -0.03563213f, -0.03382136f, 0.01136554f, -0.00178592f, 0.02044228f, -0.03897970f, 
    -0.02841909f, -0.01144673f, -0.03501514f, 0.02670345f, 0.00836000f, 0.03080409f, 0.00347816f, -0.00915689f, 
    -0.02170643f, 0.00834730f, 0.00966713f, -0.01718009f, 0.00917255f, -0.02696667f, 0.01550008f, 0.00567421f, 
    0.00521165f, -0.02933027f, 0.03094959f, -0.02963036f, 0.01390178f, -0.03402557f, 0.01424943f, -0.03339466f, 
    -0.02582841f, -0.01887549f, -0.00903916f, 0.00246050f, -0.02819358f, 0.00229727f, 0.01896693f, -0.00837164f, 
    0.01814306f, -0.00577069f, 0.01217721f, 0.01047207f, -0.02587611f, 0.01918646f, 0.01938427f, -0.02595242f, 
    0.00515038f, 0.01570893f, -0.01178946f, 0.00239117f, 0.01370346f, -0.00434466f, -0.02736191f, -0.03375922f, 
    0.02683480f, 0.02151373f, -0.02957646f, 0.02147828f, -0.01601123f, 0.02528840f, -0.02651292f, -0.00598060f, 
    -0.03764958f, 0.02353085f, -0.03287442f, -0.03564676f, -0.03987825f, -0.01055239f, 0.00760361f, -0.04101748f, 
    -0.03842761f, 0.00586595f, 0.00544736f, 0.01507541f, -0.02339260f, 0.00572054f, -0.00502429f, 0.00243706f, 
    -0.03340853f, 0.02490897f, -0.01329509f, -0.01041325f, -0.01226576f, -0.03797219f, -0.03799165f, -0.03288025f, 
    0.01188083f, -0.00948174f, 0.02903438f, 0.01251847f, 0.00498399f, -0.00948722f, -0.00294110f, -0.01865863f, 
    -0.00384024f, 0.02740270f, -0.01652852f, -0.03889311f, -0.02175154f, -0.02384790f, -0.02995927f, 0.00477646f, 
    0.00135062f, 0.02535816f, 0.02712777f, -0.00713327f, 0.00717114f, -0.00749027f, -0.00532071f, 0.00187118f, 
    -0.01765643f, -0.01776571f, -0.03187721f, 0.00559767f, 0.02381994f, -0.04105318f, 0.02334672f, -0.03850526f, 
    -0.00482261f, 0.00367986f, 0.00470322f, 0.00421888f, -0.00735558f, -0.03069039f, 0.00275760f, -0.01922097f, 
    -0.01882013f, -0.01012357f, 0.02951116f, -0.01179551f, 0.00728015f, -0.02171675f, -0.00476835f, 0.02782969f, 
    -0.03705838f, 0.01454543f, 0.01759968f, 0.02067269f, 0.01657721f, 0.00437862f, -0.00256860f, 0.02891260f, 
    0.02595848f, -0.01267533f, 0.02145321f, -0.03675712f, -0.03576132f, -0.02437799f, 0.01549950f, -0.00082851f, 
    0.01208532f, 0.00468829f, 0.02730614f, -0.02935550f, 0.02595345f, -0.00043876f, 0.01834926f, -0.01143641f, 
    0.03047665f, 0.02030879f, -0.03231215f, 0.00349743f, 0.01112496f, -0.01484655f, 0.01753851f, 0.03232978f, 
    -0.02103524f, 0.00671393f, -0.00118820f, -0.02172324f, -0.00660792f, -0.02727438f, -0.03488852f, -0.02700988f, 
    -0.03493860f, 0.03045169f, 0.00494018f, -0.01016293f, -0.03898156f, -0.04026227f, 0.01793788f, 0.01740973f, 
    -0.03186923f, -0.00709609f, -0.02120937f, -0.02798519f, -0.02146122f, -0.03840929f, 0.01618930f, 0.01623805f, 
    -0.00653356f, 0.03088232f, -0.00055188f, -0.00889352f, 0.02842265f, 0.00843082f, -0.01324489f, -0.04013541f, 
    0.01473921f, 0.01995664f, -0.03645376f, 0.02029093f, 0.01220192f, -0.02364111f, 0.00721859f, -0.03791545f, 
    0.01110126f, -0.01756007f, 0.02320066f, -0.02220633f, -0.01470011f, -0.03690877f, -0.03248620f, -0.02551341f, 
    -0.01166057f, -0.00950301f, -0.01082680f, -0.03657398f, -0.03076101f, 0.01016735f, 0.01760726f, -0.03547624f, 
    -0.00721375f, -0.00650842f, -0.03803755f, 0.01489663f, -0.00977008f, 0.01470499f, 0.03765937f, 0.01173314f, 
    0.01359729f, 0.03510607f, -0.01102310f, -0.00549127f, -0.02334297f, 0.00256645f, -0.03099157f, -0.02277832f, 
    0.02737216f, -0.00602890f, -0.01448067f, -0.01045361f, -0.01976808f, -0.00704343f, -0.02945097f, 0.00208263f, 
    0.00415374f, 0.02053673f, 0.02411113f, -0.01663277f, -0.00527220f, -0.01557084f, -0.00406546f, -0.03482870f, 
    -0.00564443f, 0.01591605f, 0.01457978f, -0.00175270f, -0.00252697f, -0.03750931f, 0.00277812f, -0.02147221f, 
    0.02228961f, 0.01212092f, 0.00118262f, 0.01473239f, -0.02321035f, 0.00643616f, 0.01290187f, -0.02773807f, 
    -0.03022396f, 0.01282637f, 0.00312568f, -0.01457109f, 0.02323245f, 0.02152344f, -0.00163990f, 0.01008084f, 
    0.02280458f, -0.01187999f, 0.00160559f, -0.00597990f, -0.02724712f, -0.03864536f, 0.02795989f, 0.00778065f, 
    -0.00811774f, -0.03282225f, -0.00953897f, 0.02347729f, 0.02065311f, -0.01741451f, 0.01593423f, 0.02296410f, 
    -0.03775040f, 0.02837702f, -0.01291041f, -0.00912323f, -0.01205491f, -0.03824106f, 0.00072496f, 0.00560753f, 
    -0.03105692f, 0.03942057f, -0.02707122f, -0.02389801f, -0.00527422f, -0.01045016f, -0.01304464f, -0.01770424f, 
    -0.02446623f, -0.01893888f, 0.01721548f, 0.03303833f, -0.00724476f, -0.01583175f, -0.03473324f, 0.02088489f, 
    -0.01186453f, 0.00017252f, 0.03621813f, -0.02342767f, -0.01105166f, 0.02325275f, -0.01933059f, 0.00020859f, 
    -0.02178684f, 0.02098055f, 0.01827254f, -0.01139893f, -0.02582308f, -0.00758932f, -0.00567890f, 0.00155535f, 
    0.02985944f, 0.01238905f, -0.02499441f, 0.00778909f, -0.00058815f, 0.00431866f, 0.02177275f, 0.01068124f, 
    -0.03213789f, 0.01446440f, -0.02086308f, 0.00562247f, -0.03479970f, -0.01186874f, -0.00270355f, 0.00856901f, 
    -0.01487728f, 0.01189057f, 0.02066447f, -0.03395978f, -0.04009774f, 0.02157005f, 0.02684940f, -0.02178627f, 
    -0.03627615f, -0.02517267f, 0.02980646f, -0.02068904f, -0.01145674f, -0.00686349f, -0.03514704f, -0.00416255f, 
    -0.02781148f, -0.02435874f, 0.03287260f, 0.00482272f, -0.04262077f, 0.02094661f, -0.00000169f, -0.00207157f, 
    0.01627182f, 0.02490930f, -0.00293847f, 0.01042321f, 0.00019759f, 0.02258969f, -0.01804147f, -0.02771459f, 
    -0.04212222f, -0.01750952f, -0.01425563f, 0.02873605f, -0.03600947f, -0.01195127f, 0.02070063f, 0.03236350f, 
    -0.02863722f, 0.03705378f, -0.01979441f, 0.01004416f, -0.02272949f, 0.00520903f, 0.00849439f, 0.01363812f, 
    -0.01750192f, -0.01152439f, -0.01433292f, 0.02627359f, -0.02349144f, -0.01310044f, -0.02258782f, -0.04027350f, 
    -0.01607292f, -0.02963653f, -0.02928018f, -0.03694174f, -0.01979572f, -0.01428406f, -0.04225882f, -0.01276088f, 
    -0.01126603f, 0.01265978f, 0.01605679f, 0.01938033f, 0.01908196f, 0.02100691f, 0.00960737f, -0.03779682f, 
    0.01580141f, 0.01560178f, -0.02227768f, 0.02268718f, -0.00976032f, -0.01160471f, 0.00117115f, -0.01565492f, 
    -0.04141755f, -0.01232374f, 0.03094483f, 0.00135576f, -0.02550887f, 0.02059959f, -0.01889049f, 0.00488044f, 
    -0.01053562f, 0.00880197f, -0.02393032f, 0.00383505f, -0.03842307f, -0.02479060f, 0.02397998f, -0.01362982f, 
    0.03127966f, 0.00683178f, 0.00867779f, 0.03102375f, -0.01393017f, 0.00060051f, 0.00381109f, -0.02178290f, 
    -0.02567381f, -0.01498866f, -0.03645448f, -0.00591090f, 0.00793036f, 0.02457508f, 0.00803351f, -0.02938147f, 
    -0.03104278f, 0.01702565f, -0.02313353f, -0.00898493f, 0.00690312f, 0.02322404f, -0.00442047f, -0.02767458f, 
    0.01617277f, -0.02766243f, -0.01715115f, -0.02912194f, 0.00579710f, -0.03709324f, 0.01180585f, -0.00089165f, 
    0.01462478f, -0.02395004f, -0.00614484f, -0.01092652f, -0.02489945f, -0.01997512f, 0.02559680f, -0.01141743f, 
    -0.01773873f, 0.01973227f, 0.00656968f, -0.01873828f, 0.01790891f, 0.01111499f, -0.00756973f, -0.04252600f, 
    -0.02141976f, 0.02227394f, -0.03112136f, 0.01785998f, -0.00842020f, 0.00505320f, -0.04055348f, 0.02746968f, 
    -0.02353832f, 0.02496777f, 0.03583940f, 0.01109253f, -0.01563887f, 0.01742470f, 0.03493319f, -0.03459658f, 
    -0.02266295f, 0.02512726f, -0.01037841f, -0.00105595f, -0.00202408f, 0.02514927f, 0.00350342f, -0.02012040f, 
    0.03468804f, 0.02696987f, -0.01286779f, -0.01384741f, 0.00480404f, -0.01747843f, -0.04226861f, -0.03039705f, 
    0.02514169f, -0.00444857f, -0.03385881f, -0.00886342f, -0.01817477f, -0.01249871f, 0.00809590f, -0.03815234f, 
    0.02184111f, 0.00422858f, 0.02212094f, -0.02881409f, 0.02068640f, -0.00987860f, -0.00554034f, 0.03780822f, 
    -0.03718676f, 0.00853526f, -0.00083840f, -0.02495605f, 0.00611160f, -0.02255671f, 0.00873540f, 0.00788794f, 
    0.03311881f, -0.00685687f, -0.02007366f, -0.03637983f, 0.00286921f, -0.03064459f, -0.03938761f, -0.02285125f, 
    -0.04268996f, -0.02902723f, 0.01674484f, 0.01845398f, -0.00327062f, -0.03199334f, 0.00441932f, -0.01182329f, 
    -0.00175292f, -0.03115278f, 0.02272009f, -0.00838672f, -0.02052327f, -0.02169389f, -0.02289227f, 0.01320335f, 
    -0.01872429f, -0.00668318f, -0.01447601f, 0.01916154f, -0.03775921f, -0.01662688f, 0.01692400f, -0.01745714f, 
    0.01498960f, -0.01865687f, 0.00469905f, -0.00806396f, -0.01571541f, -0.03295529f, -0.03970421f, 0.02753159f, 
    0.01942670f, 0.02893374f, -0.02390554f, 0.01075337f, 0.02807556f, -0.00802564f, -0.03409017f, 0.02373085f, 
    0.02377709f, 0.02853570f, -0.01459279f, -0.01656134f, -0.00244367f, 0.00830641f, -0.01411144f, -0.01829653f, 
    -0.03122942f, -0.03990876f, -0.04077901f, 0.02569827f, 0.02085692f, -0.01796861f, 0.02852708f, -0.00705215f, 
    -0.01176245f, -0.01539834f, 0.01571561f, 0.01328904f, -0.03815148f, -0.00863279f, -0.01983891f, -0.02481482f, 
    0.02309939f, -0.02844411f, -0.03034245f, -0.02939981f, -0.00720032f, -0.03529323f, -0.00279578f, -0.04058132f, 
    0.01075984f, -0.00849577f, 0.00714304f, -0.02208200f, -0.01527910f, 0.02099401f, 0.02582499f, 0.00028486f, 
    0.02247989f, 0.01177960f, 0.01781609f, 0.01059325f, -0.00899431f, -0.03297521f, -0.01484892f, 0.01708647f, 
    0.00657048f, -0.03629908f, -0.01449817f, -0.01972914f, 0.00527413f, 0.01818954f, -0.00596738f, -0.03722159f, 
    0.00991586f, 0.01498064f, 0.00907283f, 0.03889577f, -0.02634368f, 0.02832384f, -0.02075505f, 0.02254594f, 
    -0.01470326f, -0.04274016f, -0.02462287f, -0.03064163f, 0.01962414f, 0.01125956f, -0.02101424f, -0.00107084f, 
    0.02651701f, -0.00790797f, -0.01109236f, -0.00953399f, -0.01639161f, -0.01591667f, -0.01084643f, -0.00133417f, 
    0.01302224f, -0.02407704f, 0.01072978f, -0.00059819f, -0.03164629f, 0.02521758f, 0.00945678f, 0.01071482f, 
    0.00808131f, -0.04162694f, 0.02734971f, -0.03034134f, 0.00580198f, -0.01407347f, 0.00230299f, -0.00191903f, 
    -0.00831969f, -0.00705383f, -0.03670771f, 0.00763000f, -0.02293628f, -0.02286307f, 0.01102594f, 0.00968351f, 
    0.00900944f, -0.03656776f, 0.02894200f, 0.00555359f, 0.02378987f, -0.02935758f, 0.02834480f, 0.01367285f, 
    -0.04243733f, -0.01971081f, -0.02244364f, 0.01940973f, -0.02697511f, 0.00012009f, -0.00895687f, 0.01205827f, 
    0.02784140f, -0.03727591f, -0.04297129f, -0.02180056f, -0.03786595f, -0.02491033f, -0.00219111f, 0.01798631f, 
    -0.00457284f, 0.01880569f, 0.01249156f, 0.00160924f, 0.02559962f, -0.01301226f, 0.02094461f, 0.02655349f, 
    -0.04017884f, -0.04284121f, 0.01696349f, 0.00803136f, 0.00860024f, -0.00135753f, -0.02286015f, 0.00967778f, 
    -0.02839260f, 0.00113827f, 0.00701109f, 0.02743022f, 0.04088461f, -0.03254943f, 0.01720220f, 0.00611582f, 
    -0.02917561f, 0.00969143f, -0.00585211f, -0.00325058f, 0.02201828f, -0.03992855f, -0.00410875f, 0.01221435f, 
    -0.00550417f, 0.01669061f, 0.00715941f, 0.02474192f, 0.01087335f, 0.02539161f, -0.03994751f, -0.01385515f, 
    0.01524772f, -0.00413374f, -0.02764134f, -0.01156877f, -0.02158887f, -0.01715012f, -0.02074787f, 0.00694841f, 
    0.01884617f, -0.02704590f, -0.00848538f, -0.00423459f, 0.02452018f, -0.02923236f, -0.00389926f, -0.01238797f, 
    -0.00879215f, -0.01767112f, -0.01710079f, -0.02926988f, 0.00856972f, 0.01484892f, 0.01799840f, -0.02297977f, 
    -0.01765511f, -0.04136709f, -0.00260002f, -0.03544305f, -0.00364387f, 0.01390572f, 0.02290674f, -0.03768298f, 
    0.02241120f, -0.00100436f, -0.02351947f, 0.01186110f, 0.02275760f, -0.02139414f, -0.00211256f, -0.01848879f, 
    -0.00441066f, 0.00033793f, 0.01516609f, -0.00246724f, -0.00608266f, -0.02588042f, -0.04221375f, 0.00653103f, 
    -0.03294030f, -0.01580846f, -0.01467113f, -0.00525910f, 0.00000056f, -0.01423977f, -0.02862658f, -0.02116545f, 
    -0.03849473f, 0.02189570f, -0.01106480f, -0.01620599f, 0.02281073f, 0.03670552f, 0.02614106f, -0.02998474f, 
    -0.00226621f, -0.00868411f, -0.02827453f, 0.02605947f, -0.00353625f, 0.02945953f, -0.01071212f, -0.00952373f, 
    -0.03521501f, -0.02924265f, 0.01988648f, 0.01078566f, -0.02181973f, -0.02037223f, -0.02903135f, -0.00657826f, 
    -0.00377472f, -0.00722859f, 0.02752712f, 0.00547471f, -0.01548911f, -0.01507218f, 0.01011620f, -0.01691945f, 
    0.03200794f, 0.01982890f, 0.00798084f, -0.00462319f, -0.02064702f, -0.00216678f, -0.02480829f, 0.02574882f, 
    -0.01269257f, 0.02907046f, 0.03821123f, -0.00261321f, -0.02626423f, -0.00364916f, -0.02493562f, -0.00432347f, 
    0.01275707f, 0.01862059f, -0.03011552f, -0.01069885f, -0.00199255f, 0.01998463f, -0.01694301f, 0.02804718f, 
    0.00924681f, -0.01144148f, -0.02077112f, 0.01904627f, -0.02178215f, -0.03305745f, -0.03973645f, 0.01993433f, 
    -0.00279433f, 0.01881113f, -0.00513374f, 0.01381359f, 0.01638573f, -0.01244910f, 0.03866371f, -0.04048725f, 
    -0.01309867f, -0.00737545f, -0.01408308f, -0.03608633f, -0.00632461f, 0.02640878f, 0.00771634f, 0.01153506f, 
    0.02617517f, -0.02152508f, -0.03518618f, -0.03975914f, -0.00005140f, -0.00443735f, 0.02267932f, -0.02691206f, 
    0.01371861f, 0.01222245f, -0.04072752f, 0.03845098f, 0.02705687f, -0.01998418f, -0.00991286f, -0.01257275f, 
    -0.01936700f, 0.02069505f, 0.00389489f, -0.01210987f, -0.00157080f, -0.00899875f, -0.01343119f, -0.02450364f, 
    0.02123847f, 0.03452779f, -0.00499667f, 0.01398717f, -0.00132148f, -0.00756987f, 0.01589457f, -0.01436546f, 
    0.01266652f, -0.01473685f, -0.01453284f, -0.03985330f, 0.00320760f, -0.00201359f, 0.00197189f, 0.02285171f, 
    0.00056826f, 0.02415933f, -0.03261357f, 0.01708735f, 0.02155534f, 0.02548189f, 0.01667054f, -0.02201635f, 
    -0.03354341f, 0.02078724f, -0.00646311f, 0.01968033f, 0.00032853f, -0.02039891f, 0.01521096f, 0.00219424f, 
    0.04030962f, -0.02355816f, 0.00183751f, 0.02851790f, 0.00675896f, -0.03743354f, 0.02282850f, -0.01583367f, 
    -0.03350449f, 0.02515449f, 0.01980868f, -0.01949231f, -0.00398720f, 0.00411020f, -0.02115088f, 0.01564021f, 
    -0.02786968f, -0.02795531f, 0.01499608f, 0.00754282f, -0.04146435f, 0.02213763f, 0.03565743f, -0.01339020f, 
    -0.00775523f, -0.02400365f, 0.01955076f, -0.02421429f, -0.00660863f, 0.01131097f, 0.01259331f, -0.01689996f, 
    -0.14260370f, 0.22538990f, -0.03690640f, 0.16521510f, 0.02610097f, -0.02191532f, 0.03703489f, -0.09664217f, 
    0.01209250f, 0.03227955f, 0.15991230f, -0.03803421f, -0.03922114f, 0.03938270f, -0.04323179f, 0.01885737f, 
    0.02120675f, -0.00459081f, 0.04260242f, -0.04279270f, 0.05861694f, -0.09206530f, 0.19748321f, 0.06758889f, 
    0.09693469f, 0.06910987f, -0.02712882f, 0.00902918f, 0.07257674f, 0.13198934f, 0.02067038f, -0.08131320f, 
    0.02523314f, 0.04868947f, 0.07932852f, 0.01280931f, -0.11722111f, 0.29393300f, -0.10179342f, 0.11603483f, 
    0.05382054f, 0.11799589f, -0.00333002f, -0.06714433f, -0.01214414f, 0.08306549f, 0.09838004f, 0.00504216f, 
    -0.22533979f, 0.04107050f, -0.11130209f, -0.07036159f, 0.00302606f, 0.09706721f, -0.11975361f, 0.09092700f, 
    -0.10242075f, 0.01290319f, 0.00355682f, -0.02741200f, 0.01682710f, 0.06927504f, -0.02660023f, -0.09174431f, 
    0.10537884f, -0.04537362f, 0.06195422f, 0.08207215f, 0.03018678f, 0.00241645f, -0.08732142f, 0.09767815f, 
    -0.08895203f, 0.15022348f, -0.04247270f, -0.00433943f, 0.09788782f, 0.00852156f, -0.01501891f, 0.03425590f, 
    0.01122588f, -0.09222246f, 0.08573105f, 0.05549825f, 0.10694385f, -0.05637152f, 0.10919156f, -0.01558656f, 
    0.07229146f, 0.05439951f, 0.14595583f, 0.06294531f, -0.04809128f, -0.04772325f, 0.05426544f, 0.01280499f, 
    -0.10027321f, -0.02230671f, 0.12490673f, 0.07645820f, 0.00771860f, -0.05854777f, 0.09140427f, 0.03433733f, 
    0.03506266f, 0.08027176f, -0.04755600f, 0.03808252f, 0.12766965f, 0.11954743f, 0.00020739f, -0.02483676f, 
    0.00530327f, 0.13361055f, 0.07306713f, 0.13489684f, 0.08249212f, -0.02777706f, -0.02077834f, -0.02969929f, 
    -0.05326569f, 0.00938632f, 0.06516077f, -0.03709077f, -0.10481956f, 0.01397992f, 0.00362998f, -0.02172796f, 
    0.04962320f, 0.04566402f, -0.02269231f, 0.05284255f, 0.30767494f, -0.09488508f, 0.10633126f, -0.08474362f, 
    0.04338298f, 0.17768066f, 0.02619127f, 0.02590139f, -0.13394544f, 0.00130870f, 0.05503079f, -0.00050684f, 
    0.15304942f, 0.10231937f, 0.06861481f, 0.04779542f, -0.11651074f, 0.02178169f, -0.10976703f, 0.00244008f, 
    -0.05668145f, 0.06434074f, 0.06282185f, 0.03028999f, -0.12095378f, 0.00687034f, -0.06940883f, -0.07372951f, 
    0.08215848f, 0.13999797f, 0.04790040f, 0.02569820f, -0.04804997f, 0.00541237f, 0.05072839f, 0.06039622f, 
    -0.01398205f, -0.02126812f, 0.17112646f, 0.01061544f, 0.09013382f, 0.06277550f, -0.03312573f, 0.03362989f, 
    0.08209054f, 0.08745810f, -0.00245117f, 0.08014999f, -0.03663245f, -0.07626437f, 0.07209159f, -0.06755406f, 
    0.01982682f, -0.03119865f, 0.06259471f, 0.02875238f, 0.04856879f, 0.05703954f, -0.04735068f, 0.10856604f, 
    0.08844452f, 0.02954641f, -0.10827156f, 0.10677706f, 0.00660586f, -0.00296551f, -0.02653151f, 0.01693181f, 
    0.00788922f, 0.04556561f, -0.00967839f, -0.02028880f, 0.04833885f, 0.06564915f, 0.04376876f, 0.13030042f, 
    -0.01599112f, 0.10661549f, 0.07139719f, -0.03180720f, -0.02218326f, 0.07859634f, -0.04405017f, -0.03998479f, 
    -0.09504554f, 0.00175555f, 0.12918167f, 0.00359737f, 0.08500847f, 0.00299962f, 0.07668553f, 0.12782556f, 
    0.10951001f, 0.04537251f, 0.08865319f, -0.00313421f, 0.00615375f, 0.06544912f, 0.14910477f, -0.06978485f, 
    -0.07174092f, 0.04278180f, 0.01767987f, 0.11806377f, -0.03404634f, 0.03971730f, 0.02988335f, -0.08400469f, 
    0.11799138f, 0.15040596f, -0.05872194f, -0.17783840f, 0.03024383f, -0.02294667f, -0.03304430f, -0.02846462f, 
    0.00588900f, -0.05560852f, 0.05266529f, -0.09665246f, 0.06897721f, 0.15625721f, -0.03399161f, -0.12291414f, 
    0.03475795f, -0.01008993f, 0.03029860f, 0.02050063f, 0.00920345f, -0.00003464f, 0.00275761f, -0.02488634f, 
    -0.01174809f, 0.20214716f, 0.14915647f, 0.01690727f, -0.02038037f, 0.04709820f, 0.07139479f, 0.07003642f, 
    -0.10233917f, 0.00575381f, 0.04653402f, -0.04513244f, -0.04631373f, 0.08670904f, 0.10113208f, 0.01859718f, 
    -0.03582016f, -0.02868652f, 0.05251444f, -0.05213163f, 0.01869214f, -0.06838175f, -0.06005042f, -0.04213028f, 
    -0.00292312f, -0.06496556f, 0.01483626f, -0.05764176f, 0.06102199f, 0.00534415f, -0.08215699f, 0.03828251f, 
    -0.04811577f, -0.03003808f, 0.00304241f, 0.10165362f, -0.14717609f, 0.07621194f, 0.05088438f, 0.01784876f, 
    0.00511986f, 0.02093965f, 0.05236205f, 0.05454363f, 0.06716645f, -0.03300910f, 0.17515838f, -0.05363809f, 
    0.07897300f, -0.00367567f, -0.14618164f, 0.15669587f, 0.05120251f, -0.09479470f, 0.02860330f, 0.04145943f, 
    0.00278901f, -0.01149785f, -0.02734921f, -0.03458305f, 0.08998718f, 0.06127532f, -0.15621781f, 0.05022117f, 
    -0.02156121f, 0.03474875f, 0.07392467f, -0.07202636f, 0.04299410f, 0.06411733f, 0.00609267f, -0.05523004f, 
    -0.03278773f, 0.11509904f, 0.05360463f, 0.03474367f, 0.00511395f, 0.04226774f, 0.00139569f, -0.10994884f, 
    0.02368546f, 0.06370921f, -0.02465878f, 0.03541548f, -0.09723616f, -0.07753231f, -0.06098481f, -0.01758227f, 
    0.03438975f, 0.00837777f, 0.05871861f, 0.06963775f, -0.03433375f, 0.14255118f, -0.00008048f, 0.02162966f, 
    0.04041767f, 0.08536495f, -0.05675627f, -0.06965484f, 0.06994576f, 0.01512692f, -0.00437016f, 0.06296121f, 
    0.05854028f, -0.01109159f, -0.04983181f, 0.14364064f, 0.00131574f, 0.08004443f, 0.14483389f, 0.14162308f, 
    0.05747273f, 0.00181112f, -0.02465613f, 0.01130162f, -0.10392490f, 0.06253373f, 0.07569875f, 0.11958141f, 
    0.01861157f, 0.05566679f, 0.06443617f, 0.00297361f, -0.00126628f, 0.02561657f, -0.02194091f, 0.13939379f, 
    0.03283432f, -0.11455374f, -0.01431947f, -0.10194485f, 0.09139249f, -0.17596771f, 0.14819650f, 0.16679896f, 
    0.06431084f, -0.06244605f, 0.12595227f, -0.02691915f, -0.07015518f, -0.01367936f, -0.11362835f, 0.04129116f, 
    0.17984167f, -0.19742295f, 0.08733900f, 0.09263514f, 0.04533832f, 0.11666164f, 0.04336892f, -0.10521279f, 
    0.06855820f, -0.03382320f, 0.00220959f, -0.05505971f, -0.04306746f, -0.15690227f, 0.06004829f, 0.05581991f, 
    0.03755975f, 0.04761751f, -0.03170936f, -0.03989133f, 0.04354343f, 0.11560758f, 0.01943287f, 0.12296253f, 
    0.05579187f, -0.06478530f, -0.11297140f, -0.09082542f, 0.03504844f, -0.13627154f, 0.02399001f, -0.02162550f, 
    0.00971595f, 0.01913119f, -0.03516671f, 0.00607665f, 0.03323432f, -0.07826889f, 0.14930867f, 0.03510949f, 
    0.00475323f, 0.02947968f, -0.02569221f, -0.02798348f, 0.00846670f, 0.00269899f, 0.04765227f, 0.06516290f, 
    0.12011946f, -0.09310715f, -0.04344188f, 0.06411449f, 0.04809814f, -0.10107379f, 0.02659332f, 0.01116904f, 
    0.01661323f, -0.03678168f, -0.05884285f, 0.03014398f, 0.12982398f, -0.00757572f, -0.03038928f, 0.00090521f, 
    0.05028887f, 0.03141684f, -0.01697375f, 0.09191648f, -0.02181789f, 0.10987049f, 0.07987542f, 0.00580241f, 
    0.01489799f, -0.18017852f, 0.01978270f, 0.05160292f, -0.00622993f, 0.06641062f, 0.04455949f, 0.08509051f, 
    0.01392560f, -0.00367610f, 0.04057515f, -0.11629255f, -0.14371505f, 0.05895500f, -0.07895812f, -0.03418422f, 
    0.02867291f, 0.06422493f, -0.01457671f, -0.01036080f, -0.10310156f, 0.00086221f, -0.03982683f, 0.07133871f, 
    0.03455936f, -0.08377378f, -0.02612440f, 0.16411225f, 0.04746296f, -0.03033823f, -0.02303241f, -0.00295828f, 
    -0.08668682f, 0.00241788f, 0.08407395f, 0.04735079f, 0.04019767f, -0.01373659f, -0.09600858f, -0.08772695f, 
    -0.03405952f, 0.05753849f, 0.06646741f, 0.06883925f, 0.10116578f, 0.10679533f, -0.00555544f, 0.01752625f, 
    0.04806734f, 0.03503067f, -0.02212361f, 0.00601525f, -0.03483297f, 0.05795564f, 0.02701537f, 0.01449755f, 
    0.00495589f, 0.08864148f, 0.08710323f, -0.05779013f, -0.00434392f, 0.01992367f, -0.00555582f, -0.02412657f, 
    0.02340978f, -0.06634230f, 0.01663689f, 0.06670484f, -0.00180529f, -0.01744203f, 0.06992995f, -0.01669201f, 
    -0.07645636f, 0.03870490f, 0.10492327f, -0.06904465f, -0.05742619f, -0.05759614f, -0.01514316f, 0.04682926f, 
    -0.04975033f, 0.00500074f, 0.10889336f, 0.04278877f, -0.12267948f, -0.22141036f, 0.02137916f, 0.13707955f, 
    -0.04339607f, 0.00233534f, 0.04147901f, 0.00488168f, -0.07724032f, -0.02095042f, -0.11887360f, -0.02606092f, 
    -0.04484554f, 0.11825423f, -0.03879378f, -0.00854147f, -0.01241325f, 0.01420805f, 0.12112879f, -0.00242951f, 
    0.11429093f, 0.00188879f, -0.13328065f, 0.06028951f, 0.00719664f, -0.02862843f, 0.02277418f, 0.05031502f, 
    -0.04828674f, -0.05030403f, 0.02316780f, -0.03522041f, -0.00013134f, 0.04499340f, 0.03082698f, -0.10356289f, 
    -0.11613166f, 0.10125657f, 0.06959642f, -0.00138881f, 0.02690445f, -0.01417865f, 0.04133739f, 0.03437587f, 
    -0.05308195f, 0.07571522f, -0.05192056f, -0.00526178f, -0.08614679f, -0.02459894f, 0.07158639f, 0.07442801f, 
    0.09608591f, 0.02564955f, -0.01558328f, -0.05168436f, -0.10292731f, -0.12459854f, -0.08581576f, 0.03033721f, 
    0.00224722f, 0.25147298f, 0.14491992f, -0.06616180f, 0.02587261f, 0.03141623f, 0.05267212f, 0.04171977f, 
    0.00791991f, 0.10411004f, -0.19000123f, 0.10300224f, 0.01208947f, -0.03320939f, 0.03074962f, -0.01777838f, 
    0.03792389f, -0.07063345f, 0.07337058f, 0.02190616f, 0.00622573f, 0.10203755f, 0.01528328f, 0.09023573f, 
    -0.05428784f, -0.00487636f, 0.02652033f, 0.01978333f, 0.06783456f, -0.00963720f, 0.04099726f, -0.10472471f, 
    -0.02939614f, 0.08367838f, -0.01864249f, 0.02007079f, -0.11375763f, 0.11217545f, 0.10121702f, -0.12157328f, 
    0.05622407f, -0.05088779f, -0.04180014f, -0.04611555f, 0.02682588f, -0.05799509f, 0.14907233f, -0.03628996f, 
    0.10225611f, 0.05130180f, -0.00443377f, 0.02817885f, 0.01761568f, 0.00102833f, -0.02821614f, -0.00016846f, 
    0.11337454f, -0.02219293f, 0.06365882f, -0.02751269f, -0.06658151f, 0.06424563f, 0.14260045f, -0.10138965f, 
    -0.01714425f, 0.07023992f, 0.06343123f, 0.01711970f, 0.00128679f, -0.02804655f, 0.04405604f, 0.13749082f, 
    0.06767876f, 0.06745673f, 0.03464664f, -0.12949981f, -0.05888122f, 0.04406190f, 0.02022309f, 0.01848736f, 
    -0.05177020f, -0.09043164f, -0.04721164f, -0.10004075f, -0.08338035f, -0.00540003f, 0.09951800f, -0.07756951f, 
    0.03553525f, -0.04640715f, 0.09064151f, 0.02993405f, 0.07066651f, 0.09385546f, -0.09251422f, 0.03486164f, 
    -0.06011425f, 0.09128764f, 0.15095545f, -0.08887730f, -0.10072514f, -0.04758778f, -0.03925040f, 0.03664783f, 
    0.00946994f, -0.00063674f, -0.06969661f, -0.02519136f, -0.09407239f, 0.23254795f, -0.19879226f, -0.12407199f, 
    0.05575488f, 0.04279047f, -0.07547696f, 0.01154267f, 0.02215432f, 0.04780051f, 0.07415596f, -0.02028332f, 
    -0.19506112f, 0.16537336f, -0.08068482f, 0.00917038f, 0.01300449f, -0.01702382f, 0.06372773f, -0.03169632f, 
    0.04022791f, 0.03534631f, -0.04274008f, 0.05281625f, -0.15219489f, -0.19632107f, 0.10282961f, 0.07922525f, 
    0.05857538f, -0.09219963f, 0.00579831f, -0.11672301f, -0.07865356f, -0.06256885f, -0.08489613f, -0.04199112f, 
    0.14547116f, 0.24260445f, 0.00514514f, 0.09109797f, 0.00100645f, -0.01777086f, -0.00312658f, 0.04838634f, 
    0.03244017f, 0.00025220f, 0.10054842f, 0.04171356f, -0.13383055f, 0.03047354f, -0.10179520f, -0.00835494f, 
    0.03753305f, 0.13103101f, 0.06718270f, 0.03103185f, -0.00543739f, -0.05024973f, 0.17312427f, 0.06371951f, 
    0.27389941f, 0.20805609f, -0.03610700f, 0.08447390f, -0.03234490f, 0.12636706f, 0.01110064f, 0.04453551f, 
    0.06496958f, -0.07978105f, 0.09075614f, 0.06730506f, 0.17377070f, 0.22510579f, -0.03909506f, 0.03525462f, 
    0.08602747f, -0.03382696f, -0.04745705f, 0.02892539f, -0.03021829f, -0.00448585f, -0.00585796f, 0.02300854f, 
    0.00413262f, 0.07182297f, 0.08896153f, 0.22220032f, 0.02793306f, 0.11353482f, -0.02533029f, 0.05785808f, 
    0.03085154f, 0.07967497f, 0.11271431f, -0.06893840f, -0.16317464f, 0.00356285f, 0.05093374f, 0.16448571f, 
    0.05244121f, -0.03789108f, -0.02050391f, 0.08270953f, 0.06187116f, 0.09383097f, 0.00443574f, 0.06006303f, 
    -0.23980944f, 0.04501477f, 0.08780117f, 0.18257044f, 0.13985184f, -0.00950429f, -0.03359557f, 0.00622613f, 
    0.04072515f, -0.01784898f, 0.08348503f, 0.11696179f, 0.06381882f, -0.02325869f, 0.03944687f, 0.18137430f, 
    0.00437799f, 0.02920112f, 0.12227486f, 0.21088731f, -0.00957738f, 0.04434728f, 0.09950580f, -0.00391763f, 
    0.09981816f, -0.05601375f, 0.08203492f, 0.15335409f, 0.06544662f, -0.03037928f, 0.11973929f, -0.01491204f, 
    -0.00167053f, 0.13590659f, -0.05857154f, 0.00649767f, 0.00478697f, 0.06619636f, 0.04755976f, -0.00327317f, 
    0.09499717f, 0.12534466f, 0.09582271f, 0.09643885f, 0.04960584f, 0.08114514f, 0.05693565f, 0.06548133f, 
    0.09250399f, 0.02958851f, 0.01748614f, -0.00672024f, -0.00406625f, 0.14907837f, 0.14369790f, 0.00115653f, 
    -0.03480460f, 0.01151261f, 0.04995213f, -0.04829084f, 0.17215440f, -0.09225808f, 0.02876484f, -0.01100107f, 
    0.01134377f, 0.18779583f, -0.01309179f, 0.08316890f, -0.05922944f, 0.03620261f, 0.11173525f, 0.02184100f, 
    -0.03994749f, 0.10953754f, -0.10123540f, 0.00120457f, -0.01455451f, 0.00126723f, -0.04611643f, -0.01852933f, 
    -0.09730761f, 0.12592031f, 0.00882236f, 0.05513704f, -0.23976260f, 0.17458344f, 0.15505007f, -0.11386598f, 
    0.08763467f, 0.10802967f, 0.10481013f, -0.01451952f, 0.06606264f, 0.03546010f, 0.09449656f, 0.06738628f, 
    -0.08842357f, -0.04317240f, 0.18478920f, 0.06058840f, 0.11958542f, -0.02053074f, 0.00187381f, -0.00370947f, 
    0.01422806f, 0.14585161f, 0.04237103f, 0.07173876f, 0.11937485f, -0.10312277f, 0.07698651f, 0.04954890f, 
    0.05317525f, -0.04077705f, 0.14566962f, 0.13333248f, -0.00830507f, 0.00909996f, -0.00698459f, 0.07929576f, 
    0.10997025f, 0.09306531f, 0.00284813f, 0.15516263f, 0.03074024f, 0.02756884f, -0.01110385f, 0.09531254f, 
    -0.00708803f, 0.09666992f, 0.10998088f, 0.00250107f, 0.20168550f, -0.15809055f, 0.08721802f, -0.03117818f, 
    0.02090464f, 0.12129148f, 0.11100181f, 0.01071314f, 0.08566516f, 0.03802712f, -0.01371801f, 0.11410566f, 
    0.06487468f, -0.00711081f, 0.01600249f, 0.09197787f, 0.03775363f, 0.05791323f, 0.00496654f, 0.09285828f, 
    -0.01274935f, 0.09350408f, 0.01718304f, -0.00666134f, 0.16452083f, 0.06648359f, 0.17549284f, -0.07229199f, 
    0.08362887f, -0.02242116f, 0.04174078f, 0.06844086f, -0.11923673f, 0.00035994f, 0.03444138f, -0.01069604f, 
    0.22026330f, 0.00336281f, -0.01720398f, -0.06057049f, 0.07366033f, 0.03313807f, 0.00462903f, -0.02579062f, 
    0.05512967f, 0.08650078f, 0.03639376f, 0.01277414f, 0.08744398f, 0.26547790f, 0.03480069f, 0.02345558f, 
    0.09278505f, 0.01024910f, 0.00451375f, -0.00051146f, 0.00984870f, 0.04314641f, -0.08805381f, -0.10842925f, 
    0.06438506f, 0.00369989f, -0.02999873f, -0.06432269f, -0.01198138f, 0.07404044f, 0.13258947f, 0.08563959f, 
    0.03739223f, 0.04893456f, 0.02016723f, -0.03851795f, -0.00861514f, 0.05738242f, 0.01522175f, 0.04291406f, 
    0.09483234f, -0.08570966f, 0.05035471f, -0.08948528f, -0.09722321f, 0.01167957f, -0.03927778f, -0.09230975f, 
    0.11596212f, -0.00135171f, -0.04710333f, -0.05317633f, 0.04603334f, -0.01260366f, -0.06564089f, -0.08663277f, 
    -0.06534681f, -0.02285749f, 0.08886258f, 0.06372982f, 0.02118568f, 0.16543742f, 0.19235486f, -0.11018559f, 
    0.02143805f, 0.03624315f, 0.12804699f, 0.15595332f, 0.01529879f, -0.00522304f, 0.00021608f, -0.09682291f, 
    0.03288777f, 0.10968354f, 0.08613598f, 0.09888962f, 0.12063318f, -0.07174462f, 0.03011041f, 0.04821134f, 
    -0.11047553f, -0.09182695f, 0.04432695f, -0.01014983f, -0.02137118f, -0.10784214f, -0.06057417f, -0.04934648f, 
    0.04733712f, 0.10561981f, -0.04082680f, -0.04977578f, 0.04499916f, -0.00612307f, -0.04278718f, -0.05666928f, 
    0.12504756f, 0.03333050f, 0.20485291f, -0.10829735f, -0.02813372f, 0.04101918f, 0.07043546f, 0.03678511f, 
    0.02619422f, 0.05220580f, -0.06369442f, -0.01216481f, -0.03689585f, -0.04377473f, 0.12459381f, 0.23847558f, 
    0.12125336f, 0.07276254f, 0.10457302f, 0.15381803f, 0.10731104f, 0.13206035f, 0.06041529f, -0.02423495f, 
    -0.03624382f, 0.04643005f, 0.05862546f, 0.05282760f, 0.08753424f, 0.02964083f, 0.02696466f, -0.06806628f, 
    0.02904454f, -0.00846628f, -0.08696160f, 0.12196153f, -0.05656794f, -0.04029456f, 0.03858723f, -0.01649233f, 
    0.05178967f, -0.04116437f, 0.04631644f, 0.06220089f, -0.08678479f, 0.01391748f, 0.01707346f, 0.10390463f, 
    0.03330477f, 0.15191850f, 0.03298383f, 0.00919215f, -0.06045955f, -0.02272651f, 0.02597314f, 0.13542764f, 
    0.01495525f, -0.07233867f, 0.01585623f, -0.16761160f, 0.20653151f, -0.01794854f, 0.09823485f, 0.06788362f, 
    -0.02873814f, -0.03989779f, 0.06944498f, 0.05823503f, -0.00752967f, -0.04190985f, -0.08850604f, -0.01942513f, 
    0.17527398f, 0.03566180f, -0.04080482f, 0.12395807f, 0.13263671f, 0.05671763f, -0.00603881f, 0.01326848f, 
    0.07910638f, 0.00447187f, 0.03140207f, -0.07405339f, 0.11647160f, -0.06560588f, 0.01008903f, -0.04141582f, 
    -0.04232509f, 0.12026310f, 0.05620125f, 0.05207179f, 0.03845161f, 0.11981653f, 0.06807352f, 0.19476224f, 
    -0.01183084f, -0.03783306f, 0.07875127f, 0.19619814f, 0.09645893f, -0.07813431f, 0.01015621f, 0.09801570f, 
    -0.01668895f, 0.04933156f, 0.04666971f, 0.00469761f, 0.15651259f, 0.10424199f, -0.13612579f, 0.06474671f, 
    0.00555611f, 0.06611645f, -0.02741489f, -0.01556502f, 0.03042600f, 0.00305781f, 0.05996092f, 0.07476468f, 
    0.08571476f, 0.04981842f, 0.12463978f, 0.30002984f, 0.05482015f, -0.08051698f, 0.02970378f, 0.03077095f, 
    0.02210516f, 0.00940556f, 0.02495969f, 0.08697771f, 0.12582467f, 0.11707935f, -0.09255004f, -0.17241168f, 
    0.09031131f, 0.03977384f, 0.05421151f, 0.14634056f, -0.04898221f, 0.11298767f, 0.01993079f, 0.08129383f, 
    -0.00176109f, 0.03000992f, -0.12298032f, 0.17837268f, 0.06869292f, 0.00437722f, 0.01822064f, 0.10113747f, 
    -0.03188168f, -0.05211835f, -0.02880933f, -0.18824944f, -0.02784210f, 0.15801266f, -0.03791718f, 0.01259539f, 
    0.11592255f, 0.12195198f, 0.12880047f, 0.03647074f, -0.01533328f, -0.02683545f, 0.03739458f, 0.17844133f, 
    0.04159868f, 0.04927811f, -0.19028324f, 0.06301688f, 0.04932998f, 0.04312818f, 0.01333707f, 0.02888075f, 
    -0.08305073f, -0.06638797f, 0.10295632f, 0.06743523f, 0.09304268f, 0.03319087f, 0.04777611f, 0.09585055f, 
    0.03192106f, -0.03333090f, 0.10369191f, 0.04157875f, 0.01133086f, 0.09527206f, -0.01173680f, 0.02612763f, 
    -0.08939286f, -0.07520349f, -0.05113824f, -0.08118175f, 0.02189790f, 0.06791031f, 0.01369421f, -0.00015598f, 
    -0.06193038f, 0.12172115f, 0.16445012f, 0.01536569f, 0.12232084f, 0.10111318f, 0.04282087f, 0.08806113f, 
    0.07702904f, 0.06269985f, -0.01191166f, -0.01111380f, -0.10202507f, -0.00024542f, 0.05232481f, -0.00200025f, 
    -0.00483716f, 0.12384590f, 0.01121650f, 0.09328000f, 0.00015779f, 0.01058841f, 0.02160794f, -0.06761690f, 
    -0.05552320f, 0.05150953f, 0.04280409f, 0.04952079f, -0.03985168f, -0.07093657f, 0.08182126f, 0.17449974f, 
    0.03776341f, -0.00277366f, 0.02803123f, 0.08857997f, 0.02654338f, 0.07696007f, -0.10600629f, -0.04026357f, 
    -0.11482285f, -0.09690223f, -0.01768569f, 0.00222937f, 0.11773343f, 0.10470142f, 0.00161399f, 0.01856433f, 
    0.02045330f, 0.08945820f, 0.05380688f, 0.07102882f, 0.10564749f, 0.19592096f, -0.02829580f, -0.04369628f, 
    0.00793578f, -0.07024446f, -0.04390219f, 0.06790111f, -0.07138932f, 0.09268695f, -0.03323090f, -0.16574630f, 
    -0.02488151f, 0.21998602f, 0.06366988f, -0.02886469f, 0.03254811f, 0.04699067f, 0.02709737f, 0.00807195f, 
    -0.05223251f, 0.16036832f, 0.02363851f, 0.04516543f, 0.00192982f, -0.09388585f, 0.06417311f, -0.05319543f, 
    0.05820510f, 0.03956001f, 0.04617374f, 0.04905011f, -0.01732611f, 0.04968127f, -0.01502497f, -0.09619814f, 
    0.02365597f, 0.09652066f, 0.04996867f, -0.08798743f, 0.03592267f, 0.07971682f, 0.05553000f, 0.05703037f, 
    0.01050161f, 0.06200070f, -0.12736347f, 0.04365465f, 0.06434743f, -0.10490669f, 0.03590015f, 0.12886877f, 
    0.19723341f, 0.05751951f, 0.12457417f, 0.23688275f, 0.01206467f, 0.13977197f, 0.05107610f, 0.22966933f, 
    -0.21880980f, 0.03372286f, 0.00733979f, -0.11477762f, 0.10623133f, 0.12348998f, 0.00197438f, -0.02608322f, 
    0.00097656f, 0.03965921f, -0.05570424f, 0.07696371f, 0.15173040f, 0.09800464f, 0.14878210f, 0.04377757f, 
    -0.00934388f, 0.07972366f, 0.04490276f, 0.00814431f, 0.01734076f, -0.06187552f, 0.19362099f, 0.02027939f, 
    0.16287090f, 0.09821633f, 0.01589539f, 0.02084917f, 0.00130720f, 0.07173361f, -0.03088122f, 0.03226311f, 
    -0.03642606f, -0.10123771f, -0.03027467f, -0.12815703f, -0.14967266f, 0.08737527f, -0.08699121f, 0.16529174f, 
    0.02730142f, -0.05329888f, 0.09734887f, 0.03208618f, -0.04855626f, -0.01747204f, 0.07188615f, 0.02765589f, 
    0.19840756f, 0.10170164f, 0.01039360f, -0.01484994f, 0.01333619f, 0.04143219f, 0.05727969f, 0.05062763f, 
    -0.00561755f, -0.01462255f, -0.08005588f, -0.03025522f, 0.10517414f, 0.04697173f, 0.04913358f, 0.04192615f, 
    0.06115201f, 0.03167385f, 0.10566398f, 0.02437604f, -0.00145483f, 0.05280090f, 0.00657074f, -0.06501020f, 
    0.21034099f, 0.26890862f, 0.08766887f, -0.08903315f, -0.02041810f, 0.00297943f, 0.03383832f, 0.05116538f, 
    0.02948486f, 0.03961709f, -0.01243168f, -0.00262185f, -0.06360228f, 0.07445617f, 0.02144754f, 0.13112207f, 
    0.05900791f, 0.03697771f, -0.06635777f, 0.07574409f, 0.03106448f, 0.04342938f, 0.08248476f, 0.19382100f, 
    -0.10590837f, 0.02251422f, 0.05178169f, -0.02959346f, 0.06663882f, 0.08697104f, -0.02596349f, -0.05955293f, 
    -0.01327460f, 0.05073428f, -0.04066840f, 0.05184594f, 0.21759833f, 0.02618360f, 0.11823518f, 0.13427183f, 
    -0.01381824f, -0.00187600f, 0.06166730f, -0.01226342f, 0.02671312f, -0.06307339f, -0.00263181f, -0.04478603f, 
    -0.00275593f, -0.03513372f, -0.00899417f, -0.03048267f, -0.03858897f, -0.01476450f, -0.02554607f, 0.00347876f, 
    0.01688555f, -0.00059367f, 0.01010261f, -0.02456164f, -0.00934533f, 0.00973603f, -0.02285906f, 0.01899118f, 
    0.01741080f, 0.02447939f, -0.03223023f, -0.04005328f, 0.01691745f, -0.01145953f, 0.01600288f, -0.02331651f, 
    0.00156367f, 0.01039140f, 0.02030455f, 0.00150189f, 0.03641661f, 0.02455066f, 0.01416948f, -0.00288643f, 
    -0.01495963f, 0.01001417f, 0.01958135f, 0.00648852f, 0.01881301f, -0.03477803f, 0.00871841f, -0.00123004f, 
    -0.03520531f, 0.02629099f, -0.01265310f, -0.00181485f, 0.01748654f, -0.03052791f, -0.03598205f, 0.00464985f, 
    0.01344324f, -0.00028625f, -0.02850527f, -0.03595922f, 0.00132503f, -0.04018350f, -0.02361746f, -0.02459557f, 
    0.00423592f, -0.02172230f, 0.00306630f, 0.00821355f, -0.04340466f, -0.04009261f, -0.03793827f, -0.01309981f, 
    -0.02331034f, -0.04004609f, -0.03158758f, -0.02119077f, -0.02893138f, 0.01807321f, -0.00025079f, -0.02977796f, 
    -0.02673284f, -0.03314383f, 0.01453121f, 0.01247021f, 0.03059022f, -0.01191690f, -0.01078062f, 0.01118851f, 
    -0.00547001f, 0.01768327f, -0.02559434f, 0.01009909f, 0.02729834f, 0.02115431f, -0.02913799f, -0.01862521f, 
    0.00010024f, -0.04109668f, 0.00160900f, -0.01177492f, 0.01160694f, -0.00635935f, -0.03751681f, 0.02050207f, 
    0.02618571f, -0.02325806f, 0.00776779f, 0.02559413f, -0.02613103f, -0.02401029f, -0.04046250f, -0.00790634f, 
    -0.00104096f, -0.02132672f, -0.00789146f, -0.03252565f, -0.01991697f, 0.00886085f, 0.00067206f, 0.02160242f, 
    0.02151224f, -0.02664827f, 0.01837432f, 0.00896202f, -0.00113937f, -0.03576091f, -0.01053482f, -0.02843793f, 
    -0.01964212f, -0.01476319f, -0.00027889f, -0.02041158f, 0.00619086f, 0.00105229f, -0.00643027f, 0.01583579f, 
    -0.00127794f, 0.01945524f, 0.01667210f, 0.00386205f, -0.04560625f, 0.03282120f, 0.00666607f, -0.04089873f, 
    0.00120074f, 0.02308389f, -0.02885800f, -0.04038262f, 0.02344633f, 0.02025820f, -0.01248339f, 0.02604664f, 
    -0.04428662f, -0.02574009f, 0.00133406f, -0.01462402f, 0.01646416f, -0.03891625f, 0.00518485f, -0.03718904f, 
    -0.01425640f, -0.04051614f, 0.00144601f, -0.00795452f, -0.01296653f, -0.03054938f, -0.02526620f, 0.01240897f, 
    0.02015604f, -0.02670495f, -0.03240614f, -0.02044926f, 0.00930789f, 0.00613039f, 0.00095546f, -0.00836373f, 
    -0.02232107f, -0.03410208f, -0.03948227f, -0.01813131f, -0.03195511f, -0.01031413f, 0.00421367f, -0.01141624f, 
    0.00409175f, 0.02135215f, 0.01819110f, -0.03392727f, 0.02642155f, -0.02494621f, -0.02327140f, -0.03999903f, 
    -0.01582521f, 0.02935606f, 0.00623938f, 0.01783266f, -0.02517773f, -0.02631035f, 0.02511578f, -0.00354164f, 
    -0.03026241f, 0.01041084f, -0.00255398f, -0.02091947f, 0.00577848f, 0.02108107f, 0.02259985f, 0.00816649f, 
    0.02181761f, -0.04038367f, -0.03898950f, -0.01916924f, -0.01032894f, -0.04315211f, 0.00263157f, 0.00513731f, 
    -0.01617154f, 0.01857745f, 0.00569739f, -0.01575841f, 0.02988765f, -0.02518474f, 0.01081013f, 0.02161316f, 
    -0.02812938f, 0.01344561f, 0.01181262f, -0.01471794f, -0.03197268f, -0.00281945f, -0.03090191f, -0.00808995f, 
    -0.03195349f, -0.03881812f, 0.00911956f, 0.02485973f, 0.01359923f, -0.03063682f, 0.03942712f, 0.00000196f, 
    0.01433757f, -0.02829621f, -0.02005921f, -0.03690020f, -0.02218498f, -0.03669212f, -0.00957802f, -0.01438589f, 
    0.00631408f, 0.00182146f, 0.00861319f, -0.04039092f, 0.01011085f, 0.00868701f, -0.01020729f, 0.02538477f, 
    -0.03971215f, 0.02715687f, -0.04638721f, -0.00982255f, 0.01563372f, 0.00619046f, 0.01259630f, -0.02276808f, 
    0.02264688f, 0.00064519f, 0.02171364f, -0.00152421f, 0.00883548f, -0.00700068f, -0.02527021f, -0.01481706f, 
    -0.01518283f, 0.00550323f, -0.02049964f, 0.02542388f, -0.03504286f, -0.02336139f, -0.01674359f, 0.02476055f, 
    -0.00298712f, -0.03106659f, -0.03679790f, -0.00749008f, 0.00850390f, 0.02221780f, -0.02516985f, -0.00966169f, 
    0.02492624f, 0.02596676f, -0.00671367f, 0.01098387f, -0.00446109f, 0.02023851f, 0.02001505f, 0.02177342f, 
    -0.01864332f, -0.02370582f, -0.00756554f, 0.00430625f, 0.02345247f, 0.02396348f, -0.01431377f, 0.00975208f, 
    0.01110202f, -0.02062281f, -0.00786906f, -0.03141093f, -0.01522517f, -0.00309474f, -0.03103607f, -0.01612931f, 
    0.00278311f, 0.00339122f, 0.00925498f, 0.00735400f, -0.01685177f, -0.00998188f, -0.01979181f, -0.01291087f, 
    0.01939114f, 0.01757699f, 0.01257599f, 0.01526543f, 0.01812881f, -0.01595788f, -0.03559918f, 0.02273791f, 
    -0.01473286f, -0.01848670f, 0.00449585f, -0.03037855f, 0.01312008f, -0.01462103f, -0.04623552f, -0.02119237f, 
    -0.02364345f, -0.00458603f, -0.04580411f, -0.02917593f, -0.01974511f, 0.02148399f, 0.03335435f, -0.00851477f, 
    -0.02027109f, 0.00967588f, 0.01219224f, -0.01621291f, -0.02985970f, 0.02941330f, 0.01788726f, -0.03598312f, 
    -0.04046836f, -0.02777498f, 0.02666580f, -0.02284800f, -0.04241557f, -0.00478077f, 0.01679671f, -0.04085507f, 
    0.01958548f, 0.01826930f, -0.01368236f, 0.00879821f, -0.01858277f, -0.04294081f, -0.01083042f, 0.02029223f, 
    0.00199817f, -0.03590781f, -0.04250988f, 0.01724238f, -0.04188719f, -0.02935909f, -0.00034717f, -0.01024727f, 
    -0.00044328f, -0.02578179f, -0.01120160f, -0.00817380f, -0.03172851f, -0.00250100f, -0.00461394f, 0.00508751f, 
    -0.00014342f, -0.00212874f, -0.00345364f, -0.02169903f, -0.02905079f, 0.01932682f, -0.03467055f, -0.04240542f, 
    -0.03131177f, -0.00807477f, 0.02452254f, -0.00263360f, -0.04128409f, -0.02432305f, -0.00185410f, 0.03046521f, 
    -0.02844980f, -0.02760153f, -0.03363433f, 0.00201175f, -0.03250433f, -0.01546159f, 0.02297605f, 0.01528614f, 
    -0.00845916f, -0.03554094f, -0.02921745f, 0.01833494f, 0.01982084f, -0.01231965f, 0.02450110f, -0.01442785f, 
    0.00173345f, -0.03403109f, -0.02090102f, -0.03885958f, 0.00017837f, -0.03284778f, 0.01487651f, -0.03924407f, 
    -0.03216265f, 0.01240525f, 0.01680300f, -0.03867029f, -0.03605426f, 0.00894778f, 0.01134675f, -0.03715066f, 
    0.02702555f, 0.02299794f, -0.01929002f, 0.00537725f, -0.01484720f, -0.01427851f, -0.00374719f, -0.00416169f, 
    0.00530591f, -0.03886180f, 0.01484216f, 0.01484266f, 0.00663401f, -0.00002221f, -0.00481076f, 0.01715573f, 
    -0.01485345f, -0.02219757f, -0.00804451f, 0.00817244f, 0.02437349f, -0.02391945f, 0.02718307f, -0.02275266f, 
    0.01368745f, 0.01206331f, -0.00842694f, 0.02556776f, 0.01494378f, 0.01464064f, -0.01201627f, 0.00692163f, 
    -0.01706394f, -0.02031440f, 0.01152213f, -0.03212848f, -0.01632839f, -0.00370230f, -0.04311130f, -0.02951679f, 
    -0.02415552f, 0.01853659f, -0.01307180f, -0.03108823f, -0.02877782f, 0.01251411f, -0.01238570f, -0.01010853f, 
    0.00846281f, 0.02133561f, -0.03458702f, -0.01203549f, -0.03955340f, -0.01785914f, 0.02616063f, 0.02256802f, 
    -0.03608781f, 0.03079878f, -0.01403926f, -0.01727888f, 0.01927640f, 0.02633372f, -0.04089794f, -0.02848040f, 
    -0.01217313f, -0.02148891f, -0.00911883f, -0.02064300f, 0.00375365f, 0.00325575f, -0.01803354f, 0.02178341f, 
    0.03652010f, 0.02366043f, -0.04618204f, -0.04071802f, 0.00675020f, 0.01735873f, 0.00384832f, 0.02599214f, 
    0.01120175f, -0.03021739f, -0.02032305f, -0.01452821f, 0.02491752f, 0.00092456f, -0.00150094f, 0.02998428f, 
    -0.00856580f, -0.02366923f, -0.03408827f, -0.04824020f, -0.03799777f, 0.03138524f, -0.03263950f, -0.00888249f, 
    0.00148942f, -0.03282240f, -0.00052599f, -0.00280279f, 0.00657162f, 0.00292088f, 0.02156898f, -0.00523185f, 
    0.00321488f, 0.01736916f, -0.03564399f, 0.00605577f, -0.03125833f, 0.02428839f, -0.03881334f, -0.03883586f, 
    -0.03481613f, -0.02352836f, -0.02189345f, -0.03720482f, 0.00195028f, 0.02192716f, 0.02970640f, 0.03114788f, 
    -0.04040100f, -0.03524839f, 0.01402178f, 0.02018446f, 0.00817776f, 0.02928432f, -0.00623882f, -0.02059085f, 
    -0.03827196f, 0.02086027f, 0.02480548f, -0.00132342f, 0.02942697f, 0.01056538f, 0.02581965f, 0.00976675f, 
    0.01930722f, 0.02081057f, -0.03919221f, 0.00268164f, -0.00002261f, -0.02263681f, -0.00235609f, 0.01196736f, 
    0.00047545f, -0.01006657f, 0.00256095f, -0.00456249f, -0.01174079f, -0.01551131f, -0.00792710f, 0.02398656f, 
    -0.03718946f, -0.00081896f, -0.04167823f, -0.02602194f, 0.00134731f, 0.01291306f, 0.01071788f, 0.00236244f, 
    -0.03759465f, 0.00596482f, 0.00215611f, 0.02120917f, 0.01408890f, 0.00816682f, -0.01860384f, -0.01183141f, 
    -0.02642351f, 0.03151015f, -0.00290356f, -0.03135443f, -0.01587391f, 0.00392476f, 0.02814951f, 0.02030143f, 
    0.02196730f, 0.02583412f, 0.02811524f, -0.00485538f, 0.02052630f, 0.00740112f, 0.02288650f, -0.00409649f, 
    -0.04346656f, -0.01803576f, -0.01628130f, -0.02181923f, 0.00883195f, -0.02021871f, 0.02165591f, -0.00580492f, 
    -0.00394534f, 0.02018213f, -0.00542755f, 0.00293941f, 0.02580569f, 0.00040284f, 0.01067879f, -0.02410911f, 
    -0.00765111f, -0.03945658f, 0.02887345f, 0.02013128f, -0.02549690f, -0.00335017f, 0.02299638f, -0.02514126f, 
    -0.01607333f, -0.00170072f, 0.01446197f, 0.00624359f, -0.00549903f, -0.02181544f, 0.02632256f, -0.01218787f, 
    0.02877711f, 0.00544834f, -0.02207498f, -0.01250767f, 0.00563310f, -0.00791243f, 0.02469306f, -0.03189201f, 
    -0.00765474f, -0.01098034f, 0.01028043f, 0.00011771f, 0.01102275f, 0.02080051f, -0.03901093f, 0.01834819f, 
    -0.01672961f, -0.04009297f, -0.04080954f, -0.00464146f, -0.03544376f, -0.00999992f, -0.00816803f, -0.00007694f, 
    0.00399262f, -0.02640394f, 0.00382059f, -0.00043258f, -0.00851858f, 0.00493188f, 0.01088642f, 0.03191988f, 
    -0.02283090f, 0.00368073f, 0.02040699f, -0.01484800f, -0.03350429f, 0.02168219f, 0.01144607f, 0.01514375f, 
    0.00157642f, 0.00097440f, 0.01665122f, 0.00807024f, -0.03220715f, 0.00520498f, 0.03138340f, 0.00932934f, 
    0.02031096f, 0.03289931f, 0.00334533f, -0.00269892f, -0.03269317f, -0.01222696f, -0.02638673f, -0.01558901f, 
    -0.02330576f, -0.02848315f, -0.01879324f, -0.02523210f, -0.03475059f, -0.02897998f, 0.00834963f, 0.00375236f, 
    -0.01348939f, 0.01430321f, -0.02959440f, 0.01516234f, -0.03592379f, 0.00793063f, -0.01300054f, 0.02203564f, 
    -0.00079903f, 0.00180082f, -0.01116138f, -0.02864815f, -0.03147687f, 0.00010967f, 0.01022650f, -0.02241691f, 
    -0.02298856f, 0.02116369f, 0.01265640f, -0.02550191f, -0.03597766f, 0.02088444f, -0.02242450f, -0.01430882f, 
    -0.03809099f, -0.03779954f, -0.01649374f, 0.01705818f, 0.00102630f, -0.01704458f, -0.00883298f, -0.01522858f, 
    -0.01357907f, -0.02786816f, -0.02932240f, 0.03235443f, -0.02334133f, 0.00952182f, -0.03548423f, -0.04345547f, 
    -0.02034789f, 0.00664010f, -0.01886218f, -0.02344262f, -0.03209374f, -0.02809020f, 0.01267464f, 0.02184142f, 
    0.00145918f, -0.00510853f, -0.02372981f, 0.02490024f, -0.00318764f, -0.03621347f, -0.01527977f, 0.00965486f, 
    -0.02587553f, -0.01442391f, 0.01042672f, -0.01886073f, 0.03393301f, -0.03870751f, -0.00379820f, 0.02366574f, 
    0.08424176f, -0.15254252f, 0.02940192f, -0.11624452f, 0.06243422f, 0.05952917f, 0.01453367f, -0.00858588f, 
    -0.01829095f, 0.03615122f, -0.08673394f, -0.02159907f, -0.03797254f, -0.03195670f, 0.02538885f, -0.16663089f, 
    0.01298530f, 0.01953484f, -0.00791091f, -0.02602605f, 0.00431408f, 0.01136237f, 0.00102990f, -0.00597139f, 
    0.06636587f, -0.03924146f, 0.01540390f, 0.02607507f, -0.05875330f, -0.01343035f, 0.04598922f, -0.02011122f, 
    -0.00012683f, -0.03077041f, 0.05894783f, 0.06253802f, 0.22383216f, -0.18472815f, 0.07251467f, -0.03430906f, 
    0.02641940f, 0.02661049f, 0.07369230f, -0.15020543f, -0.03302364f, 0.04172971f, -0.08024254f, -0.01508126f, 
    -0.05801339f, 0.05212163f, -0.03328767f, -0.05358464f, 0.03531217f, 0.06868256f, 0.04544808f, -0.06615123f, 
    0.04029024f, -0.00286982f, -0.02267144f, 0.06654105f, -0.18908545f, -0.07303955f, -0.05382093f, -0.09564517f, 
    -0.02708086f, 0.05189680f, 0.01491220f, -0.06979243f, 0.00242424f, -0.01793594f, 0.12411512f, 0.04536473f, 
    0.04526027f, -0.27810854f, -0.02034914f, -0.10724337f, 0.02868479f, 0.02467202f, -0.01916490f, -0.15285030f, 
    -0.00417328f, -0.00504702f, 0.07832557f, 0.04248595f, 0.00857616f, -0.00392720f, -0.13469797f, -0.03674364f, 
    0.05304477f, -0.02086151f, -0.13342838f, -0.10595457f, 0.05737843f, 0.00376359f, -0.02428030f, 0.03115438f, 
    0.15437301f, -0.14986552f, -0.10821439f, 0.04008665f, -0.07142332f, -0.00406389f, 0.01778602f, 0.02888085f, 
    -0.00184711f, -0.04393849f, 0.02808608f, 0.01142684f, -0.25538209f, -0.02564231f, 0.01593140f, 0.02302008f, 
    -0.00919888f, 0.04167413f, -0.01556022f, -0.05411851f, -0.02867486f, 0.04814214f, 0.03975457f, 0.02314300f, 
    0.03290526f, 0.18639140f, 0.01518512f, -0.02672185f, 0.00966568f, 0.00585412f, 0.03676035f, 0.14170241f, 
    0.01688626f, 0.03785803f, 0.02674728f, 0.00914859f, -0.26268452f, 0.30875111f, -0.02492950f, -0.05148662f, 
    -0.03530665f, -0.08904820f, 0.06386515f, 0.03540592f, 0.04490973f, 0.01657248f, -0.01534447f, 0.04241172f, 
    0.02612896f, -0.14948505f, 0.17951886f, 0.18992628f, 0.09789259f, -0.07246835f, 0.01320578f, 0.04065401f, 
    0.12062200f, -0.03410863f, -0.04549136f, 0.04640821f, 0.14690620f, -0.07836584f, 0.17088045f, 0.04573618f, 
    0.00376404f, 0.03853153f, -0.05132441f, 0.01578389f, 0.07884771f, 0.03109074f, -0.00270112f, -0.01641459f, 
    -0.06839611f, 0.09338693f, -0.13995160f, 0.00066329f, -0.08912834f, -0.03857588f, -0.02247841f, -0.01647433f, 
    0.00794041f, -0.01640113f, -0.01911652f, -0.06194864f, -0.24341552f, 0.15093273f, 0.11127089f, 0.07139088f, 
    -0.03083535f, -0.02745363f, 0.00560064f, -0.00079196f, 0.09545357f, -0.00555346f, -0.00964193f, -0.02653535f, 
    -0.01230426f, -0.10932238f, 0.00776736f, -0.07141497f, 0.05789698f, 0.01951419f, 0.03704549f, -0.06634913f, 
    0.05139648f, -0.04694790f, 0.01829538f, 0.06680719f, -0.08708395f, 0.07794335f, -0.10550795f, 0.05761149f, 
    0.03432759f, -0.00452459f, -0.02042705f, 0.02764426f, 0.01150753f, 0.03241697f, -0.01306194f, 0.09135398f, 
    0.09369073f, -0.16710262f, -0.00079948f, 0.00118775f, -0.02992700f, -0.05838361f, 0.03034031f, -0.07986885f, 
    -0.02455482f, -0.04665405f, -0.05451694f, 0.03660275f, -0.06045656f, -0.04903205f, -0.13408081f, 0.13256250f, 
    -0.01687695f, -0.02637767f, -0.03772129f, -0.01361223f, 0.00158398f, -0.04009294f, -0.01779432f, 0.02295816f, 
    0.05944688f, 0.09244090f, 0.19614205f, 0.06056205f, -0.09022784f, -0.00278620f, 0.06043733f, 0.12038606f, 
    -0.05495332f, 0.08527622f, -0.00924961f, 0.04861156f, 0.19518267f, -0.16733979f, 0.24282004f, 0.06700332f, 
    -0.09135812f, 0.02967072f, -0.03054662f, 0.03895294f, 0.00868462f, -0.01425535f, 0.07552087f, 0.08971879f, 
    0.15345919f, -0.00857817f, 0.05057704f, 0.17712562f, -0.03610547f, 0.00333354f, -0.00702575f, 0.04841917f, 
    -0.01864778f, 0.00209467f, 0.07715405f, 0.09567965f, -0.01030301f, -0.18997051f, -0.14933860f, 0.04184237f, 
    -0.05970120f, 0.06929766f, -0.02482394f, 0.04696644f, -0.06908089f, 0.00030848f, -0.00859440f, 0.09080016f, 
    0.09291882f, -0.02471390f, 0.07999782f, 0.15414082f, -0.08303571f, -0.01168428f, 0.12320154f, 0.10573723f, 
    0.00898833f, 0.09364504f, 0.03695437f, -0.02123398f, -0.01757504f, -0.02935988f, 0.03186993f, 0.00581958f, 
    -0.03624656f, -0.03759976f, -0.05692886f, -0.01814586f, -0.04976886f, 0.01469361f, 0.05892404f, 0.06036216f, 
    -0.21803811f, 0.07910153f, 0.29497480f, 0.01692129f, 0.02763311f, -0.00282654f, -0.05097895f, 0.00183989f, 
    0.01336825f, 0.01833490f, 0.03192338f, -0.02411231f, -0.12934974f, -0.05065181f, 0.01207760f, 0.04510093f, 
    0.12725645f, 0.04113173f, -0.01821740f, 0.09356029f, 0.01104958f, -0.04811691f, -0.01861522f, 0.04406733f, 
    -0.09824043f, -0.15223707f, -0.09935819f, 0.05444205f, -0.06703856f, 0.08038392f, -0.08140254f, 0.10097000f, 
    -0.00382428f, -0.00129451f, 0.11019599f, 0.00047516f, -0.04529949f, 0.12125110f, -0.06004232f, -0.07800708f, 
    -0.00625406f, -0.00878581f, 0.01905918f, -0.13946216f, 0.02693594f, -0.06796925f, 0.12404142f, 0.02931521f, 
    -0.17991063f, 0.02870317f, -0.01579058f, -0.01990409f, -0.02060040f, 0.04784119f, 0.03303917f, 0.06217261f, 
    -0.07503098f, 0.11780585f, 0.09054008f, -0.01644215f, -0.19973959f, -0.00179980f, -0.02214743f, 0.03739116f, 
    -0.06520975f, 0.06478313f, -0.01740959f, -0.02558950f, 0.08972321f, -0.04804614f, -0.00477017f, -0.07795616f, 
    0.07795195f, 0.00544727f, -0.01113062f, 0.18870220f, -0.05216488f, 0.05756736f, -0.05067465f, -0.13994488f, 
    -0.03376728f, 0.08451999f, -0.03588431f, 0.07098293f, -0.20104836f, 0.18261695f, 0.00762891f, -0.11795218f, 
    0.03894949f, 0.06123449f, 0.00751325f, -0.00259826f, 0.12497198f, -0.05383984f, 0.01722010f, -0.06096613f, 
    -0.02875639f, 0.05316278f, -0.04452530f, 0.04922162f, 0.00826569f, 0.02259846f, 0.00167783f, 0.08061325f, 
    -0.00434876f, 0.04474206f, -0.04703631f, 0.06538509f, -0.01530518f, 0.16203965f, 0.09162977f, 0.03015472f, 
    -0.06428969f, -0.03377103f, -0.00862745f, 0.02185201f, 0.00097515f, 0.00013062f, -0.11842593f, -0.01280647f, 
    0.01639281f, 0.03134335f, -0.20207570f, -0.04706409f, -0.00899230f, 0.09321878f, -0.01385398f, -0.09765502f, 
    0.07257857f, 0.01951598f, 0.05508818f, -0.00664040f, 0.04182174f, 0.11627459f, 0.04998299f, -0.01982957f, 
    -0.06036296f, -0.01881061f, 0.01981038f, 0.06745221f, -0.10984257f, 0.04224185f, -0.08856088f, -0.06439469f, 
    0.10883193f, 0.04302457f, -0.05747916f, 0.01347623f, -0.03195992f, 0.07247368f, 0.01947053f, -0.01487496f, 
    0.01715589f, 0.02656678f, 0.08257026f, -0.00070446f, -0.18965136f, 0.03087468f, 0.00445194f, 0.09218079f, 
    -0.00602530f, -0.02752931f, 0.04938610f, 0.02772137f, 0.04123649f, -0.03448457f, -0.05615810f, 0.01397484f, 
    0.06424200f, 0.03724106f, -0.00315444f, -0.10482061f, 0.10687704f, 0.00145627f, 0.04031103f, -0.17576630f, 
    0.06778724f, 0.06378572f, 0.00955594f, 0.12755185f, 0.24597234f, -0.09081581f, 0.14976461f, -0.06211706f, 
    -0.13853563f, 0.01770905f, 0.01681637f, 0.00282116f, 0.11100325f, -0.00441046f, -0.01427973f, -0.01173191f, 
    0.12779380f, 0.07449793f, 0.11186835f, 0.06426882f, 0.01110852f, -0.00805017f, 0.03115325f, -0.10860279f, 
    0.00003970f, 0.02524838f, -0.00866847f, -0.07171324f, -0.32914060f, 0.09713800f, 0.05367727f, -0.03221807f, 
    0.08852118f, 0.01571815f, -0.07782511f, -0.12152584f, 0.03601910f, -0.03715061f, 0.03058218f, 0.00822632f, 
    0.14383608f, -0.03249315f, 0.03459341f, 0.17681286f, 0.03889033f, 0.04773144f, 0.06386723f, -0.05724332f, 
    -0.01784851f, -0.10954183f, -0.00593707f, 0.11066752f, 0.05656454f, 0.11811871f, 0.08225632f, 0.14478998f, 
    -0.08266065f, 0.04188431f, 0.03439841f, 0.03379566f, 0.03919078f, 0.00735581f, 0.08395447f, 0.07913994f, 
    0.02782376f, -0.01386161f, 0.03854987f, 0.01093868f, -0.05255640f, 0.06489628f, 0.12149469f, -0.04328641f, 
    -0.03655434f, -0.02216925f, -0.09239779f, 0.00880630f, 0.17647439f, 0.07791157f, -0.00630460f, 0.00457055f, 
    -0.02641184f, 0.00070034f, -0.05397699f, -0.02469970f, -0.00756322f, -0.03313584f, 0.12266413f, -0.02009482f, 
    0.19273673f, 0.24596395f, 0.05568513f, -0.18397605f, 0.01527009f, 0.08276512f, 0.00113374f, -0.02237779f, 
    0.05141849f, -0.03860405f, 0.12952785f, -0.05936195f, 0.15766329f, -0.05863330f, 0.03982967f, 0.16787979f, 
    -0.08283515f, 0.13137998f, 0.05034559f, 0.00572313f, 0.02512673f, 0.01112288f, -0.04861633f, -0.00192975f, 
    0.10515948f, -0.14401248f, 0.11272531f, 0.11201750f, -0.12594423f, 0.09990605f, -0.01564408f, 0.08504750f, 
    -0.02946153f, 0.02769168f, -0.02522272f, 0.12726010f, -0.05541192f, -0.09666532f, -0.03402933f, 0.23746660f, 
    -0.04043261f, 0.04431270f, -0.06851785f, 0.02833398f, 0.01162775f, -0.02487741f, 0.04096338f, -0.03413916f, 
    0.03115437f, -0.06209342f, 0.12587495f, 0.27265394f, -0.07611040f, 0.01847279f, 0.04972633f, 0.03346065f, 
    0.01320277f, -0.04032421f, 0.13779828f, 0.06516868f, 0.15151465f, 0.07440017f, 0.00817579f, 0.09415557f, 
    -0.10274143f, 0.00044738f, 0.05885335f, 0.01327793f, -0.04507191f, 0.01807727f, -0.00820210f, -0.05248230f, 
    0.18342462f, 0.07928804f, -0.03907608f, 0.06119655f, 0.00482233f, 0.11972927f, -0.01179014f, 0.10747182f, 
    0.04269600f, -0.11479867f, 0.07554069f, -0.01430149f, -0.05065783f, -0.04820478f, 0.05568695f, 0.03394069f, 
    -0.11152895f, 0.01935537f, 0.01531966f, 0.00451111f, -0.01456500f, -0.03134872f, -0.09793696f, 0.07395939f, 
    -0.05813607f, -0.04626086f, 0.12260512f, 0.01955121f, -0.03153622f, -0.05813976f, 0.04640492f, 0.06385829f, 
    0.01004053f, 0.03087178f, 0.00655931f, 0.07357494f, 0.20313606f, -0.03602165f, 0.10841786f, 0.11064991f, 
    -0.05389213f, -0.09257384f, -0.04729707f, 0.01353604f, 0.02539745f, -0.03369322f, 0.03853879f, 0.00621211f, 
    -0.02565671f, 0.02967972f, 0.23262900f, 0.06978831f, -0.13411386f, 0.03804236f, 0.02137449f, 0.05972816f, 
    0.04615802f, 0.11647810f, 0.03228324f, 0.06581730f, 0.04042687f, 0.08093727f, 0.09581184f, 0.02664374f, 
    -0.12350222f, 0.00068727f, 0.02349654f, 0.08865735f, -0.03859718f, -0.01997592f, 0.03677721f, -0.05832368f, 
    0.03940568f, 0.03212665f, 0.01223846f, 0.10898529f, -0.02779637f, -0.02043404f, 0.04246690f, 0.03745741f, 
    0.06962717f, 0.01738754f, 0.14863238f, -0.04343023f, -0.03814893f, -0.11277768f, 0.10370000f, -0.00663270f, 
    0.03795076f, -0.02790555f, 0.09166200f, -0.03624552f, -0.01926714f, -0.05896324f, -0.04272505f, -0.03843670f, 
    -0.09940905f, 0.09098405f, -0.03939172f, -0.02179431f, -0.03675339f, 0.04489776f, 0.07257836f, -0.00569225f, 
    -0.03518980f, -0.07201465f, 0.12961836f, 0.03368664f, -0.14317356f, 0.14020967f, 0.00393957f, 0.03567336f, 
    0.05312512f, 0.06784578f, 0.02102068f, 0.04065346f, 0.07593464f, 0.03595772f, -0.03424093f, 0.05690289f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01904034f, 0.02234645f, 0.02134638f, -0.00235813f, 0.04444750f, 0.06398521f, -0.02957699f, -0.03474258f, 
    0.10612681f, -0.00853134f, 0.07613796f, 0.03824002f, 0.05988719f, -0.03797181f, -0.03175465f, -0.00100952f, 
    -0.01167097f, 0.02441103f, -0.01933085f, 0.01401663f, 0.07819678f, -0.00126288f, 0.01074475f, 0.05061857f, 
    0.01621641f, 0.00978353f, -0.00622450f, -0.01159135f, 0.00620228f, 0.04165449f, 0.01594759f, 0.01934102f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10406567f, 0.11935783f, -0.04584287f, -0.11262861f, -0.16951711f, -0.17578667f, -0.06281953f, 0.12755750f, 
    0.01651681f, -0.03106106f, -0.35581055f, 0.40614507f, -0.14345615f, -0.00618206f, -0.01733763f, 0.57935429f, 
    0.23850346f, -0.00741060f, 0.01115613f, -0.02876537f, 0.09643473f, -0.32826561f, -0.03066301f, 0.43363282f, 
    0.17157643f, -0.16178150f, -0.05570059f, -0.07591499f, 0.31574658f, -0.04539357f, 0.00760039f, -0.27270409f, 
    0.07162346f, -0.24321620f, 0.08013399f, 0.05025994f, -0.03436465f, 0.08005618f, -0.07606973f, 0.16823921f, 
    0.31397602f, -0.08178106f, 0.24487175f, -0.03979691f, 0.59288216f, 0.08421586f, -0.14428964f, -0.41126111f, 
    -0.00750762f, 0.07100586f, -0.03043241f, 0.04349531f, 0.11005617f, -0.21206026f, -0.08078036f, -0.27107543f, 
    0.02154855f, 0.15217592f, -0.03023678f, 0.02087509f, -0.26907921f, 0.08968415f, 0.02845762f, 0.29176754f, 
    0.05975638f, 0.07503275f, -0.09602495f, -0.16576822f, -0.16304158f, -0.02453715f, -0.02834561f, -0.08058538f, 
    0.12091827f, -0.15506861f, -0.17521366f, -0.03904153f, 0.01849286f, -0.13009988f, 0.06975857f, 0.07606339f, 
    -0.03553135f, -0.06762265f, 0.06154903f, 0.01725361f, -0.10932675f, 0.15918557f, -0.10151683f, -0.11610609f, 
    0.12734370f, -0.15679775f, -0.13804458f, 0.15482859f, 0.08260314f, -0.18124506f, -0.11178759f, -0.10366549f, 
    0.30318153f, -0.02424178f, -0.03291411f, 0.13308272f, 0.23471726f, -0.19616754f, -0.04785825f, -0.04335631f, 
    0.05346037f, -0.02484343f, -0.06674336f, -0.13722941f, 0.09360009f, -0.03913842f, 0.00829875f, -0.10863228f, 
    -0.08966051f, 0.07621555f, 0.07813843f, 0.40060997f, -0.03681719f, 0.20594756f, 0.01296717f, -0.17840445f, 
    0.05976268f, -0.05438261f, 0.12318554f, -0.02251216f, 0.21339181f, 0.27923638f, 0.10517378f, -0.11076713f, 
    -0.00476169f, -0.13054855f, -0.16611654f, -0.13867894f, 0.06000900f, 0.01364127f, 0.05745471f, -0.15599038f, 
    -0.09689771f, 0.01705344f, -0.03192295f, -0.16884360f, -0.05376102f, 0.04576619f, 0.11136177f, 0.00931273f, 
    -0.10476758f, -0.05427698f, 0.11527559f, -0.07501403f, 0.03442618f, -0.04923709f, 0.01058937f, 0.00116351f, 
    -0.16628432f, -0.05330339f, 0.17247067f, -0.01496816f, -0.03014886f, 0.00115699f, -0.00026949f, 0.02655852f, 
    0.25045577f, -0.10322805f, 0.16957824f, -0.09870899f, 0.32212737f, 0.10071462f, -0.16244458f, 0.03277366f, 
    0.28841040f, 0.11201267f, 0.33396733f, -0.06968520f, 0.14192721f, -0.15973662f, 0.02358854f, 0.23050304f, 
    -0.02315165f, 0.02509176f, 0.12321927f, 0.23345724f, 0.00085359f, -0.20191988f, 0.09914048f, 0.04608174f, 
    -0.04899887f, 0.12018427f, -0.16661245f, -0.08767886f, -0.00850308f, -0.16406842f, -0.02192708f, -0.22085257f, 
    0.23806924f, -0.11449629f, 0.16219509f, -0.08975816f, 0.26012570f, 0.04828664f, 0.10200764f, -0.07822914f, 
    -0.03557006f, 0.04837747f, 0.34856117f, -0.19834237f, -0.38754028f, 0.30075401f, 0.01264359f, 0.04030772f, 
    -0.29154450f, 0.14613518f, -0.02565370f, 0.01266535f, -0.21814917f, 0.26202947f, 0.10543156f, 0.14284877f, 
    -0.03300419f, 0.15886441f, 0.13172895f, -0.06822409f, -0.01426014f, 0.00598661f, 0.12163780f, 0.20240787f, 
    0.31341636f, -0.34274724f, 0.10477198f, 0.15390432f, 0.06862488f, 0.03254239f, 0.00291355f, 0.00412463f, 
    -0.22350977f, 0.08699980f, -0.28761008f, 0.01444014f, -0.50793332f, 0.31173521f, -0.03966326f, 0.33314788f, 
    -0.01769709f, 0.17183848f, -0.05705190f, -0.20664872f, -0.09865532f, -0.19139016f, -0.14244980f, 0.05521069f, 
    0.13814624f, 0.14887087f, -0.04665268f, -0.04721394f, 0.27125049f, 0.23424158f, -0.05585676f, -0.20266020f, 
    -0.01046391f, -0.48244971f, 0.03537472f, -0.15199108f, -0.08643158f, 0.03445490f, 0.10504138f, -0.14099063f, 
    0.23479712f, 0.05864570f, -0.07100587f, 0.37157443f, 0.15201156f, 0.29996207f, 0.16462921f, -0.20630729f, 
    -0.25823081f, 0.00371010f, 0.10427327f, 0.03375100f, 0.15265569f, -0.04359816f, 0.07531610f, 0.06978672f, 
    0.00431071f, -0.14497063f, 0.00927667f, 0.13784657f, -0.08974920f, 0.13998592f, 0.03894947f, -0.23066960f, 
    0.00454674f, 0.34727415f, -0.01361301f, -0.07544513f, -0.03039639f, 0.22174655f, 0.12428012f, -0.14801042f, 
    -0.07876924f, 0.12987348f, 0.30886492f, -0.22463992f, 0.27996182f, 0.11836808f, -0.13880742f, -0.38514486f, 
    0.38592508f, -0.06624181f, 0.14007333f, -0.05732014f, -0.00648206f, -0.24086866f, -0.03001207f, -0.22287130f, 
    -0.07274926f, 0.21494058f, 0.10596558f, 0.12420873f, -0.02993114f, 0.11483432f, -0.06647842f, 0.10369730f, 
    0.34132054f, 0.09886505f, -0.17344154f, -0.15191408f, 0.28245243f, 0.08167370f, -0.14350663f, 0.10681025f, 
    -0.16122173f, 0.01394538f, 0.43066517f, 0.20157075f, -0.27130422f, 0.13039452f, -0.09834282f, -0.14604364f, 
    -0.12349521f, -0.02002045f, -0.15128669f, 0.12170828f, -0.18474077f, -0.16304998f, -0.14812149f, -0.24370913f, 
    0.16022179f, 0.00901364f, -0.12393698f, 0.07308131f, -0.12999722f, 0.13395725f, -0.02129734f, -0.16657831f, 
    0.18025459f, 0.18886924f, -0.04555292f, -0.11879437f, 0.01478358f, 0.04880991f, -0.07210357f, 0.12450507f, 
    -0.02146039f, -0.05909827f, 0.07126617f, -0.07538126f, 0.31858894f, -0.09218068f, 0.06353997f, -0.03571797f, 
    0.02817530f, 0.12510684f, 0.14186691f, -0.28590178f, 0.14527525f, -0.20175792f, 0.09149621f, 0.05707928f, 
    0.15606114f, -0.03945744f, -0.16624556f, 0.12242988f, 0.11723795f, 0.20057011f, -0.07762296f, -0.47462866f, 
    0.24414033f, 0.31192875f, 0.08588516f, -0.14772238f, -0.01041132f, 0.01638739f, 0.04740290f, 0.02183282f, 
    0.25481361f, 0.14064096f, 0.34296295f, -0.27711189f, 0.22302221f, -0.09938858f, -0.05910162f, 0.24400294f, 
    0.18268247f, 0.08283152f, 0.10474405f, 0.30234557f, 0.25226653f, -0.11732910f, 0.01780545f, -0.02591575f, 
    0.01809023f, 0.05586498f, 0.04182143f, -0.12969026f, -0.21710862f, -0.16191527f, -0.09766722f, 0.02984518f, 
    -0.05675089f, -0.50433666f, 0.12304819f, -0.16720814f, 0.29442149f, -0.04171443f, 0.14746429f, 0.01088682f, 
    0.00816117f, -0.16041349f, -0.33656019f, 0.22341318f, 0.16855983f, 0.09384942f, 0.14955600f, 0.18524440f, 
    -0.12002683f, 0.11796982f, 0.09485303f, -0.08328070f, 0.23880035f, 0.18630812f, 0.02627206f, 0.04492636f, 
    0.11136846f, 0.19493192f, -0.08141315f, 0.00276202f, -0.09882028f, -0.11551543f, -0.04920753f, 0.00843143f, 
    0.17043060f, -0.14927107f, 0.16392949f, -0.04701318f, 0.32338098f, -0.22931872f, 0.05243704f, -0.10040268f, 
    0.36250243f, -0.09865846f, -0.29700917f, -0.13158590f, -0.14456062f, -0.22887090f, -0.05450146f, -0.20382066f, 
    0.39042166f, -0.12340476f, -0.02928875f, -0.02852395f, 0.19699417f, -0.07477725f, 0.05002531f, 0.13116196f, 
    -0.03402458f, 0.21870118f, -0.01415436f, 0.10184933f, 0.34141594f, 0.20920141f, -0.02188021f, -0.08126681f, 
    -0.24764185f, 0.18799873f, 0.08263582f, 0.00426880f, 0.07810195f, 0.26508573f, 0.04173691f, 0.03345624f, 
    -0.22787368f, 0.11621308f, 0.22775054f, -0.08361754f, -0.13300738f, 0.22721300f, 0.04540450f, 0.34734213f, 
    -0.14548366f, -0.01739110f, -0.17832531f, -0.42777121f, -0.10944317f, 0.18386357f, -0.16942593f, 0.34716251f, 
    -0.02773001f, 0.08896986f, -0.05301882f, -0.05076145f, 0.02935238f, 0.19115831f, 0.06278007f, -0.22954592f, 
    0.11305193f, 0.14394303f, -0.16810657f, 0.09527607f, 0.06570981f, 0.02420321f, -0.10256351f, -0.12774616f, 
    -0.02442893f, -0.03194715f, -0.05757480f, -0.17544770f, -0.03811496f, 0.14640576f, -0.04632019f, -0.17031416f, 
    -0.16957402f, 0.15529530f, 0.07977037f, -0.18352768f, -0.03811426f, 0.15401570f, -0.01655110f, -0.01641934f, 
    -0.01546871f, -0.07036221f, -0.13655826f, 0.14405265f, 0.10439686f, -0.10989421f, 0.12379464f, -0.08828939f, 
    -0.22229879f, 0.16056553f, -0.04894052f, -0.08737504f, -0.24547510f, 0.21401440f, 0.02846583f, -0.09009276f, 
    0.24084809f, -0.00136739f, -0.02658946f, 0.29937339f, -0.48938504f, 0.14547840f, 0.05794496f, -0.28923523f, 
    -0.04664960f, 0.03430247f, -0.13243063f, 0.13487963f, 0.14992025f, 0.31114355f, 0.05513071f, 0.18753541f, 
    -0.10182873f, -0.26549122f, 0.12253895f, -0.12345573f, 0.20873648f, 0.04583345f, -0.03210305f, -0.06534051f, 
    -0.16471165f, 0.25246167f, 0.01312937f, -0.17038749f, -0.22704503f, 0.08291648f, -0.15245302f, -0.16375375f, 
    0.17387025f, 0.07852781f, 0.00754838f, 0.23268510f, -0.00100902f, 0.00794989f, 0.08750457f, 0.33468267f, 
    -0.15460223f, 0.10388042f, -0.01396955f, 0.11593770f, 0.24919827f, 0.30911988f, 0.14817113f, -0.12557389f, 
    0.03066839f, -0.12966031f, 0.12276277f, -0.02478606f, -0.18876287f, 0.11319871f, -0.14165670f, 0.19936441f, 
    -0.22704519f, 0.32714128f, -0.09264810f, 0.12691662f, 0.24595937f, 0.24956368f, 0.16760188f, 0.16554113f, 
    0.00791387f, 0.15978852f, 0.25413874f, 0.16921249f, 0.15268680f, -0.24169500f, 0.02135618f, 0.10118873f, 
    -0.16183363f, 0.04160590f, -0.11490358f, -0.04590349f, 0.01048090f, 0.17621227f, -0.17042850f, -0.04715037f, 
    0.06136915f, -0.03685148f, 0.06918043f, -0.12749596f, 0.05694374f, -0.08837385f, 0.08803204f, 0.06149042f, 
    0.36354965f, 0.18116611f, -0.12331603f, 0.16429077f, -0.09600881f, -0.20686845f, -0.01190159f, 0.02673754f, 
    0.38136551f, 0.01232452f, 0.19083917f, 0.04545898f, -0.08983747f, 0.04999476f, -0.02840733f, 0.07706918f, 
    -0.20822929f, 0.02184056f, 0.00397755f, 0.25761423f, -0.11280982f, 0.03711231f, 0.07692825f, 0.13034756f, 
    -0.02906058f, -0.23376104f, 0.00454660f, -0.06215174f, -0.00021436f, 0.20764129f, -0.05521175f, 0.18760727f, 
    0.06763651f, -0.16112895f, 0.01677619f, -0.09857325f, -0.26497945f, 0.01829950f, 0.01150068f, 0.09880438f, 
    0.17578834f, 0.05046242f, 0.29344130f, 0.21288536f, 0.02147801f, 0.15744887f, 0.16490178f, -0.31851000f, 
    -0.33164391f, 0.16100243f, 0.09208918f, -0.18665430f, 0.22957198f, -0.29089054f, 0.04702767f, 0.30183649f, 
    0.14965595f, 0.01345430f, -0.13164553f, -0.04203126f, -0.20171794f, 0.14788058f, 0.02093718f, -0.06386062f, 
    0.05970280f, 0.23149134f, 0.07639399f, -0.08891178f, -0.01826387f, 0.05239265f, -0.03300465f, -0.16891265f, 
    0.20805055f, 0.14116958f, -0.19705907f, -0.09161130f, -0.02761018f, 0.14178745f, 0.04927905f, -0.37746504f, 
    0.24296832f, 0.10833039f, -0.15368561f, 0.05654820f, 0.16679724f, 0.37274072f, -0.08047339f, -0.32466197f, 
    0.13284487f, -0.19685167f, 0.01578276f, 0.09435429f, -0.04456717f, 0.20660554f, 0.15614089f, 0.23788241f, 
    -0.07194001f, -0.06486454f, -0.16667654f, 0.08080025f, -0.04617672f, 0.07668819f, 0.03961888f, -0.04440299f, 
    0.05468530f, -0.06321841f, 0.03699349f, -0.11269156f, 0.00021992f, 0.13208689f, 0.07358210f, -0.02877497f, 
    -0.17384697f, -0.14692271f, -0.11447931f, -0.02891772f, -0.09222852f, 0.14288361f, 0.13381557f, -0.14574520f, 
    -0.12002078f, -0.12049965f, -0.09237540f, -0.05019531f, 0.06391318f, -0.05047335f, 0.14126968f, -0.11199126f, 
    0.07472087f, 0.20128201f, 0.08264880f, 0.12983029f, 0.18583773f, 0.33768010f, 0.00260910f, -0.11426022f, 
    -0.04037445f, 0.15109320f, 0.57433128f, 0.15722744f, -0.05551504f, -0.18051739f, -0.12512910f, -0.29115626f, 
    -0.01101767f, -0.17733483f, -0.06687652f, -0.38041502f, 0.01699867f, -0.15248832f, -0.07885098f, 0.05540656f, 
    0.02169792f, 0.12310503f, -0.02975287f, -0.14790606f, -0.07370745f, -0.02565549f, 0.16755804f, -0.16767097f, 
    0.00348777f, -0.38285184f, 0.09319714f, 0.14049779f, 0.01606298f, 0.20260313f, 0.12946963f, -0.05062763f, 
    -0.32676348f, -0.11449643f, 0.09977301f, 0.12621856f, 0.16645806f, 0.36145186f, -0.05315699f, -0.17862895f, 
    0.31563705f, -0.00770640f, -0.10127269f, -0.17157112f, -0.00048284f, -0.06445874f, -0.17250504f, -0.02596975f, 
    0.05719566f, 0.16510133f, -0.17330413f, -0.12943749f, -0.21352154f, -0.06410347f, 0.14357941f, 0.04965612f, 
    -0.28075337f, -0.26064163f, 0.06671397f, -0.07679063f, -0.31436816f, 0.34748760f, -0.02082991f, 0.15723273f, 
    -0.09369474f, 0.06926668f, 0.26512164f, 0.11105033f, -0.09435463f, 0.13503170f, 0.13984774f, -0.32566190f, 
    0.13722095f, 0.05186319f, 0.14669968f, -0.11617875f, 0.13121399f, -0.00961621f, -0.07198878f, 0.06977256f, 
    -0.05524021f, 0.14924198f, 0.09598005f, 0.08108258f, -0.16497546f, 0.14081539f, -0.00044762f, 0.25501835f, 
    -0.34826002f, 0.15607612f, 0.12547904f, -0.03476505f, -0.02322628f, 0.22751756f, 0.01907737f, 0.09267768f, 
    0.03732859f, -0.11699571f, -0.26263887f, -0.00997846f, 0.12823972f, 0.01459442f, -0.13671212f, -0.08251086f, 
    0.44790372f, 0.09524178f, -0.14732561f, 0.24556330f, 0.20969412f, 0.27090797f, -0.14574258f, -0.29818943f, 
    0.13335244f, 0.10220658f, 0.06762004f, 0.06552610f, -0.00420096f, -0.09577535f, 0.02417667f, 0.41126165f, 
    0.00662639f, -0.04189173f, 0.14065526f, 0.07359412f, 0.08860850f, -0.05284157f, 0.06112018f, 0.08900540f, 
    0.07664739f, -0.12367093f, -0.17593487f, 0.01356925f, -0.12779783f, 0.15614182f, 0.01156703f, -0.02955242f, 
    0.04812674f, -0.07724065f, -0.04651419f, -0.16699152f, -0.15094453f, 0.10120499f, 0.03352344f, -0.16378397f, 
    0.15365082f, -0.04017196f, -0.17423612f, 0.15997359f, -0.04786061f, -0.08178454f, -0.16926914f, 0.01390199f, 
    -0.11426005f, 0.01924971f, -0.07056788f, -0.12527311f, 0.24618858f, 0.24518295f, 0.05419533f, -0.17456482f, 
    -0.07763980f, -0.03131317f, 0.16626616f, -0.13648570f, 0.38087708f, -0.01188363f, 0.00825830f, 0.57464355f, 
    -0.40146992f, 0.08806178f, -0.10599465f, -0.04653881f, 0.22857955f, 0.22678678f, 0.14173682f, 0.22709298f, 
    0.05722375f, -0.12780063f, -0.08263931f, 0.08893889f, -0.14329205f, 0.05046829f, 0.11359307f, -0.12256002f, 
    -0.34042442f, -0.22088815f, -0.16272587f, -0.04668999f, 0.01192851f, 0.07389524f, 0.00680837f, 0.10180300f, 
    -0.11044095f, -0.07968515f, -0.28288260f, 0.07775588f, 0.08670922f, -0.23042053f, 0.11637361f, 0.03267894f, 
    -0.05963662f, 0.12423396f, 0.00775611f, -0.13605177f, 0.17351498f, 0.19061071f, 0.08517531f, 0.33378550f, 
    -0.06329230f, 0.27151901f, 0.12448888f, 0.02245904f, 0.29654059f, -0.04861436f, -0.00563875f, 0.31576210f, 
    0.17704165f, 0.21763070f, 0.03326865f, 0.12922618f, 0.26162907f, -0.23859933f, 0.09818399f, 0.13908401f, 
    -0.09513180f, 0.02516389f, -0.41907912f, 0.15512750f, -0.21412884f, 0.23288602f, 0.11513396f, 0.17639494f, 
    0.32848305f, -0.01705692f, -0.02473037f, 0.22078474f, -0.17762843f, 0.06480003f, -0.09829882f, 0.09073026f, 
    0.03647796f, 0.06776672f, -0.05368876f, 0.15645650f, 0.36155295f, 0.14108671f, -0.10899264f, -0.31247437f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.00192051f, -0.06340229f, -0.02987290f, 0.11914669f, 0.04610385f, 0.01886599f, -0.06721385f, 0.16253194f, 
    0.11201012f, -0.13047826f, -0.12541312f, 0.15045260f, 0.11670863f, 0.09380628f, 0.07472584f, 0.05176905f, 
    -0.12545496f, 0.01426020f, -0.06319933f, 0.22997686f, 0.02096924f, 0.16302997f, 0.13579138f, -0.09507468f, 
    0.06883941f, -0.06191794f, 0.18965480f, 0.05412742f, -0.00184447f, -0.12277225f, 0.02388728f, 0.11013623f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.51809257f, -0.25690946f, 0.14943267f, -0.37292722f, 0.09390042f, -0.20364663f, -0.14090830f, 0.32636487f, 
    -0.26804063f, -0.04810174f, -0.42809153f, -0.14083777f, -0.20253608f, -0.04408609f, 0.19086669f, -0.01577321f, 
    0.16202100f, -0.04162630f, -0.12336439f, -0.43371758f, -0.28640115f, -0.19702303f, -0.21311982f, 0.00364012f, 
    -0.21352668f, 0.20061338f, 0.13174929f, 0.12108785f, 0.00304953f, -0.22015922f, 0.31138375f, 0.23761618f, 
    -0.60145539f, 0.11571149f, 0.10974919f, -0.49645123f, -0.02809010f, -0.41077363f, -0.00295668f, 0.03214126f, 
    -0.11276129f, 0.09508651f, -0.04358200f, 0.00365459f, -0.36381897f, 0.01420472f, -0.11843952f, 0.15101545f, 
    0.09548279f, -0.07690504f, 0.02981766f, 0.20595059f, -0.37355375f, 0.00402007f, 0.06903170f, -0.10940528f, 
    0.32660919f, 0.13814650f, 0.34037077f, 0.03938352f, -0.14292066f, -0.01184899f, 0.02374679f, -0.30087349f, 
    -0.01643597f, -0.01445900f, -0.02062105f, -0.01267785f, -0.03229492f, 0.09367846f, 0.14398365f, 0.04336480f, 
    0.04643598f, 0.12359012f, 0.19095951f, 0.28704306f, -0.36376813f, -0.31821996f, 0.08461685f, 0.20082808f, 
    -0.10500615f, 0.04100592f, -0.42683443f, -0.19137473f, -0.07975477f, 0.32003084f, -0.37609386f, 0.12177395f, 
    0.33758500f, -0.06350785f, 0.03668527f, -0.61394429f, 0.11389458f, -0.15146743f, -0.06957146f, 0.02165615f, 
    -0.36061972f, 0.31143320f, -0.15733629f, 0.02626780f, 0.06901692f, -0.08510050f, -0.36372474f, -0.34632918f, 
    0.02149743f, -0.01807520f, -0.40678316f, -0.11460602f, -0.10272355f, 0.36562243f, 0.18008363f, -0.60753870f, 
    -0.08261999f, -0.39908713f, -0.07811305f, 0.01469782f, -0.33416858f, -0.23730785f, 0.10104866f, 0.07331029f, 
    -0.51567072f, 0.15973935f, 0.03488360f, 0.26576224f, 0.06377034f, -0.03610627f, 0.08016247f, 0.02658306f, 
    -0.41904277f, 0.05308749f, -0.05209085f, 0.34652153f, -0.10925671f, 0.01136093f, 0.27103350f, 0.07344987f, 
    -0.01907975f, -0.15557252f, 0.24865855f, -0.41361377f, -0.15029822f, -0.15825000f, 0.13546266f, -0.27551925f, 
    0.12501980f, 0.12428728f, -0.04337396f, -0.34035036f, 0.25555539f, -0.17069496f, 0.31447491f, 0.15909904f, 
    -0.11563512f, -0.04161746f, -0.10837267f, -0.05219880f, -0.02943396f, -0.29163074f, -0.23817752f, 0.03002407f, 
    -0.07240228f, -0.23127432f, -0.16776866f, -0.15080619f, 0.01841963f, -0.21531139f, -0.11779504f, -0.41806856f, 
    -0.37580022f, -0.09251601f, 0.05104078f, -0.03312065f, -0.03085393f, -0.27351713f, 0.00261988f, -0.01703208f, 
    0.09153327f, 0.31267589f, 0.12345996f, 0.38417381f, -0.02341769f, -0.27741772f, 0.21341597f, -0.13869043f, 
    0.14043587f, -0.29844248f, 0.00741382f, 0.18392891f, 0.10046694f, 0.06137024f, 0.08378064f, 0.01976794f, 
    0.11788069f, -0.18266906f, -0.07316922f, 0.07328415f, 0.10606436f, -0.14984679f, 0.25940785f, 0.09376799f, 
    0.05601012f, -0.62563485f, -0.42381698f, -0.31269014f, -0.31642714f, 0.18372256f, 0.00585198f, 0.15222001f, 
    -0.10975190f, 0.01607910f, 0.11150445f, 0.06135087f, 0.14647040f, -0.03677320f, -0.16726683f, 0.04192372f, 
    -0.58739865f, -0.27149576f, -0.22298096f, -0.16923799f, -0.14706324f, 0.30770871f, 0.33848727f, -0.02149316f, 
    -0.11074139f, 0.25093955f, -0.16723758f, 0.26116830f, 0.15706168f, -0.00301261f, -0.20023823f, -0.16324101f, 
    -0.47946039f, 0.17396353f, 0.03074134f, 0.15087722f, 0.29776025f, -0.49144655f, 0.08649153f, -0.11212172f, 
    -0.01105713f, -0.40187672f, -0.05450737f, -0.26861739f, 0.20594515f, -0.13362072f, 0.13682185f, -0.02047223f, 
    -0.18690318f, -0.30365151f, -0.33906877f, 0.02027394f, -0.16227302f, -0.13547142f, -0.36998478f, 0.03541936f, 
    0.04153180f, 0.11793856f, -0.13271153f, -0.32746512f, 0.01833820f, 0.28300840f, 0.07541101f, -0.17260478f, 
    0.19290222f, -0.08519687f, 0.27284378f, -0.20408282f, 0.26285464f, -0.05967913f, -0.60566944f, -0.11822790f, 
    -0.06131070f, 0.00381124f, 0.20688286f, 0.06166439f, 0.10943735f, 0.17379336f, -0.22163835f, 0.00027307f, 
    0.14999677f, 0.20352259f, 0.15055244f, -0.18062654f, 0.14772150f, 0.24828091f, -0.54452151f, -0.42467996f, 
    0.36488745f, -0.51706970f, 0.02267239f, 0.14534743f, 0.07627178f, 0.20691684f, -0.06151588f, 0.27463716f, 
    -0.06475392f, -0.30118546f, 0.32255465f, 0.35369796f, -0.09991173f, 0.00348179f, 0.16652018f, 0.01439370f, 
    -0.10956367f, -0.13739610f, 0.00295085f, 0.16774595f, -0.00053267f, -0.38010564f, -0.12112241f, 0.07212141f, 
    -0.07235514f, -0.11693098f, -0.58169931f, -0.33660263f, -0.13577114f, 0.14267363f, -0.32903260f, 0.35146704f, 
    -0.31587577f, 0.09703942f, -0.08889038f, -0.22157508f, 0.14380366f, 0.39666909f, -0.00445909f, -0.23663792f, 
    -0.40744719f, -0.06165316f, -0.27836388f, 0.02917527f, 0.30146110f, 0.04846552f, 0.25781202f, -0.09778234f, 
    0.08754847f, -0.36146533f, -0.03787100f, 0.24207973f, -0.12896618f, 0.04787403f, -0.26133007f, 0.13253693f, 
    0.30045205f, -0.18192273f, -0.06915265f, -0.14167178f, 0.16696981f, 0.16076133f, 0.20215772f, -0.40141490f, 
    0.43272862f, 0.11999695f, -0.07738550f, -0.19566727f, -0.00116053f, -0.03012041f, -0.54007518f, -0.14272936f, 
    0.37800068f, -0.36114636f, -0.39387694f, 0.12912136f, -0.15406118f, -0.03476436f, 0.19999763f, -0.33231550f, 
    -0.03354644f, 0.19299030f, 0.17736451f, -0.05389891f, 0.21408845f, 0.32296920f, 0.01638056f, 0.03660334f, 
    -0.05124010f, -0.31441414f, 0.13702579f, -0.14541590f, -0.09991790f, -0.15882105f, 0.06348932f, -0.16454069f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.03515645f, 0.10696945f, -0.08068401f, 0.06867451f, -0.07705549f, 0.07126045f, 0.01495451f, -0.23455584f, 
    0.00129087f, -0.03987504f, 0.07294457f, 0.08720913f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
