#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.18364607f, 1.00421977f, 0.04333722f, 0.82839328f, 0.18536635f, -0.13875017f, -0.70106453f, -0.59669107f, 
    -0.75418055f, 0.45257169f, -0.28498358f, 0.64974535f, -0.03666830f, 0.13212048f, 0.17983335f, -0.07634182f, 
    -0.34117067f, -0.14954570f, -0.01792101f, -0.06484158f, -0.35749999f, 0.04005528f, -0.50912476f, -0.51346374f, 
    -0.28671920f, -1.22407472f, 0.14813976f, -1.07669568f, -0.51906937f, 0.37781358f, -0.56894672f, 0.13211997f, 
    0.56371760f, 0.21433254f, 0.31626076f, 0.37427258f, -0.26977757f, 0.45759809f, -0.57692826f, 0.11193496f, 
    -0.00867404f, 0.21503848f, 0.18757701f, -0.01469897f, -0.43641761f, -0.20337090f, -0.13679722f, -0.23524524f, 
    0.02443047f, -0.12996843f, -1.08972549f, -0.40702698f, -0.07430574f, 0.10352329f, -0.49761894f, -0.52289182f, 
    -0.30663487f, 0.02577265f, 0.56316072f, -0.60959750f, -0.08612349f, 0.39380094f, -0.17117159f, 0.30828649f, 
    -0.00064265f, 0.10373874f, 0.12857737f, 0.23309772f, -0.33642825f, -0.49615592f, 0.10605443f, 0.47927225f, 
    0.02548509f, -0.05595167f, 0.17769141f, -0.05814316f, -0.96779484f, -0.13030772f, 0.38537475f, 1.04816544f, 
    -0.88882798f, -1.05087399f, -0.66205108f, -0.94293499f, -0.53031361f, 0.37368798f, 0.43404156f, 0.29823649f, 
    0.21998873f, 0.00225494f, 0.34768933f, -0.13095689f, -0.06608169f, 0.22396725f, 0.20523492f, -0.29961097f, 
    0.23774718f, 0.14057578f, 0.09250759f, -0.16196549f, 1.38183415f, 0.76466042f, -0.64081573f, 0.54964209f, 
    -0.21519387f, 0.42803353f, 0.23084719f, -0.52635127f, 0.19879454f, 0.35863945f, 0.24494240f, 0.45576248f, 
    -0.14045255f, 0.34414700f, -0.39257106f, 0.13698344f, -0.32776937f, -0.10608438f, -0.24676538f, -0.44186005f, 
    0.25957802f, 0.05097455f, 0.10673672f, -0.08921327f, 0.24956708f, -1.31611657f, 0.63603389f, 0.56198752f, 
    -0.66584301f, -0.60963053f, 1.06037581f, 0.61160076f, -0.00141703f, 0.69254214f, 0.39765692f, 0.22172610f, 
    -0.26114807f, -0.31790951f, -0.21711387f, -0.23598993f, -0.08935588f, 0.26323393f, -0.24482453f, -0.02227443f, 
    -0.13368171f, 0.11719769f, 0.10537706f, 0.10536913f, 0.11060605f, 0.24847260f, -0.86845487f, 0.75567645f, 
    0.50164872f, 0.10483825f, -0.76776105f, -0.61835426f, 0.36229238f, -0.33822018f, -0.89442784f, -0.52530801f, 
    -0.21692702f, -0.03303471f, -0.44314933f, 0.17469431f, -0.49019837f, -0.08722398f, -0.31607658f, 0.22916190f, 
    -0.13310556f, -0.78273141f, 0.23318966f, -0.07378781f, 0.26086608f, 0.28525552f, 0.47584289f, 0.43506065f, 
    -1.00196731f, -1.05679905f, 0.38618609f, 0.03772801f, -0.65797234f, 0.87602973f, 0.64466685f, -0.32933128f, 
    0.31156424f, 0.61576194f, -0.13969620f, -0.60814953f, -0.29080328f, -0.10399440f, -0.02703317f, -0.10811260f, 
    -0.33390990f, 0.03906669f, -0.24613078f, 0.03823529f, -0.01326903f, -0.09856617f, 0.27685189f, -0.25172314f, 
    -0.80088502f, 0.67708558f, -0.51916450f, -1.07769954f, -0.56114864f, 0.44865230f, 0.28470844f, 0.44307441f, 
    0.72273749f, 0.75929117f, 0.17221041f, 0.41669327f, -0.03169732f, -0.05267052f, -0.25024018f, 0.34826261f, 
    0.16810776f, 0.15262993f, 0.35020489f, 0.61992532f, -0.01622142f, -0.06161670f, 0.11708158f, -0.22648515f, 
    0.09459838f, -0.81573439f, -1.10459065f, -0.74620217f, -0.43554720f, -0.46442145f, -0.53219277f, -0.17955993f, 
    -0.38355809f, -0.52044731f, 0.45458472f, 0.32156050f, 0.48602334f, 0.19095819f, 0.37229681f, 0.36763376f, 
    -0.12107128f, -0.14838843f, 0.23643649f, -0.03323839f, -0.00165942f, 0.33083168f, -0.26376739f, -0.11653035f, 
    0.04691169f, -0.16039233f, 1.06252813f, 0.76041007f, 0.22196394f, 0.99170369f, -0.51460940f, -0.07985463f, 
    0.20555548f, 0.31885636f, 0.36984739f, 0.30666161f, -0.44766325f, 0.10876762f, 0.66123223f, -0.71275252f, 
    -0.54245704f, -0.33468542f, -0.37884995f, 0.03912551f, 0.34785002f, -0.04112396f, -0.23841856f, -0.16679057f, 
    0.09616387f, -0.16095714f, -0.07307864f, -0.14464788f, -1.30225599f, -0.53411621f, -0.22842051f, -0.37912405f, 
    0.36385381f, -0.38171747f, 0.56851488f, 0.62470329f, -0.23574586f, -0.17891753f, -0.40269592f, -0.47663423f, 
    0.12073778f, -0.03962786f, 0.34661654f, 0.18838480f, -0.40101200f, 0.06740092f, 0.31485277f, 0.14489301f, 
    -0.05399761f, 0.33680221f, 0.16141585f, -0.20394534f, 0.96405584f, 1.04837322f, -0.77376509f, -0.45612490f, 
    -1.08917439f, -0.13575941f, -0.90466750f, 0.18164854f, 0.23295633f, -0.54581356f, 0.04980956f, 0.13439631f, 
    0.02492947f, 0.13078317f, -0.37404558f, -0.11447904f, 0.01943335f, -0.00724504f, 0.04548186f, -0.03487492f, 
    -0.33150515f, -0.00574827f, 0.19434479f, 0.19696082f, -0.18013766f, -0.78728449f, 0.87650096f, 0.01069691f, 
    -0.58728963f, -0.98023838f, 0.57256514f, 0.74849069f, -0.28384876f, 0.35839343f, -0.06878785f, -0.19926375f, 
    -0.09453351f, -0.13588172f, -0.02996276f, 0.36321545f, -0.21546911f, -0.34009960f, -0.06667303f, 0.11087322f, 
    -0.07503978f, -0.39232552f, -0.38559288f, -0.04948411f, 0.21711509f, -0.01792197f, 0.62206632f, 1.10065842f, 
    0.64567399f, 0.99327248f, 0.13971162f, 0.71785313f, -0.07356827f, -1.10118663f, 0.15935387f, -0.40479800f, 
    0.38037366f, 0.16638497f, -0.04490034f, 0.28792253f, -0.14660561f, 0.02003725f, 0.05092270f, 0.43483981f, 
    -0.15842305f, 0.16753286f, 0.03654627f, -0.13904504f, 0.05534565f, 0.14711316f, 0.42608196f, 0.00126436f, 
    -0.06800329f, 0.47847083f, 0.69471174f, 0.42989922f, 0.15199268f, 0.43874487f, 0.57222325f, 0.06590953f, 
    0.46338668f, -0.81320035f, -0.83670646f, -0.37044287f, -0.29508400f, 0.02232585f, -0.55646485f, -0.37963066f, 
    0.52624100f, 0.07976105f, 0.14864960f, 0.16961294f, 0.06934389f, -0.11238451f, -0.36234197f, -0.65226555f, 
    1.23326421f, 0.48897204f, -1.01673388f, -1.00724339f, -0.41141349f, -0.57130057f, 0.07664015f, 0.55348855f, 
    0.13413985f, 0.34948689f, -0.28985032f, -0.20954834f, 0.27043700f, -0.38913757f, 0.23676224f, -0.14485820f, 
    -0.21302116f, 0.07201824f, 0.09522489f, -0.07276548f, 0.41634142f, -0.22002935f, 0.24608345f, 0.09290694f, 
    0.16164196f, -0.62015313f, -0.88065159f, -0.63860434f, 0.17841133f, 0.37408963f, 0.78903472f, 0.92131299f, 
    0.14674708f, 0.26137942f, 0.28366250f, 0.09722237f, 0.14205836f, 0.07444648f, -0.37179902f, 0.28834236f, 
    -0.24597503f, 0.25355592f, 0.57345909f, -0.02024771f, -0.22198081f, -0.35397243f, -0.41508180f, -0.16664150f, 
    -0.00160831f, 0.06109297f, -0.56879359f, -0.94929552f, -0.19947080f, 1.13173318f, 0.07303352f, -0.79790151f, 
    0.90538764f, 0.63921899f, -0.68025303f, -0.02453909f, 0.11803364f, -0.00195776f, -0.19124970f, 0.04065665f, 
    0.10271323f, 0.40347379f, 0.53885162f, -0.21348923f, 0.30963236f, 0.12931266f, -0.04553125f, 0.02075327f, 
    0.37259310f, 0.19870196f, 0.05313300f, -0.69350845f, -1.12155473f, 0.24206468f, 0.72120094f, -0.01075603f, 
    -0.66816843f, 1.28482282f, 0.62970781f, -0.27570972f, -0.03128356f, -0.19637881f, 0.33856007f, 0.12149855f, 
    -0.01264586f, 0.36383736f, -0.52059335f, -0.20933069f, -0.13607699f, -0.05004221f, -0.62520069f, 0.02703057f, 
    0.02545055f, -0.31317839f, 0.24545948f, 0.06161155f, 0.43816683f, 1.39563560f, 0.98748010f, -0.22957608f, 
    -0.25840616f, -0.93266612f, -0.36759290f, 0.13891895f, -0.14085652f, -0.43429387f, 0.01664744f, -0.10268798f, 
    -0.35575190f, 0.08814176f, 0.72037607f, -0.30033582f, 0.19184983f, 0.06788862f, -0.44759995f, -0.13731042f, 
    0.49178764f, 0.33714879f, -0.14422412f, 0.20743476f, -0.12974313f, 0.25556424f, -1.20298016f, -0.87950218f, 
    -0.40195400f, -0.75329643f, 0.22102472f, 0.60272467f, 0.48747224f, 0.50844634f, 0.35565519f, -0.47796053f, 
    -0.22914295f, -0.73122174f, -0.00990849f, -0.00651176f, 0.00506102f, -0.12767349f, -0.12803833f, 0.15817180f, 
    -0.07568690f, -0.09217408f, -0.06009296f, 0.10380279f, -0.11179841f, 0.24157476f, -0.56320661f, -0.83248693f, 
    0.36952540f, 0.54602605f, 0.38362047f, 0.86914319f, 0.09577303f, 0.24749164f, -0.38533413f, -0.73192888f, 
    -0.01012055f, -0.20210281f, -0.14842382f, 0.73549110f, 0.59770238f, 0.11405071f, 0.28516439f, -0.38684455f, 
    0.17072995f, 0.36560720f, -0.00201652f, -0.14706254f, 0.53921640f, 0.40352872f, 0.07036096f, 0.87389827f, 
    -0.37664551f, -0.98679429f, -0.29877236f, 0.56929165f, 0.62085545f, 0.19398968f, -0.62706977f, 0.31518134f, 
    0.26851857f, -0.33458328f, 0.50049752f, -0.07292408f, 0.31396222f, 0.56445980f, -0.21382734f, -0.31133592f, 
    0.17907336f, -0.07243203f, -0.06581274f, 0.16514257f, 0.39855126f, 0.31946480f, -0.03043344f, -0.08043563f, 
    0.04787542f, 1.18653655f, 0.17044386f, 0.35626775f, 0.78069520f, -0.28849167f, 0.45558330f, 0.73750156f, 
    0.38019952f, 0.19552712f, -0.51498777f, 0.42360526f, -0.23686926f, -0.43646342f, 0.03015419f, 0.35530171f, 
    -0.19061597f, 0.27264035f, 0.43507317f, 0.11766414f, 0.42189869f, 0.47234899f, -0.00725868f, -0.01454731f, 
    0.51352042f, -0.80681646f, 0.50175506f, 0.68576151f, -0.17335917f, -0.25750884f, -0.70284259f, -0.01208185f, 
    0.65069419f, 0.21493874f, -0.83129054f, 0.02630454f, -0.16487840f, -0.20407096f, 0.36667377f, -0.22671059f, 
    0.01685904f, 0.37261298f, 0.65862560f, 0.11604833f, 0.21867496f, 0.06224019f, -0.48272222f, -0.32720882f, 
    -0.14787234f, -0.38407937f, 1.37857437f, 0.35327834f, -0.37511179f, 0.98581612f, 1.00739539f, -0.38173404f, 
    -0.79000819f, 0.28904092f, 0.44498977f, 0.04344958f, -0.41592410f, -0.34289676f, -0.09182962f, -0.34705421f, 
    -0.13776100f, 0.07516533f, 0.01986146f, 0.04151141f, -0.05122290f, 0.11530457f, 0.32774189f, -0.03021140f, 
    0.12954681f, -0.10582153f, 0.03933302f, -1.12592137f, -0.28729463f, 1.13198531f, -0.13281430f, 1.15340269f, 
    0.88652045f, 0.36333445f, -0.22433044f, -0.58274919f, -0.60068065f, -0.17345431f, 0.39686361f, 0.09146145f, 
    0.09999926f, -0.10164987f, -0.03107099f, -0.03295228f, 0.16302724f, -0.08770113f, 0.02268411f, 0.09867651f, 
    -0.19000977f, -0.41970509f, -0.18974121f, 0.04638879f, 0.49405536f, -0.13253756f, 0.80603898f, 1.07501984f, 
    1.05915332f, 0.97872096f, 0.70570880f, 0.20963465f, 0.42798710f, 0.28674400f, -0.49051294f, -0.02717685f, 
    -0.41849783f, 0.61137259f, -0.16310599f, -0.10786268f, -0.28259081f, -0.01070277f, 0.03948057f, -0.20696269f, 
    0.06597809f, 0.09165924f, -0.14018086f, -0.10857518f, 0.16483432f, -0.03667410f, -0.32428226f, -0.72352642f, 
    0.11557631f, -0.31452727f, -0.85812229f, -0.70905411f, -0.38127351f, -0.04220843f, -0.41988966f, 0.50375849f, 
    0.12109631f, 0.31812319f, 0.12036644f, 0.02655785f, -0.53418058f, -0.17694303f, -0.31157857f, -0.30411333f, 
    0.08634500f, 0.06097246f, -0.20248286f, 0.32407925f, 0.03940930f, 0.13103196f, 1.36829948f, 0.38426283f, 
    1.08777297f, -0.42389607f, -0.15424164f, 0.53572959f, -0.44653034f, 0.51249647f, 0.54896319f, 0.46944240f, 
    -0.06758652f, 0.24254717f, -0.26447257f, -0.39427298f, -0.41134033f, 0.05810159f, 0.06221043f, -0.13219553f, 
    -0.53120673f, -0.33186108f, 0.03887687f, 0.09642494f, 0.03748297f, 0.08551493f, -0.34198871f, -0.84052634f, 
    -0.82753384f, -0.25455174f, -0.41952789f, -0.15807314f, 0.60186636f, -0.81651419f, -0.05076787f, 0.29650366f, 
    -0.73947459f, 0.28697187f, -0.38884264f, 0.65638679f, 0.29575002f, -0.34656471f, 0.31966388f, 0.26483735f, 
    0.23178934f, -0.31501269f, 0.00599268f, -0.17776757f, 0.31578121f, 0.04743538f, -0.13267255f, -0.36698982f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.05521313f, 0.21879500f, 0.46349779f, 0.42013812f, 0.36936003f, 0.05682462f, 0.17908172f, 0.14608349f, 
    0.17886885f, 0.28584367f, 0.34299606f, 0.01393644f, 0.29166111f, 0.10834960f, 0.39183521f, 0.12778333f, 
    0.36146012f, 0.25704920f, 0.21423540f, 0.11928324f, 0.18344739f, 0.09202020f, 0.22497049f, 0.28839961f, 
    0.29585487f, 0.18799375f, 0.01673522f, 0.12261156f, 0.27836883f, 0.33842906f, 0.31801167f, 0.18637075f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16942403f, 0.18429211f, 0.19549640f, -0.09675165f, -0.15252574f, -0.02826199f, 0.02653619f, -0.05408515f, 
    0.07113729f, 0.11630909f, -0.12850615f, -0.02133491f, 0.19854306f, 0.27533650f, -0.07795272f, 0.02876922f, 
    -0.00502274f, -0.18475202f, -0.11752760f, -0.04127108f, -0.02543331f, -0.00372233f, -0.22700413f, 0.02243577f, 
    -0.27706793f, 0.01904957f, -0.14770682f, 0.10780480f, 0.08109774f, -0.07402568f, 0.04756121f, 0.00235015f, 
    -0.03790400f, 0.11132464f, -0.13605219f, -0.04954143f, 0.08385397f, -0.34667912f, -0.04339838f, 0.17404188f, 
    -0.04985691f, 0.02125995f, -0.03001826f, 0.01329317f, -0.04007729f, 0.02074061f, -0.04298389f, -0.10498428f, 
    0.04263627f, -0.03349677f, 0.08526396f, 0.05714415f, -0.21419418f, -0.08381122f, -0.09130961f, 0.17141870f, 
    -0.06985833f, 0.11739060f, 0.00086453f, -0.02798681f, 0.60975248f, 0.11110569f, 0.18619749f, -0.03302516f, 
    -0.05280521f, 0.05852909f, 0.04853988f, -0.04679417f, -0.01455724f, 0.05502847f, -0.06238243f, 0.02953420f, 
    -0.19815774f, 0.20295970f, 0.04728042f, 0.08662910f, -0.03034847f, 0.00957138f, 0.04010693f, 0.05972293f, 
    -0.08522784f, -0.00168985f, -0.03750438f, -0.03676534f, -0.46512240f, 0.31511554f, 0.04480077f, 0.03150420f, 
    -0.04997359f, -0.03189272f, -0.05100188f, -0.14984682f, -0.05649468f, 0.05157215f, 0.03417832f, 0.00225742f, 
    0.37726519f, 0.06639461f, -0.22103399f, -0.38631970f, 0.09815308f, -0.07883514f, 0.01385638f, -0.09342348f, 
    0.01118553f, -0.03678879f, 0.00376379f, -0.03956565f, -0.38693461f, -0.38711640f, -0.16622582f, 0.12325332f, 
    -0.05635897f, -0.05626093f, 0.01879246f, 0.03131239f, 0.02551530f, -0.06876361f, -0.09349076f, 0.05122219f, 
    -0.06766853f, 0.13748084f, -0.30841032f, 0.14291012f, 0.02095008f, 0.01465453f, -0.12038031f, -0.02556226f, 
    0.09133060f, 0.00880120f, 0.03895219f, 0.06884484f, 0.22152910f, 0.03376773f, -0.02075664f, 0.04265371f, 
    0.00838614f, 0.05390628f, 0.13984814f, -0.09908397f, 0.05488643f, -0.11842142f, 0.15525788f, -0.02504984f, 
    -0.11916865f, -0.03446906f, 0.07006505f, -0.26880163f, -0.12742370f, -0.08859418f, -0.02818500f, -0.05297654f, 
    -0.13985404f, -0.05359997f, -0.07744538f, 0.07510969f, 0.53888136f, 0.20893483f, 0.13228138f, -0.30887106f, 
    -0.08388703f, 0.11896494f, 0.01998348f, -0.02237100f, 0.04171180f, 0.00235050f, -0.06723007f, 0.06307580f, 
    -0.02993750f, 0.17567772f, -0.11024913f, 0.10505924f, -0.35076526f, -0.13799787f, 0.07784043f, 0.03579448f, 
    0.03587223f, 0.05950642f, -0.15315759f, 0.07398997f, -0.15763430f, -0.05791635f, 0.01717124f, 0.30487841f, 
    -0.00964293f, 0.05073315f, 0.00248131f, -0.05578825f, 0.02519041f, -0.05601162f, 0.02364165f, 0.08258501f, 
    -0.44900051f, -0.12217252f, -0.09583360f, -0.47070837f, 0.01418151f, -0.28374764f, 0.00220170f, 0.03769824f, 
    -0.07848212f, 0.03744544f, 0.02063284f, 0.06386842f, 0.03228611f, 0.16986941f, 0.02868607f, -0.11576711f, 
    0.22561172f, 0.07553396f, -0.07504901f, 0.09383373f, -0.01613060f, 0.02482387f, -0.04607024f, 0.01758084f, 
    -0.11509883f, 0.20368777f, -0.01186222f, 0.16967198f, -0.01498384f, 0.17947868f, -0.21485718f, 0.03807723f, 
    0.08881321f, 0.03341524f, -0.00952658f, -0.05946340f, -0.24309696f, 0.09422189f, -0.04591154f, 0.18176574f, 
    0.13380504f, -0.00943685f, 0.14978378f, -0.07413661f, 0.02731495f, -0.14162643f, -0.06927550f, 0.09856056f, 
    -0.16378903f, 0.36289981f, -0.16416804f, -0.09015445f, -0.05211565f, -0.04173472f, 0.01876775f, -0.25264102f, 
    -0.09514681f, -0.11146701f, -0.01464046f, -0.04326451f, 0.16530271f, -0.16940567f, -0.11412862f, -0.26125422f, 
    -0.01116467f, -0.04244747f, 0.10129497f, -0.02679911f, 0.04606020f, -0.07775588f, 0.04640840f, 0.09214208f, 
    -0.23824704f, 0.09214465f, -0.09254272f, 0.13350226f, 0.21157454f, 0.08508252f, -0.17445596f, -0.02890022f, 
    -0.01096982f, -0.06207649f, 0.06866737f, -0.18475395f, 0.05216746f, -0.26718718f, 0.20340940f, -0.10141338f, 
    -0.09573699f, -0.02594206f, 0.14676546f, -0.03733935f, -0.15071112f, 0.08911806f, 0.14759742f, 0.00385568f, 
    0.00890269f, -0.02542972f, 0.00801333f, -0.21691428f, -0.15357208f, -0.03236869f, -0.02603197f, -0.03734756f, 
    -0.14449237f, -0.02095238f, 0.00169770f, 0.00905447f, -0.33921310f, 0.19199677f, -0.06965310f, 0.15602371f, 
    -0.08434279f, 0.05220224f, 0.03070623f, -0.07148850f, -0.01872371f, 0.04418660f, 0.14319351f, 0.07302187f, 
    0.31773493f, -0.08139895f, 0.21340099f, 0.53389597f, -0.17484769f, 0.22842811f, -0.14603549f, 0.13739079f, 
    -0.02489347f, -0.00451125f, 0.04758277f, -0.09835657f, -0.84428251f, -0.13335247f, 0.29257146f, -0.10352787f, 
    -0.02206604f, -0.02319597f, 0.19024357f, -0.02663884f, -0.00136527f, -0.00184266f, -0.00750984f, 0.08477249f, 
    -0.01446430f, -0.02547109f, 0.08776391f, 0.34877700f, -0.06567453f, -0.05575757f, 0.10779550f, -0.01639756f, 
    -0.01444516f, 0.08823961f, -0.13623938f, -0.03593932f, -0.15846741f, -0.19611779f, -0.00400032f, 0.13588525f, 
    -0.08992895f, -0.12212779f, 0.13053630f, -0.01379299f, -0.04759902f, -0.02154760f, -0.01637100f, 0.01323813f, 
    0.25215426f, 0.02580787f, 0.05576918f, -0.04857499f, -0.15737870f, -0.20172060f, 0.08662682f, -0.03714508f, 
    -0.03989471f, 0.01745349f, -0.09701301f, -0.10865325f, -0.09567826f, -0.40368646f, 0.06726807f, -0.10833815f, 
    0.11759224f, 0.12300146f, 0.08611442f, -0.07031595f, 0.04159563f, 0.01690700f, -0.11676814f, -0.09263929f, 
    -0.02081605f, -0.05008033f, -0.20244245f, -0.01794569f, 0.09225941f, 0.02902998f, -0.07623972f, -0.18371466f, 
    0.06370205f, -0.02588481f, -0.09111047f, 0.04592978f, 0.39312601f, 0.15723501f, -0.07223346f, -0.24887703f, 
    0.11595324f, 0.14344805f, -0.09768848f, 0.10741613f, 0.10379194f, -0.19139208f, 0.14300576f, 0.03589179f, 
    -0.26533887f, 0.04057943f, -0.08215646f, -0.01361371f, -0.11089414f, 0.02407147f, -0.07092970f, 0.08453102f, 
    0.05722303f, -0.23802599f, -0.02900894f, 0.14574160f, -0.31878805f, -0.01897333f, 0.13805564f, -0.12814195f, 
    0.07313353f, -0.07394803f, 0.04225274f, 0.13023975f, 0.17332403f, 0.21150698f, 0.03911339f, 0.10897128f, 
    0.28464445f, -0.22856861f, 0.01966021f, 0.01982594f, -0.11736409f, -0.11253972f, -0.02757245f, -0.01337742f, 
    -0.03549794f, -0.01426230f, -0.29863468f, 0.05049448f, -0.76895964f, -0.16653301f, -0.07529142f, -0.01330870f, 
    0.05584420f, -0.05016216f, -0.02578972f, -0.02494247f, 0.05841396f, 0.05593923f, -0.08978635f, -0.10490133f, 
    -0.26457718f, -0.01916546f, -0.55977106f, -0.23854446f, -0.13886441f, 0.12388460f, 0.02444666f, 0.04152723f, 
    0.04264890f, -0.09605776f, -0.05328679f, -0.04784709f, 0.45506290f, -0.48581591f, 0.01252881f, 0.00704152f, 
    -0.18730193f, 0.08647849f, -0.03899014f, -0.03203720f, 0.16836740f, -0.10916978f, -0.21234734f, 0.21958010f, 
    -0.33582982f, -0.16744970f, 0.03517179f, -0.39462402f, 0.03244756f, 0.01316066f, 0.05535940f, 0.12625647f, 
    0.22635300f, 0.10743406f, 0.02533814f, 0.04384331f, 0.14635319f, 0.09414745f, -0.05329476f, -0.00411152f, 
    -0.13041119f, -0.07765017f, -0.02600929f, 0.03739994f, -0.00660793f, -0.04102417f, 0.01209854f, 0.07800002f, 
    0.30916113f, 0.01803738f, 0.10186946f, 0.33502123f, -0.05207076f, -0.09150030f, -0.02777127f, 0.04967900f, 
    0.00005231f, -0.32514766f, 0.04365639f, -0.05374642f, 0.03593027f, -0.16717328f, 0.10599074f, -0.22059178f, 
    -0.15796123f, -0.00808708f, 0.04491688f, -0.03636281f, 0.20131864f, 0.16577272f, -0.10282634f, 0.13055618f, 
    0.11998643f, -0.42247114f, -0.23072501f, -0.28541976f, -0.00635028f, -0.15284225f, 0.08981687f, 0.10709871f, 
    0.00853408f, 0.06964998f, 0.06208213f, 0.00379771f, -0.62801731f, -0.20485556f, 0.01298847f, -0.17059788f, 
    -0.00416601f, 0.01768662f, -0.00164595f, -0.12557805f, -0.07717775f, 0.04090431f, -0.04913981f, 0.14653976f, 
    0.18559682f, -0.01729630f, 0.15952213f, 0.25592569f, -0.10966943f, 0.04067003f, 0.00572616f, 0.07326613f, 
    -0.01736825f, 0.03681140f, 0.18995221f, -0.01090460f, 0.23103243f, 0.00866897f, 0.04517525f, 0.24790101f, 
    0.07793470f, 0.08924125f, -0.04255263f, 0.07009888f, 0.17245610f, 0.06688326f, -0.05979753f, -0.17717056f, 
    0.45853582f, -0.19183366f, 0.28453955f, -0.52941954f, -0.04851285f, 0.04808867f, -0.02164841f, 0.11650093f, 
    -0.10614342f, -0.11405658f, -0.05485488f, -0.07498915f, 0.32311910f, -0.02177910f, -0.09006987f, -0.01051650f, 
    0.12937754f, 0.07941021f, -0.30155852f, 0.07986543f, -0.03174580f, -0.05791838f, 0.07701097f, 0.02238149f, 
    -0.15200795f, -0.05743676f, -0.16846213f, 0.17542653f, -0.33398753f, 0.02054823f, -0.07534074f, -0.11014723f, 
    -0.02416971f, 0.14163184f, -0.06565148f, 0.05451218f, -0.20666215f, -0.00374066f, -0.08489788f, 0.00304852f, 
    0.03274694f, 0.06935295f, -0.05522718f, 0.02941599f, -0.02298189f, -0.16353005f, -0.00950607f, 0.04186364f, 
    -0.09505503f, 0.17461680f, -0.16059877f, 0.01450806f, -0.11267125f, -0.16382897f, 0.04042101f, 0.02662470f, 
    0.04666991f, -0.00144529f, -0.08505314f, 0.25018340f, 0.24506865f, -0.11549956f, 0.00721023f, -0.09464356f, 
    0.09048324f, -0.05586021f, -0.05897347f, -0.02966841f, -0.09674860f, 0.01536047f, -0.06797509f, -0.05999506f, 
    0.09872665f, 0.14490741f, -0.20444123f, 0.12428134f, 0.07804120f, 0.11961596f, 0.10604831f, -0.05046989f, 
    -0.02299912f, 0.12719110f, -0.12401638f, 0.22805655f, 0.43378538f, -0.30128682f, 0.02200899f, -0.06425425f, 
    -0.10204349f, -0.05558192f, -0.09153407f, 0.00193146f, -0.07411251f, -0.00249304f, -0.10844439f, 0.01671810f, 
    0.23056868f, 0.11642563f, 0.01402796f, 0.25058934f, 0.23665580f, 0.07601216f, -0.00408570f, 0.03650261f, 
    0.15098396f, 0.02653490f, 0.02203856f, 0.00803382f, -0.34455615f, -0.02887551f, -0.34125644f, -0.19045819f, 
    0.13356394f, -0.02710271f, -0.09587818f, -0.03942204f, -0.15928581f, -0.17850378f, -0.05654484f, 0.02308293f, 
    0.34081364f, -0.17063764f, 0.04092517f, 0.35757533f, -0.13163282f, -0.11017830f, -0.05112359f, 0.02108128f, 
    0.03765579f, -0.07627064f, -0.15978824f, 0.01588088f, 0.18109551f, 0.01059072f, -0.25836310f, -0.20256633f, 
    -0.15398449f, -0.02413485f, -0.05761067f, 0.02572331f, -0.19081625f, 0.03899232f, -0.06315223f, -0.04302534f, 
    0.56956136f, 0.09242564f, 0.14166190f, 0.12678561f, -0.13368008f, 0.09389281f, -0.03259854f, 0.03951007f, 
    0.00068530f, 0.14437075f, 0.09886567f, -0.01657709f, -0.20477845f, -0.23629293f, -0.18121167f, -0.20020010f, 
    0.03508289f, 0.11892756f, -0.16463713f, 0.16694088f, -0.02823211f, -0.01233258f, -0.03787696f, -0.16930154f, 
    0.06778601f, 0.08068769f, 0.05584024f, 0.09709302f, -0.06671838f, -0.01149337f, -0.03794643f, -0.02875670f, 
    0.11808029f, -0.16179979f, 0.05351198f, -0.18205613f, -0.15191148f, 0.23480414f, -0.00364843f, -0.05738686f, 
    0.07040548f, 0.04586265f, 0.09805578f, -0.13718812f, 0.06803270f, 0.04531353f, 0.00093180f, 0.00854923f, 
    -0.06773181f, -0.15594427f, 0.04842074f, -0.27925813f, 0.04510141f, 0.15010293f, 0.04344079f, -0.09337768f, 
    -0.05617322f, -0.05591690f, 0.02372999f, -0.09855841f, 0.07315457f, -0.18050645f, -0.19528341f, 0.23147650f, 
    -0.13450845f, 0.08142090f, -0.09002541f, -0.03672659f, 0.04155549f, 0.08050291f, -0.12932116f, -0.03288096f, 
    0.12195918f, -0.27557331f, -0.34937966f, -0.17997019f, -0.14735635f, -0.11878284f, -0.05556401f, -0.07033074f, 
    -0.03264367f, -0.08950013f, -0.12160465f, 0.01275332f, 0.27110457f, -0.04439452f, -0.03953605f, -0.20285098f, 
    0.09165327f, 0.06739338f, -0.09692995f, -0.04658232f, -0.09893326f, -0.09416375f, 0.02899069f, -0.33762732f, 
    0.37680322f, -0.07743677f, 0.09513539f, -0.16693927f, 0.09755835f, -0.16284254f, 0.00073413f, -0.02969797f, 
    -0.17386883f, 0.26077634f, 0.10095538f, -0.07587289f, 0.54093236f, 0.08734043f, 0.02704597f, 0.09908431f, 
    -0.08360583f, -0.12544343f, 0.03514628f, 0.12827723f, -0.08653617f, 0.08225734f, 0.04574786f, -0.00028986f, 
    0.11969558f, 0.12617357f, -0.61092955f, -0.38177118f, 0.20853253f, 0.02654081f, -0.03247825f, 0.01344526f, 
    -0.12446117f, 0.06185735f, 0.06310665f, -0.03515479f, 0.55781734f, -0.16492797f, 0.06094288f, 0.15261626f, 
    -0.08020040f, -0.04931686f, 0.07876708f, 0.13749793f, 0.00453313f, 0.02317160f, 0.10592473f, 0.00602955f, 
    0.29694423f, 0.17998628f, 0.07702596f, 0.21107124f, -0.16772904f, 0.07510436f, 0.03079432f, -0.03479045f, 
    -0.09146482f, -0.04388358f, -0.02714546f, -0.03351891f, 0.41928467f, -0.37780452f, 0.09766509f, -0.17659049f, 
    -0.22039713f, -0.10559624f, -0.31608695f, 0.06465596f, 0.00637094f, -0.02558147f, -0.03652716f, -0.18416461f, 
    0.17379515f, 0.09134492f, -0.09998972f, 0.02335373f, -0.07469153f, 0.05747909f, 0.10497499f, 0.03928099f, 
    -0.02691618f, 0.09910880f, 0.17346039f, 0.02243790f, -0.21215014f, 0.04179874f, -0.00981170f, 0.25602132f, 
    -0.01227452f, 0.10166506f, -0.05629230f, 0.10836530f, 0.03846027f, -0.09979840f, 0.00399273f, 0.07863388f, 
    -0.40452185f, -0.19191235f, -0.10842892f, -0.30999503f, -0.08343928f, -0.02787216f, 0.18418467f, 0.01570880f, 
    -0.19096680f, 0.06516381f, 0.06808916f, -0.11563376f, 0.41476470f, 0.23603411f, -0.11261442f, -0.25762275f, 
    -0.05571964f, -0.09485682f, 0.09247701f, 0.05919636f, -0.12163790f, -0.04525970f, 0.06060154f, -0.10609144f, 
    0.27903497f, -0.03983198f, -0.09759624f, -0.00723047f, 0.15802400f, 0.02956508f, -0.06764599f, 0.03826143f, 
    -0.11397955f, 0.05250750f, -0.20957845f, 0.11126482f, -0.13532782f, 0.01025649f, 0.09260184f, -0.04505873f, 
    0.02250090f, -0.06179111f, -0.08450098f, 0.04282294f, -0.00284733f, -0.11853386f, -0.01313576f, 0.06269666f, 
    -0.04731787f, 0.08466796f, -0.10798258f, 0.14405581f, -0.00645627f, 0.01202170f, 0.16998929f, -0.07482052f, 
    -0.09530100f, 0.00490190f, -0.02865695f, 0.05648367f, 0.20869939f, -0.09057277f, 0.31922597f, 0.11896395f, 
    -0.10987439f, -0.15223047f, -0.15255098f, 0.08008836f, -0.05603966f, -0.08479075f, -0.06143855f, 0.05796734f, 
    0.62953514f, -0.22022526f, -0.05450074f, -0.08450471f, -0.14718369f, 0.04513426f, -0.04157415f, -0.01178574f, 
    -0.11595608f, -0.13750736f, 0.08119391f, -0.04410509f, 0.56872237f, 0.01787786f, -0.11182621f, 0.04080804f, 
    -0.09685958f, -0.08101414f, 0.00104688f, -0.02410806f, 0.14587976f, 0.11133487f, 0.01727544f, -0.16120544f, 
    -0.18453532f, 0.03832348f, -0.27696851f, -0.27634937f, 0.02018182f, 0.10426140f, 0.14828162f, -0.02049786f, 
    0.07713547f, -0.05100749f, -0.10796969f, 0.06127994f, 0.12740219f, 0.04522658f, 0.04569698f, 0.30076569f, 
    -0.21561211f, -0.18496247f, -0.02654272f, 0.11664058f, 0.12596075f, -0.01282056f, -0.00093817f, 0.12259967f, 
    0.20149277f, -0.08762039f, -0.05829781f, -0.14842327f, -0.20245102f, -0.00426903f, -0.28885156f, -0.00348797f, 
    0.00705496f, -0.17358331f, -0.02797635f, -0.11141209f, -0.03623186f, -0.21619777f, 0.08003379f, -0.14592053f, 
    -0.08970729f, 0.02589861f, 0.07696679f, -0.09107744f, -0.04205067f, -0.06575985f, -0.03798173f, -0.04545658f, 
    0.09177279f, 0.00297196f, -0.14316916f, -0.02936643f, 0.04236054f, 0.09783211f, 0.13549276f, -0.20693547f, 
    -0.13136648f, -0.10682961f, 0.05106469f, 0.08783463f, -0.21937892f, 0.07390790f, -0.60797989f, 0.02350111f, 
    -0.08395901f, 0.16059165f, -0.00368393f, 0.03391068f, -0.16884714f, -0.00685950f, -0.06879007f, 0.08078250f, 
    -0.07172568f, 0.09905244f, -0.16999869f, -0.00466209f, 0.17372243f, 0.04827227f, 0.05231396f, 0.08042159f, 
    0.05583217f, -0.08550982f, 0.03222442f, -0.12164410f, 0.32644746f, -0.28882891f, -0.06045320f, 0.02578717f, 
    -0.04376023f, -0.08946626f, 0.05636279f, -0.01506335f, 0.04026072f, -0.01233372f, -0.16192701f, 0.07486974f, 
    -0.03604142f, -0.21673419f, 0.04864276f, -0.07682076f, 0.12539847f, 0.06928128f, -0.00762760f, 0.02234533f, 
    0.00610622f, 0.15071110f, 0.04458607f, 0.00547516f, 0.09645467f, 0.00042422f, -0.24151206f, -0.18856724f, 
    -0.09382878f, -0.00254593f, 0.02715775f, -0.08901046f, -0.01264662f, 0.17429414f, -0.09047432f, -0.14309523f, 
    -0.15236093f, 0.15268891f, 0.16948730f, 0.00653689f, -0.05279664f, -0.01091060f, 0.08094110f, -0.00192647f, 
    -0.01639833f, 0.09270938f, -0.00692880f, 0.02342713f, -0.45283741f, -0.19572382f, -0.09875362f, -0.05748177f, 
    -0.17130129f, -0.00186784f, -0.26192534f, -0.12367233f, -0.03852268f, 0.08495201f, -0.02111256f, -0.07432037f, 
    0.06845086f, -0.09089988f, -0.15483068f, 0.56933814f, 0.02286385f, 0.06380597f, 0.17309710f, 0.09503260f, 
    0.04776012f, -0.04046311f, -0.11418441f, 0.08701982f, -0.09585660f, 0.19329129f, 0.06620610f, -0.11671872f, 
    -0.22335018f, -0.15304421f, 0.13010027f, 0.03665839f, 0.06551862f, 0.08606144f, -0.04605813f, 0.04966240f, 
    -0.00911150f, 0.16577345f, 0.08182366f, 0.03571027f, -0.10908930f, -0.07929616f, 0.05243841f, 0.04992366f, 
    -0.02897889f, 0.07511180f, 0.03346571f, 0.03325650f, 0.15082094f, 0.17186114f, 0.29581612f, 0.29486820f, 
    0.09570683f, 0.21924116f, 0.02578950f, -0.05667375f, 0.04481841f, -0.08140558f, -0.08491980f, -0.26155907f, 
    0.16457394f, -0.50904149f, -0.75116277f, 0.00772485f, -0.10759890f, -0.14500019f, -0.04927470f, 0.02912927f, 
    -0.03209087f, 0.04375555f, -0.01528114f, 0.00435977f, -0.32243887f, 0.20397529f, 0.18031511f, -0.35597211f, 
    -0.01514068f, -0.02757536f, -0.05954038f, 0.06631036f, 0.04541337f, -0.07732843f, 0.00164054f, -0.10221460f, 
    -0.08744089f, 0.34431720f, 0.16512839f, 0.12893730f, 0.15977409f, -0.03048168f, 0.00678946f, 0.18249728f, 
    -0.04612373f, 0.01346498f, -0.05663485f, 0.16473939f, 0.01966097f, -0.19250394f, 0.14179687f, 0.14466575f, 
    -0.08334494f, -0.00910903f, 0.08553185f, 0.04392057f, -0.05785142f, 0.23404267f, 0.01808803f, 0.06935504f, 
    -0.42635497f, 0.19384114f, -0.04611503f, -0.38474834f, -0.10817433f, 0.07555844f, -0.06728707f, 0.10828102f, 
    -0.12968023f, -0.13450105f, -0.14933075f, 0.10608812f, 0.02516764f, 0.12564828f, 0.04815932f, -0.05460361f, 
    -0.06260720f, -0.15760045f, -0.07971860f, -0.05625262f, 0.00269628f, -0.00290758f, 0.04038504f, 0.09016585f, 
    0.28331912f, -0.62581557f, -0.35197854f, 0.11011466f, -0.07844127f, -0.14451715f, 0.01983441f, 0.05518333f, 
    0.07868376f, 0.10949951f, -0.15917043f, 0.03651689f, 0.15808484f, -0.04570904f, -0.09893596f, -0.00988728f, 
    0.03852956f, 0.06727591f, 0.06522809f, -0.06128152f, -0.05391143f, 0.04773118f, 0.06775799f, -0.08324654f, 
    0.31528109f, -0.34094352f, -0.07724226f, -0.00327295f, -0.10457041f, 0.16761504f, -0.00028002f, 0.23990713f, 
    0.08851297f, 0.00097907f, -0.12253010f, 0.05488254f, -0.13174821f, 0.14488582f, 0.02124702f, -0.17926379f, 
    0.00402225f, 0.18533154f, -0.06615397f, 0.19554329f, -0.00245243f, 0.00887706f, 0.11026271f, 0.12046957f, 
    0.27650174f, -0.26553938f, -0.41722426f, 0.39419594f, 0.00296023f, -0.05022621f, 0.04842981f, -0.01135457f, 
    -0.09589497f, 0.04207022f, -0.08279654f, -0.06419387f, -0.35277167f, -0.32784584f, 0.11694161f, -0.11882821f, 
    -0.27437961f, -0.08413991f, 0.00063343f, -0.04553873f, 0.03477174f, 0.13513856f, 0.07548779f, -0.07472748f, 
    0.07259876f, -0.34486780f, 0.02782156f, 0.08224867f, 0.04866434f, 0.07723981f, 0.11503159f, 0.00470420f, 
    -0.03614597f, 0.13191862f, 0.03940136f, 0.06937338f, -0.12745526f, 0.00739470f, -0.10741805f, -0.10435697f, 
    -0.16125767f, -0.20176251f, 0.02548493f, 0.00216101f, -0.01110476f, -0.06326021f, 0.01282621f, 0.02890974f, 
    -0.18338458f, 0.09161815f, 0.34704232f, -0.11206218f, 0.04704800f, -0.11102529f, 0.09196369f, 0.09250353f, 
    -0.15211836f, -0.04394035f, -0.13063690f, -0.05871686f, 0.06080215f, 0.34248820f, 0.14627337f, 0.00555290f, 
    0.01831963f, -0.05847180f, 0.09764117f, -0.01647266f, -0.05734320f, 0.03876815f, -0.02548884f, 0.08488956f, 
    -0.38316268f, -0.27186716f, -0.05030798f, -0.05727592f, -0.05850147f, 0.00634253f, 0.04656179f, -0.10667809f, 
    -0.06572142f, -0.04221115f, 0.02887358f, -0.14069648f, 0.04975909f, -0.22151119f, -0.05560254f, -0.03995858f, 
    -0.17829815f, -0.00501721f, 0.02634716f, -0.13177378f, -0.03132096f, -0.02578602f, 0.04631795f, -0.10241901f, 
    0.07928327f, 0.14081015f, 0.07484289f, 0.05401699f, 0.03739237f, -0.02662243f, -0.16732745f, -0.02645156f, 
    -0.09253564f, -0.37196925f, 0.07553684f, 0.08575900f, 0.17876677f, 0.19046305f, 0.05546326f, 0.07859532f, 
    -0.01752726f, 0.24880415f, -0.09417956f, -0.06212625f, -0.12511545f, -0.01496610f, 0.14332788f, -0.02380009f, 
    -0.43931231f, -0.38016999f, -0.12240978f, -0.08747725f, -0.13080578f, 0.09566075f, -0.14858320f, 0.05213356f, 
    -0.13645832f, 0.05748774f, -0.12452812f, 0.00835504f, -0.18813537f, 0.18313003f, 0.10903016f, 0.02796094f, 
    0.11746110f, 0.18346751f, 0.10817157f, 0.03602604f, 0.09333688f, 0.09563102f, 0.06748237f, -0.03877471f, 
    0.24371749f, -0.20417726f, 0.04318224f, 0.05046956f, 0.04842187f, 0.04857868f, 0.00409576f, -0.25645965f, 
    0.14135511f, -0.04304152f, -0.09647956f, 0.01626210f, -0.17944442f, -0.15024999f, 0.28633115f, 0.10385684f, 
    0.16387178f, -0.01087179f, 0.04642006f, 0.03120417f, 0.03449041f, -0.12620544f, -0.22694646f, -0.07490296f, 
    -0.42763242f, -0.31055981f, -0.24006273f, 0.02495552f, -0.16111264f, -0.10137838f, -0.13338253f, -0.15085422f, 
    -0.01219367f, -0.06299742f, 0.09371696f, -0.01967876f, 0.34143734f, 0.15917584f, -0.03282098f, 0.02691126f, 
    -0.00962335f, -0.00251021f, 0.09956187f, -0.00218992f, 0.07520363f, 0.05095670f, 0.04252454f, -0.08103900f, 
    -0.32809705f, -0.42326629f, -0.44564530f, -0.14044069f, -0.11187941f, -0.09919483f, 0.08198743f, 0.08579485f, 
    -0.11213500f, 0.25183231f, -0.15567002f, 0.02375160f, 0.15224069f, -0.12761167f, -0.09339007f, 0.06833110f, 
    -0.06146150f, 0.00138112f, -0.10661851f, 0.10843834f, 0.00718874f, 0.12274959f, -0.00258743f, -0.06129524f, 
    -0.38934034f, -0.33038917f, 0.11056950f, 0.31768554f, -0.10168361f, 0.06888485f, 0.11642859f, 0.10626538f, 
    0.13921946f, -0.22534546f, 0.03954868f, 0.14293513f, 0.14060561f, 0.18888447f, -0.05602967f, 0.15168789f, 
    -0.02183412f, -0.02836743f, 0.16873799f, -0.00618744f, 0.19752741f, 0.05893652f, 0.02532472f, 0.03780529f, 
    0.25028190f, -0.17639862f, -0.07053553f, -0.19230790f, 0.04897627f, 0.14961091f, -0.03362245f, 0.10866099f, 
    0.12281625f, -0.10408679f, -0.00124520f, -0.05777802f, -0.33144587f, -0.19950056f, 0.23115361f, 0.26914865f, 
    0.02603647f, 0.05656954f, -0.00875928f, -0.05958772f, 0.18378371f, -0.03452424f, -0.09329394f, -0.01371023f, 
    -0.03351378f, -0.06521163f, -0.06367356f, -0.17066690f, -0.05906007f, -0.05313163f, 0.04254494f, -0.22397684f, 
    -0.09210396f, -0.05402717f, -0.02178383f, 0.02545986f, 0.31956145f, 0.37764210f, -0.03005533f, 0.05981184f, 
    0.01639097f, -0.05023874f, 0.04252335f, 0.02005076f, -0.04615116f, 0.05607016f, 0.13301884f, -0.05578152f, 
    0.15718256f, -0.07549435f, 0.11889269f, -0.02737359f, 0.14217223f, -0.00712542f, 0.05460573f, 0.04726663f, 
    0.16667563f, -0.08833419f, -0.13430795f, 0.09168455f, -0.45594621f, 0.21312930f, -0.15374549f, -0.01906499f, 
    0.09376743f, 0.02209747f, -0.02760408f, 0.08576992f, -0.09703416f, -0.09617382f, 0.09950286f, 0.03448226f, 
    0.19929346f, 0.01214481f, 0.02792764f, 0.31807745f, -0.00546653f, 0.03599172f, -0.04892978f, 0.12013198f, 
    0.01889002f, 0.18955176f, 0.12086335f, 0.00811815f, -0.01260617f, 0.06476232f, 0.20925553f, 0.11240957f, 
    0.23774225f, 0.02702155f, -0.00167962f, 0.18054165f, 0.03530194f, 0.02148582f, -0.07104822f, -0.04957733f, 
    -0.13964775f, -0.00076582f, 0.27172229f, 0.03776653f, -0.12143765f, 0.04893502f, 0.06027795f, 0.04370835f, 
    -0.03652899f, 0.05554258f, -0.00509461f, -0.15435261f, -0.34898904f, -0.07142695f, -0.07759220f, 0.23730470f, 
    0.06876706f, -0.03012192f, -0.13097297f, 0.05694462f, 0.05050195f, -0.17092127f, -0.10451112f, 0.00268088f, 
    -0.11409959f, -0.12686296f, -0.10353220f, 0.01777227f, -0.09962367f, 0.07842601f, 0.05127567f, -0.10733522f, 
    -0.00483420f, 0.10713559f, 0.12498591f, -0.03135672f, -0.03742180f, 0.05436761f, 0.04142803f, -0.07958134f, 
    0.13699265f, -0.13625957f, 0.05459319f, 0.02843639f, 0.01608834f, 0.05564289f, -0.10125630f, 0.03194485f, 
    -0.22703928f, 0.23546138f, 0.16527189f, -0.10041726f, -0.09531214f, 0.06045226f, -0.05110583f, -0.01875627f, 
    0.03871230f, 0.00074177f, -0.05110541f, -0.08325513f, 0.04009093f, 0.12297053f, -0.17050150f, 0.09519823f, 
    -0.01795812f, 0.10994834f, 0.09526221f, 0.18164828f, 0.02936343f, 0.07242748f, 0.02281213f, 0.05803183f, 
    0.16727218f, -0.32301280f, -0.13470414f, -0.01538568f, -0.09544133f, -0.11166854f, -0.02703213f, -0.15003698f, 
    -0.05798271f, -0.02535126f, -0.14486337f, -0.07785968f, -0.58527005f, -0.03427243f, -0.15161939f, 0.06779855f, 
    -0.08294114f, -0.13359652f, 0.22974241f, -0.11626573f, 0.07002940f, -0.02301617f, -0.05168673f, 0.01366335f, 
    -0.64498615f, -0.06439457f, -0.11390628f, -0.00596229f, 0.11122132f, -0.04386576f, -0.11780456f, -0.01888909f, 
    -0.10007281f, -0.03369177f, 0.02841114f, -0.04280583f, -0.76231509f, 0.07160540f, -0.11216858f, -0.21829787f, 
    -0.12067977f, -0.11776479f, 0.00238763f, 0.12921785f, -0.21540593f, -0.05777392f, -0.05594108f, 0.08398802f, 
    -0.02101571f, -0.40710515f, 0.31167480f, 0.07813830f, -0.05358116f, -0.08683863f, 0.07484650f, -0.24398938f, 
    0.10789595f, 0.15517795f, 0.00193409f, -0.01498701f, -1.02263784f, 0.07221957f, 0.10400079f, 0.33913597f, 
    0.09111528f, 0.01146401f, 0.01246587f, 0.07879758f, -0.05822572f, -0.00258911f, 0.05585570f, 0.11535564f, 
    -0.19797647f, 0.18036129f, -0.01649628f, -0.51201832f, -0.02087544f, -0.17226499f, -0.09617421f, 0.04938579f, 
    0.09947806f, -0.28040835f, 0.06828139f, -0.07409366f, -0.21158791f, -0.00858876f, -0.19711699f, -0.00609841f, 
    -0.01900017f, -0.05241545f, -0.03232536f, -0.07999237f, -0.11663429f, -0.10622047f, -0.03986923f, 0.15864724f, 
    0.23605175f, 0.00000193f, 0.04041559f, 0.11087145f, -0.22179107f, -0.04136706f, 0.17685263f, -0.03811775f, 
    0.07389791f, -0.19326945f, -0.05069483f, -0.17689115f, 0.30347052f, 0.21746531f, 0.07936542f, -0.42856702f, 
    -0.06542259f, 0.04670875f, 0.13794146f, 0.03174992f, -0.01904300f, -0.00992857f, -0.19719847f, 0.09072778f, 
    0.40706006f, -0.18250382f, -0.00905620f, 0.19297187f, 0.01049081f, -0.07430035f, 0.10189050f, -0.06533904f, 
    0.05974452f, 0.12278358f, -0.04428412f, 0.06199300f, 0.06722932f, 0.51488382f, -0.30505854f, -0.53747016f, 
    -0.02967880f, 0.01440233f, 0.09056966f, -0.02972775f, 0.02109811f, 0.03984875f, 0.01010117f, -0.05017759f, 
    -0.06309270f, 0.25680357f, -0.37732559f, 0.06125122f, 0.00389524f, -0.20588049f, 0.11523107f, 0.13759606f, 
    -0.00831055f, 0.07206222f, -0.01342093f, 0.06559037f, 0.01310617f, -0.05092628f, -0.13888565f, 0.04776514f, 
    0.16041452f, -0.06325130f, -0.01961002f, -0.05127795f, -0.00643009f, -0.01217372f, 0.00335669f, 0.04962279f, 
    -0.37441489f, -0.13022822f, 0.08830311f, -0.15339400f, -0.00313127f, 0.04025600f, -0.11807273f, 0.03404418f, 
    -0.01969448f, 0.16956989f, 0.07586702f, 0.14088231f, 0.13441707f, 0.33649823f, -0.05424960f, 0.01846813f, 
    0.08388700f, 0.00833138f, -0.07259083f, 0.10206741f, 0.03387807f, -0.09086259f, 0.09117224f, 0.09581666f, 
    0.19164449f, 0.03258437f, 0.05315863f, -0.04529868f, -0.13390721f, 0.11603767f, 0.04667502f, 0.11916918f, 
    -0.23247755f, -0.00608010f, 0.09940907f, 0.09093166f, -0.58375323f, -0.38138098f, -0.02745589f, -0.01791640f, 
    0.12905422f, 0.03307733f, -0.15359667f, -0.20753406f, -0.00300468f, 0.02335106f, 0.04408461f, 0.21584311f, 
    -0.11094943f, 0.04838886f, -0.07431526f, 0.06839364f, 0.15170883f, 0.02324669f, -0.10522562f, 0.09611473f, 
    0.07169086f, 0.07755429f, 0.13043906f, 0.14874992f, 0.09663178f, 0.00892313f, -0.06721947f, 0.00780869f, 
    -0.05313022f, -0.02772965f, -0.21488407f, -0.07621538f, -0.09633111f, -0.02868118f, 0.22054203f, 0.36738196f, 
    -0.09476623f, -0.07922088f, 0.06987045f, 0.09331921f, -0.05609858f, 0.13735256f, 0.11935949f, 0.07121078f, 
    -0.02228975f, -0.22214298f, 0.04935066f, 0.05997381f, -0.18287064f, -0.14107643f, 0.02086618f, -0.01517753f, 
    0.16141663f, 0.01303224f, 0.04782480f, -0.18319006f, 0.12383708f, -0.08589903f, -0.15082748f, 0.10890425f, 
    0.08265710f, 0.16216308f, 0.20935254f, 0.37736210f, -0.15476747f, -0.14541195f, -0.02456869f, -0.02527274f, 
    0.17328283f, -0.11501519f, 0.01941063f, -0.11676903f, -0.39524138f, 0.11700835f, -0.06380677f, -0.22238047f, 
    -0.01055072f, -0.06028556f, -0.16542415f, -0.01463527f, 0.06196839f, -0.04542020f, -0.19898088f, -0.15152650f, 
    0.07822718f, -0.07231034f, 0.00384204f, -0.04601548f, 0.09639745f, 0.01048159f, -0.03077172f, -0.10416161f, 
    -0.07376191f, 0.01450114f, 0.07515243f, 0.08699650f, -0.60864997f, -0.37128344f, -0.29131320f, 0.09209361f, 
    0.10135630f, -0.10672818f, 0.10266986f, 0.16106719f, 0.04982444f, 0.14589216f, 0.13108924f, 0.14609742f, 
    0.28479141f, 0.03997822f, 0.05693019f, -0.09604354f, -0.03200983f, -0.12893906f, 0.00028910f, -0.01918050f, 
    -0.02745409f, -0.00443399f, 0.04172886f, -0.08770972f, -0.20100021f, -0.08924950f, -0.38737965f, -0.12930274f, 
    0.16831759f, 0.01088288f, 0.19923583f, -0.23798421f, 0.02074363f, 0.27719912f, -0.22051296f, -0.20496605f, 
    -0.08770087f, 0.31419909f, -0.02904605f, 0.04052610f, 0.04717625f, -0.07969686f, -0.08827446f, -0.07094596f, 
    -0.10148257f, -0.15994772f, -0.10001963f, 0.01363264f, -0.21430926f, -0.21179065f, -0.02074965f, 0.06014686f, 
    0.01584802f, -0.22200853f, -0.05871859f, -0.06391499f, -0.08390344f, -0.06693675f, 0.11061167f, -0.14621885f, 
    0.08583149f, -0.12353887f, 0.11791272f, 0.13727719f, 0.02181271f, 0.07623465f, -0.00378822f, -0.06345224f, 
    -0.15680665f, -0.14719477f, 0.03840780f, 0.19849706f, -0.03378248f, 0.26037487f, 0.17488043f, -0.12920803f, 
    0.05012236f, -0.13117167f, -0.11942314f, -0.18326667f, -0.16442755f, -0.12224633f, 0.06515444f, -0.33826923f, 
    0.09607518f, -0.07422048f, 0.03893927f, -0.11226224f, -0.00316530f, 0.04233207f, -0.03092762f, -0.02306339f, 
    0.12943277f, 0.00875500f, 0.02106374f, -0.05355813f, -0.40162542f, 0.22091217f, -0.07115138f, -0.24433744f, 
    0.01469522f, 0.06073061f, 0.05964703f, -0.28269964f, 0.12751749f, -0.12372850f, 0.06738308f, -0.14815313f, 
    -0.36555427f, 0.18629538f, -0.13376079f, -0.31462499f, 0.11608867f, -0.07107697f, 0.14370482f, 0.11755890f, 
    0.15845720f, -0.05286834f, -0.03934813f, 0.20830895f, -0.27135107f, 0.10655740f, -0.12231378f, -0.22114679f, 
    0.09486398f, 0.06289820f, 0.01627992f, 0.11075012f, -0.06086283f, -0.05275278f, 0.01767953f, -0.42489251f, 
    0.21313596f, 0.05387650f, 0.01906499f, 0.27994239f, -0.10575402f, -0.16262102f, -0.08543184f, 0.34723878f, 
    -0.05478732f, 0.10919402f, 0.11876763f, -0.08018159f, -0.15254232f, 0.11551242f, -0.54109490f, -0.12310405f, 
    0.10120786f, 0.21353047f, 0.02372634f, -0.10443629f, -0.01336048f, 0.02833585f, -0.23662084f, 0.10954601f, 
    -0.41234919f, -0.05654065f, 0.24631062f, 0.16590513f, -0.08024968f, 0.13733438f, 0.30341855f, -0.01038228f, 
    0.15193717f, 0.36443087f, 0.07404236f, 0.09759659f, -0.26508120f, -0.12029354f, -0.05990342f, -0.17381415f, 
    -0.10311963f, -0.18266349f, -0.00348401f, 0.14294411f, 0.15733671f, 0.03368716f, 0.13595268f, -0.14463905f, 
    0.00375725f, 0.13413560f, 0.21598180f, -0.12739633f, -0.05945598f, 0.13620268f, -0.10037977f, 0.07086007f, 
    0.11373278f, 0.20838119f, 0.19127488f, 0.01849712f, 0.14436066f, -0.38166174f, 0.01952444f, 0.27743518f, 
    -0.11636116f, -0.15955092f, -0.10980369f, 0.06054410f, 0.18435651f, 0.15634738f, 0.16684578f, -0.01691939f, 
    0.00164596f, 0.05832884f, -0.06981377f, -0.50690442f, 0.02872483f, -0.10633472f, -0.06092429f, -0.04758636f, 
    0.06431054f, 0.01965477f, 0.12263537f, 0.05883056f, -0.10010329f, 0.04348567f, 0.40961331f, 0.14921868f, 
    0.18423027f, 0.14065520f, -0.20716651f, 0.02494323f, -0.01525355f, 0.01247996f, 0.25465816f, -0.00325077f, 
    -0.20386919f, 0.19343369f, 0.32534012f, -0.04401914f, 0.14223346f, 0.13496543f, -0.03856180f, -0.03553043f, 
    0.10252375f, -0.16428730f, -0.08028936f, -0.00434479f, -0.05589966f, -0.12988918f, 0.29022777f, 0.23955084f, 
    0.00999785f, -0.13118717f, 0.03350149f, 0.03523189f, -0.17334324f, -0.15932335f, 0.04750202f, 0.11038131f, 
    0.07529521f, -0.14745942f, 0.01713864f, 0.26052719f, 0.15568443f, -0.10056427f, -0.05797924f, -0.00367099f, 
    0.07669773f, -0.22787692f, -0.16403084f, -0.00302354f, -0.46085501f, -0.63957518f, -0.17316106f, 0.12020789f, 
    0.04284967f, 0.21181381f, -0.02205835f, -0.02831383f, 0.12155214f, -0.17845705f, 0.01625124f, -0.03012739f, 
    -0.01677201f, 0.41092646f, 0.12342639f, -0.13753755f, 0.01832645f, -0.03769759f, 0.05370227f, 0.05536725f, 
    0.02463472f, -0.09470218f, 0.09445082f, -0.12042159f, -0.64338702f, -0.08616852f, 0.08558422f, -0.09497400f, 
    0.08625866f, 0.00082486f, 0.02462403f, 0.01835989f, -0.04395613f, 0.04491448f, -0.06363130f, 0.12943131f, 
    0.01981233f, -0.03539537f, 0.01069686f, -0.10341448f, 0.10187346f, -0.00558791f, 0.03372193f, -0.14053178f, 
    -0.13000783f, 0.00658240f, 0.04566135f, -0.22296898f, 0.13236491f, 0.07280836f, -0.27331853f, -0.27861509f, 
    -0.05984225f, 0.10917449f, 0.05594186f, -0.08747125f, -0.08765233f, -0.13998975f, -0.18528602f, -0.21804871f, 
    -0.27639630f, 0.22429259f, -0.00822338f, 0.31310242f, -0.06690146f, 0.19104804f, -0.17030369f, 0.14598924f, 
    0.02225245f, 0.16432028f, -0.01261604f, 0.05236333f, 0.21938509f, -0.30067790f, -0.12956637f, 0.26695642f, 
    -0.14143337f, -0.05432936f, -0.04368925f, -0.01398666f, -0.19407870f, 0.02627340f, 0.05523302f, -0.05577501f, 
    0.01807702f, -0.28890622f, 0.03265083f, -0.36488685f, 0.18952736f, -0.27360296f, 0.13805589f, -0.01523420f, 
    -0.15931042f, 0.21715268f, -0.00376005f, 0.04413787f, 0.33635718f, -0.18165241f, 0.10958800f, -0.16833580f, 
    0.12506366f, -0.03307851f, 0.15547256f, 0.09932905f, 0.07011814f, 0.07750913f, 0.11515051f, 0.06100653f, 
    -0.31596020f, -0.21796019f, -0.22192089f, 0.23839955f, -0.06783215f, 0.05224861f, 0.11446994f, -0.02763863f, 
    0.05578796f, -0.04483984f, 0.00394881f, -0.07597563f, -0.34092331f, 0.10376095f, -0.19773795f, -0.30700231f, 
    -0.05925722f, 0.00157812f, -0.08883820f, -0.22960593f, 0.00951960f, -0.07641212f, -0.13967557f, -0.06743452f, 
    -0.38111985f, 0.25356430f, 0.26034766f, -0.07200462f, 0.00139307f, 0.04960100f, 0.19907092f, -0.02331168f, 
    0.11553249f, 0.11839578f, -0.04623268f, 0.22825032f, -0.21594889f, 0.07939550f, -0.03025039f, -0.33885199f, 
    -0.13810909f, -0.09194119f, -0.04724973f, 0.07878403f, -0.11537876f, -0.14189574f, 0.09311142f, 0.07500977f, 
    -0.11707070f, -0.02083742f, 0.03089088f, 0.59344900f, 0.12059947f, 0.04140870f, -0.01766373f, -0.14776823f, 
    0.10216586f, 0.04342372f, -0.04544374f, 0.08322403f, 0.32753998f, -0.12023934f, 0.03759846f, 0.39014393f, 
    -0.01642429f, 0.13139711f, 0.05453659f, -0.07997582f, -0.04195953f, 0.11339350f, -0.01503613f, 0.05043783f, 
    0.00779154f, 0.15201271f, 0.08779807f, -0.18868861f, 0.00173036f, 0.01661311f, 0.08053967f, 0.06206038f, 
    0.15351504f, -0.09119888f, -0.01735830f, -0.14017564f, 0.12268628f, -0.13023588f, 0.01548078f, -0.16646364f, 
    -0.11133195f, -0.02253177f, 0.05982358f, 0.15079230f, -0.14852814f, -0.07326436f, -0.02431689f, 0.27130231f, 
    -0.30211264f, 0.07491619f, -0.07181908f, 0.39191014f, 0.09802195f, -0.05374691f, 0.05379763f, -0.09373855f, 
    -0.02064329f, -0.11916563f, 0.12000465f, -0.03503471f, 0.02051106f, -0.47984630f, -0.16712031f, -0.26524222f, 
    -0.18989639f, 0.03552024f, -0.04732424f, 0.17102005f, 0.15091924f, 0.21093248f, -0.11351074f, 0.17587209f, 
    0.32860196f, -0.34100986f, 0.07481246f, 0.01630799f, 0.07466395f, 0.02021265f, 0.14211385f, -0.03672357f, 
    -0.11316438f, 0.06064611f, 0.05318682f, -0.31915957f, 0.40776798f, -0.32063997f, 0.05541373f, 0.04546126f, 
    -0.08058947f, 0.03646957f, 0.18394871f, -0.15053612f, 0.12430450f, -0.10260327f, 0.19865145f, 0.26992664f, 
    -0.24356675f, 0.20714007f, 0.00932979f, 0.08400618f, 0.17050889f, -0.13643609f, -0.00338861f, 0.03897252f, 
    -0.01192407f, -0.05048185f, 0.01179078f, -0.05859279f, -0.00999357f, -0.21804206f, -0.17318101f, -0.32928324f, 
    -0.05448743f, -0.06342145f, -0.09522057f, -0.19597313f, 0.01878417f, 0.01347134f, 0.23718044f, -0.01302269f, 
    0.19355138f, -0.37687129f, 0.10089669f, -0.12072589f, 0.08037277f, -0.00324282f, -0.00134798f, -0.11167791f, 
    -0.10573212f, -0.02156909f, -0.12922837f, -0.32663354f, -0.20386696f, -0.03197969f, 0.05689173f, -0.01574422f, 
    -0.00200802f, 0.05301575f, 0.01722641f, -0.05172905f, 0.03033031f, -0.08162840f, -0.19693013f, 0.02108347f, 
    -0.33002770f, 0.20557053f, 0.05896310f, 0.00802072f, -0.01600968f, -0.02775970f, 0.13194172f, 0.06583297f, 
    -0.05889770f, -0.09596184f, -0.09089883f, 0.01368442f, 0.27061072f, -0.13360064f, 0.13196377f, -0.18565401f, 
    0.04393375f, -0.08387643f, 0.05462000f, 0.06550518f, 0.03203116f, -0.11189745f, -0.21335346f, -0.16610177f, 
    -0.12947620f, 0.29360053f, 0.24441147f, -0.67778444f, -0.10684077f, 0.21378744f, 0.21209905f, 0.00995134f, 
    -0.18113539f, -0.07088661f, 0.03624877f, -0.13404310f, 0.28670156f, -0.34834051f, -0.33418581f, 0.27436054f, 
    0.04484466f, 0.12184086f, 0.01076321f, 0.02130715f, 0.08364672f, 0.03459021f, -0.08860399f, 0.04480610f, 
    0.13245435f, -0.28088412f, 0.06316753f, -0.11741632f, 0.03673908f, -0.09092577f, 0.02833354f, 0.16700506f, 
    -0.03756713f, 0.01267904f, 0.08718501f, -0.06507915f, -0.09856524f, 0.12001865f, -0.08577064f, -0.04764993f, 
    0.00798833f, -0.00894216f, -0.03082430f, -0.13594475f, 0.15494671f, -0.02198160f, -0.04222527f, 0.21039546f, 
    -0.65446895f, 0.32279921f, 0.04186384f, 0.40857244f, -0.16858137f, 0.03164358f, 0.06841604f, 0.10550667f, 
    -0.01380537f, 0.16426827f, 0.17801423f, 0.14120567f, 0.08083961f, 0.13933021f, -0.06299306f, -0.35575989f, 
    -0.23531570f, -0.08899196f, 0.00689910f, 0.05288007f, -0.25666139f, 0.15273336f, -0.06637707f, 0.15540862f, 
    -0.51261240f, -0.00791814f, 0.00634569f, 0.02496405f, -0.04324063f, -0.22875370f, 0.04881578f, 0.06193961f, 
    -0.10987863f, 0.00887003f, 0.05784742f, -0.00210179f, -0.03028323f, -0.02215300f, 0.20004335f, 0.15474549f, 
    0.18076336f, -0.04624953f, 0.06907926f, 0.02242124f, -0.03189733f, 0.00056283f, -0.01575337f, -0.03093727f, 
    0.00572254f, 0.05387164f, 0.10231031f, 0.13960309f, 0.13939229f, 0.00619233f, 0.00507984f, -0.07296556f, 
    -0.10017550f, -0.02419573f, 0.06124675f, -0.18257035f, 0.14021735f, -0.09733500f, -0.05213267f, 0.05523806f, 
    -0.10711221f, -0.13329661f, -0.05109884f, -0.12914541f, 0.00699479f, -0.00045627f, -0.05496386f, 0.00324316f, 
    -0.67099983f, 0.26306683f, -0.04513727f, -0.12660186f, -0.14471474f, 0.03228011f, -0.11618284f, -0.05696518f, 
    -0.21805897f, -0.01407017f, 0.13690843f, -0.03200843f, -0.07546166f, 0.26261869f, 0.04110164f, 0.12814629f, 
    0.12182672f, -0.01910673f, 0.10252925f, 0.02300750f, 0.04943636f, -0.04007648f, 0.09244797f, 0.00784116f, 
    0.24566530f, -0.19144292f, 0.23826386f, 0.34137765f, 0.21995640f, -0.18834043f, -0.05468175f, -0.10763814f, 
    -0.01665427f, -0.02093905f, 0.06686447f, -0.10896534f, 0.32161543f, 0.12337206f, 0.19214751f, -0.10516399f, 
    -0.13814452f, 0.06604613f, -0.03966301f, -0.04492950f, 0.02926215f, 0.08860421f, 0.02419661f, -0.17260875f, 
    0.00706222f, 0.13584410f, 0.09251713f, 0.13960576f, 0.11426835f, -0.07403839f, 0.12733948f, -0.14573178f, 
    0.09298465f, 0.04176390f, 0.01251785f, -0.10234712f, 0.28573990f, 0.17298777f, 0.18107647f, 0.12955917f, 
    -0.00114251f, 0.03866476f, -0.01018785f, -0.13617551f, 0.06411675f, -0.02025106f, -0.02991938f, -0.10387348f, 
    -0.18097922f, 0.12229122f, -0.07146908f, -0.29833919f, -0.07623409f, -0.05928569f, -0.03471861f, -0.11441664f, 
    -0.02491815f, -0.08149183f, 0.00022262f, -0.15809299f, 0.20586053f, 0.28093460f, 0.11878532f, 0.28008664f, 
    0.02257174f, 0.11826619f, 0.04288761f, 0.01905421f, -0.06134165f, -0.10023301f, 0.02244823f, -0.10783894f, 
    0.08128784f, 0.23476517f, -0.19008127f, 0.15589012f, -0.06243762f, 0.03743599f, -0.15239845f, 0.06819733f, 
    -0.03969797f, -0.04136103f, -0.04222888f, -0.13768403f, 0.09695599f, 0.10298041f, -0.10624883f, 0.17416839f, 
    0.10030154f, -0.01124589f, -0.03216015f, 0.05172662f, -0.09794136f, -0.10990481f, -0.07815644f, -0.00129224f, 
    -0.72115409f, 0.07678337f, -0.14646092f, -0.20485820f, -0.11993026f, -0.16117691f, 0.07426137f, -0.12399665f, 
    -0.14633721f, -0.02193853f, -0.03122622f, -0.00823712f, 0.13952798f, -0.02063601f, -0.17261793f, -0.19395745f, 
    -0.00980345f, 0.04047200f, 0.01802358f, -0.10695046f, -0.01078618f, 0.04621777f, 0.08078172f, 0.05289523f, 
    -0.04343251f, 0.10329921f, -0.17589940f, 0.15475345f, -0.02406134f, -0.04236219f, -0.11292126f, -0.05259571f, 
    0.01067585f, 0.02336915f, -0.06626074f, -0.10366870f, -0.16680911f, -0.03321184f, 0.19266161f, -0.09612675f, 
    -0.05167659f, -0.03797134f, 0.03690330f, -0.03664818f, -0.18685308f, 0.09988928f, 0.08340924f, -0.05211421f, 
    0.46549803f, -0.21511367f, 0.22383212f, -0.34620938f, 0.04434624f, 0.04887960f, -0.05440139f, 0.08755857f, 
    -0.07223224f, 0.09604055f, -0.00630797f, 0.00364750f, 0.30097535f, -0.13100304f, 0.12136551f, -0.17998976f, 
    0.00538469f, -0.01968421f, -0.03726805f, -0.10268241f, 0.03239961f, 0.12467516f, 0.03888033f, 0.01789551f, 
    0.11235880f, -0.41563287f, -0.03289021f, -0.14216089f, 0.10107398f, -0.10828242f, 0.06023021f, -0.04469925f, 
    -0.11730145f, -0.06088507f, 0.00188009f, -0.04923940f, 0.15465008f, 0.20010334f, 0.20569329f, 0.26665750f, 
    -0.05028560f, 0.19832245f, 0.03897247f, 0.06962709f, -0.05288874f, 0.04556469f, -0.09195205f, -0.11772377f, 
    0.01986782f, -0.19177034f, 0.10154063f, -0.10959007f, -0.12971620f, -0.07731096f, -0.04725321f, -0.05790853f, 
    -0.03312398f, 0.07649922f, -0.03070237f, -0.17563927f, -0.27711689f, 0.12273825f, -0.19470577f, 0.00024576f, 
    -0.20378019f, -0.10537698f, -0.09476833f, -0.07256068f, -0.02591386f, -0.00240706f, -0.01484713f, -0.11246651f, 
    -0.06542055f, 0.07636513f, -0.00872739f, -0.08966544f, -0.01650450f, -0.07125924f, -0.07615027f, -0.08801233f, 
    0.00810007f, -0.00930470f, -0.00774803f, 0.02368371f, 0.20257606f, -0.22027248f, 0.09494558f, 0.12402892f, 
    0.04187216f, 0.05515451f, 0.04249392f, -0.03889635f, 0.03254286f, -0.09998967f, -0.10910432f, -0.20281324f, 
    -0.01240172f, 0.19944015f, -0.05598197f, -0.13809417f, 0.01977271f, 0.04012061f, -0.11137088f, -0.06554892f, 
    -0.14662911f, -0.02644929f, -0.01883273f, -0.02541611f, -0.00711862f, -0.17000437f, 0.06792651f, -0.00030546f, 
    -0.01116699f, -0.02958604f, 0.00227341f, -0.11309212f, 0.03633244f, 0.03641178f, -0.02769446f, -0.22485894f, 
    -0.14044058f, -0.04986119f, -0.12653625f, -0.11638346f, -0.05289772f, -0.01762314f, -0.01529804f, -0.20081057f, 
    -0.08394410f, -0.01038741f, -0.09564943f, -0.06894571f, 0.11895292f, 0.04411859f, 0.01139381f, 0.05213974f, 
    -0.08875972f, -0.03267105f, -0.07970054f, -0.01951803f, -0.06407137f, -0.06419772f, 0.00020000f, -0.02297704f, 
    0.03152651f, -0.14073373f, -0.19635873f, -0.26231551f, -0.01697883f, -0.01006211f, -0.03095655f, -0.01222608f, 
    -0.10978061f, 0.01689370f, -0.04303405f, -0.02424161f, 0.12511604f, 0.35973069f, 0.10583002f, 0.26174983f, 
    0.17181240f, -0.00309323f, 0.06734867f, -0.01351054f, -0.07977119f, -0.10508610f, -0.00119234f, -0.17250524f, 
    -0.00395907f, -0.08715867f, -0.29823220f, -0.00465364f, 0.07478541f, -0.23456255f, -0.19543743f, 0.00537787f, 
    -0.03555680f, 0.10360982f, 0.07726960f, -0.15650457f, -0.30068445f, -0.05129372f, 0.21397224f, -0.01941430f, 
    -0.11016487f, -0.03709361f, -0.12463602f, -0.29915392f, -0.00204426f, -0.06411992f, 0.07258268f, -0.10464836f, 
    -0.19592693f, -0.30895272f, 0.17086650f, -0.29266456f, -0.00853814f, -0.05503661f, -0.10465171f, 0.03630199f, 
    0.06650929f, 0.03555688f, 0.06673317f, 0.04932745f, -0.40317926f, -0.06460614f, -0.17066927f, -0.37539589f, 
    -0.24819461f, 0.04941132f, 0.01964814f, 0.06562758f, 0.00312590f, 0.14073414f, 0.03193888f, 0.08531348f, 
    0.21003534f, 0.11365624f, -0.03719924f, 0.05348297f, 0.12888135f, -0.00688558f, -0.13341425f, -0.05380204f, 
    -0.12935852f, -0.06175871f, 0.14173138f, 0.00010846f, 0.22901960f, 0.11551191f, -0.09373337f, 0.10937332f, 
    -0.08824343f, 0.07663874f, 0.11627755f, 0.03502798f, 0.09637936f, -0.14731587f, -0.10022171f, 0.09536359f, 
    -0.22559881f, -0.18520707f, -0.21372442f, -0.28195748f, -0.04533309f, -0.09207143f, 0.02823729f, -0.10571900f, 
    -0.14345513f, -0.09582541f, 0.03857348f, 0.00116400f, -0.21097688f, 0.32076910f, -0.15052396f, -0.05218920f, 
    0.07591593f, -0.24820508f, -0.01131277f, -0.01651068f, -0.00176467f, -0.08217070f, -0.13841675f, -0.05752014f, 
    0.02016216f, 0.33160651f, -0.03111856f, 0.35566196f, -0.07967644f, -0.11241890f, -0.06012142f, 0.03718553f, 
    0.01767151f, -0.04568942f, 0.02532350f, 0.13182035f, -0.04047070f, 0.10824125f, 0.23409185f, -0.22779877f, 
    -0.03811381f, 0.11874002f, -0.02566383f, -0.09902503f, 0.03466534f, 0.07046761f, 0.17386474f, 0.10466749f, 
    0.19221695f, -0.17870876f, -0.16188300f, 0.11664312f, 0.27324298f, -0.25168142f, -0.11036415f, -0.12606870f, 
    -0.03770538f, 0.04198981f, 0.17501923f, 0.03167730f, -0.33153558f, 0.02387035f, 0.25882331f, -0.05843414f, 
    -0.11446660f, 0.00118402f, -0.00636454f, 0.16341697f, -0.16498639f, -0.09616806f, 0.01749266f, 0.05128577f, 
    0.03784396f, 0.14698897f, -0.32069167f, -0.26653981f, 0.03690248f, -0.05160839f, -0.14480343f, 0.00531956f, 
    0.09435815f, -0.09593233f, 0.01853709f, 0.02186058f, 0.23880450f, 0.08126907f, -0.30171251f, -0.07455739f, 
    -0.08521877f, -0.13440314f, -0.12222743f, 0.00931353f, -0.13568932f, 0.00276629f, -0.09260531f, -0.12111622f, 
    0.12340664f, -0.27324480f, 0.07714964f, 0.20895758f, 0.09581532f, -0.01585484f, -0.08422099f, -0.05935760f, 
    0.03555217f, 0.00026112f, 0.09041619f, 0.01081200f, 0.24369317f, 0.06543665f, 0.01935793f, 0.03868540f, 
    0.07873392f, -0.19944054f, -0.06071183f, 0.04765468f, 0.09174836f, 0.07381880f, 0.05189486f, -0.32826951f, 
    -0.18308669f, 0.24889129f, -0.39331552f, 0.00180806f, 0.02430609f, 0.01760457f, -0.08802535f, -0.02248862f, 
    0.04533210f, 0.04088223f, 0.01651464f, -0.04398570f, -0.14368531f, -0.06170007f, 0.09107137f, 0.23206949f, 
    -0.25970230f, -0.05630615f, -0.00611843f, -0.18388963f, 0.01897456f, -0.02782182f, -0.01356278f, 0.08021720f, 
    0.08603119f, -0.04845972f, 0.07988839f, 0.02284566f, -0.09342519f, -0.14267665f, 0.10535616f, -0.10471645f, 
    0.10257802f, -0.00336645f, -0.17032486f, 0.27885771f, 0.20341991f, -0.21975499f, 0.06642992f, 0.06130659f, 
    0.07845332f, 0.10496215f, 0.01724129f, 0.01869795f, 0.02006281f, 0.08497902f, -0.17384019f, -0.17960252f, 
    0.03735927f, -0.28678873f, 0.06781632f, -0.19039023f, 0.15519033f, 0.09932875f, -0.05550849f, 0.07009439f, 
    0.08679766f, 0.00196830f, -0.03121560f, -0.15383087f, -0.11841125f, 0.15446141f, 0.24076220f, -0.02594680f, 
    0.01937453f, -0.00463489f, -0.09979089f, 0.03155159f, 0.04139353f, -0.06212588f, -0.15428087f, -0.15735744f, 
    -0.12160777f, 0.02050039f, 0.02383338f, -0.13920480f, -0.11060166f, -0.00146431f, 0.10557387f, -0.16957359f, 
    -0.09132503f, 0.13222998f, 0.13054983f, 0.08127367f, 0.14263964f, 0.36663902f, -0.01370501f, 0.07973191f, 
    0.01369618f, 0.10538041f, -0.01325650f, 0.06054407f, 0.05169964f, 0.01141615f, 0.04043351f, -0.05037091f, 
    0.35277656f, -0.02263048f, -0.02928359f, 0.25064439f, 0.13384126f, -0.13919859f, -0.10291599f, 0.00958221f, 
    0.10977096f, 0.16488931f, 0.08606859f, 0.08060409f, 0.08208504f, -0.17007098f, 0.05992110f, -0.23203482f, 
    0.08438587f, -0.07860619f, -0.06226399f, -0.07082784f, -0.17708643f, 0.02034040f, 0.15311910f, 0.00660765f, 
    -0.35978433f, -0.35476267f, 0.11727196f, 0.06971365f, 0.12467389f, -0.10597087f, 0.00136590f, 0.01352375f, 
    0.07612128f, 0.00390045f, -0.02531450f, 0.07791044f, 0.02777306f, -0.20787707f, 0.05641825f, 0.13544710f, 
    -0.14027843f, -0.13194539f, -0.22255568f, -0.10397705f, -0.03177361f, -0.11710469f, 0.05145812f, -0.01054099f, 
    0.28955287f, 0.00306057f, 0.15347125f, 0.18945880f, 0.01578898f, -0.04106585f, -0.12629765f, -0.04318823f, 
    0.09836173f, -0.11234932f, 0.08705828f, -0.06656853f, -0.18878946f, 0.01042444f, -0.08714738f, -0.38345346f, 
    0.02259501f, -0.10243998f, 0.06793158f, 0.00427719f, -0.02540279f, 0.09398620f, 0.07537029f, 0.03726788f, 
    0.28415889f, 0.13829382f, -0.01673125f, -0.05918439f, 0.16098440f, 0.01724933f, -0.07623948f, -0.02757073f, 
    0.13020118f, 0.11165371f, -0.18949434f, 0.07426790f, -0.42414132f, -0.09685623f, 0.19912483f, -0.34008881f, 
    -0.01095827f, -0.20781255f, -0.07999080f, 0.06166022f, -0.03217014f, 0.07692436f, 0.18371840f, 0.03089976f, 
    -0.29306695f, -0.12528905f, 0.10941041f, -0.29851654f, -0.02507985f, 0.00283748f, -0.03736068f, -0.07764681f, 
    -0.07049865f, 0.17921858f, -0.01523175f, -0.05721463f, 0.28658721f, -0.79195219f, -0.26117569f, 0.11348964f, 
    -0.01805566f, 0.01082702f, 0.09017631f, 0.28783399f, -0.25271279f, 0.03316429f, 0.21962309f, -0.05453769f, 
    -0.06058653f, -0.21797812f, -0.19363081f, 0.47837543f, -0.14033191f, -0.04397681f, 0.05334321f, -0.11803003f, 
    -0.03073227f, 0.04786396f, -0.09038604f, -0.00350738f, -0.19494002f, 0.16206941f, -0.22288077f, 0.03176858f, 
    -0.11524867f, 0.00732151f, 0.06349149f, 0.02188653f, 0.00038370f, 0.03821971f, -0.01024367f, -0.11564396f, 
    -0.46640947f, 0.42491156f, 0.26777047f, -0.08527919f, 0.03420046f, 0.07035840f, 0.07199293f, -0.32202420f, 
    0.23512687f, 0.03963201f, 0.19277772f, -0.01060402f, -0.40060136f, -0.42256457f, 0.07011918f, -0.17004566f, 
    0.06393301f, 0.05653985f, -0.05667613f, 0.04491417f, -0.11314263f, -0.00261707f, 0.23570366f, 0.01741486f, 
    0.02993976f, -0.28454271f, -0.00095932f, -0.01752470f, -0.10613282f, 0.01086456f, -0.25290915f, 0.04017572f, 
    -0.20137788f, 0.05948331f, 0.02734152f, 0.18777578f, -0.40450832f, -0.07484033f, 0.06580123f, 0.14932346f, 
    -0.00324239f, 0.05260394f, -0.10507697f, 0.07022110f, -0.01639974f, 0.01943377f, 0.31453207f, 0.03742005f, 
    -0.14592785f, -0.61825424f, 0.16750315f, -0.24150562f, 0.02677404f, 0.05088535f, -0.13386579f, 0.03652927f, 
    -0.13982524f, -0.19333735f, -0.08837163f, -0.00082209f, -0.25049907f, -0.59928870f, -0.16228092f, -0.06529440f, 
    0.08166853f, 0.19308233f, 0.04682027f, -0.22328740f, -0.12276130f, -0.02486081f, -0.15832746f, -0.11486516f, 
    -0.13581729f, -0.02637771f, -0.03481683f, -0.03535903f, -0.05349236f, 0.04464531f, 0.13628952f, 0.03965311f, 
    -0.03867840f, 0.00671931f, -0.15622601f, -0.06980860f, 0.47329620f, 0.05793035f, -0.08604246f, 0.03275357f, 
    0.10999518f, -0.07656316f, -0.10717148f, 0.03148850f, -0.13032055f, -0.12846386f, 0.20407614f, 0.12854306f, 
    0.03426959f, 0.02460288f, 0.47374851f, -0.08437109f, -0.03021747f, -0.02391214f, -0.01903171f, 0.14297563f, 
    0.07629874f, -0.08380540f, 0.06642162f, -0.05423260f, -0.11240475f, -0.05301657f, 0.21975398f, 0.06378318f, 
    -0.01959660f, 0.09093493f, 0.01896962f, 0.09666102f, 0.21157058f, -0.06024955f, 0.07563075f, 0.08739237f, 
    -0.34404582f, 0.29237342f, -0.13849542f, -0.49978885f, 0.17826054f, -0.00957800f, -0.04440833f, 0.00212482f, 
    -0.15847141f, -0.05124564f, -0.06925879f, -0.19295108f, 0.08984884f, -0.04217429f, -0.07468424f, 0.04036558f, 
    -0.00362438f, 0.06784350f, 0.07990896f, -0.06825269f, -0.06743225f, 0.06576899f, 0.04386620f, 0.13737422f, 
    -0.07448427f, 0.06929750f, 0.17255421f, 0.17364447f, -0.02031785f, 0.01995473f, -0.03887356f, 0.16330230f, 
    0.00624299f, 0.04558520f, 0.04293731f, 0.01886852f, 0.05181080f, -0.19035919f, -0.05287435f, 0.21129626f, 
    0.16449440f, 0.10715774f, 0.01368575f, -0.12673324f, -0.01739400f, 0.05540810f, 0.00335787f, -0.14491744f, 
    0.18012758f, 0.01321296f, -0.13441990f, 0.07067911f, -0.05346638f, 0.00719406f, 0.05377377f, -0.03229539f, 
    0.01267018f, -0.06736597f, 0.08328549f, -0.20932241f, 0.18724668f, -0.37962520f, 0.09786676f, -0.00409182f, 
    -0.15474349f, -0.03661956f, -0.02109248f, 0.00116795f, 0.03363600f, 0.13400532f, -0.04732953f, 0.14225957f, 
    0.33657920f, -0.40643007f, 0.21994488f, -0.07444641f, 0.13946976f, 0.26408795f, -0.02821994f, -0.00076989f, 
    -0.09140777f, -0.07018971f, 0.11196743f, -0.10633656f, 0.12035733f, 0.11560309f, 0.05698103f, -0.11315110f, 
    0.04973285f, -0.05098098f, 0.02200845f, 0.12913293f, 0.08925193f, -0.10004767f, 0.05002133f, 0.01083550f, 
    0.53485197f, 0.09328966f, -0.45261857f, 0.17129910f, 0.15867965f, -0.11406124f, -0.12591797f, 0.24111341f, 
    -0.14844780f, -0.09263183f, 0.00853571f, -0.05321192f, -0.36940348f, 0.60031033f, 0.14502276f, 0.14983912f, 
    0.14357217f, 0.06067084f, -0.08920413f, 0.06274732f, 0.02030118f, -0.02864906f, 0.00310707f, -0.06249830f, 
    0.14256127f, -0.32630554f, 0.09060396f, 0.18219396f, 0.19877487f, -0.08919153f, 0.05849966f, -0.08725172f, 
    -0.14136767f, -0.01407067f, -0.08689451f, -0.26311311f, 0.14552589f, -0.11638272f, -0.00305178f, 0.23769097f, 
    -0.07250314f, -0.07053448f, 0.10987178f, 0.08137590f, 0.21746874f, 0.05095486f, 0.07125891f, -0.08863553f, 
    -0.68227237f, 0.17151567f, -0.17743330f, -0.13446380f, -0.04850183f, -0.06263258f, -0.06950331f, -0.10183066f, 
    -0.06328940f, -0.09231444f, -0.00942426f, 0.04823473f, 0.09197663f, 0.18946579f, -0.44635430f, -0.16501215f, 
    0.07042564f, -0.14128578f, 0.11146528f, -0.11768538f, -0.08531347f, -0.05764005f, -0.14479201f, 0.04287297f, 
    -0.17845790f, 0.36822790f, -0.20364659f, -0.34451181f, 0.25322995f, -0.06343485f, 0.02179229f, -0.16302693f, 
    -0.13586228f, -0.06932712f, -0.06462765f, 0.07983713f, -0.13933679f, -0.23051021f, 0.04826002f, 0.19044754f, 
    -0.13520689f, -0.01948936f, 0.11364137f, 0.01513764f, 0.09644438f, -0.09883726f, 0.04119977f, -0.01868707f, 
    0.63501877f, 0.18023160f, 0.16848083f, -0.07968476f, -0.03808695f, 0.13852519f, 0.08994829f, 0.01341319f, 
    0.07520065f, 0.01361761f, -0.00148330f, -0.05033796f, 0.09720900f, -0.22595410f, -0.00100367f, 0.20660657f, 
    0.04926383f, -0.08917321f, -0.04303142f, 0.10654532f, 0.15404274f, 0.02293696f, -0.00724145f, -0.00432828f, 
    0.08498406f, -0.07534203f, -0.11387577f, -0.12568280f, 0.07750467f, -0.07575570f, -0.15960565f, -0.14026541f, 
    -0.01784866f, -0.02155777f, -0.17826486f, -0.05751104f, 0.09688119f, -0.00533749f, 0.06597190f, -0.13151237f, 
    -0.03296558f, -0.03892824f, 0.16277525f, -0.15384775f, -0.08670564f, -0.05411245f, 0.03409209f, -0.09201099f, 
    0.33527398f, 0.06463803f, 0.06525458f, -0.06380636f, 0.22861163f, 0.22125262f, 0.12725595f, 0.17018060f, 
    -0.03791425f, 0.03830635f, 0.07175117f, 0.02871663f, 0.40607762f, 0.26902375f, -0.03442230f, -0.14585258f, 
    0.04495357f, -0.04075389f, 0.03514775f, 0.13750000f, -0.10355198f, 0.05536196f, -0.02848918f, 0.16042030f, 
    -0.70623678f, -0.50957268f, 0.04223764f, -0.03605358f, 0.06520867f, 0.07521554f, 0.07811397f, 0.02403201f, 
    0.33009589f, -0.18430381f, 0.00437117f, 0.00555894f, 0.02123567f, 0.14923726f, -0.12317095f, -0.07353364f, 
    -0.07389301f, -0.03021492f, 0.01656917f, -0.06641056f, 0.03285095f, 0.09136795f, -0.02909517f, -0.01359076f, 
    -0.34037253f, 0.10817454f, -0.06344501f, -0.04642799f, 0.00550303f, 0.27045152f, 0.03318006f, 0.01246524f, 
    0.03938530f, -0.18619609f, 0.10063294f, -0.12682445f, 0.20661582f, 0.02794152f, -0.20753586f, -0.04391770f, 
    0.04000202f, -0.08598310f, 0.00718644f, -0.08444872f, -0.07026842f, -0.29919770f, -0.20272887f, -0.09753442f, 
    0.00883697f, 0.04148299f, -0.00799285f, 0.01313967f, -0.16416857f, -0.04017370f, 0.07388886f, 0.00050868f, 
    -0.06604258f, 0.22558257f, 0.08105305f, 0.13023689f, 0.27285585f, 0.15633225f, -0.10304097f, -0.02569532f, 
    -0.03043784f, 0.22384174f, 0.24675360f, 0.00957157f, -0.02790966f, -0.00670509f, 0.02847918f, 0.11581576f, 
    -0.66124654f, -0.58257890f, -0.09748490f, -0.34000763f, 0.12295078f, 0.09637565f, -0.23051466f, -0.08143901f, 
    0.12247775f, -0.03866894f, 0.05213850f, 0.06604098f, 0.18757455f, -0.16184141f, 0.19047803f, -0.03578218f, 
    -0.16797578f, -0.05889748f, 0.03201637f, -0.06720656f, 0.03649484f, 0.16080865f, -0.13884471f, 0.00105529f, 
    -0.43055302f, -0.18589050f, 0.37949276f, 0.01502846f, 0.17249033f, 0.01043993f, 0.01950032f, -0.20581362f, 
    0.04834171f, -0.02160320f, -0.08635543f, 0.00694812f, -0.08391599f, 0.12745050f, -0.11085800f, -0.00637552f, 
    -0.10551243f, -0.08402196f, 0.01449258f, -0.13348325f, 0.09159015f, -0.01375717f, -0.11185416f, -0.22091848f, 
    -0.65470982f, -0.39222115f, -0.01136030f, -0.28487656f, 0.00127316f, 0.03945066f, 0.00486276f, 0.06960218f, 
    0.22073722f, 0.10730603f, 0.15500541f, 0.03998117f, -0.00400082f, -0.15985969f, -0.09118328f, -0.08306431f, 
    0.10848661f, -0.20434679f, -0.04577598f, 0.10091022f, -0.04772756f, -0.09505885f, -0.03001351f, -0.17656726f, 
    -0.23560694f, -0.05548815f, 0.22503762f, 0.06461336f, -0.02545025f, 0.15369056f, -0.03897667f, 0.04119871f, 
    0.08508737f, 0.02262873f, 0.02037791f, 0.01047560f, 0.22864656f, 0.19100980f, -0.01545133f, 0.13193566f, 
    -0.11251365f, -0.14073510f, 0.00425515f, 0.03724690f, -0.10370311f, -0.07525600f, -0.04134204f, -0.07853454f, 
    -0.02777599f, -0.24124193f, -0.19565950f, 0.09234772f, 0.01687239f, 0.10905650f, 0.02682701f, 0.07784644f, 
    0.09558013f, 0.08506454f, 0.12537415f, 0.16685250f, 0.26913434f, -0.09676657f, -0.15344483f, 0.09464633f, 
    -0.03519775f, 0.16216500f, -0.10482026f, -0.04438840f, -0.08116338f, 0.00057012f, -0.18135487f, -0.14937583f, 
    -0.56478137f, 0.25132450f, -0.03355464f, -0.10850254f, 0.16111238f, 0.06103807f, -0.12877813f, -0.03038643f, 
    0.00291913f, 0.00434835f, -0.10106429f, 0.12170924f, 0.22854076f, 0.06366473f, 0.05256977f, -0.08658005f, 
    -0.14113785f, 0.11313398f, 0.04324124f, -0.05079525f, 0.16428439f, -0.10040540f, -0.21471281f, -0.04464893f, 
    0.10802291f, 0.06636132f, -0.02276617f, 0.24246916f, -0.08547655f, -0.05999534f, 0.19271506f, 0.10533368f, 
    0.14644690f, 0.31887847f, -0.01606773f, -0.02054592f, -0.08150724f, -0.14889705f, 0.03614097f, 0.17012462f, 
    0.12930214f, -0.04830608f, 0.23775594f, 0.13673767f, 0.11364851f, 0.12334019f, 0.08317847f, -0.00479260f, 
    -0.34380233f, -0.10902551f, -0.02998110f, -0.09143800f, 0.05222230f, -0.03294732f, -0.01738812f, -0.02402319f, 
    0.14329585f, 0.20979333f, 0.12151130f, 0.18919955f, -0.15560547f, 0.05354037f, 0.09299109f, -0.19820616f, 
    0.12772699f, 0.02320407f, -0.05620357f, 0.04450200f, -0.10476179f, 0.06215979f, 0.14710146f, 0.02400079f, 
    -0.88191170f, -0.72251904f, -0.10623762f, -0.20332395f, -0.05590142f, -0.12300426f, 0.07308181f, 0.17933705f, 
    -0.10186186f, 0.11348721f, -0.01439853f, 0.00994020f, -0.07823198f, 0.26766282f, -0.12592156f, -0.19346242f, 
    -0.02663253f, -0.08984514f, -0.05477104f, 0.04901119f, 0.05256677f, -0.04162893f, 0.07954717f, 0.02696637f, 
    -0.06801309f, -0.02695347f, -0.14842319f, -0.26915842f, -0.02401949f, 0.00799733f, -0.13055418f, 0.11694214f, 
    -0.00381996f, 0.01663743f, 0.01038473f, -0.03646233f, 0.24544613f, 0.16266301f, 0.19584897f, 0.09016059f, 
    0.09216093f, 0.32657996f, -0.10281331f, 0.06821938f, 0.07730730f, 0.07369027f, -0.17974621f, 0.00371382f, 
    -0.58998114f, -0.37032750f, 0.00966480f, -0.04226056f, 0.15766446f, 0.09254915f, -0.15066327f, -0.22320108f, 
    -0.04239900f, -0.28690591f, -0.06039926f, 0.14638734f, 0.13070290f, 0.23208070f, -0.09920628f, -0.21416615f, 
    0.05326670f, -0.09613885f, 0.24072015f, 0.07840043f, -0.10776486f, -0.08923294f, 0.11364920f, 0.14300686f, 
    0.41579539f, 0.17363310f, -0.15007585f, -0.12417512f, 0.19988243f, -0.06811064f, 0.20329522f, 0.03180702f, 
    0.16494310f, 0.05078795f, 0.09371711f, 0.02692967f, -0.02236243f, 0.06812660f, -0.01698694f, -0.08115104f, 
    -0.21512733f, -0.03009339f, 0.08077326f, -0.15164849f, -0.03987585f, 0.07319073f, 0.02541015f, -0.25150424f, 
    -0.02419611f, 0.16775967f, 0.07854960f, -0.25964278f, -0.21483006f, -0.08354158f, 0.05962462f, -0.25436312f, 
    -0.04629985f, -0.06500690f, 0.07987577f, -0.07382364f, -0.33840385f, 0.01789342f, -0.14814067f, 0.02411572f, 
    0.27682114f, -0.21879646f, 0.18276472f, 0.16199633f, 0.03401423f, -0.12129206f, -0.14903091f, -0.15761152f, 
    0.39296550f, -0.31848773f, -0.04154905f, -0.14166090f, 0.16224842f, 0.09440953f, -0.00943243f, 0.00401550f, 
    0.05614307f, 0.16675276f, 0.06146789f, 0.07579634f, -0.43930197f, -0.30034328f, -0.09732722f, -0.06291375f, 
    -0.15351786f, 0.17018367f, -0.10726555f, 0.19168852f, -0.08284189f, 0.03539710f, -0.03647098f, -0.04346306f, 
    0.26553980f, 0.07716262f, 0.02369139f, 0.33069918f, -0.28062272f, -0.03490112f, 0.00080872f, -0.10610247f, 
    -0.06999872f, 0.16651471f, 0.05456203f, -0.04263850f, -0.33718902f, 0.11838573f, -0.13389897f, 0.03482512f, 
    0.14285149f, 0.02574649f, 0.18369719f, -0.04341698f, -0.01910152f, -0.09620827f, -0.03300270f, -0.02789839f, 
    -0.19680415f, 0.01607365f, -0.11337502f, 0.17672212f, -0.03527806f, 0.02557352f, 0.02026594f, -0.03215192f, 
    -0.07744585f, -0.06259041f, -0.07971710f, -0.15866561f, 0.07454694f, 0.19020617f, -0.24117638f, -0.12802884f, 
    -0.06629395f, 0.11688283f, -0.09608407f, -0.02198672f, 0.01870957f, -0.10148438f, -0.10615469f, -0.21719298f, 
    -0.18823330f, 0.13082401f, 0.02934484f, -0.21182871f, 0.14060400f, 0.02240879f, -0.14635256f, 0.03952125f, 
    0.03608111f, -0.12406945f, -0.02289510f, -0.00982627f, -0.02179578f, 0.07150453f, 0.04830266f, -0.12564340f, 
    0.12784000f, -0.05132171f, -0.22680616f, 0.18483645f, -0.12228473f, -0.17499967f, 0.13405989f, 0.01418466f, 
    0.23870724f, 0.28841501f, -0.01608547f, -0.06638259f, 0.13315679f, 0.05731966f, -0.21925572f, -0.13581912f, 
    0.04823846f, 0.17270555f, 0.12715529f, 0.04966428f, -0.14138374f, -0.51623094f, -0.07716983f, 0.24532963f, 
    -0.09547986f, 0.10103367f, -0.23220980f, 0.10355388f, -0.03354459f, 0.01893314f, 0.10751733f, 0.02613962f, 
    0.42978275f, -0.39579427f, -0.06213536f, -0.09079797f, 0.16129646f, -0.05015934f, -0.07649908f, 0.00024930f, 
    0.00322312f, 0.07130577f, -0.08034195f, 0.08696651f, -0.29533052f, -0.10399307f, -0.14251682f, -0.49133757f, 
    0.24150969f, 0.10508958f, 0.11129672f, 0.04541688f, 0.02662726f, -0.07241622f, -0.06348974f, 0.03249038f, 
    -0.05714732f, 0.58396250f, -0.19413339f, 0.31383201f, 0.16051543f, -0.02198624f, 0.00636061f, -0.06771927f, 
    0.04750548f, 0.02033961f, -0.05479567f, 0.09270054f, 0.25872412f, -0.11171614f, 0.20686600f, -0.03365256f, 
    -0.02138939f, -0.03511286f, 0.07420815f, 0.07505795f, -0.14995036f, 0.15934700f, -0.09027692f, -0.02120937f, 
    -0.28580260f, 0.33750555f, 0.05968101f, 0.06927286f, 0.10575248f, -0.21502642f, -0.13036984f, -0.01307757f, 
    0.01199852f, -0.04539099f, -0.19297217f, -0.19036113f, -0.59690160f, 0.14001706f, 0.06559803f, -0.01170283f, 
    0.00778292f, -0.19004254f, -0.11029127f, -0.04093538f, 0.02999050f, 0.04568888f, 0.15293677f, -0.04711230f, 
    0.52465457f, 0.26109624f, -0.05805998f, -0.10278838f, -0.22149029f, 0.09321546f, -0.10928883f, 0.14114788f, 
    0.14116742f, -0.14619344f, -0.01274474f, 0.07347136f, -0.04594706f, -0.00593382f, -0.03974647f, 0.06295593f, 
    0.01834953f, -0.29123104f, -0.08749807f, 0.01435139f, -0.04077680f, 0.06584971f, 0.15008575f, -0.01894299f, 
    -0.00583651f, -0.13470741f, 0.22806279f, -0.05441720f, -0.05058772f, -0.03837028f, -0.18557732f, 0.04528556f, 
    -0.05584516f, -0.04585756f, -0.01817416f, -0.02761372f, 0.21997033f, -0.09368635f, -0.04181803f, 0.28700131f, 
    0.21552329f, 0.00920918f, -0.10850451f, -0.09862342f, 0.10935511f, 0.03708873f, -0.06433386f, 0.02534209f, 
    -0.17882499f, 0.11497624f, -0.18124829f, -0.17598316f, 0.08857249f, 0.03865502f, -0.03327536f, 0.10675914f, 
    -0.00607612f, -0.21640906f, 0.03244241f, -0.16553965f, -0.21421359f, 0.09678745f, 0.02882884f, 0.05663628f, 
    -0.09421273f, 0.12456518f, -0.13922152f, -0.03443807f, 0.05574874f, 0.00493552f, -0.22595148f, 0.15922748f, 
    -0.14201164f, 0.45538029f, -0.30200294f, -0.03228714f, 0.27337661f, 0.00514102f, 0.12243391f, 0.17024979f, 
    -0.02518477f, -0.02549382f, 0.06889665f, 0.06802740f, -0.15850225f, -0.23933874f, 0.12499650f, 0.29174381f, 
    -0.11342573f, 0.17243190f, -0.05320058f, 0.03081946f, 0.05732171f, 0.14182958f, 0.13751265f, 0.17586331f, 
    -0.21001406f, -0.48931870f, 0.07901134f, -0.40483633f, -0.01515890f, 0.17989486f, 0.02432849f, -0.00952920f, 
    -0.04206667f, -0.05132899f, -0.08915249f, -0.02929153f, -0.25044778f, 0.10028800f, -0.11217555f, -0.22154942f, 
    0.00047595f, 0.04374695f, 0.10049701f, 0.07999875f, 0.13431166f, 0.06213539f, -0.01733578f, -0.10336255f, 
    0.10298023f, 0.01595231f, -0.22714260f, -0.24645765f, 0.11959694f, -0.08168579f, -0.15603688f, 0.19052829f, 
    -0.00816480f, 0.02824340f, 0.18084763f, -0.04308534f, 0.34241578f, -0.16434558f, -0.07815932f, 0.03045893f, 
    -0.00864608f, -0.13814837f, 0.12978940f, -0.07908343f, -0.09223491f, -0.12220799f, 0.07890226f, -0.06845950f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.10547470f, 0.03202794f, -0.01871250f, -0.02737484f, -0.00716665f, -0.03367106f, 0.02157214f, -0.13239741f, 
    -0.01350180f, -0.00141286f, 0.06680214f, 0.08042101f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
