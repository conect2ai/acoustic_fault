#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.57468969f, -1.17616022f, -1.01405311f, -0.71664351f, -0.80447268f, -0.43457058f, -0.29956451f, -0.21041545f, 
    0.15295918f, 1.05731249f, -0.92543244f, 0.22044708f, -1.07694674f, 0.34279943f, -0.82558018f, -0.81013626f, 
    -0.34154543f, -0.36522105f, 0.96433431f, 0.69610387f, 0.93469667f, 0.44270319f, 0.50778764f, 1.23174310f, 
    -0.18363319f, -0.05871801f, -0.25294006f, 1.17593265f, 0.53947842f, 1.12339318f, 0.77285510f, -0.21002536f, 
    -0.52595240f, 0.49531537f, 0.84722537f, -0.80637908f, -0.10478971f, 1.15698385f, -0.94595337f, 1.29389262f, 
    0.45857725f, -0.41750327f, 0.77946419f, 0.09195426f, -0.09132034f, -1.38747573f, -0.73951542f, 0.33929417f, 
    0.65882140f, -0.97903985f, 0.14983502f, 0.07319954f, 0.33641666f, 0.45284978f, -1.21928692f, -0.48359740f, 
    -0.16800925f, -0.24527580f, 1.02618968f, -0.89458102f, 0.39784908f, 0.01640036f, -0.71745485f, 0.46758008f, 
    0.82727748f, 0.84027857f, -1.12752438f, -0.79252094f, -1.15057647f, 0.30019656f, -0.05652772f, 0.46551460f, 
    -0.99659806f, -0.13796884f, 0.04873559f, 0.05002706f, 0.57916486f, 1.06408882f, 0.87069917f, -0.64310277f, 
    0.88493890f, -1.21863103f, 0.55330741f, 0.91590363f, 0.88373244f, 0.93669581f, -0.74352151f, -0.11534178f, 
    0.25583240f, -0.26060855f, 1.40926564f, 1.27845991f, 1.10838306f, -0.11972562f, 0.17012519f, -0.03038381f, 
    0.24329858f, -0.20292392f, 0.64407438f, -1.14363217f, -0.69930720f, -1.19805479f, 0.92524594f, -0.26644209f, 
    0.68819779f, -0.16980754f, -0.10251515f, -0.30788821f, -1.85653543f, 0.76975995f, 0.23866419f, 0.31014338f, 
    1.16038609f, 0.66575873f, -0.58401275f, -0.24593939f, -0.09065059f, -1.12282658f, 1.10890400f, -0.73184997f, 
    -0.46645814f, -0.53721291f, -1.01778746f, -0.37154403f, 0.16110615f, 0.48586413f, -0.52215201f, -0.95927668f, 
    -1.00609088f, -0.15121293f, 1.16585100f, 0.73772907f, -0.27356812f, 0.06696967f, -0.60605228f, -0.83426112f, 
    -1.11499560f, -0.09978858f, -1.39662242f, -0.06323463f, 0.82872462f, 0.00668616f, 0.30226034f, -0.16730939f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16201361f, 0.18153568f, 0.55902582f, 0.32892638f, 0.17051750f, 0.08052246f, -0.26174602f, 0.27913579f, 
    0.26932403f, -0.30706725f, 0.48278138f, 0.04958225f, 0.21094710f, 0.28625128f, -0.18457277f, 0.47278923f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.43835112f, 0.10774532f, 0.14629900f, -0.23691331f, 0.16048062f, 0.10396396f, -0.05860193f, -0.13940281f, 
    -0.15411790f, -0.46179575f, -0.05725227f, -0.16823164f, 0.23280425f, 0.27699730f, -0.05499474f, -0.09617473f, 
    0.04042965f, 0.09611347f, 0.00437468f, 0.10598193f, 0.12603343f, -0.24102123f, 0.22853668f, 0.13208129f, 
    0.10104653f, 0.22653982f, -0.23786490f, 0.40430060f, 0.33010733f, -0.11094954f, -0.06690256f, 0.07035068f, 
    0.20234117f, 0.06112505f, 0.25503996f, 0.11764268f, -0.46605220f, 0.20981370f, 0.45897353f, 0.06957699f, 
    0.00141367f, 0.05135627f, 0.14300177f, -0.00092856f, 0.06076024f, 0.06094119f, -0.22638464f, -0.30409032f, 
    0.11559072f, 0.03059676f, 0.09865778f, 0.15787984f, 0.14218184f, 0.01141705f, -0.68070614f, -0.15674447f, 
    -0.19145283f, -0.20757253f, 0.20662062f, -0.27309766f, 0.17375392f, 0.08060430f, -0.05970614f, 0.30655965f, 
    0.27628541f, 0.06574360f, -0.14828280f, -0.07586394f, 0.11624391f, 0.03118895f, 0.04942834f, 0.26496616f, 
    0.21942949f, -0.40406245f, 0.05331770f, -0.25456733f, -0.00069790f, 0.03028185f, 0.03098172f, 0.14672150f, 
    -0.00548620f, -0.24139617f, -0.16465083f, 0.14784883f, 0.05955415f, 0.05146187f, -0.03512819f, -0.18853655f, 
    -0.14011090f, -0.02143879f, -0.37518474f, -0.22279721f, 0.19954096f, -0.08110065f, 0.02820087f, -0.05145096f, 
    0.11860383f, 0.12006290f, -0.09775226f, -0.10818549f, -0.02544798f, 0.08055966f, -0.05439096f, 0.16863896f, 
    -0.18155158f, -0.18137620f, -0.20143011f, -0.07003158f, 0.70357257f, -0.46942991f, 0.07896172f, -0.21549283f, 
    0.14712033f, -0.08448781f, 0.07304060f, 0.03524193f, 0.11380170f, 0.46170142f, -0.38168472f, 0.18372580f, 
    -0.16973484f, 0.15924579f, 0.21047959f, -0.05405308f, -0.11526906f, -0.12566797f, 0.20725943f, -0.32742894f, 
    -0.63250875f, -0.00820105f, 0.09449148f, -0.15677553f, -0.10636520f, -0.08966530f, -0.22582339f, -0.13875125f, 
    -0.15966293f, -0.05591978f, -0.00311398f, 0.24214016f, -0.04447781f, -0.00780299f, 0.17151698f, -0.05241814f, 
    -0.49719772f, -0.20972523f, 0.00409740f, 0.01951942f, -0.02062398f, -0.16427821f, 0.04087910f, 0.08614864f, 
    -0.06318759f, 0.19420587f, -0.21384023f, -0.10177776f, -0.14493883f, 0.19882087f, 0.17755039f, -0.18938723f, 
    0.17595807f, -0.27640218f, -0.10646719f, 0.16519776f, -0.14215285f, -0.22970343f, -0.04174052f, 0.17824011f, 
    0.02320088f, 0.10708851f, 0.00966459f, -0.22724912f, 0.28389004f, 0.16930470f, 0.23082897f, -0.09010603f, 
    0.26965529f, 0.00320370f, 0.09298011f, -0.15389515f, 0.41499007f, -0.15234165f, -0.02786223f, 0.06265377f, 
    0.11482341f, -0.09407531f, -0.15385132f, 0.20108275f, -0.00852837f, -1.04533350f, -0.56585109f, -0.30112293f, 
    0.13980080f, 0.01581405f, -0.11808127f, 0.00944118f, 0.24819678f, 0.25199252f, 0.23411831f, 0.08719998f, 
    0.16138832f, -0.26457596f, -0.07106852f, 0.25782183f, -0.17526126f, -0.25743181f, -0.13942420f, 0.38734111f, 
    0.25546440f, -0.15575884f, -0.01443018f, -0.14170153f, -0.14002225f, -0.20080897f, 0.17076582f, 0.18055737f, 
    -0.62141019f, -0.11216910f, 0.05890045f, 0.01167211f, 0.07395133f, 0.07719576f, -0.13572422f, -0.05622976f, 
    0.20080180f, -0.27922606f, -0.12610999f, 0.64542896f, 0.09366364f, -0.07012744f, -0.19593401f, 0.01448389f, 
    0.09137215f, 0.04493630f, 0.13930905f, 0.32244700f, -0.11851602f, 0.11259417f, 0.15702139f, 0.03603165f, 
    -0.03239644f, 0.10897217f, -0.07054404f, 0.14437743f, 0.23989670f, -0.14375024f, -0.07013895f, 0.07613321f, 
    0.15342012f, 0.36045235f, -0.16865695f, 0.09559949f, 0.33322293f, 0.14944926f, 0.19840761f, 0.11061899f, 
    0.05778449f, -0.17313555f, 0.15959628f, -0.08182006f, 0.00924394f, 0.02795280f, -0.38335726f, 0.22504163f, 
    -0.08564599f, -0.11004320f, -0.31179059f, 0.26147285f, 0.03633358f, 0.03935992f, -0.16881329f, 0.32378492f, 
    -0.65970510f, 0.04511327f, 0.17796052f, -0.01557829f, -0.23171817f, -0.00527523f, -0.26270261f, -0.41163340f, 
    -0.08205310f, -0.12679712f, -0.10729891f, 0.00570133f, 0.22905585f, 0.16982944f, 0.20375900f, 0.03312800f, 
    -0.05018567f, -0.08358995f, 0.06580622f, -0.04423333f, -0.03348893f, 0.06128459f, 0.04189374f, 0.00670172f, 
    -0.07659774f, 0.04036770f, -0.07915124f, -0.04015895f, -0.09353792f, -0.03289461f, -0.06635553f, -0.01177910f, 
    -0.08295421f, 0.04809086f, 0.02326213f, 0.05577439f, 0.04855159f, 0.01888712f, -0.01533756f, -0.05560585f, 
    -0.00489959f, -0.09422270f, 0.02489182f, 0.00179914f, -0.03619338f, -0.07698920f, -0.06956463f, -0.03551042f, 
    -0.05757223f, -0.00022661f, -0.01276174f, -0.08021121f, -0.04046674f, 0.01910142f, -0.05668018f, -0.07249054f, 
    -0.04426719f, -0.01095047f, -0.01617750f, 0.02408651f, -0.07099762f, -0.08618673f, -0.04106115f, -0.06891718f, 
    -0.00359130f, -0.01190021f, 0.04466588f, 0.00013978f, 0.06552017f, -0.03284624f, 0.00328574f, -0.05875508f, 
    0.00159376f, -0.05408528f, -0.08543646f, -0.04353472f, -0.02387162f, 0.00959388f, -0.06548210f, -0.04806902f, 
    0.00912203f, 0.05167845f, 0.03457077f, 0.02388320f, -0.03990017f, -0.04709961f, -0.01487167f, -0.00800783f, 
    -0.01828947f, 0.06790570f, 0.01985424f, 0.04533331f, -0.08138458f, 0.01014057f, -0.00369337f, -0.08732712f, 
    0.05498192f, 0.05622678f, 0.02299972f, -0.03395341f, -0.08251613f, -0.03210546f, 0.01753952f, -0.06573015f, 
    -0.05994823f, -0.06850543f, -0.00772324f, -0.07966906f, -0.04406372f, 0.00015556f, 0.03974722f, -0.09745070f, 
    0.00168413f, 0.01289244f, -0.01702764f, 0.01495799f, 0.04278664f, 0.00045663f, -0.02535431f, 0.01414434f, 
    -0.05050508f, -0.01138915f, -0.06537691f, 0.01811162f, -0.00893572f, 0.03682253f, 0.06923914f, -0.08627703f, 
    -0.01425205f, -0.03407888f, -0.05750122f, -0.02896921f, -0.07903506f, 0.01956797f, 0.06310689f, -0.01615293f, 
    -0.06037518f, 0.01051074f, 0.05063939f, -0.00221100f, 0.02728304f, -0.04176010f, -0.05171552f, 0.00983107f, 
    -0.03932136f, 0.04148637f, -0.00268560f, -0.04561174f, 0.00643712f, -0.02505808f, -0.01494522f, -0.08133977f, 
    0.01805758f, -0.08468395f, -0.01871232f, 0.05713845f, 0.03090934f, 0.03805073f, -0.03682889f, -0.02064768f, 
    -0.23231846f, 0.10098448f, 0.14424102f, 0.34526342f, 0.00238940f, -0.01513693f, 0.23132132f, -0.00661167f, 
    0.07353181f, 0.19587387f, 0.25368425f, -0.32807386f, -0.31032923f, 0.11066389f, 0.11371084f, 0.11433154f, 
    -0.21843812f, 0.08672813f, 0.06004694f, 0.38195717f, 0.41229004f, 0.30057386f, 0.13527603f, -0.08799282f, 
    0.03956480f, 0.01852497f, -0.10651666f, -0.12438188f, 0.23621270f, 0.01863437f, 0.00421664f, 0.22938196f, 
    0.09112272f, -0.01980812f, -0.03926588f, 0.29888758f, -0.22680615f, -0.31142062f, 0.46157196f, -0.02718705f, 
    0.17376199f, 0.14746228f, 0.09780025f, 0.02960960f, -0.01816357f, -0.65574867f, -0.87581623f, -0.62886661f, 
    0.08665527f, 0.13039432f, -0.16404693f, 0.23166995f, 0.00827997f, -0.10226925f, -0.62131613f, 0.20659874f, 
    -0.34829500f, 0.23988302f, 0.22982270f, 0.19748829f, -0.02604121f, -0.04308405f, -0.12474439f, 0.10686760f, 
    0.25027150f, 0.29865536f, -0.04471620f, -0.02103933f, 0.09150515f, 0.19840892f, 0.04590167f, 0.23376724f, 
    -1.02155066f, -0.16307271f, -0.21275781f, 0.00353410f, 0.14309497f, -0.02644551f, 0.26535714f, -0.30202374f, 
    -0.07964534f, -0.14358430f, -0.43843001f, -0.29656592f, -0.05870092f, -0.23753840f, -0.03589415f, 0.04919052f, 
    0.15416273f, 0.00848846f, -0.04190389f, 0.27800542f, 0.38481048f, 0.09790991f, 0.11355649f, -0.24112365f, 
    0.08014572f, 0.02732371f, -0.22030805f, -0.46914724f, -0.16246590f, 0.07044643f, 0.01791004f, -0.10018291f, 
    0.06385019f, 0.17188738f, -0.11964434f, -0.00150595f, 0.46980879f, -0.28316855f, 0.06996213f, 0.03141919f, 
    0.00047251f, 0.41425407f, 0.07937820f, -0.18959650f, 0.19230193f, -0.12485787f, 0.26373720f, 0.27959299f, 
    0.01159142f, 0.21236733f, -0.05340634f, -0.02336658f, 0.14270718f, 0.03931966f, -0.23944686f, -0.06643838f, 
    -0.07013600f, 0.12330522f, 0.10485464f, 0.02881047f, -0.32841337f, -0.20911692f, -0.11513577f, -0.11778778f, 
    -0.09743486f, -0.33465734f, 0.24722910f, 0.01396300f, 0.07093356f, -0.03299440f, 0.28476009f, 0.13415936f, 
    0.13898088f, 0.53153968f, 0.11757853f, -0.15029211f, 0.01435248f, 0.04782546f, -0.05634717f, -0.06447617f, 
    -0.11878888f, -0.21936330f, -0.24570933f, -0.05086261f, -0.11947279f, -0.10357407f, -0.08760592f, -0.50040799f, 
    0.11808670f, -0.22402689f, 0.08231330f, -0.32466239f, 0.25052330f, -0.04123082f, 0.05818785f, -0.25657985f, 
    0.16017833f, -0.07403632f, 0.38120079f, -0.34834221f, -0.18693706f, 0.04357693f, -0.18178438f, -0.10303188f, 
    -0.15701799f, 0.08474132f, -0.06636461f, -0.12694371f, -0.40157449f, 0.08744687f, 0.00256889f, 0.23692574f, 
    -0.25657380f, -0.06745258f, 0.23255229f, -0.05806768f, 0.13587235f, 0.14738417f, 0.04208241f, 0.12327696f, 
    -0.03471449f, -0.17547871f, -0.01875396f, 0.02840862f, -0.01987362f, -0.03125943f, 0.24568388f, 0.47259083f, 
    0.55276561f, 0.12755923f, -0.04425757f, 0.06365838f, -0.16694254f, -0.06996984f, 0.00183688f, -0.23835742f, 
    -0.33882904f, -0.40813294f, -0.20937884f, -0.25806937f, 0.12440139f, -0.31140926f, -0.21656391f, 0.01731864f, 
    0.23869389f, 0.14492683f, -0.17407511f, -0.01138774f, -0.03622718f, 0.21696962f, 0.12977152f, -0.11818666f, 
    -0.09179132f, -0.04738882f, 0.28839439f, -0.23309524f, -0.10971587f, 0.31796637f, -0.21986766f, -0.20906322f, 
    0.00964556f, 0.34377110f, -0.70994794f, 0.08334884f, -0.13794000f, -0.18343210f, -0.13253598f, 0.00957997f, 
    -0.09722921f, 0.14067292f, 0.01964679f, 0.72686476f, 0.40300947f, 0.42885193f, 0.08727803f, 0.18760440f, 
    0.13859461f, 0.15875958f, 0.13535558f, 0.08223958f, 0.16024324f, -0.36306688f, 0.08015301f, 0.02780381f, 
    0.11451977f, -0.09319298f, -0.08978359f, 0.00529116f, -0.00363506f, -0.31500420f, -0.15533412f, -0.21676040f, 
    -0.10739714f, -0.04957319f, 0.08598913f, -0.13539249f, 0.01666291f, -0.27862206f, 0.59983873f, 0.34384412f, 
    0.49110064f, 0.54695261f, -0.02044019f, 0.01139442f, 0.31167480f, 0.07312433f, 0.20639724f, -0.01155726f, 
    -0.12916356f, 0.14365315f, 0.22440326f, -0.10035139f, -0.01725133f, 0.12574111f, -0.10155655f, 0.08644018f, 
    -0.05386087f, 0.01233412f, -0.03824054f, 0.01898169f, -0.01740729f, 0.00971863f, -0.07821574f, 0.00618051f, 
    0.05637092f, 0.01128925f, -0.06802303f, 0.04166681f, 0.01411987f, -0.07436620f, -0.06816288f, -0.06887452f, 
    0.02439588f, 0.04364940f, 0.05699270f, -0.03718928f, -0.07443793f, -0.04092507f, -0.00242224f, -0.04997468f, 
    -0.06201564f, -0.03718578f, 0.00829069f, -0.02010468f, 0.00250735f, -0.01704588f, 0.02300838f, 0.00967503f, 
    0.03027660f, -0.02902835f, 0.03461877f, 0.02690149f, -0.02732071f, -0.02332482f, -0.05958097f, -0.06214606f, 
    0.02839833f, 0.03954622f, -0.05056265f, -0.03332165f, -0.08109819f, -0.08396721f, -0.01122516f, 0.01504641f, 
    0.06037597f, -0.04794943f, 0.02381063f, -0.07149521f, 0.02345598f, -0.06514423f, -0.08457669f, 0.04618275f, 
    -0.03458647f, -0.06770337f, 0.03038790f, -0.09256884f, -0.00311597f, -0.00072681f, -0.08983407f, 0.03735730f, 
    -0.03063511f, -0.01451314f, 0.01019401f, 0.07399287f, 0.06496704f, 0.00179732f, 0.07378802f, -0.00996923f, 
    -0.02904716f, 0.07103280f, -0.00272241f, 0.06639541f, -0.08222036f, 0.06426319f, -0.00015732f, -0.07706940f, 
    -0.07619308f, -0.04230392f, 0.03492595f, -0.03068514f, 0.01891135f, -0.08849423f, -0.05248234f, 0.06805092f, 
    -0.00331717f, 0.01515394f, 0.00226862f, 0.03085687f, 0.04370378f, -0.07147235f, -0.03991507f, -0.02694875f, 
    -0.04313264f, -0.08000883f, 0.04854846f, -0.01815001f, -0.06825858f, 0.00988434f, 0.05833335f, 0.03971514f, 
    -0.08410608f, -0.07255536f, 0.02321061f, -0.02694058f, -0.07595158f, -0.04440326f, 0.01400858f, 0.04605680f, 
    -0.01736449f, -0.05778795f, 0.02791356f, 0.06252692f, -0.02980112f, 0.01085713f, -0.08694039f, -0.00591455f, 
    -0.02340473f, -0.06438933f, -0.03565301f, 0.06802699f, 0.06294549f, -0.05016192f, -0.04245009f, 0.00225470f, 
    -0.01823242f, -0.06224756f, 0.04110692f, 0.00113695f, -0.03941858f, 0.00707834f, 0.06317332f, 0.06047203f, 
    0.03794295f, -0.03430385f, -0.04783001f, -0.00029912f, -0.07017413f, -0.07109154f, 0.03422367f, 0.07475294f, 
    -0.02029053f, -0.45767325f, -0.00440732f, -0.13270073f, 0.15406869f, -0.10940941f, 0.01619548f, -0.05189294f, 
    -0.07474115f, -0.01893943f, 0.08398043f, -0.01334110f, 0.30900326f, 0.26196185f, 0.06797662f, -0.10294890f, 
    -0.11670679f, 0.00702771f, -0.72698200f, 0.17491972f, 0.07687560f, -0.00188936f, -0.06487394f, 0.09188494f, 
    -0.12322053f, -0.08286739f, 0.00396367f, -0.44406772f, -0.24558242f, 0.27310923f, 0.03557110f, 0.25087363f, 
    0.08873956f, 0.08268688f, 0.11826717f, -0.02783428f, 0.20570754f, 0.00264437f, 0.10853592f, -0.18571799f, 
    0.17860903f, -0.17697416f, -0.18863691f, 0.01913838f, 0.14384049f, -0.13741864f, 0.19069089f, -0.19723172f, 
    -0.35615888f, -0.16552727f, -0.07137050f, -0.09370431f, 0.06296987f, -0.07887567f, 0.25704446f, 0.13232829f, 
    -0.16897629f, 0.21204764f, -0.12086878f, 0.10303992f, -0.10803451f, -0.17841180f, -0.04929987f, 0.77738708f, 
    0.54944944f, 0.24827230f, 0.24076481f, 0.09511878f, -0.11306960f, -0.03806323f, 0.05500910f, -0.01090392f, 
    0.27221242f, 0.15443318f, 0.01209159f, -0.02088909f, 0.03580580f, -0.11533361f, -0.04375138f, 0.01073087f, 
    0.00009633f, 0.58045238f, -0.61327577f, -0.07782858f, -0.10308657f, 0.16515382f, 0.02043182f, 0.11460046f, 
    0.02046387f, 0.04350403f, -0.63051850f, -0.17014286f, -0.17185320f, 0.05437038f, 0.27291408f, 0.26388010f, 
    -0.14490028f, -0.17538059f, -0.16118512f, -0.03192263f, -0.02225692f, 0.04425099f, -0.54509932f, -0.12346464f, 
    -0.03938828f, 0.10070623f, 0.01593819f, 0.08265815f, 0.38666505f, 0.02065572f, -0.49750274f, -0.14133579f, 
    -0.17328288f, 0.00850792f, 0.10998831f, -0.05210096f, -0.11633768f, -0.31917840f, -0.23084034f, -0.32557407f, 
    -0.03959815f, 0.24754648f, 0.02852266f, 0.10822597f, -0.04583560f, 0.11870591f, 0.35901195f, 0.25966120f, 
    -0.11258840f, -0.32225353f, -0.04916797f, -0.00697122f, 0.10369937f, -0.00454620f, 0.09980355f, 0.49778116f, 
    -0.15483265f, 0.10221472f, 0.06297813f, 0.17856339f, -0.04885397f, -0.16670339f, -0.06176150f, 0.23531877f, 
    0.08133876f, -0.32143816f, 0.20114949f, 0.25804928f, -0.02950772f, 0.01349973f, 0.08493759f, 0.04480321f, 
    -0.01099317f, -0.45560539f, 0.22037329f, 0.29731724f, 0.01976465f, 0.18346490f, 0.28845629f, 0.23814878f, 
    -0.06319848f, -0.05352514f, -0.62771565f, -0.40591839f, -0.00315591f, 0.24171169f, 0.15793833f, 0.24388346f, 
    0.04812917f, -0.11705012f, -0.27769533f, -1.03032207f, -0.31446543f, -0.39874339f, 0.03791521f, 0.01348176f, 
    0.14806537f, -0.03065085f, 0.00737360f, -0.00605624f, -0.03947302f, 0.50008684f, 0.33449182f, 0.08667979f, 
    -0.06799279f, -0.21581264f, -0.19851272f, 0.32292214f, 0.09907791f, 0.17690930f, -0.35685587f, -0.36637905f, 
    -0.19271597f, -0.05517360f, -0.41201067f, 0.06236899f, 0.11143809f, 0.18881495f, -0.12572980f, 0.11606102f, 
    0.09038898f, -0.29950327f, -0.12212639f, -0.04319462f, 0.04691691f, 0.10216324f, 0.13100988f, 0.27720329f, 
    0.24274325f, 0.42256120f, 0.08901878f, -0.09973782f, -0.11146100f, -0.26862356f, -0.06688983f, 0.24635373f, 
    0.19400023f, -0.19469260f, 0.07117936f, 0.32663751f, 0.22415353f, 0.20913190f, -0.19554918f, 0.12642235f, 
    -0.22449780f, -0.00977769f, 0.05496454f, -0.71884590f, 0.23816557f, -0.11466242f, 0.29547274f, 0.10875228f, 
    0.15282705f, -0.20058763f, -0.94146651f, -0.31917575f, -0.05712600f, 0.46780506f, -0.01047286f, 0.14619730f, 
    0.24987602f, -0.08449964f, -0.29545289f, 0.17241898f, 0.07326470f, 0.33233827f, -0.11288867f, 0.15665817f, 
    0.13581106f, -0.17221102f, 0.01303747f, 0.04383261f, -0.21879214f, 0.07107656f, -0.23954187f, -0.00172492f, 
    0.09665243f, 0.24384077f, 0.05182280f, 0.18545990f, -0.05837379f, 0.43868664f, 0.02740539f, 0.15500300f, 
    0.05772867f, -0.12518470f, -0.23662113f, 0.06290127f, 0.12681837f, -0.24150713f, 0.35803512f, -0.23510179f, 
    0.23247235f, -0.31430978f, 0.02869775f, 0.07695281f, 0.18344863f, 0.08551753f, 0.11750807f, 0.03107296f, 
    0.02750291f, -0.10677017f, 0.08983128f, -0.08319002f, -0.26210964f, 0.23478137f, 0.42169747f, 0.08928865f, 
    -0.03574589f, -0.04825042f, -0.04823720f, 0.05217758f, -0.04877909f, -0.07066919f, -0.06317014f, 0.00719244f, 
    -0.08820070f, 0.05840901f, 0.07016494f, -0.06432787f, -0.02023085f, -0.02595085f, 0.00131505f, 0.02226845f, 
    0.00759688f, -0.07455200f, -0.09115801f, -0.00034326f, -0.01359093f, 0.01157604f, -0.06039289f, 0.01848170f, 
    0.04141059f, -0.04759574f, -0.02554500f, 0.02642522f, 0.02929330f, 0.05027245f, -0.06497862f, -0.08957420f, 
    -0.04697263f, -0.00927729f, -0.04646544f, -0.01542216f, -0.07565296f, -0.08988341f, 0.04365489f, 0.00050777f, 
    -0.01561095f, 0.05378618f, 0.03994780f, -0.02145401f, 0.02929717f, -0.06179086f, -0.07636473f, 0.00620449f, 
    0.01045047f, -0.08930204f, -0.07613773f, -0.02308986f, -0.01015424f, -0.02434464f, -0.01138159f, -0.05628178f, 
    0.01312837f, -0.03633517f, -0.07952113f, -0.06218148f, -0.00647919f, -0.03552743f, 0.01108947f, 0.05776008f, 
    -0.05648057f, 0.04400374f, 0.06400652f, -0.03659121f, -0.09368163f, -0.07975542f, -0.09073083f, -0.03522151f, 
    -0.07471787f, -0.02199277f, 0.01333983f, 0.03560936f, -0.05282125f, 0.06038742f, -0.02291783f, -0.02192679f, 
    -0.09084263f, -0.04550985f, -0.07627817f, -0.03844026f, -0.06991940f, -0.00017259f, -0.01396863f, 0.01381057f, 
    0.04325078f, -0.01899298f, -0.06920320f, -0.08889110f, 0.03054754f, -0.00914786f, -0.00172194f, -0.06037927f, 
    0.06708181f, -0.01436465f, 0.00581111f, -0.01282445f, 0.01758665f, 0.04618092f, -0.00293202f, -0.08376863f, 
    -0.09494033f, -0.05789368f, 0.03327668f, -0.07961435f, -0.04424666f, -0.05843474f, -0.04776852f, -0.03436149f, 
    -0.03691258f, -0.07792874f, 0.03518347f, -0.00767864f, 0.03620692f, -0.05011591f, 0.02649987f, -0.08409416f, 
    0.04152324f, 0.02833629f, -0.07357556f, 0.00998689f, 0.05553742f, -0.06017276f, -0.06687408f, -0.04904548f, 
    0.07075423f, 0.00676002f, -0.05823131f, -0.02983449f, -0.05652221f, -0.04000641f, 0.01108395f, -0.01811501f, 
    -0.06708263f, -0.02001221f, -0.04502014f, 0.04170413f, 0.03852700f, -0.05709090f, -0.05256196f, 0.02383181f, 
    0.02742557f, 0.19767387f, 0.52182096f, 0.00372021f, -0.27140558f, -0.17703183f, 0.20022641f, -0.10814478f, 
    0.19792134f, 0.50308686f, -0.15957290f, -0.17142607f, -0.11166381f, -0.50167203f, 0.28104693f, 0.09667441f, 
    0.26286730f, 0.09803201f, -0.74734586f, 0.25014529f, 0.21554811f, 0.05820986f, 0.13795900f, 0.46285149f, 
    0.38320571f, -0.27295586f, -0.12065320f, -0.00354154f, -0.11251138f, 0.13916326f, -0.05479316f, -0.04893577f, 
    -0.05571624f, -0.01498705f, -0.14877184f, 0.06067789f, 0.26486611f, 0.10534214f, -0.00599090f, -0.04912662f, 
    0.25374657f, -0.02031903f, -0.22073489f, -0.31924400f, -0.02473037f, 0.33727583f, -0.18259773f, 0.12179247f, 
    -0.07225181f, -0.04728794f, -0.09707195f, -0.15590242f, -0.22725762f, -0.45076361f, 0.26205152f, 0.20249581f, 
    0.12940821f, -0.04560777f, -0.22348569f, -0.01825451f, -0.22566204f, 0.00733747f, 0.14229617f, -0.20738889f, 
    0.10716656f, 0.38566759f, -0.08616839f, -0.12436553f, -0.57747990f, -0.08228031f, 0.10013734f, -0.20500492f, 
    0.03875260f, -0.30457169f, -0.17175181f, 0.14840852f, 0.17316240f, 0.04171881f, -0.16382907f, -0.27915964f, 
    -0.20491527f, 0.54745007f, 0.07337298f, 0.00978783f, 0.10542510f, 0.00223617f, 0.29285213f, 0.17690514f, 
    0.09773453f, -0.24722944f, 0.25995591f, 0.23711228f, 0.44801575f, -0.10395987f, -0.08918361f, 0.09298707f, 
    0.04516258f, -0.02634705f, 0.06647839f, 0.09678047f, -0.17122726f, 0.10453004f, 0.21472287f, 0.27540150f, 
    0.27010396f, -0.17702448f, 0.04789891f, 0.24833170f, 0.33608100f, 0.14994931f, -0.02371832f, 0.08545925f, 
    -0.06833192f, 0.13808480f, -0.05018141f, 0.15768291f, 0.00757791f, 0.06406978f, 0.33767375f, -0.12454410f, 
    -0.22105581f, -0.16655223f, -0.26876712f, 0.01733622f, 0.03936272f, -0.01009855f, 0.11704411f, -0.04479245f, 
    0.06626777f, 0.00631653f, 0.46293265f, 0.00013308f, 0.07801102f, 0.25877446f, 0.29846111f, 0.07468983f, 
    -0.29983059f, 0.01708055f, 0.04191419f, -0.07258675f, -0.08500635f, -0.01182359f, -0.12815641f, 0.03697471f, 
    -0.14626387f, 0.05129884f, 0.39981383f, 0.22626534f, 0.03928552f, 0.16415267f, 0.19243129f, 0.01392171f, 
    -0.03049450f, 0.13960654f, -0.53908825f, -0.10429411f, -0.04547545f, 0.02279037f, -0.00750350f, 0.02561116f, 
    0.20975100f, 0.21885037f, 0.21582499f, 0.07317480f, -0.28154802f, -0.24579731f, -0.23797722f, -0.29650375f, 
    0.12327613f, 0.24146174f, -0.01112587f, -0.04848244f, -0.23942165f, 0.30339757f, -0.35451823f, -0.02761296f, 
    -0.01954448f, 0.11781207f, 0.11959334f, 0.27776727f, 0.24675962f, -0.18882540f, -0.58757871f, -0.01809187f, 
    0.29500991f, 0.29391932f, -0.01080349f, -0.03979312f, -0.10129159f, -0.70046335f, 0.27183136f, -0.29425737f, 
    0.24721602f, -0.06693702f, -0.10520297f, -0.33257943f, -0.15568262f, -0.17561203f, -0.27274168f, -0.30243859f, 
    -0.04348365f, 0.06254469f, 0.17425673f, 0.08278517f, -0.04268461f, -0.37582818f, -0.22165321f, -0.14218849f, 
    -0.28313980f, 0.19960989f, -0.40456793f, -0.08142448f, -0.03936029f, -0.21367738f, 0.06390632f, 0.19379935f, 
    0.52080375f, 0.72093773f, -0.19646402f, 0.01837816f, 0.06824604f, -0.34239462f, -0.27474508f, 0.07895309f, 
    -0.22331704f, 0.07967740f, 0.00347197f, 0.29801983f, -0.30006689f, 0.20563081f, -0.12657459f, -0.21700813f, 
    0.16882828f, 0.21797229f, 0.12423178f, 0.30658084f, 0.28814623f, -0.12107248f, -0.30844274f, -0.07554055f, 
    0.11759102f, -0.03110819f, -0.06086146f, -0.06645934f, 0.36530477f, -0.27517447f, 0.31576285f, 0.25902107f, 
    0.40256450f, 0.40475571f, -0.08644044f, -0.07102448f, 0.41288140f, 0.19251440f, -0.12195130f, 0.08063992f, 
    -0.10658753f, -0.16963293f, 0.09637477f, -0.25577047f, 0.17529848f, -0.25494465f, -0.13522778f, -0.08756601f, 
    0.14224550f, 0.22245006f, -0.05281099f, 0.09490658f, -0.09867534f, -0.16916586f, -0.13678885f, 0.12806095f, 
    -0.25861764f, 0.17776844f, -0.17554027f, 0.23602010f, 0.05246808f, 0.00722905f, 0.17577101f, -0.45377189f, 
    0.09935073f, -0.23588967f, -0.10328022f, 0.22681971f, 0.00516971f, 0.12763478f, 0.09069868f, 0.08881758f, 
    0.04627862f, 0.36640981f, -0.30197853f, -0.05955744f, -0.04262233f, 0.10083614f, 0.02003759f, -0.03376669f, 
    -0.15387350f, -0.23757721f, -0.21861771f, -0.04531500f, 0.08068316f, 0.00979473f, 0.08172502f, 0.14301987f, 
    0.00437545f, -0.08058286f, 0.27881098f, 0.15671079f, -0.02267769f, 0.09546766f, -0.13359012f, 0.15840600f, 
    0.02049472f, 0.13302211f, -0.07030508f, 0.23034178f, -0.47327733f, 0.19032989f, -0.27560174f, -0.00385715f, 
    0.23856881f, 0.16454150f, -0.02507715f, -0.04256474f, -0.31253120f, -0.37624931f, -0.05883274f, 0.09124472f, 
    0.10656410f, -0.17160402f, 0.10406992f, 0.08247044f, -0.27250907f, -0.04901230f, 0.15576871f, -0.13351095f, 
    0.19187465f, -0.01128157f, 0.23988119f, 0.15565501f, 0.16270730f, -0.19320495f, 0.06889381f, -0.36541703f, 
    -0.18054037f, -0.29155132f, -0.11424235f, 0.37819833f, 0.17893404f, 0.04220386f, -0.25170660f, 0.16548501f, 
    0.24145071f, -0.05932336f, -0.02630978f, 0.06901170f, 0.52006972f, -0.22877750f, -0.39301953f, 0.18990336f, 
    0.15508872f, 0.53066528f, 0.06213629f, -0.01791759f, 0.14395826f, -0.23052347f, 0.03230590f, -0.19420873f, 
    0.04119277f, -0.65023756f, 0.03970087f, -0.24312003f, -0.11364190f, 0.06842527f, -0.10103350f, -0.09401124f, 
    0.02908214f, 0.20745163f, 0.58151585f, -0.00898941f, 0.42952228f, 0.07212549f, -0.12450033f, 0.10116486f, 
    0.10451202f, 0.08904683f, -0.00199126f, -0.02996346f, 0.20161140f, -0.48898858f, 0.07739709f, 0.11265623f, 
    -0.10326979f, 0.14172216f, -0.05295854f, -0.08638147f, -0.70990837f, -0.10015415f, -0.48554906f, 0.18456879f, 
    0.08410702f, -0.25692311f, 0.01767754f, 0.00878977f, 0.10052777f, -0.05230954f, -0.15347505f, -0.19111468f, 
    -0.00574142f, 0.15341885f, 0.11553033f, -0.11476262f, -0.15458766f, -0.16218962f, 0.20136474f, -0.37107578f, 
    -0.32386240f, 0.25174558f, -0.09531234f, -0.14562163f, 0.09724442f, 0.09230427f, -0.22850752f, 0.07531534f, 
    0.25385383f, -0.32891628f, 0.10709948f, 0.01170802f, 0.36389232f, 0.04396595f, 0.12752259f, -0.09447514f, 
    0.53815711f, -0.06391016f, -0.15160277f, 0.01909529f, 0.00398507f, -0.19673376f, 0.19245152f, -0.01047141f, 
    0.02563359f, -0.33722663f, -0.24144378f, -0.38493967f, -0.05943055f, 0.00130222f, 0.45689037f, -0.07949184f, 
    0.06062198f, -0.13763668f, -0.09310555f, -0.26041383f, -0.27182183f, 0.18713520f, -0.09647952f, 0.24270737f, 
    0.17763916f, -0.11327722f, 0.33107358f, 0.06190952f, 0.17713374f, 0.23355187f, 0.08958280f, 0.21118082f, 
    0.19225790f, 0.08763858f, 0.22146159f, -0.02411907f, 0.12874679f, 0.36914825f, 0.07800376f, 0.13811834f, 
    -0.05715996f, 0.16914706f, 0.05534384f, 0.02857803f, 0.02314056f, 0.17369892f, 0.28466779f, -0.44618124f, 
    -0.09987785f, -0.09429442f, 0.09581549f, -0.07641155f, 0.13028078f, -0.21853970f, 0.07884005f, -0.15344745f, 
    -0.26516065f, -0.46222052f, 0.06315760f, -0.03960405f, -0.07072263f, -0.14099263f, 0.03592017f, 0.00319057f, 
    0.26593661f, -0.37247628f, -0.08646285f, 0.33735433f, 0.20524855f, -0.04332732f, 0.01113606f, -0.08762927f, 
    -0.04391939f, 0.20134510f, 0.21264458f, 0.07349427f, -0.22938116f, 0.06239104f, 0.18751244f, 0.04279756f, 
    0.18602692f, 0.36014709f, -0.09196250f, -0.49053875f, -0.02824938f, 0.00211744f, -0.02119934f, -0.07669138f, 
    0.21701141f, -0.04740511f, 0.32613850f, 0.02506732f, -0.09919122f, 0.06271891f, 0.08501868f, 0.21521187f, 
    0.10613972f, 0.11519179f, 0.13754997f, -0.16304447f, 0.38699707f, 0.45047528f, -0.01595687f, 0.09749767f, 
    0.07094152f, -0.01702283f, -0.14248541f, -0.40502664f, 0.45399514f, 0.18374528f, -0.21604250f, -0.18847686f, 
    -0.15842344f, 0.07573559f, -0.24943268f, 0.12913208f, 0.15148617f, -0.24944910f, -0.36508080f, -0.03004307f, 
    0.14626060f, -0.10173768f, -0.45482069f, -0.18525419f, 0.11635210f, -0.27490976f, 0.30792928f, 0.08885736f, 
    0.36553591f, -0.01730000f, -0.37914017f, -0.13895486f, -0.14729469f, -0.01330759f, 0.00037367f, 0.59077799f, 
    -0.00156443f, -0.35460973f, 0.01491156f, 0.25044048f, 0.01119326f, -0.05324171f, 0.15759321f, -0.07495613f, 
    -0.23182051f, 0.14309645f, 0.30629081f, 0.26363581f, -0.23422523f, 0.10797627f, 0.13197975f, -0.03499982f, 
    0.16169895f, -0.69262004f, -0.10003880f, -0.42354244f, 0.10956486f, 0.02733839f, 0.13918920f, 0.11781170f, 
    -0.38338345f, -0.07494216f, 0.01044961f, 0.20637628f, 0.35270146f, 0.35273254f, 0.13230036f, -0.16081853f, 
    0.16149515f, 0.08826785f, -0.01433800f, 0.19842702f, 0.06282035f, 0.11840548f, 0.14311911f, 0.03002810f, 
    -0.08986246f, -0.05184527f, 0.07265837f, 0.14547524f, 0.09151255f, 0.27882883f, -0.30049700f, -0.19596367f, 
    -0.35777113f, -0.26976460f, 0.29129615f, 0.06178908f, 0.37822247f, 0.02769891f, -0.15601717f, 0.36565503f, 
    -0.11242808f, -0.19162734f, 0.14235502f, -0.03424479f, -0.07271362f, 0.13321531f, -0.30198276f, -0.57248950f, 
    -0.16798678f, 0.03815543f, 0.31467670f, 0.10649239f, -0.00044799f, -0.11483319f, -0.06576001f, 0.23282379f, 
    -0.56176895f, -0.39691979f, 0.21391630f, 0.07098988f, -0.08685446f, 0.20154481f, -0.19269982f, 0.02425138f, 
    0.78040951f, -0.11950989f, 0.27793717f, -0.19796923f, -0.01227591f, 0.20625441f, -0.01257923f, 0.21061422f, 
    0.12003170f, -0.35099542f, -0.30931947f, -0.27348620f, -0.10129408f, 0.04214738f, 0.22314678f, 0.18133777f, 
    -0.18321864f, -0.01675367f, -0.26137260f, -0.00368010f, -0.05382628f, 0.26888990f, 0.07542644f, -0.11128400f, 
    -0.09999478f, 0.01173210f, 0.24158449f, 0.14504820f, -0.26129636f, 0.31659308f, -0.14888099f, -0.05763335f, 
    -0.09228512f, 0.11239232f, 0.18974811f, -0.18740863f, 0.07401477f, 0.07829487f, 0.08640736f, 0.05203704f, 
    -0.04012599f, -0.24982430f, 0.00460858f, 0.11144684f, 0.01559550f, -0.69765979f, -0.23295330f, -1.06110764f, 
    0.42767468f, 0.12175625f, 0.15089203f, -0.14107427f, 0.19867796f, 0.00750170f, -0.15634352f, 0.24292766f, 
    0.25838172f, -0.04366986f, 0.16247998f, -0.22739036f, 0.16254734f, 0.06339893f, 0.00124276f, -0.49974713f, 
    -0.01960412f, 0.37085107f, 0.19062221f, -0.11250199f, -0.00016865f, -0.18282415f, -0.01071030f, 0.20710452f, 
    0.10901707f, 0.06603730f, 0.16228209f, -0.03047552f, 0.03048512f, -0.26368025f, 0.14514013f, -0.04015334f, 
    0.04042557f, -0.20226184f, -0.00169011f, -0.14136899f, -0.23354425f, 0.06040112f, -0.03954395f, 0.09552720f, 
    -0.12498467f, 0.02713027f, 0.03625938f, -0.52508372f, -0.41497961f, 0.33622098f, 0.17951313f, 0.06470802f, 
    0.12839578f, 0.04436592f, -0.20278461f, 0.63188559f, -0.38154417f, -0.13670233f, 0.09006985f, 0.00758034f, 
    0.06204655f, 0.05396004f, 0.27889791f, -0.03737254f, 0.12995358f, -0.32938263f, -0.00080867f, 0.02189545f, 
    0.17060685f, 0.04207259f, -0.05738419f, 0.09028967f, -0.08623318f, 0.03810165f, 0.04574828f, -0.03926841f, 
    -0.05665686f, -0.03397437f, 0.41994315f, 0.03145671f, -0.05904789f, -0.13083531f, -0.34035113f, -0.15582900f, 
    0.23209250f, 0.09489449f, -0.29291013f, -0.03288538f, -0.21317379f, 0.17749007f, 0.12742566f, 0.55045259f, 
    0.00412044f, -0.59257478f, 0.35633883f, -0.10681375f, -0.24303165f, 0.28242370f, 0.03992788f, 0.12262394f, 
    -0.20048708f, 0.00412100f, 0.22659440f, -0.05262684f, 0.18948315f, 0.05323045f, -0.13325372f, 0.05168280f, 
    0.01221298f, 0.23600958f, 0.02911052f, -0.12701266f, -0.05929519f, -0.06683607f, -0.04735344f, 0.12883787f, 
    -0.01365818f, 0.02520729f, 0.62281251f, 0.00378032f, -0.18524869f, 0.01370792f, -0.11659827f, -0.02816783f, 
    0.07843269f, -0.07781181f, -0.11083609f, 0.13975492f, -0.13682903f, 0.27871558f, -0.09646711f, 0.06411173f, 
    0.11401457f, -0.27329096f, 0.00111934f, 0.29180202f, -0.54430407f, 0.25940409f, 0.22447288f, -0.04642979f, 
    0.12733290f, 0.06094863f, -0.40583292f, -0.04414504f, 0.15157466f, -0.17429237f, -0.15808146f, -0.26317227f, 
    0.01226558f, 0.05695549f, -0.16828786f, 0.16137025f, -0.12486283f, -0.21054900f, -0.46992335f, 0.12098274f, 
    0.27928296f, -0.23816398f, 0.04768775f, 0.01560391f, -0.16962770f, 0.13417622f, 0.14221901f, -0.45430696f, 
    0.24278335f, -0.07946391f, 0.21206653f, -0.02204425f, 0.03110559f, 0.16782118f, 0.03472403f, 0.01375238f, 
    0.07326708f, 0.26599956f, -0.20078531f, 0.17186664f, -0.02891007f, 0.12012035f, 0.09842602f, 0.07783604f, 
    -0.14896983f, 0.10927909f, 0.46977296f, -0.15178524f, -0.05739170f, -0.14225279f, -0.09777277f, 0.01705405f, 
    -0.31019041f, -0.31398842f, -0.15569708f, -0.07623783f, 0.50944489f, -0.11502980f, -0.02158453f, 0.06242690f, 
    0.10828432f, 0.13816418f, 0.09405132f, -0.63225389f, -0.68585241f, -0.01493643f, -0.09887613f, 0.17953248f, 
    0.12137070f, 0.06044482f, 0.13991499f, -0.07844889f, 0.82868063f, 0.04135843f, -0.29909983f, -0.04709506f, 
    -0.10200202f, 0.05938314f, 0.12327710f, 0.40703192f, 0.22269396f, -0.24092835f, 0.33682457f, -0.13008229f, 
    -0.14970024f, -0.05196860f, -0.14956605f, 0.08264842f, 0.11304802f, 0.10922916f, -0.63168013f, 0.05971692f, 
    0.19286938f, -0.09513401f, -0.01586099f, 0.02386478f, -0.01799255f, -0.18584454f, -0.06428908f, 0.20305362f, 
    -0.40138057f, 0.30019417f, 0.22694427f, 0.17669354f, 0.14742047f, -0.00020123f, 0.08479878f, 0.13671213f, 
    0.26400322f, 0.52932549f, 0.00940561f, -0.09328365f, 0.30339742f, -0.06087076f, 0.08052257f, 0.24735849f, 
    0.16416822f, 0.16135660f, -0.00878140f, -0.00988856f, -0.05649914f, -0.09092631f, -0.03134803f, -0.33272868f, 
    0.32513708f, 0.18100908f, -0.73104012f, -0.58899152f, 0.17517614f, 0.34066895f, 0.31349820f, -0.05774977f, 
    0.17337444f, 0.05377809f, 0.00888563f, 0.15972927f, 0.21119921f, -0.07273056f, -0.24364041f, 0.14112762f, 
    -0.03690884f, -0.13617061f, 0.12447143f, -0.14449291f, -0.18131514f, 0.02122064f, -0.09554411f, -0.01999522f, 
    -0.14172296f, 0.00469995f, 0.02741802f, -0.13846982f, 0.00321573f, 0.30925331f, -0.40901756f, -0.11136359f, 
    0.01553387f, -0.13872115f, -0.10221802f, -0.22900598f, -0.12441701f, 0.07398918f, 0.23903024f, 0.24905211f, 
    0.16504234f, -0.20858359f, 0.13802950f, -0.07689868f, -0.19472764f, -0.03047748f, -0.22986807f, 0.03712897f, 
    0.37521812f, 0.13923018f, -0.17247987f, -0.18356735f, -0.08238990f, 0.14134833f, 0.09966888f, 0.15800260f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.32409707f, -0.09604106f, 0.03071901f, 0.32193890f, -0.18591201f, -0.08792534f, -0.04632233f, 0.27331734f, 
    -0.04461899f, -0.21025701f, 0.19274309f, 0.34088436f, 0.17023578f, 0.21487077f, 0.04312657f, 0.14075449f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.23928683f, 0.91574574f, -0.22570190f, -0.25002629f, 0.01429602f, -0.04711541f, -0.51768053f, -0.08066101f, 
    0.02961102f, 0.12534347f, 0.73157042f, -0.31330916f, -0.06701089f, -0.28517836f, -0.38866374f, -0.20370960f, 
    0.34656000f, 0.01742267f, 0.11510845f, -0.35892767f, 0.43626851f, 0.04264954f, -0.12464225f, -0.42861950f, 
    -0.05961862f, -0.03772050f, 0.47642240f, 0.69908625f, -0.16651490f, 0.35950416f, -0.57224178f, -0.26140875f, 
    -0.56528097f, -0.14293535f, 0.04419453f, -0.08183535f, -0.98008543f, -0.14769393f, 0.92295045f, -0.41151333f, 
    0.06157563f, -0.23107789f, -0.30489126f, -0.51211482f, 0.89920986f, 0.12610891f, -0.11575212f, -0.57911950f, 
    -0.15866719f, -0.11614916f, -0.02072744f, -0.44531113f, -0.39180043f, 0.19468477f, 0.42672238f, 0.51831120f, 
    -0.14028880f, 0.24887612f, -0.82875532f, -0.54935408f, -0.61566353f, -0.32945034f, -0.05817561f, 0.72342461f, 
    -0.46793118f, -0.92211568f, -0.02351666f, 0.60077626f, -0.51519501f, -0.11951989f, -0.57669044f, 0.13463323f, 
    -0.20658104f, 0.33161455f, 0.11668409f, -0.61173147f, 0.24241585f, -0.02278583f, 0.03095394f, -0.22831824f, 
    0.07510965f, 0.47977081f, -0.01954996f, 0.26070872f, 0.24731179f, 0.00718269f, -0.68004155f, -0.18294589f, 
    -0.23164633f, -0.11602728f, 0.07209042f, 0.36252344f, 0.15398510f, -0.33746633f, -0.45971677f, -0.34027576f, 
    0.19596779f, 0.13651030f, -0.21403392f, 0.65037251f, -0.77239448f, -0.24841672f, -0.04725498f, -0.22584178f, 
    -0.00779701f, 0.46102804f, -0.54277068f, 0.45362726f, -0.58641595f, -0.78272092f, 0.04923584f, -0.10943146f, 
    -0.26550004f, -0.01874048f, 0.17958367f, -0.36419728f, 0.67581600f, -0.18634503f, -0.47104704f, 0.29626223f, 
    -0.01408667f, 0.16549219f, -0.23153546f, -0.57292831f, 0.13709414f, -0.13655216f, -0.53839195f, -0.14317736f, 
    -0.22414319f, -0.15499201f, -0.03802509f, -0.22710532f, 0.15101580f, -0.15728724f, -0.12513791f, -0.89088660f, 
    -0.02408429f, -0.77641141f, 0.45090544f, 0.15477407f, -0.16933368f, 0.97427106f, 0.07358074f, 0.48587349f, 
    1.05824041f, -0.52514452f, -0.08443566f, 0.33890846f, 0.11134026f, -0.19287077f, -0.34822756f, 0.00544953f, 
    -0.09423782f, 0.16491476f, -0.27212805f, -0.62161911f, -0.05172761f, -0.04705539f, 0.31319851f, -0.77724773f, 
    -0.11895823f, -0.05899158f, 0.15959883f, -0.55987465f, 0.20543361f, 0.14849000f, 0.52251154f, 0.61253476f, 
    -0.02530271f, -0.81328893f, -0.68329436f, 0.02517386f, 0.06686306f, 0.37973005f, -0.22344746f, 0.23273075f, 
    -0.74305594f, -0.42082354f, 0.11721745f, -0.27807629f, -0.79848588f, 0.22076271f, -0.04589176f, 0.08584710f, 
    0.20307752f, 0.08305699f, -0.25573739f, 0.43898153f, 0.31342444f, -0.27103201f, 0.91244793f, -0.00170564f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14570215f, 0.15803057f, -0.30443665f, -0.03274621f, 0.25826868f, 0.13872819f, 0.00080464f, -1.01982105f, 
    -0.51213264f, 0.13065268f, 0.71818060f, -0.17049418f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
