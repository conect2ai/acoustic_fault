#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.32264256f, -0.54382956f, -0.61933595f, -0.94790411f, -0.69372702f, 0.63970250f, 0.44758359f, -0.05790851f, 
    -0.00377522f, 0.43447962f, 0.08017085f, 0.19774677f, -0.09138980f, -0.03071695f, -0.35381556f, -0.17892061f, 
    -0.21602395f, -0.26408720f, -0.24380299f, -0.30802968f, -0.36304376f, -0.07221112f, -0.29495284f, -0.13015069f, 
    -0.26619327f, 0.45444679f, -0.35963678f, -0.31436953f, -0.33999830f, -0.10131686f, -0.30112192f, 0.38433921f, 
    0.24032347f, -0.44795233f, -0.20614621f, 0.28181705f, 0.11886811f, 0.26222834f, 0.10742781f, -0.06798223f, 
    0.28116664f, -0.15267903f, 0.07506299f, 0.20060927f, -0.02655606f, 0.46395978f, 0.26544785f, -0.15971327f, 
    0.23901443f, -0.24754676f, -0.96186596f, -0.16625927f, 0.35895014f, -0.72711086f, -0.46431470f, 0.78737861f, 
    -0.15027015f, 0.10505826f, 0.84884745f, 0.73795033f, 0.10516148f, -0.18679142f, -0.11287523f, 0.09129386f, 
    -0.26277158f, -0.12925348f, -0.22364952f, 0.18933317f, -0.14924152f, -0.16182329f, -0.11341537f, 0.15699947f, 
    0.27380264f, 0.07302799f, -0.05842075f, -1.06596303f, -0.95757782f, -0.50208813f, 0.31628925f, 0.48585317f, 
    0.19935605f, 0.38175631f, 0.40962085f, 0.09556690f, 0.01925608f, 0.38025153f, -0.17298850f, -0.11296949f, 
    -0.22005206f, 0.24400629f, 0.14030325f, -0.35079595f, 0.06445714f, -0.06481794f, -0.22092865f, -0.24191947f, 
    -0.41118902f, 0.01827136f, -0.15701722f, -0.19900973f, -1.40114462f, -0.55821067f, 0.03777133f, -0.25512704f, 
    -0.07101052f, 0.35800171f, 0.05881169f, -0.18041511f, 0.50325149f, 0.47453564f, -0.45439681f, -0.52323878f, 
    -0.57246798f, -0.41851321f, -0.13963695f, 0.24470314f, 0.40557945f, -0.23155104f, -0.00514575f, -0.15214981f, 
    0.04955712f, -0.05622692f, -0.06775473f, -0.30315271f, -0.27874005f, -0.33911368f, 0.74975038f, -0.16529523f, 
    -1.16425502f, -0.70214802f, -0.05746286f, 0.31162834f, -0.08015434f, 0.04239124f, 0.14452834f, 0.40792793f, 
    0.33145350f, 0.13187113f, -0.21440947f, -0.12951581f, 0.31132412f, 0.33501631f, -0.00331980f, 0.04373497f, 
    -0.24735540f, 0.30577579f, -0.12962106f, -0.18139699f, -0.25669104f, -0.17448102f, 0.69772583f, 1.27918899f, 
    0.11230517f, -0.50286043f, 0.14007699f, -0.55191529f, -0.38115638f, 0.51857167f, -0.41726956f, -0.68506175f, 
    -0.39820638f, -0.19172975f, 0.02125039f, 0.04230655f, -0.19464728f, 0.17757861f, 0.20290200f, 0.12542027f, 
    -0.13225108f, 0.00557909f, -0.00510112f, -0.12256196f, -0.23005834f, 0.18538454f, -0.11999504f, 0.30821088f, 
    -0.49747720f, -0.29430422f, 0.45285636f, -0.31411150f, -0.17827354f, -0.00244300f, -0.19294958f, 0.28579208f, 
    -0.07770309f, 0.18603157f, -0.14870250f, 0.70527577f, -0.48627594f, -0.04198493f, 0.02510184f, -0.03626541f, 
    -0.14011358f, -0.12142658f, -0.46265829f, 0.25386369f, 0.13819292f, 0.00093397f, 0.15090464f, 0.72835767f, 
    -0.21908347f, -0.63063562f, 0.03990043f, 0.73535019f, -0.11709677f, 0.01806122f, -0.94490260f, -0.83725435f, 
    -0.72378606f, -0.23571949f, 0.71064037f, -0.21384655f, 0.23555470f, 0.24877319f, 0.46947831f, -0.44228262f, 
    -0.07358168f, -0.09305950f, -0.03521550f, -0.02611360f, 0.06375992f, 0.06656337f, -0.00395169f, -0.28482610f, 
    0.17119652f, -0.12880109f, 0.15298116f, 0.12076810f, 0.28042644f, 0.03626209f, -0.17470323f, -0.21140338f, 
    -0.25354713f, -0.04452084f, 0.48846394f, 0.44678441f, -0.42845520f, -0.05165341f, 0.00174098f, 0.16952293f, 
    -0.08541318f, 0.09308431f, -0.42688596f, -0.06131913f, 0.14770831f, 0.25044298f, -0.20220497f, -0.21275185f, 
    0.24834345f, -0.40964764f, -0.27874440f, -0.40405768f, -0.49427095f, -0.22548909f, -0.48152846f, -0.26387921f, 
    0.10571682f, -0.37116116f, -0.22123261f, 0.73755091f, -0.38788036f, -0.02976936f, -0.24647284f, 0.06248760f, 
    0.45265278f, -0.04159393f, 0.30613068f, -0.05246636f, -0.01435924f, -0.25912514f, -0.26030821f, -0.42378199f, 
    -0.31908175f, -0.24435242f, 0.09639196f, 0.51965398f, 0.19361240f, -0.60332966f, -0.83515477f, -0.82179821f, 
    0.16003944f, 0.07042068f, 0.05541546f, -0.04299704f, 0.27820277f, -0.28947437f, 0.54473132f, -0.30043975f, 
    -0.15530947f, -0.34497046f, -0.11063328f, -0.16005111f, 0.13156083f, -0.17209120f, -0.24382536f, -0.00861891f, 
    0.27989763f, 0.14068757f, 0.21271265f, 0.66543031f, 0.11506638f, -1.11558759f, 0.62913620f, 1.26227427f, 
    -0.47286016f, -0.14191976f, -0.45990869f, -0.87434298f, -0.68882126f, -0.61435485f, 0.21166545f, -0.13462587f, 
    -0.24683002f, -0.26969692f, -0.33998358f, -0.34874219f, -0.00000799f, -0.09812468f, -0.13985996f, -0.35194451f, 
    0.05185074f, -0.06935701f, -0.14620638f, 0.07913864f, -0.19888043f, -0.51225418f, -0.88145417f, 0.08972237f, 
    0.41900310f, 0.36114204f, -0.13147607f, -0.05129976f, -0.11213358f, 0.46925166f, 0.66329026f, -0.12519291f, 
    0.33990452f, -0.07342799f, -0.19224119f, -0.07650419f, -0.47017580f, 0.31766659f, 0.16348620f, -0.11462704f, 
    0.26306993f, -0.15971158f, 0.28206772f, -0.21695387f, 0.08375900f, -0.07039268f, -0.47736293f, -0.61639792f, 
    -0.46323395f, 0.22967155f, -0.18018645f, 0.69822454f, 0.55135190f, 0.19097979f, -0.44050664f, -0.43638965f, 
    0.24053714f, 0.51057047f, -0.28778252f, -0.08084094f, -0.32736608f, -0.52364582f, 0.33917162f, 0.29052004f, 
    -0.04002435f, 0.03254179f, 0.18541595f, -0.40048271f, -0.17524444f, -0.21909407f, -0.03982182f, -1.01641417f, 
    -0.00387941f, 0.33650291f, 1.01684558f, 0.64540488f, 0.32906359f, -0.68410879f, -0.59581071f, -0.13882343f, 
    0.12281232f, 0.06390990f, 0.23409152f, -0.11879209f, 0.22407669f, 0.23877168f, -0.21855772f, -0.23083904f, 
    0.06414174f, -0.18023424f, -0.07166915f, -0.03736961f, 0.16699700f, 0.10888241f, 0.02072582f, -0.23324946f, 
    1.11634898f, 0.10786857f, -0.71263522f, 0.05572733f, -0.04285889f, 0.48335907f, -0.13332494f, 0.05981985f, 
    0.01163891f, -0.06651453f, 0.00486830f, 0.50460660f, -0.27026367f, -0.37252662f, -0.13415609f, -0.16744207f, 
    -0.30456322f, 0.40465128f, -0.13492657f, -0.24272299f, 0.09660258f, -0.04380868f, -0.14808562f, 0.07172541f, 
    0.00042002f, -0.37002203f, -0.02983560f, 0.25453910f, 0.16297266f, 0.13752012f, -0.02027117f, 0.27501824f, 
    0.19119382f, -0.11385826f, 0.31664863f, -0.14679198f, 0.41496232f, 0.38066831f, -0.61769313f, -0.15679500f, 
    -0.24781714f, 0.11550114f, -0.39357287f, 0.21517354f, -0.13762389f, 0.15887631f, 0.34913132f, -0.00898700f, 
    -0.12372665f, -0.17133425f, 0.55098665f, 0.35048178f, 0.54851186f, 0.36874434f, 0.51595545f, 0.07550669f, 
    -0.27463692f, -0.36689073f, -0.26184401f, -0.22214901f, 0.14222974f, 0.20674975f, 0.31206974f, -0.16402434f, 
    -0.09534479f, 0.00608902f, 0.19243783f, -0.20480269f, -0.21657155f, 0.23897383f, -0.17660020f, 0.12368263f, 
    0.19489655f, 0.22856505f, -0.10403407f, -0.56438351f, -0.71005154f, 0.43859369f, 0.54834914f, 0.67856205f, 
    0.74825501f, -0.70192915f, -0.54310906f, -0.04368647f, 0.00392883f, -0.28279474f, -0.28838480f, -0.32825032f, 
    -0.10154089f, 0.03643211f, 0.13355362f, 0.17941608f, 0.35598394f, 0.11856868f, -0.21955878f, -0.06533266f, 
    0.00755439f, -0.25156447f, -0.06672478f, 0.28077805f, -0.37415153f, -0.00493638f, -0.18076749f, -0.37482169f, 
    -0.25882360f, 0.10652069f, -0.30312923f, -0.96647573f, -0.74426699f, -0.13695920f, -0.11365208f, 0.14087909f, 
    0.26094723f, 0.13796167f, 0.09660270f, -0.04437035f, -0.17068340f, -0.00071189f, 0.13113178f, 0.14109090f, 
    -0.34854838f, -0.18551889f, -0.41542688f, 0.07916541f, -0.44699898f, -0.50594682f, -0.12032531f, -0.87808996f, 
    -0.69763845f, -0.15976346f, -0.22045805f, -0.26494926f, -0.31051123f, -0.38018617f, -0.37275818f, -0.24748662f, 
    -0.32472384f, -0.12649468f, -0.05600499f, -0.01861514f, 0.42951262f, -0.09351654f, 0.23185477f, 0.08395650f, 
    -0.16141094f, 0.23970360f, 0.06585891f, 0.12003623f, 0.08868732f, 0.18441860f, 0.27018073f, 0.12039072f, 
    0.10684402f, -0.78881305f, -0.40597212f, 0.31609344f, 0.21903004f, -0.20818318f, -0.22162680f, 0.02742235f, 
    -0.40327507f, -0.14870749f, -0.05045094f, -0.18969736f, -0.08869205f, -0.44005510f, 0.09929246f, -0.35503706f, 
    -0.34219861f, 0.36837715f, -0.42604548f, 0.17048010f, -0.17518049f, -0.21973203f, 0.03131651f, -0.81857002f, 
    -0.54946905f, 0.04209599f, 0.01197292f, -0.34484878f, -0.24407767f, -0.19335851f, -0.23069890f, -0.77053505f, 
    -0.60747921f, -0.45929319f, -0.18115324f, 0.11368892f, -0.44847828f, -0.34512106f, -0.19989999f, -0.55858296f, 
    -0.25885102f, 0.12703016f, -0.18244484f, 0.08809303f, -0.07709122f, -0.25210211f, -0.02985599f, 0.48243895f, 
    1.36245811f, 0.21067581f, -0.56897146f, -0.78792846f, -1.15251148f, 0.35969627f, 0.22397044f, 0.43324441f, 
    0.17797075f, -0.36171994f, 0.30853561f, 0.00729405f, 0.26708916f, -0.41319874f, 0.12257354f, 0.46613216f, 
    -0.02395870f, -0.07346001f, -0.21447907f, -0.20144714f, -0.19146019f, -0.16461058f, -0.00458127f, 0.17491406f, 
    0.04324088f, 0.46179974f, 0.36862063f, 0.18503182f, -0.32602352f, -0.47182307f, -0.62821209f, -0.45061693f, 
    -0.45044047f, -0.79242772f, -0.72537446f, 0.29752210f, -0.27544025f, 0.75250775f, -0.42419851f, 0.01089058f, 
    0.05445591f, 0.12888558f, 0.12395532f, 0.04302813f, 0.01612248f, 0.03932885f, -0.05867262f, 0.11836842f, 
    -0.18807575f, 0.14424081f, -0.85652989f, -0.82531917f, -0.63334364f, -0.54557514f, -0.46134031f, -0.43517351f, 
    -0.89922124f, -0.84406692f, -0.78711557f, -0.42150694f, 0.04883894f, 0.04182581f, 0.25666618f, 0.68130243f, 
    -0.19434193f, 0.13270614f, -0.18433066f, 0.14802469f, -0.01076015f, -0.26180092f, -0.27560502f, 0.24844766f, 
    0.20682818f, 0.00661521f, 0.04867908f, -0.61145115f, -0.78105754f, 0.09257177f, 0.39429674f, 0.81829053f, 
    -0.21111788f, 0.31764334f, 0.53431362f, -0.07442122f, -0.45934144f, -0.48217517f, -0.49979392f, 0.38956112f, 
    -0.20413469f, -0.18952888f, 0.01808086f, 0.02291087f, -0.09979918f, 0.14169092f, -0.30489168f, 0.09626240f, 
    -0.36412847f, -0.28815103f, 0.44625166f, 0.02407258f, 0.41133037f, 0.42759880f, 0.47831231f, 0.26589414f, 
    0.31405181f, 0.14824042f, 0.16076951f, 0.06751253f, -0.02717384f, 0.07660257f, 0.15576284f, -0.12567858f, 
    0.28821412f, 0.17173558f, -0.19400875f, -0.16683535f, 0.06614580f, 0.02491051f, 0.04775174f, 0.08792348f, 
    -0.00371129f, 0.06516109f, -0.07811862f, -0.08308060f, 0.13798943f, 0.78163874f, 0.04949038f, -0.78796983f, 
    -0.26336879f, 0.53783643f, 0.47150120f, 0.66927892f, -0.44627503f, -0.65143406f, 0.15705471f, -0.36028361f, 
    0.07891029f, -0.34132299f, -0.11933666f, -0.09044624f, 0.12990011f, -0.15498573f, -0.14741258f, -0.06152607f, 
    -0.12449183f, -0.30975488f, -0.45715800f, -0.69433343f, -0.59068692f, -0.74877477f, 0.77389175f, -0.88582408f, 
    0.20117432f, 0.69301230f, 0.75336319f, -0.93953323f, -0.79624456f, -0.72960985f, -0.21174446f, -0.50686246f, 
    -0.08492237f, -0.19438241f, 0.04228454f, -0.05581980f, -0.43098336f, 0.14273560f, 0.32800043f, -0.23531081f, 
    -0.00388720f, 0.29666206f, -0.18453924f, -0.15645278f, -0.03040363f, -0.08321315f, 0.03953229f, -1.44930804f, 
    0.19243301f, -0.33252972f, -0.69686210f, -0.59361911f, 0.25726902f, -0.29220101f, -0.60258424f, -0.36330578f, 
    0.56692302f, 0.38961595f, 0.01342531f, 0.33559471f, 0.43707043f, 0.30919003f, -0.23904303f, -0.18859333f, 
    -0.01146455f, -0.39775604f, 0.08611858f, 0.09486645f, 0.48980743f, -0.16649021f, -0.20590089f, 0.15438491f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02269763f, 0.18975234f, 0.34813875f, -0.00160181f, -0.26467019f, 0.10423816f, 0.25036925f, 0.23490888f, 
    0.24401982f, 0.59628111f, 0.22129700f, 0.15871622f, 0.04850569f, 0.30700281f, 0.52883315f, 0.32987943f, 
    0.56400275f, 0.48264730f, -0.03250217f, 0.14589812f, -0.06356794f, -0.46695757f, 0.18990457f, 0.28690243f, 
    0.61816549f, 0.29817972f, -0.36971724f, 0.25798407f, -0.12390886f, -0.08244090f, 0.08955056f, 0.18896005f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.21567109f, 0.10508545f, -0.12941077f, -0.07072326f, 0.05552419f, 0.24249527f, 0.03454619f, -0.13439266f, 
    -0.09606533f, 0.07351202f, 0.00793262f, 0.10590654f, 0.06007117f, 0.14429672f, -0.09405009f, 0.05243208f, 
    -0.21005143f, -0.24619271f, -0.29041329f, -0.16146936f, -0.08878221f, 0.00266923f, -0.03838849f, 0.00399202f, 
    -0.30108979f, -0.29250598f, 0.21747628f, -0.10629579f, -0.03645533f, 0.14087954f, 0.04634166f, 0.02375474f, 
    0.11051387f, 0.03225752f, -0.22365472f, -0.10960972f, 0.39600864f, -0.09219431f, -0.05412508f, -0.11927284f, 
    0.11823583f, 0.15778105f, 0.14910111f, 0.06287815f, -0.01394162f, -0.18221503f, 0.05958700f, 0.16922215f, 
    0.40266803f, 0.29531950f, 0.25366330f, -0.17220181f, 0.00575315f, 0.12680772f, 0.17424750f, 0.20539419f, 
    -0.07093371f, 0.18357389f, -0.11073549f, -0.09279124f, 0.07486491f, -0.07210574f, -0.04885487f, 0.11015616f, 
    -0.01222721f, 0.15585019f, -0.04783385f, 0.06256191f, -0.05921209f, 0.13083820f, 0.10507004f, -0.03784528f, 
    -0.39412481f, 0.03985302f, -0.21157718f, 0.09684080f, -0.00866549f, -0.00780668f, -0.14341630f, 0.00463707f, 
    0.05580698f, 0.06034281f, -0.01129414f, 0.00290572f, -0.00032199f, 0.24173036f, -0.10621055f, -0.03515359f, 
    0.05261995f, -0.03188803f, -0.05024474f, -0.03476369f, -0.05734241f, -0.21786861f, -0.28680462f, -0.13331957f, 
    0.27747783f, 0.23933138f, -0.18816964f, -0.43885455f, -0.06104873f, -0.08927882f, 0.08582842f, 0.11303820f, 
    0.07485345f, 0.00877119f, 0.07570716f, -0.10602602f, -0.72282481f, -0.04540324f, 0.18323825f, -0.21419629f, 
    -0.01617085f, -0.07089149f, -0.00156022f, 0.04030787f, -0.08802453f, -0.14710072f, -0.13964239f, -0.06698277f, 
    0.04981562f, 0.18534014f, 0.06260674f, -0.08397915f, 0.03428255f, 0.01415940f, 0.07869541f, 0.16465615f, 
    -0.22205389f, 0.03695341f, 0.12183268f, -0.07252502f, 0.13126478f, -0.05310777f, -0.18978079f, -0.00963235f, 
    0.10266063f, 0.18099229f, -0.24265806f, -0.19071501f, -0.11223789f, -0.20415491f, -0.05375270f, -0.05892389f, 
    0.37402841f, 0.06242186f, -0.03977174f, -0.55243814f, -0.04574355f, -0.05801690f, -0.07587206f, 0.09191468f, 
    -0.09013468f, -0.06189436f, -0.06434499f, 0.13954836f, 0.00732197f, 0.21729246f, 0.13137363f, -0.04621049f, 
    -0.07535567f, -0.00895786f, 0.01877583f, -0.11985427f, -0.08345895f, -0.04423165f, -0.07078195f, -0.23231350f, 
    0.25216523f, -0.18718517f, -0.43004575f, -0.03407783f, 0.06835906f, 0.00946786f, -0.08910164f, -0.11310482f, 
    -0.20778710f, -0.12042791f, -0.14597473f, 0.05370685f, -0.41021502f, 0.05557159f, 0.06458224f, -0.35040408f, 
    -0.02663532f, 0.09647723f, 0.02720010f, 0.07930973f, -0.04537496f, 0.00259924f, 0.07389057f, -0.13018160f, 
    -0.82140458f, -0.71732777f, -1.14178133f, 0.31320518f, -0.05454713f, 0.03848143f, 0.02392477f, -0.02803221f, 
    -0.07752128f, -0.00861332f, -0.17302996f, -0.07666124f, -0.48394811f, 0.09686791f, 0.05729140f, -0.24821669f, 
    -0.07336953f, -0.12256892f, 0.04515943f, -0.02306814f, -0.06433283f, -0.02551726f, 0.04707180f, -0.12661290f, 
    -0.09355003f, -0.10264526f, -0.02923379f, 0.03076680f, 0.05074647f, -0.06400474f, -0.03312036f, -0.04244671f, 
    0.03631261f, -0.00663618f, 0.01163220f, 0.04620545f, 0.43811870f, 0.11868455f, -0.11285940f, -0.33689901f, 
    -0.17265770f, -0.25651625f, 0.10403042f, 0.08549814f, -0.07032762f, -0.07975379f, -0.01891904f, -0.01751004f, 
    0.44306770f, 0.33863410f, -0.29989174f, -0.06116670f, -0.08601760f, 0.02007296f, -0.04208008f, 0.11743208f, 
    -0.05665296f, -0.19454592f, -0.01157780f, 0.10662442f, 0.37603179f, 0.24210845f, -0.11615563f, -0.09446633f, 
    0.08346394f, 0.15539981f, 0.00537383f, -0.02394378f, -0.07384607f, -0.01803730f, 0.03457914f, 0.07143106f, 
    0.02302982f, 0.14918353f, -0.11359087f, 0.18162630f, 0.01260014f, -0.03088832f, -0.24611251f, -0.04558145f, 
    -0.03420642f, -0.25654739f, -0.14674366f, 0.02669924f, 0.51722896f, 0.34197924f, -0.13942336f, -0.11205959f, 
    0.09096042f, -0.10648272f, 0.14007473f, 0.05468888f, -0.05919748f, -0.14830224f, -0.10054987f, -0.26037398f, 
    -0.02265919f, -0.66393793f, -0.33276469f, 0.06515489f, 0.03446423f, -0.08910716f, -0.21034487f, -0.11703309f, 
    -0.24727048f, -0.15010360f, -0.18963411f, -0.03688995f, 0.30855206f, -0.07750998f, -0.37360263f, -0.25555277f, 
    0.09372970f, -0.10502883f, 0.09842012f, 0.11642193f, 0.04081602f, 0.10743970f, 0.02028192f, -0.01722601f, 
    0.41750863f, 0.32271785f, -0.03671594f, -0.38640791f, 0.15614091f, 0.15553117f, 0.06578955f, 0.03195211f, 
    -0.00749878f, -0.01109391f, -0.03663995f, 0.09598774f, 0.29503107f, -0.18274556f, 0.11916222f, 0.13046536f, 
    -0.06228741f, -0.05255305f, 0.09167769f, 0.14369212f, -0.03693303f, 0.01315675f, 0.06961323f, -0.05879555f, 
    -0.07224239f, -0.11110869f, 0.00430117f, 0.09373255f, 0.02259647f, 0.04452055f, 0.01019220f, 0.05106893f, 
    -0.01313805f, 0.04900427f, 0.05615362f, 0.02589835f, 0.05005317f, -0.00657319f, -0.53842968f, 0.26725447f, 
    -0.00827717f, 0.07624518f, -0.01217413f, -0.10071184f, -0.06043582f, -0.02198797f, 0.14126596f, -0.00626988f, 
    0.11212701f, 0.04969756f, 0.21387702f, -0.17435524f, 0.06567875f, -0.13389067f, -0.05169802f, -0.01117703f, 
    -0.03715140f, 0.00744716f, 0.02524180f, -0.01315590f, 0.32110983f, 0.19124156f, -0.16159678f, -0.29225233f, 
    -0.02861829f, 0.13072392f, -0.14939763f, -0.15316336f, -0.07682441f, -0.15679896f, 0.02395795f, 0.02589140f, 
    0.29635692f, -0.04673618f, -0.15661189f, -0.00675356f, -0.04252108f, 0.09053300f, -0.02735489f, 0.06169235f, 
    -0.00756952f, -0.13113171f, -0.06053004f, -0.10596134f, 0.11539464f, -0.06244573f, -0.00039150f, -0.07093754f, 
    -0.05483854f, 0.12430722f, -0.13336933f, -0.04521338f, -0.10271726f, -0.13035373f, 0.04840990f, 0.06778442f, 
    -0.17245881f, 0.45463648f, -0.12125778f, -0.44267523f, -0.05016313f, -0.00155221f, -0.02066219f, 0.09076245f, 
    -0.13578953f, 0.19331582f, 0.07683300f, -0.03343372f, -0.11701969f, -0.20477043f, -0.31228584f, 0.07623304f, 
    -0.03624727f, 0.00426962f, 0.03324247f, -0.10332442f, -0.14204983f, 0.03113385f, -0.18709922f, 0.00978082f, 
    0.31436270f, 0.36588651f, -0.22693905f, -0.08772990f, 0.11861856f, -0.07274266f, -0.07096965f, -0.04003819f, 
    -0.00142758f, -0.00630652f, -0.25745764f, -0.14508614f, -0.15898436f, -0.33329275f, 0.08793107f, -0.17700593f, 
    0.05641555f, 0.13899805f, -0.24799627f, 0.00741526f, -0.10214718f, -0.13132238f, -0.13889173f, 0.12644444f, 
    0.32384139f, 0.07162677f, 0.15045790f, 0.06913865f, -0.02822215f, -0.21611054f, 0.16135816f, -0.17621160f, 
    -0.04352244f, 0.05274598f, -0.04110665f, 0.06848776f, 0.03585223f, 0.05075420f, -0.20667960f, -0.00007807f, 
    0.13670526f, 0.11877423f, 0.13280059f, -0.02485038f, 0.02649119f, -0.01476299f, 0.12033893f, -0.04717702f, 
    -0.53955412f, -0.03195553f, -0.31388080f, -0.42080864f, 0.05728723f, -0.30349660f, 0.18063505f, 0.09608794f, 
    -0.13439760f, -0.00443137f, 0.06867843f, 0.08890507f, -0.03661148f, 0.15756015f, -0.07697857f, 0.01921372f, 
    0.06539481f, -0.01984491f, 0.00966031f, -0.02377792f, 0.06796023f, -0.09639743f, 0.18992817f, 0.04266820f, 
    0.05056924f, 0.07573100f, 0.08602645f, 0.00877172f, 0.17786962f, 0.04158143f, -0.17048480f, -0.29441971f, 
    0.24584204f, 0.02549171f, -0.00811595f, -0.17860208f, 0.45216659f, 0.02682411f, 0.10852280f, -0.33186567f, 
    -0.01880607f, 0.32396427f, 0.11757767f, 0.09265203f, 0.00347867f, 0.10126726f, -0.18276253f, -0.07478565f, 
    -0.48453513f, -0.09912660f, -0.36213353f, -0.70478338f, -0.09121036f, -0.26821342f, -0.11250003f, 0.08028943f, 
    -0.09762559f, -0.09419225f, 0.01576349f, -0.04598763f, -0.02353043f, 0.20539056f, 0.00023706f, 0.04271436f, 
    -0.08559333f, 0.00623729f, -0.05786123f, -0.01666195f, -0.14935260f, -0.16190265f, -0.09955809f, 0.09341212f, 
    0.21304305f, -0.28172606f, -0.26507014f, -0.11236314f, -0.15942836f, 0.00826498f, 0.06638581f, -0.00626945f, 
    0.39269921f, -0.03504763f, 0.10423768f, 0.16089596f, -0.04244514f, 0.12728748f, -0.18887161f, 0.19977228f, 
    -0.01271595f, -0.09966917f, 0.10132848f, 0.11575188f, -0.13470249f, 0.02992501f, 0.08158726f, -0.08022209f, 
    0.84800810f, 0.40498731f, 0.27112940f, 0.23671426f, -0.09685507f, -0.10690142f, -0.07788106f, 0.02990897f, 
    0.05701211f, -0.00393729f, -0.09860473f, 0.24989656f, 0.06962878f, -0.05392146f, -0.04216262f, 0.20654708f, 
    0.02750453f, 0.05550991f, 0.02341657f, 0.05378373f, -0.02729304f, 0.02220430f, -0.14369462f, 0.20227243f, 
    0.19951573f, 0.11741358f, 0.04699596f, 0.07203360f, 0.01263298f, -0.16828069f, -0.02923623f, -0.08957140f, 
    -0.07468279f, 0.04984600f, -0.03858801f, 0.05413289f, -0.16057397f, 0.05599987f, -0.48034561f, -0.00582547f, 
    0.21325235f, 0.04917437f, -0.10951298f, 0.01639086f, 0.26687694f, 0.01986770f, -0.02569744f, 0.00940963f, 
    0.17452697f, 0.13506022f, 0.05575117f, 0.27407447f, 0.05953994f, 0.14782891f, -0.11978048f, 0.26533571f, 
    -0.03216428f, -0.04907639f, 0.01556463f, -0.01338758f, 0.21786802f, 0.30453470f, 0.42774770f, 0.13879432f, 
    -0.02779409f, 0.13059892f, -0.07364570f, -0.11398962f, -0.05999744f, 0.00355329f, -0.02579188f, -0.11220525f, 
    0.39503959f, -0.05025920f, -0.25282502f, -0.03009709f, 0.08689892f, 0.01076557f, -0.13383067f, 0.24583024f, 
    -0.23288959f, 0.00282701f, -0.07159249f, -0.30599013f, -0.04730428f, 0.02580895f, 0.14000459f, 0.11148709f, 
    -0.05547750f, 0.25054684f, 0.05350555f, 0.07953653f, 0.06546704f, 0.08859856f, -0.04433174f, 0.06877566f, 
    0.61986715f, -0.45371082f, 0.05112348f, -0.24537352f, -0.01586407f, -0.06305049f, 0.24286704f, -0.21589923f, 
    0.22029445f, 0.08538707f, -0.17590320f, 0.01596354f, 0.15925302f, 0.01027371f, -0.23768772f, -0.29385233f, 
    -0.48669264f, -0.17430608f, 0.09589843f, -0.10546563f, -0.04725499f, 0.02414319f, -0.01628172f, 0.06658860f, 
    -0.01196567f, 0.10406209f, 0.30086344f, 0.46234897f, -0.03423133f, 0.02705104f, 0.09259299f, -0.00357054f, 
    -0.04894428f, -0.01945827f, 0.07146381f, -0.02615356f, -0.36179572f, -0.25715843f, 0.26322353f, 0.27872202f, 
    -0.05409539f, 0.00125166f, 0.05584724f, -0.07270823f, 0.15365471f, 0.04681659f, -0.00001037f, -0.03380120f, 
    0.18184546f, 0.18859628f, 0.08989404f, 0.19412917f, -0.02157355f, -0.03948560f, -0.01496236f, -0.04312910f, 
    0.02074865f, 0.02833993f, 0.07735744f, -0.01451127f, 0.29792857f, -0.04026446f, -0.17675322f, -0.00707945f, 
    -0.00199181f, 0.01037769f, -0.09307659f, 0.04236095f, -0.24841535f, -0.29820520f, -0.27052122f, -0.19939932f, 
    -0.38232267f, 0.35204864f, -0.73610985f, -0.13952965f, 0.00439745f, -0.00626544f, 0.11507267f, -0.36342257f, 
    -0.05989518f, 0.01117084f, -0.01993264f, -0.01506444f, -0.71451050f, -0.26173013f, -0.16456842f, 0.27805790f, 
    0.17567822f, 0.11880881f, -0.16085355f, -0.04235403f, -0.10473349f, -0.00859698f, 0.11557379f, 0.00887659f, 
    0.21616992f, 0.44702184f, 0.54518574f, 0.56081390f, -0.05008960f, -0.09565074f, 0.10742626f, 0.12204665f, 
    -0.02372033f, -0.18466456f, 0.00285258f, 0.02850167f, -0.10931202f, -0.10185009f, 0.09627321f, -0.00422556f, 
    -0.21473873f, -0.27655905f, 0.12841500f, 0.05172848f, 0.13218483f, -0.04943074f, 0.05965986f, -0.00379389f, 
    -0.01413473f, 0.47190621f, 0.13160497f, 0.31772181f, 0.09826037f, 0.07932588f, -0.06701107f, 0.04897770f, 
    -0.16436644f, -0.19359952f, 0.16663216f, 0.02821277f, -0.05029808f, -0.13257961f, 0.36339989f, 0.10108914f, 
    0.01362685f, 0.06362474f, 0.10523945f, 0.07161488f, -0.03629832f, -0.02318079f, 0.11554361f, 0.07221866f, 
    -0.21776234f, -0.28257057f, 0.42569274f, 0.52518910f, -0.10544512f, -0.04438631f, -0.22711636f, -0.08080422f, 
    0.07064741f, 0.01836837f, -0.28807473f, 0.06953380f, 0.23920029f, 0.12152761f, 0.04385499f, 0.06195764f, 
    0.09492632f, -0.00380416f, 0.10168457f, -0.28043664f, 0.20207042f, 0.04609741f, -0.18099770f, 0.23328157f, 
    -0.46418819f, -0.55057818f, 0.26201612f, -0.16184387f, -0.05659554f, -0.06028137f, 0.05275778f, 0.14270933f, 
    -0.00619919f, -0.02004472f, -0.06689694f, -0.00023214f, -0.10113274f, -0.11194475f, -0.23641121f, -0.01805684f, 
    -0.15589641f, 0.11427163f, -0.03752924f, -0.05693508f, 0.03955579f, -0.09614529f, -0.03123529f, 0.06588403f, 
    -0.52264762f, 0.25333315f, -0.10854522f, -0.33963397f, 0.18045269f, 0.06462204f, -0.08760016f, -0.04107314f, 
    0.01507120f, 0.03019707f, -0.08121784f, -0.06414159f, -0.02669501f, 0.02490059f, -0.00074067f, 0.06875491f, 
    0.07278748f, 0.01851309f, 0.06765100f, 0.07183484f, -0.01054057f, 0.08250324f, -0.07404697f, 0.26356956f, 
    0.23669007f, -0.28243646f, 0.27190006f, 0.02672253f, 0.03516841f, 0.26746583f, -0.16101620f, -0.20025793f, 
    -0.01690823f, 0.13039684f, -0.02057214f, 0.10949681f, -0.07199771f, 0.21663593f, 0.10164923f, -0.34020907f, 
    -0.07759170f, 0.15965149f, -0.20084316f, 0.05980562f, -0.01862178f, -0.04599440f, -0.13912271f, 0.00008029f, 
    -0.48585111f, 0.82424414f, -0.40413141f, -0.18838909f, 0.00486354f, -0.23015757f, -0.04552351f, -0.12295637f, 
    0.00012315f, -0.04740331f, 0.02616436f, -0.06531391f, 0.03308184f, -0.05245495f, -0.06322134f, 0.14970829f, 
    0.10284735f, 0.04726254f, 0.05591107f, 0.01277374f, 0.03319868f, 0.10649721f, -0.28260624f, 0.17124490f, 
    0.17926311f, -0.10938298f, 0.18291685f, -0.22910556f, 0.03705105f, -0.11568394f, 0.00739328f, 0.19601312f, 
    0.20684581f, 0.10779503f, -0.14721701f, 0.03234865f, 0.06778966f, 0.31229421f, -0.23937610f, -0.09002565f, 
    0.12998833f, -0.17733048f, -0.03766928f, 0.10210080f, -0.03326190f, 0.00140632f, 0.03243289f, -0.05985186f, 
    -0.35694301f, 0.37359610f, 0.10594768f, -0.38225374f, -0.03631705f, -0.02121574f, -0.03694538f, -0.00358655f, 
    0.03177048f, 0.01466272f, 0.03588072f, -0.06022295f, 0.17125984f, -0.17927726f, -0.27652523f, 0.19936621f, 
    0.02072722f, -0.03787591f, 0.11478293f, 0.11828980f, 0.07800526f, -0.15709841f, 0.08499490f, -0.04743794f, 
    -0.28743973f, 0.00693242f, -0.07641079f, -0.14045334f, -0.01829095f, -0.06942029f, 0.09716959f, 0.07359494f, 
    0.03932507f, -0.01831477f, -0.03541051f, -0.00752796f, -0.23191236f, 0.31755343f, -0.35620999f, 0.05905066f, 
    0.06213564f, 0.05658774f, -0.19923936f, 0.11814361f, -0.07166124f, -0.01466697f, 0.08287441f, -0.12718497f, 
    -0.05620279f, -0.32040885f, 0.25730473f, -0.01946488f, 0.10577498f, -0.04695849f, -0.06437281f, 0.05112351f, 
    -0.02354795f, 0.14587408f, 0.03886473f, -0.07937664f, -0.76544249f, -0.51008445f, 0.12598285f, -0.23285906f, 
    -0.08493171f, -0.06214963f, 0.07719485f, -0.24189398f, -0.02455339f, -0.00953884f, -0.01348265f, -0.02066525f, 
    -0.04968370f, 0.20879765f, 0.19157217f, 0.10518021f, -0.00529905f, 0.00405429f, -0.04723885f, 0.07132869f, 
    0.05321783f, 0.05884616f, -0.08472443f, -0.12172895f, 0.05964497f, 0.14124238f, -0.16411869f, 0.00815786f, 
    0.02652263f, -0.05104181f, -0.16895792f, -0.10075688f, -0.05526796f, -0.05461857f, 0.08654393f, -0.04457119f, 
    -0.30413198f, 0.36220500f, 0.16530691f, -0.30099371f, -0.02388819f, 0.04096375f, -0.00770208f, -0.36402446f, 
    0.01698573f, 0.26094151f, -0.10514456f, 0.10599744f, -0.50921834f, -0.38399857f, -0.08166994f, -0.46735290f, 
    0.16997153f, -0.02479872f, -0.05813334f, -0.17197269f, 0.11711714f, -0.05128847f, 0.06991062f, -0.02810303f, 
    -0.93370271f, -0.66725892f, 0.12292645f, -0.22268133f, -0.12726362f, -0.11654990f, -0.19011045f, -0.04990291f, 
    0.01581811f, -0.07900973f, 0.03832437f, -0.05611282f, 0.21855214f, 0.07741725f, -0.52516139f, 0.20894156f, 
    0.04774902f, -0.05763809f, 0.06743738f, -0.05606136f, -0.08942921f, -0.01039544f, 0.18652010f, -0.09405839f, 
    -0.22766462f, -0.01993634f, -0.05736542f, -0.13542540f, -0.06133091f, -0.02904804f, 0.04382695f, 0.13679461f, 
    0.00890000f, -0.04517166f, 0.04445991f, -0.05873504f, 0.11755907f, -0.22227009f, 0.06415960f, -0.27283114f, 
    0.04651716f, -0.07436983f, 0.05012986f, -0.03146543f, 0.12527581f, 0.01604165f, 0.06258254f, 0.03981956f, 
    -0.71283680f, 0.23696181f, -0.08574595f, 0.30042678f, -0.42747021f, -0.12221071f, -0.11260217f, -0.22011460f, 
    -0.06551630f, 0.01641575f, -0.00001902f, 0.01216436f, 0.53414893f, -0.37996784f, 0.11062715f, 0.73835117f, 
    0.08499262f, -0.06511243f, -0.21367294f, -0.05894425f, 0.12571010f, -0.05275202f, 0.02360263f, 0.03161984f, 
    0.05539564f, -0.21862678f, 0.01852178f, 0.30132258f, 0.14865755f, 0.05812247f, -0.02082335f, -0.07398824f, 
    -0.07573353f, 0.06948151f, -0.03293072f, 0.01143671f, -0.34950465f, -0.01617543f, -0.21775134f, 0.11906376f, 
    -0.07086424f, 0.18310504f, 0.16256988f, -0.02508352f, 0.01627692f, -0.10801399f, 0.14509785f, -0.14653525f, 
    1.04380310f, -0.28386039f, 0.10825610f, -0.12401601f, 0.28402445f, 0.12534164f, -0.01453470f, 0.09764924f, 
    -0.05067008f, -0.01987513f, -0.06683167f, 0.07024907f, -0.19942150f, 0.48029771f, -0.27470377f, -0.36917898f, 
    0.24731146f, 0.14185970f, 0.09293175f, -0.26245314f, -0.25197682f, 0.06609541f, -0.04054153f, -0.18862250f, 
    0.51944363f, 0.01929887f, -0.06172056f, -0.06989552f, 0.18068586f, 0.09483726f, -0.01978838f, 0.12096316f, 
    -0.16016556f, 0.20696020f, -0.10879972f, 0.08456049f, 0.28022724f, 0.03648887f, 0.16710027f, 0.50575781f, 
    0.09314123f, 0.03700088f, -0.19805409f, -0.05049932f, -0.23028034f, -0.03988758f, 0.04930576f, 0.25314319f, 
    0.13302380f, -0.42098853f, 0.70839137f, 0.22468607f, -0.30936101f, -0.10648500f, -0.16784269f, 0.00001603f, 
    0.11026742f, 0.18487680f, 0.10027308f, 0.11289575f, -0.05800594f, 0.22969750f, -0.11020360f, 0.11452020f, 
    -0.01818060f, -0.18538824f, -0.22264576f, -0.09631866f, 0.07101258f, 0.38152549f, -0.03579342f, -0.35937271f, 
    -0.02114343f, -0.13689922f, -0.05945898f, 0.20944183f, -0.03096328f, -0.04423916f, -0.03592073f, 0.06317891f, 
    -0.04568442f, -0.21212791f, 0.10316125f, 0.13087589f, 0.17100476f, -0.24025925f, -0.25165445f, -0.62668759f, 
    -0.30090964f, 0.00640007f, -0.04611277f, -0.18829021f, 0.15890361f, -0.01300972f, 0.04796540f, -0.01457581f, 
    -0.06485470f, -0.21845219f, -0.06748551f, 0.14487559f, -0.06740221f, -0.07972587f, -0.07064293f, -0.04286879f, 
    0.02814195f, 0.04519283f, -0.08537935f, 0.13975544f, -0.08626292f, -0.09894079f, 0.06590446f, 0.46267730f, 
    0.03260982f, -0.24582925f, -0.16854861f, -0.12066421f, -0.01771655f, 0.15403225f, 0.27347255f, -0.02763501f, 
    -0.31108350f, 0.23916046f, -0.09990492f, 0.66150677f, -0.00473268f, -0.18317094f, 0.15364465f, 0.06155352f, 
    -0.03626301f, 0.01215584f, -0.12355526f, 0.24553449f, -0.54054040f, -0.04041926f, 0.11667296f, -0.92276293f, 
    0.09451697f, 0.04194111f, -0.05640028f, 0.08790256f, -0.04176297f, 0.13044569f, -0.14154592f, -0.05481134f, 
    -0.39321527f, 0.22045031f, -0.26494023f, 0.10866649f, 0.11858697f, 0.03029437f, 0.04243079f, -0.17938541f, 
    -0.32981452f, -0.00614923f, -0.08564251f, -0.05973619f, 0.28826809f, 0.80921853f, -0.16656084f, -0.31638819f, 
    0.11938208f, -0.02022045f, -0.02514218f, 0.04341234f, -0.13956439f, 0.05181067f, -0.06292732f, 0.04368466f, 
    -0.50734061f, 0.05052252f, -0.01449576f, 0.04815742f, 0.00088703f, -0.06990895f, -0.19976640f, -0.11239664f, 
    -0.08063377f, 0.05122102f, 0.10952818f, -0.07120131f, 0.09614889f, -0.10657171f, -0.23040776f, -0.43798390f, 
    0.04365983f, -0.05653505f, -0.21551614f, -0.09181220f, -0.03238037f, -0.16136116f, -0.15905827f, -0.20218821f, 
    -0.22185288f, -0.41991666f, -0.05157767f, -0.14619622f, -0.11435921f, -0.66263008f, -0.11372354f, 0.01289730f, 
    -0.00371984f, 0.13709864f, -0.00031490f, 0.14512105f, -0.19069438f, 0.48051327f, 0.14071146f, 0.25883806f, 
    -0.32331139f, -0.21491858f, 0.07392873f, 0.14167398f, -0.11984015f, 0.06872018f, -0.06952444f, 0.00985982f, 
    -0.14438698f, -0.11280921f, -0.00401049f, 0.24966004f, 0.03041703f, 0.10012636f, 0.22256210f, -0.03614270f, 
    0.06175702f, 0.09940822f, -0.05486346f, 0.19627003f, 0.20291109f, -0.21743400f, -0.10349692f, 0.18522327f, 
    -0.14971122f, -0.04594921f, -0.02323930f, -0.00803985f, 0.05556217f, -0.04695176f, 0.00530199f, -0.13600466f, 
    -0.07411218f, -0.20539790f, 0.15625775f, 0.10015870f, -0.14307328f, -0.02025100f, -0.11623257f, 0.03388202f, 
    0.10840676f, -0.01490266f, -0.07180772f, 0.00955229f, -0.18133010f, -0.07500185f, -0.09227552f, 0.03138947f, 
    0.03984584f, -0.04157442f, -0.04570660f, 0.02265111f, -0.23421076f, -0.13819255f, 0.00412638f, -0.02232438f, 
    -0.75268918f, -0.05807829f, -0.01182483f, 0.36546734f, -0.04523138f, 0.01296215f, -0.13227683f, -0.11342445f, 
    -0.20427328f, 0.07528454f, 0.10360719f, 0.11229140f, -0.09115048f, -0.16083764f, 0.00230247f, 0.18795793f, 
    0.03836121f, 0.25817600f, 0.04416703f, -0.05910279f, -0.01229252f, 0.05763498f, -0.05960757f, 0.02338225f, 
    -0.01480474f, -0.31357986f, -0.15134290f, 0.19424544f, 0.06402060f, 0.04896074f, -0.06286144f, 0.02941115f, 
    0.01987807f, 0.09464508f, -0.04341247f, -0.01530898f, -0.35747337f, 0.61985892f, -0.59807229f, -0.42322937f, 
    0.10693883f, 0.00749539f, 0.01935425f, -0.01634002f, -0.19462968f, -0.04528794f, 0.11887949f, 0.03563686f, 
    -0.24416907f, -0.55016720f, -0.25920260f, -0.37211668f, -0.25644779f, -0.37425452f, -0.00197016f, -0.03073537f, 
    0.18351649f, 0.00871476f, 0.11920509f, -0.20862627f, 0.04605874f, 0.28025666f, -0.21743968f, 0.21929857f, 
    -0.03377941f, -0.09392224f, -0.01107950f, -0.07509948f, -0.04780445f, 0.07388949f, 0.07106484f, 0.04679755f, 
    -0.28390178f, 0.10601454f, -0.04661483f, 0.30475408f, 0.06373707f, 0.09108443f, 0.17460480f, -0.04449847f, 
    -0.02313764f, 0.00930312f, 0.02325761f, -0.12408657f, 0.12762795f, -0.21466124f, -0.01118962f, 0.25342366f, 
    0.18156043f, 0.11755067f, -0.01149951f, 0.01360200f, -0.06023846f, 0.11318254f, 0.06166763f, -0.07668497f, 
    0.10719676f, 0.09381293f, 0.16173652f, 0.15677226f, -0.04254704f, -0.17526488f, -0.01533435f, -0.10547347f, 
    0.14130189f, -0.02204394f, 0.08371662f, 0.10444292f, 0.17063977f, -0.06367171f, 0.05401917f, 0.00105675f, 
    0.10673974f, -0.07519647f, 0.00382384f, -0.14593095f, 0.20611368f, -0.08114361f, -0.11171747f, 0.00033300f, 
    0.09772869f, 0.27890950f, -0.27958989f, 0.09193557f, -0.08330601f, -0.19404635f, 0.22315595f, -0.03290396f, 
    -0.09279993f, -0.35652530f, -0.15370649f, -0.02852872f, 0.02068247f, -0.30185702f, -0.13430123f, 0.01799139f, 
    -0.14592151f, -0.04794996f, -0.05242134f, 0.05275333f, -0.06795304f, 0.19232334f, 0.03794886f, 0.05396450f, 
    -0.53407681f, -0.39291361f, -0.16418932f, 0.09670838f, -0.24266806f, 0.01396008f, 0.07351071f, -0.25540993f, 
    0.06994654f, -0.09850699f, 0.20730461f, 0.14710106f, 0.19531313f, 0.07149986f, -0.18999581f, 0.08560915f, 
    -0.04782226f, -0.04195792f, -0.13322523f, -0.14202103f, 0.03809290f, -0.26287580f, 0.08974763f, -0.15330446f, 
    0.03078388f, 0.64066058f, -0.54112554f, -0.00614910f, -0.00600292f, 0.08217839f, -0.17894854f, 0.14954498f, 
    0.11928193f, 0.00333685f, 0.03840427f, -0.07894849f, 0.20074891f, 0.00599132f, 0.12604015f, -0.01702626f, 
    0.00735459f, -0.09544791f, -0.11745880f, 0.04387169f, -0.22761080f, -0.21589953f, -0.20633006f, -0.28188297f, 
    0.04866152f, 0.12610687f, 0.22769602f, 0.13553517f, 0.07153460f, 0.02803273f, -0.13956168f, 0.09640538f, 
    -0.11885045f, -0.02027140f, -0.10378393f, -0.08940458f, -0.23625426f, -0.03313364f, -0.37968913f, 0.20721892f, 
    -0.06240632f, -0.03156753f, -0.20709765f, -0.02251057f, -0.07592985f, 0.01814267f, -0.20241892f, 0.09607214f, 
    0.05998529f, 0.04831642f, -0.04829362f, -0.02021391f, -0.11775549f, 0.02476029f, 0.10070870f, -0.20120214f, 
    -0.02748672f, 0.08496626f, 0.05091275f, 0.11840915f, -0.18857329f, 0.01890313f, -0.04689039f, 0.07327086f, 
    0.08712627f, -0.16418156f, -0.02066954f, 0.02149306f, -0.01805235f, -0.17011304f, 0.12397330f, -0.18350320f, 
    0.02616477f, -0.01077879f, 0.39705497f, 0.13143454f, 0.03756578f, -0.00186834f, -0.13742483f, 0.01069318f, 
    -0.04286018f, 0.03529882f, 0.09189141f, -0.06847705f, 0.24914867f, -0.00085341f, -0.11014006f, -0.00550348f, 
    -0.08971778f, -0.08922295f, -0.01177985f, 0.02280098f, -0.07724477f, -0.05602037f, -0.32792333f, -0.23791710f, 
    -0.01351564f, -0.35414025f, 0.14697012f, 0.15136908f, -0.04714922f, -0.13898802f, -0.11612955f, -0.05849905f, 
    -0.06837297f, -0.09124558f, -0.13121654f, -0.23330317f, -0.50610447f, -0.40199888f, 0.06852278f, 0.17204943f, 
    0.14105392f, -0.06815337f, -0.04604846f, -0.08399294f, -0.04691523f, -0.06540453f, -0.02568208f, 0.28163767f, 
    -0.39672777f, -0.46309972f, -0.58195627f, -0.53038406f, 0.04795270f, -0.00568496f, 0.06289957f, -0.00397731f, 
    -0.03606710f, -0.06894493f, 0.03842865f, -0.24040282f, 0.13622838f, 0.06941965f, -0.08707338f, -0.15000533f, 
    0.06857038f, -0.13897352f, 0.08488648f, -0.04751833f, -0.13273028f, -0.11127059f, -0.26032791f, -0.27703550f, 
    0.01672097f, 0.14748450f, 0.08661362f, 0.09351856f, 0.04745296f, 0.16075638f, 0.08636215f, 0.03314218f, 
    0.04074271f, 0.02539233f, -0.01110543f, 0.02208968f, 0.08888158f, -0.43473595f, 0.22370483f, -0.09290151f, 
    -0.08222447f, 0.08877699f, -0.05453565f, -0.10701326f, -0.14279053f, -0.06314583f, -0.01838879f, 0.04263989f, 
    0.02811413f, 0.13725211f, 0.02415371f, 0.07673746f, 0.07511948f, -0.11027160f, 0.07766125f, -0.01284370f, 
    0.00814724f, 0.15811169f, -0.03730355f, 0.02585020f, -0.04592614f, 0.03039788f, 0.08283614f, 0.14632337f, 
    0.02247841f, -0.04585948f, -0.17678137f, 0.23125508f, 0.09243044f, 0.04286763f, 0.00092829f, 0.09066068f, 
    0.01729432f, 0.03221601f, -0.06162308f, -0.23277497f, 0.07445094f, 0.02404901f, 0.07038864f, -0.11920301f, 
    -0.10001195f, 0.02785012f, 0.06062696f, 0.05189838f, -0.10160348f, -0.05942319f, -0.01348454f, -0.02636805f, 
    -0.03821651f, -0.02711669f, -0.01178066f, -0.14108509f, -0.04157048f, 0.02918458f, -0.06559671f, -0.03147542f, 
    -0.15600620f, 0.04447011f, 0.06409104f, -0.06337352f, 0.17377412f, -0.01305052f, -0.30979559f, -0.19483109f, 
    -0.08434851f, -0.21811561f, 0.13315520f, -0.04760678f, 0.07653747f, 0.46910030f, 0.28252089f, 0.11020660f, 
    -0.05855370f, -0.02818060f, 0.03099048f, 0.28436297f, 0.02703369f, -0.13553268f, -0.07376886f, -0.06992162f, 
    0.07656553f, 0.11553358f, 0.20010819f, 0.14089729f, -0.26095262f, -0.02953858f, 0.07889285f, 0.15709686f, 
    0.05803001f, -0.00183062f, 0.04858916f, 0.04351643f, -0.20513149f, -0.51855636f, 0.13756205f, -0.31975475f, 
    0.06832615f, 0.11527573f, -0.04948178f, -0.01679208f, -0.02819245f, -0.09054016f, -0.06479117f, -0.05117295f, 
    0.02335580f, -0.02204254f, -0.07260153f, 0.07761632f, 0.09970758f, 0.12623289f, -0.01172761f, 0.07047077f, 
    0.13338429f, 0.04888396f, 0.02832723f, 0.02757281f, -0.12803572f, -0.06606708f, 0.06335957f, 0.05934981f, 
    0.09379010f, -0.11003075f, 0.00431903f, 0.04692899f, 0.15126643f, 0.27513218f, 0.16611782f, 0.44348556f, 
    0.36994857f, 0.17401616f, 0.41567367f, 0.12000757f, -0.04864035f, 0.09427478f, -0.02543496f, 0.24732217f, 
    0.00380912f, -0.01611092f, 0.03808364f, 0.01669308f, 0.09069028f, 0.41177109f, 0.13291474f, 0.17517316f, 
    -0.12449843f, -0.03376403f, 0.04596195f, -0.03663860f, 0.17459185f, 0.00361030f, 0.02099743f, 0.07007318f, 
    -0.46344042f, -0.02642640f, -0.08388928f, -0.45726967f, -0.00368822f, 0.04631917f, 0.05378971f, -0.10915646f, 
    0.11186520f, -0.12729304f, 0.07339271f, -0.08965245f, -0.03244171f, 0.00153255f, -0.10437945f, -0.12719740f, 
    0.20626397f, -0.03128642f, 0.21412136f, 0.10609600f, 0.03076585f, 0.19431122f, 0.13991018f, 0.02587081f, 
    -0.82724869f, -0.69870967f, -0.22333540f, -0.15911026f, -0.12216063f, -0.08498493f, -0.11501972f, -0.20103475f, 
    0.15549444f, 0.05985914f, 0.03478986f, 0.08001785f, -0.09523328f, 0.22890303f, 0.03817050f, -0.17201877f, 
    0.03703157f, -0.01031106f, 0.00552784f, 0.05906982f, 0.20265619f, -0.21228558f, -0.30050096f, 0.05608403f, 
    -0.60006511f, -0.12905751f, 0.13742164f, -0.19593160f, -0.04058149f, -0.22735871f, -0.06934751f, 0.08507161f, 
    -0.05191037f, -0.28714892f, -0.08855400f, -0.08762685f, -0.15784772f, 0.17696242f, -0.22985548f, -0.13057739f, 
    0.04391368f, -0.13969076f, 0.08066419f, 0.20495354f, -0.09497131f, -0.04933454f, 0.00373597f, -0.08388459f, 
    0.03426145f, -0.11830241f, -0.42044359f, -0.03660828f, 0.25520724f, 0.29544154f, -0.10771819f, 0.01904541f, 
    -0.04355761f, -0.05033488f, 0.07053117f, -0.00996688f, 0.02914511f, -0.17777929f, 0.06877682f, 0.00066650f, 
    -0.20680200f, 0.11286373f, -0.16801676f, -0.08963542f, 0.09760781f, -0.02193827f, 0.01663690f, 0.28819039f, 
    0.52519834f, 0.16091089f, 0.08988480f, -0.05884016f, -0.09804466f, 0.23690763f, -0.09370080f, -0.07539117f, 
    0.09391736f, 0.02885074f, -0.12911442f, 0.05531451f, -0.12686792f, -0.05409231f, 0.34763727f, 0.13714468f, 
    0.17551386f, -0.05174643f, 0.00761719f, 0.23160851f, -0.02028823f, 0.14014992f, -0.02390620f, -0.03279560f, 
    -0.07016246f, 0.07170839f, 0.07429210f, 0.02659287f, -0.09932332f, -0.15483947f, -0.24780135f, 0.24811299f, 
    -0.15600380f, -0.29359347f, -0.11772811f, -0.03693893f, 0.01906099f, 0.00799254f, -0.19147044f, -0.15191054f, 
    -0.01366897f, 0.01904935f, -0.17688124f, -0.02257695f, 0.12539326f, -0.02598673f, 0.10127830f, 0.30080202f, 
    0.46395287f, 0.12109035f, 0.20381647f, -0.19025548f, 0.04442618f, 0.20508009f, 0.13904965f, 0.05666305f, 
    0.04698109f, -0.00397067f, 0.00610616f, -0.07504179f, -0.03144650f, -0.64743811f, 0.07428082f, 0.10161509f, 
    0.05779145f, -0.04067685f, -0.02858532f, 0.17235464f, 0.07149292f, -0.11325067f, 0.34667391f, 0.05450223f, 
    0.04689362f, 0.36169508f, -0.17866910f, -0.29560509f, 0.01397100f, 0.13376386f, 0.04672161f, 0.04899497f, 
    -0.15038779f, 0.00799246f, 0.28538683f, 0.01769447f, 0.17793021f, -0.40194276f, 0.44519600f, -0.06617957f, 
    -0.15493076f, -0.02281846f, -0.06603976f, -0.02147882f, 0.19440408f, -0.12027105f, -0.02331001f, -0.04763786f, 
    0.01436112f, -0.26699811f, -0.48731270f, -0.42722532f, 0.05349139f, 0.09578503f, 0.02649544f, 0.06772296f, 
    0.15543847f, -0.08971582f, 0.14243078f, -0.01224849f, -0.36099237f, -0.09129205f, -0.08563145f, 0.24482915f, 
    0.04404900f, -0.07459148f, -0.10474902f, 0.03268505f, 0.10934485f, -0.00233871f, 0.49468094f, 0.15378284f, 
    -0.33893856f, -0.27150491f, -0.11116283f, 0.00248301f, 0.02138091f, 0.09501036f, -0.07079720f, -0.13718040f, 
    0.02534621f, -0.07410561f, 0.03712302f, 0.03484977f, -0.08838481f, -0.12940694f, 0.47504178f, -0.22098117f, 
    -0.05314304f, 0.03622092f, 0.04044001f, -0.08421895f, -0.05719854f, -0.05554536f, 0.04434104f, 0.05489833f, 
    -0.23208714f, 0.03978147f, 0.24743192f, -0.22379157f, -0.07882941f, -0.16379231f, -0.26069430f, -0.18933809f, 
    -0.09102301f, -0.00839659f, 0.00256880f, -0.13365504f, -0.24052654f, 0.16818362f, 0.06594215f, -0.21262841f, 
    0.30058706f, -0.09698103f, 0.18134873f, 0.09726344f, 0.06923050f, -0.02866083f, 0.01148046f, 0.17081030f, 
    0.04106684f, 0.10812862f, -0.08791686f, 0.13235228f, -0.08518565f, -0.03862621f, 0.18758267f, -0.13209131f, 
    0.25024056f, -0.14370939f, -0.01553814f, -0.07306773f, 0.15670745f, 0.24797133f, 0.16454820f, 0.10020736f, 
    0.19913632f, 0.13333444f, 0.08146799f, 0.08986064f, 0.14603326f, 0.11705194f, 0.03476804f, 0.17054245f, 
    0.22831979f, 0.02182373f, -0.54565507f, -0.17498946f, -0.03087925f, 0.11922725f, -0.07568289f, 0.36824909f, 
    0.15531865f, -0.20612623f, 0.04612171f, -0.10201468f, -0.03436721f, 0.04054901f, -0.08790844f, -0.01763254f, 
    0.34180287f, 0.00398121f, -0.02746035f, -0.02233815f, -0.01638396f, 0.04311197f, 0.16489851f, -0.03529939f, 
    -0.00812081f, 0.05612021f, 0.04925982f, -0.19099039f, 0.33995101f, 0.18449844f, 0.09507629f, -0.21178369f, 
    0.10172246f, -0.06500948f, -0.02302514f, 0.02792099f, 0.33756852f, 0.07530902f, 0.18011609f, 0.00996085f, 
    -0.04844612f, 0.00764697f, -0.08210702f, 0.01038692f, -0.03117847f, -0.06781761f, -0.13747716f, -0.01490190f, 
    -0.15623143f, -0.22176696f, -0.02816959f, -0.05034945f, -0.00217119f, -0.02479824f, -0.00071789f, -0.01912050f, 
    -0.03103593f, -0.06347064f, -0.14399812f, 0.06496786f, -0.18536171f, -0.01420329f, 0.02255389f, -0.37421793f, 
    -0.01007926f, 0.03431663f, 0.11151957f, 0.06090387f, -0.04607682f, -0.46661070f, -0.32660636f, -0.57114565f, 
    0.31115487f, -0.20033035f, 0.29572663f, -0.19257379f, -0.12381618f, 0.01716660f, 0.04704289f, 0.02851801f, 
    0.15508991f, 0.00856185f, 0.01191858f, 0.00683573f, -0.01735849f, 0.01549303f, 0.25025555f, -0.31742477f, 
    -0.05385464f, -0.09413357f, 0.04629075f, 0.23167434f, -0.05037219f, 0.06887211f, -0.10776443f, -0.02674227f, 
    -0.31359604f, 0.29256627f, 0.61923587f, 0.15184930f, -0.06314078f, -0.03628568f, 0.01927522f, 0.02607488f, 
    -0.06751889f, 0.15331043f, -0.02408120f, 0.06905150f, 0.15448987f, 0.25503111f, -0.07599659f, -0.07593249f, 
    -0.19103797f, -0.10324778f, -0.04856823f, -0.04875332f, 0.03758623f, -0.01336049f, -0.12207730f, -0.10057534f, 
    -0.07084703f, 0.02968444f, 0.27276915f, 0.30792072f, 0.04230570f, -0.07148903f, -0.22028029f, 0.13234086f, 
    0.01678097f, 0.26776397f, 0.19523583f, 0.07414804f, -0.25183898f, 0.41966000f, 0.30415756f, 0.00206500f, 
    -0.07865619f, 0.03597671f, -0.02975409f, 0.09135375f, 0.14444090f, 0.00595167f, 0.15040919f, -0.09813573f, 
    0.08494296f, -0.33372980f, -0.23191594f, 0.01268931f, -0.05088030f, 0.04666767f, 0.08281635f, -0.00517410f, 
    -0.03669660f, 0.04329221f, 0.13705091f, -0.00395536f, 0.30091545f, -0.03540098f, 0.04996275f, 0.01297872f, 
    -0.00749703f, -0.00305241f, 0.15313222f, 0.11531544f, 0.18663034f, 0.16466093f, -0.07824346f, -0.22546127f, 
    -0.28388792f, -0.32030866f, 0.17909643f, -0.61125129f, -0.00449187f, 0.21025488f, 0.16180480f, -0.17821893f, 
    -0.05484915f, -0.06557611f, -0.02117979f, 0.09927221f, -0.29184619f, 0.03526003f, -0.08857591f, -0.05722823f, 
    -0.20957899f, -0.39675984f, 0.12015811f, 0.03580952f, -0.01318158f, 0.14559551f, -0.14344454f, -0.11370371f, 
    -0.78581941f, -0.97559255f, 0.00605369f, 0.53077251f, 0.08993888f, 0.08560142f, -0.09508532f, -0.19129726f, 
    0.02336038f, -0.02123364f, -0.00463182f, 0.02026602f, 0.26174685f, -0.10523026f, -0.05237329f, 0.08972558f, 
    0.00679508f, 0.16779673f, 0.01207683f, 0.11683309f, 0.06214924f, -0.02181417f, 0.06622642f, -0.23128375f, 
    -0.14700405f, -0.05072254f, -0.30037934f, 0.01249570f, -0.15137915f, 0.09778096f, 0.48910382f, 0.18278246f, 
    0.16901730f, 0.02266510f, 0.01380613f, 0.07867588f, 0.19252802f, 0.03946913f, -0.23988621f, 0.29853892f, 
    0.02348198f, -0.49444115f, 0.16415694f, 0.15885668f, 0.06444085f, 0.02914507f, -0.12382486f, -0.22633259f, 
    -0.51223135f, -1.41940904f, -0.48197642f, -0.04775232f, 0.22780907f, 0.25357798f, -0.14257635f, -0.31312168f, 
    -0.01677042f, 0.05788773f, 0.01549825f, 0.00705993f, -0.16644323f, 0.08311758f, 0.02773317f, 0.12671959f, 
    -0.01505285f, 0.10092033f, -0.09067753f, 0.13432489f, 0.03636546f, 0.09975416f, 0.07831787f, 0.03484547f, 
    -0.41637853f, 0.01141255f, 0.42680919f, 0.17081189f, -0.10659256f, -0.05507188f, 0.18941019f, -0.31752351f, 
    -0.21128768f, 0.07059930f, -0.08084510f, -0.01321744f, -0.27315775f, -0.41324237f, -0.20419799f, 0.60140669f, 
    0.04457016f, 0.16805945f, 0.05334264f, 0.05791061f, 0.09130351f, -0.03168006f, 0.03063997f, 0.03764216f, 
    0.00270941f, -0.01120261f, -0.10996035f, -0.22825381f, 0.18072216f, -0.06262748f, 0.06698795f, -0.06256557f, 
    0.03959426f, 0.11752030f, -0.19768068f, -0.02004982f, 0.04127781f, 0.05318036f, -0.00786832f, -0.00147468f, 
    -0.00467734f, 0.07074996f, -0.04264094f, -0.09011751f, 0.05509090f, 0.05188230f, 0.00167730f, 0.19620639f, 
    -0.17860812f, -0.30431250f, -0.13830012f, 0.05780759f, 0.02503836f, 0.13984206f, -0.01957230f, 0.01719230f, 
    -0.02216464f, -0.13340768f, -0.09360092f, -0.06504055f, -0.24616158f, -0.37310624f, 0.11629518f, 0.35890910f, 
    0.14114828f, 0.10466752f, -0.17259851f, 0.04426249f, 0.02420246f, 0.03890253f, 0.01580420f, 0.13739343f, 
    -0.48309407f, -0.44338983f, -0.34404305f, 0.11433551f, -0.03750483f, 0.12411287f, 0.04391433f, -0.21289231f, 
    0.09404316f, -0.03830522f, -0.01550402f, 0.08916117f, -0.49564052f, -0.51742393f, -0.55783188f, 0.05835604f, 
    -0.12138537f, -0.31379816f, -0.15992002f, -0.18126166f, -0.04916571f, 0.00159778f, -0.03173406f, -0.04916908f, 
    -0.02628510f, -0.40565801f, 0.30048755f, 0.03999981f, -0.01027280f, 0.03585077f, 0.09266225f, -0.18321797f, 
    -0.01691410f, -0.04973595f, 0.16537878f, 0.24434033f, -0.51739252f, -0.60789686f, -0.39925745f, -0.23938701f, 
    -0.15583566f, -0.34719428f, 0.06248723f, -0.51192290f, -0.04295228f, 0.03205281f, -0.08382663f, -0.01517845f, 
    0.71534109f, 0.51053053f, -0.22420599f, -0.06581336f, 0.01651340f, -0.09797957f, 0.05238328f, 0.06588515f, 
    0.20270859f, 0.15770033f, 0.11460880f, -0.16400905f, -0.11261258f, -0.49134147f, -0.24347226f, -0.20232797f, 
    0.00127479f, 0.12139191f, 0.09207591f, -0.19436510f, 0.00210950f, -0.00077898f, -0.09902503f, 0.08576757f, 
    -0.87890512f, -1.16443872f, -0.54347265f, -0.48420969f, -0.26503012f, -0.24737160f, -0.25368097f, -0.53010762f, 
    -0.04121115f, 0.05266033f, -0.10827184f, 0.00731308f, 0.20707509f, 0.04628582f, -0.09428708f, -0.30426070f, 
    0.01826648f, -0.07593034f, -0.04936527f, -0.01969667f, -0.11573935f, 0.15602688f, 0.01649173f, -0.01571212f, 
    -0.05262935f, -0.05266221f, -0.06314792f, -0.08983662f, 0.02820865f, 0.07805981f, 0.02043095f, 0.01548379f, 
    -0.12363416f, -0.09605527f, -0.20725606f, -0.06355827f, -0.01298167f, -0.16466188f, 0.05985463f, 0.22367837f, 
    0.06917594f, 0.02672218f, 0.12655054f, -0.01946838f, 0.09099034f, 0.18636204f, 0.27104917f, 0.18459907f, 
    -0.64572793f, -0.67230618f, -0.57015562f, 0.11560407f, -0.07930922f, 0.00844469f, 0.02038299f, -0.20045033f, 
    -0.00900624f, -0.02556233f, 0.00548924f, 0.09004969f, -0.73845553f, -0.52434349f, 0.52340615f, -0.00894909f, 
    -0.19790506f, -0.17549881f, 0.11995908f, 0.12798765f, -0.05481060f, -0.05952906f, 0.09869077f, 0.04011811f, 
    0.44835341f, -0.84666044f, -0.53692883f, -0.42006373f, -0.10368931f, -0.22333579f, -0.07247137f, 0.15227258f, 
    0.20111901f, 0.10492665f, -0.07563259f, 0.05516613f, -0.10284757f, 0.04410380f, 0.00815882f, -0.04798087f, 
    0.08739483f, -0.37126762f, -0.01762496f, -0.04293847f, -0.06932694f, 0.02248585f, 0.04114180f, 0.10433564f, 
    0.52446085f, -0.20277181f, 0.27094465f, -0.51611352f, -0.05602345f, 0.12890080f, -0.05800332f, 0.05207370f, 
    0.06950893f, -0.21467172f, 0.00541073f, -0.18218513f, 0.59964490f, -0.40634784f, -0.26898092f, -0.36766833f, 
    -0.00677699f, -0.17053555f, -0.03601477f, -0.04788958f, 0.26732606f, 0.07142656f, -0.01858669f, -0.13789721f, 
    0.63056260f, -0.52444965f, -0.16154794f, -0.43752274f, 0.06920892f, 0.00835784f, -0.21802814f, 0.14510430f, 
    0.08524955f, 0.01360585f, 0.01809135f, 0.17545445f, 0.00602650f, 0.04189254f, -0.10683402f, 0.02193383f, 
    -0.04268046f, 0.01083963f, 0.18275838f, -0.18761756f, 0.19209941f, -0.02488316f, -0.03038811f, 0.11887360f, 
    -0.41098261f, 0.54961437f, -0.44578174f, 0.07579107f, -0.20634650f, -0.13035339f, 0.04870998f, 0.00810543f, 
    0.12385182f, 0.02854966f, 0.08091894f, 0.04941352f, 0.07893095f, -0.04039200f, 0.23745012f, 0.03023206f, 
    -0.01214946f, 0.07511114f, 0.09604695f, 0.04374745f, -0.02342329f, -0.02461976f, -0.07521616f, 0.00496514f, 
    -0.60147989f, -0.52715349f, 0.47735640f, 0.14109553f, 0.19454001f, 0.23046638f, 0.11898505f, 0.07020979f, 
    0.06754597f, 0.09744461f, 0.02274675f, -0.01006315f, 0.02356019f, -0.15393987f, 0.02697678f, -0.22106932f, 
    -0.00387944f, 0.05784401f, 0.00262782f, -0.04955016f, 0.03559651f, -0.01001734f, -0.19916153f, -0.10820588f, 
    -0.12629631f, -0.39023069f, 0.00580804f, -0.25860927f, 0.03235027f, 0.14227112f, 0.12124073f, -0.08270060f, 
    -0.06864592f, -0.07259598f, -0.09543579f, -0.11420418f, -0.47663599f, -0.33427987f, -0.04198175f, -0.22512135f, 
    -0.17697307f, 0.10591307f, 0.29359019f, 0.02999135f, -0.00822109f, -0.00594922f, 0.10775369f, -0.04425530f, 
    -0.10516965f, -0.73197097f, 0.46312633f, 0.28257090f, -0.12161870f, 0.12549339f, 0.10810122f, 0.01202466f, 
    0.07927347f, -0.03645743f, -0.01639684f, -0.03256226f, 0.28207359f, -0.07773002f, 0.03573365f, -0.32008243f, 
    -0.03885967f, -0.04386394f, -0.07076120f, -0.08963636f, -0.12712251f, -0.07900591f, -0.03607185f, -0.32766798f, 
    -0.03925782f, 0.17744297f, 0.15537027f, -0.10685293f, 0.02169590f, -0.07710846f, -0.09147885f, 0.14491752f, 
    -0.03359192f, -0.10843375f, -0.11896166f, -0.02446714f, 0.27244806f, -0.39764181f, 0.09893869f, -0.31379673f, 
    -0.03001182f, 0.16970859f, -0.02713289f, -0.01374979f, 0.06526073f, 0.10399162f, 0.03441788f, -0.24280253f, 
    0.00501269f, -0.03713667f, 0.20997266f, -0.21832849f, 0.08368234f, -0.08019677f, 0.01411295f, -0.08675940f, 
    0.03485449f, -0.09920175f, 0.06838068f, -0.15004480f, 0.21064055f, 0.11626096f, 0.02872893f, -0.01308344f, 
    0.05180462f, -0.05290439f, -0.01465195f, -0.03313857f, -0.01914834f, -0.01253402f, -0.09627074f, -0.24537592f, 
    -0.01624485f, 0.06327104f, 0.05383543f, -0.05991941f, -0.03258001f, -0.08203848f, 0.03060692f, 0.04329471f, 
    0.09625093f, 0.00049597f, 0.05832186f, -0.01933063f, 0.54101360f, -0.66758615f, 0.26418906f, -0.59918219f, 
    0.05239557f, -0.06574507f, -0.05089742f, 0.18957944f, -0.05954639f, -0.06490325f, 0.02256999f, 0.03090978f, 
    -0.43266585f, -0.29005963f, 0.40286207f, -0.54745436f, 0.00816063f, -0.05774328f, -0.03322870f, 0.17113324f, 
    -0.23890664f, -0.03122512f, 0.01823141f, -0.00321642f, -0.39857426f, -0.20543624f, -0.30473313f, 0.04959020f, 
    0.19820042f, -0.08104521f, 0.18011636f, 0.04833257f, 0.09312797f, 0.01996704f, -0.03625708f, -0.03353003f, 
    0.07382122f, 0.20871188f, 0.22892952f, 0.22662668f, -0.00887747f, 0.07580652f, 0.04676420f, -0.09989970f, 
    -0.09559913f, -0.08678529f, -0.14043455f, -0.07174201f, -0.60789490f, 0.18682484f, 0.27188537f, 0.09651223f, 
    -0.06757185f, -0.18475372f, -0.15980521f, 0.15843441f, -0.08749370f, -0.08158323f, -0.09980784f, 0.03229623f, 
    -0.41735709f, 0.30107993f, -0.18336199f, 0.28409556f, -0.05372693f, -0.04363568f, 0.19628473f, 0.10258780f, 
    -0.15171158f, 0.00124671f, -0.07823329f, 0.00359074f, -0.75006133f, 0.21628217f, 0.01808481f, 0.00921047f, 
    0.16774835f, -0.10671611f, -0.22915788f, -0.03506285f, 0.02767133f, -0.13344702f, -0.01549091f, -0.01129295f, 
    -0.38127485f, -0.42437232f, 0.01482744f, -0.01149957f, 0.00744495f, 0.15312986f, -0.14671463f, 0.13212268f, 
    -0.03527068f, 0.02234137f, -0.02769442f, -0.00962006f, 0.03876182f, -0.16150323f, -0.30953431f, 0.01237712f, 
    0.08478273f, -0.08848002f, -0.03145499f, -0.07804552f, -0.04933289f, 0.13512979f, -0.15972500f, -0.10581349f, 
    0.02221323f, 0.08222713f, 0.07263158f, -0.07948931f, -0.02087211f, -0.00521506f, 0.01987091f, -0.00800276f, 
    0.03740375f, -0.01597166f, 0.00553295f, -0.04960700f, -0.23749918f, 0.10574698f, 0.19519642f, 0.11663543f, 
    0.07691998f, -0.16624360f, -0.02136741f, 0.01570618f, -0.12610586f, 0.12135696f, 0.23199640f, -0.08922140f, 
    -0.27213019f, -0.37731880f, 0.23051375f, -0.35020891f, 0.15893869f, -0.09215666f, 0.05967587f, -0.10420115f, 
    -0.03349254f, 0.04059654f, 0.01833092f, 0.03130684f, 0.22924972f, -0.58962166f, -0.10382049f, -0.29396051f, 
    0.07705035f, -0.03492977f, 0.06798302f, -0.09893600f, -0.09000257f, 0.12271787f, 0.05421950f, 0.01677390f, 
    -0.38277218f, -0.32088992f, -0.28505707f, 0.09264033f, 0.03906955f, 0.14121278f, 0.11855379f, 0.13865481f, 
    -0.10544779f, 0.11135741f, -0.15543237f, -0.22180934f, -0.00157528f, -0.08344521f, -0.01574514f, -0.03148221f, 
    0.01809889f, 0.15829743f, 0.02064081f, 0.06290372f, 0.01522120f, 0.09911141f, 0.10148207f, 0.14061846f, 
    -0.26108852f, -0.01868259f, -0.51031607f, 0.16560529f, 0.02311191f, 0.00476260f, 0.02333147f, 0.08836532f, 
    0.24445018f, 0.25048268f, -0.01654476f, 0.27700010f, 0.11328920f, -0.27062729f, -0.42247862f, -0.18972304f, 
    -0.05366259f, 0.01953882f, 0.03071497f, 0.03288942f, -0.06780434f, -0.11840417f, -0.05275554f, -0.38417140f, 
    -0.26778445f, 0.22344543f, -0.40531698f, -0.05159043f, 0.02406611f, -0.05737438f, 0.15270892f, 0.20975624f, 
    0.01291277f, 0.23750563f, -0.11791253f, -0.08142074f, -0.31355146f, -0.12406742f, -0.10492951f, 0.05850224f, 
    -0.16199560f, 0.17172566f, 0.00645585f, 0.08747847f, -0.40493602f, -0.06519400f, -0.12733765f, -0.23182696f, 
    -1.09674191f, -0.05885011f, 0.21590877f, 0.44048691f, 0.14954558f, -0.10648327f, -0.02783782f, -0.09441113f, 
    -0.12421600f, -0.12788831f, 0.05952333f, -0.06801134f, -0.02506269f, -0.24314916f, -0.32755375f, -0.08695839f, 
    0.22197799f, 0.13585064f, 0.05950041f, -0.06588222f, 0.24345070f, 0.26462361f, 0.14974879f, 0.26108262f, 
    0.48744556f, -0.10786730f, -0.20937288f, -0.12314124f, -0.17316470f, -0.06925578f, 0.14594436f, -0.04503958f, 
    -0.01515747f, 0.04150005f, 0.06060142f, 0.07573517f, 0.34424192f, 0.14454515f, -0.01716137f, -0.10657459f, 
    0.10170756f, 0.02605413f, 0.03216456f, -0.12292431f, -0.07519145f, 0.01854438f, 0.09780522f, -0.22742616f, 
    0.13384520f, -0.11829636f, 0.01978967f, 0.08857979f, 0.05614013f, 0.26832998f, 0.24023145f, 0.09182093f, 
    -0.02907327f, -0.11514703f, -0.17305158f, -0.22786127f, -0.72346282f, -0.51450562f, -0.08776432f, 0.48610979f, 
    0.11639128f, 0.02174086f, 0.04991077f, 0.00593942f, 0.00105132f, 0.11175979f, 0.07473403f, 0.22600654f, 
    0.67933536f, 0.09428295f, -0.12179296f, -0.75574785f, -0.01868352f, -0.15894634f, 0.00833876f, -0.20065334f, 
    -0.00306626f, 0.03582699f, 0.02672090f, 0.01501708f, -0.03084696f, 0.10050108f, -0.15247647f, -0.02020839f, 
    0.06975212f, -0.00912121f, 0.12544453f, -0.00835899f, 0.23200569f, 0.07996467f, 0.13325727f, 0.16877319f, 
    -0.02626364f, 0.18004180f, -0.06713893f, 0.18246999f, -0.19191459f, 0.05640876f, 0.14896442f, 0.02458859f, 
    0.06996576f, -0.13477533f, -0.06223975f, 0.06412201f, 0.51676577f, 0.01226609f, 0.00412971f, -0.55111098f, 
    -0.06523051f, -0.18973413f, -0.09399851f, -0.14450112f, -0.08593003f, 0.17204978f, -0.00335681f, 0.20962326f, 
    -0.71356714f, -0.01231223f, 0.29908887f, -0.11164539f, -0.14298202f, -0.00495811f, 0.01280820f, -0.05237430f, 
    -0.08625497f, -0.03937464f, 0.02976677f, 0.14627957f, 0.06102625f, 0.12774074f, 0.14104383f, -0.08754776f, 
    -0.11533280f, -0.01981374f, 0.08457942f, 0.00581663f, 0.03010854f, 0.04717886f, -0.03629382f, 0.15615322f, 
    -0.10228753f, 0.09513359f, 0.07415030f, -0.03652404f, -0.16708113f, -0.00987046f, -0.02771018f, 0.02969338f, 
    0.10417140f, 0.03375717f, 0.00735419f, 0.04004927f, 0.26315573f, 0.40107605f, 0.11665776f, -0.20763804f, 
    0.05643278f, -0.27761921f, -0.13986559f, 0.06298932f, 0.02654187f, 0.08003760f, 0.05860875f, -0.03555540f, 
    0.10042527f, -0.03731675f, -0.05989546f, -0.04267582f, 0.24951270f, -0.03150139f, 0.01022307f, -0.04338785f, 
    0.02061466f, 0.02362059f, -0.10438398f, -0.08053227f, -0.40013403f, -0.56746799f, -0.28601176f, -0.03743985f, 
    -0.00174714f, 0.19228004f, 0.01016781f, -0.19296604f, -0.05747538f, -0.05457596f, -0.04523041f, -0.02727175f, 
    -0.32420549f, -0.24425736f, -0.02137340f, 0.32457778f, 0.01580942f, 0.00887390f, -0.08248935f, 0.09764464f, 
    -0.13153811f, 0.15511335f, 0.11113428f, -0.11526255f, 0.47261298f, -0.33633748f, -0.50462478f, -0.36656550f, 
    -0.10692926f, -0.09510849f, 0.11019448f, -0.07237859f, 0.08392923f, 0.07883820f, 0.14495684f, 0.05455297f, 
    -0.83098614f, 0.02564509f, 0.36678821f, 0.18192054f, -0.04825589f, 0.17040902f, -0.04777358f, 0.03626033f, 
    0.03211035f, -0.11550532f, -0.14276113f, 0.24078684f, -0.12046205f, -0.04117145f, -0.05980555f, 0.21892957f, 
    0.00838249f, 0.06692521f, 0.02880234f, -0.28505558f, -0.01568636f, 0.07643826f, -0.01606551f, 0.03261840f, 
    -0.53625536f, -0.88181287f, -0.40561906f, -0.15661325f, -0.03503419f, -0.20473406f, 0.04775625f, 0.07147588f, 
    -0.10665780f, -0.08580475f, -0.06453836f, 0.01185927f, 0.55453616f, 0.20698521f, 0.08069316f, -0.10530005f, 
    -0.10633817f, -0.04775932f, -0.00723773f, 0.03120913f, 0.18072617f, 0.07862288f, 0.13078061f, 0.10543057f, 
    -0.14189434f, 0.00913996f, -0.03802174f, -0.02438543f, -0.06813005f, 0.04218327f, 0.03422287f, -0.02018977f, 
    -0.02058069f, 0.00189836f, -0.01664848f, -0.01255721f, 0.04378073f, -0.16001117f, 0.10635691f, 0.02834378f, 
    -0.08065153f, 0.04110857f, 0.00892466f, -0.09905460f, -0.15069452f, -0.02563968f, -0.14895539f, -0.45622370f, 
    0.81760830f, 0.17495587f, 0.02745100f, -0.05239128f, -0.04747202f, 0.02894146f, -0.14071737f, -0.41678062f, 
    0.01926503f, -0.10912696f, 0.02061689f, -0.05359511f, -0.38038757f, -0.74816722f, -0.53297770f, -0.43552861f, 
    0.22134230f, 0.03278755f, 0.10248355f, 0.08589263f, -0.26631588f, 0.05023844f, -0.04810939f, 0.00187392f, 
    -0.14876184f, -0.10879776f, 0.06124496f, -0.22616936f, -0.00354675f, 0.04909696f, -0.10866912f, -0.17217962f, 
    -0.05393679f, -0.02588431f, 0.00322271f, 0.21300873f, -0.15992709f, 0.01976098f, 0.25060144f, -0.17242442f, 
    0.21649542f, 0.00467967f, -0.03998036f, -0.02748879f, 0.12109035f, 0.09520289f, -0.13780084f, -0.01729243f, 
    0.08022012f, 0.17247824f, 0.04127296f, -0.00798120f, -0.43288168f, 0.02617276f, -0.09677029f, -0.27713579f, 
    0.02211027f, -0.12189405f, -0.08330619f, 0.00267667f, 0.06691691f, 0.11566178f, 0.55845308f, 0.66562396f, 
    0.16309640f, -0.11283318f, -0.22067897f, -0.13686727f, -0.01099134f, 0.11575038f, 0.09133258f, -0.11925209f, 
    -0.29831633f, 0.45582423f, 0.12822223f, 0.56139368f, -0.00127825f, 0.05481138f, -0.30256262f, -0.00212817f, 
    0.19553061f, -0.06665102f, 0.01996471f, 0.08316685f, -0.37947938f, 0.55931973f, 0.26781610f, -0.20614308f, 
    -0.11612529f, -0.12917890f, 0.09138705f, -0.16963729f, 0.07116476f, 0.29426721f, 0.19886078f, 0.07754853f, 
    -0.52743387f, 0.32686195f, -0.81184149f, 0.25917229f, 0.25776184f, -0.37095958f, 0.13486505f, -0.15677398f, 
    0.05936056f, -0.03120132f, -0.07425028f, -0.01887558f, 0.10111991f, 0.08548824f, -0.11502223f, 0.11462171f, 
    0.04577728f, -0.03272001f, -0.25067589f, 0.04837357f, 0.02803344f, 0.07749165f, -0.16917410f, -0.16293731f, 
    0.51167685f, -0.77689916f, 0.09490962f, -0.32317486f, -0.08801955f, -0.16419116f, -0.02890890f, 0.11970909f, 
    0.03236372f, 0.02937082f, 0.00497990f, -0.09246085f, -0.05271656f, -0.29164249f, -0.22902083f, 0.15514073f, 
    0.05940057f, 0.07246837f, 0.00674763f, -0.21299048f, 0.04797625f, 0.10258865f, -0.05309721f, 0.06371787f, 
    0.06470159f, -0.03749039f, 0.11930087f, -0.04030695f, -0.23787183f, -0.15124707f, -0.24563596f, -0.09266897f, 
    -0.05501512f, 0.04453053f, 0.03636932f, 0.06110813f, -0.09564208f, 0.07808498f, 0.39426044f, -0.92833108f, 
    0.07480609f, -0.22608659f, 0.21954101f, 0.09554542f, -0.16947503f, 0.04203142f, -0.06230621f, 0.05744214f, 
    0.06097753f, -1.17329395f, -0.13200225f, 0.11615561f, -0.14333101f, 0.07670713f, -0.17454411f, 0.11730102f, 
    -0.05687664f, 0.07979258f, 0.03789071f, 0.01496073f, -0.01490140f, -0.07615988f, 0.39479312f, 0.15983453f, 
    -0.07505645f, 0.01022311f, -0.08039580f, -0.17806251f, 0.18923368f, -0.06676697f, -0.14817879f, 0.10332404f, 
    0.00905880f, -0.17459349f, 0.06234247f, 0.05137220f, 0.13678971f, 0.06660221f, -0.46160591f, 0.07832018f, 
    0.13890588f, 0.14181696f, -0.09348676f, 0.05229272f, 0.12397248f, -0.59702724f, 0.20188478f, -0.09000058f, 
    0.04561903f, 0.16460262f, -0.01740134f, -0.20022513f, -0.15476671f, 0.00303733f, 0.01732776f, -0.14968993f, 
    0.29039165f, -0.34436876f, 0.23781179f, -0.18350935f, -0.00747028f, -0.00304592f, -0.01915185f, 0.04526777f, 
    -0.04910737f, 0.08573552f, 0.02887942f, -0.22367908f, -0.14920144f, -0.19550125f, 0.06471771f, 0.24769127f, 
    -0.06139371f, 0.29106775f, -0.19789073f, -0.09428922f, 0.09608928f, -0.24085835f, -0.23995185f, -0.09366430f, 
    0.42994064f, -0.42708546f, -0.21043545f, 0.01353487f, 0.37028855f, 0.31525013f, 0.17510816f, 0.15189047f, 
    0.00234915f, -0.11443879f, -0.04732069f, -0.09787480f, -0.13884279f, -0.70850164f, -0.10700525f, -0.10951707f, 
    -0.06697895f, 0.17640673f, 0.10286310f, 0.08612195f, 0.04929834f, 0.13267536f, 0.01763232f, -0.04525281f, 
    0.01281838f, 0.09281587f, 0.22400580f, -0.25471407f, -0.36823010f, 0.18644354f, 0.14183134f, 0.17842545f, 
    0.06969859f, 0.03209631f, 0.04870398f, 0.04394779f, -0.25098714f, -0.02163494f, 0.19360124f, -0.07458554f, 
    -0.26317289f, -0.10358551f, -0.04505833f, -0.06974115f, 0.02182146f, 0.06962742f, 0.01478266f, 0.03775261f, 
    -0.19833030f, 0.11531196f, -0.15489699f, -0.85281754f, 0.04433117f, -0.03831366f, 0.02512931f, 0.15833429f, 
    -0.01835542f, 0.04795742f, 0.13299908f, 0.29398215f, -0.53079998f, -0.03752775f, 0.13415517f, -0.15781707f, 
    -0.10660626f, 0.04338301f, 0.01341828f, 0.14804067f, 0.02475670f, -0.03062643f, 0.09528735f, -0.02259034f, 
    -0.19227012f, 0.07655915f, 0.47994745f, -0.64252645f, 0.03006121f, -0.17938414f, 0.05179231f, 0.15663026f, 
    -0.14132690f, 0.04960727f, 0.02136490f, -0.14224678f, 0.35936180f, 0.33154127f, -0.45742130f, -0.12465234f, 
    -0.07820260f, -0.08230999f, 0.08964497f, 0.27880710f, -0.08636062f, -0.01749404f, -0.06538976f, -0.13416456f, 
    -0.46163148f, 0.04646900f, -0.06906853f, 0.10522814f, -0.14491184f, -0.01986132f, 0.20430131f, 0.38759834f, 
    -0.01104977f, 0.02676718f, 0.00685289f, 0.04386618f, -0.55839795f, 0.00441534f, 0.02720288f, 0.30097386f, 
    0.15229261f, -0.06691349f, -0.04961837f, 0.11313608f, 0.01611841f, 0.01609532f, 0.06363044f, -0.01298031f, 
    -0.08351448f, -0.38202733f, -0.00188676f, 0.02579976f, 0.16062593f, 0.09509344f, 0.16291149f, -0.00732608f, 
    0.03189557f, 0.07869232f, 0.07852104f, 0.13067976f, 0.09829467f, -0.15552978f, 0.33868867f, -0.46399859f, 
    0.03599773f, 0.02754693f, -0.16495255f, 0.06557675f, 0.19142552f, 0.31794327f, 0.01282415f, 0.20185490f, 
    0.06822567f, -0.80937785f, -0.58362275f, -0.06921493f, 0.30099139f, -0.05918511f, 0.05044509f, 0.18621562f, 
    -0.05592408f, 0.05762050f, 0.00074273f, -0.04283347f, 0.05428049f, 0.42077875f, 0.04902185f, -0.62160712f, 
    -0.15046504f, -0.15110742f, -0.04130392f, -0.19610986f, -0.01470427f, -0.04576580f, -0.05989033f, 0.08755557f, 
    0.19069767f, -0.05228253f, -0.10365895f, -0.23240067f, 0.08362181f, -0.06575479f, -0.07876977f, 0.06000886f, 
    -0.10447393f, 0.11326779f, -0.21501809f, -0.52158588f, -0.15930793f, -0.23967190f, 0.09312905f, 0.34560913f, 
    -0.14340700f, 0.19558366f, -0.06549983f, 0.14727770f, 0.01136525f, 0.09921373f, 0.08189912f, 0.11076093f, 
    0.30996206f, 0.28793284f, -0.14047539f, 0.11136177f, 0.01528666f, -0.17252818f, 0.13206786f, -0.17648344f, 
    -0.19582884f, 0.33160281f, -0.09622002f, 0.05849274f, -0.25109637f, -0.01683517f, -0.03751247f, 0.12684368f, 
    0.02342421f, -0.04800268f, -0.14919549f, 0.02897723f, 0.06456106f, -0.03870266f, -0.15378815f, 0.04547580f, 
    0.13094404f, -0.20505741f, -0.31387788f, -0.20040210f, -0.12443018f, -0.02220931f, 0.26802132f, 0.05047118f, 
    -0.28789452f, 0.06414483f, -0.05492327f, -0.59723914f, 0.34620863f, -0.42866060f, 0.19374880f, 0.11984320f, 
    -0.05540774f, -0.29130724f, 0.21646360f, 0.07076492f, -0.30017605f, -0.15246524f, -0.26555538f, 0.00658805f, 
    0.21394698f, -0.45844191f, -0.16298701f, 0.04367547f, -0.21709357f, 0.13325244f, 0.13280314f, -0.11146499f, 
    -0.21727569f, 0.02380523f, -0.01772575f, -0.07053512f, -0.32756165f, 0.27678332f, 0.47033158f, 0.26208302f, 
    -0.04134832f, 0.20138657f, -0.07250758f, 0.00621798f, -0.01322749f, -0.22962743f, 0.45165697f, 0.36964661f, 
    -0.33685464f, 0.01474870f, -0.23179413f, 0.27934885f, -0.09293358f, 0.09242998f, 0.07897324f, -0.37323770f, 
    -0.00492399f, 0.09006897f, -0.00837156f, 0.04430667f, -0.07302999f, -0.02132080f, 0.26411572f, 0.25788829f, 
    -0.14728650f, 0.21056889f, 0.17720041f, -0.03340267f, -0.08220144f, 0.07152580f, -0.13171837f, -0.00028876f, 
    -0.33199769f, 0.25307375f, 0.04078383f, 0.02285924f, 0.06203421f, -0.04895795f, 0.12268704f, 0.19808447f, 
    -0.06522885f, -0.12368501f, -0.17783521f, -0.35615811f, 0.21712461f, 0.16519211f, 0.35887209f, 0.22030632f, 
    -0.21720636f, 0.08543426f, 0.14156909f, -0.06776790f, 0.11345994f, -0.00651920f, 0.15312620f, 0.27867919f, 
    -0.38501340f, -0.19183013f, -0.40324557f, 0.17814334f, -0.08114971f, 0.40304518f, -0.06168245f, 0.19666620f, 
    -0.03814198f, 0.04199522f, -0.07509749f, 0.06984197f, -0.90867680f, 0.18960433f, -0.01305500f, -0.20232935f, 
    -0.01135471f, -0.10770322f, 0.08143188f, -0.08530339f, -0.07915583f, 0.09011780f, 0.24604587f, -0.05253624f, 
    0.09720361f, -0.02177789f, 0.19078572f, 0.20770809f, 0.11314144f, 0.24172039f, -0.09439534f, 0.18678011f, 
    -0.12518692f, 0.00988646f, -0.04886467f, -0.26708850f, -0.62302089f, 0.04265152f, -0.53612870f, 0.09050449f, 
    -0.25676924f, 0.24001572f, 0.22650377f, -0.09114497f, 0.00125851f, -0.06121273f, -0.13352849f, 0.21778145f, 
    -0.14365278f, 0.35924825f, 0.13816252f, 0.42281958f, 0.16220272f, 0.05637699f, 0.16633712f, 0.06100331f, 
    0.08220194f, 0.02392121f, 0.10568849f, 0.04700335f, -0.11695088f, -0.11916182f, 0.47690141f, -0.36447421f, 
    -0.10375446f, 0.06143334f, 0.00945615f, 0.07367635f, 0.02042242f, 0.04482562f, 0.05780632f, 0.19787097f, 
    -0.15459673f, -0.59766662f, -0.37912273f, -0.14046749f, -0.21056059f, -0.08977661f, -0.15727162f, 0.11666947f, 
    -0.06116877f, 0.10736306f, 0.07929502f, -0.07450006f, -0.38295850f, 0.03785742f, -0.43303248f, 0.33282083f, 
    0.01636834f, 0.18686961f, 0.26006299f, -0.05633225f, -0.10033537f, -0.25349054f, -0.19138056f, 0.02235215f, 
    0.03657650f, 0.02280805f, -0.19796084f, -0.26726693f, 0.04944853f, 0.07496737f, 0.08476050f, 0.01156276f, 
    0.21708323f, -0.23244281f, -0.05052044f, -0.14273641f, -0.01644746f, -0.29021040f, -0.25771666f, 0.17496091f, 
    -0.06158945f, -0.02544206f, -0.00571715f, 0.14958787f, 0.08560213f, -0.01218447f, -0.05811103f, -0.01001859f, 
    -0.02378735f, -0.02379114f, 0.12056231f, 0.14122461f, -0.06962854f, -0.07994504f, 0.11740258f, 0.15214440f, 
    0.01433420f, 0.02376824f, -0.30075875f, -0.17955595f, -0.00165283f, -0.42040116f, 0.05470911f, 0.11150211f, 
    -0.18714410f, 0.21044800f, -0.12241244f, 0.28633508f, 0.09591104f, 0.00571418f, 0.10918510f, -0.08441941f, 
    -0.03716948f, -0.16416311f, -0.07431657f, 0.48128307f, 0.09576807f, -0.06847798f, -0.29013416f, 0.08768289f, 
    -0.14754625f, -0.03504663f, -0.10637660f, 0.08578379f, -0.03579451f, -0.38535452f, 0.42189020f, 0.49575657f, 
    0.07551001f, 0.07871114f, -0.18001367f, 0.04548067f, 0.03341659f, -0.05496125f, 0.15902950f, 0.15728246f, 
    -0.34503299f, 0.34217390f, -0.53902173f, 0.01142684f, 0.04213532f, -0.21451615f, -0.18715307f, -0.26965034f, 
    -0.13541150f, 0.16211526f, -0.10820924f, 0.13610731f, -0.13981357f, -0.16194265f, 0.11797202f, 0.05629694f, 
    -0.25639099f, 0.19343053f, -0.22040913f, -0.01379118f, 0.08599736f, -0.24481995f, -0.16829076f, 0.20778926f, 
    0.02227009f, -0.47074300f, -0.48590690f, -0.29737625f, -0.28419006f, -0.32319227f, -0.02190387f, -0.08279905f, 
    0.03340336f, 0.04205899f, -0.08616810f, -0.09468680f, 0.02788195f, 0.35298893f, 0.33024392f, -0.16063708f, 
    0.07710554f, -0.00666439f, -0.15860568f, -0.06390975f, -0.11720294f, -0.46242687f, -0.49245569f, -0.52803302f, 
    -0.51680094f, 0.00245567f, -0.37412474f, 0.07077452f, 0.10930681f, 0.09645707f, -0.40177774f, 0.24466497f, 
    -0.09885968f, 0.08281930f, 0.05587132f, -0.04875293f, 0.13539733f, -0.08145322f, -0.08527606f, -0.10902321f, 
    -0.07644443f, -0.18318185f, 0.30334461f, 0.06718986f, -0.17469700f, -0.04940437f, 0.16948107f, -0.04917197f, 
    -0.37286690f, 0.17081478f, -0.62805915f, -0.18563034f, 0.00836992f, -0.18762353f, 0.06291370f, 0.09463733f, 
    -0.04200519f, 0.07161342f, 0.02413168f, 0.04073427f, -0.12260100f, 0.02029617f, 0.12156855f, 0.22760122f, 
    -0.03573320f, -0.01573884f, 0.11475606f, 0.10558383f, -0.16923341f, -0.16018888f, -0.21351743f, -0.26995781f, 
    -0.28778225f, -0.24193522f, 0.06232633f, 0.30235294f, 0.06226532f, 0.01261097f, 0.20800602f, -0.09955400f, 
    -0.17256863f, -0.17497034f, -0.02811695f, -0.16622497f, -0.69542497f, -0.34832206f, -0.25104150f, -0.13134331f, 
    0.11654743f, -0.06856851f, 0.12988597f, -0.10531583f, -0.16650303f, 0.09792181f, 0.40454462f, 0.12645720f, 
    -0.13124648f, 0.15443744f, 0.07322418f, 0.09855363f, 0.15887439f, 0.22859026f, 0.17282751f, -0.24221098f, 
    0.00385898f, 0.03538314f, 0.30109528f, 0.13115463f, -0.12783271f, -0.00960233f, 0.16233073f, -0.13364087f, 
    -0.09694727f, 0.07387062f, 0.04820532f, 0.01916146f, -0.00847921f, -0.16507183f, 0.16116232f, -0.13785236f, 
    0.96419287f, -0.28177121f, 0.53641647f, -0.57124162f, -0.04873377f, -0.00524466f, -0.45778185f, 0.27791405f, 
    -0.16480485f, 0.06742549f, 0.00797459f, -0.03369689f, -0.07134303f, -0.10903168f, 0.07434906f, 0.02513047f, 
    0.04994646f, -0.19527850f, 0.34849045f, 0.13049096f, -0.10318025f, -0.15043770f, -0.13817979f, -0.41094181f, 
    -0.53822732f, 0.17470436f, -0.13200733f, 0.19195697f, -0.24379893f, -0.12842631f, 0.19768564f, -0.20799769f, 
    0.07888204f, 0.02104367f, 0.07244018f, 0.07382844f, 0.16602969f, 0.17622021f, -0.00935966f, 0.03925867f, 
    -0.03367870f, -0.15813182f, 0.12745103f, 0.04893456f, 0.05181572f, 0.00432421f, 0.07276414f, 0.09692366f, 
    -0.18555228f, 0.34650710f, -0.22677544f, -0.22831504f, 0.06500585f, -0.21798071f, 0.10061255f, 0.07759337f, 
    0.16938064f, 0.17730927f, 0.08712473f, 0.07012778f, -0.23488455f, 0.03118834f, -0.06131688f, 0.01228647f, 
    0.07513465f, 0.03182243f, -0.23213774f, 0.10747426f, -0.11233165f, 0.05608281f, -0.10093688f, -0.27634215f, 
    -0.55603981f, 0.12562348f, -0.09650990f, 0.16813698f, -0.08675161f, -0.37380233f, 0.18597957f, 0.04779739f, 
    0.12674311f, 0.08695855f, 0.00457724f, 0.03786966f, -0.06589578f, -0.01989491f, -0.38085994f, 0.09031627f, 
    0.08123462f, 0.08177670f, 0.18009412f, 0.01327179f, 0.08299249f, 0.04449402f, 0.04472411f, -0.09555162f, 
    -0.44996062f, 0.32407480f, -0.20536990f, 0.15946054f, -0.07640620f, -0.05626391f, 0.04611644f, -0.12685055f, 
    -0.02294703f, 0.04226947f, 0.11106217f, 0.08310011f, -0.35369760f, 0.42103752f, -0.19358988f, -0.10761115f, 
    0.11737114f, -0.04370228f, -0.04727332f, -0.07869627f, -0.00436510f, -0.03343012f, 0.16427524f, 0.00747114f, 
    -0.00169873f, -0.01726891f, -0.07867208f, 0.67482895f, -0.18085814f, 0.08718847f, 0.02799208f, 0.22257628f, 
    -0.35514593f, 0.06824022f, 0.10911388f, 0.04894414f, -0.10208263f, 0.17996618f, -0.10255471f, -0.21456778f, 
    -0.05793897f, 0.02035867f, 0.05380612f, -0.09204833f, 0.05736251f, -0.05245595f, 0.13615875f, -0.04400390f, 
    0.46365553f, 0.54282278f, 0.10948710f, -0.35648927f, -0.10763953f, 0.12229872f, -0.03414018f, 0.10749528f, 
    -0.13506821f, 0.06297007f, -0.07444752f, -0.05582172f, -0.27816650f, 0.03335157f, -0.04824493f, 0.34491706f, 
    0.02274965f, -0.10585865f, 0.11851002f, -0.30186957f, -0.05506365f, -0.02328925f, 0.06576930f, -0.12899932f, 
    -0.28935760f, -0.19280297f, -0.03260485f, 0.09879504f, -0.19779775f, -0.30943087f, 0.03539796f, -0.17286688f, 
    0.08656604f, 0.07821660f, -0.14331928f, 0.02193906f, 0.04835042f, -0.11589339f, 0.16449268f, -0.29109710f, 
    -0.03188712f, 0.00729168f, -0.16259766f, -0.02833798f, 0.06649596f, 0.00678146f, -0.01372929f, -0.15110736f, 
    -0.35550731f, 0.24881962f, 0.17617120f, -0.45573169f, 0.00130771f, 0.06709005f, 0.03771556f, -0.13666499f, 
    0.05317673f, 0.16115619f, 0.16178186f, 0.19863054f, 0.03957842f, -0.46317860f, 0.09167501f, 0.21693026f, 
    -0.13225307f, -0.21795629f, -0.17032339f, -0.23878287f, 0.03603220f, -0.07353365f, -0.04502017f, -0.05652424f, 
    -0.26545414f, -0.18877491f, 0.34317386f, -0.00988846f, -0.03315901f, 0.12776943f, 0.10513831f, 0.22659488f, 
    -0.18977292f, 0.08031321f, 0.18678205f, 0.09391962f, 0.11493717f, -0.11127006f, 0.80299646f, -0.02657492f, 
    -0.07353373f, -0.05072626f, -0.16873600f, -0.16559002f, -0.03165742f, -0.02498916f, -0.00122960f, -0.09622864f, 
    0.16119500f, -0.55655015f, 0.04368886f, -0.03527969f, 0.04163487f, -0.07340086f, -0.36718741f, -0.22125162f, 
    0.05056994f, -0.04258238f, 0.01340290f, -0.11218300f, -0.03608003f, 0.04327820f, -0.04603951f, 0.19072114f, 
    0.17059956f, 0.00837090f, -0.00948353f, -0.02045683f, 0.00398765f, 0.03229319f, 0.09618540f, 0.27708068f, 
    0.27110106f, 0.16858788f, 0.20084511f, -0.25503024f, -0.03585092f, 0.05228173f, -0.02809440f, 0.10029025f, 
    -0.12338745f, -0.00655578f, 0.01096665f, -0.18802272f, -0.55201131f, 0.40694195f, -0.53635716f, 0.26651096f, 
    0.02739860f, 0.17872724f, 0.02209695f, 0.05044470f, 0.09297209f, 0.12131873f, 0.12184387f, 0.16917594f, 
    0.36431029f, 0.07833593f, 0.22859876f, -0.10687873f, -0.17396289f, -0.08217321f, -0.14519522f, 0.18226427f, 
    -0.05674337f, 0.02265347f, 0.01030275f, -0.01744002f, -0.22005232f, -0.08715733f, -0.25549290f, 0.05628388f, 
    -0.24131925f, -0.17836387f, 0.00118343f, -0.18709944f, 0.23941238f, -0.04301104f, -0.17314932f, -0.06615906f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17010118f, 0.13755114f, 0.12004319f, -0.15608294f, -0.08772629f, 0.06692439f, 0.09606318f, -0.16919944f, 
    0.08920074f, 0.04144379f, 0.03977109f, -0.05136181f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
