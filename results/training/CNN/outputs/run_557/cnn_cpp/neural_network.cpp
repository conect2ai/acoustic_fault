#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.34906504f, -0.55416179f, -0.52570212f, 0.54399937f, 0.11400694f, 0.60756528f, -0.28256720f, -0.05863283f, 
    -0.27730545f, 0.55264771f, -0.00849857f, 0.45606995f, 0.61593831f, -0.11121307f, 0.03381472f, 0.26099086f, 
    0.07840946f, -0.05710222f, 0.07438476f, -0.55896044f, -0.36510631f, -0.15846418f, 0.15810029f, -0.23630275f, 
    -0.04162595f, 0.37738129f, 0.06692282f, 0.47895494f, 0.23414618f, -0.10230642f, 0.53803998f, 0.23327683f, 
    0.61059314f, -0.07892565f, -0.06037106f, 0.01157967f, 0.43167126f, 0.60076553f, 0.55162930f, -0.22021958f, 
    0.21474966f, -0.42173642f, -0.22219214f, -0.18180382f, -0.24618955f, 0.06705434f, -0.10025521f, 0.03516679f, 
    -0.63719708f, -0.10547025f, -0.60435796f, 0.27563506f, -0.12619634f, 0.03758054f, -0.59181803f, 0.33635136f, 
    0.42659619f, 0.52042907f, 0.44736740f, 0.29750082f, -0.05092073f, -0.18752222f, -0.20936652f, -0.67711014f, 
    -0.22003263f, -0.04050602f, -0.38734365f, 0.20434886f, -0.02474206f, -0.27099577f, 0.06926057f, -0.33754084f, 
    0.32142282f, 0.37917858f, -0.47440612f, -0.43507907f, 0.00350929f, -0.44716054f, 0.16298954f, 0.19820823f, 
    0.02667201f, -0.45736730f, 0.64712530f, -0.03653045f, -0.06829668f, -0.25234562f, -0.33174905f, -0.12089663f, 
    0.09110098f, -0.13748297f, 0.61693019f, 0.43709812f, -0.56359583f, 0.50562775f, -0.18926297f, 0.01610368f, 
    -0.04974966f, 0.08948971f, -0.00338557f, 0.57013828f, 0.29414529f, 0.24894074f, 0.27298424f, 0.46269086f, 
    0.26915655f, -0.11900499f, -0.05737846f, -0.24126066f, 0.05620970f, 0.17164095f, 0.12477408f, -0.39154083f, 
    0.32674482f, 0.21046330f, 0.00327722f, 0.32491985f, 0.39099425f, 0.65291804f, 0.73855263f, 0.68440080f, 
    -0.28553206f, -0.24127309f, -0.25406367f, 0.12918510f, 0.29366058f, 0.39523917f, 0.56653303f, -0.47262138f, 
    -0.29833204f, 0.08936553f, -0.49500033f, 0.02926279f, -0.25805834f, -0.26681420f, 0.44857207f, -0.66606665f, 
    -0.64320123f, 0.10704681f, 0.20996802f, -0.17851265f, 0.29750821f, 0.06593273f, 0.04821082f, 0.19899769f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.20697129f, -0.04231932f, 0.05158279f, -0.40984711f, 0.26118663f, -0.07228611f, -0.32950613f, 0.24144220f, 
    0.09738592f, -0.05902190f, -0.00324749f, -0.35223383f, -0.00875585f, -0.31198204f, -0.17902525f, 0.02016593f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.28167030f, -0.25424117f, 0.17448512f, 0.10266604f, -0.04826097f, 0.12389748f, -0.06205539f, 0.00600759f, 
    0.07560124f, 0.27177355f, -0.10023666f, -0.27032456f, -0.12360550f, 0.25661358f, 0.08201136f, -0.11680686f, 
    0.12072253f, -0.02711952f, 0.01748858f, -0.08992361f, 0.06578968f, 0.05346514f, 0.02209517f, -0.00380110f, 
    0.11981938f, -0.20925494f, -0.04075987f, -0.07505171f, 0.07609227f, 0.21381196f, -0.03929834f, 0.05196437f, 
    0.15072489f, 0.04185436f, -0.08630537f, 0.14330071f, 0.21312234f, 0.20174994f, -0.25486857f, -0.09125524f, 
    -0.17744394f, 0.19821633f, 0.18605250f, 0.04918581f, 0.12514997f, 0.02037737f, -0.07345080f, -0.33256903f, 
    0.20611225f, 0.03335845f, 0.12406714f, 0.10338908f, 0.09840177f, -0.02966571f, -0.30418625f, -0.31953949f, 
    -0.28758070f, -0.07321636f, 0.04731275f, -0.03424425f, -0.10839953f, 0.11212871f, -0.01129394f, -0.32775685f, 
    0.00029777f, 0.13368315f, 0.01106064f, 0.16139935f, -0.13873167f, 0.03901602f, 0.10112888f, 0.21883093f, 
    0.11163015f, 0.01065450f, -0.18273160f, -0.04657232f, 0.07233343f, -0.09955192f, 0.01519389f, 0.01973380f, 
    0.08576924f, -0.23375361f, -0.02363181f, -0.19231862f, 0.07961972f, -0.11534423f, 0.03323385f, 0.00411767f, 
    -0.04617767f, 0.03411062f, 0.18249264f, 0.34260604f, 0.19208747f, 0.03482752f, -0.05764761f, -0.01551897f, 
    -0.04029142f, 0.05135079f, -0.06345151f, 0.28179690f, 0.02908580f, 0.16819188f, 0.09064099f, 0.07636410f, 
    -0.27423307f, 0.00332533f, -0.10777508f, -0.03376515f, -0.16006204f, 0.10502133f, 0.04952521f, -0.03510385f, 
    -0.17358226f, 0.13545536f, 0.04461647f, -0.05272654f, -0.16535731f, 0.10678948f, 0.31787658f, -0.02324680f, 
    0.06076520f, -0.12811303f, -0.08652408f, 0.02133757f, -0.03893209f, -0.18830135f, 0.20067516f, 0.00261463f, 
    0.02864186f, 0.04324995f, 0.02489235f, 0.10397218f, 0.01039523f, -0.10978361f, -0.05626125f, 0.14090492f, 
    -0.17855382f, 0.02167319f, -0.03913692f, 0.00429348f, 0.01931292f, -0.15303023f, 0.00009865f, -0.07827570f, 
    0.06757208f, -0.08693735f, 0.07143015f, -0.09618397f, 0.07436940f, -0.16205543f, 0.01884034f, -0.07975603f, 
    -0.03852470f, -0.03881521f, -0.22689722f, -0.21508265f, -0.01547550f, 0.08871001f, 0.06134269f, 0.01861793f, 
    0.03610022f, 0.00961392f, -0.02794732f, 0.06053254f, -0.26892677f, 0.04810259f, -0.15120399f, -0.16585104f, 
    -0.15194190f, 0.13304755f, -0.18046528f, -0.35442260f, -0.25183403f, -0.18138212f, 0.11901414f, 0.01798040f, 
    0.16538252f, -0.19037458f, -0.02878338f, 0.03033012f, 0.26656410f, -0.18705830f, 0.03077525f, 0.08345269f, 
    0.06825999f, 0.08153941f, 0.01215236f, -0.05484265f, 0.13541512f, 0.02444508f, 0.04850833f, -0.20131382f, 
    0.31796765f, 0.11063892f, 0.06842256f, 0.00542270f, 0.01528187f, 0.07022647f, -0.24731463f, -0.22032139f, 
    0.00980610f, -0.01608282f, 0.03583248f, -0.06012095f, -0.15454027f, 0.16023163f, 0.08646705f, -0.38470483f, 
    0.27352434f, 0.02444602f, -0.04570127f, -0.07394667f, 0.01757518f, -0.16221021f, -0.08295205f, 0.11113143f, 
    0.07021640f, 0.11469702f, -0.27442855f, 0.00976395f, 0.01761282f, 0.06597282f, -0.12707859f, -0.01544186f, 
    -0.06542456f, 0.18080257f, -0.09162638f, 0.05240880f, 0.06153293f, 0.08885248f, -0.02673835f, 0.03804426f, 
    -0.00366820f, -0.12650014f, 0.18096974f, -0.01793772f, 0.18875700f, 0.08092188f, -0.05600446f, -0.08544731f, 
    -0.02367626f, 0.05380660f, 0.08588488f, -0.25282839f, -0.16131967f, -0.17121324f, 0.09612408f, 0.00283747f, 
    0.04813145f, 0.09003530f, 0.04038635f, 0.02721990f, -0.00226456f, 0.04194680f, 0.05541444f, -0.08674425f, 
    -0.04555554f, -0.04406259f, 0.02683971f, -0.03806566f, -0.12567672f, 0.46407035f, 0.04742626f, 0.00736720f, 
    0.20597677f, -0.18341179f, 0.04172630f, 0.07982793f, 0.10257656f, -0.00380838f, 0.27134183f, -0.03325157f, 
    -0.29667905f, 0.06026729f, -0.14862238f, 0.03630018f, 0.25560531f, 0.02404252f, -0.06270920f, -0.12572002f, 
    0.10428316f, -0.11115421f, 0.01586398f, 0.03202512f, 0.14449839f, -0.09363793f, 0.02345786f, 0.15019181f, 
    -0.07457331f, 0.02036758f, -0.02155646f, -0.06538285f, -0.02998463f, -0.01892024f, -0.04141590f, -0.09065446f, 
    -0.08667775f, -0.06533310f, -0.00311344f, -0.05695011f, 0.06180569f, -0.00355220f, 0.00766105f, 0.03428934f, 
    -0.02228724f, -0.02569593f, -0.02290230f, 0.05075423f, -0.02562513f, -0.06470235f, 0.03949515f, -0.01494147f, 
    0.03165364f, 0.05574873f, -0.01441688f, -0.08880108f, 0.00093982f, 0.05423298f, -0.07594582f, -0.04894326f, 
    0.00515465f, -0.01602086f, -0.08157659f, 0.01142988f, 0.01598670f, -0.06864432f, -0.03231499f, 0.04597871f, 
    -0.00755422f, 0.04703569f, 0.06385557f, 0.06169407f, 0.02990708f, -0.02356461f, -0.06029949f, 0.05378112f, 
    0.01990765f, 0.05666632f, -0.08809379f, -0.02312023f, 0.05632729f, -0.10765032f, -0.01593398f, -0.08073471f, 
    -0.03844023f, -0.05164541f, -0.00389125f, -0.02633938f, 0.01154566f, 0.03469693f, -0.02109233f, -0.05041502f, 
    -0.02346859f, -0.07017051f, -0.03790964f, 0.03169462f, 0.05842201f, -0.09808357f, -0.07867572f, -0.05208962f, 
    -0.05169163f, -0.04092211f, -0.09400091f, -0.02228337f, -0.03670283f, -0.03646128f, 0.05503444f, -0.03473314f, 
    -0.05898722f, -0.08609605f, 0.06711775f, 0.03336359f, 0.04146389f, -0.04076205f, -0.02518228f, -0.06585527f, 
    -0.07274318f, 0.06412859f, -0.08034128f, -0.03797443f, 0.07341801f, 0.00543630f, -0.06884135f, -0.05219439f, 
    0.06594703f, -0.01057882f, 0.03186701f, -0.06234984f, 0.00833493f, -0.02488122f, -0.02980717f, 0.03209220f, 
    -0.08157597f, 0.06176898f, -0.05371780f, 0.02626118f, -0.08381440f, 0.00226063f, -0.03150654f, 0.06220356f, 
    -0.02979215f, -0.06805772f, 0.00121145f, -0.07429814f, 0.04097665f, -0.06731724f, -0.07113215f, -0.06582459f, 
    0.00531666f, 0.06347463f, -0.07268114f, -0.06884228f, -0.05971610f, -0.06173111f, -0.06686276f, -0.08518236f, 
    0.00986580f, 0.06586649f, 0.04060612f, -0.06259118f, 0.02206456f, -0.04179865f, 0.04022321f, -0.05011096f, 
    0.00426655f, 0.02492643f, -0.00017690f, -0.07777219f, 0.06962412f, -0.00756881f, 0.03380583f, 0.01319305f, 
    0.29851958f, 0.17652428f, 0.20835745f, 0.14575902f, 0.19772975f, -0.01187954f, 0.02041146f, -0.04849075f, 
    0.22954108f, 0.00858836f, -0.00912465f, -0.10876296f, 0.00133155f, -0.08815535f, -0.02555016f, -0.06378153f, 
    0.07353743f, 0.03477279f, 0.13447167f, 0.22077739f, 0.17714585f, 0.03313304f, -0.06399583f, -0.01549952f, 
    -0.02422158f, 0.05042737f, -0.26826665f, 0.23367946f, 0.08244774f, 0.14195910f, -0.13592546f, -0.05128122f, 
    -0.07537711f, 0.21429594f, 0.10329445f, -0.02578338f, -0.21097623f, -0.14141007f, -0.03096728f, -0.00421517f, 
    -0.02936675f, 0.06288218f, -0.07823620f, -0.07240411f, 0.00321968f, 0.12482794f, -0.19258721f, 0.00572282f, 
    -0.21602543f, 0.09640945f, 0.04557237f, -0.08249571f, -0.03725308f, -0.14996018f, -0.03500337f, -0.15575431f, 
    0.08075362f, 0.01931448f, 0.09094168f, -0.01457256f, 0.01628697f, -0.01875422f, 0.16255935f, 0.22484374f, 
    0.12803409f, 0.31166145f, 0.23757814f, 0.01785046f, 0.12589712f, -0.04709097f, 0.02808025f, 0.02348634f, 
    -0.25367600f, 0.05961362f, -0.05498280f, 0.04656067f, -0.17156638f, -0.10700131f, -0.00935553f, -0.00534564f, 
    -0.12089562f, 0.05916370f, -0.23529617f, -0.09787553f, -0.05113751f, -0.00225130f, -0.12812920f, 0.02411856f, 
    0.12569892f, -0.06533185f, 0.34151706f, 0.22563967f, 0.15033045f, -0.11932801f, -0.14104666f, -0.02140150f, 
    0.00758036f, 0.02964800f, 0.00911309f, -0.05043206f, 0.05849566f, -0.06283031f, 0.11569899f, -0.03050370f, 
    0.00492560f, 0.03753582f, 0.04512625f, 0.00695415f, -0.19356270f, 0.08616333f, -0.02698506f, -0.01791210f, 
    -0.08134113f, -0.01202520f, -0.12269888f, -0.14196128f, -0.13735680f, -0.09320839f, -0.08461972f, -0.18065993f, 
    -0.12605475f, -0.12218013f, -0.08998702f, -0.15033403f, 0.12857741f, -0.04187274f, 0.25723198f, 0.05030805f, 
    -0.10221042f, -0.00147079f, -0.10672621f, -0.03370970f, 0.08104421f, -0.02707073f, -0.11326503f, 0.05762320f, 
    -0.01997872f, 0.13241008f, 0.10014702f, -0.04433054f, 0.14133124f, 0.00465911f, -0.02751881f, -0.06359440f, 
    -0.02541620f, 0.03741766f, -0.24821424f, 0.07420456f, -0.15107554f, 0.04682111f, 0.06721896f, 0.00306371f, 
    -0.14600068f, 0.07523582f, 0.07171842f, 0.19238724f, -0.19192129f, 0.07361232f, -0.03023271f, 0.04843734f, 
    0.03435915f, 0.16631214f, -0.35631549f, -0.17401050f, -0.01985333f, 0.10545747f, 0.02133464f, 0.17536207f, 
    -0.12384401f, 0.05833183f, -0.07427523f, 0.05650882f, 0.05585256f, 0.08332495f, 0.00755226f, -0.17984629f, 
    -0.15492944f, 0.18440494f, -0.15988274f, 0.11265880f, -0.01805650f, -0.12883852f, 0.09310025f, 0.06956015f, 
    -0.18566780f, -0.04616903f, -0.08100606f, 0.05434063f, 0.06497097f, 0.05392719f, 0.07509088f, -0.09321938f, 
    0.11640718f, 0.11233644f, 0.17674641f, -0.11110234f, 0.10335696f, -0.00513091f, 0.06061496f, 0.05727324f, 
    0.11376008f, 0.08055414f, -0.11417445f, -0.32638508f, 0.07400198f, 0.03338655f, 0.05381593f, -0.11233445f, 
    -0.04423125f, -0.08736956f, 0.05136795f, 0.05886561f, -0.01399238f, 0.10645276f, 0.02434463f, -0.10532717f, 
    -0.01731161f, 0.08553695f, -0.07710482f, -0.01533073f, -0.05779849f, 0.00210435f, -0.15887353f, 0.02649092f, 
    -0.08176173f, 0.05405010f, -0.33557323f, -0.04910812f, 0.19618663f, -0.02195002f, -0.04375011f, 0.01237054f, 
    -0.09291150f, -0.03335795f, -0.01118337f, 0.24338005f, -0.03934927f, -0.05462438f, 0.00635877f, -0.10560674f, 
    0.03724644f, 0.13184591f, -0.05594688f, 0.26682585f, 0.05860014f, 0.08257271f, -0.03311602f, -0.27866301f, 
    -0.30058411f, -0.00147098f, -0.03066705f, 0.10826573f, 0.17651778f, 0.19600299f, -0.12902927f, -0.05986719f, 
    -0.07243144f, 0.01506530f, 0.10138945f, 0.01063810f, 0.02713754f, 0.31049868f, 0.05528483f, 0.01045356f, 
    0.05081525f, -0.00565424f, 0.04694252f, 0.10226834f, 0.23372208f, -0.05146511f, 0.00339489f, -0.04469918f, 
    0.14236760f, 0.00825787f, 0.11774192f, -0.13418859f, -0.06971145f, -0.13925765f, -0.03716991f, -0.12980355f, 
    -0.02488065f, -0.04196790f, 0.16382463f, 0.05539268f, -0.00708519f, -0.10801160f, 0.07877598f, 0.03200462f, 
    0.31720406f, -0.20744324f, -0.56386369f, 0.08075234f, 0.20827161f, 0.06552985f, -0.18051316f, -0.06163228f, 
    0.13711929f, -0.01249289f, -0.11155794f, -0.11017267f, -0.00797797f, 0.10017778f, 0.04798406f, 0.15019703f, 
    -0.00756808f, 0.00945503f, -0.20290570f, -0.20909485f, -0.07838541f, -0.03836184f, 0.06525538f, 0.03800063f, 
    0.21635845f, -0.08240078f, -0.08748435f, -0.00866834f, -0.29812050f, -0.20326203f, 0.14472294f, 0.05627434f, 
    0.09682076f, 0.01219411f, -0.11788820f, 0.05033099f, 0.14901502f, 0.29643589f, -0.03735761f, -0.01887802f, 
    0.00519434f, 0.02550552f, 0.14548108f, 0.17412612f, 0.08871658f, -0.25385442f, -0.04657680f, 0.13215919f, 
    0.00076633f, 0.04272359f, 0.04804706f, 0.13937220f, 0.22587404f, -0.11851820f, 0.12398842f, 0.34816635f, 
    0.26920885f, -0.11357693f, 0.10964183f, -0.19127944f, -0.08549000f, 0.02046215f, 0.00854971f, 0.09853645f, 
    0.10029499f, 0.10642879f, 0.07204720f, -0.09749622f, 0.14403993f, 0.05404752f, -0.04112303f, -0.14984979f, 
    -0.24375211f, -0.04955370f, -0.01720693f, 0.08884333f, -0.04101800f, 0.02288124f, 0.01521630f, 0.02405515f, 
    0.20922570f, -0.11718224f, -0.10673811f, -0.33286479f, -0.03785119f, 0.02774579f, -0.27164194f, -0.02197304f, 
    -0.04574924f, 0.03558004f, -0.15911442f, 0.13200198f, -0.09853725f, -0.20872316f, 0.06853290f, 0.06570245f, 
    -0.12774318f, -0.07315999f, 0.13260940f, 0.23328838f, 0.06540610f, -0.34179854f, 0.01501377f, -0.05502123f, 
    -0.11971187f, 0.22421077f, 0.12563649f, 0.04814269f, 0.14901416f, 0.08570800f, -0.25451869f, 0.19075841f, 
    -0.09332962f, 0.12155510f, 0.03629588f, 0.06410123f, -0.07773719f, 0.33474642f, 0.07924947f, 0.08417603f, 
    -0.16372125f, -0.30219191f, -0.01077358f, -0.01570218f, -0.00448231f, -0.11396245f, -0.09650159f, -0.06635804f, 
    -0.04803833f, -0.11144906f, 0.09111083f, -0.08382656f, 0.12086162f, 0.03545376f, -0.06450868f, 0.15176028f, 
    0.36817285f, 0.07019689f, -0.03873716f, 0.13440862f, -0.10397549f, 0.05695898f, -0.08380561f, -0.12855069f, 
    0.01620431f, -0.07779151f, -0.02061963f, 0.05855034f, -0.06496423f, 0.03300583f, -0.01394473f, -0.06000918f, 
    -0.03808358f, -0.03680593f, -0.04394566f, -0.00280012f, 0.07661881f, -0.04638692f, 0.08137965f, -0.05553907f, 
    0.04783736f, -0.01366408f, -0.07691022f, -0.03609215f, -0.03476366f, -0.06079090f, 0.01923907f, 0.07604292f, 
    0.05794685f, 0.02049306f, -0.03897449f, 0.03445151f, -0.00074983f, -0.02421612f, -0.06860685f, -0.04994917f, 
    0.07855489f, -0.04001617f, -0.00615254f, -0.06253143f, -0.05874532f, 0.00100768f, -0.07100399f, -0.03674755f, 
    -0.01435299f, -0.05162905f, -0.07321998f, -0.00992846f, -0.00867894f, -0.06474629f, -0.04942623f, 0.02594236f, 
    0.00983524f, 0.07784646f, -0.04097983f, 0.00542262f, 0.00142958f, -0.06152514f, 0.00691254f, -0.05681651f, 
    -0.05758166f, -0.01510177f, -0.03307883f, -0.02100125f, -0.01073320f, 0.08205767f, -0.04023702f, -0.05818364f, 
    -0.06599337f, -0.06387319f, 0.06506147f, -0.00466462f, -0.06128449f, -0.07073610f, -0.02737856f, 0.07497838f, 
    0.00432409f, -0.03149688f, -0.00010505f, -0.05585337f, -0.04709402f, 0.07257785f, -0.05591274f, 0.05597309f, 
    -0.02200991f, -0.03678846f, -0.07494846f, 0.04247827f, 0.02273610f, 0.00012195f, 0.06629130f, 0.02490348f, 
    -0.04941719f, -0.08069776f, -0.02800095f, 0.08184902f, -0.03591903f, -0.05504459f, 0.05234041f, 0.05021563f, 
    -0.04354152f, -0.03762236f, -0.03379741f, 0.02410601f, -0.04665291f, -0.04299601f, -0.02001288f, -0.01634173f, 
    -0.03022238f, 0.02597376f, -0.05525933f, 0.06813477f, -0.00979573f, 0.03648387f, 0.04211724f, -0.00006611f, 
    0.06054864f, -0.00108386f, -0.08011489f, -0.04159704f, 0.07070621f, -0.01223720f, -0.02341783f, -0.07461154f, 
    -0.03174827f, 0.07802722f, -0.00113682f, -0.07036094f, 0.06941219f, -0.07998734f, 0.01275837f, -0.07780172f, 
    -0.01253974f, 0.06326613f, -0.06413558f, -0.06031087f, -0.00368360f, 0.05957712f, 0.00076433f, 0.00934642f, 
    0.03328108f, -0.04284669f, -0.01470918f, 0.06089018f, -0.01877543f, -0.07360765f, 0.01066757f, -0.02658982f, 
    0.14449270f, 0.15844846f, -0.03636046f, 0.02432744f, -0.00499600f, 0.02569938f, 0.18058304f, -0.15987687f, 
    -0.08841326f, 0.05567658f, 0.11273728f, 0.24653646f, 0.04396499f, 0.00896405f, -0.25527444f, -0.11095770f, 
    0.03270768f, -0.04948905f, 0.29016519f, 0.12097204f, 0.01888874f, 0.14663379f, -0.04024658f, 0.12725347f, 
    -0.11271755f, 0.01118504f, 0.06277683f, 0.20457675f, -0.26591706f, 0.00973837f, 0.13640308f, 0.10500193f, 
    0.03881885f, -0.01369608f, 0.02918242f, 0.00756961f, -0.13716631f, 0.01735252f, 0.14152054f, 0.06832869f, 
    -0.01130378f, 0.02303645f, -0.05368970f, -0.03280751f, -0.04046383f, -0.09903102f, -0.62024724f, -0.41890058f, 
    -0.08655506f, -0.04413800f, 0.15503001f, -0.04165550f, -0.00324369f, 0.14698595f, -0.13010344f, -0.07676425f, 
    0.04899037f, -0.01030548f, 0.14559342f, 0.07315420f, 0.10511117f, 0.09055974f, -0.09186191f, -0.07675055f, 
    0.17368846f, 0.13337305f, 0.12193164f, 0.07320008f, -0.14174685f, -0.09588087f, -0.02651452f, -0.11200067f, 
    0.06146628f, -0.43108729f, -0.26772791f, -0.00979592f, -0.01338530f, 0.05777590f, -0.06082226f, 0.00666548f, 
    0.02819426f, -0.34782115f, -0.17260259f, -0.13295947f, -0.07620227f, 0.04859434f, 0.00177215f, -0.04631548f, 
    0.01067532f, -0.11044512f, 0.11955881f, 0.02081721f, 0.03485096f, -0.12677564f, 0.02987825f, 0.06160903f, 
    0.02400371f, -0.07436036f, -0.05237069f, 0.16500300f, -0.10318810f, 0.08009290f, 0.08320211f, 0.04806211f, 
    -0.00852500f, -0.08479752f, -0.06532643f, 0.05292507f, -0.12420454f, -0.01509092f, 0.01850148f, -0.21884662f, 
    -0.21575099f, 0.04220756f, 0.11970617f, 0.20386779f, 0.05500021f, -0.14474760f, -0.21778381f, 0.15954979f, 
    0.15604131f, -0.04784964f, -0.20562461f, 0.05148576f, -0.02413754f, 0.13725688f, 0.09371154f, -0.02068315f, 
    -0.12495917f, 0.09951916f, 0.03399972f, 0.16516279f, 0.03699567f, -0.04520799f, -0.01570039f, -0.10652714f, 
    0.42899293f, 0.11399022f, 0.06160135f, -0.02721114f, -0.17239554f, -0.03277323f, -0.09844887f, -0.00968457f, 
    0.03487146f, -0.07925619f, -0.02832416f, -0.02060109f, -0.07449426f, -0.03207910f, -0.03670629f, -0.06137964f, 
    -0.00972930f, 0.02637313f, 0.05013244f, -0.08037922f, -0.01153731f, -0.00794625f, -0.04180123f, 0.05558955f, 
    0.05231719f, -0.04368011f, -0.06861615f, -0.08178467f, -0.09399886f, -0.08177659f, 0.04286825f, 0.00021138f, 
    0.04238163f, -0.08117041f, -0.05423505f, -0.01626062f, -0.05818603f, 0.01120588f, 0.04764240f, 0.02803592f, 
    -0.03442839f, 0.03816931f, -0.02884294f, 0.03161980f, -0.00062441f, -0.00422461f, 0.04159088f, 0.00767477f, 
    -0.03002864f, -0.05647893f, -0.07775538f, 0.02758273f, 0.03627024f, -0.08534426f, 0.04734443f, -0.02382041f, 
    -0.08517446f, -0.02579986f, 0.04238503f, 0.03417940f, -0.08624049f, -0.02829408f, 0.06525639f, 0.03318177f, 
    -0.02455750f, -0.05878130f, 0.00294822f, -0.05936849f, 0.06431115f, -0.08810890f, -0.05200610f, 0.04060909f, 
    -0.03945847f, -0.00798619f, -0.04615473f, -0.04873629f, -0.03233654f, 0.01382661f, -0.03330104f, -0.03093009f, 
    -0.02555015f, 0.05480839f, -0.08434337f, -0.08130721f, -0.06579613f, 0.01993138f, 0.01879543f, 0.04202733f, 
    -0.00498406f, -0.04276744f, -0.07927597f, -0.00959487f, 0.01644797f, -0.06798010f, -0.07352655f, -0.01745308f, 
    -0.08240797f, 0.02922460f, -0.07188528f, 0.01465300f, -0.08231752f, 0.06847194f, 0.02407144f, -0.08409054f, 
    -0.00865229f, 0.00187388f, 0.05598836f, -0.04427806f, -0.05889620f, 0.02436587f, -0.05908038f, 0.01945899f, 
    0.05981909f, -0.00588571f, -0.01820448f, -0.07646034f, -0.04178108f, 0.01239071f, -0.03245639f, 0.03616720f, 
    0.05771330f, 0.02936501f, -0.02501789f, -0.06287611f, -0.03836204f, -0.08780851f, 0.04839335f, -0.00154304f, 
    0.01486366f, 0.05305249f, -0.03422083f, -0.00612315f, -0.09281501f, 0.05478519f, 0.03135591f, -0.05792003f, 
    -0.01666468f, 0.04724177f, 0.02208009f, -0.07767484f, -0.01209791f, 0.04469112f, 0.05367409f, 0.03483980f, 
    -0.03422931f, 0.05017658f, 0.03608891f, -0.05313598f, 0.00126230f, -0.01107343f, 0.04058801f, -0.02402681f, 
    0.09423546f, 0.27544329f, 0.26160190f, -0.10074701f, -0.13405091f, -0.12285322f, 0.02901400f, 0.01066756f, 
    -0.03075096f, -0.18402271f, -0.09912588f, 0.06323523f, -0.08883034f, 0.08776136f, 0.02689779f, 0.16343321f, 
    0.01228586f, 0.12586743f, 0.26920164f, -0.19454375f, 0.28940558f, 0.04118593f, 0.04743879f, -0.07720952f, 
    0.01610507f, -0.06518035f, -0.17579640f, 0.01603857f, 0.14124042f, 0.07207737f, -0.08853469f, 0.04146951f, 
    0.01055868f, -0.00496929f, 0.02321238f, 0.14916228f, -0.04160685f, 0.06840352f, -0.07731946f, 0.18777485f, 
    0.06880992f, 0.12054475f, 0.01436474f, 0.04891670f, -0.10026460f, -0.10920467f, -0.03135211f, -0.09078927f, 
    0.02311701f, 0.14605531f, 0.07387660f, -0.12940840f, 0.15293680f, 0.01615072f, 0.45471999f, 0.09336179f, 
    -0.09993455f, -0.14556192f, 0.04829825f, 0.07568426f, 0.07775474f, 0.15098208f, 0.04762108f, 0.05473050f, 
    -0.26027170f, -0.51444614f, -0.02595446f, -0.02805992f, 0.08709251f, -0.07156645f, 0.08700664f, -0.01739596f, 
    0.11179927f, -0.00508215f, -0.20991957f, -0.00018243f, -0.01393069f, -0.08058477f, 0.03804325f, -0.03594050f, 
    -0.06121407f, 0.06876799f, -0.17215344f, -0.31813470f, -0.02431579f, 0.02615691f, 0.11835206f, -0.05362005f, 
    0.05330544f, -0.08963960f, 0.11503646f, -0.12755904f, -0.05855620f, 0.12960926f, -0.12093779f, 0.07685320f, 
    -0.10064331f, 0.07400078f, 0.01460484f, 0.06856652f, -0.03329011f, 0.17027318f, 0.00008673f, -0.00066569f, 
    0.13984501f, -0.05376874f, -0.00786436f, -0.02460540f, 0.25245598f, 0.17980975f, -0.20899773f, -0.07606988f, 
    -0.04614182f, 0.15866539f, -0.08967591f, 0.04055233f, 0.05495040f, -0.13461761f, 0.08570950f, 0.04538606f, 
    0.08474693f, 0.18967997f, 0.07812874f, -0.06732704f, -0.04013174f, -0.04086608f, -0.25405237f, -0.01804262f, 
    -0.10165013f, -0.03703984f, 0.06420454f, -0.00727780f, -0.07828843f, 0.00803919f, -0.22618495f, 0.15654869f, 
    0.17201149f, 0.11966296f, -0.20807908f, -0.34368628f, 0.01926740f, -0.05519775f, -0.00950263f, 0.10189005f, 
    -0.19818629f, 0.10961039f, -0.52437311f, -0.25408444f, 0.06613585f, 0.00428784f, -0.12854590f, -0.08694173f, 
    -0.06567997f, -0.32784268f, 0.14716262f, 0.26768750f, -0.00388090f, 0.15614662f, 0.07245736f, 0.16155699f, 
    0.01134554f, -0.01006700f, -0.04891508f, 0.02955055f, -0.39554730f, -0.01043398f, 0.09573389f, 0.01546600f, 
    0.04146051f, 0.00694525f, -0.17095533f, -0.18580820f, -0.04774839f, -0.04886958f, 0.12909134f, 0.15899883f, 
    0.12453062f, -0.11201007f, 0.04632722f, -0.00125149f, 0.15974145f, 0.13177624f, -0.01005740f, -0.01020420f, 
    0.01958934f, 0.29361606f, -0.00408350f, 0.10005813f, -0.10962348f, 0.23734023f, 0.13314004f, -0.19246323f, 
    0.05723052f, 0.04676428f, 0.05272056f, 0.04318821f, -0.08448204f, 0.03319550f, -0.28359303f, -0.24553141f, 
    0.03672465f, -0.17383793f, -0.00862161f, -0.14820524f, 0.04803404f, 0.02503411f, 0.04061214f, 0.04384575f, 
    0.00408730f, 0.02287494f, -0.04428387f, -0.11551978f, -0.04161390f, 0.02566591f, 0.15429954f, -0.02883214f, 
    0.12665933f, -0.02506189f, -0.01742457f, 0.11349603f, 0.02317357f, 0.09566427f, 0.02141882f, -0.05401460f, 
    -0.00750300f, 0.01058536f, -0.18575564f, -0.16406780f, 0.18738730f, 0.01388232f, 0.09969670f, 0.01064453f, 
    0.01798852f, 0.00477513f, 0.01734660f, -0.11148389f, 0.15800574f, 0.03340123f, -0.01239213f, -0.11037096f, 
    -0.13792183f, -0.02719857f, 0.08095451f, 0.09209260f, 0.10997500f, 0.01277892f, -0.08678731f, 0.07010555f, 
    -0.16963840f, 0.02766185f, 0.10208117f, -0.03773450f, 0.20127510f, -0.09308436f, -0.03523099f, 0.02507207f, 
    -0.22065529f, 0.00646675f, 0.07215832f, 0.02594834f, 0.12708402f, 0.30770189f, 0.15069768f, -0.10169924f, 
    -0.01355230f, -0.15257066f, 0.10937653f, -0.08261194f, -0.06195997f, 0.15404356f, -0.42484790f, 0.10632853f, 
    -0.12156077f, 0.09399541f, 0.06247535f, -0.06971993f, 0.14543696f, -0.02414557f, -0.04863969f, 0.03991023f, 
    -0.18810843f, 0.11530069f, -0.09813310f, 0.04763447f, 0.00670867f, 0.08225894f, 0.07880998f, 0.09074515f, 
    -0.15254335f, 0.14058487f, 0.03443632f, 0.01195772f, -0.09654996f, -0.19503416f, 0.11149377f, -0.06116897f, 
    -0.03115888f, 0.06708649f, 0.07604925f, 0.00077536f, -0.14428498f, -0.07360632f, -0.04166022f, 0.13794938f, 
    -0.03209645f, 0.08406204f, -0.07962665f, 0.13881397f, -0.13756858f, 0.06216887f, 0.04070417f, 0.03001434f, 
    0.00619877f, -0.26639950f, -0.00655658f, -0.08299963f, 0.14808767f, 0.02634542f, -0.00427822f, 0.01007819f, 
    -0.24222991f, -0.15479666f, 0.09014555f, 0.16746113f, -0.21402545f, 0.06545786f, -0.13197754f, 0.06346754f, 
    0.06693827f, 0.19719180f, -0.04750985f, 0.20514481f, 0.09411035f, -0.03792817f, -0.07275555f, 0.01171090f, 
    0.10669822f, 0.13995896f, 0.30437458f, 0.08886677f, 0.13925704f, -0.03029208f, 0.10516265f, -0.22943141f, 
    -0.10739341f, -0.15019476f, -0.06264719f, -0.11799394f, 0.03010904f, 0.07080787f, 0.18301344f, -0.01568072f, 
    0.03044907f, 0.06444855f, 0.12669015f, 0.15175416f, -0.02033299f, 0.01022242f, -0.01587938f, -0.06268653f, 
    -0.14776619f, -0.13163799f, 0.08890749f, -0.03275480f, 0.05491647f, 0.20787831f, 0.14859521f, -0.16432367f, 
    -0.00688945f, -0.27683371f, -0.07635225f, -0.17558594f, 0.11840324f, 0.08971254f, -0.05059748f, 0.09928449f, 
    -0.04900058f, 0.00245524f, -0.28383738f, 0.01879400f, -0.07426882f, 0.18003036f, 0.03246390f, 0.04888926f, 
    0.18083644f, 0.10887370f, 0.05476130f, 0.08279588f, -0.04606201f, -0.14162384f, 0.08144380f, -0.11765389f, 
    -0.26467133f, 0.12785926f, -0.03597751f, 0.14863786f, 0.07337900f, 0.12954672f, 0.03699125f, 0.00119640f, 
    -0.13752212f, -0.16831172f, -0.07940291f, 0.07290906f, 0.09250670f, -0.06230329f, 0.00345746f, -0.19810970f, 
    0.19337134f, -0.07624344f, -0.00235451f, -0.03692679f, -0.24556500f, 0.22673944f, -0.32348993f, -0.20778470f, 
    0.05882949f, -0.10482899f, -0.01790212f, -0.03829645f, 0.05383877f, 0.07476452f, 0.07998969f, -0.12860064f, 
    0.18995242f, -0.01702435f, 0.05837855f, 0.07082249f, -0.00642316f, -0.15815620f, -0.04935944f, -0.07612664f, 
    0.36005649f, 0.15685987f, 0.01710880f, -0.01686226f, -0.01055310f, -0.00069238f, -0.00565768f, 0.25724763f, 
    -0.14940532f, -0.50076669f, -0.26511604f, -0.18892151f, 0.09472948f, 0.13589066f, 0.00443817f, 0.07842077f, 
    -0.10896056f, 0.00805990f, 0.11335465f, -0.01009265f, -0.03239407f, 0.12379755f, -0.11190064f, 0.03083486f, 
    0.01924487f, 0.08104669f, 0.03048735f, -0.30057171f, -0.18613842f, -0.10984902f, -0.10071322f, 0.05641701f, 
    -0.13216786f, -0.01050562f, -0.00752421f, 0.01896127f, -0.15022907f, -0.13495216f, 0.11306751f, 0.14630263f, 
    0.12153132f, 0.12766039f, -0.15633085f, 0.01391469f, 0.00377409f, 0.08402378f, 0.08395409f, 0.16323316f, 
    0.11665572f, -0.18997516f, -0.01450060f, -0.02241901f, -0.08958918f, 0.05735864f, -0.06592944f, 0.18088697f, 
    -0.18245909f, 0.19317375f, 0.04297968f, -0.09912878f, -0.08632357f, -0.12395168f, 0.00253994f, -0.08985109f, 
    0.10159382f, 0.24636850f, -0.11397870f, -0.02842502f, 0.03000293f, 0.10013867f, -0.04560641f, -0.10016858f, 
    -0.06571940f, -0.14783992f, 0.01972758f, 0.03960731f, 0.09516486f, 0.06455648f, -0.16705614f, 0.14908814f, 
    0.04262068f, 0.18444841f, 0.00944410f, -0.12799112f, 0.00933946f, -0.03504876f, -0.00287742f, -0.04992901f, 
    -0.08758935f, -0.08726536f, -0.09184871f, -0.24921167f, -0.03418331f, 0.02797212f, 0.09187321f, -0.02344123f, 
    -0.02175517f, 0.05739603f, 0.10694124f, -0.12103929f, -0.23594190f, -0.18297237f, 0.00081845f, 0.13977927f, 
    -0.11292463f, -0.01533889f, 0.10796546f, 0.05646878f, -0.30859020f, -0.24009684f, -0.07880897f, -0.13731670f, 
    0.06355835f, -0.02769636f, 0.10813198f, 0.10236699f, 0.13206066f, -0.08460001f, -0.40335363f, 0.13114610f, 
    0.16130501f, 0.01964143f, 0.14676113f, 0.02861479f, -0.03074982f, 0.05927018f, 0.12810180f, 0.12607349f, 
    0.01508272f, -0.02627102f, -0.18819140f, 0.06480566f, 0.13009354f, 0.14959712f, 0.08601824f, 0.07981888f, 
    0.06355248f, -0.09522320f, -0.10801748f, -0.02780432f, -0.03844183f, -0.03950181f, 0.12264787f, 0.04371475f, 
    0.34010014f, -0.29716453f, -0.00182705f, 0.12712900f, 0.00801537f, 0.09516641f, 0.02853184f, 0.04931090f, 
    -0.01741123f, -0.12403915f, 0.10160973f, 0.19950941f, -0.09411281f, -0.07436387f, -0.12548892f, 0.02002077f, 
    -0.01899613f, -0.18437776f, 0.00164651f, -0.04538729f, -0.18505490f, 0.01605630f, 0.07606621f, -0.03082228f, 
    -0.01178326f, 0.01974508f, -0.04957664f, -0.20347898f, -0.14726034f, -0.05278888f, -0.14222848f, -0.11605897f, 
    0.13219064f, 0.03643351f, -0.05744931f, -0.32484719f, 0.24904102f, 0.18762527f, 0.11622041f, -0.10985962f, 
    -0.05830230f, -0.02017816f, 0.08083905f, 0.06816937f, -0.00401242f, 0.03441380f, -0.10751562f, -0.13332017f, 
    0.04301588f, 0.02104125f, 0.05254821f, 0.17857106f, -0.00963924f, 0.08760139f, -0.04805876f, 0.26324901f, 
    -0.15958653f, -0.04107146f, 0.04002664f, -0.18534590f, 0.07279803f, 0.08022298f, -0.01460998f, -0.07384079f, 
    -0.23065929f, 0.05150807f, -0.02778637f, 0.07192632f, 0.10070106f, 0.08083232f, 0.07108130f, -0.06970415f, 
    0.33328637f, -0.24293980f, -0.27195662f, -0.01815095f, 0.04905941f, -0.07662400f, 0.08521237f, 0.12893076f, 
    0.06146189f, -0.02676305f, -0.14431401f, -0.17705865f, 0.25238886f, 0.11104476f, 0.18047041f, 0.03348421f, 
    0.09419888f, 0.09563001f, -0.12185059f, -0.30795500f, 0.09220617f, -0.04469085f, -0.06754326f, 0.00065962f, 
    -0.05015263f, -0.07752150f, 0.10583416f, 0.18901905f, 0.07427248f, 0.02094875f, -0.01693377f, -0.07723583f, 
    -0.05718693f, -0.12216604f, 0.14288485f, -0.03262952f, 0.09310660f, 0.09633511f, -0.15248516f, 0.10573115f, 
    -0.14488257f, -0.03083698f, 0.02266522f, 0.00705074f, -0.04413407f, -0.07212465f, 0.13834183f, 0.15248454f, 
    -0.14649202f, -0.00785602f, -0.11154959f, -0.06345062f, 0.02073294f, 0.12525301f, -0.38448548f, 0.00677464f, 
    -0.28992900f, 0.05676728f, 0.18891075f, -0.04582415f, -0.01583011f, -0.07453313f, 0.12658112f, -0.29694006f, 
    0.31357250f, -0.01555649f, 0.04047364f, -0.03233008f, 0.02800421f, -0.12444068f, -0.01517200f, -0.02322452f, 
    -0.06758251f, 0.01663949f, 0.10223535f, -0.13267638f, 0.08535799f, 0.15154636f, -0.08960745f, -0.04220092f, 
    0.06341283f, -0.18672508f, 0.02139084f, -0.15286657f, 0.05674791f, -0.00183652f, 0.00225442f, -0.12765859f, 
    -0.02303296f, -0.02879737f, -0.10682271f, 0.06817700f, 0.13994111f, 0.11916310f, -0.11374686f, -0.05518985f, 
    0.07419771f, -0.14255963f, 0.02723576f, -0.28663334f, -0.05789860f, -0.00217063f, 0.16577677f, -0.01279229f, 
    0.07908952f, 0.07493781f, -0.04434364f, -0.12616107f, 0.02467243f, -0.01813921f, -0.06206825f, 0.12010732f, 
    0.08256271f, -0.00962184f, 0.04147514f, -0.13668552f, 0.06435052f, 0.02918637f, 0.18353449f, 0.05716022f, 
    0.03808307f, -0.00118302f, -0.34392452f, 0.01205992f, 0.05538219f, 0.18275520f, 0.02694222f, 0.04250773f, 
    -0.24164242f, -0.01440184f, -0.02745115f, 0.22705190f, 0.05661548f, -0.00094372f, -0.30703032f, -0.04014349f, 
    -0.00323784f, 0.00259879f, -0.03247244f, -0.00261449f, -0.06480470f, -0.05842299f, 0.08161879f, 0.06015981f, 
    0.04594382f, 0.04674991f, 0.10883862f, -0.06321683f, 0.07631375f, -0.14131063f, 0.08315866f, 0.15270552f, 
    0.20817989f, 0.42208150f, 0.08643021f, 0.01460517f, -0.01779569f, 0.09779673f, 0.00951538f, 0.05061182f, 
    0.00823774f, 0.06372029f, 0.10220486f, 0.14592022f, -0.06290701f, -0.00381646f, -0.00500229f, 0.12416176f, 
    -0.07086103f, 0.09563764f, -0.11565953f, -0.21930414f, -0.12415121f, -0.16243687f, 0.03282366f, -0.05458408f, 
    0.16972697f, 0.01374099f, 0.04596714f, -0.29890272f, -0.20462264f, 0.10023988f, -0.08556412f, 0.03154699f, 
    0.03958991f, -0.06947971f, -0.04806909f, 0.17285520f, -0.23424612f, -0.14745331f, -0.29984304f, 0.16751145f, 
    0.13384950f, -0.01046519f, -0.13633259f, -0.07654024f, 0.06531458f, 0.02332910f, 0.30366418f, 0.05221628f, 
    0.05257940f, -0.03639839f, -0.00771564f, -0.13226628f, 0.02839475f, 0.14585431f, -0.10370920f, 0.22901669f, 
    -0.00213526f, -0.02633415f, -0.13270180f, 0.06535185f, -0.15044148f, 0.05086622f, -0.05862006f, -0.11604990f, 
    -0.18677807f, -0.20644131f, -0.25018728f, -0.03219420f, -0.02607924f, 0.06015041f, -0.00937685f, -0.03452533f, 
    -0.00139745f, -0.30003440f, 0.15922906f, 0.06843129f, -0.09327158f, -0.01594710f, -0.12491941f, 0.06838755f, 
    0.03002435f, 0.04207008f, -0.00503375f, 0.06651355f, -0.17257002f, -0.01980849f, -0.05021824f, 0.02284181f, 
    0.01189774f, 0.02474526f, -0.11815906f, 0.04269826f, -0.08847509f, -0.16098273f, 0.09548207f, -0.10705789f, 
    0.14230368f, -0.02000011f, -0.13496119f, -0.14313103f, -0.01962009f, 0.34955382f, 0.40108356f, 0.09961599f, 
    0.06588569f, -0.04055162f, 0.04040673f, 0.06629505f, -0.01512768f, 0.14516547f, 0.19975689f, -0.04825474f, 
    -0.06818883f, 0.07768806f, 0.00407378f, -0.08284679f, 0.00935630f, 0.13442695f, 0.33111480f, -0.10689795f, 
    -0.14165379f, 0.08837392f, 0.06288275f, 0.11746231f, -0.01052347f, 0.02264150f, 0.05772294f, 0.05135027f, 
    0.08300686f, -0.06226532f, 0.08620556f, 0.07125212f, -0.02532996f, 0.07888473f, -0.11744852f, -0.00522516f, 
    -0.09829944f, -0.04288246f, -0.12895302f, -0.01005443f, -0.00845280f, -0.15431583f, -0.00716603f, 0.04105860f, 
    -0.07554140f, -0.06021674f, 0.14854877f, 0.17815880f, 0.02738279f, 0.04587018f, 0.02177058f, 0.04994719f, 
    0.06669762f, 0.07871915f, -0.02889418f, -0.02002182f, 0.07952553f, -0.17833297f, 0.00803036f, 0.00764371f, 
    0.00360561f, -0.07248434f, -0.08206582f, -0.19834037f, 0.11306036f, 0.20167066f, 0.23416148f, 0.05271985f, 
    -0.07982615f, 0.02134071f, -0.00437938f, 0.10233590f, -0.22097211f, 0.01073837f, 0.14182438f, 0.05988467f, 
    0.16109757f, 0.00366585f, 0.01014832f, -0.08729924f, 0.12990712f, -0.02298451f, 0.20921312f, 0.23746207f, 
    -0.04092762f, 0.05370840f, 0.04475284f, 0.08657461f, 0.10746232f, 0.06362693f, 0.02191350f, -0.33511284f, 
    -0.27541083f, -0.00161593f, -0.03377391f, -0.06482925f, 0.00613058f, -0.08495948f, 0.05806498f, -0.45540622f, 
    -0.40002871f, -0.16450807f, 0.11014848f, 0.06099437f, -0.03574832f, -0.11614257f, 0.10983803f, -0.03648981f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14889382f, 0.01829882f, -0.07945472f, -0.13444766f, -0.01542958f, 0.25420123f, -0.00952412f, -0.05164397f, 
    0.01092928f, -0.11390635f, 0.08224466f, 0.18349303f, 0.12112032f, -0.01478583f, -0.01446984f, 0.07736348f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19934709f, 0.45440087f, -0.02451077f, 0.20478271f, -0.58161753f, -0.05169533f, 0.14070418f, -0.19493702f, 
    -0.09776788f, 0.01202142f, 0.33618939f, -0.05257143f, 0.23331201f, -0.14503905f, -0.09581320f, -0.18814525f, 
    0.10488895f, -0.01229209f, -0.14608157f, -0.06722622f, 0.26855552f, -0.04935529f, -0.08379838f, 0.03381667f, 
    -0.17932402f, -0.42189804f, 0.33738193f, 0.46302062f, -0.27168760f, 0.31851253f, -0.11051270f, 0.18220654f, 
    -0.11396007f, -0.15503962f, -0.01158246f, 0.16601758f, -0.12333068f, -0.17813309f, 0.22908622f, 0.34561548f, 
    -0.19051254f, -0.00721630f, 0.11101644f, -0.23185879f, 0.02541977f, -0.45702860f, 0.24229115f, -0.08309021f, 
    0.45934400f, -0.05536538f, -0.20475155f, -0.16147701f, 0.17956658f, -0.10464208f, 0.09142530f, 0.49839413f, 
    -0.03413099f, 0.18620801f, 0.17276759f, -0.51894367f, -0.06786311f, -0.02357889f, -0.16851766f, -0.13804294f, 
    0.37164721f, 0.30529594f, 0.20902468f, 0.04865906f, 0.17467958f, -0.06615087f, -0.01691586f, 0.25480375f, 
    0.08166870f, 0.18744054f, 0.16407067f, 0.39030886f, 0.24695343f, -0.26646402f, -0.30139309f, -0.33798525f, 
    0.02815286f, 0.01630239f, -0.15585633f, 0.15060098f, -0.16129147f, 0.15163620f, 0.07038915f, 0.17848217f, 
    0.22316016f, 0.13000526f, -0.37414175f, 0.49163872f, -0.46453127f, -0.23107442f, 0.19993563f, 0.28815451f, 
    0.35764155f, -0.12971520f, 0.22978714f, -0.07828594f, 0.02384466f, -0.10495072f, -0.24385440f, 0.44248927f, 
    -0.20685402f, 0.02369323f, 0.05133351f, -0.03574504f, 0.22728898f, -0.45803651f, -0.27545995f, -0.03095532f, 
    0.46024519f, -0.02281029f, -0.06057618f, 0.08486564f, -0.04379896f, 0.00142589f, 0.19695073f, -0.12110201f, 
    0.12585986f, -0.01259790f, -0.33802688f, 0.08161650f, -0.07340858f, -0.04627282f, 0.14730839f, -0.22081998f, 
    -0.34230399f, 0.41414765f, 0.05442519f, 0.38620263f, 0.20358817f, 0.17940488f, 0.11923084f, -0.27340382f, 
    0.09404626f, -0.02011015f, -0.10280348f, -0.35464510f, 0.25154558f, -0.04613506f, -0.08586330f, -0.09901886f, 
    0.28707290f, 0.06385710f, -0.22015344f, 0.13170725f, -0.02769108f, 0.28809437f, -0.02886248f, -0.29710889f, 
    -0.15402718f, -0.24482748f, 0.38232160f, -0.32686365f, 0.38436812f, -0.14760171f, -0.14813904f, 0.13774016f, 
    0.20532240f, -0.10688966f, 0.05963830f, -0.23929743f, 0.04853445f, 0.28078371f, -0.03822193f, -0.34394100f, 
    -0.12145225f, 0.44805339f, -0.32702005f, -0.13756035f, 0.13590054f, 0.10774293f, 0.15584294f, -0.32759327f, 
    0.02329993f, -0.12261364f, 0.03328278f, 0.04794991f, -0.02100371f, 0.24741340f, -0.14508396f, 0.43662682f, 
    0.00164870f, -0.09149528f, -0.53966403f, 0.26316726f, 0.35522380f, -0.40283933f, 0.15777494f, 0.03369351f, 
    0.32278019f, -0.05521453f, 0.13154949f, -0.16095507f, -0.33550033f, -0.18002784f, -0.00145900f, -0.19014362f, 
    -0.15930864f, 0.24898748f, 0.12432208f, -0.16115357f, 0.05877011f, -0.24906881f, 0.44640428f, 0.26169926f, 
    0.02887389f, -0.03680868f, -0.00043558f, -0.17714757f, -0.29168203f, 0.22220103f, -0.02924305f, 0.09335042f, 
    -0.21385783f, 0.05232777f, -0.22380011f, 0.01644248f, -0.26418525f, -0.17880686f, 0.41793719f, 0.28677410f, 
    0.16643526f, 0.04168643f, -0.16524786f, -0.27673852f, -0.17803846f, -0.17064810f, 0.15519401f, 0.09265477f, 
    -0.06275913f, 0.04706312f, -0.10134073f, -0.02255620f, -0.08117675f, -0.25536820f, 0.02867451f, -0.26857513f, 
    0.09156448f, 0.14837717f, -0.25362340f, 0.00349688f, -0.12280750f, -0.22196309f, 0.01253992f, -0.04723055f, 
    0.01870914f, -0.14742386f, -0.34451708f, -0.49807376f, 0.31073686f, 0.25912768f, 0.23696809f, -0.07193849f, 
    0.23912154f, -0.07093342f, 0.21864617f, 0.40854514f, -0.10416579f, -0.17820758f, -0.03447977f, -0.13880672f, 
    0.23531339f, -0.38355216f, -0.13499902f, -0.12419418f, 0.13378595f, 0.07286609f, 0.14429936f, 0.42435086f, 
    -0.18664126f, -0.41258690f, -0.11285178f, 0.21010230f, 0.19223076f, 0.28387672f, 0.09323588f, 0.08867209f, 
    0.20513685f, -0.15754712f, 0.16070549f, 0.24508698f, 0.09953083f, -0.03453587f, -0.20365730f, -0.28074601f, 
    -0.00398821f, 0.26847774f, 0.03237133f, 0.37625462f, -0.16685557f, 0.35299495f, 0.17250159f, 0.31629682f, 
    -0.05107067f, -0.01682631f, -0.01159054f, 0.22028539f, 0.07441140f, -0.16002429f, -0.13982007f, -0.27438068f, 
    -0.29844615f, 0.19042043f, -0.21014687f, 0.01558506f, -0.04975081f, 0.20292328f, 0.12233219f, -0.09882674f, 
    -0.04368544f, 0.24087632f, -0.05892767f, 0.11599272f, 0.28093749f, -0.20897293f, 0.14125411f, -0.28732538f, 
    0.05667611f, -0.05354024f, -0.04661623f, 0.02436974f, -0.24413262f, 0.30187839f, -0.08994719f, 0.18795530f, 
    -0.03600131f, -0.24314934f, -0.27788144f, -0.00392744f, -0.08312117f, -0.12382973f, 0.26069734f, 0.31605679f, 
    -0.17489699f, -0.42204076f, 0.06961646f, -0.30678430f, 0.09076937f, 0.32205084f, -0.11602357f, -0.40934721f, 
    0.04391594f, -0.37054414f, 0.24448372f, 0.09372697f, 0.20887648f, 0.30608553f, 0.07028160f, 0.33843285f, 
    -0.05705339f, 0.52034521f, 0.09711393f, -0.12388504f, -0.42705804f, -0.13261317f, -0.14654550f, -0.35101852f, 
    0.13082287f, -0.30348492f, 0.41246876f, 0.23949037f, 0.08169671f, -0.35074449f, 0.36544737f, 0.34290707f, 
    0.10521562f, 0.23717514f, -0.17799507f, -0.00204124f, 0.26852703f, 0.00010982f, 0.05512571f, 0.29226092f, 
    -0.18042397f, -0.25854585f, -0.06856097f, -0.21267465f, 0.21942680f, 0.24041298f, 0.29626760f, -0.60754561f, 
    -0.28999639f, -0.29853475f, -0.21671881f, 0.29137090f, 0.22299287f, 0.26074624f, 0.19439140f, -0.19921653f, 
    -0.19363514f, 0.22012846f, -0.04398105f, 0.20064509f, -0.00678387f, 0.29763758f, -0.07245206f, -0.19998476f, 
    0.22757520f, 0.51255906f, 0.22053427f, -0.29262730f, -0.11344716f, 0.02905838f, 0.14559498f, 0.19780591f, 
    0.05906052f, -0.34253094f, 0.53677875f, 0.00989438f, 0.14123267f, -0.08083633f, -0.09294467f, 0.18256606f, 
    0.37371418f, -0.11734348f, -0.07704762f, -0.25617084f, 0.45618129f, -0.06282510f, -0.07926390f, -0.42363328f, 
    -0.01599791f, 0.08449514f, -0.18899716f, 0.43162191f, 0.22015828f, -0.21178924f, -0.20272829f, 0.03589968f, 
    0.14198364f, -0.73689580f, 0.05115157f, -0.05752469f, -0.19980784f, -0.23930129f, 0.18386486f, 0.28426030f, 
    0.04076821f, 0.19341810f, 0.26550984f, -0.29610690f, -0.12558562f, -0.07118189f, 0.34548616f, 0.24433793f, 
    0.22525696f, 0.44998899f, -0.20198779f, 0.06122569f, 0.02108260f, 0.02118452f, -0.00796059f, 0.26470593f, 
    0.12776729f, 0.11855654f, 0.11156782f, -0.12996086f, -0.20701829f, 0.29655930f, -0.09379379f, -0.50514483f, 
    0.22837099f, 0.04254390f, -0.11096792f, 0.13295233f, -0.56829393f, -0.34360963f, 0.03532529f, 0.26057500f, 
    -0.24343698f, -0.16713621f, -0.01541786f, -0.00808143f, 0.23602028f, -0.08120433f, 0.23672773f, -0.42805704f, 
    0.08718216f, -0.19996995f, -0.24757472f, 0.08465044f, -0.21560600f, -0.11272844f, -0.12955424f, -0.31651169f, 
    -0.20342815f, -0.06837729f, -0.12801048f, -0.02687121f, -0.14725801f, -0.05278323f, -0.09720428f, -0.16769658f, 
    0.06460149f, -0.19156469f, 0.16754188f, 0.20570725f, -0.14139676f, 0.36353403f, -0.14715326f, 0.50791675f, 
    0.11159022f, -0.03619681f, 0.07190175f, 0.03928202f, 0.18655291f, -0.54497844f, -0.10529340f, -0.16417967f, 
    0.36691636f, -0.38190013f, 0.15810123f, 0.38761517f, -0.22582829f, 0.31515726f, -0.19367257f, -0.25266859f, 
    -0.10934149f, -0.11379754f, 0.08925443f, -0.18365592f, 0.21832530f, -0.27059001f, -0.08091014f, -0.26422828f, 
    -0.16441391f, -0.23886651f, -0.02136999f, 0.16316837f, -0.05471785f, -0.06480633f, -0.22761849f, 0.29810116f, 
    -0.06918262f, 0.42091474f, 0.43997061f, -0.01928736f, -0.87688386f, -0.26279140f, -0.40449104f, -0.13043401f, 
    0.08295279f, 0.12301515f, 0.05268037f, -0.33441845f, -0.08567777f, 0.29165277f, -0.05395833f, 0.07352473f, 
    0.08716590f, 0.27888939f, -0.29448420f, 0.15821064f, -0.37676078f, 0.22646485f, 0.11426418f, -0.15923446f, 
    0.07955152f, -0.04486034f, 0.00645932f, 0.19500844f, 0.33289337f, -0.19818634f, -0.04479957f, 0.50120765f, 
    -0.20146878f, -0.47322387f, -0.01864168f, 0.45080742f, 0.04584248f, 0.03479249f, -0.13087906f, 0.24846876f, 
    0.02807476f, 0.44685662f, -0.23149061f, 0.14151044f, -0.32597083f, 0.22243097f, -0.11689892f, -0.11163008f, 
    0.04911880f, 0.10091311f, -0.03395942f, -0.30027729f, -0.32677993f, 0.09930065f, 0.35375679f, 0.19903873f, 
    0.36894792f, 0.26960069f, 0.14192885f, -0.11475908f, 0.27936110f, -0.32206997f, 0.09688050f, -0.03601196f, 
    -0.15026236f, -0.16222845f, -0.15026248f, 0.28522736f, 0.10898639f, -0.01393460f, -0.44268841f, 0.09541783f, 
    -0.00122758f, 0.23435882f, 0.12122286f, -0.14434081f, 0.24165592f, 0.08817034f, 0.15406027f, 0.24805276f, 
    0.19250497f, 0.17843372f, 0.16472585f, 0.27633515f, -0.33147773f, -0.45051664f, -0.19163342f, -0.06397349f, 
    0.10434510f, 0.07791443f, -0.12065675f, -0.29587054f, -0.24529769f, 0.10350296f, 0.14651975f, -0.51182455f, 
    -0.11774553f, 0.28420812f, 0.12447423f, 0.23665507f, 0.42809671f, 0.20067175f, 0.12995467f, -0.33910385f, 
    -0.26434228f, -0.13076544f, -0.21841337f, 0.43833870f, -0.10727014f, 0.20481254f, -0.21338201f, -0.15622167f, 
    0.10313573f, 0.25104851f, -0.05681450f, 0.10269372f, -0.21817419f, 0.20377839f, -0.05809207f, 0.30672351f, 
    -0.17904247f, 0.10333615f, -0.22035360f, -0.28605703f, 0.11641958f, 0.05283954f, 0.24491879f, -0.13881190f, 
    0.20661673f, -0.09523869f, 0.03460959f, -0.26590484f, -0.27010968f, 0.07651852f, -0.06272887f, -0.23208004f, 
    -0.20058125f, 0.32265851f, 0.16939804f, -0.12884276f, -0.12760447f, -0.12888876f, -0.18255776f, -0.04431785f, 
    0.06599781f, 0.38482165f, 0.25919062f, -0.14198871f, -0.53248668f, 0.05220331f, 0.05920590f, -0.04150001f, 
    0.12727022f, 0.53087556f, 0.11048854f, -0.06700360f, 0.22754964f, -0.08358816f, -0.13774511f, -0.52379143f, 
    -0.03428691f, 0.38383317f, -0.21968213f, 0.14769179f, -0.34188768f, 0.24772744f, -0.10727716f, -0.20187439f, 
    -0.13505194f, -0.27352062f, 0.18376735f, 0.25706804f, 0.13435102f, -0.30773073f, 0.03723776f, -0.30411738f, 
    -0.20678443f, 0.06557444f, 0.14299120f, 0.49751952f, -0.13220778f, 0.32601315f, 0.10415707f, -0.17789169f, 
    -0.20145454f, 0.04461165f, -0.02268469f, -0.25285712f, -0.04569609f, -0.07056021f, -0.00373006f, 0.22334683f, 
    -0.01173338f, -0.03488771f, -0.11937147f, -0.14252064f, 0.08586567f, -0.19166006f, -0.03437176f, -0.22992773f, 
    0.24224688f, 0.26881921f, -0.07524334f, -0.35405520f, -0.14753319f, -0.10600170f, -0.19090092f, 0.14680395f, 
    -0.10372761f, -0.14379478f, -0.07271428f, 0.18500155f, -0.42563048f, 0.10666211f, 0.16988628f, 0.32917333f, 
    0.06857251f, 0.27114841f, 0.11478719f, -0.19274859f, 0.08226694f, 0.12097254f, -0.08661687f, 0.09337466f, 
    0.22490130f, -0.11561865f, -0.25785887f, 0.16065697f, -0.29352176f, 0.21265337f, 0.06028986f, 0.10924931f, 
    0.07716296f, 0.38741019f, 0.15755600f, -0.21161307f, 0.06617888f, -0.11551119f, 0.04838622f, 0.29125854f, 
    0.19186062f, -0.31855866f, 0.35970610f, -0.02279614f, -0.14300680f, -0.34609237f, 0.35447684f, -0.27623510f, 
    0.14164375f, -0.06683307f, -0.14348723f, -0.25441578f, 0.23202287f, 0.33516562f, 0.12967080f, -0.24665608f, 
    -0.17242752f, -0.43780988f, 0.25165275f, -0.20863554f, -0.14135538f, 0.44813022f, -0.06955837f, 0.33336401f, 
    -0.09107151f, 0.00143093f, 0.05237430f, 0.04272949f, 0.03405578f, 0.33981729f, 0.19680226f, 0.31222403f, 
    -0.03252612f, 0.05038168f, -0.00308299f, -0.02656112f, -0.32743636f, 0.31757683f, -0.36735749f, -0.00143880f, 
    0.05032526f, 0.15716901f, 0.01770125f, -0.19377853f, -0.12069348f, 0.18262780f, 0.18703330f, -0.14648847f, 
    -0.06808527f, 0.43119723f, 0.15646642f, -0.18332857f, 0.09442547f, -0.25184241f, 0.16684063f, -0.31316802f, 
    0.27203727f, -0.07308139f, 0.21953589f, 0.20422389f, -0.31591982f, -0.19708642f, -0.14855689f, -0.37494010f, 
    0.24605799f, -0.02216206f, -0.87652081f, -0.05480770f, 0.22118354f, 0.45561990f, -0.14049236f, 0.03896287f, 
    -0.02061000f, -0.28370610f, -0.01654346f, -0.15110946f, -0.28668529f, 0.24563412f, 0.03220138f, 0.32747993f, 
    0.04775251f, -0.18389414f, -0.41216573f, -0.16423568f, 0.13447626f, 0.06892906f, 0.43306836f, 0.19917835f, 
    0.22584374f, 0.28310302f, 0.15519361f, -0.11696360f, -0.18753831f, 0.10192192f, -0.22809240f, 0.10721409f, 
    -0.09395192f, 0.14172868f, 0.39929286f, -0.35043156f, -0.27412170f, 0.42022985f, -0.17356829f, -0.33780232f, 
    0.29698822f, -0.15117143f, 0.14051676f, -0.17644684f, 0.02864845f, 0.18457960f, -0.19047156f, -0.12740399f, 
    0.12848772f, 0.14927189f, -0.03914806f, 0.39298579f, 0.18803568f, -0.33869046f, -0.31261933f, -0.27574140f, 
    0.37526333f, 0.24901822f, 0.18341249f, 0.14908651f, 0.00239394f, -0.11380246f, -0.06323898f, -0.49610057f, 
    -0.03679359f, 0.37088341f, -0.24458431f, -0.27796370f, -0.21569061f, -0.08759230f, 0.25408974f, 0.16001478f, 
    -0.22682883f, -0.41813824f, -0.06191561f, -0.39541593f, 0.17892817f, -0.32240140f, 0.08723754f, -0.59772104f, 
    0.13556796f, 0.39349800f, -0.05099774f, -0.16059412f, 0.28583860f, -0.03693523f, -0.05623855f, 0.46990374f, 
    0.02224217f, -0.24531266f, -0.19952062f, 0.18186484f, 0.09276318f, 0.16500799f, 0.04944414f, -0.22802234f, 
    0.11425132f, -0.17145193f, 0.29834971f, 0.02882289f, -0.23631984f, 0.24383347f, -0.11732028f, 0.36408213f, 
    0.21289223f, 0.25755373f, -0.01864086f, 0.33932227f, -0.35474294f, 0.20934336f, -0.12170345f, 0.28022701f, 
    -0.03794857f, -0.21686183f, -0.30998215f, 0.03048777f, -0.14291848f, -0.08953244f, 0.03648289f, 0.26196951f, 
    -0.04702580f, 0.13377434f, -0.00458188f, 0.10978907f, -0.10588439f, -0.28538179f, -0.19110718f, -0.37825385f, 
    -0.20097776f, 0.39721599f, -0.02756918f, 0.09004521f, 0.22500533f, 0.10197378f, 0.36631677f, 0.01259762f, 
    0.13788041f, -0.25691432f, -0.21346347f, -0.24734336f, -0.02751249f, -0.19854513f, 0.10895923f, -0.34412318f, 
    0.14655533f, -0.04575106f, 0.29161003f, 0.36116445f, 0.50257003f, -0.16225928f, 0.25355592f, 0.17723826f, 
    0.08125366f, 0.36708844f, -0.11920056f, -0.07583348f, 0.18139274f, 0.24649647f, -0.23901543f, 0.02489341f, 
    -0.03398521f, 0.09311138f, 0.17827281f, 0.34975809f, -0.29764181f, 0.02535839f, -0.23854432f, -0.08117749f, 
    0.21029767f, 0.24782494f, 0.22982919f, -0.20921619f, 0.10416813f, 0.18088120f, -0.17995378f, 0.38204950f, 
    0.04192474f, 0.33129171f, -0.22445476f, 0.01375836f, -0.54978973f, 0.28827667f, -0.07907637f, -0.56356937f, 
    -0.29274040f, -0.19536206f, 0.13491218f, 0.20652533f, -0.01997545f, 0.24154896f, -0.02035987f, 0.10651550f, 
    0.16757426f, 0.41302702f, -0.32474425f, -0.02025092f, -0.18884175f, 0.13863291f, 0.36668891f, -0.02611251f, 
    0.43906578f, 0.06302220f, 0.02880736f, -0.28123155f, 0.12603998f, 0.08223391f, -0.16893056f, -0.07181846f, 
    -0.09059531f, -0.35172379f, 0.39978594f, -0.25021321f, -0.24119025f, 0.44203186f, 0.22527932f, -0.15182476f, 
    0.33719200f, -0.02547470f, -0.08790676f, -0.02536586f, 0.18397313f, 0.31031334f, 0.00381532f, -0.74434906f, 
    -0.24761528f, -0.04593115f, -0.44263247f, 0.26839578f, -0.30177286f, 0.11630185f, 0.12828854f, -0.24292494f, 
    -0.18598346f, 0.19244051f, 0.08587523f, 0.07066076f, 0.21628560f, 0.08149862f, -0.08763304f, -0.03500681f, 
    0.24120049f, -0.38222522f, 0.46250001f, -0.05881296f, -0.28248540f, 0.21969400f, -0.29023275f, 0.31712386f, 
    0.12649527f, -0.31003886f, -0.04325641f, -0.08100353f, -0.08445726f, 0.08961079f, 0.03836221f, 0.29451126f, 
    0.21511151f, 0.04459080f, -0.21225977f, 0.40552840f, 0.01504464f, 0.39966762f, -0.02282262f, -0.02680551f, 
    -0.17162801f, -0.11105072f, 0.01463389f, -0.09247300f, 0.02230973f, -0.00423983f, -0.07656333f, -0.14472902f, 
    -0.00582513f, -0.07124021f, -0.06778521f, -0.20157278f, 0.13118823f, -0.19654495f, -0.10274595f, -0.11094017f, 
    -0.29815570f, -0.36457139f, 0.04630605f, 0.40569139f, -0.12187071f, 0.33679768f, 0.13153955f, 0.20646885f, 
    0.20735699f, -0.11605451f, 0.21212576f, 0.23563710f, -0.05304110f, 0.12788045f, -0.07477380f, -0.16368952f, 
    -0.07115515f, -0.23051853f, -0.04648945f, 0.44617099f, -0.10425201f, -0.06607304f, 0.04943961f, 0.14777960f, 
    0.08538426f, -0.05331749f, -0.08839599f, 0.36896616f, -0.12119277f, 0.09264547f, -0.13077831f, 0.31975961f, 
    -0.06389093f, 0.08799317f, -0.20715332f, -0.19556022f, -0.12339228f, 0.02316925f, 0.00099242f, -0.07792553f, 
    -0.13736504f, -0.23968121f, -0.06391922f, -0.12767321f, 0.06481233f, -0.12519190f, -0.23113292f, -0.12531087f, 
    0.00976520f, 0.31821999f, 0.18724801f, 0.21327408f, -0.07138619f, 0.07150564f, 0.21852076f, 0.65999085f, 
    0.12224931f, 0.27279136f, -0.05127255f, -0.21837832f, -0.11413939f, -0.47519156f, -0.07247493f, -0.06448052f, 
    0.01499972f, 0.29482958f, 0.17481224f, 0.35392311f, 0.08327147f, 0.23323622f, 0.17809400f, -0.32362935f, 
    0.21944004f, -0.07788076f, 0.02032643f, -0.47636610f, 0.22981787f, -0.06341867f, 0.16899805f, 0.07707851f, 
    0.31269369f, -0.41992465f, 0.08335566f, -0.00285001f, 0.13041718f, 0.35380420f, 0.01594868f, 0.44249955f, 
    -0.14024113f, -0.25233999f, 0.20981446f, 0.26644492f, -0.05182302f, 0.02986822f, -0.02888453f, -0.48383519f, 
    0.11036004f, -0.24768271f, 0.03806434f, -0.19438444f, 0.14982931f, -0.25524130f, -0.10386571f, 0.49097624f, 
    0.00037877f, 0.17936411f, 0.16540511f, 0.22325242f, 0.36054996f, -0.34313223f, 0.34660363f, -0.04750949f, 
    -0.18620767f, -0.14395240f, -0.06730741f, 0.24280646f, 0.07520045f, 0.40063894f, -0.21460667f, 0.36438608f, 
    -0.11745824f, -0.00070737f, -0.37691298f, -0.06839807f, 0.37264326f, -0.22684479f, 0.32029074f, -0.34195635f, 
    -0.08357554f, 0.19179675f, -0.02399392f, -0.09454955f, 0.08255858f, -0.34017918f, -0.23129565f, 0.36119407f, 
    -0.11816414f, 0.09519466f, 0.16891274f, 0.53058249f, -0.18605563f, 0.25209412f, -0.24964012f, 0.18163541f, 
    0.16893882f, -0.42508104f, 0.17699905f, 0.46140671f, 0.00008015f, -0.17676809f, 0.10161352f, 0.01778199f, 
    0.04617032f, 0.00789020f, -0.26421025f, -0.11626159f, 0.27934220f, 0.23355968f, -0.22358720f, 0.13379908f, 
    0.03694807f, 0.20207243f, -0.20048755f, 0.31801453f, -0.50374669f, -0.27761707f, -0.05887920f, 0.09657975f, 
    0.10321543f, -0.20120317f, 0.09398601f, -0.07677767f, 0.23506995f, -0.07297913f, 0.21361189f, 0.07039451f, 
    -0.37603793f, 0.32600734f, 0.21439341f, 0.34051019f, -0.00054053f, -0.15394981f, 0.10557598f, 0.16179630f, 
    0.04382502f, -0.13193752f, -0.40032643f, 0.06857352f, 0.18308780f, 0.12632981f, -0.09630039f, 0.39652795f, 
    0.26514861f, -0.05918238f, 0.00742092f, -0.26010036f, 0.04757189f, 0.05703039f, 0.15842137f, -0.32725632f, 
    0.24561298f, -0.38239011f, 0.39085075f, 0.25336787f, -0.19435990f, -0.22922994f, 0.23128922f, -0.28403190f, 
    -0.21852484f, 0.05513184f, -0.20481712f, -0.22158197f, 0.37241209f, -0.04812306f, -0.22941431f, 0.52747756f, 
    -0.08014920f, 0.22342463f, 0.11713794f, 0.11497080f, 0.36422402f, -0.30869782f, 0.17436662f, -0.30886507f, 
    0.28320977f, 0.32665333f, 0.03168100f, -0.25616786f, -0.14555322f, 0.25983697f, -0.05413669f, -0.25412929f, 
    0.16841070f, -0.17936683f, -0.21006770f, -0.00876249f, -0.17555432f, 0.02984427f, 0.14012678f, 0.23363550f, 
    -0.04901640f, -0.12731996f, 0.16607800f, -0.07851838f, -0.15943353f, -0.29630622f, -0.12293389f, -0.06891779f, 
    -0.18749216f, -0.04345958f, 0.17054944f, 0.12733828f, -0.07663795f, -0.14619854f, -0.11622406f, -0.01907189f, 
    0.14467582f, 0.63364214f, 0.23613639f, -0.19350147f, -0.21906734f, 0.16040163f, -0.04253438f, 0.34793600f, 
    -0.21137717f, -0.12035270f, 0.07461324f, -0.27603212f, 0.18059394f, -0.07652976f, 0.15728849f, -0.28798768f, 
    0.15168716f, -0.19518977f, 0.16958609f, -0.40444365f, 0.27837649f, 0.17242701f, -0.02263176f, 0.09022062f, 
    -0.10468813f, 0.12417101f, 0.14583650f, -0.28721511f, 0.12889114f, -0.06460244f, -0.05844644f, 0.06190862f, 
    -0.11826357f, -0.20089798f, -0.22489101f, -0.01984295f, -0.21898052f, 0.35994112f, -0.00488213f, 0.12637641f, 
    0.11838910f, -0.03992978f, -0.23535205f, -0.27807137f, 0.06809700f, -0.13630348f, 0.39773050f, 0.22066225f, 
    -0.29218349f, 0.26759326f, -0.07581073f, -0.14644465f, 0.06079418f, 0.07809650f, -0.22012797f, -0.12030444f, 
    0.16101654f, -0.16227816f, -0.23148249f, 0.28441507f, 0.17285272f, -0.25280491f, 0.29461637f, 0.12776585f, 
    -0.54844177f, -0.11482716f, 0.20976679f, -0.19489844f, 0.16748466f, -0.24864075f, -0.21667236f, -0.48667157f, 
    -0.16154735f, 0.32633910f, 0.30456075f, -0.16996042f, 0.26545307f, 0.00393408f, -0.12872225f, 0.18931136f, 
    -0.25964701f, 0.48560026f, 0.13005091f, -0.25656551f, 0.34294379f, -0.15313922f, 0.16806731f, 0.16000409f, 
    -0.04301327f, -0.26616710f, -0.37038833f, -0.15556698f, -0.00356888f, 0.29245722f, 0.24233465f, 0.11761101f, 
    0.00622842f, 0.02728046f, -0.24701840f, 0.27498034f, -0.20948066f, -0.15558018f, -0.15457833f, 0.19842298f, 
    -0.01740421f, 0.37556282f, 0.15952374f, -0.02750802f, 0.02827303f, 0.21947555f, 0.27878624f, -0.49730864f, 
    0.33452725f, -0.20937783f, 0.23413104f, -0.30278328f, -0.01177772f, 0.08078619f, -0.18829301f, -0.30067277f, 
    -0.11708048f, 0.31059200f, -0.16845417f, -0.05434752f, -0.21094315f, -0.26836550f, 0.21575683f, 0.21306805f, 
    -0.11707204f, 0.01253959f, -0.17708775f, -0.17273039f, -0.13477026f, -0.24113022f, 0.08036661f, 0.06703089f, 
    0.13203968f, -0.20982951f, -0.25406528f, -0.25519243f, -0.19721517f, 0.03549854f, 0.07316747f, 0.20248009f, 
    -0.13759945f, -0.17394623f, 0.06541660f, 0.19483183f, -0.23897716f, -0.21183427f, -0.08492073f, -0.19092491f, 
    0.15189964f, -0.07178541f, 0.17712207f, -0.24857529f, -0.23110031f, 0.01962300f, -0.16399983f, -0.20884553f, 
    0.39616257f, 0.12094286f, -0.11723443f, 0.29012001f, 0.02492426f, 0.16950223f, 0.08603194f, -0.08604570f, 
    0.09684864f, -0.35630253f, -0.21495339f, 0.03270080f, -0.27494022f, -0.22376369f, 0.20605506f, 0.05374965f, 
    0.25861627f, -0.30075845f, -0.15046814f, -0.07208557f, -0.00523761f, 0.15246068f, -0.14818254f, -0.03279595f, 
    0.01597862f, -0.28818741f, 0.36095721f, 0.14990258f, -0.10595144f, -0.30082184f, -0.02631621f, 0.32431969f, 
    0.48677081f, 0.27732185f, 0.20370179f, -0.17310663f, -0.24100931f, 0.06031443f, 0.22963771f, -0.03871083f, 
    0.24864748f, 0.00145512f, -0.16486071f, -0.29540393f, -0.13456200f, 0.01185376f, 0.32103795f, -0.05534467f, 
    0.22410120f, 0.10398702f, 0.12739128f, -0.36052901f, 0.02341454f, -0.18308632f, 0.04504591f, 0.31813392f, 
    -0.10802607f, 0.00490505f, 0.37641144f, -0.30069634f, 0.22697294f, 0.20698936f, 0.24011986f, -0.15746300f, 
    0.01420717f, 0.47615165f, -0.15028416f, 0.26760158f, -0.44843540f, -0.08954160f, -0.10321590f, 0.23266317f, 
    -0.08051942f, -0.03028723f, -0.36871290f, -0.05579879f, 0.22856146f, 0.20881486f, 0.16965687f, 0.17092685f, 
    0.05034709f, 0.01119761f, -0.24715976f, 0.17839415f, -0.20226769f, 0.30273616f, -0.11808684f, -0.03722611f, 
    0.04546865f, -0.01708584f, 0.01109069f, -0.43023822f, -0.05736702f, 0.05025938f, 0.31089580f, 0.14108461f, 
    -0.05784601f, -0.17494434f, 0.02046457f, -0.13626519f, 0.03318557f, 0.03591877f, -0.23276946f, -0.10868499f, 
    0.04656523f, 0.00557342f, 0.11862013f, -0.09648076f, -0.04369929f, -0.23434708f, 0.00730333f, -0.15959054f, 
    0.13632999f, -0.31067663f, 0.20555085f, -0.45338103f, -0.18414348f, 0.25956374f, 0.17373961f, -0.07833011f, 
    0.14157590f, 0.24170087f, -0.01135194f, 0.28906289f, 0.49558252f, 0.13057700f, 0.12554841f, -0.33933890f, 
    0.26702020f, 0.09489568f, -0.23166178f, 0.23604096f, 0.04553367f, -0.19043280f, 0.22687301f, -0.16508713f, 
    -0.03343631f, -0.36346495f, 0.09235883f, -0.29154766f, -0.02261447f, -0.38091537f, 0.39207417f, 0.08231602f, 
    -0.24550116f, 0.09661238f, 0.15497331f, 0.18557152f, -0.07549945f, -0.02666035f, 0.22491783f, 0.56348413f, 
    0.12901899f, -0.17502086f, 0.40969515f, -0.11364987f, 0.04584834f, 0.13044029f, 0.02963091f, 0.46515602f, 
    -0.05760682f, -0.20246817f, -0.08765167f, 0.49877131f, 0.05251993f, -0.05850007f, 0.08915326f, 0.51794720f, 
    0.22662190f, 0.01174518f, -0.06562703f, -0.16531529f, -0.06084185f, -0.19400886f, 0.05985555f, -0.08574771f, 
    0.19165795f, 0.27508530f, 0.12040851f, 0.38568535f, -0.15452963f, -0.02209450f, -0.24446929f, 0.42850670f, 
    -0.16559145f, -0.01850821f, -0.01166418f, -0.26287866f, -0.10579536f, -0.01575984f, -0.13717121f, -0.11022679f, 
    0.03656745f, 0.11138944f, 0.06653760f, -0.24576300f, 0.17130907f, 0.17751420f, -0.22478101f, 0.11689914f, 
    0.00053069f, 0.02995427f, 0.34831750f, -0.04934549f, 0.32946095f, -0.20796345f, -0.16795093f, -0.15568703f, 
    -0.17931271f, 0.25609845f, 0.08951194f, -0.16453911f, -0.11003566f, 0.09060341f, 0.08797327f, -0.05541157f, 
    -0.23630936f, 0.34757668f, 0.24668016f, -0.36275637f, 0.23518127f, -0.09947278f, 0.28133455f, 0.22952931f, 
    0.17116861f, 0.43260467f, 0.18668127f, -0.07519485f, 0.19613355f, 0.06323419f, 0.17105937f, 0.22194314f, 
    0.01639186f, -0.17483492f, 0.10883012f, -0.27068841f, 0.07156098f, 0.47765338f, -0.03009528f, -0.13849509f, 
    -0.13563555f, -0.16983096f, 0.03242508f, -0.41968367f, 0.48417622f, -0.00154467f, 0.03540868f, 0.49682868f, 
    -0.08132982f, -0.15219258f, 0.11754763f, 0.10020366f, -0.04216118f, 0.44334710f, -0.02662246f, -0.06865118f, 
    -0.21386679f, -0.12463871f, -0.22637194f, -0.15289985f, -0.20600575f, -0.13169612f, -0.13840827f, -0.21383798f, 
    -0.14928761f, -0.09896379f, -0.14424719f, 0.12003469f, 0.01236722f, 0.09045279f, -0.23574305f, 0.08439741f, 
    0.20126250f, 0.03674614f, -0.23587094f, -0.31722018f, -0.28644568f, 0.14015755f, 0.01658756f, 0.09033613f, 
    -0.16442244f, -0.03393508f, -0.11245324f, 0.24537256f, -0.44540727f, 0.03973558f, 0.22492251f, 0.29692584f, 
    0.29863593f, 0.49902257f, 0.00252334f, -0.19083421f, -0.22961514f, 0.08074785f, 0.23130572f, 0.13615693f, 
    -0.20961341f, -0.17416154f, 0.24570455f, -0.07700533f, 0.16768906f, 0.26514286f, 0.11518552f, -0.49173027f, 
    -0.09076642f, -0.33764553f, 0.12720415f, 0.17913359f, 0.05198678f, 0.35951638f, -0.02327248f, -0.02936889f, 
    0.16053370f, -0.19384292f, -0.16738497f, 0.18197605f, 0.24316446f, -0.17334363f, 0.07488482f, -0.15464848f, 
    -0.10027126f, 0.45012501f, 0.24684452f, -0.04859295f, -0.00878192f, -0.12828743f, 0.22418526f, -0.30067325f, 
    0.05691860f, -0.02609202f, 0.12058489f, -0.02207689f, 0.35957444f, -0.17668377f, -0.01070066f, 0.35915262f, 
    -0.28071672f, 0.11263537f, -0.05230285f, 0.15780713f, -0.23286597f, 0.30996448f, 0.16793919f, -0.26991677f, 
    -0.02972104f, -0.37288544f, -0.06296650f, 0.24329267f, 0.15919453f, 0.28513440f, 0.28280279f, 0.09323750f, 
    -0.00204521f, 0.34077206f, 0.18500379f, -0.20960455f, 0.00433097f, 0.34738097f, 0.04236031f, -0.15725999f, 
    0.15681778f, 0.12431730f, 0.10951470f, 0.29490283f, -0.22403854f, 0.19125572f, -0.23183513f, -0.17089573f, 
    0.07018928f, 0.20402579f, -0.23253509f, 0.13354474f, -0.28994641f, -0.16103923f, 0.23562625f, -0.07901938f, 
    -0.04522350f, 0.32777202f, -0.34604305f, -0.08832245f, -0.15631220f, 0.17179203f, 0.20179695f, 0.26427838f, 
    -0.28343228f, -0.22785084f, 0.18551840f, 0.04493627f, -0.15899982f, -0.00336089f, 0.11680558f, -0.27873668f, 
    -0.11765888f, 0.15545776f, 0.29145908f, -0.11919067f, 0.41090184f, 0.30742425f, 0.07818872f, 0.10946494f, 
    0.32699099f, 0.16951345f, 0.19016625f, 0.19349214f, 0.19138987f, 0.12095115f, -0.16683656f, -0.15584195f, 
    0.02744310f, -0.28811982f, -0.49150568f, 0.17775948f, -0.14857906f, -0.30041999f, 0.26288205f, 0.03166332f, 
    -0.13257705f, 0.01162799f, 0.22850332f, 0.22205621f, 0.09639233f, 0.00677008f, 0.13455710f, -0.15422398f, 
    -0.23474346f, 0.21713103f, 0.42153615f, -0.16862267f, -0.25410745f, 0.49456197f, -0.29566571f, -0.05321578f, 
    -0.13157809f, -0.16131012f, 0.09113547f, -0.21888731f, -0.03467651f, -0.09344983f, 0.21050584f, 0.46919096f, 
    -0.17349038f, 0.07171851f, 0.27499044f, 0.31334156f, 0.25775996f, 0.29872313f, -0.25502935f, 0.25904876f, 
    -0.44693404f, -0.31895134f, -0.19644144f, 0.22945303f, 0.31508559f, 0.14892866f, 0.06916296f, 0.30066764f, 
    0.10343312f, 0.19089566f, -0.04047843f, -0.11223942f, -0.00424595f, 0.20949823f, -0.24325430f, 0.24105948f, 
    0.43617028f, -0.07033750f, -0.22237471f, 0.40903217f, -0.05237924f, -0.15306896f, 0.13672107f, 0.13011740f, 
    0.02063364f, 0.18675515f, 0.08590015f, 0.14707707f, -0.09154696f, -0.10799956f, -0.00271838f, -0.44812784f, 
    -0.11891016f, -0.37074354f, 0.21501780f, -0.40410095f, 0.46825531f, -0.19775464f, -0.22264555f, 0.48602301f, 
    -0.13841976f, 0.15203357f, 0.06342115f, 0.41373459f, 0.09776630f, 0.37844431f, -0.24691600f, -0.20898421f, 
    0.14749096f, 0.02131794f, 0.20103180f, 0.24789140f, 0.20888829f, -0.24399748f, -0.08276853f, -0.05748258f, 
    -0.11594835f, -0.20474686f, -0.55408049f, 0.32764828f, 0.26795456f, 0.39713112f, 0.27910736f, -0.34968993f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.17902239f, -0.01526123f, -0.07764401f, -0.16542888f, -0.08127761f, -0.03921291f, -0.06663416f, 0.40954095f, 
    0.09002538f, 0.09740181f, 0.37433270f, 0.15124315f, 0.21888365f, 0.29706588f, -0.15169160f, 0.06509923f, 
    0.08989077f, 0.38155752f, 0.23871100f, 0.49001974f, 0.29426366f, 0.11895062f, 0.35667464f, -0.29865855f, 
    -0.23238492f, 0.18582368f, 0.18759793f, -0.22713582f, 0.17530434f, 0.03245341f, -0.11652989f, 0.03615702f, 
    0.03445175f, 0.12370951f, 0.03232652f, 0.39686716f, -0.15816487f, 0.07925310f, 0.30113798f, 0.32970852f, 
    -0.08522218f, -0.24027085f, 0.31840983f, 0.38821644f, 0.23402534f, -0.02460354f, 0.40916884f, 0.17825724f, 
    -0.13936324f, 0.02165249f, 0.08173182f, -0.23589885f, 0.37648416f, 0.43787849f, -0.03752045f, 0.58139998f, 
    -0.01769273f, -0.14425007f, 0.08011300f, 0.08172248f, 0.04018122f, 0.38522717f, -0.06562239f, 0.23264182f, 
    -0.26062006f, 0.38220450f, 0.19249430f, 0.04385657f, -0.21770810f, -0.08886706f, 0.21195860f, 0.20807880f, 
    0.11029711f, -0.47414657f, -0.28738812f, -0.06106497f, -0.46514082f, 0.07178707f, 0.23555887f, -0.46976450f, 
    0.00386094f, -0.40936589f, 0.08004122f, -0.22324803f, 0.26518968f, 0.03067716f, -0.14052704f, -0.40718737f, 
    0.25738171f, 0.35261461f, -0.08009097f, 0.09540336f, 0.18397634f, 0.37341318f, 0.20479363f, -0.08150504f, 
    0.11090431f, 0.18747081f, 0.28508970f, 0.17035916f, 0.04989159f, -0.00934245f, -0.15037742f, -0.01369320f, 
    0.26685929f, -0.05271700f, -0.11170497f, -0.27242175f, -0.00586742f, -0.33105120f, -0.18400076f, -0.22735709f, 
    -0.23360032f, 0.53478169f, -0.02238749f, 0.39078593f, 0.19119143f, 0.18011200f, 0.32899362f, 0.20644182f, 
    0.40893355f, 0.07834838f, 0.33797801f, 0.12316756f, -0.28130099f, -0.30942029f, -0.10441071f, -0.38340411f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.06968368f, -0.06524313f, -0.00856496f, 0.01695139f, -0.09717447f, -0.02340367f, 0.03267968f, -0.09748354f, 
    -0.08101278f, -0.03270871f, 0.06272011f, 0.01878173f, -0.02162022f, 0.00014531f, -0.06022073f, 0.03530646f, 
    -0.08682366f, -0.00565784f, -0.10687758f, 0.05605741f, -0.10676009f, -0.01288678f, 0.04101787f, 0.05077276f, 
    -0.09882504f, 0.02520986f, -0.03235048f, -0.02390509f, -0.09504671f, -0.06992212f, -0.02702983f, -0.02963555f, 
    -0.12552860f, -0.04757683f, -0.04873083f, -0.01951219f, 0.03553685f, -0.12124505f, -0.01076203f, 0.00468722f, 
    -0.04328775f, 0.01778596f, 0.04187148f, 0.05366318f, -0.00244834f, 0.06309458f, -0.06776275f, -0.11896757f, 
    -0.08785337f, -0.05474855f, 0.01584982f, 0.02177551f, 0.05828329f, 0.07456848f, 0.04163519f, -0.09042790f, 
    -0.02145756f, -0.01382278f, -0.03457727f, -0.03996445f, -0.02197252f, 0.02409516f, -0.11773200f, 0.00406743f, 
    0.00424998f, -0.07129525f, -0.08913184f, 0.03744536f, -0.12303265f, -0.05857317f, -0.13238439f, -0.06091805f, 
    -0.04986867f, 0.06641815f, 0.03063348f, 0.02580685f, -0.01080285f, -0.01155428f, -0.08258367f, -0.09607130f, 
    -0.04533915f, 0.01544215f, 0.03397848f, -0.08031274f, 0.03892440f, 0.03630077f, -0.00896198f, -0.06197734f, 
    -0.04133528f, 0.02430290f, 0.02419763f, -0.01942355f, 0.04577602f, -0.08443876f, 0.07013268f, 0.04875756f, 
    -0.12058847f, -0.06838661f, 0.03868354f, -0.02214993f, 0.01356672f, -0.08736545f, 0.06366380f, -0.03823293f, 
    0.03775768f, 0.05240671f, 0.01616798f, -0.09187730f, -0.02319522f, -0.03077613f, 0.01484445f, -0.02672832f, 
    -0.01576602f, -0.10307793f, 0.05721910f, -0.00555834f, 0.03456708f, 0.03273719f, -0.06660648f, 0.00220723f, 
    -0.06417635f, -0.10402080f, 0.04317765f, -0.08371233f, -0.08862364f, -0.04434726f, 0.06238677f, -0.05189081f, 
    0.13262261f, -0.10914492f, 0.01055170f, 0.41015342f, -0.11033262f, -0.13941391f, 0.22109368f, 0.06078383f, 
    -0.23402798f, 0.18297191f, 0.20406665f, 0.02303471f, 0.32562092f, 0.17168120f, 0.05064366f, -0.01635418f, 
    -0.03315457f, -0.14115345f, -0.01016979f, -0.00693105f, 0.09232674f, -0.03544270f, 0.05962531f, 0.20768243f, 
    -0.15020199f, 0.19755873f, -0.03493252f, -0.55659133f, 0.25049037f, -0.10057678f, 0.00439736f, -0.02964775f, 
    -0.22802500f, -0.08552448f, 0.09477286f, -0.02060949f, 0.24486351f, -0.28005922f, -0.49085239f, 0.11515214f, 
    -0.17577188f, 0.07270332f, 0.20509486f, -0.08259113f, -0.17535341f, 0.02720481f, 0.18630672f, 0.03054856f, 
    0.31686080f, 0.05370886f, 0.08036364f, 0.09364932f, 0.63082021f, 0.32795659f, 0.44073895f, -0.12043308f, 
    0.08094864f, 0.03322157f, 0.04310454f, 0.04909736f, 0.00818810f, 0.06092020f, -0.09155229f, 0.03450887f, 
    -0.03707184f, 0.28239083f, -0.00478736f, -0.07441270f, 0.10621317f, 0.00229043f, -0.14582440f, -0.11768109f, 
    0.03047428f, -0.02710245f, -0.07370242f, 0.06813770f, -0.09350068f, -0.02575882f, -0.24641825f, -0.37952217f, 
    -0.15022676f, -0.35255882f, -0.23506409f, 0.00838485f, 0.15204921f, -0.06811648f, 0.23124513f, 0.16941395f, 
    0.26496333f, 0.03833834f, -0.27170804f, -0.26677132f, 0.00190483f, 0.12015196f, 0.07232233f, 0.01791007f, 
    -0.06149369f, 0.00088927f, 0.39500791f, 0.43121362f, 0.04748166f, 0.15579498f, -0.05192899f, 0.25580066f, 
    -0.03035606f, -0.03634788f, -0.39601335f, -0.08731107f, 0.14834456f, 0.21248011f, 0.35999757f, -0.28509918f, 
    -0.02873205f, 0.18095066f, 0.39225131f, 0.00225083f, 0.06417062f, 0.02602634f, 0.01121160f, 0.16586240f, 
    0.08333081f, -0.09317825f, 0.05122034f, 0.07018053f, -0.07883943f, -0.27116951f, -0.43604311f, -0.09068759f, 
    0.26441875f, -0.09951320f, 0.25921959f, 0.19069670f, 0.12599184f, -0.04221981f, 0.14520474f, 0.31614655f, 
    -0.01361356f, -0.04887274f, 0.27890575f, -0.27042267f, 0.25534618f, 0.11911603f, 0.00287671f, -0.15190944f, 
    -0.14242987f, -0.08418020f, -0.10997424f, 0.19238769f, -0.10460783f, -0.17839146f, 0.69797528f, -0.27920860f, 
    -0.08097211f, 0.01515523f, 0.11396553f, 0.05286640f, 0.15711898f, -0.08316056f, -0.05932098f, -0.50622964f, 
    -0.11494131f, 0.50498641f, 0.02293498f, -0.07860806f, -0.02689385f, 0.04691840f, 0.05221180f, 0.26095009f, 
    -0.20533600f, -0.08005694f, 0.16320087f, 0.43250671f, 0.19816332f, -0.09497754f, 0.20241998f, -0.03357504f, 
    -0.30230424f, -0.15907007f, -0.10037289f, 0.32339796f, 0.34505707f, -0.01285949f, 0.09920201f, 0.29025471f, 
    0.23608848f, -0.35312498f, -0.07612815f, -0.10552558f, 0.17652307f, 0.31595731f, 0.06986172f, 0.14434019f, 
    -0.18103606f, 0.07385708f, 0.25773209f, -0.37888071f, 0.00685413f, 0.02521391f, -0.29227859f, -0.12915087f, 
    -0.08671109f, -0.21361552f, -0.17467012f, -0.15995555f, -0.08875256f, -0.28407675f, 0.05967805f, -0.30856401f, 
    -0.18965673f, -0.18790750f, -0.11955842f, 0.08254552f, 0.24686351f, 0.02655557f, -0.01377720f, -0.09615914f, 
    -0.12872282f, 0.24035983f, 0.02249487f, -0.05387742f, 0.12673301f, 0.24184398f, -0.11395999f, -0.03247198f, 
    0.07538931f, 0.04353608f, 0.38220045f, 0.12190536f, -0.01402646f, -0.15585473f, 0.03226885f, 0.12901781f, 
    -0.05686057f, -0.42276660f, -0.21765855f, -0.31805810f, 0.13364176f, -0.05834751f, -0.21984544f, -0.37030664f, 
    -0.03647752f, 0.25089079f, 0.05358557f, -0.03713469f, 0.18521895f, 0.17056443f, 0.20054661f, 0.05793179f, 
    0.04585748f, -0.00974481f, 0.04491933f, -0.09411662f, -0.28122714f, -0.22029401f, 0.07070719f, -0.34159920f, 
    -0.04611586f, 0.04956215f, 0.06942950f, 0.01708587f, -0.04236967f, -0.02314882f, -0.05389374f, -0.02550812f, 
    -0.08417679f, -0.03887714f, 0.02034713f, -0.06800800f, 0.04082123f, -0.03766040f, -0.01270614f, -0.01808188f, 
    0.01697550f, 0.02641175f, 0.03419069f, -0.04776714f, 0.05442620f, -0.02688746f, -0.00297939f, 0.02567817f, 
    -0.05414091f, -0.03066216f, 0.01379195f, -0.01514598f, -0.03012312f, 0.03296831f, 0.02677098f, -0.02321147f, 
    0.04126162f, 0.08318501f, 0.03671326f, 0.03411241f, -0.10050824f, 0.05164489f, -0.08271663f, -0.06254821f, 
    0.06491137f, 0.00618040f, -0.02715799f, 0.00585900f, -0.00849578f, 0.03822232f, -0.07538499f, -0.08822194f, 
    0.08522917f, 0.06532550f, 0.01461969f, 0.03551583f, 0.00240324f, -0.02086337f, -0.03471910f, -0.09215368f, 
    -0.01507185f, -0.06038392f, -0.03935618f, 0.03125294f, -0.03079393f, -0.04514635f, -0.09853756f, -0.08875210f, 
    -0.10904896f, -0.05771130f, -0.03772118f, 0.05816641f, -0.04275046f, -0.04153792f, 0.09407964f, -0.03192778f, 
    0.03558215f, 0.01939518f, -0.13457885f, -0.02717938f, -0.12614779f, -0.03499825f, 0.05431710f, 0.05015107f, 
    0.01399758f, 0.00737812f, 0.03031276f, 0.00005045f, 0.02763678f, -0.02847773f, 0.12432737f, -0.04676018f, 
    -0.07263947f, 0.02124560f, 0.00533065f, 0.07109339f, 0.04890669f, -0.01237048f, 0.04848761f, -0.07227495f, 
    -0.04185817f, -0.09891829f, -0.06586894f, -0.08658008f, -0.00013890f, -0.04831251f, -0.06189293f, -0.02643310f, 
    -0.03544669f, 0.01886773f, -0.00204809f, 0.05218090f, -0.03161713f, -0.03800792f, -0.07647421f, 0.06750867f, 
    0.06243839f, -0.08574864f, -0.05191272f, -0.09816422f, -0.12994671f, -0.09267239f, 0.01685270f, -0.06221764f, 
    -0.02424374f, -0.03164397f, 0.04364925f, -0.01363036f, -0.05911632f, -0.05664318f, 0.03914316f, 0.00286781f, 
    0.01147118f, -0.01929041f, 0.07387301f, 0.01592937f, -0.00708140f, -0.00306089f, -0.01994374f, -0.05719220f, 
    0.06754715f, 0.03426599f, -0.08925129f, -0.05189219f, 0.06452303f, 0.04582400f, 0.01591253f, 0.06368598f, 
    -0.08429114f, -0.06938489f, -0.05512532f, -0.01696794f, -0.05928645f, 0.00273047f, -0.07496957f, -0.08526554f, 
    -0.10271104f, -0.08008692f, -0.07723693f, 0.05681810f, 0.02258336f, -0.07348344f, 0.02415260f, 0.06616031f, 
    -0.02429844f, 0.05905752f, 0.06246286f, 0.03575139f, 0.02296457f, -0.00630441f, -0.08405599f, -0.01925120f, 
    -0.08036695f, 0.07731720f, -0.08120159f, -0.06061730f, -0.08586537f, 0.04840576f, -0.07759693f, 0.05366755f, 
    0.03946527f, 0.05780117f, 0.06972791f, -0.03437137f, -0.02098534f, 0.07360208f, -0.06054281f, -0.03452314f, 
    -0.09921212f, -0.04612161f, 0.01468611f, -0.09334183f, 0.03165095f, 0.03439714f, 0.01384145f, -0.00797579f, 
    0.04806345f, -0.03887760f, 0.03594372f, -0.07674704f, 0.00052165f, 0.07369415f, -0.04774095f, -0.06179432f, 
    -0.06905136f, -0.08370597f, -0.10082889f, 0.06084026f, -0.01314138f, -0.08378848f, 0.06775050f, -0.10097747f, 
    -0.02499770f, -0.04219560f, -0.02131364f, -0.06147286f, 0.00351235f, -0.01515111f, -0.07660137f, -0.02781772f, 
    -0.09166425f, 0.02064214f, -0.02171702f, 0.07172371f, -0.07418400f, -0.04520772f, 0.01619740f, -0.06624974f, 
    -0.10073080f, 0.02135462f, -0.08497776f, 0.04621087f, 0.02780530f, -0.06315833f, 0.04421054f, 0.07428727f, 
    -0.01554516f, 0.04938447f, -0.03443727f, -0.05553368f, 0.04307414f, 0.06106649f, 0.03921128f, -0.00452062f, 
    -0.08321855f, 0.00325092f, 0.01895540f, -0.08249407f, 0.00802641f, -0.02013364f, -0.02970922f, 0.06990767f, 
    -0.00879857f, 0.06833754f, 0.00260321f, -0.00173575f, -0.06953605f, 0.05828148f, -0.03939888f, -0.06824066f, 
    0.00353217f, -0.09963160f, -0.08078624f, -0.03545349f, 0.01942638f, -0.09378241f, -0.06401090f, -0.04047912f, 
    0.02239124f, -0.08051418f, -0.06120210f, 0.03919371f, 0.03926934f, -0.06788249f, 0.07450499f, -0.03420451f, 
    -0.08363147f, -0.03443567f, 0.01641493f, 0.02423396f, -0.09141770f, -0.07784421f, -0.00100198f, 0.04737053f, 
    -0.05924287f, -0.01735858f, 0.02033352f, -0.03587443f, 0.05908873f, 0.00936249f, -0.02775478f, -0.09161469f, 
    -0.03103894f, 0.06350102f, -0.05795369f, 0.00128186f, 0.00661308f, -0.08728930f, -0.05787821f, 0.05710765f, 
    -0.08922909f, -0.02159396f, -0.01290679f, -0.00653028f, 0.02865526f, -0.04139319f, -0.06296217f, 0.00677962f, 
    -0.04870034f, 0.01580204f, -0.11425472f, 0.04796957f, -0.02266791f, -0.03823791f, 0.05473962f, 0.04385757f, 
    0.00627236f, 0.02584923f, -0.04394452f, 0.06524637f, -0.01993352f, -0.06156526f, -0.11602694f, -0.04411278f, 
    -0.02121684f, -0.02657996f, -0.09762014f, -0.07432481f, -0.03103923f, -0.01146028f, -0.03164816f, -0.08966728f, 
    0.03562728f, -0.05787785f, -0.02594824f, 0.04931562f, -0.04128062f, -0.09748468f, 0.04441392f, -0.05395239f, 
    0.05306778f, 0.06846515f, -0.06798429f, 0.03214363f, -0.08155835f, 0.02821573f, 0.04941572f, 0.00017534f, 
    -0.04261948f, 0.06993802f, -0.00137388f, -0.00540691f, -0.06290281f, 0.05582315f, 0.07805003f, -0.03811304f, 
    -0.00319402f, -0.02986531f, -0.08952764f, -0.08666549f, -0.02895808f, 0.00056574f, 0.05726517f, -0.05564526f, 
    -0.05576355f, 0.04592442f, -0.07563637f, -0.02459729f, -0.02895498f, 0.01859713f, -0.03663140f, 0.06933237f, 
    0.03533377f, 0.03654823f, 0.04065518f, -0.05760431f, 0.03384490f, 0.00771386f, 0.03168721f, -0.10160337f, 
    -0.05150226f, -0.00111767f, -0.08538086f, -0.08454495f, 0.02642054f, 0.05215155f, -0.01062235f, -0.08821014f, 
    -0.03800473f, 0.01488897f, 0.06527915f, -0.07612751f, -0.06414148f, -0.00280435f, -0.03360680f, -0.04037586f, 
    -0.08663340f, 0.02673313f, 0.03026134f, -0.03752517f, -0.01958483f, 0.03748523f, -0.02896991f, -0.03737250f, 
    0.04878787f, -0.06593222f, 0.00059944f, -0.00454312f, -0.02494070f, 0.03209400f, -0.03219593f, 0.00864756f, 
    -0.07682043f, -0.08412440f, -0.01419819f, 0.01694881f, -0.02437637f, -0.01433933f, -0.01664852f, -0.02051975f, 
    -0.05713851f, -0.05139556f, -0.04100158f, 0.01558530f, 0.01870878f, -0.08252031f, -0.04111502f, 0.04510597f, 
    0.04476647f, 0.06701066f, 0.02128070f, 0.07926802f, -0.05487077f, -0.05009609f, -0.06567845f, -0.01119443f, 
    0.07683023f, -0.06860017f, -0.08428828f, 0.07944383f, -0.07228483f, 0.04988005f, -0.01032285f, 0.00801709f, 
    -0.05476478f, -0.02014014f, -0.02594881f, -0.05701875f, -0.08585293f, 0.00117483f, 0.04725963f, 0.05320264f, 
    0.05728549f, -0.02094574f, 0.02835267f, 0.06976337f, -0.02985927f, 0.02022350f, -0.03154109f, -0.07268671f, 
    0.02615925f, 0.05099112f, 0.02996288f, -0.01680701f, 0.08285808f, -0.01092267f, -0.03384400f, -0.00034124f, 
    -0.08265115f, 0.01845387f, 0.04988451f, -0.02870512f, 0.05875256f, 0.01236849f, -0.00468262f, -0.04802976f, 
    -0.00552424f, -0.03268511f, -0.06322148f, 0.02774181f, 0.03895365f, -0.04374564f, -0.07791112f, -0.04568678f, 
    -0.06068196f, 0.07816077f, 0.03360643f, 0.01273086f, 0.03346396f, -0.04881061f, 0.05556393f, 0.01232226f, 
    -0.06311350f, -0.02987624f, -0.01686924f, 0.07753459f, -0.05317644f, 0.02706779f, -0.07469155f, 0.06781343f, 
    -0.05916617f, -0.02475061f, 0.07967354f, -0.08558616f, -0.07867670f, -0.04525030f, -0.08228245f, -0.07261822f, 
    -0.00303594f, -0.04346221f, -0.08672629f, 0.06582782f, 0.00556368f, -0.02961486f, 0.01669934f, 0.02201078f, 
    -0.08359844f, 0.12092015f, -0.04111155f, 0.23998345f, 0.31648275f, 0.01563748f, 0.24578586f, 0.35419729f, 
    0.40220991f, -0.00852539f, 0.23454319f, -0.18313310f, -0.10987211f, -0.11422268f, -0.05795719f, -0.35207269f, 
    -0.10907268f, 0.03680591f, 0.14878942f, 0.06052074f, -0.06984401f, -0.11581763f, -0.06037010f, 0.17720969f, 
    0.14960600f, 0.02419159f, 0.21624370f, -0.04166479f, 0.24965329f, -0.46660933f, -0.06107057f, -0.09446238f, 
    0.18828808f, -0.15322846f, 0.21260206f, 0.00379250f, 0.02963834f, 0.24734807f, 0.05760315f, 0.11543775f, 
    -0.06552622f, 0.01222465f, 0.31761852f, 0.52686471f, 0.16673413f, -0.02826643f, 0.07868646f, 0.19098808f, 
    -0.22186136f, -0.09107270f, -0.05967589f, 0.03879840f, -0.38066626f, -0.30632198f, 0.09870280f, 0.20531833f, 
    0.21175393f, -1.39936376f, -0.00485101f, 0.03044550f, 0.04378956f, -0.18767229f, 0.16650574f, 0.22214141f, 
    -0.13349783f, 0.11149029f, 0.39306328f, -0.34001967f, 0.15184276f, -0.07356944f, 0.05443400f, -0.03914865f, 
    0.08823121f, 0.20112693f, 0.08204937f, 0.01871179f, -0.17131075f, 0.06335849f, 0.16357537f, 0.29214987f, 
    -0.46820244f, 0.16999933f, 0.05502813f, -0.13648008f, 0.06072509f, -0.02097787f, -0.06038023f, -0.09116670f, 
    -0.12504303f, 0.09194990f, -0.32721168f, 0.30752867f, 0.09062520f, 0.06871668f, -0.00055366f, 0.03575820f, 
    0.16510794f, -0.00945699f, 0.10413920f, -0.14275251f, 0.00138170f, 0.02275268f, -0.04996527f, -0.11064753f, 
    -0.12461511f, -0.40509671f, 0.18890873f, -0.01147697f, 0.05032432f, -0.20975722f, 0.10771329f, -0.19736683f, 
    -0.07364888f, 0.11598444f, -0.01944809f, 0.11900315f, -0.07746644f, 0.08558866f, 0.26612774f, 0.08403643f, 
    -0.19762754f, 0.20583601f, 0.09374283f, -0.09975091f, -0.29523149f, -0.01073231f, 0.08000643f, -0.00904180f, 
    -0.16361807f, 0.24920307f, -0.42385298f, -0.09455210f, 0.09949917f, -0.14857747f, 0.39788154f, -0.44813970f, 
    -0.02340019f, 0.06569505f, -0.31400257f, -0.06765921f, -0.10428443f, -0.23778249f, 0.07905415f, -0.29456389f, 
    0.03799281f, 0.06845444f, -0.07859762f, -0.15616778f, -0.16900311f, 0.12456691f, 0.21430054f, -0.12126177f, 
    0.06370918f, 0.22825269f, -0.04663499f, -0.22937818f, 0.13699947f, -0.27236566f, -0.05458043f, -0.00982203f, 
    -0.88732070f, 0.86818326f, -0.20495075f, 0.15126592f, -0.00274575f, 0.20563063f, 0.02006027f, 0.11242937f, 
    0.11232606f, 0.00504597f, 0.00093211f, -0.04516555f, 0.56600863f, 0.03000044f, 0.06441487f, -0.07637157f, 
    0.23191923f, 0.12873057f, 0.00726040f, -0.28335157f, 0.09548096f, -0.15419544f, 0.18762970f, -0.14592515f, 
    -0.06399138f, -0.13742103f, 0.20011483f, -0.22329019f, -0.07831722f, 0.12620415f, 0.06459362f, -0.20007636f, 
    -0.18440099f, 0.12409580f, -0.15636484f, 0.38703138f, 0.08453649f, -0.07087081f, 0.24768756f, 0.11848488f, 
    0.05368832f, 0.39759171f, -0.05585175f, 0.04019052f, -0.22616673f, -0.33149767f, 0.28429919f, -0.02520723f, 
    -0.09954822f, -0.14224286f, 0.04052402f, 0.05713404f, -0.05468499f, 0.06331850f, 0.03596592f, 0.07279559f, 
    -0.17350191f, -0.00092545f, -0.14419399f, 0.15097012f, 0.26851079f, -0.17171252f, 0.08668348f, 0.06780214f, 
    -0.19815290f, 0.11815585f, -0.32701164f, 0.24550068f, -0.15032645f, -0.13902757f, 0.05395628f, 0.06551229f, 
    -0.22192481f, 0.34863892f, 0.07767931f, 0.12330800f, 0.00759256f, -0.09712909f, 0.16871639f, -0.01065358f, 
    -0.06529687f, 0.04566127f, 0.14569712f, -0.14375602f, 0.18209475f, -0.03402253f, 0.06490434f, 0.04659026f, 
    0.19938570f, -0.52844781f, 0.33923307f, 0.29621398f, -0.00886009f, 0.20726192f, 0.05368656f, -0.26023898f, 
    0.00399013f, 0.25343820f, 0.25716758f, -0.46540511f, -0.16775356f, -0.18050674f, -0.14904393f, -0.40054476f, 
    0.08334070f, 0.16478552f, -0.19514334f, -0.11746651f, -0.03843074f, -0.10021428f, -0.04214626f, 0.09312552f, 
    -0.04991623f, -0.02511792f, 0.03019947f, -0.03687423f, 0.02403386f, 0.17650388f, 0.03568136f, 0.03554940f, 
    -0.07234663f, 0.16332301f, -0.13162619f, 0.00616020f, -0.08497630f, 0.05314273f, -0.08576032f, 0.09384368f, 
    -0.25615129f, 0.43120596f, -0.02475561f, 0.08794823f, -0.03151574f, -0.05413672f, -0.19867542f, 0.09126896f, 
    -0.00579101f, 0.02941030f, 0.08560367f, -0.19111775f, 0.34046489f, -0.01796068f, 0.17014509f, 0.05795858f, 
    -0.04281718f, 0.14952613f, -0.00763288f, -0.37858942f, -0.13198055f, 0.08730844f, 0.06795516f, -0.14594948f, 
    -0.30878857f, 0.11259678f, 0.22713771f, 0.01613938f, 0.11002294f, 0.19293486f, -0.08844522f, -0.19504777f, 
    -0.11956723f, 0.08447457f, -0.09619816f, 0.34684426f, -0.03086611f, 0.09985608f, 0.32490444f, 0.10190620f, 
    -0.01749896f, -0.45710739f, 0.04956368f, 0.03711670f, -0.01989133f, -0.09002355f, 0.14352438f, -0.29481411f, 
    0.60907161f, -0.22836412f, 0.15030904f, -0.13766962f, 0.11069800f, -0.07567495f, 0.25815573f, 0.04028327f, 
    -0.02792494f, 0.16329409f, -0.03691342f, 0.00737410f, -0.01442267f, -0.12486707f, -0.00607882f, -0.00798871f, 
    0.02800177f, 0.10153422f, -0.33770993f, 0.06208379f, 0.02010787f, 0.07328349f, -0.02979879f, -0.05734926f, 
    0.08218478f, 0.27793249f, -0.02657134f, 0.03261527f, 0.06547417f, -0.00626759f, 0.05172619f, 0.18884425f, 
    0.00354210f, 0.02705638f, 0.08830776f, 0.03153207f, 0.11054987f, 0.11561690f, -0.03249671f, -0.07434230f, 
    0.29345301f, -0.20124863f, 0.18177412f, 0.08738022f, -0.06387328f, -0.05012735f, 0.12450155f, -0.06378678f, 
    -0.01615442f, -0.11004976f, -0.03309377f, -0.03600731f, -0.09322362f, 0.02842474f, -0.01185790f, -0.00281509f, 
    -0.03083797f, -0.08058301f, -0.00918541f, -0.04204092f, 0.00174539f, -0.09324615f, 0.01578747f, -0.05485642f, 
    -0.02917917f, 0.04389977f, -0.02536203f, -0.06069016f, -0.10262793f, -0.09427987f, -0.04562229f, -0.00729354f, 
    -0.09506237f, -0.08880860f, -0.00337888f, -0.02219257f, -0.02608932f, -0.05517489f, 0.03177620f, 0.03093652f, 
    -0.00360710f, 0.06130148f, -0.02380407f, 0.02286870f, 0.02680664f, -0.06264460f, -0.00512598f, -0.07179699f, 
    -0.07357422f, -0.07143641f, -0.04193656f, 0.04861322f, 0.07826696f, 0.06976507f, 0.02245432f, -0.09314265f, 
    -0.08534857f, -0.02847146f, -0.07696138f, -0.10565725f, -0.00987740f, 0.05661819f, -0.04788862f, 0.02642239f, 
    -0.06043443f, 0.01546800f, 0.02661549f, -0.02998777f, -0.08083897f, 0.05392244f, -0.08036186f, -0.10042531f, 
    -0.00519935f, 0.01288223f, 0.05959699f, -0.01621900f, -0.05535755f, -0.02752182f, 0.01587523f, 0.00550509f, 
    -0.03409715f, -0.02461102f, -0.08613142f, 0.00277953f, 0.00198210f, -0.05254733f, -0.10393576f, 0.01374831f, 
    -0.03470583f, -0.06461743f, -0.03860274f, 0.04131496f, -0.09571594f, -0.02703835f, -0.10455710f, -0.02709295f, 
    -0.08519310f, -0.01693190f, -0.07960698f, 0.00309756f, -0.06102448f, -0.09841225f, 0.00993306f, 0.07446235f, 
    0.03603973f, -0.00177047f, 0.02045214f, 0.04803174f, -0.00553209f, -0.07906476f, 0.02725853f, 0.02582210f, 
    0.05820840f, -0.01868530f, -0.09970789f, -0.10049389f, 0.05959360f, -0.03542142f, -0.04843454f, -0.01785881f, 
    0.07278677f, -0.09587826f, 0.03147340f, -0.06004519f, -0.04397393f, -0.06316845f, -0.02582515f, 0.03665755f, 
    -0.07520608f, -0.09341929f, 0.00701038f, 0.04304760f, -0.07175545f, -0.04259951f, 0.01953270f, 0.05092887f, 
    0.12401162f, -0.13554113f, -0.26961210f, -0.43650889f, 0.00093834f, -0.00505815f, -0.29182929f, 0.01850401f, 
    0.28542855f, 0.06394120f, -0.01636909f, -0.10906638f, -0.17705329f, -0.27508235f, -0.01579421f, 0.12620288f, 
    0.06386571f, 0.08507992f, 0.27002615f, 0.13391984f, -0.19355041f, -0.24837385f, -0.36199799f, 0.24617772f, 
    0.17396024f, -0.11865379f, -0.30776313f, -0.16471496f, 0.04612685f, 0.02619227f, 0.01910093f, 0.17770378f, 
    0.48695970f, -0.27918455f, 0.05799002f, -0.20495400f, 0.11194362f, -0.00890342f, -0.23641092f, 0.01911864f, 
    0.05979626f, -0.11916688f, -0.09084331f, -0.28000352f, 0.56867021f, 0.04517550f, -0.13561773f, -0.23126847f, 
    -0.42134675f, -0.31434140f, 0.17984107f, 0.33723140f, 0.16747539f, -0.29570186f, 0.19758706f, 0.04664372f, 
    -0.05860692f, 0.26101643f, -0.05027167f, 0.12872867f, 0.01305826f, -0.45970476f, 0.01365260f, 0.02010188f, 
    0.10667189f, -0.03275185f, -0.00990053f, -0.00184075f, 0.00478370f, -0.05691258f, 0.26217592f, 0.10065120f, 
    0.06285944f, 0.15223256f, 0.22755124f, 0.29382733f, -0.07242980f, 0.20199512f, -0.29131049f, 0.44115022f, 
    0.16579536f, 0.26887324f, -0.21260913f, -0.02064079f, -0.24470210f, -0.02335145f, 0.31813115f, -0.17470758f, 
    -0.07828226f, -0.28334531f, 0.46360528f, -0.03436629f, 0.17419526f, -0.30191392f, 0.05847517f, 0.02532481f, 
    0.00659223f, -0.05765576f, -0.19449815f, -0.19454165f, -0.04688370f, 0.11975446f, -0.05020621f, -0.02569539f, 
    0.09270661f, -0.11489143f, 0.46842542f, 0.25297377f, 0.03447432f, 0.05326289f, 0.02230969f, -0.31643519f, 
    -0.02091808f, -0.33040684f, 0.22361238f, 0.10156329f, -0.08614126f, 0.05459419f, -0.00212496f, -0.17327181f, 
    0.03907432f, 0.12058435f, 0.09191512f, -0.28607208f, -0.15977608f, 0.57139897f, -0.16416223f, 0.10245933f, 
    0.01223762f, 0.09951446f, 0.04042248f, 0.24112815f, 0.18187661f, -0.00954038f, 0.38221508f, -0.13105449f, 
    -0.11432461f, 0.03677934f, -0.22578700f, 0.16322750f, 0.01649453f, 0.13089852f, -0.01354878f, -0.27922580f, 
    -0.08825298f, 0.10010638f, 0.24603261f, 0.02296660f, 0.11660295f, 0.06933624f, 0.30511650f, -0.22346534f, 
    -0.30618697f, 0.22415841f, -0.15505520f, 0.00156409f, -0.11203905f, -0.03568490f, 0.02377529f, 0.28728333f, 
    -0.13232823f, 0.07672983f, -0.05822091f, 0.14781912f, -0.15807319f, 0.14956926f, 0.07607555f, 0.03170511f, 
    -0.30190101f, -0.04876639f, -0.31586376f, -0.36980832f, 0.22680074f, -0.04132357f, 0.08720075f, -0.14574437f, 
    0.20790203f, -0.10876671f, -0.12854786f, 0.04371710f, 0.02633276f, 0.23236677f, 0.21947271f, 0.12292799f, 
    -0.45736584f, -0.19495048f, -0.28382757f, -0.00797743f, -0.09179588f, 0.21488155f, 0.03057534f, -0.13733189f, 
    0.03240039f, -0.00744256f, -0.28123438f, 0.15730646f, 0.16218640f, 0.02998237f, 0.09564765f, 0.11423027f, 
    -0.03904120f, 0.36410818f, -0.15627381f, 0.03030434f, 0.35973674f, 0.08748507f, 0.10472412f, -0.17757855f, 
    -0.00467756f, 0.02278444f, 0.12614733f, 0.41519600f, -0.02269921f, -0.08977372f, 0.09516364f, -0.07833802f, 
    0.05228467f, 0.19369577f, -0.35187119f, -0.06293640f, 0.16264656f, -0.11608420f, 0.08906915f, 0.00643872f, 
    -0.07283207f, 0.17373458f, -0.01613525f, 0.19023888f, 0.00850936f, -0.17828546f, -0.03277301f, 0.22552383f, 
    -0.04553961f, 0.14613068f, 0.00540615f, 0.04262244f, 0.15082847f, -0.03234133f, -0.06785540f, -0.04633896f, 
    -0.02231123f, -0.02567298f, 0.14890599f, 0.05645659f, 0.06549116f, 0.15112731f, 0.00658120f, -0.14577051f, 
    0.07887878f, -0.02586502f, -0.23680848f, 0.20645112f, -0.12297119f, -0.10214780f, -0.01053752f, -0.42423931f, 
    0.00995770f, 0.12029771f, 0.03503005f, 0.22623907f, -0.04910652f, -0.17399763f, -0.24855049f, 0.24672990f, 
    -0.25482354f, 0.09268375f, 0.18730232f, 0.05125969f, 0.25967932f, -0.01435944f, 0.04772766f, -0.21249014f, 
    0.13605684f, 0.03954971f, -0.34193274f, -0.14858879f, -0.12759617f, 0.13943000f, 0.17287764f, -0.49913865f, 
    0.06559920f, -0.06439991f, 0.23584706f, -0.19338535f, -0.01876765f, -0.15304898f, 0.02001797f, -0.61716235f, 
    -0.05267503f, 0.24768999f, 0.05270765f, 0.00225143f, -0.08042073f, -0.09601864f, -0.22273482f, 0.22768319f, 
    -0.04984399f, -0.06607743f, 0.24320810f, 0.27170879f, 0.43931359f, -0.03997177f, 0.27086240f, 0.01849244f, 
    -0.27685502f, 0.20462862f, -0.18565229f, -0.00623717f, 0.33237115f, 0.04585169f, 0.23504694f, 0.22002275f, 
    0.30497256f, -0.63903749f, 0.05676341f, -0.28287330f, 0.06319716f, 0.33321461f, 0.09678303f, 0.08730681f, 
    -0.23942381f, 0.21621281f, 0.11406280f, -0.20083585f, 0.09067819f, 0.03231504f, -0.13344052f, -0.00530715f, 
    -0.03848202f, -0.41107887f, 0.03446770f, -0.18695627f, -0.26636696f, -0.28168374f, -0.09862372f, 0.70059919f, 
    -0.04428307f, 0.22691348f, 0.18317138f, -0.45337951f, 0.14950843f, -0.02280565f, -0.43395498f, -0.01436196f, 
    -0.15858349f, -0.10119721f, -0.39916846f, -0.18294176f, -0.00315914f, 0.24816859f, 0.00750002f, -0.00286152f, 
    -0.09215502f, 0.07933456f, 0.06698034f, 0.03802279f, 0.03978944f, -0.07169907f, -0.02306296f, 0.21841493f, 
    -0.01709795f, -0.34711260f, 0.00544168f, -0.54340762f, -0.23432066f, -0.16038269f, -0.13438761f, -0.46823972f, 
    -0.07403740f, 0.14653668f, -0.02856123f, -0.01701015f, -0.05336333f, 0.02578038f, 0.03050797f, 0.00575263f, 
    0.06763352f, 0.08816019f, 0.13658227f, 0.07236235f, -0.29157373f, -0.42550004f, -0.15750477f, 0.28594682f, 
    -0.02842555f, -0.00409510f, -0.00857064f, 0.02635045f, 0.02102090f, -0.02238733f, -0.01462326f, 0.06045108f, 
    0.04267193f, -0.06477628f, 0.05962453f, -0.04517738f, -0.03818826f, 0.02942471f, -0.01328412f, -0.08772404f, 
    -0.06126709f, -0.08649549f, 0.00354394f, 0.07844822f, -0.02063943f, 0.01379539f, 0.08720974f, 0.05946543f, 
    0.00559801f, 0.07466065f, -0.00478898f, -0.06436731f, -0.02206335f, -0.00914424f, 0.01011415f, -0.07591878f, 
    0.03208180f, -0.04685241f, -0.02189338f, -0.06140450f, -0.03594056f, 0.05960761f, -0.05132730f, -0.04553308f, 
    0.02761059f, -0.02592637f, 0.07721984f, -0.00892254f, -0.02318710f, -0.03438574f, -0.06358568f, 0.00652395f, 
    0.04800059f, 0.06443251f, -0.03143803f, -0.08432288f, 0.01645812f, -0.03014981f, -0.04156910f, -0.04024290f, 
    -0.09015653f, -0.01886942f, -0.09258271f, 0.02269545f, -0.05341722f, -0.01943370f, 0.02030013f, -0.05218559f, 
    -0.04493617f, 0.05619455f, -0.07750621f, -0.04180339f, -0.08124227f, 0.06568100f, -0.07233737f, -0.07438530f, 
    -0.03584646f, -0.01491826f, -0.03373447f, 0.05036566f, -0.07260212f, 0.01064346f, -0.03745072f, -0.06268597f, 
    0.01352022f, -0.03812247f, 0.03869043f, -0.00218229f, 0.01890271f, -0.04246843f, -0.08676815f, 0.03071840f, 
    -0.06647671f, -0.02442304f, 0.01997372f, 0.01936059f, -0.00022074f, -0.00173090f, -0.01357600f, -0.02863242f, 
    -0.00456779f, -0.00891958f, 0.05074232f, -0.09352873f, -0.08655432f, 0.02275157f, 0.08082558f, 0.03625906f, 
    -0.03215130f, 0.02493068f, -0.03592183f, -0.00820228f, -0.04381768f, 0.05238029f, 0.06941237f, -0.04303633f, 
    -0.05768903f, -0.04898564f, 0.03615737f, 0.01622546f, 0.01057177f, -0.08479345f, 0.02247177f, -0.04111473f, 
    -0.05569650f, -0.05939070f, -0.00147118f, 0.07111032f, -0.01796058f, 0.03702593f, 0.08433006f, -0.06552134f, 
    0.04056743f, -0.07174169f, -0.04379461f, 0.00224602f, -0.06739697f, 0.00986047f, -0.00594091f, -0.00517001f, 
    -0.05199117f, -0.03732540f, 0.01311820f, 0.00587712f, -0.02445317f, -0.07874195f, 0.06374627f, -0.01680069f, 
    -0.12015667f, -0.06425149f, 0.05261772f, -0.10150207f, -0.08778149f, -0.03503285f, 0.02697698f, 0.00611263f, 
    -0.06921048f, 0.01211574f, -0.10923704f, -0.08809142f, -0.11066674f, -0.06834056f, 0.01387407f, -0.01301700f, 
    -0.04872764f, 0.02818018f, -0.04217154f, -0.09165896f, -0.06012091f, -0.04938360f, -0.06404335f, -0.01211207f, 
    -0.11204525f, -0.06646435f, 0.01504282f, -0.00097824f, 0.00045187f, -0.05199219f, -0.03363746f, -0.07408620f, 
    -0.07170088f, -0.02053250f, -0.05198549f, 0.01632866f, 0.07242753f, -0.10482553f, -0.10095619f, -0.04743718f, 
    0.03812363f, 0.04232602f, 0.04275586f, -0.05984982f, -0.09044850f, -0.07274894f, -0.10028420f, 0.00834207f, 
    -0.06657000f, -0.03089312f, -0.04213050f, -0.06403361f, -0.03749045f, -0.00863163f, -0.00505268f, -0.07863180f, 
    0.05227382f, -0.04573020f, -0.01226063f, -0.01958456f, -0.06293878f, 0.00735991f, -0.00256792f, -0.05090602f, 
    -0.08756186f, -0.07108656f, 0.01650897f, -0.03196507f, -0.08439317f, 0.02384519f, -0.01277752f, -0.04620599f, 
    -0.04504168f, -0.02869363f, -0.03934984f, 0.03679148f, -0.01837752f, 0.00797137f, -0.07053195f, -0.05101638f, 
    -0.07092638f, -0.03558644f, -0.04840153f, -0.06648849f, -0.09495137f, 0.02715724f, -0.06673940f, -0.00495234f, 
    0.01187083f, 0.04073554f, 0.04288873f, -0.04725099f, -0.00057739f, -0.05184146f, -0.01653197f, -0.06945875f, 
    0.07593532f, 0.03644853f, -0.03149009f, -0.07777907f, 0.01811161f, -0.10099876f, 0.01154190f, 0.03159288f, 
    -0.04713640f, -0.06827271f, -0.07082224f, -0.09511021f, 0.06704665f, -0.05302610f, 0.04651005f, 0.03743051f, 
    -0.16765064f, 0.04585087f, 0.03611659f, 0.02284822f, 0.06892909f, -0.03232272f, -0.09995314f, 0.03861716f, 
    0.11945144f, -0.06766687f, 0.09201127f, -0.00343349f, -0.26353779f, -0.09681001f, -0.01296549f, 0.51097018f, 
    -0.23416713f, 0.00023998f, 0.22631215f, 0.34177607f, -0.01380673f, 0.13620348f, -0.11593977f, 0.60550529f, 
    0.17360452f, 0.09014210f, 0.03818581f, -0.25889048f, 0.07448579f, 0.24367274f, 0.00113338f, 0.25703031f, 
    0.07319722f, -0.61968178f, 0.12282959f, 0.01772431f, 0.07538170f, -0.19033471f, -0.08843239f, 0.10796119f, 
    -0.13532856f, 0.08609958f, -0.20451736f, -0.05591659f, -0.20239849f, 0.08168875f, -0.24398898f, 0.14451534f, 
    -0.29171431f, -0.07089989f, 0.09341244f, -0.11672762f, -0.27156067f, 0.05628648f, -0.10088427f, 0.07500601f, 
    -0.27914193f, 0.42262039f, -0.24988078f, 0.08400602f, 0.01018599f, -0.04124943f, 0.14350027f, 0.21766210f, 
    0.08630490f, -0.09033266f, 0.09347833f, 0.10089704f, 0.03953606f, 0.06321601f, 0.10726999f, -0.24589653f, 
    -0.04296300f, -0.47593901f, 0.01891947f, 0.13767146f, 0.03303470f, 0.22004953f, 0.05202661f, -0.79357815f, 
    0.30565232f, -0.37634110f, -0.28282285f, 0.34151721f, 0.14427361f, 0.05023380f, 0.38188794f, 0.12183645f, 
    0.05382800f, 0.22286800f, 0.31561151f, 0.31409246f, -0.04812649f, -0.09600468f, 0.08268533f, 0.02780690f, 
    -0.05114069f, -0.05875989f, -0.00697207f, 0.06421634f, 0.06976395f, -0.02200149f, 0.01288022f, 0.18914559f, 
    -0.12121197f, -0.03389051f, -0.54709131f, -0.26249415f, 0.15971814f, 0.08598779f, 0.22510357f, 0.49863303f, 
    0.07296004f, -0.09322081f, 0.18933275f, 0.17866664f, 0.03958667f, 0.19451416f, 0.19879764f, -0.23719069f, 
    0.05525636f, -0.07996376f, -0.11731600f, -0.04312759f, -0.10072115f, -0.32196081f, 0.39705876f, 0.07998016f, 
    0.01840374f, 0.03737589f, 0.05841096f, 0.01460026f, -0.07088919f, 0.00978391f, -0.07380757f, -0.06063933f, 
    -0.08413079f, 0.01481451f, -0.06015876f, -0.08696773f, 0.02704931f, -0.02441165f, 0.01515431f, -0.05456445f, 
    -0.02727647f, -0.01211495f, -0.01044556f, -0.03948336f, -0.06505454f, -0.02529855f, -0.04048650f, -0.02698646f, 
    0.02489766f, -0.07502960f, 0.02977591f, 0.06125348f, -0.03405149f, 0.05097611f, -0.02523140f, 0.05984958f, 
    0.06340674f, 0.01608790f, 0.05419677f, 0.02014597f, -0.02647441f, -0.02636040f, 0.07830468f, 0.06206278f, 
    -0.03126981f, 0.01135625f, -0.00953775f, -0.03846730f, 0.05494974f, -0.02605671f, 0.04865656f, -0.09199435f, 
    0.00632446f, 0.00230838f, -0.05113520f, -0.04760640f, -0.04747232f, -0.07897475f, -0.04402054f, 0.04118933f, 
    0.02509691f, -0.06159398f, 0.03968998f, -0.00674244f, -0.02464198f, 0.01221878f, -0.09965832f, -0.07766413f, 
    -0.09125251f, -0.07496649f, 0.06721701f, -0.03845540f, -0.03224192f, -0.00190170f, -0.05852980f, 0.05773783f, 
    -0.03550415f, -0.06606287f, -0.05613486f, -0.08982099f, -0.00181208f, 0.06609636f, 0.01996792f, -0.06275468f, 
    -0.10683472f, 0.03144718f, -0.07346408f, 0.02399433f, -0.07384712f, 0.04242934f, -0.05709624f, -0.08507862f, 
    0.05546435f, -0.07393878f, -0.06129159f, 0.07452074f, -0.02962139f, -0.02766942f, 0.02651922f, -0.05837283f, 
    0.04164909f, 0.07005630f, -0.05637692f, 0.01288453f, -0.04951060f, 0.03753907f, -0.04284005f, -0.08745874f, 
    -0.01935064f, 0.06109421f, -0.05661589f, 0.05939047f, 0.05826731f, -0.05289569f, -0.01534659f, 0.07525103f, 
    -0.06240220f, 0.03017200f, -0.09632938f, 0.00292637f, -0.06871666f, -0.06602383f, -0.08455002f, 0.07012305f, 
    -0.06605553f, 0.01970719f, 0.01737869f, -0.07849538f, 0.02267864f, 0.05845987f, -0.06221570f, -0.00418592f, 
    0.17978644f, -0.06114595f, 0.56591266f, -0.08825941f, 0.09885422f, 0.08865900f, 0.05507419f, 0.30477905f, 
    -0.08964729f, -0.01018074f, -0.06138493f, 0.17600210f, 0.30277956f, 0.24723430f, 0.04142201f, 0.00152150f, 
    0.14364304f, -0.11347815f, 0.06430467f, 0.11198600f, 0.13493420f, -0.05811824f, 0.43646833f, -0.03251120f, 
    -0.24230479f, -0.06681301f, -0.07802087f, 0.55110669f, -0.04690063f, -0.07690756f, -0.00473257f, 0.20150054f, 
    0.43633968f, -0.11471146f, -0.17093158f, 0.08514196f, -0.02027066f, -0.03860482f, -0.31879121f, 0.07683434f, 
    -0.07862993f, -0.04004641f, -0.00073443f, -0.18694894f, 0.19000414f, 0.07564309f, 0.08702104f, -0.05096542f, 
    0.05911533f, -0.21174191f, -0.43369961f, -0.07604718f, 0.02730712f, 0.19832782f, -0.28155240f, -0.09627052f, 
    0.08419143f, -0.07572004f, -0.19075747f, 0.07853182f, 0.15249462f, 0.29674134f, -0.17798662f, -0.02838807f, 
    0.07504428f, -0.06777965f, -0.01737606f, -0.35384297f, -0.01396546f, 0.09108881f, -0.09691310f, -0.05021167f, 
    0.01996076f, 0.03194254f, 0.06378289f, -0.02135068f, 0.28465876f, 0.19080609f, -0.15551125f, 0.16397798f, 
    0.09837471f, -0.06683896f, -0.16112030f, 0.18289773f, 0.06586473f, 0.05164238f, -0.06482732f, -0.29693741f, 
    0.11685772f, 0.21782766f, -0.16194753f, -0.11803067f, 0.21720424f, 0.06311101f, 0.05081883f, 0.10679901f, 
    0.17787500f, 0.15348788f, 0.36074969f, 0.00820364f, 0.13036655f, 0.04048374f, 0.04914473f, -0.12892719f, 
    0.19911018f, 0.06891978f, 0.12822622f, -0.16235320f, -0.08167984f, -0.06117056f, -0.21783537f, -0.14381784f, 
    0.07059565f, 0.13195308f, 0.05590862f, 0.15230957f, 0.03540632f, 0.03483656f, -0.22387084f, -0.05747809f, 
    -0.11246268f, 0.35580018f, -0.31760651f, -0.12619007f, -0.37248567f, -0.01883387f, -0.15208086f, -0.11519511f, 
    0.00522930f, 0.01942602f, -0.05768869f, -0.04589374f, 0.04531273f, -0.00807375f, -0.00021420f, -0.01550835f, 
    -0.04600452f, -0.02101863f, 0.01707890f, 0.03757197f, 0.07197332f, -0.04482195f, 0.02419031f, -0.04129732f, 
    -0.08441947f, -0.04998938f, 0.06396966f, -0.00904456f, 0.01889617f, -0.02725243f, -0.08975253f, 0.00623994f, 
    0.04678763f, 0.02966349f, 0.00058459f, -0.06555577f, 0.01580435f, 0.00904069f, 0.02783064f, 0.03561126f, 
    -0.01386972f, -0.02603730f, -0.00013757f, -0.08089155f, -0.03281866f, -0.08798535f, -0.01690213f, -0.10190959f, 
    -0.00293378f, 0.06122066f, 0.04182013f, -0.08140481f, -0.07897544f, 0.00048183f, -0.03465112f, 0.06958901f, 
    -0.03859055f, 0.03305692f, -0.08004940f, -0.02697287f, -0.01081455f, 0.05821586f, 0.03979602f, -0.07079366f, 
    0.03341042f, -0.02579685f, -0.08415002f, 0.02608158f, -0.07342977f, 0.06570098f, 0.05735957f, -0.03808740f, 
    0.04733652f, 0.03253719f, -0.08109631f, -0.07656971f, 0.05034452f, -0.06327117f, -0.07845325f, 0.07124510f, 
    0.00984486f, -0.12168317f, -0.09815603f, -0.04811569f, 0.06103215f, -0.06891299f, 0.06393331f, -0.06082194f, 
    -0.07896315f, 0.02629464f, 0.05220261f, 0.00147139f, -0.09039357f, 0.02770737f, -0.06352768f, -0.03645258f, 
    -0.04927195f, 0.00733360f, -0.03097250f, 0.08076120f, -0.08302121f, 0.01623348f, -0.03111092f, -0.02625167f, 
    0.03698522f, 0.07023137f, -0.03295676f, -0.01811410f, -0.09911928f, -0.02483266f, -0.05132206f, -0.06740435f, 
    0.04417069f, -0.00555640f, -0.04799885f, -0.05182722f, -0.08504055f, 0.03373916f, -0.09604289f, -0.06583307f, 
    0.05989827f, -0.06318654f, -0.09747960f, -0.07814733f, -0.07191446f, -0.00526551f, -0.04292035f, -0.01471335f, 
    -0.05627068f, -0.01663523f, -0.02520833f, -0.04276983f, -0.00861265f, -0.00787312f, -0.03016060f, -0.01003805f, 
    -0.02141610f, -0.08563326f, -0.03113786f, -0.03350224f, -0.03513906f, -0.05252608f, -0.03214781f, -0.09002644f, 
    -0.05287218f, -0.04724792f, 0.04023659f, -0.07773092f, -0.02969480f, -0.03992483f, 0.04280808f, 0.04947820f, 
    -0.03951059f, -0.11159196f, 0.01511366f, 0.04672050f, -0.03490414f, -0.10137636f, -0.01097018f, -0.02026744f, 
    0.00169823f, 0.02832112f, 0.05294492f, -0.04619277f, -0.09240667f, -0.08794968f, 0.02401999f, 0.01621208f, 
    -0.04055805f, 0.05525441f, -0.11326040f, -0.01152799f, 0.01313645f, -0.06399129f, 0.02001139f, -0.10222615f, 
    -0.09067713f, -0.03597827f, 0.06023323f, 0.03363917f, 0.06470317f, 0.04458645f, -0.00772656f, -0.11024053f, 
    -0.03658190f, -0.09794654f, -0.00900804f, -0.09074661f, 0.02939616f, 0.08031877f, -0.07699024f, 0.00650480f, 
    -0.00560164f, -0.06244756f, 0.05915971f, 0.05039829f, -0.06227674f, -0.05334045f, 0.01796841f, -0.00502106f, 
    -0.09590378f, 0.00904139f, 0.01425109f, -0.09005936f, 0.04574699f, -0.06348357f, -0.05399558f, -0.04128847f, 
    -0.04812676f, -0.07157854f, 0.03310361f, -0.02781548f, -0.01666119f, -0.07606153f, 0.00518419f, -0.04867806f, 
    0.08178108f, -0.07077529f, 0.04099526f, 0.00146416f, -0.07032901f, 0.02692095f, -0.05890151f, 0.04939844f, 
    -0.00222102f, -0.02985444f, 0.08745404f, -0.00976110f, -0.08664454f, -0.05802823f, -0.08555400f, -0.00597047f, 
    0.04050923f, 0.02676462f, -0.01750503f, -0.01209372f, -0.03215029f, -0.04305732f, -0.03892460f, -0.08879822f, 
    -0.05309764f, -0.07491891f, 0.02411105f, -0.03711149f, -0.08977989f, -0.07657856f, -0.03048938f, 0.00881169f, 
    0.08669494f, -0.06898686f, -0.00704824f, 0.00426393f, -0.04444231f, -0.01233089f, -0.01146777f, 0.03712076f, 
    -0.02558859f, -0.03940339f, 0.03692922f, -0.01444395f, -0.01739924f, 0.01897772f, 0.00998836f, 0.06135751f, 
    0.06237552f, 0.01422389f, 0.35899919f, 0.06843046f, 0.11445191f, 0.20533215f, -0.00323926f, 0.13077649f, 
    0.17515656f, -0.06344794f, -0.13441771f, -0.05534028f, -0.19264837f, -0.01737195f, 0.03114096f, -0.09876870f, 
    0.00429858f, -0.25838915f, 0.28472352f, 0.21125506f, -0.00483372f, 0.03666118f, 0.37189895f, 0.27685204f, 
    0.03494280f, 0.03744494f, -0.05595449f, 0.01639122f, 0.13601416f, -0.13589619f, -0.03014719f, -0.12092197f, 
    -0.09748650f, -0.31466952f, 0.04427134f, 0.02169138f, 0.14299986f, -0.11450960f, 0.28342757f, -0.04822193f, 
    -0.00234266f, 0.10012659f, -0.17025834f, 0.19593601f, 0.08309443f, -0.07588344f, 0.01378691f, 0.11548680f, 
    -0.19867739f, -0.00816321f, -0.08207142f, 0.13669749f, 0.20557290f, -0.31931916f, 0.05635216f, -0.03101240f, 
    0.01875153f, 0.08314553f, -0.05813339f, 0.14488298f, 0.06184575f, -0.24542566f, 0.07202361f, 0.32081383f, 
    0.07548622f, -0.18761352f, 0.14462382f, 0.04858581f, 0.09812182f, -0.10154955f, -0.20300691f, 0.09800953f, 
    0.01028296f, -0.04910407f, -0.07491542f, 0.02611747f, -0.02148798f, -0.00438439f, 0.03182346f, -0.01874393f, 
    0.06904420f, 0.22113764f, -0.64866585f, 0.16398130f, 0.11829510f, 0.02072626f, 0.31393296f, -0.09090614f, 
    -0.10090026f, 0.20002855f, 0.31965047f, 0.16497703f, 0.01727613f, -0.17425980f, -0.08774485f, 0.02644028f, 
    0.16310410f, -0.14370885f, -0.05792827f, -0.28821182f, 0.05671090f, -0.12114599f, -0.06040534f, -0.24566634f, 
    -0.08773719f, 0.10330856f, -0.04799699f, -0.07279756f, -0.05605079f, 0.03331694f, -0.00732431f, 0.40189165f, 
    0.08182802f, 0.05057940f, 0.03252978f, -0.15337780f, 0.07011677f, 0.20513882f, 0.08828887f, 0.05843520f, 
    -0.19327538f, 0.19711676f, -0.18071544f, -0.11130900f, 0.13315590f, 0.12772810f, 0.37349296f, 0.11744600f, 
    0.10195453f, 0.00299920f, 0.35903031f, 0.04196012f, -0.04379879f, 0.12478793f, -0.07382396f, 0.06197088f, 
    -0.12657194f, -0.10015339f, 0.25374922f, 0.10059742f, 0.23818287f, 0.44046903f, -0.01455026f, 0.22450909f, 
    0.16567315f, -0.09138989f, -0.00669571f, 0.19798173f, 0.28232226f, -0.00581768f, 0.28910774f, -0.09952240f, 
    -0.04327041f, 0.01002428f, 0.05882235f, 0.14209913f, 0.14399098f, -0.16870497f, 0.01244132f, -0.00399980f, 
    -0.24821337f, -0.42685246f, 0.20089972f, -0.14459284f, 0.31568623f, -0.26137581f, 0.13552873f, 0.00976695f, 
    0.04499468f, 0.04287217f, 0.07027099f, 0.09073482f, -0.22582194f, -0.02735127f, 0.11774451f, 0.01764244f, 
    -0.18159141f, -0.02902122f, -0.05254179f, 0.08344260f, 0.38825333f, 0.32613683f, -0.15111493f, -0.18806513f, 
    0.23438928f, 0.11718440f, 0.02352057f, 0.09592317f, 0.14406586f, 0.00019274f, 0.02033204f, 0.12607419f, 
    0.24956985f, 0.10835671f, 0.02146826f, -0.20708495f, 0.06793208f, 0.02220517f, -0.16494280f, -0.01663521f, 
    0.01933967f, -0.00523902f, 0.00148937f, -0.07926633f, 0.07405648f, 0.10572311f, -0.07154436f, -0.24715358f, 
    0.02621719f, -0.23641986f, -0.35483328f, 0.07871035f, 0.14037393f, 0.07978949f, 0.05411370f, 0.05985121f, 
    0.18149017f, 0.16971497f, -0.02594997f, -0.26500878f, 0.01496669f, 0.11759906f, -0.03757386f, -0.06998269f, 
    0.20541531f, 0.01707412f, 0.30036175f, 0.01889604f, 0.04897728f, 0.16645323f, -0.03302313f, 0.06120830f, 
    0.09951311f, 0.02799552f, -0.26682445f, -0.30521846f, -0.00878171f, 0.12943536f, 0.06206364f, 0.07643327f, 
    -0.01602199f, 0.18483886f, -0.04139187f, 0.03669672f, 0.05252500f, 0.15632528f, 0.07426439f, 0.14199410f, 
    -0.00508576f, 0.21943854f, -0.12303837f, -0.06247551f, 0.05424617f, -0.42623472f, -0.07900433f, -0.38226196f, 
    -0.09436297f, -0.02919104f, 0.01473662f, -0.00758947f, 0.05724532f, 0.03616053f, -0.05258885f, -0.09247102f, 
    -0.09778106f, -0.08730119f, -0.04945670f, -0.03988106f, 0.03531226f, 0.02399832f, -0.06461012f, 0.02298707f, 
    -0.02154578f, -0.07861266f, -0.03142666f, 0.04446594f, -0.02511854f, 0.04567648f, 0.05523020f, -0.02466157f, 
    -0.05238354f, 0.00281705f, -0.10666998f, -0.06761651f, -0.06452326f, -0.09195498f, -0.05332181f, -0.07625282f, 
    0.03010513f, 0.01693267f, -0.01125850f, -0.06629521f, -0.04746532f, 0.03109904f, 0.02767589f, 0.04318874f, 
    -0.08519045f, 0.03129952f, -0.00509488f, 0.01523088f, 0.08503883f, 0.08711538f, -0.09073599f, 0.03785205f, 
    0.03342427f, 0.04451039f, 0.02255652f, -0.07732435f, -0.06861023f, -0.04418885f, -0.10683341f, -0.04520036f, 
    -0.02500689f, -0.06933936f, 0.06414934f, -0.09690727f, -0.07493041f, 0.04254670f, 0.05961525f, 0.03122964f, 
    -0.02569603f, 0.02003274f, -0.01703410f, -0.11844061f, -0.01161473f, -0.06739299f, -0.01799340f, -0.03387873f, 
    0.02659580f, -0.10107087f, 0.01592590f, -0.06114988f, -0.02895187f, 0.06145105f, 0.01455427f, -0.00459674f, 
    -0.02237489f, -0.01537314f, -0.06643625f, -0.06441869f, -0.11284333f, 0.00865372f, -0.03126461f, 0.02331458f, 
    -0.05297461f, 0.06776043f, 0.07953581f, -0.05357929f, -0.00177154f, 0.02877421f, -0.01809045f, 0.03245797f, 
    -0.06567612f, 0.03567830f, -0.06243395f, -0.10548236f, -0.03962236f, 0.05291005f, 0.01372292f, -0.10876007f, 
    0.04330289f, -0.09259647f, -0.02040207f, 0.03795433f, -0.02689525f, -0.11476190f, 0.02766949f, -0.02184220f, 
    0.05669265f, -0.01533438f, 0.04768518f, -0.04172150f, -0.05001231f, -0.04848162f, 0.05748615f, -0.04779442f, 
    -0.02875927f, -0.04477487f, -0.02101342f, -0.08214948f, -0.02089498f, -0.08309109f, -0.01445947f, 0.07158492f, 
    -0.08951696f, 0.03167649f, 0.46837077f, 0.20770052f, -0.03307888f, 0.19862396f, 0.21852447f, 0.29863635f, 
    -0.09219347f, 0.10858975f, 0.01417846f, 0.27341071f, 0.28034338f, 0.38280138f, -0.00372542f, 0.02224749f, 
    0.22551756f, -0.08646595f, 0.18863592f, 0.06445690f, 0.38149270f, 0.07459929f, 0.16344868f, -0.11216463f, 
    -0.25309783f, -0.00734428f, 0.14965394f, 0.57504386f, -0.05774779f, -0.04610163f, 0.02342733f, 0.22786643f, 
    0.42849594f, -0.02369402f, 0.00071230f, 0.19913436f, 0.00626776f, 0.10781438f, 0.11163404f, -0.07349861f, 
    -0.19989550f, -0.03246427f, -0.00851839f, -0.19244896f, -0.18225873f, -0.00765840f, 0.08612362f, 0.02959311f, 
    0.00822909f, -0.00274595f, -0.08094028f, 0.05649923f, 0.25810924f, 0.24767914f, -0.18845463f, 0.07454283f, 
    0.11840679f, -0.28012839f, -0.07503382f, 0.38303149f, -0.11385705f, 0.22573189f, 0.01122927f, -0.11495635f, 
    -0.04757580f, -0.05592764f, 0.13112150f, -0.28346008f, 0.02885758f, 0.03746599f, -0.22036777f, 0.01731148f, 
    0.01805769f, 0.07109163f, 0.07649312f, 0.00829711f, 0.38827276f, 0.13144042f, -0.29638731f, -0.06760173f, 
    -0.15896758f, -0.20327771f, -0.17272677f, 0.04665740f, 0.16727386f, -0.00981356f, -0.10696238f, -0.10856341f, 
    0.26988077f, 0.20869569f, 0.11822864f, -0.41997460f, -0.19080569f, 0.11482725f, 0.02601024f, -0.07760366f, 
    0.28540206f, 0.11905453f, 0.30938372f, -0.11327966f, 0.03273400f, 0.20407365f, -0.05233029f, -0.02741762f, 
    0.30772305f, -0.11892027f, -0.23438908f, -0.03953534f, -0.10885749f, 0.00570573f, -0.18221420f, -0.10455106f, 
    0.03577788f, 0.21395101f, -0.05282887f, 0.17634064f, -0.01991436f, 0.00069137f, -0.04973738f, -0.08169822f, 
    -0.05711554f, 0.49997845f, -0.53859740f, -0.21964544f, -0.26457146f, -0.31669751f, -0.44900489f, -0.18804164f, 
    0.17019217f, 0.04113381f, -0.63119179f, -0.21686123f, 0.18840493f, -0.18390973f, -0.21364777f, -0.10398187f, 
    0.30793425f, 0.20520404f, 0.02159068f, 0.06107393f, -0.02440698f, -0.18808326f, 0.03091196f, 0.40016529f, 
    0.31229404f, 0.08747603f, 0.12330311f, 0.05166260f, -0.04250261f, -0.10246070f, -0.13227350f, 0.33194482f, 
    0.02796158f, 0.01544262f, -0.02839637f, 0.13284071f, -0.08598507f, 0.35568768f, 0.05036435f, 0.07765310f, 
    0.34699178f, 0.38318020f, -0.17439707f, 0.03763253f, 0.13422425f, 0.15634112f, -0.20212926f, 0.18087234f, 
    0.18158390f, 0.04019319f, 0.03202841f, 0.00904362f, -0.12569721f, -0.01616299f, -0.19046876f, -0.08267359f, 
    -0.09511103f, -0.10805130f, -0.06509141f, -0.04200907f, -0.20513672f, -0.16857792f, -0.19912182f, 0.07889038f, 
    0.24079859f, -0.07170755f, -0.06621245f, 0.07418863f, 0.25396171f, 0.05852344f, -0.03233745f, -0.47485667f, 
    0.04143164f, -0.16181229f, -0.03054103f, -0.02586857f, -0.23147497f, -0.08214549f, 0.12960699f, -0.09586532f, 
    0.03279882f, -0.21009649f, 0.35598573f, 0.02854054f, 0.01653567f, 0.09508725f, -0.23413689f, 0.15204176f, 
    -0.02705040f, 0.18001388f, 0.12035690f, -0.20344982f, -0.09168662f, -0.03413628f, 0.09970256f, -0.12568818f, 
    0.11291673f, 0.05804301f, 0.04519951f, 0.25266343f, 0.16261427f, -0.12100662f, -0.03769794f, 0.05012413f, 
    0.07414418f, -0.13342434f, -0.02567421f, -0.06365993f, 0.16010362f, 0.22048345f, -0.06704040f, -0.06323480f, 
    0.09050018f, 0.07618422f, 0.22416836f, -0.01310524f, 0.06151817f, 0.21959428f, 0.12838766f, -0.35583478f, 
    -0.06188761f, -0.28502336f, 0.04782514f, -0.02880502f, 0.11745446f, 0.11538264f, 0.02072834f, -0.00335186f, 
    0.15619454f, 0.06118677f, 0.05020827f, -0.06822438f, -0.03829225f, 0.23416197f, -0.53538156f, 0.20317480f, 
    0.32347342f, -0.22342224f, 0.07379586f, 0.17202850f, 0.09753701f, 0.14168678f, -0.00446891f, 0.22423618f, 
    0.05439565f, -0.05150481f, -0.00153778f, -0.08571623f, 0.03003581f, 0.18910153f, 0.02914495f, -0.11198404f, 
    -0.04965897f, -0.32376117f, 0.31525242f, 0.07704559f, 0.11799774f, -0.37531254f, 0.35190085f, 0.02093711f, 
    -0.31293181f, 0.14173409f, -0.05636004f, -0.34620607f, 0.15291715f, -0.13683049f, -0.08626224f, 0.08834425f, 
    -0.31025296f, -0.39438930f, 0.09062294f, 0.03080637f, 0.27187571f, -0.19731529f, 0.02996046f, -0.01383734f, 
    -0.14450756f, -0.00886687f, -0.30342987f, -0.04101154f, -0.11109076f, -0.02496803f, 0.14779167f, 0.05824107f, 
    0.05823641f, -0.26345924f, -0.01296931f, 0.00199959f, -0.02568621f, 0.09168442f, 0.05176469f, 0.08859006f, 
    0.14509730f, -0.19812663f, -0.26639542f, 0.25288972f, -0.05421646f, -0.29645696f, -0.14388952f, 0.25673652f, 
    -0.00045329f, 0.05724431f, 0.12005611f, -0.26637244f, 0.15558462f, -0.03893836f, -0.01984481f, -0.07516335f, 
    -0.05987328f, 0.32198113f, -0.08847036f, -0.06862645f, -0.07138389f, -0.08013076f, -0.14670905f, -0.02623209f, 
    0.29075491f, 0.15705885f, -0.33767116f, 0.02260585f, 0.21204333f, 0.01843184f, 0.36786699f, -0.06376010f, 
    0.00366667f, -0.00228390f, -0.14696543f, -0.20747262f, 0.21059819f, -0.02815107f, -0.07631604f, 0.02387477f, 
    0.13106686f, -0.19867899f, 0.31512210f, -0.03482144f, 0.33777490f, 0.08321906f, -0.01305132f, -0.01106806f, 
    -0.04969902f, 0.04221794f, 0.10103736f, 0.49121013f, -0.05472639f, -0.11497107f, 0.06817799f, 0.05523161f, 
    0.05649074f, 0.21487106f, 0.20501122f, -0.15314060f, 0.04430923f, 0.15023984f, -0.03709547f, 0.14657925f, 
    -0.17640802f, -0.00825980f, -0.26078978f, -0.19453572f, -0.08294067f, 0.28353527f, 0.01554315f, 0.03618948f, 
    -0.01029667f, -0.08873422f, -0.00428626f, -0.07503043f, -0.06348353f, -0.08612809f, 0.07862844f, -0.08223728f, 
    0.07386996f, 0.06320943f, 0.01778489f, -0.01090446f, 0.02794695f, -0.06089463f, -0.04935078f, -0.04922928f, 
    -0.09072902f, -0.06412045f, 0.07123608f, -0.05780055f, 0.01722969f, -0.03224383f, -0.09699033f, -0.05896333f, 
    0.01108779f, 0.07289484f, -0.00166971f, -0.06662334f, -0.08527022f, 0.02656815f, -0.06297813f, -0.04598017f, 
    0.07868060f, 0.00604628f, 0.02504019f, -0.04087448f, -0.10554468f, 0.01959178f, -0.10866852f, -0.09432322f, 
    -0.09066378f, 0.07226953f, 0.04265092f, -0.09652470f, -0.05016604f, -0.00598128f, 0.05315283f, 0.02467919f, 
    -0.04571991f, -0.01531221f, 0.02172327f, 0.06280531f, 0.02445277f, 0.05555807f, -0.02902120f, -0.01392121f, 
    -0.06569465f, 0.02224145f, 0.00817598f, 0.03860894f, 0.02964924f, -0.06659289f, 0.02690131f, 0.06281725f, 
    0.04737588f, 0.04009844f, -0.06801949f, -0.02677915f, -0.08021574f, -0.05214499f, -0.06943953f, -0.00445823f, 
    -0.06197251f, 0.04886038f, -0.05222648f, -0.07676145f, -0.02493246f, -0.00976971f, -0.05151129f, -0.06287031f, 
    -0.03631775f, -0.03789778f, 0.07430127f, -0.04997154f, -0.03572245f, 0.02485201f, -0.03125425f, 0.00047714f, 
    -0.03136817f, 0.04181681f, -0.01968555f, -0.02714607f, 0.06635915f, 0.04800129f, 0.05113239f, 0.03225330f, 
    -0.07047388f, 0.04925463f, 0.06074864f, 0.02240765f, -0.00602933f, -0.07407250f, -0.05871407f, 0.00451441f, 
    -0.03635430f, 0.03087205f, -0.11576492f, -0.09136785f, -0.00796146f, -0.06984773f, 0.04799657f, -0.05340609f, 
    0.00442163f, -0.06331488f, -0.06532667f, -0.02867747f, -0.06202827f, 0.05434712f, -0.06606510f, -0.06818916f, 
    0.02907463f, 0.05434339f, 0.04608075f, -0.08967703f, 0.02700213f, -0.06141802f, -0.04221073f, -0.08467709f, 
    -0.12023392f, 0.04453497f, -0.28862342f, -0.45172706f, 0.28863692f, 0.01542040f, 0.29338050f, -0.14526527f, 
    0.23912413f, 0.19138934f, 0.00476870f, 0.04775429f, -0.16504370f, -0.38057423f, -0.01995627f, -0.39979637f, 
    0.06263914f, 0.28819409f, 0.08547887f, -0.02095400f, -0.03385839f, 0.09803973f, -0.16076364f, -0.25254408f, 
    0.03518356f, 0.19857049f, 0.29983535f, -0.09475446f, -0.00990466f, 0.22457913f, 0.04298699f, 0.17327489f, 
    -0.00544285f, 0.39099821f, -0.24361226f, 0.21199594f, -0.22272779f, 0.38142610f, 0.14883959f, 0.09157386f, 
    -0.03189984f, 0.03213165f, -0.14738679f, -0.04617120f, 0.24893178f, 0.00749606f, -0.02730179f, -0.01021959f, 
    0.00184339f, 0.14646536f, 0.07955433f, -0.27761912f, -0.37591970f, -0.07286361f, -0.07818637f, 0.34207740f, 
    -0.19346763f, -0.02728971f, 0.15880135f, -0.10036699f, -0.06385427f, 0.31225467f, 0.17144684f, -0.50238353f, 
    -0.35812509f, 0.07382982f, 0.24393857f, 0.34193209f, -0.07379387f, -0.02408449f, 0.11047875f, 0.14370422f, 
    -0.07436719f, 0.33317068f, 0.10941224f, -0.04266316f, -0.10991750f, -0.09465609f, 0.23407660f, 0.07338063f, 
    -0.33193108f, 0.08574785f, 0.37021187f, -0.11627255f, 0.02719988f, -0.00192461f, -0.13015392f, -0.07048178f, 
    -0.05199209f, -0.04634352f, 0.05422029f, 0.09351882f, -0.05946777f, -0.02020038f, 0.07750984f, 0.05459707f, 
    -0.11063199f, 0.11327334f, -0.30039966f, -0.18334343f, -0.12462603f, -0.14877394f, 0.08412653f, 0.08713205f, 
    0.00183922f, 0.12512499f, 0.20292738f, 0.23104689f, 0.09343959f, -0.00600574f, 0.03182406f, -0.17086850f, 
    0.04253921f, -0.20069659f, -0.04140355f, 0.11442222f, 0.36044204f, -0.03565651f, 0.10732013f, -0.09440915f, 
    0.02461078f, -0.11141172f, 0.06967942f, 0.07404175f, -0.01027387f, 0.07761752f, -0.18930668f, -0.10328943f, 
    0.12348807f, 0.14974587f, 0.30417007f, -0.13674292f, 0.25959203f, -0.20382307f, -0.00360049f, -0.29467830f, 
    0.18433847f, 0.30818227f, 0.00450275f, -0.08972316f, -0.02608576f, -0.29956579f, -0.06786217f, -0.28181517f, 
    -0.05237095f, 0.18295601f, -0.03109201f, 0.06107221f, -0.28163657f, 0.18324733f, -0.10108282f, -0.28357995f, 
    0.08786060f, 0.23672934f, 0.27702698f, -0.09132974f, 0.09162196f, 0.00664919f, -0.03486785f, -0.06120523f, 
    -0.17931487f, 0.80189461f, -0.12954669f, 0.18139285f, -0.11319090f, 0.41002572f, 0.09467217f, 0.20275261f, 
    0.09163433f, -0.07343963f, 0.03963790f, 0.14313260f, 0.39505506f, 0.07879579f, -0.03163084f, -0.09906754f, 
    -0.27201134f, 0.16271873f, 0.03570513f, -0.12592201f, -0.19859008f, -0.32332724f, -0.04081666f, 0.25258189f, 
    0.05318924f, -0.13365448f, 0.19146992f, -0.16455759f, 0.16200933f, 0.32094985f, 0.23330492f, -0.14066526f, 
    -0.27174664f, 0.06897674f, 0.09596895f, 0.11420149f, -0.19686945f, 0.07722778f, 0.21203816f, 0.08155671f, 
    0.06193300f, 0.32669875f, 0.11230845f, -0.24232060f, -0.12357449f, -0.26587367f, 0.16367474f, 0.02680569f, 
    -0.38812631f, 0.02796655f, -0.04898369f, -0.09078354f, -0.08092103f, 0.04081713f, -0.24568509f, -0.08705035f, 
    -0.29297921f, -0.00920710f, -0.13509011f, 0.22396807f, 0.09667792f, 0.03603006f, 0.05261084f, -0.07872793f, 
    -0.33489275f, 0.12837093f, -0.38270083f, 0.00102465f, -0.17352919f, -0.21199764f, 0.08651492f, 0.10792837f, 
    -0.17138846f, -0.04449607f, 0.18732275f, 0.35105619f, 0.07338504f, -0.10958619f, 0.09231748f, -0.28323561f, 
    0.01556696f, -0.08733762f, -0.09797867f, 0.11553978f, 0.21502419f, 0.04667633f, 0.13187641f, -0.06322981f, 
    0.22097225f, -0.29048663f, 0.21997683f, 0.14176489f, 0.00464014f, 0.02691637f, -0.00963190f, -0.12903191f, 
    -0.06334007f, 0.19757806f, -0.01911855f, -0.04208170f, -0.13735582f, -0.04444104f, -0.19956289f, 0.06564222f, 
    -0.12859476f, -0.02736729f, 0.00448347f, -0.14512786f, 0.11409681f, 0.06991662f, 0.07190197f, -0.00777767f, 
    0.22151096f, -0.03864624f, -0.33453631f, -0.21324120f, -0.00528587f, 0.17688532f, -0.16901900f, -0.53398871f, 
    -0.08061310f, 0.14414743f, 0.16044676f, -0.46180212f, -0.02493423f, -0.26594648f, 0.02071776f, -0.38587350f, 
    -0.01108657f, 0.33541149f, -0.00125989f, -0.01582844f, -0.02499703f, 0.27466911f, 0.08713733f, 0.04593578f, 
    0.03550335f, -0.07615655f, 0.34438169f, 0.36960638f, 0.35469893f, 0.00445908f, 0.26428217f, 0.13251404f, 
    -0.41437054f, 0.19074902f, -0.00507147f, -0.15739219f, 0.27950919f, 0.07284623f, 0.12537703f, 0.04379953f, 
    0.10757329f, -0.52505159f, 0.28302482f, -0.10513683f, 0.12177973f, 0.16195124f, -0.01326312f, -0.05181438f, 
    -0.32658264f, 0.14835434f, 0.12847391f, 0.12146427f, 0.16133246f, 0.04680433f, 0.02228558f, 0.08602534f, 
    -0.08037162f, -0.05444061f, -0.04795044f, -0.17298652f, -0.28458199f, -0.14107564f, 0.17245124f, 0.17116438f, 
    -0.04523974f, -0.05718933f, 0.00118721f, -0.37486309f, 0.04549002f, 0.01216232f, -0.41143975f, 0.10801724f, 
    -0.00424970f, -0.12734984f, -0.42545396f, 0.09731988f, 0.13786381f, 0.22212315f, 0.12019748f, 0.00082998f, 
    -0.02897855f, 0.08466285f, 0.07172365f, 0.15435840f, 0.08725374f, -0.03451167f, -0.00035732f, 0.09378094f, 
    -0.20781536f, -0.01497836f, -0.12729214f, -0.26982424f, -0.06323210f, -0.12229639f, 0.10659468f, -0.30859429f, 
    0.02593152f, 0.26590359f, -0.09518174f, 0.06465995f, 0.03694680f, 0.01444400f, 0.13860337f, 0.09684804f, 
    0.12831390f, -0.21284102f, 0.17421260f, 0.14837210f, -0.22082476f, -0.13572808f, -0.16688596f, 0.21827850f, 
    0.00671056f, -0.29154348f, -0.17596713f, -0.23269223f, 0.08937079f, 0.06771008f, 0.10471357f, -0.12889598f, 
    0.40763548f, 0.08432345f, 0.11280463f, -0.06094465f, -0.12432485f, -0.02900111f, -0.05729334f, 0.61356109f, 
    0.00424156f, -0.25182894f, 0.12052163f, 0.16452958f, -0.07652783f, -0.14567927f, -0.35532638f, 0.31965771f, 
    0.14536726f, -0.14404084f, 0.07450286f, -0.36709100f, 0.03555474f, 0.09454295f, 0.07158623f, -0.05128515f, 
    -0.04754507f, 0.10865372f, 0.19380023f, -0.35517141f, 0.20633292f, 0.03867795f, 0.01822320f, 0.01000052f, 
    0.11913650f, -0.10822041f, -0.14822575f, -0.01702843f, 0.06130737f, 0.05825269f, -0.30143434f, 0.02297071f, 
    -0.05045253f, -0.16493492f, 0.11700623f, 0.24966291f, 0.73191518f, -0.07064426f, -0.13313076f, -0.12778525f, 
    0.17627577f, -0.04835100f, -0.13869634f, 0.11966892f, 0.06941620f, -0.23100583f, 0.01275476f, 0.12867236f, 
    0.30513552f, -0.58872700f, -0.34162816f, -0.22646759f, -0.12182030f, -0.00442803f, -0.28197867f, -0.09910654f, 
    0.03141760f, 0.29657376f, 0.28120896f, -0.14047678f, 0.01063482f, 0.17110313f, -0.43054053f, -0.43673027f, 
    0.25838137f, -0.05234516f, -0.67437786f, 0.06337562f, -0.11700662f, -0.00605682f, 0.35474968f, 0.12306836f, 
    0.05544969f, -0.10813760f, 0.08106518f, 0.32690480f, 0.01213084f, 0.01713298f, -0.03646385f, 0.04352547f, 
    -0.06313689f, -0.45050940f, -0.07298582f, -0.05688436f, 0.13160649f, 0.17592709f, 0.07710563f, 0.03383720f, 
    -0.01493586f, -0.08513610f, -0.24720752f, 0.30077207f, 0.06595519f, 0.28546846f, 0.22827461f, 0.18559463f, 
    -0.06690589f, -0.34483016f, -0.02951859f, -0.09434050f, 0.04804312f, -0.01345714f, 0.00013071f, 0.07042067f, 
    -0.04650749f, 0.09471486f, -0.22951628f, -0.20476308f, 0.17894782f, 0.07364144f, 0.07770867f, 0.42126936f, 
    -0.06322017f, -0.07983711f, -0.09288746f, -0.28769326f, -0.02871077f, 0.01781204f, 0.13504207f, -0.21448942f, 
    0.28915840f, 0.17542870f, 0.05513658f, 0.20811911f, -0.07695469f, -0.02885298f, -0.05648102f, 0.33238578f, 
    -0.07900506f, 0.14246663f, 0.22867349f, 0.51672423f, 0.19456445f, 0.28708479f, -0.06478951f, 0.13003065f, 
    0.30294144f, -0.18723169f, -0.17152655f, -0.02811797f, -0.15748404f, 0.26301432f, -0.04862837f, -0.03064518f, 
    0.08838876f, -0.15928340f, -0.00716561f, -0.11014515f, 0.07640178f, -0.66756225f, 0.08988687f, 0.09411161f, 
    0.10056817f, -0.06747104f, 0.16486770f, 0.01121008f, 0.14177871f, -0.02094458f, -0.48893267f, -0.11695733f, 
    -0.28288466f, -0.09505139f, -0.00646864f, 0.21072228f, -0.52077407f, 0.14477625f, -0.35036647f, 0.17433935f, 
    -0.16607353f, -0.08314134f, 0.05560123f, 0.05668100f, 0.12691642f, 0.11568607f, 0.03006093f, -0.06288050f, 
    0.25740755f, -0.34624070f, -0.16227770f, 0.19210055f, -0.07500018f, 0.01174998f, 0.37872595f, 0.09744492f, 
    0.08421463f, -0.26747805f, 0.22258523f, -0.17696010f, -0.13900504f, 0.27868021f, -0.11872647f, -0.33798623f, 
    -0.02836204f, -0.18539651f, -0.03543078f, 0.11338519f, -0.18917024f, 0.00281885f, -0.18617481f, -0.04534268f, 
    0.31301671f, 0.29201928f, 0.04843269f, 0.08282135f, 0.01303956f, -0.07529461f, -0.02002969f, -0.02431503f, 
    0.07924719f, 0.03650098f, -0.31027207f, -0.29699719f, 0.02486537f, 0.19051878f, 0.03820078f, -0.07155335f, 
    0.17608498f, 0.00887184f, -0.07693277f, -0.28730631f, 0.16862836f, 0.19294323f, -0.24773008f, -0.31781843f, 
    -0.05807353f, -0.18378206f, -0.44053921f, 0.17987074f, 0.16065998f, 0.25638306f, 0.06524643f, -0.01387741f, 
    0.31972757f, -0.00522897f, 0.08970580f, -0.10283651f, -0.09530444f, -0.23608130f, -0.18015333f, -0.13479602f, 
    -0.13653275f, 0.10255741f, 0.54815668f, -0.08728112f, -0.24797812f, 0.37509328f, -0.02427958f, 0.10585845f, 
    -0.42585307f, 0.08497088f, 0.20825620f, 0.01902138f, 0.13661718f, 0.45623234f, 0.05484226f, -0.38147193f, 
    -0.01794994f, -0.04649934f, 0.02775416f, -0.02306086f, 0.27844968f, 0.10432123f, 0.07700638f, -0.29497042f, 
    0.09065166f, 0.14155295f, 0.09365007f, -0.42566195f, 0.09077017f, -0.52179432f, 0.03657159f, -0.00165297f, 
    -0.19656007f, -0.13155609f, 0.27003452f, -0.05583425f, 0.23977083f, -0.27079332f, -0.02748883f, 0.07744365f, 
    0.01897150f, -0.03582868f, 0.15376979f, 0.08525751f, -0.02728247f, 0.07922427f, 0.33252272f, 0.20854101f, 
    0.33568782f, 0.17655668f, 0.10469755f, -0.02887560f, 0.35186961f, 0.28100798f, 0.26352012f, -0.07829294f, 
    0.12240922f, -0.07726328f, 0.05873241f, 0.12529254f, 0.03821170f, -0.03780060f, 0.19719377f, 0.22201493f, 
    0.08165285f, 0.25994503f, 0.06859876f, 0.03482265f, 0.29904547f, 0.02496267f, -0.04746443f, -0.01451241f, 
    -0.02982499f, 0.11353468f, -0.19125438f, 0.13126424f, -0.10244016f, -0.15042214f, 0.05787785f, -0.09062617f, 
    -0.27581832f, -0.20179822f, -0.02483132f, -0.24491072f, 0.30838841f, -0.06059443f, -0.09602662f, 0.08031077f, 
    0.14133660f, 0.02182151f, -0.25526434f, -0.28074408f, -0.05287405f, 0.29375499f, 0.09731233f, 0.04487305f, 
    0.06739945f, 0.13621652f, 0.19488144f, 0.11116249f, -0.19759007f, 0.17646009f, -0.06787703f, 0.10077874f, 
    0.03401005f, -0.10491373f, -0.20220432f, -0.09109693f, -0.11393544f, -0.01374151f, -0.02606690f, -0.12963085f, 
    0.04057000f, 0.46488154f, 0.10403004f, 0.05974654f, -0.08727261f, -0.07279667f, 0.20639050f, 0.17155156f, 
    0.08913805f, 0.11039828f, -0.04138659f, 0.05035726f, -0.12841906f, -0.66019922f, -0.14368932f, 0.07612962f, 
    0.15651737f, -0.08621042f, -0.69074035f, -0.80853468f, 0.03264236f, -0.05126053f, -0.28679875f, -0.29585680f, 
    0.33213860f, 0.15597117f, -0.12054595f, -0.02303320f, -0.15208960f, -0.15842955f, 0.02022111f, 0.29151791f, 
    0.21139169f, 0.13502362f, 0.17448950f, 0.28644821f, 0.14128947f, 0.03864253f, -0.13982908f, 0.07786404f, 
    0.14865741f, -0.04494284f, -0.08036656f, 0.06419436f, -0.04538516f, 0.37654039f, -0.07613944f, 0.24011153f, 
    0.37863284f, -0.03615354f, -0.30189031f, 0.11754946f, 0.19544852f, -0.01863362f, 0.27518854f, -0.15223245f, 
    0.24276431f, 0.05913021f, -0.03161777f, -0.21537462f, -0.10553434f, -0.07325267f, -0.40600485f, -0.22365741f, 
    -0.27046323f, -0.00288803f, 0.15957521f, 0.27188066f, -0.02751993f, 0.09342109f, -0.38367283f, 0.08714049f, 
    -0.06258188f, -0.28411359f, 0.11450566f, 0.15469590f, -0.03969626f, -0.08468547f, -0.04646647f, -0.17536911f, 
    0.20714967f, -0.19624737f, -0.09881488f, 0.29880717f, -0.04985588f, 0.04541907f, 0.31685156f, 0.12016091f, 
    0.00321270f, -0.11318539f, 0.36425030f, -0.03997663f, -0.28528172f, 0.12022366f, -0.25469631f, 0.00918272f, 
    0.10580149f, 0.27568942f, -0.14765260f, -0.10496185f, -0.18034051f, -0.02625151f, 0.06119491f, -0.01304248f, 
    0.15149735f, 0.00082350f, 0.18773873f, 0.04639517f, 0.03852430f, -0.23754817f, -0.00816384f, 0.04694427f, 
    0.03417906f, -0.06677266f, -0.30078503f, -0.21686095f, 0.16694358f, 0.26257914f, -0.07696516f, -0.39232281f, 
    -0.02525232f, 0.20424274f, 0.17999010f, -0.05932886f, 0.05233591f, 0.10906120f, 0.06656057f, -0.29237998f, 
    -0.01398589f, -0.47352102f, -0.24713902f, 0.11317786f, 0.24126391f, 0.22410612f, -0.04203685f, 0.03624928f, 
    0.22889067f, -0.06025862f, 0.16862133f, -0.01041862f, 0.10410158f, 0.41549486f, -0.58183616f, -0.05250192f, 
    -0.02211407f, -0.00324914f, -0.05029180f, -0.06398978f, 0.05661072f, -0.02086936f, -0.00569163f, -0.06499338f, 
    0.02395603f, -0.05853210f, -0.03209132f, -0.06255733f, -0.04586779f, -0.05757861f, 0.01150926f, -0.09046803f, 
    -0.08980066f, -0.04571698f, -0.07145467f, 0.02287665f, -0.03006829f, -0.08428206f, 0.01379406f, 0.05581767f, 
    -0.06373421f, -0.05493134f, 0.04990642f, -0.03019144f, 0.04354784f, 0.05151682f, 0.08042388f, -0.09699295f, 
    0.06017886f, 0.04770174f, -0.06546345f, -0.01849500f, -0.04722112f, -0.02800161f, 0.04291313f, -0.07258989f, 
    -0.06660116f, -0.04082377f, -0.03825431f, 0.03133971f, -0.03329011f, -0.03254572f, -0.03622749f, 0.04289730f, 
    -0.03807931f, -0.07368904f, -0.00865010f, -0.00448067f, 0.07358009f, -0.05886650f, 0.07339724f, 0.01569157f, 
    -0.02460471f, -0.07797972f, -0.03909681f, 0.06115438f, 0.01917526f, -0.04766857f, -0.03702873f, 0.01021846f, 
    -0.08082695f, 0.02381259f, -0.02609382f, 0.06106327f, -0.07405146f, -0.04201091f, -0.04518380f, 0.04960420f, 
    -0.00682560f, -0.00622891f, -0.09341265f, -0.09110621f, -0.02547450f, 0.00799670f, 0.04396775f, 0.06919144f, 
    -0.02464893f, 0.04900395f, 0.01207113f, 0.00489743f, 0.01014705f, 0.02526771f, -0.02211692f, -0.04942136f, 
    -0.00701793f, -0.06928932f, 0.05129407f, -0.03611756f, -0.01382112f, -0.08222401f, 0.00299032f, -0.02029810f, 
    -0.04354993f, 0.04867028f, -0.04086801f, -0.07459133f, -0.09180466f, -0.06499487f, -0.04500655f, 0.05540295f, 
    0.05516014f, 0.00545774f, 0.03292942f, -0.05396931f, -0.03926767f, -0.09180970f, -0.03768795f, -0.01045838f, 
    0.05733837f, 0.05955319f, -0.08130188f, 0.06210401f, -0.07043375f, -0.05533740f, 0.01944080f, 0.00769021f, 
    -0.00154539f, -0.10492883f, 0.03419843f, -0.05409677f, -0.05422859f, 0.05281750f, -0.05555600f, -0.09118440f, 
    -0.08642069f, 0.02486996f, 0.07923354f, -0.04303011f, -0.02051543f, -0.11032142f, 0.01665624f, -0.09539327f, 
    -0.05294942f, -0.07304045f, -0.06607146f, -0.01972676f, -0.01698478f, -0.00195207f, -0.06874678f, -0.04705601f, 
    -0.10468351f, 0.00422341f, -0.06888923f, -0.04697217f, -0.01985091f, 0.03883111f, -0.02659638f, -0.08065158f, 
    -0.03235620f, 0.00230935f, -0.02329266f, -0.05362581f, -0.10418694f, 0.00882054f, 0.03132283f, -0.00340803f, 
    -0.07350762f, 0.04100056f, -0.05088783f, -0.02845992f, 0.01483700f, -0.06969602f, -0.03791034f, 0.03233876f, 
    -0.05055254f, -0.07861853f, -0.07042713f, 0.02530750f, 0.06134323f, -0.07982870f, -0.06172827f, -0.06512641f, 
    -0.00673262f, -0.00989243f, -0.02010942f, -0.07711362f, 0.03958783f, -0.00250554f, -0.08531669f, -0.04525845f, 
    -0.08236679f, -0.03881444f, 0.05217661f, -0.03812403f, -0.04482099f, -0.03192661f, -0.02931321f, -0.01501753f, 
    0.06337809f, 0.02114378f, -0.03742715f, 0.05957621f, 0.03788293f, -0.02329591f, -0.09199701f, -0.09135627f, 
    -0.08038144f, -0.08251356f, 0.03057118f, 0.03269443f, -0.07214056f, -0.00579959f, -0.07548170f, -0.04156500f, 
    -0.05967436f, 0.06071163f, -0.01757617f, -0.01457452f, -0.08957005f, -0.03483881f, 0.07584228f, 0.02864004f, 
    0.03241655f, -0.08086078f, 0.06661896f, -0.08089502f, 0.02493480f, 0.03928078f, -0.06252823f, -0.04224043f, 
    -0.09479923f, -0.04438225f, -0.07409202f, -0.03570404f, -0.04249408f, -0.09474315f, 0.00103064f, 0.03470599f, 
    -0.07320683f, -0.00922622f, -0.06784487f, -0.04883159f, -0.00528399f, -0.00687704f, -0.09082867f, 0.00431191f, 
    -0.07609259f, 0.03600997f, -0.00009695f, -0.01499942f, -0.09118287f, -0.01501225f, -0.04370254f, -0.04064053f, 
    0.02468750f, 0.04887229f, -0.06148288f, -0.09549665f, 0.05696421f, -0.01100157f, -0.02550794f, 0.00604082f, 
    -0.57878733f, 0.04497784f, -0.58785897f, -0.20881215f, 0.03374925f, 0.03572423f, 0.16256487f, -0.07130533f, 
    -0.08565740f, 0.10221866f, -0.12993753f, 0.25214276f, -0.10037167f, 0.24838804f, -0.05464713f, -0.07813811f, 
    0.10097734f, 0.03474998f, 0.03737173f, -0.03213790f, 0.31731415f, 0.19558972f, -0.17944479f, 0.14341448f, 
    -0.08041935f, 0.29016733f, -0.07859626f, -0.39207670f, -0.01717702f, -0.16109233f, 0.10769577f, 0.31141531f, 
    -0.23762934f, -0.56795877f, 0.03564630f, 0.25478867f, 0.13260069f, 0.39913848f, 0.11676413f, -0.00168448f, 
    -0.07871539f, -0.08073986f, -0.00673788f, -0.19769455f, -0.03649315f, 0.05202019f, 0.17709482f, 0.14190368f, 
    0.59437042f, 0.23863509f, 0.14904532f, -0.09611313f, -0.14321631f, 0.28060663f, -0.10053189f, 0.02584483f, 
    -0.19340326f, -0.20661917f, 0.02510563f, 0.30768231f, -0.35711396f, -0.01534986f, 0.01321925f, -0.18692599f, 
    -0.04160381f, 0.09905172f, -0.01219420f, 0.50316536f, 0.09922074f, 0.04975872f, 0.18737017f, -0.04185865f, 
    0.05136497f, 0.34965429f, 0.03970483f, 0.04742847f, -0.12567849f, 0.28666925f, -0.05814649f, -0.27944106f, 
    -0.32294762f, -0.13996065f, 0.50010604f, -0.06611205f, 0.20824924f, 0.02083840f, 0.18468487f, 0.09314170f, 
    0.23773545f, 0.00553325f, -0.37855598f, 0.19761685f, -0.12382072f, 0.00964587f, 0.02464396f, 0.02562627f, 
    0.10882878f, 0.12350215f, -0.01395522f, 0.02635833f, 0.10546124f, 0.06430332f, -0.04126250f, 0.03865578f, 
    -0.05260592f, 0.29016003f, -0.10562102f, 0.30993044f, 0.11385860f, -0.07289954f, 0.23635845f, -0.13484819f, 
    -0.02182781f, 0.25220710f, 0.09986340f, 0.22037080f, 0.02995126f, -0.00171128f, 0.04302771f, -0.05375627f, 
    -0.06404129f, 0.04110093f, -0.02616802f, 0.12231398f, -0.20426920f, -0.06894441f, -0.49434826f, -0.03737003f, 
    0.01956291f, 0.23656070f, -0.28146777f, -0.29536372f, 0.19333459f, -0.13934787f, 0.22263187f, -0.32848772f, 
    0.26919860f, 0.16512501f, -0.22802344f, 0.04534964f, -0.05979504f, -0.10139062f, -0.07221007f, -0.00759502f, 
    0.04096842f, 0.24195312f, 0.15246662f, -0.00006514f, -0.03319865f, 0.14175738f, -0.00247559f, 0.05449370f, 
    0.05440484f, 0.18658729f, 0.03381917f, -0.01034772f, -0.05379773f, 0.39505041f, 0.04656503f, 0.16434345f, 
    -0.10681798f, 0.20895511f, -0.19884835f, 0.31459659f, -0.19994323f, 0.42506301f, -0.14195132f, 0.11479139f, 
    -0.01760753f, 0.06843276f, -0.37320825f, -0.22531821f, 0.53090709f, -0.03083469f, -0.04670708f, 0.02984696f, 
    0.17693251f, 0.01193053f, 0.04255585f, -0.45420751f, -0.34785679f, 0.04895428f, -0.04981945f, 0.19291277f, 
    -0.22050773f, 0.03540192f, 0.16713810f, -0.03131699f, -0.02254962f, 0.14810620f, 0.03669720f, -0.25815833f, 
    -0.25190854f, 0.09476806f, -0.07570009f, 0.39872667f, 0.13377373f, 0.04599414f, 0.32842347f, 0.12055348f, 
    0.02609880f, 0.00592463f, -0.00861299f, 0.10123600f, 0.07327382f, -0.04033514f, 0.09890264f, 0.09858026f, 
    0.29823849f, 0.12864977f, 0.26420617f, -0.02530880f, -0.15688476f, -0.03330813f, 0.20112024f, -0.06699928f, 
    -0.12753214f, 0.08698741f, -0.07269593f, 0.24485427f, 0.09041531f, -0.18014868f, 0.02536616f, -0.06435116f, 
    -0.19146852f, 0.17230591f, -0.37550053f, 0.07689678f, 0.07923025f, -0.14165068f, -0.06721397f, 0.10204310f, 
    -0.04332355f, 0.19700533f, 0.33078015f, 0.40066400f, 0.03822678f, -0.09917235f, 0.02694585f, 0.16616498f, 
    -0.06825950f, -0.07936364f, -0.08731332f, 0.03414930f, 0.15846364f, 0.08597780f, 0.05010885f, -0.16563830f, 
    0.07665312f, -0.25801182f, 0.09634075f, 0.12475208f, 0.06499197f, 0.44161808f, 0.06613334f, 0.09096983f, 
    -0.04304689f, 0.00290052f, 0.06382178f, 0.07749015f, -0.01021437f, 0.00650852f, 0.03356100f, -0.01423621f, 
    -0.09202750f, 0.00783179f, -0.04036575f, -0.04495197f, -0.01194753f, 0.02675824f, 0.07072723f, -0.06296805f, 
    0.07545257f, 0.02212867f, 0.00214599f, 0.03688352f, 0.01558629f, -0.08333182f, -0.00492208f, -0.08391013f, 
    -0.02854503f, -0.03181940f, -0.09008861f, -0.05692844f, 0.01457363f, -0.01649255f, 0.05425672f, 0.04644456f, 
    0.03387285f, 0.00992217f, -0.01881260f, -0.09578685f, 0.06426720f, -0.02446507f, -0.00991024f, 0.06772958f, 
    -0.10349242f, -0.05342663f, 0.04508111f, -0.04903366f, -0.01342772f, -0.00581831f, -0.06761458f, 0.02527855f, 
    -0.02554791f, 0.01257085f, 0.03839858f, -0.09646738f, 0.03654354f, -0.01639830f, -0.06853436f, -0.03994377f, 
    0.03595355f, 0.04757683f, -0.01124291f, 0.03345109f, -0.06612828f, 0.04947729f, -0.07498855f, -0.01195546f, 
    0.03947623f, 0.02427108f, -0.00021454f, 0.04259082f, 0.02426445f, -0.07587345f, 0.05414022f, -0.05650838f, 
    0.06845777f, 0.06052646f, -0.00578577f, -0.03690289f, -0.01331388f, -0.04368749f, 0.00155365f, 0.06027862f, 
    0.07330620f, 0.02426889f, -0.04802153f, 0.03329982f, 0.01446423f, -0.05700862f, 0.02880200f, -0.04695763f, 
    0.02679856f, -0.05377198f, -0.00566305f, -0.04094896f, -0.01461775f, -0.02839200f, 0.06148983f, 0.08392968f, 
    0.03130262f, -0.03566132f, -0.05643795f, -0.07636816f, -0.07736341f, -0.09391196f, -0.02151935f, 0.06688052f, 
    -0.02428729f, 0.01102384f, -0.05336624f, -0.01337301f, 0.04979380f, 0.05873232f, -0.03635905f, 0.06913599f, 
    -0.06091816f, -0.08098943f, -0.08524335f, -0.01966083f, 0.01966079f, -0.09706734f, 0.04086003f, 0.00229989f, 
    -0.07981655f, -0.07128497f, -0.05033825f, -0.05567807f, -0.05216332f, 0.01650961f, 0.05010311f, -0.02202197f, 
    0.29282746f, 0.00449499f, -0.23812249f, 0.30808970f, -0.04125631f, 0.08497915f, -0.02945066f, 0.38051724f, 
    -0.13571343f, 0.18243630f, 0.16974294f, 0.06500900f, 0.37674525f, 0.30796033f, -0.09150963f, 0.15307388f, 
    0.19110636f, -0.18064855f, -0.11136689f, -0.18028097f, 0.22882198f, 0.01232191f, 0.30738008f, -0.20874608f, 
    -0.31432548f, 0.18624413f, 0.17438409f, -0.06892576f, 0.06871398f, -0.18366829f, -0.04898774f, -0.21284711f, 
    -0.11281396f, -0.46069819f, 0.13495563f, -0.03839847f, 0.24667107f, -0.23899756f, -0.13924301f, 0.16804588f, 
    -0.13952231f, 0.03916617f, 0.17180172f, 0.27426592f, -0.20304237f, -0.00401087f, 0.38214025f, 0.05987927f, 
    0.11380740f, 0.10227787f, -0.06870074f, 0.01335065f, 0.86527127f, 0.27218583f, 0.24428663f, -0.06155554f, 
    0.44634214f, -0.19253424f, -0.06222079f, 0.11152728f, -0.03349376f, 0.02242289f, -0.09957445f, 0.20725641f, 
    -0.28037950f, 0.28439668f, 0.22230786f, -0.19255255f, -0.04943672f, -0.02398474f, -0.28483424f, -0.06877849f, 
    -0.08444558f, -0.44539472f, 0.04592566f, 0.01741681f, -0.14513806f, -0.23760258f, -0.12889963f, 0.04735152f, 
    -0.12159858f, -0.33119187f, -0.12119448f, -0.35486108f, 0.26975125f, 0.00670437f, 0.11786848f, 0.11969107f, 
    0.11004686f, 0.01118001f, -0.37362123f, -0.11443979f, -0.14665934f, 0.19125259f, 0.02522559f, 0.04235623f, 
    0.24469440f, 0.01943496f, 0.60010725f, 0.10532182f, 0.12021387f, 0.08712258f, -0.02306363f, 0.02498644f, 
    0.15484025f, -0.22235754f, -0.59907311f, -0.16523503f, -0.11358507f, 0.00797350f, 0.05284191f, -0.21993607f, 
    0.01965965f, 0.27664322f, 0.15856248f, -0.03957940f, -0.00343418f, 0.05634272f, -0.03507298f, 0.17263991f, 
    -0.13350414f, 0.16240932f, -0.07412846f, -0.16299313f, -0.28885686f, -0.31361893f, -0.30998656f, 0.04589728f, 
    -0.00467054f, 0.15845670f, 0.15747996f, -0.21909106f, 0.05797193f, 0.02691164f, -0.15850955f, 0.02855705f, 
    0.22956695f, -0.01478929f, -0.19265407f, 0.11653103f, -0.07368830f, -0.21751952f, -0.05730618f, 0.15961078f, 
    0.08102589f, 0.15728159f, 0.21632288f, 0.11371480f, -0.13131623f, 0.08771151f, -0.22835720f, 0.23379177f, 
    0.23474346f, -0.44156709f, -0.44431192f, -0.44042361f, 0.02330974f, 0.01166078f, -0.06570739f, 0.05933001f, 
    0.18127638f, -0.19835378f, 0.09396323f, -0.01725538f, 0.07299340f, -0.08678228f, 0.35707989f, -0.17225564f, 
    -0.02314223f, -0.08394112f, -0.07507897f, 0.15643965f, 0.73938280f, 0.00562858f, -0.55600274f, 0.11320747f, 
    -0.46432129f, -0.19411568f, -0.08071498f, -0.05628023f, -0.09088992f, -0.24087001f, -0.37028378f, -0.33340511f, 
    0.10743392f, -0.16816831f, -0.00183871f, 0.10847623f, 0.08016485f, -0.21072671f, 0.19043955f, 0.32969481f, 
    0.19511695f, -0.58438027f, -0.24802443f, 0.04277613f, -0.21491690f, 0.03870028f, 0.23186293f, -0.06933079f, 
    0.03207311f, -0.10300080f, 0.19148962f, 0.20992029f, -0.02577818f, 0.18989573f, -0.31131884f, -0.09956303f, 
    0.08257315f, -0.03660807f, -0.33060262f, 0.09163639f, -0.51748860f, 0.03192987f, 0.00771503f, -0.46636784f, 
    -0.04465069f, 0.06901845f, -0.28120089f, 0.32387161f, 0.03226498f, -0.27268940f, -0.03491471f, -0.00449936f, 
    0.19846059f, -0.08989535f, -0.27704838f, -0.56769735f, 0.04875426f, 0.09866971f, 0.04305007f, -0.16067676f, 
    0.09506495f, -0.02331104f, 0.28038239f, 0.02387593f, -0.12277427f, -0.06501260f, -0.21842641f, -0.43565106f, 
    0.06067879f, -0.26654306f, -0.21205151f, 0.13982153f, -0.12480042f, 0.01609198f, -0.15157482f, -0.21481046f, 
    -0.10150004f, 0.24264327f, -0.19160414f, -0.74894112f, -0.61124152f, 0.28619465f, -0.42775917f, 0.35925031f, 
    -0.08974607f, 0.03455776f, 0.14994951f, -0.06298199f, -0.10547344f, 0.40619764f, -0.15203749f, 0.16150378f, 
    -0.26552662f, -0.08794849f, 0.08300867f, -0.03703132f, 0.18278234f, 0.47614226f, 0.04720156f, -0.52461767f, 
    -0.03715788f, 0.02811037f, -0.09044388f, -0.02323450f, 0.22497691f, 0.01065826f, 0.16588143f, -0.23716566f, 
    0.18229854f, 0.04169995f, -0.00614403f, -0.56009835f, 0.14107336f, -0.48183033f, -0.00962404f, -0.01652101f, 
    -0.15633270f, -0.44296679f, 0.21556190f, -0.14071780f, 0.23427795f, -0.21364410f, 0.12447342f, -0.02961010f, 
    0.09641027f, 0.03870207f, 0.40035400f, 0.24047922f, 0.05554365f, -0.08208270f, 0.43039930f, 0.35959333f, 
    0.38774809f, 0.14401561f, 0.23198532f, 0.03761065f, -0.19271880f, 0.10911680f, 0.20920530f, 0.08142785f, 
    0.24364324f, -0.13695022f, 0.16250135f, 0.10342528f, -0.08814862f, -0.14326212f, 0.22731730f, 0.28474778f, 
    0.19349633f, 0.24420556f, 0.19188416f, -0.06715139f, 0.29471633f, 0.02842693f, -0.10056680f, 0.00347893f, 
    0.05351686f, 0.07271335f, -0.12826136f, 0.05387008f, -0.06485664f, -0.03967713f, 0.12206464f, 0.12157501f, 
    -0.41810268f, 0.09007758f, 0.29163772f, -0.22106734f, 0.31393397f, -0.01370515f, -0.04875265f, 0.01229645f, 
    0.20312472f, 0.09780353f, -0.01294084f, -0.12678127f, -0.09682036f, 0.24434505f, 0.02436239f, -0.06054384f, 
    0.14668618f, 0.17395830f, 0.33040676f, -0.11052233f, -0.06642655f, 0.23068543f, -0.03195897f, 0.07189430f, 
    0.14109369f, -0.17240198f, -0.07206756f, -0.06534963f, -0.06328570f, -0.10221808f, 0.01060852f, -0.09965671f, 
    -0.01379147f, 0.58196014f, -0.10569625f, -0.07574987f, -0.14874749f, -0.06502036f, 0.18194258f, 0.12876852f, 
    -0.15636173f, 0.08300665f, 0.00109656f, -0.07050399f, 0.04600335f, -0.36996064f, -0.01164346f, -0.00216990f, 
    0.00631638f, 0.23410463f, 0.00111617f, -0.40780464f, -0.00251731f, 0.11475613f, 0.05855859f, -0.14156398f, 
    0.06925394f, -0.10572198f, -0.10885978f, 0.03458037f, 0.11174443f, 0.22767866f, -0.00900105f, 0.00405563f, 
    0.19729879f, -0.12131156f, -0.11384074f, -0.12916143f, 0.07866319f, 0.02762947f, 0.40479207f, -0.33810100f, 
    -0.16344355f, 0.24609858f, 0.15314464f, -0.04987888f, -0.07070608f, -0.12894094f, -0.00657256f, -0.21112403f, 
    -0.38700017f, -0.10765608f, 0.08341309f, 0.27615955f, -0.07891463f, 0.12892760f, 0.37168375f, -0.02910126f, 
    -0.06159228f, -0.01284358f, -0.26754656f, -0.12621947f, 0.20267551f, -0.08133794f, 0.20187645f, 0.20868260f, 
    0.29272801f, -0.00190212f, -0.15491059f, -0.06653281f, 0.47774750f, 0.01556188f, -0.31578183f, -0.07697846f, 
    0.04296608f, -0.28927764f, 0.03352391f, 0.13084063f, -0.04749825f, 0.06869967f, 0.10959879f, -0.05842199f, 
    -0.09718340f, 0.11380712f, -0.05336900f, 0.09723444f, 0.04927317f, -0.03698895f, -0.39040455f, -0.01105227f, 
    -0.01588742f, 0.36947361f, -0.02686694f, -0.23453189f, 0.20605856f, -0.23771442f, 0.14873347f, 0.17587653f, 
    -0.18934327f, 0.07513021f, -0.16014531f, 0.21103869f, 0.10206050f, -0.03757219f, 0.12783007f, 0.06117555f, 
    -0.05883023f, 0.10239463f, -0.28268951f, 0.26504675f, -0.11577840f, 0.12243970f, -0.10725837f, -0.02468890f, 
    0.03693867f, 0.17782517f, 0.02082485f, -0.00786118f, 0.25081947f, -0.08590589f, -0.03588317f, -0.05635038f, 
    0.26954344f, 0.11671480f, -0.22649945f, -0.21475287f, -0.02771689f, -0.05858655f, -0.10997524f, 0.35598791f, 
    0.00145945f, 0.31202877f, -0.05425012f, -0.24826469f, 0.06500345f, -0.05031357f, 0.01782722f, -0.01476858f, 
    -0.17857277f, 0.16364521f, -0.20103458f, 0.15651046f, 0.07008858f, -0.37559387f, 0.31983089f, -0.08475117f, 
    0.10978351f, 0.02230167f, 0.32104123f, -0.57041097f, -0.04921215f, 0.20666455f, -0.28311813f, 0.14582428f, 
    0.09000098f, 0.01583623f, -0.21042395f, 0.07014720f, 0.19862224f, 0.12547207f, 0.00147616f, 0.06063008f, 
    0.16147089f, -0.20653357f, 0.06633592f, 0.12269156f, 0.08327716f, 0.18433404f, 0.15607136f, -0.14422826f, 
    -0.08180102f, -0.14953585f, -0.14652622f, 0.15548493f, 0.00626614f, -0.01869553f, 0.02109151f, -0.07540752f, 
    0.20608146f, 0.00607703f, -0.21342537f, 0.11061905f, 0.17435826f, 0.24128389f, -0.47060189f, -0.03229009f, 
    0.14402524f, -0.03989358f, -0.18617764f, -0.09553340f, 0.26892671f, -0.04474340f, 0.09825529f, -0.05585717f, 
    -0.23277694f, 0.01030916f, -0.32647571f, -0.21745463f, 0.52469057f, 0.18711783f, -0.69903219f, -0.17271705f, 
    0.11933031f, -0.09333538f, 0.08767841f, 0.24716768f, 0.12932353f, 0.04168460f, -0.31920823f, 0.03258523f, 
    0.13114627f, -0.20421201f, 0.13474363f, -0.24465284f, -0.03647436f, 0.04953492f, 0.13299793f, 0.30317837f, 
    0.02792860f, -0.11803275f, 0.05574745f, -0.07859903f, -0.27084121f, 0.13084137f, -0.03824336f, 0.41019100f, 
    0.21590024f, 0.33304453f, -0.25650167f, -0.19599061f, 0.03032395f, 0.10528924f, -0.16023290f, -0.26186439f, 
    0.03253299f, 0.11549764f, 0.15750024f, 0.15109393f, 0.02346982f, -0.03848796f, -0.08422799f, -0.05412554f, 
    0.11702140f, -0.07186084f, 0.08265216f, -0.23417701f, 0.28122342f, 0.10763507f, 0.03832109f, -0.15751891f, 
    0.07495162f, 0.15539864f, 0.23835394f, -0.03422693f, -0.25988176f, 0.01628511f, -0.18590353f, -0.26149830f, 
    -0.03355866f, 0.15803924f, -0.04129595f, 0.01073448f, 0.16805923f, 0.11167051f, -0.30117935f, 0.13072684f, 
    0.14019541f, 0.27172759f, -0.28919792f, -0.15378341f, -0.28236306f, 0.31914440f, -0.17033342f, 0.14430390f, 
    -0.07282139f, -0.05602715f, -0.06740635f, -0.08697721f, -0.05039364f, -0.03624590f, -0.08764133f, -0.07515681f, 
    0.06429074f, -0.03529856f, -0.10224830f, 0.05371364f, 0.03266924f, -0.02110762f, 0.04668072f, -0.02203052f, 
    -0.05077831f, -0.03418606f, 0.06544933f, -0.07151152f, -0.04720674f, -0.07532070f, -0.06105701f, -0.04482755f, 
    -0.04700097f, -0.02158309f, 0.05395658f, -0.05561750f, -0.01035530f, 0.00021788f, 0.08018138f, 0.05385552f, 
    0.04995528f, -0.03397644f, -0.08279596f, -0.08757140f, -0.03807648f, 0.04385909f, 0.03987076f, -0.08642071f, 
    -0.05625523f, -0.05813595f, -0.04980377f, 0.03332765f, -0.03023109f, 0.02434192f, -0.00303118f, 0.04050679f, 
    0.08126982f, 0.06305648f, 0.02539036f, -0.09621329f, 0.04292346f, -0.04479055f, 0.05242421f, -0.02677861f, 
    -0.09609414f, -0.07119673f, -0.00517179f, 0.03482944f, -0.03514464f, 0.01124903f, 0.00081018f, -0.08399069f, 
    -0.01230223f, -0.02096826f, 0.01327532f, 0.04182864f, -0.09303654f, 0.07182235f, 0.00017801f, 0.00338024f, 
    -0.08129665f, -0.04988270f, -0.06500613f, -0.04435228f, 0.05570871f, -0.03567466f, -0.00927120f, -0.09034225f, 
    0.02175398f, -0.02753786f, 0.04411191f, 0.06314516f, -0.07786081f, -0.00359094f, -0.09834278f, -0.11521045f, 
    0.02498385f, 0.01088439f, -0.04698038f, -0.03797729f, 0.02555382f, 0.02103376f, -0.05738369f, -0.02724856f, 
    -0.02611242f, -0.05434556f, 0.00760258f, -0.03177498f, -0.01972874f, 0.04360945f, -0.07152067f, 0.01680375f, 
    -0.10472164f, -0.08868936f, 0.00792447f, 0.02696411f, -0.03288292f, -0.08633406f, -0.04272875f, -0.03330566f, 
    -0.03524746f, -0.07199799f, 0.00388811f, 0.03589676f, -0.01102383f, -0.03505516f, -0.01718739f, -0.03378215f, 
    0.02425710f, -0.05215521f, -0.01096566f, -0.01014849f, -0.02990578f, 0.03200331f, -0.10389823f, 0.02100326f, 
    0.18995279f, 0.01010532f, -0.24664739f, -0.11971182f, 0.18796691f, -0.47410095f, -0.09584492f, 0.20750430f, 
    -0.19695288f, 0.07293896f, 0.38241863f, 0.11801355f, 0.16028915f, -0.20691723f, 0.03522005f, 0.21361390f, 
    0.09206087f, 0.20809250f, 0.13234310f, 0.16437510f, -0.03790983f, 0.15270318f, -0.13645047f, 0.20292544f, 
    0.12845914f, 0.02469325f, 0.21085392f, -0.37393668f, 0.14820200f, 0.20151761f, 0.00880460f, 0.02945426f, 
    0.22298262f, -0.02088620f, -0.00892045f, -0.01054049f, -0.24854891f, 0.22710603f, -0.32386610f, 0.22597463f, 
    -0.29001254f, 0.12412804f, 0.03589747f, -0.20508529f, -0.10984842f, -0.07013591f, -0.37472403f, -0.08450195f, 
    0.25068778f, 0.07125477f, 0.01244347f, -0.01244686f, -0.09799284f, 0.17004254f, 0.16233970f, 0.31167871f, 
    -0.00705750f, 0.17845778f, -0.00770361f, -0.05481049f, 0.14716707f, 0.27045554f, -0.08883450f, -0.02635883f, 
    -0.36833906f, 0.25672096f, 0.10549988f, -0.18737158f, -0.00650143f, -0.01739740f, 0.09112946f, -0.30891609f, 
    0.02364101f, -0.79160774f, 0.04540647f, 0.26739892f, 0.04720620f, 0.00103310f, -0.13564372f, -0.35193175f, 
    0.00714392f, -0.48836297f, 0.24897157f, 0.02047658f, -0.01552388f, -0.01094579f, 0.02508123f, 0.19480062f, 
    0.00442322f, 0.00737871f, -0.01376289f, -0.00486094f, 0.14450218f, 0.03851088f, 0.01415422f, 0.07063475f, 
    0.04426339f, 0.01406192f, 0.22382292f, 0.38506591f, -0.04954549f, 0.06489712f, 0.06030580f, 0.42956048f, 
    0.22720471f, -0.20341370f, -0.33335447f, -0.10646798f, 0.23521547f, -0.04782081f, 0.17713475f, 0.02093224f, 
    0.01333451f, -0.20163807f, 0.27785844f, 0.09752807f, 0.04940932f, 0.06724487f, 0.05889961f, -0.20072699f, 
    0.17231861f, -0.01650788f, 0.29911020f, -0.01031034f, -0.09300818f, -0.10160144f, 0.19165891f, -0.01992088f, 
    -0.00658233f, 0.06811983f, 0.09304209f, 0.28511119f, -0.13791655f, -0.13282871f, -0.27924913f, -0.01994984f, 
    0.06393252f, 0.10578607f, -0.18740743f, 0.01533090f, -0.28971401f, -0.16239655f, 0.00750064f, 0.17664813f, 
    -0.01895064f, -0.10085107f, 0.00494882f, -0.17433770f, 0.12617056f, 0.21268550f, -0.12694414f, 0.51123780f, 
    -0.02640955f, 0.08093043f, -0.24795114f, -0.23588501f, 0.22474541f, -0.10676329f, 0.07807682f, -0.09239466f, 
    -0.28562546f, -0.15081805f, -0.02563208f, 0.00526528f, 0.13008963f, -0.24071316f, -0.24713598f, -0.10906806f, 
    0.05440257f, -0.00838140f, -0.21721566f, -0.33941728f, -0.06200333f, 0.06535114f, 0.11653040f, 0.12085347f, 
    0.46061200f, 0.17981340f, 0.07533752f, -0.31010863f, 0.06781018f, 0.01243719f, 0.22485483f, -0.37553182f, 
    -0.05210546f, -0.03098056f, 0.21873491f, 0.15478027f, 0.05373560f, -0.28502825f, -0.08718069f, 0.08460315f, 
    0.00615896f, 0.30717722f, 0.15366712f, 0.38141245f, -0.06769963f, 0.06744437f, 0.17474613f, -0.05265417f, 
    0.07093906f, 0.21037658f, 0.19395040f, 0.21519069f, -0.16140608f, 0.09816540f, -0.22122450f, -0.30510703f, 
    0.09274143f, -0.05318427f, 0.09453765f, -0.25018889f, 0.09421378f, 0.02733462f, 0.30642918f, 0.02803076f, 
    0.03267214f, -0.01202873f, 0.08383203f, -0.10419433f, 0.09182391f, -0.20895506f, -0.04947416f, 0.00029528f, 
    0.16678222f, 0.02606951f, 0.04946198f, 0.06276994f, 0.08598810f, 0.11162814f, -0.04896177f, -0.15591711f, 
    0.15749322f, 0.14922832f, 0.23036256f, 0.52489555f, -0.11842375f, -0.01567535f, 0.27598646f, 0.11455549f, 
    0.02849447f, 0.08548065f, 0.24576312f, 0.05353864f, -0.18879409f, 0.18910931f, -0.04002545f, 0.01917899f, 
    0.09519622f, 0.16004565f, 0.20067360f, -0.13402671f, 0.02381382f, 0.19313991f, -0.28637752f, 0.52955818f, 
    -0.05254475f, -0.06736326f, 0.43160489f, 0.01654939f, -0.05710047f, 0.02392039f, 0.04769088f, -0.00080091f, 
    0.18239091f, -0.04253540f, 0.12360342f, 0.09497865f, 0.13139802f, 0.07929184f, -0.02566170f, 0.35272220f, 
    -0.07399146f, 0.01836872f, 0.27225021f, 0.50186986f, 0.31650379f, 0.06735732f, -0.04102998f, 0.18155503f, 
    0.06529297f, -0.09645445f, -0.07456674f, 0.35718212f, 0.03217744f, 0.00619058f, 0.03123944f, 0.05462864f, 
    0.08474338f, -0.16822024f, 0.03858462f, -0.08360348f, 0.03523061f, -0.32638907f, 0.07115654f, 0.10108488f, 
    -0.02892143f, -0.00078570f, -0.27148500f, 0.04768085f, -0.07589974f, 0.03481170f, -0.11482442f, 0.03335359f, 
    -0.43813097f, -0.22359587f, -0.09076858f, -0.03600658f, -0.31525719f, 0.31957635f, -0.16690946f, 0.15548843f, 
    -0.22447242f, 0.12543127f, -0.11762028f, 0.04052768f, 0.23660150f, 0.12451230f, -0.03169530f, 0.13454908f, 
    0.24645935f, -0.14561433f, -0.09742887f, -0.12024785f, -0.01805787f, -0.01332046f, 0.03328034f, -0.12779510f, 
    0.01198596f, -0.28084072f, -0.00820681f, 0.04225918f, 0.15589823f, 0.26616663f, -0.07189862f, -0.64401203f, 
    0.25956726f, -0.25970742f, -0.21295410f, 0.28912053f, 0.03846608f, -0.05009177f, 0.06793246f, 0.05434646f, 
    0.20125845f, 0.28719890f, 0.09008185f, -0.09119920f, -0.02446245f, 0.08883914f, -0.03770763f, -0.05970590f, 
    0.15129662f, -0.00779505f, 0.10253667f, 0.01402112f, 0.15717946f, 0.16170110f, -0.06764923f, 0.17323038f, 
    0.00498308f, -0.13190576f, -0.08545427f, -0.34153455f, 0.14583299f, -0.01011098f, -0.18896504f, 0.10562199f, 
    -0.04505992f, 0.11166611f, -0.02533426f, 0.13449264f, 0.14410824f, 0.32901275f, -0.00126377f, -0.04579577f, 
    0.21140283f, 0.18110088f, -0.13927425f, -0.08285432f, -0.17457624f, -0.26461589f, 0.20425498f, -0.25402346f, 
    0.53961611f, 0.05547126f, 0.51220781f, -0.04744639f, 0.05315809f, 0.01713191f, -0.06023904f, -0.06577933f, 
    -0.09653381f, 0.09048668f, 0.03498239f, -0.01296047f, 0.23064475f, 0.11976277f, 0.01653508f, -0.01193940f, 
    0.05164405f, -0.20235230f, 0.12662296f, 0.13259393f, -0.06421486f, 0.03279728f, 0.31591719f, 0.11420649f, 
    -0.10634671f, 0.10253447f, -0.02417525f, -0.02634307f, 0.11698531f, 0.11675213f, 0.03232113f, 0.20884311f, 
    -0.17531204f, -0.35443804f, -0.04340129f, -0.05576395f, 0.11210306f, -0.16912767f, -0.39759097f, 0.08071572f, 
    -0.17083059f, -0.04699881f, -0.23699801f, -0.33322093f, -0.01367812f, -0.04056421f, -0.04561082f, 0.06997378f, 
    0.11412898f, -0.02139763f, -0.10192490f, 0.16742250f, 0.40437621f, 0.06289705f, 0.27197337f, -0.20121725f, 
    -0.04760591f, 0.36966068f, -0.06151709f, 0.19568272f, 0.16569319f, 0.02176711f, -0.11677045f, 0.09964704f, 
    -0.06401765f, 0.08176671f, -0.10083947f, -0.17949358f, 0.00135171f, 0.00762124f, -0.17402513f, -0.02131588f, 
    -0.06376582f, -0.25555563f, -0.00221278f, 0.00759328f, 0.28059652f, -0.12205327f, -0.01094372f, -0.35909268f, 
    0.39193511f, -0.41647273f, -0.44193521f, 0.21374461f, -0.00431475f, -0.03171961f, 0.31496352f, 0.10951414f, 
    -0.00892954f, 0.05764325f, 0.09608930f, -0.00972115f, 0.13067034f, -0.07147620f, -0.10253121f, -0.04326098f, 
    -0.04464021f, -0.07480116f, 0.22079903f, 0.23301622f, 0.03856862f, 0.13600281f, -0.02347150f, 0.31287271f, 
    0.05657968f, 0.00701406f, -0.35668749f, 0.03572394f, 0.17955489f, 0.07721525f, 0.22529723f, 0.44370502f, 
    -0.06122286f, 0.00572646f, 0.29190025f, -0.27873001f, 0.09020741f, 0.06025160f, -0.07356007f, 0.01957119f, 
    0.04325332f, -0.08037657f, -0.01700431f, -0.03186836f, 0.00843459f, -0.13169315f, 0.43547559f, -0.39806974f, 
    -0.10997033f, 0.09391954f, -0.10188870f, 0.30143252f, -0.04534817f, 0.09584262f, -0.04118071f, 0.01801057f, 
    -0.04794919f, 0.11054718f, -0.05502651f, -0.05339608f, -0.08650532f, -0.15194783f, -0.00072775f, 0.19482066f, 
    0.10993610f, 0.08595075f, 0.15001985f, -0.25730440f, 0.05076194f, 0.05156061f, -0.23474170f, 0.41483840f, 
    0.25170118f, -0.09112021f, -0.18927974f, -0.20920704f, 0.09532892f, 0.15974034f, -0.04896356f, 0.08687690f, 
    0.16595505f, -0.21592879f, 0.15269820f, -0.04157320f, 0.25986585f, -0.21909504f, -0.04459933f, -0.04841400f, 
    0.04168228f, 0.05609993f, 0.13370451f, -0.04661174f, 0.04456399f, 0.00733126f, -0.09274703f, 0.15702608f, 
    0.58125949f, 0.11065325f, 0.14203902f, -0.19828533f, -0.04303825f, -0.17935282f, 0.38374713f, -0.33173349f, 
    0.18689305f, 0.37741542f, 0.12907819f, 0.06974233f, 0.00704087f, -0.21071267f, 0.03745484f, 0.01611213f, 
    0.27596754f, 0.14938368f, 0.27058586f, 0.12308037f, 0.10044546f, 0.01542848f, 0.28759608f, -0.00900520f, 
    -0.01360156f, 0.09858693f, 0.20656109f, 0.27555546f, -0.13448375f, 0.03164020f, -0.09550501f, 0.11188862f, 
    0.08022998f, 0.06392538f, 0.35140783f, -0.26789358f, 0.08671383f, 0.00776350f, 0.20165806f, 0.06965446f, 
    0.01213995f, -0.10267621f, 0.33171040f, -0.03518693f, -0.05397283f, -0.01177148f, 0.07340942f, -0.04115603f, 
    0.19320902f, -0.02248812f, -0.01538006f, -0.10995857f, -0.05042632f, 0.12233936f, 0.05170618f, -0.15182994f, 
    0.10630970f, 0.00386775f, 0.10830935f, 0.29207921f, -0.07684577f, -0.02153206f, 0.31030560f, 0.02390964f, 
    -0.05072379f, -0.02111252f, 0.22913738f, 0.05983975f, -0.05953313f, 0.07052483f, 0.12482120f, 0.03520969f, 
    -0.19725130f, 0.08033383f, 0.11089413f, -0.09474006f, 0.17592965f, 0.31857109f, -0.40898764f, 0.58081943f, 
    0.02429001f, -0.06992235f, -0.01923386f, -0.01479900f, -0.08141606f, -0.08576104f, 0.06300969f, 0.03862587f, 
    -0.04546342f, -0.00204704f, -0.03454003f, 0.05301883f, 0.01398396f, 0.03446776f, -0.03289313f, 0.07504231f, 
    -0.03974523f, 0.03814489f, -0.07159241f, -0.08627851f, -0.08623735f, 0.04731995f, -0.04683849f, 0.04811459f, 
    0.07216315f, 0.07441991f, -0.01119840f, -0.03692243f, 0.00217014f, -0.01932085f, 0.02717214f, 0.05984535f, 
    -0.04167001f, 0.07576740f, -0.00685461f, -0.01022188f, 0.02536582f, 0.00266885f, -0.00311415f, 0.01641363f, 
    0.01754241f, -0.07256655f, -0.04851818f, 0.00420560f, -0.01106083f, -0.03749362f, -0.00401758f, 0.01309669f, 
    0.05941390f, 0.02786164f, 0.03499083f, 0.05368935f, 0.02929762f, -0.03529791f, -0.00000087f, -0.02183701f, 
    -0.04514485f, -0.07707030f, -0.04700209f, -0.05571898f, -0.03304063f, -0.00197381f, -0.01985527f, -0.07245243f, 
    -0.02481837f, 0.06338864f, 0.03802961f, -0.08807097f, 0.05065045f, 0.02260765f, 0.02317105f, -0.03617049f, 
    -0.01774340f, 0.02631474f, 0.02841865f, -0.02421038f, -0.01293891f, -0.07724994f, -0.03018531f, 0.00176213f, 
    0.02218394f, 0.08271919f, 0.05609865f, -0.06294193f, -0.07352172f, -0.07325693f, 0.04952222f, 0.02562864f, 
    0.02499165f, -0.05477149f, 0.02622313f, -0.02349617f, -0.04772937f, 0.04236602f, -0.02348277f, -0.08457635f, 
    -0.02943918f, -0.07885709f, -0.05740137f, -0.07452064f, -0.03544062f, -0.06833582f, -0.00393231f, 0.03055807f, 
    0.07376424f, -0.07278204f, -0.03889459f, 0.01669814f, 0.00947030f, 0.06235954f, 0.00976011f, -0.05093944f, 
    -0.00306748f, 0.00922868f, 0.07118995f, -0.07149538f, -0.01010219f, 0.01080282f, -0.08586761f, -0.02254915f, 
    0.07941052f, -0.06797771f, -0.06871485f, -0.05894627f, -0.08336776f, 0.08712653f, 0.06212597f, -0.01747402f, 
    0.00553670f, -0.08500878f, -0.09914584f, 0.31467673f, 0.15884948f, -0.35562393f, 0.22394453f, 0.50294620f, 
    0.02634328f, 0.17019740f, 0.33107787f, 0.01404664f, 0.25851768f, 0.03437931f, -0.08514767f, 0.10228194f, 
    0.18304071f, 0.02418816f, -0.09187260f, 0.15675946f, 0.04112161f, -0.13056669f, 0.22832288f, 0.12576705f, 
    -0.06460258f, 0.03956702f, 0.19225775f, 0.46661237f, 0.04252863f, -0.05828997f, -0.07868204f, -0.08878846f, 
    0.10908032f, -0.40368849f, 0.04572051f, 0.03642666f, -0.13174222f, -0.00665341f, -0.15497437f, 0.23995258f, 
    -0.24711293f, 0.06355513f, 0.19226113f, 0.45404547f, -0.04074689f, -0.04303296f, -0.03600094f, 0.06393928f, 
    -0.09873670f, 0.03674471f, -0.12539072f, 0.14072534f, 0.14814892f, 0.11606874f, -0.10188568f, 0.38807353f, 
    0.19278209f, -0.57279199f, -0.03347234f, -0.08189649f, 0.00682948f, 0.35472026f, -0.00142041f, 0.11017856f, 
    -0.35303602f, 0.10505321f, 0.31643343f, -0.44888568f, 0.04023888f, -0.05696706f, -0.09526681f, -0.19884302f, 
    -0.02913839f, -0.55139583f, 0.07147810f, -0.01434995f, -0.11172740f, -0.04981326f, -0.15502487f, 0.14261909f, 
    -0.22728193f, -0.11488698f, 0.00462398f, -0.24485554f, 0.25281674f, -0.05704806f, -0.09344216f, -0.06261446f, 
    0.08592272f, 0.13171612f, -0.11738700f, -0.00993488f, 0.01124523f, 0.12936336f, 0.02625476f, 0.05504968f, 
    0.17455567f, -0.11373784f, 0.30739066f, 0.24222156f, 0.11191954f, -0.03748516f, -0.06696070f, 0.20890656f, 
    0.10101160f, -0.44022352f, -0.34417272f, -0.30776519f, -0.00765360f, -0.26528981f, 0.00354145f, -0.56937474f, 
    -0.05610995f, -0.01357651f, 0.18531823f, 0.13661686f, 0.10452221f, 0.02744116f, 0.14766362f, -0.00435581f, 
    0.10972397f, 0.11307430f, -0.04236180f, -0.13339588f, -0.55987740f, -0.12715504f, -0.30156815f, 0.08167915f, 
    0.08823191f, 0.14558449f, 0.04651672f, -0.02402692f, 0.24528357f, -0.13164942f, 0.25525272f, 0.29525414f, 
    -0.16588241f, 0.12744127f, -0.08652320f, 0.00662311f, 0.01317519f, -0.07728127f, 0.00909597f, -0.54758620f, 
    -0.12696278f, 0.12101614f, 0.20693001f, 0.05330541f, -0.03773618f, -0.01344244f, 0.19280732f, 0.17928961f, 
    -0.36706781f, 0.18080419f, 0.16415390f, -0.20504467f, 0.03405693f, 0.33461225f, -0.03126069f, 0.24628913f, 
    0.32112673f, -0.44562608f, 0.05233685f, 0.01498946f, -0.26077721f, 0.06837162f, -0.00463952f, 0.10448230f, 
    -0.57954800f, 0.03269789f, -0.15222645f, -0.20690744f, -0.06558370f, -0.07889146f, 0.05221380f, -0.06237871f, 
    0.64112794f, -0.02079812f, -0.20865479f, 0.14984703f, -0.50781441f, -0.05626741f, 0.22242548f, 0.18846449f, 
    -0.09602883f, -0.69611675f, -0.20744775f, 0.05393070f, -0.41255808f, 0.11168087f, 0.02682502f, -0.05407680f, 
    -0.51880026f, 0.17631315f, 0.22558998f, 0.13501994f, -0.12766676f, 0.01911917f, -0.22407198f, -0.26869455f, 
    0.07066058f, 0.00249373f, -0.08375041f, 0.35726982f, 0.16558769f, 0.04233096f, -0.38777137f, 0.33486924f, 
    -0.18503223f, -0.44527727f, 0.85964501f, -0.06534193f, 0.09639354f, -0.02585764f, 0.32136470f, -0.10587739f, 
    -0.09883304f, -0.05582157f, -0.40187135f, -0.10740473f, -0.02585931f, -0.01735447f, -0.08851436f, 0.03414276f, 
    0.25707012f, 0.23574762f, 0.18152569f, 0.12222261f, -0.16882424f, -0.01996738f, 0.00134028f, 0.18436767f, 
    0.27807850f, -0.24602708f, -0.12455164f, 0.17663606f, 0.18683992f, -0.25238308f, 0.06609945f, -0.06965789f, 
    0.02922493f, 0.05048443f, 0.31751251f, 0.04542794f, -0.13594553f, -0.20445924f, 0.04941579f, -0.58538949f, 
    -0.41425276f, 0.22391234f, -0.23757197f, -0.30817607f, -0.58541614f, 0.12709580f, -0.04787117f, -0.27701247f, 
    -0.35274166f, -0.04871034f, 0.15748733f, -0.05538346f, -0.07760598f, 0.09084021f, -0.11862160f, 0.18197906f, 
    0.02979005f, 0.08020053f, 0.04025919f, 0.20091845f, 0.12736143f, 0.13772756f, -0.06860330f, 0.04636601f, 
    0.23648614f, 0.02042450f, 0.07906530f, 0.16773328f, 0.32143342f, 0.13584563f, -0.29208764f, 0.13499466f, 
    -0.08750602f, -0.17761835f, -0.12460590f, 0.29056847f, -0.15482806f, -0.07307944f, 0.03337607f, 0.23801546f, 
    0.44278303f, -0.30112612f, 0.05006157f, 0.04237439f, 0.04525740f, 0.02524390f, 0.12926391f, 0.07925530f, 
    -0.04379724f, 0.00658276f, 0.08175769f, -0.25102082f, -0.23051019f, -0.05909363f, 0.02501560f, 0.07737100f, 
    0.09317803f, 0.07438760f, -0.02198076f, -0.02048627f, 0.13311276f, 0.32828814f, -0.30272779f, 0.00514853f, 
    0.06929302f, 0.01089874f, -0.09026874f, 0.10894603f, -0.01644110f, 0.06483119f, -0.10445403f, 0.04305036f, 
    0.15708718f, 0.01009312f, 0.07944322f, -0.25491282f, 0.13860565f, -0.00810999f, 0.05636129f, -0.02672308f, 
    0.05375111f, 0.18721573f, 0.03614484f, 0.14425857f, 0.05042084f, 0.33731312f, -0.08155229f, 0.15477854f, 
    -0.10065924f, -0.06232725f, -0.03572098f, -0.05372648f, 0.08754677f, -0.01451585f, -0.10414760f, -0.10687556f, 
    0.19603582f, 0.09830973f, 0.12877344f, 0.10192735f, -0.08196814f, -0.05987935f, -0.07424588f, 0.08700440f, 
    0.26173612f, 0.01497307f, 0.16601117f, -0.08030486f, 0.12344414f, 0.08547378f, -0.01128190f, -0.01564226f, 
    0.07046253f, 0.01596335f, 0.03258175f, -0.23463598f, -0.08487350f, -0.05050228f, -0.06766668f, -0.27123904f, 
    -0.05477092f, 0.04670615f, -0.13509242f, 0.30678445f, -0.07403445f, 0.12743308f, -0.10170989f, 0.11271890f, 
    0.05180513f, 0.38462991f, -0.22058673f, -0.10723382f, -0.11963222f, -0.13348906f, -0.26582468f, 0.11254291f, 
    -0.22641012f, -0.00440217f, 0.38123003f, 0.06245522f, -0.22775948f, -0.03101384f, 0.06270640f, 0.03549163f, 
    -0.00822224f, -0.01386086f, 0.24668641f, 0.05439678f, 0.17867462f, 0.32020596f, 0.04254155f, -0.21790197f, 
    0.06066053f, 0.00345933f, -0.07802539f, 0.42810357f, 0.13721351f, 0.20551592f, 0.07966625f, -0.52679688f, 
    -0.13672082f, -0.03515831f, -0.00617512f, 0.26530328f, 0.00625892f, -0.25715011f, -0.04461447f, -0.19974132f, 
    -0.18902820f, -0.09889975f, 0.02579032f, -0.05096250f, 0.04566190f, -0.14750408f, 0.15737160f, 0.13063154f, 
    0.07222930f, -0.11565960f, -0.03497694f, 0.09632838f, 0.09394751f, -0.03872051f, 0.09027834f, -0.02149990f, 
    -0.69613379f, 0.13346407f, 0.00679412f, 0.09909003f, 0.40195104f, 0.50011396f, -0.19629346f, -0.00468294f, 
    0.03060960f, -0.17123453f, 0.00804942f, -0.08748358f, 0.12421229f, 0.08249652f, -0.12555510f, 0.25353500f, 
    0.28509766f, -0.08619337f, -0.05182952f, -0.30886340f, 0.05939205f, -0.02311138f, -0.13595273f, 0.02710377f, 
    -0.04165059f, -0.03991547f, -0.11894962f, -0.11816993f, 0.03591011f, 0.31358552f, 0.07709180f, -0.16482337f, 
    -0.08858938f, -0.29370609f, -0.59403932f, 0.20398960f, -0.06631243f, 0.03177937f, -0.46547905f, 0.04516801f, 
    0.28490913f, 0.12100828f, -0.26909363f, -0.07114090f, 0.10311767f, 0.20820934f, -0.08382260f, 0.03223427f, 
    0.02737862f, -0.04624984f, -0.01394811f, 0.16368492f, 0.01993980f, -0.00062472f, 0.07195060f, 0.15215141f, 
    -0.13767581f, -0.05430918f, -0.09736679f, -0.51889372f, 0.02360316f, -0.07951749f, -0.23526296f, 0.11340728f, 
    0.03698955f, 0.28371453f, -0.33209699f, 0.21994737f, -0.06368547f, 0.22675292f, 0.00279885f, 0.13104017f, 
    0.17198984f, -0.05721737f, 0.05235508f, 0.02009559f, -0.15379609f, -0.46841574f, 0.17380168f, -0.39526573f, 
    0.23886113f, 0.08753124f, 0.06054761f, -0.19335392f, 0.23576277f, 0.02505302f, -0.33000574f, 0.47995728f, 
    0.00961184f, -0.16579211f, 0.20311043f, -0.36010531f, -0.27256545f, -0.12023730f, -0.05370468f, 0.12025854f, 
    -0.19775550f, 0.16502620f, 0.34008566f, -0.05948587f, -0.31227231f, -0.04060558f, -0.30452561f, 0.02182290f, 
    0.13330230f, 0.02078693f, 0.04192898f, 0.29928699f, 0.26409584f, 0.41491547f, -0.02671104f, 0.09874508f, 
    0.36418346f, 0.56113869f, 0.21662036f, 0.13860396f, -0.22922966f, -0.11645986f, 0.34326637f, 0.02649025f, 
    -0.01552218f, -0.01169983f, 0.11439597f, 0.41804242f, 0.18960629f, 0.08049482f, 0.03418849f, 0.10999546f, 
    -0.21109980f, 0.06306304f, 0.15190156f, 0.06468701f, 0.49402243f, -0.21538052f, 0.06611142f, 0.36806300f, 
    -0.06785470f, -0.20275450f, -0.05553976f, -0.14889191f, -0.03982326f, -0.20151220f, 0.07764588f, 0.46576476f, 
    -0.18822853f, 0.22918619f, 0.31593430f, -0.14986353f, 0.09951013f, -0.04691042f, 0.14284463f, 0.04315307f, 
    0.07329774f, 0.00039905f, -0.37584195f, 0.25553918f, -0.01655929f, -0.19583759f, 0.19324167f, 0.02317683f, 
    0.40183863f, -0.37257594f, -0.52993947f, 0.04693000f, -0.06631648f, 0.02889503f, -0.20278460f, 0.11746915f, 
    -0.30845121f, -0.24364294f, -0.14180291f, 0.05611260f, 0.23336725f, -0.03410050f, -0.04248265f, -0.07273484f, 
    0.06753414f, -0.00715819f, -0.01227168f, 0.04043541f, -0.05173940f, -0.26114944f, 0.04566100f, 0.04682752f, 
    -0.28223950f, -0.25380707f, 0.22653009f, 0.10731887f, 0.03139799f, -0.38682565f, 0.05083745f, 0.30142099f, 
    -0.02573756f, 0.10853551f, 0.06873647f, -0.04209417f, -0.45830408f, -0.08019964f, 0.22664684f, -0.00929011f, 
    -0.06625283f, -0.16904536f, 0.24842237f, 0.13016969f, 0.05683979f, 0.66591984f, 0.54858583f, 0.60414529f, 
    0.00845299f, -0.06309582f, -0.06824577f, -0.05372339f, -0.07109117f, -0.08356278f, -0.06531189f, -0.08513103f, 
    0.07886521f, -0.07823797f, 0.05654949f, -0.04017818f, -0.04105462f, 0.06423327f, -0.01011057f, 0.03568336f, 
    -0.01235466f, -0.00321247f, 0.03260981f, -0.10391098f, -0.08007769f, -0.06987828f, -0.11693230f, -0.05012895f, 
    -0.10914385f, -0.06522365f, -0.04519043f, -0.08626443f, -0.10663942f, -0.04488152f, 0.02102158f, -0.04893380f, 
    0.04188605f, 0.06458516f, -0.06597454f, -0.08443099f, 0.07736968f, -0.01240156f, -0.11295468f, -0.03558248f, 
    -0.05381509f, -0.00948176f, 0.00824298f, -0.07959035f, -0.06109734f, -0.08246794f, -0.05161866f, -0.00068539f, 
    -0.02090727f, 0.03359149f, 0.02782551f, -0.08492889f, -0.06069928f, -0.06848653f, -0.02172693f, -0.01792108f, 
    0.08060487f, -0.07460973f, -0.15526065f, 0.07567031f, -0.06446885f, 0.04234264f, 0.03074414f, 0.01441786f, 
    -0.00428908f, -0.08292420f, -0.05200120f, -0.05958765f, 0.03479456f, -0.07938357f, 0.01282487f, -0.06128375f, 
    0.04190018f, -0.04946885f, 0.08604702f, -0.05861121f, -0.07171884f, -0.09171212f, 0.04517604f, 0.00685382f, 
    0.05351659f, -0.01455933f, -0.06971662f, 0.03689848f, -0.08206127f, -0.06845922f, -0.07119232f, -0.01497160f, 
    -0.00030131f, 0.00921585f, -0.03527054f, 0.03608076f, -0.05032049f, -0.02881792f, 0.04564764f, 0.00883922f, 
    -0.00480785f, -0.10784096f, -0.06223578f, 0.02948917f, -0.00880269f, -0.04292195f, 0.06720126f, 0.03791563f, 
    0.06443901f, -0.08903364f, -0.05741143f, -0.07588518f, 0.05780580f, -0.01813091f, -0.03833301f, -0.04364305f, 
    0.08386779f, -0.07178435f, -0.04957395f, -0.04689748f, -0.09585474f, -0.02421176f, -0.11835574f, -0.02055226f, 
    -0.09454491f, -0.02373898f, -0.05847672f, 0.01945081f, -0.10341624f, 0.02904091f, 0.03681112f, -0.07872759f, 
    0.30145201f, 0.15938757f, -0.01151239f, 0.00100680f, -0.15283555f, -0.20220481f, -0.22861840f, -0.14438273f, 
    -0.12331938f, 0.24907461f, -0.10605823f, -0.54100281f, 0.00230204f, -0.07764707f, 0.03813335f, -0.28399467f, 
    -0.02212666f, -0.06171478f, -0.07779604f, -0.39028755f, -0.09634767f, 0.28199410f, 0.01134985f, -0.14954160f, 
    0.09857214f, 0.26151636f, 0.05540030f, -0.41373488f, 0.27413464f, -0.02105228f, 0.02563994f, -0.21691516f, 
    -0.24927598f, -0.34741551f, -0.09116500f, 0.08771390f, 0.10691756f, 0.14947945f, -0.44172528f, -0.00242080f, 
    -0.04623204f, 0.02796502f, -0.07959358f, 0.02515728f, 0.18031397f, 0.08283826f, 0.05140415f, 0.08957672f, 
    0.27841845f, 0.38480732f, 0.12108172f, -0.43004501f, -0.15854597f, -0.14139107f, 0.38825309f, -0.28262258f, 
    0.09784889f, -0.00260572f, 0.29103559f, 0.06433966f, 0.01455463f, -0.00705511f, 0.08896784f, -0.29473206f, 
    -0.24127735f, 0.26175579f, 0.00478173f, 0.40886831f, 0.01431543f, 0.01002484f, 0.04121773f, -0.09173489f, 
    0.08374114f, -0.40323326f, 0.18452278f, -0.09388538f, -0.67336643f, -0.50868636f, 0.12363192f, -0.41541108f, 
    -0.01850286f, -0.33881482f, 0.21769978f, -0.67717296f, 0.10738605f, -0.02728066f, 0.10693492f, 0.13891804f, 
    -0.09212921f, -0.06853587f, -0.30400515f, 0.14613947f, -0.08416513f, -0.04408787f, -0.03477911f, 0.08800765f, 
    -0.00246665f, 0.09546666f, 0.11154522f, 0.23803227f, -0.04967238f, 0.17005408f, 0.07464813f, -0.31719539f, 
    0.05911284f, 0.06845757f, -0.21418515f, 0.47453570f, 0.08580071f, 0.07217571f, 0.43351224f, 0.09607314f, 
    0.06104983f, -0.02569811f, 0.09828962f, -0.33052924f, 0.11161937f, 0.01121718f, 0.10794541f, 0.02299855f, 
    0.16596369f, -0.26840618f, 0.37128600f, 0.00783849f, 0.00805058f, -0.07427517f, -0.05764821f, -0.39047512f, 
    -0.06670940f, -0.01687478f, -0.05848301f, 0.07993659f, -0.02964486f, -0.08513378f, 0.03507171f, -0.01491677f, 
    0.05653928f, -0.09333194f, 0.00647525f, 0.06662717f, 0.03670431f, 0.02880884f, 0.08305340f, 0.04032206f, 
    -0.02480576f, 0.07138857f, -0.09691145f, -0.07417838f, -0.07675511f, -0.08977462f, -0.00240231f, -0.06337915f, 
    -0.01288944f, -0.05127282f, -0.03647167f, -0.02436987f, -0.04438289f, -0.06311932f, -0.01961002f, 0.03903141f, 
    -0.01270099f, 0.01067402f, -0.04365277f, 0.00797853f, -0.03849257f, -0.02963511f, -0.08613858f, -0.00297201f, 
    -0.03082590f, 0.07033839f, -0.08833762f, 0.08555836f, 0.06387040f, 0.08764235f, -0.06161056f, -0.04456996f, 
    -0.08017593f, -0.06210741f, -0.02067145f, 0.04754563f, -0.01983448f, 0.06519886f, 0.06317503f, -0.06659760f, 
    -0.06841692f, -0.07945197f, -0.05420281f, -0.09910676f, 0.00046029f, -0.04489689f, -0.10163154f, -0.09720263f, 
    0.02047222f, 0.00140615f, -0.04438347f, 0.00485467f, 0.01929304f, 0.04389033f, 0.06173997f, 0.03196652f, 
    0.06430534f, 0.06236075f, 0.03856574f, -0.02897077f, -0.05235205f, 0.02956123f, -0.05880664f, 0.08306212f, 
    0.03217430f, -0.02038718f, -0.07430743f, 0.05323380f, 0.02739862f, -0.08724178f, -0.08474340f, -0.04257232f, 
    -0.06731006f, -0.01765205f, 0.04147845f, 0.07242038f, -0.07719141f, 0.02242507f, -0.06752884f, -0.01090471f, 
    -0.02000965f, -0.10184138f, 0.00215727f, -0.09620283f, -0.05470654f, 0.07157095f, 0.07610384f, -0.10127955f, 
    -0.01539589f, 0.07035521f, -0.07820293f, -0.02426663f, -0.08121035f, -0.08649373f, -0.08819019f, 0.03764679f, 
    0.04476908f, -0.05246859f, 0.05760987f, -0.03887589f, 0.03109766f, -0.01469922f, 0.02026212f, 0.05362730f, 
    -0.01973522f, 0.06447247f, -0.05821953f, 0.04304116f, 0.00338201f, 0.03322832f, -0.08191446f, -0.01434862f, 
    0.12137748f, 0.01293630f, 0.17586349f, 0.36554715f, 0.03180938f, -0.11670054f, 0.32379612f, 0.15406476f, 
    -0.19360249f, 0.06243701f, 0.09205211f, -0.00151025f, -0.09230743f, -0.02086525f, 0.05832748f, -0.27022448f, 
    -0.05829602f, 0.10204392f, 0.17922504f, 0.06804638f, -0.12932913f, -0.05151695f, -0.14186710f, 0.20501956f, 
    0.19228390f, -0.03463158f, 0.04332464f, 0.09686358f, -0.05668345f, -0.01571888f, 0.10354027f, 0.13538145f, 
    0.21611455f, -0.19971423f, 0.10209520f, -0.07022883f, 0.02312354f, -0.14771965f, -0.36260599f, 0.09228047f, 
    0.01373670f, 0.01348928f, -0.00677310f, 0.10623985f, -0.04896983f, -0.09375825f, -0.17415115f, -0.03839380f, 
    0.10247128f, -0.11711533f, 0.08081083f, 0.05155879f, -0.67190963f, 0.00326517f, 0.33754593f, 0.05977850f, 
    -0.02255318f, 0.32073534f, -0.10193773f, 0.03843230f, 0.12778839f, 0.06719834f, 0.00378021f, -0.02614543f, 
    -0.04650103f, 0.05633313f, 0.14751138f, -0.15983944f, 0.13750610f, -0.01615488f, 0.19360989f, -0.02252285f, 
    -0.04106197f, -0.06381711f, 0.01726729f, 0.14240611f, 0.08680785f, -0.04342053f, -0.07505660f, 0.32805780f, 
    -0.05759017f, 0.08489622f, 0.30051780f, 0.03583270f, 0.10475110f, 0.04146076f, 0.08524518f, 0.11997784f, 
    -0.10358473f, 0.05894390f, 0.32179993f, -0.05237056f, 0.08905242f, 0.06132846f, -0.08388664f, 0.08089907f, 
    -0.11072888f, -0.01706514f, 0.12453759f, 0.05767333f, -0.01688080f, -0.06485606f, -0.06606294f, 0.16519731f, 
    0.03458517f, -0.06083163f, 0.05746901f, 0.29261306f, 0.07886604f, 0.11690804f, 0.13849203f, 0.08382004f, 
    -0.11168963f, -0.16092211f, 0.24672642f, 0.00827025f, -0.02604398f, -0.03600402f, 0.07942527f, 0.06152901f, 
    -0.05336105f, -0.08932951f, 0.00302374f, -0.00312762f, 0.25730941f, 0.02326231f, 0.11347641f, 0.32079303f, 
    -0.06089508f, 0.00176765f, 0.02984701f, -0.01866883f, -0.13610446f, 0.00847681f, -0.02681792f, -0.09803776f, 
    -0.13862151f, 0.01092369f, 0.24266833f, 0.00865795f, -0.07023710f, 0.13779984f, 0.05460442f, -0.48829806f, 
    -0.14386688f, 0.24060728f, 0.05098652f, 0.07317275f, 0.16183592f, -0.02755513f, -0.39490983f, 0.13562037f, 
    0.18205069f, 0.11514410f, -0.22352222f, -0.38866743f, 0.16442543f, -0.23819484f, -0.06897825f, 0.16645437f, 
    -0.06216782f, 0.05990114f, 0.15239277f, -0.16172613f, 0.21226661f, -0.42468953f, -0.40694875f, 0.11850668f, 
    0.07922022f, -0.05522407f, 0.37700078f, -0.02132657f, -0.35775062f, -0.03516856f, -0.07736032f, 0.08984042f, 
    0.44576478f, 0.17717753f, 0.30470559f, 0.20343424f, -0.45813593f, 0.18479258f, 0.48281565f, 0.06318422f, 
    0.01171850f, -0.32771608f, 0.09890208f, 0.06050602f, -0.10440785f, -0.18342945f, 0.10981875f, 0.12934481f, 
    0.12748057f, 0.22022852f, 0.11213928f, 0.03649570f, 0.09029512f, 0.00521711f, 0.24225359f, -0.19355115f, 
    -0.03950440f, -0.12756564f, -0.02151135f, 0.19047381f, -0.10703628f, 0.01022821f, -0.29448664f, -0.37817216f, 
    -0.23999146f, -0.10674040f, 0.18580110f, -0.03307395f, 0.26498449f, 0.04366461f, -0.09632930f, 0.20141597f, 
    0.26023355f, -0.13917564f, -0.29464245f, -0.30855998f, -0.05631918f, 0.05336324f, 0.06540779f, 0.08218864f, 
    -0.12253449f, -0.00780882f, 0.14359082f, 0.13606407f, -0.03295049f, 0.15988356f, 0.06731147f, 0.38593692f, 
    0.08733227f, -0.13214794f, -0.24356973f, -0.09990127f, 0.11676792f, 0.12702079f, 0.21949434f, -0.19699721f, 
    -0.05685982f, 0.12753437f, 0.26380935f, 0.16069126f, -0.19612373f, -0.04196122f, 0.18720178f, -0.10072158f, 
    -0.01181294f, -0.01497579f, 0.12206759f, 0.06897404f, -0.03261220f, -0.44942057f, -0.35076845f, 0.29928684f, 
    0.43378928f, 0.08439769f, -0.09698832f, 0.25868732f, 0.34002364f, -0.10595987f, -0.01177692f, 0.30417657f, 
    0.06453764f, 0.13886906f, 0.12963417f, -0.28268769f, 0.19707923f, -0.19805652f, 0.04541147f, 0.07994574f, 
    -0.00940489f, -0.01159659f, 0.02342823f, -0.08563434f, -0.30545026f, -0.21629967f, 0.31239066f, 0.00966539f, 
    -0.03701958f, 0.12981568f, 0.25447369f, -0.12599249f, 0.16165379f, 0.11397165f, 0.09396252f, -0.23828381f, 
    0.21688116f, 0.20514859f, 0.10217319f, -0.10257731f, 0.00690044f, 0.12472695f, -0.02830084f, 0.25309336f, 
    -0.12171149f, -0.00482866f, 0.11982729f, 0.36795038f, 0.25077862f, -0.04024921f, 0.04679833f, -0.02849483f, 
    0.06207702f, -0.13281921f, -0.08579098f, 0.19747476f, 0.33445147f, -0.42840517f, 0.26932892f, 0.20211789f, 
    0.31171238f, -0.75840837f, -0.07581719f, -0.04336205f, 0.06102642f, 0.06450170f, 0.03499602f, 0.07773504f, 
    -0.28644162f, 0.22967266f, 0.26993367f, -0.26624653f, 0.00486057f, -0.10177470f, -0.10380082f, -0.14853887f, 
    -0.05313402f, 0.05696952f, 0.04424820f, 0.01708151f, -0.00763125f, -0.20260721f, 0.00545189f, 0.48863655f, 
    -0.09258480f, 0.00619398f, 0.25156206f, -0.19494560f, 0.05285178f, -0.02367537f, 0.18346021f, 0.10812459f, 
    -0.28953785f, -0.15060896f, -0.28096291f, -0.05179292f, 0.05984445f, 0.16798502f, -0.06625734f, 0.03905416f, 
    0.11141611f, 0.04373846f, 0.28818402f, 0.10559129f, 0.14743398f, -0.09206687f, -0.01918705f, 0.08303848f, 
    0.14612944f, -0.31304225f, -0.29768923f, -0.07248907f, 0.12476370f, -0.09920304f, 0.09787074f, -0.18013532f, 
    0.01189694f, 0.05434504f, 0.11014128f, -0.04661890f, 0.02962996f, 0.01153652f, 0.13838430f, -0.05687786f, 
    -0.11470779f, 0.03245176f, -0.04979484f, -0.02253729f, -0.23920180f, 0.14768852f, 0.11634653f, 0.00969040f, 
    0.08754762f, 0.04173024f, -0.03043879f, 0.02954470f, 0.03837698f, -0.08699925f, -0.05393768f, -0.06017531f, 
    0.03521870f, -0.03129413f, -0.00478846f, -0.01735469f, -0.00194328f, 0.01225322f, 0.08010878f, 0.02153652f, 
    0.00651902f, 0.05049243f, -0.03550571f, -0.00387156f, -0.04239497f, -0.06433292f, 0.02506516f, -0.00797372f, 
    0.02905446f, -0.10611427f, -0.02303131f, -0.07348317f, -0.07339158f, -0.00880532f, -0.02305267f, -0.08060811f, 
    -0.06495063f, 0.03015385f, -0.06609977f, -0.00841114f, -0.04295437f, -0.05286546f, -0.00015673f, -0.04312488f, 
    -0.04314824f, 0.01033838f, -0.03100329f, 0.04418996f, 0.05047200f, 0.05131488f, -0.07298979f, -0.04816587f, 
    -0.08597887f, -0.07199892f, -0.04884802f, -0.04576404f, 0.07284725f, -0.06735689f, -0.10419944f, -0.00681011f, 
    0.08291640f, 0.04125175f, -0.08824926f, -0.04029804f, 0.00544489f, -0.01398720f, 0.06132977f, -0.09740724f, 
    -0.05440044f, -0.02176229f, -0.05575682f, 0.03488030f, -0.00696988f, -0.03723539f, 0.01747378f, 0.05537661f, 
    0.07518512f, 0.04217330f, 0.00366451f, -0.08276674f, -0.07922301f, 0.02774123f, -0.02114761f, 0.01534162f, 
    -0.04681579f, -0.04224644f, 0.00031559f, 0.06457730f, -0.07946999f, -0.01709837f, -0.08500434f, -0.08403690f, 
    -0.00008200f, -0.04310676f, 0.04018708f, 0.04139811f, -0.08582210f, -0.03522792f, 0.00629452f, 0.02328287f, 
    0.01983944f, -0.00348699f, 0.05545935f, 0.04954894f, 0.02478861f, -0.07133658f, 0.00076210f, -0.03942714f, 
    -0.00048346f, -0.02822004f, -0.10542966f, 0.03222312f, 0.04635518f, -0.02464328f, -0.07057390f, 0.03404484f, 
    -0.03925642f, -0.07170289f, -0.08531734f, 0.05198192f, -0.09034546f, -0.05209704f, 0.05997858f, -0.01390524f, 
    0.03267868f, -0.02409163f, -0.01839758f, -0.00801735f, -0.06181837f, 0.06798442f, -0.02153617f, 0.07553823f, 
    -0.46572760f, 0.21779129f, -0.20092797f, -0.35229260f, -0.07319441f, 0.18676183f, 0.08268080f, 0.09039445f, 
    0.04526761f, 0.01199797f, -0.07425397f, 0.14452380f, -0.16691029f, 0.12511697f, 0.07639788f, -0.09545349f, 
    0.22312960f, 0.17079072f, 0.14509776f, -0.07463722f, 0.20215471f, 0.08593298f, -0.29066312f, -0.37062678f, 
    0.04481469f, 0.00063402f, -0.03162887f, -0.07331464f, -0.03213814f, -0.14439610f, -0.05594755f, 0.18103209f, 
    -0.00123884f, 0.65906757f, 0.09536112f, 0.27867413f, -0.10114907f, 0.44271305f, 0.27249521f, 0.05139575f, 
    0.05941705f, -0.01563581f, 0.13384221f, 0.05298224f, 0.09897717f, 0.08045761f, 0.20812947f, 0.00711414f, 
    0.12982906f, 0.25094852f, 0.21577883f, -0.15270317f, 0.27709955f, 0.14433038f, 0.02592306f, 0.13232751f, 
    -0.06702726f, -0.30794492f, 0.16369471f, 0.03627029f, -0.12493290f, 0.02204029f, 0.10801303f, -0.07549641f, 
    -0.07641799f, 0.17151019f, -0.09631783f, 0.23451339f, 0.20216879f, -0.04584889f, 0.19295223f, 0.21956730f, 
    0.03684800f, 0.41751724f, -0.07723615f, 0.08275185f, -0.00339444f, 0.12217140f, 0.18736129f, 0.43514910f, 
    -0.22884154f, 0.14344329f, 0.03981748f, -0.05587643f, -0.00234588f, -0.06285553f, -0.41123661f, -0.05941365f, 
    -0.02312622f, -0.06463520f, -0.26946476f, -0.02908499f, -0.01941292f, 0.05197766f, -0.05901432f, -0.10326385f, 
    0.11534264f, 0.13901912f, -0.25302088f, 0.06985208f, 0.09349944f, -0.05100836f, -0.00392439f, 0.07860994f, 
    -0.08661016f, 0.22258560f, 0.36030167f, 0.13320154f, -0.03041993f, -0.17555264f, 0.00941944f, 0.01202179f, 
    -0.00823794f, 0.18740058f, -0.24700098f, 0.11203931f, -0.09087312f, 0.00857812f, 0.01891148f, 0.04808169f, 
    -0.03486416f, 0.08719373f, 0.10884228f, 0.17883709f, -0.14429112f, 0.17802440f, 0.03759563f, 0.52490020f, 
    -0.02065950f, -0.04610112f, 0.01621948f, 0.06737170f, -0.06810024f, -0.00535438f, -0.06511248f, -0.08215236f, 
    -0.05383467f, -0.00766821f, 0.04468617f, -0.09076068f, -0.05204953f, -0.07015882f, 0.03586256f, -0.04032010f, 
    0.01979993f, -0.04811516f, -0.00476931f, -0.03047746f, 0.06563944f, 0.05779657f, -0.03274277f, -0.07994711f, 
    0.01722382f, -0.03602923f, -0.00581543f, 0.01899427f, -0.03548032f, -0.00315952f, -0.00123292f, -0.05968791f, 
    0.05985596f, 0.05891953f, -0.10168585f, -0.00428143f, -0.02861657f, -0.06424159f, -0.06116811f, -0.09631313f, 
    0.03928732f, 0.06249273f, -0.04016523f, 0.06448908f, -0.05922793f, 0.08491905f, 0.04382727f, -0.05364109f, 
    -0.02882804f, -0.08364380f, -0.01768191f, 0.06979595f, 0.03352560f, 0.02285706f, -0.06126441f, -0.00462017f, 
    0.01728766f, 0.03136246f, -0.01850408f, -0.06601676f, -0.05189312f, -0.01786850f, 0.01071605f, -0.04433824f, 
    0.06213876f, 0.00680035f, 0.02032994f, 0.04129126f, -0.03339003f, 0.06348924f, -0.00184124f, 0.00996069f, 
    -0.01652846f, -0.03152114f, -0.05297324f, 0.05803383f, -0.09258626f, -0.01177639f, -0.04192124f, -0.07340374f, 
    0.03736431f, -0.03148087f, 0.01369173f, -0.00256106f, -0.06000056f, -0.04747377f, 0.06150924f, -0.05164386f, 
    0.05639453f, -0.08994775f, -0.06108969f, 0.04338446f, 0.05232063f, 0.06645530f, 0.03480061f, -0.05699513f, 
    -0.07160996f, -0.04958969f, 0.08107458f, 0.04793173f, 0.03455999f, -0.04870369f, 0.04302000f, 0.07102534f, 
    -0.07602396f, 0.05028741f, -0.03902350f, -0.00544336f, 0.00266071f, 0.07111270f, -0.07866231f, -0.02033911f, 
    0.08252759f, -0.04810767f, -0.05131446f, -0.02938916f, -0.09231044f, 0.00391429f, -0.09121471f, -0.04412128f, 
    -0.00337715f, 0.07478700f, 0.03564035f, 0.04522934f, -0.09793395f, -0.05639862f, -0.03844906f, -0.02950231f, 
    -0.30340281f, 0.02569660f, 0.11334234f, 0.06303695f, -0.06476200f, -0.04002811f, 0.03495937f, 0.17506638f, 
    -0.10913892f, 0.12314117f, 0.22692342f, 0.05204144f, 0.05868942f, 0.04250558f, -0.02119645f, -0.06659222f, 
    0.03357141f, 0.25498217f, -0.03413744f, 0.02292466f, -0.01629457f, 0.08782367f, -0.30897769f, -0.09360990f, 
    0.13273181f, -0.01125119f, 0.03193896f, 0.31315112f, -0.03205386f, 0.04100907f, 0.13670953f, 0.12082560f, 
    0.22307044f, 0.26913020f, 0.07860769f, -0.10163411f, -0.10172683f, 0.07074443f, 0.03981754f, 0.12536795f, 
    0.15348811f, 0.04587290f, 0.53859967f, 0.09541851f, -0.13767816f, -0.09137179f, -0.02492101f, 0.03640240f, 
    0.00819077f, 0.07768833f, 0.20729652f, -0.11269008f, -0.47933340f, 0.22628663f, 0.06112026f, 0.18765298f, 
    0.14168179f, -0.16957662f, 0.06695155f, -0.19231370f, 0.04724050f, 0.08801217f, 0.03885419f, 0.08186221f, 
    0.16705884f, 0.09965430f, 0.05523538f, -0.17150564f, -0.02128551f, 0.00643571f, 0.26943040f, 0.10913804f, 
    0.05142558f, 0.01991783f, -0.10720741f, 0.19830470f, 0.06214947f, 0.12074871f, -0.01696553f, 0.27790937f, 
    -0.10553613f, -0.21655366f, 0.11713953f, -0.16461007f, -0.01741045f, 0.05609398f, -0.40510419f, 0.03870388f, 
    0.16834988f, -0.13245337f, -0.07662581f, -0.14784792f, 0.10420456f, 0.15778193f, -0.05802052f, 0.07892490f, 
    0.02458941f, -0.04637204f, 0.02359542f, 0.04043959f, -0.14384590f, 0.05509352f, 0.02018902f, 0.12446238f, 
    0.08099537f, -0.07619303f, 0.49151251f, 0.07716242f, -0.03825052f, -0.11181001f, -0.01558653f, -0.29881167f, 
    -0.02854390f, 0.07593203f, -0.11325948f, 0.29204232f, -0.09213889f, 0.07490539f, 0.07973152f, -0.01470735f, 
    0.16095057f, -0.01339354f, 0.28447261f, 0.06142890f, 0.00955749f, 0.13479349f, -0.19741170f, 0.31905022f, 
    0.20467088f, -0.11146577f, 0.27322212f, 0.33122170f, -0.08721133f, -0.19309206f, 0.05714624f, 0.00001577f, 
    -0.11767381f, 0.13669808f, 0.03152942f, -0.03063910f, 0.39449570f, 0.12409845f, 0.03696336f, 0.14779355f, 
    0.12846075f, -0.20781596f, -0.10369324f, 0.10659847f, 0.17113970f, 0.15080573f, 0.40425205f, -0.14733844f, 
    -0.29512480f, 0.08905105f, -0.01866661f, 0.31579962f, -0.16662396f, 0.14389876f, 0.06735794f, 0.07817029f, 
    0.23764011f, -0.12964907f, -0.14350979f, -0.03762674f, -0.05707256f, 0.23361965f, -0.61441338f, 0.15151978f, 
    -0.12882799f, 0.07363560f, -0.03548285f, -0.42972830f, -0.11740267f, 0.01198160f, 0.04755299f, -0.22032449f, 
    -0.35747105f, 0.02246119f, -0.35002878f, 0.09575747f, -0.06464382f, 0.27677518f, -0.36927027f, 0.09058703f, 
    -0.01855617f, 0.19907676f, -0.05785320f, -0.09208407f, 0.16579889f, 0.44816390f, -0.34436300f, -0.31262460f, 
    -0.21519053f, -0.02726413f, -0.35149682f, -0.32814437f, -0.13608861f, 0.03081852f, -0.06483832f, 0.08289599f, 
    -0.06383172f, -0.36886474f, -0.08708020f, -0.26082727f, 0.29304737f, -0.00971701f, 0.11924218f, -0.10547543f, 
    0.11347096f, -0.12199196f, -0.19935240f, 0.17203292f, -0.05989724f, 0.06686035f, 0.02671383f, 0.07128420f, 
    0.25685072f, 0.16539253f, 0.15301646f, -0.05820470f, 0.05872774f, 0.14881144f, 0.03949033f, 0.02791593f, 
    -0.16524200f, 0.05555083f, 0.07329769f, 0.24540786f, 0.02863633f, -0.00568713f, -0.01526145f, 0.19263875f, 
    -0.02019391f, 0.12178458f, -0.12340101f, -0.45244697f, 0.06583925f, 0.18640295f, -0.11623745f, 0.03553921f, 
    -0.04753514f, 0.01258512f, 0.08986806f, -0.07722823f, 0.25771645f, 0.16159683f, -0.28895488f, 0.04327318f, 
    0.25684643f, -0.08871942f, -0.06634127f, 0.24739735f, -0.19321646f, -0.37227979f, 0.34793368f, -0.52497011f, 
    -0.01521943f, 0.17231110f, -0.22946647f, -0.02628839f, 0.20276776f, -0.02697809f, 0.26890445f, -0.03601262f, 
    -0.14090604f, 0.12047491f, -0.13877103f, 0.15493748f, 0.07618119f, -0.11951546f, 0.03668673f, 0.10686069f, 
    0.16663004f, -0.08331260f, -0.23167680f, -0.41410285f, -0.03072842f, -0.08559648f, 0.08089689f, -0.08458628f, 
    -0.49540457f, 0.27135289f, 0.13686270f, -0.45408684f, -0.06206107f, 0.21780381f, 0.10002160f, -0.02109916f, 
    -0.23513956f, -0.20648044f, -0.10074323f, 0.20790792f, -0.03981410f, 0.44178680f, 0.23344786f, -0.14777602f, 
    -0.18741122f, 0.03222455f, -0.26439786f, -0.14907061f, -0.08917600f, 0.04252602f, 0.15610957f, 0.00013212f, 
    0.55625367f, 0.16618966f, -0.04661771f, -0.24712569f, 0.21311949f, -0.08324530f, -0.12816063f, 0.13236706f, 
    0.04066828f, -0.13831525f, 0.19246288f, 0.03192169f, -0.18206105f, 0.10981737f, 0.00277719f, -0.58452487f, 
    -0.47448668f, 0.16102989f, 0.05406885f, 0.31134415f, -0.13698483f, -0.10065078f, -0.36555660f, -0.08294889f, 
    0.06709781f, 0.27346548f, 0.08758003f, -0.14690822f, 0.04612007f, -0.01269828f, 0.13099065f, 0.22010948f, 
    0.01959651f, 0.08792187f, 0.72722107f, -0.11581004f, 0.15057564f, 0.00043505f, 0.15463874f, 0.01641801f, 
    -0.04007275f, -0.04276269f, -0.40855154f, 0.22183302f, -0.21234533f, 0.07313001f, 0.00266682f, -0.03349667f, 
    0.13919073f, 0.16119139f, -0.01214908f, 0.20201771f, 0.07264657f, 0.00827071f, -0.06077519f, -0.14275281f, 
    0.16130067f, 0.12799571f, 0.03437962f, 0.17372862f, 0.10675462f, -0.08437431f, 0.23028983f, -0.20269434f, 
    0.05057938f, 0.08473874f, 0.05312706f, -0.02697227f, 0.34632838f, -0.16746512f, -0.05471370f, -0.02244898f, 
    -0.20866780f, 0.04715297f, -0.05427542f, 0.04387914f, 0.10966021f, -0.15802929f, -0.39041272f, -0.03300683f, 
    -0.19506148f, 0.14407302f, -0.05192184f, -0.05548977f, -0.27074751f, 0.22833446f, -0.25906351f, -0.02863122f, 
    -0.16255349f, 0.14818922f, 0.09055652f, 0.08186875f, 0.12133142f, 0.26653486f, -0.05127076f, -0.16403642f, 
    0.12888786f, -0.02009177f, -0.14900023f, -0.13298605f, 0.15737429f, 0.23064189f, -0.10267364f, -0.12966704f, 
    0.13370770f, 0.04920613f, 0.01492258f, -0.10992093f, -0.04003768f, -0.54263276f, 0.14216162f, -0.11525644f, 
    -0.25842410f, 0.07816508f, 0.06348918f, -0.04982808f, 0.30038801f, -0.06870624f, -0.09932851f, -0.00697206f, 
    0.18934880f, -0.00404038f, 0.18438618f, 0.04234524f, 0.20669264f, -0.07600758f, 0.32505980f, 0.14739430f, 
    0.16403157f, 0.32045856f, 0.06414563f, -0.13726330f, -0.00303987f, 0.16096473f, 0.12996893f, -0.02955439f, 
    0.32646507f, -0.15481021f, 0.25363159f, 0.08819591f, 0.04688187f, -0.01932155f, 0.09312276f, -0.19759555f, 
    -0.00660383f, 0.34962702f, 0.17690226f, 0.27842650f, 0.01940238f, 0.08379490f, 0.06018591f, 0.03982634f, 
    -0.03381477f, 0.08038938f, 0.03175039f, -0.04909261f, -0.29109082f, -0.05286749f, -0.05399798f, -0.11550149f, 
    -0.19066794f, -0.19846642f, 0.20085211f, -0.39718577f, 0.17839777f, -0.00787968f, -0.27192947f, -0.07262418f, 
    0.09505018f, 0.03143287f, -0.23156846f, -0.14528045f, -0.05117167f, 0.26567191f, 0.00371994f, 0.04747129f, 
    0.09917380f, 0.22681445f, -0.05927096f, -0.06241574f, 0.00457865f, 0.22311315f, -0.03537865f, -0.04826073f, 
    0.03476238f, 0.10500821f, -0.05482246f, 0.04208430f, -0.06616387f, 0.02027388f, 0.06976761f, -0.35630175f, 
    -0.06185886f, 0.28762662f, -0.08122946f, 0.18376297f, -0.08246735f, 0.11573750f, 0.21190983f, 0.19976576f, 
    0.09884186f, 0.05253797f, 0.13429819f, -0.04024588f, -0.09127206f, -0.21142088f, -0.48365346f, 0.31331661f, 
    0.27440080f, 0.01740118f, 0.02329927f, 0.03371706f, 0.19309607f, 0.05410892f, 0.11642782f, -0.07242733f, 
    0.14588518f, 0.14121756f, -0.05444078f, 0.10587378f, 0.15526032f, 0.09154584f, 0.01389401f, 0.29296345f, 
    0.29257131f, -0.05178834f, 0.27801943f, 0.12450176f, 0.24106590f, -0.03067538f, 0.34800455f, -0.25937715f, 
    -0.16899535f, 0.04763580f, -0.03867203f, 0.10768674f, -0.06838802f, 0.05733161f, 0.07219457f, 0.08097930f, 
    0.11673840f, -0.19439061f, -0.14387357f, 0.15996347f, 0.01784054f, 0.06044739f, 0.02995006f, 0.01398261f, 
    0.00102257f, -0.06804982f, -0.13478962f, -0.23194988f, 0.21055801f, 0.07964858f, -0.00966004f, -0.11183498f, 
    -0.09100212f, -0.16147971f, -0.03917991f, 0.07543962f, 0.34963071f, -0.08303669f, -0.26617214f, -0.08263909f, 
    -0.09189222f, -0.17460389f, 0.07558438f, 0.21814153f, 0.14676179f, 0.00127450f, -0.09039149f, -0.03171346f, 
    -0.03404075f, -0.34141982f, -0.08223806f, 0.02266152f, 0.07485936f, 0.02193715f, -0.05527486f, 0.15494803f, 
    -0.07360352f, 0.08577302f, 0.08387232f, -0.01212261f, 0.00431916f, 0.07222308f, -0.11644037f, 0.08302512f, 
    -0.04366924f, 0.13809612f, 0.09772629f, 0.05904539f, -0.15848319f, 0.00774297f, 0.30304918f, -0.10749767f, 
    0.05818687f, 0.20150641f, -0.09320077f, -0.00083691f, 0.09184878f, -0.14888370f, -0.06331036f, 0.06826187f, 
    0.21682698f, 0.03574108f, 0.04948893f, -0.03476004f, 0.28820652f, 0.11680965f, 0.01459567f, -0.20555696f, 
    0.18173595f, 0.19232565f, -0.10253944f, -0.05701493f, 0.15766473f, 0.08279420f, -0.17296089f, 0.06395125f, 
    0.00251569f, 0.03350711f, -0.13431680f, 0.05013223f, 0.20789009f, 0.09946711f, -0.07432157f, 0.03395306f, 
    -0.00405280f, 0.24723622f, -0.16893354f, 0.00768961f, -0.02518544f, -0.15976608f, -0.05538506f, -0.34969601f, 
    -0.04418365f, -0.04229415f, 0.07183042f, -0.18372032f, 0.16851409f, -0.02729439f, -0.06397246f, 0.15234379f, 
    -0.12084524f, 0.12270203f, 0.30048659f, 0.20465350f, -0.00454768f, -0.12707576f, 0.07636598f, -0.24793568f, 
    -0.07070134f, 0.32513082f, 0.16454832f, 0.10602850f, -0.01440144f, -0.00056200f, -0.34933427f, 0.04331772f, 
    0.21309462f, 0.01271136f, 0.25178164f, 0.20666850f, -0.01786016f, 0.06941615f, 0.00183072f, 0.30108410f, 
    0.42448938f, -0.08307469f, 0.09722029f, -0.04596444f, -0.31587529f, 0.06286716f, -0.09025019f, 0.22771825f, 
    0.00381324f, -0.05624322f, 0.42567757f, -0.04735689f, -0.26946527f, -0.08472213f, -0.24053487f, -0.08835130f, 
    -0.11083814f, 0.08524880f, 0.06972960f, 0.07049280f, -0.69604987f, 0.15636291f, 0.09133759f, 0.50790554f, 
    -0.12782462f, -0.33016565f, 0.02986803f, -0.17447953f, 0.04054823f, 0.22326757f, 0.08113983f, -0.04507738f, 
    -0.11027354f, 0.06232737f, 0.25278497f, -0.22082013f, 0.13047807f, 0.03987505f, 0.35859928f, -0.05196554f, 
    -0.01006171f, -0.55380422f, -0.09324907f, 0.34019205f, 0.13108929f, 0.25419965f, -0.25406289f, 0.26864687f, 
    -0.18041933f, -0.11814076f, 0.23371668f, 0.01156497f, -0.09727252f, 0.03615838f, -0.35004124f, 0.08121777f, 
    0.03094219f, 0.03277826f, -0.41400242f, -0.76559383f, 0.15097536f, 0.11353967f, -0.06578697f, 0.03622421f, 
    -0.10471186f, 0.13018475f, -0.15137270f, -0.03416945f, -0.26602063f, 0.05006839f, -0.01823106f, 0.45381546f, 
    -0.02533121f, -0.36381420f, 0.24546632f, -0.26238310f, 0.07365312f, -0.06484385f, -0.07783793f, -0.27913401f, 
    0.02011824f, -0.07019025f, 0.08358459f, 0.34702340f, -0.22159749f, -0.08926544f, 0.16771375f, -0.33211559f, 
    0.11542045f, -0.06543054f, 0.00673648f, 0.12156399f, -0.11698754f, -0.08033938f, 0.04487779f, 0.19123983f, 
    -0.10402804f, -0.09392569f, -0.06156865f, 0.05826860f, -0.09834078f, -0.05578959f, -0.01983995f, -0.09071840f, 
    -0.02751522f, 0.02976458f, 0.03447473f, -0.02695176f, -0.05919328f, 0.02546658f, -0.06515235f, -0.05686362f, 
    0.02051931f, -0.00439605f, -0.09377885f, -0.10953350f, 0.05535869f, -0.09050848f, 0.02363737f, 0.04565065f, 
    -0.08352894f, -0.07988345f, -0.06907492f, -0.03932938f, -0.05284480f, -0.06994978f, -0.00084294f, -0.09631881f, 
    -0.06639681f, -0.04786098f, -0.00210802f, 0.02637534f, 0.02219955f, 0.07873195f, 0.01590359f, 0.00619487f, 
    -0.01538276f, 0.00720927f, -0.07979065f, -0.08164166f, -0.06365208f, -0.00438350f, 0.04433290f, 0.04576437f, 
    0.07205313f, -0.02139562f, 0.04316253f, 0.04146936f, -0.08717550f, -0.10756618f, 0.01239274f, -0.11128391f, 
    -0.01623324f, 0.03542897f, 0.04269828f, -0.03155962f, -0.01695274f, -0.04146119f, -0.06368829f, -0.02459302f, 
    -0.08560096f, -0.06876875f, -0.05922225f, -0.09959961f, 0.03787570f, 0.03058333f, 0.03609167f, 0.02108578f, 
    0.02030120f, -0.04049662f, -0.11188754f, -0.01850905f, -0.04914641f, 0.02426445f, 0.04220830f, -0.08225378f, 
    -0.03852170f, -0.11344982f, 0.07274139f, 0.02269238f, -0.05936084f, 0.07638734f, -0.06743504f, -0.03915539f, 
    -0.00571778f, 0.00163384f, 0.05073132f, -0.04697093f, -0.06222260f, 0.05290173f, 0.04910979f, -0.06576135f, 
    -0.06095857f, 0.01982362f, 0.02972795f, -0.01761077f, 0.04257314f, -0.04561088f, -0.06609237f, -0.00505532f, 
    -0.06540395f, 0.01243952f, 0.02242515f, -0.02655344f, -0.05827948f, -0.06850357f, -0.07995857f, -0.05418786f, 
    -0.00923951f, -0.02044837f, -0.01978344f, -0.08878010f, 0.02937160f, -0.01004998f, -0.05342552f, -0.09847809f, 
    -0.11469373f, 0.05740154f, -0.06242357f, -0.07332581f, -0.01017262f, -0.07169463f, -0.00188283f, -0.07466324f, 
    0.12775673f, 0.12781781f, 0.07712582f, 0.15333161f, 0.30977711f, 0.00546989f, 0.25325397f, 0.24681234f, 
    0.07217721f, 0.04150071f, 0.04601877f, -0.07701694f, 0.15976340f, 0.01085747f, 0.02955927f, -0.24867454f, 
    -0.07726083f, 0.10590352f, 0.04060125f, 0.17374784f, -0.10959879f, -0.11316388f, 0.14633280f, -0.08854561f, 
    0.01402831f, 0.08592407f, 0.21126963f, 0.41802019f, -0.00867395f, 0.02914491f, 0.03525240f, -0.14277387f, 
    0.29477891f, -0.06967328f, 0.09601355f, 0.10865904f, -0.08886937f, 0.25918621f, -0.00717474f, 0.04333052f, 
    -0.11760519f, 0.02698993f, 0.05369556f, 0.20402133f, 0.54673821f, 0.02742676f, 0.05673068f, 0.04206786f, 
    -0.08457652f, -0.19856545f, -0.10194730f, 0.11792437f, -0.31201783f, -0.35335657f, 0.08057434f, 0.14902626f, 
    0.03755062f, -0.33472916f, -0.09103647f, 0.03199219f, 0.02336437f, 0.16143377f, 0.15220790f, -0.04004509f, 
    -0.15643221f, -0.11086253f, 0.16939954f, -0.15687789f, 0.02290012f, 0.08538308f, -0.06765566f, -0.06333608f, 
    -0.00448367f, 0.03488796f, -0.09356403f, -0.01184883f, 0.20191827f, -0.14337499f, 0.03879923f, -0.01910423f, 
    -0.20124219f, 0.18148701f, 0.27194065f, 0.16730812f, -0.02817909f, -0.04149774f, 0.11830318f, -0.03860703f, 
    -0.19005841f, 0.08254001f, -0.02053414f, 0.13688575f, 0.17373635f, 0.04490944f, -0.02671435f, 0.04854809f, 
    0.05220835f, 0.11184487f, -0.00624247f, 0.03143689f, 0.07336862f, -0.22647919f, 0.04219582f, 0.01857656f, 
    0.03387419f, -0.06621828f, 0.19468455f, -0.00255960f, -0.01010399f, -0.12442318f, -0.03963304f, -0.05969014f, 
    0.00009086f, 0.09011730f, 0.04571917f, -0.04501413f, 0.04562847f, -0.00626835f, 0.16729313f, -0.14704038f, 
    -0.21481512f, 0.07196823f, -0.06821340f, -0.01222691f, -0.18395475f, 0.35216889f, 0.27257469f, 0.12142199f, 
    0.21214442f, -0.03660307f, -0.11707903f, 0.00414374f, 0.02916163f, -0.10206946f, -0.11041124f, -0.12006849f, 
    0.36755347f, 0.08786564f, 0.25445130f, 0.07161344f, 0.23001684f, 0.12606509f, -0.08747316f, 0.11398286f, 
    -0.00008966f, 0.07108817f, -0.12882856f, 0.43156815f, -0.01635990f, 0.05981287f, 0.41329670f, -0.28657651f, 
    0.09426834f, -0.03797984f, 0.31737456f, 0.10009629f, -0.10056560f, 0.05774983f, 0.07770662f, -0.30376130f, 
    -0.21014540f, -0.05751284f, -0.06488664f, -0.03783140f, -0.18447973f, 0.08507162f, 0.11680260f, 0.18838543f, 
    0.12695736f, -0.08758553f, 0.07462882f, 0.38763088f, 0.23681358f, -0.03212352f, -0.00775234f, -0.11606098f, 
    -0.50917560f, 0.01784588f, -0.03206632f, 0.22507741f, -0.11669303f, 0.06750397f, -0.28775916f, 0.31212303f, 
    0.20462582f, -0.31745523f, -0.03577117f, -0.21124730f, 0.27830634f, 0.28571337f, -0.00893659f, -0.03087916f, 
    -0.00438508f, -0.06910319f, -0.01020033f, -0.11886184f, -0.16426019f, 0.03665404f, -0.14820130f, 0.06154561f, 
    -0.03740047f, -0.13636681f, 0.06653900f, -0.35641590f, -0.11899251f, -0.01215650f, 0.02119785f, -0.31130686f, 
    0.01371456f, -0.00719270f, -0.04413438f, 0.02619016f, -0.02650887f, -0.00410449f, -0.03851960f, 0.05785968f, 
    0.19126250f, 0.30158892f, -0.05902099f, 0.02365713f, -0.01726447f, 0.32279688f, -0.11896232f, -0.02733207f, 
    -0.06892763f, -0.03684184f, -0.09024640f, 0.10711319f, 0.19364335f, -0.07974856f, -0.04060460f, 0.07732112f, 
    -0.11466055f, -0.13068320f, -0.19355503f, -0.33921358f, 0.15668842f, 0.12384340f, -0.15007459f, -0.08239681f, 
    0.08628639f, 0.05249648f, -0.27500090f, 0.11490803f, 0.38305098f, 0.26131475f, 0.02988354f, 0.14076924f, 
    0.22083209f, -0.09883428f, 0.16450903f, 0.00103484f, 0.08195744f, -0.47644338f, 0.10239813f, -0.56708914f, 
    -0.22751132f, -0.00233748f, -0.46920151f, -0.44860044f, -0.10710128f, -0.09487022f, 0.06411375f, 0.10230664f, 
    0.24948350f, 0.14994319f, 0.11808580f, 0.11191031f, 0.03699517f, 0.08075311f, 0.03549392f, -0.27451688f, 
    0.01720254f, 0.22282463f, 0.03180799f, 0.21383098f, 0.25605327f, 0.21410747f, -0.11354093f, -0.21005291f, 
    0.03605609f, -0.07438873f, 0.12707406f, 0.23703568f, -0.16886891f, 0.00638822f, -0.08173274f, 0.07074348f, 
    0.07817280f, -0.63189226f, -0.05657057f, 0.12748772f, -0.15637246f, 0.14179173f, 0.00291378f, 0.03841623f, 
    0.18586129f, -0.08216530f, -0.31831160f, 0.01081959f, 0.15429255f, -0.05353174f, -0.10796993f, -0.05267603f, 
    0.19130683f, 0.02330237f, -0.01055573f, 0.08441484f, -0.66372550f, 0.18915087f, -0.28843969f, 0.39333272f, 
    -0.25827152f, -0.45271814f, 0.09920240f, 0.02576563f, -0.12471154f, 0.17323469f, 0.01803399f, -0.48009476f, 
    0.05803161f, 0.02263321f, 0.10608466f, 0.23939626f, -0.03748279f, -0.04901255f, 0.24961379f, 0.11894560f, 
    -0.06818604f, 0.06920225f, 0.12522787f, -0.11661935f, -0.13567705f, 0.19097342f, -0.17362946f, -0.18444675f, 
    -0.32257333f, 0.07060540f, 0.53394550f, -0.17264965f, -0.08339799f, -0.08412244f, -0.31112742f, -0.05682201f, 
    0.23062462f, 0.07913789f, -0.31849957f, -0.14704685f, 0.02557161f, -0.01818206f, 0.04917403f, 0.01819029f, 
    0.11347345f, 0.15709470f, -0.29296529f, -0.21378417f, -0.03351429f, 0.11484288f, 0.05395034f, 0.19605161f, 
    -0.06597821f, -0.04972333f, 0.10228051f, -0.24842823f, 0.00203269f, -0.10639767f, -0.07911272f, -0.41943550f, 
    -0.06301536f, 0.00891793f, -0.20998824f, 0.36432424f, 0.16640267f, 0.22560798f, 0.04142172f, -0.05447927f, 
    0.10425092f, 0.04535018f, -0.01140601f, -0.06429033f, 0.03932655f, -0.09128008f, -0.48255682f, -0.28474489f, 
    -0.01269816f, 0.00852211f, -0.04452214f, -0.04365282f, 0.06233298f, -0.00738247f, 0.04148847f, -0.03090520f, 
    0.01281728f, -0.10042208f, 0.01697097f, -0.10108127f, -0.03607772f, -0.06877933f, -0.03421917f, 0.06612536f, 
    -0.04407404f, 0.06356056f, -0.03353624f, 0.01404539f, 0.04980790f, -0.05449288f, -0.00006315f, -0.02073829f, 
    -0.02802251f, -0.03539588f, -0.00849439f, -0.00954249f, 0.02742370f, 0.04616228f, 0.02533809f, 0.02368561f, 
    -0.02004101f, -0.04505472f, -0.05595328f, -0.09527037f, 0.01351573f, 0.04584415f, 0.00564244f, -0.08867952f, 
    0.01043160f, 0.06756988f, -0.07061346f, 0.06018840f, 0.01511492f, -0.06764562f, 0.04404612f, -0.05229709f, 
    -0.07896511f, -0.08930907f, -0.03795320f, -0.08713461f, 0.00980440f, 0.08499273f, 0.06564415f, -0.08777069f, 
    -0.05389334f, -0.05446120f, -0.02207305f, 0.00556406f, 0.02511269f, -0.02953394f, 0.03823023f, -0.02639616f, 
    -0.03485468f, 0.02863736f, 0.04932195f, -0.08456121f, -0.07753324f, -0.06778599f, 0.02735055f, 0.04265263f, 
    -0.07673146f, -0.00434639f, -0.04632128f, -0.08038715f, -0.00547780f, -0.01778316f, -0.06165690f, 0.00056921f, 
    -0.06965069f, 0.04974274f, 0.02468656f, -0.07400805f, -0.03126950f, 0.06594401f, -0.00175031f, 0.00243680f, 
    0.05417554f, -0.01563786f, 0.04775708f, 0.06386850f, -0.04965381f, 0.00705351f, 0.04089877f, -0.02140321f, 
    -0.03937196f, -0.04969046f, 0.08779902f, -0.04381163f, 0.04863764f, -0.06438240f, -0.08229674f, -0.03202066f, 
    -0.06172992f, -0.01944849f, 0.06476066f, -0.01270406f, -0.00598149f, 0.05221596f, -0.00548492f, -0.06441693f, 
    0.07327087f, 0.04900178f, 0.06159419f, -0.03830604f, -0.09699064f, -0.00001427f, -0.08056558f, 0.02840568f, 
    0.06652448f, -0.01716510f, -0.01212233f, -0.00573941f, 0.03038830f, -0.06910273f, -0.07737321f, -0.03683963f, 
    -0.06685781f, 0.06020727f, 0.18478748f, -0.17764395f, -0.14806302f, 0.03246579f, -0.05432596f, -0.16930667f, 
    0.30864543f, 0.00010148f, 0.03433774f, 0.06758703f, 0.10223895f, 0.15068188f, -0.05986369f, 0.49688968f, 
    -0.02314020f, -0.08180559f, 0.17500167f, 0.34215340f, 0.21850155f, 0.22522733f, -0.01488187f, 0.08010961f, 
    0.03022794f, 0.03672073f, -0.02905196f, 0.31486470f, -0.09961464f, 0.04766659f, 0.01038249f, -0.07667171f, 
    -0.17553920f, -0.06607392f, -0.10680091f, -0.08478723f, 0.05846268f, 0.12901811f, -0.00655005f, 0.10192878f, 
    0.02199008f, -0.05433394f, 0.04615915f, 0.04846904f, 0.21966550f, 0.08496413f, -0.03550618f, 0.00872697f, 
    -0.34802857f, 0.07161186f, -0.08892649f, -0.08979613f, 0.01699080f, 0.07590091f, -0.25024745f, -0.01570598f, 
    -0.07091554f, 0.20045650f, 0.01301106f, -0.00682312f, 0.18386753f, -0.04990919f, -0.13708785f, -0.09156263f, 
    0.09505231f, 0.01106559f, -0.08814835f, 0.12714532f, -0.10519845f, -0.08508098f, 0.19847097f, -0.05828574f, 
    -0.00218975f, -0.31199583f, 0.06623090f, -0.13790797f, -0.16539603f, 0.11292788f, 0.06657268f, -0.54086310f, 
    0.48409474f, -0.30683866f, -0.14217728f, -0.09782156f, 0.07378091f, 0.10319704f, 0.03884966f, -0.11298602f, 
    0.22831495f, 0.27415061f, 0.04013620f, 0.02274579f, 0.12417303f, -0.11544380f, 0.08157020f, 0.04414466f, 
    -0.07026702f, 0.04728195f, -0.24657667f, 0.01890484f, 0.12442750f, 0.14607731f, -0.00117307f, -0.06777775f, 
    -0.01660385f, 0.14041252f, -0.08820166f, -0.15212885f, 0.04454073f, 0.12987092f, -0.01810414f, -0.03422148f, 
    0.03044840f, 0.08603393f, -0.04543983f, 0.05884593f, 0.17455523f, 0.27322519f, 0.00537278f, 0.05351344f, 
    0.28363612f, -0.06843996f, 0.14036174f, 0.04496742f, -0.01049789f, -0.27291313f, 0.03243717f, -0.08076826f, 
    -0.01333456f, -0.02390441f, -0.05881274f, -0.05946842f, 0.05235165f, -0.00075755f, -0.04302978f, -0.08519354f, 
    -0.02584791f, -0.01413872f, -0.01335951f, 0.01455589f, -0.03298171f, -0.02788380f, 0.01561126f, 0.01165476f, 
    -0.02115217f, -0.09832755f, 0.06670745f, -0.08134296f, -0.06281005f, -0.00676425f, -0.09144327f, -0.08226860f, 
    -0.04216431f, 0.05147164f, -0.00516512f, -0.07504091f, -0.08442044f, -0.07152235f, -0.08657900f, -0.04944365f, 
    0.07385826f, 0.06045474f, -0.04797648f, 0.05114105f, -0.04582233f, -0.06331154f, 0.05887838f, -0.07327668f, 
    -0.05711783f, -0.00935243f, -0.03435829f, -0.03966100f, 0.00124190f, -0.01603459f, 0.01978362f, -0.10999805f, 
    -0.00913438f, -0.07658084f, 0.01683304f, -0.01167108f, -0.00593018f, -0.07452187f, -0.05343982f, -0.11296734f, 
    -0.06383297f, -0.01089989f, 0.06890751f, 0.00196581f, 0.07348656f, -0.03508420f, -0.08331266f, 0.04824396f, 
    -0.10714036f, 0.01761541f, -0.06740556f, 0.02620242f, -0.06198401f, 0.05752990f, -0.08832541f, 0.00368251f, 
    -0.08347981f, -0.00882521f, -0.02478648f, -0.06476189f, -0.08940106f, -0.00006795f, 0.04532139f, 0.04382703f, 
    0.05947778f, -0.01856842f, 0.00666088f, -0.08027553f, 0.03688353f, 0.05044342f, 0.01681992f, -0.02875134f, 
    0.02912915f, -0.07900730f, 0.06369153f, 0.02010632f, -0.03028670f, -0.08422727f, -0.06099463f, -0.03133775f, 
    -0.06217321f, 0.05637241f, -0.08776832f, -0.05146175f, -0.03078413f, 0.04771287f, -0.02562263f, 0.05627108f, 
    0.05963074f, -0.08519346f, 0.06973080f, 0.01610326f, 0.00596327f, -0.05787911f, -0.05464492f, -0.01374730f, 
    0.08286891f, -0.00973889f, -0.07614207f, -0.03078094f, 0.04602542f, 0.01669254f, 0.05179338f, -0.05400249f, 
    -0.00795244f, -0.03685443f, -0.08594778f, -0.02783837f, -0.03466965f, -0.05821301f, 0.03792195f, -0.08482762f, 
    -0.08823688f, 0.03804715f, -0.02704946f, -0.11756098f, -0.11443739f, 0.32275665f, -0.18638030f, -0.02587228f, 
    0.06394288f, 0.05424395f, -0.07512786f, 0.06727792f, -0.07518933f, 0.36363241f, 0.06447946f, -0.25837600f, 
    0.06486367f, -0.10282636f, 0.00052618f, -0.02037788f, 0.23716310f, 0.17719860f, 0.15889242f, -0.07763574f, 
    0.01670771f, 0.03843587f, -0.14623979f, -0.38151544f, 0.15211385f, -0.35987511f, 0.00430625f, -0.07729758f, 
    -0.29549843f, 0.07484129f, 0.25167105f, -0.00572565f, 0.30869782f, -0.30320588f, 0.11297372f, 0.02224551f, 
    0.16952495f, -0.01897236f, -0.01731437f, 0.08083867f, 0.10672768f, -0.09936331f, 0.24269469f, 0.17566000f, 
    0.21155231f, 0.22093599f, 0.15998885f, -0.04478381f, 0.36818692f, 0.17444605f, 0.06288337f, -0.28880197f, 
    0.06624697f, -0.26774359f, 0.18542017f, 0.17893772f, 0.01276098f, -0.08298588f, 0.16403122f, 0.27934659f, 
    0.19949730f, 0.24321669f, 0.00926767f, 0.14535797f, 0.06882029f, -0.03840154f, 0.12977883f, 0.21323328f, 
    0.01316907f, 0.29397681f, -0.03758406f, -0.07139736f, -0.27640706f, -0.00358971f, 0.07908168f, 0.04887464f, 
    -0.05696381f, 0.06982866f, -0.30830318f, -0.17409725f, 0.17027429f, 0.02706022f, 0.14421886f, -0.09331313f, 
    0.22959229f, 0.00479143f, -0.31556728f, -0.32580492f, 0.06585938f, 0.11021268f, 0.02879134f, -0.07156531f, 
    0.10533976f, 0.10709927f, 0.07329330f, -0.03904434f, 0.12873518f, 0.11958214f, -0.08366086f, -0.08443208f, 
    -0.06684397f, 0.12208137f, -0.01543253f, 0.13432679f, -0.17718059f, 0.07115982f, 0.07159533f, -0.03649022f, 
    0.00565458f, 0.41615123f, 0.16002600f, -0.01610677f, 0.10443573f, 0.20174445f, 0.20011860f, 0.14882389f, 
    0.05160323f, -0.00792877f, 0.06842915f, 0.00850290f, 0.00342501f, 0.02314785f, -0.13847557f, 0.10865907f, 
    0.27766287f, -0.00222142f, 0.07524443f, 0.07600695f, 0.25940630f, -0.04929338f, -0.20736618f, 0.31156802f, 
    0.22594583f, -0.02823841f, 0.13233750f, -0.46421772f, -0.24839090f, -0.28856152f, -0.05596181f, 0.00733834f, 
    -0.29738185f, 0.03675824f, 0.15105216f, -0.08270466f, -0.31540167f, -0.02781693f, -0.22140487f, 0.17282809f, 
    0.16914314f, -0.07170391f, -0.00754928f, 0.25437033f, 0.30848882f, 0.22671936f, -0.00601008f, 0.05347430f, 
    0.17450520f, 0.35165673f, 0.23020439f, -0.01769328f, -0.09179932f, -0.19566599f, 0.02276830f, 0.13032800f, 
    0.00742509f, -0.02604233f, 0.00458973f, 0.19889428f, 0.10688332f, 0.06609208f, 0.02873464f, 0.08122248f, 
    -0.41719195f, 0.04566315f, 0.20446895f, 0.09208377f, 0.06553599f, -0.17276774f, 0.14251962f, 0.08298123f, 
    -0.02748566f, -0.16102569f, 0.06949320f, -0.12842004f, -0.04462294f, -0.11998843f, 0.12728170f, 0.48821992f, 
    -0.10442051f, 0.15003544f, 0.14527380f, -0.08863166f, 0.18208230f, -0.00213315f, 0.26118276f, 0.06596010f, 
    0.03718738f, 0.01606053f, -0.17475140f, 0.23500139f, 0.14687581f, -0.23180589f, 0.08442986f, 0.29507136f, 
    0.21550672f, 0.21626104f, -0.35672444f, 0.02052516f, -0.08495606f, 0.01463437f, 0.09472767f, 0.01908239f, 
    -0.29875678f, -0.04405170f, 0.16793686f, 0.05334708f, 0.20164953f, 0.00287974f, -0.07795735f, -0.02199835f, 
    -0.14440514f, -0.07039917f, 0.11126639f, 0.07075950f, 0.16973400f, -0.11930346f, 0.03710901f, 0.03357593f, 
    -0.36108464f, -0.08677393f, 0.21020688f, 0.11809231f, 0.02854018f, -0.08739146f, 0.08299091f, 0.25909334f, 
    -0.09833626f, 0.05967930f, 0.19402997f, -0.10764518f, -0.09236183f, -0.12033971f, 0.10767622f, -0.00723897f, 
    -0.10453354f, -0.37506711f, 0.18314908f, 0.11830021f, 0.04556616f, 0.60680145f, 0.46068209f, 0.65861726f, 
    -0.15229811f, 0.05609415f, 0.05506004f, 0.17946747f, -0.10816718f, -0.02192887f, 0.07566287f, 0.19111812f, 
    0.00775464f, -0.10213422f, -0.06767225f, -0.25592712f, -0.01231288f, 0.02148137f, -0.05924598f, -0.04537719f, 
    -0.26106003f, -0.05306951f, -0.35111111f, -0.32132950f, 0.01804422f, 0.03715205f, 0.05697192f, 0.11569309f, 
    -0.16038099f, 0.07122332f, 0.15824255f, 0.17484181f, -0.09773581f, -0.00781493f, -0.05883902f, -0.31460989f, 
    -0.20119695f, 0.25196734f, -0.01318984f, 0.05686005f, -0.28535104f, 0.21838470f, 0.24392898f, -0.06689100f, 
    -0.20507546f, 0.04340314f, 0.22902675f, 0.18355133f, 0.16121492f, 0.05971392f, 0.11889578f, 0.06455617f, 
    -0.29362616f, 0.05686805f, 0.07204709f, -0.12627368f, -0.45467037f, -0.07497413f, 0.07118078f, 0.18931071f, 
    -0.05157265f, 0.04668332f, 0.08511139f, -0.32400683f, -0.12509790f, 0.04278239f, 0.02183041f, 0.11146296f, 
    -0.45957175f, 0.05511063f, 0.01096613f, 0.15839724f, -0.09656587f, 0.03650177f, -0.10768501f, -0.13122192f, 
    -0.02370484f, -0.21300909f, -0.24945602f, -0.03611959f, -0.25774604f, -0.09857701f, 0.02668808f, -0.33204827f, 
    -0.09433289f, -0.22654006f, 0.18885665f, -0.33926001f, -0.03380951f, -0.06084711f, -0.30003387f, 0.02635709f, 
    -0.00537719f, -0.11035490f, 0.16860467f, -0.01803892f, -0.32798535f, 0.07079058f, -0.01081675f, -0.08832992f, 
    0.08309538f, 0.13870127f, 0.02309544f, 0.05273808f, 0.07124750f, -0.40226442f, 0.01116924f, -0.28943831f, 
    -0.07072603f, -0.14770621f, -0.22535102f, -0.23652187f, -0.00616380f, -0.13612817f, -0.01898286f, 0.03293681f, 
    -0.00164720f, 0.02129067f, -0.21384460f, 0.05566206f, 0.03092593f, -0.04915579f, -0.00051018f, -0.18411586f, 
    -0.23369150f, 0.12964663f, 0.07746293f, -0.00136108f, -0.05017744f, -0.43872091f, 0.08749115f, 0.07585627f, 
    -0.29986018f, 0.14713095f, -0.03965681f, -0.39333612f, -0.02579771f, 0.06317561f, -0.08791009f, 0.03666991f, 
    0.24483913f, -0.12286782f, -0.09584674f, 0.15490398f, -0.03102622f, 0.00637145f, -0.07414560f, -0.04550155f, 
    0.09225472f, 0.11512213f, -0.11857159f, 0.18116443f, 0.01813246f, 0.22024004f, 0.01755652f, -0.26328033f, 
    0.08820169f, -0.13305388f, 0.00264483f, -0.20457497f, -0.13788919f, -0.06727642f, -0.09362166f, -0.23674145f, 
    -0.08472410f, -0.02011450f, 0.06563100f, 0.24270779f, -0.23850094f, 0.08487898f, 0.08441868f, 0.11153740f, 
    0.08661629f, 0.03972417f, -0.26479107f, 0.16211419f, 0.52735764f, 0.04777864f, 0.21279037f, 0.08723146f, 
    -0.47818336f, -0.00477920f, -0.14611119f, -0.10985772f, 0.30621243f, 0.25944337f, -0.33691081f, 0.03581877f, 
    -0.33322152f, -0.29296651f, 0.07042439f, -0.05795749f, 0.08713428f, 0.19071624f, 0.00604951f, 0.06835122f, 
    0.06311566f, -0.19091268f, 0.02990565f, 0.05872841f, 0.21036887f, -0.04003328f, 0.13258599f, 0.20372134f, 
    -0.03483392f, 0.08376798f, -0.06781490f, -0.27331778f, 0.03959542f, 0.09441209f, 0.14099924f, 0.12602583f, 
    -0.01172150f, 0.33685052f, -0.31329513f, 0.13620390f, -0.01979770f, -0.01370879f, -0.34383139f, -0.16472922f, 
    -0.06062213f, 0.19840659f, -0.07138959f, 0.33122107f, 0.03590446f, -0.05235928f, 0.05861774f, -0.08126980f, 
    -0.07637396f, -0.07954851f, -0.28463900f, -0.10302822f, 0.13674606f, -0.16616248f, -0.06916653f, 0.05856643f, 
    -0.16909151f, 0.08683614f, 0.32492191f, -0.08660679f, -0.23263396f, -0.08834095f, -0.27206308f, 0.21720080f, 
    -0.09288343f, 0.23511872f, -0.21653353f, 0.07634505f, 0.11619104f, 0.23870397f, -0.02848332f, 0.00345974f, 
    0.03710648f, 0.01266973f, 0.06786163f, 0.18505099f, -0.08508405f, 0.29966867f, 0.40843502f, 0.45041379f, 
    -0.18180956f, -0.28219625f, 0.00126545f, -0.02088693f, -0.21769883f, -0.25081438f, 0.22435483f, 0.07641353f, 
    0.16069794f, 0.10100494f, 0.27038422f, -0.10893414f, 0.11704206f, 0.11458261f, 0.00013998f, -0.11412191f, 
    -0.22307004f, -0.05763275f, -0.26630592f, 0.20219274f, -0.03811143f, 0.10108995f, -0.41326010f, -0.22207680f, 
    0.00921177f, -0.13382113f, -0.46319482f, -0.03677870f, -0.08107060f, -0.04590306f, 0.01447429f, -0.12978895f, 
    -0.01768290f, -0.27158487f, -0.09681989f, -0.48219654f, 0.18818282f, -0.57181978f, -0.48342639f, 0.09210285f, 
    0.02943313f, -0.07651048f, 0.13250686f, -0.20527790f, -0.70722854f, -0.03760516f, -0.26803508f, -0.32869074f, 
    -0.02151923f, -0.00118075f, 0.03120169f, 0.47220612f, -0.13696329f, 0.21808790f, 0.12918386f, 0.03624741f, 
    0.02810842f, -0.00545952f, -0.07519056f, -0.07564590f, 0.04430247f, -0.07509921f, -0.12920694f, -0.05429459f, 
    0.17019306f, -0.09754842f, -0.15377624f, -0.13728179f, -0.05393865f, 0.05329194f, -0.19546741f, -0.19545680f, 
    0.07020626f, 0.03583752f, 0.14990300f, -0.38500240f, -0.07463265f, 0.14770728f, -0.08227873f, -0.09948976f, 
    -0.33835444f, -0.00422490f, -0.03145020f, 0.11372547f, -0.10535478f, -0.00389776f, 0.04667845f, 0.12920167f, 
    0.31185699f, -0.02243652f, 0.20017971f, -0.24322872f, 0.21949017f, -0.07515818f, 0.02089298f, 0.04268254f, 
    -0.07255797f, -0.30417630f, 0.12378013f, 0.10343102f, 0.08632716f, 0.18966007f, -0.02956521f, 0.27600390f, 
    -0.11379496f, 0.08715225f, 0.01410375f, -0.00324755f, 0.23023720f, 0.21057992f, -0.17783119f, -0.22707260f, 
    0.06024723f, -0.16060638f, -0.14933206f, -0.07497563f, 0.07367864f, -0.08495278f, 0.13174304f, 0.10211617f, 
    0.26957029f, -0.02952088f, 0.07673884f, -0.00165839f, 0.07981452f, -0.13087904f, -0.07487424f, -0.25615117f, 
    -0.03232876f, -0.04091045f, 0.07380669f, 0.02826415f, 0.02473764f, -0.07245539f, -0.03663630f, -0.10015953f, 
    0.05843306f, 0.02512302f, -0.09792727f, -0.01842972f, -0.08933820f, -0.01783562f, 0.04839839f, 0.04940720f, 
    0.00164959f, 0.02690350f, -0.06379651f, 0.05206994f, -0.02072284f, -0.11129224f, 0.04926000f, -0.08315728f, 
    -0.02185745f, -0.07533831f, 0.01295572f, 0.03657858f, -0.01980266f, 0.01678446f, -0.04728771f, 0.05153533f, 
    0.02123000f, -0.05908267f, 0.03766710f, -0.02304360f, 0.05788688f, -0.07127441f, -0.07306790f, -0.05469503f, 
    -0.03412408f, -0.01008142f, -0.04447633f, 0.03249889f, 0.07909188f, -0.00987220f, 0.01405979f, -0.02278705f, 
    0.07218533f, 0.05484382f, -0.03862095f, 0.01492856f, 0.02791549f, 0.08797024f, -0.11084080f, 0.03597153f, 
    0.05248073f, -0.07735566f, -0.01645359f, -0.01273335f, -0.06237379f, -0.07764462f, -0.07357759f, -0.08659460f, 
    0.08420293f, -0.09756345f, -0.07772780f, -0.06378084f, -0.06245542f, 0.00279200f, 0.06581897f, -0.03913611f, 
    0.01765203f, -0.01107724f, -0.07008128f, -0.11139340f, -0.05217522f, -0.05355545f, 0.04031761f, -0.06515878f, 
    0.01754522f, 0.02511432f, 0.07043152f, -0.10945141f, -0.04044678f, -0.00063507f, -0.05054278f, -0.06383806f, 
    -0.08008262f, 0.05680072f, 0.04538039f, 0.07261791f, -0.08707967f, -0.03421011f, -0.01165799f, -0.00003276f, 
    -0.08177517f, -0.00557521f, -0.04978721f, -0.05738646f, -0.07711666f, -0.07871538f, -0.00962807f, -0.00039207f, 
    -0.01636170f, -0.09426939f, -0.08187712f, 0.00513042f, -0.07001170f, -0.05826885f, -0.10923485f, 0.04879421f, 
    -0.08414223f, -0.01674833f, 0.05142870f, -0.07114173f, 0.05752681f, -0.07309617f, 0.02321481f, 0.00316014f, 
    -0.06643374f, 0.00103384f, 0.02326217f, -0.04876729f, -0.01864885f, -0.06841117f, 0.05905058f, 0.07104453f, 
    0.44564596f, -0.18715553f, 0.45206723f, 0.11489701f, 0.08847976f, 0.03844141f, 0.06991872f, -0.05923308f, 
    -0.15474196f, 0.16737978f, 0.16753875f, 0.14437173f, 0.41333967f, 0.25292763f, -0.03783352f, 0.17034730f, 
    0.01584028f, -0.15310656f, 0.10834080f, 0.24303606f, 0.14838240f, 0.00271551f, 0.34275508f, 0.09215637f, 
    -0.07186198f, 0.04841956f, 0.07659096f, -0.03316092f, 0.07357698f, 0.15016396f, 0.05698344f, 0.13159437f, 
    -0.15915760f, -0.58024919f, 0.05273391f, -0.22114326f, 0.22279993f, -0.13310632f, -0.14811175f, 0.06181319f, 
    0.01245293f, 0.07636716f, -0.11280459f, -0.04516120f, -0.44959882f, 0.07286860f, -0.04046791f, 0.04118310f, 
    -0.00722402f, -0.09879991f, 0.01500908f, 0.29199398f, 0.03047073f, 0.03565647f, -0.01835743f, -0.09256694f, 
    0.23009464f, 0.27407014f, -0.03794831f, 0.10570719f, 0.30627614f, 0.12234597f, -0.08222958f, -0.00702708f, 
    0.11964116f, -0.03499531f, -0.08092900f, -0.08669897f, -0.04231451f, -0.03611198f, -0.19449577f, -0.11362945f, 
    0.05132397f, -0.04523035f, 0.19805923f, 0.03001025f, 0.28340828f, 0.03757574f, -0.13577658f, -0.30792090f, 
    0.16754875f, -0.21524493f, -0.06687992f, 0.14996773f, 0.11435550f, 0.02453120f, 0.34733686f, 0.06657828f, 
    0.19312462f, 0.22764568f, 0.04589671f, -0.28875902f, 0.03016303f, 0.21221802f, 0.02169087f, -0.03597866f, 
    0.09618273f, 0.03728106f, 0.19993477f, 0.06117900f, -0.00729683f, 0.15811573f, -0.04964573f, 0.14055970f, 
    0.22957794f, -0.03143903f, -0.18443994f, -0.08675943f, 0.04898117f, 0.23730719f, -0.00807544f, -0.10233495f, 
    0.03620860f, -0.02438805f, 0.15186839f, -0.02629420f, 0.19552873f, -0.01154836f, -0.02440191f, 0.12890297f, 
    0.10502350f, 0.18031093f, -0.07225119f, 0.04036055f, 0.15732092f, -0.43897897f, -0.06658834f, -0.44267660f, 
    0.50269449f, -0.51266426f, -0.04153986f, 0.34642211f, 0.22104813f, -0.27860487f, 0.02064266f, 0.15464410f, 
    0.23093016f, 0.03675646f, 0.15815757f, 0.16105653f, 0.11558007f, -0.08777105f, -0.04396849f, 0.35627216f, 
    0.01002839f, -0.03751687f, 0.23538268f, 0.30697426f, 0.04175791f, -0.25300246f, 0.14131956f, 0.12253778f, 
    -0.30919373f, -0.02389381f, -0.00576109f, -0.35654563f, 0.09277692f, 0.87066120f, 0.08560631f, 0.27196950f, 
    0.38941804f, -0.46903917f, -0.10251728f, -0.08532307f, 0.02207125f, -0.10005966f, -0.10494906f, 0.08656479f, 
    -0.27069035f, 0.05759480f, -0.44675666f, -0.23592028f, 0.14486162f, -0.02799032f, -0.43045405f, -0.21070257f, 
    0.06179792f, -0.53064322f, -0.02599617f, 0.12007021f, -0.31432551f, 0.08926432f, -0.00336395f, 0.34970418f, 
    -0.03465014f, 0.59715259f, -0.52239877f, 0.09403382f, 0.13665861f, 0.08877265f, -0.20165211f, -0.11785737f, 
    -0.18265192f, -0.25495893f, 0.03824557f, -0.40987688f, -0.34124467f, -0.08088616f, 0.10104125f, -0.33563444f, 
    -0.04459662f, -0.23768915f, 0.04021622f, 0.14726077f, 0.12601368f, 0.21116972f, -0.39115825f, -0.35928354f, 
    0.52542400f, -0.34048045f, 0.62025779f, 0.08407536f, -0.19805606f, -0.00122815f, 0.39635783f, 0.07282045f, 
    0.15970993f, 0.04524991f, 0.20377173f, 0.08405147f, 0.15502575f, 0.01188568f, -0.04052227f, 0.07784433f, 
    0.04253696f, -0.01390309f, 0.11850350f, 0.10912535f, 0.14403985f, 0.03018650f, 0.05485673f, 0.09614880f, 
    0.25195071f, -0.14110990f, 0.13924704f, 0.21537195f, 0.26572445f, 0.08580609f, -0.10977926f, -0.58921415f, 
    -0.05017185f, -0.31020173f, 0.22396260f, 0.02486177f, 0.17238379f, -0.12057252f, -0.21314730f, -0.11904220f, 
    -0.10969370f, 0.20739222f, -0.14766400f, -0.41082749f, -0.15526117f, 0.47165808f, -0.06926072f, 0.09485156f, 
    -0.39080161f, 0.08140940f, -0.23103178f, -0.07906052f, 0.04392125f, -0.10669418f, 0.49715778f, 0.04394789f, 
    0.14008254f, -0.05695272f, -0.10865060f, 0.15315962f, -0.29609230f, 0.03573390f, -0.04592735f, -0.28929490f, 
    0.03732318f, 0.05875877f, 0.25398239f, 0.22270721f, 0.25240722f, 0.17918186f, 0.00176361f, -0.02538012f, 
    -0.13778961f, 0.16395041f, -0.00335022f, 0.14132304f, -0.00682089f, -0.11696245f, -0.01365136f, 0.34633601f, 
    -0.10879520f, 0.12519006f, -0.07214430f, 0.28187650f, -0.14689396f, 0.24484996f, 0.25663683f, 0.04736739f, 
    -0.04249066f, 0.01632372f, -0.07416675f, 0.00007077f, -0.09954980f, -0.04144735f, 0.14558254f, 0.08613408f, 
    -0.02216453f, 0.05430667f, 0.03734315f, -0.11630643f, -0.06835034f, 0.33963311f, -0.12984838f, 0.32603177f, 
    -0.40593511f, -0.32569209f, -0.06204603f, 0.15585686f, -0.20487013f, 0.09328164f, 0.08080404f, 0.08587075f, 
    -0.21705565f, -0.07444055f, 0.01623320f, 0.34259236f, 0.06916621f, 0.09970679f, 0.34382406f, 0.07407523f, 
    -0.05094539f, 0.34436405f, -0.02660014f, 0.04679220f, -0.02501638f, 0.16642159f, 0.08199169f, -0.01496908f, 
    -0.16628031f, -0.02931805f, -0.08150927f, 0.09693083f, 0.16683316f, 0.03666291f, 0.07314621f, -0.06722642f, 
    0.08278541f, 0.09143054f, 0.01346361f, 0.19016549f, 0.05175444f, -0.09608407f, -0.04391949f, 0.05452465f, 
    0.11981489f, 0.00249494f, -0.11426969f, -0.08608497f, 0.09217914f, -0.06506652f, -0.07743192f, 0.03747858f, 
    -0.03007312f, 0.04638128f, 0.02941948f, 0.00428143f, 0.03843575f, -0.12351620f, 0.11608484f, 0.06843823f, 
    -0.03604641f, 0.18501554f, 0.03399505f, 0.34995750f, 0.09454308f, 0.22596471f, 0.12010549f, -0.11707572f, 
    0.15218715f, 0.04797135f, -0.07592911f, 0.14232005f, -0.28376892f, 0.23460008f, -0.03919654f, 0.01871208f, 
    0.21205884f, 0.02595571f, 0.20785511f, 0.51059681f, 0.11165302f, -0.20446134f, 0.15322044f, 0.01732982f, 
    0.07623815f, 0.10500174f, 0.19793777f, -0.27326667f, 0.05795785f, -0.03402556f, 0.00657424f, -0.41577506f, 
    -0.31370708f, -0.22998038f, -0.03243644f, -0.07586011f, -0.18984486f, -0.22965193f, 0.20013672f, 0.31602982f, 
    -0.24608913f, 0.12291026f, -0.05751370f, -0.33574599f, 0.27888110f, -0.54211789f, -0.01313163f, -0.05443921f, 
    -0.08096742f, -0.09033931f, 0.21335426f, -0.39496607f, 0.31702015f, -0.39162129f, 0.01569542f, 0.03737631f, 
    -0.36673853f, 0.03490581f, 0.25445801f, 0.40895516f, 0.08379353f, 0.05422249f, 0.24829949f, 0.16832344f, 
    0.37991738f, 0.09294268f, -0.04050083f, 0.27940506f, -0.59883708f, -0.37358546f, 0.35118905f, -0.07559431f, 
    0.32980248f, -0.80132091f, -0.17688997f, -0.11983185f, -0.12644958f, -0.30558792f, 0.14768356f, 0.20175554f, 
    -0.09426054f, 0.24066657f, 0.22338660f, -0.01588508f, -0.01412515f, 0.00651762f, -0.37692064f, -0.49222070f, 
    0.04746746f, 0.30084792f, 0.06397720f, 0.00371990f, -0.20740308f, -0.27192524f, -0.16204037f, -0.15086295f, 
    -0.32182142f, -0.86200082f, 0.27414808f, 0.06830736f, 0.21976987f, -0.02934824f, 0.26842913f, 0.16864681f, 
    -0.08288331f, -0.24962971f, -0.62899768f, -0.07480329f, 0.07491720f, 0.08480749f, 0.03108347f, 0.03705357f, 
    0.10267658f, 0.05304499f, 0.36571032f, 0.13624416f, -0.00684792f, 0.07239898f, 0.00016809f, -0.14816479f, 
    0.19941503f, -0.33990368f, -0.30784649f, 0.06511594f, 0.11026316f, 0.01508811f, 0.25550988f, 0.02284254f, 
    -0.02522545f, 0.12059767f, 0.12916709f, -0.14524262f, -0.05650653f, -0.14904562f, 0.21121234f, 0.02691963f, 
    -0.24482599f, 0.04311277f, 0.05602052f, -0.14055596f, -0.28023675f, -0.11230851f, 0.08042856f, -0.43164781f, 
    -0.40033060f, -0.04693987f, 0.10970864f, -0.02677011f, -0.22381955f, 0.29661039f, -0.40319189f, 0.13496728f, 
    -0.16345367f, -0.00613520f, 0.21561736f, -0.00077201f, 0.00719418f, 0.32284072f, -0.06311740f, -0.11318170f, 
    0.02795543f, 0.07746512f, -0.06550016f, -0.15718102f, 0.22572787f, 0.14580616f, -0.05548114f, -0.43342674f, 
    0.07503203f, -0.10086382f, 0.04471984f, -0.08569718f, 0.07568762f, -0.45927814f, 0.11133717f, -0.13057312f, 
    -0.07168291f, 0.16159390f, 0.16176488f, 0.07787392f, 0.12494818f, 0.02200657f, 0.18701401f, 0.03952698f, 
    0.16045316f, -0.00133589f, 0.39123008f, 0.31770140f, -0.18974662f, 0.08626331f, 0.34533617f, 0.17993304f, 
    0.22002405f, 0.16149753f, 0.24683422f, -0.16160065f, 0.15944149f, 0.34749478f, 0.09935917f, 0.09582633f, 
    0.21551561f, -0.26647049f, 0.13011494f, -0.01376656f, -0.03462173f, 0.02280501f, 0.09967865f, 0.07815752f, 
    0.07417449f, 0.17153721f, 0.32254925f, 0.02348055f, 0.21730030f, -0.05900514f, -0.01578113f, 0.17889553f, 
    -0.05916220f, 0.19290742f, -0.06180717f, 0.01016857f, -0.20434912f, 0.05204033f, -0.02961724f, 0.28750384f, 
    -0.43197802f, 0.16260166f, 0.15562364f, -0.23723423f, 0.19170921f, 0.00152157f, -0.53611863f, 0.00754482f, 
    0.20337190f, -0.07376947f, -0.10196798f, -0.16934201f, -0.04454889f, 0.32012895f, -0.02401307f, -0.09400520f, 
    0.03905053f, 0.01645878f, 0.00199091f, -0.06496459f, 0.03299568f, 0.07935514f, -0.05764979f, 0.00975627f, 
    -0.02449900f, -0.08988395f, 0.05093855f, -0.07957923f, -0.16562285f, 0.01172392f, -0.02077257f, -0.28146449f, 
    0.03246441f, 0.42969829f, -0.18984063f, 0.10604464f, -0.13968386f, 0.13583551f, 0.20257743f, 0.20394611f, 
    -0.00548401f, 0.11694539f, 0.14622495f, 0.00227236f, -0.06868374f, -0.34852904f, -0.33538455f, 0.21909036f, 
    0.43021518f, 0.09205129f, 0.47724798f, 0.26419622f, 0.15065093f, 0.19915715f, -0.00719793f, 0.24092785f, 
    -0.32555819f, 0.09263358f, -0.16902633f, -0.04256700f, 0.47027346f, 0.23586133f, 0.04342865f, 0.36706388f, 
    0.27406693f, -0.31956041f, -0.05648854f, -0.13464430f, 0.21821673f, -0.13210507f, 0.52736014f, 0.01557362f, 
    -0.38676354f, 0.17168726f, 0.05299031f, -0.02669891f, -0.04751698f, 0.10963037f, 0.00442318f, 0.04543657f, 
    0.17651264f, 0.05181556f, -0.23139225f, 0.14309759f, 0.22938700f, -0.05657514f, -0.08268097f, -0.01444066f, 
    -0.05608881f, -0.04079565f, 0.01838784f, -0.00351262f, -0.05944343f, -0.01154178f, 0.15460704f, -0.11157198f, 
    0.27092823f, -0.15481219f, -0.35772741f, -0.20791596f, 0.50809801f, 0.08783140f, -0.09959852f, -0.18571232f, 
    0.38803977f, -0.03652875f, 0.07200986f, 0.35374442f, 0.10771338f, 0.22297198f, -0.07631020f, -0.54801333f, 
    -0.37566409f, 0.08121894f, 0.07044573f, -0.35416719f, -0.20462197f, 0.00298970f, -0.19413646f, 0.13515890f, 
    -0.07811721f, -0.07632544f, 0.12319615f, -0.05818468f, 0.22191569f, -0.17389348f, -0.00019576f, 0.08666919f, 
    0.40940034f, -0.09948240f, -0.32033822f, -0.21993501f, 0.14091477f, 0.08758695f, 0.25128752f, -0.09347556f, 
    0.02150422f, 0.03440793f, 0.36901292f, -0.41387349f, -0.05205832f, 0.12936170f, -0.10658214f, -0.00890909f, 
    0.24101782f, 0.18528196f, 0.44357064f, 0.07010872f, 0.10097264f, 0.00987186f, 0.05640756f, -0.00799364f, 
    0.34353793f, 0.02719719f, 0.03148593f, 0.08628532f, -0.13170169f, 0.10160856f, -0.16762356f, -0.51051825f, 
    0.05634508f, 0.15989746f, 0.06430422f, -0.12492908f, 0.15786467f, -0.05457619f, -0.14039427f, 0.19341449f, 
    -0.13567446f, 0.29772013f, -0.28202164f, -0.01431476f, -0.34750369f, -0.22902645f, -0.54675484f, 0.18576866f, 
    0.05353457f, 0.00495272f, -0.18781973f, -0.16660780f, -0.23390065f, -0.14685011f, -0.30395329f, -0.03160626f, 
    0.30118057f, 0.15358827f, 0.02182246f, 0.12760480f, 0.07114898f, 0.04963693f, 0.07673404f, 0.48608321f, 
    0.17876463f, 0.17018980f, 0.11962003f, 0.16277143f, 0.21811631f, 0.20836782f, -0.08342108f, 0.20404668f, 
    0.11467458f, -0.10918186f, -0.24520536f, 0.21874756f, -0.14051209f, 0.41823217f, 0.02572769f, 0.00843073f, 
    -0.02328550f, -0.18797630f, 0.05546374f, -0.08832575f, 0.16831578f, -0.72276062f, 0.14259939f, -0.10542745f, 
    0.07687021f, 0.05676899f, 0.22110902f, -0.21890841f, -0.24039900f, -0.05648512f, -0.38955978f, -0.08827274f, 
    -0.38640910f, 0.02940337f, 0.07398282f, 0.14936878f, -0.13450338f, 0.24414495f, -0.35229620f, -0.19528276f, 
    0.03398359f, 0.25216395f, 0.09559105f, 0.16679841f, 0.02867084f, -0.11234884f, -0.10824773f, -0.00395688f, 
    0.09123670f, -0.13100794f, 0.00178938f, 0.18544050f, -0.11116072f, 0.06066293f, 0.27120081f, -0.04046053f, 
    -0.00234263f, -0.28983173f, 0.22748607f, 0.06475542f, -0.29450351f, 0.27672565f, -0.26750892f, -0.33274099f, 
    0.41468415f, -0.24298117f, 0.02365429f, -0.00984436f, -0.03597076f, 0.08553572f, 0.15469387f, 0.02784204f, 
    0.28336164f, 0.12329177f, 0.37683904f, -0.07415895f, -0.10074977f, -0.05119425f, -0.03673280f, 0.04916814f, 
    0.17587851f, 0.09311987f, -0.08862045f, -0.23263748f, 0.04683447f, 0.26345110f, 0.04540637f, -0.23847282f, 
    0.23206566f, 0.08940242f, -0.25923002f, -0.28571469f, 0.01031649f, 0.17805518f, -0.14028074f, -0.02968392f, 
    0.06755579f, -0.13817148f, -0.19326839f, 0.23459300f, 0.08353555f, 0.21345420f, -0.07506393f, -0.17214300f, 
    0.06769726f, 0.23942529f, 0.11864819f, -0.09176698f, 0.13671151f, -0.30214047f, -0.32249951f, -0.04148211f, 
    0.21277528f, -0.02193627f, 0.42708051f, 0.25518525f, 0.07360455f, -0.06428209f, 0.02176451f, 0.20931768f, 
    0.17257483f, 0.03941140f, 0.26003140f, -0.10246903f, 0.04415067f, -0.06427001f, -0.00181881f, 0.14515382f, 
    -0.25730881f, 0.16926132f, 0.13019955f, 0.29607919f, -0.15187560f, -0.09205589f, 0.03636643f, 0.31831363f, 
    0.19457412f, -0.15664199f, -0.10347062f, 0.16229823f, 0.19257262f, 0.22592549f, -0.00797626f, -0.13681990f, 
    0.18168481f, -0.19355956f, 0.12397320f, -0.23379008f, 0.15445799f, -0.30535322f, -0.28355154f, 0.10597754f, 
    0.14162581f, 0.06219649f, 0.28126591f, 0.35427842f, 0.01560886f, 0.08355847f, -0.17194095f, -0.00139118f, 
    -0.33457455f, -0.01546601f, 0.10954318f, 0.12885587f, -0.75120276f, 0.07143117f, 0.16203377f, 0.10132757f, 
    0.08415834f, 0.27177542f, -0.03520568f, -0.07846237f, 0.17501205f, -0.08752920f, 0.01540478f, 0.34446079f, 
    0.20680684f, -0.07421975f, 0.18083386f, -0.23181139f, 0.10560220f, -0.03417826f, 0.30360368f, -0.09998620f, 
    0.03325223f, -0.57206666f, 0.10696016f, 0.12597147f, -0.03618043f, 0.12264527f, 0.08342849f, -0.20974638f, 
    0.30635810f, -0.07277989f, -0.13065006f, -0.10095341f, -0.04441210f, -0.08158014f, 0.02226140f, 0.04154958f, 
    -0.01079055f, 0.16788290f, 0.32984653f, 0.02077574f, 0.11817976f, 0.05812674f, -0.01920970f, 0.02479365f, 
    -0.17619890f, -0.22870108f, -0.00499551f, 0.06188670f, -0.11828286f, 0.11693098f, 0.04467315f, 0.19985694f, 
    -0.02810806f, -0.18953840f, 0.05966903f, -0.07907949f, 0.07074570f, 0.10161262f, 0.14945765f, -0.07219166f, 
    0.01204498f, -0.05663788f, 0.06739223f, 0.13326748f, 0.10494005f, 0.06006093f, 0.17402285f, 0.16100726f, 
    0.09115566f, -0.04129002f, 0.20364307f, 0.02683607f, 0.20174789f, -0.02766489f, 0.13130157f, 0.23217854f, 
    -0.18916774f, 0.02811613f, 0.04127624f, -0.37802410f, 0.09834121f, -0.13292554f, -0.07066313f, -0.00105232f, 
    -0.01013426f, 0.14052846f, 0.08199525f, 0.03156449f, -0.02713728f, -0.09899854f, 0.07762167f, -0.30472025f, 
    -0.13919486f, 0.42110658f, 0.21808483f, 0.34706071f, 0.00156781f, 0.04627897f, -0.39754534f, 0.13216344f, 
    0.11528988f, -0.07009997f, 0.13226980f, 0.05113532f, -0.10885268f, 0.01623882f, 0.04770857f, 0.28395352f, 
    0.34471294f, 0.03625398f, 0.08414780f, -0.02281408f, -0.37474352f, 0.04442154f, -0.00562603f, 0.06730132f, 
    -0.02457424f, -0.12918356f, 0.12151428f, 0.01485773f, 0.15346366f, 0.05184089f, -0.19844876f, -0.10958659f, 
    -0.03326849f, -0.09876456f, 0.15411580f, -0.07863270f, -0.79208547f, 0.06562556f, 0.00981975f, 0.49589336f, 
    -0.41926739f, -0.12473736f, 0.08983174f, -0.22989757f, 0.02808601f, 0.25794438f, 0.09419630f, -0.09126098f, 
    -0.01569920f, -0.06329924f, 0.14167665f, -0.05574156f, 0.01724897f, -0.02345093f, 0.50937802f, 0.00156247f, 
    -0.05995585f, 0.04777459f, -0.08330492f, 0.15320887f, -0.02619767f, 0.27030769f, 0.02365565f, -0.32086539f, 
    -0.26643148f, -0.22083797f, 0.34858549f, 0.00597593f, -0.05588669f, 0.07227656f, -0.21093921f, -0.14024647f, 
    0.16222359f, -0.01566944f, -0.23664981f, -0.38301152f, 0.03026730f, 0.02216348f, -0.06124705f, 0.06149793f, 
    -0.13153137f, 0.04780985f, -0.18420006f, -0.08116084f, -0.22365659f, -0.01783815f, 0.00459991f, 0.39548737f, 
    -0.08495938f, -0.18456405f, 0.05874380f, -0.19928534f, 0.11198524f, -0.08658239f, -0.19293143f, -0.25009611f, 
    -0.00939764f, 0.01978276f, -0.03582656f, 0.43044931f, -0.11058825f, 0.09625770f, 0.14414704f, -0.20447022f, 
    0.21179540f, -0.22708908f, 0.14090137f, 0.04546152f, -0.07680967f, 0.02680306f, 0.15883243f, 0.03533227f, 
    0.16845030f, 0.02155610f, 0.32861277f, 0.12394962f, 0.23095077f, 0.07655802f, 0.09178580f, 0.08966762f, 
    -0.19396006f, 0.09001521f, 0.03413950f, 0.08504166f, -0.16238376f, -0.13208368f, -0.03962005f, 0.23218144f, 
    -0.17429352f, 0.11863419f, 0.33644140f, -0.00294332f, -0.03321434f, 0.08535851f, -0.19146766f, 0.57660723f, 
    0.03489532f, 0.15733241f, -0.04322248f, -0.73428637f, 0.05917671f, 0.44980031f, 0.08889111f, 0.43244570f, 
    0.27179667f, -0.26927459f, 0.11995462f, 0.10653430f, -0.16071823f, 0.08245775f, -0.11904388f, -0.00974990f, 
    -0.25604481f, 0.09699830f, -0.16876724f, -0.28795391f, -0.12730318f, -0.00139616f, -0.14988644f, 0.03105931f, 
    0.34835434f, -0.09124842f, 0.14074339f, -0.10483183f, -0.55305916f, 0.05484696f, 0.14821962f, 0.16287199f, 
    -0.25835547f, 0.20576683f, -0.14740729f, 0.19448523f, -0.14411758f, 0.02195842f, 0.13351318f, 0.16343294f, 
    -0.06329992f, 0.02162248f, 0.13411444f, 0.00664346f, 0.16959089f, -0.00353525f, 0.30281749f, -0.06787892f, 
    -0.04223114f, -0.31861874f, -0.00852453f, 0.27409303f, 0.08969007f, 0.14762993f, 0.06367148f, -0.32735467f, 
    0.31820419f, -0.53791368f, -0.03027024f, 0.24113920f, 0.10789839f, -0.02367223f, 0.34973183f, 0.02600240f, 
    -0.01073491f, -0.06436688f, -0.05706842f, -0.20161019f, 0.02707027f, -0.16819535f, -0.05994653f, -0.00189463f, 
    0.10708015f, -0.01214895f, -0.00854525f, 0.04651153f, -0.07060263f, -0.06660435f, -0.08117216f, 0.23319830f, 
    0.05834154f, -0.00170879f, -0.15503594f, 0.14026934f, 0.25313157f, -0.13016646f, 0.22052568f, 0.37914464f, 
    -0.00482436f, 0.04953082f, 0.37185451f, 0.13293843f, -0.35231972f, 0.05751148f, 0.10696101f, -0.28135380f, 
    -0.19390576f, -0.01517487f, 0.03318177f, 0.07216529f, 0.04299379f, 0.27969083f, 0.23526984f, 0.20132345f, 
    -0.09265957f, -0.08858673f, 0.04992778f, 0.05607766f, -0.04829074f, 0.01008495f, -0.02836138f, 0.01455877f, 
    -0.11036482f, 0.03482188f, -0.06982626f, 0.02048723f, -0.01041195f, -0.03753734f, -0.08724847f, -0.05157791f, 
    -0.06208971f, -0.05453319f, -0.00321274f, -0.02942798f, -0.05701567f, 0.02285993f, -0.11271765f, 0.01388522f, 
    -0.00819459f, -0.02058517f, -0.02175069f, -0.09924403f, -0.01145879f, 0.01195389f, -0.08538528f, -0.10925326f, 
    -0.06757991f, 0.07626199f, -0.06496792f, -0.02698360f, -0.03113272f, -0.08487241f, -0.06240147f, -0.09782373f, 
    -0.04217561f, 0.01513946f, -0.00756042f, -0.04779775f, -0.06737306f, -0.05938155f, 0.02131325f, -0.00473165f, 
    -0.02402808f, -0.05708096f, -0.08459122f, 0.03085288f, -0.07437944f, -0.03091164f, 0.02854941f, -0.08414569f, 
    0.04228956f, -0.07931298f, -0.00929084f, 0.00739084f, -0.05118572f, 0.02947297f, 0.06386279f, 0.02333037f, 
    0.04084454f, -0.01790551f, -0.00264588f, 0.02251199f, -0.04001673f, 0.07665909f, 0.02527818f, -0.11444636f, 
    0.01352912f, 0.05553712f, 0.02314801f, -0.02597577f, -0.05409658f, -0.05489134f, -0.10225444f, 0.03904607f, 
    -0.05159695f, -0.05604440f, -0.08662704f, -0.04986691f, -0.01121941f, 0.00047179f, -0.01327486f, -0.05179539f, 
    -0.10443116f, -0.04781991f, 0.04587899f, 0.06648926f, -0.02077393f, -0.08197460f, 0.01672379f, 0.08462225f, 
    0.03666157f, -0.00286287f, -0.02784151f, -0.01680040f, -0.04029522f, -0.02770335f, 0.08301798f, -0.07690664f, 
    -0.10806234f, -0.09345637f, -0.08590572f, 0.00483308f, 0.04976712f, 0.01300799f, -0.08269051f, -0.08405919f, 
    0.07101562f, 0.00166616f, 0.03195926f, -0.01938635f, -0.04442532f, -0.02766516f, -0.08286006f, -0.02249307f, 
    -0.12484992f, -0.12015288f, 0.02350227f, 0.02015029f, -0.05523943f, -0.07881913f, 0.03599359f, 0.04938313f, 
    0.19349527f, 0.14429279f, 0.16493061f, -0.00923041f, 0.31944945f, -0.08994827f, 0.11008914f, 0.00212486f, 
    -0.03973718f, 0.11466680f, 0.07352494f, -0.09137694f, 0.15273470f, -0.04803086f, -0.04361334f, -0.52650070f, 
    -0.07967585f, 0.21891992f, 0.06814717f, -0.11068598f, -0.19240065f, -0.07567017f, 0.19084015f, -0.13692571f, 
    0.07261948f, 0.15673217f, 0.16743693f, -0.21225999f, 0.27341682f, 0.08562066f, -0.03455620f, 0.02069006f, 
    0.02878598f, 0.61693817f, 0.00031587f, 0.12900476f, -0.15088797f, 0.00028348f, -0.07370891f, 0.03769473f, 
    -0.14294009f, -0.01585538f, -0.09221306f, 0.06863687f, 0.54244524f, -0.10616473f, 0.10756174f, 0.01050322f, 
    0.19914867f, -0.04086699f, 0.01048161f, 0.19479524f, -0.18273990f, -0.16133106f, 0.26309964f, 0.12526901f, 
    0.12486366f, -0.18703559f, 0.07268054f, -0.06013687f, -0.15229103f, 0.08669148f, 0.21614400f, 0.02732578f, 
    -0.30668509f, 0.19642122f, 0.03730554f, -0.01317113f, 0.04090996f, 0.03481402f, 0.01613710f, 0.05828210f, 
    0.05630646f, 0.09500591f, -0.02683234f, 0.12764716f, -0.12795451f, -0.27225801f, 0.28010374f, 0.13110800f, 
    -0.10019526f, -0.12632215f, 0.17632094f, -0.13113712f, 0.08109611f, 0.07807355f, 0.14257395f, 0.11729439f, 
    -0.18500227f, -0.16823854f, -0.56162691f, -0.27522925f, 0.23620802f, 0.09478109f, 0.02866397f, -0.01760096f, 
    0.00638071f, 0.24092634f, 0.01942066f, 0.07974877f, -0.17584802f, -0.02224114f, -0.05727880f, 0.14469831f, 
    0.05430560f, -0.00241506f, 0.14855185f, 0.24576689f, 0.11099879f, -0.05596279f, 0.14698602f, -0.25852636f, 
    0.03804893f, 0.07520058f, 0.21139756f, -0.06081148f, 0.02288101f, -0.19323228f, 0.16357870f, -0.04419255f, 
    -0.00081391f, -0.12385027f, 0.16231632f, 0.16000198f, -0.17262261f, 0.44662139f, 0.04783169f, -0.15905088f, 
    -0.03940896f, 0.02743119f, 0.05769998f, 0.04070081f, -0.09576613f, -0.02092667f, 0.03964320f, -0.05727455f, 
    -0.03942524f, -0.01771979f, -0.02773625f, -0.06585407f, 0.00906921f, 0.04346304f, -0.01425189f, -0.02477203f, 
    0.01548776f, -0.00034577f, -0.04572781f, -0.02541019f, -0.07194621f, 0.03785823f, -0.08032015f, 0.02398552f, 
    -0.04364605f, 0.00087344f, 0.04299552f, -0.03924582f, -0.09838212f, -0.10458187f, -0.08667183f, 0.04953771f, 
    0.00533977f, -0.05055325f, -0.10794877f, -0.08424210f, 0.01341591f, -0.10008505f, 0.05188997f, -0.04468998f, 
    0.03487308f, -0.01323353f, -0.04059197f, -0.00345896f, 0.04819232f, -0.04608348f, 0.00870100f, -0.12434396f, 
    -0.00566175f, 0.04262812f, -0.09227866f, -0.04165819f, 0.04644852f, -0.03534335f, -0.03583323f, 0.05985262f, 
    -0.04102225f, -0.04179835f, -0.04653465f, -0.00840043f, -0.07092606f, -0.02679077f, -0.03266425f, -0.04351539f, 
    -0.06052567f, -0.11291244f, -0.05068799f, -0.03443806f, -0.00245708f, 0.02786168f, -0.01965830f, -0.12659170f, 
    0.06327918f, -0.04122018f, -0.00819834f, -0.01250985f, -0.07560402f, 0.04168266f, 0.05176773f, -0.03164588f, 
    -0.04012232f, 0.02441730f, -0.06469366f, 0.03087569f, -0.08516130f, 0.08360890f, 0.01175220f, 0.05869590f, 
    -0.03247282f, 0.06949929f, 0.05522628f, -0.04344606f, -0.07792126f, -0.10432485f, -0.03807249f, 0.00266942f, 
    0.03271994f, -0.10159307f, 0.04220110f, -0.11588839f, -0.06925423f, -0.05282107f, 0.08806647f, -0.04931875f, 
    -0.00072508f, 0.03165882f, -0.01658040f, -0.06098090f, -0.03304696f, -0.01976274f, -0.00841783f, -0.07825777f, 
    0.06294790f, -0.04530799f, -0.11393208f, 0.00393918f, -0.02174377f, -0.10080013f, -0.09827704f, 0.02138987f, 
    -0.07531134f, -0.01802381f, -0.05621007f, -0.10840636f, -0.11305476f, -0.02776199f, 0.05399737f, 0.05108481f, 
    0.66804254f, -0.25157520f, -0.13208617f, 0.57042050f, 0.13820696f, -0.20906839f, 0.11260193f, 0.09681074f, 
    -0.02828001f, 0.11788478f, 0.17496692f, -0.19317429f, 0.19607289f, -0.15227999f, -0.01138763f, 0.28755087f, 
    -0.24226129f, 0.06369251f, -0.15766165f, 0.06982020f, -0.30946863f, -0.32544339f, 0.37183377f, 0.28832167f, 
    -0.01551431f, 0.10221820f, -0.08221828f, -0.38187817f, 0.26846734f, 0.51757175f, 0.02642150f, -0.32879144f, 
    -0.16329552f, 0.12455647f, 0.08879083f, -0.50210303f, 0.26497161f, -0.35821706f, -0.20551333f, 0.23924017f, 
    -0.23986657f, 0.07376769f, 0.36955088f, 0.25953481f, 0.32562095f, -0.00212299f, 0.06577255f, -0.01566782f, 
    0.13577795f, -0.24726366f, -0.12598060f, 0.36731526f, -0.09693531f, -0.22356758f, 0.45037359f, 0.01622700f, 
    0.23163871f, -0.23136921f, -0.24428850f, -0.18120314f, 0.20517866f, -0.04967343f, -0.03657435f, 0.32449526f, 
    -0.04609517f, 0.15105918f, 0.17972164f, -0.43654078f, -0.09484613f, -0.08689874f, 0.00991943f, -0.28926951f, 
    -0.08272836f, -0.34413934f, 0.11520252f, 0.01914657f, -0.14765035f, -0.17870292f, -0.15169722f, -0.47435227f, 
    0.48694140f, -0.22296919f, 0.22838470f, -0.02407856f, -0.01387951f, -0.02791586f, 0.52666843f, -0.02454630f, 
    -0.18289995f, 0.04113538f, -0.15307933f, -0.28384921f, 0.29154944f, 0.03565962f, 0.03675704f, -0.06656469f, 
    -0.09621850f, -0.21475755f, 0.30393407f, 0.14506155f, 0.09767591f, 0.07560279f, 0.03045326f, 0.21160798f, 
    0.26362646f, -0.42217058f, -0.64695126f, 0.09777703f, 0.10949909f, 0.15972567f, 0.17129758f, -0.23064592f, 
    0.01917252f, 0.01227004f, 0.31343725f, -0.22000875f, 0.10498985f, 0.08154673f, 0.16800590f, 0.11187725f, 
    -0.01698015f, -0.08065677f, 0.22061950f, -0.20635188f, -0.14217152f, -0.00515869f, 0.08809545f, -0.11696284f, 
    -0.25736633f, 0.05634646f, 0.27414173f, -0.13573557f, 0.00518925f, 0.06806077f, 0.17842160f, -0.06564085f, 
    -0.04206925f, -0.05127849f, 0.03637277f, 0.17379050f, -0.09530421f, -0.05025072f, 0.07439496f, -0.27624518f, 
    -0.04081256f, 0.14099279f, -0.05483205f, 0.07737824f, -0.15181749f, -0.11850508f, 0.01501474f, 0.09771482f, 
    0.05028804f, -0.00400811f, 0.29886860f, 0.20494202f, -0.25422409f, -0.12128235f, -0.07230914f, -0.04862624f, 
    0.00829056f, -0.20024142f, -0.30297285f, 0.22597285f, -0.23794433f, 0.32403028f, 0.18306148f, -0.00663959f, 
    0.00238633f, -0.00227946f, -0.14197123f, -0.06278374f, 0.17537990f, -0.02922814f, -0.14297608f, -0.11525397f, 
    0.22806735f, -0.19120710f, -0.34797654f, -0.18868978f, -0.01454737f, -0.30999330f, -0.47046393f, 0.01282881f, 
    -0.03069663f, 0.33237773f, -0.04400180f, -0.09048258f, 0.08966094f, 0.27145976f, -0.12833983f, -0.36271891f, 
    -0.06667566f, -0.22697592f, 0.12632358f, -0.14890528f, -0.16171303f, 0.00869804f, -0.14969538f, -0.06437601f, 
    0.05315675f, -0.16214810f, -0.04193595f, 0.15242243f, 0.42230567f, 0.07828850f, 0.07700546f, 0.07879826f, 
    -0.33234608f, 0.04661868f, 0.20464031f, 0.28208047f, -0.36419660f, 0.05394020f, -0.05865493f, 0.20014766f, 
    -0.18552481f, 0.31069225f, 0.44999498f, 0.30922371f, -0.35757530f, 0.07471541f, -0.06173052f, -0.06246542f, 
    0.04001743f, 0.04122747f, -0.18861553f, -0.07141141f, -0.21938211f, -0.41376376f, 0.06685496f, -0.06127781f, 
    -0.03209125f, 0.02834426f, 0.18947364f, -0.20855892f, 0.08025370f, -0.00209154f, -0.07159974f, 0.19125788f, 
    -0.02079528f, -0.27404055f, -0.11535214f, 0.09765168f, 0.17198882f, -0.25524402f, -0.21940215f, -0.00087047f, 
    0.11242838f, 0.25885540f, -0.21128437f, 0.04745252f, 0.18890832f, 0.13194428f, 0.31282696f, 0.30232310f, 
    -0.02408313f, -0.35630777f, -0.22631602f, 0.27084768f, 0.05493842f, 0.11549584f, 0.28520265f, -0.06845741f, 
    0.15761866f, 0.12124131f, -0.08599246f, 0.02766824f, 0.19409388f, 0.06630505f, -0.02447100f, 0.02769184f, 
    0.14490137f, 0.05177036f, 0.18298866f, -0.15828010f, 0.03994641f, -0.83406830f, -0.41598114f, 0.14607625f, 
    0.05064031f, -0.12946905f, -0.12742838f, 0.09947024f, -0.07664787f, -0.04697444f, -0.03610922f, 0.32462105f, 
    0.23689213f, 0.47114307f, -0.00644295f, -0.00376028f, 0.16226052f, 0.10234130f, 0.13329086f, -0.00311557f, 
    0.02643895f, -0.07619837f, -0.00442988f, -0.05684721f, -0.02055488f, 0.03932260f, 0.11031306f, -0.11670594f, 
    -0.20781972f, -0.51900417f, -0.02630806f, 0.27796391f, -0.05885383f, -0.03251097f, 0.15055647f, -0.17159367f, 
    0.11829679f, -0.13489179f, -0.19870931f, 0.24574582f, -0.04542245f, -0.37576973f, -0.00994409f, -0.03028250f, 
    0.41395977f, -0.30163530f, -0.39767826f, -0.28966236f, 0.02897753f, -0.04694413f, 0.07531749f, 0.09248937f, 
    0.00340679f, 0.65472507f, 0.20161267f, 0.02892808f, 0.33394393f, 0.09239859f, -0.07304160f, 0.21203782f, 
    -0.05480978f, 0.21209137f, -0.55315495f, 0.16254213f, -0.09718676f, 0.02104519f, 0.16068523f, -0.08779083f, 
    0.14424972f, -0.43557692f, -0.03237061f, -0.00863783f, 0.12039582f, 0.02984251f, 0.04127404f, -0.08468109f, 
    0.06429885f, 0.02104224f, 0.03460616f, -0.11365671f, 0.09117474f, 0.21714294f, -0.07182925f, 0.25376621f, 
    0.02809500f, 0.19729672f, 0.47616014f, 0.64744985f, -0.00493768f, 0.14193252f, -0.14334106f, -0.21519448f, 
    0.02126611f, -0.05626051f, -0.01177038f, -0.05353960f, -0.10047674f, -0.20545398f, -0.14341471f, 0.04922255f, 
    -0.17312910f, -0.05449076f, -0.09640215f, -0.20285840f, 0.03201525f, 0.49307010f, -0.32852459f, 0.33279997f, 
    0.33359519f, 0.06691937f, 0.05368285f, 0.03468632f, 0.13708682f, -0.06912102f, 0.17590740f, -0.31280738f, 
    0.08919594f, 0.24544056f, -0.00536267f, 0.10407868f, 0.31157210f, -0.00154831f, 0.08732935f, -0.16037734f, 
    0.03815588f, -0.11719446f, -0.21143053f, 0.04005849f, 0.07234591f, 0.00932549f, 0.43884462f, -0.28234348f, 
    -0.08744196f, 0.22379477f, 0.26286793f, -0.43842098f, -0.06434202f, 0.00101407f, -0.01426662f, -0.24114667f, 
    -0.35081902f, -0.01621733f, -0.14702217f, 0.15522443f, 0.00407334f, 0.13666096f, 0.16965853f, 0.01866063f, 
    -0.01611913f, -0.09567295f, -0.31121823f, -0.00468704f, 0.31398189f, 0.03021858f, -0.00859757f, -0.07307876f, 
    0.14069782f, -0.00360578f, -0.04563943f, 0.37903559f, -0.18856804f, -0.07218621f, -0.13917945f, 0.15091433f, 
    0.02745581f, -0.21306139f, 0.10800943f, -0.00999858f, 0.03970256f, 0.23204258f, 0.09694039f, -0.32482910f, 
    -0.05970815f, -0.05556440f, -0.15804760f, 0.16801921f, -0.21402547f, -0.09402724f, -0.30547431f, -0.00037189f, 
    0.06567741f, 0.00129237f, 0.12207039f, -0.33418560f, 0.19419593f, -0.17810765f, 0.09325258f, -0.36828205f, 
    0.01497802f, 0.02801670f, 0.23208722f, 0.31346780f, -0.00959990f, 0.01390681f, 0.46589381f, 0.08306488f, 
    0.06257360f, 0.13755067f, -0.20042752f, 0.13419637f, -0.06980164f, 0.11061604f, -0.05188285f, -0.01076595f, 
    0.02077650f, 0.20616695f, -0.13539524f, 0.10415175f, -0.15448114f, 0.04819826f, 0.01741966f, -0.05895091f, 
    0.04029333f, 0.19002511f, -0.11930536f, -0.12888651f, 0.29458189f, 0.22903007f, -0.05759535f, -0.02786678f, 
    0.06181985f, -0.09213585f, 0.07483496f, -0.07714683f, 0.37959573f, -0.04194869f, 0.08930147f, -0.10599733f, 
    -0.00653620f, -0.08925297f, -0.04266156f, 0.02496199f, 0.17537734f, -0.29356891f, -0.07481170f, -0.78924006f, 
    -0.14739965f, 0.10157937f, -0.34818411f, 0.00353655f, -0.08944119f, 0.02655408f, 0.03203836f, 0.09342943f, 
    0.17883672f, 0.10058301f, -0.19286263f, 0.19806650f, -0.04727529f, 0.24085322f, -0.03282273f, 0.27780056f, 
    0.28811574f, 0.01698328f, 0.01154165f, -0.01501131f, 0.39881057f, 0.23167829f, 0.17079173f, -0.20968297f, 
    -0.29968369f, 0.29805219f, 0.13725048f, 0.48265272f, -0.06702961f, -0.27833557f, 0.04383227f, -0.15077336f, 
    -0.17144364f, -0.15769900f, -0.11321579f, 0.39907393f, -0.03629342f, 0.21431828f, 0.35078397f, -0.10347770f, 
    0.06683529f, 0.03487122f, -0.19857322f, -0.00068748f, 0.13574430f, -0.08101378f, 0.40068868f, 0.16953418f, 
    -0.04860823f, 0.24205345f, 0.00785399f, -0.35489157f, 0.44319579f, 0.28879693f, -0.21693978f, 0.14721042f, 
    -0.07143937f, -0.39303648f, 0.13247126f, 0.26709652f, -0.20913889f, 0.06094410f, 0.00541591f, -0.06381760f, 
    -0.41806269f, 0.12974814f, 0.06565502f, 0.33662292f, 0.01054282f, -0.03445174f, -0.09937368f, 0.14045827f, 
    -0.04104009f, -0.22103386f, 0.10413655f, -0.12375890f, -0.42403367f, 0.12133468f, -0.02236938f, 0.18936612f, 
    -0.26719710f, 0.23904665f, 0.08953840f, -0.27336079f, 0.17436279f, 0.06066708f, 0.15878263f, -0.05314392f, 
    0.23403907f, 0.23598008f, -0.33344039f, 0.20579612f, -0.17130277f, 0.00614752f, -0.08570848f, -0.08896305f, 
    0.26121882f, 0.09976919f, -0.02794819f, -0.10094497f, 0.33354580f, 0.01314336f, 0.08373988f, -0.36312795f, 
    -0.01030778f, 0.23184763f, -0.28152534f, -0.18168363f, 0.01324837f, -0.24014153f, 0.01088571f, -0.01210801f, 
    -0.00334044f, 0.32217488f, -0.00883160f, 0.23596877f, 0.31430233f, 0.28020683f, 0.08369464f, -0.01717516f, 
    0.05358496f, 0.16700095f, -0.06736259f, -0.00512432f, -0.22865222f, -0.22078101f, -0.32622367f, -0.40041888f, 
    0.02606180f, 0.02761392f, -0.35390115f, 0.22167367f, 0.11216851f, -0.13460645f, 0.17380795f, 0.03764750f, 
    0.16905503f, -0.23049670f, -0.03382963f, 0.02069319f, -0.15442961f, -0.02527454f, 0.03070421f, -0.28286093f, 
    -0.21306542f, -0.09123053f, 0.06482743f, 0.05292378f, -0.10652952f, -0.43509421f, 0.05074867f, -0.00412008f, 
    -0.11770773f, 0.09370974f, -0.06388029f, 0.18075117f, 0.15980314f, 0.13489604f, 0.01073573f, -0.02204441f, 
    0.05599468f, 0.60772860f, -0.04988785f, -0.00795572f, 0.04656406f, 0.31734374f, 0.42432663f, -0.24534191f, 
    -0.08503720f, 0.06335714f, 0.47676763f, 0.19164927f, 0.02250314f, 0.04767411f, 0.06122017f, 0.04129790f, 
    0.10215780f, 0.01700643f, 0.03987536f, 0.05314799f, 0.14990209f, -0.10071192f, 0.14486034f, 0.02242737f, 
    0.23363496f, 0.29210907f, -0.10597167f, -0.13010626f, -0.01980846f, -0.25347435f, 0.11674871f, 0.14483453f, 
    -0.11598212f, 0.03363895f, 0.06163002f, -0.04127335f, -0.36631328f, 0.06588860f, -0.46332136f, -0.13357510f, 
    0.03495542f, 0.33999473f, -0.00982249f, -0.15777038f, -0.05483675f, -0.04026248f, 0.15074885f, -0.03961449f, 
    -0.00980663f, -0.05489996f, -0.30267084f, 0.02405090f, -0.03416779f, -0.02809764f, 0.31498837f, 0.03411319f, 
    -0.24869268f, -0.13780575f, 0.21973635f, -0.02475096f, 0.18880355f, -0.01341853f, 0.02263604f, -0.01072708f, 
    0.03068365f, -0.05214424f, -0.01418068f, 0.05771521f, -0.17598605f, -0.11560682f, 0.01430195f, -0.59535789f, 
    -0.00081309f, 0.06665364f, 0.20100394f, 0.03644941f, 0.10951663f, -0.00372113f, 0.09616726f, 0.03416307f, 
    -0.06432904f, -0.11328852f, 0.22644566f, -0.14958298f, 0.01712787f, -0.08804613f, 0.02255269f, 0.12625067f, 
    -0.09284630f, 0.17009944f, 0.15120240f, -0.08430647f, -0.11148556f, 0.46036097f, 0.07085849f, -0.03660385f, 
    -0.42147219f, 0.14570795f, -0.42950401f, -0.24056637f, 0.28436625f, -0.06511126f, 0.25023034f, 0.11290970f, 
    0.31381807f, -0.06841782f, -0.03856035f, -0.06435332f, -0.42884314f, -0.20455618f, 0.02261835f, -0.07041437f, 
    -0.02785216f, 0.31300822f, 0.47003296f, 0.03604821f, 0.09434134f, 0.01835572f, -0.37487912f, 0.23610109f, 
    0.00381511f, 0.19280002f, 0.05453250f, -0.09739026f, 0.05510955f, -0.10536189f, 0.02463142f, 0.39256874f, 
    0.34398425f, 0.08078977f, 0.13726729f, 0.36391461f, -0.17097275f, 0.38224819f, 0.13890174f, 0.03271074f, 
    0.02404155f, -0.04538043f, 0.02981954f, 0.05678283f, -0.15686305f, 0.08512524f, 0.01448521f, 0.20627807f, 
    -0.25661466f, 0.03011922f, 0.22629654f, -0.29957533f, -0.51384324f, -0.01469240f, -0.02129209f, 0.20883487f, 
    -0.27985004f, -0.33439019f, 0.03891096f, 0.20612890f, -0.31322908f, -0.14874002f, 0.05414288f, 0.12283114f, 
    -0.24140954f, 0.02889580f, 0.01675982f, 0.38124552f, 0.08993232f, 0.09431672f, 0.45118234f, 0.15517682f, 
    0.05129474f, 0.31277707f, -0.09589914f, 0.20754446f, -0.00224763f, 0.18471491f, 0.24469024f, 0.14975666f, 
    -0.22300373f, 0.09226356f, -0.00767314f, -0.01744020f, 0.04876055f, -0.00074690f, -0.09693098f, -0.14187746f, 
    -0.10482322f, -0.15388314f, 0.08072265f, 0.34589842f, 0.08983993f, -0.22236492f, -0.08191675f, -0.02747461f, 
    0.09920750f, 0.05939547f, -0.13378400f, -0.13948627f, 0.23922278f, -0.01490084f, -0.05623249f, 0.03396380f, 
    -0.16186537f, 0.03083983f, 0.32106283f, 0.20498639f, 0.14246187f, -0.23128317f, 0.05532643f, 0.28048253f, 
    0.06021798f, -0.03220109f, 0.07116915f, 0.22000013f, -0.16549514f, 0.06373977f, 0.12388263f, -0.13045008f, 
    -0.10524999f, -0.00352895f, 0.06896975f, 0.10888694f, 0.02646442f, 0.43980712f, 0.08030155f, 0.45047018f, 
    0.16092658f, -0.15433960f, 0.45943558f, 0.48695245f, 0.17898634f, -0.06377140f, 0.37774906f, 0.18027988f, 
    0.15021390f, -0.09409742f, 0.15944304f, 0.05334771f, 0.03005867f, 0.08852545f, 0.06869154f, -0.27585274f, 
    -0.46401730f, -0.00959476f, 0.28661892f, 0.35765293f, -0.01779846f, -0.31281567f, 0.21926904f, 0.11841474f, 
    -0.05577087f, 0.05749536f, 0.01283497f, 0.35364825f, 0.21118197f, -0.03654537f, -0.05229169f, 0.14008334f, 
    -0.10924146f, -0.23782595f, 0.05604792f, -0.00268292f, 0.02283188f, -0.20019683f, 0.07087916f, 0.12200456f, 
    -0.19417664f, 0.02308858f, -0.16957273f, 0.25910082f, 0.50548369f, 0.01509108f, -0.07232152f, -0.07214098f, 
    -0.08496199f, -0.32617715f, -0.13618287f, 0.21235891f, -0.08198584f, 0.01634367f, 0.05666153f, 0.29468128f, 
    -0.10393648f, -0.33615205f, -0.33113968f, -0.06967180f, 0.06654517f, 0.04102303f, 0.03821146f, 0.37333560f, 
    0.17997229f, -0.14371118f, 0.03089703f, -0.27295449f, 0.09619764f, 0.03166275f, -0.11662395f, -0.00311572f, 
    -0.08385537f, 0.05212062f, 0.00923538f, -0.08217198f, 0.17482460f, 0.13835908f, -0.04090654f, -0.59690458f, 
    0.03582268f, -0.33660874f, -0.39414206f, 0.17062354f, -0.00413007f, -0.07621085f, 0.20407064f, -0.06399519f, 
    0.01573119f, 0.25962153f, 0.07402860f, -0.03091938f, 0.20640522f, -0.00260243f, -0.06271450f, 0.06524920f, 
    -0.05668052f, -0.07581717f, 0.10293698f, -0.02438219f, 0.06961037f, -0.12696946f, 0.03981638f, 0.12068292f, 
    -0.10745613f, -0.24650203f, -0.16365233f, 0.03825692f, 0.05996887f, 0.12765978f, 0.06195751f, -0.13851841f, 
    -0.07174452f, -0.12689862f, 0.08594388f, 0.01504554f, 0.05517842f, 0.01541144f, 0.11465359f, -0.00970974f, 
    0.08086186f, 0.00722598f, 0.05310696f, -0.09966905f, -0.14818583f, 0.05070801f, 0.12198108f, -0.38996485f, 
    0.29567641f, 0.18567099f, 0.50904882f, 0.13829869f, 0.31015319f, 0.00964988f, -0.07488126f, 0.00443852f, 
    -0.08793820f, -0.05667159f, -0.22309422f, -0.19744536f, -0.17919426f, -0.22333065f, -0.07812914f, -0.10886640f, 
    -0.17745794f, -0.05769623f, 0.21548297f, -0.00094659f, -0.28553331f, -0.05513346f, 0.26047412f, 0.27569926f, 
    0.06416132f, 0.06094875f, 0.01446392f, 0.53160924f, 0.18339172f, 0.02584496f, -0.00260747f, 0.06099398f, 
    -0.04282915f, 0.25806063f, 0.08313949f, 0.13552062f, -0.10724296f, -0.20424262f, -0.04341682f, -0.03308075f, 
    -0.07065636f, -0.03984493f, -0.16153619f, -0.19750552f, 0.10306489f, 0.02150666f, -0.09773259f, 0.04489717f, 
    0.02905663f, -0.03821096f, -0.04579335f, 0.02883000f, -0.05435725f, -0.30096871f, 0.05052726f, -0.00080198f, 
    -0.24527781f, 0.05074870f, -0.10287227f, -0.07812164f, 0.09791461f, 0.07674284f, 0.12045777f, 0.17316982f, 
    -0.10025270f, 0.06598421f, -0.13894260f, 0.04988544f, 0.23133728f, -0.09088867f, -0.02598441f, -0.03680646f, 
    -0.04981240f, 0.07090304f, -0.01555074f, 0.25461954f, 0.44476438f, -0.18033895f, 0.24708290f, -0.02667786f, 
    0.31466135f, 0.20495763f, -0.32285815f, 0.40369186f, -0.12129208f, 0.09768411f, 0.35614321f, 0.10568935f, 
    -0.35177857f, 0.10930693f, 0.09388715f, 0.41324249f, 0.30296069f, -0.22088517f, -0.02679526f, 0.09147250f, 
    -0.11383385f, -0.01607226f, -0.07722203f, 0.18825953f, 0.12949091f, -0.11542455f, -0.03107013f, 0.09721602f, 
    -0.15771517f, 0.17422579f, -0.03284381f, 0.20036063f, 0.12007636f, 0.06212585f, 0.16339315f, 0.55653495f, 
    0.00913391f, -0.15800056f, 0.44483864f, -0.27238438f, 0.01436264f, -0.08681323f, -0.06589808f, -0.03873906f, 
    0.02645168f, -0.04284129f, -0.08302681f, 0.06704993f, 0.07953832f, 0.69074231f, 0.45958355f, 0.15940733f, 
    0.22245453f, -0.31639639f, 0.09605715f, 0.21940126f, -0.16587174f, 0.10975673f, -0.18111297f, -0.18091260f, 
    0.14870277f, 0.17501226f, -0.39966756f, 0.11804263f, 0.08118514f, 0.01429054f, 0.06146631f, 0.09272087f, 
    0.35133958f, -0.16034761f, 0.03221155f, 0.00197388f, -0.03225754f, -0.32369190f, 0.04653266f, -0.04983543f, 
    -0.11589063f, -0.18095730f, -0.35088435f, 0.17389719f, -0.12793733f, 0.16201951f, -0.04886709f, 0.05215790f, 
    0.26166144f, 0.10344826f, -0.25899890f, 0.05878793f, 0.09253708f, 0.15498565f, -0.45660803f, -0.02107752f, 
    0.17104109f, -0.04455009f, 0.18899514f, -0.21987279f, -0.26632288f, -0.04925981f, -0.10722532f, -0.25660831f, 
    0.24551384f, -0.26412106f, -0.16932069f, -0.17988458f, -0.10493394f, -0.03237691f, -0.28327930f, -0.70875466f, 
    0.17422441f, 0.03182046f, -0.13273147f, 0.15881236f, 0.20395774f, -0.18836062f, -0.25923580f, -0.34370956f, 
    0.20567773f, -0.33569589f, -0.23426367f, -0.15438823f, -0.14691985f, 0.00159320f, 0.08370657f, 0.19304031f, 
    0.01284085f, 0.25047287f, 0.28541043f, -0.06924505f, 0.16365114f, 0.19116285f, -0.11065787f, 0.66983366f, 
    0.42502460f, 0.18198219f, -0.06806563f, -0.05576199f, -0.20028712f, 0.00162252f, -0.03053916f, -0.06649492f, 
    0.06378888f, -0.05019411f, -0.15614708f, -0.41721550f, 0.20189643f, -0.02197121f, -0.01030932f, 0.08684354f, 
    0.12139890f, -0.13280103f, -0.04130650f, -0.04923328f, 0.25914589f, 0.13914767f, -0.01191341f, -0.23592572f, 
    0.03005857f, 0.36761627f, 0.64755630f, 0.50517040f, -0.20421603f, 0.09587071f, -0.28695700f, -0.25073102f, 
    -0.05839002f, -0.09028284f, -0.06568911f, -0.06222323f, 0.00825745f, 0.06090296f, -0.50046664f, 0.22135745f, 
    0.00160388f, -0.02193888f, 0.01998931f, -0.09020306f, 0.17084634f, 0.21482973f, -0.11646815f, 0.14614104f, 
    -0.45866874f, 0.13011296f, -0.54123127f, -0.24979807f, -0.19435889f, 0.04874336f, -0.15006612f, -0.01581829f, 
    0.08647498f, 0.15288131f, -0.09050578f, 0.18244746f, -0.09452491f, 0.29582438f, 0.02893229f, 0.07244201f, 
    0.12327953f, 0.07096276f, -0.00943351f, -0.07912547f, 0.31775081f, 0.29919735f, -0.03860109f, 0.18187563f, 
    -0.06828479f, 0.11233868f, 0.04409621f, -0.01448287f, 0.02942445f, -0.43424615f, -0.05889674f, 0.04320494f, 
    -0.13766091f, -0.09345409f, 0.04937993f, 0.17914090f, 0.15621485f, 0.10439692f, 0.02647628f, 0.09115433f, 
    0.14426456f, 0.05266420f, 0.13653223f, -0.07255823f, -0.18176322f, 0.06209116f, 0.15180126f, 0.08499072f, 
    0.19045147f, 0.17133723f, 0.16008933f, -0.32259953f, 0.14228939f, 0.26892984f, -0.04174462f, -0.05352104f, 
    -0.03207622f, -0.00726372f, 0.29259673f, 0.32721254f, -0.26518735f, 0.05685903f, 0.07471291f, -0.18890092f, 
    -0.22029442f, 0.22868688f, 0.16210115f, 0.34723157f, 0.02864330f, -0.02355666f, 0.00921955f, 0.05100101f, 
    0.05514404f, 0.11074315f, 0.16202065f, -0.03272726f, -0.33719900f, 0.08065226f, -0.20994745f, 0.00871574f, 
    -0.35319000f, -0.14392544f, 0.38388973f, -0.38957039f, 0.33197254f, -0.05352818f, -0.00673040f, -0.08774704f, 
    0.31743029f, 0.17234498f, 0.08916835f, -0.01546432f, -0.05073603f, 0.10050315f, 0.05888508f, -0.08209475f, 
    0.22390100f, 0.12357264f, -0.01188800f, -0.13252822f, 0.17006207f, 0.15682775f, 0.00597982f, -0.04143051f, 
    0.02502544f, 0.09468885f, -0.28558794f, 0.12436838f, -0.09098712f, -0.06160688f, 0.15026636f, -0.24930751f, 
    -0.05073832f, 0.23615053f, 0.05338667f, 0.12778763f, 0.01350413f, 0.18701872f, 0.12215140f, -0.13365592f, 
    0.00621327f, 0.33895159f, -0.03156042f, -0.05491674f, -0.08742632f, -0.46836546f, -0.49484929f, 0.19869831f, 
    -0.35792693f, 0.11835947f, 0.04585218f, -0.18575336f, 0.01963094f, 0.33491880f, -0.23689888f, 0.27890024f, 
    0.03017214f, 0.05790512f, 0.11363944f, -0.01371595f, -0.03835788f, 0.19589567f, 0.05757821f, -0.03020792f, 
    0.16770548f, 0.08052234f, 0.09690030f, -0.11983960f, 0.12471364f, 0.01681432f, -0.31309417f, -0.01561110f, 
    0.13106270f, -0.18445222f, -0.07224106f, 0.22024514f, 0.09184279f, -0.19543888f, 0.06264329f, 0.19130707f, 
    0.24104416f, -0.16386569f, 0.23985511f, -0.00483039f, 0.20308790f, -0.11693758f, 0.30852681f, -0.07592683f, 
    0.15618722f, -0.02258510f, 0.21857871f, 0.08061693f, -0.45771688f, -0.03947536f, 0.26813012f, 0.23177499f, 
    0.08532771f, 0.12718889f, 0.17986938f, 0.01853980f, 0.40030402f, 0.12233951f, -0.02407214f, 0.01453840f, 
    0.26760700f, -0.08659127f, 0.05231895f, 0.17640747f, -0.01259365f, -0.13099717f, 0.05323291f, 0.31859300f, 
    0.19335425f, 0.08037265f, 0.25693721f, -0.20415938f, 0.12270822f, 0.01436695f, 0.16217074f, 0.15509805f, 
    0.08020221f, 0.12485684f, -0.07256549f, 0.12638320f, -0.10880257f, 0.15403125f, -0.04311768f, 0.66948783f, 
    -0.19856215f, 0.02129595f, -0.13378352f, -0.04973172f, 0.17203361f, 0.02894280f, -0.32340536f, -0.07302998f, 
    0.05977974f, -0.02475733f, -0.12181588f, -0.34296679f, 0.08628011f, 0.02479773f, 0.00258559f, -0.01233925f, 
    0.25719377f, 0.08157963f, 0.08479517f, -0.08602219f, 0.00558466f, 0.07477851f, -0.08610436f, -0.02915178f, 
    0.06143542f, -0.06512100f, 0.38939598f, 0.02979551f, -0.20091079f, -0.13269562f, -0.04531828f, -0.12996131f, 
    0.08233454f, 0.32374546f, -0.09502739f, 0.11106673f, -0.31139988f, 0.04245809f, 0.12268978f, 0.09883457f, 
    -0.18253821f, 0.34573042f, -0.09772251f, -0.16849759f, -0.18440780f, 0.01002372f, -0.20110145f, 0.63240856f, 
    -0.21098183f, -0.07745025f, -0.06756828f, 0.10929424f, 0.04836055f, 0.00270216f, 0.24288803f, -0.01976258f, 
    0.01888963f, -0.01125539f, 0.05805020f, -0.01068110f, -0.06645478f, -0.13270535f, 0.06153757f, -0.13259329f, 
    -0.13265297f, 0.22931255f, -0.02536904f, -0.03023034f, 0.10588929f, 0.10634406f, -0.02947474f, 0.05987460f, 
    0.11777527f, 0.14082234f, 0.16955370f, -0.14214139f, -0.04612787f, 0.03735242f, -0.04502071f, 0.01226609f, 
    -0.03349299f, 0.62389445f, -0.15357767f, 0.00243930f, -0.02133078f, 0.14825079f, 0.05170338f, 0.01560085f, 
    -0.01000491f, -0.02728431f, 0.30553439f, 0.24398862f, 0.15849993f, -0.04586939f, -0.05199013f, -0.00817113f, 
    0.25498280f, 0.12147017f, 0.11624843f, -0.06481891f, -0.35925326f, -0.00773360f, 0.09708274f, 0.21771272f, 
    -0.01290129f, -0.04405698f, 0.05866534f, -0.16780007f, -0.06954090f, 0.12058450f, 0.15591848f, -0.40109804f, 
    -0.15863867f, -0.00040458f, 0.07855124f, 0.32210645f, -0.11551521f, 0.06990366f, 0.16071445f, 0.10522935f, 
    0.07165806f, 0.14453886f, 0.09651300f, -0.00216964f, -0.29149893f, 0.00113887f, 0.05155044f, -0.04619289f, 
    -0.19160622f, 0.11738102f, 0.60165066f, -0.12817471f, 0.13141912f, 0.01478832f, -0.00447199f, 0.01162035f, 
    -0.03156206f, 0.08054237f, 0.07632589f, 0.11212458f, 0.05161158f, 0.10622995f, 0.11197656f, 0.01615081f, 
    0.05530431f, 0.08062992f, -0.26888427f, -0.11418322f, -0.09684959f, 0.07990193f, 0.07928722f, 0.07482182f, 
    0.01021999f, 0.03839758f, -0.08928427f, 0.12532999f, 0.09493516f, -0.07893760f, 0.01422179f, -0.39904076f, 
    -0.00975952f, -0.06738481f, -0.03632379f, 0.17051955f, 0.13614532f, 0.11683068f, 0.03939049f, -0.05496772f, 
    -0.02039648f, -0.12513216f, 0.11634105f, 0.15702692f, 0.04764999f, -0.00599919f, -0.35053346f, -0.05505758f, 
    -0.05885238f, -0.06923195f, -0.03388723f, 0.06438561f, -0.07637554f, -0.02087153f, -0.00182483f, -0.05109813f, 
    -0.03845347f, -0.06813618f, -0.08108995f, 0.00378395f, 0.06137110f, -0.03348594f, -0.08385736f, -0.02208518f, 
    0.02255262f, -0.06269915f, -0.00078478f, -0.08441778f, -0.02836397f, -0.03556873f, -0.00518917f, -0.05738262f, 
    -0.02788358f, -0.04468674f, 0.06314971f, 0.01514730f, -0.09911169f, -0.06237639f, 0.04841191f, -0.11815841f, 
    0.05968749f, 0.01721730f, 0.06744594f, 0.02199970f, 0.02426197f, -0.03467973f, -0.03171342f, -0.07052291f, 
    0.00278647f, -0.00123349f, 0.05597945f, 0.06309903f, -0.02532965f, -0.05556913f, 0.01996926f, -0.09915502f, 
    0.01289964f, -0.06180087f, -0.01616556f, 0.05140357f, 0.06758022f, 0.02308040f, -0.05070090f, 0.07905514f, 
    -0.01445987f, 0.09628585f, -0.01174079f, 0.02571962f, -0.03565519f, 0.00714031f, 0.01186561f, -0.02606184f, 
    -0.06888890f, -0.03250690f, -0.05224620f, -0.11409748f, -0.12644339f, 0.07435778f, 0.03989866f, -0.11456278f, 
    0.05957794f, 0.00230129f, -0.03070948f, -0.00915841f, -0.05383018f, -0.01769450f, -0.06658456f, 0.07342969f, 
    -0.05056402f, -0.00287233f, -0.10371587f, -0.05538442f, 0.06187009f, 0.02844578f, -0.03065358f, -0.05979805f, 
    -0.09097919f, -0.08851118f, 0.09030548f, -0.10370339f, -0.01178545f, -0.08521571f, 0.04400622f, 0.05201086f, 
    -0.06836833f, -0.00571094f, -0.10384607f, 0.07292064f, -0.11253407f, -0.08071432f, -0.05416282f, 0.04193585f, 
    -0.06442589f, -0.07327323f, 0.06187103f, 0.00503305f, -0.01819139f, -0.08643902f, 0.04468306f, -0.07195164f, 
    0.04358717f, -0.01500904f, -0.06935096f, -0.09956714f, 0.08116616f, 0.00008380f, -0.02090469f, -0.01382305f, 
    0.01466238f, -0.01344640f, 0.01557213f, 0.05452241f, -0.00951257f, -0.10095500f, -0.12454701f, -0.11729486f, 
    0.33607748f, -0.06358993f, -0.35593340f, -0.20910229f, 0.25657365f, -0.20018563f, -0.28663850f, -0.01282601f, 
    0.23720933f, 0.05422660f, -0.19467539f, -0.04664261f, 0.02667935f, -0.53269517f, 0.02727155f, 0.36896834f, 
    0.14500742f, 0.05816050f, 0.22493504f, 0.07591055f, -0.15677080f, -0.60008579f, 0.04376388f, 0.21011393f, 
    0.03759055f, -0.06791802f, -0.07978386f, -0.08647548f, 0.04946038f, 0.45044738f, 0.08079434f, 0.09417444f, 
    0.05003354f, -0.86087430f, -0.44563341f, 0.09831437f, -0.03913734f, 0.05473499f, -0.49275258f, -0.08618010f, 
    0.03763643f, -0.03537866f, -0.42213210f, -0.44478044f, 0.25932753f, -0.05804616f, -0.35332203f, -0.37107655f, 
    0.29590639f, -0.46626252f, 0.06302365f, -0.36261225f, 0.00171081f, -0.29709613f, -0.16266233f, -0.27199104f, 
    0.20779510f, -0.00604715f, -0.19327091f, 0.12241975f, 0.12322620f, -0.06082215f, -0.10810954f, -0.29862136f, 
    0.15627721f, -0.09120785f, -0.17479610f, -0.24691309f, -0.15448582f, 0.01924491f, 0.13616964f, 0.11839136f, 
    -0.08651255f, -0.04495491f, 0.12731960f, -0.01138064f, 0.24435230f, 0.15752074f, -0.09435663f, 0.35855365f, 
    0.46769640f, 0.12091202f, 0.28287116f, 0.15863565f, -0.42667705f, -0.02198533f, 0.23046468f, -0.04064929f, 
    -0.07192388f, -0.13644834f, -0.11064427f, 0.17170493f, 0.25881264f, -0.31630000f, 0.06022368f, -0.02915320f, 
    -0.01201985f, -0.21431771f, -0.08712182f, 0.08583352f, 0.27363953f, 0.07199354f, 0.01529325f, -0.29590109f, 
    0.19111514f, 0.10424168f, 0.57630897f, 0.48062468f, -0.07508278f, -0.00287714f, 0.05169185f, -0.06139526f, 
    -0.05418763f, -0.49164650f, 0.14323474f, -0.02544886f, 0.11242977f, -0.01985355f, -0.27809417f, -0.06150971f, 
    0.13906054f, -0.03372038f, 0.15298495f, -0.08836451f, 0.20055766f, 0.43683258f, -0.02553041f, 0.17418034f, 
    0.18374600f, 0.16917872f, 0.04880692f, 0.09604637f, 0.05043167f, 0.10258064f, 0.16712081f, 0.16180561f, 
    -0.26339796f, 0.16095613f, -0.12143494f, 0.16916651f, 0.34956774f, 0.32062861f, 0.03720423f, 0.05578020f, 
    0.10259090f, -0.31469634f, 0.04326829f, -0.23303722f, 0.11534303f, -0.10572278f, 0.47797155f, 0.00182567f, 
    -0.41016144f, 0.29835185f, 0.09621875f, -0.31416050f, 0.04666154f, -0.03702161f, -0.04611446f, 0.09453394f, 
    -0.22367509f, -0.32272533f, -0.02991671f, 0.14144662f, 0.06255344f, 0.23286358f, 0.08245143f, 0.07631268f, 
    -0.16848223f, -0.04254652f, -0.11083069f, -0.29191238f, -0.13827667f, -0.00518484f, 0.30024853f, 0.14296871f, 
    0.48846105f, 0.01436625f, -0.15951523f, 0.06985310f, 0.51242995f, -0.06900140f, 0.09647596f, 0.01561630f, 
    0.14569177f, 0.00459880f, 0.14107843f, 0.28396732f, -0.01725612f, 0.05181177f, 0.08324817f, -0.15407386f, 
    -0.34776968f, 0.13262042f, 0.11237273f, 0.04594314f, -0.08952197f, -0.02406048f, -0.44328216f, 0.01385168f, 
    -0.00637007f, 0.26251322f, 0.04698986f, 0.08191647f, 0.11843047f, -0.28705189f, -0.03467781f, -0.02155763f, 
    -0.01539859f, -0.01831112f, 0.23283558f, -0.01180036f, 0.26900274f, -0.05237978f, 0.33659342f, 0.14050581f, 
    -0.08597272f, 0.01124789f, -0.28374153f, -0.09745124f, -0.15485479f, 0.11967164f, 0.06273511f, 0.01661613f, 
    0.22031133f, 0.23787488f, 0.38727340f, 0.22617605f, 0.04481842f, -0.01531219f, -0.02907238f, 0.05080139f, 
    0.25707832f, 0.15044780f, -0.22696424f, 0.02528567f, 0.01125309f, 0.01266187f, 0.04185690f, 0.12846699f, 
    -0.05657795f, 0.33124214f, 0.28344175f, -0.24211150f, 0.10608255f, -0.09997579f, -0.11426184f, 0.03754721f, 
    -0.16631743f, 0.13596444f, -0.33811283f, -0.06607176f, -0.07265396f, -0.19124199f, -0.16963688f, -0.15293624f, 
    -0.00425633f, -0.00451632f, -0.01403051f, -0.03502080f, -0.08903836f, -0.02070109f, -0.03932867f, -0.08271810f, 
    -0.05223777f, 0.03791675f, -0.08824412f, 0.01266624f, -0.11381659f, -0.06883454f, 0.07609661f, 0.00136122f, 
    0.01928819f, -0.11334556f, 0.02263729f, -0.06152481f, -0.03261915f, -0.09098792f, 0.03319284f, 0.08739829f, 
    0.04441772f, -0.03475809f, -0.00694939f, -0.08075716f, -0.05908690f, -0.10777505f, 0.08602717f, -0.00993420f, 
    -0.02176562f, -0.02797120f, -0.09380862f, -0.15156259f, 0.03083365f, 0.05119925f, 0.04836697f, 0.00677833f, 
    -0.05983364f, 0.03781640f, 0.04900767f, 0.06283173f, -0.02022680f, 0.05198731f, -0.06650482f, 0.00157127f, 
    0.24219351f, -0.03749011f, 0.02055570f, 0.01034717f, -0.01956295f, -0.10644657f, 0.03226910f, -0.07719925f, 
    -0.02117909f, -0.06442431f, -0.10154134f, -0.03627519f, -0.02698725f, -0.04700807f, 0.01322114f, 0.00218968f, 
    -0.06816724f, 0.01397930f, 0.04473395f, 0.03641442f, 0.02222598f, -0.07043892f, -0.02682462f, -0.10885388f, 
    -0.01153884f, 0.02198339f, -0.06848754f, -0.01235196f, -0.10123228f, 0.04819135f, -0.10870368f, 0.03882592f, 
    -0.05858497f, -0.01111823f, 0.13860561f, -0.08840991f, 0.00474139f, 0.05659914f, -0.03895777f, -0.09422725f, 
    -0.03481114f, -0.00835382f, -0.13138658f, 0.07135229f, -0.07409166f, -0.11103154f, 0.07866585f, 0.05298755f, 
    -0.02921496f, -0.05286126f, 0.07867898f, -0.09410547f, 0.05006360f, -0.05761930f, 0.05128239f, -0.09564775f, 
    -0.09373001f, -0.04848752f, 0.01595362f, 0.05948837f, 0.01797257f, 0.02716755f, 0.10829806f, -0.02047633f, 
    0.05780189f, -0.14570940f, 0.04076431f, -0.08692575f, 0.07012501f, 0.00963200f, 0.06517999f, 0.05247814f, 
    -0.05371352f, -0.08310480f, -0.09987090f, -0.10407554f, 0.02023576f, -0.04435789f, -0.08905552f, -0.05866720f, 
    0.00943671f, -0.04672907f, -0.06035736f, -0.03173856f, -0.03214131f, 0.00324905f, 0.04658583f, -0.04882403f, 
    -0.07043023f, -0.03281921f, 0.00839799f, -0.02603026f, -0.05616689f, -0.03967984f, 0.06684789f, -0.05007499f, 
    -0.01877705f, -0.09789708f, -0.06285331f, -0.02792868f, -0.07773127f, -0.04321337f, -0.00502798f, -0.07103881f, 
    -0.01927872f, 0.04505849f, 0.04843779f, -0.05047060f, 0.00174827f, -0.01812615f, 0.02587352f, 0.00379966f, 
    -0.10590024f, -0.02949491f, -0.05821170f, -0.10841019f, 0.00511601f, -0.01577333f, 0.00800624f, -0.08969196f, 
    0.01706416f, -0.04300432f, -0.06305756f, -0.00684221f, -0.05376273f, -0.02346847f, 0.01217773f, 0.02024527f, 
    -0.00010268f, -0.04721005f, -0.03189532f, -0.08567535f, -0.06541011f, 0.03360596f, -0.02090947f, -0.04835756f, 
    -0.09638799f, 0.00526161f, -0.11401618f, -0.04771675f, -0.02123919f, -0.07566341f, -0.00646307f, -0.06255536f, 
    0.02122750f, -0.06392029f, -0.08386125f, 0.04245475f, -0.02785037f, 0.05783498f, 0.03082402f, -0.08431547f, 
    0.02876808f, -0.08666276f, 0.03805895f, -0.05290349f, 0.05561349f, 0.03947972f, -0.07121722f, -0.06096447f, 
    0.05565621f, -0.03859971f, 0.07322009f, -0.06867661f, 0.01237200f, -0.00768432f, -0.10155583f, -0.01469473f, 
    -0.05294326f, -0.01745223f, 0.05258053f, -0.03689098f, 0.04173768f, -0.04950569f, 0.04115224f, -0.06806517f, 
    0.02054633f, 0.02987023f, -0.06390653f, 0.01831024f, -0.02672801f, -0.05555476f, 0.01114358f, 0.06988008f, 
    -0.04276060f, 0.01068441f, 0.08158511f, 0.01025441f, 0.05247768f, -0.08500829f, -0.01400262f, -0.01780024f, 
    -0.05577517f, -0.10927533f, -0.10318501f, -0.04013192f, -0.03011288f, 0.00264568f, -0.05496493f, 0.02396189f, 
    -0.08624848f, -0.06033164f, 0.02397121f, -0.04960980f, -0.07776877f, 0.04679246f, 0.05172127f, -0.01496114f, 
    0.00713860f, -0.01531438f, 0.03758480f, -0.04217405f, -0.03018322f, 0.06530763f, 0.08024291f, 0.01464205f, 
    -0.06497434f, 0.02952058f, 0.01796733f, 0.05808002f, 0.01186023f, -0.07778645f, -0.03819949f, -0.02546651f, 
    -0.00259872f, -0.02690072f, 0.04709549f, 0.02490577f, 0.00725008f, 0.02659348f, 0.04135434f, -0.00712293f, 
    -0.09951746f, 0.03548585f, -0.08445314f, -0.01673072f, -0.02650214f, -0.06125022f, -0.03099328f, 0.04275535f, 
    -0.01910916f, 0.01734586f, -0.07981960f, -0.05629950f, -0.09516660f, 0.00395670f, 0.04479779f, -0.01207183f, 
    -0.08217715f, 0.05386233f, -0.03127222f, -0.05850609f, -0.07379384f, -0.03060317f, -0.00737761f, 0.02138374f, 
    0.06098498f, 0.02415869f, -0.04220280f, 0.04740646f, -0.01118923f, 0.01032399f, -0.01731531f, -0.08901937f, 
    0.00459733f, 0.01733154f, 0.02894140f, -0.02420354f, -0.05847838f, -0.00454644f, 0.04587157f, -0.03983429f, 
    0.01311543f, -0.04632336f, -0.00988550f, 0.00514755f, 0.05781005f, -0.07308210f, 0.06080825f, -0.01865610f, 
    0.06098754f, -0.01655928f, -0.08373725f, -0.07655825f, -0.01329894f, -0.08811359f, 0.04908666f, 0.04752424f, 
    -0.00839940f, -0.03878919f, -0.06445812f, -0.04087645f, -0.11004270f, -0.04999622f, -0.02199761f, -0.07582784f, 
    0.01412727f, 0.00369816f, -0.07217930f, 0.01891974f, -0.06693503f, -0.09753379f, -0.01573656f, -0.08608998f, 
    -0.02372096f, -0.01486132f, 0.07699966f, 0.01762550f, -0.01819536f, -0.06112799f, 0.03169296f, -0.02705237f, 
    -0.01799192f, -0.00788703f, 0.00992844f, 0.02986788f, -0.06933017f, -0.11318731f, 0.04668614f, -0.09990640f, 
    0.05410688f, -0.02333075f, 0.06699056f, -0.05960432f, -0.09912127f, -0.08608091f, -0.02258918f, 0.03896613f, 
    -0.05413119f, -0.01376274f, 0.05642424f, 0.06395440f, -0.09371111f, -0.01010818f, -0.03661958f, 0.08190906f, 
    -0.25758865f, 0.05208586f, -0.28694576f, 0.01257748f, -0.24599092f, 0.11778247f, -0.07595079f, -0.10234530f, 
    -0.01141562f, 0.15137672f, 0.10583953f, 0.00890120f, -0.05111667f, 0.20982352f, -0.02644007f, 0.24044533f, 
    0.04634009f, 0.02430816f, 0.04554872f, -0.00975704f, 0.30957520f, 0.23511390f, -0.42379376f, 0.09825863f, 
    0.10637335f, 0.02927743f, 0.05417743f, 0.07764719f, -0.02139950f, -0.15022561f, -0.00213748f, 0.05839363f, 
    -0.15715232f, 0.04442526f, -0.00821715f, -0.14771950f, 0.32406870f, 0.06038850f, 0.01782036f, -0.05156364f, 
    0.13893060f, -0.00483514f, 0.10056903f, 0.03223741f, -0.11476780f, -0.02922649f, 0.16322932f, 0.03297410f, 
    0.01154660f, 0.20731312f, 0.16175033f, -0.19631451f, -0.26298252f, 0.22704327f, -0.02381046f, -0.08667833f, 
    0.17742372f, 0.13311970f, 0.26331758f, 0.20666511f, -0.18757904f, -0.12305892f, -0.02996047f, -0.08762836f, 
    0.10751557f, 0.20499310f, 0.17714334f, 0.21670367f, -0.04710857f, -0.07138858f, 0.13842040f, -0.01427483f, 
    0.00736644f, 0.02624360f, 0.10441708f, -0.02614200f, -0.43450764f, 0.04437887f, -0.10052719f, -0.39941683f, 
    -0.16910969f, -0.22498740f, 0.16305579f, -0.27594784f, 0.25500315f, 0.07836594f, 0.01862304f, 0.07235427f, 
    0.26226386f, -0.07242967f, 0.04336629f, -0.13638197f, -0.12403565f, 0.13223322f, 0.11673189f, -0.09415885f, 
    0.17694713f, 0.16642554f, -0.16980965f, -0.01367603f, 0.12416788f, 0.13650356f, 0.06499545f, 0.02354330f, 
    0.00358429f, 0.05036170f, 0.01264235f, 0.17039900f, -0.15889487f, -0.05026292f, -0.01001458f, -0.24725275f, 
    0.05364672f, 0.14419426f, 0.02985915f, 0.14233895f, -0.06379453f, 0.11757279f, 0.14024980f, 0.12045270f, 
    0.16648524f, 0.14496374f, 0.18372022f, -0.06523815f, -0.03126711f, -0.10411975f, -0.39119825f, 0.19900072f, 
    -0.34539673f, 0.13589247f, -0.28122479f, -0.37723830f, -0.18656625f, -0.07566700f, -0.26667571f, -0.36980924f, 
    0.20525646f, 0.11881550f, -0.31640977f, 0.10808538f, -0.32315367f, 0.02973537f, 0.05524091f, 0.30315211f, 
    0.16135773f, 0.02424681f, -0.01377988f, 0.00631387f, 0.15756795f, 0.22595190f, 0.14477390f, -0.09832197f, 
    -0.17777094f, 0.26721397f, -0.11058167f, -0.43663523f, -0.05006586f, -0.21826820f, -0.00478095f, 0.09376394f, 
    -0.20129104f, 0.11363010f, -0.07445899f, 0.24290578f, 0.08854678f, -0.06961896f, 0.05146319f, -0.04935919f, 
    -0.03689638f, 0.10441387f, -0.20700167f, -0.39335969f, -0.35474616f, -0.07316193f, 0.14456479f, 0.07041632f, 
    0.20296429f, 0.25787622f, 0.15191643f, -0.40672320f, 0.47710565f, 0.27943221f, -0.13127705f, -0.21799953f, 
    -0.48554450f, -0.50102848f, 0.04825075f, 0.04636667f, -0.31669533f, 0.09031449f, 0.01275965f, -0.26499552f, 
    -0.22134593f, 0.11915950f, -0.21543312f, 0.48667654f, -0.05791593f, -0.07304940f, 0.38859728f, 0.10793688f, 
    -0.05597039f, 0.22145170f, 0.04979173f, -0.03230731f, -0.24043724f, 0.08037382f, 0.09045353f, -0.02917897f, 
    0.04021174f, 0.18527618f, 0.10313676f, 0.10660670f, 0.02937754f, 0.04961605f, 0.23481627f, 0.12122523f, 
    0.21769552f, 0.13889815f, -0.54236460f, -0.02277789f, -0.07181598f, -0.30151096f, -0.01893778f, -0.04487431f, 
    -0.08384519f, -0.00199161f, -0.16847557f, 0.14565748f, 0.13814056f, 0.19080839f, 0.07619385f, -0.22591932f, 
    -0.07961264f, 0.38026839f, -0.02334449f, 0.20100096f, 0.19408524f, -0.00209491f, 0.17914574f, 0.15599157f, 
    -0.08766576f, -0.00604831f, 0.09919834f, 0.08814202f, 0.07482079f, 0.16495705f, -0.03101735f, -0.16197328f, 
    0.21568964f, -0.12725933f, 0.05348049f, 0.11815186f, -0.11456058f, -0.41290286f, -0.14407390f, -0.29377723f, 
    -0.15425332f, -0.04930372f, -0.01780100f, -0.11761179f, 0.11376510f, -0.05463124f, 0.17694807f, -0.40203643f, 
    0.00842069f, 0.00843299f, -0.04731449f, -0.02800776f, 0.03969307f, 0.10675187f, -0.02978859f, 0.26436222f, 
    -0.19231616f, -0.30149379f, 0.04491491f, 0.01376039f, -0.15846096f, 0.02040243f, 0.12035538f, 0.30767986f, 
    -0.21699116f, 0.13778690f, 0.10241227f, 0.20900212f, 0.03045382f, -0.21636730f, 0.01725203f, 0.17657004f, 
    -0.46354339f, -0.44444805f, 0.03244177f, -0.03598441f, 0.25110030f, -0.43474516f, -0.05931647f, 0.06422287f, 
    0.03215682f, 0.04665856f, -0.42158470f, -0.25214794f, -0.20065269f, -0.01096592f, -0.13342470f, 0.07962617f, 
    0.07226533f, 0.15170932f, 0.06890915f, 0.27059409f, 0.20526704f, -0.19633529f, 0.05928933f, -0.25731790f, 
    -0.05521366f, 0.26314342f, -0.04606930f, -0.03939369f, 0.13933377f, 0.04532271f, 0.03640072f, -0.11319585f, 
    0.00169224f, 0.02050994f, -0.16960624f, -0.11653363f, 0.15331289f, 0.01319329f, -0.51001161f, -0.16113368f, 
    0.00258422f, -0.14618480f, 0.16501562f, 0.03061321f, 0.45239103f, -0.09006975f, -0.04339977f, 0.24798366f, 
    0.06324287f, 0.04907177f, -0.04691682f, 0.18720204f, -0.06056234f, -0.04732758f, 0.37699577f, 0.31297988f, 
    0.04625716f, 0.13687503f, 0.14728624f, -0.03606761f, -0.18615727f, -0.03540872f, -0.03190667f, -0.00070367f, 
    -0.21650474f, 0.01845701f, 0.05525232f, 0.31981546f, -0.20702043f, 0.12036173f, -0.06976371f, 0.13493028f, 
    -0.19106698f, 0.30066189f, -0.27738690f, -0.08731841f, 0.29709077f, 0.37088701f, 0.27200884f, 0.31470698f, 
    0.02325357f, -0.03743310f, 0.22457291f, -0.41114902f, 0.27501532f, -0.19216758f, 0.06057835f, -0.05675916f, 
    0.16723008f, -0.11367881f, -0.11438823f, 0.13432591f, 0.08632769f, -0.37550485f, 0.22537075f, -0.16138646f, 
    0.21504907f, -0.04476909f, 0.28523180f, 0.14483000f, 0.03005527f, -0.11226051f, 0.22857919f, 0.02064377f, 
    -0.18915209f, 0.04211293f, 0.09545180f, 0.03794212f, 0.13204587f, 0.06916513f, 0.06664876f, -0.28948799f, 
    -0.21984632f, -0.10079636f, 0.02811257f, 0.14909206f, -0.14025000f, 0.09409861f, 0.31982520f, -0.11007034f, 
    -0.12875669f, 0.03101610f, -0.06676259f, 0.05883762f, 0.05750264f, 0.03850014f, 0.02011628f, 0.12903214f, 
    -0.03307867f, 0.25532627f, 0.06034432f, -0.16279891f, 0.01408526f, -0.19294584f, -0.51847374f, 0.23013620f, 
    -0.12075086f, -0.07100684f, 0.04029220f, -0.04135966f, 0.14948545f, -0.00770143f, 0.08521335f, -0.07767916f, 
    0.03792842f, -0.09257738f, -0.08349632f, 0.27786127f, -0.03565704f, 0.19317840f, 0.32823148f, -0.06686769f, 
    -0.03798900f, 0.05168834f, -0.19998825f, -0.08970496f, 0.17169428f, 0.25426656f, -0.01666957f, 0.16367818f, 
    -0.02660039f, 0.10025974f, -0.19642425f, -0.23637770f, 0.08980310f, 0.04152558f, -0.08136696f, -0.20056495f, 
    0.06605198f, 0.07317835f, -0.15726720f, 0.08998276f, 0.15167141f, -0.02444157f, -0.03062623f, -0.14952794f, 
    -0.10215294f, -0.08083034f, -0.15228285f, 0.13631774f, -0.12043120f, -0.02686984f, 0.20754778f, 0.14459470f, 
    -0.02390029f, -0.00497276f, -0.10385758f, 0.11003748f, 0.14626339f, 0.01155329f, -0.08875842f, -0.05294539f, 
    -0.22096612f, -0.21717651f, 0.19772348f, 0.37420279f, -0.12057519f, 0.04233579f, -0.08078898f, 0.32092279f, 
    0.00210178f, 0.01829999f, -0.06565198f, -0.03308755f, 0.05554695f, 0.15465435f, 0.05043545f, 0.07821600f, 
    0.00234786f, -0.10485961f, 0.22726811f, -0.07608139f, 0.00377129f, 0.07270195f, 0.03129539f, 0.11363200f, 
    0.19316386f, -0.23966821f, 0.05334570f, 0.09136552f, 0.00087302f, -0.06583989f, 0.31739369f, -0.38939139f, 
    -0.46439353f, -0.06892863f, 0.37225589f, 0.09219921f, -0.33343804f, -0.07413045f, 0.36024386f, -0.19113573f, 
    -0.13385880f, 0.11276314f, 0.06021716f, 0.26472479f, 0.21450765f, 0.35311273f, 0.08747750f, 0.23362564f, 
    0.01314498f, 0.03379421f, -0.06808969f, 0.21925063f, 0.28372663f, 0.16759084f, -0.17319547f, -0.02804429f, 
    -0.10114497f, -0.00801915f, -0.10955933f, 0.33862039f, -0.05001340f, -0.14192307f, 0.00282987f, 0.06750420f, 
    -0.11595994f, 0.26392519f, -0.02447528f, 0.03145173f, 0.13375115f, -0.30770367f, 0.06908514f, 0.05093085f, 
    0.05114296f, -0.02962309f, 0.08084688f, -0.27326658f, -0.03227130f, 0.03956534f, 0.11502942f, -0.06052815f, 
    -0.58298987f, 0.07371139f, -0.03126456f, -0.02880915f, 0.18616502f, 0.44907495f, -0.11846826f, -0.01647530f, 
    -0.09533671f, 0.12096862f, 0.08016758f, 0.06045409f, -0.10711634f, 0.18357112f, 0.00351662f, -0.06235426f, 
    0.22051930f, -0.03180220f, -0.13061078f, 0.04266855f, 0.01390068f, 0.01435983f, 0.07397526f, -0.01045343f, 
    -0.08118276f, -0.14978081f, 0.04590439f, -0.12141430f, 0.14421140f, 0.19089212f, -0.02715134f, -0.40492424f, 
    0.23183130f, -0.60218614f, -0.37632281f, 0.15538104f, 0.09347896f, 0.00051258f, -0.06600177f, 0.06219414f, 
    0.26957700f, 0.13970822f, -0.16196865f, -0.24815203f, -0.13138004f, 0.05462883f, -0.02464233f, -0.00732819f, 
    -0.00732740f, 0.18595371f, -0.06363988f, 0.12200984f, -0.16717063f, 0.25532693f, 0.08122820f, 0.16865575f, 
    -0.03424355f, 0.13356955f, -0.32906601f, -0.66686070f, -0.01637281f, 0.10890540f, -0.08331937f, -0.10242689f, 
    -0.03758710f, 0.17774387f, -0.08175836f, 0.29133219f, -0.17298016f, 0.25686908f, 0.06744666f, -0.09375047f, 
    0.12399446f, -0.07622219f, 0.06229475f, 0.03832146f, -0.28326121f, -0.72192961f, -0.22955038f, -0.07112751f, 
    -0.31179905f, 0.31613445f, 0.13489833f, -0.17028201f, 0.22077373f, 0.18252982f, 0.01895700f, 0.22627996f, 
    0.02862719f, -0.09884585f, -0.21317884f, 0.05297190f, -0.30646107f, 0.04184885f, 0.04155108f, -0.13134448f, 
    -0.11413455f, 0.09790971f, 0.33481607f, -0.22010536f, 0.21641152f, 0.15144980f, -0.18904956f, 0.25056395f, 
    -0.19742772f, 0.12356030f, 0.09185115f, 0.17513637f, -0.00268749f, -0.12129179f, 0.06969057f, 0.30756763f, 
    0.41236714f, -0.22857559f, 0.00893773f, 0.44323111f, -0.18356693f, 0.32436109f, 0.44737029f, -0.16362317f, 
    -0.07202850f, 0.04303662f, -0.15645912f, -0.00766171f, -0.11981490f, 0.02698386f, 0.25308728f, 0.25698039f, 
    0.06261265f, 0.11296535f, 0.15972061f, -0.01879057f, -0.39270771f, -0.18918449f, -0.09503175f, 0.15813245f, 
    -0.25058740f, -0.20490012f, -0.01703581f, 0.33915898f, -0.54083025f, -0.19715893f, 0.20901479f, 0.08814857f, 
    -0.30809861f, 0.04256898f, -0.02338043f, 0.29062602f, 0.15815029f, 0.07289025f, 0.08014016f, -0.03201799f, 
    0.01005400f, 0.15876536f, -0.27489597f, 0.18814899f, 0.24027741f, -0.06948573f, 0.12882243f, -0.09547204f, 
    -0.36499262f, -0.08308811f, 0.03106126f, 0.15850951f, 0.20335479f, -0.01599001f, 0.25890604f, 0.04182985f, 
    -0.13160251f, -0.17779018f, 0.26289511f, 0.44586641f, -0.15202324f, -0.03893846f, -0.04564879f, -0.07386225f, 
    0.33457971f, 0.10642266f, 0.00151081f, -0.05869905f, 0.06953529f, -0.16985430f, -0.03858262f, -0.14377373f, 
    -0.22817042f, 0.06097903f, -0.12609433f, 0.01453836f, 0.05822590f, -0.21722594f, 0.09587611f, 0.50048369f, 
    0.06457806f, 0.13885108f, 0.06013652f, 0.00336188f, -0.24986634f, -0.04208223f, 0.15543176f, -0.25878459f, 
    -0.39548555f, 0.33538628f, -0.09909213f, 0.16696239f, -0.06531990f, 0.48161882f, 0.27556652f, -0.00139137f, 
    -0.02589935f, 0.04802980f, 0.03527642f, 0.05776307f, 0.03633849f, 0.01331737f, 0.04077908f, -0.06054829f, 
    -0.04631865f, -0.07372073f, -0.04747891f, 0.02142876f, 0.00412887f, -0.04868177f, -0.01546676f, -0.04585107f, 
    0.01528107f, -0.02856795f, 0.00115270f, -0.00487372f, 0.02367041f, -0.05419581f, 0.05736654f, 0.02274681f, 
    -0.06815986f, -0.01310546f, -0.03293221f, 0.07754327f, 0.01594979f, 0.03700609f, -0.05416746f, 0.02828821f, 
    0.05281976f, -0.00855125f, -0.09126977f, -0.05219862f, -0.02235684f, 0.00174334f, -0.06607145f, -0.10160856f, 
    -0.05284983f, 0.04922330f, -0.08332585f, -0.05936442f, -0.01749872f, 0.04610438f, 0.05352877f, 0.04815703f, 
    0.06151472f, -0.07836179f, -0.04970852f, 0.00166318f, 0.03541892f, -0.04300186f, -0.05038268f, -0.00448333f, 
    -0.06800562f, -0.06015373f, 0.04439971f, 0.02665045f, -0.07901354f, 0.00530336f, 0.03849821f, 0.00213876f, 
    -0.04378153f, -0.08187008f, 0.04910174f, 0.07182650f, 0.01922027f, 0.07873265f, 0.03111504f, -0.11403869f, 
    0.07344079f, -0.09044875f, -0.07346541f, -0.10514955f, -0.10040519f, -0.05428924f, -0.00064953f, 0.08762124f, 
    -0.07359997f, 0.06535000f, 0.01595159f, -0.05953490f, -0.06269838f, 0.06229921f, 0.01007268f, -0.03820802f, 
    -0.04859440f, 0.05623414f, -0.02645307f, 0.08797560f, -0.11524854f, -0.08406583f, -0.02359711f, 0.04903601f, 
    -0.00966412f, 0.04625830f, -0.07899933f, -0.02700387f, 0.00803617f, -0.07022082f, 0.08097281f, -0.04527121f, 
    0.01377063f, 0.04000308f, -0.10736461f, 0.01291779f, 0.03883178f, -0.01232491f, -0.10505223f, 0.03147510f, 
    0.07717538f, -0.06089393f, -0.07419755f, 0.05194701f, 0.03650425f, -0.07170691f, -0.10762035f, -0.07603200f, 
    -0.04378346f, 0.04941167f, 0.05288541f, 0.00743419f, -0.05523089f, 0.02268218f, -0.00973679f, -0.10833916f, 
    -0.18779917f, -0.08704828f, 0.43297392f, 0.00206174f, -0.11097244f, 0.18301310f, 0.06572670f, 0.26736537f, 
    0.11829555f, 0.10151127f, 0.17634670f, 0.26435465f, 0.24061838f, 0.21720243f, 0.01380441f, 0.35339403f, 
    0.27206156f, 0.01403169f, 0.06560916f, 0.17518549f, 0.40423632f, 0.19229428f, -0.18199484f, 0.02846950f, 
    -0.17880484f, -0.10563453f, 0.09701894f, 0.46473646f, -0.13801959f, 0.01768611f, -0.07299488f, 0.23709889f, 
    0.61552036f, 0.22931169f, 0.03008641f, 0.19282642f, -0.07148376f, -0.05857046f, 0.10087000f, 0.04347698f, 
    -0.12860438f, 0.09110754f, -0.05723929f, -0.12434532f, -0.12852757f, 0.06100382f, -0.01779631f, 0.12813474f, 
    -0.26542580f, -0.08271160f, -0.02741873f, -0.08913280f, 0.12908632f, 0.28582644f, -0.34279686f, 0.14707190f, 
    0.06708201f, -1.21209681f, -0.04527052f, 0.33336949f, 0.01636190f, 0.06109746f, -0.15692480f, 0.04252490f, 
    -0.01908799f, -0.05254684f, 0.23306166f, -0.35939121f, -0.01014882f, 0.01423542f, 0.08512323f, 0.03064583f, 
    -0.00640312f, -0.12532061f, 0.15925731f, 0.20244502f, 0.13005093f, 0.22905132f, -0.28053877f, -0.12307937f, 
    -0.01021781f, -0.33707580f, -0.46577981f, -0.07728090f, 0.19163994f, 0.06511831f, -0.32500079f, -0.04683315f, 
    0.32738927f, 0.11797924f, -0.55841464f, 0.05891235f, -0.10520840f, 0.05784140f, -0.05919024f, 0.03617581f, 
    0.29103243f, 0.01977047f, 0.20271584f, -0.14330760f, 0.12802698f, 0.13076065f, -0.02628618f, 0.19243129f, 
    0.19992682f, -0.18993200f, -0.21938771f, -0.40997353f, -0.02241815f, -0.21872826f, -0.15097408f, -0.16843207f, 
    -0.00641357f, 0.13599153f, -0.11638555f, 0.36663505f, -0.08780517f, 0.17301807f, -0.09075859f, 0.02367910f, 
    0.07700219f, 0.41326645f, -0.44123292f, -0.22214770f, -0.43651730f, -0.25793809f, -0.40730360f, 0.14681597f, 
    0.35561997f, -0.18608628f, 0.49690852f, 0.04779334f, 0.01095791f, -0.02243458f, -0.23884347f, 0.09111956f, 
    0.43542850f, -0.08005357f, 0.04001014f, -0.09178394f, 0.07668392f, 0.09017114f, 0.07274788f, 0.35148826f, 
    0.06637789f, -0.43911830f, 0.27399683f, 0.19185786f, -0.06325177f, -0.09482929f, 0.46881869f, 0.33198303f, 
    -0.13682565f, 0.02236880f, -0.24416730f, 0.31304368f, 0.11274771f, -0.19121902f, 0.06976356f, -0.03740541f, 
    -0.03962926f, -0.54211110f, 0.01569265f, -0.23854068f, 0.30502278f, -0.38471332f, -0.13346241f, 0.12488816f, 
    0.01133277f, 0.06905902f, -0.13436416f, 0.22148156f, -0.06747078f, -0.10102901f, -0.03130692f, -0.01945721f, 
    -0.29884106f, -0.25622699f, -0.12992731f, 0.18314561f, 0.30112007f, -0.11599484f, -0.13732032f, -0.24686900f, 
    0.23553626f, 0.39775106f, -0.12447203f, 0.18392585f, 0.21303277f, -0.17983416f, 0.01279492f, 0.31264347f, 
    0.14509360f, -0.16470820f, 0.03074978f, -0.09165581f, -0.00947645f, 0.00378512f, -0.16103588f, 0.05305838f, 
    0.02705146f, -0.14856176f, 0.07221013f, -0.22341195f, -0.18366167f, -0.03395902f, -0.00923357f, -0.02499921f, 
    0.51189417f, 0.17260861f, -0.64443260f, -0.04192655f, 0.07198382f, -0.01616983f, 0.27998152f, -0.18332341f, 
    0.12987570f, 0.18837716f, 0.36701104f, 0.05696483f, 0.13913946f, 0.00814483f, 0.00680204f, 0.03571477f, 
    0.05702461f, -0.15584470f, 0.32377133f, -0.08912338f, 0.38612175f, 0.10976783f, -0.06913245f, -0.13471834f, 
    0.07434054f, -0.00424209f, -0.27107555f, 0.01741557f, -0.10595307f, 0.16894174f, 0.04426283f, 0.14238168f, 
    -0.07828687f, 0.10637419f, 0.09961522f, -0.15611787f, 0.23444851f, 0.10982729f, 0.02948823f, 0.20454906f, 
    0.04737725f, 0.12638374f, -0.15753064f, -0.19730541f, -0.07311668f, 0.13973776f, 0.09305013f, 0.12417403f, 
    0.00776305f, 0.04402987f, -0.04188168f, -0.02653484f, -0.01574128f, 0.03167972f, -0.07055515f, 0.04427446f, 
    -0.08529412f, -0.01153177f, -0.02317075f, -0.03268754f, -0.08771695f, -0.00682599f, 0.00823024f, -0.10184483f, 
    0.04961295f, -0.05138187f, -0.08846883f, -0.03266234f, 0.06622625f, -0.06900022f, -0.01566051f, 0.04893364f, 
    -0.09013791f, -0.10017905f, -0.04531405f, 0.03599443f, -0.08464722f, 0.03866670f, 0.01685435f, -0.00869375f, 
    0.00314278f, -0.08668899f, 0.00333847f, 0.04454354f, 0.05588238f, 0.01001224f, -0.04587516f, -0.10702669f, 
    0.06083173f, 0.07164969f, -0.07866047f, -0.07798748f, 0.02461207f, -0.03306698f, 0.01925857f, -0.05343723f, 
    -0.04960904f, 0.00648833f, 0.04581512f, 0.01572906f, -0.03442657f, 0.06616975f, 0.01321565f, 0.04970935f, 
    0.03218288f, -0.00273183f, -0.06592132f, -0.08818796f, -0.07464102f, -0.00665606f, -0.09891847f, -0.07325479f, 
    0.05878117f, -0.07361968f, -0.03306280f, -0.08592897f, 0.00746504f, 0.03075005f, -0.03312181f, -0.06392569f, 
    -0.06880759f, 0.04620297f, -0.03455756f, -0.05318337f, -0.04150680f, 0.04864459f, -0.01754051f, 0.07481129f, 
    -0.00664489f, 0.00929855f, -0.00935935f, -0.09259377f, 0.01004015f, -0.07403047f, -0.03557365f, -0.00081031f, 
    0.01170642f, -0.07666610f, 0.02343543f, -0.08255572f, -0.09705235f, 0.01021110f, -0.08793151f, 0.07408202f, 
    -0.00352434f, -0.08297742f, 0.05565758f, -0.04771438f, 0.06927177f, -0.05455326f, 0.08490160f, -0.05618025f, 
    0.04832476f, -0.04872539f, 0.06537862f, -0.02271281f, 0.06147493f, -0.06743942f, 0.09574755f, 0.04927490f, 
    -0.02067331f, -0.00055346f, 0.05529402f, 0.03405515f, -0.04338254f, -0.08465850f, -0.09709764f, 0.04556128f, 
    -0.09870391f, -0.07044609f, -0.05210567f, -0.05172925f, -0.05219177f, -0.06127657f, 0.08457965f, -0.01632532f, 
    -0.03514431f, 0.03141834f, 0.04145811f, -0.18829849f, 0.06021078f, -0.05526257f, 0.33189464f, 0.00834951f, 
    -0.06683131f, -0.03210642f, -0.11179368f, -0.01074363f, -0.01851967f, -0.02548857f, -0.04437600f, -0.42445466f, 
    0.04073814f, 0.01674418f, 0.05603666f, -0.03288567f, -0.00795366f, 0.04460426f, 0.31184614f, -0.30428195f, 
    -0.08217196f, -0.01513490f, 0.10403822f, 0.22526361f, 0.02405324f, -0.01460934f, 0.00334236f, -0.08872794f, 
    -0.40957966f, 0.44000840f, 0.03094883f, 0.30063647f, -0.34162399f, 0.07617158f, 0.11526467f, 0.06917081f, 
    -0.08600949f, -0.01647593f, -0.32434118f, -0.08326191f, 0.39536345f, -0.00827712f, 0.16242048f, 0.04134065f, 
    -0.05236643f, -0.08869528f, -0.11071710f, -0.31970948f, 0.09722990f, 0.10120853f, -0.02423984f, 0.20177202f, 
    -0.35445940f, -0.16101992f, -0.01306088f, 0.01558434f, 0.11523990f, 0.24011733f, 0.09156913f, 0.04096883f, 
    -0.07158650f, -0.15454414f, -0.08131535f, 0.09800193f, 0.14407989f, 0.01113507f, -0.07916304f, 0.10023791f, 
    -0.04407166f, 0.29634070f, -0.11606386f, -0.09636457f, 0.23127767f, -0.23464951f, 0.31942335f, 0.14308563f, 
    0.07606217f, 0.23084420f, -0.13809770f, 0.25062090f, -0.06302123f, 0.03009275f, -0.13022982f, -0.15107478f, 
    -0.02714107f, 0.12496173f, -0.18459518f, 0.07777102f, 0.15656064f, -0.13182263f, -0.05645999f, 0.05177722f, 
    -0.13979818f, -0.03571348f, -0.17285420f, 0.08097517f, 0.02733331f, -0.11819857f, 0.03109253f, 0.12717757f, 
    -0.19610567f, 0.25848407f, 0.11976531f, 0.28216174f, -0.01821857f, -0.04569612f, -0.11213831f, 0.21976547f, 
    -0.05322141f, 0.12590811f, 0.03522513f, -0.04270110f, 0.08697689f, 0.02023712f, 0.09224227f, 0.06741929f, 
    -0.00526806f, -0.12698948f, 0.04734975f, 0.31933257f, 0.09077200f, 0.32573515f, 0.32144451f, 0.00412507f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.01543418f, 0.19235086f, 0.28998491f, -0.05794005f, -0.02057066f, -0.06669293f, -0.05383512f, 0.01275275f, 
    0.18082026f, -0.00707805f, -0.11374387f, -0.18615742f, 0.05702908f, 0.16476546f, -0.09792832f, 0.05237553f, 
    0.06737154f, -0.05484327f, 0.04358505f, 0.04035705f, -0.07265399f, -0.15875407f, 0.13948721f, -0.00689759f, 
    0.06811266f, -0.06893805f, -0.09100805f, 0.02138192f, 0.18238428f, 0.10470758f, 0.15388900f, -0.28943077f, 
    0.06158408f, 0.17330584f, 0.07073142f, -0.10505157f, 0.01320399f, 0.12367168f, 0.16988729f, 0.05709631f, 
    0.00502284f, -0.06647900f, 0.04011263f, 0.09576862f, -0.02088315f, -0.08183149f, 0.11089690f, -0.09768243f, 
    0.21596448f, 0.03782562f, -0.31880194f, 0.01512510f, 0.26405588f, -0.04842052f, 0.02025254f, 0.25775439f, 
    0.21928564f, -0.11362309f, 0.08271315f, -0.05737584f, -0.03114602f, 0.00080274f, -0.10935667f, -0.08849204f, 
    0.10705047f, -0.07111496f, 0.15145433f, 0.14692380f, 0.05849325f, 0.21364924f, -0.06338605f, 0.02511180f, 
    -0.04887881f, 0.10347337f, 0.27188435f, 0.14421982f, -0.10292406f, 0.22820882f, 0.01370031f, 0.14164709f, 
    0.05049551f, 0.01054689f, 0.19224595f, 0.09517147f, 0.03464387f, -0.05444825f, 0.05229580f, 0.15440613f, 
    -0.00064161f, 0.24922302f, 0.02759310f, 0.07382409f, 0.01035649f, 0.28473049f, -0.01726561f, -0.09137628f, 
    0.01125912f, 0.02224052f, 0.00252470f, -0.10385273f, -0.32073495f, 0.13066950f, 0.28975651f, 0.18116280f, 
    0.05378389f, 0.18861426f, -0.04589073f, -0.25724626f, 0.13959767f, 0.04698102f, 0.09533001f, 0.06289464f, 
    -0.11544678f, -0.04160528f, -0.08690901f, -0.05441783f, 0.02581688f, 0.14354099f, 0.12336408f, -0.18152358f, 
    0.09815451f, 0.14587541f, -0.05916720f, -0.07583508f, 0.20817304f, -0.00743327f, 0.03095538f, 0.06345678f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.02188822f, -0.01144869f, -0.39269638f, 0.03731215f, 0.06389520f, -0.09753254f, -0.03943988f, 0.02071532f, 
    -0.07882287f, 0.12561418f, -0.02341816f, -0.82334989f, -0.11455816f, -0.25083867f, -0.08574199f, -0.07016741f, 
    0.18157257f, 0.07845195f, -0.18734890f, 0.03123812f, -0.01831991f, 0.06623774f, 0.04259453f, -0.04147176f, 
    0.06768657f, -0.10502794f, -0.27041391f, -0.05895257f, -0.11646444f, -0.18401831f, 0.04191453f, -0.18532979f, 
    0.19981939f, 0.07958383f, -0.17540018f, 0.01172192f, 0.04471519f, 0.16959845f, -0.03928407f, -0.02867234f, 
    -0.11109275f, -0.35801494f, 0.07378351f, -0.68556535f, -0.56930602f, 0.06308174f, 0.08276974f, 0.29366535f, 
    0.11431077f, -0.25046122f, 0.34002975f, -0.05730891f, -0.01258975f, -0.07643486f, 0.19715892f, -0.01685468f, 
    -0.27036911f, -0.06873010f, -0.11538431f, -0.09658010f, 0.07047002f, 0.20012534f, -0.48741400f, 0.08518029f, 
    0.03354795f, 0.03320979f, 0.18621288f, -0.38497776f, -0.36334160f, 0.17159097f, -0.22166221f, 0.22454572f, 
    -0.07270125f, -0.12008765f, 0.00014461f, 0.15649705f, 0.02592821f, 0.13231286f, 0.05899152f, 0.03475016f, 
    -0.21462253f, -0.09224638f, -0.12634267f, -0.18080707f, 0.02894609f, -0.01761449f, -0.21411961f, 0.12791072f, 
    -0.25714386f, 0.11719747f, -0.44713467f, 0.23298086f, 0.13961753f, 0.22439542f, 0.20626727f, -0.04697031f, 
    -0.39760807f, -0.04874381f, -0.51225179f, -0.16374148f, -0.43340611f, -0.31576306f, -0.04770795f, 0.26417443f, 
    0.15894583f, -0.01157872f, -0.33649808f, -0.79332054f, 0.24021031f, 0.16335237f, 0.13873290f, -0.09119388f, 
    -0.44456291f, -0.38330284f, 0.06647122f, 0.04066994f, -0.08557064f, 0.19418214f, 0.07925075f, -0.17043062f, 
    -0.47487190f, 0.14984912f, 0.01990071f, -0.02754626f, 0.18394764f, 0.03451336f, -0.00752657f, -0.54046887f, 
    -0.02928066f, 0.10732094f, -0.31550899f, -0.00037255f, 0.02433294f, -0.04687482f, -0.06891835f, -0.15522160f, 
    0.17492378f, 0.12212432f, -0.05058477f, 0.23144785f, -0.22841398f, -0.13059291f, -0.05345687f, -0.07707068f, 
    0.15561213f, -0.04009746f, 0.05468575f, -0.04249884f, 0.02428204f, -0.16337571f, -0.21351683f, 0.02231277f, 
    -0.39504451f, 0.06539754f, 0.37932226f, -0.04072623f, 0.07165457f, 0.22168136f, 0.13903509f, -0.62219882f, 
    -0.40398911f, 0.11412986f, -0.14702003f, 0.06900428f, -0.01301218f, -0.01709317f, 0.18417555f, -0.00293515f, 
    -0.19925427f, -0.32003495f, 0.02040062f, -0.04610949f, -0.01555637f, 0.01460987f, 0.12131730f, 0.07416706f, 
    -0.05101642f, 0.05612756f, 0.02246024f, -0.05790039f, -0.27718982f, -0.65320683f, -0.15617347f, -0.06034262f, 
    0.19629624f, -0.05468334f, 0.27233827f, 0.05770829f, 0.03858847f, 0.24737458f, -0.18424454f, 0.06419003f, 
    0.17467254f, 0.00701657f, 0.13787743f, -0.04380500f, -0.12711377f, 0.12058738f, -0.30444428f, 0.17084683f, 
    -0.05854458f, -0.14643125f, -0.08875737f, -0.29100463f, -0.03590287f, -0.01696824f, 0.01039343f, 0.11605123f, 
    0.20313832f, -0.24347976f, 0.11368431f, -0.36652872f, -0.01581170f, -0.21181837f, -0.33507991f, 0.07583536f, 
    -0.39212918f, 0.06843792f, -0.23640464f, -0.44407299f, -0.00059781f, 0.21173021f, 0.09208309f, 0.05287783f, 
    0.11986108f, -0.07132384f, -0.22107401f, -0.01080547f, 0.34234571f, -0.17835496f, -0.23567101f, -0.22727834f, 
    0.14227313f, -0.15576555f, 0.04385779f, 0.41053921f, -0.03796035f, 0.08942547f, 0.02482934f, -0.00590066f, 
    0.52720928f, -0.33785343f, -0.08637062f, -0.06326926f, -0.04228226f, 0.03451549f, 0.13706407f, -0.12194638f, 
    0.06905703f, -0.08300943f, -0.10763218f, -0.02722459f, -0.26604038f, 0.06049475f, 0.04054313f, 0.09847103f, 
    0.01094226f, 0.08790050f, 0.37271547f, -0.02546577f, -0.00048850f, 0.02523841f, -0.03938687f, 0.23534358f, 
    -0.10049329f, -0.41323775f, 0.01981422f, 0.19535300f, -0.26820773f, 0.33406439f, 0.01284140f, -0.02931166f, 
    -0.36555609f, 0.02568180f, -0.07512558f, 0.01575658f, -0.06018495f, 0.00729067f, 0.01008965f, -0.02663580f, 
    -0.29413176f, -0.48293969f, -0.31120405f, 0.02774399f, -0.13997327f, 0.01350139f, 0.04405491f, -0.53979725f, 
    -0.69922411f, 0.10063899f, -0.36575165f, -0.03482446f, 0.02796395f, -0.83551496f, -0.30114719f, 0.05617863f, 
    0.22602440f, 0.04670935f, 0.14524904f, -0.12652165f, -0.26848996f, 0.05947894f, 0.01305192f, -0.35251427f, 
    -0.17046559f, -0.15531422f, 0.03728520f, -0.02514884f, 0.25973079f, -0.33602706f, -0.23408017f, -0.01285454f, 
    0.02116037f, 0.05489287f, -0.29265249f, -0.05695126f, 0.11648343f, 0.13245985f, 0.18424124f, -0.06647043f, 
    -0.18634203f, -0.07115225f, 0.11480581f, -0.02517825f, -0.10622646f, 0.01154711f, -0.29536718f, 0.12257642f, 
    -0.03063201f, -0.04055906f, 0.11877634f, -0.36459982f, 0.04957193f, -0.18689877f, -0.08312662f, 0.05326698f, 
    0.17364356f, -0.31049255f, 0.19765235f, -0.26563615f, 0.01251560f, -0.01851051f, -0.30887687f, -0.46957952f, 
    0.31999576f, 0.13282889f, 0.20411378f, -0.31436411f, 0.34890676f, -0.05280293f, -0.43399748f, -0.01230148f, 
    0.11956052f, -0.00602244f, 0.53184623f, 0.21390560f, -0.74967158f, -0.04268171f, -0.94181389f, 0.09109184f, 
    -0.49563280f, 0.10936627f, -0.10674261f, -0.66203552f, -0.41846859f, 0.03675352f, 0.04872993f, -0.04965807f, 
    -0.27978215f, -0.18977241f, -0.12405997f, -0.00163533f, -0.08335844f, -0.13400249f, -0.22424598f, 0.02215039f, 
    0.06934832f, -0.50659674f, -0.72507948f, -0.05455695f, -0.21485882f, 0.07362510f, -0.09296114f, -0.03495152f, 
    0.02435109f, 0.00970825f, 0.05591119f, -0.01744608f, -0.03402159f, 0.02735219f, 0.00515819f, -0.61924064f, 
    -0.67427576f, 0.03823484f, 0.07339798f, -0.10164048f, -0.11359644f, -0.73575211f, 0.01672322f, -0.00615755f, 
    0.13524756f, -0.00086343f, 0.10050748f, -0.05529089f, 0.04821043f, -0.00870126f, 0.08438035f, 0.01340638f, 
    0.06597430f, 0.10042372f, 0.15853886f, -0.05267582f, -0.01985048f, 0.17087960f, -0.83673352f, 0.03918952f, 
    -0.05438165f, -0.50349498f, 0.10905025f, 0.05838524f, -0.08228927f, -0.14896470f, -0.00325866f, 0.02053230f, 
    0.10722842f, -0.44277290f, -0.56784582f, -0.00921504f, 0.01984223f, -0.01634877f, 0.21351482f, 0.10133346f, 
    0.06766143f, 0.19734018f, -0.07549427f, -0.00671753f, -0.00433364f, -0.20592555f, -0.10362919f, -0.25017431f, 
    0.03903300f, 0.03189238f, -0.99327159f, -0.08852722f, -0.00128567f, -0.29262477f, -0.00099463f, 0.02248862f, 
    -0.60191792f, 0.00745805f, -0.29422414f, 0.23054136f, -0.00027242f, -0.27775741f, 0.12511930f, -0.21280575f, 
    -0.00641141f, -0.06861389f, 0.12319238f, -0.23717654f, -0.07542792f, 0.07338379f, -0.04376597f, -0.16889106f, 
    -0.08207184f, -0.02776968f, -0.62649167f, -0.29807195f, 0.07928118f, 0.17845678f, 0.22830060f, -0.28070858f, 
    -0.71494001f, -0.32411423f, 0.21707681f, 0.14299922f, 0.04411006f, -0.32115051f, 0.08930767f, 0.01496532f, 
    -0.21763603f, -0.04234644f, 0.23565087f, 0.18647705f, -0.22953726f, 0.24663374f, -0.02003416f, -0.33661637f, 
    -0.28085166f, -0.01824775f, 0.07137515f, 0.06974339f, -0.11434840f, -0.34946820f, -0.18413839f, 0.08546118f, 
    0.11970764f, 0.21664704f, 0.02819424f, -0.08783796f, -0.00120351f, 0.02087826f, 0.19084325f, 0.30271000f, 
    0.01186780f, -0.18890339f, -0.16179018f, -0.05330520f, 0.00585676f, 0.20540772f, -0.02706862f, -0.17562141f, 
    -0.08874462f, 0.02724597f, 0.06236691f, 0.06306576f, 0.05957644f, -0.05134405f, -0.06766579f, 0.04405617f, 
    -0.39867693f, -0.06637388f, 0.03008494f, -0.52545065f, -0.09704912f, 0.00302242f, 0.02047094f, -0.03524658f, 
    0.00399362f, -0.08649014f, 0.19891623f, -0.04405339f, -0.06348632f, 0.17064567f, 0.17554751f, -0.05417116f, 
    0.21444814f, -0.12392234f, -0.11174060f, -0.08194868f, -0.63446712f, -0.62483907f, 0.04597826f, -0.33646032f, 
    -0.11257793f, 0.10088057f, -0.03187187f, -0.00646671f, 0.03539281f, -0.08684028f, -0.48886800f, 0.07309089f, 
    0.25294536f, -0.41740811f, 0.04210678f, 0.13400011f, 0.34076941f, 0.01215111f, -0.29316762f, -0.13821492f, 
    0.09284509f, 0.06024602f, -0.26767221f, -0.05731070f, 0.02147359f, -0.58554536f, 0.20507294f, 0.27530387f, 
    0.45804095f, 0.06847515f, -0.78763223f, -0.05687663f, -0.17535903f, -0.13675006f, -0.13507865f, 0.04262668f, 
    0.06537523f, 0.01626958f, -0.03834751f, 0.24242532f, -0.19736965f, 0.05078747f, 0.08894559f, -0.38047546f, 
    0.01156291f, -0.10662406f, 0.01540710f, -0.16378836f, -0.08910532f, 0.02375046f, -0.03216424f, 0.10835238f, 
    0.22637618f, -0.14179075f, 0.06384508f, 0.20292605f, 0.06820418f, -0.00955690f, -0.76773286f, 0.03005223f, 
    -0.13557111f, 0.09040476f, 0.04334027f, 0.06156490f, -0.20864545f, -0.55893517f, -0.33422580f, 0.00509521f, 
    -0.12037676f, 0.02568167f, -0.68385339f, -0.44817898f, -0.37947384f, -0.14723001f, 0.19428031f, 0.13685666f, 
    -0.12153952f, 0.01312587f, 0.24582347f, -0.00174560f, 0.06031086f, 0.21501042f, -0.25522998f, -0.01346836f, 
    -0.50259334f, 0.06593196f, -0.01492331f, -0.04907855f, -0.03050065f, 0.01636608f, -0.01410153f, 0.21853273f, 
    -0.05814646f, 0.20137432f, 0.12692511f, -0.03717334f, 0.30825669f, 0.08261018f, 0.08063266f, -0.00098374f, 
    0.00862094f, -0.30955634f, 0.30092698f, -0.02652786f, -0.03918876f, -0.05223412f, 0.08090906f, 0.01804860f, 
    0.18417543f, 0.06119226f, -0.01039544f, 0.28706816f, 0.17585845f, 0.13625742f, 0.02047231f, 0.07011382f, 
    -0.27936897f, 0.03844009f, -0.52106231f, -0.04004318f, -0.06253937f, -0.20290604f, -0.14554082f, 0.05017689f, 
    -0.47256705f, 0.15914463f, 0.00568509f, 0.07616806f, 0.11675229f, 0.20215382f, 0.17873111f, 0.49477768f, 
    0.35206667f, -0.11738206f, 0.60884321f, 0.04913039f, -0.07427572f, 0.15768041f, 0.18479635f, 0.00319796f, 
    -0.44066182f, 0.21354334f, -0.11854469f, 0.10400371f, -0.13727006f, 0.02319009f, -0.19138731f, 0.00494866f, 
    0.02089394f, -0.39333469f, -0.20956898f, 0.07030334f, 0.03993579f, 0.01780644f, -0.13474973f, 0.03815738f, 
    -0.07270514f, 0.06690806f, -0.17135991f, -0.00041205f, -0.27941948f, -0.37324178f, 0.06545380f, -0.05635953f, 
    0.13503525f, -0.08568264f, 0.01270202f, -0.46945217f, 0.23004803f, 0.08403064f, 0.03450364f, -0.12682155f, 
    0.05406170f, 0.03973993f, 0.16543186f, 0.33117121f, -0.05506155f, 0.04198944f, 0.03213714f, 0.06591640f, 
    -0.12190159f, 0.22036099f, 0.22307011f, -0.18556318f, -0.00684819f, -0.29265079f, 0.22790670f, 0.16257784f, 
    -0.20838006f, 0.05272678f, -1.03293788f, 0.24284756f, -0.22874403f, 0.18148431f, -0.36565503f, -0.07201347f, 
    0.08990663f, -0.04802585f, -0.01269944f, -0.38829312f, 0.16933803f, 0.28114220f, 0.43185481f, 0.34701565f, 
    0.07958645f, -0.11246727f, -0.31146109f, -0.31625912f, 0.10692302f, -0.12828435f, 0.15576261f, 0.03066185f, 
    -0.02498809f, -0.11228949f, 0.00384190f, -0.07776971f, 0.03811664f, 0.04476941f, 0.24613672f, -0.39926895f, 
    -0.02927273f, -0.05239860f, 0.05114080f, 0.07073471f, -0.42858937f, -0.09794586f, -0.09123091f, 0.08202716f, 
    -0.05204351f, 0.20846455f, -0.27557668f, 0.03643455f, 0.02821945f, 0.01982876f, -0.07477683f, -0.61990476f, 
    0.24669513f, 0.05990946f, -0.01086132f, -0.33629802f, 0.30502939f, 0.01851782f, 0.02403441f, 0.06815445f, 
    -0.20414445f, 0.03502573f, -0.25128874f, -0.00469708f, -0.04937022f, -0.39439419f, 0.08810294f, -0.06712400f, 
    -0.02811668f, -0.40715095f, -0.12180428f, -0.07695506f, -0.06126897f, 0.02722213f, 0.14392488f, 0.44929755f, 
    -0.21452931f, 0.19023618f, -0.56688118f, 0.03828582f, -0.06659641f, 0.20880082f, 0.00495311f, -0.03958311f, 
    0.07387393f, -0.06562544f, 0.06838297f, 0.10696574f, -0.21257348f, -0.00931627f, 0.10927472f, 0.18334244f, 
    -0.10129507f, 0.11570814f, 0.04000502f, -0.00402480f, -0.22965211f, 0.26756275f, -0.02927894f, 0.03565114f, 
    -0.78479970f, -0.00287695f, 0.26071084f, 0.01044997f, -0.16637158f, 0.14776772f, -0.28935400f, -0.02606340f, 
    0.08931711f, -0.02324654f, 0.01420190f, 0.00261307f, 0.22618806f, 0.22105412f, -0.05225494f, -0.27779761f, 
    -0.02151531f, -0.42842010f, -0.02213779f, -0.06229251f, -0.02273889f, -0.02695751f, -0.04828535f, 0.16362451f, 
    -0.57131380f, -0.31748840f, -0.19443090f, 0.48546439f, -0.09939498f, 0.06817078f, 0.04060326f, -0.04609614f, 
    -0.01851166f, 0.09993751f, -0.07824000f, -0.04771114f, -0.34236723f, -0.34684548f, 0.02211198f, -0.02064352f, 
    0.09021939f, -0.01955155f, -0.15266444f, -0.60257953f, 0.34847599f, 0.25742796f, 0.10128555f, -0.11271676f, 
    -0.34374398f, -0.04745438f, -0.39854556f, -0.47628030f, 0.10528690f, -0.00362311f, 0.09077772f, 0.04116179f, 
    -0.65870243f, 0.30882210f, -0.07267309f, -0.06069048f, -0.09618496f, 0.11007954f, 0.11562653f, -0.04114695f, 
    0.15610494f, 0.11375669f, -0.24732815f, -0.00196927f, -0.22151299f, -0.43175107f, -0.08393256f, -0.03910986f, 
    -0.03416658f, -0.78071016f, -0.65949559f, 0.01440186f, -0.00946969f, 0.01724887f, -0.02187064f, 0.29558998f, 
    0.20019086f, 0.06724509f, 0.01779802f, 0.24522854f, -0.46988922f, -0.30914533f, -0.09683281f, -0.05066552f, 
    -0.05239515f, -0.03144573f, 0.03562241f, -0.00309101f, -0.03314066f, 0.10621467f, -0.14884101f, 0.03901835f, 
    -0.05981373f, 0.21354079f, -0.16630332f, 0.05876776f, -0.17536527f, -0.15863958f, 0.06289988f, 0.12750703f, 
    0.17182341f, -0.06604482f, 0.14424959f, -0.02366709f, -0.06917829f, -0.21380931f, 0.12123083f, 0.02727725f, 
    -0.52859581f, 0.58479232f, 0.14551827f, -0.09871540f, 0.21216342f, 0.03262376f, -0.79466581f, 0.05964710f, 
    0.07543164f, -0.02548672f, 0.14175762f, -0.02388476f, -0.78216141f, -0.31170037f, 0.13145652f, -0.19506302f, 
    0.39555097f, -0.07984968f, 0.24396646f, -0.03814722f, -0.08684861f, -0.21898706f, -0.07091167f, -0.02944272f, 
    0.03609740f, -0.04468636f, 0.05346241f, 0.00310346f, -0.45601386f, 0.04142622f, 0.06606408f, -0.24889664f, 
    -0.00215111f, 0.09108716f, -0.21353535f, -0.39182022f, -0.04431696f, -0.00056424f, -0.00337460f, -0.09872597f, 
    0.22046658f, -0.21152157f, 0.00945216f, 0.52160227f, 0.05186129f, -0.02344630f, 0.23282561f, -0.16338694f, 
    -0.33517841f, -0.12798290f, -0.01455469f, 0.13809949f, 0.00841720f, -0.08656274f, 0.13957769f, 0.02975240f, 
    0.26600486f, 0.05492750f, -0.17459059f, -0.43746856f, 0.08033270f, -0.34182888f, -0.30653644f, -0.21685007f, 
    0.06569414f, -0.24988800f, 0.10763507f, 0.22360283f, -0.22707528f, 0.08978211f, -0.35018489f, -0.12216237f, 
    0.19699830f, -0.31503245f, -0.02764152f, 0.03775596f, -0.04928887f, -0.05169587f, -0.37497115f, -0.13137154f, 
    -0.54781681f, -0.04883225f, 0.49365318f, -0.03693332f, 0.05009012f, 0.13453455f, 0.01058451f, -0.11569734f, 
    0.08598037f, -0.06155363f, -0.29723692f, 0.02253495f, -0.01975574f, -0.05446940f, 0.05454480f, 0.10902649f, 
    0.29512483f, 0.20769964f, 0.00918372f, 0.04469082f, 0.12647213f, -0.13724272f, -0.07384411f, -0.03013913f, 
    -0.04338046f, 0.07858505f, -0.50301760f, -0.00486267f, 0.03436959f, 0.12819283f, -0.67797458f, -0.00776681f, 
    -0.18802521f, -0.19673459f, -0.06879596f, 0.03169073f, 0.22104874f, 0.15542024f, -0.31803480f, -0.18812132f, 
    -0.44655758f, -0.28274354f, 0.06171800f, 0.04379606f, 0.04011887f, -0.02735157f, 0.25400662f, 0.02894946f, 
    -0.37224421f, -0.28284270f, -0.30744132f, 0.16247304f, -0.69462609f, -0.02433851f, 0.03438440f, -0.40768951f, 
    -0.75521034f, -0.05425143f, 0.12922084f, 0.00712006f, -0.06508522f, 0.35531995f, -0.49415210f, -0.74411923f, 
    0.19843382f, 0.00286795f, -0.55231601f, 0.01162213f, 0.05300355f, -0.16266462f, 0.15454479f, 0.01470486f, 
    0.23403963f, 0.03527534f, -0.12955764f, -0.27857485f, 0.16933377f, -0.58473104f, -0.09257814f, -0.17010124f, 
    0.06169798f, 0.07766326f, -0.90186363f, -0.18253399f, 0.01216971f, -0.36241525f, 0.03860940f, -0.10653631f, 
    0.19781883f, -0.14862680f, -0.02473731f, -0.04029102f, 0.00635319f, -0.59529465f, 0.01754053f, 0.19297248f, 
    0.28016946f, -0.15137321f, -0.24359465f, -0.33848479f, -0.33276853f, -0.17126465f, 0.21182682f, -0.01554289f, 
    0.14483558f, -0.06096821f, -0.16163303f, 0.03943421f, -0.06978198f, -0.10028681f, -0.16625984f, 0.14133093f, 
    0.34863874f, -0.04215150f, 0.26331678f, -0.24801074f, -0.35540447f, -0.01328032f, 0.10091473f, 0.07033677f, 
    -0.15947469f, 0.12866245f, -0.06336050f, -0.02798633f, 0.03106719f, -0.63838398f, 0.37473607f, -0.02973110f, 
    -0.05420337f, -0.32538807f, 0.31033781f, 0.05610602f, -0.37272561f, -0.20449139f, 0.01649638f, 0.17899513f, 
    -0.04414014f, 0.00190720f, 0.03094889f, -0.02834293f, -0.06151820f, -0.11693071f, -0.01435379f, 0.12580049f, 
    -0.29064924f, -0.49642867f, -0.06668233f, 0.13489687f, -0.26029631f, 0.19820227f, -0.02994571f, -0.00734634f, 
    -0.34598491f, -0.04005955f, 0.08940189f, -0.08837575f, -0.08879740f, -0.08181269f, -0.10179493f, -0.08499598f, 
    0.16841535f, 0.21537046f, -0.39128098f, -0.04168845f, -0.02099491f, 0.00600988f, 0.16412120f, 0.38005474f, 
    -0.22672571f, 0.09792319f, 0.17342739f, 0.04971202f, -0.05760924f, 0.02312837f, -0.22659589f, -0.08492216f, 
    0.14032869f, -0.44983888f, 0.13956352f, 0.14533749f, -0.09926633f, 0.02585866f, 0.15600376f, -0.16657060f, 
    -0.15803713f, -0.21965209f, -0.03946524f, -0.06953380f, 0.13494153f, 0.27123487f, 0.15022586f, -0.11422044f, 
    -0.18345521f, 0.06289824f, 0.13974364f, -0.00979128f, 0.02443262f, 0.13713452f, 0.15903731f, 0.01268270f, 
    0.12463672f, -0.01602797f, 0.09953022f, -0.24632868f, 0.15728734f, 0.06099021f, 0.10476076f, 0.31592381f, 
    -0.08028372f, 0.05991009f, -0.06596057f, 0.06346944f, -0.00031219f, -0.23085286f, 0.07547517f, -0.08078700f, 
    -0.12192330f, 0.30129242f, -0.14731695f, -0.13997050f, -0.05721920f, -0.06754698f, -0.01660092f, -0.09210110f, 
    0.09112588f, 0.16274928f, 0.14345618f, -0.24145073f, -0.23643470f, 0.21935442f, -0.20259510f, -0.01969448f, 
    0.01265950f, -0.11214428f, -0.08663698f, 0.29161456f, 0.49339917f, -0.15885217f, 0.07736579f, -0.13183519f, 
    0.02822911f, -0.50745583f, -0.46991080f, 0.13941304f, 0.11243337f, 0.18664682f, 0.04085359f, -0.07795186f, 
    0.09569699f, 0.14335527f, 0.00071350f, -0.05247334f, -0.04362918f, 0.03797111f, -0.42964613f, -0.80027002f, 
    -0.05751825f, -0.21943264f, 0.11793216f, 0.00938855f, 0.16646899f, -0.46502930f, 0.04518462f, -0.24005036f, 
    0.01850733f, -0.02443432f, 0.13284323f, 0.01790171f, -0.04549977f, -0.03205788f, 0.01285551f, -0.02787990f, 
    0.26649842f, 0.10963462f, 0.02055084f, -0.15699510f, 0.16224438f, -0.16376737f, 0.01433520f, 0.00547559f, 
    0.15030384f, -0.04087785f, 0.21549474f, 0.02982380f, -0.06629659f, -0.21174504f, -0.11824718f, 0.06807316f, 
    0.12381073f, -0.01726573f, -0.21444647f, -0.01607546f, 0.12546971f, 0.30433968f, -0.28500184f, -0.23165607f, 
    0.13850482f, -0.41751349f, -0.03687770f, 0.06001410f, -0.03605121f, -0.17466791f, 0.14649834f, 0.01770526f, 
    -0.17189217f, -0.01426880f, -0.84990644f, -0.14892441f, -0.13003230f, -0.00752713f, 0.24142103f, -0.48054984f, 
    0.18278967f, 0.11292212f, -0.67736208f, -0.05155614f, 0.07162473f, 0.23902656f, 0.01989844f, 0.08664253f, 
    0.05126578f, 0.04227256f, 0.11835050f, -0.06929570f, 0.10155275f, -0.13693942f, -0.13606071f, 0.03221304f, 
    -0.35195652f, 0.03741321f, 0.06465064f, 0.34075221f, -0.06710441f, -0.63631105f, 0.03735839f, 0.22865304f, 
    -0.00330603f, 0.16774757f, 0.06022749f, 0.16123419f, 0.01472639f, 0.01694218f, -0.03831993f, -0.62666124f, 
    -0.03904984f, -0.05552546f, -0.09236950f, 0.30428314f, -0.03112368f, 0.05231182f, 0.23596041f, 0.00443084f, 
    -0.11610621f, -0.76380265f, -0.18294023f, 0.04293159f, 0.13898045f, 0.30916750f, 0.18138675f, -0.04485581f, 
    0.14389756f, -0.10331899f, 0.05496598f, 0.05480691f, -0.15281250f, 0.15469360f, -0.26851097f, 0.11658050f, 
    -0.09872702f, 0.25446284f, 0.02379494f, -0.23663634f, -0.35454315f, -0.54001051f, 0.01501581f, 0.05100138f, 
    -0.04703102f, -0.18949398f, -0.02330318f, -0.03887406f, 0.07925566f, -0.20301275f, -0.33136585f, 0.07436679f, 
    0.19160733f, 0.12107197f, -0.32676160f, 0.01979013f, 0.16851130f, -0.12347986f, -0.05658200f, 0.10044684f, 
    -0.02405303f, 0.04847364f, 0.12243188f, -0.04067764f, 0.02870176f, -0.05641636f, -0.06512442f, -0.01006148f, 
    -0.28413683f, 0.15462247f, -0.04816609f, 0.08314221f, 0.11729232f, -0.33471325f, -0.09048212f, -0.03215600f, 
    0.08656902f, -0.03116086f, 0.01062608f, -0.03170026f, -0.04657668f, 0.27819538f, 0.00557774f, 0.01413887f, 
    0.07429364f, -0.17094442f, 0.33383641f, -0.02683102f, -0.13850930f, -0.33232468f, -0.36247414f, 0.33488467f, 
    0.03269349f, 0.05178714f, -0.39655155f, -0.08785219f, 0.06379416f, -0.13040233f, 0.05599543f, 0.00843288f, 
    0.06381126f, 0.28350079f, 0.01831068f, 0.14715058f, -0.16099705f, -0.04418957f, -0.20399001f, 0.05102697f, 
    0.05637602f, 0.15521242f, 0.00277564f, 0.01934516f, -0.03206737f, 0.05633118f, -0.21115677f, -0.15989724f, 
    -0.38221803f, 0.02173708f, 0.29010585f, -0.02178065f, 0.08950698f, 0.01458321f, 0.13170688f, -0.00355234f, 
    -0.28679135f, 0.07886442f, -0.43372583f, -0.29824144f, -0.10137736f, -0.08050527f, 0.12850180f, -0.22582407f, 
    0.02325666f, 0.17011847f, 0.00220379f, -0.15598264f, 0.07261370f, 0.02861698f, -0.06975093f, 0.02007031f, 
    -0.05916665f, -0.10377990f, 0.36609748f, -0.34268016f, 0.05478874f, 0.11498386f, -0.15202589f, -0.05096690f, 
    0.40389523f, -0.23279250f, 0.00804120f, -0.00784567f, 0.01502319f, -0.08111784f, 0.04352568f, 0.03449416f, 
    -0.05005561f, -0.00763039f, 0.24051571f, 0.13994776f, 0.05748768f, 0.11744220f, 0.02730335f, -0.34161061f, 
    -0.17522532f, 0.25956368f, 0.07612643f, -0.16156456f, 0.00380831f, -0.16652958f, -0.01163551f, -0.07716169f, 
    -0.19964296f, 0.20754030f, 0.03606690f, -0.03915172f, 0.07242163f, -0.06956907f, -0.18605478f, 0.08092494f, 
    0.05921913f, -0.39249745f, -0.07048415f, -0.08873120f, -0.16934226f, 0.26486775f, -0.01440028f, 0.12030041f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.01911310f, 0.06444187f, -0.03316262f, -0.06268542f, 0.04701183f, 0.12546255f, 0.08549975f, -0.28913701f, 
    -0.16646476f, -0.10919994f, 0.04060186f, -0.08142308f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
