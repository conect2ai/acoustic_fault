#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.45310807f, -0.23869343f, 1.30199718f, -1.42089593f, 0.12474787f, 1.10520649f, 0.35782966f, -0.09922507f, 
    0.06375826f, 0.99868518f, 0.27031255f, -0.27965754f, -1.20304644f, 0.03873406f, 0.14382517f, -0.04501133f, 
    -0.10006184f, 1.15019453f, -1.25584662f, -0.75907838f, -0.93076015f, 1.49526274f, 0.03823119f, 0.06075516f, 
    -0.64253861f, -0.72783875f, -0.45186055f, -0.69407696f, 0.82187808f, -0.40050215f, -0.92893231f, -1.05665934f, 
    -0.94128567f, 0.37782112f, 0.18836564f, 0.70492029f, 1.22996771f, 0.70770448f, 0.43261051f, -0.33141014f, 
    0.26444447f, -0.45124108f, 0.46019250f, -0.27710944f, 0.48089975f, 0.60234535f, 0.64579254f, 0.53589988f, 
    0.50627005f, 0.15860555f, 0.34926513f, -0.65947694f, -1.31859255f, -0.46447983f, 1.73814404f, 0.18704396f, 
    -0.66831475f, -0.29884058f, -0.26201063f, -0.09507481f, -0.45526382f, 0.50242680f, -0.10742832f, -1.07404339f, 
    -0.54823279f, -0.70231414f, -0.72127509f, -0.27784899f, -1.52806365f, 0.53332931f, 0.21053310f, -0.02790032f, 
    0.68537253f, -1.34205222f, -0.63456702f, -0.70158309f, -0.48062605f, 0.81815243f, -0.24433625f, 0.09240378f, 
    -0.41417563f, 0.33077508f, -0.47752208f, -0.85540241f, 0.77289933f, 0.56179363f, 0.43018416f, -0.62229615f, 
    1.61318743f, -0.97057027f, 0.58980399f, 0.81817943f, 0.64605266f, 0.90487576f, -0.91827106f, -1.05706632f, 
    0.08173541f, 0.07497866f, -0.04820065f, -1.62974918f, -0.38204572f, 0.99976736f, 0.76938105f, 0.77712429f, 
    0.90160930f, 0.53607613f, 0.65082699f, -0.17157634f, 0.63820869f, 0.65619808f, -0.11133362f, -0.18304002f, 
    0.58975625f, 0.14075534f, 0.76780885f, 0.51360011f, 0.90556824f, 1.52780330f, -2.02155662f, 0.64442742f, 
    -0.47449946f, -0.66546315f, -0.72909951f, -0.14931479f, -0.30443099f, -0.35940593f, -1.15334606f, 0.98853648f, 
    -1.30623055f, -0.28241673f, 0.33517620f, 0.08640944f, 0.64282113f, 0.62852901f, 0.56980711f, -1.41918278f, 
    -0.72928637f, 0.44931427f, -0.23877010f, -0.86778694f, -0.71176982f, -0.51590222f, -0.25245684f, -0.74955547f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.41425124f, 0.55480987f, -0.13086613f, 0.40045398f, 0.39809880f, 0.58731008f, 0.50610036f, -0.55988830f, 
    0.78679222f, 0.81068850f, 0.52097178f, -0.05683466f, 0.28772977f, 0.14351712f, 0.44882604f, -0.62331831f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.17126516f, -0.23642968f, -0.12461358f, 0.04436086f, 0.02965818f, -0.13172209f, -0.17695132f, -0.10474300f, 
    0.07283515f, -0.12570800f, -0.23171781f, 0.01523862f, -0.04683658f, 0.16930646f, -0.07680029f, -0.02777040f, 
    -0.13450389f, 0.15043163f, 0.09782068f, 0.16443509f, 0.14314361f, -0.04079951f, 0.16103488f, 0.11462023f, 
    -0.38949844f, -0.12836385f, -0.11872853f, 0.07325073f, 0.37272921f, 0.37316930f, 0.17642550f, 0.26177090f, 
    0.15988673f, 0.11508594f, 0.16835909f, 0.03178199f, 0.10279386f, 0.02015805f, 0.06355181f, 0.07175729f, 
    0.09415758f, 0.07695065f, 0.13671595f, 0.03109615f, 0.03691038f, -0.02619940f, -0.29938501f, -0.03989751f, 
    0.16887142f, -0.06926242f, 0.12301907f, -0.25649625f, -0.14609872f, -0.53008211f, -0.09498172f, 0.08678201f, 
    -0.43899706f, 0.01402869f, 0.11761722f, -0.05328713f, 0.05053537f, -0.21387829f, 0.16040885f, 0.19816558f, 
    0.61273813f, 0.54169995f, -0.10683437f, -0.06224649f, 0.12566204f, 0.08535815f, 0.09367623f, 0.19578321f, 
    0.26402050f, 0.13717206f, -0.12539409f, -0.02475580f, -0.19301072f, 0.05842680f, -0.07808909f, -0.08289973f, 
    -0.09273249f, -0.13815804f, -0.02353190f, -0.29129422f, 0.19287392f, 0.36918110f, -0.01966240f, -0.07273013f, 
    0.00406804f, -0.24809822f, 0.00546570f, -0.46430227f, -0.25038141f, 0.01890071f, -0.08355486f, 0.15066426f, 
    0.23236367f, 0.03265655f, -0.13798812f, 0.13888121f, 0.06367714f, 0.17755534f, 0.38433826f, 0.00454943f, 
    -0.17986004f, 0.05221598f, 0.04025766f, -0.07583517f, -0.09207739f, 0.05840468f, 0.11098167f, -0.01638801f, 
    0.09827321f, -0.13089482f, -0.13003281f, 0.16553381f, 0.22462791f, 0.67046493f, 0.66527295f, -0.10476344f, 
    0.34855247f, 0.14010097f, 0.01998504f, -0.10550708f, -0.10957425f, -0.39594853f, -0.11103091f, 0.20453896f, 
    0.19031659f, -0.11413892f, -0.34712240f, -0.01812606f, 0.03859131f, 0.27508414f, 0.08230908f, 0.25227731f, 
    0.22870828f, 0.34442839f, -0.11461603f, -0.15019594f, 0.03333404f, 0.13306151f, -0.07849359f, -0.80306828f, 
    -0.13950869f, -0.32840976f, -0.10929840f, -0.10806971f, -0.09674759f, 0.21560608f, 0.21257225f, 0.19486631f, 
    0.01676966f, 0.02352346f, -0.07382586f, -0.20627645f, 0.06523158f, -0.09544662f, -0.38821745f, 0.11032856f, 
    -0.08274079f, 0.15492675f, -1.02991188f, 0.29318085f, 0.20702592f, -0.20237528f, -0.01445238f, 0.16361950f, 
    0.07145227f, 0.04114280f, 0.16180265f, -0.26848802f, -0.22991310f, -0.30022094f, -0.31888053f, -0.06764361f, 
    -0.19801441f, 0.01701114f, -0.08166757f, -0.20971669f, 0.48396659f, 0.00714674f, 0.17377977f, 0.34000474f, 
    0.02456011f, -0.15141821f, -0.13464031f, -0.15686403f, -0.03479662f, 0.56179553f, 0.03876072f, -0.01622041f, 
    0.27486694f, -0.13171256f, -0.01315897f, 0.03767067f, 0.05521023f, 0.15315218f, 0.49990702f, -0.28877139f, 
    -0.39018971f, 0.07030224f, 0.03932365f, -0.05554849f, 0.05778453f, -0.00906198f, 0.07186903f, -0.31245106f, 
    -0.08458115f, 0.23942509f, 0.03098978f, 0.25628391f, -0.42070416f, 0.02600294f, 0.10506532f, -0.12905931f, 
    0.29544476f, -0.00690546f, -0.02144047f, 0.14741895f, 0.20870484f, 0.04255008f, 0.15690127f, -0.02911226f, 
    0.09496693f, -0.19391349f, -0.35529658f, -0.13010062f, 0.18819532f, -0.07260462f, 0.00682734f, 0.29692799f, 
    -0.16954650f, 0.33445552f, 0.40027818f, -0.27071583f, -0.02987436f, 0.07663833f, 0.02932187f, 0.23651171f, 
    -0.04259061f, 0.18331386f, 0.04873621f, -0.48576441f, -0.13039440f, 0.18908632f, 0.13086343f, 0.02016426f, 
    0.15758930f, 0.26393348f, -0.09541495f, -0.04823504f, 0.41723856f, 0.20734002f, 0.29967034f, 0.10075663f, 
    0.10085935f, -0.04992791f, -0.10290790f, 0.04068349f, -0.16985486f, 0.80161190f, -0.38403425f, -0.47970170f, 
    0.14210875f, -0.01008350f, 0.13540746f, -0.20018624f, -0.09421898f, 0.05419178f, -0.20907566f, 0.15935358f, 
    -0.11719806f, 0.00159625f, -0.40456456f, -0.00535972f, -0.06872211f, -0.01221340f, -0.40577564f, -0.32012948f, 
    0.06744365f, 0.49081492f, 0.01512133f, 0.05167049f, 0.16356611f, 0.04320768f, 0.06833949f, 0.01062350f, 
    0.63155764f, 0.02269025f, -0.10664037f, -0.15774690f, 0.11562437f, 0.16416775f, 0.03440779f, -0.06867167f, 
    -0.00070032f, 0.70309770f, 0.40284717f, -0.36942568f, 0.03859698f, 0.11795906f, -0.13062719f, 0.12817712f, 
    0.04467517f, -0.16195932f, -0.40477243f, -1.05540681f, -0.53379959f, -0.02030267f, 0.35650745f, 0.10740031f, 
    -0.11079067f, -0.20575793f, 0.25999707f, -0.66732341f, -0.33357003f, -0.78052217f, -0.16623446f, -0.20934370f, 
    -0.11265489f, 0.23542705f, 0.15524168f, 0.02204434f, 0.46556050f, 0.33053571f, -0.09635472f, 0.01250716f, 
    -0.07817286f, -0.04317375f, -0.10188794f, 0.03123596f, -0.20359181f, -0.36030149f, 0.36509639f, 0.12280557f, 
    -0.35692340f, -0.21236576f, -0.08140925f, -0.10228604f, 0.02490367f, 0.24778993f, 0.34500423f, -0.00387962f, 
    0.18940933f, -0.02690491f, -0.10368367f, 0.16427536f, -0.17174506f, 0.13793989f, 0.08806837f, 0.14729513f, 
    0.03780412f, -0.24701223f, -0.09678093f, 0.13543814f, -0.69982386f, 0.03949732f, 0.03975809f, -0.07111599f, 
    0.16482909f, 0.41616157f, -0.18655291f, -0.07223839f, 0.24653420f, 0.36141875f, 0.22239250f, 0.16679940f, 
    0.12606695f, 0.15162189f, 0.19263037f, 0.42699170f, 0.04532474f, 0.03305986f, 0.12247039f, 0.04041232f, 
    0.19767410f, 0.31171355f, 0.28528363f, 0.23012953f, 0.00086118f, -0.17949356f, -0.14558871f, 0.01730758f, 
    0.13548410f, -0.04452116f, 0.08186030f, -0.73990446f, -0.19116206f, -0.28944927f, -0.21333206f, 0.02942630f, 
    0.12513213f, 0.07574741f, -0.03739249f, 0.10126920f, 0.16554765f, 0.17262572f, -0.34662977f, -0.01795309f, 
    0.08757684f, 0.09392561f, 0.06436139f, -0.16414402f, 0.04783553f, -0.06406845f, -0.64568239f, -0.53352267f, 
    -0.38776872f, 0.06557317f, 0.06715754f, -0.15045659f, -0.01271552f, -0.13775514f, -0.56201577f, -0.32886556f, 
    -0.18958341f, 0.09831713f, 0.16318779f, 0.11544677f, 0.15580203f, -0.21933840f, -0.34001017f, 0.46367958f, 
    -0.02108092f, -0.05825724f, -0.57497430f, -0.07047758f, 0.01947522f, 0.03523475f, 0.06420248f, 0.09251552f, 
    0.06061653f, -0.04331153f, -0.03401997f, 0.05670673f, 0.00618831f, 0.06941394f, 0.01901120f, 0.02370473f, 
    -0.02119418f, -0.07774527f, -0.03484466f, -0.06593075f, 0.04500242f, 0.02874517f, -0.01545772f, -0.02048895f, 
    0.05332763f, -0.05214930f, 0.03251244f, 0.01157957f, 0.07114046f, -0.03707847f, 0.05998353f, 0.06074462f, 
    0.01903380f, -0.08697485f, 0.05803537f, 0.01563380f, -0.02153257f, -0.06214532f, -0.05624263f, -0.07466741f, 
    -0.03293239f, 0.02394657f, -0.04645945f, -0.08979017f, -0.06893469f, -0.05271028f, -0.04820626f, -0.06027604f, 
    -0.03718584f, -0.01903029f, -0.04088586f, -0.04059056f, 0.02256611f, 0.06538469f, 0.07067191f, -0.09501321f, 
    0.05080412f, 0.04709543f, -0.08893810f, 0.00948658f, 0.04927916f, -0.07814182f, -0.07030644f, -0.09169349f, 
    0.05495685f, -0.03414559f, 0.02489819f, 0.04267864f, -0.07202000f, 0.03470416f, -0.01672979f, -0.02876337f, 
    -0.09110747f, -0.00882004f, 0.06165163f, 0.06662077f, 0.03583859f, -0.04421734f, -0.07144370f, -0.09704570f, 
    -0.01891731f, -0.00817961f, -0.03997435f, 0.01121198f, 0.03060141f, -0.07117734f, 0.03285006f, -0.02710909f, 
    -0.03918756f, -0.06095926f, -0.04633304f, -0.02423371f, -0.07055441f, -0.09027094f, -0.00974916f, 0.03788896f, 
    -0.07429019f, -0.06728353f, 0.06202926f, -0.02983614f, 0.00677549f, -0.04824768f, -0.04370990f, 0.03535302f, 
    0.06582394f, -0.03475028f, -0.05729657f, -0.03904242f, 0.06777807f, -0.05456368f, -0.02185620f, -0.01255406f, 
    -0.01677296f, -0.06331436f, 0.00571286f, -0.03166990f, -0.08120526f, -0.02607731f, -0.09104364f, 0.05034042f, 
    -0.00607266f, -0.01677824f, -0.07396085f, -0.07732849f, -0.02005965f, 0.03878127f, 0.06264316f, -0.03185223f, 
    0.07395801f, -0.04789636f, 0.01780463f, -0.04717444f, -0.00149200f, -0.07319918f, -0.03389958f, -0.05041265f, 
    0.04824146f, 0.05039167f, -0.06080368f, -0.04694493f, -0.07412674f, 0.06177592f, -0.05452300f, -0.00001537f, 
    -0.08672708f, -0.03554532f, -0.01974157f, 0.05246190f, 0.02949148f, 0.04846767f, -0.03467928f, 0.02734958f, 
    -0.28334612f, -0.66051394f, -0.05551815f, -0.16534697f, 0.11966735f, -0.21319483f, 0.20254765f, 0.03901307f, 
    0.08259327f, 0.27107564f, 0.01615884f, -0.09363662f, 0.07393414f, -0.01450102f, 0.00371918f, 0.00489890f, 
    0.14617929f, 0.33110353f, 0.74361002f, 0.35908565f, 0.72331703f, -0.12188730f, -0.11933140f, 0.15633900f, 
    0.40239313f, 0.13434601f, -0.12536992f, 0.19447266f, 0.03422557f, 0.28131846f, -0.23343141f, -0.48761082f, 
    -0.17450742f, -0.20025809f, 0.26301119f, 0.22005777f, 0.07429922f, -0.58890212f, 0.01997787f, -0.13177502f, 
    -0.08791963f, 0.08142011f, -0.18579435f, 0.13447821f, 0.06107121f, 0.12791622f, 0.07151263f, 0.00253048f, 
    -0.04899406f, -0.09209401f, 0.03731184f, 0.31285480f, 0.04706478f, -0.29182163f, 0.27631783f, -0.07503888f, 
    -0.46486440f, -0.15881133f, -0.10972632f, 0.03366350f, 0.08653480f, 0.02868302f, 0.01227930f, 0.25386280f, 
    0.43545216f, 0.52451313f, -0.44254899f, -0.02069662f, -0.08597586f, 0.16105583f, -0.13779175f, -0.01541385f, 
    0.52108252f, 0.16786811f, 0.18277395f, -0.12792152f, -0.05415126f, 0.12334665f, 0.13554892f, 0.06568050f, 
    -0.32259238f, 0.87309349f, -0.61934525f, -0.29437259f, -0.12552086f, 0.13041446f, -0.08756422f, 0.19303899f, 
    -0.14699474f, -0.27705395f, -0.36016905f, -0.82976800f, -0.22536765f, -0.08581501f, -0.06214662f, 0.07392193f, 
    -0.19406098f, -0.02112269f, 0.02977875f, -0.88831997f, -0.80737132f, -0.63719338f, -0.33487982f, 0.13422568f, 
    0.18105370f, -0.11990436f, 0.34970006f, 0.05495337f, 0.45189410f, 0.05633947f, -0.04452059f, 0.18014446f, 
    0.01085507f, 0.03669963f, 0.14005427f, 0.10320710f, 0.09635747f, -0.21550569f, -0.31349823f, -0.67223865f, 
    -0.47645321f, 0.19516510f, -0.30462742f, 0.08175017f, 0.01950831f, 0.02292367f, -0.34502089f, -0.62979144f, 
    -0.60436875f, 0.12219138f, 0.14459015f, 0.16951543f, -0.11505517f, 0.41246048f, -0.05237000f, 0.65057689f, 
    0.20190364f, -0.03323618f, -0.08475705f, -0.04849445f, -0.05178232f, 0.16174549f, 0.23767661f, -0.28617465f, 
    0.21497488f, 0.24970910f, 0.44152215f, 0.02558699f, -0.02739037f, -0.31850290f, 0.12525935f, 0.14825536f, 
    -0.03396148f, 0.08113297f, 0.11288977f, 0.29047626f, 0.19141355f, 0.30356023f, -0.07655949f, 0.02125179f, 
    -0.02659271f, 0.13860273f, -0.90298456f, -1.03167498f, -1.04258347f, -0.04652742f, -0.15615942f, 0.00784419f, 
    -0.18140973f, -0.25423396f, -0.01961830f, -0.71326518f, -0.17984198f, 0.09502866f, 0.17798369f, 0.05428504f, 
    -0.04641188f, -0.09946499f, -0.03525976f, 0.05184054f, 0.37097031f, 0.26107562f, 0.09055132f, -0.05784031f, 
    -0.14188565f, -0.03712286f, -0.02246222f, 0.15367959f, 0.07069013f, 0.11305457f, 0.01440728f, 0.31873706f, 
    0.04804276f, 0.10279579f, -0.19370073f, -0.07118735f, 0.03911238f, 0.30462307f, 0.39797342f, -0.12273773f, 
    0.32140326f, -0.14851794f, 0.09778179f, 0.22756603f, 0.06185365f, 0.08686172f, 0.00255624f, -0.16022250f, 
    0.30528262f, 0.18985961f, 0.04280551f, -0.19156434f, -0.04170963f, -0.03031822f, 0.01145947f, -0.23377427f, 
    -0.32297778f, -0.53616232f, -0.02424311f, 0.00372457f, 0.41528115f, 0.03016561f, 0.19481546f, 0.21530408f, 
    -0.10475853f, 0.10639595f, -0.27955571f, -0.27369744f, -0.22218798f, -0.07098145f, -0.13639587f, -0.33859205f, 
    -0.23392801f, 0.23831502f, 0.27736372f, 0.35264319f, 0.13732426f, -0.19045779f, -0.25258049f, 0.03904141f, 
    0.00733625f, 0.30723014f, 0.03033358f, 0.26995713f, -0.25312760f, -0.47474852f, 0.01543988f, -0.09166338f, 
    0.00806174f, -0.05695228f, -0.18355797f, -0.30960962f, 0.12117853f, 0.08062955f, 0.07087428f, 0.18647048f, 
    0.12144806f, -0.03931968f, -0.12974483f, 0.10247951f, -0.04103795f, -0.65358275f, 0.11269850f, -0.27836084f, 
    0.05557621f, 0.22416079f, 0.23530221f, -0.03232634f, 0.00388669f, 0.01923609f, -0.19975390f, -0.53931725f, 
    -0.27549917f, 0.00879004f, -0.01084246f, 0.03608681f, 0.15453468f, 0.04141201f, 0.09091649f, -0.55606496f, 
    -0.38569248f, 0.04915318f, 0.26493785f, -0.01811372f, 0.53695577f, 0.09296834f, -0.02253909f, -0.14866060f, 
    -0.43718240f, -0.82444268f, 0.07834337f, -0.11068378f, -0.02699178f, -0.16653222f, 0.20016225f, 0.09513763f, 
    -0.14360937f, 0.80315214f, -0.29586729f, -0.09550238f, -0.17962724f, 0.10088095f, 0.03493132f, 0.05893566f, 
    0.03868132f, 0.01448113f, -0.12781455f, -0.32955915f, -0.29977643f, 0.02581483f, -0.40775546f, 0.11442464f, 
    -0.13362123f, 0.15816413f, 0.10553745f, 0.70562875f, -0.20691633f, -0.15533893f, -0.05444461f, -0.07251769f, 
    -0.12342630f, -0.07944968f, -0.02770472f, -0.00228094f, 0.03199783f, -0.46480042f, -0.14252412f, 0.00636954f, 
    0.00928119f, 0.15804599f, 0.29108441f, -0.24239887f, -0.14299038f, 0.02122765f, 0.00345842f, 0.03108683f, 
    -0.11035429f, 0.02599610f, -0.07715823f, 0.03634632f, 0.12656407f, 0.32468504f, 0.30160341f, -0.10760830f, 
    -0.20759095f, 0.01856786f, 0.25514051f, -0.05764833f, -0.06937069f, -0.06074127f, 0.16783173f, -0.36102381f, 
    0.57239580f, 0.22613508f, -0.19362751f, -0.26520348f, -0.14082758f, 0.05307829f, -0.03058907f, 0.02463554f, 
    -0.50588280f, 0.20748159f, -0.18173781f, -0.13845545f, 0.10727406f, 0.02984050f, 0.18690421f, 0.18541166f, 
    0.03483321f, 0.22013082f, 0.60878479f, -0.28339121f, -0.21315773f, -0.18496898f, 0.00338474f, 0.24836904f, 
    0.16735585f, 0.42119256f, -0.33436999f, 0.09396520f, 0.37967110f, 0.10028733f, 0.05402966f, -0.05187308f, 
    0.12285449f, -0.03583029f, -0.11701285f, -0.01394111f, 0.10188196f, 0.28199497f, -0.43655840f, -0.38168472f, 
    -0.22646879f, 0.03064824f, -0.00107875f, -0.11264625f, 0.31332844f, -0.19686589f, -0.24243423f, -0.10421018f, 
    0.00408460f, 0.18618441f, 0.33731142f, -0.15616880f, 0.09044212f, -0.47270027f, -0.69717604f, -0.37872800f, 
    -0.22881345f, 0.30866417f, 0.08288257f, 0.08102919f, -0.05745021f, -0.14188176f, -0.15097387f, 0.26087219f, 
    -0.22111668f, 0.04710125f, 0.14469437f, -0.10207301f, 0.05544483f, -0.04962715f, 0.17692341f, -0.13170776f, 
    0.38937661f, 0.35942292f, -0.09222569f, -0.01068226f, 0.10885075f, 0.15071709f, 0.15715382f, 0.13508765f, 
    -0.29693750f, -0.94020951f, 0.19379269f, -0.28670335f, -0.04280485f, -0.26255473f, -0.03740130f, 0.05726939f, 
    0.03323643f, 0.03081911f, -0.47889453f, 0.14462171f, 0.01309570f, 0.26085255f, 0.09163164f, -0.35244599f, 
    0.11874891f, -0.12721621f, -0.56427908f, -0.09281434f, 0.42557266f, 0.18158512f, -0.07016990f, -0.11267993f, 
    0.10691140f, 0.15098347f, -0.24614881f, -0.15035303f, -0.41468352f, 0.13374336f, -0.09628318f, -0.18046995f, 
    0.07030321f, -0.01773504f, 0.02582777f, 0.18138443f, -0.46616644f, -0.06705953f, 0.13759182f, -0.12920560f, 
    0.13439779f, 0.06767871f, -0.22949578f, 0.34196278f, -0.06261187f, 0.21441935f, -0.04525081f, -0.29796830f, 
    -0.29859793f, 0.15719570f, -0.19125575f, 0.20503461f, -0.03590731f, -0.28375825f, 0.66533577f, 0.29241163f, 
    0.46893290f, 0.09622837f, -0.13012454f, 0.16434759f, -0.02236500f, 0.02230883f, 0.40934989f, -0.68087590f, 
    -0.35750112f, 0.20876102f, -0.12393366f, -0.25981399f, -0.18739000f, 0.11044987f, 0.26609322f, 0.14205804f, 
    0.47352391f, 0.54677135f, 0.10533468f, 0.23340368f, -0.13615325f, -0.10750232f, -0.07401989f, -0.04657070f, 
    0.06299629f, 0.08760905f, 0.21993349f, 0.94734329f, -0.15514097f, -0.01909821f, -0.12171337f, -0.00354153f, 
    -0.04018726f, 0.39800093f, -0.94060236f, -0.12790634f, 0.06865562f, -0.12615617f, -0.12075805f, -0.26978201f, 
    0.13196386f, 0.29097933f, 0.05779384f, 0.00913629f, 0.01675803f, -0.06554116f, -0.39125037f, -0.21552168f, 
    -0.10775606f, -0.08220050f, 0.06552003f, 0.06054324f, -0.15261176f, -0.54647440f, -0.45670539f, -0.17568469f, 
    0.05894154f, -0.27552605f, 0.25437662f, 0.24470034f, 0.10279002f, 0.18199566f, -0.02319742f, 0.19836032f, 
    -0.19258229f, -0.04531297f, 0.08148081f, -0.25474802f, -0.06760553f, -0.09386081f, 0.45341727f, -0.07261518f, 
    0.48439535f, 0.09642641f, 0.31982329f, 0.22761954f, 0.10464794f, 0.14773506f, 0.13688152f, -0.22268449f, 
    -0.01774307f, 0.15887403f, 0.02027548f, -0.06695443f, -0.43678531f, 0.02334342f, 0.13330659f, -0.08835249f, 
    0.28060231f, -0.79923433f, -1.00523520f, 0.09155657f, -0.40390897f, -0.13343534f, -0.02000668f, 0.17703415f, 
    -0.12294060f, 0.36535111f, 0.01375382f, -0.32764560f, -0.13223255f, 0.05197691f, 0.04772611f, 0.02324186f, 
    0.11261702f, -0.01041612f, -0.33101809f, 0.16099316f, 0.15587446f, 0.02537566f, -0.10779792f, -0.03854487f, 
    0.03449111f, 0.02774474f, -0.13437970f, 0.50354320f, -0.14677107f, 0.00201434f, 0.01712044f, -0.04470716f, 
    0.01167347f, -0.13394958f, -0.11433782f, 0.13210215f, -0.15374549f, -0.04159537f, -0.24357691f, 0.20388836f, 
    0.08612801f, 0.19032839f, -0.11557383f, -0.07633470f, 0.05112455f, 0.19521134f, 0.20777124f, 0.13419074f, 
    0.06328589f, 0.09991437f, 0.11822727f, 0.05301101f, 0.14646697f, 0.06973350f, 0.33288422f, 0.45867994f, 
    0.11831611f, -0.01179984f, -0.06644133f, -0.15603583f, 0.16404980f, -0.01318536f, 0.06949043f, -0.24260239f, 
    -0.54631972f, 0.53677934f, 0.09885554f, -0.09244636f, 0.15599449f, -0.14221102f, -0.03584298f, 0.10535921f, 
    0.38531888f, -0.01523648f, 0.13567631f, 0.15027554f, 0.19098130f, -0.07193334f, -0.03822386f, 0.03752558f, 
    -0.14762294f, -0.22490396f, -0.59440070f, -0.02555176f, 0.03961395f, 0.09847348f, -0.02194613f, 0.16226643f, 
    0.01519071f, 0.24646516f, -0.67570692f, 0.14798144f, 0.18831038f, -0.22883089f, 0.03105724f, 0.09495979f, 
    0.13523933f, 0.13433738f, 0.12881905f, -0.27507481f, -0.46367216f, -0.13150564f, 0.13733099f, 0.06816889f, 
    0.00627135f, 0.15286314f, -0.14422211f, 0.17995033f, 0.06171625f, -0.00150380f, -0.05571072f, -0.17242177f, 
    -0.03357576f, -0.02134285f, -0.08095031f, 0.28952119f, 0.13462777f, 0.92817938f, -0.14228900f, -0.43452069f, 
    0.18848108f, 0.08603830f, -0.21447563f, 0.23369840f, 0.02239606f, 0.05067751f, -0.00722703f, -0.33592778f, 
    -0.71422863f, -0.00974650f, -0.15782967f, 0.06095660f, 0.01419614f, -0.08927071f, 0.03122713f, 0.02117094f, 
    -0.14871082f, 0.28181976f, 0.01166898f, -0.22630820f, -0.20433393f, -0.00682851f, 0.25990519f, 0.00159177f, 
    -0.91364324f, 0.08952487f, -0.27172539f, -0.26842460f, -0.17071569f, -0.21393219f, -0.26368418f, 0.06733725f, 
    -0.02090533f, -0.78363603f, 0.45778915f, -0.35810411f, 0.11509150f, -0.07800993f, -0.03247461f, -0.26668531f, 
    -0.03826306f, 0.00971808f, -0.45035979f, -0.19906327f, 0.28726023f, -0.06354854f, -0.02857981f, -0.12347566f, 
    -0.05018292f, 0.01268889f, 0.13620374f, 0.48918423f, 0.82199323f, 0.44208267f, 0.29306096f, 0.26637521f, 
    -0.00140104f, 0.06023215f, 0.06868793f, -0.31322947f, -0.50554138f, 0.26702461f, 0.31517583f, 0.14040887f, 
    0.05688285f, 0.15327765f, -0.08011568f, 0.03098831f, -0.02042820f, -0.32395872f, -0.30299926f, -0.37218413f, 
    -0.05577725f, -0.18098535f, 0.13844182f, 0.24746667f, -0.33542386f, 0.30549240f, -0.48097202f, -0.17832072f, 
    -0.20205519f, -0.12996979f, -0.07944826f, 0.08080760f, 0.12578788f, 0.10134935f, 0.09294766f, 0.51218766f, 
    0.48897621f, 0.49661249f, -0.10671939f, -0.25057009f, -0.16415489f, 0.10108282f, 0.03690261f, 0.24992290f, 
    -0.38801351f, 0.06185393f, -0.39648008f, 0.02983755f, -0.21513185f, 0.18654114f, 0.09527284f, -0.19175170f, 
    0.25495476f, -0.36942959f, 0.28898391f, -0.02020962f, -0.02885132f, 0.03935947f, -0.15523721f, -0.11604300f, 
    0.32967293f, -0.02481390f, -0.34672940f, -0.72711015f, -0.11627728f, -0.01690698f, -0.16573681f, -0.17693008f, 
    -0.04532490f, 0.01662807f, -0.04296700f, -0.02052642f, 0.01629137f, -0.06339687f, -0.17145832f, 0.05882030f, 
    0.05418907f, 0.22410691f, 0.17043042f, -0.08407897f, 0.04337183f, 0.07066113f, 0.05919291f, 0.01629644f, 
    -0.06074328f, 0.19241570f, 0.10426563f, 0.03076708f, 0.11523572f, 0.29254043f, 0.18824273f, 0.16891123f, 
    0.07433281f, 0.19055894f, 0.61827767f, -0.13196379f, -0.27249500f, -0.20781575f, 0.12257718f, -0.00213113f, 
    -0.03503692f, -0.06336568f, 0.16367683f, 0.11104267f, 0.13014208f, 0.15959926f, -0.07350914f, -0.09528396f, 
    0.13410233f, 0.27325073f, 0.09356513f, 0.08627654f, -0.24326795f, 0.20113099f, 0.04500629f, 0.25150463f, 
    0.15754004f, -0.02987987f, -0.07281196f, 0.04269534f, -0.15884693f, 0.02383272f, -0.00903193f, 0.24031068f, 
    0.03438439f, 0.18573631f, -0.34574640f, -0.19291820f, -0.06266195f, 0.10114711f, 0.40361923f, 0.22805576f, 
    0.05376130f, -0.09833571f, 0.17699760f, -0.12389337f, -0.52388531f, -0.25022572f, -0.11637751f, -0.11507983f, 
    0.21526426f, 0.05720280f, -0.00411883f, -0.86728758f, -0.54651421f, 0.12524681f, -0.20772251f, 0.27080867f, 
    0.30900735f, -0.11161478f, -0.09647939f, 0.15962425f, 0.44291818f, -0.34521154f, 0.21652688f, -0.03634429f, 
    0.06458692f, 0.14673942f, -0.01081661f, 0.01534010f, -0.07185274f, 0.07501363f, 0.12069922f, -0.01962871f, 
    0.06809440f, 0.06904354f, -0.10097338f, 0.20148090f, 0.02409499f, 0.28135237f, 0.48953587f, 0.00911945f, 
    -0.74179393f, 0.33780786f, -0.08848301f, 0.15143843f, 0.14417730f, 0.12600663f, 0.05832116f, 0.55019397f, 
    0.32140532f, -0.22038454f, -0.13347332f, -0.03674264f, -0.07009414f, -0.01234184f, 0.22770102f, 0.01022037f, 
    -0.09375554f, -0.25139374f, -1.40510523f, 0.00725526f, 0.21846601f, -0.08730484f, 0.00929247f, 0.05080999f, 
    -0.10889776f, 0.18567540f, -0.23824511f, 0.29128972f, 0.10932981f, -0.01075214f, -0.11824907f, -0.23109262f, 
    0.09172547f, 0.04047478f, 0.16623461f, -0.59923470f, 0.02899682f, -0.16164808f, 0.19279726f, 0.16005044f, 
    0.00071871f, 0.11486637f, 0.29916206f, 0.03268411f, 0.12550640f, 0.20232004f, -0.57572550f, -0.16074197f, 
    -0.34964803f, 0.11129957f, -0.14238480f, -0.06975087f, 0.20011957f, -0.04458402f, -0.03146988f, -0.02058112f, 
    -0.16763514f, 0.06133306f, -0.02493644f, -0.03888348f, 0.01377006f, -0.64189374f, -0.22414753f, -0.74251819f, 
    0.10105325f, 0.31530458f, 0.29601756f, 0.14718400f, -0.08950849f, -0.09924491f, -0.06837532f, 0.11473947f, 
    0.27231717f, -0.20467663f, 0.24949296f, 0.01665559f, 0.09446565f, 0.07090477f, 0.06177836f, 0.19028243f, 
    0.45118260f, -0.10280605f, -0.03737573f, -0.09491054f, -0.25891188f, -0.00176609f, 0.02150146f, 0.16881220f, 
    0.02158712f, 0.23995920f, 0.49342346f, -0.01259023f, 0.08340534f, -0.01676437f, -0.20082612f, 0.12486121f, 
    0.26885518f, -0.32864782f, -0.16484712f, 0.13595605f, 0.10230278f, 0.14123093f, 0.10553828f, 0.20312545f, 
    0.18998624f, 0.10184702f, -0.22406103f, -0.30741289f, -0.11416250f, -0.22615278f, -0.22500145f, -0.16079459f, 
    -0.15094157f, -0.38435802f, -0.39328486f, -0.17762370f, 0.01661885f, -0.31414378f, 0.33697790f, 0.18587831f, 
    0.24347669f, 0.29874760f, 0.43138975f, 0.33850840f, -0.24018307f, 0.11214095f, 0.13791002f, -0.19135654f, 
    -0.40556556f, -0.05286165f, 0.27204052f, 0.15328853f, 0.01061502f, -0.26950428f, 0.16673881f, 0.02763010f, 
    -0.06941012f, -0.23577358f, -0.02770761f, -0.16212392f, -0.20261005f, -0.39141273f, 0.04428341f, 0.20720272f, 
    0.04665895f, 0.05560701f, 0.04986972f, 0.08009470f, 0.26726267f, 0.28751588f, -0.08689098f, -0.29707271f, 
    -0.25780934f, -0.56254441f, -0.28498876f, -0.04654730f, -0.12641013f, 0.08413662f, 0.24585561f, 0.28546825f, 
    0.30640957f, -0.08159886f, 0.18608053f, 0.19162190f, 0.24821365f, 0.11535397f, -0.16236342f, 0.10073216f, 
    0.13440366f, -0.18863633f, 0.28192815f, 0.32765830f, 0.25914365f, 0.53018391f, -0.25400248f, -0.04351267f, 
    -0.13535365f, 0.07652634f, -0.38188526f, 0.05503196f, -0.18993507f, -0.02365623f, -0.14433581f, -0.25311586f, 
    0.05244982f, 0.01907982f, -0.11860946f, 0.41200027f, -0.00823297f, -0.29936361f, 0.06733098f, 0.31944177f, 
    0.04208241f, -0.02957207f, 0.16555850f, -0.02412803f, -0.21363527f, -0.08822680f, -0.06916863f, -0.44189262f, 
    -0.35685554f, -0.08847134f, -0.10017491f, 0.14347899f, 0.23849328f, -0.46098074f, 0.49660495f, 0.30535629f, 
    0.10808478f, 0.40895012f, -0.14741230f, -0.09194306f, -0.05190440f, 0.31811988f, 0.12195092f, -0.16997646f, 
    -0.17512618f, -0.26713777f, -0.07887519f, -0.04861753f, 0.26114762f, 0.28009009f, 0.17858155f, -0.30621806f, 
    0.03910637f, -0.48132965f, -0.11440571f, -0.23264460f, -0.09422830f, 0.29014045f, 0.13070154f, -0.38607249f, 
    0.06073233f, 0.04183198f, -0.06783346f, -0.05578903f, 0.00945979f, -0.01706180f, -0.06505869f, 0.03858344f, 
    -0.01747651f, 0.03291945f, 0.07023128f, 0.03959342f, -0.05592649f, -0.08427434f, 0.00465965f, 0.06127707f, 
    0.04385301f, 0.01578748f, -0.07180321f, 0.06839972f, 0.00643657f, 0.02991846f, 0.01684822f, 0.02310358f, 
    -0.05535407f, 0.04902993f, 0.02607126f, 0.05028734f, -0.01248331f, 0.05090664f, -0.02848569f, -0.02831692f, 
    -0.08069924f, 0.03582058f, 0.02172578f, -0.01255109f, -0.01404075f, -0.09451194f, -0.03876569f, -0.05683425f, 
    -0.03439207f, -0.07522757f, -0.03867974f, -0.06676282f, 0.03706329f, -0.03148661f, -0.04387606f, 0.02585785f, 
    -0.01808245f, -0.00461877f, 0.04059234f, -0.06826414f, -0.06054200f, -0.02946223f, -0.06944262f, -0.07415830f, 
    -0.08528964f, 0.03897662f, 0.06683905f, -0.01281867f, 0.04760602f, -0.01670647f, -0.07035659f, -0.04236177f, 
    -0.03881494f, 0.06628451f, 0.03392040f, 0.05377231f, -0.00384009f, 0.06495560f, -0.06841330f, -0.06565458f, 
    -0.04720394f, 0.05377139f, 0.03362279f, 0.03541502f, 0.01192111f, 0.06599437f, -0.02241262f, -0.09014012f, 
    -0.04891174f, -0.02726192f, -0.01355599f, 0.06097983f, -0.05480812f, -0.02813308f, 0.02344594f, -0.03423920f, 
    -0.06710414f, 0.06052727f, 0.05301924f, 0.00807488f, 0.04490830f, -0.03016761f, -0.02341825f, -0.07138592f, 
    -0.00455868f, 0.04714492f, 0.02108100f, 0.07478942f, -0.00328745f, -0.01033584f, 0.06934485f, -0.07315304f, 
    0.05512160f, -0.04057889f, -0.03277235f, -0.00317402f, -0.07929790f, -0.00928756f, 0.06502976f, -0.02126469f, 
    0.07061835f, 0.04267795f, 0.01504048f, 0.02724061f, 0.02648378f, -0.06042251f, -0.00724174f, -0.01598702f, 
    -0.02431172f, -0.04547213f, -0.00404202f, 0.05175888f, -0.07016882f, 0.06336031f, -0.04574060f, -0.03883861f, 
    -0.00255364f, -0.06218596f, -0.05155800f, -0.04693333f, -0.01004194f, -0.05625697f, -0.08540993f, -0.04749272f, 
    -0.05993408f, -0.00255788f, -0.04632269f, 0.04898314f, 0.06331015f, -0.04896640f, 0.04543314f, -0.05826277f, 
    -0.12569734f, 0.18069650f, -0.19615059f, -0.03835915f, 0.00477823f, 0.12145422f, 0.16082647f, -0.02174933f, 
    -0.01242752f, -0.21907970f, 0.28064609f, 0.07761970f, 0.14074844f, 0.21148391f, -0.19011703f, 0.17432728f, 
    -0.25987941f, 0.02247622f, 0.20093776f, -0.01604120f, 0.04435286f, 0.10864388f, 0.46126258f, 0.64317662f, 
    0.17766236f, 0.24783659f, 0.30515191f, -0.15047200f, -0.08240918f, -0.20660500f, 0.42927635f, 0.11435448f, 
    -0.06287008f, -0.35876006f, -0.49293083f, -0.38023362f, 0.10651237f, 0.12429190f, -0.08767495f, -0.03494639f, 
    -0.04881304f, -0.03833100f, 0.13471769f, 0.01425533f, -0.07258075f, -0.23035504f, -0.06245773f, -0.30669031f, 
    0.13228615f, 0.31782621f, 0.07433935f, 0.15354949f, 0.05313604f, -0.01086775f, -0.36782396f, 0.15437256f, 
    0.64464241f, -0.10314755f, 0.14902110f, 0.08148342f, 0.21031812f, 0.02375559f, 0.19273202f, 0.25852931f, 
    -0.44696531f, -0.11969759f, 0.43092221f, 0.22361968f, -0.20009546f, 0.00356770f, -0.03128336f, -0.17158633f, 
    -0.19679940f, 0.35660416f, 0.15820338f, -0.08112465f, 0.11569893f, 0.08938672f, 0.12045287f, 0.22168796f, 
    0.31752530f, -0.10308336f, 0.04116835f, 0.41652250f, 0.03076375f, 0.15431589f, 0.29276189f, 0.02943697f, 
    -0.12231982f, 0.33641174f, 0.30051646f, -0.04107955f, -0.03426894f, -0.12829384f, -0.05897778f, -0.10720021f, 
    -0.13337143f, 0.08187057f, -0.04286955f, 0.11643977f, 0.01946130f, 0.22762164f, 0.13534883f, 0.22328249f, 
    0.10936253f, -0.00433548f, -0.29579380f, -0.24478668f, -0.00776164f, -0.15501888f, -0.03642292f, -0.03567349f, 
    -0.02862556f, 0.10654046f, -0.21653734f, -0.19573045f, -0.38770080f, -0.21127994f, 0.48388684f, 0.31279558f, 
    0.16029713f, -0.06046082f, -0.10420437f, 0.14852244f, 0.26353124f, 0.36567265f, 0.17155792f, -0.00190221f, 
    0.30169138f, 0.20803481f, 0.08625217f, -0.15370069f, 0.03305187f, -0.64829582f, -0.00728913f, 0.04662150f, 
    0.40999594f, -0.11316757f, 0.16724721f, 0.10448531f, 0.29530504f, -0.08496113f, 0.01122087f, 0.21952905f, 
    -0.34103411f, 0.31716597f, 0.12067094f, -0.17934427f, -0.08306219f, 0.22844037f, 0.02824787f, -0.09049526f, 
    0.15416870f, -0.31859848f, 0.49665979f, 0.11965984f, 0.24586160f, 0.10238605f, -0.14449014f, 0.05494589f, 
    -0.19418944f, 0.23472746f, -0.48213288f, -0.13557412f, -0.23426647f, 0.00782863f, 0.01816199f, -0.22543162f, 
    0.06645851f, -0.11880157f, -0.30461007f, 0.04322423f, 0.42840177f, -0.27277809f, 0.15769725f, 0.27195311f, 
    0.07377844f, 0.25573492f, 0.35143775f, 0.19911130f, -0.06612926f, -0.06635604f, 0.00860458f, -0.02753859f, 
    -0.06310434f, -0.00570859f, -0.01167881f, -0.07976741f, 0.20796096f, -0.36076608f, -0.23328769f, 0.03553975f, 
    0.00317419f, -0.25248018f, -0.01834247f, 0.13058478f, -0.11396389f, -0.00585174f, 0.32555878f, -0.87286931f, 
    0.00154842f, -0.32620972f, -0.04216015f, 0.23995715f, -0.04868996f, 0.19345477f, 0.25052968f, -0.65217417f, 
    0.56698090f, 0.41327339f, -0.04816449f, -0.05636377f, 0.02445348f, 0.21526133f, 0.23926681f, 0.03707745f, 
    0.00563994f, -0.11655017f, 0.17237477f, 0.07566889f, -0.06754939f, 0.11422916f, -0.04713988f, 0.11223079f, 
    -0.06502818f, 0.43697605f, 0.28612998f, 0.05932910f, -0.05404356f, -0.29191780f, -0.30249643f, 0.02318462f, 
    0.09809267f, 0.00839076f, -0.12374661f, -0.35730308f, 0.14436246f, 0.09718630f, 0.04821024f, -0.15784433f, 
    0.03776024f, 0.13443781f, 0.02853874f, -0.21997097f, 0.13133785f, 0.06663428f, 0.11298254f, 0.21625903f, 
    -0.22140452f, -0.14006379f, 0.03160457f, -0.04921586f, -0.04287575f, 0.27488253f, 0.14664973f, 0.18162364f, 
    0.03443339f, 0.04324484f, -0.17142966f, 0.12764716f, 0.16087295f, 0.37418008f, -1.30303407f, -0.44257802f, 
    -0.02192793f, 0.29306534f, 0.52563858f, -0.01386705f, 0.07981838f, 0.01546416f, -0.52852947f, 0.10474978f, 
    0.24682190f, 0.25873789f, 0.06888932f, 0.11610598f, -0.02468735f, 0.22560222f, 0.12856655f, -0.53091651f, 
    -0.22684425f, 0.18998717f, 0.03344160f, 0.10302951f, 0.27862728f, 0.10166425f, 0.10851526f, 0.04955422f, 
    -0.43847692f, -0.48231274f, -0.00346803f, -0.06197311f, 0.11879392f, -0.45074987f, 0.27153829f, 0.34478191f, 
    0.06017412f, -0.03576176f, 0.12973700f, 0.19456139f, -0.17600563f, -0.02529320f, 0.22824572f, -0.02378088f, 
    0.08331995f, 0.11308369f, 0.41046867f, 0.33310381f, 0.01421341f, 0.02967377f, 0.14945017f, -0.08771263f, 
    -0.21922177f, 0.10789531f, -0.29439262f, 0.31368360f, 0.08268250f, -0.01441372f, 0.06001582f, 0.00763377f, 
    0.18859494f, -0.31567031f, -0.20610453f, 0.26286227f, -0.54635274f, -0.25979117f, -0.17276357f, -0.29173100f, 
    0.17269340f, 0.12350517f, 0.04574650f, 0.16911581f, 0.27325392f, -0.18727623f, -0.55845183f, 0.28289455f, 
    0.16997969f, -0.17810917f, -0.22879279f, -0.13629197f, -0.24818410f, -0.24347837f, -0.00548229f, 0.16898921f, 
    0.25715005f, -0.04427428f, -0.02358735f, 0.00612956f, 0.17868769f, -0.30589688f, -0.05640376f, 0.33547235f, 
    0.26575604f, -0.29131800f, -0.03568566f, 0.08456627f, 0.19328712f, 0.06849326f, 0.03330999f, 0.26044440f, 
    0.22446425f, 0.33897379f, 0.30710533f, 0.08878074f, 0.13285996f, -0.13892885f, 0.24402857f, 0.16465956f, 
    -0.17819060f, -0.32078031f, -0.20383684f, 0.11647756f, 0.17929767f, 0.01415610f, 0.00214849f, 0.35211205f, 
    0.10754497f, 0.46920127f, -0.60575509f, -0.03866692f, 0.43169874f, -0.46201423f, -0.00440303f, 0.20067787f, 
    -0.26821107f, 0.11374126f, 0.15253451f, -0.01855674f, -0.29996103f, -0.11389221f, 0.14078829f, -0.06374098f, 
    -0.28161845f, -0.03182759f, 0.06383427f, 0.19944081f, -0.20920792f, -0.34717971f, -0.25124696f, 0.09507307f, 
    0.13832550f, 0.07930849f, -0.06411563f, -0.00068863f, 0.05108421f, -0.70602584f, 0.02794983f, -0.40198943f, 
    -0.05794450f, 0.08309937f, -0.03280421f, -0.04212965f, -0.00287245f, 0.12065679f, -0.17378123f, 0.11326148f, 
    -0.08313723f, 0.08261529f, -0.01009222f, 0.30620468f, 0.06930746f, 0.00534398f, -0.10417020f, 0.62682623f, 
    0.56154019f, -0.43789870f, -0.04003294f, -0.01893519f, 0.23461224f, 0.04142599f, 0.06795293f, -0.10523964f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.43508920f, 0.24744441f, 0.16225581f, -0.07092386f, 0.02307374f, 0.14203912f, 0.54945302f, 0.45506409f, 
    0.25510204f, -0.10054776f, 0.21429408f, 0.22392073f, -0.04377116f, -0.10701407f, 0.36255613f, 0.28355557f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07744855f, -0.04639684f, -0.22794415f, 0.23096430f, 0.73180419f, -0.30503246f, -0.24001695f, -1.58622384f, 
    -1.04964924f, 0.13217868f, 0.32800460f, -0.41636708f, 0.16361165f, -0.02244085f, 0.01424255f, 0.55967200f, 
    -0.16446364f, -0.04561318f, 0.10609164f, 0.22934557f, 0.94524616f, 0.40917423f, -0.21190578f, 0.17348187f, 
    0.13056530f, -0.66005713f, 0.37046880f, -0.09908019f, 0.10491734f, -0.49022201f, 0.21791679f, 0.33598179f, 
    -0.54751068f, 0.43090156f, -1.24737084f, 0.17061387f, -1.13329995f, -0.32460046f, -0.41671515f, 1.06676686f, 
    0.25820363f, -0.86928368f, -0.18082692f, -0.00991205f, -0.05753407f, 0.20722312f, -0.14313219f, -0.10685776f, 
    -0.22780453f, -1.11589253f, -0.70343792f, -0.12184408f, -0.15791647f, -0.40001997f, 0.00860200f, -0.25470212f, 
    0.30748832f, -0.20501791f, 0.41906530f, -0.29329273f, -0.22365673f, 0.38243148f, -0.49108127f, 0.52814913f, 
    0.02877831f, 0.29748765f, -1.13286710f, -0.17730549f, 0.18989454f, 0.00899776f, 0.19714947f, -0.26177645f, 
    -0.35784969f, 0.94045120f, -0.13711745f, -0.57959276f, -0.10730962f, 0.04013729f, 0.08241271f, -0.49739838f, 
    0.20064011f, 0.45101401f, -0.54633236f, 0.19123194f, -0.13648547f, 0.03604622f, 0.06417464f, -0.15619013f, 
    0.91223377f, 0.02001804f, -0.21313918f, 0.21701869f, 0.14665434f, -0.40187338f, -0.02230921f, 0.13137721f, 
    -0.72120756f, 0.04232397f, 0.61685342f, -0.24149941f, -0.61796051f, -0.81962687f, 0.50922149f, 0.42983988f, 
    -0.61483705f, -1.22882807f, 0.42382696f, -0.21630801f, -0.04541887f, 0.29973850f, -0.43627304f, -0.96817988f, 
    0.16990112f, -0.48437372f, -0.41955066f, -0.08264211f, -0.27188411f, 0.68804079f, -0.78364062f, 0.03452143f, 
    0.15911019f, 0.05382002f, 0.10408535f, 0.27873096f, -0.12617421f, 0.23967297f, -0.60733998f, -0.82120985f, 
    0.46375838f, -0.42108405f, 0.91982049f, 0.08024130f, -0.15658380f, -0.02009206f, -0.47078225f, -0.07089522f, 
    0.76846355f, -0.59766030f, -0.35794359f, 0.37214115f, -0.18783808f, -0.48492187f, 0.46197680f, -0.49012926f, 
    -0.84370321f, 0.07439296f, -0.63336277f, 0.13501072f, -0.10096098f, 0.09820942f, 1.46286058f, -0.65200186f, 
    -0.16162182f, -0.30789980f, -0.54060173f, -0.73228216f, 0.09371451f, 0.31563187f, 0.32017145f, -0.13718081f, 
    0.05500561f, -0.92276967f, -0.53866464f, 0.15386273f, -0.60620290f, -0.42902592f, -0.16002981f, 0.85361701f, 
    -1.27944183f, 0.21367227f, 0.12297869f, 0.19125058f, 0.10613168f, -0.38554507f, 0.57332528f, 0.03099643f, 
    -0.55148441f, 0.07585935f, 0.75090528f, 0.02540655f, -0.96766633f, 0.18544678f, -0.87431985f, 0.45786145f, 
    -0.16749059f, -0.27752721f, -0.86117858f, -0.49279746f, 0.11867762f, 0.31730092f, 0.58811539f, -0.71541888f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.59523362f, 0.28337261f, 0.10672940f, 0.25467893f, -0.36460552f, -0.09762695f, -0.03026899f, -0.47118673f, 
    -0.05852351f, 0.28193557f, 0.44905075f, -0.15080492f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
