#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.71801120f, -0.96332079f, -0.63100559f, 0.00610420f, -0.18833888f, -0.50107229f, -0.26671553f, -0.46360731f, 
    -0.24904892f, 0.17520447f, 0.00579861f, 0.47008535f, 0.07670779f, 0.57944041f, -0.31498387f, -0.20677400f, 
    0.04557089f, 0.50898927f, -0.15674734f, -0.06284413f, 0.18947151f, -0.33295134f, -0.09768526f, 0.15036356f, 
    0.19477731f, -0.51415718f, -0.13322334f, 0.49059707f, -0.83820617f, -1.10259807f, 0.32920095f, -0.65357059f, 
    -0.13232310f, -0.47639120f, -0.25582650f, -0.07459427f, 0.38695702f, 0.22857137f, 0.32719964f, 0.05981658f, 
    0.09270190f, 0.28330302f, 0.28158477f, 0.29119775f, -0.28424391f, 0.23392823f, 0.28950408f, 0.07206097f, 
    0.39945143f, 0.02057889f, -0.88823116f, -0.67587286f, -0.64361066f, -0.37865242f, -0.61986130f, 0.65149313f, 
    0.60906821f, 0.20723265f, 0.34085608f, 0.57306123f, 0.19211426f, -0.16920994f, -0.23696600f, -0.27480394f, 
    -0.20041560f, 0.09084306f, -0.11783637f, -0.11125045f, -0.45135039f, 0.12176926f, 0.04014454f, -0.09783980f, 
    -0.31923237f, -0.19533424f, -0.10830329f, 0.20437427f, -1.35569859f, -0.19770187f, 0.99379355f, -0.13981484f, 
    -1.12615275f, 0.25995535f, 0.57949060f, -0.60842717f, -0.12649676f, 0.19648275f, 0.25703844f, -0.26817805f, 
    -0.15699497f, -0.07328969f, -0.24954021f, 0.00427397f, 0.01234253f, -0.10460442f, -0.36246368f, 0.02549884f, 
    -0.03167379f, -0.05621187f, 0.04367181f, -0.00281900f, 0.41952986f, 1.00335193f, -0.80491072f, -0.99152309f, 
    -0.21238844f, 0.67293274f, -0.00283122f, -0.65879416f, -0.23623431f, -0.18000856f, 0.47215372f, 0.15261349f, 
    0.23162216f, 0.21010971f, 0.05286416f, 0.22485836f, -0.12264244f, 0.18442026f, 0.01880509f, 0.36246774f, 
    0.10309235f, 0.03393603f, 0.06376953f, -0.04219873f, 0.14081864f, 0.89678633f, 0.31168160f, 0.34829229f, 
    1.06159055f, -0.12333484f, -0.31013787f, -0.43692043f, 0.54467875f, 0.05427620f, -0.50110948f, -0.46894786f, 
    -0.56066239f, -0.34895062f, 0.23965512f, 0.25752541f, -0.25627989f, -0.00313812f, 0.16475160f, -0.13285384f, 
    0.31387112f, -0.03031200f, -0.18704233f, -0.06400603f, 0.23547523f, -0.07183250f, -1.49262989f, 1.12569940f, 
    0.75419104f, -0.50125456f, 0.07431453f, -0.02472350f, 0.46502170f, 0.43209040f, -0.14686200f, 0.00695086f, 
    -0.03600176f, -0.15591103f, 0.27977905f, -0.11906172f, -0.11481731f, -0.16925110f, -0.30944926f, -0.10594874f, 
    -0.26778466f, -0.21529560f, -0.08590203f, -0.16892913f, -0.01540867f, 0.07931580f, -0.12254116f, 0.58294463f, 
    0.25514755f, -0.14739500f, 0.99008512f, 0.68315971f, 0.80887663f, 0.86354440f, 0.10868751f, 0.43081319f, 
    0.24681588f, -0.12038986f, -0.16859281f, -0.02785656f, -0.30923733f, 0.00560351f, -0.41632298f, -0.25874540f, 
    0.16987459f, -0.12462722f, -0.34232616f, 0.29436320f, 0.06084307f, -0.01182374f, 0.11578209f, 0.07512970f, 
    1.05257988f, 0.49665916f, 0.61514026f, -0.45847392f, 0.38577867f, 0.66388762f, -0.59432703f, 0.34792396f, 
    0.39315042f, 0.32730603f, 0.04870463f, 0.13029884f, -0.34066388f, -0.46745667f, -0.16554751f, 0.02764150f, 
    0.05388044f, -0.51624465f, -0.44346941f, -0.22708203f, -0.17778717f, -0.04075734f, 0.15820198f, -0.07405082f, 
    -0.26664814f, 0.84542495f, -0.47614238f, -1.04859138f, -1.07550275f, -0.07909562f, 0.60451633f, -0.43253386f, 
    0.46827033f, 0.31070301f, 0.22696693f, -0.70298487f, 0.01908565f, -0.18532415f, 0.01721894f, -0.10234777f, 
    -0.19350109f, -0.30113065f, -0.14079130f, 0.15274374f, 0.02012696f, -0.14448018f, 0.09042335f, -0.36967888f, 
    0.00363148f, -0.12869163f, 0.76480049f, 0.49730232f, 0.77430725f, 0.41733214f, 0.24024315f, 0.41735616f, 
    -0.79631627f, -0.67609584f, -0.61451334f, -0.29473242f, 0.40512505f, 0.60262650f, 0.02240499f, 0.02719735f, 
    0.13916753f, 0.19508493f, 0.15349126f, 0.07490091f, 0.18042031f, 0.61973310f, 0.07135898f, 0.09801854f, 
    -0.14023480f, -0.12426557f, 0.43768671f, -0.69674987f, -1.00268328f, -0.94635725f, -0.27153447f, 0.11859659f, 
    -0.27895603f, 1.19790745f, 0.50635976f, -0.46123296f, -0.10235914f, 0.07536095f, -0.39483380f, -0.45272827f, 
    -0.37019399f, 0.20304061f, 0.03832597f, 0.13422513f, -0.26322076f, -0.08335091f, 0.10500040f, -0.03376010f, 
    0.15486881f, 0.28365582f, 0.12541263f, 0.02986151f, 0.95351064f, 0.57915920f, 0.28793141f, 0.03177259f, 
    -0.55009788f, 0.13203824f, -0.79374659f, -0.48969275f, 0.22019818f, -0.20215172f, -0.54099476f, -0.54544204f, 
    0.12966636f, 0.16219752f, -0.17402650f, -0.03564027f, 0.03476490f, -0.07883602f, -0.03533547f, -0.01952180f, 
    0.42222521f, 0.38694459f, 0.24817045f, -0.13927679f, 0.09991156f, 1.34036589f, -0.01241914f, -0.17670994f, 
    0.84216928f, 0.84242094f, 0.40507016f, -0.28955775f, -0.03867139f, 0.71542549f, 0.66557586f, -0.11335384f, 
    0.36861932f, -0.12073252f, 0.34034374f, -0.29303458f, 0.21370654f, 0.21721429f, -0.12408933f, -0.18551750f, 
    -0.23669831f, -0.02757112f, 0.12108074f, 0.14648306f, 0.00701573f, 0.23061991f, 0.00609984f, 0.40861285f, 
    0.89293396f, 0.88399863f, 0.77197188f, 0.42487618f, 0.15426436f, 0.36349452f, 0.26633713f, 0.37437028f, 
    -0.42875314f, -0.19245476f, 0.20862108f, 0.06964665f, -0.24507427f, -0.05669628f, 0.26290819f, 0.14204489f, 
    0.00268315f, 0.31532943f, -0.34748060f, -0.05871180f, -0.09447891f, 0.29294273f, -0.09206657f, 0.42346475f, 
    0.92393363f, 0.77773058f, 0.77314281f, 0.25364497f, -0.99124742f, -0.33959672f, -0.88074601f, -0.37201509f, 
    -0.04752083f, 0.12622429f, 0.01689403f, -0.02701654f, 0.14104110f, -0.39544588f, -0.51276779f, -0.02333783f, 
    0.04127569f, -0.54199070f, -0.06139296f, 0.14419879f, -0.05914419f, -0.00442329f, -0.03678358f, 0.17053099f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11750093f, 0.36492881f, 0.06525386f, 0.19683339f, 0.23235263f, 0.12222096f, -0.01057669f, 0.19307587f, 
    0.21584998f, 0.11741540f, 0.18089679f, 0.06458022f, 0.07825084f, 0.03435966f, -0.00814811f, 0.47914809f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.27096033f, -0.13606313f, -0.22729637f, 0.04367921f, -0.13411777f, -0.09975857f, 0.10900969f, 0.05739858f, 
    -0.02656855f, 0.06801425f, 0.21839243f, 0.07738361f, -0.46901447f, 0.16230392f, -0.01179926f, 0.00914503f, 
    -0.00953535f, -0.18495235f, 0.11603132f, 0.03166419f, 0.05203964f, 0.19070488f, 0.30967954f, 0.18444839f, 
    0.30584207f, -0.00585245f, -0.11992165f, -0.25408575f, -0.03503833f, -0.13408138f, -0.16592777f, -0.09032124f, 
    0.01864880f, -0.10706801f, -0.29223683f, -0.08937337f, 0.53498435f, -0.05794775f, 0.20012082f, 0.06368785f, 
    0.00570322f, -0.10174564f, 0.10791247f, 0.08595204f, 0.11908263f, -0.14026745f, 0.00439770f, 0.08900276f, 
    -0.07473891f, 0.20426939f, -0.04489562f, -0.06120024f, -0.08943178f, -0.01262147f, 0.02149171f, 0.10157087f, 
    0.13949180f, 0.08230925f, 0.04920206f, 0.10207418f, -0.45413974f, -0.32523966f, -0.14899570f, -0.20885104f, 
    0.00785627f, -0.05747565f, -0.19207434f, 0.15209411f, -0.16775061f, 0.07126863f, -0.03933621f, -0.07791630f, 
    -0.00261714f, -0.28802156f, -0.22484943f, 0.04301227f, 0.15437295f, 0.08657013f, -0.06828413f, -0.10788295f, 
    0.14411341f, -0.16883524f, 0.15621601f, 0.12075013f, 0.12044851f, 0.08224991f, -0.09109596f, -0.29115334f, 
    0.24816816f, -0.01312757f, -0.12399311f, 0.10220832f, 0.24993108f, 0.00466505f, 0.16069236f, 0.01409380f, 
    -0.08794628f, 0.09276064f, 0.04456875f, -0.00791931f, 0.11744516f, 0.03662971f, 0.17662138f, -0.20670490f, 
    0.08294267f, -0.04536780f, -0.05999388f, 0.00287240f, -0.05014303f, 0.29423115f, 0.24555802f, -0.29508534f, 
    -0.05749076f, 0.06562222f, -0.05361906f, 0.17656989f, 0.16854571f, -0.02484695f, -0.07982146f, 0.03619571f, 
    0.33047634f, 0.24509895f, -0.07630640f, -0.16741341f, 0.12086052f, 0.19363187f, 0.22192360f, -0.08197590f, 
    -0.12459849f, 0.18109703f, 0.09659713f, 0.13536143f, 0.44327581f, -0.05519955f, -0.24478368f, 0.11013810f, 
    -0.03039562f, 0.07658440f, -0.07304218f, 0.02723682f, 0.10026327f, 0.14107013f, -0.23690128f, -0.00592056f, 
    -0.41685107f, -0.29076993f, 0.19640549f, 0.05740358f, 0.21545500f, 0.17461680f, 0.05337745f, 0.01073815f, 
    0.03100917f, 0.04480362f, -0.04162443f, -0.03129836f, -0.36373833f, -0.11682101f, -0.16873817f, -0.15247595f, 
    0.17599142f, -0.02353739f, 0.16305615f, -0.09563628f, 0.10854501f, -0.12281755f, 0.15106893f, 0.00916047f, 
    0.07092366f, -0.13888441f, 0.05590283f, -0.17936619f, 0.17132588f, -0.03408814f, -0.11851092f, -0.08114804f, 
    0.06329393f, 0.13026302f, 0.14750147f, 0.09969141f, 0.13661978f, -0.01904254f, -0.06151773f, -0.18757606f, 
    0.29828680f, 0.11846136f, 0.16528319f, 0.12336031f, -0.12891571f, 0.07073280f, 0.16068856f, 0.14605753f, 
    0.34842992f, -0.19513047f, -0.14100868f, -0.10173894f, -0.26047808f, 0.03394774f, 0.07970973f, 0.12641579f, 
    -0.05614566f, -0.21744792f, -0.07853809f, -0.08718050f, -0.46887758f, 0.12606043f, -0.23489755f, -0.27384108f, 
    -0.14951994f, 0.18306626f, 0.07371386f, -0.09758329f, -0.07482937f, 0.09602595f, -0.03474279f, -0.16875878f, 
    0.35031685f, 0.08417795f, 0.25855654f, -0.04889324f, -0.18028118f, -0.14069057f, 0.05637690f, 0.05646576f, 
    -0.02326073f, 0.08944670f, 0.08573394f, -0.05696722f, -0.15837951f, -0.28766441f, -0.29677793f, 0.44664496f, 
    -0.09447168f, 0.03542069f, 0.04457209f, -0.12775418f, -0.00974209f, -0.03646945f, 0.06329236f, -0.02808814f, 
    0.07628715f, -0.34833005f, -0.00496470f, -0.27017394f, -0.06137580f, 0.00738383f, 0.15659538f, 0.02905456f, 
    0.03125377f, 0.14967681f, 0.09484034f, 0.10938022f, -0.11516146f, 0.30192983f, -0.20011486f, 0.23782152f, 
    0.07142059f, 0.12236349f, 0.13061303f, 0.22719464f, 0.16544367f, -0.10553408f, -0.13895272f, 0.15472449f, 
    0.04866487f, 0.43150055f, -0.40446538f, -0.27530903f, -0.07971922f, 0.28957933f, 0.03023634f, 0.11785305f, 
    0.08224524f, -0.03966863f, 0.23287424f, 0.01250803f, 0.39872962f, -0.05211115f, 0.10741226f, 0.40761834f, 
    0.05372725f, 0.07803183f, 0.02798368f, 0.09113033f, -0.09731634f, 0.16642404f, -0.02294116f, 0.31543511f, 
    0.08638509f, 0.05332340f, 0.19516340f, -0.18656951f, 0.03806239f, 0.17391326f, 0.22399555f, 0.11749664f, 
    0.08127594f, -0.08923745f, 0.19690298f, 0.08117481f, 0.08860346f, -0.11985547f, -0.01646892f, -0.21038812f, 
    0.05208207f, -0.20060071f, 0.21490449f, -0.02889721f, -0.10298923f, -0.09371564f, -0.02464527f, 0.06321675f, 
    -0.07459670f, -0.01153077f, 0.25092790f, -0.26046440f, 0.04342236f, 0.13517313f, -0.00945352f, -0.03745205f, 
    0.21342571f, -0.07573644f, 0.05182960f, 0.06738762f, 0.37173346f, -0.04933786f, -0.04059897f, -0.00839263f, 
    -0.21548319f, -0.14382552f, -0.26495901f, -0.02489792f, 0.12165252f, 0.02905484f, 0.14009468f, 0.00747973f, 
    -0.17718734f, -0.05355351f, 0.09870923f, -0.20271370f, 0.01471080f, -0.06215974f, 0.08972165f, 0.05857519f, 
    -0.14780644f, -0.00297756f, -0.02258151f, -0.01636314f, 0.43152803f, -0.23176898f, 0.11787321f, 0.36859411f, 
    0.06728856f, 0.13829246f, -0.13685159f, 0.19667873f, -0.07330685f, 0.04558558f, -0.01664095f, -0.13836920f, 
    -0.03679400f, 0.12136394f, -0.23041590f, 0.39785612f, -0.08974707f, 0.24231984f, 0.03694868f, 0.12905094f, 
    0.02165045f, -0.10707040f, -0.02446615f, -0.03379851f, 0.27426258f, 0.17346238f, 0.03552090f, -0.26497927f, 
    0.05993809f, 0.00479737f, -0.00559875f, 0.07934649f, 0.09028950f, -0.12364422f, -0.00916519f, -0.04920707f, 
    -0.06605223f, -0.05417429f, -0.00002427f, 0.01966946f, 0.03622047f, -0.03564500f, 0.04060688f, 0.02765880f, 
    0.01857887f, -0.04131287f, -0.00595794f, 0.02985152f, -0.05502105f, -0.01744828f, 0.00951831f, 0.02104455f, 
    0.02050140f, -0.02627264f, -0.00924794f, -0.07091331f, 0.06383649f, -0.07558086f, 0.03938663f, -0.02916880f, 
    -0.00416789f, -0.03096983f, -0.03126611f, -0.05058758f, -0.04993578f, 0.02420764f, 0.04691536f, -0.07767705f, 
    -0.06179716f, -0.02548172f, 0.05178093f, 0.02796734f, -0.03852526f, 0.01323927f, -0.00831729f, -0.00353718f, 
    -0.03769620f, 0.04333223f, 0.01310845f, -0.02937013f, -0.01060729f, 0.06334928f, 0.01171888f, 0.00649865f, 
    -0.03188328f, 0.03558608f, 0.02825184f, -0.01418070f, 0.02486952f, 0.02815920f, -0.07219061f, -0.02460355f, 
    -0.07059933f, -0.00033324f, -0.03718175f, 0.04325069f, -0.02396495f, 0.03924503f, 0.05545403f, -0.07591096f, 
    -0.07413848f, 0.05800087f, -0.04018433f, -0.04552058f, -0.00098154f, 0.01118885f, -0.01825033f, 0.03377447f, 
    -0.02020687f, -0.00377836f, 0.05787045f, -0.02515723f, -0.03318364f, 0.06612767f, -0.02992957f, 0.02410556f, 
    -0.00779961f, 0.01594331f, -0.03379089f, 0.00587337f, -0.04846056f, 0.05120741f, 0.06312116f, 0.04101632f, 
    -0.06133639f, 0.03539393f, 0.04806620f, -0.05436863f, -0.06763775f, 0.02493315f, -0.06872840f, 0.01032172f, 
    0.01572829f, 0.03303134f, -0.06283344f, -0.03795316f, 0.04694534f, 0.02389065f, -0.05834636f, -0.07604955f, 
    0.05289632f, 0.04144312f, -0.06298447f, -0.01514769f, -0.00878685f, -0.07080175f, -0.02401604f, -0.05162476f, 
    -0.04558354f, 0.02119363f, 0.00643399f, 0.06060462f, 0.02335977f, -0.04033080f, 0.02257456f, 0.03612429f, 
    0.02878299f, 0.00385650f, 0.00128014f, -0.07516116f, -0.06936884f, -0.00595504f, -0.05170555f, 0.05360292f, 
    -0.02403633f, -0.01780391f, 0.04469690f, 0.05745003f, 0.05146304f, 0.04120459f, -0.02111106f, 0.00995078f, 
    -0.02819663f, -0.03187726f, -0.06345822f, 0.02427187f, -0.03491771f, -0.06246530f, 0.03102654f, -0.04989382f, 
    -0.02717788f, -0.05207950f, -0.06696091f, -0.05448490f, 0.02068320f, 0.01136052f, 0.04921113f, 0.00457845f, 
    0.01794188f, -0.04301388f, 0.05094786f, -0.04024484f, -0.05149142f, -0.05035278f, -0.00408119f, 0.04970567f, 
    -0.06871718f, -0.05639918f, -0.03814504f, -0.07195893f, -0.05977766f, -0.00995166f, -0.03327597f, -0.06762680f, 
    -0.04465097f, 0.00138363f, -0.03496984f, -0.06955964f, 0.04020679f, 0.06219526f, 0.01340805f, 0.04160680f, 
    -0.03901143f, -0.01025012f, 0.02532843f, -0.02362817f, 0.00124331f, -0.03570592f, -0.06902748f, -0.00597379f, 
    -0.02094064f, 0.04129091f, 0.01391385f, -0.07244233f, -0.06577312f, -0.05454939f, -0.02748542f, 0.04003687f, 
    -0.31143644f, -0.31416208f, -0.10479963f, -0.10810095f, -0.19435480f, 0.05971159f, 0.07245526f, -0.11561179f, 
    0.02872146f, -0.11552663f, -0.33142459f, -0.14488696f, -0.10476059f, 0.10942163f, -0.18727392f, 0.14739433f, 
    -0.01233500f, -0.15373977f, 0.05738438f, -0.09844154f, 0.02351846f, 0.11294609f, 0.03310626f, -0.04187552f, 
    -0.23736371f, -0.23604190f, -0.11469243f, -0.30597797f, 0.07790346f, 0.16755636f, 0.04922712f, -0.03251626f, 
    0.03260587f, 0.09316669f, -0.03767332f, -0.03452889f, -0.52209932f, 0.04045025f, -0.10153079f, 0.31308842f, 
    -0.06966515f, -0.13430133f, 0.05729623f, -0.10732041f, 0.03665048f, -0.04844846f, 0.09633983f, 0.10909972f, 
    0.13913554f, 0.22249109f, 0.25905421f, -0.10153503f, 0.02915264f, -0.02174800f, -0.03476575f, 0.06925104f, 
    0.18354024f, 0.05924331f, 0.08778840f, 0.03982764f, 0.25926149f, -0.15868856f, -0.11263923f, 0.10663769f, 
    0.09987669f, -0.14016241f, 0.02901538f, 0.07135347f, 0.09189998f, -0.12051834f, -0.06872182f, -0.00416895f, 
    -0.03341565f, -0.47723830f, 0.19055457f, -0.00712255f, 0.15952277f, -0.02079172f, -0.07629247f, -0.00937044f, 
    -0.04735558f, 0.04136448f, 0.15391780f, 0.14974791f, -0.37012538f, 0.18108253f, -0.07943372f, 0.11324352f, 
    0.09205347f, 0.03709392f, 0.01632503f, -0.07994088f, -0.02590893f, 0.04152490f, -0.01435455f, 0.07897282f, 
    0.64991957f, 0.31611887f, 0.05560920f, -0.18839656f, -0.04558798f, -0.00508384f, -0.06030489f, 0.05216026f, 
    0.04158061f, -0.04971201f, 0.15258677f, 0.00271847f, 0.42977017f, 0.28595644f, 0.16865788f, -0.14582925f, 
    0.00512280f, -0.06424907f, -0.13860901f, -0.00417836f, 0.08786545f, 0.19542474f, 0.08822077f, 0.13989589f, 
    0.34216750f, 0.15613742f, -0.05982994f, -0.15032889f, 0.09906702f, -0.16449697f, 0.02054860f, -0.06638868f, 
    -0.02110065f, 0.22061279f, 0.03481297f, -0.04552649f, 0.14036500f, 0.04093394f, 0.00386773f, 0.08497370f, 
    0.04275926f, 0.09057217f, -0.12051478f, -0.07715547f, 0.01541248f, 0.04502272f, -0.02660237f, -0.03227415f, 
    0.40808827f, 0.02169080f, -0.10562088f, -0.07806268f, -0.05896378f, 0.17042422f, -0.08219273f, 0.04567707f, 
    -0.11399428f, -0.11317422f, -0.16653691f, -0.11780228f, 0.02989601f, 0.29368597f, 0.18943353f, -0.00303429f, 
    0.06819100f, -0.00959728f, -0.03059703f, -0.03170738f, 0.13278185f, -0.01089070f, 0.08221601f, -0.15455884f, 
    -0.01418754f, 0.07803287f, 0.07594530f, -0.08399387f, 0.08497825f, 0.04006001f, -0.12600537f, -0.16551469f, 
    -0.09726058f, -0.10231321f, -0.15720858f, 0.20301479f, 0.16755815f, -0.01438798f, -0.09468448f, -0.07860409f, 
    0.14739938f, -0.10250887f, -0.01043317f, 0.03101070f, 0.14247918f, -0.08528569f, 0.00523288f, -0.00486267f, 
    0.08402546f, -0.12056506f, -0.19683476f, 0.09057066f, 0.28320909f, 0.08328851f, 0.28166556f, 0.17990297f, 
    -0.01719590f, -0.06442893f, 0.14226666f, 0.00268369f, -0.37994823f, 0.08158911f, -0.11892045f, 0.55839795f, 
    0.07977437f, -0.19887280f, -0.07120770f, -0.04513909f, 0.11361244f, 0.05065712f, 0.08164355f, 0.07783589f, 
    0.08128072f, 0.11958680f, -0.45571691f, -0.12514232f, -0.01715288f, 0.02547499f, 0.04342425f, -0.22045602f, 
    -0.12224419f, -0.05502828f, -0.00457306f, 0.10275265f, 0.27490926f, -0.03705475f, 0.15241507f, 0.31991696f, 
    -0.19512980f, 0.06078294f, 0.04025237f, 0.06346430f, 0.05386347f, -0.07451797f, 0.08571991f, 0.06782465f, 
    -0.16161573f, -0.32174623f, -0.11707838f, 0.02599189f, -0.15403466f, 0.10485020f, 0.19169566f, 0.03058424f, 
    0.11050460f, 0.13374035f, -0.00842711f, -0.05215340f, -0.02276691f, 0.11330174f, 0.06625164f, -0.00247311f, 
    -0.30649009f, 0.00933500f, -0.10929406f, 0.01937798f, -0.09628608f, 0.03398535f, -0.21826811f, 0.10579701f, 
    -0.30313319f, -0.37665850f, 0.00805182f, 0.23811410f, 0.03365679f, -0.09422164f, -0.01558286f, -0.12614258f, 
    0.10757660f, -0.12975273f, -0.15598802f, -0.06745028f, -0.12802057f, 0.30046675f, 0.12360026f, -0.10357507f, 
    -0.18190131f, 0.04603757f, -0.04336872f, 0.05802655f, 0.13906704f, -0.08323007f, 0.10853971f, -0.08926893f, 
    -0.34045255f, 0.04987071f, 0.15989006f, 0.28340560f, -0.14225589f, -0.02806361f, 0.07581072f, -0.01248878f, 
    0.02780806f, -0.03393258f, -0.08439229f, 0.00437303f, 0.35197493f, -0.41233486f, -0.10115304f, -0.48898858f, 
    0.14041062f, 0.16091815f, 0.13522987f, -0.07305422f, 0.02644574f, 0.01445424f, 0.16029832f, 0.22747411f, 
    0.02434751f, 0.25093067f, 0.05997935f, -0.03273848f, -0.05261099f, 0.13117836f, 0.14128157f, 0.05143902f, 
    -0.00701354f, 0.07262812f, 0.02267530f, 0.20652455f, 0.13318251f, 0.18851921f, -0.12831201f, -0.20605080f, 
    0.08703512f, 0.23904541f, 0.05307479f, 0.16486393f, 0.12358524f, 0.20377980f, -0.07753075f, -0.10188051f, 
    -0.17077348f, 0.10415012f, 0.25324446f, 0.33036181f, -0.00653469f, -0.17533265f, 0.11155178f, 0.12426148f, 
    -0.02621702f, -0.06604028f, -0.09698842f, 0.00488017f, -0.05278401f, -0.01634733f, -0.04987460f, -0.07819740f, 
    0.03149347f, 0.01093837f, -0.13031907f, -0.04540968f, 0.04653572f, 0.03947325f, 0.20819251f, -0.02798151f, 
    0.03264395f, 0.02805334f, 0.18286638f, -0.19571212f, 0.01208574f, 0.13056396f, 0.12752162f, -0.10795730f, 
    -0.00484571f, 0.09347512f, -0.01207163f, 0.00120251f, 0.25786558f, 0.16176786f, 0.30039251f, -0.07159173f, 
    -0.09672036f, -0.14821094f, 0.04958102f, 0.16270193f, -0.22305010f, -0.07482417f, 0.06324647f, 0.15718347f, 
    -0.31514841f, -0.26010171f, 0.00984321f, 0.19604170f, 0.06683008f, -0.10228937f, 0.09292528f, 0.33236998f, 
    0.07995085f, 0.03798812f, 0.22903812f, -0.06674653f, -0.11134399f, -0.08019914f, 0.22313072f, 0.08298003f, 
    0.03872331f, -0.13358106f, 0.10834893f, 0.18002599f, 0.13863049f, -0.01686451f, -0.02575323f, 0.17671169f, 
    -0.04677730f, 0.07878087f, -0.07199226f, -0.10825425f, 0.36385861f, 0.01748966f, -0.11942636f, -0.03328658f, 
    0.04985387f, 0.08027446f, 0.03575765f, -0.10091020f, -0.17378075f, -0.38884428f, 0.08088607f, 0.26730880f, 
    -0.12575635f, -0.00926322f, -0.24687493f, 0.00435377f, -0.01154536f, -0.08716561f, -0.15259883f, -0.03987906f, 
    0.04638454f, 0.26766878f, -0.04071764f, -0.29964301f, -0.05646048f, 0.08768004f, 0.12354820f, -0.07352161f, 
    -0.00286830f, 0.04089138f, 0.10534900f, 0.06610089f, 0.47656474f, 0.00940206f, -0.25802982f, 0.35927704f, 
    -0.23378706f, -0.05812865f, -0.11742508f, -0.05011566f, -0.25675410f, -0.00410021f, -0.07818621f, 0.05340017f, 
    0.01493663f, -0.02416211f, 0.20707485f, -0.05998740f, -0.05823739f, -0.09538267f, 0.13818958f, -0.05225805f, 
    0.01442675f, -0.09135088f, -0.23796733f, -0.19507332f, 0.48064980f, 0.10057829f, 0.11608937f, 0.33038521f, 
    -0.15860841f, 0.08932972f, -0.11237630f, 0.05978673f, 0.03452041f, -0.08128978f, 0.05821722f, -0.16384467f, 
    0.17389059f, -0.00747027f, 0.16677524f, 0.21889372f, -0.04477091f, -0.14872624f, 0.07968838f, -0.05757458f, 
    0.05542422f, -0.00411713f, -0.21454965f, -0.13961522f, 0.22660394f, -0.37263551f, -0.00240420f, -0.43346193f, 
    0.14517845f, 0.07256327f, 0.04104592f, -0.06593476f, -0.04273744f, -0.07960111f, 0.17808163f, 0.00241034f, 
    -0.09404133f, -0.02288881f, 0.09750073f, 0.09689515f, -0.18484557f, 0.09994273f, -0.02044177f, -0.09005201f, 
    -0.02838740f, 0.05166988f, 0.05227520f, 0.10620948f, -0.03019660f, 0.19628307f, -0.16177265f, -0.50560570f, 
    0.06650797f, 0.14349855f, -0.00445947f, -0.01160275f, 0.28336382f, 0.09720055f, -0.16214535f, 0.05889202f, 
    0.12267869f, -0.19387573f, -0.04773132f, -0.05754032f, -0.12661465f, -0.21472074f, 0.15535036f, 0.13166735f, 
    0.10604097f, -0.07684784f, -0.08684999f, -0.03096714f, 0.57880282f, -0.12710765f, 0.00750048f, 0.29673582f, 
    -0.06157145f, -0.00302528f, -0.18347608f, 0.01450391f, 0.07175780f, 0.04975310f, 0.07003467f, -0.04219444f, 
    0.53615719f, 0.16860181f, 0.08635212f, 0.41941103f, -0.08403218f, 0.08726072f, 0.04088836f, -0.06937775f, 
    0.00349142f, -0.05039497f, 0.07855096f, 0.09545948f, -0.11212054f, -0.12949771f, -0.02629479f, 0.24609280f, 
    -0.14717709f, -0.14622663f, 0.07143654f, -0.06771635f, -0.11992204f, -0.17637530f, -0.09379802f, -0.03052502f, 
    0.01484580f, -0.01480209f, -0.04883872f, -0.07115135f, 0.04770951f, -0.00748792f, -0.04737249f, 0.03257362f, 
    -0.04898125f, -0.01260928f, 0.01309469f, -0.04876194f, -0.00796115f, -0.01194573f, -0.07885082f, -0.05323794f, 
    -0.05017016f, 0.05693716f, -0.03831010f, 0.03465714f, 0.02991268f, -0.00572718f, 0.02925862f, 0.03295520f, 
    -0.07186430f, 0.04693036f, 0.03121530f, -0.02284588f, 0.03454866f, 0.01828032f, 0.04219662f, -0.04280897f, 
    0.02824929f, 0.03787762f, -0.03998305f, -0.00122208f, 0.01285055f, -0.00459669f, -0.07243678f, -0.06579474f, 
    0.02123531f, 0.00209851f, -0.01120177f, 0.01504992f, 0.03732105f, 0.05403490f, 0.01791815f, -0.06084158f, 
    -0.02690680f, 0.02690741f, 0.04645431f, 0.01538216f, -0.00506121f, 0.03091372f, -0.06010882f, 0.01282889f, 
    -0.02582912f, -0.07384788f, 0.03477019f, -0.06335783f, 0.03887971f, 0.05080306f, -0.03625838f, -0.00270438f, 
    0.04323226f, 0.03149739f, 0.04798181f, -0.06082322f, 0.06041251f, 0.05061703f, -0.03877262f, -0.05745621f, 
    -0.07173955f, -0.05714698f, -0.01699607f, 0.00989097f, -0.02369989f, -0.05863754f, 0.02033897f, -0.03285171f, 
    0.04289168f, -0.05812991f, -0.01691320f, -0.00649372f, -0.08045267f, -0.06380504f, -0.05721536f, -0.04717449f, 
    0.01152855f, -0.06407837f, 0.02914243f, 0.02475177f, 0.00079944f, -0.07287105f, -0.05618614f, -0.03878693f, 
    0.06180448f, 0.01495877f, 0.04850479f, -0.07809662f, 0.03656862f, -0.04444911f, -0.07790749f, -0.05424642f, 
    -0.06969424f, -0.04561042f, -0.04752951f, -0.05705523f, 0.06100785f, -0.06655208f, -0.04992410f, -0.07782355f, 
    -0.06672096f, 0.05057994f, -0.05655024f, 0.06133190f, 0.04590686f, 0.03020051f, -0.07595311f, -0.07335661f, 
    -0.01105466f, -0.05781988f, 0.02397501f, -0.06527704f, 0.04113906f, -0.00123222f, -0.01729046f, -0.01342673f, 
    0.02947141f, 0.02315900f, 0.02058631f, -0.03870651f, 0.00596372f, 0.01853069f, 0.04448333f, 0.00840964f, 
    -0.05033069f, -0.03190921f, 0.02075543f, -0.01208437f, 0.04962134f, 0.04570333f, -0.04702424f, 0.01558030f, 
    -0.05627925f, 0.04670084f, -0.04493518f, -0.00073975f, -0.04815056f, 0.01540229f, 0.00163953f, -0.03529322f, 
    0.02302427f, 0.01655577f, 0.04486451f, -0.02697033f, 0.04766396f, -0.05732244f, -0.03223783f, 0.06045563f, 
    0.00262012f, 0.01134633f, -0.03944728f, -0.06774369f, 0.02074553f, 0.01145353f, -0.07747351f, -0.01153790f, 
    -0.04067934f, -0.07329381f, 0.04638368f, 0.00285420f, -0.01116728f, -0.01405023f, 0.02891911f, -0.06010587f, 
    -0.02640459f, 0.01686955f, -0.00279619f, 0.03350779f, -0.02157200f, 0.03969135f, 0.02148814f, -0.04313033f, 
    0.03513123f, -0.05248552f, -0.03374796f, 0.02148564f, -0.06554922f, 0.05887279f, 0.00452847f, 0.03671989f, 
    0.06484416f, 0.52257484f, 0.20321430f, -0.02397100f, 0.23732874f, -0.01037658f, 0.01592426f, -0.07308466f, 
    0.02888264f, 0.04010077f, 0.03408969f, 0.10502164f, 0.29750571f, -0.10932485f, 0.14271222f, 0.29928440f, 
    0.02171426f, 0.16490701f, -0.08867583f, -0.10972720f, 0.03488457f, -0.01217952f, -0.01136681f, -0.08678890f, 
    -0.08088847f, -0.00018886f, -0.03671691f, 0.18254372f, -0.15372822f, 0.12658603f, 0.14496090f, 0.04618597f, 
    -0.06201342f, 0.08291883f, 0.25087902f, 0.06063804f, 0.17593698f, 0.38532007f, 0.21389371f, -0.16190058f, 
    0.17354675f, 0.10159373f, 0.01477058f, 0.03391016f, -0.00032639f, 0.11430660f, -0.06174096f, -0.07071677f, 
    0.34671071f, -0.33013943f, -0.23316167f, 0.47762996f, 0.02199524f, 0.06416957f, 0.07168683f, 0.03441975f, 
    -0.03643268f, -0.03963586f, -0.09396245f, -0.00190406f, 0.18681833f, 0.04300420f, 0.31885388f, -0.23932566f, 
    0.05796560f, 0.05763041f, 0.15451607f, -0.12008505f, 0.00987027f, -0.04098886f, 0.06614739f, 0.11565456f, 
    -0.31504074f, 0.13769376f, 0.24788927f, 0.26871353f, 0.00990025f, -0.12752296f, 0.10869554f, 0.05455865f, 
    -0.04346456f, 0.03039397f, -0.11376359f, -0.08666278f, -0.01753886f, -0.28623736f, -0.06565190f, -0.23725662f, 
    -0.18689623f, -0.02195573f, 0.08967571f, 0.07601062f, -0.09427803f, -0.03328912f, -0.04674226f, 0.03677618f, 
    -0.52508247f, -0.08965500f, -0.16858852f, 0.18567544f, -0.06872976f, 0.12027580f, -0.02595385f, 0.05560904f, 
    0.01727892f, 0.08989578f, 0.02718003f, -0.01318774f, -0.12589310f, -0.45739126f, -0.27023840f, 0.17481007f, 
    0.06074979f, 0.00556466f, 0.11187202f, -0.21032670f, -0.02672471f, -0.04440641f, 0.01710860f, -0.00042809f, 
    -0.15320985f, -0.18046437f, 0.04055281f, 0.35157880f, -0.02920205f, -0.07794640f, -0.01308890f, 0.13550590f, 
    0.14270191f, -0.14184399f, -0.10114775f, -0.05077728f, -0.40382445f, 0.13506442f, 0.26773185f, -0.09421685f, 
    0.16509858f, -0.08815777f, 0.22811852f, 0.11233961f, -0.01850248f, -0.07819764f, 0.21263719f, 0.04027870f, 
    0.16248442f, 0.31846106f, -0.11024223f, 0.23960762f, 0.00522158f, 0.00638127f, -0.06410731f, 0.09894224f, 
    0.02468177f, 0.15357673f, 0.15533149f, 0.11555054f, -0.04489443f, -0.12798075f, -0.12531137f, -0.06585925f, 
    -0.00587067f, 0.11130779f, -0.03176695f, -0.00976560f, -0.06676369f, 0.08308396f, -0.02609692f, 0.02742150f, 
    -0.16242780f, -0.09442080f, -0.00123571f, -0.37453225f, -0.05497243f, 0.01108039f, 0.18733741f, 0.18106979f, 
    0.05170443f, 0.04442337f, -0.10844665f, -0.01734793f, 0.06998147f, 0.07811632f, 0.21787491f, 0.19410275f, 
    -0.06076570f, -0.04618903f, 0.01103181f, 0.11322493f, -0.00943850f, 0.07303714f, 0.07106003f, -0.00699250f, 
    -0.30482396f, -0.19907700f, -0.09955353f, -0.04801820f, -0.20451847f, 0.06045863f, 0.09453713f, 0.04349867f, 
    0.00130234f, 0.00583504f, 0.07031124f, 0.02029287f, -0.31514376f, 0.03574074f, 0.05500406f, -0.03283134f, 
    -0.19049434f, 0.02883297f, 0.04615214f, 0.01961770f, 0.34062654f, -0.00989667f, 0.03768449f, 0.06392322f, 
    -0.01961392f, -0.04746524f, -0.10235313f, -0.13745794f, 0.23487893f, 0.11553492f, -0.01334542f, -0.10345818f, 
    0.06375691f, -0.14898868f, -0.17568299f, -0.21378769f, -0.78552336f, 0.03488646f, -0.18808402f, 0.13667297f, 
    -0.10968481f, -0.02865314f, -0.15860447f, 0.00433090f, 0.06544740f, 0.07585078f, -0.03778295f, -0.01926029f, 
    0.15420903f, 0.24041286f, 0.00136051f, -0.15957570f, -0.06200605f, -0.01118437f, 0.03352215f, -0.16271533f, 
    0.14713551f, 0.00438050f, 0.01228647f, 0.13285531f, 0.25267044f, -0.15208115f, -0.26055074f, 0.17349483f, 
    0.11014770f, -0.07853603f, -0.10295697f, 0.10225947f, -0.14330457f, -0.08240669f, 0.08319072f, -0.16791624f, 
    -0.38639849f, 0.00761650f, 0.30366910f, 0.07854677f, -0.00877156f, -0.00718120f, -0.08717512f, 0.02720650f, 
    0.07919730f, 0.06441541f, 0.13074602f, 0.01113850f, 0.11766686f, -0.09959140f, 0.05553792f, 0.06294689f, 
    -0.05162000f, 0.03219307f, 0.05771302f, -0.03155577f, 0.00605050f, -0.02611027f, 0.06123198f, -0.13247700f, 
    0.65921140f, -0.07633039f, 0.22755587f, -0.11027803f, 0.02495046f, -0.16779833f, -0.17675291f, -0.05690756f, 
    0.08786618f, -0.08378631f, 0.12217342f, -0.00771658f, 0.19903485f, 0.28679299f, 0.16010766f, -0.35509875f, 
    0.18657896f, -0.09306542f, -0.15831484f, -0.30684489f, -0.05770221f, -0.01394622f, 0.06755169f, -0.02473204f, 
    0.42176825f, -0.09109220f, -0.04597615f, 0.19748101f, 0.02220058f, 0.06044193f, 0.05981864f, 0.04675332f, 
    -0.06279569f, 0.23842379f, 0.00860813f, 0.21071154f, -0.69656026f, 0.30294111f, 0.05638294f, -0.06534435f, 
    0.11166755f, -0.02339819f, 0.09162372f, -0.02920355f, 0.11113579f, 0.04626736f, -0.18213519f, -0.00174843f, 
    0.49866030f, 0.04059066f, -0.15276836f, -0.13920227f, 0.10666282f, -0.04105084f, 0.03929462f, 0.07617704f, 
    0.12031059f, -0.00886715f, -0.04133502f, -0.11661465f, 0.38315123f, -0.04640130f, -0.10234770f, 0.11246583f, 
    0.12505372f, -0.06738801f, 0.01512945f, 0.04178355f, 0.18551825f, 0.05663395f, 0.03474104f, 0.15032123f, 
    -0.08152869f, -0.07091264f, 0.11982098f, 0.26714718f, 0.15753274f, -0.02578597f, -0.00452667f, -0.09114872f, 
    0.00723169f, -0.12029923f, -0.11285864f, 0.24775794f, 0.46152934f, -0.01638212f, -0.17255646f, 0.38539928f, 
    0.05336035f, -0.08858639f, 0.09554370f, -0.02357290f, 0.15929605f, -0.01532008f, 0.12450724f, 0.05254627f, 
    -0.06360064f, 0.00312525f, -0.00985418f, -0.15819359f, 0.04042491f, 0.08605261f, -0.25965104f, -0.06287912f, 
    -0.01967422f, -0.03237941f, 0.19205941f, -0.10732433f, -0.33803010f, -0.02219313f, -0.08791128f, -0.06396167f, 
    0.02121127f, -0.12250351f, 0.01728408f, 0.14267749f, 0.19497561f, -0.15769891f, 0.13994767f, -0.08408283f, 
    -0.37665719f, -0.28150478f, 0.07493652f, 0.36297828f, 0.00850064f, 0.11262041f, 0.01962537f, -0.02775713f, 
    0.08837435f, 0.02128421f, -0.27719375f, -0.13195641f, -0.28237298f, 0.11743754f, -0.08836178f, -0.26807457f, 
    0.09601445f, -0.01035833f, -0.06160971f, 0.06451289f, 0.06240094f, -0.00006410f, 0.15585405f, 0.00125537f, 
    0.12404992f, -0.04351845f, -0.25804123f, 0.21769531f, 0.19379437f, -0.23661189f, 0.07619764f, -0.27650625f, 
    -0.08487151f, 0.17141032f, 0.04706792f, -0.08447885f, -0.24456595f, 0.09071272f, -0.01572776f, -0.08004077f, 
    0.14820722f, 0.19188850f, -0.14194064f, -0.04858277f, -0.00645838f, 0.10457347f, -0.12831546f, 0.24547040f, 
    -0.03045827f, 0.06591503f, -0.27473673f, -0.14147854f, -0.07264295f, 0.36525252f, -0.03844361f, -0.02708115f, 
    -0.11401768f, 0.02048055f, 0.05193780f, 0.01685929f, 0.48757291f, -0.01865036f, 0.11378621f, -0.12635526f, 
    0.10828286f, -0.08633442f, -0.08027416f, 0.05456013f, -0.03371078f, -0.04812805f, 0.10566889f, 0.14588554f, 
    0.04916570f, 0.21813042f, 0.07496946f, 0.12251563f, 0.34431106f, -0.15211606f, 0.04849874f, -0.13910359f, 
    -0.04503155f, 0.05740310f, -0.01037569f, -0.00607451f, -0.49890369f, 0.10578157f, -0.00179514f, 0.19792691f, 
    0.07466059f, -0.00064775f, -0.06495551f, 0.04395327f, 0.05616932f, -0.09024208f, -0.07644939f, -0.17241099f, 
    0.11509509f, 0.02917723f, 0.01277686f, 0.15870377f, 0.00272917f, 0.06101985f, -0.02959784f, -0.21045388f, 
    -0.17656799f, 0.04207030f, 0.02773746f, 0.19604282f, 0.02932996f, -0.16824651f, -0.08876490f, 0.02864098f, 
    0.07141354f, 0.01394238f, -0.09889008f, -0.13907206f, 0.07073320f, -0.09172948f, -0.03738830f, -0.18819201f, 
    0.02812068f, 0.37076277f, -0.03135531f, -0.04841487f, -0.01416409f, 0.03786053f, -0.01361382f, -0.13184930f, 
    0.14003439f, -0.01513645f, 0.24723321f, -0.28411162f, -0.16243097f, -0.05624419f, 0.02533782f, -0.28918636f, 
    0.00549483f, -0.01069485f, 0.12985303f, -0.04117085f, 0.06324063f, 0.09464727f, -0.08348652f, 0.21363597f, 
    0.29181492f, 0.00522499f, 0.25402731f, -0.04141849f, 0.14580928f, 0.13782547f, -0.10179429f, -0.18742618f, 
    -0.16246010f, 0.06842272f, 0.27141520f, 0.00605810f, 0.30894834f, 0.05193146f, -0.12647595f, 0.18054338f, 
    0.21358491f, 0.09241952f, 0.03879058f, -0.03906057f, 0.07071804f, 0.05883617f, 0.20400196f, 0.15744674f, 
    -0.47683415f, 0.00358722f, -0.11167729f, 0.05519969f, 0.22937126f, 0.01989694f, -0.00901860f, -0.00114910f, 
    0.14486583f, -0.09200929f, 0.17143543f, 0.06979568f, 0.32504559f, -0.04446239f, -0.20287424f, -0.37104189f, 
    0.21328789f, -0.08350725f, -0.09646010f, 0.00590645f, -0.02560328f, -0.03336548f, 0.11025437f, 0.06464382f, 
    -0.67630523f, -0.36368999f, 0.09101538f, 0.21561538f, 0.19486085f, -0.02333780f, -0.06579363f, 0.12345992f, 
    0.10493255f, -0.06096149f, -0.05544923f, 0.14356090f, -0.67724717f, 0.05114080f, -0.18668437f, -0.23648278f, 
    0.07332559f, -0.07665849f, 0.00525876f, 0.13949379f, -0.08420310f, -0.01939716f, -0.17378914f, 0.07710771f, 
    -0.01466644f, 0.02011939f, -0.15209459f, 0.00211100f, 0.15205614f, -0.04359264f, 0.07677740f, -0.13731372f, 
    0.08653185f, 0.14424291f, 0.09416663f, -0.07572309f, 0.05357671f, 0.18254028f, 0.37137476f, 0.21684648f, 
    0.09377652f, 0.13228896f, -0.05967119f, -0.02614750f, 0.11975026f, 0.19095600f, -0.07047281f, 0.13773113f, 
    0.13869050f, 0.00631809f, -0.14935851f, -0.14062922f, -0.08519991f, -0.06162841f, 0.08523698f, -0.05490492f, 
    -0.13690804f, 0.16514315f, 0.18235233f, -0.13379771f, 0.26667461f, 0.02153236f, -0.08594529f, 0.11110950f, 
    0.08442821f, -0.02358590f, 0.07997774f, -0.00407816f, -0.05440884f, -0.01617507f, -0.17418002f, 0.06814324f, 
    0.10402808f, 0.03814544f, 0.07263399f, 0.14062871f, 0.08408593f, -0.01901224f, -0.02110365f, -0.08824801f, 
    0.14657456f, 0.05646414f, 0.01120718f, 0.09791888f, -0.51657110f, -0.11975396f, 0.03952575f, 0.17695156f, 
    -0.05491452f, 0.04284205f, 0.01411066f, 0.24593410f, 0.16694710f, -0.04115095f, 0.06412527f, 0.09080499f, 
    -0.12128557f, 0.16830780f, 0.28644916f, 0.07271851f, 0.07545248f, 0.16100134f, -0.20609456f, -0.19435528f, 
    0.14196624f, -0.02110250f, 0.16266160f, 0.16677296f, -0.33221674f, -0.24910188f, -0.37685958f, -0.03507108f, 
    0.05295105f, 0.00531347f, -0.01124210f, -0.02622379f, -0.01432491f, -0.30770060f, 0.07105852f, 0.08109333f, 
    -0.14051156f, 0.22176261f, 0.32075369f, 0.16467349f, -0.21602379f, 0.05414450f, 0.12123991f, -0.06770179f, 
    0.16616587f, -0.08218478f, 0.14638494f, -0.09876338f, -0.04391796f, 0.00803012f, 0.18563493f, 0.04175008f, 
    0.06937472f, -0.07366944f, 0.11949356f, -0.03209742f, 0.09142764f, 0.03325690f, 0.04647586f, 0.23603936f, 
    0.50557268f, 0.29094744f, 0.20550153f, 0.14268717f, 0.10620968f, -0.02448377f, -0.10606623f, 0.02337077f, 
    -0.11597792f, 0.03507229f, 0.20913787f, -0.04567467f, -0.31319383f, -0.01639764f, 0.40044096f, 0.25301555f, 
    0.00280163f, 0.01338085f, -0.01393617f, 0.02784651f, 0.10915301f, -0.02224976f, 0.02607624f, 0.03000089f, 
    0.48448110f, 0.24511126f, 0.27730069f, 0.13019074f, -0.10149287f, -0.01847991f, -0.14664602f, -0.01537022f, 
    0.04113679f, -0.05741434f, -0.05808266f, 0.03132048f, 0.63315052f, 0.00797090f, -0.00472309f, -0.33063492f, 
    0.17937496f, 0.05023718f, 0.01118056f, 0.16875301f, 0.01587337f, 0.03574166f, 0.00651767f, 0.07971761f, 
    -0.01617400f, 0.28833398f, 0.27097484f, 0.21786854f, 0.06717420f, -0.19322182f, 0.01636386f, 0.25153103f, 
    0.04765828f, -0.02635032f, -0.04358042f, 0.00881095f, -0.03513232f, 0.17938344f, 0.17993596f, -0.03622957f, 
    0.15728113f, -0.08475761f, 0.00763014f, 0.18225239f, -0.12150808f, 0.01952783f, -0.02095706f, 0.11721090f, 
    -0.01648830f, 0.34622049f, 0.25055304f, -0.28714731f, 0.03332319f, -0.15501530f, -0.04377493f, 0.16230963f, 
    -0.01062299f, 0.05665299f, 0.23059344f, -0.09538332f, -0.01285280f, -0.27755961f, -0.02496754f, 0.24453236f, 
    -0.08004937f, 0.00511941f, 0.02049112f, -0.06070050f, 0.07399359f, 0.13213043f, 0.16572130f, 0.15297924f, 
    0.16743349f, 0.26067856f, -0.07131267f, -0.32036993f, 0.18247396f, 0.17594102f, -0.13445273f, 0.15514930f, 
    -0.08406089f, 0.16958517f, 0.01040118f, 0.14803070f, -0.24784817f, -0.00000911f, -0.19949016f, 0.08703787f, 
    0.00619889f, -0.08989843f, -0.05087164f, -0.16463937f, 0.02201114f, 0.00194956f, -0.07222511f, -0.06119299f, 
    -0.00083791f, -0.06736448f, -0.29920608f, -0.31438726f, 0.05047198f, -0.03816414f, -0.09616145f, -0.09549356f, 
    0.01585661f, -0.07099345f, 0.01062072f, -0.02324373f, -0.05088599f, 0.49320623f, 0.09399185f, 0.49955848f, 
    -0.16069233f, 0.21516433f, -0.09640349f, 0.31712702f, 0.05092291f, 0.14408804f, -0.03882289f, -0.10050336f, 
    -0.16339809f, -0.16401626f, -0.18241802f, 0.06005823f, 0.11766887f, -0.21403912f, -0.01021824f, -0.02378925f, 
    -0.14057419f, 0.06501611f, 0.04713121f, -0.14630583f, 0.58150983f, -0.23415335f, -0.03671115f, 0.34180740f, 
    -0.13260983f, 0.09395034f, 0.00647388f, 0.03373552f, -0.05016312f, -0.07796670f, -0.04388666f, -0.04111524f, 
    -0.07525526f, -0.29132503f, 0.17719045f, -0.03011629f, -0.10627384f, 0.19608690f, 0.05452187f, -0.07227398f, 
    0.00102173f, 0.00026819f, -0.03123434f, 0.10387705f, -0.35487413f, 0.16086969f, -0.18986079f, -0.05995476f, 
    0.03125314f, 0.06115783f, 0.07064912f, -0.04134872f, -0.01776787f, -0.07412267f, -0.06302804f, -0.02183770f, 
    -0.15791379f, 0.09586656f, -0.15727128f, -0.01280059f, 0.04137716f, -0.06124597f, -0.21525459f, -0.00252092f, 
    -0.03002991f, -0.05172203f, 0.19008662f, -0.13648073f, -0.41580364f, -0.13438375f, 0.03436844f, 0.02734774f, 
    0.04265304f, 0.07116206f, -0.07832377f, -0.02217235f, 0.01912480f, 0.13946274f, 0.01805892f, -0.15543567f, 
    -0.00720923f, -0.08856978f, -0.18680927f, 0.04340677f, 0.15764312f, 0.28745791f, 0.17285302f, -0.12866259f, 
    -0.03823047f, 0.02800257f, -0.21706887f, 0.05271498f, 0.10487285f, 0.00440558f, -0.10219757f, 0.21647148f, 
    0.23455617f, 0.05633377f, 0.00472987f, -0.06205408f, -0.08897957f, -0.06701989f, 0.19345245f, -0.18522204f, 
    -0.16124003f, -0.06332996f, -0.19769368f, 0.13280633f, 0.08639164f, 0.17869149f, 0.13511293f, -0.08104565f, 
    0.02797146f, 0.08347760f, -0.07611088f, 0.03304974f, -0.25255233f, 0.45318308f, -0.14132935f, -0.06341347f, 
    -0.03513637f, -0.05226680f, 0.15052837f, 0.12501274f, 0.00602125f, 0.00440280f, 0.20947623f, 0.08813773f, 
    -0.34593189f, -0.07184791f, 0.22490589f, 0.44516942f, 0.11304031f, -0.01609297f, 0.05718277f, 0.06792520f, 
    0.12232973f, 0.07100172f, -0.03246225f, -0.10899074f, -0.19343831f, 0.02832930f, 0.03255112f, -0.27427974f, 
    0.13215747f, 0.02778007f, 0.07276206f, -0.03096343f, 0.10260855f, 0.22464566f, 0.06380112f, 0.03817328f, 
    0.00503192f, -0.72086865f, 0.11119367f, 0.34253541f, 0.09362996f, -0.05027362f, -0.05644981f, 0.02214313f, 
    0.04898575f, 0.01358206f, 0.05649294f, 0.19552466f, -0.74242890f, 0.28993896f, -0.04488845f, -0.34349763f, 
    0.19088571f, 0.09920112f, -0.02879794f, -0.12282833f, 0.10251363f, -0.03264917f, -0.06921139f, -0.12222428f, 
    0.18427515f, 0.14007917f, 0.06113004f, -0.11164544f, 0.15170935f, 0.13299170f, -0.06279379f, 0.03316562f, 
    0.03206962f, -0.14856037f, 0.19370915f, -0.03033596f, -0.07757055f, 0.36998206f, 0.01012611f, 0.42561516f, 
    -0.03229944f, -0.03379601f, -0.10183012f, -0.05085729f, 0.01982217f, 0.10391479f, -0.04628453f, -0.02429999f, 
    0.13191137f, 0.23653741f, -0.09674928f, -0.35140067f, 0.11811634f, -0.09192621f, 0.10228095f, 0.14965998f, 
    -0.04373578f, -0.02385533f, 0.13549566f, 0.19491832f, -0.20841622f, -0.13818352f, -0.03035960f, 0.28740549f, 
    0.28389010f, 0.07750925f, -0.01639127f, 0.11965971f, -0.14050302f, 0.01169772f, 0.09759693f, -0.16382396f, 
    0.04079102f, 0.48390126f, 0.24145782f, -0.06741843f, 0.18004571f, 0.11559074f, -0.04828708f, -0.13887626f, 
    0.02418397f, 0.02172554f, 0.03120396f, 0.04203648f, -0.51540095f, 0.56463218f, -0.16834398f, -0.36135545f, 
    0.25241101f, -0.00295311f, 0.10438816f, 0.12410612f, 0.17469217f, 0.07574828f, 0.21274528f, 0.08041562f, 
    -0.34520912f, 0.01113265f, -0.20109183f, -0.64117396f, 0.22671494f, 0.03326972f, -0.10038941f, 0.01303905f, 
    0.09714930f, 0.06990550f, -0.15993559f, 0.13184823f, -0.05993495f, 0.10193314f, 0.23420577f, -0.40812841f, 
    -0.05481302f, -0.03723197f, -0.01536882f, 0.16039160f, 0.01122667f, 0.01852304f, 0.05340232f, 0.11930031f, 
    0.07964204f, 0.27073836f, 0.17287359f, -0.40206423f, -0.23563342f, 0.07071083f, -0.01918454f, -0.17657292f, 
    0.05411452f, -0.18832134f, -0.01475260f, -0.05338611f, -0.05937991f, 0.21971269f, -0.12567122f, -0.05963876f, 
    -0.19545893f, -0.09301122f, 0.14794050f, -0.06080640f, -0.09567513f, 0.14239503f, 0.04472999f, -0.00108531f, 
    0.11516745f, -0.29473910f, 0.47376195f, -0.05691890f, -0.32721797f, 0.03394128f, -0.07055037f, 0.02548719f, 
    -0.06345116f, 0.09047812f, -0.03711924f, 0.24006724f, 0.54655325f, -0.04126931f, 0.21555685f, -0.00687330f, 
    0.24206407f, -0.11277356f, 0.16867439f, -0.09166244f, 0.09397281f, 0.06294462f, 0.09487685f, 0.05845844f, 
    0.28491494f, 0.12264106f, -0.45936838f, -0.02846281f, 0.17016132f, -0.04374949f, -0.19240992f, -0.02148022f, 
    0.03896559f, -0.15538126f, -0.05944892f, 0.11470126f, -0.28762159f, -0.14355597f, 0.26102751f, -0.20837274f, 
    0.24706723f, 0.01952058f, 0.01122311f, 0.04851653f, 0.11010973f, 0.00548303f, -0.10727483f, -0.01643754f, 
    0.17581731f, -0.02774798f, -0.11933359f, -0.19122104f, 0.02049079f, 0.14181274f, -0.09481335f, 0.09035255f, 
    -0.10099595f, 0.04755286f, 0.13609330f, 0.05028258f, 0.33515134f, -0.26633731f, -0.19965315f, 0.05293212f, 
    0.14083418f, -0.07235277f, 0.01187011f, 0.03577628f, -0.07151116f, 0.07840364f, 0.01951082f, 0.22269274f, 
    -0.21428864f, 0.17955084f, -0.17432213f, 0.15172186f, 0.07953491f, -0.01852579f, 0.05831205f, 0.04075768f, 
    0.10431574f, 0.24115801f, 0.08351178f, 0.24456884f, -0.30795777f, 0.30594140f, 0.11609122f, -0.13378832f, 
    -0.06412365f, 0.15438730f, 0.11543331f, 0.20271590f, 0.19405420f, 0.03628083f, -0.20421506f, -0.04691003f, 
    0.21006534f, 0.01402304f, -0.10719144f, -0.02522436f, 0.04269702f, -0.22135836f, 0.06956507f, -0.06001477f, 
    0.28994367f, 0.03137633f, -0.04644717f, -0.11555839f, 0.55985272f, -0.26956144f, 0.14302735f, 0.13513395f, 
    -0.05365463f, -0.02202302f, 0.08304702f, -0.16029207f, 0.00300784f, -0.03263311f, 0.03327854f, 0.13294242f, 
    -0.00736264f, -0.11244512f, -0.08920603f, 0.24094714f, 0.04378742f, 0.21093792f, -0.05930361f, -0.04123839f, 
    0.04121318f, -0.05362020f, 0.06003156f, 0.04347901f, -0.15720996f, -0.16755487f, 0.38640466f, -0.11309479f, 
    -0.00540784f, 0.05634559f, -0.05884930f, -0.01750007f, 0.01492068f, -0.01390077f, -0.02682903f, -0.06316362f, 
    0.21004501f, -0.00834651f, 0.13750333f, 0.00406717f, -0.10555764f, -0.01247442f, -0.07992683f, 0.04232810f, 
    -0.02659100f, 0.05707863f, 0.06725888f, -0.01058776f, 0.12819810f, 0.11751528f, -0.27552393f, -0.29402155f, 
    0.42600486f, 0.09901040f, 0.01693833f, 0.09699700f, 0.21111269f, 0.01242281f, 0.17067954f, 0.00754039f, 
    0.18361723f, -0.15762116f, 0.13989398f, 0.16529533f, -0.03918240f, -0.06967356f, 0.04850620f, 0.01786152f, 
    0.18952984f, 0.08771440f, -0.11916202f, -0.04748930f, 0.23992532f, 0.00810293f, 0.01778921f, 0.06533971f, 
    0.06980540f, 0.08412016f, -0.01073372f, -0.15515883f, 0.02096759f, 0.28279972f, -0.19707426f, -0.10232899f, 
    0.29160681f, 0.36880833f, 0.26627418f, -0.09742890f, 0.29418486f, 0.06715851f, 0.07643202f, 0.05806249f, 
    -0.08476780f, -0.10888813f, 0.06760316f, 0.21948563f, 0.02257963f, -0.05547441f, -0.00610715f, 0.32210773f, 
    -0.04398825f, -0.02011669f, -0.03123445f, -0.02263695f, 0.01533900f, 0.09768169f, -0.15911019f, 0.00974254f, 
    -0.54720366f, 0.13878459f, 0.17283677f, -0.41316459f, -0.03192960f, 0.10037891f, 0.10760246f, 0.08029945f, 
    0.33017573f, -0.06857114f, -0.01656415f, 0.04978466f, 0.23657797f, 0.11525431f, -0.09663364f, 0.26917997f, 
    0.06320189f, -0.15909944f, -0.11520191f, -0.18868430f, 0.05573602f, 0.14907689f, 0.08937141f, 0.04933068f, 
    0.31817687f, 0.29378596f, -0.17502719f, -0.13567597f, 0.03097201f, -0.02377484f, -0.05755943f, -0.01955322f, 
    0.03656692f, 0.09351252f, -0.04352235f, -0.07961392f, 0.11939190f, 0.04356723f, -0.34289315f, 0.05755569f, 
    -0.16718963f, 0.07189978f, 0.04038378f, -0.01372671f, -0.00927161f, 0.17571002f, 0.00732155f, 0.13630043f, 
    -0.03175721f, -0.18089737f, -0.07668632f, -0.66074520f, -0.04748568f, 0.11231245f, -0.11959901f, -0.08400810f, 
    0.00384214f, -0.04263492f, -0.07940179f, 0.21994311f, 0.23837948f, -0.35256538f, -0.17255190f, -0.14368770f, 
    0.10688668f, 0.21591382f, 0.16031660f, 0.02608318f, -0.00260382f, -0.10210992f, 0.12528725f, -0.00131650f, 
    -0.43620342f, -0.07941939f, 0.16816856f, -0.05922934f, -0.14337245f, 0.01180739f, -0.16776049f, 0.02019626f, 
    0.37662917f, 0.08787758f, 0.00671247f, -0.00955783f, -0.01961655f, 0.07589798f, 0.18786725f, -0.04298727f, 
    -0.06800570f, 0.13198878f, 0.05225250f, 0.14020889f, 0.15863959f, 0.07595079f, 0.04489098f, 0.17801893f, 
    -0.12449412f, -0.18662606f, 0.28448263f, 0.13531508f, -0.14531392f, 0.00991063f, -0.12155432f, -0.19817638f, 
    0.05977872f, 0.14528486f, -0.08432445f, 0.20101583f, 0.22563285f, -0.57551426f, -0.21652749f, 0.43213335f, 
    0.10799318f, -0.11789941f, -0.03762127f, -0.06967001f, -0.02247046f, -0.00447659f, 0.01796053f, 0.05119431f, 
    -0.07967124f, -0.03860417f, -0.47938508f, 0.04110184f, -0.12467664f, -0.35392308f, -0.31504303f, 0.15012495f, 
    0.08037332f, -0.04968721f, 0.12875521f, -0.02157982f, -0.28305256f, -0.16526066f, 0.37789711f, 0.03113926f, 
    -0.30398291f, -0.05670399f, -0.28966379f, -0.22210038f, 0.07335010f, 0.10117915f, -0.03082012f, -0.08408234f, 
    0.35785946f, 0.42109516f, 0.10235255f, 0.09462375f, -0.09165104f, -0.05524216f, 0.02157492f, 0.11939678f, 
    -0.19571725f, -0.27130219f, -0.02979295f, -0.02800052f, 0.27858913f, -0.09823385f, 0.22671887f, 0.32232264f, 
    -0.01360522f, 0.14936423f, 0.05089427f, 0.08015940f, 0.06265353f, -0.08226384f, -0.19391266f, -0.12215933f, 
    0.05766834f, 0.27569935f, 0.04580545f, 0.04515427f, -0.00831162f, -0.21855715f, 0.21730284f, 0.20965989f, 
    0.00133708f, -0.07091656f, 0.02254643f, -0.22617961f, -0.38938236f, 0.17606747f, 0.41839793f, 0.32403344f, 
    0.06146995f, -0.12879765f, -0.02962288f, 0.18983839f, -0.30117673f, 0.03556476f, 0.00374797f, 0.10122292f, 
    0.51491457f, -0.00381418f, 0.02536396f, 0.12700808f, 0.01305589f, 0.05192941f, 0.04287464f, 0.10259292f, 
    -0.27005002f, 0.16639568f, 0.08873702f, -0.13541664f, 0.39995092f, -0.26818824f, -0.05602374f, -0.13382405f, 
    -0.18621838f, 0.01965239f, -0.00092133f, 0.16007948f, 0.15841432f, -0.12047613f, 0.20174439f, 0.04035147f, 
    -0.60098600f, 0.22576042f, -0.02092808f, -0.25716537f, 0.08298984f, 0.00178126f, -0.09657891f, 0.22462860f, 
    -0.01397579f, 0.09439836f, 0.05725850f, 0.18032292f, -0.19879636f, -0.29351613f, -0.17087655f, -0.19242777f, 
    0.00259000f, -0.00216238f, -0.09570379f, 0.00498880f, -0.00975234f, 0.03435710f, 0.09267738f, -0.00290185f, 
    0.12683836f, -0.06509861f, -0.27531648f, 0.03685231f, -0.01610174f, 0.09465890f, -0.05173074f, 0.06598753f, 
    -0.02719838f, -0.02827897f, 0.24993791f, 0.05246242f, 0.27558076f, 0.07236601f, 0.10194647f, 0.29716402f, 
    -0.04076558f, 0.03739347f, 0.01746666f, 0.05269648f, -0.08607179f, 0.19461107f, 0.08393992f, 0.05646963f, 
    0.21803352f, -0.32010517f, -0.34848368f, 0.47952491f, 0.20591688f, -0.17195150f, -0.07507169f, -0.07265266f, 
    -0.09686375f, -0.12733085f, -0.13777530f, -0.22305027f, 0.14614157f, -0.06850176f, 0.18673459f, 0.34550279f, 
    -0.15055369f, -0.02336183f, 0.02633841f, 0.00501463f, -0.12059100f, 0.04201091f, -0.11878913f, -0.08430537f, 
    0.66281712f, -0.12879799f, -0.11764529f, -0.00044716f, -0.18129924f, -0.04119874f, -0.09060549f, 0.10652307f, 
    0.04519865f, -0.12072323f, -0.24729295f, 0.19046149f, 0.02233586f, 0.02160718f, -0.38386613f, -0.16394924f, 
    0.02403007f, 0.09642743f, -0.00032745f, 0.05763220f, -0.04483974f, 0.11339449f, -0.16999330f, 0.16495636f, 
    -0.25928658f, -0.25748575f, -0.21807389f, -0.31557432f, 0.00528397f, -0.07087662f, -0.08893856f, -0.00644607f, 
    -0.18894280f, -0.04929738f, -0.04886039f, 0.00696171f, 0.39595312f, -0.17246421f, -0.27282375f, 0.17658171f, 
    0.05585194f, -0.06824050f, -0.06905248f, -0.03124141f, 0.07814123f, 0.04270695f, 0.09378540f, 0.11160056f, 
    -0.10563477f, -0.14828704f, 0.03833522f, 0.06161048f, -0.13137290f, -0.08128920f, -0.11401542f, -0.04021687f, 
    -0.02659895f, 0.12685727f, -0.28190631f, -0.19143721f, -0.08998991f, 0.06350876f, 0.03692314f, -0.20615856f, 
    -0.00569788f, 0.14124313f, -0.08844610f, 0.02201993f, -0.13320544f, -0.02305967f, -0.15250616f, -0.05815205f, 
    0.24593647f, 0.22975436f, 0.28835651f, 0.02916142f, 0.24818619f, 0.00115824f, -0.01804549f, 0.13326836f, 
    0.04132261f, 0.06420702f, 0.05786846f, -0.28182888f, 0.17525418f, -0.17220949f, -0.14822447f, 0.13405032f, 
    -0.21911828f, -0.01917046f, 0.00237871f, -0.11395080f, -0.01537559f, -0.00928013f, 0.07484104f, -0.07329565f, 
    -0.10780615f, 0.28060716f, 0.43728685f, -0.31236836f, -0.04512839f, 0.02596164f, 0.14213793f, 0.12534299f, 
    -0.05818108f, -0.01709894f, -0.01694597f, -0.01125938f, 0.36123583f, 0.11410070f, -0.25056875f, 0.19412035f, 
    -0.09462978f, 0.02177531f, -0.01550615f, 0.00662701f, -0.01405671f, -0.17326732f, 0.12667814f, -0.13214663f, 
    0.49255848f, -0.10436530f, 0.06939368f, -0.04398049f, 0.08935782f, 0.13160834f, 0.18295927f, 0.00235326f, 
    0.08183978f, 0.10476298f, 0.10997929f, 0.05138960f, -0.21263406f, 0.20061523f, 0.01881380f, 0.12136395f, 
    -0.03168485f, 0.03329010f, 0.05469406f, 0.02976689f, -0.00289126f, 0.22165568f, -0.01137889f, 0.04503551f, 
    0.56627363f, -0.08759893f, -0.01499518f, -0.25972387f, -0.02261977f, 0.06772768f, 0.14032038f, 0.08919436f, 
    -0.03706497f, 0.00547401f, 0.04385217f, -0.15173775f, 0.21398942f, 0.25713950f, -0.02829441f, 0.13780124f, 
    0.12906638f, -0.11665780f, 0.10990445f, 0.01528934f, -0.22749619f, 0.08409210f, 0.04464117f, 0.14443052f, 
    0.01698984f, 0.03040893f, 0.05939428f, 0.19538225f, 0.08407532f, 0.00632428f, 0.02203022f, -0.04458069f, 
    -0.10341781f, 0.08258843f, 0.14723688f, -0.17694464f, 0.12367687f, 0.14130615f, 0.21986157f, 0.06148209f, 
    -0.06967495f, -0.05935165f, -0.09450539f, 0.06809328f, -0.05569880f, -0.07176475f, 0.13209404f, 0.02674806f, 
    0.35770693f, -0.13420105f, -0.11845885f, -0.16789623f, -0.05064835f, -0.03137607f, -0.01076662f, -0.06144097f, 
    -0.19558263f, -0.08169687f, -0.01871886f, 0.07410020f, 0.24371719f, 0.24975953f, -0.19508517f, 0.12293194f, 
    0.07814382f, 0.12688585f, -0.09295926f, 0.18535413f, -0.13105284f, 0.00473829f, 0.02024657f, -0.08788002f, 
    -0.04983485f, 0.08722257f, -0.24697778f, 0.27392599f, -0.16780820f, 0.03544962f, -0.02015610f, -0.10187512f, 
    0.06706011f, -0.00144907f, -0.13484544f, 0.12504651f, -0.15059924f, -0.04251746f, -0.16779551f, 0.27267975f, 
    -0.17077351f, -0.01420575f, 0.01592580f, -0.27670696f, -0.06853557f, 0.06107213f, -0.13686913f, -0.07505709f, 
    -0.00751232f, -0.22417556f, -0.10255085f, 0.12812553f, 0.17340407f, -0.11191115f, -0.06460372f, 0.00533791f, 
    -0.01043195f, 0.24744149f, -0.16175382f, -0.13336729f, 0.04118381f, -0.00832711f, 0.07927717f, 0.08436818f, 
    -0.07806576f, 0.08745626f, -0.20272769f, -0.14279947f, 0.01938401f, -0.23960945f, -0.09915976f, -0.09780671f, 
    0.17256320f, 0.22001398f, 0.02755704f, 0.24076755f, 0.25266713f, 0.22391310f, 0.27858850f, 0.25350416f, 
    -0.05135518f, -0.04729601f, 0.19720294f, -0.10292749f, 0.14017482f, 0.17911470f, -0.45268527f, 0.11340220f, 
    0.01162365f, -0.01496488f, -0.10510286f, -0.09282222f, -0.03833957f, 0.24019592f, 0.04508543f, -0.05054108f, 
    -0.34141257f, -0.33533788f, 0.30467564f, 0.15910710f, -0.10919830f, 0.08984882f, 0.17286068f, -0.10512921f, 
    0.02790861f, -0.06829546f, -0.24843362f, -0.26572731f, 0.29667312f, 0.24312645f, -0.27186799f, -0.03044823f, 
    0.14261484f, -0.05467022f, -0.13198911f, -0.11882305f, -0.10952686f, -0.11085547f, 0.13551332f, 0.08373490f, 
    0.24177617f, 0.06084749f, 0.04003137f, 0.53736532f, -0.11875544f, -0.02402063f, -0.00182471f, 0.12351929f, 
    -0.02443657f, -0.05579222f, 0.08141282f, 0.06417230f, -0.09830538f, -0.04695176f, 0.14802983f, -0.36814690f, 
    0.02396931f, 0.10348585f, 0.06321270f, -0.15032469f, 0.14755715f, 0.16319530f, -0.13663065f, -0.06274516f, 
    0.13207686f, -0.18934707f, 0.17586161f, -0.33720994f, 0.07536902f, 0.13612929f, 0.00746102f, -0.06270530f, 
    0.11515623f, -0.02391772f, 0.06905064f, 0.01317788f, 0.30789757f, -0.30227229f, -0.36723441f, 0.18082461f, 
    0.19227275f, -0.16113059f, 0.15675354f, -0.03009434f, -0.13506705f, -0.10070246f, 0.25140584f, 0.20590140f, 
    0.01585920f, 0.01927596f, 0.17926154f, 0.18444857f, -0.00737370f, 0.10471959f, 0.02148693f, -0.14966300f, 
    -0.01975948f, -0.10511234f, -0.13397169f, 0.06907512f, -0.58679909f, 0.27320015f, 0.09302951f, -0.02220899f, 
    0.21029961f, 0.07061898f, 0.06650076f, 0.14397083f, 0.05030429f, -0.00436691f, 0.29731187f, 0.12663251f, 
    0.31734306f, 0.26191157f, 0.02863268f, -0.07266492f, -0.06478586f, 0.05461595f, 0.05583780f, -0.24713619f, 
    0.05222501f, 0.08338878f, 0.14821942f, 0.18139161f, 0.29815891f, -0.14130862f, -0.25784311f, -0.02937715f, 
    0.30639720f, 0.00906665f, 0.14279611f, 0.04707668f, 0.01948385f, 0.13867317f, -0.00243670f, 0.10725193f, 
    0.00328432f, 0.03356832f, -0.34723139f, -0.08154138f, 0.12395093f, -0.01476066f, 0.00569038f, -0.02013978f, 
    0.01506564f, -0.02551512f, -0.17736056f, 0.07476592f, 0.11591293f, 0.14827529f, 0.25226158f, 0.24681337f, 
    -0.23259532f, -0.12684669f, -0.21434808f, -0.27313972f, 0.01659905f, 0.01801829f, -0.04959301f, 0.12120812f, 
    0.00020361f, -0.07432294f, 0.03157320f, -0.14782096f, -0.10959073f, -0.02103081f, 0.18589923f, 0.13113342f, 
    -0.02479433f, -0.17176470f, 0.11110996f, -0.00066518f, -0.08496956f, 0.13401915f, -0.04386089f, -0.00218664f, 
    -0.17046307f, 0.18150023f, 0.18833424f, -0.20809437f, 0.21708332f, 0.26564655f, 0.06133431f, 0.01134661f, 
    0.04748845f, -0.07578646f, 0.15150011f, -0.14230062f, -0.16727152f, 0.09640639f, 0.11500186f, -0.09842705f, 
    -0.21990357f, -0.21292548f, -0.00012012f, 0.05179444f, -0.60529095f, -0.05065497f, -0.11650213f, 0.10372885f, 
    0.17434041f, -0.02970738f, 0.16746840f, -0.11376999f, 0.13034700f, 0.07171606f, -0.06078194f, 0.11102579f, 
    0.23877773f, 0.03436872f, -0.47382477f, 0.01365695f, -0.08523729f, -0.03285921f, -0.04638028f, -0.15825815f, 
    0.06820093f, 0.03872624f, 0.07926878f, 0.30718690f, 0.02450545f, -0.14139815f, -0.10034963f, 0.17620568f, 
    0.08166435f, -0.07704440f, 0.06149871f, 0.05829467f, -0.03242686f, -0.01307084f, -0.13105926f, 0.09301946f, 
    -0.70875883f, 0.40214556f, 0.21759780f, -0.02463247f, 0.02328939f, 0.05889773f, -0.08516668f, 0.06062605f, 
    0.04969770f, 0.05471924f, 0.06514613f, -0.10230336f, 0.46985933f, -0.34968713f, -0.07168135f, 0.21908383f, 
    -0.18128192f, -0.00178082f, 0.07821914f, 0.01761690f, 0.00809453f, 0.04584636f, 0.10876179f, -0.02540239f, 
    -0.01266958f, -0.09366876f, 0.15095752f, 0.01245565f, -0.02306598f, -0.12369356f, -0.00805111f, 0.12809415f, 
    0.06983696f, -0.02194883f, 0.00010327f, 0.23107691f, 0.07681098f, -0.24960889f, 0.04824831f, -0.40967676f, 
    0.03141755f, -0.04904334f, -0.06538724f, -0.17424324f, 0.18110113f, -0.03977887f, 0.03301045f, -0.08407298f, 
    0.16264547f, -0.20781618f, 0.11794550f, -0.06613117f, -0.13212734f, -0.09959302f, -0.09399208f, 0.04238724f, 
    0.28776717f, 0.21651365f, -0.01835079f, 0.32432365f, -0.31591555f, 0.08626269f, 0.11720871f, -0.21094365f, 
    -0.07872150f, -0.06120586f, 0.17988923f, 0.02925906f, 0.12371555f, 0.10201546f, -0.11527960f, -0.02280274f, 
    0.11398109f, 0.00698458f, -0.02443876f, 0.09009835f, -0.04640567f, -0.08167142f, 0.08701081f, 0.16027556f, 
    0.05201137f, 0.15862451f, -0.03272722f, -0.05616892f, 0.23701151f, -0.53454560f, 0.06191773f, 0.34916967f, 
    0.02809902f, 0.08753245f, -0.13697894f, 0.09166228f, 0.12412842f, -0.00715185f, -0.06437598f, 0.04517288f, 
    0.05633681f, -0.12630056f, 0.13629253f, 0.06092365f, -0.09555604f, -0.02275884f, -0.09337730f, 0.11125501f, 
    0.00099925f, -0.17054448f, -0.00287579f, -0.07823777f, 0.60380769f, -0.04407259f, -0.02264249f, 0.11995874f, 
    0.10007377f, -0.01912056f, -0.01084458f, 0.15272941f, 0.27755636f, -0.07025933f, 0.17732261f, 0.05863402f, 
    -0.10389081f, 0.01890980f, 0.02595815f, -0.10856779f, -0.03559658f, 0.00375671f, -0.21148421f, -0.24604374f, 
    -0.01358428f, -0.16154528f, -0.01961324f, -0.10632159f, -0.26220065f, 0.23511937f, -0.10277478f, 0.54537016f, 
    -0.07359084f, -0.27763006f, -0.05780433f, -0.03303469f, 0.05810051f, -0.12670135f, 0.03689584f, 0.00811823f, 
    -0.06155309f, 0.10465971f, 0.19388679f, 0.22737405f, -0.00640386f, 0.21914385f, 0.01371827f, -0.19511883f, 
    -0.01306119f, 0.11155519f, -0.18778284f, -0.03626532f, 0.48212668f, 0.01762226f, 0.00467497f, 0.01616714f, 
    -0.14793833f, -0.15829130f, 0.02240903f, -0.10292839f, -0.01397270f, -0.02542272f, 0.09894726f, 0.01618211f, 
    -0.02538062f, 0.13559157f, -0.33844978f, 0.12120787f, 0.11059400f, -0.24811122f, 0.01522458f, -0.13129333f, 
    -0.00575492f, 0.01485973f, -0.03131329f, -0.14442021f, 0.04913119f, 0.22757447f, 0.13909563f, -0.27371514f, 
    -0.04309193f, -0.06499892f, -0.08645578f, 0.03325294f, 0.04188218f, -0.11975623f, -0.17749882f, -0.03373189f, 
    0.21987137f, -0.67079020f, 0.06804774f, 0.15988183f, 0.08185247f, 0.16407403f, -0.08998974f, -0.15608127f, 
    -0.24967623f, 0.00515243f, -0.06426943f, -0.03775844f, 0.21722534f, 0.02046566f, 0.12525091f, -0.10881732f, 
    0.09800401f, 0.03424184f, -0.09322460f, 0.05168753f, 0.00621909f, 0.08882715f, 0.03589839f, -0.00456991f, 
    0.13682449f, 0.42949185f, 0.07719256f, 0.31164235f, 0.12442788f, -0.11842488f, 0.02206785f, -0.01652061f, 
    -0.09996379f, 0.11155391f, 0.04459402f, 0.05756347f, 0.18263881f, 0.07219433f, 0.05004370f, -0.18415505f, 
    -0.05250407f, 0.07068551f, -0.03513922f, 0.01185014f, 0.08995035f, -0.04205609f, 0.01674236f, 0.00441600f, 
    0.06527002f, 0.13598658f, -0.14240015f, 0.14017542f, -0.05313134f, -0.07980455f, 0.06068719f, -0.17762743f, 
    -0.02646518f, 0.07548456f, 0.01239324f, -0.00094431f, 0.47613269f, 0.00859617f, 0.20455748f, -0.10733587f, 
    0.16740793f, 0.11611106f, -0.04239394f, -0.18548533f, -0.01200384f, 0.01510841f, -0.00083586f, -0.08146866f, 
    0.23287325f, 0.13041124f, -0.45273098f, 0.16736527f, -0.28175819f, 0.02727622f, -0.08352611f, 0.12950622f, 
    -0.11162134f, 0.06289916f, 0.06037993f, -0.08693229f, 0.15275820f, 0.10005981f, 0.30386323f, -0.31118974f, 
    -0.02805060f, 0.10766046f, -0.17181978f, -0.05895119f, -0.10799116f, -0.01100119f, 0.04508152f, -0.17998599f, 
    0.43430498f, 0.08629270f, 0.39224887f, -0.07644130f, 0.00877569f, 0.16895743f, -0.06701049f, -0.20118438f, 
    -0.06406996f, 0.13087051f, 0.16761014f, -0.14040151f, 0.26217604f, -0.00229255f, -0.34678030f, -0.04351966f, 
    0.05973370f, -0.11967877f, 0.02658426f, 0.02427391f, -0.09622993f, -0.18557116f, -0.00188554f, 0.15909243f, 
    -0.31219637f, 0.00706172f, 0.13735564f, 0.25217134f, 0.37268540f, -0.05868454f, 0.05973113f, 0.02593156f, 
    0.05168419f, 0.29492742f, 0.13374873f, 0.07530010f, 0.52423853f, -0.21327618f, 0.23178525f, 0.13234615f, 
    0.17033154f, -0.10431852f, -0.07427826f, 0.10471378f, 0.09871678f, -0.23925106f, 0.04444255f, 0.17800511f, 
    -0.38502550f, -0.24429967f, -0.36440387f, 0.14570665f, 0.18255581f, 0.09640095f, -0.10803212f, -0.08416916f, 
    0.08861305f, 0.00769137f, 0.03485179f, 0.01243297f, -0.30025342f, 0.27561739f, 0.17916732f, -0.32310259f, 
    0.05940953f, 0.01766723f, -0.08217029f, 0.09734128f, -0.06617261f, -0.03866106f, -0.06473476f, -0.00107337f, 
    -0.08311357f, 0.23285361f, -0.01733830f, 0.41191429f, 0.03236787f, -0.05023876f, -0.01949755f, -0.10097700f, 
    0.06187686f, -0.04614658f, -0.02229750f, -0.01454515f, 0.07863583f, -0.05898134f, 0.23406281f, -0.19445913f, 
    -0.01354817f, -0.01955820f, 0.01879880f, -0.04645482f, -0.15911575f, 0.06145144f, 0.16803622f, -0.04266759f, 
    -0.02205214f, -0.37051189f, 0.32052013f, 0.32980272f, 0.00116140f, -0.26968360f, 0.02981104f, -0.00760596f, 
    -0.14155029f, -0.01700549f, -0.05135309f, -0.03510420f, -0.20001160f, 0.14548795f, 0.09617834f, -0.27083853f, 
    -0.00937301f, -0.11560360f, -0.08576344f, -0.03009514f, 0.07274400f, -0.19947179f, 0.03654748f, -0.22914261f, 
    -0.03000848f, -0.01476211f, -0.15328830f, 0.19223128f, -0.00734786f, -0.14199528f, -0.13963081f, -0.14008637f, 
    -0.03037531f, 0.04855330f, -0.13067938f, -0.03903001f, -0.16163635f, 0.12920821f, -0.02018528f, 0.33552378f, 
    0.02725715f, 0.09834310f, -0.28667286f, -0.05921424f, 0.06949503f, 0.07282797f, 0.09053925f, -0.02946394f, 
    0.04558562f, 0.08316220f, -0.03699092f, 0.06419440f, -0.11639857f, -0.04717505f, -0.06811764f, 0.08343373f, 
    -0.20093919f, -0.00776849f, -0.02681332f, 0.06131109f, -0.62906718f, 0.08494739f, -0.15832873f, -0.08332294f, 
    0.31178689f, 0.02656623f, 0.30802932f, 0.04116563f, -0.08163385f, -0.05136905f, -0.05311672f, 0.05224610f, 
    0.08235475f, 0.13750763f, 0.11310033f, 0.06512766f, 0.06174553f, 0.16292076f, 0.03590460f, 0.06173633f, 
    0.07602782f, -0.04394978f, 0.11102267f, 0.04787903f, -0.28981474f, 0.25023866f, -0.01969903f, -0.37901381f, 
    -0.03599256f, -0.18448177f, 0.16968904f, -0.17507647f, 0.16768897f, 0.04073349f, 0.11003415f, 0.15323284f, 
    0.01460062f, -0.07376345f, 0.16104700f, -0.27620167f, 0.14136888f, -0.14611067f, -0.02149298f, -0.06739786f, 
    -0.06841005f, 0.10955007f, -0.05545101f, 0.06840535f, -0.24523978f, -0.05510383f, 0.21497762f, 0.16647026f, 
    -0.14363199f, -0.00306203f, -0.01796188f, 0.07589205f, -0.00528007f, 0.02514473f, 0.02699844f, 0.10899802f, 
    -0.03044042f, -0.05226524f, 0.03203918f, 0.01616826f, 0.02215754f, 0.06567406f, 0.03119247f, -0.04857088f, 
    -0.04153066f, -0.08147841f, -0.05825060f, 0.05592663f, -0.00064518f, -0.06411854f, 0.03944056f, 0.02216537f, 
    -0.04485492f, 0.01952411f, 0.02039820f, 0.03630875f, -0.01824213f, 0.05264954f, -0.06313752f, -0.03110612f, 
    -0.02228575f, -0.03032069f, 0.00875167f, -0.01297101f, -0.06582865f, 0.02680091f, -0.06504578f, 0.03830592f, 
    0.04648708f, 0.03308672f, -0.07566310f, 0.05299542f, 0.04325570f, 0.03954384f, 0.00407457f, -0.07040393f, 
    -0.04505145f, 0.02699998f, 0.04030267f, 0.00439720f, -0.02537754f, -0.02392473f, -0.07491282f, -0.01615876f, 
    0.02693358f, -0.04472494f, 0.00934480f, -0.03229167f, 0.01645977f, -0.07229231f, -0.01711399f, 0.02785185f, 
    -0.07536779f, 0.03373653f, 0.04503166f, -0.04840869f, -0.04446984f, 0.02735553f, -0.03136694f, 0.05813948f, 
    -0.03898882f, 0.04035376f, 0.02677899f, 0.00990142f, -0.04913234f, -0.02705353f, -0.02675764f, 0.02456110f, 
    -0.01233119f, -0.00396208f, 0.01110631f, -0.06016531f, 0.03981921f, 0.00673568f, -0.06491898f, 0.01577168f, 
    0.03579138f, -0.02749638f, 0.05435058f, -0.01556893f, 0.03937353f, -0.03629444f, -0.04657327f, -0.04454937f, 
    -0.01713429f, -0.04130346f, -0.03532042f, -0.01123747f, 0.03159731f, -0.04491579f, -0.02184464f, -0.00021149f, 
    -0.07046197f, -0.02173406f, -0.04530228f, -0.01093095f, -0.03710591f, 0.02927740f, 0.05227184f, -0.00021510f, 
    0.00652499f, 0.05018868f, -0.01392137f, 0.06124938f, 0.01067966f, -0.06574524f, 0.01060957f, -0.07300473f, 
    -0.04956046f, -0.00940260f, -0.03171832f, -0.06817707f, 0.03925295f, 0.05010401f, -0.00615834f, -0.02148193f, 
    -0.04054852f, -0.06984819f, 0.00565530f, 0.02026882f, -0.06791839f, -0.05296950f, 0.06687474f, -0.02919641f, 
    -0.02389377f, 0.03262086f, 0.01483953f, 0.01296805f, -0.06861151f, -0.04485667f, 0.01900070f, 0.01665644f, 
    -0.06570622f, -0.06452633f, 0.01181954f, -0.04156038f, -0.00461299f, 0.04821157f, -0.03722633f, -0.03617999f, 
    -0.00035376f, -0.04268980f, -0.01206012f, -0.00764244f, 0.05663911f, -0.04664281f, 0.00438827f, -0.02207692f, 
    -0.02527397f, -0.01183498f, -0.05480269f, 0.05606963f, -0.03529980f, 0.01726468f, 0.04998521f, -0.05949928f, 
    -0.05342583f, 0.03227327f, 0.01780920f, 0.04783720f, 0.01540148f, 0.03396736f, -0.02293343f, 0.02185421f, 
    -0.03512438f, 0.01446708f, -0.04861533f, -0.02365623f, -0.00250806f, -0.01369443f, 0.05761516f, -0.06981351f, 
    -0.02644705f, -0.03575514f, -0.00038405f, -0.05107488f, -0.03890814f, -0.00718846f, -0.04396948f, 0.01201923f, 
    -0.02142274f, 0.04762403f, 0.00649554f, 0.04495138f, -0.06642255f, 0.06022941f, -0.05558181f, -0.06460307f, 
    -0.01373165f, 0.06171739f, 0.41561013f, 0.21661590f, 0.14495562f, -0.07913314f, -0.15916125f, 0.07785784f, 
    0.13117753f, 0.10388966f, 0.22326946f, 0.05926529f, 0.52892387f, 0.07163114f, 0.24452111f, -0.08791872f, 
    0.10366009f, -0.09931691f, 0.05121179f, 0.17977722f, 0.02964523f, -0.04081511f, -0.01493016f, 0.21271060f, 
    -0.13064934f, 0.11441547f, 0.22912386f, 0.36989111f, 0.21616869f, -0.05225968f, -0.16855831f, 0.02445328f, 
    0.04818654f, -0.06329191f, -0.01854899f, -0.01861431f, -0.22494240f, -0.11072662f, 0.00429940f, -0.24424310f, 
    -0.07408950f, -0.01882380f, -0.17806712f, 0.15722272f, -0.10340471f, -0.06385959f, -0.24955158f, -0.02844199f, 
    0.06641480f, 0.45949250f, -0.12276272f, -0.11607441f, 0.04047909f, -0.13382491f, -0.05163376f, -0.09670179f, 
    -0.11048644f, 0.03639328f, 0.08393679f, 0.00418123f, 0.14390095f, 0.00042716f, 0.02412422f, 0.24720451f, 
    -0.01901326f, 0.12405229f, 0.09282645f, -0.14217012f, -0.04092485f, 0.10830990f, 0.15148497f, 0.05160318f, 
    0.36993730f, 0.21651955f, 0.10257179f, 0.00308849f, -0.00009314f, 0.00606525f, 0.14400759f, 0.00302538f, 
    -0.22441664f, -0.01707669f, -0.10488363f, -0.16362439f, 0.53130525f, -0.06241450f, -0.02478302f, 0.31587431f, 
    -0.17117240f, -0.09779108f, 0.01597356f, 0.04991604f, -0.04465261f, -0.06809337f, 0.07734385f, -0.08942199f, 
    0.10801341f, 0.02467361f, -0.16942281f, 0.02847322f, 0.19778320f, -0.14160286f, -0.07111888f, -0.00444557f, 
    -0.06934273f, -0.02096912f, -0.36631474f, 0.05630663f, -0.01066352f, -0.04660322f, 0.07776337f, 0.16377857f, 
    -0.02914373f, 0.21345730f, -0.17227678f, 0.13440359f, 0.01248183f, -0.00019234f, 0.00232756f, -0.13343476f, 
    -0.39969328f, -0.09419861f, 0.03205975f, 0.08741147f, -0.01545610f, 0.10873613f, -0.07847829f, -0.07786911f, 
    0.00385302f, -0.02144888f, -0.00701339f, -0.08110048f, 0.07887089f, 0.14525892f, -0.08351529f, -0.17472839f, 
    -0.17659162f, 0.11121228f, 0.13335127f, -0.07136322f, 0.13933064f, -0.13217807f, -0.11073480f, 0.14506072f, 
    -0.15157641f, -0.05795906f, -0.00720391f, -0.12450286f, -0.12089405f, -0.00327620f, 0.15534458f, 0.13660432f, 
    0.12545797f, -0.06181848f, 0.11309952f, 0.05456241f, 0.17752303f, 0.02452676f, 0.13597210f, 0.20233743f, 
    -0.10620169f, -0.03180954f, 0.02040908f, -0.05058971f, 0.04388453f, -0.02064971f, -0.09939972f, 0.13380343f, 
    0.39710897f, 0.12307373f, 0.05549750f, 0.29078087f, 0.10613926f, -0.10545426f, 0.03015022f, 0.07973947f, 
    -0.06778732f, -0.05180036f, 0.31332716f, -0.15612431f, -0.46981072f, -0.37139943f, -0.06169366f, 0.26074806f, 
    -0.12224112f, 0.04809633f, 0.04631435f, -0.07749937f, -0.03657276f, 0.00924966f, -0.07376783f, -0.02695120f, 
    -0.15331569f, -0.00232610f, -0.18444335f, -0.07294410f, 0.19436334f, -0.08721785f, -0.06477973f, 0.10643069f, 
    -0.19463722f, 0.05815925f, -0.07754700f, 0.02210232f, -0.44328746f, -0.11556961f, 0.06052622f, -0.02668088f, 
    -0.10614881f, -0.02370502f, -0.26824206f, 0.12698884f, -0.17891769f, -0.14070766f, -0.13591844f, 0.03041513f, 
    0.10566499f, -0.00175399f, 0.11912225f, -0.15006612f, 0.07345998f, 0.13390920f, -0.03127930f, 0.08409077f, 
    -0.00988580f, 0.16840059f, 0.28323835f, 0.00014826f, 0.91384518f, -0.16710158f, 0.12196777f, -0.02996331f, 
    -0.04001065f, 0.06427534f, 0.09554291f, -0.03325995f, 0.01083295f, 0.01829765f, 0.14761071f, -0.10045842f, 
    0.06120350f, -0.24495363f, 0.12373686f, 0.00312412f, 0.00726987f, 0.15499106f, 0.21893793f, 0.10427082f, 
    -0.12722839f, 0.00066188f, -0.10235906f, -0.21880214f, 0.03493482f, 0.17305039f, 0.10716359f, -0.24828485f, 
    -0.10282844f, 0.04585835f, -0.00805620f, 0.11790738f, -0.05146950f, -0.16863516f, -0.03174532f, -0.04162669f, 
    0.61755365f, -0.35164177f, -0.13638882f, 0.07812871f, -0.05173761f, -0.17670009f, 0.18261316f, 0.12589148f, 
    0.03740742f, 0.07315683f, 0.07097062f, 0.18726645f, -0.09730847f, 0.04836388f, 0.08695570f, -0.08611981f, 
    0.13274334f, -0.01456081f, 0.01321188f, 0.19406091f, 0.03874152f, 0.09385817f, -0.01196433f, 0.19863653f, 
    -0.26040795f, 0.15499723f, -0.01246108f, 0.31246388f, -0.10859394f, 0.06550042f, 0.30272609f, 0.06317630f, 
    -0.00042736f, 0.24308002f, 0.19654746f, -0.12961487f, -0.09969334f, 0.00743438f, 0.02210660f, -0.07037636f, 
    0.09457817f, -0.09260342f, 0.37893602f, 0.07954855f, -0.13712920f, 0.07731700f, 0.01348501f, 0.23143773f, 
    0.00947124f, 0.06912019f, 0.02835468f, -0.03613634f, -0.04992570f, 0.09995965f, 0.03758024f, 0.05531164f, 
    0.04546962f, -0.16121180f, -0.11477283f, -0.19938387f, 0.03873882f, -0.01709722f, -0.08762632f, 0.05242397f, 
    0.16891187f, -0.04577437f, 0.04517037f, 0.04511118f, -0.06097886f, 0.02010499f, 0.28002653f, 0.11889327f, 
    0.04355269f, -0.01757542f, -0.08911837f, 0.13541588f, 0.01511976f, -0.02538266f, 0.05862683f, 0.09647837f, 
    0.00597133f, -0.16132459f, 0.08749002f, 0.07660219f, 0.13024670f, 0.24355215f, 0.07482993f, -0.23590587f, 
    -0.05782748f, -0.05178741f, -0.04034730f, 0.02472827f, -0.11791268f, 0.01702871f, 0.11255880f, -0.14994237f, 
    0.30524749f, -0.00948145f, 0.05285867f, 0.20725933f, -0.22425430f, 0.14586550f, 0.33736035f, -0.08966067f, 
    0.22011790f, 0.24160187f, -0.17790310f, 0.03379947f, -0.18688041f, 0.33229929f, -0.09203352f, -0.05333303f, 
    -0.01623452f, 0.07863864f, 0.01806168f, -0.08665937f, -0.10768167f, 0.03402169f, -0.17710896f, 0.10975718f, 
    -0.25313747f, -0.14167793f, -0.12444506f, 0.07139124f, -0.00489705f, 0.03803314f, 0.12805335f, 0.13488458f, 
    -0.02759332f, -0.10779100f, -0.21274023f, -0.01943843f, 0.15132537f, -0.20849548f, -0.09081790f, -0.12230884f, 
    0.17156206f, -0.20577145f, -0.06617076f, 0.08732334f, -0.00836043f, -0.06713438f, -0.09683097f, 0.11880936f, 
    -0.24382836f, -0.12547451f, -0.34689996f, -0.11965162f, 0.10827522f, -0.08944633f, -0.07407482f, 0.12419949f, 
    0.20207888f, 0.24930626f, 0.19756155f, 0.18578392f, -0.56958872f, -0.23952952f, -0.00188081f, 0.36526749f, 
    -0.13289882f, -0.04806615f, -0.00076352f, -0.07350414f, -0.07224609f, 0.04410205f, 0.16741477f, 0.04111063f, 
    0.05746346f, -0.19103561f, 0.54298294f, -0.16453113f, 0.12774967f, 0.13463625f, -0.01159312f, 0.14184625f, 
    -0.02575010f, 0.17644134f, 0.00574435f, -0.20072581f, 0.28150845f, 0.19006611f, 0.04911172f, 0.10523226f, 
    -0.14594860f, 0.02923169f, 0.08921680f, 0.12819235f, 0.15733367f, -0.19281869f, 0.07398035f, 0.14014959f, 
    0.09184331f, 0.04890474f, -0.29405391f, -0.27170104f, 0.04123424f, 0.05416597f, 0.11314479f, -0.03642536f, 
    -0.04620257f, -0.03901573f, 0.05568193f, 0.16883521f, -0.26577625f, 0.10925139f, -0.11981250f, 0.22870892f, 
    -0.01220725f, 0.15442859f, 0.08436307f, -0.01102320f, -0.01748998f, 0.13189499f, -0.08176169f, 0.25419474f, 
    0.22115189f, 0.18371174f, 0.09959698f, 0.04119316f, -0.11002395f, 0.10933632f, 0.01435123f, 0.14716755f, 
    0.08475693f, 0.04752996f, 0.18329979f, -0.03516164f, 0.11995028f, -0.16651551f, 0.08133358f, 0.03239113f, 
    0.12832701f, 0.03868023f, 0.16198269f, 0.12744358f, -0.04049373f, 0.16278468f, 0.13749899f, 0.32092109f, 
    0.05174743f, 0.17982426f, 0.08320778f, -0.24449949f, 0.02759023f, -0.04122813f, -0.12602030f, 0.02041430f, 
    -0.05948975f, -0.10356206f, 0.05841351f, -0.30561432f, 0.46228608f, -0.29862088f, -0.50532192f, 0.11368211f, 
    -0.02388914f, 0.11426748f, -0.34631121f, 0.09942959f, -0.04615501f, -0.03402395f, 0.13861063f, -0.07859661f, 
    0.24122968f, -0.13336858f, 0.17214116f, -0.09473475f, -0.09234030f, 0.02111307f, 0.08230085f, -0.06353721f, 
    -0.12199865f, -0.25594756f, -0.04595271f, 0.00986314f, 0.25090423f, 0.32032910f, 0.14027098f, -0.03567826f, 
    -0.12648766f, -0.07457902f, 0.00796304f, -0.02766628f, 0.00862130f, -0.18230474f, -0.11752640f, -0.04141276f, 
    0.16495463f, 0.23021865f, -0.01864925f, 0.04471060f, -0.06662438f, 0.04033864f, 0.18543409f, 0.09605844f, 
    0.00485546f, -0.05031585f, -0.07222357f, -0.02293975f, -0.17281657f, -0.01970551f, 0.11480895f, -0.28334787f, 
    -0.06282911f, 0.11846297f, 0.14820151f, 0.05918076f, 0.05875517f, -0.07500528f, -0.12468436f, 0.05581051f, 
    0.00166642f, 0.19566192f, -0.05475279f, 0.12503870f, 0.11412521f, -0.17738402f, 0.03950629f, 0.19098121f, 
    -0.01295359f, 0.27986494f, 0.24302508f, 0.17123736f, 0.00537273f, -0.23460843f, 0.15235645f, -0.01050941f, 
    0.03301855f, 0.15598239f, 0.01982100f, 0.12508281f, 0.25714055f, -0.10131215f, 0.13996704f, 0.06889676f, 
    -0.01451681f, 0.03994976f, -0.38560757f, -0.34245420f, -0.02892530f, -0.02656837f, -0.10905147f, 0.03540511f, 
    0.06041083f, -0.11730351f, 0.07191737f, -0.04299083f, -0.26629850f, 0.12463718f, 0.28745618f, -0.09308903f, 
    0.05329707f, 0.12962440f, -0.02770876f, 0.15763462f, -0.01464672f, 0.05656558f, 0.06014148f, -0.03401654f, 
    0.48305967f, -0.06891795f, 0.01537743f, 0.04059473f, -0.13372947f, 0.10337915f, 0.08489811f, 0.10046811f, 
    -0.16931346f, 0.04254733f, -0.02966432f, -0.06071777f, 0.19696926f, -0.21776995f, 0.01395780f, 0.06691854f, 
    -0.14506257f, 0.03607627f, 0.00032142f, 0.11389608f, -0.18481743f, -0.00713450f, 0.09568298f, 0.11866392f, 
    -0.67032909f, 0.43497851f, 0.13121291f, 0.01734450f, 0.06466909f, -0.00895962f, 0.10936280f, 0.17216012f, 
    0.15666428f, -0.00875085f, -0.02684032f, 0.07844117f, -0.13260651f, -0.29525906f, 0.07283390f, -0.42989418f, 
    -0.21559368f, 0.01858978f, -0.01261440f, -0.03676816f, 0.16451487f, 0.07142530f, 0.08200864f, -0.01989297f, 
    -0.21851516f, -0.30882487f, -0.10805167f, 0.32872456f, -0.05069507f, -0.09682608f, -0.02210595f, -0.20815708f, 
    0.02089736f, -0.08035555f, -0.02407423f, -0.07033102f, -0.13487886f, -0.31707793f, 0.03756060f, -0.22772756f, 
    0.01593850f, 0.02619725f, -0.05398147f, -0.13254884f, -0.01517436f, 0.07370546f, 0.22088242f, 0.10908164f, 
    0.32992461f, -0.29695043f, 0.07100476f, 0.67088932f, 0.03180718f, 0.10612950f, 0.13306239f, 0.05330006f, 
    -0.17767949f, -0.06274296f, 0.02204576f, 0.07820944f, -0.45928353f, 0.10352205f, -0.12875842f, 0.03253639f, 
    0.16375771f, -0.16199714f, 0.26152730f, 0.16051611f, -0.00600329f, 0.05305108f, -0.04743312f, -0.06485941f, 
    0.25552407f, -0.11527225f, -0.01095578f, -0.03273429f, 0.13956586f, -0.11355973f, -0.01628302f, 0.10091837f, 
    0.18174244f, 0.02888353f, 0.00499140f, 0.07823447f, 0.06401699f, -0.13118550f, -0.34923536f, -0.14083670f, 
    -0.16101167f, -0.02513623f, 0.26831043f, -0.18770002f, 0.09249404f, 0.04354465f, -0.14534439f, 0.37826380f, 
    -0.16614296f, -0.12560166f, 0.19508742f, -0.02134189f, 0.07136717f, -0.12262784f, 0.12609653f, -0.13430211f, 
    -0.03866293f, -0.00555217f, -0.14008558f, 0.11143950f, 0.40363395f, 0.11993858f, 0.09796607f, 0.56588197f, 
    -0.10798539f, 0.11975986f, 0.13467923f, -0.05721070f, 0.03605598f, 0.05505383f, 0.04235330f, 0.13596407f, 
    -0.16418760f, 0.22642632f, 0.28456759f, -0.02992328f, 0.02057266f, -0.04650154f, -0.05274151f, -0.20825763f, 
    -0.00305323f, 0.21182933f, -0.11336894f, 0.04430614f, 0.47633162f, 0.02186626f, 0.03878187f, -0.29441500f, 
    -0.05389377f, 0.05441796f, 0.01875500f, -0.08439042f, -0.16671586f, -0.04946301f, -0.07292817f, 0.02940429f, 
    -0.05608513f, -0.03313415f, 0.22911745f, -0.01866902f, -0.05992441f, 0.06584886f, 0.10874522f, 0.17468554f, 
    0.02406824f, 0.02997271f, 0.19603640f, 0.16865773f, 0.54949534f, 0.13015844f, 0.23133548f, -0.27057233f, 
    0.31129235f, 0.06574027f, 0.19068478f, 0.02561753f, 0.08946483f, 0.08094253f, -0.00578075f, 0.08125163f, 
    0.02122768f, 0.21031144f, 0.07175148f, 0.19573274f, 0.00826734f, 0.09631969f, -0.08991427f, 0.12401191f, 
    -0.04785828f, -0.19023846f, -0.03903513f, 0.00232173f, 0.08674774f, -0.06604481f, 0.24004416f, -0.06786665f, 
    0.24552625f, -0.03117811f, 0.03224967f, -0.05772240f, 0.16036682f, -0.04708333f, 0.21310322f, -0.01878301f, 
    0.42468971f, -0.14824860f, 0.16237731f, 0.07788954f, 0.08248588f, -0.16695319f, 0.02647801f, 0.16294549f, 
    0.10690396f, 0.16380838f, 0.02903109f, 0.17686382f, -0.29285130f, -0.09504872f, -0.22804953f, -0.05823481f, 
    0.10045477f, -0.03699374f, 0.13388760f, -0.10540796f, 0.01702710f, 0.05828197f, -0.03215988f, 0.09534284f, 
    -0.18518437f, 0.00079166f, -0.20982556f, -0.11243254f, -0.12953769f, 0.11016820f, 0.02975088f, 0.09486588f, 
    0.02471583f, 0.22897974f, 0.04778640f, 0.12303513f, -0.21002357f, 0.47234425f, -0.13224904f, 0.29540530f, 
    -0.08141433f, 0.06800796f, 0.16062030f, 0.07349239f, 0.06830077f, 0.17123383f, -0.16376540f, 0.08066818f, 
    -0.01661596f, -0.09788503f, -0.12700340f, -0.02276775f, 0.11335624f, -0.03236283f, 0.01514448f, 0.03709727f, 
    0.15814224f, -0.10126231f, -0.00906015f, -0.30523753f, -0.26819891f, -0.05506916f, 0.19249988f, 0.16940401f, 
    0.12514760f, -0.11275026f, 0.19690700f, 0.05692312f, -0.20961162f, -0.12539265f, 0.21311438f, 0.22993255f, 
    0.15164970f, -0.07285739f, -0.01808616f, 0.23022044f, 0.16828193f, 0.31839931f, -0.21474576f, 0.00796193f, 
    0.05994431f, 0.14082941f, 0.02643479f, 0.14554819f, -0.28234068f, 0.09460635f, 0.12823103f, 0.00035023f, 
    -0.08603316f, -0.02508856f, 0.05823999f, 0.04340499f, 0.00824710f, 0.11598407f, 0.10934921f, 0.04412578f, 
    -0.17299728f, -0.05858191f, -0.11112215f, -0.04840649f, -0.04790623f, -0.11900269f, 0.07166418f, 0.05682022f, 
    0.07540271f, 0.09057785f, -0.15582550f, 0.06376989f, -0.24993511f, 0.10773727f, -0.00715103f, -0.00722716f, 
    0.03476574f, 0.06351709f, -0.04733211f, -0.08981883f, 0.06552606f, 0.13864186f, -0.05045564f, -0.05776279f, 
    0.43131015f, 0.03571845f, -0.05584510f, 0.15870710f, 0.09658706f, 0.03862075f, 0.04503225f, 0.10961992f, 
    0.10698451f, -0.03494324f, 0.37221733f, 0.05980053f, -0.02840301f, 0.06113330f, -0.07918061f, 0.17063531f, 
    0.09920719f, -0.15876132f, 0.13621055f, 0.13743259f, 0.17269658f, -0.00894989f, 0.20246316f, 0.11964162f, 
    0.13118243f, 0.22646004f, -0.14971018f, 0.15712154f, 0.10581015f, -0.21451938f, -0.06832313f, -0.19649737f, 
    0.07136541f, -0.11077648f, -0.29972312f, -0.02217677f, -0.15325530f, 0.03500688f, -0.04366500f, 0.06910489f, 
    -0.12264974f, -0.02380675f, -0.11292135f, 0.17750944f, -0.08856964f, -0.09685747f, -0.01554198f, 0.05815745f, 
    -0.11353230f, 0.22657923f, -0.09370669f, -0.16401412f, 0.08843757f, -0.24155946f, 0.05709885f, -0.03920639f, 
    0.04579062f, 0.24367206f, 0.13361660f, 0.10949250f, -0.18182872f, -0.13741525f, -0.09070364f, 0.23309693f, 
    -0.25767255f, 0.04985847f, -0.10125414f, 0.01638537f, -0.07968772f, 0.25464454f, -0.02964604f, 0.04103354f, 
    -0.27935132f, 0.07380346f, -0.02672304f, -0.14529364f, 0.05681460f, 0.13813572f, -0.06089831f, -0.17890848f, 
    0.05728715f, -0.10131172f, -0.05400911f, -0.16655633f, 0.32317853f, 0.18568885f, -0.03154509f, -0.07527427f, 
    -0.00791360f, 0.01194957f, -0.15123677f, 0.02863191f, 0.17341766f, -0.00896103f, 0.17994407f, -0.06096708f, 
    -0.01939797f, -0.05104964f, 0.02751922f, 0.00067764f, 0.25353476f, -0.20490433f, -0.00495381f, -0.14014389f, 
    -0.00086560f, -0.17780848f, -0.22454527f, 0.05931175f, 0.13664240f, -0.13274728f, 0.23153095f, -0.28597066f, 
    -0.02552473f, 0.25562373f, -0.17690776f, 0.05359738f, 0.05214841f, -0.07082108f, 0.06328252f, -0.24206153f, 
    -0.18712930f, -0.03083426f, -0.03381303f, 0.15014707f, -0.09744496f, 0.17700905f, 0.05422532f, -0.10730657f, 
    -0.18032940f, 0.13802762f, 0.14437659f, 0.27578115f, 0.54623967f, -0.02336954f, -0.22818676f, -0.13554883f, 
    -0.19696988f, 0.16074571f, -0.04310373f, 0.01028998f, 0.17664364f, 0.15176946f, -0.39529601f, -0.03788321f, 
    -0.38451535f, -0.14791946f, 0.21966401f, 0.00310464f, 0.02535396f, -0.20727015f, 0.23820736f, 0.02467573f, 
    0.12042197f, -0.00965805f, 0.01316778f, -0.01076743f, -0.08331539f, -0.13983591f, -0.14174072f, -0.03909843f, 
    0.09055118f, -0.06309003f, 0.17453210f, -0.02132471f, 0.05756020f, -0.08358724f, 0.01247636f, 0.17678954f, 
    0.04681647f, 0.05598928f, 0.03004619f, 0.00076138f, 0.15947275f, -0.00142257f, -0.08980529f, -0.08155925f, 
    -0.01951819f, -0.00450229f, 0.35299551f, -0.14482018f, 0.06015163f, -0.23907243f, 0.08331908f, 0.14232263f, 
    0.13433991f, 0.07619409f, 0.16694236f, 0.15398546f, -0.13531627f, -0.08787134f, 0.11287527f, 0.09303476f, 
    0.05406879f, -0.03189531f, 0.04965619f, 0.05178921f, -0.04926312f, 0.02341199f, -0.01023055f, 0.02242345f, 
    0.04845479f, -0.04928997f, 0.06257328f, 0.00460717f, -0.03596557f, -0.02722519f, 0.01568133f, -0.01339632f, 
    0.05881876f, 0.00461452f, -0.04967485f, -0.02344519f, 0.05073948f, 0.04541732f, -0.07394633f, -0.01095452f, 
    0.06665868f, -0.07366153f, -0.03795992f, 0.03181789f, -0.02611918f, -0.03928182f, 0.05695699f, -0.00323307f, 
    -0.01484000f, -0.06802677f, -0.00491724f, -0.04973482f, -0.05265184f, 0.00346612f, -0.00333447f, -0.05854800f, 
    0.04505605f, 0.06660276f, -0.00762379f, -0.00322967f, -0.07623591f, -0.06460916f, 0.05677526f, -0.01701725f, 
    0.01069258f, 0.00330237f, 0.05835481f, 0.03582420f, 0.00152270f, 0.02149701f, -0.03384929f, -0.00540329f, 
    -0.04868729f, -0.02998745f, -0.05784009f, 0.02382739f, -0.02501474f, -0.06885529f, -0.02132135f, -0.01321549f, 
    0.06466206f, 0.04059140f, -0.04433785f, -0.02428133f, -0.06915868f, -0.02098636f, 0.00859551f, -0.04068496f, 
    0.02483932f, -0.05330222f, 0.02292773f, -0.06455266f, -0.04889124f, -0.04824141f, -0.03079612f, -0.03414792f, 
    -0.06222660f, 0.04363556f, -0.05926320f, -0.07432018f, 0.01728537f, 0.03230084f, 0.02318035f, -0.06330857f, 
    -0.04486609f, 0.02495131f, -0.05277640f, -0.03537172f, -0.06145366f, -0.02995672f, 0.05391525f, 0.01367806f, 
    -0.03120474f, -0.02409562f, -0.03103590f, -0.05351206f, -0.00437372f, -0.05005237f, -0.03814847f, -0.01378349f, 
    0.04305121f, 0.05380148f, 0.02473454f, 0.04123551f, 0.01166750f, -0.07571343f, -0.06014245f, -0.00513061f, 
    -0.00122325f, -0.01878758f, -0.04360178f, -0.01615392f, -0.04351562f, -0.04893928f, -0.03509113f, 0.02656632f, 
    -0.00951020f, 0.02561399f, -0.04357553f, -0.06462888f, -0.01648819f, -0.01713352f, 0.06394742f, -0.01154861f, 
    -0.01425643f, -0.04269406f, -0.02132338f, 0.05483276f, -0.00179654f, 0.02090158f, 0.02197346f, 0.02065525f, 
    0.05481773f, 0.02600824f, -0.04617942f, 0.00988803f, -0.03239676f, -0.03268136f, 0.04972865f, 0.06240068f, 
    0.02589631f, 0.04124720f, 0.00515938f, 0.06562050f, -0.04467595f, -0.00365598f, 0.00769234f, 0.01206653f, 
    0.00391098f, -0.05725757f, -0.00293859f, -0.03625904f, 0.04190084f, 0.01674792f, -0.04099329f, -0.07719200f, 
    0.01857019f, -0.03786834f, 0.02239422f, -0.07566256f, 0.01497203f, -0.06594183f, -0.03494968f, 0.01063435f, 
    -0.07188848f, -0.07526974f, 0.00208142f, -0.02045539f, 0.05221315f, 0.05007884f, -0.00299398f, 0.00653552f, 
    0.05602926f, 0.02960470f, -0.06271522f, -0.05867449f, -0.02357464f, -0.07701261f, -0.03360401f, -0.03453590f, 
    0.02965327f, 0.03543400f, -0.03829071f, -0.07566830f, -0.00770341f, -0.02235613f, -0.04296363f, -0.05111144f, 
    0.13803032f, 0.23427619f, -0.05434406f, -0.01921411f, 0.06264375f, -0.06506010f, 0.00963192f, 0.04388250f, 
    -0.03674605f, 0.04046424f, 0.14599103f, 0.24737802f, -0.01417076f, -0.14167351f, -0.03302877f, -0.37526369f, 
    -0.11588930f, 0.14830005f, 0.03538847f, 0.11166496f, -0.06613301f, -0.08021718f, 0.08493730f, 0.03348069f, 
    -0.04158855f, -0.23722424f, 0.09412273f, -0.00425130f, -0.29933304f, -0.09609845f, -0.01956418f, -0.02793324f, 
    -0.06386667f, -0.00465823f, 0.10396957f, 0.15947971f, 0.12605889f, 0.06663159f, -0.10087255f, -0.18117207f, 
    0.29168150f, 0.11986009f, 0.05506384f, 0.13457380f, 0.03776168f, 0.11737594f, 0.07879162f, -0.02681786f, 
    0.25942078f, -0.41911671f, -0.15630609f, 0.29276633f, -0.03376187f, 0.05548099f, -0.03584098f, 0.06079502f, 
    -0.06965013f, -0.02992292f, -0.09605453f, 0.03520055f, -0.31370437f, -0.05884391f, 0.10710384f, -0.28655514f, 
    0.21099642f, 0.17864063f, 0.03724564f, 0.07480440f, -0.03371411f, 0.07484708f, -0.04578853f, 0.13825208f, 
    -0.06289010f, 0.54626858f, -0.29090804f, 0.00194478f, -0.16955476f, -0.02953786f, 0.06372637f, 0.17709275f, 
    -0.10430476f, 0.08135688f, 0.21578401f, 0.07521122f, 0.31516042f, -0.38432261f, -0.09021437f, -0.13355592f, 
    0.09212384f, 0.01684608f, 0.13021681f, 0.19626546f, 0.02042855f, -0.08145089f, 0.06037411f, 0.15146342f, 
    -0.47625145f, -0.06553718f, 0.06471133f, 0.29550043f, 0.02065741f, 0.14886893f, 0.15865597f, 0.09803876f, 
    0.09245499f, 0.19549403f, 0.12067628f, 0.11300789f, -0.46524197f, 0.02940503f, -0.07457167f, 0.15778452f, 
    -0.05086327f, -0.09375288f, 0.10619005f, -0.03356830f, 0.12340447f, -0.06491592f, -0.08355091f, -0.03947891f, 
    0.10525528f, 0.06439352f, 0.02405578f, -0.19691569f, 0.01956077f, 0.08719684f, -0.07372082f, 0.00726668f, 
    0.14492224f, -0.16292341f, -0.19537358f, -0.01716754f, -0.39367428f, -0.23537116f, -0.10610716f, 0.21171458f, 
    0.05931835f, -0.18332569f, 0.02530430f, -0.13748853f, -0.04991133f, -0.06360521f, 0.05622936f, -0.01458151f, 
    -0.13731334f, 0.20402542f, 0.01203098f, -0.06736243f, 0.11373252f, 0.08031885f, 0.07349396f, -0.09459183f, 
    0.17811255f, 0.01936861f, 0.10260499f, -0.02221436f, -0.06860883f, -0.22518750f, 0.18114118f, -0.14147958f, 
    0.00198072f, -0.08766171f, 0.15855488f, 0.11887778f, 0.14385906f, 0.03528474f, 0.03181067f, 0.12690219f, 
    0.05527009f, -0.09617484f, 0.04990102f, -0.10573088f, -0.00198416f, 0.03526244f, 0.06216894f, 0.19635439f, 
    0.07596197f, -0.04339456f, -0.01017483f, -0.10112215f, 0.19894315f, 0.21064441f, 0.05446358f, -0.18027586f, 
    0.16814910f, 0.18506069f, 0.01927946f, 0.14077434f, 0.14961082f, 0.14275719f, 0.04203277f, 0.16510849f, 
    0.03895210f, 0.06031227f, 0.00898917f, -0.03240254f, -0.03739825f, -0.03142083f, -0.03525182f, -0.04369796f, 
    -0.05472395f, -0.05559857f, 0.03314912f, -0.02290606f, 0.03411881f, -0.04565150f, -0.03752573f, -0.00599235f, 
    0.00613141f, 0.06282637f, -0.01083248f, 0.03236451f, 0.04646452f, 0.03593801f, -0.07835981f, 0.03816678f, 
    0.04810719f, -0.07175039f, -0.03647399f, -0.03676767f, 0.01993345f, 0.02999524f, 0.04158972f, 0.00152296f, 
    -0.05535010f, -0.05778821f, -0.01547551f, -0.02432922f, 0.03508585f, -0.06873455f, 0.06102791f, -0.06078318f, 
    -0.05151480f, -0.04522038f, -0.06935077f, 0.01402144f, -0.05201907f, 0.05342203f, 0.03178144f, 0.02310211f, 
    0.03600488f, -0.01073576f, -0.02158252f, -0.06483966f, -0.04567915f, -0.04654375f, 0.06272633f, -0.02006884f, 
    -0.02864769f, -0.05574849f, 0.00090406f, 0.03102187f, -0.01714910f, 0.05253909f, -0.06836789f, 0.05396317f, 
    0.06574275f, 0.00347813f, -0.06102950f, -0.02239727f, -0.06792715f, -0.02838780f, -0.00705526f, -0.04442451f, 
    -0.00214153f, -0.01103944f, -0.01676618f, -0.00192017f, -0.01325098f, -0.02078872f, -0.01476473f, -0.00046228f, 
    0.04793317f, -0.07655894f, -0.04796145f, -0.05492842f, -0.04563875f, -0.02229053f, -0.04771777f, -0.01004089f, 
    0.06270688f, 0.01175752f, 0.01969453f, 0.04826299f, -0.03997582f, -0.05187199f, -0.01830627f, 0.01815800f, 
    -0.00215506f, -0.07169079f, -0.05359111f, 0.05024517f, -0.05221023f, 0.04516609f, -0.02859607f, 0.04308231f, 
    -0.01724751f, -0.04269775f, -0.02460242f, 0.00418694f, 0.04684171f, -0.00163034f, 0.04166716f, 0.01626184f, 
    0.02804937f, -0.03040040f, -0.01157381f, -0.05918951f, 0.06159903f, -0.00713709f, 0.03249220f, 0.01379610f, 
    -0.04742311f, -0.06564813f, 0.03455644f, 0.04588910f, 0.04741009f, -0.05083407f, -0.00643082f, -0.04084238f, 
    0.05062008f, -0.06829530f, -0.02021897f, -0.05632485f, 0.03969239f, 0.01674945f, -0.07276528f, -0.04310158f, 
    -0.04011948f, -0.06629580f, -0.05413773f, -0.04973897f, -0.02634572f, -0.06596404f, -0.03470013f, -0.05838848f, 
    -0.01962596f, -0.03188382f, -0.03793551f, 0.00370652f, -0.04443075f, -0.06938214f, -0.03950157f, 0.05145082f, 
    0.01493380f, -0.03914496f, 0.05626989f, 0.03860447f, 0.00131217f, 0.05744485f, -0.05220087f, 0.03980751f, 
    0.01920304f, 0.06095029f, -0.01799547f, 0.04620584f, 0.04285620f, 0.05666357f, -0.06372641f, -0.02667141f, 
    -0.04754438f, 0.00812074f, 0.04343515f, 0.06283514f, -0.06173062f, -0.07437469f, -0.06091542f, 0.02705326f, 
    -0.07560194f, -0.07215414f, 0.04225410f, -0.05635899f, -0.00410725f, -0.07335046f, 0.03296442f, -0.02639396f, 
    0.04696206f, -0.07003906f, -0.03011470f, -0.01267584f, -0.06939425f, -0.05778219f, 0.06147552f, 0.04814054f, 
    0.01038389f, -0.07892322f, 0.01391237f, 0.05182258f, 0.04110593f, -0.01214785f, 0.01239760f, -0.02599486f, 
    -0.01763797f, -0.06809448f, -0.05575034f, 0.03381964f, -0.02022410f, -0.02284117f, 0.03455092f, 0.01650679f, 
    0.03913503f, -0.02545032f, -0.03786594f, -0.05276344f, -0.04074664f, 0.03253497f, -0.03252310f, 0.02310441f, 
    -0.00769524f, -0.02506196f, 0.02358670f, -0.04819377f, -0.01589204f, 0.00974898f, -0.05265820f, 0.02328097f, 
    -0.05787127f, -0.02512192f, -0.00070320f, -0.02945934f, -0.07056617f, -0.01441622f, 0.01993139f, -0.07726793f, 
    0.04921647f, -0.07030214f, 0.04838941f, -0.02042298f, -0.03099584f, 0.02361761f, 0.06118121f, 0.01381560f, 
    0.02547943f, 0.01169564f, -0.05009447f, 0.04907513f, -0.04143154f, -0.03312308f, -0.03056197f, -0.00767039f, 
    -0.03047360f, -0.04879557f, -0.03781609f, 0.00370583f, -0.06263788f, 0.04286238f, -0.03885484f, -0.02854874f, 
    -0.01764907f, -0.04064944f, -0.02990424f, -0.02775950f, 0.03060877f, -0.05091013f, 0.03702138f, -0.07235909f, 
    -0.05525230f, 0.04502730f, -0.03103290f, 0.00568985f, -0.04430149f, -0.04736410f, 0.05659958f, -0.06516122f, 
    0.00662846f, -0.04428493f, 0.00433507f, 0.05641394f, 0.00944742f, -0.06837992f, -0.07910912f, 0.01759710f, 
    -0.02084574f, -0.01437212f, 0.01492360f, -0.03772739f, -0.01256623f, 0.02858541f, 0.05006497f, -0.01122419f, 
    -0.04019980f, -0.02653035f, -0.06041054f, -0.04819545f, 0.01213774f, 0.01488833f, -0.03919708f, -0.07107894f, 
    -0.01210977f, 0.02333701f, -0.03035179f, 0.05726644f, 0.04335937f, 0.04607721f, -0.06844226f, 0.06291425f, 
    -0.01351342f, 0.00188340f, -0.05858414f, 0.04228809f, 0.06016238f, -0.03970544f, 0.00704878f, 0.01605957f, 
    0.04953033f, -0.06738462f, -0.06967825f, 0.02626592f, -0.06842036f, 0.03214793f, 0.02119167f, -0.05028988f, 
    -0.04345459f, -0.04174628f, 0.01646142f, -0.00031445f, -0.03664489f, -0.07704647f, 0.05698866f, 0.06487942f, 
    -0.04368696f, -0.02632001f, 0.00393864f, -0.04669100f, -0.02001691f, 0.00422166f, 0.01245355f, 0.00284007f, 
    0.04786857f, -0.06263418f, 0.00016156f, 0.02957667f, -0.04496625f, 0.02202677f, -0.00279969f, 0.02814010f, 
    0.00927902f, 0.04586805f, -0.05431710f, -0.04417738f, -0.07564151f, -0.05140660f, -0.04529786f, -0.06334868f, 
    -0.01973247f, -0.00357734f, -0.02407961f, -0.01833891f, -0.06454502f, 0.02424791f, -0.07203729f, 0.03371025f, 
    0.06469183f, -0.06280449f, 0.05055963f, -0.00552930f, 0.03070479f, -0.01876649f, -0.02778733f, -0.01325289f, 
    0.03922250f, -0.05957198f, 0.00455940f, 0.03451745f, 0.04035111f, 0.04055829f, -0.00503216f, -0.08034225f, 
    -0.07115076f, 0.05760965f, -0.05284377f, -0.05849499f, 0.03310369f, 0.01085747f, -0.03564473f, 0.06046969f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02739248f, 0.06253512f, 0.03304096f, 0.01585611f, 0.00271116f, -0.00653418f, 0.00344060f, 0.01709166f, 
    0.05533798f, 0.13715000f, 0.16340490f, 0.04324653f, 0.03995636f, 0.10846698f, 0.01224599f, 0.15634234f, 
    -0.10456829f, -0.07165352f, 0.08998919f, -0.12675504f, -0.02100208f, -0.06672759f, -0.01747236f, -0.02648107f, 
    0.01592606f, 0.10999181f, -0.09379548f, 0.13026257f, -0.02745399f, 0.15201798f, 0.02493851f, -0.01288289f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.15368299f, 0.23347528f, -0.14729160f, 0.23653127f, 0.14538957f, 0.44573998f, 0.02189591f, -0.16415390f, 
    0.43325025f, -0.84266835f, -0.49984896f, -0.76286411f, -0.28714857f, -0.48986429f, 0.50013965f, -0.51908267f, 
    0.32015881f, 0.43600872f, 0.27515462f, -0.26809570f, -0.39265588f, -0.10421939f, -0.16865648f, 0.06155791f, 
    -0.09697902f, -0.14351857f, -0.14167581f, -0.39442062f, -0.11374556f, -0.21479620f, -0.06444052f, 0.13914546f, 
    -0.03646803f, 0.20144168f, 0.11445627f, 0.13381040f, 0.11598178f, 0.39269957f, -0.05719904f, -0.24110131f, 
    0.07998885f, 0.24396065f, 0.18781124f, 0.05403734f, -0.43702608f, -0.11414964f, -0.09733476f, 0.47667974f, 
    0.01928854f, -0.34521151f, 0.09744511f, 0.19525592f, -0.35343710f, -0.10778911f, 0.13580997f, -0.09841190f, 
    0.32549453f, -0.07230140f, -0.64483052f, 0.35330391f, -0.15672311f, -0.12618321f, -0.04709391f, 0.07454573f, 
    0.27477837f, 0.36355036f, 0.05829205f, -0.69323051f, -0.40701520f, -0.13850036f, -0.13540137f, -0.44726276f, 
    -0.39981508f, 0.34790775f, -0.38613576f, 0.09569686f, -0.24372384f, 0.24093375f, -0.17911270f, -0.61845809f, 
    0.42600307f, 0.26174253f, -0.64865470f, 0.23141821f, -0.62014228f, 0.13689414f, 0.01110032f, 0.50646794f, 
    -0.24226452f, -0.46517432f, 0.10073821f, -0.14604673f, 0.07791909f, 0.25211981f, -0.08657660f, 0.06140203f, 
    -0.09807814f, -0.41472551f, -0.10065264f, -0.21632439f, -0.35142890f, -0.06487660f, 0.04541569f, 0.20840062f, 
    -0.14797364f, -0.62242323f, -1.14528477f, 0.33907107f, -0.45764413f, 0.02733185f, -0.00695783f, 0.48760334f, 
    0.08980465f, -0.24796738f, -0.16232154f, -0.64452505f, 0.05213351f, -0.04145548f, -0.02518978f, 0.00367913f, 
    0.01230497f, 0.65971321f, 0.35875931f, -0.18779278f, 0.04364235f, 0.03747104f, 0.01381175f, -0.13375416f, 
    -0.87499148f, -0.04466101f, 0.03842973f, -0.41129467f, -0.36220822f, 0.07355920f, -0.16184349f, 0.30051881f, 
    -0.29107392f, -0.02121882f, 0.42451042f, 0.13847627f, -0.03853381f, -0.49592185f, 0.29465201f, -0.15326576f, 
    -0.00007602f, 0.35194713f, -0.13018951f, -0.62248111f, 0.30618367f, -0.06014826f, 0.43803957f, -0.09996878f, 
    0.12184219f, -0.09730401f, 0.13095042f, -0.27728909f, -0.13065732f, 0.18211173f, 0.05168810f, 0.10359684f, 
    0.23805107f, -0.40795505f, -0.05241343f, -0.04722799f, 0.32089117f, 0.24941531f, 0.11901838f, 0.07205096f, 
    0.26055032f, 0.30299264f, 0.10507996f, -0.43674478f, 0.12627159f, -0.52774256f, -0.60287696f, -0.19836017f, 
    -0.21473879f, 0.16009498f, -0.07471263f, 0.16925675f, 0.53767103f, 0.04094249f, 0.03465311f, -0.02467093f, 
    -0.19846417f, 0.35691696f, -0.37246829f, 0.37615541f, 0.02851823f, 0.00357864f, -0.05820283f, 0.06316054f, 
    0.01698165f, -0.17724770f, -0.16394837f, -0.14455809f, 0.20771167f, -0.19579205f, 0.16179855f, 0.40905929f, 
    -0.78269100f, 0.02890206f, 0.05006572f, -0.74169713f, -0.00074789f, 0.57131487f, -0.50273263f, -0.98020709f, 
    -0.37349799f, -0.13668863f, -0.13339643f, 0.46543378f, 0.14332825f, -0.09535680f, -0.26955587f, 0.41603202f, 
    0.00883914f, -0.31695861f, 0.34066972f, -0.83249062f, -0.07054994f, 0.29258913f, -0.15044108f, -0.00182949f, 
    -0.28565636f, -0.41515198f, -0.10808655f, 0.08597577f, -0.04784932f, -0.11652279f, -0.13367924f, 0.27364555f, 
    -0.68964797f, -0.45190841f, -0.77280629f, 0.39523205f, 0.22650695f, -0.19980985f, 0.42024624f, 0.15739150f, 
    0.31916031f, 0.26870868f, -0.62731451f, 0.54164982f, 0.10238482f, -0.06906196f, 0.17797792f, -0.17552127f, 
    -0.39935452f, -0.51919031f, 0.22545953f, 0.02219360f, -0.11479601f, -0.77170998f, -0.16743003f, 0.01662968f, 
    0.07684875f, -0.23154196f, -0.10066666f, 0.20296970f, -0.62461430f, 0.28980711f, -0.12335628f, -0.38214231f, 
    0.38258818f, 0.24270225f, 0.47272202f, 0.23622446f, -0.43062979f, 0.43996757f, -0.10862493f, -0.37396771f, 
    -0.08305284f, -0.85084248f, 0.31649071f, 0.17940603f, 0.17512859f, -0.02324530f, 0.50448078f, -0.45411074f, 
    -0.44837829f, -0.35101613f, 0.07806470f, 0.16977444f, -0.16210823f, -0.02249287f, 0.04033522f, -0.15041879f, 
    0.20408502f, -0.17055333f, 0.10873355f, 0.72870070f, -0.15053387f, -0.33278644f, 0.10960045f, -0.57013381f, 
    -0.13576110f, -0.16010295f, 0.19508827f, 0.29587916f, 0.59835529f, -0.21618107f, -0.11380684f, -0.27947092f, 
    0.25087386f, -0.10111279f, -0.89743888f, -0.24227200f, 0.27976748f, -0.14626133f, -0.18340646f, 0.06549501f, 
    0.55010211f, -0.55212855f, 0.21168703f, -0.35957360f, -0.13812913f, -0.12964314f, 0.01399822f, -0.07610522f, 
    0.50020689f, 0.17609896f, -0.10734794f, -0.67163843f, 0.26736701f, -0.79664153f, -0.14029010f, 0.03874872f, 
    -0.69674784f, -0.07542907f, -0.17488359f, 0.29720041f, 0.18076886f, 0.12788211f, 0.45148715f, 0.03620084f, 
    -0.46395519f, -0.27945206f, 0.27614850f, -0.72335833f, -0.30868524f, -0.06711618f, -0.26768750f, -0.51688528f, 
    -0.47651663f, -0.10413537f, -0.13954929f, 0.63987190f, -0.13402778f, 0.23065569f, 0.09201975f, 0.08853626f, 
    -0.38944811f, 0.07947333f, -0.05746731f, 0.38835609f, -0.37068212f, -0.72452801f, 0.02158388f, 0.25953785f, 
    0.56582338f, 0.37272194f, -0.47341758f, -0.24241626f, 0.25898901f, 0.09187323f, -0.64194322f, 0.39786077f, 
    -0.05768400f, 0.17534725f, 0.39990503f, 0.05703635f, -0.13006176f, 0.04260070f, -0.55055642f, -0.30368346f, 
    -0.20169510f, 0.19812453f, 0.00584259f, -0.58073038f, 0.02998861f, 0.23838583f, 0.11378848f, -0.16272289f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01975056f, -0.03516504f, -0.09823036f, 0.01683925f, 0.14235994f, 0.00373596f, -0.00056300f, -0.09695769f, 
    0.02690049f, 0.16273133f, 0.25480533f, 0.07077289f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
