#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.87514865f, 0.54970133f, 1.01865268f, 0.26994580f, 1.02658439f, 0.41185883f, 0.46823767f, -0.01535993f, 
    -0.99413902f, -0.56602257f, 0.26045758f, 0.25305313f, -0.09656783f, -0.04487338f, -0.16789973f, -0.00675719f, 
    0.14705843f, 0.21992247f, 0.07733251f, 0.19236228f, -0.07789001f, 0.10970731f, 0.17725784f, 0.27347103f, 
    0.21701938f, 1.01382232f, -0.13009286f, -0.62814087f, -1.42175865f, -0.47623858f, 0.22929960f, -0.65983003f, 
    0.33510539f, 0.63328910f, -0.21723773f, -0.78647470f, 0.09800369f, -0.05111071f, -0.30288756f, -0.35653239f, 
    0.06811735f, 0.03320741f, -0.07016538f, -0.12479263f, 0.02065046f, -0.17026804f, 0.17621337f, 0.07372056f, 
    -0.12175738f, 0.14769198f, -0.12484983f, -0.58987546f, 0.16866381f, 0.40218377f, 0.29399231f, -0.12761097f, 
    -0.84480262f, -0.68156672f, -0.39466277f, -0.75107723f, 0.44623789f, 0.50666040f, 0.52975780f, -0.11851004f, 
    0.08449075f, 0.38301891f, 0.13947234f, 0.58275324f, 0.39152506f, -0.17047799f, -0.25816408f, -0.38778704f, 
    -0.38146505f, 0.41573629f, -0.36414197f, 0.79683715f, 0.25200436f, 0.50504935f, 1.19294214f, 0.69900787f, 
    0.79839152f, -0.38864183f, 0.11318828f, 0.44233134f, 0.69453245f, -0.07602066f, -0.40247285f, 0.14495635f, 
    0.29727796f, 0.14986621f, 0.31858188f, -0.38962957f, -0.03434477f, 0.24012102f, -0.24954674f, 0.79880583f, 
    0.52606368f, 0.06779448f, 0.15680857f, 0.15219532f, -1.20173955f, 0.83346963f, 0.79538620f, -0.10730021f, 
    0.46689829f, -0.37118417f, 0.98121804f, 0.21139531f, -0.03977162f, 0.29025123f, -0.65689439f, -0.54719096f, 
    0.49806517f, -0.31993732f, -0.30850559f, -0.16981602f, -0.43959162f, -0.01504958f, -0.33632913f, -0.42118126f, 
    -0.18921061f, 0.08661263f, -0.46398604f, 0.10671343f, -0.05376316f, 0.43443441f, 0.84686452f, 0.63147020f, 
    1.01153874f, 0.54792458f, -1.19288790f, -0.10504183f, -0.94685757f, -0.83313668f, 0.22280236f, 0.47229108f, 
    0.27209905f, 0.18220903f, 0.41709384f, 0.06797666f, -0.06100137f, 0.17068478f, 0.11818810f, -0.27806529f, 
    0.23141868f, 0.41941434f, -0.08592084f, -0.16871735f, 0.34821409f, 0.23102239f, -0.20947202f, -0.31829327f, 
    -0.67763269f, -0.62055171f, -0.49124837f, 0.45780876f, 0.89090753f, 0.71561241f, 0.87102324f, 0.73390323f, 
    0.02409249f, 0.00350399f, -0.06152341f, -0.29263708f, -0.02489203f, -0.10384855f, 0.04718637f, -0.32677728f, 
    0.32386401f, 0.07177997f, -0.38049483f, -0.21019879f, -0.02639580f, -0.41655108f, 0.01581625f, -0.59544164f, 
    1.02161896f, 0.31274369f, 0.42125601f, -0.54266787f, -0.93030375f, 0.02183548f, 0.11219323f, -0.36040014f, 
    -0.54402626f, -0.51141453f, 0.04139262f, -0.29413396f, -0.05078267f, -0.07770655f, -0.02992363f, -0.11867588f, 
    0.26462069f, 0.22267853f, -0.11010399f, -0.46529508f, -0.44016892f, -0.03778894f, -0.35162437f, 0.07869394f, 
    0.03687536f, -0.07598192f, 1.01938939f, 0.06926631f, -0.67716140f, 0.40310976f, -0.29839757f, 0.42174628f, 
    0.10507294f, 0.27866247f, 0.46773046f, -0.44171882f, 0.12380638f, 0.31076661f, 0.47983140f, 0.26062077f, 
    0.19507834f, -0.29852337f, -0.36891520f, 0.63678747f, 0.27458325f, 0.41679332f, -0.12246361f, 0.00470545f, 
    0.59516919f, -0.09999990f, 0.16615778f, 1.01746368f, 0.59258306f, -0.65303606f, -0.46672240f, -0.39815038f, 
    0.55941242f, 0.56080067f, -0.71321708f, -0.29099119f, -0.14239573f, -0.30955461f, -0.36574563f, 0.19658232f, 
    0.06579036f, 0.38633281f, 0.35737872f, 0.07273518f, -0.03722021f, 0.39382142f, 0.10847197f, -0.27121532f, 
    -0.17521363f, -0.58462280f, -0.30659252f, -1.17417479f, -0.71915776f, -0.02677764f, 0.59267217f, -0.30747873f, 
    -0.68411624f, -0.43240884f, -0.35505515f, 0.01832990f, -0.03802956f, 0.62587720f, 0.07380037f, -0.37368396f, 
    -0.23141219f, -0.09567491f, -0.09423397f, 0.34731427f, -0.15914194f, -0.30263931f, 0.00851153f, -0.49143624f, 
    -0.26116157f, -0.18413870f, 0.40545505f, -0.08622308f, 0.62368727f, 0.20760314f, -0.55767882f, -0.76609343f, 
    -1.00910997f, -0.38041109f, -0.32924750f, 0.06260038f, -0.73972732f, 0.18747135f, 0.62228042f, -0.21312936f, 
    -0.21871525f, -0.28689891f, 0.18647258f, -0.04125715f, 0.01887205f, -0.21342216f, 0.02664504f, -0.05292943f, 
    0.41364184f, -0.17235689f, 0.39773825f, -0.27131686f, 0.65786874f, -1.44048631f, 1.17230690f, 0.55638522f, 
    -0.13814574f, 1.01226163f, -0.25811708f, 0.58099735f, -0.20966116f, -0.17168865f, -0.12136725f, -0.33071548f, 
    -0.27723277f, 0.31730607f, -0.17365648f, 0.06155595f, 0.25876501f, 0.22420436f, 0.10334434f, -0.15443130f, 
    0.13441758f, 0.08787102f, -0.10826179f, -0.32256576f, -0.14971462f, 0.81162435f, -1.74307561f, 0.17941073f, 
    0.32155830f, 0.59581220f, -0.95110393f, 1.03691018f, -0.14323547f, -0.40820298f, 0.14750455f, 0.20139909f, 
    0.09676366f, 0.05801845f, -0.21613781f, 0.32252133f, -0.47986174f, 0.07020794f, -0.27289662f, -0.03847857f, 
    -0.36005175f, 0.01568227f, 0.04628660f, -0.02069930f, -0.11705038f, 0.04669878f, -0.54029471f, -0.65015662f, 
    -0.81016731f, -0.66713560f, -0.61688483f, -0.25936118f, 0.21448632f, 0.57053143f, 0.39468360f, 0.54868150f, 
    -0.25064087f, -0.35345611f, -0.21900657f, 0.03887272f, 0.07644700f, -0.05967226f, 0.33440092f, 0.20928971f, 
    -0.48122737f, 0.19392191f, 0.43943459f, -0.17711906f, 0.09279874f, 0.09936416f, 0.15760392f, -0.69081712f, 
    -0.65187204f, -0.97442639f, -0.36115310f, -0.18593328f, 0.73431963f, 0.05050161f, -0.10868354f, 0.58023834f, 
    0.36561695f, -0.45048138f, 0.07838064f, 0.22854091f, -0.57246548f, -0.29398510f, -0.23230258f, 0.26822454f, 
    0.28283003f, 0.21858631f, -0.39151683f, 0.13170812f, -0.28774500f, -0.09184181f, 0.24032132f, 0.16533662f, 
    -0.26232421f, 1.29283047f, 0.56705481f, -0.12337974f, 0.91744983f, 0.19524562f, -0.49283975f, 0.47574866f, 
    0.23114619f, 0.45502195f, -0.61878741f, -0.05319251f, -0.00871285f, 0.73454267f, -0.26678902f, 0.11285400f, 
    0.50617552f, -0.05553434f, -0.01307795f, -0.44842833f, 0.13651749f, 0.07464458f, -0.10789035f, 0.17657487f, 
    -0.05041225f, -0.59421229f, -1.05491781f, -1.10913217f, 0.21948083f, 0.04325083f, -0.44229552f, -0.40260652f, 
    -0.04345013f, -0.14488705f, 0.28826040f, 0.15834571f, 0.30701235f, -0.14175801f, 0.39558926f, 0.47813749f, 
    0.25525105f, 0.14127286f, 0.19298011f, 0.26816079f, 0.53750700f, 0.35296759f, 0.25535586f, -0.01111568f, 
    -0.30620545f, -0.06305724f, -1.10444605f, 0.81967044f, -0.59529829f, -0.57130605f, 0.21324843f, -0.25780228f, 
    0.04284699f, -0.22155713f, 0.09348125f, 0.19832577f, 0.51256114f, 0.08474421f, -0.07670149f, -0.45828247f, 
    -0.19639398f, 0.26090643f, 0.51508111f, 0.53195745f, -0.00151168f, -0.26411635f, -0.11874349f, 0.07821179f, 
    0.14416118f, -0.07364232f, 0.37707898f, -0.80929750f, 0.46568927f, -0.80535048f, 0.00022108f, 0.39947423f, 
    0.76116812f, 0.19240478f, 0.45403886f, -0.01546460f, -0.37676141f, 0.46937534f, -0.54037714f, -0.32455683f, 
    0.08984581f, 0.58079565f, -0.02625356f, -0.40772077f, 0.14418274f, -0.30206126f, -0.25374123f, 0.55108458f, 
    0.39057818f, -0.36861143f, 0.57236701f, -0.17885429f, -0.70355833f, -0.93033624f, 0.14148408f, 1.12155867f, 
    -0.35508424f, -0.63487834f, -0.00025730f, 0.33281827f, -0.42138651f, -0.36849430f, 0.01120004f, 0.44831684f, 
    -0.17890882f, 0.36097407f, 0.01602957f, -0.35396448f, 0.08622908f, 0.25508496f, -0.13630344f, -0.37873915f, 
    -0.12596308f, -0.31086358f, -0.25794992f, 0.31297868f, -0.21959373f, -0.44141829f, -1.26388443f, -0.92256558f, 
    -0.47931811f, -0.06374902f, -0.90592384f, 1.08389175f, 0.68730497f, -0.37594792f, 0.41484171f, 0.52310985f, 
    -0.20868389f, 0.00546577f, -0.26209518f, -0.01415116f, 0.00199340f, 0.03873390f, -0.08408672f, -0.19493659f, 
    -0.21520586f, 0.04148351f, 0.18150030f, 0.19731867f, 0.21361986f, 0.02036761f, 0.93809056f, -0.57575214f, 
    -0.87402296f, -0.41438860f, 0.73307067f, 0.49178639f, 0.15540154f, 0.44139758f, 0.64999622f, 0.57540327f, 
    -0.48271716f, -0.14184050f, -0.29522929f, 0.13729635f, -0.35852486f, -0.01474142f, -0.19911051f, -0.10612018f, 
    -0.02924019f, -0.03914611f, 0.11297777f, -0.10975545f, -0.26465607f, -0.01771505f, -0.31254062f, 1.18108928f, 
    0.92607713f, 0.44154149f, -0.37541470f, -0.99211425f, 0.17525426f, 0.13513014f, -0.92935753f, -0.29255363f, 
    -0.41844648f, 0.27781036f, 0.14803658f, -0.40615651f, 0.10328660f, -0.12558231f, -0.11724979f, -0.30998015f, 
    0.19468068f, 0.15703422f, -0.24614103f, -0.36848116f, 0.01766280f, 0.00058438f, -0.24834082f, -0.08120269f, 
    -1.02158558f, 1.62822759f, 0.29599375f, -0.82544982f, 0.15357339f, -0.62481177f, 0.09942356f, 0.32052445f, 
    -0.82127225f, -0.40142295f, 0.19926706f, 0.30149293f, -0.17820817f, 0.25151047f, 0.01980100f, -0.23923339f, 
    0.00412206f, -0.49237719f, -0.14428028f, -0.00049754f, 0.37376967f, -0.04620233f, 0.27481115f, 0.03835538f, 
    -0.02489943f, -0.50989544f, 0.81434584f, 0.38531744f, -1.04234886f, 0.93731648f, 1.17257488f, -0.20344406f, 
    -1.14685202f, -0.20245525f, -0.76780218f, 0.41106832f, -0.09989560f, -0.32100996f, -0.07369697f, -0.44308585f, 
    -0.12357688f, 0.16888604f, -0.18132296f, -0.32520086f, -0.02246653f, 0.11343531f, -0.09212747f, -0.20408307f, 
    -0.11978763f, -0.02374786f, 1.20185256f, 0.96479285f, -0.38945585f, -0.93976510f, -0.09011356f, -0.48496291f, 
    0.79727334f, 0.08027651f, 0.47620997f, 0.74398106f, 0.32766122f, 0.02861419f, 0.01502247f, -0.33781901f, 
    0.21366496f, 0.10025048f, 0.11236501f, -0.00999259f, 0.07908425f, 0.25409988f, 0.24811132f, 0.17829084f, 
    0.12932883f, -0.03507175f, 0.22916424f, 0.84796590f, 0.94902456f, 0.91805786f, 0.69027168f, 0.10249155f, 
    0.11597202f, 0.26979253f, -0.67116529f, 0.46437520f, 0.67729306f, -0.38024750f, 0.36498141f, -0.57622498f, 
    -0.42686367f, -0.05594325f, 0.05555358f, -0.11574620f, -0.15633436f, -0.37963396f, 0.12259734f, -0.47521520f, 
    0.05602669f, 0.13701074f, -0.27434665f, 0.17768694f, -0.57020903f, -0.89050233f, 0.02703683f, -0.31125379f, 
    0.04273341f, -0.36876372f, -0.58012849f, -0.15852906f, -0.27156752f, -0.47593945f, 0.66087019f, 0.41542011f, 
    -0.08362408f, 0.02226343f, -0.15381189f, 0.79179204f, 0.50376469f, -0.59613329f, 0.01110938f, -0.36522609f, 
    -0.08742898f, 0.18417667f, 0.07049328f, -0.24643594f, 0.00010903f, -0.85606337f, -0.70897877f, -0.34828258f, 
    -0.90820712f, -0.71916753f, -0.54199350f, -0.42852423f, 0.14727713f, -0.46206483f, 0.13219357f, 0.25892207f, 
    -0.04038522f, 0.32034111f, 0.06989451f, -0.01861082f, -0.04253307f, -0.03245260f, 0.02479137f, 0.18826284f, 
    -0.22654019f, -0.13288645f, 0.26131165f, 0.08304293f, 0.34071949f, 0.37387231f, 1.13970459f, 1.04793763f, 
    0.39344671f, 0.37212899f, 0.13183787f, -0.05798857f, -0.69442797f, -0.44946370f, -0.40726644f, 0.19610018f, 
    -0.08218128f, 0.44903371f, 0.20305161f, 0.01854965f, -0.10056428f, 0.14495708f, 0.14273247f, 0.32332140f, 
    0.12999739f, 0.04577029f, 0.22319847f, 0.42269453f, 0.03307280f, -0.38250655f, 0.51112282f, -1.68304169f, 
    0.45183158f, 1.07757473f, -0.65343773f, -0.20434843f, 0.90131670f, 0.85303348f, 0.35789156f, -0.05614031f, 
    0.02036174f, 0.32896465f, 0.11252252f, 0.50346309f, -0.44678041f, 0.08120717f, -0.14329159f, -0.35654455f, 
    0.00268546f, -0.25484321f, -0.15798816f, 0.10792599f, -0.07444336f, 0.50081092f, 0.04612986f, 0.07057449f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01310713f, 0.35964674f, 0.42529240f, 0.30060425f, 0.07131307f, 0.22142728f, 0.20609275f, 0.08322729f, 
    0.17204423f, 0.01593341f, 0.29942030f, 0.18715678f, -0.06158929f, 0.21379091f, 0.24890301f, 0.15758353f, 
    0.19357772f, 0.23146904f, 0.45342675f, 0.18885033f, 0.36436173f, 0.14877693f, 0.07633917f, 0.12600730f, 
    0.23881307f, 0.09757122f, 0.42239842f, 0.34862757f, 0.11571494f, 0.26509103f, 0.03502884f, 0.10979690f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.00623070f, 0.07750885f, 0.00989234f, -0.24790858f, -0.29167378f, -0.01863844f, 0.01093911f, 0.12927215f, 
    0.00340472f, -0.04938161f, 0.01105933f, -0.08506469f, 0.48590571f, -0.05387083f, 0.04894749f, -0.49094301f, 
    0.11449178f, -0.04297325f, -0.03783012f, -0.11460184f, -0.15922335f, -0.03653170f, 0.03587943f, -0.03012019f, 
    -0.18476082f, -0.29305333f, 0.05227573f, 0.05488313f, 0.14515793f, 0.06826608f, 0.01731849f, -0.06287826f, 
    0.13846068f, 0.07344831f, -0.09192415f, -0.08673967f, 0.24658717f, -0.22018769f, -0.14702971f, 0.33422691f, 
    0.05731234f, 0.00602634f, 0.02443487f, -0.09861050f, -0.05777595f, -0.03874927f, -0.05904425f, -0.08034413f, 
    0.05068314f, -0.00950028f, 0.15826024f, 0.18935013f, -0.13943274f, 0.00395519f, 0.07991150f, 0.05608841f, 
    -0.00986771f, -0.10855515f, 0.03398491f, -0.07736538f, 0.19772911f, -0.03550440f, 0.02145668f, 0.26007307f, 
    -0.33916089f, -0.13622585f, 0.04979207f, -0.07394639f, -0.08841083f, -0.04987076f, -0.10870600f, -0.00830351f, 
    0.27772197f, 0.22282661f, -0.07652450f, -0.31260815f, 0.04720469f, 0.00098087f, 0.07351555f, -0.11072738f, 
    0.00404518f, 0.04418353f, -0.05475686f, 0.04557233f, -0.15155582f, 0.24144603f, -0.18736783f, 0.15000378f, 
    0.03263278f, -0.10698038f, 0.06208703f, 0.03594936f, 0.02565735f, 0.02695214f, 0.02992716f, -0.01666295f, 
    -0.14341263f, -0.18289971f, -0.07255748f, 0.09654535f, -0.07143500f, -0.00639735f, -0.00960432f, -0.04081313f, 
    0.14538945f, -0.03445441f, -0.12782370f, 0.25191075f, -0.07858001f, 0.16262293f, -0.13241251f, 0.44408932f, 
    -0.23895665f, -0.00060263f, 0.07282210f, -0.13666688f, -0.01157066f, -0.01828757f, 0.07724144f, -0.00779474f, 
    -0.35557801f, -0.81000185f, 0.09186919f, -0.04137063f, -0.10612201f, 0.08225979f, 0.05198621f, 0.06660556f, 
    0.08324139f, 0.14701402f, -0.04445993f, 0.04052225f, -0.30306315f, 0.04172119f, 0.13136607f, -0.00334311f, 
    -0.12430328f, 0.04405458f, -0.36843130f, -0.00007866f, 0.06052520f, -0.01689090f, -0.01420408f, -0.09976915f, 
    0.03394324f, -0.09131781f, 0.06488608f, 0.37908909f, -0.03004565f, -0.02759643f, 0.22944054f, -0.09354691f, 
    0.00027317f, 0.15067090f, -0.02831323f, -0.04112313f, 0.21692698f, -0.24216701f, 0.09940240f, 0.22906533f, 
    -0.20023635f, -0.21460028f, -0.05156455f, -0.17790717f, -0.19069915f, 0.08265483f, -0.17335059f, 0.06414369f, 
    0.01335771f, 0.16889860f, -0.27098271f, -0.39562044f, 0.12300169f, 0.13425910f, -0.10335567f, 0.06578111f, 
    0.07843976f, 0.03645092f, -0.15184420f, 0.00522876f, 0.33949512f, 0.15395404f, -0.23459300f, -0.29601085f, 
    0.15891171f, -0.04737498f, 0.00926296f, 0.12787206f, -0.08057018f, -0.01924231f, -0.06922857f, 0.06143899f, 
    -0.14493926f, -0.00445032f, 0.19411576f, -0.02518474f, 0.03870855f, 0.00886174f, 0.07635637f, -0.15484880f, 
    0.04257401f, 0.10188755f, -0.14370964f, -0.23803560f, -0.06603943f, -0.18862583f, 0.03865658f, 0.16082066f, 
    0.09277326f, -0.02054289f, 0.10128456f, 0.11318166f, -0.05282579f, -0.36263904f, 0.12038807f, -0.00749843f, 
    0.22822614f, -0.14625379f, 0.07853195f, -0.02528364f, -0.00231893f, -0.09781268f, -0.02715811f, 0.03190827f, 
    0.02262407f, -0.04790913f, 0.00831255f, -0.16057067f, 0.08454432f, 0.03561257f, 0.20737523f, -0.02170779f, 
    0.00525484f, 0.02130859f, 0.13611849f, -0.21706264f, 0.09526058f, -0.04620288f, 0.09576467f, 0.09225263f, 
    -0.24205443f, -0.04228181f, -0.36816698f, 0.30437472f, -0.03744937f, 0.02488416f, 0.11212319f, -0.03449648f, 
    0.20729165f, -0.01859372f, -0.04180457f, -0.04282209f, -0.63888460f, 0.40936959f, 0.04583036f, -0.16384958f, 
    -0.00779571f, -0.02664578f, -0.04190642f, -0.03570997f, -0.00995887f, -0.06827004f, 0.00095956f, 0.16611287f, 
    0.30042341f, 0.09496363f, 0.06272154f, -0.00925427f, 0.16545957f, 0.00173699f, 0.11127097f, -0.08354139f, 
    -0.14124778f, -0.02485734f, 0.07861079f, -0.04352870f, -0.05592123f, 0.23237740f, 0.03998415f, -0.16507919f, 
    -0.12523328f, 0.06566833f, -0.08859779f, 0.06195180f, -0.10941055f, 0.03151983f, -0.10360347f, -0.15261889f, 
    -0.62598205f, 0.27997860f, 0.22337973f, -0.24137402f, 0.06514794f, 0.06557234f, 0.07172784f, 0.09008890f, 
    -0.01306240f, -0.18786559f, 0.07069565f, 0.00000234f, -0.42942917f, 0.03191122f, 0.30232453f, -0.41125405f, 
    -0.07366621f, -0.02219783f, 0.18455230f, -0.17824624f, -0.00846227f, 0.05746097f, 0.05765770f, 0.05608509f, 
    -0.42735687f, 0.01435657f, 0.03039714f, -0.50716740f, -0.05403054f, -0.08474715f, 0.15420052f, 0.04909907f, 
    0.00532026f, 0.08899109f, -0.00355713f, -0.01893690f, 0.07711756f, -0.03056032f, -0.07465550f, 0.34698242f, 
    -0.14385881f, -0.24691612f, -0.12894553f, 0.06469010f, -0.07829393f, 0.05274262f, 0.02700286f, -0.00819007f, 
    -0.47811186f, -0.39117903f, -0.00566134f, 0.17342165f, -0.08778694f, 0.08719518f, -0.05184556f, 0.08705740f, 
    -0.03625209f, 0.19199474f, 0.05459140f, -0.15004437f, -0.38223127f, -0.14390594f, -0.07792855f, -0.21215068f, 
    0.06417081f, 0.02411573f, 0.13921785f, 0.09145964f, 0.08277611f, 0.13562600f, -0.13850680f, -0.05233357f, 
    0.27545083f, -0.02314354f, 0.04019560f, -0.13977583f, -0.21400866f, 0.01048633f, -0.00818346f, 0.10360783f, 
    -0.05158787f, 0.14050795f, -0.12398856f, 0.12755994f, 0.38102821f, -0.12219522f, 0.28416115f, -0.08438036f, 
    0.05315895f, -0.03585192f, -0.02266923f, -0.04155606f, 0.09027307f, -0.04651858f, 0.11852655f, 0.10045516f, 
    0.06207531f, 0.27004969f, 0.21809827f, 0.25918689f, -0.11623485f, -0.02465126f, 0.03319279f, -0.00107273f, 
    -0.11028815f, -0.02661443f, 0.01326568f, 0.07305595f, 0.09643887f, -0.39658976f, 0.24667443f, -0.37742618f, 
    0.06690029f, 0.04700653f, 0.08874360f, 0.02365100f, -0.04949374f, -0.19002645f, 0.20497759f, -0.11089024f, 
    -0.32896581f, 0.02206451f, -0.09515171f, 0.02895166f, -0.04396212f, -0.01065924f, 0.02974654f, -0.17730629f, 
    0.15061507f, 0.02911136f, 0.08579944f, 0.19834392f, 0.12250045f, 0.13845971f, 0.12381405f, 0.31688458f, 
    -0.28144673f, -0.00642219f, 0.10482395f, -0.01112538f, -0.05982874f, 0.15126309f, -0.00925635f, 0.16564281f, 
    -0.05485082f, 0.15763940f, -0.18138205f, -0.08380523f, 0.03856279f, 0.25582963f, -0.01450922f, -0.02709456f, 
    -0.25018549f, -0.02401956f, 0.09372842f, -0.24757998f, -0.01355316f, -0.09706459f, 0.06373864f, 0.02324295f, 
    0.03571077f, 0.05123296f, -0.07424168f, 0.10460413f, 0.17834373f, 0.05215513f, 0.07018361f, -0.02642694f, 
    0.12321062f, -0.20111957f, 0.04089374f, -0.06407070f, 0.17759344f, -0.01951626f, -0.00480279f, 0.12209138f, 
    0.02509929f, 0.03068272f, -0.00783733f, 0.00301110f, -0.19747989f, -0.16341595f, -0.72278184f, -0.22327292f, 
    0.13680169f, 0.15297388f, -0.08260501f, -0.12102034f, 0.01062605f, -0.28850994f, -0.01711049f, 0.12024746f, 
    -0.32168925f, 0.26605853f, 0.07763286f, 0.05677598f, -0.02725745f, -0.10877947f, 0.11625060f, 0.00173529f, 
    -0.04268448f, -0.07210419f, 0.19841683f, -0.05961948f, -0.29323673f, 0.11256570f, -0.27234244f, 0.06647793f, 
    0.06175782f, -0.20831981f, -0.06832211f, -0.05605246f, 0.00266952f, -0.13561027f, -0.29927856f, 0.05627134f, 
    0.09282786f, 0.00689285f, 0.06964001f, -0.15135962f, 0.04037066f, 0.00557491f, -0.25755388f, 0.20451649f, 
    -0.05879860f, -0.33411607f, 0.23678084f, -0.14980574f, -0.13018362f, -0.14930058f, -0.42990008f, -0.40671667f, 
    0.03229019f, -0.00567026f, 0.06620917f, 0.16892445f, -0.11120525f, -0.11703581f, -0.00355712f, -0.00566430f, 
    0.05902294f, 0.04655611f, -0.03967348f, 0.17170312f, 0.01992248f, 0.14302705f, -0.03443826f, -0.01239922f, 
    0.17843464f, 0.17960611f, 0.09718297f, -0.11101852f, 0.06210230f, -0.52130848f, 0.14645693f, 0.12972055f, 
    -0.02497951f, 0.14595406f, 0.03455283f, 0.08024031f, 0.17519866f, -0.04101690f, 0.07217680f, -0.17715730f, 
    0.03772321f, -0.16077021f, -0.01225639f, -0.22614606f, 0.15800247f, 0.00327593f, -0.01680454f, 0.03923054f, 
    0.14951964f, -0.00458810f, 0.06128986f, -0.10005851f, -0.07147925f, -0.16019723f, -0.05455810f, -0.16937019f, 
    0.09394720f, -0.12513924f, 0.00454201f, 0.06864233f, 0.17371748f, -0.13325571f, 0.02383020f, 0.01646769f, 
    0.20410070f, 0.09829747f, -0.07195905f, 0.13549417f, -0.06285904f, -0.05998138f, 0.04117716f, 0.01248909f, 
    -0.07668447f, -0.21961424f, -0.15146108f, -0.05828287f, 0.05413999f, -0.02932517f, -0.12352435f, -0.01460231f, 
    0.02509303f, -0.00264445f, -0.04114433f, 0.13579054f, -0.05921754f, 0.15576585f, 0.19369607f, 0.06390552f, 
    -0.19162308f, 0.06142038f, -0.34897494f, -0.47732061f, -0.00844022f, 0.10108446f, -0.05234779f, 0.09896273f, 
    0.17275473f, -0.05886112f, 0.14354722f, 0.02664754f, 0.08553877f, 0.15086313f, -0.26990965f, 0.04553164f, 
    -0.03525307f, 0.07020485f, -0.20839553f, -0.00338267f, 0.03679579f, 0.02672931f, 0.07465120f, 0.12928544f, 
    -0.34266454f, -0.06606133f, -0.28479049f, 0.30139667f, -0.01687327f, -0.07765515f, -0.15732422f, -0.03158037f, 
    -0.18448067f, -0.18000169f, 0.14160301f, 0.12414094f, 0.56030601f, -0.30655667f, -0.16574740f, 0.09236550f, 
    -0.12394351f, -0.01407558f, -0.01252467f, 0.08313993f, 0.07318676f, -0.11939340f, -0.00212783f, 0.02871180f, 
    0.30674571f, -0.43824840f, 0.26685956f, -0.22089872f, 0.04937353f, 0.05106143f, -0.20606115f, 0.05918378f, 
    0.14942764f, 0.08647457f, -0.05862917f, 0.00453103f, 0.26500976f, -0.20101552f, -0.09587198f, -0.05466713f, 
    -0.04362923f, -0.14721161f, -0.04358741f, 0.02175016f, -0.03406208f, -0.01209065f, 0.10567730f, 0.15679207f, 
    -0.17699561f, 0.19652441f, -0.30286473f, -0.41106242f, -0.01348636f, 0.12030888f, 0.00954709f, -0.10254574f, 
    0.00095022f, 0.21045652f, -0.08776025f, -0.15013428f, -0.07624289f, -0.10052963f, -0.08861317f, -0.22204392f, 
    -0.10978281f, -0.02970166f, -0.08671136f, -0.01252534f, -0.10257219f, 0.05780169f, -0.20141929f, -0.14140035f, 
    0.62561578f, -0.02303782f, -0.12428237f, -0.27284321f, -0.14422779f, -0.23753169f, -0.04506461f, 0.02922518f, 
    -0.05161801f, -0.08024110f, -0.15729779f, 0.16004954f, 0.38989562f, 0.15697843f, 0.17964910f, 0.24012601f, 
    -0.07412633f, -0.02691153f, 0.16861932f, -0.07639405f, -0.10902450f, -0.23476781f, 0.03173348f, -0.15352859f, 
    -0.08092955f, 0.27017176f, -0.10947224f, 0.01043388f, -0.14843151f, 0.04765304f, 0.15614408f, 0.12357239f, 
    -0.01762569f, 0.00671373f, -0.06158264f, 0.14588401f, 0.14207950f, 0.04411745f, -0.01441654f, 0.04699547f, 
    -0.03254912f, 0.01495040f, 0.01340710f, 0.26153299f, -0.01488757f, 0.04999543f, 0.12409520f, 0.07136232f, 
    0.23762691f, -0.11531537f, 0.16598070f, 0.23811135f, 0.05419946f, -0.16815646f, 0.06500644f, -0.00623001f, 
    0.01301607f, -0.17440395f, 0.05714872f, -0.12360347f, -0.42358196f, 0.06780258f, -0.17373504f, -0.04042883f, 
    -0.05798668f, 0.03188437f, 0.05930652f, 0.00028831f, 0.01404008f, -0.04026466f, -0.02671499f, -0.16104555f, 
    -0.06836203f, 0.01331256f, -0.06819745f, 0.02545435f, 0.21080644f, -0.07074212f, -0.02801849f, -0.11388579f, 
    0.13436864f, 0.06540917f, -0.01970515f, 0.01612803f, -0.59854937f, 0.21559508f, -0.16498610f, 0.10123720f, 
    0.02013636f, -0.06772254f, 0.12468755f, 0.03369926f, -0.07951059f, 0.23208874f, -0.04763466f, 0.05201706f, 
    0.07403745f, -0.19476011f, 0.00737037f, -0.05618497f, -0.13740706f, -0.03890513f, -0.10684633f, 0.00500193f, 
    -0.22135009f, -0.08422572f, -0.04429493f, -0.23794587f, -0.01979436f, 0.01642067f, 0.02044162f, 0.00427632f, 
    0.08036607f, 0.00846104f, -0.06739638f, -0.19038007f, -0.08855329f, 0.06370670f, 0.09144915f, -0.07100578f, 
    0.41008204f, -0.30141816f, -0.27884293f, -0.03645979f, 0.01626816f, 0.06865855f, 0.03268685f, -0.00920144f, 
    0.11999312f, 0.15630691f, 0.02440121f, 0.02173505f, 0.24913882f, 0.14532301f, -0.08752795f, 0.01353212f, 
    0.16991773f, -0.01001005f, 0.01576004f, -0.08966710f, -0.11847766f, 0.07009262f, -0.11800724f, -0.01594831f, 
    0.21226992f, 0.22835374f, 0.19579175f, 0.28396711f, -0.12024689f, -0.13230300f, 0.01717159f, 0.26091459f, 
    -0.11192216f, 0.01853989f, 0.02309678f, -0.01484079f, -0.06345887f, 0.15384114f, -0.59503484f, -0.17575069f, 
    -0.00038780f, 0.09529455f, 0.00115013f, -0.05423090f, -0.20457976f, -0.07066981f, -0.06044547f, -0.02868007f, 
    -0.07592118f, 0.20979953f, -0.06442069f, 0.04925299f, -0.01036938f, 0.02476172f, 0.02803056f, -0.13530490f, 
    -0.09662793f, -0.09950585f, 0.01236773f, -0.03825502f, -0.29580256f, 0.11995220f, -0.26803902f, -0.03011355f, 
    -0.00826641f, 0.07312287f, 0.01250958f, 0.05065396f, -0.00633494f, -0.04783392f, 0.08517820f, -0.01626849f, 
    -0.07951294f, -0.46575564f, -0.02038328f, -0.10004938f, -0.02505660f, -0.11066934f, 0.05891640f, -0.17585869f, 
    -0.06150456f, 0.13763028f, 0.01345944f, -0.17557879f, -0.44072586f, -0.05682335f, -0.11471123f, -0.37134308f, 
    -0.00975741f, 0.09715452f, 0.05006149f, -0.10811021f, 0.05926654f, -0.01826134f, 0.08799440f, -0.13550569f, 
    -0.63118172f, 0.00056118f, 0.03506671f, -0.13218963f, -0.17812988f, 0.11405019f, -0.06534589f, -0.01030460f, 
    0.03664141f, -0.14464138f, -0.11483704f, -0.14320311f, 0.73431998f, -0.14505914f, 0.12564589f, -0.26294041f, 
    -0.00793560f, -0.02972585f, -0.03168110f, -0.06052976f, 0.02546625f, -0.01052300f, -0.02704260f, -0.06083872f, 
    0.31696755f, 0.07309032f, 0.09405263f, 0.33087587f, -0.22140406f, -0.14745821f, -0.08437067f, -0.00489463f, 
    0.01152705f, 0.00849780f, -0.04985687f, 0.06464504f, -0.00377078f, 0.14219458f, 0.10034162f, 0.19199556f, 
    -0.19971547f, -0.11047354f, -0.07316959f, 0.03555151f, -0.01814631f, 0.04848570f, -0.12900595f, 0.08102805f, 
    0.09343106f, 0.04073328f, -0.02346670f, 0.09760328f, 0.08128259f, 0.04067909f, 0.13059805f, -0.13819635f, 
    -0.05935892f, 0.02601424f, -0.11293008f, 0.03902630f, 0.38010415f, -0.32588300f, 0.07322865f, -0.02989168f, 
    -0.05344877f, -0.02300579f, 0.13107473f, -0.01133964f, 0.00039680f, -0.14526738f, 0.02553727f, 0.00692247f, 
    -0.03618045f, -0.36888182f, 0.08635027f, -0.10445814f, -0.04754990f, 0.06363400f, -0.01388979f, -0.00289054f, 
    -0.12736149f, -0.01035277f, -0.06727460f, -0.15680751f, -0.05587247f, 0.07308405f, -0.02152822f, -0.02256441f, 
    0.01940254f, -0.10449906f, 0.04013038f, -0.12671612f, 0.19645798f, -0.03594561f, -0.04538747f, 0.11343980f, 
    0.51512283f, -0.13163970f, -0.14821064f, 0.01392234f, -0.26774549f, 0.09519237f, 0.10760348f, 0.02314889f, 
    0.02440203f, 0.05719529f, -0.14829816f, -0.18079062f, 0.53401715f, 0.09176873f, 0.14634719f, 0.38470060f, 
    -0.21846634f, -0.12521909f, -0.00896328f, 0.00703743f, -0.03294432f, 0.08651341f, 0.10730150f, 0.11134733f, 
    -0.02633716f, 0.08770102f, -0.07787066f, 0.15621820f, 0.00472641f, -0.07139419f, 0.11903375f, 0.06328775f, 
    -0.00256096f, -0.13655275f, -0.13098340f, 0.00459429f, -0.03326922f, -0.01508205f, -0.11671733f, -0.35579389f, 
    -0.03974960f, 0.04436092f, 0.03487547f, 0.06432898f, -0.12022907f, 0.05500182f, -0.04393008f, -0.08412767f, 
    0.33401245f, 0.01961372f, -0.45267719f, -0.23522824f, 0.03757275f, 0.14924149f, 0.00886347f, -0.13200718f, 
    -0.15908732f, -0.08627672f, 0.05863127f, 0.02835085f, 0.16994700f, -0.32104784f, 0.00869455f, 0.10023361f, 
    0.03391475f, -0.12040195f, 0.13067526f, -0.16954058f, 0.05650440f, 0.02891640f, -0.06587720f, -0.07920945f, 
    0.03976813f, -0.01205299f, 0.09898304f, -0.05434882f, -0.11763506f, -0.00212158f, 0.00970492f, 0.06201124f, 
    -0.08708271f, -0.08823630f, 0.11719940f, -0.00563671f, 0.17210537f, -0.18574680f, -0.09531434f, -0.13531394f, 
    0.00211447f, 0.16647081f, 0.04168904f, 0.07511751f, -0.00045465f, 0.07156093f, 0.06473562f, -0.03796756f, 
    0.16650422f, -0.30605921f, -0.10200412f, -0.25103348f, -0.06715000f, -0.02077104f, -0.08892870f, 0.03468584f, 
    0.03175318f, -0.21135451f, 0.02177745f, -0.19218093f, 0.08889535f, -0.20397793f, -0.06851612f, -0.15050186f, 
    -0.12267106f, -0.16765229f, -0.20032880f, -0.16128984f, 0.03737088f, 0.00390644f, 0.02095210f, -0.03672509f, 
    -0.24906227f, 0.00803221f, 0.09203625f, -0.35418659f, 0.10997761f, 0.13231307f, 0.03909896f, -0.10364237f, 
    -0.08872689f, 0.12400056f, -0.00646302f, -0.08131588f, 0.53891855f, 0.09303119f, -0.05074981f, -0.05828464f, 
    -0.07591120f, -0.09129483f, -0.06234333f, 0.09882913f, -0.09966751f, 0.08345682f, -0.01807301f, -0.01395496f, 
    -0.59014118f, -0.61890417f, 0.27203691f, 0.17501950f, -0.08754466f, -0.01592495f, -0.04500337f, 0.00482549f, 
    -0.00153847f, -0.10669409f, -0.01625352f, -0.04503133f, -0.04974511f, -0.04827219f, 0.09845425f, 0.10199110f, 
    -0.14461887f, 0.08465238f, -0.09791865f, 0.02816964f, -0.08627591f, 0.18676093f, -0.13454105f, 0.08536915f, 
    0.09469238f, -0.12590532f, 0.15094654f, 0.20883161f, 0.18568954f, 0.02772160f, 0.08094259f, -0.03594978f, 
    -0.07526807f, 0.20919791f, -0.15302502f, -0.08334085f, -0.57929164f, -0.25882342f, -0.48063201f, -0.05696879f, 
    -0.03575256f, 0.00516386f, -0.09664498f, -0.20987448f, 0.00487300f, -0.11344922f, 0.05697688f, -0.06178029f, 
    -0.36453140f, 0.11719564f, 0.01183126f, -0.02492286f, 0.05085518f, -0.01627771f, 0.03034277f, 0.13630109f, 
    -0.01612237f, 0.03837927f, 0.06549150f, 0.04480158f, -0.54486972f, -0.23586796f, 0.06170350f, 0.24430995f, 
    0.03703534f, 0.02183767f, 0.05005325f, -0.10262557f, -0.00292886f, -0.05120243f, -0.01126307f, -0.17345622f, 
    -0.22241922f, 0.13639246f, -0.18281491f, -0.19606683f, -0.03955448f, 0.01477536f, -0.03630948f, -0.04266093f, 
    -0.03400704f, -0.13667899f, 0.04727576f, -0.01043458f, -0.38493434f, 0.24420799f, 0.01025750f, 0.00686326f, 
    -0.09188916f, 0.04588858f, 0.02866066f, 0.24623646f, -0.10887901f, 0.08194958f, -0.01104332f, 0.00146101f, 
    -0.11050154f, -0.05162502f, 0.01198539f, -0.05256605f, -0.01272152f, 0.04611842f, 0.14548820f, 0.09049397f, 
    -0.07217862f, 0.08092947f, -0.03701072f, -0.07803456f, -0.10566284f, -0.00938160f, 0.11355038f, 0.16091302f, 
    -0.02047845f, 0.08190767f, -0.04867385f, 0.08856401f, -0.04412993f, 0.09503824f, 0.14958769f, 0.04079751f, 
    0.23458864f, 0.17578372f, 0.04910325f, 0.09787205f, 0.00394572f, -0.07734101f, -0.07509422f, -0.07773401f, 
    0.11767197f, 0.02035833f, -0.14571126f, 0.10229016f, -0.23273426f, 0.35954154f, -0.00756770f, 0.03028445f, 
    0.01278446f, 0.22044456f, -0.00880700f, 0.11587543f, -0.01081134f, -0.02653591f, 0.12412205f, -0.11801507f, 
    0.20745827f, -0.54280466f, -0.16435125f, 0.12891558f, -0.09214253f, 0.04973349f, 0.04425440f, -0.05179984f, 
    -0.06683452f, 0.07350466f, -0.11282299f, 0.02527483f, 0.00251725f, 0.13741341f, 0.22692221f, 0.29794690f, 
    0.12349191f, 0.21552813f, -0.02455217f, 0.03043223f, 0.00039325f, 0.21129525f, -0.00135860f, 0.03669851f, 
    0.11626919f, -0.03005995f, -0.02142396f, -0.12180933f, -0.09571317f, 0.01068230f, 0.05502471f, -0.01281243f, 
    -0.01682097f, 0.03542573f, -0.07604741f, 0.01994201f, 0.01547979f, 0.06973828f, -0.02873087f, -0.22776447f, 
    -0.25628507f, -0.15285386f, 0.04906209f, 0.08318184f, -0.22493778f, -0.03651094f, 0.02404332f, 0.05410739f, 
    0.21200420f, -0.19392422f, -0.25390679f, -0.01990237f, -0.26323414f, -0.01564295f, -0.05922231f, -0.08742828f, 
    0.02181598f, 0.02838492f, -0.09798713f, 0.11835919f, 0.10071238f, 0.10532567f, -0.14292473f, -0.08832069f, 
    -0.14873587f, 0.05899492f, 0.01914502f, -0.02072096f, -0.02919937f, -0.08322658f, -0.00593532f, -0.13278244f, 
    -0.02456461f, 0.35463774f, 0.09784501f, -0.13391283f, -0.10638014f, -0.09018992f, -0.07257000f, 0.07153213f, 
    0.08354542f, -0.07625820f, -0.24454547f, -0.04149623f, -0.10420971f, 0.31790981f, -0.05385441f, -0.09538536f, 
    -0.07197157f, -0.11716423f, 0.18636745f, -0.08974943f, -0.08905242f, -0.00891971f, -0.05377189f, -0.05496670f, 
    -0.04499623f, 0.19051087f, 0.22078402f, -0.13778250f, 0.10510146f, 0.00541817f, 0.13720003f, 0.10824911f, 
    -0.01597899f, 0.03060783f, 0.12551902f, 0.07029079f, 0.13719329f, -0.17617890f, -0.02554016f, 0.08524776f, 
    -0.08946753f, -0.12311099f, -0.02705120f, 0.07745256f, -0.04420330f, -0.00936722f, -0.12615620f, -0.03705533f, 
    -0.11926336f, 0.21197057f, -0.11616804f, -0.08105167f, -0.06041988f, -0.01823295f, -0.01115871f, -0.14471862f, 
    -0.10741714f, 0.11049488f, 0.11710567f, -0.08426572f, 0.05617619f, 0.14116137f, -0.33532885f, 0.14688876f, 
    -0.24612992f, -0.04913369f, -0.01880110f, 0.10034135f, -0.05441799f, 0.15324825f, 0.05746343f, -0.12719770f, 
    0.08255334f, 0.24722271f, 0.25499657f, -0.18534006f, 0.13794862f, 0.02593344f, 0.02249504f, 0.04759885f, 
    0.00153786f, 0.14379844f, -0.01428096f, -0.07662965f, 0.83065212f, 0.12612402f, 0.23295251f, 0.18491051f, 
    0.04004836f, -0.10820996f, -0.16153055f, 0.08273480f, -0.14311053f, -0.04599387f, -0.00286444f, -0.12547734f, 
    -0.24325085f, -0.38329625f, -0.16725175f, -0.07273950f, -0.11283217f, 0.08242152f, -0.05706247f, 0.14107452f, 
    -0.09314886f, -0.02579486f, -0.04557270f, 0.11462193f, -0.36915213f, -0.41575149f, -0.52524930f, 0.08490515f, 
    -0.10535322f, -0.01759111f, 0.03187399f, 0.09058585f, 0.05043861f, -0.02791358f, 0.02483179f, 0.04739958f, 
    -0.02845178f, 0.08344526f, -0.01514901f, 0.20901071f, -0.02989161f, -0.10000247f, -0.11928362f, -0.05578615f, 
    0.05499513f, -0.04562218f, 0.15405267f, -0.08027810f, 0.27110964f, 0.03654306f, 0.08632396f, -0.15984148f, 
    -0.13880935f, -0.24056856f, -0.08750413f, -0.08216428f, -0.00098789f, -0.11480036f, -0.02300590f, 0.08370307f, 
    0.18795748f, -0.45022997f, -0.42035288f, 0.29851550f, 0.00255919f, 0.02318050f, -0.04685002f, -0.03595670f, 
    0.05984784f, -0.05865821f, -0.15043594f, -0.05541934f, -0.27286285f, 0.25656819f, 0.13896911f, -0.14717034f, 
    0.02464626f, -0.02507968f, 0.06368747f, 0.11986634f, 0.13985652f, -0.06515697f, 0.02797312f, 0.00142323f, 
    -0.03980306f, 0.18751135f, 0.07051161f, -0.20262656f, 0.11874770f, -0.05166610f, -0.09060918f, 0.05169423f, 
    0.03408717f, -0.07295029f, 0.10074818f, -0.11426894f, -0.03666428f, -0.27567476f, -0.23010617f, 0.02342427f, 
    -0.05668282f, 0.03860047f, 0.03072178f, 0.00665803f, -0.06513119f, 0.00254030f, 0.05899101f, 0.11338136f, 
    -0.04469557f, -0.01571302f, 0.10765386f, 0.10062207f, -0.00466793f, -0.06679422f, -0.01556995f, 0.12674382f, 
    0.07595273f, -0.20979179f, -0.00243066f, -0.08878721f, -0.02931727f, 0.04721270f, -0.06273640f, 0.20854828f, 
    -0.01710266f, -0.02610247f, -0.06382107f, 0.07230011f, 0.08780448f, -0.16570868f, 0.05624871f, -0.07764934f, 
    -0.25743058f, 0.51448458f, -0.06937733f, -0.08566885f, -0.01223150f, -0.05441241f, 0.05946509f, 0.09013559f, 
    0.09420697f, 0.05895240f, -0.00664146f, 0.14024179f, -0.56303072f, -0.19628690f, 0.33276099f, 0.20779844f, 
    -0.19278705f, -0.03528483f, -0.12039305f, -0.13305466f, 0.10306017f, -0.01534560f, -0.21012989f, -0.00470687f, 
    -0.31192461f, 0.09543598f, 0.18041325f, 0.24887219f, -0.02126472f, 0.17674048f, 0.05330896f, 0.16301043f, 
    0.01894987f, 0.14078204f, 0.10184010f, 0.04908556f, 0.10916532f, -0.07048476f, 0.25679427f, -0.20463155f, 
    0.16083342f, -0.00592279f, 0.13727833f, -0.00027195f, 0.02835925f, 0.04363116f, -0.08927921f, -0.00959888f, 
    0.20371561f, -0.35927904f, 0.03192836f, -0.21344957f, 0.01839402f, 0.02885659f, -0.35376811f, -0.03916440f, 
    -0.01910030f, 0.00834257f, -0.13475718f, -0.28101727f, 0.05733951f, -0.13028051f, 0.11514594f, -0.27312240f, 
    0.09410901f, 0.07182329f, 0.13486920f, 0.07425573f, -0.06165354f, 0.15344539f, 0.05343897f, 0.09543637f, 
    -0.20326945f, 0.00727408f, 0.04395900f, 0.19402902f, 0.04889973f, -0.14609687f, 0.13622552f, 0.05114719f, 
    0.01255800f, 0.04600506f, 0.00908390f, -0.01354401f, 0.06703486f, -0.28702563f, 0.17972751f, 0.06069616f, 
    -0.02917459f, -0.14714026f, 0.31941113f, -0.04338391f, -0.11737166f, 0.09471484f, 0.18554838f, 0.09432862f, 
    -0.37753421f, 0.40535843f, 0.07320601f, -0.41838288f, 0.07300502f, 0.08799074f, -0.09551530f, 0.10661614f, 
    0.06418816f, -0.04321480f, -0.09694774f, 0.11609395f, -0.66020364f, 0.12196993f, -0.06712769f, -0.25470361f, 
    0.07844650f, -0.09122422f, -0.16129357f, 0.05869307f, -0.00189733f, -0.06856120f, -0.13293080f, 0.01417796f, 
    -0.13372675f, 0.02987124f, 0.02403739f, 0.26724327f, -0.01976573f, -0.14929280f, -0.02735485f, 0.24891600f, 
    -0.11464241f, -0.11298585f, 0.01588864f, 0.09690854f, -0.24383146f, -0.08579209f, -0.07381462f, 0.21022739f, 
    0.20366582f, -0.03389901f, 0.05968628f, -0.02887907f, -0.19334185f, 0.01189407f, 0.03192485f, -0.00862931f, 
    0.45575371f, -0.09192916f, -0.10570460f, 0.23287512f, -0.18081589f, -0.00313736f, 0.08545451f, 0.04251219f, 
    -0.01943223f, 0.16501498f, -0.05988672f, -0.01661248f, 0.01573369f, 0.19851010f, -0.11584900f, 0.24171989f, 
    0.13553710f, 0.07176977f, 0.05260235f, 0.03717918f, 0.27000654f, 0.02908364f, -0.03693340f, -0.13100410f, 
    0.05867175f, 0.24283391f, 0.03000814f, -0.07854903f, -0.05883439f, 0.04992834f, 0.16150916f, 0.13094772f, 
    0.09431486f, 0.18955517f, 0.05829357f, 0.08454181f, 0.18447539f, -0.11939176f, -0.49840906f, -0.29093921f, 
    0.00104011f, 0.01204435f, 0.07721941f, -0.11563488f, -0.17755498f, -0.20335932f, 0.08870192f, -0.16951950f, 
    -0.37432718f, -0.08557604f, 0.04494471f, -0.16749664f, 0.03363814f, 0.05662244f, -0.04002399f, -0.06480649f, 
    -0.09697951f, -0.03368241f, -0.11480414f, -0.01599439f, -0.56972849f, 0.06529079f, 0.00569022f, 0.07437883f, 
    0.00319450f, 0.08216439f, -0.00215214f, 0.12860867f, 0.04686286f, 0.08033602f, -0.02670991f, -0.02846378f, 
    -0.27135575f, -0.08426963f, -0.11449922f, 0.18728057f, 0.07818521f, -0.04634042f, 0.14504206f, -0.08945291f, 
    -0.12040319f, -0.00435035f, 0.14005136f, 0.06048766f, -0.22301491f, -0.16565080f, 0.21958967f, -0.31895652f, 
    -0.06386075f, 0.03879289f, 0.03426429f, 0.00030970f, 0.07732680f, -0.04967236f, 0.02276007f, 0.11364985f, 
    0.08782100f, 0.03017725f, 0.02081202f, 0.13744885f, 0.00063240f, -0.11873289f, 0.05965593f, -0.06947767f, 
    -0.01972543f, -0.09484862f, -0.00356304f, 0.06717852f, 0.06273886f, 0.23724313f, -0.15292592f, -0.24384280f, 
    -0.00004089f, 0.10992169f, 0.04478759f, 0.05769087f, -0.02050810f, 0.01398589f, 0.04232409f, -0.04848311f, 
    0.00090480f, -0.21413764f, 0.07196706f, -0.14717837f, -0.15351260f, -0.08507266f, -0.02695902f, -0.05666449f, 
    0.02893647f, 0.01350132f, -0.07398005f, -0.11320226f, -0.19652164f, 0.20304266f, 0.13151138f, -0.11682769f, 
    -0.23234954f, 0.08422677f, -0.07805126f, 0.13452168f, 0.00862557f, 0.01917263f, 0.03396203f, 0.04629015f, 
    0.09493578f, -0.11441503f, 0.05956187f, 0.18715256f, -0.03048425f, 0.00556297f, -0.10348782f, 0.01033454f, 
    0.06087366f, 0.02646067f, -0.08646271f, -0.09499860f, 0.22564551f, -0.19083068f, -0.04048965f, 0.10143380f, 
    0.20809348f, -0.03242692f, 0.11411300f, 0.15946165f, -0.00112194f, -0.11010019f, -0.05453049f, 0.05611996f, 
    -0.28998262f, -0.25481915f, 0.28106478f, 0.11507722f, -0.31907004f, -0.05043121f, -0.02479748f, -0.00690123f, 
    0.08792856f, -0.09940811f, 0.07683706f, 0.03645032f, 0.07796096f, 0.39451355f, -0.23834263f, -0.17514719f, 
    0.00548697f, -0.00691349f, -0.03918582f, 0.00409612f, -0.12772170f, -0.07300615f, -0.09292526f, 0.02371523f, 
    -0.08603895f, -0.07238880f, 0.36251029f, 0.33034676f, -0.17943832f, 0.12394290f, 0.06379016f, -0.07697455f, 
    0.01768130f, 0.17382684f, 0.00221168f, 0.23585999f, 0.04492124f, -0.17140850f, 0.05355553f, 0.08228678f, 
    0.04823952f, 0.01083738f, -0.02504928f, -0.12199439f, 0.03490060f, -0.08305100f, -0.13927151f, -0.07865478f, 
    -0.13349566f, 0.09225498f, -0.05290573f, -0.09593062f, -0.08844533f, -0.00153561f, -0.02515563f, 0.20042136f, 
    0.02366014f, -0.08900820f, 0.28359908f, 0.29006621f, 0.04349038f, 0.06577187f, 0.07803553f, -0.24327973f, 
    0.19325502f, -0.03460543f, 0.01924280f, 0.20563978f, 0.14722666f, 0.06449200f, -0.01264363f, 0.11250286f, 
    -0.22237536f, -0.10356795f, 0.16823407f, 0.12809224f, 0.00300211f, -0.18683419f, 0.01528876f, -0.12064846f, 
    -0.07567444f, -0.16451892f, -0.05497798f, -0.11673512f, 0.25324157f, 0.10134017f, 0.10813612f, 0.03225504f, 
    -0.08471172f, 0.01481776f, 0.12793964f, 0.08219772f, -0.19219664f, -0.09293753f, 0.16364563f, 0.22168651f, 
    0.11198307f, 0.09438241f, -0.32810947f, -0.16383344f, 0.02934216f, -0.08653773f, -0.14855668f, -0.28813115f, 
    -0.07787994f, -0.00005311f, -0.04077837f, 0.02000328f, 0.21538325f, 0.05279912f, 0.01374136f, 0.02928032f, 
    -0.18130606f, -0.05120098f, -0.01360616f, 0.12254959f, 0.03237386f, 0.16952093f, 0.11386846f, 0.10948458f, 
    0.17147173f, -0.02379479f, -0.16570026f, 0.14508408f, -0.02438022f, -0.09117813f, 0.02981842f, -0.12043207f, 
    0.06827010f, 0.22975826f, 0.06946086f, 0.14701071f, 0.12671526f, -0.10207374f, 0.06439550f, -0.04015840f, 
    0.00382653f, 0.02726842f, -0.14975600f, 0.17748028f, 0.11749999f, 0.10167863f, 0.12364114f, -0.20253874f, 
    0.00189098f, -0.02904584f, -0.04128960f, 0.04416103f, 0.05696046f, 0.19974345f, -0.01827086f, -0.12552853f, 
    -0.11466238f, 0.00722064f, 0.02081721f, 0.11256849f, 0.00432950f, 0.27273977f, 0.00551041f, 0.33252111f, 
    0.09098208f, -0.20713075f, 0.03659992f, 0.04855989f, 0.10750355f, -0.08706063f, -0.16182972f, 0.09289634f, 
    -0.34390083f, 0.11175188f, -0.00317682f, 0.20509927f, 0.06052789f, -0.23139861f, -0.27369410f, -0.08431670f, 
    0.10354441f, -0.07067399f, 0.01973064f, 0.04439435f, -0.35787791f, 0.24446796f, 0.06173179f, -0.27042839f, 
    -0.09107662f, 0.04837158f, 0.06914286f, 0.06016108f, -0.05940335f, -0.35511357f, -0.00072358f, -0.17581815f, 
    -0.01944143f, -0.07054442f, -0.58483702f, 0.10302085f, 0.18658781f, 0.05175427f, 0.08429137f, 0.00391262f, 
    0.03978460f, 0.08303925f, -0.12375852f, -0.01787276f, -0.19861421f, -0.07679899f, -0.31883624f, -0.01491813f, 
    0.19175161f, 0.29367849f, -0.04331217f, -0.10379437f, 0.11514666f, -0.01719950f, 0.10541116f, -0.19742140f, 
    0.02633702f, 0.04694963f, 0.29308042f, 0.05281175f, 0.12297124f, -0.12978877f, -0.07571745f, 0.13660663f, 
    0.01872311f, -0.03981088f, 0.07233340f, -0.02967663f, -0.64801872f, -0.11147826f, -0.01196248f, 0.03045236f, 
    0.06635807f, -0.06356753f, -0.19656004f, -0.09639899f, 0.02507585f, 0.21280457f, -0.12645662f, -0.01264201f, 
    -0.13797773f, -0.23496160f, 0.04883022f, 0.16607411f, 0.04488673f, -0.02412448f, -0.13723864f, -0.08192640f, 
    0.09496290f, -0.07951592f, 0.02138335f, 0.25812325f, -0.34968480f, 0.15545194f, 0.26537666f, -0.29851276f, 
    -0.01785882f, -0.06597909f, 0.15442081f, 0.14617775f, 0.24440371f, 0.10634378f, -0.16888183f, -0.21439548f, 
    0.06721025f, 0.05795851f, -0.22486594f, -0.27162081f, 0.07611030f, -0.11101282f, -0.09350282f, 0.11226712f, 
    -0.10635187f, 0.09131750f, 0.09519763f, -0.06422818f, -0.66736615f, -0.17478198f, -0.12285127f, -0.27499679f, 
    0.11965058f, 0.07177050f, -0.02762760f, 0.00616846f, 0.02843012f, 0.07996986f, -0.17332120f, 0.03512586f, 
    0.06820836f, 0.13298112f, -0.05425177f, -0.37828490f, 0.02990304f, 0.02010612f, -0.28104678f, -0.16822854f, 
    0.05812643f, -0.06413305f, -0.12100395f, -0.16088626f, -0.21578386f, 0.08078530f, -0.11038232f, 0.24831489f, 
    0.06127049f, 0.08240274f, 0.12240950f, -0.01069214f, -0.04200165f, -0.16501474f, 0.10880288f, -0.15562418f, 
    -0.34636962f, -0.30588853f, 0.05052333f, 0.49019876f, -0.18599615f, -0.17099261f, 0.02307426f, 0.16751878f, 
    0.06836020f, 0.10134745f, -0.11137189f, 0.11842982f, -0.11846355f, -0.11761326f, 0.21384175f, 0.34354177f, 
    0.00097778f, 0.05828202f, 0.01108332f, -0.04874530f, -0.03083139f, 0.06059790f, -0.12617284f, 0.04050585f, 
    0.19838145f, -0.17320292f, 0.03402711f, -0.12496991f, -0.11671869f, 0.14342628f, -0.10280684f, -0.13823020f, 
    -0.00489088f, 0.08128609f, 0.02356915f, 0.02055006f, 0.08505874f, -0.02773486f, -0.06996742f, -0.02699518f, 
    0.11163608f, 0.10246081f, -0.00470896f, -0.09162138f, -0.03343520f, 0.04181976f, -0.30709761f, -0.08245777f, 
    0.06170217f, -0.18409158f, 0.06011187f, 0.05518541f, 0.25998047f, -0.11741921f, 0.03901854f, -0.05075869f, 
    0.01029788f, 0.09124169f, -0.10222242f, 0.19452226f, -0.43045619f, -0.29225689f, -0.09995662f, 0.26235768f, 
    0.19741860f, 0.12991178f, 0.05085084f, 0.01117829f, -0.01083353f, -0.10545487f, 0.10385472f, 0.06062128f, 
    0.00241606f, 0.12442201f, 0.00109527f, 0.05449051f, -0.02512326f, 0.05940481f, 0.02280248f, 0.04227666f, 
    -0.09358482f, -0.04954370f, 0.13304213f, 0.14033869f, -0.75374603f, -0.56511676f, 0.19943626f, 0.09551252f, 
    0.04396468f, -0.15954144f, 0.09737123f, -0.06702638f, -0.01276644f, -0.03257965f, -0.01972447f, -0.08466091f, 
    0.15596701f, -0.03025055f, 0.10076689f, -0.18723609f, 0.02560584f, -0.14956017f, 0.01699679f, 0.09017880f, 
    -0.00617634f, 0.06165434f, 0.09473831f, -0.23587906f, -0.14268486f, 0.00902220f, -0.18029563f, 0.30381373f, 
    -0.02820578f, -0.04206345f, 0.22205023f, -0.06496118f, 0.06302707f, -0.02771784f, -0.07704529f, 0.09135002f, 
    0.23624393f, 0.04135090f, 0.07650068f, -0.06272078f, 0.04114227f, 0.13288289f, -0.01844847f, 0.02609011f, 
    -0.04391487f, -0.08955023f, -0.30435356f, -0.13136478f, -0.04437170f, 0.12589543f, 0.18580587f, -0.25863937f, 
    -0.12752053f, 0.06431903f, -0.04191279f, 0.13938273f, -0.17023522f, -0.05529980f, 0.12631412f, -0.16439112f, 
    0.25260672f, -0.30086023f, -0.04385045f, -0.08794548f, -0.01997520f, 0.04006704f, 0.16374993f, -0.00394378f, 
    0.08699493f, -0.07027598f, -0.09812921f, 0.08650625f, 0.08006556f, 0.27830347f, -0.05481644f, -0.36566749f, 
    0.02300690f, 0.04568456f, -0.06869695f, 0.08420114f, -0.05804596f, -0.00116343f, -0.09074712f, -0.03747910f, 
    -0.38079631f, -0.34438893f, -0.26511964f, -0.06808470f, -0.01023378f, 0.02281530f, 0.01203450f, 0.07917587f, 
    0.09053409f, 0.06892443f, 0.11670209f, 0.10687935f, 0.10451504f, 0.10426515f, 0.31306875f, -0.12700075f, 
    -0.02324769f, -0.22205205f, 0.03216519f, 0.07356451f, -0.07516616f, 0.00363634f, -0.09986526f, -0.06399050f, 
    -0.14625001f, -0.17134358f, 0.15533747f, 0.15092409f, 0.07656780f, 0.14569442f, 0.05316190f, 0.19272606f, 
    0.10718277f, -0.27716541f, -0.01922198f, -0.44036946f, 0.16898391f, -0.05921337f, 0.17801161f, -0.25290310f, 
    0.15125822f, -0.02170371f, 0.20779854f, -0.00969859f, -0.11083720f, -0.09570572f, -0.03654825f, 0.06091693f, 
    0.03570495f, -0.01780878f, -0.26349139f, -0.44261301f, 0.06049560f, -0.05013599f, -0.00686302f, -0.01987479f, 
    0.06686301f, -0.09900039f, -0.05566645f, 0.08301566f, -0.32016611f, -0.34014019f, -0.06492250f, 0.21482816f, 
    0.08919737f, 0.22715987f, -0.04143312f, -0.05854255f, -0.01548613f, -0.09856617f, 0.04270908f, 0.11939488f, 
    0.11672959f, -0.20748334f, 0.03340212f, -0.11386804f, 0.04012466f, 0.13020130f, 0.17967072f, -0.04665136f, 
    -0.14140497f, -0.03973048f, -0.11368810f, -0.01473352f, 0.86162806f, -0.11702927f, 0.20737587f, 0.08936519f, 
    -0.15960193f, -0.06568539f, 0.01836586f, 0.02765696f, 0.02833436f, 0.05704318f, 0.17621769f, 0.22149903f, 
    -0.23303503f, -0.10370628f, -0.06043299f, -0.23398393f, -0.00969597f, -0.13943420f, 0.00873097f, -0.30044869f, 
    -0.11258808f, 0.05539645f, 0.05920776f, 0.02561859f, -0.08455382f, -0.10694653f, -0.25123134f, -0.44239441f, 
    -0.28308263f, -0.01636492f, -0.10314514f, -0.07134994f, -0.05425638f, 0.18866235f, -0.11291641f, 0.24670002f, 
    -0.23232216f, 0.35167024f, 0.07038236f, -0.18701722f, -0.05098750f, -0.09971899f, 0.18754277f, -0.10270853f, 
    -0.06442033f, 0.28475890f, -0.00124027f, -0.13782436f, -0.23553035f, 0.21674004f, 0.06384163f, -0.06526262f, 
    -0.07756931f, -0.00533015f, 0.18674812f, 0.07180835f, -0.06066955f, -0.12663458f, -0.00339876f, -0.17762250f, 
    -0.12002923f, -0.06625940f, -0.17301947f, 0.18943448f, -0.01755594f, -0.05698699f, -0.00691697f, -0.07063044f, 
    -0.12380138f, -0.00527354f, -0.19552889f, -0.06730499f, 0.04739643f, -0.27181622f, 0.07342815f, 0.17147127f, 
    0.08117513f, 0.03962900f, -0.08742687f, -0.14183985f, -0.10982444f, 0.00410869f, 0.03745621f, -0.02874769f, 
    0.27264449f, -0.02206541f, 0.09562361f, -0.23290025f, 0.09449502f, 0.11719403f, 0.14543696f, 0.14840576f, 
    0.22792158f, -0.03156758f, 0.06573105f, 0.01224511f, -0.03633707f, -0.17462696f, -0.09445740f, -0.26606673f, 
    0.04994740f, -0.01077118f, -0.03411841f, -0.01780850f, -0.02920020f, -0.22128202f, 0.20617586f, -0.00750642f, 
    -0.37243348f, -0.21602111f, 0.21886235f, -0.09907646f, -0.16443883f, -0.10357229f, 0.07919717f, 0.10781519f, 
    -0.06016652f, 0.02878591f, 0.16210835f, 0.23176840f, -0.03787619f, 0.16970484f, 0.09810079f, 0.25329891f, 
    0.17103823f, 0.00409607f, 0.05383594f, 0.02460718f, 0.11701514f, 0.07749160f, -0.08656481f, 0.06167184f, 
    -0.11338764f, -0.11481193f, -0.10316595f, 0.11839005f, -0.00022354f, -0.00782836f, -0.00751817f, 0.02043092f, 
    -0.11627543f, 0.07795172f, 0.21620326f, 0.08262411f, 0.16485023f, -0.28928244f, -0.31504953f, 0.07302251f, 
    -0.02905233f, -0.02495636f, -0.00244046f, 0.09069856f, 0.06311641f, 0.04043956f, 0.04375361f, 0.10602418f, 
    -0.80310744f, 0.17273615f, 0.02618256f, 0.42781439f, 0.18960391f, -0.06631164f, 0.11774056f, 0.10469601f, 
    0.02097644f, -0.19027857f, 0.06041969f, -0.29791862f, -0.21909015f, 0.34274518f, 0.14685398f, 0.02666814f, 
    -0.16720159f, -0.01389404f, 0.11416314f, 0.10095556f, 0.02814883f, 0.08414030f, 0.12786303f, 0.03569167f, 
    0.01671676f, 0.02442150f, -0.00028205f, -0.35979849f, -0.12480829f, -0.07784525f, -0.12035144f, -0.12482788f, 
    -0.07676151f, 0.00180500f, 0.08833276f, -0.17245041f, -0.30229422f, 0.06328639f, -0.11770336f, -0.23769552f, 
    -0.20849206f, 0.08050200f, -0.15449739f, -0.24630035f, 0.01734969f, -0.00840417f, -0.10558437f, -0.11577189f, 
    0.07057792f, 0.26018712f, -0.03540816f, -0.13074069f, -0.08764002f, 0.20974337f, -0.02888572f, 0.07322350f, 
    0.03133391f, -0.02575791f, -0.05235894f, -0.23764774f, 0.43757141f, -0.37478855f, -0.36274692f, 0.42936429f, 
    -0.08474293f, 0.05014108f, -0.04420265f, 0.05446089f, -0.02661609f, 0.03152016f, -0.05795268f, 0.06679104f, 
    0.07438217f, -0.30711374f, -0.05975800f, 0.04667241f, -0.15428963f, -0.08864525f, -0.06393827f, -0.04978822f, 
    0.04660410f, -0.01494992f, -0.03800145f, -0.03407774f, 0.22952147f, 0.30939209f, -0.22818619f, 0.30704114f, 
    0.09480906f, -0.06185371f, -0.05906017f, 0.07966933f, 0.03174265f, 0.09033191f, 0.01763702f, -0.09852528f, 
    0.02856426f, -0.11825068f, -0.00064973f, -0.07402410f, -0.08633503f, -0.13415387f, -0.01858579f, 0.00283854f, 
    -0.08685834f, 0.01890855f, -0.09584988f, -0.22616367f, -0.08115167f, 0.20377904f, -0.20319723f, -0.26852018f, 
    -0.00673985f, 0.04199522f, -0.13309340f, -0.12367608f, -0.11233801f, -0.07163106f, -0.04981032f, -0.11522530f, 
    0.29594862f, -0.32369873f, 0.17237210f, 0.09908213f, -0.04202795f, -0.08297712f, -0.16374582f, -0.04215597f, 
    0.00806547f, 0.02251446f, -0.02166161f, 0.00399342f, -0.08703320f, -0.17499097f, -0.34248501f, -0.23033655f, 
    0.00450716f, -0.19919504f, -0.11899231f, -0.03914218f, -0.04472787f, 0.02463414f, 0.03450089f, 0.00687070f, 
    0.01621292f, 0.16852914f, 0.09491999f, 0.00868917f, -0.04307685f, -0.05178231f, 0.08899166f, -0.10572104f, 
    0.11690358f, 0.04648092f, -0.08829132f, -0.13071415f, 0.11281028f, -0.34037736f, 0.21669696f, 0.11087098f, 
    -0.06097140f, -0.15873724f, 0.00203688f, -0.09370701f, -0.03281773f, 0.10982292f, -0.02778238f, -0.03273163f, 
    0.10146528f, -0.11428810f, -0.09372806f, 0.00149340f, -0.06806275f, -0.01676327f, -0.17113537f, -0.10008033f, 
    0.17874560f, -0.07337847f, -0.03131489f, 0.00252380f, 0.29621509f, -0.03970963f, -0.03402356f, -0.02069438f, 
    0.07001241f, -0.01633899f, 0.01925491f, -0.16077179f, -0.04952430f, -0.04208691f, 0.09117669f, -0.05042585f, 
    -0.04858399f, -0.06678624f, 0.22619477f, 0.09565232f, -0.07224078f, -0.00976449f, -0.12948965f, 0.04328887f, 
    0.02152197f, 0.04729974f, -0.10395998f, -0.06693272f, 0.20464599f, -0.17360307f, 0.03730935f, 0.21788980f, 
    0.00147628f, -0.04554499f, -0.13218348f, -0.12743138f, -0.14442018f, -0.02439249f, 0.08054256f, -0.17495146f, 
    0.03901571f, 0.01788960f, -0.05338408f, -0.06371671f, 0.00169918f, -0.06966739f, -0.00380169f, -0.01583913f, 
    -0.21009815f, 0.08105943f, 0.00905793f, -0.00050291f, 0.18880722f, -0.04225351f, 0.02065939f, -0.12982818f, 
    -0.18119884f, -0.10833835f, -0.01570006f, -0.16539879f, -0.03206066f, 0.11640468f, -0.15871781f, -0.01100348f, 
    -0.05783848f, 0.11072215f, 0.23101254f, 0.18863060f, 0.15090482f, -0.01613706f, 0.11443880f, -0.02464061f, 
    0.01487412f, 0.04319290f, 0.00067050f, -0.05183385f, 0.12567925f, 0.23826811f, 0.10512214f, 0.22125089f, 
    0.09726518f, -0.00630983f, 0.09837561f, 0.02449660f, -0.10901836f, 0.07903560f, 0.00216132f, -0.06098501f, 
    -0.18202309f, 0.14829922f, -0.17418222f, -0.13513005f, 0.14005998f, -0.03810057f, -0.04993563f, -0.11724368f, 
    -0.05468503f, 0.03543209f, 0.02947843f, 0.08555724f, 0.04034393f, -0.10927401f, 0.23338692f, -0.05116850f, 
    0.03039546f, 0.05358940f, -0.20102066f, -0.10657565f, -0.08508733f, -0.00929974f, -0.05011089f, 0.02722399f, 
    -0.08044198f, 0.08980398f, 0.11389577f, 0.11679462f, 0.25985840f, -0.03875861f, -0.02576280f, 0.00769727f, 
    -0.00464736f, -0.00442277f, 0.00879795f, -0.11995921f, -0.23316167f, -0.06128211f, -0.02697884f, -0.03267696f, 
    0.04467886f, -0.02844056f, -0.04335288f, 0.03054375f, 0.01904916f, -0.09870688f, 0.01111672f, -0.03397815f, 
    0.30601436f, -0.06781751f, 0.16456726f, -0.02707751f, -0.02564075f, 0.00456175f, 0.04358809f, -0.11340268f, 
    -0.05624963f, -0.00422771f, -0.07939839f, -0.17484768f, 0.21950391f, 0.13156843f, 0.39595896f, 0.01930090f, 
    0.02027251f, 0.07393158f, 0.03564556f, -0.05634419f, 0.00098229f, 0.09767964f, -0.01098961f, -0.06339689f, 
    0.07969819f, 0.03531479f, -0.01433234f, -0.01207248f, -0.02862656f, 0.01225701f, 0.08830828f, -0.17224935f, 
    -0.10193521f, 0.03174183f, -0.04653658f, -0.11012336f, -0.26220950f, -0.30874020f, -0.15079916f, 0.18776952f, 
    -0.10201313f, -0.00101093f, -0.03111408f, -0.02381964f, -0.03046079f, -0.02656222f, 0.02047285f, 0.01183181f, 
    0.29032493f, -0.31493238f, 0.34271321f, 0.19535734f, 0.09243189f, -0.09064189f, -0.03241026f, -0.11517679f, 
    -0.09523922f, -0.24749012f, -0.11375038f, -0.06604679f, -0.29751125f, 0.18834198f, -0.10918368f, 0.19779269f, 
    0.05050774f, -0.00636051f, 0.07797413f, -0.02274789f, 0.11465587f, -0.15073164f, 0.13919798f, -0.05562040f, 
    -0.41172311f, -0.05173763f, 0.01079073f, -0.07197609f, 0.10090790f, 0.00408093f, -0.05820724f, -0.01712184f, 
    0.11025231f, 0.00758007f, 0.09321272f, -0.03841452f, -0.27052918f, -0.03456702f, -0.28149062f, -0.21959345f, 
    0.06541375f, -0.05879003f, -0.05208179f, -0.05778534f, -0.04669603f, -0.06810261f, -0.05830130f, -0.08886438f, 
    -0.00857344f, -0.11289646f, 0.22885479f, 0.07990452f, -0.00559640f, 0.02849803f, -0.07550245f, 0.02532109f, 
    0.02087688f, 0.08796572f, -0.05068539f, -0.01676533f, 0.12827843f, 0.22621873f, 0.13837290f, 0.25603810f, 
    0.13018954f, 0.08106612f, 0.03545811f, -0.07726215f, -0.04544170f, -0.08100285f, -0.08276084f, -0.10138395f, 
    -0.55447465f, 0.04392866f, -0.22042125f, -0.01451513f, 0.08493568f, -0.18389067f, -0.02139524f, -0.01152655f, 
    -0.12909757f, 0.04636905f, -0.06682417f, 0.03546708f, 0.26270616f, 0.07241566f, 0.05684728f, 0.05349715f, 
    0.07725858f, -0.01111406f, 0.01041130f, -0.04599137f, -0.07453901f, 0.01494494f, -0.08039076f, -0.06212910f, 
    0.14773758f, 0.12134921f, -0.29891565f, 0.36805519f, 0.16896683f, 0.00803718f, -0.06049968f, -0.11504437f, 
    0.02649985f, -0.02476239f, -0.11902806f, 0.01123601f, -0.12610346f, 0.19685028f, -0.10838448f, -0.18830836f, 
    -0.07228480f, 0.02689447f, -0.11265164f, 0.12169902f, 0.11400365f, -0.08691664f, 0.06254583f, -0.00576149f, 
    -0.15041779f, -0.24485078f, -0.11060640f, -0.18341233f, -0.10680398f, 0.04911667f, 0.08537827f, -0.05249774f, 
    -0.13812684f, 0.10453814f, 0.14607914f, 0.07528497f, 0.16464920f, -0.10672200f, 0.14460015f, 0.32322198f, 
    -0.00755417f, 0.10239512f, -0.00538875f, 0.01026708f, 0.06110106f, 0.09092437f, 0.00591631f, -0.30702677f, 
    0.09809388f, 0.00204687f, -0.05857257f, 0.15505324f, 0.02792635f, 0.05053439f, -0.12497154f, -0.26436299f, 
    -0.02785666f, -0.10016715f, -0.07236445f, -0.28540820f, 0.04861381f, -0.12175050f, -0.44321850f, 0.10268036f, 
    0.19940962f, 0.07122255f, 0.00547170f, 0.02363122f, 0.12946148f, 0.11250930f, 0.20046052f, 0.09339444f, 
    -0.01125384f, 0.07588530f, 0.08778761f, 0.15646493f, -0.17577530f, -0.03477111f, -0.03920840f, -0.09263874f, 
    -0.08000235f, -0.10273639f, -0.11835942f, -0.05521521f, -0.24958864f, -0.33919418f, -0.15049034f, -0.07427064f, 
    0.19228883f, -0.11476170f, -0.09572676f, -0.19148827f, 0.03066533f, 0.14736184f, 0.05167229f, -0.05944018f, 
    -0.04267754f, -0.10920718f, -0.06022844f, -0.09857125f, -0.06041153f, -0.02382332f, -0.03257282f, -0.00166617f, 
    0.04306774f, 0.07439224f, -0.15789069f, 0.12498638f, -0.01083734f, -0.26986241f, 0.09559295f, -0.09747410f, 
    0.19008167f, -0.03829130f, -0.08279111f, 0.11988781f, 0.01880661f, 0.18110202f, -0.01722100f, -0.00177391f, 
    -0.50688255f, 0.03133681f, 0.01973025f, -0.17575856f, -0.18540463f, 0.10077678f, -0.08442556f, -0.17847128f, 
    0.01773674f, -0.15289015f, -0.07524098f, 0.10512849f, 0.05616621f, -0.00298348f, -0.34349027f, -0.45921904f, 
    -0.05911330f, -0.21508600f, -0.20899609f, 0.12858930f, 0.08514453f, 0.07681301f, -0.11992295f, 0.21943794f, 
    -0.13657299f, 0.33500791f, 0.13527006f, 0.01775153f, -0.03951986f, -0.16256218f, -0.06224468f, 0.01856370f, 
    0.22354750f, -0.12475277f, 0.10238387f, 0.18232588f, -0.24750058f, 0.20023273f, -0.29762819f, -0.35048351f, 
    0.06730045f, 0.08635312f, -0.13798580f, -0.07228900f, 0.09728649f, 0.03692229f, -0.04314013f, -0.10669153f, 
    -0.22362736f, -0.07348540f, 0.24014156f, 0.00334308f, -0.06169950f, 0.07319645f, -0.03038100f, 0.01867992f, 
    -0.03010877f, 0.04295893f, -0.18889904f, -0.21352980f, -0.19345865f, 0.03620645f, 0.25233176f, 0.08409221f, 
    -0.22284670f, 0.09860132f, -0.15126386f, -0.00312544f, 0.05952970f, -0.11292876f, 0.01233259f, -0.00532850f, 
    0.02579313f, -0.20676883f, -0.04321121f, -0.06733149f, 0.10153968f, -0.02748308f, -0.19877677f, 0.03581112f, 
    0.05800486f, -0.01908676f, 0.13966002f, -0.04881217f, -0.35356790f, 0.07767492f, 0.16110919f, -0.17302461f, 
    -0.01327844f, -0.14486822f, -0.22812940f, 0.08139491f, 0.14131051f, 0.21831751f, -0.03006308f, 0.11330427f, 
    -0.11118312f, 0.16913980f, -0.10998408f, -0.06255889f, 0.08502463f, 0.15669844f, -0.20757149f, -0.03424757f, 
    0.03066912f, -0.02726492f, 0.16406053f, 0.15675499f, -0.03656042f, 0.12814444f, -0.06971879f, 0.12116449f, 
    -0.09047606f, -0.10718510f, -0.03267030f, 0.07716667f, -0.13598508f, 0.14557241f, -0.09071142f, -0.07453329f, 
    -0.02742640f, -0.48098928f, 0.11243267f, -0.17722180f, 0.03164753f, -0.12439570f, 0.06700842f, -0.04053445f, 
    0.01205113f, 0.07546893f, -0.02703676f, -0.02920301f, -0.25234583f, 0.14869285f, 0.12677462f, -0.07900508f, 
    0.01757254f, -0.03058692f, 0.04820886f, -0.09011905f, 0.01036523f, -0.02911070f, -0.06625552f, 0.03250160f, 
    -0.15936954f, 0.17597924f, 0.13735989f, 0.10618384f, -0.20823172f, 0.05924660f, -0.19509053f, -0.01137107f, 
    0.08715059f, 0.12000150f, -0.16873403f, -0.22282431f, 0.25157169f, 0.04625105f, -0.43813157f, -0.04001960f, 
    0.07182670f, -0.06466252f, -0.02881438f, -0.07766320f, -0.04179023f, -0.09346732f, -0.07167383f, -0.02331239f, 
    0.20179975f, 0.36604136f, -0.06833938f, -0.04529617f, 0.04716373f, -0.02148783f, -0.07790894f, -0.07877604f, 
    0.03408397f, 0.06368671f, -0.02123843f, 0.05038880f, -0.04919620f, 0.09842233f, -0.22546820f, -0.07732934f, 
    0.08299056f, -0.16382584f, -0.25427639f, 0.02143951f, 0.14006957f, 0.00409322f, -0.04284334f, 0.05711329f, 
    0.03767549f, 0.21887431f, -0.33919987f, 0.14416103f, -0.02386200f, 0.12031979f, -0.03065003f, -0.08061370f, 
    0.05965639f, 0.15342698f, 0.05070445f, 0.00680573f, 0.16435696f, -0.13516068f, -0.01708085f, 0.19137293f, 
    0.19846129f, -0.11567712f, -0.02262763f, -0.14622572f, -0.03885556f, -0.04657278f, -0.14984417f, 0.14239906f, 
    -0.44039878f, -0.15818182f, 0.02829217f, -0.32014132f, 0.11494052f, -0.09917443f, -0.12482902f, -0.09622787f, 
    0.01000259f, 0.04606330f, 0.05820634f, 0.23786414f, -0.14888877f, 0.14690301f, 0.15577781f, -0.29125708f, 
    0.00757307f, 0.04409032f, 0.10216004f, -0.04260450f, 0.11897627f, -0.03163156f, 0.17964831f, 0.09675311f, 
    -0.06165605f, -0.11763460f, -0.23634335f, -0.06971218f, 0.02584131f, 0.14353557f, -0.01299856f, -0.01265071f, 
    0.03621516f, -0.02318352f, 0.18492034f, -0.06858458f, 0.24238378f, 0.03545536f, 0.08038533f, 0.05578205f, 
    0.06779735f, 0.00891483f, 0.07934715f, 0.07888068f, 0.00862752f, -0.13574357f, 0.02785643f, -0.08813112f, 
    -0.14531387f, 0.27614611f, -0.45846173f, -0.49733388f, 0.15406244f, 0.05392346f, -0.14787586f, 0.08107144f, 
    -0.15977229f, -0.03923314f, -0.19766387f, -0.02233659f, 0.13985668f, 0.29472435f, 0.21400283f, 0.14712796f, 
    -0.03637302f, -0.12327484f, -0.10663274f, 0.17049821f, 0.13972022f, 0.02090720f, -0.07258294f, 0.09532049f, 
    -0.02071514f, 0.37354365f, -0.09773679f, -0.03760993f, 0.08916477f, 0.05738035f, -0.03610457f, 0.05583158f, 
    -0.02315123f, 0.28184837f, -0.11756830f, -0.15069790f, -0.14325395f, 0.33464956f, -0.01224645f, -0.41278234f, 
    0.10815933f, -0.01297083f, 0.08616194f, -0.27597696f, -0.05094689f, -0.08478849f, -0.07278701f, 0.04883472f, 
    0.47330701f, -0.67908818f, 0.14942867f, -0.05837401f, -0.02890031f, -0.00093583f, -0.09034729f, 0.03045257f, 
    0.05015430f, 0.21290372f, 0.17423138f, 0.18538120f, -0.31512633f, 0.02893298f, 0.07902362f, -0.59539360f, 
    0.07028141f, -0.09799176f, -0.03670846f, 0.12561813f, 0.02083767f, -0.07551903f, -0.13314357f, -0.17114064f, 
    -0.01770894f, -0.42315638f, 0.08525424f, -0.06797496f, 0.12129267f, -0.08852098f, -0.01104069f, 0.08063883f, 
    0.11757973f, 0.02298911f, 0.00834556f, -0.12427051f, 0.19110197f, -0.43752524f, -0.00695626f, 0.11478852f, 
    -0.22694969f, 0.03541149f, -0.04085784f, 0.07688415f, 0.06886075f, -0.05319637f, 0.05671996f, -0.10086078f, 
    0.26697308f, 0.25976190f, 0.07662284f, -0.19501238f, 0.06951789f, 0.12111904f, 0.12155847f, -0.10701171f, 
    -0.10343487f, -0.00904710f, 0.05692232f, 0.05787067f, 0.29120538f, 0.13636038f, 0.01241900f, 0.22185387f, 
    -0.10447828f, 0.05843413f, 0.06894512f, -0.25119457f, -0.01637917f, 0.00607332f, 0.01207132f, -0.02768181f, 
    -0.05324605f, -0.15746371f, -0.13000658f, 0.12237705f, -0.05101766f, -0.12418613f, 0.12413876f, -0.12352728f, 
    -0.00773882f, 0.11194315f, -0.11663157f, 0.06918633f, 0.19481120f, -0.21316516f, 0.02030847f, -0.16671598f, 
    -0.07160889f, -0.05499702f, -0.05230991f, -0.07087482f, -0.03918092f, 0.03092531f, 0.08162051f, -0.12425539f, 
    0.85723084f, 0.18369871f, -0.26289442f, -0.40660620f, 0.11217950f, 0.00422053f, 0.11727218f, -0.03456545f, 
    -0.22613011f, -0.03619879f, 0.03885387f, 0.14571306f, -0.26816019f, -0.10589789f, -0.35071850f, 0.20982239f, 
    0.10300978f, -0.04587075f, 0.04602679f, -0.03678821f, -0.13032129f, 0.02156023f, 0.06696431f, 0.15341537f, 
    -0.05635479f, -0.14631990f, 0.05982488f, -0.13604558f, 0.09695679f, -0.00585432f, -0.05008599f, 0.02457239f, 
    -0.12897059f, 0.00497140f, 0.00980668f, 0.05328228f, -0.37535793f, -0.49365017f, 0.22337954f, 0.02340648f, 
    -0.05189183f, -0.05791722f, 0.01445042f, -0.02834025f, -0.00046802f, 0.01831887f, 0.10998680f, 0.16667183f, 
    -0.00687586f, -0.26407635f, -0.05984118f, -0.20802854f, -0.04372156f, 0.07686847f, -0.04720178f, -0.12860268f, 
    -0.05250401f, -0.05368679f, 0.17150004f, 0.19505160f, -0.10917017f, -0.42561221f, 0.04864966f, -0.09426876f, 
    -0.13131922f, 0.14902191f, 0.00721626f, -0.25933167f, -0.04708080f, -0.08872585f, -0.18165614f, -0.09859194f, 
    0.04905711f, -0.60551661f, -0.07245190f, 0.02819380f, -0.04209734f, 0.06100823f, -0.01935295f, 0.22438698f, 
    -0.18250205f, -0.04847974f, -0.02058029f, -0.09343936f, -0.07009127f, -0.08976083f, 0.23134696f, 0.04222457f, 
    0.04921159f, 0.08402156f, 0.19149408f, 0.07766981f, -0.13228622f, -0.12338984f, -0.05628945f, -0.00012788f, 
    0.01727708f, -0.02874685f, 0.09990212f, 0.22539659f, -0.17319706f, -0.01686414f, 0.05716648f, 0.00393041f, 
    0.05602711f, 0.00834455f, -0.07004360f, -0.00739175f, 0.03077701f, -0.35063994f, -0.11758817f, 0.28675997f, 
    -0.13030781f, 0.00086253f, -0.07262754f, -0.04968096f, -0.09701093f, 0.18502323f, 0.01636228f, -0.09931912f, 
    -0.04972184f, 0.50788903f, -0.02238089f, 0.23039374f, 0.05139499f, 0.04162893f, -0.04947645f, 0.13820013f, 
    0.11343682f, 0.01041085f, 0.10718630f, 0.18622772f, 0.01484804f, 0.02182460f, 0.31846911f, -0.09680678f, 
    -0.04993205f, 0.06714398f, -0.06716163f, 0.00495758f, -0.01541356f, 0.07369556f, 0.01799094f, 0.06763924f, 
    0.33546504f, -0.58427024f, -0.02823175f, -0.32827887f, -0.17141016f, 0.07308369f, -0.08819294f, 0.07652052f, 
    -0.04577690f, 0.08100895f, 0.01399761f, 0.02689052f, -0.56792074f, 0.17980245f, -0.12769194f, -0.34815633f, 
    -0.03059065f, -0.10688759f, -0.00563610f, 0.08344968f, -0.05216157f, -0.12620358f, 0.19532512f, -0.03515662f, 
    0.11111721f, 0.20485510f, 0.16191441f, 0.22332606f, 0.16015244f, 0.08018304f, -0.05161976f, -0.04023245f, 
    -0.10369239f, -0.01594558f, -0.00504623f, 0.00959344f, -0.20363814f, -0.02493571f, 0.27909037f, -0.17481539f, 
    0.04326161f, 0.12145320f, -0.08949298f, -0.00066469f, 0.16111623f, 0.07654249f, 0.05913761f, 0.03627305f, 
    0.26950583f, -0.05199106f, -0.06983387f, 0.16513254f, -0.05174568f, 0.13675986f, 0.18805654f, 0.05409497f, 
    -0.00626088f, -0.04520793f, 0.15244405f, -0.17146105f, -0.28062940f, -0.24406213f, -0.13402934f, 0.03140026f, 
    -0.11352527f, -0.06823692f, -0.03212338f, -0.09705582f, -0.19028790f, 0.05065183f, -0.08475289f, -0.03306190f, 
    -0.18463346f, 0.18149880f, 0.08555644f, -0.34176791f, 0.14941381f, 0.03621976f, 0.07043960f, -0.14200182f, 
    -0.19961870f, 0.02727556f, -0.16820833f, -0.08178816f, 0.07439505f, -0.09364053f, 0.17483407f, -0.04113701f, 
    0.07738985f, 0.02504283f, -0.08880402f, -0.10698488f, 0.09562541f, 0.10202461f, 0.11798849f, 0.13475563f, 
    -0.40435669f, -0.13410927f, -0.37989932f, -0.64248103f, -0.13894939f, 0.05144406f, -0.01978467f, -0.05986093f, 
    -0.02065759f, 0.06826767f, -0.01331505f, 0.11408786f, -0.39809904f, -0.15446781f, 0.28543153f, 0.07805207f, 
    0.08566591f, 0.09412633f, 0.05083687f, 0.01405683f, 0.15678708f, -0.20099942f, -0.00509189f, -0.04988439f, 
    0.20712756f, 0.28620750f, -0.04629478f, -0.04505000f, -0.03792728f, -0.04677323f, 0.10623347f, -0.01208288f, 
    -0.00607951f, -0.09360282f, 0.24116389f, 0.10902916f, -0.73101163f, -0.51317745f, -0.06475975f, -0.17901354f, 
    0.08456046f, -0.14066075f, 0.09857367f, 0.04872496f, 0.05680535f, 0.18656555f, -0.00922117f, 0.28371972f, 
    -0.36813727f, 0.29063350f, -0.29598519f, -0.20766988f, 0.01485982f, 0.08994827f, -0.21815756f, -0.04764849f, 
    0.15044788f, -0.02376243f, -0.07471642f, -0.17162611f, 0.03022392f, 0.02801195f, -0.04850374f, -0.04993286f, 
    0.06176332f, 0.09572387f, 0.04412868f, 0.15569726f, -0.03268608f, 0.14292829f, 0.17087869f, 0.15531623f, 
    0.35447848f, 0.01272067f, -0.02634018f, -0.19832233f, -0.18754269f, -0.07498495f, 0.07905437f, -0.07372347f, 
    -0.03640934f, -0.13808323f, -0.14174822f, 0.03238713f, -0.39764521f, 0.04174845f, 0.16430637f, 0.06511870f, 
    0.15789886f, -0.07142419f, -0.14805003f, -0.25289690f, 0.01392261f, -0.06133460f, -0.02222912f, -0.01910873f, 
    -0.33683500f, -0.12759832f, 0.01516553f, 0.19632234f, 0.02214717f, 0.07184428f, 0.10244492f, 0.09540277f, 
    -0.00773566f, 0.21347696f, 0.06430976f, 0.27812859f, -0.55260527f, 0.04537318f, 0.01395876f, -0.19591346f, 
    0.01649225f, -0.12889801f, -0.12930028f, -0.06924628f, -0.05349433f, 0.14361277f, -0.01679209f, 0.01232312f, 
    0.24686165f, 0.20645373f, 0.02375620f, -0.06891096f, 0.11197136f, 0.01249245f, 0.01718960f, 0.09993298f, 
    -0.18192996f, -0.12611008f, 0.07874698f, -0.11939901f, 0.23212036f, 0.20921972f, 0.29322347f, -0.04754959f, 
    -0.04403050f, -0.09222844f, -0.08615540f, -0.04895020f, -0.02054387f, 0.04376975f, -0.15534246f, 0.10246749f, 
    -0.52897930f, -0.12221909f, 0.10229743f, 0.26219082f, -0.01552480f, -0.02889941f, -0.09467180f, -0.05313314f, 
    -0.04693129f, 0.15859102f, 0.21350975f, -0.18243976f, -0.02423840f, -0.01151054f, -0.00053231f, 0.05306464f, 
    0.01104828f, 0.08490611f, 0.03847580f, 0.01472109f, -0.04966031f, -0.01895337f, -0.06459658f, -0.08832634f, 
    0.27343997f, 0.03586635f, 0.08247520f, -0.07699115f, -0.15649928f, -0.03810044f, 0.00052044f, -0.08708183f, 
    0.03916619f, 0.09670845f, 0.02740365f, 0.03717434f, 0.12574828f, 0.09251003f, -0.00606667f, 0.01434142f, 
    -0.13276371f, -0.12475430f, -0.07913694f, -0.05723397f, 0.08007467f, -0.09178470f, -0.03877838f, -0.20514542f, 
    -0.65059435f, -0.07551805f, -0.28861818f, -0.13083889f, 0.27002665f, 0.00559858f, -0.11530974f, 0.02972465f, 
    0.01150793f, -0.01661073f, 0.12337778f, 0.00774303f, 0.20680028f, -0.02034107f, -0.05874115f, 0.00264098f, 
    -0.00691305f, -0.11654924f, -0.03739888f, 0.03840913f, -0.05675299f, 0.24518475f, 0.13963510f, 0.31964272f, 
    -0.04900312f, 0.14562277f, 0.01266353f, 0.04979404f, 0.07056800f, -0.03125740f, 0.15739928f, -0.10975052f, 
    -0.10660093f, 0.10110912f, 0.12908089f, 0.02159023f, 0.33531022f, -0.16119176f, -0.09978627f, 0.12402230f, 
    -0.07841630f, -0.08917027f, -0.09942108f, 0.18739444f, 0.13309456f, 0.21072291f, 0.03617962f, 0.25933358f, 
    0.14039372f, 0.13397235f, 0.01692900f, 0.13210674f, 0.01149374f, -0.00564910f, 0.03567981f, 0.02841199f, 
    -0.05413268f, 0.03745608f, -0.07555073f, 0.04505066f, 0.32891870f, 0.01244712f, -0.05232642f, -0.12430927f, 
    -0.05598240f, 0.09000350f, 0.01932553f, -0.09365026f, -0.02798139f, -0.03343878f, -0.01579579f, -0.00869744f, 
    -0.03971414f, -0.24837625f, -0.08558714f, 0.10944251f, 0.01096563f, -0.04159102f, -0.01421189f, 0.21016364f, 
    0.05227742f, -0.20605397f, -0.16387109f, -0.01405979f, -0.77593076f, -0.23424411f, 0.26254752f, -0.04548632f, 
    0.25908265f, -0.07740961f, 0.03099670f, -0.01384680f, 0.00330598f, -0.07430815f, -0.08249442f, -0.07951745f, 
    -0.36530185f, 0.25746143f, -0.24191736f, -0.14314421f, 0.10939924f, 0.19292745f, -0.01314632f, 0.07433455f, 
    0.07615186f, 0.07872169f, -0.09138737f, -0.02238386f, -0.36019513f, 0.04264110f, -0.21347310f, -0.17894588f, 
    0.20790626f, -0.00925901f, -0.04633269f, 0.04583829f, 0.17353866f, -0.09775081f, -0.14699650f, 0.09434269f, 
    -0.35963067f, -0.31152713f, -0.00499798f, 0.10931430f, -0.02702506f, 0.01596287f, 0.03170987f, -0.02762808f, 
    0.08132860f, 0.16107132f, 0.04102217f, 0.09777560f, -0.65605617f, -0.29781699f, -0.16103661f, -0.22544181f, 
    0.09054416f, -0.00292673f, -0.10265857f, -0.23572733f, 0.05627340f, -0.07089894f, -0.11805738f, 0.17467362f, 
    0.18929051f, 0.24898519f, 0.03174728f, -0.30050880f, 0.14863361f, -0.06414536f, 0.14757502f, 0.03727194f, 
    -0.08673422f, -0.09091423f, 0.11446550f, 0.04561253f, 0.12740792f, 0.13784450f, -0.09565651f, -0.15209401f, 
    0.08197298f, 0.13805337f, -0.02060578f, 0.06867281f, -0.00647443f, 0.14004907f, 0.16657248f, -0.03144706f, 
    -0.39324847f, -0.16703622f, -0.12233083f, -0.03881308f, 0.15883635f, -0.01712691f, -0.07195338f, 0.02406380f, 
    0.14779675f, 0.09319085f, 0.11869444f, 0.02996688f, -0.38079548f, 0.15400371f, -0.13863593f, -0.12269756f, 
    -0.08200323f, -0.10640462f, -0.03636460f, 0.01637406f, 0.02631544f, -0.00708351f, 0.03211972f, -0.08486827f, 
    0.40679422f, -0.32159245f, -0.41045305f, 0.16910395f, 0.04015096f, 0.03704780f, 0.14541776f, -0.11678069f, 
    -0.01445476f, 0.02835684f, -0.01277429f, -0.09855179f, -0.12692285f, 0.35212299f, -0.08140577f, -0.07773863f, 
    -0.08745914f, -0.10888542f, -0.18774055f, -0.16912223f, -0.08595358f, 0.15094516f, -0.02346976f, -0.05827342f, 
    0.02030392f, -0.08824082f, -0.05266067f, 0.06532756f, 0.03993607f, -0.03606476f, 0.00515343f, 0.07588636f, 
    -0.11751561f, -0.07791445f, -0.04721728f, -0.16660263f, 0.24859315f, -0.39664203f, -0.13725881f, -0.36913875f, 
    -0.07066805f, 0.05829271f, -0.05880636f, 0.09720006f, -0.07576564f, -0.11367191f, -0.13296282f, -0.04125539f, 
    -0.63607413f, 0.14496370f, -0.15947276f, -0.12240907f, -0.09598336f, -0.11656177f, -0.03062382f, 0.06438333f, 
    0.02057078f, 0.10005262f, 0.04137965f, 0.14771727f, 0.41784766f, 0.13714220f, -0.37359506f, 0.05877293f, 
    0.04043328f, -0.03431880f, -0.01091188f, -0.01619206f, -0.06776956f, -0.04190424f, -0.06837800f, 0.07162770f, 
    -0.33626664f, -0.16917987f, -0.03912549f, 0.01673907f, 0.07564367f, -0.04136918f, 0.01981042f, -0.01438587f, 
    -0.01661395f, -0.05999869f, 0.00391212f, -0.08500834f, 0.03666808f, 0.24349780f, -0.01455836f, 0.02101238f, 
    -0.07013357f, 0.04197058f, -0.03609943f, 0.06688061f, 0.05523083f, -0.08866335f, 0.09140857f, -0.02962272f, 
    0.00720626f, -0.13546310f, 0.03694645f, -0.02961077f, -0.06855348f, -0.17066330f, -0.19170475f, 0.26102772f, 
    -0.16811503f, -0.07108667f, -0.05706977f, -0.00179635f, -0.19209769f, 0.06859884f, 0.14010119f, -0.20365572f, 
    -0.15973265f, 0.15700723f, -0.05184314f, -0.04420879f, -0.00747533f, -0.25256571f, 0.01985515f, 0.02769685f, 
    0.08501910f, 0.09302088f, -0.37225807f, 0.04374353f, 0.01149916f, -0.07999312f, -0.03691401f, -0.05159121f, 
    -0.00039549f, 0.12884875f, 0.00622261f, 0.03309048f, 0.27878264f, 0.03387968f, 0.00307454f, 0.01083649f, 
    -0.08389319f, 0.07915723f, 0.03161549f, -0.16670026f, 0.04230717f, 0.06359783f, -0.13251214f, -0.10147272f, 
    -0.23843612f, -0.50306588f, 0.10753733f, -0.23588592f, 0.08687008f, -0.06647483f, -0.04060096f, 0.07384837f, 
    -0.04734465f, -0.14355403f, -0.09514554f, -0.07970199f, -0.25366554f, 0.21166137f, -0.32627475f, 0.04146801f, 
    0.27087563f, -0.10460614f, 0.08805499f, -0.03807107f, 0.10790349f, 0.15864941f, 0.08292809f, 0.09229187f, 
    -0.06320690f, 0.14801937f, 0.02951376f, -0.05526741f, -0.27996215f, -0.00386971f, -0.09989037f, -0.13164012f, 
    -0.03962742f, 0.10568601f, 0.19314660f, -0.03059254f, 0.24305263f, -0.14365487f, -0.04627773f, -0.00070249f, 
    -0.12381801f, 0.03603918f, -0.01361815f, 0.13433176f, 0.00743599f, 0.01819748f, -0.12276408f, -0.13708238f, 
    -0.29822952f, -0.15886842f, -0.13776307f, -0.02252680f, 0.00678411f, 0.16210370f, -0.16442168f, 0.13195890f, 
    0.20159753f, 0.03830226f, -0.10578099f, 0.10749082f, 0.31729051f, 0.27845910f, -0.04189204f, -0.03621409f, 
    0.00743922f, -0.10247976f, -0.09084288f, -0.11458752f, 0.00142779f, -0.20173870f, -0.14796804f, -0.05180251f, 
    0.28547570f, 0.10885004f, -0.06534635f, 0.23763394f, -0.28893059f, 0.07265571f, 0.10463883f, -0.14265390f, 
    -0.07329456f, 0.08832557f, -0.11834833f, -0.09310841f, -0.02041459f, -0.16412233f, 0.25087261f, 0.19416432f, 
    -0.08531327f, 0.12596442f, -0.22927862f, -0.00732133f, -0.06724707f, 0.07356484f, 0.15049727f, 0.08939572f, 
    -0.19427250f, 0.37407538f, 0.01129165f, -0.09194780f, -0.06734757f, 0.08346990f, -0.15129206f, -0.13836573f, 
    0.07051634f, 0.08349342f, 0.04306555f, 0.02795070f, -0.15983923f, 0.29366213f, -0.06616784f, 0.09121496f, 
    0.08966466f, -0.05566617f, 0.08107863f, -0.07126908f, -0.02055965f, -0.00187562f, 0.08438210f, -0.16267534f, 
    -0.22690481f, -0.11337448f, -0.28117070f, 0.02557219f, 0.04425281f, -0.09302369f, 0.15845925f, 0.08104002f, 
    0.09511088f, 0.13396558f, 0.04035458f, -0.00152424f, 0.65515298f, -0.14661366f, -0.09628894f, 0.02477302f, 
    -0.01529406f, -0.03092374f, -0.13295448f, -0.26592547f, 0.12345052f, 0.02577935f, 0.07529464f, 0.12347277f, 
    -0.06624424f, 0.01368311f, 0.01941156f, 0.28939667f, -0.00136717f, -0.00982828f, -0.06233483f, 0.03501211f, 
    0.00896484f, -0.15656340f, 0.08097424f, -0.00916366f, 0.16514908f, -0.37292376f, 0.13677347f, 0.59716529f, 
    -0.07894182f, 0.11776213f, -0.03100723f, 0.01805811f, -0.00709996f, 0.00152034f, 0.01281936f, 0.00129699f, 
    0.07922960f, 0.19465984f, 0.04094533f, 0.29710817f, 0.14425799f, 0.11182728f, 0.07680379f, 0.04586944f, 
    -0.04016788f, 0.07246398f, -0.06918054f, 0.04894496f, 0.49627662f, -0.06482454f, -0.06345212f, -0.31697211f, 
    0.08482073f, -0.09435683f, 0.02476481f, 0.11061572f, 0.01697037f, -0.02890676f, 0.13404073f, -0.00934696f, 
    -0.14193922f, 0.11175467f, -0.12563057f, -0.15897886f, -0.06814062f, 0.06267674f, 0.07986155f, -0.03236499f, 
    -0.07730484f, -0.05020432f, 0.02535402f, -0.17018652f, -0.18294750f, 0.05606785f, -0.12198657f, 0.01328699f, 
    -0.21674928f, -0.14310682f, 0.02691083f, -0.25742608f, 0.07165460f, 0.05569327f, 0.01740679f, -0.03239597f, 
    0.48184273f, 0.08082630f, -0.19029564f, 0.02522071f, 0.09933734f, -0.09702126f, 0.04380295f, -0.01488996f, 
    0.11626430f, 0.18314360f, -0.09948463f, -0.12947087f, -0.43435296f, -0.18202737f, -0.03171066f, -0.02344072f, 
    -0.12453023f, 0.26914218f, -0.07209192f, 0.10215928f, -0.09645331f, 0.06078877f, 0.09458458f, -0.02247624f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07046981f, 0.08284343f, -0.09954929f, 0.03289976f, 0.05475504f, -0.01968630f, -0.01079274f, -0.04481544f, 
    -0.04372051f, 0.01044659f, 0.06064799f, -0.00334492f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
