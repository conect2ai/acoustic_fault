#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.49883246f, -0.23163828f, 0.00608659f, -0.72704601f, 0.41752127f, 0.58916533f, 0.05648443f, -0.21958140f, 
    0.35124654f, 0.74829584f, 0.81274736f, 0.39058337f, -0.36498132f, 0.27018017f, -0.44989124f, -0.38894546f, 
    -0.23799692f, 0.04001376f, 0.32777292f, 0.49283105f, 0.78842092f, 0.78593034f, 0.01890099f, -0.18485209f, 
    -0.51984209f, 0.00387897f, 0.02410270f, 0.98738629f, -0.44116586f, -0.45403978f, -0.13570362f, 0.28443238f, 
    0.07440452f, -0.16020025f, -0.03613866f, 0.18185562f, 0.95871031f, 0.31424713f, -0.99892557f, 0.49837932f, 
    -0.05084080f, -0.34402812f, -0.37100893f, -0.05281932f, -0.11467015f, 0.98857409f, 0.61744767f, 0.47969094f, 
    0.15307428f, 0.16672359f, -0.08639985f, 0.37182578f, -0.18880931f, 0.07934482f, -0.11616473f, -0.06621771f, 
    0.68576539f, -1.07776570f, 0.45467401f, -0.32986736f, 0.15717350f, -0.22850105f, 0.08434305f, -0.21808070f, 
    -0.95072359f, -0.79727089f, -0.23360485f, -0.25092542f, -0.13422504f, 0.31856757f, 0.14144333f, 0.54358339f, 
    0.10850953f, 0.51270539f, 0.43903425f, 0.48794749f, 0.09493659f, 0.69302797f, -0.60446268f, -0.56127661f, 
    -0.07797154f, -0.74358016f, 0.18050887f, -0.58841443f, 0.05035962f, 0.42013115f, 0.50306028f, 0.11980798f, 
    0.54011083f, -0.40046436f, -0.82759994f, 0.10137547f, -0.63907063f, 0.05653841f, 0.78599465f, 0.58487564f, 
    -0.40260902f, 0.06499058f, 0.39026785f, -0.36292621f, -0.66491944f, -0.22281919f, 0.71655220f, 0.99041474f, 
    -0.42313394f, -0.06040952f, 0.05198834f, -0.16188644f, -0.51916903f, -0.65488541f, -0.45039412f, 0.34159970f, 
    0.50841862f, 0.73028886f, 0.06777938f, -0.13022506f, 0.25320268f, 0.08981217f, -0.16364165f, -0.96277094f, 
    -0.83425510f, 0.27179858f, 0.38670015f, -0.23232564f, -0.20223208f, 0.52610356f, -0.52785456f, -0.21106444f, 
    -0.53363425f, -0.37842065f, 0.81824720f, 0.06542414f, -0.41501361f, -0.52268124f, -0.57174337f, -0.75025421f, 
    0.04455099f, -0.19214593f, 0.27798805f, 0.75639480f, 0.17569655f, 0.03905611f, -0.29037195f, 0.02518597f, 
    -0.71650583f, -0.46664938f, 0.03604750f, -0.76717657f, -0.34542567f, 0.64353681f, 0.49102092f, 0.08991084f, 
    0.55211967f, 0.05841773f, 0.57956547f, 0.70509410f, 0.57594901f, 0.27418381f, 0.13941787f, 0.44633791f, 
    0.48699832f, 0.37585855f, 0.16809043f, -1.04998040f, -0.43208566f, -0.71024638f, -0.00388514f, -0.53963768f, 
    -0.03477009f, 0.11444889f, -0.11934140f, 0.51331073f, 0.27470994f, -0.08008689f, -0.78593928f, 0.69561660f, 
    -0.71810555f, 0.25841233f, 0.53089899f, 0.13333800f, 0.64854437f, -0.42816117f, 0.22805849f, 1.09276283f, 
    0.41428468f, -0.16937916f, -0.06629771f, 0.25957021f, 0.05185742f, 0.58814818f, -0.41782424f, -0.27597558f, 
    -0.53525549f, -0.63788539f, 0.07042255f, -0.53623539f, -0.08181053f, -0.02127015f, 0.58659863f, 0.56489831f, 
    0.69479895f, -0.24057117f, -0.70442528f, -0.02010506f, 0.27306792f, -0.19432592f, -0.35127723f, -0.75730222f, 
    -0.51084477f, 0.40203214f, -0.59890670f, -0.45799926f, -0.69773442f, 0.06800347f, 0.20058358f, -0.38836649f, 
    0.69970524f, 0.04653603f, 0.26884204f, -0.58651477f, -0.54942197f, -0.60452205f, 0.16666350f, 0.69477218f, 
    0.41803208f, -0.63988829f, -0.49757540f, -0.53789753f, -0.16790085f, -0.59633088f, 0.54474574f, -0.43764162f, 
    0.15022258f, -0.32387349f, -0.13872863f, 0.40457314f, 0.46314827f, -0.42409694f, -0.67031991f, -0.05704278f, 
    -0.32949853f, 0.43474439f, -0.34286571f, 0.48799691f, 0.60875517f, 0.00425914f, -0.18656594f, -0.24701570f, 
    0.73183084f, 0.14580026f, 0.17947091f, 0.30674160f, -0.68004012f, 0.97662878f, -0.36964276f, -0.14207421f, 
    0.37913787f, -1.13060641f, -0.04103334f, 0.25871822f, 0.18994556f, 0.77930868f, 0.36975399f, 0.77562362f, 
    0.47479904f, -0.68377125f, 0.58996445f, 0.01708387f, 0.50823885f, 0.23759517f, -0.54063332f, -0.68162030f, 
    -0.47169411f, -0.49557406f, 0.36590967f, -0.24221234f, 0.18561505f, 0.39516506f, 0.19602944f, -0.95013016f, 
    0.00951640f, 0.39453048f, 0.37547266f, 0.38838899f, -0.31240627f, -0.10503425f, -0.27860931f, -0.34808555f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.49395949f, 0.11985461f, 0.15730998f, -0.34693226f, 0.13770765f, -0.00957536f, 0.06076521f, 0.24759077f, 
    -0.20396078f, 0.18108839f, 0.12564175f, -0.07487086f, -0.26036090f, -0.22207347f, -0.04690523f, 0.13954389f, 
    0.08629272f, 0.11434335f, 0.35600907f, -0.11995928f, 0.16589418f, 0.04480205f, 0.05396019f, 0.13823968f, 
    -0.31729597f, 0.28154981f, 0.27160928f, 0.37284446f, 0.04291259f, -0.04840240f, 0.31218642f, -0.01358492f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.01219510f, 0.05278038f, -0.00093353f, 0.04997247f, -0.00394729f, -0.05199455f, 0.00988534f, -0.01784438f, 
    0.00738209f, -0.02603677f, 0.04531282f, -0.05100496f, -0.05837795f, 0.00540919f, -0.02808870f, 0.01299775f, 
    -0.01423765f, -0.06607427f, -0.01977405f, -0.05748883f, -0.05069882f, 0.01738309f, 0.03372873f, -0.03435014f, 
    -0.03371502f, 0.04934399f, -0.00796523f, -0.01718864f, -0.03251263f, 0.02576303f, 0.04318669f, -0.01524849f, 
    0.01147514f, -0.04566070f, 0.00144410f, 0.00043537f, -0.05235641f, -0.00359969f, 0.04401260f, -0.01114441f, 
    0.04770725f, 0.02745929f, 0.03119012f, -0.03532733f, 0.03850400f, -0.02530568f, -0.04821440f, 0.03074193f, 
    0.03064868f, 0.02841489f, 0.05428613f, 0.04857935f, 0.01042290f, 0.00717261f, 0.02614882f, -0.03342176f, 
    -0.00508602f, -0.05921705f, -0.04154205f, -0.01681321f, -0.04988476f, 0.01674737f, 0.03820303f, -0.03486564f, 
    0.03876965f, -0.00777551f, 0.04243129f, 0.01441730f, 0.04739711f, 0.01085776f, -0.03420576f, -0.03499884f, 
    -0.02861123f, 0.02453199f, -0.06228779f, 0.02878520f, 0.01135885f, -0.00836967f, -0.02807217f, -0.01292603f, 
    -0.03907469f, 0.03547022f, 0.00644700f, -0.03439545f, 0.02848084f, 0.04190229f, -0.05368870f, 0.05385932f, 
    0.04437657f, -0.03123746f, 0.04689775f, -0.03701254f, -0.06459799f, 0.04262075f, 0.02067293f, -0.04852731f, 
    0.01586253f, 0.02667244f, 0.01419627f, 0.01807189f, 0.01520155f, -0.01318219f, 0.04762482f, 0.00912839f, 
    -0.06157089f, -0.06367566f, 0.02109092f, -0.03533206f, -0.04686664f, 0.03542341f, -0.06512407f, -0.00250575f, 
    -0.03314699f, -0.03065036f, -0.04994549f, 0.01245139f, 0.03910691f, -0.04099893f, 0.04966487f, -0.05443678f, 
    -0.01100910f, -0.01530888f, 0.01787509f, 0.01513108f, -0.01077239f, -0.03595483f, 0.04384585f, -0.05313803f, 
    -0.03940580f, 0.01563414f, 0.03967695f, -0.01142796f, 0.01125141f, -0.03550321f, 0.00373249f, -0.06383684f, 
    -0.00456588f, -0.05326817f, -0.06636151f, 0.02510716f, 0.03078564f, 0.03763421f, -0.02345915f, -0.00921088f, 
    -0.04951172f, -0.05265294f, -0.02210935f, -0.00884478f, -0.01586887f, 0.02601470f, -0.03727863f, -0.01729564f, 
    -0.01210346f, 0.04357441f, 0.01249972f, 0.05566660f, -0.04051304f, -0.00439104f, -0.00187856f, 0.03397356f, 
    -0.02637231f, -0.01563540f, -0.03127740f, 0.04434960f, 0.00986011f, -0.01947907f, 0.00430128f, -0.06481353f, 
    0.01047798f, 0.04367270f, 0.04315314f, 0.04850876f, 0.04797110f, -0.03610935f, 0.00398913f, 0.01292784f, 
    0.00471237f, -0.06469038f, 0.00620120f, 0.05489768f, -0.03333188f, 0.01701793f, 0.01616155f, -0.02934427f, 
    0.03993075f, -0.00806556f, 0.03141934f, 0.02158512f, -0.04815814f, -0.01550451f, -0.03050446f, -0.07234437f, 
    -0.02263993f, -0.03294406f, 0.03258532f, -0.03611215f, 0.05053407f, -0.00721865f, -0.05629299f, 0.05460517f, 
    -0.03328237f, 0.03000532f, -0.05057661f, -0.03610190f, 0.00541906f, -0.03285822f, 0.00992612f, 0.01941771f, 
    0.03672625f, -0.00584247f, -0.02536432f, -0.00074245f, -0.05033282f, -0.00207425f, 0.04453668f, -0.01446799f, 
    -0.04647380f, 0.06084859f, -0.04818366f, 0.03222400f, 0.02976351f, -0.04115343f, 0.03825236f, -0.02237656f, 
    -0.01065488f, -0.00452414f, 0.03031864f, -0.04766089f, -0.04640012f, -0.01617160f, -0.02957995f, -0.02143921f, 
    -0.05461696f, -0.04006873f, 0.03880776f, 0.02466753f, -0.03831133f, 0.02178123f, -0.00484444f, -0.04234408f, 
    -0.05791620f, -0.05029225f, 0.00944433f, 0.02368297f, -0.04842009f, 0.04763160f, -0.05201488f, -0.02205624f, 
    -0.00090903f, 0.05319884f, -0.00708289f, -0.04339930f, 0.02835367f, -0.00343648f, 0.00172381f, -0.03919720f, 
    -0.01520510f, -0.03170952f, -0.05962069f, 0.00931930f, -0.03712182f, -0.05740832f, -0.05557909f, 0.04835659f, 
    -0.00264012f, -0.02378563f, 0.03331878f, -0.03795682f, -0.00301697f, 0.04606677f, 0.02925580f, -0.03470837f, 
    0.01766307f, -0.03697398f, -0.03307561f, 0.00047414f, -0.01479739f, -0.04751021f, 0.02050484f, -0.06533714f, 
    0.03569717f, -0.04057478f, 0.03056319f, 0.01461332f, -0.05381462f, -0.02520930f, 0.04777982f, -0.05826051f, 
    0.01248181f, -0.04689106f, -0.04869931f, 0.04202080f, 0.03936357f, -0.03787670f, 0.00799460f, 0.03461748f, 
    -0.01830245f, 0.02636966f, 0.02954940f, 0.00757192f, -0.05357366f, -0.03050616f, -0.01771440f, -0.06675979f, 
    0.03063644f, 0.01461002f, -0.02868858f, -0.00933983f, -0.00066318f, 0.03698010f, -0.03317863f, -0.06185928f, 
    0.00122413f, -0.00811510f, 0.03599880f, -0.04073703f, 0.02826268f, 0.02514328f, 0.03323739f, 0.00400537f, 
    0.03289447f, -0.00279108f, 0.01858492f, -0.04233458f, -0.02823832f, -0.02310311f, 0.01949569f, 0.00087954f, 
    0.03198193f, 0.01957979f, -0.06419653f, 0.00542829f, -0.03205398f, 0.00184417f, -0.04481443f, -0.04816498f, 
    -0.03368356f, 0.02678361f, -0.05196587f, 0.02743690f, -0.05438508f, -0.01454422f, 0.01333957f, 0.03645021f, 
    0.04000293f, -0.03203106f, -0.00321848f, 0.01414823f, 0.01520451f, 0.01475265f, 0.02121955f, -0.02746901f, 
    -0.05280391f, 0.04044145f, -0.04671779f, -0.01588992f, 0.04778032f, 0.03897858f, -0.00184278f, -0.03410891f, 
    -0.04829955f, 0.00552705f, 0.04839608f, 0.02925057f, 0.03182959f, 0.01671128f, -0.03431067f, -0.06195456f, 
    -0.05990825f, -0.01372917f, -0.04752576f, -0.02201403f, 0.01144946f, 0.00888802f, 0.04799015f, -0.01020113f, 
    -0.05905559f, 0.00662969f, -0.05833030f, -0.05114424f, 0.00932149f, -0.03678169f, -0.04480359f, 0.02712241f, 
    -0.05420840f, -0.05094466f, -0.02478865f, 0.04244347f, -0.02114570f, 0.02090000f, -0.00738342f, 0.01786326f, 
    -0.02115419f, -0.02102369f, 0.01843479f, 0.03159970f, 0.03096787f, 0.05192000f, 0.01764898f, 0.02425388f, 
    -0.06663609f, -0.02462051f, 0.04360794f, -0.03047311f, 0.04707080f, -0.06723156f, 0.01596987f, -0.01392956f, 
    -0.01316481f, -0.03209685f, -0.01596807f, 0.03515752f, 0.04218502f, -0.06738169f, -0.03948537f, -0.00140468f, 
    0.03077354f, 0.02554288f, -0.05226818f, 0.04101155f, 0.03130778f, -0.06192984f, -0.04741061f, -0.03134746f, 
    0.02863355f, 0.00859378f, 0.02456501f, -0.01587436f, -0.07019559f, 0.02248878f, 0.03157603f, 0.00810917f, 
    -0.01200339f, 0.03037036f, -0.03475190f, -0.03253388f, -0.05489878f, -0.00847386f, 0.00815492f, 0.01822775f, 
    -0.05024214f, 0.00335441f, -0.00527643f, 0.03918980f, 0.02727651f, -0.02217974f, -0.05002982f, -0.03495780f, 
    0.03366317f, 0.02172181f, 0.01658016f, -0.03446745f, 0.04122834f, -0.02987441f, 0.03149780f, -0.03148182f, 
    -0.05810905f, -0.03952872f, 0.00327015f, -0.04677166f, 0.03373849f, 0.04010689f, 0.02850822f, -0.06627788f, 
    -0.05906066f, 0.00931441f, 0.00991847f, -0.05719018f, 0.02156148f, 0.00811138f, -0.02174594f, -0.03790539f, 
    0.04006756f, 0.04714640f, -0.00394352f, 0.02955589f, 0.04796213f, 0.01282803f, -0.00127580f, -0.03152792f, 
    0.04934371f, -0.04176379f, 0.04872452f, 0.01022386f, -0.01304534f, -0.02596016f, -0.03648228f, 0.02304934f, 
    -0.04973636f, -0.03422495f, 0.00499257f, -0.06147515f, 0.03708458f, -0.03644922f, 0.00648118f, -0.04200358f, 
    0.01180367f, -0.05874228f, -0.03091252f, -0.00565910f, 0.02296934f, -0.05181183f, -0.03244894f, -0.03392049f, 
    -0.03117840f, 0.02621499f, -0.02950201f, 0.04860622f, -0.02213985f, -0.02333946f, -0.04651441f, 0.02693352f, 
    0.00548073f, -0.04152121f, -0.04783634f, -0.00177826f, 0.03519464f, 0.03185392f, 0.02813172f, -0.02971100f, 
    -0.06454349f, -0.03092942f, 0.03547930f, 0.04913058f, -0.03195081f, -0.03636660f, -0.01228714f, -0.06688397f, 
    -0.02204320f, -0.00511755f, -0.01728653f, -0.00455975f, 0.04453539f, -0.06549510f, -0.06311159f, 0.03993187f, 
    -0.01166095f, 0.00440590f, -0.05129057f, -0.02803067f, -0.05408056f, 0.00679856f, 0.01759044f, -0.02690891f, 
    -0.03041071f, -0.04138222f, 0.00722419f, 0.03386020f, -0.01999922f, -0.05136476f, 0.04052345f, 0.01519470f, 
    0.04730453f, -0.03397224f, 0.00851063f, -0.04376960f, -0.05028205f, 0.01818103f, -0.01124984f, -0.03733104f, 
    -0.05124447f, 0.04260162f, 0.04488230f, 0.02712069f, 0.01576761f, -0.03253975f, -0.04616837f, -0.02703883f, 
    -0.05859627f, 0.01477540f, 0.02026542f, -0.06634432f, 0.00720248f, -0.03851665f, 0.00143850f, 0.04209756f, 
    -0.03175357f, 0.02120935f, -0.03813333f, -0.04018849f, 0.04186843f, -0.03117465f, 0.01403477f, -0.05339009f, 
    0.00619233f, -0.04932693f, 0.02542022f, -0.02995700f, -0.02850970f, 0.03486691f, -0.04123809f, 0.04551349f, 
    -0.02121248f, -0.01952383f, -0.01729665f, -0.02552602f, 0.01733668f, 0.03204419f, 0.00285292f, 0.03034650f, 
    -0.02136337f, 0.01260627f, 0.00560365f, -0.02968730f, -0.04637625f, 0.01004240f, 0.00897040f, -0.05213038f, 
    -0.05962775f, 0.03983087f, -0.07346182f, -0.00969674f, -0.01987606f, -0.01454636f, -0.02981391f, -0.02575435f, 
    0.02717806f, -0.06521864f, 0.01463284f, -0.05516334f, 0.03301861f, -0.04073124f, 0.03783180f, 0.03747740f, 
    -0.01501596f, 0.03412239f, -0.03703306f, 0.01465563f, -0.00198851f, -0.05686073f, 0.01855293f, -0.03071545f, 
    0.03114371f, -0.01792186f, 0.02175997f, 0.02615158f, -0.01020436f, -0.03654967f, 0.03347825f, -0.00528636f, 
    0.00834546f, -0.02314740f, -0.04480888f, -0.02727936f, -0.02789732f, 0.00657172f, 0.03469954f, -0.00249425f, 
    -0.03767887f, -0.01842924f, 0.03497322f, -0.02062489f, -0.06104144f, 0.02515653f, -0.00547869f, 0.00862431f, 
    0.03881861f, -0.06531829f, -0.06688126f, 0.02233543f, 0.01378764f, 0.03461134f, 0.04840667f, -0.03036975f, 
    0.02477560f, 0.00432620f, -0.07329961f, 0.03754084f, -0.04221767f, 0.00055387f, 0.02936964f, 0.02743327f, 
    0.05188338f, 0.03062760f, -0.01967441f, -0.04297768f, 0.02230295f, -0.01906087f, -0.02196346f, 0.02615384f, 
    -0.00181370f, 0.02550993f, 0.04686211f, 0.03991406f, -0.04430465f, -0.00130894f, -0.02534676f, -0.03870374f, 
    0.05160074f, 0.04539374f, -0.01448389f, -0.03335175f, 0.03318985f, -0.05056844f, 0.00821297f, 0.03652188f, 
    -0.04426574f, 0.01405787f, 0.03744052f, 0.00949904f, -0.00088900f, -0.05091384f, -0.05994717f, -0.02110862f, 
    0.01913105f, -0.03695606f, 0.01869070f, -0.04795381f, -0.02658069f, -0.06152714f, -0.03608771f, -0.00658661f, 
    0.03737798f, -0.01392914f, 0.03399038f, -0.01355945f, -0.04060272f, -0.04353509f, -0.01559631f, 0.03662398f, 
    0.03330386f, 0.02252816f, 0.01493974f, 0.03379297f, -0.01945977f, -0.05244739f, -0.04545657f, 0.04038247f, 
    -0.03798555f, -0.04669022f, 0.02164399f, -0.01948827f, -0.02485397f, -0.06115989f, -0.02196443f, -0.05666050f, 
    -0.04106198f, 0.03752564f, -0.05374733f, -0.03719627f, 0.03585928f, 0.02149671f, -0.04064906f, -0.05911249f, 
    -0.00017671f, 0.01292510f, 0.03016267f, 0.00184896f, -0.03806354f, -0.02137502f, -0.04091335f, -0.02414645f, 
    0.01695633f, -0.02154295f, 0.00570090f, -0.00392667f, 0.02140369f, 0.01486395f, -0.06249814f, -0.02827514f, 
    0.01064341f, 0.02460682f, -0.03474774f, 0.03361499f, -0.05969359f, -0.04682372f, -0.00741351f, -0.00046487f, 
    -0.03052061f, -0.02302290f, 0.01476925f, -0.03877391f, -0.01095673f, -0.00158152f, 0.02959529f, -0.05005125f, 
    -0.01080903f, -0.00738291f, 0.03634476f, -0.05002569f, -0.05596420f, -0.01136506f, 0.01162040f, -0.01826777f, 
    0.00918049f, -0.04273844f, 0.00370856f, -0.00313041f, -0.02345191f, 0.03981095f, -0.01249522f, 0.03347897f, 
    0.01767098f, -0.03834518f, 0.01406424f, -0.05959335f, -0.00453418f, 0.05028955f, 0.05073767f, -0.00428263f, 
    -0.01141524f, -0.05468968f, 0.03525957f, 0.04758221f, -0.00304294f, -0.06766164f, 0.02387817f, 0.02651446f, 
    -0.03113337f, 0.02243416f, 0.04192740f, -0.00739009f, 0.02532215f, -0.01601852f, -0.00065785f, 0.02881272f, 
    -0.01017163f, -0.01466992f, -0.05508979f, 0.02177526f, 0.03891051f, -0.06997176f, 0.03940179f, -0.04849320f, 
    0.02380121f, 0.00024680f, 0.02992866f, -0.02453663f, 0.03825627f, 0.03968265f, 0.00652365f, 0.01735766f, 
    -0.04180937f, 0.05699925f, -0.02298786f, -0.05061282f, -0.00450991f, 0.03381088f, -0.00880567f, 0.03959074f, 
    0.02986859f, 0.02346166f, 0.04108962f, -0.06246688f, 0.00868219f, -0.04059761f, -0.03819020f, -0.00626991f, 
    -0.01006729f, -0.06193800f, -0.02569972f, -0.05291847f, 0.03937421f, -0.05876186f, -0.02577175f, -0.00348965f, 
    -0.06020869f, 0.01576985f, 0.03097995f, -0.06237967f, 0.00770724f, -0.03084412f, 0.01785978f, -0.00298059f, 
    -0.03459985f, -0.04404549f, 0.02049991f, 0.04479153f, -0.04118261f, 0.04512945f, -0.03890071f, 0.04107383f, 
    -0.00312749f, -0.03146791f, -0.05512049f, 0.04373933f, 0.02197265f, -0.02500929f, 0.04075961f, -0.01320550f, 
    0.02072788f, 0.00009471f, 0.02866358f, -0.03978963f, 0.05556863f, 0.04359259f, 0.01467844f, -0.01237552f, 
    -0.01642622f, -0.05295703f, -0.05520639f, 0.03025975f, 0.00895970f, 0.01592505f, 0.02871480f, -0.00096854f, 
    0.04406635f, -0.03596393f, -0.01673154f, -0.02779617f, -0.00550371f, -0.06112431f, -0.01611700f, -0.02036668f, 
    -0.00292483f, -0.02522330f, -0.04485008f, 0.00684478f, -0.02896080f, -0.04712223f, -0.00411701f, 0.00841892f, 
    -0.02023639f, 0.02008161f, -0.01791770f, -0.03102217f, -0.02197856f, 0.04155741f, 0.01237047f, 0.04112406f, 
    -0.05310299f, 0.01484189f, 0.04036811f, -0.02388414f, -0.01536724f, 0.04802180f, -0.04495932f, 0.05406911f, 
    0.00134637f, 0.01813800f, 0.03439824f, -0.02824180f, -0.01901518f, 0.04297270f, 0.04507324f, 0.04043538f, 
    -0.05081332f, 0.01278266f, -0.05629054f, -0.00839958f, -0.01988231f, -0.00364177f, -0.03867894f, -0.00095842f, 
    0.02918213f, -0.00551045f, 0.03861029f, 0.03103042f, 0.01235115f, 0.02548202f, -0.03613164f, -0.03386549f, 
    0.00536857f, 0.03100592f, -0.05881513f, -0.03294259f, 0.03749468f, -0.03482330f, -0.02934134f, -0.03084113f, 
    -0.06966414f, 0.04602192f, -0.01643585f, 0.03852406f, 0.03424236f, 0.03236745f, 0.02410956f, 0.02411473f, 
    -0.04846649f, 0.04215834f, 0.00658489f, -0.05163404f, -0.00390282f, -0.02156322f, -0.05219450f, 0.03374237f, 
    -0.00560033f, -0.00242672f, -0.02109539f, -0.01571807f, -0.02781698f, -0.02212343f, 0.01766654f, 0.01720194f, 
    -0.05891952f, 0.02700043f, -0.03341895f, -0.01451701f, 0.03226154f, -0.00556294f, -0.05495182f, -0.03855648f, 
    0.01660884f, 0.01893276f, -0.01095918f, -0.00308730f, -0.02892620f, -0.04708627f, -0.03358392f, -0.04746670f, 
    -0.03399647f, -0.05454287f, -0.00211902f, -0.01166199f, -0.05729664f, 0.03040561f, 0.04498785f, -0.02180356f, 
    -0.05082838f, -0.00862440f, 0.00604691f, -0.03675232f, 0.01874956f, -0.05632519f, 0.01371699f, -0.03192215f, 
    -0.00029568f, 0.03272464f, -0.03477541f, 0.04011696f, 0.03768353f, -0.04571969f, -0.04807332f, 0.01577942f, 
    -0.03012093f, -0.01801998f, -0.03807392f, -0.05462150f, -0.03374044f, -0.05394141f, -0.01403330f, 0.00225178f, 
    0.01324344f, 0.04319290f, -0.04569266f, -0.04076803f, 0.04561367f, -0.05110577f, 0.01509381f, 0.02664572f, 
    0.03964655f, -0.03148432f, -0.02468281f, 0.01743612f, 0.01505948f, -0.01296597f, -0.00698818f, 0.04337384f, 
    0.04786149f, 0.01525170f, -0.05609650f, 0.02935424f, 0.01593487f, 0.03132952f, 0.03273402f, 0.04076052f, 
    -0.05275837f, -0.03891778f, -0.02486601f, -0.03725789f, -0.00996975f, 0.05244602f, -0.03847912f, 0.00545066f, 
    -0.03383588f, -0.02265041f, -0.01803290f, 0.04020053f, 0.02025109f, -0.04196887f, 0.00230775f, 0.01194631f, 
    0.04352203f, 0.00277359f, -0.02321841f, -0.04719028f, 0.02331352f, -0.01640249f, -0.05124054f, -0.00986683f, 
    0.02391769f, 0.01325630f, -0.05802668f, -0.00274301f, 0.00217898f, -0.04703053f, 0.02847208f, -0.05551796f, 
    0.00449036f, 0.04248367f, -0.04184601f, 0.04025541f, 0.02592859f, 0.00259791f, 0.05173538f, 0.03170008f, 
    -0.02823833f, 0.02731563f, -0.05703439f, -0.00375979f, -0.03134112f, 0.04595547f, 0.02109809f, -0.04419059f, 
    0.03494854f, 0.02208669f, -0.04931667f, -0.01966328f, 0.03230979f, 0.01908590f, -0.04819378f, 0.00674926f, 
    -0.01373413f, 0.03659905f, -0.05243188f, -0.06285858f, -0.05630165f, -0.04045243f, -0.01865178f, -0.02650949f, 
    -0.05331983f, -0.05284214f, 0.00454364f, -0.04047457f, 0.00944526f, 0.01663562f, 0.03182839f, 0.03425455f, 
    -0.03642183f, 0.01418069f, -0.06620617f, 0.01180337f, 0.02401200f, -0.06128040f, 0.02188070f, -0.06005195f, 
    -0.01328379f, -0.00842296f, 0.05179291f, -0.04930143f, -0.02933002f, 0.05299552f, -0.02551707f, 0.00618884f, 
    -0.02614340f, -0.06320871f, -0.00487137f, -0.03225792f, -0.02144078f, -0.01383154f, -0.04079711f, 0.00933345f, 
    -0.52869105f, -0.23475750f, -0.21593446f, -0.24347146f, -0.08689664f, -0.06434431f, -0.12209275f, -0.24832460f, 
    0.10734533f, -0.01456990f, 0.19668706f, 0.11616680f, 0.07563855f, -0.20520155f, -0.14530240f, 0.00201279f, 
    0.11594309f, 0.02796561f, 0.02491431f, 0.07893322f, 0.26464659f, -0.05844273f, -0.03853137f, -0.11158030f, 
    0.20903906f, 0.06373192f, -0.09619932f, -0.13298947f, -0.14276646f, -0.19373809f, -0.19743766f, -0.19827498f, 
    0.05092428f, -0.07543908f, -0.17586300f, -0.00260896f, -0.25641906f, 0.20950185f, -0.03522693f, -0.10458504f, 
    -0.09338116f, 0.06232452f, 0.04364828f, 0.04193809f, 0.05076583f, -0.09712414f, 0.09694029f, 0.09221892f, 
    -0.03721863f, -0.01293792f, -0.09143475f, 0.13959517f, -0.02880413f, -0.00588202f, -0.05788154f, -0.04331443f, 
    0.02855856f, 0.00084083f, -0.01822266f, -0.02118865f, -0.06696070f, -0.05335867f, 0.07357123f, 0.04458126f, 
    -0.06389540f, -0.03649251f, 0.10911246f, 0.19654304f, -0.05290017f, -0.10715725f, -0.07279705f, -0.10431404f, 
    -0.00291932f, 0.05877795f, 0.14179686f, -0.00496556f, -0.05776347f, 0.00642729f, 0.30155963f, 0.06925721f, 
    0.03577986f, -0.19923306f, -0.24394178f, -0.05399762f, 0.11149934f, 0.02009535f, -0.06897459f, -0.02994044f, 
    0.10263593f, -0.06536251f, 0.36788240f, -0.17700739f, -0.06052267f, 0.17892966f, 0.07253163f, -0.06175438f, 
    0.01046767f, -0.04382798f, 0.04528794f, -0.29650414f, -0.20875891f, -0.20029561f, 0.25290427f, 0.07093061f, 
    -0.01800531f, 0.03264983f, -0.03478651f, -0.09011346f, 0.13933158f, -0.15530433f, -0.07532083f, 0.05541977f, 
    0.08580380f, -0.00194175f, -0.06201223f, -0.18668412f, -0.01743044f, -0.00833968f, -0.21454191f, -0.06580312f, 
    -0.17441492f, -0.08017072f, -0.04152944f, -0.11210214f, -0.02879209f, 0.21619500f, 0.17065765f, -0.09991986f, 
    0.02951832f, 0.06143868f, -0.03528523f, -0.04788276f, 0.08476891f, -0.00602326f, -0.02298842f, 0.18106085f, 
    -0.05623483f, 0.05708411f, 0.16285026f, -0.10255932f, -0.02215248f, -0.06964786f, -0.06618018f, 0.04373731f, 
    0.06613425f, -0.32299221f, -0.04301849f, 0.15942283f, 0.05151745f, 0.14170158f, -0.04614402f, -0.04563085f, 
    -0.13331079f, 0.00745324f, 0.00845759f, -0.10535713f, 0.03847323f, 0.13063101f, -0.10287561f, -0.06701968f, 
    0.09612232f, -0.15379892f, -0.21243943f, 0.03405807f, 0.00210446f, -0.02414203f, 0.28803572f, 0.07398339f, 
    0.00636275f, -0.00884989f, -0.02215158f, -0.20867011f, -0.03456254f, 0.04824063f, 0.07798827f, -0.03741716f, 
    -0.16433300f, -0.02323921f, 0.08253624f, 0.06803263f, 0.05475036f, 0.16317591f, 0.18942387f, 0.12289765f, 
    -0.01502755f, 0.15720426f, 0.22317453f, 0.01826462f, 0.00831554f, 0.01144939f, -0.05244637f, 0.02979941f, 
    0.06210848f, 0.00946672f, 0.07904658f, -0.16217719f, -0.05821228f, 0.10771902f, 0.21286672f, 0.02973478f, 
    0.14597507f, -0.13908361f, -0.08922035f, -0.00576253f, -0.04010011f, 0.14746833f, 0.15939085f, -0.13203543f, 
    0.02935183f, -0.13156739f, 0.19049725f, 0.13938083f, 0.14281802f, -0.03591664f, 0.10133151f, -0.10735872f, 
    -0.08899000f, 0.10644323f, 0.02488463f, -0.19414115f, -0.05962196f, 0.09224518f, 0.01026810f, -0.08387928f, 
    0.10120533f, -0.14152934f, -0.09805042f, -0.00969128f, 0.14669953f, 0.09607896f, -0.09128050f, -0.15410213f, 
    0.00850407f, 0.00996780f, -0.01086647f, 0.11912473f, 0.12125921f, -0.28229994f, -0.04523242f, 0.11217225f, 
    0.01952050f, 0.23828539f, 0.10065199f, -0.24420285f, 0.05708250f, -0.07843927f, -0.06943223f, 0.07429271f, 
    0.16141032f, -0.03747817f, -0.03011946f, -0.13234834f, -0.03564138f, -0.11227380f, -0.20910734f, 0.14988953f, 
    0.00559121f, 0.03521765f, -0.00838004f, 0.21537070f, -0.06749299f, -0.01273376f, -0.01896983f, -0.05597911f, 
    0.07512979f, -0.03989436f, 0.11129655f, -0.04966676f, 0.03709046f, 0.06502847f, -0.26791373f, -0.17478275f, 
    -0.04316058f, 0.07199156f, 0.14612532f, 0.10226455f, -0.11227382f, -0.05565713f, 0.02984114f, -0.05607484f, 
    0.07204826f, 0.14090928f, 0.05512390f, -0.07292069f, 0.08139566f, -0.02010460f, 0.08535322f, 0.01092789f, 
    -0.15214083f, -0.00147820f, -0.11842605f, -0.18914999f, -0.05425867f, -0.05324271f, 0.10039638f, -0.10945819f, 
    -0.13419029f, 0.32942677f, 0.08756910f, -0.10226735f, 0.23809548f, -0.03429949f, 0.05054009f, 0.12842607f, 
    0.05294326f, 0.08220021f, 0.06854731f, -0.10206745f, -0.02752549f, 0.07425977f, 0.14495468f, 0.21034157f, 
    0.07058339f, 0.22184366f, -0.11546440f, -0.08195502f, 0.40019184f, 0.25782436f, -0.20509079f, -0.11669618f, 
    0.00035786f, -0.01243397f, 0.07051945f, -0.00596343f, 0.16033027f, 0.25533137f, 0.16175078f, -0.04147104f, 
    0.07179414f, 0.08943415f, 0.01774186f, 0.07456000f, -0.06247979f, -0.03144241f, -0.02082758f, -0.09648170f, 
    0.20245737f, 0.05004829f, -0.00897244f, 0.02437615f, -0.01163103f, 0.05046169f, -0.02921214f, 0.12649594f, 
    -0.14886424f, -0.05852799f, -0.05210767f, -0.07014239f, 0.10304891f, 0.16513616f, 0.02336593f, 0.20307258f, 
    -0.02936572f, 0.08508127f, 0.08565426f, 0.02240742f, 0.08055479f, 0.11611591f, -0.02121332f, 0.10316474f, 
    -0.07542769f, -0.01326107f, -0.17960982f, 0.05474107f, 0.04809815f, 0.13800929f, 0.17185861f, 0.21113022f, 
    -0.36321947f, 0.13450530f, 0.19050984f, 0.00892548f, 0.11447325f, 0.07855275f, 0.19692612f, -0.11531175f, 
    -0.10623449f, 0.13203709f, 0.04734980f, 0.05750107f, 0.15856883f, 0.26036066f, 0.09755427f, 0.11361577f, 
    -0.17367403f, -0.07774144f, 0.03705053f, -0.32545537f, -0.10819860f, 0.24149379f, 0.22560467f, -0.09916428f, 
    -0.00270701f, -0.16745688f, 0.12447119f, 0.02988502f, 0.05831762f, -0.19413991f, 0.14627670f, 0.34431794f, 
    0.12423564f, 0.01831000f, -0.00457552f, -0.13422932f, 0.02217184f, -0.02159575f, 0.14808267f, 0.01864025f, 
    0.02009495f, 0.11193699f, -0.10669036f, 0.08827920f, 0.00382048f, -0.07480399f, -0.26428434f, 0.26196119f, 
    0.03752203f, -0.20946057f, -0.02477420f, 0.11836918f, -0.14683403f, 0.32422048f, 0.17485343f, -0.10324828f, 
    -0.04713803f, 0.10359038f, 0.06731986f, 0.14308389f, 0.20282970f, -0.06719366f, 0.09075270f, 0.27507484f, 
    -0.16142572f, 0.09139262f, -0.03437177f, 0.13476822f, 0.09285662f, -0.02103130f, 0.08741912f, -0.17267399f, 
    -0.21652751f, 0.04756637f, 0.10623154f, -0.11432943f, 0.16034500f, 0.07424288f, 0.19462211f, 0.13224554f, 
    0.11745455f, -0.22421400f, 0.01792484f, 0.00210659f, 0.13635610f, -0.19029360f, -0.08702398f, -0.10562118f, 
    0.15842129f, 0.02594291f, 0.16227940f, 0.02226369f, 0.20349529f, 0.07335708f, -0.02780934f, -0.10111608f, 
    -0.21145287f, 0.04964375f, 0.10987850f, -0.02247335f, -0.05813123f, -0.06735864f, -0.03431752f, 0.16263388f, 
    -0.03398546f, 0.12872745f, -0.08577927f, 0.14164734f, -0.32701591f, 0.10437280f, 0.21082555f, -0.03781491f, 
    -0.14500728f, 0.05217664f, 0.06800066f, 0.18414013f, 0.10044206f, 0.01213033f, 0.08758611f, -0.05053651f, 
    -0.25745872f, 0.09347609f, -0.00531150f, -0.09347209f, 0.23423715f, 0.07188085f, 0.09661541f, 0.07534259f, 
    0.02587828f, 0.03612916f, 0.06030803f, -0.04713489f, -0.04430730f, 0.07831760f, 0.17416392f, 0.07920652f, 
    -0.13944246f, -0.11176073f, -0.02809694f, 0.01863395f, -0.04062035f, -0.22129881f, 0.10693033f, 0.19156902f, 
    -0.12758699f, 0.16198964f, -0.01097101f, 0.21589300f, 0.02658765f, -0.08827834f, 0.16813216f, -0.02137428f, 
    0.08562369f, 0.25220290f, -0.03424980f, 0.12095128f, 0.01573989f, 0.05112395f, 0.01735074f, -0.09926964f, 
    0.11865231f, 0.10272373f, 0.00746328f, -0.05522146f, -0.03717574f, -0.07526999f, 0.11873823f, 0.09049490f, 
    -0.06397236f, 0.09307188f, 0.05138157f, -0.38695878f, 0.14151603f, 0.26605341f, 0.15803781f, -0.05887777f, 
    -0.08011650f, -0.19220227f, -0.00174268f, -0.08648226f, 0.02867212f, -0.17568447f, -0.32034016f, -0.15615906f, 
    -0.06112343f, 0.19479170f, -0.05445832f, 0.08793055f, -0.07854345f, -0.18963951f, -0.06750455f, 0.01732976f, 
    0.06777833f, 0.12555951f, -0.00184355f, 0.01506803f, 0.03983483f, -0.06660468f, 0.14470299f, 0.00852944f, 
    -0.05106532f, 0.05087131f, -0.06082636f, -0.09513167f, 0.14547570f, -0.04560423f, -0.03511792f, -0.19475834f, 
    -0.03019759f, 0.00147919f, 0.01063234f, -0.00930852f, 0.03310455f, 0.04255436f, -0.03653897f, -0.03711567f, 
    0.03251260f, -0.04720560f, -0.03971239f, -0.05282499f, 0.00476837f, 0.03063081f, -0.04383949f, 0.01924968f, 
    0.03541549f, 0.04204781f, -0.00919256f, -0.02099580f, 0.04928786f, 0.03626525f, -0.03251157f, -0.02681822f, 
    0.04997100f, -0.00416784f, -0.00957530f, -0.01713221f, -0.01643531f, 0.00122300f, 0.01258442f, 0.03338788f, 
    -0.02904608f, -0.05233509f, -0.05098959f, 0.05138078f, 0.00461070f, 0.04863103f, 0.04984983f, -0.05309698f, 
    -0.06338146f, -0.00515411f, 0.01855898f, 0.02996697f, -0.05988503f, -0.03310532f, -0.01426955f, 0.00013520f, 
    -0.04637692f, -0.01696287f, 0.03904173f, -0.05459491f, 0.03396431f, -0.04380185f, -0.02492597f, -0.00812409f, 
    -0.04765923f, 0.00363658f, -0.05475355f, -0.06621038f, 0.01899846f, 0.03312464f, -0.01927705f, -0.00890271f, 
    0.01441227f, -0.00809501f, -0.01653511f, -0.02834365f, 0.03474972f, -0.01548284f, -0.06535552f, -0.05692703f, 
    0.05640075f, -0.04850651f, -0.02822677f, -0.01587117f, -0.05070609f, -0.05368191f, 0.03779862f, -0.01323127f, 
    -0.02991933f, 0.04059493f, 0.00357481f, 0.02695991f, 0.02850383f, 0.01107996f, -0.06297331f, -0.06369063f, 
    0.03005866f, -0.03665162f, 0.00644725f, 0.04104737f, -0.03362459f, -0.03693530f, 0.03028551f, -0.00152543f, 
    -0.05677711f, -0.02561548f, -0.05415803f, 0.01054548f, -0.05536279f, -0.05104053f, 0.02471456f, -0.03993108f, 
    0.02780156f, -0.00653091f, -0.03523584f, 0.05122325f, -0.04234303f, -0.00565921f, -0.05856083f, -0.05408343f, 
    0.00628433f, -0.05295867f, -0.06070885f, -0.01197940f, -0.06273273f, -0.04726085f, -0.02459121f, 0.03680150f, 
    -0.04129968f, 0.01030682f, -0.03919176f, -0.05348498f, 0.04203991f, -0.01693655f, -0.06357358f, 0.01061781f, 
    0.02972328f, -0.02906961f, 0.02577141f, -0.03052115f, -0.02069188f, -0.05972341f, 0.03575056f, 0.01288911f, 
    -0.02680831f, 0.03953330f, -0.06012598f, -0.05205041f, -0.01627736f, 0.03725539f, 0.02040328f, 0.01367361f, 
    0.03000960f, -0.05305961f, -0.00561861f, 0.04140958f, -0.06270687f, -0.06251726f, -0.05818929f, -0.00809584f, 
    0.01316625f, 0.02182552f, -0.03106501f, -0.00576883f, -0.03867616f, 0.01052321f, 0.04203448f, -0.06045775f, 
    -0.06548954f, -0.02900698f, 0.00590697f, 0.03243664f, 0.03266729f, 0.01164932f, -0.03964690f, -0.02909113f, 
    -0.00836145f, 0.03334049f, 0.00156249f, -0.02722521f, -0.06036744f, -0.01501970f, 0.02935906f, -0.01962914f, 
    0.03460968f, -0.00394898f, 0.04368040f, 0.04550662f, -0.02910605f, -0.04064787f, 0.04242252f, 0.03591903f, 
    -0.06990046f, 0.04282622f, -0.00547385f, 0.00391409f, 0.02403268f, 0.00614172f, 0.01636743f, 0.00215155f, 
    0.00772959f, -0.06726402f, 0.01871394f, 0.03799967f, -0.01803457f, 0.01269028f, 0.02819330f, -0.00600466f, 
    0.00519650f, -0.03597321f, -0.02924807f, 0.03865700f, 0.03075241f, -0.01710521f, -0.05258897f, -0.02781619f, 
    0.04634788f, 0.04692200f, -0.05959070f, -0.03423713f, -0.02025078f, 0.00823794f, -0.01262766f, 0.02947909f, 
    0.03567300f, -0.03663233f, -0.04728522f, -0.05088540f, 0.01090478f, -0.01912989f, 0.02779146f, 0.01398345f, 
    -0.04751064f, -0.03526151f, 0.01764358f, -0.00914573f, 0.02616711f, 0.02957209f, -0.04299269f, 0.01562566f, 
    0.01462471f, 0.00014831f, -0.02088829f, -0.05590607f, 0.01308668f, -0.02920006f, -0.02822379f, 0.02894428f, 
    -0.06344967f, -0.00941314f, 0.01500051f, -0.00975889f, 0.04232207f, 0.01068067f, -0.02428780f, -0.00775659f, 
    -0.01340849f, -0.00021219f, -0.05844573f, 0.03018068f, -0.04003371f, -0.02545535f, 0.04548185f, -0.03045394f, 
    -0.06246615f, 0.04159961f, 0.01930070f, 0.00011956f, 0.05054315f, 0.02312968f, 0.02513885f, -0.02711968f, 
    -0.06387983f, 0.01555202f, -0.00789007f, 0.00022834f, -0.01124111f, 0.03564238f, -0.00041508f, 0.00092064f, 
    -0.01185366f, -0.03273426f, -0.03102827f, 0.02764258f, 0.01791695f, -0.03320074f, -0.05548896f, -0.04323635f, 
    -0.02059071f, -0.04084738f, 0.03127889f, 0.03369447f, -0.00856902f, -0.03520666f, -0.05570271f, -0.02902417f, 
    0.19688402f, -0.05856740f, -0.28650779f, -0.06677350f, -0.17188002f, 0.14083068f, 0.01736958f, -0.06596557f, 
    0.09697262f, 0.27446094f, 0.09750607f, -0.16217409f, -0.22696744f, 0.03654532f, 0.25004616f, -0.03825739f, 
    -0.07128321f, -0.11652134f, -0.08644169f, -0.14290950f, 0.13530500f, -0.07963875f, 0.09198331f, -0.03952746f, 
    -0.12884116f, 0.01097934f, 0.19016097f, -0.36039114f, -0.67813045f, -0.30455789f, -0.16504283f, -0.01701141f, 
    0.11687126f, 0.06615826f, -0.13968274f, -0.16237600f, -0.06096058f, -0.77078211f, 0.00899652f, -0.06451358f, 
    -0.08241760f, -0.06451743f, -0.16356891f, -0.06938090f, -0.09676912f, 0.10304310f, -0.02038809f, -0.03757817f, 
    0.02968455f, -0.09503329f, 0.13285060f, -0.12542532f, 0.10650256f, -0.02571312f, 0.06496754f, 0.14116190f, 
    -0.44558281f, -0.01021204f, 0.09798466f, -0.06327555f, 0.00762879f, -0.06324901f, -0.04471532f, 0.18523172f, 
    -0.05980767f, 0.11007520f, -0.06926373f, 0.15966387f, -0.07531156f, 0.01146611f, 0.18778141f, -0.12530637f, 
    0.08350147f, 0.17586766f, -0.07158853f, 0.04672001f, 0.01904800f, -0.03135252f, -0.07188770f, 0.10000034f, 
    -0.00575456f, 0.17237650f, 0.05163809f, -0.06286369f, -0.23910171f, 0.01376594f, 0.05602453f, 0.14019825f, 
    0.02762576f, 0.05847684f, 0.27432227f, 0.14433336f, -0.22285619f, 0.07426900f, -0.02938239f, -0.10015480f, 
    -0.02686785f, -0.06414642f, 0.19473392f, 0.36013082f, -0.48249614f, 0.05296760f, -0.00426695f, 0.03348339f, 
    0.03632550f, 0.10771709f, 0.12704852f, 0.00293486f, 0.28547516f, 0.23720253f, -0.14728823f, 0.02152903f, 
    -0.14419670f, 0.09221409f, 0.02101198f, -0.10662507f, 0.17261159f, 0.44909060f, -0.12375820f, -0.12043991f, 
    0.14086179f, 0.10756857f, -0.15605420f, 0.00561663f, -0.19332881f, 0.10534035f, 0.02036973f, 0.04569259f, 
    -0.47319868f, 0.04545380f, -0.04873352f, 0.07596386f, 0.17377773f, 0.02682036f, -0.06228656f, 0.23523574f, 
    0.19354738f, -0.12285633f, -0.11577410f, 0.01849798f, 0.06150035f, 0.05239953f, 0.02823308f, -0.04948281f, 
    0.21226132f, 0.06915642f, -0.05628997f, 0.05600790f, 0.02272422f, 0.01740582f, -0.19120644f, -0.01387376f, 
    0.00214995f, 0.05242619f, -0.07931993f, 0.07073012f, -0.17192283f, 0.07631584f, -0.13749036f, -0.10910807f, 
    -0.07782108f, -0.08244483f, 0.14633723f, -0.43726277f, 0.02822754f, 0.17575622f, 0.25669041f, 0.08909310f, 
    -0.05473485f, 0.04776113f, -0.05243773f, 0.40271378f, -0.08284033f, -0.14343722f, 0.07393904f, 0.21509793f, 
    0.03696679f, 0.09678839f, 0.00536463f, -0.12135175f, 0.08033015f, -0.37596649f, 0.23769225f, -0.04994075f, 
    0.09355493f, 0.04007775f, -0.02485902f, -0.00683413f, 0.14568588f, -0.35018161f, -0.12690960f, 0.17204824f, 
    0.19637427f, 0.11363619f, 0.09071539f, -0.14171851f, 0.05096425f, -0.00837361f, -0.14701892f, 0.17071925f, 
    -0.04960784f, -0.04673024f, -0.07838137f, 0.12333418f, -0.10566304f, 0.05239066f, 0.03036966f, -0.10016263f, 
    -0.30567899f, -0.18699412f, -0.04228391f, -0.08812661f, 0.18303439f, -0.06492769f, -0.08159155f, 0.10138191f, 
    -0.04673764f, 0.26416096f, -0.05149273f, 0.02309170f, -0.07231676f, -0.01350712f, -0.00155460f, -0.00189942f, 
    -0.09084062f, -0.23816146f, -0.03833621f, -0.10089172f, 0.03207298f, 0.02465657f, 0.15813254f, 0.03175388f, 
    -0.03876073f, 0.01382134f, -0.03992090f, 0.20726365f, -0.08070030f, -0.15353514f, -0.08025338f, -0.03460727f, 
    0.06454721f, 0.08593319f, 0.00317096f, 0.00342748f, -0.02764409f, 0.04123966f, -0.00485826f, -0.05278577f, 
    0.07700638f, 0.03552659f, -0.07097659f, 0.11548996f, -0.10083120f, -0.08721699f, -0.48348698f, 0.14456667f, 
    0.17162836f, 0.11711516f, -0.02718724f, 0.06828832f, 0.12489619f, -0.34533319f, 0.09753251f, 0.12408023f, 
    0.04687418f, 0.05684412f, 0.09047043f, -0.06594716f, 0.03162107f, -0.05450584f, 0.09631237f, -0.18419021f, 
    0.08427158f, -0.07884307f, 0.14002585f, 0.08861899f, -0.02524471f, 0.08503316f, -0.11037041f, 0.09527373f, 
    -0.04824817f, -0.07644755f, -0.23939122f, 0.02632420f, 0.01290752f, 0.05031655f, 0.05254102f, 0.01352189f, 
    0.02976878f, -0.22355299f, -0.01803758f, -0.02674697f, 0.24138635f, -0.21945634f, 0.05028237f, 0.14131887f, 
    0.14526765f, -0.39181232f, -0.06421003f, -0.05275548f, -0.15067706f, -0.08599835f, -0.01109658f, 0.00149230f, 
    -0.05142561f, -0.09655273f, 0.23049580f, 0.06294171f, -0.15479486f, -0.07998280f, -0.05209048f, -0.12578630f, 
    0.09537521f, 0.08366496f, -0.08588384f, 0.27813303f, 0.01539708f, 0.02188456f, -0.00773494f, 0.09323962f, 
    0.02810895f, -0.01839719f, 0.23068041f, -0.03632127f, 0.27115947f, 0.09644463f, 0.07806761f, -0.21026741f, 
    0.08401106f, 0.03422567f, -0.06318031f, -0.00121291f, 0.01649748f, -0.06774373f, 0.05579873f, 0.12694542f, 
    -0.10782089f, -0.03774406f, -0.07042619f, 0.05120196f, -0.03357762f, 0.08748884f, 0.08458090f, -0.33153662f, 
    0.03689697f, 0.02693324f, 0.00627135f, -0.06127352f, -0.12692505f, 0.04888240f, 0.00460224f, 0.27256006f, 
    0.15450196f, 0.22940788f, -0.04651263f, -0.06361443f, -0.07314626f, -0.05969497f, -0.02211102f, -0.08797329f, 
    0.43385097f, -0.11601470f, -0.10388044f, -0.07985160f, -0.09795919f, -0.13716049f, 0.06983371f, 0.20406567f, 
    0.21214595f, 0.10848536f, -0.09813177f, 0.10415558f, 0.07270632f, 0.05570563f, -0.01162457f, 0.04884057f, 
    0.03368503f, -0.01394767f, 0.11792470f, -0.13585211f, 0.14206117f, 0.11120627f, -0.02411353f, 0.04559096f, 
    -0.07799763f, -0.00898631f, 0.14235958f, 0.01970518f, 0.18390177f, 0.26804328f, 0.08875098f, 0.16956981f, 
    -0.03834386f, 0.03973806f, 0.08410986f, 0.04720988f, 0.23423013f, 0.10729668f, 0.22341792f, 0.10961364f, 
    0.12149137f, -0.01435515f, 0.11712163f, 0.00443010f, 0.17627087f, 0.02734823f, -0.10092893f, 0.21131167f, 
    0.03839135f, -0.05796975f, 0.00763976f, 0.05461022f, 0.17067806f, 0.00200344f, 0.21454358f, 0.00595793f, 
    0.19334719f, 0.22167407f, 0.06452831f, -0.02702679f, -0.06731573f, -0.08544994f, 0.07602047f, -0.00781853f, 
    0.06664978f, 0.11921731f, 0.12884516f, -0.00246187f, -0.14432801f, -0.10008864f, -0.07770982f, 0.01354879f, 
    0.03170464f, -0.39474374f, 0.01101903f, -0.05563825f, -0.00917174f, -0.06781072f, 0.05429435f, -0.13248630f, 
    -0.06506749f, 0.11681961f, 0.12737621f, 0.06026038f, 0.04504902f, 0.02129270f, -0.07064044f, -0.02231990f, 
    0.07638401f, -0.00178307f, 0.21629262f, 0.02881342f, 0.31594294f, 0.04762794f, -0.03567677f, 0.00795514f, 
    -0.00178985f, -0.02111277f, -0.14459263f, -0.22830856f, -0.11422594f, 0.05470181f, 0.02149626f, -0.07972287f, 
    -0.14105122f, -0.05220667f, -0.05917010f, -0.04696899f, -0.12031437f, -0.17804414f, -0.07651848f, -0.04864889f, 
    -0.16297470f, -0.15615405f, 0.06627976f, 0.02431357f, -0.02580250f, 0.06892856f, 0.10712485f, 0.02186989f, 
    -0.05641202f, 0.00691324f, -0.14864634f, -0.19975197f, -0.01987822f, -0.01510775f, -0.24596639f, -0.02889826f, 
    -0.17733596f, -0.16943279f, -0.08063918f, -0.11670528f, 0.00929629f, -0.05799455f, 0.06081103f, 0.07664316f, 
    -0.17263263f, -0.02699651f, -0.01314946f, -0.04644162f, -0.04024854f, 0.02069041f, -0.02738234f, -0.01758344f, 
    0.11160260f, 0.19387071f, -0.25541767f, -0.16926800f, 0.03017675f, 0.02835808f, 0.02843309f, 0.06770230f, 
    -0.03230088f, 0.06167348f, 0.26537609f, 0.37642807f, 0.13672641f, -0.00554949f, 0.04376254f, -0.07516441f, 
    0.00436492f, -0.12029117f, -0.07717346f, -0.11088874f, -0.21160614f, -0.26735017f, -0.10025037f, -0.05890390f, 
    -0.17613049f, -0.04482007f, 0.02858283f, -0.34535092f, 0.19242929f, -0.09524227f, -0.16658837f, -0.11043362f, 
    -0.14221691f, -0.01527775f, -0.07295950f, -0.09772290f, -0.37682584f, -0.12923564f, -0.05831655f, -0.01584958f, 
    -0.05188204f, 0.06805748f, 0.00018102f, 0.01562327f, 0.00280242f, 0.19677804f, 0.23366944f, 0.01835626f, 
    0.01932019f, 0.02723003f, -0.10472537f, -0.16817936f, -0.06148758f, -0.09897722f, 0.02105396f, -0.03183242f, 
    0.31656897f, 0.06028760f, -0.00621022f, -0.00352004f, -0.17964686f, -0.09568872f, -0.02286674f, 0.05983131f, 
    0.28995875f, 0.13676271f, 0.09349444f, 0.12334767f, -0.01651671f, -0.17285891f, 0.02892208f, 0.12955727f, 
    0.03581923f, 0.04163350f, 0.02110384f, -0.06425826f, -0.01124294f, 0.02021119f, -0.00870006f, 0.04534478f, 
    -0.05057280f, -0.01223039f, -0.00553095f, -0.00845759f, -0.01060625f, -0.01531340f, 0.04925076f, 0.04253976f, 
    0.00465627f, -0.02931105f, 0.01942964f, -0.05348384f, -0.06263570f, 0.01965864f, 0.02420379f, 0.01089833f, 
    -0.04220355f, 0.02452066f, -0.04679111f, -0.00296845f, 0.04435657f, 0.02703302f, -0.00494931f, -0.02864620f, 
    0.04822247f, 0.01621535f, -0.03731704f, -0.04723488f, 0.03972490f, -0.01337629f, 0.00444297f, -0.05428256f, 
    -0.03945396f, -0.03042961f, 0.02849500f, -0.00751369f, -0.00300002f, -0.01968227f, -0.01866822f, 0.00304808f, 
    -0.00014011f, -0.01211697f, 0.02242249f, 0.00054337f, -0.01620517f, 0.00876806f, -0.00634972f, -0.01956670f, 
    0.01001680f, 0.03385424f, 0.04281672f, 0.01675818f, 0.01114386f, -0.00751279f, 0.04471335f, 0.01008308f, 
    -0.03015200f, 0.04503780f, -0.03792931f, -0.05697841f, -0.02329710f, -0.01037106f, 0.01105798f, -0.06195913f, 
    -0.05815334f, -0.07082053f, 0.03807058f, 0.03556545f, -0.00352365f, -0.05103450f, -0.02512089f, 0.05062781f, 
    0.03676444f, 0.03985536f, 0.03248179f, -0.03355098f, 0.00971951f, 0.02531701f, -0.02025035f, 0.00132558f, 
    -0.02061444f, -0.02170645f, 0.01619666f, 0.01625466f, 0.02421189f, 0.00724727f, 0.03636182f, 0.04627634f, 
    0.04936143f, -0.01988331f, 0.00927104f, 0.04321218f, -0.02239904f, -0.05041769f, -0.02971046f, -0.03573164f, 
    -0.03512869f, -0.00207211f, -0.03929666f, -0.02049290f, -0.05001467f, 0.03192922f, 0.00603505f, 0.01133495f, 
    0.03554827f, -0.03198433f, -0.01491847f, -0.01208856f, 0.02743427f, 0.03921274f, 0.03226407f, -0.02121367f, 
    -0.02293085f, -0.01156623f, 0.03175589f, 0.04195555f, -0.04182775f, -0.05254869f, -0.02886862f, -0.02207080f, 
    -0.04735130f, 0.00696668f, -0.02890604f, 0.02351907f, -0.02475875f, -0.03303775f, 0.04285927f, 0.02733104f, 
    -0.06591069f, 0.01056169f, -0.04757098f, -0.03065966f, -0.05489399f, -0.04273599f, -0.02732933f, -0.01608199f, 
    0.00133266f, -0.03875532f, -0.01507859f, -0.00676678f, 0.01641409f, 0.03754513f, 0.03346530f, 0.01538710f, 
    -0.06747146f, -0.03071109f, -0.05241180f, -0.05847276f, -0.06513417f, -0.02324804f, -0.03622263f, 0.03066511f, 
    0.01551549f, -0.00070449f, 0.01358671f, -0.00592654f, -0.01147696f, 0.00961814f, 0.00287268f, 0.03187041f, 
    -0.01630687f, 0.02314630f, 0.05048716f, -0.01408711f, -0.03418503f, -0.05303299f, -0.01226917f, -0.02905347f, 
    0.04538651f, -0.05290338f, -0.00865244f, -0.04155113f, -0.02398070f, -0.06439558f, 0.00794782f, -0.02207222f, 
    0.00989009f, 0.04649958f, 0.02977537f, 0.05132136f, -0.00662986f, -0.00814817f, -0.01815810f, -0.00568025f, 
    0.03064638f, -0.04726033f, 0.04160753f, 0.00711635f, 0.04623171f, -0.00744404f, 0.04304550f, -0.02844701f, 
    0.00637616f, -0.05840885f, -0.04840852f, -0.01651996f, -0.04687668f, 0.05147981f, -0.03607339f, -0.03310740f, 
    -0.04685087f, 0.01739719f, -0.02560840f, -0.00713272f, 0.00034387f, -0.05738239f, -0.00454467f, 0.00742450f, 
    -0.05019720f, -0.01706273f, -0.06544938f, -0.03587720f, 0.05271375f, 0.03699741f, 0.00763890f, -0.04615838f, 
    0.02666995f, -0.01015295f, -0.01887993f, 0.04664086f, 0.00985804f, 0.05729581f, -0.02005418f, -0.05163201f, 
    0.04487391f, -0.00155805f, 0.03652505f, -0.00125411f, -0.00343104f, -0.03357907f, 0.03779734f, -0.04948707f, 
    -0.05119596f, -0.02806831f, 0.04292301f, -0.05886503f, -0.04421726f, -0.01125578f, -0.02209305f, 0.01526738f, 
    0.01051896f, -0.00136008f, -0.04962920f, -0.05281428f, -0.01943692f, -0.05250099f, 0.01996977f, 0.00892400f, 
    -0.03754275f, 0.03273715f, -0.05465235f, -0.00381921f, 0.01194958f, 0.01546685f, 0.02294317f, -0.05560834f, 
    0.04023094f, -0.02127875f, -0.03942289f, -0.05915795f, -0.05523791f, 0.00634699f, -0.03007222f, -0.06310169f, 
    -0.00414322f, 0.02412103f, 0.03186376f, 0.03180647f, -0.02759889f, -0.03791798f, -0.04034869f, -0.02928821f, 
    0.01620656f, -0.04698511f, -0.04035179f, 0.01278299f, -0.04535700f, -0.03688831f, 0.04540905f, 0.02513635f, 
    -0.03068643f, -0.00810991f, -0.02026739f, 0.04154889f, -0.05687955f, 0.01739257f, 0.00174043f, -0.02156015f, 
    0.02381780f, 0.00244363f, 0.03053099f, -0.05437761f, -0.05396596f, 0.03246320f, 0.03194938f, 0.04907531f, 
    0.00349751f, 0.01489950f, 0.03176079f, -0.06080060f, 0.04244353f, -0.00523437f, -0.00561057f, -0.04213079f, 
    -0.02909391f, 0.05172823f, 0.01024177f, -0.05620815f, -0.01604231f, 0.00944997f, -0.04758217f, 0.00367750f, 
    0.04624077f, -0.04976327f, 0.02158665f, -0.01120454f, -0.01735105f, -0.06089658f, -0.05729192f, -0.05479317f, 
    -0.03688645f, -0.00348639f, -0.06424150f, 0.03029846f, -0.04770235f, -0.02363163f, -0.01636272f, 0.02481791f, 
    0.02600495f, 0.02133499f, 0.03783388f, -0.02554720f, -0.01691195f, -0.06107198f, 0.02699114f, -0.04285176f, 
    0.04728815f, 0.01846964f, 0.04639376f, 0.03484963f, -0.01472423f, -0.03158622f, 0.02088194f, 0.02638908f, 
    -0.06067992f, -0.03511564f, 0.05023646f, -0.04746706f, -0.04701398f, -0.00221619f, 0.02462107f, -0.05546405f, 
    -0.04835144f, 0.03669297f, -0.03722973f, 0.01963805f, -0.05728757f, 0.01281745f, 0.05321100f, -0.05427828f, 
    -0.03845000f, 0.04351295f, -0.03764404f, -0.02991340f, 0.00467482f, 0.03344383f, -0.00443160f, 0.04937155f, 
    -0.00776097f, 0.04334893f, -0.04811285f, -0.01408566f, 0.05113552f, -0.05915921f, -0.00748979f, -0.00202287f, 
    0.04206480f, -0.03784147f, -0.04277424f, -0.05726729f, 0.00121019f, -0.00735686f, -0.05656976f, 0.01458542f, 
    0.00843001f, -0.01562611f, -0.03310977f, -0.05906003f, -0.03791472f, -0.01205072f, -0.05532116f, 0.03243954f, 
    0.01873329f, 0.01701877f, 0.04661013f, -0.04301643f, -0.04976524f, 0.00737197f, 0.03381545f, 0.00819880f, 
    0.03914241f, -0.00669527f, -0.05541086f, 0.00383741f, 0.00855090f, -0.03510235f, 0.03295384f, 0.00780111f, 
    0.00037641f, -0.03931391f, -0.00401535f, -0.05407804f, -0.00325513f, -0.00550611f, -0.03883464f, -0.05933590f, 
    0.03515876f, 0.04726540f, 0.05173887f, 0.00019523f, 0.03257756f, -0.04755748f, 0.04425385f, 0.01662435f, 
    -0.02170358f, -0.03505210f, 0.04619322f, 0.03220539f, 0.03177504f, -0.05651363f, -0.00831475f, 0.00378140f, 
    0.01698146f, -0.03371327f, -0.06371275f, -0.03640338f, -0.01188233f, -0.03805634f, -0.02912161f, -0.00616356f, 
    -0.01826245f, -0.02601683f, -0.04811259f, 0.01961527f, -0.01328436f, 0.01340151f, -0.04789181f, 0.03526079f, 
    0.01605900f, 0.02151832f, 0.04657419f, 0.02608146f, -0.02870788f, 0.00946984f, -0.03205142f, -0.01901601f, 
    0.02841954f, -0.03391730f, 0.03639075f, 0.02820767f, -0.05185912f, 0.03736563f, -0.01905299f, 0.05607056f, 
    0.01074415f, 0.04022060f, 0.01072265f, 0.03506505f, -0.00999337f, -0.02217065f, -0.00618590f, 0.03521879f, 
    0.01962962f, -0.05864570f, -0.00792357f, 0.00572939f, -0.02790910f, 0.03897846f, 0.02608694f, -0.04363593f, 
    0.00035939f, -0.02301406f, -0.05979922f, 0.03740067f, -0.01688038f, 0.05091581f, -0.03805697f, -0.02387366f, 
    0.02317524f, 0.03764813f, -0.05188362f, -0.06287937f, 0.02879348f, 0.04358581f, 0.01317918f, -0.00775024f, 
    0.00534128f, -0.03867408f, 0.02738796f, 0.04789001f, -0.00254243f, -0.02795139f, 0.02521103f, -0.01937649f, 
    -0.03744351f, -0.05210797f, -0.04309757f, -0.03994007f, 0.00714462f, -0.01399376f, -0.02095770f, -0.03117711f, 
    0.01479493f, -0.01961973f, -0.02590302f, -0.05003183f, 0.02630002f, -0.04547616f, -0.03472642f, 0.02756299f, 
    0.00943122f, -0.01347614f, 0.03724679f, -0.01951029f, 0.02762987f, 0.00994791f, -0.01964051f, 0.01170793f, 
    -0.06091122f, -0.01468730f, -0.01764604f, -0.00245662f, 0.05306925f, 0.04720392f, -0.03467926f, 0.01230512f, 
    0.00886515f, 0.03804772f, 0.01150351f, -0.03269593f, 0.00493771f, 0.00436741f, -0.02067934f, -0.06089938f, 
    -0.03944271f, 0.01919509f, -0.01868357f, -0.03014688f, -0.01859326f, -0.04291043f, 0.02580042f, -0.05947064f, 
    0.02012243f, 0.04605017f, -0.04363069f, 0.04810929f, -0.03857830f, -0.02851998f, 0.05243522f, -0.01231240f, 
    -0.03875019f, -0.04709478f, 0.05281878f, 0.01742745f, 0.00405838f, -0.05542066f, -0.04637014f, -0.02820362f, 
    0.01705595f, -0.19991344f, -0.33785939f, -0.08656278f, -0.01263826f, 0.17673030f, 0.08501691f, 0.13073099f, 
    -0.03184608f, -0.16672164f, -0.02553320f, 0.01093264f, 0.03431934f, -0.01852259f, -0.06176502f, 0.04386146f, 
    0.03312450f, -0.12314183f, 0.29863527f, -0.07989033f, 0.14836465f, -0.19490823f, -0.04294670f, -0.04217477f, 
    -0.04504723f, -0.01188590f, 0.13761368f, 0.08650421f, -0.17257170f, -0.05992357f, -0.16310655f, 0.04220333f, 
    0.08854656f, -0.08264084f, 0.05308008f, 0.22854701f, 0.02150903f, 0.02963858f, -0.05834197f, -0.18207155f, 
    -0.11200185f, -0.12656018f, 0.06617481f, 0.08617313f, -0.01229344f, -0.38881254f, 0.28046900f, 0.30516979f, 
    -0.02097218f, -0.03107318f, -0.15764038f, -0.04294885f, -0.14078291f, 0.09095844f, -0.24419254f, 0.22101927f, 
    0.09712013f, -0.02818100f, -0.12062304f, -0.04586904f, 0.04941359f, 0.01259730f, 0.09617093f, 0.17087670f, 
    0.03157588f, -0.01445159f, 0.00761594f, 0.06388137f, -0.06575576f, 0.00305173f, -0.02723126f, -0.09661125f, 
    0.18357818f, -0.06252418f, -0.05562427f, -0.08077151f, 0.00620166f, 0.01472154f, 0.01460631f, 0.10535283f, 
    -0.01349353f, -0.23090276f, 0.09317802f, -0.27135441f, 0.06228023f, -0.00214366f, 0.03652757f, -0.00817741f, 
    0.08559522f, 0.16616513f, -0.15193133f, 0.06847636f, -0.06085544f, -0.08227742f, 0.12483008f, -0.06011221f, 
    0.10543988f, 0.06113096f, 0.08133627f, -0.44496650f, 0.21276648f, 0.00063267f, 0.03041750f, 0.01822059f, 
    -0.11407994f, 0.04092852f, 0.14813942f, -0.02990643f, 0.16006984f, 0.04710771f, -0.16397667f, 0.04205920f, 
    0.12807570f, -0.04515517f, 0.10657164f, -0.09388710f, 0.10518984f, 0.24272217f, 0.08689780f, -0.19251511f, 
    -0.01570896f, 0.14720255f, 0.16738178f, 0.02042606f, -0.04917740f, -0.07349958f, -0.21005578f, 0.35173783f, 
    -0.16294843f, 0.02395092f, -0.09506186f, 0.11121996f, -0.00023145f, -0.17424928f, 0.19562273f, -0.01989840f, 
    0.09726398f, 0.01467808f, -0.05939067f, -0.02726006f, 0.02138845f, -0.01314443f, 0.08538949f, 0.21458778f, 
    -0.06680701f, -0.09382177f, -0.11175369f, -0.00443787f, -0.14464614f, -0.11364270f, 0.04631254f, 0.00198731f, 
    0.09393419f, 0.02013692f, 0.14732538f, 0.37923318f, -0.02361220f, -0.02589845f, -0.03901586f, 0.04394047f, 
    -0.13096581f, -0.10783911f, 0.06859778f, 0.21637274f, 0.08147030f, -0.11048269f, 0.01864452f, -0.17215320f, 
    -0.13443758f, -0.11901789f, 0.12039898f, -0.30660456f, 0.23202661f, 0.07164057f, -0.04440270f, 0.13856550f, 
    -0.13983253f, 0.02722852f, -0.12160611f, -0.11575232f, -0.19407719f, -0.11079256f, -0.32736915f, -0.07781821f, 
    -0.12281562f, -0.05599994f, 0.06527743f, -0.00024310f, -0.04799998f, 0.14727087f, 0.06666774f, -0.09090699f, 
    -0.14690326f, 0.09867969f, -0.07329338f, 0.11600410f, 0.11674281f, 0.07763882f, -0.08385993f, -0.19326949f, 
    -0.04566379f, -0.03533047f, 0.08433113f, -0.15548664f, 0.11049285f, -0.08666163f, -0.00092390f, -0.08050179f, 
    0.00128374f, 0.08604588f, 0.18139830f, 0.00696414f, -0.09134600f, 0.12781194f, -0.06675822f, 0.23326574f, 
    0.16591384f, 0.11136211f, -0.09451147f, 0.01591128f, -0.01967457f, 0.00241485f, 0.10978805f, 0.04365889f, 
    0.00757178f, 0.04181086f, -0.00706871f, 0.17493139f, -0.00484617f, -0.08175909f, 0.15420896f, -0.03902052f, 
    -0.04195620f, 0.17308353f, 0.00590751f, 0.11128733f, -0.03670873f, 0.10040870f, 0.16601630f, -0.01859259f, 
    -0.14939207f, 0.05338667f, -0.16842055f, 0.08113592f, -0.23206156f, -0.22872351f, -0.21807647f, 0.08236493f, 
    -0.01928195f, -0.09605555f, 0.04637575f, -0.17297634f, 0.31790873f, 0.16024064f, 0.05842888f, 0.07689279f, 
    -0.08387437f, -0.02268443f, 0.08301441f, 0.02707911f, -0.07552400f, 0.22196101f, -0.26064497f, -0.12361746f, 
    0.02716405f, 0.24283206f, 0.19226782f, -0.05252336f, -0.19539893f, -0.12363306f, -0.17723989f, 0.22939357f, 
    -0.00465524f, 0.03568836f, 0.08340918f, -0.07870195f, 0.02332863f, -0.11538199f, -0.05671512f, 0.16573198f, 
    0.18805109f, -0.03575856f, 0.00924369f, 0.13923664f, 0.01820832f, -0.03028012f, -0.04204357f, 0.14175129f, 
    -0.00552224f, -0.04533998f, -0.02625200f, -0.00740656f, -0.05139149f, -0.03574316f, -0.03847801f, -0.03214741f, 
    0.00287004f, 0.03298171f, 0.01618129f, 0.00589916f, 0.03240535f, -0.04977468f, 0.03138210f, 0.05204857f, 
    0.04324910f, 0.02309978f, -0.01889436f, -0.05758496f, 0.00755806f, -0.03027285f, -0.01002749f, -0.04120002f, 
    0.01446628f, 0.00173087f, -0.04414055f, 0.02974703f, -0.00466687f, -0.05018259f, 0.00445480f, 0.03251079f, 
    0.00602405f, -0.01167848f, -0.01627882f, -0.00470973f, -0.00631993f, -0.03824186f, 0.03309319f, -0.01761646f, 
    0.00628052f, -0.02442971f, 0.03352462f, -0.04683178f, -0.02573135f, 0.01137236f, 0.02223432f, 0.00370795f, 
    -0.02751604f, -0.02521740f, -0.05676209f, -0.05352526f, 0.05740661f, -0.01905928f, 0.01591902f, 0.01439142f, 
    -0.04652135f, -0.00756362f, -0.03702614f, 0.03682403f, -0.01761470f, 0.00368993f, -0.06283428f, -0.00682503f, 
    -0.02863724f, -0.02775797f, -0.01809579f, 0.00602996f, -0.04788702f, -0.00349972f, -0.02170606f, 0.02259713f, 
    -0.03482476f, -0.01183600f, -0.01381908f, 0.00112664f, -0.05551976f, 0.04113741f, 0.05250237f, 0.05831341f, 
    0.01144766f, -0.05716154f, 0.02773745f, 0.01977777f, 0.03349325f, -0.03733042f, -0.05106614f, -0.05260922f, 
    -0.02540871f, -0.05634619f, -0.03610590f, 0.02475451f, -0.04449171f, 0.02800910f, -0.00587859f, -0.00228020f, 
    0.03394072f, -0.00168522f, -0.03627118f, -0.03727111f, -0.04345407f, -0.03595862f, 0.04762850f, 0.04994280f, 
    0.00156163f, 0.00092560f, 0.01886287f, 0.01022073f, 0.01768030f, 0.03444519f, -0.01460799f, 0.05107445f, 
    -0.03807823f, -0.05270147f, -0.04740052f, 0.00622410f, -0.01209482f, 0.03542815f, -0.04228552f, 0.01963516f, 
    -0.04844872f, 0.02656086f, -0.02345443f, -0.04019845f, -0.01928758f, 0.03291903f, 0.04897111f, 0.01335562f, 
    -0.02749901f, 0.02669029f, 0.04256638f, -0.01773195f, -0.02783478f, -0.01102483f, -0.00705479f, -0.00086145f, 
    0.03033184f, -0.02678418f, 0.02941168f, 0.02555115f, 0.04948934f, 0.00903063f, -0.02351429f, -0.02115533f, 
    0.01314432f, -0.00655398f, -0.06299844f, 0.00316445f, 0.02521390f, -0.05344632f, -0.01076027f, 0.05174389f, 
    -0.02972754f, -0.05117946f, -0.04513660f, 0.03159008f, -0.04262001f, -0.01281623f, -0.04303514f, -0.04611299f, 
    -0.03992273f, -0.04075303f, -0.03944664f, 0.03929234f, -0.00243736f, -0.01645931f, -0.02568684f, 0.00080984f, 
    0.04043655f, -0.00014503f, 0.03674103f, -0.03898690f, -0.04736451f, 0.01720998f, 0.02143269f, -0.01434449f, 
    -0.00409556f, -0.05452383f, -0.02037627f, 0.04195020f, -0.04506390f, -0.04597358f, -0.01887787f, 0.01796572f, 
    0.03159900f, -0.03439493f, -0.00389904f, 0.01332259f, -0.02557370f, -0.00622179f, -0.00478168f, 0.02220439f, 
    -0.03873840f, 0.00214159f, -0.03269236f, 0.01824447f, 0.01276506f, 0.03135461f, -0.01833666f, -0.03159461f, 
    0.00619670f, 0.00362055f, 0.01698971f, -0.03177971f, 0.02151990f, -0.01494488f, -0.03280374f, 0.00486274f, 
    -0.02962655f, -0.02076989f, 0.03901004f, 0.06038253f, 0.00606883f, -0.00917186f, -0.01946912f, -0.06073317f, 
    -0.06322753f, 0.00774659f, -0.03881758f, 0.04928067f, -0.03849283f, 0.03219827f, -0.02408749f, -0.04083041f, 
    -0.04319533f, -0.01142840f, -0.05864247f, -0.03446555f, 0.03234930f, -0.03335414f, 0.02243447f, 0.03207323f, 
    -0.03094712f, -0.05060866f, 0.01033861f, -0.00625579f, -0.05929352f, 0.02728393f, 0.01320833f, -0.01994737f, 
    0.03705322f, -0.03275432f, -0.05154474f, -0.06322112f, -0.05453302f, -0.00384166f, 0.03705005f, 0.00927396f, 
    -0.02142900f, 0.02554300f, -0.06185471f, -0.01342434f, 0.01219620f, 0.02332065f, 0.04053463f, -0.01076677f, 
    -0.00609487f, -0.00982396f, -0.02596153f, -0.02900714f, -0.06196484f, 0.04430130f, 0.02087441f, 0.02279406f, 
    -0.02090861f, 0.05615052f, 0.04832569f, -0.01791966f, 0.02393435f, -0.02751285f, -0.01621189f, 0.00348594f, 
    0.00602384f, 0.01225657f, -0.01113726f, -0.04141007f, -0.05077042f, 0.02940655f, -0.02034441f, 0.02918015f, 
    -0.01322019f, -0.04655966f, -0.04464093f, 0.00628850f, -0.03383306f, -0.04475165f, -0.02875180f, -0.04547586f, 
    -0.04175837f, -0.34109458f, -0.19132915f, -0.05524544f, 0.10110570f, -0.13447373f, 0.19280836f, -0.07329194f, 
    -0.18347344f, -0.29373586f, 0.03293658f, 0.18001184f, 0.18886562f, 0.22355360f, -0.06531452f, -0.01371384f, 
    -0.20430604f, 0.07299440f, -0.53533161f, 0.01110415f, 0.08933248f, 0.09173363f, 0.01217160f, -0.01262282f, 
    0.03586584f, 0.07157071f, 0.18255481f, 0.07395307f, -0.01323698f, -0.10750576f, -0.21655248f, -0.06056620f, 
    -0.13927726f, 0.03531500f, 0.06612787f, -0.07047253f, 0.08161573f, 0.07404742f, -0.13505073f, 0.05803090f, 
    -0.11718593f, -0.05639439f, -0.05597826f, -0.18244293f, 0.08971833f, -0.53720844f, -0.12736887f, 0.03559184f, 
    0.25437334f, 0.22978364f, 0.01171042f, 0.06157567f, -0.10747371f, 0.05102306f, 0.50710690f, 0.11152538f, 
    0.16103035f, 0.13982455f, 0.00666429f, 0.02211376f, 0.04254094f, -0.01189991f, -0.21769659f, -0.09196758f, 
    0.09005850f, 0.11150044f, 0.16730188f, -0.09312950f, 0.07658376f, 0.00690126f, 0.00051970f, 0.16001610f, 
    -0.57985955f, -0.09426157f, 0.00166563f, 0.24828005f, 0.01529410f, 0.12897560f, -0.20229961f, -0.13443726f, 
    -0.10320950f, 0.22288610f, 0.14344652f, -0.01990553f, -0.06788599f, 0.23914945f, -0.01424082f, 0.05241522f, 
    0.07554010f, 0.14798392f, 0.05071318f, 0.00995925f, -0.13998540f, -0.12149283f, -0.01702400f, -0.02599484f, 
    -0.01263791f, 0.01176189f, -0.01960531f, 0.25212038f, -0.03846057f, -0.17721483f, -0.08447002f, -0.27084190f, 
    0.05164942f, -0.19321232f, 0.06408170f, -0.16701375f, 0.21586919f, 0.01791855f, -0.08085351f, -0.12039080f, 
    -0.09956932f, -0.15193255f, -0.09583347f, 0.03845042f, -0.10653886f, -0.21596432f, -0.30365261f, 0.25200102f, 
    0.11322045f, -0.12421562f, 0.12112942f, 0.20062612f, 0.01588324f, 0.05017993f, -0.04258950f, -0.13654709f, 
    -0.26326296f, -0.28089106f, 0.07774752f, 0.01831348f, -0.04360429f, 0.12119676f, -0.04760561f, 0.15489490f, 
    -0.07558291f, -0.18390587f, -0.05120141f, -0.04649239f, 0.04034767f, 0.02216913f, 0.09616132f, -0.10652009f, 
    0.06335336f, 0.23167320f, -0.04806961f, 0.04700342f, -0.06453212f, -0.00802448f, 0.05661093f, 0.04837844f, 
    0.01982202f, -0.27269199f, -0.06741943f, -0.06799062f, 0.03410180f, -0.10758576f, 0.06474129f, -0.08835779f, 
    -0.06602772f, 0.02995573f, 0.14127013f, 0.07204811f, -0.18615213f, 0.15265040f, -0.13094957f, 0.03881445f, 
    -0.02728403f, 0.08015347f, 0.06397638f, 0.14563273f, 0.28025889f, -0.00161430f, 0.06906645f, -0.00440047f, 
    -0.18673754f, -0.06873150f, 0.07751165f, 0.13540991f, 0.08912893f, -0.15736781f, 0.01682526f, -0.14263314f, 
    -0.04906604f, 0.17856500f, 0.08435629f, 0.06058407f, -0.02430114f, 0.14406414f, 0.05221492f, -0.05824908f, 
    -0.08604277f, 0.17126757f, -0.06828657f, 0.24229610f, -0.09570507f, -0.06342597f, -0.03494674f, 0.15751454f, 
    0.23880737f, 0.21821254f, 0.09700140f, -0.11154694f, -0.05282430f, -0.15464672f, 0.06844388f, 0.38002276f, 
    0.13301532f, 0.06027524f, -0.00631859f, 0.06523100f, 0.05480762f, -0.14302482f, -0.02645836f, 0.16974986f, 
    0.19804259f, 0.05863288f, 0.03775170f, -0.09291422f, 0.04043510f, 0.15540676f, -0.07468085f, 0.08052458f, 
    -0.11692525f, 0.05012402f, -0.09096191f, 0.05120001f, -0.17031306f, -0.07785530f, 0.03742426f, 0.13610412f, 
    0.06290181f, 0.15327325f, 0.22241284f, 0.23420066f, 0.17918469f, 0.12215116f, -0.01509298f, 0.06454772f, 
    -0.03688746f, 0.01395848f, 0.14713572f, -0.26937220f, -0.04729119f, -0.00147462f, 0.07263946f, 0.11348569f, 
    0.14479861f, -0.08117784f, 0.09439165f, 0.16522115f, 0.22082941f, 0.09693166f, 0.18376343f, -0.15850298f, 
    -0.04810948f, -0.18181905f, -0.04438561f, 0.05339803f, 0.20734924f, -0.36957651f, -0.02549598f, 0.20985132f, 
    0.18061839f, 0.06699504f, 0.06239554f, 0.02039272f, 0.03175642f, 0.02585410f, -0.02155304f, 0.16379862f, 
    -0.08028965f, -0.07357749f, -0.08254758f, -0.06196287f, 0.11067509f, 0.02061502f, -0.00252164f, 0.20042427f, 
    -0.13631645f, -0.08759443f, -0.04158718f, -0.09991805f, -0.01102477f, -0.16890877f, 0.04481659f, -0.07431218f, 
    -0.01130053f, 0.03570460f, -0.00471413f, -0.03234464f, -0.00220904f, 0.03978609f, 0.04718605f, -0.03019035f, 
    0.02248706f, 0.04479669f, 0.01623387f, 0.02279868f, 0.02624457f, -0.01780252f, 0.00469419f, 0.01784753f, 
    -0.04650144f, -0.02213749f, 0.00112993f, 0.03056106f, 0.00330795f, -0.04617997f, 0.01406473f, -0.03801991f, 
    0.00093896f, -0.00331238f, 0.05001784f, 0.02948853f, -0.01406078f, 0.04833322f, 0.03429486f, 0.01965553f, 
    -0.03293971f, 0.02178413f, -0.02085193f, -0.00347187f, 0.02797538f, -0.04731261f, 0.00112121f, -0.00458160f, 
    -0.01980788f, 0.03440883f, -0.06336754f, 0.01332593f, 0.03490551f, -0.02473343f, -0.02294329f, 0.04868254f, 
    -0.04649301f, 0.04529419f, -0.03813208f, 0.00570152f, 0.00222845f, 0.03382497f, 0.01148377f, 0.03744001f, 
    -0.00861264f, 0.03985525f, 0.05138368f, 0.00146981f, -0.04374784f, -0.02036664f, -0.03548918f, 0.04213380f, 
    0.00178888f, -0.05632983f, 0.02509221f, -0.01798805f, 0.02881407f, 0.01018997f, 0.00572519f, -0.04453481f, 
    -0.04272576f, 0.04584495f, -0.03709053f, -0.05577778f, -0.01276814f, -0.04648305f, -0.01418970f, -0.00673867f, 
    0.02183482f, -0.01994490f, -0.04521694f, -0.00215725f, -0.00559809f, 0.02776749f, 0.01396235f, 0.00102289f, 
    0.04107003f, -0.01647792f, 0.04286542f, 0.04656506f, 0.02329360f, -0.02656941f, -0.05521955f, -0.06159091f, 
    -0.02054317f, 0.03556756f, -0.03061671f, -0.01222677f, -0.01420403f, 0.01607956f, -0.00559506f, -0.02850415f, 
    -0.00761495f, -0.04178591f, -0.01636294f, -0.02957207f, 0.04627201f, -0.00738863f, -0.04035475f, -0.02547080f, 
    0.03914656f, 0.05827100f, 0.01331956f, -0.05069283f, -0.02456622f, 0.01380086f, -0.02393268f, -0.02369680f, 
    -0.04843459f, -0.03328395f, -0.01870782f, 0.04402044f, 0.01493722f, 0.01858964f, -0.00424459f, -0.05258620f, 
    -0.01354161f, -0.04080464f, 0.03478656f, -0.00428305f, -0.06362262f, 0.00684411f, -0.04455684f, -0.04859227f, 
    -0.05884883f, -0.02574830f, 0.05148884f, 0.00029756f, 0.00973320f, 0.01845401f, -0.01109164f, 0.02361918f, 
    -0.05555664f, 0.05129186f, -0.05233555f, 0.04599180f, 0.00252711f, 0.05117371f, 0.00216298f, -0.03940004f, 
    -0.05328801f, 0.00838247f, 0.02162700f, 0.01039125f, 0.05311931f, -0.05602348f, 0.03530509f, 0.03261196f, 
    -0.01750972f, -0.05315077f, 0.01099118f, -0.00517953f, -0.06031317f, 0.03128144f, 0.00171619f, 0.05291091f, 
    -0.04988975f, -0.00428050f, 0.00651307f, -0.01701817f, 0.00649536f, 0.00242888f, 0.01112584f, -0.01050356f, 
    -0.00523046f, -0.02370821f, -0.01998660f, -0.03294853f, -0.02093329f, -0.02985900f, 0.00869203f, -0.03141733f, 
    0.04412234f, -0.03423641f, -0.01700873f, -0.03320032f, -0.02558296f, 0.04861826f, -0.06088848f, -0.06541251f, 
    -0.02739383f, 0.01571066f, 0.05170268f, 0.00719665f, -0.00086942f, -0.04768243f, 0.00604278f, -0.01734450f, 
    -0.05494631f, -0.04670818f, 0.00199720f, -0.02909408f, -0.05540260f, 0.03333611f, -0.02342341f, -0.05511511f, 
    -0.01420261f, -0.00959425f, 0.03996422f, 0.00238070f, 0.02146941f, -0.01856166f, -0.02484633f, 0.05796673f, 
    0.01176129f, -0.05699698f, -0.04051731f, -0.02820606f, 0.00458003f, 0.02510140f, -0.02046466f, -0.00312470f, 
    -0.03675203f, -0.06218607f, 0.02608245f, -0.03001865f, 0.01800250f, -0.00445269f, -0.03992220f, 0.01504371f, 
    -0.00043833f, -0.05883211f, -0.04883308f, -0.00384047f, -0.03952932f, -0.02344772f, 0.00285853f, 0.03847024f, 
    0.00820229f, -0.03457587f, -0.05894993f, -0.01945576f, -0.02309857f, -0.04240986f, -0.01132973f, -0.03320992f, 
    0.02661268f, -0.04632272f, 0.04291047f, -0.03712216f, -0.02649026f, 0.01495595f, -0.03587070f, -0.00094194f, 
    0.04883426f, -0.03422441f, -0.05007571f, -0.04390910f, -0.02376688f, 0.03811841f, -0.01681658f, 0.04471262f, 
    -0.02041239f, -0.04929944f, -0.03641668f, -0.02512497f, -0.03214565f, -0.00594229f, -0.02638688f, -0.01220796f, 
    0.00565338f, -0.01164185f, -0.00933531f, 0.01526452f, 0.03714547f, 0.03782957f, 0.03578772f, -0.03816826f, 
    -0.05575120f, -0.03678554f, -0.01291042f, -0.03210099f, -0.01254157f, -0.04723263f, -0.01835100f, 0.03409246f, 
    -0.07304344f, -0.32234353f, 0.10160543f, -0.04044665f, -0.12772296f, 0.05739171f, 0.02964323f, -0.00287452f, 
    0.11284339f, -0.04733931f, 0.18275431f, -0.25882217f, 0.10379640f, -0.19409062f, -0.02360506f, -0.04914699f, 
    -0.05047105f, -0.06350975f, 0.10828723f, 0.23898889f, -0.46554160f, 0.02650615f, -0.13779971f, 0.07634234f, 
    -0.03756834f, 0.07851241f, 0.10875414f, 0.13871679f, -0.12563701f, 0.42147690f, -0.15686204f, 0.03039572f, 
    0.05475923f, -0.01459868f, -0.10020620f, -0.12397838f, 0.54004961f, 0.29258496f, 0.14207797f, -0.15218405f, 
    -0.01152246f, -0.00027899f, 0.05300282f, 0.02038764f, -0.00706167f, -0.02441194f, 0.30397204f, 0.00775963f, 
    0.05374967f, -0.19580954f, -0.12130879f, -0.17255867f, -0.01949304f, -0.21434723f, -0.41779971f, 0.15163913f, 
    -0.32531321f, 0.16012141f, 0.03505844f, 0.01721246f, 0.17706999f, 0.08206505f, 0.09738069f, -0.14291967f, 
    0.08157717f, 0.22147147f, 0.01733394f, -0.05371740f, 0.00883327f, -0.12714157f, -0.09701678f, 0.00171498f, 
    -0.03808003f, -0.09405971f, -0.00474719f, 0.14578024f, 0.01927494f, -0.08531535f, -0.00125292f, 0.17047615f, 
    0.14340769f, -0.41583452f, -0.15469484f, 0.16824575f, -0.09734900f, -0.02170560f, -0.12966987f, 0.10406570f, 
    0.07756586f, -0.13571091f, -0.20646839f, -0.03334770f, 0.28185397f, -0.02762004f, 0.09289773f, 0.01731879f, 
    0.06514717f, 0.02460022f, 0.02333664f, -0.09636486f, -0.27276754f, 0.10152211f, -0.19641927f, -0.26492599f, 
    0.03107673f, -0.10978981f, 0.04400133f, -0.06776690f, -0.04956538f, -0.19513912f, 0.27692413f, -0.03496914f, 
    -0.01454762f, 0.04794771f, -0.18587823f, -0.04984460f, 0.18176347f, 0.16708951f, 0.09217404f, 0.06741361f, 
    0.05590772f, 0.07402646f, 0.06773938f, 0.07353992f, 0.00275460f, 0.09144534f, -0.27873972f, 0.10588637f, 
    0.19729601f, 0.01279503f, 0.10570008f, -0.05156992f, -0.00538923f, 0.12040232f, 0.13065335f, -0.30693331f, 
    -0.04531542f, 0.18505253f, -0.06679961f, 0.01280960f, 0.05473127f, -0.11853071f, 0.04773635f, -0.02491668f, 
    0.13982950f, -0.00139794f, 0.13273250f, 0.11009471f, -0.01022631f, -0.04841882f, 0.09486523f, -0.00312791f, 
    0.08600762f, 0.05358557f, 0.21004556f, -0.34584674f, -0.01189386f, 0.01821915f, -0.03331245f, 0.04462987f, 
    0.05966656f, 0.18430813f, 0.14674415f, 0.08878897f, 0.03532453f, 0.02190061f, -0.03126646f, -0.10217122f, 
    -0.09906269f, 0.02874326f, 0.12103967f, 0.30346069f, -0.11938715f, -0.14262293f, 0.00054738f, 0.09586712f, 
    -0.11214779f, 0.07556829f, -0.01236095f, 0.04637722f, 0.35499972f, -0.05607174f, 0.10248853f, 0.00482543f, 
    -0.03779808f, 0.00139605f, -0.00489712f, 0.06962845f, 0.15081275f, 0.05450447f, -0.10032495f, -0.11509664f, 
    0.11227776f, 0.17098399f, 0.04688814f, 0.13002950f, 0.08044504f, 0.05781252f, -0.08265893f, 0.28412962f, 
    -0.15542836f, 0.11794868f, 0.03696984f, -0.07904541f, -0.12243925f, 0.07046546f, -0.02096271f, -0.18772016f, 
    -0.14337921f, -0.08266309f, 0.14016716f, 0.03948078f, -0.03413489f, -0.04696836f, 0.05454655f, 0.05490567f, 
    0.36936691f, -0.00233018f, -0.44418168f, 0.15010752f, 0.04663511f, -0.10050406f, 0.06173020f, -0.20635849f, 
    -0.05701739f, -0.16164438f, -0.41093683f, 0.11405975f, -0.00060663f, 0.01943456f, 0.01555400f, -0.00993106f, 
    0.03940042f, 0.05047031f, -0.29269794f, 0.34074369f, -0.20193611f, -0.03098425f, -0.04957649f, 0.01472903f, 
    0.23661858f, 0.12364293f, -0.05112880f, 0.10531509f, 0.17775074f, 0.09310097f, 0.12703577f, 0.09573106f, 
    0.04407384f, -0.02497523f, 0.10804498f, -0.18690962f, -0.26101297f, -0.09609114f, -0.35221383f, 0.07481204f, 
    0.05213948f, 0.02954163f, 0.10202073f, -0.10181472f, 0.10435813f, 0.01523424f, 0.08873299f, 0.03258724f, 
    0.14504270f, 0.10172758f, 0.12531200f, 0.02875579f, -0.03642238f, -0.00443545f, -0.27003208f, -0.00650939f, 
    0.18442826f, -0.05806528f, 0.00456169f, 0.07336710f, -0.10998737f, -0.08377519f, 0.08061820f, -0.37458098f, 
    -0.16064359f, -0.19688226f, 0.02997326f, 0.02869874f, 0.03312450f, -0.09738841f, 0.01355813f, -0.02592508f, 
    0.01079348f, 0.03671369f, -0.00723428f, 0.04236456f, 0.03951607f, 0.02871592f, -0.00436061f, -0.03458844f, 
    -0.03634754f, -0.01860074f, 0.01897505f, 0.03193180f, -0.04243372f, 0.05474441f, -0.00049458f, -0.02792569f, 
    0.04035543f, -0.04306187f, -0.06406424f, 0.01762482f, -0.04489301f, 0.05090800f, -0.05260229f, -0.01317098f, 
    -0.03726399f, 0.04127008f, -0.05110937f, 0.00816042f, 0.04160879f, -0.06259874f, 0.02060742f, 0.01749093f, 
    0.03091324f, 0.00004656f, -0.03482714f, 0.01326183f, 0.03225372f, -0.00473113f, -0.00716524f, -0.02245659f, 
    0.05085629f, -0.00396582f, 0.04777261f, 0.02771962f, -0.03258089f, -0.00988304f, 0.03074836f, -0.01251009f, 
    0.02001154f, -0.03392488f, 0.00067724f, 0.02468879f, -0.02581633f, 0.01042570f, 0.03552508f, -0.01150747f, 
    -0.01403076f, 0.00051356f, 0.02497413f, -0.05819743f, 0.04993978f, -0.00357491f, 0.01801559f, 0.00804109f, 
    -0.03721644f, 0.02248540f, 0.00151661f, -0.03306253f, -0.05665057f, 0.04249189f, 0.03108575f, -0.04113226f, 
    0.02535024f, 0.00884338f, -0.04179736f, -0.05062690f, -0.00242360f, 0.00747486f, -0.00078389f, 0.00866203f, 
    0.02720559f, 0.02764961f, 0.04498879f, -0.02510372f, -0.05873635f, 0.04053692f, -0.05176172f, -0.04629282f, 
    -0.03664752f, 0.06049440f, -0.02108872f, 0.02184375f, -0.00976050f, -0.05575256f, -0.03204086f, -0.06606400f, 
    0.00369674f, -0.02820398f, 0.04389280f, -0.04263080f, -0.02706072f, -0.02548640f, -0.06091246f, 0.03859746f, 
    0.00699577f, -0.01632511f, -0.02833416f, -0.02709143f, 0.02783238f, -0.01273963f, -0.02544020f, -0.03624381f, 
    0.04168188f, -0.05688022f, 0.04207608f, 0.01545054f, -0.04895617f, -0.01816764f, -0.04265764f, -0.05932533f, 
    0.00306583f, -0.05453006f, 0.00261398f, -0.04336734f, -0.01856769f, -0.03362153f, -0.04422712f, 0.03200168f, 
    -0.01597456f, -0.04561740f, 0.03607349f, 0.03040961f, -0.06253983f, -0.03238437f, 0.02564197f, -0.04599742f, 
    0.02010250f, -0.01646706f, -0.00067701f, -0.04990664f, 0.03019633f, -0.06017160f, 0.00757181f, 0.01077237f, 
    -0.04616599f, 0.04911594f, 0.05295643f, -0.03580295f, 0.04743406f, -0.00315845f, -0.01576881f, 0.02632750f, 
    0.01087161f, -0.03913073f, 0.00069639f, 0.02732457f, -0.00820932f, -0.04708021f, 0.00909136f, 0.04444521f, 
    0.04871348f, -0.01712959f, 0.03918939f, -0.02767658f, 0.02095179f, -0.03210051f, 0.03262134f, -0.03672718f, 
    -0.00605601f, 0.03214657f, -0.01859431f, 0.02556668f, 0.02066291f, 0.03058255f, -0.02358210f, -0.05412498f, 
    -0.05369489f, 0.05043866f, 0.02158537f, -0.03163148f, 0.03231076f, 0.04335264f, 0.03505763f, 0.02883552f, 
    -0.02981201f, 0.03206048f, 0.04728157f, 0.04336220f, 0.05290367f, -0.04859059f, -0.02234979f, -0.02043194f, 
    0.04567991f, -0.02493699f, 0.00559059f, 0.04751652f, 0.00186646f, -0.00033909f, 0.04580881f, -0.02902240f, 
    -0.04110449f, -0.05980850f, 0.00702099f, 0.00886802f, 0.03655803f, -0.00383390f, -0.00290928f, 0.03823978f, 
    0.01106329f, 0.03883198f, 0.04182508f, -0.00090815f, -0.04206265f, -0.00866579f, 0.00411153f, -0.01167548f, 
    -0.00971923f, -0.04725499f, 0.00715695f, -0.02233626f, 0.04490619f, -0.01038969f, 0.03978583f, -0.05631740f, 
    -0.05496345f, 0.01434062f, -0.00420452f, -0.00830026f, -0.00300934f, 0.03231916f, -0.02537298f, -0.04566988f, 
    -0.05206956f, 0.04219186f, -0.03754492f, -0.04690472f, -0.05881651f, 0.01684303f, -0.04973235f, -0.05793969f, 
    0.03946150f, -0.03520865f, 0.03286982f, 0.00581875f, -0.04694505f, -0.04746614f, 0.04224612f, 0.02117970f, 
    -0.01374426f, 0.00156039f, 0.00751141f, -0.04742804f, 0.02310255f, 0.01028960f, 0.00519726f, -0.00434535f, 
    -0.03266176f, 0.04263218f, 0.00738214f, -0.02975916f, 0.03313383f, -0.03807772f, -0.04950838f, -0.02109581f, 
    0.04623954f, -0.00216870f, -0.01898604f, -0.06900112f, 0.03218928f, -0.04507810f, -0.04628978f, -0.05639105f, 
    -0.01313728f, 0.03649763f, 0.00699053f, -0.03772296f, -0.01392126f, -0.06140154f, -0.06090962f, 0.02919900f, 
    -0.03499394f, 0.01944344f, -0.01786276f, -0.05153863f, 0.00871788f, 0.04902184f, 0.01728648f, -0.00743154f, 
    -0.02771678f, 0.02727335f, 0.00140363f, -0.06288081f, 0.03537419f, -0.03754401f, 0.02692822f, -0.05121189f, 
    -0.06126643f, 0.03056749f, -0.03698046f, 0.05308963f, -0.02732199f, 0.01971848f, -0.02283135f, -0.03803030f, 
    0.02997768f, -0.04700195f, 0.03786531f, -0.00635268f, -0.02133377f, 0.02960128f, 0.01085620f, -0.01101172f, 
    0.00923092f, -0.01782536f, 0.01536694f, -0.03374058f, -0.02680497f, -0.04911221f, -0.02058685f, -0.05729074f, 
    -0.04408705f, 0.06101106f, -0.02233349f, -0.04256506f, -0.00843694f, -0.00544835f, -0.04320510f, -0.01605278f, 
    -0.01222910f, 0.05061040f, -0.03611998f, -0.02920068f, -0.02123032f, 0.02158951f, 0.04138488f, 0.00347590f, 
    0.00419612f, -0.04502416f, -0.03962673f, -0.06478646f, 0.03451662f, 0.00651109f, 0.02155474f, 0.00353245f, 
    0.03417893f, -0.00373650f, -0.04019580f, 0.02549029f, -0.01534406f, -0.02243836f, -0.00984115f, -0.04755035f, 
    -0.05732704f, 0.03099729f, -0.02449902f, -0.03451763f, 0.03642612f, 0.04372343f, -0.04424968f, -0.02345490f, 
    0.03533163f, -0.03573433f, -0.02778148f, -0.05815169f, 0.02743765f, 0.01768895f, 0.00210211f, -0.05021238f, 
    -0.05851459f, -0.01546932f, -0.06651380f, 0.03013097f, 0.03878854f, -0.02888966f, -0.01272935f, -0.04767461f, 
    0.00751951f, -0.02160698f, -0.02191957f, 0.02853799f, 0.02879295f, 0.03470421f, 0.02011790f, -0.06559716f, 
    -0.03313648f, 0.03315265f, 0.02106300f, 0.03127014f, -0.02962757f, 0.01748956f, -0.02487205f, 0.01739586f, 
    0.03614641f, 0.00336062f, -0.05108964f, 0.03722425f, 0.03505873f, -0.05665926f, 0.01782375f, -0.02291753f, 
    0.01971722f, 0.02735054f, -0.03928729f, 0.01698016f, -0.01510632f, -0.03923866f, 0.04141735f, 0.01820025f, 
    0.03875485f, -0.01916137f, -0.04278445f, -0.06424548f, -0.05063201f, -0.04760224f, -0.02000626f, -0.00539829f, 
    -0.03905527f, -0.01704157f, -0.03299233f, -0.01551296f, 0.00084283f, 0.04547504f, -0.00599517f, 0.02105383f, 
    0.01444027f, -0.03215120f, 0.04167945f, -0.03909169f, -0.00808595f, 0.00122234f, 0.02169353f, 0.01562915f, 
    0.03055098f, 0.00230472f, 0.04232413f, 0.00441451f, -0.00260955f, -0.00421727f, -0.03428333f, -0.01616095f, 
    -0.05610923f, -0.06333692f, 0.00713850f, -0.00527789f, -0.03146345f, -0.02293428f, 0.04149444f, 0.04343430f, 
    -0.03582370f, -0.05876347f, 0.01706822f, 0.01146830f, 0.04444131f, 0.04288243f, -0.02449927f, 0.02790614f, 
    -0.04368334f, 0.01763947f, 0.02254357f, -0.00506418f, -0.01417934f, -0.03129457f, 0.03105393f, -0.05218802f, 
    0.03067628f, -0.00753732f, -0.03207590f, -0.03407386f, -0.01181788f, -0.05246286f, -0.06011791f, -0.01934882f, 
    -0.06409118f, -0.04071579f, -0.01886768f, 0.02094077f, -0.03930430f, -0.04382076f, -0.00996769f, -0.05684080f, 
    -0.03934855f, 0.00789833f, -0.02455730f, -0.00326654f, 0.01221086f, 0.01304627f, 0.00433719f, -0.01251974f, 
    0.02574067f, -0.02720900f, 0.04511058f, 0.03494897f, 0.04654195f, -0.04561273f, -0.06601913f, -0.07007796f, 
    0.02367993f, 0.00791679f, 0.04111433f, 0.01059966f, -0.01905087f, 0.02174982f, 0.00981724f, -0.03589005f, 
    -0.00564183f, -0.00455498f, -0.01464394f, -0.03597581f, -0.00243517f, -0.04714862f, -0.05302848f, 0.01897769f, 
    -0.05463478f, -0.04125217f, -0.01742158f, -0.04066111f, -0.05848751f, 0.01900995f, -0.06367487f, -0.03721734f, 
    0.01794054f, -0.05321995f, -0.03289532f, -0.04947244f, -0.03015559f, 0.00036271f, 0.03750550f, -0.05826276f, 
    0.04222688f, 0.05351873f, -0.00399581f, 0.00180092f, -0.05662101f, -0.06164211f, -0.00267869f, 0.02260011f, 
    -0.05077824f, -0.00162911f, 0.00034300f, 0.02794602f, 0.01303250f, -0.02555094f, 0.03872354f, -0.04815077f, 
    -0.01199976f, -0.02731625f, -0.02149875f, 0.03092836f, -0.02907615f, 0.04358856f, -0.04754946f, 0.04272732f, 
    0.04089989f, -0.05877852f, -0.02726187f, -0.02691637f, -0.01182123f, -0.05241133f, 0.03476257f, -0.01863212f, 
    -0.03278257f, -0.02364627f, 0.02913736f, 0.04021249f, -0.01499700f, 0.03346923f, 0.04436649f, -0.04253581f, 
    0.01811854f, -0.01421944f, 0.03298053f, -0.02092506f, 0.00013321f, -0.01878855f, -0.04670270f, 0.01464290f, 
    -0.01341003f, -0.30960590f, 0.10916749f, 0.03142500f, -0.09250499f, 0.13516042f, 0.20563059f, -0.26521108f, 
    -0.24636620f, -0.26347458f, 0.24595709f, -0.14798951f, 0.09274633f, 0.03649597f, 0.07866453f, 0.05688331f, 
    -0.14059265f, 0.00094704f, -0.34817106f, 0.05394055f, -0.13658245f, 0.15473121f, -0.12988348f, 0.02471438f, 
    0.10980535f, -0.08663630f, -0.22298573f, -0.02189494f, 0.04019037f, 0.09772384f, -0.21086402f, -0.10932582f, 
    -0.04150088f, 0.16266860f, -0.04326412f, -0.15802258f, -0.16735214f, 0.01976079f, 0.06100571f, 0.13627277f, 
    -0.06527766f, 0.27292806f, -0.02586826f, -0.03950715f, 0.05677641f, -0.39121109f, 0.06403700f, -0.12504940f, 
    0.02349104f, 0.04647882f, -0.04346490f, 0.12002151f, 0.12259588f, -0.10724308f, 0.08148917f, -0.00906763f, 
    0.09971280f, -0.01634598f, 0.02417387f, 0.13154472f, 0.02465987f, -0.05397260f, -0.08686460f, 0.22049765f, 
    0.09003977f, -0.10064013f, -0.00262460f, 0.09486163f, -0.09123652f, -0.10813293f, 0.00647928f, 0.00272025f, 
    -0.16933607f, 0.11060274f, 0.02372338f, 0.12048125f, 0.05439105f, 0.04442355f, -0.08527456f, -0.06620289f, 
    -0.24297251f, 0.18567494f, 0.22490059f, 0.07133885f, -0.05509462f, 0.12286362f, 0.00466859f, -0.06704910f, 
    0.08298396f, 0.16061550f, 0.06163141f, -0.03857679f, -0.06599373f, 0.03918510f, 0.02788604f, 0.10463322f, 
    -0.05053351f, 0.00693311f, -0.00651871f, 0.21564439f, 0.14439066f, 0.05084411f, -0.04613673f, -0.13404065f, 
    0.12087063f, 0.19436626f, 0.13024744f, 0.06548379f, 0.22133321f, 0.11533432f, -0.09077507f, 0.00510247f, 
    0.07568351f, -0.03739523f, -0.09616431f, -0.05367529f, -0.10762125f, 0.11220139f, -0.05326492f, -0.02241840f, 
    0.21092087f, 0.07197922f, 0.07044275f, -0.04053860f, -0.14501382f, -0.19870548f, 0.11900775f, 0.03538042f, 
    -0.16554672f, -0.09065734f, 0.07112594f, 0.08466212f, -0.18463384f, -0.03250017f, 0.09371833f, 0.31019107f, 
    0.08008079f, -0.18225354f, 0.10296730f, 0.04417085f, 0.11737624f, 0.11397979f, 0.04163985f, 0.13214916f, 
    0.21462016f, -0.01661056f, -0.15909608f, -0.05403023f, 0.00769305f, 0.00385255f, 0.16999309f, 0.01859264f, 
    0.00115212f, -0.13952756f, 0.01436687f, -0.06704551f, 0.04757474f, 0.05553991f, -0.04386310f, 0.05594352f, 
    -0.07574038f, -0.06707629f, 0.12752376f, -0.04862728f, -0.08320583f, 0.18027185f, 0.08652133f, -0.06023955f, 
    0.02469561f, 0.03489873f, 0.07474372f, -0.20154470f, 0.15509258f, 0.03959435f, 0.16586345f, -0.03888032f, 
    -0.02844403f, -0.04202297f, -0.12595877f, 0.23704855f, -0.25143403f, -0.09369981f, -0.03340003f, -0.11563846f, 
    -0.01177385f, 0.04454266f, 0.20477149f, -0.09255744f, 0.12079388f, -0.08824572f, -0.18055028f, 0.01099045f, 
    0.08947460f, 0.03976359f, 0.04063764f, 0.18286298f, -0.09021921f, 0.12678240f, -0.27390537f, 0.12887712f, 
    -0.47800079f, 0.05260791f, 0.05753376f, -0.06522070f, 0.01555459f, 0.00423891f, -0.08854744f, 0.33179355f, 
    -0.15899467f, 0.23206700f, -0.11106476f, -0.15728521f, -0.03834758f, 0.06759741f, -0.07947604f, 0.07647095f, 
    0.02564381f, -0.01847108f, -0.19172719f, 0.15166803f, -0.09154457f, -0.04797450f, -0.23065186f, 0.12871970f, 
    0.14104854f, 0.19609615f, 0.21173905f, 0.00380049f, -0.13079080f, -0.10314078f, 0.11278607f, -0.09837881f, 
    0.04952565f, 0.13736440f, 0.09658746f, -0.01259148f, -0.11425276f, -0.08954087f, -0.02985931f, -0.12097985f, 
    -0.03650453f, 0.03075467f, -0.06020926f, -0.21412997f, 0.02705551f, -0.04291867f, 0.17812413f, 0.04290196f, 
    0.14754671f, -0.04118320f, -0.03481648f, 0.00639041f, 0.00687985f, -0.01279694f, -0.19766803f, -0.08226079f, 
    -0.07075086f, -0.02575571f, 0.05286372f, 0.10733479f, 0.17985499f, -0.35991031f, -0.13037160f, -0.16373987f, 
    0.12182695f, -0.00913541f, -0.09826288f, -0.07955692f, 0.05474000f, 0.04594539f, 0.16355336f, 0.10442276f, 
    -0.09210877f, -0.01396393f, -0.14218576f, -0.10812515f, 0.04595174f, 0.07343086f, -0.10647754f, 0.33509001f, 
    0.06404815f, -0.01845624f, -0.10974758f, -0.02464801f, 0.18179345f, 0.13949585f, -0.06385456f, 0.00289848f, 
    -0.30545503f, -0.31281281f, 0.00173348f, 0.05911452f, -0.24361683f, 0.08475945f, 0.16247654f, 0.08396473f, 
    -0.05546543f, 0.13458639f, -0.02884843f, -0.02667256f, 0.09536903f, -0.18639347f, 0.09494729f, -0.00436151f, 
    -0.03844402f, 0.09515589f, 0.03872398f, 0.04477972f, 0.02554333f, -0.08641323f, 0.03383896f, -0.16471647f, 
    0.08802962f, -0.00724744f, -0.01245719f, 0.33475536f, 0.01439351f, -0.03500651f, 0.06288473f, -0.16019447f, 
    -0.01466631f, 0.10841815f, -0.10481697f, 0.06493820f, 0.27974838f, 0.11034012f, 0.12070912f, 0.07045048f, 
    0.07886781f, -0.08087156f, -0.01596574f, -0.12290338f, 0.18747757f, 0.14916798f, -0.13616370f, 0.02578949f, 
    0.08870494f, 0.00354875f, 0.06569593f, 0.11458857f, 0.04334033f, 0.08626546f, -0.25328207f, -0.05893768f, 
    -0.19755340f, 0.08530767f, 0.12268711f, 0.11578804f, -0.09176555f, -0.05936540f, 0.12822357f, 0.25689015f, 
    0.25572547f, -0.17936799f, 0.07763296f, -0.15529782f, 0.05262190f, -0.05290490f, -0.01905818f, 0.10370445f, 
    -0.04308845f, -0.13149594f, -0.00417826f, -0.00246001f, -0.03830528f, -0.05487910f, -0.12188834f, -0.05357744f, 
    0.19691761f, 0.02792939f, -0.04166466f, 0.25000897f, -0.01564412f, -0.02709706f, -0.18147412f, 0.08993340f, 
    -0.03515896f, 0.07492150f, -0.07486704f, 0.13710590f, 0.11586823f, -0.09204017f, 0.07988777f, -0.18817148f, 
    0.00439125f, 0.11336862f, 0.03601103f, -0.07972469f, 0.03228297f, -0.17143697f, -0.12436389f, 0.17882811f, 
    0.05752678f, -0.17586112f, 0.07468502f, 0.00977856f, 0.16026576f, 0.18945593f, 0.03421751f, 0.07698165f, 
    0.19212367f, -0.05401308f, -0.05463969f, 0.14633466f, -0.04691593f, 0.02079091f, -0.03924767f, -0.23808447f, 
    -0.10965279f, 0.12298085f, -0.05783844f, -0.09416042f, -0.09979008f, 0.08872970f, 0.02033031f, -0.02698664f, 
    -0.09106635f, 0.01432758f, 0.05370491f, -0.06021448f, 0.06535151f, 0.02987844f, -0.19105217f, -0.14637180f, 
    -0.01058447f, 0.01174532f, -0.16975822f, 0.17076418f, -0.05507915f, -0.07345372f, 0.06541546f, 0.00731363f, 
    -0.20544975f, 0.28501660f, -0.01397546f, -0.00947922f, -0.04849713f, -0.17534813f, 0.00177287f, -0.03197341f, 
    0.11156880f, 0.18762344f, -0.15048474f, -0.01128506f, -0.14792277f, -0.18120052f, 0.05942756f, -0.02035812f, 
    0.10781383f, -0.13676894f, 0.45657858f, 0.16726172f, -0.28081954f, 0.04525780f, 0.01176127f, -0.09418885f, 
    0.04980419f, 0.01122091f, -0.04243153f, 0.12234942f, -0.25925514f, -0.24795450f, 0.08428838f, -0.18399104f, 
    0.17704916f, -0.13701570f, 0.02702554f, 0.10903033f, -0.15215899f, -0.21643282f, -0.26770988f, 0.03527490f, 
    0.03635130f, -0.07693698f, 0.01142884f, 0.11277661f, 0.00795921f, 0.18836202f, 0.03284664f, -0.18536735f, 
    -0.06947218f, 0.02058700f, 0.04557084f, 0.03118962f, -0.16798346f, -0.06136595f, 0.21647361f, -0.14069256f, 
    0.08330202f, 0.13651922f, -0.02273307f, 0.05687943f, -0.01880622f, -0.16570285f, 0.12247549f, -0.20322360f, 
    0.12981953f, -0.16768999f, -0.08977217f, -0.08968189f, 0.00327657f, 0.01650038f, -0.07648635f, 0.04512893f, 
    0.05839775f, -0.16774359f, -0.08288972f, 0.18317889f, -0.08242372f, 0.09750863f, 0.07381406f, 0.03952377f, 
    0.07704116f, -0.08816747f, 0.05032316f, -0.11742949f, 0.13347638f, -0.02709976f, 0.06633696f, 0.00636971f, 
    0.00975471f, 0.02413625f, -0.04567806f, 0.00277168f, -0.06833860f, 0.01432521f, 0.05299751f, -0.01900868f, 
    0.02043902f, -0.10194347f, 0.00485469f, 0.22111340f, -0.15113907f, 0.10175351f, 0.20705885f, -0.16828074f, 
    0.03812817f, 0.03722748f, -0.01870937f, -0.15001039f, -0.11715462f, -0.02093528f, -0.22198202f, -0.07395630f, 
    -0.14423585f, 0.03794695f, -0.05653274f, 0.02706949f, -0.00504578f, 0.04665361f, -0.05571481f, 0.10985674f, 
    0.11516758f, -0.03534606f, -0.02019401f, 0.08997443f, 0.05598429f, 0.00226031f, 0.05839853f, 0.21259002f, 
    -0.17329343f, -0.08273477f, 0.01537046f, -0.05598898f, -0.00386379f, -0.01852984f, 0.02211803f, -0.55464518f, 
    0.17379451f, -0.08673809f, 0.07310635f, 0.06448212f, -0.01755223f, -0.14010453f, 0.10972470f, 0.08792963f, 
    -0.04497993f, -0.11587112f, -0.19458675f, 0.09503356f, 0.10293383f, -0.03381947f, 0.04349140f, -0.14329305f, 
    0.21786112f, 0.11613906f, -0.21367274f, -0.08936907f, 0.11674858f, 0.13289726f, 0.22461355f, -0.17184621f, 
    -0.01348677f, -0.01042474f, -0.20686261f, -0.14764421f, -0.06965323f, 0.08197691f, 0.05035295f, 0.12152506f, 
    -0.11386403f, -0.02615664f, -0.13439105f, 0.05657169f, 0.14419284f, 0.23163676f, 0.03679373f, -0.05749141f, 
    -0.02473601f, 0.07109983f, -0.14000784f, -0.04297317f, 0.00650460f, -0.07057068f, 0.23628943f, -0.08458033f, 
    0.00776444f, -0.00707314f, -0.19431081f, -0.00622307f, -0.24184650f, -0.09354218f, -0.09407672f, 0.14284292f, 
    -0.11091845f, 0.03896065f, 0.16855012f, 0.03186887f, -0.16468526f, 0.04539155f, 0.13776670f, -0.01922065f, 
    -0.02190995f, 0.03404741f, 0.02580898f, 0.06160743f, -0.00587871f, 0.02333667f, -0.14075470f, 0.10978221f, 
    0.02838995f, 0.10141265f, -0.23172104f, -0.17737050f, -0.09144634f, -0.01258925f, 0.07956469f, -0.19406833f, 
    -0.10096769f, 0.02826935f, -0.00230004f, 0.10509779f, 0.20831986f, 0.16710922f, -0.16837317f, 0.16552193f, 
    0.02055551f, 0.07486083f, 0.02608563f, 0.03959136f, -0.12401312f, -0.22620042f, 0.09598699f, 0.05827712f, 
    0.04591899f, -0.03555226f, 0.21050914f, 0.06974399f, 0.10857079f, -0.14165640f, -0.10519544f, -0.19140823f, 
    -0.09756932f, 0.03917316f, 0.00491530f, -0.01133337f, 0.21122307f, 0.21009758f, -0.07517516f, -0.16410027f, 
    -0.07483292f, 0.18938316f, 0.05135721f, -0.06013165f, 0.14423595f, 0.23463473f, 0.19531699f, -0.12159371f, 
    -0.12961017f, 0.05467648f, -0.08722682f, 0.11113445f, 0.13959675f, 0.28206757f, 0.03710063f, 0.05521929f, 
    -0.03767918f, -0.02817800f, -0.16240333f, -0.09137326f, 0.04853209f, -0.07476656f, 0.06309897f, 0.01914592f, 
    0.00577793f, 0.08289048f, -0.08799862f, 0.05845637f, -0.04661892f, -0.08426987f, -0.04201125f, 0.14881450f, 
    0.20893633f, 0.02175600f, -0.03794108f, -0.00146744f, -0.01042833f, 0.12439271f, 0.00576626f, -0.00270726f, 
    -0.04096339f, -0.06028257f, -0.06333456f, -0.22142048f, -0.10950855f, -0.09263084f, 0.14514174f, -0.02003439f, 
    0.06217561f, -0.05972464f, 0.05762501f, 0.00482442f, -0.05752085f, 0.03485882f, 0.00051581f, 0.12789887f, 
    -0.05804531f, 0.00784488f, 0.08038910f, 0.00902492f, -0.02199080f, -0.03378127f, -0.10243060f, -0.00110580f, 
    0.02304053f, 0.04707156f, -0.12385396f, 0.13390209f, -0.03630659f, 0.02627048f, -0.05710427f, -0.06503337f, 
    -0.19236679f, 0.10650818f, 0.01228387f, -0.16207206f, -0.31540650f, 0.14103624f, 0.03896392f, 0.02028445f, 
    -0.13753103f, -0.09457953f, 0.11244375f, -0.04577592f, 0.10127299f, 0.11962932f, 0.07550138f, -0.12159029f, 
    -0.08628382f, -0.01237486f, 0.15702286f, -0.00392148f, -0.12109563f, -0.09326518f, 0.17788510f, -0.22737959f, 
    -0.09871597f, 0.03609002f, 0.09059098f, 0.03452617f, -0.08299644f, -0.09506360f, -0.06220335f, 0.01124787f, 
    0.08168752f, 0.26578876f, -0.10296920f, 0.03103956f, -0.20291913f, 0.01573518f, 0.04910987f, -0.02754269f, 
    0.48775506f, 0.07858022f, 0.15121180f, -0.12417904f, 0.08822261f, 0.16930701f, 0.25547010f, -0.03059910f, 
    -0.01336405f, 0.12965384f, -0.07438201f, 0.08694810f, -0.08073051f, -0.18962175f, 0.14534613f, 0.04848404f, 
    0.08143097f, 0.16270089f, 0.10440327f, -0.00373256f, -0.03496270f, 0.13481846f, -0.00156075f, -0.04458585f, 
    0.04731113f, -0.17529432f, -0.04910490f, 0.02628179f, 0.06601144f, 0.03282393f, -0.11874399f, 0.03282895f, 
    0.11634383f, 0.02764590f, -0.14202620f, 0.03485614f, 0.09693217f, -0.25011241f, 0.05652896f, -0.02214442f, 
    -0.14871925f, 0.05292502f, -0.02206400f, -0.14230205f, 0.05430865f, -0.23078860f, -0.17300025f, -0.07065269f, 
    0.03857325f, 0.04745646f, 0.17138483f, -0.08074096f, 0.04533527f, 0.10783498f, 0.05343032f, 0.04937110f, 
    0.16723917f, -0.01581770f, -0.16349551f, -0.03350449f, 0.01307373f, 0.07626901f, -0.18558353f, 0.02866628f, 
    -0.02051030f, 0.14919241f, 0.00759664f, 0.03849351f, 0.02983808f, 0.04252591f, 0.05527768f, 0.07625539f, 
    -0.20122540f, -0.07362145f, 0.04991151f, 0.14611830f, 0.07724297f, -0.07105581f, -0.00265144f, -0.03927267f, 
    0.20491855f, -0.16231573f, -0.00564922f, -0.01219234f, -0.10688826f, 0.16053347f, 0.18419904f, -0.04107666f, 
    0.14539887f, 0.06312217f, -0.22419304f, -0.11628010f, -0.03569210f, 0.07212336f, 0.08044767f, 0.03699429f, 
    0.02932491f, -0.21754466f, 0.25365490f, -0.06445751f, -0.31742027f, -0.04667460f, 0.21620114f, 0.11738961f, 
    -0.16302185f, -0.18675390f, -0.08840693f, -0.13057204f, -0.03471358f, -0.00190190f, -0.24055210f, 0.04581363f, 
    0.26085514f, -0.05347179f, -0.11033437f, 0.11412358f, -0.13622956f, 0.04361127f, 0.07789660f, -0.06626686f, 
    -0.04965941f, 0.07578585f, -0.00174477f, 0.04959211f, 0.11045308f, 0.18588957f, -0.13311106f, 0.05714905f, 
    -0.26142478f, 0.08831653f, -0.09014267f, 0.23030154f, -0.18270214f, 0.11463896f, 0.04353340f, 0.28447294f, 
    0.22217605f, -0.08923067f, 0.01993625f, -0.06617394f, 0.10954969f, 0.16580923f, 0.16807814f, -0.09250001f, 
    -0.15637401f, -0.20735438f, -0.10922508f, 0.39944139f, 0.00035209f, -0.06546861f, -0.16045095f, 0.11355762f, 
    0.24322043f, 0.10440741f, 0.12193400f, 0.07654251f, 0.21239763f, 0.13180140f, -0.23249656f, 0.08846234f, 
    0.10284775f, 0.14852892f, 0.01849280f, 0.17201233f, 0.01340038f, 0.10123245f, 0.03214364f, 0.02602040f, 
    0.02983628f, 0.03043451f, -0.06153905f, 0.31527552f, 0.11261936f, -0.10563185f, -0.10999823f, -0.08667148f, 
    0.12624286f, 0.13463472f, 0.07611308f, -0.17199388f, 0.33959687f, 0.12719913f, -0.01320638f, 0.01339404f, 
    0.22665490f, -0.01061380f, 0.16378696f, 0.01130008f, 0.22250336f, 0.07829816f, 0.15273605f, -0.01235136f, 
    0.07882825f, 0.02896978f, -0.15639941f, -0.19980487f, 0.12719733f, 0.12580702f, 0.10819273f, -0.12515582f, 
    0.10742010f, 0.14468779f, 0.15582654f, -0.45176172f, 0.03022446f, -0.03003319f, -0.12545606f, 0.10700075f, 
    0.07819024f, 0.05277585f, 0.24032314f, 0.07442779f, 0.01662857f, 0.04607108f, -0.11101093f, -0.12342800f, 
    0.08940725f, 0.06785817f, 0.05184199f, 0.02546674f, 0.06117749f, 0.12878235f, -0.02106154f, 0.08814821f, 
    0.24785310f, -0.27837703f, 0.12017813f, -0.05904716f, 0.07957654f, 0.04383781f, -0.17276980f, 0.04070174f, 
    0.17879306f, 0.28652695f, 0.17190318f, -0.05428884f, 0.25542039f, 0.28756282f, 0.00209720f, 0.10651504f, 
    -0.09159956f, 0.10599551f, -0.25866383f, -0.24910769f, -0.23897901f, 0.19676740f, 0.10791209f, -0.13080996f, 
    0.01500301f, 0.04542338f, -0.00355490f, -0.18943697f, -0.12087023f, 0.08554049f, -0.12950189f, 0.02531521f, 
    -0.04189589f, 0.05356219f, 0.44735906f, 0.15342855f, 0.16085434f, 0.05660473f, -0.16655017f, -0.19873203f, 
    -0.16387279f, -0.07859077f, 0.14025716f, -0.31312090f, -0.05084084f, 0.01503724f, 0.18484262f, -0.04609287f, 
    -0.16204278f, -0.03115007f, 0.01127298f, 0.27896869f, -0.08385037f, 0.01732909f, -0.00885981f, 0.27813804f, 
    0.25786218f, -0.01702446f, 0.01464171f, 0.03128827f, 0.16718431f, -0.13851187f, 0.13521053f, -0.06662802f, 
    -0.16016960f, -0.18551055f, 0.30118182f, -0.24186896f, -0.09392177f, 0.05366836f, -0.03494618f, -0.27226597f, 
    0.01108574f, 0.37663031f, 0.14821269f, 0.07805243f, 0.02652431f, 0.22498249f, -0.01603750f, 0.02258352f, 
    0.16332936f, 0.11632038f, 0.01045950f, -0.05402769f, -0.02773791f, -0.36987561f, 0.07013994f, 0.02738449f, 
    -0.10709315f, 0.04005730f, 0.11404843f, 0.03967832f, -0.00008705f, -0.02190249f, 0.08192477f, -0.04596485f, 
    0.01266210f, 0.21763571f, -0.02423815f, 0.25898975f, -0.19407754f, -0.00629519f, 0.18323170f, 0.03367762f, 
    -0.02184184f, 0.19230320f, 0.02875558f, -0.09263592f, -0.13520938f, 0.12667650f, -0.08010507f, -0.05874928f, 
    0.03215003f, -0.07075131f, -0.06859840f, 0.19278072f, -0.04579567f, 0.34001118f, 0.14494933f, 0.26196557f, 
    0.11080535f, 0.22333485f, -0.07399984f, 0.16862068f, 0.11003429f, 0.12740719f, -0.05456405f, -0.05829079f, 
    0.17598411f, 0.12700868f, 0.15516424f, 0.08763597f, 0.01865362f, -0.20531459f, 0.09835164f, -0.03110467f, 
    -0.01688225f, -0.05703090f, 0.00828729f, -0.04072889f, 0.01084826f, 0.02722943f, -0.03489603f, -0.02512618f, 
    0.01978536f, 0.03399450f, 0.03568618f, 0.04826697f, 0.01507993f, 0.01633590f, 0.02864973f, 0.00296602f, 
    0.01658038f, -0.06396274f, 0.03004410f, 0.01837017f, -0.06227147f, -0.01127684f, -0.06016791f, 0.01289876f, 
    0.00377049f, -0.04480474f, 0.01619175f, -0.01091231f, -0.06002492f, -0.04172487f, -0.06305029f, -0.06441034f, 
    0.02110969f, -0.03533899f, -0.02297214f, 0.02997757f, -0.02853785f, -0.04735705f, -0.02978502f, -0.05616472f, 
    0.00834806f, -0.05319936f, -0.02209993f, 0.01517090f, 0.04314725f, 0.00299785f, -0.03182286f, -0.01888941f, 
    -0.01895053f, -0.01528137f, 0.00101119f, -0.01722560f, -0.01909352f, 0.00475200f, -0.02094459f, 0.01820869f, 
    -0.02808245f, -0.04221090f, -0.00294735f, -0.06910940f, -0.02018775f, -0.04759251f, 0.01753342f, 0.01196301f, 
    0.03762072f, -0.01578912f, 0.02566991f, 0.03272607f, -0.01226148f, -0.03818738f, 0.02526012f, -0.04784980f, 
    -0.03457780f, 0.01472892f, -0.04616039f, 0.04575415f, 0.03300430f, 0.00927207f, -0.00777538f, 0.04515911f, 
    -0.01877769f, -0.05852515f, 0.04487943f, -0.03133352f, -0.06162189f, -0.01806617f, -0.05575569f, 0.00102558f, 
    0.01430837f, -0.00026364f, 0.04803595f, 0.03633408f, 0.04119454f, -0.04028087f, 0.04028862f, 0.04205487f, 
    0.02890185f, 0.01424625f, -0.01245446f, 0.01426650f, 0.01183585f, -0.03032669f, 0.00887801f, -0.01516512f, 
    0.02486557f, -0.05098912f, -0.02481941f, 0.02694079f, -0.02181457f, -0.00394940f, 0.00050340f, -0.04535159f, 
    -0.06892329f, 0.02723271f, -0.06811002f, 0.01281812f, -0.00435385f, -0.03300632f, -0.04293046f, -0.03606504f, 
    0.02197831f, -0.06827337f, -0.01064165f, 0.04528157f, -0.03422957f, -0.01703695f, -0.01929533f, 0.04124587f, 
    0.04654826f, -0.06372576f, 0.01751583f, 0.02598689f, -0.06482580f, 0.04922426f, -0.01021963f, -0.00095621f, 
    -0.02005658f, -0.01709800f, -0.02377374f, 0.02922435f, -0.04265189f, -0.02324379f, -0.03392883f, 0.02016961f, 
    -0.00333269f, -0.04976320f, -0.06183285f, 0.01970360f, -0.06032460f, -0.00219831f, -0.06060157f, 0.04408193f, 
    -0.00608879f, 0.03310182f, 0.01617422f, -0.04708461f, -0.02780490f, 0.02951704f, -0.00735479f, -0.05234026f, 
    -0.06541152f, -0.02162826f, 0.00062753f, -0.05104245f, -0.03787702f, -0.03234041f, 0.03365848f, -0.02250387f, 
    0.03604310f, 0.03780682f, -0.01436391f, 0.00312719f, 0.00494733f, 0.02963065f, 0.04173679f, -0.01144917f, 
    -0.04580078f, 0.04137195f, -0.05414105f, -0.03323137f, -0.01912857f, -0.04998455f, -0.04786140f, -0.06202931f, 
    0.02915671f, 0.03385780f, 0.02325729f, 0.00705032f, -0.04474139f, 0.03156172f, 0.00334197f, -0.03833760f, 
    -0.05031544f, 0.03462747f, 0.00032313f, 0.01031030f, 0.02879492f, -0.02186067f, -0.00688798f, 0.01371250f, 
    -0.05109465f, 0.03127670f, -0.02436545f, 0.04485045f, 0.01373519f, -0.06284062f, 0.02751768f, -0.04597672f, 
    -0.04621179f, 0.01996923f, 0.02445800f, -0.03224813f, -0.06179014f, 0.02334683f, 0.01166182f, 0.01460090f, 
    0.01258210f, -0.01306972f, -0.03797550f, -0.06027218f, -0.00862904f, 0.01171077f, -0.04863407f, 0.01995648f, 
    0.00825959f, -0.05313738f, 0.02155079f, 0.02022847f, -0.06072992f, 0.04213942f, 0.01034811f, -0.02817177f, 
    0.02251449f, -0.06077462f, -0.05276358f, -0.02578848f, -0.05026828f, -0.06463657f, 0.02424123f, 0.01171069f, 
    -0.00299372f, -0.02233331f, 0.01413895f, 0.01413378f, 0.01150659f, 0.01210493f, -0.05369435f, -0.05543473f, 
    -0.03485904f, -0.01667135f, -0.05418994f, -0.02486544f, 0.03596347f, 0.03958681f, 0.00638073f, 0.03068125f, 
    -0.02169860f, 0.04688768f, 0.03458053f, 0.00310590f, 0.02173339f, 0.03837580f, -0.04379657f, 0.00007052f, 
    0.04220556f, -0.05566144f, 0.04322306f, 0.03430655f, -0.03795104f, -0.01836549f, -0.05377610f, -0.01417926f, 
    -0.01886421f, 0.04264602f, -0.03410009f, 0.02058984f, 0.01743121f, -0.01529660f, -0.06166886f, -0.02015165f, 
    0.02108308f, 0.02830989f, 0.00056295f, 0.03044066f, 0.00556670f, 0.04732116f, -0.05512274f, 0.03832317f, 
    0.02903724f, 0.00401653f, 0.30099943f, 0.05906907f, -0.07028376f, -0.09413958f, 0.09198327f, 0.10776176f, 
    -0.02358535f, 0.33494693f, 0.26432386f, -0.07810241f, 0.06319210f, -0.09329160f, -0.04796211f, -0.00224934f, 
    0.07668327f, 0.19298528f, 0.18672705f, -0.05965215f, -0.03330842f, 0.08039655f, 0.01303329f, -0.03867821f, 
    0.00155622f, 0.01347972f, 0.05373617f, -0.38493773f, 0.02972676f, 0.03578736f, 0.10693970f, -0.02503101f, 
    -0.07721665f, -0.08032610f, -0.03588333f, -0.05852196f, 0.08228650f, 0.17936419f, -0.02250442f, -0.02398249f, 
    0.01182616f, -0.16307794f, 0.03286441f, 0.04985093f, 0.08301224f, 0.30320594f, 0.10018338f, 0.14448576f, 
    -0.13795529f, -0.10976140f, -0.14456193f, 0.03938636f, 0.08627941f, 0.01125504f, -0.11018865f, 0.17369600f, 
    0.03172287f, -0.06775571f, 0.18535349f, -0.19181287f, 0.10768118f, 0.02294528f, 0.05488926f, -0.14538909f, 
    0.08790509f, -0.17605966f, 0.12583053f, -0.06896869f, -0.07130314f, -0.03517186f, -0.01939502f, -0.00003925f, 
    0.09344956f, -0.06467972f, 0.06305268f, 0.07683851f, 0.07941376f, 0.04869521f, 0.03707098f, -0.17476058f, 
    0.06990750f, -0.21542369f, -0.22526713f, -0.06736158f, -0.03376746f, 0.10261386f, 0.01354814f, 0.05061916f, 
    0.05934954f, 0.00068346f, -0.19790661f, -0.10399012f, 0.12742047f, 0.07906793f, 0.11888152f, -0.07514545f, 
    -0.07901884f, -0.09377644f, -0.10712564f, -0.07752813f, -0.22350214f, -0.29630309f, 0.22324760f, 0.00602533f, 
    0.04587787f, 0.02711907f, -0.18948619f, -0.10717059f, -0.08123692f, -0.11767690f, -0.15164474f, 0.21195862f, 
    0.14915219f, 0.01374684f, 0.10295541f, -0.14921005f, 0.00728875f, -0.18866228f, 0.01535187f, 0.21975893f, 
    -0.04231127f, -0.00830311f, 0.04309566f, 0.08822066f, 0.03867916f, -0.07729130f, -0.03488195f, -0.18256114f, 
    0.16940109f, -0.03641021f, 0.11407830f, 0.02668371f, -0.15154071f, -0.01864679f, -0.04205084f, -0.35709050f, 
    -0.25915867f, 0.09463271f, 0.02532531f, 0.00785801f, -0.04968606f, -0.16698498f, 0.05637804f, -0.07164109f, 
    -0.47908396f, 0.06569816f, -0.09752202f, 0.16104715f, 0.05324064f, -0.02925323f, 0.02814119f, -0.06932118f, 
    0.12177241f, 0.15481351f, -0.31051019f, -0.04094899f, 0.03005498f, 0.10990840f, -0.00940997f, -0.03766769f, 
    -0.12277544f, -0.05624665f, 0.05103606f, 0.10788570f, -0.36178732f, 0.14190294f, 0.03675596f, 0.05752794f, 
    0.01463019f, 0.06954288f, -0.12583743f, 0.27827206f, -0.09546136f, -0.06440107f, -0.12905258f, 0.29544818f, 
    0.11220862f, -0.06430906f, -0.13870668f, 0.10566708f, -0.21822216f, -0.25780651f, 0.17377825f, 0.22263539f, 
    -0.02063904f, -0.08152484f, -0.04533345f, -0.13907850f, -0.00101534f, -0.01625252f, 0.16369578f, -0.13305901f, 
    -0.10721114f, -0.04007930f, 0.10635483f, -0.02107227f, 0.08409443f, 0.07810790f, 0.39955336f, 0.17783785f, 
    0.04113810f, 0.02729878f, 0.17478362f, 0.06398671f, -0.01008289f, -0.06109031f, 0.01189896f, -0.01971573f, 
    -0.10090480f, -0.25562066f, 0.00355648f, 0.01296989f, 0.08626034f, -0.11923365f, 0.14851128f, -0.02196032f, 
    0.42072621f, 0.13006964f, -0.18076888f, 0.04946706f, 0.06433659f, 0.12690248f, 0.20791729f, 0.08440010f, 
    -0.15788591f, -0.00324613f, 0.11589948f, -0.14313915f, -0.10575169f, -0.03333762f, -0.08389094f, -0.05842730f, 
    -0.03179236f, -0.01492067f, -0.05502322f, -0.00101537f, -0.13095288f, 0.12313733f, 0.15733248f, 0.08095355f, 
    0.01015615f, 0.08611105f, 0.00484218f, 0.24627398f, 0.22295789f, 0.13901035f, 0.12031478f, 0.09021031f, 
    0.06497982f, -0.01744055f, 0.03992634f, 0.03172358f, -0.24374503f, -0.08291034f, 0.01904426f, -0.02639039f, 
    -0.11839940f, 0.03530109f, 0.07383229f, -0.13978314f, 0.09137329f, 0.45338380f, 0.12437753f, 0.05603834f, 
    -0.06224136f, 0.09992680f, 0.19715755f, 0.11465412f, -0.01658504f, 0.10912788f, -0.08348072f, 0.08200555f, 
    -0.18669966f, -0.00873919f, 0.00173493f, -0.02281501f, -0.07152852f, -0.03745109f, -0.07379601f, -0.57203978f, 
    -0.07002063f, -0.07045726f, 0.00658089f, 0.06254540f, -0.03216704f, -0.05802281f, -0.03088048f, -0.09913774f, 
    -0.41511163f, -0.41126540f, -0.33161166f, -0.06387502f, 0.05115940f, -0.12821808f, -0.09666187f, 0.06887114f, 
    0.00042578f, 0.11314154f, 0.10085995f, -0.06172060f, -0.14656542f, 0.14625405f, 0.06058343f, -0.07787624f, 
    0.06349365f, 0.00141957f, -0.02095597f, 0.17503983f, 0.21947849f, -0.05355176f, -0.07000025f, -0.09959216f, 
    0.14017433f, 0.10484546f, 0.09402196f, -0.47099918f, -0.14527816f, 0.01409630f, -0.15727712f, 0.13983922f, 
    -0.15023039f, -0.18675196f, 0.09076795f, -0.14859599f, -0.36723348f, 0.14372142f, 0.08698987f, -0.22728042f, 
    -0.23140226f, -0.10801511f, -0.02704212f, 0.05169204f, 0.06878860f, 0.17653485f, 0.13436705f, -0.08159471f, 
    -0.14048125f, 0.08155651f, 0.01283299f, -0.07724693f, 0.12438690f, -0.02559706f, -0.05268565f, -0.20611714f, 
    0.18111908f, 0.08424285f, -0.06927365f, 0.07454045f, -0.05385673f, 0.07689437f, -0.02886532f, -0.27928379f, 
    0.14164595f, 0.05564565f, -0.07199225f, -0.02127443f, -0.09180143f, 0.03520732f, -0.00093943f, 0.03795001f, 
    -0.05755685f, 0.06160385f, 0.00985558f, 0.02928628f, 0.10570043f, -0.06841264f, 0.14460647f, 0.10285203f, 
    0.06104771f, 0.12701441f, -0.20230670f, -0.05187866f, 0.06835449f, 0.07474646f, 0.03016157f, 0.02268970f, 
    0.02289405f, -0.01153015f, 0.46503615f, 0.06642391f, -0.23722416f, 0.14592335f, -0.02987356f, -0.02260321f, 
    0.06715851f, 0.01072317f, -0.02323344f, 0.08926807f, 0.07054599f, -0.38841704f, 0.18465413f, 0.03156601f, 
    0.06480066f, 0.01418909f, -0.04525285f, -0.07730238f, 0.23682840f, -0.19649579f, -0.35571393f, 0.19196837f, 
    0.06609166f, 0.00371804f, 0.03345035f, -0.08772941f, -0.12361085f, -0.13331535f, -0.07509909f, -0.21313496f, 
    0.08412844f, -0.00634631f, -0.08133093f, 0.03550638f, 0.14220531f, 0.12127382f, 0.34777987f, -0.06637690f, 
    -0.08700617f, 0.16693744f, 0.03328930f, -0.13154526f, -0.01418546f, 0.09143164f, -0.08141692f, 0.37883493f, 
    0.21399792f, -0.00299232f, 0.12050147f, 0.01221050f, 0.00438014f, 0.08867473f, -0.10858772f, 0.01646947f, 
    -0.31991503f, -0.15212195f, 0.08401667f, -0.02205889f, 0.02293901f, -0.08843547f, -0.09696371f, 0.06401347f, 
    -0.04925708f, 0.13617025f, 0.32293925f, 0.15140483f, -0.03832641f, -0.01762475f, -0.04271631f, 0.01377743f, 
    0.00276206f, -0.00576301f, -0.28582308f, 0.09921327f, 0.02060585f, -0.09810598f, 0.04924364f, 0.00563210f, 
    0.08256101f, 0.04382054f, -0.02874452f, -0.11739167f, -0.10896395f, -0.06365511f, -0.05969628f, 0.09345191f, 
    0.11606497f, 0.10390000f, -0.03565933f, 0.07575492f, 0.13441685f, -0.02327074f, -0.08011563f, 0.12030490f, 
    0.01623426f, 0.04574135f, 0.18478510f, 0.08842941f, 0.09492370f, -0.12701494f, -0.24570052f, 0.05555091f, 
    -0.04533688f, 0.01575263f, -0.03456227f, 0.12591676f, 0.13789323f, 0.01812177f, 0.24738380f, 0.07985742f, 
    0.09179406f, -0.12837972f, -0.05670920f, 0.14808649f, 0.02942726f, 0.21301007f, -0.04306234f, -0.53913373f, 
    -0.15650570f, -0.00559886f, 0.03705981f, 0.06736057f, -0.07487261f, 0.15792988f, -0.04400064f, -0.11734664f, 
    0.25972977f, 0.02613105f, 0.00404787f, -0.23722735f, 0.06913622f, -0.06207410f, -0.26371455f, 0.05173434f, 
    -0.00855957f, -0.07131477f, -0.02458529f, -0.11827912f, -0.03657828f, 0.12952331f, -0.08643601f, 0.05894902f, 
    0.00460048f, -0.01185651f, 0.11994515f, 0.08413427f, 0.12313456f, -0.03805413f, -0.09566923f, 0.02423784f, 
    0.04966359f, 0.12883618f, -0.03252636f, 0.04887997f, 0.02567563f, -0.11139062f, 0.03669922f, 0.10258175f, 
    0.12512299f, -0.18709791f, 0.02384280f, 0.03282440f, 0.01837806f, -0.13080885f, -0.05991003f, -0.10713642f, 
    -0.12237166f, 0.01776076f, -0.03807982f, -0.00272984f, 0.12997416f, 0.25210211f, 0.10272045f, 0.20029688f, 
    -0.08604455f, -0.04303798f, -0.02067695f, -0.02852338f, -0.07198647f, -0.01031106f, -0.16895410f, -0.22696896f, 
    0.02906317f, -0.11159126f, 0.02602897f, 0.04307109f, 0.04994123f, -0.03511570f, 0.05067322f, -0.08993917f, 
    0.27146924f, 0.51301390f, -0.01514451f, -0.01058685f, -0.00438117f, 0.07033580f, 0.09132486f, 0.04605646f, 
    -0.05683326f, -0.28007179f, -0.05280470f, 0.03222497f, -0.11684660f, 0.04245639f, 0.02462423f, 0.00841983f, 
    -0.08013791f, -0.33949855f, -0.60689795f, -0.01089678f, 0.03912819f, -0.07465605f, 0.06280496f, -0.17612229f, 
    0.05027332f, 0.03990933f, 0.19846345f, -0.00876241f, -0.09605544f, 0.01888371f, -0.16374233f, 0.09775105f, 
    -0.11084919f, 0.04222605f, 0.07568815f, 0.29447448f, 0.35570112f, -0.09283867f, 0.05733137f, 0.22801894f, 
    0.14551575f, -0.07556551f, -0.07848158f, 0.13560311f, 0.19446841f, 0.24133439f, -0.02042713f, -0.10402321f, 
    0.08547166f, 0.04318308f, -0.17535745f, -0.07835229f, -0.07398208f, -0.47223023f, -0.21125984f, -0.01145771f, 
    0.05749577f, 0.13129461f, 0.10946933f, -0.11444806f, -0.02311019f, 0.07247123f, -0.00691604f, 0.07462591f, 
    0.02794058f, -0.07346322f, -0.07401711f, -0.02337013f, -0.01158875f, -0.03108552f, -0.06633165f, 0.06438968f, 
    0.01702912f, -0.18641965f, 0.03576024f, -0.02704990f, 0.11032920f, -0.10099268f, 0.09253930f, -0.00743132f, 
    -0.35082605f, -0.00312855f, 0.12347105f, -0.00067237f, -0.00339961f, 0.05449944f, 0.11717792f, -0.00551659f, 
    -0.02595646f, 0.16710773f, 0.21055008f, 0.07097646f, 0.02299531f, -0.06803396f, -0.03308745f, -0.00472121f, 
    0.18389902f, 0.11805607f, -0.10690901f, 0.09113363f, -0.01432102f, -0.02608230f, -0.01640128f, 0.03726629f, 
    -0.00248432f, 0.07933990f, -0.02586350f, -0.01303536f, -0.00380069f, 0.14008670f, -0.09366007f, 0.11701842f, 
    0.05299762f, -0.07903951f, -0.00108847f, -0.03561120f, 0.06875946f, -0.00878279f, 0.03706242f, 0.06337526f, 
    0.03058740f, -0.08828678f, 0.00818818f, 0.22789143f, -0.01792505f, 0.04068859f, 0.01036976f, -0.02662646f, 
    -0.15115403f, 0.08079812f, 0.20561694f, -0.02927712f, 0.09184052f, -0.06708182f, 0.10668956f, 0.00107131f, 
    0.19699062f, 0.12891121f, -0.17994396f, 0.33404347f, 0.05439140f, -0.13448656f, 0.13429850f, -0.11636276f, 
    0.07885853f, 0.12089783f, 0.09397955f, -0.07747873f, 0.07025501f, 0.03290010f, 0.08180850f, 0.01166696f, 
    -0.15404287f, 0.04111024f, -0.10924777f, -0.14873980f, -0.04701318f, -0.18866898f, -0.04496858f, -0.02304329f, 
    0.07385003f, -0.07451978f, -0.01266694f, 0.15820205f, 0.11070657f, -0.17117813f, -0.00322367f, 0.05501486f, 
    0.08703313f, -0.10003265f, 0.12135604f, 0.23870665f, -0.05124806f, -0.09530201f, -0.07102684f, -0.02882288f, 
    0.08303805f, -0.09529345f, -0.10471568f, 0.04416088f, 0.04818153f, 0.00988598f, -0.12804934f, 0.02481307f, 
    -0.03920861f, 0.02598403f, -0.02091765f, -0.08897913f, -0.05259729f, 0.13835435f, -0.19923641f, 0.02454069f, 
    0.03436452f, -0.12340040f, 0.00964862f, 0.14817369f, 0.04496608f, 0.02540161f, 0.29927233f, -0.00010704f, 
    0.11390452f, -0.06592907f, -0.11076757f, -0.02019912f, -0.06567511f, -0.14460048f, -0.11334210f, -0.52726901f, 
    -0.04689902f, 0.00440163f, 0.12198322f, 0.06555955f, -0.04176958f, -0.03250220f, -0.11348604f, 0.00187344f, 
    0.22732173f, 0.08427195f, 0.03181580f, -0.05075900f, -0.18223590f, -0.16909599f, -0.10474176f, -0.02140093f, 
    0.10888399f, -0.16624740f, 0.08224434f, 0.08162947f, 0.01680880f, 0.13302951f, 0.23666212f, -0.06034316f, 
    0.13832846f, -0.14530031f, 0.06997697f, 0.11451989f, -0.00675636f, 0.08104330f, -0.12061077f, -0.19240928f, 
    0.03288981f, 0.06505314f, -0.05646980f, -0.06918718f, 0.11074790f, 0.04848396f, -0.02386858f, -0.00355851f, 
    -0.10940792f, -0.11379701f, -0.20276472f, -0.04048936f, -0.18651196f, -0.01047124f, -0.07599095f, 0.01042046f, 
    -0.03949491f, 0.01101792f, 0.00231699f, 0.04708659f, 0.52178556f, -0.08713810f, 0.10753223f, 0.01960440f, 
    0.11094543f, 0.07764611f, -0.27904496f, -0.08363217f, 0.12107287f, -0.29245186f, -0.21359150f, 0.03565460f, 
    0.02526062f, -0.01011856f, 0.04699370f, 0.02197941f, 0.07031494f, 0.00309445f, -0.11730117f, -0.00020443f, 
    0.18235980f, 0.03486620f, -0.05159565f, 0.02513667f, 0.12135985f, 0.01483676f, -0.01564941f, 0.04890405f, 
    0.18539153f, 0.17327824f, -0.05022351f, 0.08648494f, 0.06175433f, -0.03219811f, -0.05908418f, 0.17165023f, 
    -0.01010368f, -0.13029709f, -0.07328948f, -0.03714886f, 0.01821924f, 0.01979866f, 0.13788310f, -0.04157477f, 
    0.08773042f, 0.02076605f, -0.17333202f, -0.12694310f, 0.06835524f, 0.19027242f, -0.03257765f, 0.04179031f, 
    0.03195036f, -0.02664643f, 0.16042612f, 0.07029010f, 0.03917984f, -0.08983449f, -0.01563984f, -0.10725929f, 
    0.06088541f, 0.13001704f, 0.09687502f, -0.56176090f, 0.12067822f, -0.06526369f, -0.02909742f, -0.06453507f, 
    -0.20259497f, 0.05422936f, -0.06829448f, -0.15657459f, -0.16168360f, 0.08062434f, -0.41158909f, -0.08055486f, 
    0.18413909f, -0.08802485f, -0.18986109f, 0.03588377f, 0.06262051f, -0.06280904f, 0.07714680f, 0.13119374f, 
    0.03553845f, 0.06412455f, -0.02035258f, 0.09482783f, -0.00731098f, 0.05321673f, -0.14248382f, -0.42075089f, 
    -0.05968913f, 0.05656039f, -0.05349018f, -0.00689158f, 0.19673082f, -0.09308206f, -0.03116951f, -0.22944550f, 
    0.20488961f, 0.07329513f, -0.05551857f, -0.08048444f, 0.01299400f, 0.03476879f, 0.23181555f, 0.02551433f, 
    0.36166263f, 0.05387232f, 0.12036245f, -0.17762795f, -0.06827966f, 0.02781495f, -0.00847088f, 0.14775008f, 
    -0.06831024f, -0.07141966f, -0.10230588f, -0.08157866f, -0.02345373f, -0.03835943f, -0.04032876f, 0.03819928f, 
    0.17752586f, -0.22608823f, 0.09397122f, -0.08848751f, 0.14719182f, 0.02126046f, -0.11891095f, -0.03407111f, 
    -0.09294673f, 0.06103550f, -0.14274538f, -0.13767447f, -0.28455338f, 0.01186383f, -0.08079307f, -0.07881656f, 
    0.00321016f, 0.00426597f, -0.02227720f, 0.00680065f, -0.04001908f, 0.00301241f, 0.39025956f, -0.29788235f, 
    0.01854368f, -0.05323485f, -0.12984563f, 0.17461802f, 0.04712564f, -0.00763190f, -0.00789152f, -0.19163376f, 
    -0.05221014f, 0.05530582f, -0.04271064f, -0.20331998f, -0.08322702f, -0.06833382f, -0.14433096f, 0.07938837f, 
    -0.14991276f, -0.03413646f, 0.09478384f, -0.13153394f, 0.15039821f, 0.10880098f, -0.14388214f, -0.05272388f, 
    -0.03264774f, 0.02914921f, -0.12254716f, -0.12423395f, -0.00741325f, 0.06689376f, -0.05355873f, -0.14817704f, 
    0.18179747f, -0.14301355f, 0.19461459f, -0.03303726f, -0.05172576f, -0.09752570f, -0.09592972f, 0.06223686f, 
    0.16673352f, 0.24065986f, 0.18261008f, -0.04278419f, 0.07315478f, -0.09202895f, -0.10163470f, 0.09980842f, 
    0.03331432f, 0.06012562f, -0.25290412f, 0.41924065f, -0.01577787f, 0.13361047f, 0.07131897f, 0.09588178f, 
    -0.02479143f, -0.06516778f, 0.02037928f, 0.17489477f, -0.02819629f, -0.31745094f, -0.06935513f, 0.17367098f, 
    0.29420164f, 0.12156031f, -0.03773225f, -0.05144715f, 0.13416567f, 0.20062423f, 0.02473938f, 0.12739234f, 
    -0.12502594f, -0.09489335f, -0.04456647f, 0.02917028f, 0.07314993f, -0.33703691f, -0.05570781f, -0.21886148f, 
    0.12185332f, 0.07475273f, 0.02989981f, 0.08235881f, 0.02984906f, -0.04857788f, 0.03509274f, 0.07946692f, 
    0.06081538f, 0.15763569f, 0.16323225f, 0.06103942f, 0.04075124f, -0.04147431f, 0.12982169f, -0.36246327f, 
    -0.22664589f, 0.11625320f, -0.04707179f, -0.04394827f, 0.11047167f, 0.09372286f, -0.00499998f, 0.09317347f, 
    0.07162751f, -0.00670593f, -0.04719925f, 0.01411445f, 0.05131961f, 0.14039072f, 0.12917595f, 0.06631549f, 
    0.02760063f, -0.35841736f, -0.11575057f, 0.06971107f, -0.16658266f, 0.03010688f, -0.08282536f, 0.10435592f, 
    0.11610336f, 0.01742405f, 0.06987559f, -0.26668343f, 0.10128222f, 0.08998877f, 0.10643383f, 0.07236192f, 
    0.22176045f, -0.20816833f, -0.05300490f, 0.15241210f, 0.21221796f, 0.19881843f, 0.01804166f, 0.02043718f, 
    -0.04211877f, 0.02508450f, 0.04323273f, 0.03328514f, -0.14200366f, -0.07770015f, -0.74225336f, 0.12656190f, 
    0.16548616f, -0.05710759f, 0.15350252f, 0.21199222f, 0.18060072f, 0.04323918f, 0.08775240f, 0.10343470f, 
    0.20905384f, -0.01012580f, -0.12252013f, -0.02071895f, 0.07354659f, -0.01148599f, -0.28813788f, 0.12512097f, 
    0.03666630f, 0.09513891f, 0.07825785f, 0.16491523f, 0.04041097f, 0.04455310f, 0.07200056f, -0.08489809f, 
    -0.44147560f, -0.07234779f, 0.04094974f, 0.01964303f, -0.02879534f, -0.00537886f, -0.07601961f, 0.02389886f, 
    -0.15765223f, -0.61733282f, -0.21506146f, -0.02505185f, -0.22645344f, -0.17963120f, 0.13222814f, 0.09225000f, 
    -0.08445987f, -0.48745149f, -0.28568542f, 0.08530071f, 0.16624986f, 0.09869814f, 0.00347330f, -0.06275596f, 
    0.11668474f, -0.08944729f, -0.48860970f, 0.14716847f, -0.19376312f, 0.00700150f, 0.05437107f, 0.00568298f, 
    -0.02310707f, 0.04127672f, 0.06691299f, 0.00860869f, -0.01373176f, -0.08595628f, 0.12580577f, 0.08985737f, 
    -0.12247731f, -0.09071315f, 0.00043551f, -0.07817040f, -0.18866292f, 0.03893416f, 0.29008144f, 0.08902951f, 
    0.06564983f, 0.10013850f, -0.03753383f, -0.00474464f, 0.13382766f, -0.41195500f, -0.60227078f, -0.12437523f, 
    0.13759282f, 0.07715934f, -0.09492458f, 0.01248873f, 0.04557806f, 0.04122369f, -0.15559338f, 0.04616763f, 
    0.04849545f, 0.20805010f, -0.01731254f, -0.02220501f, -0.07701620f, -0.06466356f, -0.03845518f, 0.08172268f, 
    -0.00207358f, 0.00760146f, 0.00848644f, 0.02521570f, -0.04981331f, -0.07034983f, 0.10187602f, 0.00228828f, 
    -0.27075085f, -0.16379538f, 0.04073031f, -0.00158518f, 0.13892113f, 0.03573623f, -0.08841594f, -0.07264301f, 
    0.02424014f, 0.07002573f, 0.11122451f, 0.08566692f, -0.01280412f, 0.08550152f, -0.11859789f, 0.10715099f, 
    0.03452373f, -0.03599592f, -0.04617076f, 0.05055062f, -0.08203688f, 0.08342119f, 0.02116606f, -0.06679689f, 
    -0.02537857f, 0.04989253f, 0.06037519f, -0.00537397f, 0.07044359f, -0.17182735f, -0.04001923f, 0.05242137f, 
    -0.02906693f, 0.20334823f, 0.21287507f, 0.04806366f, 0.09632874f, 0.14774770f, 0.01688707f, 0.06656370f, 
    -0.01462145f, -0.08477002f, -0.15755124f, 0.07863365f, 0.06532455f, -0.13725017f, -0.20623665f, -0.08723165f, 
    0.14683740f, -0.01694653f, 0.00577428f, 0.04008306f, 0.12459361f, -0.00367048f, 0.07356687f, -0.12101607f, 
    -0.11899899f, 0.08330803f, -0.15880409f, -0.12460985f, -0.01589762f, 0.02736837f, -0.18078271f, 0.06912878f, 
    0.07276680f, -0.08386073f, 0.11487354f, -0.00285563f, -0.04138354f, 0.12494067f, 0.02882023f, 0.04772489f, 
    -0.13649063f, 0.15921663f, 0.02425307f, -0.01385544f, -0.04499336f, -0.07997806f, -0.02046019f, -0.00598784f, 
    0.17792296f, -0.34613594f, 0.10057202f, -0.07130788f, -0.00609962f, -0.01755155f, -0.12674761f, 0.09899224f, 
    -0.05254764f, 0.00157838f, 0.08440848f, 0.13048263f, 0.02308468f, 0.12415981f, 0.08528109f, 0.12995166f, 
    0.03102034f, -0.02298568f, -0.05546689f, -0.17909856f, -0.09304098f, -0.02328918f, 0.08497290f, -0.00445210f, 
    -0.12496755f, 0.07241958f, 0.00258433f, 0.06603982f, -0.12403844f, 0.04195861f, -0.18243910f, 0.03663337f, 
    0.09450662f, -0.22867166f, 0.20154658f, 0.20855984f, 0.23663469f, -0.08435357f, 0.03196312f, 0.22131476f, 
    -0.03636061f, 0.05424232f, -0.02095203f, -0.04010188f, -0.08122829f, -0.12123671f, -0.34700486f, -0.03239173f, 
    0.09795000f, 0.11816117f, 0.09784602f, 0.09665263f, -0.16188641f, 0.13097200f, -0.11524899f, 0.15461195f, 
    0.22389133f, 0.16020446f, 0.09279563f, -0.02422309f, 0.11326891f, 0.00609906f, -0.03626379f, -0.05348759f, 
    0.03402686f, -0.11150958f, 0.02373954f, 0.12997234f, 0.03650220f, -0.11399581f, -0.09535679f, 0.04950470f, 
    0.15737316f, 0.03301572f, -0.01700560f, 0.17451088f, 0.09547929f, 0.00359880f, -0.10178334f, -0.17997730f, 
    0.07012679f, 0.00347890f, 0.04172389f, 0.08720768f, -0.03978518f, 0.10426246f, 0.07825492f, -0.07294909f, 
    0.03149922f, 0.06677544f, -0.11740252f, -0.24683094f, -0.33268785f, 0.03822479f, 0.09800298f, -0.04302761f, 
    0.01458017f, 0.01478689f, -0.00389683f, 0.18207800f, 0.19241077f, -0.02469433f, -0.07302735f, 0.13376750f, 
    -0.08878330f, 0.07546930f, -0.07240042f, 0.16962394f, 0.20904222f, -0.52750188f, -0.57179630f, -0.08041865f, 
    0.04655328f, -0.05960212f, 0.01195830f, -0.00644966f, 0.07025415f, 0.08564410f, -0.14221144f, 0.10049731f, 
    0.18208830f, 0.16102819f, -0.10501289f, -0.00906469f, -0.00620282f, 0.02256266f, 0.03579536f, -0.05926585f, 
    -0.04671069f, -0.14819477f, 0.02197823f, 0.03795529f, -0.13774961f, -0.00277345f, 0.23949167f, 0.09123265f, 
    -0.02499078f, -0.02190992f, 0.00046866f, -0.03572002f, -0.03983890f, -0.01325291f, -0.04566508f, 0.00694321f, 
    0.03858233f, 0.05029213f, -0.04972178f, -0.03887161f, -0.02197063f, -0.05225716f, -0.04962036f, 0.04475467f, 
    -0.04920101f, 0.03282227f, -0.02545556f, 0.00911655f, -0.00168036f, -0.00754498f, 0.01221842f, 0.01101007f, 
    -0.06529170f, 0.04136120f, -0.03701061f, -0.04400415f, -0.05665256f, -0.03183062f, 0.05670457f, 0.05237187f, 
    -0.01658331f, -0.03199833f, 0.04920958f, -0.03961950f, -0.01420034f, -0.02341032f, -0.01771048f, 0.01476624f, 
    0.01382959f, -0.00688574f, -0.05977563f, 0.01399018f, 0.02115073f, -0.06137891f, -0.02452633f, -0.00000839f, 
    -0.04470274f, -0.04337429f, 0.00776197f, 0.00495607f, 0.03246819f, -0.04229306f, -0.04987861f, -0.04755788f, 
    -0.06393300f, 0.01800292f, 0.00809639f, 0.03327773f, -0.04731469f, -0.00291752f, 0.00500257f, 0.01134272f, 
    -0.02140906f, 0.00613177f, 0.00360357f, -0.03237629f, 0.03149398f, -0.06080035f, -0.04023783f, -0.00678682f, 
    0.00323758f, -0.06208948f, -0.00410529f, -0.01259406f, -0.05365779f, -0.03078028f, -0.03698425f, 0.03245802f, 
    -0.04280395f, 0.03751585f, 0.05043095f, 0.04729467f, -0.02499328f, -0.05776338f, -0.04150609f, 0.03179831f, 
    0.05295976f, -0.04032163f, -0.01149648f, 0.04294157f, 0.01704509f, 0.03624463f, 0.02844970f, 0.01975052f, 
    -0.05838665f, 0.00826143f, -0.05987053f, -0.02935577f, -0.04764859f, -0.02916378f, 0.03515440f, -0.04699370f, 
    -0.04739977f, -0.03130382f, -0.04080447f, -0.04303332f, -0.02590339f, 0.00342013f, -0.03956943f, 0.03281081f, 
    0.00018400f, 0.05031728f, 0.03010079f, -0.00281632f, -0.01803855f, -0.05812000f, 0.03982889f, -0.03105129f, 
    0.04956010f, 0.04303228f, 0.00836596f, -0.00231834f, -0.05885400f, -0.02536171f, 0.02185257f, -0.02819701f, 
    0.03079158f, 0.00972951f, -0.05237059f, 0.03296099f, 0.04922758f, 0.01562452f, 0.03911830f, -0.01440663f, 
    0.03674398f, -0.00269944f, -0.02899382f, 0.04146722f, 0.01110972f, 0.00099934f, -0.05856025f, -0.03501493f, 
    -0.02698593f, 0.04758815f, -0.00170969f, 0.02254423f, -0.01875549f, 0.04281133f, -0.06687787f, -0.06522705f, 
    0.02781699f, -0.04293553f, 0.03962433f, -0.03786730f, 0.04123326f, -0.03902381f, 0.04998494f, -0.01683393f, 
    -0.05056927f, -0.06018082f, 0.00507854f, 0.04123854f, 0.03309217f, -0.01595967f, 0.03704379f, -0.05495388f, 
    -0.02537351f, 0.02361660f, -0.05404215f, -0.03170361f, -0.02057958f, -0.01786219f, 0.01048869f, 0.01952980f, 
    -0.01835484f, -0.01290959f, 0.05175147f, -0.03172412f, 0.02511689f, -0.01933123f, -0.00365934f, -0.01038908f, 
    -0.03792838f, -0.06415830f, 0.04020898f, 0.02656819f, -0.00958227f, -0.03753632f, -0.05643438f, 0.02449010f, 
    0.05122283f, -0.03652740f, -0.04893967f, -0.00709646f, -0.03766401f, -0.04857554f, 0.04128193f, 0.04373170f, 
    0.02004096f, 0.01443277f, 0.02179791f, -0.00212653f, -0.05978172f, -0.02597502f, 0.03359391f, 0.02840798f, 
    -0.01963081f, -0.01230818f, -0.05354381f, -0.04866651f, -0.01806718f, -0.00574547f, 0.04844713f, 0.00078919f, 
    -0.01705275f, 0.00179001f, -0.02889476f, 0.01396549f, -0.00065085f, -0.05199393f, 0.03770810f, 0.06203186f, 
    0.05021884f, -0.01658597f, -0.02397103f, 0.03925990f, -0.06195132f, -0.01244704f, -0.02647271f, 0.04842455f, 
    0.01139700f, -0.03674985f, -0.03318425f, 0.02222741f, 0.00312082f, -0.00676363f, -0.04528793f, 0.03675355f, 
    0.03048867f, 0.02488043f, 0.02987819f, -0.04701549f, -0.06396483f, -0.04929106f, -0.04723007f, -0.05446950f, 
    0.02889091f, 0.03671112f, 0.00157609f, 0.04199052f, -0.03047795f, 0.03048225f, -0.01436187f, 0.04662041f, 
    -0.03951807f, 0.02291631f, 0.03857640f, -0.02747723f, 0.01163684f, -0.05006932f, 0.04532678f, 0.01910235f, 
    -0.05684516f, -0.02144986f, -0.02165454f, -0.02545180f, -0.04766395f, 0.00608465f, -0.03588385f, -0.03595500f, 
    -0.03257173f, -0.05601299f, -0.04125654f, -0.00489296f, -0.02232995f, -0.05115413f, 0.04274707f, -0.00982128f, 
    0.03138303f, -0.01717070f, -0.03604824f, -0.01491266f, -0.06434859f, 0.01635857f, -0.06282064f, 0.00514188f, 
    0.29985473f, 0.10700197f, -0.25930920f, 0.29276502f, -0.01484610f, 0.26122710f, -0.14479932f, 0.03902558f, 
    0.29181170f, -0.09554794f, 0.14726095f, -0.03847981f, 0.07482516f, -0.05929134f, 0.07984182f, -0.13042621f, 
    0.03163270f, 0.08771274f, 0.12301082f, -0.07622837f, -0.15326011f, 0.03773070f, 0.01997583f, 0.11029189f, 
    -0.02229289f, 0.04466521f, 0.00792937f, 0.22464681f, 0.16859002f, -0.30500314f, -0.03178101f, 0.05515072f, 
    0.20424269f, -0.00741232f, -0.20167179f, -0.01373968f, 0.18987232f, -0.32206205f, 0.10463112f, 0.00296453f, 
    0.07531559f, 0.05467317f, -0.08386957f, 0.03532890f, 0.05830394f, 0.30319285f, 0.27659923f, -0.05761549f, 
    -0.01653351f, -0.25090072f, 0.07581016f, -0.00377228f, -0.01515879f, 0.06457028f, 0.05773985f, 0.04473844f, 
    -0.26954374f, -0.15000103f, 0.27928528f, -0.09212709f, -0.03035783f, 0.00894399f, -0.01283660f, 0.21641265f, 
    -0.18055134f, 0.13165046f, -0.12269214f, -0.03425146f, -0.09933425f, 0.06451663f, 0.03411860f, 0.01166403f, 
    0.08247065f, 0.13723712f, -0.04342592f, -0.12998748f, -0.04999406f, 0.22322905f, 0.07988236f, 0.20592287f, 
    0.11320277f, 0.24726295f, 0.03110053f, 0.11241411f, -0.22723587f, -0.01654429f, 0.05437188f, -0.06161907f, 
    0.08263432f, 0.05658566f, 0.21517333f, 0.14453688f, 0.29764700f, -0.31067634f, 0.05873094f, 0.11474043f, 
    -0.14775665f, 0.01523436f, 0.06800162f, -0.05838512f, -0.09203209f, 0.21045767f, 0.08742246f, 0.12211055f, 
    -0.23876099f, 0.06590599f, 0.10005967f, -0.05390876f, 0.16399233f, 0.11465862f, 0.46890619f, -0.02231008f, 
    -0.04878101f, 0.17777631f, -0.02403832f, 0.04311676f, -0.03875168f, 0.29335719f, 0.03022689f, -0.10693608f, 
    -0.04157182f, -0.14415941f, 0.03867191f, -0.08500748f, -0.02527096f, 0.07728859f, -0.04312261f, 0.10025474f, 
    0.04010303f, -0.07108438f, -0.16423473f, 0.03589492f, -0.11286472f, 0.09220707f, 0.02403230f, 0.33354500f, 
    0.17013231f, 0.17670780f, -0.09033381f, 0.00252197f, 0.05107289f, 0.02914145f, -0.06607349f, -0.02013475f, 
    0.28865382f, -0.11420738f, -0.08662154f, -0.23461883f, 0.06489781f, -0.07455043f, -0.07281468f, 0.05017519f, 
    0.10651994f, 0.29403666f, 0.13809246f, -0.08400965f, -0.03489697f, -0.00671401f, 0.23793201f, 0.09369069f, 
    0.01630142f, -0.06148501f, 0.10944350f, -0.25085616f, 0.10903956f, -0.04656639f, 0.02126872f, 0.02214525f, 
    0.07786188f, -0.18284222f, -0.06969576f, 0.13934384f, 0.16727692f, 0.07147618f, 0.00068358f, 0.18075506f, 
    -0.01466753f, -0.06321553f, -0.11244004f, -0.12281711f, 0.02880993f, -0.05172581f, 0.11871289f, 0.10581168f, 
    0.00979071f, -0.12808324f, 0.06907492f, 0.10384589f, -0.03958631f, -0.18149734f, -0.25568542f, 0.03997418f, 
    0.10173076f, 0.07401820f, 0.04415780f, 0.16455159f, 0.00782270f, -0.11471455f, -0.20423982f, 0.00400149f, 
    -0.16076992f, 0.19504753f, 0.04655368f, -0.05922370f, 0.02751761f, -0.13358435f, -0.02584990f, -0.03151129f, 
    -0.27341101f, -0.42571560f, -0.12909950f, 0.05441010f, -0.16159208f, 0.02930356f, 0.05160207f, -0.00042719f, 
    -0.26043099f, 0.16735516f, 0.15341572f, -0.00987231f, 0.08531703f, -0.01058846f, -0.00266462f, 0.06866970f, 
    -0.28718150f, -0.05333956f, 0.07473934f, 0.06259428f, 0.01164340f, 0.10259325f, -0.13052331f, -0.03558088f, 
    -0.01964760f, -0.08492200f, -0.32687023f, 0.04144724f, -0.29782882f, -0.04299002f, 0.07135490f, 0.05356894f, 
    -0.07848789f, 0.10649727f, 0.06746183f, -0.05636860f, 0.08862813f, 0.03851113f, 0.12565605f, -0.12566334f, 
    0.09355396f, -0.04971313f, -0.03702620f, 0.04607647f, -0.02227770f, -0.12071270f, -0.21647465f, 0.05034925f, 
    -0.07772139f, -0.22041094f, 0.05123581f, -0.05447385f, 0.06004661f, -0.13365863f, 0.09917887f, -0.01138847f, 
    0.11546187f, -0.15816727f, 0.04494790f, 0.07056094f, 0.15942168f, -0.08998794f, 0.20785746f, -0.11447549f, 
    0.16724159f, 0.05330414f, -0.03531498f, 0.02721884f, 0.00177597f, -0.16068101f, 0.03693737f, 0.19310351f, 
    -0.16828854f, -0.22326352f, -0.11636873f, 0.03883141f, -0.09198537f, -0.08847622f, 0.15488075f, 0.06888275f, 
    -0.03770547f, 0.01458362f, -0.04276237f, 0.00672609f, 0.03216871f, -0.00082891f, 0.02598435f, -0.00988988f, 
    -0.00984082f, -0.03153575f, -0.01134224f, 0.01520160f, -0.03913172f, 0.00975767f, -0.03282016f, -0.02634485f, 
    -0.02644326f, 0.02866339f, -0.05200328f, 0.03547757f, 0.03687331f, -0.01168428f, 0.01120877f, 0.03483132f, 
    -0.02934051f, 0.00800692f, 0.02649646f, -0.03634258f, 0.03674787f, -0.02005332f, -0.03749940f, -0.02776974f, 
    -0.01228960f, 0.04786712f, -0.03775250f, -0.06322170f, 0.02767173f, -0.04059185f, -0.01825576f, -0.03371075f, 
    -0.01468769f, -0.01934370f, -0.04848357f, -0.06288017f, -0.03845257f, 0.00905652f, -0.02336430f, -0.06078550f, 
    0.03059769f, 0.01728959f, -0.04141027f, 0.05174955f, 0.02320198f, -0.01267663f, 0.02488443f, -0.01024393f, 
    -0.02908858f, -0.06047866f, 0.04739261f, -0.04700736f, -0.00651733f, -0.03369675f, 0.01970275f, -0.02628678f, 
    0.04155601f, 0.05033479f, -0.06657334f, 0.03604900f, -0.04104433f, 0.01901029f, 0.01480054f, -0.03766648f, 
    -0.04778378f, -0.03078707f, 0.02848809f, 0.04701078f, -0.06361828f, -0.00791851f, 0.02349206f, 0.03993087f, 
    -0.03009737f, -0.04690149f, -0.03929291f, -0.04964954f, -0.01010022f, 0.01705704f, -0.05605907f, -0.05611241f, 
    -0.01963688f, 0.03667827f, -0.02709990f, 0.04906061f, -0.05547982f, 0.02810144f, -0.04901187f, 0.02326943f, 
    0.02017078f, -0.02207195f, -0.03952706f, -0.02755749f, -0.02038192f, 0.03860481f, -0.02878243f, 0.02841252f, 
    -0.05168318f, 0.00123017f, 0.03480999f, -0.02645815f, 0.02032725f, 0.03743022f, -0.05625034f, -0.02147125f, 
    -0.02491141f, -0.03647256f, 0.00707039f, -0.04087749f, -0.00112153f, -0.03187513f, -0.00370483f, -0.00960769f, 
    -0.04046480f, 0.02379411f, -0.02311145f, 0.00088059f, 0.04672746f, 0.02716707f, 0.05032251f, 0.00382623f, 
    0.04516842f, 0.01809439f, 0.02812340f, -0.05836169f, -0.01544971f, 0.02908957f, 0.04780478f, -0.01291351f, 
    -0.01732678f, -0.03580317f, 0.03264974f, 0.04190781f, 0.03685063f, -0.05954147f, -0.04927063f, -0.03172146f, 
    -0.01998697f, -0.01667752f, 0.00128461f, 0.04895123f, -0.05617262f, 0.00615492f, -0.00622410f, -0.04977652f, 
    -0.04188645f, -0.01471868f, 0.04077419f, -0.06554354f, 0.00240436f, -0.02506980f, 0.00850165f, 0.03458095f, 
    0.02424344f, -0.01624177f, -0.04723157f, 0.04588769f, -0.01355257f, -0.01532884f, -0.06579996f, -0.02908679f, 
    0.01607944f, 0.02282841f, -0.04435961f, -0.06093158f, -0.01558194f, -0.00340871f, -0.06093979f, -0.02362248f, 
    -0.03445457f, 0.00616758f, 0.03646292f, 0.02674466f, -0.00506300f, -0.04409698f, 0.02404825f, 0.01337933f, 
    -0.00919187f, -0.03406112f, 0.02185587f, 0.00074569f, 0.00855142f, -0.06630339f, -0.05039116f, 0.01959229f, 
    -0.05579929f, -0.05149254f, -0.00589847f, 0.00685422f, 0.02726133f, -0.04855947f, -0.06563918f, 0.01464615f, 
    0.01234074f, 0.01978409f, -0.02157808f, -0.01438218f, -0.00389696f, -0.01665308f, -0.05704466f, -0.01973057f, 
    -0.05811693f, -0.02991908f, -0.01065481f, -0.00993877f, -0.06347536f, -0.02635248f, -0.02669797f, 0.03127817f, 
    -0.03527481f, -0.03541689f, 0.04311609f, -0.03786499f, -0.04528182f, -0.04246800f, -0.01678603f, -0.04320745f, 
    0.01973736f, 0.03491519f, 0.04722782f, -0.05444033f, 0.04602240f, 0.01938563f, -0.05576865f, -0.05606442f, 
    -0.03398740f, -0.03936525f, 0.01146394f, 0.03309089f, -0.00241659f, 0.01399193f, 0.00255631f, 0.04125488f, 
    -0.04580168f, -0.02972579f, -0.06079369f, -0.03775543f, 0.02356550f, 0.02499913f, -0.02560544f, -0.06499978f, 
    -0.00831090f, -0.02340394f, -0.02222262f, -0.03197931f, 0.01909199f, 0.00209457f, -0.00146483f, -0.06595771f, 
    0.01379253f, -0.06551999f, 0.00056661f, -0.03480202f, -0.00512442f, -0.02177707f, -0.03254485f, -0.00083050f, 
    -0.01535616f, 0.01962195f, 0.04567660f, 0.00123677f, 0.04316958f, 0.00012283f, 0.00485073f, 0.01158293f, 
    0.05069293f, 0.02976704f, 0.03719324f, -0.04134391f, -0.05047479f, 0.04727272f, -0.03222457f, 0.01126279f, 
    -0.02032127f, -0.05028831f, 0.04361924f, -0.01325611f, 0.02836004f, 0.02147556f, 0.01515298f, -0.04758480f, 
    -0.18591799f, -0.02938311f, -0.31661543f, -0.12739533f, 0.05236293f, -0.01535825f, -0.12757456f, -0.07791936f, 
    0.15910427f, -0.12507659f, 0.27247706f, 0.32753280f, -0.00338562f, 0.10914645f, -0.01114573f, -0.00456296f, 
    -0.04834901f, 0.09579524f, 0.20856193f, 0.23529428f, 0.22428487f, -0.03621428f, 0.19757724f, -0.01303437f, 
    0.12280352f, 0.00938244f, 0.09380449f, -0.19687703f, -0.60107958f, -0.30221897f, -0.10733605f, 0.01442337f, 
    -0.12035778f, -0.10839923f, -0.21241899f, -0.18397732f, 0.00243666f, -0.39790037f, 0.17511229f, 0.05766567f, 
    0.01571493f, -0.01552571f, 0.02828214f, -0.14299291f, 0.00507562f, -0.12720756f, 0.14942454f, 0.30745223f, 
    0.06998421f, 0.10556547f, 0.05639350f, 0.11470787f, -0.16365397f, 0.02798823f, 0.08449489f, 0.12360528f, 
    0.10700830f, -0.03871916f, 0.00929875f, 0.03341412f, 0.07394228f, -0.15054578f, 0.02982927f, -0.22373961f, 
    0.15853029f, -0.00922849f, 0.12113156f, 0.10315874f, 0.07374758f, -0.00882447f, -0.01149424f, -0.01611031f, 
    0.37978733f, 0.13181964f, 0.08261965f, 0.10256208f, 0.11442298f, 0.13212755f, 0.22364266f, -0.01915740f, 
    -0.00595360f, -0.19342886f, -0.16394760f, -0.22312030f, 0.07776069f, -0.09636020f, 0.05341841f, -0.03170024f, 
    0.00372400f, -0.07818761f, -0.18819888f, -0.02346125f, -0.01964083f, 0.04747687f, 0.03751726f, -0.00021224f, 
    -0.02728185f, 0.01071405f, 0.04834759f, -0.21780300f, -0.37477240f, -0.28706336f, 0.04247044f, -0.08839785f, 
    0.04702439f, 0.01554888f, 0.00201449f, -0.06082180f, -0.12385015f, -0.23886435f, 0.09220813f, 0.07233495f, 
    0.05813895f, 0.05446464f, 0.08911738f, -0.07780958f, -0.08008635f, -0.17693450f, -0.26227817f, 0.20006593f, 
    0.00303866f, -0.02099587f, -0.03363557f, 0.03047572f, -0.08140019f, 0.02838179f, -0.12404208f, -0.23416479f, 
    0.05707832f, -0.04179582f, 0.10562111f, 0.05322034f, -0.03179586f, -0.05766872f, -0.00724133f, -0.17201883f, 
    -0.12273324f, -0.22971675f, 0.01456667f, 0.01450698f, 0.12027080f, 0.04433048f, -0.13558045f, 0.07409345f, 
    -0.19821654f, -0.32138753f, -0.19273557f, 0.22428513f, -0.15069859f, 0.05150700f, 0.09851027f, -0.00185843f, 
    0.08359142f, 0.14672358f, -0.01513063f, 0.17068675f, 0.02085955f, -0.00662323f, 0.03081592f, 0.02002274f, 
    -0.07004470f, 0.04260739f, -0.12378738f, 0.15148556f, -0.31803674f, 0.16483691f, 0.05792958f, 0.10281008f, 
    0.08709812f, -0.04827747f, 0.01568333f, -0.06390962f, 0.12713811f, 0.04333909f, 0.01443108f, 0.08155958f, 
    0.05223763f, -0.15559576f, -0.12011681f, 0.06788171f, -0.33068419f, -0.12029754f, 0.13182098f, 0.04628413f, 
    0.14431830f, -0.04740240f, 0.09264617f, -0.08048303f, 0.03565047f, -0.15137877f, -0.07926209f, -0.02414433f, 
    -0.15812388f, 0.00964241f, 0.04301842f, 0.02728111f, -0.06984959f, 0.05389178f, -0.13375637f, 0.02624507f, 
    0.33793417f, -0.04077045f, 0.11711431f, -0.24602683f, 0.07251565f, 0.14184639f, 0.15258034f, 0.17969762f, 
    -0.00272093f, -0.17977519f, 0.04392082f, -0.03607822f, -0.05393545f, 0.07241906f, 0.15767783f, -0.07823273f, 
    0.05413286f, 0.05335411f, 0.07017397f, -0.28002200f, -0.11813630f, 0.04352166f, -0.01526717f, 0.05770386f, 
    0.08737322f, -0.26909944f, 0.00850720f, -0.11644417f, 0.08715189f, 0.13859975f, -0.11454590f, 0.02772967f, 
    -0.06836516f, 0.08795168f, 0.08550436f, 0.05421403f, 0.21263647f, -0.15826936f, 0.08713966f, 0.06831380f, 
    0.12613830f, 0.13997354f, -0.04056780f, 0.07686851f, 0.15877202f, -0.00278280f, -0.00861763f, 0.03125539f, 
    0.02091070f, 0.04095474f, -0.07560094f, -0.00950595f, -0.21048786f, -0.00464633f, -0.00506250f, 0.20013545f, 
    0.00049567f, -0.01550510f, 0.04832886f, 0.04108069f, 0.17659155f, -0.32729462f, 0.19169998f, 0.21205854f, 
    0.08559204f, 0.13946237f, -0.02691636f, 0.07918894f, -0.01620626f, -0.10123332f, -0.18260665f, 0.12917733f, 
    -0.07532182f, 0.09266387f, 0.09653014f, 0.14831720f, -0.07764100f, -0.08578647f, -0.06051617f, 0.23683567f, 
    0.00275509f, -0.32423902f, 0.01321829f, -0.14470233f, -0.05893322f, 0.10214030f, -0.00593500f, -0.03645168f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.04434633f, 0.00202046f, -0.01114752f, -0.01715580f, 0.09355346f, 0.05933535f, -0.01621461f, 0.03679641f, 
    -0.15315396f, 0.04738371f, -0.02529178f, -0.01941685f, 0.02828974f, 0.09072295f, -0.04110525f, 0.02803414f, 
    -0.05671172f, 0.03665395f, 0.08399744f, 0.07619157f, 0.01651086f, 0.13191605f, 0.02702723f, -0.08560020f, 
    0.12423846f, -0.04856666f, 0.00375525f, 0.09126571f, 0.03628870f, 0.00928442f, 0.02456725f, 0.14024258f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04851702f, -0.11669033f, -0.10904037f, -0.16754520f, -0.05051002f, -0.08891188f, 0.13609366f, -0.10461043f, 
    0.04169676f, -0.01659839f, -0.02063887f, -0.08840550f, -0.17391945f, -0.20668319f, 0.14696787f, -0.19697823f, 
    0.00788233f, 0.06127897f, 0.09714305f, 0.14534816f, 0.01359717f, -0.06071777f, 0.08395337f, -0.13222404f, 
    -0.11473039f, -0.14351250f, 0.02435604f, -0.04520934f, 0.13144839f, 0.12760906f, -0.14668490f, 0.03519100f, 
    -0.01400767f, 0.15498103f, 0.14959063f, -0.14042418f, -0.11105161f, -0.16194580f, -0.09859069f, 0.47969285f, 
    -0.35102391f, -0.11459741f, 0.13234025f, -0.30650061f, 0.07474326f, 0.07401621f, 0.07432300f, -0.28213224f, 
    -0.01070863f, -0.02331134f, 0.40808141f, 0.11851052f, 0.38946131f, 0.12791391f, 0.06472183f, -0.05157431f, 
    -0.01426131f, -0.05623929f, 0.53955150f, 0.15427548f, -0.16058177f, 0.39759532f, 0.12863378f, -0.32894248f, 
    0.17645364f, -0.17106438f, 0.04707353f, 0.03480591f, -0.10852595f, 0.28073943f, 0.10096403f, -0.58630675f, 
    -0.14579536f, 0.04746020f, -0.17657946f, 0.24714276f, 0.13735035f, 0.26227391f, -0.04375208f, -0.00399582f, 
    0.01769117f, 0.03348166f, -0.13990469f, 0.34211433f, 0.19107465f, 0.00283365f, -0.12622184f, 0.12179097f, 
    -0.30674052f, 0.39257735f, 0.16343899f, 0.06564612f, -0.00448582f, -0.07004720f, -0.04088395f, -0.10623828f, 
    -0.01589480f, -0.13046512f, 0.11486452f, -0.10227384f, -0.24563833f, 0.36255693f, 0.04794463f, -0.30365735f, 
    -0.40283808f, -0.11688019f, 0.01455252f, 0.22818901f, -0.10512087f, 0.40673703f, -0.07329649f, 0.24073824f, 
    0.06694949f, 0.13171333f, 0.27462763f, -0.55412328f, -0.20246860f, -0.03844908f, -0.17132719f, 0.22532481f, 
    -0.29476544f, -0.25922498f, -0.49056637f, -0.15858123f, -0.00654619f, 0.21084054f, -0.02421901f, 0.41918275f, 
    0.07420272f, 0.14488856f, 0.07304288f, 0.01685861f, -0.08943539f, 0.19928308f, 0.13592820f, -0.09631295f, 
    -0.23845567f, 0.06858918f, 0.15703787f, 0.04638922f, 0.04673758f, 0.31990105f, -0.02284996f, 0.40695861f, 
    -0.09885374f, -0.01667359f, -0.13889526f, 0.36820599f, -0.31279400f, 0.05514739f, -0.08910589f, 0.25528884f, 
    -0.31742260f, -0.16595568f, 0.00783124f, -0.32475173f, 0.15039320f, 0.03281293f, 0.14324155f, 0.29484978f, 
    -0.11372663f, -0.05344975f, -0.06262247f, 0.09074733f, -0.05601695f, 0.28719592f, 0.09179762f, 0.18609147f, 
    0.06768830f, -0.04051960f, -0.09493462f, 0.36062476f, -0.03370595f, 0.03584370f, 0.13465635f, 0.40400171f, 
    0.01640538f, 0.01530495f, 0.38383260f, -0.34096470f, 0.32766438f, -0.31411037f, 0.04659896f, 0.05408192f, 
    -0.05493611f, 0.21458595f, -0.15966454f, -0.12768210f, -0.17303437f, 0.47085485f, -0.03213545f, -0.26855412f, 
    -0.08444340f, 0.16869406f, -0.13369936f, -0.12882894f, 0.16488998f, 0.15772612f, -0.07336335f, 0.56881022f, 
    -0.10036506f, 0.11482420f, 0.17820360f, -0.45876956f, -0.00781485f, 0.21609420f, 0.15698031f, -0.21983428f, 
    0.05933877f, -0.11704442f, 0.24954070f, -0.42143682f, -0.27585030f, 0.17260593f, 0.09913030f, -0.05794651f, 
    0.11126535f, -0.52822334f, -0.10370503f, 0.19477114f, 0.17963156f, 0.26242775f, -0.00225027f, 0.10027260f, 
    0.05465057f, -0.01379872f, 0.02064021f, -0.11121009f, -0.24378757f, -0.11050877f, 0.11200757f, 0.21014114f, 
    0.21579516f, -0.15400210f, 0.09723777f, -0.18171778f, 0.15603134f, -0.00953070f, 0.14188591f, -0.00025843f, 
    0.02194317f, 0.07080210f, 0.31399521f, 0.03031942f, 0.50817025f, 0.22002567f, -0.15929872f, -0.01428347f, 
    0.03896517f, 0.28385192f, -0.08533337f, 0.36128965f, 0.01160853f, 0.05905497f, 0.06399178f, -0.57434231f, 
    -0.06423759f, -0.09138156f, 0.05908591f, 0.17162755f, 0.39564008f, -0.01124642f, 0.06994191f, 0.25035012f, 
    0.21721251f, -0.08564177f, 0.14897318f, -0.07426562f, 0.15366304f, -0.11170831f, 0.16532572f, -0.11539055f, 
    0.15231836f, 0.01886129f, -0.35558516f, 0.72048336f, -0.06472532f, 0.28385812f, 0.00615742f, 0.10844442f, 
    0.05741528f, -0.04896204f, 0.52100325f, -0.40073252f, 0.07188699f, -0.08308180f, 0.05036101f, -0.11271235f, 
    0.03086330f, -0.12610278f, -0.10391120f, 0.18206292f, -0.38029292f, 0.24660607f, 0.17082077f, 0.53543478f, 
    0.45459041f, -0.10365094f, 0.00690358f, -0.17331590f, 0.11979236f, -0.10651278f, 0.14941134f, -0.00616197f, 
    0.16462581f, -0.00529486f, 0.11457425f, -0.52333665f, 0.15719196f, 0.03296969f, 0.01721132f, 0.16440085f, 
    0.18050802f, -0.25493112f, -0.24366076f, 0.15174049f, -0.00950091f, 0.19880991f, 0.14212196f, -0.21262591f, 
    -0.01226903f, -0.03648615f, 0.03903732f, -0.08268124f, -0.37429190f, 0.24763030f, -0.13903362f, -0.03183501f, 
    0.25997859f, 0.14713182f, -0.11469508f, 0.14447166f, 0.07380115f, -0.10211951f, 0.09910279f, -0.08026425f, 
    -0.16690192f, 0.15380600f, -0.04626628f, 0.12070023f, 0.06713597f, 0.05037380f, -0.01214057f, 0.45758218f, 
    -0.15289173f, -0.18386707f, -0.28145829f, -0.24522816f, -0.08641446f, 0.01353686f, -0.02266518f, -0.44954860f, 
    -0.11192413f, 0.06185364f, -0.00593295f, -0.14334014f, -0.40420726f, 0.33624238f, 0.01178681f, -0.03475183f, 
    -0.46461174f, 0.08899507f, -0.01602093f, 0.07977118f, -0.04173270f, 0.28768182f, -0.13392034f, 0.17910124f, 
    -0.11741360f, 0.01398998f, 0.47699133f, 0.06990089f, 0.22592890f, -0.27353939f, -0.03712803f, 0.36315051f, 
    -0.34104329f, 0.07395057f, 0.05642394f, 0.24975078f, -0.05547547f, 0.06425865f, -0.16589096f, -0.25047052f, 
    -0.11474337f, 0.15177102f, 0.13646130f, -0.15724705f, -0.53918672f, 0.27840352f, 0.05351961f, 0.04378429f, 
    -0.28723800f, 0.08601266f, -0.03755443f, 0.33285609f, -0.07558401f, 0.14888361f, 0.08667296f, -0.36841702f, 
    0.01282463f, -0.01303971f, -0.29174200f, 0.70929080f, 0.15521561f, 0.05392397f, 0.04397066f, -0.08615343f, 
    -0.12656397f, 0.50091159f, 0.07085407f, -0.03288248f, -0.05783642f, -0.19608669f, 0.05232752f, 0.24370041f, 
    -0.15880495f, -0.03740260f, 0.15328257f, 0.03240976f, -0.07272478f, 0.17929870f, -0.06757613f, -0.38272911f, 
    0.32697052f, -0.04669263f, 0.14608611f, 0.05998602f, -0.06087033f, 0.16301066f, 0.15005657f, 0.47249353f, 
    -0.05713750f, 0.05193421f, -0.31307375f, 0.61846358f, -0.02589060f, -0.10328508f, 0.10941394f, 0.50943911f, 
    0.02702244f, 0.15165675f, 0.10162522f, -0.20050400f, -0.12891306f, -0.28136188f, -0.02905419f, 0.09349174f, 
    -0.04888518f, 0.17736968f, -0.08195136f, 0.09069873f, 0.24847586f, 0.27149308f, -0.15256616f, -0.11300194f, 
    -0.43877059f, 0.06900474f, -0.12920195f, -0.23533358f, 0.04706090f, 0.03872873f, 0.05221796f, 0.45795715f, 
    0.07417917f, 0.09519625f, -0.04552814f, 0.44523060f, -0.08771883f, 0.09887512f, 0.06532522f, -0.13920128f, 
    -0.07113427f, -0.00506820f, -0.18534490f, 0.27409413f, -0.13894176f, -0.07733154f, -0.03079866f, -0.32209504f, 
    0.10696398f, -0.16696469f, -0.11370441f, 0.17907171f, -0.02176198f, -0.02056574f, -0.03484272f, 0.28336877f, 
    0.20396584f, -0.05679054f, 0.08708085f, 0.31519505f, 0.11100116f, -0.16597866f, 0.08527779f, -0.52495092f, 
    0.16574915f, 0.02238056f, -0.14285466f, 0.03892335f, 0.07858807f, 0.21012582f, -0.16120611f, -0.27840355f, 
    -0.02242942f, 0.12209655f, 0.52760136f, -0.13748954f, 0.12749107f, 0.09787942f, 0.07814171f, 0.36448616f, 
    -0.06426983f, -0.05306771f, -0.05462756f, -0.12297522f, -0.09959126f, 0.10345373f, 0.15608761f, -0.25888363f, 
    0.30925944f, -0.01628843f, -0.00672235f, 0.13736755f, 0.02649170f, -0.05601893f, 0.02599997f, -0.02808185f, 
    0.04608111f, 0.00342489f, 0.26462314f, -0.28815442f, 0.31985947f, 0.18705973f, 0.08798648f, -0.49673924f, 
    0.02419258f, 0.22191533f, -0.17466107f, 0.58515918f, 0.09896567f, -0.11507890f, 0.08020786f, -0.10307163f, 
    -0.02137688f, -0.09334242f, 0.08799177f, 0.02065630f, 0.38049769f, 0.04545184f, -0.05866879f, -0.42112908f, 
    0.01814226f, -0.15916060f, 0.17302838f, 0.10102785f, -0.11032596f, 0.04566739f, 0.03911573f, 0.25620496f, 
    0.12567413f, 0.17213590f, 0.20161237f, -0.46871188f, -0.29146099f, -0.00159296f, -0.01996752f, -0.31677184f, 
    -0.08739953f, -0.18240722f, 0.06953637f, 0.25064981f, -0.01172572f, 0.37946427f, 0.07368974f, 0.25648963f, 
    0.06495050f, 0.02158331f, 0.02987520f, -0.01956864f, 0.22483417f, 0.12610511f, 0.12974302f, -0.00379191f, 
    0.38038102f, 0.07276015f, -0.00662209f, 0.72093880f, 0.12459519f, 0.01434065f, 0.11594039f, -0.05352704f, 
    0.15106291f, 0.15446381f, -0.29348040f, -0.36518955f, -0.30966190f, 0.08409505f, -0.03625830f, -0.02650796f, 
    0.37265751f, 0.17278276f, -0.40862623f, -0.38668197f, -0.11836874f, 0.14125708f, 0.06323455f, 0.61734676f, 
    0.03138425f, 0.07540661f, -0.09283580f, -0.08077727f, -0.00846086f, -0.16124463f, 0.06790061f, 0.29159471f, 
    0.45733246f, 0.13398963f, 0.08642513f, -0.10978132f, -0.06278251f, -0.05586654f, 0.14562002f, -0.37914237f, 
    0.09407970f, -0.11209103f, 0.15648647f, 0.50037712f, -0.02286840f, 0.24755365f, -0.03245208f, -0.10421932f, 
    -0.09578505f, -0.12974682f, -0.07550473f, -0.00100089f, 0.03769650f, -0.06224661f, -0.13324164f, 0.09126175f, 
    0.12436439f, 0.16904794f, 0.05880098f, 0.10280887f, 0.15354416f, 0.05900262f, 0.06448216f, 0.09213144f, 
    0.20582242f, 0.10843308f, -0.08713696f, -0.03935308f, 0.01202394f, -0.21597740f, -0.02542416f, -0.10553841f, 
    -0.16637678f, 0.09160095f, 0.30843171f, 0.08303664f, -0.13555443f, 0.07643207f, -0.00431207f, -0.28997785f, 
    0.45839223f, -0.33490196f, 0.07215580f, -0.11758804f, -0.04112004f, -0.04575105f, -0.15529516f, -0.33766216f, 
    0.03654177f, -0.05245769f, 0.14919032f, 0.11463408f, -0.13767846f, -0.14468895f, -0.03509934f, -0.06194926f, 
    0.03812338f, -0.12833622f, -0.12269022f, -0.00824088f, -0.08560310f, -0.09192865f, -0.03957237f, -0.14898568f, 
    -0.14846268f, -0.02870305f, -0.17031111f, 0.15965432f, 0.02095850f, -0.07549640f, -0.11966044f, -0.15099084f, 
    0.07211716f, -0.05547352f, 0.09978702f, -0.14309970f, -0.07447674f, -0.00146695f, 0.14241040f, -0.17308617f, 
    0.15251437f, 0.08567447f, 0.08499046f, -0.15480804f, -0.11121652f, -0.17643119f, -0.09291020f, -0.08735219f, 
    0.09640177f, 0.02542064f, -0.07575196f, -0.14547159f, -0.04191702f, -0.06198273f, -0.08513680f, 0.08682296f, 
    0.08146438f, -0.06607233f, -0.05470248f, -0.13658392f, -0.01266325f, 0.12292649f, -0.02313067f, -0.13074563f, 
    -0.16079107f, 0.10396987f, -0.08432389f, 0.01361330f, -0.16464363f, -0.19179571f, -0.12901661f, -0.16691278f, 
    -0.16273202f, 0.03508750f, -0.12789427f, 0.06015733f, 0.32506230f, 0.20204736f, -0.13699751f, -0.10342131f, 
    -0.31216672f, -0.04787383f, 0.14192270f, 0.05392330f, 0.07412377f, 0.19550644f, 0.08193102f, 0.22540726f, 
    0.09122889f, 0.13496947f, 0.06756601f, -0.11809921f, -0.27370849f, 0.10465311f, -0.09867878f, -0.15721132f, 
    0.34774014f, 0.11573501f, -0.33464590f, 0.17109965f, 0.06470449f, -0.34348738f, 0.01290130f, 0.49525425f, 
    0.15722710f, -0.11585933f, -0.07082383f, 0.16060504f, 0.31256965f, -0.03039440f, 0.04094082f, -0.26031077f, 
    0.63057172f, -0.09744469f, 0.03877588f, 0.07947583f, -0.16847524f, -0.10013438f, 0.02931168f, 0.05378415f, 
    -0.01434366f, 0.07161846f, -0.16488081f, -0.06266691f, -0.23591942f, 0.21561569f, -0.10299965f, 0.12884772f, 
    0.44331336f, 0.06228920f, 0.10085414f, -0.21540077f, 0.12080499f, -0.26553962f, 0.14022519f, 0.23669024f, 
    0.11061138f, 0.16272439f, -0.07143319f, 0.08221499f, -0.34827754f, 0.02052792f, -0.04059296f, -0.17705657f, 
    0.18433419f, -0.07671975f, 0.15038337f, -0.31411943f, 0.10460836f, 0.03531951f, -0.10127922f, 0.29291800f, 
    0.01311300f, 0.08693451f, 0.39181581f, 0.04938672f, 0.43022728f, 0.10725967f, -0.12534176f, 0.03473250f, 
    -0.56990856f, 0.11012343f, 0.27436194f, 0.10306006f, 0.09925651f, 0.30171362f, 0.02723227f, -0.35460019f, 
    -0.00454686f, 0.07587260f, -0.04311317f, -0.04969234f, -0.10610081f, 0.31506100f, 0.14657027f, -0.15964302f, 
    0.20604450f, -0.05758290f, -0.15001689f, 0.44677934f, -0.11394489f, 0.00083009f, -0.08761581f, 0.06034249f, 
    -0.00172281f, -0.14651026f, 0.16256090f, -0.71723473f, 0.16756931f, -0.13967235f, 0.14497264f, -0.40321481f, 
    -0.14083448f, 0.05608170f, -0.02305845f, 0.25941834f, 0.12542342f, 0.57163209f, -0.15569554f, -0.20629716f, 
    0.03566983f, 0.00094885f, 0.18128312f, -0.14990605f, 0.06336887f, -0.12180652f, -0.06343732f, 0.66626358f, 
    -0.00816200f, -0.11341572f, -0.01680229f, -0.60736036f, 0.13376378f, 0.24552864f, 0.05345625f, -0.14912835f, 
    0.04440196f, -0.07338748f, 0.18490018f, -0.04402782f, -0.22276263f, 0.30688772f, -0.02458230f, 0.46411839f, 
    0.27802268f, -0.28175473f, -0.00253964f, 0.01284408f, -0.05240757f, -0.16707218f, 0.08373469f, 0.05044463f, 
    0.05412056f, -0.07350536f, 0.03137928f, 0.01631445f, 0.00738737f, -0.17228715f, -0.00472646f, 0.29563269f, 
    -0.04838933f, -0.08842622f, -0.12459497f, -0.15726317f, -0.05262226f, 0.21494241f, -0.06734476f, -0.23336723f, 
    -0.12290956f, 0.06216096f, 0.06320255f, -0.41476128f, -0.18582380f, 0.24354780f, 0.00066031f, 0.28090656f, 
    0.43889850f, -0.12065599f, -0.37519503f, -0.19496332f, 0.04286663f, 0.24132495f, -0.04694427f, 0.25163749f, 
    -0.07639845f, 0.14775778f, 0.16668971f, -0.01014670f, -0.26052943f, 0.12061156f, 0.10831258f, -0.22122879f, 
    0.08662883f, -0.06773639f, 0.12805519f, 0.16492288f, 0.14226988f, 0.15142523f, 0.00480008f, -0.33267701f, 
    -0.13370705f, 0.01627596f, 0.04952958f, 0.09547888f, -0.10752233f, 0.23482335f, -0.03886384f, 0.33309895f, 
    0.00120446f, 0.29018268f, -0.45306173f, 0.08036535f, -0.03204399f, -0.15102141f, -0.01616167f, 0.31332314f, 
    0.05748751f, -0.07753009f, 0.09547693f, -0.00395995f, -0.11780895f, -0.21985780f, -0.13002469f, -0.20239776f, 
    0.01673449f, 0.13565916f, 0.08219685f, 0.39827028f, -0.15054095f, 0.19619055f, 0.07849443f, -0.00247403f, 
    0.07871054f, 0.11083603f, 0.00382306f, 0.18756749f, -0.13929807f, 0.02098141f, 0.12775575f, -0.01621832f, 
    0.10979662f, 0.38194379f, 0.37276387f, 0.34657279f, -0.14807665f, -0.03492747f, -0.14923765f, 0.54627204f, 
    -0.00274715f, -0.13812746f, 0.05995153f, -0.16195899f, -0.13479713f, 0.36823845f, 0.06674089f, 0.07372071f, 
    0.02358039f, -0.15345246f, 0.13007694f, 0.09324763f, -0.06146614f, 0.03642220f, -0.11598054f, -0.12518083f, 
    0.08375839f, -0.06052138f, 0.00165359f, 0.23209718f, 0.04731673f, -0.14028159f, -0.03748096f, 0.29392323f, 
    -0.29269239f, -0.08979861f, -0.31085387f, -0.20455888f, 0.07081448f, 0.17243940f, -0.08874084f, 0.19669978f, 
    0.14542226f, 0.09646890f, -0.09338192f, 0.10256386f, 0.27937156f, -0.27328810f, -0.09816899f, -0.35321626f, 
    0.73438650f, -0.00593954f, -0.15098622f, 0.06703235f, -0.08317692f, 0.01161328f, -0.05125032f, -0.54937375f, 
    -0.02884723f, 0.09004524f, 0.23764108f, -0.09932110f, 0.06263778f, 0.16154630f, 0.13018587f, 0.12536873f, 
    0.16856806f, -0.13343878f, -0.50129700f, 0.34161302f, 0.15854934f, -0.11428270f, -0.00005021f, -0.00414454f, 
    -0.11185280f, -0.03717122f, -0.13487741f, 0.09139692f, -0.20765162f, 0.22155759f, 0.12576595f, -0.29712278f, 
    -0.59977263f, -0.13360375f, -0.08116306f, -0.53664255f, -0.14768778f, 0.22745568f, -0.13089055f, 0.09247888f, 
    0.02463757f, 0.10503755f, -0.03965186f, 0.44424808f, 0.50324851f, 0.10315801f, -0.13531452f, 0.45386308f, 
    -0.08317207f, 0.14163944f, 0.15935549f, 0.35166845f, 0.03284550f, -0.35174552f, 0.06490391f, -0.37482864f, 
    0.09116209f, -0.00568523f, -0.07971019f, 0.09898604f, -0.20548405f, 0.25382343f, 0.02760180f, -0.01768996f, 
    0.00038370f, -0.14293405f, 0.01015583f, 0.26174846f, 0.07323038f, 0.20043686f, 0.10196092f, -0.42136556f, 
    -0.15462744f, -0.05890646f, 0.08699290f, -0.24928644f, 0.12576650f, 0.26499790f, -0.10332083f, -0.08078977f, 
    0.17790258f, -0.10693741f, -0.24232955f, 0.14306657f, 0.09101551f, -0.18848693f, -0.07663763f, 0.01216878f, 
    -0.17069466f, -0.12626559f, -0.00759575f, -0.02707619f, 0.02133097f, 0.01193070f, 0.08326546f, -0.00498277f, 
    0.03652823f, -0.10929871f, -0.00768944f, -0.17519513f, 0.16055861f, -0.00018241f, -0.17595926f, -0.05035712f, 
    0.01916998f, -0.15777735f, 0.02259748f, -0.11637540f, 0.11967486f, -0.18742390f, -0.11063862f, -0.20434706f, 
    -0.16589043f, -0.14817517f, 0.12272730f, -0.13630952f, -0.13025144f, 0.10876978f, -0.14312299f, -0.08660133f, 
    0.16840467f, 0.09763553f, -0.14366426f, -0.11815021f, 0.05813723f, 0.18280025f, -0.16810660f, -0.01703393f, 
    -0.19669484f, -0.01641114f, 0.10709850f, 0.34232619f, 0.06924047f, -0.22757299f, -0.11881207f, -0.38169843f, 
    0.09825698f, -0.12138387f, -0.06570527f, 0.56183159f, 0.31617323f, 0.10593788f, 0.05230009f, -0.45163146f, 
    0.06383984f, 0.32579041f, 0.50824308f, 0.02068757f, 0.09982049f, 0.25936458f, 0.10615166f, -0.13258372f, 
    0.07319950f, 0.10740594f, -0.06987046f, -0.06295045f, -0.14788696f, -0.20914902f, 0.01085223f, 0.43463910f, 
    -0.22489445f, 0.04251463f, -0.08041676f, -0.29627365f, 0.04859447f, 0.14280462f, 0.07040362f, 0.24226008f, 
    0.07788252f, -0.12634952f, 0.00229857f, 0.47874358f, 0.43556184f, 0.10842291f, -0.08773427f, 0.24713461f, 
    -0.32753244f, 0.35501921f, 0.55308920f, 0.30500579f, 0.15948680f, 0.03363659f, 0.14439555f, -0.29664543f, 
    -0.13626762f, 0.08685330f, 0.08725651f, 0.10821420f, 0.00478659f, 0.27005976f, -0.11713312f, -0.37579423f, 
    -0.18870082f, 0.13242020f, -0.11554130f, 0.26421890f, -0.05110708f, 0.10973516f, 0.05344970f, -0.34927821f, 
    -0.08164264f, -0.13742730f, 0.09088355f, -0.35975879f, 0.04600142f, 0.27526835f, 0.12159923f, -0.50474036f, 
    -0.12010540f, 0.08103596f, -0.19290511f, 0.24583319f, 0.00337043f, 0.16299742f, 0.03597585f, 0.15474379f, 
    -0.17803732f, 0.08460572f, 0.06722584f, -0.01230666f, 0.21024062f, -0.11451406f, 0.08920603f, 0.04884722f, 
    0.49388516f, 0.15350586f, -0.10867827f, -0.01480556f, 0.05530836f, -0.24193178f, -0.00715757f, -0.08051797f, 
    -0.15316518f, 0.00667196f, 0.13153720f, 0.01013969f, -0.09043046f, 0.29128781f, -0.09355687f, 0.15783320f, 
    -0.27871993f, -0.23090796f, 0.32208624f, -0.16198519f, 0.11095575f, 0.32311112f, -0.09234113f, 0.05725108f, 
    0.06021673f, -0.08434406f, 0.09568170f, 0.00507232f, 0.28974792f, -0.20460375f, 0.04748202f, 0.57047504f, 
    0.34390759f, -0.00193930f, -0.11411291f, 0.07019106f, 0.00649251f, 0.02523091f, 0.01649071f, 0.68252987f, 
    -0.09357265f, 0.04307887f, 0.07521021f, 0.00803149f, 0.27593488f, -0.09614172f, 0.03199397f, -0.16002689f, 
    -0.11139226f, 0.14466175f, 0.56602049f, 0.47339839f, -0.06615078f, 0.10864735f, -0.17128456f, -0.31638721f, 
    -0.15909775f, -0.18066332f, 0.02500038f, 0.04058816f, 0.33789748f, 0.27609089f, 0.04746217f, 0.29336327f, 
    -0.16196343f, 0.01569567f, 0.04073378f, -0.02888970f, -0.12469867f, 0.08325241f, -0.03313700f, 0.06661393f, 
    0.02905752f, 0.16393650f, -0.18688309f, 0.52279025f, -0.04394963f, -0.02655965f, 0.11195506f, 0.09292373f, 
    0.00719222f, 0.15907907f, 0.05721682f, -0.32512614f, 0.10385395f, -0.13470641f, 0.13613118f, 0.19130598f, 
    -0.09559100f, 0.04822642f, -0.06322453f, 0.03030878f, 0.12770367f, -0.10257036f, 0.14447343f, -0.07383594f, 
    0.75977361f, 0.02674393f, 0.05159368f, 0.16305007f, 0.00838013f, -0.02825352f, -0.01178616f, -0.11555693f, 
    0.06726374f, -0.18119068f, 0.13809747f, 0.41035685f, 0.20542376f, 0.07666156f, 0.01236967f, -0.14388745f, 
    -0.23456171f, 0.04174284f, -0.40513074f, 0.19132963f, 0.06612273f, 0.25813529f, 0.03112528f, -0.11282236f, 
    -0.16065820f, 0.15138289f, -0.06360023f, 0.13442183f, 0.10146575f, -0.02518905f, 0.02990450f, -0.01626316f, 
    0.17781708f, -0.08073966f, 0.01938102f, -0.14170812f, -0.16800596f, -0.15346038f, 0.14085425f, -0.19649751f, 
    0.08417667f, -0.15113561f, 0.10603368f, -0.03065882f, -0.13241270f, -0.10337190f, -0.12981859f, -0.05070537f, 
    -0.02919621f, -0.06957746f, -0.07557800f, -0.11778847f, -0.07746772f, -0.10043558f, 0.11782699f, 0.16915686f, 
    0.05131465f, 0.10896026f, -0.05315173f, 0.17484283f, 0.48358011f, 0.17157593f, 0.15663005f, 0.02066789f, 
    0.45541963f, -0.12885572f, -0.13143773f, -0.09797320f, -0.16499040f, -0.06073256f, 0.11196651f, 0.11859174f, 
    -0.03741247f, 0.15095873f, -0.01527289f, 0.23180448f, -0.24330480f, 0.10084588f, -0.03043201f, 0.47157255f, 
    0.15369134f, -0.49841991f, -0.20885180f, -0.29680163f, -0.04705739f, 0.03211907f, -0.03061049f, 0.18572313f, 
    0.12728335f, 0.16197731f, -0.10933486f, 0.01133678f, 0.05099811f, 0.08708682f, 0.06076499f, -0.11568871f, 
    -0.12024362f, 0.13563764f, -0.15789640f, 0.12976657f, 0.07067993f, -0.20843872f, 0.03483669f, 0.65138650f, 
    -0.16225842f, 0.01201657f, -0.68299156f, -0.74445081f, -0.03467966f, 0.19106899f, -0.16260946f, -0.23713517f, 
    0.22520937f, -0.51013941f, 0.39734998f, -0.32510254f, -0.11224911f, 0.13171189f, -0.10961358f, -0.08162063f, 
    -0.06466501f, 0.13569354f, -0.02219137f, -0.15854204f, 0.17117286f, 0.15325847f, -0.03121008f, -0.42789614f, 
    -0.00087862f, 0.11496853f, 0.12992136f, -0.16891472f, 0.01831628f, -0.14037475f, 0.03543694f, 0.16952856f, 
    -0.03296660f, -0.13455988f, -0.09841105f, -0.02158406f, 0.23076041f, 0.20878248f, 0.11807334f, 0.20704477f, 
    0.24665473f, -0.24230853f, -0.12435222f, -0.19226608f, 0.00002412f, 0.05486720f, 0.09696110f, -0.49141926f, 
    -0.17065638f, -0.02145249f, 0.05159358f, 0.11455688f, -0.09722557f, -0.03250925f, 0.06860921f, -0.10526832f, 
    -0.17318864f, -0.00534319f, -0.00072775f, -0.02999778f, -0.08114878f, -0.08968110f, 0.10595861f, 0.07163219f, 
    -0.15717670f, -0.06002769f, -0.12071673f, -0.07750769f, 0.08572008f, -0.10737989f, -0.07425025f, -0.10690070f, 
    -0.06881204f, 0.11072245f, -0.04970528f, -0.10047452f, 0.03709095f, 0.08193906f, -0.07896364f, 0.01228113f, 
    -0.01559522f, 0.04565294f, 0.11950553f, -0.15760532f, 0.03567056f, -0.08628000f, -0.12722597f, 0.01179530f, 
    -0.11509238f, 0.10309941f, 0.01444210f, -0.14102827f, -0.00735182f, -0.16658546f, 0.04595026f, -0.01503764f, 
    0.15269727f, -0.06945301f, -0.14821275f, -0.07597492f, 0.07226193f, -0.17253065f, -0.09180675f, -0.12062135f, 
    0.04376501f, -0.05687892f, -0.05431820f, 0.01629022f, 0.02549657f, 0.00503345f, 0.16197328f, 0.01480484f, 
    -0.14048947f, 0.08026975f, -0.05268276f, 0.12944530f, 0.07434729f, 0.28148308f, 0.07039673f, 0.24458537f, 
    0.02497271f, 0.14704530f, 0.07662941f, -0.19143517f, -0.15070996f, -0.18392149f, -0.11805722f, -0.04779221f, 
    0.16228592f, -0.09685396f, 0.26474121f, 0.14707686f, 0.15179595f, -0.07695296f, 0.11395663f, -0.19060510f, 
    0.37911215f, -0.43181315f, -0.16941851f, -0.26907161f, 0.03651599f, 0.06951027f, -0.03408318f, -0.36970532f, 
    0.10851268f, 0.04936153f, 0.06575885f, -0.08002132f, 0.42425615f, 0.00179401f, -0.05930086f, 0.06157127f, 
    0.24354756f, 0.03255214f, 0.08019640f, -0.10811324f, -0.06164960f, 0.02055073f, 0.04544163f, 0.25248682f, 
    -0.14686443f, 0.12836248f, -0.31671983f, 0.27191865f, -0.30257142f, 0.22576626f, 0.03204873f, 0.38145262f, 
    0.27975705f, -0.35335603f, 0.23151509f, -0.14935373f, -0.03855864f, -0.08993082f, 0.09552517f, -0.17391756f, 
    -0.01122912f, 0.07879465f, 0.02572651f, -0.15919182f, 0.09550408f, 0.14381585f, -0.07649942f, -0.01364846f, 
    0.12309773f, -0.08881641f, 0.11593313f, 0.46813789f, -0.01784497f, 0.08791757f, -0.15148716f, -0.18450330f, 
    0.10608084f, 0.17800990f, 0.24091129f, -0.35697559f, -0.01957674f, 0.02791107f, 0.03784099f, -0.57845712f, 
    0.06999891f, -0.00509135f, -0.02252491f, 0.41905347f, 0.10453320f, 0.16064851f, -0.06243198f, 0.17390800f, 
    -0.15211399f, 0.02956567f, 0.02895821f, -0.05238499f, 0.00030967f, -0.19505768f, -0.11759914f, 0.38278881f, 
    -0.03192137f, -0.04866928f, -0.04355277f, 0.00276953f, 0.08833933f, 0.01832639f, -0.15362859f, -0.12838109f, 
    -0.06155925f, 0.17911783f, 0.11936236f, -0.08251037f, 0.24796797f, 0.23411804f, -0.05403356f, -0.45691019f, 
    0.40521544f, 0.36920443f, 0.18833371f, 0.40134078f, 0.12890212f, -0.23380266f, -0.01255024f, -0.22603102f, 
    -0.16999362f, -0.05695889f, 0.14487575f, 0.02282106f, 0.21914154f, 0.19500911f, -0.05050619f, -0.53456652f, 
    0.36267528f, -0.14749709f, -0.00956195f, 0.75910681f, -0.13347499f, -0.02173904f, 0.14759421f, 0.07387523f, 
    -0.14154296f, -0.02474620f, -0.08067477f, 0.08291809f, 0.19508432f, -0.15478964f, 0.06951412f, -0.35641944f, 
    0.33945000f, 0.47974300f, 0.00426571f, -0.25235540f, 0.16201890f, 0.25817481f, 0.00131110f, 0.00466457f, 
    0.16387619f, -0.09053659f, 0.10479819f, -0.13340943f, -0.25896734f, -0.12388462f, -0.16091971f, 0.32291561f, 
    -0.32745370f, -0.08696650f, -0.05892327f, -0.44648197f, 0.05493250f, 0.18822359f, -0.07673127f, -0.18136249f, 
    0.05678466f, 0.16110742f, -0.08224005f, 0.41903561f, 0.03231216f, 0.33073762f, -0.13698113f, 0.59822816f, 
    -0.15954769f, -0.32062185f, 0.21618290f, -0.25591645f, 0.08457896f, 0.02121164f, 0.13968252f, 0.42667907f, 
    0.09007436f, -0.02339513f, -0.02846434f, 0.15310520f, -0.11808299f, -0.09942646f, 0.13028650f, -0.15817319f, 
    0.13222444f, -0.04814396f, -0.07012147f, -0.12688711f, -0.04742323f, 0.01926330f, 0.16330019f, -0.07093645f, 
    -0.15143089f, 0.00708562f, 0.01717377f, -0.14881343f, -0.08377422f, -0.09858884f, 0.11955860f, 0.01165309f, 
    0.07645954f, -0.15925629f, -0.02992410f, -0.06141355f, -0.08167756f, 0.15112999f, 0.16618998f, -0.11724456f, 
    0.14445160f, -0.14171165f, -0.05900647f, 0.12861513f, -0.12033263f, -0.14955892f, -0.07034085f, -0.09640273f, 
    -0.13366118f, -0.11629093f, 0.03498732f, -0.08882037f, -0.13135231f, 0.11702024f, -0.09334468f, -0.07145171f, 
    -0.06632508f, 0.11936112f, -0.09427270f, -0.00941829f, -0.17421372f, -0.17763609f, 0.13032366f, -0.11415342f, 
    0.09151504f, 0.14150196f, 0.04330020f, -0.11907380f, 0.08798272f, -0.14735904f, -0.04709048f, 0.08294158f, 
    -0.09112605f, -0.13533066f, -0.11068412f, -0.01284953f, -0.11766532f, -0.07962403f, 0.01836523f, -0.06788298f, 
    0.09966522f, 0.14425886f, -0.04036884f, -0.05271790f, -0.10442764f, 0.13820860f, -0.00232680f, 0.06310097f, 
    -0.03127562f, -0.14079332f, -0.10426186f, -0.07604399f, -0.16787061f, -0.11707012f, 0.05073898f, -0.17039973f, 
    -0.12247305f, 0.08507240f, -0.13071020f, 0.08360256f, 0.00906096f, -0.08954251f, 0.02837199f, -0.12874608f, 
    0.09483382f, -0.10177189f, 0.05731878f, 0.10598307f, 0.13156301f, -0.13559592f, -0.09478179f, 0.00218601f, 
    0.01379123f, -0.04085456f, -0.16439897f, -0.09846359f, 0.09113815f, -0.06216614f, 0.05606391f, 0.16963771f, 
    0.05381339f, -0.06015763f, 0.11263741f, 0.09914254f, -0.10302000f, -0.08211923f, -0.02855597f, -0.14516260f, 
    -0.00208941f, -0.07567842f, -0.10207229f, -0.04758497f, -0.11933621f, -0.17614675f, -0.17429692f, 0.03506192f, 
    -0.14151360f, -0.15232117f, -0.13276334f, -0.05027757f, 0.54410303f, 0.07621232f, -0.11024728f, 0.37633231f, 
    0.07496694f, 0.04038355f, 0.00168784f, -0.16937430f, -0.17248714f, -0.17668228f, 0.10240744f, 0.19919872f, 
    0.03011971f, 0.00919948f, 0.11602932f, 0.31675977f, -0.15169150f, 0.17453372f, 0.02706135f, 0.09469337f, 
    0.27518341f, -0.37491196f, 0.31498274f, -0.10968377f, -0.15901111f, -0.16367252f, 0.08118840f, -0.04924515f, 
    0.12173986f, 0.10826015f, -0.04519802f, 0.09307888f, 0.12878618f, 0.21089272f, -0.11023122f, -0.58971572f, 
    -0.15315269f, -0.10881404f, 0.08006388f, 0.12733279f, 0.13128683f, 0.39169320f, 0.06454512f, 0.35662299f, 
    -0.01525734f, -0.04476203f, 0.02077301f, -0.39331490f, -0.28787774f, -0.01459040f, 0.02817592f, 0.21170296f, 
    0.15274380f, -0.02966918f, -0.59212446f, -0.03904266f, 0.05912693f, -0.08511402f, 0.14123988f, 0.39213416f, 
    -0.08693817f, 0.05288167f, 0.11685364f, 0.01342642f, 0.01336021f, -0.17388973f, -0.02659163f, 0.15504661f, 
    -0.11949401f, 0.03812315f, -0.02112974f, 0.00307440f, 0.13914329f, -0.18323903f, -0.06828284f, -0.08635291f, 
    0.06296304f, -0.02915361f, -0.07513677f, -0.11431501f, -0.04410539f, -0.12827367f, 0.04903092f, -0.02637801f, 
    0.15914433f, 0.16329916f, 0.04345832f, 0.12353059f, 0.11326913f, -0.13230412f, 0.00663760f, 0.12979288f, 
    -0.03729182f, 0.06432111f, -0.09763138f, -0.14687194f, 0.15669578f, 0.11038716f, 0.12161919f, -0.42349532f, 
    0.38270453f, 0.09670048f, -0.06900097f, 0.01451597f, -0.14340578f, -0.07063127f, -0.13213474f, 0.57096511f, 
    0.01983385f, 0.05691399f, 0.11116866f, 0.04705620f, 0.10481506f, 0.01405623f, 0.10581817f, -0.28308839f, 
    -0.47838938f, -0.35392740f, -0.13661143f, 0.07624989f, -0.11525199f, 0.08781074f, 0.00553563f, 0.12975405f, 
    -0.12921467f, 0.09379998f, 0.12622449f, -0.05629150f, -0.00192071f, 0.07075793f, 0.08775160f, -0.08743877f, 
    -0.16705570f, -0.05711257f, 0.05311768f, 0.13488184f, -0.11618650f, -0.08464891f, 0.03483586f, -0.06279691f, 
    0.07683540f, -0.04590851f, 0.01724405f, 0.01717625f, 0.01316654f, -0.09398155f, 0.11863434f, -0.04346212f, 
    -0.12746669f, -0.02783677f, 0.11840274f, -0.14479141f, -0.05212671f, -0.16923621f, 0.08626398f, -0.02887908f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.08917682f, 0.00029034f, 0.13483278f, 0.12664180f, 0.12113933f, 0.01674463f, 0.13849656f, 0.12090290f, 
    -0.05893775f, -0.18629387f, -0.05869938f, 0.16709039f, 0.20877668f, -0.04096065f, -0.12647787f, 0.10399055f, 
    0.10769344f, 0.18028294f, 0.25240749f, -0.12503964f, 0.22356403f, 0.05982853f, -0.18781452f, 0.09479801f, 
    -0.20312528f, 0.01674826f, 0.06393173f, 0.09743928f, 0.06847151f, -0.04123501f, 0.06133508f, 0.07189671f, 
    -0.05719247f, 0.04922076f, 0.16187389f, -0.03959552f, 0.15495892f, -0.16768505f, 0.33382541f, 0.11002621f, 
    -0.17183717f, -0.10053382f, -0.25435957f, -0.02638126f, 0.10290083f, 0.17960297f, 0.13482238f, -0.07548948f, 
    -0.07392182f, 0.18069331f, 0.12011229f, 0.16703665f, -0.03316591f, -0.08122166f, 0.15971163f, -0.00941505f, 
    -0.03072175f, 0.15543664f, -0.10292117f, 0.17319301f, -0.00763968f, -0.02677440f, 0.16948470f, -0.02185804f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.13726366f, 0.09376073f, -0.26612630f, -0.40149340f, -0.53205514f, 0.06694145f, 0.08729173f, 0.12374672f, 
    0.02167961f, 0.00302704f, -0.19923747f, -0.38203052f, -0.29211894f, -0.63111639f, -0.07609453f, -0.01977717f, 
    0.13312182f, 0.11607625f, 0.11962785f, -0.31771636f, 0.67355251f, 0.08284891f, 0.04057900f, 0.12406625f, 
    0.10478239f, -0.36043158f, 0.19924307f, -0.00302426f, 0.11262830f, -0.12816389f, -0.05670717f, -0.49303314f, 
    -0.12415078f, -0.42152071f, 0.17811774f, -0.09231181f, 0.27223590f, -0.36477774f, 0.19583321f, -0.16730352f, 
    -0.05777960f, 0.00225677f, -0.14701340f, -0.14947113f, -0.05614507f, 0.13713184f, 0.18141191f, 0.01453697f, 
    -0.06034429f, 0.70422262f, -0.08653180f, 0.28250086f, 0.38198698f, 0.36841592f, -0.44564998f, -0.04880719f, 
    0.05071180f, -0.03885283f, -0.04544635f, 0.09541834f, -0.04049863f, 0.10837837f, -0.33715972f, 0.00071668f, 
    0.06446961f, 0.09991743f, -0.35013288f, -0.70551342f, -0.09173618f, -0.36461467f, 0.17893574f, -0.01561057f, 
    0.27340221f, 0.08839645f, -0.74819762f, -0.36732620f, 0.09781753f, -0.13241576f, 0.07955255f, 0.28613532f, 
    -0.14285201f, -0.18403567f, -0.06107763f, 0.31861404f, 0.15143341f, -0.04273315f, -0.00807683f, 0.05176495f, 
    0.06543114f, -0.21347910f, -0.49236590f, 0.31443828f, -0.06092506f, -0.22348911f, 0.06038950f, -0.08891019f, 
    -0.16759826f, -0.18378747f, -0.03286868f, -0.16221763f, 0.06558793f, 0.17998061f, -0.19874722f, 0.13531467f, 
    0.33313930f, 0.21138065f, 0.37403986f, -0.05977610f, 0.11025903f, -0.06995127f, -0.33390388f, -0.04323958f, 
    -0.00544424f, 0.10875482f, 0.28625765f, -0.05111334f, 0.27899930f, -0.40054357f, 0.08948855f, -0.02025536f, 
    -0.08831167f, -0.11471918f, 0.01584817f, 0.33224404f, -0.63408321f, -0.04807705f, 0.24708064f, 0.00064432f, 
    0.05030081f, 0.40068811f, -0.55864418f, 0.12081617f, 0.06555110f, 0.62226784f, 0.20678872f, 0.13340290f, 
    -0.12488943f, 0.36480916f, -0.15364473f, 0.29887459f, -0.67073768f, -0.41115800f, -0.23899296f, -0.06990737f, 
    -0.64751953f, -0.00647688f, 0.01023664f, -0.63085794f, 0.02288795f, -0.09229843f, -0.05946466f, -0.49466124f, 
    -0.52216125f, 0.15129425f, 0.39966547f, 0.12688659f, 0.23926844f, -0.44888419f, -0.36413682f, 0.26752555f, 
    -0.43858758f, -0.57646292f, -0.28255090f, 0.20653422f, -0.16290841f, 0.17240234f, -0.37460399f, 0.16566841f, 
    0.38939151f, -0.00864009f, -0.30024377f, 0.00374165f, 0.02179783f, -0.05439087f, -0.18239333f, -0.09940785f, 
    -0.10411927f, 0.29200655f, -0.08962344f, -0.15233462f, -0.25115219f, -0.19182435f, 0.04274936f, -0.00298349f, 
    -0.03570628f, -0.07325487f, -0.07973234f, -0.07103704f, -0.37221566f, 0.02291999f, -0.56280953f, -0.12668170f, 
    0.00846510f, -0.04696063f, 0.34094128f, -0.01766481f, 0.03091506f, 0.01977888f, -0.37034652f, 0.15755679f, 
    -0.27255696f, -0.23083007f, -0.12153596f, 0.22310035f, 0.62602943f, -0.01417653f, 0.10238960f, 0.05200998f, 
    0.11807134f, -0.19580351f, 0.00678680f, -0.35059458f, -0.49561614f, -0.03157905f, 0.06870388f, 0.09726417f, 
    -0.45203760f, -0.07705399f, 0.07639495f, -0.39428124f, -0.27929220f, 0.08471224f, 0.29309052f, -0.15407145f, 
    -0.58916658f, 0.14105149f, 0.12194023f, 0.02172132f, 0.30418944f, 0.22832406f, 0.20059098f, -0.64329493f, 
    0.07075569f, 0.04567891f, -0.18496211f, -0.13203670f, -0.81922209f, -0.41293320f, -0.37996057f, -0.12137692f, 
    -0.07272924f, -0.41939640f, -0.78649271f, 0.12778215f, 0.21175531f, 0.25424373f, -0.23416762f, 0.06591450f, 
    0.01405020f, 0.03430069f, -0.03621775f, -0.60877222f, -0.03379262f, -0.11138669f, -0.42947406f, -0.09976072f, 
    -0.00726210f, -0.19360968f, 0.14738061f, 0.34134158f, 0.18553117f, 0.10681644f, 0.11260470f, -0.46991026f, 
    -0.24412294f, -0.15550485f, -0.48952556f, 0.15849026f, -0.12145281f, -0.26949960f, 0.02107267f, 0.17319645f, 
    0.02209899f, 0.44947633f, 0.17936678f, -0.20706856f, -0.39014140f, 0.10875638f, -0.02462830f, 0.02322467f, 
    -0.21536051f, 0.03413683f, 0.41617733f, -0.35546598f, -0.22069946f, -0.09530538f, 0.12415615f, 0.21125287f, 
    -0.27135989f, -0.45870328f, -0.00031901f, 0.00814278f, 0.12074190f, -0.35499531f, 0.33802202f, 0.17818961f, 
    -0.13950512f, 0.02146214f, -0.06513905f, -0.09342744f, 0.00822929f, -0.03052726f, -0.35718620f, 0.10001945f, 
    0.00047855f, -0.21649334f, -0.32370910f, 0.23139764f, -0.51139158f, 0.18094367f, -0.22226413f, -0.00591350f, 
    0.04800567f, 0.02651607f, 0.08071990f, -0.15163960f, 0.15757774f, 0.10885413f, 0.32781708f, 0.06331748f, 
    -0.00158601f, -0.11194712f, -0.21441923f, -0.03461270f, 0.12290176f, -0.62095678f, 0.13248222f, -0.04870635f, 
    0.10015241f, -0.13514224f, 0.19464315f, -0.82402521f, -0.00838774f, -0.11049548f, -0.18138494f, 0.14226548f, 
    0.07783826f, 0.09618676f, 0.27349204f, 0.33261004f, -0.37584558f, -0.11393609f, -0.05386934f, 0.04173807f, 
    0.31279776f, -0.32828292f, -0.26276347f, 0.15775275f, 0.23829480f, 0.18570437f, 0.08727255f, -0.21566325f, 
    0.71928537f, -0.30108741f, 0.18707567f, -0.00208125f, -0.08876830f, -0.25411439f, 0.19745302f, 0.25494853f, 
    -0.66093194f, -0.08629983f, 0.28704152f, 0.12486565f, 0.12264765f, 0.45504531f, 0.09946598f, 0.03750038f, 
    -0.11103517f, -0.49230370f, 0.16994177f, -0.08668691f, -0.08334713f, -0.07013666f, 0.23854458f, -0.07094585f, 
    0.08323353f, 0.10289474f, -0.09325680f, -0.01848570f, 0.13438453f, -0.02568880f, -1.05056608f, 0.08714482f, 
    0.03102742f, -0.30467054f, 0.06635990f, 0.37783289f, 0.21445948f, -0.10452238f, 0.06735544f, -0.59689116f, 
    -0.17399831f, -0.00178457f, -0.44691074f, 0.22924665f, 0.34165722f, 0.34841496f, -0.09959306f, -0.24750476f, 
    -0.36707497f, -0.08972950f, 0.26171157f, -0.38498524f, -0.85818917f, -0.05974947f, -0.05192015f, 0.25887093f, 
    0.10512831f, -0.47662842f, -0.54454601f, 0.21640542f, 0.17845565f, 0.31374341f, 0.24384080f, 0.31292653f, 
    -0.11670408f, 0.04995644f, 0.02238778f, -0.05754111f, -0.57965738f, -0.19256872f, -0.13123827f, -0.26811796f, 
    -0.60331523f, 0.22024502f, -0.82998848f, -0.05123941f, 0.21231475f, -1.22105742f, -0.45993030f, 0.08723934f, 
    0.12049890f, -0.18629675f, -0.01473702f, -0.14246373f, -0.29452407f, -0.14195770f, 0.17828989f, 0.03918767f, 
    -0.02350946f, -0.03322371f, -0.04124233f, -0.08404749f, 0.43982369f, -0.08540733f, -0.35200948f, -0.11946593f, 
    -0.02758444f, -0.28440043f, 0.07206917f, -0.49353510f, -0.56247294f, 0.05978925f, -0.36332437f, 0.15205880f, 
    -0.12250992f, 0.32628199f, 0.14179981f, -0.12394994f, -0.04345701f, 0.20529510f, -0.64420533f, 0.18754768f, 
    0.20598401f, -0.09960138f, 0.06234375f, -0.06094656f, 0.26150280f, 0.07818878f, -0.11267029f, -0.55483747f, 
    0.35555854f, 0.17052606f, 0.27269575f, -0.41711172f, -0.21812832f, 0.12167557f, 0.06784377f, -0.11553890f, 
    0.29561329f, -0.40631264f, 0.10712463f, -0.17245005f, 0.00832700f, -0.11230333f, -0.00066229f, 0.17932408f, 
    0.05114153f, -0.35282865f, 0.30106014f, -0.20890892f, -0.03951860f, -0.04711946f, -0.02838560f, -0.04642250f, 
    0.08819583f, -0.05470875f, -0.17206246f, 0.06170367f, 0.04994817f, 0.36641687f, -0.34779692f, -0.10639932f, 
    -0.12040090f, -0.09574307f, 0.12059982f, -0.36802083f, -0.31504178f, -0.04702483f, 0.18408421f, 0.10340541f, 
    -0.11624894f, 0.18827201f, 0.23302421f, -0.82892722f, 0.11963736f, -0.03792072f, -0.35489196f, -0.10836046f, 
    0.35189375f, -0.73952675f, 0.05978013f, -0.02428865f, -0.07154324f, 0.42507881f, 0.06374519f, -0.01421804f, 
    -0.29412073f, -0.03517770f, -0.36411843f, -0.23490031f, -0.13315770f, -0.08050007f, 0.04293461f, -0.37906346f, 
    0.15964086f, 0.22804661f, -0.49638841f, -0.11820761f, -0.24748933f, -0.34659982f, 0.24944289f, -0.42436689f, 
    -0.01381411f, 0.16351861f, -0.76542217f, -0.06308261f, 0.32009244f, 0.40402806f, -0.58824122f, 0.29390913f, 
    0.39249447f, 0.12497939f, -0.03615549f, -0.12196001f, 0.08035839f, -0.27241164f, 0.06697073f, -0.11450416f, 
    -0.00708349f, -0.74392015f, 0.33537820f, -0.66067648f, -0.10951956f, 0.20226817f, 0.04784324f, 0.11419178f, 
    0.03585068f, 0.06512467f, 0.09437838f, 0.20625524f, -0.47058105f, -0.07936940f, -0.19460480f, -0.05732700f, 
    -0.07885913f, -0.61154807f, 0.03677788f, 0.12825510f, 0.18022123f, 0.03292504f, -0.00602213f, -0.13313486f, 
    -0.09969784f, -0.05452601f, 0.12808919f, -0.13582024f, -0.99587125f, 0.41058359f, 0.34191567f, -0.76036382f, 
    0.02769545f, 0.19826810f, 0.08336286f, 0.27115089f, -0.06386710f, -0.03970705f, -0.01066818f, 0.11088266f, 
    0.13278148f, -0.13494459f, -0.02947523f, -0.03403122f, -0.14029454f, -0.13155371f, -0.20452712f, -0.17260659f, 
    0.41498259f, -0.03172673f, -0.12813780f, -0.02579704f, -0.59137887f, -0.19233048f, -0.08043694f, -0.07220932f, 
    0.22494648f, 0.06809790f, 0.23186947f, -0.10191209f, 0.19708599f, 0.52223724f, 0.32978755f, -0.11871213f, 
    0.04208331f, -0.08363616f, 0.29357025f, -0.17459187f, -0.34070328f, 0.05980382f, -0.35835686f, 0.11189137f, 
    0.00500616f, 0.01326830f, -0.10192652f, 0.03818168f, 0.40998968f, 0.03545495f, 0.19113693f, 0.02540618f, 
    -0.00796555f, 0.36983755f, 0.01726028f, 0.00381813f, -0.17830019f, -0.11294585f, 0.19634102f, 0.40424144f, 
    -0.35738343f, 0.13735721f, -0.61625832f, 0.33374232f, -0.35102287f, -0.43891504f, 0.09902550f, -0.32569832f, 
    0.20161639f, 0.12440643f, -0.94156611f, -0.02520899f, -0.21753326f, -0.09267900f, -0.03060868f, -0.10716611f, 
    -0.55424213f, 0.41739056f, 0.04330157f, 0.21697432f, -0.03568606f, -0.02923576f, 0.09398847f, -0.43301493f, 
    -0.12825219f, 0.37668538f, 0.05461552f, 0.02313791f, -0.17982921f, 0.38609788f, 0.10692763f, -0.01769254f, 
    0.26192814f, -0.40456986f, -0.20142008f, -0.02448425f, -0.39875063f, -0.70986289f, -0.16813935f, 0.12007997f, 
    -0.03938708f, -0.43245721f, -0.44097978f, 0.06304251f, 0.25165781f, -0.64701456f, 0.10604879f, 0.01437755f, 
    0.06342854f, 0.08657110f, -0.08259854f, -0.10756605f, -0.11073598f, 0.10473185f, 0.33292913f, 0.03466833f, 
    -0.10467802f, 0.08834299f, 0.23953947f, -0.00808441f, 0.08554929f, 0.01436703f, 0.02421032f, 0.08156768f, 
    0.07201026f, 0.06884120f, 0.37686411f, 0.25714451f, 0.34742507f, 0.14354692f, 0.21353534f, -0.19764650f, 
    -0.14919299f, -0.40107036f, -0.42634532f, -0.09485872f, -0.40577313f, 0.06101369f, 0.06518685f, -0.24305062f, 
    -0.39277980f, 0.16054386f, -0.08885909f, 0.10745673f, -0.16521618f, 0.06489337f, -0.47556552f, 0.26684731f, 
    -0.09106217f, 0.46999985f, 0.20047212f, -0.03500275f, 0.13907081f, 0.06137934f, 0.04805448f, -0.12254962f, 
    -0.48406422f, 0.15343794f, -0.31278718f, 0.01763736f, 0.05246526f, -0.69569576f, 0.39375067f, 0.12263902f, 
    -0.03511612f, 0.15542977f, -0.00367718f, -0.28974745f, -0.29300132f, -0.21934734f, 0.03629451f, -0.07719859f, 
    0.00112199f, 0.06097715f, -0.06715867f, -0.10289714f, -0.08997643f, 0.11012969f, 0.05438661f, 0.01825704f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06175096f, -0.03542974f, 0.05534209f, -0.01958271f, 0.07144688f, 0.13099533f, -0.05361321f, -0.25458539f, 
    -0.13131441f, 0.00367001f, 0.08846395f, 0.09856945f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
