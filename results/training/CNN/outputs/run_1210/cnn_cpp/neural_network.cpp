#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.77901119f, -0.67196262f, 0.51361978f, 0.63600475f, 0.62116802f, 0.28141370f, 0.84443748f, -0.02165735f, 
    -0.28687236f, -0.07469197f, 0.02521919f, -0.26670495f, -0.08409595f, -0.02533531f, -0.10420246f, -0.08188342f, 
    -0.29321614f, -0.46263286f, -0.02210674f, 0.34864104f, -0.37952888f, 0.11993154f, 0.44278330f, -0.19084685f, 
    -0.18813315f, 0.84512454f, 1.57677066f, 1.27638996f, -0.83040154f, -0.59519213f, -1.53823280f, -0.62317216f, 
    -0.46711180f, -0.72216064f, -0.86387044f, 0.00275401f, -0.33750498f, 0.18961242f, 0.46439114f, -0.11242606f, 
    0.23577504f, -0.27075669f, 0.12394650f, 0.23638128f, -0.21832000f, -0.22721842f, 0.14985569f, -0.18593267f, 
    0.02352609f, 0.29800785f, 0.55830485f, -0.04105567f, -0.21310967f, 0.53802973f, 0.61226207f, 0.22044721f, 
    0.49664316f, 0.16180180f, 0.39370120f, -0.32099512f, -0.18519248f, -0.52657837f, -0.34625626f, -0.06227572f, 
    0.24814798f, -0.11959974f, -0.13753024f, -0.09421688f, 0.17499934f, -0.03025356f, -0.15759777f, -0.61680025f, 
    -0.54657352f, -0.36281833f, -0.52803463f, 0.53841668f, 0.17697461f, -0.63944316f, -1.27276826f, -1.09742510f, 
    0.35157433f, 0.08488002f, -0.43196192f, -0.60144830f, 0.74575621f, -0.06278639f, 0.69653547f, -0.12608184f, 
    0.06610772f, 0.37244499f, 0.11308798f, 0.45074642f, 0.44176853f, -0.26047963f, -0.28508270f, -0.07395005f, 
    -0.39734045f, -0.48755845f, 0.01673138f, 0.21246511f, -1.77793288f, 0.77536881f, 0.52246386f, -1.18180966f, 
    0.00098467f, -0.94664073f, 0.05470673f, 0.62658793f, 0.98244238f, 0.73119342f, -0.36316809f, -0.09667881f, 
    -0.20552820f, -0.38614765f, 0.44460553f, -0.07279299f, -0.05060878f, -0.14940856f, -0.06239848f, -0.18398871f, 
    -0.32287392f, 0.04160114f, 0.45949301f, -0.26337698f, -0.13666567f, -0.39198849f, -0.61001533f, -1.50214756f, 
    -1.71655047f, -1.08525527f, 0.33008799f, 0.18937302f, 0.69550246f, 0.14824879f, 0.00456283f, -0.72283047f, 
    -0.49794737f, -0.63547069f, -0.74878478f, -0.53453130f, -0.25667939f, -0.25153351f, 0.21423064f, 0.05853647f, 
    -0.06185539f, -0.14841597f, 0.07219554f, -0.03498306f, 0.08128534f, -0.16480377f, -0.07295639f, -0.22689547f, 
    0.20632686f, 0.44008210f, 0.38700268f, -1.32372725f, -0.74566287f, 0.42434475f, 0.79135019f, 0.69071633f, 
    -0.33038768f, -0.08687316f, 0.25968960f, 0.42045406f, -0.36911526f, 0.11677473f, 0.02952962f, -0.01228246f, 
    0.08975940f, -0.57547498f, -0.35160246f, -0.15790564f, -0.02704955f, -0.26922539f, 0.41478470f, -0.73933601f, 
    -0.66834742f, -0.06976569f, 0.57155406f, 0.49407998f, 0.59763956f, -0.77401787f, 0.07254753f, 0.54833180f, 
    -0.55523407f, -0.14393619f, 0.43468922f, -0.48412445f, 0.95732796f, -0.79434729f, -0.33954364f, 0.23449937f, 
    0.23780409f, -0.12628621f, -0.02333074f, 0.19257745f, 0.42264476f, -0.12947713f, -0.21810748f, 0.14616686f, 
    -0.22891133f, -0.29987130f, -0.63655263f, -0.49760100f, -1.11745167f, -1.21565819f, -0.93054318f, -0.69783187f, 
    -1.01474535f, -1.19023049f, 0.69935018f, -0.37612662f, -0.18332620f, 0.01622562f, 0.16952078f, -0.12167893f, 
    0.00266156f, -0.36779240f, -0.66975814f, -0.62833136f, -0.47411451f, -0.34674534f, 0.34083864f, -0.51288205f, 
    -0.03574659f, 0.82043761f, 0.54976118f, -0.01480814f, 0.10428136f, 0.46533576f, 0.31020257f, -0.12834680f, 
    0.17228678f, 0.04366442f, 0.18921071f, -0.26749578f, -0.00057476f, 0.14145453f, 0.16831882f, 0.01578401f, 
    0.00036527f, 0.09922636f, 0.15423954f, -0.01110793f, -0.11352424f, -0.06325465f, 0.14068370f, 0.27217931f, 
    -0.21634951f, -0.31430516f, -1.01512861f, -0.91243190f, -0.26489076f, -0.11282589f, -0.25719506f, -0.26986668f, 
    -0.37021685f, -0.46287033f, -0.82043105f, -0.89598352f, 0.00578297f, 0.19364248f, 0.06362706f, -0.09892120f, 
    -0.07969604f, -0.13163333f, -0.33175832f, 0.20365462f, 0.00143763f, -0.31205896f, 0.24593243f, 0.28665277f, 
    0.45842373f, 0.52280754f, 0.58684260f, -1.02316976f, -1.14191484f, -0.79216611f, -0.20765515f, -0.91022718f, 
    1.00504434f, 0.58819026f, 0.34458840f, 0.32365873f, 0.69774902f, 0.17979848f, 0.19045757f, 0.26214594f, 
    0.08075079f, -0.16546030f, -0.23719327f, -0.15975596f, -0.27144995f, -0.29686770f, -0.31706449f, -0.32213885f, 
    -0.08361507f, -0.16402473f, -0.29099432f, -0.12066146f, 0.99314094f, -0.36176911f, 0.09396497f, -0.28580588f, 
    -0.84314275f, 0.59880936f, -0.47559598f, -0.36659420f, 0.17273125f, 0.17272830f, 0.77616012f, -0.11187470f, 
    -0.41029200f, -0.26846120f, -0.36391839f, -0.00271779f, -0.01016462f, -0.49322036f, -0.19136462f, -0.81501508f, 
    -0.39600992f, -0.39399478f, -0.28199449f, -0.70309442f, -0.87676853f, 0.96851093f, 0.70733839f, -1.12658203f, 
    -1.42170167f, -1.27126551f, 0.12014789f, -0.22967970f, 0.69061714f, -0.18709750f, 0.17847510f, 0.15860987f, 
    0.22051501f, 0.76553297f, -0.06855743f, -0.16953295f, -0.14646885f, -0.39807311f, -0.25053114f, -0.37838259f, 
    -0.30447945f, 0.47157523f, 0.03090308f, 0.01035215f, 0.17368251f, 0.43009710f, 0.40210366f, 0.06014589f, 
    0.17294320f, -0.29385546f, -0.23227385f, -0.44853875f, 0.20124517f, 0.63545299f, -0.15592398f, -0.33496225f, 
    -0.00652352f, 0.31078321f, -0.06911079f, -0.30308324f, 0.17902537f, 0.73333621f, 0.34737858f, -0.12639697f, 
    0.28734401f, -0.15429857f, 0.61933541f, 0.04614975f, -0.56617808f, -0.04048512f, 0.16918989f, -0.39702797f, 
    1.06172860f, 0.22372048f, 0.35737473f, -0.58156842f, -0.42982745f, -0.68730277f, 0.21891172f, 0.96366882f, 
    -0.16819483f, -0.79421508f, -0.36178857f, -0.16686125f, 0.10736696f, -0.38421953f, 0.35458052f, 0.05167207f, 
    -0.19625713f, 0.03508661f, 0.42466447f, -0.31232309f, 0.11093012f, -0.00202534f, -0.04564798f, -0.22777916f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.84416950f, 0.31359476f, 0.17797798f, 0.82045740f, 0.22768074f, 0.03047841f, 0.98339820f, 0.41983730f, 
    -0.01006078f, 0.03468686f, 0.10508377f, -0.12290525f, 0.04296188f, 1.03283095f, 0.45936838f, 0.33359924f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.76174110f, -0.33882430f, -0.10403460f, -0.66873556f, 0.07833126f, -0.24979818f, 0.19701697f, -0.03901165f, 
    -0.12089242f, -0.11277598f, 0.08098514f, 0.18831922f, 0.05993840f, -0.06104616f, -0.07917763f, 0.03555902f, 
    -0.06770381f, 0.06695413f, 0.05552560f, 0.07847423f, 0.04572714f, 0.06509266f, -0.06230011f, 0.03294326f, 
    -0.58623797f, -0.59784722f, 0.03864070f, 0.07764041f, 0.01007191f, 0.17013623f, 0.17421120f, 0.04645697f, 
    0.30845717f, 0.02741102f, 0.18734625f, 0.01696580f, 0.40124720f, -0.07675436f, -0.27955407f, 0.11882576f, 
    -0.08233599f, -0.05112950f, -0.28193128f, -0.07543059f, -0.11413520f, 0.07127988f, 0.05063797f, 0.01340775f, 
    -0.65183151f, -0.31893027f, 0.39108524f, -0.05004789f, -0.16531573f, 0.08831279f, 0.06159975f, 0.16290057f, 
    -0.07331011f, -0.11245030f, -0.00733902f, -0.08834865f, 0.42837375f, 0.09319757f, -0.15926066f, 0.01803563f, 
    0.27840543f, 0.41910926f, 0.05576621f, 0.09154299f, 0.07996809f, -0.01439401f, -0.02690046f, 0.02900513f, 
    -0.62213755f, -0.00898242f, 0.37929076f, -0.17458630f, -0.13820186f, -0.05597712f, 0.02905394f, 0.03784949f, 
    -0.26886636f, -0.25008026f, -0.32797405f, -0.03526989f, 0.31903732f, 0.16136762f, 0.23744263f, -0.34659287f, 
    -0.32974699f, -0.03356355f, -0.06861305f, -0.11626525f, -0.09895400f, -0.13396128f, -0.28587392f, -0.31268618f, 
    0.70411086f, 0.33189571f, -0.10153531f, -0.33009267f, 0.19610989f, -0.02472267f, -0.22647336f, 0.27625436f, 
    -0.04056214f, 0.05875161f, 0.00567565f, -0.14414003f, -0.20588258f, -0.03113503f, -0.09459856f, 0.22981010f, 
    0.14365412f, 0.00533509f, 0.01182305f, -0.03201825f, 0.04252496f, -0.01729372f, 0.04624772f, 0.06398035f, 
    0.63898087f, 0.26094592f, -0.25215203f, -0.33359331f, 0.16904269f, -0.02301082f, 0.08460806f, -0.09750667f, 
    -0.00433548f, -0.11187776f, -0.04780265f, -0.02143104f, 0.32643545f, 0.20022647f, -0.20050760f, 0.09220066f, 
    0.25771976f, 0.10597096f, 0.06477701f, -0.11109100f, 0.00709228f, 0.12408925f, 0.05326089f, 0.22578205f, 
    -0.45183232f, -0.34424216f, -0.13192254f, -0.02662545f, -0.01425785f, -0.20501845f, -0.13635843f, -0.03700897f, 
    -0.34202462f, -0.10280324f, -0.02289900f, 0.28557023f, 0.35749835f, -0.02521440f, -0.53501391f, -0.05194794f, 
    -0.05782264f, -0.17146078f, -0.22432308f, -0.27914748f, -0.13242301f, -0.18773359f, -0.19240527f, -0.04580409f, 
    -0.22788274f, -0.09457871f, -0.06558254f, 0.06996179f, -0.36198297f, -0.29924330f, -0.51925880f, -0.27985689f, 
    -0.00343258f, 0.05542303f, -0.00674340f, -0.04458794f, -1.39922523f, -0.03406580f, 0.36205658f, -0.25944680f, 
    -0.03251686f, 0.05235483f, 0.04807487f, 0.02014740f, 0.12225635f, -0.11065201f, -0.07782990f, -0.05369836f, 
    0.55588323f, -0.09411635f, 0.35850814f, 0.29729292f, -0.09749126f, -0.00508496f, 0.10192561f, 0.08475666f, 
    -0.05257634f, 0.28267774f, 0.25463483f, 0.20053412f, 0.57143617f, -0.55469078f, -0.08723529f, -0.48912099f, 
    -0.29555625f, -0.20240226f, -0.25410974f, 0.06586580f, -0.07045206f, -0.03798772f, 0.05754017f, 0.06281546f, 
    0.32966948f, 0.21080960f, 0.14072551f, 0.20240422f, -0.03792804f, -0.06327788f, -0.11581634f, -0.13305458f, 
    -0.31871307f, -0.16219118f, 0.24164447f, -0.16271354f, 0.25878829f, -0.41912949f, -0.00705455f, -0.28419957f, 
    0.31801462f, 0.25402465f, -0.20768249f, -0.27495584f, 0.30069706f, 0.00968853f, -0.21234925f, -0.01780741f, 
    -1.22269380f, -0.04192801f, 0.20186810f, -0.35950994f, 0.15574583f, 0.07850523f, -0.13485312f, -0.01204704f, 
    0.10742843f, 0.13508390f, -0.25469294f, -0.05296648f, 0.34509164f, 0.67152387f, 0.03541061f, -0.13412037f, 
    -0.13347182f, -0.00051101f, 0.05275944f, -0.10699600f, -0.02690143f, -0.03276606f, -0.26741919f, -0.13161375f, 
    -0.60497695f, 0.26394370f, 0.27409494f, -0.08775188f, 0.19072966f, 0.13009405f, -0.02126103f, -0.19432212f, 
    0.15064354f, 0.06004158f, 0.03418493f, 0.10494151f, -0.51517582f, -0.04350557f, -0.31958804f, 0.15497500f, 
    -0.05922464f, -0.17651202f, 0.27883458f, 0.08513264f, 0.04732206f, -0.27506226f, 0.04497843f, 0.25950786f, 
    -0.22254677f, -0.04356375f, 0.36877736f, -0.29209360f, 0.06989705f, 0.00673638f, 0.00331722f, 0.00412134f, 
    -0.01562065f, 0.05004041f, -0.00818212f, 0.20440055f, 0.17355146f, 0.25635785f, 0.03314383f, 0.18789977f, 
    -0.03340081f, -0.01261933f, -0.03003704f, 0.00224150f, -0.10798250f, 0.06060017f, 0.08460418f, -0.04397401f, 
    -0.19034623f, 0.07869603f, 0.32392305f, 0.34599453f, -0.11114430f, 0.10804743f, 0.12345392f, 0.24663392f, 
    -0.09726463f, 0.09203435f, 0.02745559f, 0.01377918f, 0.28031754f, -0.14045495f, -0.23020616f, -0.05476688f, 
    0.00203328f, -0.03772219f, -0.04835798f, -0.12463296f, -0.25674945f, -0.34531406f, -0.20366287f, -0.17576456f, 
    0.06447992f, -0.01267313f, 0.28999475f, -0.34924635f, -0.08069653f, -0.00014104f, -0.15785681f, 0.14627802f, 
    -0.19980004f, -0.30375975f, -0.43796706f, -0.21911232f, 0.13474739f, -0.61583412f, 0.05319552f, -0.34611556f, 
    0.03639810f, 0.21693102f, -0.00901688f, 0.33756009f, 0.12554348f, 0.02170527f, 0.02714916f, 0.08158454f, 
    0.06466454f, -0.05948007f, 0.03341962f, 0.05726142f, 0.12525256f, 0.11773280f, 0.26752311f, -0.16164373f, 
    -0.19224800f, -0.18774767f, -0.09731043f, 0.01440725f, -0.31180617f, 0.25360709f, 0.28700420f, -0.29330117f, 
    -0.03748254f, -0.10834073f, -0.13662456f, -0.06115512f, 0.01353415f, 0.00506929f, -0.04077006f, -0.13669243f, 
    0.07650468f, 0.26864237f, -0.35548875f, 0.02147538f, 0.08603919f, -0.03112651f, 0.11083059f, 0.11799050f, 
    -0.25581419f, 0.12145009f, 0.04319281f, -0.09094851f, -0.85355026f, -0.88171881f, 0.35413262f, -0.79516482f, 
    0.13123874f, -0.42898270f, -0.57793295f, -0.34384415f, 0.07460057f, -0.08470339f, 0.05412272f, -0.04044038f, 
    0.00744709f, -0.06643771f, -0.35683689f, -0.04780125f, -0.00277769f, -0.04347674f, -0.00919386f, 0.04627744f, 
    0.15403824f, 0.22463250f, -0.20240185f, -0.08782594f, 0.18679257f, 0.12294701f, 0.15702423f, -0.21247981f, 
    0.08183572f, 0.00752304f, -0.10401732f, -0.14220215f, 0.06307875f, 0.13604988f, -0.02653605f, 0.18814814f, 
    0.46783850f, 0.40332940f, -0.15505007f, 0.02469756f, 0.09983639f, 0.15850192f, 0.07685669f, -0.22110011f, 
    -0.13348624f, 0.13963190f, -0.13055426f, 0.15483057f, -0.44999015f, 1.08509719f, 0.70541084f, 0.34035748f, 
    -0.11727359f, 0.05465131f, 0.20299801f, -0.05117892f, 0.04595790f, -0.03543200f, -0.05112703f, -0.19372998f, 
    -0.18959242f, 0.06808675f, -0.07743552f, 0.12686898f, -0.16339679f, 0.05130051f, 0.10404754f, -0.05580812f, 
    0.01436963f, -0.16487372f, 0.05484299f, 0.00119540f, -0.14169016f, 0.07320972f, -0.33804384f, -0.03475927f, 
    -0.22283971f, 0.03010514f, -0.11729938f, 0.51891738f, 0.08525538f, 0.10251929f, -0.07225660f, -0.06069420f, 
    -1.50289202f, -0.75406748f, 0.04951211f, -0.28678980f, 0.01431047f, 0.16795827f, 0.05751489f, -0.34740886f, 
    -0.10655889f, 0.00774307f, 0.01947489f, 0.04327079f, -0.13285506f, -0.16869424f, 0.12916595f, -0.10653754f, 
    -0.11038505f, -0.06065770f, 0.12627433f, -0.07659966f, 0.03103283f, -0.13901763f, -0.01889720f, 0.01986414f, 
    -0.45715761f, -0.36023268f, -0.16456217f, -0.28326231f, 0.23966436f, -0.14859258f, 0.14958246f, 0.08658570f, 
    -0.06063953f, -0.11868335f, -0.06005570f, -0.14255722f, 0.14687379f, 0.24153532f, 0.58334219f, 0.43388423f, 
    -0.05679381f, 0.03557300f, 0.06083274f, 0.06776366f, -0.13942151f, -0.13357377f, 0.19673139f, -0.04178590f, 
    -0.37702575f, 0.45963487f, 0.17226249f, 0.02838352f, -0.06665032f, 0.00668508f, -0.02085304f, -0.08682404f, 
    0.28302112f, -0.08412584f, 0.14638187f, 0.51111180f, -0.16888608f, 0.53476894f, 0.03427103f, 0.19050331f, 
    0.03162279f, 0.07364929f, -0.03774919f, -0.05060026f, 0.10885520f, -0.10466912f, -0.12674661f, 0.02688287f, 
    -0.04638339f, 0.09206346f, 0.06257857f, 0.15516877f, -0.12637630f, -0.02124436f, -0.22672817f, 0.14092602f, 
    0.20983008f, -0.12413298f, -0.03555997f, 0.11290988f, -0.02838378f, -0.16168648f, -0.44389170f, -0.13736311f, 
    -0.06350100f, 0.03972583f, 0.04008561f, 0.09830730f, -0.10292009f, 0.09543685f, 0.03180420f, -0.00222200f, 
    -0.74473888f, 0.92811525f, -0.60063320f, -0.77990723f, 0.08419059f, 0.09993374f, -0.24652827f, 0.15425305f, 
    -0.35149965f, -0.19674754f, 0.05625002f, -0.18520747f, 0.02381032f, -0.24040452f, 0.57272768f, 0.18522444f, 
    -0.06600618f, 0.12565358f, -0.04259330f, -0.11917414f, 0.14799726f, -0.06077066f, 0.27174425f, -0.05172833f, 
    0.53145951f, 0.56603169f, -0.38045272f, 0.30604506f, 0.06071727f, 0.02479596f, 0.02858616f, 0.04595112f, 
    -0.00007553f, 0.11032797f, 0.13726503f, -0.01838381f, -0.31043872f, -0.30339229f, -0.24762161f, 0.40207517f, 
    -0.11401855f, -0.17629457f, 0.12460656f, -0.04564983f, 0.02496343f, 0.07766382f, -0.10064840f, -0.00851837f, 
    1.70416677f, 0.01707481f, -0.05181948f, -0.00098660f, 0.15379575f, -0.12300327f, -0.14170009f, -0.20534228f, 
    -0.18692295f, -0.12959781f, -0.02538921f, 0.05333137f, 0.29516864f, -0.25607461f, -0.10115316f, 0.28422347f, 
    0.12266095f, -0.06315116f, -0.02714418f, -0.04338621f, 0.07479992f, 0.08978309f, 0.13889158f, 0.26060823f, 
    -0.09442348f, -0.21903019f, -0.18139027f, -0.62656534f, -0.67234170f, -0.17472655f, -0.21686573f, -0.02117752f, 
    -0.01048898f, -0.16547535f, 0.15286380f, -0.44098663f, 0.05380876f, -0.09258328f, -0.30585372f, -0.66492295f, 
    -0.18910988f, -0.10156526f, -0.01813472f, 0.11802604f, -0.38682270f, 0.09376699f, -0.06632715f, -0.03955736f, 
    0.00990657f, -0.30697152f, -0.00766258f, 0.09369142f, -0.14554572f, 0.24995968f, -0.02778328f, 0.08433177f, 
    -0.01193652f, -0.14213111f, -0.17950189f, -0.11229164f, -0.50081170f, -0.83252764f, -0.49124792f, -0.12429573f, 
    -0.06480646f, -0.05690952f, -0.35683593f, 0.28456739f, 0.05758560f, 0.06558162f, 0.02016094f, 0.19730842f, 
    -0.00286260f, 0.00223149f, -0.03872509f, 0.21132745f, -0.06054042f, 0.05715533f, -0.05932000f, -0.05262529f, 
    -0.03146261f, 0.01990089f, -0.10028255f, -0.01249706f, -0.30700082f, -0.15083966f, 0.02952803f, 0.19231050f, 
    0.38844267f, 0.16078486f, -0.05624020f, 0.18820266f, -0.10622604f, 0.10714648f, 0.03028450f, -0.02237187f, 
    -0.43125278f, 0.03740386f, 0.10453726f, 0.12572497f, -0.13052925f, 0.22261226f, -0.13874254f, -0.07847758f, 
    -0.11849434f, 0.29674196f, -0.01906854f, 0.18332049f, -0.17355250f, 0.08162793f, -0.21263026f, 0.70184785f, 
    0.04818702f, 0.04227659f, -0.08035925f, -0.05000604f, 0.01559581f, 0.04752196f, 0.24033280f, -0.01050942f, 
    -0.18449889f, 0.04096473f, 0.11958833f, 0.08944245f, -0.15538269f, -0.19163100f, 0.21671531f, -0.19722475f, 
    -0.19672494f, -0.11450750f, -0.21803237f, -0.12489912f, 0.58388245f, 0.22343113f, 0.40054718f, -0.49961784f, 
    -0.46473396f, -0.03294230f, -0.07479275f, 0.24576226f, 0.07019786f, 0.04532253f, 0.32185316f, -0.03442804f, 
    -0.14755961f, -0.97889501f, 0.10187128f, 0.09356236f, -0.06060205f, -0.07991880f, -0.06837653f, -0.09524970f, 
    -0.15365413f, -0.18473819f, -0.14341480f, -0.12558936f, 0.07761487f, 0.73969513f, -0.14241241f, 0.58123714f, 
    0.26896214f, 0.22691397f, 0.04739409f, -0.01368293f, 0.07712561f, -0.00227474f, -0.02808000f, -0.11190284f, 
    -0.10210808f, 0.04252852f, -0.03143050f, -0.03830713f, 0.14132628f, 0.05960745f, -0.01508775f, 0.09626452f, 
    0.14023778f, -0.05743481f, -0.18216036f, 0.50152302f, -0.03591302f, 0.19524679f, -0.01720011f, 0.17864706f, 
    -0.06206692f, -0.11927906f, -0.26683810f, -0.31157702f, -0.13501829f, -0.01883590f, 0.05373804f, -0.06836461f, 
    -0.40134072f, 0.06289233f, -0.44002268f, -0.14435565f, 0.01501009f, -0.10961173f, 0.10042403f, 0.03605816f, 
    -0.04230860f, -0.32452902f, 0.09928997f, -0.01099456f, -0.57151061f, -0.29692841f, 0.12960851f, 0.08574833f, 
    -0.08698856f, -0.01525462f, -0.21750693f, -0.13184294f, -0.03237871f, -0.07473289f, 0.04140002f, -0.00170176f, 
    -0.23756005f, -0.23498601f, -0.21152906f, -0.00963547f, -0.14478636f, -0.02747548f, -0.03299431f, 0.07149151f, 
    0.02767237f, -0.13878936f, 0.12235203f, -0.14855526f, 0.15779233f, -0.41178423f, 0.31643254f, -0.12990955f, 
    -0.21443284f, -0.02346452f, -0.37371022f, -0.08675402f, -0.00961581f, 0.16248290f, -0.37255433f, -0.04794088f, 
    0.13393222f, 0.38123971f, 0.30679083f, 0.32889965f, -0.01141040f, -0.19078872f, 0.09628704f, 0.09487805f, 
    0.08616408f, -0.11005201f, 0.13487460f, -0.02424907f, 0.16665205f, 0.05544739f, 0.00639139f, 0.00290098f, 
    0.20326230f, 0.16613686f, 0.12979202f, 0.05235841f, 0.15485762f, 0.03369596f, 0.05204101f, 0.02769208f, 
    0.24020864f, 0.11308748f, 0.27521443f, 0.05907449f, -0.04285665f, -0.00133275f, 0.07677923f, -0.00192700f, 
    -0.03169067f, -0.00097676f, 0.04275179f, 0.01169204f, 0.49092677f, 0.20854020f, 0.23051071f, 0.16002882f, 
    -0.11930507f, -0.20307760f, 0.16380756f, 0.17365703f, 0.17737031f, -0.08074208f, 0.06173405f, 0.14229012f, 
    0.37493053f, 0.01414940f, -0.42918697f, 0.19016610f, 0.08607534f, -0.17406476f, -0.12510963f, -0.12588784f, 
    0.32225499f, 0.03617020f, 0.02304558f, 0.32025212f, -0.16898689f, -0.09733906f, 0.19162104f, 0.08606555f, 
    -0.12932631f, -0.06452268f, -0.19395217f, -0.22203058f, -0.11668337f, -0.18956870f, 0.05215980f, -0.12734896f, 
    0.04433018f, 0.02713025f, 0.09212617f, -0.02363219f, -0.28917521f, -0.35094464f, -0.06261250f, -0.22369416f, 
    0.25946414f, -0.06714959f, -0.05820811f, -0.26141420f, 0.32479495f, -0.63517833f, -0.50648314f, 0.14118300f, 
    0.00576788f, 0.02153226f, 0.12869933f, 0.03667373f, 0.18455559f, 0.00873402f, 0.04278521f, -0.04352138f, 
    -0.41885984f, -0.13302116f, 0.18442307f, 0.27961886f, 0.07610594f, -0.21020159f, -0.00302279f, 0.11722219f, 
    0.21009608f, -0.12024343f, -0.36775506f, 0.04691442f, -0.27344173f, 0.17921858f, -0.59943664f, 0.33163336f, 
    0.18041666f, -0.07138583f, 0.01806830f, 0.08864389f, -0.10525510f, 0.03560668f, -0.07054540f, 0.04670651f, 
    -0.31867638f, -0.35824892f, -0.04789235f, -0.11668674f, -0.05672666f, 0.05626197f, 0.10342561f, 0.06913120f, 
    -0.24678254f, -0.11726784f, -0.42693958f, -0.31060848f, -0.15844339f, 0.24149100f, -0.15754214f, -0.39778095f, 
    0.04596129f, -0.05276903f, 0.02526255f, 0.46782184f, -0.18812421f, -0.24049188f, 0.19239469f, 0.05818145f, 
    -0.58137310f, -0.14375678f, -0.02601242f, 0.23232982f, -0.15895662f, -0.21324897f, 0.10825668f, 0.01778511f, 
    0.18298505f, 0.09256689f, -0.29058054f, -0.12582549f, 0.03287610f, 0.03247584f, -0.12594281f, -0.26977336f, 
    0.07123946f, -0.04847005f, 0.12940462f, 0.07415191f, -0.07384264f, -0.03671784f, 0.09581988f, 0.03344929f, 
    0.23822580f, -0.58039355f, 0.23625565f, 0.37475228f, -0.10134548f, -0.12499916f, -0.01421022f, 0.27068058f, 
    -0.02446528f, 0.22627865f, 0.00339136f, 0.15702356f, 0.45706460f, 0.08832958f, 0.05352821f, 0.00495482f, 
    0.01430972f, 0.08174098f, 0.09801165f, -0.36695910f, 0.16814570f, 0.17993334f, 0.37614930f, -0.12887079f, 
    0.21695797f, 0.31274459f, 0.16570234f, 0.19802171f, 0.14285925f, 0.05709796f, -0.13596123f, -0.17066336f, 
    0.03907163f, 0.00620594f, 0.04371573f, -0.02245928f, -0.02633575f, -0.43116665f, 0.09042376f, -0.04905206f, 
    -0.10052790f, 0.05085555f, -0.08284137f, -0.13663347f, 0.05056516f, -0.09412073f, -0.04749329f, -0.13747068f, 
    0.04278499f, 0.14146344f, 0.10596363f, -0.18140569f, 0.14924167f, 0.20918550f, 0.34536478f, -0.12285724f, 
    0.21619943f, 0.06752368f, -0.05000452f, 0.08214799f, -0.56402415f, -0.49217159f, -0.36986408f, -0.61992419f, 
    0.00598185f, 0.12232439f, -0.03265460f, 0.07892943f, 0.22241753f, -0.12614663f, 0.10630183f, -0.04059497f, 
    0.16811493f, -0.09492852f, -0.27780288f, -0.28248101f, 0.01460162f, 0.07463390f, 0.09233201f, -0.00882269f, 
    0.09456914f, -0.30328774f, 0.01302260f, -0.41514924f, 0.14848796f, 0.07520877f, -0.08602142f, -0.21193449f, 
    -0.08743869f, -0.00737317f, -0.13618235f, -0.16632965f, 0.09959767f, 0.08173889f, -0.04669300f, -0.03543982f, 
    0.07337584f, -0.01586030f, -0.26964763f, -0.06838614f, 0.29938373f, 0.17859508f, -0.43785611f, 0.45096543f, 
    -0.01206004f, -0.02144702f, 0.28620327f, 0.18466350f, 0.42770258f, -0.23048012f, -0.09684362f, 0.60990596f, 
    0.03280590f, 0.12260150f, -0.02054548f, 0.03451789f, -0.00515042f, -0.07034684f, -0.13286719f, -0.06443594f, 
    -0.23275806f, -0.12657963f, 0.09518859f, 0.25105315f, 0.11296116f, 0.17712693f, -0.16438262f, 0.11528638f, 
    0.10369483f, -0.06574788f, 0.28905433f, 0.05405123f, 0.09978686f, -1.11074674f, -0.64864033f, -0.73752898f, 
    0.01053265f, 0.12509014f, 0.41632751f, -0.40493423f, -0.03364616f, 0.05876326f, -0.10144288f, 0.03174093f, 
    -0.06332268f, 0.12384069f, 0.08292289f, 0.05328215f, 0.08003917f, -0.09386318f, -0.01219511f, 0.06424275f, 
    0.03196676f, 0.01411076f, 0.14458261f, 0.07537474f, 0.54964626f, 0.14543138f, -0.25380346f, -0.00115843f, 
    -0.02912323f, -0.31009924f, 0.19349310f, 0.15717630f, 0.12325655f, 0.05340242f, 0.02561295f, -0.04085025f, 
    0.36361632f, 0.01858766f, -0.22495726f, 0.46950519f, -0.12425391f, -0.03305805f, -0.16004378f, 0.10493753f, 
    0.18458478f, 0.08729106f, 0.40175283f, 0.05974922f, -0.93614829f, -0.91930223f, -0.15688354f, 0.87379736f, 
    -0.19606696f, -0.02121091f, -0.19984598f, 0.11275930f, 0.04478778f, -0.02209607f, 0.06399183f, -0.19321811f, 
    0.20334119f, 0.17133878f, -0.39747766f, -0.00134386f, -0.17713457f, 0.02514199f, 0.11291172f, 0.27780977f, 
    -0.32108310f, 0.05244949f, -0.20103851f, -0.16710944f, -0.43743530f, -0.01694921f, 0.35412243f, 0.13514991f, 
    -0.06249539f, 0.06249499f, -0.31082681f, -0.09140589f, -0.14847369f, -0.00966162f, -0.18672457f, -0.04965320f, 
    -1.13968432f, -1.14388955f, -0.45479584f, -0.34739712f, -0.09219057f, -0.05527594f, 0.13779312f, -0.36146042f, 
    0.04993141f, -0.03493168f, 0.04404197f, -0.15218341f, 0.09420989f, 0.04108723f, 0.01140921f, -0.16095848f, 
    0.04608876f, 0.06398589f, -0.13992125f, 0.13565423f, -0.14439407f, -0.17386267f, -0.17770521f, -0.05888296f, 
    -1.16524923f, -0.87961966f, -0.52216065f, 0.04872494f, -0.44131762f, -0.69873619f, -0.40049031f, -0.68336374f, 
    -0.16651332f, 0.01212335f, -0.12395111f, -0.08877012f, -1.00867534f, 0.41799435f, 0.49677417f, 0.10922448f, 
    -0.06590373f, -0.10412762f, 0.00395263f, -0.08064457f, -0.01457703f, 0.22984304f, 0.08234010f, 0.20932466f, 
    0.16275099f, -0.15792717f, 0.04933665f, -0.14540671f, 0.10057329f, 0.11170038f, 0.22731224f, 0.09047501f, 
    0.14246029f, 0.35943031f, 0.34750551f, 0.03736875f, 0.89551854f, 0.69015503f, -0.14584452f, -0.56658453f, 
    -0.04517365f, -0.20208956f, 0.06959143f, 0.00036710f, -0.00380628f, 0.12993640f, -0.01944519f, -0.00094549f, 
    0.34791303f, 0.10652640f, 0.00331853f, -0.15816455f, -0.32540438f, -0.09531253f, 0.33503488f, -0.26266333f, 
    0.07639784f, 0.10353709f, 0.07457753f, -0.14942613f, -0.14817806f, 0.33802304f, -0.08266854f, -0.24053550f, 
    -0.10235927f, 0.16988355f, 0.05234967f, -0.03684371f, 0.05960910f, -0.10785998f, 0.19445637f, 0.00703083f, 
    0.26973996f, 0.09974676f, -0.32802194f, -0.32244721f, 0.09016540f, -0.13422939f, 0.10154443f, -0.01338102f, 
    0.04187934f, 0.11270356f, -0.28421879f, -0.69033605f, -1.39999378f, 1.19227660f, -0.54493982f, 0.23286571f, 
    -0.18621156f, 0.00081667f, -0.10970960f, 0.17276362f, 0.08712891f, 0.04003210f, -0.00121264f, 0.04153890f, 
    0.19582535f, -0.01963060f, 0.15596478f, 0.04418944f, 0.08982462f, -0.01195958f, 0.00773934f, -0.06441385f, 
    0.20571913f, 0.25210452f, 0.20491154f, -0.15242627f, -0.66475588f, -0.06131594f, 0.11477172f, -0.11375848f, 
    -0.34759715f, 0.10682146f, 0.30938348f, -0.05105308f, 0.00694791f, 0.17655246f, 0.08471952f, -0.02384142f, 
    0.64654750f, -0.38082820f, -0.30637646f, 0.40681762f, 0.03745015f, 0.03666630f, -0.00336837f, -0.10654321f, 
    -0.03254716f, 0.00636362f, -0.07687557f, -0.01452235f, -0.75307769f, -0.62390465f, -0.79489881f, -0.93260014f, 
    0.04809763f, -0.04551362f, 0.20755967f, 0.09391322f, 0.10381680f, -0.10060508f, -0.11586870f, -0.00516219f, 
    0.14048660f, -0.20464456f, -0.03712781f, -0.18103416f, -0.00804714f, -0.03004050f, -0.07285320f, -0.26653233f, 
    -0.13928534f, -0.16722929f, -0.11147323f, -0.09676693f, 0.31007448f, 0.11069604f, 0.01146570f, -0.50748742f, 
    -0.29359534f, 0.25959751f, -0.23875311f, 0.24637116f, -0.09243523f, 0.10510430f, -0.01515388f, -0.02031336f, 
    -0.93464452f, -0.00527844f, 0.03285458f, 1.14756811f, -0.05923355f, 0.21412635f, 0.16822313f, 0.07745943f, 
    -0.13757652f, -0.14804018f, -0.12006605f, -0.11090793f, 0.03733024f, 0.03463831f, -0.00797680f, -0.05577045f, 
    -0.04693783f, -0.15155701f, 0.02679914f, -0.01964698f, 0.22660430f, -0.06245298f, 0.13244610f, 0.00632724f, 
    -0.69716400f, -0.46351299f, 0.26560092f, 0.29246795f, -0.04328578f, -0.31698471f, -0.24615297f, 0.04943907f, 
    0.09704759f, -0.02833052f, 0.02485048f, -0.00841060f, 0.89040488f, -0.80143017f, -0.27724737f, -0.37274170f, 
    -0.00530172f, -0.05332782f, -0.06290431f, 0.06888428f, 0.27547398f, 0.28769502f, -0.01972714f, -0.08598544f, 
    0.13168046f, -0.22966638f, 0.45588237f, -0.22656094f, -0.06075835f, -0.14179301f, -0.08845878f, 0.00393383f, 
    0.03704743f, 0.23232752f, 0.10291421f, 0.27706069f, -0.89374518f, -0.10883268f, -0.92492318f, 0.48782828f, 
    -0.03527017f, 0.03885879f, 0.04743177f, 0.01239260f, -0.02208547f, -0.02255818f, 0.07837127f, 0.06915329f, 
    0.02082328f, 0.13621387f, -0.00327536f, 0.04386586f, 0.12444460f, -0.30817428f, -0.19553775f, -0.31688538f, 
    -0.04549507f, 0.11475361f, -0.15875724f, 0.14358714f, -0.09498125f, 0.36231887f, -0.24723017f, 0.18577360f, 
    0.08059273f, 0.08021759f, -0.02158621f, -0.27248621f, -0.10720836f, 0.18632247f, 0.05646381f, 0.04533862f, 
    0.39633679f, 0.20702372f, -0.29576442f, -0.68415743f, -0.39586815f, -0.11427645f, -0.18531235f, -0.06538508f, 
    0.25829256f, 0.14935605f, 0.20814759f, 0.17904444f, -0.60626453f, 0.21137500f, 0.33331659f, 0.29362026f, 
    0.26476893f, -0.18793239f, -0.18367973f, -0.06862254f, -0.07185327f, -0.07820269f, 0.05736594f, 0.05401560f, 
    -0.27567214f, -0.44716209f, -0.02716401f, -0.39498606f, -0.17375803f, -0.21082823f, -0.14425325f, -0.26541790f, 
    -0.19419481f, -0.22827810f, -0.07385114f, -0.71179742f, -0.76707727f, -0.55191934f, 0.07180138f, 0.31775394f, 
    -0.12889269f, 0.22478737f, 0.21770908f, 0.04835818f, 0.05483163f, -0.21980666f, -0.26466542f, -0.08337741f, 
    0.18358776f, 0.22462294f, -0.23440175f, -0.23030172f, 0.12102707f, 0.16009864f, -0.20939481f, 0.11501101f, 
    0.12010597f, 0.08255592f, 0.11997005f, 0.08335258f, 0.36151156f, -1.06885695f, -0.44852814f, 0.65069443f, 
    0.04345952f, 0.21282941f, -0.07013702f, 0.12238434f, 0.00630875f, 0.04858879f, -0.01139202f, 0.10198679f, 
    0.65574408f, 0.20183480f, -0.35719591f, -0.19846603f, 0.31716165f, -0.19617197f, -0.00186236f, -0.00263071f, 
    0.26611683f, 0.03266396f, 0.15886791f, 0.26671711f, 0.16502762f, 0.03088958f, -0.40280074f, -0.19838347f, 
    0.01649441f, -0.14948304f, 0.27787200f, 0.04553707f, 0.16478539f, 0.00841301f, 0.12813181f, 0.15654349f, 
    -0.52711272f, -0.58174032f, -0.14946890f, -0.65668261f, 0.12384609f, -0.11702653f, -0.14219917f, -0.07049136f, 
    0.03286583f, 0.00421300f, 0.12693147f, 0.04154446f, -0.58112127f, 0.08440924f, 0.06632748f, -0.08983160f, 
    -0.09587968f, -0.11472500f, 0.02403183f, -0.05740337f, -0.01325534f, 0.11143839f, -0.15078075f, 0.16587986f, 
    -0.24003839f, -0.30389151f, -0.65704668f, 0.17218852f, -0.07747679f, 0.10467812f, 0.00795011f, 0.10744245f, 
    0.15588258f, 0.15044439f, 0.07466497f, 0.21701398f, -0.54212147f, -0.56129652f, -0.28978315f, 0.10916003f, 
    -0.00824120f, 0.11690941f, 0.08369777f, 0.03785785f, 0.10082459f, 0.02319347f, 0.05751231f, -0.33233672f, 
    -0.18342692f, 0.21946314f, -0.21255942f, -0.07301079f, 0.17753804f, 0.06668702f, 0.17168428f, 0.05131213f, 
    0.02938247f, -0.24016747f, -0.30938184f, -0.72149289f, -1.02976620f, -0.34424406f, 0.03297437f, 0.52076244f, 
    0.11283427f, 0.20629953f, 0.23403864f, 0.02873145f, -0.22403151f, -0.06103166f, -0.00108814f, 0.22270043f, 
    -0.20632230f, 0.04503387f, 0.18105602f, 0.17209259f, 0.24457531f, 0.22821835f, -0.07813876f, 0.05017236f, 
    0.01545531f, 0.15107867f, 0.20682180f, 0.09273898f, 0.18430981f, 0.25535125f, 0.46450973f, -0.04543482f, 
    0.18348904f, 0.04242090f, -0.20098053f, -0.03659894f, -0.24528165f, -0.20032859f, 0.03341744f, -0.01735273f, 
    -0.55714744f, -0.02917322f, 0.36814269f, 0.28566718f, 0.19537091f, 0.10352970f, -0.39450154f, 0.04602248f, 
    -0.04771286f, -0.18236032f, 0.14525114f, -0.18448830f, -0.41745457f, 0.93182844f, -1.15095544f, 0.06294681f, 
    -0.12293468f, -0.13607621f, 0.28744343f, 0.13852584f, -0.02328295f, -0.01816637f, -0.07432943f, -0.05137343f, 
    0.07027379f, -0.12571093f, 0.17870960f, 0.17752805f, 0.04524783f, 0.22724664f, 0.16690794f, 0.02446224f, 
    0.07558554f, -0.00581260f, 0.13090819f, 0.35855943f, 0.03173968f, 0.33165094f, 0.52260774f, -0.67180228f, 
    -0.30486962f, -0.25156289f, 0.00807786f, -0.03209576f, -0.07120246f, 0.19401674f, 0.03002187f, 0.06412056f, 
    -0.80275840f, 0.30225280f, 0.19209282f, 0.14208466f, 0.07740486f, -0.12825659f, -0.17592688f, -0.21432427f, 
    -0.03861257f, -0.08317741f, 0.10225343f, -0.07607560f, 0.10879086f, -0.30120182f, 0.24657202f, -0.40904322f, 
    -0.00769834f, -0.17856081f, -0.18320863f, -0.03177642f, -0.06998947f, 0.08146296f, 0.14543249f, -0.00113439f, 
    -0.23335680f, 0.11123980f, -0.33776650f, 0.39098728f, 0.21142688f, -0.17047994f, 0.14575230f, -0.34939805f, 
    0.16971976f, -0.12893808f, -0.09030788f, -0.08688739f, -0.13728884f, -0.57143456f, -0.54930979f, 0.13657507f, 
    0.13028210f, 0.09622808f, 0.04833730f, 0.00844824f, -0.01568140f, -0.28250301f, -0.28370532f, -0.00979200f, 
    0.02970149f, 0.23680800f, -0.10893817f, -0.29041696f, 0.08040723f, 0.01148644f, -0.07671602f, 0.38054249f, 
    0.02555104f, 0.16898708f, 0.09354738f, -0.10369871f, -0.00452623f, -0.25542495f, -0.13719973f, -0.26997969f, 
    0.43701798f, 0.08435494f, 0.22093758f, -0.02626232f, 0.21558122f, -0.13925907f, 0.01692960f, 0.16329247f, 
    -0.34246400f, -0.18157323f, 0.09704826f, -0.40480363f, -0.26982570f, -0.07396708f, -0.38344920f, 0.31364417f, 
    -0.02616056f, -0.17106509f, 0.03456314f, -0.01994112f, 0.63402003f, 0.44750103f, 0.18578780f, 0.13146220f, 
    0.03791982f, -0.21358642f, -0.27032104f, -0.20806941f, -0.04229419f, 0.11971388f, -0.05401125f, 0.08374298f, 
    0.27319065f, -0.32536057f, 0.11873478f, -0.11368261f, -0.06331957f, 0.05933584f, 0.11541671f, -0.12770365f, 
    -0.08669444f, 0.19811578f, 0.08742058f, 0.08678094f, -0.15467939f, 0.69726598f, 0.53021622f, -1.33986187f, 
    -0.07210081f, -0.57215685f, 0.01942767f, -0.13748316f, -0.08908171f, 0.08816736f, 0.02058668f, 0.11690403f, 
    -0.32891229f, -0.06872109f, -0.01816600f, -0.28392339f, 0.22423229f, 0.14632609f, 0.22862434f, 0.01181326f, 
    0.19173132f, 0.15044917f, -0.25828081f, -0.10115559f, -0.69934833f, 0.12305046f, -1.08007848f, 0.19898547f, 
    0.34104660f, -0.12464733f, 0.20437752f, -0.00146449f, 0.08129451f, 0.02086783f, 0.07178078f, 0.14676636f, 
    -0.16804224f, -0.15046772f, 0.63030589f, 0.04701125f, -0.12392259f, 0.09010146f, 0.11929987f, 0.30390573f, 
    -0.01801782f, 0.05431706f, -0.21624598f, 0.42385325f, 0.01393559f, -0.64237344f, 0.06596446f, -0.26890713f, 
    -0.40630886f, -0.06933655f, 0.46266624f, -0.26500452f, -0.05460074f, 0.13461471f, -0.02834851f, 0.13582896f, 
    -0.39244682f, 0.43948442f, 0.00909247f, -0.42778835f, -0.27593836f, -0.03081449f, -0.33937284f, -0.17876427f, 
    0.21223913f, -0.18422118f, -0.16323544f, -0.52636385f, 0.03157282f, 0.18747813f, 0.26398319f, 0.32992783f, 
    -0.03375631f, -0.02526408f, 0.31022352f, 0.07596079f, -0.10037211f, -0.33443487f, 0.06822378f, -0.17842242f, 
    0.55273932f, -0.11762682f, 0.45399010f, -0.39089257f, -0.21534041f, -0.27670231f, 0.29892546f, 0.23393117f, 
    0.02762382f, -0.21498075f, -0.27893358f, -0.13859400f, -0.03287393f, -0.47979006f, 0.18811920f, 0.12042928f, 
    -0.20215848f, -0.05888870f, 0.09929439f, 0.01168685f, 0.09270705f, 0.18658800f, -0.36076704f, -0.08764170f, 
    -0.71461755f, 0.47186205f, -0.09614845f, -0.34781852f, -0.38271025f, -0.02377187f, -0.09564425f, 0.35258824f, 
    -0.10337918f, 0.03866219f, 0.05343876f, -0.02994443f, -0.88984162f, 1.29010344f, 0.41858837f, 0.76380175f, 
    0.32743397f, 0.09554483f, 0.12636898f, -0.19507787f, -0.35420710f, 0.34518045f, 0.35918537f, 0.12527780f, 
    -0.32524592f, -0.42804244f, -0.78194988f, 0.40776077f, 0.03925095f, -0.06509271f, 0.20101571f, -0.19291322f, 
    -0.04210906f, 0.04692262f, -0.08404630f, 0.05000776f, -0.38146356f, 0.04934172f, -0.97679317f, -0.04544365f, 
    -0.48908061f, -0.32839361f, -0.17367974f, 0.03662546f, -0.21825659f, 0.12755580f, -0.06025068f, 0.05433544f, 
    -0.16652150f, -0.03512547f, -0.01758833f, 0.27348435f, -0.12543659f, 0.05326072f, -0.11892376f, 0.22944251f, 
    0.11501125f, 0.15399314f, 0.25488049f, 0.25269583f, -0.10793837f, -0.05391870f, -0.10318132f, -0.24650356f, 
    0.12874696f, -0.15248480f, -0.41175506f, -0.09068745f, 0.06799497f, 0.07987252f, -0.07435083f, -0.39164743f, 
    0.03423060f, 0.42412794f, -0.62115842f, 0.31276047f, 0.16940203f, -0.09874327f, 0.06724767f, 0.12237899f, 
    -0.30648035f, -0.26576155f, -0.59916246f, -0.72887009f, 0.45048717f, -0.21106350f, 0.38085580f, 0.29332876f, 
    -0.07286898f, 0.10137797f, 0.11904349f, 0.02180290f, -0.04515529f, -0.28082451f, 0.08036841f, -0.03427142f, 
    -0.18078540f, -0.27465203f, 0.19095819f, 0.03944882f, -0.28298679f, 0.10605919f, 0.16115791f, 0.22781891f, 
    -0.08254384f, -0.14654718f, 0.11206304f, -0.14185755f, 0.24848661f, 0.25612149f, 0.09890579f, -0.11175514f, 
    -0.49436665f, 0.23679124f, 0.20565020f, -0.11493838f, 0.02330869f, -0.01080013f, -0.34772924f, -0.16921486f, 
    -0.73351729f, 0.10093307f, -0.61122280f, 0.19464074f, 0.01188241f, 0.05805026f, -0.01250701f, -0.20359103f, 
    0.05539855f, -0.11360173f, -0.04055310f, 0.01796587f, 0.85101849f, -0.19722870f, 1.14498115f, -0.35922480f, 
    0.17915875f, 0.05666790f, -0.51256526f, -0.04738422f, -0.13944358f, -0.07502191f, -0.07338569f, -0.03110643f, 
    0.09355531f, 0.12550871f, -0.32535434f, 0.06259038f, -0.02552780f, -0.04655091f, 0.00803844f, 0.06578650f, 
    0.24155249f, 0.15679161f, -0.02637097f, 0.17426002f, -0.49065599f, 0.36132362f, 0.10854285f, 0.31480879f, 
    -0.05430897f, -0.20755035f, 0.20086132f, 0.11727536f, -0.11065885f, 0.03709120f, -0.06182683f, 0.02071266f, 
    0.13629480f, -0.27842695f, -0.00447428f, -0.36555910f, 0.12880529f, 0.25626880f, 0.06180937f, -0.12686546f, 
    -0.22916107f, 0.19621409f, 0.17440666f, 0.06553776f, -0.23443891f, 0.13720936f, 0.19863093f, -0.90475750f, 
    0.22245683f, 0.04567615f, 0.05020499f, -0.04199606f, -0.06862300f, 0.17182654f, 0.15451345f, 0.02463158f, 
    0.62249845f, -0.10300133f, 0.02572856f, -0.17963809f, -0.01732059f, -0.00185856f, -0.01355726f, 0.05277913f, 
    0.04400643f, 0.16389397f, 0.22740115f, -0.15573734f, -0.16575079f, -0.64175361f, 0.27921417f, 0.61438441f, 
    0.38784429f, -0.01095851f, -0.02123316f, 0.21545970f, 0.15866043f, -0.34312147f, 0.07467087f, -0.11211728f, 
    -0.31996417f, -0.53300387f, -0.06400315f, 0.05404840f, -0.51602042f, -0.01300754f, -0.23269036f, -0.26264867f, 
    0.12281457f, 0.11064303f, 0.06344005f, 0.01021106f, 0.30718631f, 0.01930739f, -0.09983320f, -0.05860929f, 
    0.11575401f, 0.21572779f, -0.12210153f, 0.33964238f, -0.21593973f, -0.00346446f, -0.11215117f, -0.24772166f, 
    -0.22154635f, -0.08072284f, 0.03548491f, -0.27501354f, -0.02347089f, -0.05498318f, -0.16880196f, 0.07604115f, 
    0.02598613f, -0.09260876f, -0.20121354f, -0.34855190f, -0.71483773f, 0.12913275f, -0.43678120f, -0.14654282f, 
    -0.16174459f, -0.31356460f, -0.03305502f, -0.01305793f, -0.27788523f, 0.10711847f, -0.16698833f, -0.19823200f, 
    -0.17680731f, 0.12214636f, 0.07100569f, 0.39801854f, -0.00658935f, 0.09251659f, 0.19554390f, 0.10892919f, 
    -0.16428588f, 0.24857084f, 0.28476077f, 0.16650975f, -0.26067668f, -0.68704158f, 0.80414557f, -0.73658282f, 
    0.08624290f, 0.16619511f, 0.18319456f, 0.16605541f, -0.03116533f, 0.04982673f, -0.19823621f, -0.20755325f, 
    0.01285191f, 0.05416077f, 0.11664268f, -0.03157382f, -0.10165790f, 0.15121427f, 0.29500794f, 0.21646878f, 
    -0.05095257f, -0.12861274f, 0.02118397f, -0.30203494f, 0.45084250f, -0.65848607f, 0.44210148f, -0.03860965f, 
    0.19759946f, -0.17672186f, -0.12391337f, 0.07848378f, -0.08719719f, 0.15750775f, -0.09851518f, 0.18918015f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.26001039f, 0.15445535f, 0.15519905f, -0.15395111f, -0.19243041f, 0.06619379f, 0.01197008f, -0.17824595f, 
    0.08822344f, 0.02120024f, 0.04170234f, -0.03283191f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
