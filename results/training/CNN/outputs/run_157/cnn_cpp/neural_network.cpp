#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.31653601f, 0.17333001f, 0.38190037f, 0.58001673f, 0.24647832f, 0.14847884f, 0.28191233f, -0.29113910f, 
    0.14896733f, -0.67404425f, -0.37546590f, -0.38137501f, 0.16972432f, 0.36897218f, 0.82093161f, -0.24441896f, 
    0.03477205f, 0.19566648f, 0.46267623f, -0.67541581f, 0.29946494f, 0.45417947f, -0.81300330f, -0.07703739f, 
    -0.13163646f, -0.01744715f, 0.46921110f, 0.29419115f, 0.69931489f, 0.23118111f, 0.57427156f, -0.11033697f, 
    0.26169538f, 0.61923426f, -0.59374714f, -0.47531074f, 0.33465680f, -0.52121699f, -0.44993544f, 0.68673652f, 
    0.60017693f, 0.27430332f, -0.11770079f, 0.27641907f, 0.23055685f, -0.85853153f, 0.25424764f, 0.74865091f, 
    -0.47916937f, -0.14724489f, 0.62964147f, 0.15068120f, 0.29161468f, 0.36575735f, -0.65356004f, -0.35594088f, 
    0.22904947f, 0.74155092f, 0.51277149f, -0.57594591f, -0.14269966f, -0.53437287f, -0.36019883f, 0.38109306f, 
    -0.73406190f, -0.14603198f, -0.70286906f, -0.36970505f, -0.33832353f, 0.14489070f, 0.34988642f, 0.25826302f, 
    -0.08200268f, -0.62107921f, 0.66376442f, 0.65256774f, 0.23493649f, 0.21357369f, 0.47136986f, 0.08914711f, 
    0.45449802f, 0.87702614f, 0.48048791f, -0.08227660f, -0.10909897f, -0.17535606f, -0.28154746f, 0.09937810f, 
    -0.38019592f, -0.45718452f, -0.98962587f, 0.10510548f, -0.70990628f, 0.26231974f, 0.52086616f, 0.09364729f, 
    0.46072608f, 0.16434385f, 0.09568533f, -0.03185927f, 0.82882553f, -0.55672151f, 0.61709285f, -0.42166153f, 
    -0.36727813f, -0.41086528f, -0.20704198f, -0.22652344f, 0.56851023f, 0.23315130f, 0.29863316f, 0.54132897f, 
    0.72126949f, 0.01682906f, -0.34089735f, 0.39027315f, 0.15360735f, 0.03370272f, 0.55934101f, -0.36779553f, 
    0.22999680f, -0.58653659f, -0.68734968f, 0.14850707f, 0.09951443f, 0.57400250f, 0.52331251f, 0.16485408f, 
    0.28127959f, 0.72438437f, 0.11707797f, -0.74635327f, 0.30791122f, -0.24410690f, 0.10142995f, -0.00856520f, 
    0.49064007f, 0.13350502f, -1.16173720f, 0.69295728f, -0.20263731f, 0.02856852f, 0.20807318f, 0.25360450f, 
    0.25920388f, 0.48562869f, -0.84700114f, 0.11604264f, 0.64082712f, -0.31962323f, 0.57954895f, 0.33296031f, 
    -0.07539369f, -0.14121221f, 0.60658836f, 0.59910291f, 0.34948376f, 0.00824980f, 0.53609586f, 0.31281713f, 
    0.35309252f, -0.10658892f, 0.59771848f, 0.30390090f, 0.68374294f, -0.50194043f, 0.13942796f, -0.28795904f, 
    0.15948144f, -0.18138762f, 0.39676896f, -0.81779629f, -0.80716127f, -0.67248595f, 0.07085112f, -0.13591997f, 
    -0.18108970f, -0.18492313f, 0.02418050f, 0.27135324f, 0.66548425f, 0.28606418f, 0.45513982f, 0.06575981f, 
    -0.47582534f, -0.01113431f, -0.54932916f, -0.19449697f, -0.35391670f, 0.91126442f, -0.85595268f, 0.31391120f, 
    -0.73295939f, 0.09886794f, 0.50538164f, 0.01721859f, 0.13890631f, -0.15358156f, -0.31403479f, -0.37915140f, 
    -0.58886105f, 0.57705200f, -0.06745168f, 0.03132996f, -0.22008140f, -0.13984753f, -0.53919393f, 0.09260395f, 
    0.45580795f, 0.68710017f, 0.36573434f, 0.47413239f, -0.04919872f, -0.19648752f, 0.09080228f, -0.24411578f, 
    0.50625896f, 0.32522529f, -0.07829437f, -0.10840475f, -0.21573569f, -0.55633789f, 0.64298964f, 0.63807076f, 
    -0.00440169f, -0.07354522f, 0.09834088f, 0.60967720f, 0.62435853f, 0.14251798f, 0.35119748f, -0.47856614f, 
    -0.61015087f, 0.34105614f, -0.58922493f, -0.61702669f, -0.02979748f, -0.50963074f, -0.64784527f, 0.19108258f, 
    -0.15165257f, 0.27957007f, -0.15717185f, -0.25177369f, -1.05930519f, -0.34058636f, -0.46748415f, -0.28108531f, 
    0.67527604f, 0.08394425f, -0.12212135f, -0.04167970f, 0.70141613f, 0.73019922f, 0.17395860f, -0.55439162f, 
    0.29812998f, -0.34894043f, 0.05638877f, 0.33179539f, 0.00681306f, 0.83919871f, -0.34399983f, -0.71180117f, 
    -0.35817021f, 0.20556001f, -0.08021761f, -0.30070195f, -0.20098285f, 0.37528628f, -0.38019782f, -0.20064653f, 
    -0.19388168f, -0.25962719f, 0.63754004f, -0.70350617f, -0.42480662f, 0.15384275f, -0.09796875f, 0.22198403f, 
    0.03207134f, 0.25532272f, -0.66506630f, -0.87724560f, 0.42883873f, 0.28128323f, -0.38336271f, 0.22026162f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00004217f, -0.14800574f, -0.11236525f, -0.22413886f, -0.28821400f, -0.28734967f, -0.25194553f, -0.11969625f, 
    0.23298018f, -0.07352208f, 0.09671815f, -0.05435160f, 0.26882276f, 0.09489309f, -0.21782351f, -0.07249290f, 
    -0.22855110f, -0.25228950f, -0.22832251f, 0.04114319f, 0.30454549f, -0.17365295f, -0.27807969f, 0.15598103f, 
    0.05771170f, -0.11816528f, -0.27005801f, -0.05165588f, -0.46796587f, 0.08906516f, -0.15319617f, 0.10877830f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12558801f, 0.34283638f, 0.12605658f, 0.10362652f, -0.01947733f, 0.00741530f, 0.06478426f, -0.00959427f, 
    -0.01371909f, -0.00084669f, 0.01320367f, 0.16867620f, -0.11172250f, 0.13845098f, -0.16358455f, -0.09533910f, 
    -0.04590516f, -0.04167422f, -0.04560843f, 0.00545561f, -0.10121877f, -0.10531741f, -0.08235624f, -0.15811206f, 
    0.08406492f, 0.11839282f, 0.01974152f, 0.13938130f, 0.20690250f, 0.15684821f, 0.04536087f, -0.08473508f, 
    -0.09304070f, 0.12803513f, -0.07841401f, -0.06259361f, -0.06149673f, 0.07938388f, -0.25478560f, -0.03656540f, 
    -0.12208683f, -0.11519925f, -0.00702808f, 0.04009266f, 0.09171491f, 0.02477016f, -0.26718828f, -0.11244252f, 
    0.06210845f, 0.03259479f, -0.09085584f, -0.04914946f, 0.03605295f, -0.17631364f, -0.04521081f, 0.01912935f, 
    0.02689301f, 0.03619666f, -0.05489137f, -0.17318310f, 0.07336863f, -0.06201782f, 0.11248969f, -0.22534637f, 
    0.07065182f, -0.04583294f, 0.00715662f, -0.00197358f, 0.07008862f, -0.14612488f, 0.15970039f, 0.07096343f, 
    0.17488700f, 0.13763806f, -0.01502871f, 0.03201096f, -0.07960594f, -0.05713894f, -0.02134668f, 0.06030616f, 
    0.04265170f, -0.22065699f, -0.16706747f, -0.05485141f, 0.07344989f, -0.05835818f, 0.02758471f, -0.04462657f, 
    0.00750851f, 0.05731931f, -0.29206795f, -0.09023762f, -0.04639727f, -0.03167616f, 0.06592308f, -0.06917102f, 
    0.09205259f, 0.01994674f, 0.03472588f, -0.18075413f, -0.16708195f, -0.26916015f, -0.06453675f, 0.02664638f, 
    0.04285700f, 0.11749116f, -0.03331852f, -0.03904191f, 0.26371229f, 0.15094279f, 0.06908542f, -0.10114333f, 
    0.09675332f, 0.00798521f, 0.03628071f, 0.28534299f, -0.08818465f, -0.09748903f, -0.08805765f, -0.25420305f, 
    0.01349963f, 0.15456398f, 0.01727035f, 0.09705631f, 0.08437347f, 0.09978916f, -0.04607314f, 0.18403281f, 
    0.02788023f, 0.05224041f, -0.05806516f, -0.06362533f, -0.05305317f, -0.17689517f, 0.08870240f, 0.20855813f, 
    -0.04891725f, -0.43760791f, -0.04645913f, -0.02394530f, 0.18808900f, 0.07696870f, -0.06580564f, -0.00101536f, 
    0.11637716f, -0.09659688f, -0.47626483f, -0.16645557f, 0.10451120f, -0.05731615f, 0.03721615f, -0.16104162f, 
    0.11322993f, 0.13773914f, 0.03052552f, 0.07500449f, 0.04226444f, -0.14379865f, -0.04863586f, -0.11805039f, 
    0.03785228f, 0.09431726f, -0.01740885f, -0.11249726f, 0.10773463f, -0.02574417f, -0.00825259f, 0.02357163f, 
    0.12471075f, -0.10494329f, 0.31206071f, -0.16367377f, 0.23805034f, 0.24986686f, 0.03775246f, 0.05336696f, 
    0.07573861f, 0.13874866f, 0.04631542f, 0.15480830f, -0.10801792f, 0.03030491f, -0.04302042f, -0.01758889f, 
    0.04376752f, 0.07759687f, 0.10892446f, 0.04901660f, 0.08450800f, -0.45668146f, -0.20070456f, -0.10771558f, 
    0.03766197f, 0.11988203f, -0.04321260f, -0.02097559f, -0.04660464f, 0.05736333f, 0.09772947f, -0.07688917f, 
    -0.33547273f, 0.06063186f, -0.16613248f, -0.09075855f, 0.08890296f, 0.09932783f, -0.15729906f, 0.06975816f, 
    0.17845625f, 0.16765642f, -0.01400884f, -0.04189093f, 0.12553810f, 0.17301962f, 0.01605012f, -0.11574810f, 
    0.05182294f, 0.21049282f, -0.01645715f, -0.02225206f, 0.07736210f, -0.01956671f, -0.02453831f, -0.01580820f, 
    0.01773806f, 0.19639027f, 0.06244910f, 0.16149138f, -0.02609927f, 0.03868198f, -0.04466529f, -0.00592148f, 
    0.06638756f, -0.07200523f, -0.19165842f, -0.18005167f, 0.08251082f, 0.16542916f, -0.02834914f, 0.15155777f, 
    0.24788058f, 0.04332986f, 0.01544860f, -0.29106966f, 0.04325979f, 0.02933459f, 0.03753910f, -0.04289587f, 
    0.11252959f, 0.08654820f, 0.02620778f, -0.05204268f, -0.09908845f, -0.37319204f, 0.02464360f, 0.10659391f, 
    -0.02605133f, 0.16708238f, -0.02890434f, -0.08895009f, 0.07628368f, -0.54096109f, 0.11156991f, -0.34363490f, 
    -0.00250919f, -0.05084710f, 0.04815114f, -0.04066279f, -0.09683014f, -0.06785652f, -0.24942595f, -0.28500223f, 
    -0.14299305f, 0.06539436f, -0.02837152f, 0.10559022f, -0.02922102f, 0.06673938f, 0.15685460f, 0.16459605f, 
    -0.08468253f, -0.04265594f, -0.04633217f, -0.02001084f, 0.09617055f, -0.04945148f, 0.03239666f, 0.19073337f, 
    0.05150712f, -0.06295500f, 0.01514631f, 0.02998080f, -0.02205447f, -0.03936781f, 0.04911847f, 0.04606863f, 
    0.03337777f, 0.04897901f, -0.03713032f, -0.05780852f, -0.03904995f, 0.04962733f, 0.01105095f, 0.00184856f, 
    0.04237056f, -0.05690778f, 0.03580824f, 0.03266354f, 0.01984067f, -0.06391557f, -0.01325256f, 0.02659551f, 
    -0.04274959f, 0.02559640f, 0.01268503f, -0.04039102f, 0.03091478f, -0.02429492f, -0.05031152f, -0.05400363f, 
    -0.06003936f, 0.01038146f, -0.04117218f, -0.04897868f, -0.01392635f, 0.03686338f, -0.02036292f, 0.01356385f, 
    -0.00428541f, 0.03863851f, -0.05499763f, -0.01854332f, 0.02312854f, 0.00201376f, 0.04736836f, 0.05069576f, 
    0.01487872f, -0.05095088f, -0.03657416f, -0.05672242f, 0.04705790f, -0.04367477f, -0.00127348f, -0.00546044f, 
    -0.00576388f, 0.00582763f, 0.03404719f, 0.04647188f, -0.04371983f, -0.02386114f, -0.01411057f, -0.03941359f, 
    0.00982075f, 0.04453544f, -0.05489172f, -0.04593299f, -0.00585124f, 0.05162709f, -0.01259677f, -0.04888409f, 
    -0.00652047f, 0.01987771f, 0.03338937f, -0.03199080f, -0.00505006f, 0.03320033f, -0.01292416f, -0.04509963f, 
    -0.05748164f, -0.00212647f, -0.06115727f, -0.01268312f, 0.01997806f, 0.01515993f, 0.00050251f, -0.03624758f, 
    0.04569548f, -0.05103577f, -0.02927248f, -0.02168510f, -0.05110390f, -0.00226976f, 0.00194696f, -0.06312216f, 
    0.02687810f, 0.01420324f, 0.00635954f, 0.02601508f, -0.02930768f, -0.01613601f, 0.04056058f, -0.04393451f, 
    -0.05624939f, 0.03900768f, -0.02605719f, -0.04749838f, -0.04014888f, -0.01859103f, -0.04029442f, 0.02489606f, 
    -0.00874633f, -0.01936607f, 0.03390263f, -0.05128132f, -0.04110031f, 0.04066151f, -0.01207344f, -0.02384929f, 
    0.03286873f, 0.04135581f, 0.01331506f, -0.01931419f, -0.03622738f, -0.05284968f, -0.02585590f, 0.05137203f, 
    -0.01967175f, -0.03805992f, 0.00276114f, -0.03782346f, 0.05208817f, 0.03560663f, 0.00955213f, -0.01705741f, 
    -0.03557695f, -0.05966863f, -0.02198724f, 0.00697667f, 0.03259487f, 0.01427085f, 0.04299130f, -0.03262012f, 
    0.03148015f, 0.01041809f, -0.00218847f, 0.02938628f, 0.04836963f, 0.01395822f, -0.01874661f, 0.04281126f, 
    -0.06554932f, -0.06926116f, 0.00343725f, 0.01375809f, -0.03445324f, 0.04389966f, 0.03181960f, -0.01628731f, 
    -0.02483110f, 0.03120858f, -0.00894293f, -0.04782283f, -0.00690450f, -0.02187740f, -0.04503605f, -0.06241111f, 
    0.02578628f, -0.01353999f, -0.02150378f, 0.00494199f, -0.00008455f, -0.03195304f, 0.02443681f, 0.02993579f, 
    -0.05043039f, 0.03936273f, 0.04427451f, -0.05130991f, -0.01656133f, -0.03288031f, -0.01982660f, -0.05431412f, 
    0.00923831f, 0.03130954f, 0.03724171f, -0.05822090f, 0.02404221f, -0.05830923f, -0.02247631f, 0.04819420f, 
    -0.04899846f, 0.02929549f, 0.01298094f, -0.05925229f, -0.02283822f, -0.04023001f, -0.04724476f, 0.00610202f, 
    0.03911152f, -0.02325976f, -0.06090971f, 0.03665501f, 0.01333517f, 0.00751370f, 0.03296258f, 0.05085579f, 
    -0.04382711f, 0.00097593f, 0.00342282f, -0.05871409f, 0.04417360f, 0.00952717f, 0.05301734f, -0.04705679f, 
    -0.04483182f, 0.05212681f, -0.03929225f, 0.00729439f, -0.03283461f, -0.02003350f, -0.03961983f, -0.05106814f, 
    -0.02566141f, 0.05071992f, 0.02095271f, -0.06718459f, 0.03145404f, -0.04238815f, -0.01496974f, -0.01316940f, 
    0.01534241f, -0.05922468f, 0.00076243f, 0.00319971f, 0.03201272f, 0.03114210f, 0.01829173f, -0.05808703f, 
    -0.06349069f, -0.02348642f, -0.02034352f, -0.01234162f, 0.00044576f, -0.00718404f, -0.01180007f, -0.01530905f, 
    0.03699769f, -0.00909617f, 0.04078976f, -0.00911910f, 0.02991953f, -0.00366397f, 0.02366478f, -0.00030832f, 
    -0.00550118f, -0.01142286f, -0.03233147f, -0.00966065f, -0.02488715f, 0.03524230f, 0.01623928f, -0.01917187f, 
    -0.04049345f, -0.04019207f, -0.06333358f, -0.06275121f, -0.03312803f, -0.02934411f, -0.03985318f, 0.02023631f, 
    0.02006165f, -0.00224787f, 0.02199249f, -0.01113739f, -0.05001312f, -0.02292389f, -0.06563945f, 0.04096068f, 
    -0.03619614f, -0.05811501f, -0.05972928f, 0.00488120f, -0.01040614f, -0.02575330f, -0.03045815f, 0.05492721f, 
    -0.23576990f, 0.07391456f, -0.00953766f, -0.01635121f, -0.04008837f, -0.09057986f, -0.04657096f, -0.02758002f, 
    0.01238945f, -0.02430047f, 0.20661399f, 0.12379606f, 0.07002699f, 0.10418533f, 0.05399881f, 0.04667993f, 
    -0.15296796f, 0.00485486f, 0.29446095f, -0.20065387f, 0.02754332f, -0.00054114f, -0.17237078f, 0.12323362f, 
    0.06646743f, 0.04407028f, 0.02274054f, -0.10746284f, 0.08736625f, 0.12128438f, 0.05800248f, 0.03177023f, 
    -0.05800300f, -0.05069570f, -0.01164012f, -0.10566627f, 0.01666501f, 0.03386332f, -0.15201811f, -0.01011080f, 
    -0.16064665f, 0.15926966f, 0.02613772f, 0.04063107f, -0.02533060f, -0.07843538f, -0.18974052f, -0.08926620f, 
    0.22948058f, -0.07566238f, 0.08279292f, 0.01294212f, 0.05865770f, 0.07929111f, 0.43454361f, 0.13696176f, 
    0.07518266f, -0.07962876f, -0.00388149f, 0.00508115f, 0.05984942f, 0.09090941f, 0.28367963f, -0.08490771f, 
    0.04713948f, 0.12302711f, -0.00337506f, 0.06113750f, 0.19934884f, -0.14019915f, -0.01515399f, -0.09434330f, 
    -0.11402768f, -0.08593273f, 0.06210632f, 0.02718281f, 0.03938193f, 0.02160946f, 0.08827911f, 0.13023593f, 
    -0.08672375f, -0.32626602f, -0.15027320f, -0.11853746f, -0.22877361f, 0.00428721f, -0.00174833f, 0.01561407f, 
    -0.03603653f, -0.11873236f, 0.21224371f, 0.18179221f, 0.19428392f, 0.03546429f, 0.08902670f, 0.09106113f, 
    0.17254211f, -0.06150752f, -0.07802310f, 0.17442180f, -0.06462263f, 0.04958930f, -0.00999521f, 0.05853376f, 
    0.09960401f, 0.17248626f, -0.05906318f, -0.01839881f, -0.08973584f, -0.06573629f, 0.06316737f, -0.04255578f, 
    0.06034877f, -0.11509619f, 0.05700500f, 0.02851699f, 0.06827439f, -0.03749160f, -0.01789080f, -0.18883316f, 
    -0.16219126f, 0.11462858f, 0.05505636f, 0.06128956f, -0.03020879f, -0.22440335f, -0.13014683f, 0.03374694f, 
    -0.10924836f, 0.03002758f, 0.06976041f, 0.02898341f, 0.18426397f, -0.10007143f, 0.03847997f, -0.28067812f, 
    0.05158614f, 0.19560774f, 0.03642732f, -0.07625101f, 0.02308762f, -0.07956484f, 0.08746648f, -0.10892937f, 
    -0.02594784f, -0.06399296f, -0.00685012f, -0.05031023f, 0.06054857f, -0.01323414f, -0.05314029f, 0.13034098f, 
    -0.05861156f, -0.23577911f, 0.04371371f, -0.09912258f, -0.00170688f, -0.07665690f, -0.27097282f, -0.10375350f, 
    0.00181586f, 0.04318277f, -0.19968058f, 0.00953072f, 0.10435468f, -0.25889713f, -0.00218597f, -0.04713549f, 
    0.14769314f, -0.09013606f, -0.02518423f, 0.14062683f, 0.11418344f, 0.17011796f, -0.06159072f, 0.04819563f, 
    0.13635616f, 0.21660948f, -0.14094026f, 0.09074295f, 0.00233554f, -0.00630116f, 0.15827973f, -0.10856529f, 
    -0.09261928f, 0.11488774f, 0.06866398f, -0.09079286f, 0.04007273f, -0.05925586f, 0.21542236f, -0.05658154f, 
    0.16931663f, 0.08160902f, -0.08337266f, -0.15179992f, 0.12407178f, 0.01805333f, 0.22317463f, 0.29552633f, 
    0.29847375f, 0.13424687f, -0.28059000f, 0.03467117f, 0.14169908f, 0.01403151f, -0.02051755f, -0.01698733f, 
    -0.06128049f, -0.01475937f, -0.10226888f, 0.02400330f, -0.03312699f, -0.09114265f, 0.13736370f, 0.10545988f, 
    -0.10856847f, -0.16136701f, -0.10054313f, -0.12761009f, 0.00463286f, 0.01873928f, -0.08481434f, 0.05390446f, 
    0.02825309f, 0.06320349f, 0.01896229f, -0.10511725f, 0.17445186f, 0.12493940f, -0.08946924f, 0.09833708f, 
    -0.05184943f, -0.05188503f, 0.07494408f, 0.05528028f, 0.21013068f, 0.17342162f, 0.03180245f, 0.04760376f, 
    0.12285142f, 0.01675491f, -0.08127341f, 0.01859424f, 0.14219561f, 0.20615499f, 0.17403324f, 0.07814468f, 
    -0.07094134f, 0.06868152f, -0.04399259f, 0.08538519f, -0.37069422f, -0.13897690f, 0.13755177f, -0.24740258f, 
    0.08576177f, -0.08225515f, -0.10303403f, 0.01682409f, 0.09652336f, 0.13207379f, -0.06908809f, -0.20055830f, 
    0.11574329f, -0.02416267f, -0.00649916f, -0.01249315f, -0.08722199f, 0.05456815f, -0.12597556f, 0.15225461f, 
    -0.03120956f, 0.26250365f, -0.20796710f, 0.07628435f, -0.16964321f, -0.08036884f, 0.05174581f, 0.13182093f, 
    -0.06087594f, -0.04680476f, -0.07133855f, 0.09977114f, -0.07396126f, 0.18105441f, -0.01544961f, -0.08303978f, 
    0.18937939f, 0.19149293f, -0.10023518f, 0.22361092f, 0.27910665f, -0.17748480f, 0.01314054f, 0.14200421f, 
    0.04873041f, -0.22293475f, -0.11292002f, 0.73331678f, -0.10207131f, 0.03489548f, -0.04677941f, -0.28183216f, 
    0.10192092f, -0.01996357f, -0.28629127f, -0.28123477f, -0.20330571f, 0.07399787f, -0.03673790f, 0.13516173f, 
    -0.02327532f, -0.08269396f, -0.06228219f, 0.38022947f, 0.03104454f, 0.00766897f, -0.01895876f, 0.16228966f, 
    -0.17943366f, -0.05565000f, 0.00571472f, -0.12751175f, 0.05067735f, 0.14608279f, 0.19013710f, -0.01267979f, 
    -0.11696415f, 0.08032038f, -0.31097457f, 0.20972128f, 0.15240687f, 0.13502035f, 0.29350349f, 0.05934629f, 
    0.01391530f, 0.07080107f, -0.12665187f, 0.08616266f, 0.03091661f, 0.22024478f, -0.22217214f, -0.25276253f, 
    -0.06884625f, -0.07683918f, -0.04881153f, 0.01489694f, -0.04431001f, -0.03555379f, -0.04674656f, 0.02657059f, 
    0.08348504f, -0.20093040f, 0.19941984f, -0.06347141f, 0.21976380f, 0.06657661f, -0.02228628f, -0.08719926f, 
    0.00210996f, 0.11265298f, 0.01675064f, 0.04389841f, -0.20342946f, 0.08967046f, -0.10555249f, 0.11493775f, 
    0.09276055f, 0.42794728f, 0.10011329f, -0.17268659f, -0.01958120f, 0.16126196f, 0.06112098f, 0.04391097f, 
    0.08798203f, -0.13499856f, -0.42473063f, -0.09647835f, 0.35173109f, -0.09973935f, 0.06467652f, 0.22485857f, 
    -0.23060624f, -0.10248970f, -0.03363979f, 0.04545920f, 0.06156094f, -0.06708132f, 0.12383590f, 0.00798610f, 
    -0.08321285f, 0.16470456f, -0.05566901f, -0.11709710f, 0.30654734f, -0.01231158f, -0.01504529f, 0.07981631f, 
    0.08826167f, -0.13200033f, 0.00422407f, 0.03706091f, 0.28826800f, 0.16798063f, 0.09327988f, -0.27043974f, 
    0.30265456f, 0.04245115f, 0.02555702f, 0.12467363f, -0.06486848f, 0.08174827f, 0.02859618f, -0.09151503f, 
    -0.04324904f, 0.13123642f, 0.08715905f, 0.11617278f, -0.00125172f, -0.06844530f, 0.10249486f, 0.11847045f, 
    0.05257387f, -0.27409130f, -0.02911641f, 0.04447675f, -0.00480945f, 0.15577368f, -0.01406924f, 0.06020943f, 
    0.21030851f, 0.22964081f, -0.30259299f, -0.03490527f, -0.06851322f, 0.03383859f, -0.11076903f, -0.01406005f, 
    0.00545839f, 0.09964027f, -0.04469246f, 0.18072481f, -0.04804920f, -0.04184180f, -0.03038922f, 0.12926261f, 
    0.03722185f, 0.07781383f, 0.26588333f, -0.07853275f, -0.34083050f, 0.29363227f, 0.19697082f, 0.03041664f, 
    0.11772095f, -0.13830212f, 0.03130113f, -0.01187367f, -0.05421436f, 0.47691056f, 0.21805249f, 0.16510402f, 
    0.20923780f, -0.00213007f, 0.02499579f, 0.04907146f, 0.09228168f, 0.24134843f, -0.12436800f, 0.14557996f, 
    0.14555313f, 0.15336108f, 0.11627800f, 0.14791407f, 0.03079327f, -0.46884120f, -0.08570994f, -0.22389479f, 
    0.07478724f, -0.09146839f, 0.34319809f, 0.14501193f, 0.08770099f, 0.09395567f, 0.07857953f, 0.00728303f, 
    0.02543797f, 0.21586120f, 0.02686030f, -0.25486594f, -0.05995721f, -0.09214569f, 0.02843765f, 0.02084263f, 
    0.09105536f, -0.23556979f, 0.02926414f, 0.04694142f, -0.06561902f, 0.14639460f, -0.03229649f, 0.00209285f, 
    0.40521157f, -0.00745228f, -0.25756124f, 0.31439093f, 0.19147921f, 0.06712700f, -0.02183744f, 0.00503122f, 
    -0.10685351f, 0.10510243f, 0.19207928f, -0.29683456f, 0.04350027f, -0.18339868f, -0.03284473f, -0.11780670f, 
    0.09451577f, 0.20382042f, -0.02209086f, 0.05257601f, 0.06014628f, 0.27419987f, 0.21424441f, -0.06407509f, 
    0.12646556f, 0.00195381f, 0.17673422f, -0.28495696f, 0.04219007f, 0.51104283f, -0.18738082f, 0.05886119f, 
    0.14022140f, 0.18200582f, -0.06599720f, -0.01315661f, 0.14554770f, -0.21906380f, -0.10107224f, 0.18510205f, 
    0.07918268f, 0.07036306f, 0.03766544f, -0.12421473f, 0.00107140f, 0.13768305f, -0.00876299f, 0.33594212f, 
    0.10329289f, -0.09883681f, 0.04696311f, 0.08970817f, -0.02058107f, 0.00141206f, -0.45732996f, 0.02445967f, 
    -0.07543346f, 0.14600837f, 0.14196537f, 0.05548977f, 0.05146866f, 0.05166113f, -0.00190068f, 0.17446180f, 
    0.07667258f, -0.13075745f, 0.44101727f, -0.00532409f, 0.10339874f, 0.23925333f, 0.04093127f, 0.04089948f, 
    -0.03882345f, 0.04102814f, -0.01537797f, 0.02855550f, -0.01256536f, -0.04365362f, 0.04083855f, 0.03035307f, 
    -0.00457948f, 0.01554408f, 0.00494422f, 0.01574354f, -0.03126169f, 0.01296431f, 0.01972221f, 0.03687789f, 
    -0.04922643f, 0.01348257f, 0.00040862f, -0.01776741f, -0.01699843f, -0.06289078f, 0.05397324f, 0.01716716f, 
    0.03803491f, 0.01692080f, -0.01697936f, 0.03549135f, -0.01634601f, -0.04107735f, -0.03851072f, -0.03305608f, 
    -0.03529865f, 0.02460137f, -0.03529524f, 0.01291905f, -0.05325721f, -0.03351583f, 0.00767868f, 0.02227923f, 
    0.01722259f, 0.05251974f, -0.02545358f, -0.04513107f, -0.00204092f, 0.00520628f, -0.02031643f, 0.03129160f, 
    0.04618233f, 0.02632761f, -0.06204577f, -0.05072185f, -0.00771858f, 0.05335891f, -0.06368280f, 0.04298927f, 
    0.02071263f, -0.01756874f, -0.01764547f, 0.03390501f, 0.00394343f, -0.01092869f, -0.02530023f, -0.01914792f, 
    0.03443512f, 0.04866758f, 0.03605649f, -0.06086987f, 0.03167232f, 0.01214845f, 0.00357839f, -0.00577270f, 
    0.05342656f, 0.02235076f, 0.04918840f, -0.02671038f, -0.05245219f, -0.06184725f, -0.01924226f, -0.04534724f, 
    -0.02786393f, -0.04354143f, -0.06220546f, -0.02714787f, -0.03855362f, 0.04990704f, -0.00069604f, -0.04392007f, 
    -0.01015313f, -0.04732101f, 0.03984828f, 0.03295958f, -0.03145111f, -0.02675733f, -0.05631006f, -0.02580878f, 
    0.01023215f, 0.01563719f, -0.01015726f, -0.03763273f, 0.01751324f, -0.00093736f, -0.05687669f, -0.01997517f, 
    0.04355935f, -0.00631419f, -0.06055110f, 0.02801201f, -0.05412780f, 0.04337159f, 0.02581694f, -0.03068010f, 
    0.04363478f, 0.00045350f, -0.01051759f, 0.00995903f, 0.04027669f, -0.02247894f, -0.05469437f, -0.01596271f, 
    -0.01324914f, 0.01289473f, 0.04335947f, -0.01870375f, 0.03780957f, -0.03052413f, 0.04606063f, -0.02776222f, 
    -0.05122126f, -0.01199419f, 0.04280529f, -0.02521409f, -0.00780689f, -0.05549594f, 0.03093688f, -0.00480379f, 
    0.05355575f, 0.03020451f, 0.02378500f, -0.05442458f, 0.01277120f, 0.04899770f, -0.04333461f, -0.05961223f, 
    -0.03265430f, -0.04724842f, -0.03451683f, 0.02533880f, -0.04968323f, -0.05775517f, -0.02869261f, 0.02477887f, 
    0.03534533f, -0.04676880f, -0.01705761f, 0.02517503f, -0.03909843f, 0.03084338f, -0.05603366f, -0.01201866f, 
    0.01234902f, 0.02103109f, -0.02691823f, -0.04194114f, 0.02269378f, 0.02689319f, -0.01880704f, -0.05273653f, 
    0.01764489f, -0.04194751f, -0.04192936f, -0.05234129f, -0.03548582f, 0.00214341f, 0.02134896f, 0.01745253f, 
    0.03677597f, 0.00849665f, 0.00038194f, -0.03675321f, -0.06353966f, -0.03962601f, -0.04250450f, -0.01922952f, 
    -0.02175823f, 0.05032506f, -0.01210057f, -0.05993756f, -0.05123677f, 0.04286631f, -0.04431900f, 0.01397523f, 
    -0.01506930f, 0.05028022f, 0.02782371f, 0.03674757f, -0.04057299f, -0.02845183f, 0.01144869f, 0.03992086f, 
    0.00669398f, 0.02984527f, -0.01278232f, 0.03492506f, -0.02983615f, 0.03120449f, 0.00087585f, -0.01670319f, 
    0.04670230f, -0.05024722f, 0.04927703f, 0.03474984f, 0.04041642f, 0.01519615f, -0.04360694f, 0.04322931f, 
    -0.02652995f, 0.02369032f, 0.03216961f, 0.02926170f, -0.04563368f, -0.03184171f, 0.04851852f, -0.02943840f, 
    0.00239327f, -0.05178514f, -0.00182402f, 0.01730069f, 0.03014467f, 0.01634121f, -0.01194981f, -0.04903338f, 
    -0.02732541f, 0.00928666f, 0.01802034f, 0.02986250f, -0.02798371f, 0.01135370f, -0.06235549f, -0.01863553f, 
    -0.02920211f, -0.02276859f, 0.03983350f, -0.05312049f, 0.01241446f, 0.01027545f, 0.04739598f, -0.00155197f, 
    -0.04178265f, -0.02941171f, 0.03723964f, -0.03145908f, -0.06257663f, -0.03580338f, 0.00075114f, -0.04854313f, 
    -0.05763160f, 0.01133163f, -0.05060500f, 0.03293954f, 0.00430836f, 0.00360819f, -0.02507580f, -0.02578484f, 
    0.03610995f, 0.05088312f, 0.05083496f, -0.05779940f, 0.03156372f, -0.02670399f, -0.05857337f, 0.04005749f, 
    0.00421233f, 0.02447949f, 0.01492148f, -0.01281075f, 0.05194581f, -0.00865309f, 0.01381980f, -0.00841191f, 
    -0.00428798f, -0.06387003f, -0.00798022f, -0.00716742f, -0.03643482f, 0.00089509f, -0.04251441f, -0.00854948f, 
    -0.00665079f, -0.04569902f, -0.01140966f, 0.01716185f, -0.12765139f, 0.04578306f, -0.06091274f, 0.00821435f, 
    -0.10076628f, 0.33578378f, 0.44813654f, 0.15392284f, 0.03203775f, 0.13866496f, -0.23473597f, -0.01603740f, 
    0.02549171f, -0.20118967f, 0.03211949f, -0.03522184f, 0.16457897f, 0.03863076f, -0.13624333f, 0.16319567f, 
    0.02659162f, 0.07963029f, 0.04556990f, -0.04091207f, 0.15523008f, -0.14745152f, 0.07235509f, 0.01653115f, 
    0.04650000f, -0.38134086f, 0.12922671f, -0.08779274f, 0.10259926f, 0.25060001f, -0.14752291f, 0.05223577f, 
    -0.02752017f, -0.06001078f, 0.07545703f, 0.12722078f, 0.04862009f, -0.06380316f, -0.01464642f, -0.09697292f, 
    -0.13319206f, -0.04380609f, -0.09330472f, -0.14680065f, -0.12779847f, -0.07186413f, 0.17663930f, 0.10906923f, 
    -0.25073385f, 0.05284061f, -0.09378396f, -0.04917728f, 0.03633846f, 0.11929313f, 0.10198040f, 0.14008653f, 
    -0.03776862f, 0.09718572f, 0.01946384f, 0.03518518f, 0.18544434f, -0.02352499f, -0.11904757f, 0.02214590f, 
    0.02436378f, 0.10760695f, 0.17556129f, -0.11436003f, -0.09123882f, 0.06778976f, 0.11202915f, -0.06209258f, 
    0.06678548f, -0.34133500f, 0.17002483f, 0.19263084f, -0.00953343f, -0.10597055f, -0.00143773f, -0.02684796f, 
    0.08621207f, 0.01346728f, 0.15157562f, 0.19021878f, 0.23835929f, -0.02600253f, 0.09887831f, 0.06470851f, 
    -0.08483533f, 0.03767186f, 0.07372124f, -0.06521576f, 0.02769810f, -0.16886415f, -0.06551718f, 0.13086602f, 
    -0.03963017f, -0.03084425f, -0.13610956f, -0.07782005f, 0.00552574f, -0.03211035f, -0.06330556f, -0.01115580f, 
    0.00839276f, 0.00332886f, 0.04547800f, 0.00683613f, 0.12660307f, 0.26736546f, -0.20562412f, -0.00502114f, 
    -0.06736105f, -0.07127110f, 0.12205585f, -0.08221309f, -0.02895682f, -0.02463652f, -0.15951802f, -0.40001407f, 
    -0.06466154f, -0.09307330f, -0.05892833f, -0.08517566f, 0.09543787f, -0.01225001f, 0.07329489f, -0.14077598f, 
    -0.09969068f, -0.22694610f, 0.13624556f, 0.05730975f, -0.09860619f, -0.03251216f, -0.18568207f, 0.03052811f, 
    -0.04225739f, -0.20356382f, -0.24940921f, -0.06245909f, -0.01786643f, 0.10499184f, 0.04097285f, 0.10721949f, 
    -0.01327763f, -0.14847869f, -0.06828732f, -0.01513783f, 0.09996579f, -0.04501772f, -0.17628606f, -0.04582629f, 
    -0.03530918f, -0.18277273f, -0.34024620f, -0.20882438f, 0.09401867f, 0.13123633f, 0.05466249f, -0.02453098f, 
    0.01750277f, -0.01743070f, -0.09818872f, 0.10611510f, 0.29973087f, 0.14108047f, -0.04439594f, 0.01215402f, 
    0.05782830f, -0.11850506f, 0.12708117f, -0.01375169f, -0.00308505f, 0.07682606f, 0.12681440f, 0.08719626f, 
    0.02266505f, 0.06915548f, -0.07555310f, 0.02513419f, 0.02638163f, -0.14760271f, 0.19756041f, 0.01121792f, 
    0.01748622f, -0.13594553f, -0.16991511f, 0.12623534f, 0.12568302f, 0.13021207f, 0.12390567f, 0.17952721f, 
    -0.11104861f, -0.07602630f, 0.10861660f, 0.02415230f, 0.16516253f, 0.16741519f, -0.13658121f, -0.04362947f, 
    -0.17583199f, -0.31692904f, 0.13817912f, 0.05902663f, 0.01581319f, -0.06944602f, 0.09284066f, -0.00717936f, 
    0.12728809f, -0.28099301f, -0.02448141f, -0.02007977f, -0.09475483f, 0.16692080f, 0.04576600f, 0.04504121f, 
    0.06246009f, 0.05506182f, 0.07705283f, -0.09644579f, -0.04108833f, -0.13693641f, 0.04159411f, 0.11740056f, 
    0.05254546f, 0.06562647f, 0.09779083f, 0.20926358f, 0.09998943f, -0.04363924f, -0.01539655f, -0.04046131f, 
    -0.00313422f, -0.07239556f, -0.11340709f, 0.00077579f, 0.11119717f, -0.00947341f, 0.11398170f, -0.06907316f, 
    -0.09013624f, -0.12833408f, 0.07974531f, -0.03813827f, -0.35620543f, -0.17696756f, 0.00756397f, 0.08681001f, 
    0.07834283f, 0.10002349f, -0.13525324f, -0.06547854f, 0.07692875f, -0.08819244f, -0.18390392f, -0.02324920f, 
    -0.04757949f, -0.09060866f, 0.14372459f, 0.09788595f, 0.01013538f, -0.10832865f, 0.00186993f, 0.11330341f, 
    -0.27750841f, -0.02688040f, 0.04175807f, 0.23377915f, -0.08655238f, 0.00651909f, -0.13900501f, -0.11356950f, 
    0.02703087f, -0.00962122f, 0.09151399f, -0.04401122f, 0.06665096f, -0.14470969f, -0.00123682f, 0.02502993f, 
    -0.01079366f, 0.19262838f, 0.01783393f, 0.03018839f, 0.00375772f, -0.15697764f, -0.02960514f, -0.05772254f, 
    -0.08474464f, 0.01604986f, 0.27174705f, -0.18287440f, 0.20939997f, 0.20141394f, -0.21872307f, 0.06722037f, 
    -0.03628172f, 0.17282103f, 0.06554624f, -0.41617334f, -0.10305905f, 0.10993264f, 0.02731629f, 0.01532564f, 
    -0.07020525f, 0.05990052f, 0.15485258f, -0.09052834f, -0.01186834f, -0.02746088f, 0.07092893f, 0.10780300f, 
    -0.08207213f, 0.02899892f, -0.07655355f, 0.15014376f, 0.07681926f, 0.24600343f, -0.08092812f, 0.04791645f, 
    -0.01366042f, -0.05294736f, 0.05806312f, 0.02761241f, 0.10645472f, -0.07069608f, -0.07156897f, -0.27755913f, 
    -0.08597367f, 0.06514337f, -0.07590783f, -0.13770771f, -0.10439269f, -0.11166936f, 0.04432492f, 0.10415161f, 
    -0.32904202f, -0.03927397f, -0.07765260f, 0.00912387f, 0.01140678f, 0.12384456f, -0.03088519f, -0.04636667f, 
    0.07258232f, -0.06821603f, -0.45646209f, -0.04603336f, -0.03918913f, 0.03084445f, 0.12942158f, 0.04862589f, 
    -0.06089922f, 0.04268471f, -0.11128955f, 0.12388302f, 0.02097897f, 0.02691844f, -0.12305906f, -0.19096345f, 
    -0.02055824f, -0.32962066f, 0.05687726f, -0.09629557f, 0.03601069f, 0.15803069f, -0.31170568f, -0.03354437f, 
    0.07918874f, 0.06578424f, 0.12454685f, 0.02674800f, -0.13532662f, 0.04691936f, 0.29007936f, 0.06884754f, 
    0.08700895f, 0.08336838f, -0.05555395f, 0.25586167f, 0.04573196f, -0.08709385f, 0.13952953f, -0.03598799f, 
    -0.05008268f, 0.15658371f, 0.04694295f, -0.07860582f, -0.11291591f, 0.24663943f, 0.24724169f, 0.06123738f, 
    -0.05677298f, -0.01523612f, 0.17068633f, 0.02697582f, 0.03193687f, 0.13623250f, 0.09100379f, -0.16569334f, 
    -0.07130475f, 0.03035451f, -0.13064705f, -0.00741402f, 0.02481796f, 0.00771179f, -0.19379622f, 0.15965046f, 
    -0.15386686f, 0.03013645f, -0.09004884f, -0.14801903f, -0.06636070f, -0.02516509f, 0.17070109f, -0.45526612f, 
    0.34494340f, 0.20982523f, 0.12010281f, -0.02442547f, -0.13207589f, 0.02926469f, -0.17452711f, 0.08420040f, 
    -0.17738055f, -0.08522845f, 0.09475086f, 0.19408515f, 0.02823281f, -0.18278268f, 0.10638422f, -0.02445522f, 
    -0.08482686f, -0.00113564f, 0.03767269f, 0.10001147f, 0.14316523f, 0.01367050f, 0.00389966f, 0.21087509f, 
    -0.19144775f, -0.04097238f, -0.07061118f, -0.07278811f, 0.17974316f, -0.10732067f, 0.12517998f, 0.08412158f, 
    -0.16973299f, -0.06162746f, -0.04686259f, 0.04621649f, -0.16291453f, 0.17455836f, 0.14737576f, -0.06421603f, 
    -0.02574578f, 0.08947451f, 0.06719804f, 0.01244655f, -0.18049842f, -0.03456399f, 0.18968420f, 0.08245998f, 
    0.15074995f, 0.18179131f, 0.15306391f, 0.18521284f, 0.07019731f, -0.35369366f, -0.20794380f, -0.19682214f, 
    -0.04176539f, 0.01518491f, -0.05694424f, -0.08881433f, 0.13533497f, 0.04125117f, 0.23263922f, -0.11120644f, 
    -0.06499322f, 0.19044784f, -0.09832927f, 0.01542717f, 0.18236531f, -0.12539892f, -0.09449788f, 0.10329855f, 
    0.15853193f, 0.08060509f, 0.05839394f, 0.05315216f, -0.08731823f, 0.10206039f, 0.02453613f, 0.12719619f, 
    -0.01532120f, 0.00995500f, 0.00083690f, 0.07897652f, -0.00419959f, -0.00517824f, -0.00919010f, 0.07057154f, 
    -0.03586447f, -0.11562683f, -0.02989121f, -0.12893808f, 0.14908975f, 0.11360199f, 0.02299575f, 0.12574320f, 
    -0.05919148f, 0.04762431f, 0.17882451f, 0.06549507f, 0.14686255f, -0.13386668f, -0.30675349f, -0.03885466f, 
    0.12333874f, 0.18675348f, 0.00274986f, -0.17037259f, -0.08217005f, -0.27706859f, 0.00568819f, -0.13381982f, 
    0.02362124f, -0.04816859f, 0.01529116f, 0.12015829f, -0.30012101f, -0.09035758f, 0.08842655f, -0.04035644f, 
    0.13409080f, 0.09195272f, 0.09474862f, 0.04162607f, 0.11437300f, 0.07241385f, -0.10951854f, -0.09173356f, 
    -0.10821591f, 0.05922365f, -0.06663904f, -0.06353216f, -0.07254327f, 0.00582399f, -0.15872766f, -0.06241310f, 
    -0.22098304f, 0.10197099f, -0.11021596f, 0.10077830f, -0.02044248f, 0.08953474f, -0.07240594f, 0.18033639f, 
    -0.24996766f, -0.08435182f, -0.20459992f, 0.03816088f, 0.09438156f, -0.07621874f, 0.00636189f, 0.05958740f, 
    0.05415232f, 0.01528373f, 0.02561018f, -0.04644332f, 0.00182041f, 0.04034883f, -0.00051909f, -0.01733619f, 
    0.00340726f, 0.01582433f, 0.02466571f, 0.03375386f, 0.04037580f, -0.04584064f, -0.04028789f, 0.00884764f, 
    0.03018504f, -0.00298407f, -0.04579284f, 0.00807534f, 0.03362214f, -0.02088144f, -0.03463426f, 0.05033113f, 
    -0.06662152f, -0.01429955f, -0.00971707f, -0.01134140f, 0.01491877f, -0.05840025f, -0.02739800f, -0.02715724f, 
    -0.00173916f, -0.05761848f, 0.00130432f, -0.04532021f, -0.04764305f, -0.03998711f, 0.04619718f, -0.03954468f, 
    0.02480681f, 0.00955640f, -0.01951073f, 0.04955325f, -0.06411169f, 0.00337373f, -0.01005230f, 0.03342359f, 
    0.01186240f, -0.03440582f, -0.04036056f, 0.02987965f, -0.02547224f, 0.01893364f, -0.04708796f, 0.01427411f, 
    -0.02197886f, -0.00603903f, 0.01328614f, -0.04816160f, -0.05796295f, -0.03590813f, -0.01936384f, 0.01416265f, 
    0.02541315f, 0.01986217f, -0.01150974f, 0.01814014f, -0.00803287f, -0.04803560f, 0.04545639f, 0.05532739f, 
    0.02694517f, -0.04683439f, 0.02879983f, -0.04417022f, 0.02785127f, -0.06397501f, -0.00902513f, -0.02573023f, 
    0.00819786f, -0.01460980f, 0.03383352f, -0.01820149f, 0.02629954f, -0.03580980f, -0.04787337f, -0.00632478f, 
    -0.04062904f, 0.04780619f, 0.03568645f, -0.04765913f, 0.03513006f, 0.03050474f, -0.03688724f, 0.05785801f, 
    -0.03965672f, 0.00265290f, -0.00594343f, 0.04656182f, -0.02954812f, -0.00589421f, -0.06774363f, -0.03963770f, 
    -0.01197526f, 0.03588780f, -0.02105223f, -0.05224215f, -0.02590280f, -0.02225284f, -0.02222816f, 0.02285805f, 
    0.00475897f, -0.00950416f, 0.02720583f, 0.01315881f, -0.05745075f, -0.00373568f, -0.05430372f, -0.05151837f, 
    0.00126206f, 0.00810930f, -0.06152956f, -0.05158980f, -0.00370626f, -0.06183438f, 0.03761213f, -0.01071710f, 
    -0.03912301f, -0.03979674f, -0.02421738f, -0.01025097f, 0.00670445f, -0.00820996f, -0.01962549f, 0.03079509f, 
    -0.00401372f, -0.03208179f, 0.00191892f, -0.05618021f, 0.03836306f, -0.01576288f, -0.01036360f, 0.01484195f, 
    -0.00804368f, -0.03132927f, 0.04269448f, 0.00544422f, 0.01344923f, 0.02331894f, 0.03286075f, -0.03124829f, 
    -0.02595800f, 0.03534338f, -0.04822870f, -0.00138420f, 0.03532504f, 0.02970582f, -0.04949033f, 0.04707415f, 
    0.05978207f, -0.00891564f, 0.04139785f, -0.05952460f, 0.03854721f, -0.03336589f, -0.05640187f, 0.04203984f, 
    -0.03297306f, 0.02577549f, -0.03779518f, 0.00960589f, -0.04306722f, -0.01864686f, -0.05358149f, -0.04107483f, 
    -0.02250006f, -0.01421875f, 0.02992797f, -0.04066502f, 0.03752955f, -0.05327068f, -0.01569830f, -0.06062681f, 
    0.04915803f, 0.02134403f, -0.01998737f, 0.02046767f, -0.02340420f, 0.02373772f, -0.05605768f, 0.03524523f, 
    -0.02346762f, 0.04542138f, -0.02071606f, -0.02994438f, 0.00396305f, 0.04768429f, -0.02126257f, 0.02792342f, 
    -0.00178714f, 0.02385057f, 0.02510284f, 0.03374767f, -0.00014441f, -0.05350577f, -0.01821733f, -0.01536996f, 
    -0.05886300f, -0.04783263f, -0.04190882f, -0.00515632f, -0.04048021f, 0.04727403f, 0.00230388f, -0.01179999f, 
    -0.03258816f, -0.02352755f, 0.03242128f, -0.02354143f, 0.05367455f, 0.05320339f, 0.03788394f, -0.04888579f, 
    0.03559849f, 0.00437139f, -0.06682702f, 0.03515465f, -0.03349598f, 0.05017170f, 0.02476933f, 0.01839944f, 
    -0.01096978f, 0.04542081f, 0.01690881f, 0.02962602f, -0.01196905f, 0.00278979f, -0.00343741f, -0.03039858f, 
    -0.03518546f, -0.05599429f, -0.04692057f, -0.00631548f, 0.00059253f, 0.02812767f, -0.05806698f, 0.02568837f, 
    -0.04109170f, -0.06027015f, 0.03367088f, -0.03664026f, 0.02789723f, 0.04249759f, 0.04695723f, -0.02104459f, 
    0.00448290f, -0.06027390f, -0.01599813f, 0.05125829f, -0.01822449f, -0.05244780f, 0.04409676f, -0.04182298f, 
    0.04554251f, -0.00201397f, -0.02394715f, 0.03562079f, 0.01446551f, 0.01346320f, 0.03036505f, -0.02882325f, 
    0.02791408f, -0.04698602f, 0.00522711f, -0.05673863f, 0.03088859f, -0.03712824f, -0.02233978f, 0.00023845f, 
    -0.04657789f, -0.00430395f, 0.02709228f, -0.04814672f, -0.01472026f, -0.06730863f, -0.05135388f, -0.03475084f, 
    -0.09012594f, 0.03595943f, -0.00558336f, -0.04042664f, -0.06059002f, 0.02896404f, 0.05275801f, -0.01295305f, 
    -0.08532965f, 0.02982361f, -0.04237803f, -0.07942647f, -0.00357777f, -0.02099836f, -0.00217020f, 0.02122733f, 
    -0.06518118f, -0.00872158f, -0.05675785f, -0.06374442f, -0.02209272f, -0.00539669f, 0.02557812f, -0.04849798f, 
    -0.02175275f, 0.01533647f, -0.00613567f, 0.00775122f, -0.06333257f, 0.01131098f, -0.07871170f, 0.00649145f, 
    -0.08050651f, 0.00724978f, -0.02416119f, -0.06086997f, 0.00482386f, 0.01462601f, -0.01561436f, -0.00915932f, 
    -0.01282642f, 0.01597510f, -0.01513646f, -0.02529004f, -0.07107130f, 0.02757429f, -0.07839950f, -0.01545095f, 
    -0.02239755f, 0.00172580f, -0.02517276f, -0.01633407f, -0.03256947f, 0.00032123f, 0.01979504f, 0.01694413f, 
    -0.03703049f, -0.02549192f, -0.03931034f, -0.01669490f, -0.06210012f, -0.08488426f, 0.00384033f, -0.06397472f, 
    -0.04201315f, 0.01185407f, 0.00089107f, 0.02147114f, 0.01764650f, -0.01509988f, -0.08506618f, -0.03910605f, 
    -0.00021500f, -0.03249934f, -0.00975974f, 0.00306527f, 0.00251128f, -0.00968255f, -0.03766760f, -0.03929261f, 
    -0.05200041f, -0.02901806f, -0.03775533f, -0.01150253f, -0.01483660f, -0.02806850f, -0.04115421f, -0.03608524f, 
    -0.07327687f, -0.03157195f, -0.01545110f, -0.03248532f, 0.01866044f, -0.04492451f, -0.01292250f, -0.01376498f, 
    -0.04477433f, -0.07852066f, 0.00277666f, -0.02939040f, -0.03295466f, 0.00146851f, -0.05550060f, 0.00425929f, 
    -0.01313805f, -0.00973248f, -0.04801985f, -0.08546432f, -0.03813048f, -0.04286169f, -0.01373909f, 0.02668047f, 
    0.02177277f, -0.05858097f, -0.03220480f, 0.02355132f, 0.02420583f, -0.06135955f, 0.03064619f, -0.04548152f, 
    -0.05041562f, -0.03798355f, -0.00500709f, -0.07408629f, 0.02168811f, -0.05916980f, -0.04348725f, -0.04168780f, 
    -0.08450443f, 0.01288031f, 0.02128181f, -0.07101402f, -0.05921125f, 0.02606443f, -0.07378989f, 0.03011209f, 
    -0.06647339f, -0.06848941f, 0.01047255f, -0.00822144f, -0.04864924f, -0.03732726f, 0.02291149f, 0.01757658f, 
    -0.05697895f, -0.08151852f, 0.00942070f, -0.02420383f, -0.06897552f, -0.07235388f, -0.08544449f, -0.02746152f, 
    0.01755542f, -0.02647119f, 0.04468129f, -0.00993567f, -0.04075342f, -0.01837250f, -0.01406602f, -0.03485615f, 
    -0.01946289f, -0.02052120f, -0.08501334f, -0.05910500f, -0.05016943f, -0.05982683f, -0.04228064f, -0.06157970f, 
    -0.05507274f, -0.02783737f, -0.05106184f, -0.01601961f, 0.01649909f, -0.00408977f, -0.02862501f, -0.09298286f, 
    -0.01846001f, -0.07681018f, -0.03344783f, 0.01237086f, -0.00912353f, -0.03527751f, 0.01138610f, 0.00647417f, 
    -0.03928967f, -0.00068272f, -0.08454510f, -0.06299622f, -0.02324463f, -0.03245692f, -0.01971522f, -0.08334712f, 
    0.02588817f, -0.01708105f, 0.00101059f, 0.00225994f, -0.06119364f, -0.05358483f, 0.01460198f, -0.06856384f, 
    0.02660277f, 0.00380336f, -0.03937195f, -0.08211669f, -0.05296801f, 0.00467703f, -0.05072701f, -0.04199833f, 
    -0.05281729f, -0.07228518f, 0.00697743f, -0.07703395f, -0.00388798f, 0.01882083f, -0.03689143f, 0.03144303f, 
    -0.05330719f, -0.00900735f, -0.06262156f, 0.02416968f, -0.07873906f, -0.02335556f, -0.01842503f, -0.04908908f, 
    -0.04533666f, -0.02192180f, 0.00217559f, -0.04439480f, 0.01069751f, -0.08155429f, -0.00969638f, -0.07281479f, 
    0.00012207f, -0.04837869f, -0.03862478f, -0.09555067f, -0.07047007f, -0.08517313f, -0.00722370f, -0.05773232f, 
    -0.02100512f, 0.01944565f, -0.05040598f, -0.04013380f, -0.07496313f, 0.01800726f, -0.01899200f, -0.06731083f, 
    -0.09104414f, 0.01317076f, -0.05889672f, -0.00792635f, -0.02595062f, 0.02083969f, 0.03019999f, -0.05487387f, 
    0.01243065f, 0.02396064f, -0.00144476f, -0.00511566f, -0.06150079f, 0.00062294f, -0.00820004f, 0.01483134f, 
    -0.00134956f, -0.03777914f, 0.00331091f, 0.01672705f, -0.05507044f, -0.01612523f, 0.01605892f, -0.09320949f, 
    -0.06117208f, -0.05008504f, -0.02649662f, -0.01668070f, -0.06514151f, -0.04933704f, -0.08496743f, -0.08378226f, 
    -0.03861753f, -0.07665710f, -0.02048515f, -0.06139163f, -0.05205219f, 0.00136107f, -0.06892453f, 0.01794868f, 
    -0.08050694f, 0.05161123f, 0.04475971f, -0.11202439f, -0.11743031f, 0.07438599f, 0.14423040f, -0.11087728f, 
    0.00204807f, 0.09436937f, -0.24670684f, 0.12862581f, -0.10314979f, -0.01234012f, -0.02653150f, 0.08189020f, 
    0.07712010f, 0.09367999f, 0.26956147f, 0.07702269f, 0.02124289f, 0.12953326f, 0.03196900f, -0.08533720f, 
    -0.08846036f, -0.02724694f, -0.20605944f, -0.01789944f, 0.28053927f, 0.14496508f, -0.15250707f, -0.05615469f, 
    0.15246221f, 0.03941544f, -0.06506114f, -0.07435989f, 0.09880373f, -0.20023741f, 0.05847145f, 0.16335075f, 
    0.06805655f, 0.03549773f, 0.04358092f, 0.05971908f, 0.11643424f, 0.03724390f, 0.11616395f, -0.03828568f, 
    -0.15735781f, 0.20579264f, -0.08360770f, 0.15974496f, -0.08120347f, 0.21459027f, 0.06301267f, 0.08420487f, 
    0.18292679f, 0.15423164f, -0.03083791f, 0.04348617f, -0.03755836f, 0.07644198f, -0.17360994f, 0.16146822f, 
    0.14875717f, 0.08125622f, -0.16862115f, -0.03894628f, 0.05717930f, -0.07789050f, -0.05879005f, -0.06972548f, 
    0.03594612f, -0.07422317f, 0.02836971f, 0.08535691f, 0.03973960f, -0.05360622f, 0.19319120f, 0.15426788f, 
    0.18334731f, -0.16879213f, -0.24462055f, -0.01743153f, -0.11497370f, -0.01187083f, 0.09031598f, 0.01955203f, 
    0.08667485f, -0.09388433f, 0.20977719f, -0.00462336f, -0.00355382f, -0.08642051f, -0.08786862f, 0.23105860f, 
    0.08573746f, 0.13470294f, 0.03423042f, 0.13710001f, -0.08832102f, 0.06635239f, -0.01954019f, 0.06439392f, 
    0.09786017f, -0.07118499f, -0.13001791f, -0.08033193f, -0.09332683f, -0.08356820f, 0.06709977f, 0.01620298f, 
    -0.01438806f, 0.02359176f, -0.08228810f, -0.06449831f, 0.20906976f, 0.00269978f, -0.04072439f, -0.10611913f, 
    -0.01394812f, 0.00715279f, -0.15532662f, 0.03804782f, -0.00530825f, -0.12994669f, -0.25490898f, -0.07293668f, 
    -0.15458059f, -0.07882115f, -0.06665030f, -0.04849752f, 0.05404449f, -0.00354481f, 0.04641170f, 0.01969438f, 
    -0.12194665f, 0.00721710f, 0.18541634f, 0.01114642f, -0.11376861f, 0.08034157f, -0.09160278f, 0.18319379f, 
    -0.10511609f, -0.05659068f, 0.07976247f, -0.05548250f, -0.04902923f, -0.02251747f, 0.17732726f, -0.05212149f, 
    0.13942228f, -0.08201597f, -0.00358739f, 0.02102908f, 0.02291630f, 0.07192920f, -0.06366874f, 0.00454519f, 
    -0.12665224f, 0.18273656f, -0.17068289f, -0.15573241f, 0.15655002f, 0.05309629f, -0.02526028f, -0.02269511f, 
    0.01435305f, -0.08544689f, 0.07750231f, 0.01907839f, 0.11649111f, 0.13815288f, -0.02388792f, -0.20385611f, 
    0.11667309f, -0.06129266f, 0.08354697f, -0.04650413f, -0.15849534f, -0.27096578f, 0.07551874f, -0.10492219f, 
    -0.07310549f, 0.00397757f, -0.08446056f, -0.17646386f, 0.09912998f, -0.10265604f, 0.28031379f, 0.13125342f, 
    -0.03604596f, 0.00247415f, -0.13055651f, -0.21472502f, -0.03539320f, 0.18119422f, 0.04463889f, -0.00504420f, 
    -0.10810927f, 0.10739227f, 0.27958131f, 0.14890940f, 0.05338356f, -0.09161998f, -0.17433290f, 0.03730093f, 
    0.06079153f, -0.03086825f, 0.03686027f, 0.12131137f, 0.03082109f, -0.02492095f, 0.07533499f, -0.09081227f, 
    -0.25802326f, -0.25959331f, 0.13623545f, 0.08265120f, 0.06439182f, 0.01881268f, 0.07360245f, -0.09086213f, 
    -0.12213515f, -0.12487889f, -0.17377891f, -0.03649226f, 0.04342397f, 0.14583774f, -0.03382561f, 0.04775684f, 
    0.04300999f, 0.04937803f, 0.07179153f, -0.03664934f, 0.13974997f, -0.04741015f, -0.10962801f, 0.08115997f, 
    -0.09392239f, 0.15451032f, -0.17716172f, 0.05952864f, -0.21583705f, 0.25423211f, -0.08154649f, -0.02418507f, 
    -0.06013319f, 0.01128007f, -0.00631215f, -0.01686817f, -0.29903451f, -0.45785019f, -0.17078131f, 0.12837692f, 
    0.08528396f, 0.04647245f, 0.03736718f, 0.07635359f, 0.07086711f, 0.10981485f, 0.08620447f, 0.17767021f, 
    0.08439091f, 0.35073927f, -0.08190849f, -0.11608768f, -0.19516523f, -0.03606104f, 0.21269278f, 0.22190833f, 
    0.15878665f, 0.02379930f, -0.07328390f, -0.00529386f, -0.12299453f, 0.28457469f, 0.03654909f, 0.09601655f, 
    -0.20060734f, -0.12432344f, 0.02305685f, 0.02635684f, 0.03504764f, -0.12070672f, 0.00714396f, 0.08177768f, 
    -0.30724072f, -0.29815039f, -0.20827322f, -0.07539136f, -0.06352146f, 0.12230742f, 0.06818792f, 0.07892751f, 
    -0.13741900f, 0.04818287f, -0.06505888f, -0.08376586f, 0.15006867f, 0.06737890f, -0.12501399f, 0.09351211f, 
    0.03300722f, 0.05134712f, 0.11286028f, -0.01080442f, -0.38759446f, -0.10725589f, 0.05860703f, -0.10143303f, 
    -0.02745268f, 0.03830171f, -0.07659443f, -0.25333062f, -0.28047171f, -0.16336234f, -0.13919699f, -0.08237185f, 
    -0.00769215f, 0.27603766f, -0.17574476f, -0.17235592f, -0.01826565f, 0.05563342f, -0.04942913f, 0.14187928f, 
    0.05234696f, 0.07982778f, -0.13226479f, 0.17917317f, -0.12292571f, -0.16076906f, 0.06795871f, -0.08292906f, 
    -0.04157205f, 0.11383972f, 0.04688507f, 0.02962133f, -0.02122982f, -0.13828404f, -0.17566241f, -0.16292857f, 
    0.09901707f, 0.01915082f, -0.08468632f, 0.00229013f, 0.07127176f, 0.13169780f, 0.01319455f, 0.03709501f, 
    0.28767410f, -0.02275376f, 0.01800620f, -0.06776800f, -0.38953403f, 0.15491992f, -0.05618315f, 0.01975687f, 
    0.12238412f, 0.01742093f, -0.18306646f, 0.02787678f, 0.01945475f, 0.02270032f, -0.03650885f, 0.03002287f, 
    -0.19559190f, 0.16138528f, -0.00379710f, -0.05011735f, -0.00398684f, 0.21547753f, 0.00394092f, 0.16141717f, 
    0.03902759f, -0.06727353f, 0.08855035f, 0.08722172f, 0.11142349f, -0.03177281f, 0.11383500f, 0.00943922f, 
    0.05296094f, -0.03427834f, 0.03758483f, 0.19011684f, 0.20688665f, -0.16316122f, 0.01124377f, -0.14263208f, 
    0.14809097f, 0.05433784f, 0.03826435f, -0.01609000f, -0.12880364f, -0.22364888f, -0.12653627f, 0.17633453f, 
    0.01729410f, 0.20759444f, 0.00077144f, 0.27385482f, -0.17235562f, 0.22164908f, -0.03407232f, 0.08149952f, 
    -0.08486134f, -0.16669197f, 0.05803607f, -0.15439762f, 0.14437433f, 0.00949992f, -0.06199133f, -0.09164331f, 
    0.03329292f, -0.02503983f, -0.08322164f, 0.11174762f, -0.10460778f, 0.03183221f, -0.12350149f, -0.07079865f, 
    0.02496467f, 0.14653845f, 0.04049829f, -0.02067939f, -0.03896308f, -0.05495697f, 0.18784358f, -0.10628890f, 
    0.03756978f, -0.04486473f, 0.13603458f, -0.10769065f, 0.20276570f, 0.15091442f, -0.06189302f, 0.05798997f, 
    -0.07737667f, -0.18049914f, -0.42126393f, 0.00109996f, -0.19902167f, 0.10546490f, 0.10235872f, 0.05734568f, 
    -0.17880827f, -0.13612922f, 0.03422387f, -0.19423667f, 0.08815683f, 0.06729707f, -0.02051096f, -0.12792701f, 
    -0.02262531f, -0.04080959f, 0.18664092f, 0.08275821f, -0.05503414f, -0.05288667f, -0.07091867f, -0.04848878f, 
    -0.04590757f, 0.16242960f, 0.01731236f, -0.00910930f, 0.06021485f, -0.17124467f, -0.15891783f, 0.07423718f, 
    0.08035047f, 0.00410321f, 0.13676283f, 0.00893884f, -0.09398014f, -0.09048945f, 0.06632172f, -0.07817405f, 
    -0.25045604f, 0.15922405f, 0.19508225f, 0.16368867f, -0.02378862f, -0.14156953f, -0.27604380f, -0.03425725f, 
    0.19666994f, -0.18444271f, 0.11051127f, 0.19582571f, -0.05192277f, 0.02829033f, 0.24070941f, -0.00230891f, 
    -0.00170629f, 0.05010170f, 0.17082521f, -0.05217294f, 0.13894390f, 0.05029588f, 0.08612988f, -0.24402332f, 
    -0.13776873f, -0.00689382f, 0.01460689f, 0.06729879f, 0.04505674f, -0.02481403f, 0.06167751f, 0.00763421f, 
    -0.07728435f, -0.08371137f, -0.27059498f, -0.03993339f, 0.08371413f, 0.13490590f, 0.28337875f, -0.05059738f, 
    0.13673110f, -0.30898926f, 0.06544337f, 0.04661741f, 0.22595525f, 0.03596732f, -0.01733110f, -0.18531059f, 
    0.02902770f, 0.03057602f, 0.22506861f, 0.32351184f, 0.05397717f, 0.05773866f, 0.00951728f, 0.00254208f, 
    -0.13408893f, 0.06869948f, -0.08691173f, 0.01091006f, 0.19261500f, 0.12164665f, 0.15132380f, 0.00802428f, 
    0.01226390f, -0.10560617f, 0.04665330f, 0.14093542f, 0.13741328f, 0.06230548f, 0.20061642f, -0.09205244f, 
    -0.01702388f, -0.05159647f, -0.16563241f, 0.12252694f, 0.16981716f, 0.08734523f, -0.16996703f, 0.14532955f, 
    0.30628663f, 0.14126053f, -0.07460182f, -0.17943075f, 0.04095895f, 0.09554061f, 0.24089034f, 0.16723546f, 
    -0.08476346f, 0.04810377f, 0.04956171f, 0.11984810f, -0.04960201f, 0.13947193f, -0.01319117f, -0.08402333f, 
    -0.12282782f, -0.05351039f, 0.23022959f, -0.03878222f, 0.02649695f, 0.13385816f, -0.16764247f, 0.05462642f, 
    0.03710862f, 0.41333279f, 0.38839015f, -0.26917222f, 0.33254871f, -0.09780018f, 0.01680017f, 0.03304315f, 
    0.01493913f, 0.27986792f, -0.20822680f, -0.05084511f, 0.03947062f, -0.15596265f, 0.23581934f, -0.05809912f, 
    0.06980152f, 0.16639413f, 0.05091242f, 0.06198525f, 0.23028725f, 0.01684960f, 0.00549170f, -0.03828430f, 
    0.06841996f, -0.14418586f, 0.28065398f, -0.05477312f, 0.16302960f, -0.05126014f, -0.12962909f, 0.27457699f, 
    0.09259769f, -0.07192727f, 0.05573327f, -0.06280953f, -0.15370937f, -0.69511962f, 0.06081462f, -0.05262084f, 
    -0.03798215f, -0.07001731f, -0.08056620f, -0.14785571f, -0.02054188f, -0.15605792f, 0.31810921f, 0.14453459f, 
    0.08808731f, 0.05847786f, 0.00306352f, -0.17359978f, 0.04148252f, 0.11404890f, 0.01482010f, -0.33081192f, 
    -0.38272253f, 0.42333433f, -0.03473652f, 0.26154515f, -0.01422929f, -0.05376993f, 0.17372936f, -0.09105941f, 
    -0.39388558f, 0.04660309f, 0.21172762f, 0.06735911f, 0.16785789f, -0.08709199f, -0.03025917f, 0.07733475f, 
    -0.17746139f, 0.19621271f, -0.09370934f, 0.01941759f, -0.07181063f, 0.01081660f, -0.09163576f, 0.03287822f, 
    0.12300197f, 0.08107154f, 0.90151954f, 0.21771806f, -0.05903092f, 0.08671901f, 0.15448442f, -0.04506266f, 
    0.31960738f, -0.05885410f, -0.07896770f, 0.10036425f, -0.40279794f, -0.03213957f, -0.23872225f, -0.13372767f, 
    0.08862036f, 0.12843560f, 0.08061241f, -0.11583337f, 0.08641379f, 0.18227915f, 0.12153134f, -0.13578361f, 
    -0.01605407f, 0.08085779f, -0.00188208f, 0.12351277f, 0.15880921f, -0.33100677f, 0.00189189f, -0.21415915f, 
    -0.08806216f, -0.06275075f, -0.21151939f, -0.03150346f, 0.00337672f, 0.18121798f, -0.08523373f, -0.26578414f, 
    -0.04639776f, -0.15817033f, 0.01779628f, -0.03210434f, 0.03396065f, 0.20355152f, 0.00113605f, -0.04938740f, 
    -0.05653473f, -0.47888613f, -0.01678814f, -0.08689667f, -0.08655772f, -0.09914353f, -0.06763281f, -0.16909891f, 
    0.26672530f, -0.40235877f, -0.12167180f, 0.02490846f, 0.00601224f, -0.09324811f, -0.00418476f, -0.20008771f, 
    0.04706784f, -0.05319905f, 0.17252125f, -0.00071171f, -0.11418038f, 0.07542955f, -0.04700299f, 0.00724343f, 
    -0.18535592f, -0.12307766f, 0.30811223f, 0.12211826f, -0.06608497f, -0.35425788f, -0.15885840f, 0.02870349f, 
    -0.03642387f, 0.06281234f, -0.00666743f, 0.12657996f, 0.07463529f, 0.04605226f, -0.08475923f, 0.16795194f, 
    -0.01398214f, 0.18537937f, 0.02329860f, -0.06638781f, 0.01985793f, 0.10025784f, 0.02649178f, -0.19472788f, 
    0.00343898f, 0.09668544f, 0.10969551f, 0.00939838f, -0.01808280f, -0.08537615f, -0.25638264f, -0.07437954f, 
    -0.13198590f, 0.03854223f, -0.03576974f, 0.04708370f, 0.13725656f, -0.05268070f, 0.23306742f, -0.02006196f, 
    -0.21758853f, 0.17178586f, -0.08912313f, -0.01845006f, 0.15877730f, 0.12251457f, -0.30110916f, -0.01614049f, 
    0.26638615f, 0.23844260f, -0.22584689f, 0.00071587f, -0.09748761f, -0.10775755f, 0.02913066f, 0.10692101f, 
    -0.19016699f, 0.07030966f, 0.18975000f, 0.05757330f, -0.13466096f, -0.04232949f, -0.20168890f, 0.06841395f, 
    -0.03130996f, -0.05941448f, 0.25568137f, 0.38848040f, 0.03690011f, 0.03101628f, 0.06780103f, 0.16612770f, 
    0.07836279f, -0.09510021f, -0.38941848f, -0.47606209f, 0.04623510f, -0.06292197f, -0.15054296f, 0.21155302f, 
    -0.01719095f, 0.09261607f, -0.06500454f, 0.15649025f, -0.06132701f, -0.03337384f, -0.03143990f, 0.01641995f, 
    0.07141274f, 0.03285399f, -0.10018156f, 0.05169766f, 0.23085731f, 0.10549845f, -0.17824796f, -0.13877191f, 
    -0.18531144f, -0.09488511f, -0.02172245f, 0.06734980f, -0.08228854f, 0.03415627f, -0.32649726f, 0.03201776f, 
    -0.13275523f, 0.12449728f, -0.04111224f, 0.04465554f, -0.12523641f, 0.06396598f, -0.17912844f, -0.26115420f, 
    -0.10791789f, 0.19944748f, 0.06808415f, 0.19591706f, 0.03583524f, -0.11874025f, -0.17629346f, -0.13060556f, 
    -0.16152853f, -0.18648893f, 0.07583573f, -0.14009203f, -0.07716645f, 0.00272290f, 0.14583021f, 0.20237820f, 
    -0.01511418f, 0.20639203f, -0.00537252f, -0.01332501f, 0.01655779f, -0.09448397f, -0.02805079f, 0.06856469f, 
    -0.00236420f, 0.07086020f, 0.25195351f, 0.16992877f, -0.13115449f, 0.02761378f, 0.01333267f, -0.07770274f, 
    0.07733839f, -0.05614861f, 0.04848398f, -0.05291906f, -0.06843788f, 0.10605579f, -0.00300735f, 0.01457027f, 
    0.09721473f, 0.06698929f, 0.03194271f, 0.33139050f, -0.01985897f, 0.00275061f, -0.06008688f, -0.01918761f, 
    0.05450828f, 0.05655330f, -0.05584939f, 0.16778924f, -0.02727252f, 0.00868018f, -0.06838065f, -0.13372931f, 
    0.04803796f, 0.01081022f, -0.15871927f, 0.12779403f, -0.00937551f, -0.12356363f, 0.16905549f, 0.09848937f, 
    -0.21123503f, -0.03726832f, -0.00799330f, 0.04962316f, 0.09144561f, 0.01324376f, -0.42874745f, -0.29153705f, 
    -0.15600604f, -0.21037023f, -0.07118906f, -0.01107370f, -0.03161325f, -0.03239656f, 0.19261724f, 0.23617360f, 
    0.28640890f, -0.13613588f, 0.07594198f, -0.21549372f, -0.19211781f, 0.14389081f, 0.05123496f, 0.00152512f, 
    -0.07233026f, -0.07671475f, 0.12362719f, 0.01205871f, 0.02519615f, 0.01838805f, -0.03202369f, 0.15735130f, 
    0.02460727f, 0.35941786f, 0.34035569f, -0.02726424f, 0.12049512f, -0.03803652f, 0.07387877f, 0.10058153f, 
    0.04373956f, 0.01429651f, -0.14054844f, 0.19861943f, 0.03553982f, -0.10939405f, 0.09304665f, 0.01981137f, 
    -0.01680482f, -0.02123317f, -0.01590012f, 0.20449920f, -0.40581182f, -0.14292225f, 0.03670984f, 0.13841940f, 
    -0.14377774f, -0.07643709f, -0.12324197f, 0.13189463f, -0.22517724f, -0.12565932f, -0.18545805f, -0.14082234f, 
    -0.08513828f, 0.03023060f, 0.05675408f, 0.10924529f, -0.15458944f, 0.34556457f, -0.20459212f, -0.13256720f, 
    0.08904752f, 0.06054113f, -0.05521521f, -0.12871374f, 0.10108772f, 0.00098297f, -0.23284252f, -0.01189480f, 
    0.05567537f, -0.06568100f, 0.10110831f, -0.15941854f, -0.07635529f, 0.12074620f, 0.01143975f, -0.05079951f, 
    -0.22534333f, 0.08467471f, -0.13946089f, -0.11120633f, 0.04073900f, -0.05289134f, 0.05356378f, 0.07650857f, 
    0.14142379f, -0.29445672f, -0.22010416f, -0.18055575f, 0.03117780f, -0.11650293f, -0.11764716f, 0.12943912f, 
    0.02211819f, 0.05066744f, -0.24473566f, -0.06246302f, 0.21384399f, 0.03392751f, 0.08731830f, 0.15829551f, 
    -0.04394205f, -0.05007500f, -0.06949298f, -0.08737430f, 0.16092178f, 0.13152792f, 0.17932306f, 0.05104028f, 
    -0.11660614f, 0.10142253f, -0.01365501f, 0.04768423f, 0.23014763f, -0.31674412f, -0.05573066f, -0.00739226f, 
    0.10036451f, 0.05467582f, 0.00206674f, -0.09066802f, -0.16794538f, 0.05669010f, 0.15425904f, 0.11187027f, 
    0.18630451f, -0.05554624f, 0.15760840f, -0.14019059f, -0.01183157f, -0.37096000f, -0.09687485f, 0.06396706f, 
    -0.03042701f, 0.10635816f, -0.06610560f, 0.12710115f, 0.01165473f, -0.02400934f, 0.05388379f, -0.04679430f, 
    -0.31861627f, -0.09059735f, 0.03313050f, 0.14683591f, -0.18448567f, -0.01043038f, -0.06524213f, 0.23138365f, 
    0.00605751f, -0.08774605f, -0.17174885f, -0.04317194f, -0.07290951f, 0.01959509f, -0.07329608f, -0.02644812f, 
    0.16138233f, 0.03608879f, -0.07787471f, 0.08677062f, -0.00259098f, 0.08231512f, -0.09900725f, 0.20106976f, 
    0.00940518f, -0.16283099f, 0.00878863f, 0.10604044f, -0.10739277f, 0.05484343f, -0.00798357f, 0.05703474f, 
    -0.06629316f, 0.06283785f, -0.11466775f, 0.32495672f, -0.12856263f, 0.03294513f, -0.16484581f, -0.02157329f, 
    0.04922181f, -0.02235535f, 0.06808957f, 0.02254563f, 0.22283624f, -0.09146242f, 0.04596984f, 0.10639673f, 
    -0.04983412f, 0.01064581f, -0.00121788f, 0.07547037f, 0.21176474f, -0.16594653f, -0.03013505f, 0.16859801f, 
    0.00704615f, 0.09907789f, -0.12746461f, -0.03085174f, -0.06692619f, 0.17063254f, 0.10589743f, -0.39448547f, 
    -0.02724948f, -0.01574522f, -0.02296843f, 0.08249222f, 0.04854521f, -0.09638574f, -0.18627740f, 0.20978774f, 
    -0.05152193f, -0.07043651f, 0.10437672f, -0.07933549f, -0.12239230f, -0.00145827f, -0.18045615f, -0.01536391f, 
    0.03432338f, 0.00043343f, 0.12008819f, -0.04557279f, 0.02511250f, 0.10737242f, -0.00797434f, 0.06128567f, 
    0.04082705f, 0.08369947f, 0.30841202f, -0.08188646f, 0.06744203f, -0.13103682f, 0.04404001f, 0.00904541f, 
    0.02893819f, -0.35423258f, -0.45342210f, -0.41936994f, 0.23682658f, 0.20654237f, 0.12096760f, -0.00702257f, 
    -0.18437043f, -0.01000764f, -0.34389606f, -0.28691590f, -0.19473629f, -0.02118279f, 0.13695686f, -0.19773631f, 
    0.11266339f, -0.16050333f, 0.10640894f, 0.02168503f, 0.05702845f, 0.19857913f, 0.00930016f, 0.03177914f, 
    -0.11694311f, 0.10263544f, 0.22494340f, 0.08219361f, -0.12644547f, -0.02830176f, -0.19880897f, -0.08405693f, 
    0.05412752f, 0.08956970f, -0.00346464f, 0.02128033f, -0.16521156f, -0.20320725f, -0.41876957f, -0.22375625f, 
    -0.02442932f, -0.04624603f, 0.06879644f, -0.01668849f, -0.00765540f, -0.02858417f, -0.22674643f, -0.03284636f, 
    -0.34147039f, -0.10272773f, 0.12478744f, 0.07693265f, 0.13504854f, 0.24982257f, 0.04412085f, -0.04786820f, 
    -0.02199557f, 0.13774873f, 0.04734419f, 0.08958196f, -0.11891502f, 0.05204073f, -0.16104494f, 0.05995121f, 
    -0.14681584f, -0.17607522f, 0.17923249f, 0.01942309f, 0.05729423f, 0.08598505f, 0.07783459f, 0.01265026f, 
    0.08991493f, -0.04406742f, 0.05928717f, 0.28601235f, 0.16135898f, -0.09881750f, -0.06582628f, -0.07949326f, 
    -0.03894709f, 0.06792780f, -0.29537356f, 0.07938031f, -0.10718159f, 0.16370949f, -0.03498321f, 0.01530470f, 
    0.02694217f, -0.09064811f, -0.03610895f, -0.13426937f, -0.21058612f, 0.32542923f, 0.14694981f, 0.10860734f, 
    -0.13246697f, 0.14486274f, 0.04447237f, -0.15428923f, -0.17533903f, 0.14548911f, 0.18497241f, 0.10412971f, 
    0.00415762f, 0.13430648f, -0.00456395f, 0.10711944f, 0.16362357f, 0.12666245f, -0.01889468f, 0.12792857f, 
    -0.12337238f, 0.03816532f, 0.01537746f, 0.12936243f, -0.05420443f, 0.09913581f, -0.09417428f, -0.03763594f, 
    0.00761135f, -0.09015436f, 0.07020161f, 0.02426286f, 0.02548519f, 0.03623530f, 0.11713435f, 0.07624640f, 
    0.09568685f, -0.09101366f, 0.16040789f, -0.09211698f, 0.17853470f, 0.11988313f, -0.04094169f, 0.18839054f, 
    -0.26640642f, 0.05442574f, 0.09307404f, -0.11100397f, -0.06082402f, -0.15010506f, 0.06673959f, 0.11202905f, 
    0.04084392f, 0.20126911f, 0.02672473f, 0.12107562f, 0.07161760f, 0.05198774f, 0.02891543f, -0.01835742f, 
    0.08196171f, -0.24960314f, 0.06876077f, 0.29662597f, 0.35697660f, -0.13927311f, 0.02649690f, -0.06743299f, 
    -0.11808899f, -0.01342023f, -0.02593669f, -0.63942850f, 0.17737480f, -0.04289280f, 0.22133774f, 0.06998193f, 
    0.09769786f, 0.07113467f, 0.24173221f, 0.04714836f, 0.03286446f, 0.39437687f, 0.22828868f, 0.19187289f, 
    0.02432889f, 0.02414373f, 0.05372243f, 0.16126026f, 0.23508988f, 0.17843908f, 0.00821380f, -0.12563433f, 
    0.10379166f, -0.05329791f, 0.02785642f, -0.30538529f, -0.01800528f, 0.12755108f, -0.18368901f, 0.14688814f, 
    -0.20766966f, -0.10001011f, -0.27481401f, -0.11902233f, 0.09007450f, 0.14621244f, -0.13629627f, 0.20254427f, 
    0.23813374f, 0.28717282f, 0.17691369f, -0.01736025f, -0.16766469f, -0.00792099f, 0.06290817f, 0.08397528f, 
    0.14244892f, -0.01594668f, 0.05473677f, -0.25083405f, -0.06407099f, -0.00551054f, 0.08024472f, 0.08104500f, 
    -0.05832651f, 0.25459084f, -0.04231872f, 0.13749565f, -0.11561304f, -0.05429919f, -0.03085745f, 0.12949300f, 
    0.00611509f, 0.13826431f, -0.41143304f, -0.14208990f, 0.10542785f, 0.03474593f, 0.15226723f, -0.03560241f, 
    -0.07617198f, -0.03936416f, 0.00784511f, -0.38367498f, -0.11890892f, -0.06397112f, 0.29588366f, 0.15458639f, 
    0.04569234f, -0.11261474f, -0.10685027f, -0.07528418f, 0.08284812f, 0.31609580f, 0.32712215f, 0.06778520f, 
    -0.02253687f, -0.06345458f, -0.20747231f, -0.10171496f, 0.17077108f, -0.08007754f, -0.46705943f, 0.07870371f, 
    -0.03946964f, 0.00689518f, 0.03326550f, -0.03326903f, 0.07281100f, -0.05706311f, -0.39361894f, 0.01782483f, 
    -0.17377104f, 0.07945882f, 0.07203270f, 0.11973397f, -0.03086731f, 0.05745985f, -0.05957919f, -0.07478467f, 
    0.14632282f, 0.00377789f, 0.09516552f, -0.08000502f, 0.27924705f, -0.01953472f, 0.17007358f, 0.12012232f, 
    0.00321313f, 0.09215762f, 0.15732995f, -0.03178380f, -0.28432676f, -0.06007565f, -0.00813295f, 0.01722658f, 
    0.03206420f, 0.08879396f, 0.08293232f, 0.13677229f, 0.04655522f, 0.10813651f, 0.16369666f, 0.00433847f, 
    0.03038426f, 0.04720245f, 0.14852391f, 0.22941476f, -0.22120656f, 0.01461163f, -0.32591709f, -0.07945878f, 
    -0.12523066f, -0.06150295f, -0.19057223f, 0.10301200f, -0.00478563f, -0.03401536f, -0.07854873f, 0.06176934f, 
    0.00104716f, -0.04660163f, -0.20873974f, 0.19383794f, 0.05668043f, -0.10805364f, -0.14251879f, -0.00035694f, 
    0.15080847f, 0.03128277f, 0.06099516f, 0.03241908f, 0.07086965f, 0.34509200f, -0.15325367f, -0.08143384f, 
    0.12759320f, -0.02245305f, -0.03085489f, -0.08527572f, -0.09621808f, -0.04400068f, -0.09479479f, 0.43049398f, 
    0.28679240f, 0.03106673f, 0.18969724f, -0.04056452f, 0.31737351f, 0.14444280f, 0.12028248f, 0.19097610f, 
    0.09491557f, -0.15256798f, -0.06527984f, -0.00375105f, -0.18815058f, -0.00791474f, -0.11065980f, -0.09907266f, 
    -0.11011869f, 0.02571320f, -0.12176746f, -0.04795509f, -0.07990538f, -0.16568054f, 0.02970479f, 0.02639039f, 
    -0.12196282f, -0.45046228f, -0.09709774f, 0.06411798f, 0.04838010f, -0.07691857f, -0.01153364f, -0.02907420f, 
    0.07130437f, -0.03404637f, -0.05271822f, 0.01012302f, 0.01568519f, -0.02691029f, -0.03806949f, 0.11431602f, 
    -0.00112659f, 0.03210052f, 0.19313973f, 0.18056221f, 0.05399646f, 0.12355042f, 0.01867934f, -0.04273461f, 
    0.03028044f, 0.17340550f, -0.13936783f, 0.05321938f, -0.21767844f, -0.03682972f, -0.02375229f, 0.04792287f, 
    -0.04282324f, 0.04953655f, 0.06026377f, 0.01892898f, -0.06558666f, -0.29093266f, 0.01018455f, -0.07015207f, 
    -0.15795314f, -0.06246180f, -0.03345652f, -0.06520767f, -0.01328442f, 0.00402380f, -0.21875772f, 0.10981512f, 
    -0.00226801f, -0.10281761f, -0.16028620f, -0.02907488f, -0.26552826f, 0.09326773f, 0.08225340f, 0.20278369f, 
    -0.10209229f, -0.00941424f, 0.06732403f, 0.03892900f, 0.01802961f, -0.17268106f, -0.08812549f, -0.10546460f, 
    -0.24896191f, -0.01174149f, 0.04907029f, 0.04183273f, 0.05722820f, -0.05232402f, -0.00785560f, 0.07686768f, 
    0.07052182f, 0.15585496f, -0.06695288f, 0.01143439f, -0.13496318f, 0.03330645f, -0.07858191f, -0.15282482f, 
    -0.04168018f, -0.05436236f, 0.02157359f, -0.09139910f, -0.11692423f, -0.12624660f, 0.02949633f, -0.14248419f, 
    -0.14222787f, 0.02374240f, -0.08382891f, -0.24371915f, 0.08001920f, 0.15484202f, 0.07368074f, -0.12292638f, 
    0.05232120f, -0.05765766f, 0.03277180f, -0.00403128f, -0.15902431f, 0.08892903f, -0.03586527f, -0.15879753f, 
    -0.00760212f, -0.02425943f, -0.00042287f, -0.07930396f, 0.12040363f, 0.10562201f, 0.27065831f, 0.06886034f, 
    -0.08703046f, 0.02158982f, 0.04796614f, -0.13379341f, 0.02191014f, 0.17856345f, 0.05065713f, 0.20462514f, 
    0.09171974f, 0.11322688f, 0.06478403f, 0.05443552f, 0.22005956f, -0.04760563f, -0.04161162f, 0.08794089f, 
    0.00851879f, -0.01207188f, 0.05691373f, -0.07863633f, -0.13360484f, 0.00160429f, -0.04812824f, -0.08014332f, 
    -0.14316764f, -0.08492533f, -0.12857889f, 0.15418494f, -0.00469902f, -0.22949575f, -0.14410584f, -0.09084893f, 
    -0.08278986f, 0.24677446f, 0.01317505f, -0.39736176f, 0.01505813f, 0.04513812f, -0.04607239f, 0.08485621f, 
    0.17952076f, -0.10957678f, 0.11411229f, -0.09455126f, 0.26194265f, 0.08096159f, -0.02980313f, 0.03552762f, 
    0.02877122f, 0.00706565f, -0.11945987f, 0.19093387f, 0.01154021f, 0.18085055f, -0.17175919f, -0.07031841f, 
    -0.04600309f, 0.03388587f, -0.02953171f, -0.01842325f, -0.04605705f, -0.13600430f, -0.15525378f, 0.12493155f, 
    0.01518935f, -0.00312383f, 0.06138283f, 0.17204194f, -0.00719511f, 0.13263941f, 0.16394457f, 0.06256952f, 
    -0.02601973f, 0.10634095f, -0.17735545f, -0.20075309f, 0.12372053f, -0.12526454f, -0.17896782f, 0.17023744f, 
    0.35992271f, 0.04244338f, -0.00196145f, -0.01935652f, 0.02757221f, 0.05600405f, -0.10732599f, -0.06411119f, 
    -0.04190147f, -0.50688654f, -0.22394815f, -0.09913769f, -0.11762066f, -0.04639809f, -0.10549500f, 0.17765489f, 
    -0.03375372f, 0.03348753f, 0.01644312f, 0.00964109f, 0.04789509f, -0.00139175f, 0.00621943f, 0.04152870f, 
    0.01151846f, 0.03942836f, -0.04162307f, 0.02085675f, -0.02430430f, -0.03934285f, 0.01424061f, -0.01850042f, 
    0.00783513f, -0.05245784f, -0.04449500f, -0.03833321f, -0.03071610f, -0.01373232f, -0.00014834f, 0.00759047f, 
    -0.02528000f, 0.03289065f, -0.04148041f, -0.01092911f, 0.02719620f, 0.04336235f, -0.02621161f, 0.01168347f, 
    0.00137838f, 0.01463209f, -0.01171578f, 0.02526376f, -0.02252192f, -0.01150475f, 0.01788502f, 0.00033752f, 
    0.02041345f, -0.00212594f, -0.04083359f, -0.06323465f, 0.01399450f, -0.00743899f, -0.05617587f, 0.02128574f, 
    0.05100796f, -0.00660586f, 0.03566636f, -0.04779690f, 0.01545072f, 0.04702076f, -0.03398705f, -0.00308856f, 
    -0.05832009f, -0.05611384f, -0.00966269f, -0.03541602f, 0.04080927f, -0.00009350f, -0.02873637f, 0.02496799f, 
    -0.01252886f, 0.01489500f, 0.02551783f, -0.05167870f, -0.05646088f, 0.04969960f, -0.03801896f, 0.03066424f, 
    0.04144025f, 0.01804649f, -0.01509753f, -0.04187151f, 0.05024790f, -0.00494710f, -0.03810618f, -0.00128571f, 
    -0.02598215f, -0.04330873f, -0.01915675f, 0.01348348f, -0.04428435f, -0.02373530f, -0.02224712f, -0.01401366f, 
    -0.05149143f, -0.01636821f, -0.04461304f, 0.03588205f, 0.02142697f, -0.00196244f, 0.03408432f, 0.01930584f, 
    -0.00828983f, -0.01537578f, -0.01916807f, 0.00629587f, -0.01111126f, -0.02156874f, 0.03616891f, 0.01561318f, 
    -0.04877490f, -0.05583285f, -0.00862465f, -0.05173626f, -0.02836975f, 0.03721772f, -0.04150916f, 0.02155495f, 
    0.03216519f, 0.04810432f, -0.04238443f, -0.00331261f, 0.00405980f, 0.01513478f, -0.06256204f, -0.03611261f, 
    0.01547102f, -0.04762501f, -0.03589882f, -0.03700669f, -0.01773338f, -0.06161447f, 0.01390315f, 0.04104164f, 
    0.01134266f, -0.02592387f, 0.02151135f, -0.05834581f, -0.02653956f, -0.06315986f, -0.01279086f, 0.00587881f, 
    -0.02375204f, 0.03881919f, -0.06051418f, -0.04715785f, 0.03822577f, -0.06406631f, 0.01993345f, -0.00834247f, 
    0.00288622f, -0.04270177f, 0.01296680f, -0.04792167f, -0.05491744f, -0.00715443f, 0.03106068f, -0.03590740f, 
    0.01313249f, -0.06458011f, 0.04476380f, -0.02550111f, -0.02578705f, -0.01083809f, 0.02574293f, -0.03311224f, 
    -0.03810494f, 0.02188066f, -0.03759374f, 0.00236217f, 0.00989807f, 0.02925574f, 0.03924146f, 0.04350874f, 
    -0.03909895f, -0.06295552f, -0.01323489f, -0.00010002f, 0.00478892f, 0.03698447f, -0.00394671f, 0.02316980f, 
    0.04194710f, 0.00949826f, -0.04719912f, 0.02879813f, -0.03646688f, 0.04291505f, -0.06219343f, 0.02592009f, 
    -0.01252637f, -0.03483788f, -0.03573959f, 0.01437462f, -0.01385635f, 0.01040590f, -0.00837311f, -0.05858769f, 
    -0.00113765f, -0.05420384f, -0.00563294f, 0.04575431f, 0.01371830f, -0.06213617f, 0.03333806f, -0.03735660f, 
    -0.04192111f, 0.04624580f, -0.04526436f, -0.01356684f, 0.00996741f, -0.01027149f, -0.05563299f, 0.03182182f, 
    0.05076391f, -0.00920306f, 0.03259695f, -0.01809952f, -0.01172251f, -0.00513375f, 0.00104624f, -0.00378053f, 
    -0.02512131f, -0.01014270f, 0.01156507f, 0.03444163f, -0.03205133f, 0.03881754f, -0.01193981f, -0.06076923f, 
    0.04009677f, 0.03787699f, -0.04747368f, -0.05122536f, 0.03351844f, -0.02457060f, -0.00223893f, -0.01293498f, 
    -0.02405112f, 0.04675833f, 0.02881008f, -0.03851863f, 0.02300878f, 0.02309499f, -0.01500899f, 0.00868537f, 
    0.02578974f, -0.05240409f, 0.01854597f, -0.00000126f, 0.01453832f, -0.01196936f, -0.02920506f, 0.02207368f, 
    -0.00864947f, -0.06556919f, 0.00655748f, -0.05506225f, 0.00158754f, 0.02590768f, -0.00082545f, 0.04687756f, 
    -0.01107879f, -0.01898597f, 0.00981950f, -0.06419789f, 0.02912795f, 0.04130081f, 0.01535870f, 0.03709888f, 
    0.00923603f, 0.01185393f, 0.04641676f, 0.01002984f, -0.04317350f, 0.05062798f, -0.02602004f, -0.04914264f, 
    -0.02099925f, -0.01063144f, -0.01398489f, 0.04392464f, -0.01315146f, -0.00425869f, -0.02063774f, -0.03016766f, 
    -0.05679391f, -0.03516768f, -0.02927399f, -0.02105519f, 0.03657337f, -0.03382208f, -0.00717909f, -0.05991770f, 
    -0.07451765f, -0.01170431f, -0.03398008f, -0.01331398f, 0.02036099f, -0.06355557f, -0.03440822f, 0.04421689f, 
    -0.00940121f, -0.04837348f, -0.03006622f, -0.05852070f, -0.07583729f, -0.08480699f, -0.00548348f, -0.01143349f, 
    0.00582444f, -0.03784985f, -0.09308404f, -0.00362531f, -0.02453212f, -0.00311416f, -0.03114650f, -0.05915421f, 
    0.01708261f, -0.08851155f, -0.08504676f, -0.03498352f, 0.01494037f, 0.00915173f, 0.01940411f, -0.07578775f, 
    -0.02645885f, 0.03068284f, 0.03645506f, 0.01245307f, 0.00267810f, -0.00697643f, -0.06516854f, -0.04055953f, 
    -0.00636230f, -0.08107418f, -0.08107819f, 0.01729516f, 0.02461451f, 0.01269211f, -0.00033820f, -0.00500317f, 
    -0.03004680f, -0.09386788f, -0.05343889f, 0.03472285f, -0.05268343f, -0.03720026f, -0.00286196f, 0.01577016f, 
    0.00335326f, -0.08890392f, -0.06765464f, -0.02305038f, -0.03180484f, -0.00300843f, -0.02190199f, -0.02026050f, 
    -0.03265504f, 0.01595335f, -0.03312355f, -0.03716070f, -0.07855163f, -0.03354508f, -0.03276672f, -0.04035343f, 
    -0.06819715f, 0.00708834f, -0.02728205f, -0.00590547f, 0.00436989f, -0.01035661f, -0.04820743f, 0.03575557f, 
    -0.07364449f, -0.07665676f, -0.05737481f, -0.04152959f, -0.03883033f, 0.02691284f, -0.09250999f, -0.07515905f, 
    -0.06267273f, -0.04415731f, -0.03636517f, -0.07219394f, -0.02906395f, -0.05810032f, -0.01793040f, -0.01469422f, 
    0.00501779f, 0.02444407f, -0.03222539f, -0.01351284f, -0.06687898f, -0.04146403f, -0.07061295f, -0.08365882f, 
    -0.02893050f, -0.03512131f, -0.05715704f, -0.01009168f, -0.05891917f, -0.05579102f, -0.02374467f, -0.03160856f, 
    -0.04359379f, -0.05681290f, -0.09918340f, 0.04341328f, 0.03398309f, -0.06156335f, -0.03547810f, 0.00687938f, 
    0.00579706f, -0.03879740f, -0.06061864f, 0.02836088f, -0.07620415f, -0.05090484f, 0.01382365f, -0.01695633f, 
    -0.08330536f, 0.01556481f, -0.04203563f, -0.01301254f, 0.00203344f, -0.04967896f, -0.04954045f, -0.07506067f, 
    -0.04771918f, -0.04084067f, -0.03148418f, -0.02716062f, 0.01666302f, -0.05835517f, 0.02206005f, 0.01642912f, 
    -0.05458831f, -0.07678667f, -0.10412369f, -0.02911506f, -0.07139901f, -0.05293999f, 0.00996410f, 0.02857221f, 
    -0.00709071f, 0.00058014f, 0.00406696f, -0.02016507f, -0.00403037f, -0.00500035f, -0.03556171f, -0.05902783f, 
    -0.03326192f, 0.02353427f, -0.09369196f, -0.05798280f, -0.01493402f, -0.04349491f, -0.01020908f, -0.08859630f, 
    -0.01331407f, -0.07800028f, 0.00675339f, -0.03016545f, 0.00878096f, -0.00967062f, 0.00328690f, -0.02168011f, 
    -0.04726151f, -0.06458234f, -0.09711465f, -0.05977757f, -0.05554598f, -0.04484891f, -0.02451670f, -0.03923037f, 
    -0.08171055f, -0.08214241f, 0.02245172f, -0.08806089f, 0.02137820f, 0.00017521f, -0.00006546f, 0.02849089f, 
    -0.04965605f, -0.01751777f, -0.06694037f, -0.04473625f, 0.01374663f, -0.05913605f, -0.06317276f, -0.09173637f, 
    -0.05142535f, -0.09149252f, -0.04279516f, -0.00089121f, -0.05005527f, 0.01601449f, -0.02008418f, -0.03733568f, 
    -0.00685994f, -0.02081888f, 0.01072431f, 0.02473143f, -0.08107404f, -0.07314205f, -0.03846737f, -0.06415156f, 
    -0.08209744f, -0.04232386f, -0.09754297f, 0.00518784f, -0.08514441f, -0.07514863f, -0.03455153f, -0.06475953f, 
    -0.05922863f, -0.05744018f, -0.08353987f, -0.01154759f, 0.01386030f, 0.00715814f, -0.10473093f, -0.04391927f, 
    0.00399956f, -0.00105142f, -0.06240631f, -0.07304708f, 0.00255346f, -0.01757814f, -0.07797220f, -0.00096958f, 
    0.03008765f, -0.05854141f, 0.00240413f, -0.05339489f, -0.07258652f, -0.04492872f, 0.01025223f, -0.04615063f, 
    0.02263240f, -0.03471172f, -0.09414271f, -0.02924934f, -0.08453506f, -0.06209606f, -0.09736978f, -0.04976219f, 
    -0.05302585f, -0.06403849f, -0.04114181f, 0.01540120f, -0.06122516f, -0.02107269f, -0.03308073f, 0.02732067f, 
    -0.04547371f, -0.06227062f, -0.01262464f, -0.08244910f, -0.07283082f, -0.00593061f, -0.05516079f, -0.04406099f, 
    0.01393558f, 0.01453078f, 0.00551032f, -0.08467047f, -0.06942522f, 0.03236753f, -0.02460728f, 0.02266693f, 
    -0.05429581f, -0.01491227f, -0.08816940f, -0.01786224f, -0.00390148f, 0.02223921f, -0.05356996f, -0.04866422f, 
    -0.06650572f, 0.00856424f, -0.03812942f, -0.06029900f, -0.04177790f, -0.02275623f, -0.03424048f, -0.05235790f, 
    0.02665125f, 0.03979852f, -0.03679448f, 0.00788336f, 0.00740825f, 0.05251792f, 0.03862371f, 0.02548902f, 
    0.02724589f, 0.03068530f, -0.01409387f, -0.05035365f, -0.05134212f, -0.01204465f, -0.01015608f, 0.03290982f, 
    0.03539828f, -0.06226270f, -0.03873903f, -0.05418418f, 0.02084734f, -0.05343387f, -0.00996828f, 0.01529669f, 
    0.02030177f, 0.04442373f, -0.01782960f, 0.01149363f, -0.00839454f, 0.02020193f, -0.05728685f, -0.03984411f, 
    0.04525245f, -0.05110711f, -0.03084827f, 0.01204778f, -0.02181561f, -0.01472759f, 0.02526820f, 0.03946863f, 
    0.02658013f, -0.01452589f, -0.01023760f, -0.03994906f, 0.00075288f, 0.02668692f, 0.00221948f, 0.03070205f, 
    -0.06815738f, 0.01777574f, 0.03068891f, -0.01102975f, -0.01042085f, 0.02487629f, -0.04992176f, -0.04205381f, 
    0.04703682f, 0.04330276f, 0.03651157f, -0.03524986f, -0.01829551f, -0.05149507f, 0.03370532f, -0.02570008f, 
    -0.02942115f, 0.03589974f, 0.03446355f, -0.01844403f, -0.06261344f, -0.01928434f, 0.02011146f, -0.05240474f, 
    -0.03375621f, 0.02274007f, -0.01620918f, -0.05891424f, -0.06001165f, -0.01098849f, 0.01692270f, 0.04984206f, 
    0.00539338f, 0.04345712f, 0.02106702f, 0.02847656f, 0.00370320f, -0.00289051f, 0.05075670f, -0.06677465f, 
    -0.05499974f, -0.06612042f, -0.03526302f, -0.00777208f, -0.00739540f, -0.05836198f, -0.05558784f, 0.04031913f, 
    0.04633940f, 0.02884195f, -0.03428371f, -0.03565603f, -0.02000168f, 0.00771551f, 0.03245636f, 0.00357669f, 
    0.03114212f, 0.03550331f, 0.02122337f, 0.02922018f, -0.03782364f, -0.06323766f, -0.05309862f, 0.03230448f, 
    -0.02637348f, -0.00911409f, -0.05959937f, -0.05206326f, 0.01384521f, -0.01476014f, -0.01548860f, 0.00472830f, 
    0.03627700f, 0.02018323f, 0.01083592f, 0.02040809f, -0.03871045f, -0.00960050f, -0.00973614f, -0.06071933f, 
    0.00613665f, -0.02659648f, 0.03971938f, 0.00558016f, 0.02983192f, -0.03762960f, 0.02158896f, 0.04079458f, 
    0.03226008f, 0.01031839f, -0.05142353f, -0.01825838f, 0.03595592f, -0.01111394f, 0.04034825f, -0.02095794f, 
    0.00000626f, 0.01004560f, 0.03340068f, 0.03183837f, -0.01931435f, -0.02954380f, -0.04563735f, 0.04373200f, 
    -0.02024193f, 0.02508630f, -0.06548221f, -0.04062114f, -0.02167300f, 0.02198004f, 0.04394949f, 0.00311801f, 
    -0.06526748f, -0.00979429f, -0.02822256f, 0.02086328f, -0.04882042f, -0.04185644f, 0.01350957f, -0.00645655f, 
    -0.02534254f, -0.00119172f, -0.05431101f, -0.03837468f, 0.01315311f, -0.01443363f, 0.00961948f, -0.03204665f, 
    0.03748360f, 0.02219557f, -0.06576641f, 0.02272264f, -0.01441267f, -0.01692398f, -0.06036068f, -0.00083218f, 
    0.04269806f, -0.00782522f, 0.03792376f, -0.06503767f, -0.03528511f, -0.00551718f, 0.02878764f, -0.03105181f, 
    0.00659495f, -0.05382941f, -0.06099362f, -0.03936253f, 0.00110514f, -0.00921259f, 0.05063814f, -0.05930594f, 
    -0.05270339f, -0.06665818f, 0.01804794f, 0.01588039f, -0.04750392f, 0.04204400f, -0.00715514f, 0.01097204f, 
    0.01205843f, -0.01825741f, -0.05312084f, -0.03051063f, 0.04756597f, 0.02436564f, -0.04399182f, -0.01399267f, 
    -0.03492963f, -0.03613265f, 0.04394140f, -0.02233606f, -0.00922062f, -0.05599636f, -0.03026529f, -0.06804249f, 
    -0.01456195f, -0.02777294f, 0.04137282f, -0.06233961f, -0.04684996f, -0.03279663f, 0.03651220f, 0.00239129f, 
    0.00272271f, -0.03526128f, -0.05030974f, -0.01926924f, 0.02903680f, 0.03238432f, -0.03402530f, 0.00916296f, 
    0.01391381f, 0.02756490f, 0.04728160f, -0.03271301f, -0.04772748f, 0.03404099f, 0.04994268f, -0.00872092f, 
    0.01216431f, -0.00038584f, -0.00509397f, 0.01429595f, 0.02740213f, 0.05353193f, -0.01227040f, 0.00506789f, 
    -0.05530481f, 0.00806777f, -0.03339931f, -0.02991899f, 0.00777254f, 0.00388842f, 0.00778762f, 0.01298109f, 
    0.03135737f, -0.02507220f, 0.00468079f, -0.05624925f, -0.02351169f, 0.04683045f, 0.02110847f, -0.04538890f, 
    0.04173619f, -0.02319480f, 0.04122815f, -0.03062435f, -0.03229991f, 0.03391017f, 0.01127687f, -0.00363218f, 
    -0.02368526f, 0.04831480f, 0.10991724f, 0.07366397f, 0.10402376f, 0.07098829f, 0.06813238f, 0.08516755f, 
    0.10734046f, 0.43160918f, 0.14667138f, -0.19449055f, -0.45225292f, -0.15147205f, -0.26022139f, -0.08414967f, 
    -0.10463338f, 0.17874941f, -0.81812489f, -0.08497569f, 0.22844596f, -0.11143330f, -0.00583612f, -0.01567157f, 
    -0.14406523f, 0.08168878f, -0.06092722f, 0.10436847f, 0.03543737f, -0.08305638f, 0.02739280f, 0.13714030f, 
    -0.08861969f, 0.31661239f, 0.11213695f, 0.24064019f, 0.13619076f, -0.15397103f, 0.21358243f, -0.34090713f, 
    -0.06259045f, 0.06334892f, 0.17609003f, -0.08186627f, 0.12371081f, 0.33432332f, 0.26199448f, -0.63353091f, 
    -0.13710119f, -0.08267896f, 0.02745941f, -0.07760409f, -0.00641143f, -0.18652356f, 0.29010782f, -0.19846374f, 
    0.12858728f, -0.11922659f, 0.14195894f, 0.09711832f, 0.01661737f, 0.00756022f, -0.16721550f, 0.72867852f, 
    0.26150873f, -0.40094453f, 0.18241251f, 0.01149613f, 0.02827962f, -0.04721642f, -0.00296043f, -0.07246972f, 
    -0.02171074f, -0.19160831f, 0.17006585f, -0.25221252f, 0.07474283f, -0.08750299f, -0.01018682f, 0.00078957f, 
    -0.14875107f, 0.53602844f, 0.01511799f, 0.17152989f, 0.11347553f, 0.06301078f, 0.09935211f, 0.02543784f, 
    0.07091593f, 0.06129315f, 0.26835233f, 0.23692520f, 0.02963518f, -0.33154190f, -0.02789777f, -0.12699643f, 
    -0.05644663f, 0.02192008f, -0.01299574f, -0.21324955f, -0.42783302f, 0.15513615f, 0.09099730f, 0.27187401f, 
    -0.02907543f, -0.22859071f, -0.24551840f, 0.00286538f, 0.06458540f, -0.09865686f, 0.02769940f, 0.02066154f, 
    -0.07299302f, 0.04852084f, -0.05883775f, 0.02585785f, 0.11148795f, -0.09844974f, 0.01302747f, -0.04631047f, 
    0.05634794f, 0.12277550f, -0.00440110f, -0.01866130f, 0.15941954f, 0.04997971f, -0.10098845f, -0.30528852f, 
    0.05708430f, 0.00196245f, 0.18707436f, 0.02084307f, 0.07217185f, 0.16537914f, -0.11453729f, 0.31390336f, 
    0.29155022f, -0.36572486f, -0.00893571f, 0.12495460f, 0.26771581f, -0.11997079f, -0.02216942f, -0.00958583f, 
    0.24714451f, -0.29219854f, -0.01782236f, -0.13273285f, 0.02431550f, 0.17502020f, -0.10938173f, -0.05495132f, 
    -0.13104911f, 0.25008136f, 0.08376408f, -0.07922364f, -0.19375217f, 0.01179296f, 0.06068215f, 0.02600489f, 
    0.00314174f, -0.01962116f, -0.11734987f, 0.29040068f, 0.03280225f, -0.04559838f, 0.14682037f, 0.10836895f, 
    0.23106372f, 0.03519472f, -0.17563695f, 0.03704600f, -0.21620072f, 0.33440804f, -0.00933634f, 0.13759013f, 
    -0.14755210f, -0.09841888f, 0.01929809f, 0.07905694f, -0.43473890f, 0.10302792f, 0.01349316f, 0.13404495f, 
    0.13670763f, 0.05253032f, -0.03670374f, 0.06537081f, 0.01194578f, 0.49758467f, -0.01577826f, -0.30400318f, 
    0.11651012f, -0.01820026f, 0.26678774f, -0.00089713f, 0.05700835f, 0.11278404f, -0.16683958f, -0.01834555f, 
    -0.09952001f, -0.02848545f, 0.11724260f, 0.08634383f, -0.10219517f, -0.04385683f, 0.21753158f, 0.04807381f, 
    -0.27046806f, 0.12627582f, -0.01531053f, 0.00233051f, 0.13308465f, 0.12687710f, 0.16487469f, -0.11669847f, 
    0.03239823f, 0.31320727f, -0.02471123f, 0.09884478f, -0.05656563f, 0.19293703f, 0.02498851f, 0.14057343f, 
    -0.20824164f, -0.15098362f, 0.16927056f, 0.14751644f, -0.04096205f, 0.00908830f, -0.07280421f, 0.22149202f, 
    0.06127086f, -0.07111863f, -0.07894071f, -0.15026328f, -0.18059550f, -0.12502918f, 0.09439433f, -0.13426054f, 
    0.01380452f, -0.02464094f, 0.04386886f, 0.66184711f, 0.04932555f, -0.26110956f, -0.21466722f, 0.26296636f, 
    -0.06686731f, 0.08731179f, -0.13890333f, 0.21845657f, 0.14222439f, 0.66130090f, -0.09387427f, 0.06793348f, 
    0.08159073f, -0.01306025f, -0.01240289f, -0.10260053f, -0.02679895f, 0.48291478f, -0.23836263f, -0.07129183f, 
    -0.16386662f, 0.23036149f, -0.00738261f, 0.01532297f, -0.03733842f, -0.04080292f, 0.04204642f, 0.09540138f, 
    -0.13997160f, 0.09229477f, 0.33582735f, 0.12136940f, -0.17938532f, -0.08728075f, -0.03436781f, -0.15677068f, 
    -0.00419107f, -0.11252722f, -0.13687028f, 0.12305787f, -0.02911826f, -0.06604382f, 0.15554987f, 0.23986886f, 
    -0.00431255f, 0.14403415f, 0.12203591f, 0.01604787f, -0.05248148f, -0.24607050f, -0.04077134f, 0.06906867f, 
    0.00956163f, 0.16155306f, 0.13053699f, 0.13766176f, 0.04603903f, -0.00833502f, -0.12853992f, -0.07772598f, 
    -0.11721294f, 0.05313542f, -0.46613073f, 0.01773421f, 0.16071405f, 0.01088764f, 0.13639499f, -0.01397290f, 
    0.10449758f, -0.17188668f, -0.03372686f, -0.01668991f, 0.15803574f, -0.00238663f, 0.13412657f, -0.13922918f, 
    -0.10876469f, -0.06465630f, 0.01258869f, -0.03478430f, 0.05011600f, -0.24721587f, 0.04226948f, -0.34762648f, 
    0.06860165f, -0.06080825f, 0.23619145f, 0.05938967f, 0.06788093f, 0.05101642f, 0.25679767f, -0.52124929f, 
    0.19007376f, 0.06111695f, 0.12134358f, 0.03824992f, 0.11894109f, -0.16596751f, -0.10941791f, 0.39251226f, 
    -0.08502707f, 0.05877578f, 0.05642840f, -0.00017805f, -0.08539532f, 0.08090406f, -0.10973595f, -0.16044967f, 
    0.01904316f, -0.14618656f, -0.03132245f, -0.05998323f, 0.02765041f, 0.02348564f, -0.16299605f, 0.01754273f, 
    -0.12027554f, -0.02930956f, 0.30870703f, -0.07616394f, -0.00774484f, 0.07708785f, 0.00510135f, 0.08885667f, 
    0.10401977f, -0.07268125f, -0.25731611f, -0.03080350f, 0.07234826f, 0.06221489f, 0.13092579f, -0.15322809f, 
    -0.03616667f, -0.11914612f, -0.10848137f, 0.14409640f, -0.05033184f, 0.10873175f, -0.10340147f, -0.04379809f, 
    0.09578045f, 0.02481765f, -0.04130084f, -0.04719107f, -0.03865942f, 0.02143974f, -0.05309850f, 0.06334332f, 
    0.01909589f, -0.00160314f, -0.00731537f, 0.02780994f, -0.03384001f, 0.13258548f, 0.16473092f, 0.11707544f, 
    0.00846078f, -0.15422392f, 0.00859510f, 0.14765126f, 0.21441874f, -0.03158150f, -0.07637613f, -0.08404434f, 
    0.02398145f, 0.05452716f, 0.04261114f, 0.08746786f, -0.11083694f, 0.08933349f, -0.26467100f, -0.02662716f, 
    0.19330643f, -0.09781882f, 0.06565882f, 0.00272504f, -0.08234069f, -0.02821377f, 0.04586789f, 0.22829770f, 
    -0.01015810f, 0.03594600f, -0.07826961f, -0.04534866f, 0.13986565f, 0.07414103f, -0.10633075f, 0.10318575f, 
    0.21446009f, -0.20384628f, 0.08762433f, 0.02944237f, -0.02782972f, 0.02114812f, 0.05700160f, 0.10917999f, 
    0.13547900f, 0.03011522f, 0.06342565f, -0.08702238f, 0.28538966f, -0.06142177f, -0.30474266f, 0.09447522f, 
    0.20621316f, 0.16798578f, 0.02614230f, -0.05034962f, 0.14460959f, -0.02361161f, -0.07653999f, 0.04521549f, 
    -0.13344438f, 0.00137156f, 0.18662359f, 0.05196565f, 0.11150742f, -0.19242309f, -0.03871536f, -0.06995442f, 
    0.08463529f, 0.12637156f, -0.03874717f, -0.04765835f, 0.01586358f, -0.02532087f, 0.01522849f, 0.04816983f, 
    -0.13094120f, 0.01299988f, -0.04243460f, -0.04699121f, 0.04321622f, -0.39711156f, 0.04003083f, -0.23964483f, 
    0.17071274f, -0.03916193f, -0.02128219f, -0.05565247f, 0.03117871f, -0.14634073f, 0.12107144f, 0.22206128f, 
    -0.15747745f, 0.02456419f, -0.03344821f, -0.14740215f, 0.14977910f, 0.22784302f, -0.33057851f, -0.11060736f, 
    0.04865262f, 0.08388488f, 0.04684229f, -0.05184437f, -0.00821679f, 0.02930639f, 0.11193300f, -0.06398361f, 
    0.06939369f, 0.03938319f, -0.04813893f, -0.14924239f, 0.03500491f, 0.06730963f, 0.13012125f, -0.21347752f, 
    0.08233786f, 0.20223831f, 0.18364364f, 0.08718682f, -0.08187131f, -0.10848241f, -0.20560008f, 0.00332293f, 
    0.16233857f, 0.17950624f, -0.05588825f, -0.05928905f, 0.04692810f, 0.21532947f, -0.05339633f, 0.20919029f, 
    -0.10821364f, 0.15761872f, -0.23448938f, -0.30454761f, 0.07270371f, 0.14972840f, 0.14741895f, 0.04394063f, 
    -0.04169254f, -0.03511337f, 0.04556496f, 0.03888835f, 0.10036307f, -0.20292366f, 0.07448465f, -0.13528779f, 
    -0.08220698f, 0.08103070f, -0.32553101f, 0.07350777f, -0.05175893f, -0.00117003f, -0.09313645f, -0.22024938f, 
    0.08828830f, -0.10740531f, 0.12226678f, -0.01489483f, 0.04786260f, -0.07832506f, -0.05621320f, -0.11293671f, 
    -0.06527209f, -0.00946603f, 0.03349199f, 0.09596972f, 0.00896857f, -0.23028642f, -0.09274212f, -0.05677732f, 
    0.13899441f, -0.05448592f, 0.07390399f, -0.02041119f, 0.01753828f, 0.07972405f, -0.12345862f, 0.11029693f, 
    -0.05652401f, -0.08884043f, -0.16211534f, 0.01270539f, 0.00770676f, 0.17786799f, -0.03503747f, -0.00071543f, 
    -0.01746314f, 0.16170111f, -0.12638673f, -0.01576837f, 0.20082010f, 0.09225573f, -0.00750951f, -0.05962199f, 
    -0.04261778f, 0.12670420f, 0.12368737f, -0.04583807f, -0.12566921f, -0.12012486f, -0.11957873f, 0.10766372f, 
    -0.03816928f, 0.13041243f, -0.08598975f, 0.11665266f, 0.04372255f, -0.07249009f, -0.12837434f, 0.20124812f, 
    -0.01239227f, 0.05945518f, -0.01530504f, -0.12275666f, 0.24774760f, 0.22576824f, 0.14375864f, 0.24171712f, 
    0.05895160f, 0.06568553f, -0.15358652f, -0.00655547f, -0.13467860f, -0.10562292f, 0.19329663f, -0.11182858f, 
    -0.00762137f, 0.03053358f, 0.02550473f, -0.02840671f, -0.04216417f, -0.42480156f, -0.10454261f, -0.30037317f, 
    -0.39816791f, 0.08063215f, 0.25170285f, 0.05783371f, -0.01500789f, -0.08857474f, 0.17752352f, -0.08378653f, 
    -0.12696740f, 0.01100631f, 0.05188329f, 0.05192157f, -0.03383682f, 0.14149252f, 0.19208515f, -0.14295906f, 
    0.30324650f, -0.05179541f, -0.12128195f, -0.10298603f, 0.10596367f, 0.22522490f, -0.10625853f, -0.05327332f, 
    -0.11912982f, 0.37182254f, 0.25026786f, 0.11318802f, -0.38731876f, -0.08178980f, -0.17558932f, 0.20228647f, 
    0.11857396f, -0.12685843f, 0.33906505f, -0.12965477f, 0.13150297f, -0.02368245f, 0.07282116f, 0.22402661f, 
    -0.07373058f, -0.11452162f, 0.06306326f, 0.13878855f, 0.23178993f, -0.09127616f, -0.06197457f, -0.12292922f, 
    0.12224288f, -0.07816000f, 0.06204091f, -0.09637186f, -0.03365871f, 0.19864586f, -0.06391915f, 0.12681293f, 
    0.03145890f, 0.12984605f, 0.15552768f, 0.14377423f, -0.05889395f, 0.01827296f, -0.02725942f, 0.07391847f, 
    0.02647421f, -0.08592241f, -0.04908331f, -0.20257503f, -0.05867064f, -0.03543450f, 0.13400042f, -0.08715107f, 
    -0.13395846f, -0.04575771f, -0.08332335f, 0.01844482f, 0.12283252f, 0.08937258f, 0.00129842f, -0.29052022f, 
    0.04305505f, 0.06083406f, -0.09388728f, 0.03277890f, 0.05156988f, 0.01549813f, 0.01911462f, -0.17652547f, 
    -0.14933003f, 0.26002216f, -0.05895126f, -0.02363927f, -0.11202589f, 0.00413048f, -0.04909329f, 0.00934078f, 
    0.10365643f, -0.03490046f, 0.02642544f, 0.01535596f, 0.01225338f, 0.04949763f, 0.08581073f, -0.07498325f, 
    -0.10276297f, -0.07414860f, 0.01466230f, 0.08418435f, -0.13355200f, 0.07169113f, -0.24997979f, 0.02787334f, 
    -0.00747998f, -0.00494815f, 0.14825690f, 0.05862378f, -0.19204801f, 0.22135675f, 0.16924220f, 0.15724696f, 
    0.04825887f, 0.08966101f, -0.16414763f, 0.07149678f, 0.26638103f, 0.22846711f, 0.10553990f, -0.12914269f, 
    -0.06365255f, 0.15438111f, 0.12566099f, -0.02889455f, 0.00356630f, -0.02407406f, -0.13628680f, 0.02180910f, 
    -0.39299759f, 0.05080467f, -0.04624472f, 0.09286539f, 0.09229749f, 0.02836853f, -0.23748150f, -0.04159218f, 
    0.15080962f, 0.18862842f, 0.10734839f, 0.36728454f, -0.35294530f, -0.06557019f, 0.32657963f, 0.03124539f, 
    0.25772893f, -0.09344231f, 0.09046873f, 0.11512147f, 0.19535263f, 0.10155051f, -0.06419602f, -0.10737538f, 
    -0.02080786f, 0.00923523f, -0.22842291f, 0.05679629f, -0.16123471f, -0.22553009f, -0.13592805f, 0.13603444f, 
    -0.03865554f, -0.00543102f, 0.13838862f, -0.03347314f, 0.20020834f, -0.04236462f, 0.34334657f, 0.07605511f, 
    -0.06757094f, -0.10497747f, -0.20833202f, 0.12537558f, -0.05095055f, 0.01282075f, 0.05981835f, -0.05274185f, 
    0.00393274f, 0.22277096f, 0.11610050f, 0.13087687f, -0.13085745f, -0.01030173f, -0.06852989f, 0.00734923f, 
    -0.13874073f, 0.12740235f, 0.05904245f, 0.03462812f, -0.00907959f, 0.30595666f, 0.09333780f, -0.08271219f, 
    -0.40836307f, -0.00533673f, 0.07334237f, 0.01930084f, 0.18531464f, 0.10602513f, -0.03669412f, 0.20022301f, 
    0.05845335f, 0.11562979f, -0.17237195f, 0.07238775f, 0.02157379f, -0.07204050f, -0.20392454f, -0.02615584f, 
    0.23309480f, -0.12169721f, -0.10282289f, -0.02439624f, -0.00102289f, -0.19252405f, 0.29593587f, -0.22581226f, 
    -0.00892964f, -0.22066437f, 0.10429411f, 0.13287801f, -0.17126831f, 0.20320566f, 0.06234812f, -0.11140621f, 
    0.06440639f, -0.08020633f, -0.06287299f, 0.11081216f, -0.03055647f, 0.03500440f, -0.02210199f, -0.10817818f, 
    0.02126605f, 0.15771049f, 0.01671534f, 0.16797471f, 0.16392526f, 0.02880886f, -0.16490090f, -0.06049558f, 
    0.04572038f, 0.03799334f, 0.23901384f, 0.21006997f, -0.00680761f, -0.05891502f, -0.06201334f, -0.03406216f, 
    0.04703406f, 0.10478186f, -0.06018703f, -0.09226387f, 0.16578031f, -0.10199813f, 0.00825353f, 0.03229159f, 
    0.09374610f, -0.06305079f, -0.01946167f, -0.01552056f, 0.11167346f, -0.21118252f, 0.21758494f, -0.00513623f, 
    0.01571000f, -0.01968352f, 0.06877831f, 0.04406094f, -0.04054526f, 0.02849334f, 0.03497184f, -0.07340471f, 
    -0.00245114f, -0.04037562f, 0.02731572f, 0.05527179f, -0.04744235f, 0.17072803f, -0.17111957f, 0.10437105f, 
    0.06524550f, -0.13398634f, -0.04098277f, 0.01984144f, -0.01974656f, -0.11430992f, 0.09598462f, 0.22484773f, 
    0.03813117f, -0.06609831f, -0.33672068f, -0.01981580f, -0.07619954f, -0.01946133f, -0.14559822f, 0.02017077f, 
    0.22522707f, 0.04684013f, -0.15503116f, 0.11575696f, -0.18152925f, 0.00311302f, 0.30493248f, -0.23161697f, 
    0.04118672f, -0.29982707f, -0.11086892f, 0.01554095f, -0.03021102f, -0.13618889f, -0.09179530f, 0.02936868f, 
    0.17224737f, -0.20052403f, 0.07772905f, -0.13567646f, 0.04366476f, 0.17907780f, -0.13176872f, 0.12628774f, 
    -0.06163979f, 0.14688329f, 0.01667775f, 0.38372830f, 0.08613688f, 0.12782352f, 0.02121602f, -0.09782097f, 
    -0.05621548f, -0.13392110f, 0.06203278f, -0.00959262f, -0.08099133f, 0.14438809f, 0.00350909f, 0.15111654f, 
    0.02162257f, 0.02649009f, 0.18064488f, -0.02658016f, -0.04911612f, 0.01562468f, -0.00742454f, -0.05334794f, 
    -0.04126758f, -0.04221627f, 0.08575993f, -0.05225406f, 0.00448583f, 0.04866006f, -0.12894174f, 0.12408844f, 
    -0.19028963f, 0.01248093f, -0.10431695f, 0.13589609f, -0.17123444f, -0.11867486f, 0.10198013f, -0.18374173f, 
    0.05247128f, 0.11012074f, -0.16439676f, 0.10758656f, -0.21580918f, -0.08375260f, -0.08327086f, -0.01505856f, 
    -0.12608640f, 0.20340607f, 0.11256529f, -0.07642145f, -0.10626933f, -0.07037163f, 0.19326593f, 0.04868476f, 
    -0.04022791f, -0.11534123f, -0.08484475f, -0.12220139f, 0.12954794f, -0.16311230f, 0.11117264f, 0.04338297f, 
    -0.01095989f, -0.02279653f, -0.07726806f, 0.06974589f, -0.06919778f, -0.00683987f, -0.07714545f, -0.00388401f, 
    -0.28386861f, 0.06643339f, 0.06430857f, -0.07584290f, -0.17895110f, 0.37402588f, 0.19189189f, 0.00610875f, 
    0.01378144f, -0.05372475f, 0.13468868f, -0.05411868f, 0.02456798f, -0.16511473f, -0.05369841f, -0.15983330f, 
    -0.16824391f, 0.00059165f, 0.04594283f, 0.04378849f, -0.01083983f, -0.03010984f, 0.19087663f, 0.04951334f, 
    -0.09221912f, 0.05956762f, 0.03770734f, -0.13435747f, 0.09799016f, 0.15634111f, 0.05533084f, -0.03469630f, 
    0.10082447f, 0.23663038f, -0.06849270f, 0.05915620f, -0.01712023f, -0.07040221f, 0.01743093f, 0.07459138f, 
    0.03533285f, -0.21911262f, 0.05555850f, 0.10385635f, 0.21152765f, -0.08643647f, 0.02418625f, -0.01054326f, 
    -0.17939946f, 0.00830481f, 0.02449308f, -0.13255392f, 0.02547874f, -0.17761917f, 0.14441667f, -0.01656958f, 
    0.00279364f, 0.29239026f, -0.02105003f, -0.24717323f, 0.21396251f, 0.08036021f, 0.08458974f, -0.04001589f, 
    -0.01157631f, -0.02423489f, 0.20709164f, -0.09488001f, 0.05709662f, 0.14027305f, 0.19709396f, -0.04100284f, 
    -0.00381423f, 0.02877838f, 0.04164187f, 0.20918301f, -0.14775623f, 0.19405837f, -0.04340763f, 0.06947817f, 
    -0.18824732f, -0.01610498f, 0.09917520f, 0.08353157f, -0.33582035f, 0.05358646f, -0.12511213f, -0.02028292f, 
    -0.12498339f, -0.03409239f, -0.14440461f, 0.23033625f, 0.11740255f, 0.25475922f, -0.13080415f, 0.16397507f, 
    -0.05508721f, 0.08109616f, 0.00553804f, -0.17418361f, -0.05633774f, 0.06699942f, -0.20342895f, -0.21810524f, 
    0.30416197f, 0.06785218f, -0.02114750f, 0.08138096f, -0.08701219f, 0.06962659f, -0.14596151f, 0.29330501f, 
    -0.02412963f, -0.22477213f, -0.12184950f, 0.03087825f, -0.04011548f, 0.01046872f, 0.09060928f, 0.05847520f, 
    0.00230148f, -0.01372430f, 0.03241230f, -0.03975419f, 0.01810907f, -0.01066980f, 0.00823089f, 0.01331642f, 
    0.04980176f, 0.00934157f, 0.04582354f, -0.01039975f, -0.00314002f, -0.06395207f, 0.02383131f, 0.04807249f, 
    -0.06260701f, -0.02157123f, -0.04458815f, -0.02341468f, -0.03145718f, 0.02622363f, 0.02298918f, 0.05199377f, 
    -0.00920910f, -0.04930197f, -0.06474756f, 0.00028811f, -0.04735996f, 0.02987703f, 0.04113085f, -0.04084485f, 
    0.03321510f, 0.00017580f, 0.00961914f, 0.00595605f, 0.00848165f, -0.03638357f, 0.01839454f, 0.01374150f, 
    -0.02733969f, 0.03916939f, -0.00917061f, -0.00286944f, -0.04356619f, -0.04499244f, -0.05501622f, -0.07083024f, 
    0.00421154f, 0.03319669f, -0.02384196f, -0.01605157f, -0.06304314f, -0.05828194f, -0.04446026f, 0.03828932f, 
    0.04093426f, 0.04088150f, -0.05608341f, -0.00044550f, -0.05726786f, 0.04293625f, 0.02030855f, -0.03469726f, 
    -0.05128305f, -0.05288152f, 0.00162060f, -0.04020698f, 0.02080718f, -0.05193255f, -0.03335613f, -0.03654001f, 
    -0.00135350f, -0.04520596f, -0.03268905f, 0.03403980f, -0.04237145f, -0.05125020f, 0.03932618f, 0.02135729f, 
    0.03552966f, -0.07081706f, -0.03364521f, 0.02973617f, -0.01390226f, -0.00284354f, -0.06385956f, 0.01442889f, 
    -0.00140428f, 0.00568382f, 0.00402530f, 0.01318751f, 0.04532964f, -0.04764386f, -0.02734257f, -0.01967639f, 
    -0.01667401f, 0.01458035f, 0.02839422f, 0.03888407f, -0.06195609f, -0.00361576f, -0.02358894f, 0.02624754f, 
    -0.01863116f, -0.05487947f, -0.04282936f, -0.00142344f, -0.04486136f, -0.06220407f, -0.01347648f, -0.00732472f, 
    -0.01471147f, -0.01491896f, -0.06412602f, 0.04722195f, 0.01786636f, -0.00102131f, -0.05442836f, -0.01067684f, 
    0.03124858f, -0.01315885f, -0.03840297f, 0.03173584f, -0.05363456f, 0.03153589f, 0.01575282f, -0.00720107f, 
    -0.06509663f, -0.03725542f, 0.01954714f, -0.00659811f, -0.03888276f, 0.02915124f, 0.00588008f, -0.04142738f, 
    0.00941012f, -0.00084878f, 0.03401466f, -0.06005054f, 0.04384417f, 0.00886816f, -0.05765720f, -0.00430815f, 
    0.02907577f, -0.02931380f, 0.00210513f, 0.01069161f, 0.05493329f, -0.05741199f, -0.00406939f, -0.05712659f, 
    -0.00306757f, -0.00470293f, 0.01357906f, -0.04418213f, -0.02193223f, 0.02217017f, -0.01516597f, -0.04461712f, 
    -0.01231813f, -0.00995984f, -0.01127393f, -0.04433487f, -0.04927614f, 0.00600102f, 0.04509772f, 0.00985194f, 
    -0.00397730f, -0.00116517f, -0.00751713f, -0.01150032f, -0.02417354f, -0.05152687f, -0.03780034f, 0.00493298f, 
    -0.06871532f, -0.04430722f, -0.00949582f, -0.05687743f, -0.05887634f, -0.06152313f, -0.04857235f, 0.03235766f, 
    0.04411393f, -0.04733569f, -0.06745028f, -0.02343509f, -0.03949948f, -0.04706997f, 0.00312994f, -0.01723847f, 
    0.03437166f, 0.00536049f, 0.04660277f, -0.01981829f, -0.00050622f, 0.02387680f, -0.00674630f, 0.00643406f, 
    0.03278205f, -0.04873103f, 0.01561545f, 0.01250038f, 0.01774877f, -0.06101964f, 0.01334767f, 0.01058493f, 
    -0.06132281f, 0.04261282f, -0.01981503f, 0.02498011f, 0.02193681f, -0.05558581f, -0.02512472f, 0.01888790f, 
    -0.01360706f, 0.02200060f, -0.03953433f, 0.02294727f, 0.04901906f, 0.04447593f, 0.01728555f, -0.04728895f, 
    -0.00908996f, 0.01447819f, -0.06135672f, 0.00790109f, 0.00994089f, 0.00630066f, -0.05604732f, -0.04649862f, 
    -0.04770193f, -0.03904298f, 0.04208879f, -0.04832756f, 0.03359881f, 0.04622912f, -0.02609778f, 0.02113869f, 
    -0.06433524f, -0.00169617f, 0.00259246f, 0.01108759f, -0.06220600f, 0.01635515f, 0.00229099f, -0.02541396f, 
    0.02143950f, -0.06797560f, 0.03395364f, -0.03443693f, -0.01293796f, 0.02534845f, 0.04189918f, 0.00226076f, 
    -0.02186239f, -0.00836721f, 0.04005227f, 0.03139482f, -0.01120658f, 0.03169893f, -0.02647963f, 0.04498552f, 
    -0.00562055f, 0.01459489f, 0.04144546f, 0.01838401f, -0.01529753f, -0.06301186f, 0.03204956f, 0.00395117f, 
    0.01870938f, -0.05363785f, -0.03969774f, 0.00575861f, 0.03132237f, -0.00090821f, 0.03539982f, 0.04873640f, 
    0.00945147f, 0.04273308f, -0.01592324f, 0.00191744f, -0.03448796f, -0.01610699f, 0.01250244f, 0.05212367f, 
    -0.25118110f, -0.11697754f, -0.02298340f, -0.05564292f, 0.17787072f, 0.14295644f, 0.07412268f, -0.14060919f, 
    -0.04507173f, 0.39167053f, 0.12754467f, 0.05630805f, -0.16349865f, -0.24324141f, -0.10591903f, -0.00103062f, 
    -0.01783575f, 0.05842931f, -0.03908481f, -0.14986220f, -0.13396707f, 0.03031875f, 0.04170230f, 0.08500951f, 
    -0.26816446f, -0.03391544f, -0.17231698f, 0.09132861f, 0.07067569f, -0.35465708f, 0.02697236f, 0.07323255f, 
    0.11755479f, -0.02190877f, 0.03996515f, -0.05042243f, -0.03719240f, 0.12094624f, 0.04845520f, -0.05260134f, 
    -0.03872122f, -0.27976254f, -0.06104251f, -0.02270089f, 0.04932034f, 0.06638318f, 0.06715242f, -0.00565852f, 
    -0.06409012f, 0.00280175f, 0.01038553f, 0.11443678f, -0.07373662f, 0.11718507f, -0.13191593f, -0.03651610f, 
    0.24302946f, -0.08945727f, -0.03127691f, -0.04176529f, 0.13525419f, -0.02378329f, 0.09974980f, 0.24692801f, 
    0.16076617f, 0.08971134f, 0.04553221f, 0.04827759f, -0.15108575f, 0.26936442f, -0.07198942f, -0.00301090f, 
    -0.03608282f, 0.09175695f, 0.05853041f, -0.00509689f, 0.05241157f, 0.09673684f, -0.01179370f, -0.13794121f, 
    0.01117873f, 0.05738046f, -0.17584735f, 0.00980029f, -0.12493952f, 0.10384679f, 0.02166044f, 0.03348653f, 
    -0.00518978f, -0.08690709f, -0.05445962f, 0.04206757f, 0.07146161f, 0.12175906f, -0.05990887f, 0.03787519f, 
    0.15961935f, 0.00152449f, 0.00141600f, 0.26411507f, -0.19006768f, -0.12403602f, -0.00109242f, -0.00115039f, 
    0.16882141f, -0.19233026f, 0.02444213f, 0.02572346f, -0.21516405f, -0.10343406f, -0.08491428f, -0.01247489f, 
    -0.00065569f, 0.06128095f, -0.00746289f, -0.00047211f, -0.12668025f, 0.23554273f, -0.12545277f, -0.02568090f, 
    -0.00816530f, -0.06085897f, 0.07281777f, 0.02545681f, 0.02007322f, -0.02916439f, -0.34289944f, -0.06648746f, 
    0.01129927f, -0.00839880f, 0.00521377f, 0.07305050f, 0.00782661f, -0.11862066f, -0.00459929f, 0.01705470f, 
    0.11319489f, -0.06522002f, -0.00089526f, -0.05104601f, 0.02742111f, -0.09551123f, -0.09584977f, -0.10306266f, 
    -0.01795718f, 0.04288927f, 0.13803916f, -0.07570264f, -0.11219570f, 0.06240401f, -0.12950017f, -0.08294872f, 
    0.03909799f, -0.11393019f, 0.14874597f, -0.28196749f, -0.01374087f, 0.00749763f, 0.16096234f, 0.21198446f, 
    -0.11393267f, 0.15957555f, 0.15168129f, -0.09733140f, 0.22692390f, 0.01050825f, 0.07720678f, 0.12330020f, 
    0.08335742f, -0.17444460f, -0.11989185f, -0.22162807f, 0.02737910f, 0.14846133f, -0.09922811f, -0.11224114f, 
    -0.06059071f, -0.07399760f, 0.14796126f, 0.04870937f, -0.22745067f, -0.39458406f, -0.09206209f, 0.07617991f, 
    0.20892684f, 0.03919901f, -0.09538146f, -0.04611219f, -0.02462963f, -0.12973814f, 0.37749144f, -0.12179349f, 
    -0.04470259f, 0.12619253f, 0.01681210f, 0.13477966f, -0.05264260f, 0.11674571f, -0.01063955f, 0.09524511f, 
    0.04166738f, 0.02848432f, -0.02399228f, -0.03198978f, -0.03481315f, 0.17282675f, 0.16729723f, -0.07167426f, 
    -0.05365619f, -0.09751458f, 0.12128530f, 0.05657797f, 0.08981395f, 0.00689923f, 0.00752942f, 0.02305414f, 
    0.11623853f, -0.01864868f, 0.17277217f, -0.04547752f, 0.01390445f, -0.04148382f, 0.06206969f, -0.08400588f, 
    0.02074342f, -0.19463605f, -0.22937910f, 0.00650476f, 0.00641408f, 0.16136239f, 0.12939760f, -0.16528702f, 
    0.02188767f, 0.04196166f, -0.14692812f, 0.02587522f, 0.05189681f, -0.05648614f, 0.18208101f, -0.02912855f, 
    0.11152279f, 0.02805340f, -0.02491537f, 0.14807709f, 0.02657581f, -0.10264814f, -0.09695893f, -0.07450731f, 
    -0.04279891f, 0.06565346f, 0.19187012f, 0.07080282f, 0.13170798f, -0.20275129f, -0.22821844f, 0.11452451f, 
    0.10683849f, 0.02467413f, -0.09377184f, -0.03968882f, -0.09148420f, 0.15526506f, -0.04676945f, 0.04406964f, 
    -0.11509478f, -0.00465324f, -0.03756483f, -0.01133409f, -0.08477802f, -0.21650018f, 0.02864873f, 0.03386262f, 
    0.03343336f, 0.03349836f, 0.04101075f, 0.00225240f, 0.03346886f, 0.10695785f, -0.06527396f, 0.27559280f, 
    -0.21420622f, -0.08128799f, -0.11227418f, -0.04237251f, 0.08174311f, -0.00883562f, -0.09290322f, 0.10992540f, 
    -0.04241298f, 0.01080690f, -0.03705615f, -0.04000214f, -0.05853342f, -0.02051591f, 0.00730773f, -0.03781243f, 
    -0.02276684f, -0.02810594f, 0.04521078f, -0.00082037f, 0.00137863f, -0.00082224f, 0.04378770f, -0.05060150f, 
    0.03879702f, -0.05019746f, 0.02188535f, 0.04613616f, 0.03807841f, 0.01558493f, -0.05047653f, -0.01381385f, 
    -0.00279255f, -0.05539766f, 0.03100584f, -0.01417448f, 0.03013767f, 0.04165134f, -0.05811964f, -0.00029207f, 
    -0.00234706f, -0.04908560f, -0.01128603f, -0.02195919f, -0.02391088f, -0.02259928f, -0.03794826f, -0.05360404f, 
    -0.04699627f, -0.04441682f, -0.03176852f, 0.03159738f, -0.02982780f, 0.00305146f, 0.00152187f, -0.00570670f, 
    -0.04777981f, 0.03615104f, -0.05353700f, -0.05320963f, -0.05574133f, 0.04372492f, -0.00950596f, 0.00452715f, 
    0.01938234f, -0.00559930f, -0.05586943f, 0.04823138f, 0.03759473f, 0.05346749f, 0.05533884f, -0.02656368f, 
    -0.05376282f, -0.05247872f, -0.02057927f, -0.02793449f, 0.04596617f, -0.04162930f, -0.00515936f, 0.05727807f, 
    0.04054418f, -0.03253135f, 0.03972385f, 0.03796967f, 0.05507560f, 0.04223383f, -0.03402606f, 0.02618966f, 
    -0.05140948f, 0.02254563f, 0.03679565f, 0.03774742f, -0.03341496f, -0.04441172f, 0.04741324f, 0.01410394f, 
    0.00383925f, -0.02100718f, 0.01181412f, -0.01300621f, 0.05882721f, 0.02983981f, -0.00235574f, 0.05210013f, 
    -0.05720470f, -0.02181647f, 0.05781761f, 0.00933036f, -0.03807078f, -0.03843009f, -0.02473447f, -0.05769433f, 
    -0.04232690f, 0.02330421f, 0.04797691f, -0.02458243f, -0.00757892f, -0.03637107f, -0.00532926f, -0.02690120f, 
    -0.00755984f, -0.04911136f, -0.01085990f, -0.05471186f, 0.01072032f, -0.03554580f, -0.03943475f, 0.04344905f, 
    -0.02169310f, 0.05454987f, 0.05420015f, -0.01771585f, 0.02455638f, -0.05819197f, -0.02674947f, -0.02990183f, 
    -0.00420139f, -0.02361364f, -0.05038525f, -0.02209713f, -0.01535270f, -0.04390956f, -0.05061013f, -0.02494406f, 
    0.04572415f, 0.02485948f, 0.01901808f, -0.00605712f, -0.00910452f, -0.02327591f, 0.01230440f, 0.02321115f, 
    0.04375708f, -0.02771581f, -0.04927939f, 0.05619545f, 0.04420446f, -0.05751455f, 0.02677190f, -0.04999305f, 
    0.01842282f, -0.03468378f, 0.00281641f, -0.00350137f, 0.01564400f, 0.02395696f, 0.04525634f, -0.01622953f, 
    -0.02840464f, 0.02252377f, 0.04765398f, -0.04999993f, 0.02391466f, -0.01257456f, -0.05135050f, -0.00560064f, 
    0.02179989f, 0.04560072f, 0.04391073f, -0.01523498f, -0.05166830f, 0.04357218f, -0.02398412f, -0.03299155f, 
    0.04821678f, -0.02403458f, -0.04172156f, 0.04821439f, 0.00565861f, -0.03029716f, -0.02595452f, -0.04893526f, 
    0.01546204f, -0.05673229f, -0.00747649f, -0.05609651f, -0.02644367f, 0.04516925f, 0.03939231f, -0.02572497f, 
    -0.04219610f, -0.00125355f, -0.02827129f, 0.02315641f, -0.03563930f, -0.03164260f, 0.04501311f, 0.01059022f, 
    -0.00332636f, 0.02703806f, 0.01280072f, -0.04351293f, 0.01235887f, -0.04396268f, -0.02228235f, 0.02370011f, 
    0.01803886f, -0.02272884f, 0.01937249f, -0.02393001f, 0.00368824f, 0.02017556f, 0.01096017f, 0.00145838f, 
    -0.04327071f, -0.00551226f, 0.01595642f, -0.02425636f, 0.01683309f, 0.04493063f, 0.00204449f, -0.04699102f, 
    -0.04313939f, -0.03886275f, -0.03152436f, 0.01517700f, -0.00890399f, 0.02939834f, -0.05452101f, -0.03980412f, 
    -0.03711373f, 0.02355280f, -0.01414288f, 0.01053837f, -0.00516467f, -0.05612622f, -0.03719456f, -0.03570499f, 
    -0.03404277f, -0.02084720f, 0.05075202f, 0.00377802f, 0.05334574f, 0.02673576f, -0.02048404f, -0.00771687f, 
    -0.03193133f, 0.03023224f, 0.04841868f, -0.03984344f, 0.02908321f, -0.00396864f, 0.00784085f, -0.02528127f, 
    -0.01136896f, -0.03843278f, 0.03492064f, -0.00436270f, 0.00357476f, 0.02267970f, -0.02289575f, 0.02830553f, 
    0.01904690f, 0.01972742f, -0.01320203f, -0.04456805f, 0.00187511f, -0.02277104f, -0.00134926f, 0.03402293f, 
    -0.04515756f, 0.03951529f, -0.04707304f, 0.04676714f, -0.02122637f, 0.05873334f, 0.01835332f, -0.05287695f, 
    -0.04732984f, 0.01869261f, -0.04538789f, -0.01459481f, -0.04760976f, -0.05128818f, -0.05452371f, -0.01091658f, 
    0.00682939f, -0.02544079f, 0.05451537f, 0.14242880f, -0.00599696f, -0.11827161f, 0.13360679f, -0.02077308f, 
    -0.05952185f, 0.26640129f, 0.31714538f, 0.19159485f, 0.02378334f, -0.23303881f, -0.37012324f, 0.18856336f, 
    0.18610364f, 0.09788585f, 0.07283241f, -0.29588985f, 0.33023417f, -0.02177137f, 0.24382865f, 0.14982152f, 
    -0.03337786f, -0.03178542f, -0.23588753f, 0.34789947f, -0.33464465f, 0.07291546f, 0.05530166f, -0.06388717f, 
    -0.09924319f, 0.07283900f, -0.04503100f, 0.04412690f, 0.14247029f, 0.05514744f, -0.02485402f, 0.06164262f, 
    -0.14172049f, -0.05913833f, -0.00792868f, -0.03375206f, 0.17509028f, -0.03065573f, 0.17880230f, -0.14150643f, 
    -0.00613240f, -0.15329336f, -0.18931796f, -0.12047889f, 0.05224902f, -0.02088152f, -0.08422628f, 0.02717115f, 
    -0.36496148f, 0.15990344f, -0.03261052f, 0.12484333f, -0.07160115f, -0.12872466f, -0.02343115f, 0.14586870f, 
    0.08567246f, -0.15486194f, -0.07302524f, -0.07894970f, 0.06735032f, 0.02584955f, 0.01456399f, -0.22772759f, 
    0.07734365f, 0.16490221f, 0.06562342f, 0.14482805f, 0.02693301f, 0.05219898f, -0.01695941f, 0.13507009f, 
    0.17035674f, 0.13828853f, 0.10432252f, 0.07719667f, 0.10000778f, 0.15147123f, -0.02305689f, 0.12548167f, 
    -0.06253630f, 0.11817310f, -0.00773325f, 0.07496427f, 0.05501853f, 0.03618237f, 0.09144885f, -0.03520518f, 
    0.02513515f, -0.08291651f, 0.07035217f, 0.25277805f, -0.18950462f, -0.14656547f, -0.03773278f, 0.14113544f, 
    0.01770110f, -0.05324417f, -0.15206860f, -0.15387501f, -0.19635293f, -0.07093542f, -0.15771331f, -0.07782009f, 
    0.08958360f, -0.10004969f, 0.08807927f, -0.08913500f, 0.12909029f, 0.26950333f, -0.27974930f, 0.05044720f, 
    0.19775355f, 0.01644337f, -0.02755268f, 0.05276348f, -0.17118044f, -0.01637057f, -0.10023215f, -0.14179555f, 
    -0.06522639f, -0.05437531f, 0.03736515f, -0.21478473f, 0.17718357f, 0.01640824f, -0.02963608f, -0.03811309f, 
    -0.12169757f, 0.09714571f, -0.04077126f, -0.05877203f, -0.12991542f, -0.04426405f, -0.07473426f, 0.10121454f, 
    -0.02864766f, -0.22025239f, 0.00416945f, 0.05429045f, -0.06540149f, 0.02114244f, 0.04115015f, 0.01357445f, 
    0.02795890f, -0.14163889f, -0.13991959f, -0.17332858f, 0.20650582f, 0.00825512f, -0.09277602f, 0.12150376f, 
    -0.30042636f, 0.07352156f, -0.16588050f, -0.08484510f, 0.07892009f, 0.27844352f, 0.00936201f, 0.01837913f, 
    -0.01836586f, 0.11011468f, -0.05949705f, 0.10997157f, 0.10312914f, -0.18225244f, -0.22812323f, -0.05088275f, 
    0.13653518f, 0.17282258f, 0.08285215f, 0.05419284f, -0.13629596f, -0.04988599f, 0.02536608f, 0.13534941f, 
    0.05209808f, 0.02722091f, 0.11056366f, -0.14697441f, -0.00445262f, -0.26813585f, 0.04309579f, -0.06980485f, 
    0.01313046f, -0.01532878f, -0.19428119f, 0.13505946f, 0.04899802f, 0.08172730f, -0.05888736f, 0.07012628f, 
    -0.10522811f, 0.00560763f, 0.13430268f, -0.02725630f, 0.00081621f, 0.05733446f, -0.05320330f, 0.07112975f, 
    -0.09074739f, -0.12880249f, 0.09229486f, 0.00040136f, -0.07428733f, 0.13849977f, -0.14676015f, -0.12077165f, 
    0.08657113f, -0.12871540f, 0.02437537f, 0.08309565f, -0.04226547f, 0.03990261f, 0.10559368f, -0.17814437f, 
    0.12946661f, -0.14526920f, 0.14946032f, -0.00420927f, 0.04953083f, -0.13022830f, -0.11601338f, 0.20186941f, 
    -0.05179599f, -0.19422354f, -0.02535168f, 0.13938229f, -0.16240409f, -0.25523970f, -0.03425543f, -0.01832734f, 
    -0.01435813f, 0.13015945f, -0.23052247f, -0.09162833f, 0.14646019f, -0.02692742f, 0.03794937f, -0.21546312f, 
    0.04498422f, -0.00951472f, 0.17079884f, -0.05912803f, -0.14439590f, -0.15070120f, 0.08324174f, 0.03911590f, 
    0.11184382f, -0.05115580f, 0.20796715f, -0.25332752f, 0.07798334f, -0.05677852f, 0.29251188f, -0.18392514f, 
    0.00710295f, -0.02921106f, 0.28498474f, 0.10029124f, -0.01224693f, -0.12930354f, -0.05121182f, 0.09623890f, 
    -0.03921455f, -0.13153975f, -0.09101218f, 0.14563680f, 0.16627236f, -0.13062133f, -0.22277021f, 0.14924026f, 
    -0.09433711f, 0.18029794f, -0.07927325f, -0.22628698f, 0.23116836f, -0.02762705f, 0.14335540f, -0.04726193f, 
    -0.05681676f, 0.03074599f, 0.04843900f, 0.04885994f, -0.01165191f, 0.02059788f, -0.06391234f, -0.03047340f, 
    0.04212805f, 0.04794063f, -0.05123771f, -0.04281662f, 0.02217678f, 0.01564560f, -0.00904458f, 0.02801345f, 
    -0.00987768f, -0.04387152f, 0.02557760f, -0.01558387f, 0.02421472f, -0.04949607f, 0.04363174f, -0.06660967f, 
    0.03866882f, -0.05054989f, -0.04947374f, -0.01425786f, -0.02079147f, -0.00353094f, 0.02832248f, -0.05502679f, 
    0.04649688f, -0.01891069f, -0.02654356f, 0.04071748f, -0.03967390f, 0.04509949f, -0.05027912f, -0.00675291f, 
    0.02830431f, -0.00162010f, 0.00371831f, -0.05546837f, -0.03279010f, -0.03245017f, -0.01882670f, 0.03645216f, 
    -0.04705670f, 0.04399279f, 0.02406094f, 0.00928290f, -0.04141689f, -0.04548332f, 0.03251509f, 0.01698677f, 
    0.03533712f, 0.04670265f, -0.04047345f, -0.05390747f, 0.01415242f, 0.04887039f, 0.02164692f, 0.03567782f, 
    -0.05393034f, 0.03215664f, 0.01395883f, 0.04558529f, 0.03205374f, 0.04012281f, 0.02954215f, 0.00638454f, 
    0.00318858f, -0.06523918f, 0.03234827f, 0.01979343f, -0.03761933f, -0.05315366f, -0.04824467f, -0.00161004f, 
    -0.05339052f, -0.01451117f, 0.01825084f, -0.05117542f, -0.06374995f, -0.04851955f, -0.06137070f, 0.00792307f, 
    -0.04592831f, -0.05539852f, 0.01005650f, 0.04994990f, -0.04810101f, -0.03221011f, 0.03715055f, 0.02170716f, 
    0.04695389f, -0.01347821f, 0.04321586f, -0.02552574f, -0.05461580f, -0.01327963f, -0.01262698f, -0.01013432f, 
    -0.05572395f, 0.04406969f, 0.00225658f, 0.04104946f, -0.06051539f, 0.01388874f, 0.00818287f, -0.03439836f, 
    0.00531693f, -0.05987776f, -0.04324162f, -0.06274040f, 0.00217783f, -0.01536294f, -0.06276745f, -0.03016189f, 
    0.00777986f, 0.02002937f, 0.03897184f, 0.04896217f, 0.02525015f, 0.02687678f, -0.01740745f, 0.00160405f, 
    -0.00129155f, -0.00048978f, 0.01480339f, -0.05400781f, 0.02952645f, -0.04928356f, -0.00963435f, 0.00666975f, 
    -0.04464822f, -0.03208438f, 0.03741587f, 0.03465744f, -0.03716633f, -0.03137750f, 0.00568771f, 0.03105362f, 
    0.01959847f, 0.04814856f, 0.03533057f, -0.03657841f, -0.04415116f, -0.03271651f, -0.00079257f, 0.03567982f, 
    -0.04485189f, -0.00381141f, 0.03154695f, 0.04236643f, -0.00142536f, 0.03243897f, -0.05359368f, -0.02221032f, 
    0.01973485f, 0.02506507f, -0.03845716f, 0.04817885f, 0.01667587f, 0.01007685f, -0.00046440f, -0.03285066f, 
    0.01716773f, -0.02099524f, -0.03169543f, 0.00700272f, 0.00722714f, 0.04930199f, -0.00149729f, -0.04803666f, 
    -0.02799100f, -0.05435392f, -0.00494645f, 0.00213667f, 0.00716416f, 0.00452997f, -0.00565152f, 0.04387198f, 
    -0.03351422f, -0.01287628f, 0.02314108f, 0.02964245f, -0.00877474f, -0.00340853f, -0.01115574f, 0.03016647f, 
    -0.04921097f, 0.04735052f, -0.01323535f, 0.04243677f, -0.00735053f, -0.02455791f, 0.00476817f, 0.01143594f, 
    0.03050992f, -0.03317819f, 0.01311175f, 0.02866907f, 0.01145295f, -0.00574429f, -0.03219131f, -0.04937353f, 
    -0.02789767f, -0.04354150f, 0.02343727f, 0.02859624f, 0.02006754f, 0.01830568f, -0.03358165f, -0.06105201f, 
    -0.00689516f, -0.06087149f, -0.00098542f, -0.02902255f, -0.04555365f, -0.03032946f, -0.01579428f, 0.04667062f, 
    0.00269640f, -0.03708840f, -0.02325273f, -0.06484812f, 0.04047070f, 0.01031962f, -0.03486207f, 0.03083733f, 
    -0.06494655f, -0.05979453f, -0.04511890f, -0.00564209f, -0.02506023f, 0.00938099f, 0.03444717f, 0.04621037f, 
    -0.01307299f, -0.00865462f, -0.04674985f, -0.05453768f, -0.05897740f, -0.01163655f, -0.06341761f, -0.04684687f, 
    -0.01592517f, 0.02044050f, 0.01485223f, -0.00655924f, -0.04330749f, 0.01977453f, -0.04042297f, -0.06098218f, 
    -0.01102932f, -0.00740391f, -0.06300949f, -0.03474240f, -0.01706588f, 0.03829210f, -0.03260462f, -0.04713935f, 
    -0.04963407f, -0.06040269f, -0.05237353f, -0.06386909f, -0.01083789f, -0.02882429f, -0.05553748f, -0.05863820f, 
    0.03886616f, 0.02373073f, -0.04103351f, 0.03135671f, 0.01600622f, -0.00923728f, -0.03299177f, 0.04269904f, 
    -0.05595039f, 0.03599790f, 0.02612783f, 0.03087392f, 0.02623641f, 0.02584873f, -0.04836643f, -0.04812561f, 
    0.04670279f, -0.02175867f, 0.05273405f, -0.03768888f, 0.00241054f, -0.03114751f, 0.04745424f, -0.02751349f, 
    0.05399284f, 0.01659038f, -0.01759358f, -0.05718936f, 0.04301175f, 0.05750067f, -0.00405199f, -0.05733955f, 
    -0.02419693f, 0.02976478f, -0.03358411f, -0.03155125f, -0.00125675f, -0.06018625f, -0.00783297f, 0.01323959f, 
    -0.06581023f, -0.02198820f, 0.01116496f, -0.05826428f, 0.03788815f, -0.00910804f, 0.04299003f, -0.03594492f, 
    0.01283745f, -0.01276131f, 0.04918926f, -0.04273200f, 0.00304104f, -0.06114950f, 0.04964761f, -0.02289535f, 
    -0.00801025f, -0.03692456f, 0.01638330f, 0.00848817f, -0.03111224f, 0.00387642f, -0.00637065f, 0.00721918f, 
    -0.04545645f, -0.04838908f, -0.00034749f, -0.01453537f, -0.00379340f, -0.03002562f, 0.04741536f, -0.01073693f, 
    0.00102711f, -0.04063024f, -0.00683637f, 0.04469081f, -0.04795189f, -0.01056519f, 0.01208220f, -0.00762292f, 
    -0.02042923f, 0.00877412f, -0.04092008f, -0.01247410f, 0.02146016f, -0.04913685f, -0.02490984f, -0.04570612f, 
    0.04276865f, -0.02796422f, -0.02898521f, -0.03008705f, 0.01982430f, 0.02646812f, 0.00658513f, -0.02240210f, 
    0.01466145f, 0.04497739f, -0.03556973f, -0.05181896f, 0.04938258f, -0.02622015f, 0.01721719f, -0.03261660f, 
    -0.03001162f, -0.03766569f, 0.00415602f, -0.03821052f, 0.00748573f, -0.03321157f, 0.01400222f, -0.02363959f, 
    -0.03366944f, -0.00367113f, 0.03532227f, 0.00592677f, -0.05683634f, -0.02313519f, 0.03530218f, -0.06146480f, 
    -0.03602780f, 0.02937710f, -0.01198759f, -0.02935950f, 0.02849721f, -0.02562344f, -0.01688531f, 0.00932621f, 
    -0.06273331f, -0.00392840f, 0.02426066f, 0.02414199f, 0.00552738f, 0.04110028f, 0.02427228f, -0.01444463f, 
    0.03813842f, -0.02734450f, -0.03838579f, -0.06263485f, 0.04942456f, 0.03621226f, 0.03589924f, 0.02009629f, 
    0.01293949f, 0.05151243f, 0.02269158f, -0.05036356f, 0.02508126f, -0.02954192f, 0.00570359f, -0.03056836f, 
    -0.01567261f, -0.03338007f, -0.04800398f, 0.02792443f, -0.05823370f, -0.04250151f, 0.03725511f, -0.04929362f, 
    -0.01551867f, 0.02780155f, -0.01282306f, 0.05062873f, 0.00150802f, -0.02857047f, -0.05187679f, 0.05355368f, 
    -0.04918942f, 0.03329550f, -0.03751043f, 0.03016222f, -0.01644544f, 0.02283598f, 0.00241791f, -0.03711657f, 
    0.02600914f, -0.01131482f, -0.04761204f, -0.04159689f, 0.02390284f, -0.00349215f, -0.05929303f, -0.02543387f, 
    0.00407478f, 0.01005024f, 0.00830782f, 0.00640752f, -0.02270737f, 0.00697937f, 0.01591256f, 0.03799241f, 
    0.01688961f, -0.04892246f, -0.02979371f, -0.04368660f, -0.01751918f, -0.01684045f, -0.01147489f, 0.00734549f, 
    -0.05933704f, -0.02468775f, -0.05934203f, 0.02865608f, 0.02516788f, -0.05629668f, -0.04644185f, -0.04952804f, 
    0.03688545f, -0.00893356f, -0.02808043f, -0.03698569f, -0.06181132f, 0.02543317f, -0.03687075f, 0.05296339f, 
    -0.06369349f, -0.03938743f, 0.03749840f, -0.01350540f, -0.03152026f, -0.02767564f, -0.00342143f, -0.03449000f, 
    -0.02089408f, -0.06524984f, 0.04258609f, 0.02130309f, 0.05161119f, -0.04420569f, -0.03442352f, 0.02880686f, 
    0.00867689f, 0.04726457f, 0.03493103f, -0.06409422f, 0.04206046f, -0.02022557f, -0.00568135f, -0.03645310f, 
    0.01320021f, 0.00084722f, -0.00117970f, -0.03634584f, -0.04910201f, -0.06297704f, -0.04549110f, -0.04014888f, 
    -0.01856835f, -0.01186652f, 0.01435495f, -0.00767713f, -0.00721353f, 0.00309883f, -0.03889336f, 0.02578653f, 
    0.02167841f, -0.04490043f, -0.05192916f, -0.00721045f, -0.03682309f, -0.01406368f, 0.00529385f, 0.01361046f, 
    -0.02637550f, -0.05705241f, 0.01237294f, -0.02558495f, 0.03469250f, 0.00840110f, -0.01970170f, -0.03135088f, 
    -0.04652794f, 0.06491213f, 0.00647317f, -0.00877844f, -0.01830374f, -0.01674532f, 0.00663554f, -0.05270612f, 
    -0.03035759f, 0.02589609f, 0.01398304f, 0.04499450f, -0.05628137f, -0.02058051f, -0.05581349f, -0.03148970f, 
    -0.04487779f, -0.04239785f, 0.02518172f, 0.05060430f, -0.04417067f, -0.00803154f, 0.02228438f, -0.06239700f, 
    -0.05595513f, -0.01857845f, -0.01484436f, -0.03233864f, -0.02819827f, 0.02109575f, 0.00087995f, -0.00643242f, 
    -0.00090869f, -0.05160381f, -0.04269677f, 0.03465057f, -0.02840093f, -0.05048952f, 0.04554084f, -0.02500650f, 
    -0.01584208f, 0.05995821f, -0.02221727f, -0.04880768f, -0.01731172f, -0.03900067f, -0.04898728f, 0.03853745f, 
    0.01062367f, 0.04073553f, 0.01285920f, -0.02391237f, -0.05056646f, 0.02797054f, 0.01980018f, 0.04951019f, 
    0.02217708f, 0.04314908f, -0.00577463f, 0.04223076f, 0.03164920f, 0.04704073f, -0.04758663f, -0.05168222f, 
    0.03386218f, -0.03763497f, 0.02313186f, 0.02334060f, 0.04239477f, 0.01082552f, 0.02623022f, 0.01068399f, 
    -0.02737136f, -0.05055880f, -0.03597288f, -0.04494960f, -0.03420941f, -0.00910104f, 0.03138836f, -0.05717754f, 
    0.02374196f, 0.00432792f, -0.05202047f, -0.01368584f, 0.03628734f, -0.00016720f, 0.04039659f, -0.02329552f, 
    -0.01471070f, 0.04218492f, -0.01459636f, 0.04404787f, -0.01689032f, -0.00311743f, 0.04682888f, 0.01879735f, 
    0.03413623f, -0.05471805f, -0.02103289f, 0.02562114f, 0.01077684f, -0.03925987f, 0.04546968f, 0.01682695f, 
    -0.05993077f, -0.02534614f, -0.03960269f, -0.05303609f, -0.00825588f, 0.01323705f, 0.00855457f, 0.02469647f, 
    0.00912634f, -0.05862565f, -0.05120970f, 0.01504435f, 0.05013463f, -0.01149237f, -0.03853776f, 0.00586218f, 
    0.02911702f, -0.01466906f, -0.00440859f, -0.00990300f, -0.05189221f, -0.00510738f, 0.01418779f, -0.05134101f, 
    -0.00383613f, 0.00377523f, -0.04824058f, -0.04096795f, 0.02723869f, -0.01466650f, 0.01950082f, 0.02732527f, 
    0.02048401f, -0.04792381f, -0.03651532f, -0.04571375f, 0.00200122f, 0.00332238f, 0.01310210f, -0.04344274f, 
    0.01181774f, -0.04904353f, -0.05780546f, 0.05249493f, -0.05429411f, 0.03850043f, 0.03526250f, 0.02294196f, 
    -0.01516634f, 0.02397813f, 0.05171212f, -0.03193806f, 0.01038019f, 0.00586212f, -0.00382649f, 0.01028082f, 
    0.02008491f, -0.03899157f, -0.01033724f, -0.00955765f, 0.03175382f, -0.00975912f, 0.00299768f, 0.00270834f, 
    0.03460202f, 0.02268538f, -0.00764766f, 0.02439607f, 0.01250407f, -0.04658443f, -0.00186779f, -0.00916167f, 
    0.03432607f, 0.03369771f, -0.02845842f, -0.01628191f, 0.05062873f, 0.04960988f, 0.02971368f, -0.03786755f, 
    0.00807100f, -0.04193322f, -0.04744676f, -0.05720703f, 0.00558716f, -0.00613970f, 0.03684313f, 0.00373215f, 
    -0.00133880f, -0.00399603f, 0.01839736f, 0.02602447f, 0.02258462f, -0.02025233f, 0.04565203f, 0.04675042f, 
    0.04597076f, -0.04210264f, 0.00608690f, -0.05825929f, -0.03273679f, 0.01323445f, 0.01236509f, -0.01943855f, 
    -0.03120785f, 0.03273099f, -0.02790081f, -0.02597330f, -0.05163438f, 0.01258620f, -0.04237201f, 0.03519960f, 
    0.02920969f, -0.01344322f, 0.05166870f, -0.02504030f, -0.03471173f, -0.01107380f, -0.01049941f, -0.01476500f, 
    0.00006180f, 0.01079402f, -0.00353855f, 0.02722078f, 0.00663870f, -0.00768030f, -0.02549579f, -0.06548475f, 
    0.04098839f, -0.06578879f, -0.04880919f, -0.01229230f, -0.06690973f, -0.01721996f, -0.06049955f, -0.03292894f, 
    -0.06167759f, -0.02708718f, 0.04745310f, -0.03595706f, -0.05959812f, 0.01391718f, -0.03680218f, 0.04239816f, 
    -0.04964652f, -0.03152629f, 0.05430985f, 0.00874591f, -0.04615739f, 0.01035625f, 0.03891746f, 0.01792664f, 
    0.05196111f, -0.05766178f, 0.03227768f, 0.03584297f, 0.02088830f, -0.05960863f, -0.05730032f, -0.02242552f, 
    0.03184155f, -0.00527643f, 0.00917204f, 0.01973964f, 0.03832816f, -0.01710978f, 0.04282198f, 0.00703673f, 
    -0.04615099f, 0.04099633f, -0.05072732f, 0.01827158f, 0.01105057f, -0.05111530f, -0.04803303f, -0.00744421f, 
    0.01753074f, -0.05729111f, 0.01261113f, -0.02675190f, -0.04874907f, -0.05434920f, -0.02042970f, -0.05109973f, 
    -0.01401506f, 0.01946450f, 0.03031647f, 0.05138505f, -0.05831553f, -0.04196292f, 0.02034041f, -0.03282456f, 
    0.04873367f, 0.03929241f, -0.01553269f, -0.04817055f, -0.00608973f, 0.02301434f, -0.05111113f, -0.02351726f, 
    -0.01118907f, 0.02232288f, -0.04256796f, -0.05352067f, -0.02169292f, -0.01154599f, -0.00747437f, -0.05625846f, 
    -0.01857540f, 0.04446527f, 0.04511343f, -0.05242110f, -0.02943333f, -0.00121736f, -0.03763076f, -0.03036235f, 
    0.12132158f, 0.09973311f, 0.10162085f, -0.10249696f, 0.10566961f, 0.06550411f, 0.08243822f, 0.10068446f, 
    -0.10157961f, 0.10419884f, -0.08707821f, -0.28490621f, 0.17852400f, 0.18145299f, 0.08462709f, -0.00510440f, 
    0.02910280f, -0.16095984f, -0.14760040f, 0.12809445f, -0.23535627f, 0.04412227f, 0.12718736f, -0.15054108f, 
    -0.09023378f, -0.00230997f, 0.16779676f, 0.05331733f, -0.11824747f, -0.08704726f, 0.19215333f, 0.17163736f, 
    0.15428826f, 0.17087094f, 0.02100969f, -0.06794086f, -0.26951259f, -0.33475628f, -0.03350830f, 0.10698309f, 
    0.04298571f, -0.07843147f, -0.04040476f, -0.11006247f, -0.10617296f, -0.16925260f, -0.10490481f, -0.15807518f, 
    0.08667502f, -0.01917773f, -0.13241903f, 0.04926115f, -0.07279010f, 0.03877858f, -0.06596426f, -0.43462640f, 
    -0.18560812f, 0.23366225f, 0.03617776f, 0.05765517f, 0.16802523f, -0.14091212f, -0.14708605f, 0.18338124f, 
    0.38127494f, -0.35519877f, 0.14021593f, 0.13736571f, 0.07984588f, -0.00327552f, -0.06387118f, 0.00142200f, 
    -0.02518359f, -0.28975073f, 0.20144215f, -0.10207225f, 0.10530622f, 0.00756672f, 0.09043477f, -0.04486142f, 
    0.01836313f, 0.17313860f, 0.05547378f, -0.00151534f, -0.13603774f, -0.04682751f, 0.01198990f, 0.10040220f, 
    -0.10950124f, 0.12461174f, -0.23175438f, -0.26858875f, -0.09077777f, -0.02375224f, -0.04488784f, 0.00072243f, 
    -0.02082824f, -0.09307185f, -0.12465201f, -0.25459376f, 0.00273699f, 0.19314411f, 0.00533097f, 0.15792301f, 
    0.09301627f, -0.00847330f, 0.04513055f, -0.01434813f, 0.09030963f, 0.10973215f, 0.21486604f, 0.02428122f, 
    -0.03100161f, 0.00227775f, 0.08586232f, -0.05297651f, -0.00526078f, -0.10987061f, -0.05031290f, -0.27521932f, 
    0.15597169f, 0.16710326f, -0.14366178f, 0.05687474f, 0.03779766f, 0.09934929f, -0.21245641f, 0.03214960f, 
    -0.14940180f, 0.08798673f, 0.04848735f, 0.06467378f, 0.07689554f, -0.07123949f, -0.09518152f, 0.21684322f, 
    -0.16131662f, 0.01249638f, -0.11803792f, 0.07119329f, -0.03938475f, 0.07031471f, -0.07762759f, -0.24052565f, 
    -0.05111080f, -0.22472124f, 0.35346287f, -0.16444463f, -0.00414097f, -0.19513810f, 0.10954561f, -0.04252277f, 
    0.04556207f, -0.06555717f, -0.09061363f, 0.08988231f, -0.14521423f, 0.00550348f, 0.05928206f, -0.02622818f, 
    -0.08710535f, -0.00627780f, 0.20402336f, 0.31838101f, -0.02141697f, -0.09473164f, 0.00624748f, -0.02959966f, 
    0.04733403f, -0.06822576f, 0.00797397f, -0.15113205f, 0.11084343f, -0.48416927f, 0.08997098f, 0.06967332f, 
    0.09941477f, 0.10169786f, 0.08001650f, 0.07457886f, 0.14631502f, 0.29743952f, -0.10667787f, -0.04731104f, 
    -0.08245342f, -0.05778382f, -0.08522815f, 0.15554512f, 0.12677768f, 0.53650236f, -0.05941914f, 0.22120227f, 
    -0.09617242f, -0.17419396f, 0.02787005f, -0.00008909f, 0.08104338f, 0.02701805f, -0.14435548f, 0.31594780f, 
    -0.24551621f, 0.12152000f, -0.04611267f, -0.10929727f, 0.17837757f, -0.03885402f, -0.19707030f, 0.19469063f, 
    -0.06939766f, 0.20583025f, 0.05617448f, 0.02430452f, -0.12074423f, -0.01524849f, 0.03697347f, -0.06677800f, 
    0.24298130f, 0.01958279f, -0.17164327f, 0.06738859f, -0.13579468f, -0.07721411f, 0.06877351f, -0.01109005f, 
    0.07139387f, 0.01908996f, -0.02047082f, 0.20790897f, -0.10563930f, 0.04109756f, -0.10758482f, 0.13159165f, 
    0.10114014f, 0.01583768f, -0.17842121f, 0.11396404f, -0.37726903f, 0.13075384f, 0.00932877f, 0.19851747f, 
    -0.11640154f, -0.06186835f, -0.06047823f, 0.37339312f, 0.09404241f, -0.41695887f, 0.17614414f, -0.02345797f, 
    0.15476483f, 0.00653564f, 0.08890182f, -0.11850315f, 0.25809008f, 0.36066085f, -0.00971740f, -0.07682069f, 
    -0.17348394f, -0.04163751f, -0.26714671f, -0.04842862f, 0.03468611f, -0.32510427f, -0.11309731f, -0.09648833f, 
    0.05188823f, -0.10524829f, -0.05380931f, -0.14314701f, -0.07986940f, 0.07870306f, -0.03048073f, -0.27995950f, 
    -0.37938514f, -0.00244447f, 0.17979544f, 0.26850069f, -0.16983359f, -0.08803703f, -0.05612025f, -0.02114211f, 
    0.22712222f, -0.02000899f, 0.01898153f, -0.00432010f, 0.19025779f, 0.12517439f, -0.09084616f, 0.23208162f, 
    -0.01903231f, -0.03421408f, 0.01736803f, 0.00305969f, 0.00892676f, 0.03083461f, -0.00302644f, -0.01827564f, 
    0.03768452f, 0.03137115f, 0.01208369f, 0.03542460f, -0.03509279f, 0.00149679f, 0.03856517f, -0.01343460f, 
    0.03296373f, 0.01947483f, -0.02723574f, -0.01204311f, 0.04355473f, 0.03758309f, 0.01872682f, -0.00519432f, 
    -0.00172208f, -0.05123327f, 0.04369495f, -0.01431265f, 0.04188951f, 0.02098831f, -0.05495104f, 0.04537262f, 
    -0.04273894f, 0.00521868f, 0.02425573f, -0.06417769f, -0.06262545f, 0.01778608f, 0.01202248f, 0.00427692f, 
    -0.03289045f, -0.02203751f, 0.04715500f, -0.00665379f, -0.00081020f, -0.02172583f, 0.03388608f, 0.05047354f, 
    -0.05780236f, -0.06450602f, -0.01480021f, -0.04118335f, 0.02906224f, 0.05150511f, -0.00234570f, -0.00948855f, 
    -0.05101556f, -0.06113323f, -0.03032027f, 0.02563822f, 0.01261204f, 0.02622562f, -0.04493146f, 0.00775002f, 
    0.03521291f, 0.03791091f, -0.03144481f, -0.02164159f, -0.05825703f, -0.03757967f, -0.04732103f, 0.04518922f, 
    -0.05447258f, -0.05379663f, -0.03664960f, 0.01661659f, -0.06216725f, 0.04437843f, 0.04771880f, 0.01017811f, 
    -0.01663386f, -0.04637578f, -0.02315792f, 0.02885127f, -0.04304005f, -0.05717843f, -0.02428770f, 0.02938672f, 
    0.03186042f, 0.02268605f, -0.05261931f, -0.01626473f, -0.02136908f, -0.01338459f, 0.02870638f, -0.06001921f, 
    -0.05941022f, -0.03070336f, 0.02415632f, 0.00394882f, -0.01183150f, -0.00629705f, 0.04558662f, 0.05267344f, 
    -0.01077296f, -0.00461290f, -0.02318567f, -0.06416968f, -0.02659438f, 0.04561557f, 0.01167816f, -0.03634334f, 
    0.02553147f, 0.03454306f, 0.00444118f, -0.03661321f, 0.02244038f, -0.04628169f, 0.00659634f, -0.05852225f, 
    -0.03721976f, 0.02573220f, -0.05847508f, 0.04025228f, -0.04650050f, 0.04128927f, 0.02829193f, 0.02074529f, 
    -0.06653593f, -0.04478695f, -0.01923628f, -0.00542307f, -0.00938963f, -0.04246045f, -0.05574691f, 0.03691301f, 
    0.03833053f, -0.00558903f, 0.00922898f, -0.01300433f, -0.02831882f, -0.02268450f, 0.02389414f, 0.03984841f, 
    -0.00292052f, -0.06395531f, -0.04275565f, -0.01657434f, 0.00311598f, -0.02000954f, -0.00603575f, 0.03729718f, 
    -0.00621453f, -0.05197928f, -0.00373517f, 0.02531896f, 0.04339846f, -0.03870496f, -0.05662449f, -0.00721975f, 
    -0.02757168f, -0.04221619f, 0.01969148f, -0.00422572f, -0.02758974f, -0.04547066f, -0.00079307f, -0.04324304f, 
    -0.06320142f, 0.00497105f, -0.00619125f, -0.01978846f, -0.00075613f, -0.00329239f, -0.02645731f, -0.05987350f, 
    0.00995921f, 0.04721874f, -0.05267359f, -0.00337724f, -0.02398331f, -0.00301093f, 0.00656210f, 0.00995982f, 
    -0.06056017f, -0.05358520f, -0.03504744f, 0.01700756f, -0.06347821f, -0.04927469f, -0.04398812f, -0.04466244f, 
    0.03727495f, 0.02037503f, 0.04127333f, 0.04476534f, -0.05499163f, 0.04861346f, 0.03342994f, -0.05485301f, 
    -0.02407825f, -0.02949462f, -0.01560377f, 0.01052898f, 0.03643605f, 0.02252018f, -0.02098759f, -0.01488780f, 
    0.00681136f, -0.01440939f, 0.03092110f, 0.01968172f, -0.05298051f, 0.00561326f, 0.02419414f, -0.05802543f, 
    0.04028826f, -0.01925655f, -0.06531115f, 0.04239526f, 0.03755911f, -0.03583663f, -0.05514770f, -0.05971598f, 
    0.00400939f, -0.05327010f, -0.03340163f, 0.01710319f, -0.02065452f, -0.00616397f, -0.03056823f, 0.03390669f, 
    -0.02902761f, -0.01445527f, -0.00191802f, 0.01578720f, 0.04416415f, 0.02195165f, -0.03130601f, -0.05926349f, 
    -0.04035047f, 0.00552002f, -0.01458806f, -0.02517019f, -0.05089513f, -0.05850023f, 0.00419107f, 0.04791679f, 
    -0.04204121f, 0.03379689f, 0.04788820f, -0.06437056f, 0.00060404f, -0.03451173f, -0.03026981f, -0.02470860f, 
    0.00918300f, -0.02062422f, 0.05038481f, 0.00004134f, 0.00418267f, -0.02265834f, -0.06161647f, -0.02638681f, 
    0.03808641f, -0.06392603f, -0.00297333f, -0.04799905f, 0.00768374f, -0.06016298f, 0.04035656f, 0.03266926f, 
    -0.04906184f, 0.02847438f, 0.00033123f, 0.02607130f, 0.02975220f, 0.01199771f, 0.01598691f, 0.00604671f, 
    -0.05239816f, -0.02171696f, -0.05292628f, -0.01864271f, -0.00891146f, 0.01292811f, -0.02256991f, -0.01061433f, 
    -0.25522953f, -0.22452743f, -0.06630956f, 0.00859468f, -0.19075778f, 0.18474019f, -0.11175808f, -0.05432190f, 
    -0.05821764f, 0.12571752f, -0.19232945f, -0.07798367f, -0.14316255f, -0.04986276f, 0.04253447f, 0.02266608f, 
    0.03651723f, -0.10240248f, 0.15384024f, 0.11949807f, -0.02021297f, 0.05758944f, 0.15131249f, -0.09147726f, 
    -0.06089169f, 0.03361217f, 0.19598474f, 0.02122148f, -0.07213670f, 0.05009235f, -0.09931778f, 0.06599949f, 
    0.09784440f, -0.03767226f, -0.09852012f, -0.13328238f, 0.14367133f, 0.07356463f, -0.13558166f, -0.11857110f, 
    0.01921827f, -0.00555887f, -0.01856153f, 0.08927875f, 0.00746447f, 0.12509492f, 0.07099778f, -0.28028873f, 
    0.02644394f, -0.09399306f, 0.11800005f, 0.06668115f, -0.12640835f, -0.06585332f, 0.23262803f, -0.15565789f, 
    -0.08778369f, -0.11864307f, -0.09433563f, 0.09353143f, -0.07533454f, 0.23286948f, 0.08383570f, 0.21663933f, 
    0.01707256f, 0.23386429f, 0.13213858f, -0.08712202f, -0.05536420f, -0.04558764f, 0.05821925f, 0.15995869f, 
    0.31863335f, -0.20793037f, -0.12671354f, 0.01123029f, -0.01975547f, 0.01891388f, 0.07025858f, 0.11082278f, 
    -0.07707176f, -0.40552452f, 0.20968008f, -0.00786448f, 0.05241872f, 0.05937945f, -0.09825888f, 0.02941359f, 
    -0.11212298f, -0.07376274f, 0.10639764f, 0.13732809f, -0.09221423f, -0.06098389f, -0.20630524f, 0.23035051f, 
    -0.03022844f, 0.06463204f, 0.11141554f, 0.33543307f, 0.23906966f, 0.03428540f, -0.05964039f, 0.02066331f, 
    0.13089962f, -0.01920694f, 0.04087251f, -0.11052575f, -0.33890355f, -0.19991224f, -0.09394508f, 0.05444943f, 
    -0.07979788f, 0.06076845f, 0.09491813f, 0.02897184f, -0.08988077f, 0.22097147f, -0.10725461f, 0.10550862f, 
    0.00239588f, 0.10007486f, 0.06270784f, -0.10687048f, 0.09142452f, -0.03324521f, -0.36964443f, -0.07924479f, 
    0.14907189f, 0.13845602f, -0.05807339f, 0.02191352f, -0.21254405f, 0.01417518f, 0.02007217f, 0.07417322f, 
    0.33476064f, -0.07348941f, 0.16810879f, -0.05944278f, -0.03969277f, -0.03070893f, 0.09160025f, -0.01240570f, 
    0.12220133f, 0.12860405f, -0.02979231f, 0.04554052f, -0.07108967f, -0.02296414f, -0.10401648f, -0.07107987f, 
    0.00920620f, -0.31565717f, -0.23151806f, 0.06301170f, -0.13947758f, 0.01545335f, 0.15586288f, -0.06917726f, 
    -0.02107070f, -0.22935781f, -0.29379401f, -0.10284339f, 0.13112803f, 0.16562396f, 0.01952661f, -0.03591994f, 
    0.06515966f, -0.01474456f, -0.06363486f, 0.04411846f, -0.19463517f, 0.09606822f, 0.04057864f, -0.07451722f, 
    -0.02585147f, 0.00227497f, -0.01043261f, 0.11912680f, -0.53977787f, 0.09069265f, 0.24585384f, 0.16405374f, 
    -0.01400614f, -0.03225554f, 0.15367098f, -0.06975417f, -0.02680362f, -0.07267141f, 0.08483998f, -0.08765107f, 
    0.03195515f, 0.11581806f, 0.08153013f, 0.14388154f, 0.06315093f, -0.07768639f, -0.07627374f, -0.34884578f, 
    0.13956094f, -0.03558294f, -0.02874325f, 0.14592455f, -0.13515367f, -0.00504854f, -0.08437121f, -0.15140107f, 
    0.03016831f, 0.17068571f, 0.07064921f, -0.07264397f, 0.26203656f, 0.05603676f, 0.09346960f, -0.07705534f, 
    -0.04841386f, -0.04286502f, -0.05065082f, 0.18880466f, -0.08190374f, -0.07449528f, -0.06813776f, 0.00173458f, 
    0.07670470f, -0.01239137f, -0.10163794f, -0.19497228f, -0.00791623f, -0.18413264f, 0.26418617f, -0.16549771f, 
    0.12597923f, -0.17395014f, 0.19518769f, -0.05740615f, 0.22499409f, 0.05251332f, 0.08736710f, -0.11035121f, 
    -0.08641453f, 0.02234851f, 0.03202440f, 0.02137440f, -0.17481674f, 0.25200498f, 0.09290044f, 0.02233037f, 
    -0.01698924f, 0.06696708f, 0.09245837f, -0.13021843f, -0.69286209f, 0.19572839f, 0.14457595f, 0.13799082f, 
    0.13099808f, -0.03630216f, 0.02301325f, -0.10974770f, 0.12189807f, 0.04128620f, -0.09505579f, 0.22146399f, 
    0.10239857f, 0.05635167f, -0.03861724f, 0.00212025f, 0.01121563f, -0.03440809f, 0.10876423f, 0.03557812f, 
    0.13144252f, 0.02042586f, -0.09265737f, -0.19501428f, 0.07983330f, 0.02537041f, 0.10992694f, 0.15222649f, 
    -0.02476761f, 0.08740171f, -0.05224712f, 0.11900187f, -0.18444730f, 0.11044465f, 0.03674875f, -0.00854577f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.02529638f, -0.05514096f, 0.11208105f, 0.05916064f, -0.05775525f, 0.10925709f, 0.19528857f, 0.03733883f, 
    -0.06767652f, -0.06520218f, 0.00706743f, 0.03934196f, -0.01541711f, 0.18113910f, -0.13812511f, 0.00857580f, 
    -0.06408370f, -0.04119764f, 0.07159622f, 0.04989658f, 0.03760516f, -0.02902303f, 0.02130044f, -0.00361808f, 
    0.02949217f, 0.08964165f, -0.03932368f, -0.04294638f, -0.00889612f, 0.06235914f, 0.01257545f, 0.14719786f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03513321f, -0.13758573f, -0.11945548f, -0.03203223f, -0.10431965f, 0.08314855f, -0.09006276f, 0.04347490f, 
    0.05031217f, -0.14627656f, 0.12940606f, -0.01672982f, -0.10861522f, 0.09785097f, 0.07701074f, -0.05939029f, 
    0.11561175f, 0.07569979f, -0.15175569f, 0.10627706f, -0.17009415f, -0.18735802f, 0.08076257f, -0.12008988f, 
    0.16338931f, 0.11215039f, -0.02000812f, -0.11517479f, 0.02124036f, -0.15037528f, 0.08311965f, -0.10057227f, 
    -0.30340034f, 0.25183046f, 0.14291865f, -0.13705634f, 0.13811001f, -0.32370412f, 0.31669891f, 0.04599224f, 
    0.18002963f, 0.09718302f, 0.35789031f, 0.28154776f, 0.01957705f, 0.27968627f, 0.68328857f, -0.03414998f, 
    0.13811570f, 0.15834238f, -0.00732334f, -0.37484878f, 0.37015876f, 0.37308028f, -0.13574798f, 0.05686773f, 
    -0.07537683f, -0.18088289f, 0.14139423f, -0.04173170f, -0.07977753f, 0.08640684f, 0.03979904f, 0.14913960f, 
    -0.14729278f, 0.06727105f, -0.05050151f, -0.17394857f, -0.01181180f, 0.05974164f, -0.01551139f, 0.07735936f, 
    -0.10430603f, 0.08706778f, 0.01724959f, 0.13924794f, 0.06462146f, -0.00380455f, -0.17210956f, 0.04098964f, 
    -0.03351983f, -0.02966255f, -0.15064891f, -0.02672173f, -0.00182435f, -0.11704797f, -0.11661548f, 0.11929595f, 
    0.05447529f, -0.05871094f, -0.16313151f, -0.08639328f, -0.15898377f, 0.01548427f, -0.01545557f, -0.05816941f, 
    0.11029088f, -0.02571855f, -0.04420033f, -0.08814947f, 0.15996647f, -0.16845123f, -0.12658702f, 0.11566762f, 
    0.06970553f, 0.03772055f, -0.09431805f, -0.16911465f, -0.06297600f, 0.00874575f, -0.02630992f, 0.11327460f, 
    0.16848658f, -0.08871125f, -0.02412715f, -0.07327816f, -0.00700619f, -0.06890343f, 0.02027980f, -0.01899713f, 
    -0.07593168f, -0.00824521f, -0.02978846f, -0.13437688f, 0.05798932f, 0.04890446f, -0.00469800f, -0.07970747f, 
    0.12931062f, 0.13817562f, 0.13159110f, -0.16250086f, 0.17414327f, -0.05748859f, -0.14991562f, 0.10880519f, 
    -0.04501281f, -0.07058984f, -0.11972562f, 0.02216136f, -0.04481205f, -0.07294662f, 0.01659429f, -0.14614762f, 
    -0.09897508f, -0.08316287f, -0.05686712f, -0.09932910f, 0.10802834f, -0.08100160f, -0.17127316f, 0.15718293f, 
    0.15299375f, 0.07588753f, -0.13147703f, -0.05198017f, -0.13969564f, -0.13176721f, -0.08874284f, -0.07208681f, 
    -0.16027473f, 0.09965689f, -0.06668035f, -0.02936024f, 0.02409522f, 0.04793824f, -0.14882854f, -0.11899828f, 
    0.12763517f, -0.01108388f, -0.13694976f, -0.13576229f, 0.08724984f, 0.00523806f, 0.17420818f, -0.07996832f, 
    -0.11619771f, -0.02106792f, -0.04871239f, 0.00050888f, 0.01804838f, -0.10739149f, 0.08701656f, 0.07031842f, 
    -0.13754743f, -0.14162827f, -0.01533098f, -0.12654847f, 0.17025377f, -0.13314064f, 0.13396680f, 0.02647185f, 
    -0.06550835f, -0.11284296f, 0.03960276f, -0.19554688f, -0.08244655f, 0.09570432f, 0.10058443f, -0.10706390f, 
    -0.01825856f, -0.14947000f, 0.02506003f, -0.05542145f, 0.11814785f, -0.13446797f, -0.03818271f, 0.14785679f, 
    0.07946105f, -0.07178973f, -0.11948826f, 0.13984723f, -0.11649982f, -0.20442916f, 0.09280766f, 0.12981834f, 
    0.14783883f, -0.13767011f, 0.02438140f, -0.11032572f, 0.06104383f, 0.02913053f, 0.03243024f, -0.09832040f, 
    0.16850601f, 0.18529911f, 0.13282776f, 0.14905515f, 0.11342110f, 0.72070253f, 0.48236471f, 0.03862220f, 
    -0.13734660f, 0.02564089f, -0.02060239f, -0.49273911f, -0.30402344f, 0.11319394f, 0.46793014f, -0.03221567f, 
    -0.00864924f, -0.08627377f, 0.04335834f, 0.04602384f, -0.00037143f, 0.36869285f, 0.00505462f, 0.21002898f, 
    0.11670199f, 0.28997764f, -0.16118488f, -0.14842594f, -0.10934480f, -0.46273780f, 0.12582058f, 0.24529959f, 
    -0.17193863f, -0.06479855f, 0.29390532f, 0.12678894f, 0.11351802f, -0.10594845f, 0.28213543f, 0.09775007f, 
    -0.17422751f, -0.34075171f, -0.09141034f, 0.22519054f, -0.71965080f, 0.28794855f, -0.37770972f, -0.00636707f, 
    -0.14047375f, -0.18228431f, 0.20227389f, -0.35046345f, 0.34736368f, 0.17509870f, -0.00882538f, -0.31441632f, 
    0.10849252f, -0.42965698f, 0.09023236f, -0.14802679f, -0.03211777f, -0.00868712f, -0.01116548f, 0.14324300f, 
    0.03747870f, -0.01771822f, -0.18801624f, 0.08336004f, -0.12642582f, -0.16909720f, -0.07084356f, -0.02850358f, 
    0.06617399f, 0.02171213f, -0.05852006f, 0.02687210f, -0.14620498f, -0.13639134f, -0.01955067f, 0.17007819f, 
    -0.08159709f, 0.11558788f, -0.09435800f, -0.18689226f, -0.10722160f, -0.06247701f, 0.13562661f, 0.00597179f, 
    0.08915312f, -0.19182375f, 0.15950316f, -0.05445281f, -0.10335846f, 0.11298177f, -0.02582827f, -0.17231017f, 
    -0.00292311f, 0.06183995f, -0.01008630f, -0.03167172f, 0.06194257f, 0.04681873f, 0.12581034f, 0.14618939f, 
    -0.16605636f, -0.05468996f, 0.04981498f, -0.01402426f, 0.14696087f, -0.05795704f, -0.11529798f, 0.12622520f, 
    0.00160779f, -0.03287714f, -0.15403871f, -0.14754979f, -0.18813695f, 0.14033803f, 0.14312844f, 0.08482692f, 
    -0.11116910f, -0.12636465f, 0.01389811f, 0.03731162f, -0.02372655f, -0.14914341f, -0.01283433f, -0.05534063f, 
    -0.08016514f, 0.13893633f, 0.42869934f, 0.03355374f, -0.01304146f, 0.32241067f, -0.06189316f, -0.02512098f, 
    -0.13222986f, 0.00649567f, -0.03624626f, -0.02263421f, -0.12176823f, 0.44182697f, -0.56333506f, 0.09365612f, 
    0.09998164f, -0.04022351f, -0.02857377f, 0.08076137f, -0.14732173f, -0.46317172f, -0.05206639f, -0.44760671f, 
    -0.00467609f, 0.05329866f, -0.16436683f, -0.16243473f, 0.13239393f, 0.64081997f, 0.01895679f, -0.16170791f, 
    -0.54036057f, -0.04540085f, -0.04455334f, 0.20448810f, 0.14466144f, -0.30408385f, 0.00649746f, -0.07488317f, 
    0.05911288f, -0.43923774f, 0.28565800f, -0.10770443f, -0.02519982f, 0.19001751f, -0.62931114f, -0.18056832f, 
    0.08535233f, 0.16379742f, 0.11234096f, -0.25993234f, 0.28375769f, -0.17364320f, -0.15790430f, -0.32347590f, 
    -0.10863995f, -0.05880680f, 0.00284892f, -0.15877052f, 0.03709978f, 0.05259008f, 0.09279054f, 0.25040355f, 
    -0.58237296f, 0.09125535f, -0.03424091f, -0.01839009f, -0.02616237f, -0.21157542f, 0.29804140f, -0.04017252f, 
    -0.08958113f, -0.29775301f, 0.31261379f, -0.07267995f, -0.03554454f, 0.26893204f, -0.71433347f, -0.14034005f, 
    -0.21017437f, 0.13727552f, 0.07075260f, -0.20783359f, 0.24851063f, -0.01891986f, -0.06925364f, -0.31544688f, 
    -0.16032191f, 0.01799172f, 0.06780735f, 0.03800568f, 0.16564016f, 0.27615157f, -0.14001274f, 0.34569541f, 
    -0.44315323f, 0.07016394f, -0.13125369f, 0.19017133f, 0.16825242f, -0.31803924f, -0.28482017f, -0.09368351f, 
    -0.06540129f, -0.01648650f, 0.35954535f, 0.13759769f, 0.23241140f, 0.19973946f, -0.70086914f, 0.06450920f, 
    -0.11317024f, -0.14616637f, 0.04321713f, -0.33976966f, 0.17700745f, -0.24047168f, 0.05790448f, -0.05774727f, 
    0.07686871f, 0.07940049f, 0.16687301f, -0.06086768f, 0.06709336f, 0.37796453f, 0.15365987f, 0.07115486f, 
    -0.13276204f, -0.02371905f, 0.44715232f, -0.00254627f, 0.08501283f, 0.50589418f, 0.23266020f, -0.08541829f, 
    0.06832200f, 0.38738856f, 0.15248325f, -0.14501819f, -0.32441208f, -0.15893875f, 0.61233890f, -0.09463311f, 
    0.07204995f, 0.17852864f, 0.09760640f, 0.45971751f, -0.16842751f, 0.37553704f, -0.06127551f, 0.16806674f, 
    -0.04839408f, 0.20872509f, -0.14741123f, 0.16715382f, -0.07380932f, 0.07911181f, 0.10601728f, 0.23056458f, 
    -0.02422606f, 0.04992506f, -0.24771689f, -0.08147503f, 0.06056650f, 0.05540813f, -0.12289756f, -0.09342624f, 
    -0.00278811f, 0.19552569f, 0.01298786f, -0.14477302f, 0.65604573f, 0.08301701f, -0.63297379f, -0.08699071f, 
    -0.01288056f, 0.05584670f, 0.52533662f, 0.15435492f, -0.24503076f, -0.65592605f, 0.09745643f, 0.35436633f, 
    0.03559038f, 0.19352540f, 0.01029862f, -0.08890820f, 0.09042595f, 0.05953350f, 0.00337680f, 0.62508935f, 
    -0.12736455f, 0.07221503f, -0.25025931f, 0.19827047f, -0.14582749f, -0.25579661f, -0.57499921f, -0.08131519f, 
    -0.01515604f, -0.12370129f, 0.27458751f, -0.09134629f, 0.02555781f, -0.32455865f, -0.31697509f, -0.04639098f, 
    0.13715670f, -0.02026914f, 0.32863945f, -0.41775718f, 0.22754495f, 0.29249394f, -0.08392090f, 0.12841557f, 
    -0.13632675f, -0.09688744f, 0.07742472f, 0.01898694f, 0.07102693f, 0.45760587f, -0.16620182f, 0.06088290f, 
    0.19026074f, -0.10583887f, 0.05325339f, 0.35430285f, -0.15725988f, 0.67999190f, 0.02870196f, 0.15808812f, 
    0.08830021f, -0.13046791f, -0.20537928f, -0.49055079f, 0.06682736f, 0.09663865f, -0.32212296f, -0.00881710f, 
    0.09980082f, 0.13581540f, -0.11749785f, 0.25558516f, -0.19901958f, -0.00850817f, 0.06861260f, -0.00104172f, 
    0.02953995f, 0.23353194f, -0.07915288f, -0.03860361f, -0.02594969f, 0.17142209f, -0.07817443f, -0.17956540f, 
    0.82826275f, 0.11274488f, -0.07536081f, 0.36175865f, -0.15889876f, 0.26864287f, 0.21200785f, -0.03216744f, 
    -0.14286542f, 0.29661676f, 0.24461739f, 0.52088481f, -0.12933543f, -0.22605550f, 0.64936900f, -0.07633836f, 
    0.12369843f, -0.13424923f, 0.11147174f, 0.17785075f, 0.21522625f, 0.53003460f, -0.09024547f, 0.38546687f, 
    -0.04643653f, 0.22780360f, -0.05602650f, -0.16041841f, -0.12607376f, -0.36566043f, 0.13307872f, -0.16385143f, 
    0.10580244f, 0.13137145f, -0.05651765f, 0.36353585f, 0.06286427f, -0.13084696f, 0.09047502f, -0.06617973f, 
    -0.08653767f, -0.26873744f, -0.09425189f, -0.23859054f, 0.29334870f, 0.12531032f, -0.72400689f, -0.06489174f, 
    0.11274200f, 0.08073982f, 0.16623887f, 0.53629768f, 0.12946597f, -0.12731609f, -0.01786478f, -0.35161367f, 
    -0.12479673f, 0.14958298f, -0.03228186f, 0.01929474f, -0.05274092f, 0.36831206f, -0.10334936f, -0.49853551f, 
    -0.11119211f, -0.13719650f, -0.04796507f, 0.11284561f, -0.04339963f, 0.10109749f, 0.01846744f, 0.00398630f, 
    -0.17531957f, 0.28953207f, 0.33370355f, 0.16882390f, 0.59039968f, -0.40633529f, -0.70974034f, 0.12702318f, 
    -0.02511282f, 0.13305701f, 0.14984827f, -0.07154121f, 0.22169952f, -0.02181398f, -0.01687880f, 0.20747605f, 
    -0.00839706f, 0.59240663f, -0.04066290f, -0.03822891f, -0.16899645f, -0.32821202f, 0.03941341f, 0.26473349f, 
    0.02905833f, -0.04492545f, -0.14162089f, -0.02359493f, 0.15843962f, 0.12321489f, -0.17683953f, -0.15404208f, 
    0.13541734f, -0.18822576f, -0.10008253f, -0.13007972f, 0.13701400f, -0.11487773f, 0.07823375f, -0.06424782f, 
    0.12764804f, -0.13339150f, -0.00523779f, -0.16582377f, -0.19378212f, -0.11972066f, 0.12137307f, -0.04456896f, 
    0.00921016f, 0.10745142f, -0.01099352f, -0.16210674f, 0.04377945f, -0.08267367f, -0.03343555f, 0.09083736f, 
    0.36862275f, -0.14681041f, 0.09044085f, 0.24772516f, 0.03402448f, 0.19694981f, -0.35992873f, 0.14845833f, 
    0.01908543f, 0.00769434f, -0.14087780f, 0.32739210f, -0.19012460f, 0.02695002f, -0.32247266f, 0.04509211f, 
    -0.13369144f, 0.16562442f, 0.23634256f, 0.27903169f, -0.11480027f, -0.12683333f, -0.14671202f, -0.18368226f, 
    0.08335628f, 0.04977734f, 0.14304247f, 0.16499434f, 0.10958788f, 0.38413608f, -0.17245492f, -0.42237800f, 
    -0.05956759f, 0.13696069f, -0.06605766f, -0.15176578f, -0.13936216f, -0.03277484f, 0.03467457f, 0.05681024f, 
    0.16212581f, -0.06287416f, -0.05562996f, 0.16758567f, -0.02169576f, -0.08942194f, 0.14328887f, 0.03079461f, 
    -0.10137965f, -0.00856654f, -0.06551576f, -0.09417652f, 0.06004284f, -0.09733128f, -0.03274121f, -0.10736551f, 
    -0.11965299f, -0.03590823f, 0.07878949f, -0.15550891f, -0.12790111f, -0.05547305f, -0.08356567f, -0.01272165f, 
    -0.06874853f, 0.14560512f, -0.13167687f, -0.07117408f, 0.16631785f, -0.15949057f, -0.04793700f, 0.07733867f, 
    -0.06170891f, -0.02533957f, -0.11561260f, 0.02397530f, 0.09001433f, 0.05459530f, -0.06623015f, 0.11022520f, 
    -0.08814514f, 0.12369286f, -0.02974541f, -0.06214066f, -0.10977701f, 0.03115956f, 0.02209633f, -0.06791838f, 
    -0.01175130f, -0.04221077f, -0.04299383f, 0.03078096f, -0.00692454f, -0.11543493f, -0.16210525f, 0.02656054f, 
    0.07914331f, 0.08828635f, 0.57504863f, -0.14804395f, -0.13017559f, 0.23257124f, 0.21482997f, 0.00469325f, 
    -0.13503277f, 0.30255437f, -0.11077581f, 0.58537066f, -0.35253319f, 0.30990580f, 0.36444631f, -0.04372754f, 
    0.16528438f, -0.04734489f, -0.10159233f, 0.11203486f, 0.11222256f, -0.25068849f, -0.01345632f, -0.38816205f, 
    0.00737157f, -0.19469944f, -0.14012702f, 0.03360598f, -0.14930694f, -0.05493825f, -0.17024481f, 0.15866742f, 
    -0.10714450f, 0.17191392f, -0.14145286f, 0.08696741f, -0.06565674f, 0.02166139f, 0.00612288f, -0.11694511f, 
    -0.12674506f, -0.14539866f, -0.13452189f, -0.00159010f, -0.03359801f, 0.01578237f, 0.08475857f, 0.17384742f, 
    -0.07378563f, -0.17052568f, -0.17647018f, -0.06547960f, -0.13768485f, -0.12470923f, -0.04676338f, -0.02951917f, 
    0.08403089f, -0.16865493f, 0.00174962f, -0.15500163f, -0.03528545f, -0.11907576f, 0.00649380f, -0.03564926f, 
    0.25944081f, -0.09626096f, 0.07825821f, 0.01989958f, -0.10148720f, 0.29963529f, 0.02561752f, -0.14514035f, 
    0.08863476f, 0.47256222f, -0.28640693f, 0.25379449f, 0.31557769f, 0.01965118f, 0.92167652f, -0.11444921f, 
    -0.02487687f, -0.13066149f, 0.06021579f, 0.44595757f, -0.31366369f, 0.09595590f, 0.05453372f, 0.28827059f, 
    0.13429482f, 0.09962085f, 0.17951633f, -0.17054027f, -0.13112924f, 0.04238745f, -0.03613225f, -0.11041715f, 
    -0.08735514f, -0.02790758f, -0.06758179f, -0.14239797f, -0.14934145f, 0.02596661f, -0.06549169f, 0.09224577f, 
    0.10827118f, -0.12311020f, -0.01777238f, -0.14992528f, 0.06305648f, -0.17565975f, -0.11822040f, 0.10762910f, 
    -0.11367456f, -0.01739577f, -0.17900310f, 0.11600090f, 0.01950746f, 0.10752000f, -0.12520033f, -0.11610351f, 
    -0.16906793f, 0.16176927f, -0.15590055f, -0.11772943f, -0.07231238f, -0.05390338f, 0.14613968f, 0.17693704f, 
    -0.33126214f, -0.10755175f, 0.32967398f, -0.12770635f, -0.09373961f, 0.11943360f, 0.31632379f, 0.06965229f, 
    -0.09255587f, 0.03848638f, 0.17350291f, 0.05838676f, 0.32615572f, -0.00889507f, 0.56061107f, 0.09826257f, 
    -0.07951526f, 0.02432079f, -0.13304633f, -0.10649244f, 0.03112924f, 0.24130765f, -0.08991461f, 0.16904107f, 
    0.14483318f, 0.34293845f, 0.10816452f, 0.14546125f, 0.04357890f, -0.36286125f, 0.06897228f, 0.54543132f, 
    0.48233688f, 0.10968556f, 0.16153927f, -0.07194749f, 0.09941757f, -0.31642434f, -0.44836664f, -0.08149517f, 
    -0.00693742f, 0.32525396f, -0.00722661f, 0.69727069f, -0.23107037f, -0.05237285f, 0.44331750f, -0.12288506f, 
    -0.05132134f, 0.01930440f, 0.29214376f, 0.12016856f, 0.02739767f, -0.25479493f, 0.08742046f, 0.06616792f, 
    -0.16995758f, -0.09942829f, -0.14316060f, 0.02383263f, -0.12715289f, 0.10612179f, 0.13107710f, -0.18695176f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05115916f, -0.06855329f, -0.08123925f, -0.15907617f, -0.06361504f, 0.05099021f, -0.06110756f, 0.02536985f, 
    0.16017070f, 0.12422855f, 0.14303623f, 0.14760494f, 0.12874606f, 0.30874354f, 0.14552490f, 0.12010103f, 
    -0.11855750f, -0.05471980f, -0.02898012f, -0.04350257f, -0.02495760f, 0.16484566f, 0.15040378f, 0.02395290f, 
    -0.06675707f, 0.03618617f, 0.29432285f, 0.03591748f, -0.08742730f, -0.09531444f, 0.27429965f, -0.03610111f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13611245f, 0.33682841f, 0.16411541f, 0.14322598f, -0.08521848f, 0.13669848f, -0.07296025f, -0.00600939f, 
    0.70394784f, -0.08436258f, 0.00068918f, 0.26968211f, 0.52951980f, 0.52583379f, 0.41251311f, 0.03842791f, 
    -0.14343052f, 0.48525420f, -0.26034871f, -0.14745499f, 0.01477148f, -0.09322602f, 0.05912880f, 0.01194516f, 
    -0.00339326f, -0.14548026f, 0.18493953f, -0.08246229f, -0.18128054f, -0.05092072f, -0.03936309f, 0.22333820f, 
    0.04546345f, -0.03822881f, 0.14658511f, 0.09518889f, -0.09370517f, 0.13284656f, -0.04456452f, -0.11592534f, 
    -0.12197445f, 0.05334841f, -0.09914476f, -0.06141347f, -0.08973533f, 0.05541313f, 0.03465240f, -0.06738129f, 
    -0.06216894f, -0.10319593f, 0.07255859f, -0.16449538f, 0.09646145f, -0.01593593f, 0.02156588f, 0.05143877f, 
    -0.11327136f, 0.11956397f, 0.03609594f, 0.09451753f, -0.03286049f, 0.16608582f, 0.05808935f, -0.16404857f, 
    0.04446714f, -0.32562426f, -0.03628776f, 0.05381425f, 0.08478957f, -0.12069675f, 0.15193020f, 0.30234438f, 
    -0.21546596f, 0.11475062f, -0.05348301f, 0.26932168f, -0.22467874f, -0.05048795f, -0.29834422f, 0.31179306f, 
    0.22711314f, -0.67693174f, 0.36567733f, 0.01166816f, 0.13101777f, -0.12081209f, -0.12895924f, 0.22941367f, 
    -0.11854024f, -0.12085606f, 0.16802226f, -0.10369010f, 0.42128772f, -0.11404984f, 0.24009904f, -0.10190158f, 
    0.03776234f, -0.30808061f, 0.08651643f, 0.09973808f, -0.14387920f, 0.08765987f, -0.13725840f, 0.30696365f, 
    -0.00261629f, -0.01420703f, -0.08949435f, 0.10618597f, -0.26387390f, -0.26343849f, -0.27706796f, 0.26270819f, 
    -0.34171176f, 0.07709395f, 0.65125704f, 0.22667129f, 0.41243163f, 0.05344389f, 0.04945807f, 0.21714078f, 
    -0.04205944f, -0.04882105f, -0.23696022f, 0.06207004f, 0.33918712f, -0.05804092f, -0.07869114f, -0.22569863f, 
    -0.09247106f, -0.16000347f, -0.09459905f, 0.05543115f, 0.00862337f, 0.14327860f, 0.08102766f, 0.11707818f, 
    -0.06411445f, 0.11412247f, 0.09317742f, 0.03846551f, 0.08935435f, -0.15458822f, -0.01291800f, -0.04365662f, 
    -0.09634288f, -0.08299975f, 0.08278739f, -0.06653589f, 0.03793126f, -0.14859998f, -0.17864865f, -0.05620425f, 
    -0.17143394f, 0.02752583f, -0.02892991f, 0.06050013f, -0.08081707f, -0.07349534f, -0.06827665f, 0.02110442f, 
    -0.13082789f, -0.01680528f, -0.00563919f, -0.08902609f, -0.14919658f, 0.01610052f, 0.14070758f, -0.06222280f, 
    -0.03930307f, -0.12545940f, 0.11029682f, 0.03244470f, -0.14507166f, 0.05715837f, -0.14637330f, 0.16114333f, 
    -0.15692872f, -0.12757309f, -0.13289793f, -0.18187551f, -0.01288101f, 0.04231545f, -0.16743341f, 0.10357622f, 
    0.04160686f, 0.13039413f, -0.06149207f, -0.12014956f, -0.15026698f, 0.00821061f, 0.10718603f, 0.09448968f, 
    -0.21677907f, -0.16832341f, 0.07329179f, -0.13260496f, -0.07131063f, -0.02994052f, 0.15186703f, 0.36003867f, 
    0.24089468f, 0.08890030f, 0.08751050f, -0.45184135f, -0.07016701f, -0.13285591f, -0.39235625f, 0.18599698f, 
    0.38374490f, -0.61437458f, -0.17955950f, 0.34194341f, -0.33097506f, 0.34118840f, 0.10883445f, -0.08557121f, 
    -0.09728830f, 0.16974154f, 0.16528472f, 0.01308405f, 0.05760191f, -0.05689304f, 0.22867161f, 0.44448966f, 
    -0.08971460f, -0.06665645f, 0.05929617f, -0.09864803f, 0.17048860f, 0.04498747f, 0.01389327f, 0.08316160f, 
    -0.22457103f, 0.13899232f, -0.07560341f, -0.03564399f, -0.47005555f, -0.31684104f, -0.15855449f, 0.24268056f, 
    0.16658282f, 0.15434869f, -0.06912347f, 0.27820349f, -0.08083831f, 0.30602279f, 0.01941847f, 0.29966858f, 
    0.03167102f, 0.17366803f, 0.07420694f, 0.12347026f, 0.39061677f, -0.05083688f, -0.12299702f, 0.50502366f, 
    -0.17498665f, 0.51902199f, -0.09698971f, 0.09698201f, 0.02321933f, 0.06316088f, 0.10222162f, 0.10009509f, 
    0.44514424f, 0.07914756f, 0.05594736f, 0.45624867f, 0.25041449f, 0.25140858f, 0.03987627f, -0.11720613f, 
    -0.78509003f, -0.65087098f, -0.16515779f, 0.12121353f, 0.18513390f, -0.30424902f, -0.03364155f, 0.03868702f, 
    -0.14315839f, -0.04593115f, 0.64634007f, 0.00986544f, 0.07577334f, 0.11137477f, 0.04980412f, 0.07773419f, 
    -0.08040279f, 0.25620010f, -0.12922251f, 0.06211874f, 0.13329192f, -0.00390117f, 0.10240149f, 0.36016446f, 
    0.26925185f, -0.15637137f, 0.02471442f, -0.34423015f, -0.19644874f, -0.17048503f, -0.35288259f, 0.11655855f, 
    -0.08146477f, -0.33776611f, -0.05431000f, 0.33179015f, -0.36197823f, 0.26230410f, 0.03964654f, -0.30082363f, 
    -0.06067096f, 0.04613312f, 0.28365722f, 0.01070701f, 0.08058292f, 0.04030953f, 0.54787213f, -0.18925847f, 
    0.11077467f, 0.55249453f, 0.03212532f, -0.12010679f, -0.12330684f, -0.06588280f, 0.05804193f, 0.12451318f, 
    0.12712586f, -0.03710647f, -0.06353877f, -0.13437088f, 0.26127127f, 0.46428260f, 0.27669284f, 0.20169502f, 
    -0.11590841f, -0.43704727f, -0.26554075f, 0.09801052f, 0.07192121f, 0.33869433f, -0.03018292f, -0.30708069f, 
    -0.14521614f, -0.11169305f, -0.05740569f, -0.04399522f, -0.30476898f, -0.11656775f, 0.54490185f, -0.38376743f, 
    0.00244819f, -0.16003066f, 0.05392816f, -0.19243206f, 0.03376850f, -0.10916492f, 0.02228257f, -0.17189640f, 
    0.23629454f, -0.09867599f, 0.13260067f, 0.60212809f, 0.00640669f, -0.01409245f, 0.28333083f, 0.26790172f, 
    -0.49754882f, 0.02971168f, 0.46356854f, 0.03578951f, -0.03312916f, 0.00072243f, 0.14829421f, 0.56891775f, 
    -0.15323696f, 0.12232050f, 0.26397914f, -0.16021007f, -0.15243636f, 0.09472181f, -0.21661967f, 0.09876660f, 
    0.01934499f, 0.55821234f, 0.09334479f, 0.00496119f, -0.08783498f, -0.00994440f, -0.04465069f, 0.06998394f, 
    0.41102314f, 0.17110974f, -0.13903645f, -0.11725261f, -0.03966940f, 0.27948278f, -0.07035506f, 0.25260922f, 
    -0.69271237f, -0.45836151f, -0.11063898f, 0.30974746f, 0.08732396f, 0.05782739f, -0.13577366f, -0.14634053f, 
    0.04399427f, 0.03559327f, 0.22882305f, 0.09633054f, 0.02243417f, 0.21195488f, 0.27542430f, -0.22464395f, 
    -0.17510298f, -0.16390498f, 0.03191186f, -0.00843259f, 0.16005903f, 0.08457406f, 0.09893488f, -0.15751387f, 
    -0.01002313f, 0.16385055f, -0.15014015f, -0.11606231f, 0.05710667f, -0.16301608f, 0.15341274f, -0.01437231f, 
    -0.00143160f, -0.14459005f, -0.06046813f, -0.04254076f, 0.17126769f, -0.08809692f, -0.16919464f, -0.00623233f, 
    -0.09116454f, -0.00623472f, -0.13102846f, -0.11457878f, -0.14515615f, 0.02719009f, 0.04535837f, -0.11762142f, 
    0.01050815f, -0.24662390f, 0.11089057f, 0.05123676f, -0.08393353f, -0.22390404f, 0.11434311f, 0.18120085f, 
    -0.16707000f, -0.07224962f, 0.09904617f, 0.31933090f, 0.19485417f, 0.08127053f, -0.11944354f, 0.14536823f, 
    0.29279348f, -0.63453031f, 0.64355332f, 0.05060442f, 0.32806361f, 0.04092516f, -0.14959310f, -0.05365980f, 
    0.14024632f, -0.17327335f, -0.05752536f, -0.13939631f, 0.06629370f, -0.12042851f, 0.28109574f, -0.50839901f, 
    0.12109265f, 0.31842759f, -0.02334944f, 0.08324226f, 0.01909874f, -0.13987955f, 0.06209928f, 0.18505749f, 
    -0.58032149f, -0.10205570f, -0.11909986f, -0.09781826f, -0.50448000f, -0.08952112f, -0.02917068f, 0.32156098f, 
    0.22677022f, 0.22845815f, 0.05036540f, 0.02943816f, -0.60265249f, 0.17762662f, -0.06869513f, -0.44742045f, 
    0.03661855f, -0.06590115f, -0.09349170f, 0.04941088f, 0.36163092f, 0.03031440f, 0.47619876f, -0.22353424f, 
    -0.13008088f, -0.03211563f, -0.04212756f, 0.15451999f, 0.17415756f, -0.16198850f, -0.08242567f, -0.27085519f, 
    -0.07488896f, 0.08442140f, -0.11879585f, 0.51854104f, 0.01074668f, 0.30863205f, 0.21363619f, 0.07731614f, 
    1.00249135f, -0.48476145f, -0.25204808f, -0.29745227f, 0.21467601f, 0.13500081f, -0.08878691f, 0.07956199f, 
    0.05319215f, 0.10149488f, 0.33694986f, -0.15592004f, 0.39129898f, 0.09555947f, 0.03997368f, 0.45311007f, 
    0.13715777f, 0.04623046f, -0.17285061f, 0.15387054f, 0.10297752f, -0.15186745f, -0.06184398f, -0.16606797f, 
    0.02931906f, 0.15321854f, 0.10632050f, 0.11192457f, 0.07228497f, 0.05990438f, 0.07099698f, -0.19280839f, 
    0.11669324f, 0.05308628f, 0.05571098f, -0.11517880f, -0.22033755f, -0.23408018f, -0.10469401f, -0.05816084f, 
    -0.08139237f, -0.03040101f, -0.18693620f, -0.06221724f, -0.14318690f, 0.13809910f, -0.13311061f, -0.14432505f, 
    -0.13568589f, -0.15045159f, 0.04702377f, 0.10091049f, -0.08066970f, -0.12941682f, 0.15404268f, -0.11493304f, 
    0.14332312f, 0.01220421f, 0.11331160f, 0.02829735f, 0.05514558f, -0.00287507f, 0.17030962f, -0.00262427f, 
    -0.07743752f, -0.09941533f, -0.11830059f, 0.02704800f, -0.16642867f, -0.04115038f, -0.08100867f, -0.16428243f, 
    0.07073811f, -0.04521311f, -0.15552373f, -0.14729072f, -0.04466318f, -0.14857677f, -0.14723113f, -0.00840333f, 
    -0.16312133f, -0.14724520f, -0.12602641f, -0.08921862f, -0.07305941f, -0.15823480f, 0.10715718f, -0.09326878f, 
    -0.10588367f, -0.10180234f, 0.00705089f, -0.15410030f, 0.07435284f, -0.17228007f, 0.05624181f, -0.16136384f, 
    -0.12374292f, -0.02390835f, -0.17569120f, -0.14091612f, 0.15956391f, -0.01957156f, -0.09941424f, -0.16594851f, 
    0.15153089f, 0.05157917f, 0.07392032f, -0.02038561f, -0.09434123f, 0.14207292f, 0.07481055f, 0.01947859f, 
    -0.05363667f, -0.14558229f, -0.09824666f, 0.12801227f, 0.10742477f, 0.09763967f, -0.04738943f, -0.08608829f, 
    0.11649517f, -0.11518247f, -0.06970904f, -0.05086381f, -0.13512853f, -0.01223047f, -0.03167856f, 0.03570656f, 
    -0.08575649f, 0.02019965f, 0.15499817f, -0.17063040f, 0.03689317f, -0.00204631f, -0.14184591f, -0.08674924f, 
    0.15872905f, -0.06024287f, -0.12875709f, 0.02353438f, 0.13548991f, -0.06175097f, 0.03049848f, -0.03283745f, 
    0.11563446f, -0.11779726f, 0.15833452f, 0.00171203f, 0.11195140f, 0.03303698f, -0.15854141f, -0.14937566f, 
    0.07729263f, -0.15792900f, 0.03179353f, -0.22152105f, -0.07018900f, 0.00458829f, 0.00793148f, -0.07707792f, 
    0.06153117f, -0.17411117f, -0.04102682f, -0.00059481f, 0.00185042f, -0.13397597f, 0.12486186f, -0.08491585f, 
    -0.08143060f, 0.15763515f, -0.06473128f, -0.17411301f, 0.00208492f, 0.17348574f, -0.01706355f, 0.13501212f, 
    -0.08142932f, -0.11921909f, -0.16631055f, -0.13875769f, -0.13457151f, -0.07066479f, 0.04905476f, -0.01696201f, 
    0.21691237f, 0.15405355f, -0.13082962f, 0.24115604f, 0.05460504f, -0.14048457f, -0.18622011f, -0.18133886f, 
    0.47340164f, 0.11924885f, 0.40286356f, -0.00404517f, 0.39239824f, -0.34789062f, -0.07200105f, 0.29515219f, 
    0.13347603f, -0.04696545f, 0.02889888f, -0.12613705f, 0.18416524f, 0.00916941f, -0.49733827f, 0.23009560f, 
    -0.13852997f, 0.11322042f, 0.12322476f, -0.13054134f, -0.15088853f, -0.02814586f, -0.09481373f, 0.26740599f, 
    0.32746249f, 0.06129130f, -0.08672634f, 0.01755347f, 0.56850827f, 0.42716986f, 0.33359754f, 0.03588657f, 
    0.80919313f, 0.77410972f, -0.11295364f, -0.14038320f, 0.05984138f, 0.21226631f, -0.04074254f, -0.12780929f, 
    -0.06503560f, -0.01450090f, -0.26360148f, 0.05149228f, -0.39549226f, 0.15816960f, -0.07522956f, -0.32894522f, 
    0.02960460f, 0.01053635f, 0.07924579f, -0.06573864f, 0.05488065f, 0.16464806f, -0.07111771f, -0.42311591f, 
    -0.04079856f, 0.02932562f, -0.17551810f, -0.21246967f, 0.23928572f, 0.01873254f, 0.39755285f, -0.24492674f, 
    0.23057875f, 0.84772044f, -0.36256760f, 0.24372776f, 0.24996735f, 0.50281262f, -0.10080487f, 0.36205974f, 
    0.00239493f, 0.12769569f, 0.00944343f, 0.15957439f, 0.06464764f, 0.13097830f, -0.10756499f, 0.72467053f, 
    -0.11538526f, -0.17241780f, 0.11756821f, 0.06077110f, -0.01056864f, 0.08054106f, 0.00219364f, -0.07604630f, 
    -0.06376015f, 0.12638547f, 0.03291934f, 0.01984593f, 0.00519556f, 0.08132689f, 0.07421561f, -0.01159545f, 
    0.05843724f, 0.05080864f, -0.03830626f, -0.09529453f, -0.13547540f, 0.01943939f, 0.14520402f, -0.09793311f, 
    0.06041881f, -0.14877020f, -0.14537267f, 0.02370592f, -0.16463847f, -0.08415798f, -0.09727295f, 0.03035197f, 
    0.16633897f, -0.00240155f, 0.03697075f, 0.14619192f, 0.15518935f, 0.11016484f, -0.06936201f, -0.10132642f, 
    -0.32917821f, -0.06306227f, 0.13390552f, -0.39654157f, 0.03339089f, -0.26976579f, 0.04735048f, 0.16309670f, 
    0.20578168f, 0.72292763f, -0.05108977f, 0.40864706f, 0.21299531f, 0.28588450f, -0.03901540f, 0.09726421f, 
    -0.11052960f, -0.10511854f, -0.41547468f, -0.16849743f, 0.19087514f, 0.00768353f, -0.03746982f, 0.35144144f, 
    -0.17230934f, 0.02936547f, -0.01366228f, -0.04438338f, 0.09689923f, 0.01238350f, -0.11165227f, 0.10112368f, 
    0.70189410f, 0.05160213f, 0.00494760f, 0.31002063f, 0.28051120f, 0.30514988f, 0.08483277f, 0.00256938f, 
    -0.21412694f, 0.71092045f, 0.26350093f, 0.20314352f, 0.40736914f, -0.27953151f, -0.03192379f, 0.43665704f, 
    0.09152934f, 0.02496853f, -0.15202403f, 0.04657275f, -0.21288596f, -0.17357562f, -0.41193932f, 0.18915747f, 
    0.14046085f, -0.03936963f, -0.16721393f, 0.04164657f, 0.07415061f, 0.07172718f, -0.07995766f, 0.11223800f, 
    -0.09921043f, 0.02588808f, -0.07607099f, 0.09916706f, -0.43123329f, -0.45983046f, -0.14175823f, 0.08990473f, 
    -0.16675089f, -0.22801046f, -0.21824315f, 0.34340051f, 0.10906915f, -0.15687612f, -0.08979034f, 0.27442497f, 
    -0.15604818f, -0.00224938f, 0.24059519f, 0.16391550f, 0.47618321f, -0.20092542f, -0.20080408f, 0.81055540f, 
    0.04036574f, 0.05361829f, 0.11035644f, -0.07776587f, -0.12089606f, 0.13955021f, -0.15280272f, 0.00013169f, 
    -0.16513075f, -0.04279637f, -0.00607199f, -0.03053243f, -0.04533493f, -0.12726706f, 0.12860097f, -0.07337641f, 
    -0.12091939f, -0.13882054f, -0.05152145f, 0.13411009f, -0.16021669f, -0.05798594f, -0.13748768f, -0.02634912f, 
    0.08300999f, 0.07152912f, -0.03198674f, -0.17378287f, -0.19087069f, 0.17657539f, -0.16548367f, -0.15670216f, 
    -0.06527299f, 0.11372307f, 0.08224116f, 0.16617562f, 0.02165653f, -0.12194223f, -0.09928863f, 0.09833826f, 
    -0.03355619f, -0.07030174f, -0.01706149f, 0.07634313f, -0.11213523f, -0.19763552f, -0.16799136f, 0.02800252f, 
    -0.05363224f, -0.11496950f, -0.03120372f, -0.16137981f, 0.03093574f, -0.05959701f, 0.06662433f, -0.11497265f, 
    0.04285059f, -0.13625930f, -0.06648660f, -0.01742540f, -0.00410216f, -0.11589976f, -0.13210253f, -0.07704569f, 
    -0.08704028f, -0.34491089f, -0.06506289f, 0.00895995f, -0.07034615f, -0.15817174f, -0.01583468f, 0.33333150f, 
    -0.28246799f, 0.16409668f, -0.13992161f, 0.03468374f, 0.24542627f, 0.10481371f, 0.24133749f, -0.09853152f, 
    -0.33963481f, 0.46967322f, 0.76795316f, 0.18989016f, 0.39474267f, 0.37712607f, -0.10208791f, -0.06037513f, 
    -0.08416485f, 0.13903458f, -0.19257334f, -0.08935420f, -0.11197475f, -0.06075178f, -0.02325812f, -0.70785654f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.28137755f, 0.13762413f, 0.04824618f, 0.07331275f, 0.07255457f, 0.16881144f, 0.09969754f, 0.01120497f, 
    0.34467575f, 0.18712854f, 0.42996854f, 0.41654596f, 0.13518649f, -0.02171990f, 0.07942558f, -0.21009797f, 
    0.10427967f, -0.00909467f, -0.01856277f, -0.11095067f, 0.16937412f, 0.08714095f, -0.24963118f, -0.05224487f, 
    -0.16879325f, 0.00375270f, -0.22846396f, 0.04327455f, 0.07117511f, -0.05809826f, 0.03103817f, 0.25131163f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.25390542f, 0.08281046f, -0.41976556f, -0.54015213f, 0.10329160f, -0.03914893f, 0.21926437f, 0.05190993f, 
    0.25399080f, 0.22082177f, 0.13130045f, 0.19315934f, 0.13790315f, 0.03278983f, -0.77285904f, -0.23092118f, 
    0.00686164f, -0.00656447f, -0.04425237f, -0.15818892f, 0.04999968f, -0.20137112f, -0.57091635f, -0.20394203f, 
    0.31290060f, 0.10041902f, -0.12570055f, -0.21123582f, 0.22619520f, -0.01340028f, -0.17314292f, -0.60945159f, 
    -0.20935562f, 0.03355554f, 0.06600661f, -0.01341861f, 0.11088296f, -0.17340033f, 0.15182532f, 0.24929127f, 
    0.07372594f, 0.02508081f, -0.51290888f, 0.19135857f, -0.11136705f, 0.07337047f, -0.39173266f, 0.23342849f, 
    0.14424276f, 0.12655126f, -0.10974032f, 0.12138033f, -0.10097720f, 0.01039457f, 0.23103058f, -0.42947263f, 
    0.17974867f, 0.03586614f, -0.14165780f, -0.04232064f, 0.50987232f, 0.16289009f, 0.08676740f, -0.55987900f, 
    0.23791678f, -0.12889564f, -0.40697792f, -0.15420176f, 0.05332798f, 0.09806722f, -0.06976551f, 0.02120056f, 
    -0.60562778f, -0.88800037f, -0.53982812f, -0.20356956f, -0.61784053f, -0.05055227f, -0.47672459f, -1.15240538f, 
    0.02691247f, -0.01983388f, -0.13238865f, 0.01177659f, 0.13116440f, -0.01415750f, 0.29053968f, 0.48329288f, 
    0.25592196f, -0.03954511f, 0.35007417f, 0.28658679f, -0.00427289f, -0.05797405f, -0.13117427f, -0.30776653f, 
    -0.21095352f, 0.01209118f, -0.09798896f, -0.31475168f, -0.07931048f, 0.12879024f, 0.18505381f, 0.10721498f, 
    -0.54761511f, 0.29480863f, 0.21900123f, -0.74446380f, -0.06048867f, -0.14929029f, 0.10460994f, 0.59882212f, 
    0.10500846f, -0.09371986f, -0.00431999f, -0.04151479f, 0.08160500f, -0.05716110f, -0.06754443f, 0.17116813f, 
    -0.10281993f, 0.09902163f, 0.04541054f, -1.12041068f, -0.32468373f, 0.00299702f, -0.09397175f, 0.16872086f, 
    0.02641428f, 0.17188817f, -0.21167533f, -0.07357059f, -0.00936336f, -0.03049049f, 0.28267613f, -0.46592617f, 
    0.29117751f, 0.38959298f, 0.25729057f, -0.11424635f, 0.29181445f, 0.04203565f, 0.16636716f, -0.52460188f, 
    -0.17040388f, -0.09769729f, -0.03416965f, 0.01041988f, -0.06877597f, -0.02331308f, -0.06431168f, 0.04245042f, 
    -0.28944138f, -0.13343059f, -0.52805537f, -0.02812047f, -0.40067321f, 0.01478715f, 0.14114071f, 0.05715895f, 
    0.03364092f, 0.06966282f, 0.32494411f, 0.21472757f, 0.10844041f, 0.09029218f, -0.37778720f, -0.01278399f, 
    0.25182781f, 0.03971878f, -0.09749795f, 0.24450783f, 0.16011445f, -0.10030184f, 0.11632616f, 0.06854751f, 
    0.14328891f, 0.09534661f, -0.02864419f, -0.06311193f, -0.01413032f, 0.04303740f, 0.04750777f, -0.34863272f, 
    -0.37544936f, -0.08550274f, -0.51155293f, -0.09719440f, 0.04917537f, 0.05002648f, 0.12781529f, -0.10397699f, 
    0.23537801f, -0.07685713f, -0.21371818f, -0.76215553f, -0.07827897f, 0.06063433f, -0.58105063f, -0.58839375f, 
    0.21163601f, -0.68037134f, 0.21674353f, 0.07516099f, -0.24876817f, 0.08391489f, 0.11247290f, -0.72003800f, 
    0.56602782f, -0.00834540f, 0.03055628f, 0.16212283f, -0.09355491f, 0.13684611f, -0.01932604f, 0.43565622f, 
    0.14876743f, -0.06190112f, -0.61004496f, 0.01711988f, -0.82903844f, -0.09889801f, -0.15405250f, -0.29716817f, 
    -0.48040608f, -0.00813828f, 0.16401061f, 0.22892658f, 0.10277981f, 0.02187598f, 0.11314153f, 0.01910294f, 
    0.17225842f, 0.30273068f, -0.08313034f, -0.45890084f, 0.22093706f, 0.12717856f, -0.15610334f, 0.41054159f, 
    -0.22469577f, -0.08356680f, 0.01146220f, 0.01376870f, 0.05855159f, -0.11435037f, 0.06581397f, -0.55979532f, 
    -0.41889864f, -0.00501506f, 0.07071569f, -0.21913581f, 0.30938596f, 0.09651481f, 0.14702481f, -0.55169338f, 
    -0.53051251f, -0.03965053f, 0.07948692f, 0.43036225f, 0.03683005f, -0.07724383f, -0.46453601f, 0.08422736f, 
    -0.24599592f, -0.30588192f, -0.79844528f, 0.11014543f, -0.84485096f, 0.08112762f, 0.45222157f, -0.57470131f, 
    -0.03862853f, 0.09894334f, -0.15869081f, 0.09961433f, -0.06132232f, -0.17402516f, 0.21718483f, -0.40131360f, 
    0.14071338f, -0.12841830f, 0.21048275f, -0.18508583f, 0.10852990f, 0.13277556f, -0.15996726f, 0.50575238f, 
    0.21978600f, 0.12909387f, -0.62039495f, -0.06792212f, 0.04891080f, 0.13055167f, -0.60390973f, -0.40813196f, 
    0.22498962f, -0.11545000f, 0.03356609f, 0.32781768f, 0.15737754f, -0.06826583f, -0.30790946f, -0.06684453f, 
    -0.47450978f, -0.09747192f, -0.14378709f, -0.03364305f, 0.13813761f, -0.03513254f, -0.32783043f, 0.15864065f, 
    -0.00196357f, -0.00584221f, -0.24479899f, 0.27991500f, -0.48997694f, -0.03961264f, 0.01348005f, 0.33397558f, 
    -0.33014098f, 0.17194572f, 0.40874991f, 0.28176621f, 0.04708096f, -0.11748152f, 0.28236014f, 0.01155231f, 
    -0.59567457f, 0.21377705f, -0.09951414f, 0.12765048f, -0.26967332f, -0.07917464f, 0.43732330f, -0.08686002f, 
    -0.05455234f, 0.17131078f, -0.11552859f, 0.06420542f, -0.06573051f, -0.02060789f, -0.13511187f, 0.08988284f, 
    -0.47350428f, 0.08449057f, -0.15474260f, -0.40297610f, -0.23454639f, -0.15398787f, 0.06743897f, 0.23559640f, 
    -0.19947657f, -0.01470061f, -0.35155693f, 0.09172026f, 0.10840827f, -0.12900800f, -0.11668467f, 0.05284059f, 
    -0.69258744f, -0.29173622f, 0.18682767f, -0.12938122f, -0.15203433f, 0.00555841f, -0.01634086f, -0.40107137f, 
    -0.09745372f, -0.04220684f, 0.01496659f, 0.10400731f, -0.07154795f, 0.02576810f, -0.61285752f, 0.10812639f, 
    0.45078489f, -0.15519391f, 0.59724712f, -0.22265102f, -0.07810985f, -0.12202529f, -0.01220463f, 0.26593086f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.25764397f, 0.02131771f, -0.17625980f, -0.18118338f, 0.13982832f, 0.23629192f, 0.18878444f, -0.33464000f, 
    -0.34266350f, 0.09095629f, 0.33113274f, 0.17333075f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
