#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.85592175f, 0.59791040f, -0.57007283f, 0.06992827f, 0.41160005f, 0.44700408f, 0.08725175f, 0.54083633f, 
    0.37363020f, -0.17072313f, 0.03214114f, 0.71625537f, 0.42074561f, -1.01939654f, -0.90101713f, -0.29381102f, 
    -0.44816095f, -0.79395944f, 0.29077557f, 0.96843392f, -1.28734338f, 0.26989642f, 0.25056484f, -0.41294026f, 
    -0.47480971f, 0.62699360f, -0.81681281f, -0.97442132f, -0.39641392f, -0.53017032f, -0.74697578f, -0.97563308f, 
    -0.79049081f, -0.39448628f, -0.62037051f, -0.72740972f, 0.45461366f, -0.55405390f, 0.76978093f, -1.17070270f, 
    -1.24776721f, -0.93863481f, -0.26978078f, 0.56995028f, 0.20734377f, 0.85256881f, 0.78248852f, 0.85072744f, 
    -0.68715328f, -0.06075744f, -0.21384007f, 0.00432263f, 0.42299661f, -0.37751257f, -0.91715240f, -0.63522702f, 
    -0.07953822f, 0.30357575f, -0.08601587f, -1.00122213f, 0.57901293f, 0.25619042f, 0.68370867f, -1.50830817f, 
    -0.53300542f, -0.46382308f, 0.35661194f, 0.24234775f, 0.99304360f, 0.36993036f, -0.16935603f, 0.05804181f, 
    -0.41736543f, -0.80264813f, -0.84629631f, -1.25707400f, -1.03058958f, 1.16869938f, 0.17800431f, -0.43628901f, 
    -0.19593132f, -1.10647452f, -1.06176162f, -1.01193321f, 0.93664581f, 0.53311503f, 0.20031427f, -0.34212583f, 
    0.03644774f, -0.57783622f, -0.37087461f, -0.90611112f, -0.39081484f, -0.27638242f, 1.26274693f, -1.32577097f, 
    0.11077697f, -0.28942508f, -0.73621655f, 0.80826813f, 0.80899823f, -0.60249072f, -0.59240693f, -0.67522752f, 
    0.47985342f, -0.20045629f, -0.02661746f, 0.45908040f, -0.78334510f, -0.03036845f, 0.81528014f, 0.77885747f, 
    0.12806745f, -0.61626935f, -0.61303860f, 0.55040622f, -0.06197138f, 0.28577152f, 0.70272267f, -0.02380951f, 
    -0.73485404f, 0.75487864f, 0.24219505f, 0.17440803f, 0.70521855f, 0.33256152f, -0.70039785f, -1.18971741f, 
    -0.76537418f, -0.57846946f, -0.00179105f, 0.24176335f, 0.12236670f, 0.43357158f, 0.84429067f, 0.64706707f, 
    0.02717477f, 0.72991806f, 0.96705019f, 0.21955007f, -0.13971062f, 0.65575767f, -0.30747733f, -0.18134856f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10037649f, 0.42837793f, 0.09696046f, -0.15745726f, 0.30598584f, 0.78238440f, 0.02198036f, 0.09611570f, 
    0.38535684f, -0.04682017f, 0.31441644f, 0.36028394f, 0.46145567f, 0.35575205f, 0.39512017f, -0.01524625f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.25181583f, -0.06530590f, 0.01727643f, -0.06070998f, 0.13447404f, -0.04156328f, 0.09480977f, 0.04008152f, 
    0.10316794f, 0.04700156f, 0.07914681f, 0.09274995f, 0.04189689f, -0.21964219f, 0.12299890f, 0.07671677f, 
    0.05078685f, -0.01694239f, -0.00042782f, 0.00231164f, 0.35091159f, -0.13497357f, 0.14831522f, 0.27358097f, 
    0.10523317f, -0.01453812f, -0.18403694f, 0.40630782f, -0.20150143f, 0.12191390f, -0.12834024f, 0.07480015f, 
    -0.13603312f, -0.11633416f, -0.02554628f, 0.13372965f, 0.21188276f, 0.06366368f, 0.13132669f, 0.07426742f, 
    -0.41949090f, -0.31124723f, -0.24279192f, 0.33649176f, 0.49587712f, -0.03508028f, -0.03972861f, -0.05183688f, 
    0.08247404f, 0.14538527f, -0.10455485f, 0.03843738f, 0.08229975f, 0.10776690f, -0.09738976f, 0.14369428f, 
    -0.01165068f, -0.04165343f, 0.03032058f, 0.05819080f, -0.09747773f, -0.22771317f, -0.15540954f, 0.07315481f, 
    0.23489763f, -0.20894447f, -0.14095347f, -0.01294084f, -0.23681141f, 0.00627917f, 0.05102049f, -0.00780293f, 
    0.05507920f, 0.15629777f, 0.00803980f, 0.18447214f, 0.13794030f, 0.01472900f, 0.17319751f, 0.06466558f, 
    0.68569303f, 0.36244580f, 0.58927602f, 0.37258852f, 0.24832681f, 0.29788807f, -0.04014983f, 0.23711678f, 
    0.19272548f, 0.18830693f, -0.08857024f, 0.10020550f, -0.02800102f, -0.17834689f, 0.05613004f, 0.01565592f, 
    -0.10992671f, -0.03529425f, -0.07745315f, 0.08031007f, -0.01472247f, 0.25273305f, 0.18523754f, 0.23495780f, 
    0.01352328f, -0.08881415f, 0.04687057f, 0.10591968f, 0.05521873f, -0.03329840f, 0.04117215f, -0.02196381f, 
    0.04578940f, -0.00166908f, 0.08407646f, 0.01261707f, 0.12546912f, 0.06246782f, -0.18963356f, 0.10094856f, 
    -0.17259835f, -0.08791235f, -0.49325329f, 0.32358059f, -0.15141386f, 0.02861272f, -0.14897677f, -0.06584567f, 
    -0.25659561f, 0.37606242f, -0.04059344f, -0.08774116f, -0.08819106f, -0.08946934f, -0.04274752f, 0.10801513f, 
    -0.06306743f, -0.09416612f, -0.02654201f, -0.15168029f, -0.31093591f, -0.28564700f, 0.12274573f, 0.00837864f, 
    -0.07637593f, -0.02393382f, 0.04600139f, -0.03157120f, 0.07026330f, 0.14753981f, 0.09584378f, -0.07047348f, 
    0.04336445f, -0.09390618f, -0.01617383f, -0.09027013f, -0.04518034f, -0.00273723f, -0.05542208f, 0.10447752f, 
    0.12134679f, -0.45641908f, 0.18870029f, -0.08167036f, 0.25537980f, -0.03944893f, -0.11911346f, -0.28523707f, 
    0.13745086f, -0.16690710f, 0.03564581f, -0.01698758f, 0.02707184f, 0.10677266f, 0.06932278f, 0.03421001f, 
    -0.04587703f, -0.09486146f, 0.02744014f, 0.12542367f, -0.34294435f, -0.02685102f, -0.15936700f, 0.27096087f, 
    0.22314194f, 0.01472490f, 0.26034150f, -0.04900778f, -0.35208735f, 0.05833102f, -0.07484643f, -0.11513948f, 
    0.04595630f, 0.17847571f, 0.22698082f, -0.01149018f, 0.07148764f, 0.09140598f, -0.16279615f, -0.06003384f, 
    -0.43788165f, 0.28727183f, -0.34535229f, 0.49958128f, 0.18156114f, -0.07632467f, 0.18067601f, -0.10784196f, 
    -0.27156436f, -0.02512494f, -0.12608685f, -0.01665228f, 0.02772406f, 0.09437116f, -0.04688106f, 0.04423457f, 
    0.13234445f, 0.20634998f, 0.00980474f, 0.03344806f, 0.04502586f, -0.03004258f, 0.31211194f, 0.14241843f, 
    0.29406342f, -0.04327925f, 0.01135550f, -0.08050342f, 0.10057252f, -0.26729807f, -0.07219721f, 0.02181457f, 
    0.01442755f, -0.12149541f, 0.12394616f, -0.21477354f, 0.02688499f, 0.10040117f, -0.06251666f, -0.11389218f, 
    -0.21578217f, -0.14968359f, -0.29515755f, -0.06115664f, -0.28010464f, 0.02182363f, -0.04986832f, 0.19852716f, 
    -0.31396219f, 0.18169861f, -0.17168732f, -0.09918240f, -0.18251085f, 0.27694371f, 0.14477512f, -0.00199642f, 
    -0.27160329f, 0.02720231f, -0.02411737f, -0.19600165f, -0.09070949f, 0.02900798f, 0.04163106f, -0.04448125f, 
    -0.04757528f, 0.03476350f, 0.14730141f, 0.03994874f, -0.04717179f, -0.00285288f, 0.03168030f, 0.14417768f, 
    0.09423195f, -0.13847807f, 0.16662376f, 0.17879993f, 0.11345077f, 0.01629474f, -0.05984058f, 0.03439070f, 
    0.20530759f, -0.38051602f, -0.00718752f, 0.29408219f, 0.41192111f, 0.07325105f, -0.20615134f, -0.23011693f, 
    -0.05870128f, 0.13501531f, 0.07310867f, -0.03963612f, -0.01406508f, -0.07771995f, 0.09685234f, 0.00350534f, 
    0.00681766f, -0.01976134f, 0.02500660f, 0.01405086f, -0.31350777f, -0.09889898f, -0.00704433f, 0.01807704f, 
    -0.25317496f, 0.01661357f, 0.06733529f, 0.19480038f, 0.06479425f, 0.07573804f, -0.01932792f, -0.01799486f, 
    0.09925719f, 0.02350678f, 0.00922724f, 0.16095243f, 0.16737562f, 0.03845905f, -0.14969327f, 0.12238670f, 
    -0.01632347f, 0.03384034f, 0.00403230f, -0.00006190f, 0.00376207f, 0.02776795f, -0.00807547f, 0.02122002f, 
    0.01665570f, -0.00096756f, -0.00567577f, 0.02715869f, 0.02146799f, 0.02252589f, -0.00489044f, -0.05197447f, 
    0.02647578f, -0.00067510f, -0.01497630f, -0.02725273f, -0.00468582f, -0.03084169f, -0.03731422f, -0.04173238f, 
    0.02333542f, 0.00576318f, 0.00015477f, -0.03961902f, 0.03449560f, -0.06465679f, -0.03488338f, -0.04075561f, 
    -0.04825726f, 0.03867296f, -0.04745314f, -0.02685930f, -0.03584019f, -0.04804581f, -0.00603664f, -0.00817373f, 
    -0.03911557f, -0.00113946f, 0.02007696f, 0.00688173f, 0.00734564f, -0.05957058f, -0.00161766f, 0.03473044f, 
    0.03213004f, -0.02125747f, 0.03578044f, -0.03740988f, 0.01730957f, -0.02484447f, -0.03305122f, 0.03618037f, 
    -0.05888743f, 0.01260558f, 0.03953222f, 0.04186142f, 0.02494240f, 0.00663999f, -0.01672368f, 0.02639890f, 
    -0.02558925f, -0.03122855f, -0.06455407f, -0.01968106f, 0.00797170f, -0.00640096f, 0.04426713f, -0.03085140f, 
    -0.03904277f, -0.01584661f, 0.03829904f, -0.03294814f, 0.05597090f, -0.00483357f, -0.06406746f, -0.06083018f, 
    0.00444213f, 0.01326830f, 0.01292807f, -0.03749721f, -0.01753113f, 0.01072443f, -0.03507926f, 0.04003481f, 
    0.04253205f, 0.03737915f, -0.03878222f, 0.03048889f, -0.02024932f, 0.01216601f, -0.03602941f, -0.05313086f, 
    -0.05491456f, 0.02432029f, 0.01733769f, 0.00185728f, 0.03364205f, 0.03430982f, 0.01084484f, 0.01741109f, 
    -0.06051710f, 0.02489061f, -0.05833691f, 0.02831440f, -0.03206461f, 0.03573788f, -0.06356589f, -0.01463071f, 
    -0.03763413f, -0.02285653f, 0.04410473f, -0.04780514f, -0.06061793f, 0.00654794f, 0.02250453f, 0.01969448f, 
    -0.03061537f, -0.03047060f, -0.03729531f, 0.03994371f, 0.02354569f, -0.02150968f, -0.04782482f, 0.03419824f, 
    -0.00175619f, -0.01249477f, 0.01545156f, 0.03749965f, 0.03753725f, -0.02585670f, -0.01677150f, -0.05111556f, 
    -0.05986742f, 0.02594272f, 0.02441424f, -0.00709903f, 0.02309959f, -0.04789525f, 0.03542560f, -0.05575796f, 
    -0.04721926f, -0.00163651f, -0.04735835f, -0.00881897f, -0.03503557f, 0.02139803f, 0.04313089f, -0.04861468f, 
    0.03021212f, 0.03622792f, 0.00825319f, 0.02513875f, -0.04175080f, -0.00754273f, 0.02723985f, 0.03859748f, 
    -0.03311327f, -0.04088333f, -0.00570408f, -0.00716079f, 0.05608030f, 0.01148506f, -0.05503072f, -0.02947476f, 
    0.03681479f, -0.04414260f, -0.02132848f, -0.04907460f, -0.03297783f, 0.00040076f, -0.01030261f, -0.03907159f, 
    0.03545289f, -0.03804960f, 0.02309061f, -0.02902873f, 0.03081013f, 0.04868805f, 0.05034908f, -0.03960370f, 
    0.01764330f, 0.04401260f, 0.04381461f, 0.03451293f, 0.03822337f, 0.00291371f, -0.00774667f, -0.02602641f, 
    -0.03776544f, 0.02166384f, -0.06621177f, -0.04954633f, -0.02746387f, 0.01649530f, -0.03325500f, -0.00698768f, 
    0.03575968f, -0.03062220f, 0.04263933f, -0.03684065f, -0.01033751f, -0.00431713f, -0.03903019f, 0.02351016f, 
    0.02998041f, -0.00575169f, -0.05675482f, 0.00786194f, 0.02312406f, -0.04028869f, -0.06620626f, -0.04551549f, 
    -0.02452970f, 0.02492083f, 0.03710611f, -0.05115549f, -0.05308051f, 0.02155638f, 0.02325129f, -0.06631157f, 
    -0.02230311f, -0.01087538f, 0.03377119f, 0.03237614f, -0.04245420f, 0.04213858f, -0.01307580f, 0.01106042f, 
    0.01176801f, 0.01541118f, 0.02916479f, -0.05470938f, 0.02127742f, 0.02157086f, -0.02117313f, -0.03522747f, 
    0.01050873f, 0.04283747f, -0.01567567f, -0.05270286f, -0.02749796f, 0.01511628f, 0.02266357f, -0.04821168f, 
    0.03695535f, 0.02591925f, -0.06170198f, -0.02110584f, -0.00697356f, 0.00827422f, -0.00854158f, -0.05307024f, 
    -0.00055548f, -0.02922087f, -0.00995607f, 0.04303228f, 0.01757821f, -0.05085092f, -0.03291691f, 0.03539610f, 
    0.02696458f, -0.00908345f, 0.04162324f, 0.03365611f, -0.03558195f, -0.02572591f, -0.03459832f, 0.01384460f, 
    0.00838186f, 0.00465521f, -0.06314214f, 0.03847413f, 0.04158697f, -0.04407097f, -0.00702969f, -0.01451824f, 
    -0.02360943f, 0.05021366f, -0.04179306f, -0.02045470f, -0.04280321f, 0.00277246f, 0.04169071f, -0.04282288f, 
    0.01527011f, -0.02917763f, 0.01100038f, 0.03142423f, -0.05578397f, -0.00079285f, -0.05530292f, -0.04586554f, 
    0.01599694f, 0.02436895f, 0.04476723f, -0.03207670f, 0.01816704f, -0.02781564f, -0.01320126f, -0.01382193f, 
    0.02256650f, 0.02600537f, 0.04129000f, 0.04573848f, -0.03889399f, -0.03131784f, -0.03264027f, 0.04164599f, 
    -0.03197617f, -0.05621354f, 0.04309160f, -0.02170699f, -0.06322858f, -0.02122951f, 0.00316684f, -0.03897928f, 
    -0.02435462f, -0.19692782f, -0.05555772f, -0.14760254f, -0.23322974f, -0.10795881f, -0.03544809f, -0.00615979f, 
    0.00204074f, 0.05271772f, 0.20235854f, 0.12893431f, -0.18392290f, 0.01218606f, 0.02908155f, -0.11246444f, 
    0.12186826f, -0.09004602f, 0.12897982f, 0.04264040f, 0.06031515f, 0.27512413f, 0.29344824f, -0.05463774f, 
    0.04751792f, 0.24037066f, 0.10725707f, -0.06878898f, 0.24497832f, -0.22573538f, 0.01645964f, 0.04932359f, 
    0.08431777f, 0.06234489f, 0.12990317f, 0.15382378f, 0.01176418f, -0.02930267f, -0.18281674f, -0.14894380f, 
    -0.01305156f, 0.41540995f, 0.43390214f, 0.51366770f, -0.18371493f, 0.23537813f, -0.09839319f, -0.15725270f, 
    -0.04745636f, -0.29672456f, 0.12736396f, 0.19642913f, 0.19960865f, 0.30048132f, 0.07883941f, 0.14265823f, 
    -0.09453062f, 0.02068632f, 0.34014797f, -0.28299206f, -0.36360744f, -0.24883462f, -0.39350858f, -0.08514147f, 
    0.34650517f, -0.09341654f, -0.08016555f, -0.14499402f, -0.11856148f, -0.41623953f, -0.06121903f, -0.01622041f, 
    -0.08108574f, -0.05571982f, 0.05010998f, -0.06912716f, -0.03258191f, -0.03932598f, -0.30367672f, -0.03171711f, 
    0.07300496f, -0.67332023f, -0.13879751f, 0.02580860f, 0.24469943f, -0.10921619f, 0.05968883f, -0.35687843f, 
    0.12918296f, -0.08808475f, -0.09142426f, -0.04208023f, 0.01612787f, 0.00449795f, 0.22840700f, -0.11148181f, 
    0.11399294f, 0.18490613f, 0.06681781f, 0.09710169f, 0.21707135f, 0.16261326f, 0.39381650f, 0.00862854f, 
    -0.08447558f, 0.08350225f, -0.11814730f, -0.09395383f, -0.02331750f, -0.00915734f, -0.08214458f, -0.04980072f, 
    0.00785484f, 0.01745129f, 0.04679586f, -0.08576140f, 0.08983349f, -0.00674658f, 0.12411190f, -0.01547291f, 
    -0.44100326f, -0.23823574f, 0.13861901f, 0.05305944f, -0.13809577f, 0.26319227f, -0.25800201f, -0.02222739f, 
    0.09478261f, 0.09134062f, 0.02487370f, 0.10101491f, -0.05211991f, 0.02687488f, -0.00446735f, -0.16490208f, 
    0.10078632f, 0.24561177f, -0.03306738f, 0.13222064f, -0.46412501f, -0.40400150f, -0.40642291f, -0.48910570f, 
    0.54124349f, -0.26696509f, 0.05959566f, 0.48311785f, 0.16565192f, 0.39789787f, -0.03742393f, 0.27766165f, 
    -0.14556056f, -0.02355593f, -0.11997525f, -0.07702702f, -0.06339428f, -0.06318832f, 0.04939494f, -0.05112604f, 
    -0.32644084f, 0.12714715f, -0.72408837f, -0.03416035f, 0.77805799f, -0.34228736f, 0.45014071f, 0.10788975f, 
    0.06740374f, -0.04307657f, 0.01934025f, -0.03214950f, 0.04965100f, 0.08830575f, 0.00815138f, 0.01767704f, 
    0.01781795f, 0.00448001f, 0.09118544f, 0.04334312f, -0.34784710f, -0.07471813f, 0.38481048f, -0.04845104f, 
    0.86540985f, -0.27028471f, -0.21981998f, 0.22573975f, -0.17684560f, 0.16597432f, 0.04847823f, 0.12627128f, 
    -0.13481504f, -0.20332395f, -0.04939279f, -0.07805818f, -0.05071008f, -0.11854720f, -0.05872536f, -0.12157608f, 
    0.05470130f, -0.16794850f, 0.11735985f, 0.27213013f, 0.48982868f, 0.12570325f, 0.10974765f, 0.13176695f, 
    -0.00047560f, -0.25954956f, -0.00166846f, 0.10644215f, 0.11545762f, -0.03913421f, 0.19595699f, 0.08438709f, 
    -0.02113160f, 0.05152815f, 0.03809825f, -0.13682878f, 0.18634598f, -0.01929553f, 0.38432521f, -0.01973561f, 
    0.38632098f, -0.10578197f, 0.10628577f, 0.10409470f, 0.07570111f, 0.08942585f, -0.01388531f, -0.07550551f, 
    0.08393855f, 0.14020778f, -0.05733040f, 0.20797803f, -0.08349720f, 0.07386067f, -0.02979971f, 0.20198987f, 
    0.61687511f, 0.07813853f, 0.06489105f, 0.19575357f, -0.19655998f, 0.10083597f, 0.03288763f, 0.19592398f, 
    0.30718425f, -0.17047605f, 0.21048012f, 0.16474734f, 0.05828644f, 0.16190037f, 0.14063734f, 0.12204397f, 
    0.05804553f, 0.06887737f, 0.07325689f, 0.15428205f, 0.18630043f, -0.09164152f, 0.04139092f, 0.02742955f, 
    -0.07998292f, -0.15958409f, -0.11691897f, -0.17889749f, -0.01396705f, 0.08893165f, 0.14871621f, 0.05094213f, 
    0.13108847f, 0.10425865f, 0.10671042f, -0.21644080f, 0.00915747f, 0.05827726f, 0.15538147f, 0.05138537f, 
    -0.18112704f, 0.03458614f, -0.26997370f, -0.24968527f, 0.21457943f, -0.19611044f, 0.39656153f, 0.23577453f, 
    0.10516658f, 0.12462366f, 0.07183456f, 0.05717982f, -0.10283908f, 0.05476841f, -0.08064110f, 0.06371189f, 
    0.13073774f, -0.01710488f, 0.07075009f, 0.02520487f, 0.09075988f, 0.45488188f, 0.09626205f, 0.03517390f, 
    -0.16746809f, 0.05876657f, -0.18995343f, -0.18977256f, -0.03257270f, -0.03242491f, 0.08261166f, -0.06807084f, 
    -0.00004214f, -0.07912895f, 0.16917597f, -0.05507619f, -0.05001251f, 0.00347680f, 0.05779678f, 0.07658048f, 
    0.01319727f, 0.15576527f, 0.19034010f, 0.06139191f, 0.10455547f, -0.00083069f, -0.13154680f, -0.03574273f, 
    -0.15857185f, -0.06995676f, -0.07584101f, 0.01219435f, 0.03945817f, 0.09906247f, -0.02721460f, 0.00735939f, 
    -0.02227125f, 0.06538429f, 0.07704468f, -0.00587367f, -0.25266078f, 0.08029348f, 0.31716108f, 0.11402116f, 
    0.19535235f, -0.03163398f, 0.42039207f, 0.04420245f, 0.19236533f, 0.26509902f, 0.08802027f, 0.02835697f, 
    0.01670859f, -0.00618675f, -0.01160753f, 0.20966083f, 0.06601771f, 0.23033108f, 0.10026789f, -0.10548919f, 
    0.69942760f, 0.10507136f, 0.58380413f, -0.50817007f, 0.43707320f, 0.02380493f, -0.03742237f, 0.08803755f, 
    -0.02846716f, -0.03921610f, 0.23174229f, -0.11089440f, 0.15912026f, 0.06111955f, 0.06494470f, 0.34653136f, 
    0.22777949f, 0.11868452f, -0.00768194f, -0.07066462f, -0.28609225f, -0.26834562f, -0.15915027f, 0.03015435f, 
    -0.21525374f, 0.03487650f, 0.02243750f, 0.09433039f, 0.12932521f, 0.00876944f, 0.00983349f, 0.01279116f, 
    0.01862073f, 0.03327955f, -0.01858956f, -0.01910687f, -0.01119634f, -0.03346928f, 0.03964448f, -0.03120911f, 
    -0.26587924f, -0.51636535f, -0.21642761f, -0.00663943f, -0.15942156f, 0.28157949f, 0.24135569f, 0.21077096f, 
    -0.10130119f, -0.09592672f, 0.11316931f, -0.03008293f, -0.13232107f, -0.08520529f, -0.06735233f, -0.03808338f, 
    0.00029411f, 0.02316026f, 0.10745794f, 0.18452507f, -0.38192520f, -0.20893236f, -0.23199627f, -0.07455824f, 
    0.13578968f, 0.14244802f, 0.19543977f, 0.15604632f, 0.00563928f, 0.16242431f, -0.01701751f, -0.01731314f, 
    -0.07163940f, 0.03355868f, -0.07608392f, 0.04503150f, -0.17804110f, 0.18987849f, -0.07484241f, -0.09165049f, 
    -0.13527086f, -0.42813101f, 0.28694102f, -0.35418242f, -0.11222084f, -0.13734266f, 0.05637388f, -0.32599947f, 
    -0.00507224f, -0.24584778f, 0.12088127f, 0.12664290f, -0.00342961f, -0.03638824f, 0.02250695f, 0.04601052f, 
    0.07430382f, -0.00670215f, 0.05192875f, 0.10001358f, -0.34633094f, 0.65824103f, 0.07326848f, 0.23899810f, 
    0.13097566f, 0.15484129f, -0.00767507f, -0.15976642f, 0.01145773f, -0.03446897f, 0.12039360f, 0.10529440f, 
    0.28455210f, 0.08109243f, 0.11858907f, -0.08650157f, -0.02366724f, -0.00895173f, 0.04366746f, -0.01597989f, 
    0.13912024f, -0.21186978f, -0.28328747f, 0.03008004f, -0.23631248f, 0.01661664f, 0.04018969f, 0.01720288f, 
    0.15946208f, 0.20480977f, -0.02112149f, -0.07322542f, 0.04457936f, -0.04678492f, 0.06546106f, -0.08003682f, 
    0.10422219f, 0.04034927f, 0.21731521f, 0.01331285f, -0.66365832f, 0.05176995f, 0.12014726f, -0.10294532f, 
    0.11690079f, 0.17216606f, -0.25417989f, -0.07058763f, -0.07320801f, -0.02412230f, -0.09874089f, 0.09637097f, 
    0.10465764f, 0.08297011f, 0.08401117f, -0.05686596f, -0.05463013f, 0.09099415f, -0.00319069f, -0.03226030f, 
    -0.41725251f, 0.02597844f, 0.19896498f, -0.04269318f, -0.08939569f, -0.01838270f, 0.06063584f, -0.01159482f, 
    0.21548377f, -0.10322018f, 0.01181185f, 0.00433271f, 0.14830761f, -0.02543821f, 0.07401434f, -0.06777744f, 
    0.05269327f, 0.08337219f, 0.32745573f, 0.12553108f, 0.21780753f, 0.36763889f, -0.50857192f, 0.08058845f, 
    0.27617124f, 0.03191058f, 0.23742670f, 0.35762289f, 0.07082982f, 0.23435065f, 0.00315257f, 0.03658986f, 
    -0.10893000f, -0.04064135f, 0.02640522f, 0.25211447f, 0.11091696f, 0.01031567f, -0.02489387f, 0.16297586f, 
    -0.04595377f, 0.35208282f, -0.21485235f, -0.02110541f, -0.05935476f, -0.16467117f, 0.09451306f, -0.23764800f, 
    0.01622591f, 0.14305022f, 0.32108173f, 0.16827030f, 0.12072232f, 0.06318267f, -0.01990614f, 0.10241127f, 
    0.15748137f, -0.08300493f, 0.20717080f, 0.30614543f, 0.02533094f, 0.02621673f, -0.20229743f, 0.01497276f, 
    0.16684358f, 0.00909518f, -0.04932155f, -0.02265788f, -0.03131483f, 0.04237195f, -0.10989890f, -0.08637461f, 
    -0.04345602f, 0.07984146f, -0.16733192f, 0.14814009f, -0.01352748f, 0.18655342f, 0.02537975f, -0.06498893f, 
    -0.20465825f, 0.11628801f, 0.22415869f, -0.09456167f, -0.13451186f, 0.10342652f, -0.00283479f, -0.25697884f, 
    0.21022829f, 0.26762891f, 0.01932592f, 0.11010062f, -0.09984151f, 0.01670466f, -0.01545311f, -0.05642965f, 
    0.09257740f, 0.06573223f, 0.10095325f, 0.12008713f, -0.23832694f, -0.10281508f, -0.12917945f, -0.31711814f, 
    0.12981477f, -0.01311461f, -0.03663238f, -0.11257021f, -0.01907304f, 0.03281168f, 0.01824632f, -0.16739802f, 
    0.03675174f, 0.07704063f, -0.02119732f, 0.00567451f, 0.20204125f, -0.03712606f, -0.02120201f, 0.11780032f, 
    0.00894345f, 0.02209749f, -0.06309570f, -0.05447301f, 0.04460845f, 0.04129947f, -0.01643484f, -0.02162173f, 
    -0.04974901f, -0.00214058f, -0.00241322f, 0.01112849f, 0.02692445f, -0.01527122f, 0.00256695f, -0.01332163f, 
    0.01585068f, 0.00135383f, -0.04086662f, 0.02528943f, -0.07630714f, 0.00327556f, -0.04537601f, -0.00714353f, 
    -0.09065919f, -0.03110206f, -0.02789953f, 0.03407484f, -0.01578709f, 0.00352659f, 0.02557443f, 0.01552496f, 
    0.02652460f, -0.04621530f, -0.02610538f, 0.02302293f, 0.00478193f, -0.03620194f, -0.05276826f, 0.01855842f, 
    -0.01137973f, -0.02246184f, 0.07539862f, -0.04901127f, 0.04748049f, 0.00229349f, -0.02936962f, 0.00354908f, 
    0.04348671f, 0.00448141f, -0.03992203f, 0.03305669f, -0.03339737f, -0.01910022f, -0.02889452f, 0.00751991f, 
    -0.01412085f, -0.00779902f, 0.00857536f, -0.02503856f, -0.00366494f, -0.07479659f, -0.08715515f, 0.00477225f, 
    -0.05867625f, -0.05900256f, -0.00150207f, 0.04054979f, 0.00107883f, -0.01395729f, -0.00822475f, 0.01102565f, 
    -0.01009300f, -0.06109287f, 0.02822539f, -0.05317825f, 0.00374633f, -0.05633790f, 0.04491585f, -0.01153639f, 
    0.02543414f, 0.05129835f, -0.06103209f, -0.06574152f, -0.00754889f, 0.00561835f, -0.03470525f, -0.02724495f, 
    -0.06904771f, 0.01662132f, -0.03421278f, 0.03826840f, 0.02171919f, -0.00269237f, -0.02938214f, 0.03763280f, 
    -0.00701274f, -0.04364695f, -0.01219287f, -0.07323532f, -0.02971120f, -0.02042018f, -0.04640647f, -0.07233498f, 
    -0.07356081f, -0.02708818f, 0.01494644f, -0.05391972f, 0.01236106f, -0.00376572f, -0.00116812f, -0.03864403f, 
    -0.01145319f, 0.01505230f, 0.00156613f, -0.07719187f, 0.03890008f, -0.05748710f, -0.01903538f, -0.05595602f, 
    0.02005895f, -0.01784408f, -0.07203450f, 0.01434785f, 0.04055169f, -0.03380427f, 0.00343549f, -0.00219099f, 
    -0.07364546f, -0.07886626f, -0.00501801f, -0.02712142f, -0.02430901f, -0.01971698f, 0.04043344f, -0.05289509f, 
    -0.01120391f, -0.04039792f, 0.04632610f, -0.02426823f, 0.03624410f, -0.03725514f, -0.06841108f, -0.01736073f, 
    0.00190123f, -0.03995658f, 0.02268167f, -0.01810019f, -0.02960655f, -0.08133719f, -0.04915654f, -0.02176338f, 
    -0.00285189f, 0.05065544f, 0.06514572f, -0.02811305f, -0.00856026f, 0.03789373f, 0.04157679f, 0.01032117f, 
    -0.03833113f, -0.05793876f, -0.06396400f, -0.08529915f, -0.04409955f, -0.09375381f, -0.02083227f, 0.00291968f, 
    0.00350619f, 0.03728842f, 0.01011652f, -0.05179920f, -0.05085895f, 0.02203923f, 0.03701048f, 0.02423472f, 
    -0.06365448f, -0.00086578f, -0.02561098f, -0.01302400f, 0.00389631f, -0.07796133f, -0.10312708f, -0.05104656f, 
    -0.06726659f, -0.04373582f, -0.05093547f, -0.05793781f, -0.02220581f, -0.06411671f, 0.03149856f, 0.04115203f, 
    0.02807004f, -0.04352428f, -0.02168290f, 0.05421694f, 0.03007791f, -0.04607354f, -0.00501306f, -0.06128658f, 
    -0.07054774f, -0.00342144f, -0.04502343f, -0.00021398f, -0.07583942f, -0.07845265f, -0.05171983f, -0.02353599f, 
    -0.03365576f, -0.02807822f, -0.05802846f, -0.02300581f, 0.03649832f, -0.03013302f, -0.04583236f, -0.05309433f, 
    -0.04928555f, -0.03846626f, -0.06026490f, 0.01181771f, -0.05494304f, -0.05839888f, -0.07197629f, 0.01243733f, 
    -0.06481214f, 0.02670637f, -0.02768301f, -0.01964919f, -0.05846473f, -0.03899518f, 0.00459335f, -0.04273531f, 
    -0.02444740f, -0.00772931f, -0.07089675f, -0.04651982f, 0.03300757f, 0.01892495f, -0.01995776f, -0.05207579f, 
    -0.05532240f, -0.01015008f, -0.05360537f, -0.06852049f, 0.00776883f, -0.03067979f, -0.06413559f, -0.06604975f, 
    -0.02684028f, 0.02227923f, -0.03641393f, -0.05176770f, -0.03006850f, -0.04545522f, -0.07560966f, 0.01799317f, 
    -0.00153887f, 0.00917666f, -0.03325741f, -0.05737842f, -0.02801264f, -0.02680620f, -0.06020805f, 0.03214128f, 
    0.01359208f, -0.03813583f, 0.03719255f, -0.01934412f, 0.03743909f, 0.03175813f, -0.04507626f, -0.03333812f, 
    0.02768173f, -0.01082726f, 0.01850555f, -0.02214701f, -0.02585620f, 0.02682266f, -0.02915702f, -0.03550289f, 
    -0.02698441f, -0.02985398f, -0.03498745f, -0.07622094f, 0.01516649f, 0.00035209f, 0.00303758f, 0.05755603f, 
    -0.04682617f, -0.01915373f, -0.05880845f, -0.05050436f, -0.00178373f, 0.04486529f, -0.05024971f, 0.01669744f, 
    0.02564500f, -0.03257566f, 0.04008735f, -0.03807777f, -0.00400322f, -0.03537921f, -0.02197501f, -0.04781377f, 
    -0.01699122f, -0.04714185f, -0.00534656f, -0.06173789f, 0.00556977f, 0.03180221f, -0.04265703f, -0.01584980f, 
    -0.01544571f, -0.06579465f, -0.01373477f, -0.00589350f, -0.03587196f, -0.05740431f, 0.03386806f, -0.05383159f, 
    -0.05520367f, -0.03200257f, -0.05858724f, -0.02122925f, 0.00581409f, -0.03004184f, -0.05653284f, 0.01507879f, 
    -0.03609992f, 0.00894465f, -0.03734992f, 0.02106441f, 0.04324649f, 0.01829495f, 0.01390634f, 0.02541978f, 
    0.04073559f, 0.04290481f, -0.05226926f, 0.00392599f, -0.06064174f, -0.00009461f, 0.04652643f, 0.01769372f, 
    -0.02653566f, 0.04763474f, 0.00932452f, 0.04154308f, 0.02422629f, 0.04185298f, -0.06126375f, 0.03522986f, 
    -0.05617746f, 0.02996817f, -0.01871566f, -0.02992974f, 0.02731589f, 0.03545200f, -0.03682133f, -0.05757327f, 
    0.05436678f, 0.02158906f, 0.04667905f, 0.00867447f, -0.02549573f, 0.04121112f, -0.04920842f, -0.04176440f, 
    0.03229698f, -0.01004329f, 0.00847630f, 0.00047570f, -0.03290293f, 0.00772836f, -0.01382856f, 0.02350845f, 
    -0.03707964f, -0.06304150f, -0.02502967f, -0.03348818f, -0.00198336f, -0.03653490f, -0.04713162f, -0.03723682f, 
    -0.05208663f, -0.04789963f, 0.00992488f, -0.01189848f, -0.04828874f, -0.06258647f, -0.05022878f, -0.05928550f, 
    0.03913613f, -0.01525455f, -0.00837975f, 0.02005114f, 0.04252156f, -0.02330239f, 0.04512863f, 0.03473254f, 
    -0.03548810f, -0.05855466f, -0.03529458f, 0.00505274f, 0.03615173f, 0.03275352f, -0.06009756f, 0.04704311f, 
    -0.03621158f, 0.01911622f, 0.02610592f, 0.04199855f, 0.00233003f, 0.02027781f, 0.04513669f, -0.04227266f, 
    -0.02741310f, 0.01970014f, -0.03794751f, -0.01543313f, 0.00131011f, -0.00201357f, 0.04356584f, 0.01772184f, 
    0.02413572f, -0.05837950f, 0.04119510f, -0.01947490f, -0.04052537f, -0.06152099f, -0.04847199f, 0.03735149f, 
    -0.03037963f, -0.01597250f, -0.04684844f, -0.01384383f, -0.01520533f, 0.04251457f, -0.05242827f, -0.02427720f, 
    -0.00986649f, 0.05398458f, -0.04319641f, 0.02708602f, 0.04880673f, 0.03196539f, -0.02107196f, -0.05826503f, 
    -0.01909932f, 0.03271486f, -0.00985444f, -0.01117458f, 0.02580736f, 0.02941626f, -0.04348382f, 0.00537477f, 
    -0.04962924f, -0.05078398f, -0.00038515f, 0.02627464f, -0.04569433f, -0.01850555f, 0.04085727f, 0.02414378f, 
    -0.01067250f, -0.03622141f, 0.04962226f, -0.04390882f, -0.01193486f, 0.01316478f, -0.01339750f, -0.03159030f, 
    0.03095027f, -0.00590868f, 0.00680367f, 0.02582569f, 0.01660095f, -0.01932177f, -0.00253744f, 0.04573799f, 
    -0.05741497f, -0.05098023f, -0.05698933f, -0.01617809f, -0.05341485f, -0.01090095f, 0.00484218f, -0.00748672f, 
    -0.04056255f, -0.06024614f, -0.01307705f, 0.01622452f, -0.04634914f, 0.01766130f, -0.04118474f, -0.02380039f, 
    -0.01444455f, -0.01014782f, 0.01512108f, -0.01244342f, -0.05926435f, -0.04645098f, 0.03699964f, -0.03769812f, 
    0.01258004f, 0.03430551f, 0.00951134f, 0.04003612f, 0.00825465f, -0.04336969f, -0.04741051f, -0.01011963f, 
    -0.04019859f, -0.03543664f, -0.02921693f, -0.02451781f, 0.01891156f, 0.02928947f, -0.00091528f, 0.02406681f, 
    -0.00735419f, -0.05192207f, -0.01646734f, -0.00117908f, -0.01221808f, 0.03390740f, 0.04444609f, 0.00128033f, 
    -0.01535608f, -0.04825461f, 0.02249661f, -0.00682574f, -0.05067354f, -0.03692417f, -0.03873874f, -0.01943838f, 
    -0.01968870f, 0.03222233f, -0.05403581f, 0.01238429f, -0.00349726f, 0.01412405f, -0.03046250f, 0.02274119f, 
    -0.05156561f, 0.01039861f, -0.05311261f, -0.04299587f, 0.00097502f, 0.02831329f, -0.03433578f, 0.02193459f, 
    -0.03933701f, -0.00105632f, 0.00740844f, 0.04525084f, -0.04201156f, -0.01443477f, 0.03089723f, -0.02468194f, 
    -0.03507777f, 0.02743161f, 0.04398759f, -0.00378735f, 0.03476870f, 0.02569276f, -0.02832367f, -0.03508517f, 
    0.01689906f, -0.02046272f, -0.02651084f, -0.01946481f, -0.04379838f, -0.00359637f, -0.03015536f, -0.04872281f, 
    -0.05748748f, 0.01056569f, 0.03384779f, 0.01388500f, -0.05990670f, 0.03450486f, -0.06284847f, -0.00685446f, 
    -0.04393594f, 0.01079505f, 0.00100541f, 0.02214428f, -0.03535095f, -0.05951834f, -0.01668264f, -0.00394419f, 
    -0.04711201f, 0.04159920f, 0.03450124f, 0.00107496f, 0.00989054f, 0.00363112f, -0.02976161f, -0.06014191f, 
    -0.05008902f, 0.03772485f, -0.01685423f, -0.05618164f, -0.06107404f, -0.03282807f, 0.03005373f, -0.06168087f, 
    -0.03874429f, -0.03378723f, -0.05016599f, -0.05990515f, -0.01121656f, -0.05503161f, -0.01930656f, 0.03796022f, 
    -0.03191653f, 0.02812147f, -0.05331587f, -0.06281805f, 0.02930475f, 0.03343144f, -0.00901853f, -0.01971123f, 
    0.01520037f, 0.01924785f, -0.04062798f, 0.01996396f, -0.01434333f, 0.00728243f, 0.03832057f, 0.03515117f, 
    -0.02449175f, -0.01558348f, -0.02830925f, -0.03273116f, 0.03854761f, -0.05557780f, -0.01719841f, -0.03783287f, 
    -0.05869121f, 0.01597113f, -0.02307479f, -0.00905675f, -0.02091634f, 0.01167090f, -0.00414871f, 0.00960516f, 
    0.03706147f, 0.01539770f, -0.01687675f, 0.01815958f, 0.04096249f, -0.04236700f, -0.05198349f, -0.00643778f, 
    -0.00293535f, -0.04666687f, -0.01527682f, -0.03835711f, -0.05488990f, 0.00912012f, 0.01343052f, -0.04340010f, 
    -0.03918916f, -0.05810180f, -0.06174008f, -0.02476093f, 0.01305697f, 0.01736864f, -0.05528254f, 0.02636611f, 
    -0.03974802f, 0.01580131f, 0.03116910f, -0.06024824f, -0.02173287f, 0.03696287f, -0.03205970f, 0.02765118f, 
    -0.01349519f, 0.01989889f, -0.00920131f, 0.04128458f, -0.02608504f, 0.00446092f, 0.03006053f, 0.02669365f, 
    -0.04804368f, -0.01176003f, 0.01987810f, -0.01203289f, -0.02323313f, -0.04178803f, 0.00139267f, -0.01625552f, 
    -0.05615177f, -0.00360948f, -0.00138190f, -0.03451397f, 0.01837402f, -0.03114476f, -0.00269480f, -0.04570491f, 
    -0.02351461f, -0.06163222f, -0.00457918f, -0.04175185f, -0.02313203f, -0.00351747f, 0.03879720f, 0.03590858f, 
    0.03746016f, 0.00915617f, 0.03059941f, 0.03244795f, -0.01667128f, 0.01767171f, 0.01573041f, -0.04320936f, 
    -0.00867599f, -0.05171690f, 0.01395051f, 0.03956485f, -0.05405799f, 0.02196115f, -0.04483646f, -0.00944827f, 
    0.02193487f, 0.05293311f, -0.00561950f, 0.03200830f, -0.00367258f, 0.02100886f, -0.06032211f, -0.00121894f, 
    0.02857233f, 0.04594771f, 0.01528160f, -0.04338207f, 0.03476085f, -0.05798861f, -0.00900798f, 0.04095348f, 
    0.05093327f, -0.03621074f, 0.00204688f, -0.05375740f, -0.05956557f, 0.00950539f, -0.02415380f, 0.02738069f, 
    0.00556904f, -0.04720050f, 0.04398671f, 0.04274765f, -0.03475958f, 0.03020062f, -0.03098358f, 0.03238685f, 
    0.02886076f, 0.05447486f, -0.05050165f, -0.03195001f, 0.04038661f, 0.01568877f, -0.00923325f, -0.05292144f, 
    0.01738790f, 0.00702452f, 0.03035711f, -0.04166218f, -0.02627646f, 0.01957933f, 0.02691978f, 0.03511066f, 
    -0.05798401f, -0.03339599f, 0.02321893f, -0.05405044f, 0.00286210f, -0.00427359f, -0.03061675f, 0.01819238f, 
    -0.06488308f, -0.03491477f, -0.00338441f, -0.00231420f, 0.02064078f, -0.03624452f, 0.04700118f, 0.03433931f, 
    0.01575300f, 0.00439172f, -0.06359883f, -0.00064286f, -0.03606902f, -0.05664459f, 0.00155499f, -0.01479058f, 
    0.04339930f, 0.00659591f, 0.00018638f, 0.03778878f, -0.01114788f, -0.02754525f, 0.01780306f, -0.02313310f, 
    0.03002728f, 0.05061244f, -0.00290982f, 0.02941285f, -0.02777665f, -0.02657334f, -0.03653189f, -0.00891983f, 
    -0.01144613f, -0.02989939f, -0.02490837f, -0.03341911f, -0.05011864f, -0.00710826f, -0.04684528f, -0.03406332f, 
    -0.02228206f, -0.03861122f, -0.03901298f, -0.01740918f, -0.05740948f, -0.01367859f, 0.01648583f, 0.04440354f, 
    -0.05023447f, 0.02277354f, -0.05219220f, -0.03913404f, -0.04737782f, -0.02110511f, 0.04245567f, 0.04773231f, 
    0.00433064f, -0.01610617f, 0.01138534f, -0.01720905f, 0.04079732f, -0.03705877f, -0.05771612f, 0.02277425f, 
    -0.05291846f, -0.03564461f, -0.05300891f, 0.00794905f, 0.01370041f, -0.02559644f, 0.00796157f, 0.02142668f, 
    0.01295275f, -0.02639169f, 0.03080447f, 0.04856248f, -0.05326683f, -0.04109222f, -0.05673335f, -0.02498367f, 
    -0.01812478f, -0.01265152f, -0.00506612f, 0.01664853f, -0.02848732f, -0.01652649f, 0.01677439f, -0.05636290f, 
    0.01837487f, -0.04065992f, -0.01161520f, -0.03753721f, 0.01555927f, -0.01043356f, 0.00402718f, 0.02745763f, 
    -0.02239802f, -0.04048604f, 0.04602086f, -0.04363311f, -0.04519248f, 0.02223410f, 0.00336524f, -0.03724551f, 
    -0.02268221f, 0.04366469f, -0.01319077f, -0.04048358f, 0.02215970f, -0.06143621f, -0.02734565f, -0.04436182f, 
    -0.03026173f, 0.02144872f, -0.02952102f, -0.00810761f, -0.00394648f, 0.02739680f, 0.02774969f, 0.01671639f, 
    0.03450343f, 0.02086755f, -0.01646173f, 0.03774369f, -0.03052414f, -0.01650480f, -0.03991066f, -0.02260571f, 
    -0.01485431f, -0.03362659f, -0.02261100f, -0.06181212f, 0.03846552f, 0.00181991f, 0.00872112f, -0.05158996f, 
    -0.00526175f, -0.05078423f, -0.04785937f, -0.06201598f, 0.04012388f, -0.06100183f, -0.04752210f, 0.04183906f, 
    -0.02719889f, -0.04633277f, 0.02087130f, 0.02995611f, -0.06149023f, -0.06115951f, -0.00151195f, 0.04570346f, 
    0.02132409f, 0.04163339f, -0.04159606f, -0.02542528f, 0.04299905f, 0.03756180f, -0.05713300f, -0.02538303f, 
    0.01952285f, -0.00002388f, 0.01782991f, 0.01028430f, -0.04547065f, -0.00475476f, -0.00847995f, 0.02093768f, 
    0.04408133f, -0.00973626f, -0.00544980f, 0.01491067f, -0.05888594f, 0.04573339f, -0.05425043f, 0.01288807f, 
    -0.10894427f, 0.07057936f, 0.05852933f, -0.03137157f, -0.06805338f, -0.07559607f, -0.13847841f, -0.15867576f, 
    -0.11340997f, 0.01477985f, 0.20034769f, 0.10836778f, -0.03346887f, 0.07542437f, -0.17187545f, 0.01897752f, 
    0.05265420f, -0.07676247f, -0.07958356f, 0.13198116f, -0.14131930f, -0.43287534f, -0.39670715f, 0.05165634f, 
    0.00167274f, -0.05443624f, 0.22144105f, 0.10465464f, 0.01573181f, 0.16031702f, -0.04879561f, -0.05358095f, 
    0.00752717f, 0.02464724f, -0.00818267f, -0.02993735f, -0.03074556f, -0.04533573f, 0.02794470f, 0.10639309f, 
    0.17461737f, 0.19155453f, -0.03673155f, -0.63849050f, 0.16394809f, -0.12470317f, -0.00312705f, 0.06763063f, 
    0.04192785f, 0.04317585f, -0.07120296f, 0.09506459f, -0.05123604f, -0.17800651f, -0.19012374f, 0.12108047f, 
    0.36835381f, 0.24453607f, -0.25336137f, 0.25775748f, 0.00722004f, 0.37141368f, 0.27132902f, 0.29285195f, 
    -0.00666583f, 0.18654265f, 0.01765961f, -0.17037494f, -0.12754545f, 0.05221519f, 0.06576555f, -0.02690235f, 
    0.05943148f, 0.06084508f, 0.00724029f, -0.08336727f, 0.03971370f, 0.03504512f, 0.13213210f, -0.13430095f, 
    0.51128125f, 0.60990548f, -0.46675605f, -0.08906962f, 0.07601492f, 0.01905424f, 0.19918092f, 0.29999763f, 
    0.00768552f, 0.28906432f, -0.05065828f, 0.02606239f, -0.01457575f, -0.07884073f, -0.02080506f, 0.00603989f, 
    0.07293776f, -0.00309585f, 0.10239188f, 0.02791051f, 0.22465216f, 0.06216893f, -0.30241510f, 0.31654921f, 
    0.47123358f, 0.11054123f, 0.09868170f, 0.20858756f, 0.01392102f, -0.08630712f, 0.01474291f, -0.03367711f, 
    -0.05778975f, 0.01906038f, 0.11770757f, -0.00003522f, 0.18884473f, -0.13931894f, 0.06088935f, 0.00171402f, 
    -0.32148308f, 0.12810217f, -0.14642446f, -0.51051843f, -0.14402205f, -0.03896745f, 0.26770553f, 0.06250431f, 
    0.22066481f, 0.19185226f, -0.05970103f, 0.04360345f, 0.03350208f, 0.03059566f, -0.00003424f, -0.02957841f, 
    -0.06097826f, -0.07041235f, 0.02081645f, 0.09686856f, -0.10789872f, 0.29699722f, -0.26811051f, -0.02683659f, 
    -0.55740088f, -0.08925052f, -0.23021381f, -0.26885980f, -0.12044656f, 0.10597415f, 0.02266990f, -0.06162775f, 
    0.05637109f, 0.03013135f, 0.00074626f, -0.03785706f, 0.03155259f, -0.08757661f, 0.03856530f, 0.05625775f, 
    -0.27759734f, -0.41699496f, 0.06315627f, 0.18814395f, -0.47743526f, 0.09361283f, -0.14362313f, -0.03284974f, 
    0.00222913f, -0.01290038f, 0.01284393f, 0.00084115f, -0.05613205f, 0.07054547f, 0.00362986f, 0.02430898f, 
    -0.01059564f, 0.05731561f, 0.06063293f, 0.06756013f, 0.41091070f, 0.32352546f, -0.46325743f, 0.13335596f, 
    -0.64719111f, -0.06128185f, -0.08565822f, -0.37086248f, 0.10830170f, 0.28435513f, -0.00013084f, -0.03149167f, 
    0.07046738f, -0.00254852f, -0.01490314f, 0.00650071f, 0.05905399f, 0.12989263f, 0.07584547f, 0.03297533f, 
    0.15053333f, -0.02237313f, -0.41716951f, -0.32417297f, -0.23096964f, -0.20175481f, 0.05638952f, -0.22982596f, 
    0.03947102f, 0.03648200f, -0.01298972f, -0.08157233f, 0.04922684f, 0.04804386f, -0.16294664f, -0.11844713f, 
    0.03378928f, -0.00939065f, -0.01543602f, -0.11259307f, 0.05228572f, 0.28377330f, -0.31867898f, 0.13255875f, 
    0.12031966f, 0.08633415f, -0.14439756f, 0.21212965f, -0.02343646f, 0.06768350f, 0.00036611f, -0.01785301f, 
    -0.01159036f, -0.01605798f, -0.02461837f, 0.02712724f, 0.16577628f, -0.04381505f, 0.16231072f, 0.03089297f, 
    -0.16741814f, 0.01616691f, 0.32410210f, 0.02851198f, 0.06175557f, -0.14672087f, 0.04801408f, -0.18989752f, 
    -0.06624289f, -0.02722606f, 0.10357614f, -0.18259412f, 0.08492088f, 0.18654640f, -0.07205847f, 0.29570571f, 
    0.13703312f, 0.11154354f, -0.19513071f, 0.00022607f, 0.01047627f, 0.17569128f, 0.03952833f, 0.01573331f, 
    0.07209674f, 0.06814018f, 0.03876277f, 0.08506912f, -0.04438047f, -0.07121649f, 0.15922946f, 0.17223470f, 
    -0.01086682f, 0.03963372f, -0.00343848f, 0.04601688f, 0.02783834f, -0.10056257f, 0.01270240f, 0.04866995f, 
    -0.68733072f, -0.04063648f, -0.14707945f, -0.13023300f, -0.52363849f, 0.03440418f, -0.04051926f, 0.00620477f, 
    0.02426300f, 0.15174390f, -0.04744526f, -0.13766544f, 0.01092259f, 0.01310755f, -0.07033674f, -0.09672619f, 
    -0.02531829f, -0.02728345f, 0.13233162f, 0.06395691f, 0.25782356f, -0.00322695f, 0.12732857f, 0.22871704f, 
    0.25689000f, -0.02653286f, 0.13118638f, -0.03040510f, -0.09547823f, -0.09548353f, 0.05912936f, -0.05202752f, 
    0.03718254f, -0.05943260f, 0.15975390f, -0.01401668f, -0.15388423f, 0.00680708f, -0.11139370f, -0.02377087f, 
    0.05501238f, 0.04914783f, -0.03259593f, 0.05150224f, -0.01020732f, 0.04254356f, 0.03690720f, -0.00121716f, 
    0.05599082f, 0.04796022f, -0.02799843f, -0.00948200f, -0.01947541f, 0.01294184f, 0.00890607f, 0.04403188f, 
    0.02112457f, 0.04296508f, -0.01882182f, 0.01113913f, -0.02629940f, 0.01452304f, -0.00112073f, 0.00129175f, 
    -0.03690261f, -0.04657234f, -0.01239212f, -0.02779563f, -0.03149272f, 0.03313235f, -0.03963071f, -0.00657761f, 
    -0.02969445f, -0.00968528f, 0.03078735f, -0.05732386f, -0.04719329f, -0.01830532f, 0.04319890f, -0.04955385f, 
    -0.05091581f, 0.02075340f, -0.00750361f, 0.02554943f, -0.02829425f, -0.04814223f, -0.03444931f, -0.05208623f, 
    -0.05226959f, 0.01608874f, 0.00541201f, -0.01780373f, -0.05839914f, -0.02084427f, 0.01531624f, -0.01637224f, 
    -0.04466549f, -0.00748942f, -0.05163155f, 0.05011909f, 0.03884045f, -0.05026092f, -0.02184517f, -0.02840577f, 
    -0.00224888f, -0.05654928f, 0.02106922f, 0.01814000f, -0.03482445f, 0.03135970f, 0.01200691f, -0.05762574f, 
    -0.03344376f, -0.02077418f, 0.02350896f, 0.01641599f, 0.03880292f, 0.00811695f, -0.00095811f, -0.00463652f, 
    0.00200909f, -0.03731678f, 0.01349532f, -0.00951336f, 0.01314991f, 0.00628557f, 0.03757756f, 0.00967518f, 
    -0.01260298f, 0.00772202f, -0.03588226f, 0.03591185f, -0.01677240f, 0.03835665f, -0.05560398f, -0.05287654f, 
    0.02020539f, -0.01204548f, -0.04148215f, 0.04462010f, 0.01627551f, -0.02367298f, 0.00441854f, 0.03357661f, 
    -0.03871214f, 0.04032150f, -0.03828016f, 0.02296526f, 0.04381403f, 0.00290409f, -0.04034815f, -0.03279366f, 
    0.03667356f, -0.06047944f, -0.01311303f, -0.01869961f, -0.01489576f, -0.01143632f, -0.03016139f, 0.03256083f, 
    -0.05371602f, -0.01407128f, -0.00323213f, 0.01158919f, 0.03018402f, 0.00260736f, -0.05046374f, -0.03062293f, 
    0.02747484f, -0.04437959f, -0.02985797f, 0.01772768f, 0.02759837f, -0.00295101f, -0.04216067f, -0.02668370f, 
    0.03038165f, -0.05386075f, 0.00965694f, 0.00814032f, -0.01436812f, 0.04220252f, 0.00222273f, -0.06055482f, 
    -0.02818359f, -0.06269087f, -0.04935255f, -0.00206654f, 0.00389319f, -0.05949055f, -0.00011429f, 0.01499146f, 
    -0.01961512f, -0.00008631f, 0.04209128f, -0.02391641f, -0.04852106f, 0.04732916f, 0.00206293f, -0.00083252f, 
    -0.02230006f, 0.02080079f, -0.00457099f, 0.00525422f, 0.02383882f, 0.00624051f, 0.04814716f, 0.00650633f, 
    0.04224334f, 0.04830971f, -0.01417936f, -0.05604088f, 0.00767733f, 0.04018797f, -0.02563177f, 0.00998442f, 
    0.03845492f, 0.01954634f, -0.03265414f, 0.03273362f, -0.01775681f, 0.02083972f, 0.01737844f, 0.04916002f, 
    0.03240727f, -0.05538076f, -0.03287567f, -0.05019091f, -0.03981695f, 0.00424099f, -0.00118904f, 0.04233852f, 
    -0.02746596f, -0.03893788f, 0.00285522f, 0.02616137f, -0.05940923f, -0.04852017f, 0.00532137f, 0.04847685f, 
    -0.02104225f, 0.02670095f, -0.04192413f, 0.01122948f, 0.04590400f, 0.00454170f, -0.04067386f, 0.03728005f, 
    0.05347228f, -0.03178039f, -0.05958249f, 0.00890789f, -0.02364094f, 0.03697034f, -0.02282585f, -0.02236781f, 
    0.01897462f, -0.00967215f, 0.00164645f, 0.03843812f, 0.00045922f, 0.04386508f, -0.04780344f, -0.02614247f, 
    0.02309346f, 0.04100983f, -0.00444148f, 0.02419000f, 0.00062983f, -0.03453659f, -0.00222647f, -0.06044558f, 
    -0.06095871f, -0.05062198f, -0.05685843f, 0.00927790f, 0.01444226f, -0.00416684f, 0.03154036f, -0.05920802f, 
    -0.02188705f, 0.00511945f, -0.03396316f, 0.05601038f, 0.02194062f, -0.04185145f, -0.03070177f, -0.03784444f, 
    -0.05661497f, -0.03959410f, -0.05846649f, 0.01608597f, 0.01662940f, 0.00540235f, -0.01598034f, -0.00726528f, 
    0.04695797f, -0.01123752f, -0.02827283f, -0.05122703f, -0.01813549f, 0.04063411f, -0.00754400f, 0.03026796f, 
    -0.02011508f, 0.01129880f, 0.01395055f, -0.00201280f, -0.02099628f, -0.02347598f, -0.03096659f, 0.02581361f, 
    -0.00436103f, 0.04012213f, -0.01156474f, -0.03752974f, -0.01166677f, -0.06239148f, -0.00585089f, -0.01668713f, 
    -0.05188129f, -0.05455843f, 0.04182797f, 0.04148080f, 0.04164681f, -0.03252893f, 0.02427343f, -0.01192287f, 
    -0.00421975f, -0.01400123f, -0.02695999f, -0.05776215f, -0.04430752f, -0.04933554f, 0.02008523f, -0.03182697f, 
    0.00431426f, 0.02420752f, 0.02771354f, -0.02656657f, -0.00813060f, -0.03127488f, -0.03389539f, 0.03174810f, 
    0.00641628f, -0.02639172f, 0.00058114f, -0.01597284f, -0.02737969f, -0.02876151f, 0.02050790f, 0.01186193f, 
    0.01353378f, 0.01215440f, -0.05301102f, 0.03398900f, -0.04164089f, -0.03082758f, -0.05649307f, 0.01564627f, 
    -0.03644222f, 0.02140518f, 0.02449300f, -0.01632394f, -0.03299885f, 0.00972659f, -0.04883676f, -0.03814899f, 
    0.01517354f, -0.02401754f, -0.00138164f, -0.02778226f, -0.01125986f, -0.02041404f, 0.02998757f, 0.03166876f, 
    -0.05081779f, -0.01356648f, -0.05888082f, 0.00472099f, -0.03064294f, 0.03718073f, 0.04655695f, -0.01684673f, 
    -0.03203613f, 0.01685184f, 0.04166804f, 0.01198197f, -0.04554141f, 0.01603276f, -0.02704413f, -0.00774571f, 
    0.01957579f, 0.04355447f, -0.02918474f, 0.03015366f, 0.03296902f, 0.04172720f, -0.03835918f, -0.02222014f, 
    -0.05986154f, -0.04585618f, 0.02589342f, 0.03502361f, 0.03582130f, -0.04079256f, -0.03730589f, 0.00113128f, 
    0.00526379f, -0.05167947f, 0.00027801f, 0.00254154f, -0.01183047f, 0.03854938f, 0.04311501f, -0.06250931f, 
    -0.05672786f, -0.04221061f, -0.02299929f, 0.04507403f, -0.03809257f, -0.06119909f, -0.05901737f, 0.00551359f, 
    0.00447923f, 0.04944951f, -0.00413085f, -0.02283412f, 0.02773266f, -0.01527455f, -0.01754675f, 0.05259402f, 
    -0.02971581f, -0.05826422f, -0.02699310f, -0.01510950f, -0.06188372f, -0.04241071f, -0.01608052f, -0.05596567f, 
    -0.00882417f, -0.02236799f, -0.02062470f, -0.00211662f, 0.04343508f, -0.00085428f, -0.03479791f, -0.02156959f, 
    0.02103335f, -0.05076420f, 0.01644642f, -0.04319895f, 0.02166720f, 0.03370132f, -0.03406014f, 0.01504235f, 
    -0.00190252f, 0.04487994f, -0.02936226f, 0.04955282f, 0.01072597f, -0.03349580f, -0.01857485f, 0.02984030f, 
    -0.05491761f, -0.00477775f, -0.06317122f, -0.02714614f, -0.01539901f, -0.03336656f, 0.00610572f, 0.01745223f, 
    -0.05580370f, 0.03749263f, -0.00837672f, -0.02404426f, 0.01171470f, -0.01616340f, -0.02698409f, 0.00183486f, 
    -0.04606661f, -0.05921596f, 0.00537087f, 0.04677321f, 0.01547780f, -0.00160568f, -0.02066109f, 0.04102559f, 
    0.03338028f, -0.02213078f, -0.02862233f, -0.03141911f, 0.01989461f, 0.04746533f, -0.04313285f, -0.03815544f, 
    -0.00504252f, -0.01533157f, -0.03278957f, -0.04377730f, 0.00524486f, 0.01775761f, -0.01581907f, 0.04752549f, 
    -0.04017901f, 0.01425583f, -0.02387860f, 0.03086793f, -0.02612864f, 0.01798874f, 0.03157700f, 0.03128235f, 
    -0.00011624f, 0.01155156f, -0.02082635f, -0.02103634f, 0.00827102f, -0.02932911f, -0.04421807f, -0.03451673f, 
    -0.06252398f, -0.02201607f, -0.01588247f, -0.01219058f, -0.04752506f, -0.01004295f, 0.01786576f, 0.01435594f, 
    0.00374039f, -0.02024858f, 0.01416424f, 0.01975996f, -0.04104771f, -0.04237121f, 0.01230499f, -0.06174002f, 
    -0.00878108f, -0.03640927f, -0.05095044f, -0.01089851f, -0.05665618f, 0.04223030f, 0.00667983f, -0.04216777f, 
    -0.04737263f, -0.02055617f, 0.02483578f, 0.02683376f, -0.06038936f, -0.01903841f, -0.00692378f, -0.01804529f, 
    -0.03160186f, -0.01720768f, -0.00712711f, 0.00295878f, 0.02806798f, -0.04959059f, -0.01282175f, 0.00995391f, 
    -0.05712618f, 0.00103318f, 0.01175358f, -0.01506776f, 0.01788618f, -0.00827460f, 0.01688371f, -0.05108275f, 
    -0.04326915f, -0.00497295f, -0.00352151f, -0.05325470f, -0.05672734f, -0.00789939f, -0.04269332f, 0.02503217f, 
    -0.00961412f, -0.00785346f, 0.00853447f, 0.04512810f, 0.02242600f, 0.01420364f, 0.02835887f, -0.00039576f, 
    0.01603496f, -0.02294475f, -0.04773409f, -0.03698388f, 0.04254601f, 0.01614535f, -0.01777016f, -0.06244288f, 
    0.02140894f, 0.04349211f, -0.02307697f, -0.04117159f, 0.04198020f, -0.06033590f, -0.04635008f, -0.00471635f, 
    0.02586946f, -0.01719594f, 0.01443054f, 0.02025744f, 0.01183148f, 0.02024904f, -0.01506193f, 0.04769802f, 
    -0.00569224f, -0.05859308f, 0.01487113f, 0.03965575f, -0.05858970f, -0.00472054f, -0.04195958f, 0.02924246f, 
    0.03879403f, 0.02289326f, 0.03043942f, 0.02896893f, -0.03438363f, -0.02426496f, -0.05527899f, -0.02981746f, 
    -0.01858494f, -0.01278250f, 0.04565238f, 0.00184599f, 0.02842665f, -0.05752950f, 0.02771621f, 0.01027370f, 
    -0.02094417f, -0.00263049f, 0.00273954f, 0.03350196f, -0.03420391f, -0.02905581f, 0.01474517f, 0.03673872f, 
    0.02597293f, 0.04126744f, -0.04871657f, -0.02678496f, -0.04191042f, -0.03817817f, -0.04570753f, 0.00199924f, 
    -0.04710671f, 0.01125664f, 0.02403255f, 0.01316942f, -0.03413747f, -0.05042857f, 0.01693265f, -0.03207169f, 
    -0.04514335f, 0.00759661f, -0.05886720f, -0.04828409f, 0.03501790f, -0.00807650f, -0.02591087f, -0.04627629f, 
    -0.01706105f, -0.04594717f, 0.00724370f, 0.04252728f, -0.06016081f, 0.04094989f, -0.01306894f, 0.02029512f, 
    -0.00537841f, 0.00491075f, 0.04736098f, -0.03643687f, -0.05167292f, 0.04679046f, -0.04522129f, -0.01698227f, 
    -0.05236068f, -0.00204720f, -0.04054908f, -0.01755656f, -0.03517226f, -0.04618252f, 0.01860852f, 0.01917153f, 
    -0.04096696f, -0.04227958f, -0.04791663f, -0.01897361f, 0.01472029f, 0.00449439f, -0.05401825f, 0.00601867f, 
    -0.04500785f, -0.04329904f, -0.03091876f, -0.05918898f, -0.05798556f, -0.02831402f, -0.03262352f, -0.00192444f, 
    -0.06382444f, -0.02131342f, -0.02726764f, -0.02256110f, -0.02511797f, 0.01099292f, -0.01689254f, -0.04663654f, 
    -0.00098455f, -0.01540330f, -0.04838055f, -0.06001952f, -0.03440550f, 0.02304856f, -0.00085183f, -0.01471559f, 
    -0.02445053f, 0.04132806f, -0.05123601f, 0.04140961f, 0.00770155f, -0.01293063f, -0.01596871f, 0.02038712f, 
    -0.04508759f, 0.02415325f, 0.03094462f, 0.03369197f, -0.06074784f, -0.03569947f, -0.06179214f, 0.01344730f, 
    -0.05595672f, 0.04080413f, 0.01767877f, -0.03776619f, -0.00368078f, 0.02402061f, -0.02039879f, -0.05441666f, 
    0.04415732f, 0.00244564f, 0.04502729f, -0.01968846f, 0.01971184f, 0.01989341f, -0.00695812f, -0.02616505f, 
    0.02023551f, 0.03984887f, 0.04534711f, 0.01904969f, 0.03882473f, -0.02404238f, -0.01193167f, -0.06108219f, 
    0.02830659f, -0.01617722f, -0.03293063f, -0.00632831f, -0.03203721f, 0.03879355f, -0.02334359f, -0.01914467f, 
    -0.05235975f, 0.02761667f, 0.01216983f, 0.02387609f, -0.03281792f, 0.01731864f, 0.04068997f, -0.00208788f, 
    0.01858649f, 0.00092895f, 0.00068885f, 0.03613678f, -0.02159514f, 0.01791353f, 0.01538222f, -0.02262758f, 
    -0.06302512f, -0.00901813f, 0.04592925f, -0.04201716f, -0.02591602f, 0.01183687f, -0.05552540f, -0.01339549f, 
    0.01811503f, -0.06184966f, 0.01686630f, 0.01766029f, -0.06267828f, -0.01784704f, -0.04746158f, 0.03731860f, 
    -0.05756691f, 0.01880644f, 0.03891310f, -0.05481209f, 0.02852234f, -0.00503087f, -0.02181387f, -0.00728358f, 
    0.03439373f, 0.00287158f, -0.03553760f, 0.00898719f, 0.01245973f, 0.00244120f, -0.00511387f, -0.06112704f, 
    -0.03750442f, 0.01205975f, -0.00525937f, -0.02659736f, -0.04602052f, 0.02177721f, 0.03378866f, -0.01849837f, 
    0.03769762f, -0.05920719f, 0.03888882f, 0.02956820f, -0.01364910f, -0.04572364f, -0.06021815f, 0.00569865f, 
    0.00967915f, 0.02123975f, 0.00560600f, 0.00548331f, 0.01326992f, -0.03636337f, -0.02852313f, -0.05416619f, 
    0.01858299f, 0.03941828f, 0.01610936f, 0.03996507f, -0.05334104f, 0.04117617f, -0.04583150f, -0.00842457f, 
    -0.01540689f, -0.05633455f, -0.03895048f, -0.03262934f, -0.01118866f, 0.00690117f, 0.01082119f, -0.00411403f, 
    0.02027376f, 0.01265853f, -0.04379679f, -0.00998602f, 0.00705838f, -0.03746274f, 0.04259807f, -0.05858345f, 
    -0.06052030f, -0.03285788f, 0.00105245f, 0.01693897f, 0.00768756f, 0.04795922f, 0.01128035f, 0.02338801f, 
    -0.04615416f, -0.05123438f, -0.00666442f, -0.01528480f, -0.05216376f, -0.05741318f, -0.03074925f, -0.03077238f, 
    -0.00688797f, -0.02498399f, -0.05488895f, 0.00313830f, -0.04682793f, -0.03026114f, -0.05778692f, 0.02610500f, 
    -0.03134711f, 0.00761830f, -0.00148516f, -0.05573020f, 0.03714813f, -0.02680799f, -0.03443919f, -0.05098622f, 
    0.01886802f, -0.00261020f, -0.01682180f, 0.02239916f, -0.05073122f, -0.03560293f, -0.01600412f, -0.01659380f, 
    -0.06555074f, -0.00800084f, 0.00178842f, -0.03718239f, -0.02270434f, -0.03618523f, 0.00415186f, -0.01337856f, 
    0.02133895f, -0.04677796f, 0.01888451f, 0.01291011f, -0.01678035f, -0.05923822f, 0.02490169f, -0.00926620f, 
    -0.04937845f, 0.01269461f, -0.06477966f, 0.00503343f, 0.02448818f, -0.02918409f, 0.01834554f, 0.01036051f, 
    -0.02240823f, 0.00192482f, 0.04220461f, 0.03588560f, -0.02684266f, 0.01477394f, -0.02870866f, -0.02940338f, 
    0.02656946f, -0.01331342f, -0.03596152f, -0.03371320f, 0.02019224f, 0.00288644f, 0.04541773f, 0.02006326f, 
    -0.05367572f, -0.03160498f, 0.02811191f, 0.02600839f, 0.02889643f, -0.04504463f, -0.01892173f, -0.02680839f, 
    -0.05882946f, -0.01351271f, -0.01457365f, -0.01506572f, 0.03118179f, -0.05960850f, 0.01305953f, -0.06571851f, 
    0.01072575f, -0.01852620f, -0.00118882f, -0.03366372f, 0.01083536f, -0.03547398f, -0.01532339f, 0.04160843f, 
    0.03385792f, -0.01126955f, -0.06075692f, 0.00926758f, 0.03807621f, -0.05694300f, 0.04564512f, 0.01650986f, 
    -0.06045363f, -0.00391375f, -0.00890916f, -0.02875356f, -0.04874165f, -0.04519330f, -0.05970537f, -0.05362460f, 
    -0.02769925f, -0.03605261f, 0.02208122f, -0.00086146f, 0.02979886f, 0.04411042f, -0.03801070f, -0.02272172f, 
    0.03138545f, -0.04221766f, 0.01698984f, -0.00292815f, -0.04002005f, -0.00662788f, 0.02227836f, 0.03341349f, 
    0.04356231f, -0.03242462f, -0.04845789f, -0.05002686f, 0.03756301f, 0.01193319f, 0.00617775f, -0.02116268f, 
    -0.04144499f, 0.02095050f, 0.02296504f, -0.02978473f, 0.04236005f, 0.04434973f, -0.01008898f, 0.03375847f, 
    -0.04102607f, 0.02289075f, 0.03919003f, -0.03982463f, 0.02709610f, 0.04234498f, 0.03774090f, 0.00511217f, 
    -0.05001249f, 0.02283010f, 0.03200270f, -0.05271038f, -0.03102339f, -0.02370140f, -0.02253020f, -0.05244374f, 
    -0.03070402f, -0.00201802f, 0.01622517f, -0.02416793f, -0.06103653f, 0.04614276f, -0.04165112f, -0.05735271f, 
    0.02025690f, 0.02155938f, -0.04402324f, -0.02680690f, -0.05958891f, -0.05342145f, 0.02498334f, 0.01314190f, 
    -0.01353064f, 0.02020205f, -0.03065541f, -0.02416574f, -0.02250275f, 0.00385678f, -0.02138094f, -0.00719550f, 
    -0.00690921f, -0.01353757f, 0.01869093f, -0.03019758f, 0.03957792f, -0.00213711f, 0.01113583f, 0.04547278f, 
    -0.02509998f, 0.01882602f, 0.00554089f, 0.00056949f, 0.00012833f, 0.00629981f, 0.02910620f, -0.00289001f, 
    0.01005111f, -0.04366972f, -0.03757734f, 0.00958963f, 0.04851854f, -0.04464612f, 0.01227257f, 0.03825925f, 
    0.01044203f, 0.03993852f, -0.05791419f, 0.03958646f, -0.04443449f, -0.04590178f, 0.00237673f, 0.02683441f, 
    0.02749738f, 0.04825740f, -0.02172981f, -0.03529898f, -0.03019212f, 0.05859748f, -0.05013020f, 0.03881782f, 
    -0.01507922f, -0.06092691f, 0.03910247f, 0.01700470f, -0.02737022f, 0.04282126f, -0.03433575f, 0.02717711f, 
    -0.04549165f, -0.02434814f, -0.05736082f, 0.03618541f, 0.02643770f, 0.04820799f, 0.02103197f, -0.05915022f, 
    -0.02550587f, -0.03617806f, 0.01490176f, 0.00923381f, -0.02879733f, -0.04656623f, 0.06087987f, -0.00179152f, 
    -0.02074051f, -0.03667881f, -0.03580967f, 0.03682045f, 0.02241203f, 0.03849673f, 0.03109895f, 0.01841189f, 
    -0.01451939f, -0.05863484f, -0.04127722f, -0.00456446f, -0.04778808f, -0.03725263f, 0.04383601f, 0.02769592f, 
    -0.01682921f, 0.00534721f, -0.02102171f, -0.04689233f, 0.05294231f, -0.04343966f, -0.04870277f, 0.05598876f, 
    -0.04727864f, -0.06085067f, 0.06009262f, 0.01286916f, 0.00997339f, 0.01044484f, -0.02656660f, -0.05374413f, 
    -0.04023792f, -0.04132308f, 0.00794807f, -0.00078277f, -0.00737514f, -0.01146379f, -0.01991849f, 0.02298321f, 
    0.04019138f, -0.01972985f, 0.04667700f, -0.02636406f, -0.04868238f, -0.03067447f, -0.02757417f, 0.03803432f, 
    0.03031593f, -0.03725859f, -0.00429027f, -0.03160235f, -0.03512667f, 0.02596942f, -0.05720324f, -0.02453909f, 
    0.04921793f, -0.02134038f, -0.01867641f, 0.01581831f, 0.03703761f, 0.01590487f, 0.04489953f, -0.05394408f, 
    -0.02027359f, -0.02221194f, 0.04115512f, -0.02181405f, -0.00981714f, -0.00071423f, -0.05766126f, 0.02594335f, 
    -0.03216996f, 0.03061571f, -0.01219665f, -0.03838330f, 0.01192643f, 0.03866833f, 0.03492684f, -0.02844271f, 
    -0.02452894f, -0.03584554f, 0.01114437f, 0.03487946f, 0.00530320f, -0.00560427f, 0.03947303f, 0.00199975f, 
    0.00063394f, -0.05313039f, -0.02193850f, 0.00969634f, -0.03423056f, -0.06041190f, -0.00429852f, -0.00317827f, 
    -0.01490983f, -0.01516011f, -0.01204854f, -0.04800310f, -0.03755214f, -0.04410605f, -0.03907724f, 0.00530822f, 
    -0.04216883f, -0.05928351f, -0.01246957f, -0.04522674f, -0.04130839f, 0.03030215f, 0.01609862f, 0.00972372f, 
    -0.04574566f, -0.01139179f, -0.05116135f, 0.03808067f, -0.00329254f, 0.01806874f, -0.04762420f, 0.03680320f, 
    -0.03373571f, -0.03924719f, 0.04902346f, 0.02110800f, -0.05063157f, 0.04529751f, 0.00972864f, -0.00775425f, 
    0.03940729f, 0.02628770f, -0.04006000f, -0.04199177f, 0.02575783f, -0.00319912f, 0.00851079f, -0.04838307f, 
    0.02026803f, -0.06148770f, -0.03470769f, -0.03224699f, 0.04359505f, -0.04134377f, -0.02348317f, 0.01510938f, 
    0.04322923f, -0.04153275f, -0.04316395f, -0.00561575f, -0.01918012f, -0.03834360f, -0.02302474f, -0.02241223f, 
    0.03036814f, -0.04979629f, -0.02999093f, 0.03782258f, 0.05124112f, 0.00111097f, -0.02457937f, -0.03438717f, 
    0.01259988f, -0.01624937f, 0.01649347f, 0.01908184f, 0.04435639f, -0.06039327f, 0.04029805f, 0.01124168f, 
    -0.02931208f, 0.04764911f, -0.05281544f, -0.02898206f, -0.06017900f, -0.04077261f, -0.02997373f, 0.01504854f, 
    0.01567863f, -0.04333213f, -0.00896475f, 0.02075796f, -0.04007185f, -0.00157508f, -0.00148947f, 0.05312904f, 
    0.03139063f, 0.03612101f, -0.00661973f, -0.03859280f, -0.01624936f, -0.04301551f, -0.03435980f, -0.05654383f, 
    0.04071644f, -0.02540847f, -0.00394514f, -0.01626795f, 0.04301143f, 0.04160924f, 0.06184321f, 0.01269739f, 
    -0.02428773f, -0.04193212f, -0.05534888f, 0.02253994f, -0.02033607f, 0.03224944f, 0.01815364f, -0.04356074f, 
    0.01225237f, -0.03139592f, -0.05441875f, 0.00507820f, -0.03236419f, 0.04928819f, 0.01410554f, -0.04331970f, 
    -0.03299501f, 0.01971025f, -0.02584080f, -0.01125964f, 0.03421982f, 0.03949514f, -0.05026765f, -0.05779853f, 
    -0.02581605f, -0.00359048f, -0.01603789f, 0.00066272f, -0.03400089f, -0.03171219f, 0.00206895f, 0.04622245f, 
    -0.02044796f, 0.01827262f, -0.05768999f, -0.04538751f, 0.03918643f, 0.04918276f, -0.01262528f, 0.02408240f, 
    -0.03138051f, -0.02122439f, -0.03309276f, -0.05383818f, -0.00513009f, -0.01317812f, -0.03555806f, -0.02199712f, 
    0.00224605f, -0.04779336f, -0.03834658f, 0.04686501f, 0.03624685f, -0.02675617f, 0.04071270f, 0.03006559f, 
    0.01091221f, 0.01633472f, 0.04754844f, 0.03996873f, -0.00141145f, 0.04252093f, 0.00424780f, 0.02177298f, 
    0.04138104f, -0.04355927f, -0.04694486f, -0.03072857f, 0.04008058f, -0.00286831f, -0.05758082f, 0.05220317f, 
    0.04488315f, -0.01310755f, -0.04159943f, -0.00722318f, 0.01787390f, 0.00725214f, -0.04384080f, -0.04447288f, 
    -0.02184417f, 0.04200159f, -0.05795553f, -0.00277830f, 0.00453125f, 0.04155483f, -0.06076669f, -0.02370131f, 
    0.01521347f, 0.02582559f, 0.03081223f, -0.03139375f, -0.02995350f, -0.01565041f, 0.00900233f, 0.04372350f, 
    -0.03471313f, 0.01574406f, -0.01851047f, -0.02936440f, -0.06109998f, -0.03035167f, 0.01476427f, 0.00448182f, 
    -0.05700057f, 0.04171410f, 0.03285783f, -0.04638895f, 0.04914868f, -0.02846466f, -0.05959099f, -0.03172249f, 
    0.01838316f, -0.06059166f, -0.00031968f, -0.01750785f, -0.04342368f, -0.00557270f, 0.02039441f, -0.04602841f, 
    -0.01600143f, -0.05760701f, 0.04812575f, -0.01538134f, 0.01103730f, -0.03624862f, 0.01499502f, -0.01815635f, 
    -0.04902507f, -0.02715819f, 0.03304897f, 0.01280003f, 0.04517820f, 0.01330087f, -0.01861432f, -0.04412564f, 
    0.03646167f, 0.04271936f, -0.04313620f, -0.02832459f, 0.00185622f, 0.05351319f, 0.04041833f, -0.04293738f, 
    0.04590568f, 0.04947173f, -0.01277764f, 0.01173943f, 0.00167670f, 0.00704336f, -0.01741819f, -0.03192653f, 
    -0.03605772f, 0.02044023f, 0.01379141f, 0.00880410f, -0.04059596f, 0.01526360f, -0.05252784f, -0.04530548f, 
    -0.03206993f, 0.00839644f, -0.03442890f, -0.00714140f, -0.05561796f, 0.02382915f, 0.01806454f, -0.01490621f, 
    0.02418872f, -0.02647502f, 0.02220744f, -0.04610018f, -0.00357802f, -0.03553226f, -0.01768082f, -0.03282357f, 
    0.04285923f, -0.01942579f, -0.00837142f, -0.00816020f, 0.00359306f, -0.05326354f, -0.02122513f, -0.00434480f, 
    0.04640857f, -0.05981294f, -0.04495324f, -0.03092957f, -0.02070777f, -0.01860367f, 0.02684247f, -0.03810093f, 
    -0.03794235f, -0.00493390f, -0.04458849f, -0.02286504f, -0.03067763f, 0.00736830f, -0.01443710f, 0.01972368f, 
    0.00456865f, -0.00330382f, 0.04899904f, 0.01975215f, 0.02067631f, -0.03842225f, -0.05658763f, -0.00681239f, 
    -0.05078897f, 0.01029026f, 0.03848482f, -0.00444997f, 0.00334225f, -0.01381989f, -0.02797890f, 0.01983350f, 
    0.01252798f, -0.00717858f, 0.00029621f, 0.00467733f, -0.01851087f, -0.02373328f, 0.00138704f, -0.00912619f, 
    0.04202212f, -0.03787359f, -0.04856398f, 0.01105605f, -0.03023590f, -0.00490762f, -0.01678288f, -0.04363434f, 
    -0.03740205f, -0.05962353f, -0.00513433f, -0.01943796f, -0.00202825f, -0.02869189f, -0.02803405f, -0.02158141f, 
    0.00884168f, -0.00904903f, -0.05118651f, -0.03695168f, 0.02435816f, -0.00164815f, -0.00159106f, -0.02919978f, 
    -0.02064594f, 0.02844612f, 0.01395043f, 0.03639257f, -0.05917383f, 0.00356928f, 0.03630855f, -0.06122268f, 
    -0.00422093f, 0.03886217f, -0.04867725f, -0.04030298f, 0.00496475f, -0.03211103f, 0.04280500f, -0.05314532f, 
    -0.00439614f, -0.03665425f, -0.02651729f, -0.03579248f, -0.05560229f, 0.02158685f, 0.01950379f, 0.01380297f, 
    0.02128848f, 0.03378597f, -0.04807280f, 0.02014916f, 0.01343734f, 0.01316028f, 0.03104905f, -0.02106020f, 
    -0.00138663f, 0.03917662f, -0.02572154f, -0.04295750f, -0.01375462f, 0.03282997f, -0.02155606f, -0.02473334f, 
    -0.03672013f, -0.03406543f, -0.05561195f, 0.02905154f, -0.01579805f, -0.04299163f, 0.01797806f, -0.02856772f, 
    0.02152334f, 0.02898400f, -0.04543163f, 0.00702250f, -0.00360684f, -0.04732649f, -0.01084690f, 0.03449515f, 
    0.04921548f, 0.02389238f, -0.03431113f, 0.01835024f, 0.04035802f, 0.04742356f, 0.03026456f, -0.04086765f, 
    0.04263303f, -0.02507430f, -0.05986518f, -0.02923002f, -0.05478395f, 0.00492980f, 0.03265661f, 0.01581931f, 
    -0.30355063f, -0.08907600f, 0.05027349f, -0.11675033f, 0.04231191f, -0.07862016f, -0.00548024f, -0.09796615f, 
    0.07402157f, -0.04731409f, 0.09693368f, 0.13294874f, -0.03234082f, 0.10665612f, 0.06456330f, -0.17539605f, 
    -0.10429552f, -0.10209043f, 0.02063780f, -0.00329428f, 0.02280454f, -0.23307149f, -0.28432521f, 0.21278541f, 
    -0.45772153f, 0.37869570f, 0.03071731f, 0.16086909f, 0.16546653f, 0.11429769f, 0.07421522f, 0.17312796f, 
    0.05675114f, 0.04490938f, -0.01513743f, -0.09460273f, 0.20536382f, -0.10380318f, 0.13594952f, 0.08397426f, 
    0.13160078f, -0.12209012f, -0.45953619f, -0.42631036f, -0.01595847f, -0.13572256f, -0.18871823f, -0.05390039f, 
    -0.00004404f, 0.08536074f, -0.04531347f, 0.16357990f, -0.13855769f, -0.01492388f, 0.13770114f, 0.04737291f, 
    -0.01337291f, 0.02372777f, 0.23664236f, 0.09145259f, -0.29100364f, 0.04494473f, 0.29588372f, 0.32293040f, 
    -0.25801796f, -0.05241219f, -0.19313975f, 0.04055612f, 0.05570506f, -0.13321856f, -0.05425309f, 0.03165230f, 
    0.06018820f, 0.09387469f, 0.05856032f, 0.02308501f, 0.05968456f, -0.01969977f, -0.13409829f, 0.05651575f, 
    -0.22079709f, 0.05959788f, -0.35657907f, -0.09586343f, -0.20147982f, -0.05454759f, -0.01770115f, -0.17451835f, 
    -0.03440839f, 0.02884980f, -0.20900612f, -0.00775883f, -0.04750005f, 0.07467268f, -0.05021967f, 0.04137640f, 
    -0.01980248f, -0.03876589f, 0.17269929f, 0.11115362f, 0.49135044f, -0.07718485f, -0.25940886f, 0.10736595f, 
    0.28485945f, 0.17147860f, 0.07604660f, 0.03915448f, -0.01177947f, 0.11468790f, -0.01536713f, 0.07940253f, 
    -0.01784786f, 0.03013369f, 0.02899666f, 0.20124474f, -0.00511894f, 0.02982271f, 0.00342541f, 0.01147149f, 
    -0.16467367f, -0.06363057f, 0.51856315f, 0.34846911f, -0.24795046f, -0.24978741f, -0.29442680f, 0.01279906f, 
    0.07137521f, -0.05579098f, -0.19213894f, -0.09649529f, 0.04184569f, -0.14743382f, -0.07018323f, -0.04830835f, 
    -0.06578527f, -0.10215301f, 0.02672449f, -0.06193296f, -0.61168462f, 0.32483003f, 0.19067861f, 0.48596618f, 
    -0.29231077f, -0.22453476f, -0.16144526f, -0.03878037f, -0.14917339f, 0.09814736f, 0.10846294f, 0.02661257f, 
    0.08865323f, -0.01048356f, -0.03988333f, -0.00265693f, -0.05860942f, 0.07470637f, -0.14509414f, 0.10221876f, 
    -0.22798353f, 0.31543142f, 0.40087149f, 0.43222263f, -0.14050645f, 0.05136097f, -0.11705940f, 0.19858785f, 
    -0.12047359f, 0.22460920f, -0.06071853f, 0.03738310f, 0.03183193f, -0.00206704f, -0.00853320f, 0.08076478f, 
    0.10864386f, -0.04783231f, 0.06456848f, 0.21417394f, -0.27478755f, 0.03066676f, 0.58576375f, 0.22459157f, 
    -0.56921303f, -0.13229713f, -0.09739218f, -0.04243567f, 0.05139210f, -0.09244996f, 0.18594849f, -0.17854801f, 
    -0.13005973f, -0.08171452f, -0.17633034f, 0.07106601f, -0.02127989f, -0.11127357f, -0.00838821f, -0.04680870f, 
    0.19775093f, -0.17243575f, 0.32173657f, 0.26790166f, -0.19878522f, 0.10642809f, 0.06968582f, 0.09337658f, 
    0.34327698f, -0.01161410f, 0.04125761f, -0.08215800f, 0.12393022f, -0.13034075f, -0.04669586f, -0.00259558f, 
    -0.02668724f, -0.23732041f, -0.00150807f, -0.01424705f, 0.41732913f, -0.02055067f, 0.13061902f, -0.24850112f, 
    -0.21255836f, 0.18665998f, 0.15387911f, 0.10874403f, 0.01274188f, 0.01223603f, -0.09520961f, -0.07836283f, 
    0.14840665f, 0.14685351f, -0.06180117f, 0.03616188f, 0.14950317f, 0.02365506f, -0.05403917f, 0.04952791f, 
    -0.18239197f, -0.72889018f, 0.17223330f, 0.35997826f, 0.48924112f, 0.08857672f, 0.01582341f, -0.00392852f, 
    0.00690344f, 0.15123808f, 0.27437657f, 0.10036806f, 0.23410214f, 0.25534710f, 0.16379359f, 0.45503208f, 
    0.04606370f, 0.06961692f, 0.08293071f, 0.10392015f, 0.10167611f, -0.15018527f, -0.00875362f, -0.04866799f, 
    0.21869820f, 0.03521093f, 0.06601425f, -0.05612496f, 0.02708139f, 0.03068067f, 0.09325651f, 0.10702328f, 
    0.08172128f, 0.19052516f, 0.05192271f, -0.03717920f, 0.08397943f, 0.00548776f, -0.04128234f, 0.03573966f, 
    -0.28380188f, 0.04240856f, 0.33012930f, 0.45110527f, -0.38270241f, -0.20346044f, 0.14524847f, 0.01517019f, 
    0.04745544f, 0.06725004f, -0.04265462f, 0.04862596f, 0.03521189f, 0.00989758f, -0.05649650f, -0.01479199f, 
    0.13774702f, 0.02596929f, 0.03590766f, 0.04928471f, 0.13721254f, -0.08952300f, -0.13385710f, 0.10725120f, 
    0.22246002f, -0.08800847f, -0.12107888f, -0.01997617f, -0.12203652f, 0.00401778f, -0.08584379f, -0.08492120f, 
    -0.00137082f, 0.08624747f, -0.00116674f, 0.07179135f, -0.06451531f, 0.07366779f, 0.02070084f, -0.16198412f, 
    0.52540845f, 0.20480716f, 0.15753207f, -0.12708054f, -0.02666647f, -0.05635779f, -0.04119032f, 0.03706820f, 
    0.03273612f, -0.19396491f, 0.10673557f, -0.06006518f, 0.21448788f, -0.08276813f, 0.13164754f, 0.07085291f, 
    -0.31240875f, 0.11941417f, 0.02759887f, -0.08770316f, 0.37616947f, -0.29832014f, -0.17440416f, 0.28443834f, 
    -0.03640027f, 0.03076108f, 0.19106357f, 0.11796206f, -0.16843964f, 0.19342007f, -0.02997148f, -0.06376900f, 
    -0.16557193f, -0.05415908f, -0.08539866f, 0.09461331f, 0.17342925f, -0.22130440f, 0.19428092f, 0.43257874f, 
    -0.19946676f, 0.07025076f, 0.29687491f, -0.17477041f, -0.03963368f, 0.14284818f, -0.20490608f, 0.42769685f, 
    0.05082981f, 0.22036140f, -0.14037588f, -0.02818145f, 0.11683214f, 0.03458441f, -0.03904960f, -0.01891315f, 
    -0.02471277f, 0.18523556f, -0.34970060f, 0.35524911f, -0.06872901f, -0.09347736f, -0.19209391f, 0.30101001f, 
    0.14925063f, -0.13241744f, 0.12923652f, -0.14145468f, 0.10914572f, 0.30388251f, -0.06956201f, 0.10837749f, 
    -0.00581072f, 0.17717487f, 0.07991792f, 0.00922358f, 0.21512096f, 0.06574430f, 0.24145955f, 0.08510432f, 
    -0.53929621f, -0.11248744f, 0.25865269f, 0.26537895f, 0.38918456f, 0.01507386f, 0.10207724f, 0.34991965f, 
    0.00932767f, 0.30651310f, 0.04118545f, 0.01608359f, -0.16578414f, -0.09157751f, -0.17818171f, 0.12363062f, 
    -0.00447223f, -0.08702789f, 0.03739246f, -0.02015945f, 0.07983147f, -0.21812148f, -0.27553403f, -0.08506673f, 
    -0.07806076f, 0.02514010f, 0.00184475f, 0.27866700f, -0.10293001f, -0.03453278f, -0.01207068f, -0.04142736f, 
    0.09768119f, -0.08207231f, 0.02721486f, 0.10181519f, 0.13420710f, -0.04135448f, -0.10165480f, -0.00570497f, 
    0.27430439f, 0.20378114f, 0.14806189f, 0.26230064f, 0.28474435f, -0.10720976f, 0.21806335f, 0.06380551f, 
    0.09043788f, 0.32586047f, -0.07304325f, 0.14396814f, -0.03640548f, -0.00221700f, 0.11283802f, 0.10474826f, 
    -0.11936191f, -0.13762334f, -0.01573967f, -0.15383460f, 0.88533247f, 0.29938355f, 0.50068772f, 0.24628569f, 
    -0.22210309f, -0.18289348f, -0.22126198f, -0.38324857f, 0.07027767f, -0.00305940f, 0.05920532f, 0.14151090f, 
    -0.03424974f, -0.03325951f, 0.05600747f, 0.04104748f, -0.00327327f, -0.09303132f, 0.17150511f, 0.07274404f, 
    -0.35124007f, -0.21007803f, 0.14721085f, 0.15165021f, -0.10371194f, 0.01405420f, -0.13406837f, -0.02703644f, 
    0.02019488f, 0.00854000f, -0.01795290f, 0.12564257f, -0.04818922f, 0.09677649f, 0.04305489f, 0.07746280f, 
    0.06489927f, -0.02987779f, 0.05283995f, -0.00532472f, 0.43659389f, -0.28673235f, -0.17564283f, 0.35764447f, 
    -0.04287320f, -0.18613803f, 0.05558768f, -0.19796133f, 0.33388034f, -0.26438615f, 0.08375165f, 0.14613198f, 
    0.06190456f, 0.03277848f, 0.12538046f, 0.06214382f, 0.14601536f, 0.09478831f, 0.06714658f, 0.05376077f, 
    -0.46383503f, -0.01417242f, 0.22218062f, 0.22337779f, 0.16221000f, -0.01011983f, -0.18286748f, -0.13046670f, 
    -0.06109875f, 0.00332649f, -0.02902718f, 0.03340504f, 0.02849510f, -0.01404625f, -0.10539218f, 0.02420740f, 
    0.14532699f, 0.16157733f, -0.11545175f, 0.05362851f, -0.49401671f, 0.08628257f, -0.69808871f, -0.06417184f, 
    -0.10561745f, 0.04564947f, -0.14470661f, 0.31662783f, 0.15281828f, -0.33168462f, -0.10631578f, -0.06290698f, 
    -0.00887010f, -0.20954919f, 0.05211086f, -0.05442160f, -0.02017329f, -0.11701873f, 0.15031770f, -0.06076945f, 
    0.19134989f, -0.39504519f, 0.34269309f, -0.20085104f, 0.09342528f, 0.02422552f, -0.01612280f, 0.01208617f, 
    -0.23340061f, -0.14005537f, -0.01432193f, 0.01754123f, 0.17783295f, 0.05216229f, -0.04981819f, 0.00782712f, 
    -0.09669124f, -0.05852189f, -0.04765295f, -0.13370068f, -0.18060030f, -0.04163632f, 0.07779044f, -0.28595734f, 
    -0.25167412f, -0.11948960f, -0.16315219f, 0.18320502f, -0.02764812f, -0.20563100f, 0.06099814f, -0.18515114f, 
    0.10767679f, -0.06581332f, 0.15175487f, -0.10475228f, -0.16170557f, -0.04734835f, -0.07592278f, 0.00555909f, 
    0.15046601f, 0.00905684f, 0.29099268f, 0.19362119f, 0.17983101f, -0.03499849f, -0.06608377f, -0.06290083f, 
    0.14399812f, -0.04428365f, 0.01895185f, 0.12158798f, 0.04590484f, -0.00440796f, -0.04827677f, -0.10352326f, 
    -0.08328970f, -0.01680569f, 0.21513303f, -0.17804104f, 0.21486416f, -0.20075823f, 0.17310169f, -0.14085408f, 
    -0.15533036f, -0.13458733f, -0.00098811f, 0.01197993f, -0.01300659f, 0.17875378f, -0.01412728f, -0.07769827f, 
    -0.13953264f, -0.16586645f, -0.04549830f, 0.14447704f, -0.18075019f, -0.24112444f, -0.03356304f, 0.16618557f, 
    0.04301767f, 0.02587938f, 0.04622022f, 0.00693778f, 0.05343192f, -0.04492214f, 0.00364981f, 0.02670086f, 
    -0.03657286f, 0.02309971f, 0.00022662f, 0.00052689f, -0.02018501f, 0.03127763f, -0.00184136f, -0.00872594f, 
    -0.02277871f, 0.00234822f, 0.01279318f, -0.02209874f, -0.05839128f, 0.03129397f, -0.02496460f, -0.02272101f, 
    -0.04300682f, -0.05725883f, -0.03707239f, 0.00640990f, 0.02516673f, 0.01645345f, 0.04031042f, 0.02710897f, 
    -0.03850206f, 0.03506751f, -0.03725401f, -0.02590640f, -0.00934739f, 0.03882258f, -0.06095663f, -0.03046247f, 
    -0.05577441f, -0.04305362f, -0.05329034f, -0.03797591f, -0.03649145f, 0.00966469f, 0.01033509f, 0.04662418f, 
    -0.02268219f, -0.05296287f, 0.04549053f, -0.04850976f, 0.00914365f, -0.05914891f, 0.03500620f, -0.01576674f, 
    -0.02913104f, -0.03396658f, 0.04850853f, -0.05805278f, -0.02857054f, -0.03033795f, -0.00544716f, 0.01516296f, 
    0.00173707f, -0.00196501f, 0.04093260f, -0.00515038f, -0.04317954f, 0.01522467f, -0.03015842f, -0.01145570f, 
    0.04447745f, 0.02098993f, -0.01315982f, -0.01310688f, 0.00849786f, 0.04563317f, -0.00418362f, 0.00729686f, 
    -0.06053771f, 0.01065457f, -0.01193831f, 0.00450818f, -0.04692102f, 0.05050464f, -0.06035066f, -0.00671190f, 
    -0.00153806f, -0.01307139f, -0.03311590f, -0.05531587f, -0.05805233f, 0.05185180f, -0.01661859f, -0.03348211f, 
    0.04604436f, 0.00370837f, 0.04740501f, -0.01532511f, 0.04175274f, -0.03034151f, -0.05790742f, -0.02244358f, 
    0.02898158f, 0.03209250f, -0.01534797f, -0.05664229f, 0.03578863f, -0.00426455f, -0.03399509f, -0.01000210f, 
    0.02098060f, 0.01583775f, -0.00744621f, -0.01546362f, -0.03514715f, -0.03120623f, -0.03252957f, 0.04150784f, 
    0.04210614f, 0.00754433f, -0.04899379f, 0.00932253f, -0.02611152f, -0.04520828f, 0.05334497f, -0.03247339f, 
    0.00228816f, -0.03199941f, 0.00901088f, -0.00326114f, 0.04375196f, -0.02136063f, 0.01890262f, -0.04208004f, 
    -0.04453938f, 0.01480652f, -0.01212493f, 0.03768389f, -0.00493733f, 0.02064115f, -0.00730683f, -0.05428497f, 
    -0.04550729f, 0.03850353f, -0.04404934f, -0.04301070f, -0.04049797f, 0.03816070f, 0.01979850f, 0.03285145f, 
    0.05101944f, -0.02937763f, 0.02938351f, -0.03633911f, -0.04698255f, 0.01182279f, 0.04784766f, 0.03238342f, 
    0.03170354f, -0.05444025f, 0.00163309f, 0.03508605f, 0.04832134f, -0.04684358f, -0.00015001f, 0.00136520f, 
    -0.02394904f, -0.00539262f, 0.02214560f, -0.02362549f, 0.04014512f, -0.00981503f, 0.00196297f, 0.04258389f, 
    -0.04296834f, -0.03624463f, 0.03523136f, 0.03937437f, -0.00426376f, -0.03594315f, -0.01120418f, -0.05145826f, 
    -0.04570246f, 0.03213811f, -0.01377027f, 0.03221188f, 0.02130529f, -0.01950013f, -0.04602003f, 0.03374920f, 
    -0.04048156f, -0.04878185f, 0.02581344f, -0.01609474f, 0.01241272f, -0.05144175f, -0.00685680f, 0.02196388f, 
    0.01093761f, -0.00383240f, 0.03162248f, -0.01596745f, 0.02431461f, 0.02766073f, -0.00411531f, -0.01146754f, 
    -0.03152895f, -0.05367946f, 0.04750099f, 0.04194689f, 0.03537493f, 0.04052170f, 0.00973906f, 0.01327058f, 
    -0.05833171f, -0.02107027f, -0.01198836f, 0.02586987f, -0.05418665f, -0.04486800f, 0.00710786f, -0.04191101f, 
    -0.02691793f, 0.00758972f, -0.05339979f, 0.03349820f, 0.04316324f, 0.01947012f, 0.00965786f, -0.03245947f, 
    -0.02518457f, -0.03695694f, -0.02623428f, -0.04821916f, 0.03437850f, -0.05852094f, 0.03238650f, -0.04149961f, 
    0.00026434f, 0.04613933f, -0.05861397f, -0.01156262f, -0.02808788f, -0.01446599f, -0.00896164f, -0.05631768f, 
    -0.01465001f, -0.05189948f, -0.04257420f, 0.00116486f, -0.02357904f, -0.03436534f, 0.02305759f, -0.01339813f, 
    -0.00787448f, -0.05709258f, 0.02567710f, -0.04527449f, -0.04327204f, -0.03505487f, 0.01510555f, 0.01892981f, 
    0.03091557f, -0.04280685f, -0.03880433f, 0.00488173f, -0.02963541f, -0.03236253f, -0.01041206f, 0.03165768f, 
    0.02574269f, -0.03055664f, -0.02136508f, -0.02420305f, -0.00834511f, -0.01196567f, -0.01761773f, -0.00378813f, 
    -0.02173804f, -0.03815248f, -0.00143129f, 0.04675252f, -0.02570611f, -0.04910158f, -0.02269803f, -0.02074339f, 
    0.03967777f, -0.03732100f, -0.03571468f, 0.03855276f, -0.04015341f, -0.02586257f, -0.01403755f, -0.01515761f, 
    -0.02556139f, -0.02585575f, -0.05993554f, -0.05606614f, 0.00769967f, 0.02249381f, 0.04835442f, -0.03367120f, 
    -0.01729645f, 0.01488468f, -0.03447942f, -0.04739118f, -0.01282664f, 0.04430496f, -0.02956606f, -0.02466128f, 
    -0.02230286f, 0.00540744f, 0.03192737f, 0.00563877f, -0.03245421f, 0.00988024f, -0.04975717f, -0.01031959f, 
    -0.03843972f, 0.03992373f, 0.03195163f, -0.03159281f, -0.00147225f, -0.06106029f, -0.01276713f, -0.03282461f, 
    0.04037063f, 0.04483268f, -0.02154418f, 0.00475679f, 0.03104367f, 0.03833365f, -0.00997171f, 0.04185661f, 
    -0.01883653f, -0.00940203f, 0.03367155f, 0.02542107f, -0.01515817f, 0.00794055f, 0.02501868f, 0.04154685f, 
    0.03553678f, -0.00789193f, 0.03754814f, -0.03871313f, -0.05855377f, 0.03449697f, 0.02474005f, -0.04638030f, 
    -0.04658375f, 0.03639558f, 0.04759150f, -0.03655883f, -0.02266231f, -0.05986612f, 0.01042949f, 0.02054117f, 
    0.02298295f, 0.04400064f, 0.04230731f, -0.01468765f, -0.02832428f, -0.03586336f, -0.00773369f, 0.01573781f, 
    -0.01325462f, -0.05117239f, -0.00804109f, -0.03713318f, 0.01359943f, 0.04578250f, -0.01680148f, 0.05358056f, 
    -0.04610297f, -0.05188337f, -0.01057795f, -0.01348015f, -0.04204721f, -0.04932716f, -0.01439230f, -0.05614748f, 
    -0.00949883f, 0.03653977f, 0.02506520f, 0.03581103f, 0.00833563f, -0.03500659f, -0.03047077f, -0.03082519f, 
    -0.00926335f, -0.01347439f, -0.03154416f, 0.03241286f, 0.00253213f, 0.03481375f, 0.03966282f, 0.02692108f, 
    -0.04415527f, -0.04577950f, 0.00075831f, -0.00651904f, -0.03074246f, 0.01384782f, -0.00191068f, -0.00609604f, 
    0.02700576f, -0.04980962f, 0.00447405f, 0.00808922f, 0.00699219f, 0.02762020f, -0.01845400f, 0.04770489f, 
    0.04054122f, -0.04832299f, -0.05190550f, -0.02625976f, -0.03328609f, 0.04438861f, 0.02037838f, 0.00299328f, 
    0.02610972f, -0.06668589f, 0.04162120f, -0.04893507f, -0.01255222f, -0.00533574f, 0.02174907f, 0.02544601f, 
    -0.02361000f, 0.02470203f, 0.01645362f, -0.03792623f, -0.03731782f, -0.03881700f, -0.02741167f, -0.02295266f, 
    0.03632970f, -0.02248815f, -0.00210462f, 0.04616179f, 0.01568606f, -0.03261414f, -0.02090827f, -0.01471596f, 
    -0.02755799f, -0.03672142f, 0.00960958f, -0.02474594f, -0.01529504f, 0.00959851f, 0.01589960f, -0.04594023f, 
    -0.01787275f, -0.05148778f, -0.02600265f, 0.00549631f, -0.02253298f, -0.02144707f, 0.02617408f, 0.01879180f, 
    -0.02941038f, 0.04408321f, -0.01483868f, -0.03617968f, 0.01566805f, -0.02434146f, 0.02142427f, 0.03736131f, 
    0.00302501f, -0.03363754f, 0.03137310f, -0.05003031f, -0.01078738f, -0.03814555f, 0.00595620f, 0.03004300f, 
    0.04735205f, 0.02370097f, -0.06282621f, -0.00183763f, -0.04034128f, -0.02080796f, -0.03904653f, 0.04060549f, 
    -0.00885302f, -0.02791560f, 0.04651792f, -0.03174823f, -0.00876016f, -0.03577681f, -0.04162652f, 0.00795959f, 
    0.01347004f, -0.05544757f, 0.01494053f, 0.04446078f, 0.03179490f, 0.03185549f, -0.05998550f, 0.02785301f, 
    0.03673120f, -0.04046579f, -0.03042832f, 0.00476459f, -0.03783586f, 0.00972626f, 0.03839231f, -0.04441569f, 
    -0.04599409f, 0.03246915f, -0.03336537f, 0.03089998f, -0.00066620f, -0.02375232f, 0.02192602f, -0.03890905f, 
    -0.05213975f, 0.00513787f, 0.04746866f, 0.00853095f, 0.01863790f, -0.01804605f, -0.04730818f, 0.02183435f, 
    0.05933350f, -0.00845959f, 0.01754986f, 0.00107447f, 0.00122530f, -0.00373703f, -0.03173828f, 0.01340801f, 
    0.03136313f, -0.03833684f, 0.01176119f, -0.00602030f, -0.05487321f, -0.05437296f, -0.00936540f, -0.03836560f, 
    -0.03669735f, -0.00705488f, -0.04480201f, 0.04171452f, -0.00046843f, 0.00508151f, -0.05183614f, 0.03355311f, 
    0.04733743f, 0.03522317f, 0.00468994f, 0.00023349f, 0.04391059f, -0.01261115f, -0.04385979f, 0.02258225f, 
    0.02798932f, -0.04544194f, -0.05904573f, 0.04651563f, 0.00329020f, -0.02389991f, -0.01626954f, -0.04487608f, 
    -0.00272648f, 0.01399154f, 0.00521723f, 0.03026642f, 0.03408687f, -0.03709254f, 0.00412382f, -0.05347099f, 
    -0.02651622f, -0.00856364f, -0.05605459f, 0.00368808f, -0.01866550f, 0.01564712f, 0.00756183f, -0.04260714f, 
    -0.04735681f, -0.06409134f, 0.03843212f, -0.01454493f, -0.02430873f, 0.01404284f, 0.04526592f, -0.04415489f, 
    -0.01187683f, 0.02619204f, -0.04683891f, 0.00335414f, -0.05653242f, 0.01444718f, -0.04247902f, -0.01936254f, 
    -0.06163300f, -0.02220706f, 0.03802954f, -0.05706082f, 0.04201900f, 0.04071334f, 0.04025136f, -0.02963193f, 
    -0.03298333f, -0.04056806f, -0.05654886f, 0.05299585f, -0.00583256f, -0.05430881f, 0.01029410f, 0.01530605f, 
    -0.05262417f, -0.02277656f, -0.00470252f, 0.05477358f, -0.01868631f, -0.03323777f, 0.01161843f, -0.01261083f, 
    0.01358048f, 0.03130053f, 0.03579300f, -0.00817698f, 0.02771305f, 0.02331908f, -0.03999604f, 0.05004584f, 
    -0.02247566f, -0.01047716f, -0.04708838f, 0.03927081f, -0.04079895f, 0.04088276f, -0.05618521f, 0.00032496f, 
    0.14143284f, -0.04378847f, -0.26979697f, -0.00219074f, -0.17890120f, -0.02161234f, -0.09286588f, -0.18851490f, 
    -0.18770397f, -0.10052077f, 0.08183081f, -0.02435744f, 0.01827231f, 0.15652306f, 0.08463429f, -0.01187125f, 
    -0.06974287f, -0.10367432f, 0.02546434f, 0.06082074f, -0.16028127f, -0.09919575f, -0.03427291f, -0.03921647f, 
    -0.12704733f, 0.12094045f, 0.07559847f, -0.01752314f, 0.31397560f, 0.13783972f, 0.03138595f, 0.09654985f, 
    -0.04002820f, -0.03158908f, -0.11232419f, -0.08311787f, 0.09731244f, 0.04461470f, 0.00271878f, -0.02039072f, 
    0.40623444f, -0.07109760f, -0.53427088f, -0.79775727f, -0.29132164f, -0.02212699f, -0.32710361f, -0.06938025f, 
    -0.14739533f, 0.00540547f, -0.09078804f, 0.01863291f, -0.15793073f, -0.11013944f, -0.14814557f, -0.06801561f, 
    0.05692665f, -0.11600855f, 0.23541331f, 0.11337192f, -0.27302971f, 0.02500098f, 0.50587422f, 0.72858667f, 
    -0.15266354f, 0.21401975f, -0.08488753f, -0.07743216f, 0.07399697f, 0.03982797f, 0.12386606f, -0.02169211f, 
    -0.08796132f, 0.06309006f, 0.12525272f, -0.10852125f, 0.14336239f, 0.15181164f, -0.28956872f, 0.02019044f, 
    -0.31603968f, 0.20312926f, -0.04849492f, 0.05345387f, -0.16910018f, -0.02075221f, 0.06200501f, -0.37796158f, 
    -0.01800302f, 0.37910885f, 0.04041941f, -0.03223675f, 0.03970916f, -0.00150780f, -0.04457626f, 0.06677534f, 
    0.04278819f, -0.15677680f, -0.24336167f, -0.00562221f, -0.02378470f, -0.05477829f, -0.27102128f, 0.06349280f, 
    0.24440429f, 0.14614706f, 0.07267716f, -0.07308985f, -0.07724165f, -0.01461429f, 0.16235144f, 0.01004268f, 
    -0.13934690f, 0.04146651f, -0.07565269f, 0.14202654f, 0.06450931f, 0.08003109f, 0.16270390f, -0.12072412f, 
    0.40336597f, -0.13330102f, 0.04620229f, 0.12829706f, -0.01093429f, 0.09337112f, 0.09240422f, 0.07708538f, 
    0.45843562f, -0.06239551f, 0.08567099f, 0.11790878f, 0.03394571f, 0.04212485f, 0.03591656f, 0.03941543f, 
    -0.00144179f, 0.00821457f, -0.07811161f, -0.14202283f, 0.07348387f, 0.19832246f, -0.51075286f, 0.30594775f, 
    -0.18748040f, -0.00498203f, -0.17175822f, -0.05517999f, -0.09245259f, -0.37947753f, 0.15808830f, 0.07362407f, 
    -0.01610596f, -0.02266820f, 0.03499971f, 0.03607579f, 0.12650312f, 0.08518164f, -0.02710450f, 0.04571363f, 
    -0.49708903f, 0.54460150f, -0.05082284f, 0.65628701f, 0.02621106f, 0.34639588f, 0.02709252f, 0.23870733f, 
    -0.18910542f, 0.24817395f, -0.05825884f, 0.19037493f, -0.07646953f, -0.01592628f, 0.00571696f, -0.01671534f, 
    0.19284135f, -0.05547235f, -0.21954112f, 0.10014209f, 0.08210510f, -0.11306924f, 0.53216040f, 0.25857058f, 
    -0.35478088f, 0.01903584f, -0.03782374f, -0.08470190f, 0.34235483f, -0.31044400f, 0.35327092f, -0.11363547f, 
    -0.23380511f, -0.11496183f, 0.13741355f, 0.02297613f, 0.06942752f, -0.02705241f, 0.01128284f, -0.00227204f, 
    0.37322429f, -0.33684435f, 0.16091883f, -0.31306663f, 0.16134262f, 0.01296998f, 0.03638127f, 0.01855825f, 
    0.28685656f, 0.18473420f, 0.08964537f, -0.10563304f, -0.02448696f, -0.01687782f, -0.04192564f, -0.05218258f, 
    -0.01161684f, -0.16990979f, 0.03727118f, -0.02322931f, -0.45257202f, 0.09412514f, 0.00621071f, -0.02273983f, 
    -0.02232249f, 0.21670806f, 0.09472241f, 0.05999401f, -0.34820440f, 0.09838164f, 0.02395868f, -0.08586854f, 
    0.12485551f, 0.06774892f, -0.03120170f, 0.02625691f, -0.04225548f, -0.11842538f, -0.08927751f, 0.05005148f, 
    -0.02251424f, -0.09156681f, 0.08657011f, -0.03677766f, 0.33880171f, 0.00032560f, -0.03252847f, -0.22232257f, 
    0.21246651f, -0.04999591f, 0.01877196f, -0.07625651f, 0.08106469f, 0.03743387f, 0.01218656f, 0.18378611f, 
    0.05488412f, 0.10970997f, -0.03151859f, 0.11992697f, -0.13714777f, -0.01210926f, -0.13962695f, -0.18700255f, 
    -0.00635414f, 0.06062695f, -0.05255815f, -0.14458297f, -0.03912819f, -0.11202987f, 0.21776460f, 0.02763528f, 
    -0.01317056f, 0.03186198f, 0.08778642f, 0.15482216f, 0.05398828f, -0.09005652f, -0.04571096f, 0.02821717f, 
    0.16047600f, -0.31964949f, 0.04230563f, 0.31510177f, -0.01528628f, 0.01892741f, -0.04308552f, 0.25516632f, 
    0.24832508f, -0.00117022f, 0.07689217f, -0.02143583f, 0.16598268f, 0.00510357f, -0.08892948f, 0.08343200f, 
    0.04213968f, 0.01689363f, -0.13588671f, -0.02322682f, 0.21899721f, -0.05020529f, 0.00250775f, -0.06808869f, 
    0.39943972f, 0.01297881f, -0.05214493f, -0.22962682f, -0.04861367f, -0.09049587f, 0.10139289f, -0.03689690f, 
    0.00173890f, 0.02731981f, 0.01782705f, 0.10155743f, 0.08975879f, 0.01711252f, 0.16176681f, -0.18532591f, 
    -0.01147505f, 0.03267243f, 0.02109527f, -0.05493516f, 0.02854148f, -0.02614537f, 0.04998324f, 0.03267512f, 
    0.04456668f, 0.01189097f, -0.06004003f, 0.03447350f, 0.01620617f, -0.00595209f, -0.05132374f, 0.00303904f, 
    -0.05077451f, 0.03113282f, -0.01100958f, -0.00543011f, 0.01856517f, -0.03550524f, -0.04072549f, -0.02716376f, 
    -0.04159649f, 0.01373720f, -0.02282489f, 0.03355866f, 0.01202296f, -0.05913304f, -0.04675516f, 0.02991934f, 
    0.02144563f, 0.02183700f, 0.00905905f, 0.02176086f, 0.00746023f, 0.01163761f, 0.04433627f, -0.00195348f, 
    -0.06563620f, 0.01844086f, 0.01009637f, -0.05004102f, -0.01864836f, -0.04045691f, -0.00358302f, 0.03993031f, 
    -0.02972163f, 0.02035981f, 0.02554792f, 0.01996315f, 0.01464520f, -0.04919861f, 0.01747320f, -0.00394458f, 
    -0.03510091f, -0.06902896f, 0.04439380f, 0.00831058f, 0.00089655f, -0.02676064f, 0.02883198f, 0.02263894f, 
    0.01970006f, 0.04137337f, 0.02362743f, -0.01455879f, -0.00459726f, 0.01571453f, 0.02458923f, -0.01970517f, 
    -0.00269509f, -0.00133765f, 0.01129774f, -0.04806249f, -0.03269213f, 0.01243746f, 0.00478024f, -0.00458665f, 
    -0.04573233f, -0.04704816f, -0.02380675f, 0.00693464f, 0.01947277f, -0.00889709f, -0.05477205f, 0.02011974f, 
    0.01778185f, -0.02014315f, -0.03680406f, -0.01966337f, 0.01512650f, -0.01820499f, -0.07054424f, -0.02824291f, 
    -0.03488608f, 0.01143474f, -0.05331744f, -0.04593261f, -0.01338097f, -0.00219461f, -0.05291554f, 0.03259286f, 
    -0.04433923f, -0.00266433f, -0.04470199f, -0.05595355f, -0.02366700f, -0.02379890f, 0.04409607f, -0.04241597f, 
    0.01113817f, -0.05483960f, 0.03969963f, -0.00066527f, -0.03562394f, 0.02457209f, -0.00722038f, -0.01160841f, 
    -0.05750614f, -0.00546421f, -0.01717011f, 0.01503464f, -0.02896972f, -0.02984927f, 0.04224067f, -0.05998568f, 
    0.01782686f, 0.04703764f, 0.02608819f, -0.00171643f, 0.03571076f, -0.02099050f, -0.05703644f, 0.00856466f, 
    0.03752739f, -0.05628431f, -0.05957251f, -0.00411755f, -0.02388016f, -0.06059360f, -0.05340244f, -0.00493712f, 
    -0.02733024f, -0.01646886f, -0.05934678f, 0.04183168f, 0.00006712f, 0.02993826f, 0.04148810f, -0.05463537f, 
    -0.05295235f, 0.02176193f, 0.04950212f, -0.05314170f, 0.05004774f, -0.05741085f, -0.04243852f, -0.00836389f, 
    0.01161966f, -0.01212047f, 0.04119409f, -0.02619293f, -0.05010464f, -0.05268192f, 0.02663744f, -0.02995730f, 
    0.02395657f, 0.04124105f, -0.03185080f, 0.02799677f, 0.03302558f, -0.01681175f, -0.02582749f, 0.01768445f, 
    0.04037206f, 0.03250750f, -0.01429280f, -0.00556529f, 0.03931569f, -0.00072600f, -0.00122445f, 0.00066843f, 
    -0.05009650f, -0.02828629f, -0.03146268f, -0.05816445f, 0.01574115f, -0.04132681f, 0.00691971f, -0.04703070f, 
    0.02448709f, -0.05255607f, -0.04991307f, -0.02048384f, -0.03708545f, 0.00027912f, -0.01187356f, -0.03307198f, 
    -0.00999179f, 0.03635493f, -0.05012357f, 0.00201440f, -0.01140034f, 0.04394957f, -0.05545211f, 0.02234506f, 
    -0.03035021f, 0.03836211f, -0.04688414f, -0.00455591f, 0.00312381f, -0.01595374f, 0.00025205f, 0.01510119f, 
    -0.05315755f, -0.04744823f, 0.04418817f, 0.00802510f, 0.00209573f, 0.01415507f, -0.00851800f, -0.00586093f, 
    -0.03739015f, 0.04621658f, 0.04935655f, 0.01867304f, 0.01366631f, -0.02561128f, -0.00636190f, -0.05229625f, 
    -0.00381958f, -0.05550805f, 0.01148482f, -0.00066723f, 0.02371318f, -0.03979519f, -0.00202849f, -0.00563082f, 
    0.00689433f, -0.03323708f, -0.05428237f, -0.02413394f, 0.00341226f, 0.04079294f, -0.05831296f, -0.05686847f, 
    -0.01294905f, 0.04014948f, 0.04453938f, -0.01326674f, -0.05126858f, -0.03788554f, 0.04353246f, -0.00208594f, 
    0.04719618f, 0.04169337f, -0.01144010f, 0.02693444f, -0.03729282f, -0.00386418f, 0.02422486f, -0.01385120f, 
    0.00967925f, -0.02012442f, 0.01673873f, 0.00570197f, 0.02205293f, 0.04173651f, -0.05830434f, 0.02115481f, 
    -0.01410200f, -0.04559769f, 0.04522477f, -0.03508047f, 0.03746216f, -0.02254106f, -0.02196005f, -0.04780633f, 
    -0.00559722f, 0.03418274f, 0.02960808f, -0.06036280f, -0.02254304f, 0.01640829f, -0.02128240f, -0.02989503f, 
    -0.05316985f, -0.03540324f, 0.02905414f, 0.04885597f, 0.04031454f, -0.05776437f, -0.01704405f, 0.02672807f, 
    -0.01269029f, 0.01734116f, 0.04316253f, -0.04606174f, -0.03402087f, -0.01509973f, -0.01388191f, 0.02293157f, 
    -0.04285811f, -0.05872222f, -0.01388971f, 0.04008963f, 0.00578846f, -0.05195351f, -0.00597440f, -0.04381585f, 
    -0.05082531f, -0.01506510f, -0.01792454f, 0.03759992f, -0.01252283f, -0.04213843f, -0.05010530f, -0.05101707f, 
    -0.02837005f, -0.07696511f, -0.01274478f, -0.03480098f, 0.01710781f, -0.06236919f, 0.00825032f, -0.00214267f, 
    -0.07246357f, 0.01157623f, 0.02156933f, 0.01053134f, -0.01057638f, 0.04951726f, -0.02737859f, -0.04772040f, 
    -0.02025948f, 0.00719526f, -0.02306725f, -0.01939577f, -0.02490941f, -0.00082526f, 0.00963093f, 0.02133723f, 
    0.00494187f, 0.01907777f, -0.00231821f, -0.02819791f, 0.01406590f, -0.01816406f, 0.02003957f, -0.05063131f, 
    -0.02852250f, 0.01009325f, 0.01637939f, 0.02160487f, 0.00237935f, -0.07277028f, -0.03966852f, 0.02604114f, 
    -0.07541482f, -0.03920556f, 0.00068604f, -0.05582182f, 0.01658577f, -0.07357226f, -0.00646348f, 0.01744556f, 
    -0.01613472f, -0.03086261f, -0.00137649f, -0.06981928f, -0.04059672f, -0.05074031f, -0.06623681f, -0.01491122f, 
    -0.07382638f, -0.01512469f, 0.00786663f, 0.01850552f, -0.05552975f, -0.07545456f, -0.09202871f, -0.06651098f, 
    -0.03207809f, 0.03237477f, -0.02015481f, 0.04561913f, -0.03860388f, -0.02076771f, -0.00870681f, -0.01030171f, 
    0.00171045f, -0.06428436f, 0.02466683f, -0.00486778f, -0.05206664f, -0.05785468f, -0.08656918f, -0.02279787f, 
    -0.00133677f, -0.05558490f, 0.05457392f, -0.05190139f, -0.05762918f, -0.03374854f, -0.06919184f, -0.01379106f, 
    -0.07533655f, 0.04941242f, -0.01660168f, 0.02366367f, 0.01740997f, -0.08478481f, -0.02361031f, 0.00594328f, 
    -0.00377467f, -0.06164687f, -0.07777264f, -0.06407863f, 0.04960856f, -0.03064542f, -0.00822402f, -0.04471501f, 
    0.00619474f, -0.02684071f, -0.05414612f, -0.02655287f, -0.02103064f, -0.03479347f, -0.05774423f, -0.08781426f, 
    -0.01456639f, -0.07262044f, -0.03242974f, 0.03149961f, -0.03681478f, -0.03648081f, 0.01286961f, 0.02059973f, 
    -0.02072864f, -0.00381697f, -0.06081118f, -0.00430204f, 0.01164749f, -0.02366103f, -0.06092755f, -0.01905958f, 
    -0.03749614f, -0.03199925f, -0.00699297f, -0.02702816f, -0.01468300f, -0.07477155f, -0.06974757f, 0.02409723f, 
    0.00290709f, -0.01815770f, 0.01882442f, -0.08195479f, -0.02754888f, -0.02485083f, -0.05239500f, -0.01712062f, 
    -0.01996026f, -0.01532227f, 0.00292587f, -0.01146593f, -0.04990878f, -0.03560616f, -0.03351766f, 0.02496050f, 
    -0.02109139f, -0.00600471f, 0.00552570f, -0.05653616f, -0.03618170f, -0.06596708f, -0.00626674f, -0.03486408f, 
    -0.03178202f, -0.03355948f, -0.02306895f, -0.02314799f, -0.04634259f, 0.01655368f, -0.03596653f, 0.03135299f, 
    -0.05081764f, -0.02269255f, -0.02897727f, -0.05026370f, -0.07720358f, -0.04526862f, -0.06379353f, -0.07893635f, 
    -0.05846285f, -0.00417952f, -0.05542740f, -0.03203896f, -0.03421538f, 0.03011861f, -0.06121299f, -0.05977511f, 
    -0.00402474f, -0.00355295f, 0.01196711f, -0.02636746f, 0.01349725f, 0.01078000f, -0.05228144f, -0.01514075f, 
    0.03797098f, -0.04127293f, 0.01576193f, 0.01724979f, 0.02391368f, -0.00643324f, 0.00569705f, -0.00955844f, 
    -0.01293098f, -0.03569175f, -0.07738663f, -0.00302409f, -0.04753105f, 0.01431359f, -0.02275137f, 0.01055239f, 
    -0.05335688f, 0.03520197f, -0.05974931f, 0.00541780f, -0.04898896f, 0.00158701f, -0.04055486f, -0.04081025f, 
    -0.03618351f, -0.08946969f, -0.04804866f, -0.07448516f, -0.07052272f, -0.04316841f, 0.04961241f, -0.07678499f, 
    0.00066699f, -0.02934710f, -0.06386294f, 0.01053450f, -0.02861763f, 0.00781556f, -0.04066776f, -0.07856796f, 
    0.00818496f, -0.04090600f, -0.04009045f, -0.08544637f, -0.03928777f, -0.03681390f, -0.02111515f, -0.00364717f, 
    -0.06329130f, -0.01192136f, -0.07374211f, 0.02733526f, 0.00917336f, -0.00457909f, -0.03721316f, -0.06365638f, 
    -0.07585983f, 0.00038790f, -0.07976034f, 0.00941959f, -0.08260489f, 0.04830517f, 0.01359080f, -0.00795930f, 
    0.00647402f, -0.05193537f, 0.01923063f, -0.01765562f, 0.02822188f, -0.00636959f, -0.05700397f, 0.02736333f, 
    -0.01758476f, -0.00867910f, -0.04732637f, -0.01746470f, -0.00965984f, -0.06291254f, -0.00852636f, -0.03639872f, 
    -0.04722633f, -0.01918146f, 0.03324185f, -0.03489403f, 0.02407045f, -0.04320866f, -0.05608113f, -0.03381694f, 
    -0.07618531f, -0.07036761f, -0.06735957f, 0.02061279f, 0.00622005f, -0.03695358f, -0.06715432f, -0.03307243f, 
    0.00142036f, -0.07098949f, -0.00593870f, 0.04178620f, 0.00959995f, -0.05813662f, -0.05577492f, -0.02072380f, 
    -0.00558155f, -0.01846135f, -0.04029110f, -0.05782754f, -0.05365089f, -0.01435090f, 0.00543177f, -0.01577310f, 
    -0.08437247f, -0.03189638f, 0.01149819f, -0.06095485f, -0.05026505f, -0.07792570f, -0.01379434f, -0.07271329f, 
    -0.05537991f, -0.02384946f, -0.02976870f, -0.03142227f, 0.02491740f, -0.05335474f, 0.03732597f, -0.00450459f, 
    0.19261454f, 0.14940439f, -0.18733585f, 0.08845581f, 0.00596934f, -0.01184689f, -0.01168222f, -0.00132261f, 
    -0.11429635f, -0.01134663f, -0.07857782f, -0.14657526f, 0.23218410f, -0.11878682f, -0.05068095f, 0.11404591f, 
    0.12029121f, 0.18511343f, 0.00413954f, 0.02507496f, 0.11315516f, -0.04640918f, 0.56073678f, 0.19857533f, 
    0.37048990f, -0.22330633f, 0.05715298f, 0.13073526f, -0.06115041f, 0.15284488f, 0.00499875f, 0.10892054f, 
    -0.00103180f, -0.05072604f, -0.06340887f, 0.11768533f, 0.06930634f, 0.18114270f, -0.12169126f, -0.26602146f, 
    0.42190567f, 0.33247018f, 0.35136664f, -0.30802548f, 0.76961076f, 0.14354743f, -0.01192455f, 0.15658477f, 
    -0.09309374f, -0.06625315f, 0.29966062f, -0.21944945f, 0.24242140f, 0.17876685f, -0.11065114f, 0.11547328f, 
    -0.14534393f, 0.05655769f, -0.02225707f, -0.17897338f, -0.24248965f, -0.18755339f, 0.06575992f, 0.22923587f, 
    0.10601193f, 0.03401309f, 0.02624368f, -0.04876995f, -0.06066532f, -0.00891429f, 0.00512003f, -0.02239178f, 
    0.00010496f, 0.15691234f, 0.03410039f, 0.18073186f, 0.11956421f, -0.17530733f, -0.07516763f, -0.13236398f, 
    0.02369174f, -0.15733762f, 0.69039321f, 0.55035442f, 0.06147239f, 0.19030519f, -0.01486228f, 0.14726967f, 
    -0.00401111f, 0.12188762f, 0.11474461f, 0.08717261f, -0.01866744f, -0.13774139f, -0.09414415f, 0.01830176f, 
    0.00591068f, -0.11436172f, -0.16709952f, 0.13193952f, -0.37823358f, 0.21861072f, 0.09611288f, 0.23018861f, 
    -0.07780597f, -0.01118765f, 0.07083170f, 0.07824882f, 0.05807351f, -0.00717890f, 0.02744508f, 0.01275707f, 
    0.04296759f, -0.00751290f, 0.03118550f, -0.14679091f, -0.08598580f, 0.29213393f, -0.06377242f, -0.10581350f, 
    0.02091012f, -0.65752172f, -0.23078485f, -0.06484897f, -0.02066679f, 0.02211549f, 0.15975714f, -0.34168342f, 
    -0.07646062f, 0.09914405f, 0.17219843f, 0.11567223f, -0.05120850f, -0.07595679f, 0.07906090f, 0.02699105f, 
    0.11150701f, -0.07236716f, 0.04190309f, 0.19010340f, 0.18255155f, -0.02935968f, -0.48477772f, -0.13870862f, 
    -0.06637017f, 0.06663443f, -0.02838425f, -0.19615397f, 0.13504294f, -0.12828982f, 0.10808153f, -0.05653077f, 
    0.01806828f, -0.04088404f, -0.05572823f, -0.08776888f, 0.00929281f, -0.05447024f, -0.00666030f, 0.02177376f, 
    0.09107088f, -0.34527957f, -0.04052990f, 0.17806600f, 0.09909125f, 0.09934999f, 0.00400259f, -0.18787886f, 
    0.22742811f, 0.08052219f, 0.02163514f, -0.04350182f, -0.03025862f, 0.04160704f, 0.02710495f, -0.15195261f, 
    0.06646587f, 0.05772329f, -0.00149362f, 0.07696129f, -0.54311717f, -0.08514615f, -0.27000633f, -0.09322110f, 
    0.16010776f, 0.13735041f, -0.01207778f, -0.09188654f, -0.12706126f, -0.10294767f, -0.20384164f, -0.02021801f, 
    -0.01812493f, 0.12971039f, 0.21744055f, -0.10394815f, -0.04780497f, 0.01344178f, -0.02500840f, -0.09038231f, 
    -0.55021000f, 0.17556825f, 0.10434890f, 0.19298798f, 0.29489693f, -0.13064060f, 0.10521282f, -0.02238803f, 
    -0.06685296f, -0.17368807f, -0.03277021f, 0.00965959f, -0.05177301f, 0.07363109f, 0.08602118f, -0.08146604f, 
    0.07222943f, 0.36070526f, 0.26225626f, -0.02725008f, 0.12474781f, 0.20049646f, -0.30871302f, 0.28935277f, 
    0.32503629f, 0.02853484f, 0.13712516f, 0.00247463f, 0.04774846f, 0.14891000f, 0.09312886f, -0.02346857f, 
    0.03615725f, -0.26246685f, 0.11740420f, 0.12131834f, 0.01760962f, 0.16262843f, -0.05531775f, 0.14829443f, 
    0.00072973f, 0.29101339f, -0.27748716f, -0.18647924f, -0.40360457f, -0.03215994f, -0.08438583f, -0.07576697f, 
    -0.10270726f, 0.01979307f, -0.06525755f, 0.12349082f, -0.00979207f, -0.00873324f, 0.08286025f, -0.15323997f, 
    0.00604340f, -0.00994394f, 0.04598452f, 0.07168731f, -0.09377728f, 0.16851141f, -0.19718850f, -0.02927474f, 
    -0.02584409f, 0.09680014f, -0.00157923f, 0.02793391f, 0.00841452f, 0.00109458f, -0.08143281f, 0.05083193f, 
    0.10975487f, 0.00456527f, 0.00398069f, 0.26878610f, 0.05024814f, 0.25663468f, -0.01999896f, -0.04851190f, 
    0.26174027f, -0.53377581f, -0.05000390f, 0.01610122f, 0.19746061f, 0.17469521f, -0.12438891f, -0.27451903f, 
    0.30233935f, 0.19774956f, 0.00352867f, -0.06286465f, -0.11094507f, -0.12317201f, -0.05405515f, 0.05982788f, 
    0.09496205f, 0.05797664f, -0.00239075f, 0.16609716f, -0.19248077f, 0.04685137f, 0.14111364f, -0.20341076f, 
    -0.04818105f, 0.10991450f, 0.05455137f, 0.01614994f, -0.03953855f, -0.08138048f, 0.06357751f, -0.12605287f, 
    0.00260200f, 0.07279857f, -0.04728516f, 0.05404451f, 0.17732346f, 0.06055507f, -0.05385397f, -0.03193360f, 
    -0.33032811f, -0.01566151f, 0.13950007f, -0.11183950f, 0.05640590f, -0.04759356f, -0.04115352f, -0.08908328f, 
    0.04628380f, -0.05693484f, 0.21418661f, 0.08841589f, 0.04696721f, 0.04199617f, 0.26361957f, 0.04835907f, 
    -0.10541407f, -0.10972309f, -0.07731840f, -0.03153523f, 0.28462481f, -0.30252314f, -0.21369351f, 0.27123526f, 
    -0.37518993f, 0.30817640f, 0.13476995f, 0.32540250f, 0.00000569f, 0.05943949f, 0.03754344f, 0.01437961f, 
    0.02983870f, 0.05602765f, 0.02779037f, -0.00910876f, 0.26655728f, -0.04193422f, 0.25294593f, 0.15731789f, 
    -0.28038070f, -0.12884173f, -0.69249654f, -0.24607393f, -0.01072555f, 0.05016072f, -0.09437577f, 0.00794045f, 
    0.17407607f, 0.09039371f, -0.16564363f, 0.13114065f, 0.04177368f, 0.09180782f, 0.05415773f, 0.15840855f, 
    0.01416869f, 0.14762726f, 0.08295978f, 0.17657405f, -0.37441859f, -0.23745708f, 0.07844196f, 0.25215805f, 
    0.00804873f, -0.16361363f, -0.22519390f, -0.11214697f, -0.14239845f, -0.08548311f, 0.06730775f, 0.10479409f, 
    0.05708560f, 0.20959030f, 0.11367875f, 0.01599791f, 0.14484002f, 0.03412265f, 0.13738863f, 0.13388419f, 
    0.11777455f, 0.02326332f, -0.08674896f, 0.02822543f, 0.22721112f, 0.03263778f, 0.05304421f, 0.02482977f, 
    -0.01006555f, 0.08758113f, -0.07619623f, 0.04900502f, -0.09318532f, -0.09087959f, 0.00170518f, 0.08345275f, 
    -0.01651559f, -0.06692641f, 0.21271551f, -0.05161083f, 0.75118977f, 0.07388633f, -0.32197917f, 0.08356125f, 
    0.21761218f, 0.02338795f, 0.06622888f, 0.16788997f, -0.11348349f, 0.04976874f, 0.03237831f, 0.03160590f, 
    -0.03455597f, -0.09152077f, 0.01681475f, 0.09399591f, 0.09923011f, -0.05771377f, 0.09964998f, 0.15373014f, 
    -0.29129386f, -0.04071097f, 0.29177627f, 0.45362407f, -0.29412207f, -0.01924457f, -0.23346755f, -0.10362089f, 
    -0.13876680f, 0.04573028f, -0.19098109f, 0.01763070f, 0.09318077f, 0.03743921f, 0.01728907f, 0.05245165f, 
    -0.11402297f, -0.04083212f, -0.20536815f, -0.29962805f, -0.57724333f, 0.34968433f, 0.27142385f, 0.28477222f, 
    -0.12046000f, -0.26181394f, -0.19232176f, -0.02159884f, -0.20411457f, 0.54121745f, -0.07597045f, 0.04759669f, 
    0.04246831f, -0.00132438f, 0.04235132f, 0.00630304f, -0.01105107f, -0.07174864f, -0.00462296f, 0.02904852f, 
    -0.40930790f, -0.13881245f, 0.18438716f, 0.18563482f, -0.02286634f, -0.17977951f, -0.20305108f, -0.01870793f, 
    -0.04263398f, -0.07448447f, 0.04362772f, 0.07738123f, 0.09475771f, 0.11455771f, -0.02110200f, 0.02187055f, 
    0.06174991f, -0.08478040f, 0.15223128f, 0.00372592f, -0.25245595f, -0.27476129f, 0.48936757f, 0.34243301f, 
    -0.14855625f, -0.23372221f, 0.00829115f, -0.16179441f, -0.03847644f, 0.14121674f, 0.15838817f, 0.03935454f, 
    -0.04356718f, 0.05703546f, -0.01259203f, 0.13941485f, 0.07773381f, 0.07298668f, 0.06704036f, -0.02680238f, 
    -0.19173089f, -0.20342822f, 0.02985076f, 0.44542208f, -0.10364377f, -0.04697399f, 0.02074910f, -0.08854115f, 
    0.06489823f, -0.10616294f, -0.00184921f, 0.01467951f, 0.20528151f, -0.01300487f, -0.13442731f, 0.04583599f, 
    0.12437022f, -0.00313426f, -0.07642671f, -0.13111600f, 0.49189538f, 0.05573030f, -0.04118636f, -0.36443084f, 
    0.11917727f, -0.05189627f, -0.04634021f, 0.12046351f, 0.03694069f, -0.16474102f, -0.06251289f, 0.01917325f, 
    0.08862841f, -0.08076815f, 0.01185118f, -0.07635143f, 0.11567333f, -0.04072357f, -0.07415320f, 0.04080472f, 
    -0.01968359f, -1.10961986f, 0.15206900f, 0.11359677f, 0.02116439f, 0.16290952f, 0.12959293f, 0.10041475f, 
    -0.18722689f, 0.22180206f, 0.09131805f, 0.07528353f, 0.04702201f, 0.23123699f, 0.03850984f, 0.35033882f, 
    -0.04167346f, 0.21333900f, -0.10057848f, -0.05336685f, 0.19525251f, -0.02628094f, -0.06573655f, -0.25347847f, 
    0.14665431f, 0.05662003f, 0.10436396f, 0.09382213f, -0.00277900f, 0.00338216f, 0.20132796f, 0.17370769f, 
    0.09425657f, 0.02056269f, 0.15663043f, 0.00985867f, 0.03106246f, -0.08657496f, -0.03429885f, -0.04512051f, 
    -0.17297342f, 0.02237939f, 0.32845819f, 0.41717586f, -0.00355024f, -0.15655117f, 0.01228745f, -0.07690683f, 
    -0.02980004f, 0.02848686f, 0.02410783f, 0.09393434f, 0.06321250f, -0.01983083f, 0.01985475f, -0.04270073f, 
    -0.01270929f, 0.08634193f, -0.00010605f, -0.11470255f, 0.06392484f, 0.03161697f, -0.00369335f, -0.12416604f, 
    -0.14469932f, 0.04544120f, 0.00468248f, -0.00015414f, -0.09294425f, 0.06609530f, 0.05011042f, -0.00752353f, 
    -0.01733438f, -0.07118885f, -0.25297338f, 0.12203306f, 0.04390176f, -0.06128660f, -0.03015453f, 0.02437269f, 
    0.18005703f, -0.11096390f, -0.19391562f, -0.06852552f, -0.12624495f, 0.03782613f, 0.04308159f, 0.03971182f, 
    -0.01724237f, 0.00724042f, -0.15823494f, 0.04709661f, -0.09446667f, -0.03209294f, -0.15576290f, -0.08586446f, 
    0.03395945f, 0.18910395f, -0.00017133f, -0.00276838f, -0.10710528f, 0.08433942f, 0.10358886f, -0.06553388f, 
    0.17387396f, -0.14044221f, -0.26990086f, -0.13611124f, -0.02990466f, -0.07875860f, 0.03235670f, 0.03486926f, 
    0.00557334f, 0.02533864f, 0.01445454f, -0.03274187f, -0.15989274f, -0.17786375f, -0.24833189f, -0.12206219f, 
    0.46042159f, 0.38936257f, 0.09071258f, 0.44104317f, 0.00173385f, -0.11945423f, 0.14017144f, 0.04733404f, 
    -0.00614701f, -0.13766792f, 0.07306594f, -0.04690413f, -0.02403359f, -0.13100189f, -0.12750141f, -0.37363067f, 
    -0.36113992f, -0.09280688f, 0.04421342f, -0.03816070f, 0.38296783f, 0.70681667f, 0.41417846f, 0.20982239f, 
    0.47622693f, 0.45095378f, 0.17683665f, 0.12873794f, 0.17760414f, 0.25054595f, 0.02802194f, 0.07549194f, 
    0.00204020f, -0.05330774f, -0.00567851f, 0.01835450f, 0.00228954f, 0.04321750f, -0.13121533f, -0.13856311f, 
    -0.41946977f, 0.38518071f, 0.65307069f, 0.38063008f, 0.04394475f, -0.28992772f, -0.26861265f, -0.11296854f, 
    0.05115782f, 0.12139563f, -0.06643663f, 0.07872985f, 0.13426456f, 0.17792661f, -0.01819282f, 0.03145819f, 
    -0.06214196f, -0.09778174f, -0.07424982f, 0.19393723f, 0.03001255f, -0.01088223f, 0.18251915f, 0.13379462f, 
    -0.12866858f, -0.09293354f, -0.16513133f, -0.21147454f, 0.08173767f, -0.06353309f, -0.05589510f, 0.03485315f, 
    0.09873686f, -0.05617208f, 0.08031586f, 0.11693437f, 0.05071766f, 0.12333968f, -0.01589394f, -0.06517349f, 
    -0.03732381f, 0.22317120f, -0.07416336f, -0.05021398f, 0.25200215f, 0.29984444f, 0.40271071f, 0.61304039f, 
    0.10586190f, 0.12178339f, 0.00445967f, 0.02217853f, 0.06971599f, 0.00705598f, -0.01219035f, -0.04568226f, 
    0.03306701f, 0.00203679f, 0.11387990f, 0.13173708f, 0.45491222f, -0.36097708f, -0.36323810f, -0.23302053f, 
    -0.32974109f, 0.27124420f, -0.03154264f, -0.09803227f, 0.10099380f, -0.34495988f, -0.07124673f, 0.03778454f, 
    -0.14418401f, -0.07207154f, -0.10041603f, -0.01669542f, -0.03924870f, 0.05184642f, -0.04631609f, -0.00838710f, 
    0.18903497f, 0.57660836f, 0.53905010f, 0.22465537f, 0.15774523f, 0.23385458f, 0.13072768f, -0.03858831f, 
    -0.10721239f, -0.09092353f, 0.01301358f, 0.05063563f, -0.13788924f, 0.02211219f, 0.03646680f, 0.07962668f, 
    -0.02780299f, 0.08166154f, -0.08131400f, 0.00671723f, 0.18704860f, 0.65294570f, -0.39462820f, -0.12322165f, 
    -0.34491643f, 0.31000134f, 0.31627467f, 0.04680073f, 0.19129400f, -0.12738112f, -0.03813147f, -0.07829269f, 
    0.02079910f, -0.13230865f, 0.00946565f, -0.09203430f, -0.00159114f, -0.17448908f, -0.02011427f, 0.08018108f, 
    0.20085318f, 0.78952742f, 0.31406245f, -0.05887223f, 0.42559013f, 0.19406173f, -0.03966990f, 0.18279293f, 
    -0.00525097f, 0.22804977f, 0.01542695f, 0.03005351f, -0.07809520f, -0.01263598f, -0.00353453f, 0.05234861f, 
    -0.04808616f, 0.33722764f, -0.04410481f, 0.14914027f, 0.11140317f, -0.23652002f, 0.19912660f, 0.17010002f, 
    -0.30615306f, 0.16841295f, 0.15911528f, -0.20067894f, 0.06428555f, 0.13504675f, 0.04970379f, -0.05346579f, 
    0.11369172f, 0.17501681f, 0.02128629f, 0.07988931f, -0.07049081f, 0.09394007f, 0.04136705f, 0.03037847f, 
    -0.09284208f, 0.39874706f, 0.12497239f, 0.18992665f, 0.08183160f, 0.04013692f, -0.13777682f, 0.13405775f, 
    0.08601079f, -0.21022108f, -0.32570022f, -0.00965872f, 0.02524548f, -0.13636188f, 0.26918653f, -0.11039767f, 
    0.02632564f, -0.06809930f, -0.06527059f, -0.05863309f, -0.05412704f, -0.17546725f, -0.05981041f, 0.11271385f, 
    -0.12761679f, 0.03825451f, -0.05425810f, -0.00392451f, -0.03787065f, -0.00767939f, -0.12118252f, -0.02235312f, 
    0.02647481f, 0.14376830f, 0.04988926f, 0.05427678f, 0.10466086f, 0.11162791f, -0.00247744f, 0.03106669f, 
    -0.08584770f, -0.21149248f, -0.09169563f, -0.04040619f, 0.01639875f, 0.03766274f, 0.10785528f, 0.13463458f, 
    -0.06635717f, 0.03070535f, 0.05209827f, 0.02922118f, 0.01760174f, 0.01007226f, -0.01489453f, 0.03443145f, 
    0.01346547f, -0.01429183f, 0.00915128f, 0.07866537f, 0.14674635f, 0.02265138f, 0.08824030f, 0.32360420f, 
    0.10969882f, -0.06247183f, -0.05894883f, 0.12634842f, -0.05733068f, -0.11110624f, 0.03164814f, 0.07616529f, 
    0.00415163f, 0.14581218f, 0.16770354f, -0.05637415f, -0.05407218f, -0.01580895f, 0.12207182f, -0.08313049f, 
    0.12628014f, 0.07872402f, 0.30992511f, 0.18314730f, 0.16833937f, 0.13804072f, -0.13719055f, -0.09199990f, 
    -0.10044203f, -0.22543702f, -0.16353604f, 0.06757803f, 0.03300451f, 0.14103368f, 0.17484961f, 0.18198115f, 
    -0.25279787f, -0.50269276f, -0.05799697f, -0.29410827f, -0.01203465f, -0.02729020f, -0.17130807f, -0.02380974f, 
    0.13803270f, 0.04718394f, 0.04174409f, -0.01897959f, -0.07393108f, -0.14530842f, -0.06827974f, -0.06176452f, 
    -0.00195337f, -0.11084704f, 0.19487570f, 0.19842178f, 0.07157265f, 0.21944763f, 0.21922792f, 0.40636548f, 
    0.28385580f, -0.45783633f, 0.17697035f, 0.27001914f, -0.30933017f, 0.11948208f, -0.09293441f, -0.45147961f, 
    0.19450150f, -0.13189472f, -0.17577715f, 0.09385321f, 0.10753700f, 0.14392604f, 0.11342702f, 0.32295066f, 
    0.19779490f, 0.13329230f, 0.45191389f, 0.30447099f, -0.07344820f, -0.17839739f, -0.48079780f, -0.06764925f, 
    0.07889325f, -0.09828708f, 0.00401176f, -0.14384328f, -0.02507402f, 0.02557565f, -0.16085024f, -0.02641834f, 
    -0.00092093f, -0.08410671f, -0.10898533f, -0.08569378f, 0.02503844f, 0.09696300f, 0.14700493f, 0.34387109f, 
    -0.40165785f, -0.21118605f, -0.18209535f, -0.00380456f, 0.34651363f, 0.04671306f, 0.24559444f, 0.21956080f, 
    0.01879840f, 0.08246914f, 0.00788072f, -0.02990949f, -0.20483221f, -0.02748474f, -0.12136324f, -0.03742597f, 
    -0.25579339f, 0.10080840f, -0.06229952f, -0.12759821f, 0.27872270f, -0.27503091f, 0.55176640f, -0.41569659f, 
    0.05555032f, -0.26220396f, 0.05924148f, -0.01953141f, -0.09568730f, -0.03877504f, 0.06631336f, -0.23500295f, 
    0.05129439f, 0.09861729f, 0.02582278f, 0.10424168f, 0.15072580f, -0.16735564f, 0.02227646f, 0.05765929f, 
    -0.44951275f, -0.30330500f, -0.29543447f, 0.20795108f, 0.25115809f, 0.11949547f, -0.05575621f, -0.04302622f, 
    0.12874559f, -0.04999610f, -0.01653859f, 0.03933951f, -0.16970025f, 0.02597820f, -0.34310219f, 0.06713751f, 
    -0.31825864f, 0.19926891f, -0.19069411f, -0.40354225f, 0.06846989f, 0.45359138f, 0.74088556f, 0.25528097f, 
    0.43293473f, 0.19745769f, -0.06596226f, -0.14303130f, 0.17211276f, -0.23107915f, -0.27747032f, 0.09736828f, 
    0.11992013f, 0.10003775f, 0.09082355f, 0.14099914f, -0.03553860f, 0.05422360f, 0.05657658f, -0.02042742f, 
    -0.22047989f, 0.16147606f, -0.18646613f, -0.01612642f, 0.08260900f, -0.10611864f, -0.13393767f, -0.02992056f, 
    -0.17835376f, -0.16135022f, 0.00981112f, 0.12660937f, 0.05931802f, 0.00438309f, 0.10295720f, 0.01209483f, 
    0.13171031f, 0.03244474f, 0.01922425f, -0.02944450f, -0.12926623f, -0.00768942f, 0.58093262f, 0.59774882f, 
    0.39974034f, 0.19244516f, -0.00209567f, 0.03777196f, 0.26953343f, -0.15133265f, -0.20096195f, -0.01806924f, 
    0.14940992f, 0.20098798f, 0.15511999f, 0.11090150f, 0.13577731f, 0.09300826f, 0.14647178f, 0.15564476f, 
    -0.27839643f, 0.02198728f, -0.20295312f, 0.03072308f, 0.11859096f, 0.09455620f, 0.10010032f, -0.11058868f, 
    -0.03660066f, 0.17797312f, 0.12648603f, 0.09869009f, 0.19487232f, -0.01939887f, -0.03217125f, 0.28366783f, 
    0.21131399f, 0.08622187f, 0.15958385f, 0.22958894f, -0.50506306f, 0.14920850f, 0.41169572f, 0.18425226f, 
    0.46784616f, 0.03182968f, 0.23477080f, 0.07148734f, -0.01303958f, -0.20466867f, -0.11196063f, 0.13830423f, 
    -0.08563156f, -0.03168919f, 0.00964908f, -0.12580335f, 0.20683418f, -0.02501266f, 0.09070554f, -0.09592827f, 
    0.12400761f, 0.84651482f, -0.04412552f, 0.01770559f, 0.37912700f, 0.27286890f, 0.23929021f, 0.07195187f, 
    0.02477174f, 0.11515995f, -0.27586931f, 0.14118733f, -0.19853428f, 0.11208995f, 0.19350490f, -0.32566017f, 
    0.06611905f, 0.00231977f, -0.04516592f, -0.26611105f, 0.11920366f, -0.13269338f, 0.03448861f, -0.48567832f, 
    0.00510360f, -0.14429075f, -0.10966003f, -0.06019849f, -0.04062271f, 0.01848769f, 0.16907914f, 0.03147529f, 
    -0.01786541f, 0.00929995f, 0.09548727f, -0.00167152f, -0.13290434f, -0.49367741f, -0.10282221f, -0.20886952f, 
    -0.16099250f, 0.33534244f, 0.05709567f, 0.08146472f, 0.41781944f, -0.11940315f, -0.07909425f, 0.06351237f, 
    0.00054796f, -0.06194649f, -0.07114429f, 0.19955838f, 0.12528445f, 0.03754336f, 0.02856020f, 0.04244960f, 
    -0.32917234f, 0.06233369f, 0.06437372f, -0.23006926f, -0.01842006f, -0.03616194f, 0.00818740f, -0.42338988f, 
    -0.18569562f, -0.15134397f, 0.00702727f, 0.28370422f, -0.12309586f, 0.18896665f, -0.24612951f, 0.13381106f, 
    0.23530611f, -0.09435869f, -0.16030586f, 0.18094766f, -0.03419762f, -0.20719005f, -0.08123285f, -0.31460929f, 
    -0.02705551f, 0.00237433f, 0.01872833f, -0.00701017f, -0.00648060f, 0.04212603f, 0.02908688f, -0.03022718f, 
    0.00549994f, -0.00769890f, 0.04004459f, -0.06031316f, -0.04237130f, -0.01934008f, -0.04969596f, 0.01394041f, 
    0.02988764f, 0.01010333f, 0.03981862f, -0.04350628f, 0.03911023f, -0.04688394f, 0.02414834f, -0.02422895f, 
    0.00012254f, -0.01591622f, -0.00463090f, -0.04662034f, -0.01957755f, 0.00590991f, -0.02032502f, -0.04312037f, 
    0.02023138f, -0.02612459f, 0.01108148f, 0.02225026f, 0.01804153f, 0.00908140f, 0.02449055f, 0.02886717f, 
    0.02473184f, 0.00281166f, -0.03440136f, -0.00242032f, -0.02112122f, -0.00891977f, -0.05056151f, 0.02647759f, 
    -0.04314877f, -0.00677069f, 0.04745281f, -0.02749883f, -0.04368436f, 0.05359507f, -0.00123950f, 0.00060368f, 
    -0.03829962f, 0.04619768f, 0.00782709f, -0.02890875f, -0.03846568f, 0.04809156f, -0.05261022f, -0.05690403f, 
    0.04218286f, -0.00059316f, -0.04372265f, 0.01407491f, -0.00761942f, -0.01705863f, 0.00413690f, -0.00219172f, 
    -0.01223540f, 0.02463941f, -0.01012270f, -0.04206805f, 0.01790350f, -0.02206103f, 0.03367051f, -0.03882554f, 
    -0.03958467f, 0.03132586f, -0.01855202f, 0.03261914f, -0.02768367f, -0.03046946f, -0.01587429f, -0.05912191f, 
    -0.00924752f, -0.02638387f, -0.01190949f, -0.05513842f, 0.00297409f, 0.05029711f, -0.02828668f, -0.01596295f, 
    0.01405498f, -0.00799304f, 0.00090819f, -0.04503414f, 0.02567061f, 0.04267794f, -0.02465117f, -0.05973362f, 
    -0.01367805f, 0.04006320f, -0.04315924f, -0.02480723f, 0.03538790f, -0.04769449f, -0.03105531f, -0.03083001f, 
    0.03766690f, 0.02528757f, -0.01953351f, -0.03224574f, -0.05290419f, -0.00577721f, -0.03216187f, -0.00568417f, 
    -0.03616358f, -0.04162867f, 0.05171209f, 0.04426365f, 0.05016143f, 0.03073809f, -0.00467368f, 0.02614411f, 
    0.00593866f, -0.00966016f, -0.02815936f, -0.03338210f, 0.01488523f, 0.03439618f, -0.05228071f, -0.05169036f, 
    0.00997547f, -0.01975378f, -0.04401977f, -0.00668660f, -0.03128257f, -0.04264667f, -0.05063112f, -0.02075939f, 
    0.01823406f, -0.03334333f, -0.02283015f, -0.02428167f, -0.00414167f, -0.04542314f, -0.00681759f, 0.01190541f, 
    0.03048071f, 0.04894528f, 0.02050265f, 0.04593024f, -0.00290596f, 0.02246742f, -0.05035016f, -0.03251141f, 
    -0.03009551f, -0.00700502f, -0.02495371f, 0.03325467f, 0.03941683f, 0.01483071f, 0.01951227f, -0.05311396f, 
    0.04663687f, 0.02864001f, 0.03891637f, -0.00085874f, 0.03005374f, -0.00137447f, 0.04968916f, 0.01594737f, 
    -0.03410142f, -0.02471208f, -0.05090161f, -0.03113824f, -0.04501137f, -0.03019010f, 0.04826247f, -0.01269279f, 
    0.04993394f, 0.03400189f, -0.04331265f, -0.03608528f, -0.01481345f, -0.03910078f, -0.04472915f, 0.05408129f, 
    -0.02674725f, 0.03513550f, -0.01992702f, 0.04280313f, 0.01594247f, 0.03340925f, 0.05070748f, -0.00632297f, 
    -0.02072685f, -0.01212194f, 0.00106033f, 0.02647649f, -0.04115866f, -0.02931009f, -0.05756728f, -0.02694575f, 
    0.04002191f, -0.03197778f, 0.02158795f, -0.02173709f, 0.04186031f, -0.01068716f, 0.01820985f, -0.02836658f, 
    0.03861978f, -0.04192038f, -0.03059904f, 0.04165076f, -0.05494976f, -0.05187872f, 0.00840891f, 0.00876384f, 
    -0.02254779f, -0.01921100f, -0.03807140f, -0.00772802f, -0.00848689f, -0.06122294f, 0.00287448f, -0.01553716f, 
    0.02527125f, -0.05210200f, -0.01072906f, -0.05249045f, -0.02641556f, 0.03369326f, -0.04146833f, 0.02975001f, 
    -0.02062846f, -0.05037498f, -0.03911731f, 0.03032620f, -0.01281577f, 0.00915816f, -0.02220657f, -0.02442114f, 
    0.00297572f, 0.04133642f, -0.04642581f, 0.01096071f, -0.05149272f, -0.04319698f, 0.03102603f, 0.00554344f, 
    -0.04075843f, -0.02189349f, -0.01817554f, 0.01643637f, 0.03386146f, 0.01891227f, -0.02212543f, -0.00199659f, 
    0.00589484f, -0.00598590f, 0.01218458f, -0.00357738f, -0.06235507f, -0.05423122f, 0.04235550f, -0.02916307f, 
    -0.00576900f, -0.01501952f, 0.01136607f, -0.04454281f, -0.05221247f, 0.03323775f, 0.00032396f, -0.05805556f, 
    0.04141884f, -0.00412903f, 0.02506431f, -0.05539164f, -0.03812059f, -0.01635988f, 0.01504364f, 0.00004938f, 
    -0.04381875f, -0.05254480f, 0.03711034f, 0.00442629f, -0.03842320f, -0.00543726f, -0.00635350f, 0.00223743f, 
    -0.05651835f, 0.01828518f, 0.03273382f, 0.03141026f, -0.00526708f, 0.02610124f, -0.03965221f, 0.04614031f, 
    0.01092867f, -0.03652053f, -0.02107079f, 0.01797241f, -0.05683222f, -0.03329238f, -0.02323847f, 0.03271410f, 
    0.04732509f, -0.02968899f, -0.03542104f, 0.03260518f, 0.03285825f, -0.01012199f, 0.04268185f, -0.00452222f, 
    0.11470778f, 0.04445465f, 0.01438501f, 0.03201682f, 0.06868036f, 0.12464860f, 0.04042489f, 0.02454891f, 
    0.05939994f, 0.01597233f, -0.16834567f, -0.17913504f, -0.15946472f, -0.03813987f, -0.04539447f, 0.02575058f, 
    0.01648070f, -0.02967246f, -0.03809009f, -0.00838850f, -0.11775298f, -0.20253338f, -0.31216294f, -0.01574382f, 
    0.22670268f, -0.31947383f, -0.18054084f, -0.22659492f, -0.01812054f, -0.07590031f, -0.03084748f, 0.03130346f, 
    0.03850451f, 0.09068682f, 0.02391711f, -0.13923322f, -0.13630950f, -0.13840751f, 0.27811253f, 0.08904034f, 
    0.48692772f, 0.32579517f, 0.01453331f, -0.35946244f, -0.34815022f, -0.11669845f, -0.07252438f, 0.05780575f, 
    0.14039399f, 0.10398283f, -0.06976047f, 0.09553208f, 0.07513040f, -0.12773690f, -0.21052299f, 0.06392155f, 
    -0.14118439f, 0.16734001f, -0.09825060f, 0.11611939f, -0.19880600f, 0.02549580f, -0.06458897f, 0.17137986f, 
    -0.17260195f, 0.13425080f, 0.20145331f, -0.23740403f, 0.27434954f, 0.44811398f, -0.09021634f, 0.00476129f, 
    -0.04751385f, -0.15325844f, 0.03172443f, -0.20999154f, -0.07153184f, 0.05364987f, 0.10355207f, 0.08474153f, 
    -0.82582891f, 0.27409941f, 0.04251952f, 0.01353306f, 0.38853505f, -0.11272504f, 0.08357617f, -0.25151065f, 
    0.13465330f, 0.49912554f, 0.06027034f, -0.02081423f, 0.02911281f, 0.10573974f, -0.08824652f, 0.04772300f, 
    0.03615952f, -0.03112830f, -0.09043135f, -0.15608163f, 0.15122080f, 0.00315568f, 0.05628216f, 0.08655765f, 
    0.27572510f, -0.06177077f, 0.00647179f, -0.01844325f, 0.02125204f, -0.04127130f, 0.13433821f, 0.11013088f, 
    0.07550932f, 0.08163305f, 0.06867463f, 0.11830613f, -0.06804359f, -0.15961687f, 0.07167734f, -0.08092184f, 
    0.22156212f, 0.22874115f, -0.00172861f, 0.01427233f, 0.14374660f, 0.40035066f, 0.30444029f, 0.35375553f, 
    0.35286537f, 0.05501984f, -0.00001698f, 0.01033499f, 0.08346591f, 0.06428191f, 0.00108853f, -0.01862663f, 
    0.10882581f, 0.07339296f, 0.18905264f, -0.01886083f, 0.52195227f, -0.06474775f, 0.28159481f, 0.18076052f, 
    0.01454012f, 0.06760009f, -0.03747387f, -0.05223000f, -0.04888161f, -0.14227426f, -0.05531615f, -0.23799574f, 
    -0.13463970f, -0.11936096f, 0.06565813f, 0.02011140f, 0.10213206f, 0.07810104f, 0.01358278f, 0.04598884f, 
    -0.45298532f, 0.21136588f, -0.23677728f, 0.05886823f, -0.46025124f, -0.01628752f, -0.01837718f, -0.02587963f, 
    -0.19629841f, 0.16565287f, -0.10049343f, 0.04801757f, -0.03381791f, -0.09787586f, -0.04717781f, 0.04677445f, 
    -0.08368004f, -0.00189159f, -0.33970574f, -0.02458066f, 0.47746152f, -0.05240425f, 0.05689372f, 0.09105618f, 
    -0.26322103f, -0.00094073f, 0.02504900f, -0.29155403f, 0.52825409f, -0.01144405f, 0.10470219f, -0.06701950f, 
    -0.08416792f, -0.04309657f, -0.08381889f, -0.08118613f, 0.07532246f, 0.05171599f, 0.09763261f, 0.01035698f, 
    -0.00335945f, -0.14865172f, 0.03435407f, -0.76732755f, -0.24168830f, 0.07459670f, -0.15469918f, -0.27526397f, 
    0.24615830f, 0.13932659f, 0.00689829f, -0.04542676f, -0.01182832f, 0.03697449f, -0.11469647f, -0.06421712f, 
    -0.06885961f, -0.27967042f, -0.06477895f, -0.11337125f, -0.24195933f, 0.18037477f, 0.03083615f, -0.02178551f, 
    0.10399202f, 0.04856613f, -0.09703729f, 0.08954968f, -0.09758365f, 0.01512779f, 0.13137883f, 0.10822392f, 
    -0.07600398f, 0.14881530f, -0.02998472f, 0.18067847f, -0.04145477f, -0.13238826f, -0.01421644f, -0.10767488f, 
    0.25868046f, 0.06623314f, 0.31377786f, 0.06416865f, 0.25316691f, -0.12817495f, -0.02519817f, 0.07846720f, 
    -0.04701261f, 0.00850823f, -0.01860873f, -0.04899987f, 0.22527404f, -0.11185125f, -0.28478295f, 0.02502720f, 
    -0.06585863f, 0.10529907f, -0.18068528f, 0.04375674f, -0.06340761f, -0.05688623f, 0.06559959f, 0.01339936f, 
    0.08869167f, 0.11357199f, 0.00299196f, 0.06623407f, 0.05534876f, 0.06976570f, 0.09436543f, 0.01764660f, 
    -0.08550545f, -0.04373721f, 0.04530609f, 0.02984878f, -0.01827584f, 0.01046788f, -0.04072224f, -0.02167723f, 
    -0.02200070f, -0.07631819f, 0.11866226f, -0.02730315f, -0.07367019f, 0.16678831f, 0.12992539f, 0.13059942f, 
    0.08126099f, -0.04907506f, -0.04341159f, -0.17781241f, 0.08114000f, 0.05014508f, 0.00002470f, 0.07288324f, 
    -0.03761687f, 0.03081255f, -0.02988659f, 0.10506824f, 0.21555094f, 0.05021082f, -0.06014882f, 0.18747915f, 
    0.25085270f, 0.00416519f, 0.04223967f, 0.01746613f, -0.02038499f, 0.01916095f, 0.21145548f, 0.12200826f, 
    0.00758188f, -0.06719954f, 0.04821489f, -0.06313558f, -0.11438354f, -0.00242633f, -0.03859825f, -0.08554256f, 
    0.03538506f, -0.36775914f, -0.08031448f, -0.13852659f, -0.31325635f, -0.13339493f, -0.02101903f, -0.12727015f, 
    -0.09697463f, -0.16529936f, 0.07462106f, 0.28724968f, 0.07920210f, -0.00347049f, 0.00523494f, -0.01639077f, 
    0.11080265f, 0.06487998f, 0.26313326f, 0.04757943f, -0.08210821f, 0.08420740f, 0.14480934f, 0.02261573f, 
    0.18470608f, 0.12379687f, 0.03399164f, 0.23793896f, 0.20608564f, -0.01202175f, -0.01475623f, 0.11999342f, 
    0.07307492f, -0.02359230f, 0.15927617f, 0.20628369f, -0.24766774f, -0.21917933f, -0.45668301f, -0.41232395f, 
    0.64177996f, -0.03852946f, 1.04026258f, 0.38462609f, 0.17235506f, -0.22607026f, -0.04125508f, -0.05780884f, 
    -0.17162597f, -0.32763562f, 0.15366602f, 0.09280807f, 0.00066356f, 0.21989186f, -0.02751662f, 0.02653763f, 
    -0.07786581f, -0.14058109f, 0.14824869f, -0.35849673f, -0.06653395f, 0.08253063f, -0.36723170f, 0.12850973f, 
    0.17990467f, 0.08861182f, -0.27635527f, -0.25031489f, 0.02671990f, -0.02877168f, 0.03088683f, 0.02011309f, 
    -0.02368850f, -0.08194179f, 0.02655949f, 0.06986780f, -0.02781576f, 0.12522028f, -0.14782049f, -0.24426080f, 
    0.06861707f, -0.08040501f, -0.29029626f, 0.26853195f, -0.26615837f, 0.19855148f, -0.32048771f, 0.02349311f, 
    0.09223118f, -0.11124816f, -0.18747067f, -0.05284328f, 0.06735127f, 0.11025675f, 0.01157405f, 0.02504143f, 
    0.25320116f, 0.10979459f, -0.14631866f, 0.20563516f, 0.05015306f, 0.23735060f, 0.51021981f, -0.27456477f, 
    -0.38735750f, -0.25668532f, -0.12141181f, -0.07253644f, 0.09300557f, -0.07394677f, -0.08720627f, -0.00082429f, 
    0.02542537f, 0.02173630f, -0.06320752f, 0.00434438f, 0.02388000f, 0.11253136f, 0.17053591f, 0.06455013f, 
    -0.56360000f, -0.76028430f, -0.43450150f, 0.31311661f, 0.20435910f, 0.04541887f, 0.01286086f, 0.06060266f, 
    0.11512290f, 0.01712684f, -0.27448198f, -0.09246486f, -0.02474747f, -0.06497511f, -0.07438096f, 0.02043275f, 
    0.19463390f, 0.18781666f, 0.00761029f, 0.05008666f, 0.30918506f, -0.22082703f, -0.12916276f, -0.07071503f, 
    -0.32413203f, 0.00649864f, -0.11285447f, -0.18652175f, -0.12415025f, -0.11161332f, 0.15234078f, 0.09810478f, 
    -0.00393958f, 0.00449523f, -0.10207855f, 0.01084813f, -0.04940419f, -0.04041311f, -0.10682657f, -0.03384542f, 
    -0.27676842f, 0.15926708f, -0.22827691f, 0.20942147f, 0.13053343f, 0.15847819f, -0.03484241f, -0.08288573f, 
    -0.00421848f, 0.03177880f, 0.03781853f, 0.06697485f, -0.12215701f, 0.05266947f, 0.16143599f, 0.14021878f, 
    0.01228054f, 0.10786157f, -0.14628074f, 0.13122967f, 0.05698572f, 0.40285209f, -0.02754028f, 0.20247288f, 
    0.02538245f, 0.06845308f, -0.05445921f, -0.08819865f, 0.27349675f, -0.10941268f, -0.09307069f, -0.12262936f, 
    0.06486169f, -0.12285666f, -0.03850820f, 0.07129741f, -0.04156936f, -0.19015241f, -0.01341809f, 0.01840664f, 
    -0.10637352f, 0.17118974f, 0.05242740f, 0.07119434f, 0.22552019f, 0.09188788f, 0.23069309f, 0.06403571f, 
    0.39819434f, 0.25501326f, 0.10795515f, -0.06375547f, 0.09403449f, -0.06740806f, 0.15973221f, 0.14909621f, 
    0.06690182f, 0.07099195f, 0.03843613f, 0.07093968f, -0.52932543f, 0.10845482f, 0.38746211f, 0.41590634f, 
    -0.06831340f, 0.12812454f, 0.01992183f, 0.02766581f, 0.18194880f, -0.05990173f, -0.11103131f, 0.01355459f, 
    0.12748432f, 0.22844374f, -0.05205338f, 0.16487624f, 0.14814612f, 0.15646511f, 0.22691762f, 0.19497351f, 
    -0.01754950f, 0.74478024f, 0.14415419f, 0.17674547f, 0.37624806f, 0.02767780f, 0.22569096f, 0.11307968f, 
    0.22721176f, -0.10788377f, 0.08511405f, 0.16726169f, -0.03449503f, 0.21487178f, 0.28535891f, 0.00705655f, 
    0.20253856f, 0.00159052f, -0.02691283f, -0.00568438f, -0.18503658f, 0.07128405f, 0.24071951f, -0.09123696f, 
    -0.21622902f, -0.13692701f, -0.03740655f, -0.18200818f, -0.02896876f, -0.14975204f, 0.24387656f, 0.11957064f, 
    0.08479763f, 0.28269297f, 0.19507636f, -0.02325687f, 0.24245903f, 0.19471014f, 0.31406367f, 0.14067756f, 
    -0.34186855f, -0.44541264f, -0.20223823f, -0.01725354f, 0.12942916f, -0.01174711f, 0.12187815f, -0.11934677f, 
    0.09248753f, 0.13644785f, -0.10026558f, -0.05281258f, 0.07875109f, -0.05374922f, -0.01675195f, 0.06322881f, 
    0.07714541f, 0.01599496f, 0.00468625f, 0.07478428f, -0.03353688f, 0.13068196f, 0.22609949f, 0.21932675f, 
    -0.14096467f, -0.29493853f, -0.13980453f, -0.05889570f, -0.01013754f, -0.24727368f, -0.09740072f, 0.04107627f, 
    -0.03500831f, -0.02259703f, 0.12574369f, 0.10999458f, 0.00918724f, 0.20242091f, 0.05497058f, 0.01537403f, 
    0.04698682f, 0.22359766f, -0.08112419f, -0.05522328f, -0.08458411f, 0.01013714f, 0.06898584f, -0.06531051f, 
    -0.09998684f, -0.09239963f, 0.10094978f, 0.07941121f, 0.15936442f, 0.15077908f, 0.09208380f, 0.06629394f, 
    0.00178156f, -0.18278398f, -0.11141960f, -0.15999296f, 0.24804783f, 0.11051229f, 0.52964902f, 0.05163231f, 
    -0.00648568f, 0.10249216f, 0.06120241f, -0.10960596f, 0.12997532f, -0.02535683f, 0.00252307f, -0.02641595f, 
    0.10750689f, -0.04631422f, 0.06739420f, 0.12331252f, 0.26056677f, 0.32989120f, 0.13358995f, -0.12202841f, 
    -0.22299437f, 0.09764852f, -0.07914306f, 0.38952288f, 0.43309516f, 0.09099833f, 0.16194274f, -0.09966040f, 
    0.05467662f, -0.12197611f, 0.03888159f, -0.11640348f, 0.01645743f, 0.17125867f, 0.11489181f, 0.11785780f, 
    0.08456495f, 0.00905081f, 0.06821228f, -0.09530105f, 0.23383152f, -0.30498421f, 0.09490293f, -0.21179782f, 
    -0.11586111f, 0.13782065f, -0.18776105f, -0.01090637f, 0.06210106f, -0.08752967f, -0.01008884f, -0.04951988f, 
    -0.04413347f, -0.08251233f, -0.06678557f, 0.00500353f, 0.04171396f, -0.06808818f, 0.28784737f, 0.10971701f, 
    0.52039605f, -0.42142797f, 0.20166157f, 0.16856681f, 0.01003157f, 0.00599496f, 0.07638709f, 0.03683675f, 
    -0.12293269f, -0.40438080f, 0.11248954f, -0.00397714f, 0.00551268f, -0.01214560f, 0.05097422f, -0.01885755f, 
    -0.00863620f, 0.09982479f, 0.24225341f, -0.12925956f, 0.08504590f, 0.22332391f, 0.18287407f, 0.01479424f, 
    -0.25335988f, -0.05951283f, 0.11740862f, -0.02037865f, 0.01081202f, 0.05927470f, -0.05733043f, 0.00434703f, 
    0.01494974f, -0.00789409f, -0.08284107f, -0.00853806f, 0.03457637f, 0.06727482f, 0.18301120f, 0.12920263f, 
    0.06959900f, -0.50112730f, -0.01702587f, 0.20418538f, -0.23685855f, -0.11717893f, -0.12897964f, -0.14793403f, 
    -0.17143515f, -0.20218255f, 0.12435304f, -0.06674536f, -0.08975914f, -0.08426504f, -0.03117185f, -0.03512324f, 
    -0.07386716f, 0.09890157f, -0.19436580f, -0.28288811f, 0.31464013f, 0.09125079f, -0.10284401f, -0.26440796f, 
    -0.08944014f, -0.07747433f, -0.06472544f, 0.11310730f, -0.09728235f, 0.37655124f, 0.05815494f, 0.09096851f, 
    0.11624316f, 0.00968542f, 0.04086937f, -0.01421712f, 0.02894619f, -0.01818269f, 0.03651024f, -0.04043886f, 
    0.63018280f, -0.39583409f, -0.34408167f, -0.15717581f, -0.01292858f, 0.10166688f, 0.08336180f, 0.13542183f, 
    0.18213709f, 0.05828385f, 0.10844866f, 0.00599065f, 0.08036451f, -0.11870731f, -0.08360874f, -0.06776042f, 
    0.10258040f, 0.07295069f, 0.26019716f, -0.08403129f, 0.08530011f, -0.23060898f, -0.07263030f, -0.25702351f, 
    0.00438328f, -0.12375800f, -0.12095930f, 0.08612159f, 0.05290876f, 0.05592558f, 0.16783397f, -0.00029664f, 
    0.06539945f, 0.28953150f, 0.10516232f, -0.03306717f, 0.04469977f, 0.07181971f, 0.11759600f, 0.07196321f, 
    0.10355464f, -0.40213311f, -0.27144650f, 0.01699224f, -0.15213346f, -0.19938935f, 0.07240584f, 0.33308062f, 
    0.04502308f, -0.09929103f, 0.07734856f, 0.03099723f, -0.00284786f, 0.03796861f, 0.16818640f, 0.05818173f, 
    0.12541534f, 0.07064441f, 0.26076898f, -0.03635586f, 0.48874968f, 0.08957980f, -0.05234614f, -0.03059195f, 
    0.00805839f, 0.01046825f, 0.24178535f, 0.08948298f, 0.18618350f, 0.02115686f, 0.14302057f, 0.07164560f, 
    -0.10201063f, 0.03912397f, 0.02340734f, 0.06459192f, 0.00993836f, 0.05815476f, 0.06268778f, 0.28087530f, 
    -0.06267773f, 0.16015317f, -0.03399322f, -0.14593542f, -0.09483646f, 0.06725532f, 0.19388919f, 0.05099926f, 
    0.06771353f, 0.03764090f, -0.01395833f, 0.21926957f, -0.02022262f, -0.24530680f, 0.01078400f, -0.16674817f, 
    0.19589211f, 0.13860856f, 0.03145979f, 0.09173569f, 0.15237983f, 0.25263128f, 0.00597660f, 0.05152112f, 
    0.02764271f, -0.05119560f, 0.04005839f, 0.04669718f, 0.04164744f, 0.02730335f, -0.08421612f, 0.09879714f, 
    0.12239183f, 0.13617526f, -0.03724630f, -0.08005691f, -0.14248769f, -0.00916652f, -0.03741905f, -0.03647978f, 
    0.48139223f, -0.12077115f, -0.25753376f, -0.30202785f, -0.13060968f, 0.14122470f, -0.06102537f, 0.04724727f, 
    -0.05199236f, -0.01661082f, 0.11698100f, 0.07080750f, -0.09988836f, -0.01754733f, 0.02242031f, 0.00460017f, 
    -0.05870919f, 0.08082504f, -0.14708272f, -0.13562314f, 0.05644373f, 0.28894264f, 0.24954985f, -0.08631493f, 
    -0.13558479f, -0.02022723f, 0.11978341f, 0.04171426f, -0.01382747f, 0.03982125f, 0.01623958f, -0.07274967f, 
    0.18439204f, -0.00725444f, -0.10489108f, 0.02631297f, 0.11266124f, 0.01485205f, -0.07140307f, -0.02461694f, 
    0.08146635f, 0.19015639f, -0.57028943f, 0.49678957f, 0.35918143f, -0.06660917f, -0.32848012f, 0.00615818f, 
    -0.28366178f, 0.00893230f, 0.02116562f, -0.05448810f, 0.04007116f, 0.16466996f, -0.02037647f, -0.10848862f, 
    -0.10880185f, -0.03172553f, -0.41959429f, -0.15840034f, -0.02490236f, 0.28662586f, 0.39656004f, -0.10084789f, 
    0.27410781f, -0.24230908f, 0.03708233f, 0.01004802f, 0.14886287f, 0.28515026f, 0.03661483f, 0.03405914f, 
    0.01139109f, -0.02975956f, -0.17361397f, -0.09148332f, 0.19167145f, 0.32684892f, 0.25564846f, 0.24483465f, 
    0.14454842f, 0.10237416f, -0.61519533f, -0.22817092f, 0.01828354f, 0.21828473f, -0.28997919f, -0.19015828f, 
    0.00947549f, 0.14106193f, 0.04743587f, 0.03623521f, -0.00894057f, -0.13337553f, -0.08745061f, 0.30381694f, 
    0.06435464f, 0.05155647f, 0.16855831f, 0.08707996f, 0.13297103f, -0.14474864f, 0.40621847f, -0.04964218f, 
    -0.02584466f, 0.04236319f, 0.25979248f, 0.19022039f, 0.05527876f, 0.11452814f, 0.08051621f, -0.07869752f, 
    0.02205857f, 0.05653565f, -0.03120032f, 0.14127390f, 0.17473589f, -0.11686914f, -0.00595362f, 0.27021441f, 
    -0.22025274f, 0.23023684f, 0.87565792f, 0.08725896f, -0.01815372f, -0.20899767f, 0.26577863f, -0.05091363f, 
    0.02128111f, 0.36059770f, 0.02960547f, -0.15391706f, -0.02156880f, -0.07122595f, -0.10698093f, 0.07384856f, 
    -0.11034284f, -0.11264000f, -0.26755717f, -0.07443471f, -0.58651829f, -0.17269389f, -0.13578825f, 0.42888683f, 
    0.20156528f, -0.25607386f, -0.16782680f, -0.16841903f, 0.08360430f, -0.05333462f, -0.00030230f, -0.07964914f, 
    -0.20197965f, -0.01936976f, 0.00617462f, 0.20175590f, 0.02415619f, 0.11415970f, -0.02439230f, 0.04980691f, 
    0.59441972f, 0.33871925f, 0.07802285f, -0.10771978f, -0.08854806f, 0.27278516f, 0.13103424f, -0.06291461f, 
    0.14448467f, 0.22514828f, 0.28885409f, -0.02507559f, -0.13322099f, 0.02214938f, 0.10913970f, 0.04456491f, 
    -0.27334392f, -0.12206159f, -0.14436543f, -0.00641041f, -0.17591020f, 0.22723003f, -0.00623240f, 0.05744033f, 
    0.31470731f, -0.04449826f, 0.11510509f, 0.07395552f, 0.22279055f, -0.12980354f, -0.08797604f, -0.05920978f, 
    0.16943789f, -0.04413326f, 0.00464034f, -0.10931353f, 0.08805861f, 0.12084596f, -0.00073720f, 0.12861413f, 
    0.45548749f, 0.05543692f, 0.27284425f, -0.03122003f, -0.01656838f, 0.12412316f, 0.22774902f, 0.00983448f, 
    0.02292115f, 0.04262659f, -0.09445430f, -0.12121069f, 0.11398548f, 0.00152663f, 0.09901269f, -0.00489337f, 
    0.23408280f, -0.08503541f, 0.06486274f, 0.10919880f, -0.23929381f, 0.00527199f, 0.32262015f, -0.15661792f, 
    0.10969068f, 0.01066505f, -0.03496876f, 0.10868575f, -0.24415360f, 0.02272771f, -0.18317260f, 0.04911089f, 
    0.03014938f, 0.14817968f, 0.24742268f, -0.00282984f, 0.01161929f, 0.17201568f, 0.10448873f, 0.23743483f, 
    -0.09536366f, 0.14350057f, 0.03663877f, -0.09610521f, 0.06801715f, -0.03006353f, 0.08441416f, 0.18461107f, 
    -0.19721760f, 0.08003439f, -0.11828486f, 0.05155227f, -0.08156701f, 0.13429183f, 0.03999406f, 0.09165461f, 
    0.03002091f, -0.17158596f, 0.33732387f, 0.19555803f, 0.09050477f, 0.04149042f, 0.11638308f, -0.22125556f, 
    0.20776732f, -0.17438132f, 0.07144103f, -0.20550931f, -0.24137357f, 0.14309256f, -0.04527928f, 0.11008616f, 
    -0.01865391f, -0.15172422f, 0.14535508f, -0.01712641f, 0.12560785f, 0.03601691f, -0.18701681f, -0.09065507f, 
    0.02807015f, 0.17173041f, -0.36526483f, -0.13709380f, -0.48294657f, -0.18448232f, -0.18138638f, -0.11047934f, 
    -0.07074530f, 0.00481073f, -0.10967992f, -0.06306953f, -0.01642358f, -0.04466369f, 0.10142928f, 0.01637221f, 
    -0.13968630f, 0.09703927f, 0.39902642f, 0.14632533f, -0.37546089f, -0.33601007f, -0.68944556f, 0.12657036f, 
    0.05109392f, 0.05844361f, -0.24891964f, -0.08597939f, -0.24628732f, -0.05367818f, -0.06893264f, 0.16332197f, 
    0.03020098f, -0.05993112f, 0.02772889f, 0.25830516f, -0.27503210f, -0.10754592f, -0.46430883f, -0.33681604f, 
    0.48711374f, 0.30321983f, 0.25337869f, 0.11581013f, 0.18177405f, 0.32394782f, -0.00031845f, 0.10765639f, 
    0.07745866f, 0.02999830f, -0.14154460f, -0.05304770f, -0.17466499f, -0.04918921f, 0.06195064f, 0.07750733f, 
    0.05185198f, -0.02794915f, -0.19676343f, 0.00848018f, -0.43171021f, -0.57709402f, -0.63951886f, -0.47283915f, 
    0.19437292f, 0.35706690f, -0.02425174f, 0.02343013f, -0.24736489f, -0.34001353f, 0.15233994f, 0.09094384f, 
    0.06174688f, 0.14069062f, -0.12428221f, -0.02166693f, 0.10285432f, 0.01840421f, 0.02531254f, 0.00887721f, 
    -0.11580261f, -0.27755231f, -0.19312829f, 0.02705066f, -0.07916129f, -0.04804690f, -0.05040755f, 0.03842281f, 
    0.04006850f, 0.00443560f, 0.12444226f, 0.14753252f, -0.20832816f, -0.06096468f, -0.07460138f, -0.04732250f, 
    0.15782657f, -0.03722423f, 0.03254826f, 0.05646410f, -0.17403530f, 0.36671895f, -0.12952934f, -0.28861567f, 
    0.10318673f, 0.15001558f, -0.25210711f, -0.23953845f, 0.05718893f, -0.15351491f, -0.02463766f, -0.05239905f, 
    0.00612728f, 0.00942941f, 0.07512128f, -0.03546097f, -0.07096420f, 0.06600150f, -0.02017079f, 0.07491858f, 
    -0.43124011f, -0.14175010f, 0.06033021f, 0.26300806f, -0.46281958f, -0.10529061f, 0.07567136f, -0.12313457f, 
    -0.16450503f, 0.02505731f, -0.03209417f, 0.12139817f, -0.15425748f, -0.10665442f, 0.04751101f, -0.03164889f, 
    0.32442054f, 0.07288551f, 0.04673679f, 0.20830303f, 0.45265982f, 0.45103878f, 0.13847636f, -0.29863280f, 
    -0.00759374f, 0.17028044f, 0.19674934f, 0.20013298f, 0.19849235f, -0.01008578f, 0.00161300f, 0.03024052f, 
    -0.02644774f, 0.05804919f, 0.09931249f, -0.04129940f, -0.06566127f, 0.23053451f, -0.06811073f, 0.06241650f, 
    0.71058267f, 0.57453704f, -0.20144211f, -0.55256945f, -0.34267649f, -0.07015429f, 0.13976526f, -0.19739054f, 
    0.25863662f, 0.18029465f, -0.00235791f, -0.04942459f, 0.10203394f, 0.13815913f, 0.07153512f, 0.02725878f, 
    0.17581402f, 0.07641844f, 0.17559369f, 0.08484841f, -0.32113647f, -0.16180885f, 0.05638649f, -0.13048391f, 
    -0.11964562f, 0.07427779f, -0.04686620f, -0.16395032f, 0.00393354f, -0.00077176f, -0.04185145f, -0.07539925f, 
    -0.03457138f, -0.00389574f, 0.04437190f, 0.04744865f, 0.24795224f, -0.00879049f, 0.06818518f, 0.00147794f, 
    0.39447096f, 0.59772801f, -0.21759586f, -0.29985535f, 0.12512411f, -0.08211780f, -0.05328130f, 0.38281390f, 
    0.28493920f, 0.21629624f, 0.16433123f, -0.11142135f, 0.06467049f, 0.06946789f, -0.03429409f, 0.00466027f, 
    0.13725694f, 0.11939403f, 0.09888016f, 0.14374794f, 0.06336301f, -0.40228742f, -0.35926616f, -0.19504787f, 
    0.19165748f, 0.18236437f, 0.21754953f, 0.31643704f, 0.11533275f, -0.23160775f, 0.17614143f, -0.05404415f, 
    -0.06996857f, 0.04709604f, 0.04486630f, 0.14133513f, 0.09076092f, 0.04878102f, -0.00978629f, 0.01914503f, 
    0.12451006f, 0.42877144f, 0.06392715f, -0.08851100f, 0.13822569f, 0.08507641f, 0.25143394f, 0.37692314f, 
    0.08570043f, 0.21159428f, -0.00208620f, -0.05780405f, -0.09768801f, 0.03366394f, 0.09590486f, 0.07704525f, 
    -0.01497184f, -0.02334015f, -0.01903984f, 0.26497394f, 0.61834848f, 0.24031955f, -0.23541903f, -0.14559029f, 
    0.19559586f, 0.01689084f, 0.10381927f, 0.34523711f, -0.10868933f, -0.02180906f, 0.02777468f, 0.00956401f, 
    -0.10496150f, -0.02947004f, 0.08163725f, 0.09001820f, 0.11556944f, 0.00687931f, -0.01917680f, -0.01404730f, 
    0.79716092f, 0.11512200f, -0.03915410f, -0.35924429f, -0.01782226f, 0.23277441f, 0.15091895f, 0.32069206f, 
    0.07192528f, 0.33058989f, 0.05650874f, -0.05901665f, -0.12941721f, 0.15186253f, 0.15352215f, 0.08628734f, 
    -0.17703325f, -0.06684706f, -0.16132264f, 0.12952538f, -0.47638613f, -0.24578527f, 0.22660922f, 0.10748616f, 
    -0.24835590f, -0.02350703f, 0.05112743f, -0.27042532f, -0.21330051f, 0.02395616f, 0.06831346f, -0.06946211f, 
    0.02306815f, 0.27549979f, 0.00514389f, -0.00056186f, -0.01625005f, -0.03487018f, 0.09827332f, -0.05854117f, 
    0.09982002f, 0.42728397f, -0.17636786f, -0.03776492f, 0.05248433f, 0.00649411f, -0.04728384f, 0.00218217f, 
    0.22279315f, -0.13738337f, 0.16866876f, -0.09002960f, 0.03715632f, -0.10415178f, 0.08952741f, -0.03853154f, 
    0.31302992f, 0.00644688f, -0.05967586f, 0.02248323f, -0.20856245f, -0.17115824f, -0.01881181f, 0.00372380f, 
    -0.13410547f, -0.05620777f, -0.03827984f, -0.14104833f, 0.00675024f, 0.00290766f, 0.07343336f, -0.07755303f, 
    -0.17348965f, 0.00811868f, 0.02881928f, -0.17030534f, 0.07532664f, -0.12376814f, 0.12717488f, -0.00800802f, 
    0.20605552f, 0.33033675f, -0.29386884f, -0.10029674f, -0.04478472f, -0.01216466f, 0.01210015f, 0.46975434f, 
    0.03929412f, 0.04275626f, 0.01874379f, -0.09014608f, 0.01872744f, 0.07828806f, 0.03200277f, 0.02999862f, 
    0.03802652f, -0.00853659f, 0.13560823f, -0.00238221f, -0.31378704f, -0.18295625f, -0.22619686f, 0.04979744f, 
    -0.06978676f, -0.05331758f, -0.14156455f, -0.13591625f, -0.07071427f, -0.09759454f, -0.02728326f, -0.01267238f, 
    -0.00034750f, -0.00190324f, 0.27715033f, 0.09354402f, -0.11599316f, 0.03766925f, -0.01923068f, 0.07395867f, 
    -0.03051540f, 0.01756028f, -0.22948323f, -0.04264209f, -0.03583556f, -0.06886809f, 0.02508196f, -0.04403215f, 
    0.02942561f, 0.02783709f, -0.02645070f, 0.09803633f, -0.07943702f, -0.00187451f, -0.03961053f, -0.11097813f, 
    -0.15365343f, -0.10782062f, -0.18975136f, -0.08395065f, 0.38809410f, 0.06833880f, 0.19882163f, -0.00306072f, 
    -0.20321164f, 0.11929338f, -0.07243813f, 0.10734808f, 0.09028674f, 0.15897527f, -0.08586323f, 0.04760760f, 
    0.06102993f, 0.02568563f, 0.08232281f, 0.02630979f, 0.05244904f, 0.13852121f, 0.11852448f, 0.01883850f, 
    0.32869411f, 0.12677565f, -0.13702136f, 0.64901108f, 0.22642550f, -0.11195003f, 0.18793514f, -0.22819643f, 
    0.01885617f, 0.00401161f, 0.06911592f, 0.00725286f, -0.06564168f, 0.12725264f, -0.06186074f, 0.11491600f, 
    0.03449279f, -0.00295678f, 0.18614310f, 0.06184125f, 0.26845786f, -0.37487224f, -0.38093141f, -0.41201913f, 
    -0.01836713f, 0.18985943f, -0.08974302f, -0.09168757f, -0.01829715f, 0.05069308f, -0.03902920f, 0.02167062f, 
    0.08009017f, 0.07209547f, 0.01618505f, -0.00629646f, -0.06537909f, -0.09326880f, 0.17235117f, 0.12346199f, 
    -0.16828240f, -0.01549294f, 0.32694215f, 0.36561024f, 0.09320492f, -0.02579200f, -0.00176597f, -0.05502260f, 
    0.18447159f, -0.05579325f, -0.21372542f, -0.00383071f, -0.05458251f, 0.05863648f, 0.05676667f, -0.02942571f, 
    -0.16645409f, 0.08925506f, 0.27187532f, -0.11532318f, 0.50744689f, 0.24733059f, 0.43616998f, 0.18273486f, 
    0.03283906f, -0.14369187f, -0.05535209f, -0.11337030f, 0.08551200f, 0.02659953f, -0.11088020f, -0.05493561f, 
    -0.01550864f, -0.06615541f, -0.01638883f, 0.10384653f, -0.07478347f, -0.05835569f, -0.00275445f, 0.15500294f, 
    -0.07184383f, -0.18407536f, -0.08552476f, 0.57224435f, -0.07025217f, 0.03514702f, -0.38415515f, -0.04994887f, 
    0.11321754f, 0.12810351f, -0.00531053f, -0.02479139f, -0.03431200f, -0.12855430f, -0.05101968f, -0.10650876f, 
    -0.11878392f, 0.01956332f, -0.07700366f, -0.23062351f, -0.15139978f, -0.62527001f, -0.30773205f, -0.40172511f, 
    -0.40396348f, -0.11613718f, -0.17895243f, -0.11905525f, 0.13513079f, -0.08272407f, -0.16759512f, -0.08710957f, 
    -0.01309778f, -0.10169330f, -0.20579700f, -0.15195282f, 0.10790758f, -0.00679738f, -0.02274456f, 0.08886083f, 
    0.30832842f, -0.23194470f, 0.12687971f, -0.39763057f, -0.12021418f, 0.04544714f, -0.05918249f, 0.04514299f, 
    -0.01364864f, -0.22094925f, 0.00246244f, 0.02880297f, -0.00250841f, 0.06361641f, -0.05534336f, 0.05905687f, 
    0.14935295f, 0.06702583f, 0.28986242f, -0.01193770f, -0.41986784f, -0.73384064f, -0.89487749f, -0.10957795f, 
    -0.57695681f, -0.01252607f, -0.18412785f, -0.36575150f, 0.20891428f, 0.05067764f, -0.11358216f, -0.15160640f, 
    0.02631218f, 0.01980654f, 0.01724820f, -0.03539276f, -0.00384187f, 0.00566935f, 0.02858820f, 0.11391033f, 
    -0.22559026f, -0.29689276f, -0.46132401f, 0.05323166f, 0.04469476f, 0.10638101f, 0.04016444f, 0.07900915f, 
    -0.00003934f, -0.03374152f, -0.05582602f, 0.04838325f, 0.09198960f, 0.08645359f, -0.08232247f, 0.07378631f, 
    0.09064767f, 0.13967551f, 0.20345037f, 0.01496119f, 0.62764770f, -0.05669325f, 0.50538486f, 0.07325017f, 
    -0.13342452f, 0.16136564f, 0.34317133f, -0.09279214f, 0.28087863f, 0.12121372f, -0.15151739f, -0.02844575f, 
    -0.11452035f, 0.00776017f, -0.02155627f, 0.09779419f, 0.02125885f, -0.04234283f, 0.10950621f, -0.03277044f, 
    0.05758660f, 0.09198573f, 0.34985849f, 0.07655357f, 0.26262787f, 0.17172596f, 0.08880957f, 0.32095113f, 
    -0.06981398f, -0.07550757f, -0.13624059f, 0.05452977f, -0.01930688f, 0.15749168f, 0.20573828f, 0.19465643f, 
    -0.05448326f, 0.24625336f, 0.13760084f, 0.01324431f, 0.20175381f, -0.00690427f, 0.10725190f, 0.16272718f, 
    0.14330897f, -0.04586513f, 0.02595306f, -0.07026581f, 0.02155362f, 0.04245399f, -0.07607355f, 0.11599796f, 
    -0.01078532f, 0.03987943f, 0.12392393f, -0.15420753f, -0.04399425f, -0.08816680f, -0.17070672f, -0.09749641f, 
    0.11777775f, -0.34308445f, -0.32632467f, -0.05705553f, -0.37211743f, 0.08808420f, -0.15951316f, -0.10237347f, 
    -0.01913029f, -0.01991168f, -0.00653206f, 0.19117999f, -0.01946101f, -0.05567165f, 0.01400817f, -0.04959173f, 
    0.06955843f, 0.01197529f, -0.02141649f, 0.01912072f, 0.36440900f, 0.20061858f, 0.31125104f, 0.23210767f, 
    -0.02066031f, -0.16013196f, 0.01183963f, 0.10982811f, -0.08735667f, -0.02669939f, -0.11045063f, -0.13025761f, 
    -0.10001543f, 0.04913100f, -0.02846367f, 0.02875124f, 0.01928151f, 0.06029071f, -0.10995576f, -0.14101900f, 
    -0.21473977f, -0.11865766f, 0.17524776f, -0.00950563f, 0.05851531f, -0.05205721f, -0.00343944f, 0.07273832f, 
    0.14898594f, 0.08480121f, 0.14126141f, 0.04499533f, 0.10504853f, -0.05051364f, -0.09917884f, -0.09517939f, 
    -0.02669480f, 0.18320565f, -0.10514378f, 0.00362583f, 0.11861599f, 0.12239742f, -0.09474112f, 0.21899045f, 
    0.00976587f, -0.01571027f, -0.07941187f, 0.09259340f, -0.07816284f, 0.05724391f, 0.02264255f, -0.03041878f, 
    -0.03757459f, 0.08273812f, 0.01523628f, 0.10108577f, 0.11371019f, 0.07789374f, 0.13528971f, 0.24127683f, 
    -0.08833357f, 0.29918095f, 0.07870492f, 0.35708988f, 0.26720005f, 0.05458678f, 0.02735303f, 0.10171827f, 
    0.02130716f, 0.16657689f, 0.12741713f, -0.09203413f, 0.03489893f, 0.00317544f, 0.07508050f, -0.07863079f, 
    -0.03156013f, 0.04843136f, -0.02782452f, 0.10157027f, 0.04197772f, 0.18762656f, 0.15791492f, -0.04644561f, 
    -0.04207514f, 0.06012626f, 0.28092340f, 0.26017711f, 0.03035055f, 0.01170688f, 0.00888160f, 0.02287196f, 
    0.03098570f, 0.02857784f, -0.01664520f, 0.12231059f, -0.08077917f, -0.30694744f, -0.04225076f, -0.04603996f, 
    -0.21315587f, 0.04689312f, 0.20334701f, -0.09682324f, 0.07570453f, -0.03802656f, 0.13313952f, 0.28015193f, 
    0.12616666f, -0.02976240f, -0.08464629f, -0.10348530f, -0.02821722f, -0.02716953f, -0.02057775f, -0.01130254f, 
    0.02760348f, -0.00493522f, 0.31376868f, 0.14266482f, 0.07179292f, -0.20961913f, -0.25958002f, 0.18693015f, 
    0.32937318f, 0.09499248f, -0.02496856f, 0.11699806f, 0.05744522f, -0.01211397f, -0.15321518f, 0.07225225f, 
    -0.05387231f, -0.12709849f, 0.08264466f, 0.10720285f, -0.05592013f, 0.16399302f, -0.00648286f, -0.03024060f, 
    0.09565631f, 0.44519323f, 0.45967805f, -0.19009624f, -0.28167844f, -0.15273374f, -0.01591015f, -0.02704985f, 
    -0.32449210f, 0.12970544f, 0.11847716f, -0.20734416f, -0.08122864f, 0.01665417f, 0.04024610f, 0.01079839f, 
    0.01306161f, -0.16846432f, -0.01227105f, 0.08196398f, -0.42401189f, 0.14439341f, 0.27807099f, -0.04462763f, 
    -0.04603641f, -0.05711468f, -0.00418534f, -0.06980161f, -0.02814552f, 0.20891450f, -0.04343108f, 0.00920964f, 
    -0.11750345f, 0.06321403f, -0.04008084f, -0.03687416f, -0.03582425f, 0.08276925f, 0.00208723f, 0.04702869f, 
    0.28967831f, 0.00039640f, 0.43766722f, -0.11164454f, -0.04046476f, 0.01962481f, 0.13183199f, 0.13681419f, 
    0.15675059f, 0.13150266f, -0.01592193f, -0.09010065f, 0.00800435f, 0.08743758f, -0.02281177f, -0.00360402f, 
    0.02753237f, -0.05390716f, 0.19030558f, 0.08518583f, -0.23112516f, 0.09420753f, -0.04156365f, -0.25267449f, 
    -0.25161883f, 0.05057013f, 0.07624214f, -0.07191763f, -0.37415415f, 0.18909167f, -0.18198219f, 0.04754797f, 
    -0.00902546f, -0.16014110f, -0.16384694f, -0.07586662f, 0.02518305f, -0.04261440f, -0.06002728f, -0.05189755f, 
    0.01998871f, 0.19422148f, 0.41803196f, 0.33900625f, -0.04794175f, 0.14137945f, -0.05438819f, 0.12502106f, 
    -0.08565179f, -0.08699465f, -0.08601059f, 0.09898141f, -0.04703200f, 0.08472952f, -0.08144702f, -0.03995305f, 
    -0.03013662f, 0.10094028f, -0.01158705f, 0.10999227f, 0.79805833f, -0.31205279f, -0.08856424f, -0.21529660f, 
    -0.20174779f, -0.12159391f, 0.10065132f, -0.08591445f, 0.16318910f, 0.11023166f, -0.07696573f, -0.03715452f, 
    -0.01976131f, -0.03778864f, -0.04574295f, 0.10609961f, -0.03209975f, 0.14988008f, 0.01893700f, 0.07799036f, 
    -0.00896791f, -0.66760552f, 0.08547524f, 0.24520500f, -0.13656162f, 0.04691434f, -0.25176564f, 0.02256502f, 
    -0.23524152f, 0.02870210f, 0.11048120f, -0.01510155f, 0.27065510f, 0.05915369f, 0.05698211f, 0.16953678f, 
    0.07832938f, -0.12346795f, 0.22053677f, 0.08636997f, 0.08551431f, -0.29112852f, -0.02131259f, 0.13824528f, 
    0.06747732f, 0.05043729f, 0.01482356f, 0.03947717f, -0.00758044f, 0.06559050f, -0.20962872f, 0.01748837f, 
    0.07334418f, 0.02240029f, -0.10651074f, -0.00949699f, -0.01642290f, 0.18933670f, -0.14575949f, 0.01140929f, 
    0.00472429f, 0.23501286f, 0.33878615f, -0.02182312f, -0.34214735f, -0.06215178f, 0.15765643f, -0.09211761f, 
    0.03865874f, 0.03533450f, -0.03663011f, -0.01553812f, -0.10945889f, -0.05103894f, -0.01035136f, 0.00900095f, 
    0.12036946f, -0.06892984f, 0.02817560f, 0.04907082f, -0.12961031f, -0.25364926f, -0.29795638f, 0.18859592f, 
    -0.03172525f, 0.00008026f, -0.11453842f, 0.05740108f, -0.05727264f, 0.05539757f, -0.10654088f, -0.05790951f, 
    -0.16611153f, 0.17591938f, 0.09009890f, 0.00821115f, 0.03226370f, -0.03028876f, -0.00334761f, 0.03815978f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07776093f, 0.01736154f, 0.23924008f, 0.13150637f, -0.05714141f, 0.03898428f, 0.01817015f, 0.11308578f, 
    0.01769880f, -0.01470149f, -0.00529504f, 0.00085838f, 0.02371821f, 0.32745975f, -0.03660787f, 0.03272922f, 
    0.03242129f, 0.17108671f, -0.02994199f, -0.03805320f, -0.02174280f, 0.19088846f, -0.08159412f, -0.02271094f, 
    -0.04149614f, 0.06998631f, 0.22749022f, -0.09105577f, -0.06959539f, 0.03341190f, 0.16847381f, 0.00934199f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.22413814f, 0.05322409f, -0.33594292f, -0.33551311f, 0.12357108f, -0.12936941f, -0.01492603f, -0.24739888f, 
    0.02912485f, 0.13271904f, 0.15515685f, 0.13195594f, -0.16257136f, -0.32608470f, -0.19326317f, 0.02653081f, 
    -0.16250071f, -0.15059301f, 0.14593102f, -0.09814832f, -0.69171292f, -0.36062366f, 0.14529333f, -0.16823554f, 
    -0.06208777f, 0.28305867f, -0.62202078f, -0.05246931f, 0.31043941f, 0.37008026f, -0.11465896f, 0.15488829f, 
    -0.27593389f, -0.03016068f, 0.13733758f, -0.31604737f, -0.10992689f, 0.12073472f, 0.17819287f, 0.17012809f, 
    -0.07163818f, -0.04566478f, -0.08049849f, -0.08737229f, -0.10238650f, 0.22476897f, -0.35914665f, 0.02010079f, 
    -0.12610890f, 0.52648991f, -0.07361989f, -0.03448921f, -0.50765949f, 0.06458085f, 0.20070171f, -0.25990111f, 
    -0.08468672f, 0.08464374f, 0.21316515f, -0.15421192f, -0.31257120f, 0.14540528f, 0.48293173f, -0.14564301f, 
    -0.16406277f, -0.11384618f, 0.12487476f, 0.32591689f, -0.11924078f, 0.00349675f, -0.10720205f, -1.04937601f, 
    0.00792309f, 0.01099636f, 0.01264872f, 0.16730353f, 0.13608560f, 0.16748507f, -0.29838735f, -0.01211621f, 
    0.02497401f, 0.30464864f, -0.08327265f, 0.10512172f, -0.07853834f, 0.10756452f, -0.43339846f, 0.53843719f, 
    0.09403840f, 0.07206053f, 0.05631391f, -0.10173793f, 0.06277134f, -0.24580559f, -0.32929948f, -0.27782917f, 
    0.19092302f, 0.14079942f, 0.02619533f, 0.13596320f, 0.06442981f, -0.00657743f, -0.18475063f, 0.06024707f, 
    -0.06264162f, 0.16259697f, -0.14586593f, 0.06958384f, -0.07968452f, -0.91190475f, -0.15371543f, -0.15109916f, 
    -0.14373499f, -0.27281275f, -0.03954651f, 0.08585273f, 0.37531105f, -0.50815773f, 0.17338675f, 0.51073307f, 
    0.10076125f, -0.05740222f, 0.18486516f, -0.20934638f, 0.22106555f, -0.08620949f, -0.70875496f, -0.35904381f, 
    0.29733825f, 0.09980770f, 0.03157252f, -0.38473815f, -0.16531254f, -0.00131681f, 0.16271883f, 0.28218368f, 
    0.15563658f, 0.01115142f, 0.15749350f, -0.15797880f, -0.18024956f, -0.06993368f, 0.35629639f, -0.08729494f, 
    -0.15156054f, 0.12401278f, -0.08069078f, 0.13378859f, 0.16205302f, 0.31569478f, 0.03236429f, -0.10491740f, 
    0.04821566f, 0.02575020f, -0.69937891f, -0.11422366f, 0.19386953f, -0.21203344f, -0.53728473f, 0.02475181f, 
    -0.10610766f, -0.04758276f, 0.03132555f, 0.40610915f, -0.16004370f, 0.05752325f, 0.13756831f, -0.05754881f, 
    -0.05963618f, 0.03945776f, 0.11992323f, 0.01737487f, 0.10660380f, 0.13501744f, -0.53191948f, 0.07709825f, 
    0.13551068f, 0.14092262f, 0.02655253f, 0.11263916f, 0.47984332f, -0.06156194f, 0.12138174f, -1.11553180f, 
    -0.10313395f, -0.14205404f, -0.18747163f, -0.05587238f, 0.24854180f, -0.17349227f, -0.17155761f, 0.27980810f, 
    -0.26776424f, 0.15875480f, 0.31762600f, 0.40096107f, 0.02313842f, -0.05645694f, -0.06642364f, -0.08788314f, 
    0.04852363f, 0.08677044f, 0.10376991f, 0.09136034f, 0.02567798f, 0.15842624f, -0.05649731f, -0.05070498f, 
    0.01081260f, -0.74671185f, 0.11806234f, -0.15387225f, -0.30040288f, 0.42722592f, -0.76308924f, 0.32231137f, 
    0.09854334f, -0.26808232f, -0.26816460f, 0.16483004f, -0.69802016f, -0.48107710f, -0.23734175f, 0.14560360f, 
    -0.41107371f, -0.15490934f, -0.06662172f, -0.09065193f, -0.09773239f, -0.10642078f, -0.05285164f, -0.06440116f, 
    0.07879869f, 0.04513968f, -0.15558325f, 0.10048147f, 0.05218762f, -0.37841845f, 0.65027994f, -0.12754939f, 
    -0.03507532f, 0.29385298f, 0.04836777f, -0.04089487f, 0.30779442f, -0.17539354f, 0.27158436f, -0.33918995f, 
    0.12070887f, 0.09785707f, 0.22444336f, 0.19531746f, -0.05699383f, -0.65521985f, 0.09176622f, -0.59601897f, 
    0.22451885f, 0.02524812f, 0.38309982f, -0.05280745f, 0.04047772f, -0.03110233f, 0.08099863f, -0.06471340f, 
    0.03583440f, -0.03264440f, 0.16738686f, -0.09148402f, 0.00278044f, -0.30461130f, -0.45837873f, 0.00026475f, 
    0.16231965f, -0.31001827f, 0.03153478f, -0.07994340f, 0.20406236f, -0.21371442f, -0.15855722f, -0.69091994f, 
    0.05198269f, -0.39670739f, 0.44536662f, 0.14471018f, -0.73199588f, 0.29917988f, 0.00624178f, -0.41011757f, 
    0.12653713f, -0.08696053f, -0.87092263f, 0.25811300f, 0.09981672f, -0.05500497f, -0.09955748f, 0.52187657f, 
    0.00972879f, 0.00600637f, 0.09072332f, -0.09774666f, 0.01389989f, 0.27800646f, 0.35405016f, -0.09529550f, 
    -0.12295108f, 0.30476391f, -0.01156535f, 0.00491316f, -0.01337256f, 0.29407725f, -0.44418585f, 0.08773073f, 
    -0.00816558f, -0.07732726f, 0.05222603f, -0.10719003f, -0.13432764f, -0.22348103f, -0.31728473f, -0.29285133f, 
    -0.04802999f, 0.16871066f, 0.08434134f, 0.09728315f, 0.05208612f, 0.10379653f, -0.02567628f, -0.43810293f, 
    0.07983051f, 0.06852809f, -0.07072470f, -0.15359195f, 0.00678680f, 0.07579488f, 0.43953171f, 0.04382960f, 
    -0.11990894f, -0.68773556f, 0.03899568f, -0.01555881f, -0.05998933f, -0.11760801f, 0.29467648f, -0.24714018f, 
    0.09377281f, -0.07197139f, 0.50529164f, -0.46375316f, -0.80319786f, -0.19914871f, -0.47154811f, 0.35879716f, 
    0.46113685f, 0.08350266f, -0.14077720f, -0.27714115f, -0.02690120f, -0.18119991f, 0.13631633f, -0.51333117f, 
    0.08099709f, 0.01733589f, 0.14949706f, 0.07563952f, -0.05602055f, 0.22716779f, -0.51962531f, 0.02676951f, 
    0.12057380f, -0.85051060f, 0.06619612f, 0.09322218f, -0.06910118f, 0.35441956f, 0.12971617f, -0.06531685f, 
    -0.11039527f, -0.50703001f, 0.12373336f, 0.26081407f, -0.06922456f, -0.52794421f, 0.60340786f, 0.19936009f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.09524509f, 0.21445069f, -0.04928663f, -0.02786089f, -0.11414405f, -0.13591802f, 0.21393360f, -0.14532162f, 
    0.13696136f, 0.03766653f, 0.17874855f, -0.04798803f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
