#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.57877004f, 0.96517283f, -0.52774930f, -0.59791392f, -0.21551903f, 0.04683372f, 0.10439155f, 0.39020377f, 
    -0.04984115f, 0.38870355f, 0.26560190f, 0.62041068f, 0.15230691f, 0.23515865f, 0.42429620f, -0.32604787f, 
    0.22906663f, -0.24153641f, -0.90694380f, 0.15927435f, 0.05893056f, 0.32872570f, 0.46144092f, 1.04996824f, 
    -0.43676224f, -0.07116581f, 0.32057318f, -0.04728384f, -0.82905412f, -1.11390531f, 0.61790013f, 0.98980951f, 
    0.20865296f, -0.03513559f, 0.11724018f, -0.17589149f, -0.00035868f, 0.30143675f, -0.23980843f, -0.19842896f, 
    -0.63593692f, 0.22837830f, -0.36674166f, -0.49101785f, -0.52508843f, 0.55362785f, 0.64043063f, 0.37707853f, 
    -0.14980172f, -0.57220763f, -0.59194899f, -0.05755181f, -0.11624878f, 0.07048558f, -0.66784763f, -0.11947292f, 
    -0.35642543f, 0.04644921f, 0.24285765f, -0.37743264f, 0.59764487f, 0.46414316f, 0.33336854f, -0.35396612f, 
    -0.23753206f, -0.81369591f, 0.41243520f, 0.01097185f, 0.30961376f, 0.21362309f, 0.27608541f, 0.55457461f, 
    0.11036824f, -0.28787076f, 0.78161573f, -0.03722233f, 0.06025754f, 0.52424169f, 0.07108921f, 0.25877595f, 
    0.38434258f, 1.14300704f, -1.24149454f, -0.16304918f, 0.00240206f, -0.15100639f, -0.14238544f, -0.33067197f, 
    0.10160930f, -0.20575427f, -0.09989206f, -0.25982463f, 0.92282611f, -0.10237543f, -0.64122587f, 0.63018137f, 
    0.40599883f, -0.34377730f, -0.17961054f, 0.72660226f, 0.31111580f, 0.26205373f, -0.21337408f, 0.15544394f, 
    -0.06596140f, 0.33589792f, -0.35719264f, -0.29743111f, -0.03546365f, -0.14664516f, 0.18976815f, -0.50973439f, 
    -0.60158163f, -0.37817436f, 0.18855594f, 0.90897542f, -0.11348131f, -0.37033722f, -0.50288314f, 0.06455853f, 
    -0.22034211f, -0.68781990f, -0.57098007f, 0.15939663f, -0.15646888f, 0.40182292f, 0.09736643f, -0.44396493f, 
    -0.88115507f, -0.03501692f, -0.30942231f, 0.47687200f, -0.06993204f, -0.21651837f, -0.45936173f, -0.70878232f, 
    -0.81194341f, 0.71904612f, -0.42879027f, 0.20120420f, -0.17041291f, 0.20148219f, 0.10224015f, -0.29601622f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12817891f, 0.30435619f, -0.30295974f, 0.03487908f, -0.23897383f, 0.26316753f, 0.32010511f, -0.20661229f, 
    0.33882594f, -0.21065857f, 0.11155633f, -0.23028053f, -0.28858662f, -0.42518505f, 0.18493816f, 0.27167335f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.17564598f, 0.03698319f, 0.33850917f, -0.15600826f, -0.02958809f, -0.05320011f, 0.01175193f, -0.23755331f, 
    -0.04080907f, -0.02743419f, -0.33877689f, -0.03783610f, 0.12105229f, 0.06948172f, 0.08957123f, -0.02098042f, 
    -0.19889693f, 0.11772379f, -0.06574461f, -0.09981854f, -0.52902877f, 0.26282847f, 0.09584796f, -0.06484126f, 
    0.03982135f, 0.07030626f, 0.00802324f, 0.08218814f, -0.02760618f, 0.18546394f, 0.13611729f, 0.18045436f, 
    -0.07346959f, -0.03015679f, 0.03284493f, 0.19704203f, 0.19368418f, 0.16308528f, 0.14788243f, -0.04658633f, 
    0.07656242f, 0.22223359f, -0.06793495f, 0.10667587f, -0.13543566f, -0.45457232f, -0.13658255f, 0.31177217f, 
    -0.14125720f, -0.05285785f, 0.22860478f, 0.02439083f, 0.01332918f, -0.08010571f, 0.01420288f, -0.06396425f, 
    0.12150305f, 0.03573699f, 0.00116697f, 0.22990867f, 0.19791453f, 0.05767843f, -0.10809451f, -0.45148566f, 
    -0.50863421f, -0.26416254f, 0.03009102f, 0.11743670f, -0.01371619f, -0.04159103f, 0.13468322f, 0.17306429f, 
    -0.06197919f, -0.33020946f, -0.40503246f, -0.04148880f, -0.09286204f, -0.11073723f, 0.01706417f, 0.11526749f, 
    -0.02367959f, -0.30845860f, 0.31346422f, 0.03068255f, -0.28055629f, -0.13776776f, -0.35074160f, 0.09798001f, 
    0.06711713f, 0.10502288f, -0.25502855f, -0.09103338f, -0.22576775f, 0.02103169f, 0.20245239f, -0.38589838f, 
    0.22582236f, 0.02873627f, -0.05917086f, -0.76363719f, -0.37927654f, 0.16364570f, 0.20099497f, -0.09795810f, 
    0.00528326f, -0.00868262f, 0.00956948f, 0.43557376f, 0.38235545f, 0.08312207f, -0.22572069f, -0.00916703f, 
    0.01685767f, 0.03342480f, 0.04346343f, -0.20750479f, 0.05446381f, 0.32406384f, 0.04674800f, -0.05216273f, 
    -0.08462969f, -0.02025405f, -0.02054857f, 0.05765034f, 0.20771289f, -0.23338884f, 0.24456444f, 0.01659654f, 
    0.28606188f, 0.04368977f, 0.25178123f, -0.01299478f, 0.08514951f, -0.01649124f, -0.08421746f, 0.28622150f, 
    0.06660549f, 0.01658032f, 0.07035445f, -0.00743257f, -0.07871799f, -0.06437851f, 0.18750411f, -0.10361312f, 
    0.26898152f, -0.27711990f, -0.61560339f, -0.00988591f, 0.20952722f, 0.15202558f, 0.09522738f, -0.05046218f, 
    0.17155668f, 0.07061820f, 0.10550937f, 0.25394762f, 0.17527130f, -0.05970183f, -0.11517709f, -0.04862200f, 
    -0.03544699f, 0.13075538f, -0.22679335f, -0.23086572f, 0.10879000f, -0.15549889f, -0.02060722f, -0.11487100f, 
    0.08118360f, -0.00685877f, 0.06576690f, -0.13244356f, -0.12582611f, 0.28875327f, -0.06735630f, -0.11426961f, 
    -0.07088278f, 0.12400868f, 0.19219176f, -0.09022220f, 0.04572286f, -0.01639718f, -0.22003585f, -0.04240119f, 
    0.02222991f, -0.10837930f, 0.24227454f, 0.20258696f, 0.22672074f, 0.11060558f, -0.84005362f, -0.04349934f, 
    0.14614613f, 0.15219595f, 0.14465106f, 0.03956779f, 0.05817371f, 0.12673070f, -0.35110036f, 0.18545683f, 
    0.08812913f, -0.03834163f, 0.01638211f, 0.21333270f, 0.07181834f, 0.13312764f, 0.19725537f, -0.38267058f, 
    0.25457507f, -0.22384128f, -0.13146548f, 0.04118896f, -0.15546340f, -0.10540181f, 0.04733955f, 0.12981413f, 
    0.23166160f, 0.19474503f, 0.29427043f, 0.01219134f, -0.10853620f, 0.10618271f, 0.11949672f, 0.02498601f, 
    -0.04189243f, 0.33397341f, -0.19513272f, -0.60849494f, 0.05456803f, 0.06661975f, -0.36488178f, -0.05374526f, 
    -0.10636711f, -0.20368606f, -0.35857520f, -0.23656754f, 0.04322723f, 0.01853200f, 0.05402890f, 0.20921949f, 
    0.03910972f, 0.20417537f, -0.08698313f, 0.00822680f, -0.26585901f, -0.07579935f, 0.07369442f, -0.08695421f, 
    -0.24579911f, 0.23704204f, 0.02684231f, 0.16353481f, -0.11578555f, -0.33847144f, -0.05538013f, -0.12098905f, 
    -0.06530004f, -0.09200522f, -0.09079382f, -0.06344229f, 0.09527574f, -0.45203811f, 0.16445176f, 0.37569103f, 
    -0.18795288f, -0.09723382f, -0.08290617f, -0.00308750f, 0.13169235f, -0.00853395f, -0.09058910f, 0.30949402f, 
    0.05882579f, -0.05104599f, -0.00684107f, -0.10055140f, 0.17155521f, 0.02107545f, -0.12993670f, -0.28843442f, 
    -0.09442794f, 0.21720441f, -0.13334514f, -0.01222041f, 0.20335129f, -0.08597242f, -0.11639045f, 0.20139258f, 
    -0.12786140f, -0.13725495f, 0.04974920f, -0.18805638f, -0.01044101f, 0.02481357f, -0.12701665f, -0.01188751f, 
    0.16570462f, 0.08873776f, -0.14381742f, -0.09494460f, -0.14489293f, -0.11569221f, 0.17053755f, -0.11657847f, 
    -0.05564233f, -0.03125570f, -0.44555670f, 0.10116048f, 0.18752232f, 0.10232385f, -0.21024494f, -0.15690356f, 
    0.06737714f, 0.08550417f, 0.04673466f, 0.52782577f, 0.02864436f, -0.50893581f, 0.14305314f, -0.00504600f, 
    -0.05595150f, 0.01024105f, -0.04184267f, -0.00301582f, -0.13170999f, 0.13966221f, 0.22255053f, 0.03489767f, 
    0.13172400f, -0.02532164f, 0.01832045f, -0.06587455f, -0.06454366f, -0.79032344f, -0.07946151f, 0.00275964f, 
    -0.09266784f, -0.03780187f, 0.04771324f, 0.06833637f, 0.06530961f, 0.17235793f, 0.00957312f, 0.23822871f, 
    0.00802595f, -0.11020099f, 0.11282282f, 0.04552776f, -0.02852154f, 0.06565611f, -0.10689382f, -0.15524012f, 
    -0.00590817f, -0.14336701f, 0.08946010f, 0.00001170f, 0.03683322f, 0.01566469f, 0.02777984f, -0.01822494f, 
    -0.06424062f, 0.04567670f, 0.15925460f, 0.00501999f, -0.03093898f, 0.09294671f, -0.11935571f, 0.03109146f, 
    0.06143947f, 0.27481684f, 0.09187414f, 0.24279194f, 0.03763247f, -0.06101682f, -0.11633430f, 0.08292568f, 
    0.09064869f, 0.21630909f, -0.49241841f, -0.02060250f, 0.41174316f, 0.00821292f, -0.02319026f, 0.03632115f, 
    0.05932460f, 0.08392733f, 0.02952236f, -0.03858345f, -0.20056863f, 0.04675967f, -0.02428910f, 0.07097195f, 
    0.20799465f, -0.14602946f, 0.07586793f, -0.14228240f, 0.04492470f, 0.04467254f, 0.07355746f, 0.01520434f, 
    0.06990315f, -0.13392366f, -0.01842806f, 0.14499985f, 0.35504273f, 0.22839667f, 0.29404828f, 0.26620209f, 
    0.10258422f, 0.01407623f, -0.07178237f, 0.03897406f, 0.06242597f, -0.06426553f, 0.46402657f, 0.13004865f, 
    0.05316470f, 0.07995261f, 0.09351115f, 0.04197363f, 0.12172331f, -0.13615133f, -0.07095253f, 0.56925750f, 
    0.22891307f, 0.20511691f, 0.05071766f, -0.09833284f, 0.15364715f, 0.02603369f, 0.05938230f, 0.02651580f, 
    0.03547326f, 0.20103812f, 0.09336907f, 0.25211340f, 0.03308042f, -0.06277672f, -0.16796020f, -0.11250894f, 
    0.07393282f, 0.08937345f, 0.15838362f, 0.13994876f, -0.02990845f, 0.03828444f, -0.00859107f, 0.14315471f, 
    -0.01831300f, 0.08197967f, -0.49702948f, 0.22084168f, -0.24832250f, 0.04853340f, -0.29331356f, -0.33116069f, 
    -0.20732740f, -0.22107786f, -0.07294988f, 0.14202698f, -0.56505650f, 0.08980255f, -0.08028231f, -0.06831710f, 
    0.08292831f, -0.30914766f, -0.02617353f, -0.14368895f, -0.25972912f, 0.13480742f, 0.18692607f, -0.12349285f, 
    -0.05623664f, 0.22867572f, -0.03410465f, 0.05175956f, -0.11676437f, 0.30575296f, 0.46239215f, -0.20859264f, 
    0.23861462f, 0.04435736f, 0.16190934f, 0.02581043f, 0.07901776f, 0.12172338f, -0.01873709f, -0.30703914f, 
    0.13642180f, 0.08075667f, 0.19768316f, 0.00903993f, 0.05024599f, 0.01985760f, -0.04771486f, -0.04528370f, 
    -0.22491424f, -0.31666270f, -0.09133419f, -0.04258452f, 0.09738233f, 0.08424547f, 0.16098480f, -0.10886899f, 
    0.19133781f, 0.17515655f, 0.04888645f, 0.02386440f, 0.10843214f, -0.07380741f, 0.18700013f, -0.13133097f, 
    -0.18547395f, -0.14565073f, -0.76913941f, -0.29073489f, -0.19469987f, 0.20464766f, 0.17737582f, -0.07625562f, 
    -0.07808347f, 0.00248269f, -0.01604450f, 0.24285786f, 0.28719130f, -0.07175449f, 0.15450764f, -0.15089595f, 
    0.11440220f, 0.05876884f, -0.05416265f, 0.21915202f, 0.20268586f, 0.21106961f, -0.00512032f, -0.13671482f, 
    0.10871268f, -0.06398917f, 0.13357486f, 0.05980233f, -0.32710528f, -0.56273717f, 0.18482102f, 0.06191162f, 
    -0.15140925f, -0.12738851f, -0.11796801f, -0.02645240f, -0.03738908f, -0.07771146f, -0.03917779f, 0.47835174f, 
    -0.24469404f, -0.02384857f, -0.31517875f, 0.01316410f, 0.06362768f, -0.18403733f, 0.27231866f, 0.24396782f, 
    -0.19012287f, -0.13045888f, -0.32204291f, -0.13535917f, -0.01708682f, 0.09098582f, 0.15556076f, -0.25883529f, 
    -0.35776493f, -0.16096954f, 0.11305017f, 0.31569955f, -0.21613365f, -0.01188841f, 0.21330273f, 0.04378873f, 
    0.19507778f, -0.05832225f, 0.29630616f, -0.03717427f, 0.07838526f, -0.09343165f, -0.01567451f, 0.16904050f, 
    0.08139787f, -0.04627945f, -0.13179997f, -0.12342323f, 0.09133960f, -0.03540172f, 0.06675497f, 0.00129006f, 
    -0.21864705f, -0.00999511f, 0.04260855f, -0.05877985f, -0.12210323f, -0.00131310f, 0.06154955f, 0.14998683f, 
    0.05019587f, -0.08977140f, -0.14697991f, -0.07169110f, 0.02321849f, 0.17873801f, -0.01565158f, 0.09700034f, 
    0.15588556f, -0.17768912f, -0.35275567f, 0.02321074f, 0.07713551f, -0.06720137f, -0.07809076f, 0.02222330f, 
    0.08120880f, 0.20174450f, -0.10576724f, -0.14889045f, -0.22020917f, 0.06765828f, -0.19972248f, -0.13908181f, 
    0.05031998f, 0.00810638f, -0.06453523f, -0.00135734f, 0.08527446f, -0.00252551f, 0.07672527f, 0.13738501f, 
    0.11569005f, 0.03912694f, -0.15462635f, 0.14638749f, 0.13591622f, 0.33274218f, 0.25642774f, -0.08948743f, 
    0.12539443f, 0.14662051f, 0.04975632f, -0.06014416f, -0.00597260f, 0.02548695f, -0.11490627f, 0.32926628f, 
    -0.09505290f, -0.01641392f, 0.23709245f, 0.12478619f, 0.20241074f, 0.12096178f, 0.01978317f, 0.22814597f, 
    0.23533221f, -0.20252544f, 0.09668640f, 0.22487228f, 0.18717746f, -0.01452156f, 0.21994346f, -0.05545735f, 
    -0.20862484f, 0.09970967f, 0.20307381f, -0.12220434f, 0.26948664f, -0.03127559f, -0.16345589f, 0.18901558f, 
    -0.08803783f, -0.01353672f, 0.06458093f, 0.09398434f, -0.13338973f, 0.00623000f, -0.04814214f, -0.17114416f, 
    -0.11030260f, -0.06891523f, -0.03300248f, -0.23186080f, 0.05947092f, -0.17107631f, -0.23172477f, -0.12022344f, 
    0.16544345f, -0.02880145f, 0.20802876f, 0.08424844f, 0.11792413f, -0.11991298f, -0.29429200f, -0.55693108f, 
    -0.01460180f, -0.03916354f, 0.10488526f, 0.26345143f, 0.01906159f, -0.11308453f, -0.25435701f, -0.02266026f, 
    0.44961616f, -0.09539662f, -0.22290589f, 0.01869579f, -0.32662386f, -0.00333320f, 0.05035789f, 0.13612616f, 
    0.11236705f, 0.03960738f, 0.14776494f, 0.00099322f, 0.15590511f, 0.04332754f, 0.11932907f, 0.07511988f, 
    -0.63769495f, 0.19741184f, -0.08384048f, 0.09768523f, 0.20318966f, 0.04339085f, -0.05485997f, 0.07260326f, 
    0.01238456f, -0.18088554f, 0.04874728f, 0.24332212f, -0.14291118f, 0.03637183f, -0.22172919f, 0.13354068f, 
    -0.07615626f, 0.09707367f, -0.00244779f, -0.28573847f, 0.10573164f, -0.23761290f, -0.18756232f, -0.21954942f, 
    -0.08200188f, 0.11404851f, 0.10985494f, 0.20116596f, -0.06106481f, 0.58964592f, -0.10897499f, -0.22131179f, 
    -0.05792967f, -0.04167551f, -0.06429330f, 0.11071683f, 0.02870603f, -0.15723455f, -0.12660362f, -0.02531875f, 
    0.09536922f, 0.17022742f, 0.21131878f, 0.17038280f, 0.06419712f, -0.31910264f, -0.12397303f, 0.13363783f, 
    0.15700696f, 0.07564081f, 0.04489378f, 0.00831107f, 0.14495799f, 0.05746091f, 0.34312227f, -0.24051192f, 
    0.33084124f, 0.11053212f, 0.20756780f, 0.06803184f, 0.17261724f, -0.01288943f, 0.12092298f, -0.16530435f, 
    -0.27976975f, 0.42467961f, 0.05832159f, -0.07854075f, -0.26709330f, 0.03394578f, -0.04166650f, 0.04888888f, 
    -0.13663509f, -0.09919149f, -0.17314714f, -0.13114756f, 0.07370352f, 0.07689267f, 0.21947758f, -0.04367987f, 
    0.01776871f, 0.02668072f, 0.08052032f, -0.06850614f, 0.01282391f, -0.16384476f, -0.15249644f, 0.07013293f, 
    -0.02250630f, 0.10764184f, -0.32001945f, -0.48259759f, -0.35889596f, 0.01723198f, -0.00914010f, 0.19776924f, 
    0.15648416f, 0.05276608f, 0.26832443f, -0.25433272f, -0.38409591f, 0.04153597f, -0.27538583f, 0.09131766f, 
    -0.09212580f, 0.10651893f, -0.11043026f, -0.20612180f, 0.04067974f, 0.00825135f, 0.48338333f, -0.16072884f, 
    -0.08018366f, -0.04968822f, -0.03940121f, 0.03953164f, -0.13651595f, -0.11103390f, -0.02697985f, 0.60496676f, 
    -0.36367008f, 0.14133684f, -0.15153979f, -0.00745866f, -0.00048675f, -0.04129045f, 0.06047979f, 0.17645574f, 
    0.09163966f, 0.19607717f, -0.09152481f, 0.08944336f, 0.14282820f, -0.11169013f, -0.21834014f, -0.03898488f, 
    0.04458112f, 0.23843430f, 0.14205064f, -0.13674603f, -0.05911721f, 0.14863873f, 0.15002975f, 0.07205840f, 
    -0.29733875f, 0.11827665f, -0.14732035f, 0.14269918f, -0.22115543f, -0.21749045f, 0.05720494f, -0.02690445f, 
    -0.13846666f, 0.28571439f, 0.32149079f, -0.20764622f, 0.00643063f, 0.07182585f, -0.03990217f, -0.10275883f, 
    -0.01138281f, 0.08320805f, -0.80835563f, -0.33095947f, -0.66184765f, -0.04888780f, 0.09044823f, -0.04406522f, 
    0.02943130f, 0.01947718f, 0.00638461f, 0.33185524f, -0.14451648f, 0.38695297f, -0.01376144f, 0.06163915f, 
    0.30010000f, 0.15176845f, 0.04815386f, 0.16724704f, -0.44204572f, 0.26860064f, -0.11926626f, 0.12012208f, 
    -0.07393921f, 0.09063918f, 0.06082424f, 0.00712789f, -0.09795469f, 0.08897360f, 0.11231911f, -0.14306831f, 
    0.05361560f, -0.10055207f, -0.04096454f, -0.02421552f, -0.04064821f, 0.15307373f, -0.03343480f, -0.08154174f, 
    -0.07302915f, -0.01084783f, -0.02056724f, -0.00123814f, -0.07289876f, -0.00632195f, -0.15227087f, -0.13406523f, 
    -0.23953830f, 0.15695271f, 0.16413754f, 0.00887696f, 0.14417963f, -0.12410469f, 0.02701040f, -0.09670454f, 
    0.19874196f, -0.20292610f, -0.07236547f, 0.08199751f, -0.06096366f, -0.14820710f, 0.03744050f, -0.05494461f, 
    -0.06010789f, 0.42965722f, 0.44185132f, -0.28330383f, 0.11310311f, 0.05677481f, -0.14856577f, 0.07995643f, 
    0.14963101f, -0.10410506f, 0.23005137f, -0.22360417f, -0.17342018f, 0.09465477f, 0.04021370f, -0.07389945f, 
    0.14116299f, -0.03034692f, -0.06098859f, -0.03988739f, 0.44960022f, -0.08249134f, -0.07203176f, 0.18110164f, 
    -0.17847762f, -0.17157780f, -0.09229059f, -0.04314069f, -0.01843492f, 0.30773053f, -0.25384223f, -0.01697995f, 
    -0.05771420f, -0.42188144f, 0.02312634f, -0.02984496f, 0.03668717f, -0.50300360f, 0.08817378f, -0.09328530f, 
    0.29838818f, -0.28391314f, 0.28715363f, 0.12169755f, 0.03578092f, 0.12153113f, 0.11930754f, 0.26349917f, 
    0.25565675f, 0.13956437f, 0.05969650f, 0.19764575f, -0.08826464f, 0.08401948f, -0.05856095f, 0.01280484f, 
    0.14053278f, 0.06119693f, -0.07096825f, 0.11471166f, -0.09354670f, 0.03801196f, -0.12068970f, 0.13359080f, 
    0.45559743f, -0.21342632f, -0.51537907f, -0.02736217f, -0.04173750f, -0.02225703f, 0.01608664f, 0.12436090f, 
    0.04613188f, 0.23716000f, -0.29662067f, -0.20815742f, 0.06614103f, -0.05047885f, -0.02945060f, 0.00568265f, 
    0.01662931f, 0.02384738f, -0.15278502f, -0.00563615f, -0.46365866f, 0.01787321f, 0.01826002f, 0.14615384f, 
    -0.10561532f, 0.06648006f, 0.14133704f, -0.28906310f, -0.14868082f, 0.12311888f, -0.07010378f, 0.10503500f, 
    0.00331998f, 0.08021879f, 0.03036193f, 0.21012063f, 0.21124981f, -0.30739897f, 0.10896576f, -0.08527657f, 
    0.20061646f, -0.07734071f, -0.22085431f, 0.11298298f, 0.09015656f, 0.24487650f, 0.11085422f, 0.03345878f, 
    0.18103717f, 0.04760002f, 0.19364472f, 0.07172016f, 0.22863655f, 0.04465135f, -0.14113453f, 0.06420898f, 
    0.10554793f, 0.11964820f, 0.05856446f, -0.05086854f, 0.01871742f, -0.08223483f, -0.42589509f, -0.14959940f, 
    -0.08549162f, -0.14035724f, -0.08507310f, -0.03037465f, 0.12094244f, 0.00633547f, -0.44529855f, -0.27522805f, 
    0.20046090f, -0.12317169f, -0.22891891f, 0.02146047f, 0.19449835f, 0.01202614f, 0.03014332f, -0.04050370f, 
    -0.18827955f, 0.10153449f, 0.24470784f, -0.34209508f, -0.02877945f, -0.14086761f, -0.18845321f, -0.00253122f, 
    0.11545790f, 0.07399666f, 0.33828431f, -0.03854154f, -0.27091011f, 0.13425724f, 0.16310877f, -0.03941178f, 
    -0.08186804f, 0.21860448f, -0.03882258f, 0.15392858f, -0.03900766f, -0.00907635f, 0.08530614f, -0.09278036f, 
    -0.01936169f, -0.05970573f, 0.01624028f, -0.12099066f, 0.32014358f, -0.15984759f, -0.20764753f, 0.09349990f, 
    0.00447066f, 0.12145393f, -0.04264893f, 0.05494742f, -0.24885687f, 0.17264470f, -0.29141349f, -0.05925211f, 
    0.21457501f, -0.28031516f, -0.01134109f, -0.14005846f, 0.13935423f, -0.23115274f, 0.07454108f, -0.04316657f, 
    -0.11533565f, -0.12348548f, -0.04243591f, -0.13551025f, -0.08957458f, 0.20882665f, 0.27901340f, -0.07747944f, 
    0.18781824f, -0.04969923f, 0.22012749f, -0.09690008f, -0.02914442f, 0.06754510f, 0.19716166f, 0.08884351f, 
    -0.08616798f, -0.03950186f, -0.08590692f, -0.00973156f, 0.07325003f, 0.00143420f, -0.00617435f, -0.04560478f, 
    -0.01924901f, 0.01311637f, -0.00170574f, -0.01956778f, 0.04384352f, -0.07128288f, -0.03276113f, -0.05345982f, 
    -0.07754510f, -0.01462553f, -0.06788628f, -0.01934851f, -0.00837801f, -0.01312419f, -0.00938291f, -0.00408099f, 
    -0.03043661f, 0.05231660f, -0.05689575f, -0.08906475f, -0.01195687f, -0.03307938f, -0.00475729f, -0.05135818f, 
    -0.02604371f, -0.07424052f, -0.06814822f, 0.01409395f, 0.07231326f, 0.06400082f, -0.06138892f, -0.00054262f, 
    -0.06572340f, 0.03147875f, -0.07808769f, 0.07450967f, -0.00552434f, -0.02409064f, -0.00515305f, -0.03802348f, 
    -0.04351180f, -0.00801204f, 0.02314113f, 0.02884163f, 0.01473636f, -0.00605263f, -0.04046663f, 0.07215420f, 
    -0.05861235f, 0.06486400f, -0.00663245f, -0.01371890f, 0.05484246f, 0.01505632f, -0.00646016f, 0.03922865f, 
    -0.06820492f, 0.07245658f, -0.08162601f, -0.05202383f, 0.07385148f, -0.04674307f, -0.01756365f, -0.03121469f, 
    -0.02191130f, -0.00791844f, -0.08033914f, -0.06472180f, -0.02370539f, -0.06688092f, 0.00866370f, -0.05454118f, 
    0.02220521f, -0.01750628f, -0.07076552f, 0.06446186f, -0.02904244f, -0.03167674f, 0.01375360f, 0.06624862f, 
    -0.04871349f, 0.00152363f, 0.03447456f, 0.05103495f, 0.04086094f, -0.07707375f, -0.00454085f, 0.05550280f, 
    0.04560559f, 0.01665206f, 0.00308233f, -0.07749043f, 0.02744308f, -0.02414637f, -0.08112966f, 0.03747366f, 
    -0.07040437f, 0.06870174f, -0.06155838f, 0.00177078f, -0.08698759f, -0.03522788f, -0.04476089f, -0.00284492f, 
    -0.06238909f, 0.06701115f, -0.07155448f, -0.00231204f, 0.01083151f, 0.00470359f, -0.05701343f, -0.08665748f, 
    0.06597082f, -0.01470224f, 0.04982207f, 0.00423031f, 0.02044002f, 0.03935681f, 0.04540754f, 0.05739354f, 
    -0.08385082f, -0.08836578f, -0.05059141f, -0.04793461f, -0.06522392f, -0.05064680f, 0.04262593f, 0.04261138f, 
    -0.08150417f, 0.00598693f, 0.01145948f, 0.02383007f, -0.01506350f, -0.04039570f, 0.01350991f, -0.05264963f, 
    -0.20478800f, -0.05527522f, -0.00229144f, 0.06850804f, -0.13867246f, 0.22033735f, 0.09987209f, 0.05163913f, 
    -0.02374336f, 0.06379357f, 0.17435856f, 0.27902597f, -0.11103413f, -0.06839199f, 0.00908501f, -0.03569961f, 
    -0.21967894f, 0.04578253f, 0.22835113f, 0.08840532f, 0.26345918f, -0.12126895f, 0.05169619f, -0.24704714f, 
    0.07662567f, -0.07600718f, -0.03676041f, 0.60986495f, -0.27209157f, -0.15317826f, -0.14045344f, -0.10509375f, 
    -0.02840029f, 0.00206818f, -0.13203548f, -0.03709197f, -0.27570057f, -0.26706794f, -0.27242190f, 0.12830499f, 
    -0.24486460f, -0.06030453f, -0.25098121f, 0.29588568f, 0.18566799f, -0.14325306f, -0.03770809f, 0.11950952f, 
    -0.01015522f, 0.03783406f, 0.24352409f, 0.07507052f, -0.04852688f, 0.11566379f, 0.46963722f, -0.19171728f, 
    -0.28853142f, 0.02956168f, -0.00114049f, 0.15393244f, 0.17012608f, 0.02853220f, 0.14122914f, 0.45392597f, 
    -0.00735971f, -0.21564025f, -0.00897257f, 0.10509566f, 0.02067838f, 0.15058570f, -0.00207335f, -0.03215677f, 
    0.00182160f, 0.16292422f, 0.00829293f, -0.15508428f, -0.21683994f, -0.31915885f, 0.06076231f, -0.06819560f, 
    0.05320023f, 0.23756313f, -0.65831530f, -0.22828425f, 0.07570798f, 0.11526730f, 0.18576959f, 0.01331364f, 
    -0.10622900f, -0.06567584f, 0.18757167f, -0.09162825f, 0.17339055f, 0.08086853f, 0.04462391f, 0.05130015f, 
    0.12663220f, 0.04705957f, -0.04888100f, 0.19172166f, 0.14454226f, 0.28219455f, -0.06140248f, 0.09860376f, 
    0.15157078f, -0.14006549f, -0.03618393f, 0.24059702f, -0.07741451f, -0.02765660f, 0.03763443f, 0.14966123f, 
    -0.05462210f, 0.10738721f, -0.07396646f, -0.09464311f, 0.33258140f, 0.36336967f, 0.51499212f, 0.41448036f, 
    -0.08510511f, -0.03861975f, -0.03367308f, -0.06610206f, -0.09255741f, 0.06325048f, 0.22477859f, -0.20369509f, 
    -0.82578135f, 0.11535332f, -0.29959404f, 0.01458930f, 0.03972402f, 0.03930092f, -0.10477552f, 0.56247652f, 
    -0.29825401f, -0.68187386f, 0.15387230f, -0.08684202f, -0.11169650f, 0.07980809f, 0.00777405f, -0.13078324f, 
    0.43006232f, -0.17033875f, -0.25890204f, -0.08961685f, 0.01567742f, -0.09840439f, 0.01925113f, -0.09559304f, 
    0.08722501f, 0.19158520f, 0.35181227f, 0.03259539f, 0.01239686f, -0.03569860f, -0.03910543f, 0.07834219f, 
    0.01317431f, 0.03167683f, -0.59736341f, -0.25463384f, -0.37716246f, 0.07934102f, 0.03809711f, 0.06561654f, 
    0.01509257f, 0.06623493f, 0.19124834f, -0.53349626f, 0.44834194f, 0.52275014f, -0.02730568f, 0.08407416f, 
    0.10095616f, -0.02735707f, 0.02572419f, 0.05977158f, -0.23506971f, 0.04223450f, 0.23908615f, -0.08259451f, 
    -0.18953365f, -0.08228964f, 0.16835070f, 0.04580983f, 0.20834251f, 0.01434998f, 0.03817567f, -0.07339785f, 
    0.03968588f, 0.09986974f, -0.02306638f, 0.10711986f, -0.01126170f, 0.03721890f, -0.27525073f, 0.09234596f, 
    0.20450535f, -0.00803883f, 0.11478567f, 0.00320219f, -0.00096076f, 0.11506274f, 0.02695564f, -0.38847491f, 
    0.12588990f, -0.05369795f, -0.19737561f, 0.02759476f, -0.12835954f, 0.05023992f, -0.01173693f, -0.07152173f, 
    0.44568384f, -0.06499878f, -0.16662937f, -0.08231451f, -0.18062361f, 0.03100260f, 0.02420535f, 0.05529502f, 
    -0.06192228f, -0.60927951f, -0.23202498f, -0.56771696f, -0.10341335f, -0.03264669f, -0.13495781f, 0.04542954f, 
    0.04817437f, 0.14570399f, 0.35388237f, -0.11045690f, -0.33108693f, 0.02310091f, 0.09648650f, 0.04003206f, 
    -0.04927249f, 0.10608796f, 0.14695199f, -0.07772782f, 0.11883492f, -0.10765073f, 0.00723167f, -0.05254294f, 
    -0.20557061f, -0.08230565f, -0.03777716f, -0.04118339f, -0.69590294f, -0.79831296f, -0.43179983f, -0.17364585f, 
    -0.10906334f, -0.15037403f, 0.12856592f, 0.00662120f, -0.09509966f, -0.55261075f, -0.47140405f, -0.45375112f, 
    -0.14297839f, -0.02120310f, -0.35907227f, -0.20493725f, -0.18764541f, 0.00776559f, -0.06502147f, 0.00383396f, 
    -0.04840094f, -0.01704204f, 0.18197060f, 0.11422803f, 0.05486729f, -0.00937513f, 0.07654151f, 0.22486211f, 
    -0.13603474f, -0.29596964f, 0.17473476f, 0.21573190f, 0.14867267f, -0.05974760f, 0.08666785f, -0.01403099f, 
    -0.13462879f, -0.24686188f, -0.63323903f, -0.17028657f, 0.06530470f, 0.00802079f, 0.05355078f, 0.12934344f, 
    0.10596960f, -0.19620909f, -0.27027100f, -0.33754054f, -0.09900223f, 0.00348621f, -0.13192959f, -0.02656494f, 
    -0.01811055f, -0.23795009f, -0.00057858f, -0.05299550f, 0.31093934f, 0.02143940f, -0.19429864f, -0.10694339f, 
    0.02073524f, 0.02814634f, 0.04262085f, 0.23578109f, -0.29491439f, -0.33733004f, 0.10905353f, -0.05575039f, 
    0.02397636f, -0.05306292f, -0.02173553f, 0.06590225f, -0.06489982f, 0.12548847f, 0.17150319f, -0.01529983f, 
    0.11711278f, -0.05162159f, 0.11321659f, 0.09953966f, -0.14680277f, 0.06458420f, -0.25342241f, -0.17173992f, 
    -0.01429633f, -0.02183339f, 0.19228241f, 0.02111210f, -0.04813105f, 0.02136009f, 0.01333528f, 0.17895383f, 
    0.08870937f, -0.05028636f, 0.06677783f, 0.07442134f, 0.01907366f, 0.07464051f, 0.13075341f, -0.00659799f, 
    -0.06560336f, -0.19164106f, -0.04579931f, -0.28907752f, 0.07248612f, -0.01301676f, 0.06587315f, 0.11674944f, 
    -0.20245370f, -0.03985190f, -0.16529271f, 0.08538353f, -0.09667922f, -0.04070228f, 0.14442024f, 0.01889422f, 
    0.09552130f, 0.31074166f, -0.30923897f, -0.09470240f, 0.07246561f, 0.19835559f, 0.09438806f, 0.03420777f, 
    0.02415582f, -0.15157418f, -0.59386295f, -0.33683839f, 0.14544471f, -0.11570361f, -0.01676485f, -0.20409757f, 
    -0.11595646f, 0.01746661f, 0.14956409f, -0.14715816f, -0.40300900f, 0.22237967f, -0.02162499f, 0.07579035f, 
    0.21802551f, 0.06211074f, 0.23069340f, -0.13422720f, 0.04902724f, 0.23287533f, 0.49548629f, -0.24021901f, 
    0.27035299f, -0.15282872f, 0.04038900f, 0.18180390f, 0.11940949f, 0.21789750f, 0.54715645f, 0.29688331f, 
    -0.00839500f, 0.07125343f, -0.18453498f, 0.06450710f, -0.00906440f, 0.06689264f, 0.14375022f, 0.06935708f, 
    0.21327405f, 0.00504954f, -0.11667472f, 0.13824105f, 0.03781434f, -0.12961470f, -0.07657896f, 0.27660808f, 
    0.13154809f, 0.29670584f, 0.08721931f, -0.21261330f, 0.30517331f, 0.03988247f, 0.08368448f, -0.11156515f, 
    0.02090843f, -0.08227199f, 0.03211191f, -0.01641445f, 0.04522786f, -0.00985817f, -0.08123078f, 0.03596102f, 
    -0.01629782f, 0.01726440f, -0.05873043f, -0.03044357f, 0.02617012f, -0.04167347f, -0.00190393f, -0.00790037f, 
    -0.00184665f, -0.02116679f, 0.00700103f, 0.03067877f, 0.03661951f, -0.08356363f, -0.08604641f, 0.02211219f, 
    -0.00786620f, -0.01826237f, 0.04447772f, -0.05377821f, 0.03126885f, -0.01966502f, 0.04979437f, 0.00207585f, 
    -0.07713291f, -0.05319150f, -0.06097094f, -0.07638513f, 0.05043329f, -0.00033688f, -0.05193113f, 0.02045937f, 
    0.03708829f, -0.02777297f, 0.01847777f, -0.09597982f, -0.08555252f, -0.09937407f, -0.03942930f, -0.09373779f, 
    -0.07494865f, -0.00512181f, -0.07288726f, -0.05386373f, -0.09197587f, -0.08380307f, 0.05104992f, -0.11498568f, 
    0.02651628f, -0.05629010f, 0.01106767f, -0.01846351f, 0.02122788f, -0.03933316f, -0.05591388f, -0.03330314f, 
    -0.09471963f, 0.04599703f, 0.04344667f, -0.00353227f, 0.00706276f, -0.04113151f, -0.07607328f, -0.05934247f, 
    -0.01725544f, 0.00324797f, 0.00727534f, -0.02500807f, -0.09085194f, -0.00740397f, -0.04217896f, -0.06784651f, 
    -0.03986709f, -0.03471847f, -0.05923630f, -0.04140506f, -0.04700769f, 0.01633788f, -0.09277454f, 0.03814593f, 
    -0.00273365f, 0.02012322f, -0.08614149f, -0.10327055f, -0.09918560f, -0.08870079f, -0.04836207f, -0.02879822f, 
    0.00416982f, 0.01856453f, -0.02944508f, 0.02955364f, -0.05033084f, -0.10772043f, -0.01046830f, -0.04492600f, 
    -0.07708979f, -0.06522435f, 0.03251596f, 0.03637474f, 0.02039558f, -0.05572977f, -0.08527520f, -0.06869374f, 
    -0.10030659f, 0.02027774f, -0.11772474f, -0.02333168f, -0.08758745f, 0.01143845f, -0.05468411f, 0.06059176f, 
    -0.01365790f, 0.05258064f, -0.04485459f, 0.01525304f, -0.01353796f, 0.02412250f, -0.01602623f, 0.02356682f, 
    -0.07853153f, -0.11021397f, -0.04302219f, 0.04020929f, -0.03783647f, -0.07473173f, -0.00653059f, -0.03595486f, 
    -0.09426460f, -0.07988663f, -0.10765167f, -0.04346188f, -0.00216016f, -0.04602119f, -0.01899675f, -0.10318989f, 
    0.29847506f, -0.19176964f, -1.01430905f, 0.03765536f, -0.29624960f, -0.27902502f, 0.09442465f, 0.01370264f, 
    -0.01110303f, -0.23157106f, -0.34248957f, -0.48290724f, 0.05504278f, -0.08617645f, -0.00922253f, 0.14486042f, 
    0.06495392f, -0.06080849f, 0.19345999f, 0.18942502f, -0.43834400f, -0.20142716f, -0.13275084f, 0.22659788f, 
    -0.08628907f, -0.11468747f, 0.16007370f, -0.20477138f, 0.23009519f, 0.14349787f, -0.01384089f, -0.04519944f, 
    -0.02355519f, 0.07336790f, 0.07196180f, 0.01155732f, 0.14065206f, 0.12366614f, 0.05432518f, 0.18036850f, 
    -0.04468893f, 0.00371010f, 0.19196659f, -0.02210194f, 0.00961287f, 0.32155219f, -0.22259434f, 0.22242106f, 
    0.01141833f, -0.05255895f, -0.13664402f, -0.01167993f, -0.08505683f, 0.01749134f, 0.16708496f, 0.09202337f, 
    0.16572382f, -0.04678980f, -0.06198170f, 0.05215950f, 0.21386738f, -0.14159726f, 0.03106523f, 0.12743556f, 
    0.04250832f, 0.38102925f, 0.01120115f, -0.03156499f, 0.01177736f, -0.01367925f, -0.04282144f, -0.00933446f, 
    0.02878709f, -0.53449184f, -0.50291449f, 0.05975334f, -0.19580869f, -0.08474641f, -0.08896080f, 0.04766835f, 
    -0.05779109f, 0.18753228f, 0.22358970f, -0.11396084f, 0.15866870f, 0.03543857f, 0.05034962f, -0.04235053f, 
    -0.09994505f, 0.11594476f, 0.04441613f, -0.39500532f, -0.18069467f, -0.05848552f, -0.08601374f, 0.00480108f, 
    -0.09706971f, 0.09501962f, -0.11957838f, 0.15809545f, 0.13377634f, 0.11915179f, 0.19226153f, 0.07719081f, 
    -0.08274695f, 0.26119193f, -0.12769683f, 0.08530706f, 0.14591262f, 0.15584157f, 0.23931366f, -0.14423278f, 
    0.04682431f, -0.02779491f, -0.03419461f, -0.09512103f, -0.32822779f, 0.43655941f, 0.09036665f, 0.39112458f, 
    0.09097668f, 0.02567894f, -0.09238566f, 0.12079310f, -0.00199779f, 0.11668426f, -0.04495241f, -0.06906682f, 
    -0.10604452f, -0.06127505f, 0.08798370f, 0.23625284f, -0.07209822f, -0.08408792f, 0.14560242f, -0.00874063f, 
    0.21173936f, 0.25036785f, 0.11667919f, 0.07102504f, 0.06818701f, 0.15552914f, 0.01490005f, -0.13832180f, 
    0.21164450f, 0.30672348f, 0.07099152f, 0.06175272f, -0.04648468f, -0.14209314f, -0.01776055f, 0.17588358f, 
    -0.15730037f, 0.01903802f, -0.10780548f, -0.01022573f, -0.03144588f, 0.11707682f, 0.21407896f, 0.03142425f, 
    0.01062293f, -0.29460177f, 0.09370415f, 0.10562866f, 0.16923313f, 0.10143460f, -0.02449337f, 0.11848883f, 
    -0.15719873f, -0.18153641f, -0.03959477f, -0.06520615f, -0.41000718f, 0.21923034f, -0.03957049f, 0.02584087f, 
    0.30845639f, 0.17717627f, 0.17054808f, 0.37262392f, 0.19568792f, 0.07528045f, 0.33913639f, -0.00470078f, 
    -0.02962931f, 0.14776416f, 0.24109414f, 0.07533024f, 0.25893047f, 0.34370989f, 0.31315750f, 0.08805539f, 
    0.04454165f, 0.11544134f, -0.15614831f, -0.10449393f, 0.01718449f, -0.03128811f, 0.02733197f, -0.08686350f, 
    -0.01911918f, -0.00420151f, 0.07597442f, -0.10435867f, -0.01147283f, -0.13128278f, -0.14859845f, -0.01889150f, 
    0.11017466f, 0.08920899f, -0.05676785f, -0.04970492f, -0.20328370f, -0.13130270f, 0.02142607f, -0.26952749f, 
    0.08358048f, 0.02316116f, 0.01335106f, -0.09044909f, 0.17031629f, -0.01859599f, 0.02698008f, -0.02224016f, 
    -0.31155142f, -0.22914322f, 0.32866842f, 0.69110155f, -0.22041725f, -0.21812935f, 0.28738448f, -0.03898887f, 
    0.05332524f, 0.08190995f, 0.20480785f, 0.27432930f, 0.13507397f, -0.14442162f, 0.13085583f, 0.09726044f, 
    0.04102395f, 0.22019416f, -0.15152536f, -0.12157235f, 0.01317529f, 0.07079715f, 0.07242957f, 0.02200712f, 
    -0.00573310f, 0.04603100f, 0.07500117f, -0.01411322f, 0.03863876f, -0.12990905f, -0.10820872f, 0.16002610f, 
    0.09981106f, 0.01699270f, -0.11883186f, -0.30902937f, -0.14433935f, 0.03521422f, 0.09378168f, -0.09345879f, 
    0.35639060f, 0.10454143f, 0.07206219f, -0.23234954f, -0.11681352f, -0.07491556f, 0.04526827f, -0.20831929f, 
    -0.08538894f, -0.04352197f, 0.23287554f, 0.14826474f, -0.01544226f, 0.17341781f, 0.19154741f, 0.12416483f, 
    0.03942296f, -0.10171429f, 0.07415362f, 0.08141678f, 0.04258436f, 0.10839251f, 0.06958116f, 0.21221329f, 
    0.13179713f, -0.07051411f, 0.14080225f, -0.02447540f, 0.16869774f, 0.07793892f, 0.14506267f, 0.19175369f, 
    0.00173516f, -0.03422168f, -0.03773611f, 0.14613743f, -0.07108955f, 0.04125842f, -0.13248497f, 0.02534869f, 
    0.06912939f, 0.14028800f, 0.30426434f, -0.75732583f, -0.14869273f, -0.09292860f, -0.01045266f, -0.15022571f, 
    0.07422636f, -0.17333308f, 0.10966036f, -0.35414672f, -0.54370564f, -0.58437610f, -0.24003404f, 0.33930793f, 
    -0.11379061f, 0.01050245f, 0.05251947f, 0.09962365f, 0.05055328f, 0.00781501f, 0.25025463f, -0.06851980f, 
    -0.06721289f, -0.25663042f, 0.12180578f, -0.04702535f, 0.01288911f, 0.40965912f, 0.06844727f, 0.29786438f, 
    0.02978566f, -0.16409887f, 0.09859876f, 0.06429605f, 0.06319616f, 0.11316073f, -0.15766887f, -0.18610668f, 
    0.10036115f, -0.01212984f, 0.16561414f, 0.06381778f, 0.19422857f, 0.12469356f, -0.00602870f, -0.08739082f, 
    -0.38557592f, -0.01044862f, 0.00030540f, -0.13446280f, -0.02692714f, -0.07103756f, -0.03398731f, -0.08161406f, 
    0.02386540f, -0.03598862f, -0.01641138f, 0.02867693f, 0.03677423f, 0.07841352f, -0.06654163f, -0.04930357f, 
    -0.10686064f, -0.25824246f, -0.13077287f, -0.70734411f, 0.05372657f, 0.31171802f, -0.01234415f, 0.15814999f, 
    -0.12752026f, -0.24075554f, -0.06254830f, 0.25740525f, 0.34558952f, 0.03519610f, -0.03562125f, 0.04614416f, 
    0.15071806f, -0.05615417f, 0.07000979f, -0.02604166f, 0.29194048f, 0.11258980f, -0.06333748f, -0.01671720f, 
    -0.25628576f, -0.05756327f, -0.02462270f, 0.05746045f, -0.19097292f, -0.41835171f, 0.29557520f, -0.24259460f, 
    0.17028274f, -0.12176919f, 0.07699387f, 0.29721868f, 0.20135881f, -0.14169808f, 0.25220463f, 0.17623106f, 
    -0.16565859f, -0.28380132f, -0.08737116f, 0.16176249f, -0.06099165f, 0.12607698f, 0.05216666f, -0.47156000f, 
    -0.27637056f, -0.09652416f, -0.05437594f, -0.13625541f, 0.14062217f, -0.11945645f, 0.22167714f, -0.13056852f, 
    -0.15546247f, 0.00158802f, 0.04215628f, 0.17168921f, 0.18217699f, 0.09071546f, -0.03322063f, -0.01148353f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.10423465f, 0.32587406f, -0.03590066f, 0.21387142f, 0.24549146f, 0.31673345f, 0.04964096f, 0.22596835f, 
    0.02375027f, -0.25979090f, 0.29398397f, -0.10535587f, -0.03035353f, 0.04659286f, 0.04096905f, 0.10060202f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03377650f, 0.16289303f, -0.06988736f, -0.33574086f, 0.03436716f, 0.13386439f, 0.24380699f, 0.15289707f, 
    0.14897782f, -0.14096001f, 0.20637558f, -0.46000782f, 0.16333497f, -0.03708838f, 0.41565165f, -0.42847219f, 
    -0.23118494f, -0.03718342f, 0.27974108f, -0.16740045f, 0.02007601f, 0.49434376f, 0.07521508f, -0.45037806f, 
    0.08220901f, -0.22883748f, 0.53274661f, 0.39741340f, 0.08945610f, -0.26313826f, -0.13016307f, -0.31885573f, 
    0.39519474f, -0.27840158f, 0.22373423f, 0.20348538f, 0.25906360f, 0.03695463f, -0.13722493f, 0.20765013f, 
    0.11721651f, -0.22543991f, -0.12760513f, -0.48619401f, -0.19989583f, 0.09076359f, -0.18030660f, 0.49790975f, 
    0.14855537f, -1.11174417f, -0.02964817f, 0.12125061f, -0.11401954f, -0.02015550f, 0.04429064f, -0.08796101f, 
    -0.19874623f, -0.18641613f, -0.41313493f, 0.26939347f, -0.18025336f, 0.14202152f, 0.27913356f, 0.46637684f, 
    -0.18279263f, 0.06216088f, 0.19262679f, 0.42266408f, 0.03885716f, -0.20108749f, 0.07429278f, 0.16677958f, 
    0.13954325f, -0.32961696f, 0.73450947f, -0.32106438f, -0.15357392f, -0.41571894f, 0.03354867f, 0.21734022f, 
    0.34231848f, -0.31715247f, 0.20105448f, -0.22703302f, 0.06390481f, -0.16078669f, -0.19422475f, -0.04239962f, 
    -0.06903981f, 0.17262425f, 0.30521986f, 0.04722854f, -0.18887481f, 0.10778065f, -0.04078805f, 0.53541166f, 
    -0.20659432f, 0.28758523f, -0.18127404f, 0.43821910f, 0.16115738f, -0.13191786f, -0.12986712f, 0.16077033f, 
    0.19127087f, -0.19668329f, -0.20246829f, 0.43465826f, 0.01196348f, 0.12463186f, 0.12739679f, 0.44723675f, 
    0.17539513f, 0.04272621f, -0.06858390f, -0.14196447f, -0.24314462f, -0.10118517f, 0.19593042f, 0.06564882f, 
    0.10086945f, 0.10090128f, 0.13682710f, -0.15184547f, 0.15959756f, 0.04626091f, -0.23053509f, -0.01651959f, 
    -0.15524513f, 0.19601262f, 0.31111762f, 0.59860444f, 0.33844593f, -0.13283083f, -0.01513163f, -0.02539351f, 
    -0.16168182f, -0.47599211f, 0.21414348f, 0.18401052f, 0.15081400f, -0.23907009f, -0.04640494f, 0.19321279f, 
    0.42307365f, 0.20678461f, -0.04574493f, 0.04414342f, -0.13003078f, 0.60372072f, 0.18930236f, 0.16538695f, 
    0.15433326f, 0.21324785f, 0.09993628f, 0.09221702f, 0.19899602f, -0.19008727f, -0.26674649f, -0.05311526f, 
    -0.24688792f, -0.28641191f, -0.24736971f, 0.15641028f, -0.07431097f, 0.13258693f, -0.07308153f, 0.14311710f, 
    -0.01026866f, 0.02234250f, -0.23237155f, 0.15541759f, -0.15972450f, -0.12172547f, 0.02969792f, -0.18372987f, 
    -0.06751949f, -0.20175877f, -0.24214156f, -0.25877091f, -0.16209249f, 0.18748061f, 0.02765549f, 0.17391725f, 
    0.22007516f, -0.24893910f, 0.12614420f, -0.21467276f, -0.09236939f, -0.06275028f, -0.11894976f, -0.24463257f, 
    0.17257513f, -0.10227683f, 0.54621029f, 0.57650226f, -0.12985416f, 0.01241174f, -0.08143803f, -0.15725514f, 
    -0.19085088f, -0.09470398f, -0.16447611f, 0.27858266f, -0.08823269f, -0.21884809f, -0.19499674f, 0.63120812f, 
    -0.07730845f, -0.13108212f, 0.35773426f, -0.04996660f, 0.06820854f, -0.13799679f, 0.19381210f, 0.06979244f, 
    -0.09753054f, 0.06232396f, -0.09908942f, 0.39053696f, -0.23472363f, 0.32126904f, -0.34616634f, -0.75269085f, 
    0.18279670f, -0.40192258f, 0.33600691f, -0.36083916f, 0.24340884f, 0.12852640f, -0.36286288f, -0.05287834f, 
    0.23337610f, 0.11969003f, -0.65254039f, 0.40810469f, 0.06142108f, 0.46970254f, -0.12505971f, 0.22404164f, 
    0.20142445f, -0.69746614f, -0.25784588f, -0.34275651f, 0.02837836f, 0.67297238f, 0.08101501f, -0.13651006f, 
    0.14647479f, 0.22098005f, 0.03807345f, 0.27607372f, 0.01031468f, -0.00751828f, 0.17834954f, 0.44397891f, 
    -0.16745600f, 0.22229439f, -0.11035831f, 0.29554588f, 0.32174996f, -0.19517815f, 0.27785674f, 0.11638055f, 
    0.16485962f, -0.11528485f, 0.25534654f, 0.27440381f, 0.14958765f, 0.36517715f, -0.22031373f, 0.36667222f, 
    -0.03412444f, 0.46026093f, -0.36573958f, -0.26777971f, 0.27456301f, 0.28747076f, 0.40495822f, -0.23507889f, 
    -0.21489315f, -0.80603534f, -0.26503092f, 0.17384562f, 0.13439690f, 0.13311937f, -0.23528568f, 0.15657724f, 
    -0.26840922f, 0.24735925f, -0.32999948f, 0.30847195f, -0.11129162f, 0.07025104f, 0.35813788f, -0.16675040f, 
    0.20078282f, 0.01705577f, 0.50745070f, 0.05945841f, -0.13728608f, 0.08667100f, 0.17912462f, 0.09903415f, 
    0.24901091f, -0.06288693f, -0.21527623f, 0.52380627f, -0.00749541f, 0.02269617f, 0.57604772f, 0.27840438f, 
    0.22116013f, -0.00212059f, -0.10807893f, -0.24921122f, 0.09395066f, -0.21873054f, 0.20263067f, 0.10616187f, 
    -0.24310839f, -0.13620915f, -0.04883992f, 0.01066739f, 0.19867545f, 0.18562065f, -0.44446421f, 0.38538331f, 
    0.01574643f, -0.44613212f, 0.18993641f, 0.32592487f, -0.01227824f, 0.44724700f, -0.13541710f, 0.35859686f, 
    -0.02662647f, 0.12063497f, 0.25827420f, -0.11669570f, -0.26411685f, -0.24658231f, -0.16132332f, 0.00308730f, 
    -0.00960329f, -0.43873784f, 0.51525009f, 0.32353455f, -0.24730301f, 0.26060316f, 0.04513991f, 0.30591825f, 
    0.00935272f, 0.19601294f, -0.01269726f, -0.08023149f, 0.17332160f, -0.02343931f, -0.03217367f, -0.14159517f, 
    -0.16643307f, -0.33899668f, -0.92278874f, 0.34997389f, -0.18206330f, 0.40835971f, 0.14423868f, 0.16421242f, 
    0.02462236f, -0.01073667f, 0.27641138f, -0.52480900f, 0.21401684f, 0.45012838f, -0.21361643f, -0.29375505f, 
    -0.02281949f, -0.35558900f, -0.18504614f, 0.08953001f, 0.07383980f, 0.05424396f, 0.11473980f, -0.77879298f, 
    -0.19458725f, -0.41582388f, -0.13781324f, 0.12944479f, 0.02359414f, 0.16770138f, -0.20967847f, 0.43253180f, 
    0.19905703f, -0.25268099f, 0.43756413f, 0.06700692f, -0.07852963f, 0.57552958f, 0.17385964f, 0.16259724f, 
    0.30148411f, -0.03745057f, -0.25102872f, 0.16399434f, 0.08493575f, -0.03392848f, 0.39914197f, 0.02337986f, 
    0.12456144f, -0.04050839f, -0.28866109f, -0.37629735f, -0.19019155f, 0.05024308f, 0.28940764f, 0.30784118f, 
    -0.23404206f, 0.06529367f, -0.05732365f, -0.16748525f, 0.06673819f, -0.15365772f, 0.17777556f, 0.23735528f, 
    -0.02137771f, -0.14833407f, 0.13694926f, -0.24223702f, 0.01608885f, -0.21414454f, 0.47256172f, -0.41861555f, 
    0.26835307f, 0.21032253f, 0.02043546f, 0.16574594f, -0.34455714f, 0.26227340f, -0.12381043f, 0.11646704f, 
    0.06158658f, 0.03965149f, -0.89177406f, 0.39133555f, 0.20269166f, 0.08437508f, 0.14000459f, -0.28357092f, 
    0.01308912f, -0.29202014f, 0.15075342f, 0.07825694f, 0.08701954f, 0.29331639f, -0.39501351f, 0.24929488f, 
    0.01092415f, -0.77216876f, -0.03301230f, -0.32001010f, -0.18282880f, -0.40697849f, 0.36953864f, -0.07963621f, 
    0.07426721f, -0.04384424f, 0.35482988f, -0.26809323f, 0.35417655f, 0.08708689f, -0.39591223f, -0.08885334f, 
    0.12198141f, -0.32012820f, 0.48961559f, 0.18177874f, -0.09774720f, -0.20348804f, -0.16746299f, 0.26290491f, 
    0.13238283f, 0.31690252f, 0.23666997f, -0.25748190f, -0.02987774f, 0.11727380f, 0.62729901f, 0.29764178f, 
    0.19822608f, -0.03601106f, 0.23493513f, -0.15015140f, 0.16912134f, -0.24063435f, -0.07656744f, -0.54695052f, 
    -0.21371910f, -0.04196293f, -0.23483045f, 0.32250780f, 0.17181633f, -0.32676166f, -0.13331096f, 0.00538264f, 
    -0.18970999f, 0.09129491f, 0.00663403f, -0.12638921f, -0.12195980f, 0.31118038f, -0.28059179f, -0.07694038f, 
    0.22580817f, -0.57742047f, 0.23936971f, 0.01923962f, -0.54629385f, 0.10190104f, -0.35240608f, -0.03456927f, 
    0.02035395f, 0.02443543f, 0.15413420f, 0.10228230f, 0.06733478f, 0.27693829f, 0.38084653f, -0.21426548f, 
    0.29733914f, -0.38327998f, -0.01595872f, 0.02347462f, -0.45272642f, 0.02502832f, -0.24729094f, -0.16376373f, 
    0.09744495f, -0.20263794f, 0.25866646f, 0.24494548f, -0.04139248f, 0.43042168f, 0.37644932f, 0.16235219f, 
    0.35983083f, -0.04752233f, 0.02271066f, 0.30517596f, 0.04154167f, -0.50397259f, -0.40392402f, -0.09428268f, 
    0.22841591f, 0.33295614f, -0.08253012f, -0.20941879f, 0.00257487f, 0.30841583f, 0.10422932f, 0.05500097f, 
    -0.10144398f, 0.22102484f, -0.24118607f, 0.13089956f, 0.04568413f, -0.17672066f, 0.24137108f, 0.29163745f, 
    0.19737811f, -0.06431764f, -0.42834187f, -0.22694094f, 0.16754891f, 0.37868449f, 0.38786566f, 0.01630781f, 
    0.07919794f, -0.23559758f, -0.02869225f, -0.04799628f, -0.24720994f, 0.12446707f, -0.02497876f, -0.22755894f, 
    0.16742635f, 0.11580852f, -0.11517733f, -0.16700348f, 0.23684311f, -0.22699925f, -0.11926335f, -0.12407830f, 
    0.26064217f, -0.22623190f, 0.44623959f, 0.36409763f, 0.26171827f, -0.28395462f, -0.02588435f, 0.35700181f, 
    0.21306510f, 0.18216346f, 0.04130071f, 0.27704412f, -0.15497388f, 0.12682454f, -0.39950427f, 0.26932344f, 
    0.38000888f, -0.33482620f, 0.05017288f, 0.06249063f, 0.36257246f, -0.01338238f, 0.03521634f, 0.16510309f, 
    0.13152838f, -0.26571295f, 0.44558182f, 0.51870126f, 0.21524899f, 0.10588701f, -0.38654310f, 0.05356934f, 
    0.28801176f, -0.21937661f, 0.18963425f, -0.59982395f, 0.00107129f, 0.25137553f, -0.25857908f, 0.01988341f, 
    0.08305176f, 0.15836821f, 0.49019161f, -0.17513157f, 0.01193014f, -0.27303734f, -0.06176983f, -0.09783421f, 
    -0.18066339f, 0.09881154f, 0.35059047f, -0.49402136f, 0.00291392f, -0.38744375f, 0.23574743f, 0.14020750f, 
    0.00472475f, 0.11907450f, 0.29790887f, 0.08866697f, 0.04558145f, -0.01256519f, 0.00509685f, 0.38581392f, 
    -0.03472440f, -0.24067339f, 0.06812190f, 0.27702898f, -0.11779779f, -0.09347965f, -0.21896729f, 0.14803383f, 
    0.17481121f, 0.22535881f, 0.31719622f, 0.50726467f, 0.25508368f, -0.08553625f, 0.05246210f, 0.22363493f, 
    -0.15596059f, -0.06589554f, -0.37416500f, 0.38597170f, 0.06193414f, 0.15729037f, 0.33478045f, 0.20166852f, 
    0.09516541f, 0.06594172f, 0.45464551f, 0.18797067f, 0.10895019f, 0.47408283f, -0.05590977f, 0.25163183f, 
    0.21620975f, -0.18621890f, 0.20628183f, -0.17936832f, 0.53243369f, -0.06596838f, -0.03311656f, -0.04895354f, 
    -0.06435739f, -0.22492526f, -0.69604087f, 0.25787911f, -0.06941696f, 0.17052944f, -0.33581352f, -0.31828558f, 
    0.35262004f, -0.03948558f, 0.24034753f, 0.47775760f, -0.20819008f, -0.08944634f, 0.29830790f, 0.13143484f, 
    0.11135117f, 0.28608966f, -0.04185348f, 0.24514590f, 0.27499655f, -0.01463878f, -0.25858325f, 0.24923664f, 
    0.02812055f, -0.08227248f, -0.16419698f, -0.22902314f, -0.51118487f, 0.20032667f, 0.35260659f, 0.32833537f, 
    -0.21985419f, -0.26151672f, 0.42499459f, -0.46406570f, 0.18178605f, 0.41845134f, 0.46596330f, 0.04453368f, 
    0.13540620f, -0.09879935f, -0.24460632f, -0.22388059f, 0.02169082f, -0.05038510f, -0.01444548f, -0.13402182f, 
    -0.24809074f, -0.03590464f, -0.20424186f, -0.06291549f, -0.23546791f, -0.00209926f, -0.04353919f, 0.16537869f, 
    0.08850225f, 0.16316099f, 0.03370397f, -0.46343538f, -0.01436350f, 0.34402099f, 0.05129452f, 0.25875822f, 
    0.17468269f, -1.03636193f, -0.37136880f, 0.21285599f, -0.01311364f, 0.35516584f, 0.20294243f, -0.56710196f, 
    0.33373436f, 0.23295330f, 0.38480264f, 0.18923748f, -0.29533282f, -0.01616585f, 0.16906807f, -0.27108341f, 
    0.21678725f, -0.28903350f, -0.78492630f, 0.34151614f, -0.17845109f, -0.22709481f, 0.15687287f, 0.08787327f, 
    0.26553592f, -0.14337821f, -0.10355465f, 0.67123210f, -0.18713674f, 0.19451027f, 0.46890980f, 0.19534865f, 
    0.09686387f, 0.33763576f, 0.48712975f, 0.03714702f, 0.07011741f, 0.18486412f, -0.23102914f, 0.04641534f, 
    -0.21720219f, -0.13194306f, -0.00340248f, 0.36816180f, 0.22412615f, 0.29753301f, -0.46578398f, -0.42696357f, 
    -0.05195951f, -0.02723002f, -0.17231005f, 0.21068853f, -0.09391299f, 0.14056619f, 0.31180924f, 0.00773658f, 
    -0.20769018f, 0.01731097f, -0.54755616f, -0.05260826f, 0.07611268f, 0.26052165f, 0.42368296f, 0.00602945f, 
    -0.24430095f, -0.14842428f, 0.39443356f, 0.20757662f, -0.10265063f, 0.29359904f, 0.07396904f, -0.13623053f, 
    0.39332092f, -0.01919714f, -0.02403546f, 0.63033205f, -0.30719727f, 0.06538247f, -0.23546202f, 0.05532164f, 
    -0.08243009f, 0.07484750f, 0.21195571f, 0.03124574f, -0.02032845f, -0.22718041f, -0.17839158f, -0.09614886f, 
    -0.09200756f, 0.20577507f, -0.08251699f, -0.22504611f, -0.21788698f, -0.13608989f, -0.14821780f, 0.17617416f, 
    0.08023152f, -0.21267970f, 0.05443390f, 0.01697211f, 0.10638537f, -0.00143763f, -0.01818907f, -0.00281404f, 
    0.06588266f, -0.24137084f, -0.00715354f, 0.10577940f, 0.01044590f, -0.00872247f, -0.21448949f, -0.21968696f, 
    0.23870715f, -0.02673370f, -0.21569346f, -0.12180782f, 0.17339788f, 0.03320923f, -0.13217071f, 0.09679777f, 
    -0.10842434f, 0.03603932f, -0.19759378f, -0.02073976f, -0.10498542f, -0.24034283f, -0.11940020f, -0.12255570f, 
    -0.02087325f, 0.05654147f, -0.12564042f, -0.12462679f, 0.01330292f, -0.12151581f, -0.11822727f, -0.01017967f, 
    0.47313371f, -0.16735885f, 0.34276184f, -0.15875129f, -0.08363622f, -0.33473369f, 0.23904619f, 0.54042411f, 
    0.24239971f, 0.22486871f, 0.17223974f, -0.08633083f, -0.00617974f, 0.49106851f, -0.26344016f, 0.07186022f, 
    0.15402515f, -0.42102355f, 0.40656394f, -0.21262884f, 0.10666472f, 0.17213176f, -0.11760207f, -0.01816026f, 
    -0.20716338f, 0.15461761f, -0.79547727f, 0.41172403f, -0.16790037f, 0.30411953f, -0.27878889f, -0.40895465f, 
    0.05217015f, 0.06393683f, 0.42074275f, -0.00801401f, 0.04897438f, -0.04668733f, -0.38234827f, -0.33182538f, 
    0.17181909f, -0.17512639f, 0.36737424f, 0.13479827f, -0.25804457f, -0.07777600f, -0.21458024f, 0.23989077f, 
    0.12778412f, 0.33463460f, -0.18275256f, 0.08642440f, -0.16539012f, 0.20662029f, 0.33183339f, 0.14951122f, 
    0.18465698f, -0.30018562f, -0.67604464f, 0.51806307f, 0.17251317f, 0.42856702f, 0.01907391f, -0.11212893f, 
    -0.03164163f, 0.12035683f, -0.18849134f, -0.00600249f, -0.11892286f, -0.19117022f, 0.15669364f, -0.24025938f, 
    -0.07408783f, -0.14744648f, -0.14891729f, 0.18967313f, 0.19214234f, -0.12228504f, -0.04715356f, -0.04319623f, 
    -0.40803939f, 0.18915276f, 0.15256405f, -0.44251037f, 0.20816395f, -0.08820950f, 0.02963676f, -0.28075048f, 
    0.00993986f, -0.21489665f, 0.13754624f, -0.19732146f, 0.08930305f, -0.28324705f, 0.42600462f, 0.17605431f, 
    -0.30219123f, 0.09791686f, 0.35915563f, -0.22181538f, 0.14882812f, -0.41908732f, 0.06905149f, 0.22657432f, 
    -0.05710697f, 0.07792002f, -0.03004602f, 0.30956972f, 0.12393931f, 0.05084262f, -0.02985568f, 0.01617545f, 
    -0.13498208f, -0.05064743f, -0.36582094f, 0.48843691f, -0.15170518f, 0.09862518f, -0.12465576f, -0.23865615f, 
    -0.05478218f, 0.18985623f, 0.38798884f, 0.25860214f, -0.13926660f, 0.32917681f, 0.17131735f, 0.60757011f, 
    0.19816436f, -0.00330673f, 0.34844607f, -0.61659384f, -0.12769093f, 0.01531263f, 0.04259058f, 0.29249093f, 
    -0.16466565f, -0.03584426f, -0.05852911f, 0.12629966f, -0.02525413f, -0.04657821f, -0.10519953f, -0.62399268f, 
    -0.26893872f, 0.07960671f, -0.20155825f, -0.21906145f, -0.16068195f, -0.15865053f, -0.57873815f, -0.20197813f, 
    -0.10513934f, 0.25046381f, -0.05059235f, -0.01269226f, 0.21527222f, -0.77184314f, -0.03419484f, -0.66803247f, 
    0.37225512f, -0.47242054f, 0.60817724f, -0.23003687f, 0.19821721f, 0.23613259f, -0.21415439f, 0.08848809f, 
    0.18705341f, -0.08942293f, 0.18329255f, 0.23951198f, -0.00315075f, -0.52572727f, -0.34643996f, 0.30404955f, 
    0.26165542f, 0.08475107f, 0.09769436f, -0.03131162f, -0.28506607f, -0.07785141f, 0.04109779f, -0.11852797f, 
    0.00642842f, 0.08404680f, -0.31920743f, 0.32617190f, -0.00249712f, 0.01618624f, 0.12686761f, 0.32848674f, 
    0.24032511f, 0.11467797f, 0.03563941f, -0.21003954f, -0.06242592f, -0.17363013f, -0.13637438f, -0.24787557f, 
    -0.03169811f, -0.24151972f, -0.18909577f, -0.19509536f, 0.20243792f, 0.06805822f, -0.21738240f, 0.06903882f, 
    -0.10730256f, -0.01742219f, -0.10617670f, 0.22270103f, 0.22057942f, 0.49494311f, 0.50337839f, -0.35572344f, 
    -0.06512962f, -0.03149907f, 0.58663344f, -0.09236486f, 0.19973232f, -0.31041828f, -0.22679177f, 0.14482608f, 
    0.18558402f, -0.16485460f, 0.46672940f, 0.28115842f, 0.22026494f, -0.23312427f, 0.26876709f, 0.22096904f, 
    -0.09704089f, -0.21503979f, 0.57816416f, -0.12348923f, 0.03323225f, -0.24047063f, -0.15010111f, -0.09445930f, 
    0.01736236f, -0.36847612f, 0.24269079f, 0.19624454f, -0.07072937f, 0.43416008f, 0.01361914f, -0.12185517f, 
    0.06020369f, -0.68048036f, -0.21414916f, -0.45115340f, -0.02670551f, -0.53147471f, 0.32555974f, 0.26339889f, 
    0.32118005f, -0.43280327f, 0.00716023f, -0.09543344f, -0.22578827f, 0.12349587f, 0.04372378f, -0.14032866f, 
    0.22657925f, 0.34629270f, -0.69205523f, 0.26614362f, 0.25868392f, 0.36694664f, 0.00101809f, 0.46197173f, 
    -0.14820260f, 0.27277407f, 0.12909754f, -0.11813152f, -0.01498850f, 0.11966651f, -0.33625674f, 0.10807904f, 
    -0.06832325f, -0.30401880f, -0.23638709f, 0.05912402f, 0.05855835f, 0.23064120f, -0.09047633f, -0.03843173f, 
    0.32402968f, -0.94317377f, 0.35366184f, -0.00181287f, -0.33525190f, 0.09981562f, -0.23693034f, 0.23852184f, 
    -0.15307775f, 0.14841761f, 0.03543701f, 0.00240669f, -0.10744435f, 0.08230288f, -0.01018123f, 0.18016043f, 
    0.13477220f, -0.26781800f, 0.09511978f, 0.66016591f, -0.06993143f, 0.32732770f, 0.08269677f, -0.25895533f, 
    0.19904007f, 0.12046554f, -0.13241026f, 0.00800768f, -0.17513797f, -0.42635491f, 0.00000489f, -0.06759787f, 
    -0.18627308f, 0.14373733f, -0.12194466f, -0.22988120f, -0.14775246f, -0.16362931f, 0.22368668f, 0.18642554f, 
    -0.19006455f, -0.18994276f, -0.20830435f, -0.11567139f, 0.24895780f, 0.18486795f, -0.10079100f, -0.07279233f, 
    0.34472018f, 0.09517469f, -0.06838157f, -0.40733516f, -0.20470360f, 0.21739499f, -0.33251759f, 0.00463994f, 
    0.11646675f, 0.12305002f, 0.37249875f, -0.56335151f, 0.07039797f, 0.25794902f, 0.22525774f, -0.17667080f, 
    -0.34697941f, 0.20310570f, 0.04227776f, 0.01564522f, 0.34433195f, 0.06774446f, 0.27193773f, 0.10222346f, 
    0.06851529f, -0.30730382f, 0.08456452f, 0.06683378f, -0.03342880f, -0.46942848f, 0.03855090f, 0.06327690f, 
    0.27381569f, -0.10611533f, 0.34238660f, 0.55265373f, 0.11948107f, 0.20341063f, 0.11996090f, -0.18574049f, 
    0.11434488f, -0.12895572f, -0.20699094f, -0.19264038f, 0.04417775f, -0.35965568f, -0.23180042f, 0.20525739f, 
    -0.51154375f, -0.06724545f, 0.00678542f, -0.38141415f, 0.15034921f, -0.01407182f, 0.05543910f, -0.21401650f, 
    0.00113502f, 0.25793925f, -0.66740698f, 0.26582050f, -0.25764039f, -0.02702653f, 0.10536509f, -0.53880203f, 
    0.42782071f, -0.47322327f, 0.24409185f, -0.24258602f, 0.24542464f, 0.41385520f, -0.23471518f, 0.12631139f, 
    0.04731368f, -0.18756282f, 0.57953113f, -0.50200510f, 0.10120174f, 0.03500072f, -0.25956890f, -0.14933887f, 
    -0.13384733f, 0.28745237f, 0.12330572f, -0.49332008f, -0.17978759f, -0.03752460f, 0.01156524f, 0.21388336f, 
    -0.13358065f, 0.07003740f, 0.48409164f, -0.19068453f, 0.06514191f, 0.07847629f, 0.11243688f, -0.57967031f, 
    -0.59842402f, -0.13797761f, 0.09365300f, -0.13782497f, 0.22663072f, -0.28910679f, -0.12047195f, 0.16286197f, 
    0.11114228f, 0.13669141f, -0.53400588f, 0.08036096f, -0.07751086f, -0.31255272f, 0.29835281f, -0.20569895f, 
    -0.00547818f, -0.29167837f, -0.19587623f, 0.70546001f, 0.12416507f, 0.47148368f, 0.27531841f, 0.03934542f, 
    -0.04982515f, 0.00277434f, 0.02316927f, -0.14043702f, 0.13077720f, 0.14681093f, -0.17188357f, 0.14178763f, 
    0.49311355f, 0.03771412f, -0.02794480f, -0.10264812f, -0.15087664f, 0.36212909f, -0.00651260f, 0.33919838f, 
    -0.05299420f, 0.10747273f, 0.09533653f, -0.09719662f, -0.20275915f, 0.37956151f, -0.14481047f, -0.49628189f, 
    0.49311051f, -0.37911475f, 0.13825850f, -0.42588928f, 0.06700318f, 0.24000257f, 0.34536782f, -0.31439769f, 
    -0.06440023f, 0.18723924f, -0.53533101f, 0.02375920f, -0.00636759f, -0.29111654f, 0.18952949f, -0.11262375f, 
    -0.31094339f, 0.24482746f, 0.06216239f, -0.23510733f, 0.22283241f, 0.36704844f, 0.13179642f, -0.20546032f, 
    -0.10764718f, -0.26475629f, 0.04610261f, 0.09931386f, 0.15109664f, -0.45024133f, -0.01416737f, 0.14210892f, 
    0.07788764f, 0.16735327f, 0.11718621f, -0.08625494f, 0.09663051f, 0.08328211f, 0.37337220f, 0.11293734f, 
    -0.00516238f, -0.31103888f, 0.55253327f, -0.45206049f, -0.04632064f, -0.29521453f, 0.22556503f, -0.27096161f, 
    -0.02523227f, 0.31564185f, 0.01447300f, 0.47425550f, -0.27741909f, -0.16016172f, 0.24615361f, 0.44869846f, 
    -0.23946346f, -0.39361483f, -0.18247890f, -0.09824302f, -0.14988773f, -0.45243776f, 0.24026744f, -0.02020679f, 
    -0.02269059f, 0.01559052f, -0.20735575f, 0.12063331f, 0.28692156f, 0.34685898f, 0.25090536f, 0.00129127f, 
    0.15406238f, -0.00087473f, 0.24956125f, -0.02059501f, -0.01150677f, -0.00535454f, -0.23931439f, -0.13720436f, 
    0.23576638f, -0.34200537f, 0.42819956f, 0.00096729f, 0.42407650f, 0.28472841f, -0.48829883f, 0.08082637f, 
    -0.21488868f, -0.28623098f, -0.00149379f, -0.11684582f, -0.01355588f, -0.29282060f, -0.03490604f, 0.02327989f, 
    0.09098489f, 0.50971127f, -0.37419742f, -0.32628551f, -0.08987451f, 0.14272922f, 0.27837107f, 0.25600493f, 
    -0.05497938f, -0.61644411f, 0.33545113f, -0.26898289f, -0.17910345f, 0.06777439f, 0.47585192f, -0.28634053f, 
    0.02074148f, 0.29116091f, -0.17402989f, -0.27706981f, -0.10969918f, 0.25203139f, 0.21708889f, 0.29773524f, 
    -0.08235393f, -0.25055727f, 0.12224679f, -0.06562675f, -0.14232124f, -0.01874097f, 0.35167873f, -0.55484122f, 
    -0.35424036f, -0.10360125f, 0.37273976f, 0.03641202f, 0.32086775f, -0.13792807f, -0.60187835f, 0.02649034f, 
    0.15815276f, -0.41607621f, 0.07600015f, 0.35326052f, -0.09888612f, -0.30745256f, 0.28815737f, 0.03557890f, 
    0.02584429f, -1.00336015f, -0.17760642f, 0.53903943f, -0.27104869f, 0.10610414f, 0.10624287f, 0.25428078f, 
    -0.11055022f, -0.46678028f, -0.39924955f, 0.39115211f, -0.02764857f, 0.17169516f, 0.18397637f, -0.00273043f, 
    0.26929533f, 0.19535930f, -0.33296144f, -0.13799652f, 0.02368324f, 0.27859652f, 0.26306629f, -0.28486779f, 
    0.11905681f, 0.26824924f, -0.23393479f, 0.40108249f, -0.24196751f, 0.40325731f, -0.20979342f, 0.41452518f, 
    -0.10520677f, 0.30099571f, -0.16312331f, -0.25364530f, 0.38215083f, -0.18958026f, 0.24993777f, 0.41991431f, 
    0.03871610f, -0.47607425f, 0.09953258f, -0.28595269f, -0.21610907f, 0.04253297f, 0.39335331f, -0.08748888f, 
    0.00654105f, 0.49991050f, 0.13794422f, -0.27148724f, 0.39278069f, 0.12761015f, -0.07978833f, 0.13165326f, 
    0.04084176f, -0.89691269f, 0.05868375f, 0.16282876f, -0.19808339f, 0.22173639f, -0.43126896f, 0.21739383f, 
    -0.35859406f, -0.19979684f, 0.03598054f, -0.07285696f, 0.45965132f, -0.29527229f, -0.24166675f, 0.15762921f, 
    0.08444656f, -0.42048043f, -0.04792998f, 0.28874227f, -0.12095077f, 0.10125336f, 0.14818394f, 0.27049190f, 
    -0.01345483f, -0.08140716f, 0.01490018f, -0.21326278f, -0.02575300f, -0.20931596f, -0.09700495f, 0.49225089f, 
    -0.05813846f, 0.09121511f, -0.15494154f, -0.21067530f, 0.23413113f, 0.58402884f, 0.29105237f, -0.06006350f, 
    0.44069830f, -0.44352344f, 0.30338296f, 0.08798447f, -0.16145420f, 0.33534116f, -0.09561336f, 0.19828613f, 
    -0.14764152f, -0.50029480f, 0.01433225f, 0.36863270f, -0.09322219f, 0.21909045f, -0.00486339f, -0.12205430f, 
    0.07854015f, 0.06597476f, 0.37928000f, 0.60740495f, -0.15718816f, -0.43325257f, -0.01496109f, 0.32092959f, 
    -0.06385448f, -0.30696470f, 0.25172022f, -0.57959938f, -0.01933229f, 0.06826003f, 0.24953942f, -0.02064978f, 
    0.30515254f, -0.54132402f, -0.40806958f, -0.31757993f, -0.14224416f, 0.04319079f, 0.21646738f, 0.02068650f, 
    0.08353686f, 0.29408285f, -0.08958478f, 0.13136479f, 0.03621760f, 0.61902344f, 0.25845456f, 0.25437140f, 
    -0.15916580f, 0.11028273f, -0.07586537f, -0.19387449f, 0.07115777f, -0.00568695f, 0.03583995f, -0.20429014f, 
    0.24838632f, -0.27509895f, -0.12349111f, -0.08882527f, -0.03047076f, -0.11531609f, -0.06611373f, 0.01776396f, 
    0.02196112f, -0.53700662f, -0.17204815f, 0.58235699f, -0.05373902f, -0.07894426f, 0.13530326f, 0.04967629f, 
    0.21926683f, -0.72802311f, -0.00835503f, -0.12735760f, 0.23896234f, 0.15002806f, 0.41615289f, 0.04070705f, 
    0.25011981f, -0.20174737f, 0.27222672f, 0.03082958f, 0.22760829f, 0.16778995f, 0.30651098f, 0.39521730f, 
    0.03536499f, -0.18324538f, -0.39181730f, 0.38755563f, 0.25200745f, -0.02534625f, -0.29790187f, -0.11775251f, 
    -0.25812387f, 0.04080730f, 0.09582992f, 0.20487528f, 0.28836057f, 0.19769895f, -0.65539867f, -0.19358736f, 
    -0.14727408f, -0.22364867f, -0.26524359f, 0.06109657f, 0.27798444f, -0.06012384f, 0.18032429f, 0.07224452f, 
    0.07766136f, -0.27332926f, -0.22575976f, 0.08370104f, -0.00083546f, -0.46135843f, 0.41104400f, 0.46908242f, 
    -0.23584986f, 0.27065107f, -0.26704901f, -0.59899759f, -0.23326205f, -0.10934835f, -0.04637865f, -0.32870001f, 
    -0.12572134f, 0.11437212f, -0.06316752f, -0.13895574f, -0.19959544f, -0.25558370f, 0.00368960f, -0.26677093f, 
    0.23549567f, 0.05805317f, 0.23707987f, 0.08845343f, -0.03070658f, -0.03454259f, -0.24885415f, -0.19485627f, 
    0.06757858f, -0.18683206f, -0.06976709f, -0.17499001f, 0.29378617f, -0.05514004f, -0.33541438f, 0.14364344f, 
    0.05319907f, -0.12655801f, 0.22007433f, -0.29088902f, -0.17615972f, 0.43846104f, 0.19464862f, -0.16841811f, 
    0.37787926f, -0.22833765f, -0.25404820f, -0.49797073f, -0.08760547f, 0.40387070f, -0.26409602f, 0.36052066f, 
    -0.04672027f, -0.00040943f, 0.08175586f, -0.51191401f, -0.12546763f, 0.08533469f, 0.26770213f, -0.49099427f, 
    0.21387349f, 0.09606727f, 0.11408172f, 0.06489376f, 0.00366900f, 0.63256687f, 0.13197637f, -0.37268546f, 
    0.03963308f, 0.04238743f, -0.53242731f, -0.01390032f, 0.00828105f, -0.30151194f, 0.12145409f, -0.31488228f, 
    0.01819294f, 0.10755368f, -0.01810700f, 0.12527975f, 0.19149296f, 0.37852469f, 0.49930957f, -0.07539205f, 
    0.23511818f, -0.33982462f, 0.83122283f, -0.21190313f, -0.29171744f, -0.39179713f, 0.04706231f, -0.39597890f, 
    0.29296449f, 0.24218571f, -0.18776451f, -0.09933081f, -0.04245933f, -0.01146438f, 0.30306539f, -0.17186414f, 
    -0.20969562f, -0.14659424f, -0.18806396f, -0.27349499f, -0.07466526f, -0.04434888f, 0.28833273f, -0.00694055f, 
    -0.16529460f, 0.12340216f, 0.16000898f, 0.38751972f, -0.00434240f, -0.45967543f, -0.08426590f, 0.01903473f, 
    0.04135847f, -0.07419437f, 0.54191208f, -0.60760212f, 0.03331232f, -0.44390729f, 0.32402024f, 0.26704186f, 
    0.04049217f, 0.34964743f, -0.21623930f, 0.38721877f, -0.18018922f, 0.35496989f, 0.20772028f, 0.09783938f, 
    0.06033361f, 0.19150737f, 0.59058523f, 0.06023160f, -0.17031839f, 0.12247601f, -0.25580344f, 0.01165135f, 
    -0.00360502f, -0.75273651f, 0.22885355f, 0.07256311f, -0.05024846f, -0.20528929f, 0.11004616f, -0.10217348f, 
    0.02323438f, -0.06587052f, -0.28007999f, 0.02130092f, 0.07134565f, -0.05809127f, 0.27927679f, 0.43940920f, 
    0.09002048f, -0.21209428f, -0.13371065f, -0.07291979f, -0.13790599f, 0.04208919f, 0.17115951f, 0.16404864f, 
    -0.23925802f, -0.23312604f, 0.03468692f, 0.02785087f, 0.13251525f, -0.22055733f, -0.22536850f, -0.13261560f, 
    0.39321646f, -0.57568520f, 0.58477896f, 0.11601660f, 0.17266175f, -0.33537829f, -0.11210902f, 0.10033908f, 
    -0.11579245f, -0.05250967f, -0.16104127f, 0.17537582f, -0.00980286f, -0.13098058f, -0.14446349f, 0.68987095f, 
    0.55693299f, -0.20769837f, -0.08237764f, -0.14239202f, -0.19003269f, 0.23032126f, 0.03942799f, 0.28569049f, 
    -0.12265855f, 0.34610400f, -0.07271875f, -0.29765344f, 0.01445991f, -0.07054318f, -0.11560934f, 0.38241592f, 
    0.29740426f, 0.09558447f, -0.02548448f, 0.31339422f, 0.26388681f, 0.15528855f, 0.36002785f, 0.16227756f, 
    0.19085032f, -0.43119162f, 0.26189089f, -0.33480874f, 0.13697423f, -0.20410232f, 0.07703138f, -0.31730413f, 
    -0.13013096f, 0.27984154f, -0.27473131f, -0.26739818f, -0.38753507f, 0.40901390f, -0.01455855f, 0.01715603f, 
    -0.04239864f, -0.76216578f, 0.10987417f, -0.15541102f, -0.07816041f, 0.04819202f, 0.59432107f, 0.19027381f, 
    0.43619618f, -0.31044263f, -0.31174970f, 0.07670517f, -0.37262708f, 0.48660153f, -0.21642138f, 0.54098350f, 
    0.08913428f, -0.07473204f, -0.26079813f, -0.22512010f, 0.02490093f, 0.20984112f, 0.19887272f, 0.11327414f, 
    -0.01213954f, 0.35180181f, 0.41599083f, 0.15297873f, 0.24242581f, 0.19922084f, 0.13235702f, -0.27117851f, 
    -0.16564697f, -0.64410150f, -0.27750552f, 0.10584237f, -0.18476160f, -0.31336927f, -0.50299913f, 0.13254233f, 
    0.24919219f, 0.25742233f, 0.33976269f, 0.15448622f, 0.25246564f, 0.20104557f, -0.04238441f, -0.38519645f, 
    0.10197544f, -0.61409527f, -0.24670921f, 0.23171493f, 0.01156818f, -0.23295897f, -0.43607047f, 0.15818065f, 
    0.24969442f, 0.03127838f, 0.12425942f, -0.43033931f, 0.16105011f, 0.36182594f, 0.66828388f, -0.10265161f, 
    -0.08889791f, 0.13182472f, 0.48080078f, -0.43037489f, -0.03116266f, -0.55194676f, -0.04090480f, -0.54657787f, 
    -0.31546560f, -0.42431131f, 0.02149296f, 0.35858643f, -0.02189095f, -0.18010564f, 0.19696696f, 0.40743712f, 
    -0.00256556f, -0.52474588f, 0.14632697f, -0.13800631f, -0.11213604f, 0.39231876f, 0.15408804f, 0.16388747f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08051720f, 0.07392886f, 0.25029567f, 0.02716583f, -0.17703210f, -0.15655720f, 0.39156124f, -0.11770244f, 
    -0.03792727f, 0.51046360f, -0.28170598f, 0.15964736f, -0.05876981f, -0.14557613f, 0.05283292f, 0.11155955f, 
    0.04761505f, 0.52684563f, -0.07438686f, -0.04111365f, 0.06116071f, -0.34653786f, 0.08625995f, 0.22113809f, 
    0.32234699f, 0.32177386f, 0.19403988f, -0.05937522f, 0.50064987f, 0.19934887f, -0.14103308f, -0.38662013f, 
    0.04296361f, -0.45105860f, -0.21054438f, -0.09416883f, -0.23073718f, -0.22518502f, 0.07115463f, 0.17911981f, 
    -0.25132352f, -0.45376343f, -0.10978218f, 0.53574526f, -0.05690671f, 0.11481821f, -0.11292493f, 0.25815147f, 
    -0.10066066f, -0.05093502f, -0.13956442f, 0.25538042f, 0.43302196f, -0.09689551f, 0.18190753f, -0.00208446f, 
    -0.00646202f, -0.05313802f, 0.02414391f, -0.01253764f, -0.23731086f, 0.30403969f, -0.31370959f, -0.16379264f, 
    0.06890772f, -0.00103619f, 0.27516192f, -0.39170983f, 0.23703198f, 0.39259458f, 0.17332417f, 0.33994448f, 
    -0.04420960f, -0.15433872f, -0.18948455f, 0.21740486f, -0.01077553f, 0.13956843f, 0.21709259f, 0.17279300f, 
    -0.22636701f, 0.27859065f, -0.03285968f, 0.21911995f, 0.05185497f, 0.18253899f, 0.05984155f, 0.15066761f, 
    0.25694531f, 0.50975317f, 0.42134675f, 0.52241552f, 0.28484577f, 0.46303001f, 0.05677166f, 0.08302844f, 
    0.28420734f, 0.37654749f, 0.19942062f, 0.29207173f, 0.33496815f, 0.48911488f, 0.05227799f, 0.10980432f, 
    -0.04642050f, 0.03369630f, 0.38583532f, 0.15761814f, 0.03069303f, 0.16749345f, 0.35469383f, 0.55644023f, 
    0.12664713f, 0.52109897f, 0.26757964f, 0.16811618f, -0.20579559f, 0.04500998f, -0.01969275f, 0.07590811f, 
    -0.24356192f, 0.30584136f, 0.38826191f, 0.08012421f, 0.16959362f, -0.09716007f, -0.05425989f, -0.08490133f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.26805714f, 0.09070513f, -0.39593166f, 0.18789308f, 0.00524042f, 0.14231411f, -0.14006384f, 0.01354513f, 
    0.09687720f, -0.03776002f, -0.07525692f, -0.02961609f, 0.24985264f, 0.27123132f, 0.16184732f, -0.09982663f, 
    -0.20947710f, -0.52562982f, 0.02586814f, -0.40705079f, -0.12559021f, 0.45856223f, 0.01065301f, 0.08229365f, 
    -0.10038441f, -0.68472493f, -0.14738217f, 0.17558771f, -0.20873685f, 0.05780718f, 0.03936558f, 0.10419358f, 
    0.29344910f, 0.20701057f, 0.05123317f, -0.14205271f, -0.00552212f, 0.16058947f, 0.06324325f, -0.00039357f, 
    0.18143857f, 0.28047079f, -0.19031292f, 0.07348255f, 0.18481235f, -0.09229103f, -0.06836057f, 0.08122754f, 
    0.16088609f, -0.06157842f, -0.14886022f, -0.38378564f, 0.31917199f, -0.08355537f, -0.01555957f, 0.01987027f, 
    0.19236352f, 0.22024642f, 0.16627134f, -0.02770818f, 0.00765698f, -0.15292318f, 0.20235889f, -0.22846781f, 
    0.25712988f, 0.15159796f, 0.21135156f, 0.12318960f, 0.08987813f, -0.63281703f, 0.08429383f, 0.03370381f, 
    0.14026874f, -0.15184997f, 0.40621501f, -0.06768649f, 0.07396372f, -0.10242181f, -0.18897280f, -0.21889906f, 
    -0.00115712f, -0.21771468f, 0.13880822f, -0.07213955f, -0.69483650f, 0.05754139f, 0.08621149f, -0.25301954f, 
    -0.45726344f, -0.58155423f, -0.28187200f, -0.00148518f, -0.73284024f, -0.05483904f, 0.23612203f, 0.16692357f, 
    -0.03973175f, -0.44854733f, -0.25711411f, 0.18680608f, -0.08868136f, 0.13316169f, -0.73670471f, 0.03657765f, 
    0.05757369f, -0.00102109f, 0.10082488f, -0.12974221f, -0.12996221f, -0.02323107f, -0.37331337f, -0.39315799f, 
    -0.01984648f, -0.71013612f, -0.35312870f, -0.12393457f, 0.08316605f, 0.21832381f, 0.07526182f, 0.35834539f, 
    -0.02160551f, -0.59684873f, -0.44610044f, -0.14628994f, -0.21624586f, -0.00428968f, -0.15874882f, -0.21149401f, 
    -0.21582448f, 0.14749289f, 0.15462296f, -0.34471303f, 0.05244284f, -0.07548750f, 0.01218433f, 0.01442172f, 
    0.04052807f, 0.08430271f, -0.04063011f, -0.04341625f, 0.27376875f, 0.33040565f, -0.02623816f, -0.32235995f, 
    0.06273383f, 0.26992446f, 0.06713793f, 0.13155657f, -0.48851785f, -0.91913754f, 0.08035310f, 0.16006649f, 
    -0.58304787f, 0.04590075f, -0.34067374f, 0.09718391f, -0.18489552f, -0.12219509f, 0.16017631f, 0.01402182f, 
    -1.06555176f, -0.93327469f, 0.01267342f, -0.09102592f, 0.04602929f, 0.10987443f, 0.05573361f, -0.15563606f, 
    -0.15231490f, -0.01228615f, 0.03851648f, 0.32053292f, 0.22987072f, -0.31800231f, -0.07268355f, 0.15669067f, 
    0.14306943f, 0.19415836f, -0.20042807f, 0.02210562f, 0.45968369f, 0.05260695f, -0.11603747f, 0.05187276f, 
    0.03954847f, 0.16669178f, -0.09991991f, 0.11893547f, 0.05733914f, -0.22542298f, -0.00778605f, 0.07729424f, 
    0.19912757f, -0.31412473f, 0.04372443f, -0.00491616f, -0.02558245f, 0.09482759f, 0.20461451f, -0.32703674f, 
    -0.02452737f, -0.46925044f, -1.13397861f, 0.27533782f, 0.02612714f, -0.19131151f, -0.05938328f, 0.30004659f, 
    0.07042455f, -0.06575356f, -0.14516804f, 0.10337088f, 0.22106721f, 0.04422738f, 0.03220021f, -0.08825670f, 
    0.00714558f, 0.32049179f, 0.07525729f, -0.04517713f, -0.26204985f, -0.12134530f, -0.39663255f, -0.43433198f, 
    0.01055947f, -0.15986924f, 0.07334019f, -0.55044049f, -0.24275964f, 0.03121288f, 0.52612978f, -0.21175918f, 
    0.07444721f, -0.79059845f, 0.17523691f, -0.04067761f, -0.98340100f, 0.00768424f, -0.33627698f, -0.30496210f, 
    0.22209030f, 0.02108016f, -0.04803895f, 0.06821351f, 0.09542165f, -0.22796987f, -0.07636954f, 0.03070495f, 
    -0.04302398f, 0.12363850f, -0.66643900f, -0.28130355f, 0.39302540f, 0.29812947f, 0.15521231f, -0.37905744f, 
    0.13286254f, 0.32547644f, 0.12386286f, -0.99200469f, -0.30225402f, -0.08759396f, -0.27672970f, 0.03555641f, 
    -0.23290588f, 0.15147778f, -0.05585873f, 0.02216837f, -0.47112048f, 0.19846489f, -0.80442536f, -0.08390437f, 
    -0.07081984f, 0.10171251f, -0.23494315f, -0.06904710f, -0.19814442f, 0.44997376f, -0.42075568f, 0.26055571f, 
    0.18944749f, -0.09544066f, -0.06088982f, -0.26577768f, 0.49969399f, 0.06001050f, 0.18760444f, 0.20801686f, 
    -0.02493086f, 0.05187014f, 0.11224797f, -0.04542221f, -0.06929392f, -0.22975194f, -0.08846153f, 0.14248854f, 
    -0.14464395f, -0.43477932f, -0.10212927f, -1.27870929f, -0.30277941f, 0.24996398f, 0.03322452f, 0.28851852f, 
    -0.48323339f, -0.11363803f, -0.30599618f, 0.00114836f, 0.41797772f, -0.09139652f, 0.01530175f, 0.03260047f, 
    0.10594409f, -0.40153027f, -0.14885679f, -0.49984893f, 0.08269916f, 0.01675162f, -0.05146067f, -0.43700463f, 
    0.34620231f, 0.14458916f, -0.05224760f, -0.30625421f, -0.06149866f, 0.13403147f, 0.09995797f, 0.44528276f, 
    -0.35850406f, 0.05692326f, -0.54187858f, 0.00841282f, -0.01189934f, 0.23026818f, -0.01518969f, -0.07929444f, 
    0.03510949f, 0.74360746f, 0.11979338f, 0.07529015f, 0.01635866f, 0.16010605f, 0.05463431f, -0.00528324f, 
    0.20838526f, -0.10889486f, 0.09271971f, 0.15045564f, 0.17673509f, 0.17859103f, -0.16002291f, -1.12111890f, 
    -0.09596681f, 0.09091803f, 0.06158832f, -0.44420218f, 0.04035849f, 0.20065641f, -0.27833834f, -0.13277572f, 
    -0.09262948f, -0.10063136f, -0.05942470f, -0.12583789f, -0.07601016f, 0.02955998f, 0.16445401f, 0.59015501f, 
    -0.01210026f, 0.36411965f, 0.01666832f, -0.14365999f, -0.10907018f, -0.38339946f, -0.08395293f, -0.69796604f, 
    0.08321117f, 0.10610807f, 0.27817357f, 0.25698858f, -0.50268805f, -0.83733147f, 0.29178104f, -0.16407277f, 
    0.08560147f, -0.24684013f, 0.26700535f, 0.30640757f, -1.16450596f, 0.17340328f, -0.55022591f, 0.00731921f, 
    -0.51862854f, 0.08903081f, -0.01194729f, -0.06821350f, -0.08051723f, -0.05912188f, 0.07205835f, 0.18974480f, 
    -0.39550099f, -0.30613631f, -0.76497173f, 0.06403051f, -0.49497554f, -0.31565487f, -0.09177496f, -0.02305883f, 
    -0.02671678f, 0.09965392f, 0.13221768f, 0.02314749f, 0.00349694f, -0.12717339f, 0.05906819f, -0.30900285f, 
    0.24986063f, 0.19443658f, -0.75481808f, -0.08468070f, -0.05034730f, 0.08776212f, -0.05957323f, 0.27586943f, 
    -0.13539077f, -0.04509008f, -0.11926028f, -0.19254641f, 0.13759091f, 0.08799924f, -0.05400654f, -0.08892617f, 
    0.05489071f, 0.11103739f, -0.23226672f, -0.13353121f, -0.27784753f, -0.03815241f, -0.07099544f, 0.08141082f, 
    0.18302397f, 0.03987358f, -0.18908238f, -0.06205355f, -0.07634120f, -0.24191457f, -0.31640407f, -0.54070145f, 
    0.05456205f, -0.30123582f, 0.10681371f, 0.06959502f, -0.06689911f, 0.05577943f, 0.05388590f, 0.14447038f, 
    0.19900090f, -0.19716689f, 0.39991474f, 0.16971773f, -0.05232963f, 0.22951269f, -0.13806520f, 0.05977596f, 
    -1.06891978f, 0.33601147f, -0.02498801f, -1.51481450f, 0.09601336f, 0.19987358f, 0.24278803f, -0.18404563f, 
    -0.03989427f, 0.00385410f, -0.04208276f, 0.09769344f, -0.13678329f, 0.05467525f, -0.46465337f, 0.22180223f, 
    -0.01135814f, -0.20171417f, -0.59943020f, -0.31672546f, -0.00202329f, 0.11847233f, -0.73019218f, 0.18596140f, 
    0.04431675f, 0.33054337f, 0.09672321f, -0.32043496f, -1.16450727f, 0.02014998f, 0.01837826f, 0.41838408f, 
    0.11835400f, -0.20169097f, 0.07659283f, -1.31060433f, 0.08273634f, 0.18481997f, -0.06450162f, 0.09586819f, 
    0.66131276f, 0.07410578f, -0.03607768f, 0.25855872f, -0.56374478f, -0.27650461f, 0.39064866f, 0.02621610f, 
    -0.11723047f, 0.01617930f, -0.43087170f, 0.07753570f, -0.31552544f, 0.00651020f, 0.15004130f, -0.04767620f, 
    -0.38285047f, 0.02072292f, -0.09059115f, -0.05440119f, -0.11537871f, 0.07100487f, 0.12649584f, 0.21069223f, 
    0.05380689f, 0.17599268f, -0.06585988f, -0.10258406f, 0.32428592f, 0.01843843f, 0.20213300f, 0.12278721f, 
    0.15756944f, -0.05405137f, -0.53885388f, 0.18384133f, -0.01580221f, -0.11607327f, -0.18971136f, -0.05458390f, 
    0.16165096f, 0.23856837f, 0.14706548f, 0.10975707f, 0.05079397f, -0.03081918f, -0.08768768f, -0.11930133f, 
    -0.23219992f, 0.13665335f, 0.17383748f, -0.13622464f, -0.04746784f, 0.06727258f, 0.01465206f, 0.18995225f, 
    0.05377350f, 0.03074147f, 0.36170518f, 0.24440457f, 0.23824729f, -0.05119758f, 0.01810284f, 0.08679391f, 
    -0.07285965f, 0.07126811f, -0.16522661f, 0.23717448f, -0.07852493f, -0.23523995f, -0.10816139f, 0.45295686f, 
    -0.06398574f, -0.66456205f, -0.30863029f, 0.10401346f, 0.07197514f, -0.34581783f, -0.94909751f, -0.09140752f, 
    0.19641832f, 0.08464936f, -0.31618050f, -0.00878688f, 0.02120331f, 0.06695929f, -0.59279770f, -0.42407650f, 
    -0.32405937f, -0.25399521f, -0.07529612f, -0.06438232f, -0.00622092f, 0.21496361f, -0.03950214f, -0.21006338f, 
    -0.33665991f, -0.35706994f, -0.05521578f, -0.03732504f, 0.05605962f, 0.06489871f, -0.17958307f, 0.33190337f, 
    0.18162064f, -0.04537952f, 0.04560790f, -0.23962614f, 0.04604848f, 0.12567860f, -1.39423859f, 0.22618246f, 
    -0.02626402f, -0.01046807f, -0.06989419f, 0.10041139f, -0.53232688f, -0.02299065f, 0.14545338f, 0.23282690f, 
    0.03993377f, -0.36854023f, -0.02543834f, -0.07907431f, 0.15477487f, -0.21444194f, 0.06551011f, -0.30337620f, 
    -0.00854671f, -0.24456674f, 0.40715554f, 0.23082393f, -0.29032055f, -0.07598276f, -0.59796321f, -0.06533626f, 
    -0.12226524f, -0.16902636f, 0.31551188f, -0.43239793f, -0.26847646f, 0.15268563f, 0.21687627f, -0.07336167f, 
    0.02950413f, -0.02996610f, -0.00582867f, -0.08290461f, 0.02106611f, 0.08528432f, 0.15219882f, -0.15288785f, 
    0.22396967f, 0.31124479f, -0.20858753f, -0.05469788f, 0.34654856f, 0.10916395f, 0.15270182f, 0.04805468f, 
    0.08643883f, 0.06988534f, -0.26309311f, -0.14079389f, -0.27004504f, 0.21328357f, -0.05805191f, -0.08373570f, 
    -0.42376766f, -0.18964861f, -0.01076763f, 0.08803912f, 0.04507558f, 0.15973955f, 0.19965085f, -0.12105864f, 
    0.12117010f, -0.02923613f, 0.05340627f, 0.35990325f, 0.01610895f, -0.11050898f, 0.03314942f, 0.03670717f, 
    0.01937092f, -0.14381021f, -0.21311727f, -0.09834322f, -0.83832866f, 0.02634489f, -0.07873037f, 0.02171285f, 
    0.26494667f, 0.09981612f, 0.14605969f, -0.02133261f, -0.02089557f, -0.03968624f, 0.16437048f, -0.14451788f, 
    0.06254771f, -0.33044475f, -0.01020026f, -0.02385925f, 0.00236223f, -0.32791191f, 0.01634656f, -0.47363439f, 
    -0.02183785f, 0.16882288f, -0.40721458f, -0.47315913f, -0.09484126f, -0.07606459f, -0.09046552f, -0.13488966f, 
    -0.22521369f, 0.01781139f, -0.16248460f, 0.19679433f, -0.17016891f, 0.04523242f, -0.12948708f, -0.12564866f, 
    -0.13814674f, -0.14207891f, -0.02501617f, 0.12939395f, -0.12751876f, -0.05170575f, 0.11351870f, -0.58296955f, 
    0.06846929f, 0.19455856f, 0.56508696f, 0.51945263f, 0.22576720f, 0.03902988f, 0.02327486f, 0.05946806f, 
    -0.11428303f, -0.49313745f, 0.11634861f, 0.05796139f, 0.37049821f, -0.06517525f, 0.20174642f, -0.12259588f, 
    -0.35010961f, -0.40752575f, -0.02883388f, -0.15573332f, -0.24527688f, 0.01679450f, 0.08094580f, 0.17768475f, 
    0.05558659f, -0.01587010f, -0.44460654f, -0.14449733f, 0.29701072f, 0.21164736f, -0.49588859f, 0.09668634f, 
    0.23819771f, -0.29618487f, -0.53708065f, -0.55113018f, 0.23120759f, -0.29359007f, 0.13103683f, -0.07007818f, 
    0.10661853f, -0.28597179f, -0.06379131f, -0.08560949f, -0.64776605f, -0.10539140f, -0.56282467f, -1.00712812f, 
    0.01686320f, -0.72128791f, 0.18722904f, 0.10604247f, -0.80548882f, 0.61275840f, -0.54431838f, -0.67087269f, 
    -0.01443032f, 0.13264167f, 0.28511691f, -0.21713966f, -0.09099531f, 0.10351960f, 0.39546216f, -0.02009994f, 
    0.05718365f, 0.04639181f, -0.13465717f, 0.13953884f, 0.00454467f, -0.39522681f, -0.74570382f, -0.03383312f, 
    0.18826321f, -0.25859648f, -0.03388146f, -0.17960180f, -0.33860776f, 0.21577781f, 0.03955111f, -1.00195491f, 
    -0.43527645f, -0.24129817f, -0.37764540f, 0.16456963f, -0.61326534f, 0.05072873f, -0.07098303f, -0.04596781f, 
    -0.12580070f, -0.31097633f, 0.07524703f, -0.66555285f, -0.08347990f, 0.21937571f, 0.02029924f, -0.12100486f, 
    -0.37952492f, -0.17611305f, -0.72920901f, -0.02630692f, -0.03921553f, -0.12191524f, 0.13274409f, -0.63464433f, 
    -0.25103116f, -0.01408891f, -0.10146137f, -0.52232695f, -0.01891385f, 0.13229790f, 0.07823984f, -0.41614023f, 
    -0.01085839f, -0.14079636f, 0.43019989f, 0.15517390f, -0.35129943f, -0.38200986f, -0.48309258f, -0.00578913f, 
    0.27037671f, 0.28582340f, -0.14540076f, -0.42550987f, 0.47476411f, 0.25542572f, 0.03003039f, -0.42891765f, 
    -0.27511045f, 0.28777799f, -0.53909057f, 0.06915293f, 0.11827834f, -1.03503227f, 0.26667431f, -0.30024856f, 
    -0.01338072f, 0.12175646f, -1.04151213f, -0.03355787f, -0.47247419f, -0.08526342f, 0.13422157f, 0.29331863f, 
    -0.54596633f, 0.16671136f, 0.16842514f, 0.28297427f, -0.05940642f, -0.30383965f, -0.04416996f, -1.05279601f, 
    -0.48406735f, 0.18725601f, 0.38776559f, -0.76005530f, 0.13056400f, -0.10817037f, 0.12783045f, 0.11623369f, 
    -0.13436668f, -0.36547101f, 0.21677844f, 0.58304554f, -0.18232000f, 0.24061280f, 0.08419192f, -0.03126188f, 
    -0.02654720f, -0.07078417f, -0.02537895f, -0.09970405f, 0.21752304f, -0.10379532f, -0.27227786f, 0.55701762f, 
    0.13936029f, -0.56616932f, 0.04760253f, 0.04945563f, 0.12990776f, -0.41924655f, -0.36696839f, -0.24365659f, 
    0.13659485f, 0.14946517f, -0.40160590f, -0.43421116f, -0.79074794f, -0.50893742f, -0.66912138f, 0.00794964f, 
    0.46343905f, 0.11017699f, -0.03775994f, -0.00918100f, -0.02572487f, -0.07209586f, -1.07576859f, 0.07230954f, 
    0.14484258f, -0.02830141f, 0.10591099f, -0.49829552f, 0.12023715f, 0.13860394f, -0.08055285f, -0.40052021f, 
    -0.27073702f, 0.12535332f, -0.02195790f, -0.08720564f, -0.49491224f, -0.01014215f, 0.00365087f, 0.01817073f, 
    0.08734553f, -0.37579608f, 0.19492416f, -0.57897669f, 0.08236593f, 0.03383382f, -0.10995094f, 0.24588086f, 
    -0.23085353f, 0.23372757f, -0.29367891f, 0.09715705f, -0.04955491f, 0.18569669f, -0.48216146f, 0.46897075f, 
    0.15636337f, -0.21381220f, 0.64365888f, -0.13459164f, 0.01127879f, 0.11483541f, 0.00075582f, 0.10260538f, 
    -0.38659984f, -0.53752798f, 0.03240848f, -0.36609769f, 0.05598375f, -0.39664537f, -0.30730516f, 0.07051713f, 
    -0.19010092f, -0.37583640f, -0.00840912f, -0.56856567f, -0.39183065f, -0.70759821f, -0.70473129f, -0.33260605f, 
    0.18434326f, -0.17409028f, -0.34000206f, -0.27255747f, -0.18812436f, -0.71772897f, -0.54097283f, 0.42360917f, 
    -0.09100197f, 0.18267201f, -0.62414712f, -0.02263670f, 0.27205729f, 0.05357784f, -0.22785866f, -0.32716909f, 
    -0.42612234f, -0.77994668f, 0.05328819f, -0.04379172f, 0.12578800f, 0.36806479f, 0.02378809f, 0.12652072f, 
    0.14257619f, -0.49758974f, 0.45524073f, -0.04626963f, -0.21739410f, -0.10238340f, -0.32242784f, 0.00477485f, 
    -0.11834940f, 0.50866377f, -0.08392677f, -0.11973742f, 0.22038558f, 0.21133117f, 0.10363209f, -0.09609129f, 
    0.11532691f, -0.03114111f, -0.06234438f, 0.00475235f, -0.02677306f, -0.76096541f, -0.12634812f, 0.47671711f, 
    0.20837417f, -0.48318917f, 0.10409442f, -0.00619507f, 0.30809289f, -0.44015282f, -0.70108551f, -0.52639884f, 
    0.33850783f, -0.15226546f, -0.24317829f, -0.68244296f, -0.79331225f, 0.25272048f, 0.16440363f, -0.18163109f, 
    0.26821339f, -0.37596762f, -0.18307526f, -0.20449872f, 0.00573325f, 0.16008870f, 0.56780064f, 0.16088653f, 
    0.08201979f, 0.20599881f, 0.21144691f, -0.62554669f, -0.08183404f, -0.68267810f, -0.03177363f, -0.79767662f, 
    -0.77148831f, 0.10184149f, 0.01606818f, 0.20408137f, -0.58337486f, 0.02664254f, 0.01720218f, 0.00052405f, 
    -0.03370589f, -0.24577071f, 0.15855958f, -0.50175512f, -0.03641739f, 0.05784979f, 0.10586782f, 0.10488824f, 
    -0.52360320f, -0.64431429f, 0.46687099f, -0.36686471f, -0.02360360f, 0.30054188f, 0.25469458f, -0.51039314f, 
    -0.35765582f, -0.33590841f, -0.13214675f, 0.10930967f, -0.04707705f, -0.20042168f, 0.19208911f, -0.05678191f, 
    0.09973705f, 0.46936256f, 0.06029600f, -0.12863968f, 0.10552045f, -0.10213488f, 0.01969631f, 0.08097582f, 
    0.10703672f, -0.32660189f, 0.17965442f, 0.11992092f, -0.34417623f, -0.16534668f, 0.13630067f, 0.07762954f, 
    0.00101775f, 0.09840071f, -0.16800259f, 0.27205965f, -0.37065056f, 0.00848296f, -0.31399080f, -0.05745276f, 
    0.06845491f, -0.70052415f, 0.19665121f, -0.07130165f, -0.92133123f, -0.04383026f, 0.00747157f, -1.03721642f, 
    -0.18333013f, 0.15283687f, -0.10927654f, 0.04107420f, -0.01191179f, 0.04880125f, -0.08024002f, 0.16395752f, 
    -0.25991079f, 0.00237458f, -1.14152789f, -0.92764378f, -0.30227593f, -0.18677320f, 0.23681995f, -0.06734935f, 
    0.17546324f, -0.19141436f, -0.47091749f, -0.32711101f, -0.22047293f, -0.38910237f, 0.10192297f, -0.10152712f, 
    -0.03632829f, 0.14656693f, -0.07467140f, 0.06709920f, -0.50343609f, -0.24261771f, -0.57718271f, 0.10311631f, 
    0.05573021f, 0.57268965f, 0.17900465f, 0.13886677f, 0.29077560f, -0.28233719f, 0.18610193f, -0.32995677f, 
    0.11982937f, 0.15985413f, 0.07109769f, 0.32901773f, -0.21796386f, -0.50138259f, 0.14045396f, -0.27648997f, 
    -0.19547023f, -0.04865047f, -0.26189220f, 0.16633452f, -0.05955695f, -0.50716901f, -0.43405688f, -0.43922359f, 
    -0.09569424f, -0.18486649f, 0.09045848f, -0.58091271f, -0.17697324f, 0.24513106f, -0.06991941f, 0.23154229f, 
    0.42484686f, 0.04439050f, 0.00070886f, 0.33826995f, 0.01942746f, -0.03009933f, 0.01379712f, 0.07352532f, 
    -0.27839351f, -0.38468471f, -0.36175027f, 0.47804907f, 0.02569934f, 0.01288444f, -0.13670333f, -0.07352222f, 
    -0.37695611f, -0.34828708f, -0.81276989f, 0.01259045f, 0.06799939f, 0.08649676f, -0.28401700f, 0.06887985f, 
    -0.58700830f, -0.07131961f, -1.10190618f, 0.11764805f, 0.05117129f, -0.05557587f, 0.12512945f, -0.23980089f, 
    -0.11742596f, -1.02955604f, -0.17189181f, -0.52318275f, 0.19375317f, -0.29427642f, 0.04341801f, 0.12373060f, 
    0.13259466f, 0.23343733f, 0.11630455f, -0.50279069f, 0.22356330f, 0.26772419f, -0.25289625f, -0.03252574f, 
    0.17518470f, 0.12470885f, -0.15333416f, -0.14070152f, -0.00505422f, -0.12956409f, -0.26584730f, 0.17358889f, 
    -0.10367513f, 0.03905919f, -0.00944616f, -0.11233485f, 0.56267118f, 0.05061198f, -0.12950115f, -0.08040799f, 
    0.20516989f, 0.11050199f, 0.13543856f, -0.18151051f, -0.00382277f, -0.04148772f, 0.08204880f, -0.99904931f, 
    -0.20015982f, 0.09027083f, 0.43129861f, 0.18064871f, -0.20247036f, -0.31683958f, 0.12870269f, 0.02744201f, 
    -0.13710062f, 0.27902266f, 0.08006476f, -0.46916109f, -0.11393245f, -0.05034549f, -0.00349583f, -0.06146529f, 
    0.02419795f, 0.04092671f, -0.04922001f, 0.00728013f, 0.19995978f, -0.33269358f, 0.00628298f, 0.11819588f, 
    -0.24778889f, 0.14915173f, -0.29172063f, -0.25406581f, -0.22335878f, -0.82197940f, 0.14692245f, 0.26417431f, 
    -0.75984800f, -0.06908675f, -0.00764584f, 0.02966273f, 0.39022449f, 0.29248390f, -0.18849292f, -0.10201620f, 
    -0.33858430f, -0.29384449f, -0.29778215f, -0.22893846f, 0.05711334f, -0.23790126f, -0.10296816f, 0.15871459f, 
    -0.07111999f, -0.35576066f, -0.65673870f, -0.05017586f, -0.52518058f, -0.57053936f, -0.02790524f, -0.14222385f, 
    0.30147105f, -1.02101803f, 0.45933005f, -0.44498700f, -0.40534419f, 0.00125091f, 0.07194899f, 0.02192726f, 
    -1.00856733f, 0.03673165f, 0.19431366f, -0.35472989f, 0.07974743f, 0.29514396f, -0.05148263f, -0.24030687f, 
    -0.13837199f, -0.31434670f, 0.26883665f, 0.00003951f, -0.01073172f, -0.01845287f, -0.14784554f, 0.44240722f, 
    -0.07475121f, -0.07266219f, -0.39934063f, 0.17892738f, 0.09131145f, -0.20837590f, 0.08309393f, 0.23359627f, 
    0.01229576f, -0.17511295f, -0.11307716f, 0.06373262f, -0.34101358f, -0.35069984f, 0.20700364f, 0.29522678f, 
    0.01773135f, 0.11373673f, -0.02661537f, 0.31914684f, -0.12825906f, 0.02059563f, 0.37724653f, -0.67934448f, 
    0.00505267f, -0.00559463f, 0.12839541f, 0.32314658f, -0.34346479f, -0.09686242f, 0.01829494f, -0.53519404f, 
    -0.06821102f, -0.52846038f, 0.01456664f, 0.29499570f, -1.07367659f, 0.01664655f, -0.01251804f, -0.28082329f, 
    0.43557185f, 0.08919173f, 0.06406485f, 0.10508682f, -0.97570777f, 0.06545530f, 0.02628316f, -0.02087006f, 
    -0.41354963f, 0.10809129f, 0.17294788f, -0.54402214f, 0.32223493f, 0.21460894f, 0.12129952f, -0.37786514f, 
    -0.00081944f, -0.70952767f, 0.19959369f, -0.21253043f, 0.22447771f, -0.04384711f, 0.08803708f, -0.11445224f, 
    0.20521493f, -0.45003918f, 0.04274500f, -0.01193040f, 0.14563793f, -0.32997411f, -0.05816532f, -0.28913566f, 
    -0.02064764f, -0.53562945f, -0.14427488f, 0.08468281f, 0.10688851f, 0.29733658f, -0.51029801f, -0.73387367f, 
    0.25000456f, 0.06048485f, -0.01993598f, -0.78902739f, 0.79544753f, 0.04746066f, -0.52566731f, 0.10638144f, 
    -0.21196532f, -0.16982597f, 0.13788939f, 0.06909018f, 0.04296900f, 0.06490356f, -0.38393608f, -0.09266326f, 
    -0.18945530f, -0.06043230f, -0.07067949f, -0.68645203f, -0.16144611f, -0.00791480f, 0.01617767f, -0.21791986f, 
    -0.33858576f, -0.11679009f, 0.27692831f, -0.19747178f, 0.11041706f, 0.05558586f, -0.05945746f, -0.05044901f, 
    -0.16795495f, -0.52797699f, 0.00319977f, -0.39116135f, -0.05400366f, -0.00133820f, -0.05649243f, -0.11000496f, 
    -0.29415673f, -0.01102024f, 0.05506845f, -0.30132267f, -0.08489238f, -0.07533851f, 0.13691932f, 0.51874638f, 
    -0.69648838f, 0.21410649f, 0.17110780f, 0.19604354f, -0.04094326f, -0.00026145f, 0.03858956f, 0.10864028f, 
    0.37288207f, 0.08027525f, -0.43297487f, -0.04899976f, 0.16687338f, -0.51713347f, -0.36302793f, 0.09389983f, 
    0.02968579f, 0.10541673f, -0.06394972f, 0.36349845f, -0.00563891f, -0.15392312f, 0.36956939f, -0.25806361f, 
    -0.48328266f, 0.13410389f, -0.36749631f, 0.28941676f, -0.02628212f, 0.27791598f, 0.34759608f, -0.32857022f, 
    -0.02423480f, 0.74706203f, 0.03834940f, 0.23885150f, 0.49682125f, 0.04537805f, 0.24189335f, 0.08975830f, 
    -0.13930699f, -0.18575114f, -0.05162602f, 0.08628835f, -0.29739016f, 0.12092497f, -0.03352085f, -0.02876394f, 
    -0.41059944f, 0.04278993f, 0.11922078f, 0.00794015f, -0.36174822f, -0.81032640f, -0.60161299f, 0.31461695f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.28929040f, 0.02786453f, 0.07646366f, 0.00241965f, -0.05929125f, 0.08867544f, 0.09997341f, -0.11723962f, 
    -0.01739094f, 0.19511828f, 0.11166490f, -0.17313632f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
