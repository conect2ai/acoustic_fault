#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.26845369f, 0.37012985f, 0.13429031f, 0.03419333f, 0.13513651f, 0.37192950f, 0.34297186f, 0.15705082f, 
    0.44563204f, 0.01559347f, 0.29045734f, -0.17247067f, 0.09376699f, 0.07429510f, 0.13205087f, -0.14659467f, 
    0.13999733f, -0.30996066f, -0.32644981f, -0.24627304f, 0.24693090f, -0.11135262f, 0.32669169f, 0.23411393f, 
    -0.10950432f, -0.49285266f, -0.04167330f, -0.06085094f, 0.52981275f, 0.07139572f, -0.67380261f, 0.08314142f, 
    -0.33171722f, 0.13231131f, 0.68083048f, 0.16594461f, 0.05459966f, -0.24081394f, -0.37471944f, 0.24164045f, 
    0.29989415f, -0.00718751f, -0.23535430f, -0.34508893f, -0.20077556f, -0.07289251f, 0.15056628f, 0.36537033f, 
    0.09307058f, 0.12904701f, -0.50414765f, -0.42407972f, -0.14653182f, 0.31917083f, 0.60834354f, 0.75582552f, 
    0.03923797f, -0.92345512f, -0.50226784f, 0.70505631f, -0.22986320f, -0.27158636f, 0.08250867f, -0.07075089f, 
    0.22298308f, -0.40064070f, -0.17597120f, 0.05172452f, 0.28903413f, 0.04170925f, 0.51487714f, 0.00917166f, 
    -0.02393062f, -0.03259508f, -0.06745373f, -0.36436588f, -0.30437663f, 0.64074039f, 0.83078551f, 0.42663005f, 
    0.81569123f, -0.09657861f, -0.69710535f, -0.66849107f, -0.28068656f, -0.16227072f, -0.19341134f, -0.29478487f, 
    -0.39948049f, -0.21611255f, 0.11820804f, -0.05764580f, 0.10845731f, 0.40170711f, -0.00760390f, 0.15248871f, 
    -0.19200791f, -0.36270720f, -0.03834993f, -0.40776652f, -0.34237322f, -0.08825968f, 0.22251368f, -0.05059072f, 
    -0.08554737f, -0.16303883f, 0.22293718f, -0.35891637f, 0.23622967f, -0.28777030f, 0.13956924f, -0.48220024f, 
    -0.60892463f, 0.55379170f, 0.06184725f, -0.55528361f, -0.22475128f, -0.12613142f, 0.13843100f, 0.12727214f, 
    -0.14545402f, -0.55042708f, -0.24399230f, -0.28218073f, -0.84840649f, 0.61983097f, 0.83208257f, -0.06516021f, 
    -0.37494087f, -0.58338255f, -0.42094550f, -0.37909085f, 0.03119241f, -0.17216642f, 0.34707955f, 0.01884926f, 
    0.04360972f, 0.24955423f, -0.00038611f, 0.13797602f, 0.04601885f, 0.22917120f, -0.21505739f, 0.20290263f, 
    -0.13264947f, 0.14431420f, -0.16994108f, -0.38186333f, -0.06124862f, 0.08718716f, 1.08003032f, -0.90960222f, 
    -1.07205915f, -0.66511780f, -0.81111479f, 1.05299008f, 0.60017955f, 0.39844269f, -0.14249320f, -0.36561480f, 
    0.00726902f, 0.06179522f, -0.27169916f, 0.14552259f, -0.04884097f, -0.12642875f, -0.35113272f, 0.40985724f, 
    -0.30072954f, -0.68471223f, -0.11523864f, -0.34474701f, -0.12286196f, 0.08886508f, -0.19748949f, -0.04845601f, 
    0.32114181f, 0.04481030f, 0.17284569f, 0.20986602f, -0.50159574f, 0.08569317f, -0.50628585f, 0.31673136f, 
    0.28127787f, -0.33752745f, 0.30940163f, 0.00096293f, 0.26372427f, -0.27064088f, -0.22352707f, -0.05585769f, 
    0.00753608f, 0.09611200f, 0.07532990f, 0.10592434f, -0.29925734f, -0.03291452f, 0.16134259f, -0.19625503f, 
    0.43517992f, -0.18168516f, -0.39368203f, -0.39086080f, -0.31941536f, -0.08546110f, -0.41039428f, -0.80970770f, 
    -0.95597887f, -1.14260590f, 0.88447970f, -0.08207131f, -0.18187071f, 0.18278368f, -0.04016571f, -0.27395007f, 
    -0.14545642f, -0.43381882f, -0.34478825f, -0.02037311f, -0.36960778f, -0.05673694f, 0.14348194f, -0.08990315f, 
    -0.50671887f, -0.39891139f, 0.36814585f, 0.15703511f, 0.68903142f, 0.02871084f, -0.80618346f, -0.79929757f, 
    -0.36654240f, -0.26508665f, 0.02756819f, 0.06597315f, 0.17225170f, 0.13361825f, 0.34180748f, 0.52569604f, 
    -0.21712048f, -0.14982225f, -0.32112369f, -0.18892716f, -0.13454461f, -0.00606666f, -0.06254739f, 0.05298813f, 
    0.15428583f, 0.02306361f, 0.62417245f, 0.80959827f, 0.36223263f, 0.35123539f, -0.48188302f, -0.34582248f, 
    -0.38679260f, -0.22229578f, -0.02965946f, 0.22409490f, 0.14857621f, 0.01669802f, -0.03504540f, -0.24751677f, 
    -0.08072623f, 0.11619452f, -0.22533961f, -0.20747158f, 0.27076092f, 0.00036191f, -0.11678120f, 0.29293591f, 
    -0.29719105f, -0.28287551f, 0.26792079f, -1.32929671f, 0.96146315f, 0.62940252f, -0.96484947f, -0.07100837f, 
    -0.87650341f, 0.89510250f, -0.06589921f, 0.10023118f, 0.04036505f, 0.15118584f, 0.00753351f, -0.32325047f, 
    -0.42175412f, 0.09254139f, 0.18544821f, -0.49081743f, -0.32431090f, -0.19005960f, -0.35150778f, -0.03747685f, 
    -0.11517894f, 0.05991989f, -0.30112118f, -0.12392696f, -0.52398026f, -0.38575128f, -0.14702691f, 0.34842280f, 
    0.17281651f, 0.21220760f, -0.27992138f, 0.12056155f, 0.50977224f, 0.62454933f, 0.22427927f, 0.09682760f, 
    -0.10685096f, -0.16766371f, 0.03202834f, 0.11516812f, 0.01653535f, -0.03301025f, -0.05379322f, -0.09346801f, 
    -0.10194187f, 0.22776161f, -0.00294651f, 0.05227290f, -0.15809080f, -1.12125087f, -0.75492561f, -0.47796223f, 
    0.08379261f, 0.24781486f, 0.94812161f, -0.45497808f, -0.22510456f, 0.28965163f, 0.26168647f, -0.46682376f, 
    -0.63123161f, -0.40912971f, -0.01031868f, -0.20018771f, -0.13433501f, 0.14811759f, -0.06689683f, -0.18871264f, 
    -0.47942904f, -0.24674354f, -0.27165145f, 0.07981560f, 0.27423802f, -0.03191619f, -1.55057740f, 0.08494107f, 
    -0.55578041f, -0.09185666f, -0.22593294f, -0.34541503f, -0.11980063f, 0.52653682f, 0.69412208f, 0.32984367f, 
    0.23735195f, 0.10675767f, 0.22055067f, 0.41710734f, -0.18934980f, 0.11841039f, -0.32919180f, -0.12092993f, 
    -0.20788765f, 0.01925624f, 0.15055303f, -0.01492766f, 0.28625235f, -0.10901850f, -0.02423992f, -0.90275782f, 
    -0.53651160f, -0.68407393f, -0.48358977f, -0.59739417f, 0.14810161f, -0.06602313f, -0.35572353f, -0.41384965f, 
    -0.18560643f, -0.05701490f, -0.26533499f, -0.44245958f, -0.47201106f, -0.45900783f, 0.20997636f, -0.47178665f, 
    -0.16282396f, 0.30055860f, -0.12038837f, 0.22303362f, 0.01873503f, -0.23210533f, 0.05316446f, -0.18207677f, 
    -0.85316455f, -0.72825336f, -0.72527391f, -0.22313841f, 0.20598900f, -0.06116479f, -0.72939867f, -0.77919126f, 
    -0.87031299f, 0.14653261f, 0.39138076f, 0.40504584f, 0.18903045f, 0.50983882f, -0.05430551f, 0.05813032f, 
    0.06813816f, -0.24622189f, -0.03795831f, 0.03511969f, -0.01376681f, 0.04412838f, 0.24172646f, 0.03408791f, 
    0.09154395f, -0.23933619f, -0.13426894f, -0.10426453f, -0.61424917f, -0.74778193f, -0.33993235f, 0.09047345f, 
    0.57446045f, 0.53504860f, 0.16113672f, -0.42087159f, -0.47258651f, 0.27018851f, 0.29592559f, 0.26845950f, 
    0.13663603f, 0.30956116f, -0.07625234f, 0.09053248f, 0.15267904f, -0.39065778f, -0.17216995f, -0.31690699f, 
    -0.44313034f, -0.50399077f, -0.32200745f, 0.31770992f, -0.14648983f, -0.27067253f, 0.19427136f, -0.73473644f, 
    0.07970901f, -0.90744406f, -0.66114593f, -0.71840036f, -0.10444500f, 0.44690281f, -0.24283731f, -0.45830783f, 
    0.00273344f, 0.20026430f, 0.08503330f, 0.12260982f, 0.44788593f, 0.22824587f, -0.19980559f, -0.07694244f, 
    0.05134341f, -0.14229164f, 0.09007479f, 0.13717896f, -0.63309747f, -0.07778274f, -0.01076040f, 0.33478603f, 
    -0.01807873f, -0.18941270f, -0.39396733f, -0.60302961f, -0.62903553f, 0.12482668f, -0.60812521f, -0.01586322f, 
    0.63421792f, -0.50343072f, -0.03897421f, 0.09370141f, -0.09890757f, 0.15243334f, 0.01565835f, -0.28276154f, 
    -0.01461594f, -0.11102061f, 0.23891883f, 0.52866107f, -0.15786745f, -0.94305557f, -0.58060741f, 0.13506454f, 
    -0.13509960f, -0.46061715f, -0.55360824f, -0.61796057f, -0.14190406f, -0.28135547f, -0.25186929f, -0.51375985f, 
    -0.37478226f, 0.46489993f, -0.26886487f, 0.11889639f, -0.19072528f, -0.23249841f, -0.34382200f, -0.03935852f, 
    -0.08020607f, -0.38319933f, -0.44374004f, -0.39929545f, 0.13670917f, -1.09927440f, -0.67470902f, -0.64391518f, 
    -0.73372591f, -1.02181423f, 0.39886793f, 0.59415573f, -0.20782909f, -0.47213218f, -0.11600475f, -0.12333953f, 
    -0.43633333f, -0.05952381f, -0.07468024f, -0.04047852f, -0.08036519f, 0.16636501f, -0.09776243f, -0.20341113f, 
    0.00558147f, -0.21660721f, -0.23206343f, 0.51384795f, -0.19168699f, -0.22062697f, -0.92356801f, 0.58821076f, 
    1.25607336f, -0.92580229f, -0.98202789f, 0.14797437f, 0.43860760f, 0.12694044f, 0.38913941f, 0.10308953f, 
    -0.12097689f, -0.02135326f, -0.01965941f, 0.19878110f, -0.41081750f, 0.17310655f, -0.03740385f, -0.11839678f, 
    -0.09552909f, 0.05777358f, -0.05915741f, 0.14068070f, 0.10785374f, -0.09704936f, -0.08845969f, -0.81963271f, 
    -0.60960311f, -0.94698060f, -0.16038671f, 0.33481956f, 0.68390405f, 0.51144886f, 0.43298823f, 0.45294219f, 
    0.25689486f, -0.04535993f, 0.12558454f, -0.08359085f, 0.23044720f, -0.35025790f, 0.03033343f, -0.13522823f, 
    -0.17128311f, 0.27629292f, 0.00934840f, 0.03897259f, -0.24346931f, 0.16129962f, -0.19872986f, -0.02800516f, 
    0.29497695f, -0.44545501f, 0.28293315f, 0.60476381f, 0.51018894f, 0.37377375f, -0.00040975f, -0.00216092f, 
    0.13753234f, 0.02930978f, -0.21786264f, 0.05698558f, 0.32158077f, -0.14014421f, -0.45582202f, -0.23355219f, 
    -0.01131033f, -0.19979711f, -0.04832898f, -0.33654881f, 0.11198004f, -0.11625936f, -0.26111940f, -0.08663017f, 
    0.13166918f, 0.55117661f, -0.94036871f, -0.01945806f, 0.21527486f, 0.36105108f, -0.21029700f, -0.15806024f, 
    -0.22558057f, -0.09723628f, 0.09491767f, 0.01300888f, 0.50991350f, -0.38603875f, -0.20055352f, -0.10142403f, 
    -0.42195645f, -0.05239411f, 0.20168979f, 0.26198253f, 0.25849861f, -0.45449501f, -0.39232719f, -0.18061024f, 
    0.16923109f, -0.20352933f, -0.85984099f, -0.39318508f, -0.29168075f, 0.47660521f, 0.91365689f, 0.06615303f, 
    0.07878709f, -0.26027918f, -0.10769676f, 0.77940279f, -0.33215445f, -0.05654357f, -0.15147924f, 0.19498521f, 
    -0.43191287f, 0.21469562f, -0.23736411f, -0.36359748f, -0.12971976f, -0.48894081f, -0.37497503f, -0.29099461f, 
    -0.53654420f, -0.58076966f, -0.56017345f, 0.49596342f, 0.47915626f, -0.06056038f, -0.39297533f, -0.15302867f, 
    0.14024423f, -0.24127921f, -0.42070508f, -0.33413741f, 0.25039402f, 0.30474672f, -0.46782023f, -0.29404074f, 
    0.37722158f, -0.01926626f, 0.24275137f, 0.16308509f, 0.12043815f, -0.17058817f, -0.30953792f, -0.26937908f, 
    -0.19443972f, 0.35798571f, 0.37293008f, -0.04067466f, 0.33553165f, -0.16253723f, -0.27790013f, -0.12081195f, 
    -0.08354721f, 0.40087071f, -0.31722894f, 0.19715756f, 0.63028872f, 0.09485699f, 0.48614502f, -0.25069201f, 
    0.06310479f, 0.25350517f, -0.44379064f, -0.49686649f, 0.12382676f, 0.17197080f, 0.11754769f, -0.28567186f, 
    0.10289060f, 0.13080619f, 0.00305581f, -0.09596770f, 0.39918697f, -1.14199471f, 0.35392368f, -0.29884046f, 
    -1.16238070f, -0.86614978f, 1.05122137f, -0.01821283f, -0.58536381f, -0.16224486f, 0.22603571f, -0.29739153f, 
    -0.09462573f, 0.21850389f, 0.02802538f, 0.30465013f, 0.03821587f, 0.06181865f, -0.03733712f, -0.35926491f, 
    -0.37523118f, -0.10473281f, 0.58951598f, -0.16359037f, -0.25533533f, 0.29615679f, 0.44486055f, 0.64914221f, 
    0.27779222f, -0.48688543f, 0.46014124f, -0.19054066f, 0.45593318f, 0.06568611f, -0.57925099f, -0.58866394f, 
    -0.52190775f, 0.24946702f, 0.09587969f, 0.05379329f, -0.11288884f, -0.06152617f, 0.11113197f, -0.20743696f, 
    -0.19804724f, 0.18676627f, -0.01834813f, 0.19598614f, 0.00267005f, 0.28127339f, -0.25727752f, -0.50274795f, 
    -0.57533193f, -0.44578046f, -0.55274045f, -0.89328802f, 0.71952099f, 0.45115197f, -0.05342205f, -0.18273449f, 
    0.25686333f, 0.30130941f, 0.50581282f, -0.33811203f, -0.42534244f, -0.44060808f, -0.27668157f, -0.04213641f, 
    -0.25509292f, 0.08298558f, 0.11140236f, 0.37090954f, 0.10216103f, 0.38576168f, 0.30610591f, 0.05197799f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.14136648f, 0.48137066f, 0.58374411f, -0.12122457f, 0.02553715f, 0.17597824f, 0.22186539f, 0.09570229f, 
    0.17091587f, 0.14855534f, 0.66814595f, 0.21360719f, 0.14305723f, -0.19624726f, 0.34160191f, -0.36778238f, 
    0.37477067f, -0.12946773f, 0.12039758f, 0.31406167f, -0.08543831f, -0.55922025f, 0.32380176f, 0.16909534f, 
    0.63114399f, 0.36777872f, -0.08480618f, 0.58471680f, 0.46870795f, 0.23387699f, 0.04058640f, 0.28587613f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09749810f, -0.17481230f, -0.17555384f, -0.02171060f, 0.03525123f, 0.12001793f, 0.02033669f, 0.06773762f, 
    -0.07875749f, 0.06649324f, -0.35633248f, -0.11584160f, -0.11785176f, 0.19422202f, 0.18665034f, -0.31787336f, 
    -0.13547532f, -0.17539085f, 0.00092563f, -0.01278103f, -0.07370913f, -0.09561313f, -0.23982181f, -0.11435443f, 
    0.21167317f, 0.27908763f, -0.15892594f, -0.08853089f, -0.26510486f, -0.15696311f, -0.04820547f, -0.15571150f, 
    -0.12287021f, -0.26764736f, -0.13880649f, -0.13105041f, 0.56380123f, 0.37327313f, -0.14449777f, 0.16566987f, 
    0.01974701f, -0.12879115f, 0.05151080f, 0.10058717f, -0.05182959f, -0.02910684f, 0.00872395f, 0.04735274f, 
    0.06089579f, -0.03051405f, -0.09722371f, -0.18063195f, -0.11227150f, -0.16253564f, -0.07691431f, -0.03666626f, 
    0.05539025f, -0.21945897f, -0.13244118f, 0.27562597f, -0.09528004f, -0.12255993f, -0.08172114f, 0.09225663f, 
    0.02443394f, 0.00701569f, -0.11105251f, -0.07658508f, -0.27978244f, -0.11819066f, -0.10945011f, 0.09837312f, 
    0.24118479f, -0.30983263f, -0.44879878f, 0.04853525f, 0.13115560f, 0.09842493f, -0.18876675f, -0.12967782f, 
    -0.07314862f, -0.14716168f, -0.23885413f, 0.21928418f, -0.09884676f, -0.04210195f, -0.05720386f, -0.03369755f, 
    0.10203201f, -0.05820116f, -0.05413703f, 0.06383670f, -0.03298723f, 0.00805762f, 0.00189561f, -0.00820540f, 
    0.43486127f, 0.03525467f, -0.28055280f, -0.15294768f, -0.04899511f, -0.17325348f, -0.06476567f, 0.11941823f, 
    -0.13417603f, 0.09739178f, -0.22641967f, -0.12624648f, -0.03198694f, 0.06605916f, 0.02734147f, -0.42865673f, 
    -0.33318347f, 0.08184860f, -0.07684913f, -0.06379772f, 0.11018892f, -0.01240293f, -0.00679450f, -0.02799555f, 
    -0.91879594f, -0.40719628f, -0.17234781f, 0.03883500f, 0.06493472f, -0.00557537f, -0.01085722f, -0.02068227f, 
    -0.06793125f, -0.01146480f, 0.04266870f, 0.03303931f, -0.41629127f, -0.07254793f, 0.29879674f, -0.02499864f, 
    -0.15581596f, 0.04515505f, 0.05214638f, 0.03713391f, -0.11637529f, -0.07206038f, 0.01165324f, -0.02853838f, 
    0.01172081f, 0.03798206f, 0.06020590f, 0.02302247f, -0.01859039f, 0.04282914f, 0.03855938f, -0.01506910f, 
    -0.03267181f, -0.02047211f, -0.11812452f, -0.10731608f, 0.33338538f, 0.13095501f, 0.31039652f, -0.19065922f, 
    -0.17395784f, -0.00062058f, -0.00648396f, -0.26990750f, -0.05388921f, 0.05103089f, -0.15262845f, -0.00204899f, 
    -0.01084241f, 0.07942811f, 0.28124189f, -0.05870721f, 0.02496459f, 0.13424689f, 0.03773852f, 0.12798095f, 
    0.01339434f, -0.03544609f, -0.06179541f, -0.04233813f, 0.38120422f, 0.36438408f, -0.00790119f, -0.15188420f, 
    0.17207083f, 0.23156753f, 0.20386532f, 0.14692491f, 0.01444121f, -0.04679878f, -0.04821595f, -0.05094218f, 
    0.40877047f, 0.39589691f, -0.09078790f, -0.16993167f, 0.01939836f, -0.06451519f, -0.05145974f, -0.04835004f, 
    0.03829186f, -0.05428670f, -0.04245031f, 0.01693347f, -0.02751279f, 0.01177835f, 0.23621191f, 0.03004655f, 
    0.09407430f, 0.17369455f, -0.07882284f, 0.05717372f, -0.07863624f, 0.11695689f, 0.20296155f, 0.04860930f, 
    0.20553152f, 0.25227666f, -0.25761378f, -0.10886190f, 0.18676813f, -0.04409667f, -0.07636190f, -0.05306814f, 
    0.02841630f, 0.02454383f, 0.01187678f, 0.01836490f, 0.30612794f, -0.00597140f, -0.17447452f, -0.41114917f, 
    0.07984298f, -0.15168189f, -0.01821364f, 0.13330109f, -0.03518791f, 0.06945583f, 0.03573720f, -0.03676340f, 
    0.38554519f, 0.20842163f, 0.09865154f, -0.32058483f, 0.10814977f, 0.10163867f, 0.09755240f, 0.13782807f, 
    -0.11331206f, -0.07262850f, -0.09025041f, -0.10565651f, 0.42060098f, 0.08473913f, -0.18949114f, -0.11601754f, 
    0.25664106f, 0.28742120f, 0.11130823f, 0.08599389f, -0.10285113f, -0.04219416f, 0.06954924f, 0.12023713f, 
    -0.44967058f, -0.73854131f, 0.12909061f, -0.18737923f, -0.18427436f, 0.05173181f, -0.01985204f, 0.15436730f, 
    -0.02152116f, -0.11477999f, -0.31466958f, -0.20405558f, 0.10566232f, -0.00879561f, -0.30005187f, 0.06158469f, 
    0.08029711f, 0.12271163f, 0.10061149f, -0.05784176f, -0.06129048f, 0.15285002f, -0.02013238f, -0.00696468f, 
    -0.62083447f, -0.22446458f, 0.14817345f, 0.14858928f, 0.03692300f, 0.00914464f, 0.06607705f, 0.02056074f, 
    0.01383512f, -0.03152031f, 0.05779102f, -0.00108093f, 0.06811363f, 0.15606155f, -0.11437441f, -0.05599490f, 
    -0.05075549f, -0.19827585f, -0.13292155f, -0.20935836f, 0.02826109f, 0.01393143f, -0.06830271f, -0.08585896f, 
    0.37210709f, 0.13442554f, -0.01547117f, -0.02049415f, -0.04691971f, 0.07172108f, 0.02125918f, 0.03671845f, 
    -0.06399716f, 0.11272325f, 0.09781978f, 0.06085001f, -0.01176131f, 0.06057088f, -0.17653033f, -0.03202719f, 
    -0.04617172f, -0.12091690f, -0.18304011f, -0.19312921f, -0.11457162f, -0.05573088f, -0.03990773f, 0.00101163f, 
    -0.11938306f, -0.15366678f, -0.08310287f, -0.05300215f, -0.09392722f, -0.01670972f, -0.05692496f, -0.01929937f, 
    -0.19955426f, -0.16266562f, -0.16949973f, -0.53158617f, 0.27197731f, 0.06287558f, -0.23065838f, -0.12019744f, 
    -0.23335364f, 0.23418988f, -0.29492351f, -0.24243312f, -0.06425589f, -0.09651998f, -0.01813176f, 0.04068550f, 
    -0.19297007f, -0.19880974f, -0.39866003f, 0.37643772f, -0.01841666f, -0.00981151f, -0.05478811f, 0.05709036f, 
    0.07067905f, 0.06823289f, 0.06602646f, 0.00796033f, 0.27987206f, 0.01346254f, -0.31821299f, -0.09179137f, 
    0.10301603f, 0.05903770f, 0.02396210f, 0.06474650f, 0.01370190f, -0.03235877f, -0.00974813f, 0.02915856f, 
    0.13491307f, 0.12304655f, 0.16484299f, 0.18727452f, -0.07103085f, -0.09450702f, 0.09173109f, 0.03717349f, 
    -0.07815988f, -0.04531493f, 0.17050609f, -0.02760583f, -0.20058274f, -0.04308016f, 0.15607651f, -0.11254376f, 
    0.22402494f, 0.18087055f, -0.01706331f, -0.02015281f, -0.08979963f, 0.10044505f, 0.01338860f, 0.21137306f, 
    -0.07317112f, 0.01515349f, -0.17388949f, 0.13273358f, 0.01613844f, 0.21494003f, 0.13659148f, 0.12558325f, 
    -0.02152785f, 0.03424567f, 0.16012779f, -0.12567480f, 0.22959085f, -0.12351003f, -0.13668841f, -0.08159041f, 
    -0.02869419f, -0.11208224f, -0.10594073f, 0.10643985f, 0.12169956f, -0.09007395f, 0.06164751f, -0.01453028f, 
    0.09720718f, -0.12555645f, -0.00535346f, -0.42162621f, 0.07100920f, 0.00180060f, -0.03204701f, 0.03437495f, 
    -0.30618826f, 0.05986173f, 0.17727928f, -0.68635637f, 0.05703903f, -0.09429371f, 0.08288217f, -0.06938287f, 
    0.12124109f, 0.07271293f, -0.01446843f, 0.00151414f, 0.08582305f, -0.08831342f, -0.08735303f, 0.03072825f, 
    0.84721333f, -0.23010966f, 0.06814680f, -0.13563918f, -0.01965124f, 0.02713685f, 0.00746422f, -0.14930446f, 
    0.05226245f, 0.09939102f, -0.05308354f, -0.08168398f, -0.04519842f, 0.11997636f, 0.06577938f, 0.03221856f, 
    0.04863229f, 0.00180452f, -0.14879595f, 0.00600638f, 0.10337950f, -0.00972629f, 0.10810227f, -0.00874450f, 
    -0.00107082f, -0.13672614f, 0.01655065f, -0.11096625f, -0.12665729f, -0.15526746f, 0.36358181f, 0.33169025f, 
    -0.07328682f, -0.04402092f, -0.04741414f, 0.19496541f, -0.47187623f, -0.25686985f, -0.38959247f, -0.06719296f, 
    -0.09163216f, -0.11033920f, 0.01445237f, 0.10930903f, -0.08630965f, -0.05247424f, 0.10247659f, 0.19895479f, 
    0.20890194f, 0.16178709f, 0.28684506f, -0.17721568f, -0.00840821f, -0.02837363f, -0.04312347f, -0.00433111f, 
    -0.04113460f, -0.02534335f, 0.08325436f, 0.01134204f, -0.26422006f, -0.75156856f, -0.01435952f, -0.53689754f, 
    0.06740291f, 0.01624649f, -0.17750353f, 0.15880115f, 0.00718736f, 0.10936990f, -0.39719817f, -0.29647815f, 
    -0.06491196f, 0.11954842f, 0.10459960f, 0.01571324f, -0.05834774f, -0.05872151f, -0.07104763f, 0.03547992f, 
    -0.17503828f, -0.06464007f, -0.10282791f, 0.07653238f, 0.26769319f, 0.27871174f, -0.09383872f, -0.16774835f, 
    0.11442032f, -0.08762947f, 0.16148120f, 0.14055353f, 0.27646536f, 0.00821593f, -0.10141994f, -0.42418909f, 
    -1.26737630f, -0.34861150f, -0.18190396f, -0.22642638f, -0.03134547f, 0.10365093f, 0.05498668f, -0.07364373f, 
    -0.10107991f, 0.03035111f, 0.06394166f, -0.01308419f, 0.21215075f, 0.27996758f, 0.29297459f, 0.20244025f, 
    -0.15301970f, 0.08568078f, -0.14623369f, 0.00065308f, -0.02721254f, 0.00909566f, -0.05250455f, -0.03387985f, 
    -0.15437274f, -0.14394115f, -0.09544636f, 0.30963445f, 0.02266148f, -0.02676096f, 0.13417593f, 0.03254532f, 
    -0.04537008f, -0.04065001f, -0.02900439f, -0.02006564f, -0.18357290f, -0.09982215f, 0.01744465f, -0.03876569f, 
    0.06949066f, 0.07163237f, -0.09102223f, -0.22318913f, 0.07023431f, 0.11961512f, -0.09050885f, -0.03257918f, 
    0.22731200f, -0.14090233f, -0.32100061f, -0.43014193f, -0.28596103f, -0.02928500f, -0.29771388f, -0.34401500f, 
    -0.01342943f, -0.03112844f, -0.01949070f, 0.03814892f, -0.22717550f, -0.00672425f, 0.09581345f, -0.03929996f, 
    0.03734883f, 0.07147989f, 0.31608236f, -0.20421316f, 0.08089388f, -0.06416757f, 0.02997704f, -0.04092508f, 
    -0.09027881f, 0.11538944f, 0.05674959f, -0.12897700f, 0.31163764f, -0.19521387f, 0.12581348f, -0.07903748f, 
    0.05595586f, -0.06719977f, -0.00711149f, 0.09586162f, 0.43937474f, 0.26694596f, 0.50717413f, -0.10973171f, 
    0.10208383f, 0.09674552f, -0.06163836f, -0.33629671f, 0.02303975f, 0.02810925f, -0.02569350f, -0.06996419f, 
    0.07980209f, 0.03924446f, 0.00674680f, -0.15565127f, -0.00452295f, -0.07575557f, 0.03653582f, 0.04830201f, 
    -0.03318026f, -0.02917697f, 0.03143481f, -0.05015819f, 0.09647657f, 0.05299098f, -0.30431998f, 0.00304546f, 
    -0.11937629f, 0.03626570f, 0.03371437f, -0.04815377f, 0.07727727f, 0.02372876f, 0.03734152f, 0.12434915f, 
    0.40285873f, 0.41181800f, 0.32066312f, 0.50027788f, -0.04070825f, -0.01330316f, 0.00322631f, -0.03391596f, 
    -0.00990651f, 0.03478712f, -0.04929137f, 0.13707961f, 0.08117541f, 0.11769298f, -0.15080944f, -0.14552394f, 
    -0.08114951f, 0.00407175f, -0.00564708f, -0.09098823f, -0.00690776f, -0.27401620f, 0.14841025f, 0.19561148f, 
    -0.02499808f, -0.06993243f, -0.20385894f, 0.22801073f, 0.02297785f, 0.07914777f, -0.04033902f, -0.02806376f, 
    -0.40968436f, -0.40373236f, -0.50989771f, -0.34722370f, 0.15379654f, -0.04203629f, 0.08344286f, -0.05607473f, 
    0.18035512f, -0.44048551f, 0.12579216f, 0.11184569f, 0.07266668f, 0.11032569f, 0.02804797f, 0.02463095f, 
    -0.06190153f, 0.16144541f, 0.10649496f, -0.02235317f, -0.02978431f, -0.01155848f, -0.01238766f, 0.03660640f, 
    -0.03136784f, 0.17991604f, 0.08604417f, -0.15297502f, -0.21624656f, 0.12579875f, 0.25024065f, 0.16051993f, 
    0.26714349f, 0.12115148f, -0.16029567f, 0.22970389f, -0.05549555f, 0.05543199f, 0.04308901f, -0.14067952f, 
    0.55421513f, -0.20244516f, -0.02237887f, 0.08093401f, -0.01909289f, -0.41720879f, -0.01846363f, 0.00736621f, 
    -0.05692870f, 0.06971693f, -0.06056732f, 0.07523059f, 0.27611592f, 0.19143432f, -0.09796828f, -0.33891183f, 
    0.01685722f, 0.04182766f, 0.04581658f, 0.30292290f, -0.15742309f, 0.00905789f, -0.20343567f, 0.02385135f, 
    -0.44707111f, -0.51310831f, -0.21721211f, -0.07379465f, -0.05228260f, -0.02088247f, 0.08066879f, -0.04809185f, 
    -0.06587895f, -0.11397361f, -0.07546677f, 0.05081419f, 0.09911310f, -0.31180021f, -0.06387483f, 0.03962730f, 
    0.01075187f, 0.03471180f, -0.00825407f, 0.01506496f, -0.03560288f, -0.04172545f, -0.22126229f, 0.13868620f, 
    0.04727798f, -0.10164119f, 0.03474736f, 0.19362988f, 0.13204047f, -0.01408819f, 0.13390037f, -0.02817549f, 
    -0.04876777f, 0.12327168f, -0.02076240f, -0.25401780f, -0.06319292f, 0.36078784f, -0.41952786f, -0.23123597f, 
    0.01599952f, -0.07425138f, 0.02975140f, 0.04442669f, 0.03559316f, -0.01860079f, -0.01895742f, -0.02436707f, 
    0.00500418f, 0.00638347f, -0.12635534f, -0.05140727f, -0.04300542f, -0.13872802f, 0.10391611f, -0.00492229f, 
    0.22734557f, 0.19024442f, 0.16329807f, 0.00018222f, -0.07337257f, 0.03192928f, 0.06910542f, -0.02036194f, 
    -0.01881334f, 0.06422550f, -0.29342246f, -0.19379623f, 0.15964417f, 0.03524812f, -0.13224286f, 0.09392848f, 
    -0.26017827f, 0.46578842f, 0.69156098f, -0.46864626f, -0.12828913f, -0.07132972f, 0.16892979f, 0.06235829f, 
    0.02494720f, -0.05639340f, 0.14854684f, -0.03203769f, -0.09700385f, 0.00561427f, 0.02734366f, 0.02746951f, 
    -0.05111521f, 0.00837288f, 0.05480802f, 0.02982053f, 0.01987435f, -0.07639307f, 0.09318480f, 0.00629929f, 
    -0.76050043f, -0.17676169f, -0.06225622f, -0.57348430f, 0.09901877f, -0.12757836f, 0.03980112f, -0.20322849f, 
    0.03248432f, 0.04895454f, -0.06696524f, 0.01965899f, -0.51846755f, -0.05807361f, -0.14778562f, 0.04825413f, 
    0.05194333f, -0.18503600f, -0.34123960f, -0.22279947f, -0.01199663f, 0.07340957f, -0.00205417f, -0.03279845f, 
    -0.61356384f, -0.07173827f, 0.38368073f, -0.14900209f, 0.01980329f, 0.00642591f, -0.11877663f, 0.12685092f, 
    0.02790956f, -0.05181826f, -0.00358725f, 0.06362418f, 0.60997301f, 0.19553007f, 0.18594584f, -0.19724102f, 
    0.06716502f, 0.00855928f, -0.07230669f, -0.21504766f, -0.20556672f, 0.17655063f, -0.19264182f, 0.12785727f, 
    0.03007775f, 0.08989323f, -0.05927595f, 0.10701215f, -0.01834156f, 0.03947520f, -0.01621226f, 0.03628073f, 
    -0.04624861f, -0.05851202f, -0.07715733f, 0.22221370f, -0.23391053f, -0.00895005f, 0.51115972f, 0.29696840f, 
    -0.01934561f, -0.06049253f, 0.03034609f, -0.05475989f, 0.04146343f, -0.04187345f, 0.01364946f, -0.00814318f, 
    0.27036342f, 0.42301098f, -0.04417479f, 0.30994144f, -0.05323987f, 0.03824753f, 0.03266506f, -0.13595033f, 
    0.00869476f, -0.04371978f, -0.05504013f, 0.10102627f, -0.48132631f, -0.04763823f, 0.21378124f, 0.04330154f, 
    0.02923726f, -0.08259620f, 0.03093521f, 0.13187218f, 0.02120453f, -0.05110530f, 0.04457064f, 0.08029036f, 
    0.00867684f, -0.62342966f, -0.10400280f, 0.05975697f, 0.05184931f, 0.05599543f, 0.02597917f, 0.01747222f, 
    0.03410099f, -0.03387675f, -0.06143938f, -0.00950848f, -0.00213270f, 0.11548945f, -0.02614780f, 0.14825250f, 
    -0.00705510f, 0.03091745f, 0.16839027f, -0.22570470f, 0.14405818f, 0.18955818f, 0.06656094f, 0.00554409f, 
    -0.51746088f, -0.56466913f, -0.16910414f, -0.47887027f, 0.04147541f, -0.04778334f, -0.10248923f, 0.03638601f, 
    0.00071312f, -0.04579342f, 0.02726661f, -0.06282876f, -0.43262237f, -0.08704032f, -0.17740907f, -0.17086107f, 
    -0.03965823f, -0.01279297f, 0.05034035f, -0.01610450f, -0.04624558f, -0.04670066f, 0.06814461f, -0.06142945f, 
    -0.57896906f, -0.23859714f, -0.07703133f, -0.20970808f, -0.04516329f, -0.01790097f, -0.13491981f, -0.05631702f, 
    0.00466697f, 0.02292291f, 0.07248123f, -0.09223025f, -0.59752792f, 0.09808437f, 0.70806611f, 0.11518999f, 
    -0.32997924f, -0.04201462f, 0.16294043f, -0.03366274f, 0.04174899f, 0.00283625f, 0.02941197f, -0.01980856f, 
    0.78729379f, 0.15953982f, -0.11552493f, 0.27622509f, 0.10278190f, -0.06793623f, -0.13686435f, 0.17329764f, 
    0.07354533f, -0.11832695f, 0.11131789f, 0.00090771f, -0.20183818f, -0.08023494f, 0.36060947f, 0.20276481f, 
    -0.07406183f, 0.00913886f, 0.08518267f, 0.08933214f, 0.04859853f, -0.13952059f, 0.06894160f, -0.01211708f, 
    0.05889487f, 0.45157316f, -0.32745707f, -0.00324832f, 0.02190559f, -0.02197783f, 0.05421814f, 0.05082005f, 
    -0.04988050f, -0.11993692f, 0.09556656f, -0.21440649f, -0.08299665f, 0.05580877f, -0.03053263f, 0.09971281f, 
    -0.05681506f, -0.07115372f, -0.14568387f, -0.09188322f, 0.04044210f, -0.00814823f, -0.02811657f, -0.01833755f, 
    -0.13061172f, -0.36651954f, 0.08632414f, 0.14264977f, -0.08641527f, -0.00738984f, 0.00535822f, -0.03272326f, 
    0.01233917f, 0.08698820f, 0.07517407f, -0.01650077f, -0.26021588f, -0.14882414f, 0.16639508f, -0.04437145f, 
    -0.00923478f, -0.05088007f, 0.04024157f, -0.03719353f, -0.02198202f, -0.09341792f, 0.06367137f, 0.08668968f, 
    -0.18864435f, 0.17195694f, -0.05068380f, -0.04199344f, 0.05081569f, 0.04142772f, -0.03979715f, 0.06804007f, 
    -0.16080937f, -0.08340689f, 0.01409619f, 0.05204199f, 0.30937648f, -0.13447051f, 0.28709659f, 0.64584261f, 
    0.17181283f, 0.14867771f, -0.11039863f, 0.00504728f, 0.08986159f, -0.01869515f, -0.03065529f, 0.11495262f, 
    0.42929095f, -0.12439674f, -0.24664921f, -0.72816980f, 0.06314962f, -0.15118964f, 0.16721903f, 0.07879969f, 
    -0.02045106f, -0.04608385f, -0.05909241f, -0.01492324f, -0.13312471f, 0.07194157f, 0.40785897f, 0.04231869f, 
    -0.08559416f, -0.24221864f, 0.04789305f, 0.06757338f, 0.08997775f, 0.02992826f, -0.09988605f, 0.00247212f, 
    -0.37439215f, -0.41067094f, -0.13372920f, 0.08858046f, 0.27790350f, 0.08222398f, 0.01735869f, 0.06345587f, 
    -0.19070290f, -0.01144001f, -0.06005619f, 0.00610908f, 0.30465028f, -0.02880200f, -0.05360915f, -0.37202507f, 
    -0.00575999f, -0.17378405f, -0.02294156f, -0.24309516f, -0.01351805f, 0.15149045f, -0.01568818f, -0.08458377f, 
    -0.14186077f, 0.23849633f, -0.30653206f, -0.47692093f, 0.16553211f, 0.05356939f, -0.24657995f, -0.21110143f, 
    -0.16884476f, -0.19423956f, -0.08406503f, 0.03791703f, -0.47100323f, 0.84809023f, 0.19808194f, 0.41571006f, 
    -0.04959848f, 0.22825430f, 0.11312850f, -0.04848743f, 0.10996087f, 0.09624026f, 0.08782613f, 0.19660044f, 
    0.14244114f, 0.04281969f, 0.00774250f, 0.07941937f, -0.19873548f, 0.10511395f, 0.01742655f, -0.00910433f, 
    0.08797566f, -0.10122004f, 0.13527796f, -0.01933417f, -0.61833143f, 0.24461301f, 0.21488014f, 0.09324927f, 
    -0.32731417f, 0.10594166f, -0.17643294f, -0.02973941f, -0.03182704f, 0.12526777f, -0.10310194f, -0.10391399f, 
    -0.34775349f, -0.07057410f, 0.06514065f, 0.30812320f, 0.21594031f, 0.11644634f, 0.16172293f, -0.06595476f, 
    -0.05770232f, -0.04700005f, 0.20445314f, 0.01470196f, -0.14937635f, 0.13272059f, -0.14128371f, -0.66944897f, 
    -0.28732517f, -0.02736855f, 0.02520444f, -0.05896334f, -0.01173944f, 0.07349180f, -0.13479660f, 0.15462679f, 
    -0.17201510f, -0.16159116f, -0.01042938f, 0.26244780f, 0.03349436f, 0.10765439f, -0.00281958f, 0.11444981f, 
    0.01638907f, -0.07104406f, 0.03705645f, 0.00814476f, 0.22476475f, 0.09382834f, -0.09789177f, 0.07358869f, 
    0.29212677f, -0.11362206f, -0.03075774f, 0.08042480f, -0.12711157f, -0.04701234f, 0.01227328f, 0.10003343f, 
    -0.70070750f, -0.20235275f, 0.49785095f, -0.23145325f, -0.29370987f, 0.00897219f, -0.53528976f, 0.04106537f, 
    0.08293044f, -0.05062860f, -0.01851776f, -0.17960866f, 0.98041272f, 0.07584384f, 0.16375996f, -0.02005811f, 
    -0.08648777f, -0.14849775f, -0.22160214f, -0.18967393f, -0.09301853f, -0.00118063f, 0.07287905f, -0.15985040f, 
    -0.12199823f, -0.33058786f, -0.16995668f, -0.62715286f, 0.14671639f, 0.14075747f, -0.00819884f, 0.05723695f, 
    0.02389734f, -0.01993553f, -0.10780037f, -0.02014589f, -0.03684973f, 0.16037764f, -0.15006702f, -0.24303858f, 
    0.19690146f, 0.11956961f, 0.03547562f, -0.04793426f, -0.13146748f, -0.01108572f, 0.01993851f, 0.10218560f, 
    0.45800743f, -0.18020834f, -0.07776655f, 0.03465950f, 0.12164921f, -0.06498811f, 0.04705166f, -0.08779002f, 
    -0.17195188f, 0.07801197f, -0.13559321f, 0.09463153f, -0.01344107f, -0.12960184f, -0.05306750f, 0.23998545f, 
    0.01972760f, -0.03057513f, 0.02245797f, 0.05995932f, -0.01287996f, 0.07457089f, 0.13428284f, 0.06674400f, 
    -0.06402197f, -0.20327576f, -0.34856179f, 0.01009905f, 0.04758623f, 0.08995473f, 0.01722278f, 0.04548569f, 
    -0.03954476f, -0.05226786f, -0.01739051f, 0.02061745f, 0.66437775f, -0.27076921f, 0.08090813f, 0.14125660f, 
    -0.05316393f, 0.14718071f, 0.14358917f, -0.04759631f, -0.08600059f, -0.04676228f, -0.01092269f, 0.13409336f, 
    0.07005556f, -0.12610713f, 0.15308571f, 0.09959275f, -0.07737043f, 0.08314890f, 0.00386483f, 0.09034313f, 
    0.08380617f, -0.15167619f, -0.03348644f, 0.03385875f, -0.08947709f, -0.12974681f, -0.15115631f, 0.25420114f, 
    -0.08040623f, 0.11235782f, 0.02462631f, -0.24810739f, -0.07817262f, -0.14672722f, -0.03203795f, -0.30144361f, 
    -0.07628722f, -0.09163953f, -0.22067563f, 0.13237509f, -0.18649904f, -0.05722323f, -0.05739908f, 0.09810205f, 
    0.04366129f, 0.05693693f, 0.04113602f, -0.15174308f, 0.07359119f, -0.16502944f, 0.01129937f, 0.36024755f, 
    0.07866254f, -0.01218780f, 0.04166696f, -0.15697822f, 0.03388302f, 0.02222365f, 0.03632555f, 0.08289211f, 
    0.95954478f, 0.15541790f, 0.33936006f, 0.49290615f, 0.01660360f, 0.10895714f, -0.27347755f, -0.21356085f, 
    -0.13073573f, 0.05357975f, 0.14149641f, -0.06453610f, 0.35412773f, -0.22822104f, -0.36512831f, -0.22252610f, 
    0.41334882f, 0.20298560f, 0.10180952f, -0.01983455f, -0.05746939f, -0.00616929f, 0.03251591f, 0.00279898f, 
    -0.53680819f, 0.52458239f, -0.27519789f, -0.34584910f, 0.11629062f, -0.12743828f, -0.01709596f, -0.17323489f, 
    -0.11487596f, 0.00277824f, 0.07078402f, -0.03532237f, -0.63141423f, 0.12020273f, -0.08220541f, 0.24350369f, 
    -0.21455948f, -0.20830290f, 0.13361159f, -0.12498920f, 0.04113858f, 0.00152904f, -0.01430029f, 0.12461263f, 
    0.04105124f, 0.31152576f, -0.44742125f, -0.21461503f, -0.02534119f, 0.08872415f, -0.03231177f, -0.10922893f, 
    -0.17089932f, -0.07210647f, -0.08274990f, -0.06383306f, -0.16008021f, -0.21948269f, 0.07765862f, 0.05098971f, 
    -0.24469481f, -0.14854079f, -0.12692709f, -0.28125811f, -0.08538157f, -0.21523954f, 0.10995082f, 0.00004387f, 
    -0.10449582f, -0.50257534f, 0.06955273f, -0.10348292f, 0.09318909f, 0.13702752f, -0.03348107f, -0.33434072f, 
    -0.00074294f, 0.02205300f, 0.00761141f, -0.04237312f, 0.31962395f, -0.19074161f, 0.02662618f, 0.28478712f, 
    0.06326825f, -0.03637715f, -0.23026557f, 0.03041497f, -0.14105403f, 0.03926181f, -0.05889162f, 0.13087939f, 
    0.14832349f, 0.21090707f, 0.76541787f, 0.37278339f, -0.25496793f, -0.43211418f, -0.06841821f, 0.11250072f, 
    -0.03064105f, -0.10955070f, -0.04084750f, 0.25795242f, -0.12863359f, 0.03177783f, 0.01754107f, 0.25812462f, 
    0.16345631f, 0.00950528f, 0.04870989f, -0.17097376f, 0.04155340f, 0.08701107f, 0.10262449f, 0.11666218f, 
    0.19093239f, 0.15033750f, 0.16129525f, -0.02532039f, 0.12153597f, 0.04525658f, 0.03998598f, 0.09044561f, 
    0.13283727f, -0.02518485f, -0.07179976f, -0.03861342f, -0.02517413f, -0.07116660f, -0.18084885f, 0.07896633f, 
    -0.20847462f, -0.12781695f, 0.08570445f, -0.03976845f, -0.09021896f, -0.14191666f, -0.38576069f, -0.29620019f, 
    -0.09579471f, -0.01229977f, -0.07442828f, 0.05394739f, -0.02676329f, -0.08996485f, -0.16293292f, -0.26663768f, 
    -0.09045583f, 0.03975094f, -0.16575344f, -0.17056289f, 0.46736366f, -0.65715712f, 0.09125281f, 0.31523982f, 
    0.09057502f, -0.00295454f, 0.10004057f, 0.07363947f, -0.03839860f, 0.01977603f, -0.00493823f, 0.06884093f, 
    -0.11565646f, 0.08277334f, -0.04926653f, -0.00501023f, -0.01370200f, -0.08745068f, 0.06982278f, -0.10411446f, 
    0.06508659f, 0.27271545f, -0.23929763f, 0.34852064f, 0.01120309f, -0.07166442f, -0.01504633f, 0.12694608f, 
    0.05318795f, 0.05018791f, -0.15818566f, -0.10899153f, 0.19883026f, 0.11249907f, -0.09153187f, -0.09465739f, 
    -0.16815796f, 0.06678294f, 0.10021015f, 0.19032043f, -0.08857134f, -0.14161824f, -0.03873472f, -0.20320067f, 
    0.06286413f, -0.11011865f, -0.06110633f, 0.15107997f, -0.07741233f, -0.12115686f, -0.08764575f, 0.11112180f, 
    0.00954163f, 0.00597711f, 0.02428414f, -0.00173403f, 0.04711117f, 0.01601427f, -0.06491688f, -0.02714940f, 
    0.13442773f, 0.47097746f, 0.28138617f, 0.04905877f, 0.04107901f, 0.04920401f, -0.08902489f, 0.13363330f, 
    -0.04912328f, -0.00107729f, 0.12009224f, -0.02436555f, -0.15878448f, 0.12504004f, 0.25053459f, 0.44075897f, 
    -0.12081272f, 0.03838976f, -0.08340786f, 0.03779973f, -0.03539038f, -0.03712345f, -0.12494288f, -0.03096788f, 
    -0.01686653f, -0.13874507f, -0.02724054f, 0.11529142f, -0.02385692f, -0.04580625f, 0.09591847f, -0.06028966f, 
    0.02977963f, 0.09154397f, 0.08814532f, -0.02138107f, -0.06911765f, -0.15801357f, -0.37980267f, 0.25737047f, 
    0.14599688f, -0.08334558f, -0.01579980f, -0.23306799f, 0.05879952f, -0.41258407f, 0.07875732f, 0.11978850f, 
    0.08329893f, 0.00854351f, -0.08628181f, -0.03633796f, 0.04656168f, 0.06764776f, 0.11254662f, 0.06986294f, 
    0.05000820f, 0.09185594f, -0.17294456f, -0.09734226f, -0.18634196f, -0.26762101f, -0.05202366f, 0.21336007f, 
    -0.09844399f, 0.07670443f, 0.19063908f, -0.07168485f, -0.16660291f, -0.02940607f, 0.07570354f, -0.04380927f, 
    0.24741498f, 0.03622587f, -0.07895228f, -0.05155011f, -0.10125076f, -0.03464679f, -0.00648002f, 0.19765553f, 
    0.14299187f, -0.06450599f, -0.16223539f, 0.00661159f, -0.09414663f, -0.13409822f, -0.05374639f, 0.10561929f, 
    0.03535616f, -0.03057920f, -0.14802103f, -0.12222008f, 0.01352504f, 0.06076936f, -0.04976081f, 0.00487175f, 
    0.26329073f, 0.25099218f, 0.19010513f, 0.09642521f, -0.35732913f, -0.13504694f, -0.06992003f, -0.03126258f, 
    0.00487214f, 0.12200530f, 0.01670188f, 0.04771634f, -0.11365995f, 0.12217554f, -0.04371325f, -0.04068380f, 
    -0.03115853f, -0.15198158f, 0.03914900f, 0.03438725f, 0.01371476f, -0.08954427f, -0.00843469f, 0.39513552f, 
    0.08156551f, 0.28380832f, 0.07436895f, 0.35390100f, 0.00951783f, -0.01042154f, 0.04219451f, 0.05059573f, 
    -0.03404682f, 0.04298288f, 0.01330004f, -0.12530884f, -0.05969458f, 0.12931825f, 0.19183812f, 0.11839002f, 
    0.08388235f, 0.08457470f, -0.24605571f, 0.11057825f, -0.03482356f, -0.00253057f, -0.11151861f, -0.10935204f, 
    0.02387002f, 0.06320022f, 0.20705727f, -0.08506064f, -0.10332642f, 0.10165820f, -0.15441801f, -0.09027366f, 
    -0.04115719f, 0.05386145f, 0.01695456f, 0.22433288f, -0.14175451f, 0.04233345f, 0.11148146f, 0.15097788f, 
    -0.11860043f, -0.30563089f, 0.02596970f, 0.13503776f, 0.00550682f, -0.03513407f, 0.11895909f, 0.04775278f, 
    -0.12758000f, -0.34048095f, -0.45058727f, -0.39895782f, 0.00626645f, -0.17850615f, 0.04507492f, -0.20565425f, 
    -0.17786187f, -0.28001082f, 0.04818118f, -0.13712184f, -0.32195759f, -0.18699715f, 0.10943061f, -0.00213400f, 
    -0.19900237f, 0.01134606f, -0.05816369f, 0.16714874f, 0.09855703f, -0.06281276f, -0.16740429f, -0.08207036f, 
    -0.01796889f, -0.94042087f, -0.08849427f, -0.26504445f, 0.06809126f, 0.08445312f, 0.00365353f, 0.04548205f, 
    -0.00611910f, 0.00370840f, -0.07499447f, -0.05095676f, 0.11618516f, -0.17564410f, 0.15240879f, 0.02925958f, 
    -0.19520500f, -0.06401544f, -0.02284214f, -0.05624119f, -0.09070002f, 0.09047112f, -0.01606299f, -0.23661764f, 
    -0.04251019f, -0.10969481f, 0.22809704f, 0.18063149f, 0.03040566f, -0.01412192f, -0.07862152f, -0.05536339f, 
    -0.00042525f, 0.30292213f, 0.25137779f, 0.40318900f, -0.07356342f, 0.06313910f, -0.14098760f, 0.14909901f, 
    0.11923974f, 0.06282347f, -0.08773485f, -0.02521786f, -0.10545325f, -0.04723179f, -0.31793281f, -0.12074803f, 
    0.08269682f, 0.06562876f, -0.00808326f, -0.06331237f, -0.01134650f, 0.12091966f, -0.00325868f, 0.13226761f, 
    -0.03932573f, -0.37270552f, -0.39464614f, -0.13311183f, 0.08315246f, 0.04956075f, 0.03444130f, 0.13581483f, 
    -0.11933413f, -0.20884369f, -0.05928948f, -0.25041434f, 0.12789285f, -0.07735754f, 0.13345073f, -0.00903454f, 
    0.25233361f, 0.26794007f, -0.41790017f, 0.15040004f, 0.07383297f, 0.20408989f, 0.02183622f, 0.05108225f, 
    0.10671362f, 0.02737741f, -0.04782632f, -0.16402249f, 0.12198424f, 0.18450958f, 0.08051578f, 0.19701266f, 
    0.13351595f, -0.15240014f, -0.12412824f, -0.25277349f, 0.01984376f, -0.04608792f, 0.02862010f, 0.12784053f, 
    -0.14689328f, -0.20115207f, -0.12464947f, 0.16564272f, -0.05786758f, 0.00237152f, -0.16383868f, -0.08131848f, 
    0.05156402f, 0.18325669f, -0.11811512f, 0.04043492f, -0.23172872f, 0.17693411f, 0.13900021f, 0.22312124f, 
    -0.07061126f, 0.02430971f, -0.04595551f, 0.15331590f, 0.12397403f, -0.08864634f, 0.10186226f, 0.05303238f, 
    -0.12078518f, 0.06166438f, 0.45249912f, -0.19431099f, -0.19072923f, -0.16831139f, -0.03728118f, 0.21712446f, 
    0.15648638f, 0.20303573f, -0.06434280f, 0.02719058f, -0.30855513f, 0.04625153f, 0.08842286f, -0.03430085f, 
    -0.06122664f, -0.00328685f, -0.12749812f, 0.07122833f, -0.02776947f, 0.09700149f, -0.13167447f, -0.04853918f, 
    -0.19865739f, 0.00292494f, 0.02098973f, 0.27232486f, 0.09392145f, 0.07758663f, -0.00094050f, 0.05391819f, 
    -0.20390689f, -0.02334730f, -0.31506565f, -0.55264235f, 0.06170077f, 0.01267705f, -0.12435227f, 0.12748523f, 
    -0.02938752f, -0.14800122f, -0.00603521f, 0.00197796f, -0.03753699f, 0.06300496f, 0.11445279f, -0.12250718f, 
    -0.12072565f, 0.09734462f, -0.29653066f, -0.57397598f, -0.01168169f, -0.00030845f, 0.00535852f, 0.05073802f, 
    0.13619159f, -0.19720846f, -0.08504512f, -0.27986649f, -0.00959293f, -0.25360531f, 0.04796397f, 0.07239257f, 
    -0.06158025f, -0.03010226f, 0.05401437f, 0.02644967f, -0.08506912f, -0.15509491f, -0.03378342f, -0.13452700f, 
    0.10301220f, 0.19653098f, 0.00485380f, -0.06685705f, 0.18913440f, 0.09573153f, -0.14272517f, -0.40901509f, 
    -0.08033841f, -0.02201460f, -0.08684865f, -0.03503228f, 0.02470655f, -0.00800802f, 0.23812658f, 0.05209367f, 
    -0.00794524f, -0.06704862f, 0.05153751f, 0.05350518f, -0.10043496f, -0.00409820f, -0.07927040f, -0.11082999f, 
    0.15433452f, -0.11147428f, -0.49233860f, 0.52727187f, 0.15962483f, 0.02396785f, 0.01594550f, 0.10868675f, 
    0.13463923f, 0.03433423f, -0.15472770f, 0.11864403f, -0.86344260f, 0.68579841f, -0.06964638f, 0.28350699f, 
    -0.05386369f, -0.03859995f, 0.11463125f, 0.14500934f, 0.15888748f, 0.00362332f, -0.04782594f, 0.22142796f, 
    -0.08687475f, -0.19763468f, -0.00189866f, 0.07431853f, 0.00342680f, -0.07345960f, -0.07511967f, 0.00958807f, 
    -0.01708669f, -0.07164193f, 0.19867320f, -0.06163200f, -0.26749074f, -0.02630278f, 0.23421445f, -0.07024372f, 
    -0.11167525f, -0.03874153f, -0.25586277f, -0.13169536f, -0.02799364f, -0.12871355f, -0.08100852f, 0.24051277f, 
    -0.27142283f, -0.30880430f, 0.01976888f, 0.09826913f, 0.02323736f, -0.06617630f, -0.05459711f, 0.00311700f, 
    0.06349885f, -0.00780598f, 0.08957238f, -0.04344747f, -0.13139527f, 0.14462763f, 0.05345267f, -0.19215001f, 
    0.13868377f, -0.09190565f, 0.17191313f, 0.03334298f, 0.03002084f, 0.03053774f, 0.03747381f, 0.10708880f, 
    -0.07561509f, 0.07329363f, 0.29121789f, -0.28418869f, 0.33173811f, 0.15617074f, 0.03461454f, 0.01733085f, 
    0.13625067f, 0.00699744f, -0.04080442f, 0.05298570f, 0.11432148f, -0.11291950f, -0.16055675f, -0.07234912f, 
    0.03163807f, -0.12408292f, 0.02947493f, 0.10301174f, -0.05589782f, -0.20444553f, -0.07881252f, -0.45718038f, 
    -0.16206267f, 0.23697959f, 0.21413513f, -0.05384256f, 0.32615671f, 0.03106757f, 0.29347551f, 0.32525212f, 
    0.04243071f, 0.06669428f, 0.08087055f, 0.05094238f, 0.22469296f, 0.19307895f, 0.03628263f, -0.05915078f, 
    -0.05822358f, 0.12319674f, 0.06124599f, -0.09621334f, 0.03316166f, 0.11197297f, 0.06332483f, 0.21095094f, 
    0.22662374f, 0.12775971f, 0.20963220f, 0.18081978f, 0.10626443f, 0.03452916f, -0.18680000f, 0.14595427f, 
    0.04504036f, -0.03433647f, -0.06513555f, 0.06692798f, -0.29309791f, 0.19074850f, -0.43813169f, -0.21637186f, 
    0.09425748f, 0.06908703f, -0.01536514f, 0.04074764f, 0.00532986f, -0.02181030f, -0.07279424f, -0.09838601f, 
    -0.87203687f, -0.10137925f, -0.45340988f, 0.01851512f, 0.21406305f, -0.04939731f, 0.10872971f, -0.01251370f, 
    0.17067908f, 0.11963765f, -0.29041541f, 0.02918826f, -0.52308822f, -0.19805373f, -0.21426861f, -0.20750844f, 
    0.09079655f, -0.04229641f, -0.05655607f, -0.11878705f, -0.05735006f, -0.04371494f, -0.01489775f, 0.02781823f, 
    -0.07158755f, -0.40417233f, 0.11667744f, 0.02803375f, -0.05777091f, 0.00934455f, -0.01472153f, 0.05387229f, 
    0.05535531f, 0.03888540f, 0.16445400f, 0.03873694f, 0.24353322f, -0.09415897f, 0.08088472f, -0.05854363f, 
    0.27922335f, -0.03286260f, 0.07244820f, 0.03077202f, 0.08356170f, 0.00451642f, -0.19416866f, -0.05310958f, 
    -0.36084718f, -0.02855982f, 0.44361240f, -0.27511808f, 0.02118543f, -0.12244587f, 0.04405881f, 0.10236956f, 
    0.11519510f, -0.46894217f, -0.28470892f, -0.43644482f, -0.05664971f, 0.07827719f, -0.16559395f, -0.27013567f, 
    0.02707429f, 0.52576572f, -0.15001547f, -0.11179375f, 0.07399808f, -0.04291574f, 0.17474025f, 0.11060706f, 
    0.09146252f, -0.16118589f, -0.12834328f, 0.04558551f, -0.16226797f, -0.11211087f, -0.04066519f, -0.11182123f, 
    0.10006627f, -0.17444859f, 0.19993758f, 0.32525703f, -0.12500404f, 0.20742267f, 0.02258874f, -0.36837590f, 
    0.27484530f, -0.05900469f, 0.20746623f, 0.05172116f, 0.15189105f, -0.06088772f, -0.05004865f, -0.02481792f, 
    -0.61797172f, -0.07009061f, -0.27513736f, 0.08574151f, 0.03409468f, 0.27352265f, -0.00077346f, 0.04073076f, 
    -0.00130738f, -0.06290158f, 0.01375512f, -0.01478694f, -0.30262277f, -0.08693805f, -0.03195457f, -0.06173278f, 
    -0.11750940f, 0.14391099f, 0.05852225f, -0.12303287f, 0.21877809f, 0.11464330f, 0.22207780f, -0.07473218f, 
    0.02598258f, -0.06388305f, -0.05654119f, -0.18036008f, 0.03310069f, -0.06873280f, -0.12524210f, -0.07625522f, 
    0.05739806f, -0.06821219f, 0.05207819f, -0.04483439f, 0.18153703f, -0.20336515f, -0.12226982f, 0.22208329f, 
    -0.27203324f, -0.02333786f, -0.01710594f, 0.16292621f, -0.07731128f, 0.06077452f, 0.14175476f, -0.42044085f, 
    -0.06606755f, -0.26713249f, 0.00691047f, 0.39126325f, 0.13227436f, 0.13239464f, 0.14460270f, 0.11668918f, 
    0.10316933f, -0.01858373f, 0.10989729f, 0.27487123f, -0.19678888f, -0.35126105f, -0.08638909f, 0.28245309f, 
    0.12787014f, 0.14681822f, -0.13844344f, -0.30097249f, 0.06516663f, 0.01284702f, 0.10147146f, -0.03111738f, 
    -0.32951826f, -0.07992126f, 0.12362545f, -0.02681926f, 0.03649330f, 0.16893409f, 0.04344248f, -0.05052905f, 
    -0.02141632f, -0.05158886f, 0.22190402f, 0.25867909f, 0.40858600f, 0.02111814f, -0.26851746f, -0.14166257f, 
    -0.12587886f, -0.09741969f, 0.42914599f, 0.15961078f, 0.13287766f, 0.04710753f, -0.01062220f, -0.04563419f, 
    -0.27951649f, 0.66684717f, 0.21626826f, 0.00886418f, 0.00529135f, -0.02474076f, 0.02778200f, 0.00177545f, 
    0.09049010f, 0.18090680f, 0.18287745f, 0.06529590f, -0.13945580f, -0.07633846f, -0.05614300f, 0.05114884f, 
    -0.04328134f, -0.01580542f, 0.08314176f, 0.07428575f, 0.01683510f, -0.02514600f, -0.11308821f, -0.03566227f, 
    -0.72739929f, -0.52451104f, 0.08838446f, -0.12561491f, 0.24195454f, 0.11340406f, -0.18324208f, -0.41862658f, 
    0.11854281f, -0.04374576f, 0.15867326f, 0.05860279f, -0.24563223f, -0.61237621f, -0.69014955f, 0.13945588f, 
    -0.14777231f, 0.15980005f, 0.18614790f, 0.16722623f, 0.01735979f, -0.09542939f, 0.00588573f, 0.01112499f, 
    0.32074562f, -0.22582382f, -0.40259418f, -0.10369556f, 0.00313282f, 0.03103151f, 0.25835997f, -0.06447676f, 
    -0.11118939f, -0.05510315f, 0.02038007f, -0.16174774f, 0.05384441f, -0.24100812f, 0.22940235f, -0.13784945f, 
    -0.09264437f, -0.04121405f, 0.03557313f, 0.06283057f, -0.01774950f, 0.13622712f, 0.28998694f, -0.00601798f, 
    -0.02095386f, 0.04509116f, 0.04285431f, -0.04557546f, 0.00052093f, -0.02165376f, -0.09677678f, 0.08130432f, 
    0.08541357f, -0.00194566f, 0.23795328f, -0.15415068f, 0.06830897f, -0.41254619f, -0.21773890f, -0.28765085f, 
    -0.10604823f, -0.07100692f, -0.08013473f, 0.22484863f, -0.15125483f, 0.09768003f, 0.03887026f, 0.10069370f, 
    -0.50985354f, 0.34264141f, 0.28936660f, 0.20600952f, -0.08496186f, 0.02927823f, -0.08906768f, 0.09884476f, 
    -0.08168540f, 0.17457587f, 0.22515455f, 0.07521755f, -0.55020845f, -0.56832910f, -0.01557176f, -0.11879882f, 
    -0.17822288f, -0.24015921f, -0.05264755f, -0.30370748f, -0.00764767f, 0.06129576f, 0.00682323f, -0.06957401f, 
    -1.29296160f, -0.38743171f, 0.28716198f, -0.00081652f, -0.30798575f, -0.23545749f, -0.34594730f, -0.15346926f, 
    -0.09943784f, -0.05596441f, -0.02168954f, -0.05067715f, 0.16052316f, 0.17354351f, -0.13270383f, 0.00261771f, 
    -0.09289107f, 0.01709105f, 0.07891210f, -0.04480958f, 0.03036005f, -0.18284589f, 0.00932193f, 0.10892712f, 
    -0.65308911f, -0.86254787f, -0.75045854f, 0.44028404f, 0.00381006f, -0.12629114f, 0.06855884f, -0.08447059f, 
    -0.00365489f, -0.04303482f, 0.03333626f, 0.01840337f, -0.10637002f, -0.61570567f, -0.08279901f, -0.09124145f, 
    0.13261561f, -0.33974168f, -0.14064305f, -0.22808966f, -0.03355008f, -0.07038422f, -0.12548327f, 0.06626656f, 
    -0.26430395f, -0.65678740f, -0.73772293f, 0.03430918f, -0.19680250f, -0.12181924f, 0.08525917f, -0.26013809f, 
    0.07102476f, 0.05733155f, 0.00467977f, 0.05005001f, -0.89862734f, -0.42204329f, -0.20866026f, -0.58602029f, 
    -0.07750873f, 0.03286173f, -0.21259502f, -0.31552956f, -0.09090251f, 0.01118645f, 0.06888524f, 0.07024686f, 
    0.22282070f, -0.27996790f, 0.58192629f, 0.15931450f, -0.00478054f, 0.06368827f, -0.07292601f, -0.15255597f, 
    -0.00554256f, 0.29225895f, 0.07282583f, 0.10807635f, -0.40357542f, 0.31036079f, 0.55726177f, 0.05856230f, 
    -0.05892517f, -0.01309258f, -0.07244040f, 0.09672844f, 0.02321254f, 0.08943696f, 0.08815216f, -0.04285680f, 
    -0.08601384f, -0.12097731f, -0.07863010f, -0.11010525f, 0.04098975f, 0.03440258f, -0.06118514f, -0.01377396f, 
    -0.04770287f, 0.07918333f, -0.13968943f, -0.08723771f, -0.27939257f, 0.10229960f, -0.09503400f, 0.19833235f, 
    0.06460242f, 0.20944735f, 0.23533823f, 0.11348879f, 0.09973052f, 0.04334332f, 0.15799588f, 0.14964780f, 
    0.00710227f, -0.13379861f, -0.13548195f, -0.12476943f, -0.05693471f, -0.03155741f, 0.08955128f, 0.13576175f, 
    0.06964391f, 0.22273888f, 0.22527635f, 0.21583945f, 0.33868396f, -0.13236119f, -0.17672305f, -0.11819746f, 
    0.00486707f, 0.16564079f, 0.02145598f, 0.14639878f, -0.05090087f, -0.00280584f, -0.04463495f, -0.15957633f, 
    -0.08566736f, 0.14712344f, -0.10369813f, -0.00988530f, 0.01731068f, -0.05531531f, 0.03507880f, 0.04669357f, 
    0.08685648f, 0.21875259f, 0.00178099f, 0.06081294f, -0.79322356f, -0.03341905f, 0.49059123f, -0.60882092f, 
    0.18827960f, -0.39358988f, 0.03251834f, 0.02784850f, -0.00592511f, 0.01433938f, 0.01278720f, 0.03433538f, 
    -0.61135328f, -0.45883930f, 0.16486509f, -0.04665327f, 0.11069538f, 0.25010794f, -0.17878768f, -0.21973397f, 
    -0.02426488f, -0.00109551f, -0.05306131f, 0.07683803f, -0.50281161f, 0.07952535f, 0.49400958f, 0.51633650f, 
    -0.22025603f, -0.16511150f, -0.14827025f, -0.25423920f, -0.04239088f, -0.05160259f, 0.00362965f, -0.03741547f, 
    0.11265355f, 0.12105183f, 0.06448768f, -0.04750270f, 0.05211300f, -0.01711004f, -0.00519812f, 0.00737889f, 
    0.05995738f, -0.04048016f, -0.15255290f, -0.22068241f, 0.25859362f, -0.17554192f, -0.00874910f, 0.05503599f, 
    -0.33123767f, -0.13487940f, -0.04553793f, -0.01603074f, 0.06912701f, 0.01547968f, -0.03505078f, -0.12351600f, 
    0.46668509f, -0.23517717f, 0.36537430f, -0.54326457f, 0.08604795f, 0.07791173f, -0.17520440f, 0.16380991f, 
    -0.04244087f, 0.02864185f, -0.03232179f, -0.19701776f, 0.20567441f, -0.11920286f, -0.04054812f, -0.27418983f, 
    0.04414300f, -0.04878340f, -0.12574178f, -0.00009913f, -0.03522013f, 0.10833777f, 0.01697141f, 0.04248893f, 
    0.00994207f, -0.10242076f, -0.08773773f, -0.04065875f, -0.05835149f, -0.10086657f, -0.15288514f, -0.05585701f, 
    0.05027709f, 0.06702076f, -0.08819430f, 0.13135774f, -0.08788627f, 0.06487965f, -0.04231988f, -0.03331194f, 
    -0.05855975f, 0.01235258f, 0.10500026f, 0.08289092f, -0.22878607f, 0.13617194f, -0.00730945f, 0.06118447f, 
    -0.45901796f, -0.32337779f, -0.52842373f, -0.14015007f, -0.01713919f, -0.11304423f, 0.13507923f, 0.01632713f, 
    -0.02075028f, 0.11040912f, 0.08206705f, -0.01769298f, 0.10681974f, 0.09551794f, -0.07014199f, -0.20005134f, 
    -0.04567268f, -0.02994690f, -0.03155041f, -0.06948239f, 0.02562722f, 0.06090890f, 0.00997662f, -0.02030852f, 
    -0.50700796f, 0.16201450f, 0.37164682f, 0.32730505f, 0.07831276f, -0.03833831f, 0.07543802f, -0.01036726f, 
    -0.03224946f, -0.22366396f, 0.03172966f, -0.07923913f, -0.58255261f, -0.28709164f, 0.19406623f, 0.24526772f, 
    0.04930576f, 0.12215990f, 0.08223847f, -0.05310163f, 0.02898456f, -0.05335108f, -0.03000658f, -0.04622211f, 
    -0.01080483f, 0.08562174f, -0.03309488f, -0.14511363f, 0.00482839f, 0.01216967f, -0.07023028f, -0.07114705f, 
    0.03436529f, 0.10141228f, 0.03062368f, 0.01182776f, 0.26595587f, 0.17101125f, -0.45667771f, 0.48678803f, 
    0.06888185f, 0.07641839f, -0.03342516f, -0.14613086f, -0.09153020f, -0.07032706f, 0.05541011f, -0.10805222f, 
    0.21553242f, -0.14745456f, 0.04660676f, -0.21320134f, 0.07087084f, 0.02544255f, -0.03384773f, -0.04664131f, 
    0.07260522f, -0.08363613f, -0.12939499f, -0.21343000f, 0.69508266f, -0.65112382f, 0.32305247f, -0.74421668f, 
    -0.03600021f, -0.01941749f, -0.18074492f, 0.29708776f, 0.05023659f, -0.01043097f, -0.06590487f, -0.00016337f, 
    1.03367352f, -0.14250928f, -0.26601523f, -0.20480688f, 0.04630337f, -0.08220170f, -0.07393480f, -0.07851961f, 
    -0.02875578f, 0.00547925f, 0.02606421f, 0.04975129f, -0.26926184f, -0.39232159f, -0.20423496f, -0.23167825f, 
    -0.03013254f, -0.03987987f, 0.00492985f, 0.20872654f, 0.07188196f, -0.04121677f, -0.05868518f, 0.00345280f, 
    0.28835756f, -0.57275963f, 0.29449648f, -0.04718764f, 0.09198097f, 0.12940916f, -0.02462735f, 0.10983408f, 
    0.03715819f, 0.11423261f, 0.06696558f, 0.01482881f, 0.12356025f, -0.04057829f, -0.10880993f, 0.09192882f, 
    -0.04880904f, 0.02824151f, 0.09911471f, 0.00234743f, -0.00649620f, -0.05071309f, -0.01195973f, 0.09751123f, 
    -0.37998939f, -0.13304284f, 0.00563647f, 0.10758553f, 0.19145663f, -0.11026141f, -0.01885626f, 0.05739280f, 
    0.01761002f, -0.04077992f, 0.03265188f, 0.04338747f, -0.57864237f, -0.24638191f, 0.65489012f, -0.14224367f, 
    -0.08756518f, -0.03249070f, -0.02414558f, 0.17508614f, 0.00182972f, 0.07879354f, -0.06664063f, -0.05047614f, 
    -0.38168004f, -0.40233943f, 0.33716273f, 0.10930905f, -0.13670090f, 0.01047685f, 0.14675228f, 0.12549210f, 
    -0.09539092f, 0.00086902f, -0.12823491f, -0.12730744f, -0.18153003f, -0.50149667f, -0.41996637f, -0.25662857f, 
    0.07677857f, -0.23953372f, -0.00088998f, 0.24668907f, 0.11573412f, -0.01256265f, 0.02020564f, 0.09188650f, 
    -0.08453068f, 0.25545201f, -0.06024336f, 0.21854764f, -0.02893130f, 0.19173771f, -0.14462554f, 0.05522935f, 
    -0.08238752f, 0.09797312f, 0.12161157f, -0.06644593f, 0.56433332f, -0.02483125f, -0.35368896f, -0.34454176f, 
    0.06446538f, -0.03352021f, 0.00235627f, -0.03737108f, 0.02568265f, 0.00029893f, -0.14236571f, -0.07265745f, 
    -0.00013053f, -0.02385168f, -0.06046845f, -0.30521739f, 0.06327148f, -0.07315513f, 0.00178028f, -0.03621227f, 
    0.04986557f, 0.00275888f, -0.11467507f, -0.06419601f, -0.05206864f, -0.14049675f, 0.20351835f, -0.25088263f, 
    -0.07513464f, 0.01993230f, -0.05579258f, 0.07219090f, -0.14753209f, 0.03857656f, 0.15196496f, 0.01673863f, 
    0.39678967f, -0.26489687f, -0.13065976f, -0.13296284f, 0.01695634f, -0.06960420f, -0.08971756f, -0.10045487f, 
    0.17039013f, 0.21928410f, 0.02289057f, 0.00745700f, -0.14774445f, 0.05744244f, 0.15063637f, -0.00182287f, 
    -0.31487232f, 0.03690702f, -0.03115391f, 0.04340856f, 0.03573335f, -0.03869765f, -0.01572150f, -0.04220887f, 
    0.07142645f, -0.02659130f, 0.05941299f, -0.19971576f, -0.00674999f, 0.01853701f, -0.02001263f, 0.00015569f, 
    -0.21605892f, -0.02087142f, -0.16214424f, -0.09281233f, -0.22877330f, -0.65266109f, 0.05362247f, -0.44518170f, 
    -0.20353471f, 0.14546832f, 0.12879105f, -0.00954575f, 0.14982405f, 0.00754773f, 0.00743343f, 0.03894461f, 
    -0.25327742f, 0.33700758f, 0.01528604f, 0.07945880f, -0.16285852f, -0.15897091f, 0.04743620f, 0.02843813f, 
    0.03757903f, 0.00320096f, 0.06788030f, -0.01590264f, 0.14212853f, -0.63695920f, -0.66429228f, -0.34908354f, 
    -0.06738377f, -0.20023626f, 0.07337943f, 0.16197038f, 0.09282185f, -0.00500878f, 0.07868729f, -0.00158451f, 
    -0.33611414f, -0.01200039f, -0.03058787f, -0.30930594f, -0.02810652f, -0.02215056f, -0.04780941f, 0.03343858f, 
    0.06446704f, 0.08343793f, 0.13471568f, 0.20766751f, 0.37562755f, 0.08904428f, -0.05360398f, -0.12424919f, 
    0.14798801f, 0.07310283f, -0.04645288f, -0.01988428f, 0.10274656f, 0.19135007f, 0.19126210f, 0.26581556f, 
    0.32798132f, -0.16395678f, -0.13476513f, -0.15280241f, 0.01703587f, -0.10754758f, 0.21834053f, -0.06583122f, 
    -0.01314393f, -0.05407312f, 0.21393718f, 0.28550705f, 0.18960138f, 0.22924890f, 0.08304832f, -0.43511412f, 
    -0.14823575f, -0.11811108f, -0.18500209f, -0.11394474f, -0.18544264f, -0.13684997f, -0.21592055f, -0.15211768f, 
    0.19341119f, 0.20891841f, 0.13024153f, -0.03790447f, 0.16549315f, -0.00946258f, 0.01301066f, 0.18472928f, 
    -0.13002561f, -0.13547039f, -0.18673106f, -0.28531995f, -0.41615480f, -0.14198442f, 0.02808998f, 0.13654621f, 
    -0.01278348f, -0.00524651f, -0.02342192f, 0.15291443f, -0.08983669f, -0.11890652f, 0.24258734f, -0.09266006f, 
    -0.68802893f, -0.65442890f, 0.18169567f, 0.40347123f, 0.01274288f, 0.13907653f, 0.01607373f, 0.25895962f, 
    -0.08264219f, -0.09557646f, -0.12124064f, -0.06823356f, 0.24125606f, 0.14427787f, -0.01814182f, -0.06160425f, 
    0.01469745f, 0.04979399f, 0.08624853f, 0.02586302f, -0.15494332f, -0.07723897f, -0.02793465f, 0.05846956f, 
    -0.02150181f, -0.22067988f, -0.16628985f, -0.40213114f, 0.06714611f, -0.07827249f, 0.12855750f, 0.06224090f, 
    0.10551274f, -0.02171763f, 0.09639101f, -0.02413334f, 0.80098236f, 0.11770961f, 0.08066507f, -0.23963165f, 
    0.07331440f, 0.00403059f, 0.09657121f, -0.00644482f, 0.14697173f, 0.03445179f, 0.10119695f, -0.09800475f, 
    -0.33664984f, 0.27182704f, 0.22843693f, 0.13018857f, 0.09319320f, -0.06439565f, -0.06728734f, -0.01296260f, 
    -0.17227086f, 0.03553858f, -0.03544688f, -0.04153907f, 0.21802934f, 0.23553537f, -0.24874742f, -0.30256027f, 
    0.14483906f, 0.20214528f, 0.02310315f, 0.13957420f, 0.16996621f, 0.24434741f, -0.02521113f, -0.21492665f, 
    -0.13122346f, -0.12195788f, -0.23568703f, -0.22470622f, 0.04828913f, -0.04511778f, 0.00770974f, -0.03148865f, 
    0.06674883f, 0.04962686f, 0.02882540f, 0.06322402f, 0.13333002f, -0.04772320f, -0.68961090f, -0.29494071f, 
    0.06495135f, -0.13493238f, 0.07076785f, 0.11616835f, 0.11564823f, 0.11170989f, 0.05445315f, -0.10118404f, 
    0.21482374f, -0.39637610f, -0.40184441f, -0.28998023f, 0.02292594f, 0.14757185f, 0.02256321f, 0.03767613f, 
    0.06768335f, -0.14691707f, -0.16404997f, -0.10290623f, 0.27170661f, -0.51814514f, -0.69732118f, -0.20419894f, 
    -0.03374681f, -0.13774918f, 0.02778686f, -0.17338085f, -0.06867745f, 0.02568448f, 0.02595232f, -0.08302705f, 
    0.12520303f, -0.68643975f, -0.41125274f, 0.03950951f, -0.21278721f, -0.03802969f, 0.12731351f, 0.11178513f, 
    -0.07396863f, 0.00265289f, 0.00368289f, -0.06050457f, -0.25286686f, -0.31878892f, -0.05908165f, 0.00961052f, 
    0.13949196f, 0.05102829f, -0.01888340f, 0.30018434f, -0.37884098f, -0.17055406f, 0.09688264f, -0.32735044f, 
    0.04705028f, -0.01532900f, 0.08206712f, 0.11910514f, -0.24454261f, 0.04227238f, 0.03387988f, -0.19562188f, 
    -0.08478305f, -0.02032092f, 0.00106650f, 0.03729444f, 0.36481851f, 0.13834427f, 0.10031457f, -0.00693460f, 
    0.12178852f, -0.12283639f, 0.16956800f, -0.10927977f, 0.12814568f, -0.02099701f, 0.12495823f, 0.11727149f, 
    0.22809784f, -0.08948187f, -0.11036590f, -0.18571992f, -0.08895321f, -0.04411019f, 0.22196986f, -0.10393051f, 
    0.04090722f, -0.16430120f, -0.11132681f, -0.09441318f, 0.05039105f, -0.69630986f, -0.86952204f, -0.42381516f, 
    -0.26303184f, 0.09695800f, 0.00083346f, -0.07508791f, -0.15326433f, -0.06593414f, -0.09066756f, 0.03494829f, 
    -0.44524670f, 0.10024476f, -0.00909048f, 0.46180862f, -0.07434259f, 0.08815920f, -0.31614208f, 0.30355966f, 
    0.18666446f, 0.08546313f, 0.12494124f, 0.05044110f, 0.18077300f, -0.49992114f, -0.26999304f, -0.09965322f, 
    -0.25810397f, -0.06261344f, 0.11684540f, 0.01623787f, 0.06218344f, 0.10715900f, 0.09019920f, -0.11561276f, 
    0.28451660f, 0.11555905f, -0.06317457f, -0.25761795f, -0.04185551f, -0.05728849f, -0.00812678f, -0.13342486f, 
    -0.10350635f, 0.01857228f, -0.08535420f, 0.04950752f, 0.32172099f, -0.06880485f, -0.16565317f, 0.08934476f, 
    0.11866437f, -0.04028217f, 0.02636964f, -0.16682765f, -0.08342116f, -0.21422264f, 0.05173822f, -0.21008514f, 
    0.18122090f, -0.00767708f, -0.00883380f, -0.20235674f, 0.10239810f, 0.03693346f, 0.01427002f, -0.03141356f, 
    0.08794481f, -0.01935605f, -0.04259314f, -0.44260079f, -0.42772692f, -0.01894185f, 0.23617934f, 0.09831442f, 
    0.03772085f, -0.14066519f, 0.01723167f, 0.09245425f, 0.24819265f, 0.15139653f, 0.22497833f, 0.00487972f, 
    -0.11241531f, -0.01402509f, -0.05214623f, -0.07492523f, 0.05743096f, -0.08084925f, 0.04662166f, -0.05087952f, 
    0.08421387f, 0.10051832f, 0.01520300f, 0.27067539f, -0.37618247f, -0.89860481f, -0.25671718f, 0.17035294f, 
    0.17154047f, 0.02679613f, 0.20067222f, 0.04449206f, -0.26809356f, 0.07846619f, -0.03121587f, 0.05400970f, 
    -0.53822142f, 0.06311709f, 0.22232291f, 0.06193667f, -0.03051172f, -0.07762042f, -0.08948136f, 0.09532961f, 
    0.02549767f, -0.00991590f, 0.01038047f, 0.07444243f, -0.13591488f, -0.69617879f, -0.27848932f, 0.57956624f, 
    -0.25432339f, 0.21930698f, 0.16432407f, 0.17717493f, 0.02672758f, -0.05886690f, 0.11161557f, 0.09729014f, 
    0.04741797f, 0.15005793f, -0.14081839f, 0.12680562f, 0.02277241f, -0.03762690f, 0.00228925f, -0.23992641f, 
    0.11600124f, 0.11998247f, 0.18225564f, -0.14909321f, -0.05581456f, -0.28312615f, 0.09160367f, -0.01729089f, 
    0.31686175f, 0.04255264f, -0.06563671f, -0.10428537f, 0.06317692f, -0.13365263f, -0.05675495f, -0.09617397f, 
    0.03637252f, -0.82444209f, 0.38013658f, -0.17055751f, 0.02317352f, 0.06383518f, -0.41102868f, -0.06657662f, 
    -0.14353791f, -0.08777221f, -0.05182012f, 0.01405964f, -0.07287423f, -0.62211943f, 0.28978810f, -0.24218968f, 
    -0.09034478f, 0.22288230f, 0.03988019f, 0.20574881f, -0.00226901f, 0.03970632f, 0.05958756f, 0.11874472f, 
    -0.17031512f, -0.09710765f, -0.26453778f, 0.23507585f, -0.05197111f, 0.10364553f, -0.03875137f, 0.09219543f, 
    0.11313272f, -0.03842577f, 0.15855150f, 0.24823852f, -0.30304673f, 0.50549829f, -0.15141752f, -0.17003962f, 
    0.11256699f, -0.08487068f, 0.13212614f, 0.03191693f, -0.01668851f, 0.08961811f, 0.08253102f, 0.05357075f, 
    0.30586469f, -0.17126271f, 0.29892212f, -0.05473150f, -0.05676188f, -0.16415592f, -0.07834181f, 0.00741857f, 
    -0.12077626f, 0.04754276f, -0.05734220f, 0.07139910f, -0.12432462f, -0.24427806f, -0.16089253f, -0.07915344f, 
    0.16325288f, 0.12681295f, 0.07968611f, -0.01829819f, 0.06338461f, -0.15338056f, -0.04489857f, 0.06030490f, 
    0.38537809f, -0.09469963f, 0.04958767f, -0.11929298f, -0.25693780f, 0.06164307f, 0.12854046f, 0.10616405f, 
    0.11972056f, 0.13719870f, 0.04426891f, -0.15252702f, 0.38431919f, 0.08439682f, -0.18388003f, -0.20766187f, 
    -0.15571931f, 0.08891276f, 0.04314133f, -0.09469362f, 0.14798878f, -0.12851980f, -0.08734435f, -0.13354480f, 
    -0.07312332f, -0.10550448f, -0.50459927f, 0.10580814f, 0.03630029f, 0.21992493f, 0.05339504f, 0.09249766f, 
    0.04307550f, -0.13963367f, -0.00005239f, -0.00631049f, -1.15978038f, 0.16133672f, -0.26041609f, -0.16631714f, 
    -0.05908757f, 0.03555955f, -0.08056738f, -0.12389540f, -0.03992058f, 0.04085446f, 0.08203565f, -0.02217639f, 
    0.19028445f, 0.03444675f, 0.36227357f, 0.30630833f, -0.05009807f, 0.00336981f, -0.07312296f, -0.19058697f, 
    0.33409104f, 0.08278846f, -0.00023824f, 0.00993777f, 0.16739158f, 0.15026297f, 0.00209276f, 0.47091401f, 
    0.00535343f, 0.13868585f, -0.04541958f, -0.05883770f, 0.06703190f, -0.08611276f, 0.07377382f, 0.02947163f, 
    -0.18411131f, 0.35333538f, 0.31037059f, 0.30978188f, -0.01261127f, -0.27366358f, -0.27933037f, -0.17900634f, 
    0.09545489f, -0.22352724f, 0.10841825f, 0.11516720f, -0.24055333f, -0.01717565f, 0.23792316f, -0.10258895f, 
    -0.24591678f, -0.01278479f, -0.04776401f, 0.11063762f, 0.12737685f, 0.10149612f, 0.06110150f, 0.00055344f, 
    0.01945306f, -0.17597307f, 0.33560148f, 0.06218196f, -0.06596485f, 0.09639847f, -0.04492648f, 0.24371703f, 
    -0.04692042f, -0.13986145f, 0.02755226f, -0.02000242f, -0.06289610f, 0.31904012f, -0.05624590f, -0.05840268f, 
    -0.13962974f, -0.36912552f, -0.03111221f, -0.13590081f, 0.13948898f, 0.09718402f, 0.16873462f, 0.13928312f, 
    -0.16286691f, -0.31792110f, 0.26174819f, -0.50641125f, -0.16239753f, -0.02506507f, 0.01242210f, -0.05186422f, 
    0.04690668f, 0.02209154f, -0.01521548f, -0.03561483f, -0.36860514f, -0.52362090f, -0.28838542f, -0.08207063f, 
    -0.09097733f, -0.13685240f, -0.07557894f, 0.25539061f, -0.04405694f, -0.02505481f, -0.08153197f, -0.14498621f, 
    -0.34734035f, -0.05575274f, 0.03256349f, 0.37448648f, -0.13013239f, -0.08151510f, -0.02671131f, 0.15566109f, 
    0.07541799f, 0.16945305f, 0.06298839f, -0.09274234f, -0.44831365f, -0.06181239f, -0.17355146f, -0.27331141f, 
    -0.13099030f, -0.03054660f, -0.12171636f, 0.25295693f, 0.16783653f, -0.06109226f, 0.09504440f, 0.05647055f, 
    -0.58597231f, 0.54498702f, -0.94201005f, -0.11926530f, -0.32021368f, -0.05759346f, 0.01714361f, 0.00830996f, 
    0.17148602f, -0.05202104f, 0.00315222f, 0.04819750f, 0.25980720f, 0.26000959f, 0.30672514f, 0.42898428f, 
    0.08772711f, -0.30761942f, -0.31769776f, 0.02121384f, 0.01801710f, -0.09579180f, -0.06211383f, 0.18148871f, 
    -0.13088539f, -0.41400167f, 0.11807781f, 0.06397040f, 0.16299878f, 0.18159188f, -0.01891465f, -0.06207736f, 
    0.02439946f, 0.06275170f, -0.00160614f, 0.09952665f, 0.12845150f, -0.54820901f, 0.28131124f, -0.24170959f, 
    -0.12858787f, 0.01358352f, -0.02809568f, 0.07779501f, -0.04063696f, 0.02234571f, 0.10547639f, -0.04684789f, 
    -0.19652651f, -0.34994113f, 0.29310259f, 0.35793549f, 0.08859405f, 0.06813227f, -0.05166252f, -0.02625965f, 
    -0.02222558f, 0.29331258f, 0.18273839f, 0.04221584f, 0.03468130f, -0.17362793f, -0.15727553f, -0.07865204f, 
    0.08097150f, -0.07026369f, 0.13872154f, 0.13481157f, -0.03152046f, 0.03611533f, -0.25809669f, -0.11318210f, 
    0.33554000f, -0.08024783f, 0.12804042f, -0.08010542f, 0.09538469f, -0.10811543f, 0.09733813f, -0.22706589f, 
    -0.00946476f, 0.16224235f, -0.17413501f, -0.20528224f, 0.16317378f, 0.12202286f, -0.35534301f, -0.61578590f, 
    -0.49324819f, 0.08359453f, 0.02041456f, -0.03081081f, 0.13817231f, 0.06950304f, 0.02773504f, -0.07447388f, 
    -0.28393802f, -0.19031078f, -0.02927697f, -0.38991016f, 0.11541174f, -0.21016012f, 0.01558376f, 0.05320000f, 
    0.02424249f, -0.17674246f, -0.02030995f, -0.03433768f, 0.05324366f, 0.12059523f, 0.21458085f, -0.50535202f, 
    0.24643832f, 0.18925031f, -0.19510753f, 0.08048663f, 0.05249763f, -0.08443081f, -0.00265929f, -0.01510542f, 
    -0.26233187f, 0.05092604f, -0.61398494f, -0.11777331f, -0.03774101f, -0.13995087f, -0.07201990f, -0.04107261f, 
    -0.11799812f, 0.07299419f, -0.00375665f, 0.24888615f, -0.17825013f, -0.01247121f, 0.06424831f, -0.05996896f, 
    -0.03875687f, 0.08827826f, 0.16091417f, 0.10532618f, -0.01773014f, 0.00653005f, 0.29352757f, 0.10327812f, 
    -0.51650727f, 0.20797026f, -0.26337543f, 0.12177723f, 0.09793911f, -0.02564873f, 0.07232935f, 0.07461742f, 
    0.12468487f, 0.20043181f, 0.11986200f, 0.09894442f, -0.11693100f, -0.48173565f, -0.16876186f, -0.01195613f, 
    -0.26058179f, -0.18333136f, 0.00557288f, -0.27492434f, 0.06341901f, -0.28962696f, -0.28563434f, -0.17531365f, 
    0.03008415f, 0.29769164f, 0.33689189f, -0.16960448f, -0.04631574f, 0.10952675f, -0.01510410f, 0.00395933f, 
    -0.05282679f, -0.15693556f, -0.30682170f, -0.50312376f, -0.03221995f, 0.02105992f, -0.01551111f, 0.05114640f, 
    -0.04239610f, -0.13344923f, 0.20592277f, 0.01526679f, -0.17226596f, 0.08697408f, 0.04905860f, -0.02876320f, 
    0.04765191f, 0.09204639f, -0.29249918f, 0.26872063f, 0.08107547f, -0.06054084f, -0.08862836f, 0.08366608f, 
    -0.08059640f, 0.00490189f, -0.24962291f, -0.25637436f, -0.35214490f, 0.25669557f, 0.26740116f, -0.02256093f, 
    -0.28817973f, 0.01186321f, -0.04553754f, -0.07685228f, 0.15108168f, 0.04451486f, 0.13429759f, -0.07168962f, 
    -0.11278950f, -0.02927034f, -0.29351535f, 0.35884258f, -0.03208837f, 0.04306646f, -0.08308622f, 0.00528105f, 
    0.01627701f, 0.01829705f, -0.00398947f, -0.10090248f, -0.57629496f, -0.23552875f, 0.12109164f, -0.09571242f, 
    0.06174503f, 0.21268873f, 0.18591808f, -0.08044919f, -0.06116697f, 0.23116386f, 0.08129089f, -0.09105756f, 
    -0.01795455f, -0.08171538f, -0.01868176f, -0.40181938f, -0.12812066f, -0.04041262f, 0.10939839f, -0.18519828f, 
    -0.10426447f, 0.17271221f, 0.05157711f, 0.06074619f, 0.72982806f, -0.55263716f, 0.53802812f, -0.00103313f, 
    -0.00573770f, 0.13891691f, 0.13948876f, 0.19570404f, -0.03505678f, -0.26000321f, -0.30672684f, -0.07092965f, 
    -0.46831983f, -0.09803524f, -0.27136600f, -0.18852158f, -0.05727770f, -0.11155738f, 0.00104971f, -0.07830571f, 
    -0.11770049f, -0.08125491f, 0.06907436f, -0.02038021f, -0.49459347f, 0.18706343f, -0.78331852f, 0.27858487f, 
    0.01272716f, 0.00163470f, 0.20994160f, -0.01582767f, -0.09264585f, 0.08039318f, -0.22142230f, -0.08086015f, 
    0.29184341f, 0.30077603f, 0.15711878f, -0.46552801f, -0.03052650f, -0.12153302f, 0.08141624f, 0.29321423f, 
    -0.16526623f, -0.04664313f, -0.20957406f, -0.05516882f, -0.04368256f, -0.57248223f, -0.26785913f, -0.13700311f, 
    -0.08062470f, -0.00888531f, 0.00539104f, 0.05944852f, 0.06583608f, -0.00305716f, -0.09406676f, -0.04117645f, 
    -0.45196801f, 0.26995978f, -0.11249678f, 0.03844865f, 0.00452902f, -0.06703967f, 0.19742009f, 0.04598016f, 
    -0.10365801f, 0.13811031f, 0.17536461f, 0.12540190f, -0.01859627f, -0.01590819f, 0.07180066f, -0.09326692f, 
    0.01879544f, -0.16450149f, -0.08032215f, 0.06419306f, -0.15414953f, 0.09099601f, -0.33738112f, -0.72754377f, 
    -0.01610152f, -0.29247341f, 0.26163876f, 0.03868392f, 0.05038569f, 0.14713249f, 0.13956761f, -0.08758222f, 
    -0.02369283f, -0.09492598f, 0.07966524f, -0.00130320f, -0.06407759f, 0.15626085f, -0.38938236f, 0.26853916f, 
    -0.12781726f, 0.23041533f, -0.13546631f, 0.20732924f, 0.09521402f, 0.20866507f, 0.13242054f, 0.12427511f, 
    -0.28693005f, 0.25203711f, -0.47096226f, 0.08786691f, 0.02898320f, 0.02391121f, -0.13951206f, -0.01997641f, 
    -0.02392437f, 0.06469152f, -0.21967462f, -0.17788979f, 0.01420898f, -0.47941706f, 0.00879973f, 0.13570049f, 
    -0.02743579f, -0.19547981f, -0.19964002f, 0.19362517f, -0.08982571f, 0.15510617f, -0.10799649f, -0.07279774f, 
    0.88294125f, 0.25271428f, 0.37381139f, -0.24072248f, 0.01602725f, 0.04155659f, 0.02544545f, 0.01253747f, 
    -0.07665916f, 0.22012934f, -0.02081723f, 0.03521354f, 0.04663926f, 0.25844741f, 0.03078937f, -0.21621376f, 
    0.04651691f, -0.02148626f, -0.03038529f, -0.10617634f, 0.01576975f, 0.10866959f, -0.01346671f, -0.12942770f, 
    -0.38823119f, 0.09560814f, -0.30785108f, 0.07818957f, -0.22517587f, -0.01834234f, -0.02163288f, 0.07469128f, 
    0.12349989f, -0.07665563f, 0.19798008f, 0.06139819f, -0.40771627f, 0.23716827f, 0.18119261f, -0.14277053f, 
    0.22566523f, 0.17311017f, -0.19697961f, 0.23094416f, -0.14560299f, -0.16095845f, 0.02908394f, -0.37118813f, 
    -0.35260206f, 0.39114463f, 0.07518493f, -0.20875965f, -0.05727917f, -0.00675174f, -0.00960805f, 0.14156631f, 
    -0.11777835f, -0.15735020f, -0.50935447f, -0.64001662f, 0.11628462f, 0.01383565f, -0.21105576f, 0.28548595f, 
    -0.04422228f, 0.05628885f, 0.11864511f, -0.02935203f, 0.07539140f, 0.22217466f, -0.26309180f, 0.11602670f, 
    -0.11683920f, 0.12419623f, -0.39126128f, 0.23548426f, -0.28401780f, -0.09621492f, 0.14359286f, -0.12307701f, 
    0.01011716f, -0.00158103f, 0.11153428f, 0.13393106f, 0.33748800f, -0.00390604f, 0.06310182f, 0.19188775f, 
    -0.03215262f, 0.06830963f, 0.26792896f, 0.11809762f, -0.09160261f, 0.12317062f, 0.00846113f, 0.08818687f, 
    -0.06633830f, -0.42301831f, 0.26773733f, 0.09118350f, -0.14487807f, 0.28567943f, 0.12437506f, 0.03106048f, 
    -0.01934429f, 0.00694363f, 0.09201773f, -0.00044454f, 0.04039941f, -0.18494835f, 0.20026927f, 0.06321703f, 
    -0.12963498f, -0.15303984f, -0.09612668f, 0.18789703f, -0.09812539f, 0.07247729f, 0.03494390f, -0.09235676f, 
    0.15592401f, -0.10649478f, -0.09224346f, -0.11350724f, -0.00896543f, 0.06500009f, -0.06096356f, 0.04054980f, 
    -0.19065988f, -0.07323427f, -0.09363664f, -0.03778486f, -0.24763398f, 0.31895459f, -0.37739357f, 0.27252436f, 
    0.08510477f, -0.18906184f, 0.03551687f, -0.05744463f, -0.09889613f, -0.00803706f, 0.12461340f, -0.26968154f, 
    -0.67937940f, 0.43270832f, -0.64143425f, 0.46828514f, -0.02098574f, 0.03184554f, 0.38308981f, -0.30854574f, 
    0.01575583f, -0.13854645f, -0.10921465f, 0.06434800f, -0.47977325f, 0.28095889f, -0.19157553f, -0.14891987f, 
    -0.14122577f, -0.11828811f, 0.25914666f, -0.15862685f, -0.00713207f, 0.04281420f, -0.03952688f, 0.06035739f, 
    0.09732952f, -0.17216913f, -0.02455585f, 0.26258203f, 0.03989699f, -0.04553989f, 0.10717423f, -0.00708799f, 
    0.28860274f, 0.21490389f, 0.17146955f, 0.41945973f, 0.27567568f, -0.01911313f, 0.33693147f, -0.16741431f, 
    0.10719004f, 0.04881350f, 0.01822034f, 0.02367978f, -0.02967000f, -0.01730946f, 0.03521451f, 0.09019476f, 
    -0.99162763f, 0.00827468f, -0.08975173f, -0.00976413f, -0.12458202f, -0.00250672f, -0.02017332f, 0.27870670f, 
    -0.34278107f, -0.10034588f, 0.05936686f, 0.11395694f, 0.37994969f, -0.03771478f, 0.04671359f, 0.19014454f, 
    0.08721467f, 0.19455886f, -0.00619003f, -0.07185218f, -0.03461060f, 0.16448833f, -0.12546614f, 0.07922278f, 
    -0.75872338f, -0.60133916f, -0.01123774f, 0.24723701f, -0.44118544f, 0.12586133f, -0.11594605f, -0.20133263f, 
    0.07568515f, 0.08132634f, 0.11760779f, 0.14231892f, 0.54291928f, 0.42654529f, 0.14481932f, -0.15158111f, 
    0.19402337f, -0.16812208f, -0.06829254f, -0.05244758f, -0.00641594f, 0.16078922f, 0.03092603f, 0.23963191f, 
    0.43986988f, 0.33796751f, 0.30951849f, 0.05397357f, -0.08091556f, 0.01331296f, -0.01246726f, 0.06325492f, 
    -0.14534128f, 0.01616617f, -0.05270834f, -0.07446443f, -0.12985972f, -0.25009495f, -0.21382689f, 0.09841268f, 
    0.05635068f, -0.00224670f, 0.10490759f, 0.07248140f, 0.02469866f, 0.19477193f, 0.12489645f, 0.08628991f, 
    -0.19039501f, 0.14887664f, -0.28723535f, 0.22721203f, -0.01828894f, -0.03111149f, 0.07639674f, -0.03501116f, 
    0.16320197f, 0.10167844f, 0.04473238f, -0.00130464f, -0.22399813f, -0.28278351f, 0.00141744f, 0.42360273f, 
    0.07403716f, -0.07702491f, -0.00617120f, -0.17666426f, -0.15967061f, -0.05718489f, 0.28355807f, 0.04272434f, 
    -0.00809088f, -0.68274838f, 0.04896084f, -0.34128046f, 0.12097816f, 0.00905752f, 0.07271494f, 0.00597923f, 
    0.04215772f, 0.19511577f, 0.05741364f, -0.11835546f, 0.08767059f, -0.18253700f, -0.28843737f, -0.14619595f, 
    -0.30633789f, -0.01770379f, -0.03000318f, 0.00686432f, 0.04207803f, 0.10868012f, 0.14133868f, -0.06499068f, 
    -0.10854898f, 0.08533223f, -0.30223510f, 0.15762976f, 0.07235095f, -0.12541863f, 0.00660536f, -0.34711200f, 
    -0.01930855f, -0.14551884f, -0.15379401f, -0.03704163f, 0.38483885f, 0.06828786f, 0.15553418f, -0.35381344f, 
    -0.22441901f, -0.06357764f, -0.17488645f, 0.06703098f, 0.10543384f, 0.12447623f, 0.12493961f, 0.05029550f, 
    0.01459264f, 0.08700562f, -0.11256779f, 0.19332524f, -0.35489315f, -0.02164088f, -0.22174521f, -0.23631099f, 
    0.05207276f, -0.03503922f, -0.23269011f, -0.09032471f, 0.13242745f, 0.06462602f, 0.26173869f, 0.30688566f, 
    -0.05104057f, 0.12138450f, -0.20846705f, 0.05678975f, -0.06008663f, -0.11663032f, -0.04260005f, -0.07122864f, 
    -0.17288922f, -0.18926156f, 0.01506649f, -0.06280863f, -0.19125597f, -0.09956426f, 0.02732963f, -0.06479415f, 
    -0.00319076f, 0.09326889f, 0.13348576f, -0.00868398f, 0.07456348f, 0.18738712f, -0.23911315f, 0.04063168f, 
    -0.51432943f, 0.05855252f, 0.18589413f, -0.09682253f, 0.00210154f, 0.02120164f, -0.11020835f, -0.07384183f, 
    -0.31685302f, -0.46091858f, 0.49948606f, -0.44577807f, 0.21322855f, -0.00145796f, 0.45512185f, -0.20129688f, 
    0.03310715f, -0.00248478f, 0.10411619f, 0.06705490f, -0.49008438f, -0.14249693f, -0.28862470f, 0.05960851f, 
    0.14235789f, 0.04458772f, -0.16689624f, 0.01013159f, -0.07595633f, 0.04468915f, 0.11855887f, 0.05236411f, 
    0.02693598f, 0.22702824f, -0.00431496f, 0.01084987f, -0.00429556f, -0.14947818f, 0.01268169f, 0.06209648f, 
    -0.01220348f, 0.07512090f, -0.08796662f, -0.11393845f, -0.09072242f, 0.13640715f, -0.16750044f, 0.38017881f, 
    -0.05806415f, 0.10401044f, 0.01981915f, 0.21063116f, 0.10408258f, 0.13764808f, -0.19475672f, 0.15156479f, 
    -0.31824842f, 0.15676080f, -0.43798432f, 0.02423390f, 0.16106363f, -0.00051836f, -0.05250112f, -0.06458096f, 
    0.17237829f, -0.00909927f, 0.13934503f, 0.10195760f, 0.27480263f, 0.13195212f, 0.31146663f, 0.11986829f, 
    0.00739791f, 0.03880409f, -0.10459932f, 0.01619386f, -0.09045395f, -0.04724909f, 0.05740527f, -0.01194267f, 
    0.01444885f, -0.33823508f, 0.22839713f, 0.44888669f, -0.06931962f, -0.06111819f, -0.00607721f, -0.01504926f, 
    -0.04804050f, -0.15706544f, 0.04747054f, -0.01924153f, -0.57879215f, 0.33274004f, 0.02776813f, 0.10129985f, 
    -0.27122527f, -0.03527851f, -0.07423061f, -0.03355157f, 0.06420515f, -0.04834795f, -0.14204572f, -0.12503645f, 
    0.64009887f, 0.38885063f, -0.05289365f, -0.49704778f, -0.14790684f, 0.39909065f, -0.08709571f, -0.03325050f, 
    -0.01127597f, 0.06441481f, -0.11323215f, 0.19829869f, -0.18147676f, 0.33646554f, -0.38223314f, -0.17781325f, 
    0.04668323f, 0.00525798f, -0.08350274f, -0.07174756f, -0.13951306f, -0.00238520f, -0.07929275f, -0.17168593f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21272239f, 0.18914081f, 0.04436977f, -0.09022942f, -0.11682893f, 0.15298595f, 0.07758813f, -0.18353662f, 
    0.13024433f, 0.03204850f, 0.01512999f, -0.02081046f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
