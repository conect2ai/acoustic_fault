#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.94554561f, -0.53997898f, 1.17464006f, -0.68922192f, -0.74884379f, 1.24027455f, -0.06290933f, 0.28372478f, 
    -0.08643886f, 0.73388690f, 0.33672053f, -0.70457035f, 0.41249946f, 0.85970050f, 0.30601740f, -0.59394163f, 
    -0.37371886f, 0.23786180f, -1.72077644f, 1.62316692f, -0.29322311f, -0.78070241f, 0.02678577f, 0.78490007f, 
    -0.09200335f, -0.16538474f, -0.42736518f, -1.59894073f, 0.31418207f, 0.30215618f, -0.07718252f, 0.90037084f, 
    0.79062152f, -0.33915749f, 0.17826353f, 0.02595000f, -0.27908283f, -0.84937721f, -0.74648863f, 0.19011797f, 
    -0.63340962f, -0.47435784f, 0.73199052f, 0.72735256f, 0.54680783f, 0.02278864f, 0.94077104f, -0.48451936f, 
    -0.26974127f, 0.30682442f, 0.05700690f, -0.68076301f, 0.90264159f, 0.24331993f, 0.77061880f, -1.80161345f, 
    -1.67264318f, 0.85831445f, 0.99637145f, 0.46498141f, -0.28655681f, 0.00731809f, 0.10104734f, -0.14498849f, 
    0.29343742f, 0.99089497f, -1.26751912f, -0.85586917f, -1.25371003f, 0.11482034f, -0.62192047f, -0.76208884f, 
    1.05927491f, -0.01083987f, -1.00965571f, 0.32442477f, 0.84646171f, -0.72741401f, 0.47762454f, 0.13058956f, 
    -0.42466047f, -0.96961266f, -0.89766800f, -0.09835806f, -1.09744573f, -1.35502005f, -0.99459445f, -0.18388079f, 
    -0.23893043f, 0.41482297f, 1.08129358f, 0.18578395f, 0.40163288f, -0.58763808f, -0.00152838f, 0.19678068f, 
    0.22580144f, 0.36674830f, 0.26810312f, -0.34321123f, -0.51892632f, -0.61700106f, 0.05476057f, -0.32147428f, 
    0.92774063f, 0.42785072f, 0.43400565f, 0.39050084f, -1.40479064f, -0.65136653f, -0.85265607f, 0.60423070f, 
    -0.21818174f, 0.60962588f, -0.65035009f, -0.84692013f, -0.61767995f, -0.02358071f, -0.90392601f, -0.57192755f, 
    -0.82714218f, -0.42445946f, -0.98234391f, -0.25764033f, -0.09579840f, 0.94721335f, -1.34687638f, -1.19606042f, 
    -0.47458687f, -0.56354737f, -0.05839185f, -0.27575472f, 0.17955968f, -0.71618372f, -0.68759745f, 1.08043051f, 
    0.78145039f, 0.59254503f, -0.67465442f, -0.69640183f, 0.45490879f, -0.55159432f, -0.72949272f, -0.37147161f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.34038982f, 0.63620776f, 0.26875630f, 0.52742243f, 0.06298221f, 0.40801460f, 0.37573963f, -0.01817286f, 
    0.56661779f, -0.47140855f, 0.48053661f, 0.14444518f, -0.12923983f, 0.34259322f, 0.33124533f, 0.17714757f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.36168244f, -0.09104783f, 0.49679986f, -0.12518266f, 0.08948445f, -0.27694753f, 0.00629537f, -0.00991780f, 
    -0.07515164f, -0.35308158f, 0.08797088f, -0.19234833f, -0.27854475f, -0.01710722f, -0.11755914f, -0.00349325f, 
    -0.04545816f, -0.06516665f, -0.09563024f, -0.17474495f, -0.41334188f, -0.18282336f, -0.16966937f, 0.07184825f, 
    -0.05332793f, 0.09920582f, -0.00317997f, -0.03241124f, 0.01742821f, 0.01175947f, 0.17985666f, -0.04717154f, 
    -0.07936901f, -0.00091901f, -0.03968772f, -0.13203871f, 0.04913051f, 0.02690235f, -0.04624314f, -0.07357314f, 
    -0.81607288f, -0.03120136f, 0.35427389f, 0.08103356f, -0.15420036f, -0.54785562f, -0.19515987f, -0.09756506f, 
    -0.04376386f, -0.29319724f, 0.07820494f, -0.01619172f, -0.09296880f, -0.01128541f, 0.03898407f, -0.07399616f, 
    -0.02696858f, -0.08548495f, -0.38708872f, 0.06695782f, -0.32509929f, -0.53919452f, 0.11612928f, 0.00863091f, 
    0.07987904f, -0.05987716f, -0.05253627f, 0.08660980f, 0.03545228f, -0.05514974f, -0.31614959f, -0.00600676f, 
    0.03273068f, -0.04199350f, -0.19249509f, -0.08410141f, -0.05526586f, 0.08575596f, -0.05433646f, -0.07368654f, 
    0.43838492f, 0.41324526f, -0.00136609f, -0.13089076f, 0.05281661f, 0.07715397f, 0.10136162f, 0.06276561f, 
    -0.08153553f, -0.01029637f, 0.06842350f, -0.09082060f, 0.03750920f, 0.05170438f, 0.07035165f, -0.02241279f, 
    -0.05219790f, -0.02112705f, 0.05077224f, 0.06259024f, -0.15151457f, -0.20287113f, -0.17607875f, 0.06013111f, 
    -0.06256807f, 0.03174946f, 0.00789302f, 0.01334018f, -0.01750024f, 0.03296622f, -0.19392574f, 0.04856899f, 
    -0.06762516f, -0.25472456f, -0.10451107f, -0.02769917f, -0.08579313f, -0.21618253f, -0.05507383f, -0.06826013f, 
    0.51336789f, -0.11053229f, -1.15391660f, -0.00294005f, 0.00867411f, 0.25287724f, 0.08018453f, 0.16583866f, 
    -0.15394214f, 0.13293846f, -0.15488075f, -0.00808223f, -0.09896097f, -0.00381623f, -0.03697601f, 0.06819455f, 
    0.18413936f, -0.01611222f, 0.03795357f, 0.04612807f, 0.08772544f, 0.31555030f, 0.04497607f, -0.60007244f, 
    0.01925134f, 0.00843018f, 0.11845859f, -0.22567965f, -0.09023549f, -0.01895612f, 0.03722046f, -0.12479669f, 
    0.01341791f, 0.01248712f, 0.03585029f, -0.07666385f, -0.03519728f, 0.05837015f, 0.20225598f, 0.01967001f, 
    -0.32278359f, -0.13972606f, -0.61157453f, 0.16452616f, -0.11418813f, -0.08703959f, -0.06055157f, -0.06964438f, 
    -0.00857289f, 0.10987809f, -0.26875031f, -0.02486853f, -0.43660372f, -0.29949376f, -0.18778746f, -0.07091819f, 
    0.02572254f, -0.06697108f, -0.13975604f, 0.02849579f, 0.53917378f, 0.51070559f, 0.12247983f, -0.51380163f, 
    -0.11048560f, 0.10653604f, 0.17138521f, 0.06228574f, 0.01310875f, 0.12395810f, 0.02367077f, -0.01236391f, 
    0.04105899f, -0.05000676f, 0.02568588f, -0.05954143f, -0.09367634f, -0.00408391f, 0.01870237f, -0.17281164f, 
    -0.14527145f, -0.02907255f, -0.02084929f, 0.02747077f, -0.02683425f, -0.06789152f, -0.02213637f, -0.01508386f, 
    0.00664457f, 0.01159305f, -0.02680506f, 0.03794628f, -0.00205863f, -0.02395110f, 0.07063635f, -0.06701164f, 
    -0.10167374f, -0.08481564f, -0.18600953f, -0.01979259f, 0.17717634f, 0.11837130f, -0.02995490f, -0.00033153f, 
    0.05488284f, 0.15787090f, 0.03553502f, 0.09161056f, 0.02783453f, 0.01819205f, -0.27009267f, -0.05203702f, 
    -0.01927208f, -0.01789911f, 0.10751250f, -0.00123469f, -0.05475256f, -0.11610025f, 0.04445534f, -0.09833430f, 
    0.55552351f, 0.26434720f, 0.35704571f, -0.43039709f, -0.06450289f, -0.04724412f, 0.22084557f, 0.09750513f, 
    0.06772560f, 0.10971381f, -0.01616362f, 0.07407728f, 0.00563769f, 0.01584079f, -0.02846345f, -0.02476465f, 
    0.03867274f, 0.00669668f, -0.10438732f, -0.06262289f, 0.35349417f, 0.37615612f, -0.04171836f, -0.35566846f, 
    -0.30440730f, 0.08286981f, -0.08197296f, 0.08571798f, -0.10528937f, 0.10010656f, -0.03759430f, -0.04673890f, 
    -0.07885006f, 0.00853186f, 0.04534527f, -0.00437999f, -0.10130186f, -0.05398177f, -0.07030498f, -0.22975555f, 
    0.56838906f, 0.21110445f, 0.14430322f, -0.36128876f, -0.12669426f, 0.15277486f, 0.21568224f, 0.10049596f, 
    0.07903309f, 0.08730016f, -0.02145610f, -0.06334740f, 0.00052377f, -0.02893800f, -0.02211335f, -0.02562893f, 
    -0.12429961f, -0.07273164f, -0.18300813f, 0.02931972f, -0.80258322f, 0.53866547f, 0.23263440f, -0.11739170f, 
    0.00950167f, 0.09470244f, -0.05133381f, -0.08717622f, 0.05925474f, 0.05910015f, 0.11177956f, 0.04893005f, 
    -0.04629688f, 0.06599565f, 0.01001057f, 0.20603859f, 0.10983562f, -0.09037446f, 0.10256509f, -0.08402456f, 
    -1.04848146f, -0.07188386f, -0.00920640f, -0.10309912f, 0.32376376f, 0.00671243f, 0.04858093f, 0.08309425f, 
    0.19615643f, 0.11215793f, 0.13051265f, 0.12950557f, -0.06683299f, -0.03493629f, -0.12535478f, -0.01034733f, 
    0.23343450f, 0.11195968f, 0.12174344f, 0.18426347f, 0.59928399f, 0.01251901f, 0.24332391f, 0.20755206f, 
    0.20826927f, -0.03497661f, -0.04321724f, 0.04284944f, 0.08413527f, -0.10172906f, -0.17082031f, -0.00045631f, 
    -0.08362501f, -0.01438387f, -0.00228386f, 0.17135198f, 0.03774120f, -0.12909883f, 0.03464932f, 0.00686718f, 
    -1.47083211f, -0.80877185f, 0.03512380f, -0.41676852f, -0.06359550f, 0.27490667f, 0.15402292f, -0.13807884f, 
    -0.31652448f, -0.02590142f, -0.08335978f, 0.12846433f, -0.02469056f, 0.01968171f, 0.10037419f, 0.02457916f, 
    -0.32761770f, -0.03743825f, 0.03333081f, -0.08059021f, -0.30214286f, -0.41310883f, -0.00121629f, 0.16259925f, 
    0.08810295f, -0.03987624f, -0.06007940f, 0.07868662f, -0.03348169f, 0.01146373f, 0.03658180f, 0.00799031f, 
    -0.19735481f, 0.00350996f, 0.14798556f, 0.02650858f, -0.06464615f, -0.10675538f, 0.02813003f, -0.06804030f, 
    -0.40849301f, -0.13878848f, -0.22027144f, 0.21629812f, 0.01355812f, 0.08106217f, 0.10538095f, 0.14009354f, 
    0.08019399f, -0.10197597f, -0.12612288f, 0.12163786f, 0.02061399f, 0.05042088f, 0.04594365f, -0.04505416f, 
    0.00925622f, 0.01578658f, -0.00187361f, 0.06024513f, -0.02963135f, -0.10938846f, 0.05550662f, 0.03017573f, 
    0.00433394f, 0.05479697f, -0.12682661f, -0.00725524f, 0.06063979f, 0.00617281f, 0.11852001f, 0.19523600f, 
    -0.05413545f, 0.12069610f, -0.04972055f, -0.27504256f, 0.16618431f, -0.23997337f, 0.06446847f, 0.04597166f, 
    1.05655110f, -0.51241839f, -0.16421922f, 0.07441862f, -0.24853407f, -0.08139373f, 0.01175859f, 0.12108625f, 
    -0.23915710f, 0.01965812f, 0.22106004f, -0.32412171f, 0.03182316f, -0.12164790f, -0.13469706f, 0.06020650f, 
    0.02444655f, -0.08744642f, 0.01490840f, 0.03675495f, -0.13688524f, -0.20757549f, -0.51604944f, -0.72523898f, 
    -0.20700496f, -0.02356509f, -0.23215201f, -0.44721800f, 0.21252936f, -0.07776920f, -0.07487125f, -0.02688712f, 
    0.04239606f, -0.04007040f, 0.01805871f, -0.07603742f, -0.18496168f, -0.08608226f, -0.19579495f, -0.32306588f, 
    0.45498356f, -0.00365653f, -0.06485309f, 0.15803736f, -0.26911455f, -0.00381256f, -0.02416214f, -0.05514137f, 
    0.07991631f, -0.06565142f, 0.14716014f, 0.25448793f, 0.04811977f, -0.01049743f, 0.13450541f, 0.00518300f, 
    -0.13398294f, 0.05063544f, 0.13084975f, -0.04047176f, -0.24041142f, 0.35075623f, -0.05018782f, 0.45400274f, 
    0.10232586f, -0.25816327f, -0.08565306f, 0.00444663f, 0.11090605f, -0.12160814f, -0.07212924f, 0.05326948f, 
    0.00182261f, -0.00825670f, 0.07988121f, -0.04356141f, 0.06608634f, 0.13276216f, -0.38889715f, 0.02357739f, 
    0.19017826f, 0.07934982f, 0.20140268f, -0.03697276f, -0.02448130f, -0.01689120f, -0.03485488f, -0.10893883f, 
    0.00252169f, 0.04586827f, -0.02187660f, -0.15068047f, 0.06860681f, 0.11449773f, 0.01129755f, -0.10110367f, 
    0.04400305f, -0.00488599f, 0.17194563f, -0.00727080f, -0.10269817f, -0.25158194f, -0.24655372f, -0.08786950f, 
    -0.14247398f, -0.04633537f, 0.07185563f, 0.04673688f, -0.05924228f, 0.07935353f, 0.04618713f, 0.25211197f, 
    -0.17613617f, 0.02931451f, -0.01661095f, -0.12321842f, 0.05304116f, -0.03933824f, -0.11028131f, 0.10655485f, 
    -0.09729520f, 0.33745521f, 0.33156395f, 0.10122328f, -0.34260628f, 0.09155841f, -0.09829496f, 0.24345249f, 
    -0.03627717f, 0.00405016f, 0.04466017f, -0.00501797f, 0.01637067f, -0.23065531f, 0.15464112f, 0.27888829f, 
    -0.00996696f, -0.26461175f, -0.05039281f, -0.07693298f, -0.24998455f, 0.03489471f, -0.22295953f, 0.18487376f, 
    -0.17594700f, -0.00524199f, 0.07441397f, 0.06423576f, -0.01378300f, -0.10463814f, 0.01887378f, -0.06692489f, 
    0.09637531f, 0.02671704f, 0.04588593f, -0.04360023f, 0.01213447f, 0.07194785f, -0.20553897f, 0.01450029f, 
    0.15487209f, 0.30168444f, 0.35981506f, 0.09424074f, 0.14961487f, 0.21396016f, -0.02498565f, 0.08814115f, 
    -0.02862123f, 0.05092023f, 0.00630917f, -0.00366696f, 0.03505797f, -0.09921841f, 0.08357517f, 0.10429349f, 
    0.01690654f, 0.03261496f, -0.10419155f, -0.00664761f, 0.70464653f, 0.37842891f, -0.01508287f, 0.01328271f, 
    -0.00903753f, -0.11849182f, -0.06933798f, -0.03082490f, -0.18784627f, -0.07823703f, -0.07386779f, 0.00348860f, 
    -0.02421911f, 0.00575443f, -0.02703121f, -0.12149900f, -0.08746348f, -0.01351811f, 0.16590136f, -0.00059061f, 
    0.84612197f, 0.47011507f, -0.61913615f, 0.04142933f, 0.21341948f, -0.10625605f, 0.16157657f, -0.25350225f, 
    -0.02804676f, 0.27656597f, -0.14112975f, 0.01739880f, -0.09729379f, -0.00476131f, -0.14678718f, 0.00991989f, 
    0.04132990f, 0.08968674f, -0.35028571f, 0.20438690f, -0.06842451f, -0.11573278f, -0.17874297f, -0.20966299f, 
    -0.08821762f, -0.00826441f, -0.04883293f, -0.05291963f, -0.03983906f, 0.08571512f, -0.08698315f, -0.15505919f, 
    -0.13212703f, -0.22315149f, -0.01478960f, 0.07746886f, 0.03646579f, -0.08070788f, 0.22470002f, 0.04146803f, 
    0.52266949f, 0.06219346f, -0.02115903f, -0.00991747f, 0.12987977f, 0.07846245f, -0.04538058f, -0.04682149f, 
    -0.40146983f, 0.20704371f, -0.08387472f, -0.07839701f, 0.10233674f, 0.06299033f, -0.04339192f, 0.15102996f, 
    0.21104905f, -0.00691082f, 0.18073170f, 0.15385978f, 0.17059037f, -0.15858737f, 0.01584422f, 0.01904348f, 
    0.19744468f, 0.02228503f, 0.11811065f, 0.10634046f, 0.01645853f, -0.00434683f, -0.09760036f, 0.02882882f, 
    -0.05308444f, 0.09736402f, 0.13263723f, 0.07957087f, 0.01498578f, 0.09432710f, -0.03049064f, -0.00811603f, 
    -0.02585041f, -0.07240804f, -0.16348034f, 0.19401358f, -0.06185836f, 0.00873442f, -0.21174343f, -0.37189028f, 
    0.13950631f, -0.46438760f, 0.06923270f, 0.14786744f, -0.01141616f, 0.06475828f, -0.04568628f, 0.04070906f, 
    -0.06777211f, -0.04178010f, -0.01964046f, -0.10418316f, 0.11801358f, -0.11966169f, -0.01872132f, -0.07196403f, 
    0.11532907f, 0.05001391f, 0.00082923f, -0.07009338f, 0.06882484f, 0.04188918f, 0.10138003f, -0.05139366f, 
    -0.11577293f, 0.22393741f, 0.12266170f, 0.10523506f, -0.22208768f, -0.12621637f, 0.08640500f, -0.06945389f, 
    -0.00464578f, 0.29293436f, 1.20917594f, 0.19181396f, 0.27595913f, -0.05756381f, 0.00021336f, 0.12626646f, 
    0.03697129f, -0.22324239f, 0.11991078f, 0.08565683f, 0.09435589f, -0.05673563f, 0.10354380f, 0.02967854f, 
    0.02294105f, 0.08111960f, 0.09919137f, -0.12991928f, -0.39286044f, -0.29788104f, 0.30828020f, -0.28222388f, 
    -0.04783374f, 0.04628617f, -0.15611833f, -0.30080137f, -0.01138280f, 0.06966440f, 0.02661263f, -0.02695069f, 
    0.05941953f, 0.03032944f, -0.11187078f, -0.03472992f, -0.06895478f, 0.19127746f, 0.07811376f, 0.07783246f, 
    -0.13061203f, -0.03174070f, 0.12285419f, -0.30288544f, 0.06215522f, -0.02596796f, -0.16482301f, -0.22682323f, 
    0.16525719f, 0.00520615f, -0.00309289f, -0.19049585f, -0.11514644f, -0.02199629f, -0.04365610f, 0.20077856f, 
    -0.08212265f, -0.40850741f, 0.18769062f, -0.05820122f, -0.83066624f, -1.26058626f, -1.12646019f, 0.00096730f, 
    -0.98478580f, -0.05946837f, -0.13361150f, -0.21467490f, -0.03052250f, 0.00023183f, -0.07482847f, 0.03349431f, 
    -0.06997894f, -0.05579540f, -0.10669234f, -0.03148349f, -0.00573748f, 0.03103360f, -0.21773936f, 0.10986544f, 
    -0.47719139f, -0.03299013f, 0.04324634f, -0.01517753f, -0.03753807f, -0.13278899f, -0.09255214f, -0.11422800f, 
    -0.06324811f, 0.07638636f, 0.13094883f, 0.03609174f, -0.04805050f, 0.17784226f, -0.05675649f, -0.00931378f, 
    -0.24009861f, -0.03178030f, -0.04953802f, 0.00131658f, -0.04072849f, 0.29777202f, 0.01781046f, 0.17819192f, 
    0.18822730f, -0.01764441f, -0.00013698f, 0.13161162f, 0.06575701f, -0.39422515f, -0.07363693f, -0.16394287f, 
    -0.08164024f, 0.07048418f, 0.05215540f, -0.06799830f, -0.10297102f, 0.04607989f, -0.02715895f, -0.04596451f, 
    -0.64043975f, -0.17791361f, 0.58419251f, 0.53745949f, 0.32210824f, -0.09914124f, -0.29512623f, -0.18175621f, 
    -0.08627243f, -0.18266234f, 0.01627898f, 0.00946755f, 0.00166288f, -0.10373164f, -0.13242280f, -0.12467849f, 
    0.08262677f, 0.03437872f, -0.07379269f, -0.00104438f, 0.02808067f, -0.95069367f, -0.31538814f, 0.14752093f, 
    -0.53388184f, 0.23495941f, 0.14485292f, 0.13381104f, -0.18048984f, -0.04865689f, -0.00845769f, 0.03430937f, 
    0.04750388f, 0.00957285f, -0.07118400f, -0.02673105f, -0.02587510f, -0.02387837f, -0.05013465f, -0.00830042f, 
    -0.03688915f, 0.21909346f, 0.47869226f, 0.43138775f, 0.59926617f, 0.05392400f, 0.26499590f, -0.02701659f, 
    0.26015630f, 0.12360077f, -0.00927200f, -0.02263646f, 0.03636872f, 0.05400533f, -0.02382213f, 0.03718298f, 
    0.03485217f, -0.02927007f, -0.07512172f, 0.08745431f, -0.57414198f, -0.57906854f, 0.15134397f, -0.16827457f, 
    -0.32239056f, -0.04954299f, 0.01047670f, 0.01598374f, 0.02206703f, 0.11428849f, 0.04435710f, -0.03117103f, 
    -0.02776448f, 0.02373323f, 0.00747446f, -0.07802349f, 0.08836950f, 0.27756360f, -0.16838345f, -0.19643377f, 
    0.26428953f, 0.58352792f, -0.42116961f, -0.78922379f, -0.15382524f, -0.00332696f, 0.06463704f, -0.34144750f, 
    -0.09546507f, -0.30840334f, 0.04057298f, 0.08415292f, -0.27090326f, -0.18792719f, 0.01009412f, 0.16604455f, 
    0.04628916f, -0.08523752f, -0.20931403f, -0.05178005f, 0.12472678f, 0.05452971f, -0.53758305f, 0.21437737f, 
    -0.70345527f, 0.43325654f, 0.14802587f, -0.01615107f, 0.14133795f, 0.08168763f, 0.03024396f, -0.30901238f, 
    0.00275354f, -0.06111791f, -0.10498574f, -0.16755475f, -0.02637487f, -0.04205730f, 0.00946658f, -0.20043732f, 
    1.03650296f, 0.04370314f, -0.17260551f, -0.46142820f, -0.13147040f, 0.13763882f, -0.03597295f, 0.09250274f, 
    -0.06565996f, -0.12282497f, -0.16399914f, -0.25614709f, 0.07495195f, -0.09157621f, -0.07950260f, -0.08002667f, 
    -0.03642489f, 0.10460792f, 0.05955313f, 0.09020323f, 0.81340706f, 0.61953044f, -0.11898618f, -0.07501067f, 
    -0.12083122f, 0.32337734f, 0.00950897f, -0.09198081f, -0.18493484f, -0.14080326f, -0.42943752f, -0.25798583f, 
    0.08222088f, -0.03216014f, 0.00119027f, 0.03603197f, 0.16106281f, -0.39122161f, -0.01695730f, 0.05683025f, 
    -0.17735481f, -0.08073942f, -0.33302423f, 0.00025409f, 0.40621385f, 0.14654903f, 0.20668690f, 0.21277767f, 
    0.16161665f, 0.13754749f, -0.01151467f, 0.05818735f, 0.05326538f, 0.16832216f, 0.05734032f, 0.08810290f, 
    -0.14068103f, 0.19897118f, 0.08841641f, 0.31826055f, -0.49233866f, 0.24105538f, 0.62355167f, -0.46223679f, 
    0.07424313f, 0.11115184f, -0.26728940f, -0.27791891f, -0.40070006f, -0.19324122f, -0.06241806f, -0.05784509f, 
    -0.08091373f, 0.04688009f, 0.10494015f, -0.12197386f, -0.04909736f, 0.32678887f, -0.30069396f, -0.07767397f, 
    -0.45666802f, 0.97359329f, -0.04411878f, 0.09842416f, 0.60456651f, 0.41002762f, 0.13045038f, 0.02106755f, 
    -0.37132525f, -0.08488173f, -0.25724271f, -0.01359348f, 0.00636419f, 0.02709328f, 0.15153378f, 0.09556905f, 
    -0.05866147f, -0.06418937f, 0.03424242f, 0.00132173f, 0.17831746f, -0.09567094f, 0.42590487f, -0.04823074f, 
    0.42395842f, -0.18322496f, 0.26705480f, 0.08172388f, -0.05756048f, -0.00806842f, 0.05755078f, 0.04015753f, 
    -0.05842067f, -0.14338095f, 0.08681438f, -0.01973465f, -0.08950669f, 0.06057839f, -0.05355331f, 0.02084688f, 
    -0.55407208f, 0.52346051f, -1.10525167f, 0.35651407f, 0.06199473f, 0.00267108f, -0.34281355f, -0.18095362f, 
    -0.08341679f, -0.05573764f, -0.01825869f, -0.00426417f, 0.26287434f, -0.19133350f, -0.29154539f, -0.09630813f, 
    0.01218571f, 0.01511289f, 0.06999785f, -0.19272517f, 0.03450298f, -0.14590394f, -0.30135861f, 0.08029608f, 
    0.30846518f, 0.07836079f, -0.08833209f, 0.08285365f, 0.09293255f, 0.13092354f, -0.20749089f, 0.04057351f, 
    -0.08934815f, -0.09488349f, -0.05487709f, -0.01845957f, -0.09743825f, 0.04322914f, -0.30295271f, -0.07256898f, 
    -0.87539923f, -0.40572354f, 0.25993413f, 0.22105135f, -0.31857860f, -0.06812970f, -0.19476169f, 0.06189224f, 
    -0.05173113f, -0.21037513f, -0.03651376f, 0.16461037f, -0.14137778f, -0.12344336f, 0.05299285f, 0.09572221f, 
    0.10097240f, -0.11818673f, 0.03073960f, -0.34972292f, -0.27459943f, -0.09357191f, -0.30710843f, -0.06491224f, 
    0.43841520f, 0.28251079f, 0.00916983f, 0.02303320f, -0.02578257f, -0.05085751f, -0.09582926f, 0.02819817f, 
    -0.05264607f, 0.11214539f, 0.13159893f, 0.20264459f, -0.07371868f, 0.26009193f, -0.03745010f, -0.14726689f, 
    0.23984003f, -0.01759916f, -0.35793260f, -0.10856602f, 0.34180269f, 0.28005111f, 0.07684301f, -0.02249001f, 
    0.22732808f, -0.04008751f, -0.04921703f, 0.17272627f, 0.21366464f, 0.06233129f, 0.09431046f, -0.23766907f, 
    0.27548173f, 0.17973891f, 0.07465363f, -0.04184389f, -0.04337338f, 0.01892307f, -0.46193385f, 0.13609865f, 
    0.15799481f, 0.05425419f, -0.23233441f, 0.16481900f, 0.04719071f, 0.09429028f, -0.02597476f, 0.02556246f, 
    -0.15754658f, -0.08818315f, -0.07545560f, -0.04257281f, -0.22150142f, 0.01472946f, -0.09357837f, -0.27431360f, 
    -0.10823527f, 0.02200340f, -0.13536195f, -0.22889335f, 0.29810426f, 0.02628251f, 0.07500675f, -0.06080391f, 
    -0.03760624f, -0.12056348f, -0.07361700f, 0.00507973f, -0.00720512f, -0.07950399f, 0.09408617f, -0.16079167f, 
    -0.17848961f, 0.16357368f, -0.00376510f, 0.03156662f, -0.08993185f, -0.81220061f, 0.93331885f, 0.03259772f, 
    0.07188801f, -0.13681774f, -0.06671956f, -0.13695155f, 0.17839636f, 0.01116859f, 0.14807294f, -0.01559714f, 
    0.11601289f, -0.02433870f, 0.23381864f, -0.07380087f, 0.05006866f, 0.06675092f, -0.01709769f, -0.13854460f, 
    -0.28183651f, -0.57890302f, -0.06418199f, -0.06254662f, -0.10908986f, -0.32816458f, -0.23547387f, -0.08321262f, 
    -0.14089046f, -0.06977081f, -0.13365898f, -0.28956708f, 0.18184927f, 0.04160046f, -0.07320100f, -0.05948142f, 
    -0.43458515f, -0.12933601f, -0.10056815f, -0.16036364f, -0.37886846f, 0.06240747f, -0.01741144f, -0.27656999f, 
    -0.27643871f, 0.15249802f, 0.04419987f, -0.09375794f, 0.11577453f, 0.11689401f, -0.02813643f, 0.12262415f, 
    0.13973047f, -0.05278062f, 0.02085831f, -0.19838735f, 0.07955077f, -0.02050632f, -0.26761678f, 0.03570088f, 
    0.49021888f, -0.32465124f, -0.35701707f, 0.11662772f, -0.21763821f, 0.32049373f, -0.09459457f, -0.07352774f, 
    0.35945773f, -0.03605736f, 0.12307895f, -0.10903475f, 0.06683405f, -0.01278474f, -0.00757408f, 0.01072656f, 
    0.02528404f, 0.01246013f, -0.17662130f, 0.05510367f, 0.12611222f, -0.37404343f, 0.01825087f, -0.22359627f, 
    -0.03151270f, -0.07233652f, -0.12160723f, 0.01568051f, 0.06527941f, 0.18970200f, 0.12650076f, -0.07016619f, 
    -0.04561041f, -0.19691178f, -0.01762170f, -0.09600937f, -0.09026191f, 0.01150712f, -0.10154730f, -0.02539217f, 
    0.26787606f, 0.19890261f, 0.35172617f, 0.01731768f, -0.10168070f, 0.08418823f, -0.13037406f, -0.21149310f, 
    -0.20196496f, 0.18077393f, 0.05406132f, 0.01458344f, 0.00361902f, 0.02592677f, 0.07136026f, 0.13209720f, 
    -0.00711959f, -0.07879359f, -0.09507491f, -0.16735134f, 0.09890013f, -0.01391904f, -0.24324895f, 0.01393795f, 
    -0.02813546f, 0.12747371f, 0.02345738f, 0.07589781f, -0.04829588f, 0.00757361f, -0.06284020f, 0.07028941f, 
    0.12993111f, -0.62731963f, -0.01681548f, 0.16937803f, -0.31212488f, 0.01873457f, -0.07430094f, -0.13141787f, 
    -0.20283696f, -0.59427804f, 0.47713220f, -0.08064593f, -0.02079845f, -0.36400697f, -0.03190852f, -0.21486251f, 
    -0.08703744f, -0.20176175f, 0.07423471f, -0.11091352f, -0.07228151f, 0.03472766f, -0.07469095f, 0.02376157f, 
    0.02914705f, 0.04556248f, -0.14255768f, -0.17896046f, -0.00597478f, 0.16995040f, -0.06532685f, 0.41719967f, 
    0.03080873f, 0.35030288f, 0.16182108f, 0.07420088f, 0.02132276f, 0.20771714f, -0.02219305f, -0.02014302f, 
    -0.00004528f, -0.00939500f, -0.01813486f, 0.05179614f, 0.13502818f, -0.20782900f, 0.10034614f, 0.22197574f, 
    -0.01798947f, -0.22000246f, 0.01755931f, -0.23747408f, -0.12840037f, 0.11333228f, -0.07237953f, 0.21357208f, 
    -0.05755406f, -0.00505367f, -0.10109282f, -0.21549278f, 0.03795714f, 0.04966537f, -0.06936672f, 0.00705044f, 
    -0.00421366f, -0.30977884f, -0.19924712f, 0.12189629f, 0.04442280f, 0.22828797f, 0.30324104f, 0.21161167f, 
    0.14204761f, -0.18056200f, 0.14709970f, 0.13077287f, 0.18634401f, 0.11827404f, 0.03143593f, 0.00914875f, 
    0.01347568f, 0.05235498f, 0.07854134f, -0.04417140f, -0.09088770f, -0.14050765f, 0.08596939f, 0.02404924f, 
    0.10801250f, -0.04785959f, -0.07427822f, -0.04543020f, 0.23766927f, 0.07963572f, 0.10246901f, 0.15551944f, 
    0.01306745f, 0.06927948f, 0.18781872f, 0.04099146f, 0.08570697f, -0.03104217f, 0.13385418f, 0.01458822f, 
    -0.09427243f, -0.23344402f, -0.11284179f, 0.02236778f, 0.26890376f, 0.13038680f, 0.19168653f, -0.02569795f, 
    0.10231526f, -0.00486743f, 0.02051379f, -0.04359008f, 0.08329036f, -0.00149292f, 0.18566577f, -0.11621905f, 
    -0.04518376f, -0.09854792f, 0.02772317f, 0.17450476f, -0.01616936f, -0.03956807f, -0.06829205f, -0.04413457f, 
    -0.19642456f, -0.42327225f, 0.11547166f, 0.24319364f, -0.00939994f, -0.21471387f, 0.09640416f, 0.03449330f, 
    -0.13843581f, -0.02154465f, 0.01374898f, 0.10994425f, -0.03673154f, -0.06646273f, -0.01969279f, -0.12477398f, 
    0.01326942f, -0.02101360f, 0.07067476f, 0.09380784f, 0.23315336f, 0.25738823f, 0.47942513f, 0.07796453f, 
    0.39729893f, -0.18331951f, 0.11315287f, 0.05127145f, 0.06525131f, 0.10588270f, -0.10188065f, -0.05286641f, 
    -0.07777803f, 0.02621148f, 0.05027524f, -0.07102673f, -0.03766944f, -0.14328380f, -0.13394077f, -0.34970808f, 
    -0.09600081f, -0.06666675f, -0.04687809f, 0.19432735f, -0.00603377f, -0.28532207f, 0.02532010f, -0.11206195f, 
    -0.34772694f, -0.16341831f, -0.05898087f, 0.02789331f, 0.03046837f, 0.12740521f, -0.05887491f, 0.12740621f, 
    0.06991461f, -0.09574989f, 0.01757525f, 0.16058728f, -0.09524424f, 0.64821738f, -0.69426537f, 0.00943762f, 
    0.36158884f, -0.05814997f, 0.06495901f, 0.00836325f, 0.16872379f, 0.08808547f, 0.14607441f, 0.07963262f, 
    0.01108527f, -0.03527623f, 0.04235834f, -0.05050232f, 0.17728789f, 0.11358340f, -0.01753572f, 0.11628058f, 
    0.25124913f, -0.57278979f, 0.04003638f, 0.30220795f, -0.44408289f, 0.21052718f, -0.11350898f, -0.04249393f, 
    0.03506621f, 0.21582566f, -0.08718076f, 0.00661595f, -0.02015146f, 0.10180106f, 0.31610638f, -0.06661409f, 
    0.01222900f, 0.03826387f, 0.07125090f, 0.16961098f, 0.05926516f, -0.01897741f, -0.35465577f, -0.19408847f, 
    0.11912802f, -0.17212525f, 0.02713122f, -0.12509699f, -0.21805321f, -0.01648542f, 0.20914389f, -0.05921567f, 
    -0.00015067f, 0.05940501f, 0.15416126f, -0.12819988f, -0.03648448f, 0.32197970f, 0.07535568f, 0.06915020f, 
    -0.88561714f, 1.04734313f, 0.12338484f, 0.48306125f, -0.02220138f, -0.23804751f, -0.21912935f, -0.06596388f, 
    0.11078174f, 0.07035874f, 0.00431677f, 0.12577280f, -0.09447673f, -0.13836411f, -0.13540195f, -0.04847910f, 
    -0.08895980f, 0.09784334f, -0.05933937f, -0.07732854f, -0.43845648f, 0.32960948f, -0.38246730f, 0.10404855f, 
    -0.09547959f, 0.14053148f, -0.10164817f, -0.06273575f, 0.12902433f, -0.02786380f, 0.11089840f, -0.03305523f, 
    0.00310301f, 0.15518016f, 0.07293471f, -0.07383753f, 0.12303348f, 0.25752258f, -0.10785344f, 0.03289586f, 
    0.10489309f, -0.05786669f, 0.18254659f, -0.31394273f, -0.30333978f, -0.02739724f, 0.10184406f, 0.13882831f, 
    -0.18411323f, 0.08054402f, 0.16521212f, -0.12980719f, -0.06078309f, -0.05774934f, -0.01917882f, -0.08880188f, 
    0.11173408f, -0.02684604f, 0.00043899f, 0.08679508f, 0.21070342f, -0.06336746f, -0.31048009f, 0.17161211f, 
    0.01325448f, -0.06648810f, 0.10106096f, 0.03689399f, 0.03165943f, -0.05613663f, -0.06690197f, -0.18889192f, 
    0.02418674f, 0.09451152f, -0.05806080f, 0.32589024f, 0.03525787f, 0.18828093f, 0.02190272f, 0.08003711f, 
    -0.47955796f, -0.25642145f, -0.62277704f, -0.56221956f, -0.18492448f, 0.15765347f, -0.04175567f, -0.09521949f, 
    -0.00157458f, 0.14891063f, 0.00340453f, 0.17891909f, -0.07217355f, -0.11907920f, -0.04060663f, -0.02715425f, 
    -0.18187411f, 0.13694775f, -0.07475648f, 0.13133289f, -0.05341039f, 0.06081716f, 0.41087824f, 0.30926067f, 
    -0.50365710f, -0.09203087f, -0.12194143f, 0.18893573f, 0.23135066f, 0.02052560f, -0.02186226f, 0.08665121f, 
    -0.10985579f, -0.01195682f, 0.03676498f, 0.00756203f, -0.02818627f, 0.11813684f, -0.34547132f, -0.23014389f, 
    0.00860124f, 0.23945336f, -0.17587708f, -0.55371982f, 0.32932100f, 0.06326441f, 0.12198365f, 0.02681251f, 
    -0.22466940f, -0.07177411f, 0.22419299f, -0.03515127f, -0.26120383f, 0.07644731f, 0.05192227f, -0.04033382f, 
    0.09802566f, 0.26428172f, 0.07432634f, -0.17103057f, 0.15408102f, -0.14839762f, 0.38068041f, -0.00192415f, 
    -0.30363616f, 0.36300829f, 0.15672241f, -0.04836907f, -0.17959972f, -0.19806099f, 0.12737538f, -0.00135814f, 
    0.11006106f, 0.06367950f, 0.09714052f, 0.08291639f, 0.11576504f, -0.09822575f, -0.17280899f, 0.09725450f, 
    -0.08959380f, -0.26758441f, -0.40692398f, 0.03220340f, 0.08280691f, 0.11811487f, -0.04929945f, 0.02186665f, 
    -0.00858007f, 0.01432180f, 0.07370830f, -0.02586376f, 0.00365474f, -0.17028420f, 0.03472828f, 0.16974616f, 
    0.04444512f, 0.27330077f, -0.14136957f, -0.06904246f, 0.03313182f, -0.11682673f, -0.06488612f, 0.09753542f, 
    -0.13505457f, 0.08764675f, -0.04379682f, 0.01725013f, 0.02420775f, 0.11425184f, -0.09270202f, -0.23181471f, 
    0.16261047f, -0.08614066f, -0.17919795f, -0.02439813f, 0.15046886f, 0.03700753f, 0.10124671f, 0.02442933f, 
    -0.54410374f, 0.28230652f, -0.21833377f, -0.24931899f, -0.14863007f, -0.05976509f, -0.12753540f, -0.16395746f, 
    -0.10619063f, 0.07249676f, -0.01177462f, -0.01512905f, -0.14374821f, 0.04854219f, -0.04095320f, -0.26146296f, 
    -0.29245511f, -0.02406550f, -0.12984221f, -0.05946581f, 0.24021107f, 0.02812625f, 0.39037722f, -0.00751941f, 
    0.01589652f, 0.12240987f, 0.05264708f, -0.17055768f, 0.04487797f, 0.07723902f, 0.06556269f, -0.01398416f, 
    0.00736528f, -0.00250911f, 0.00375580f, 0.02750416f, 0.06169721f, -0.13117787f, 0.08144904f, 0.41258293f, 
    -0.18806574f, 0.02214856f, 0.03023177f, 0.22125033f, -0.16264258f, 0.08765147f, 0.11878987f, 0.14749503f, 
    0.04471969f, -0.03579765f, 0.09008929f, -0.08309853f, 0.02467820f, 0.15003692f, -0.02501233f, -0.08904985f, 
    0.01049425f, 0.02084631f, 0.03785780f, -0.34576482f, 0.15021265f, -0.43879613f, -0.23734061f, 0.03500196f, 
    0.06723867f, 0.18297122f, 0.01107519f, -0.04392376f, 0.03645155f, 0.12579395f, 0.02398999f, -0.00444209f, 
    -0.02793107f, -0.03206480f, 0.00720719f, -0.16097941f, -0.32470292f, 0.05311960f, 0.08956868f, 0.09774521f, 
    -0.47315252f, 0.09311420f, -0.30425286f, 0.08336972f, 0.01462067f, -0.06179721f, -0.05901963f, -0.20752838f, 
    0.13394593f, 0.37419084f, -0.09413694f, 0.17741512f, 0.10542391f, 0.02969241f, 0.15459158f, 0.05697159f, 
    0.08516161f, -0.28180805f, 0.28574586f, -0.28944278f, -0.05306929f, -0.03634229f, 0.10610395f, -0.16721211f, 
    0.16606538f, -0.05465437f, -0.06963625f, -0.01921384f, -0.06294066f, -0.09182930f, 0.03568767f, -0.04915479f, 
    0.17575645f, -0.06466628f, -0.06036323f, 0.02192946f, -0.06791930f, 0.07133583f, -0.23726907f, 0.04021960f, 
    -0.41757390f, 0.13745211f, -0.33337483f, 0.00615577f, 0.50499487f, -0.12111178f, -0.01425388f, 0.00956547f, 
    0.31043541f, 0.32318619f, 0.11207320f, 0.00808758f, 0.21820012f, -0.04128907f, 0.15018177f, 0.15010272f, 
    0.17439158f, -0.13296095f, 0.29827595f, -0.03336269f, -0.24963172f, -0.06849026f, 0.19002931f, -0.05060926f, 
    0.13217238f, -0.08196899f, 0.04940978f, 0.09189477f, -0.09579898f, 0.29654503f, -0.04016748f, 0.10746554f, 
    0.13315262f, 0.07525130f, 0.00166382f, 0.00024328f, 0.05682387f, -0.12339916f, 0.10109073f, 0.04785952f, 
    -0.56821221f, 0.31297848f, 0.17569089f, -0.08293345f, -0.13891625f, -0.35929573f, -0.04526574f, -0.57489026f, 
    -0.14175163f, -0.27046192f, -0.06578623f, -0.08773949f, -0.06538332f, 0.01038931f, 0.10215127f, -0.04816453f, 
    -0.00950887f, 0.05082912f, -0.03466066f, -0.09205335f, 0.09253164f, 0.05669602f, 0.06423178f, -0.21329013f, 
    0.12534669f, 0.12670949f, 0.01057285f, 0.07176298f, 0.13632545f, -0.02473026f, -0.10556496f, -0.05219903f, 
    -0.00204193f, 0.03217982f, -0.10706902f, -0.08494869f, -0.10067102f, -0.06866633f, -0.05383244f, -0.02643417f, 
    -0.80948633f, 1.08220863f, 0.49149904f, 0.12477320f, 0.52097839f, -0.05000292f, -0.00106398f, -0.09274430f, 
    0.05911749f, 0.20855440f, 0.19203602f, 0.18078387f, 0.21176274f, 0.20714268f, 0.05820715f, 0.10598083f, 
    -0.04238887f, 0.03516582f, 0.00775185f, 0.00190545f, -0.93298244f, -0.88247526f, -1.30673206f, -0.23747481f, 
    0.40279296f, -0.13049378f, 0.22128241f, 0.07719561f, -0.12423988f, -0.43494412f, -0.04865442f, -0.09539048f, 
    -0.00508123f, 0.00122403f, 0.11483498f, 0.06048023f, 0.11053739f, 0.21500355f, 0.29465854f, 0.08196220f, 
    0.14015420f, 0.14155193f, -0.04074894f, 0.01428301f, -0.10630555f, 0.18887766f, 0.00070408f, 0.07502489f, 
    -0.01375544f, -0.20110402f, -0.06410649f, 0.05922864f, 0.15177929f, 0.00101612f, 0.14992994f, 0.12308438f, 
    0.12497584f, -0.10121822f, -0.21774946f, -0.06708051f, -1.05491948f, -0.68474096f, -0.45979136f, -0.65253836f, 
    0.33655018f, -0.20848548f, -0.03855392f, -0.14350024f, -0.20931545f, -0.42237407f, -0.01859620f, -0.10428918f, 
    -0.05715686f, -0.00694082f, 0.00210232f, -0.05434142f, -0.05507607f, 0.07608899f, 0.47061458f, 0.22062792f, 
    0.32262099f, -0.03613416f, -0.35711274f, -0.27689889f, 0.00313452f, -0.03629916f, -0.09458364f, 0.18852794f, 
    -0.01990749f, 0.08096983f, -0.09425297f, -0.02971865f, -0.13288605f, -0.18721868f, -0.07735292f, -0.20305553f, 
    -0.19071795f, -0.07987837f, -0.01930704f, 0.05085272f, -0.29800329f, 0.53489572f, 0.19283673f, -0.00085861f, 
    -0.01703643f, -0.23719032f, -0.03637975f, -0.22373962f, -0.03877561f, 0.06689846f, 0.08815263f, -0.07481836f, 
    0.14749260f, -0.01101649f, 0.07607810f, 0.07965595f, -0.04002021f, -0.07076281f, 0.04350761f, -0.09772947f, 
    -0.01807991f, -0.74439597f, -0.20832737f, -0.10146857f, 0.68504560f, -0.03184355f, -0.16623724f, -0.00232590f, 
    -0.12881245f, -0.02337304f, -0.07869005f, 0.06262664f, 0.11271267f, -0.07903992f, -0.25288069f, -0.01243659f, 
    0.10063256f, 0.01835435f, 0.16702513f, 0.01986088f, -0.97724003f, -0.53570038f, -0.65133023f, -0.03149012f, 
    -0.28359613f, -0.19267450f, 0.21219990f, -0.05065337f, -0.04034030f, -0.50196505f, 0.04206302f, 0.03273688f, 
    -0.12330797f, 0.00182601f, 0.01339790f, 0.02309366f, 0.00998000f, 0.22727975f, -0.02318936f, -0.03335920f, 
    -0.78396708f, -0.95133042f, -0.37708101f, -0.08423520f, -0.25220245f, -0.27401501f, -0.08876819f, 0.18944943f, 
    -0.27941146f, -0.10265116f, 0.00362211f, -0.03731691f, 0.01082034f, -0.05754444f, -0.06184177f, -0.00216944f, 
    -0.09505192f, -0.01708181f, 0.19108483f, -0.10414184f, -0.27798530f, -0.13195679f, -0.43507653f, -0.46108410f, 
    0.00181185f, -0.05571099f, 0.03381335f, 0.10489862f, 0.01385206f, 0.03377794f, -0.00788550f, -0.02735632f, 
    0.01240508f, -0.04721080f, -0.02510166f, 0.08952785f, 0.01425689f, -0.06531687f, -0.02118491f, 0.23725627f, 
    0.60784948f, 0.18766586f, -0.29118210f, 0.24226171f, -0.05653597f, 0.12379800f, 0.02641094f, 0.11919981f, 
    -0.24690761f, -0.19561934f, 0.01534971f, 0.04417741f, 0.09555296f, -0.13481224f, -0.07531417f, -0.26157534f, 
    -0.14647280f, 0.06778109f, -0.17258959f, -0.28058252f, 0.03884011f, 0.15359512f, -0.05255027f, 0.13122275f, 
    -0.13714582f, 0.05342184f, 0.04138579f, 0.12982635f, -0.05441793f, 0.00869740f, 0.04458505f, -0.11181312f, 
    0.00274370f, 0.02738241f, -0.02882721f, -0.02675265f, -0.07365784f, -0.03006683f, -0.06582924f, 0.03420283f, 
    0.76749808f, 0.37449938f, -0.10907950f, 0.57668614f, -0.70341039f, -0.19897708f, 0.20356393f, 0.01217770f, 
    -0.24689080f, -0.20127772f, -0.02827929f, -0.06172017f, -0.15735044f, -0.08253764f, -0.02456735f, -0.30785918f, 
    -0.00862095f, -0.00291672f, -0.11390997f, -0.07013528f, 0.44971627f, 0.57805562f, -0.39737603f, -0.01665071f, 
    -0.54626036f, 0.05092848f, -0.04397351f, -0.08010934f, -0.12019605f, -0.21390870f, -0.06251485f, -0.17013340f, 
    0.04574297f, -0.16397181f, -0.30178124f, 0.02054403f, -0.08835723f, -0.02197164f, -0.03593836f, -0.03477133f, 
    -0.11182863f, -0.56712264f, -0.17130138f, 0.04194755f, 0.11101509f, -0.01529079f, 0.05115095f, 0.11082716f, 
    0.06322865f, -0.04550344f, 0.00460116f, 0.06542616f, 0.09644305f, 0.06590755f, 0.09991477f, 0.03315781f, 
    0.02757581f, -0.04651760f, -0.03933746f, -0.10229373f, 0.00537267f, 0.20663962f, -0.01824880f, 0.08495768f, 
    -0.22140081f, -0.05547251f, -0.06722275f, 0.11107144f, -0.08718854f, -0.07157838f, 0.00256283f, -0.10437872f, 
    0.06869399f, -0.08050101f, -0.19638975f, -0.08429304f, -0.22521824f, 0.18972221f, -0.11193153f, 0.00883850f, 
    0.06268062f, -0.76280010f, -0.32050493f, -0.09942151f, -0.24880227f, -0.07297762f, -0.08463589f, 0.25187182f, 
    0.27667624f, -0.06599023f, -0.08070904f, 0.11981107f, 0.01713508f, 0.05916285f, 0.12532251f, -0.03277560f, 
    -0.00227067f, 0.03312015f, 0.14239520f, 0.12656699f, -0.54700315f, -0.29797965f, 0.04374808f, 0.65761638f, 
    -0.08784586f, -0.06565071f, 0.13507502f, -0.08678225f, 0.02001910f, 0.39610496f, 0.06064105f, 0.01083790f, 
    0.06099977f, 0.00891512f, -0.07209744f, 0.02343553f, 0.06050347f, -0.21284688f, 0.00986756f, -0.00453443f, 
    -0.14957364f, 0.09716284f, 0.23676403f, -0.14474364f, 0.18322398f, -0.02659297f, -0.06824797f, -0.02488633f, 
    -0.04392812f, 0.02077194f, 0.10980365f, -0.17554329f, 0.17557456f, 0.00454248f, -0.18145061f, 0.02827623f, 
    -0.01014814f, -0.07692254f, 0.06365449f, -0.00405340f, 0.06388441f, -0.71981031f, 0.52375400f, 0.61650115f, 
    0.06263727f, 0.15067546f, 0.14808320f, 0.02088211f, 0.10668655f, 0.28961843f, 0.01310527f, -0.01854873f, 
    0.00457281f, -0.06860331f, -0.10248694f, 0.05171123f, -0.09481397f, -0.03786682f, 0.31729221f, -0.16565622f, 
    -0.00122583f, 0.10110114f, 0.09029321f, 0.00613899f, -0.15218036f, 0.00397957f, 0.00870038f, 0.03245220f, 
    -0.01023278f, -0.05815933f, 0.05442797f, 0.06946459f, -0.00177955f, -0.05512289f, -0.04386643f, -0.08258536f, 
    -0.19247201f, -0.00911996f, 0.01275960f, 0.05348772f, 0.18400221f, -0.08013609f, -0.23639530f, -0.08443920f, 
    -0.03966512f, 0.03186021f, 0.01104762f, -0.02010868f, -0.15628242f, 0.00368831f, -0.10563984f, -0.10921306f, 
    0.17231703f, 0.01616433f, 0.04961343f, 0.02781037f, -0.02061607f, 0.04443563f, 0.01831464f, -0.08364139f, 
    0.83755213f, -1.15385532f, -0.83885771f, -1.10462070f, -0.39116439f, 0.22022253f, 0.05565673f, -0.27621409f, 
    0.39988363f, -0.00016575f, 0.12322234f, 0.01078380f, -0.03368322f, 0.19333777f, 0.12385502f, -0.15056035f, 
    -0.13591154f, -0.05149674f, -0.04686404f, 0.01001255f, -0.70046663f, -0.86134505f, 0.10453963f, 0.12148740f, 
    0.26012832f, -0.04147594f, 0.01016175f, 0.07174971f, 0.02079778f, -0.12817977f, -0.01999273f, -0.02471420f, 
    -0.04560227f, -0.12188070f, -0.03247120f, 0.09706695f, 0.00187387f, 0.00617732f, 0.08224761f, -0.01226756f, 
    0.77910656f, -1.07262743f, -0.81921244f, -0.42043659f, -0.11667896f, 0.00407319f, -0.16071567f, -0.08806194f, 
    0.29093993f, 0.03438437f, 0.03690799f, 0.03237779f, -0.05832671f, -0.13324733f, -0.00632776f, -0.06036211f, 
    -0.00563713f, -0.02150153f, 0.00727894f, -0.12842748f, -0.17725641f, 0.28452402f, -0.00083150f, -0.04146339f, 
    -0.33786172f, 0.10912978f, 0.06892719f, -0.02945420f, -0.09733122f, 0.02723350f, 0.11269197f, 0.01786873f, 
    0.07591004f, 0.00774680f, -0.01465251f, 0.13805807f, 0.04336671f, -0.24485944f, -0.14851731f, 0.03331497f, 
    0.56815970f, 0.14520842f, -0.33347303f, -0.22445080f, -0.03995755f, 0.24025407f, -0.07597578f, 0.04391062f, 
    0.05242477f, 0.02242685f, 0.10684304f, -0.03505356f, 0.21991655f, 0.15156794f, 0.03657674f, -0.06761132f, 
    0.01778798f, -0.13357477f, 0.17758711f, -0.05220677f, -0.57277232f, -0.14573331f, 0.23924363f, 0.04459415f, 
    0.04243012f, -0.15592557f, -0.00100259f, -0.19808264f, -0.05480973f, -0.05860870f, -0.16673064f, 0.10704900f, 
    0.03561498f, 0.14491524f, 0.06186977f, 0.12420074f, -0.00106875f, -0.01336116f, 0.05528366f, 0.04910315f, 
    1.04896951f, 0.15699942f, 0.06410155f, 0.05230972f, 0.30858725f, -0.00313973f, 0.35264987f, -0.05434378f, 
    0.14847164f, -0.13175409f, 0.05394383f, 0.07149830f, 0.11723571f, -0.00525835f, 0.19853087f, 0.18154261f, 
    -0.06680319f, -0.29499778f, -0.00548146f, -0.13783261f, 0.06095956f, -0.17832088f, -0.16573685f, -0.27028593f, 
    -0.23825674f, -0.13855723f, 0.13656393f, 0.06312176f, 0.07699952f, -0.08245318f, 0.18733840f, 0.08053130f, 
    0.15795697f, -0.07950156f, 0.06583924f, 0.00305351f, 0.06314199f, -0.04788357f, 0.10701086f, 0.00729470f, 
    -0.01526552f, -0.37727806f, -0.34999698f, -0.04698414f, 0.04136237f, -0.22543091f, -0.20757230f, -0.20433368f, 
    0.07870870f, 0.09992018f, -0.14374024f, -0.02534780f, -0.12417850f, -0.11248408f, 0.03335989f, -0.08118638f, 
    0.06232883f, 0.16362430f, 0.08880154f, 0.07830001f, -0.23202047f, -0.01031423f, 0.14614455f, 0.02266802f, 
    -0.25393915f, -0.07864044f, 0.04321468f, -0.05525863f, 0.13730110f, -0.00446704f, 0.02475611f, 0.10333872f, 
    0.03913547f, 0.13318741f, 0.13310200f, 0.03178101f, 0.34514821f, 0.06813623f, 0.24054655f, 0.07146297f, 
    -0.26884866f, -1.20138645f, -0.38699856f, 0.12042233f, 0.40567189f, -0.12411528f, 0.17538114f, 0.23949136f, 
    0.01158252f, 0.07568127f, 0.22807081f, -0.17641497f, -0.02173101f, 0.06520063f, -0.08928569f, -0.04359705f, 
    0.03941195f, -0.01156623f, 0.07498898f, -0.06314867f, 0.49524072f, 0.24074134f, 0.37774366f, -0.15986612f, 
    -0.18681523f, 0.25457600f, -0.49229270f, -0.17688131f, -0.27812764f, -0.53458273f, -0.05862400f, 0.06041178f, 
    0.07473008f, 0.02223878f, -0.05588553f, 0.08706256f, 0.14176488f, -0.12260602f, 0.01289071f, -0.42559761f, 
    -0.49148735f, -0.22842230f, 0.14874661f, 0.09567957f, 0.12451232f, -0.06177378f, 0.02367945f, 0.01505991f, 
    0.10954805f, -0.07145026f, -0.04573399f, 0.01386533f, 0.10053863f, -0.04980977f, 0.18357353f, -0.13733016f, 
    -0.02679871f, 0.01161040f, 0.06254293f, 0.08261696f, 0.09920636f, -0.52664798f, -0.64394301f, -0.29786375f, 
    -0.19901149f, 0.01863614f, -0.19530767f, -0.07784079f, 0.03877274f, -0.25660062f, -0.02684824f, 0.00895624f, 
    -0.06499036f, 0.00201073f, 0.04424845f, 0.07053959f, 0.00864604f, 0.10560422f, -0.03344106f, -0.08998473f, 
    -0.21717441f, 0.12973821f, 0.08956653f, 0.02771676f, -0.15028436f, -0.01421141f, 0.02573950f, -0.14842638f, 
    -0.09598344f, -0.04980442f, 0.03364222f, -0.05115323f, -0.02315625f, 0.05056259f, 0.03882204f, -0.00433701f, 
    0.20677787f, 0.18131480f, 0.14913902f, 0.14316107f, -0.28016943f, -0.42110556f, -0.36160108f, -0.00431741f, 
    -0.02005186f, -0.03730202f, 0.03347575f, 0.15667620f, 0.08943473f, 0.06359982f, 0.10767021f, 0.08350824f, 
    -0.10545037f, -0.08120099f, -0.05946692f, 0.00530518f, 0.09019294f, 0.04251744f, 0.18029466f, 0.08288679f, 
    0.04357647f, -0.12481172f, -1.25394046f, -0.14168306f, 0.27235287f, 0.03474648f, -0.24913847f, 0.15581077f, 
    0.09208435f, 0.04733225f, -0.02911673f, -0.05224705f, 0.00829612f, -0.13849401f, 0.01361154f, 0.12066931f, 
    -0.06100544f, -0.07935534f, -0.27601242f, -0.25642017f, 0.39017963f, -1.02104378f, -0.71785879f, -0.09837651f, 
    -0.11058001f, 0.25250605f, 0.22222620f, 0.00670120f, 0.12335432f, -0.04735228f, -0.01070708f, 0.05562124f, 
    0.02940122f, 0.00657317f, 0.09887439f, 0.09569248f, 0.12302705f, 0.10439428f, 0.09049244f, 0.14754212f, 
    -0.15590930f, -0.45060006f, -1.21352696f, -0.64975750f, -0.11649813f, -0.00362124f, 0.01091970f, 0.03017135f, 
    0.00316398f, -0.05170709f, 0.00082878f, -0.02665080f, -0.04642592f, 0.16818546f, 0.04550369f, 0.07921121f, 
    -0.00046642f, 0.05897306f, -0.08351548f, 0.09684111f, -0.75274312f, 0.27329859f, 0.44452500f, 0.34538066f, 
    -0.04539187f, 0.06148105f, -0.17577162f, -0.07693628f, -0.08128355f, -0.16352271f, -0.09458554f, -0.05826527f, 
    0.00043727f, -0.07036413f, -0.18792248f, -0.20800652f, -0.33605257f, -0.08154659f, -0.29852241f, -0.07658663f, 
    -0.37659216f, 0.05696894f, -0.34026361f, 0.26002270f, -0.35723212f, -0.06029254f, 0.13542055f, 0.01710757f, 
    -0.24998033f, -0.33345616f, -0.02482166f, -0.00930732f, -0.07668408f, -0.08205503f, -0.08330449f, -0.16452996f, 
    0.01189151f, -0.21893731f, 0.09683467f, 0.16728796f, -0.15493625f, 0.01083957f, -0.04971397f, 0.04590831f, 
    0.05715394f, -0.00613083f, -0.19052415f, 0.12717873f, 0.00932829f, 0.00360922f, -0.02064009f, 0.28939095f, 
    -0.12835246f, 0.02620070f, -0.16301361f, 0.16385384f, 0.14266104f, 0.13479640f, -0.02133373f, 0.06069255f, 
    -1.42918551f, -0.22013484f, -0.95524204f, 0.30394462f, -0.46122524f, 0.15984973f, -0.20057461f, 0.01642997f, 
    -0.47759447f, -0.02688814f, 0.05796336f, -0.01190636f, -0.00964503f, 0.12052669f, -0.04209979f, -0.10785934f, 
    -0.00349333f, 0.01708079f, 0.08632350f, 0.10733964f, -0.47191048f, 0.43873119f, 0.08349175f, 0.58332092f, 
    0.18027455f, -0.01080864f, -0.14734101f, -0.37509176f, -0.07630140f, -0.23232830f, 0.13171247f, 0.01108482f, 
    0.00480211f, -0.16196774f, -0.04589469f, 0.08231782f, -0.08493122f, -0.05497217f, 0.00653488f, -0.02411213f, 
    -0.01337246f, -0.04997104f, 0.49118847f, -0.03150121f, -0.17523172f, -0.05393443f, -0.05229177f, 0.08528826f, 
    -0.01540499f, 0.16362455f, -0.02001710f, -0.03750366f, 0.09040686f, -0.02796288f, -0.08707242f, 0.06392949f, 
    -0.09687455f, -0.10028217f, -0.11520856f, -0.12319934f, -0.38574046f, 0.32534331f, 0.04184138f, -0.28420326f, 
    -0.02189030f, 0.00579498f, -0.03164435f, -0.03148180f, -0.04266899f, -0.02967799f, 0.23091908f, 0.05464416f, 
    -0.06327771f, 0.12016206f, -0.03773201f, 0.16746122f, 0.04512059f, -0.12334774f, -0.04908258f, -0.06837562f, 
    0.14086030f, -0.21032681f, 0.37467974f, 0.20566511f, -0.64228439f, -0.13246112f, -0.24362317f, -0.45540145f, 
    0.02054994f, -0.33231357f, -0.06860621f, 0.04014249f, -0.00148942f, 0.26930422f, -0.04800621f, 0.07148523f, 
    0.05503492f, -0.03033845f, -0.05830052f, 0.09647119f, 0.42342106f, 0.02964221f, -1.32125306f, 0.22008699f, 
    -0.11732531f, -0.06891547f, 0.09988038f, 0.24089403f, -0.09168156f, 0.27134624f, 0.01429558f, 0.02199153f, 
    -0.02933799f, 0.03453042f, -0.05404906f, 0.02206116f, 0.02342380f, -0.01083940f, 0.08967473f, 0.10227033f, 
    0.32577428f, -0.23116493f, 0.29464513f, -0.45298755f, 0.11303884f, -0.14955077f, 0.00381053f, 0.07832117f, 
    0.06399640f, 0.18356885f, -0.07366601f, 0.13984029f, 0.08765046f, -0.12506394f, 0.01138510f, 0.15931728f, 
    0.21367130f, -0.04296762f, -0.16712390f, 0.18617131f, -0.23626570f, -0.38986570f, -0.00904140f, 0.20780957f, 
    -0.36935514f, -0.20212515f, -0.31316614f, 0.30331331f, -0.06480436f, 0.27925557f, 0.02418083f, 0.04168010f, 
    0.03578293f, -0.05988144f, -0.07818273f, 0.06936667f, 0.00540944f, 0.14928374f, 0.16705999f, -0.06876744f, 
    -0.12446208f, 0.08582678f, -0.17362599f, -0.05509680f, 0.15188338f, 0.15853329f, 0.30985931f, 0.35667828f, 
    0.08204313f, -0.12713432f, 0.19576921f, -0.10836581f, 0.03221150f, -0.10668407f, -0.22901581f, 0.21515936f, 
    0.01029158f, -0.26199326f, 0.00638960f, -0.13516487f, 0.00057362f, 0.13934173f, 0.58130687f, 0.21367049f, 
    -0.36900765f, 0.14417233f, -0.25649181f, -0.33148605f, -0.37052041f, -0.13851494f, -0.12436966f, 0.14258619f, 
    0.06176601f, 0.13920602f, -0.02251755f, -0.02541897f, -0.24662827f, -0.24750566f, 0.03280450f, -0.01572414f, 
    0.18984176f, 0.15853447f, -0.19177739f, 0.65789294f, -0.83762497f, 0.11000212f, -0.08195212f, -0.24552585f, 
    0.05798592f, -0.05252869f, 0.13918914f, -0.10446053f, -0.00457695f, -0.04769344f, 0.11320534f, 0.14681923f, 
    0.19346508f, 0.09826407f, 0.06963672f, 0.17488116f, -0.38387665f, 0.04962894f, 0.05518140f, -0.01908918f, 
    -0.21486393f, -0.31798357f, -0.16386826f, 0.11100900f, -0.02286153f, 0.10623842f, -0.10118292f, 0.04162001f, 
    0.03512699f, -0.05693989f, -0.01103597f, -0.07207607f, -0.00583491f, 0.06801039f, -0.15089668f, -0.18476784f, 
    -0.32537812f, 0.00126416f, 0.52333820f, 0.54349512f, -1.19123304f, 0.27997544f, -0.41921103f, -0.09871361f, 
    0.21184969f, 0.19382536f, 0.06400519f, 0.03443189f, 0.09190669f, 0.08913463f, -0.02290678f, 0.00162847f, 
    0.03033412f, 0.11709198f, -0.01014996f, 0.02703942f, -0.30624402f, -0.21366717f, -1.10982525f, 0.24705634f, 
    0.03863812f, 0.05221185f, -0.01728236f, 0.32976598f, 0.03031570f, -0.01821654f, -0.00056128f, -0.02219564f, 
    -0.05377812f, 0.06784936f, 0.00851149f, 0.01743069f, 0.22324288f, -0.07603126f, -0.01454952f, 0.11651880f, 
    -0.17307714f, 0.08810409f, 0.59446865f, -0.08464266f, 0.08385646f, -0.19308949f, -0.19140738f, 0.26548830f, 
    0.36581108f, -0.03691152f, -0.10078843f, -0.11711645f, 0.02131548f, 0.17672069f, 0.14323974f, 0.24618325f, 
    -0.08887403f, 0.27363306f, 0.19125934f, -0.00757202f, -0.04435841f, -0.20211312f, 0.17172579f, -0.06407814f, 
    -0.29380187f, -0.06276201f, -0.00686172f, 0.17218691f, -0.20563188f, -0.06316713f, 0.11144590f, 0.03467681f, 
    -0.13883972f, 0.09212039f, -0.06781789f, 0.06455684f, -0.00599067f, 0.08504610f, -0.05997648f, -0.23009920f, 
    0.48388478f, -0.45608014f, 0.38193083f, -0.18717594f, 0.15190893f, -0.22976582f, 0.26624969f, 0.48234558f, 
    0.26675978f, 0.16878234f, -0.06771810f, -0.09226476f, -0.21714093f, 0.12994416f, 0.10861531f, -0.01480034f, 
    0.06720931f, 0.09468621f, -0.04159054f, -0.27983510f, 0.76860774f, -0.25612894f, 0.55871958f, -0.36929232f, 
    -0.20518695f, 0.02437401f, -0.15531473f, -0.12671794f, 0.00683468f, -0.11607375f, -0.12506874f, 0.26704624f, 
    -0.10103283f, -0.00285347f, -0.07377919f, -0.06265146f, -0.03958596f, 0.04976907f, 0.00646410f, -0.14702055f, 
    -0.42679542f, 0.02671386f, -0.51060182f, 0.02347786f, 0.17328644f, -0.02067103f, 0.11729603f, 0.11459287f, 
    0.00779050f, -0.07192129f, -0.10292299f, -0.16890962f, -0.07014173f, -0.05469655f, -0.00187252f, 0.09748041f, 
    0.18698983f, -0.22419707f, 0.15058629f, 0.31488767f, -0.21099004f, -0.25904810f, 0.37285668f, -0.14971569f, 
    -0.10284983f, 0.05929665f, 0.16467336f, 0.25469053f, 0.07188648f, 0.09699626f, -0.03666022f, -0.20753352f, 
    -0.02761203f, -0.02706701f, -0.02909661f, -0.18198238f, 0.16108112f, 0.34539792f, 0.27089116f, 0.05448414f, 
    -0.48371866f, 0.59227639f, -0.19352534f, -0.05731919f, 0.02792283f, 0.14458176f, -0.21522909f, 0.02948349f, 
    0.17056866f, 0.09174006f, -0.14705953f, 0.10077091f, 0.05248773f, -0.02777349f, -0.18290678f, -0.10801335f, 
    -0.00833437f, -0.12976310f, -0.03191262f, -0.13306360f, -0.23730104f, -0.27467746f, -0.44029120f, -0.16412032f, 
    0.05762486f, -0.00275024f, -0.08852065f, 0.15001298f, -0.32962960f, -0.09646530f, -0.05770807f, 0.06130883f, 
    -0.00690657f, -0.00768740f, -0.10366873f, 0.28676969f, -0.24143122f, -0.12297400f, -0.15720807f, -0.16754594f, 
    0.22983056f, -0.10976687f, 0.39977303f, 0.54712552f, 0.06206447f, -0.13265164f, -0.12740728f, 0.12572928f, 
    -0.15904644f, 0.06377468f, -0.10826460f, 0.04819034f, -0.12872098f, 0.15220740f, 0.11515854f, 0.01875589f, 
    -0.00693252f, 0.34524506f, -0.03212779f, 0.14332502f, -0.53326708f, -0.01623179f, -0.05538386f, -0.12483346f, 
    0.11898585f, -0.13984379f, -0.14614633f, -0.38575152f, -0.01318316f, 0.04762782f, -0.00951425f, 0.22000062f, 
    0.09515820f, 0.12029167f, 0.01229112f, 0.13551502f, -0.09012590f, -0.33993182f, 0.08071423f, -0.21102288f, 
    -0.45975727f, -0.74742585f, -0.25476694f, -0.15279797f, -0.39709359f, -0.22267897f, -0.14145797f, -0.08414350f, 
    0.21113868f, -0.04842534f, -0.38613677f, -0.02249768f, 0.10389859f, -0.21813522f, 0.01554111f, 0.14691940f, 
    0.02001685f, 0.24660257f, 0.29261550f, 0.13140315f, -0.18881349f, -0.25735819f, 0.21162552f, 0.15028509f, 
    -0.09946900f, -0.04547366f, 0.05873605f, -0.23566006f, 0.08408909f, 0.05735572f, 0.16383043f, -0.03705000f, 
    -0.07204982f, -0.08429145f, -0.01213986f, 0.18001148f, 0.08388001f, 0.09057154f, 0.30412325f, 0.25208184f, 
    -0.23399392f, -0.12532742f, 0.15997498f, 0.42165709f, 0.14099698f, -0.05865100f, 0.10658142f, 0.01442272f, 
    -0.01576432f, 0.04522695f, -0.17275713f, 0.21506637f, -0.14452122f, -0.23375887f, -0.29903656f, 0.05434214f, 
    -0.20523797f, 0.11629406f, -0.12745290f, -0.14128904f, -0.62998253f, 0.00561000f, 0.14748845f, 0.14729634f, 
    0.26963937f, -0.04444774f, 0.06071454f, -0.26806918f, 0.08242290f, -0.17417076f, 0.06359088f, 0.06850775f, 
    0.05058539f, 0.15071212f, 0.07429551f, 0.05521433f, 0.08510364f, -0.29112440f, 0.11815550f, 0.09546118f, 
    -0.59467655f, 0.09784915f, -0.53749299f, 0.07737268f, 0.13341294f, -0.15738739f, -0.06838638f, -0.19891906f, 
    0.10163727f, 0.05712930f, -0.05131487f, 0.10322774f, 0.06908491f, -0.02332799f, -0.08529838f, -0.01977051f, 
    -0.15747456f, -0.05985833f, 0.02513207f, -0.12731272f, -0.11081215f, -0.41317886f, -0.08359173f, 0.05825258f, 
    0.24861620f, -0.21840326f, -0.05336211f, -0.23249587f, -0.06374484f, -0.28287068f, -0.27470732f, 0.12064254f, 
    -0.08610541f, -0.04393924f, -0.04579099f, 0.11816086f, -0.34854737f, -0.14553690f, -0.09904879f, -0.00478490f, 
    0.22968119f, -0.11641791f, 0.77828109f, -0.10034005f, 0.44915241f, 0.31585017f, 0.34098306f, 0.12213606f, 
    0.05714829f, -0.13376555f, 0.05334394f, -0.02718785f, 0.11534677f, 0.03739174f, -0.02349115f, 0.14329608f, 
    0.17934568f, 0.07720181f, -0.27261135f, 0.05569503f, -0.02692050f, -0.14211909f, -0.11259589f, -0.10085487f, 
    0.06822305f, -0.00365661f, 0.20051776f, -0.14038855f, 0.11910898f, -0.08870500f, -0.26392341f, 0.08788231f, 
    0.02328306f, -0.16273044f, 0.11128531f, 0.16487767f, -0.08358213f, -0.04124082f, -0.02586730f, -0.13737518f, 
    -0.02393896f, -0.59422261f, 0.32175002f, -0.82987362f, 0.56359553f, 0.16093956f, 0.18718073f, -0.27340099f, 
    0.47949666f, 0.13776843f, -0.14446357f, 0.10700996f, 0.00175756f, 0.14629094f, -0.02240857f, 0.12021856f, 
    0.15708096f, 0.07122007f, 0.21370381f, 0.06840432f, -0.37003681f, -0.21449327f, -0.15599085f, -0.31422317f, 
    0.32615778f, 0.08370423f, 0.26738423f, 0.00211390f, -0.18952239f, 0.17527676f, 0.05492631f, 0.05208734f, 
    0.07192768f, -0.00518201f, 0.03421438f, -0.13848963f, 0.00655525f, 0.06435426f, -0.11212985f, 0.13873753f, 
    0.01703965f, -0.52800900f, -0.22732484f, 0.36118293f, -0.04241470f, -0.25578445f, -0.37149018f, 0.13566887f, 
    0.03488086f, -0.01822196f, 0.04212594f, -0.00794605f, -0.16665977f, -0.07907856f, -0.06619277f, 0.02339734f, 
    -0.20924324f, -0.02636638f, -0.20838864f, -0.51339555f, 0.17908983f, -0.12086597f, 0.02741823f, 0.18636210f, 
    0.35996515f, -0.03397858f, 0.23974796f, -0.23228441f, 0.10758778f, 0.10138166f, 0.01845401f, 0.19048665f, 
    -0.03321353f, 0.08785920f, 0.09815080f, -0.26035261f, -0.23775707f, 0.02892173f, -0.17884213f, -0.17850539f, 
    -1.25212955f, 0.09851247f, -0.58603662f, 0.43764052f, -0.57852519f, -0.02847356f, 0.20445664f, -0.27959639f, 
    0.40666682f, 0.07459079f, -0.28762823f, -0.11129097f, -0.01315714f, 0.06171300f, 0.08761539f, 0.06344873f, 
    -0.00252307f, -0.01124420f, -0.21583371f, 0.18974169f, 0.41850227f, -0.18368244f, 0.58669001f, -0.02092517f, 
    0.19580629f, -0.13749325f, -0.43034425f, 0.16180830f, -0.37490466f, -0.19627452f, 0.08073705f, 0.01687264f, 
    0.01215724f, -0.00652735f, 0.00490270f, 0.03605193f, -0.08621012f, -0.05856785f, 0.03625250f, 0.04947439f, 
    -0.50870156f, -0.08775760f, -0.33495146f, 0.55529684f, -0.07371773f, -0.10846932f, 0.26467484f, 0.00841118f, 
    0.23133518f, 0.15060312f, -0.24345751f, -0.04484651f, 0.09103941f, 0.21951030f, 0.04675742f, 0.03945215f, 
    -0.04511441f, -0.02737108f, -0.10619691f, 0.00729155f, -0.12731630f, -0.70376807f, -0.43077669f, -0.25433657f, 
    0.10810268f, 0.03033771f, -0.37588459f, -0.10429201f, -0.11589342f, -0.18733925f, -0.08364100f, -0.00500307f, 
    0.06748337f, 0.01545808f, -0.08516262f, 0.08027094f, -0.11178982f, 0.01997459f, 0.00228721f, 0.02637729f, 
    0.49239749f, 0.32280526f, 0.46595091f, 0.14256340f, -0.26095608f, -0.07397517f, 0.28792739f, -0.04966073f, 
    0.21229140f, -0.17974159f, -0.25799274f, -0.04850207f, 0.13224274f, -0.04686243f, -0.16687252f, 0.10445186f, 
    0.05388634f, -0.07931388f, -0.16291831f, 0.08302869f, -0.14685439f, -0.31394023f, 0.12247905f, -0.05567497f, 
    -0.06845556f, 0.05899883f, -0.07179679f, -0.02927581f, 0.11885317f, -0.14190277f, 0.02715876f, 0.12049170f, 
    0.03801468f, -0.09670711f, 0.06775453f, -0.01110144f, -0.18316664f, 0.08970577f, -0.15154234f, -0.17484133f, 
    -0.06733412f, -0.59969699f, 0.66152090f, -0.44370702f, -0.35458618f, 0.16627206f, 0.03445308f, -0.03268415f, 
    -0.31618410f, -0.00111470f, -0.04326552f, -0.09469581f, 0.32758018f, 0.32034785f, 0.05014824f, -0.16154502f, 
    0.12729093f, 0.02818092f, 0.24738562f, 0.09113424f, -0.10404447f, -0.31722140f, 0.04558817f, -0.07626525f, 
    -0.13653305f, -0.04398787f, -0.58660662f, -0.21646340f, -0.06828598f, -0.18939091f, -0.02133763f, 0.00040129f, 
    -0.05130569f, -0.02369754f, -0.03614002f, 0.09572941f, -0.03769162f, -0.02820398f, 0.22071683f, 0.02752413f, 
    0.07609605f, -0.35707843f, -0.23261099f, 0.09094674f, -0.18114068f, -0.31837934f, -0.12712909f, -0.06662980f, 
    -0.06313958f, -0.03820516f, -0.00179483f, 0.08496238f, 0.29839632f, -0.03863367f, -0.09472909f, 0.12021358f, 
    0.02426959f, -0.00566973f, 0.01483533f, 0.12957557f, 0.75500840f, -0.38709271f, 0.64122349f, -0.27546886f, 
    -0.19391498f, 0.04199357f, -0.04560182f, -0.20108043f, 0.03869604f, -0.17183010f, -0.15170072f, -0.02741540f, 
    -0.01915878f, -0.18647303f, -0.10568648f, 0.06824205f, 0.17570189f, -0.01180522f, 0.14504585f, -0.01617670f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21969563f, 0.19996725f, 0.03906190f, -0.18845983f, -0.06921592f, 0.01348529f, 0.06467308f, -0.13400082f, 
    0.11296932f, 0.02258313f, 0.00567304f, -0.12864630f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
