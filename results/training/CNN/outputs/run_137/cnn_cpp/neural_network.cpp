#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.00433385f, 0.53625250f, -0.31450728f, -0.59380430f, 0.07625677f, 0.05255318f, 0.39997587f, 0.49831802f, 
    0.49833867f, 0.47468692f, -0.19007951f, -0.23788282f, 0.10637698f, -0.24583402f, -0.08252774f, 0.15788089f, 
    0.04222893f, -0.09889361f, 0.05320263f, -0.15628111f, -0.21875432f, -0.14383617f, 0.13752170f, 0.08383231f, 
    0.02407023f, 0.78789014f, 0.70921153f, 0.56935465f, 0.27071714f, -0.45315543f, -0.84009188f, 0.36687732f, 
    -0.57408065f, -0.28946638f, 0.27225184f, 0.05481783f, 0.32430324f, -0.00024207f, 0.24853432f, -0.01130952f, 
    -0.14164643f, -0.07933187f, 0.08050056f, 0.16359356f, 0.05862658f, -0.13664176f, 0.13102700f, -0.08166078f, 
    0.05967818f, 0.06219664f, 0.12479439f, -0.12863052f, 0.79355282f, -0.50794721f, -0.62041771f, 0.41579497f, 
    -0.41533369f, 0.52437645f, 0.05449388f, -0.11942896f, 0.21215276f, 0.27020556f, -0.36099371f, -0.10394445f, 
    -0.14569734f, 0.14107274f, 0.05073233f, -0.24707898f, -0.30106801f, -0.26021719f, 0.14966807f, 0.16712697f, 
    0.08041968f, 0.06626157f, -0.13049333f, 0.99307710f, 0.60281396f, 0.48379698f, 0.83481544f, 0.83453876f, 
    0.16796556f, -0.01761575f, -0.19589594f, 0.24075714f, -0.19616705f, -0.07606443f, 0.22103979f, -0.10930710f, 
    -0.06616940f, -0.09603858f, 0.05660938f, 0.03227451f, 0.16395859f, -0.14206818f, -0.10322057f, 0.25184417f, 
    0.17935018f, 0.00296033f, -0.06968030f, 0.28458312f, -0.37301087f, 0.47022912f, 0.77669615f, 1.06659377f, 
    -0.43554121f, -0.01229830f, -0.18340679f, -0.07457098f, 0.27918780f, -0.01786908f, 0.08414585f, -0.01139638f, 
    0.04023954f, -0.06781361f, 0.04836239f, -0.08918902f, 0.09259116f, -0.00996294f, 0.01724573f, -0.01957757f, 
    -0.15562539f, 0.00062980f, -0.00538020f, 0.01792864f, -0.14451469f, -0.57048994f, -0.94231057f, -0.43294853f, 
    0.49602407f, 0.12153907f, -0.46951672f, 0.44335246f, 0.08058701f, -0.23911190f, -0.40290126f, 0.08820871f, 
    0.33201224f, -0.07048702f, 0.39599299f, 0.24051116f, 0.15638562f, -0.14737506f, -0.22006316f, -0.04281145f, 
    -0.03924856f, 0.15759768f, -0.05483960f, -0.06041453f, 0.13817896f, -0.02041114f, -0.41902849f, 0.00817357f, 
    -0.55344057f, -0.85626560f, -0.01662393f, -0.25403634f, -0.03178680f, 0.22310434f, -0.28600475f, -0.39208561f, 
    0.24087879f, 0.02945730f, 0.32924545f, 0.13000961f, 0.05418245f, 0.33772713f, 0.09809024f, 0.16493876f, 
    0.35978037f, 0.20035809f, -0.03516433f, -0.10801008f, 0.02446976f, -0.26564452f, 0.17872106f, 0.31657878f, 
    -0.40714809f, -0.68858016f, -0.69168729f, -0.35251144f, -0.07073662f, 0.37132969f, 0.58255017f, 0.34416148f, 
    0.03585958f, 0.27191889f, -0.19838257f, -0.06963364f, -0.05390181f, -0.04122081f, 0.17609964f, -0.01614892f, 
    -0.31610888f, 0.09294478f, -0.02838747f, 0.20239091f, 0.16646378f, -0.05430907f, 0.18512653f, 0.13187067f, 
    -0.15571849f, 0.08236220f, -0.60996866f, -0.64937878f, -0.73230940f, 0.76155573f, 0.27456212f, -0.21454056f, 
    0.11863667f, 0.09894533f, 0.02521072f, 0.08845089f, -0.01786885f, -0.05251082f, 0.22567803f, 0.13324620f, 
    -0.13834031f, 0.05322270f, 0.24765100f, -0.11184695f, -0.04860438f, -0.28014237f, 0.01177180f, -0.03864541f, 
    0.26431409f, -0.07801661f, -0.13563184f, 0.20660320f, 0.50216198f, 0.52606827f, 0.45250607f, -0.17324728f, 
    -0.06687690f, -0.13863440f, 0.04734285f, 0.48633805f, 0.39238092f, 0.16658068f, 0.00558742f, 0.22089744f, 
    0.43513894f, 0.26728335f, 0.19021314f, 0.27961424f, 0.47064501f, -0.24641311f, 0.07805794f, 0.25944740f, 
    0.03387795f, -0.03992640f, 0.50196457f, 0.12231220f, -0.14535947f, -0.48328310f, 0.77435577f, -0.24077345f, 
    -0.94528008f, -0.50835121f, -0.38826257f, 0.25224221f, 0.02641784f, 0.15883873f, -0.00448898f, 0.03802220f, 
    -0.11257914f, -0.05359509f, 0.21740304f, -0.14673512f, 0.08839314f, 0.47150242f, 0.08660840f, 0.09109831f, 
    -0.08569487f, -0.36746091f, -0.19048356f, -0.68294996f, -0.49913290f, -0.29250848f, 0.27977952f, -0.38123453f, 
    -0.25043258f, -0.57582855f, 0.01857340f, 0.02562306f, 0.13548762f, -0.10799912f, 0.17549281f, -0.39577490f, 
    0.24281824f, -0.38934964f, -0.35607859f, 0.05872678f, -0.33045995f, 0.05859719f, -0.30977339f, 0.17459440f, 
    -0.11099788f, 0.16646454f, -0.33891672f, 0.00877460f, -0.28297299f, 0.26359835f, -0.16924444f, -0.41698763f, 
    -0.25970423f, -0.73216623f, -0.71188706f, -0.60600877f, -0.62695289f, -0.38012093f, 0.17144519f, 0.23977087f, 
    0.21514598f, -0.18268663f, 0.12985291f, -0.21630132f, 0.02200649f, -0.26601979f, 0.02952963f, -0.28544083f, 
    0.24857372f, 0.10122995f, 0.16415682f, 0.24549131f, 0.09651190f, -0.83079171f, 0.65866643f, 0.85423881f, 
    -0.32701579f, -0.20910497f, -0.35407430f, 0.54527336f, 0.06017332f, -0.26982239f, -0.33295858f, -0.27469677f, 
    0.27688137f, -0.39194882f, 0.15528941f, -0.26002237f, -0.09610300f, -0.12625335f, 0.12721424f, -0.13809527f, 
    0.01659177f, 0.01225927f, 0.02050406f, -0.06715072f, 0.02757987f, -0.03755020f, 0.47010338f, -0.18187159f, 
    -0.60516661f, -0.10810690f, -0.07519195f, 0.55551165f, 0.13174972f, 0.66592371f, 0.50166720f, 0.47426313f, 
    0.14698043f, -0.13637741f, 0.06699423f, -0.14890510f, 0.09419861f, -0.33758113f, 0.02514008f, 0.20808539f, 
    0.25837049f, 0.00458820f, -0.14450008f, -0.20415284f, 0.06086657f, -0.41009521f, -0.38054034f, -0.46968004f, 
    -0.91835266f, -0.41465196f, -0.27432227f, -0.04042599f, -0.44822934f, 0.68673038f, 0.39029059f, -0.18209033f, 
    0.19402979f, -0.12313169f, -0.10529602f, -0.21171364f, -0.33933303f, -0.24936020f, -0.14754887f, 0.06651492f, 
    0.04085343f, -0.04577758f, -0.15492380f, -0.03235101f, -0.01936390f, 0.18663055f, -0.05899775f, -0.05068647f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00803124f, 0.10206982f, 0.11645522f, 0.12345835f, 0.10361461f, 0.12872891f, 0.29958692f, 0.01340861f, 
    0.19349073f, 0.18134142f, 0.18101671f, 0.25464791f, 0.18201907f, -0.04948418f, 0.15430103f, 0.17043135f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09642847f, 0.06315459f, 0.00071645f, 0.13052867f, 0.02087150f, 0.09293563f, 0.06128727f, 0.08175649f, 
    0.11370715f, 0.10586802f, 0.04390464f, 0.14808679f, 0.45878041f, -0.07598311f, 0.00087224f, -0.04674972f, 
    0.06938607f, -0.07842217f, -0.05795610f, -0.03599252f, 0.08298466f, -0.05929038f, -0.06873029f, -0.04351025f, 
    -0.29056180f, 0.18836381f, -0.12575869f, -0.10550521f, -0.02213294f, -0.00971679f, -0.11897302f, 0.00104899f, 
    -0.00655769f, -0.05971147f, 0.09957951f, -0.08965296f, 0.37325883f, 0.10276973f, 0.19987956f, 0.18227315f, 
    0.03315421f, -0.03077408f, 0.11326517f, 0.06722533f, 0.04197732f, 0.03651216f, -0.05488814f, -0.13339794f, 
    0.17097247f, -0.19726491f, -0.08735696f, -0.13384296f, -0.03994811f, -0.03487998f, -0.01262043f, -0.12803793f, 
    0.05201682f, -0.06490730f, -0.03384256f, 0.03720949f, 0.19130383f, -0.04010914f, 0.10786246f, 0.03847362f, 
    -0.07277934f, 0.16741824f, 0.01447849f, 0.06211375f, 0.03805794f, -0.04074548f, -0.03746467f, 0.03311426f, 
    0.25067911f, 0.25425547f, 0.01113551f, 0.05676743f, -0.00327739f, 0.09665339f, -0.03444594f, -0.04165005f, 
    -0.04645278f, -0.07523549f, 0.01737444f, -0.11661880f, 0.06313758f, 0.03202469f, 0.07469473f, 0.00950191f, 
    0.00331072f, -0.00003501f, -0.06952570f, 0.03082153f, 0.16130440f, -0.05342378f, 0.02713547f, 0.05961263f, 
    0.07313419f, 0.09121494f, 0.05737312f, 0.15617128f, 0.05885608f, -0.13475503f, 0.07016819f, 0.01181027f, 
    -0.09532632f, 0.05483928f, -0.05683964f, -0.14760914f, 0.02319367f, -0.14311406f, -0.03432496f, 0.04901000f, 
    -0.17271249f, -0.04219532f, 0.02710382f, -0.03603020f, -0.18245649f, -0.06980925f, -0.05806807f, -0.13635540f, 
    -0.13807803f, -0.09187638f, -0.08399329f, -0.04253558f, 0.02956944f, -0.02796009f, 0.02507925f, 0.02697451f, 
    -0.06297827f, 0.01111644f, -0.01595038f, -0.15221813f, -0.01485828f, 0.18652335f, -0.03769503f, -0.01741940f, 
    -0.04552969f, 0.10817951f, 0.02172264f, 0.01300998f, -0.00745495f, -0.05242233f, -0.03990188f, 0.03489315f, 
    -0.14502735f, -0.14702098f, -0.08386024f, -0.28080279f, 0.06487103f, 0.01977641f, 0.04705104f, -0.03412997f, 
    0.08320438f, 0.09698810f, 0.08080281f, 0.03980888f, 0.41674721f, 0.00335361f, -0.22562827f, -0.19065417f, 
    -0.06846590f, 0.09731872f, 0.03039977f, -0.13959759f, -0.06879006f, 0.02487219f, 0.04131730f, -0.09291004f, 
    0.05032165f, 0.03310681f, 0.17062283f, 0.05768337f, -0.06873817f, 0.00574893f, -0.00999553f, 0.00729806f, 
    -0.01634631f, 0.03756590f, -0.00127423f, -0.08296980f, 0.24404693f, 0.09211768f, 0.22450671f, 0.17643447f, 
    0.03780435f, 0.12812263f, 0.01646021f, -0.06828203f, -0.03474475f, -0.07176226f, 0.14901336f, 0.12498209f, 
    0.32697037f, -0.06636765f, -0.02516984f, 0.19526342f, 0.02470355f, 0.04879660f, 0.05692236f, -0.20966199f, 
    -0.05694545f, -0.10865513f, 0.02361946f, -0.01476896f, -0.12879507f, -0.00303824f, 0.27877510f, 0.05357373f, 
    -0.03370126f, -0.01767031f, -0.12809262f, 0.00371369f, -0.14733072f, -0.02441890f, 0.04960170f, 0.03398803f, 
    -0.22418612f, 0.09668700f, 0.08581000f, 0.12220415f, -0.03078551f, -0.07140103f, -0.00285178f, -0.16461168f, 
    -0.03998069f, 0.02239561f, -0.10031861f, -0.01150647f, -0.00469623f, -0.00371863f, 0.02360490f, -0.08113977f, 
    -0.12714206f, -0.05436339f, -0.03114784f, 0.05722228f, 0.06313672f, 0.10875388f, 0.14455213f, 0.03436150f, 
    0.01635588f, 0.11265226f, 0.01107139f, 0.00903944f, -0.13738365f, -0.03632879f, -0.10781161f, -0.12335816f, 
    -0.00599026f, 0.05302013f, -0.06213865f, 0.09421644f, -0.07978023f, -0.21383938f, -0.07202275f, 0.07554878f, 
    0.18550508f, 0.06217670f, -0.05757749f, 0.29210091f, 0.00738644f, 0.03602340f, -0.01748401f, 0.10794873f, 
    -0.03578286f, 0.05012133f, 0.08820532f, -0.01084564f, 0.22076277f, -0.06657570f, -0.01924145f, 0.00192538f, 
    -0.22809726f, 0.05620420f, 0.01662159f, 0.08165094f, -0.15006350f, 0.13823266f, 0.01455968f, -0.03235498f, 
    -0.08420661f, 0.03982150f, 0.02975471f, 0.01218767f, 0.07986861f, -0.06129551f, -0.05484349f, -0.04721002f, 
    0.00241110f, 0.15640868f, -0.04674892f, -0.03705117f, 0.15110290f, 0.02649497f, 0.19254602f, 0.00038521f, 
    0.12804091f, 0.03715603f, -0.06677123f, 0.03385250f, -0.02931221f, -0.16886386f, -0.20118143f, -0.04882061f, 
    -0.01557769f, 0.11202907f, 0.03815354f, 0.10504176f, 0.07266656f, 0.08464541f, 0.14436515f, 0.26083970f, 
    -0.05468145f, -0.15885125f, 0.19762915f, -0.19916047f, 0.00731882f, -0.07234684f, -0.04388431f, 0.09387332f, 
    0.05178249f, 0.00123596f, 0.01592416f, 0.16269211f, 0.17619108f, -0.13653927f, -0.06014303f, 0.14670421f, 
    0.32978025f, 0.03461821f, -0.03385838f, 0.05331027f, -0.05276882f, -0.15148169f, -0.21141388f, -0.04985444f, 
    0.07230909f, 0.19957943f, 0.27744174f, 0.31023961f, 0.11406646f, -0.08533075f, 0.02699766f, -0.02348980f, 
    -0.06116725f, -0.00930880f, -0.10960428f, 0.05958399f, -0.22191732f, -0.10753269f, 0.06010073f, 0.01862165f, 
    0.00000047f, -0.08947189f, -0.00158403f, -0.08158109f, -0.02201421f, -0.08778828f, -0.00593550f, -0.13270827f, 
    -0.00952720f, 0.12170992f, -0.09026939f, -0.00035545f, 0.13807213f, 0.04598296f, 0.11957778f, -0.03691024f, 
    0.01252806f, -0.03706429f, 0.12760332f, -0.08310527f, -0.27504060f, -0.03871295f, 0.02136577f, -0.06778987f, 
    0.07962827f, 0.06227022f, 0.14454716f, 0.12726898f, 0.02682559f, 0.03277942f, -0.11210708f, -0.07192489f, 
    0.12114498f, -0.36266068f, -0.05181161f, -0.07693873f, 0.00002121f, 0.10758305f, 0.01447067f, -0.04937587f, 
    0.07280443f, -0.00232529f, 0.07155348f, -0.02895695f, -0.32427889f, -0.04202474f, 0.04612324f, -0.00208594f, 
    -0.00896901f, -0.04143062f, 0.00599853f, 0.00239087f, 0.00037924f, -0.03139862f, -0.04033431f, 0.04834767f, 
    0.56021804f, -0.15900126f, 0.05104836f, -0.13658397f, 0.12608905f, 0.04587102f, -0.04716036f, 0.04904983f, 
    0.08942091f, 0.14728285f, -0.04694397f, 0.05045415f, -0.43695635f, -0.08225908f, -0.19322127f, -0.14260280f, 
    0.03383269f, 0.09827842f, -0.06626946f, -0.03639041f, -0.04486707f, -0.01130143f, 0.11359311f, 0.07663492f, 
    -0.27052698f, 0.04119470f, 0.00838036f, 0.15077405f, 0.10951378f, 0.06730821f, -0.14699925f, 0.08316703f, 
    -0.11632249f, -0.00863614f, 0.00649151f, 0.01782182f, 0.08301738f, -0.27427572f, -0.02491572f, 0.10275438f, 
    0.02937386f, 0.01107582f, -0.05291355f, 0.10859402f, -0.02863034f, 0.04687456f, -0.14891317f, 0.09393492f, 
    0.12953539f, -0.25871775f, 0.05569008f, 0.05363008f, 0.07782012f, 0.09551623f, -0.11050676f, 0.06119183f, 
    0.01082782f, 0.02658000f, -0.08771201f, 0.01388423f, 0.28413683f, -0.09267596f, 0.06557414f, 0.03246681f, 
    -0.06467386f, 0.05577285f, 0.02425472f, 0.16444553f, -0.03898238f, 0.05239715f, -0.15301013f, -0.05559202f, 
    -0.28451279f, 0.06333739f, 0.16679920f, -0.07022853f, 0.14335701f, -0.00653718f, 0.08341729f, -0.06838119f, 
    0.11202075f, -0.13392629f, 0.00985885f, 0.09385149f, -0.04919913f, 0.13450240f, -0.01885667f, -0.07895011f, 
    0.07192724f, 0.07877687f, 0.04922258f, 0.17822221f, 0.01068624f, 0.00994494f, 0.17495859f, 0.12841287f, 
    0.02787295f, 0.06776468f, -0.04679026f, -0.09183522f, 0.13833924f, -0.02461430f, 0.02792846f, -0.14022651f, 
    0.00532013f, 0.04220063f, -0.07267249f, 0.08108957f, 0.15949145f, -0.05530414f, 0.16534743f, 0.07962690f, 
    0.12945266f, 0.10381186f, -0.13601412f, -0.11765211f, 0.05156276f, 0.17772844f, -0.07854240f, 0.04902277f, 
    0.33687469f, 0.15133135f, 0.18110625f, 0.02348801f, -0.04104576f, -0.04481911f, -0.08049443f, -0.12523715f, 
    0.00947879f, 0.04952133f, 0.10355446f, -0.02644431f, -0.14216955f, -0.12457519f, 0.00767777f, -0.07621699f, 
    -0.15136260f, -0.08161090f, -0.16379733f, -0.01260094f, 0.02176804f, 0.14571622f, -0.12283553f, 0.02755989f, 
    0.04374829f, -0.02398926f, -0.03237583f, 0.06759813f, 0.10540657f, 0.04887725f, 0.04084549f, -0.03071517f, 
    -0.05772080f, 0.01089090f, -0.01992431f, -0.04766937f, 0.22964662f, -0.11578880f, -0.02182940f, 0.06600462f, 
    0.05213264f, 0.03964138f, 0.06738413f, -0.09001974f, 0.11481780f, 0.01377250f, -0.01806882f, -0.10094677f, 
    0.08385670f, 0.10830020f, 0.04733148f, 0.14823510f, 0.02289638f, 0.06118760f, 0.09409238f, -0.05989716f, 
    0.08140847f, -0.08659391f, -0.03491700f, -0.05635256f, -0.16633670f, -0.30337292f, 0.06676961f, 0.00749265f, 
    0.10606096f, 0.07604381f, -0.03382948f, -0.06932749f, 0.07201816f, 0.09784123f, 0.01885662f, -0.02701486f, 
    0.04478662f, 0.05193434f, 0.06593664f, -0.03295724f, 0.02035640f, 0.10751950f, -0.00608885f, 0.11300141f, 
    -0.03250195f, -0.02145083f, -0.11336472f, 0.06863524f, -0.14082213f, -0.17154136f, -0.08551046f, 0.06874412f, 
    0.01091850f, 0.01410305f, 0.04118025f, -0.12543231f, -0.02636794f, 0.11738978f, 0.11396340f, 0.10575204f, 
    -0.17525305f, -0.17354433f, 0.10131504f, -0.05862755f, 0.04334961f, -0.08064231f, -0.08209725f, -0.04055046f, 
    0.11375167f, 0.05840174f, -0.11093023f, 0.04063595f, -0.11202739f, -0.16113506f, 0.06308091f, -0.13098641f, 
    0.10153489f, -0.06650105f, 0.02674448f, 0.13383144f, -0.02121341f, 0.04096171f, 0.03775045f, 0.16121656f, 
    -0.01574430f, 0.19050650f, 0.07173102f, 0.00989475f, 0.11871237f, -0.14618264f, -0.08250861f, 0.03043994f, 
    0.01382219f, 0.00137346f, 0.06732235f, 0.06957871f, -0.03281230f, 0.17735410f, 0.03703218f, 0.02561160f, 
    -0.15080038f, 0.04015668f, 0.15450710f, 0.01904994f, -0.04638226f, -0.06751864f, 0.02015628f, -0.00758994f, 
    0.02458001f, 0.17915697f, -0.02055751f, 0.02317480f, 0.05474155f, 0.01098284f, 0.08598659f, -0.04326647f, 
    0.05761176f, 0.04336481f, -0.01268783f, 0.00372904f, 0.02000357f, -0.07404322f, -0.07326479f, -0.02668735f, 
    -0.03548511f, -0.04761325f, 0.07335420f, 0.03534532f, 0.03694257f, 0.11582773f, 0.16036335f, 0.15152885f, 
    -0.08682998f, -0.19054206f, -0.08270645f, 0.09730366f, 0.02275288f, -0.05263102f, -0.07413742f, -0.05327389f, 
    0.08967037f, 0.17287894f, -0.04117080f, -0.06695311f, 0.12984560f, -0.17103593f, 0.07229853f, -0.03977636f, 
    0.14740747f, 0.11470471f, -0.09892621f, 0.01445990f, -0.03754795f, -0.09519409f, -0.03182581f, -0.13391116f, 
    0.21048999f, 0.15773587f, 0.05109703f, 0.08443797f, 0.02127003f, -0.03937366f, -0.06799481f, -0.16673113f, 
    0.00117158f, -0.00800922f, -0.07912663f, 0.07962849f, 0.14819688f, 0.10637578f, 0.21309522f, 0.06042206f, 
    0.05236637f, -0.01861660f, -0.04991729f, -0.00233853f, 0.03901025f, -0.06482220f, -0.00571278f, -0.01851366f, 
    -0.09587593f, 0.09137387f, -0.09648263f, 0.07630452f, -0.03148677f, 0.01221317f, 0.15389189f, -0.04886961f, 
    0.00670758f, 0.08742821f, -0.02782351f, -0.04771841f, -0.24731532f, 0.05602136f, 0.16243097f, 0.05579589f, 
    0.05173481f, -0.05716484f, 0.13746896f, -0.07132185f, -0.06997536f, 0.03829462f, 0.07366952f, -0.04307453f, 
    -0.15383096f, -0.31851643f, -0.10691122f, -0.02269400f, 0.03123148f, 0.06434970f, 0.09552642f, 0.14338367f, 
    -0.11827600f, 0.04279285f, 0.00466505f, 0.10577735f, 0.53445822f, 0.17271806f, 0.14273152f, 0.11664516f, 
    0.05115597f, -0.04382722f, -0.01700088f, -0.07343717f, 0.17674990f, 0.01133232f, 0.06356562f, 0.11519345f, 
    0.00180076f, 0.06599400f, -0.15443148f, -0.19180962f, -0.06658387f, -0.00620693f, 0.03596729f, 0.02510086f, 
    -0.04286288f, -0.03172270f, 0.07509885f, 0.00278769f, 0.52664578f, 0.38645977f, 0.23591265f, 0.14974749f, 
    0.01591289f, -0.02171966f, -0.04313813f, -0.01366296f, 0.05876857f, 0.06889474f, -0.05709048f, -0.06721163f, 
    0.52035803f, 0.07228596f, 0.27804312f, -0.03340956f, 0.03282400f, 0.07222805f, 0.04259794f, 0.01601775f, 
    0.09825069f, 0.09708142f, 0.01243169f, 0.13788104f, -0.37755907f, 0.10736685f, -0.15137510f, -0.00254262f, 
    0.09693115f, 0.12212204f, 0.09083400f, 0.00212743f, 0.14980017f, 0.02729849f, -0.02480223f, -0.01398353f, 
    -0.07166723f, -0.02160718f, -0.23117609f, 0.05509289f, -0.01916159f, 0.19402234f, 0.03142086f, -0.10241647f, 
    0.08696334f, -0.20991424f, 0.02538135f, -0.23797117f, -0.25751686f, 0.04052157f, -0.14869529f, -0.10525433f, 
    0.25030443f, -0.07637087f, -0.04380266f, 0.05112661f, -0.02132161f, -0.06009147f, 0.08032685f, -0.03293229f, 
    0.02670348f, -0.23899749f, -0.08728136f, -0.11461095f, 0.13851556f, 0.08659389f, 0.02998273f, -0.01691797f, 
    -0.06186877f, -0.09706869f, -0.00710157f, -0.12260506f, 0.08137500f, 0.19383888f, 0.07240014f, 0.06842039f, 
    0.07604031f, -0.07539014f, 0.05766137f, 0.05187446f, -0.00263536f, 0.03409366f, -0.05670229f, -0.18024138f, 
    0.11734885f, 0.07734768f, 0.15713760f, 0.16267048f, 0.04456409f, -0.11984584f, 0.03746615f, 0.12272096f, 
    0.15712918f, -0.05704890f, 0.14822647f, 0.08746006f, -0.35190412f, 0.10376766f, -0.05487796f, -0.16716832f, 
    0.08555340f, 0.03619637f, -0.01324713f, -0.01938570f, 0.05779058f, 0.05106787f, 0.00120653f, 0.03057455f, 
    -0.19000950f, -0.12959503f, -0.15787236f, -0.05429116f, -0.12817499f, -0.03710814f, -0.02478308f, -0.01468975f, 
    0.06432777f, 0.07351246f, -0.03745823f, 0.13077268f, 0.10346727f, -0.09499900f, -0.06452813f, 0.22375502f, 
    -0.19899371f, 0.07869961f, 0.00042193f, -0.07434602f, 0.02564869f, 0.11068080f, 0.16393787f, 0.04195774f, 
    -0.20286620f, -0.12641573f, 0.04080547f, 0.05869199f, 0.19431262f, 0.04757522f, 0.09019564f, 0.12587337f, 
    0.11023588f, -0.01404238f, 0.08699313f, 0.01002256f, -0.50043935f, -0.04605347f, -0.11377279f, -0.05991538f, 
    0.22673027f, 0.02037213f, -0.04125256f, 0.07125247f, -0.02562358f, -0.13080345f, 0.01358940f, 0.04473007f, 
    0.12011380f, -0.33230844f, -0.10000849f, 0.13089906f, 0.00780082f, -0.00670594f, 0.09629145f, 0.07282612f, 
    -0.05205984f, 0.05207511f, -0.01505620f, -0.07232984f, -0.43322423f, 0.09231680f, 0.28762069f, -0.08986070f, 
    0.10162854f, 0.08353486f, -0.01420086f, 0.02270419f, 0.05016592f, 0.06417230f, -0.00985585f, -0.00369752f, 
    0.30033690f, -0.08061071f, 0.10455112f, 0.00631844f, 0.11970771f, 0.06193864f, 0.04083716f, -0.01992091f, 
    -0.10799547f, 0.01686233f, 0.20865598f, 0.16897260f, -0.33431745f, 0.23539855f, -0.17652912f, -0.38056818f, 
    0.05768562f, 0.06913833f, -0.03624697f, -0.04736364f, 0.09530450f, -0.00637750f, 0.06158463f, 0.05224744f, 
    0.09128282f, 0.19525370f, 0.15696891f, -0.15843086f, 0.01054140f, 0.04341024f, -0.07730453f, -0.01126763f, 
    -0.02306576f, -0.02040256f, -0.05008747f, 0.08176032f, -0.04697944f, 0.09846361f, -0.06268626f, 0.17031473f, 
    0.08262175f, -0.10210133f, 0.04023506f, 0.06901363f, 0.06787665f, -0.06626240f, 0.04513678f, 0.06010443f, 
    0.03048332f, -0.11419348f, -0.06780506f, 0.00366490f, -0.01184961f, 0.03957859f, 0.07947430f, 0.09060805f, 
    -0.01195195f, -0.02046814f, -0.10290366f, -0.02712753f, -0.06133055f, 0.19412707f, -0.02074155f, 0.08725963f, 
    -0.01424648f, -0.07774965f, -0.00798554f, -0.04044935f, -0.03354103f, -0.06832977f, 0.03101004f, 0.01056048f, 
    -0.01686888f, 0.04840185f, -0.01772763f, 0.13867907f, 0.00350633f, 0.01296344f, 0.05355460f, -0.14078657f, 
    0.04317215f, -0.04696067f, -0.00376676f, -0.02205357f, 0.20110624f, 0.12106834f, -0.02386660f, 0.03030540f, 
    0.05206152f, -0.12912083f, 0.03571966f, 0.16215739f, 0.03124587f, 0.02057639f, -0.01812270f, -0.13078302f, 
    0.01907339f, 0.17545988f, 0.13502169f, 0.03032494f, -0.02180989f, 0.12869677f, 0.05548388f, 0.04009716f, 
    0.04653717f, -0.03800385f, -0.10202192f, 0.06960896f, 0.14152725f, 0.01506569f, 0.12594822f, -0.18742912f, 
    0.07682712f, -0.00957406f, 0.18198918f, 0.00784205f, -0.03082026f, 0.28861690f, 0.06018284f, 0.04444584f, 
    0.24467072f, 0.07870003f, 0.04277675f, -0.06979988f, -0.07819595f, 0.12947859f, 0.03538057f, -0.07872000f, 
    0.04909198f, -0.06540536f, -0.06574284f, 0.02558848f, -0.04169651f, -0.09482075f, -0.15994583f, -0.06509631f, 
    -0.05456246f, -0.00491034f, -0.02396045f, 0.07176491f, 0.03554355f, 0.06174447f, -0.00645926f, 0.15353231f, 
    -0.11143494f, -0.01379821f, -0.08715122f, 0.02762078f, 0.11978028f, 0.07304832f, 0.28748116f, 0.12280679f, 
    0.04371459f, 0.01580985f, 0.01656790f, 0.14403909f, -0.19168493f, -0.09605899f, -0.20143682f, -0.00515378f, 
    0.00386523f, -0.02298781f, -0.05238615f, 0.04782047f, -0.01461528f, -0.01111027f, 0.07047953f, -0.02118807f, 
    0.02308796f, -0.01352591f, -0.07326806f, -0.22385381f, -0.04248085f, 0.14406553f, -0.04343394f, -0.14251943f, 
    0.12422097f, 0.01417880f, -0.02884480f, -0.04868656f, -0.04482884f, -0.12496691f, 0.11641674f, 0.12174794f, 
    0.04198030f, -0.07629789f, -0.02337840f, 0.06809469f, -0.10989231f, 0.04223985f, -0.01822588f, 0.05467085f, 
    0.01721852f, 0.03977434f, -0.01239584f, -0.13141057f, 0.05678683f, 0.07181235f, 0.09036836f, 0.02910074f, 
    0.10115509f, 0.09584937f, 0.03744498f, 0.07679549f, -0.24243911f, -0.10364359f, -0.08157617f, 0.06336959f, 
    -0.12490182f, 0.12852615f, 0.00244062f, -0.02001448f, 0.02351946f, -0.00161385f, 0.09971658f, 0.11745419f, 
    -0.16620463f, 0.07578101f, 0.14172459f, 0.03241574f, 0.02949774f, -0.06986097f, -0.11459236f, -0.15813027f, 
    -0.09942240f, -0.08369508f, -0.08389160f, 0.10531625f, 0.04380694f, -0.31950679f, -0.07875627f, -0.05755323f, 
    -0.05576960f, 0.02175456f, 0.06813332f, -0.04963310f, -0.00867436f, 0.11273731f, -0.11128002f, 0.19185796f, 
    0.15282011f, -0.00417831f, 0.05427687f, -0.17615560f, 0.11692958f, 0.11192738f, -0.24216953f, -0.05408544f, 
    -0.01711987f, 0.26901832f, 0.09710411f, 0.07221134f, 0.11043523f, -0.13561434f, 0.00249328f, -0.00317410f, 
    -0.01327405f, 0.17440769f, -0.03587134f, 0.06209583f, 0.11021529f, 0.05831048f, -0.07728462f, 0.06659763f, 
    -0.17872544f, -0.02631377f, -0.02807473f, -0.21385628f, -0.07035150f, 0.03547724f, 0.00008607f, 0.04255719f, 
    0.01952943f, -0.05870275f, -0.05127664f, 0.09227825f, 0.04699330f, 0.11478756f, 0.03944980f, 0.00310335f, 
    -0.13591155f, -0.06050507f, -0.01656002f, -0.03995495f, 0.03674609f, 0.07583033f, 0.10329843f, 0.37208903f, 
    0.00415088f, -0.09795178f, -0.16064768f, 0.00068614f, 0.04925786f, -0.09406295f, -0.00275338f, 0.01560008f, 
    0.09057546f, 0.16333304f, -0.09494165f, 0.01226397f, 0.18688329f, -0.10773624f, 0.05697364f, 0.15345205f, 
    0.04080785f, 0.00073938f, 0.12145650f, -0.09972280f, 0.08998439f, -0.04536514f, -0.05221035f, 0.03260108f, 
    0.23132442f, 0.17268948f, 0.08289824f, -0.08138401f, 0.12260726f, 0.06470586f, -0.01407769f, -0.09015620f, 
    0.12448253f, 0.09286455f, 0.15166868f, 0.02195487f, -0.28058222f, 0.02170889f, 0.05092813f, -0.14725317f, 
    -0.06258624f, 0.10477395f, -0.12308498f, 0.12832205f, 0.03279769f, 0.19828944f, -0.03460475f, -0.14538747f, 
    0.23688941f, -0.10274751f, 0.09605914f, -0.10012952f, 0.07588770f, -0.00798623f, -0.00319775f, -0.13065562f, 
    -0.08823691f, 0.12526153f, -0.14564162f, -0.10440113f, 0.15054853f, -0.15352252f, -0.15366481f, -0.10955530f, 
    0.04385202f, -0.04560168f, 0.19403549f, -0.16234596f, 0.16745983f, -0.01151485f, -0.06199131f, -0.22224168f, 
    -0.02245999f, 0.03117608f, -0.04808735f, -0.04174046f, -0.02913656f, -0.02914065f, 0.06155596f, 0.01169321f, 
    0.00650161f, 0.02409865f, -0.02833840f, -0.06885250f, -0.05390227f, 0.03418688f, 0.00356858f, -0.05080104f, 
    0.03775479f, -0.07842620f, 0.01764338f, -0.04669471f, -0.04846436f, 0.03853919f, -0.06730924f, -0.04555719f, 
    -0.01453817f, 0.04570185f, -0.02008695f, -0.07645017f, -0.03310798f, 0.00468660f, -0.07164974f, 0.02678756f, 
    0.05689909f, -0.00204376f, -0.04598890f, -0.00767380f, 0.03434636f, -0.05384878f, 0.00312398f, -0.05572395f, 
    -0.00102828f, -0.06637394f, -0.05233718f, -0.01742296f, 0.01927430f, -0.02211945f, -0.05072253f, -0.04784049f, 
    0.04957908f, 0.01483120f, 0.02104691f, 0.05538594f, -0.03237341f, 0.04080782f, -0.01752478f, -0.05389855f, 
    0.05856949f, -0.07128453f, 0.00142526f, 0.01210466f, 0.02176770f, 0.05211006f, -0.03548495f, 0.01852129f, 
    -0.04266502f, 0.00942983f, -0.05607758f, 0.03868586f, -0.07667379f, 0.04831754f, -0.02364375f, -0.06523723f, 
    -0.01586278f, 0.00642137f, -0.05106674f, -0.04395502f, -0.01575899f, 0.01437075f, 0.00578696f, 0.04641602f, 
    -0.08226746f, 0.00870437f, 0.05981036f, 0.03498731f, -0.01769207f, -0.05949786f, -0.03534401f, 0.06237847f, 
    -0.00884104f, 0.01601793f, -0.00816243f, -0.00774863f, 0.05588498f, -0.04061720f, -0.06497048f, -0.05589969f, 
    0.03090949f, -0.06156122f, -0.04847003f, -0.05907075f, -0.06530858f, 0.00382446f, -0.02337551f, 0.00070589f, 
    -0.05902458f, 0.01222449f, -0.07934235f, -0.03714167f, 0.04325966f, -0.01889097f, -0.00206431f, 0.03290069f, 
    -0.05230010f, -0.00813906f, -0.00862649f, -0.07911505f, -0.00167989f, -0.00631288f, -0.07448868f, -0.05701788f, 
    -0.03568840f, 0.05150317f, -0.04343991f, -0.02794620f, 0.00586948f, -0.01963454f, 0.04974064f, 0.02017671f, 
    -0.00790414f, -0.03013124f, -0.01908822f, -0.03688311f, -0.02119002f, -0.01053101f, -0.00857839f, -0.06248636f, 
    -0.02959814f, -0.07260255f, 0.05813941f, 0.04144593f, -0.00264827f, 0.01035658f, 0.05520586f, -0.06297173f, 
    0.04679646f, 0.04750547f, -0.00705182f, 0.04222511f, 0.03197495f, -0.06906592f, 0.05760027f, 0.05670293f, 
    -0.06067736f, -0.02628933f, 0.02796030f, 0.02804163f, 0.01519569f, -0.03157387f, -0.03523894f, 0.00286698f, 
    -0.00559203f, 0.05528638f, 0.02076901f, 0.00860804f, -0.02615273f, -0.04890168f, -0.06306724f, -0.00385877f, 
    0.05788957f, -0.00707455f, -0.04293883f, 0.03674339f, -0.01450951f, -0.07127669f, 0.00713509f, 0.04721989f, 
    -0.04161437f, -0.01494179f, -0.01426818f, -0.00486956f, -0.07534071f, -0.03032785f, 0.03320688f, -0.07901043f, 
    -0.06415332f, 0.05642626f, 0.03692090f, 0.00948758f, 0.02621454f, 0.02762895f, 0.02592578f, -0.05980234f, 
    0.07384960f, 0.01159575f, 0.03280818f, 0.03474307f, 0.04050117f, 0.06015795f, 0.03579655f, -0.05924034f, 
    -0.05093832f, -0.07154121f, -0.05411359f, -0.05993007f, -0.05750949f, -0.00809478f, -0.02152630f, -0.07037766f, 
    -0.04579958f, -0.08810649f, -0.06472319f, 0.01605717f, 0.04858989f, -0.04139503f, 0.04446476f, -0.06134895f, 
    0.02357658f, 0.02668763f, 0.04358637f, 0.00804839f, -0.03549292f, -0.02746402f, -0.04258323f, -0.07811740f, 
    0.00369014f, 0.04013909f, -0.07461161f, -0.09653138f, 0.06047278f, -0.03054166f, -0.00571187f, -0.04853749f, 
    0.04349742f, -0.01302713f, 0.02401048f, 0.01611088f, 0.05354703f, -0.00774116f, -0.02387613f, 0.01173186f, 
    -0.03800825f, 0.00976445f, 0.02832643f, 0.03164000f, -0.05514340f, -0.00148414f, 0.03175085f, -0.02570121f, 
    0.05033111f, -0.03289178f, 0.03196263f, -0.09016207f, -0.11695067f, -0.01588263f, -0.01969467f, 0.05850479f, 
    0.03160640f, 0.00942210f, -0.03579199f, 0.01674807f, -0.00914608f, -0.06264459f, 0.01378136f, -0.03012130f, 
    -0.06065201f, -0.00445947f, 0.00979549f, -0.02074754f, 0.02761698f, -0.01448509f, -0.07447457f, 0.00087029f, 
    -0.00225425f, 0.01321114f, -0.08514857f, -0.07405438f, -0.07889280f, -0.01651976f, 0.00909635f, -0.05877094f, 
    0.00024158f, -0.06299540f, 0.04732211f, 0.06516388f, 0.01859093f, 0.05909079f, -0.07991998f, -0.03559977f, 
    0.02913908f, -0.05720091f, 0.03046638f, -0.09495459f, -0.04488996f, 0.04034260f, -0.05889980f, -0.04485767f, 
    -0.08634374f, -0.06618284f, 0.04308610f, -0.08618206f, 0.00968158f, -0.04166179f, 0.03427961f, -0.05697770f, 
    0.03229081f, -0.02600694f, -0.06240503f, 0.03630614f, 0.03894391f, -0.05398325f, -0.02721939f, -0.05601424f, 
    0.01946304f, 0.03724642f, 0.02100079f, -0.05873251f, 0.01109953f, -0.00668313f, 0.03846304f, -0.07693280f, 
    -0.08098418f, -0.02937701f, 0.04434203f, 0.05671484f, -0.05080229f, -0.08029653f, -0.09391226f, 0.02588959f, 
    0.01982558f, -0.01727636f, -0.09666406f, -0.05336474f, 0.01489578f, -0.05006470f, -0.10171971f, -0.01740880f, 
    -0.00130490f, -0.00803586f, 0.00975834f, 0.06508251f, 0.00492891f, -0.00824780f, -0.06749713f, -0.07637230f, 
    -0.04123339f, 0.00518135f, 0.05068852f, 0.01157520f, -0.04866614f, 0.04183423f, 0.02857425f, 0.01234471f, 
    -0.05857427f, 0.01325727f, -0.07393462f, -0.05416681f, 0.03637384f, 0.01157910f, -0.06151026f, -0.09444211f, 
    0.04216528f, -0.05196057f, -0.06223262f, 0.03983073f, 0.00856909f, -0.04946380f, 0.03900347f, -0.02947553f, 
    0.01890896f, 0.00116605f, 0.01514274f, 0.03342444f, -0.07259788f, -0.06586650f, 0.02398568f, -0.04102824f, 
    0.03480908f, 0.02017857f, 0.01566972f, 0.00090534f, 0.00025346f, -0.01375259f, -0.08874079f, -0.05191649f, 
    -0.15765402f, -0.06106540f, 0.00430335f, 0.19174719f, -0.04147395f, 0.01553619f, 0.01333355f, -0.06074827f, 
    -0.01575903f, 0.03463306f, 0.17015103f, 0.05008394f, 0.30539465f, 0.02301192f, -0.16845314f, -0.18807617f, 
    0.10572652f, -0.09120306f, 0.15317550f, 0.05474595f, -0.14465539f, 0.07647672f, 0.00220160f, -0.03617112f, 
    0.02353228f, 0.18007270f, 0.04300011f, 0.06924730f, 0.06272321f, 0.13033159f, -0.04516164f, 0.08258485f, 
    0.08252893f, -0.14221174f, 0.12152242f, -0.00240222f, -0.14636065f, 0.07298147f, -0.08241139f, -0.23409478f, 
    0.13416608f, 0.07217783f, -0.00447849f, -0.16550110f, -0.06640340f, 0.08053803f, 0.05750047f, 0.09085321f, 
    0.24601886f, -0.06264470f, -0.04950637f, -0.13270566f, -0.07564103f, 0.09116538f, -0.21540867f, -0.11669533f, 
    -0.06669025f, 0.02915384f, 0.07001155f, -0.01278401f, 0.44229439f, -0.09689591f, 0.01805996f, -0.04439715f, 
    -0.07227496f, 0.01879750f, 0.08090454f, 0.05820632f, 0.10551814f, 0.07743783f, -0.04809536f, -0.11139236f, 
    0.10242646f, -0.04040900f, 0.05142195f, 0.04226137f, 0.07432017f, 0.07732928f, -0.02633434f, -0.08504210f, 
    -0.06393800f, -0.08760926f, -0.11201255f, 0.00753802f, 0.00550952f, 0.25278300f, 0.15525295f, 0.15756820f, 
    -0.00778986f, -0.06460374f, -0.11276389f, 0.14834958f, -0.04165501f, -0.02497960f, -0.03608038f, 0.01663497f, 
    0.01535752f, 0.18185569f, 0.02626628f, 0.13448659f, -0.01629391f, -0.01874313f, 0.00473631f, -0.04079633f, 
    0.11267057f, 0.00630944f, 0.11483207f, -0.03852968f, 0.23311312f, 0.07022082f, 0.12043796f, -0.11892299f, 
    -0.08420714f, -0.09645620f, -0.02818412f, -0.02176864f, -0.15767230f, -0.01196376f, 0.05041043f, -0.07025287f, 
    -0.08250239f, 0.10357039f, -0.17817976f, 0.08265761f, 0.17530268f, -0.09889444f, -0.08343883f, -0.01555787f, 
    0.02982005f, 0.03148924f, 0.08123358f, -0.02839439f, -0.02753467f, -0.06272428f, 0.00354960f, 0.04448331f, 
    -0.10454357f, -0.02572812f, 0.01474632f, -0.14154224f, 0.07226797f, 0.07214089f, -0.10631406f, -0.04168852f, 
    0.04101870f, 0.03686265f, -0.23510554f, -0.10276634f, 0.02225034f, -0.03301883f, -0.01377984f, -0.09827029f, 
    -0.04977890f, -0.13396651f, 0.12720436f, -0.07754623f, 0.43006435f, -0.12735115f, -0.19887729f, 0.10399156f, 
    -0.02644539f, -0.00130521f, -0.05940283f, -0.12200367f, 0.04377698f, 0.08421841f, 0.11009885f, 0.05091097f, 
    0.04261780f, 0.10020063f, 0.07832487f, 0.05834189f, -0.12331582f, 0.01288248f, 0.03792582f, 0.06990968f, 
    0.02524081f, 0.08279125f, 0.01208700f, -0.00228413f, 0.40904412f, -0.06594647f, 0.06426259f, 0.06600969f, 
    0.00056363f, -0.02334981f, 0.08466619f, 0.06113264f, -0.00782756f, -0.02761650f, 0.09404758f, 0.01669110f, 
    -0.29893747f, -0.11862485f, -0.12946133f, -0.22047904f, -0.03250784f, -0.03559088f, -0.12274681f, -0.10681185f, 
    -0.05792209f, 0.02568432f, -0.02583089f, 0.02501364f, 0.12870413f, 0.11660273f, 0.02237541f, 0.05172026f, 
    0.09353989f, -0.14380412f, -0.01146236f, 0.08072600f, 0.08168832f, 0.03589839f, 0.02800580f, 0.12293988f, 
    -0.22391778f, -0.12427726f, 0.06715106f, -0.01437504f, 0.18897904f, -0.02289781f, 0.10133358f, 0.04761360f, 
    0.00626573f, -0.06892611f, 0.12960841f, 0.02369057f, -0.10466441f, 0.07476816f, 0.02652777f, -0.10803239f, 
    0.04151791f, 0.09808958f, 0.03002791f, 0.13902198f, 0.10305773f, -0.05987591f, 0.08580308f, 0.13197535f, 
    0.02477855f, 0.19996889f, 0.12510172f, -0.06671944f, -0.01587376f, -0.05082065f, -0.07439242f, 0.02109837f, 
    -0.02893526f, -0.03654999f, 0.12278511f, 0.12188591f, -0.03292382f, 0.09093635f, -0.02174671f, 0.07781170f, 
    -0.01546598f, 0.07521295f, 0.04334018f, -0.05892598f, 0.00816195f, 0.03297536f, 0.00210822f, 0.01375858f, 
    0.18804413f, -0.02906938f, 0.07077903f, -0.06197670f, -0.03744427f, 0.12512659f, 0.04916809f, -0.01872215f, 
    -0.05562358f, 0.05175158f, 0.04498915f, 0.05693524f, 0.08918184f, -0.19108637f, 0.01808685f, -0.05190786f, 
    0.13881204f, -0.03482523f, -0.14812119f, -0.04265726f, -0.02044828f, -0.03593654f, 0.05203172f, -0.01530699f, 
    -0.09654665f, -0.10704558f, -0.09351811f, -0.00167985f, 0.05836022f, -0.04265059f, -0.06590687f, -0.01032069f, 
    0.01819686f, -0.04431708f, 0.09279062f, 0.04625939f, 0.13409647f, 0.18911842f, 0.09013043f, -0.02070102f, 
    0.03891948f, -0.14465751f, -0.03065980f, 0.01059498f, 0.06183190f, 0.10434876f, 0.02873774f, 0.08502132f, 
    0.34697494f, 0.05688657f, -0.03532972f, 0.15042581f, 0.15028964f, -0.05027879f, 0.00078934f, 0.11932756f, 
    0.04113131f, 0.11742823f, 0.03718900f, 0.10303465f, -0.06542657f, 0.25149271f, -0.08100137f, 0.00905679f, 
    -0.07643295f, -0.11325355f, 0.02935931f, 0.06945790f, 0.01740475f, 0.10490984f, -0.01401106f, 0.11353620f, 
    0.00705772f, 0.02148608f, -0.04088175f, 0.06227464f, -0.01981749f, 0.01376876f, 0.01947065f, 0.05646293f, 
    -0.06214601f, 0.03660908f, 0.07377943f, -0.02418435f, -0.47133303f, -0.08147027f, -0.24038976f, 0.00320300f, 
    -0.07712462f, 0.07906882f, 0.01137932f, 0.04253349f, 0.03150036f, 0.12388732f, -0.05840007f, -0.07776596f, 
    0.24887550f, -0.12520073f, 0.02978391f, -0.07552356f, 0.08383310f, -0.14136913f, 0.03524357f, 0.04906383f, 
    0.09332220f, -0.08616515f, -0.02147540f, -0.10274827f, 0.05033018f, 0.03306191f, -0.14667150f, -0.13217312f, 
    -0.06123791f, -0.11690238f, 0.00583835f, 0.03926799f, 0.04416781f, -0.05253326f, -0.01260877f, -0.14261582f, 
    -0.09930032f, 0.21118926f, 0.12217895f, -0.03874958f, -0.02115054f, -0.02592053f, -0.02453979f, -0.18717319f, 
    0.11179168f, -0.13684402f, -0.08452798f, 0.03264573f, -0.16242123f, -0.12722707f, -0.07448912f, 0.16398229f, 
    0.03162461f, -0.03230232f, 0.01497752f, -0.02008495f, -0.02943882f, 0.03956796f, 0.04913205f, 0.03501812f, 
    -0.09903125f, 0.07966250f, 0.04417255f, -0.01914423f, 0.07952709f, -0.09254144f, 0.08107749f, 0.09133928f, 
    0.16693158f, -0.00788970f, -0.14730899f, 0.11936130f, 0.16949075f, -0.37782037f, 0.09783272f, 0.46092221f, 
    -0.02988819f, 0.03352131f, 0.01171090f, 0.01844553f, 0.09951819f, -0.04355529f, 0.08104744f, 0.24710676f, 
    -0.20130976f, -0.10278590f, 0.10043608f, 0.02818345f, 0.04367647f, -0.04571752f, -0.07045455f, -0.04456237f, 
    -0.00809646f, 0.02847296f, 0.08221880f, -0.06988505f, -0.04727839f, -0.26193258f, -0.12230946f, -0.05333167f, 
    0.03084997f, -0.02628855f, 0.01835916f, 0.11957167f, -0.06930288f, -0.04568301f, -0.08659326f, 0.14199187f, 
    -0.02705682f, 0.14600407f, 0.08112423f, -0.05544665f, 0.13356140f, -0.08806379f, -0.08209224f, 0.08567435f, 
    0.02315715f, 0.11520519f, 0.15519461f, 0.15045688f, 0.10434762f, -0.17210647f, -0.00735252f, 0.00587830f, 
    -0.11685444f, 0.12047329f, 0.02324686f, 0.13488013f, 0.00165991f, 0.01479614f, -0.06160830f, 0.07995053f, 
    -0.06155856f, -0.07489152f, 0.01401059f, -0.04841965f, -0.01770496f, 0.07335578f, 0.02521797f, 0.09375042f, 
    -0.06581637f, 0.02682774f, -0.00897535f, 0.08951753f, 0.00038738f, -0.07565805f, 0.02797246f, 0.05081857f, 
    -0.09737641f, -0.03136006f, 0.01975502f, -0.08862571f, 0.01202055f, 0.01878086f, 0.14317191f, 0.37818515f, 
    -0.10211904f, -0.08096060f, 0.04565315f, -0.06236305f, -0.00331030f, -0.08728456f, 0.01901817f, 0.08877609f, 
    0.04293649f, 0.17487833f, 0.01313427f, 0.07378148f, 0.00892728f, -0.06192667f, 0.08539203f, 0.02365526f, 
    0.04627482f, 0.02434237f, -0.10780863f, 0.07582006f, 0.06150063f, -0.12016565f, -0.07638529f, 0.01582104f, 
    0.12379527f, 0.10684264f, 0.09806789f, 0.07680432f, -0.02921358f, 0.01358387f, 0.06059099f, 0.13704728f, 
    0.08343478f, 0.18396759f, 0.10643219f, 0.12295480f, -0.26953572f, 0.18051356f, -0.09018538f, -0.07574138f, 
    0.07539003f, 0.09741662f, -0.00386092f, -0.01452577f, 0.05096267f, -0.04242457f, -0.08611760f, -0.06036514f, 
    0.11917970f, 0.06147153f, -0.05451731f, 0.02223026f, 0.00753661f, -0.13992679f, -0.06497028f, -0.04384732f, 
    0.06520864f, -0.01596789f, -0.02973775f, -0.02085596f, -0.04033801f, -0.10589109f, 0.07174551f, 0.02466292f, 
    -0.00307496f, -0.09320315f, 0.10838713f, 0.04397187f, 0.04204926f, -0.08246294f, -0.10869900f, -0.07811325f, 
    -0.06697461f, -0.03037137f, -0.05752384f, -0.05140090f, 0.04020587f, 0.03565684f, 0.03789505f, 0.03834007f, 
    0.03899441f, -0.02830745f, 0.05322212f, -0.06638071f, -0.05080526f, -0.02515088f, 0.00764538f, 0.04456554f, 
    0.06430186f, -0.02443626f, -0.06254063f, -0.04927100f, -0.05374372f, -0.04095295f, 0.06387902f, -0.06617812f, 
    0.05501179f, -0.01491553f, 0.00439387f, 0.02483255f, 0.00835458f, 0.01982277f, -0.03299119f, -0.05197103f, 
    0.02898111f, 0.06369894f, 0.07112841f, 0.01429284f, 0.00020531f, 0.00935670f, -0.01307216f, 0.04017869f, 
    0.01071204f, 0.00907464f, 0.04263850f, 0.00175232f, -0.05309227f, -0.02403728f, 0.02760497f, 0.00315205f, 
    0.00792130f, -0.01147717f, 0.05566507f, -0.02858792f, 0.00339025f, 0.00178100f, -0.07219254f, 0.03529472f, 
    -0.00830106f, 0.01676193f, 0.01677172f, -0.02399835f, 0.01522789f, -0.03269336f, 0.04968863f, -0.02674939f, 
    0.07112337f, -0.07587521f, 0.05811460f, 0.04669042f, -0.04208143f, -0.05172704f, 0.01059208f, 0.03678421f, 
    -0.00889219f, 0.03478849f, 0.04142864f, -0.03618304f, -0.00135249f, -0.04571680f, -0.05099618f, 0.05650647f, 
    -0.02530334f, -0.03529360f, 0.05282977f, -0.03101055f, -0.05884656f, -0.02121754f, -0.03419238f, 0.00726086f, 
    0.02394558f, 0.00357936f, -0.02490770f, -0.02727443f, -0.05703640f, -0.03232011f, 0.04711691f, -0.02422025f, 
    0.01461507f, 0.04928394f, -0.01942046f, 0.01634052f, 0.04677158f, -0.06003961f, -0.02863931f, 0.05671813f, 
    -0.03177684f, 0.04532398f, -0.07701287f, -0.02488318f, 0.00703849f, -0.00692631f, -0.00955008f, -0.06179570f, 
    0.01053006f, 0.01048599f, -0.02503844f, 0.05952293f, -0.03087992f, -0.07313763f, -0.03288819f, -0.01242583f, 
    -0.01049399f, -0.05563197f, 0.00354858f, 0.03023462f, 0.05123168f, -0.04988647f, -0.02478394f, -0.03434744f, 
    -0.03855587f, -0.03789172f, -0.05847947f, -0.02503046f, -0.01643780f, 0.02343852f, -0.03987132f, 0.06413215f, 
    0.00144463f, -0.05992398f, -0.00465678f, 0.03153797f, 0.04515692f, 0.01164659f, 0.02390864f, -0.06659991f, 
    -0.00480441f, -0.05849565f, -0.02104306f, -0.00762425f, 0.05820690f, 0.03228014f, 0.00868353f, -0.03463842f, 
    -0.04488121f, -0.06767169f, 0.02335612f, 0.01473449f, -0.05655843f, 0.00254051f, -0.00378192f, -0.05034770f, 
    -0.00465853f, -0.05492075f, 0.02054357f, -0.01866107f, -0.03122440f, 0.04620998f, -0.01838326f, 0.05848259f, 
    -0.07771645f, -0.07183634f, -0.01598071f, 0.00933460f, -0.00239999f, -0.06446826f, -0.05198221f, 0.04345136f, 
    -0.01213958f, -0.05391449f, 0.05885826f, -0.00541996f, -0.05773151f, 0.03696382f, -0.03295399f, -0.03731113f, 
    -0.05690112f, -0.03804561f, 0.01033176f, -0.05440082f, -0.01100660f, -0.05756629f, -0.07170362f, 0.00787302f, 
    0.20390050f, -0.20838411f, -0.00590730f, 0.01083579f, 0.02974425f, 0.01794952f, -0.02699299f, -0.18120916f, 
    -0.02758056f, -0.18875483f, 0.04559404f, -0.01899810f, -0.02287483f, -0.15390533f, 0.06623687f, 0.15421394f, 
    0.00968390f, -0.09522332f, -0.11872593f, -0.02838758f, -0.02652678f, 0.05542222f, 0.12899688f, -0.00589991f, 
    0.27131805f, 0.09745205f, 0.03411362f, -0.01161199f, 0.07729287f, 0.01636632f, 0.08236631f, 0.02588945f, 
    0.01613459f, 0.10258459f, -0.00394789f, 0.17814067f, -0.16537413f, -0.05376148f, 0.06133126f, 0.07731055f, 
    -0.01142679f, 0.04075462f, -0.04707275f, 0.00675307f, -0.02686182f, -0.06110227f, 0.16856071f, 0.16847055f, 
    -0.10648316f, 0.02703488f, 0.24523374f, 0.14282270f, 0.11688612f, -0.12207795f, -0.03521768f, -0.03233945f, 
    -0.01190145f, 0.09612018f, -0.07033522f, 0.05515901f, -0.36027929f, -0.08701468f, -0.11378707f, 0.12124441f, 
    0.15008803f, -0.11426938f, -0.01908234f, 0.14546584f, -0.03005912f, 0.05506378f, -0.00400177f, 0.11530735f, 
    0.06196903f, -0.09875356f, -0.00345469f, -0.12331202f, -0.02451559f, 0.03226354f, -0.14190362f, -0.01986782f, 
    -0.13281749f, 0.15759055f, 0.11407895f, 0.15508161f, 0.02185061f, 0.01196841f, 0.03599969f, -0.21885929f, 
    0.03922989f, 0.15906176f, -0.02711816f, 0.00354896f, -0.01756625f, -0.00667503f, -0.03324616f, -0.04218573f, 
    -0.11155609f, 0.08220982f, 0.00045838f, -0.16413356f, 0.02392951f, 0.12223031f, 0.10594755f, -0.03346112f, 
    0.15654640f, -0.04655641f, 0.01788905f, 0.16798292f, 0.07702283f, 0.03149282f, -0.13954365f, -0.05838144f, 
    0.09343700f, -0.06324771f, 0.04514569f, 0.06710952f, 0.14765900f, 0.20963803f, 0.13514744f, 0.28731558f, 
    0.07200158f, 0.01624570f, 0.05724099f, -0.08985575f, -0.01002831f, -0.10319149f, -0.02454875f, 0.14132243f, 
    0.09717302f, 0.08536974f, 0.07306225f, 0.17835745f, 0.05828841f, -0.15604006f, 0.11579426f, 0.09259877f, 
    0.20638351f, -0.10452066f, -0.01777930f, -0.00252150f, 0.00439739f, -0.01095795f, -0.07127536f, -0.00972843f, 
    0.11770470f, 0.08808868f, 0.03293841f, 0.13099110f, -0.04204735f, -0.04380425f, 0.03633858f, 0.06026891f, 
    0.01943944f, 0.03132031f, 0.03503584f, 0.05033790f, -0.31665611f, -0.23796155f, 0.12349130f, 0.09291884f, 
    0.02360902f, 0.05681325f, -0.13105635f, -0.02802791f, 0.07791103f, 0.01484860f, -0.10000968f, 0.09746270f, 
    0.03116994f, -0.00339623f, 0.02580084f, 0.03813987f, 0.07867505f, -0.02105257f, 0.06182384f, 0.00405671f, 
    0.09379283f, -0.00451496f, 0.07890821f, -0.00219977f, -0.24823749f, -0.12140635f, -0.06695004f, -0.12044317f, 
    0.03022327f, 0.02581152f, 0.08690581f, -0.05771489f, 0.07844688f, 0.04644816f, -0.10977337f, -0.07871317f, 
    -0.27047884f, -0.14966433f, -0.01262215f, 0.05952711f, -0.04900127f, -0.00179735f, 0.06993601f, 0.15543796f, 
    -0.09072188f, 0.07621536f, 0.01447424f, 0.10060067f, -0.13474843f, -0.04986361f, 0.13285604f, -0.02071445f, 
    0.11875306f, 0.04745897f, -0.01723625f, -0.17190358f, 0.09811530f, -0.00099431f, -0.09173521f, -0.09242912f, 
    0.20970188f, 0.21305448f, -0.02561994f, 0.03971476f, 0.24228080f, 0.13539842f, 0.05967757f, 0.08865409f, 
    -0.12465467f, -0.00276661f, 0.10019449f, 0.07969400f, -0.36613712f, 0.15916492f, -0.10172082f, -0.40405905f, 
    0.04074890f, 0.05136542f, -0.02965733f, -0.15705723f, -0.04929288f, 0.01711559f, -0.01490400f, 0.02150950f, 
    0.08319487f, 0.01492990f, 0.15114373f, -0.22440645f, 0.16702829f, -0.09977948f, -0.03044337f, -0.04211974f, 
    -0.05498772f, 0.05078349f, -0.00862214f, 0.00585806f, 0.30607831f, -0.00778998f, 0.14817145f, 0.05495895f, 
    -0.04861043f, -0.04965621f, 0.05954625f, 0.03582838f, 0.00980893f, -0.04286112f, 0.05340543f, 0.01796561f, 
    0.18298909f, -0.05609486f, -0.01939971f, -0.08249427f, -0.01949433f, 0.08814252f, 0.04760937f, -0.03551381f, 
    0.02621438f, -0.06149090f, -0.07312898f, -0.02500425f, -0.00912012f, 0.06811895f, 0.16882500f, 0.12613761f, 
    -0.07590654f, -0.04477173f, 0.01746779f, 0.09427646f, 0.05015874f, -0.01006406f, 0.01243269f, -0.08573583f, 
    -0.04089357f, 0.07778027f, -0.07251572f, 0.15910518f, -0.14704974f, 0.08052254f, 0.02941677f, 0.04762662f, 
    -0.01936064f, -0.05906292f, 0.03582185f, -0.07819786f, 0.09792780f, 0.00458413f, 0.09496679f, -0.01969399f, 
    -0.12439173f, -0.13100000f, 0.01224324f, 0.00017533f, -0.09556775f, -0.04612214f, 0.00262506f, -0.13465823f, 
    -0.03074629f, 0.19711530f, -0.18510126f, 0.06517327f, 0.06393577f, -0.06329194f, 0.01635140f, -0.04120686f, 
    0.09955160f, -0.06388764f, 0.01887942f, 0.02396356f, 0.14623663f, 0.10636413f, 0.15643014f, -0.04356201f, 
    0.00939629f, 0.01429156f, 0.08971380f, -0.02239059f, 0.09761682f, 0.21854746f, 0.01997878f, 0.09991906f, 
    0.31222844f, 0.00514168f, -0.03492263f, -0.14319056f, 0.07947066f, 0.07230565f, -0.10011280f, -0.02101580f, 
    -0.05246096f, -0.02342152f, 0.07410176f, 0.04954299f, 0.23115425f, -0.14875661f, -0.13187438f, 0.06035221f, 
    0.10255229f, -0.02959733f, 0.01975773f, -0.01495154f, 0.09536067f, 0.11416057f, -0.03057686f, 0.04568701f, 
    -0.17039806f, -0.00502103f, -0.04550932f, 0.08528213f, -0.08327858f, 0.02971470f, 0.11603998f, 0.17084605f, 
    0.13011797f, 0.13907175f, 0.04059983f, -0.07100247f, 0.29275650f, 0.01949891f, 0.09617577f, -0.03037660f, 
    0.12350898f, 0.13670525f, 0.00117624f, -0.00865528f, -0.05714961f, 0.07480846f, 0.05241527f, 0.07696860f, 
    -0.16702504f, -0.27236509f, -0.05321212f, 0.08379268f, 0.01150319f, -0.05137976f, 0.05919538f, -0.14866646f, 
    -0.01727801f, -0.06393417f, 0.06458981f, 0.08592346f, 0.48602432f, 0.02159417f, -0.02332064f, -0.05539411f, 
    0.10465847f, -0.12250122f, 0.03553045f, 0.01164858f, -0.09301609f, -0.00055918f, 0.09271062f, 0.02826775f, 
    0.03076079f, 0.18756214f, -0.03791576f, 0.22726133f, 0.12367371f, -0.01559357f, -0.03405630f, 0.11275418f, 
    0.13486059f, 0.02011847f, 0.02454348f, 0.07976952f, 0.03285008f, 0.22813965f, 0.15887050f, -0.11283707f, 
    0.11775454f, 0.15564844f, -0.06431823f, 0.06976531f, 0.07816326f, -0.06775087f, -0.00729307f, -0.02421916f, 
    0.38684481f, -0.03042053f, 0.30107400f, -0.14526351f, -0.00628061f, -0.07141869f, -0.05365203f, -0.04008126f, 
    0.08071315f, 0.10936579f, -0.03800025f, 0.03819794f, -0.15609971f, -0.08077098f, -0.18042685f, -0.05628387f, 
    0.08042940f, -0.01476844f, 0.01158774f, 0.13649179f, -0.04285257f, 0.10158791f, -0.00154826f, 0.07444769f, 
    -0.10678255f, -0.07488583f, -0.04048534f, 0.12577486f, 0.08981507f, 0.15441176f, -0.12869605f, -0.13095361f, 
    -0.13328964f, 0.08531868f, -0.00156908f, 0.01456741f, -0.16288973f, 0.13782567f, 0.06560954f, -0.00881269f, 
    0.21512368f, -0.04278877f, -0.09211903f, 0.18306647f, 0.04170164f, 0.05417993f, 0.00008183f, 0.07445747f, 
    -0.05424317f, 0.03828287f, -0.05172332f, 0.08501552f, 0.18125121f, 0.09179246f, -0.00386213f, -0.18530014f, 
    0.09561606f, -0.02876176f, 0.11063167f, 0.05406867f, 0.16298972f, 0.07023855f, -0.01456819f, -0.01704456f, 
    0.05364501f, -0.12419868f, -0.02104991f, -0.05931487f, 0.00040993f, 0.09000243f, 0.04991730f, 0.18072462f, 
    -0.05840943f, 0.12323282f, -0.16068494f, 0.01472442f, -0.05043704f, -0.07421221f, -0.03415392f, 0.04533819f, 
    0.10323129f, 0.15776776f, 0.04334702f, 0.04569840f, -0.07296930f, -0.07986245f, -0.01323157f, 0.00131438f, 
    0.06731508f, -0.00461689f, 0.07173599f, -0.04879105f, -0.01018331f, 0.14690717f, -0.12211917f, 0.00202528f, 
    -0.06755035f, 0.02777248f, -0.17829119f, 0.04154504f, -0.08615202f, 0.00069194f, 0.04282029f, 0.08960349f, 
    0.03946680f, -0.06334716f, 0.03284171f, -0.00441513f, 0.13077357f, -0.34338006f, -0.20117971f, 0.24325989f, 
    -0.02293186f, -0.02475230f, -0.01439498f, -0.05177799f, 0.06443642f, 0.12489600f, -0.03154851f, 0.05067118f, 
    0.06131205f, 0.18517251f, 0.11275870f, -0.04520596f, 0.16089909f, -0.15875933f, -0.06277004f, 0.04075998f, 
    -0.01796593f, 0.00452263f, 0.10134776f, -0.16243841f, -0.10950437f, -0.04058044f, -0.25397676f, -0.16925836f, 
    0.13333946f, -0.01358460f, 0.10799048f, -0.05733204f, 0.09979310f, 0.05406086f, -0.02843229f, 0.00890067f, 
    -0.08084133f, 0.18363827f, 0.00300821f, 0.06543507f, -0.01909305f, -0.11815164f, -0.10115536f, -0.02539163f, 
    -0.05222839f, -0.02786878f, -0.00290140f, -0.05288088f, 0.24936198f, -0.02516009f, -0.34137797f, 0.05640766f, 
    0.03953308f, -0.03640189f, 0.12819555f, 0.12648401f, 0.03630182f, 0.03549604f, 0.10420494f, 0.02775878f, 
    0.16076979f, -0.10830094f, 0.08162781f, -0.18327688f, -0.05871619f, -0.12966111f, -0.00067782f, 0.13489439f, 
    0.09722568f, 0.07913588f, -0.08962741f, 0.05472697f, 0.17750593f, -0.37128887f, 0.03008429f, 0.28805476f, 
    0.17138065f, 0.00369459f, -0.01321095f, -0.10079492f, 0.12276674f, -0.01743650f, -0.07022432f, 0.09298348f, 
    -0.16952449f, -0.07261062f, -0.04491708f, 0.11461499f, -0.00645608f, 0.08358499f, -0.12939186f, 0.08718333f, 
    -0.00451796f, 0.07970062f, 0.02797391f, 0.06970688f, -0.14608002f, 0.12406003f, 0.01463740f, -0.28875250f, 
    0.01305234f, -0.11768922f, -0.02238942f, -0.16856161f, 0.08323789f, 0.05151013f, -0.11866889f, 0.10465152f, 
    -0.18478064f, 0.05133786f, -0.05332571f, 0.11110090f, -0.06221073f, -0.04227450f, 0.00558729f, -0.07832252f, 
    0.11135750f, 0.04865389f, 0.06201387f, 0.03505483f, -0.07677709f, 0.11280387f, -0.10483960f, 0.21766523f, 
    0.09675066f, 0.08888059f, 0.00136298f, 0.13656248f, -0.16978413f, 0.00436413f, -0.03415500f, 0.00207265f, 
    -0.02065860f, -0.03415876f, 0.07849381f, -0.03053452f, 0.02181652f, -0.05030547f, -0.05990101f, 0.01498231f, 
    -0.10654294f, 0.02143907f, 0.20616026f, 0.06046479f, 0.05428884f, 0.02676583f, 0.04246036f, 0.05981081f, 
    0.20220877f, 0.12225603f, 0.07461409f, -0.05829475f, 0.02199105f, 0.04765118f, 0.06596973f, 0.13041434f, 
    0.00494530f, 0.14105156f, -0.12711440f, 0.32740891f, 0.04486760f, -0.05591085f, -0.06815428f, 0.04462278f, 
    0.04747539f, 0.15876256f, -0.00043788f, -0.04093995f, -0.11340814f, -0.06377763f, -0.01197276f, -0.19999312f, 
    -0.10309279f, 0.07813710f, -0.01844203f, 0.02426242f, 0.08360790f, -0.04804709f, 0.10367877f, 0.01065289f, 
    -0.05220467f, 0.03571238f, -0.07612602f, -0.06109462f, -0.02408868f, 0.04584967f, 0.07788270f, 0.00338230f, 
    0.18644482f, 0.10805746f, -0.02600081f, -0.03979077f, 0.19622672f, 0.19071685f, 0.06483332f, 0.04341714f, 
    -0.07477374f, -0.07866996f, -0.14138585f, 0.14129721f, 0.01965296f, 0.08022046f, -0.01077800f, 0.07806979f, 
    -0.00295087f, 0.09738018f, -0.02124370f, -0.09406032f, 0.02175720f, -0.11808932f, -0.13806164f, -0.03606085f, 
    -0.07198767f, -0.00260658f, 0.06285788f, -0.02906908f, -0.28030699f, 0.18081604f, -0.04996717f, 0.24374557f, 
    -0.08158545f, -0.03608866f, 0.06639346f, -0.01858283f, 0.07002029f, 0.01269798f, -0.12648609f, -0.07987559f, 
    -0.04496475f, 0.05375070f, -0.06910175f, 0.02893539f, 0.06223337f, 0.05943213f, 0.00600278f, 0.05494475f, 
    -0.05821422f, -0.03099868f, 0.06127670f, -0.01992386f, 0.02249284f, -0.05513444f, -0.03056276f, 0.05344467f, 
    0.00454892f, 0.00040363f, -0.00568952f, -0.07410397f, 0.04257226f, -0.07617339f, -0.00909187f, -0.00809493f, 
    -0.06278613f, 0.02165802f, 0.00530397f, 0.03681473f, 0.00104666f, 0.04000462f, 0.01530610f, -0.07099479f, 
    -0.03108630f, 0.06004936f, 0.00485735f, -0.07026912f, -0.07790139f, 0.05209023f, -0.04358593f, 0.04554087f, 
    -0.03123604f, 0.00025508f, 0.01328067f, -0.02259645f, -0.01735271f, -0.07438767f, -0.01205011f, -0.00420976f, 
    -0.04991005f, 0.00030953f, -0.05046606f, -0.04712001f, -0.03541495f, -0.01910043f, 0.06341758f, -0.07196018f, 
    -0.01826747f, -0.03892275f, -0.05504181f, -0.06070014f, 0.01727441f, 0.03060405f, -0.06193451f, 0.05534365f, 
    0.05222365f, -0.02508950f, 0.01759424f, -0.06414144f, -0.07729148f, -0.06161907f, -0.03151346f, -0.01052267f, 
    -0.04563046f, -0.06674344f, -0.05995930f, -0.01524688f, -0.00838517f, 0.02191741f, 0.03700455f, -0.07213592f, 
    0.02732578f, 0.03674516f, -0.07536183f, -0.02567308f, -0.06879988f, -0.03271574f, 0.00345980f, 0.03311328f, 
    0.04521809f, -0.01881495f, 0.00623162f, -0.00185954f, -0.02162035f, -0.06826573f, -0.03864961f, -0.06169548f, 
    -0.02749903f, -0.01415995f, 0.03947135f, 0.03728862f, -0.05505716f, 0.05740704f, -0.05735892f, -0.01962215f, 
    -0.06074034f, -0.04838746f, -0.06143208f, -0.00065803f, -0.02373932f, -0.03190379f, 0.02891641f, 0.05572136f, 
    -0.00227145f, -0.05591697f, 0.06368868f, -0.04784633f, -0.03744482f, -0.02773364f, -0.03580760f, -0.03039406f, 
    0.01167606f, -0.06057166f, 0.06197497f, 0.04310708f, -0.03149585f, 0.03874402f, -0.00563475f, -0.02511517f, 
    0.05034950f, -0.06735699f, -0.04493066f, 0.05155140f, -0.05133350f, 0.02664239f, 0.00839127f, 0.01368480f, 
    -0.02149973f, 0.02771119f, -0.05849634f, 0.06293520f, -0.01454550f, 0.05183676f, -0.03304737f, -0.02063839f, 
    -0.01905994f, -0.01864594f, 0.00281139f, 0.04819011f, -0.05726239f, -0.02150905f, -0.05294914f, -0.06899083f, 
    0.04069437f, -0.02528725f, 0.02687345f, -0.06033142f, -0.05068512f, -0.00107818f, -0.06960717f, -0.00676622f, 
    0.00088596f, 0.05812699f, -0.04757404f, 0.05748593f, 0.05523337f, -0.04708768f, -0.00377008f, -0.01329300f, 
    -0.04482656f, -0.06165754f, 0.03318545f, -0.06076220f, -0.05448223f, -0.07479376f, -0.07436781f, 0.04601818f, 
    -0.02611057f, -0.05718630f, 0.06449313f, 0.06153745f, 0.06436518f, 0.02389819f, -0.01806207f, -0.01135690f, 
    -0.04724127f, 0.04600716f, -0.05693417f, -0.02591832f, 0.00451685f, -0.07805943f, -0.03247799f, -0.05690434f, 
    0.32818052f, -0.06639989f, 0.00968245f, -0.03897460f, -0.05921197f, 0.13779941f, 0.09411099f, -0.00693614f, 
    0.09712836f, -0.03420651f, -0.01028570f, -0.00958843f, 0.17116387f, -0.04818799f, 0.02073531f, 0.02053663f, 
    0.03890017f, -0.03551845f, -0.11815023f, -0.00095747f, 0.01296615f, 0.11311602f, -0.05458656f, 0.06859048f, 
    0.08340802f, 0.30111161f, -0.00519145f, -0.03361994f, -0.02425627f, 0.03712422f, 0.14474002f, -0.00979153f, 
    0.09390452f, 0.02733307f, 0.07523927f, 0.09562306f, -0.10620117f, 0.14414778f, 0.07215100f, 0.08337165f, 
    0.06571528f, -0.05456187f, -0.01874744f, 0.02228743f, -0.06207316f, 0.06257545f, 0.20305911f, 0.04367027f, 
    0.17735212f, 0.07731162f, -0.01274884f, 0.12709036f, 0.09256036f, -0.06242897f, -0.01693019f, -0.06921397f, 
    0.01438196f, -0.03472603f, 0.02508247f, 0.04571972f, 0.22923307f, -0.23583110f, -0.11122330f, 0.18678367f, 
    0.02001082f, 0.08195329f, 0.06198229f, 0.02297086f, 0.00958113f, -0.05616249f, 0.06986039f, -0.05763143f, 
    0.05403654f, 0.08145110f, -0.03524205f, -0.31902388f, -0.02987163f, 0.12796772f, -0.03006906f, 0.02698871f, 
    -0.16635811f, 0.02597982f, 0.01138423f, 0.15065832f, 0.02417672f, 0.20609319f, 0.07271715f, -0.12672427f, 
    0.01425007f, -0.08048122f, 0.04909278f, -0.01725953f, 0.09803808f, -0.05992260f, -0.10455447f, 0.07865524f, 
    0.13717644f, 0.16605791f, 0.10220551f, -0.13517189f, -0.03518911f, 0.03891953f, 0.02586959f, 0.00745821f, 
    0.09649305f, -0.07829806f, 0.05656812f, -0.00011572f, 0.12445273f, -0.02585928f, -0.13868855f, -0.02157038f, 
    -0.03206889f, -0.07534845f, 0.04180800f, 0.02522239f, -0.04968985f, 0.06321847f, 0.06598542f, 0.11449842f, 
    -0.03525053f, 0.00906289f, 0.15476853f, -0.37208322f, 0.01202115f, 0.06400540f, -0.00109828f, 0.08406567f, 
    0.09828843f, 0.02880923f, 0.11851048f, 0.01569405f, -0.10964320f, -0.00082998f, 0.17329700f, 0.05470615f, 
    -0.01697740f, -0.15738605f, -0.02240612f, 0.03175169f, 0.04221679f, -0.07822580f, -0.14658955f, -0.05914467f, 
    -0.06431306f, 0.17211908f, -0.14793451f, -0.27069762f, 0.08746300f, -0.01475567f, 0.07629256f, 0.05126657f, 
    0.04752779f, 0.05546509f, -0.01566452f, 0.00464283f, -0.17145671f, -0.14081019f, -0.23774338f, -0.10772243f, 
    -0.00251058f, 0.05917643f, -0.04744072f, -0.07629331f, 0.00899583f, -0.07189659f, 0.03360923f, 0.03926372f, 
    0.13087802f, 0.10136215f, 0.09417411f, 0.06403921f, 0.07732268f, 0.03670635f, 0.06013039f, 0.14767908f, 
    0.07172468f, 0.06305016f, -0.05467517f, -0.14728220f, 0.22620647f, -0.15940754f, 0.07681546f, -0.13980810f, 
    -0.00544184f, 0.05568933f, 0.07262289f, -0.05898202f, 0.14011173f, -0.05503386f, 0.01135845f, -0.01921189f, 
    -0.28256008f, 0.05112217f, 0.08542158f, 0.10027755f, 0.03548889f, 0.00286931f, 0.02284698f, -0.11858095f, 
    -0.04316385f, 0.11691932f, -0.01493936f, 0.14003208f, -0.02690012f, 0.07126027f, -0.09818758f, 0.02291103f, 
    0.00426152f, -0.00732400f, 0.06318291f, 0.00905428f, -0.12324747f, -0.06553926f, 0.06210415f, 0.04421685f, 
    -0.03570940f, 0.01668818f, -0.11584963f, 0.27865052f, 0.13130489f, -0.12154195f, -0.05564376f, 0.10009140f, 
    0.11628537f, -0.02312198f, -0.14315674f, 0.08222890f, -0.16554058f, -0.19691445f, 0.11855330f, -0.07305641f, 
    0.08961959f, 0.02721745f, -0.00654649f, -0.12051667f, -0.02295844f, -0.15820734f, 0.06043006f, 0.16087081f, 
    0.03425578f, -0.11991993f, 0.27289712f, -0.05652682f, 0.07250524f, -0.02896361f, 0.02186525f, -0.00145932f, 
    -0.04033714f, 0.07135475f, -0.01792807f, -0.03177188f, 0.02195478f, 0.05146414f, 0.21329929f, -0.26033336f, 
    0.12873673f, -0.02476277f, 0.15681815f, -0.02320525f, 0.08961519f, 0.12565276f, -0.05028635f, 0.11609985f, 
    0.02273807f, -0.07765698f, 0.01300888f, 0.13207994f, 0.06639692f, -0.00600587f, -0.14230765f, -0.06219933f, 
    0.12310138f, 0.09956078f, 0.05040253f, -0.02241469f, 0.02597515f, -0.01780922f, -0.03148803f, 0.16810465f, 
    0.03043745f, 0.13686433f, -0.15649140f, -0.02191089f, 0.03847618f, 0.02862909f, 0.05831594f, -0.02077225f, 
    -0.04079959f, 0.13446982f, -0.18458667f, 0.15143648f, 0.12326869f, 0.12584169f, 0.00275187f, -0.08100352f, 
    0.06197701f, -0.05728798f, 0.00721419f, -0.01346876f, -0.05533407f, -0.10654625f, 0.10448220f, -0.08932112f, 
    -0.05440727f, -0.09441859f, 0.04659793f, 0.05207584f, -0.01763348f, 0.08872107f, 0.05133799f, 0.17691416f, 
    -0.03682777f, 0.19764204f, -0.31129262f, 0.23928769f, 0.09578642f, -0.10138766f, -0.13265198f, -0.06707928f, 
    -0.04750133f, 0.08588113f, -0.09894992f, -0.02198187f, 0.07216829f, 0.00475241f, -0.01159727f, -0.01172145f, 
    0.09090078f, 0.10591557f, 0.05984708f, -0.10955229f, 0.06403980f, 0.08174372f, 0.02325288f, 0.03150766f, 
    0.17194651f, 0.05503889f, -0.04616311f, 0.20427202f, 0.05356393f, -0.09921866f, -0.05598369f, 0.05600162f, 
    0.06107960f, -0.07116113f, 0.07832725f, -0.01235846f, 0.21840519f, -0.12515870f, 0.11352372f, 0.22071365f, 
    0.02377952f, -0.02701296f, -0.01190742f, -0.00396309f, -0.03755489f, 0.19362633f, -0.05949316f, -0.04574935f, 
    -0.03557567f, 0.04052272f, -0.12733687f, -0.21872371f, -0.08266933f, 0.01721912f, -0.11432157f, 0.03334183f, 
    -0.10316049f, -0.04702967f, -0.00656810f, -0.13069992f, 0.01902715f, 0.10472827f, -0.02091119f, -0.04035417f, 
    0.06482255f, 0.10464832f, 0.05824545f, -0.11290523f, 0.09817812f, 0.05593064f, -0.11817510f, -0.04995335f, 
    -0.07647500f, -0.12120376f, -0.12229434f, 0.13991222f, 0.00020155f, 0.07189208f, 0.07250366f, 0.11375118f, 
    0.01870585f, 0.10159568f, -0.04923860f, 0.09204262f, -0.45142803f, 0.00721269f, 0.31013343f, 0.10142124f, 
    0.01977887f, 0.07268963f, -0.02722917f, -0.21114811f, 0.09645490f, -0.07576383f, -0.04703554f, -0.03371675f, 
    -0.33207968f, 0.02876834f, -0.20304354f, 0.05714474f, 0.06416757f, 0.06958416f, -0.03108387f, -0.10616901f, 
    -0.14729004f, 0.02834897f, 0.19611718f, 0.00045072f, 0.02471586f, 0.08210588f, 0.17459011f, -0.11900993f, 
    -0.11624450f, -0.07030562f, 0.05413759f, 0.13610141f, 0.04373506f, 0.04402524f, 0.05973408f, 0.06422484f, 
    0.17887184f, 0.03365409f, 0.15263180f, -0.29699466f, -0.00181673f, -0.05463364f, 0.14403684f, 0.00513919f, 
    0.01426952f, -0.05792075f, -0.03779811f, -0.05746024f, 0.07982101f, 0.04518282f, 0.01692587f, 0.13637502f, 
    0.08289357f, -0.02038732f, 0.05839964f, 0.11213289f, 0.03283992f, -0.13698810f, 0.13692236f, -0.02583377f, 
    0.09985735f, 0.17009489f, -0.09490500f, -0.04172166f, 0.00129466f, 0.02055359f, 0.09699144f, 0.01676582f, 
    0.13531996f, -0.07635144f, -0.05799282f, -0.09108717f, -0.10876065f, -0.12352850f, 0.04378404f, 0.02816976f, 
    -0.05525966f, 0.03434108f, 0.05974629f, -0.07426269f, 0.16325673f, -0.08799856f, 0.14766340f, -0.03300522f, 
    0.01352791f, -0.07428101f, -0.05870783f, 0.22258316f, -0.09390550f, 0.01463785f, 0.13970535f, -0.02522740f, 
    -0.04885087f, 0.07045747f, -0.10995244f, -0.04903562f, 0.06407361f, -0.09839875f, 0.13230972f, -0.04082934f, 
    -0.11669036f, -0.05690588f, 0.06237934f, 0.10836650f, -0.04284156f, -0.07139650f, 0.03240579f, -0.21049911f, 
    -0.03287503f, -0.00510363f, 0.24149443f, -0.10540748f, -0.03079138f, 0.07763232f, 0.07713171f, 0.09249318f, 
    -0.01911610f, -0.14319834f, -0.07319130f, -0.00248917f, 0.09922875f, 0.22174235f, 0.14850882f, -0.12383869f, 
    0.13855064f, 0.07417550f, 0.07349099f, 0.16990522f, 0.08096035f, 0.11784862f, 0.06334080f, 0.09364302f, 
    0.05103568f, -0.11886287f, 0.05068239f, -0.08448964f, 0.04147385f, 0.14455278f, -0.06298658f, 0.00871471f, 
    0.01307208f, -0.02546540f, -0.01917369f, 0.07031553f, 0.04444185f, 0.07486594f, -0.25920719f, -0.14614697f, 
    0.08180279f, -0.03003693f, 0.24978063f, -0.09288667f, 0.01604302f, -0.02175251f, 0.12776904f, -0.06144544f, 
    -0.27689150f, -0.30218488f, -0.00103983f, 0.07484982f, -0.04625626f, 0.07051795f, 0.10467219f, 0.03221858f, 
    0.05785220f, -0.00724440f, 0.06949687f, 0.11991963f, -0.10857896f, -0.08446479f, 0.08767502f, -0.12259439f, 
    0.08297057f, 0.03715597f, -0.04010171f, 0.03450059f, -0.04733578f, 0.01474100f, 0.14766879f, 0.10254104f, 
    -0.29573607f, 0.31657425f, -0.01760754f, -0.35447577f, -0.00508368f, -0.01504796f, 0.05845436f, -0.11290833f, 
    0.03341929f, -0.04659722f, -0.06942790f, 0.01800813f, 0.04018278f, 0.12488687f, -0.01148043f, 0.23944424f, 
    -0.05828568f, -0.01482387f, 0.02368095f, 0.03534327f, -0.04282642f, -0.01715286f, -0.01089575f, 0.07664028f, 
    -0.33738223f, -0.05018571f, -0.01710337f, 0.20528349f, 0.01392446f, -0.12326785f, 0.04484800f, 0.09409348f, 
    0.13841903f, 0.03565718f, -0.07689596f, -0.02109589f, 0.11753122f, -0.25345790f, 0.15583570f, 0.24723631f, 
    -0.13143896f, 0.01491817f, -0.04641780f, -0.07445886f, 0.01531462f, 0.01548218f, -0.04275108f, 0.19851308f, 
    -0.10257601f, 0.02053829f, 0.00928278f, 0.17215303f, 0.04507003f, -0.00097424f, 0.02882362f, 0.02578773f, 
    -0.04563277f, 0.07239146f, 0.08818766f, -0.02999679f, -0.20387018f, -0.03365617f, 0.05077020f, -0.03888661f, 
    0.00325226f, 0.03212846f, -0.03049348f, -0.10700763f, -0.10796736f, 0.01762589f, 0.00623492f, 0.01041741f, 
    -0.03551961f, -0.03718760f, 0.04189020f, -0.06865674f, 0.12214528f, 0.02645606f, 0.00314569f, 0.05663378f, 
    -0.07361239f, 0.03610750f, 0.02395811f, 0.00898530f, 0.03215634f, -0.27174771f, -0.20059337f, -0.14818388f, 
    -0.01226811f, 0.05907597f, -0.06627785f, 0.02003505f, 0.06049938f, 0.09878804f, -0.10634516f, 0.04075423f, 
    -0.05331529f, -0.11217865f, -0.13537338f, -0.22881207f, 0.02579647f, 0.13307115f, -0.09463356f, 0.09651393f, 
    0.08980098f, 0.01462082f, -0.01258951f, 0.04581802f, -0.15353560f, -0.01940630f, 0.11114725f, 0.06266946f, 
    0.07579477f, 0.10200924f, -0.08124073f, -0.16420294f, 0.02319929f, -0.00755385f, -0.03865445f, 0.24999794f, 
    0.16429372f, 0.15725869f, 0.04530026f, 0.22002761f, 0.01196426f, 0.05747116f, 0.03978448f, 0.00865056f, 
    -0.04244622f, 0.06304932f, 0.04599210f, 0.07147364f, -0.06098898f, 0.19957638f, -0.10596747f, 0.12977943f, 
    -0.02705451f, 0.03775802f, 0.05587522f, -0.04966224f, 0.11391560f, -0.01580333f, 0.01501273f, 0.04000720f, 
    0.00185695f, -0.03739608f, 0.07222531f, 0.28374329f, 0.05693964f, 0.01671457f, -0.03280474f, 0.15502471f, 
    -0.01198275f, 0.09137994f, -0.00523769f, -0.04161972f, -0.38030997f, 0.16412619f, 0.23951133f, 0.14273246f, 
    0.08649243f, 0.02801836f, -0.04862400f, 0.07039537f, -0.01455103f, 0.07712501f, 0.04072240f, 0.02696691f, 
    0.23775463f, -0.01413698f, -0.11815128f, -0.25648928f, 0.06828286f, -0.08086845f, -0.12125371f, -0.04711624f, 
    -0.02588763f, -0.03571379f, 0.01183839f, -0.02069458f, 0.01815767f, 0.06480639f, -0.07988740f, 0.00341723f, 
    0.01922883f, -0.09452462f, 0.11049862f, 0.13233088f, 0.04638771f, 0.06722018f, -0.10723467f, -0.07497204f, 
    0.16865219f, 0.42465207f, 0.04053244f, -0.06780623f, 0.01472925f, 0.10160157f, -0.03235024f, -0.11229482f, 
    0.03355221f, 0.01069188f, 0.00991311f, -0.00409280f, 0.21394061f, 0.14892361f, -0.08968999f, 0.06455880f, 
    -0.14949678f, 0.07408916f, 0.05612865f, 0.13299008f, -0.01520162f, -0.04330920f, 0.04708678f, 0.09398701f, 
    -0.31870964f, -0.13929859f, 0.07429530f, -0.08311523f, -0.15040554f, -0.00763713f, 0.07845022f, -0.04918970f, 
    0.07028332f, 0.05924906f, -0.06415781f, -0.18554832f, 0.31790793f, -0.22044292f, -0.03275259f, 0.20782435f, 
    -0.00712002f, -0.04638802f, -0.01907356f, 0.01326226f, 0.07575004f, 0.09783114f, -0.05751245f, 0.03476397f, 
    -0.03331977f, 0.02470379f, -0.29436994f, 0.15497610f, -0.16357499f, 0.02228621f, 0.08389233f, 0.11238048f, 
    -0.01553939f, -0.03335415f, 0.03788344f, 0.07079750f, -0.10605752f, 0.09213374f, 0.00599077f, -0.01284590f, 
    0.04067946f, 0.08087792f, -0.12343600f, -0.07426197f, -0.01461245f, 0.00571483f, -0.04567896f, 0.03269375f, 
    -0.18000011f, 0.08318908f, 0.07820798f, 0.06749009f, -0.00911644f, -0.12997742f, 0.06399874f, 0.01653372f, 
    -0.01108485f, 0.06636132f, -0.01505968f, 0.12343199f, -0.00716736f, -0.10232563f, -0.11290330f, -0.05870448f, 
    0.12273922f, -0.00339055f, 0.08832750f, 0.03882316f, -0.03399670f, 0.06305400f, -0.06415943f, 0.03858673f, 
    0.16232756f, -0.22105344f, -0.02213803f, -0.16778456f, -0.00117713f, -0.05227789f, -0.07562197f, 0.04376655f, 
    -0.00947363f, 0.04421647f, 0.10758638f, 0.04049215f, -0.08955516f, -0.06508602f, 0.15132308f, 0.09341270f, 
    0.04260704f, 0.14575019f, -0.08798417f, -0.04072872f, 0.01351636f, -0.06591509f, -0.03279797f, 0.09907188f, 
    0.18725930f, -0.03787909f, 0.16692913f, 0.09007586f, 0.06627338f, 0.08695386f, 0.07739990f, 0.04441398f, 
    -0.01475499f, 0.04430768f, 0.02240580f, 0.04694716f, -0.07546734f, 0.08796541f, -0.24542034f, 0.06059501f, 
    -0.07858481f, -0.01859230f, -0.06956419f, 0.05223072f, 0.01820384f, -0.13166088f, 0.00371524f, -0.08631921f, 
    -0.11107948f, -0.01359951f, 0.13552292f, 0.11639629f, 0.03921220f, -0.03356643f, 0.06114261f, 0.00122516f, 
    0.00477196f, 0.15192667f, -0.00183850f, -0.07202932f, -0.26296565f, 0.36585227f, 0.07628304f, -0.03402379f, 
    0.00504988f, 0.09056265f, -0.01229576f, 0.09054374f, 0.04379419f, -0.00031748f, 0.08050967f, -0.04963815f, 
    0.22577614f, 0.08975705f, -0.05952790f, -0.00206751f, 0.06289525f, -0.01484361f, 0.00706056f, -0.09487221f, 
    -0.00089714f, -0.10962336f, -0.06337656f, -0.00924765f, -0.08738712f, 0.29809439f, -0.10667625f, 0.12500286f, 
    -0.04224551f, -0.03151555f, 0.10458836f, 0.11323681f, 0.04884753f, 0.00508597f, -0.04268319f, 0.00115680f, 
    0.00352384f, -0.00308365f, -0.01390481f, 0.04866030f, 0.01659105f, 0.06201446f, -0.06293274f, 0.05783876f, 
    0.05499279f, -0.06954885f, -0.05417874f, -0.03016403f, -0.01850063f, -0.02699685f, -0.05451839f, -0.06041801f, 
    -0.01543923f, -0.04804943f, -0.03936940f, -0.06622250f, 0.00931304f, 0.04038895f, 0.02921314f, 0.01282083f, 
    0.00766869f, 0.04933617f, -0.03851520f, -0.03055502f, -0.03718954f, 0.03450153f, -0.04425784f, 0.00698291f, 
    0.01349607f, 0.00814141f, -0.04017138f, 0.02007598f, 0.06396958f, 0.01099070f, -0.07222683f, -0.01020192f, 
    -0.03002911f, -0.03180835f, 0.02322827f, -0.03850647f, 0.02507332f, 0.05117589f, -0.07151596f, -0.02525300f, 
    -0.01233350f, 0.01388701f, -0.07075244f, -0.02439977f, 0.04320559f, -0.05218410f, -0.00141954f, -0.01719122f, 
    -0.03288933f, -0.01738991f, 0.01645679f, -0.03304565f, -0.02532932f, 0.03198289f, 0.01768365f, -0.07181846f, 
    0.04772063f, -0.05453368f, -0.01915680f, -0.04418357f, 0.02729374f, 0.03519403f, -0.00952232f, -0.03305493f, 
    0.00770150f, -0.00105399f, -0.01143793f, 0.04363687f, 0.05103952f, 0.02251459f, -0.03784603f, -0.04493457f, 
    -0.05995405f, 0.03548548f, -0.07361975f, -0.07188424f, -0.05985984f, -0.05776126f, -0.05200122f, -0.02576212f, 
    -0.02711572f, -0.01372277f, 0.02681693f, 0.01225880f, 0.05286026f, -0.04569079f, 0.03610345f, -0.03476900f, 
    -0.01579744f, -0.05833470f, 0.06707274f, 0.00255428f, -0.02043784f, 0.04262028f, -0.02429159f, 0.03341407f, 
    0.04020243f, -0.03813161f, -0.07690246f, 0.05725519f, -0.02526285f, 0.03123624f, 0.00472402f, 0.06621023f, 
    -0.02522242f, -0.05739409f, 0.03151656f, -0.02803683f, -0.04414874f, 0.03657402f, 0.01516439f, 0.06420895f, 
    -0.01922199f, -0.02065569f, -0.02390219f, -0.07065552f, -0.07590674f, 0.00857608f, -0.01894773f, 0.06375020f, 
    0.05728312f, 0.02869665f, -0.00043286f, 0.00393117f, 0.02534717f, -0.02176373f, 0.01236300f, -0.03480761f, 
    -0.03423578f, 0.03791165f, -0.03310996f, -0.04623213f, -0.04653782f, -0.06005112f, 0.03892356f, -0.07192701f, 
    -0.07159662f, 0.03752561f, 0.00083104f, -0.01964963f, 0.02054670f, -0.01070445f, -0.06260816f, -0.03087995f, 
    0.00303439f, -0.06032931f, -0.02696064f, 0.01142933f, -0.01119377f, 0.06143910f, -0.00823539f, -0.02647501f, 
    0.03110691f, -0.04218092f, -0.03603978f, 0.05409183f, -0.02762882f, -0.04065179f, -0.03896265f, 0.02705756f, 
    -0.05196389f, 0.01006629f, 0.01593814f, -0.05566396f, -0.06879892f, -0.05007498f, 0.06308774f, 0.03593279f, 
    0.05712750f, -0.00210509f, 0.04294157f, -0.07201952f, 0.04158395f, 0.01192392f, 0.04580101f, -0.07602179f, 
    -0.05896642f, 0.02578904f, -0.04428717f, 0.00604389f, 0.04906541f, -0.03987959f, -0.03220451f, -0.06421851f, 
    -0.34679759f, 0.17702137f, -0.08466083f, -0.12983179f, -0.01595677f, 0.05500982f, 0.13850303f, 0.02734207f, 
    -0.10395227f, 0.16022655f, -0.06234685f, 0.06155409f, -0.19033337f, 0.18748602f, 0.15458243f, 0.02435973f, 
    0.00280351f, 0.00917497f, 0.13021550f, -0.15940803f, 0.06649762f, 0.04632685f, -0.04532944f, 0.02889797f, 
    -0.50988197f, 0.00602802f, -0.06094979f, 0.22229651f, 0.22692345f, 0.00618240f, 0.01382835f, -0.10921597f, 
    -0.01182694f, -0.03730258f, 0.13654494f, -0.16278599f, 0.11608075f, 0.08036986f, 0.21739186f, 0.10431966f, 
    0.04611152f, 0.02149021f, -0.07439240f, -0.06822486f, 0.12730250f, 0.06673810f, 0.06504750f, 0.12720332f, 
    0.06320813f, 0.03493227f, 0.17091823f, -0.24630103f, -0.01844591f, 0.03100157f, 0.13997211f, -0.11366201f, 
    -0.10884365f, 0.00434349f, 0.02357740f, -0.01915473f, 0.34851518f, 0.02436661f, -0.03655182f, -0.30481902f, 
    -0.06462407f, 0.04790771f, 0.01051467f, 0.19056429f, -0.01802606f, 0.06883644f, 0.04098834f, -0.07708997f, 
    -0.06032579f, -0.11901790f, -0.35936424f, -0.00919880f, 0.14399062f, 0.08901288f, 0.08619381f, -0.00013083f, 
    0.06790031f, 0.02847134f, 0.00068549f, -0.08824150f, 0.18385220f, -0.46703026f, -0.09314234f, 0.16707458f, 
    -0.02501252f, -0.08295969f, -0.06864008f, 0.08117778f, 0.27715895f, -0.07093528f, 0.09408762f, -0.05901373f, 
    -0.28763989f, -0.28239933f, -0.17038803f, 0.34563074f, 0.05484676f, 0.06077243f, 0.07432080f, 0.13174486f, 
    -0.02958319f, 0.02240637f, 0.06818516f, 0.04976306f, 0.10971203f, -0.03963882f, 0.23335938f, -0.03098304f, 
    -0.06280009f, -0.11584719f, -0.02143281f, -0.11170456f, -0.01050897f, -0.14458187f, -0.10223354f, -0.01810882f, 
    0.10036939f, -0.02696825f, -0.09337860f, 0.37917179f, 0.10155268f, -0.07308655f, 0.01126309f, 0.01374068f, 
    0.00970645f, -0.02358374f, 0.02180670f, 0.01438685f, -0.03745897f, 0.26667437f, -0.17543870f, -0.28354645f, 
    0.01555636f, 0.04746824f, 0.05946440f, 0.10852827f, 0.08984932f, -0.00334526f, -0.01524525f, 0.13871475f, 
    -0.07316324f, -0.19023180f, -0.17965029f, -0.02673706f, 0.03308890f, 0.06493477f, 0.03708656f, -0.04235900f, 
    -0.04584325f, 0.12724872f, 0.01092600f, -0.01987998f, 0.16791445f, 0.27354169f, -0.25145769f, -0.06632718f, 
    -0.02429506f, 0.02945104f, 0.22615662f, -0.01303489f, 0.03011322f, 0.06602310f, 0.06740449f, -0.12400045f, 
    -0.00666405f, -0.09129162f, -0.03352768f, -0.07360054f, -0.04375355f, -0.06324200f, -0.08544382f, 0.14644110f, 
    0.07975668f, 0.13136761f, -0.12422586f, 0.05351876f, 0.24554327f, -0.23887077f, -0.20846067f, -0.02236497f, 
    -0.01531557f, -0.10417304f, 0.02401146f, 0.10901923f, -0.02259700f, -0.00530602f, -0.05733778f, -0.01450095f, 
    0.00647304f, -0.02294497f, -0.02169567f, -0.04144003f, 0.04522192f, -0.01168856f, -0.00928959f, 0.05822207f, 
    0.01604051f, -0.05283307f, 0.05637771f, 0.04732364f, 0.01663584f, -0.04432118f, -0.05168336f, 0.02594760f, 
    -0.06842416f, -0.02003196f, -0.03432994f, 0.06560999f, -0.00329724f, -0.01232966f, -0.01626346f, -0.00280732f, 
    -0.01279300f, -0.03394262f, 0.01370222f, -0.03817003f, 0.06026560f, -0.04667368f, 0.00703820f, 0.00959899f, 
    -0.05668134f, 0.01551363f, -0.01264930f, -0.04529080f, -0.04793595f, 0.01179522f, -0.03878753f, -0.07113016f, 
    -0.02286159f, -0.05073624f, 0.05118444f, 0.03354004f, -0.00458618f, 0.03075416f, 0.01933886f, -0.04977776f, 
    -0.00791884f, -0.05198376f, 0.01117363f, 0.04236556f, -0.04067251f, -0.04447585f, 0.04584553f, 0.05088362f, 
    -0.02848325f, 0.01834158f, 0.01572493f, 0.06292599f, 0.00502062f, -0.03454153f, 0.01761135f, 0.05560155f, 
    -0.04731542f, -0.01120041f, 0.04427100f, 0.04081671f, -0.04497701f, 0.02783229f, 0.01217497f, -0.01413855f, 
    -0.07624326f, -0.00490029f, 0.05117525f, 0.03438242f, 0.05711513f, 0.01513208f, 0.05981807f, 0.00615656f, 
    -0.07540359f, -0.07161342f, 0.01309977f, -0.03112720f, -0.00157331f, 0.02854728f, 0.02456736f, -0.05298879f, 
    0.00466452f, -0.05101400f, -0.04071603f, -0.03115471f, -0.07823326f, -0.00466691f, -0.04272544f, -0.01537326f, 
    -0.04388186f, -0.00189582f, 0.02095202f, 0.04785258f, -0.00377226f, 0.04552892f, -0.06687426f, 0.01003704f, 
    0.03096659f, 0.01056591f, 0.03116910f, -0.06065628f, 0.05371231f, -0.06324682f, -0.06486909f, 0.02907674f, 
    -0.05889975f, 0.01794932f, -0.00391296f, 0.04486898f, -0.04526311f, 0.05807903f, -0.01328805f, 0.04714210f, 
    -0.07472100f, -0.07077070f, -0.03221449f, -0.07630987f, 0.01415057f, -0.04854904f, -0.03327473f, -0.06136616f, 
    -0.06134688f, 0.04811018f, 0.06455996f, 0.01080805f, -0.01221573f, 0.01812095f, -0.01191293f, -0.00143722f, 
    -0.04665864f, -0.04461367f, -0.00571007f, 0.05430568f, -0.04782557f, 0.00589443f, -0.01732820f, -0.06347149f, 
    -0.06812327f, -0.00027697f, -0.03857227f, -0.07034691f, 0.02901101f, -0.05521625f, -0.04610940f, 0.01928731f, 
    -0.03010293f, 0.05670872f, 0.01206995f, -0.04215385f, 0.03072953f, -0.04099712f, 0.02780379f, 0.06491861f, 
    0.02394287f, -0.06792507f, 0.04604287f, 0.03332858f, 0.02208508f, -0.04784976f, 0.04980146f, -0.05464108f, 
    0.05796899f, -0.07211201f, -0.07825392f, -0.02945110f, -0.05474318f, 0.04711919f, -0.00290759f, -0.00975483f, 
    -0.07332299f, -0.04736905f, -0.05451323f, 0.05060003f, -0.03203822f, -0.02346903f, -0.07198426f, 0.06360876f, 
    -0.07812629f, 0.01799609f, -0.03108002f, -0.07915805f, -0.06347996f, 0.05203680f, 0.01755883f, 0.01517877f, 
    0.07072259f, -0.13683374f, 0.00357623f, 0.20597886f, -0.08981453f, -0.06880561f, 0.07269190f, 0.00227807f, 
    -0.00792658f, 0.02935804f, -0.01126070f, 0.06637246f, -0.18990590f, -0.16197738f, 0.03764931f, -0.02029095f, 
    0.11076184f, 0.11533549f, 0.07715995f, -0.10417379f, 0.03070819f, 0.02588348f, 0.08717979f, -0.11495452f, 
    0.46361583f, 0.14920184f, 0.01831981f, -0.09741611f, 0.03308502f, -0.02356106f, 0.08348108f, 0.03163037f, 
    0.02963782f, 0.07895470f, -0.04360891f, 0.23372719f, 0.11518317f, -0.04838093f, 0.05281676f, 0.07057618f, 
    0.05233119f, 0.10110289f, -0.00257993f, -0.07988844f, -0.02263282f, 0.01250234f, 0.09947044f, 0.02885937f, 
    -0.00126130f, -0.09982339f, 0.02901934f, -0.09918893f, 0.24682856f, 0.07335293f, -0.07735762f, -0.03746008f, 
    -0.07052000f, 0.11510225f, 0.00129586f, -0.13532394f, -0.29825687f, -0.13976835f, 0.03045279f, -0.11044883f, 
    0.03182453f, -0.24339144f, -0.06528243f, -0.05024998f, 0.02860442f, 0.12198327f, -0.12420762f, 0.11222784f, 
    0.00121099f, -0.02733070f, 0.00350196f, 0.03463750f, -0.09468221f, -0.11535909f, -0.03704224f, 0.07638094f, 
    0.19621271f, 0.02313334f, 0.04370247f, 0.02066326f, -0.00518143f, 0.05951725f, 0.02088014f, 0.07527898f, 
    -0.26713052f, -0.02556850f, 0.02262229f, 0.16030817f, 0.01621668f, -0.02515783f, -0.07478192f, -0.08086307f, 
    -0.19200751f, 0.23065817f, 0.11590118f, 0.10679292f, -0.13796610f, -0.05170441f, 0.09148015f, 0.08582710f, 
    0.04821288f, 0.02672084f, 0.03710153f, 0.11279879f, -0.06005208f, 0.07864439f, -0.04434257f, -0.05732892f, 
    -0.00046889f, -0.11326528f, -0.10225639f, 0.00965026f, 0.05874488f, 0.03345105f, 0.07969775f, -0.05441485f, 
    -0.39663953f, -0.22124854f, -0.14675052f, 0.07471000f, -0.01421639f, -0.04132041f, -0.03843627f, 0.02520496f, 
    0.00752918f, 0.09681061f, -0.09760238f, 0.04801911f, -0.05065921f, -0.34220758f, 0.12655832f, -0.02300348f, 
    -0.02341844f, -0.04220468f, -0.04778305f, 0.03371883f, 0.18328360f, 0.14340509f, 0.05408846f, 0.23931210f, 
    -0.13022444f, -0.27960339f, 0.03810708f, 0.00160454f, -0.12848091f, -0.00300261f, 0.11552094f, 0.09219639f, 
    0.06716055f, -0.01604014f, 0.11116520f, 0.14916420f, 0.24875577f, -0.07935631f, 0.12626970f, -0.09394432f, 
    0.06433405f, -0.08110218f, 0.07318743f, -0.03253562f, -0.01079476f, 0.06745839f, -0.08124416f, 0.14754546f, 
    0.01909765f, 0.26128373f, -0.01862381f, 0.11450163f, -0.11213039f, 0.02586537f, -0.08130342f, 0.09200379f, 
    0.06177638f, 0.09242126f, 0.00921480f, -0.03154632f, -0.37645921f, -0.19341804f, 0.00392786f, 0.06138684f, 
    0.02255658f, 0.00196422f, 0.04825510f, -0.00572606f, 0.04408806f, 0.06039831f, 0.07248564f, -0.06604950f, 
    0.26789498f, 0.11491638f, -0.14221023f, -0.26681575f, 0.07212637f, -0.00942808f, -0.06819822f, 0.17520338f, 
    0.06872471f, 0.08500627f, 0.05179445f, -0.07991351f, 0.07480364f, 0.09528492f, -0.10817155f, 0.22770096f, 
    -0.19602121f, 0.07666123f, 0.01601961f, 0.04879536f, 0.00120362f, -0.06718627f, 0.00039943f, 0.05367515f, 
    0.24020369f, -0.00102992f, -0.02169962f, 0.15273917f, -0.14765909f, -0.03780612f, -0.05130252f, -0.10987592f, 
    -0.03763761f, 0.08458807f, 0.04188999f, -0.00408684f, 0.12853445f, 0.05101836f, 0.05946232f, 0.00137553f, 
    -0.05810843f, -0.28071478f, -0.06174415f, -0.13243963f, -0.14961876f, -0.06813984f, -0.04520075f, 0.02876132f, 
    0.09603750f, 0.06795573f, -0.03622544f, 0.36638314f, 0.04678997f, -0.05270037f, -0.00000611f, 0.16995320f, 
    0.05864878f, 0.05812716f, 0.06116563f, -0.04331718f, -0.11849598f, -0.00739437f, -0.03910559f, 0.20516758f, 
    -0.01390244f, -0.06609106f, 0.04129649f, 0.00278323f, 0.06511095f, -0.03566584f, 0.09950478f, -0.09465608f, 
    -0.31476393f, -0.04844194f, -0.03850115f, -0.01875165f, -0.12060401f, -0.04484502f, 0.07575016f, 0.06671627f, 
    0.28528073f, -0.03072050f, -0.09156780f, 0.00458979f, -0.02377553f, 0.05170975f, -0.19815384f, -0.22054486f, 
    0.05887151f, -0.04979023f, 0.17059335f, 0.01342174f, -0.00837047f, 0.06210510f, -0.03490962f, 0.10628198f, 
    0.19254851f, -0.05237820f, 0.06518764f, -0.47066456f, 0.15214092f, -0.02091938f, -0.01235659f, 0.03666916f, 
    0.05772354f, 0.03492837f, 0.01246697f, 0.05441516f, -0.12593316f, 0.00366822f, -0.13358566f, 0.06387156f, 
    0.13252126f, 0.09428684f, -0.07864891f, 0.09894961f, 0.00892940f, 0.00993408f, -0.11108641f, -0.25240037f, 
    0.13331088f, 0.10108303f, 0.15796979f, -0.10534739f, 0.02082550f, 0.09405863f, 0.03457456f, -0.02218663f, 
    -0.00240821f, -0.08812427f, 0.01271893f, -0.05261567f, -0.09774269f, -0.15556261f, -0.11228896f, 0.13641657f, 
    0.09837598f, -0.02737164f, 0.07273798f, 0.04471830f, -0.14992298f, 0.08136669f, 0.09228483f, -0.01903537f, 
    -0.27935570f, -0.06973437f, 0.12488790f, 0.13518985f, -0.01219794f, -0.09497314f, -0.16534340f, -0.11956191f, 
    0.09900656f, -0.05769816f, -0.08681552f, 0.13078716f, -0.04486856f, 0.10486563f, 0.30331236f, 0.27527925f, 
    0.13664681f, 0.09576945f, -0.04499386f, 0.04781793f, -0.10010666f, 0.00482490f, 0.10602199f, 0.12434070f, 
    -0.06579451f, -0.04662786f, -0.09543339f, -0.18863122f, 0.00824093f, 0.15547456f, 0.08816906f, -0.01836047f, 
    0.07583966f, 0.01289089f, -0.02089798f, 0.08476523f, -0.03577797f, 0.11092252f, -0.09972303f, -0.18757601f, 
    0.01417646f, 0.03547827f, -0.00259030f, 0.17975090f, -0.05450954f, 0.15498172f, -0.01557954f, 0.04413255f, 
    -0.04844318f, 0.30649975f, -0.04693082f, -0.06975031f, -0.13527238f, -0.02805880f, -0.00763732f, 0.00240549f, 
    -0.02570759f, -0.02405154f, 0.07296401f, -0.09361807f, 0.28376165f, 0.04966034f, -0.21510327f, 0.04830452f, 
    0.09353056f, -0.00924964f, 0.01408840f, 0.05271959f, 0.12850899f, 0.01953294f, 0.03848293f, 0.02083679f, 
    -0.20590824f, -0.05566477f, 0.13922808f, -0.16891433f, -0.07546699f, 0.00863672f, 0.08458967f, 0.17431609f, 
    0.13361911f, 0.02244982f, -0.07261486f, -0.06347969f, 0.29385138f, -0.39790243f, -0.15379687f, 0.25372797f, 
    0.10428955f, -0.04392013f, -0.00408250f, -0.04979355f, 0.09607572f, 0.13946161f, 0.02275489f, 0.09513093f, 
    -0.24325646f, -0.09454434f, -0.23272416f, 0.10480027f, -0.10996126f, 0.04267705f, -0.01225009f, 0.06514428f, 
    0.00323785f, 0.06010518f, -0.01017664f, 0.09617404f, -0.07033414f, 0.16883434f, 0.00227224f, -0.18424134f, 
    0.10054110f, 0.00479348f, -0.03777011f, -0.07965940f, -0.02759335f, 0.02657855f, -0.04543328f, 0.10542813f, 
    0.05098728f, 0.09825011f, 0.08663344f, -0.08446105f, -0.00204383f, -0.09973200f, 0.05568038f, -0.09592316f, 
    -0.13348082f, 0.08625539f, 0.01539559f, 0.11110111f, -0.09502395f, -0.01511077f, -0.16783668f, 0.06401036f, 
    0.08962210f, -0.00454822f, 0.04007666f, 0.01744425f, -0.02822787f, 0.05443947f, -0.03671913f, 0.01707461f, 
    0.13668717f, -0.17395656f, -0.00990274f, -0.05934112f, 0.06765911f, -0.04246869f, -0.09990350f, -0.00233688f, 
    0.02134212f, 0.05964630f, 0.06115581f, -0.01808026f, 0.01469317f, -0.01683966f, 0.11391125f, 0.16842782f, 
    0.12287876f, 0.03840590f, 0.02322870f, 0.01690038f, -0.08718821f, -0.03298104f, 0.04967214f, 0.25371718f, 
    0.10542169f, 0.02345243f, -0.08169515f, 0.19833057f, 0.02544638f, -0.01685628f, 0.02739944f, 0.08411819f, 
    0.07571603f, 0.21951441f, 0.03543790f, 0.00250058f, -0.00485405f, 0.08734349f, -0.09906397f, -0.08971154f, 
    -0.12068474f, -0.02766625f, 0.05252705f, 0.05113846f, 0.09190164f, -0.03994519f, 0.06303167f, -0.00440525f, 
    0.04080065f, 0.17157944f, 0.07622973f, -0.07783718f, 0.03862879f, 0.08140855f, -0.02184804f, -0.06833444f, 
    0.02048789f, 0.11564794f, -0.01060663f, -0.09890985f, -0.23020570f, 0.56315207f, -0.03855633f, 0.00486814f, 
    -0.07323906f, 0.12610807f, -0.11100273f, 0.12071934f, 0.00090490f, -0.01276838f, 0.13125618f, -0.02025217f, 
    0.05532140f, 0.02675500f, -0.01948614f, -0.04480163f, 0.07786447f, -0.15490188f, -0.00657185f, -0.02838510f, 
    -0.01870667f, -0.11812170f, -0.01692507f, 0.00699828f, -0.24913217f, 0.26304376f, -0.15837276f, 0.21445164f, 
    -0.15435001f, -0.04653535f, 0.18735436f, -0.03610218f, 0.05684416f, -0.00699257f, -0.01782461f, -0.02501268f, 
    0.04063365f, -0.02680775f, -0.00678494f, 0.06443943f, -0.00627441f, -0.04201652f, 0.00721957f, -0.07331517f, 
    0.02871300f, -0.02219079f, -0.01086773f, -0.01569123f, 0.02944377f, -0.00982269f, 0.02982911f, 0.02544989f, 
    -0.01843262f, -0.00832443f, 0.00198104f, -0.03728875f, -0.01983174f, 0.06017348f, 0.01468394f, -0.07032096f, 
    -0.07137004f, -0.03351625f, -0.01635640f, 0.00495982f, 0.05021529f, 0.04319108f, -0.07862559f, -0.00039419f, 
    -0.01690278f, -0.04798054f, -0.01483485f, 0.00124854f, -0.03732074f, 0.03452302f, 0.06114618f, -0.07404704f, 
    0.05962048f, -0.06383537f, 0.01150724f, -0.03397715f, -0.00387408f, 0.03014378f, -0.03929647f, 0.02751241f, 
    -0.07583347f, -0.01544305f, -0.00493564f, -0.02439861f, -0.03071430f, -0.02269210f, 0.04968730f, 0.06043112f, 
    0.03510128f, -0.04460573f, -0.07143450f, -0.00720870f, 0.01546329f, 0.04724374f, -0.00576894f, 0.03065226f, 
    0.04936152f, -0.04481246f, -0.00877059f, -0.06444757f, -0.05935214f, 0.00054243f, -0.03617960f, -0.01399282f, 
    0.03413658f, -0.04615585f, -0.03892522f, 0.01434228f, -0.06508651f, 0.00486928f, -0.03177404f, -0.07516897f, 
    -0.01155341f, -0.07721063f, -0.01414916f, 0.01842157f, 0.05233146f, -0.01721185f, -0.04195911f, -0.04821141f, 
    0.02056767f, -0.08060211f, 0.05207182f, 0.00538487f, -0.01930614f, 0.02228716f, -0.01847077f, 0.05532553f, 
    0.02847068f, -0.01302155f, -0.05722582f, 0.01246773f, -0.01537729f, 0.03649088f, 0.04470107f, -0.02552263f, 
    0.04829713f, -0.05537706f, -0.04468281f, 0.02772004f, 0.06043933f, -0.01107498f, -0.03331302f, 0.01209005f, 
    0.03336692f, -0.01010962f, -0.01713213f, -0.00459142f, 0.04290320f, -0.03067735f, 0.02278108f, 0.00829886f, 
    0.02483348f, -0.01538086f, 0.06331765f, -0.04358338f, -0.01918172f, -0.01754417f, -0.07795408f, 0.03772226f, 
    -0.04110004f, -0.00362733f, -0.08068141f, 0.04013825f, -0.05493807f, -0.02094945f, -0.03703910f, -0.05939193f, 
    0.05433154f, 0.00251537f, -0.03928657f, -0.06040847f, -0.01907166f, 0.03323573f, -0.02686015f, 0.01994905f, 
    0.04708793f, 0.01594248f, -0.07266309f, 0.02311252f, -0.04433984f, -0.06917845f, 0.02618754f, 0.05331106f, 
    -0.04552904f, -0.04403720f, 0.01128089f, -0.04249188f, -0.06545861f, -0.04584618f, -0.04819682f, 0.05175808f, 
    0.02078080f, 0.00174811f, -0.02816200f, -0.03694491f, 0.04191797f, -0.02773983f, -0.03993993f, 0.01502333f, 
    -0.00052743f, -0.03219345f, -0.03730083f, -0.03126000f, 0.06077874f, 0.03903659f, -0.07449806f, 0.05012371f, 
    0.05736212f, 0.03347060f, 0.03226960f, -0.05389151f, -0.00729504f, -0.06311616f, -0.03665359f, -0.07183061f, 
    0.02644327f, 0.05807763f, 0.04378033f, -0.07453157f, 0.00147787f, -0.04034830f, -0.05215747f, -0.07365017f, 
    0.04888902f, -0.04423232f, -0.04410021f, -0.00394371f, -0.00510177f, -0.01353184f, 0.01264261f, -0.03635069f, 
    -0.02215965f, -0.03225107f, -0.07725000f, 0.06745883f, 0.06031111f, -0.01991891f, -0.03175954f, 0.00305391f, 
    -0.07530073f, -0.01420207f, 0.03147226f, -0.04427850f, -0.01641701f, 0.03688421f, -0.01438785f, -0.07092113f, 
    -0.01338521f, -0.02256282f, -0.04135172f, -0.05358261f, 0.06539663f, 0.05701910f, -0.03760812f, -0.04920430f, 
    -0.01014367f, 0.01749485f, -0.01308310f, 0.06393447f, -0.00882516f, 0.00688723f, 0.04466726f, -0.03814070f, 
    -0.05156002f, -0.05909938f, -0.03952209f, -0.00214248f, 0.06202983f, -0.04508084f, 0.01942655f, -0.05528735f, 
    -0.04303976f, -0.06448912f, -0.01491204f, 0.04087960f, -0.06077955f, -0.03794258f, 0.04136151f, -0.05893595f, 
    0.03924244f, 0.06126555f, -0.04330688f, -0.00733980f, 0.05816160f, 0.03210133f, -0.02882208f, 0.02875683f, 
    -0.02200984f, -0.06719004f, -0.01642843f, -0.05273327f, 0.01773736f, 0.03351093f, -0.04996203f, 0.02158773f, 
    -0.04280749f, 0.00380608f, 0.01712201f, 0.00150316f, 0.00903661f, -0.07474792f, 0.06617388f, 0.06385364f, 
    -0.04435030f, -0.00074047f, -0.00464209f, -0.04732706f, 0.03250923f, 0.02769944f, 0.00092961f, 0.05015830f, 
    0.04005538f, -0.07859465f, 0.00561032f, -0.02793094f, 0.05519001f, -0.04871941f, 0.00927689f, -0.07705812f, 
    -0.04550981f, -0.01423478f, 0.05886095f, 0.02263812f, 0.01128178f, -0.01329262f, 0.02491826f, 0.03333811f, 
    -0.07146328f, 0.02218723f, 0.00043400f, 0.02170501f, -0.02526717f, 0.06523585f, -0.06471442f, 0.02676564f, 
    0.04429210f, -0.00144492f, -0.06924058f, -0.07171291f, 0.04223066f, -0.02516831f, 0.02123889f, -0.01765663f, 
    0.02015441f, -0.07176284f, -0.02144715f, -0.01687077f, 0.01018632f, -0.05279535f, 0.05949617f, -0.03958662f, 
    -0.00166269f, 0.00529571f, 0.02558494f, 0.06074500f, 0.06082533f, -0.00430747f, 0.02404495f, -0.05808427f, 
    -0.02610356f, -0.04051583f, -0.05996397f, -0.06868581f, 0.02373759f, 0.05511508f, -0.01723496f, -0.05953141f, 
    -0.06458460f, -0.05008183f, -0.06544757f, -0.03794426f, 0.01320080f, 0.06418982f, -0.03814325f, 0.04485375f, 
    0.06088405f, -0.05312751f, 0.02795303f, -0.01772629f, 0.01033121f, -0.05958511f, 0.01016336f, 0.05901609f, 
    -0.03209614f, 0.04045137f, 0.01479029f, -0.05202395f, 0.02677254f, -0.03943264f, 0.02873208f, -0.07082788f, 
    -0.00936133f, -0.03099805f, -0.04574586f, -0.03311099f, 0.02825780f, 0.00460732f, -0.05793395f, 0.01877042f, 
    -0.00604339f, 0.05040405f, 0.01150909f, -0.04997754f, -0.07566247f, -0.05453997f, 0.05076353f, 0.03516195f, 
    -0.03664893f, -0.04322024f, 0.02924531f, -0.04783129f, 0.06691781f, 0.02811485f, -0.01185869f, -0.01748203f, 
    -0.31347811f, 0.21391584f, 0.05594489f, -0.22933583f, -0.26280904f, 0.07303852f, 0.12323276f, 0.07244556f, 
    0.17757379f, 0.00397640f, 0.06714121f, -0.32100019f, 0.34979394f, 0.43953571f, -0.46721962f, 0.11238734f, 
    0.09130229f, -0.01004855f, 0.04110906f, 0.02966006f, 0.11786309f, 0.17242324f, 0.06728614f, 0.01022123f, 
    0.39782649f, -0.03994302f, -0.07559191f, -0.02545522f, -0.01386355f, 0.08470289f, 0.01013344f, 0.07344704f, 
    -0.00158297f, -0.07461623f, 0.13362905f, 0.12186950f, 0.21690232f, -0.24055228f, -0.18493903f, 0.07965747f, 
    -0.32465610f, -0.16848610f, -0.10781534f, 0.01545453f, 0.19173014f, -0.07379039f, -0.06744543f, -0.04591784f, 
    0.06010908f, -0.27707419f, -0.25741589f, 0.17004623f, -0.10304757f, -0.07487615f, 0.06817646f, 0.07947555f, 
    -0.01872650f, 0.03504915f, 0.18247497f, -0.02486077f, -0.11620215f, -0.08106125f, 0.20134157f, 0.01193312f, 
    0.09766756f, -0.10712662f, 0.18570824f, -0.03978610f, -0.20085567f, 0.10194718f, 0.15339740f, -0.13901542f, 
    -0.18378735f, 0.05039568f, 0.05992335f, -0.22864078f, 0.04254206f, 0.11822502f, -0.00126517f, 0.03324696f, 
    -0.16894303f, -0.22352618f, 0.08796652f, -0.02077651f, -0.07148168f, -0.03121146f, -0.00462144f, -0.20828019f, 
    -0.05749946f, -0.04237689f, 0.05018849f, 0.13048880f, -0.11466195f, -0.00352085f, -0.09737546f, -0.07212684f, 
    -0.24877259f, 0.01723439f, -0.14355832f, -0.23951010f, -0.11885047f, -0.12858459f, -0.12622063f, 0.15507878f, 
    -0.07982005f, -0.10863776f, 0.06125546f, 0.04519258f, -0.28439307f, -0.09793362f, 0.02781695f, 0.11707441f, 
    0.19567585f, 0.17447592f, 0.08719850f, -0.06790005f, -0.26242277f, -0.03909847f, -0.21013975f, 0.08375633f, 
    -0.02035273f, 0.18005183f, -0.08436202f, -0.13030563f, -0.03231225f, 0.18745843f, -0.07044039f, 0.05722496f, 
    -0.00332902f, 0.11293311f, -0.08306065f, -0.06341963f, 0.05586458f, -0.04926838f, 0.22276717f, 0.10462310f, 
    -0.11771012f, 0.18419224f, 0.05689595f, 0.01784945f, -0.02115530f, -0.02355823f, 0.10881224f, 0.11683457f, 
    -0.13035972f, -0.01221825f, 0.08941614f, -0.10683835f, -0.00017166f, 0.02261041f, 0.10095392f, -0.00328557f, 
    0.15110061f, -0.03970309f, -0.23098430f, -0.03603749f, -0.14354649f, 0.41292384f, 0.12597746f, 0.07342668f, 
    0.19876780f, 0.07323880f, 0.12123410f, -0.00409973f, 0.01753191f, 0.06504173f, 0.19596413f, -0.14553992f, 
    0.03234167f, -0.01596636f, 0.09997209f, -0.20448783f, -0.21997072f, 0.07165560f, 0.03531865f, -0.00620149f, 
    0.00302083f, 0.09645020f, -0.10964662f, 0.03041093f, 0.07655098f, -0.06574523f, -0.00102808f, 0.05830061f, 
    0.16016236f, 0.00694656f, 0.16021837f, 0.00707007f, 0.03925870f, -0.11892327f, 0.10325997f, -0.00903352f, 
    -0.19710885f, 0.02556467f, 0.02810715f, 0.14807500f, 0.03142943f, -0.10662570f, 0.02195273f, 0.02955338f, 
    -0.08600635f, 0.08198624f, 0.03193077f, -0.04362559f, -0.00138679f, 0.02652797f, -0.04234400f, -0.13757886f, 
    0.04432071f, 0.00728220f, 0.17008087f, 0.03837074f, -0.05184898f, 0.03821088f, 0.10679518f, -0.09611411f, 
    0.03812661f, -0.03886681f, 0.06152038f, 0.16400848f, 0.04712412f, -0.01754109f, -0.06085123f, 0.11396556f, 
    0.00929581f, -0.00761232f, -0.02399117f, -0.01203383f, -0.17337127f, -0.12159459f, -0.12216496f, -0.24621852f, 
    0.20499119f, -0.00397804f, 0.05041022f, -0.07974773f, -0.00808399f, 0.09446026f, -0.07934791f, 0.03758997f, 
    0.11190011f, -0.14701329f, 0.12676668f, -0.14059286f, -0.00551815f, 0.04628209f, -0.03800626f, 0.00652153f, 
    -0.04481573f, 0.02525987f, 0.10059072f, 0.06392375f, 0.10381925f, 0.10756867f, 0.20679158f, -0.13495873f, 
    0.14140746f, 0.01130632f, -0.06165279f, -0.08376455f, 0.16373181f, 0.02897967f, 0.01251012f, -0.04337871f, 
    -0.10283476f, -0.03712844f, -0.00563621f, 0.23611529f, -0.05016440f, -0.13939986f, -0.05201362f, 0.02238644f, 
    0.10003098f, 0.00018888f, -0.04052240f, -0.08674482f, -0.13828731f, 0.14757207f, 0.02450360f, 0.19016016f, 
    -0.00002970f, -0.11841638f, 0.06103876f, 0.03750379f, -0.04381789f, 0.01018310f, -0.00161702f, 0.04676593f, 
    0.03163937f, 0.05597898f, -0.11153107f, 0.17415832f, -0.02241682f, -0.08965905f, -0.04777193f, -0.01485733f, 
    0.00852140f, 0.06287065f, 0.07090595f, 0.00477131f, 0.04843381f, 0.04692451f, 0.18019320f, -0.02142192f, 
    -0.04564360f, -0.01897450f, 0.05219296f, -0.01835739f, -0.02442600f, 0.07267048f, -0.00235728f, -0.01758418f, 
    -0.02026407f, 0.18598084f, -0.15673861f, 0.34251487f, 0.10631490f, 0.01760771f, -0.07744190f, -0.08521626f, 
    -0.00863080f, -0.06105534f, 0.02880841f, 0.07224241f, 0.17629024f, -0.08411901f, -0.11532664f, -0.04490152f, 
    -0.04692410f, 0.04271935f, 0.03341240f, -0.13079561f, 0.00290180f, 0.11737550f, 0.12572777f, 0.02004928f, 
    0.17407119f, 0.05658199f, -0.03300148f, 0.09470747f, -0.05263571f, -0.05163159f, -0.14637466f, -0.10395049f, 
    -0.08028415f, -0.05147063f, -0.01485007f, -0.04429001f, 0.45206273f, 0.03080308f, 0.00761622f, 0.25676563f, 
    0.07824343f, -0.09678944f, -0.02758588f, 0.06015137f, 0.17205229f, 0.10044196f, 0.05204188f, 0.05709116f, 
    -0.15555568f, 0.05367030f, -0.05813704f, -0.08930060f, -0.11025210f, 0.06566672f, 0.09148914f, 0.11192093f, 
    -0.10722406f, 0.05772131f, 0.09097442f, 0.01232884f, -0.07141598f, 0.10383780f, 0.05348216f, 0.16273911f, 
    0.00776484f, -0.05468893f, 0.04831116f, -0.00544546f, 0.01305065f, 0.04534288f, 0.06205368f, 0.09541034f, 
    0.22284666f, 0.17518479f, -0.16951673f, 0.00108929f, 0.05665717f, 0.08525421f, 0.08266698f, 0.09052461f, 
    -0.05069132f, 0.07484017f, 0.00273771f, 0.05287607f, -0.07978106f, -0.02814406f, 0.05854480f, -0.04739920f, 
    -0.10823066f, 0.14954831f, -0.06067056f, -0.06666695f, 0.01542268f, -0.02762175f, 0.01092092f, -0.01428281f, 
    0.05831105f, -0.17105491f, 0.03298453f, -0.22589323f, -0.19252828f, 0.24673979f, -0.01706373f, 0.02429565f, 
    -0.06184341f, 0.15870745f, -0.01262039f, 0.08759655f, 0.15216169f, -0.23930576f, -0.14523642f, -0.05699432f, 
    -0.03125538f, -0.09509325f, -0.24047622f, -0.29328507f, -0.08703417f, 0.01031467f, -0.10260314f, 0.01220103f, 
    -0.18697286f, 0.00164607f, -0.20773199f, 0.12646002f, -0.06101444f, 0.10029335f, -0.16792713f, -0.02898396f, 
    0.00193336f, -0.07154331f, 0.05203984f, 0.06595808f, -0.11513849f, 0.17599621f, 0.08997957f, -0.15819578f, 
    0.11559171f, -0.16062970f, -0.10030758f, -0.02449100f, 0.08547368f, -0.00647860f, 0.07889778f, -0.05585745f, 
    -0.00989169f, 0.15292685f, 0.03079410f, 0.14852017f, -0.01404924f, -0.13694397f, 0.09022876f, 0.08484045f, 
    -0.00351650f, -0.06600204f, -0.12161344f, -0.10153779f, -0.11578564f, 0.22038257f, -0.20706479f, -0.05418920f, 
    0.01916204f, 0.20659095f, 0.16952728f, -0.05518080f, -0.08128417f, 0.03221285f, 0.05276586f, -0.02353902f, 
    0.12641303f, -0.02561728f, -0.03184020f, -0.04644021f, 0.01455837f, -0.11067157f, 0.05961255f, -0.04035966f, 
    0.06652254f, 0.03452555f, 0.02101837f, 0.09427696f, -0.20539735f, -0.06940708f, -0.13271312f, -0.06952370f, 
    0.15161407f, 0.02104158f, -0.00136356f, 0.10475314f, -0.04621515f, -0.10798520f, 0.01147443f, -0.24768494f, 
    0.09214372f, -0.09327192f, 0.11087120f, 0.23662460f, 0.09314865f, -0.01588770f, 0.05651898f, -0.05059824f, 
    -0.02010741f, -0.07423136f, 0.07603958f, -0.10254830f, 0.25573140f, 0.04324840f, -0.16499488f, 0.08722247f, 
    0.08699186f, 0.02679815f, 0.06572344f, 0.06900502f, -0.12824929f, -0.00258945f, 0.15670249f, 0.01866700f, 
    0.10443233f, 0.13597141f, 0.26701692f, 0.09552702f, -0.07229587f, -0.05657767f, 0.02724047f, -0.12200856f, 
    0.03078230f, 0.10040588f, 0.01059572f, 0.00853607f, 0.00746883f, 0.29110694f, 0.46770123f, 0.03758014f, 
    0.00882465f, 0.07813084f, -0.17701274f, -0.06517965f, 0.01471881f, -0.00211343f, 0.09128764f, 0.18946551f, 
    -0.00135520f, 0.04763773f, -0.27037907f, 0.02081523f, -0.06741208f, 0.10351460f, 0.16211520f, -0.02719801f, 
    -0.03428772f, 0.01073347f, 0.03142296f, 0.15008406f, -0.35304147f, 0.28879979f, 0.08939599f, 0.10014509f, 
    0.04525685f, 0.16456343f, 0.13001718f, 0.11588136f, -0.02282202f, 0.03500291f, 0.11298977f, 0.03874800f, 
    -0.05679900f, -0.00892470f, 0.05157933f, 0.01061049f, 0.01665096f, 0.05832665f, -0.03720597f, -0.04139001f, 
    -0.06534019f, -0.02183563f, 0.00721400f, -0.03490401f, 0.05862757f, -0.08077642f, -0.02324118f, 0.00618653f, 
    -0.04007178f, -0.07092844f, 0.04672924f, 0.02208406f, 0.01579608f, 0.04037742f, 0.00355460f, -0.00677999f, 
    0.00863036f, 0.04473289f, -0.00467278f, -0.08055070f, 0.03193295f, -0.02478468f, 0.01163645f, -0.03125105f, 
    -0.01195647f, -0.07090502f, -0.03465938f, 0.05871150f, -0.02990220f, -0.03783346f, -0.01036180f, -0.01214966f, 
    0.03981761f, 0.05503519f, -0.06007365f, 0.01947359f, -0.04215123f, -0.07092083f, -0.04153569f, -0.04750904f, 
    -0.03902617f, -0.03226932f, 0.05093718f, 0.05715044f, 0.05701297f, -0.03337313f, -0.02380255f, -0.00477033f, 
    -0.04766598f, -0.03107980f, 0.04031717f, -0.06740537f, -0.02103372f, 0.03330807f, -0.01810169f, -0.02595895f, 
    -0.00209553f, 0.03792009f, -0.03312410f, 0.04581132f, -0.05457443f, -0.03069432f, 0.04755000f, -0.01921830f, 
    -0.07919377f, -0.07720223f, -0.00481975f, -0.00737793f, -0.01222404f, -0.04996658f, 0.02636505f, 0.02868867f, 
    0.01914151f, -0.01301138f, 0.00140129f, 0.01620856f, 0.02452788f, -0.05396564f, -0.08280942f, 0.01082267f, 
    0.00993301f, 0.02587928f, -0.03715256f, 0.00290512f, -0.02249242f, -0.06633195f, -0.01596949f, 0.02188868f, 
    0.04339365f, -0.00717627f, -0.04169083f, 0.02874304f, -0.05872850f, -0.06140903f, -0.05024775f, 0.01288928f, 
    -0.01864571f, -0.01475276f, -0.02778697f, 0.02454990f, 0.02507260f, 0.00355755f, 0.03875398f, 0.03825155f, 
    -0.07482176f, 0.04516903f, 0.01860300f, -0.07037599f, -0.02549830f, -0.04442352f, 0.04648859f, 0.00692518f, 
    -0.02532224f, -0.03183454f, 0.03925142f, -0.06213064f, 0.01366310f, 0.01612317f, 0.05644919f, 0.04564936f, 
    -0.07464946f, 0.04573073f, 0.02688549f, 0.02191735f, -0.03501150f, -0.01572892f, -0.05027547f, 0.04186364f, 
    -0.07092055f, -0.01778515f, -0.01292957f, -0.04968528f, 0.02923529f, -0.00217520f, -0.02550347f, 0.05670096f, 
    -0.05908457f, -0.05163611f, -0.05670009f, -0.04474311f, -0.07262547f, 0.01580629f, 0.05610386f, 0.04889584f, 
    0.02015056f, -0.07708591f, 0.01333251f, -0.06299398f, 0.05085809f, 0.05100464f, -0.01056988f, 0.05437025f, 
    0.05806084f, 0.02441256f, -0.04956326f, -0.05805108f, 0.05196829f, -0.03416755f, -0.06479136f, -0.05449386f, 
    -0.00933222f, 0.00702063f, 0.00958376f, 0.00583752f, -0.03166093f, 0.05293005f, -0.05245154f, 0.00292345f, 
    -0.01782012f, -0.01734093f, -0.04244766f, -0.03267213f, -0.08090348f, 0.04413610f, -0.07851287f, -0.06365814f, 
    -0.02951870f, -0.08315520f, 0.04715959f, -0.01687654f, 0.03304620f, 0.01228917f, -0.06578844f, 0.00017347f, 
    0.04653956f, 0.24061915f, -0.00988072f, -0.14743344f, -0.01863728f, 0.07856679f, 0.01402197f, -0.00269029f, 
    0.00981015f, 0.05341082f, -0.05482602f, -0.00950143f, -0.29413041f, 0.13239537f, 0.16779749f, 0.21811517f, 
    -0.01761699f, 0.14596176f, -0.00840870f, -0.02362246f, 0.04142667f, -0.05082728f, -0.13506940f, 0.06262638f, 
    -0.14873834f, -0.10670469f, -0.00762487f, -0.07989746f, -0.05417916f, 0.02603813f, 0.07278736f, -0.17291734f, 
    -0.06238142f, 0.01186876f, 0.13169877f, -0.12100437f, 0.07594579f, -0.06799656f, -0.02078790f, 0.16541068f, 
    -0.16124509f, -0.07799594f, 0.03757336f, 0.05550386f, 0.06498735f, 0.10851104f, 0.06840876f, -0.00280319f, 
    -0.19143169f, 0.09588506f, -0.07025827f, 0.15856624f, -0.00212335f, -0.05721951f, 0.19049181f, 0.02034216f, 
    -0.04737667f, -0.09961946f, 0.07933480f, 0.06270208f, 0.01260145f, 0.13377689f, -0.02784737f, 0.19733684f, 
    -0.03954299f, -0.01242611f, 0.04927853f, -0.02668371f, -0.00628823f, -0.15366456f, 0.11586457f, -0.01809786f, 
    0.03993495f, 0.18195908f, 0.02773580f, -0.20896135f, -0.16492125f, -0.11564276f, 0.18138890f, 0.01923650f, 
    0.11839148f, -0.03742456f, -0.03661200f, 0.07020877f, 0.14409199f, -0.24244726f, -0.01225642f, -0.15044588f, 
    -0.13432789f, -0.04538045f, 0.03492840f, -0.13853562f, 0.06074295f, -0.01705356f, -0.00315539f, 0.06511687f, 
    0.14805089f, -0.16065672f, 0.03763285f, -0.04379677f, -0.09375689f, -0.00762427f, -0.05136202f, 0.06214407f, 
    -0.09618451f, 0.05724769f, -0.00323583f, 0.04590995f, -0.00160346f, -0.04453552f, 0.05220226f, 0.21504927f, 
    -0.04358003f, 0.10977441f, -0.08443795f, 0.08460081f, -0.07330409f, 0.02182545f, 0.02234707f, -0.09061151f, 
    0.22646822f, 0.05428408f, 0.22125004f, -0.17168070f, -0.01456230f, 0.15161009f, 0.09653216f, -0.03939630f, 
    -0.01729063f, -0.08128951f, 0.08184323f, 0.05008430f, 0.06534867f, 0.11407670f, 0.04356438f, -0.00386272f, 
    -0.00258350f, 0.00941804f, -0.00546348f, 0.10114063f, 0.04819621f, 0.01775221f, 0.06453925f, 0.04869880f, 
    -0.03421998f, 0.06380849f, 0.12245350f, -0.00978894f, 0.14178531f, 0.10249955f, 0.00852435f, 0.05903101f, 
    0.01099793f, 0.07306188f, -0.11303420f, 0.09959257f, -0.33214200f, 0.33670655f, -0.08073426f, -0.18441921f, 
    0.02562644f, 0.01801389f, 0.11891586f, 0.07122512f, -0.02085122f, -0.09776121f, 0.10151468f, -0.06685137f, 
    0.05232369f, -0.20571367f, 0.04614415f, 0.07548939f, 0.00059203f, 0.10070086f, 0.10963377f, -0.02046263f, 
    0.11863003f, 0.02051632f, -0.02064036f, 0.15873294f, -0.03919991f, 0.02943683f, 0.00243780f, -0.10311866f, 
    0.02114648f, 0.04079282f, -0.04036416f, 0.01613882f, 0.00080821f, -0.03009356f, 0.06850988f, 0.11691574f, 
    0.02099524f, -0.11140515f, 0.01228531f, -0.17885654f, 0.08436039f, 0.03236036f, 0.04352079f, 0.32306588f, 
    0.01281153f, 0.04386739f, -0.03200199f, 0.10107185f, -0.05109700f, -0.07148539f, 0.10062379f, 0.04987011f, 
    -0.01964685f, 0.01373400f, -0.02575678f, -0.06217112f, 0.04538444f, 0.00815431f, -0.04450551f, 0.06812380f, 
    0.07140185f, 0.10140273f, -0.06073331f, 0.08100779f, 0.03961894f, 0.12971354f, 0.04720932f, -0.09151325f, 
    -0.12352204f, 0.02628939f, 0.15935968f, 0.04795523f, -0.09916624f, 0.13794981f, -0.03903817f, -0.04480649f, 
    -0.04321880f, 0.01578933f, 0.05900257f, 0.03521352f, 0.00068246f, -0.01356927f, 0.05999745f, -0.17607108f, 
    -0.03375832f, -0.04655167f, 0.01131513f, -0.01295776f, 0.08647145f, -0.09536766f, 0.03755445f, -0.06814468f, 
    0.04903623f, -0.03291956f, 0.06672862f, 0.00032664f, 0.38148344f, -0.01357558f, 0.21138366f, 0.11242583f, 
    -0.11150640f, 0.06294700f, -0.00264768f, -0.03774971f, -0.00709448f, 0.00276714f, -0.04220672f, 0.01168009f, 
    0.10495055f, 0.16031685f, 0.09218222f, -0.04265427f, 0.02847635f, 0.05455722f, 0.10073299f, 0.11253987f, 
    0.12560828f, -0.23928657f, -0.07970077f, -0.08263142f, 0.10567766f, -0.08154295f, 0.12371082f, 0.02369704f, 
    0.04421338f, 0.06129223f, -0.06682918f, 0.00404338f, 0.12735327f, -0.04026309f, 0.06288210f, -0.03444698f, 
    -0.10807362f, 0.06170202f, 0.18964736f, 0.12302396f, -0.10669636f, 0.04971049f, -0.03396139f, 0.12570587f, 
    -0.04772009f, 0.00664569f, -0.03853054f, -0.00113779f, -0.03475840f, 0.02964949f, -0.03788894f, 0.00647794f, 
    -0.06474139f, -0.04057236f, 0.08099047f, 0.02581158f, -0.09465097f, -0.02227046f, -0.01850607f, -0.25019088f, 
    0.04606925f, -0.00837496f, 0.06097534f, -0.14325127f, 0.01674829f, 0.14092566f, -0.01355913f, 0.00686932f, 
    -0.01083962f, -0.15150665f, 0.07309616f, -0.02079861f, -0.10073691f, -0.04149646f, 0.12642018f, 0.00984951f, 
    -0.00942302f, -0.05139209f, -0.08291414f, 0.01456068f, -0.06256878f, 0.04205129f, 0.03896253f, -0.10545281f, 
    -0.03841847f, -0.09078372f, -0.11023895f, -0.07680117f, 0.08628935f, 0.06007389f, -0.13342613f, 0.00767108f, 
    -0.04105200f, -0.10440630f, 0.05803729f, -0.04971851f, 0.07285313f, -0.20979829f, -0.03126298f, 0.00091993f, 
    0.13082373f, 0.02059647f, 0.13831070f, -0.14706308f, -0.00768272f, -0.16094728f, 0.10444032f, -0.05141513f, 
    -0.11045298f, -0.25392482f, 0.02366361f, -0.02041092f, -0.02306741f, 0.12414588f, 0.04028242f, 0.12358779f, 
    0.10725658f, 0.19172248f, 0.01027794f, 0.01498599f, 0.42681605f, -0.31448156f, 0.23009714f, 0.03337821f, 
    0.17777628f, 0.10762288f, -0.10596142f, 0.02342522f, -0.13288623f, -0.07904573f, 0.05690013f, 0.05707013f, 
    -0.14093341f, 0.20656252f, -0.17608853f, -0.08997745f, 0.09385801f, 0.04595951f, 0.02995726f, 0.01874710f, 
    0.04255155f, 0.07323796f, -0.07368946f, 0.03556935f, -0.16921055f, 0.07553861f, 0.00516389f, 0.08025898f, 
    -0.05241914f, 0.08129554f, 0.06623008f, -0.08016750f, 0.04559783f, -0.12991913f, -0.06831917f, -0.00630950f, 
    -0.14702533f, -0.05011431f, 0.01577595f, 0.21094635f, -0.11675058f, 0.09516010f, -0.04835410f, -0.06837066f, 
    -0.08322448f, 0.02431158f, -0.07234434f, 0.07224851f, -0.01988296f, 0.03432465f, 0.10758451f, -0.05706671f, 
    0.04402707f, -0.07341936f, -0.10383750f, -0.13442154f, 0.00324335f, 0.05778098f, 0.00748396f, 0.09671466f, 
    0.16631070f, -0.04164504f, 0.12772952f, -0.00193772f, 0.01808624f, -0.01687025f, 0.09273489f, -0.08711755f, 
    0.00730994f, 0.03010305f, -0.04730104f, -0.04425741f, 0.00270392f, 0.13871124f, 0.13967966f, -0.17467922f, 
    0.13132860f, -0.15925585f, 0.03317415f, -0.03254833f, 0.11410031f, -0.05251589f, -0.01406375f, -0.15190031f, 
    0.00655506f, 0.01758767f, 0.04177472f, 0.19795430f, -0.10486206f, -0.20010164f, -0.00160334f, 0.15513590f, 
    0.27403706f, -0.02067340f, -0.06393901f, -0.05138097f, -0.07360132f, 0.02541253f, -0.07735203f, -0.03537381f, 
    -0.08415574f, 0.04404318f, 0.09692500f, -0.21521668f, -0.05524290f, 0.01232441f, 0.20169353f, -0.02831648f, 
    0.16703016f, -0.08283714f, -0.14489700f, -0.01925018f, -0.00183356f, 0.01098848f, 0.05848240f, -0.09164461f, 
    0.07280119f, 0.04302595f, -0.08018598f, 0.05305703f, -0.08217661f, -0.08735475f, -0.07090290f, 0.00511624f, 
    0.07820249f, 0.02210612f, 0.00458217f, 0.00961552f, 0.01585911f, 0.05245319f, -0.19931701f, -0.24486502f, 
    0.09273811f, 0.11618510f, 0.07351133f, 0.15290536f, 0.03527738f, 0.07271059f, 0.04196867f, -0.13053557f, 
    -0.14522223f, -0.09751771f, 0.06536209f, -0.03327533f, 0.20880853f, 0.01717288f, 0.02231514f, 0.02348549f, 
    0.09215393f, 0.06608484f, 0.07154500f, 0.01885815f, -0.12192680f, 0.06241614f, 0.08520297f, -0.02515561f, 
    0.15079762f, 0.09822880f, 0.09633947f, 0.27819115f, -0.02565347f, -0.06881255f, -0.16970822f, -0.10758294f, 
    -0.04051543f, 0.00464149f, 0.06419420f, 0.04654288f, 0.14770673f, 0.05754545f, 0.31258994f, 0.04574191f, 
    0.11108255f, 0.11128841f, 0.09923152f, 0.03192654f, 0.00488694f, 0.00797255f, -0.04067101f, 0.13604508f, 
    -0.18498987f, -0.04660256f, -0.31114942f, -0.10288255f, -0.06321362f, 0.21175905f, 0.15760529f, -0.12767164f, 
    0.04884008f, -0.03631365f, -0.08150557f, 0.09259568f, -0.10828226f, 0.18489154f, 0.15693890f, -0.11717287f, 
    0.04748508f, 0.02876162f, 0.03821197f, 0.09425633f, -0.16541113f, 0.09902471f, 0.13071987f, 0.03333727f, 
    -0.31661031f, -0.13445073f, -0.12397733f, -0.17054576f, 0.08136681f, 0.07947294f, 0.09769146f, -0.21054740f, 
    -0.00385297f, -0.06882842f, 0.01831704f, 0.02799687f, -0.09397373f, 0.16248079f, 0.15719345f, 0.14620446f, 
    -0.02138992f, -0.03003111f, 0.05244073f, -0.02699198f, -0.10225417f, -0.10200416f, 0.06166569f, 0.08166360f, 
    -0.32876843f, -0.11854398f, -0.06085923f, 0.27068120f, 0.08955555f, -0.00853705f, 0.09218598f, -0.01592246f, 
    -0.00920586f, 0.03220227f, -0.03626915f, 0.03812078f, -0.08371018f, -0.08800598f, 0.13449749f, -0.14113134f, 
    -0.04876529f, -0.00242828f, -0.07202425f, 0.03301361f, 0.01717189f, -0.01018344f, 0.02863776f, 0.21590456f, 
    -0.00210563f, 0.07636315f, 0.18847656f, -0.03306054f, 0.08022000f, -0.06945220f, -0.01935508f, 0.02597197f, 
    -0.03251161f, -0.06279688f, -0.01158204f, 0.12955922f, -0.23818396f, -0.12223420f, -0.05349298f, 0.02771379f, 
    0.08203920f, 0.09840744f, 0.03104169f, 0.15405527f, 0.03285364f, -0.02075050f, 0.01475073f, 0.09447140f, 
    0.00649276f, -0.17312238f, 0.02556562f, 0.01272189f, 0.21329105f, 0.08581684f, 0.05411164f, 0.04751965f, 
    -0.07091866f, 0.06521686f, -0.02616334f, 0.00475943f, 0.16564944f, -0.25168636f, -0.03302926f, -0.22747564f, 
    -0.00106194f, 0.05057774f, -0.02635696f, -0.02751354f, 0.04700346f, 0.03140515f, 0.07645272f, 0.02240973f, 
    -0.11366197f, -0.15980057f, -0.14402710f, -0.13358073f, 0.09144181f, 0.17647308f, 0.06057989f, -0.05312970f, 
    0.14049450f, 0.03958174f, 0.02553041f, 0.10879035f, 0.07956017f, 0.08248950f, 0.03000072f, -0.06620269f, 
    -0.01985139f, 0.03070997f, 0.06294417f, 0.03426705f, 0.16717997f, 0.13123038f, 0.09594822f, 0.13301775f, 
    0.21496233f, -0.01554611f, 0.16027595f, 0.09031966f, -0.00487635f, -0.07795465f, 0.02240232f, 0.01277358f, 
    -0.06550431f, 0.09359272f, 0.05435706f, 0.08976599f, 0.07243658f, 0.20898527f, -0.01644038f, 0.07794856f, 
    0.21115638f, 0.02849927f, 0.07216472f, 0.07444261f, 0.01331565f, -0.04666689f, -0.08438820f, 0.08114157f, 
    0.04103887f, 0.10103519f, 0.09167019f, 0.41691384f, 0.05966307f, -0.03389341f, -0.05162679f, 0.01852047f, 
    0.01545489f, 0.03166381f, -0.01105770f, 0.03139947f, -0.31539068f, -0.14163025f, 0.01380610f, 0.13088173f, 
    0.12998831f, 0.14246213f, -0.00424219f, 0.01745613f, 0.11152951f, 0.07368678f, -0.06222671f, -0.08412295f, 
    0.17650406f, -0.09562121f, -0.07987823f, -0.16959278f, 0.15243505f, -0.09829748f, -0.06605829f, -0.02949221f, 
    0.07106048f, -0.05334264f, 0.05636687f, 0.07383597f, -0.07888965f, -0.07419648f, -0.18919535f, -0.09840578f, 
    0.09261629f, 0.02390435f, 0.02859481f, 0.05348472f, 0.06224979f, 0.02464432f, 0.00738642f, -0.09647282f, 
    0.08373693f, -0.28459156f, -0.13451234f, -0.10590873f, 0.02160354f, 0.08928334f, -0.06060591f, 0.12488589f, 
    0.04048125f, 0.09776050f, 0.06056844f, -0.04558415f, -0.01996628f, 0.14281183f, 0.25722218f, 0.00080405f, 
    0.07171810f, -0.06384420f, 0.05417563f, -0.03376217f, 0.08740547f, -0.03292716f, -0.16925855f, 0.07824074f, 
    0.10696352f, -0.06539202f, -0.03611223f, -0.04468734f, 0.03731943f, 0.08315592f, -0.01853463f, -0.03091230f, 
    -0.07005612f, -0.00319712f, 0.20011723f, -0.02061985f, 0.00046032f, 0.36796793f, 0.02331070f, -0.15310475f, 
    -0.11522210f, 0.06591568f, 0.08639927f, 0.07020643f, 0.03614238f, 0.06981345f, -0.10934135f, -0.08456126f, 
    0.10300997f, 0.19188951f, -0.04452184f, -0.18330358f, 0.02017226f, 0.14695264f, 0.00945576f, 0.10633274f, 
    -0.06444573f, -0.04450442f, 0.00429334f, 0.00450585f, -0.09710228f, 0.18984027f, -0.07329033f, 0.15402704f, 
    -0.02172760f, 0.03564629f, 0.03396718f, 0.01248333f, 0.08895120f, -0.10497734f, -0.00365052f, 0.00528376f, 
    0.15402353f, -0.05030537f, 0.00816018f, 0.11306067f, -0.10185058f, 0.16667369f, 0.14438659f, 0.07446774f, 
    0.05428229f, -0.09531136f, -0.08082508f, 0.00536609f, 0.11305942f, -0.06835939f, 0.00261866f, 0.04147619f, 
    0.14656879f, -0.11119115f, 0.00970463f, -0.06925306f, 0.04126813f, -0.00411566f, 0.09546329f, -0.05151430f, 
    -0.14644469f, -0.12204118f, 0.09724844f, 0.07600933f, -0.01001202f, -0.03560944f, 0.02998603f, -0.01790538f, 
    0.01455771f, 0.03742851f, -0.07554099f, -0.04106930f, 0.05536724f, 0.16510950f, -0.03511493f, 0.01132236f, 
    0.07092558f, 0.02074146f, 0.03977653f, 0.20117599f, 0.03318394f, -0.10332247f, -0.10496958f, -0.24845982f, 
    0.17069268f, 0.00240930f, 0.11611310f, -0.06141614f, 0.01795501f, 0.12701054f, 0.08255904f, 0.01646571f, 
    0.07336591f, -0.13049020f, 0.12302481f, 0.06796764f, -0.00904802f, 0.15776083f, -0.05326252f, -0.10010765f, 
    0.02075700f, -0.03247464f, 0.13182150f, 0.08396875f, 0.10344560f, 0.20630081f, 0.06513408f, 0.07272222f, 
    -0.09170459f, -0.14176980f, -0.05416020f, -0.14360410f, -0.05495360f, 0.18997028f, 0.05753531f, 0.09449360f, 
    0.03388537f, 0.05097339f, -0.02580418f, -0.01778266f, -0.13945764f, -0.08948716f, -0.28233361f, -0.09454059f, 
    -0.12696601f, 0.06609007f, -0.00814649f, -0.04646614f, -0.05132009f, 0.10794322f, 0.11416853f, 0.03186249f, 
    -0.00963321f, -0.14080748f, 0.05124217f, 0.15892717f, 0.09776556f, 0.01272904f, 0.10425723f, 0.11425204f, 
    0.04249027f, 0.02923211f, -0.06021232f, 0.09892245f, 0.00926278f, -0.09590136f, -0.19448860f, 0.00972237f, 
    0.05261106f, -0.01739971f, -0.17755418f, 0.06235838f, -0.08669610f, 0.03584749f, 0.24906307f, 0.14004199f, 
    0.12433322f, -0.12469305f, 0.07661650f, 0.27589983f, -0.10214834f, -0.04836131f, 0.12255433f, -0.09411168f, 
    0.00245921f, -0.04088380f, -0.02083083f, 0.09871850f, -0.18712968f, -0.04195967f, -0.03658338f, -0.13156532f, 
    0.09559721f, 0.11470360f, 0.11910652f, 0.01920698f, -0.06875763f, 0.00873133f, 0.05811569f, -0.04618365f, 
    0.31403026f, 0.00255504f, 0.04053874f, 0.05174238f, 0.02268114f, -0.09166615f, 0.01438949f, 0.02381423f, 
    0.00999009f, 0.04763429f, -0.11368678f, 0.12392655f, 0.03133507f, 0.02301548f, -0.04412667f, -0.08685660f, 
    0.12041713f, 0.04803470f, 0.03529588f, -0.06829545f, 0.01265816f, 0.04770569f, 0.07573833f, 0.04570010f, 
    0.10528291f, -0.08211082f, 0.09972068f, -0.13538562f, 0.01687608f, 0.05514667f, -0.10319158f, -0.02466119f, 
    0.01591867f, 0.05872850f, -0.12750344f, -0.00140568f, -0.18549840f, 0.09259811f, -0.07642298f, -0.06417273f, 
    0.08466522f, -0.14602126f, -0.05747583f, 0.10558201f, 0.05713860f, 0.05724063f, 0.02721588f, -0.00524200f, 
    -0.22205372f, -0.05253128f, -0.08877631f, 0.12102987f, -0.02826827f, -0.12082757f, -0.18517751f, 0.01194536f, 
    0.04109083f, 0.02038106f, 0.06070746f, 0.00350400f, -0.15640074f, 0.31421229f, 0.06365560f, 0.17564106f, 
    0.03911829f, -0.11949277f, -0.04424331f, 0.22223638f, 0.00592110f, -0.04479370f, 0.03701541f, -0.04128201f, 
    -0.18112382f, 0.22147968f, 0.12988989f, 0.13798138f, -0.00676947f, 0.02725199f, 0.03881773f, -0.02159432f, 
    -0.00429113f, -0.00679661f, 0.08589248f, 0.10690895f, -0.01589288f, 0.03881872f, -0.02100755f, -0.10417069f, 
    0.09706217f, -0.00392628f, -0.04083236f, -0.02735974f, 0.08447258f, 0.04305365f, 0.11220443f, 0.00782118f, 
    -0.26425409f, -0.02471142f, -0.08447600f, 0.00076849f, -0.05992877f, -0.03172400f, 0.01612592f, -0.00868345f, 
    0.06117789f, -0.03536122f, -0.06510878f, 0.00944694f, 0.04494052f, -0.33600822f, 0.03387786f, -0.04395325f, 
    0.08491978f, 0.09417557f, -0.00152056f, 0.02114632f, 0.03783811f, 0.07718483f, 0.03559279f, 0.03002724f, 
    -0.11947264f, -0.06136173f, -0.01535353f, -0.01848299f, -0.09418217f, -0.16345203f, 0.04789827f, 0.11659481f, 
    -0.01407942f, -0.11020334f, -0.05690944f, 0.13230304f, 0.41887477f, -0.14505492f, -0.06882098f, 0.02253631f, 
    0.01964916f, -0.15147181f, 0.04834611f, 0.04854774f, 0.01253229f, 0.07183618f, -0.07610876f, -0.00433752f, 
    -0.00810570f, 0.21804844f, -0.03464748f, 0.12281189f, 0.03813951f, 0.00858123f, 0.01071373f, 0.10565570f, 
    0.01441005f, -0.01638119f, 0.12217278f, 0.00514242f, -0.26738715f, -0.00110160f, -0.00381903f, 0.08412178f, 
    0.03566559f, 0.01385088f, 0.00327952f, -0.02864672f, -0.00248549f, 0.12082250f, -0.03172578f, -0.01277696f, 
    -0.06061192f, -0.04537333f, -0.02244194f, 0.01860170f, -0.05557154f, -0.00381178f, -0.01982901f, 0.03435222f, 
    0.02281025f, -0.04358252f, 0.03352545f, 0.04505614f, -0.07343557f, -0.00970123f, -0.05711948f, -0.02820305f, 
    -0.02929248f, -0.04206874f, -0.03331729f, -0.06729846f, 0.05530441f, 0.02927894f, 0.00056904f, 0.06181092f, 
    0.03520500f, -0.02092769f, -0.04992845f, -0.06106052f, -0.01835110f, -0.07560196f, -0.07520575f, -0.04379224f, 
    0.01960380f, -0.06680263f, -0.01382378f, 0.00861772f, -0.07134789f, -0.04387982f, -0.03877735f, 0.02711541f, 
    -0.06945942f, -0.01605088f, -0.01396684f, 0.05560812f, 0.03830303f, -0.07525271f, -0.04131434f, 0.02987792f, 
    -0.02377367f, -0.03881386f, 0.03040460f, -0.05737280f, -0.02964298f, -0.04383688f, 0.00128081f, -0.04942639f, 
    -0.00857812f, 0.03517706f, -0.00368157f, 0.02194700f, 0.02541359f, -0.05140516f, -0.03824827f, 0.01653083f, 
    0.06008585f, -0.03792837f, 0.04225640f, -0.00028915f, -0.07299583f, -0.04767857f, 0.04876998f, -0.01045919f, 
    0.05023472f, -0.07910265f, 0.05537872f, -0.05771767f, -0.02742753f, -0.05048745f, -0.00838780f, 0.02939640f, 
    -0.03268756f, -0.03155503f, -0.02134701f, 0.01755754f, 0.03253641f, -0.00384606f, -0.03075273f, -0.06789558f, 
    0.00970766f, -0.00547046f, 0.05228169f, 0.00414774f, -0.04831326f, 0.03461622f, -0.00044111f, 0.04848137f, 
    0.03072979f, 0.03870580f, 0.05011103f, 0.05459591f, 0.01547824f, -0.04370657f, 0.01090245f, 0.00335483f, 
    0.01581084f, -0.01539230f, -0.03756372f, 0.02988552f, -0.07791007f, 0.02342020f, 0.05490194f, -0.02017269f, 
    0.05214178f, -0.07500488f, 0.03670989f, -0.05996295f, -0.07836109f, -0.01590841f, -0.02196969f, 0.00131855f, 
    -0.02613504f, 0.03462067f, -0.06593389f, -0.01973244f, -0.01233753f, -0.04223793f, 0.04449039f, 0.03269239f, 
    0.04656499f, -0.07125531f, -0.00332096f, 0.05815981f, -0.02664093f, -0.05359171f, 0.01839602f, -0.02582566f, 
    -0.07686523f, -0.01357353f, 0.04519433f, 0.00456144f, -0.02198142f, -0.06896544f, -0.00913501f, -0.06993946f, 
    0.03098600f, 0.01753697f, -0.02287478f, 0.05032512f, 0.02617660f, 0.00152646f, -0.04842909f, -0.04835729f, 
    -0.01967525f, 0.03431446f, -0.03908904f, 0.03746920f, 0.04582250f, -0.05095955f, -0.07029808f, -0.00482297f, 
    0.04399182f, -0.02250640f, 0.06121754f, 0.03253422f, 0.04779202f, -0.07414918f, -0.01344500f, -0.02124099f, 
    -0.02676921f, -0.07606117f, 0.04822220f, -0.05853871f, -0.04315790f, -0.02668753f, 0.04668577f, -0.02682934f, 
    0.03161014f, 0.01247514f, -0.04166984f, -0.06387192f, -0.05566832f, 0.05515428f, -0.07352833f, 0.04216145f, 
    0.00465331f, 0.00962168f, 0.01298850f, -0.00396751f, 0.03222590f, -0.01581903f, -0.06088063f, 0.01686069f, 
    -0.05069182f, -0.05983016f, 0.02238005f, 0.01196095f, -0.06435982f, 0.00961555f, -0.02144711f, -0.02107343f, 
    -0.04776382f, -0.01335892f, -0.06045680f, 0.05427177f, -0.06146167f, -0.00305624f, 0.04462531f, 0.01042796f, 
    0.01887812f, -0.01543324f, -0.02433847f, 0.04370613f, -0.00651763f, 0.03240113f, 0.04606037f, 0.01419296f, 
    -0.01098931f, 0.04060464f, 0.02506288f, -0.04872065f, 0.04686081f, -0.03028102f, -0.06152689f, -0.00540302f, 
    -0.01835442f, 0.00293072f, -0.04668384f, -0.00839002f, 0.03445122f, -0.00286708f, 0.00317596f, -0.04925873f, 
    -0.02247142f, 0.00415082f, -0.02212421f, -0.04786495f, 0.04189265f, -0.00798341f, -0.07277802f, -0.07090777f, 
    0.00413284f, 0.05917406f, -0.07919541f, 0.01147265f, 0.01427157f, -0.06113173f, -0.06342854f, 0.03128716f, 
    -0.00728407f, 0.06223362f, -0.04073814f, -0.00884889f, -0.06235941f, 0.04988594f, 0.03125956f, 0.06351315f, 
    0.03567903f, -0.06116266f, 0.01732016f, -0.01790839f, -0.02522649f, -0.05682452f, -0.00179868f, 0.06028378f, 
    -0.05511407f, -0.02159804f, 0.06454046f, -0.01559211f, 0.05059461f, -0.01506423f, -0.03582233f, -0.07733068f, 
    0.04354562f, 0.01001114f, 0.03120767f, -0.00068867f, -0.01034531f, 0.03862766f, -0.02222852f, 0.00286837f, 
    -0.04971943f, 0.04967621f, -0.00616925f, -0.06289800f, -0.02789754f, -0.02268312f, -0.05476481f, 0.01775484f, 
    -0.02322245f, -0.04001272f, -0.01213573f, 0.05528513f, 0.04507424f, -0.02141095f, -0.05926106f, 0.03297146f, 
    0.02798699f, 0.02668870f, 0.06351973f, -0.04430319f, -0.00083694f, 0.03238650f, 0.02403814f, -0.02181748f, 
    -0.04599846f, 0.04756923f, -0.07480622f, -0.05163556f, -0.07751076f, 0.05420284f, 0.00465472f, 0.05309279f, 
    -0.07534429f, -0.00557087f, 0.04319703f, -0.07240761f, -0.03893924f, 0.05301671f, -0.00007952f, -0.04966215f, 
    -0.01165946f, -0.00909921f, 0.01342269f, -0.06810960f, -0.03956455f, 0.00343450f, 0.00253244f, 0.00203492f, 
    0.04347410f, 0.04669679f, -0.05253264f, 0.03512015f, 0.05931892f, 0.04120054f, 0.05395220f, -0.00609269f, 
    -0.05948000f, -0.04857553f, -0.03515219f, -0.04582090f, -0.06529898f, -0.08559578f, -0.01845972f, 0.03177213f, 
    0.00660723f, -0.03234496f, -0.03136462f, 0.03670200f, 0.04525210f, 0.00282130f, -0.03316930f, -0.02266412f, 
    0.00926747f, -0.00839321f, -0.02974464f, 0.04185968f, -0.00240472f, -0.07437436f, -0.03930594f, -0.04985492f, 
    0.03534660f, -0.02660868f, -0.06405177f, 0.04828240f, -0.06751362f, 0.02091330f, -0.03915945f, -0.00066577f, 
    -0.07922727f, -0.03365515f, -0.05523650f, -0.00690934f, -0.02689605f, -0.01513702f, 0.04418514f, -0.04712490f, 
    0.04555029f, 0.01816302f, -0.06565100f, -0.02540394f, -0.01103969f, -0.08155271f, -0.05600491f, -0.02901368f, 
    -0.04063532f, -0.03003559f, -0.00695177f, 0.03369762f, 0.03176090f, -0.04381569f, -0.01494287f, 0.01129548f, 
    0.02446343f, -0.05794089f, 0.01682267f, 0.02217274f, 0.05155407f, -0.04627714f, 0.05665614f, -0.02120318f, 
    -0.03051347f, 0.02059688f, -0.02374284f, -0.08529090f, 0.01412993f, 0.02696279f, 0.02579266f, -0.06310049f, 
    -0.03340434f, 0.04024999f, -0.04008928f, 0.02958613f, 0.03798903f, -0.01501066f, -0.03991652f, -0.08370234f, 
    0.06183074f, 0.00715140f, -0.06892557f, -0.05822203f, -0.05814014f, -0.02545274f, 0.00934418f, 0.05012479f, 
    -0.05245693f, -0.07175940f, 0.02706636f, 0.00148476f, 0.04649318f, -0.05958095f, 0.01298819f, 0.00561281f, 
    0.05893109f, 0.05572485f, -0.02808941f, -0.04807576f, -0.02756392f, -0.01845969f, 0.03282288f, 0.03759700f, 
    0.04817276f, -0.07628122f, -0.03363322f, -0.08490365f, 0.04935098f, -0.01851073f, -0.04147116f, 0.04530858f, 
    -0.01168621f, -0.01273222f, -0.03261329f, -0.01506494f, -0.04823494f, -0.01212819f, 0.02072161f, 0.02401356f, 
    0.02017934f, -0.04092807f, -0.05991298f, 0.04407870f, 0.02321146f, -0.01133974f, -0.05472967f, -0.02908419f, 
    -0.07700269f, 0.01702803f, 0.05621461f, 0.05342962f, 0.00415124f, -0.03115973f, -0.02335552f, 0.04810013f, 
    -0.02518160f, 0.02979535f, 0.04834734f, 0.01346439f, 0.04316387f, 0.03711454f, -0.04190320f, 0.01415572f, 
    -0.05168739f, -0.02892625f, 0.03837566f, -0.00670105f, -0.08166994f, -0.02770407f, 0.01637908f, -0.06825623f, 
    0.05868106f, -0.07156456f, -0.05758388f, -0.00603278f, -0.06907709f, 0.03000009f, -0.01315600f, 0.06364638f, 
    0.03379462f, -0.07952511f, -0.01788896f, -0.04845996f, 0.04825450f, -0.06708623f, -0.01884466f, -0.04628656f, 
    -0.03011420f, -0.01431848f, 0.00784108f, 0.00725746f, -0.02037127f, 0.01700561f, -0.07059361f, -0.06628252f, 
    0.04600440f, 0.02318256f, -0.03532101f, -0.01011267f, -0.07826571f, -0.00946471f, -0.02140773f, -0.03572117f, 
    -0.03614232f, -0.00583758f, -0.04970798f, -0.07479646f, -0.05658791f, 0.02170894f, -0.03859418f, -0.02298217f, 
    -0.00374506f, 0.01440258f, -0.02555315f, 0.01682827f, 0.02316587f, -0.06887531f, 0.02319953f, -0.03289935f, 
    0.02537397f, -0.01453600f, -0.05074065f, -0.06861841f, 0.03967772f, -0.04224769f, -0.00709452f, 0.00850445f, 
    0.01202727f, 0.04850155f, -0.06779905f, 0.05300806f, 0.00088779f, -0.03404441f, 0.02630783f, -0.03174474f, 
    -0.00435489f, 0.00837319f, -0.00786575f, -0.06761172f, -0.04683765f, -0.00610676f, 0.02306550f, -0.07842252f, 
    -0.05827260f, 0.01819773f, -0.02609873f, -0.05506584f, 0.03167691f, -0.04240695f, 0.02447755f, -0.05579105f, 
    0.01473086f, 0.05658695f, 0.01597035f, -0.06827211f, -0.02329511f, 0.05057172f, 0.05692261f, -0.04653391f, 
    0.34924477f, -0.19372199f, -0.11431248f, 0.16060863f, -0.02040635f, 0.01099780f, -0.02182495f, 0.02333539f, 
    -0.06460717f, 0.00128491f, 0.05344225f, -0.05672346f, 0.10624766f, 0.03534895f, 0.11720550f, 0.01512407f, 
    0.01353762f, -0.06178027f, -0.05449568f, 0.03403996f, -0.00800483f, -0.05996200f, 0.03476251f, 0.04491438f, 
    0.21357244f, -0.03349153f, 0.15536690f, -0.14618261f, -0.01038450f, -0.03388669f, -0.07922302f, -0.01530970f, 
    0.07660223f, -0.00908893f, -0.04461306f, 0.01149034f, 0.14768669f, 0.09331281f, -0.02094473f, -0.08492903f, 
    0.07500207f, 0.07911004f, 0.03740809f, 0.01953473f, 0.12994881f, 0.06321383f, -0.01222834f, 0.07949959f, 
    -0.00320695f, 0.16615838f, 0.06062475f, 0.01331417f, -0.16147114f, 0.13651621f, -0.05057762f, -0.02640205f, 
    -0.05825038f, 0.03599883f, 0.00691916f, 0.06180017f, -0.46169025f, 0.04423078f, -0.19392373f, 0.00733910f, 
    0.13665786f, 0.00585741f, -0.06689869f, 0.17977579f, 0.08930791f, 0.00882543f, 0.05138059f, 0.06061801f, 
    -0.09996709f, -0.18665965f, 0.02322614f, 0.12153567f, -0.00977763f, 0.06326929f, -0.11783691f, -0.05930850f, 
    -0.17915845f, 0.10363956f, 0.00880149f, 0.08607050f, -0.18018171f, 0.22483639f, 0.03302675f, 0.04760753f, 
    0.14443575f, -0.09452928f, 0.00116634f, 0.07458054f, -0.08222564f, -0.04727045f, 0.03544656f, -0.02383884f, 
    -0.05399111f, -0.01273559f, 0.07248838f, -0.05275273f, 0.15596953f, 0.06941026f, 0.10979795f, -0.04530639f, 
    0.14613140f, 0.06315605f, 0.05240051f, 0.03558891f, 0.04875948f, 0.08598454f, -0.06122353f, -0.07466073f, 
    0.24987985f, 0.06888064f, -0.00604277f, 0.16577125f, 0.09289802f, 0.03869394f, 0.11779330f, 0.08860894f, 
    0.06447244f, -0.05302064f, 0.09391545f, 0.08329989f, -0.05100011f, -0.02614271f, 0.05778710f, 0.07168153f, 
    0.03014857f, 0.02469685f, 0.07006543f, 0.21026465f, 0.06130501f, -0.14861937f, -0.13861498f, -0.11853978f, 
    0.16760792f, 0.11561492f, 0.06089690f, 0.04578501f, 0.04061732f, 0.14461333f, -0.06280441f, 0.09927641f, 
    -0.02345504f, 0.11979619f, 0.03266668f, 0.02015873f, -0.04001739f, 0.02652892f, 0.00529084f, 0.06370731f, 
    -0.00834900f, -0.01530729f, -0.03451322f, 0.02884486f, -0.04793385f, -0.13935123f, -0.06259080f, 0.13979569f, 
    -0.11095545f, -0.02205461f, -0.12392525f, 0.09217414f, 0.11975916f, 0.07767827f, -0.10807740f, 0.10614002f, 
    0.01330387f, 0.12636390f, -0.11725707f, 0.05819002f, 0.21260434f, -0.03785761f, 0.09261595f, 0.08909240f, 
    -0.04869523f, -0.12591556f, 0.00347721f, 0.00085018f, -0.53458613f, 0.11213750f, -0.15522549f, 0.06640072f, 
    -0.01195561f, -0.04162019f, 0.09994017f, -0.04336804f, 0.00584874f, -0.01638306f, 0.03890646f, -0.09032871f, 
    0.43516770f, -0.15391850f, 0.00916678f, 0.09905777f, -0.03825254f, 0.09980527f, 0.04608992f, 0.20959532f, 
    0.00621019f, 0.09104683f, 0.02493346f, 0.04116094f, -0.30709970f, -0.06121196f, 0.18811610f, 0.05521472f, 
    0.01014422f, 0.16357920f, -0.00570240f, -0.06094220f, 0.10052201f, -0.02430200f, -0.05017120f, 0.03612994f, 
    0.36544126f, -0.00694672f, -0.02438507f, -0.19738187f, -0.04306237f, 0.12318549f, 0.01696140f, -0.11776604f, 
    -0.14653437f, 0.05883177f, 0.02343095f, 0.07878412f, 0.00061343f, 0.18261230f, 0.05181548f, 0.03430019f, 
    -0.04473668f, -0.03402483f, 0.03605377f, 0.01015698f, -0.03345934f, 0.07258122f, 0.04772290f, -0.05991790f, 
    -0.09581684f, 0.14516319f, -0.06407198f, 0.09864816f, 0.08688898f, 0.00690020f, 0.10370360f, 0.00230726f, 
    0.02502424f, -0.02533825f, -0.09113055f, 0.05332200f, -0.04066999f, 0.14573425f, -0.03985681f, 0.21503390f, 
    0.03206594f, -0.10375039f, -0.00228324f, 0.02182635f, 0.05344826f, -0.01017467f, 0.02765939f, -0.03883776f, 
    -0.12991595f, -0.02910753f, -0.11995772f, -0.08080939f, -0.05297345f, -0.08245536f, 0.16274542f, 0.07619751f, 
    0.11156084f, -0.07730115f, -0.05838772f, -0.03996128f, -0.15795980f, 0.07797281f, -0.04523953f, 0.04522902f, 
    -0.12444665f, 0.00468178f, 0.14642353f, -0.07796154f, -0.00360009f, -0.02189757f, 0.11661079f, -0.04737077f, 
    -0.09627658f, 0.01957176f, 0.21556279f, 0.05405664f, -0.10344825f, -0.04618083f, 0.05184325f, 0.14372709f, 
    -0.02138309f, -0.01540665f, -0.04898324f, 0.00358602f, 0.03683992f, -0.07435280f, -0.01799981f, 0.03593948f, 
    -0.00412292f, 0.05872975f, 0.07083543f, 0.14737369f, 0.06015353f, -0.08107186f, -0.07276858f, -0.25268066f, 
    -0.14466880f, -0.05220307f, 0.18718967f, -0.14679292f, -0.06624797f, 0.20472291f, -0.00036251f, -0.04285755f, 
    0.04260004f, -0.06403270f, -0.02706805f, 0.01428237f, -0.05920047f, -0.08126997f, 0.10596570f, -0.08790523f, 
    -0.00203138f, 0.03579336f, 0.07472206f, 0.13075759f, -0.03597073f, 0.09404035f, 0.16807127f, 0.09960461f, 
    -0.04452627f, -0.09047099f, 0.07088664f, -0.17490762f, 0.05806727f, 0.02268319f, -0.01768808f, 0.05684324f, 
    -0.00392298f, -0.06464627f, -0.11542201f, 0.08744754f, 0.02461229f, 0.04650979f, 0.02296006f, -0.28351539f, 
    0.00014519f, -0.08638626f, 0.10662466f, 0.13882449f, 0.01309215f, 0.01626548f, 0.00070104f, 0.04037741f, 
    -0.23630697f, -0.02789760f, -0.04015829f, 0.11378706f, -0.05450290f, 0.18994847f, 0.04904315f, 0.11855751f, 
    -0.04721513f, 0.02753053f, -0.01312468f, 0.09191009f, -0.22214867f, -0.09165683f, 0.10692213f, 0.03183630f, 
    0.01763481f, 0.08828920f, -0.06087006f, -0.02244877f, -0.10898530f, 0.07521597f, 0.11473297f, 0.09992115f, 
    -0.31394276f, 0.28596097f, 0.17552680f, -0.05753964f, -0.03285461f, 0.05003140f, -0.06705776f, -0.01462367f, 
    0.07936806f, 0.04436051f, 0.01994066f, 0.02959131f, 0.30414957f, -0.08121751f, -0.27941167f, 0.00038982f, 
    0.11337247f, -0.03225488f, 0.00813223f, -0.05363032f, 0.17522807f, 0.06175904f, -0.03729586f, 0.07015742f, 
    -0.12229199f, 0.06296688f, 0.01171595f, -0.18147674f, 0.05709895f, 0.11047843f, 0.06107777f, 0.02276063f, 
    0.04228213f, -0.01750429f, -0.03525115f, -0.06984632f, 0.22476082f, -0.12682682f, -0.02275162f, 0.32628128f, 
    0.02583854f, 0.02504444f, -0.00673290f, 0.04629544f, -0.06176248f, -0.05595838f, -0.09148097f, -0.01146973f, 
    -0.05324815f, -0.26507965f, -0.07845733f, 0.08130100f, 0.03199326f, -0.12531322f, -0.02387693f, -0.00046570f, 
    0.07716796f, -0.02218149f, 0.09929299f, -0.01563635f, 0.01791122f, 0.07240116f, 0.11159717f, 0.01557667f, 
    -0.04429777f, -0.05971385f, -0.00205789f, -0.14677571f, -0.02518062f, -0.05194440f, -0.03162966f, 0.00871767f, 
    0.12568751f, 0.31001267f, 0.04491524f, -0.05601823f, -0.07114953f, 0.04055161f, 0.16923870f, -0.06775766f, 
    -0.00125077f, -0.00133962f, 0.13938367f, -0.01102575f, -0.05020984f, -0.00361972f, -0.05996201f, -0.03673491f, 
    0.05838735f, -0.02928356f, -0.04761845f, -0.03534777f, 0.09791599f, 0.06843574f, 0.05859632f, -0.06533525f, 
    0.16470943f, 0.00116292f, 0.05090107f, -0.02324473f, -0.08497437f, -0.05411770f, 0.05124707f, 0.06243987f, 
    -0.02049348f, -0.02374145f, 0.02758849f, -0.04736795f, -0.01930186f, -0.04070295f, -0.03711053f, 0.15158205f, 
    -0.05980372f, 0.03772438f, 0.02126475f, -0.08710007f, -0.15843527f, -0.12441371f, -0.07913567f, 0.09459127f, 
    0.15008473f, -0.00657088f, -0.08171263f, 0.06971972f, 0.05929393f, -0.00145334f, 0.04805402f, 0.02011633f, 
    0.13069068f, 0.12912363f, 0.10191373f, -0.10115886f, -0.03155475f, 0.17981213f, 0.19367349f, 0.02216810f, 
    -0.11448602f, -0.02881023f, 0.00739889f, -0.05588576f, 0.05942979f, -0.12783387f, 0.03686547f, 0.00573527f, 
    0.04012717f, 0.04032193f, -0.07698118f, -0.24958162f, 0.08615822f, 0.15139139f, 0.00952537f, -0.01120427f, 
    0.12993707f, 0.08027619f, 0.04294832f, -0.07487465f, 0.07691371f, 0.29808837f, -0.03323985f, -0.12059997f, 
    -0.07700999f, 0.18723810f, -0.05632079f, -0.05593365f, -0.09706062f, -0.09077644f, 0.05764943f, 0.01487788f, 
    -0.02003521f, -0.04050911f, 0.15352355f, 0.06461839f, -0.03213513f, -0.07638230f, 0.00159278f, 0.05345233f, 
    0.07220583f, 0.08612924f, 0.06122845f, -0.01612329f, 0.12189730f, 0.16009818f, 0.23589069f, 0.03014751f, 
    0.04425096f, -0.04746468f, 0.03193059f, -0.02734355f, -0.01793021f, -0.00363328f, 0.04717351f, 0.00248937f, 
    0.03280342f, 0.05362024f, -0.06010682f, -0.08386358f, -0.06958059f, -0.02034182f, -0.04683809f, -0.00807122f, 
    0.02897305f, -0.02734025f, -0.04207182f, -0.03155790f, -0.02414688f, 0.05238362f, 0.02443084f, 0.01096761f, 
    0.00756940f, 0.02864168f, -0.05521542f, 0.04076055f, -0.01311580f, -0.08463936f, -0.03611836f, -0.07255553f, 
    0.02499758f, -0.03801416f, -0.04312878f, 0.03666756f, 0.04630766f, -0.08175444f, 0.06788745f, 0.05014899f, 
    -0.00769518f, -0.06964240f, -0.07705668f, 0.02065227f, -0.05240439f, -0.05856793f, -0.07122328f, -0.00563003f, 
    -0.00477458f, 0.01623590f, 0.05320659f, -0.03164291f, -0.06827825f, -0.03546085f, -0.08389470f, -0.00739373f, 
    -0.02902156f, -0.05042973f, -0.05936363f, -0.08207563f, -0.00356450f, -0.06176793f, 0.01374016f, -0.02172458f, 
    0.01790305f, -0.07039473f, 0.02743837f, 0.02886274f, 0.05264878f, -0.00702426f, -0.02467478f, -0.02432421f, 
    -0.04988363f, -0.06308914f, 0.01216492f, -0.03189912f, -0.00847778f, 0.00986167f, -0.00045505f, -0.03156251f, 
    0.05117821f, -0.00422275f, -0.02558413f, -0.06750973f, 0.00520221f, 0.00469261f, 0.04547026f, 0.04304569f, 
    0.03690531f, 0.05277677f, -0.02669432f, 0.00035900f, -0.00595957f, 0.04725363f, -0.00025371f, -0.07010280f, 
    -0.00519732f, -0.05313363f, -0.05302474f, -0.06364761f, -0.04300033f, -0.01073937f, -0.01124277f, -0.03815235f, 
    -0.08066072f, -0.04824125f, 0.01968958f, -0.04116366f, 0.00411266f, 0.05164452f, -0.03340731f, -0.06156915f, 
    -0.08433656f, -0.05949755f, -0.07209250f, -0.02014660f, -0.05062325f, -0.05164043f, -0.07649475f, -0.08588791f, 
    -0.04892073f, 0.04327626f, -0.05793171f, 0.01797955f, 0.03701130f, 0.01217627f, 0.04212953f, 0.05071466f, 
    0.01581676f, 0.00448992f, -0.04548423f, 0.00738041f, -0.02807238f, -0.06066509f, -0.08007666f, -0.07080340f, 
    -0.01194373f, -0.08622587f, 0.04030574f, -0.03906236f, -0.06777062f, 0.00518383f, -0.07288014f, -0.05269431f, 
    -0.02514973f, -0.02450600f, -0.08569248f, -0.02790580f, -0.02592546f, -0.01189042f, 0.02020116f, -0.02173626f, 
    0.00210573f, 0.01855715f, -0.06302126f, -0.04996985f, -0.04840847f, 0.00747719f, -0.08040329f, -0.07418604f, 
    0.03626637f, -0.05577777f, 0.00906502f, 0.05218376f, -0.06387781f, -0.00363961f, -0.06250875f, 0.01178647f, 
    -0.05449525f, -0.01753761f, 0.02834318f, 0.02078372f, 0.03480496f, -0.05026276f, -0.00208765f, -0.07075693f, 
    -0.00233125f, 0.05461976f, -0.04633763f, 0.04908285f, 0.00917292f, -0.05562696f, -0.05125586f, -0.02117346f, 
    -0.00591351f, -0.03880528f, -0.01922074f, -0.08310896f, 0.00326116f, -0.00201110f, -0.05495453f, -0.03195173f, 
    -0.03272825f, -0.06993961f, 0.02878001f, 0.05433306f, -0.06964444f, -0.03510281f, -0.02559218f, -0.01126136f, 
    0.11756554f, -0.17241345f, -0.05614650f, -0.12042683f, 0.08189483f, 0.02851039f, 0.02350232f, -0.00681765f, 
    0.04689281f, 0.02870386f, 0.07287553f, -0.05428937f, 0.24225810f, 0.05644066f, -0.09823813f, -0.19830455f, 
    0.10170965f, -0.08530799f, 0.06464547f, -0.03789783f, -0.00734098f, 0.04229385f, 0.00520615f, 0.04174109f, 
    0.08356921f, 0.16657250f, 0.07769243f, 0.13887136f, 0.15573902f, 0.04612705f, 0.16110514f, -0.00609598f, 
    -0.00277685f, -0.05933668f, 0.15632582f, 0.06479788f, -0.28235835f, 0.23761821f, -0.35516664f, -0.34792915f, 
    0.16604492f, -0.07747453f, -0.03744882f, 0.05263643f, -0.09561064f, 0.01717887f, 0.05702053f, -0.05552574f, 
    0.23913732f, 0.23062526f, -0.15542012f, 0.08285988f, 0.07283297f, 0.00255694f, -0.09751008f, -0.06803414f, 
    -0.01904358f, 0.01720534f, 0.07729591f, 0.07089669f, 0.34637323f, -0.17712808f, -0.07870884f, 0.16460857f, 
    -0.15142874f, -0.01713288f, -0.02782767f, 0.08233359f, 0.03709453f, 0.03159834f, 0.07201362f, -0.01575067f, 
    -0.02022352f, -0.09102470f, 0.10698047f, -0.13255326f, -0.17241038f, 0.04153286f, 0.04173636f, 0.02802906f, 
    -0.06544246f, 0.01814483f, -0.05472251f, 0.17104340f, 0.09964726f, 0.12499993f, 0.06825070f, -0.14493690f, 
    -0.00842896f, -0.09962197f, 0.06316964f, -0.03991143f, 0.03459926f, 0.05074477f, -0.00465901f, 0.11270238f, 
    0.26690024f, 0.12000076f, 0.00276188f, -0.15170999f, -0.10524478f, -0.00985363f, 0.07212831f, 0.02509705f, 
    0.19814350f, 0.01793242f, 0.00843992f, 0.00795805f, 0.19353700f, 0.14837296f, -0.01325375f, -0.04449343f, 
    0.03114275f, 0.02384833f, 0.02556446f, 0.09433448f, -0.03587041f, 0.10358270f, 0.09827098f, 0.03583147f, 
    0.00983452f, 0.08570947f, 0.09817301f, -0.13430509f, 0.19767916f, 0.01749246f, -0.05395053f, 0.11012825f, 
    0.06462637f, 0.12977906f, 0.01279632f, 0.10108699f, -0.17320649f, -0.01776499f, 0.05226440f, 0.10545433f, 
    -0.10883854f, -0.11268941f, -0.02590502f, 0.04779154f, -0.09911197f, 0.09554958f, -0.12402536f, -0.16175720f, 
    -0.03946923f, 0.09813435f, -0.00949673f, -0.04666234f, 0.01164928f, -0.04069661f, -0.02394823f, -0.06352998f, 
    -0.00351373f, -0.03012504f, -0.03278081f, -0.10250550f, -0.04994380f, -0.23713955f, -0.05581601f, 0.09148576f, 
    0.10562508f, 0.02025645f, -0.01382032f, 0.04635882f, 0.06918742f, 0.04025240f, -0.04056159f, 0.06287107f, 
    0.21454169f, 0.07389119f, 0.07065002f, -0.12022967f, 0.04709673f, -0.06492477f, 0.18550789f, 0.04138302f, 
    0.10403184f, 0.00748222f, -0.02141110f, -0.04187441f, 0.47802135f, -0.15942407f, -0.03128832f, -0.07699804f, 
    -0.07356829f, -0.00902506f, -0.04452647f, -0.01690119f, 0.00610283f, -0.03582287f, -0.01318802f, -0.08138424f, 
    0.04442607f, -0.23141846f, -0.06987860f, 0.21327461f, 0.04337989f, -0.04244878f, 0.09995291f, 0.12086963f, 
    -0.09894025f, -0.01409156f, 0.02564084f, 0.02804288f, -0.03751712f, -0.18760872f, 0.09578087f, -0.11220744f, 
    0.10395648f, 0.05106168f, -0.01855057f, -0.22545265f, 0.10861976f, -0.08418033f, -0.17264460f, -0.03541794f, 
    0.24293461f, 0.16638286f, -0.03930271f, -0.27724993f, 0.16492906f, 0.05221185f, -0.11541646f, 0.01534823f, 
    -0.06394598f, 0.03440206f, 0.16075401f, -0.01003018f, 0.09364993f, 0.21111466f, 0.08509146f, 0.02121441f, 
    0.21065557f, 0.04989482f, -0.10349892f, -0.17307995f, -0.05426012f, 0.02070683f, -0.04458063f, -0.07604175f, 
    0.17052667f, -0.03601709f, 0.20175280f, -0.09669886f, 0.07118318f, 0.03147690f, -0.11176202f, -0.09827647f, 
    0.12810983f, -0.01412684f, -0.00989200f, -0.00962913f, 0.08549520f, -0.02401432f, 0.05398213f, 0.01038614f, 
    0.03302790f, -0.05965997f, 0.10472721f, 0.11593559f, 0.08018262f, 0.06330021f, -0.04395433f, -0.01326976f, 
    0.03303541f, 0.13068403f, -0.08559131f, 0.08800756f, 0.00911014f, -0.04447759f, 0.04508514f, 0.00087535f, 
    0.01460975f, -0.18983252f, -0.04884071f, -0.15574352f, -0.10965458f, 0.23476034f, 0.07474535f, 0.17130423f, 
    0.05671376f, 0.03046056f, 0.04386577f, 0.07617304f, -0.05052815f, -0.11176337f, 0.16876873f, 0.03217975f, 
    -0.05816232f, 0.13978034f, 0.08545894f, 0.22418053f, 0.05001347f, -0.10546448f, 0.14677618f, 0.09440238f, 
    0.04084832f, -0.02665613f, -0.09524681f, -0.04351281f, 0.12822127f, 0.01790082f, 0.03716005f, -0.10364387f, 
    0.05082289f, -0.09923293f, 0.04899145f, 0.14261833f, 0.01208217f, -0.12198527f, -0.09605543f, -0.23857170f, 
    -0.15666460f, -0.07853630f, -0.11589202f, 0.09973104f, 0.08794201f, -0.03143876f, 0.02413573f, -0.01272096f, 
    0.06492589f, -0.09865520f, -0.00882718f, -0.08609308f, 0.06839150f, -0.03227168f, 0.07659237f, -0.13051093f, 
    0.03963199f, 0.04686834f, 0.02432411f, 0.07002631f, -0.06642938f, 0.07358528f, 0.08504841f, 0.13816890f, 
    -0.02636243f, -0.08197423f, -0.20168157f, -0.26030424f, -0.00577327f, 0.07931507f, -0.02052099f, -0.09572248f, 
    -0.03773086f, -0.02150154f, 0.07428206f, -0.01502616f, 0.42619634f, -0.23347245f, -0.04899789f, -0.19935378f, 
    -0.11502628f, -0.06128857f, 0.00129539f, -0.08611234f, -0.01191498f, 0.00272956f, 0.04035890f, -0.01412760f, 
    -0.21138877f, 0.02194558f, 0.00467143f, 0.23748595f, -0.04171202f, 0.10310382f, 0.10300170f, 0.10755868f, 
    -0.10762761f, 0.06288222f, 0.02656543f, 0.03717677f, -0.10537308f, 0.04156334f, 0.08283626f, 0.04284528f, 
    0.07507063f, 0.17242281f, 0.01613637f, 0.00381287f, -0.10102149f, -0.00169975f, 0.17130685f, 0.04674201f, 
    -0.09199303f, 0.00933797f, -0.04698672f, 0.03059413f, -0.12322702f, 0.14818676f, -0.04459846f, -0.11357509f, 
    0.10276669f, -0.06124251f, 0.11078373f, 0.01752687f, 0.16532439f, -0.14613028f, -0.08514421f, -0.01589774f, 
    0.10762167f, -0.01186282f, 0.03773748f, -0.03987813f, 0.12888496f, 0.02778152f, 0.16358937f, 0.07195301f, 
    0.16951913f, 0.08805465f, 0.04466598f, -0.30455151f, -0.04791993f, 0.04640826f, -0.04050451f, 0.25785393f, 
    0.06637013f, -0.10154557f, -0.05751129f, 0.14591312f, 0.10880728f, -0.32363585f, -0.07181352f, 0.22259618f, 
    0.16289796f, 0.12396824f, -0.09665536f, -0.07448180f, 0.01962887f, 0.02625860f, 0.19206788f, 0.19371037f, 
    -0.16919701f, -0.14655483f, 0.07398250f, -0.10859962f, 0.10582133f, 0.03109162f, -0.20348409f, -0.13176923f, 
    -0.00603466f, 0.07980171f, 0.02895913f, 0.09092270f, -0.17358740f, -0.16540655f, -0.04865858f, -0.04097813f, 
    0.04156960f, -0.11501718f, 0.01431898f, 0.05283180f, -0.04149365f, 0.09251244f, -0.15301709f, 0.17014129f, 
    0.12700237f, 0.09824248f, 0.06250590f, -0.11422460f, -0.04716936f, 0.02752407f, -0.07643920f, 0.06161045f, 
    -0.01154647f, 0.07839520f, 0.11359558f, 0.05735445f, 0.12159587f, -0.06891729f, 0.01546383f, 0.06679164f, 
    -0.10428489f, 0.14487065f, 0.04164673f, 0.10651016f, 0.01322390f, 0.05110398f, -0.04897036f, -0.00464787f, 
    -0.11913851f, -0.06492988f, 0.12636572f, -0.09228456f, -0.03954046f, -0.10817616f, 0.12280012f, 0.04484122f, 
    0.03251253f, 0.00770361f, 0.02751005f, -0.01993465f, 0.12927379f, 0.12499290f, -0.02231176f, -0.03411974f, 
    0.13408148f, -0.04561805f, 0.10112438f, 0.06834339f, -0.00066048f, 0.03889016f, 0.16001807f, 0.32687548f, 
    -0.05752003f, -0.04822820f, -0.12743273f, 0.17751008f, 0.16439462f, -0.18125176f, 0.01608786f, 0.04233311f, 
    0.14707246f, 0.16583939f, -0.14284322f, 0.04458698f, 0.08916544f, -0.10522838f, 0.09163024f, -0.10101376f, 
    -0.07276697f, -0.04441346f, -0.10824656f, -0.02653358f, 0.04027022f, -0.03627928f, -0.09115214f, 0.05422237f, 
    0.04672919f, 0.02598391f, 0.01068422f, -0.22237532f, 0.08920472f, 0.09639024f, 0.05234126f, 0.00061684f, 
    0.10206417f, 0.10605322f, -0.03108742f, -0.09586731f, -0.14812888f, 0.26052424f, -0.34139588f, -0.16132672f, 
    -0.14095445f, 0.03262943f, -0.10030536f, 0.13625835f, 0.00687812f, 0.02772049f, 0.09676263f, 0.06988177f, 
    0.07373303f, 0.02269225f, 0.06344470f, 0.17925972f, 0.02125252f, -0.15826854f, 0.03341414f, -0.02055221f, 
    0.04563538f, -0.04534348f, 0.05614585f, -0.06117377f, -0.11237112f, -0.08092040f, -0.08715706f, 0.20222181f, 
    -0.17915550f, 0.03043694f, 0.11050679f, 0.02146708f, 0.06611771f, 0.03811157f, -0.03818693f, -0.16253154f, 
    -0.18646751f, 0.22700852f, 0.10006648f, -0.02219464f, -0.15965970f, -0.08522873f, 0.06865389f, -0.17522182f, 
    0.02266533f, 0.03722954f, -0.20775916f, 0.01571758f, -0.64257562f, 0.05716221f, 0.13118054f, 0.08986637f, 
    0.19587569f, 0.28253487f, 0.17269243f, 0.02205095f, -0.09286173f, 0.07905322f, 0.03962511f, 0.02379022f, 
    0.14436473f, 0.03974062f, 0.02263462f, 0.01353094f, 0.10883393f, -0.03115412f, 0.04435901f, -0.00093101f, 
    0.04010311f, 0.12323009f, -0.05922267f, 0.04067845f, -0.53309286f, -0.47022429f, -0.15857448f, -0.06553686f, 
    0.06363576f, 0.09933361f, 0.06701073f, -0.00568191f, 0.08363789f, -0.03295778f, 0.09747378f, 0.22982641f, 
    -0.29722106f, -0.15207852f, 0.18013027f, 0.06509303f, 0.14411569f, -0.09734624f, 0.02366812f, 0.10962477f, 
    -0.08338147f, 0.01979538f, -0.00288365f, -0.05184719f, 0.26541618f, 0.02474502f, 0.18599112f, 0.06898098f, 
    -0.10866733f, -0.20962031f, 0.03305976f, 0.00134563f, 0.12177785f, -0.21567352f, -0.01309372f, 0.01683689f, 
    0.03763263f, 0.07401510f, 0.00545110f, -0.26867765f, -0.14323530f, -0.08170085f, 0.04296800f, 0.03315631f, 
    0.07488032f, 0.00079428f, -0.06415071f, 0.07986401f, -0.01068664f, -0.21020079f, -0.00443461f, 0.12467789f, 
    -0.25671768f, -0.03248446f, 0.00255438f, -0.18063413f, 0.07629412f, -0.04145241f, 0.12227456f, 0.00499313f, 
    0.19404602f, -0.01059267f, -0.06825170f, -0.10199470f, -0.08769593f, 0.11713862f, -0.02443594f, 0.10597128f, 
    -0.21615639f, 0.00718744f, 0.05694805f, -0.06696054f, 0.03976754f, -0.02143130f, 0.10743577f, 0.05709619f, 
    -0.24191321f, -0.00513557f, 0.05961968f, -0.11504266f, -0.02015209f, 0.00783385f, -0.05041681f, 0.11630385f, 
    -0.03276785f, 0.23402554f, 0.03718686f, 0.19126211f, 0.14705512f, 0.08640811f, 0.07615511f, -0.06568735f, 
    -0.10822980f, 0.01541784f, -0.11057519f, 0.04770990f, 0.08110102f, 0.12014430f, 0.24339254f, -0.02408472f, 
    -0.06558079f, 0.03190508f, 0.06646521f, 0.09345378f, 0.09331083f, -0.02344711f, 0.13974734f, 0.09751267f, 
    0.20943211f, 0.20843028f, 0.20279372f, 0.09458476f, 0.09124178f, -0.03826585f, -0.18631218f, 0.03365665f, 
    -0.06371418f, 0.04537039f, 0.08167604f, 0.09386076f, -0.10129787f, 0.17039974f, 0.06361257f, -0.15350328f, 
    0.14129899f, -0.05104578f, 0.00927866f, 0.09135161f, 0.08857024f, 0.03237110f, 0.02384046f, 0.01558137f, 
    -0.02893246f, 0.02614307f, -0.17098621f, 0.05787198f, -0.11309591f, 0.05440027f, 0.02937232f, -0.02842480f, 
    0.02132270f, 0.08346752f, -0.07049238f, 0.04730338f, 0.06267941f, -0.10491126f, 0.10252526f, 0.02344320f, 
    -0.27392206f, -0.02504489f, -0.05059120f, -0.05911553f, 0.15761442f, -0.00358467f, -0.02719356f, 0.20056808f, 
    0.36629623f, 0.35413784f, -0.03171990f, 0.08842901f, -0.09118468f, 0.06700232f, 0.05891892f, 0.07000452f, 
    0.01442445f, -0.04342633f, 0.04009045f, 0.07365910f, 0.02564770f, -0.08958939f, -0.05302578f, -0.11561125f, 
    0.12207700f, -0.07034386f, -0.00595516f, -0.01718246f, 0.00162270f, -0.01876545f, -0.06862038f, 0.04619006f, 
    -0.14979699f, 0.11361811f, -0.03001563f, -0.30874553f, 0.00124883f, 0.08185972f, 0.04665105f, -0.03567334f, 
    0.12451719f, -0.04371658f, -0.06301612f, -0.06569381f, 0.08239205f, -0.03767484f, 0.18137668f, 0.31329957f, 
    -0.00528296f, -0.01011440f, 0.06056875f, 0.07459667f, -0.13741997f, -0.02671590f, 0.02622992f, -0.00118772f, 
    -0.14626516f, 0.04663874f, -0.18467371f, 0.24329002f, 0.03856311f, 0.04646913f, -0.05984816f, -0.12658045f, 
    -0.06033963f, -0.00103423f, -0.04126525f, 0.00918587f, 0.42654777f, -0.22485477f, -0.10869518f, -0.08186611f, 
    -0.20959041f, 0.15465558f, -0.08255133f, -0.04753548f, 0.07217999f, 0.08262966f, -0.04544293f, -0.00764233f, 
    0.10158070f, 0.14040954f, -0.08721676f, -0.33895805f, -0.04534142f, -0.02020597f, 0.00565308f, 0.00801852f, 
    -0.02519277f, 0.12098414f, 0.10760183f, 0.04646744f, 0.26999038f, 0.08140589f, 0.03922170f, -0.20094380f, 
    -0.04470464f, -0.04365736f, 0.15002371f, -0.00447214f, 0.04677762f, 0.06185529f, 0.14293244f, -0.05167442f, 
    0.26515996f, 0.08915835f, -0.02617419f, -0.16434914f, -0.13995762f, -0.05467233f, 0.02137119f, 0.08568504f, 
    0.04854888f, -0.04997947f, 0.06605852f, -0.04864072f, 0.10350517f, 0.01915826f, 0.12270516f, 0.18208277f, 
    -0.16250058f, -0.02301940f, -0.13841450f, -0.12447922f, 0.01784636f, -0.11351351f, 0.17340618f, 0.12422277f, 
    -0.17386483f, -0.28389153f, 0.06264094f, -0.16381764f, 0.13314852f, -0.01408400f, 0.05237592f, 0.10498214f, 
    0.08831687f, 0.04801521f, 0.04211753f, -0.11812688f, -0.02472804f, 0.18563092f, -0.01856098f, -0.00473707f, 
    -0.09105986f, -0.02453516f, -0.09088529f, 0.03022385f, -0.02178129f, -0.19723876f, -0.19370762f, -0.06661362f, 
    -0.03163255f, -0.03932773f, -0.29776454f, -0.57617664f, 0.17934357f, 0.14580397f, 0.04902135f, 0.04252148f, 
    0.06585948f, 0.12019741f, 0.06643465f, -0.05924433f, -0.09790311f, 0.26720962f, -0.27566701f, -0.23193984f, 
    0.04459273f, 0.09292746f, 0.06555331f, -0.12221461f, -0.10290702f, 0.01963702f, 0.03972034f, -0.14735575f, 
    0.16070022f, 0.05053090f, 0.26708883f, 0.04984632f, -0.07836550f, -0.05807723f, 0.10882051f, 0.14556669f, 
    0.03947131f, 0.00546019f, 0.00612713f, -0.09853159f, 0.42678031f, -0.12397616f, -0.00312800f, 0.00529644f, 
    -0.12220793f, -0.01521466f, 0.01340018f, 0.05083742f, 0.03722678f, -0.07462319f, 0.08600154f, 0.05853682f, 
    0.30781427f, 0.20292193f, -0.12588952f, -0.10364257f, 0.20390157f, 0.12452307f, -0.19209696f, -0.08818895f, 
    0.11083631f, 0.13005580f, 0.04132666f, 0.07054047f, -0.19838431f, 0.19869272f, -0.02236705f, 0.24213012f, 
    -0.23268645f, -0.04204252f, -0.18560237f, 0.03360787f, -0.28729928f, 0.03074824f, -0.10648691f, 0.09761707f, 
    0.18405780f, -0.02018198f, -0.01350379f, 0.16966668f, -0.13794474f, 0.05812269f, 0.01912186f, -0.17880143f, 
    -0.01512661f, 0.06585581f, -0.08199125f, 0.07832190f, -0.22929113f, -0.10032093f, 0.00617740f, 0.16237299f, 
    -0.12058527f, -0.09957623f, -0.15304430f, -0.34005406f, -0.04493291f, -0.17231628f, -0.00689394f, -0.04615860f, 
    -0.11278292f, 0.15067512f, 0.09818752f, 0.38894862f, -0.01093636f, -0.06954579f, -0.22985378f, -0.06325446f, 
    -0.09646816f, -0.09411600f, -0.24107254f, -0.14134936f, 0.03939578f, -0.01464448f, 0.11343710f, -0.05740409f, 
    0.14070691f, 0.11863904f, 0.00283246f, -0.09697874f, -0.05053687f, -0.02595013f, -0.07625391f, -0.15694018f, 
    -0.06345586f, -0.05539928f, 0.07839870f, -0.10477791f, 0.10657828f, 0.06396869f, -0.05933797f, 0.02292516f, 
    0.10509790f, 0.01218256f, 0.00484089f, 0.05293162f, 0.08511589f, 0.05887099f, -0.21022990f, -0.26556069f, 
    0.04381860f, 0.29148662f, 0.01628214f, -0.04937332f, -0.04741372f, 0.06520875f, 0.07848927f, 0.03205083f, 
    0.12589878f, 0.04493347f, -0.24483542f, -0.33664456f, 0.18736926f, 0.16600740f, 0.09875916f, -0.07654593f, 
    -0.04669378f, 0.09945086f, 0.06053081f, 0.01658033f, -0.28443399f, -0.17086530f, -0.35471991f, 0.01889233f, 
    -0.04122165f, 0.02670095f, -0.24447308f, -0.12061410f, 0.09385420f, 0.06223575f, -0.02368605f, -0.13003667f, 
    0.09361596f, 0.22727637f, 0.11223125f, 0.02820747f, -0.08055322f, -0.00912437f, -0.11870872f, -0.19418576f, 
    -0.05334781f, -0.04828277f, 0.08785809f, 0.00144163f, 0.14803319f, 0.04083725f, -0.00310626f, 0.19798423f, 
    0.21406224f, 0.11648738f, 0.10095622f, 0.05465820f, -0.20018691f, -0.10753085f, 0.07685999f, -0.14398502f, 
    0.31204352f, 0.38039565f, 0.25920433f, 0.13023905f, -0.00759314f, -0.12614845f, 0.01761402f, 0.00920008f, 
    -0.04052458f, 0.10225643f, 0.01758594f, 0.14430347f, -0.07429319f, -0.11127324f, 0.43935400f, 0.13813582f, 
    0.15594795f, 0.05797613f, 0.00269729f, 0.05516336f, -0.10743058f, 0.10030980f, 0.00169316f, 0.06825503f, 
    0.19423616f, 0.13829239f, -0.35567647f, -0.44275880f, 0.01067302f, 0.29871851f, -0.20189598f, -0.22167718f, 
    0.01050137f, -0.06985492f, -0.00829579f, -0.14263554f, 0.13216293f, 0.30524126f, -0.02132691f, -0.05683554f, 
    0.08184648f, 0.20836265f, 0.07020068f, 0.13556270f, 0.00285707f, 0.22645764f, -0.08156068f, 0.05168519f, 
    0.44669044f, 0.31053856f, 0.10588311f, 0.25403818f, -0.07584254f, -0.05356705f, -0.15749465f, -0.00824485f, 
    0.04306610f, 0.00570800f, -0.02558563f, 0.04074995f, -0.23507695f, 0.13230030f, 0.11509755f, -0.05070463f, 
    0.14084022f, 0.02971554f, 0.05399835f, 0.10726767f, -0.03300866f, 0.08380285f, -0.05914560f, -0.11942590f, 
    0.34091592f, 0.06292645f, 0.03977667f, 0.10354260f, -0.19757976f, 0.10928611f, -0.10265607f, -0.07491794f, 
    -0.11067958f, -0.04670108f, 0.06862948f, -0.13626899f, -0.12648249f, 0.11655352f, 0.00134691f, 0.24884711f, 
    -0.01013086f, -0.01087831f, 0.19690771f, 0.15423810f, -0.05316390f, 0.02108689f, -0.08651309f, -0.28645980f, 
    0.07382182f, -0.11607286f, -0.00345559f, 0.12282014f, 0.07243549f, 0.09617578f, 0.16474642f, 0.08931525f, 
    0.05395595f, 0.08443990f, -0.07784308f, -0.12826423f, 0.04561239f, -0.07726886f, 0.12871870f, -0.13496825f, 
    -0.18835166f, -0.16060624f, 0.08227473f, -0.16294684f, 0.10896180f, -0.02555415f, -0.08719784f, 0.01010592f, 
    0.03683427f, -0.18412508f, -0.21281812f, -0.01695666f, -0.07855877f, -0.10899537f, -0.10729764f, 0.04773691f, 
    0.06114455f, 0.06569590f, 0.06994401f, 0.09697618f, 0.04391098f, 0.06667188f, 0.13365829f, 0.00172528f, 
    -0.12874348f, -0.04929410f, 0.03574761f, -0.17077999f, 0.02692139f, -0.01067371f, 0.09649816f, -0.07061430f, 
    0.15285373f, 0.08721720f, -0.20003696f, 0.15596725f, -0.00036513f, -0.03033114f, -0.07575741f, -0.21148571f, 
    0.06701996f, 0.11631767f, 0.06371797f, 0.12768444f, 0.23486327f, -0.05265386f, 0.06467669f, 0.18271393f, 
    -0.07904065f, 0.09396100f, 0.03130293f, -0.07040546f, 0.08898503f, -0.10189459f, 0.22499911f, 0.01706239f, 
    -0.14613144f, -0.19414680f, -0.14333937f, -0.02425420f, 0.00088735f, -0.00209109f, -0.06905219f, 0.07478892f, 
    0.03955995f, -0.12151459f, 0.15019642f, -0.12327042f, 0.01744340f, -0.22236761f, -0.04097128f, -0.23924214f, 
    -0.11346631f, 0.09920259f, 0.06795641f, -0.03682219f, 0.04574666f, -0.06481113f, -0.04830703f, -0.18717077f, 
    -0.17140858f, -0.20313612f, -0.03088154f, -0.27428716f, -0.10819168f, -0.09193143f, -0.12992562f, 0.03067292f, 
    0.05815744f, -0.02383900f, -0.11824700f, 0.17667499f, 0.15223481f, 0.37043315f, 0.15110455f, -0.03085369f, 
    -0.10000249f, -0.08199140f, 0.03065951f, 0.19186403f, 0.04700735f, -0.04629576f, 0.16092275f, 0.07430223f, 
    -0.00483548f, 0.04381927f, 0.14056122f, 0.15195823f, -0.17668270f, 0.00348500f, 0.15128322f, -0.13639325f, 
    -0.02121370f, 0.04579296f, -0.04818428f, -0.10235093f, -0.00829045f, -0.00271131f, 0.01583139f, 0.04701394f, 
    -0.08774136f, -0.24501888f, -0.17141519f, 0.06097473f, -0.04127955f, 0.16818850f, -0.04564855f, 0.19363591f, 
    -0.06678848f, -0.07390697f, -0.05393883f, -0.15023233f, -0.02721780f, 0.04421851f, 0.00890245f, 0.15814392f, 
    0.01188889f, 0.06404935f, -0.08828482f, -0.01766237f, -0.08576379f, -0.01586066f, 0.14658415f, 0.14965440f, 
    0.05947580f, -0.02430513f, -0.03895941f, -0.03837562f, 0.04232683f, 0.04620966f, -0.05510592f, 0.07415319f, 
    0.11845640f, -0.01871040f, -0.10818276f, -0.03472284f, -0.08279645f, 0.10305174f, 0.01843484f, -0.17683613f, 
    -0.17343365f, 0.00756590f, 0.19486816f, 0.10567267f, -0.03075547f, 0.09023809f, -0.03276376f, -0.14455850f, 
    -0.14719063f, -0.02951794f, -0.04808413f, 0.02048329f, 0.00158753f, -0.00771338f, -0.06295402f, -0.15149093f, 
    0.22795339f, -0.02318775f, 0.12273380f, -0.02742847f, 0.04035641f, -0.05795265f, 0.13194992f, 0.00923528f, 
    0.14536785f, 0.05900570f, -0.02602601f, -0.00464129f, -0.21859002f, 0.30747059f, 0.10523263f, 0.22479984f, 
    0.14262609f, 0.00115984f, 0.09761285f, 0.00876073f, 0.13242131f, -0.09318051f, 0.16745344f, -0.08819392f, 
    -0.05220666f, 0.06474991f, -0.00066577f, -0.10031646f, -0.18187150f, 0.07911905f, 0.21487872f, 0.16551580f, 
    0.19255862f, -0.12681156f, 0.01231582f, -0.12680827f, -0.09440948f, 0.02224222f, -0.11249088f, -0.23358001f, 
    0.05403860f, 0.05775134f, -0.00845124f, -0.06791594f, 0.01881548f, -0.09664261f, 0.09454826f, -0.08012637f, 
    0.20424369f, -0.02081518f, -0.02207068f, 0.07338007f, -0.03856751f, 0.08811961f, 0.05091223f, -0.04914914f, 
    -0.05585488f, 0.09099519f, -0.06769182f, -0.07075007f, -0.10439414f, -0.07166623f, -0.00102848f, -0.01720517f, 
    -0.00850843f, 0.03682874f, 0.03238671f, 0.06405445f, 0.00252197f, 0.01339270f, -0.05466268f, -0.22608100f, 
    0.16641115f, 0.05904021f, 0.13382095f, -0.21505649f, -0.00405622f, 0.25622338f, -0.02265634f, 0.09322762f, 
    0.09163973f, -0.14984550f, 0.14137997f, -0.00897429f, 0.16130553f, 0.01292338f, 0.19943596f, -0.17886513f, 
    0.05833903f, 0.00178169f, 0.10841717f, 0.19135068f, 0.05713354f, 0.16605876f, 0.12632519f, 0.06409639f, 
    -0.08906444f, 0.01270182f, 0.04256108f, 0.02993291f, -0.00170314f, 0.11036696f, -0.04695012f, 0.03520518f, 
    0.02496135f, -0.08488408f, -0.14444159f, 0.10573494f, -0.09459603f, 0.02779873f, 0.18926083f, 0.02308700f, 
    -0.03285505f, -0.02738413f, 0.03799175f, -0.06652378f, -0.00911647f, -0.01174684f, 0.12828998f, 0.15202132f, 
    -0.29030898f, -0.18339719f, -0.10945301f, 0.06535096f, -0.02674118f, 0.19480434f, 0.24031414f, 0.01417104f, 
    0.08665046f, 0.08849083f, 0.04913360f, 0.16214736f, -0.34400961f, 0.02648416f, 0.17563637f, -0.23964809f, 
    0.03577447f, 0.01620085f, -0.10359275f, 0.00922394f, 0.05250100f, 0.01392403f, 0.04941772f, 0.07272318f, 
    0.14435148f, 0.01562149f, 0.01038364f, -0.14596058f, 0.02767013f, -0.01549498f, 0.07823686f, 0.11622672f, 
    0.03523435f, 0.04678291f, 0.05336763f, 0.14802338f, -0.10778756f, 0.14610295f, -0.00983582f, 0.10470265f, 
    -0.12183010f, 0.20596488f, 0.17537314f, -0.10208100f, 0.02665242f, -0.12686796f, 0.12358306f, 0.10858442f, 
    0.06072462f, 0.17639980f, -0.22813405f, 0.03859672f, -0.07504316f, -0.04125563f, 0.00310490f, -0.10410363f, 
    0.06652665f, -0.03624960f, 0.06043663f, 0.07890175f, 0.40171582f, 0.16651540f, 0.44261885f, 0.51505023f, 
    -0.01562484f, 0.01442393f, 0.06356635f, -0.09517021f, 0.11641090f, -0.11733712f, 0.12167479f, 0.08645687f, 
    0.24237038f, 0.00542627f, 0.16751164f, 0.19349270f, 0.11070215f, 0.06141442f, 0.13262591f, 0.12969613f, 
    0.01801423f, 0.13734460f, 0.03745325f, -0.02470778f, -0.05939106f, -0.00425896f, -0.06518593f, -0.11664130f, 
    0.15493102f, 0.05631477f, 0.04572807f, 0.07476667f, 0.05653242f, 0.06532807f, -0.01376250f, -0.23245369f, 
    -0.27357206f, -0.06623521f, -0.28503421f, -0.08765472f, 0.11822345f, 0.10649331f, 0.03222273f, 0.04414102f, 
    0.24647717f, -0.10532811f, -0.05251223f, -0.09807744f, -0.18722199f, -0.10618021f, -0.17646368f, -0.08339514f, 
    0.03106657f, -0.02831974f, 0.09905354f, 0.12472948f, 0.09014712f, -0.11923202f, -0.00076804f, 0.07689217f, 
    -0.17608178f, -0.06120796f, -0.02642683f, -0.07197709f, 0.09676947f, 0.08572445f, -0.06529506f, 0.22190265f, 
    -0.11226231f, -0.06588206f, -0.04425805f, -0.01094817f, -0.04179383f, -0.05532856f, 0.16066371f, 0.08009327f, 
    -0.03223161f, 0.14557138f, 0.01691786f, 0.07107782f, -0.01566039f, 0.03556454f, -0.13476804f, -0.04462332f, 
    -0.20412037f, 0.18399431f, 0.34841040f, -0.10570907f, -0.07727444f, 0.04541572f, 0.08297076f, -0.06596006f, 
    -0.02475445f, -0.06835426f, -0.10733484f, -0.02556684f, -0.37179542f, -0.08671019f, 0.07524453f, -0.04386864f, 
    0.19823088f, 0.05153888f, -0.11197764f, 0.13727149f, 0.04106902f, -0.00509975f, 0.08512759f, -0.01383818f, 
    -0.22563580f, -0.13226876f, -0.07893510f, -0.03309628f, -0.06389328f, -0.09132303f, 0.05254392f, -0.04204058f, 
    0.12934592f, 0.03249489f, -0.08016756f, 0.05301029f, 0.31188941f, 0.16106023f, -0.00829620f, -0.14139214f, 
    0.15430883f, -0.06988742f, 0.07796884f, 0.00337651f, -0.10268396f, 0.06927427f, 0.08636522f, -0.00315348f, 
    -0.18206179f, 0.13144977f, -0.02766742f, -0.09132829f, -0.02553030f, 0.11640231f, -0.09718782f, 0.14942785f, 
    -0.04326544f, 0.00978128f, 0.05805501f, 0.11972450f, -0.18705697f, -0.16586480f, 0.00474428f, 0.01761362f, 
    0.08907603f, 0.08340173f, 0.09422164f, 0.19322789f, -0.01590437f, -0.07643785f, -0.05623049f, 0.07397746f, 
    0.45067340f, 0.11433328f, -0.19536470f, -0.03148175f, 0.00714751f, 0.05224236f, 0.02656536f, 0.18466243f, 
    0.06146199f, 0.00165650f, 0.05262772f, -0.06541023f, 0.06989353f, -0.05938008f, 0.09442636f, 0.08431979f, 
    -0.08645082f, 0.07330003f, -0.05028864f, -0.15240829f, 0.02329216f, -0.07777530f, -0.04378501f, 0.05315393f, 
    0.11042094f, 0.00525958f, -0.04705770f, -0.41337910f, -0.19978647f, 0.16599990f, 0.08672903f, -0.06562969f, 
    -0.18520558f, 0.12804271f, 0.11139787f, -0.11784730f, 0.15054618f, 0.11435843f, -0.03236037f, 0.21041638f, 
    -0.18533105f, -0.17334759f, -0.01208171f, -0.15561746f, 0.05498591f, 0.10524425f, 0.03494721f, 0.05169833f, 
    -0.16684797f, 0.10576518f, -0.32463109f, 0.30811328f, 0.07923038f, 0.03969110f, -0.04894590f, -0.01708183f, 
    0.02450339f, 0.04471777f, 0.06088607f, -0.03822587f, -0.26243153f, 0.08787232f, -0.14016719f, 0.17371243f, 
    0.03569305f, -0.07771776f, -0.02454829f, 0.07564423f, 0.07082452f, -0.08090784f, -0.12870778f, -0.13298841f, 
    0.00416768f, 0.21792722f, 0.07147136f, -0.03691578f, -0.02735918f, -0.17510730f, 0.21627352f, 0.08058657f, 
    0.11005417f, -0.07884215f, -0.06843802f, -0.32684848f, 0.14565893f, 0.02001594f, -0.03934052f, -0.07622829f, 
    0.00067113f, -0.06831355f, 0.14899062f, 0.02764784f, -0.07781166f, -0.16519473f, 0.09492705f, -0.03203261f, 
    0.05882226f, -0.05969628f, 0.16753301f, -0.17206334f, 0.02477034f, -0.13809797f, 0.21763647f, 0.15200071f, 
    -0.06184809f, -0.04739815f, -0.20403166f, 0.10073827f, 0.01439316f, 0.04613522f, -0.00125916f, 0.06137500f, 
    0.08571086f, 0.08917566f, 0.06925191f, 0.31208041f, 0.02984454f, -0.16309370f, -0.07797321f, -0.44005331f, 
    -0.08302998f, -0.26966438f, 0.24656437f, -0.04594882f, 0.10437699f, -0.02858826f, 0.02524616f, -0.11626280f, 
    0.14651975f, -0.02383014f, -0.02607968f, 0.03031530f, 0.17915361f, -0.16470121f, -0.25522828f, 0.22834621f, 
    -0.00338841f, 0.01749015f, -0.05360462f, 0.16368498f, 0.03880630f, -0.03681417f, 0.07019039f, -0.03754909f, 
    -0.23540474f, -0.10459048f, 0.08542842f, -0.08019957f, -0.00887469f, -0.07258913f, 0.05322712f, -0.16015188f, 
    0.07206332f, 0.07250172f, -0.06090009f, 0.03503003f, -0.09203178f, 0.22139762f, 0.10049164f, -0.14648235f, 
    -0.04437213f, 0.10807621f, 0.03689238f, -0.00216918f, -0.14616507f, -0.08806098f, 0.18110286f, -0.01456827f, 
    0.12091998f, -0.12317003f, -0.08880603f, 0.05256085f, -0.01966557f, 0.18155742f, 0.17571892f, 0.12423192f, 
    -0.09936178f, -0.03379254f, 0.00270762f, 0.09863152f, -0.14065917f, 0.02885465f, 0.04089686f, 0.18473476f, 
    -0.01986429f, 0.06748244f, -0.06842510f, 0.05158749f, 0.01835046f, 0.02676097f, 0.10608293f, 0.03401690f, 
    0.02403763f, 0.04880992f, -0.05423978f, -0.01026306f, -0.03575053f, -0.04210109f, -0.06728639f, -0.03286435f, 
    0.04688919f, 0.01439551f, 0.01433850f, -0.06445972f, -0.01730820f, 0.02191787f, -0.05668866f, 0.01359802f, 
    -0.01853979f, 0.01335956f, -0.03089579f, 0.03354111f, -0.02610050f, 0.05122995f, 0.02670035f, -0.00309374f, 
    0.01539150f, -0.05684552f, -0.06704680f, -0.02318192f, 0.03163110f, -0.06592015f, 0.03481330f, 0.03559892f, 
    -0.05046405f, 0.00411359f, 0.05721860f, -0.01978736f, -0.02123661f, -0.05347292f, -0.02329158f, 0.04742669f, 
    0.05060837f, -0.06472059f, -0.03264334f, -0.05418244f, -0.07840803f, -0.01429476f, -0.02145674f, -0.06052064f, 
    0.03231991f, 0.06126514f, 0.03092839f, 0.04714179f, -0.01761851f, 0.06483196f, 0.03033312f, -0.07486007f, 
    -0.07170749f, 0.02429398f, -0.03058304f, 0.02450787f, -0.03284484f, -0.03677673f, -0.00118561f, 0.00020804f, 
    -0.03194348f, -0.00855941f, 0.01187133f, -0.00060241f, 0.01424633f, 0.00871260f, -0.04939368f, 0.02048973f, 
    -0.05391200f, 0.01353178f, 0.04409790f, -0.05810600f, -0.01103419f, -0.01909479f, 0.03646807f, -0.04857526f, 
    0.03050167f, -0.03038638f, -0.01386674f, 0.01488435f, 0.01391168f, -0.03514187f, -0.03529653f, -0.05167305f, 
    0.01275825f, 0.05415536f, -0.02423690f, 0.00160721f, -0.05028071f, 0.04268647f, -0.00630851f, -0.05402072f, 
    0.03697763f, -0.00228634f, 0.00856262f, 0.01515250f, 0.06878810f, -0.07530944f, -0.06573620f, 0.05873713f, 
    -0.03058632f, -0.03806894f, 0.05572550f, -0.06005270f, 0.01575975f, 0.04621922f, 0.02028675f, -0.02602026f, 
    -0.05931380f, 0.02890592f, -0.00583806f, -0.07901724f, -0.04165613f, -0.05829095f, 0.00099677f, 0.04277153f, 
    -0.04127550f, 0.02956848f, 0.00877636f, 0.04468637f, -0.01164805f, 0.05238016f, -0.00884106f, -0.00431369f, 
    -0.04644848f, -0.06200663f, -0.02673555f, -0.02417707f, -0.05140616f, 0.05494532f, 0.05391297f, -0.04541281f, 
    -0.04144182f, -0.04037557f, 0.03117873f, 0.00139009f, 0.05869969f, -0.02481008f, -0.03420869f, -0.04429223f, 
    -0.01806581f, -0.02542466f, 0.00443822f, -0.04555704f, -0.06640425f, 0.02320034f, -0.06969033f, 0.04315145f, 
    0.02708830f, 0.05887919f, -0.00956165f, -0.05147488f, -0.04714712f, -0.02681013f, -0.01480164f, 0.07987621f, 
    0.05374260f, -0.06803031f, -0.06550824f, -0.02117151f, -0.03207656f, -0.03989580f, 0.03275409f, -0.03620758f, 
    0.06723876f, -0.01854480f, 0.07154818f, 0.00034404f, -0.04289192f, -0.02518655f, -0.05975684f, 0.00767828f, 
    -0.02557684f, -0.02137840f, -0.05282163f, 0.04801548f, 0.00955232f, 0.03012922f, 0.00932059f, -0.06731729f, 
    0.06035627f, 0.06634220f, 0.05178063f, 0.00700444f, 0.00660855f, 0.03368474f, 0.00680243f, -0.05599733f, 
    0.07674446f, 0.04904804f, -0.10675254f, 0.01659350f, 0.02382231f, 0.09340418f, -0.02006073f, 0.23583685f, 
    0.00080316f, 0.04755109f, 0.01143641f, 0.01363273f, -0.12802453f, -0.01456980f, 0.11218489f, -0.05087602f, 
    0.03502047f, 0.01423937f, -0.07248947f, -0.07616564f, 0.02948296f, 0.00732716f, -0.06990246f, -0.05568856f, 
    -0.03271745f, -0.05006749f, 0.18287674f, -0.21750660f, -0.05726453f, 0.19925895f, -0.06328823f, 0.10881642f, 
    -0.13024029f, 0.00472656f, 0.15613058f, -0.04084561f, -0.03539558f, -0.00075922f, -0.25203779f, -0.13275598f, 
    0.01743699f, 0.04164388f, 0.03883007f, -0.07054888f, 0.05258858f, 0.13436985f, -0.01367174f, -0.01509632f, 
    -0.13084857f, 0.08934604f, -0.23687334f, -0.12050724f, -0.03003780f, 0.11574483f, -0.11907808f, -0.05885334f, 
    -0.00319701f, -0.04187664f, 0.01260069f, 0.00741709f, 0.23191312f, 0.11011236f, 0.14567614f, 0.04810356f, 
    -0.03060148f, -0.12242358f, -0.04538226f, 0.03350332f, -0.03345482f, -0.05597480f, -0.05603919f, 0.08977975f, 
    0.15757456f, 0.00163558f, 0.12297340f, 0.15846184f, 0.06829151f, -0.07317198f, 0.01569816f, -0.01665235f, 
    -0.04201967f, 0.04884645f, -0.07634618f, -0.11641409f, 0.00907286f, 0.08623544f, 0.11197069f, 0.18863145f, 
    -0.09043752f, -0.04908254f, 0.09910797f, -0.02825521f, -0.10705699f, 0.05650165f, 0.00678716f, -0.04144500f, 
    -0.08381276f, -0.05517804f, 0.01853734f, 0.14519167f, -0.00170308f, -0.12266774f, 0.10275444f, 0.02001476f, 
    -0.01735499f, 0.03461217f, 0.03528284f, -0.05919741f, 0.03049418f, 0.11512168f, 0.03418559f, 0.01723480f, 
    0.02454580f, 0.09152725f, 0.01940652f, 0.11056858f, -0.09401230f, -0.06568713f, 0.07283277f, -0.24602555f, 
    -0.01309154f, -0.10046519f, -0.05143704f, 0.34389168f, 0.08391885f, -0.02966418f, 0.10451928f, 0.00664539f, 
    0.02991487f, -0.02494313f, -0.05460597f, 0.03718047f, 0.24494387f, 0.12561090f, -0.03543068f, -0.00390277f, 
    -0.18854487f, 0.10295783f, 0.11164492f, -0.05033078f, -0.04485863f, 0.01257794f, 0.11720765f, 0.05197192f, 
    0.23802082f, 0.00426910f, 0.12018745f, 0.00849407f, 0.05758286f, 0.07735305f, 0.01675171f, -0.15523352f, 
    0.05974396f, -0.01324037f, -0.09143639f, -0.07443465f, 0.12596546f, 0.32154146f, 0.04321920f, -0.05133326f, 
    -0.07129545f, 0.04054710f, -0.03530317f, 0.02718209f, -0.04455145f, 0.02000143f, 0.04713181f, -0.03176364f, 
    -0.09633455f, -0.20368978f, -0.03024577f, 0.18298645f, -0.02331829f, -0.00354242f, 0.25662905f, 0.05131352f, 
    -0.03226990f, -0.04981707f, 0.02678537f, 0.04495841f, 0.01155269f, 0.14734413f, 0.04483579f, 0.26690313f, 
    -0.11561172f, 0.02905150f, -0.09156384f, 0.04690345f, -0.11544729f, 0.03857658f, 0.12747061f, -0.01993755f, 
    -0.05270757f, 0.03197781f, 0.01961860f, -0.11808523f, -0.05255949f, 0.12276006f, -0.04056170f, -0.24337050f, 
    0.07286365f, -0.09109729f, 0.02139185f, 0.03900522f, 0.06415834f, -0.03748446f, 0.02697833f, 0.05970876f, 
    -0.04053229f, -0.03050773f, 0.04459901f, 0.10916847f, 0.01028292f, -0.00717057f, 0.13817984f, 0.04935489f, 
    -0.23192160f, -0.01295977f, -0.05931633f, 0.06612792f, 0.10242558f, -0.04150327f, 0.11200043f, -0.03501964f, 
    0.11955010f, -0.01557428f, -0.04343934f, 0.04726283f, 0.24756853f, -0.26108259f, 0.14921886f, 0.25063291f, 
    0.00261111f, 0.11316372f, -0.05287643f, 0.06142653f, 0.07871189f, -0.11132096f, 0.02343800f, 0.23754843f, 
    -0.15970415f, 0.03085050f, 0.09962024f, 0.12933007f, 0.04179543f, -0.10716345f, 0.06326163f, 0.01926283f, 
    -0.00459646f, 0.06246026f, -0.04133379f, -0.02795263f, -0.33162412f, 0.00510649f, -0.09937209f, -0.05533182f, 
    0.03921836f, 0.02508087f, 0.05280717f, 0.06338909f, -0.08682608f, 0.08646097f, 0.06306245f, 0.14806931f, 
    0.02213443f, 0.02156571f, 0.01105883f, -0.07169728f, 0.04118893f, -0.01008945f, 0.00341953f, -0.07052629f, 
    -0.03317789f, 0.12841424f, 0.17631638f, 0.11161841f, 0.13506120f, -0.18311577f, -0.05561796f, -0.04040819f, 
    0.11330843f, 0.10649040f, -0.02528146f, 0.03927873f, 0.04404783f, 0.08322664f, 0.00479906f, 0.05436184f, 
    -0.07888974f, -0.15210256f, -0.10211899f, -0.13573961f, 0.07836120f, 0.06034211f, -0.04002513f, 0.01363862f, 
    -0.00414226f, 0.04639321f, 0.06776851f, 0.07241424f, -0.02006008f, -0.01184400f, -0.03317484f, -0.01285992f, 
    0.08128835f, -0.00952192f, -0.04420123f, -0.06048521f, 0.16601771f, 0.04960683f, 0.10056064f, 0.24508512f, 
    0.15619187f, 0.00765091f, 0.08447474f, -0.06309756f, -0.05156340f, -0.00866820f, -0.00582360f, 0.10892789f, 
    -0.06523038f, 0.04938512f, -0.01345379f, 0.15841927f, 0.03247295f, 0.07473698f, -0.02540412f, -0.03969109f, 
    0.04775360f, 0.01970354f, -0.02024108f, 0.01062806f, 0.02681794f, -0.04059813f, -0.11594852f, 0.07647399f, 
    -0.10555563f, 0.07814763f, 0.10683228f, 0.18641688f, 0.10132743f, -0.02902881f, 0.13374494f, 0.09878252f, 
    -0.00274362f, 0.14069989f, 0.01224950f, 0.13341753f, -0.37173641f, 0.09856223f, -0.12526298f, 0.00859447f, 
    -0.07695663f, 0.10116322f, 0.00824582f, 0.01147629f, 0.01739768f, 0.11618081f, -0.01431765f, 0.00326939f, 
    0.24340504f, 0.05261090f, -0.05614084f, -0.10923028f, 0.09262661f, -0.13604803f, -0.09929010f, -0.12686752f, 
    0.08470833f, -0.03845703f, 0.07409466f, -0.07766004f, -0.09345858f, -0.05509320f, -0.20849609f, -0.07801539f, 
    -0.03623080f, -0.08774456f, 0.11812861f, 0.05348326f, 0.08641693f, -0.11476170f, -0.13864368f, -0.02357620f, 
    -0.05027016f, -0.05476692f, -0.03450204f, -0.04639118f, -0.01961869f, 0.04854807f, 0.01860099f, 0.02485499f, 
    -0.03120426f, -0.05564434f, -0.02893057f, 0.05698324f, -0.05737672f, 0.04304247f, -0.07616720f, 0.02792043f, 
    -0.05790700f, -0.03880534f, 0.04973677f, 0.05408727f, -0.07275784f, -0.03653231f, 0.04145470f, 0.03572456f, 
    -0.02577010f, 0.00657375f, -0.05319128f, -0.06102442f, 0.00467541f, 0.05664901f, 0.05800738f, 0.01388057f, 
    0.00165309f, 0.04753601f, -0.07987612f, -0.05259204f, -0.03240190f, 0.00242328f, -0.02586194f, 0.00378350f, 
    0.03196374f, -0.04431312f, -0.03833655f, 0.05322453f, -0.01765648f, -0.07752563f, -0.04909304f, -0.04937253f, 
    0.05303988f, -0.01421009f, 0.01790763f, 0.05802854f, -0.00453194f, -0.08124476f, -0.04221020f, -0.06097703f, 
    -0.05166119f, -0.06641796f, -0.03409878f, 0.03114408f, 0.00236456f, -0.04326637f, -0.04301950f, -0.01191834f, 
    0.05672755f, 0.04092079f, -0.02108389f, 0.00176309f, 0.01470822f, -0.07022454f, -0.02592322f, -0.01572090f, 
    0.01339311f, 0.00459170f, 0.02675997f, 0.01310226f, -0.06930787f, 0.04779651f, -0.04318064f, 0.06103982f, 
    0.01703387f, -0.07484604f, -0.07902350f, 0.01473556f, 0.01814670f, 0.03534067f, -0.01010572f, -0.00425489f, 
    0.02895099f, -0.00589834f, -0.00670545f, -0.07413385f, 0.02582584f, 0.02520361f, -0.01718048f, -0.05359049f, 
    -0.05659575f, 0.06341057f, 0.05024852f, -0.00797958f, -0.01178633f, 0.05761052f, -0.00482639f, 0.02549974f, 
    0.03313354f, 0.05607483f, -0.04502692f, -0.05161576f, -0.04795739f, 0.00795229f, -0.07585531f, -0.03557705f, 
    0.04328647f, 0.05152734f, -0.04772312f, -0.02717249f, -0.04750100f, 0.03683614f, -0.06923244f, -0.06362823f, 
    -0.00241847f, -0.03506936f, -0.07064143f, 0.05314549f, -0.03781790f, -0.00413627f, 0.01776513f, -0.07199267f, 
    0.04747717f, 0.05973737f, -0.04842760f, -0.00889235f, -0.01250583f, -0.03209621f, 0.03973480f, -0.00180814f, 
    0.03606084f, -0.01358513f, 0.05680715f, -0.06222885f, -0.05703107f, 0.06260558f, -0.03652185f, -0.01213204f, 
    0.02145307f, 0.00518807f, -0.04559969f, 0.03415694f, 0.02906835f, -0.07776277f, 0.04379003f, -0.07884835f, 
    0.02406642f, -0.02849573f, 0.03277503f, -0.00550184f, -0.01738995f, -0.01634333f, 0.03843231f, -0.06944465f, 
    0.02477152f, 0.03568691f, 0.02963658f, 0.04419924f, 0.03759470f, -0.02268166f, -0.01089723f, -0.04233424f, 
    -0.00798079f, 0.05141619f, -0.03994448f, -0.02000132f, -0.07614699f, -0.07443278f, -0.02724192f, -0.02483499f, 
    0.05382660f, -0.06634130f, -0.06639683f, -0.00241364f, -0.05902312f, -0.03844082f, 0.00497293f, 0.06248536f, 
    -0.01552376f, -0.04129326f, 0.04800537f, -0.01111450f, -0.06550241f, -0.07743248f, 0.00764045f, -0.05444915f, 
    0.41576278f, -0.00872339f, -0.08864686f, -0.02213791f, 0.14664017f, -0.07784182f, 0.02269924f, 0.14266603f, 
    -0.01601848f, 0.06535546f, 0.04006527f, 0.02964706f, -0.01098225f, 0.12267010f, -0.11409844f, -0.02161927f, 
    -0.13745964f, 0.11447179f, -0.03515032f, -0.02549869f, -0.04273513f, -0.10919642f, -0.08141922f, -0.00918014f, 
    0.41937047f, 0.01307039f, -0.02721008f, 0.10472859f, -0.13188408f, 0.03582750f, 0.05243201f, -0.02425021f, 
    0.05286833f, 0.11013064f, 0.08027607f, 0.14550813f, 0.01751509f, 0.24047042f, -0.01150225f, -0.12347992f, 
    0.10418536f, -0.23967263f, -0.06948096f, -0.35854322f, -0.11054154f, -0.06876732f, -0.09063212f, -0.07779175f, 
    0.13903111f, 0.15219527f, 0.00028814f, 0.28935653f, 0.08559218f, -0.04041102f, -0.05838110f, 0.10405786f, 
    -0.03800117f, 0.02904909f, -0.02069581f, -0.00145352f, 0.09626018f, 0.11584196f, -0.08930999f, 0.11440402f, 
    0.03135955f, -0.12736784f, -0.06044656f, -0.04847049f, 0.11064186f, -0.01237400f, 0.02343238f, -0.06758475f, 
    -0.21418937f, -0.10616753f, -0.10125217f, 0.08730689f, -0.03581246f, -0.00975269f, -0.03067260f, 0.10556156f, 
    0.20598461f, -0.09655398f, -0.06046827f, -0.07542929f, -0.05609883f, 0.28797838f, -0.10246974f, 0.01389066f, 
    0.00276233f, -0.00792814f, 0.10073344f, -0.01708594f, -0.01559805f, 0.06876387f, 0.07914507f, -0.00874698f, 
    0.10903657f, 0.09011251f, 0.19899161f, -0.07835917f, 0.08776518f, -0.10938352f, -0.03801229f, 0.01541604f, 
    0.07983457f, 0.02731494f, -0.02254422f, 0.01686176f, -0.03643937f, 0.00629615f, -0.13625681f, -0.11084194f, 
    0.15651464f, -0.04792714f, -0.02720153f, 0.08290543f, 0.00294122f, -0.02229978f, -0.20361149f, -0.44586113f, 
    -0.08290225f, 0.00267488f, 0.19839925f, -0.19987395f, -0.02527837f, 0.12364405f, -0.00767602f, -0.08768910f, 
    0.01787540f, -0.13870321f, -0.02065233f, 0.07135560f, 0.06349965f, -0.19687730f, -0.03341723f, 0.23910490f, 
    0.03831828f, 0.07693978f, -0.01324324f, -0.02666451f, -0.09403098f, 0.10114783f, 0.14169116f, -0.03605121f, 
    -0.14055274f, -0.17567086f, 0.00591672f, 0.04809179f, -0.02380703f, -0.06630060f, -0.07135638f, -0.12248619f, 
    -0.04187032f, -0.17566180f, 0.07138880f, 0.16173618f, 0.39825159f, -0.11302435f, 0.26276883f, 0.23255374f, 
    0.05652229f, 0.09360822f, -0.06876428f, 0.04965345f, -0.10664311f, 0.03169341f, -0.04782638f, 0.22769125f, 
    -0.09733015f, 0.15180944f, -0.11236244f, -0.03876986f, -0.10164910f, 0.27547973f, 0.11894912f, 0.09992475f, 
    0.05190017f, -0.03546638f, 0.02493816f, 0.10755693f, 0.02056071f, 0.08025735f, -0.09888359f, 0.02359771f, 
    -0.04277485f, 0.18434952f, -0.00867770f, 0.13162290f, -0.12954313f, 0.24598329f, 0.04446269f, 0.22021654f, 
    -0.07570449f, -0.03140238f, 0.02162057f, 0.00055250f, 0.21531956f, 0.16703200f, -0.11675494f, -0.11033821f, 
    0.09374852f, 0.16289365f, -0.15973762f, 0.20316303f, -0.07539634f, -0.09944063f, 0.06433003f, -0.02759634f, 
    -0.21830207f, -0.04703070f, -0.16366662f, 0.02722315f, 0.03825117f, -0.13694163f, -0.16300654f, -0.11199734f, 
    -0.26846319f, 0.04111143f, -0.07632083f, 0.20817925f, 0.03331744f, -0.13279632f, -0.03399043f, -0.06592857f, 
    0.02398744f, 0.03403628f, -0.04080267f, -0.04404045f, -0.06564534f, -0.17543125f, -0.04151618f, -0.08115561f, 
    -0.05950867f, -0.00230606f, 0.03400252f, 0.16223401f, -0.10387009f, 0.02148130f, -0.01655400f, -0.08690135f, 
    -0.12980324f, -0.24834330f, 0.01936610f, -0.16048862f, 0.17643714f, -0.02424966f, 0.06367345f, 0.08192027f, 
    0.01612528f, -0.04330058f, -0.07817929f, -0.09215529f, 0.32934490f, -0.20389132f, 0.19042324f, 0.08604015f, 
    -0.05361313f, 0.06525527f, 0.07025875f, 0.04751945f, -0.20475985f, -0.06235156f, -0.18619530f, 0.09645191f, 
    0.15742636f, 0.19958733f, 0.34055641f, 0.13098480f, 0.22949821f, 0.06889710f, -0.11391699f, -0.14008561f, 
    -0.03070587f, 0.11278465f, 0.13781120f, 0.12277069f, 0.22597502f, 0.10490137f, -0.06785274f, -0.06832649f, 
    -0.12440346f, 0.18127155f, 0.00814146f, -0.06339378f, 0.02463753f, 0.05152936f, 0.03761508f, -0.09041267f, 
    0.03059836f, 0.14464684f, -0.18035351f, -0.00378385f, 0.02844191f, -0.03346379f, 0.15194914f, -0.05728413f, 
    -0.02961294f, 0.02180239f, -0.00477885f, -0.11699968f, -0.16875848f, -0.21005742f, -0.13284916f, 0.00595782f, 
    -0.09139878f, -0.05466888f, -0.07715602f, 0.03407980f, -0.07810097f, -0.12557043f, -0.05099651f, -0.24136487f, 
    -0.03887025f, 0.13135238f, 0.08559863f, 0.03580447f, -0.02699052f, -0.15983666f, -0.12565660f, -0.07016006f, 
    -0.09274299f, 0.06870128f, -0.04099516f, -0.07899044f, 0.06490446f, 0.15367433f, 0.13441303f, 0.27010828f, 
    0.09564479f, 0.17130095f, 0.01090453f, 0.09938621f, -0.03423483f, -0.09890717f, 0.00124455f, 0.11660222f, 
    0.22188342f, 0.17505024f, 0.35975641f, 0.20323840f, 0.01538692f, -0.16316530f, -0.18346235f, -0.00335787f, 
    -0.11188340f, 0.09258610f, 0.05608504f, 0.14012387f, 0.28768992f, -0.13427053f, 0.20226415f, -0.12315960f, 
    0.15001935f, 0.04901762f, 0.09533906f, -0.01571140f, 0.01579086f, 0.26186547f, -0.22550616f, -0.18594044f, 
    -0.03245274f, 0.06313554f, -0.18014134f, -0.06300258f, -0.01027361f, 0.09256211f, -0.11909877f, -0.03030143f, 
    -0.08521261f, -0.07952250f, -0.15827163f, -0.14365560f, 0.20090649f, 0.20150483f, 0.20364544f, -0.08922373f, 
    0.07079501f, 0.21346660f, -0.09552588f, 0.06589728f, 0.08908302f, 0.09611429f, -0.06995505f, 0.03601722f, 
    0.00668461f, 0.05049952f, -0.05794182f, -0.04204011f, -0.02938446f, -0.02263287f, 0.05201317f, -0.03088581f, 
    0.01022684f, 0.01046619f, 0.04371719f, -0.00094933f, 0.01130478f, -0.00406616f, -0.07694656f, 0.06420659f, 
    0.04451161f, -0.01863341f, -0.00373270f, 0.04881108f, -0.03688048f, 0.03891075f, 0.00285609f, -0.03195808f, 
    0.01856518f, -0.07691985f, 0.06119691f, 0.01552450f, 0.03265106f, 0.00364995f, 0.03504167f, 0.01294122f, 
    -0.04460550f, -0.05949467f, -0.04673292f, -0.01167852f, -0.02371997f, -0.02496253f, 0.00199319f, -0.02462007f, 
    0.01255091f, 0.03288292f, -0.00600283f, -0.04133985f, 0.01944589f, -0.06127688f, 0.00429205f, -0.05054284f, 
    0.05836684f, 0.02414636f, 0.05791381f, -0.04117204f, 0.05864230f, 0.00396712f, -0.03567124f, 0.00772725f, 
    0.06336483f, -0.03175905f, 0.05269919f, -0.04424144f, 0.01703975f, -0.02401664f, -0.02338190f, -0.05926063f, 
    -0.01904033f, -0.00800806f, -0.06721340f, 0.03684117f, -0.04820504f, -0.00502019f, -0.03459210f, -0.05188562f, 
    -0.02745870f, -0.03995824f, 0.01444428f, 0.01692178f, -0.05444496f, 0.00812592f, -0.02412171f, 0.05440236f, 
    -0.00606416f, -0.01476129f, -0.06384272f, 0.03319981f, -0.05106235f, -0.05380527f, 0.01059129f, -0.06125895f, 
    -0.01765378f, -0.01282301f, -0.04765271f, -0.04121590f, -0.06923553f, -0.00101674f, -0.06948692f, -0.06391315f, 
    -0.02332218f, -0.06271763f, -0.04655795f, -0.04298841f, 0.05382060f, -0.03102006f, -0.06951961f, -0.04603181f, 
    0.02685218f, 0.05970327f, -0.00917329f, -0.02322386f, -0.04376669f, 0.04812300f, 0.04136571f, 0.03104461f, 
    -0.04683398f, 0.06231786f, 0.02363688f, 0.03899555f, 0.06429420f, -0.01761232f, 0.04462451f, -0.00228242f, 
    0.03125025f, -0.03662407f, -0.06433237f, -0.07040957f, -0.04018895f, 0.04487140f, -0.05074762f, -0.04617750f, 
    0.02800681f, -0.04003979f, -0.07193292f, 0.03007653f, 0.02127624f, 0.02364673f, -0.03439369f, -0.06406764f, 
    -0.05065863f, 0.04112951f, 0.00895496f, -0.05652606f, -0.07217425f, 0.04108560f, -0.01605256f, 0.06549405f, 
    -0.06255306f, -0.00812779f, 0.05804948f, -0.01194298f, -0.06824283f, -0.06611025f, -0.02492222f, 0.01828477f, 
    0.00810870f, 0.04852383f, -0.02047527f, -0.03318292f, -0.02243494f, 0.01219012f, -0.02356187f, 0.00359661f, 
    0.04613978f, 0.04274984f, -0.06241972f, 0.00734334f, -0.00715434f, -0.02106397f, 0.05839337f, -0.03869013f, 
    0.00904283f, -0.02009934f, 0.01363711f, 0.06512342f, -0.01411695f, -0.04845268f, -0.06231369f, -0.02259816f, 
    0.02752812f, -0.07083362f, 0.03484228f, -0.07304873f, -0.07530794f, 0.05804551f, -0.04478455f, -0.03111066f, 
    0.00471243f, 0.01510936f, -0.03535151f, 0.03256602f, -0.01758378f, 0.04458372f, -0.04985714f, -0.04223385f, 
    -0.01709957f, -0.01820570f, -0.01310872f, 0.05129553f, -0.02161451f, 0.06623014f, -0.06343883f, 0.02722888f, 
    -0.04073932f, -0.05450823f, -0.01671996f, 0.04475429f, -0.06149228f, -0.02744789f, 0.04917493f, -0.05317557f, 
    0.04147017f, -0.04320711f, 0.02630783f, 0.00960425f, -0.03204732f, 0.00664928f, -0.04321455f, -0.03700698f, 
    -0.00296098f, 0.02398125f, -0.05393345f, 0.00394216f, 0.03270666f, 0.01613791f, -0.00591694f, 0.01430964f, 
    -0.03621929f, -0.05649407f, 0.06121192f, 0.00223779f, 0.05592285f, -0.02117351f, -0.06031572f, 0.05746531f, 
    -0.07307921f, 0.03469736f, 0.02776854f, 0.05482240f, -0.00224983f, -0.07710268f, -0.05550015f, -0.06735151f, 
    -0.05531684f, -0.05800504f, -0.03918856f, -0.01996100f, -0.00741162f, 0.04638605f, 0.05484836f, -0.05143591f, 
    -0.04980412f, -0.00831749f, -0.00969031f, 0.04838616f, -0.00655955f, -0.07070398f, 0.05882768f, -0.05864657f, 
    0.03643370f, 0.01357005f, -0.05838213f, 0.03681812f, -0.04176085f, 0.05411224f, 0.02846297f, 0.01634130f, 
    -0.06074060f, -0.01467856f, 0.06023090f, -0.07087377f, -0.05052049f, 0.02990584f, -0.04802924f, -0.01447457f, 
    0.00382227f, -0.05845254f, -0.06422628f, -0.02033859f, 0.00636574f, -0.03232889f, -0.05302608f, -0.01297760f, 
    -0.05467733f, 0.03376715f, -0.01493207f, 0.06691834f, 0.04630922f, -0.01698935f, -0.03874351f, 0.00155749f, 
    -0.05832926f, 0.02320497f, -0.03797718f, 0.05722267f, 0.00161695f, -0.07633052f, -0.04494967f, -0.01577528f, 
    -0.07143012f, 0.06657737f, 0.02091611f, -0.03387459f, -0.01652678f, 0.01260877f, 0.04488400f, -0.04439034f, 
    -0.06985362f, -0.03071193f, -0.06569995f, -0.04580897f, -0.06340350f, 0.00166607f, 0.00068268f, 0.04990090f, 
    -0.07279214f, -0.06854624f, -0.05322907f, -0.02999751f, 0.04333568f, -0.01153732f, 0.05906569f, -0.03940512f, 
    0.06339067f, -0.07481702f, -0.07024272f, -0.00020386f, -0.06953334f, 0.04596672f, -0.06081228f, -0.04619386f, 
    -0.05297283f, -0.01868120f, 0.00307415f, 0.06605106f, 0.01352875f, -0.00948924f, 0.02383117f, 0.02327685f, 
    0.05790303f, -0.03148798f, -0.04259832f, 0.04995177f, -0.03686652f, 0.05551033f, 0.01511518f, 0.03281058f, 
    0.02848936f, -0.06596977f, -0.02982884f, -0.03344189f, -0.06592322f, -0.00629388f, 0.02888317f, 0.00671056f, 
    0.06118891f, -0.00962855f, -0.04467688f, 0.05281920f, -0.07579311f, -0.03819979f, -0.01131302f, -0.04758900f, 
    -0.03610654f, 0.02923416f, 0.04729711f, -0.07262590f, 0.03529264f, 0.04029603f, 0.04246385f, 0.05276561f, 
    0.06164554f, 0.05770984f, -0.04723652f, -0.01664615f, -0.02719674f, 0.06444157f, 0.02776856f, -0.01972569f, 
    -0.07670988f, -0.02602078f, -0.04497933f, -0.06830244f, 0.03355311f, -0.04199217f, 0.04056417f, -0.03639452f, 
    -0.03089499f, 0.05636491f, 0.01101331f, -0.08056037f, -0.04188168f, -0.00825453f, 0.01683093f, 0.02970483f, 
    0.04808194f, 0.02786366f, 0.05060079f, 0.00277885f, 0.04653129f, 0.03958202f, -0.01039456f, 0.04602037f, 
    0.00051886f, 0.04758854f, 0.03302857f, -0.06821983f, 0.04791031f, 0.00222559f, 0.04214697f, -0.04345854f, 
    -0.02629035f, -0.01525591f, -0.05377931f, -0.04205798f, -0.02133977f, -0.00519234f, -0.04590231f, 0.00240166f, 
    -0.00957826f, 0.00374163f, -0.00460741f, -0.06780902f, -0.03918175f, 0.01302793f, -0.04987854f, -0.06193763f, 
    0.04026556f, 0.04867946f, 0.02230281f, -0.05187146f, -0.02883626f, -0.04787983f, 0.01963259f, 0.05518232f, 
    -0.06484326f, 0.04506943f, -0.04593493f, 0.02657885f, 0.04916818f, 0.04500115f, 0.00653457f, -0.02582854f, 
    0.02052082f, -0.00422313f, -0.05502650f, 0.05161444f, -0.06902266f, 0.00623670f, -0.01531761f, 0.00218969f, 
    0.00882887f, 0.00661708f, -0.00938423f, 0.05486542f, -0.02610492f, 0.00422576f, 0.04032518f, 0.01275862f, 
    0.00809326f, -0.03660775f, -0.00064551f, -0.00302565f, 0.00763823f, -0.01332663f, -0.06682692f, 0.05408286f, 
    0.04082879f, 0.05998783f, 0.00845668f, 0.01152816f, 0.02333384f, -0.05285520f, 0.01942135f, -0.07091634f, 
    0.00778550f, -0.07581734f, -0.05084611f, 0.01917739f, 0.04788049f, 0.01146294f, -0.05217927f, -0.01206273f, 
    0.06085474f, -0.04164730f, -0.01576130f, 0.00554384f, 0.00736973f, -0.01947637f, -0.04981237f, -0.00052087f, 
    -0.02407831f, 0.03857127f, -0.02045484f, 0.04955108f, 0.00870817f, -0.05287736f, 0.00066129f, 0.05408584f, 
    -0.05589106f, -0.05608447f, -0.06750818f, -0.06266337f, 0.02759071f, 0.04128763f, 0.00735044f, 0.05557377f, 
    0.04447239f, -0.00114052f, -0.07012090f, -0.03818028f, -0.07556681f, -0.07797485f, -0.03028943f, 0.02931793f, 
    -0.05227776f, 0.00323150f, -0.04019857f, -0.00357480f, -0.04065111f, -0.04793653f, -0.01719154f, 0.06735906f, 
    -0.07769730f, 0.00401871f, -0.06293780f, 0.00831160f, -0.04703515f, 0.02015571f, -0.01712035f, 0.02163507f, 
    -0.07730807f, -0.03226333f, -0.00265714f, 0.01610021f, -0.05601215f, 0.01968373f, -0.06736581f, 0.01383750f, 
    0.03486650f, -0.02380479f, -0.04666116f, -0.04254865f, -0.00030767f, -0.05562853f, -0.06049263f, -0.08066148f, 
    0.05113037f, -0.06924850f, -0.02199710f, 0.00563492f, 0.01496010f, -0.06488717f, 0.04683541f, -0.01370371f, 
    0.00357721f, 0.00997241f, 0.02634622f, -0.06522225f, -0.06817809f, -0.01832738f, 0.05502896f, -0.06526969f, 
    -0.04774256f, 0.03157774f, -0.06627598f, -0.05903108f, 0.03159696f, -0.03136782f, 0.01715502f, -0.07320657f, 
    0.06427019f, 0.04364798f, 0.05366310f, 0.01036379f, -0.07018532f, 0.02544746f, -0.02695081f, -0.04744490f, 
    0.43858662f, -0.18738991f, -0.04315146f, -0.00732926f, -0.13350110f, -0.00485844f, -0.10774989f, 0.04054819f, 
    0.08023321f, -0.02598885f, 0.13208525f, 0.00206073f, -0.05310961f, 0.09327054f, 0.12419030f, 0.07390974f, 
    0.16514795f, 0.06159522f, 0.08212168f, 0.17914195f, -0.09882367f, -0.14682798f, -0.09081770f, 0.10601272f, 
    0.37692663f, 0.20055726f, 0.07254038f, -0.06724887f, -0.00001190f, 0.18597446f, 0.08901007f, -0.04955442f, 
    0.18738894f, -0.00452424f, 0.08134294f, 0.05789958f, -0.06789218f, 0.13694744f, -0.20232105f, -0.07147072f, 
    0.10956512f, 0.03323352f, -0.03864689f, -0.36006197f, 0.04971964f, -0.20638296f, -0.19303480f, 0.01361091f, 
    -0.02924080f, 0.23964481f, 0.06684781f, 0.10836376f, 0.05510185f, -0.08898395f, -0.07551114f, -0.07454236f, 
    -0.30838758f, -0.01338855f, -0.05617282f, -0.13891086f, -0.02519135f, -0.06940985f, -0.29040012f, -0.06944901f, 
    0.03949105f, -0.09430660f, -0.05473744f, 0.12296352f, -0.10513388f, 0.01358170f, -0.08129971f, -0.04512294f, 
    -0.10042723f, -0.46621656f, 0.14886987f, -0.16033362f, 0.00008591f, 0.11318803f, -0.09795910f, 0.09411999f, 
    -0.02908854f, 0.09614579f, -0.15164958f, 0.08543707f, 0.04269118f, 0.23078954f, 0.04294159f, 0.13358596f, 
    -0.00126293f, -0.07130293f, -0.09204663f, 0.04907263f, -0.08252494f, 0.14324449f, -0.13755295f, -0.00140032f, 
    -0.02825961f, 0.21449362f, 0.14714468f, -0.07513145f, 0.05073970f, 0.04589769f, 0.01876378f, 0.10121304f, 
    0.15308316f, 0.04022138f, 0.15658905f, -0.04394532f, -0.00521866f, 0.06257168f, -0.29543218f, -0.08895703f, 
    0.12403465f, -0.03954265f, -0.36934441f, -0.14676595f, -0.12006701f, 0.09597005f, -0.27840626f, 0.03008668f, 
    0.03517495f, 0.04201240f, 0.06979672f, 0.01661789f, -0.10699677f, 0.13961978f, 0.05390799f, -0.14923084f, 
    -0.14690427f, 0.09983867f, -0.12628993f, 0.07556649f, 0.03342133f, -0.28656286f, 0.04529455f, 0.10620605f, 
    -0.00547436f, 0.10386293f, 0.12056080f, -0.04259939f, -0.10466253f, 0.12744783f, 0.02728215f, 0.02532339f, 
    0.10668860f, 0.16960499f, -0.04038174f, -0.08799683f, -0.02460483f, 0.12963179f, 0.09255195f, -0.17649373f, 
    -0.03847107f, 0.06138254f, 0.01281171f, 0.11760894f, -0.03547224f, -0.31511244f, -0.02745612f, 0.11300791f, 
    0.01910692f, -0.10317543f, -0.14020297f, 0.19322246f, 0.00665779f, 0.13245527f, 0.16711183f, -0.06002884f, 
    0.23957989f, 0.17770484f, 0.07570064f, -0.17529453f, 0.08930116f, 0.13235858f, -0.15605885f, 0.09351271f, 
    -0.17792590f, -0.20246902f, 0.01525269f, -0.07578804f, 0.10515583f, 0.07891300f, -0.21260558f, 0.03281770f, 
    0.02626677f, 0.07905731f, -0.01312171f, -0.11556042f, -0.09795915f, 0.24725391f, 0.05695006f, -0.04897311f, 
    -0.23277204f, -0.23505954f, 0.02707877f, -0.19312710f, -0.10356326f, 0.04829231f, -0.02085163f, 0.11224626f, 
    -0.08262047f, 0.06748372f, 0.03096172f, -0.00495303f, 0.08177637f, -0.03394685f, 0.11568780f, 0.00031128f, 
    0.15922634f, -0.11643572f, -0.08842950f, -0.12305163f, 0.15087561f, 0.02414825f, 0.01138920f, 0.15082832f, 
    0.10002376f, -0.01681092f, -0.05711425f, -0.14562474f, 0.17729935f, 0.01693349f, 0.10058091f, 0.10438715f, 
    0.01456936f, -0.01342009f, 0.14364140f, 0.22429675f, -0.08305552f, 0.03633524f, 0.01715646f, -0.20157833f, 
    -0.06792631f, 0.08843099f, -0.09862056f, 0.09935036f, 0.10230986f, -0.10980991f, -0.03553371f, -0.06885356f, 
    0.04193484f, 0.06890356f, 0.31643340f, -0.15970589f, 0.13649982f, -0.08277547f, -0.06448870f, 0.02415476f, 
    -0.02819214f, 0.00961440f, 0.00443609f, 0.14018105f, -0.21515742f, 0.07812309f, -0.08623545f, 0.24826394f, 
    -0.01849900f, -0.01219203f, 0.10561232f, 0.05497520f, -0.03448675f, 0.07394714f, 0.12766881f, 0.03829021f, 
    0.30938074f, -0.02381553f, 0.01507609f, -0.14545462f, -0.10194059f, 0.13424721f, 0.02973234f, 0.05325816f, 
    -0.05765182f, 0.02452253f, 0.02095308f, 0.04742425f, 0.11808868f, -0.06449220f, 0.02629073f, 0.01361098f, 
    0.02658914f, 0.02417341f, -0.15708202f, -0.05184584f, -0.01013493f, -0.09084310f, 0.12841839f, -0.05583208f, 
    -0.05040219f, -0.10442927f, -0.05870850f, -0.03320758f, -0.08879805f, 0.08576447f, -0.01193068f, -0.03559988f, 
    0.11837535f, -0.03644299f, -0.05963353f, -0.01583736f, 0.19301048f, 0.16133048f, 0.01966953f, 0.00034105f, 
    0.06396494f, -0.16319555f, 0.03651474f, 0.15410760f, -0.02296792f, 0.02894878f, -0.05814578f, 0.03828326f, 
    0.19446783f, 0.11923533f, -0.06994870f, 0.09462708f, 0.14535265f, 0.02138312f, 0.04334461f, 0.04200448f, 
    0.18670519f, 0.09140593f, 0.02197193f, 0.00879111f, -0.05201640f, 0.20194311f, 0.12356404f, -0.11270155f, 
    -0.07834366f, -0.09576302f, 0.11317875f, 0.11877669f, 0.08827692f, 0.06404222f, 0.03052716f, 0.13849364f, 
    0.11013643f, 0.12059733f, -0.14795557f, -0.08519619f, -0.05209661f, 0.19074269f, 0.07408766f, 0.07795947f, 
    0.12413651f, 0.05240288f, -0.01255175f, 0.01369736f, -0.33694714f, -0.04466547f, -0.24698780f, -0.03861821f, 
    -0.16136278f, 0.15590073f, -0.01110921f, 0.07782660f, 0.07196290f, 0.07690927f, -0.02237337f, 0.06789394f, 
    -0.00015885f, -0.14973952f, 0.13151421f, 0.14159185f, 0.12535456f, 0.04090734f, 0.15064551f, 0.01930221f, 
    0.13515702f, -0.03756632f, 0.01491812f, -0.03402524f, -0.03008028f, -0.12171324f, -0.16925709f, -0.09803870f, 
    0.04925688f, -0.00451212f, -0.10664570f, -0.10692509f, -0.05145599f, -0.00531136f, 0.04618764f, -0.10073600f, 
    -0.02924381f, 0.06355736f, 0.04646166f, 0.00382600f, -0.02830854f, -0.04853006f, 0.00133022f, -0.07206562f, 
    0.05556151f, -0.04859255f, -0.00941152f, -0.05055458f, 0.06254171f, 0.01715692f, 0.02215471f, -0.07028995f, 
    -0.01925551f, 0.03490661f, -0.00166900f, 0.03583590f, -0.00571111f, -0.04457319f, 0.00030501f, 0.04091654f, 
    -0.00632721f, 0.02383932f, 0.04755521f, -0.06837793f, -0.06316940f, 0.04843835f, -0.06426935f, -0.06175192f, 
    0.03088368f, 0.07106659f, -0.00919966f, -0.00229855f, 0.02164939f, 0.03680183f, -0.03707915f, 0.02519296f, 
    -0.03749288f, -0.06070995f, -0.04469448f, 0.02508648f, -0.04426557f, -0.04442907f, 0.06335360f, 0.05589824f, 
    -0.02061732f, -0.04030694f, -0.01648992f, -0.00344219f, 0.04559238f, 0.03438636f, 0.06158187f, -0.06812197f, 
    -0.07127988f, 0.00779058f, 0.05118501f, -0.04199363f, -0.06891661f, -0.00357864f, -0.05546311f, 0.00499228f, 
    -0.01190587f, -0.02482549f, -0.01793541f, -0.02067827f, 0.04323833f, -0.03895725f, 0.05941234f, -0.03733768f, 
    -0.04515668f, -0.01614114f, -0.00916795f, 0.05252577f, -0.04037907f, 0.04116720f, 0.02427129f, -0.06010593f, 
    0.00930389f, -0.03460661f, -0.02780220f, -0.03060534f, -0.05134158f, 0.00846361f, -0.03213584f, -0.01542740f, 
    -0.04693953f, -0.05085047f, 0.02765195f, -0.04340497f, 0.03654606f, 0.01438905f, -0.04464008f, 0.01057170f, 
    -0.00571646f, 0.00925531f, 0.01145569f, 0.06515590f, -0.03135750f, -0.00151367f, -0.07845528f, -0.03345832f, 
    -0.03573813f, -0.05944719f, -0.00881832f, 0.04423350f, -0.01367278f, -0.01151848f, -0.00853201f, -0.04167216f, 
    -0.06896297f, 0.01067733f, -0.05733321f, 0.03339269f, 0.04897863f, 0.04014014f, -0.02700896f, -0.06484093f, 
    -0.05469958f, -0.03992326f, -0.06564910f, -0.05972914f, -0.04067136f, -0.05593617f, -0.00680614f, -0.07051999f, 
    -0.04769876f, 0.03036889f, -0.05082012f, -0.07082675f, -0.03025952f, -0.06515067f, -0.05913085f, 0.02318246f, 
    0.02591777f, 0.02858878f, -0.05506090f, -0.05748540f, -0.02259999f, -0.07638298f, -0.02353020f, -0.01610697f, 
    -0.07324013f, 0.06030812f, 0.03828406f, 0.00112628f, 0.03041158f, -0.04296809f, 0.01906285f, 0.02471816f, 
    -0.04153105f, -0.03771329f, 0.03419748f, -0.07795363f, -0.06693464f, -0.01160370f, 0.00671623f, 0.02385814f, 
    -0.07279404f, -0.05989666f, 0.01283271f, -0.07771163f, -0.00417407f, -0.06497923f, -0.07457291f, 0.05463810f, 
    -0.01562839f, 0.03885771f, -0.02621539f, -0.01759011f, 0.02272374f, -0.01904179f, -0.00462187f, 0.00089092f, 
    -0.04911373f, 0.03420629f, 0.01351954f, 0.03849849f, 0.00192744f, 0.03238598f, 0.03219153f, 0.06160288f, 
    -0.04508926f, -0.02913280f, -0.05199780f, 0.02780223f, -0.01642083f, -0.02086396f, 0.01703372f, -0.06710825f, 
    0.06872944f, 0.27453306f, -0.03862897f, -0.08836075f, -0.07354227f, 0.11182080f, -0.04734293f, 0.14107533f, 
    0.04742102f, 0.04975549f, 0.03324551f, 0.04604678f, -0.08772951f, -0.07781821f, 0.08760360f, 0.09025156f, 
    0.03079447f, 0.06709970f, -0.07230550f, -0.00848886f, 0.16862020f, 0.01492888f, -0.04412474f, 0.08419579f, 
    -0.08814144f, -0.13559550f, 0.15338597f, -0.35705799f, -0.14659946f, 0.12829936f, 0.00050553f, -0.00647285f, 
    -0.13185927f, -0.00830756f, 0.09436359f, -0.00703496f, 0.22444651f, -0.14259155f, -0.18109620f, 0.16309415f, 
    -0.04012084f, -0.04128762f, 0.03299058f, 0.01563515f, 0.01521017f, 0.03661079f, -0.00302479f, -0.05700767f, 
    -0.35115603f, -0.06380846f, -0.20907365f, 0.02373897f, -0.02542058f, 0.03966988f, 0.05994835f, -0.00575896f, 
    0.07313554f, -0.09382574f, 0.04385507f, 0.07124429f, -0.17153989f, 0.14282592f, 0.10822191f, 0.15372007f, 
    -0.03706759f, -0.08104386f, 0.01398987f, -0.05235583f, 0.06602708f, -0.00748957f, -0.04916140f, 0.08606133f, 
    0.23166817f, 0.28544867f, 0.07591788f, -0.13913624f, -0.05257389f, -0.07478452f, 0.15201335f, 0.06444639f, 
    0.03858027f, 0.02803195f, -0.02975032f, -0.08684766f, 0.04883277f, 0.03299405f, -0.06717346f, -0.03085166f, 
    0.02548784f, -0.04876087f, 0.03962017f, -0.05841099f, -0.03924832f, -0.01225775f, 0.02962156f, 0.00095550f, 
    0.11855840f, -0.19181588f, -0.03551577f, -0.12494046f, -0.01936300f, -0.01039217f, 0.08644138f, 0.11667406f, 
    -0.01769247f, -0.03103195f, -0.00228462f, -0.02810378f, -0.01947368f, 0.00663036f, -0.10611963f, 0.14030427f, 
    0.07784512f, -0.01886693f, 0.05549909f, 0.14947863f, -0.04012020f, -0.12411389f, 0.03734764f, -0.10337111f, 
    0.19613974f, -0.16628820f, 0.13885172f, 0.17601545f, 0.00025228f, 0.09955759f, -0.01124723f, -0.03728484f, 
    0.10704428f, 0.08089495f, -0.06236845f, 0.05155994f, 0.17446917f, 0.07884048f, -0.00832301f, -0.04547705f, 
    -0.07948035f, 0.00368528f, 0.03919718f, 0.05070313f, 0.02644574f, -0.13701473f, 0.04637178f, -0.00090251f, 
    0.05197005f, 0.02628126f, 0.15386868f, -0.11571689f, 0.04597502f, 0.06121999f, 0.02501396f, -0.05061639f, 
    0.02644910f, 0.18385462f, -0.08642583f, -0.01413269f, -0.32886970f, 0.41513973f, 0.13287066f, -0.23447470f, 
    -0.06631498f, 0.17274126f, -0.03114039f, 0.01119063f, -0.05858944f, -0.15574823f, 0.14318627f, 0.01786321f, 
    0.02179482f, -0.24146733f, 0.00561037f, 0.13271365f, 0.00485224f, 0.05292225f, 0.17084248f, 0.02138196f, 
    0.08990595f, 0.05608476f, -0.04887379f, 0.01420742f, -0.33809575f, 0.20405653f, 0.20290852f, 0.18103798f, 
    -0.11489107f, -0.08279140f, 0.02424006f, -0.03643557f, 0.03847149f, -0.01016912f, 0.13297561f, 0.04872214f, 
    0.31635109f, -0.02023899f, 0.01078493f, 0.11924068f, -0.05328118f, 0.08539894f, 0.02954152f, 0.04405227f, 
    0.00859860f, -0.05331161f, 0.05564549f, 0.01938393f, -0.20755287f, -0.00807141f, 0.01767057f, -0.05226041f, 
    0.01019403f, 0.13536999f, 0.07430504f, -0.00647750f, -0.09728359f, 0.14229591f, -0.07162552f, -0.02869207f, 
    0.16446324f, 0.25847590f, -0.05557638f, -0.02114991f, 0.01870217f, 0.03880296f, 0.08373024f, -0.05123184f, 
    -0.01360897f, 0.05190801f, 0.00561462f, -0.01045551f, -0.35384190f, 0.17216963f, 0.01279872f, -0.09396816f, 
    0.08364777f, -0.10343581f, 0.04808861f, -0.06414749f, -0.11508659f, -0.01594462f, 0.12216414f, -0.01231542f, 
    -0.00214043f, 0.08268608f, -0.08072745f, 0.21491878f, 0.13994773f, -0.04275971f, -0.02122579f, 0.00172167f, 
    -0.05120775f, 0.07406847f, 0.03271578f, -0.06184430f, 0.51326346f, -0.14707805f, -0.05833842f, 0.20758006f, 
    -0.05693688f, 0.08928996f, -0.02850260f, -0.03652595f, 0.08270383f, -0.02576710f, 0.04641106f, -0.08680987f, 
    -0.10002520f, 0.09320029f, -0.05786489f, -0.15679395f, -0.03077709f, -0.07652937f, 0.04271964f, 0.14303133f, 
    0.08862872f, -0.06212479f, -0.10393184f, 0.07539354f, -0.08880121f, 0.14153159f, 0.14607239f, -0.09535813f, 
    -0.14820828f, -0.09497666f, 0.11026201f, -0.13872834f, 0.01111356f, -0.03912003f, -0.07249915f, -0.05831285f, 
    0.13623720f, 0.26391333f, 0.15304522f, 0.01741693f, -0.08379742f, 0.05955985f, 0.08004834f, 0.00542160f, 
    -0.03404982f, -0.02400114f, -0.09058250f, 0.03582279f, 0.00947310f, -0.06372459f, -0.08262973f, 0.05540083f, 
    -0.10636596f, 0.05370960f, 0.03187035f, 0.09050441f, 0.00968106f, 0.01740162f, 0.05466022f, -0.07243111f, 
    -0.15285540f, 0.09190843f, 0.24359629f, -0.38944417f, -0.02246825f, 0.20437834f, 0.03933549f, -0.04671064f, 
    0.07053873f, 0.00848988f, 0.07277983f, 0.02335115f, -0.04698046f, -0.18119143f, 0.22602084f, 0.13480847f, 
    -0.04328531f, -0.09798796f, 0.05367595f, 0.08699591f, -0.00105448f, 0.00571531f, -0.01891812f, -0.04808847f, 
    0.15487154f, 0.10872707f, -0.12460461f, -0.22480214f, 0.06984625f, 0.07866737f, -0.03869146f, -0.08131988f, 
    -0.00283384f, -0.07196172f, -0.08785930f, -0.03522521f, 0.10360846f, -0.11168496f, -0.14292732f, -0.15646054f, 
    0.10857651f, 0.06906363f, 0.10389197f, 0.06606654f, -0.08554257f, 0.02599687f, 0.03263240f, -0.02243057f, 
    -0.13470571f, 0.10379343f, 0.13850881f, 0.00906157f, 0.00121299f, 0.15245466f, 0.14804265f, 0.12131428f, 
    0.08396435f, 0.10986214f, -0.09418909f, 0.04557122f, 0.39557207f, -0.26262084f, 0.15601391f, -0.02980557f, 
    -0.03003239f, 0.09064803f, -0.11594893f, -0.05627687f, -0.02014638f, 0.06773726f, -0.05002222f, 0.10672244f, 
    0.22604389f, -0.07138083f, 0.08549736f, -0.20962755f, -0.01617519f, 0.05576219f, -0.15659270f, 0.10160580f, 
    0.04026689f, 0.04195067f, 0.14765850f, -0.05594620f, 0.27100039f, 0.13148089f, -0.09647038f, -0.03675740f, 
    -0.11144225f, 0.00545052f, 0.08231919f, -0.00048543f, -0.00835436f, -0.03255346f, -0.01010627f, 0.13386306f, 
    0.40188780f, 0.10780057f, 0.04147936f, -0.12398300f, -0.02470306f, -0.08762749f, -0.04723194f, -0.07182179f, 
    0.07265793f, 0.03920076f, -0.01623682f, 0.04882596f, 0.09874466f, 0.19924158f, 0.11638021f, 0.27972901f, 
    -0.06281994f, -0.00746414f, 0.05201482f, 0.00464133f, -0.04294800f, -0.09087000f, 0.04310180f, -0.10829075f, 
    0.06771503f, 0.08039566f, -0.02187811f, 0.25069457f, 0.14508621f, 0.02918200f, 0.07958219f, 0.03680186f, 
    0.05134749f, 0.00490261f, 0.08771899f, -0.00677082f, -0.08697702f, -0.03739802f, -0.18585607f, 0.13622731f, 
    -0.14027476f, 0.10515812f, 0.02737692f, -0.00263797f, -0.05122157f, 0.07792285f, -0.08553506f, -0.02093610f, 
    -0.01553650f, -0.11309034f, -0.08577938f, -0.02161641f, -0.12381402f, 0.18542986f, 0.07637750f, 0.12702657f, 
    0.05477493f, -0.09661331f, 0.07337282f, 0.10170303f, 0.09663971f, -0.16643001f, -0.00045706f, -0.01697238f, 
    0.04995783f, -0.03924981f, -0.02233750f, 0.06941320f, -0.09526860f, -0.00362049f, -0.04336960f, 0.03780112f, 
    -0.16170315f, -0.04276020f, 0.33533463f, -0.10455778f, 0.02158767f, -0.00435485f, 0.02890907f, 0.07740515f, 
    0.00201991f, 0.00790603f, 0.07941242f, 0.08675902f, -0.03673751f, 0.07976257f, -0.10769918f, 0.05047493f, 
    0.08105695f, 0.06687139f, -0.04726651f, -0.00846425f, -0.02800251f, -0.07030641f, -0.01098284f, -0.04368033f, 
    -0.04350454f, 0.12925230f, 0.09648570f, -0.27888596f, -0.05475405f, 0.08509527f, 0.03526609f, -0.07406593f, 
    0.07236261f, -0.04921208f, -0.00764021f, -0.02140873f, -0.15563746f, -0.02445522f, 0.13143550f, 0.10193907f, 
    -0.00334167f, -0.04078832f, -0.13055310f, 0.09565552f, 0.10050977f, 0.00739358f, 0.05215491f, 0.15038857f, 
    -0.17357063f, -0.14606777f, -0.02782280f, -0.16070063f, 0.06166447f, -0.01667298f, 0.19472003f, 0.17778128f, 
    0.11148605f, 0.05671159f, 0.01454462f, 0.00549717f, -0.10696001f, -0.08026189f, -0.07847638f, -0.20384307f, 
    -0.05038888f, 0.00048992f, 0.07590507f, -0.00679281f, -0.02205610f, 0.05010880f, 0.03988026f, -0.00246677f, 
    0.18464175f, 0.08648948f, 0.12941377f, 0.06825744f, 0.03081590f, 0.08407182f, -0.10363396f, 0.06896613f, 
    0.06775573f, 0.02632740f, -0.05014655f, 0.03866500f, 0.23366351f, -0.22791232f, -0.04856606f, 0.05308857f, 
    -0.01369868f, 0.02407369f, -0.10511836f, -0.02856169f, -0.00050470f, -0.02850185f, -0.01808181f, 0.06939232f, 
    0.23520672f, 0.03511321f, -0.07485833f, -0.14922512f, -0.02631346f, 0.09259458f, 0.03832386f, 0.00681176f, 
    0.07489447f, -0.05534207f, -0.02752535f, -0.02348831f, 0.16419750f, 0.03617789f, 0.11325134f, 0.09225038f, 
    -0.12846330f, -0.02993164f, -0.03828236f, -0.04842633f, -0.08463079f, -0.11147088f, 0.00697610f, 0.01920693f, 
    -0.33110642f, 0.15337563f, 0.02564467f, 0.06416222f, 0.01338214f, -0.12063182f, 0.05738538f, -0.00476501f, 
    0.10124429f, 0.01826163f, -0.04946226f, -0.11387975f, 0.34781897f, 0.17089552f, 0.28618976f, 0.26746702f, 
    -0.09895685f, -0.00824094f, -0.01946279f, 0.06860758f, 0.03277584f, -0.01070504f, 0.08595834f, 0.02558335f, 
    0.13718168f, 0.03817380f, -0.04626062f, 0.16633989f, -0.04791813f, -0.06830988f, 0.08879129f, -0.02799082f, 
    -0.05250639f, -0.03862262f, 0.10886135f, 0.01368744f, 0.03942488f, -0.13363807f, -0.23422696f, -0.00460604f, 
    -0.13531774f, 0.10802317f, 0.03898175f, 0.15531507f, -0.05753173f, 0.04989159f, -0.08651542f, -0.12616818f, 
    -0.09714898f, 0.00845939f, -0.03321443f, -0.21498594f, 0.12669879f, 0.12615782f, 0.04832037f, 0.01714927f, 
    -0.08329026f, 0.00590303f, 0.12964182f, 0.02370068f, 0.18091828f, -0.15009567f, -0.09336385f, -0.09719342f, 
    0.04529294f, 0.03388833f, 0.08072753f, 0.11490253f, 0.14514993f, 0.00713158f, -0.04908120f, 0.08560722f, 
    -0.03110619f, -0.05862533f, 0.09623954f, -0.13506183f, -0.01685758f, 0.10712249f, 0.12478272f, 0.14289217f, 
    0.07443003f, -0.12225270f, 0.05993323f, 0.07689717f, 0.06103563f, -0.05135454f, 0.09344249f, -0.04357934f, 
    -0.12591194f, 0.03569908f, -0.03441080f, -0.00347193f, -0.03771804f, -0.03246561f, 0.05244261f, 0.19673675f, 
    -0.08910473f, -0.18408455f, 0.35223484f, -0.30993736f, 0.06406311f, -0.04276937f, 0.14210096f, 0.06937188f, 
    0.05334614f, -0.01429568f, -0.04441289f, 0.05787729f, -0.10149798f, 0.07530917f, -0.14271741f, 0.21218082f, 
    0.20342132f, -0.09293442f, 0.02132796f, 0.11338539f, 0.04609176f, -0.10394813f, -0.12591432f, -0.11798307f, 
    -0.25993803f, -0.16436327f, -0.06477938f, -0.02376773f, 0.13798319f, -0.00860049f, 0.12350241f, 0.15329939f, 
    0.06045800f, 0.01307336f, -0.11647391f, -0.05027434f, -0.25984672f, 0.05374182f, -0.19324365f, -0.13558486f, 
    0.08023915f, 0.03565095f, 0.07775785f, -0.08317679f, 0.00628720f, -0.09732273f, 0.04460209f, -0.05792710f, 
    0.31035054f, 0.00699810f, 0.12535766f, -0.04311217f, 0.08318319f, -0.13126796f, -0.03739510f, 0.00693614f, 
    0.00438869f, -0.08870134f, 0.04282336f, -0.02170852f, 0.30104387f, -0.11982094f, -0.19810639f, -0.00111426f, 
    -0.07006148f, -0.02258977f, 0.09900128f, 0.04680244f, 0.08806521f, -0.06577571f, 0.03830520f, 0.02977035f, 
    -0.16711007f, 0.18159768f, 0.00008087f, 0.11153167f, -0.01322926f, -0.10074402f, 0.01763115f, 0.15351449f, 
    0.02107707f, 0.02390449f, -0.08214846f, -0.00961322f, -0.13398993f, -0.15675195f, -0.06597623f, -0.00977283f, 
    0.14124328f, -0.00352333f, 0.02441899f, -0.07807928f, 0.08583313f, 0.09760515f, 0.01165058f, -0.03956176f, 
    0.03490402f, 0.17161827f, 0.06604994f, -0.11119457f, 0.08802234f, 0.15642172f, 0.03325361f, 0.07364310f, 
    0.02747722f, 0.07784756f, -0.07371397f, 0.03399896f, -0.30710360f, -0.24949472f, -0.28947687f, -0.13865098f, 
    0.19352530f, 0.00409441f, -0.10710695f, -0.16966751f, -0.08101201f, 0.08910955f, 0.00478584f, -0.04816820f, 
    -0.28272837f, -0.22473377f, -0.13255571f, 0.05893535f, 0.05149771f, -0.00501043f, -0.11997396f, -0.14375857f, 
    0.02141542f, -0.00727804f, -0.07074664f, 0.08699146f, 0.36597770f, -0.09344640f, 0.17671514f, -0.02531858f, 
    0.08378879f, -0.09782355f, -0.01691881f, -0.09776263f, 0.03466597f, 0.04030242f, 0.06161887f, 0.16956379f, 
    0.10600872f, 0.20141163f, 0.16218920f, -0.07667729f, -0.12049491f, -0.06928728f, -0.00361147f, 0.05386309f, 
    0.05435738f, 0.11134391f, 0.00060511f, -0.03023721f, -0.04350342f, 0.13353986f, 0.05940496f, 0.07157224f, 
    -0.14836361f, 0.00653519f, 0.13609973f, -0.01733630f, 0.02400079f, -0.01296325f, -0.07517700f, -0.05646460f, 
    0.15209846f, 0.04721281f, -0.03696828f, 0.14565805f, -0.12778942f, -0.08158043f, 0.06867949f, 0.08921173f, 
    0.04446491f, -0.04885664f, 0.03749819f, -0.04202643f, 0.04211997f, 0.01882654f, -0.05497862f, 0.01296098f, 
    -0.02158873f, -0.00290945f, 0.01834561f, -0.05441491f, -0.09550127f, -0.08788606f, 0.14447148f, 0.08809745f, 
    -0.01677113f, -0.01345276f, -0.17967474f, 0.26657438f, 0.05787982f, -0.04096451f, 0.02997201f, 0.00959687f, 
    0.11862187f, 0.18810689f, 0.04653822f, -0.01452979f, 0.16988173f, 0.01713755f, 0.18889408f, -0.00180888f, 
    -0.05205593f, -0.01534448f, 0.12710062f, 0.06383071f, 0.07509029f, -0.04851500f, 0.08906177f, -0.01280380f, 
    0.22143532f, 0.18883236f, 0.06420318f, -0.10242280f, 0.09205063f, 0.15259938f, -0.14605416f, -0.04556631f, 
    0.00101314f, 0.06226294f, -0.01246231f, -0.06417324f, 0.08442703f, 0.36642909f, 0.12017704f, -0.00852420f, 
    0.04835301f, 0.07827045f, -0.05895232f, 0.00475945f, -0.00075836f, 0.00550659f, -0.03179440f, 0.06318835f, 
    -0.14885584f, -0.01436753f, 0.00704821f, 0.03370848f, -0.09754485f, 0.03608345f, 0.17300858f, 0.07866868f, 
    0.04178852f, 0.09328220f, -0.06716628f, -0.13888121f, 0.08790489f, 0.11016951f, 0.12673444f, 0.18311442f, 
    -0.01129047f, -0.00784719f, 0.05156619f, -0.05278220f, -0.06683563f, 0.11623260f, 0.07602111f, -0.00103350f, 
    -0.04654361f, 0.23968029f, -0.10609716f, 0.02755963f, 0.03987531f, -0.02408939f, 0.11813882f, 0.03595389f, 
    -0.01389151f, 0.03463424f, -0.07634243f, -0.03690472f, 0.16310585f, 0.21485680f, -0.04221788f, 0.10858238f, 
    0.04681583f, 0.06395420f, -0.03944721f, -0.11374433f, -0.05615274f, 0.02185975f, -0.05183039f, -0.02844803f, 
    -0.22378722f, 0.01100234f, 0.07456392f, -0.00826113f, -0.09976394f, 0.15117717f, 0.07860689f, -0.08362866f, 
    -0.18313622f, 0.05906099f, 0.08963279f, -0.04503641f, 0.06504981f, 0.07577099f, -0.05039973f, -0.21501334f, 
    0.00050155f, -0.08403444f, -0.05204880f, -0.10690057f, -0.01478254f, 0.03579653f, -0.01384205f, -0.08853395f, 
    0.35423815f, -0.13255675f, -0.02316583f, 0.01333077f, -0.11668906f, -0.05885274f, -0.00947988f, -0.00652376f, 
    0.10813842f, 0.08226455f, 0.11371387f, -0.01016776f, 0.17328882f, 0.16739845f, 0.04525444f, 0.00501148f, 
    0.01731625f, -0.03900915f, 0.04426739f, -0.15740487f, 0.05038952f, -0.04429071f, 0.02517443f, -0.15709947f, 
    0.00096342f, 0.15780081f, -0.05506392f, -0.03280999f, -0.13509852f, -0.01699611f, 0.10578073f, 0.00626243f, 
    0.03802506f, -0.17559053f, -0.14236179f, -0.09639491f, -0.18339303f, 0.20888314f, -0.13346364f, -0.10680921f, 
    0.10043090f, -0.09505422f, 0.16436860f, -0.04994497f, 0.07523366f, -0.05534171f, 0.01542165f, 0.03404220f, 
    0.43520418f, -0.00696951f, -0.21248707f, 0.03357896f, -0.02699966f, -0.00198855f, -0.07730905f, 0.04396990f, 
    -0.02056768f, -0.00008453f, -0.01571844f, -0.09129924f, 0.09916995f, -0.08761463f, 0.07439198f, 0.06963881f, 
    -0.08279134f, -0.00338843f, 0.02532251f, -0.02924823f, -0.18381767f, -0.04287657f, -0.24933979f, -0.33860892f, 
    0.18092768f, 0.21812445f, 0.11045088f, 0.06803386f, 0.12926966f, 0.20558244f, 0.01737256f, -0.00609484f, 
    0.07197630f, -0.21400318f, -0.01814328f, 0.03394349f, 0.01975457f, 0.08766153f, -0.02308284f, -0.08125328f, 
    -0.02897790f, 0.04857830f, 0.10368593f, -0.02701008f, -0.07266502f, 0.06804211f, 0.13899130f, -0.08959365f, 
    0.00715000f, 0.03902609f, -0.05265065f, -0.05252830f, 0.02608811f, 0.04642779f, -0.13700315f, -0.13601188f, 
    -0.10030653f, -0.10009067f, -0.10567293f, 0.05826291f, 0.13589214f, 0.21949913f, -0.00676621f, 0.12587936f, 
    0.06044346f, 0.06486040f, -0.04876310f, -0.01641907f, 0.03302835f, 0.00154881f, 0.21304779f, 0.13007298f, 
    -0.12788603f, -0.04734592f, -0.04857859f, -0.02912552f, 0.05251522f, 0.11018968f, 0.24868345f, 0.15039182f, 
    0.02373487f, 0.03170662f, -0.05771810f, 0.06536480f, 0.03945795f, 0.16566874f, 0.00906557f, -0.03222344f, 
    0.05692968f, 0.01580719f, 0.03425576f, 0.10252288f, -0.01043849f, 0.09447641f, 0.12312622f, 0.13641195f, 
    0.18327548f, 0.06199070f, 0.03025038f, -0.07922917f, 0.08177289f, 0.00255059f, -0.14281672f, -0.06491970f, 
    0.09366836f, -0.11377130f, 0.04870252f, -0.07733223f, 0.48400316f, -0.06950498f, -0.18096632f, -0.03059375f, 
    0.02822160f, -0.06984171f, 0.03250231f, 0.17923240f, 0.11653504f, -0.00053953f, 0.00268643f, 0.07266410f, 
    0.15279412f, -0.00001490f, 0.07394774f, 0.00137864f, -0.05330811f, -0.02723693f, 0.04773398f, -0.02665521f, 
    0.16734307f, 0.05277235f, -0.08999484f, -0.03768589f, 0.47888723f, -0.01018408f, -0.02945424f, 0.48009607f, 
    -0.04113197f, -0.03517908f, 0.00513069f, -0.02441430f, -0.01218913f, -0.06441502f, -0.05976059f, -0.06345693f, 
    -0.05076713f, 0.05331377f, -0.19133040f, 0.24694291f, -0.08061480f, 0.07541284f, 0.08718491f, 0.10971458f, 
    0.05021461f, -0.04288333f, -0.06579947f, 0.06503837f, -0.42689222f, 0.02908635f, -0.14779563f, 0.14681441f, 
    -0.01140296f, -0.03147092f, -0.00100150f, 0.04392399f, -0.03528482f, 0.08767251f, -0.15099497f, 0.07314409f, 
    -0.02770079f, 0.07427400f, 0.12594125f, 0.07490344f, -0.05122472f, -0.03682205f, 0.03692818f, 0.08370451f, 
    0.01807507f, 0.11179672f, 0.09986022f, 0.00270137f, 0.16067125f, 0.00174229f, -0.04472955f, -0.08797621f, 
    0.06030991f, 0.16504200f, -0.07870074f, 0.05660185f, 0.03488288f, -0.02925111f, -0.15603431f, 0.03780438f, 
    0.04705385f, 0.02616814f, 0.12919067f, -0.24436471f, 0.06858274f, -0.04894558f, -0.04687841f, 0.14095438f, 
    0.06241477f, -0.04427974f, -0.08102019f, 0.05161237f, -0.06793052f, 0.13886783f, -0.12945320f, 0.07258488f, 
    0.19316627f, 0.10915444f, -0.08116732f, 0.01543581f, 0.04940633f, 0.02691580f, -0.04129766f, 0.14381535f, 
    0.00827305f, -0.15869820f, 0.08724611f, -0.05564253f, -0.03251300f, -0.09279331f, -0.02954835f, 0.07836935f, 
    -0.05258911f, 0.03467378f, 0.13878423f, -0.00058211f, -0.20831409f, -0.07374487f, -0.15792692f, 0.26043758f, 
    -0.06664128f, 0.00827651f, -0.13525963f, -0.01834436f, 0.02993693f, -0.16517417f, -0.03782677f, 0.01968118f, 
    -0.34821719f, -0.05073557f, 0.06265904f, 0.08636204f, -0.09628038f, -0.09066440f, 0.13105324f, 0.12997866f, 
    0.09348074f, 0.14596379f, 0.05378975f, 0.00680560f, -0.23782590f, -0.05591191f, 0.24257784f, 0.05442202f, 
    -0.01620404f, 0.06788602f, 0.01889722f, 0.00952273f, -0.09509423f, -0.03089597f, -0.11251526f, 0.11406653f, 
    0.30077481f, 0.01600070f, 0.00603412f, 0.04134970f, -0.00298377f, -0.06359454f, -0.23277798f, -0.04502922f, 
    -0.10686390f, -0.06097523f, 0.10301257f, -0.07830759f, -0.16535120f, 0.18377501f, 0.08883480f, 0.06440573f, 
    -0.08034176f, -0.02780898f, -0.00737831f, 0.00266903f, 0.06309287f, -0.04518002f, -0.11569238f, -0.01601917f, 
    -0.36425072f, -0.08895618f, 0.05118695f, -0.06680720f, -0.01927694f, -0.03215680f, 0.06776215f, 0.07417869f, 
    0.00133115f, 0.03315486f, -0.01947427f, -0.01766753f, 0.02203349f, 0.00564576f, -0.03801153f, 0.01125732f, 
    -0.01601586f, 0.03554621f, 0.00834620f, -0.05831939f, 0.11923378f, 0.02169293f, 0.02886268f, -0.02191599f, 
    0.44836569f, 0.03515403f, -0.07648303f, 0.03453182f, 0.08014432f, -0.03017571f, -0.00704755f, 0.07785771f, 
    0.01268581f, 0.04417400f, 0.12598042f, 0.07102042f, -0.27782062f, 0.07489886f, -0.18277627f, -0.28067172f, 
    -0.05542445f, 0.08273479f, 0.02241816f, -0.09651227f, -0.09214939f, -0.13767922f, -0.00207686f, -0.09270044f, 
    0.03010275f, -0.04273249f, 0.25412303f, -0.11768730f, 0.21693328f, -0.13002849f, -0.06210721f, 0.09338803f, 
    0.00338628f, -0.02963574f, -0.00937075f, -0.00886855f, -0.13562125f, 0.11446123f, 0.28200430f, 0.08230450f, 
    -0.02233892f, -0.15548602f, 0.07731051f, -0.05917045f, 0.01045662f, 0.13730721f, -0.03515695f, 0.11755941f, 
    0.25949985f, -0.05859088f, 0.15028854f, -0.00790862f, -0.01650349f, 0.06951055f, -0.00907105f, 0.00722880f, 
    0.16291453f, -0.11486154f, -0.08296546f, -0.10048267f, 0.14137328f, -0.04269949f, 0.01999820f, 0.18898247f, 
    -0.00821261f, 0.01878588f, -0.09298565f, -0.00709055f, 0.01694115f, 0.04538566f, 0.04030990f, -0.05400295f, 
    -0.00513127f, 0.01856565f, 0.04643808f, 0.15226197f, -0.04755734f, 0.08699407f, -0.03439777f, 0.02308393f, 
    0.09908193f, -0.00777419f, 0.03710686f, -0.01200829f, -0.05928611f, 0.16986123f, -0.04289814f, -0.10176307f, 
    -0.00855080f, -0.08176368f, 0.08255558f, 0.04811955f, 0.02578263f, -0.00347532f, -0.10636039f, -0.17540383f, 
    0.13955575f, 0.15006945f, -0.27655330f, 0.14939332f, 0.00737971f, -0.05270638f, -0.02369045f, -0.00675541f, 
    -0.01497952f, -0.06060866f, -0.03386626f, -0.00685429f, 0.10455942f, 0.07959271f, 0.16146244f, -0.08668736f, 
    0.01291205f, -0.04801942f, 0.03253013f, -0.02982548f, -0.00148253f, 0.12467118f, 0.07092807f, 0.17944185f, 
    0.19357686f, 0.04162234f, 0.02698769f, 0.05918402f, -0.14762996f, 0.00154954f, -0.14368510f, -0.03542056f, 
    0.07373404f, -0.06869183f, 0.12327141f, -0.07379610f, 0.11158574f, -0.10066054f, 0.10669852f, 0.09901233f, 
    0.02762021f, -0.04704271f, -0.04076603f, 0.10598662f, -0.02662610f, 0.15990078f, -0.06884056f, 0.11327819f, 
    -0.03798519f, -0.10628595f, 0.03660362f, 0.03332713f, -0.08894368f, -0.00785253f, -0.01996264f, 0.01944643f, 
    0.12370787f, 0.08979886f, 0.07699421f, -0.04012556f, 0.13119185f, 0.10236604f, 0.09283581f, 0.10018544f, 
    0.14520013f, 0.07112162f, -0.05835831f, 0.03979514f, -0.13462847f, 0.06842834f, -0.05533325f, -0.07443731f, 
    -0.00643555f, 0.03560284f, 0.00485264f, 0.01187504f, 0.00533525f, 0.01707687f, 0.00156719f, 0.02454023f, 
    -0.02358464f, 0.04596451f, -0.05201489f, 0.01229320f, -0.04830110f, -0.01800745f, -0.02156237f, -0.04127168f, 
    -0.04133236f, 0.05448813f, 0.04174069f, -0.00703330f, -0.06663103f, -0.01975087f, -0.02518461f, -0.02030439f, 
    -0.05863580f, -0.03987988f, 0.02529197f, -0.06277765f, -0.05209513f, 0.00126593f, -0.02951253f, -0.06257316f, 
    -0.01237454f, -0.00373147f, -0.04531083f, -0.01266597f, 0.02789927f, -0.00422973f, 0.00022255f, 0.04982985f, 
    -0.00387953f, 0.05627789f, 0.01804614f, -0.01298093f, -0.06239466f, -0.00114045f, -0.05547470f, 0.01494496f, 
    -0.00655873f, 0.02948099f, -0.03026139f, 0.03426718f, -0.07476660f, 0.00682539f, 0.05582456f, -0.01474075f, 
    -0.07793826f, -0.07136068f, 0.04977435f, -0.05283885f, 0.04016391f, -0.06783983f, 0.02962544f, -0.05148573f, 
    -0.07643195f, -0.03800921f, -0.03194378f, 0.05875796f, -0.04572936f, -0.01246060f, -0.03995218f, 0.07095746f, 
    -0.01437650f, -0.06661673f, -0.03126951f, 0.01998842f, -0.04571767f, -0.04419477f, 0.01280268f, 0.01909984f, 
    0.00118818f, 0.02528636f, -0.01064237f, -0.04756982f, -0.06740121f, -0.07743268f, 0.05898959f, 0.03613786f, 
    -0.01703846f, 0.06166541f, -0.07537632f, 0.04413196f, -0.01293973f, -0.00004954f, 0.02203980f, -0.04935594f, 
    0.04216025f, -0.03217207f, -0.00813549f, -0.01562160f, 0.01389517f, 0.00495812f, -0.02676573f, -0.03347526f, 
    0.01345069f, 0.01608090f, -0.07211215f, 0.05439631f, -0.06811567f, 0.04364212f, -0.01522906f, -0.00910880f, 
    -0.05131147f, 0.02041699f, 0.02187118f, 0.03914906f, -0.06438316f, -0.02677547f, -0.06224295f, -0.02931567f, 
    0.03358894f, 0.03838795f, -0.06615476f, 0.04791958f, -0.00298445f, 0.03583082f, -0.06960531f, 0.01124256f, 
    -0.00834851f, -0.02340487f, 0.03439467f, -0.06317670f, 0.02617361f, -0.07777854f, -0.03664250f, 0.04992132f, 
    0.04758347f, 0.01212446f, -0.00608456f, 0.06548065f, 0.05749322f, -0.03378418f, -0.06628858f, 0.02575102f, 
    -0.06403582f, -0.05307944f, 0.06547671f, 0.06550249f, 0.05599947f, 0.00460578f, -0.01623505f, -0.05419083f, 
    0.04043042f, 0.03655761f, -0.05984201f, 0.02520354f, -0.02092039f, 0.00498052f, -0.04644090f, 0.06404896f, 
    -0.06561690f, -0.06174105f, 0.02421393f, -0.01068808f, 0.01453216f, -0.04060088f, -0.03794564f, 0.00839325f, 
    -0.05748164f, -0.00740374f, 0.04849114f, 0.03504770f, 0.01483882f, 0.03848411f, -0.05696892f, -0.03686428f, 
    -0.06759804f, 0.01557436f, -0.02395470f, -0.03053837f, -0.05732067f, -0.05751698f, 0.04805069f, -0.02658004f, 
    -0.02348832f, 0.00577755f, -0.05491615f, -0.00899646f, -0.04592416f, -0.04987028f, 0.02495165f, -0.00730122f, 
    0.30973068f, -0.13345768f, -0.23733340f, -0.03355035f, 0.06568474f, 0.04276340f, 0.02974791f, -0.04345889f, 
    0.00523923f, 0.01605286f, 0.03591096f, 0.02513776f, -0.40016744f, -0.18189190f, 0.24264131f, -0.00926352f, 
    -0.02216764f, 0.00045168f, -0.01870740f, -0.07956854f, -0.09533422f, -0.17838819f, -0.04452137f, -0.05093371f, 
    0.02324924f, 0.08991549f, -0.00767979f, -0.30764648f, -0.08503719f, 0.08455841f, -0.00019538f, -0.03086282f, 
    0.16564143f, -0.01081523f, 0.03857386f, 0.03978921f, -0.03190174f, -0.08163406f, 0.00373342f, 0.14328206f, 
    -0.05912524f, 0.10515241f, -0.14267324f, -0.16025463f, 0.01570999f, -0.04826580f, -0.06931408f, 0.02736262f, 
    -0.30168051f, 0.10575093f, -0.09252775f, -0.00875823f, -0.00970672f, 0.11007094f, -0.02831764f, -0.10307187f, 
    -0.14635283f, -0.04706853f, -0.04566271f, 0.02988580f, -0.10482255f, -0.20807947f, -0.15577361f, -0.08551884f, 
    0.03213177f, 0.03234983f, 0.02519331f, 0.19493900f, -0.08678591f, 0.05727592f, -0.10874522f, 0.18350525f, 
    0.00608578f, 0.04015169f, 0.19603351f, 0.00073187f, 0.09313358f, -0.06176759f, -0.02424669f, 0.14841251f, 
    -0.05890844f, 0.24582997f, 0.12122786f, 0.04924005f, 0.13320439f, -0.00934907f, 0.08235364f, 0.05519706f, 
    -0.08905316f, 0.06763253f, -0.01185096f, 0.15955399f, 0.00237452f, 0.05452402f, -0.03329477f, -0.03318118f, 
    -0.35292917f, 0.06051863f, 0.11797192f, 0.05228234f, 0.06317864f, 0.02173503f, 0.16140231f, 0.07423858f, 
    -0.01050554f, -0.02083932f, 0.01490438f, 0.16803581f, -0.11798079f, 0.00250485f, -0.18837900f, -0.07452816f, 
    -0.01964389f, -0.07655472f, -0.18558446f, 0.10575332f, 0.15080348f, -0.06352603f, 0.27813384f, 0.16408274f, 
    -0.11445493f, -0.18556888f, -0.09552732f, 0.06628394f, 0.03292215f, -0.02954074f, -0.09749630f, -0.08057995f, 
    0.05314769f, 0.20297837f, -0.03391116f, 0.11524341f, 0.23133992f, -0.08587532f, 0.02587202f, 0.23608282f, 
    0.11557920f, 0.03140961f, -0.01213589f, 0.07458697f, 0.01695745f, -0.13111228f, -0.04567521f, 0.07120924f, 
    0.24791397f, 0.13546246f, 0.23727505f, 0.11023086f, -0.02973361f, 0.05573060f, 0.13685918f, -0.05606360f, 
    0.12600277f, 0.03907380f, 0.10825172f, 0.18073580f, -0.11176758f, 0.13468145f, 0.15976648f, -0.11601837f, 
    0.01860050f, 0.09040944f, 0.03777628f, -0.01676399f, 0.00392663f, -0.01319277f, -0.17406291f, -0.11511540f, 
    0.10372287f, 0.12369382f, -0.08881978f, 0.00336808f, 0.04158822f, -0.03531666f, -0.01097472f, 0.03108631f, 
    -0.10875319f, -0.04045775f, 0.01941994f, -0.06380200f, -0.20307596f, 0.07324306f, 0.04257637f, 0.10643184f, 
    0.13168156f, 0.07558380f, 0.05647438f, 0.07708541f, 0.14077324f, 0.04549678f, 0.07595223f, -0.08522855f, 
    -0.37054023f, 0.12852684f, 0.04199549f, -0.04539517f, -0.02773137f, 0.01063593f, 0.11382236f, 0.28161296f, 
    0.01206500f, 0.04721480f, 0.11115173f, 0.08316169f, 0.11596378f, -0.12147492f, -0.02007950f, -0.09690886f, 
    0.01580489f, 0.06833466f, -0.06067684f, -0.03156070f, 0.08032046f, 0.07044216f, -0.08713381f, 0.01122855f, 
    0.10857499f, -0.22451146f, 0.02961647f, -0.11573574f, -0.03604877f, 0.04888586f, -0.04989360f, 0.10813969f, 
    -0.08763587f, -0.03076512f, 0.08836757f, 0.12582235f, 0.24498791f, -0.16249995f, -0.09204318f, -0.03666050f, 
    -0.08000874f, -0.07748549f, -0.12958048f, -0.11957711f, 0.04512274f, 0.06216200f, -0.07554524f, -0.06400359f, 
    -0.22969677f, -0.25545177f, -0.03195929f, -0.16524154f, 0.07425500f, -0.04692059f, 0.01838143f, 0.05140117f, 
    0.06690771f, -0.08110123f, 0.13518311f, 0.09739129f, -0.19740127f, 0.22356512f, 0.21767905f, -0.07738917f, 
    -0.02774427f, -0.03903326f, 0.05018896f, -0.06121595f, -0.10604500f, 0.00280742f, -0.01962655f, 0.07927956f, 
    0.16652811f, 0.20470287f, 0.08429515f, 0.22289777f, -0.05143795f, -0.04913992f, 0.09794614f, 0.01211425f, 
    0.11926951f, -0.14236119f, -0.09953479f, -0.19265772f, 0.08447822f, -0.01072063f, -0.07114979f, 0.22937411f, 
    0.01766322f, 0.10104544f, -0.01189353f, 0.06992561f, -0.10282976f, 0.04867699f, 0.05758771f, 0.01071907f, 
    -0.08564838f, 0.00129105f, 0.10760784f, 0.25346643f, -0.05579481f, -0.00768585f, 0.04813831f, 0.06254756f, 
    -0.03934748f, 0.02277842f, 0.04756006f, -0.04147486f, -0.15427752f, -0.05351415f, -0.10452969f, -0.01367403f, 
    0.00915421f, 0.03184887f, 0.13429520f, 0.03382700f, -0.04601580f, -0.16562888f, -0.11607679f, -0.26712039f, 
    0.04292133f, 0.03619887f, -0.17942481f, 0.33538693f, -0.05899001f, -0.01607185f, -0.09727626f, -0.00812070f, 
    0.06474624f, -0.03350369f, -0.06654384f, -0.02403718f, 0.12069330f, 0.01591060f, 0.04708500f, -0.05453661f, 
    -0.16454124f, 0.11869130f, -0.03962065f, 0.02505932f, -0.00684480f, 0.01684858f, 0.11619542f, 0.12666047f, 
    0.13503395f, -0.01366052f, 0.07386535f, 0.05840464f, -0.12196197f, 0.09792300f, -0.05492130f, 0.03193146f, 
    -0.01865897f, 0.06414461f, -0.08424355f, 0.02855260f, 0.10748407f, 0.26229396f, 0.24408782f, 0.04657666f, 
    -0.09883104f, 0.03205676f, -0.01444813f, -0.02438192f, -0.02211461f, -0.01579194f, 0.04920337f, 0.04611370f, 
    -0.16675904f, -0.15210529f, -0.03205669f, 0.13962330f, -0.00129816f, 0.10384598f, 0.02548633f, -0.00744838f, 
    0.00966068f, 0.09477121f, 0.02750450f, 0.01828863f, -0.30042115f, 0.24117377f, 0.25835222f, 0.27057615f, 
    0.05883485f, 0.04638093f, 0.03225675f, -0.00998797f, -0.01465760f, 0.05825960f, 0.07688475f, -0.02739193f, 
    -0.00260513f, -0.11551993f, -0.08297058f, -0.09006665f, 0.12483829f, 0.01206030f, -0.07847061f, -0.05821158f, 
    -0.07204114f, 0.02722087f, 0.02301571f, -0.04216424f, -0.15654533f, 0.17736277f, 0.11723181f, 0.02627134f, 
    -0.11097496f, 0.16241553f, 0.03545240f, 0.09207535f, -0.20157599f, -0.09263597f, -0.00004106f, 0.14541355f, 
    0.02350799f, -0.35791382f, 0.18121259f, 0.25172204f, -0.01116141f, -0.14435756f, -0.00694907f, -0.03417375f, 
    0.03754460f, 0.14122209f, -0.05579927f, 0.02866383f, -0.10108311f, 0.08279350f, -0.03887338f, -0.23438092f, 
    -0.01896093f, 0.05977314f, 0.06417767f, 0.04820878f, -0.00222307f, 0.01180850f, -0.04593857f, 0.11244595f, 
    0.02211833f, 0.30847213f, -0.03892003f, 0.11905134f, -0.04457414f, 0.17482163f, 0.12087717f, 0.23107482f, 
    -0.05081606f, 0.04933347f, 0.07844932f, 0.05843446f, -0.20247117f, 0.21817279f, -0.05541020f, 0.02046477f, 
    0.09961814f, -0.02596888f, -0.05365965f, -0.06893992f, 0.09745519f, 0.04626139f, 0.10092700f, -0.07886175f, 
    -0.14384681f, -0.19490522f, 0.07560197f, 0.20246598f, 0.05705221f, 0.04886536f, 0.05778170f, 0.01808198f, 
    -0.03028342f, 0.03121853f, 0.00111655f, 0.10125979f, 0.01572863f, -0.06080891f, -0.09114666f, -0.03217494f, 
    0.13961776f, -0.06541118f, 0.08137707f, -0.06662548f, -0.02338808f, 0.12997627f, 0.02702447f, -0.04779658f, 
    -0.03763176f, -0.10959722f, 0.02444042f, -0.10511718f, 0.08543698f, -0.04242918f, -0.08325790f, -0.11339024f, 
    0.10845938f, 0.02356971f, 0.03288008f, 0.05875279f, 0.04461721f, 0.18231277f, 0.14718737f, -0.00554904f, 
    0.20924313f, 0.06285032f, -0.03604308f, 0.09638218f, 0.17132837f, -0.01774733f, -0.08257736f, -0.03672414f, 
    0.17861372f, 0.12284537f, 0.06184297f, 0.18891306f, -0.08440838f, 0.05350608f, 0.09562278f, -0.00783268f, 
    -0.08525581f, -0.03889857f, 0.10446394f, 0.08906402f, 0.04880947f, 0.09449821f, -0.18430090f, 0.03005598f, 
    0.08596744f, 0.01815748f, 0.02278020f, -0.07805727f, -0.04902041f, 0.18193331f, 0.04926164f, 0.05047066f, 
    -0.02784364f, -0.06929880f, 0.14273261f, 0.39887658f, -0.05778965f, -0.09916718f, 0.02365388f, 0.09748112f, 
    -0.07461916f, 0.02453283f, -0.06496328f, 0.05090556f, -0.13991071f, -0.11719953f, 0.28192019f, 0.15815866f, 
    0.08156357f, -0.03608416f, 0.01004433f, 0.09827112f, 0.11288465f, 0.09506949f, -0.02894072f, -0.00344393f, 
    0.16429199f, 0.08316275f, -0.09636138f, -0.16689314f, 0.15856071f, 0.03580636f, -0.04904698f, -0.01493155f, 
    -0.07060141f, -0.03883664f, 0.02614809f, 0.14843930f, -0.17247035f, 0.13092396f, -0.17619915f, -0.01667429f, 
    -0.07552654f, -0.12013295f, -0.00111876f, 0.00674379f, 0.05901399f, 0.05183632f, -0.01134303f, 0.05909436f, 
    -0.06893155f, 0.06360470f, 0.03376630f, -0.15433961f, -0.00005455f, -0.06678922f, -0.11541619f, -0.06019371f, 
    -0.06184913f, 0.05626799f, -0.02935138f, -0.05416366f, 0.21442200f, 0.32008544f, -0.23870890f, -0.09548244f, 
    -0.00012969f, 0.07711250f, 0.14195099f, 0.05882797f, -0.06060231f, 0.04053663f, 0.05184404f, 0.02401489f, 
    -0.14949942f, -0.03557234f, 0.07306915f, 0.16721494f, 0.01379996f, -0.08005899f, 0.13947944f, -0.08888850f, 
    0.01773588f, 0.06217117f, 0.05765525f, -0.03798611f, 0.03208347f, 0.01308810f, -0.11912879f, -0.20535386f, 
    0.08045170f, 0.07881365f, 0.08771139f, 0.08979191f, 0.08406028f, -0.02600788f, -0.10857215f, 0.02208778f, 
    0.22814657f, 0.15221576f, -0.13644312f, 0.14952624f, 0.04778105f, 0.01240021f, 0.09242676f, 0.17505734f, 
    0.06757978f, 0.12732148f, 0.05714263f, -0.05357471f, 0.40510207f, 0.06556951f, 0.00256824f, 0.05291652f, 
    -0.15499789f, 0.07062852f, -0.00686049f, -0.16730435f, 0.11353980f, -0.00500140f, -0.00127831f, -0.11488715f, 
    -0.15313305f, -0.08823030f, -0.00704391f, 0.06295735f, -0.14290760f, -0.02064686f, 0.15486735f, 0.02257229f, 
    0.02738129f, -0.09485559f, -0.09904412f, 0.11288068f, -0.00448892f, -0.03792429f, -0.16119979f, 0.12123156f, 
    0.10841233f, -0.11650185f, 0.07208320f, -0.07217377f, -0.01560483f, 0.02592642f, 0.02131709f, 0.08795862f, 
    0.16059926f, -0.16618250f, -0.05309562f, -0.05157540f, -0.03141294f, -0.06338277f, -0.11269709f, -0.07752152f, 
    -0.03685350f, 0.03417065f, 0.03599288f, -0.05043449f, 0.11552121f, -0.00101291f, 0.22028118f, 0.13883103f, 
    0.10861502f, 0.13956703f, 0.05619739f, -0.07570499f, -0.07403556f, 0.07861906f, -0.12931187f, -0.10485247f, 
    0.08822930f, 0.29556307f, 0.08575714f, 0.10336939f, 0.18214555f, 0.16471201f, 0.03032173f, -0.04368899f, 
    -0.08208606f, -0.05969452f, 0.10104442f, -0.07297926f, -0.20128165f, 0.08827992f, 0.02062237f, -0.06176426f, 
    -0.23855980f, -0.15564214f, 0.00329699f, -0.01885375f, -0.03750389f, 0.05938566f, 0.08873110f, -0.05973014f, 
    -0.04879823f, -0.01255244f, -0.05155602f, 0.01511922f, 0.02884984f, -0.02548548f, -0.10969351f, 0.11184446f, 
    0.02907111f, -0.02285178f, -0.01206110f, -0.16829197f, 0.12792471f, -0.01301185f, -0.05021738f, 0.05787404f, 
    0.06709858f, -0.07632987f, 0.02006002f, 0.07185690f, 0.05288487f, 0.10316630f, -0.07875320f, 0.09842146f, 
    0.05222468f, 0.19614817f, 0.06510769f, -0.18883942f, 0.03216068f, -0.03331750f, -0.00153638f, 0.12808481f, 
    0.15771821f, -0.07550909f, 0.01913187f, -0.06585798f, 0.40445858f, 0.06420712f, -0.23444729f, 0.00279202f, 
    -0.11739954f, -0.11879307f, -0.09023637f, -0.02394465f, 0.10084357f, -0.02124186f, -0.00148554f, 0.11579372f, 
    0.09117308f, -0.13687120f, -0.01964870f, 0.03037801f, 0.02356626f, 0.00280016f, -0.04534059f, 0.05397652f, 
    0.07061449f, -0.01395847f, 0.07845068f, -0.09599078f, 0.65802193f, 0.16805191f, -0.19250351f, -0.11828047f, 
    0.12215427f, -0.15766272f, -0.01845604f, -0.01698733f, 0.04091613f, 0.00182304f, 0.01806233f, -0.03146771f, 
    -0.05178819f, 0.11839238f, 0.02853874f, -0.04116646f, 0.00201626f, 0.08221351f, 0.02867055f, 0.12358708f, 
    -0.00526233f, 0.01894438f, 0.14329198f, -0.00101284f, 0.19123785f, 0.34020564f, 0.07474314f, -0.00984287f, 
    0.08686960f, -0.04106226f, 0.15236981f, 0.08462936f, 0.10008691f, 0.03964221f, 0.03429170f, -0.10380243f, 
    0.40845466f, 0.13209067f, 0.04873688f, -0.00775913f, -0.05007451f, 0.09677512f, -0.04714231f, -0.09996863f, 
    -0.03095840f, -0.04736789f, 0.05658471f, 0.05875781f, 0.11751624f, -0.07240821f, -0.22352707f, 0.06643657f, 
    -0.06941406f, 0.14330423f, -0.01257240f, -0.00054826f, 0.06336195f, 0.08012465f, -0.02065302f, -0.00232716f, 
    0.07791690f, 0.03090981f, 0.00592433f, -0.06391215f, -0.00602302f, 0.15255187f, 0.02630554f, -0.02828521f, 
    -0.15133348f, -0.09105802f, -0.04609067f, -0.08387458f, -0.05817640f, 0.22008978f, 0.05471056f, -0.07119358f, 
    0.20187990f, -0.16241468f, 0.00661171f, 0.03426737f, 0.00553057f, 0.01970847f, 0.00725864f, -0.00781624f, 
    0.13646685f, 0.04703994f, 0.11673681f, 0.00207105f, 0.00910760f, -0.05537624f, -0.01236809f, -0.01178039f, 
    0.06509757f, 0.05165234f, 0.09305187f, -0.00985718f, 0.15818372f, 0.10038233f, 0.01309118f, 0.00016767f, 
    0.05516744f, -0.01608082f, -0.01442310f, -0.03628903f, -0.05914164f, 0.02614403f, -0.08168200f, -0.02665154f, 
    0.05362461f, 0.11512683f, -0.09810507f, -0.08040188f, 0.07985694f, -0.05844409f, 0.00496755f, 0.12165214f, 
    0.02414107f, 0.07181384f, 0.17515898f, -0.03841052f, -0.28686401f, 0.03311168f, -0.09181077f, 0.01423746f, 
    -0.04474439f, -0.09971581f, 0.04314252f, 0.01694955f, 0.02981558f, 0.01245560f, -0.08405899f, -0.05438007f, 
    -0.23062158f, -0.08986618f, -0.25094840f, -0.36338034f, 0.01858173f, 0.07518426f, 0.04478511f, 0.07315064f, 
    0.01064160f, 0.02992535f, 0.11269026f, -0.11743404f, 0.13167956f, -0.26240391f, -0.21590960f, 0.04951897f, 
    -0.13769285f, -0.01218164f, -0.09717759f, -0.01031177f, -0.02273590f, 0.04741389f, 0.12533341f, 0.04928489f, 
    0.14705689f, 0.18397906f, 0.24304068f, 0.05398073f, 0.06566902f, -0.13216606f, -0.00184841f, 0.09250928f, 
    0.08551140f, -0.03801282f, -0.00186000f, -0.10708020f, 0.23268813f, -0.09632973f, -0.15263224f, -0.14435428f, 
    -0.00588043f, 0.05669145f, 0.03442892f, 0.02476314f, 0.07958071f, -0.11698259f, 0.03134672f, 0.02060059f, 
    -0.06096008f, -0.12056175f, -0.02936503f, -0.14239945f, 0.00117032f, 0.05571189f, -0.00672976f, 0.02852040f, 
    0.15071996f, 0.05004480f, 0.11017553f, 0.03164468f, -0.03115872f, -0.09354091f, 0.12537824f, -0.06042839f, 
    0.00318031f, -0.05551651f, -0.05999309f, -0.01583404f, 0.18959172f, 0.04992158f, -0.03670523f, 0.06389128f, 
    0.19730245f, 0.06686645f, -0.09169604f, -0.10691524f, 0.01402239f, -0.03284620f, -0.02917830f, -0.01408842f, 
    -0.00375143f, 0.02357648f, -0.00057592f, 0.04537265f, 0.12207796f, -0.00462205f, 0.07402483f, 0.19812433f, 
    -0.11910693f, 0.03011849f, -0.04389220f, -0.02810098f, -0.05144988f, 0.00462688f, 0.06042516f, -0.02205677f, 
    -0.21311577f, 0.10880677f, -0.06054219f, -0.01324212f, 0.11309275f, -0.02900522f, 0.08784183f, 0.02316594f, 
    -0.04731885f, -0.08498725f, -0.01857840f, 0.02307582f, -0.21374094f, -0.15724510f, -0.08702303f, 0.15090081f, 
    -0.06268267f, -0.00882839f, 0.00920575f, 0.04150547f, -0.10589576f, 0.00512737f, -0.07529669f, 0.13842455f, 
    0.33577818f, 0.03100733f, 0.04226427f, 0.02671169f, 0.12625828f, 0.03675972f, 0.03722166f, 0.04858520f, 
    -0.04099091f, 0.06199368f, 0.11882936f, -0.04806405f, 0.37689695f, -0.37372169f, 0.10435114f, 0.01432274f, 
    -0.06270066f, 0.18472891f, -0.12302084f, -0.04449478f, -0.05815374f, 0.02370501f, 0.00569433f, -0.02973408f, 
    -0.39402726f, -0.04556119f, 0.13503791f, 0.02913780f, -0.07152665f, 0.02860151f, 0.14273939f, 0.07012188f, 
    0.02278714f, -0.11147849f, -0.06758473f, 0.08356047f, -0.01256184f, 0.14665452f, -0.10917819f, -0.09140168f, 
    0.13170357f, 0.03350177f, 0.03950025f, 0.10343542f, 0.04322437f, -0.13621724f, 0.02149845f, 0.04155000f, 
    0.02366916f, -0.21552476f, 0.07285269f, -0.03041581f, 0.03352377f, 0.00659997f, 0.07671115f, 0.00167533f, 
    -0.03560553f, 0.01730830f, -0.03587361f, 0.05721579f, 0.11305653f, 0.12126444f, 0.03958731f, 0.04641550f, 
    0.00311758f, -0.00379359f, -0.03515661f, 0.05132286f, 0.05335711f, -0.15087897f, 0.04312932f, 0.09529305f, 
    -0.04738672f, -0.05875201f, 0.10545091f, -0.06738600f, -0.06909753f, 0.10444972f, 0.01611066f, 0.11839765f, 
    0.12679678f, 0.13419752f, 0.11218224f, 0.07055606f, -0.30826661f, 0.07072390f, -0.04500756f, -0.18284008f, 
    -0.02340380f, 0.07388189f, 0.03091872f, -0.01211631f, -0.04683438f, 0.01723721f, -0.06477518f, 0.00547274f, 
    0.17486037f, -0.13239525f, 0.06666111f, 0.07879804f, 0.05889957f, -0.05194055f, -0.00403834f, -0.03161703f, 
    0.08240053f, -0.03350495f, -0.00767583f, -0.02587983f, 0.03482538f, -0.18634775f, 0.04749469f, 0.08403050f, 
    -0.05107969f, 0.03238682f, 0.00799771f, 0.02256833f, 0.01630337f, -0.08277619f, 0.05226514f, -0.03380812f, 
    -0.35559782f, -0.16341208f, 0.05033446f, -0.18086453f, 0.01214823f, -0.06385870f, -0.10813089f, 0.02165896f, 
    -0.07843493f, 0.01807401f, 0.02799265f, 0.07475557f, 0.00937420f, 0.06794455f, -0.01955059f, 0.01652100f, 
    -0.01140581f, -0.04116923f, 0.03352078f, 0.13421251f, 0.04416591f, -0.00449915f, 0.02989333f, 0.06038136f, 
    0.16371560f, -0.13661887f, -0.01416741f, 0.13355766f, -0.02247762f, -0.02683650f, -0.00364621f, 0.11740097f, 
    -0.01886417f, 0.02254738f, -0.00037732f, 0.10380614f, -0.04622381f, -0.06874906f, -0.02176755f, -0.11299811f, 
    -0.07611559f, -0.03776801f, -0.14193468f, -0.08305944f, 0.02170787f, -0.07548463f, -0.12650715f, 0.07886617f, 
    -0.06190263f, -0.03122861f, 0.21238439f, -0.03474591f, 0.12756492f, -0.07552370f, 0.07650013f, 0.08874390f, 
    0.12787780f, 0.05468908f, 0.03870956f, 0.04981553f, -0.29449272f, 0.20312016f, 0.18303268f, 0.07187889f, 
    0.12130006f, -0.14700425f, 0.07611063f, -0.06615639f, 0.01335751f, 0.04295940f, -0.03174605f, 0.06939995f, 
    -0.00660602f, -0.08891176f, 0.17681508f, 0.23366641f, 0.02088354f, 0.09292185f, -0.06216624f, 0.00180151f, 
    0.14573127f, 0.00531088f, 0.01700532f, 0.05057668f, 0.14702116f, -0.17524961f, -0.06459733f, 0.05439347f, 
    0.01094063f, 0.19647740f, -0.07574115f, -0.04114691f, -0.13568649f, 0.10520220f, 0.02070444f, -0.03872843f, 
    -0.10322957f, -0.02850682f, -0.02683226f, -0.09569904f, 0.11985736f, 0.12659678f, -0.06578043f, -0.04939194f, 
    0.16123269f, 0.02142400f, 0.02879401f, 0.12564857f, -0.12825832f, 0.07508504f, -0.10207055f, -0.08428077f, 
    0.10290769f, 0.09973495f, 0.03639488f, 0.01587226f, 0.05588781f, -0.00245670f, 0.00800232f, -0.00791127f, 
    0.20128062f, 0.04201114f, -0.12574363f, 0.40713271f, -0.01530690f, -0.04082664f, -0.04396887f, -0.03551102f, 
    0.02861616f, -0.01976490f, 0.03780886f, -0.02345806f, 0.22130507f, 0.00545046f, -0.01192202f, 0.09414424f, 
    0.05634209f, -0.01333953f, -0.06920100f, 0.03018093f, -0.02331387f, 0.05480326f, 0.15660103f, 0.11130828f, 
    -0.02526440f, 0.02517634f, 0.14546455f, 0.41006750f, -0.18769145f, -0.05264506f, 0.05738829f, 0.09045267f, 
    -0.05021221f, 0.06197032f, 0.05894544f, -0.02470622f, -0.03089300f, -0.06375550f, 0.56924301f, 0.21395607f, 
    0.00165502f, 0.00844367f, 0.07130989f, 0.07557298f, 0.02192996f, 0.00233563f, -0.12730470f, 0.19579996f, 
    -0.01574133f, -0.04504560f, -0.09057581f, -0.14060679f, -0.04407678f, 0.01858614f, -0.02773080f, -0.11347459f, 
    -0.01136429f, 0.03541067f, 0.13166729f, 0.08568498f, -0.21596408f, 0.16559899f, 0.07976161f, 0.03823042f, 
    0.13041809f, 0.00144643f, 0.05414793f, -0.04988975f, -0.07672773f, 0.07369696f, -0.05322203f, -0.02489166f, 
    0.01415233f, -0.01536216f, -0.04240644f, -0.12762399f, 0.04802503f, -0.03194194f, -0.01616823f, 0.27012661f, 
    0.03018606f, 0.04251374f, 0.07581300f, 0.07893337f, -0.07269430f, 0.00953521f, 0.05584723f, -0.06549579f, 
    -0.16798536f, 0.13439171f, 0.09752691f, -0.04288622f, 0.10522893f, -0.08734791f, -0.03631887f, 0.02202314f, 
    0.30299306f, -0.09734873f, -0.00118286f, -0.05981358f, -0.09524617f, -0.02981952f, -0.11603860f, 0.00349321f, 
    -0.01165973f, 0.06406727f, 0.09979245f, -0.02337296f, 0.08492111f, 0.11687292f, -0.02880760f, 0.13317584f, 
    0.06751420f, 0.07077014f, 0.01575181f, -0.04351867f, -0.00116724f, 0.09511209f, -0.02698984f, -0.13997447f, 
    -0.18355516f, 0.16239682f, -0.25320649f, 0.00959402f, 0.08373310f, 0.21825269f, 0.06795954f, 0.14093991f, 
    0.03059961f, 0.03340692f, 0.01194054f, -0.04769436f, 0.04930588f, 0.09661467f, 0.12641266f, 0.03543218f, 
    -0.08635587f, -0.07506257f, -0.03051563f, -0.05467581f, -0.06577329f, -0.04860420f, -0.04710583f, -0.02779754f, 
    -0.02261478f, -0.02425007f, 0.04082990f, 0.25843421f, 0.07992660f, -0.04895180f, 0.09868176f, 0.11779790f, 
    0.20613816f, -0.05321273f, -0.01845418f, -0.10190595f, 0.15241872f, -0.09709137f, -0.03088894f, 0.18672939f, 
    -0.04623457f, 0.07092458f, -0.00297914f, -0.05644185f, -0.14865643f, 0.11740899f, 0.03355745f, -0.04432948f, 
    -0.34899589f, 0.00293670f, 0.28021118f, 0.06291877f, 0.04510341f, -0.01869506f, 0.03306298f, 0.17339791f, 
    -0.00078240f, 0.06623228f, 0.01966108f, 0.07599115f, 0.01125303f, 0.12922588f, 0.04436179f, 0.02050875f, 
    0.05162549f, 0.04620709f, -0.08396390f, -0.00529391f, 0.04355676f, -0.17286688f, -0.06366243f, -0.18259835f, 
    -0.10470665f, -0.12106766f, -0.06996544f, 0.05844957f, 0.00963217f, 0.04430757f, -0.01245173f, -0.21007028f, 
    -0.04309794f, -0.10615455f, 0.00470850f, -0.07256091f, 0.00985521f, -0.02386881f, -0.06021026f, 0.06037594f, 
    -0.10944030f, 0.06528290f, -0.18191157f, 0.01927731f, -0.01331492f, 0.03181683f, 0.15103243f, 0.13816960f, 
    -0.03608087f, -0.22041565f, 0.13870163f, -0.06238210f, -0.08218629f, -0.06227830f, 0.15143503f, 0.06319783f, 
    0.02474646f, 0.03415733f, -0.01756438f, -0.08325360f, 0.36907369f, 0.05186032f, 0.20332873f, -0.14219716f, 
    -0.03155505f, -0.04897168f, 0.11207542f, 0.01885721f, -0.03109409f, 0.03210052f, -0.12403174f, 0.02080813f, 
    0.07511713f, -0.12502649f, 0.03489006f, 0.04058921f, -0.02041865f, 0.13655218f, -0.17045744f, -0.00792294f, 
    -0.08342187f, 0.07635538f, 0.00937459f, 0.10793537f, 0.15631907f, -0.07099244f, 0.12102245f, 0.22905578f, 
    0.05893487f, 0.04952456f, -0.16730939f, -0.00714082f, -0.16571446f, 0.04677846f, 0.11405097f, 0.04509698f, 
    0.19649357f, -0.18625084f, -0.07109917f, 0.04885256f, 0.11634112f, -0.08659352f, 0.04126841f, 0.19450577f, 
    0.02781010f, 0.01354798f, 0.12792540f, -0.04490252f, -0.20412412f, -0.16019587f, 0.13088828f, -0.18779348f, 
    0.00548575f, 0.00067670f, -0.00611257f, 0.08222482f, 0.05099660f, -0.04599330f, -0.06477601f, -0.02433922f, 
    0.45144150f, 0.03415657f, 0.04792811f, 0.03121243f, -0.02480805f, 0.08987475f, -0.01343459f, 0.16687384f, 
    -0.01623930f, 0.01498116f, 0.06113064f, 0.03183493f, -0.25049323f, 0.20506941f, -0.28591153f, -0.17750491f, 
    0.01252222f, 0.01059753f, -0.04848341f, -0.22922416f, -0.12539233f, 0.05857247f, -0.07390277f, -0.01525720f, 
    -0.13229792f, 0.25825116f, -0.16723670f, 0.17321059f, 0.04489752f, 0.23366481f, -0.18068159f, -0.09702460f, 
    -0.01484721f, -0.03739898f, 0.03068264f, 0.04517470f, 0.18898389f, -0.19740060f, 0.10168720f, 0.07155804f, 
    -0.00494304f, -0.06739949f, -0.02583360f, 0.02311335f, 0.04418633f, 0.01338372f, -0.19076587f, 0.04251322f, 
    0.04229363f, -0.22434832f, 0.07789748f, 0.05416536f, -0.03462470f, -0.01276465f, -0.05936243f, 0.02747050f, 
    0.07989924f, 0.07601685f, -0.01367266f, -0.00239915f, 0.04466634f, 0.21576294f, 0.08539122f, 0.07655608f, 
    -0.09542805f, 0.03754835f, 0.04434664f, 0.04015513f, -0.07594059f, -0.00607461f, -0.02056449f, 0.03024918f, 
    -0.26064110f, 0.14933673f, 0.14730042f, 0.04709447f, -0.00549453f, -0.04079009f, 0.13229734f, 0.07720054f, 
    0.11780814f, -0.03113405f, -0.01696185f, 0.02281578f, 0.05255345f, 0.15206777f, -0.07199544f, -0.08308937f, 
    0.20486766f, 0.02393425f, -0.08470058f, 0.06663455f, 0.08395012f, -0.09447186f, 0.13220674f, -0.13259527f, 
    -0.15102673f, -0.02090579f, -0.11218132f, -0.02123138f, -0.01226872f, -0.00804336f, 0.04220094f, -0.03896260f, 
    0.11738139f, -0.01600350f, 0.04643819f, -0.03437303f, 0.03211182f, -0.31898460f, 0.05491814f, 0.22066729f, 
    0.03324502f, 0.09871626f, -0.02519077f, 0.00598142f, -0.04843256f, 0.14200832f, 0.09047428f, -0.01623057f, 
    0.14533290f, 0.02616954f, 0.09994546f, 0.02801309f, -0.03879077f, -0.01705159f, 0.03238164f, 0.00999336f, 
    0.10002817f, -0.09270691f, 0.03274429f, -0.02528978f, 0.15779039f, -0.25996587f, 0.22850204f, 0.05070033f, 
    0.03552713f, -0.07638270f, -0.05767212f, 0.02894404f, -0.00399965f, 0.00298138f, -0.00093996f, 0.07840402f, 
    -0.03629359f, 0.05202342f, 0.09754139f, -0.01893752f, 0.04269145f, 0.06039074f, 0.07824614f, 0.05159150f, 
    -0.10754914f, 0.02320585f, -0.00069317f, 0.02894021f, 0.12479284f, -0.04204048f, -0.02748415f, 0.03750013f, 
    -0.01089544f, 0.01209616f, -0.02206429f, -0.01966538f, -0.08611839f, 0.12884058f, 0.00502280f, -0.05081356f, 
    -0.32378992f, 0.10531330f, -0.01328960f, 0.07029242f, 0.01741599f, -0.00148378f, 0.04853952f, -0.18294413f, 
    -0.08233444f, 0.07307792f, -0.03422778f, -0.03782291f, -0.04496491f, 0.19359545f, 0.10279228f, 0.06217379f, 
    0.11129101f, -0.05381263f, 0.03489264f, 0.05572682f, -0.13548608f, -0.07460791f, 0.02781713f, 0.06074136f, 
    -0.37790662f, -0.15075496f, -0.01913512f, 0.25376645f, 0.09378462f, 0.10605729f, 0.05390031f, -0.05269346f, 
    -0.10251432f, 0.07428448f, 0.01550953f, -0.03664410f, -0.14539106f, -0.03793724f, -0.09809230f, -0.33634964f, 
    0.10751218f, -0.01134280f, -0.00606077f, 0.08192833f, 0.12725121f, 0.01741236f, 0.00322271f, 0.06650388f, 
    0.30450541f, -0.03837580f, 0.09469592f, -0.09362102f, -0.12971385f, -0.02196962f, 0.03065266f, -0.05539064f, 
    -0.00628001f, 0.01725874f, 0.06888598f, -0.00427326f, 0.10169891f, 0.04140831f, 0.19884054f, -0.14952484f, 
    0.05037190f, -0.00899766f, 0.01860921f, 0.04289560f, 0.13776954f, -0.02714509f, 0.09604453f, -0.04186997f, 
    0.12241539f, 0.05717514f, 0.15158331f, 0.04037362f, -0.01226317f, -0.08925227f, -0.00816002f, -0.07400510f, 
    -0.04336199f, 0.08396105f, -0.10585229f, 0.08305269f, -0.13771915f, 0.10566411f, -0.05125458f, 0.04752289f, 
    0.05550390f, -0.02760150f, -0.02549201f, -0.08879383f, 0.10392915f, 0.03131786f, -0.00381341f, -0.03331045f, 
    0.26899087f, -0.06736398f, -0.35641834f, 0.08986314f, -0.00543353f, 0.04391809f, -0.07923462f, -0.12038904f, 
    0.18409437f, 0.01265884f, 0.07682166f, 0.01351039f, 0.07539911f, 0.03934133f, 0.11116029f, -0.03708852f, 
    0.02619495f, -0.05597979f, 0.02691627f, 0.02149070f, -0.00203063f, 0.18919916f, -0.00325686f, 0.09187455f, 
    0.22255187f, 0.06883519f, -0.00913848f, 0.29193398f, 0.03219173f, -0.02998885f, -0.03253718f, 0.10774067f, 
    0.02076747f, -0.05795027f, 0.02384579f, 0.12656504f, 0.24397349f, 0.26815054f, 0.01174644f, 0.02029029f, 
    0.12446083f, 0.08910584f, 0.16161370f, -0.01099567f, -0.00529629f, 0.08664300f, -0.03835578f, -0.04730247f, 
    0.08447374f, 0.14584704f, 0.02128363f, 0.35129139f, -0.03225346f, 0.02797187f, -0.12574074f, -0.09300952f, 
    -0.02956864f, -0.00824875f, -0.07443428f, 0.02554599f, 0.05943124f, -0.04438912f, 0.05079289f, 0.33218861f, 
    0.09533252f, 0.03089685f, -0.01988328f, 0.03754115f, 0.04747120f, 0.09045121f, -0.00221324f, -0.05274661f, 
    -0.00858548f, 0.03629423f, -0.07755199f, -0.05456335f, 0.13178982f, -0.07984293f, 0.11901075f, 0.03642244f, 
    0.00234737f, -0.05838315f, -0.02594995f, -0.04226886f, -0.13284002f, 0.20915873f, -0.13418101f, -0.14246972f, 
    0.09914611f, -0.07124194f, 0.13829455f, 0.08842810f, 0.00889254f, 0.01784308f, 0.09018780f, 0.02493532f, 
    -0.00411513f, 0.01352848f, -0.05253572f, 0.02235712f, 0.00426351f, 0.00351873f, -0.04599074f, 0.05267732f, 
    0.02591814f, -0.04386047f, -0.05817915f, 0.02324032f, -0.07307424f, 0.03264457f, 0.03462943f, -0.00424450f, 
    -0.02026732f, -0.04973158f, -0.04047769f, -0.06770834f, -0.08292542f, 0.01615207f, 0.03547712f, -0.01769679f, 
    -0.04326902f, -0.05081195f, 0.00145110f, 0.03655930f, 0.04534540f, 0.02624832f, 0.05518694f, 0.00616778f, 
    0.04203706f, -0.05077241f, -0.07427772f, -0.05193982f, 0.04921668f, 0.02763378f, -0.06361215f, -0.01100547f, 
    0.00336389f, -0.06594526f, -0.01985843f, -0.05492190f, -0.05373508f, -0.01625800f, 0.03334160f, 0.02474372f, 
    0.03230104f, -0.01189044f, -0.05203182f, -0.01547363f, -0.06761094f, 0.01157835f, -0.08361772f, -0.06891941f, 
    -0.08327097f, -0.02698743f, -0.02661422f, 0.03929521f, -0.01036368f, -0.05033694f, 0.01055862f, -0.08084253f, 
    -0.01993844f, 0.03118774f, 0.01397081f, 0.05521427f, 0.00559721f, -0.01114182f, -0.00871302f, -0.01460953f, 
    -0.04256389f, -0.02781656f, 0.00962911f, 0.05434301f, 0.02261633f, 0.00666529f, -0.06715208f, 0.02218279f, 
    0.02473869f, -0.02015103f, -0.05540897f, 0.02380184f, -0.02060580f, -0.03347392f, 0.04935243f, -0.04527033f, 
    0.04408820f, 0.00838895f, 0.00400317f, 0.03803213f, -0.06265370f, -0.08218221f, -0.02036436f, 0.05723403f, 
    -0.02362261f, -0.00198668f, -0.06878770f, -0.06998753f, 0.01544729f, -0.01721135f, -0.06839939f, 0.03459336f, 
    -0.02989337f, 0.01600375f, -0.05874015f, -0.07047621f, 0.00442188f, 0.03340985f, -0.04050066f, 0.05439729f, 
    0.01401120f, -0.02823980f, -0.01256269f, 0.03614431f, 0.03819850f, 0.01691793f, -0.01574122f, 0.01967571f, 
    0.05841307f, 0.01324745f, -0.08047890f, 0.01964971f, -0.08411913f, -0.04868940f, 0.02643714f, 0.05442851f, 
    -0.07803378f, -0.02109558f, 0.01728553f, -0.06139490f, -0.04268329f, 0.04032902f, 0.05068573f, 0.00897406f, 
    0.03383689f, 0.05105087f, -0.02307092f, 0.06399506f, 0.04563510f, -0.00429744f, 0.03851249f, -0.01956843f, 
    0.02536612f, 0.05753136f, 0.01911814f, -0.00391766f, -0.08403078f, -0.07289279f, -0.02577493f, 0.03120277f, 
    0.01818858f, 0.02880142f, 0.01543654f, 0.01139219f, 0.03322065f, -0.01206233f, 0.05415414f, 0.02858002f, 
    0.04194698f, -0.00001498f, -0.07888691f, 0.05655589f, -0.00402626f, -0.04390987f, 0.05813824f, -0.07812129f, 
    -0.07917023f, -0.05006002f, 0.04981067f, -0.01246128f, -0.06926105f, -0.07295559f, -0.02698914f, -0.04437568f, 
    -0.03781907f, -0.07958800f, -0.04981236f, 0.02821446f, -0.05497618f, 0.03114298f, 0.04726557f, 0.00145927f, 
    -0.05244833f, -0.03556223f, -0.03914942f, 0.00614179f, -0.03996354f, -0.05653384f, 0.00521471f, -0.02561074f, 
    0.02566072f, 0.32554486f, 0.10235789f, 0.10123100f, -0.06355163f, -0.02032768f, 0.07327167f, 0.04789131f, 
    -0.00067018f, 0.08186318f, 0.01969030f, -0.05256584f, 0.13021880f, -0.22544613f, -0.19821206f, -0.00773066f, 
    0.09673610f, 0.06387793f, 0.00853620f, -0.04523245f, 0.19021593f, -0.00014687f, 0.01623031f, -0.02057288f, 
    0.13694017f, 0.03857882f, 0.13432562f, -0.14102399f, -0.05466343f, -0.04018119f, -0.06929644f, 0.14189582f, 
    0.04946062f, -0.00121259f, -0.08539812f, 0.04977811f, 0.23452181f, -0.26808167f, -0.05577124f, 0.28129023f, 
    0.09735978f, 0.01578132f, -0.02470844f, -0.12746593f, 0.12377891f, 0.10202676f, 0.00855806f, -0.00172099f, 
    -0.20701075f, -0.20859006f, -0.11690294f, 0.08303762f, 0.08645411f, 0.06686065f, -0.11966606f, -0.04992633f, 
    0.06173402f, 0.06083285f, 0.04456091f, -0.02574351f, 0.06152099f, 0.02431864f, 0.10679793f, -0.23287708f, 
    0.06734888f, -0.11415644f, -0.03503780f, 0.00467287f, -0.02913734f, -0.06112804f, -0.08502208f, 0.09217048f, 
    -0.04199983f, 0.15728790f, 0.00661927f, 0.15739955f, 0.08720744f, -0.05155765f, -0.10016569f, -0.02220021f, 
    0.11307177f, 0.03490419f, 0.01384714f, -0.07863846f, 0.01844517f, 0.01482063f, -0.04286972f, 0.09365562f, 
    -0.06805237f, 0.08995710f, 0.10083434f, 0.16834897f, -0.01605641f, 0.03210355f, -0.02929798f, -0.02877901f, 
    -0.03820484f, 0.14602759f, 0.12112647f, 0.07520258f, -0.03865550f, -0.03416926f, 0.03415138f, 0.18134309f, 
    0.00414403f, 0.03753649f, 0.08751284f, 0.09781721f, 0.01920865f, -0.04195775f, 0.00980859f, -0.01786159f, 
    -0.02602335f, 0.01457907f, 0.00733794f, 0.03886673f, 0.07078856f, -0.00931462f, 0.07549716f, 0.11563170f, 
    -0.12059966f, -0.12735412f, -0.12359197f, 0.28640974f, -0.04195777f, -0.02242862f, 0.00504106f, -0.03745701f, 
    0.06052949f, 0.14371324f, -0.15852048f, -0.12153434f, 0.12741072f, -0.11427609f, 0.02994887f, -0.02168175f, 
    -0.06423575f, 0.07085401f, -0.03466249f, -0.01963914f, 0.04588209f, -0.16382648f, 0.01895062f, -0.02404391f, 
    0.09782957f, 0.01062868f, 0.07415333f, -0.05291012f, 0.01333791f, -0.04508771f, -0.02581785f, -0.11208340f, 
    0.18323661f, 0.03504896f, 0.00474776f, -0.06303484f, 0.25731906f, 0.44570854f, 0.19433677f, -0.01313209f, 
    -0.05706143f, -0.00313069f, -0.10906326f, 0.11967120f, -0.04434140f, -0.10514574f, 0.03755205f, 0.00162048f, 
    -0.06447025f, 0.14617877f, 0.00304431f, 0.13807857f, -0.14583230f, -0.05188534f, -0.04711875f, 0.00193409f, 
    -0.12178515f, -0.03972017f, 0.06164066f, -0.02407852f, -0.14664920f, 0.09046233f, 0.13135791f, 0.28555858f, 
    -0.11103477f, 0.05131801f, 0.00376931f, -0.06812888f, -0.03590287f, -0.02360074f, -0.05832317f, -0.06556312f, 
    -0.08648104f, -0.43021521f, -0.11965336f, 0.11579269f, 0.01870219f, 0.17150225f, -0.01498693f, 0.06906952f, 
    -0.03799453f, 0.09248714f, 0.00401878f, -0.00913099f, 0.21695608f, 0.02763159f, 0.21449472f, 0.01312246f, 
    0.07277679f, -0.10356757f, 0.03412668f, -0.11177079f, 0.08069609f, -0.05098787f, 0.06187473f, -0.04784550f, 
    -0.18313546f, 0.10770960f, -0.17449293f, 0.08046111f, 0.02656540f, 0.09317377f, 0.01531614f, 0.07495593f, 
    -0.07306052f, 0.01468005f, -0.03049576f, 0.16318318f, 0.33776352f, 0.25178412f, 0.22731887f, -0.02515727f, 
    -0.07423078f, 0.07929365f, 0.04979067f, 0.08996686f, 0.08738029f, 0.04424530f, 0.12758830f, 0.07767548f, 
    0.39368525f, 0.02541425f, 0.15749229f, -0.20732744f, -0.05438243f, 0.07501922f, -0.09699882f, -0.11453453f, 
    0.07586098f, -0.04567221f, -0.10514917f, 0.07809716f, -0.29336575f, -0.07003969f, -0.16596006f, 0.12720984f, 
    0.13175447f, 0.13076600f, 0.05763526f, 0.19555867f, -0.07849815f, 0.04370719f, -0.03130761f, 0.11868997f, 
    0.03240990f, -0.12341467f, 0.01557201f, 0.09995510f, 0.20963021f, 0.03490055f, -0.02684885f, -0.10598815f, 
    -0.13478880f, 0.04767191f, 0.07338637f, -0.13393059f, -0.11217536f, -0.12615114f, 0.06875293f, 0.05694932f, 
    0.13387841f, 0.05031100f, -0.09565610f, 0.19788118f, 0.11141937f, -0.01118399f, 0.08504002f, -0.00278755f, 
    -0.19753720f, -0.09635039f, 0.06653416f, 0.15720865f, 0.17205544f, 0.01473797f, 0.16162476f, -0.10460821f, 
    0.10057556f, -0.03042801f, -0.08144125f, -0.11121497f, 0.16751206f, 0.09768285f, 0.10227831f, -0.13766496f, 
    0.09195805f, -0.04992120f, -0.00244520f, 0.09377584f, 0.02745769f, 0.05819270f, 0.17983845f, 0.02851128f, 
    -0.05353618f, -0.20602947f, 0.00484848f, 0.03247608f, 0.00233085f, -0.26326644f, 0.02878793f, 0.03059492f, 
    0.03863625f, 0.01612296f, 0.08916365f, 0.08268257f, -0.03164986f, -0.06596763f, -0.07033656f, -0.00440694f, 
    0.20052803f, 0.11970993f, 0.02732582f, 0.00296371f, -0.00034971f, -0.02500773f, -0.11848186f, 0.15226990f, 
    -0.18927771f, -0.06032101f, -0.11082548f, 0.12872083f, -0.12571822f, -0.02600563f, 0.01802055f, 0.01487635f, 
    0.07972071f, 0.09173805f, 0.10426072f, 0.06919481f, 0.12772946f, -0.10726319f, -0.26003808f, 0.12008978f, 
    -0.03056812f, 0.01218768f, -0.03308825f, -0.11751648f, -0.02630132f, 0.15705356f, -0.08591791f, -0.02066971f, 
    0.03575871f, -0.13031593f, 0.01407604f, 0.05374068f, 0.09507709f, -0.15486126f, -0.00678632f, 0.02049166f, 
    0.06944471f, -0.01749224f, 0.05920819f, -0.07891415f, -0.17083223f, -0.14585038f, -0.17224039f, 0.01374372f, 
    0.19401450f, 0.10368326f, 0.08846343f, 0.04869184f, -0.00255728f, -0.07171051f, 0.06141909f, -0.02425027f, 
    -0.32990980f, 0.15344019f, 0.05372104f, -0.14307818f, 0.02160189f, 0.05478534f, 0.10495509f, 0.16191375f, 
    0.05467444f, -0.08849751f, 0.11078219f, -0.06931630f, 0.03920919f, -0.02230306f, -0.20912345f, 0.05804639f, 
    -0.01468771f, -0.04571001f, -0.04890976f, -0.12057984f, 0.01976294f, -0.04921212f, -0.17786466f, 0.07347903f, 
    0.12365826f, -0.16128467f, 0.15081711f, -0.11974230f, -0.00919733f, 0.07207507f, 0.02981303f, 0.24212921f, 
    -0.04119520f, -0.05359670f, 0.12166329f, 0.02208048f, -0.14990306f, -0.22228856f, -0.36162561f, -0.17567819f, 
    0.01073728f, -0.06941777f, -0.24301016f, -0.18982473f, -0.00804410f, 0.06794540f, -0.05316070f, -0.04257350f, 
    -0.22832787f, -0.24056892f, -0.22208583f, 0.05059269f, 0.00439920f, -0.09551854f, -0.18961211f, -0.02786119f, 
    -0.09663846f, -0.04179890f, 0.12623934f, 0.24373785f, 0.17887352f, -0.02540920f, 0.21581584f, -0.10253174f, 
    -0.11189969f, -0.00871706f, 0.03324915f, -0.03676751f, -0.22978137f, -0.08499874f, -0.10192060f, 0.09717309f, 
    0.18682429f, 0.14286076f, 0.14921767f, 0.26197106f, 0.09421568f, -0.00627646f, -0.07912330f, 0.06546848f, 
    -0.10163634f, 0.06515166f, -0.20413350f, -0.08013508f, 0.25491706f, 0.15003827f, 0.14012469f, 0.23536174f, 
    -0.06265114f, 0.07271089f, 0.08867464f, 0.15040073f, -0.16207469f, 0.17608285f, -0.12414691f, 0.01564352f, 
    0.08692987f, 0.10228287f, 0.20070429f, 0.22503725f, 0.02716786f, -0.04641015f, -0.00278303f, 0.21220145f, 
    0.03165590f, -0.04934026f, -0.03287147f, -0.00391117f, -0.09710974f, -0.11149979f, -0.00580051f, -0.15367353f, 
    0.18895857f, -0.02362505f, 0.10312935f, 0.00392722f, -0.15461923f, 0.04584646f, 0.01041961f, -0.09969371f, 
    0.18099420f, 0.08744664f, -0.19359680f, 0.13890897f, 0.09316023f, -0.08925600f, -0.07744543f, -0.11741664f, 
    0.01527790f, 0.01823233f, 0.03483672f, -0.09450519f, 0.31035852f, 0.03749594f, 0.12642461f, 0.02942269f, 
    0.01075350f, 0.02778200f, -0.03740930f, -0.01356096f, 0.01727186f, 0.07240695f, 0.05477761f, 0.06966850f, 
    0.36778116f, 0.20584840f, 0.09080102f, 0.06060761f, 0.01174421f, 0.09113134f, -0.11494039f, -0.20829707f, 
    -0.03930326f, 0.00692498f, 0.01272259f, -0.05264759f, -0.06572326f, 0.19581069f, 0.22662005f, 0.11684623f, 
    0.06022852f, 0.06608009f, -0.13208175f, 0.00429000f, -0.04460061f, 0.03895677f, 0.01929559f, 0.01612034f, 
    0.11904507f, -0.09471869f, 0.09239794f, -0.05028899f, 0.01632218f, 0.10079135f, 0.05565852f, 0.10580383f, 
    0.01171266f, -0.07231529f, -0.00753791f, -0.04036169f, 0.27849469f, 0.14506546f, 0.13073108f, 0.30539238f, 
    -0.01880171f, 0.11551161f, 0.04832944f, -0.06042992f, -0.10590453f, 0.07290260f, -0.13261753f, -0.10288014f, 
    0.02090851f, -0.00589335f, -0.05334707f, -0.01927476f, 0.00502468f, -0.05935569f, 0.06552275f, -0.06916960f, 
    -0.07525489f, 0.04307138f, 0.01391727f, -0.01650029f, -0.07704682f, -0.00369703f, -0.05619691f, -0.06554240f, 
    0.01781857f, -0.07684524f, -0.06648533f, 0.05449326f, -0.05615388f, -0.02008780f, 0.01933720f, 0.00566808f, 
    0.05550604f, -0.02526462f, 0.04454298f, -0.02467125f, -0.02380904f, 0.05470851f, -0.02560816f, 0.05052305f, 
    -0.02964910f, 0.06182816f, 0.02663814f, 0.04510453f, -0.05645104f, 0.04241872f, -0.00423345f, -0.06974076f, 
    -0.04458329f, -0.04163248f, -0.04488071f, 0.02324528f, -0.04613053f, 0.04077809f, 0.00852014f, -0.03935305f, 
    -0.00006400f, -0.04400531f, 0.01558897f, -0.04189903f, -0.06496900f, 0.01542599f, 0.05621789f, -0.05186053f, 
    -0.00527440f, -0.02422471f, 0.01005976f, -0.04481542f, -0.03029379f, -0.06771675f, 0.04906825f, -0.00949303f, 
    0.00460384f, 0.00955080f, -0.03418721f, 0.02098845f, -0.07671675f, -0.00104968f, 0.05570729f, 0.02689494f, 
    0.06290383f, -0.02641062f, -0.06411782f, -0.06195587f, 0.06471094f, -0.07326169f, 0.02802518f, -0.07465787f, 
    -0.05705453f, 0.04571841f, -0.01200427f, 0.03634735f, -0.05509431f, 0.04839511f, -0.02748319f, -0.06702334f, 
    -0.02149474f, -0.05194331f, -0.06741635f, 0.03546800f, -0.04551788f, 0.02879081f, -0.06626549f, 0.01711739f, 
    -0.02723666f, -0.04804245f, 0.03872658f, -0.07539580f, 0.05374353f, -0.07036413f, -0.00359864f, -0.04718699f, 
    0.04665413f, -0.02016365f, -0.03875697f, 0.01443755f, 0.05879873f, -0.03107687f, -0.02059039f, -0.04772740f, 
    0.01153257f, 0.03333420f, -0.00414310f, 0.05207323f, 0.05056658f, 0.06340967f, 0.06004860f, 0.02418809f, 
    -0.04498886f, 0.05931585f, 0.06483996f, -0.05378573f, -0.02810444f, -0.03053858f, 0.01926987f, 0.02555109f, 
    -0.06804132f, -0.03968694f, 0.04447056f, 0.04462022f, -0.03122380f, -0.01514768f, -0.02829836f, -0.03967618f, 
    0.01148305f, 0.01182413f, -0.07010917f, -0.04255477f, -0.05891740f, 0.04367315f, -0.02700144f, -0.05907673f, 
    -0.04541498f, 0.03734471f, 0.01394016f, 0.05304637f, -0.06930242f, 0.03100085f, -0.06430140f, -0.00172905f, 
    -0.01275468f, 0.04994772f, 0.04189102f, -0.03379465f, -0.04700235f, -0.00979586f, -0.07190330f, -0.07391239f, 
    -0.01442605f, -0.01659404f, -0.04603756f, -0.07414754f, 0.01836973f, -0.05051690f, 0.06336762f, -0.03395043f, 
    0.00934092f, 0.02577463f, -0.04109233f, -0.06780589f, 0.03478053f, 0.01248782f, -0.01451394f, -0.03312599f, 
    0.05129528f, -0.06884862f, 0.00292219f, 0.06516646f, -0.07049524f, 0.05056404f, 0.03687407f, -0.05054084f, 
    0.00680494f, -0.07128964f, 0.00128818f, -0.04028288f, -0.04439781f, -0.00879740f, -0.05830940f, -0.00463666f, 
    -0.22852515f, 0.29795033f, 0.10936729f, -0.00401537f, -0.07902235f, -0.02480462f, 0.03473637f, -0.03166657f, 
    0.07448745f, -0.00543906f, -0.05802874f, -0.07958983f, 0.62115580f, 0.05768275f, -0.31634587f, -0.12181481f, 
    0.12404832f, -0.15407671f, 0.01817261f, 0.05802859f, 0.01434170f, 0.10183071f, 0.06114069f, 0.10174019f, 
    -0.21216939f, 0.14834543f, 0.06076295f, 0.01045387f, 0.05526076f, 0.07090952f, 0.10506486f, 0.13138597f, 
    0.07574659f, -0.07392754f, -0.07101479f, 0.01692246f, 0.17980853f, -0.18668216f, -0.16129257f, 0.00355083f, 
    0.16052966f, 0.08918273f, -0.02450107f, -0.02872933f, 0.01940662f, -0.07532816f, 0.09080038f, 0.13251382f, 
    0.20297536f, -0.17714147f, -0.15358119f, 0.01895359f, -0.06304655f, -0.06408540f, -0.06930606f, -0.06025673f, 
    0.03056367f, -0.00938418f, 0.10446767f, 0.08669339f, 0.30361086f, -0.09593080f, 0.05078078f, -0.10061837f, 
    -0.09186243f, 0.00734027f, -0.02512647f, -0.00342973f, 0.08670853f, -0.02439707f, 0.07664639f, 0.03097695f, 
    -0.00136112f, 0.16921455f, 0.06393127f, -0.01274396f, 0.02256630f, 0.04060302f, -0.11568760f, -0.14630628f, 
    -0.12450598f, 0.08345433f, 0.02276541f, 0.00183556f, 0.04409123f, 0.10276492f, 0.08103786f, 0.06138928f, 
    -0.00415884f, -0.08480968f, -0.00200076f, 0.09132028f, 0.05119890f, 0.09142708f, -0.10193563f, 0.07786529f, 
    0.27792835f, -0.05467584f, -0.08458520f, 0.00077312f, -0.04143745f, 0.03327500f, -0.05465256f, -0.03447281f, 
    -0.00171572f, -0.03414254f, 0.06390994f, -0.09290156f, 0.02612097f, 0.01142742f, 0.16945674f, 0.07129165f, 
    -0.05602461f, -0.00469982f, -0.05831515f, -0.20232069f, -0.15698496f, 0.14627688f, 0.05230151f, 0.12399556f, 
    -0.00791263f, 0.03217485f, -0.16278170f, 0.10648794f, 0.13146290f, -0.15922597f, -0.07034314f, 0.08099909f, 
    -0.01531249f, 0.19775362f, 0.09027742f, -0.04842819f, -0.23859195f, 0.18017076f, -0.02081635f, 0.09280271f, 
    -0.19015303f, -0.05699550f, 0.06915893f, -0.13454846f, -0.01280631f, -0.09110983f, -0.11406831f, -0.09036070f, 
    -0.06066259f, 0.18070091f, -0.15496753f, -0.05168665f, 0.08232486f, 0.06505346f, 0.04271650f, -0.04276621f, 
    0.03729608f, 0.05879534f, 0.04860401f, -0.05966406f, 0.04056794f, 0.09176974f, -0.20268898f, 0.13155188f, 
    -0.00709871f, 0.13066429f, -0.14127165f, -0.01594204f, 0.01895319f, 0.06245333f, 0.09434539f, 0.03858421f, 
    0.19965121f, 0.18716463f, 0.14506705f, -0.15780646f, 0.01276162f, -0.19691129f, 0.00605064f, -0.05623943f, 
    0.17656972f, -0.05333575f, -0.04313013f, -0.03991452f, 0.26141742f, 0.09011833f, 0.00202210f, 0.07133547f, 
    0.00939799f, -0.05456476f, 0.05206643f, 0.06745660f, 0.07123837f, -0.05467424f, -0.00911281f, -0.00560203f, 
    0.52978331f, -0.00026830f, -0.04673867f, 0.07286306f, 0.05090883f, 0.10887740f, -0.00834318f, 0.14121914f, 
    -0.05966739f, -0.04542227f, 0.04415632f, -0.11344137f, -0.33047774f, 0.11219729f, 0.19036153f, 0.11450464f, 
    -0.00129688f, 0.18007129f, 0.00599624f, 0.00007870f, 0.02218823f, -0.01770512f, -0.04447625f, -0.02816539f, 
    0.36484101f, 0.00752074f, 0.09630001f, -0.05943212f, -0.05502854f, 0.08877292f, 0.01772316f, -0.09105280f, 
    0.03017782f, 0.16953093f, 0.03891001f, 0.09193616f, -0.01373895f, -0.00952295f, -0.11901590f, -0.00325147f, 
    0.01692984f, -0.05408009f, 0.01924275f, -0.07125175f, -0.03321576f, 0.04210544f, 0.01057317f, 0.05854022f, 
    -0.16464289f, 0.14319487f, -0.00993538f, 0.20285365f, 0.04350194f, 0.03020545f, 0.03881862f, 0.12849160f, 
    -0.02490802f, 0.06616065f, -0.08893103f, -0.00617575f, -0.04282677f, 0.11697903f, -0.06344784f, 0.11373493f, 
    0.14948195f, 0.02396355f, -0.04921024f, 0.05012260f, -0.03767907f, -0.00208100f, 0.02364422f, -0.09115742f, 
    -0.22282746f, -0.07887275f, -0.07724053f, -0.12665002f, -0.13646156f, -0.08663547f, 0.06754419f, 0.16916524f, 
    0.08168749f, 0.05786243f, 0.00388511f, 0.13401641f, -0.06982098f, -0.03075282f, 0.06947806f, 0.05541582f, 
    -0.11917178f, -0.01540553f, 0.20532358f, 0.06599052f, -0.02727347f, -0.12757945f, -0.06705858f, 0.04310399f, 
    -0.03772333f, -0.02357913f, 0.18964201f, -0.11389188f, -0.02343614f, 0.03830824f, 0.08219806f, 0.08046693f, 
    -0.05438231f, -0.04644039f, -0.01956610f, 0.03306126f, -0.00523939f, -0.04855247f, -0.06037389f, 0.00709980f, 
    0.13912319f, 0.03783480f, 0.05219505f, 0.17715818f, 0.04488279f, 0.03817306f, -0.01086764f, -0.07123845f, 
    -0.13165134f, 0.04575770f, 0.27034706f, -0.29415280f, -0.04584520f, 0.19583695f, 0.02488729f, 0.00333276f, 
    0.03909356f, -0.02952569f, 0.00241455f, 0.13155928f, -0.10040284f, -0.15693545f, 0.04032069f, -0.04233139f, 
    0.03045445f, 0.02823564f, 0.01337796f, 0.16543436f, 0.08315912f, 0.07339896f, 0.02443348f, 0.02396993f, 
    -0.00804923f, 0.11849534f, 0.11523999f, -0.11405604f, 0.06322093f, 0.03376060f, -0.02441999f, 0.01410969f, 
    -0.00661387f, 0.01341129f, -0.06121250f, 0.16605644f, -0.19851521f, 0.06686139f, 0.06251705f, -0.13916507f, 
    -0.07272837f, -0.05771692f, -0.00410320f, 0.19537525f, 0.03596966f, 0.06554624f, 0.01861954f, 0.03935482f, 
    -0.08827990f, -0.00600095f, 0.05913394f, 0.09462177f, 0.07413203f, 0.11549275f, 0.05355320f, 0.05789995f, 
    -0.06538037f, -0.09531274f, 0.02242088f, 0.03436053f, -0.25239694f, -0.13081531f, -0.04618657f, -0.10342638f, 
    -0.00212402f, 0.10762690f, -0.09957989f, 0.07734407f, -0.02916679f, 0.05273996f, -0.02750595f, 0.08342096f, 
    0.04822762f, -0.04223990f, 0.05016579f, -0.01544482f, -0.05346111f, 0.01535496f, 0.01577258f, 0.00113314f, 
    -0.07902706f, -0.01254727f, -0.05226146f, -0.02654521f, -0.02500552f, -0.06621051f, 0.00200315f, 0.03544917f, 
    -0.05343220f, 0.04731266f, -0.03071190f, 0.05072377f, 0.04635967f, -0.06796439f, -0.05452564f, 0.04111772f, 
    0.02967733f, -0.04612594f, -0.06308189f, -0.06426995f, 0.04095002f, -0.02397600f, -0.04936591f, -0.07471164f, 
    -0.02994946f, 0.03133408f, -0.01145363f, -0.02756356f, -0.07764623f, -0.01517720f, 0.04851022f, 0.04095161f, 
    -0.07752927f, 0.05830415f, -0.05903696f, -0.04978912f, 0.01746028f, 0.00259335f, 0.01714704f, -0.05367955f, 
    -0.06908835f, 0.05873221f, -0.05014794f, 0.02713359f, -0.04483251f, -0.03418670f, -0.07856686f, 0.02855184f, 
    -0.04056588f, 0.02815146f, -0.07760406f, -0.06412543f, -0.03287249f, -0.03907634f, 0.05982371f, 0.02384962f, 
    0.01163815f, -0.02498161f, 0.02980140f, 0.03995986f, 0.06841086f, -0.04829104f, -0.01987414f, 0.04836759f, 
    -0.01368374f, 0.00240364f, -0.05413227f, -0.06946316f, -0.06769755f, -0.02297952f, 0.05812053f, -0.01565705f, 
    -0.02905374f, -0.07315299f, -0.01811591f, -0.06362730f, 0.00893671f, -0.01499431f, 0.05728520f, -0.04374768f, 
    -0.05351933f, 0.03673840f, 0.01102671f, 0.00697831f, -0.02802136f, -0.04955409f, 0.02755147f, 0.06083052f, 
    0.03669365f, -0.01408030f, -0.05749729f, -0.07297190f, -0.06125385f, -0.02059163f, -0.00398001f, 0.05374577f, 
    0.02879924f, 0.03025719f, 0.06286397f, -0.01827981f, -0.07403705f, 0.04047399f, -0.00992238f, 0.05955713f, 
    0.05160864f, -0.03455387f, 0.00790992f, 0.05072207f, -0.03298961f, 0.02363038f, -0.03396350f, -0.03169265f, 
    -0.02418015f, -0.06703278f, 0.02926735f, -0.03154384f, 0.04510381f, -0.03783481f, 0.01031520f, -0.07764681f, 
    -0.01869807f, 0.02308954f, -0.00938283f, 0.03559935f, -0.05313499f, 0.01638674f, -0.01759272f, -0.03686331f, 
    -0.00532265f, -0.02893376f, -0.04572825f, -0.05378137f, 0.03519516f, 0.06162556f, 0.03691453f, -0.04512233f, 
    0.02982083f, -0.06271917f, -0.07204901f, -0.04631843f, 0.00321010f, -0.06604653f, 0.02796387f, -0.04777566f, 
    0.04539889f, -0.03714591f, -0.03571802f, 0.05900371f, 0.04388834f, 0.03984779f, -0.02764168f, -0.07540262f, 
    -0.06679942f, -0.06366556f, -0.02167408f, 0.00652917f, 0.03880259f, 0.04038344f, -0.03345589f, -0.06543536f, 
    -0.04428488f, 0.02866625f, 0.01663148f, 0.05376836f, 0.04816265f, -0.04178521f, -0.07538433f, 0.00673219f, 
    0.00757571f, 0.00125328f, -0.04483545f, 0.05573296f, -0.08140276f, -0.01784928f, -0.03144344f, -0.04247079f, 
    -0.00636310f, -0.03866358f, 0.03341482f, -0.01044863f, -0.06898478f, -0.02658867f, 0.03750788f, 0.01137074f, 
    0.15657562f, -0.14868373f, -0.12468943f, 0.14197148f, 0.01031190f, -0.05512896f, -0.04321469f, 0.10380758f, 
    -0.08188174f, 0.12289527f, 0.03280668f, -0.00903710f, -0.44098094f, 0.01499857f, 0.31705081f, -0.08883404f, 
    -0.16301551f, 0.10306080f, 0.08861274f, 0.06193249f, -0.02390027f, 0.00711080f, 0.00450159f, 0.07433955f, 
    0.12285662f, -0.14670640f, -0.04343406f, 0.28466919f, 0.01400865f, 0.00186833f, -0.05718173f, -0.06372041f, 
    -0.12653619f, 0.05079859f, 0.02770106f, 0.03169024f, -0.09296842f, 0.25985804f, 0.08008937f, -0.09299435f, 
    -0.03779965f, -0.04833853f, 0.11199406f, -0.05828068f, -0.05336932f, 0.02007168f, 0.01430250f, 0.04470132f, 
    0.08563208f, 0.11030252f, 0.04139252f, -0.02979426f, -0.07330538f, 0.06687755f, 0.13052845f, -0.02583962f, 
    0.00605686f, 0.05829903f, -0.07416868f, -0.01923433f, 0.21049607f, -0.04072454f, 0.05964991f, -0.03408140f, 
    0.02789652f, -0.00962979f, 0.08798160f, 0.04863815f, 0.06595730f, -0.04068540f, -0.04144305f, -0.06448533f, 
    -0.13328835f, -0.16857456f, -0.04446181f, 0.26849717f, 0.19678110f, -0.05622993f, -0.08064464f, 0.10595546f, 
    0.10787212f, -0.03950607f, -0.14044753f, -0.02149923f, 0.10215131f, -0.03084206f, 0.09626333f, 0.14626524f, 
    -0.10629167f, -0.05380597f, 0.06136630f, 0.02483564f, -0.02774237f, 0.06886339f, 0.11570121f, -0.07653795f, 
    -0.27462947f, 0.09049332f, 0.11826005f, 0.25470772f, 0.09817541f, -0.04293537f, 0.07053608f, 0.10648811f, 
    -0.04936676f, 0.00938082f, 0.05294694f, -0.01821471f, 0.01514917f, -0.06060250f, 0.02895186f, -0.14995004f, 
    0.05669058f, 0.11193921f, -0.02114250f, 0.08498231f, 0.17487185f, -0.07128005f, 0.03220874f, -0.20396297f, 
    -0.18886167f, 0.03806113f, -0.05317461f, 0.04644092f, -0.10703184f, 0.04604978f, -0.02340601f, -0.10042072f, 
    -0.12485950f, -0.18664050f, -0.01723925f, -0.07091178f, 0.20737687f, -0.17760900f, -0.12038250f, -0.05294369f, 
    0.05876934f, 0.19094998f, 0.04749209f, 0.01812117f, 0.04639482f, 0.10121596f, 0.07424729f, 0.01767665f, 
    -0.01269275f, -0.19068161f, 0.02957913f, 0.24946770f, -0.00543442f, -0.02537734f, -0.04084190f, 0.05269460f, 
    -0.10719738f, -0.12838954f, 0.05165862f, -0.01016588f, 0.39683604f, -0.18346392f, 0.07329014f, -0.01529341f, 
    0.13617109f, -0.05012168f, 0.16028556f, -0.02661528f, -0.04797731f, 0.11189624f, -0.11163145f, -0.00409276f, 
    -0.14226831f, 0.08580312f, -0.12087885f, 0.02196329f, -0.06361691f, 0.06351078f, -0.06756338f, 0.05107241f, 
    -0.06507972f, 0.00375111f, 0.09238103f, 0.11160358f, 0.12270766f, -0.07393754f, 0.06243323f, 0.06220427f, 
    0.02016610f, 0.08500590f, -0.13318545f, -0.02111057f, -0.12653850f, 0.04421703f, 0.09057470f, 0.07716654f, 
    0.09396350f, 0.11380335f, 0.05272632f, -0.09595254f, 0.04948778f, 0.06596640f, -0.08249020f, 0.07489141f, 
    0.10711126f, -0.03836724f, -0.04017851f, 0.17734745f, -0.49135759f, 0.00313118f, 0.17084582f, 0.09283973f, 
    -0.00343358f, 0.17090319f, 0.02365841f, -0.04554537f, 0.09114522f, 0.00148600f, 0.01122765f, 0.01655244f, 
    -0.00654562f, 0.00113999f, 0.01802071f, 0.04886537f, -0.02452749f, 0.06399871f, 0.00062605f, -0.07341310f, 
    0.03210046f, 0.08844077f, 0.03944620f, 0.02000894f, -0.19496535f, -0.12110550f, 0.14780042f, 0.21337779f, 
    -0.07755685f, -0.00331483f, 0.01008208f, -0.00157903f, -0.01252940f, -0.05187302f, 0.02639616f, -0.05061894f, 
    -0.27762213f, 0.02840793f, -0.06574892f, 0.14430857f, 0.10438762f, 0.06823744f, 0.05618383f, -0.02626862f, 
    0.02448918f, 0.02905630f, -0.04533365f, -0.17098254f, 0.31006604f, -0.14821965f, 0.10815756f, 0.18299529f, 
    -0.00279874f, -0.03610627f, -0.01436655f, -0.04809940f, 0.02748505f, 0.01628558f, 0.04669882f, -0.04622321f, 
    0.02231719f, 0.05020628f, 0.01932042f, -0.17524211f, -0.08437062f, -0.12215291f, 0.09738021f, 0.06302366f, 
    0.13114089f, -0.06772469f, 0.15393236f, 0.04115457f, 0.21894151f, -0.33010668f, 0.06428357f, -0.10241611f, 
    -0.17309797f, 0.07605617f, 0.01929083f, -0.16920744f, 0.01944053f, -0.02926969f, -0.00781720f, -0.01878835f, 
    -0.12135224f, 0.07155296f, 0.18477631f, -0.02023610f, -0.13374616f, -0.00229684f, 0.01867887f, 0.11608595f, 
    -0.03181824f, 0.03052601f, -0.06968433f, 0.02587831f, -0.00887633f, -0.01489652f, -0.03352815f, 0.07314053f, 
    -0.04746458f, -0.02739322f, 0.01984409f, 0.10426448f, 0.07464099f, 0.00560576f, 0.06841967f, -0.13094299f, 
    -0.07512347f, -0.03921395f, 0.15874983f, -0.12209675f, 0.08451381f, 0.16337399f, 0.11779632f, -0.02733942f, 
    -0.01534095f, -0.02739669f, -0.02935853f, 0.00901231f, 0.05882949f, 0.04022820f, 0.16649938f, 0.11096738f, 
    0.01501531f, 0.04386706f, -0.05066670f, 0.22438739f, 0.02392211f, -0.08421902f, 0.04767331f, 0.09994259f, 
    0.15348904f, -0.02911637f, 0.07514877f, 0.04491740f, 0.08303512f, 0.08026732f, -0.00285837f, 0.06754013f, 
    -0.06339640f, 0.01232337f, -0.01361302f, 0.04637637f, -0.14262716f, 0.17718491f, -0.00118791f, -0.22335181f, 
    0.19391479f, 0.13380526f, 0.17282768f, 0.07058361f, -0.11865652f, -0.02409162f, -0.04263360f, -0.05373041f, 
    -0.03236642f, -0.06696507f, 0.04188086f, -0.04084230f, -0.14206402f, 0.14902227f, -0.05704879f, 0.01420858f, 
    -0.08027617f, -0.01451454f, -0.02706635f, 0.02700266f, 0.36372590f, -0.19640101f, 0.19361293f, -0.07942386f, 
    -0.07397147f, -0.00264119f, -0.18499856f, 0.03507977f, -0.02762992f, 0.05711946f, 0.00367893f, 0.02549734f, 
    0.04643246f, 0.00586523f, 0.05540875f, 0.01267655f, -0.00695870f, -0.04559172f, -0.00091881f, 0.05037763f, 
    -0.08640659f, 0.02477931f, -0.04932823f, 0.06109418f, 0.04589114f, 0.02191938f, -0.03584159f, 0.02621966f, 
    0.06507703f, 0.03878994f, -0.06094217f, 0.00970103f, 0.02997386f, 0.02369612f, -0.03352061f, -0.00908930f, 
    0.02175183f, 0.02721491f, -0.03976526f, 0.04677248f, -0.04052836f, 0.00141727f, 0.05145698f, -0.00055127f, 
    -0.00128898f, 0.00270231f, -0.08828320f, -0.01240598f, 0.04536426f, -0.07638598f, 0.05093753f, -0.03619424f, 
    0.00208678f, -0.06035207f, -0.00989864f, -0.07318968f, -0.04379667f, 0.02328001f, -0.06957663f, -0.01694845f, 
    0.01193417f, 0.06123196f, -0.02662525f, -0.01364131f, 0.03400335f, -0.07322899f, -0.05083365f, -0.01534308f, 
    -0.00240262f, -0.01267922f, 0.01695270f, -0.03688691f, 0.03545482f, -0.02461735f, 0.02866624f, 0.02095978f, 
    0.00653835f, -0.01401233f, -0.06298257f, -0.05380452f, 0.02805266f, -0.02396800f, -0.06698245f, 0.03496858f, 
    -0.07011926f, -0.03968839f, 0.00558739f, -0.04326483f, 0.02371861f, -0.04703499f, -0.02306972f, -0.02993529f, 
    -0.02118741f, -0.06176819f, 0.01406547f, 0.03692706f, -0.05498638f, -0.01352979f, 0.06770917f, -0.00745825f, 
    -0.03843514f, -0.04289814f, 0.04721601f, -0.02132166f, 0.06385602f, -0.02759872f, 0.03260326f, -0.03689232f, 
    -0.01006539f, 0.04582647f, -0.04067323f, -0.01049417f, -0.03527842f, 0.01292988f, 0.02686020f, -0.02253974f, 
    -0.04290603f, -0.07526717f, -0.03737585f, -0.05788959f, 0.02163356f, 0.03860346f, -0.04478138f, 0.07020368f, 
    -0.01905966f, -0.01021481f, -0.00238575f, -0.06115196f, 0.02760770f, -0.05677830f, 0.00987857f, -0.03056060f, 
    0.03868520f, -0.02968855f, -0.04968782f, -0.07530906f, 0.06817695f, -0.07250513f, 0.04439759f, 0.02561960f, 
    -0.03529411f, 0.03808141f, -0.06436660f, 0.04349289f, -0.06241082f, -0.01002545f, 0.02590344f, -0.04846044f, 
    0.06326377f, -0.08174648f, 0.02017875f, -0.02163824f, -0.02315150f, 0.06267841f, -0.02498048f, -0.07853059f, 
    -0.03143522f, -0.03656567f, 0.00187678f, -0.01733755f, 0.04252075f, -0.02985907f, -0.02978530f, 0.01363818f, 
    0.03963565f, -0.05540783f, 0.05476187f, -0.03993842f, 0.02085501f, 0.06086351f, 0.04344675f, 0.02611096f, 
    0.04546853f, -0.05460849f, -0.05438561f, -0.05951510f, 0.00381115f, -0.06776039f, -0.05257037f, -0.04284458f, 
    -0.00424506f, 0.05345570f, 0.05918096f, -0.03373852f, -0.06728268f, 0.02497898f, 0.00158568f, 0.04655337f, 
    0.01644693f, -0.02924250f, -0.03087470f, 0.02321032f, 0.03566653f, 0.06593616f, 0.00677460f, -0.05994127f, 
    0.04068339f, -0.05113566f, -0.03465931f, 0.05801061f, -0.05059485f, -0.03412056f, 0.03514190f, -0.06231333f, 
    0.09280732f, 0.27211863f, 0.11511645f, 0.18979117f, 0.05886674f, 0.00509319f, 0.05052257f, 0.05705228f, 
    -0.08063835f, 0.02086065f, 0.02426418f, 0.00418779f, 0.28736544f, -0.09303990f, -0.08230066f, 0.05674313f, 
    -0.05290169f, 0.01901574f, -0.06084417f, -0.06756548f, 0.06624661f, 0.01649981f, 0.00052391f, -0.12404179f, 
    -0.12968102f, 0.02356531f, 0.02741703f, -0.08920389f, -0.07269344f, 0.00930392f, -0.06781083f, -0.00015292f, 
    0.04315561f, -0.00988882f, -0.05000705f, -0.10850976f, 0.32100114f, -0.14599045f, -0.07950886f, 0.12602632f, 
    0.06808459f, -0.06940359f, 0.00837903f, -0.05853110f, 0.03082718f, 0.14622630f, -0.01011846f, -0.09376956f, 
    -0.00154815f, -0.23298334f, -0.11201518f, -0.10122956f, -0.17819130f, 0.04677795f, 0.02450307f, 0.07086382f, 
    0.09748290f, 0.05705209f, -0.02076002f, -0.03032675f, -0.23986879f, 0.18082188f, 0.08405217f, -0.08656589f, 
    0.15166569f, 0.04559457f, 0.00080611f, 0.03945294f, 0.03145209f, -0.02499952f, 0.04253560f, 0.00640086f, 
    0.06514949f, 0.21879202f, 0.05650434f, 0.12738854f, -0.02625860f, -0.09256548f, 0.00103193f, -0.07369961f, 
    0.00494053f, -0.08225416f, 0.02698065f, -0.01623319f, -0.13230565f, 0.28302693f, 0.01474625f, 0.07878277f, 
    0.10442625f, 0.04566436f, 0.05673796f, 0.02522820f, 0.00348729f, 0.01706969f, 0.09825902f, -0.00140975f, 
    0.13870297f, 0.01183933f, 0.00164202f, 0.06907938f, 0.09454440f, -0.10517304f, -0.02266629f, 0.02902675f, 
    0.01258288f, 0.04429359f, -0.05602575f, -0.09961285f, -0.05122083f, -0.06851261f, -0.07924926f, 0.04106215f, 
    0.00758727f, 0.04999314f, 0.02558909f, 0.01600625f, -0.00234163f, -0.07363075f, -0.02414414f, -0.07638230f, 
    0.01234573f, -0.17012626f, -0.09358617f, 0.11832165f, -0.02873677f, 0.02547265f, -0.09380544f, 0.03335783f, 
    -0.01552568f, 0.05176663f, -0.02498668f, 0.02977675f, 0.14051543f, 0.05621516f, -0.03524410f, 0.05474482f, 
    0.07890438f, 0.05818251f, -0.04645308f, -0.04236250f, -0.04253228f, -0.07118010f, 0.01822789f, -0.02028074f, 
    -0.13325590f, 0.10640886f, 0.08408400f, -0.04804816f, -0.01073253f, -0.04989839f, -0.05819850f, -0.09315606f, 
    0.09863240f, 0.03955390f, -0.11577122f, 0.08081355f, 0.18649828f, 0.29048687f, 0.23027137f, 0.00748056f, 
    -0.01675368f, 0.04273989f, 0.00535999f, -0.01124572f, -0.07228655f, -0.09143142f, 0.07416805f, 0.02141247f, 
    -0.18588801f, 0.02515804f, -0.03137107f, 0.12779208f, 0.02519814f, -0.01657524f, 0.07943032f, -0.01078700f, 
    0.01363928f, -0.02166783f, 0.05784925f, 0.02507751f, -0.40068978f, 0.31814590f, 0.17473495f, 0.07483620f, 
    0.05250964f, 0.01846344f, 0.08781320f, 0.02389289f, 0.01905984f, 0.03417589f, 0.10757603f, 0.07352750f, 
    -0.05119554f, -0.03769399f, 0.04578117f, -0.04274340f, -0.05258666f, -0.07536926f, 0.06250168f, -0.04258660f, 
    -0.00036795f, -0.02721286f, -0.04601172f, -0.04263470f, 0.04775871f, -0.07055335f, 0.01659249f, -0.06241167f, 
    0.06129661f, -0.05357665f, 0.00130845f, 0.01296194f, -0.03969465f, 0.02154796f, -0.05403549f, 0.00577342f, 
    0.01115219f, 0.05092811f, -0.06196151f, -0.06749304f, 0.03774096f, -0.07225388f, -0.04238788f, -0.06135170f, 
    -0.06689612f, 0.02733218f, -0.03090693f, -0.03581996f, 0.01620352f, 0.00886434f, -0.04644514f, 0.00093012f, 
    0.03747889f, -0.02272910f, 0.02901809f, 0.03432087f, 0.03045909f, -0.05383725f, -0.07491321f, -0.03874372f, 
    0.03508034f, 0.04470895f, 0.06656320f, -0.00597804f, 0.05205730f, -0.00724568f, -0.07633369f, -0.07413751f, 
    -0.04914404f, 0.05687577f, -0.05774338f, -0.06961967f, 0.03782581f, -0.03839465f, 0.03247201f, 0.02050016f, 
    -0.02352870f, -0.06928020f, 0.03898038f, -0.01871390f, 0.04014467f, -0.03936539f, 0.05674531f, -0.04651998f, 
    -0.00653796f, -0.02392041f, -0.05031405f, -0.05787747f, 0.02751223f, 0.03757167f, -0.06280975f, -0.03320568f, 
    0.02677889f, -0.01913844f, -0.07941812f, 0.01884182f, -0.03978061f, 0.05511260f, 0.06624331f, 0.00406313f, 
    -0.05876745f, -0.03675547f, 0.02285367f, 0.02578364f, -0.04756299f, 0.02318920f, 0.00253142f, -0.01013666f, 
    -0.01005959f, -0.01549520f, 0.04093444f, -0.03175064f, 0.04944641f, -0.02371988f, -0.00704854f, 0.01433930f, 
    0.06375344f, -0.01367365f, 0.00458590f, 0.05668543f, -0.04785353f, 0.02317756f, -0.06675372f, -0.04351802f, 
    0.05152887f, -0.06994475f, -0.00302111f, 0.01376893f, 0.06143254f, 0.01026569f, 0.01692574f, -0.02354968f, 
    -0.03215298f, -0.02520669f, -0.02767687f, -0.01226261f, 0.00731513f, 0.00722300f, -0.04207335f, 0.04264927f, 
    0.03406327f, 0.01240858f, -0.06128998f, 0.00196325f, 0.05633615f, 0.02769819f, -0.06891502f, -0.05404705f, 
    -0.06917408f, 0.01569880f, -0.05815117f, -0.02929447f, 0.00856527f, 0.02847192f, 0.06092971f, 0.02421167f, 
    0.00430566f, -0.01407568f, -0.01665779f, 0.02454390f, -0.03491423f, 0.05599527f, 0.00583787f, -0.02683067f, 
    0.00287295f, -0.02595545f, -0.00496941f, -0.07259081f, -0.01099724f, 0.05488475f, 0.06247529f, -0.05329713f, 
    0.05604991f, 0.03810173f, 0.05994565f, -0.05241765f, -0.03758242f, -0.06588870f, 0.01677190f, -0.07770209f, 
    -0.06265841f, -0.05996690f, -0.04097793f, -0.05661815f, 0.01353628f, 0.06050210f, -0.02083881f, 0.02339219f, 
    0.05568620f, -0.04410563f, -0.02090197f, -0.02807267f, -0.06747571f, -0.03354010f, -0.02015234f, -0.03496269f, 
    0.03459410f, -0.00700982f, -0.02563308f, 0.03615703f, -0.06599741f, -0.02296782f, -0.04380405f, 0.06451385f, 
    -0.02784185f, -0.01348056f, -0.03270823f, -0.07182747f, -0.01766353f, -0.03837288f, 0.02335665f, -0.00160636f, 
    0.01580780f, 0.04100334f, -0.02699479f, 0.06420784f, 0.04363237f, -0.01791586f, 0.00311569f, -0.07128341f, 
    -0.00920542f, -0.06328100f, -0.05155909f, 0.00575899f, -0.06819145f, -0.02419165f, 0.06018360f, 0.03630210f, 
    0.04682771f, 0.03496286f, 0.05895615f, 0.02718651f, 0.04600128f, 0.04676337f, 0.03268916f, -0.04958805f, 
    -0.06263318f, -0.01741213f, 0.02676682f, -0.06622007f, -0.00210705f, -0.05883415f, -0.03354153f, 0.01776224f, 
    -0.06028006f, 0.06089587f, 0.00545016f, -0.04732570f, 0.05504105f, 0.04265060f, -0.01072410f, 0.06148315f, 
    -0.03458448f, 0.03241165f, -0.04623011f, -0.07484467f, -0.05054828f, 0.05466960f, 0.04802428f, 0.05430235f, 
    -0.00940858f, -0.00863325f, -0.06515867f, -0.02354212f, 0.02020819f, 0.03814754f, 0.05900726f, -0.00582270f, 
    -0.02543169f, 0.01480420f, 0.00030677f, 0.06209027f, -0.02799132f, -0.07209737f, 0.05359918f, 0.05329477f, 
    0.05333794f, -0.05875920f, -0.00561293f, 0.02848670f, -0.02849427f, -0.07085414f, -0.05998368f, 0.01576519f, 
    -0.03044336f, 0.02063156f, -0.07462980f, -0.05589463f, -0.06348459f, -0.07407559f, 0.03488738f, -0.06943147f, 
    -0.02704541f, -0.05527576f, -0.03502754f, 0.00584856f, 0.02644838f, -0.05296159f, -0.05054401f, -0.06664789f, 
    0.00821773f, 0.00256185f, -0.06276751f, 0.05585456f, -0.06461808f, -0.04785512f, -0.01073278f, -0.00753939f, 
    -0.02142018f, 0.04830595f, 0.01332388f, -0.05637845f, 0.00555696f, 0.06250476f, 0.01851344f, -0.02226777f, 
    0.01637860f, 0.03466143f, -0.05486331f, -0.06729294f, 0.03926120f, 0.02780646f, -0.06036381f, 0.00122379f, 
    -0.01945579f, -0.03323498f, 0.02222438f, 0.06465105f, -0.07002234f, 0.00857531f, 0.03195558f, -0.00819846f, 
    -0.03227687f, -0.00205694f, 0.00433007f, 0.01467913f, 0.03185048f, -0.04652467f, -0.02386223f, -0.02698310f, 
    -0.04265870f, 0.05469662f, -0.06318053f, 0.02529668f, -0.04677537f, -0.01814253f, -0.02393243f, -0.04699706f, 
    0.04866914f, -0.02411642f, 0.03102390f, 0.04557773f, -0.01237832f, -0.03471468f, -0.04153166f, 0.01274132f, 
    -0.04238987f, -0.00348116f, 0.05286862f, -0.07088493f, -0.05484499f, -0.05849061f, 0.01305120f, 0.03077413f, 
    0.03118562f, 0.00560943f, -0.04882875f, 0.01356958f, 0.00336993f, -0.04118385f, 0.04716123f, 0.02261999f, 
    -0.06212691f, -0.02765872f, -0.06794070f, -0.07988869f, -0.03161571f, 0.01954530f, -0.02278931f, -0.01896092f, 
    -0.02236508f, -0.06264246f, -0.00018816f, -0.06322024f, -0.07900875f, 0.00175923f, -0.06616944f, 0.00639682f, 
    0.02112877f, -0.07645603f, 0.03739940f, -0.01440696f, 0.01842210f, 0.01563611f, -0.00996788f, -0.06935333f, 
    0.11561526f, 0.07105042f, 0.23005524f, -0.02913500f, 0.07502825f, -0.02791225f, -0.02774155f, -0.05528621f, 
    0.04685994f, -0.02046173f, -0.00615488f, 0.00974466f, 0.37917224f, 0.01383042f, -0.25374004f, -0.01354682f, 
    -0.03896958f, 0.03090660f, -0.00364670f, 0.11767958f, 0.06872686f, -0.00081971f, 0.14458382f, 0.01825984f, 
    0.15350236f, 0.07380344f, -0.10708298f, -0.00198580f, -0.20822224f, -0.06969593f, -0.00224512f, -0.06376855f, 
    0.00403364f, 0.04800358f, -0.05763088f, -0.06045047f, 0.49063212f, -0.06389599f, 0.25653395f, 0.49267900f, 
    -0.09160279f, 0.00519889f, 0.14136648f, 0.12199202f, 0.04155170f, -0.03817698f, -0.03661218f, -0.15231015f, 
    0.14295548f, -0.11749562f, 0.00241220f, 0.06570159f, 0.09077914f, -0.07458265f, 0.21159565f, 0.08604351f, 
    0.05975362f, 0.01371367f, -0.02324036f, -0.04515778f, -0.36804837f, 0.15745029f, 0.02409966f, -0.02107135f, 
    0.10319641f, 0.03563590f, 0.01728824f, -0.11516394f, 0.03477570f, 0.15173906f, 0.06244776f, -0.02017839f, 
    -0.13959631f, 0.08676475f, 0.01358946f, -0.01355013f, -0.01200227f, 0.04619550f, 0.05566229f, 0.11245237f, 
    0.23124684f, 0.02083473f, 0.10836480f, 0.06931245f, 0.00198627f, -0.03305988f, -0.04512258f, -0.02601977f, 
    0.05474459f, 0.00939485f, -0.07043203f, 0.04692756f, 0.14139293f, -0.07021362f, 0.08136179f, 0.04221584f, 
    0.06048056f, 0.05387760f, 0.11808805f, -0.18688451f, 0.10636673f, 0.05571147f, -0.03730487f, 0.01588800f, 
    -0.09028021f, 0.05022050f, -0.05476135f, 0.03022716f, -0.28048843f, -0.17929581f, 0.00637451f, 0.13346308f, 
    0.02957903f, 0.09832044f, -0.02889620f, -0.06850203f, 0.04101885f, -0.03465336f, -0.13608177f, 0.00705948f, 
    -0.02918176f, -0.04200620f, 0.14995238f, -0.23409705f, -0.09929267f, 0.02585389f, -0.01761115f, -0.03804337f, 
    -0.07513260f, -0.05795688f, 0.06105514f, -0.08349099f, -0.17301139f, -0.04381352f, -0.00899320f, 0.01923089f, 
    0.09211380f, 0.03315665f, -0.08203760f, 0.06311311f, -0.03943006f, -0.09114319f, 0.00748553f, -0.01586917f, 
    -0.30863762f, -0.08081003f, 0.07856870f, -0.04201804f, -0.12017296f, -0.11575266f, 0.14311945f, 0.21286660f, 
    0.07687202f, 0.14239918f, 0.00194638f, 0.03239755f, 0.16343181f, -0.00569881f, 0.21555194f, -0.15424316f, 
    0.07127126f, -0.07381894f, 0.05442365f, -0.02273731f, -0.16012268f, 0.02353236f, -0.08450184f, 0.11114813f, 
    0.07369954f, 0.22627319f, 0.01831213f, 0.07970641f, -0.05616421f, 0.02173698f, -0.27865085f, -0.08513647f, 
    0.03736965f, 0.05810308f, 0.08457593f, 0.03066694f, -0.20122878f, 0.00167536f, 0.11787325f, 0.06539620f, 
    0.12485593f, 0.04795299f, -0.00899709f, -0.02329000f, 0.10904559f, 0.04472792f, -0.03025276f, 0.11974475f, 
    0.36045364f, -0.07451574f, -0.01979193f, -0.10945342f, 0.06721843f, -0.03875308f, -0.10862873f, 0.12389458f, 
    0.04850397f, -0.04376347f, 0.16431661f, -0.08088242f, -0.31581467f, 0.05372671f, 0.01217596f, -0.05483916f, 
    -0.09680926f, 0.14781833f, 0.11515194f, 0.13691968f, 0.01212694f, 0.02601208f, -0.08726786f, 0.00360646f, 
    0.34028021f, 0.11235221f, 0.16987514f, 0.03030695f, -0.03778955f, -0.01814659f, 0.06439661f, -0.07306390f, 
    0.04120886f, 0.00687917f, 0.00712853f, 0.01992517f, -0.23529284f, 0.22346085f, -0.18793599f, -0.15871465f, 
    0.02270639f, 0.00095368f, 0.04954229f, -0.02277520f, -0.10608844f, 0.08387967f, -0.00211608f, -0.02979692f, 
    -0.06198925f, 0.30665389f, -0.26695344f, 0.19176726f, 0.01030540f, 0.12359888f, 0.03537076f, 0.06366088f, 
    0.04023279f, 0.02169757f, 0.09842126f, -0.08603372f, 0.34896368f, -0.09274684f, -0.09345798f, 0.25343287f, 
    -0.12128503f, 0.05039045f, -0.08858521f, -0.00051898f, 0.05577042f, 0.01344468f, -0.14148493f, -0.03023425f, 
    -0.06469121f, -0.16522785f, -0.02933788f, 0.04120563f, -0.03153178f, -0.01660856f, 0.10120063f, 0.06589574f, 
    0.13357402f, 0.00430345f, -0.01469340f, 0.02785154f, 0.06799192f, -0.03324129f, 0.14973728f, 0.00809035f, 
    -0.14228153f, -0.01458343f, 0.08228090f, -0.04185880f, -0.07990085f, 0.07315118f, -0.03547348f, 0.09628163f, 
    -0.12844898f, 0.09644251f, 0.27799091f, 0.00751336f, 0.01616647f, -0.04321501f, 0.02941387f, 0.17091468f, 
    0.03237187f, 0.01428859f, 0.06935285f, 0.02599262f, 0.08867932f, 0.02928290f, -0.04740571f, 0.00157188f, 
    0.13687196f, 0.08691477f, -0.07665958f, 0.08817722f, -0.03426268f, -0.02271785f, -0.06706904f, -0.24644782f, 
    -0.12272286f, 0.04179229f, 0.25177452f, -0.20045194f, 0.00380023f, 0.17633675f, 0.04424201f, -0.05179719f, 
    0.00560334f, -0.09080441f, -0.02263403f, -0.01379283f, -0.08036593f, -0.26960006f, -0.07393111f, 0.19107784f, 
    -0.06641328f, -0.04770306f, -0.00611133f, -0.01564690f, 0.00713414f, 0.11686458f, 0.08440835f, 0.02930471f, 
    -0.04604893f, -0.05058489f, 0.13340354f, -0.12492679f, 0.10244346f, 0.01993335f, 0.05982022f, -0.06313038f, 
    0.03106098f, -0.02875851f, 0.08143929f, -0.07077225f, -0.00346779f, -0.10900451f, 0.08678290f, -0.04725319f, 
    0.05932057f, -0.06582467f, 0.02744030f, 0.02627975f, 0.01927610f, -0.06342908f, -0.06135570f, 0.07671356f, 
    0.03050766f, 0.11635517f, 0.12270121f, -0.01135130f, -0.07799393f, 0.16978267f, -0.01552289f, 0.00337881f, 
    -0.04558780f, 0.04620978f, -0.08276088f, 0.13339363f, 0.39504129f, -0.28645739f, 0.01346892f, 0.05417627f, 
    -0.09202705f, 0.01901438f, -0.08365414f, -0.00933484f, -0.07429609f, -0.00105384f, -0.01152127f, 0.06096253f, 
    -0.29311189f, -0.14249371f, 0.12825276f, 0.03929415f, 0.15539610f, 0.08929390f, -0.00785653f, -0.09668130f, 
    0.12193345f, -0.00197449f, -0.07666578f, -0.02698178f, 0.09641999f, 0.05072853f, -0.20575155f, 0.04960594f, 
    0.15345304f, -0.00702622f, 0.15153356f, 0.02700416f, -0.11290073f, -0.04081516f, -0.05513551f, 0.00936400f, 
    0.02514824f, -0.02910685f, -0.03017257f, 0.05982283f, -0.06896023f, -0.06256164f, 0.04705888f, 0.12258741f, 
    0.06325522f, 0.18167920f, -0.16098797f, 0.12990041f, 0.11413780f, -0.28134072f, -0.04134659f, 0.20657915f, 
    0.06591008f, 0.08831307f, -0.06205868f, 0.02372070f, 0.04520915f, 0.09293230f, 0.14996077f, 0.10402644f, 
    0.15941076f, -0.22903879f, 0.15098932f, -0.01387438f, 0.05404024f, 0.09744737f, -0.07928301f, 0.08127964f, 
    0.00929253f, -0.07580760f, 0.07841136f, -0.01748712f, -0.20794651f, 0.08134671f, 0.14722639f, 0.13095324f, 
    -0.06547385f, -0.04687065f, -0.10010020f, -0.01224445f, -0.05005926f, 0.02674175f, 0.00880702f, -0.08989293f, 
    0.15626191f, 0.28636855f, 0.01260009f, 0.00791327f, 0.15330619f, 0.09865718f, -0.05114180f, -0.01475439f, 
    -0.17412862f, -0.01033951f, -0.02156626f, -0.06335571f, 0.35355720f, -0.17560992f, 0.09356859f, 0.09645016f, 
    0.04945288f, 0.06661342f, 0.04979967f, -0.00471062f, -0.04034089f, 0.10089242f, -0.17509183f, -0.04039532f, 
    0.06617145f, 0.16824456f, -0.00776527f, -0.15651079f, -0.08114793f, -0.03831580f, 0.12205984f, -0.05224442f, 
    0.05020637f, -0.04168478f, -0.03933790f, -0.00466233f, -0.16143177f, 0.07356705f, 0.08194982f, 0.07166104f, 
    0.16616504f, 0.02387380f, -0.00769949f, 0.09091658f, 0.03806614f, 0.06019942f, 0.04372421f, 0.02196258f, 
    -0.40052381f, 0.06995814f, 0.13043144f, -0.16283022f, -0.03191453f, -0.09136210f, 0.01406638f, -0.10078038f, 
    -0.05732259f, -0.06942074f, -0.15877867f, -0.02689308f, -0.28531608f, 0.02981905f, 0.18915096f, 0.15126941f, 
    0.18192571f, -0.15003170f, -0.35272580f, -0.06259664f, 0.14892054f, -0.03736122f, 0.02927556f, -0.02621560f, 
    -0.02828087f, 0.07917253f, -0.03815515f, -0.05708889f, 0.07549284f, -0.15669003f, -0.06767821f, 0.11311063f, 
    -0.16272168f, -0.08021715f, 0.05692478f, 0.06757321f, 0.05589494f, -0.32668313f, -0.08561496f, -0.03884326f, 
    -0.06796259f, -0.04592506f, 0.01209635f, 0.04809405f, 0.06784679f, 0.17556217f, -0.06968483f, 0.21123601f, 
    0.33754200f, -0.00546398f, -0.05474422f, 0.07523838f, -0.01767758f, 0.00179918f, -0.14589527f, 0.04181900f, 
    0.03138567f, -0.05442466f, -0.01344464f, -0.17975010f, -0.03021714f, -0.02645212f, 0.00056493f, 0.03230343f, 
    0.02402567f, -0.00500210f, -0.08342537f, 0.11326029f, -0.01465516f, 0.08948860f, -0.09715960f, -0.17363389f, 
    -0.13608429f, -0.12355261f, 0.03318176f, 0.07346810f, 0.07316953f, -0.13572811f, -0.06297279f, -0.12858388f, 
    -0.10053074f, -0.02520955f, -0.10951600f, 0.04214047f, -0.04181569f, 0.03835039f, -0.06335547f, 0.05479711f, 
    0.05122285f, 0.02245889f, 0.08105617f, 0.06887491f, -0.09151690f, 0.01008247f, 0.10978212f, 0.07011580f, 
    0.29327208f, 0.06367375f, -0.17242163f, 0.35113430f, 0.03707042f, -0.03736503f, 0.05916150f, 0.02411985f, 
    0.11036239f, -0.01884148f, -0.03277674f, 0.19091815f, -0.19394194f, 0.04322176f, 0.06104878f, -0.00993689f, 
    0.05531192f, 0.11244521f, 0.01603790f, -0.01107894f, -0.08781472f, -0.05711290f, 0.01491914f, 0.09727725f, 
    0.18765169f, -0.03193156f, 0.42322999f, -0.01270427f, 0.11138534f, -0.04835866f, 0.07410973f, 0.05923082f, 
    0.03269116f, 0.07338723f, -0.03098169f, -0.02949309f, -0.26746583f, -0.05432238f, 0.12168486f, 0.03169842f, 
    0.21001585f, -0.01618226f, 0.16246717f, -0.04020675f, -0.05084831f, 0.05139615f, -0.01237047f, 0.06306103f, 
    -0.06435235f, -0.10041253f, -0.03658166f, 0.09332033f, -0.05098873f, 0.08608097f, -0.14205125f, 0.05448351f, 
    0.14115871f, 0.00602403f, 0.10416654f, 0.03724053f, -0.13497399f, 0.11907314f, -0.00927759f, -0.08500553f, 
    0.05037212f, 0.10587756f, -0.14922380f, 0.00168876f, 0.08607715f, -0.00883171f, 0.03538637f, -0.00684416f, 
    -0.07114362f, 0.15866499f, -0.13138793f, -0.04280794f, 0.04873864f, 0.20171264f, -0.01760280f, -0.07782692f, 
    0.01211955f, -0.08051181f, 0.06249766f, 0.07536771f, -0.07661212f, -0.01958506f, -0.02153676f, -0.05140775f, 
    0.03154252f, -0.09564716f, 0.17820999f, -0.05341631f, 0.14088847f, 0.10252439f, 0.04551074f, 0.14852636f, 
    -0.04339927f, 0.10805977f, -0.02961346f, -0.05560735f, -0.10993724f, 0.00234580f, -0.17341749f, 0.08707096f, 
    -0.04845731f, -0.02685878f, 0.00380691f, 0.10609806f, 0.10300564f, -0.18054415f, 0.17284757f, -0.03726548f, 
    0.21764854f, -0.00224487f, -0.00402730f, -0.05481189f, 0.00478269f, 0.11126931f, 0.04945564f, 0.10169975f, 
    0.00832362f, -0.03915652f, -0.04581566f, 0.29353046f, -0.12670895f, -0.05429249f, -0.01771622f, 0.06264961f, 
    0.03029013f, -0.06286026f, -0.00074611f, 0.12786286f, 0.02076084f, -0.31142837f, 0.27812010f, 0.18055892f, 
    0.15723324f, 0.01677674f, 0.00547773f, 0.03407174f, -0.03603660f, 0.01657461f, -0.12291709f, 0.01415232f, 
    -0.08642109f, 0.11671818f, -0.00551320f, -0.14849739f, 0.03004573f, -0.03381710f, -0.05996687f, 0.00857961f, 
    -0.01123672f, -0.01082729f, 0.08059655f, -0.05189501f, -0.22967494f, -0.03493951f, 0.06255875f, -0.21793473f, 
    0.11527198f, 0.03571183f, 0.08596789f, 0.00806962f, 0.01820483f, 0.00387655f, -0.14814702f, -0.05970016f, 
    -0.43127674f, -0.09563375f, 0.01928513f, -0.18736857f, -0.01966116f, 0.01453602f, -0.02485629f, 0.12411869f, 
    0.10635451f, 0.11701222f, 0.00854706f, 0.06802176f, 0.10706206f, 0.03402341f, -0.09807701f, -0.01528884f, 
    0.03009333f, -0.09198660f, -0.00605966f, -0.07095627f, 0.05283025f, 0.00563613f, -0.10715109f, 0.03766221f, 
    -0.10479460f, -0.15737477f, -0.13676593f, 0.02109253f, -0.01741738f, 0.03967587f, 0.01074036f, 0.06211404f, 
    0.00067906f, 0.02139371f, 0.14616247f, -0.04489145f, 0.05218668f, 0.05975197f, 0.07904952f, 0.01708678f, 
    -0.24687576f, 0.06968885f, 0.04596423f, 0.09257822f, -0.05583224f, -0.03061699f, -0.12255218f, -0.03711253f, 
    0.15400240f, -0.17272806f, 0.12085122f, -0.07280058f, -0.04131833f, -0.03829217f, 0.13895272f, -0.02266404f, 
    0.06128132f, -0.03929197f, 0.15454127f, 0.08538140f, -0.10630184f, 0.16753562f, 0.17166440f, 0.11981536f, 
    -0.12227563f, 0.07179366f, 0.03366417f, -0.03522805f, -0.10737205f, -0.04040902f, 0.03528956f, 0.00419934f, 
    0.27595675f, 0.03584912f, -0.01024324f, 0.04588548f, 0.00930401f, 0.13100089f, 0.20077960f, 0.04507774f, 
    0.07082102f, -0.09063593f, 0.03247348f, -0.07899383f, 0.17829710f, -0.39170441f, -0.04994773f, -0.02799414f, 
    -0.05466347f, -0.04671523f, -0.09966245f, -0.11538886f, 0.06734012f, 0.10061932f, 0.16994724f, 0.02068165f, 
    0.02124550f, -0.17141041f, 0.00748714f, 0.01875152f, -0.11714606f, -0.06726135f, -0.04344229f, -0.02326023f, 
    0.02258253f, -0.01429554f, -0.08086696f, -0.10034224f, -0.09847653f, -0.03354108f, 0.04198420f, 0.07233206f, 
    0.00168770f, -0.07553980f, 0.02311135f, -0.10812072f, -0.20219050f, -0.07357321f, -0.12961265f, -0.21599641f, 
    0.13820815f, 0.06469586f, -0.09279177f, 0.18844239f, 0.11508442f, 0.14143354f, 0.07689207f, -0.02301876f, 
    -0.08783667f, -0.07632669f, 0.08082417f, -0.17182575f, 0.11461232f, 0.40377626f, 0.08587993f, -0.10544809f, 
    -0.06607120f, -0.06936703f, 0.09559695f, 0.08583403f, 0.12353108f, 0.05315391f, 0.14924869f, 0.13161050f, 
    -0.09270702f, -0.08609197f, -0.01671973f, -0.02553857f, -0.00638703f, 0.09626838f, -0.06059615f, 0.10748091f, 
    0.01388065f, 0.05180094f, 0.08426538f, -0.02998236f, 0.00757860f, 0.12958188f, -0.05162368f, 0.06241619f, 
    0.02990888f, 0.10354606f, 0.06986598f, -0.12114510f, 0.06239836f, -0.02746622f, 0.12727018f, 0.10525747f, 
    0.02267150f, -0.16430402f, -0.06604683f, -0.09014437f, 0.03472885f, -0.04035061f, 0.04005003f, 0.01882114f, 
    0.06529956f, 0.13096365f, 0.10253532f, 0.02818550f, 0.15344439f, 0.04386796f, 0.08880945f, 0.04543041f, 
    0.09508962f, 0.00422486f, -0.05454344f, 0.04665252f, -0.00366519f, 0.03763647f, 0.16347568f, -0.04438724f, 
    0.32055783f, -0.07652253f, 0.02748063f, -0.21601060f, 0.01077511f, 0.06978206f, -0.07195032f, 0.03680847f, 
    0.08740050f, -0.00113947f, 0.14313686f, -0.01836085f, -0.04719235f, -0.04320320f, -0.01155926f, 0.02867073f, 
    -0.06868009f, -0.08084825f, -0.03094453f, 0.04606811f, 0.03788243f, 0.08163170f, -0.09862581f, 0.05551537f, 
    0.36226046f, 0.05920788f, 0.18787430f, -0.08475304f, -0.05755036f, 0.08034315f, 0.14052020f, -0.12913990f, 
    -0.00660920f, 0.03809806f, 0.13593334f, 0.04260326f, -0.19284242f, 0.15042789f, -0.25812098f, -0.11682628f, 
    0.01667775f, -0.16401707f, -0.07414131f, -0.03647712f, -0.07476939f, 0.06089059f, -0.02922986f, -0.04588838f, 
    -0.10038933f, 0.26743233f, -0.20056726f, 0.31250471f, 0.11046030f, -0.01492826f, -0.09180866f, -0.05638697f, 
    0.03841675f, 0.08509956f, 0.01420230f, 0.07431210f, 0.00713444f, -0.09856479f, -0.03727429f, 0.22632185f, 
    -0.03881610f, 0.02367404f, -0.05733858f, -0.05835019f, 0.02307167f, -0.00751870f, 0.04054870f, 0.06366498f, 
    0.00953276f, -0.15342395f, 0.04351139f, -0.09607063f, -0.05859384f, -0.00668931f, 0.06377634f, 0.07523465f, 
    0.03863928f, -0.06177666f, 0.00820158f, -0.04261402f, 0.16737147f, 0.14599325f, 0.13121775f, -0.17820144f, 
    0.01616316f, -0.02418928f, 0.16043968f, -0.02565445f, -0.13728555f, 0.06856481f, -0.10512798f, -0.01318404f, 
    0.14457056f, 0.11092353f, 0.18215922f, -0.20287541f, 0.04893058f, -0.02315007f, 0.08037221f, 0.07921717f, 
    0.09217767f, -0.04903702f, -0.06770794f, 0.12968613f, 0.00634674f, 0.16699733f, -0.14547500f, 0.02466738f, 
    0.06988040f, 0.07983484f, -0.00726891f, 0.01220594f, 0.02529474f, 0.05397478f, -0.00364034f, -0.15179208f, 
    0.12558201f, 0.05151680f, 0.16613127f, -0.29812220f, 0.06296983f, 0.06658716f, 0.04247545f, 0.07333851f, 
    0.06903209f, -0.01548770f, 0.14700386f, 0.00730809f, -0.05008181f, -0.14510074f, 0.09895687f, 0.15394576f, 
    -0.10812075f, -0.04114790f, 0.01906560f, -0.03290586f, -0.01211412f, 0.03679640f, -0.02471237f, -0.10851627f, 
    0.03352566f, 0.09099315f, 0.02406680f, -0.10738352f, -0.02668290f, 0.07866190f, 0.02909515f, 0.04290204f, 
    -0.00479639f, -0.08650348f, -0.02914941f, -0.08898482f, -0.22424379f, -0.15834196f, 0.17173477f, 0.05400947f, 
    0.00956334f, 0.00958439f, -0.02880619f, -0.03801935f, -0.00802186f, 0.06802454f, 0.01169974f, 0.06329434f, 
    0.05640198f, -0.04846057f, 0.06545524f, -0.09889330f, 0.00573325f, 0.16588138f, 0.05333294f, -0.03315420f, 
    -0.04787315f, -0.02725165f, -0.05203007f, -0.00317771f, 0.19065890f, -0.08550972f, 0.12458967f, 0.05399534f, 
    -0.03359724f, 0.02522393f, -0.05843779f, -0.00993248f, -0.05019246f, 0.02290074f, -0.06412125f, -0.05591334f, 
    0.08875749f, 0.01091699f, -0.14642127f, 0.07969262f, 0.12259173f, 0.08001403f, 0.01577457f, 0.17735527f, 
    0.01480090f, 0.04584521f, 0.05120434f, -0.09691995f, -0.16135854f, 0.00187517f, 0.13398847f, -0.02002026f, 
    0.01133505f, 0.08022650f, -0.02028984f, 0.04398465f, 0.10926568f, 0.08760331f, -0.03327993f, -0.02058492f, 
    0.02435692f, -0.09635408f, 0.21078312f, -0.22773583f, 0.00707885f, 0.08971949f, -0.00156463f, 0.11254148f, 
    -0.04055293f, 0.09302755f, 0.06185057f, -0.10953301f, -0.12248690f, -0.05632668f, -0.33941412f, -0.20331991f, 
    0.01230994f, 0.02297664f, 0.00442729f, -0.10182411f, 0.03513788f, 0.10345203f, -0.00187445f, -0.04690624f, 
    -0.16130376f, 0.21723501f, -0.20598412f, 0.00404989f, -0.10611060f, 0.19913891f, -0.08664200f, -0.06916711f, 
    0.05261354f, 0.02075561f, -0.00803284f, 0.05705347f, 0.19504224f, 0.05659070f, 0.09274184f, -0.04067132f, 
    -0.07127061f, -0.04371795f, -0.06293504f, -0.00209316f, 0.01765141f, -0.07931867f, -0.09160113f, 0.00333534f, 
    0.10975885f, -0.03268741f, 0.06564637f, 0.10520147f, -0.06196338f, -0.08704077f, 0.06625584f, -0.01752453f, 
    -0.07114355f, 0.04273510f, -0.19761267f, -0.05937966f, 0.08265889f, 0.14985450f, 0.11800859f, 0.17637540f, 
    0.01789578f, -0.04368285f, 0.18387747f, -0.03743053f, -0.05157213f, -0.02049212f, 0.03899335f, -0.03671251f, 
    0.10255092f, -0.02807196f, -0.02881516f, 0.09436221f, -0.03254373f, -0.07016747f, 0.06538356f, 0.03984330f, 
    0.14141692f, -0.01755831f, 0.04777174f, -0.06679459f, 0.09595600f, 0.10590301f, -0.04569948f, 0.03775428f, 
    0.11038641f, 0.06814645f, -0.05034472f, 0.08285577f, 0.03369492f, -0.08511014f, 0.03284754f, -0.14496493f, 
    0.02129902f, -0.00009035f, 0.02650607f, 0.29608265f, 0.09964625f, 0.07771324f, 0.09259190f, -0.05233695f, 
    -0.00939963f, 0.01672885f, -0.01829499f, 0.10439991f, 0.25600713f, -0.06586686f, -0.07224405f, 0.06977172f, 
    -0.13709167f, 0.06390638f, -0.02377273f, -0.09816033f, -0.03307567f, 0.08447193f, 0.09632263f, -0.10737146f, 
    0.19501054f, 0.07755179f, 0.17193909f, 0.03955201f, -0.03351576f, 0.06789108f, -0.03969417f, -0.11796705f, 
    0.06827270f, -0.08122109f, -0.05017106f, -0.04318974f, -0.02309022f, 0.19755037f, 0.12034615f, 0.02296183f, 
    -0.11309125f, 0.04856090f, -0.10366449f, 0.05808057f, 0.01743976f, -0.05843430f, 0.10022376f, 0.01216599f, 
    -0.04129336f, -0.07773165f, -0.04837364f, 0.12044871f, 0.07812170f, -0.01725111f, 0.16352181f, 0.04109603f, 
    -0.06749800f, -0.08303190f, 0.00445989f, 0.07551096f, -0.08775506f, 0.27758062f, -0.05117228f, 0.30831698f, 
    -0.00325796f, 0.02014195f, -0.04306240f, 0.04551445f, -0.06609213f, 0.04151637f, 0.15256031f, 0.02097198f, 
    0.00774638f, 0.10798891f, 0.08055034f, -0.22187018f, 0.08076611f, 0.10508018f, -0.00141279f, -0.09069385f, 
    0.03530803f, -0.09640364f, -0.06365295f, -0.08047383f, 0.06771611f, -0.00762986f, -0.04588448f, -0.00533953f, 
    0.00794179f, -0.12112655f, -0.00658423f, 0.08595460f, 0.05403016f, 0.01888223f, -0.03631327f, 0.01929593f, 
    -0.08283871f, -0.05680733f, -0.01051836f, 0.11198003f, -0.05937908f, 0.09310790f, 0.00846755f, -0.05835066f, 
    0.03847339f, -0.00417689f, 0.03413569f, -0.04451267f, 0.05150895f, -0.03884483f, -0.06697342f, 0.08625586f, 
    -0.16026179f, -0.00622367f, -0.07957188f, 0.06553822f, -0.10873508f, -0.12357479f, 0.03427196f, 0.09457851f, 
    -0.05110694f, 0.06420539f, -0.13529107f, 0.18125220f, 0.08957421f, -0.09856521f, -0.04304774f, -0.08266707f, 
    -0.03364522f, -0.07569458f, 0.11435798f, 0.06380606f, -0.02078698f, -0.15210487f, 0.07571051f, 0.13398090f, 
    -0.10989559f, 0.12295645f, 0.02817925f, -0.06606174f, -0.01831671f, 0.12752287f, -0.05141257f, 0.16023973f, 
    0.23686340f, 0.05550452f, 0.17546469f, -0.15336685f, 0.01446285f, -0.03265275f, -0.04697482f, 0.02338121f, 
    -0.14610481f, 0.01176972f, 0.10568723f, -0.05413815f, 0.21431261f, -0.21229522f, 0.02541303f, -0.23517698f, 
    -0.02106670f, 0.11158020f, 0.00417750f, -0.03287390f, 0.09552114f, 0.10755637f, -0.09235165f, -0.02612536f, 
    0.06048414f, -0.03842372f, -0.00780878f, -0.15626627f, -0.00018085f, -0.02989083f, 0.12777159f, 0.15694585f, 
    0.05329107f, 0.03252035f, -0.02879351f, -0.00498962f, -0.10003595f, 0.13069718f, -0.01736467f, 0.01356939f, 
    0.12668158f, -0.01172365f, -0.04017399f, -0.03245167f, -0.03777691f, -0.03040192f, 0.08551738f, 0.02952438f, 
    0.17772438f, -0.15492478f, 0.09442511f, -0.06550329f, 0.02607393f, 0.01766721f, 0.02555214f, 0.04425434f, 
    -0.11465575f, 0.03176410f, 0.13533919f, 0.04693028f, 0.09817105f, 0.14779295f, -0.03176549f, 0.18712045f, 
    0.04064672f, -0.00436688f, -0.04096013f, -0.03562363f, -0.04620350f, -0.16926184f, -0.03414245f, -0.03309749f, 
    0.00981861f, -0.02530548f, 0.09233611f, 0.22029132f, 0.05468490f, -0.04945503f, -0.02389780f, 0.02015429f, 
    -0.07021111f, 0.00913361f, 0.04388966f, -0.02535709f, -0.34065971f, -0.01676714f, 0.22341681f, 0.04492877f, 
    0.08279937f, 0.15826216f, 0.00926970f, 0.00431666f, 0.01124609f, -0.06450832f, -0.04419677f, -0.04914357f, 
    0.27955845f, -0.12086683f, -0.00351609f, -0.15384579f, 0.09471060f, -0.06639788f, -0.00332864f, -0.05525333f, 
    -0.03456057f, 0.11913836f, 0.03876717f, -0.02793607f, 0.19499329f, -0.04578887f, 0.10417555f, -0.07775637f, 
    0.02457759f, 0.01812777f, 0.01096777f, -0.01244745f, 0.02558756f, 0.02610586f, 0.02528584f, -0.06734101f, 
    0.24109964f, -0.02560454f, -0.06141995f, -0.02500671f, 0.05052451f, 0.01805757f, -0.05272975f, -0.13693364f, 
    -0.01632452f, 0.05367400f, 0.05353851f, 0.06781048f, 0.07925477f, 0.23314567f, 0.13140301f, -0.06776261f, 
    -0.02244235f, 0.03982176f, 0.04634884f, 0.02177633f, -0.09059049f, -0.07910334f, 0.01884911f, -0.01821644f, 
    -0.24839112f, 0.02820579f, -0.07392639f, 0.10666271f, 0.05201939f, -0.06573926f, -0.02967875f, -0.04301958f, 
    -0.00257684f, 0.04371163f, -0.04472606f, -0.00653474f, 0.31265548f, 0.11993667f, 0.20361054f, 0.05827154f, 
    -0.08618577f, 0.00106045f, 0.08895615f, 0.10194278f, 0.01959245f, 0.02994283f, -0.01789075f, 0.15728925f, 
    0.13613802f, 0.16969168f, -0.04797292f, 0.08318482f, -0.08768722f, 0.06218994f, 0.07388321f, 0.02488750f, 
    -0.10616884f, -0.03140774f, -0.04551762f, 0.07995091f, 0.03313300f, -0.06277368f, -0.21158347f, 0.04428494f, 
    -0.03972073f, 0.08045223f, -0.01198599f, 0.09913927f, -0.08708227f, 0.04286892f, 0.07991625f, -0.00222327f, 
    -0.11037102f, -0.12529790f, -0.06407005f, 0.02942503f, 0.19457173f, 0.07923993f, 0.03373611f, -0.02005362f, 
    -0.07978926f, 0.14702024f, 0.03459563f, 0.14854795f, 0.04965341f, -0.10919897f, 0.04870888f, -0.02727857f, 
    0.07241267f, -0.03863813f, -0.06036075f, 0.00626496f, 0.12314535f, 0.03254662f, -0.02819129f, 0.10127302f, 
    -0.02569888f, -0.10586536f, 0.03360872f, 0.00148143f, 0.17035235f, 0.03244806f, 0.02783155f, 0.04426765f, 
    -0.01745030f, -0.03120458f, -0.05493591f, 0.05935352f, -0.00553293f, 0.08727474f, -0.00825852f, 0.01713246f, 
    0.08151389f, 0.13196413f, -0.07230802f, 0.01635781f, 0.03046887f, 0.00058353f, -0.05699434f, 0.12225755f, 
    0.02737801f, -0.10228550f, 0.17163298f, -0.19891053f, -0.02283945f, -0.03478569f, 0.04543606f, 0.05767885f, 
    -0.08023782f, 0.04261810f, 0.08779306f, 0.14671652f, -0.12756580f, 0.04310392f, -0.14968750f, 0.17140490f, 
    0.10248935f, -0.02324832f, 0.04413829f, -0.04533376f, 0.01664910f, -0.03315952f, -0.06935796f, -0.00921051f, 
    -0.14491792f, -0.09151985f, 0.02397900f, 0.10549647f, 0.10603866f, 0.00380716f, 0.14909019f, 0.09911874f, 
    -0.06635320f, 0.02106798f, 0.08478478f, 0.08599919f, -0.20520645f, -0.04380127f, -0.20458786f, 0.05373387f, 
    -0.03682167f, 0.01760154f, 0.03898748f, -0.02372519f, 0.04322153f, 0.04263785f, 0.04212828f, -0.09815172f, 
    0.20244333f, 0.15395196f, 0.03782055f, -0.05599709f, 0.10891648f, -0.05011162f, -0.12749170f, 0.03174109f, 
    -0.00393223f, -0.10216628f, -0.01810409f, -0.01028835f, 0.10080205f, -0.05479556f, -0.24263492f, -0.11445714f, 
    0.04970593f, 0.06753717f, 0.05674145f, 0.14040115f, 0.10603143f, -0.00646731f, 0.00314209f, -0.00462873f, 
    -0.00074603f, 0.35795605f, -0.00308055f, 0.01348333f, 0.06746347f, 0.09512897f, 0.08025271f, -0.07964575f, 
    0.01471370f, 0.00794102f, -0.02484701f, -0.04337979f, -0.08393519f, -0.02722392f, 0.07895807f, 0.14146821f, 
    -0.05299081f, 0.08571299f, -0.04466577f, 0.06776139f, -0.09243821f, -0.11796155f, -0.00161163f, 0.05773138f, 
    -0.39775750f, -0.17304835f, -0.00825742f, 0.05547050f, 0.00270748f, 0.06668741f, 0.02173348f, -0.01270551f, 
    -0.04481727f, 0.10332707f, -0.08832448f, -0.13768446f, 0.20476668f, -0.21742031f, 0.06761093f, 0.21590213f, 
    -0.07385026f, 0.09541751f, -0.01960744f, 0.02039915f, 0.15139431f, 0.09950774f, -0.08016857f, 0.04615868f, 
    -0.19240724f, -0.07325882f, -0.10765211f, 0.01535806f, -0.03978211f, -0.06450020f, 0.14257148f, 0.10875793f, 
    -0.00495433f, -0.09594229f, -0.01409761f, 0.01736298f, -0.36313018f, 0.15198249f, 0.09493773f, -0.03467408f, 
    0.08173654f, -0.08445323f, -0.04537863f, 0.09703100f, -0.08883911f, -0.09472410f, 0.02468095f, 0.00391378f, 
    -0.08212751f, 0.14002007f, 0.07620262f, 0.02237018f, 0.09443773f, -0.19486417f, 0.00746737f, 0.05631377f, 
    -0.09955356f, 0.18830705f, 0.06596544f, 0.04690790f, 0.01127416f, -0.00322659f, -0.18136537f, -0.01743996f, 
    -0.01824905f, 0.03059501f, 0.11246189f, 0.00208496f, 0.09170786f, 0.02881552f, -0.00773678f, 0.01711560f, 
    0.13919073f, -0.14550637f, -0.22219484f, -0.03742842f, 0.02882773f, 0.07637346f, 0.05232815f, -0.01751875f, 
    0.12048170f, 0.14636423f, -0.01596714f, -0.00938603f, -0.16922821f, -0.15290153f, 0.06805690f, 0.10844686f, 
    0.07497150f, 0.07968159f, -0.03255847f, -0.03993797f, 0.08886798f, 0.02069619f, 0.10258671f, 0.19685756f, 
    0.13057394f, -0.11370678f, 0.16802050f, 0.19254771f, -0.07764069f, -0.01800421f, -0.09655954f, 0.03877219f, 
    -0.15579113f, 0.07520700f, 0.06556108f, 0.13601173f, 0.11428542f, 0.13628370f, -0.14939567f, 0.01274999f, 
    0.14367707f, 0.01935078f, 0.02112461f, 0.09156389f, -0.06910929f, -0.05306592f, 0.08979839f, -0.04310403f, 
    -0.00263220f, 0.03724706f, 0.20359398f, 0.16743171f, 0.05534384f, -0.09269814f, -0.04822554f, -0.03489697f, 
    -0.11583538f, 0.18072717f, -0.13322304f, 0.01868528f, -0.23123699f, 0.42007416f, 0.24168594f, 0.11018103f, 
    0.06299108f, 0.08807644f, 0.06241019f, 0.02735732f, 0.06451086f, -0.00695673f, -0.02337475f, -0.06083384f, 
    0.09168141f, -0.03475212f, -0.16092424f, -0.08720922f, -0.00397736f, -0.06187750f, -0.04184280f, -0.06867044f, 
    -0.05398781f, 0.04071419f, -0.05467845f, 0.01940311f, -0.33846179f, 0.35712740f, 0.10263444f, 0.01367114f, 
    -0.00601879f, -0.06015684f, 0.07504764f, 0.08048730f, 0.05020770f, -0.02013816f, 0.04168554f, 0.04182518f, 
    -0.05285406f, -0.02451752f, 0.03194938f, 0.08897545f, 0.08869092f, 0.03458133f, 0.16041705f, -0.14232638f, 
    0.04432211f, -0.01675228f, -0.06079369f, 0.05312476f, -0.14766175f, 0.14597854f, 0.17679542f, 0.12211266f, 
    0.06674154f, -0.03548055f, 0.11716966f, 0.05179935f, -0.06936664f, -0.06981934f, 0.11045592f, -0.07465232f, 
    -0.20715982f, 0.04515037f, -0.12945057f, 0.45900226f, 0.06504834f, 0.00966023f, -0.01944323f, -0.12095146f, 
    -0.08572831f, -0.01018065f, 0.01528340f, -0.03492568f, -0.12355053f, 0.12819317f, 0.19860429f, -0.12200486f, 
    -0.09235318f, 0.01824980f, 0.07433266f, 0.10639539f, 0.06609455f, -0.08147028f, 0.07357741f, 0.11888837f, 
    0.25931317f, 0.01650697f, 0.39506060f, -0.03421726f, -0.02161627f, -0.17320254f, 0.10522837f, 0.00170944f, 
    0.03531824f, 0.11188693f, -0.03241035f, 0.01523559f, -0.05362522f, -0.06701339f, 0.07382142f, 0.01722218f, 
    0.17078835f, 0.02494160f, 0.03986524f, 0.06824139f, -0.00384268f, 0.04130911f, 0.20156068f, 0.02204724f, 
    -0.12096913f, -0.03276948f, -0.03271429f, 0.06108317f, -0.00322528f, -0.00884706f, -0.02654949f, -0.09893712f, 
    -0.01656007f, 0.08147734f, -0.03809994f, 0.10726415f, -0.16752563f, 0.01471596f, -0.07635354f, -0.13863002f, 
    0.00046104f, 0.04074030f, 0.02344374f, -0.05920898f, 0.10216969f, -0.02622648f, -0.04591697f, -0.01019969f, 
    0.06038013f, 0.13177674f, -0.29756263f, 0.07666878f, -0.00842829f, 0.08684993f, 0.02580005f, -0.11779696f, 
    0.05394423f, 0.01297964f, -0.07061844f, 0.07806142f, -0.01262499f, -0.10356973f, -0.00373808f, 0.04291114f, 
    -0.07850145f, 0.02257835f, 0.11357819f, -0.02927260f, 0.09898850f, 0.15932317f, -0.04823306f, 0.21520710f, 
    0.02615846f, 0.17867473f, 0.17168795f, -0.16947776f, -0.04348782f, 0.09539784f, -0.02346760f, 0.12339249f, 
    -0.06788070f, -0.07837342f, 0.09017751f, 0.10532863f, 0.11608910f, 0.00083190f, 0.04560283f, -0.03793522f, 
    0.19882093f, 0.04449282f, 0.09703474f, 0.02743834f, 0.07323772f, 0.01563881f, -0.09074382f, -0.01811506f, 
    -0.01753357f, 0.01985319f, 0.04082668f, 0.39896050f, 0.05059066f, -0.16734512f, -0.00048124f, 0.11276816f, 
    -0.04185228f, 0.00673807f, 0.03002821f, 0.08984504f, -0.09726278f, -0.29857776f, 0.05993824f, 0.15459955f, 
    0.13964123f, 0.01423252f, 0.07216799f, -0.07824565f, 0.07411239f, 0.09769961f, -0.04922743f, 0.03357529f, 
    0.02577772f, 0.06161340f, -0.02221352f, -0.15970759f, 0.10344123f, 0.03597664f, 0.01064198f, -0.07181709f, 
    0.06626200f, -0.04964507f, 0.01440070f, 0.02958148f, -0.10908140f, -0.05101739f, -0.07851049f, -0.36200681f, 
    0.02465912f, -0.07589553f, 0.01249540f, 0.05509095f, 0.01064165f, 0.00014141f, -0.06760523f, 0.03203136f, 
    -0.03812649f, -0.03289009f, 0.04182279f, -0.07320332f, 0.00673829f, -0.05502740f, -0.03510577f, 0.00846649f, 
    0.02729871f, -0.00656385f, 0.00275964f, -0.07518689f, -0.04630292f, -0.02922195f, -0.00406977f, -0.02130744f, 
    -0.07102763f, -0.05989293f, -0.05148686f, 0.00935035f, -0.00187633f, -0.03684887f, -0.00014012f, -0.01270819f, 
    -0.06137487f, 0.05392726f, 0.05191546f, -0.03866304f, -0.06565379f, 0.00246478f, -0.06081127f, -0.01504209f, 
    -0.03161093f, 0.03742797f, 0.00780171f, -0.03905549f, -0.02835998f, 0.01968921f, -0.00420515f, 0.00167121f, 
    0.04297185f, -0.06725138f, -0.02648578f, -0.02276663f, -0.05075746f, -0.06511337f, -0.03861035f, 0.05120881f, 
    0.06407386f, 0.02775938f, -0.01149312f, 0.01215013f, -0.04344149f, 0.00266647f, -0.00698682f, 0.04197044f, 
    0.01239628f, 0.00837294f, -0.02727859f, -0.05064652f, 0.02031518f, -0.02061248f, -0.05850212f, 0.04133468f, 
    0.05375487f, -0.03448806f, -0.05231651f, -0.06948185f, 0.02732396f, -0.02828917f, 0.00127038f, -0.07999471f, 
    -0.06792149f, -0.00714306f, 0.04996071f, 0.02714880f, -0.05038859f, -0.01997636f, -0.00480260f, -0.06584679f, 
    0.05857566f, -0.06249768f, -0.00747488f, 0.00506367f, 0.00833191f, 0.00370871f, -0.08145150f, -0.00440278f, 
    -0.05760672f, 0.04334036f, -0.00001770f, -0.00431011f, 0.01525883f, -0.02187126f, 0.02992673f, 0.04796000f, 
    -0.04082991f, 0.02959879f, -0.05315587f, -0.05507098f, -0.01154434f, 0.05401331f, -0.08002637f, 0.00865194f, 
    -0.01978273f, -0.03388375f, -0.05094915f, 0.04083051f, -0.00862409f, -0.01893482f, -0.05788387f, 0.03553888f, 
    -0.08045314f, -0.00900626f, 0.03402204f, -0.02766358f, 0.02605491f, 0.03899037f, 0.05508890f, -0.05745127f, 
    -0.00389386f, 0.03393209f, 0.03993285f, 0.06406747f, 0.02392385f, -0.03302356f, -0.04193109f, 0.04335997f, 
    -0.02435874f, 0.00699886f, 0.00262561f, -0.01703449f, -0.06209632f, -0.02875704f, 0.04539138f, -0.00473998f, 
    0.03870280f, -0.04024796f, 0.02526114f, -0.07816070f, 0.03589879f, 0.02715221f, -0.06861884f, 0.00694473f, 
    0.00732712f, -0.03656905f, 0.03287044f, 0.07091875f, -0.01782913f, -0.04359300f, 0.04699954f, -0.06342301f, 
    -0.01650955f, -0.01399647f, 0.05105117f, 0.06550597f, -0.05515281f, -0.04466518f, 0.04481523f, 0.04755197f, 
    -0.03745134f, 0.04569775f, -0.03281466f, -0.00929398f, -0.01931136f, 0.04496107f, 0.04818006f, 0.06040877f, 
    -0.05249838f, 0.01754591f, 0.05460681f, -0.03752631f, 0.03338085f, -0.03743652f, -0.01547353f, -0.07248615f, 
    -0.06105987f, 0.05781829f, 0.05859335f, -0.05997001f, -0.00781382f, -0.04512982f, -0.00947846f, 0.04070731f, 
    0.04382648f, 0.00276838f, -0.05360672f, -0.01889632f, 0.03943297f, -0.07638399f, -0.00958865f, -0.04200989f, 
    -0.28759933f, -0.30973536f, -0.12821530f, 0.08387270f, 0.01553741f, -0.07989867f, 0.06824383f, 0.08370087f, 
    -0.04133648f, 0.06846371f, -0.01719238f, 0.02762441f, -0.35473898f, 0.09633077f, 0.19865035f, 0.05785616f, 
    0.03350742f, 0.04922399f, 0.05614719f, 0.03424140f, -0.05923737f, 0.01785216f, 0.12192718f, 0.01295162f, 
    0.19140163f, -0.08456894f, -0.03832318f, 0.10432932f, 0.10503326f, -0.07410775f, -0.01270351f, 0.04517966f, 
    -0.05718844f, 0.04967588f, 0.14819248f, 0.08285953f, -0.16338354f, 0.08487553f, 0.13970132f, -0.17356302f, 
    0.02426600f, 0.01054510f, 0.00300750f, 0.00503707f, 0.09600383f, 0.02480121f, -0.04976438f, 0.04013924f, 
    0.18621877f, 0.05197374f, 0.33410650f, -0.19284430f, 0.09937157f, -0.02204206f, -0.02880271f, 0.08122782f, 
    0.07235638f, -0.05651991f, 0.00297050f, 0.01293132f, -0.25417230f, 0.30336460f, 0.10640396f, -0.09348363f, 
    0.12435954f, -0.14060073f, 0.08073066f, -0.05952626f, 0.04480552f, 0.05910823f, 0.02796709f, 0.06000328f, 
    0.06529180f, -0.19542037f, -0.03334565f, 0.23003159f, 0.04932395f, 0.04062328f, 0.00533035f, -0.02227522f, 
    0.19575885f, -0.01105041f, -0.05210317f, -0.02120614f, -0.08631533f, -0.11713918f, -0.06098311f, 0.21228521f, 
    0.09721533f, -0.07575603f, -0.15016715f, 0.06830036f, -0.03151851f, -0.09496582f, 0.08293701f, -0.12363023f, 
    -0.20281634f, -0.05352958f, -0.06064766f, 0.17136803f, 0.03025222f, 0.07687900f, -0.12718990f, -0.07894346f, 
    -0.04423271f, 0.00798563f, 0.09311996f, -0.00347661f, 0.06557219f, 0.06151165f, 0.16100688f, -0.12023725f, 
    0.07071026f, -0.11426048f, 0.02296809f, 0.12370047f, 0.04809421f, 0.02875346f, -0.00524942f, -0.22239447f, 
    0.06393688f, 0.19011362f, -0.07607244f, 0.31133181f, -0.00390338f, -0.02512037f, 0.01201438f, 0.00074642f, 
    0.05923408f, -0.01080451f, -0.07347693f, 0.03403509f, 0.18424280f, 0.01791118f, 0.09776124f, -0.22767408f, 
    0.03890226f, 0.04099097f, 0.02656974f, 0.07657652f, 0.07063439f, 0.27156210f, 0.07101133f, 0.12996615f, 
    0.17711325f, -0.01932511f, -0.00357661f, 0.14816387f, -0.08170331f, -0.00618666f, -0.06357426f, 0.07077228f, 
    0.07908248f, 0.01330253f, 0.03708627f, 0.07592081f, 0.23570701f, -0.09594990f, 0.02914687f, 0.05614040f, 
    0.03659866f, -0.04051388f, 0.08424730f, 0.08305310f, -0.00279197f, 0.03150018f, -0.00557913f, 0.08129291f, 
    -0.28324020f, -0.08962546f, -0.16252367f, 0.08962563f, 0.07882334f, -0.01229953f, -0.04585531f, 0.07264399f, 
    0.08871822f, 0.03412170f, 0.08151353f, 0.17457028f, -0.30008617f, -0.00711299f, -0.08800558f, -0.13183944f, 
    -0.00836563f, 0.04550267f, 0.04507297f, 0.00546485f, -0.05963583f, 0.10856165f, 0.00809859f, 0.09083875f, 
    0.05184637f, -0.09552148f, -0.01431240f, 0.18026592f, -0.11551647f, -0.04496539f, 0.04159284f, 0.09186195f, 
    -0.07716431f, -0.02470064f, 0.04084052f, 0.00327236f, -0.33347431f, -0.10086957f, 0.13491043f, -0.09105005f, 
    0.12947051f, -0.05122508f, 0.01737060f, -0.12216701f, -0.00793069f, 0.02731267f, 0.03386798f, -0.07932726f, 
    0.35168985f, 0.11796598f, 0.09804026f, -0.27208358f, 0.12188682f, 0.09340844f, 0.05787420f, 0.13972135f, 
    0.09631273f, 0.09719490f, 0.06279970f, 0.07674603f, -0.27645838f, -0.11527638f, -0.07788780f, -0.08006593f, 
    0.10868359f, 0.11393503f, 0.02489265f, -0.08660202f, 0.08094311f, 0.11578047f, 0.10879300f, 0.09942652f, 
    -0.27569240f, 0.05694458f, 0.05295271f, -0.12373789f, -0.00485134f, 0.09112017f, -0.13117062f, -0.08255040f, 
    -0.02495061f, 0.01928692f, 0.07491898f, 0.07783155f, 0.21565619f, -0.12282912f, 0.07500378f, -0.02859488f, 
    -0.00074285f, -0.06899931f, -0.10289930f, 0.12705204f, -0.01555768f, 0.01556327f, -0.11587957f, 0.01989318f, 
    0.10466975f, -0.09824005f, -0.03345221f, -0.14558753f, 0.07466296f, -0.08479741f, -0.02907826f, -0.01770313f, 
    -0.09481399f, 0.08216711f, -0.06572796f, -0.03753533f, 0.03119155f, 0.13354567f, 0.04349306f, 0.18446231f, 
    -0.22977658f, -0.01521526f, 0.06480118f, 0.19703890f, -0.08448780f, -0.04943376f, -0.05503386f, -0.11411062f, 
    -0.20276673f, 0.06601680f, 0.05515565f, 0.01525971f, -0.03753215f, -0.06011547f, 0.06755164f, 0.09577700f, 
    0.03970691f, -0.05453932f, 0.11927678f, -0.03594391f, 0.17610416f, 0.12621723f, 0.07391682f, 0.03287624f, 
    0.02372545f, -0.13489832f, -0.04798092f, 0.15079637f, -0.07836531f, 0.02352769f, 0.10633557f, 0.08698507f, 
    -0.19812526f, 0.03059247f, -0.09207834f, 0.16963269f, 0.13574859f, -0.01178484f, 0.02420942f, -0.06536324f, 
    0.10961090f, 0.16666333f, -0.06728051f, -0.06665232f, 0.06157650f, -0.20081188f, 0.10077888f, -0.11624206f, 
    -0.02229122f, -0.01898052f, 0.00008042f, 0.05076833f, 0.18982531f, 0.15817007f, -0.01402947f, 0.16050060f, 
    0.28199798f, 0.11141261f, 0.06328144f, -0.16383329f, 0.05369525f, 0.15810667f, -0.08566490f, -0.10059208f, 
    0.13495670f, 0.01110165f, 0.07392652f, -0.02918049f, 0.14172702f, 0.06773490f, -0.19851565f, -0.20586608f, 
    -0.09000069f, -0.07190643f, -0.03524717f, 0.07204842f, 0.14767778f, 0.15576676f, -0.00396323f, 0.09638292f, 
    0.01672919f, 0.11088549f, 0.06495754f, 0.08485125f, -0.01569659f, -0.04075997f, 0.05678466f, 0.14696079f, 
    0.05914743f, -0.05478144f, -0.02076759f, -0.08288544f, 0.05882374f, -0.07688215f, -0.03904893f, 0.14814696f, 
    -0.04789736f, 0.00374762f, 0.04215620f, -0.00860477f, -0.08222447f, -0.02094559f, 0.03384810f, -0.09772941f, 
    -0.02766237f, -0.05936772f, -0.06938430f, -0.07423313f, 0.01696310f, 0.05707967f, 0.03002428f, -0.06277346f, 
    -0.00530226f, -0.00833027f, 0.02332688f, 0.06449024f, -0.02257126f, -0.03853625f, 0.00286051f, -0.07192624f, 
    0.01574387f, -0.05400672f, -0.00937769f, -0.00089326f, -0.00477247f, 0.00139903f, -0.05491985f, 0.02365728f, 
    0.02167153f, -0.07495486f, -0.01281571f, -0.05473135f, 0.04637334f, -0.07060950f, -0.07104330f, 0.06808990f, 
    0.04909617f, 0.01056091f, -0.01238417f, 0.02682981f, 0.03930983f, 0.05594954f, -0.02790680f, 0.01148466f, 
    -0.03829283f, -0.06405152f, 0.03032014f, -0.06207400f, -0.05055852f, -0.00451166f, 0.02145829f, 0.04699317f, 
    -0.02986877f, 0.04419326f, -0.03868171f, -0.04230519f, 0.04205690f, -0.00067284f, -0.04812361f, -0.01511152f, 
    -0.05236533f, 0.06074126f, -0.04268243f, 0.03193976f, 0.05217982f, 0.02050693f, 0.01826897f, 0.04271931f, 
    -0.01027314f, 0.01904448f, -0.00096003f, -0.07166037f, 0.03622154f, -0.07839291f, -0.06423411f, -0.04710722f, 
    -0.06239325f, -0.00534058f, -0.01277796f, -0.06862561f, 0.01677641f, 0.00214753f, -0.03439557f, 0.00437623f, 
    -0.00666369f, -0.06908835f, -0.06158671f, -0.05493416f, 0.06031618f, -0.01757411f, -0.05768344f, -0.06549402f, 
    -0.01283016f, -0.02560763f, -0.07714341f, 0.06939424f, 0.05866901f, -0.06351556f, -0.02990078f, 0.02208314f, 
    0.01526057f, 0.04986036f, 0.06545566f, -0.01195350f, -0.06263880f, -0.03414644f, -0.03037953f, -0.03784082f, 
    -0.01334201f, -0.05357097f, -0.04833360f, -0.05284343f, -0.06727759f, 0.00095725f, 0.06898546f, -0.02077242f, 
    -0.04545533f, -0.03849908f, 0.04758245f, 0.03260556f, 0.00280133f, -0.03817585f, -0.00732643f, -0.02415517f, 
    -0.02309917f, -0.06921022f, -0.01415241f, -0.05713326f, -0.01120173f, 0.04605981f, 0.02493422f, -0.05202960f, 
    -0.04648709f, -0.02679575f, -0.01449679f, 0.05029253f, 0.05491263f, -0.01215119f, -0.03907342f, 0.06353305f, 
    -0.03899393f, 0.00773640f, -0.00967816f, -0.03453011f, -0.05799560f, -0.04693523f, -0.01946947f, 0.01038707f, 
    0.01851835f, -0.04744856f, -0.04354622f, 0.05438668f, 0.02121064f, 0.00460326f, -0.06831197f, -0.00915272f, 
    0.03780803f, 0.00530769f, 0.04099454f, 0.01026611f, 0.05904384f, -0.01818470f, -0.07703922f, -0.00999337f, 
    0.01789637f, -0.02735547f, 0.03834694f, -0.01627258f, -0.00503998f, 0.03494677f, 0.02503123f, 0.01691627f, 
    -0.06225379f, -0.05997591f, 0.01075776f, 0.03753758f, 0.01712054f, -0.05539968f, -0.05849497f, -0.04994487f, 
    -0.01798802f, -0.06560716f, 0.05863314f, 0.04636795f, -0.03836184f, -0.00211252f, -0.02399261f, -0.06580826f, 
    0.02013288f, -0.02899623f, 0.05598589f, -0.02739722f, -0.03383432f, -0.03866422f, -0.06377554f, -0.05759277f, 
    -0.18361470f, 0.18242091f, 0.00385109f, -0.11294861f, 0.02559143f, 0.03178607f, -0.03067734f, -0.04540154f, 
    0.02940976f, 0.01047248f, 0.05924218f, -0.00454710f, 0.27413306f, -0.03663990f, -0.07904753f, 0.01529550f, 
    0.02786222f, -0.02854666f, -0.00572693f, -0.09137435f, 0.04707767f, 0.04293124f, -0.03602171f, -0.02658656f, 
    -0.47058782f, 0.02298632f, 0.07117322f, -0.09532901f, -0.01695660f, 0.05499467f, -0.03843511f, 0.12357944f, 
    0.10430620f, -0.01843136f, 0.05162887f, -0.13113031f, 0.33337629f, -0.23015448f, 0.14016987f, 0.32708889f, 
    0.04715345f, -0.01727227f, -0.02906289f, 0.09389166f, 0.03579943f, 0.03979609f, 0.03826742f, 0.03892301f, 
    -0.11708975f, -0.09187449f, -0.21539317f, -0.02508031f, -0.04442119f, -0.06044647f, -0.04974537f, -0.03999671f, 
    -0.09674432f, 0.01714432f, 0.01025678f, 0.11928321f, 0.02768828f, -0.06180269f, 0.01281970f, -0.04596727f, 
    -0.04452323f, 0.04774559f, -0.07866647f, 0.07569040f, -0.10061286f, -0.00219615f, 0.01080147f, 0.12088467f, 
    0.27959636f, 0.13944763f, 0.10223080f, 0.02844068f, 0.14023520f, -0.02368806f, 0.00858783f, -0.08634180f, 
    -0.08306140f, 0.14051706f, 0.11070149f, -0.05312276f, 0.19716485f, -0.21577954f, -0.02918377f, 0.01902763f, 
    0.09165907f, 0.08238798f, 0.00483237f, -0.02153349f, 0.13412926f, 0.09567251f, -0.05326369f, 0.05846164f, 
    0.00987465f, -0.16412479f, -0.04408546f, -0.01086560f, -0.00851231f, -0.02775589f, 0.07835966f, 0.08935923f, 
    0.02883422f, -0.03667044f, -0.01469378f, -0.10397926f, 0.05572288f, 0.04933623f, 0.11947195f, 0.03811742f, 
    0.04748724f, 0.05006984f, -0.00429167f, -0.03536388f, 0.05127513f, -0.06179113f, 0.05619253f, 0.10929437f, 
    0.02809847f, -0.20183466f, 0.03414794f, 0.12493642f, 0.11232235f, -0.11468697f, 0.04865681f, 0.08914834f, 
    -0.00504399f, 0.05972305f, 0.02824551f, -0.00182204f, -0.06162687f, 0.29206401f, -0.15255596f, 0.04667747f, 
    -0.04164168f, 0.02221323f, 0.03481362f, -0.00559863f, 0.06266091f, -0.19594386f, -0.06972570f, 0.06586317f, 
    -0.02907599f, 0.04213510f, -0.05134057f, -0.02680804f, 0.11560629f, 0.03510033f, 0.05810133f, 0.03707052f, 
    0.01928342f, 0.17464764f, 0.05405037f, 0.01613532f, -0.15706390f, 0.34136018f, -0.25606909f, -0.11325361f, 
    -0.07738183f, 0.13183632f, 0.06829887f, 0.01199655f, -0.05950249f, 0.04309765f, -0.01892472f, -0.14420222f, 
    0.22484468f, -0.07253604f, 0.09480710f, -0.00233052f, -0.02830624f, -0.09742553f, -0.07493167f, 0.01988235f, 
    -0.01000616f, 0.04730970f, 0.04085543f, -0.00454960f, 0.07624631f, 0.13525026f, -0.06114906f, 0.13278121f, 
    -0.03581044f, -0.08858629f, 0.01733390f, 0.08835224f, 0.10367107f, -0.06158555f, 0.01550719f, -0.05167603f, 
    -0.00598969f, 0.18971372f, -0.04664186f, -0.19124421f, -0.08553691f, 0.06024755f, 0.08757355f, 0.06546125f, 
    0.01758718f, 0.00332740f, -0.05790507f, -0.02733951f, 0.03360221f, 0.14737390f, -0.05036571f, 0.04435518f, 
    0.03654971f, 0.07720402f, 0.03137652f, 0.00914789f, -0.17861564f, 0.03564440f, -0.05993433f, 0.05050066f, 
    -0.30356264f, 0.01091747f, -0.09026004f, 0.12865786f, 0.15396568f, -0.07087082f, -0.01853344f, 0.05187205f, 
    0.03730803f, 0.09087516f, -0.07707936f, -0.12644927f, -0.14728343f, -0.21915385f, 0.06129498f, 0.16426808f, 
    0.02250159f, 0.06650294f, 0.08893020f, 0.00427839f, -0.06658133f, -0.14328185f, 0.04004015f, 0.12718706f, 
    -0.06025275f, 0.09556169f, -0.04532951f, 0.10749758f, 0.08891156f, -0.03718024f, 0.03345981f, 0.00447120f, 
    -0.03412108f, 0.02462371f, 0.04936951f, -0.00230479f, 0.22341569f, -0.08093141f, 0.00710612f, -0.00200797f, 
    -0.07855397f, 0.01549026f, -0.01180629f, 0.01562279f, 0.04332268f, -0.00265557f, -0.03430822f, -0.07516026f, 
    -0.06227149f, -0.05072246f, -0.04732565f, -0.24532771f, -0.00235453f, 0.04260935f, -0.02938581f, 0.01669895f, 
    -0.09900109f, 0.03236565f, 0.05616570f, 0.02691000f, 0.23836613f, -0.23115526f, -0.04622609f, -0.20404771f, 
    -0.05681415f, 0.01493913f, 0.02311445f, -0.03239357f, -0.00808808f, 0.00378962f, -0.00556951f, 0.08228417f, 
    0.15513240f, -0.16493231f, -0.07818273f, -0.26140159f, -0.05928317f, -0.06107170f, -0.01657577f, 0.06646213f, 
    0.01693025f, -0.04321044f, 0.05434253f, 0.00267281f, 0.06398386f, -0.01766527f, 0.18349555f, 0.07384024f, 
    -0.08339097f, 0.05292628f, -0.03019312f, -0.06213886f, -0.05708899f, -0.01419625f, 0.08242320f, 0.13069721f, 
    0.11506162f, 0.18576041f, 0.11244196f, -0.10139767f, 0.10670233f, 0.02357593f, 0.19978262f, -0.02435503f, 
    0.06099484f, 0.00165483f, -0.00853392f, -0.03907092f, -0.03628868f, 0.26487264f, -0.02285986f, 0.03981742f, 
    -0.07697056f, 0.02945826f, 0.09935236f, 0.01041651f, 0.11302499f, -0.03434306f, -0.01016484f, -0.06123328f, 
    0.18553005f, 0.13215832f, -0.01541893f, -0.04784423f, 0.14145988f, 0.08400188f, -0.07197832f, 0.06887914f, 
    0.03628924f, 0.05451044f, -0.10570800f, -0.00620791f, -0.20943652f, 0.23884055f, -0.10882130f, -0.01873852f, 
    0.23426630f, 0.15064414f, -0.08753718f, 0.09535998f, -0.03643633f, 0.08031568f, 0.06217339f, 0.08337813f, 
    0.24876830f, 0.04890465f, 0.01174591f, -0.25126743f, 0.00121450f, -0.17726018f, 0.03583885f, 0.05767211f, 
    0.03065646f, -0.05024709f, -0.03419686f, 0.09115810f, 0.41999805f, -0.12638123f, -0.22144893f, -0.16465616f, 
    -0.00198730f, -0.14208174f, -0.04999738f, 0.10641430f, 0.14283301f, -0.05676191f, 0.02814496f, 0.04124028f, 
    -0.13816151f, -0.05248198f, 0.04839868f, 0.21470101f, 0.03108628f, -0.09101243f, 0.10526755f, 0.02751606f, 
    -0.03317805f, -0.00409489f, -0.06599611f, 0.03304078f, 0.07938706f, -0.13494912f, 0.13452764f, 0.05305091f, 
    0.07901013f, 0.00878741f, 0.00139979f, -0.01205861f, 0.02015709f, -0.03324175f, -0.02893945f, -0.02810372f, 
    0.11799749f, -0.07295345f, -0.03154963f, 0.04903189f, 0.02085885f, 0.04042747f, -0.02030502f, 0.09411343f, 
    -0.06170940f, -0.06924014f, 0.07519531f, 0.11308413f, 0.01001077f, 0.02716226f, 0.12908897f, -0.16235800f, 
    -0.02680491f, 0.01513620f, -0.02010621f, -0.02938495f, 0.06293222f, 0.10969669f, -0.02979541f, -0.03790218f, 
    0.19250000f, -0.21876624f, 0.22024013f, -0.22241920f, 0.05625719f, -0.02051742f, -0.04760350f, 0.07947681f, 
    0.05040962f, 0.00530652f, -0.01633500f, 0.00363784f, -0.30735412f, 0.19891927f, 0.16225135f, -0.02016045f, 
    0.20206697f, -0.07454431f, 0.02774353f, 0.03371155f, 0.03088579f, -0.02256520f, 0.05056421f, 0.06797511f, 
    0.02718331f, 0.09268785f, 0.06790980f, 0.22584714f, -0.03158242f, 0.02300293f, -0.00099225f, 0.01934154f, 
    0.17007555f, -0.08512275f, 0.00445771f, -0.11990738f, -0.21513161f, 0.18484753f, 0.01885995f, 0.07204705f, 
    0.02216879f, 0.04475398f, -0.04668125f, 0.04618293f, -0.00621617f, -0.09890410f, 0.12364250f, -0.09427921f, 
    -0.04694625f, 0.10947525f, -0.11106283f, 0.16019998f, 0.00942353f, 0.05853171f, -0.07063786f, -0.04787147f, 
    0.07195557f, 0.04872037f, -0.07082827f, -0.01553019f, 0.00813256f, 0.00593096f, 0.09558275f, -0.08063668f, 
    -0.05546371f, -0.07251186f, 0.15798645f, 0.06757620f, -0.00702311f, 0.04350759f, 0.03449863f, -0.18479373f, 
    -0.01587686f, -0.01829992f, -0.21928006f, 0.30748209f, -0.02221828f, -0.02296458f, -0.07525579f, 0.01419890f, 
    0.01036110f, 0.02731221f, -0.06019661f, -0.00284205f, 0.12413006f, 0.07725783f, 0.07776545f, -0.13129543f, 
    0.07214868f, 0.08451058f, 0.12350324f, -0.00057581f, 0.06094907f, 0.10265876f, 0.09332141f, -0.00422667f, 
    -0.00779310f, 0.06063732f, -0.05272822f, 0.05954527f, -0.12032303f, 0.08957531f, -0.08066560f, -0.07093626f, 
    0.06370762f, -0.01646740f, -0.04405034f, 0.05536979f, 0.25468352f, -0.02322835f, 0.11068708f, 0.05478731f, 
    0.02433697f, -0.09565197f, 0.06871136f, -0.01188693f, -0.03666370f, 0.05400005f, 0.09983337f, 0.12974450f, 
    -0.33246657f, -0.03620121f, -0.08957797f, 0.17582135f, -0.03181183f, 0.00484617f, 0.04444633f, 0.00222129f, 
    0.00078070f, 0.01378896f, 0.10060229f, 0.08543342f, -0.41236991f, 0.20233423f, 0.04868174f, 0.02754709f, 
    0.05341100f, 0.09132733f, -0.02050243f, -0.05581053f, -0.08946257f, 0.04664492f, 0.13303263f, 0.04373927f, 
    0.08168396f, 0.20075561f, 0.18853319f, 0.14206213f, 0.00729574f, 0.05526571f, 0.03717034f, 0.06974733f, 
    0.00584459f, -0.04146976f, -0.02146137f, -0.03142331f, 0.10272534f, -0.19869700f, -0.05006508f, 0.15131778f, 
    -0.03572696f, -0.00594408f, -0.03730422f, 0.00641841f, 0.05512949f, -0.01023941f, 0.12129255f, 0.00223455f, 
    0.18532801f, 0.02050016f, 0.03579416f, -0.17053796f, -0.06877372f, 0.02710498f, -0.02732100f, -0.00456673f, 
    -0.01087716f, 0.03386217f, -0.08963913f, 0.00525926f, 0.15470517f, -0.15991333f, 0.04224709f, 0.29869640f, 
    -0.00353058f, -0.08716821f, 0.01495232f, 0.05486333f, 0.02985450f, 0.10309209f, -0.13417000f, -0.10857408f, 
    -0.12587273f, -0.21349022f, -0.03678709f, 0.05574383f, -0.01651038f, -0.08169927f, 0.01214239f, 0.03113957f, 
    0.06346093f, 0.02861310f, -0.04523479f, -0.01457184f, -0.42929149f, 0.19584039f, 0.11208650f, -0.09395766f, 
    0.22019222f, -0.01517814f, 0.09666431f, -0.08988734f, -0.00336899f, 0.03948505f, 0.05945773f, 0.04660368f, 
    0.06272548f, 0.24123420f, 0.15080036f, 0.11470756f, -0.06915212f, -0.12471890f, 0.05586304f, 0.00122850f, 
    0.16136700f, -0.05144603f, 0.08461186f, -0.04569549f, -0.14358602f, 0.23048510f, -0.04713016f, -0.07342852f, 
    0.06946255f, 0.15728197f, 0.06565475f, -0.07767189f, 0.11582988f, 0.05827195f, -0.00806640f, 0.01991824f, 
    0.20329075f, 0.08193538f, -0.04389569f, 0.03181913f, 0.06126761f, -0.04644381f, 0.06314049f, -0.08511459f, 
    0.05909093f, 0.01538131f, -0.00019282f, -0.02584625f, -0.18419777f, -0.08982380f, -0.11507539f, 0.14444730f, 
    -0.02194555f, 0.13608328f, -0.00472720f, 0.03326102f, 0.04566918f, -0.04443836f, -0.00497011f, -0.01844666f, 
    0.03463125f, -0.20119177f, -0.07520493f, 0.08126391f, -0.11985385f, 0.10109919f, -0.10909714f, 0.04131062f, 
    0.01527665f, 0.01700049f, -0.00502197f, -0.02078375f, 0.14961578f, -0.02515327f, 0.03121257f, 0.05983621f, 
    0.02810003f, 0.02629798f, -0.03349583f, 0.08956833f, -0.01232368f, -0.16299470f, -0.00296631f, -0.10258281f, 
    -0.09811274f, -0.00857328f, 0.06189809f, 0.06918012f, -0.02532182f, -0.08742084f, 0.02671235f, 0.01955512f, 
    0.09755789f, 0.04496608f, -0.00734683f, 0.02612394f, 0.03421901f, 0.09757193f, 0.44675109f, 0.08535045f, 
    -0.07858893f, 0.03330858f, 0.05372600f, 0.00147638f, -0.10677490f, -0.09775732f, -0.03668187f, -0.02831596f, 
    -0.17084226f, 0.03988476f, -0.05554585f, 0.05131249f, -0.05672982f, 0.10069419f, 0.04840473f, -0.12564714f, 
    0.06425701f, 0.02824584f, 0.03177887f, 0.06285877f, -0.55083400f, 0.20962758f, 0.30921620f, 0.04967405f, 
    0.08054539f, -0.02253751f, 0.08220783f, -0.05281270f, -0.03745192f, 0.06015509f, 0.04608588f, 0.06712022f, 
    0.09850785f, 0.42311850f, -0.04497598f, 0.18737490f, -0.13208154f, -0.01806683f, -0.09089656f, 0.01343416f, 
    -0.02408466f, -0.05410531f, -0.03135809f, 0.14301372f, -0.03489945f, -0.00421012f, -0.11379100f, 0.06379166f, 
    0.19161537f, 0.16160339f, 0.03216348f, -0.11789878f, 0.02463618f, -0.02560353f, 0.07053452f, -0.04906192f, 
    -0.02718918f, 0.22135694f, -0.19471546f, -0.06802938f, 0.10811746f, 0.03164117f, 0.00416119f, 0.05004165f, 
    0.08855474f, 0.01537870f, -0.06798702f, 0.09523662f, 0.19220370f, -0.14928956f, 0.24776678f, 0.35653013f, 
    0.22655919f, -0.02167499f, 0.01234984f, 0.05096140f, -0.00074601f, -0.00458010f, 0.21598187f, 0.12995836f, 
    -0.01359121f, -0.21150891f, 0.08503591f, 0.04820036f, 0.02292300f, 0.01089884f, 0.01073138f, -0.12588204f, 
    -0.08083632f, 0.08576265f, 0.03284295f, -0.06374498f, 0.18555142f, -0.11529126f, -0.24150437f, -0.30966106f, 
    -0.12681989f, -0.07383832f, 0.00871640f, 0.23919080f, -0.10409568f, -0.04465776f, -0.08239198f, 0.05576320f, 
    -0.03943953f, 0.01208829f, -0.12232343f, -0.11125881f, 0.16045758f, -0.10049399f, -0.03149061f, -0.06070337f, 
    -0.06338164f, 0.10215832f, 0.08064099f, 0.03202514f, 0.11758518f, 0.06116829f, 0.09511554f, 0.12306706f, 
    -0.08426740f, -0.04602988f, -0.00707745f, 0.16553701f, 0.03428915f, -0.03398658f, 0.01619969f, 0.08683887f, 
    0.00731330f, 0.06314883f, 0.01412528f, -0.07175724f, -0.01939668f, -0.05823884f, 0.02500888f, 0.14052810f, 
    -0.03771497f, 0.00831183f, 0.13323456f, 0.12918019f, 0.05245608f, -0.05111982f, 0.10599619f, 0.06712056f, 
    -0.00654760f, -0.12208094f, -0.03549998f, -0.08553399f, -0.09033095f, 0.00877084f, 0.07639105f, 0.11926484f, 
    -0.35338295f, -0.34199679f, -0.00402960f, -0.05639012f, 0.13312127f, -0.01451027f, 0.07631431f, 0.07202558f, 
    0.14816543f, 0.07843900f, -0.11860169f, -0.01019871f, -0.03326537f, -0.02243118f, 0.03961799f, -0.00604028f, 
    -0.03883653f, -0.05683349f, 0.08631962f, -0.08876339f, 0.08218103f, -0.09179335f, -0.09700141f, 0.06400624f, 
    -0.16209087f, -0.10850561f, -0.26584992f, -0.38102868f, 0.07393248f, -0.02946478f, 0.01441172f, -0.10535811f, 
    0.03976110f, -0.00317351f, -0.11920946f, 0.02779282f, 0.14999695f, 0.24581291f, -0.38815272f, -0.09997319f, 
    -0.02208359f, -0.03305653f, -0.00400439f, -0.05099571f, -0.00828278f, 0.02977885f, 0.03321590f, -0.13098483f, 
    0.22765082f, 0.16852741f, 0.19569135f, -0.02363000f, -0.04533409f, -0.05161392f, 0.00036537f, 0.13061753f, 
    -0.09937295f, -0.00670464f, -0.01845153f, -0.07219478f, 0.16667415f, -0.12901109f, 0.00501365f, -0.02870275f, 
    -0.26255479f, 0.01317651f, 0.03849841f, -0.01129202f, 0.01965798f, 0.06977897f, 0.03943672f, 0.07664949f, 
    0.07864032f, -0.37015605f, -0.09641049f, 0.06715839f, 0.07111795f, 0.02401786f, -0.00932406f, 0.07871036f, 
    -0.11942270f, 0.03120765f, 0.06842139f, 0.05429416f, 0.23905306f, 0.11695313f, 0.09721699f, -0.09164004f, 
    0.04489770f, -0.05535058f, 0.01978142f, -0.02323215f, -0.00092877f, -0.05932759f, -0.08012668f, 0.00006961f, 
    0.18705605f, 0.00866570f, -0.07851865f, 0.10627670f, 0.06676093f, -0.04090152f, -0.04949712f, -0.04379897f, 
    -0.00316659f, 0.01720751f, 0.07407387f, 0.05610404f, -0.18911859f, 0.43370870f, -0.12660718f, -0.39249226f, 
    0.15773679f, -0.04431131f, 0.07301901f, 0.00154962f, -0.00682273f, -0.01439263f, 0.01421679f, -0.13343447f, 
    0.33583817f, 0.13342921f, 0.11786178f, -0.13501479f, 0.01584245f, 0.13248675f, -0.05972444f, -0.00421097f, 
    0.00291487f, 0.02077560f, 0.07870146f, 0.05142293f, 0.24036032f, -0.04741604f, -0.01587142f, 0.09063550f, 
    0.06459098f, 0.05798887f, -0.03812620f, -0.01319312f, 0.07623931f, -0.04421917f, 0.11696392f, -0.15166953f, 
    0.00880855f, -0.20888120f, 0.02561717f, 0.10891510f, -0.04760894f, 0.03790312f, 0.00785422f, -0.02727002f, 
    -0.01943780f, -0.06765419f, -0.16842294f, -0.04166546f, -0.12829012f, 0.33539256f, 0.05359776f, 0.08114237f, 
    0.07818642f, -0.05358561f, -0.04103165f, 0.06522984f, -0.05302666f, -0.05752656f, -0.00110681f, -0.04879682f, 
    -0.04369406f, 0.09082260f, 0.00016434f, 0.10586690f, 0.05399754f, -0.00780303f, -0.01525305f, -0.07588169f, 
    0.06473870f, -0.01250333f, -0.00838951f, 0.00553202f, 0.18367510f, 0.09250370f, 0.02251336f, -0.03100461f, 
    0.02280452f, -0.02996534f, 0.01773271f, 0.01117262f, -0.00313459f, 0.08060703f, -0.05784120f, -0.26503468f, 
    0.03037386f, 0.14956070f, -0.01727291f, -0.09167110f, 0.02823595f, 0.05424412f, 0.09524500f, -0.00405742f, 
    0.04338733f, -0.10126186f, 0.09346751f, 0.11170396f, -0.02519030f, 0.05804385f, 0.01939257f, -0.00059860f, 
    -0.01748745f, -0.08438206f, 0.06397572f, -0.03472466f, 0.03305079f, 0.15498973f, 0.05058031f, 0.06991714f, 
    0.09677513f, 0.02849363f, -0.19236347f, -0.06700753f, 0.02484776f, -0.02813769f, -0.08145642f, -0.10560380f, 
    -0.05576030f, -0.07256120f, 0.03895161f, -0.06787681f, 0.31076410f, -0.40711516f, -0.20394114f, 0.23929605f, 
    -0.06725646f, -0.08540291f, -0.02323642f, -0.09019802f, 0.07606978f, 0.05848394f, -0.03492243f, 0.07253860f, 
    -0.08269757f, 0.07046968f, 0.05336303f, 0.01426619f, 0.09554315f, 0.06827567f, 0.10954523f, 0.17308722f, 
    -0.03714562f, 0.00492073f, -0.05087532f, 0.06399088f, 0.13012798f, -0.06367087f, -0.10643975f, -0.07688352f, 
    0.12591349f, 0.11695599f, -0.02892502f, -0.01356087f, 0.00964155f, -0.00251471f, 0.10577938f, 0.06976792f, 
    -0.11382905f, 0.08632361f, 0.05618871f, 0.03944663f, 0.09145873f, 0.03393458f, -0.01546964f, -0.11206238f, 
    -0.02596740f, 0.05894268f, 0.03222505f, 0.09904352f, 0.28847760f, 0.09502921f, 0.03620353f, -0.08942121f, 
    -0.10338482f, -0.05607657f, 0.02999032f, -0.03419023f, 0.01091713f, -0.17455228f, -0.02822733f, -0.01861517f, 
    -0.33445591f, 0.00889734f, -0.02739273f, 0.22229877f, 0.08302312f, -0.14770216f, -0.08324815f, -0.09020001f, 
    0.11578602f, -0.05133495f, -0.08971621f, -0.08721521f, 0.46295696f, 0.05968984f, 0.36217093f, 0.22654684f, 
    -0.04020270f, 0.12668131f, 0.05075309f, 0.15266761f, 0.08552463f, -0.03176339f, -0.01926652f, 0.00218663f, 
    0.16956377f, -0.03677111f, 0.02609170f, -0.04937221f, -0.12027199f, 0.05209983f, 0.17032662f, -0.01271074f, 
    -0.08320415f, -0.08040703f, -0.05030624f, -0.05285307f, -0.00232262f, -0.02135967f, -0.01055049f, -0.12806030f, 
    -0.02700916f, 0.10707977f, -0.00872168f, 0.13417281f, -0.01175179f, 0.00956609f, 0.01755576f, 0.05926072f, 
    0.05883541f, 0.06955063f, -0.06377624f, 0.26798549f, 0.17402254f, 0.08759693f, -0.12705560f, 0.01059392f, 
    0.02370464f, 0.08099781f, 0.09090178f, -0.03401354f, 0.09915068f, -0.06838847f, -0.04997705f, 0.01996251f, 
    0.00061207f, 0.05554837f, -0.06140369f, 0.03447952f, 0.14566241f, -0.02613584f, 0.01472402f, 0.01971769f, 
    -0.08637132f, -0.02516011f, 0.02655900f, 0.09917604f, 0.15762749f, 0.04391416f, 0.02576880f, 0.04841644f, 
    0.05517766f, 0.12817037f, 0.00767078f, -0.04893392f, -0.14709537f, -0.11436759f, 0.05306145f, -0.02104636f, 
    -0.04429089f, -0.05279910f, -0.11559777f, -0.04104572f, 0.12878560f, -0.04761332f, -0.03370538f, -0.01421071f, 
    -0.12173384f, -0.09370141f, -0.07102624f, 0.01685614f, -0.07336219f, -0.16083097f, -0.04585613f, 0.03819154f, 
    -0.15876424f, -0.04262330f, -0.00137674f, -0.05185925f, -0.00233778f, 0.13494611f, -0.19884932f, 0.13697121f, 
    0.19753650f, 0.15445711f, 0.00118429f, -0.08165427f, -0.01783938f, -0.08906141f, 0.01466242f, 0.01203087f, 
    -0.18596974f, -0.13370830f, 0.00703636f, 0.17080221f, 0.10309155f, -0.18446040f, 0.09104796f, 0.11224779f, 
    -0.05567764f, 0.08229323f, 0.03006811f, 0.04566363f, 0.30208018f, -0.02072440f, -0.09876043f, 0.10196943f, 
    0.06592885f, 0.00261987f, 0.11512164f, -0.03692432f, 0.04445801f, 0.10634592f, -0.09576873f, -0.18723461f, 
    0.13571215f, 0.17934734f, -0.04464686f, -0.01172371f, -0.00038940f, -0.07590817f, -0.21750727f, -0.09503551f, 
    -0.11294211f, 0.01404975f, 0.09380395f, 0.06652759f, 0.11106028f, 0.05152005f, -0.03835730f, 0.01417125f, 
    0.00973872f, 0.08081224f, 0.05083290f, 0.00118529f, 0.04833477f, -0.04605197f, 0.07489766f, 0.05923698f, 
    0.09922592f, -0.02039146f, -0.05812113f, 0.11076066f, 0.06835257f, 0.03539535f, 0.03289468f, -0.10228723f, 
    -0.04077658f, 0.04556108f, 0.09344295f, 0.07128098f, 0.23303173f, 0.10255886f, -0.03481105f, -0.21307279f, 
    0.08564622f, -0.10400546f, 0.00384684f, -0.01524646f, -0.01873638f, -0.06807031f, -0.04920958f, -0.03931666f, 
    -0.19065663f, 0.21741302f, -0.00937985f, 0.22324361f, 0.16223598f, 0.01994847f, 0.00681216f, -0.01965308f, 
    0.13320956f, -0.12093858f, -0.08599551f, 0.03716217f, -0.08842976f, 0.07718798f, 0.15660453f, -0.06167787f, 
    0.15574650f, 0.10791340f, 0.07978815f, 0.04564184f, 0.03222401f, -0.01011414f, 0.13903672f, 0.03812147f, 
    0.27897900f, 0.08262426f, -0.03279274f, -0.04934835f, -0.00870059f, 0.09072580f, -0.06491218f, -0.16428769f, 
    -0.01758684f, -0.04610328f, 0.02289322f, -0.04302744f, 0.40564463f, -0.18897794f, -0.06696556f, -0.12224732f, 
    -0.14856806f, 0.14160758f, 0.02009641f, 0.12209807f, -0.08293260f, 0.09823696f, -0.05949747f, 0.00252695f, 
    -0.05460804f, -0.01270277f, 0.05857592f, 0.08173807f, 0.12298307f, 0.14099947f, -0.13241540f, -0.06083884f, 
    -0.15850358f, 0.14169234f, -0.04070809f, 0.07118817f, 0.00834174f, 0.09865601f, 0.07449853f, 0.15991248f, 
    -0.05291401f, -0.03094198f, -0.03675302f, 0.08556073f, 0.09673147f, -0.01096195f, -0.09761280f, 0.07901344f, 
    -0.09248968f, 0.09851939f, -0.03112186f, 0.13452022f, 0.10232293f, 0.06954933f, 0.08298413f, 0.07157189f, 
    0.01745050f, -0.00447185f, -0.00574519f, -0.01855012f, 0.14794542f, -0.06453796f, 0.02420704f, -0.12644576f, 
    -0.13390298f, -0.10116637f, -0.05023212f, -0.11030938f, -0.15535422f, 0.04302689f, 0.09216946f, 0.17518787f, 
    -0.16434035f, -0.00156738f, -0.15817994f, -0.14602020f, 0.13473056f, -0.12481028f, 0.06415303f, 0.08515658f, 
    -0.09277637f, 0.02603797f, 0.05349727f, 0.02224481f, -0.10788502f, 0.01204514f, -0.02429635f, 0.17976001f, 
    -0.00770525f, 0.03390371f, 0.02152004f, -0.10070025f, 0.03552110f, 0.03600010f, -0.10873038f, -0.01257544f, 
    -0.02377212f, -0.02973586f, -0.16914621f, -0.02135597f, 0.14825371f, -0.08104791f, 0.04852299f, -0.04355131f, 
    -0.01418936f, -0.06450843f, 0.03912865f, -0.07949112f, 0.35303378f, -0.11568715f, -0.33995879f, 0.03829273f, 
    0.07971510f, -0.02967955f, -0.05984174f, -0.13008191f, 0.12493160f, 0.10206709f, -0.01564437f, -0.01315571f, 
    0.26065907f, 0.16402966f, 0.10495140f, -0.14788358f, 0.03805748f, -0.15651624f, -0.12894681f, 0.08216370f, 
    0.00274914f, -0.04080860f, -0.02251405f, -0.07461425f, 0.49669769f, -0.08869036f, -0.04343589f, 0.07654001f, 
    0.03185411f, -0.01866830f, 0.11078579f, -0.02062778f, 0.00354226f, -0.02432331f, -0.06976473f, 0.07114170f, 
    0.07519539f, 0.00798398f, -0.00912482f, 0.05368342f, -0.08432186f, 0.08006646f, -0.13769557f, 0.03828639f, 
    0.03358695f, 0.05429732f, 0.11475595f, 0.08187905f, 0.23066387f, -0.03406331f, -0.09427317f, -0.15031986f, 
    0.09487386f, 0.02580457f, 0.07381494f, -0.10022619f, 0.09081805f, 0.14378159f, -0.04732542f, 0.01200028f, 
    -0.01713196f, 0.27528554f, 0.02868195f, -0.31013718f, -0.04925363f, -0.04966306f, 0.05101825f, 0.13251756f, 
    0.04983174f, -0.10106356f, -0.06809933f, 0.00429111f, 0.09310916f, -0.11582870f, 0.08464640f, 0.18068749f, 
    0.18814734f, 0.06283171f, -0.04233815f, 0.05234351f, -0.03937813f, -0.01929943f, 0.07346635f, 0.05777333f, 
    -0.16999049f, 0.15600133f, -0.29085907f, -0.03212853f, 0.03296436f, 0.16503675f, -0.05040582f, -0.13426886f, 
    -0.06056423f, 0.02986664f, 0.01356899f, 0.00951320f, 0.21581838f, -0.14172544f, -0.18022244f, 0.04205579f, 
    -0.21672547f, 0.00434994f, -0.08227113f, 0.07678965f, 0.06665948f, 0.01160737f, -0.09195300f, 0.05044499f, 
    0.21386074f, 0.06061772f, 0.04968975f, -0.06808091f, 0.05102098f, -0.01157388f, 0.09030464f, 0.01971865f, 
    -0.00361931f, 0.01579167f, 0.08651067f, 0.08570494f, 0.19334053f, -0.10551354f, 0.07996791f, 0.06062721f, 
    -0.02201087f, -0.06959207f, -0.01369536f, 0.06577386f, -0.08723595f, -0.07411287f, 0.04868729f, 0.04349043f, 
    -0.14737211f, 0.00864623f, 0.20091476f, -0.11359250f, -0.00451137f, -0.18481141f, 0.17444673f, 0.07680409f, 
    0.03250764f, -0.09133665f, 0.04129418f, -0.00270014f, 0.20712194f, 0.16654080f, 0.07190514f, -0.04519365f, 
    0.04928242f, -0.05652674f, -0.09180714f, 0.00961169f, 0.00740559f, -0.02492163f, 0.10811547f, -0.08758790f, 
    -0.12858666f, -0.28242505f, 0.00643486f, 0.04201731f, 0.16785455f, -0.04309592f, 0.02115788f, 0.00227964f, 
    0.04675959f, 0.02063282f, -0.02741028f, -0.06689924f, -0.20106161f, 0.08735537f, -0.00559950f, 0.10401791f, 
    -0.06786297f, -0.05804641f, -0.10555290f, 0.10722179f, -0.04273229f, -0.18599074f, -0.03102436f, 0.07856950f, 
    -0.10240906f, -0.08422896f, -0.11472075f, -0.44417888f, 0.08996518f, 0.10105585f, 0.18303719f, 0.14502804f, 
    0.08671956f, 0.20586275f, 0.08866282f, -0.05138165f, 0.01292096f, 0.18264638f, -0.53119421f, -0.15888399f, 
    -0.12787417f, 0.11501019f, 0.04181204f, -0.06403986f, -0.10762732f, 0.05017065f, 0.10467464f, 0.03990420f, 
    0.12693983f, -0.02189216f, 0.11930598f, 0.17442161f, -0.06917224f, -0.15299022f, -0.04316279f, 0.04874078f, 
    0.10199474f, 0.00107424f, -0.07439291f, -0.14178902f, 0.31778008f, -0.10622425f, -0.11655890f, 0.14669307f, 
    -0.12329994f, 0.07654990f, -0.03915881f, 0.12360144f, -0.06855659f, 0.00219740f, 0.01163688f, -0.07219529f, 
    -0.06768969f, -0.00406693f, 0.02465828f, 0.00965373f, 0.00421529f, -0.05980768f, -0.00261261f, -0.02240235f, 
    -0.04727731f, -0.00158985f, -0.06985079f, 0.00678139f, -0.07189830f, 0.02812278f, 0.01205726f, 0.00553183f, 
    -0.03379097f, -0.03380807f, -0.05104909f, 0.04456372f, -0.04980772f, -0.05006738f, -0.01542624f, -0.01877369f, 
    -0.02003596f, 0.04545503f, -0.07129315f, 0.04727856f, -0.01461239f, -0.06899914f, -0.00165050f, 0.01222352f, 
    -0.00359115f, -0.08174681f, 0.05749565f, -0.01704344f, -0.02472131f, 0.06062833f, -0.06599018f, -0.00735649f, 
    -0.01030165f, -0.01318201f, 0.03269806f, -0.06322023f, 0.01512411f, 0.05686429f, -0.04046762f, 0.04840393f, 
    0.04260720f, -0.03796254f, -0.06784450f, 0.06447860f, 0.03446830f, -0.00178788f, 0.04848263f, 0.04020666f, 
    -0.07490979f, 0.00922072f, -0.04835531f, 0.00121113f, 0.05369768f, -0.00660046f, -0.07085916f, 0.04646841f, 
    0.01320711f, -0.05342377f, 0.03259438f, 0.05165086f, -0.05429345f, -0.06332406f, 0.01034052f, 0.02276659f, 
    0.04045781f, -0.02148674f, 0.02777905f, -0.00364604f, 0.04628315f, -0.03825274f, 0.00074216f, 0.06001918f, 
    -0.05566822f, -0.03744169f, -0.00747235f, 0.00667025f, -0.00524439f, -0.04014937f, 0.05003788f, -0.02814388f, 
    -0.03266725f, 0.01301811f, 0.01759166f, -0.00196881f, -0.05207890f, -0.06176158f, 0.05633413f, -0.07221855f, 
    0.01677287f, 0.05624590f, -0.04585898f, 0.00238610f, -0.00522220f, 0.00359425f, -0.03106289f, -0.02290124f, 
    0.03398847f, 0.01197545f, 0.00205159f, -0.05347928f, 0.02097716f, -0.02075704f, 0.06654452f, 0.00731240f, 
    0.01189874f, -0.01539476f, -0.03085447f, -0.02596345f, -0.01596271f, -0.01896724f, -0.06753007f, -0.06137935f, 
    -0.05185904f, -0.03398893f, -0.07367470f, -0.01704768f, -0.06517814f, 0.00950412f, 0.02160437f, 0.01253095f, 
    -0.00412225f, 0.04649676f, 0.01866723f, 0.05151648f, 0.02089809f, 0.03036870f, -0.04367269f, -0.01993112f, 
    -0.07450040f, 0.01067180f, -0.05533099f, -0.01583469f, 0.03167850f, 0.02898553f, -0.03168001f, -0.05928368f, 
    0.00327142f, -0.00996947f, 0.04623730f, -0.01162384f, -0.02885281f, -0.01136993f, -0.03597929f, -0.00173585f, 
    -0.06864938f, 0.00601935f, 0.04398140f, -0.00661606f, -0.07757872f, -0.04592486f, -0.07063504f, 0.02404167f, 
    -0.04386997f, 0.03669558f, -0.02263151f, 0.05290462f, 0.04679957f, -0.02319937f, -0.06093059f, 0.03102763f, 
    0.01992296f, -0.04654970f, 0.00202551f, -0.06037057f, -0.07209267f, 0.06269048f, 0.05854859f, -0.03967481f, 
    0.04255011f, -0.07782745f, 0.05447948f, -0.00716036f, 0.02534368f, 0.02940145f, -0.02142340f, 0.00018722f, 
    -0.00693141f, -0.02552693f, -0.07477304f, 0.00803921f, 0.03142241f, -0.04338409f, 0.05360061f, -0.02180571f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03304482f, 0.08214641f, 0.05344014f, 0.08815836f, 0.02367435f, 0.10897320f, 0.17369322f, 0.00592954f, 
    -0.06420782f, 0.07335737f, 0.11974517f, 0.08383863f, -0.05463902f, 0.06126908f, 0.08502204f, 0.05200782f, 
    0.06976400f, 0.05922923f, 0.06738758f, 0.00230864f, 0.05542926f, -0.01295958f, 0.04993304f, 0.04495919f, 
    -0.00954679f, -0.03534975f, 0.13259186f, -0.06301876f, 0.11522697f, -0.02704114f, 0.00843985f, 0.01052188f, 
    -0.04281706f, -0.00158351f, -0.04174707f, 0.09611648f, -0.04874039f, 0.01415629f, 0.09463262f, 0.07882156f, 
    -0.00674788f, -0.01469996f, 0.01031488f, -0.07541291f, 0.05431917f, 0.03887238f, -0.03583508f, -0.06086221f, 
    0.04872997f, -0.01675298f, 0.17237237f, 0.14812179f, 0.04112428f, -0.03309762f, -0.12820336f, -0.01859309f, 
    -0.02554406f, -0.01926671f, -0.03421511f, 0.06185886f, 0.03140159f, -0.01664144f, 0.01372977f, -0.02946709f, 
    -0.02186669f, 0.02477359f, -0.02524111f, 0.10830677f, 0.10444593f, -0.07236931f, -0.03702893f, -0.05404787f, 
    -0.05168686f, 0.01519880f, 0.06897990f, -0.05512581f, -0.07995150f, 0.07906861f, -0.00933148f, 0.12092206f, 
    0.04391256f, 0.01745238f, 0.01204975f, -0.05410952f, 0.05381925f, 0.02450666f, -0.11225311f, 0.03472704f, 
    0.04642766f, -0.01524822f, 0.03929954f, 0.09658208f, 0.02089286f, 0.02936845f, 0.07348100f, -0.00279251f, 
    0.05248564f, 0.00502034f, 0.04486160f, -0.08153705f, -0.10051899f, -0.06480587f, 0.01176800f, -0.02391119f, 
    -0.05830954f, 0.01130603f, -0.04216394f, 0.05820007f, -0.00052780f, 0.03804163f, -0.01601749f, 0.00889704f, 
    0.03497959f, -0.04832662f, 0.03967147f, -0.00018686f, 0.15100735f, 0.05940091f, 0.10668704f, 0.10138460f, 
    -0.05270397f, -0.09000889f, 0.09670478f, 0.01676308f, -0.04131927f, 0.02536398f, 0.07539640f, -0.03259087f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.07450606f, 0.28118268f, -0.36368108f, -0.02441978f, 0.02308762f, -0.14450856f, -0.20162626f, 0.06444078f, 
    0.10530555f, -0.47701737f, -0.13410266f, -0.06555134f, -0.04354876f, 0.09430653f, -0.54839963f, -0.16784589f, 
    -0.12249056f, 0.00586474f, 0.12766472f, -0.44575652f, -0.12123720f, 0.05164124f, 0.27233487f, -0.09031162f, 
    -0.62813419f, 0.01494361f, -0.38220903f, 0.43061104f, 0.06847026f, 0.06153299f, -0.03536137f, 0.17312022f, 
    -0.22084905f, 0.19963014f, -0.06235755f, 0.21470994f, -0.01306981f, 0.07003233f, 0.00237582f, -0.01755201f, 
    -0.17068604f, 0.07719629f, 0.06939367f, 0.00739900f, 0.06716942f, 0.10883914f, 0.01422047f, 0.06089483f, 
    0.12052822f, -0.41150421f, -0.24510953f, -0.27951530f, 0.07416422f, 0.28917366f, 0.14905864f, 0.17855826f, 
    0.07557452f, 0.33412576f, -0.07927734f, -0.09949575f, 0.04204004f, -0.05636314f, 0.29192013f, -0.40223140f, 
    0.06276026f, -0.00745924f, 0.07213868f, 0.08324745f, -0.17122640f, -0.06595925f, 0.20613083f, 0.16129032f, 
    0.06665605f, 0.11613595f, -0.16983393f, 0.18582743f, 0.25791049f, -0.50631398f, 0.07756305f, -0.07500537f, 
    -0.28199536f, 0.09502864f, 0.04911713f, 0.01279647f, -0.11582033f, -0.04322249f, -0.12844175f, -0.08652920f, 
    -0.01929885f, -0.08519081f, -0.09882960f, -0.11817675f, -0.23003095f, 0.01104278f, -0.07703783f, 0.19052245f, 
    -0.00956957f, -0.17357506f, 0.06888733f, 0.01076994f, 0.17129481f, 0.03844846f, -0.00328321f, 0.16815573f, 
    0.11981460f, -0.49086842f, -0.01756635f, -0.15503646f, 0.32766926f, -0.01172013f, 0.19570114f, 0.08316783f, 
    0.20917754f, 0.07150310f, -0.00754880f, -0.30287719f, -0.46851102f, 0.06809042f, -0.06618621f, 0.02789921f, 
    -0.23006569f, 0.27454460f, -0.20465904f, -0.17269091f, -0.04923393f, -0.20791182f, -0.23306493f, -0.05864387f, 
    0.25240171f, -0.14793253f, -0.12341783f, -0.24015656f, 0.12490617f, -0.36823678f, 0.17397586f, -0.01515905f, 
    -0.03973184f, -0.08557432f, 0.13440366f, 0.11577619f, -0.07189425f, -0.04471973f, -0.15865439f, -0.02148678f, 
    -0.08740364f, -0.08021985f, 0.03807513f, -0.17339329f, -0.02658566f, 0.16734454f, 0.11797309f, -0.00900491f, 
    0.29805177f, -0.01239966f, -0.20718576f, -0.07145929f, 0.03188352f, -0.01272324f, 0.04369545f, 0.43130520f, 
    -0.34327960f, -0.51205426f, -0.06457233f, 0.07772249f, 0.10313130f, -0.48124319f, 0.11012392f, 0.07027534f, 
    -0.28638676f, -0.02637977f, -0.05935894f, -0.06789333f, -0.13294293f, -0.13290747f, 0.14441416f, -0.06351146f, 
    -0.05258136f, -0.20380194f, 0.11561745f, -0.23397376f, 0.26415896f, -0.37915012f, -0.21215028f, -0.19297467f, 
    0.19935143f, 0.00870045f, 0.08362384f, -0.06313872f, 0.16856584f, 0.05710711f, -0.40167826f, 0.27873185f, 
    -0.00233839f, 0.05316513f, -0.00777628f, -0.43508738f, 0.06706273f, -0.02283905f, 0.03693897f, -0.09842341f, 
    0.16900156f, 0.26250783f, -0.14438820f, -0.30473322f, 0.20035964f, -0.02877686f, 0.07770976f, -0.01865534f, 
    0.19352017f, -0.09044309f, -0.02072793f, 0.11536372f, 0.30826762f, -0.06444246f, 0.11536529f, -0.33685750f, 
    -0.17232816f, 0.00794490f, -0.02243505f, 0.13550600f, 0.15169051f, -0.08269821f, 0.09477716f, -0.09463868f, 
    -0.07834023f, -0.15983859f, 0.15205327f, 0.04577969f, -0.12466015f, -0.04280569f, -0.05304167f, 0.10646059f, 
    -0.08998118f, 0.32702783f, -0.12154453f, 0.22695559f, -0.09731539f, -0.19147825f, 0.22814587f, 0.13843995f, 
    0.01060797f, -0.09799556f, -0.03380825f, -0.21177970f, -0.14542285f, -0.03857985f, 0.29213196f, 0.20101765f, 
    -0.30476350f, -0.12442327f, 0.13119237f, -0.23427425f, 0.22314620f, 0.06307355f, 0.29029268f, -0.09799867f, 
    0.22270077f, -0.15222481f, -0.11901146f, -0.11163148f, -0.23381302f, 0.01514374f, -0.31837389f, 0.08534181f, 
    -0.02114621f, 0.26740655f, -0.24928401f, -0.12839419f, -0.07941520f, -0.42227376f, 0.07128589f, -0.08567724f, 
    0.09208322f, 0.02956199f, 0.05085918f, -0.21236025f, -0.03044313f, -0.38829595f, 0.14385128f, 0.02986438f, 
    0.15355606f, -0.03976588f, -0.13102911f, -0.07402975f, 0.12415136f, 0.03829162f, 0.06573562f, -0.57892579f, 
    0.15874745f, -0.01147207f, 0.02724167f, -0.01176796f, 0.04969548f, -0.26152489f, -0.48063371f, 0.03172197f, 
    0.07224830f, -0.02064550f, 0.00798553f, -0.10176431f, -0.02537135f, 0.09281959f, -0.04930175f, 0.01029032f, 
    0.12098927f, 0.16429032f, -0.03686745f, 0.11172168f, 0.26930413f, -0.09714436f, 0.05006658f, -0.51494992f, 
    0.10368488f, 0.11006188f, -0.01466428f, 0.20439906f, -0.26133874f, -0.02549536f, 0.24426083f, -0.21480037f, 
    0.03523336f, 0.07207256f, -0.06132779f, 0.28586853f, -0.27802795f, -0.08850676f, -0.11041037f, 0.28603184f, 
    0.03075878f, 0.06956226f, 0.09254444f, 0.16733570f, -0.21653181f, -0.47474691f, -0.03496077f, -0.07561485f, 
    -0.32769179f, -0.09499931f, 0.27373818f, 0.17007069f, -0.34337625f, -0.64533556f, 0.14302377f, 0.05853140f, 
    -0.10113094f, -0.01635486f, 0.11662518f, -0.07606824f, -0.08276356f, -0.03401340f, 0.14026748f, 0.12420119f, 
    -0.03339320f, 0.17529072f, 0.05093367f, -0.06400203f, -0.01585531f, 0.05875633f, 0.03576180f, -0.13738677f, 
    0.30990753f, -0.15097675f, -0.46205935f, -0.37373808f, -0.03488506f, 0.15522002f, -0.43156669f, 0.09740044f, 
    -0.12044197f, -0.26610640f, 0.02448319f, -0.20670556f, 0.18448888f, -0.05147910f, 0.02523789f, 0.13000530f, 
    -0.30853903f, -0.43128809f, 0.26086098f, 0.11761539f, 0.07513666f, 0.25391921f, 0.24542658f, 0.04057343f, 
    -0.35276532f, -0.41608703f, 0.05494460f, -0.00561997f, -0.48646253f, -0.05514377f, -0.04442209f, -0.03099886f, 
    -0.03949970f, -0.23431942f, 0.01325590f, 0.08518075f, -0.00314004f, -0.07274210f, -0.00194958f, -0.40608272f, 
    0.27732497f, -0.00370434f, -0.31928867f, 0.10696477f, -0.13690796f, 0.24744995f, 0.14515679f, 0.03947703f, 
    0.26808205f, 0.07696793f, 0.05584797f, 0.19615343f, 0.17014052f, -0.08862578f, -0.03813219f, 0.71904010f, 
    0.12336371f, 0.22605361f, -0.07486507f, 0.18246858f, -0.01164622f, 0.21293028f, 0.02222508f, -0.14232118f, 
    -0.08921469f, -0.02459199f, 0.02060498f, -0.02793593f, -0.28224066f, 0.01731708f, 0.10866445f, -0.04130511f, 
    -0.23398042f, -0.37244844f, 0.04661526f, 0.35661528f, -0.27741522f, 0.15444410f, -0.08320234f, 0.04246655f, 
    -0.03586918f, -0.04269569f, -0.05949682f, 0.05162882f, 0.03208756f, 0.05930714f, 0.03079076f, -0.04783959f, 
    -0.08393387f, -0.06939726f, 0.05372581f, -0.29872981f, -0.01283711f, -0.08756110f, 0.13286737f, -0.05253933f, 
    -0.03249085f, -0.38079727f, 0.13285296f, 0.06996723f, -0.08467821f, 0.15238135f, -0.00868925f, -0.09806984f, 
    0.22579096f, 0.11187759f, 0.15994968f, -0.53448182f, -0.00248171f, 0.19276501f, 0.21188948f, -0.11526968f, 
    0.00469789f, -0.06470508f, 0.14937428f, -0.54331225f, 0.14058897f, 0.02983986f, -0.07327455f, 0.04747114f, 
    0.06449666f, 0.00714720f, 0.22025724f, -0.05455143f, -0.09131661f, 0.05445810f, -0.03831460f, -0.00718564f, 
    0.05137343f, -0.08282834f, 0.04337302f, 0.16264439f, -0.03363018f, 0.02993324f, 0.01303789f, -0.25098547f, 
    0.15329933f, -0.10373259f, 0.07349343f, 0.08526915f, 0.03810712f, -0.07631683f, -0.03666033f, 0.15407300f, 
    -0.08474042f, 0.05923751f, -0.24984752f, -0.40268308f, -0.23369895f, -0.37046781f, -0.16834339f, 0.00553790f, 
    0.05150618f, 0.15633461f, -0.02130306f, 0.14384668f, 0.06155794f, 0.11564320f, -0.17908117f, -0.04202098f, 
    0.06038872f, -0.29752615f, -0.18831991f, -0.03194308f, -0.04643298f, 0.02009744f, -0.06010356f, -0.13186781f, 
    -0.03241723f, 0.03171095f, -0.22720142f, -0.04271194f, 0.23567580f, -0.15224628f, -0.04137385f, -0.05449757f, 
    0.01794614f, 0.07655308f, 0.29571140f, -0.08769453f, -0.04774297f, 0.02526385f, -0.07310718f, -0.47576416f, 
    0.00143387f, 0.26195043f, 0.06624275f, 0.05249720f, -0.04003757f, 0.10642315f, -0.00307220f, 0.07880638f, 
    0.12864654f, 0.05113422f, -0.00985860f, 0.03384185f, 0.12832379f, 0.22303817f, -0.12334204f, 0.04412807f, 
    -0.53350407f, 0.22837262f, 0.03389817f, -0.10715827f, 0.07086296f, -0.17193942f, 0.45552438f, 0.12346126f, 
    0.08291053f, 0.34053287f, -0.08790281f, 0.13503240f, -0.03955626f, 0.05718905f, 0.00581237f, 0.20703098f, 
    -0.08659689f, -0.04501502f, -0.06183086f, -0.29135090f, -0.01556358f, 0.08168282f, 0.20234871f, -0.14743119f, 
    -0.10862852f, -0.10488478f, -0.03894201f, -0.16383155f, -0.04899102f, -0.04229938f, -0.07902843f, 0.29226905f, 
    0.23091319f, -0.01455535f, -0.42917255f, -0.26611611f, 0.12933841f, 0.05043099f, 0.13871530f, -0.01788143f, 
    -0.04957861f, -0.08712696f, 0.10565303f, 0.11969502f, -0.16617388f, -0.07091565f, -0.45961708f, 0.11390218f, 
    -0.03718722f, 0.17697331f, 0.03820588f, -0.06437777f, 0.19821803f, -0.06720625f, 0.05165417f, 0.03394485f, 
    -0.13813995f, -0.15250690f, -0.01028475f, -0.01475788f, -0.24567774f, 0.06349339f, -0.11789503f, -0.05541918f, 
    0.16756915f, -0.04591171f, 0.01176244f, 0.11971971f, 0.03501569f, -0.10677817f, -0.04896685f, -0.50380158f, 
    0.21232314f, 0.21628101f, 0.17074111f, -0.14564833f, 0.05909985f, -0.26462090f, 0.04639285f, -0.07699136f, 
    -0.20126675f, 0.23914526f, 0.11858881f, -0.03371999f, 0.03746266f, -0.01899520f, 0.06061327f, 0.05899829f, 
    0.07810786f, -0.01382312f, 0.12842534f, 0.06687576f, -0.07652922f, 0.14232697f, -0.19183794f, 0.22794026f, 
    0.14035641f, -0.07124747f, -0.12248144f, 0.20082283f, -0.16084301f, 0.16577460f, 0.10219289f, -0.02977460f, 
    0.06605837f, -0.00435851f, 0.15851745f, -0.00057620f, 0.01713750f, -0.03967614f, -0.01270078f, -0.34628353f, 
    0.06919283f, -0.08896563f, 0.01529705f, -0.16802771f, -0.34138486f, -0.00343804f, 0.22810820f, -0.07340995f, 
    0.18645580f, 0.08034009f, -0.03131978f, -0.07137065f, 0.19842635f, -0.22620055f, -0.27014089f, -0.02471005f, 
    -0.05002821f, -0.26531935f, 0.03671750f, -0.08773870f, -0.58723980f, 0.49888617f, -0.39511970f, -0.18358247f, 
    0.07418964f, -0.49554017f, -0.06428445f, -0.18991558f, 0.21420583f, 0.03203149f, -0.04922171f, 0.20999280f, 
    0.02157846f, 0.04796936f, -0.02792163f, 0.37149686f, -0.03729364f, 0.03144522f, -0.39538512f, -0.25278905f, 
    -0.04122128f, 0.02261338f, -0.40100509f, -0.26809344f, 0.07890651f, -0.17534317f, 0.08050097f, 0.13452618f, 
    -0.42397738f, 0.20163055f, 0.05104778f, -0.00441505f, -0.09806004f, 0.12168717f, -0.15953939f, -0.14691243f, 
    0.17231169f, 0.05926192f, -0.10779578f, 0.13991120f, -0.29798341f, 0.05104102f, 0.03349876f, -0.01130872f, 
    0.01379079f, 0.06078270f, -0.17259601f, -0.05241432f, -0.09733322f, 0.04668414f, -0.06135956f, 0.04688635f, 
    -0.19037999f, 0.44793925f, 0.19468829f, -0.17236686f, -0.20988823f, -0.12129800f, -0.01099942f, 0.17113233f, 
    0.15691929f, 0.21490426f, -0.04329799f, 0.07964281f, -0.04975178f, -0.00280891f, -0.03054219f, 0.01799647f, 
    -0.05490655f, -0.10544696f, 0.03244808f, -0.02478150f, 0.19937912f, 0.09124117f, -0.23412351f, -0.03411723f, 
    0.10374334f, -0.05145432f, -0.46984744f, -0.25698984f, 0.16484179f, 0.20227915f, -0.47625491f, 0.07053824f, 
    0.02220350f, 0.09449520f, 0.05814084f, -0.24911323f, -0.00533774f, -0.05638852f, 0.27038884f, 0.10409376f, 
    -0.50110358f, -0.02028568f, 0.03074422f, 0.04775901f, 0.37080619f, -0.15523808f, -0.24098916f, 0.07174110f, 
    0.26683825f, 0.06607073f, -0.20324920f, 0.07045779f, -0.49121943f, -0.01892596f, 0.01572927f, -0.23762584f, 
    0.07217916f, -0.44557750f, -0.05215267f, 0.10700507f, 0.26261440f, 0.12575647f, 0.09934879f, 0.18848129f, 
    -0.02396131f, 0.03741851f, -0.08034879f, 0.01045579f, -0.11841571f, 0.09591028f, -0.05275445f, 0.04423639f, 
    0.10517406f, 0.14642447f, -0.47213772f, 0.44175267f, -0.15333308f, -0.40009746f, -0.02421461f, 0.28684250f, 
    0.16586062f, -0.23677590f, 0.04626637f, -0.12300727f, -0.10654040f, 0.01101518f, 0.12280039f, -0.14661098f, 
    0.05178979f, -0.03568902f, 0.06496119f, -0.45278299f, 0.12657006f, 0.04936104f, -0.31916890f, 0.23611437f, 
    -0.01533830f, -0.01607192f, -0.15786919f, 0.33352074f, -0.48610845f, 0.10529587f, -0.07522392f, -0.58750993f, 
    -0.20961043f, 0.03175966f, 0.15137392f, 0.07404514f, -0.17491701f, -0.03465420f, -0.12120480f, -0.28501394f, 
    0.18611734f, 0.02373439f, -0.51359534f, 0.10196253f, -0.69571960f, -0.07063338f, -0.15072729f, 0.01160098f, 
    0.03793992f, 0.19119608f, 0.09941151f, -0.08872022f, -0.19455083f, 0.04145460f, -0.02094285f, -0.00850659f, 
    -0.05607897f, -0.20708962f, 0.15047133f, 0.24473812f, -0.13521980f, -0.18376619f, -0.15798922f, 0.02462873f, 
    -0.14435911f, 0.27619290f, 0.07482785f, 0.18913990f, -0.17657657f, 0.04451894f, -0.26636478f, 0.08929031f, 
    0.12864660f, -0.20454091f, -0.22265278f, 0.24144465f, 0.04629884f, 0.02826199f, -0.35483804f, -0.05751342f, 
    0.20077388f, 0.06582738f, -0.01132814f, 0.21459790f, -0.25483403f, -0.33491915f, 0.01572781f, 0.06025194f, 
    -0.01565067f, 0.29801029f, -0.38329262f, -0.13650094f, -0.07751577f, -0.12968990f, 0.20517813f, 0.00955760f, 
    -0.16745339f, -0.09108766f, -0.16544309f, 0.25087678f, -0.27287668f, -0.06758162f, -0.20452814f, -0.04045107f, 
    0.01186015f, 0.02888741f, 0.00332780f, -0.19553773f, -0.27099651f, -0.10019026f, -0.05229637f, -0.18247578f, 
    0.24375899f, 0.10843905f, -0.00178564f, -0.42976034f, 0.16398439f, 0.20235334f, -0.02094034f, -0.40752590f, 
    -0.03520081f, -0.06205944f, -0.06514842f, -0.01972167f, -0.43292749f, -0.35369635f, 0.03896182f, -0.06129105f, 
    0.04708491f, 0.17059702f, -0.21974115f, -0.04757109f, 0.06575012f, 0.17837518f, 0.13047200f, -0.22761649f, 
    -0.25622526f, -0.11227748f, 0.00651948f, 0.08944481f, -0.33597618f, -0.00423878f, 0.16162325f, 0.29018432f, 
    0.06898394f, 0.04822206f, 0.01280124f, -0.15933821f, -0.38143846f, -0.02112865f, -0.22240186f, 0.05220056f, 
    -0.32783455f, -0.22990529f, 0.20066550f, 0.06264248f, -0.08992744f, 0.14487392f, 0.06071655f, 0.01779465f, 
    0.14533366f, -0.11191371f, -0.11791295f, -0.04704886f, -0.13814075f, 0.12656023f, 0.09843053f, 0.23319200f, 
    0.14187838f, -0.06758176f, 0.15798344f, -0.03219573f, 0.19961028f, -0.01888692f, 0.10949513f, -0.52644092f, 
    0.07658615f, 0.22537707f, 0.00864239f, 0.00283146f, 0.12571874f, 0.05218451f, -0.02721183f, -0.10422809f, 
    -0.01797705f, -0.08084440f, 0.11002555f, -0.00933375f, -0.05773784f, 0.04767438f, 0.12304071f, -0.25867802f, 
    -0.01690366f, 0.03249306f, 0.07947414f, -0.11161510f, -0.06367242f, 0.03583934f, -0.09103674f, -0.19600527f, 
    0.11356357f, 0.11948857f, 0.09073768f, 0.04378475f, 0.15466107f, 0.16429798f, -0.18159091f, -0.07329021f, 
    0.16463192f, 0.02790739f, -0.15549505f, 0.24111818f, 0.07620504f, -0.18756299f, 0.06391474f, -0.02894639f, 
    0.03959749f, 0.04258201f, -0.23958342f, 0.17937809f, 0.01095516f, 0.18769492f, 0.02640457f, 0.19905837f, 
    0.31991452f, 0.03931320f, 0.23425813f, 0.08311961f, -0.27838257f, -0.26109269f, -0.19154800f, 0.01075705f, 
    -0.49321976f, -0.03965906f, 0.29320130f, -0.32696256f, 0.08823042f, 0.00125632f, -0.05006548f, 0.26401696f, 
    -0.03575844f, -0.26604411f, -0.04262697f, -0.23126833f, -0.09727745f, -0.28377336f, -0.40085199f, -0.35056037f, 
    0.18515511f, 0.07146118f, 0.06128966f, -0.01611219f, -0.04651602f, 0.02899025f, 0.23273523f, -0.03427340f, 
    -0.06002766f, 0.25973257f, 0.26038703f, -0.02036851f, 0.13816836f, -0.14935161f, -0.04469854f, -0.03051664f, 
    0.23811725f, -0.34331217f, -0.08435510f, -0.32288143f, 0.02919605f, 0.06049140f, -0.08012660f, -0.09710408f, 
    -0.03230255f, -0.04322473f, -0.06143748f, 0.05950403f, 0.01221225f, 0.07838558f, -0.13273196f, 0.16099495f, 
    0.09964411f, -0.07843989f, 0.09702130f, -0.08500983f, 0.07922693f, -0.01715481f, 0.05789581f, -0.02166384f, 
    -0.01191985f, -0.45646209f, -0.16644689f, 0.12988125f, -0.14905222f, -0.15588363f, -0.31777382f, -0.18844132f, 
    -0.26243839f, -0.05180908f, 0.26005450f, -0.01758190f, -0.21370800f, 0.06154879f, 0.15848154f, 0.04586820f, 
    0.08167572f, -0.38545671f, -0.08896445f, -0.01086441f, 0.11017118f, -0.05823866f, -0.02113024f, 0.20367032f, 
    -0.32425621f, 0.14063966f, 0.18742056f, -0.31072924f, -0.12709844f, -0.37774754f, -0.22437376f, -0.18193407f, 
    -0.16270380f, -0.03645246f, 0.00838880f, -0.12466966f, 0.15049759f, 0.04271239f, -0.07419090f, -0.16621466f, 
    0.07431255f, 0.22579944f, 0.25217539f, -0.14959711f, -0.07582974f, 0.02930622f, 0.07122778f, 0.03768691f, 
    -0.16375615f, -0.14733133f, 0.44573098f, -0.14871062f, 0.05063257f, 0.25731274f, 0.10217254f, -0.01210344f, 
    0.05326862f, 0.07450923f, 0.03987608f, -0.33591771f, -0.03518644f, 0.11521946f, 0.12394366f, 0.07791466f, 
    -0.07400647f, -0.06149571f, 0.04627531f, -0.10573959f, -0.16171299f, -0.46012953f, -0.29827774f, -0.03775477f, 
    -0.38136750f, -0.06353462f, 0.20223731f, 0.07519282f, -0.31858552f, 0.00816902f, 0.06407342f, 0.03476019f, 
    -0.02113819f, -0.05096847f, 0.07518066f, -0.19282325f, 0.13885465f, -0.19617134f, -0.06008271f, 0.20636241f, 
    0.09066410f, -0.04270419f, -0.06128120f, -0.03924708f, 0.13476458f, 0.15630779f, -0.28595752f, 0.02468121f, 
    0.31052908f, 0.15583768f, -0.01887885f, -0.53172797f, -0.36053163f, 0.00100869f, -0.23712966f, 0.02086579f, 
    -0.04690800f, 0.14085916f, -0.06318160f, 0.03497029f, -0.19232543f, -0.03911418f, 0.26528609f, -0.50756764f, 
    0.05536614f, 0.05073825f, -0.05954449f, 0.39891994f, 0.14535633f, -0.08552852f, -0.19055387f, 0.15388778f, 
    0.20640054f, -0.15813689f, -0.15022387f, -0.28466216f, 0.07513020f, 0.18574423f, 0.03640905f, 0.04043369f, 
    -0.04068085f, 0.08265910f, 0.04621749f, 0.12347165f, 0.11711470f, 0.07727721f, 0.22237694f, 0.36488846f, 
    -0.21672779f, 0.04753346f, -0.19306956f, 0.05154622f, 0.14604223f, 0.06330558f, -0.27294829f, 0.14963551f, 
    0.00964849f, 0.15130958f, -0.00684068f, 0.01177236f, -0.30191714f, 0.01993028f, 0.01548738f, -0.08632638f, 
    0.37930360f, -0.02677028f, 0.06739862f, -0.06260426f, 0.39852452f, 0.03917550f, -0.06502310f, -0.05625793f, 
    -0.52058065f, -0.14198348f, 0.02358813f, 0.08932760f, 0.13935488f, 0.01229576f, -0.41045925f, -0.25332204f, 
    -0.06096762f, -0.25860542f, -0.42789546f, 0.25503528f, -0.22505954f, -0.06660722f, 0.07801143f, -0.06547314f, 
    -0.25473306f, 0.42613709f, 0.28130493f, 0.15805118f, -0.52906823f, 0.25558639f, 0.35195169f, 0.05425962f, 
    -0.03121642f, 0.00646878f, 0.18999313f, 0.13933954f, -0.01120676f, 0.21555862f, 0.17347775f, -0.06447677f, 
    -0.32117882f, -0.06573795f, 0.18156853f, -0.05388108f, 0.13960277f, 0.00639425f, -0.08001668f, -0.06617086f, 
    -0.13867080f, -0.05824897f, -0.13567397f, -0.57897472f, 0.05739743f, -0.01549889f, 0.05372993f, -0.64067256f, 
    -0.09439371f, -0.06626999f, -0.01459521f, 0.15678148f, 0.01141162f, -0.10557091f, 0.20466226f, -0.01800430f, 
    -0.21998975f, -0.08002330f, -0.04992198f, -0.00023037f, -0.03011065f, -0.08527578f, -0.05309592f, -0.04900111f, 
    0.24133928f, -0.20002216f, 0.20473099f, 0.24885878f, 0.20961247f, -0.02223915f, 0.06170559f, -0.06381134f, 
    -0.79569882f, -0.10655782f, -0.10894770f, 0.10769241f, 0.07359582f, 0.04386601f, -0.59509134f, -0.01332937f, 
    0.04398593f, -0.07859557f, -0.07855175f, 0.22100855f, 0.19948943f, 0.02675791f, 0.13205890f, 0.19978552f, 
    -0.22801585f, 0.03864019f, 0.20513529f, -0.07860551f, -0.43011227f, -0.00844434f, -0.00281573f, 0.23334968f, 
    -0.18358535f, -0.06540571f, -0.15471914f, -0.16730992f, 0.09965756f, -0.08313454f, -0.44419912f, 0.01645697f, 
    0.15036404f, -0.00011036f, -0.10086150f, 0.03726385f, 0.11078460f, -0.07905516f, -0.00601701f, 0.07542573f, 
    0.05789428f, -0.20443408f, 0.17206588f, 0.04771375f, -0.25157771f, 0.07434874f, 0.03785055f, -0.55235702f, 
    -0.05961343f, -0.06473110f, -0.06214051f, -0.12107375f, 0.13821377f, 0.10259400f, 0.15623762f, -0.06205093f, 
    0.03868139f, 0.08751589f, -0.08498386f, -0.08680249f, 0.26837596f, -0.00958318f, 0.05118774f, 0.23257101f, 
    -0.20257725f, -0.24222960f, 0.19937405f, -0.09362163f, -0.43831387f, -0.01563405f, 0.04604908f, -0.07516912f, 
    0.16213898f, -0.30427432f, -0.33254609f, -0.04374404f, 0.26121017f, 0.03697598f, -0.07989208f, 0.08166114f, 
    -0.06510127f, 0.13752642f, 0.16881064f, -0.22203352f, 0.06812605f, -0.09499352f, 0.02981248f, 0.14495052f, 
    0.26905191f, -0.04489971f, -0.17052917f, -0.00947312f, -0.13526288f, -0.00511977f, 0.14497645f, 0.02247047f, 
    -0.14174560f, 0.03104225f, -0.41130722f, -0.24404046f, 0.31762210f, -0.01208151f, 0.02114594f, 0.23253872f, 
    0.18343955f, 0.18244442f, -0.00597877f, -0.10309304f, -0.18190467f, -0.01342705f, -0.04498267f, 0.11252315f, 
    -0.14960501f, 0.06748197f, -0.04882143f, -0.07748920f, 0.12685183f, -0.24034412f, 0.23293370f, 0.01461079f, 
    -0.03506022f, 0.08940981f, 0.12163889f, -0.32685915f, -0.10884197f, -0.45787671f, -0.25493041f, 0.07276133f, 
    -0.27948692f, -0.11067920f, 0.06517882f, 0.16180260f, -0.05605040f, -0.08646177f, -0.21435921f, -0.52232188f, 
    0.07553621f, -0.00369223f, 0.04233738f, -0.21440962f, 0.16960604f, 0.04065570f, 0.18568757f, -0.40565249f, 
    -0.18840376f, -0.33668017f, 0.08254178f, 0.31821564f, -0.01885653f, 0.07982309f, 0.01332168f, -0.34583086f, 
    0.28469652f, 0.02059488f, 0.11754398f, 0.20214768f, -0.17028189f, 0.08377023f, -0.17247233f, -0.24570601f, 
    0.21544214f, 0.02454456f, 0.04818155f, 0.08167816f, 0.05300150f, -0.06318387f, 0.28134549f, -0.23779766f, 
    0.06774273f, -0.37569624f, -0.51896781f, -0.04787026f, 0.25862902f, 0.06546382f, 0.00059745f, -0.05711181f, 
    -0.62948704f, -0.23866707f, -0.08954877f, 0.25006974f, -0.20534226f, 0.12532735f, -0.07599857f, -0.13518202f, 
    0.09371004f, -0.15575562f, 0.01213221f, 0.05652209f, -0.03135042f, -0.09247898f, 0.14888316f, -0.06180616f, 
    0.22640847f, 0.11509323f, -0.34715348f, 0.07206610f, -0.06225558f, -0.11391652f, 0.01929867f, -0.01305263f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02065497f, -0.01611337f, 0.01064267f, 0.00657832f, -0.07242635f, 0.09156131f, -0.05451198f, -0.14528467f, 
    0.07891472f, -0.07744568f, 0.07079297f, 0.05444631f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
