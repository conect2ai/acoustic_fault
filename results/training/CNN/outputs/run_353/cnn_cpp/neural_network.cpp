#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.07124346f, -1.24770737f, 0.11965710f, 0.82756728f, -0.22580163f, -0.60308331f, 0.17510454f, 0.53643161f, 
    -0.38651773f, -0.05296862f, -0.02234469f, 0.08556828f, -0.08060808f, -0.00925030f, 0.15609808f, -0.04803530f, 
    0.18144083f, 0.12768807f, -0.15468469f, -0.06526555f, 0.11466495f, -0.01907761f, -0.03944447f, 0.00157589f, 
    0.13298583f, 0.21742633f, -0.02260593f, 0.21451485f, 0.99721843f, 0.64329016f, 0.69887358f, 0.61359072f, 
    0.42173269f, -0.05553105f, 0.07684022f, -0.03773729f, -0.31570455f, -0.16926210f, -0.25273827f, -0.19054677f, 
    -0.28290725f, 0.11383037f, -0.13922670f, 0.13142368f, -0.20583671f, 0.10749871f, 0.20695308f, -0.25990114f, 
    0.18558887f, -0.03352495f, -0.49050915f, 0.04147725f, 0.44022307f, 0.57175213f, -0.04643995f, 0.37364408f, 
    0.48322341f, 0.31415713f, -0.29570952f, 0.13916360f, -0.14955607f, 0.29154912f, 0.40744108f, 0.63023067f, 
    0.33168820f, -0.09365883f, -0.09017009f, 0.06801159f, 0.16858473f, 0.34839350f, -0.18551029f, -0.08544249f, 
    -0.12384395f, 0.25908020f, -0.21346271f, -0.07032255f, -0.27358076f, 0.17984945f, -0.32951424f, 0.30353212f, 
    0.39746764f, 0.01576834f, 0.06276426f, -0.26952136f, -0.47665980f, 0.40608284f, 0.01837066f, -0.17738014f, 
    0.44226626f, -0.00242255f, 0.37515780f, -0.35297424f, 0.02252067f, 0.07549069f, 0.32506409f, 0.15754540f, 
    0.51712173f, -0.15009870f, 0.10745820f, 0.43259257f, 0.88781941f, 0.35905614f, -0.26733977f, -0.00687403f, 
    0.63159215f, 0.02099627f, -0.23349352f, -0.38347411f, 0.41516930f, 0.48904485f, -0.29350454f, -0.28113595f, 
    -0.13499498f, -0.04495919f, 0.05579790f, -0.27947155f, 0.02221599f, -0.08549421f, 0.02060260f, -0.07434702f, 
    0.15780242f, -0.08645706f, 0.07704647f, -0.11073159f, 0.09300782f, 0.28369009f, 0.84928226f, 0.58352947f, 
    0.31542227f, 0.36950889f, -0.51362944f, 0.84138829f, -0.04221327f, -0.35162881f, 0.31980753f, 0.01220435f, 
    0.19216116f, -0.11418289f, -0.19815087f, 0.14415824f, -0.08846448f, -0.11856597f, -0.11902825f, -0.00358044f, 
    -0.23820183f, 0.08981254f, 0.12233805f, 0.21849670f, 0.04892409f, 0.00014837f, 0.59671032f, 0.10900304f, 
    0.32582307f, 1.01261973f, 0.32237321f, -0.03926273f, -0.44892287f, -0.45126790f, -0.44761813f, -0.00902639f, 
    -0.23754537f, 0.14304963f, 0.33685389f, 0.09244259f, -0.31288460f, -0.15746266f, 0.15824898f, 0.40549174f, 
    -0.00433393f, 0.05311118f, 0.01943470f, -0.06790984f, 0.05351311f, -0.18207039f, 0.02006748f, -0.24833827f, 
    -0.52077806f, -0.45714918f, -0.49566820f, -0.52275759f, -0.15947191f, 0.87848222f, 0.73696363f, 0.11962438f, 
    0.38713396f, -0.17368175f, -0.27867898f, -0.17839226f, -0.38475922f, -0.31386745f, -0.14823781f, 0.01969191f, 
    -0.19866201f, -0.20576130f, 0.03030564f, -0.16079760f, -0.08694822f, -0.18177925f, -0.27108341f, 0.16846177f, 
    0.21648234f, 0.77171952f, -0.05505023f, -0.66732204f, -0.40933394f, 0.24813981f, -0.12761518f, -0.79164493f, 
    -0.73920703f, -0.41322064f, -0.00128957f, 0.33727512f, 0.32839391f, -0.06522040f, 0.17704087f, -0.10402654f, 
    -0.10559386f, 0.15532401f, 0.06762992f, -0.11079554f, 0.22736233f, 0.06163764f, 0.04318510f, -0.17461491f, 
    -0.03046919f, -0.47450122f, -0.45935798f, -0.12051358f, 0.13119522f, 0.24336264f, -0.47884300f, 0.20111980f, 
    -0.48908845f, -0.73208481f, 0.26510152f, 0.48439169f, 0.15364884f, -0.23668246f, 0.13921218f, 0.07507271f, 
    -0.00810046f, -0.34486470f, -0.17124870f, 0.08196200f, -0.28768888f, 0.05432583f, -0.29697073f, 0.33620337f, 
    -0.04475005f, 0.05302018f, -0.40544406f, -0.73881352f, -0.84136891f, -0.03854169f, -0.18625067f, -0.23248462f, 
    -0.27870682f, -0.18682584f, 0.15002784f, 0.45085698f, -0.03108525f, 0.25197530f, 0.24202614f, -0.02732427f, 
    0.01305784f, 0.17912549f, -0.10094444f, 0.26707798f, 0.16824907f, 0.03646501f, -0.16549832f, 0.20716745f, 
    -0.31985742f, 0.14008400f, -0.01167323f, -0.03728646f, -0.25059372f, -0.53532797f, -0.55653191f, -0.10408355f, 
    -0.11006173f, -0.27488983f, 0.38228893f, 0.21952601f, -0.45656511f, -0.55820936f, -0.22604240f, -0.22646421f, 
    -0.23147407f, -0.12341253f, -0.37469473f, -0.10851590f, -0.30976951f, -0.02299598f, 0.00562815f, -0.06519789f, 
    0.28902593f, -0.15209457f, 0.08107162f, -0.12560196f, 0.00393042f, -1.01968491f, -0.59254050f, -0.31092206f, 
    -0.05786109f, 0.44408265f, -0.13035336f, 0.27983838f, 0.10486860f, -0.05609292f, 0.02484506f, 0.10117698f, 
    -0.34793183f, 0.26605564f, 0.14147227f, -0.05719079f, 0.08874133f, 0.03240739f, 0.16167609f, 0.38648409f, 
    0.24471490f, -0.07136779f, 0.38114151f, 0.18205707f, 0.11465364f, -0.21789567f, 0.37617877f, 0.29625365f, 
    -0.11205062f, 0.53898132f, -0.93753487f, -0.07344203f, -0.19777629f, -0.47133380f, -0.70788825f, 0.08977343f, 
    0.17629601f, 0.10665926f, 0.06078215f, 0.07336745f, -0.04241125f, -0.16309711f, 0.20868775f, -0.13502407f, 
    -0.00556719f, -0.15682374f, -0.05006599f, -0.05414325f, 0.26371354f, -0.16720024f, -0.61431682f, -0.06547763f, 
    -0.41857705f, 0.01191970f, -0.71284145f, 0.62715775f, 0.99368054f, -0.62471008f, 0.38439989f, 0.31130397f, 
    -0.00796724f, 0.09036626f, 0.09872380f, -0.03047843f, -0.02617872f, -0.01581204f, -0.11358262f, 0.02637995f, 
    0.02238762f, -0.14414029f, 0.08586174f, -0.00279443f, 0.09929720f, 0.01766172f, 0.09310432f, 0.94660109f, 
    0.47830725f, 0.75649607f, -0.53281522f, -0.51974463f, -0.52126259f, -0.16949905f, -0.07130105f, 0.04312208f, 
    0.04177523f, -0.04245206f, 0.09658873f, -0.09805588f, 0.08834568f, 0.07619533f, 0.04377411f, -0.17330430f, 
    -0.01261978f, -0.05828592f, 0.12588187f, 0.02772094f, 0.01192192f, -0.08606886f, 0.05822449f, 0.17448585f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.01056686f, 0.07586063f, 0.13232981f, 0.02538733f, -0.03400943f, 0.10742143f, -0.03133571f, 0.18094024f, 
    0.21132308f, 0.35323557f, 0.04833505f, 0.02685234f, 0.25951737f, 0.06916256f, 0.07984260f, 0.12919204f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03479489f, 0.01274021f, -0.08195698f, -0.01069241f, 0.05795909f, -0.01012272f, -0.07616394f, -0.03327325f, 
    0.01491339f, -0.01582267f, -0.00374223f, -0.00050768f, -0.06380051f, -0.03094307f, -0.06233612f, -0.02763317f, 
    -0.07471888f, -0.02928910f, -0.02382289f, 0.03146755f, -0.03159332f, -0.03434804f, 0.05659678f, 0.04777157f, 
    -0.00165518f, 0.03845279f, 0.05681231f, 0.05573501f, -0.01797483f, 0.05011604f, -0.00314558f, 0.05391640f, 
    0.01628271f, 0.01495523f, -0.04875249f, -0.05091486f, -0.02821615f, 0.06330592f, -0.07377970f, -0.01737581f, 
    0.04177279f, -0.02546070f, 0.04276183f, 0.04636739f, -0.05632170f, -0.03937690f, 0.05320947f, 0.05826814f, 
    -0.00673268f, -0.03961858f, -0.00454793f, -0.07220308f, 0.06558960f, -0.06943933f, -0.01692588f, 0.00040239f, 
    -0.07039978f, -0.04705463f, 0.02100485f, -0.01315660f, 0.02046543f, 0.02980292f, -0.00757751f, -0.05331235f, 
    0.06324784f, 0.05577379f, -0.05298526f, -0.03491653f, 0.06274468f, -0.05792596f, 0.06546652f, 0.05160375f, 
    -0.03604754f, -0.02556465f, 0.01392929f, -0.05375036f, -0.02506746f, -0.06739889f, 0.05218974f, -0.06015776f, 
    0.00115356f, -0.02513814f, -0.05960931f, -0.01359543f, -0.06648318f, 0.03498368f, -0.00327934f, -0.02642208f, 
    0.03178329f, 0.03304850f, -0.00692338f, 0.01413414f, 0.03612842f, 0.05709036f, -0.05052490f, -0.07692008f, 
    -0.05685638f, -0.05992461f, -0.00159191f, -0.06039605f, 0.00497379f, -0.07544799f, 0.01294849f, -0.04657394f, 
    0.03833467f, -0.00170661f, -0.00687899f, 0.02125663f, 0.02645024f, 0.03775026f, -0.05761259f, 0.01427894f, 
    -0.03064080f, 0.01955656f, 0.00054790f, 0.05862809f, -0.02533691f, -0.06796931f, -0.00224254f, 0.04967409f, 
    0.03942044f, 0.02011649f, 0.01591236f, -0.03809331f, -0.01254780f, 0.03242920f, 0.05421712f, 0.02663206f, 
    -0.01223215f, 0.04196240f, -0.03641569f, 0.02052907f, -0.03697369f, 0.00798038f, 0.02029392f, -0.03716492f, 
    0.03256777f, -0.02168524f, -0.06810018f, 0.03118161f, -0.04742423f, -0.01931802f, -0.05980246f, 0.06173012f, 
    -0.02633099f, -0.03126550f, -0.00690119f, -0.01282968f, 0.04523253f, -0.02205527f, -0.04801765f, 0.02787425f, 
    0.05661527f, -0.06778971f, -0.02649752f, -0.06163284f, 0.06737810f, -0.04695249f, -0.04760645f, -0.00602517f, 
    0.01873964f, -0.04916470f, 0.06878603f, 0.05610925f, -0.02370857f, 0.04356496f, 0.02048372f, 0.05418877f, 
    -0.05098079f, 0.06609943f, -0.04269513f, -0.06795711f, -0.01300942f, 0.00354656f, -0.06071762f, -0.05747810f, 
    -0.07923741f, 0.02361026f, -0.05448132f, -0.05895108f, 0.01729960f, 0.03144088f, -0.03773267f, 0.01991772f, 
    0.02483317f, 0.06139580f, -0.05202868f, -0.03010853f, 0.05305956f, 0.02400535f, -0.05158188f, 0.00485371f, 
    -0.10108113f, 0.14330103f, -0.02058399f, -0.07257692f, 0.07291155f, 0.11010684f, -0.20784774f, 0.04019230f, 
    -0.00035857f, 0.09014086f, -0.13277797f, -0.03880124f, -0.01285612f, 0.23165886f, 0.22885962f, -0.15411976f, 
    -0.09187787f, -0.02456388f, -0.08191967f, -0.10104483f, -0.13567050f, -0.08985287f, -0.11221991f, -0.03319424f, 
    -0.33767146f, -0.02981986f, -0.10840422f, -0.17448100f, 0.06384035f, -0.10915534f, 0.11580701f, -0.11344508f, 
    -0.00608242f, -0.03804323f, 0.00736571f, -0.00285265f, -0.11570389f, 0.07672471f, 0.00983987f, -0.09111750f, 
    -0.04264950f, -0.04456579f, -0.06411254f, 0.06186088f, 0.07373174f, 0.02735414f, -0.01985230f, 0.04568690f, 
    -0.01729687f, -0.26448667f, -0.05747619f, -0.03956381f, -0.09099118f, -0.01481669f, -0.00413288f, -0.15181130f, 
    0.02730881f, 0.02327002f, -0.05678979f, 0.08603213f, -0.48376587f, -0.07686196f, -0.03589831f, 0.10558279f, 
    -0.04280956f, 0.07926395f, -0.11923262f, -0.17215298f, 0.04039008f, -0.04258851f, -0.10383136f, -0.01009622f, 
    0.26329580f, -0.08381793f, 0.10684912f, 0.17235187f, -0.09205753f, 0.04330229f, 0.00441170f, -0.05788376f, 
    -0.01699590f, -0.03173172f, 0.14049923f, -0.01859564f, -0.06723384f, 0.08567838f, 0.05751211f, -0.18637882f, 
    -0.02236250f, 0.19531195f, -0.00827534f, -0.10773566f, -0.03269114f, -0.07682066f, 0.03785436f, 0.08236232f, 
    -0.09138942f, 0.10438609f, 0.10870260f, -0.03223043f, 0.07517061f, 0.03447748f, 0.05389642f, 0.01376134f, 
    -0.09397291f, 0.16374661f, -0.08630710f, -0.03643369f, -0.07160144f, 0.08782925f, 0.32837868f, 0.14184099f, 
    0.03198826f, -0.02738420f, 0.05871107f, 0.04901611f, -0.01036489f, -0.06799412f, 0.02740396f, 0.12354509f, 
    0.11265171f, 0.17522338f, 0.08695294f, 0.13966173f, 0.17374416f, 0.05241614f, -0.04142921f, 0.14263682f, 
    0.04761322f, -0.03302871f, 0.28026193f, -0.06195897f, 0.32247305f, -0.01941207f, 0.06420402f, -0.00082568f, 
    0.09014855f, 0.25310120f, 0.09476775f, 0.20836471f, -0.06117410f, 0.04498711f, 0.06293176f, -0.01744630f, 
    -0.30139157f, 0.23396221f, -0.06380074f, 0.04500824f, 0.15904023f, 0.05272871f, 0.06884048f, 0.01076542f, 
    0.08342487f, -0.00761781f, 0.00709113f, -0.00557402f, -0.03333107f, 0.02266922f, 0.36284682f, 0.22131436f, 
    0.00349651f, 0.00426906f, -0.04126580f, -0.08733892f, -0.02681712f, -0.01941556f, -0.00723723f, 0.11614754f, 
    0.09272178f, 0.43403569f, -0.04324886f, -0.05475967f, -0.01538491f, 0.15475219f, 0.10224020f, 0.09890739f, 
    -0.07360064f, -0.03866200f, -0.00548511f, -0.09865940f, -0.21381283f, -0.13676274f, -0.04949039f, -0.02332353f, 
    -0.03359060f, 0.11892337f, -0.01096451f, -0.09135447f, 0.09366205f, 0.06996047f, -0.03542800f, 0.02316375f, 
    0.03767648f, -0.11622912f, -0.00951445f, 0.10540098f, -0.05755469f, -0.06285696f, -0.08393217f, -0.01836522f, 
    -0.03262070f, 0.01454461f, 0.02485811f, -0.00692160f, 0.43622878f, -0.08141602f, 0.13818726f, 0.14302325f, 
    0.02756320f, 0.10669832f, 0.04008664f, 0.13664728f, 0.05463887f, -0.00717145f, -0.03423580f, -0.03043331f, 
    0.18922575f, 0.19008416f, -0.00256906f, 0.12431267f, -0.03408273f, 0.07824913f, 0.01339552f, -0.15807065f, 
    0.06423753f, 0.03448903f, 0.06424074f, -0.14088511f, -0.09664265f, -0.04608423f, -0.10550358f, -0.00352855f, 
    -0.08455069f, -0.01079193f, -0.06074779f, 0.02772810f, -0.06075705f, -0.01152300f, -0.06682511f, -0.02805254f, 
    0.16823477f, -0.01169285f, -0.01345003f, 0.06701460f, 0.09535214f, -0.03986812f, 0.07324382f, 0.04917990f, 
    -0.02605415f, 0.01721498f, 0.07371807f, -0.08231786f, 0.29714677f, 0.40250975f, -0.01971860f, 0.04296292f, 
    0.05879202f, 0.08872387f, 0.10846566f, 0.01045222f, 0.16779289f, 0.02054038f, -0.00699147f, -0.02391870f, 
    -0.04827159f, 0.09921805f, 0.09880881f, -0.11363757f, 0.06309842f, -0.07636746f, -0.08249976f, 0.05923501f, 
    0.03683465f, -0.03927815f, 0.05365079f, -0.08504093f, 0.28430787f, -0.11933654f, 0.05501954f, -0.01615093f, 
    -0.05718957f, -0.02302329f, -0.00699772f, -0.02343694f, 0.05656353f, -0.08202571f, 0.04178969f, -0.06239530f, 
    0.02634296f, -0.22547595f, -0.19737995f, -0.14031586f, 0.05300023f, 0.08211750f, 0.04611547f, -0.08640984f, 
    0.15616234f, -0.01024693f, 0.01515796f, -0.06051053f, 0.25767884f, 0.05563163f, -0.26030368f, -0.10630213f, 
    0.02060003f, 0.07196752f, -0.06489216f, 0.06866910f, 0.02384766f, 0.00474823f, 0.02709984f, -0.00259390f, 
    0.20702289f, 0.06343033f, 0.04729408f, -0.01309458f, 0.00071173f, -0.15204301f, 0.03410446f, 0.00590199f, 
    -0.01945241f, -0.00929694f, -0.05806860f, -0.03765516f, -0.23931192f, -0.01975690f, -0.09672925f, -0.14754815f, 
    0.09078464f, -0.15015058f, 0.01618047f, -0.20748647f, 0.11026309f, 0.02526667f, -0.01088279f, -0.03843774f, 
    -0.00055224f, 0.00095259f, 0.09076176f, -0.13290633f, -0.07815378f, 0.04065715f, -0.01736159f, -0.00587349f, 
    -0.02415110f, -0.00899029f, 0.06599772f, 0.08539986f, 0.04849331f, 0.06100670f, -0.20212513f, -0.14032048f, 
    0.03837541f, 0.13211706f, 0.06344103f, 0.02409509f, -0.04469218f, 0.15846214f, -0.11245983f, 0.03778677f, 
    0.39145291f, -0.31893772f, -0.03770853f, 0.02518363f, 0.02951897f, -0.12175549f, 0.01551430f, 0.13215108f, 
    -0.00677023f, -0.02324867f, -0.11120705f, 0.03735403f, 0.06054940f, 0.13966160f, -0.12052002f, -0.02955847f, 
    0.05246586f, -0.04219559f, 0.00877040f, 0.01979272f, 0.05467744f, -0.00418071f, -0.04461564f, -0.00731032f, 
    0.11213513f, 0.00023756f, 0.27333704f, -0.16589186f, 0.14958419f, -0.06868066f, -0.04500942f, 0.11675674f, 
    -0.02354484f, -0.03878246f, -0.02738944f, 0.01593516f, 0.16298255f, -0.35096303f, 0.08571265f, -0.37102634f, 
    0.08462849f, -0.10292924f, 0.05509771f, 0.06030115f, 0.13807493f, -0.02351006f, -0.10631809f, -0.11149579f, 
    0.02493731f, -0.21587974f, 0.25023144f, -0.01270862f, -0.06952477f, 0.05312170f, 0.01648848f, 0.01651639f, 
    -0.01156545f, -0.01337448f, 0.06772807f, -0.00705390f, -0.10185328f, -0.09399907f, 0.19688840f, 0.17368399f, 
    0.03292510f, -0.02398561f, 0.05746873f, 0.00457182f, 0.01141403f, -0.12215056f, 0.08976406f, 0.06594900f, 
    -0.16942513f, 0.08791430f, -0.07240309f, -0.00131617f, 0.13763998f, 0.05550299f, 0.04600158f, -0.03996211f, 
    0.16750152f, 0.02810107f, 0.11459319f, -0.02972822f, -0.08235392f, 0.19651982f, -0.20008038f, 0.03827871f, 
    0.00483729f, -0.00840739f, 0.03986122f, 0.00707624f, 0.03922726f, 0.09243350f, 0.05275422f, -0.03927665f, 
    0.15804243f, -0.12844160f, 0.04270561f, -0.05010444f, 0.16703786f, 0.03823224f, 0.00721433f, -0.04972029f, 
    0.05597883f, -0.05193854f, 0.17867577f, 0.10998087f, -0.19652198f, -0.12144639f, 0.01734838f, 0.14224185f, 
    -0.14693630f, 0.08209124f, -0.05740917f, -0.08388813f, -0.00166267f, 0.00724210f, 0.10234796f, -0.05242609f, 
    0.29276088f, -0.06401892f, -0.28386071f, 0.22314671f, 0.18952440f, 0.04940123f, 0.09678723f, -0.01543042f, 
    0.06965751f, -0.08223724f, -0.03450513f, 0.03083268f, 0.29019514f, 0.16704719f, 0.03044690f, 0.04247993f, 
    0.09817851f, 0.07221160f, -0.00107587f, -0.03163530f, 0.01608767f, -0.05456216f, 0.14635061f, 0.07219780f, 
    -0.04697380f, 0.13579185f, 0.00877199f, -0.04169743f, -0.12221637f, -0.05910512f, -0.17104706f, -0.02428081f, 
    0.11860615f, 0.12414906f, 0.10542698f, -0.00381465f, -0.08474658f, -0.00370143f, -0.13566504f, 0.08026847f, 
    -0.13575436f, -0.00669346f, 0.01136877f, -0.02346588f, -0.00876859f, -0.09584704f, 0.16551611f, 0.08013878f, 
    -0.33401892f, 0.07362038f, -0.03854714f, -0.03102668f, -0.05513871f, -0.11745738f, 0.01553696f, -0.07817010f, 
    -0.06171755f, 0.01857758f, -0.05095058f, 0.08566276f, 0.03257659f, 0.17255102f, -0.03125371f, 0.15245405f, 
    0.01826864f, 0.01363601f, 0.11301094f, 0.11240366f, 0.00622774f, 0.10855514f, -0.12214307f, -0.03069433f, 
    0.45803952f, -0.02062174f, -0.10113557f, 0.13691910f, -0.11233536f, 0.10521501f, 0.07478733f, -0.00583350f, 
    -0.17088495f, -0.00182032f, -0.02675073f, -0.16961586f, -0.08343410f, 0.15954451f, -0.09337134f, 0.06761187f, 
    -0.07974617f, 0.02954910f, 0.04290116f, -0.07208127f, 0.11187374f, 0.02458319f, 0.09817582f, -0.07952784f, 
    0.18576263f, 0.07488494f, 0.00468641f, -0.13920988f, 0.07858717f, 0.04678234f, 0.07313976f, 0.03743030f, 
    -0.07346502f, 0.13237357f, -0.07818616f, -0.02189617f, -0.20690066f, -0.07277086f, -0.08810350f, -0.08651081f, 
    0.03595021f, 0.01858467f, 0.15120502f, -0.01246905f, -0.03042877f, 0.14757891f, 0.00096029f, 0.04422655f, 
    0.01658573f, -0.02725050f, 0.13167651f, -0.10190635f, -0.10144032f, -0.02514329f, 0.05974764f, 0.12177849f, 
    0.05218616f, -0.04835728f, -0.01613635f, 0.06498376f, -0.03684140f, 0.03345073f, 0.01281401f, 0.01191053f, 
    0.07086287f, -0.03662209f, 0.09867383f, -0.12561452f, -0.07327958f, -0.17096081f, 0.00902428f, -0.12477673f, 
    -0.04144920f, 0.17081399f, -0.09747775f, 0.07433250f, 0.01733282f, 0.11793330f, 0.00730601f, 0.11414144f, 
    0.00766094f, 0.13314776f, -0.00734156f, 0.08846011f, 0.12216780f, -0.11030500f, 0.10440906f, -0.04174608f, 
    0.11190007f, -0.07795732f, -0.02632691f, -0.00053232f, -0.09892632f, 0.04724354f, 0.00331905f, -0.01973328f, 
    -0.01217376f, 0.13175242f, 0.00548861f, -0.19145469f, 0.00979962f, 0.02291576f, 0.00688784f, 0.07259358f, 
    0.01650814f, 0.10884761f, -0.16598804f, 0.05096643f, -0.32805061f, 0.09612057f, 0.15538676f, 0.16529447f, 
    0.06400970f, 0.11070327f, 0.10599463f, 0.08634156f, 0.01997053f, 0.09547556f, 0.17456223f, 0.13082691f, 
    -0.04121475f, 0.10362401f, 0.09541237f, 0.10060260f, -0.03487261f, 0.00895319f, -0.04179618f, -0.10098374f, 
    -0.03808536f, -0.02703373f, -0.10090306f, 0.11717036f, -0.18289083f, -0.08789454f, 0.15346830f, -0.01929414f, 
    0.08577911f, -0.10016586f, 0.03612886f, 0.02018887f, 0.00576042f, 0.09806503f, 0.12183711f, 0.00795392f, 
    -0.10326552f, 0.07925025f, 0.00073542f, 0.05195326f, 0.08479516f, 0.14727890f, 0.05228653f, -0.04758127f, 
    0.11144902f, 0.13709301f, -0.05030670f, -0.02167888f, 0.03896996f, 0.07929298f, -0.00944138f, 0.17451656f, 
    -0.00255961f, -0.07405055f, -0.05050825f, 0.07710981f, 0.00759629f, -0.03028547f, 0.15332435f, 0.15111881f, 
    -0.02233843f, 0.19119242f, -0.09469354f, 0.02556507f, 0.12423336f, -0.00971403f, -0.05458231f, -0.05892517f, 
    -0.04134792f, -0.08921131f, -0.05193744f, -0.21535301f, 0.01778672f, -0.31129047f, 0.05592935f, 0.10523375f, 
    -0.02300099f, -0.05618047f, -0.05971820f, -0.04626490f, 0.01225161f, -0.13724977f, 0.00039544f, -0.08949246f, 
    -0.04370777f, 0.18572356f, 0.20916317f, 0.05794283f, 0.06197558f, 0.09543510f, 0.01921863f, -0.08504173f, 
    -0.02698055f, 0.03778489f, 0.03902856f, 0.04675516f, 0.18602803f, 0.00686081f, 0.23483221f, 0.06601444f, 
    -0.00418531f, 0.00547095f, -0.07258443f, -0.05370680f, 0.06605405f, -0.02530329f, 0.13346942f, -0.06302736f, 
    -0.29329476f, 0.17973574f, -0.03291376f, -0.10515671f, -0.02246337f, -0.08436280f, 0.03099884f, 0.06891041f, 
    -0.08280310f, -0.07858776f, 0.06348935f, -0.06707412f, -0.04360120f, 0.09487583f, 0.07463187f, 0.04663765f, 
    0.02733598f, 0.15050749f, 0.09208573f, 0.09301877f, -0.00638952f, 0.16927832f, 0.05095772f, 0.10342263f, 
    -0.03200294f, -0.03092877f, 0.20323123f, -0.16257963f, 0.01742567f, -0.00650926f, -0.03132412f, 0.12530057f, 
    -0.15729545f, -0.00099013f, -0.09203938f, -0.00757155f, -0.07456253f, 0.09803628f, 0.01681754f, 0.02667905f, 
    0.11747205f, -0.11016288f, -0.01752327f, 0.00525889f, -0.02387658f, -0.02215326f, 0.09774829f, -0.08519230f, 
    0.33179843f, 0.15407898f, 0.07988248f, -0.08294147f, -0.10305197f, -0.04622640f, 0.03268985f, 0.01057702f, 
    -0.02966096f, -0.03217137f, -0.07572321f, -0.08636336f, -0.05917605f, 0.03190625f, 0.29997903f, 0.08264212f, 
    -0.03025735f, -0.00445191f, -0.02966008f, 0.07191157f, 0.00065298f, -0.03141169f, -0.02670316f, 0.06315230f, 
    0.04478326f, 0.14773194f, 0.09908178f, -0.03164433f, 0.09110599f, 0.09792635f, -0.06675447f, -0.06328453f, 
    0.04393702f, -0.09458666f, -0.17906940f, 0.05937285f, -0.20770669f, -0.09905741f, -0.13241594f, 0.08947391f, 
    0.11440901f, 0.04202791f, -0.03054695f, 0.00656961f, -0.03376424f, 0.04180305f, 0.18400158f, 0.08221409f, 
    0.00824543f, -0.17152873f, 0.23681553f, 0.16310850f, -0.02201048f, -0.00633511f, -0.10882632f, 0.16062194f, 
    -0.01935637f, 0.14430462f, 0.10533896f, 0.08137102f, -0.38642991f, 0.06124229f, 0.14756402f, 0.06364613f, 
    -0.00336292f, 0.00373655f, 0.02464988f, 0.07927364f, 0.00285860f, 0.05613144f, 0.17030364f, -0.06205037f, 
    -0.05040736f, 0.01828781f, -0.12164795f, 0.08523738f, 0.04982162f, 0.13185771f, -0.00584014f, 0.10398407f, 
    -0.05411487f, 0.03409926f, 0.08397802f, 0.08213338f, 0.00774600f, -0.12362729f, -0.00764304f, 0.09415492f, 
    0.01129652f, 0.06969237f, -0.02557983f, -0.02802797f, 0.04079096f, -0.01850113f, 0.06556710f, 0.19304192f, 
    0.05433897f, 0.07414650f, -0.22537002f, -0.02937700f, 0.16975455f, -0.03327338f, 0.02248200f, 0.05291570f, 
    0.02917930f, 0.04933524f, -0.05944433f, -0.03472209f, -0.04104942f, 0.01098302f, 0.19736701f, 0.06711285f, 
    -0.05773710f, 0.04325273f, 0.07407417f, 0.07439263f, 0.03823549f, -0.08040837f, -0.02663862f, 0.09378964f, 
    -0.55513406f, -0.06906630f, -0.07289551f, -0.08379251f, 0.18498078f, 0.05513909f, 0.01120420f, -0.16264631f, 
    0.01302018f, 0.01067134f, -0.07219775f, 0.01810867f, 0.22963703f, -0.00200933f, -0.02018608f, 0.15850545f, 
    0.03116141f, 0.01227099f, 0.15417455f, 0.07520358f, 0.03255312f, -0.01236757f, 0.10948486f, -0.09344585f, 
    0.20735565f, -0.03409157f, 0.05606627f, -0.16632397f, -0.07328387f, -0.00019702f, -0.07952849f, 0.04518270f, 
    0.04146604f, 0.03746415f, -0.01932053f, -0.16211568f, 0.29466826f, 0.10863326f, 0.21668644f, -0.08839937f, 
    -0.03715849f, -0.06380866f, -0.11437522f, 0.05829706f, 0.22418323f, -0.05346910f, 0.08172528f, 0.07214487f, 
    0.14111818f, 0.12411920f, 0.16362253f, 0.01340357f, -0.00800605f, 0.07625243f, 0.06888671f, 0.09875863f, 
    -0.07064908f, 0.03273845f, 0.13945948f, -0.09076615f, -0.07754928f, -0.01687199f, 0.07450961f, 0.06632296f, 
    0.12974070f, -0.04701120f, -0.14077744f, -0.03425096f, -0.06456077f, 0.02397106f, -0.02428124f, 0.06710761f, 
    0.21366544f, -0.04219586f, 0.03552350f, -0.14117448f, -0.04877698f, -0.03790194f, 0.05373628f, -0.03721547f, 
    -0.11537743f, -0.04521024f, -0.10242231f, -0.07401412f, -0.03476325f, 0.24018185f, 0.20585883f, 0.10906485f, 
    -0.04389578f, 0.12581004f, 0.04620732f, 0.05317057f, 0.09813513f, 0.07914314f, 0.07742409f, 0.17002410f, 
    0.12318847f, 0.10212869f, 0.18228815f, 0.04241568f, 0.04696839f, -0.03979543f, -0.02679111f, -0.12913333f, 
    -0.04502604f, -0.08090109f, 0.11253495f, 0.10853975f, 0.01888833f, -0.20988196f, -0.08482694f, -0.04217216f, 
    -0.07178083f, -0.05049584f, -0.08217277f, -0.06315565f, 0.11788002f, -0.16808452f, 0.02184212f, -0.01536237f, 
    -0.15338612f, -0.38485190f, -0.09837539f, 0.19186752f, 0.09191763f, 0.04799125f, 0.05907960f, 0.10411550f, 
    -0.05338727f, 0.01314912f, -0.07537854f, -0.01983399f, 0.17666312f, -0.04748557f, -0.12580398f, -0.00262983f, 
    -0.04037527f, -0.01187206f, -0.09743313f, -0.00382900f, -0.06090086f, 0.01320773f, -0.03605531f, 0.05202591f, 
    0.09211835f, 0.02878534f, -0.06882854f, -0.00024306f, -0.10381610f, 0.06258006f, -0.04317131f, 0.01716008f, 
    -0.06068831f, -0.02904022f, -0.03405962f, -0.14579776f, 0.00223179f, -0.23032929f, -0.09847081f, 0.13982408f, 
    -0.03362820f, -0.01834750f, 0.01329236f, -0.07351834f, 0.06641181f, 0.01446095f, -0.07130460f, 0.01167962f, 
    -0.15669094f, -0.03663433f, -0.03721944f, 0.07233764f, 0.01861524f, 0.00116557f, 0.06470155f, -0.01620967f, 
    0.21019439f, 0.11734851f, -0.02859087f, 0.06356449f, 0.01440893f, -0.02948600f, 0.13553810f, 0.16015880f, 
    -0.03115830f, -0.01992530f, 0.08718646f, -0.07702103f, -0.02207659f, 0.07461064f, 0.01883000f, 0.03568815f, 
    -0.21317431f, 0.08027683f, -0.05227606f, -0.08906359f, -0.07258244f, -0.01299839f, 0.03081598f, 0.00844503f, 
    -0.09459817f, -0.09877901f, -0.06041384f, -0.15912193f, -0.30015668f, -0.11489627f, -0.15853634f, 0.23077586f, 
    0.02009672f, 0.00760181f, 0.17047681f, 0.03298867f, -0.08314103f, -0.01731501f, 0.12602820f, -0.05887307f, 
    -0.25370196f, -0.05843333f, -0.21283498f, 0.21239236f, -0.02550982f, -0.03880741f, -0.03435136f, -0.02632345f, 
    0.09832089f, 0.10717934f, 0.05086355f, 0.11429942f, 0.27073801f, 0.44436431f, 0.04462996f, 0.24440064f, 
    0.00048817f, -0.05137355f, -0.10693351f, 0.05799380f, 0.03051777f, 0.01394949f, 0.01584111f, -0.03859410f, 
    0.28978053f, 0.22763969f, -0.19273213f, 0.17322069f, 0.06359479f, -0.00675611f, -0.08425610f, -0.20642355f, 
    0.00228360f, 0.03177032f, 0.16311766f, -0.08160656f, 0.17756219f, 0.09251342f, -0.01074210f, -0.25538495f, 
    0.01565279f, -0.01651891f, -0.19697134f, 0.06634595f, -0.03679199f, 0.22449775f, -0.03404366f, 0.11186490f, 
    -0.27211815f, -0.24330673f, 0.07026093f, 0.16970986f, 0.13025029f, -0.10705902f, 0.04270010f, 0.05171322f, 
    -0.04121566f, 0.04072202f, -0.09000106f, -0.02277679f, 0.14947860f, 0.15917626f, -0.00075828f, 0.06223488f, 
    0.12539409f, 0.12470951f, 0.08043987f, 0.05419167f, 0.08247345f, 0.05472653f, -0.02365040f, 0.09395137f, 
    -0.04785484f, -0.03665053f, 0.01266052f, 0.10187276f, -0.10355056f, -0.05420459f, 0.03671387f, -0.01516502f, 
    -0.01853110f, 0.06115010f, 0.09099754f, -0.05270677f, 0.47520167f, 0.15331304f, 0.06913728f, -0.06775318f, 
    -0.09947510f, 0.07507585f, -0.14720650f, 0.00992595f, -0.01687459f, -0.20551825f, -0.29973620f, -0.05449387f, 
    -0.23282856f, 0.00479078f, -0.01172963f, -0.40824828f, 0.03087444f, 0.06037404f, 0.06668020f, 0.04928469f, 
    0.20574801f, 0.01170804f, 0.13581719f, -0.09447507f, 0.01870164f, -0.04177333f, -0.22904311f, -0.10036138f, 
    -0.11846735f, -0.08211807f, -0.03062341f, 0.09982976f, 0.05644287f, 0.02832466f, -0.17948847f, 0.15328269f, 
    0.00645132f, 0.00286498f, 0.01553601f, -0.19127837f, 0.00686215f, -0.29587951f, 0.05598490f, 0.07310864f, 
    -0.06894935f, 0.04363193f, 0.09281010f, 0.06116349f, 0.01452195f, -0.19604133f, -0.04467447f, -0.41064453f, 
    0.00141638f, -0.00166652f, -0.10711438f, 0.07422517f, 0.12689275f, 0.08565751f, -0.11133330f, -0.14315702f, 
    0.10142750f, 0.02520455f, 0.22518986f, -0.10695622f, -0.12705323f, 0.00949939f, -0.03785624f, 0.14366472f, 
    0.11848174f, 0.11704749f, -0.08273815f, 0.15574884f, -0.06314576f, -0.04296295f, -0.15953857f, -0.20724353f, 
    0.12618206f, -0.00414407f, 0.07843424f, 0.11498328f, 0.03827932f, -0.02045645f, 0.11472821f, 0.10278394f, 
    0.17507881f, 0.02477799f, -0.07239673f, -0.02898701f, -0.14201862f, -0.19829205f, 0.13252693f, 0.15402991f, 
    0.22392890f, -0.02345373f, 0.10172141f, 0.06029655f, -0.10314993f, -0.16687021f, -0.04861448f, -0.22526452f, 
    0.27263519f, 0.16266680f, 0.01287968f, -0.04187485f, -0.00048709f, 0.02072158f, -0.01367696f, 0.08341380f, 
    -0.41784513f, -0.09242187f, -0.16150507f, 0.20005623f, -0.04440725f, -0.01302955f, -0.04425070f, -0.08471360f, 
    0.03723799f, -0.12479596f, 0.02523588f, 0.14837089f, 0.25849277f, 0.23379268f, -0.04679165f, 0.17984632f, 
    0.02361611f, -0.03508733f, -0.08329292f, -0.01405040f, -0.06986500f, -0.06752641f, 0.01598335f, 0.09812059f, 
    0.22704184f, 0.18674739f, -0.14469437f, 0.22429118f, -0.06827633f, 0.11555465f, -0.01670423f, -0.11944962f, 
    0.11860759f, 0.08018847f, 0.07530853f, -0.09964523f, 0.13903011f, -0.00080071f, -0.05598899f, -0.23951113f, 
    0.03437227f, -0.03250469f, 0.00889030f, -0.03786403f, -0.02790253f, 0.15446272f, -0.07295830f, 0.12603287f, 
    -0.12468060f, -0.16551419f, -0.00178033f, 0.41520515f, 0.11304817f, -0.08724554f, 0.03109836f, 0.11258039f, 
    -0.07205659f, 0.10053149f, -0.09441047f, 0.01395038f, 0.43013036f, 0.12376648f, -0.02834537f, 0.20060669f, 
    0.00363713f, 0.06052471f, 0.08732377f, -0.02208031f, 0.03524805f, 0.15043807f, -0.05831542f, 0.03115599f, 
    -0.24329413f, 0.19032609f, 0.01475932f, -0.06206290f, -0.15754573f, -0.06692282f, 0.06800317f, 0.08775792f, 
    0.05032200f, 0.16052173f, 0.14205462f, -0.15198180f, 0.22660382f, 0.05453714f, 0.20118427f, 0.08772957f, 
    -0.06561685f, -0.00355158f, 0.02363663f, 0.07766756f, 0.13292620f, -0.05502224f, -0.05054289f, 0.00663608f, 
    -0.01246352f, 0.09227516f, -0.05892397f, -0.29337609f, 0.02428774f, 0.13281000f, 0.03558972f, -0.04736829f, 
    0.11554030f, -0.00135436f, 0.03501190f, 0.00037554f, 0.04111153f, -0.09230140f, -0.21777141f, -0.05891166f, 
    0.00108779f, -0.01402883f, 0.16284832f, 0.05845183f, 0.03918315f, 0.02344230f, -0.12544195f, 0.07847310f, 
    0.02465492f, -0.00903304f, 0.11656577f, -0.06563310f, 0.15064290f, -0.08330642f, 0.11719119f, 0.09994227f, 
    -0.09724937f, 0.00898323f, 0.05791790f, 0.06363702f, -0.14534746f, -0.05471412f, -0.12520127f, -0.31405485f, 
    -0.02780995f, -0.11221118f, -0.01001370f, 0.04350375f, 0.06411472f, 0.01904703f, 0.00698271f, -0.09735117f, 
    0.02551972f, -0.06753701f, 0.21397448f, -0.08269978f, -0.08680274f, 0.04772098f, 0.00948218f, -0.04301233f, 
    -0.03750277f, 0.07226831f, -0.06717807f, 0.07665431f, -0.01689500f, -0.02941325f, -0.16902295f, -0.02312796f, 
    0.02717536f, -0.06392572f, -0.07475121f, 0.00187614f, 0.10309631f, 0.12035941f, -0.01527330f, 0.10681265f, 
    0.27855897f, -0.12266459f, 0.00221657f, 0.02878138f, -0.08339811f, -0.17273141f, 0.02897411f, 0.00222961f, 
    0.05677314f, 0.15898298f, -0.02177751f, 0.15294084f, 0.12235801f, -0.22260053f, 0.21634315f, -0.07849410f, 
    0.07054010f, 0.00535181f, -0.02806403f, -0.19302270f, 0.05250724f, 0.05576730f, -0.13025826f, 0.17367947f, 
    0.41435695f, -0.11460759f, 0.12269019f, -0.24733609f, 0.18907160f, 0.00245757f, 0.10577664f, -0.00693765f, 
    -0.07519390f, 0.02483351f, -0.07332242f, 0.05408169f, 0.04548439f, -0.15903902f, -0.23132202f, -0.15727429f, 
    0.09532721f, -0.07768103f, 0.11467571f, 0.00310569f, 0.01876117f, 0.14261495f, 0.08513430f, 0.13751738f, 
    0.19302660f, -0.11133011f, 0.00758193f, 0.00598091f, -0.11839873f, -0.00005181f, -0.10636136f, 0.06564104f, 
    0.05000638f, 0.02300262f, -0.15552066f, 0.07901746f, 0.15493394f, 0.03424497f, 0.01536977f, -0.03058286f, 
    0.14513142f, -0.09642086f, 0.00102222f, -0.15300585f, -0.06397108f, -0.04384547f, 0.08752889f, -0.08057584f, 
    -0.40668046f, 0.27768809f, 0.02098625f, 0.00276353f, -0.01251282f, 0.11694192f, 0.16093463f, -0.07296211f, 
    0.03861715f, -0.01155229f, -0.02503062f, 0.07350178f, -0.14841557f, -0.09286510f, 0.00897047f, -0.05653632f, 
    0.12551785f, -0.00007774f, 0.04383125f, 0.11484928f, -0.10491436f, 0.05636849f, 0.06107125f, 0.03168769f, 
    -0.14464878f, 0.09820295f, -0.00115387f, -0.27673855f, 0.06957778f, 0.17089228f, -0.04950842f, 0.05208223f, 
    0.06770474f, 0.08814580f, -0.14402221f, -0.08295395f, -0.04230753f, -0.25362378f, 0.06822993f, 0.23392189f, 
    -0.06566797f, -0.13641278f, 0.06051157f, 0.10999130f, -0.03876646f, 0.06522293f, 0.20658246f, 0.14926781f, 
    0.04572653f, -0.20145348f, 0.05105276f, -0.03201190f, 0.02009312f, -0.01184818f, -0.10480476f, 0.08879590f, 
    -0.04015095f, -0.00011171f, -0.02173195f, 0.01500579f, 0.19300060f, -0.00896660f, -0.02920099f, -0.04720997f, 
    0.11250685f, 0.02047104f, -0.00021717f, 0.04504620f, -0.00586469f, 0.06509558f, 0.14259185f, -0.06155336f, 
    -0.07593017f, -0.08079793f, 0.10713927f, 0.02391179f, -0.16612247f, 0.05781376f, -0.03867419f, 0.01856915f, 
    -0.02417408f, 0.01025955f, -0.04066133f, -0.03059771f, -0.10116994f, -0.01747034f, -0.01110246f, 0.19849069f, 
    -0.13821100f, -0.03677960f, 0.00151372f, 0.11855628f, 0.07900091f, 0.04924113f, 0.11186443f, 0.21206196f, 
    0.04404821f, 0.06572175f, 0.12147249f, 0.07800065f, -0.03493431f, -0.06100498f, 0.00270691f, -0.09270269f, 
    -0.08609138f, -0.09196445f, 0.08192245f, -0.07789796f, 0.22131532f, 0.05686544f, -0.05207473f, -0.20437011f, 
    -0.03812997f, 0.03977137f, 0.00123361f, 0.02733275f, 0.03199986f, 0.05035448f, -0.02254871f, -0.02315920f, 
    -0.04688441f, -0.12236397f, 0.08436346f, 0.17734802f, -0.09374211f, 0.01296390f, 0.04886446f, -0.03343748f, 
    0.05785739f, 0.06506762f, 0.00677950f, 0.02467715f, -0.30156451f, -0.27637324f, 0.25726882f, 0.17871468f, 
    0.07964596f, 0.10888685f, 0.09820186f, -0.06956315f, 0.10318134f, 0.03090277f, -0.04135051f, 0.00866709f, 
    0.24358313f, -0.26757863f, 0.10076385f, -0.02870923f, 0.02726945f, 0.01890442f, 0.14413705f, -0.04100007f, 
    -0.03658991f, 0.01197318f, 0.09026577f, -0.01579171f, 0.11152064f, -0.13034356f, -0.12256420f, 0.17008044f, 
    0.07965279f, -0.03703197f, 0.06961866f, -0.05687998f, 0.03484831f, 0.05729159f, 0.03566324f, 0.17984362f, 
    0.28261089f, -0.00281558f, 0.03919974f, 0.05946495f, -0.06202534f, 0.00048887f, -0.04050319f, -0.14799617f, 
    0.04310329f, 0.00097901f, -0.05890319f, -0.03978211f, 0.06685783f, 0.03127726f, -0.08494440f, 0.11452518f, 
    -0.01631306f, 0.14665478f, 0.06435512f, 0.00677507f, -0.05245518f, 0.04716709f, -0.01557397f, -0.11028600f, 
    -0.06524409f, 0.30103156f, 0.02023627f, 0.14295228f, 0.04333811f, 0.05171094f, 0.05729597f, 0.06103426f, 
    -0.03505230f, -0.06156684f, 0.03326681f, 0.09838969f, 0.31299561f, 0.16499436f, -0.14608331f, 0.07489906f, 
    0.17848152f, 0.01140569f, -0.03565981f, 0.07095227f, -0.01409187f, 0.03669972f, 0.05368762f, 0.12824626f, 
    -0.13640422f, 0.10983511f, -0.05834770f, -0.06756335f, 0.16069719f, 0.04547944f, -0.02306950f, -0.03100435f, 
    0.04100594f, 0.05203702f, -0.08311543f, -0.08404709f, 0.12251095f, -0.22062643f, 0.10925009f, 0.07369609f, 
    0.07506642f, -0.10852671f, 0.10250813f, 0.09918111f, -0.00708592f, 0.01004363f, 0.15046582f, 0.08928316f, 
    0.23609358f, -0.12203814f, -0.06540069f, -0.07469149f, -0.03502883f, 0.09901535f, -0.11403308f, -0.01433856f, 
    0.06912893f, 0.00161347f, -0.10801236f, 0.03508900f, -0.02666862f, 0.06632186f, -0.14317036f, 0.01133724f, 
    0.07685674f, 0.10376956f, 0.04511504f, -0.05230017f, 0.03795340f, 0.03752873f, 0.11055706f, -0.07476730f, 
    0.11183523f, -0.13321635f, 0.10169361f, -0.22902505f, -0.10641606f, -0.03276671f, 0.05247894f, 0.05613174f, 
    0.08661753f, 0.07053224f, -0.16072161f, 0.03036861f, -0.34521192f, 0.16214201f, -0.09327456f, -0.06938720f, 
    -0.03625071f, -0.12568113f, -0.04807151f, 0.06599928f, 0.08237112f, -0.04381468f, 0.01451714f, 0.11658362f, 
    0.31503990f, -0.05391099f, 0.16948047f, -0.00123080f, -0.14879189f, -0.03494081f, -0.06144098f, -0.03208885f, 
    -0.07830302f, -0.10626050f, 0.03709258f, 0.03326339f, -0.14759234f, -0.03259882f, -0.25926799f, -0.17291133f, 
    0.03374855f, 0.15035027f, -0.07059761f, -0.01977650f, 0.00201913f, 0.16073701f, 0.01874309f, -0.01516530f, 
    0.12510136f, -0.40044919f, 0.09568413f, -0.00650491f, 0.02578702f, 0.00265896f, 0.00518697f, 0.03695959f, 
    -0.02178671f, 0.04219803f, 0.01460886f, 0.15744320f, 0.17535399f, 0.06274600f, -0.09885512f, 0.05542547f, 
    0.09198145f, -0.04361603f, 0.01657126f, -0.02596043f, 0.11030046f, -0.01420191f, -0.01933544f, 0.05679921f, 
    -0.04297126f, -0.02272305f, 0.02609901f, 0.04893416f, -0.02096818f, -0.06922101f, -0.00971099f, 0.02069068f, 
    0.00101204f, 0.03402305f, -0.02349635f, 0.00277081f, 0.03003547f, -0.06952418f, -0.01758735f, -0.00373163f, 
    -0.06149602f, 0.02089048f, 0.05104858f, 0.00461080f, -0.00740686f, -0.06122220f, -0.02343046f, -0.05167499f, 
    0.00651610f, 0.03718438f, 0.02550907f, -0.06582588f, -0.04134081f, -0.07718207f, -0.05702432f, -0.00244991f, 
    -0.03794529f, 0.01300676f, 0.04871941f, 0.00102142f, -0.05238020f, -0.03284913f, -0.01478534f, -0.05449608f, 
    0.02085945f, 0.05471787f, 0.04855976f, -0.00811612f, -0.05437015f, -0.07410348f, -0.00960289f, -0.02138945f, 
    -0.01674573f, -0.03864553f, -0.06401544f, -0.02485933f, 0.04078432f, 0.02998300f, 0.02735675f, 0.06019598f, 
    0.05560369f, 0.00853787f, 0.01421841f, 0.02982973f, -0.02264885f, -0.03882633f, 0.04987540f, -0.06042176f, 
    0.00138072f, -0.00362282f, -0.06068515f, 0.01885369f, -0.05711922f, -0.00801627f, -0.01865951f, 0.00425771f, 
    -0.02043352f, -0.02023865f, 0.04627418f, 0.03266230f, -0.05324376f, -0.00543524f, -0.00735156f, -0.00781784f, 
    -0.00124289f, -0.06503968f, -0.01205857f, -0.01200653f, -0.01352009f, -0.05918255f, -0.02642885f, -0.03143255f, 
    0.02658653f, -0.00439539f, 0.02350251f, 0.00942348f, 0.01453021f, 0.00070785f, -0.03657543f, -0.07610165f, 
    0.03200883f, -0.06408804f, -0.00566963f, -0.04767270f, -0.02479460f, -0.01388998f, -0.02488578f, -0.04552741f, 
    -0.04900847f, -0.07481413f, -0.05514990f, 0.03878854f, -0.02914429f, -0.05409624f, 0.02669006f, -0.01798148f, 
    -0.04384303f, 0.04965382f, 0.05232703f, -0.03088165f, -0.05123187f, -0.05941565f, -0.06269269f, 0.03587010f, 
    -0.04949601f, -0.04193834f, -0.05094924f, 0.04148168f, 0.01783990f, 0.06339084f, -0.06917673f, 0.06443343f, 
    0.03012537f, -0.06003984f, 0.03721059f, -0.06724695f, -0.00302167f, -0.04502926f, -0.06144601f, 0.01148544f, 
    -0.02848020f, -0.01477682f, 0.00817515f, 0.05227408f, -0.01454256f, -0.02735145f, -0.04613437f, -0.02039557f, 
    -0.07599476f, -0.06311752f, -0.04382684f, 0.01593456f, -0.05493787f, -0.06785883f, 0.04424167f, 0.01612257f, 
    -0.04113447f, 0.02706578f, 0.05438246f, -0.04652488f, 0.05666144f, -0.04029278f, -0.07319843f, -0.02423674f, 
    -0.01924228f, -0.03292519f, 0.04289564f, 0.01648672f, -0.03399273f, -0.03872058f, 0.02727179f, -0.06914618f, 
    -0.02640831f, -0.07566711f, 0.00000180f, -0.00425605f, -0.01838174f, -0.01195187f, 0.03888365f, 0.05002443f, 
    0.02516000f, -0.04645535f, -0.00396752f, -0.04099464f, 0.05214731f, -0.02964697f, -0.05903151f, -0.07756414f, 
    0.03508558f, -0.07649935f, -0.04440629f, -0.01636821f, 0.04587942f, 0.04040014f, 0.05268172f, -0.07724011f, 
    0.10870593f, 0.05661433f, 0.08198447f, -0.00644765f, 0.01101292f, 0.01186129f, -0.03103260f, 0.01635149f, 
    0.03700360f, 0.01125220f, -0.00360346f, 0.04159979f, -0.17154953f, -0.08703132f, 0.04230508f, -0.30434155f, 
    0.17336749f, -0.07193176f, -0.06858250f, -0.14381272f, 0.10806217f, -0.09564655f, -0.08716878f, -0.16596331f, 
    0.29203817f, -0.09964812f, -0.02596948f, -0.09822416f, 0.04966990f, 0.04422657f, 0.09710587f, 0.08164955f, 
    -0.10185070f, 0.05453789f, 0.15334252f, -0.05129540f, -0.10550152f, -0.00630047f, 0.19239765f, 0.29116553f, 
    -0.03195444f, 0.04947492f, 0.00691486f, -0.03838390f, 0.08081143f, 0.05949849f, -0.01552556f, 0.12882398f, 
    -0.07103760f, -0.02607126f, -0.32027835f, -0.05095439f, 0.06157355f, 0.06419756f, -0.00822199f, 0.03372283f, 
    0.16293684f, 0.02298525f, -0.04195249f, -0.09707513f, 0.28631106f, -0.22575778f, -0.26899531f, -0.10278971f, 
    0.04342881f, 0.09094323f, -0.02736393f, 0.01959370f, 0.00650829f, 0.00431967f, 0.04896623f, 0.00657805f, 
    -0.04855403f, -0.20065969f, -0.10035975f, -0.11274169f, 0.02741739f, 0.02480358f, 0.04285082f, -0.06890385f, 
    -0.05629903f, -0.03874578f, 0.14770150f, 0.12779695f, 0.07213441f, 0.28192574f, -0.04916798f, 0.06640248f, 
    -0.08224799f, -0.01354341f, 0.04469011f, 0.06721568f, 0.04848824f, 0.02708552f, -0.02562538f, -0.11056997f, 
    0.22634572f, -0.02915740f, -0.22837648f, 0.20557386f, 0.06372378f, -0.16754144f, 0.04720760f, -0.10496625f, 
    0.04040943f, 0.04488486f, 0.16382137f, -0.05092082f, 0.19792627f, -0.17890799f, 0.00811290f, 0.03448088f, 
    -0.03607349f, -0.04787943f, -0.01682613f, -0.05760328f, -0.02877168f, -0.01506657f, 0.08243297f, 0.04415723f, 
    -0.06824812f, 0.06330243f, 0.16164659f, -0.01368131f, -0.08951768f, 0.02598844f, -0.12458914f, -0.12415153f, 
    0.09293757f, 0.13821538f, 0.05409928f, 0.01036474f, 0.08447307f, 0.07743414f, 0.16988172f, 0.13237879f, 
    -0.01537539f, 0.14290996f, 0.00013414f, 0.12287097f, -0.03931293f, -0.01127129f, -0.03517988f, -0.15449207f, 
    -0.18221283f, 0.14820755f, 0.09148108f, 0.16104744f, -0.08900069f, 0.03597235f, 0.05469271f, -0.09601764f, 
    -0.02093963f, 0.11394794f, -0.06443765f, 0.09290062f, 0.08332041f, -0.28696641f, -0.04646930f, 0.23421775f, 
    0.08401489f, -0.19285467f, -0.03597265f, -0.09209750f, -0.04441413f, 0.09779651f, 0.11254976f, -0.01752440f, 
    0.03204644f, 0.14066115f, -0.01447427f, 0.10644805f, -0.06821834f, 0.10266542f, 0.10443916f, 0.02875760f, 
    0.05256602f, -0.08991552f, 0.01461042f, -0.04943706f, 0.10792376f, 0.15119258f, -0.19166154f, -0.15382245f, 
    -0.05531444f, -0.03072004f, 0.11059093f, 0.01617105f, 0.03367465f, 0.02772219f, 0.10970280f, 0.00963926f, 
    -0.03924306f, 0.09979062f, 0.00593486f, 0.15486239f, -0.05381138f, -0.03968612f, -0.03638135f, 0.04241351f, 
    -0.02233181f, 0.03230233f, 0.07368544f, 0.02445742f, 0.19241913f, 0.16522682f, 0.08570857f, -0.04941121f, 
    -0.06877811f, 0.05996716f, -0.12473211f, -0.05546775f, -0.05602997f, -0.05077726f, 0.04699032f, -0.04326348f, 
    -0.12585624f, -0.06653284f, -0.05273404f, 0.08580025f, 0.16549683f, 0.06802624f, 0.05320528f, -0.05289474f, 
    0.07893806f, -0.02291634f, 0.00746166f, -0.10026457f, 0.05986110f, -0.18973537f, 0.05074054f, 0.07661571f, 
    -0.05819730f, 0.07739452f, 0.06486636f, 0.06383594f, 0.12473173f, 0.09492405f, -0.13951303f, 0.16104716f, 
    -0.09782355f, 0.09575982f, 0.03786769f, -0.05506083f, -0.12748821f, -0.16446467f, -0.08246022f, 0.05454561f, 
    0.01010891f, 0.05361900f, 0.01375434f, -0.01002472f, -0.10058799f, -0.30352828f, 0.02177033f, -0.06512041f, 
    -0.11782348f, 0.03433013f, -0.06983946f, 0.02183079f, 0.06089462f, 0.01548341f, -0.07705071f, 0.04013855f, 
    0.25628650f, 0.03440034f, 0.01440450f, -0.09599452f, -0.12791316f, -0.11023923f, 0.03348299f, -0.06230485f, 
    -0.07611874f, 0.00271190f, 0.11310031f, 0.12359657f, 0.21036607f, 0.12374842f, -0.08002813f, -0.22719462f, 
    0.12184662f, 0.15083928f, -0.01791350f, -0.04433050f, 0.19077042f, -0.08983445f, -0.06357765f, 0.10160407f, 
    -0.07668523f, 0.03243930f, 0.10653514f, 0.34147501f, 0.00907686f, -0.06187296f, 0.07822951f, 0.10310039f, 
    -0.12457199f, 0.00401592f, 0.11866156f, -0.03839394f, -0.01671102f, 0.00182776f, 0.07531847f, -0.01195957f, 
    -0.06612013f, -0.16012867f, 0.02851311f, 0.03514041f, -0.01739177f, 0.02732996f, -0.11100084f, 0.06932808f, 
    -0.18772706f, 0.04679589f, -0.11595456f, -0.11620606f, 0.14280966f, 0.10840326f, 0.10369020f, -0.07001189f, 
    -0.14733529f, 0.02351152f, 0.01414415f, 0.03769122f, 0.34277928f, 0.05497938f, 0.10278130f, 0.01949008f, 
    0.07056378f, 0.10020021f, -0.02768526f, -0.07343503f, 0.00941659f, 0.03699100f, -0.12739165f, -0.05231272f, 
    0.00269363f, 0.02450906f, 0.02057344f, -0.06140390f, 0.24136658f, 0.17921275f, 0.04944697f, 0.08125800f, 
    0.09948794f, 0.17221630f, -0.07511569f, 0.03824615f, 0.23051670f, -0.04387611f, 0.14377318f, 0.15068683f, 
    -0.03369047f, -0.17646897f, -0.03192008f, 0.10090599f, 0.13468498f, -0.08832633f, 0.04414333f, 0.12110651f, 
    -0.20745508f, 0.12972817f, 0.04039092f, -0.02432232f, 0.06260130f, -0.01651541f, 0.15111691f, -0.05131733f, 
    0.09523169f, 0.02783233f, -0.03335622f, 0.05102592f, -0.00402292f, 0.01454280f, 0.07067118f, 0.32096639f, 
    -0.10368297f, -0.01342524f, -0.01010691f, 0.00942541f, -0.10757669f, 0.00798920f, -0.04819496f, 0.03785008f, 
    -0.03178530f, 0.02231273f, 0.05759713f, -0.21320389f, -0.06038919f, 0.07033528f, 0.08341605f, 0.17631382f, 
    0.12201633f, -0.14221473f, -0.18763517f, -0.00599772f, -0.00259869f, 0.03191750f, -0.07559773f, 0.05947987f, 
    0.02868633f, -0.08651137f, 0.15959306f, 0.22286609f, 0.20216084f, 0.20216982f, 0.05237844f, 0.00687202f, 
    0.12338381f, 0.04152479f, 0.14319542f, 0.06607734f, -0.02082607f, 0.03228678f, 0.02386223f, 0.28970724f, 
    -0.14544645f, 0.10065638f, 0.05082868f, 0.13764757f, 0.22742869f, 0.00150572f, 0.19229013f, 0.05051022f, 
    -0.11588325f, 0.02135968f, 0.21270725f, -0.02551599f, 0.03657112f, -0.05553578f, 0.18197474f, 0.19887200f, 
    -0.10714606f, 0.03186249f, 0.05360260f, -0.21204849f, 0.04958381f, 0.04514894f, 0.02947657f, 0.06520839f, 
    -0.19029309f, 0.09433436f, -0.00287703f, 0.03132536f, -0.07341065f, -0.01651847f, 0.13350028f, -0.02928855f, 
    -0.04488608f, -0.00647506f, 0.06718719f, 0.10968715f, 0.05803823f, 0.13249823f, 0.16744737f, -0.04743290f, 
    -0.21595119f, -0.11893267f, -0.01523024f, -0.04656219f, -0.03657366f, -0.11523461f, 0.03298381f, 0.05373282f, 
    -0.03712220f, 0.01843230f, -0.03042348f, 0.41405764f, -0.18920814f, -0.14226691f, -0.02508381f, 0.17490079f, 
    -0.10234317f, -0.18193083f, -0.41529161f, 0.07887282f, 0.17529026f, -0.14951667f, -0.36160937f, -0.08632091f, 
    -0.18001103f, -0.06453288f, -0.02087513f, 0.11165425f, 0.02529663f, -0.06363447f, -0.01658241f, -0.15663621f, 
    -0.11899643f, -0.24325165f, 0.16314718f, 0.20605104f, -0.09187309f, -0.04828656f, 0.02833472f, 0.00447609f, 
    -0.11211774f, -0.13969335f, -0.07621665f, -0.01541966f, 0.08980613f, -0.11763502f, 0.01376678f, 0.08866639f, 
    -0.22843137f, -0.01698887f, 0.00984749f, 0.09584692f, -0.04091295f, 0.19305682f, -0.08347767f, -0.11768623f, 
    0.09596847f, -0.09869516f, -0.04113108f, 0.01434098f, 0.02863080f, -0.05486414f, 0.08843821f, 0.12065741f, 
    0.01233763f, -0.13660875f, -0.07381018f, 0.00282162f, 0.05335078f, 0.07633048f, -0.19214346f, -0.07831728f, 
    -0.12878935f, -0.01544437f, -0.01386999f, -0.01085347f, -0.11693894f, -0.01540293f, 0.06486228f, -0.09531514f, 
    0.07435710f, 0.11354803f, 0.00102253f, 0.11528915f, 0.02333519f, -0.34056813f, -0.08653599f, 0.15586850f, 
    0.04382975f, -0.01805729f, -0.03698513f, 0.04455734f, -0.13353682f, -0.27699018f, 0.06095952f, -0.06920366f, 
    -0.16400409f, 0.03661610f, 0.13267215f, 0.14480121f, -0.27908161f, -0.00581396f, -0.17176387f, -0.03698789f, 
    0.19323280f, 0.05347550f, 0.26193839f, -0.15718620f, -0.18798231f, 0.02808568f, -0.13747221f, -0.06638987f, 
    0.02999348f, 0.06089244f, -0.22753243f, 0.09646118f, -0.12155657f, 0.07460319f, 0.19652295f, -0.22390589f, 
    -0.30449912f, 0.04618163f, 0.00051820f, 0.26907471f, -0.08531539f, -0.01222878f, -0.13452441f, 0.01264775f, 
    0.14403675f, -0.00047644f, 0.07317107f, 0.09631492f, -0.04760880f, 0.09199163f, 0.16312408f, 0.11380149f, 
    -0.05342364f, 0.05743027f, -0.04359132f, -0.00767271f, -0.01299550f, 0.01421931f, -0.08713230f, -0.10233893f, 
    -0.08099043f, 0.00708449f, -0.07020311f, 0.03320600f, 0.10843812f, -0.04117403f, 0.02117218f, -0.08808589f, 
    -0.00408972f, -0.01588398f, 0.11993421f, 0.05998360f, -0.05425240f, -0.16239095f, 0.09025570f, 0.10103496f, 
    -0.05319970f, 0.08659723f, -0.05425780f, 0.01144760f, 0.09568754f, 0.09810246f, -0.13334928f, 0.04715311f, 
    0.24276125f, -0.15098377f, -0.03820937f, 0.07240627f, 0.11160705f, -0.05302776f, -0.13396446f, 0.02581656f, 
    0.09121718f, 0.00549049f, -0.04693277f, -0.04144212f, 0.32954079f, 0.03479303f, -0.08504948f, 0.02572954f, 
    -0.01782788f, 0.01973340f, 0.08604963f, -0.01776066f, 0.09678096f, 0.04319480f, 0.00865202f, 0.02758474f, 
    0.12170468f, -0.11164977f, -0.09656753f, 0.36471775f, 0.02751533f, -0.07074549f, 0.00446952f, 0.06506572f, 
    0.08306881f, 0.04700842f, 0.17477486f, -0.08746590f, 0.11619692f, 0.26001003f, 0.01197567f, -0.13407348f, 
    -0.03065826f, -0.02230416f, -0.04555510f, -0.00952047f, 0.03375837f, 0.02750366f, -0.06332439f, -0.10137106f, 
    0.13909581f, 0.14737327f, -0.18713923f, -0.02393439f, 0.00727899f, -0.00817397f, 0.08713418f, -0.10117844f, 
    0.05837264f, 0.04622205f, 0.08610942f, -0.09106868f, -0.13246384f, 0.04538668f, 0.02669439f, 0.00838867f, 
    -0.00209319f, -0.04881094f, -0.10040778f, -0.05447954f, -0.09975716f, 0.04700879f, -0.08920499f, 0.02945158f, 
    0.24049681f, 0.16585654f, 0.02571861f, -0.15412208f, 0.02690117f, -0.17647509f, 0.01356493f, 0.04020313f, 
    0.05844430f, -0.04616351f, 0.07509170f, 0.04320339f, 0.05449725f, 0.18250461f, 0.09909578f, -0.17773609f, 
    0.03375947f, -0.03358464f, -0.02571964f, -0.19523795f, -0.01545650f, 0.07649556f, -0.12053346f, -0.09549531f, 
    0.13587715f, 0.04413873f, 0.02409763f, 0.00074940f, -0.03914002f, 0.10379705f, -0.03837411f, 0.09118719f, 
    0.06507187f, 0.11191610f, -0.03777299f, 0.07688262f, -0.22860010f, -0.00772117f, 0.04260716f, 0.07671349f, 
    -0.00643117f, -0.00262552f, -0.01689578f, 0.03109541f, 0.04197418f, 0.10982274f, 0.08563094f, -0.01594806f, 
    0.27693057f, 0.05528077f, -0.07529527f, -0.01071487f, 0.08375143f, 0.05237937f, 0.00678312f, 0.08241311f, 
    -0.04433094f, -0.08546988f, 0.08315444f, -0.01391521f, 0.33296719f, 0.17116860f, -0.33064625f, -0.13853388f, 
    0.10740470f, -0.09618946f, -0.10735878f, 0.05879727f, 0.01198255f, -0.01387513f, 0.03215122f, 0.07875346f, 
    0.03242439f, 0.01067500f, 0.03318968f, -0.01598681f, 0.00536498f, 0.00753488f, 0.04944051f, -0.01178340f, 
    0.04271620f, -0.00507706f, -0.01933439f, 0.02547414f, 0.01812757f, -0.07713077f, 0.01033787f, 0.01873543f, 
    0.03025645f, -0.01349510f, -0.01793055f, -0.07329613f, -0.07696605f, -0.03103481f, -0.04036239f, -0.00352834f, 
    -0.05558537f, -0.01486278f, 0.04547196f, -0.01143303f, 0.06015464f, -0.05970095f, 0.00026795f, 0.02716611f, 
    -0.06953017f, -0.07675649f, 0.05006376f, -0.04567091f, -0.03486136f, 0.01092744f, 0.01174629f, -0.02350917f, 
    0.03096294f, 0.04055288f, -0.03073531f, -0.04060733f, 0.02694579f, -0.06614635f, -0.06630860f, 0.02590059f, 
    0.05706441f, -0.07436610f, -0.00292671f, -0.05909534f, -0.05607393f, 0.04118731f, -0.00170080f, -0.03072711f, 
    -0.06969452f, -0.00892510f, -0.05087691f, -0.01698604f, 0.02908359f, -0.05806761f, -0.06128418f, 0.02277925f, 
    -0.01986002f, -0.05007449f, 0.01247615f, 0.03651234f, -0.05763408f, 0.03601589f, 0.03455320f, 0.02173147f, 
    -0.03505531f, 0.02825329f, 0.02288899f, -0.03048732f, 0.04379893f, 0.03251081f, 0.05120451f, -0.00936052f, 
    -0.06793936f, -0.05064877f, 0.04334173f, 0.00296207f, 0.04624922f, -0.01888727f, -0.00654563f, 0.01887795f, 
    -0.04242602f, -0.03933727f, -0.03246382f, 0.05157298f, -0.07312389f, 0.03417169f, -0.05395040f, 0.03946948f, 
    0.03709318f, -0.04355845f, 0.04588841f, 0.02158710f, -0.02529749f, -0.05208201f, 0.00181305f, 0.00687900f, 
    0.02472891f, 0.03468575f, -0.05133381f, 0.05162357f, 0.05681985f, -0.01546773f, -0.02093457f, 0.06606382f, 
    -0.06789467f, 0.01083247f, -0.00427721f, -0.02443049f, -0.03457974f, 0.00665760f, -0.07704550f, -0.02894011f, 
    0.05245347f, -0.07741282f, 0.04231620f, -0.05255878f, -0.01270971f, 0.05370577f, 0.00260121f, -0.05710673f, 
    -0.06955612f, 0.01558501f, 0.00895941f, 0.00623009f, 0.01365743f, 0.03281440f, -0.06392869f, -0.04789396f, 
    0.05144583f, -0.03859134f, 0.02185892f, -0.01653714f, -0.05997727f, 0.01691753f, -0.03042011f, -0.01336105f, 
    0.05795341f, -0.03485822f, -0.04676137f, -0.02351938f, -0.06458234f, 0.00055641f, -0.02944934f, 0.06423622f, 
    -0.02189313f, -0.04045874f, -0.03738303f, -0.03103856f, 0.05356231f, -0.04961187f, 0.05637073f, 0.06450181f, 
    -0.01553162f, -0.00949744f, -0.01641123f, -0.04765732f, 0.06029000f, -0.01513381f, -0.04973088f, -0.02847444f, 
    -0.04866932f, -0.07183349f, 0.04867021f, -0.04869984f, 0.00975007f, -0.06261361f, -0.02728429f, -0.06037322f, 
    -0.05007483f, -0.05653705f, 0.01835255f, -0.03987750f, -0.07022749f, -0.00729597f, 0.03175618f, -0.05502817f, 
    0.05235895f, -0.04492729f, 0.05612915f, -0.02172463f, 0.02863218f, -0.06364658f, 0.05315964f, -0.06326917f, 
    -0.07431766f, 0.04179652f, -0.04089049f, 0.00711473f, -0.01077112f, -0.05311101f, -0.00327292f, -0.05121350f, 
    -0.03258138f, -0.03076098f, 0.06046648f, 0.04368497f, 0.02119003f, -0.03152554f, -0.02639676f, -0.00925909f, 
    -0.04092926f, -0.02475376f, -0.07465150f, -0.03728367f, -0.03916754f, -0.01525174f, 0.04276033f, -0.03553685f, 
    0.00729014f, 0.03804459f, 0.05447297f, -0.03082612f, -0.04426197f, -0.03775122f, 0.04220566f, 0.04836385f, 
    -0.04938608f, 0.02346089f, -0.07349068f, 0.03653424f, -0.05202717f, -0.07070944f, 0.01735449f, 0.06479702f, 
    -0.01267981f, -0.07840186f, -0.03575808f, 0.02878549f, 0.05593386f, -0.06898906f, 0.05396663f, -0.05444863f, 
    -0.06759763f, -0.04230471f, -0.05814730f, -0.00232658f, -0.06961661f, -0.07176019f, -0.01124416f, 0.06238446f, 
    -0.04935709f, -0.02920784f, -0.05282936f, -0.04602728f, 0.02970189f, -0.06038252f, 0.06254700f, -0.06871396f, 
    0.03128479f, -0.01096151f, 0.02869042f, -0.04470413f, -0.00172422f, 0.05219810f, 0.05987558f, -0.04667090f, 
    0.00296434f, -0.06919299f, -0.04060729f, 0.01100901f, 0.00817243f, 0.01379480f, -0.04051372f, -0.05712450f, 
    0.00268042f, -0.05252308f, 0.05862722f, 0.02616651f, -0.04444687f, -0.00746064f, -0.04385591f, 0.00815106f, 
    -0.03842389f, 0.01645485f, 0.06379426f, -0.06826063f, -0.06670701f, -0.07123460f, -0.06977230f, 0.01276698f, 
    -0.07597205f, -0.03199382f, -0.07047913f, -0.07128163f, -0.00097054f, 0.05446732f, -0.03824635f, -0.01532189f, 
    0.02911112f, 0.01685696f, -0.00428109f, 0.04129628f, -0.03090078f, 0.00201165f, 0.00197416f, 0.02378141f, 
    0.02822179f, -0.03837572f, -0.06765373f, -0.06966988f, 0.05372853f, 0.02755994f, -0.07596114f, -0.03657989f, 
    -0.00802791f, -0.02406069f, -0.02227551f, 0.00692085f, 0.04395099f, -0.00295539f, -0.00996008f, 0.03067934f, 
    -0.01494135f, 0.00358506f, -0.01651438f, -0.00303434f, -0.02587079f, 0.03069336f, 0.04677204f, 0.03412949f, 
    0.00302752f, 0.05958172f, 0.04885441f, 0.05255229f, 0.02726238f, -0.06616519f, -0.06960364f, -0.00573136f, 
    0.00094474f, -0.07412320f, 0.01714084f, 0.06124951f, -0.03707535f, -0.02778476f, -0.07065611f, 0.04478168f, 
    -0.07041088f, 0.02025748f, -0.04497534f, 0.01399998f, -0.04858864f, -0.03338787f, -0.07633317f, 0.01707143f, 
    -0.07321646f, -0.03561273f, -0.07207090f, -0.05869129f, -0.01830666f, 0.04551506f, -0.04791518f, -0.04890272f, 
    0.00306681f, 0.01415995f, -0.01883831f, -0.00086952f, -0.04605626f, 0.00018396f, -0.00403442f, -0.04665014f, 
    -0.00373460f, -0.05077174f, 0.06658151f, -0.04903689f, 0.04389425f, 0.03477875f, 0.06264720f, 0.02443611f, 
    -0.02080975f, 0.03126375f, 0.03947799f, -0.06279933f, -0.00306453f, -0.06830271f, 0.02283734f, 0.00243329f, 
    -0.39989278f, 0.14346315f, -0.29790583f, 0.04322626f, 0.02944064f, 0.06342387f, -0.01093879f, 0.03353251f, 
    0.04712259f, -0.01363620f, 0.04247711f, 0.06572655f, -0.18175298f, 0.32545927f, 0.03893269f, 0.05578157f, 
    -0.03877287f, -0.09493971f, -0.15136708f, -0.03679208f, -0.15691119f, 0.00331444f, 0.10796952f, 0.00326167f, 
    -0.06034268f, -0.02536376f, -0.18292844f, -0.02910518f, 0.10127326f, 0.02259059f, -0.04568752f, 0.06827669f, 
    0.01925659f, 0.07882423f, -0.04100522f, -0.02902605f, 0.02446850f, 0.07253297f, -0.01807041f, -0.17656417f, 
    0.03905531f, -0.01671364f, 0.05009863f, 0.10611459f, 0.00230763f, 0.12977323f, -0.11232454f, 0.05973268f, 
    0.00496831f, -0.13141222f, 0.04230465f, 0.03436975f, 0.08074369f, -0.08072238f, -0.09753089f, 0.04405441f, 
    0.01919203f, 0.00845088f, 0.02950995f, -0.06184182f, 0.29208532f, -0.18316901f, 0.12763676f, -0.02330158f, 
    0.07670153f, -0.08615609f, 0.02575969f, -0.04446413f, 0.13512814f, -0.01938711f, -0.05634223f, -0.04028204f, 
    -0.02436155f, 0.10213352f, 0.02637034f, 0.09609166f, -0.13142790f, -0.01629420f, 0.03478593f, -0.01176269f, 
    -0.03009111f, 0.13793269f, 0.00172439f, 0.10770751f, -0.02482526f, 0.30541095f, 0.07627907f, 0.07415253f, 
    0.10405615f, 0.11806267f, -0.04445181f, 0.05215990f, -0.02525810f, -0.01178351f, -0.10464259f, -0.03546176f, 
    -0.32423934f, 0.29002166f, 0.16551876f, 0.02457978f, -0.10024704f, 0.04300301f, 0.05816396f, -0.14737388f, 
    0.11137103f, 0.00214732f, 0.12242737f, -0.01421110f, -0.12363512f, -0.19084433f, 0.06881579f, -0.10421804f, 
    0.00422993f, -0.08962283f, 0.06301106f, -0.04486180f, -0.08357097f, -0.05645136f, 0.03488400f, 0.04967580f, 
    -0.21137217f, -0.03840582f, 0.09615070f, 0.13032381f, 0.18801536f, 0.11964396f, -0.02278124f, 0.08097996f, 
    0.03127786f, 0.05430215f, -0.04473855f, -0.03087759f, 0.02952353f, 0.06633347f, -0.03423628f, -0.03200470f, 
    0.02889135f, 0.19427222f, -0.13184525f, 0.02299744f, -0.07599518f, 0.00797109f, -0.04857234f, -0.08185777f, 
    -0.12221363f, -0.00543605f, 0.09623400f, 0.11724719f, 0.11630049f, 0.07228945f, -0.03736026f, 0.08571626f, 
    0.16521713f, -0.00488192f, -0.16221538f, -0.00599499f, 0.14315131f, -0.09066489f, 0.02811176f, 0.11056193f, 
    -0.12598477f, -0.21834284f, -0.16868602f, 0.01904098f, 0.04697028f, -0.07412292f, 0.22383521f, 0.09498694f, 
    -0.07662869f, 0.05094922f, -0.00888654f, 0.02287706f, 0.15378924f, 0.10508458f, 0.04487187f, -0.03731256f, 
    0.11493854f, 0.11203498f, 0.01295988f, 0.04387743f, 0.38549447f, -0.10131540f, 0.16613802f, -0.03748159f, 
    0.02270891f, 0.07530519f, -0.10105061f, 0.00681044f, -0.09480532f, -0.03618466f, 0.07232347f, 0.02484903f, 
    0.51495540f, -0.34885255f, 0.09655578f, 0.09951045f, -0.06166523f, 0.11852183f, 0.14016156f, -0.02832561f, 
    0.08722930f, 0.11289409f, 0.14963810f, 0.08242073f, 0.04787928f, -0.27963820f, -0.02379712f, -0.01623736f, 
    -0.10657629f, 0.03785508f, 0.03697359f, 0.02615799f, 0.15089053f, -0.07980939f, 0.03812514f, 0.09648042f, 
    -0.09086259f, 0.04508079f, -0.06896331f, 0.12418422f, -0.15082508f, -0.18157160f, -0.03117901f, -0.09213024f, 
    0.15603432f, 0.00901689f, -0.01272541f, 0.00816915f, 0.01411359f, -0.10170002f, 0.01853853f, -0.03151723f, 
    -0.01796122f, -0.10647935f, 0.09931923f, -0.03252605f, 0.11865590f, 0.04259508f, 0.04595271f, -0.00243330f, 
    -0.18496674f, -0.01616217f, 0.09350593f, 0.01313177f, 0.01493886f, 0.06393228f, 0.23070498f, 0.10703144f, 
    -0.15878418f, -0.00183006f, 0.01652510f, 0.00360830f, -0.35378402f, -0.03524943f, -0.03676815f, -0.08989324f, 
    0.03020925f, 0.02709947f, -0.03161113f, 0.00537045f, -0.14616849f, 0.08582394f, -0.05938048f, 0.15476367f, 
    0.09304158f, -0.19570470f, -0.09718556f, -0.14169432f, -0.06994946f, 0.09174351f, -0.09162898f, 0.11192127f, 
    -0.08535534f, -0.01076831f, 0.05872025f, 0.03338378f, 0.22334781f, -0.08543526f, 0.10600632f, -0.16295806f, 
    -0.06520009f, -0.10774630f, 0.03154817f, -0.01618728f, 0.05001740f, -0.15411195f, 0.03676946f, 0.03471892f, 
    -0.06637017f, -0.13665994f, 0.05313278f, -0.03303730f, 0.09153556f, 0.05837845f, -0.08390249f, 0.06424418f, 
    -0.10437693f, 0.03010332f, -0.13995388f, -0.02313991f, 0.23151697f, 0.14842205f, -0.04088932f, 0.13106833f, 
    -0.02199211f, 0.07143024f, -0.05611016f, 0.09013005f, 0.07389729f, 0.03628635f, 0.02171323f, 0.01607009f, 
    0.13388576f, 0.07917939f, 0.03045736f, -0.16194095f, -0.14793816f, -0.09792895f, 0.12726091f, 0.04729201f, 
    -0.13873538f, -0.05702530f, -0.03521224f, 0.06867400f, 0.15445480f, -0.04217424f, 0.00856697f, -0.09997189f, 
    -0.07852170f, -0.17398027f, 0.19427899f, -0.05031231f, 0.06085458f, 0.11989597f, 0.04257032f, 0.02931361f, 
    0.21533816f, 0.03286486f, 0.01088850f, -0.06551921f, -0.11588101f, 0.01059534f, -0.02795264f, 0.02205597f, 
    0.05253692f, 0.03088374f, 0.01209695f, -0.07095867f, -0.01798250f, 0.12094936f, -0.02628825f, -0.18604515f, 
    0.14441122f, 0.19088444f, 0.13969150f, 0.15939780f, -0.00050076f, 0.03410296f, -0.12684125f, -0.01486693f, 
    0.40919313f, 0.15883596f, -0.00240376f, 0.05931587f, -0.05613581f, -0.06223480f, -0.01986250f, 0.04341563f, 
    0.10121621f, 0.08837085f, 0.15965939f, 0.05964837f, -0.53219956f, -0.04123825f, -0.10997619f, 0.12317196f, 
    0.13453183f, 0.00494790f, 0.01411276f, 0.11869717f, 0.04565748f, 0.02634910f, -0.16154948f, -0.03113525f, 
    -0.27987903f, 0.03865851f, -0.16896167f, 0.20199057f, -0.09777734f, -0.03725496f, 0.05101735f, -0.06948753f, 
    0.08885910f, -0.06250465f, 0.07246188f, 0.03692393f, 0.20554526f, -0.02163139f, 0.08638988f, 0.08481262f, 
    0.06704924f, 0.10088164f, 0.01490333f, -0.03909262f, 0.02310899f, 0.05207658f, -0.01996396f, 0.14303699f, 
    0.02486947f, 0.11775967f, -0.10206440f, 0.12507099f, -0.06702728f, 0.13992503f, 0.02315537f, -0.12129315f, 
    0.07984658f, 0.03043073f, 0.05335407f, 0.01626987f, -0.13381805f, -0.09518569f, -0.13138717f, -0.01226241f, 
    0.03889213f, 0.03690447f, 0.03000240f, -0.01697704f, -0.12608035f, -0.02527713f, -0.04538302f, -0.13302299f, 
    0.37282056f, 0.01540180f, 0.07451605f, 0.04917996f, 0.11126684f, -0.08932154f, 0.10141299f, 0.11590230f, 
    -0.01939585f, -0.03932523f, 0.03546070f, -0.03228164f, 0.62739581f, 0.35577878f, 0.16600403f, 0.11478228f, 
    -0.00666730f, -0.01430387f, 0.13829839f, 0.03393139f, 0.08674063f, 0.08886103f, -0.01297162f, 0.03813972f, 
    0.05205883f, 0.28293535f, 0.06022421f, -0.01424076f, 0.00193235f, -0.02498449f, -0.08587313f, 0.01328045f, 
    -0.04501798f, 0.02450675f, 0.04629957f, -0.06487995f, 0.02088409f, -0.04482802f, -0.05971563f, 0.08651946f, 
    0.06633796f, -0.00645027f, -0.00441323f, 0.04069639f, 0.09758264f, -0.02683838f, 0.05225125f, -0.09860045f, 
    -0.18884377f, 0.03463585f, -0.01846564f, -0.02731744f, -0.04556237f, 0.09128472f, 0.07289764f, -0.10620485f, 
    0.04376364f, -0.05762709f, 0.01667303f, 0.07174201f, 0.02547248f, -0.14242138f, -0.19243219f, 0.05089594f, 
    0.05967684f, 0.09756009f, -0.02377594f, 0.07118170f, -0.08705968f, 0.05720972f, -0.08973909f, 0.03461231f, 
    0.01349883f, -0.14650939f, -0.16311976f, -0.04819070f, 0.08693483f, -0.14409597f, 0.10486274f, 0.02700057f, 
    -0.06428210f, 0.02579821f, -0.13856308f, 0.04842550f, -0.20813124f, -0.00959941f, -0.16723327f, -0.11949871f, 
    0.01779926f, -0.10877012f, 0.03815595f, -0.16391915f, 0.15076230f, 0.00729348f, -0.00506207f, 0.03501759f, 
    0.02881885f, -0.13718320f, 0.00525265f, -0.00361293f, 0.10087487f, 0.06167418f, 0.02872911f, 0.04955752f, 
    0.05820206f, 0.05778443f, -0.02747477f, 0.13331091f, 0.08312824f, 0.01205907f, -0.21412268f, 0.06670035f, 
    0.08143294f, -0.04501394f, -0.01543833f, -0.02996862f, 0.08450028f, 0.10385975f, -0.02858052f, 0.03788978f, 
    0.18149045f, -0.19493569f, -0.02451983f, -0.16529471f, 0.05287065f, -0.00151841f, 0.04883810f, -0.00885249f, 
    -0.04060422f, 0.00107416f, -0.15396869f, -0.03568175f, 0.23242524f, 0.27472582f, 0.07503405f, 0.10214522f, 
    -0.03648669f, -0.13854684f, 0.06907494f, 0.01252519f, 0.05882246f, -0.03145291f, -0.01215032f, 0.06549528f, 
    0.27041516f, 0.03585520f, 0.10554799f, -0.07852553f, 0.00978945f, 0.06292531f, 0.06667003f, 0.01385961f, 
    -0.07631161f, 0.10727925f, -0.01975390f, -0.02444205f, -0.24081478f, 0.12216192f, -0.18700318f, -0.09316830f, 
    -0.08507859f, -0.07574996f, 0.06263272f, -0.01271972f, -0.04513638f, -0.03365543f, 0.07070004f, 0.14320455f, 
    -0.11603710f, 0.02517159f, -0.13094524f, -0.19288336f, -0.03268041f, -0.01975648f, -0.07932551f, 0.10620036f, 
    -0.02365522f, -0.02817859f, -0.08479472f, 0.14040193f, 0.10581689f, 0.24457197f, -0.04850180f, -0.08070777f, 
    0.01942981f, -0.07355645f, 0.04814166f, 0.03081154f, 0.01524247f, 0.00827441f, 0.04922836f, 0.03468831f, 
    -0.31836414f, -0.06541491f, -0.05048570f, 0.03845222f, 0.03079261f, 0.08946165f, 0.05904643f, -0.08394780f, 
    0.03324431f, 0.03660362f, -0.16852657f, 0.11190006f, -0.48533088f, -0.27350590f, 0.03713221f, 0.00683668f, 
    0.01895443f, 0.13181569f, -0.15881160f, -0.02034212f, -0.00797291f, 0.07159626f, 0.03851407f, -0.02888830f, 
    -0.26701316f, -0.10814173f, 0.00009104f, -0.07732118f, -0.08716390f, 0.02779643f, 0.05455745f, 0.00191469f, 
    -0.04335361f, 0.06512158f, -0.21704382f, 0.06538992f, -0.00287359f, -0.00952205f, 0.02241355f, -0.06476244f, 
    -0.02792466f, -0.03837452f, 0.02075634f, 0.13710935f, -0.06418717f, 0.04505965f, -0.09157482f, 0.02567432f, 
    0.03375003f, 0.03808377f, 0.11773533f, -0.06662224f, -0.02385558f, -0.03247016f, -0.00333548f, 0.18665563f, 
    -0.00467988f, 0.03124194f, -0.07038873f, 0.06430898f, 0.09811971f, 0.06479037f, 0.18660660f, 0.12287463f, 
    -0.05224895f, -0.02587221f, 0.04820851f, 0.09117479f, 0.00950139f, 0.02345932f, -0.08448694f, -0.09673681f, 
    0.15894157f, 0.02169750f, 0.09794077f, -0.00303943f, 0.14240381f, 0.08373456f, 0.02972360f, -0.10429793f, 
    -0.09726375f, 0.07575268f, -0.04781249f, 0.05749811f, 0.29712370f, 0.07686926f, 0.18128696f, 0.26321861f, 
    0.06977172f, 0.06451058f, 0.04760513f, 0.16095214f, -0.10059121f, 0.11006017f, -0.03737679f, 0.03626403f, 
    0.15873358f, -0.08663329f, -0.02140377f, 0.25516737f, 0.10115404f, 0.09477520f, -0.00672804f, 0.04317783f, 
    0.00331347f, -0.05791478f, 0.02661406f, 0.07733466f, 0.21461561f, -0.06187269f, 0.17675494f, 0.01123894f, 
    -0.07795457f, 0.10749853f, 0.11801046f, -0.01295914f, 0.03647237f, -0.02246265f, 0.10519778f, -0.14054894f, 
    -0.39826921f, 0.21312730f, 0.03257353f, 0.04850797f, 0.10181829f, -0.00286551f, -0.09851964f, 0.01220621f, 
    0.07051250f, 0.09327009f, 0.05987789f, 0.09372818f, -0.22260620f, -0.31631368f, 0.12526807f, 0.01152190f, 
    -0.02836507f, -0.01621612f, 0.09940140f, -0.02421900f, -0.01792276f, 0.04258344f, -0.08648475f, 0.07231598f, 
    -0.02718735f, 0.02453953f, 0.09019530f, 0.03009996f, -0.06335468f, -0.00674524f, 0.05632010f, 0.05708406f, 
    0.02415124f, -0.10603170f, 0.00032964f, -0.12341682f, -0.13216551f, -0.19963488f, 0.22322580f, -0.08714311f, 
    -0.04192320f, 0.07355673f, 0.08989371f, 0.02878445f, -0.00616683f, -0.02304764f, -0.09497950f, -0.06361555f, 
    -0.27532324f, -0.14052656f, 0.17535125f, -0.03638562f, -0.00976509f, -0.02025737f, 0.09407910f, 0.00147573f, 
    0.03532814f, -0.05778033f, 0.02930877f, -0.05464715f, -0.25871211f, -0.07279624f, 0.10577771f, 0.12163562f, 
    -0.02757825f, -0.00947247f, 0.01762386f, -0.01791310f, -0.00197257f, -0.15647298f, 0.07313605f, 0.02545286f, 
    0.19358462f, -0.05001165f, 0.03311678f, 0.06247955f, 0.01101900f, 0.12272766f, 0.04567648f, 0.03144162f, 
    0.07616044f, 0.09506785f, 0.14282642f, -0.07465765f, -0.00029972f, 0.06069589f, 0.04046036f, -0.03261200f, 
    -0.15116097f, -0.10806818f, 0.04281636f, 0.04658767f, -0.07862195f, 0.09483749f, 0.08823446f, -0.01534953f, 
    0.22160359f, -0.06402283f, 0.04064728f, 0.22231084f, 0.10477789f, 0.05887336f, 0.05444745f, 0.00336751f, 
    0.00105194f, 0.04708492f, -0.07789772f, 0.09774216f, -0.23754564f, 0.08178724f, 0.07351043f, 0.01188017f, 
    0.00018439f, 0.11081427f, 0.01932748f, 0.07354735f, 0.11713889f, 0.08990218f, 0.10886559f, 0.14871803f, 
    0.00461497f, 0.12909032f, 0.08456099f, 0.18363109f, 0.00909841f, 0.05609353f, 0.08079059f, -0.03711151f, 
    -0.07056600f, -0.04668971f, 0.00339105f, 0.07666363f, -0.06316879f, 0.00802280f, 0.09691663f, 0.04855194f, 
    0.04808666f, -0.02576336f, 0.04496779f, -0.01132488f, 0.05199450f, -0.13225698f, 0.04989598f, 0.05889914f, 
    -0.15834737f, 0.04741032f, -0.06376683f, 0.05872276f, 0.01219240f, 0.01124171f, 0.01623508f, 0.00616327f, 
    0.07470244f, -0.01011251f, -0.07235770f, 0.01055908f, -0.08079357f, 0.01789452f, -0.19563076f, -0.07953793f, 
    0.03818038f, 0.09756373f, 0.12365732f, -0.07968944f, 0.00417710f, -0.00523166f, 0.06600042f, 0.12529738f, 
    -0.35764214f, -0.01754807f, -0.10945353f, -0.14740714f, 0.07892399f, -0.09922922f, 0.01366414f, -0.10693508f, 
    -0.08432861f, -0.05766777f, 0.06840228f, -0.11285864f, -0.03870971f, 0.04979183f, 0.02301572f, 0.06634510f, 
    0.03841103f, 0.00826240f, 0.01119676f, -0.03819716f, -0.00458768f, -0.03822107f, -0.06501366f, -0.03411902f, 
    0.52221543f, 0.18453950f, 0.05291868f, -0.03218212f, -0.05275959f, 0.21406168f, -0.03873385f, 0.02907171f, 
    -0.14852591f, -0.04337495f, 0.04618777f, -0.01477479f, 0.01122624f, 0.16447027f, -0.03766083f, -0.03510474f, 
    -0.11994898f, -0.08397619f, -0.05340810f, -0.00589930f, 0.07709181f, 0.07082865f, 0.00239051f, -0.14439735f, 
    0.11660802f, -0.05771612f, -0.05375256f, 0.08808067f, -0.14646293f, 0.16049691f, -0.02510645f, 0.00968491f, 
    -0.02700369f, 0.02907233f, -0.06068796f, -0.02324207f, -0.02503901f, 0.34245020f, 0.00105957f, 0.30386052f, 
    -0.10432825f, 0.05423868f, 0.03492059f, -0.00706333f, -0.00536879f, 0.02562888f, 0.05054722f, -0.02686091f, 
    0.03568939f, 0.21240258f, -0.08966232f, -0.09064451f, -0.03190582f, -0.06550877f, 0.04823830f, 0.02892101f, 
    -0.02319646f, 0.08145792f, -0.02256314f, -0.02727069f, -0.10901604f, 0.22099835f, -0.04478350f, -0.21372803f, 
    -0.12228323f, -0.10778379f, -0.10976773f, -0.09083325f, -0.05128522f, 0.05637335f, -0.01567993f, 0.05064564f, 
    0.25762740f, -0.32569432f, 0.10721165f, -0.02684595f, 0.08053058f, 0.05735959f, 0.04134349f, 0.01606619f, 
    -0.15926035f, -0.05236394f, -0.16538902f, -0.06728305f, -0.08287846f, 0.04312662f, 0.08078252f, 0.08201983f, 
    0.00362993f, 0.11605765f, 0.06305981f, -0.11178065f, 0.09526618f, 0.03941968f, -0.04870976f, -0.08634846f, 
    -0.11796761f, 0.01086716f, 0.14734182f, 0.23287210f, -0.12451646f, 0.00163432f, -0.06160150f, 0.00275356f, 
    -0.05996497f, 0.12439325f, -0.03192313f, -0.05493945f, 0.07313284f, -0.01610846f, 0.18901990f, 0.17105389f, 
    0.04646572f, -0.04798173f, -0.04260761f, 0.13616531f, -0.04569633f, 0.12347334f, -0.11733955f, -0.07352156f, 
    -0.28817746f, 0.11665946f, 0.04409714f, -0.35854334f, -0.00105639f, -0.02764556f, -0.01503388f, -0.00138361f, 
    0.08599051f, 0.09076169f, 0.00369448f, -0.01442038f, -0.14292707f, -0.04281857f, 0.16601816f, -0.06263634f, 
    0.00301445f, -0.03173807f, -0.11771587f, 0.06741905f, -0.01508974f, 0.07559711f, -0.05423447f, 0.03291242f, 
    0.20912287f, 0.05491488f, 0.20050247f, 0.14393619f, 0.03926187f, 0.06928802f, -0.05261660f, 0.22806101f, 
    0.08706988f, -0.07863506f, 0.05763574f, 0.10885236f, 0.11474143f, -0.05822398f, 0.07691135f, 0.05416194f, 
    0.06908216f, 0.13471168f, 0.16228914f, 0.11941039f, -0.02868189f, 0.04872232f, 0.07577209f, 0.00855411f, 
    -0.04160292f, 0.04095270f, -0.00392386f, 0.11751985f, -0.04130125f, 0.05029035f, -0.01539275f, 0.02749724f, 
    0.00099253f, -0.05524180f, 0.11327754f, 0.00502584f, -0.05211386f, -0.06450896f, 0.03410447f, -0.02396731f, 
    0.07657113f, 0.03172089f, 0.03940625f, -0.08874042f, -0.03634431f, 0.10846261f, 0.12605570f, -0.00451981f, 
    -0.12204266f, 0.14510359f, 0.03203418f, -0.07924472f, 0.02700383f, -0.08572942f, -0.00246562f, 0.13751766f, 
    0.04255704f, -0.01480221f, 0.06886315f, -0.01067296f, -0.15463696f, -0.15279193f, -0.10310400f, -0.22653358f, 
    0.00894133f, 0.02531356f, 0.13593133f, 0.02604681f, 0.06109750f, -0.02521348f, 0.03205715f, 0.10398871f, 
    0.09724732f, 0.19140844f, 0.11952301f, -0.20155531f, 0.17307203f, -0.13309026f, -0.03980218f, 0.01138597f, 
    -0.07516997f, 0.02026904f, -0.00722634f, 0.06411170f, 0.25061032f, -0.10911313f, 0.03405830f, -0.25855023f, 
    -0.05451923f, -0.05083085f, -0.01942150f, 0.00758997f, 0.01333001f, -0.01255962f, 0.02835128f, 0.02852377f, 
    -0.03826223f, -0.18000785f, 0.11921532f, -0.00804238f, 0.04812538f, 0.07806104f, -0.05131191f, 0.04016622f, 
    0.10264163f, 0.11845203f, 0.05395593f, -0.01720125f, 0.08457658f, -0.08083922f, 0.11697224f, 0.22605816f, 
    0.01368057f, 0.10579409f, 0.02571470f, 0.04946117f, 0.05266588f, -0.00715846f, 0.03758116f, 0.04498516f, 
    -0.43960452f, 0.24694477f, -0.10600894f, 0.07032908f, -0.10896105f, -0.02991484f, 0.01319948f, 0.03149408f, 
    0.08003497f, 0.08478860f, -0.01831304f, 0.09505118f, -0.05830606f, -0.17757413f, -0.15171573f, -0.05127613f, 
    -0.02981776f, -0.06457490f, -0.07814065f, -0.03559634f, -0.05769377f, 0.02166808f, 0.02229870f, 0.03912377f, 
    0.08261104f, 0.11918630f, -0.12072350f, -0.43620220f, -0.03877909f, -0.11240473f, 0.06708298f, -0.00881105f, 
    0.02733594f, 0.06766173f, 0.12976189f, -0.08404781f, -0.10168575f, -0.05229796f, -0.03947769f, -0.07224219f, 
    0.03793653f, 0.11690620f, -0.07920808f, -0.05398979f, 0.08018968f, -0.03087024f, 0.07569084f, 0.05386450f, 
    0.17671503f, -0.12316473f, -0.02733539f, 0.45719427f, 0.03248664f, -0.01894815f, -0.03286223f, 0.04346899f, 
    -0.03886059f, -0.06416589f, -0.01161409f, -0.01277765f, 0.15324065f, 0.05259075f, -0.01599199f, 0.00699214f, 
    0.05608776f, 0.01115368f, 0.05679875f, 0.03872040f, 0.00050614f, 0.02530657f, 0.08962444f, 0.04346950f, 
    -0.08312824f, 0.22335537f, 0.06117190f, -0.08003866f, 0.01645548f, 0.04616869f, 0.05299939f, -0.12932315f, 
    -0.10431480f, 0.02036080f, -0.03510605f, 0.00658834f, 0.13174258f, 0.03508882f, 0.12042404f, 0.09103821f, 
    0.06194839f, 0.05270316f, -0.03728512f, 0.06890196f, -0.02012841f, -0.04486705f, -0.00440018f, 0.02075224f, 
    -0.07797645f, 0.12920167f, 0.09697545f, 0.01275420f, 0.03153284f, 0.11076213f, 0.03135738f, 0.01202477f, 
    0.06513558f, 0.21946727f, -0.13815543f, -0.14335760f, 0.09005271f, -0.01172105f, -0.01693025f, 0.04652354f, 
    -0.10804280f, -0.01092670f, 0.06323379f, 0.11747075f, 0.06498837f, 0.00097478f, -0.05871860f, -0.00749575f, 
    -0.10776946f, 0.04400939f, 0.04549969f, 0.09676690f, 0.02828540f, 0.07851857f, 0.12068047f, -0.02109190f, 
    0.07579995f, 0.05681489f, -0.06762973f, 0.06650281f, -0.08137803f, -0.10322277f, 0.19456686f, 0.29389355f, 
    0.03487676f, 0.06776677f, 0.00434984f, 0.00186460f, 0.00330254f, 0.08978362f, -0.04647412f, 0.02127016f, 
    0.20130897f, 0.11434615f, -0.04263017f, -0.08517003f, 0.15919447f, -0.20882884f, 0.08231467f, 0.08919661f, 
    -0.00885518f, 0.05557543f, 0.03668738f, -0.06018934f, -0.30925041f, 0.21188593f, 0.04753832f, -0.14250959f, 
    0.14176382f, -0.12483789f, 0.02706807f, -0.17471868f, -0.07036108f, 0.05101809f, 0.19445468f, 0.01250609f, 
    0.06503265f, -0.03422149f, 0.04011495f, -0.18644103f, 0.04400085f, -0.10691855f, -0.12659043f, 0.11246331f, 
    0.04376506f, -0.05847266f, -0.27371448f, 0.07008349f, -0.09375098f, -0.02532121f, -0.06211452f, 0.08562388f, 
    -0.01015192f, -0.17200020f, -0.04798047f, -0.13784221f, 0.07283950f, -0.08906004f, -0.10516937f, -0.03018227f, 
    0.04590444f, 0.17168732f, -0.03734085f, 0.20501907f, -0.07894679f, 0.04186470f, 0.04393984f, -0.17552170f, 
    0.04257159f, 0.07835372f, 0.16526426f, 0.08116956f, 0.13285021f, -0.26069728f, -0.03705623f, -0.05450775f, 
    0.12148246f, 0.01004567f, -0.17433935f, -0.02595824f, -0.05350979f, -0.23308538f, -0.10127954f, 0.07806519f, 
    -0.09899835f, 0.07031553f, -0.19104235f, 0.02781348f, 0.18546209f, 0.11950349f, 0.06204452f, -0.02789794f, 
    0.01987744f, 0.05468161f, -0.14185727f, 0.04688156f, -0.25444084f, 0.20071635f, -0.09659561f, -0.04380923f, 
    -0.01034497f, 0.17038913f, 0.13300964f, 0.22172569f, -0.05636095f, 0.16602802f, 0.18220384f, 0.16457845f, 
    -0.05709981f, 0.19075313f, 0.23025228f, 0.05400577f, 0.01584636f, 0.12729354f, 0.04172045f, 0.00850362f, 
    -0.02351796f, 0.01410868f, -0.05213847f, 0.14655416f, -0.06738906f, -0.10365020f, 0.13882932f, 0.01913963f, 
    0.09982149f, -0.07540065f, 0.07750817f, 0.01734699f, 0.09928351f, 0.01448711f, 0.14449893f, -0.01387885f, 
    0.00146842f, -0.14713010f, 0.02126610f, 0.01121770f, -0.01469026f, 0.17870666f, 0.06994861f, -0.00668066f, 
    0.03724292f, 0.04810105f, -0.07155190f, -0.11996222f, 0.08423287f, 0.13528204f, -0.09322786f, 0.23998378f, 
    -0.05801205f, 0.04024529f, 0.05184446f, 0.13376969f, -0.13448863f, 0.08716191f, 0.18472131f, 0.11628497f, 
    0.01499628f, -0.08748754f, -0.07094600f, 0.00542291f, 0.08471636f, 0.02257851f, -0.08039214f, -0.14234395f, 
    -0.03696894f, -0.25935611f, -0.05476700f, -0.11513321f, 0.12676002f, -0.19774516f, -0.08491555f, 0.00875129f, 
    0.06993435f, -0.09725813f, -0.03372394f, 0.01395669f, -0.04908265f, -0.24991333f, -0.01895678f, -0.09027998f, 
    -0.01359075f, 0.15521820f, -0.02368996f, -0.11432533f, -0.04795747f, 0.15451734f, -0.05707309f, 0.08549948f, 
    0.06843719f, 0.05645157f, -0.06403715f, 0.04075536f, 0.36950457f, 0.00526208f, 0.38158408f, -0.07423105f, 
    0.01671217f, 0.21419656f, -0.07400061f, -0.06781148f, 0.01554591f, -0.08456765f, 0.02703516f, 0.03864992f, 
    -0.09691275f, -0.04776932f, -0.11516336f, 0.09540824f, -0.00167586f, 0.11656052f, -0.03462128f, 0.03338307f, 
    0.04898906f, 0.03007247f, -0.04966812f, -0.01380427f, 0.15564947f, 0.45309091f, 0.00392989f, 0.42571568f, 
    -0.03405946f, 0.08215725f, -0.03334150f, 0.07634059f, -0.01090449f, 0.04970001f, 0.04675670f, 0.03551040f, 
    0.06286333f, 0.18802422f, -0.03394262f, -0.08916867f, 0.07015348f, -0.00945893f, 0.00144119f, 0.05421740f, 
    -0.08651475f, -0.05900007f, -0.06057505f, -0.07361466f, -0.07268642f, 0.11321872f, -0.28493002f, -0.16927844f, 
    0.00942206f, -0.07196376f, 0.02796376f, -0.06889563f, -0.10204174f, 0.08202223f, -0.06202069f, 0.00409248f, 
    0.24361657f, -0.12243121f, 0.31380582f, -0.15210503f, -0.13888210f, -0.02595499f, -0.06933348f, 0.03703524f, 
    -0.06166747f, -0.08159649f, -0.01008805f, -0.06176367f, 0.04403235f, 0.07465075f, 0.37464127f, 0.07841609f, 
    -0.09001871f, 0.04643158f, 0.04425269f, -0.03763435f, 0.06418307f, 0.02082804f, 0.06231184f, 0.03170241f, 
    0.06293675f, 0.17200801f, 0.08771472f, 0.24836192f, -0.11382548f, 0.02844844f, -0.05928090f, 0.03476538f, 
    -0.09925022f, -0.01442301f, 0.01146357f, 0.09279218f, 0.20207326f, -0.13440692f, -0.00036839f, -0.02451771f, 
    0.22944413f, -0.00101363f, -0.03556523f, -0.00225752f, -0.00582720f, 0.03051664f, -0.11217681f, 0.13482326f, 
    -0.35309547f, 0.12619004f, 0.26830253f, -0.30028784f, -0.02438294f, 0.02258488f, 0.02263653f, 0.11767528f, 
    -0.04336783f, 0.05972440f, 0.05025938f, 0.11308338f, -0.32789680f, -0.02762057f, 0.09203874f, 0.02719550f, 
    -0.04373056f, -0.02766725f, -0.06474642f, 0.07164688f, 0.07467290f, -0.02985064f, 0.04526759f, -0.03488235f, 
    -0.13336399f, -0.12965435f, 0.02321443f, 0.08039470f, 0.16236658f, 0.03818551f, 0.00592824f, 0.17175952f, 
    0.03682718f, -0.00466978f, 0.02633484f, 0.09804600f, -0.05408939f, -0.02865199f, 0.05375647f, -0.14040373f, 
    0.12668714f, 0.01505849f, 0.07094438f, 0.19541968f, -0.00962307f, 0.04981203f, 0.00512729f, 0.06623702f, 
    0.06252269f, 0.05151222f, -0.08787662f, 0.08767506f, 0.05360480f, 0.04632062f, 0.04804792f, 0.04131370f, 
    0.13092531f, -0.01949014f, -0.01104969f, 0.07852478f, -0.10416429f, 0.03033211f, 0.01137459f, -0.07136204f, 
    0.01785788f, 0.03190865f, -0.03598883f, -0.07207012f, -0.01496846f, -0.08334774f, 0.16661181f, 0.07983058f, 
    -0.39498270f, 0.01390996f, 0.10219642f, -0.09761827f, 0.09255833f, -0.13856134f, 0.01209347f, 0.02695098f, 
    0.15854850f, 0.03656789f, -0.00782511f, 0.06062072f, -0.01757043f, -0.07665062f, -0.05856038f, -0.05858003f, 
    0.05769577f, 0.03463985f, 0.13592015f, 0.09225486f, -0.00338244f, 0.00168657f, 0.02312289f, 0.02768596f, 
    0.46057451f, -0.08640423f, 0.13702270f, -0.18891081f, 0.08899924f, -0.01435321f, 0.03060670f, 0.13011840f, 
    0.00724825f, 0.09582944f, -0.05466833f, -0.01743867f, 0.25427464f, -0.02719454f, 0.07931723f, -0.06623109f, 
    0.00312955f, -0.08123578f, -0.11512053f, 0.02984567f, 0.18306136f, -0.07643331f, 0.07057071f, -0.03498502f, 
    0.19794050f, -0.13623634f, 0.10134491f, -0.06170934f, 0.06419808f, 0.00973534f, 0.06132442f, 0.04652083f, 
    -0.00096781f, 0.07994440f, 0.09145638f, -0.15923633f, 0.09436163f, 0.10097103f, 0.03160742f, 0.11641935f, 
    0.02644738f, 0.06012714f, -0.11620545f, 0.08630580f, -0.03356495f, 0.06436501f, 0.03744044f, 0.02011907f, 
    -0.27822927f, -0.12990893f, -0.06233019f, -0.04294891f, 0.04111556f, -0.00886447f, -0.10473847f, -0.04590014f, 
    0.03646616f, -0.06260479f, -0.09182753f, 0.06264514f, -0.17901878f, -0.02763184f, -0.06151859f, 0.06332365f, 
    0.18650703f, 0.04813898f, -0.03635634f, -0.03311009f, 0.05224024f, 0.00747460f, 0.00051327f, -0.00588102f, 
    0.02331237f, -0.15514785f, 0.07650100f, -0.13164674f, 0.10682408f, 0.04832749f, 0.02777536f, -0.11572716f, 
    0.00306805f, -0.06054362f, 0.17565216f, -0.05595539f, 0.22575499f, -0.15344952f, 0.04723522f, 0.06681575f, 
    -0.10899280f, -0.05640585f, 0.01630174f, -0.09601931f, -0.05742235f, -0.01708762f, -0.01700000f, 0.00035675f, 
    0.15492842f, -0.15493636f, -0.25294879f, 0.13470101f, 0.09019376f, -0.05631657f, -0.07087017f, 0.07329556f, 
    0.07818687f, 0.05364398f, 0.06174961f, 0.04995009f, 0.29431707f, 0.16646409f, 0.04527994f, -0.01517155f, 
    -0.04952627f, 0.03823386f, -0.01687384f, 0.00512288f, 0.10233219f, 0.05382347f, 0.08711164f, 0.05641013f, 
    -0.03418860f, 0.14632455f, 0.13688490f, -0.04053748f, -0.03183217f, 0.01156251f, -0.13098218f, 0.11001663f, 
    -0.05955661f, 0.04013201f, 0.15409806f, -0.00127013f, 0.03625046f, -0.16172266f, 0.05964121f, 0.17943609f, 
    0.05963908f, -0.00263067f, 0.04560602f, 0.12539333f, 0.09678540f, 0.03210473f, -0.05197033f, -0.10095299f, 
    -0.16822642f, 0.11385264f, 0.14539510f, 0.04329845f, -0.09819889f, -0.07720219f, 0.00530807f, -0.12461607f, 
    0.00209282f, 0.10669462f, -0.02820028f, 0.11630887f, 0.07846998f, 0.06808630f, 0.08606821f, 0.05798338f, 
    0.09426130f, 0.11912240f, 0.07077350f, 0.04728896f, -0.09318881f, 0.11582021f, -0.04702857f, 0.13745847f, 
    -0.10648596f, 0.04088233f, -0.01293850f, 0.18113740f, -0.07246707f, -0.00737519f, 0.02422733f, 0.04035410f, 
    0.01800997f, -0.06420110f, 0.04502583f, -0.03077988f, -0.44496807f, -0.15631354f, -0.06172306f, 0.11428463f, 
    0.05314250f, 0.16162975f, 0.12144725f, -0.09279230f, 0.01806200f, 0.01041898f, -0.00693365f, -0.00995488f, 
    -0.13931191f, -0.15211801f, 0.14325975f, 0.22133382f, -0.02208359f, 0.03241958f, -0.04340936f, -0.06669335f, 
    0.12180082f, 0.11615065f, -0.02744665f, 0.08446112f, 0.25175083f, -0.17327228f, -0.01706378f, 0.14382048f, 
    -0.11655736f, 0.13655065f, 0.03708627f, 0.09169847f, 0.02568037f, 0.07746205f, 0.03474022f, -0.03637961f, 
    -0.13152726f, -0.02380067f, 0.01838846f, 0.07082166f, -0.08017116f, -0.09932557f, 0.12024612f, -0.21609418f, 
    0.06832412f, -0.01373939f, 0.05022690f, -0.02280552f, -0.10226562f, -0.13271706f, 0.15347981f, 0.07543372f, 
    -0.07282805f, 0.03801962f, -0.06816850f, 0.10296856f, 0.07748483f, 0.15849982f, 0.03957859f, -0.01527805f, 
    0.06874235f, -0.08194509f, 0.05825721f, 0.01600918f, 0.00204225f, -0.11006178f, 0.00676668f, -0.05201683f, 
    -0.05586323f, 0.02486392f, -0.03037725f, 0.00137580f, -0.17266604f, 0.18080263f, -0.08394877f, -0.00597150f, 
    -0.14980374f, -0.04719901f, -0.02143660f, 0.01121944f, 0.07257000f, 0.07306638f, 0.07260946f, 0.13121349f, 
    0.31964961f, 0.00509421f, -0.01501363f, 0.31221524f, 0.05895684f, -0.04623406f, 0.01280931f, -0.02860666f, 
    0.01641572f, -0.11553749f, 0.15839757f, -0.06529859f, 0.06950913f, -0.04815790f, 0.15292923f, -0.26897943f, 
    -0.01572932f, 0.07593651f, -0.00795367f, -0.07775399f, 0.05472963f, -0.06411079f, 0.03653959f, -0.02441970f, 
    0.27261627f, 0.02103754f, -0.01605129f, 0.06675573f, 0.04426199f, 0.05777032f, 0.07991218f, 0.02988261f, 
    0.09622242f, -0.00135779f, 0.01099286f, 0.08375543f, -0.19475944f, 0.29240027f, 0.06243504f, 0.07012340f, 
    0.00878694f, 0.07502550f, -0.04145674f, 0.07112160f, 0.09116095f, 0.06543653f, -0.04271327f, 0.00015866f, 
    0.17831416f, 0.26622415f, 0.04854545f, -0.14152384f, -0.06674721f, -0.24557416f, -0.05114448f, -0.00081502f, 
    -0.00320900f, -0.01177318f, -0.08290825f, 0.03323789f, -0.02720805f, 0.11587574f, 0.13112663f, -0.22139509f, 
    -0.00067262f, -0.07658417f, 0.12679611f, -0.08433313f, -0.05563999f, 0.04536654f, -0.10800409f, 0.01696827f, 
    0.20573425f, 0.07288114f, -0.11296644f, -0.17776015f, -0.06672195f, 0.08414633f, 0.07262670f, 0.03340776f, 
    -0.00918857f, 0.00917027f, -0.04737633f, 0.00708567f, -0.40374607f, -0.01964329f, 0.08383752f, -0.05909813f, 
    0.03593320f, 0.10691220f, 0.06271230f, 0.02447263f, 0.11917218f, 0.04367221f, -0.02560158f, -0.03273893f, 
    0.26061961f, 0.02648952f, 0.05361651f, 0.06246737f, -0.04193391f, 0.05246647f, 0.03307934f, 0.05990564f, 
    -0.02589175f, 0.01439651f, 0.06764256f, 0.09245329f, 0.05377747f, 0.16705030f, -0.40843546f, -0.03267732f, 
    0.09594829f, -0.11230369f, -0.06294666f, 0.00349558f, 0.10580745f, 0.03012993f, -0.08063561f, 0.10764235f, 
    -0.36454478f, 0.09481120f, 0.05984784f, 0.02747149f, 0.03044846f, 0.02868255f, 0.04458761f, -0.02563161f, 
    -0.11492150f, -0.00307989f, 0.00141502f, 0.06560671f, -0.24560815f, -0.19304535f, -0.34260723f, -0.39611357f, 
    -0.13365881f, -0.10096859f, -0.07421704f, -0.00725745f, -0.02316674f, -0.01642177f, -0.00001279f, 0.03280727f, 
    -0.40096983f, -0.03704802f, -0.06021324f, -0.03846561f, -0.07109734f, 0.01196229f, 0.00754916f, 0.06378518f, 
    -0.04686835f, -0.04219172f, 0.01213068f, 0.18513112f, 0.03024492f, -0.00001073f, 0.14650120f, -0.07113785f, 
    0.02769660f, -0.11735707f, 0.05173086f, 0.03481093f, -0.04828512f, -0.15739867f, 0.05488178f, -0.01391692f, 
    0.12851693f, -0.05307302f, -0.35737845f, 0.16667961f, 0.06884297f, -0.14335218f, -0.03361044f, -0.11447909f, 
    0.13078286f, 0.14645258f, -0.01722004f, 0.17305188f, -0.12780714f, -0.15250027f, -0.31436706f, -0.18486160f, 
    -0.08673903f, -0.12294750f, -0.08798833f, -0.13019629f, 0.03543122f, -0.00659026f, 0.22928175f, -0.08728376f, 
    -0.02735446f, -0.07688971f, -0.16642931f, -0.00349289f, 0.00467567f, -0.16494632f, 0.02873220f, -0.02127000f, 
    -0.00564562f, 0.05964352f, -0.06844136f, 0.03959059f, -0.09087281f, 0.11224548f, 0.11878993f, 0.03931100f, 
    0.01297555f, -0.01677313f, 0.09021703f, 0.17617933f, 0.05469953f, 0.04340797f, -0.01125147f, -0.02783232f, 
    0.20972611f, 0.02056363f, -0.08796533f, 0.16771866f, -0.06574616f, 0.09878159f, -0.02720772f, -0.03944094f, 
    0.06433102f, 0.00449074f, -0.03212742f, -0.01500063f, 0.07766126f, 0.13767956f, 0.01859850f, 0.04074674f, 
    0.08217344f, 0.12119815f, 0.01472455f, 0.15842150f, -0.03886366f, -0.04272237f, 0.08235645f, 0.11851377f, 
    0.48454574f, 0.21912488f, 0.00155048f, 0.17161204f, 0.04194611f, 0.04252685f, 0.20865069f, 0.01890131f, 
    -0.08752760f, -0.02305214f, -0.14703394f, -0.03618824f, 0.24080780f, 0.08438250f, 0.13857050f, 0.37294832f, 
    -0.04244984f, 0.05603218f, -0.01803789f, -0.08702527f, -0.17997444f, 0.00011669f, 0.02873134f, 0.02523073f, 
    0.34496850f, -0.01894392f, 0.17398204f, 0.34657660f, 0.05212977f, 0.03039895f, -0.06307642f, 0.00894577f, 
    -0.07442342f, -0.05491380f, -0.00984930f, 0.04248369f, -0.07106186f, 0.03478242f, 0.11509977f, 0.26304305f, 
    -0.02107593f, 0.03830029f, -0.07027562f, 0.10586409f, 0.02915186f, 0.03389851f, 0.00987667f, 0.01562547f, 
    0.00871310f, 0.13098940f, -0.06760790f, 0.00246137f, 0.10209206f, 0.02389679f, -0.00631187f, 0.15113746f, 
    -0.02259712f, -0.03353961f, 0.00561694f, 0.04087037f, 0.30360398f, -0.00682052f, 0.13608658f, -0.18540300f, 
    -0.08398692f, -0.03286216f, -0.19079542f, -0.03588299f, 0.11879764f, 0.06646138f, 0.05171528f, 0.14609869f, 
    -0.18975048f, 0.04461381f, 0.07057607f, -0.17193773f, 0.08295490f, -0.08098235f, 0.11154950f, 0.05823289f, 
    -0.09630367f, 0.06086309f, -0.14170040f, -0.01148585f, -0.09438861f, 0.09912955f, -0.29610550f, 0.17775685f, 
    -0.00852239f, -0.00984617f, 0.09677448f, 0.08264566f, -0.04641713f, 0.08348292f, 0.04243479f, 0.04825004f, 
    -0.07390329f, -0.04448773f, 0.11340836f, -0.15869831f, 0.00018865f, -0.11572487f, 0.10436339f, 0.07232614f, 
    -0.01512617f, 0.08921354f, -0.06038550f, 0.02017402f, 0.13866165f, 0.20221892f, -0.00876476f, -0.02833402f, 
    0.03157903f, -0.14473043f, -0.05008293f, 0.02142463f, -0.02537418f, -0.05059573f, 0.13319458f, -0.12203228f, 
    -0.22197391f, 0.21654743f, -0.00551984f, 0.12846777f, -0.05768132f, 0.06396520f, -0.02684197f, -0.10788209f, 
    0.03119145f, 0.01404635f, -0.03017853f, 0.10423262f, -0.28785914f, -0.17444450f, 0.18968306f, 0.11748355f, 
    0.12661937f, -0.02495591f, -0.10262991f, 0.02835434f, -0.07090029f, -0.02757141f, -0.01344478f, 0.10266367f, 
    -0.03199481f, 0.07617707f, -0.05216184f, -0.07879823f, 0.05525676f, 0.03800258f, 0.07315260f, -0.02032558f, 
    0.11889420f, -0.04608367f, -0.06037553f, 0.06072893f, -0.26873943f, -0.10354134f, 0.06089702f, -0.05873199f, 
    0.06360169f, 0.01899554f, 0.05347336f, 0.04476739f, -0.03322346f, 0.07985195f, 0.09296528f, 0.22793189f, 
    0.09217855f, -0.01288116f, 0.12685004f, 0.01166814f, 0.02583466f, 0.08504693f, -0.10680368f, 0.05393683f, 
    0.02193158f, -0.02191873f, -0.08522201f, 0.09234165f, -0.35671890f, 0.11421135f, 0.18861748f, 0.12492287f, 
    0.13123047f, -0.01658368f, 0.05220959f, 0.09533621f, 0.07924011f, 0.04943562f, 0.07077197f, -0.00124804f, 
    -0.13345408f, 0.05408630f, 0.05790840f, -0.02932724f, -0.03967638f, 0.10880423f, 0.01156866f, -0.02607559f, 
    -0.00615346f, 0.05073876f, -0.02137329f, -0.02941147f, 0.02355069f, 0.11076615f, -0.02628410f, 0.01178415f, 
    -0.08963517f, -0.03440548f, -0.00229346f, 0.17659697f, 0.04405866f, 0.02024142f, 0.06333474f, 0.21338066f, 
    0.15425053f, 0.18014921f, -0.03999045f, 0.01225589f, -0.07637001f, 0.00690178f, -0.02603680f, 0.04086319f, 
    -0.05778088f, -0.09669299f, 0.05674792f, -0.14597219f, -0.24675058f, -0.03813140f, 0.11608192f, -0.12445219f, 
    -0.06810328f, 0.09982646f, 0.03947770f, -0.02342667f, 0.12476729f, 0.04671013f, 0.00238151f, 0.07256322f, 
    -0.32166156f, 0.02018907f, 0.08897322f, -0.05738096f, -0.06097318f, -0.04777143f, 0.01093113f, -0.06827488f, 
    0.14681622f, 0.08578064f, 0.07418730f, 0.09526090f, 0.07983522f, -0.20042382f, -0.01362773f, 0.05963400f, 
    0.13356759f, 0.16541785f, 0.13757382f, 0.03782032f, 0.05001033f, 0.14285600f, 0.00706278f, -0.03456818f, 
    -0.02860373f, -0.05070760f, 0.03554521f, 0.04989677f, 0.01699473f, -0.03754593f, 0.04351566f, -0.01602678f, 
    -0.05935648f, 0.01201697f, 0.02377700f, -0.00173637f, -0.07210802f, 0.04535512f, -0.00325909f, -0.05758527f, 
    -0.04335881f, 0.01574815f, 0.04077787f, -0.02252964f, 0.04937490f, -0.00300258f, -0.06499674f, 0.03745912f, 
    -0.01472768f, -0.05054115f, 0.01305518f, -0.08208279f, -0.06667166f, -0.01814647f, 0.05849962f, -0.05135464f, 
    0.02986380f, -0.06664366f, -0.05347819f, 0.05292978f, -0.05000979f, -0.01794638f, 0.07029425f, 0.01902694f, 
    0.01195042f, -0.01425191f, -0.04570838f, -0.07943837f, 0.05827631f, 0.02491663f, 0.02052373f, -0.04866767f, 
    -0.07374752f, -0.04737889f, 0.05765263f, -0.05106391f, 0.00072067f, 0.00377520f, -0.01991336f, 0.01607480f, 
    0.05164167f, 0.00681301f, -0.06718103f, -0.00661579f, -0.08113181f, 0.01425333f, -0.01201348f, 0.05332332f, 
    0.05504015f, -0.02308240f, 0.05591642f, 0.05832369f, 0.02238012f, -0.04758120f, -0.00256013f, 0.03284705f, 
    0.05907937f, -0.03150651f, 0.04700584f, 0.03030287f, -0.00422601f, -0.02833709f, -0.03127794f, 0.01465465f, 
    -0.03002582f, 0.02868954f, -0.03091408f, 0.01893552f, -0.01739856f, -0.06267997f, -0.02366765f, 0.02346920f, 
    -0.05906767f, 0.06075834f, -0.06583996f, 0.01900575f, -0.03453677f, -0.06443696f, -0.03424307f, 0.02888609f, 
    0.00438395f, 0.01009725f, -0.03250073f, -0.07744228f, -0.03837590f, 0.03188275f, 0.02071570f, -0.03533009f, 
    0.03817046f, -0.02755432f, -0.02368462f, 0.01076488f, -0.07624067f, 0.00636879f, -0.02487810f, -0.05631189f, 
    0.04135755f, 0.01261978f, 0.04124324f, -0.00062409f, -0.07412698f, -0.05072914f, 0.01888572f, 0.05468266f, 
    -0.03651041f, 0.03849472f, -0.00993507f, 0.00080095f, 0.05727816f, -0.07617690f, -0.05504349f, -0.06845938f, 
    0.00465846f, -0.07341143f, -0.06460237f, -0.04995933f, 0.01442324f, -0.01507590f, -0.05541500f, 0.04386403f, 
    -0.02359486f, 0.00531308f, 0.03853904f, -0.03313672f, 0.06018161f, 0.04931102f, -0.00643619f, 0.05957709f, 
    0.03076961f, -0.00681099f, 0.06372304f, 0.01277741f, -0.04390625f, -0.03604371f, 0.06053357f, -0.01131911f, 
    -0.03791612f, -0.00459390f, -0.02291389f, 0.05145531f, -0.02616410f, -0.05224188f, -0.06609937f, 0.01826731f, 
    -0.02732841f, -0.01113079f, -0.01324112f, 0.03626639f, 0.01028423f, 0.02843227f, 0.02603918f, -0.02274757f, 
    -0.07453989f, -0.04870737f, -0.00131227f, 0.02112846f, -0.02737934f, 0.02548068f, 0.06091532f, -0.00576526f, 
    0.02103286f, 0.03542163f, -0.04446980f, -0.03587945f, -0.07615387f, 0.00539946f, -0.00072646f, -0.03783431f, 
    -0.05695714f, 0.00239167f, -0.00070425f, -0.02067779f, -0.02500962f, -0.05810523f, -0.01925291f, 0.01371692f, 
    -0.01175965f, -0.01209558f, 0.04225743f, -0.04833564f, -0.04380593f, 0.00997316f, 0.06272521f, -0.05365129f, 
    -0.05890014f, 0.03685738f, 0.06639079f, -0.01485492f, -0.04986781f, -0.06469683f, 0.02883353f, -0.04739576f, 
    0.02980896f, 0.06266978f, 0.03274299f, -0.02935034f, 0.03435913f, -0.04482785f, -0.02092796f, -0.02769949f, 
    -0.05299757f, 0.02039523f, -0.03291815f, -0.00503854f, 0.05808569f, -0.05509402f, -0.04139574f, 0.02147765f, 
    -0.00326374f, -0.02554028f, 0.02321563f, -0.05887948f, -0.02550112f, -0.00183485f, 0.03808303f, -0.05822130f, 
    -0.06262440f, -0.07627863f, -0.06554373f, -0.07351321f, 0.06167758f, 0.07505181f, -0.04349532f, -0.06299260f, 
    0.00940610f, -0.06655529f, -0.01758395f, 0.03542886f, -0.05601940f, -0.04486904f, 0.03076296f, 0.06490344f, 
    -0.04606717f, 0.03720115f, -0.05146643f, 0.01638310f, 0.03185235f, 0.02140036f, -0.02768263f, -0.05609933f, 
    -0.03608104f, 0.02969660f, -0.04551077f, -0.05348105f, 0.06146515f, -0.06562496f, 0.00151856f, -0.02794670f, 
    -0.05515482f, 0.02082559f, 0.00474430f, 0.04610498f, 0.03833166f, 0.01719829f, 0.06091181f, -0.00687061f, 
    0.00149787f, -0.04523779f, 0.06368475f, 0.03141922f, -0.07523065f, -0.07280926f, -0.04527487f, 0.02264165f, 
    0.05047419f, -0.00474345f, 0.01410421f, 0.02554113f, -0.00369676f, -0.06209651f, -0.05440345f, 0.07205214f, 
    0.05577847f, -0.00997450f, -0.01057985f, -0.00054794f, 0.00419087f, -0.03002123f, 0.02617717f, -0.04276640f, 
    -0.00513121f, -0.03994176f, -0.00036741f, -0.05385057f, -0.04221838f, -0.01172656f, -0.04184656f, -0.05623107f, 
    0.01705889f, -0.03959754f, -0.07485929f, -0.00895494f, -0.06930901f, -0.04713315f, -0.04706668f, -0.01112558f, 
    0.00077158f, 0.03567580f, 0.01863887f, -0.06342084f, 0.03115332f, -0.06496660f, -0.00751155f, -0.01433575f, 
    -0.06177504f, 0.02740245f, -0.02058751f, 0.00716249f, -0.00563334f, -0.03775267f, -0.06598271f, 0.04119825f, 
    0.03757600f, 0.05967641f, -0.00352356f, -0.00393310f, 0.03417071f, -0.03398205f, -0.05624999f, -0.02835268f, 
    0.04900475f, -0.00132052f, 0.00965151f, -0.03181711f, -0.04473703f, 0.02724843f, -0.07537152f, -0.05709166f, 
    0.01426928f, -0.05084947f, -0.05079933f, 0.02734264f, -0.00943346f, 0.02269480f, 0.06092660f, -0.06707302f, 
    0.01808886f, -0.04355009f, 0.04564944f, 0.02451232f, -0.02520409f, 0.03185229f, -0.06362718f, -0.01626009f, 
    -0.00605387f, 0.04470632f, -0.04861878f, 0.01800729f, 0.00143423f, -0.04189987f, -0.00031245f, 0.05211948f, 
    0.06030120f, -0.02673245f, -0.03967092f, -0.05739700f, 0.04252029f, 0.02056818f, 0.05155662f, 0.01493710f, 
    -0.02520158f, 0.05411665f, 0.02415607f, 0.06424420f, -0.03385953f, -0.05743475f, -0.04491669f, -0.02618837f, 
    -0.11105917f, -0.09063648f, 0.21193513f, -0.12333249f, 0.18821307f, -0.13705957f, -0.00975921f, 0.04996751f, 
    -0.03544851f, -0.03756686f, -0.04580538f, 0.10172925f, 0.22755626f, -0.12032805f, -0.05108028f, -0.09402038f, 
    0.09773700f, -0.01520623f, 0.00291356f, -0.04596265f, 0.17693326f, 0.03189445f, -0.02848935f, 0.03170498f, 
    0.27641046f, -0.02978159f, 0.02889724f, 0.07374751f, 0.00466086f, -0.01791211f, -0.02648001f, -0.13203746f, 
    -0.01805004f, 0.07970846f, -0.02170911f, -0.11748979f, 0.14821239f, 0.01657817f, 0.05193018f, 0.12699702f, 
    0.09346914f, 0.11249185f, -0.15661700f, 0.02997849f, -0.02263169f, 0.16086523f, 0.00959846f, -0.03378306f, 
    -0.08618646f, 0.23720801f, 0.00781120f, -0.01972330f, -0.00838451f, 0.03254043f, -0.10636780f, 0.02123326f, 
    0.13033383f, -0.05017065f, 0.02939828f, -0.01220692f, 0.12219873f, 0.18585704f, -0.13119775f, 0.03240833f, 
    0.08810483f, 0.08528378f, 0.00906459f, -0.00883150f, 0.08936389f, 0.05695987f, -0.05316965f, 0.09021528f, 
    0.05336927f, -0.06583673f, 0.03258852f, -0.12685621f, 0.12643084f, -0.12264502f, 0.05764669f, -0.02044176f, 
    0.03607837f, -0.06019002f, 0.13685150f, -0.04657425f, 0.03672604f, -0.24100675f, -0.00963715f, -0.06974900f, 
    -0.06389313f, -0.00349392f, 0.00448945f, -0.11334173f, -0.00028773f, -0.04451188f, 0.14886805f, 0.03795733f, 
    0.42727959f, -0.22933970f, -0.28245929f, 0.12900592f, 0.01815866f, 0.05503191f, -0.11204094f, 0.05709591f, 
    0.11822821f, -0.00276406f, 0.07451788f, 0.03278751f, 0.04432461f, 0.11264870f, -0.17918940f, -0.06776797f, 
    -0.00138758f, 0.13521615f, 0.04988495f, -0.03746967f, 0.08684903f, 0.11379712f, 0.19194993f, 0.01007900f, 
    -0.05746841f, 0.06214353f, 0.01439985f, -0.13545783f, -0.15104070f, -0.05902208f, -0.07461161f, 0.00120039f, 
    0.01231350f, 0.05092946f, 0.04136055f, -0.00000006f, -0.27575597f, -0.03437621f, -0.01225597f, -0.16193281f, 
    -0.01620818f, -0.13015795f, -0.08489044f, 0.01289417f, 0.11816327f, -0.05407607f, -0.01107482f, -0.07959566f, 
    0.07351724f, 0.04982483f, 0.12394220f, -0.06250042f, -0.15054111f, -0.06635433f, 0.05336098f, -0.06375682f, 
    0.11293875f, 0.12151261f, -0.07604147f, 0.16593581f, -0.13122341f, 0.02379267f, -0.05259492f, -0.07264572f, 
    -0.09112834f, 0.20666029f, -0.00122471f, 0.00620367f, -0.01643465f, 0.15113276f, -0.05885969f, 0.15937738f, 
    -0.07064396f, -0.31860983f, -0.09953346f, 0.09646200f, 0.09829585f, -0.07116847f, -0.01453616f, -0.06908794f, 
    0.00312727f, -0.11209764f, -0.06694049f, 0.08130231f, 0.09576645f, 0.12640066f, -0.06972383f, 0.08464807f, 
    0.04652174f, 0.01146851f, 0.07450021f, 0.02034055f, 0.10500206f, 0.08890405f, 0.04526406f, 0.11929529f, 
    -0.17186420f, -0.07635695f, 0.06913453f, 0.15696156f, 0.11915874f, -0.00003219f, 0.03556386f, 0.10154624f, 
    0.00551875f, 0.02904322f, -0.14205694f, 0.01784656f, 0.14721383f, 0.01962676f, 0.17872813f, 0.04380425f, 
    -0.11815800f, -0.04449274f, -0.05854139f, 0.06363433f, 0.06246714f, -0.06909888f, 0.09179358f, -0.03333152f, 
    -0.12028595f, -0.09240875f, 0.07861431f, 0.01825033f, 0.11351474f, 0.11815991f, -0.00033010f, -0.03185554f, 
    0.11287282f, 0.02066911f, 0.05299295f, -0.02740915f, 0.10085388f, -0.10583167f, -0.00009510f, 0.04668506f, 
    0.03284086f, 0.08670679f, 0.12919599f, -0.00234082f, 0.05448467f, 0.10437592f, -0.01424164f, 0.09472112f, 
    -0.18486169f, 0.00088777f, 0.19600265f, -0.06414076f, -0.09753612f, -0.08330502f, 0.00439578f, 0.00276960f, 
    0.12876023f, 0.07336608f, 0.06178233f, 0.02380358f, -0.28012675f, -0.00338691f, 0.07815573f, 0.02704937f, 
    -0.15960142f, 0.05407071f, -0.05199541f, -0.04612549f, 0.05548661f, 0.03778830f, -0.03841614f, 0.09525894f, 
    0.29788846f, -0.06169800f, 0.09525784f, 0.18093257f, -0.03145467f, -0.09148221f, -0.03404038f, 0.00262110f, 
    -0.06576467f, 0.00768984f, 0.11342208f, 0.19041021f, 0.13106473f, 0.00115404f, -0.09419669f, -0.23189196f, 
    0.07244483f, 0.11319955f, -0.09501465f, 0.02803633f, 0.05840622f, -0.02841402f, -0.07197341f, 0.04088465f, 
    -0.05525193f, 0.07979541f, 0.03809171f, 0.05869440f, 0.14796168f, 0.00070089f, 0.11388393f, 0.14682241f, 
    0.00705321f, -0.06762945f, 0.08236052f, 0.08203275f, 0.01914262f, 0.05923831f, -0.00873882f, 0.04463678f, 
    0.03552157f, -0.02143265f, 0.06492963f, 0.00272632f, 0.11435138f, -0.06626809f, 0.00181255f, 0.01570560f, 
    -0.29729009f, -0.16610563f, -0.20209409f, -0.16523217f, -0.01838926f, 0.01751980f, -0.03538377f, 0.00264084f, 
    0.06237083f, -0.06964851f, 0.01349341f, 0.07534906f, -0.00720678f, -0.13669844f, 0.03548937f, -0.14895681f, 
    -0.02038059f, 0.14023873f, -0.01312720f, 0.03852354f, -0.01114467f, 0.07050278f, -0.01979917f, -0.02431765f, 
    -0.07584475f, 0.01268311f, -0.10730858f, -0.16613698f, 0.11779387f, 0.00412952f, 0.16220565f, -0.05027075f, 
    0.11529060f, 0.03084117f, -0.10859399f, 0.05543448f, 0.07582795f, 0.22451419f, 0.03307723f, -0.05938492f, 
    -0.03300017f, 0.10109328f, -0.02864884f, 0.11714837f, 0.03412008f, 0.02211844f, -0.01859003f, 0.03621640f, 
    0.14148380f, -0.01167267f, 0.03518151f, -0.00771755f, 0.00469260f, -0.03479469f, 0.12953247f, -0.05524063f, 
    0.08623085f, 0.02639103f, 0.08678611f, 0.04051402f, -0.19880901f, 0.08751591f, -0.05905007f, 0.17252082f, 
    0.02001160f, 0.09515251f, -0.06068606f, 0.00853803f, -0.01049045f, -0.00775470f, -0.09220341f, 0.07913517f, 
    0.23591678f, 0.06740130f, 0.00855680f, 0.07792001f, 0.03514415f, -0.06751043f, -0.04303047f, 0.12717858f, 
    -0.05711089f, 0.06618673f, -0.16553944f, -0.04036254f, -0.09751610f, 0.20064640f, -0.02214869f, 0.15704411f, 
    0.12457717f, -0.11343844f, -0.05984572f, 0.11728806f, -0.05374322f, 0.11796340f, 0.06035206f, 0.04402412f, 
    -0.06389431f, -0.03400239f, 0.03377299f, -0.09402192f, 0.03771811f, -0.12632297f, 0.08334177f, 0.18399912f, 
    0.02548786f, -0.12831126f, -0.25876334f, 0.01019202f, 0.01491025f, 0.12529837f, -0.16607249f, -0.16254066f, 
    0.01775116f, -0.20442656f, -0.08712377f, -0.08078044f, 0.01088210f, -0.15292118f, 0.13646702f, 0.05602500f, 
    0.14781810f, -0.00266319f, 0.35213581f, -0.06171639f, -0.18318139f, 0.01062225f, 0.05883190f, -0.18120724f, 
    0.09758460f, -0.11299004f, 0.12638234f, 0.08213612f, -0.23079892f, -0.29465902f, 0.24904636f, -0.00342088f, 
    -0.03239055f, 0.00651879f, -0.11777273f, 0.08017251f, -0.10465445f, 0.02904663f, 0.07172812f, 0.06929408f, 
    0.25837326f, 0.15874766f, 0.15891056f, 0.10629503f, -0.07548931f, 0.01595778f, 0.00837767f, -0.08653066f, 
    0.05462960f, 0.05294317f, -0.21399635f, 0.10961124f, 0.04247691f, -0.03270649f, -0.22893620f, -0.16677263f, 
    0.04982530f, 0.03583813f, 0.10592354f, 0.11962647f, 0.09413875f, 0.14461699f, 0.09896682f, 0.29628637f, 
    -0.17412031f, 0.18292001f, 0.29804042f, -0.06732101f, -0.06813333f, 0.07034417f, -0.13368112f, 0.16086334f, 
    -0.05786978f, 0.04988166f, -0.06572470f, 0.14761169f, -0.25501579f, -0.05551092f, 0.20769116f, -0.12299013f, 
    0.14172865f, -0.06802835f, -0.08464162f, -0.04548173f, 0.02738266f, 0.08304405f, 0.05193740f, -0.07761374f, 
    -0.26601866f, -0.11184943f, -0.08801243f, 0.00396386f, 0.09753245f, 0.04869114f, -0.04329280f, 0.00463570f, 
    0.06458147f, 0.07637878f, -0.03158429f, -0.02417818f, 0.06125785f, 0.05089384f, -0.13303280f, -0.02194181f, 
    -0.09188721f, 0.10828273f, 0.14564925f, 0.12203536f, -0.05366711f, 0.08379649f, 0.02706972f, 0.31499556f, 
    0.06592148f, 0.13995270f, -0.15204479f, -0.12851331f, 0.16576988f, -0.01018689f, 0.02818863f, -0.04601219f, 
    0.07250974f, -0.16139030f, 0.05457895f, -0.13249335f, 0.03763693f, 0.06700318f, 0.16205169f, -0.06124497f, 
    0.05343431f, -0.00208582f, -0.05877038f, 0.03282088f, 0.01308851f, -0.06117479f, 0.02997590f, 0.02983496f, 
    0.05837622f, 0.05849289f, 0.05839007f, -0.27205706f, 0.07248726f, -0.07359632f, -0.04327593f, 0.01505489f, 
    0.07174550f, 0.14937249f, 0.08586874f, 0.08473897f, 0.10461226f, 0.01592026f, 0.07159262f, 0.21307883f, 
    -0.02190258f, 0.09414098f, 0.01389388f, -0.10543122f, 0.09498548f, -0.15254696f, 0.00108406f, -0.01817352f, 
    -0.51483643f, -0.07190303f, 0.01618045f, 0.22896300f, 0.04388404f, 0.00717464f, 0.02564779f, -0.00265129f, 
    0.02023400f, -0.02953430f, 0.01721149f, 0.05658419f, 0.08786405f, -0.04240438f, -0.05305038f, 0.19313174f, 
    -0.11161838f, 0.16197807f, 0.07782762f, 0.02019850f, 0.02040896f, -0.03021533f, -0.03049344f, 0.02378028f, 
    -0.28706017f, 0.02712770f, -0.06283014f, 0.10648715f, 0.00062373f, -0.00923562f, 0.03497487f, -0.09193955f, 
    -0.00025379f, -0.05584721f, 0.07612576f, 0.04455042f, 0.02547866f, -0.00939867f, 0.14860533f, -0.03832624f, 
    -0.03477562f, 0.04741912f, -0.09557506f, 0.11494972f, -0.04491568f, 0.02822760f, -0.03747907f, -0.00159054f, 
    0.29030198f, -0.16201849f, 0.12541033f, 0.04750198f, 0.10781170f, -0.13635719f, -0.01267057f, 0.00136775f, 
    -0.03678024f, -0.00678206f, -0.04386438f, -0.06106051f, -0.11920785f, 0.29400772f, -0.08859179f, 0.06317436f, 
    -0.15984978f, -0.02987406f, 0.06227256f, -0.09470571f, 0.00656543f, 0.02724633f, 0.00772994f, 0.07838555f, 
    0.28678474f, -0.04977124f, 0.00960398f, 0.36687422f, 0.07883739f, -0.02584654f, 0.08393657f, 0.08662906f, 
    0.13650168f, -0.02192233f, 0.14643244f, 0.02537882f, -0.11915067f, 0.02830093f, 0.09516561f, -0.23224269f, 
    -0.01421323f, 0.06655505f, -0.06757756f, -0.00075821f, 0.04300934f, -0.04100982f, 0.06286021f, -0.01103071f, 
    0.06244799f, 0.18746127f, -0.03287829f, -0.14068717f, 0.07784372f, 0.13084811f, 0.02628976f, 0.03106673f, 
    0.01628202f, 0.05023997f, 0.06069992f, 0.11902855f, -0.15397738f, 0.07932466f, 0.09344753f, 0.10207298f, 
    0.12587495f, 0.01327631f, 0.05239455f, 0.06062962f, 0.05242318f, 0.05147983f, -0.00639668f, 0.07662886f, 
    0.17199306f, 0.08326332f, -0.15287720f, 0.00050427f, 0.05137815f, -0.11216319f, 0.01818826f, 0.09429251f, 
    0.07157708f, -0.03160027f, -0.02310553f, 0.13570696f, -0.17632286f, -0.00598664f, -0.01847297f, -0.30110380f, 
    -0.04016970f, -0.00002785f, 0.08248612f, -0.11322314f, -0.04527805f, 0.01500367f, -0.03146933f, -0.01021104f, 
    0.13206047f, -0.07765642f, -0.12854412f, -0.16382828f, -0.06308683f, -0.01056857f, 0.00260516f, 0.00298041f, 
    0.02059622f, -0.00119581f, 0.03765079f, 0.02606750f, -0.43831366f, 0.20334071f, 0.07652885f, -0.04827425f, 
    -0.04049165f, 0.04958295f, -0.01924936f, 0.10528770f, 0.09714607f, 0.09118710f, 0.03538141f, 0.09902251f, 
    0.19752967f, -0.06802667f, -0.09717307f, -0.08635560f, 0.07140136f, 0.01515482f, -0.01060709f, 0.02277815f, 
    -0.02022025f, -0.00092876f, 0.02507293f, 0.08423106f, 0.34459385f, 0.33328795f, -0.25422144f, -0.18064947f, 
    0.03445955f, -0.16452542f, -0.03227665f, 0.03538326f, 0.12993096f, 0.02018775f, -0.02104384f, 0.07182200f, 
    0.55027175f, -0.20517513f, 0.02973185f, -0.18526275f, 0.08868742f, 0.13357139f, 0.08468661f, -0.01298221f, 
    -0.01874092f, 0.05815990f, -0.09906407f, 0.07319380f, 0.07275461f, 0.07869695f, -0.04328983f, 0.00185455f, 
    0.10079738f, -0.02089229f, -0.03569761f, 0.12824404f, -0.00010574f, 0.04631607f, 0.06291507f, 0.11988493f, 
    0.25225362f, -0.01178802f, -0.11509625f, -0.02783026f, -0.01705122f, 0.01659645f, -0.01078529f, 0.07463631f, 
    0.01006369f, 0.00150115f, -0.02298957f, -0.06074196f, 0.06996197f, 0.06516196f, -0.21386081f, -0.16036364f, 
    0.08908394f, -0.07738158f, 0.15273176f, -0.00823591f, 0.01794450f, 0.00224613f, 0.03310333f, 0.09259678f, 
    -0.38816252f, -0.02403827f, 0.12218031f, -0.02791835f, -0.15513186f, 0.08554482f, 0.13442354f, 0.08117922f, 
    -0.07391522f, 0.12916714f, -0.00087301f, 0.15876295f, -0.05984470f, -0.10639399f, -0.02589841f, -0.08057936f, 
    0.24072205f, 0.10634297f, -0.11165107f, 0.02456483f, 0.02586005f, 0.10028768f, -0.03825869f, 0.01778393f, 
    -0.18869907f, 0.06138702f, 0.08105648f, -0.22830440f, -0.18624948f, 0.09405336f, 0.02642152f, 0.02375170f, 
    -0.04258577f, 0.07837564f, 0.00340975f, -0.01750046f, 0.08002519f, -0.12079500f, 0.08586457f, 0.11058689f, 
    -0.09192347f, 0.03179771f, 0.07781541f, 0.08392545f, 0.02068742f, -0.05296370f, 0.03965962f, 0.04313218f, 
    -0.20356816f, 0.02875923f, 0.07814125f, -0.21392779f, 0.04804571f, 0.02683400f, -0.08735128f, 0.01014113f, 
    -0.06469046f, -0.01281138f, -0.12543195f, -0.01978669f, 0.29012749f, -0.08113021f, -0.12118750f, -0.05228469f, 
    -0.05564703f, 0.06748366f, 0.02318199f, -0.05366671f, 0.08415977f, -0.02615597f, 0.08726896f, 0.03316866f, 
    -0.23494385f, -0.13923034f, 0.20969431f, 0.19148195f, 0.13795644f, 0.08489282f, 0.03630144f, 0.06388214f, 
    -0.08029316f, -0.05024517f, -0.04066558f, -0.03094701f, 0.00594713f, -0.03680871f, 0.01693457f, 0.09623610f, 
    0.00441685f, -0.00392295f, 0.02445111f, 0.09616251f, 0.13426585f, 0.03263486f, 0.04696948f, 0.12165368f, 
    -0.26183170f, 0.01377688f, 0.15223351f, 0.07413902f, 0.07681980f, -0.00294903f, -0.02765630f, -0.00126835f, 
    0.03529933f, 0.01546502f, -0.03558004f, -0.11377201f, 0.34912625f, -0.01435988f, -0.13990349f, -0.09842320f, 
    0.03480566f, 0.02588924f, 0.05898574f, 0.04476498f, -0.01556710f, 0.00339649f, 0.05217863f, -0.02214511f, 
    0.10055859f, 0.00723429f, 0.19455132f, 0.10206370f, -0.00698099f, -0.01026635f, 0.04770850f, -0.01956445f, 
    0.09146212f, 0.11929989f, 0.06711856f, 0.04766040f, -0.32034522f, -0.27838612f, 0.14651398f, 0.08368001f, 
    0.01595945f, 0.17528072f, 0.07679535f, -0.03622019f, 0.07531983f, 0.01158535f, -0.11939383f, -0.00995360f, 
    -0.00573901f, 0.00871724f, 0.02760948f, -0.01178115f, -0.00875490f, 0.00832083f, -0.05001468f, -0.08084683f, 
    -0.00521597f, 0.06574141f, 0.02370008f, 0.05207284f, -0.00062227f, 0.06053491f, 0.03646328f, -0.05959913f, 
    0.02926332f, -0.05599258f, -0.05474490f, 0.00554695f, -0.07485003f, -0.03575506f, -0.01990510f, 0.06009356f, 
    0.05745427f, 0.02468104f, 0.00896559f, -0.00051363f, -0.01570316f, -0.06542000f, -0.00382555f, -0.00431138f, 
    -0.06186029f, -0.05983779f, 0.02023653f, 0.06131001f, 0.06788294f, -0.00009789f, -0.01047825f, -0.06941286f, 
    -0.03199707f, -0.07497361f, 0.07024709f, -0.05995010f, -0.00225891f, 0.04184231f, 0.00322301f, 0.05508139f, 
    0.00048773f, 0.05091266f, -0.02032096f, -0.00252831f, -0.04083780f, 0.00193549f, 0.03876769f, 0.04028514f, 
    -0.03277012f, 0.04471610f, -0.06474338f, 0.04146334f, 0.03003450f, -0.02347902f, -0.07641369f, 0.02322787f, 
    -0.00332520f, 0.00966919f, -0.03958827f, -0.03514050f, 0.04841554f, -0.05006298f, -0.04064365f, 0.02167982f, 
    -0.05044512f, 0.05645107f, -0.00947839f, -0.06827147f, -0.05270509f, 0.04136362f, 0.03268322f, -0.05474085f, 
    0.06128916f, -0.00099648f, -0.05229226f, -0.04124412f, -0.03265604f, -0.07146826f, -0.00033231f, 0.04987289f, 
    0.02862843f, -0.00791989f, -0.00875090f, -0.01425927f, 0.01150892f, 0.05342968f, 0.01732730f, 0.04451277f, 
    -0.03357681f, 0.03274044f, -0.03316876f, 0.01959821f, 0.04736258f, -0.07351382f, -0.00412825f, 0.04009041f, 
    -0.04368245f, -0.04606862f, -0.05772503f, -0.04976078f, -0.05795467f, -0.04306466f, 0.04501851f, 0.06388226f, 
    -0.04120480f, -0.05918738f, -0.04418175f, -0.03596064f, -0.02107356f, -0.04991573f, 0.05874475f, 0.01484282f, 
    -0.05095286f, 0.01623121f, -0.04058321f, -0.02877017f, -0.01112097f, 0.01237168f, -0.06595328f, -0.07178716f, 
    0.04597145f, 0.00814478f, -0.05308274f, 0.04466023f, 0.04239541f, -0.01745419f, 0.04801400f, -0.02273824f, 
    0.04100995f, 0.03794856f, -0.07132035f, -0.02925051f, -0.04307555f, -0.02352688f, -0.03922413f, 0.00677881f, 
    -0.05776995f, 0.00690296f, -0.03128618f, -0.02706631f, 0.03534606f, 0.04945359f, -0.02285185f, -0.04725058f, 
    0.02288203f, -0.02896329f, 0.03754203f, -0.07907320f, -0.07094027f, -0.00315430f, -0.07266743f, 0.02064280f, 
    0.00354837f, -0.02565774f, 0.00159839f, 0.05781594f, 0.01595212f, -0.02000172f, 0.04380542f, 0.01785704f, 
    0.02546135f, -0.01723110f, 0.04432485f, -0.03411137f, -0.02425658f, -0.07124671f, -0.02566796f, 0.06555180f, 
    -0.04345112f, 0.05686279f, -0.06327704f, 0.02460666f, 0.04721924f, 0.04348221f, -0.04508295f, 0.02328524f, 
    -0.05136380f, -0.04102120f, 0.00327787f, -0.06411760f, -0.01309773f, 0.01380584f, -0.04147054f, 0.05996964f, 
    -0.41272059f, 0.16442433f, -0.11465101f, 0.12954184f, 0.00142746f, -0.08453735f, -0.02607249f, 0.01944069f, 
    -0.00684117f, 0.01092084f, 0.15799874f, -0.11594433f, 0.00952228f, 0.05208001f, -0.03644624f, -0.14489019f, 
    -0.06073061f, 0.16947024f, 0.02041379f, 0.08934222f, -0.05054233f, 0.07456175f, -0.10599100f, 0.01752858f, 
    -0.33205155f, 0.09331958f, -0.02634198f, 0.08913574f, -0.08981705f, -0.07082271f, 0.05587114f, 0.08073583f, 
    -0.05601994f, 0.01810066f, 0.05440842f, 0.21235947f, -0.07967100f, 0.03287671f, 0.03539760f, -0.14455068f, 
    0.01213153f, -0.25858942f, -0.04473609f, 0.11083262f, -0.03248432f, -0.03466033f, 0.14025865f, -0.09154381f, 
    0.31540862f, -0.18788859f, 0.02945150f, 0.06746041f, -0.07222681f, -0.05128242f, 0.13404323f, -0.00029842f, 
    -0.06518187f, 0.01315216f, 0.01030483f, 0.08294848f, -0.22133438f, 0.25142550f, 0.17238463f, -0.03468105f, 
    -0.20586430f, -0.08024555f, 0.07394449f, -0.00679990f, 0.05731397f, 0.01750688f, 0.06250855f, -0.00664697f, 
    0.25394958f, 0.01202118f, 0.05068471f, 0.04231390f, -0.00833231f, 0.10782203f, -0.07165353f, 0.04239666f, 
    -0.08902748f, -0.04872549f, -0.07287061f, 0.08559100f, -0.26513368f, -0.07847483f, -0.06567723f, 0.03312081f, 
    0.06084165f, 0.00964118f, -0.05549001f, -0.05690368f, 0.17674351f, 0.00012189f, 0.07234444f, 0.01859559f, 
    -0.16084355f, -0.04844810f, 0.17797957f, 0.08009917f, 0.06431667f, 0.01094994f, 0.00021640f, 0.01422920f, 
    0.05475186f, 0.08631912f, 0.06791069f, -0.00454113f, 0.03481351f, 0.03598296f, 0.12313294f, 0.10685614f, 
    0.03777740f, 0.05275023f, -0.03677868f, 0.09985567f, -0.00567382f, -0.06934281f, -0.03952319f, 0.03957855f, 
    0.26811236f, 0.16100848f, -0.14446214f, 0.27958575f, 0.07169300f, 0.09194644f, 0.04441382f, 0.04409784f, 
    0.06577057f, -0.00701186f, 0.08522350f, 0.15657848f, 0.12190734f, -0.23407272f, -0.05504405f, 0.05140119f, 
    -0.02285015f, 0.06345583f, 0.04292456f, -0.20025271f, 0.03010792f, -0.05608270f, -0.00408161f, 0.09811985f, 
    -0.07095166f, 0.01970824f, -0.17116067f, -0.05038791f, 0.12279639f, -0.03831477f, 0.10674140f, 0.11553903f, 
    0.03820015f, 0.06412490f, -0.01580920f, 0.04592426f, -0.04893328f, 0.13542418f, 0.26164493f, 0.28703693f, 
    0.02718360f, -0.08429886f, 0.02948550f, -0.04088845f, -0.03033730f, -0.05797153f, -0.12824307f, 0.03585114f, 
    -0.17750472f, 0.09742610f, -0.06843238f, -0.10239740f, 0.07973269f, 0.03706727f, -0.02196024f, 0.06553220f, 
    -0.05098230f, 0.03286127f, -0.00191109f, -0.07187312f, -0.11493298f, 0.12361476f, 0.08915035f, 0.08517864f, 
    0.04095946f, -0.10489173f, 0.05547288f, -0.04037247f, 0.06062395f, -0.02233153f, 0.05662714f, -0.00394350f, 
    0.11942977f, 0.13912551f, 0.15040551f, -0.26211938f, 0.14408813f, -0.16573051f, -0.04747776f, 0.06570538f, 
    -0.07583345f, 0.08478393f, -0.03384826f, -0.04369957f, 0.06326969f, -0.21591343f, 0.04746449f, -0.30882111f, 
    0.13527793f, -0.08088411f, -0.00039734f, -0.03281441f, -0.03189261f, -0.08221310f, 0.03159148f, -0.05487125f, 
    0.22772436f, -0.15505506f, 0.07262965f, -0.04875169f, -0.00810471f, 0.09271970f, -0.07596160f, 0.14912750f, 
    0.00325628f, -0.01819361f, 0.07971996f, 0.04145391f, 0.16856426f, 0.05238697f, 0.04115628f, 0.19307880f, 
    0.15121518f, 0.00773304f, 0.07131550f, 0.06928109f, -0.04445332f, -0.08115303f, 0.00820811f, 0.05275004f, 
    -0.31371728f, 0.15590584f, -0.19818127f, -0.02821014f, -0.01890286f, 0.04062453f, -0.04435841f, 0.03346710f, 
    0.14599365f, 0.12124629f, -0.01073509f, 0.01204660f, 0.02098802f, -0.19280584f, -0.22158681f, -0.02599582f, 
    0.08962233f, -0.01517799f, -0.04527161f, 0.04845874f, -0.06005604f, -0.01049036f, 0.02901742f, 0.02695571f, 
    -0.06319501f, -0.04455584f, -0.01909554f, -0.36007878f, 0.14774719f, 0.00842071f, -0.01572611f, 0.00977680f, 
    0.02820796f, -0.00531882f, 0.10678957f, 0.03947423f, -0.03993180f, 0.02788154f, -0.03667996f, 0.06882721f, 
    -0.07738734f, 0.06760956f, 0.05579195f, -0.06495001f, 0.02335439f, 0.02525677f, 0.08859828f, -0.04205246f, 
    0.38304082f, -0.13091442f, -0.23826915f, 0.34471110f, 0.08095711f, 0.03114485f, -0.05690048f, 0.03854669f, 
    0.05341327f, -0.00807645f, 0.04726807f, -0.00895746f, 0.28494337f, 0.06106360f, -0.03278768f, -0.03056605f, 
    0.03969482f, -0.02549504f, 0.08537558f, -0.09026977f, 0.09152812f, 0.09253205f, 0.08214531f, 0.04445262f, 
    -0.02697928f, 0.14297289f, 0.01311724f, -0.07637347f, -0.10588769f, 0.17088206f, -0.01757890f, -0.10814122f, 
    0.06004278f, 0.08156975f, 0.11969142f, -0.10533383f, 0.11610280f, 0.00663379f, 0.07315100f, 0.21357277f, 
    -0.03571660f, 0.11364482f, -0.14874271f, 0.07861369f, 0.00515985f, -0.01633959f, 0.09714410f, -0.04709957f, 
    -0.14103445f, 0.16499139f, 0.08333310f, 0.06453440f, -0.02193412f, 0.03042943f, 0.06906463f, -0.12268868f, 
    0.02508116f, 0.13113026f, -0.01899350f, -0.05197513f, 0.24982458f, -0.03054747f, 0.04667531f, 0.11752998f, 
    -0.09245684f, -0.06976087f, 0.10313520f, 0.08646265f, -0.02825563f, 0.01901180f, -0.09987769f, -0.01624388f, 
    -0.13617480f, -0.03766038f, 0.07867506f, 0.19715001f, -0.06770872f, 0.15048200f, 0.10560669f, 0.02434876f, 
    0.04592215f, 0.00940533f, 0.09578221f, -0.00526444f, -0.08140311f, -0.01275390f, 0.15348022f, 0.24938907f, 
    -0.01259592f, 0.05309035f, -0.03714013f, 0.01828460f, 0.06598119f, 0.00112660f, 0.00448862f, -0.05269280f, 
    0.05839399f, -0.12904026f, -0.06714582f, 0.31494570f, 0.03221488f, 0.07317033f, 0.04489724f, 0.00382009f, 
    0.05611630f, 0.00548535f, 0.13504232f, -0.07561550f, 0.06784308f, -0.06615379f, -0.07645445f, 0.08360920f, 
    0.06622231f, 0.07663165f, 0.00656481f, 0.08265854f, 0.00605350f, 0.02789330f, 0.00354404f, 0.07906573f, 
    -0.05392960f, 0.22964165f, -0.08856658f, 0.01097252f, 0.04840819f, 0.07975513f, -0.02550798f, -0.05893840f, 
    0.09409337f, -0.01682193f, -0.08568084f, 0.12255497f, 0.12372182f, -0.01443885f, -0.02677705f, -0.05974237f, 
    0.05393161f, -0.06443027f, -0.08233882f, 0.03298849f, -0.00705109f, 0.05302158f, 0.05116715f, -0.17605250f, 
    0.04603563f, 0.00700782f, 0.18943341f, -0.01880746f, -0.11937513f, -0.04729375f, 0.11502483f, 0.02579311f, 
    -0.07441080f, -0.06369133f, 0.01920746f, 0.01618562f, -0.09167189f, 0.11613803f, 0.05738873f, -0.03834964f, 
    -0.00899084f, 0.19900081f, 0.03532018f, 0.09184661f, 0.04833715f, 0.01783279f, 0.02452185f, 0.11487270f, 
    0.10667156f, 0.01695737f, -0.01674254f, 0.07330214f, -0.04650509f, -0.00333008f, -0.00416121f, 0.08379298f, 
    -0.00408822f, 0.03524207f, -0.08912608f, -0.05493372f, 0.28609419f, -0.14334324f, -0.12089367f, -0.10785040f, 
    -0.01106876f, -0.18448944f, 0.03925071f, 0.03174824f, 0.06363527f, -0.01162133f, 0.01774433f, 0.03982446f, 
    -0.11570155f, -0.09996005f, 0.20411512f, -0.19988778f, -0.06069892f, 0.03335420f, 0.01522642f, 0.20549288f, 
    -0.01210144f, 0.05976493f, -0.05440753f, 0.06057991f, 0.19877803f, 0.07758295f, -0.07433484f, 0.10552071f, 
    -0.01960866f, 0.06366073f, -0.06950488f, 0.03556740f, 0.05952803f, 0.00456225f, -0.06814254f, -0.03044050f, 
    0.14214849f, -0.09134533f, -0.11477413f, -0.09295626f, -0.07729630f, -0.01647535f, 0.09455155f, 0.03391064f, 
    -0.06824414f, -0.04152558f, -0.04618151f, 0.02336347f, -0.06321994f, -0.11590783f, 0.10594352f, -0.14547497f, 
    -0.12092384f, -0.13829969f, 0.10895120f, -0.03537686f, 0.02697076f, 0.08533429f, -0.13254234f, 0.10259136f, 
    0.43293747f, -0.18316492f, 0.01675196f, 0.02944178f, -0.00517350f, -0.00449433f, 0.02727606f, 0.14460976f, 
    0.11018398f, -0.03935386f, 0.00988458f, 0.00498495f, 0.03228870f, 0.30979005f, -0.13649406f, -0.16918470f, 
    0.09012156f, 0.18553162f, -0.01850257f, 0.10162745f, 0.05573840f, 0.02728973f, 0.06603716f, 0.01441715f, 
    -0.12640847f, -0.20555833f, -0.02944119f, -0.20191228f, 0.04194077f, -0.16501479f, 0.02683017f, 0.05287864f, 
    0.09371924f, 0.06009446f, -0.00315864f, 0.09660472f, -0.13961531f, 0.09379583f, -0.02586052f, 0.13870461f, 
    0.09900954f, 0.02781844f, 0.19394870f, 0.06830508f, -0.07174510f, -0.03313558f, -0.06964581f, 0.06587852f, 
    -0.06872676f, 0.00740000f, -0.03493062f, 0.03161379f, -0.03611507f, 0.02812434f, -0.00287298f, -0.07204814f, 
    -0.02155332f, 0.00733502f, -0.05607997f, -0.00132561f, -0.06737815f, -0.04381163f, -0.04241805f, 0.04624291f, 
    0.01281686f, -0.04896370f, -0.06352420f, 0.02391897f, -0.01499550f, 0.00439621f, -0.07655618f, -0.07041580f, 
    -0.03810047f, -0.01524852f, 0.02706401f, 0.01045129f, -0.01640918f, 0.00222956f, -0.00131284f, -0.07099683f, 
    -0.07040376f, -0.01957919f, 0.03767906f, -0.00614483f, 0.01516349f, -0.02439737f, -0.07952407f, 0.05583072f, 
    0.02667209f, -0.06864955f, 0.02804521f, -0.06369797f, -0.06508690f, -0.03297859f, 0.00376898f, 0.01675769f, 
    0.04205987f, -0.05019003f, -0.08091543f, -0.07532356f, -0.00084191f, -0.01887726f, 0.02315566f, -0.05956474f, 
    0.05592760f, -0.00186837f, 0.01065393f, -0.09063984f, -0.01260734f, 0.00284563f, 0.01086386f, 0.02807544f, 
    0.03159083f, -0.00698381f, 0.04605581f, -0.03380359f, 0.03338284f, -0.07249867f, 0.03574475f, -0.06941920f, 
    -0.08718774f, -0.03347703f, 0.02686987f, -0.00610151f, -0.00338965f, -0.07382043f, 0.00221726f, -0.04771805f, 
    -0.06487737f, -0.02803569f, -0.09642806f, 0.00248150f, 0.03257531f, 0.03863209f, -0.03555475f, -0.08728959f, 
    -0.00449687f, 0.04834373f, -0.00538916f, 0.02244868f, 0.03435242f, -0.03527305f, 0.04720328f, 0.01041778f, 
    0.01376926f, -0.03633125f, -0.04284095f, 0.04353489f, -0.06309731f, -0.00834202f, -0.06497924f, 0.05544583f, 
    -0.06542606f, -0.02438332f, -0.01782213f, 0.01852294f, 0.00050968f, 0.04273921f, -0.04212851f, 0.02971726f, 
    -0.08078574f, 0.04913013f, -0.05707904f, -0.04498760f, 0.00287869f, -0.07792673f, -0.06997035f, 0.00312567f, 
    0.04715778f, 0.00735634f, 0.01707885f, 0.02337256f, 0.03979324f, -0.08253798f, -0.00384645f, -0.06695246f, 
    -0.00678987f, -0.04032590f, 0.00318184f, -0.06214631f, -0.06553125f, 0.02138628f, -0.02804079f, -0.05686691f, 
    -0.06597159f, 0.06400010f, -0.06300905f, -0.05542435f, 0.03804169f, -0.05695585f, -0.07061190f, -0.05270489f, 
    0.02721058f, -0.01454671f, -0.02521542f, -0.07845356f, -0.01357117f, 0.02038305f, -0.05311522f, -0.07587690f, 
    -0.04436926f, 0.04469046f, 0.03480044f, 0.03730853f, -0.01511627f, -0.03995962f, 0.00852415f, -0.03006341f, 
    -0.01326970f, 0.04616978f, -0.00159461f, -0.01581347f, -0.02370526f, -0.02799532f, 0.00362507f, 0.01710381f, 
    -0.05845499f, -0.03303197f, -0.00192313f, -0.00207790f, 0.03392735f, -0.00514015f, -0.07255698f, 0.05226828f, 
    -0.08178675f, -0.06909578f, 0.00312186f, -0.03242399f, 0.01233039f, -0.07811089f, 0.04933589f, -0.06534109f, 
    -0.02715193f, 0.00256320f, 0.00748206f, -0.05373929f, -0.02539347f, 0.02965634f, -0.02868462f, 0.04352178f, 
    0.40577856f, 0.07554515f, 0.06798720f, -0.14211558f, 0.09588077f, 0.04156882f, 0.02637284f, 0.09423063f, 
    -0.12082449f, 0.03114006f, 0.05732074f, -0.03729605f, 0.06276913f, -0.08194604f, -0.01526301f, -0.26732042f, 
    0.03713640f, -0.07918768f, 0.14098264f, -0.01098897f, 0.06976129f, -0.02929393f, 0.04864889f, 0.02771209f, 
    -0.23126750f, -0.11076479f, 0.03676799f, 0.02081783f, -0.10717301f, 0.01159005f, 0.08521411f, 0.09935293f, 
    0.14293610f, -0.06888057f, -0.16694258f, 0.03859056f, 0.15308222f, 0.06502308f, 0.19796881f, -0.06377338f, 
    0.07136478f, -0.10643333f, -0.03379183f, 0.04962602f, 0.16508739f, -0.10705996f, 0.18410385f, 0.09353299f, 
    -0.26165771f, 0.02863123f, -0.09250812f, -0.01657437f, 0.06953623f, 0.05261166f, 0.09561981f, -0.13323006f, 
    0.10916007f, 0.10237135f, 0.01503367f, 0.18424287f, -0.39823449f, -0.24042076f, 0.03524857f, -0.06545679f, 
    0.08794823f, -0.01840185f, -0.11396052f, 0.11235021f, -0.15106799f, 0.01418138f, -0.01818389f, -0.11553662f, 
    0.02943774f, -0.07439701f, 0.00027864f, -0.14657255f, -0.02020683f, -0.02665503f, 0.12439006f, -0.05792983f, 
    0.01038751f, 0.02035224f, -0.02669866f, 0.05284843f, -0.05523119f, -0.03480650f, -0.10611708f, -0.04339509f, 
    -0.09646965f, 0.09796915f, -0.01239358f, 0.12033997f, -0.03784531f, -0.07917755f, 0.09762534f, 0.07773054f, 
    -0.09225218f, -0.08115347f, 0.11359674f, 0.24976835f, 0.09399147f, -0.07785830f, -0.02820324f, 0.19404438f, 
    -0.03648922f, 0.02287475f, -0.02122482f, 0.01959912f, 0.30595496f, 0.08563139f, 0.15722930f, -0.04887565f, 
    0.22099471f, -0.14533073f, 0.02676538f, -0.04463155f, 0.06249172f, 0.01116986f, -0.04428297f, -0.06451251f, 
    -0.00748211f, 0.12866203f, -0.06460977f, 0.12730831f, 0.04267449f, 0.02031057f, -0.01616706f, 0.00436249f, 
    0.03775304f, 0.14960101f, -0.09637272f, 0.03349803f, 0.31845656f, -0.14327243f, -0.01005750f, 0.20669357f, 
    -0.18564057f, 0.08525667f, -0.02029373f, 0.02365562f, -0.13375694f, -0.07453949f, 0.06493206f, 0.13114309f, 
    -0.03621260f, 0.02216928f, -0.08713067f, -0.03515224f, 0.14209132f, -0.02813966f, 0.02035873f, -0.13040987f, 
    -0.01291532f, -0.04507307f, -0.01377261f, -0.05825458f, 0.30684018f, 0.12335368f, 0.13437526f, 0.06936694f, 
    -0.04000179f, 0.01295403f, 0.01964767f, 0.11413189f, 0.05259629f, -0.10748605f, -0.01933104f, -0.02879999f, 
    0.01592533f, 0.29658410f, -0.06514193f, 0.01585389f, 0.00029360f, 0.09180839f, 0.07460368f, 0.02519941f, 
    0.00220140f, 0.07492740f, 0.05393654f, -0.09454612f, -0.51602292f, -0.07042063f, 0.24517512f, 0.22613746f, 
    -0.10034747f, 0.07752240f, 0.02726249f, 0.00777026f, 0.13093863f, 0.01359661f, -0.02585907f, -0.01429726f, 
    0.22501728f, -0.02284231f, -0.05059632f, -0.04502054f, 0.09833778f, 0.01465941f, 0.08204151f, -0.06648307f, 
    -0.08559256f, -0.04109425f, 0.01897335f, 0.16106226f, 0.09947629f, 0.30036911f, -0.11368534f, 0.03111342f, 
    -0.04934000f, -0.11090293f, -0.08917847f, -0.05267175f, -0.01473593f, 0.06912779f, 0.15415452f, 0.03673886f, 
    0.35852587f, -0.00696185f, -0.16654016f, 0.02831482f, 0.02288519f, 0.01038606f, 0.02684668f, 0.03997780f, 
    0.02747318f, 0.10935359f, 0.02814593f, -0.07875671f, 0.22600190f, 0.17939411f, -0.23268884f, -0.01314452f, 
    0.07374516f, 0.17524621f, 0.03730311f, 0.01051831f, -0.05663933f, 0.14186259f, -0.09513562f, 0.13704710f, 
    -0.36338276f, 0.15834099f, -0.03070347f, -0.04447689f, -0.10415430f, 0.04012607f, -0.12669510f, -0.05200993f, 
    -0.10816313f, -0.00117438f, -0.00985763f, 0.00398625f, 0.22745775f, -0.22018915f, -0.04121513f, 0.00433129f, 
    0.12093753f, 0.11209472f, -0.08558936f, -0.05819537f, 0.04770204f, -0.03760903f, -0.01823040f, 0.04415356f, 
    -0.29960543f, 0.10961754f, -0.02958795f, -0.22119063f, -0.01188660f, -0.09045370f, 0.05367534f, -0.00941832f, 
    -0.10247556f, 0.06368168f, 0.05368441f, -0.16155507f, 0.23128426f, -0.05791263f, 0.09670079f, 0.13529390f, 
    0.01927515f, 0.00170282f, 0.01903724f, -0.00584379f, 0.06634658f, 0.05235722f, -0.04491147f, 0.04785066f, 
    -0.03591774f, -0.01823680f, -0.07243645f, 0.00117131f, -0.10686019f, -0.00945332f, 0.04745283f, 0.01218220f, 
    0.00828349f, 0.00863908f, -0.02758975f, -0.02676550f, 0.08153580f, -0.13618214f, -0.11230873f, -0.09312790f, 
    -0.05445066f, 0.06065383f, 0.05211325f, -0.11860537f, 0.00004456f, 0.00755393f, 0.09357587f, 0.10015767f, 
    -0.13440084f, -0.07732055f, 0.22402453f, -0.06784196f, 0.13884337f, 0.06509653f, 0.03491162f, 0.00075781f, 
    -0.11900292f, 0.04270931f, 0.00057535f, -0.03089461f, 0.10985503f, 0.06444548f, 0.13389270f, 0.06782274f, 
    0.10442477f, 0.05571465f, -0.17358030f, 0.20540120f, 0.02304569f, -0.04076526f, -0.01464325f, -0.10624641f, 
    -0.02792805f, 0.04354591f, 0.25072321f, 0.21312654f, 0.00645307f, 0.12448481f, -0.04891718f, -0.04366821f, 
    0.01521079f, 0.16138260f, -0.04632977f, -0.00392440f, 0.25094914f, -0.13996813f, -0.12283795f, -0.05527502f, 
    -0.03082344f, -0.00519749f, -0.01619777f, -0.03510509f, -0.00511494f, 0.01022257f, 0.16122161f, 0.03730819f, 
    -0.32069519f, -0.07500651f, 0.09693941f, 0.25126007f, 0.11882570f, -0.04517960f, 0.02903776f, 0.05598958f, 
    0.12590270f, 0.02662355f, 0.06468521f, 0.08823040f, -0.05548378f, -0.23460484f, 0.11315817f, 0.11988401f, 
    0.02641335f, 0.15127702f, 0.00292923f, -0.11284884f, 0.01746956f, 0.00142535f, -0.03231376f, 0.00582015f, 
    0.47269464f, -0.12653501f, 0.28805211f, -0.24277785f, 0.09308075f, 0.05674781f, 0.04695995f, 0.05590715f, 
    0.04734454f, 0.07013610f, -0.10896591f, 0.05940059f, 0.10086014f, -0.06424225f, 0.30288002f, 0.02567831f, 
    -0.03551940f, -0.05152110f, 0.02885702f, 0.01961567f, 0.08608508f, 0.04318595f, -0.04055412f, -0.04213065f, 
    0.21565101f, -0.25457928f, 0.24418631f, 0.02600864f, 0.12011556f, -0.05104006f, 0.16901767f, -0.05326181f, 
    0.09554107f, 0.03139923f, 0.07356680f, -0.13041934f, -0.03111926f, -0.06050310f, -0.14884311f, 0.17775206f, 
    0.04192052f, 0.12498885f, 0.10816307f, -0.14840344f, -0.02474296f, -0.08611950f, -0.03847418f, 0.01981369f, 
    -0.13741557f, 0.19680689f, 0.01045439f, -0.17737988f, -0.16206884f, 0.07809032f, -0.07083581f, -0.03336222f, 
    -0.04748774f, 0.07746172f, 0.08536770f, -0.03128397f, -0.02866886f, -0.15829149f, 0.04603981f, 0.08388580f, 
    -0.02719840f, -0.03323127f, -0.02626218f, 0.04355387f, -0.00379430f, -0.00029521f, 0.04532641f, 0.05150796f, 
    0.24088593f, -0.00501069f, 0.04111938f, 0.01374872f, 0.16260096f, -0.03436243f, 0.07152396f, -0.11756960f, 
    -0.12222072f, -0.05773846f, 0.09296574f, -0.07130441f, 0.12650262f, -0.03704679f, 0.00183578f, -0.05202293f, 
    0.07518870f, 0.11021617f, 0.03736334f, -0.08419399f, -0.01395033f, 0.01651427f, 0.07580553f, 0.12105270f, 
    0.09155329f, 0.02939728f, -0.17953455f, 0.26577404f, -0.04313511f, -0.09114526f, -0.06182550f, 0.10786402f, 
    -0.05570507f, 0.00800981f, 0.04471129f, 0.01599469f, -0.13037090f, 0.02321994f, 0.12516122f, -0.12406986f, 
    -0.10086498f, -0.08904777f, -0.06848415f, -0.09715252f, 0.04502527f, -0.04261489f, 0.14387541f, -0.01711886f, 
    -0.39091650f, 0.10955942f, 0.23100814f, -0.06273726f, 0.01664914f, -0.03659770f, -0.02508888f, -0.06983417f, 
    0.04747175f, 0.01851440f, 0.08930514f, -0.05747854f, 0.02637108f, 0.21029113f, 0.03122264f, 0.07276889f, 
    0.13853756f, 0.05151170f, 0.03901090f, 0.21802644f, 0.03815692f, 0.00874873f, -0.02566409f, 0.10547694f, 
    -0.21974227f, 0.23773800f, -0.10486139f, -0.15698959f, -0.01848773f, 0.01737570f, 0.04683964f, -0.03694421f, 
    -0.05511639f, -0.03051770f, 0.03450871f, -0.07829612f, -0.04436646f, -0.19730958f, 0.12762004f, -0.10250564f, 
    0.01400464f, 0.04819001f, -0.01569840f, 0.01508294f, -0.06610267f, -0.02063238f, -0.07910025f, -0.04076024f, 
    0.08888414f, 0.06787676f, 0.12785403f, 0.16214740f, -0.04864984f, 0.01977115f, 0.05911867f, -0.09502344f, 
    -0.03789327f, -0.04355125f, -0.03908216f, 0.05535501f, -0.06363228f, 0.05117463f, -0.28567204f, 0.22898574f, 
    -0.07920184f, 0.02688533f, 0.03260485f, 0.10724819f, -0.02441156f, -0.09442856f, 0.09392096f, -0.14146532f, 
    0.04740942f, 0.01777173f, 0.04270860f, -0.04508771f, -0.04459447f, 0.03422350f, 0.06476953f, -0.07112012f, 
    -0.01968754f, -0.04077743f, -0.03001218f, 0.01678719f, -0.04520449f, -0.02657036f, -0.02721161f, -0.02542612f, 
    0.05432053f, 0.05319948f, 0.04562827f, -0.07626395f, -0.00189661f, 0.04210245f, 0.03548567f, -0.06663533f, 
    -0.07599762f, 0.03249193f, -0.05776619f, -0.00918293f, -0.05157038f, -0.03335563f, -0.07827386f, -0.05637842f, 
    -0.00052244f, -0.05806104f, -0.06561696f, -0.02109778f, -0.03596969f, -0.07323897f, -0.03815922f, -0.02145485f, 
    -0.02932676f, -0.04201030f, -0.02499830f, -0.04540323f, -0.01226871f, -0.02540857f, -0.00968241f, 0.00192127f, 
    0.04695273f, 0.01635910f, 0.01345604f, -0.01424107f, -0.07024272f, -0.04848288f, 0.04223513f, -0.01002186f, 
    0.02890172f, 0.05506270f, -0.06320332f, 0.01869114f, -0.03485925f, -0.02105519f, -0.00803335f, -0.05568802f, 
    -0.05289967f, 0.01355930f, -0.00890143f, -0.02846762f, 0.07531754f, 0.02196023f, -0.02622107f, -0.02369032f, 
    -0.00630454f, 0.05009559f, -0.05998513f, -0.03955094f, 0.02100573f, -0.04886159f, 0.05885242f, -0.02051862f, 
    -0.05527921f, 0.01399641f, -0.00305304f, -0.05487895f, -0.01276507f, -0.06429662f, -0.02247599f, 0.01623522f, 
    0.00805121f, -0.01786375f, -0.02441126f, -0.03816955f, 0.06734740f, 0.05579346f, -0.02353224f, -0.06074318f, 
    -0.01651740f, 0.01092461f, -0.04684848f, 0.00727655f, -0.02695375f, 0.04432086f, -0.03096039f, -0.01882703f, 
    -0.01036851f, 0.00384411f, 0.00571153f, 0.00688390f, -0.01306781f, 0.03397027f, 0.02342455f, 0.02172490f, 
    -0.01983758f, 0.06879673f, 0.04869655f, -0.04961583f, -0.02430802f, -0.06996269f, 0.00682328f, 0.00083386f, 
    0.06301351f, -0.01635696f, 0.04583285f, 0.04526307f, -0.07020528f, -0.01759293f, 0.03095932f, 0.03869043f, 
    0.01524206f, 0.06229755f, 0.03828868f, -0.03014140f, 0.07220577f, 0.02007361f, -0.06863805f, 0.03160285f, 
    0.06428921f, -0.03612065f, 0.02379676f, -0.05957223f, 0.06443799f, -0.05739447f, -0.05159631f, 0.02701900f, 
    -0.05218144f, -0.06076482f, 0.03878848f, -0.02109521f, -0.06957400f, -0.03301963f, 0.05464248f, 0.02742846f, 
    0.00504943f, -0.05648309f, -0.05826027f, -0.00382137f, 0.02443507f, 0.00194421f, -0.07205955f, -0.04624409f, 
    -0.04810176f, 0.05503936f, -0.07319215f, -0.01576486f, -0.01759137f, -0.05620163f, -0.03645355f, -0.04124948f, 
    -0.04345380f, -0.01618182f, -0.06332356f, 0.03475990f, 0.03914124f, -0.06072979f, -0.04289019f, 0.02724462f, 
    -0.03757527f, -0.04880937f, -0.06713704f, 0.05027597f, 0.00346060f, -0.01134283f, 0.01973302f, -0.03922184f, 
    0.06173368f, -0.00126769f, -0.02311333f, 0.05657228f, -0.05420190f, 0.04681248f, -0.06768128f, 0.04876586f, 
    -0.13052815f, 0.25848153f, -0.11611632f, -0.29792356f, 0.15127532f, -0.03122142f, -0.16285874f, 0.07019685f, 
    0.05312099f, 0.08938642f, -0.12557387f, 0.06930787f, 0.16106072f, 0.25798732f, 0.05078145f, 0.18494892f, 
    -0.04058173f, -0.09862985f, 0.03723044f, 0.10994987f, 0.08710560f, 0.05024017f, 0.16185243f, -0.17292267f, 
    0.07700302f, 0.11807224f, 0.03978511f, 0.10007163f, -0.10270601f, -0.14619571f, 0.07449256f, 0.03441430f, 
    -0.06744722f, 0.06678471f, 0.06334865f, -0.00394103f, 0.10906104f, 0.13580742f, 0.07262076f, -0.35896730f, 
    -0.12157866f, 0.01338698f, -0.18620096f, 0.05771013f, 0.08765437f, -0.08307239f, 0.23680608f, 0.09354279f, 
    0.05981499f, -0.23076957f, 0.22945336f, 0.11067274f, 0.08399019f, 0.05225293f, 0.04645638f, 0.00150182f, 
    0.03176133f, 0.03387764f, -0.18975276f, 0.04560723f, -0.25680301f, 0.29059374f, 0.04591024f, 0.44074759f, 
    0.03633628f, -0.05705265f, -0.09753374f, 0.13767721f, -0.05257473f, 0.09700342f, 0.12704210f, 0.07976463f, 
    -0.21752322f, -0.11333915f, 0.20053993f, 0.30569276f, 0.09377731f, 0.08230222f, 0.11791917f, 0.08630712f, 
    0.00652460f, -0.08201683f, 0.03378230f, -0.00512815f, 0.11281160f, -0.06123895f, 0.14516555f, 0.19102608f, 
    -0.24149266f, -0.28046498f, -0.15603174f, 0.00935387f, -0.18411548f, -0.09084967f, -0.01214056f, 0.03964007f, 
    0.02896097f, -0.00758822f, -0.09505330f, -0.04660187f, 0.02363947f, 0.01728237f, -0.15766378f, -0.09060325f, 
    0.04958500f, -0.02672786f, -0.13692762f, 0.17360906f, -0.03810375f, -0.02564759f, -0.02192681f, -0.14430098f, 
    -0.05573587f, -0.01132823f, -0.01411601f, 0.11793275f, 0.01268806f, 0.04967266f, -0.03936817f, 0.09805951f, 
    0.00373135f, 0.16521472f, 0.01042110f, 0.02965216f, -0.00027236f, 0.04699135f, -0.14217615f, -0.02599595f, 
    -0.02528127f, 0.07596392f, -0.01325088f, -0.14337143f, -0.09304938f, -0.26693264f, -0.21036933f, -0.04880306f, 
    -0.09205347f, 0.08226306f, -0.04010550f, 0.06169088f, -0.08185959f, -0.10235356f, 0.03812205f, -0.08483806f, 
    -0.20046547f, 0.10946255f, -0.04883370f, -0.03451746f, -0.09274849f, -0.15927103f, -0.00074100f, -0.20698762f, 
    -0.01388161f, -0.10121706f, -0.00483068f, -0.00115880f, -0.02517505f, -0.24755445f, 0.13808693f, 0.19181806f, 
    0.16672760f, 0.05109622f, 0.08705432f, -0.06000342f, -0.03304508f, -0.23810449f, 0.16796833f, 0.07791717f, 
    0.15806946f, 0.17450860f, 0.06882870f, 0.12618792f, -0.05589341f, -0.06281120f, -0.14306003f, -0.11107125f, 
    -0.09343521f, 0.00826584f, 0.10271269f, 0.06106266f, -0.34536603f, 0.02446175f, -0.05451655f, -0.16629277f, 
    0.07504185f, 0.14521053f, -0.06698006f, 0.00913501f, 0.18107581f, -0.00251246f, 0.01287294f, 0.16737013f, 
    0.01955098f, 0.13437364f, -0.10853081f, 0.06131529f, -0.00114175f, -0.15232371f, 0.00725675f, 0.02835343f, 
    0.03126817f, 0.00382247f, -0.00411934f, 0.08574444f, -0.23919588f, -0.09948274f, -0.14795749f, -0.24427013f, 
    0.11987517f, -0.00265528f, -0.06104132f, -0.15485853f, 0.02471910f, -0.06240074f, -0.04835265f, 0.07833892f, 
    0.28897780f, 0.11701739f, -0.15962052f, -0.10327984f, 0.12913102f, 0.04385176f, -0.04153309f, 0.11733269f, 
    -0.02891327f, 0.04319008f, 0.06956534f, 0.01931754f, 0.18782233f, 0.11186809f, 0.14301705f, 0.25023955f, 
    0.06750444f, 0.09901349f, 0.06549255f, 0.04756096f, 0.08530791f, 0.14769492f, -0.03908770f, 0.17579778f, 
    -0.14158018f, -0.00610905f, -0.12751202f, -0.09937606f, 0.07019159f, -0.01200239f, -0.04943527f, 0.08172646f, 
    0.07793619f, 0.07104839f, 0.04818407f, -0.03420945f, 0.35882193f, -0.28274557f, -0.30074266f, -0.18238007f, 
    0.12912001f, 0.16718350f, 0.05214532f, 0.01987774f, -0.04035056f, -0.02807126f, -0.09165921f, -0.01945742f, 
    -0.29109159f, -0.16954614f, -0.17229080f, -0.24818464f, 0.10998074f, -0.01416378f, -0.00691670f, 0.05350260f, 
    -0.02903704f, 0.06892322f, 0.09497938f, 0.05838091f, 0.16577914f, 0.23230653f, -0.13941440f, 0.11025033f, 
    -0.09356904f, -0.01592573f, -0.00000500f, 0.05807562f, -0.04620973f, -0.01551950f, -0.13389646f, -0.06893368f, 
    0.05870160f, -0.02757866f, -0.06907406f, 0.03777156f, 0.00868812f, -0.05145567f, 0.01381342f, 0.00603927f, 
    0.10320877f, -0.00517504f, 0.04192544f, -0.03599728f, 0.30137804f, -0.16081245f, -0.13572438f, -0.00764011f, 
    -0.10777758f, 0.00787041f, 0.05994237f, -0.03043201f, 0.06958870f, -0.03093359f, 0.04888564f, 0.03338540f, 
    0.08185969f, -0.11896562f, -0.01190474f, 0.07742725f, -0.10838430f, 0.11923476f, 0.00695183f, -0.07013454f, 
    -0.01174646f, 0.01992860f, 0.09398954f, -0.09007360f, 0.13714257f, 0.06681328f, 0.09631260f, 0.14879467f, 
    -0.09706349f, 0.01850184f, -0.13812117f, 0.06349041f, 0.07545490f, -0.01328779f, -0.05365869f, -0.06445388f, 
    0.17816460f, -0.07319210f, 0.22355072f, 0.28241894f, -0.06842962f, 0.04296469f, -0.09778345f, -0.07595626f, 
    -0.05354912f, 0.16643816f, 0.05866633f, 0.13011217f, 0.20818591f, -0.13950771f, -0.21401055f, 0.10891193f, 
    0.03971367f, -0.01494306f, 0.02658062f, -0.00003967f, -0.02695435f, 0.02337249f, 0.16435185f, 0.02781479f, 
    -0.06267682f, -0.03144835f, 0.04766016f, 0.02560491f, -0.05139500f, 0.05106722f, -0.01305537f, 0.07239025f, 
    0.12003203f, -0.11302353f, -0.02799155f, -0.07117657f, 0.10762645f, -0.03962354f, 0.08525123f, -0.07764509f, 
    -0.11496663f, -0.10589179f, 0.13085844f, 0.06834923f, -0.02895666f, -0.00484357f, 0.02857253f, 0.14005004f, 
    0.04694596f, -0.03790209f, -0.03200919f, 0.03640008f, -0.05156574f, -0.03698952f, -0.05860708f, -0.03880089f, 
    0.04400940f, -0.03836032f, 0.02877252f, 0.04786270f, 0.01932681f, 0.02773409f, -0.08313406f, -0.03545415f, 
    0.01673439f, -0.07652056f, -0.03130023f, 0.00248607f, 0.04711347f, 0.04388345f, -0.07347186f, 0.00409878f, 
    -0.04652009f, 0.00761354f, 0.03089210f, -0.05781856f, 0.04589527f, -0.02162887f, -0.06314868f, -0.06254339f, 
    0.04249815f, -0.04920867f, 0.03034184f, 0.02156302f, 0.01232234f, 0.05258926f, 0.05091621f, 0.02721316f, 
    -0.00446731f, -0.03900167f, -0.05235194f, -0.03029123f, 0.02426359f, 0.00917572f, -0.02378424f, -0.05322162f, 
    0.04210576f, -0.02203297f, 0.05628770f, 0.01499968f, -0.04693557f, -0.05639504f, 0.02799843f, -0.08185659f, 
    -0.06462081f, -0.03754552f, 0.06220077f, -0.04191247f, -0.03675731f, 0.00056693f, -0.00700821f, -0.01915422f, 
    0.01712155f, -0.08325042f, -0.01379729f, 0.03775648f, 0.03770256f, -0.01262259f, 0.05144950f, -0.07231774f, 
    0.03243844f, -0.07143792f, 0.01111110f, 0.04021087f, -0.03685001f, -0.05418744f, -0.01796356f, -0.04792938f, 
    0.01662841f, -0.01496246f, -0.08356784f, -0.01333912f, 0.04431322f, -0.00732645f, -0.07005598f, 0.02265565f, 
    -0.02373792f, 0.04743143f, 0.00448536f, -0.02559090f, -0.05426759f, -0.02538015f, -0.00945371f, -0.03093793f, 
    0.01450966f, 0.03489653f, 0.02628068f, 0.05787571f, 0.03794024f, -0.01114925f, 0.04158540f, 0.05465540f, 
    -0.05218932f, -0.03202562f, -0.01310863f, -0.03620487f, -0.00317862f, -0.02278976f, -0.06055385f, 0.05284597f, 
    -0.02506099f, 0.01727214f, 0.00527788f, 0.05710408f, 0.04753609f, 0.03872454f, 0.00169006f, -0.04772143f, 
    0.03154473f, -0.02926676f, 0.00420470f, 0.03664638f, -0.07349078f, -0.03695987f, -0.07374904f, 0.00631616f, 
    -0.06347004f, -0.00515959f, 0.03486688f, -0.03829416f, -0.06939103f, -0.04859779f, 0.02035752f, -0.01132682f, 
    0.01713146f, -0.07501164f, -0.02341454f, -0.03568503f, 0.02822771f, -0.05757648f, 0.03654651f, -0.00428452f, 
    0.03928716f, -0.06015788f, -0.00283014f, -0.03824629f, -0.05769143f, -0.05427073f, 0.01099453f, 0.02071959f, 
    -0.07149506f, -0.08933647f, -0.01141998f, 0.00019608f, -0.03623047f, 0.00120479f, 0.04056414f, -0.00605337f, 
    -0.05696893f, -0.05413789f, 0.04470049f, -0.00888875f, -0.05802716f, 0.04001525f, 0.00529832f, 0.06204503f, 
    -0.02799482f, 0.05693951f, -0.01580638f, 0.05536798f, -0.08056182f, -0.06965710f, 0.01336063f, -0.00964364f, 
    0.02901543f, -0.01272399f, -0.03409760f, 0.02214088f, 0.01428557f, -0.02182491f, 0.02232995f, -0.04670263f, 
    -0.06839753f, -0.05825993f, -0.01380461f, -0.04496765f, -0.00563359f, -0.03218834f, -0.07849691f, 0.04822329f, 
    0.08447558f, -0.02287244f, -0.03542636f, 0.00486771f, -0.05256066f, 0.10545195f, 0.03924493f, -0.04417215f, 
    0.00425662f, 0.05374152f, -0.02270691f, 0.02820162f, -0.19987521f, -0.13913655f, -0.03362625f, 0.03784154f, 
    0.01994316f, -0.08305438f, 0.11072335f, 0.01561647f, 0.02755928f, 0.04167223f, -0.00367730f, -0.01581942f, 
    -0.26357535f, 0.10336742f, -0.03194860f, 0.00584280f, -0.13999116f, -0.00156372f, 0.00180639f, -0.01725129f, 
    0.12160124f, -0.02391347f, 0.02856103f, 0.11745270f, -0.07319464f, -0.04280877f, 0.15574256f, -0.05620928f, 
    -0.09091529f, -0.11621994f, 0.12913966f, 0.02699849f, 0.09997958f, -0.01262945f, -0.00627499f, -0.04560686f, 
    -0.06180003f, -0.12884825f, -0.11968692f, 0.15592305f, 0.18848743f, 0.10930780f, 0.05899179f, 0.00316259f, 
    0.01130444f, 0.13718911f, 0.04952304f, 0.09908475f, -0.05273056f, -0.03721668f, -0.12419117f, -0.12209648f, 
    0.04930035f, -0.07186360f, -0.06588902f, -0.06150186f, -0.01752679f, 0.06751800f, -0.00337479f, -0.06275906f, 
    -0.04249582f, -0.04414895f, -0.09374601f, 0.20717829f, -0.03694621f, 0.01376316f, 0.01022686f, 0.02605426f, 
    0.02049449f, 0.16029103f, -0.13123034f, 0.00035197f, -0.03865634f, 0.10019573f, 0.24496914f, -0.00128631f, 
    -0.11386000f, -0.03516243f, 0.03689361f, 0.05008839f, -0.00605651f, 0.03302062f, 0.05974566f, -0.04644838f, 
    -0.01310752f, 0.22118878f, 0.07042430f, -0.03158518f, 0.02136025f, -0.01263033f, 0.05799494f, -0.10495377f, 
    0.01980847f, -0.03624756f, -0.03637177f, 0.01223428f, 0.05336349f, 0.00988332f, 0.13760810f, 0.07285033f, 
    0.07417190f, -0.02487853f, 0.08180950f, 0.11751816f, 0.06503274f, -0.00900920f, -0.09288178f, -0.03208183f, 
    0.24744029f, 0.04158534f, 0.11579605f, 0.02405454f, -0.03770397f, -0.02060110f, 0.09802719f, 0.00507327f, 
    0.15144123f, 0.02291240f, -0.06557428f, -0.07421159f, 0.05477192f, 0.17129213f, -0.01558293f, 0.06852057f, 
    -0.05640131f, -0.05601774f, 0.08013485f, -0.05609203f, -0.12926400f, 0.06371723f, 0.15354970f, 0.05584806f, 
    0.09005344f, 0.08226203f, 0.05026073f, 0.00591166f, -0.03120150f, -0.01925700f, 0.04784720f, 0.05414396f, 
    -0.11621545f, -0.14333808f, -0.00584320f, -0.13280463f, -0.05509615f, -0.08838277f, 0.01207031f, 0.04454997f, 
    0.04744789f, -0.02610142f, -0.01548927f, -0.05170028f, 0.05128661f, 0.04969800f, 0.04855818f, -0.11388496f, 
    0.41720739f, 0.22934821f, 0.11403600f, -0.02512642f, -0.03825306f, -0.01023296f, 0.02309634f, 0.01860817f, 
    -0.00502842f, 0.12964588f, 0.11361676f, 0.05728846f, 0.06339388f, -0.00590456f, 0.10228224f, -0.21528029f, 
    0.00464927f, -0.05656535f, -0.05983263f, 0.02157242f, 0.13819729f, 0.13406560f, -0.01537656f, 0.10990827f, 
    -0.54771727f, 0.15472457f, 0.05674832f, 0.02997887f, 0.05729809f, -0.00772103f, -0.12580755f, 0.06565959f, 
    0.00993515f, -0.10772399f, -0.00073030f, 0.03389946f, 0.23692650f, 0.06741004f, 0.14845319f, 0.07938886f, 
    0.01592593f, 0.10574707f, -0.00648551f, 0.06076140f, 0.05736174f, -0.02614745f, 0.04258850f, 0.02791008f, 
    0.05262904f, -0.01368554f, 0.00557904f, 0.07687635f, 0.03106908f, 0.00482740f, -0.02647518f, -0.02858490f, 
    -0.09545081f, 0.00092262f, 0.15010402f, -0.00633772f, 0.03341753f, 0.01014942f, 0.06683866f, 0.08286779f, 
    0.08936281f, 0.08829857f, -0.05774508f, 0.06534138f, -0.05348632f, 0.11462563f, -0.08989345f, 0.05842252f, 
    0.30737746f, 0.01884804f, -0.02060426f, 0.03416087f, -0.00593795f, -0.09630637f, -0.07578919f, -0.00372951f, 
    0.10491163f, 0.00575573f, 0.01288435f, -0.05218806f, 0.17414576f, 0.28009385f, 0.04994127f, 0.15784681f, 
    -0.06665779f, -0.04926956f, 0.05972711f, 0.01589852f, 0.15370204f, 0.13505875f, 0.06111173f, 0.06187769f, 
    0.14591171f, -0.07994555f, 0.15451548f, 0.05218302f, 0.05383746f, -0.09529512f, -0.02875267f, -0.02437593f, 
    0.10537705f, -0.10743209f, 0.24427845f, 0.04477974f, -0.06856059f, -0.09597129f, -0.01198847f, -0.01514591f, 
    0.01762677f, 0.06129337f, -0.05832693f, 0.00842239f, 0.05020794f, 0.00921976f, 0.01399042f, -0.02611103f, 
    0.19408068f, -0.05929501f, -0.16878073f, 0.14191489f, 0.03612388f, 0.02562970f, 0.03555381f, 0.04105021f, 
    0.07700132f, 0.02449119f, 0.11631913f, 0.06448846f, -0.07346653f, 0.08711453f, -0.06473591f, -0.05935609f, 
    -0.03965712f, 0.05059414f, 0.09996931f, 0.07850165f, 0.06210657f, -0.03928730f, 0.11135874f, 0.07734963f, 
    -0.05766385f, 0.07191355f, -0.13142808f, 0.02951363f, -0.00190763f, -0.07786352f, -0.06275114f, 0.06240012f, 
    0.06474964f, 0.06068381f, 0.17568471f, -0.02293102f, -0.22549175f, -0.05405001f, -0.02189177f, -0.19561227f, 
    0.08599231f, 0.00137873f, -0.09463283f, 0.02391034f, 0.10802785f, -0.02834259f, 0.02222197f, -0.05626909f, 
    -0.05571051f, 0.06541388f, -0.00263069f, -0.08746327f, -0.04530454f, -0.09368397f, -0.00341134f, 0.02701667f, 
    0.05036074f, 0.12813449f, 0.02823771f, 0.14674976f, -0.15877278f, 0.18110323f, 0.05418126f, 0.08837181f, 
    -0.09671202f, -0.03089754f, 0.09527617f, 0.05749687f, 0.07113563f, 0.15379304f, 0.05377424f, 0.26843435f, 
    -0.12437853f, -0.31293371f, -0.21290682f, -0.00289393f, 0.06769776f, 0.14285786f, 0.12353306f, 0.04035492f, 
    0.04949170f, -0.02587014f, 0.00529874f, 0.02816106f, 0.20289741f, 0.20170392f, -0.17967664f, 0.04413876f, 
    -0.05712532f, -0.02964455f, 0.09684527f, -0.08569819f, -0.00264798f, -0.04097670f, 0.07686717f, -0.01531572f, 
    0.20099464f, -0.02997494f, 0.17793460f, -0.21716799f, 0.03441662f, 0.01589125f, 0.04089980f, 0.00367110f, 
    0.02730201f, 0.11715390f, -0.09675945f, -0.08524487f, -0.30110058f, -0.16786425f, -0.04527618f, -0.12620012f, 
    0.06572028f, -0.07139014f, 0.15203767f, -0.11842194f, 0.03609087f, 0.02061783f, -0.03496760f, 0.01793723f, 
    -0.08726020f, -0.01376966f, 0.10043571f, -0.20282850f, -0.04629359f, -0.11269937f, 0.03367583f, 0.02253409f, 
    -0.01324796f, -0.06713641f, -0.07731507f, 0.11542512f, -0.04404408f, 0.03644422f, 0.08461932f, 0.13321771f, 
    -0.01483642f, -0.08024622f, -0.06083872f, -0.03121341f, -0.05000700f, -0.03513334f, 0.05146453f, -0.08258397f, 
    0.05109651f, 0.05634436f, -0.14245585f, 0.00504478f, -0.02403764f, 0.13393912f, -0.00286116f, -0.08026951f, 
    0.03503957f, 0.12756208f, -0.07184262f, 0.06045767f, -0.42380559f, -0.06316883f, -0.07640264f, 0.06852610f, 
    0.07694975f, 0.01742317f, -0.02461339f, -0.07527431f, -0.01991163f, -0.05910175f, 0.02807502f, 0.02845920f, 
    0.10283248f, -0.19818762f, -0.01857267f, 0.15288323f, 0.17792463f, 0.18522429f, 0.01421630f, -0.06568640f, 
    0.16282143f, 0.10612284f, -0.05973619f, 0.05329413f, -0.22837886f, 0.02234842f, 0.07723035f, 0.08452505f, 
    -0.00736567f, -0.04527730f, 0.09997789f, 0.13252313f, -0.00534232f, 0.13859938f, 0.21590015f, -0.00938713f, 
    0.19391447f, 0.05065019f, 0.02699780f, 0.16275445f, 0.05854231f, 0.03673343f, -0.00614518f, 0.03340163f, 
    -0.04322314f, 0.07036517f, -0.06167073f, 0.05184685f, 0.08835247f, 0.09869455f, 0.23922186f, 0.04584493f, 
    0.09743536f, -0.02995264f, -0.06826906f, -0.04513473f, -0.03950538f, 0.02900267f, 0.09252604f, 0.02620625f, 
    0.12306914f, 0.09188290f, 0.05473036f, 0.01874928f, -0.11526449f, 0.06596780f, -0.05440554f, -0.11386721f, 
    0.14762166f, 0.11440900f, 0.01773598f, 0.08058447f, 0.15078686f, 0.11922206f, 0.08250212f, 0.17220119f, 
    0.02776243f, 0.01102219f, 0.05699182f, 0.12913278f, -0.06663945f, 0.08948077f, 0.10268158f, 0.04779590f, 
    0.01990755f, 0.10392906f, -0.19058304f, 0.05520000f, -0.01113594f, -0.00595521f, -0.05063337f, 0.03638738f, 
    -0.11406809f, -0.08251175f, 0.18368167f, -0.10417794f, -0.06854609f, -0.07007786f, 0.20590068f, 0.20616508f, 
    0.09710288f, 0.02589048f, 0.08562798f, -0.08875778f, 0.00188920f, -0.01775504f, 0.01178995f, -0.08389758f, 
    -0.09042954f, 0.27208897f, -0.02032940f, -0.04009144f, -0.04401308f, -0.00831448f, 0.04968936f, 0.04373567f, 
    -0.08663300f, -0.02494786f, 0.08608323f, -0.11560429f, -0.16270816f, -0.05077145f, -0.06483928f, -0.19965997f, 
    -0.05973362f, 0.02835668f, 0.06122216f, -0.04288578f, 0.07304902f, 0.13552460f, 0.16144477f, -0.04376019f, 
    -0.00147896f, -0.01090318f, 0.06855325f, -0.04705779f, 0.02579132f, 0.06428893f, 0.04141391f, 0.02360994f, 
    0.03430080f, 0.04973467f, 0.03740256f, 0.04271014f, 0.03360269f, 0.06300289f, -0.06989793f, -0.00900393f, 
    -0.01755212f, -0.05905961f, 0.00780426f, 0.02327327f, 0.04760470f, 0.06452408f, -0.05288326f, -0.03863018f, 
    0.05635028f, 0.00992407f, -0.05042126f, 0.04398596f, -0.02265972f, -0.04075093f, 0.00579443f, -0.02486989f, 
    0.05090335f, -0.04612276f, -0.04261939f, -0.06320116f, 0.02395561f, -0.00831325f, 0.01943449f, -0.02769720f, 
    -0.03464605f, 0.06881165f, -0.01061319f, -0.03533292f, 0.00506032f, 0.02628423f, -0.05471994f, -0.05255909f, 
    0.02260950f, 0.01817696f, -0.06821951f, -0.06880337f, -0.01082647f, -0.03084855f, -0.01387982f, -0.00137901f, 
    -0.03783619f, -0.04997329f, -0.06276958f, -0.06341011f, -0.03894430f, -0.03051140f, -0.01726360f, 0.02056953f, 
    -0.00716078f, -0.06601232f, 0.06342755f, -0.04345961f, 0.07136122f, -0.05639321f, 0.04484547f, -0.01666466f, 
    0.05365911f, 0.02006392f, -0.07054723f, 0.02093896f, 0.04984532f, 0.00507094f, 0.05008751f, -0.01355301f, 
    -0.00068723f, 0.00582538f, -0.05281813f, 0.00236185f, -0.06981215f, -0.00468223f, -0.01258782f, -0.06228002f, 
    -0.05847600f, 0.05849995f, -0.00580531f, -0.01975807f, -0.04324265f, 0.01253172f, -0.05439630f, -0.04038632f, 
    -0.01968825f, 0.01076828f, 0.00960762f, 0.00012126f, -0.03954614f, -0.01930917f, 0.00569426f, -0.05619931f, 
    0.01146853f, -0.04803225f, -0.07180592f, -0.03008190f, 0.01110011f, -0.02285708f, -0.06546977f, -0.04114824f, 
    0.07137837f, -0.01197415f, -0.04017067f, -0.01062956f, 0.04590727f, -0.03326074f, -0.05647670f, -0.06690830f, 
    0.06476586f, -0.04489449f, -0.06208941f, -0.06679487f, -0.06612635f, 0.03504584f, 0.04840666f, 0.03452117f, 
    -0.01902914f, 0.00426248f, -0.06689366f, -0.03810166f, 0.01738507f, 0.03648497f, 0.07016448f, -0.01797102f, 
    0.04837131f, 0.04909921f, -0.00565957f, -0.02997471f, 0.05148299f, 0.05784804f, 0.00435253f, -0.01518755f, 
    -0.06768061f, -0.03058165f, -0.01013404f, -0.03509437f, -0.04510548f, -0.07173194f, -0.02921435f, -0.00558591f, 
    -0.03330807f, 0.01072147f, -0.02942858f, 0.03929903f, 0.01971407f, 0.01115130f, 0.01954713f, -0.01850056f, 
    0.05144865f, -0.02340354f, 0.00632114f, -0.05967596f, 0.06154250f, 0.03601552f, -0.01634145f, 0.02032779f, 
    -0.05394635f, -0.05591361f, -0.02049534f, -0.06484612f, -0.07078795f, 0.03158830f, 0.06656349f, -0.05692236f, 
    0.01607743f, 0.06403502f, -0.04408429f, 0.04450753f, -0.04563049f, -0.01625604f, 0.02158237f, 0.01374014f, 
    0.04489857f, -0.05580388f, -0.07017305f, 0.04502108f, 0.04170414f, 0.03339633f, -0.06805487f, -0.03436838f, 
    -0.45541760f, 0.12690680f, -0.07671750f, 0.09605970f, 0.10490575f, -0.12884945f, -0.00977310f, -0.08586999f, 
    0.04819728f, -0.07350440f, 0.08883481f, 0.08500555f, 0.04238364f, -0.10162564f, 0.07738262f, -0.16214494f, 
    0.06397272f, -0.14541277f, -0.10525541f, -0.05294976f, -0.02898073f, -0.10488115f, -0.02264325f, -0.04600849f, 
    0.17542627f, -0.04008675f, -0.03662509f, 0.05849360f, 0.16736615f, 0.10989442f, 0.00007664f, -0.05732575f, 
    0.00280399f, 0.03132771f, 0.14133602f, 0.06594973f, 0.11684630f, -0.08394413f, 0.01658919f, 0.13697416f, 
    0.02374570f, 0.17295986f, -0.00942362f, 0.19209808f, 0.15364982f, 0.21368223f, -0.08676223f, 0.13020512f, 
    -0.18083537f, 0.03599766f, -0.08045731f, 0.03881684f, 0.06493659f, -0.09192822f, -0.04433224f, -0.00038322f, 
    0.17592634f, -0.00332698f, 0.01349914f, -0.03543125f, 0.26462740f, 0.00813733f, -0.23278877f, -0.06701090f, 
    0.00685252f, 0.08392496f, 0.02901893f, -0.05014632f, 0.04440161f, -0.06808987f, -0.06203970f, -0.04073826f, 
    -0.07698701f, -0.04065260f, -0.07727806f, -0.06658687f, -0.01933779f, -0.12615179f, -0.04730552f, 0.03392887f, 
    0.02012635f, -0.03821208f, 0.15072538f, 0.04446173f, 0.19357039f, 0.13584054f, -0.13692327f, -0.05944931f, 
    -0.02658914f, 0.10465089f, -0.05279004f, -0.02285239f, 0.03660296f, -0.06764243f, -0.08303857f, -0.11908706f, 
    0.16442432f, 0.00814154f, -0.08434395f, 0.14821242f, 0.12932570f, 0.05547336f, 0.11182821f, -0.01779467f, 
    0.08531964f, 0.01473736f, 0.16113862f, -0.06946659f, 0.23097984f, 0.03061390f, -0.21055441f, 0.02340410f, 
    -0.06587067f, 0.03083864f, 0.14808077f, 0.05160706f, 0.07305674f, -0.03407842f, 0.00881422f, 0.15123215f, 
    -0.01999576f, 0.04504380f, -0.15130858f, -0.16064823f, 0.02116346f, 0.04757733f, 0.02028169f, -0.07502984f, 
    0.05231646f, 0.03276094f, 0.07271370f, -0.06738237f, 0.00831914f, -0.03578429f, 0.06985850f, -0.08285073f, 
    0.04711240f, 0.02774739f, -0.11008485f, -0.06844552f, 0.09761526f, -0.01793903f, -0.02872364f, -0.13906406f, 
    0.02045739f, -0.13863297f, 0.24430189f, 0.06095682f, -0.05278844f, -0.02907682f, 0.01229557f, 0.02804285f, 
    0.12025400f, 0.16502866f, -0.02617083f, 0.05982330f, 0.23267142f, 0.17584422f, -0.19571307f, -0.00672018f, 
    -0.11469053f, -0.02945520f, 0.05345544f, 0.08301438f, -0.01989811f, 0.01652897f, 0.08248416f, 0.08737618f, 
    0.13759558f, -0.23104677f, -0.15961081f, 0.10968921f, 0.06252272f, -0.02940007f, 0.12842564f, 0.02795835f, 
    0.07828008f, -0.09037483f, -0.06061686f, -0.02765828f, 0.15309514f, 0.13409355f, 0.12985927f, 0.04037709f, 
    -0.02175391f, 0.03022597f, -0.06545772f, -0.06103506f, -0.01289149f, 0.02848138f, -0.05334567f, 0.03019935f, 
    -0.31285873f, 0.18811141f, -0.11161826f, 0.01921495f, -0.04687697f, -0.08610800f, -0.04424195f, -0.05733926f, 
    0.00990411f, -0.03766664f, 0.05058717f, 0.14181702f, -0.22654480f, 0.33615625f, 0.12035289f, 0.04382933f, 
    0.12882501f, -0.04808936f, -0.10242110f, -0.09691779f, -0.07048248f, -0.05513820f, 0.02014318f, -0.08387940f, 
    0.10641655f, -0.08807716f, 0.01642226f, -0.09108772f, 0.22062857f, 0.04443271f, -0.01433389f, 0.03982203f, 
    -0.04210908f, 0.01949190f, 0.07942715f, -0.01186751f, 0.01410749f, -0.00873393f, -0.04119508f, 0.09111216f, 
    0.07352915f, 0.16975895f, 0.11649537f, 0.10122883f, 0.01906648f, 0.14176749f, -0.02947775f, 0.06841323f, 
    -0.00612666f, 0.22104351f, -0.05010511f, -0.06997416f, -0.02993537f, -0.06990481f, -0.15229066f, 0.01014952f, 
    0.04083325f, 0.01170887f, -0.01308090f, -0.05168342f, 0.34685922f, -0.23729467f, 0.07383664f, 0.04974544f, 
    0.11356968f, 0.02995087f, 0.04358087f, -0.06606008f, 0.00695950f, -0.04454500f, -0.05771384f, -0.00023537f, 
    -0.09751203f, 0.07477289f, -0.02542025f, -0.02821022f, -0.01359903f, -0.07759711f, 0.10845805f, 0.05427682f, 
    0.03307449f, 0.02547694f, -0.02616870f, 0.14491417f, -0.02806501f, 0.20209938f, -0.15894593f, 0.01666472f, 
    0.09073104f, 0.11036908f, -0.04167394f, -0.00243224f, -0.03564189f, 0.06628642f, -0.14649369f, 0.05945396f, 
    -0.01601983f, 0.22311398f, 0.06387424f, 0.07799853f, -0.10903608f, -0.02386177f, 0.04492737f, -0.01639018f, 
    -0.00378872f, 0.05351318f, 0.04374605f, -0.06600755f, -0.15022391f, -0.11210220f, -0.06686212f, -0.05988125f, 
    -0.06453152f, -0.11298796f, 0.08205922f, -0.11453078f, -0.08932819f, 0.03550298f, 0.04864494f, 0.10205745f, 
    -0.31794763f, -0.10601226f, -0.09047635f, 0.04136319f, 0.15943906f, 0.14962223f, 0.04271774f, -0.03750376f, 
    -0.03851241f, 0.12216821f, 0.14139959f, -0.02588878f, 0.04943594f, 0.05857966f, 0.00758471f, 0.08330707f, 
    0.12815785f, 0.13880034f, -0.11142075f, 0.04233881f, -0.06515267f, 0.03684317f, -0.10588743f, -0.13146754f, 
    -0.02059499f, 0.07783575f, 0.02601931f, 0.08353416f, 0.16883662f, 0.02963853f, -0.11069372f, -0.04765552f, 
    0.07864469f, 0.09080651f, 0.03783619f, 0.09192578f, 0.17907071f, -0.05248490f, -0.07838853f, 0.02448566f, 
    -0.03137555f, -0.09038287f, -0.01225135f, 0.01154305f, 0.01424573f, -0.04940027f, 0.10853427f, 0.06985418f, 
    -0.32542425f, -0.14853314f, -0.02954776f, 0.02156967f, 0.10187124f, 0.10628057f, 0.09484297f, -0.02135861f, 
    0.14432596f, -0.05357380f, -0.03818732f, 0.03077492f, 0.47052813f, 0.04556036f, 0.23573694f, -0.06061985f, 
    -0.00066952f, 0.07581076f, -0.04890416f, 0.06391561f, -0.08973216f, 0.04168477f, 0.12238742f, 0.04883775f, 
    0.38688365f, -0.10969934f, -0.00597912f, -0.12624665f, 0.03406609f, 0.08362379f, -0.00718447f, 0.04976925f, 
    -0.00363526f, -0.08427963f, -0.06279777f, 0.07958577f, 0.27800030f, 0.08939456f, 0.03835991f, -0.11424837f, 
    0.01383878f, -0.11868825f, -0.02635719f, 0.10733367f, 0.03757521f, -0.03385142f, 0.07506136f, 0.07540281f, 
    0.37231851f, -0.15053967f, -0.05429956f, -0.07499489f, -0.01341594f, 0.03722696f, 0.01056703f, 0.04823887f, 
    -0.11673520f, 0.00446850f, -0.02765058f, -0.12885299f, 0.00214047f, 0.06721665f, -0.06774461f, -0.08014433f, 
    0.11651165f, -0.01383349f, 0.04747472f, 0.00264248f, -0.06994523f, -0.10165331f, 0.08511648f, 0.15782394f, 
    -0.29973900f, -0.14564961f, 0.06881563f, 0.05790575f, 0.02283199f, 0.07759080f, 0.00935048f, 0.02775281f, 
    -0.00189476f, 0.01179841f, -0.07605605f, 0.07978722f, 0.13354453f, 0.04467561f, -0.13686676f, 0.07493233f, 
    0.09906706f, 0.06753777f, -0.04368795f, -0.05369599f, 0.10261294f, 0.10526947f, -0.00521552f, 0.03404219f, 
    -0.19442531f, 0.05802383f, 0.03878406f, -0.17496353f, 0.02627276f, 0.00544345f, -0.04046164f, 0.07384869f, 
    -0.00910653f, -0.01107136f, 0.18044879f, -0.10093740f, 0.18578672f, -0.20581725f, 0.11525971f, 0.21943073f, 
    -0.09776544f, 0.00884216f, 0.11657329f, -0.07306251f, 0.03931143f, 0.00215910f, 0.06007309f, -0.00645327f, 
    -0.03642603f, -0.08921854f, -0.23682961f, -0.04436679f, 0.14155494f, 0.03348736f, 0.05159837f, -0.09560605f, 
    0.08891977f, -0.07935381f, 0.06223345f, -0.00956088f, 0.24583730f, -0.03958730f, -0.11750699f, -0.04424062f, 
    0.05746629f, 0.04200892f, 0.01407230f, -0.06293682f, -0.03860086f, -0.06981718f, -0.00677809f, 0.03875423f, 
    -0.16620158f, -0.00448562f, 0.22562648f, 0.16533631f, 0.10084177f, 0.06035731f, -0.08975840f, -0.01198096f, 
    -0.01947412f, 0.07144090f, 0.02263660f, -0.06486615f, -0.16926470f, -0.22591592f, -0.16238967f, -0.00274120f, 
    0.00325110f, 0.05665443f, -0.07740554f, 0.20248318f, 0.05797634f, -0.07355869f, 0.06144275f, 0.00271159f, 
    -0.35983205f, 0.08141189f, 0.15073863f, -0.00873851f, -0.06474900f, -0.01125680f, 0.03276332f, -0.02135403f, 
    0.04822535f, 0.01775388f, -0.04409739f, 0.07355714f, 0.22485247f, 0.01566744f, -0.02832857f, -0.01418646f, 
    0.07698710f, 0.07513005f, 0.00768615f, -0.04685572f, -0.03537540f, 0.08718581f, -0.09632298f, 0.11912593f, 
    0.12151103f, -0.05810634f, 0.05820570f, 0.14512354f, -0.05028930f, -0.03809291f, 0.03012279f, 0.07563283f, 
    -0.03907184f, 0.03783473f, 0.06679586f, 0.00351955f, -0.25866216f, -0.27648100f, 0.12032757f, 0.03433765f, 
    -0.00988564f, 0.14043157f, 0.07103034f, -0.04815474f, 0.06438749f, -0.04215240f, -0.00937500f, -0.00768062f, 
    -0.07905719f, -0.10835762f, -0.11873544f, 0.03572138f, 0.05700712f, 0.00928734f, 0.02098388f, 0.08453356f, 
    0.03698272f, -0.00567455f, -0.03720766f, 0.14807761f, 0.22017482f, 0.19184370f, -0.32778940f, 0.13382100f, 
    0.00831858f, 0.04134871f, 0.08795082f, 0.05689786f, -0.01723689f, 0.12263127f, 0.06325248f, 0.20955420f, 
    0.08423614f, 0.15805377f, -0.08727004f, -0.00176552f, -0.06808689f, 0.05147588f, -0.11108953f, 0.08724403f, 
    -0.00467098f, 0.15934683f, -0.09729393f, 0.10581765f, 0.03810204f, 0.25327754f, -0.11650339f, -0.20613492f, 
    0.10764214f, -0.12054368f, -0.10953559f, -0.10407565f, -0.03332075f, -0.06647498f, 0.08606116f, -0.11030415f, 
    0.01393530f, -0.10246619f, 0.10675243f, 0.10276102f, -0.01874888f, 0.04775317f, 0.08753040f, 0.04288878f, 
    -0.13724740f, -0.04908824f, -0.10739063f, 0.06782482f, 0.02647070f, 0.21105900f, 0.11873308f, 0.16248251f, 
    0.03146450f, 0.08073409f, 0.01486830f, 0.03922871f, 0.10854848f, 0.18521400f, 0.03816187f, 0.06614858f, 
    -0.22402456f, 0.19785611f, 0.09178151f, -0.14962211f, -0.06726697f, 0.00340034f, 0.00581083f, 0.03022003f, 
    -0.02222189f, 0.04304160f, -0.01818527f, -0.10349927f, -0.07683295f, -0.24924915f, 0.19624731f, 0.22584577f, 
    0.08560179f, -0.05126901f, 0.05070532f, 0.07928899f, -0.01368540f, 0.08601198f, 0.00993940f, 0.07294666f, 
    -0.19865686f, -0.05694695f, 0.01778940f, -0.29045051f, 0.02474423f, 0.10045639f, 0.00254292f, -0.00719360f, 
    0.13939781f, -0.03411203f, -0.12327004f, 0.04857196f, -0.11432140f, -0.12497805f, -0.07250327f, -0.01743102f, 
    0.04152376f, 0.14603591f, 0.03587230f, 0.11398211f, -0.00108784f, 0.06846628f, 0.07740550f, -0.06698832f, 
    0.02601438f, -0.02984133f, 0.14862530f, 0.14200819f, 0.05540163f, 0.02153251f, 0.06650230f, 0.06474596f, 
    -0.05865162f, -0.01673442f, -0.01506916f, -0.02580208f, -0.12787968f, -0.13445550f, -0.07420389f, -0.02860921f, 
    -0.03758790f, 0.02368660f, 0.02044497f, 0.15790148f, 0.12980637f, -0.05585889f, 0.04420301f, 0.03109233f, 
    0.09097306f, 0.10144079f, 0.16385707f, 0.12318903f, 0.03643571f, -0.01195184f, 0.05959918f, -0.02510242f, 
    0.01974171f, -0.14892335f, -0.01539693f, 0.06373417f, -0.02617131f, -0.02498909f, -0.05580017f, -0.13394181f, 
    -0.00943790f, 0.05477934f, -0.03077106f, -0.10924855f, 0.07624312f, 0.01169416f, 0.08082861f, 0.02866364f, 
    -0.19680746f, -0.18237469f, -0.00543920f, 0.04721545f, 0.03882449f, -0.07488041f, -0.09510475f, 0.00621980f, 
    0.11134105f, 0.06977564f, -0.02527205f, 0.01939867f, -0.02499173f, -0.27277276f, 0.07801794f, -0.10731077f, 
    0.12290977f, 0.07934540f, 0.04767501f, -0.12053418f, 0.09855749f, -0.00804076f, -0.01351380f, 0.06661570f, 
    -0.02432722f, -0.04031835f, -0.07571892f, -0.05752859f, -0.04361777f, 0.06425786f, -0.03612049f, 0.01879144f, 
    0.03310972f, -0.01778683f, -0.00001022f, -0.07197258f, -0.04883958f, -0.01039577f, 0.03720494f, -0.00695805f, 
    -0.00404011f, 0.01852421f, -0.03495321f, -0.05178102f, -0.02354401f, -0.00293646f, 0.05649177f, 0.00394119f, 
    0.05203472f, 0.04338076f, 0.06076295f, 0.05811233f, 0.00364246f, 0.03714807f, -0.06250317f, -0.00920177f, 
    -0.04403826f, -0.07142431f, -0.07469186f, -0.04026016f, -0.00213094f, 0.05451381f, -0.03925335f, -0.01315279f, 
    0.01975076f, 0.03477674f, 0.00704482f, -0.02063971f, -0.07702056f, 0.04284643f, 0.01128432f, 0.01289204f, 
    -0.04874619f, 0.04730662f, 0.01547490f, -0.01486467f, 0.00796829f, 0.03520053f, 0.01969821f, -0.02059906f, 
    -0.05845682f, -0.06222429f, -0.01064653f, 0.03466278f, -0.06192213f, -0.01132159f, -0.00121448f, -0.07605389f, 
    0.04761260f, 0.00644322f, 0.00669056f, 0.04728534f, -0.03890631f, 0.02058643f, 0.01304250f, -0.00462080f, 
    -0.07057765f, -0.05214567f, -0.07811277f, 0.02156972f, 0.04157332f, -0.04796823f, 0.00056999f, 0.00840236f, 
    -0.02832648f, -0.07538595f, -0.02658677f, 0.01280652f, 0.01956010f, 0.00035491f, -0.02571054f, 0.00006149f, 
    -0.03757377f, 0.00857506f, -0.00842871f, 0.02245096f, 0.01460411f, 0.02634182f, -0.06872308f, -0.00710861f, 
    -0.01002062f, 0.01837094f, -0.00284338f, 0.01380117f, -0.01984344f, -0.04404742f, 0.04557912f, -0.04759542f, 
    0.03429895f, 0.02527129f, -0.06315768f, 0.02473951f, 0.00051888f, 0.06360196f, -0.02901147f, 0.01318098f, 
    -0.06268642f, -0.04138171f, 0.00044816f, -0.03524571f, 0.00662630f, 0.03737187f, 0.04505842f, -0.05433770f, 
    -0.01028864f, 0.03397188f, 0.06185585f, -0.07562730f, 0.07584904f, 0.00408906f, 0.01841762f, -0.03098349f, 
    -0.04431340f, 0.06195407f, 0.01536542f, -0.05182593f, -0.03620197f, -0.06460751f, -0.07097651f, -0.06825832f, 
    -0.02478255f, 0.04660198f, -0.06469940f, 0.05764683f, 0.03496917f, -0.02290550f, 0.01336682f, -0.07159682f, 
    -0.06523131f, -0.07392890f, -0.01710801f, -0.00015903f, 0.05417008f, 0.03450540f, -0.03732900f, 0.05406551f, 
    0.00352379f, -0.04384739f, -0.03101013f, -0.03606371f, 0.02545340f, -0.03795726f, 0.00887372f, 0.06341828f, 
    -0.03169530f, -0.06285460f, -0.03821444f, -0.07288365f, 0.01315344f, 0.00847958f, -0.03191707f, -0.03746931f, 
    0.00010239f, 0.06565012f, 0.03128617f, -0.01317049f, -0.00651282f, -0.01283409f, -0.03559371f, 0.00208491f, 
    -0.06621316f, -0.06579155f, -0.04837447f, -0.05660107f, 0.03303697f, -0.05326828f, -0.03723553f, 0.06490102f, 
    -0.00804681f, -0.01809427f, 0.04874704f, -0.02548406f, 0.01105546f, 0.02158454f, 0.01368661f, 0.01076762f, 
    0.39577508f, -0.25050911f, -0.12602831f, 0.07335284f, -0.01014866f, -0.05167364f, 0.03209884f, 0.01962378f, 
    0.02462393f, 0.15730180f, -0.02402952f, 0.09730789f, -0.25618857f, 0.06729823f, -0.09313124f, 0.04128804f, 
    0.12718865f, -0.02532149f, -0.05524629f, -0.06852427f, -0.00805653f, -0.01288512f, -0.03829356f, -0.09924793f, 
    0.30705380f, 0.08882539f, -0.18720745f, -0.21953310f, 0.26555744f, 0.01213853f, 0.07246852f, 0.02639696f, 
    0.04661301f, -0.03417979f, 0.03823933f, -0.01328226f, 0.04948410f, 0.10632689f, 0.14113644f, 0.11792661f, 
    0.03240400f, 0.08450350f, 0.19178659f, -0.15098891f, -0.02867633f, 0.10558386f, -0.09427139f, 0.11312918f, 
    -0.29461575f, -0.02347895f, -0.03798303f, -0.01533568f, 0.09677928f, 0.14593025f, -0.09457638f, 0.06746253f, 
    0.06454248f, 0.03561714f, 0.05678817f, -0.00283996f, 0.23169759f, -0.22348675f, -0.02332278f, -0.23881410f, 
    0.17631549f, 0.16804972f, 0.03689157f, 0.01996022f, 0.00904784f, -0.05494650f, -0.04760071f, -0.05130452f, 
    -0.34203404f, 0.02071975f, -0.20060188f, 0.09895013f, 0.08287819f, 0.03353795f, 0.06361400f, 0.01896848f, 
    0.09447554f, 0.01647535f, -0.18849646f, -0.00891367f, 0.08814172f, 0.10232700f, 0.05993789f, -0.02611921f, 
    -0.01944003f, 0.00653985f, 0.10684223f, 0.14062136f, 0.03654885f, 0.01360292f, -0.14968856f, 0.01739638f, 
    -0.16254109f, 0.11408444f, 0.29577628f, -0.28504109f, 0.01247894f, -0.03737740f, 0.05996497f, 0.03743881f, 
    -0.00040381f, 0.02421399f, 0.09802771f, 0.04897248f, -0.09975909f, -0.44415659f, 0.06978482f, 0.15491335f, 
    0.01038492f, 0.02501993f, -0.09288272f, -0.08747672f, 0.04578254f, 0.08197699f, -0.09136212f, -0.10580347f, 
    -0.37170944f, -0.24472849f, 0.16521069f, 0.06137495f, -0.35328102f, 0.03115694f, -0.04450946f, 0.11304923f, 
    0.04208664f, 0.00349563f, 0.17919739f, -0.01393733f, -0.18122455f, 0.12852606f, 0.02695202f, 0.09834992f, 
    -0.09139403f, -0.03403576f, -0.02684586f, 0.09931085f, 0.10380857f, 0.06364255f, -0.05723215f, 0.11680268f, 
    0.01028270f, 0.05964422f, 0.15070201f, 0.13939193f, -0.28405863f, -0.00921533f, -0.14325753f, 0.08355093f, 
    -0.04407654f, -0.02016178f, 0.05215427f, -0.01431631f, -0.09646586f, -0.33587408f, -0.19514284f, -0.00673906f, 
    0.03133523f, 0.06167105f, 0.03069663f, -0.02733803f, 0.06530157f, 0.05737397f, 0.09953915f, -0.11277081f, 
    0.10865721f, 0.11532261f, 0.17463529f, -0.03749102f, -0.18337457f, -0.09545968f, 0.01299467f, 0.15496740f, 
    0.16175380f, -0.01435859f, 0.03995979f, 0.17437211f, 0.02633693f, -0.04181015f, 0.12463136f, -0.22708851f, 
    0.05042901f, 0.11215332f, 0.13525955f, -0.09514977f, -0.05956988f, 0.01089775f, 0.07724106f, 0.04377046f, 
    -0.27396205f, -0.09319124f, -0.19645317f, -0.19383889f, -0.10314268f, 0.01433909f, 0.11558738f, 0.01446456f, 
    -0.03433998f, 0.03442259f, -0.05784624f, 0.14661603f, 0.00828096f, -0.05350680f, 0.12876755f, -0.15278168f, 
    0.10585403f, -0.00928649f, -0.16915056f, -0.00358529f, 0.04029744f, -0.16943647f, -0.01354840f, 0.03319320f, 
    0.06667607f, 0.03752912f, 0.07744239f, 0.05024358f, 0.16984254f, 0.07269751f, 0.16494149f, 0.21361196f, 
    -0.14687119f, -0.08095109f, 0.09687158f, 0.05330677f, 0.05074894f, -0.03964812f, 0.14986332f, 0.19560194f, 
    -0.01956273f, -0.12337416f, 0.16695637f, 0.09963807f, -0.16869247f, 0.07202370f, -0.09344102f, 0.09127196f, 
    -0.01084232f, 0.05374844f, -0.06111900f, -0.18754473f, 0.03575229f, 0.15855303f, -0.07815123f, -0.04617452f, 
    0.20666699f, 0.04168984f, 0.14701787f, -0.04689891f, 0.22633705f, 0.01895127f, 0.15719721f, -0.09085913f, 
    0.09337816f, 0.01280312f, -0.04516370f, -0.00902871f, 0.03205031f, -0.06305557f, 0.04886752f, 0.12686519f, 
    0.05974772f, -0.10310312f, 0.03421761f, -0.17786460f, 0.09555312f, -0.02512021f, 0.19683935f, 0.06059596f, 
    0.06242143f, 0.03398721f, 0.09211125f, 0.23058467f, -0.17715177f, 0.17414199f, -0.03779655f, -0.23661484f, 
    -0.02169232f, -0.07896465f, -0.20639484f, 0.04731042f, 0.17104682f, -0.03029175f, -0.25349668f, 0.13304815f, 
    -0.44400701f, -0.34700650f, 0.05555663f, 0.17370330f, 0.16341612f, -0.03938112f, 0.03317355f, 0.24461232f, 
    0.27041984f, 0.03602504f, 0.17458957f, -0.04558915f, 0.01602546f, -0.25281939f, -0.17560965f, 0.00759728f, 
    -0.06582619f, 0.02504495f, 0.01838828f, -0.08604276f, 0.09721461f, 0.01185909f, 0.16618259f, 0.12191138f, 
    -0.11335053f, -0.08925531f, -0.27772209f, -0.00982231f, -0.33391032f, 0.02456943f, 0.02121216f, -0.12857148f, 
    -0.04004697f, -0.06467045f, 0.11892517f, 0.11900509f, -0.30411899f, -0.19026828f, 0.05028258f, -0.03001082f, 
    -0.03541842f, -0.07898887f, 0.02980827f, -0.06690355f, -0.06256109f, 0.12314757f, -0.20392358f, -0.04451745f, 
    -0.26181749f, -0.20880945f, 0.03044957f, 0.27509189f, 0.00252765f, -0.13052204f, -0.12761211f, 0.05864388f, 
    -0.08523779f, 0.12797219f, -0.15373997f, -0.13033436f, -0.05286174f, -0.11823002f, -0.03203928f, 0.04498654f, 
    -0.09474293f, -0.00803777f, -0.01771099f, 0.23197919f, -0.03980709f, 0.02883734f, 0.18980917f, 0.16189216f, 
    -0.17207994f, 0.11035848f, 0.04933792f, 0.12872410f, -0.11223537f, -0.04021278f, -0.07811758f, 0.18789420f, 
    0.06833053f, -0.18419926f, 0.03432057f, -0.05910468f, -0.12485389f, -0.14136617f, 0.05798285f, 0.06982418f, 
    0.06332741f, 0.03015689f, 0.04004575f, 0.04613091f, -0.04833905f, -0.17316994f, 0.04518037f, 0.22505230f, 
    -0.46195817f, 0.12183490f, 0.06859783f, -0.04883295f, 0.07596745f, -0.06097311f, 0.10885593f, 0.11631147f, 
    -0.01534297f, -0.01465965f, -0.13318391f, 0.05069011f, 0.05543304f, 0.08086278f, -0.24859953f, 0.10999141f, 
    0.00571446f, -0.02141345f, 0.13116238f, 0.07939037f, -0.14693524f, 0.15478134f, 0.01383205f, -0.00382776f, 
    -0.02757756f, -0.01308096f, -0.00903891f, -0.04387546f, 0.03438220f, 0.02249188f, 0.02857216f, 0.13048896f, 
    0.04100011f, 0.00611783f, 0.03720393f, 0.04683797f, -0.02340980f, 0.11000689f, -0.04501433f, -0.06330354f, 
    0.06957578f, -0.09623276f, -0.00627569f, -0.11247599f, 0.06635875f, -0.05752994f, 0.06435321f, -0.07396617f, 
    0.03633140f, 0.17563187f, 0.18122438f, 0.11930592f, -0.01085474f, -0.00148982f, -0.02022916f, 0.03035318f, 
    0.06982437f, 0.03877577f, 0.06576895f, 0.01613861f, 0.01603652f, 0.01985293f, 0.08915696f, 0.14065763f, 
    0.03342605f, -0.13120790f, -0.02683611f, -0.01895998f, 0.02408597f, 0.11261441f, 0.04233987f, 0.02994385f, 
    0.00128025f, 0.18806082f, 0.01844860f, 0.05340583f, 0.05883739f, 0.00741187f, 0.13570790f, 0.01843604f, 
    0.11369516f, 0.03414613f, 0.02022056f, 0.01895824f, -0.38878348f, -0.03758477f, 0.12725288f, 0.11302732f, 
    0.02297180f, 0.07762745f, 0.05689001f, 0.01190641f, -0.01075215f, 0.02843319f, 0.08601401f, 0.14501175f, 
    0.00115691f, 0.23110932f, 0.12380130f, -0.13725084f, -0.01883735f, 0.09962891f, -0.02842270f, -0.07648651f, 
    0.10635703f, -0.06919760f, 0.01818429f, 0.15755922f, -0.41561413f, -0.04542634f, 0.09533767f, 0.10062370f, 
    0.09063424f, -0.07100265f, 0.05742688f, -0.02558928f, 0.03572088f, 0.06822053f, 0.13512024f, 0.05334582f, 
    -0.18427837f, -0.04390828f, 0.02865451f, 0.13624780f, -0.02579030f, 0.13917819f, 0.03276642f, 0.04941035f, 
    0.06504849f, 0.08250096f, 0.00842209f, -0.03361584f, -0.15603423f, 0.03828241f, -0.11265410f, -0.09316055f, 
    -0.01026807f, 0.08513857f, -0.04360519f, 0.12538394f, -0.02832982f, 0.03034890f, 0.16084984f, 0.08992442f, 
    -0.07572297f, 0.09200802f, -0.12979694f, -0.13861428f, 0.09061868f, 0.01583381f, 0.08464763f, 0.01250570f, 
    -0.02770407f, -0.15272303f, 0.04805711f, -0.02654248f, -0.28443086f, -0.03449708f, 0.05203509f, -0.05145389f, 
    -0.09813058f, -0.04686448f, -0.03446119f, 0.03828915f, 0.09586363f, -0.01869900f, 0.07952990f, 0.03687750f, 
    0.05934439f, -0.06282336f, -0.00834166f, 0.00781154f, 0.02559436f, 0.01987154f, -0.09716908f, -0.03438694f, 
    -0.03340150f, 0.02256812f, -0.06564843f, 0.08825429f, 0.33029684f, 0.09222498f, 0.16444182f, -0.10592103f, 
    -0.02254500f, 0.18149890f, -0.10649194f, -0.02850349f, 0.02050574f, 0.09475863f, 0.05345875f, -0.02078438f, 
    0.01166266f, -0.08648796f, -0.03916973f, -0.05501770f, 0.00797268f, 0.00261198f, 0.03209393f, 0.02989848f, 
    0.00844070f, -0.07021180f, -0.07371844f, 0.00499748f, -0.06835654f, -0.05224799f, -0.01723201f, 0.00467268f, 
    -0.00124567f, 0.01922765f, -0.08009596f, -0.01152888f, -0.03136562f, -0.02347218f, -0.01637394f, -0.00034438f, 
    -0.03092046f, 0.05006103f, -0.01505237f, -0.02216804f, -0.05425136f, -0.00107706f, -0.06247665f, -0.03457237f, 
    0.00561903f, -0.00134854f, -0.05822290f, 0.02289596f, -0.03679010f, -0.04437415f, -0.02743776f, 0.02956941f, 
    0.02509141f, 0.05646572f, 0.02207019f, -0.03230620f, -0.04147770f, -0.01012440f, 0.04462015f, 0.01598655f, 
    -0.04248401f, 0.05050861f, 0.01350414f, 0.04580765f, 0.05132227f, -0.05744144f, -0.01991833f, 0.05984146f, 
    -0.03026691f, -0.04304117f, -0.01504073f, 0.01539622f, 0.00634843f, 0.02050426f, 0.02064862f, -0.04509399f, 
    -0.07321519f, -0.01074529f, -0.01195703f, 0.04297587f, -0.06517171f, -0.08059302f, -0.02858168f, 0.01457284f, 
    -0.01514639f, 0.02179224f, -0.05472445f, -0.07419544f, 0.04469791f, -0.01055732f, -0.03358259f, -0.04169375f, 
    -0.07520552f, 0.00612045f, -0.03573137f, 0.04193004f, 0.06420705f, -0.06598181f, 0.01838495f, 0.04134570f, 
    -0.05829057f, 0.01360616f, 0.00388255f, 0.02910544f, -0.00646590f, -0.01138852f, 0.01316738f, 0.03915552f, 
    -0.05804280f, -0.07954381f, 0.05958752f, 0.02047693f, 0.05936124f, -0.01042967f, -0.02978069f, -0.04481564f, 
    0.02525396f, 0.03608353f, 0.03236740f, -0.07262387f, -0.03027429f, -0.02150511f, -0.05035378f, 0.01471324f, 
    0.00522524f, -0.06788182f, 0.03362100f, 0.02263709f, 0.04860611f, -0.05924069f, 0.00975027f, -0.03260595f, 
    0.01038278f, -0.05584243f, -0.04738463f, -0.07774702f, -0.01111784f, -0.07797489f, 0.02991784f, 0.02350648f, 
    0.01735868f, -0.02143583f, -0.06109615f, -0.03553367f, 0.05080209f, -0.04617825f, -0.00291558f, 0.05847251f, 
    -0.06635798f, -0.06590857f, 0.05086510f, -0.06594098f, 0.03047758f, 0.02038292f, -0.00763348f, 0.04219475f, 
    0.04938025f, -0.03948253f, 0.03138166f, -0.03351539f, -0.06618384f, 0.01848101f, 0.02985771f, 0.00688545f, 
    0.01428691f, -0.02867309f, -0.03369002f, -0.06778272f, -0.04136765f, 0.05792636f, -0.04010172f, 0.03252453f, 
    0.04401343f, -0.01282867f, 0.02615782f, 0.04598586f, -0.03150801f, 0.05011632f, -0.01958453f, 0.00219239f, 
    -0.06385666f, -0.06148070f, -0.04216237f, 0.01887210f, -0.07422281f, -0.00829615f, -0.08014590f, -0.05699927f, 
    -0.05370375f, -0.03314816f, 0.00990205f, 0.00450102f, 0.03329350f, -0.01940235f, -0.06555157f, -0.06611066f, 
    -0.01287961f, -0.04824087f, -0.05289087f, -0.04371892f, -0.00107791f, 0.02855825f, -0.01516378f, -0.04036329f, 
    0.03210538f, 0.00858955f, -0.00635431f, 0.03026171f, 0.03669284f, 0.01927229f, 0.01307913f, 0.01037043f, 
    0.03128680f, 0.04618767f, -0.01907942f, 0.05770173f, -0.03462024f, -0.03535177f, 0.03419819f, 0.03620325f, 
    -0.08001416f, 0.00131097f, -0.00735637f, 0.02815853f, -0.05712306f, -0.06726107f, 0.00252248f, -0.01091872f, 
    -0.03129581f, 0.03462992f, -0.05199821f, -0.01900356f, -0.06238972f, 0.00412788f, -0.02017458f, 0.00128298f, 
    -0.01258254f, -0.02316896f, 0.01710646f, -0.08209998f, -0.06549232f, 0.03550417f, 0.00350268f, -0.06945132f, 
    0.06551949f, -0.06923261f, -0.00308235f, 0.03613011f, 0.03625692f, -0.01034198f, -0.02442588f, -0.06883121f, 
    -0.01770997f, -0.04135275f, -0.03222927f, -0.07672537f, 0.04197451f, -0.00007130f, 0.05268437f, -0.00615719f, 
    -0.04776663f, 0.05478033f, 0.03193133f, -0.01018585f, 0.04399356f, 0.03547456f, -0.06202601f, 0.02328841f, 
    -0.03421265f, -0.08754384f, 0.05030524f, 0.04369625f, 0.02318776f, 0.01735811f, -0.05304999f, 0.03252447f, 
    0.05109841f, -0.06412777f, 0.00202303f, -0.07659515f, 0.01023722f, 0.04814850f, -0.04449609f, -0.04699764f, 
    0.03967130f, -0.05968521f, -0.06367692f, 0.02715217f, -0.04105529f, 0.04755988f, -0.04464867f, -0.05253166f, 
    -0.03037027f, -0.06651843f, -0.03969499f, -0.03569603f, 0.02481928f, 0.03231259f, -0.06792434f, 0.01670378f, 
    -0.05402175f, -0.04497730f, 0.01849917f, 0.03449203f, -0.03835180f, 0.00507660f, 0.01526768f, -0.02557814f, 
    -0.01533544f, -0.03004527f, -0.07719621f, 0.03633505f, 0.00245023f, 0.06229998f, -0.01611977f, -0.05806906f, 
    -0.04615024f, 0.06190097f, -0.00043912f, -0.01194318f, -0.06554668f, 0.05659325f, -0.02975351f, -0.01114568f, 
    0.01271017f, -0.03322452f, 0.00742809f, -0.05877702f, 0.01687682f, -0.08203644f, -0.07986277f, 0.00301192f, 
    0.03703629f, 0.03271119f, -0.02505985f, -0.07687874f, 0.02668002f, 0.02211504f, -0.02865323f, 0.02368504f, 
    -0.06034939f, 0.03662407f, -0.06017806f, -0.05558182f, -0.05751354f, -0.04543129f, 0.01650227f, 0.01381290f, 
    0.04848456f, -0.03650528f, 0.03598111f, 0.05254758f, -0.04111695f, 0.02202940f, -0.03992067f, -0.06873547f, 
    -0.07601530f, 0.04711005f, 0.04204437f, -0.05844416f, 0.03100193f, 0.01632532f, 0.07183156f, -0.05178982f, 
    -0.06169506f, 0.03527590f, -0.06811521f, -0.00162960f, -0.04994208f, -0.02624013f, -0.05183568f, 0.00940745f, 
    0.04560625f, -0.01392817f, 0.01121271f, 0.02595163f, 0.03397248f, 0.04966128f, -0.06588958f, -0.01291331f, 
    0.04612539f, -0.03694471f, -0.03754959f, -0.07799547f, -0.03846064f, 0.01974891f, -0.00221931f, 0.04410187f, 
    -0.02294624f, -0.02252069f, 0.03965468f, -0.00463380f, 0.00995884f, -0.06143518f, 0.02214198f, 0.04202214f, 
    -0.00672440f, 0.06466953f, 0.00763092f, -0.03519838f, -0.05917320f, -0.00778566f, 0.00355628f, -0.07386626f, 
    0.05127136f, 0.02995271f, -0.02573283f, -0.06071362f, 0.06627119f, 0.03835351f, -0.01984969f, -0.02555450f, 
    -0.03872977f, 0.03392571f, -0.02984198f, -0.03402126f, -0.00922756f, 0.06516124f, 0.02655984f, -0.00958168f, 
    0.05484829f, 0.01149519f, -0.03578883f, 0.02261314f, -0.03070318f, -0.00683596f, -0.05501326f, 0.05814625f, 
    -0.03959119f, 0.05271549f, 0.03369882f, -0.04983434f, -0.00828598f, -0.02025429f, -0.04514965f, -0.04328224f, 
    0.04342319f, -0.02390167f, -0.00893650f, 0.02384250f, -0.06398591f, -0.02420891f, -0.01279750f, -0.00274165f, 
    -0.06298792f, 0.03077328f, -0.01007687f, -0.04772101f, 0.02971235f, -0.05097666f, -0.02225835f, -0.04051497f, 
    -0.03605471f, -0.04194275f, 0.05773318f, 0.04668714f, -0.07045250f, -0.00758038f, -0.02097595f, -0.00499921f, 
    0.02560799f, -0.02062043f, -0.03509177f, -0.00936171f, -0.07153493f, 0.04143969f, 0.06140135f, 0.02816636f, 
    -0.03973856f, 0.05416757f, -0.00108246f, -0.01840505f, 0.00632439f, 0.02623577f, -0.05317217f, -0.04045238f, 
    0.04268813f, 0.00479055f, 0.02258663f, -0.04928404f, 0.01323693f, -0.05213126f, -0.06765439f, -0.06509536f, 
    -0.00658251f, -0.07319067f, 0.03129698f, 0.01902495f, -0.07120901f, 0.00105661f, -0.01776564f, 0.05890231f, 
    -0.04733516f, -0.02532486f, 0.04665819f, -0.05388151f, 0.04104893f, -0.02337542f, -0.03682444f, 0.05215819f, 
    0.03687675f, -0.00774160f, -0.04836738f, 0.00504848f, -0.01211060f, -0.03299544f, -0.04139580f, -0.03043463f, 
    0.00793789f, 0.02744291f, -0.02121193f, -0.01504934f, -0.00906198f, -0.04691734f, -0.04752645f, 0.00234127f, 
    0.05514625f, -0.04504489f, -0.06563894f, 0.01949697f, -0.00044821f, -0.05002041f, 0.02646128f, -0.04619266f, 
    -0.00433205f, -0.00787558f, 0.06498980f, -0.06604595f, 0.06043309f, 0.06138758f, 0.03743283f, 0.01005607f, 
    -0.04072919f, -0.02689614f, 0.05873659f, 0.05748417f, -0.05348355f, -0.06008473f, -0.00246886f, 0.02017679f, 
    0.03340155f, -0.07444791f, -0.06475887f, 0.01601519f, -0.06015703f, -0.01628662f, -0.01755039f, -0.04778336f, 
    0.02682874f, -0.05514205f, -0.02084744f, -0.06180554f, 0.04429575f, -0.04894954f, -0.06385347f, -0.01422983f, 
    -0.05959230f, 0.04822088f, 0.04645182f, -0.04165309f, -0.06131049f, -0.05152144f, -0.04496922f, 0.04123801f, 
    0.02127124f, -0.03641203f, 0.01236573f, 0.05692633f, -0.04655547f, -0.01875016f, -0.04881983f, 0.03622434f, 
    -0.06162912f, 0.05612959f, -0.02481888f, -0.05182956f, 0.05832211f, -0.01218236f, 0.02736355f, 0.06284162f, 
    -0.02985034f, -0.01366475f, -0.04453781f, -0.04594725f, 0.03148230f, -0.07668966f, 0.01109306f, -0.03997010f, 
    -0.00041889f, 0.04200852f, 0.06156037f, 0.02892422f, 0.04806235f, -0.00353537f, -0.06086813f, 0.02690583f, 
    0.03224523f, 0.05970501f, -0.00889271f, -0.06135923f, 0.03052665f, -0.01977317f, 0.01817430f, -0.05273685f, 
    -0.07170188f, 0.05360512f, -0.02694405f, -0.05745125f, -0.03639080f, -0.02359119f, -0.07215071f, 0.01745209f, 
    -0.02785911f, -0.04219539f, -0.01693339f, -0.04267510f, 0.03162990f, -0.05519349f, 0.06555250f, -0.06814200f, 
    -0.02209413f, -0.08122484f, 0.04502143f, -0.03946077f, -0.05883553f, 0.01007655f, 0.00692188f, -0.05043750f, 
    -0.04419669f, -0.00462398f, 0.02634171f, -0.01963701f, 0.02336033f, 0.04802923f, -0.04594612f, -0.06726349f, 
    0.02847622f, -0.07113481f, -0.00620545f, -0.07816180f, -0.02027223f, -0.01810263f, 0.02961752f, 0.04906936f, 
    0.04942634f, -0.03544841f, 0.05729352f, -0.04849019f, -0.01106408f, 0.01615638f, 0.05962426f, 0.05296586f, 
    -0.00682441f, -0.01641463f, 0.04158834f, 0.02650813f, 0.02790030f, -0.04432935f, 0.03484622f, 0.06167962f, 
    0.00094409f, 0.03162583f, 0.05190058f, 0.00078766f, -0.00904004f, 0.01766798f, 0.03786097f, -0.02056775f, 
    -0.05937971f, 0.04762546f, 0.06242602f, -0.04429739f, -0.04817439f, -0.05181271f, -0.05113027f, 0.03311790f, 
    -0.06746348f, 0.04080600f, -0.01919965f, 0.01596755f, 0.03597509f, 0.01443225f, -0.07379641f, 0.03637822f, 
    -0.03634647f, 0.05445192f, 0.05241596f, 0.02636570f, 0.06008082f, -0.07402466f, -0.04537861f, -0.07562622f, 
    0.05172655f, -0.05505525f, 0.03437238f, 0.05254065f, -0.01635600f, -0.05681898f, 0.04353008f, -0.06060872f, 
    -0.04293834f, 0.01030223f, -0.01631795f, -0.00813713f, 0.04947890f, 0.00579096f, -0.06773663f, 0.04579338f, 
    -0.01281137f, -0.02312417f, -0.06022394f, -0.03247594f, 0.06314795f, -0.04734055f, -0.01639358f, 0.03702011f, 
    -0.02047952f, 0.02956199f, -0.03850008f, -0.07091831f, -0.03186120f, -0.02336185f, 0.00746509f, 0.06179217f, 
    -0.03323673f, 0.03058164f, 0.03596558f, -0.07768977f, -0.01549644f, -0.03916958f, -0.06122424f, -0.06525872f, 
    -0.07643623f, 0.02593580f, -0.03556238f, 0.03210440f, -0.07190473f, 0.03078465f, 0.03355034f, -0.00996290f, 
    -0.03630505f, -0.04461874f, 0.04052428f, -0.03001084f, 0.01454326f, 0.03583085f, 0.06225189f, 0.00839152f, 
    0.00692758f, -0.01289259f, 0.03084360f, -0.06594165f, 0.00647499f, -0.04140754f, -0.05723285f, -0.06570622f, 
    -0.06072171f, 0.01733208f, -0.07176021f, -0.03414422f, -0.07767658f, 0.01094052f, -0.02120492f, -0.02342706f, 
    -0.02619681f, 0.00777891f, 0.03550583f, -0.04115997f, 0.01424106f, 0.00029142f, -0.06880688f, -0.01539197f, 
    -0.04995748f, -0.06214911f, 0.03397459f, -0.07631457f, -0.01648971f, -0.04586462f, -0.02495136f, 0.02022441f, 
    0.09450030f, 0.04561107f, -0.02757936f, -0.13481596f, -0.02194821f, -0.03939775f, 0.09738965f, -0.03832203f, 
    0.00184609f, 0.01357565f, 0.02007820f, -0.09881023f, -0.22646464f, -0.10139986f, -0.10222469f, 0.00092798f, 
    0.11116400f, 0.12128955f, 0.13497549f, 0.05562591f, -0.02934369f, 0.19784400f, 0.02951726f, 0.15569820f, 
    -0.06395809f, 0.05019106f, 0.16693524f, 0.03738071f, -0.04672690f, -0.00975078f, -0.00380079f, 0.07802255f, 
    0.13413000f, -0.03477057f, -0.09130720f, 0.06288368f, 0.00892382f, 0.00566748f, 0.04725126f, 0.05460913f, 
    0.07612596f, -0.08797862f, 0.15453321f, -0.07666779f, -0.01983023f, -0.13542728f, 0.03681460f, -0.15037525f, 
    0.11265142f, 0.36872289f, 0.05809134f, 0.04963866f, -0.15001944f, 0.08727337f, 0.08627214f, 0.03647717f, 
    -0.04406216f, -0.01315783f, 0.02419473f, 0.09403770f, 0.13725993f, -0.00709715f, 0.11096581f, -0.04414604f, 
    0.04726883f, -0.08114111f, 0.00949940f, 0.13621882f, -0.13609140f, -0.01184146f, 0.07239975f, -0.01107347f, 
    -0.02368672f, 0.19687288f, -0.08455862f, -0.18814152f, 0.06494496f, 0.02196013f, -0.00138098f, 0.01226990f, 
    -0.01237963f, -0.02668400f, -0.24686261f, -0.07687624f, -0.32621762f, 0.00257346f, 0.01093460f, -0.01511803f, 
    0.02373822f, 0.06716223f, 0.16164042f, 0.02318645f, 0.06796269f, 0.03571443f, 0.24718121f, 0.11878977f, 
    0.03450656f, 0.02736030f, 0.24435124f, 0.11498956f, -0.04055749f, -0.00264326f, -0.05434244f, 0.05783313f, 
    -0.07962875f, 0.03578738f, -0.04037560f, 0.11684743f, -0.18443501f, -0.02001931f, -0.00458332f, 0.13768557f, 
    -0.02019365f, -0.01094295f, 0.06678934f, 0.01883222f, 0.04758839f, 0.05016948f, 0.02781384f, -0.08969842f, 
    -0.07442672f, -0.08315026f, -0.04401218f, 0.02486704f, -0.01682182f, 0.06766734f, 0.14570107f, -0.09020203f, 
    0.04678165f, 0.10861169f, -0.10325653f, 0.01774413f, 0.08993593f, 0.14311008f, -0.07559113f, 0.17434172f, 
    -0.04356513f, -0.12195046f, 0.09565637f, -0.02822455f, 0.08810192f, 0.06079868f, 0.06367050f, 0.19331910f, 
    0.25053239f, 0.06954081f, -0.14158681f, -0.06852403f, 0.12537441f, 0.08765054f, -0.02961590f, 0.03983717f, 
    -0.05020621f, -0.07996635f, -0.00670199f, -0.22148921f, -0.00574651f, -0.14545350f, -0.02746873f, -0.06880093f, 
    -0.01458701f, -0.00346128f, 0.00643970f, -0.04315147f, 0.05552807f, -0.03137001f, -0.00953557f, -0.13174731f, 
    -0.15909657f, -0.04645335f, 0.18189117f, -0.02821367f, 0.01903442f, 0.03276130f, 0.01638938f, -0.05078311f, 
    -0.01054017f, 0.12311752f, -0.05402998f, 0.08932224f, 0.20084307f, 0.06045816f, 0.23578677f, 0.14824346f, 
    -0.00515629f, -0.01838271f, -0.05269765f, 0.03531227f, 0.05673482f, -0.02359906f, 0.01309055f, -0.13393885f, 
    -0.00519820f, 0.31375912f, -0.07829341f, -0.14545701f, -0.00748139f, -0.08234524f, 0.03030603f, 0.01497042f, 
    -0.13605708f, 0.05101583f, 0.02140421f, -0.01122897f, -0.21798830f, 0.10518801f, 0.17462024f, -0.16821362f, 
    0.11772288f, -0.10863502f, -0.06480952f, -0.09701630f, -0.07325641f, -0.07438242f, -0.02987482f, -0.09398110f, 
    0.13611056f, -0.08471106f, 0.13968885f, -0.15525123f, 0.05905318f, 0.05210311f, -0.00298232f, 0.20069419f, 
    -0.11537044f, -0.04612558f, 0.04295859f, 0.08516835f, -0.01634244f, 0.15956376f, 0.05439191f, 0.03868687f, 
    0.11640804f, -0.04325335f, -0.03727569f, -0.04279850f, -0.05196025f, -0.13994879f, -0.06509504f, 0.10072164f, 
    0.19755006f, 0.05894394f, -0.19778442f, -0.10363240f, 0.02893287f, 0.00200811f, -0.12669614f, 0.03339635f, 
    0.06517020f, 0.01857281f, 0.03254631f, -0.13582927f, 0.27337140f, -0.07791358f, 0.02120821f, -0.03672910f, 
    0.18011175f, -0.01969392f, 0.02353034f, 0.05597308f, 0.06124802f, 0.03042893f, 0.01168413f, -0.05696482f, 
    -0.21137272f, 0.02184925f, 0.04913839f, -0.02505736f, 0.01156389f, 0.03080976f, -0.01912905f, 0.02099884f, 
    -0.06820202f, -0.04321911f, 0.00074840f, 0.02646728f, -0.18300630f, 0.12026581f, -0.02515093f, 0.21530861f, 
    0.02349683f, 0.02278733f, -0.00420250f, 0.11341915f, -0.07149003f, 0.11426051f, -0.06246791f, -0.02974819f, 
    0.04018755f, -0.03138896f, -0.04291039f, 0.30049163f, 0.03320437f, -0.08793702f, -0.01529336f, -0.10775213f, 
    -0.04345317f, 0.08651024f, 0.08588649f, -0.09238435f, 0.05289964f, -0.08650268f, 0.06522113f, -0.06975721f, 
    -0.00871926f, -0.03859031f, 0.11715239f, -0.03564018f, -0.03448626f, -0.00073325f, 0.12375246f, -0.04425165f, 
    -0.04082854f, 0.12157835f, 0.03598353f, 0.14163107f, 0.07307723f, 0.20995466f, -0.11493882f, -0.05878054f, 
    0.05315979f, 0.05060586f, 0.15067701f, -0.06477115f, 0.21996808f, 0.05128533f, 0.09197637f, 0.30172446f, 
    0.13579069f, 0.12620577f, -0.08794068f, 0.05693960f, 0.02001728f, -0.01141315f, -0.00253142f, -0.09298778f, 
    -0.20709044f, 0.15691704f, 0.03965734f, 0.09706274f, 0.00727777f, -0.08456600f, -0.02242965f, -0.07276289f, 
    0.04293044f, 0.14101574f, -0.01388522f, -0.00563257f, 0.24485408f, -0.22718804f, 0.12860966f, 0.17872466f, 
    -0.00018089f, -0.10386638f, 0.07497273f, -0.06208741f, -0.03172174f, -0.02341233f, 0.13645692f, 0.11172800f, 
    -0.23751499f, 0.14792384f, 0.05978561f, 0.09038731f, -0.00621810f, 0.09460672f, 0.06684241f, -0.06053728f, 
    0.05604342f, -0.05816344f, 0.02833143f, -0.14720917f, 0.11619478f, -0.02037607f, 0.13575406f, -0.01394187f, 
    -0.12179764f, 0.00358567f, 0.06190897f, -0.03094617f, -0.07292920f, 0.01741769f, 0.17337166f, -0.09321646f, 
    -0.17627706f, 0.12607765f, -0.07756198f, -0.00910840f, 0.14174004f, -0.07539710f, 0.05929202f, 0.04060521f, 
    0.01644265f, -0.10797762f, 0.10357431f, -0.02930043f, 0.24168234f, 0.05652093f, 0.15602584f, -0.18417346f, 
    -0.00077130f, 0.09459326f, -0.01980829f, -0.03770446f, -0.00922123f, -0.04264231f, 0.05817695f, 0.05686761f, 
    0.02367335f, -0.07630134f, 0.05094842f, 0.06819747f, 0.17186126f, 0.13825560f, 0.01594243f, 0.02456612f, 
    0.05719066f, -0.02098938f, 0.05353437f, -0.07330705f, 0.20242944f, -0.06239802f, -0.04761992f, 0.04980968f, 
    0.12323594f, 0.07239084f, -0.03927781f, 0.13204204f, 0.07320619f, 0.07990964f, -0.00561483f, 0.04993441f, 
    -0.16882160f, 0.14896008f, 0.14805354f, -0.18258929f, -0.13244195f, -0.13832386f, -0.07058384f, -0.00238656f, 
    0.02829999f, 0.03343031f, 0.06744751f, -0.01847675f, 0.00641945f, 0.07201289f, 0.13627671f, -0.09603503f, 
    0.01140978f, 0.12466985f, -0.00560010f, 0.06416325f, 0.01359914f, -0.02807400f, -0.08269496f, 0.00438967f, 
    0.16047212f, 0.13979763f, 0.13563773f, -0.19150911f, 0.07741022f, -0.07394129f, 0.01757360f, -0.00669787f, 
    0.01012107f, -0.07637997f, 0.14600000f, -0.00816734f, 0.05040242f, -0.06690148f, -0.29223418f, -0.12123992f, 
    0.04259835f, 0.12409299f, -0.00361672f, -0.05966111f, 0.10337016f, -0.05539630f, -0.06693026f, 0.04672505f, 
    0.02109843f, -0.13719524f, 0.01536598f, 0.26888621f, 0.11064124f, 0.01063507f, 0.10799737f, 0.18828602f, 
    -0.04098320f, 0.01149158f, 0.17268997f, -0.02573694f, 0.17457440f, 0.02970192f, -0.13793449f, -0.03572007f, 
    -0.09330301f, 0.08660138f, 0.00528162f, 0.00581540f, 0.10752727f, -0.02253616f, 0.08769887f, 0.00530414f, 
    -0.26318845f, -0.05564019f, -0.10994884f, -0.08678930f, 0.11354970f, 0.05416948f, 0.11958870f, -0.06889459f, 
    -0.03380961f, 0.03395426f, 0.11835007f, 0.03865793f, 0.01450034f, -0.18859147f, -0.02798210f, -0.00417084f, 
    0.07354882f, 0.04152754f, -0.06991091f, -0.04614643f, 0.07342730f, -0.00817950f, -0.06348040f, 0.01329459f, 
    -0.00946066f, -0.12972443f, -0.04279105f, -0.03621162f, 0.13940640f, -0.01916466f, 0.09915676f, -0.01561864f, 
    0.07341792f, 0.21320331f, -0.10141356f, 0.11304250f, 0.25488690f, 0.24546747f, 0.01527472f, 0.03541666f, 
    -0.11495982f, 0.03515511f, 0.08721203f, 0.15539318f, -0.01803148f, -0.01241421f, -0.00051613f, 0.23867400f, 
    -0.45876753f, -0.26922789f, -0.13388580f, -0.06027265f, 0.11330095f, 0.04630622f, 0.05227741f, -0.08471002f, 
    0.04754964f, 0.00292122f, -0.06346533f, -0.06518166f, -0.19162840f, 0.06383482f, 0.17106439f, 0.31728292f, 
    -0.01424550f, -0.01223753f, 0.14737403f, -0.01005413f, -0.10610317f, 0.02582548f, -0.02356214f, -0.02063837f, 
    0.25518695f, -0.02684507f, 0.05796113f, 0.13508187f, -0.14831409f, 0.17011474f, -0.04957542f, -0.15847382f, 
    -0.02565113f, 0.04250235f, 0.09184744f, -0.10634174f, -0.35573134f, -0.00744821f, 0.15675011f, 0.04246614f, 
    0.08519216f, 0.03301414f, -0.04548468f, -0.03727235f, 0.01487385f, 0.00515486f, -0.01311851f, -0.05740030f, 
    -0.04380138f, 0.08014356f, -0.02147107f, -0.09015927f, -0.06364313f, -0.08407512f, 0.10260359f, 0.01443423f, 
    -0.05894623f, -0.08997751f, -0.02275910f, 0.01245472f, -0.21360813f, -0.07890869f, 0.18501040f, 0.07424724f, 
    -0.10265895f, 0.00069279f, 0.06253517f, -0.13972710f, -0.02377234f, -0.03317169f, -0.01177497f, -0.01104431f, 
    0.55387712f, -0.20763867f, -0.01737453f, -0.00760610f, 0.03450124f, 0.05741499f, 0.04149402f, -0.07183059f, 
    0.00683780f, -0.05024743f, 0.02061513f, -0.01382014f, 0.12119414f, 0.09495600f, -0.07357509f, -0.02263209f, 
    0.02074896f, 0.01583772f, 0.08249122f, -0.10375509f, -0.05854614f, 0.03226695f, 0.07833066f, -0.00573401f, 
    0.02632270f, -0.00397388f, 0.11656205f, 0.35483938f, -0.00197553f, 0.00380938f, -0.05143873f, -0.04140227f, 
    -0.04956618f, 0.04284717f, -0.17654616f, 0.15536046f, 0.10559657f, 0.20775971f, -0.01457453f, 0.06782584f, 
    -0.06685289f, -0.07453903f, 0.13695481f, 0.10325930f, -0.08754703f, 0.04081925f, 0.10672422f, -0.07553779f, 
    -0.03704548f, -0.04327418f, 0.04187071f, -0.09890924f, -0.10729656f, -0.03899210f, 0.11616830f, 0.02216396f, 
    0.03967958f, 0.04460349f, 0.00335725f, 0.01394270f, 0.07616180f, 0.02533973f, 0.10947629f, 0.02209765f, 
    0.04507181f, -0.00463235f, -0.17861290f, 0.04430739f, -0.00106805f, -0.05995835f, -0.07752289f, -0.06873866f, 
    0.39328864f, 0.04005961f, 0.05451062f, 0.04298561f, -0.00421482f, 0.01555176f, -0.04422542f, 0.06176755f, 
    0.04139224f, -0.05285030f, 0.00718669f, 0.03752843f, 0.10971200f, 0.17682488f, 0.02700028f, 0.19405572f, 
    -0.02883363f, -0.02904323f, 0.12779564f, -0.13292541f, -0.17059857f, -0.08988856f, 0.03464004f, 0.08398381f, 
    0.18836096f, -0.02041638f, -0.01576461f, 0.04530809f, -0.05544411f, 0.04543660f, 0.00715954f, -0.02835528f, 
    -0.15441407f, -0.17650557f, 0.17003311f, -0.00197493f, -0.09163186f, 0.10579199f, 0.06080950f, 0.13620415f, 
    0.17015290f, 0.08958285f, -0.00040641f, -0.05185479f, -0.08717827f, 0.08369185f, 0.02955736f, -0.00096431f, 
    0.16775249f, 0.11198771f, -0.03535549f, -0.12400611f, -0.01216638f, -0.01881293f, 0.04883672f, 0.06308456f, 
    -0.10836911f, -0.02508240f, -0.03396504f, -0.05235219f, 0.06289773f, 0.30305132f, -0.17751214f, -0.14417693f, 
    -0.04678274f, -0.19793385f, 0.09044161f, 0.10863833f, -0.11468684f, -0.17966485f, 0.00958882f, 0.00035179f, 
    -0.04681137f, -0.16393775f, 0.20056115f, 0.02908695f, 0.04513235f, -0.16847080f, 0.11056046f, -0.08952662f, 
    -0.33000317f, 0.09317901f, 0.09831284f, 0.07171507f, 0.14615126f, -0.14717717f, -0.25338489f, -0.11220130f, 
    -0.20294847f, 0.02400767f, 0.03985843f, 0.04006255f, 0.01631672f, 0.03117417f, 0.19699718f, 0.04961436f, 
    -0.05146308f, -0.12149366f, -0.14492799f, 0.01436954f, -0.09068000f, -0.05192707f, -0.07463174f, 0.07394911f, 
    -0.16416654f, 0.09958517f, -0.12689097f, 0.04770648f, 0.22838578f, -0.07299350f, 0.09134746f, -0.06140557f, 
    0.13708448f, -0.00115173f, -0.15585610f, -0.03650413f, -0.17060766f, -0.11533761f, 0.00982346f, -0.19676149f, 
    -0.22647336f, 0.06341960f, -0.19122456f, -0.17294946f, -0.14673735f, -0.01515553f, -0.01437939f, -0.13008015f, 
    0.11643471f, -0.10973702f, -0.00605179f, 0.11324114f, -0.23921345f, -0.40118271f, -0.13202284f, -0.20606884f, 
    -0.07027379f, 0.05227327f, -0.07270969f, 0.00853634f, -0.06921206f, 0.05233748f, 0.21137691f, -0.03625579f, 
    -0.08494350f, -0.11359251f, -0.03021775f, -0.12889948f, 0.03693561f, -0.07517984f, 0.00586158f, -0.00977010f, 
    -0.08788912f, -0.07741750f, 0.00298902f, -0.24513416f, 0.12064242f, 0.14714500f, 0.27166435f, 0.14652371f, 
    0.04287062f, -0.14650670f, 0.05457011f, 0.16407293f, 0.05234484f, 0.01448515f, -0.17006911f, 0.12364041f, 
    0.13451597f, -0.14412712f, -0.10162342f, 0.17977600f, -0.04303269f, 0.16271269f, -0.27584541f, 0.07578563f, 
    0.08482592f, 0.07360238f, -0.09386180f, -0.09898217f, -0.07394755f, 0.26748437f, 0.09631147f, 0.05379751f, 
    0.01906309f, 0.10315900f, 0.03827153f, 0.06646483f, 0.02000340f, 0.10513838f, 0.10341615f, 0.02394218f, 
    0.42163685f, 0.31179601f, 0.24561660f, 0.02875710f, 0.07675609f, -0.01988121f, 0.30327690f, -0.07341988f, 
    -0.14264223f, -0.14602481f, 0.01236146f, 0.05262246f, 0.28415206f, 0.09413226f, 0.35420609f, 0.25972721f, 
    0.01065774f, 0.01948430f, -0.04287206f, -0.07701252f, -0.05231285f, 0.10914200f, -0.14899513f, 0.25015724f, 
    0.59165281f, 0.07845501f, 0.15837952f, 0.42415404f, 0.04541698f, 0.09521036f, 0.13618058f, -0.03256995f, 
    -0.12333956f, 0.02221425f, -0.00499588f, -0.02660451f, -0.19825801f, -0.00411403f, 0.04941613f, -0.05249675f, 
    0.05567029f, 0.09801332f, -0.05765575f, 0.15043037f, -0.06779221f, -0.08078215f, 0.00288024f, 0.06225214f, 
    -0.26723769f, 0.20459670f, 0.16576813f, 0.24381411f, -0.00046418f, -0.12079239f, -0.02899356f, 0.16046356f, 
    -0.00985352f, -0.05118237f, 0.06299611f, 0.17708980f, 0.07431880f, -0.16495787f, 0.09770445f, 0.04870772f, 
    0.14489312f, -0.12081451f, 0.00395638f, -0.01844417f, 0.02713535f, -0.09242512f, -0.10438974f, 0.03343663f, 
    0.14309692f, 0.00327852f, -0.00547790f, -0.20665278f, 0.03993909f, 0.02187040f, -0.02747019f, -0.02979571f, 
    -0.02087200f, 0.02797317f, 0.06378032f, -0.02088972f, 0.07444157f, -0.14122711f, -0.05195407f, 0.03605699f, 
    0.10141465f, 0.03002811f, 0.04611642f, 0.00620832f, -0.00803920f, 0.00024788f, 0.04327761f, 0.15693164f, 
    0.16573077f, -0.02953338f, -0.02325346f, -0.06215369f, -0.11840126f, 0.02985898f, -0.00283297f, 0.02941994f, 
    -0.01988038f, 0.09300324f, 0.01841211f, -0.08144493f, -0.09761494f, 0.15904848f, -0.05631458f, 0.00581801f, 
    0.01975040f, -0.00954333f, -0.06427583f, -0.08605166f, -0.13198742f, -0.15588681f, 0.03284855f, -0.14103845f, 
    0.13119349f, 0.11015584f, 0.06638733f, 0.22172764f, 0.08706222f, 0.05403537f, 0.11203106f, 0.12511759f, 
    -0.04355730f, 0.01382560f, 0.02316356f, 0.03357283f, 0.32511723f, 0.23373406f, -0.00812115f, 0.15454121f, 
    0.12298311f, -0.01579254f, 0.05899504f, 0.08214068f, -0.01535409f, 0.03520610f, 0.11678397f, -0.03025792f, 
    -0.22277476f, 0.19032146f, 0.09967390f, -0.13183744f, -0.06070923f, 0.13804047f, -0.04156049f, 0.07256941f, 
    -0.00075626f, 0.08903544f, -0.00387492f, -0.09989405f, -0.21471314f, -0.11688661f, 0.17042892f, 0.35303125f, 
    -0.04874410f, 0.00333808f, 0.15415275f, 0.02854867f, 0.04784577f, 0.07898796f, 0.18790887f, 0.01369665f, 
    0.06351744f, -0.01643127f, -0.11633470f, -0.08965511f, -0.01749952f, 0.08078612f, -0.07255948f, -0.14070415f, 
    0.06395394f, 0.01939121f, -0.13298999f, -0.03839968f, 0.03709759f, -0.11380593f, -0.14844286f, -0.05734636f, 
    0.08383358f, 0.18192290f, 0.07660720f, -0.00138614f, -0.01710409f, 0.01741018f, 0.05399957f, 0.03544315f, 
    0.04833328f, 0.07541810f, 0.14532043f, 0.15302780f, -0.05588423f, 0.00576687f, 0.01196793f, -0.00558601f, 
    0.08536433f, 0.10619263f, -0.19943309f, -0.06632993f, -0.28712228f, 0.05956331f, -0.25080785f, 0.08490665f, 
    0.02400064f, -0.14416823f, -0.10578062f, 0.01056810f, 0.12797962f, -0.02695390f, 0.09973733f, 0.14703037f, 
    -0.20320529f, 0.12011448f, 0.15627223f, 0.03444102f, -0.07954968f, -0.09512872f, -0.03284249f, 0.01800936f, 
    -0.02802252f, -0.09172904f, 0.03128973f, -0.01328746f, -0.08108800f, -0.07489084f, -0.14014596f, 0.00061080f, 
    -0.00006565f, -0.01461631f, 0.03279072f, -0.13380966f, 0.04360929f, -0.02460523f, -0.06168752f, -0.04820963f, 
    0.26739085f, -0.11969750f, 0.04681038f, 0.03257275f, 0.04414736f, 0.04843424f, -0.00327100f, 0.08164146f, 
    -0.02628781f, 0.04501346f, -0.01474193f, -0.03478203f, -0.02180056f, 0.00816219f, -0.00617026f, -0.05696226f, 
    0.03817002f, 0.07029169f, 0.04174510f, -0.06045601f, 0.05868501f, -0.03268282f, 0.07083033f, -0.07716309f, 
    0.04930959f, -0.01619312f, -0.03440976f, -0.05606893f, 0.03969806f, -0.03834804f, -0.00833722f, -0.03228129f, 
    -0.03362552f, 0.00421422f, 0.02386745f, 0.03908155f, -0.00191392f, 0.01504368f, -0.03110876f, 0.02760479f, 
    -0.00080209f, 0.03919517f, -0.07393160f, -0.00229900f, -0.01336146f, -0.05807155f, 0.02658390f, -0.05032999f, 
    -0.07214244f, 0.05752395f, 0.03796741f, 0.05441994f, -0.03118990f, 0.02792465f, -0.03502104f, -0.03958803f, 
    0.02567267f, -0.06122706f, -0.01481105f, -0.02143367f, 0.04755949f, -0.05947445f, -0.05024350f, 0.00988030f, 
    0.06233421f, -0.04151751f, -0.02874346f, 0.01528315f, 0.06054738f, -0.05691565f, 0.00905728f, -0.02499428f, 
    0.00776454f, -0.04216601f, 0.05818169f, -0.01048317f, 0.01447743f, -0.05133047f, -0.02891516f, 0.06228374f, 
    -0.03151306f, -0.00336712f, 0.03835445f, -0.08106717f, 0.05403318f, 0.03416047f, 0.00431494f, 0.01022512f, 
    -0.00150847f, -0.03081626f, 0.01538097f, -0.03422639f, 0.02647171f, -0.05902299f, -0.00395487f, -0.06741238f, 
    -0.00728446f, 0.01211852f, -0.00416105f, 0.06212472f, -0.07268882f, -0.04760896f, -0.06577449f, 0.01158901f, 
    -0.00360537f, -0.03118546f, -0.03108752f, -0.01167306f, -0.02252802f, 0.04603743f, 0.04858625f, -0.06113297f, 
    -0.02859934f, 0.01009464f, -0.07500900f, 0.00669988f, -0.04604907f, -0.00064594f, -0.00909525f, -0.02746144f, 
    -0.05661641f, -0.04945259f, 0.01843346f, 0.01600982f, 0.04870331f, 0.01090855f, -0.02445060f, -0.05866245f, 
    0.00175492f, 0.00649022f, 0.01020469f, -0.06602180f, -0.03888049f, -0.08099739f, -0.05798617f, -0.03474325f, 
    -0.05486967f, 0.00027318f, -0.06648058f, -0.05309869f, -0.07467192f, 0.05376437f, 0.01585628f, -0.00449982f, 
    0.03338251f, -0.06276896f, -0.05702851f, -0.00095297f, -0.01740593f, -0.01901013f, 0.01270049f, -0.07493775f, 
    0.03310807f, -0.06694873f, 0.06066733f, -0.05486809f, -0.02699965f, -0.07440981f, 0.02025388f, 0.03161563f, 
    -0.03454587f, -0.06992515f, -0.02199233f, -0.06820999f, -0.01501547f, 0.00615254f, 0.03394122f, -0.07196487f, 
    -0.00735083f, -0.03447780f, 0.05280339f, -0.07192028f, -0.04752771f, -0.00919015f, 0.01444002f, 0.01446385f, 
    0.02667630f, 0.01148561f, -0.05620703f, -0.05024758f, -0.00860323f, -0.00858222f, -0.07486326f, -0.00999689f, 
    0.04468082f, 0.05910254f, 0.03282174f, 0.05275020f, 0.00063333f, 0.00440488f, -0.05625225f, 0.04830818f, 
    -0.02667837f, -0.03174391f, 0.00965234f, -0.05048623f, 0.00277808f, -0.06851427f, -0.06222192f, 0.00858238f, 
    0.04501306f, -0.04569703f, -0.06562227f, 0.04023325f, -0.07415355f, -0.02596971f, 0.05030813f, 0.01177613f, 
    0.02776076f, 0.05578668f, -0.00686857f, 0.04160526f, 0.05621407f, -0.02945659f, 0.02256133f, -0.03153069f, 
    0.02967360f, 0.03818753f, -0.05074337f, -0.03271808f, 0.04718642f, 0.05116969f, -0.00678310f, 0.02599020f, 
    0.02736912f, 0.01718660f, -0.02200149f, -0.01773277f, 0.00957968f, -0.03356128f, 0.02710438f, -0.01657931f, 
    -0.04497039f, -0.00426113f, -0.00927340f, 0.05384844f, -0.04179423f, 0.00160883f, -0.02581493f, 0.01584149f, 
    -0.05290320f, -0.02658314f, -0.02888834f, 0.01248219f, -0.06980902f, 0.04785885f, -0.06409618f, 0.00464827f, 
    -0.04005119f, 0.03861228f, -0.05090125f, 0.06002800f, -0.03831219f, -0.03892814f, -0.06434648f, 0.01370432f, 
    -0.06101697f, -0.01706948f, -0.03536923f, -0.03276571f, -0.05942344f, 0.01553273f, -0.02971882f, 0.06135923f, 
    -0.07970386f, -0.05091844f, 0.05718312f, 0.04629768f, -0.05760268f, -0.04418071f, -0.02891366f, -0.04844299f, 
    0.01279254f, -0.05577505f, 0.02689080f, -0.07062632f, 0.05792398f, -0.03631333f, 0.00261626f, -0.01671085f, 
    0.02091530f, -0.03747054f, 0.03657638f, -0.03473312f, 0.04236911f, -0.05791019f, 0.03729182f, -0.02441152f, 
    -0.02927781f, -0.08324417f, 0.01014122f, 0.02968358f, 0.06085024f, -0.03661086f, 0.02244135f, 0.02637064f, 
    -0.02801014f, 0.02829916f, -0.02242346f, 0.01318756f, -0.01896647f, 0.01374518f, 0.06331570f, 0.04789004f, 
    -0.07145225f, -0.04410602f, -0.06949379f, -0.04813973f, -0.00517932f, 0.06202932f, 0.03224872f, -0.03411292f, 
    0.03149568f, -0.05852577f, -0.05853302f, -0.04061893f, -0.00709242f, 0.02077750f, -0.05850913f, 0.04358942f, 
    -0.04360596f, -0.03048194f, -0.05370170f, 0.05023474f, -0.00191880f, -0.06262247f, -0.02039358f, 0.06301109f, 
    0.04881518f, -0.00526166f, 0.02195513f, -0.07163402f, 0.01759739f, 0.00150816f, -0.07081900f, -0.02083519f, 
    0.01239679f, -0.05774117f, 0.05411999f, -0.04029810f, -0.02933368f, -0.03700951f, 0.04964351f, -0.04846700f, 
    -0.00284968f, 0.04002957f, 0.03374904f, -0.02187052f, -0.07091458f, -0.00802164f, -0.04207380f, -0.03864298f, 
    0.04203360f, -0.03903694f, -0.01885466f, 0.03332642f, 0.06140989f, 0.07858139f, -0.06199795f, -0.04600606f, 
    -0.01743262f, -0.02399083f, 0.00095279f, -0.04664186f, -0.07119071f, -0.06346887f, -0.02488660f, 0.06517244f, 
    -0.02784943f, -0.05084536f, -0.01942872f, 0.06065622f, -0.05991198f, -0.01257601f, -0.00193457f, 0.03723550f, 
    -0.06514925f, -0.02770354f, 0.01068335f, -0.01966729f, 0.00257059f, 0.02303928f, -0.07190407f, -0.02983642f, 
    -0.01494414f, 0.03154980f, -0.03705521f, 0.04867932f, -0.07289718f, -0.08381169f, -0.02668783f, 0.04916167f, 
    0.04814966f, 0.01607053f, -0.06435426f, 0.03105079f, 0.03833820f, -0.00165102f, -0.02524504f, 0.00768268f, 
    0.02553463f, -0.04794781f, 0.01405060f, -0.04621437f, 0.07217955f, -0.05110015f, 0.01736917f, -0.05889297f, 
    -0.22702047f, -0.03876290f, -0.20703046f, 0.24603999f, 0.02176501f, -0.03060251f, -0.04614408f, -0.00871586f, 
    0.05208622f, -0.07720584f, 0.14338881f, -0.02586646f, -0.20470773f, 0.23763801f, 0.05416763f, 0.15865454f, 
    0.09199126f, -0.01154439f, -0.10944968f, -0.04602575f, -0.07780380f, 0.00777917f, -0.01173535f, -0.01754043f, 
    0.17351885f, 0.07112190f, -0.00512473f, 0.01028237f, 0.05338825f, 0.13700663f, -0.10675814f, 0.08601054f, 
    -0.06648228f, -0.01870560f, 0.00654002f, 0.08524247f, 0.09129632f, 0.02212294f, -0.12819713f, 0.02171828f, 
    0.08161451f, 0.10493032f, 0.04064688f, -0.00949492f, -0.05165544f, 0.06750602f, -0.10328330f, -0.02588972f, 
    0.16149846f, 0.03612961f, 0.12142920f, -0.05650523f, 0.03042503f, -0.04132036f, -0.02437108f, 0.01137298f, 
    0.08083746f, 0.00349353f, 0.04083461f, -0.07914900f, 0.41631559f, 0.08075758f, -0.01055588f, 0.09528095f, 
    0.09815891f, 0.09534271f, 0.13555577f, -0.01198805f, 0.03680303f, -0.01099694f, -0.00308802f, 0.01881714f, 
    -0.13467796f, 0.04101096f, -0.01017605f, 0.17730744f, 0.02111591f, 0.00979273f, 0.01927352f, 0.02803167f, 
    -0.03463503f, 0.00969657f, 0.01261031f, 0.08761881f, 0.14209901f, 0.17629123f, -0.10428526f, 0.03197992f, 
    0.09731634f, -0.02807088f, -0.04283905f, 0.12600021f, -0.07651261f, 0.05354448f, -0.03417492f, 0.02331277f, 
    -0.10440890f, 0.17148900f, 0.17670286f, -0.21509658f, -0.08341521f, 0.06220439f, 0.14485243f, 0.08419856f, 
    0.06298801f, -0.00766709f, 0.13411839f, 0.08937176f, 0.02899185f, -0.08440106f, -0.12818991f, 0.02113537f, 
    -0.02662493f, 0.10659995f, 0.07979207f, 0.05085951f, 0.05801749f, 0.00537306f, 0.08164103f, -0.04183272f, 
    -0.10216074f, -0.20758152f, -0.18847582f, -0.01064121f, -0.01700938f, 0.07110487f, 0.05007171f, 0.08799767f, 
    -0.00322587f, -0.04070282f, 0.10285484f, 0.10840002f, -0.17623532f, -0.00286202f, -0.10649272f, -0.09743996f, 
    0.04007827f, 0.00923012f, -0.03164926f, 0.04410164f, 0.00995295f, 0.00050897f, 0.00848869f, 0.04508970f, 
    0.04688708f, -0.07901246f, 0.06080993f, -0.00117773f, 0.10758620f, 0.06977466f, -0.08342706f, 0.04868940f, 
    0.10489344f, 0.07772039f, 0.02065814f, 0.12703352f, 0.14214070f, 0.15614678f, -0.28361815f, -0.13317341f, 
    0.02321267f, -0.00538179f, -0.03568329f, 0.03086185f, -0.03333182f, 0.01386698f, 0.11717325f, 0.15662825f, 
    0.05386192f, -0.22148223f, -0.08535025f, -0.04832067f, 0.07101797f, -0.06382062f, 0.04383320f, 0.03408315f, 
    0.04794647f, 0.02647018f, -0.04212651f, 0.02739687f, 0.27429509f, 0.13792454f, 0.18626095f, -0.05498666f, 
    -0.03317861f, -0.05745621f, 0.09894262f, -0.02574523f, -0.03827678f, -0.05482625f, -0.02442345f, 0.02721385f, 
    -0.11801452f, -0.00089100f, -0.16676523f, -0.03334485f, -0.07264486f, 0.07096114f, -0.12034439f, 0.16693462f, 
    0.03727168f, -0.10875075f, -0.02880847f, -0.00636763f, 0.16271690f, 0.21536204f, 0.14204879f, 0.03559817f, 
    -0.11704940f, 0.01580639f, -0.10871593f, 0.02869330f, 0.13644275f, -0.06741728f, -0.04455043f, -0.00999600f, 
    -0.01451105f, 0.01795055f, -0.03381002f, -0.05455798f, 0.00110631f, 0.00254094f, 0.03392079f, 0.03746244f, 
    -0.17322174f, 0.05664045f, 0.08756478f, -0.01412854f, -0.07866337f, 0.00081272f, -0.03563603f, -0.13378596f, 
    -0.00410519f, 0.04691709f, -0.12257897f, -0.01710875f, 0.02401955f, 0.01612331f, 0.02721443f, 0.07274956f, 
    0.26310539f, -0.39959446f, 0.00041891f, -0.04102064f, 0.09048413f, -0.09795696f, -0.08690570f, -0.11758674f, 
    0.00031597f, 0.01033466f, -0.10210785f, -0.15089869f, -0.12101388f, 0.18524717f, 0.01999276f, 0.07037236f, 
    -0.01666633f, 0.08493719f, 0.12524442f, -0.03345405f, 0.14047647f, 0.03772351f, -0.04177409f, 0.01530540f, 
    0.08274540f, -0.15690273f, 0.08656592f, 0.29141265f, -0.03696854f, 0.01672195f, -0.03841551f, 0.03239796f, 
    -0.06015904f, -0.00417035f, 0.22009403f, 0.01134881f, 0.10231318f, 0.05566061f, 0.04435395f, 0.11699757f, 
    -0.02065465f, 0.04054216f, 0.01104234f, -0.07356739f, -0.00859751f, -0.00192207f, -0.15842360f, -0.03809961f, 
    -0.20297752f, 0.03310398f, -0.02107770f, -0.08957481f, 0.11065715f, 0.00720799f, 0.13354924f, -0.10509551f, 
    0.05362930f, 0.01857880f, 0.05022317f, -0.04988127f, 0.07150497f, -0.04157688f, 0.11460896f, -0.09029093f, 
    -0.00711673f, 0.05043587f, -0.09069866f, -0.02181478f, 0.01050746f, -0.05386540f, 0.00453030f, 0.09745359f, 
    0.07674611f, 0.15003240f, 0.16194478f, 0.23255451f, 0.10398821f, 0.04998244f, -0.12354875f, 0.20154181f, 
    0.00379351f, -0.02970807f, 0.10642107f, -0.01622390f, 0.07151446f, -0.16930060f, -0.04382484f, -0.05650457f, 
    0.08283971f, 0.21568611f, 0.07671835f, 0.15172492f, -0.03260857f, 0.07829215f, -0.07930503f, -0.07614599f, 
    -0.39116740f, 0.04697797f, 0.03052805f, 0.05017154f, -0.04019943f, -0.02280083f, 0.04446086f, -0.04910650f, 
    0.09547235f, 0.03217454f, 0.03963018f, 0.16834314f, 0.00920283f, 0.03377949f, 0.18120097f, 0.14373456f, 
    0.09208531f, 0.03594739f, 0.06754068f, 0.00115267f, -0.02009372f, 0.07760365f, 0.10176998f, 0.21540381f, 
    -0.00095554f, 0.16576430f, -0.05629149f, -0.03866084f, 0.05145492f, -0.02631496f, 0.02971667f, 0.06409416f, 
    -0.05178734f, -0.08526287f, 0.02795333f, -0.10091107f, -0.20290746f, -0.09677500f, -0.23607872f, -0.12453232f, 
    0.01576276f, -0.01890250f, 0.10676629f, -0.03007252f, 0.01056614f, 0.03461375f, 0.11866705f, 0.04759457f, 
    0.22204648f, -0.11564644f, -0.03117610f, 0.22213066f, -0.08476026f, 0.08687932f, -0.00073983f, -0.05415331f, 
    0.03267051f, 0.00204371f, 0.01399847f, -0.02274976f, -0.18286054f, -0.18145120f, 0.13450138f, -0.09267094f, 
    -0.04327029f, -0.10257378f, -0.07691533f, -0.11326100f, 0.02511630f, -0.05331484f, -0.01157439f, -0.05206521f, 
    -0.12965117f, -0.07561898f, 0.00436396f, 0.16361779f, 0.10526264f, -0.08491389f, 0.02335349f, -0.05399193f, 
    0.07196848f, 0.00846773f, 0.10856860f, -0.09243101f, 0.05693495f, -0.17863306f, 0.12592141f, 0.06522915f, 
    -0.12338287f, 0.08359215f, 0.14728805f, 0.16349456f, 0.19755395f, 0.05835468f, 0.01265470f, 0.22152904f, 
    -0.25694880f, -0.22596346f, -0.07928757f, -0.08860232f, 0.05875809f, -0.02240990f, 0.04589772f, 0.02364447f, 
    0.18184073f, 0.14640427f, 0.06875859f, 0.04823742f, -0.23954891f, -0.20729430f, -0.22289510f, -0.20909698f, 
    0.03620574f, 0.06974205f, -0.05164257f, -0.06409094f, 0.03283413f, -0.08173049f, 0.00653531f, -0.06936895f, 
    0.10517641f, -0.26468432f, -0.10761289f, 0.20453009f, 0.08955196f, -0.05647301f, 0.07977605f, -0.00150526f, 
    -0.02028597f, 0.11777020f, -0.00081000f, 0.15895294f, 0.31139481f, 0.29165879f, -0.07279655f, -0.25483739f, 
    -0.10734273f, 0.05000271f, 0.04908317f, 0.04674232f, 0.08735611f, 0.01406524f, -0.04575674f, -0.06351421f, 
    0.10890093f, 0.10903828f, 0.02574657f, 0.13133132f, 0.10484457f, -0.03567012f, 0.09791506f, 0.07851318f, 
    -0.13923635f, -0.01527230f, 0.07662474f, 0.02568475f, 0.38162035f, 0.05700564f, 0.00248015f, 0.06645345f, 
    -0.09197167f, -0.12432843f, 0.02959566f, 0.04973982f, 0.00764371f, -0.06350207f, -0.05892988f, 0.01132553f, 
    0.16578169f, 0.15188116f, -0.01145274f, -0.19110085f, -0.04566199f, -0.19591348f, 0.00046337f, -0.11859246f, 
    -0.02449910f, -0.11352106f, -0.07861545f, -0.03802950f, 0.25847822f, 0.04461950f, 0.07572891f, -0.00078055f, 
    -0.03393641f, 0.04750973f, -0.02357957f, -0.06763482f, -0.06748952f, 0.08296713f, -0.05732783f, -0.04549174f, 
    0.11619633f, -0.05901170f, 0.06974333f, -0.06347486f, -0.03096669f, -0.00848753f, 0.01161808f, -0.04601418f, 
    -0.03976385f, 0.11433782f, 0.03992810f, 0.04734183f, 0.21029370f, 0.25966030f, -0.01500755f, 0.04987903f, 
    0.04611795f, 0.05015327f, 0.05726913f, 0.10326031f, 0.01190254f, -0.04757498f, 0.03858723f, -0.10093958f, 
    0.51906002f, 0.38150486f, 0.02646620f, 0.06193618f, -0.18307495f, 0.07167232f, 0.16266625f, 0.05037826f, 
    0.08581637f, -0.01035818f, 0.15265431f, 0.00078743f, -0.21157041f, 0.01877081f, -0.09383491f, 0.04907949f, 
    -0.06694265f, 0.02695266f, -0.06407943f, 0.12742212f, -0.12086862f, -0.02888146f, 0.01537400f, 0.06916536f, 
    -0.34121525f, 0.00773837f, 0.00246066f, 0.31533140f, -0.09619530f, 0.09975232f, -0.06946356f, 0.02109671f, 
    0.15173815f, -0.05233832f, -0.01418407f, 0.01279266f, -0.05811777f, -0.12102734f, 0.02520326f, 0.03610763f, 
    -0.05270275f, 0.02704118f, 0.02220843f, 0.09071079f, 0.02395739f, -0.03835258f, -0.06744915f, -0.03539038f, 
    -0.20035782f, 0.11458307f, -0.11821315f, 0.20532203f, 0.01085527f, 0.04290921f, 0.11325369f, -0.05134286f, 
    0.11211965f, 0.02703393f, 0.17271292f, 0.02531953f, -0.07580114f, -0.09424213f, 0.23028108f, -0.06102051f, 
    -0.00575021f, 0.02309444f, 0.00551562f, 0.13863792f, 0.14080600f, 0.11458861f, 0.04389848f, 0.07442826f, 
    0.17791303f, -0.33783883f, -0.04993147f, 0.13408539f, 0.16721676f, -0.02776975f, -0.00101787f, 0.03549622f, 
    0.14268221f, 0.06426134f, 0.06608852f, 0.06245321f, -0.12707664f, 0.05632439f, -0.26973835f, -0.02380403f, 
    -0.00502067f, 0.01981795f, 0.02855527f, -0.09613489f, 0.01078536f, -0.00938148f, -0.03435049f, -0.03924690f, 
    0.18943483f, -0.24451241f, -0.08953663f, 0.41000271f, -0.06247805f, -0.00179998f, 0.00942100f, -0.01249311f, 
    -0.00273165f, 0.07989773f, 0.09395648f, 0.03629329f, 0.15151820f, 0.22888039f, 0.10623531f, -0.13078672f, 
    -0.07455801f, -0.01675628f, -0.04347433f, 0.11591329f, 0.03153362f, -0.06810706f, -0.07932889f, -0.11673185f, 
    0.06908727f, 0.19179834f, -0.08716642f, -0.24021558f, 0.08982711f, 0.07278260f, 0.15882643f, -0.08937946f, 
    0.09667680f, -0.06251738f, 0.00349618f, -0.01498461f, 0.21713580f, 0.13526423f, 0.02610796f, 0.01459187f, 
    0.04705597f, -0.03268117f, -0.07028512f, 0.10152494f, 0.04183965f, -0.02069156f, -0.17908327f, 0.10277762f, 
    0.28738657f, 0.09964236f, -0.14923172f, -0.11090369f, -0.04337798f, -0.23226978f, 0.08651232f, 0.09730875f, 
    0.01146083f, -0.04011447f, 0.03606925f, 0.06000484f, -0.03225746f, -0.02154295f, 0.02378266f, -0.19857559f, 
    -0.01535089f, 0.07330481f, 0.08816276f, -0.10286862f, -0.09696499f, 0.02600359f, 0.01746831f, -0.12523323f, 
    0.03213447f, -0.05384973f, 0.06501552f, -0.06749456f, -0.07706501f, -0.00995805f, 0.00442317f, 0.04513691f, 
    -0.04522126f, -0.01561375f, 0.07319519f, 0.17840473f, -0.12869956f, 0.21522252f, 0.00240140f, 0.05971902f, 
    0.06001177f, 0.00304368f, 0.00867894f, 0.00551046f, -0.04553301f, 0.10578847f, 0.07703508f, -0.00490152f, 
    0.48196599f, 0.17682691f, -0.20871887f, -0.08222197f, -0.04866046f, -0.00560851f, 0.06316533f, 0.15938988f, 
    0.00310994f, -0.09719849f, 0.00599241f, 0.02187488f, 0.08999356f, 0.21640322f, -0.09953700f, -0.23976018f, 
    0.03539604f, -0.07214615f, 0.01038760f, -0.01026812f, 0.02035183f, 0.00333267f, -0.01792659f, 0.21266146f, 
    0.14852042f, 0.05672527f, -0.11926269f, 0.03489181f, 0.07654238f, -0.05391702f, -0.00580782f, 0.07209369f, 
    0.02656125f, -0.07313662f, 0.10549959f, 0.03648170f, 0.14959793f, -0.00149712f, -0.04764475f, -0.06723383f, 
    0.23336829f, 0.02251586f, -0.11482100f, 0.05419946f, 0.12044328f, 0.07215078f, 0.08522975f, 0.01581616f, 
    0.39996132f, -0.01575252f, 0.07242005f, 0.09071135f, 0.03586168f, 0.08991186f, -0.14139912f, -0.01200739f, 
    -0.04497499f, 0.03767448f, -0.03991966f, -0.03799529f, 0.15662780f, 0.02343221f, -0.04877786f, 0.07345759f, 
    0.09184767f, 0.02333097f, -0.01960144f, -0.08842102f, -0.06473172f, 0.03992902f, 0.01140619f, 0.03094640f, 
    -0.12945397f, 0.23392785f, 0.06769904f, -0.04396024f, 0.06240450f, 0.06499364f, -0.03806688f, 0.12408745f, 
    -0.01917305f, -0.03524795f, 0.03369667f, -0.00756699f, 0.49792930f, 0.26568806f, -0.03947549f, 0.09789724f, 
    0.23469009f, 0.13995385f, 0.11418037f, 0.02812300f, -0.00810421f, 0.06296276f, 0.03451233f, 0.02126120f, 
    -0.24682136f, 0.07152379f, 0.06845115f, -0.21875580f, 0.12319766f, 0.07895792f, 0.00218092f, -0.00710757f, 
    -0.01374527f, -0.08588907f, 0.10279281f, 0.00725849f, 0.00950870f, -0.13541946f, -0.12044434f, 0.20003608f, 
    0.05634324f, -0.07167723f, 0.10315955f, 0.06566474f, 0.06758397f, 0.05203745f, 0.05116211f, -0.00347191f, 
    0.03032065f, -0.12894633f, -0.19109716f, -0.00108833f, 0.05630784f, 0.06226068f, -0.06127988f, 0.06073484f, 
    0.07413053f, -0.00624041f, 0.01464796f, 0.02990986f, 0.13614275f, -0.09472708f, -0.22748545f, -0.04772791f, 
    -0.00187930f, 0.07441176f, 0.11985780f, -0.05936072f, 0.06873080f, 0.03624060f, 0.17340764f, 0.08460007f, 
    -0.19454610f, -0.08097189f, 0.02187473f, -0.00842712f, -0.03624958f, -0.02145318f, 0.06065070f, 0.08322199f, 
    0.02356522f, 0.02019568f, -0.03294148f, -0.04195398f, -0.24911222f, -0.03302081f, -0.17387241f, 0.09182322f, 
    -0.03316225f, -0.09925518f, -0.18421267f, -0.01458801f, 0.07362552f, -0.05377044f, -0.02686231f, 0.09385174f, 
    -0.13631921f, -0.09750570f, 0.21816993f, 0.00113611f, -0.00668372f, -0.07152840f, 0.02721956f, 0.00256246f, 
    0.05423753f, 0.02767635f, -0.04112419f, 0.08702811f, 0.26315081f, 0.14792906f, -0.20207593f, -0.08840401f, 
    0.04805672f, 0.06355689f, 0.10226530f, 0.06302886f, -0.02366152f, 0.13299964f, -0.03818030f, 0.14633675f, 
    -0.13636003f, -0.41013536f, -0.06189017f, 0.03740928f, 0.08365051f, -0.04687884f, 0.05436096f, -0.04902164f, 
    -0.04577462f, -0.02387050f, -0.01164000f, 0.01993432f, -0.01142298f, 0.07100882f, 0.08269008f, 0.19029684f, 
    -0.04762167f, 0.09739259f, 0.16215888f, 0.01360780f, -0.01276070f, 0.03932632f, -0.03097642f, -0.05453929f, 
    0.03921961f, 0.02711617f, -0.01447795f, 0.03993906f, -0.00535520f, 0.00876312f, -0.07122570f, 0.00929259f, 
    -0.06449229f, -0.05653951f, 0.02100843f, -0.00621366f, -0.05980504f, 0.03680668f, 0.00611358f, 0.03231487f, 
    -0.02338727f, 0.01313182f, 0.06144359f, 0.06592561f, -0.07336164f, -0.04734882f, 0.03266934f, -0.02369121f, 
    0.05554087f, 0.03985460f, -0.02678652f, 0.00981796f, -0.05371439f, -0.07757507f, 0.00946030f, 0.06175561f, 
    0.05603674f, -0.01829006f, -0.06108066f, -0.04545237f, -0.03337269f, 0.05877439f, -0.00052042f, -0.06701096f, 
    -0.03682949f, -0.07421928f, -0.00475719f, 0.01998799f, 0.01639268f, -0.04510498f, 0.06146492f, 0.01959259f, 
    -0.00917673f, 0.04271629f, -0.00978938f, -0.05105236f, -0.07864834f, -0.02476388f, -0.05903519f, 0.01974014f, 
    -0.07538606f, 0.00398197f, -0.00154095f, 0.00663855f, -0.03635063f, -0.00734863f, 0.03347389f, 0.02092826f, 
    -0.05606743f, 0.02361150f, 0.03301208f, -0.03806949f, -0.03991146f, 0.05832223f, -0.06509941f, 0.02272970f, 
    -0.01951342f, -0.06130909f, 0.04572968f, 0.06596657f, -0.01331283f, 0.05659856f, -0.00403521f, 0.03104989f, 
    -0.07236742f, 0.00073575f, -0.07252199f, -0.01138729f, -0.07550513f, -0.04126722f, 0.05245777f, -0.00547445f, 
    -0.05843553f, -0.01265367f, 0.01868845f, -0.07103540f, -0.06020708f, -0.03223331f, -0.00792710f, -0.00743090f, 
    0.05747285f, 0.00331422f, -0.07566434f, -0.02993533f, 0.04552134f, -0.05647336f, 0.01114084f, 0.05358347f, 
    0.02688803f, -0.07108330f, 0.06508455f, 0.01918529f, -0.07402150f, 0.00838680f, -0.05628234f, -0.06147935f, 
    -0.01416487f, -0.07894997f, 0.02509804f, 0.04630545f, -0.05193134f, -0.07235681f, -0.06231446f, -0.07611742f, 
    0.00043881f, 0.04259218f, 0.02152572f, 0.03053460f, 0.00074603f, -0.06637225f, 0.02695807f, 0.05818853f, 
    0.03423223f, 0.04568964f, -0.04503188f, 0.04969703f, -0.00504388f, -0.06581376f, -0.03972078f, -0.07137766f, 
    -0.03170925f, -0.01018828f, 0.05127181f, 0.06402536f, -0.01259807f, -0.06367705f, -0.07203154f, -0.02726287f, 
    0.03155102f, -0.00070419f, -0.00069504f, -0.05909739f, 0.04926130f, -0.08155028f, 0.03508175f, -0.01769866f, 
    0.01571050f, -0.04131611f, -0.06964865f, -0.00638584f, 0.01594090f, 0.04821262f, -0.00485139f, 0.00451754f, 
    0.05863906f, -0.07209500f, 0.00850915f, -0.02094022f, -0.05024857f, 0.05707841f, 0.03582454f, -0.03695900f, 
    -0.06541806f, 0.02262492f, -0.04819798f, 0.00609700f, -0.01131355f, -0.02903382f, 0.04443965f, -0.05804235f, 
    -0.05197341f, -0.07808322f, -0.00122283f, -0.03586081f, 0.02069713f, -0.06240776f, -0.03346418f, -0.04581467f, 
    0.05114096f, -0.03126242f, -0.02229177f, 0.03843117f, -0.03557820f, 0.06574513f, -0.03977209f, -0.00835811f, 
    0.60013950f, -0.17723542f, 0.08064991f, 0.12125478f, -0.06933495f, 0.09688359f, 0.03723487f, -0.03166704f, 
    0.04332786f, 0.05057235f, -0.09865294f, 0.10998830f, 0.12984012f, -0.09961872f, 0.05081181f, 0.06647760f, 
    -0.17110446f, 0.05251560f, -0.05042830f, 0.03667881f, 0.05917514f, -0.08026280f, -0.03322745f, -0.02388602f, 
    -0.12936442f, -0.01995528f, -0.08385129f, 0.11568079f, 0.08608598f, 0.00085615f, -0.02377241f, -0.03242083f, 
    0.15384854f, 0.01098078f, 0.03924118f, -0.09821647f, -0.20799513f, -0.13490082f, -0.04111293f, -0.01619473f, 
    -0.08961117f, 0.04845126f, 0.21532042f, -0.09170933f, 0.05304474f, 0.04844734f, -0.03301652f, 0.11409674f, 
    -0.15148574f, -0.02263852f, 0.13595770f, 0.00123973f, 0.09696066f, -0.10748558f, 0.07159231f, 0.14787008f, 
    0.05070928f, 0.07101400f, 0.07313164f, 0.05281293f, -0.03940022f, -0.08080335f, -0.09679244f, -0.10385371f, 
    -0.04390959f, -0.08521275f, 0.04702947f, 0.01777920f, 0.03412069f, 0.01469513f, -0.06423879f, 0.02406297f, 
    0.05320188f, 0.00695075f, -0.10916402f, 0.12627724f, -0.10784379f, 0.05289906f, 0.07521558f, 0.04611311f, 
    -0.04385233f, 0.14050230f, 0.07174929f, 0.11660022f, 0.22247697f, 0.09944838f, 0.15056033f, -0.23613703f, 
    -0.08999545f, 0.08501698f, -0.03403247f, 0.00663458f, 0.04907998f, -0.03537038f, -0.13970260f, 0.07237835f, 
    -0.27669924f, 0.11220791f, 0.07798381f, -0.17416336f, -0.01131483f, 0.03350959f, 0.03097336f, -0.12637030f, 
    -0.01216931f, -0.04921680f, 0.05040091f, -0.00235067f, 0.16117381f, -0.00378330f, -0.01568914f, -0.00625026f, 
    0.03186887f, -0.08444587f, 0.04441879f, -0.05392987f, 0.00020480f, 0.00650132f, -0.05608406f, 0.05790938f, 
    -0.12637006f, 0.00779217f, 0.16805306f, -0.00156083f, 0.11422214f, -0.12972201f, -0.00656320f, -0.00353136f, 
    -0.06215478f, -0.02999984f, -0.05704141f, 0.06815980f, 0.07917860f, 0.07451995f, 0.01416090f, -0.20909306f, 
    -0.03934203f, -0.04193123f, 0.14176211f, -0.01669239f, -0.09462996f, 0.05657928f, 0.03443758f, 0.04624170f, 
    -0.21683165f, 0.03084291f, 0.12608705f, -0.11920433f, -0.00872400f, 0.08046518f, 0.07879253f, 0.08534572f, 
    -0.06487001f, 0.00158196f, 0.02530959f, -0.03369366f, 0.12521827f, 0.05867152f, -0.10133833f, -0.06089247f, 
    0.07768267f, -0.00483176f, -0.08576300f, 0.01086759f, -0.05777420f, -0.04256880f, 0.00582039f, 0.04896697f, 
    0.60832918f, 0.26237878f, 0.20212783f, 0.01250169f, -0.06277199f, -0.01411850f, -0.04981919f, -0.04200976f, 
    -0.08699524f, 0.09239618f, 0.14109948f, -0.00746759f, -0.21307431f, -0.01955467f, -0.08900580f, 0.03185834f, 
    -0.06444559f, -0.05503861f, -0.19397332f, -0.00613704f, -0.00782845f, 0.06362011f, -0.10458732f, -0.02587658f, 
    0.20876183f, -0.11842239f, -0.06167580f, 0.10591524f, -0.08209253f, 0.04713496f, -0.14176963f, 0.03363079f, 
    0.02308067f, 0.09245180f, 0.00084562f, -0.06795092f, 0.12286711f, -0.06368459f, -0.09065316f, -0.10321736f, 
    -0.00926168f, -0.02940058f, 0.05921096f, -0.02179169f, 0.00270951f, -0.08243361f, 0.05739336f, 0.19503768f, 
    -0.17770539f, 0.01145482f, -0.17490925f, -0.12886976f, -0.23600659f, 0.02714125f, -0.04179700f, 0.14409645f, 
    0.07881197f, -0.01932283f, -0.02343851f, -0.13491060f, -0.16589801f, 0.09902878f, 0.07601885f, -0.06866373f, 
    0.07552592f, -0.25099280f, -0.16205817f, -0.08203859f, 0.00967056f, -0.12858473f, 0.07273185f, -0.09323329f, 
    0.18585110f, -0.30561653f, 0.05765797f, 0.09892772f, 0.05474417f, -0.04397280f, 0.27254590f, -0.08714578f, 
    -0.02925538f, 0.10371617f, -0.00375707f, 0.16286041f, -0.19034630f, 0.18324082f, -0.02260743f, -0.01984545f, 
    -0.08561039f, 0.04718145f, -0.05712103f, -0.10772870f, 0.00974232f, 0.12142268f, 0.13852999f, 0.08402686f, 
    0.24170385f, 0.00412869f, 0.05158461f, 0.17836253f, -0.24110766f, -0.00179620f, -0.04590633f, 0.02119878f, 
    0.07199094f, 0.09073477f, -0.11749807f, 0.08083497f, -0.21819654f, -0.12456719f, 0.16280928f, 0.09063098f, 
    -0.03970148f, 0.08453342f, 0.07423824f, 0.08224560f, 0.13936442f, -0.07900399f, 0.24663225f, 0.09695452f, 
    -0.17889637f, -0.03381412f, 0.03817754f, -0.07366180f, 0.04395480f, 0.00811492f, 0.08145404f, -0.09108172f, 
    0.10181414f, -0.03079603f, -0.14817205f, 0.02839197f, 0.16212820f, -0.05933766f, 0.16475037f, 0.00970860f, 
    0.16076554f, 0.11194512f, -0.19057882f, 0.12224521f, -0.02257111f, -0.01639049f, 0.00431150f, -0.06463794f, 
    0.17290358f, 0.10290378f, 0.00864345f, 0.21179721f, 0.11215844f, 0.03229718f, -0.04859307f, 0.11434478f, 
    0.03474412f, 0.02322659f, -0.15105015f, -0.12030303f, 0.00029484f, -0.00684060f, -0.30211672f, 0.08448253f, 
    -0.07200385f, 0.07771568f, 0.15228356f, 0.02161395f, 0.10363426f, -0.11827188f, 0.17153531f, 0.17810684f, 
    -0.11946633f, 0.14282276f, -0.15881926f, -0.01998955f, 0.06335903f, 0.08342199f, 0.04306758f, 0.04806033f, 
    0.09772513f, -0.20780198f, -0.08780748f, -0.12246317f, -0.08565367f, 0.11285480f, 0.21745345f, 0.07966279f, 
    0.07689428f, -0.06324156f, 0.01469496f, -0.25547352f, 0.07855764f, 0.07795601f, -0.05969411f, -0.05256514f, 
    0.49289325f, 0.20895724f, 0.05545669f, -0.34066889f, -0.03216324f, 0.02958685f, 0.09153972f, 0.25392655f, 
    -0.08855635f, 0.01239459f, -0.03373632f, -0.16052285f, -0.21227548f, -0.02512083f, -0.00752255f, 0.08656905f, 
    -0.08042331f, 0.03015365f, -0.02691821f, -0.20127365f, 0.01902007f, 0.03094863f, 0.06782069f, -0.06422295f, 
    0.03592100f, 0.01831795f, -0.00581945f, -0.03515656f, -0.05916461f, -0.01464772f, 0.01240189f, -0.00395472f, 
    -0.00283325f, 0.04578251f, 0.04551902f, -0.05388100f, 0.01446818f, -0.01417648f, -0.02421123f, -0.05961628f, 
    -0.06292556f, 0.02259777f, -0.06621891f, 0.06160376f, 0.03167034f, -0.02117407f, 0.06111024f, -0.07754523f, 
    -0.02497569f, -0.02034261f, -0.00570413f, 0.03759611f, -0.05623445f, -0.01599647f, -0.02564421f, -0.06153424f, 
    0.03944647f, -0.02492543f, -0.04096391f, 0.00960130f, 0.01289377f, -0.00882602f, -0.06252216f, 0.01726873f, 
    -0.04673906f, 0.00876487f, -0.05666893f, 0.02228988f, -0.06744670f, 0.04159397f, 0.01652714f, -0.00274141f, 
    -0.05750119f, -0.06586367f, -0.02337790f, -0.03410818f, -0.02512070f, -0.05792506f, -0.06106553f, 0.00977472f, 
    0.05563700f, -0.02396649f, 0.04542756f, -0.04891284f, -0.04323091f, 0.03089448f, -0.02734261f, 0.03790484f, 
    -0.02639611f, 0.05942269f, 0.05120875f, 0.05400174f, -0.03854227f, 0.05966908f, 0.02631000f, -0.00262242f, 
    0.04919712f, -0.00199888f, 0.04792384f, -0.03233619f, -0.03077957f, -0.03539446f, -0.07783064f, 0.04951868f, 
    0.04087479f, -0.02856248f, 0.00022615f, -0.04078012f, -0.01839534f, -0.03690825f, -0.05183095f, -0.07951021f, 
    0.01716878f, 0.01778965f, -0.06519395f, 0.00732967f, -0.01933437f, -0.03552135f, -0.06331587f, -0.06764839f, 
    -0.04901835f, -0.04563813f, -0.02015307f, 0.04754157f, -0.01728061f, 0.04219041f, 0.02119289f, 0.05190195f, 
    -0.07832697f, -0.03941130f, -0.02980725f, -0.00978963f, -0.03311286f, -0.02107439f, -0.04734222f, -0.01080292f, 
    -0.02437743f, -0.07050668f, -0.00176590f, -0.00711379f, -0.00793324f, 0.02165020f, 0.03547083f, -0.00187322f, 
    -0.03692866f, 0.04556560f, -0.04534579f, 0.05738737f, 0.03981020f, -0.05336934f, 0.04711998f, -0.04485276f, 
    0.01707901f, 0.04794120f, 0.02705683f, -0.04820524f, -0.04728744f, 0.06231741f, -0.05141469f, -0.06956678f, 
    0.02883106f, 0.05444255f, -0.03869150f, -0.05581889f, 0.05839909f, -0.01394471f, -0.04293472f, 0.01963602f, 
    0.03083510f, 0.05903137f, 0.05433059f, 0.02898653f, -0.05648000f, -0.03663673f, 0.01072488f, -0.03759736f, 
    -0.04622130f, -0.06236379f, -0.03246404f, -0.01420939f, -0.07557348f, 0.00700633f, -0.04958840f, -0.03891366f, 
    -0.05024958f, -0.06178010f, 0.04539970f, -0.00221673f, -0.03871631f, 0.03455374f, 0.03410997f, 0.02743036f, 
    -0.05876822f, -0.02990620f, -0.01742488f, -0.05669298f, 0.05323992f, -0.05668192f, 0.05928284f, -0.03711656f, 
    -0.07253898f, 0.03898462f, -0.03904057f, 0.05241024f, 0.02408564f, 0.01212779f, 0.05965631f, -0.05743563f, 
    0.03290848f, -0.01548112f, 0.02882094f, -0.05351822f, 0.06023314f, 0.03558234f, -0.05653012f, 0.05602696f, 
    -0.04569518f, -0.03767816f, 0.02824676f, 0.05123478f, -0.06967252f, 0.06223724f, 0.04309667f, 0.06376059f, 
    0.01796403f, -0.01584606f, 0.06026456f, 0.00594495f, 0.04601610f, 0.06536133f, -0.07031551f, 0.05675510f, 
    0.00342524f, -0.07393979f, 0.03045903f, -0.06366573f, -0.01613211f, -0.03923327f, 0.01215350f, 0.02360488f, 
    0.00535861f, -0.00545020f, 0.01382197f, -0.07122063f, -0.06169036f, -0.05249849f, -0.06104883f, -0.07143909f, 
    -0.07350957f, -0.01991863f, -0.07251143f, 0.06602721f, -0.01114824f, -0.01942050f, 0.03178750f, 0.04753084f, 
    -0.06134417f, 0.02427440f, 0.05466451f, -0.07359035f, 0.03583691f, -0.00220544f, -0.05436791f, -0.02797489f, 
    0.00615368f, 0.04856463f, -0.00338515f, -0.00496831f, 0.05023740f, -0.03520187f, -0.07261117f, -0.07069915f, 
    0.00320025f, -0.03165982f, -0.07092883f, 0.04966673f, -0.05925952f, 0.03552308f, 0.04941201f, 0.05136146f, 
    0.03416659f, 0.05888418f, -0.01828205f, -0.02195392f, -0.05682944f, -0.06789169f, -0.06192464f, 0.03625680f, 
    -0.06891409f, 0.02281264f, -0.04951077f, 0.03592716f, 0.02150132f, -0.05751030f, -0.03114515f, -0.07603592f, 
    0.01883494f, -0.04819056f, -0.03909291f, -0.00066114f, 0.00710860f, 0.05034378f, -0.07609263f, -0.05956144f, 
    0.04275720f, -0.06449249f, -0.04793782f, -0.04787714f, 0.01289801f, -0.07711969f, -0.06395646f, -0.06235871f, 
    -0.04579558f, -0.02194911f, -0.03006508f, -0.01449776f, -0.03439837f, -0.07400472f, -0.07660457f, 0.05799273f, 
    -0.01074345f, 0.01283434f, -0.04614851f, 0.02805629f, -0.04946018f, 0.02280281f, 0.06012185f, -0.04810715f, 
    -0.00679095f, 0.01843860f, -0.03702414f, -0.06529541f, -0.07473662f, 0.03434871f, 0.05343119f, 0.01164016f, 
    -0.03731309f, -0.05854313f, 0.04820946f, 0.02596714f, -0.00785825f, 0.05883242f, 0.05891559f, 0.00994533f, 
    -0.05707007f, 0.01257745f, -0.02900855f, 0.02948073f, 0.04098868f, 0.05929431f, -0.06681541f, 0.05938811f, 
    0.00381647f, 0.01546377f, 0.02094855f, -0.03714695f, 0.03765590f, 0.06114499f, 0.04519080f, 0.01283635f, 
    0.00772655f, -0.00109577f, -0.07549687f, 0.01589982f, -0.05673782f, 0.00689426f, 0.05291916f, 0.02643464f, 
    0.04575050f, 0.03482747f, 0.03868620f, -0.00388112f, -0.02171398f, -0.05556025f, 0.03693670f, 0.02587263f, 
    -0.04123161f, -0.07706605f, 0.02252699f, -0.00729901f, -0.04427287f, -0.07519928f, 0.00603826f, -0.00903216f, 
    -0.03061033f, 0.00327301f, 0.01737693f, 0.00338837f, -0.04463153f, -0.05840359f, 0.00512822f, -0.05185763f, 
    -0.01089352f, -0.06068903f, -0.03848940f, -0.02370759f, 0.06249363f, 0.05077447f, 0.05249695f, -0.03248102f, 
    0.06260173f, -0.00396125f, -0.06268376f, -0.05338571f, -0.01550632f, 0.04813078f, -0.04889054f, -0.02238592f, 
    -0.56113827f, 0.30641380f, -0.13169801f, -0.03597421f, 0.06276886f, -0.01820832f, -0.14935666f, 0.04012073f, 
    0.02369433f, 0.00205681f, 0.04344715f, 0.00753058f, -0.19949397f, 0.10340653f, 0.17290516f, -0.31410852f, 
    0.05021621f, -0.00467165f, -0.11252419f, -0.03996283f, 0.03528671f, 0.01561520f, 0.03033538f, -0.05609781f, 
    -0.30224484f, -0.04420200f, 0.04332096f, -0.02271929f, 0.15473434f, 0.07390994f, -0.01427814f, 0.14028962f, 
    -0.11404782f, -0.02354633f, 0.06026803f, 0.04628801f, 0.09385085f, 0.00947242f, 0.24818398f, 0.00001871f, 
    0.00346688f, -0.03068599f, 0.03541795f, 0.05750588f, 0.04069382f, 0.04519152f, 0.07765828f, 0.08153750f, 
    0.11303980f, -0.20549984f, -0.23059537f, -0.00061608f, 0.07732746f, -0.02219268f, -0.09314848f, -0.04518636f, 
    0.18610013f, -0.01447102f, -0.11730600f, -0.04694845f, -0.29625344f, -0.08907729f, -0.02316606f, -0.06209087f, 
    -0.07789405f, 0.06107413f, 0.02915957f, 0.09850404f, 0.13496755f, -0.05931774f, -0.05651898f, -0.02714069f, 
    0.03774201f, -0.19126473f, 0.02449742f, -0.03002682f, 0.06826346f, 0.01376609f, 0.00897835f, -0.06208642f, 
    -0.02349233f, 0.03412786f, 0.01103325f, 0.24410152f, -0.09821794f, 0.14054650f, -0.06020798f, -0.08785346f, 
    -0.03436192f, 0.09263272f, -0.09677307f, 0.00280208f, 0.00795925f, 0.06075394f, -0.10283544f, -0.09971921f, 
    0.10992346f, 0.05619003f, 0.01134143f, 0.27860489f, 0.09309912f, 0.07307456f, 0.10080257f, -0.01776007f, 
    -0.01513323f, 0.08216315f, 0.07520428f, 0.03452200f, 0.12613922f, 0.11220764f, 0.11664663f, 0.01890113f, 
    0.08118995f, -0.01515473f, 0.11926297f, 0.04039603f, -0.05474888f, -0.03010784f, -0.00331306f, 0.08680210f, 
    0.09297937f, 0.22455443f, -0.25627548f, 0.04991854f, 0.04978521f, 0.18762346f, -0.04316013f, -0.06943756f, 
    0.04178449f, -0.01175944f, 0.12990865f, 0.05308075f, 0.30720741f, -0.06883723f, 0.07841710f, 0.08210264f, 
    -0.03400363f, 0.17850074f, -0.01578032f, -0.03285000f, -0.07030797f, 0.00288219f, 0.03150154f, -0.15292579f, 
    -0.17536309f, -0.05496594f, -0.09967782f, 0.05734690f, 0.13326988f, -0.05029624f, 0.06073127f, -0.02626608f, 
    0.12034702f, 0.10343673f, 0.02344706f, 0.07641523f, 0.03431486f, 0.11344503f, 0.27654180f, 0.31151310f, 
    -0.02771102f, -0.07455137f, 0.06480403f, 0.06391228f, -0.05814769f, 0.01247437f, 0.02621530f, 0.18653394f, 
    -0.22456968f, 0.15922536f, -0.23020039f, 0.01224238f, -0.00988451f, 0.12472255f, 0.01372394f, 0.04739992f, 
    0.01462119f, -0.01259728f, 0.02659459f, -0.09359915f, -0.02508548f, -0.01524752f, 0.13539183f, 0.00521429f, 
    -0.02830522f, -0.02662537f, 0.00449972f, 0.04634040f, 0.02406096f, -0.00139805f, 0.04814431f, -0.01146924f, 
    0.28337893f, -0.05087156f, -0.15025805f, 0.03488282f, 0.10310719f, 0.02311212f, 0.08636209f, 0.00504768f, 
    -0.06115067f, -0.01079184f, 0.00784106f, 0.02889382f, -0.03184794f, -0.05755823f, -0.02647910f, -0.00125369f, 
    -0.00393987f, 0.03959941f, -0.02564420f, 0.07464598f, -0.01025508f, 0.00700609f, 0.02274901f, 0.00375045f, 
    0.01197523f, 0.01122862f, -0.08715788f, -0.04818009f, 0.01908751f, 0.03392297f, -0.02948600f, 0.05199013f, 
    0.01511954f, -0.05140448f, 0.01059230f, 0.04434501f, 0.19559179f, -0.01071884f, 0.00282797f, -0.04886705f, 
    0.10848608f, -0.06628966f, 0.18080667f, 0.01732090f, 0.07659940f, 0.00796612f, 0.10603748f, 0.12535766f, 
    -0.30680335f, -0.06149212f, 0.11614204f, -0.12988061f, -0.04254564f, 0.09683751f, 0.10085209f, 0.06515714f, 
    0.01241571f, 0.03666548f, 0.06634007f, 0.11293706f, -0.20412929f, -0.13915581f, -0.06443014f, -0.23527659f, 
    0.06539794f, 0.17292574f, -0.02233448f, 0.07204249f, -0.01849220f, 0.00474435f, -0.02724944f, -0.04175158f, 
    0.02396783f, 0.02297227f, 0.02597087f, -0.13919584f, -0.02914232f, 0.05669934f, -0.05389361f, 0.02401649f, 
    -0.02314904f, 0.06581930f, -0.10998895f, 0.07824798f, 0.18033585f, 0.06578812f, -0.16330291f, -0.09153496f, 
    -0.03065279f, -0.00291219f, 0.03223194f, 0.02320001f, 0.14717263f, -0.03264514f, 0.00627350f, 0.01176521f, 
    -0.22760703f, 0.14091343f, 0.26440346f, -0.06085471f, 0.13909334f, -0.01687114f, 0.09496345f, 0.15415271f, 
    0.00428652f, -0.06602756f, 0.06830444f, -0.03623720f, 0.28998262f, -0.07162073f, -0.18607071f, 0.10276394f, 
    0.04441294f, -0.04297475f, 0.01226189f, 0.06205759f, 0.02821852f, -0.02063652f, 0.06148851f, -0.03762802f, 
    -0.19034517f, -0.24490899f, -0.13586201f, 0.10471714f, -0.03659824f, 0.06992669f, 0.05426944f, -0.02769343f, 
    -0.10301884f, 0.01735003f, 0.13011895f, -0.01675395f, 0.00971051f, -0.18820482f, 0.08121159f, -0.02668856f, 
    -0.05128853f, 0.02788048f, -0.06564546f, 0.11267558f, 0.03301620f, 0.09372273f, -0.01153483f, 0.04282828f, 
    -0.06591628f, -0.09800234f, 0.04014944f, -0.00562860f, 0.08877911f, 0.02599336f, -0.01002968f, -0.01930224f, 
    0.02210634f, 0.08599339f, -0.03840895f, 0.01729855f, 0.43327036f, 0.19940983f, -0.24294814f, -0.09597470f, 
    0.04355013f, 0.06310366f, -0.00786260f, 0.08175167f, -0.02987715f, -0.10101254f, 0.09269950f, 0.01583732f, 
    0.07097201f, 0.02739860f, -0.03519968f, -0.01467606f, -0.10835607f, -0.00367244f, 0.08781031f, 0.04568898f, 
    0.09682430f, 0.02232256f, 0.02194721f, -0.04481116f, -0.35919893f, -0.09889433f, 0.21062249f, 0.12268618f, 
    -0.03931366f, 0.16167358f, 0.02178069f, -0.00957725f, -0.02853025f, 0.05762194f, -0.05676195f, 0.01439275f, 
    0.05171309f, 0.02069877f, -0.22084481f, 0.19694017f, 0.00576113f, 0.04391050f, 0.03761820f, 0.02777173f, 
    0.01767914f, -0.03455497f, 0.09356369f, 0.02294179f, -0.24340935f, 0.26140854f, 0.12122714f, 0.15459794f, 
    0.00778272f, -0.00479273f, -0.08073174f, -0.06665193f, -0.07270536f, 0.01883027f, 0.10097739f, 0.00234456f, 
    0.00985681f, 0.08080532f, -0.01599451f, -0.08716532f, 0.13368978f, -0.03475318f, 0.00524027f, -0.05028712f, 
    0.06021666f, -0.00890616f, 0.05112558f, 0.07140122f, 0.08146773f, 0.02015290f, -0.04228926f, -0.00883474f, 
    -0.00700952f, 0.09813721f, 0.18303049f, 0.09062671f, 0.09230085f, 0.13092680f, -0.14427073f, 0.10030999f, 
    0.00024487f, 0.01572450f, 0.07329577f, -0.16065215f, -0.07055867f, -0.01304238f, -0.13645481f, 0.04586400f, 
    0.01512570f, -0.08958050f, 0.00050275f, -0.08908340f, 0.11565311f, -0.26039490f, 0.12219024f, -0.02108648f, 
    -0.07558239f, 0.03196595f, -0.04744729f, 0.03729784f, -0.01925473f, -0.12074883f, -0.14213809f, 0.03423605f, 
    0.04637567f, 0.06505062f, -0.08390210f, 0.05480261f, 0.00215348f, -0.05903931f, 0.09506530f, 0.00826597f, 
    -0.07644907f, 0.07193036f, -0.07289817f, 0.11277495f, 0.32254466f, 0.26676556f, -0.15958527f, -0.18064670f, 
    0.08104604f, 0.02977799f, -0.09515401f, 0.09108917f, -0.02432947f, 0.05112685f, -0.11046489f, 0.03256174f, 
    -0.18841141f, 0.18250528f, 0.25248986f, 0.00316033f, -0.11918805f, -0.01894457f, 0.03119559f, 0.11623302f, 
    -0.10263731f, 0.06453928f, 0.02477410f, -0.02225328f, -0.09801507f, -0.19221461f, -0.06272310f, 0.02884569f, 
    -0.05467276f, -0.01608357f, -0.01654615f, 0.04503756f, 0.04035920f, -0.00641416f, -0.05051374f, 0.02496957f, 
    -0.14058529f, -0.24746323f, -0.06860620f, -0.01092551f, 0.07160027f, 0.14925471f, 0.07252972f, -0.07925531f, 
    -0.09138200f, 0.04633408f, 0.01523948f, -0.00111931f, 0.21321562f, 0.15531236f, 0.17955884f, 0.04454748f, 
    0.07076878f, 0.07150111f, -0.01764908f, -0.00407570f, -0.03222917f, 0.14270435f, -0.10144474f, -0.09132954f, 
    0.24605519f, -0.12768537f, -0.02224883f, 0.16663724f, 0.08396472f, 0.09462467f, -0.04957198f, 0.15542403f, 
    0.09329342f, 0.13735230f, 0.06848913f, -0.03832983f, 0.25903192f, 0.01497733f, -0.03404354f, -0.06452286f, 
    -0.03026300f, -0.00932893f, -0.02367881f, 0.14481439f, 0.05468438f, -0.07825075f, 0.23049815f, 0.03275882f, 
    -0.32968360f, 0.12997685f, 0.00457540f, -0.01147344f, 0.13630536f, -0.04743052f, 0.01304803f, 0.01402085f, 
    0.10729389f, 0.04458166f, -0.03385915f, 0.05174375f, 0.20680141f, -0.08314755f, 0.10060119f, 0.06839795f, 
    -0.06897530f, 0.05514563f, -0.03474191f, 0.04842092f, -0.13428207f, -0.11011959f, -0.04206291f, 0.04761190f, 
    -0.06193504f, -0.01426131f, -0.01086545f, 0.03038961f, -0.03884167f, -0.01355705f, -0.05186518f, 0.04865433f, 
    0.04230027f, 0.04222997f, -0.04845463f, 0.01640175f, 0.05772659f, 0.01440369f, 0.02755581f, -0.02249450f, 
    -0.05437760f, -0.05196192f, -0.03979640f, -0.04264354f, -0.02442493f, -0.07611424f, -0.01000435f, 0.05806237f, 
    -0.00079834f, 0.00482178f, -0.00770831f, 0.01545855f, 0.05983244f, 0.06063470f, -0.07394778f, 0.03874691f, 
    0.03176471f, -0.02708391f, -0.00588150f, 0.03229556f, 0.04408853f, -0.08593367f, -0.05169652f, -0.05553043f, 
    0.03664331f, 0.01670347f, -0.01178607f, -0.02258115f, -0.04892367f, 0.00732668f, -0.03027331f, -0.02273264f, 
    0.05176679f, -0.07403689f, 0.00375164f, 0.02598856f, 0.02343390f, 0.05371939f, -0.06326197f, -0.01034503f, 
    -0.00980593f, 0.04970424f, 0.02723403f, 0.00288059f, 0.03527548f, -0.04575900f, 0.07096879f, 0.01181116f, 
    0.02904178f, -0.02000518f, 0.03399031f, -0.08813701f, -0.01858156f, 0.00010304f, -0.03102929f, -0.08387303f, 
    -0.01946564f, 0.03037069f, 0.01490282f, -0.01766926f, -0.03971758f, -0.00300534f, -0.05994770f, 0.03214548f, 
    -0.07373994f, -0.03497941f, 0.00037448f, 0.03348139f, 0.03896998f, 0.04513995f, 0.03627999f, -0.03064243f, 
    -0.05788191f, 0.05305928f, -0.04833158f, 0.05041714f, -0.00133352f, -0.05286148f, 0.03981990f, 0.03138052f, 
    -0.00418893f, -0.09688658f, 0.01127129f, -0.01363895f, -0.07274240f, -0.03589704f, -0.04112276f, 0.02601341f, 
    -0.06111420f, -0.02670405f, -0.05397719f, 0.05472140f, 0.02489885f, -0.06518793f, 0.01806767f, 0.05411105f, 
    0.05257368f, -0.07099305f, -0.03287997f, -0.01124301f, -0.03910801f, 0.04613391f, -0.02077902f, -0.07958736f, 
    0.03580332f, 0.05007090f, 0.05793345f, -0.08928967f, -0.03454575f, 0.02332640f, 0.02775713f, -0.00674815f, 
    -0.02307403f, -0.03197186f, 0.01798754f, -0.02957889f, 0.04359722f, 0.04066578f, -0.00059953f, -0.06093211f, 
    -0.09111851f, 0.05626873f, 0.03848650f, -0.00790988f, -0.06921049f, -0.05817121f, 0.05509746f, -0.05619864f, 
    -0.08402449f, 0.04720938f, -0.05977248f, -0.08099887f, 0.04954761f, -0.02132714f, 0.01646868f, 0.01290289f, 
    -0.07906758f, 0.01547931f, -0.05116582f, -0.03046831f, 0.01951737f, -0.00506963f, -0.05524461f, 0.00918774f, 
    0.00403261f, -0.02453089f, -0.01934552f, -0.03758267f, -0.05735292f, 0.00489100f, -0.04210158f, -0.00085544f, 
    -0.06191405f, 0.01004579f, -0.03951040f, -0.04178571f, 0.05214712f, 0.04910182f, -0.01161889f, -0.02118122f, 
    0.03788437f, -0.02394045f, 0.00824038f, -0.05912314f, 0.02203037f, 0.02235952f, -0.01445256f, 0.04564875f, 
    -0.02108347f, -0.06041800f, -0.00876269f, -0.02615978f, 0.02452753f, 0.04946152f, 0.05518373f, -0.00355516f, 
    0.06969216f, -0.22649470f, -0.03028184f, 0.30699611f, 0.10546064f, 0.05880839f, 0.02237870f, -0.03521977f, 
    0.12270614f, -0.06821178f, 0.10715523f, 0.08992046f, 0.19060124f, -0.05318430f, 0.01685194f, 0.27018943f, 
    0.06652141f, 0.08158670f, -0.04370597f, 0.01566872f, -0.00448011f, 0.00127922f, 0.04888252f, 0.10474318f, 
    0.15536723f, 0.09306753f, -0.01852006f, 0.02020952f, -0.07037095f, -0.00993084f, -0.05531761f, -0.09284622f, 
    0.02588876f, 0.05129589f, 0.01321626f, -0.11428048f, 0.08199155f, 0.04028235f, -0.05338740f, -0.00164979f, 
    0.00332415f, 0.09773531f, 0.01674010f, -0.02906411f, -0.06913112f, 0.05729146f, -0.07484350f, -0.05684502f, 
    0.14284939f, -0.07381475f, 0.27546036f, -0.07443199f, 0.02302966f, -0.08688065f, 0.08531949f, 0.03128120f, 
    0.00134937f, -0.06466801f, -0.02589837f, 0.03324230f, 0.26228425f, 0.24301490f, -0.03622156f, 0.05529714f, 
    0.01876372f, 0.06818115f, 0.03464204f, 0.03800416f, -0.04094282f, 0.06107847f, 0.06126748f, 0.06762584f, 
    0.09589119f, 0.08759708f, 0.06587461f, 0.18503349f, 0.06019444f, 0.03701705f, -0.01615276f, 0.04676330f, 
    0.01000627f, -0.03444793f, 0.05341870f, -0.04836748f, 0.28724769f, -0.06979799f, 0.03835894f, -0.00383756f, 
    -0.02766492f, -0.13243993f, -0.00781951f, 0.05846505f, 0.02327764f, -0.00130873f, 0.05598015f, 0.09696864f, 
    -0.05318527f, 0.08663956f, 0.03300550f, -0.37488094f, -0.01189141f, 0.07499356f, 0.00866976f, 0.05999406f, 
    0.10836475f, 0.06528796f, 0.01800023f, 0.09265310f, 0.05174089f, 0.00691406f, -0.18098390f, 0.00250327f, 
    0.06031775f, 0.06401990f, -0.05982789f, 0.02500636f, 0.07493456f, 0.05560220f, -0.00610487f, -0.00233838f, 
    -0.01948564f, -0.12841608f, -0.07325321f, -0.02549399f, -0.03151877f, -0.10217563f, 0.06492604f, 0.12576126f, 
    0.00401391f, -0.02846454f, -0.05832995f, 0.06210351f, -0.25300604f, 0.02031755f, -0.03546664f, -0.16853248f, 
    -0.08069061f, -0.10101062f, -0.03775373f, -0.01153077f, 0.10629092f, 0.03871101f, 0.00204999f, 0.01463366f, 
    0.12429911f, -0.10468484f, 0.07871890f, -0.09679825f, -0.00047606f, -0.03603293f, 0.05999370f, 0.11549325f, 
    -0.01061180f, -0.06958285f, 0.03378557f, 0.14951286f, 0.01771751f, 0.28365710f, -0.20092601f, -0.18623815f, 
    0.07816681f, 0.17074221f, 0.06568269f, 0.01752915f, 0.04771530f, 0.10174865f, -0.04345546f, 0.06293540f, 
    0.28417119f, -0.29215896f, 0.07138523f, -0.00579252f, 0.04825480f, -0.16118963f, -0.08231477f, 0.02969720f, 
    0.00129652f, -0.01231296f, 0.00967164f, 0.10654640f, -0.00874488f, 0.13412969f, -0.15738469f, -0.10834911f, 
    0.08619131f, -0.06326912f, 0.09850991f, -0.06063649f, -0.09765895f, 0.01890098f, -0.04488796f, 0.14082581f, 
    -0.02916124f, 0.04033852f, -0.05603970f, 0.05415904f, -0.01036098f, 0.03694994f, -0.04804756f, -0.01465899f, 
    0.07158398f, -0.06267213f, 0.06065124f, -0.01834852f, -0.02537869f, -0.05578049f, -0.03567567f, 0.04983275f, 
    0.03020241f, -0.03019689f, 0.00764323f, -0.06673495f, -0.06982654f, 0.03718159f, -0.07248362f, -0.02184581f, 
    0.05316807f, -0.01366298f, -0.01614270f, -0.01452805f, -0.04338094f, 0.05926804f, 0.00329856f, 0.03622387f, 
    -0.04173903f, -0.01397695f, -0.03190156f, 0.04160537f, -0.07937440f, 0.00647264f, -0.04005145f, -0.01374401f, 
    0.02428918f, 0.00512765f, -0.02263724f, 0.03988128f, -0.01929673f, -0.00102750f, 0.04719368f, -0.04112803f, 
    -0.05600902f, -0.03838776f, -0.01956469f, 0.01364299f, -0.04897839f, 0.00441150f, -0.06384849f, -0.06456660f, 
    -0.05500790f, 0.03612794f, 0.05890188f, 0.02431274f, 0.00407480f, 0.01046455f, -0.04124004f, 0.04303393f, 
    0.04254158f, -0.01317452f, 0.04782391f, 0.01294223f, -0.07592700f, -0.07760096f, -0.00045339f, -0.02916659f, 
    -0.05547812f, -0.00569755f, -0.00084984f, 0.02978407f, -0.01926936f, -0.04786564f, -0.01283232f, -0.05273328f, 
    -0.05891908f, 0.02653115f, -0.04150379f, -0.06647724f, 0.04970514f, 0.00482484f, -0.05682784f, 0.01373804f, 
    -0.06466777f, 0.00563372f, -0.04759989f, -0.01644166f, -0.04414573f, 0.03143973f, -0.05256398f, -0.04334775f, 
    0.00870953f, -0.01043271f, -0.06516206f, 0.00362195f, 0.01198681f, -0.05641425f, -0.04668262f, -0.04080013f, 
    -0.07969134f, 0.02007869f, 0.05611182f, -0.01846752f, 0.05084902f, -0.02918400f, -0.04209105f, 0.05851416f, 
    -0.00643261f, -0.04377007f, -0.07181444f, -0.03391041f, 0.00691525f, -0.02934917f, -0.00703549f, 0.05301516f, 
    -0.00069179f, 0.03831257f, -0.05884821f, 0.05935381f, -0.00717402f, 0.04547208f, -0.02678335f, -0.00354686f, 
    -0.05731682f, 0.00398217f, -0.03644187f, 0.00047677f, 0.02843936f, -0.01958354f, -0.01187875f, 0.03327201f, 
    0.06202693f, -0.02989787f, 0.05258844f, -0.01369815f, -0.04677172f, -0.05277665f, 0.00799776f, -0.01204229f, 
    -0.06522431f, 0.04950047f, -0.06912985f, 0.04159531f, 0.02502549f, 0.03214001f, 0.03411719f, -0.06721599f, 
    0.06370042f, 0.00271331f, -0.06487900f, 0.06567097f, -0.04717853f, -0.00396262f, -0.00937373f, 0.06295842f, 
    -0.04267951f, 0.03565945f, 0.00284058f, -0.00487453f, 0.04852818f, 0.04872780f, 0.05381804f, -0.06164037f, 
    0.02850847f, 0.04904244f, -0.05879094f, -0.01445680f, 0.05717589f, -0.07633385f, -0.02253542f, -0.05793845f, 
    0.04390134f, -0.02868581f, -0.01854989f, -0.05010427f, 0.04430765f, 0.00403788f, 0.00981115f, -0.03912928f, 
    -0.08046475f, 0.00732650f, 0.02236435f, 0.05230586f, 0.03843988f, 0.01988889f, -0.03223147f, -0.01451610f, 
    -0.32406297f, 0.17450681f, -0.22633639f, 0.15121226f, -0.12678114f, -0.05449660f, -0.01722916f, -0.10360987f, 
    0.00169682f, -0.10389067f, 0.12227793f, 0.01512028f, -0.19338112f, 0.26551229f, -0.00182036f, 0.03738449f, 
    -0.04633009f, 0.09639788f, 0.00384044f, -0.02148820f, -0.05444413f, 0.07866210f, 0.03016375f, 0.05860675f, 
    -0.08763192f, 0.25792867f, -0.05434171f, 0.06438341f, 0.02486795f, 0.00383895f, -0.11027023f, 0.03629309f, 
    -0.08670236f, 0.08254170f, -0.04598992f, 0.15588687f, -0.00953751f, 0.10063008f, -0.05462145f, -0.08082964f, 
    -0.08315454f, -0.07592276f, -0.05220978f, 0.08368784f, -0.09720653f, 0.06876715f, -0.02474770f, -0.08004121f, 
    0.32960215f, -0.08657008f, -0.03659621f, 0.14223719f, 0.08005390f, -0.08694468f, -0.06653431f, 0.08309767f, 
    -0.04878527f, -0.16039304f, -0.10628294f, -0.06308853f, 0.16128328f, 0.07293990f, 0.07482033f, 0.05693561f, 
    -0.04418485f, -0.02471334f, 0.03394491f, 0.00789399f, 0.04515357f, -0.07831495f, -0.04012587f, -0.03573355f, 
    -0.05898711f, 0.06645773f, 0.05259052f, 0.03089324f, -0.11238711f, -0.05648326f, 0.01991014f, 0.05037659f, 
    -0.01464403f, -0.00418392f, -0.05967135f, -0.08303361f, 0.08895606f, 0.12769321f, -0.04784777f, 0.07765418f, 
    -0.00290738f, -0.00164070f, 0.04639332f, 0.04622925f, -0.06009341f, 0.11359744f, -0.04000403f, -0.02109336f, 
    -0.15573806f, 0.09653481f, 0.17053308f, -0.10242600f, -0.04452639f, 0.00979156f, -0.04046796f, -0.08056486f, 
    0.01964421f, 0.04008904f, 0.04896598f, 0.05304354f, -0.10887521f, -0.08341683f, 0.05992336f, 0.07101389f, 
    -0.04592567f, -0.00575583f, -0.06179587f, 0.13657629f, -0.01095792f, 0.06590831f, -0.02667452f, 0.01565880f, 
    0.28553793f, -0.02203829f, -0.00630162f, 0.14676814f, 0.11647321f, 0.04443539f, 0.07404608f, 0.02073774f, 
    -0.04994346f, 0.05691960f, -0.00976489f, -0.01703767f, 0.15983716f, -0.07609698f, 0.10425188f, -0.00283587f, 
    0.07774048f, -0.01288161f, 0.03833035f, -0.08591857f, -0.10734311f, -0.02511416f, -0.00318241f, 0.01930658f, 
    0.30886158f, -0.04591194f, 0.00551834f, 0.11589100f, 0.03292488f, 0.02671434f, -0.13436550f, 0.14731197f, 
    0.12133877f, 0.06969377f, 0.05935797f, 0.04732571f, -0.01692493f, -0.04519970f, 0.07513162f, 0.03979282f, 
    0.07303996f, -0.04292545f, -0.00666097f, -0.03966569f, -0.01279118f, 0.05018859f, 0.09980027f, 0.08346695f, 
    -0.46287262f, 0.04061645f, -0.04796631f, -0.07961196f, 0.11495185f, -0.01604116f, -0.01835424f, 0.01098474f, 
    0.07006566f, 0.09762866f, -0.01097577f, -0.08235651f, 0.22110341f, -0.00874299f, 0.15059911f, -0.11717951f, 
    0.06968969f, -0.03645636f, 0.04252558f, 0.02646348f, -0.08869910f, -0.05417186f, 0.09024809f, 0.08583221f, 
    -0.01409794f, -0.01517866f, 0.04900707f, 0.00863741f, -0.07590302f, 0.00900391f, -0.06795238f, 0.03117514f, 
    -0.04692290f, -0.01188440f, -0.00589871f, 0.03087525f, 0.05065851f, -0.04628631f, 0.03063120f, 0.03614923f, 
    -0.03501414f, -0.06335693f, -0.00352517f, -0.06520487f, -0.05991798f, 0.05633322f, -0.03662658f, -0.06897516f, 
    0.04306119f, -0.00069607f, 0.02628268f, 0.02461075f, -0.06533351f, 0.01239783f, -0.00452512f, -0.02955380f, 
    -0.02186308f, -0.04698536f, -0.05212235f, 0.00416218f, 0.02521464f, -0.04348451f, -0.01165421f, 0.00223753f, 
    -0.04791538f, -0.00531468f, -0.06669673f, 0.05538636f, -0.03810596f, 0.06097952f, -0.07708273f, -0.00181700f, 
    -0.02316249f, -0.05786940f, -0.01748865f, -0.07689704f, 0.05228163f, -0.02148145f, -0.05510053f, -0.06336764f, 
    0.02756938f, -0.05753704f, -0.07814689f, 0.00083378f, -0.00941175f, 0.00664195f, -0.06964217f, -0.04086636f, 
    0.01885605f, 0.00213530f, -0.02446573f, -0.03886463f, 0.04449540f, -0.04173998f, 0.05820075f, -0.03116354f, 
    -0.08051287f, 0.02608193f, -0.03203381f, -0.07072173f, 0.03052825f, 0.01703525f, 0.01800089f, -0.04051135f, 
    0.05220167f, -0.00593656f, 0.02851664f, 0.05774257f, -0.05836771f, 0.05998941f, 0.04073299f, -0.01651581f, 
    -0.00926871f, -0.03825224f, 0.03204973f, -0.05817083f, -0.06256524f, -0.00370588f, -0.05267946f, -0.02265435f, 
    -0.05536931f, -0.05609047f, -0.00833052f, -0.04935527f, -0.03906148f, -0.05824019f, -0.02135763f, 0.01615320f, 
    -0.06105734f, -0.00145115f, -0.03965594f, 0.02303633f, -0.01952428f, -0.07465590f, 0.02316662f, 0.01845733f, 
    -0.06721444f, -0.03575798f, 0.03574947f, -0.05658284f, -0.07208917f, 0.01498789f, 0.04106126f, -0.01785739f, 
    0.05833907f, -0.01686457f, 0.02884389f, -0.06560084f, -0.02866012f, -0.00606800f, -0.00995429f, -0.07049314f, 
    0.03653979f, -0.05404720f, 0.02698440f, 0.04761874f, 0.03928322f, 0.06247195f, 0.02042706f, 0.02789976f, 
    0.00349716f, 0.00662405f, -0.03299873f, 0.04830083f, -0.04235631f, -0.07330436f, -0.06636074f, 0.03948657f, 
    0.05536165f, 0.02654970f, 0.01471578f, 0.01042042f, 0.01655705f, 0.03465433f, -0.02872289f, 0.01892558f, 
    -0.01557078f, 0.01168584f, -0.05384234f, -0.06525666f, -0.00107455f, 0.00049718f, 0.05731257f, 0.01756621f, 
    -0.01100335f, -0.06055145f, -0.06925160f, 0.06001770f, 0.00320284f, 0.00880334f, 0.02196246f, 0.00051411f, 
    0.02479085f, 0.04670641f, 0.03907055f, 0.05020451f, 0.00698134f, -0.06673020f, -0.07426728f, 0.02407623f, 
    -0.01788654f, 0.02253134f, 0.02654222f, 0.01949327f, -0.06458523f, 0.01223885f, 0.03963765f, -0.01400592f, 
    -0.02615821f, -0.07412419f, -0.04918820f, -0.03880557f, -0.03354691f, 0.03124463f, -0.06547355f, -0.02092838f, 
    0.12376879f, 0.03573407f, 0.26615530f, -0.14031112f, 0.08306014f, -0.11523183f, 0.05660591f, -0.06424454f, 
    -0.21337445f, -0.02011419f, -0.05089594f, 0.10003039f, -0.18930559f, -0.23567064f, -0.27572015f, -0.11001825f, 
    -0.14786692f, -0.10292064f, 0.01319316f, 0.04532131f, 0.01255861f, 0.06133905f, 0.12024906f, -0.02173371f, 
    0.03749369f, -0.11967716f, -0.08751813f, -0.10842407f, -0.02924088f, -0.14039455f, -0.03135511f, 0.19421406f, 
    -0.11247443f, -0.00229844f, -0.18005304f, 0.05545469f, 0.25880861f, 0.07827713f, 0.07053944f, 0.02493156f, 
    0.06614954f, -0.10826468f, 0.04021633f, -0.14970425f, -0.14061703f, -0.07322570f, 0.08551239f, -0.04794958f, 
    -0.25412437f, 0.18508811f, -0.21410125f, -0.02484437f, 0.02510948f, 0.04428028f, -0.07373054f, -0.17288433f, 
    0.18297590f, -0.12926796f, 0.08710809f, 0.02297840f, -0.12005094f, -0.25058532f, -0.13277754f, -0.09293467f, 
    -0.04761362f, 0.16816752f, -0.02023713f, -0.02015408f, -0.14072825f, 0.00859779f, 0.04073645f, -0.04275491f, 
    -0.11174633f, -0.06864722f, -0.10210995f, -0.19105160f, 0.05983644f, 0.06755651f, -0.05430425f, 0.03837088f, 
    -0.10361916f, -0.08475935f, -0.10703155f, -0.06745153f, 0.08226982f, 0.12255969f, 0.13701832f, 0.17709014f, 
    0.04731328f, -0.11235096f, 0.14387311f, 0.18314479f, 0.03569264f, 0.19058362f, 0.01402354f, 0.08000052f, 
    0.24216506f, -0.00599449f, -0.07525071f, 0.07086552f, -0.09438343f, -0.01633947f, -0.21149813f, 0.05005198f, 
    -0.03689361f, 0.06372552f, -0.02694436f, 0.06099518f, -0.04497020f, 0.11748741f, 0.14855604f, 0.02071833f, 
    0.03490683f, 0.16677023f, -0.03804411f, -0.01522871f, -0.01576667f, 0.04276188f, 0.15687044f, 0.01760748f, 
    0.36030081f, 0.14538874f, 0.21661600f, 0.00449158f, 0.06476337f, 0.04765199f, 0.10333122f, -0.06220737f, 
    -0.00098523f, 0.08693031f, -0.06793489f, 0.03731343f, 0.20270096f, 0.19540942f, 0.22483732f, 0.27170056f, 
    0.01200587f, -0.04067383f, -0.00174587f, 0.03702642f, -0.08935691f, -0.03041745f, 0.04404252f, 0.15002397f, 
    0.41028488f, 0.18294957f, 0.06271442f, 0.45793921f, 0.06771391f, -0.08427011f, -0.07714500f, -0.10129520f, 
    -0.26041946f, -0.01288008f, 0.00012993f, -0.00414029f, -0.03440385f, -0.06713191f, 0.04837476f, 0.02640788f, 
    0.04352349f, 0.07887475f, 0.03703771f, 0.06370389f, 0.01633819f, 0.05891968f, -0.07415935f, 0.07016683f, 
    -0.40821296f, 0.21921352f, 0.13884518f, 0.17768237f, -0.04635612f, 0.05365988f, -0.02467334f, 0.12041030f, 
    0.10893945f, 0.02632336f, 0.04129601f, 0.05903687f, 0.08452958f, -0.09117156f, 0.12574299f, -0.07199142f, 
    -0.01629424f, -0.12997356f, 0.13914540f, 0.03124349f, -0.00089584f, -0.07004964f, -0.03520722f, 0.07689010f, 
    0.19863386f, -0.12679736f, 0.23283057f, -0.05339466f, 0.10248867f, -0.08960234f, 0.12983517f, 0.09151264f, 
    0.04620182f, 0.02770873f, -0.13459429f, -0.04577702f, 0.17277558f, -0.04245055f, 0.10528839f, 0.12149505f, 
    -0.11960753f, -0.09318772f, 0.00177048f, 0.02016091f, 0.12271137f, 0.02808113f, 0.07008094f, -0.10085509f, 
    0.33954039f, -0.23332520f, 0.17330481f, -0.08790293f, 0.08892852f, -0.12751369f, 0.00832706f, -0.03965686f, 
    -0.04176238f, -0.02186773f, 0.04645721f, -0.07570955f, 0.06055436f, -0.01192402f, -0.03516418f, 0.14416465f, 
    0.05652472f, 0.23794673f, 0.04560304f, 0.05044521f, -0.02168510f, 0.13412677f, -0.00207848f, 0.02494571f, 
    -0.16291448f, 0.28682601f, 0.13166659f, -0.16235058f, -0.16526803f, -0.00414700f, -0.16385058f, -0.15129825f, 
    0.04523557f, 0.00425761f, 0.11264313f, -0.09063757f, 0.03121996f, -0.16906555f, 0.05365808f, 0.08548687f, 
    0.05566744f, 0.09489578f, -0.05753719f, 0.04634320f, -0.04147329f, -0.03153832f, -0.04387479f, 0.11544970f, 
    0.23423651f, -0.00090470f, -0.02248747f, 0.02694413f, 0.24070321f, -0.13925515f, 0.05806681f, -0.10735762f, 
    -0.03910573f, -0.11445691f, 0.14156877f, -0.01336732f, 0.20039049f, -0.08001850f, -0.14460123f, -0.05197544f, 
    0.03765333f, 0.09035920f, -0.03573157f, -0.09938069f, -0.06978887f, 0.02530995f, 0.06544344f, 0.06699749f, 
    0.16546513f, -0.08741610f, -0.11469857f, 0.04946209f, 0.03551672f, -0.04360517f, -0.06698572f, 0.17863300f, 
    -0.02810438f, 0.03129229f, -0.00877922f, 0.03364040f, -0.10454878f, 0.09117469f, 0.02540144f, -0.04924843f, 
    -0.06404824f, 0.04071513f, -0.07943921f, -0.13674723f, -0.01090558f, 0.07372561f, 0.18143402f, -0.02921146f, 
    -0.36087254f, -0.00063844f, 0.10015400f, -0.28083548f, -0.13602015f, -0.07455453f, -0.07094372f, 0.01969685f, 
    0.03603020f, -0.02339245f, 0.02156743f, 0.07729476f, -0.08658134f, 0.04578579f, 0.13090567f, -0.05113197f, 
    0.03437053f, -0.02080048f, 0.05338953f, 0.11389996f, 0.06924389f, 0.00245237f, -0.03925166f, 0.04453316f, 
    0.04499005f, 0.09792370f, 0.00854006f, -0.08780140f, 0.00647116f, 0.00772632f, 0.08561157f, -0.08137493f, 
    -0.00649499f, 0.09160418f, 0.02881892f, 0.04853721f, 0.00205755f, 0.11186948f, 0.01057092f, -0.12663274f, 
    0.03206778f, 0.18251859f, 0.00171144f, 0.15356545f, -0.02713604f, 0.09818918f, 0.05489660f, 0.05641612f, 
    -0.05272758f, -0.13184521f, 0.00509883f, 0.10356738f, -0.05153398f, -0.00282601f, 0.11643540f, -0.06029384f, 
    -0.00038149f, -0.11264981f, 0.04771211f, 0.09503753f, 0.04501658f, 0.06660497f, -0.28052896f, 0.11011273f, 
    0.02236010f, 0.01531952f, 0.12766373f, 0.07191291f, -0.14007504f, -0.00080507f, 0.06452747f, 0.00899123f, 
    -0.62240189f, 0.34458017f, 0.00608563f, -0.14749764f, 0.02395702f, -0.00318235f, -0.14207116f, 0.11575192f, 
    0.02389830f, -0.04586289f, 0.03060437f, -0.02908691f, -0.14974982f, -0.05645976f, 0.08979037f, -0.27466482f, 
    -0.00413409f, 0.02603155f, 0.05575074f, 0.09383108f, 0.02938060f, 0.02722146f, -0.00697210f, -0.05685766f, 
    -0.39865878f, -0.07192402f, 0.07378529f, 0.02457026f, 0.10661124f, 0.00521596f, 0.00269366f, 0.10121033f, 
    -0.06638367f, 0.04838958f, 0.08884795f, 0.07547688f, -0.08508372f, -0.02078792f, 0.16816494f, 0.01383055f, 
    0.04563624f, -0.03085827f, -0.04690588f, 0.00191463f, 0.04918561f, -0.07172173f, 0.18824974f, 0.09730334f, 
    0.13832156f, -0.17499167f, -0.11770961f, 0.12625264f, 0.09757902f, -0.05338690f, 0.06786196f, -0.07193549f, 
    0.17585379f, -0.02824956f, 0.03010975f, 0.04057354f, -0.43016994f, 0.04868082f, 0.03739278f, 0.05744249f, 
    -0.04187782f, 0.01604399f, 0.02107232f, 0.09125144f, 0.11417919f, 0.01242500f, 0.04962829f, -0.01886755f, 
    0.22145051f, -0.17632341f, 0.13280435f, 0.07291354f, -0.00034372f, 0.09794307f, 0.07841079f, 0.00161303f, 
    -0.00607335f, -0.08148836f, 0.09887702f, 0.25558686f, -0.36910519f, 0.02395064f, -0.09481569f, -0.09010710f, 
    -0.04181860f, 0.04823591f, -0.03635743f, -0.01135942f, 0.01163784f, 0.02505293f, -0.00447754f, 0.04843320f, 
    0.12385491f, 0.00484781f, 0.07854070f, 0.31112295f, 0.08335924f, 0.01817776f, 0.00720407f, -0.00328960f, 
    0.02903717f, 0.00645529f, 0.13576023f, 0.05264323f, -0.09957734f, 0.10198703f, 0.19302896f, 0.12167005f, 
    0.07845443f, -0.05087902f, 0.00646797f, 0.10327429f, -0.05024008f, -0.02657921f, 0.03434410f, 0.03877081f, 
    0.21024345f, 0.27319583f, -0.17316829f, 0.17814916f, 0.04872269f, 0.13991052f, -0.12737797f, -0.01968738f, 
    0.07417003f, 0.04700780f, 0.12488186f, -0.02021591f, 0.19339304f, -0.07767587f, 0.03800423f, 0.10713805f, 
    -0.04533061f, 0.19194278f, 0.05546702f, -0.04059128f, -0.12311355f, -0.06418667f, 0.04687347f, 0.01372260f, 
    -0.20521413f, 0.13275898f, -0.24155398f, -0.02189360f, -0.01187513f, -0.08805337f, 0.05218409f, -0.07688870f, 
    -0.02655405f, 0.02807049f, -0.03479623f, -0.01554556f, -0.03646635f, 0.14097786f, 0.31547073f, 0.33143744f, 
    0.05086216f, 0.03852526f, 0.14537852f, 0.03898340f, 0.01273965f, 0.00568669f, 0.00157248f, 0.07984751f, 
    -0.11992500f, 0.18518321f, -0.18400127f, -0.07774148f, -0.06222731f, 0.06781100f, 0.05794508f, 0.07744133f, 
    -0.10937304f, -0.05883332f, 0.10439122f, -0.16846277f, 0.05697189f, 0.10531351f, 0.08335697f, -0.03847283f, 
    -0.13147570f, -0.00426941f, 0.04359648f, 0.07703698f, 0.08584736f, 0.04378675f, 0.10420255f, -0.00095420f, 
    -0.42347643f, 0.07734804f, 0.10245105f, -0.01329120f, 0.06958748f, -0.01729470f, 0.01692153f, 0.11774676f, 
    0.01968111f, -0.07045820f, 0.00224557f, -0.06762595f, 0.26152655f, 0.05905135f, 0.05659412f, 0.02345133f, 
    -0.08386979f, 0.07543047f, -0.03665448f, 0.15373310f, -0.01612796f, 0.02121725f, 0.07343929f, 0.08464450f, 
    -0.11077701f, -0.04822082f, 0.13567595f, -0.08180948f, 0.07204885f, 0.07519161f, 0.05489913f, 0.09296154f, 
    -0.09883331f, 0.01451626f, 0.03404922f, -0.03651152f, 0.07185978f, 0.07757591f, 0.04519837f, -0.10788311f, 
    0.15371773f, 0.00243036f, -0.14330092f, 0.03593921f, -0.07990205f, -0.07821329f, 0.07806729f, 0.02711251f, 
    0.11050001f, -0.01901046f, 0.12537971f, -0.02284504f, -0.09693405f, -0.12208267f, 0.08539104f, 0.01689630f, 
    0.07613273f, -0.01447177f, -0.02536159f, -0.05716778f, -0.19377029f, 0.12354427f, 0.20281163f, 0.11760426f, 
    -0.14169219f, 0.07591067f, 0.05441019f, 0.05542580f, 0.12925483f, 0.08725997f, 0.06984333f, 0.06398802f, 
    0.21017827f, -0.01033935f, 0.13347745f, -0.02890155f, -0.01777348f, 0.03277401f, 0.02687098f, -0.02838448f, 
    -0.06104688f, -0.15102576f, 0.04169975f, 0.10752373f, -0.10570623f, -0.19546878f, -0.10660468f, 0.01156537f, 
    0.06709461f, 0.07930839f, -0.11315157f, -0.03527787f, 0.01332889f, -0.06074095f, 0.08237453f, 0.12473537f, 
    -0.07762742f, -0.03940282f, 0.12864296f, 0.00129060f, 0.11900190f, 0.18572120f, -0.02637838f, 0.14932203f, 
    -0.01129602f, 0.08964593f, 0.05262963f, 0.07753519f, -0.12902327f, 0.14750010f, 0.10267171f, 0.04991126f, 
    0.09452879f, -0.00997632f, 0.02000637f, 0.09138970f, 0.10017782f, 0.07046756f, 0.08925748f, 0.03466673f, 
    -0.09871248f, 0.05516917f, -0.16482168f, 0.08936922f, 0.04469221f, 0.08138932f, -0.06811857f, 0.08389954f, 
    -0.01183295f, 0.09918819f, 0.14354326f, 0.14020027f, -0.12457892f, -0.03848968f, -0.09432874f, -0.11181040f, 
    0.01643084f, 0.12104529f, -0.04228161f, 0.08652416f, -0.00979007f, 0.07104959f, 0.04340361f, 0.13773657f, 
    -0.03139091f, -0.01676319f, -0.20664638f, -0.05104319f, 0.12076011f, -0.07163099f, 0.10433168f, 0.00561666f, 
    0.13566780f, 0.07468397f, 0.02417513f, 0.07634735f, -0.02426956f, 0.19700217f, 0.09364747f, -0.04200318f, 
    -0.04575325f, 0.06753280f, 0.00328512f, 0.02916765f, -0.00336530f, -0.00633064f, 0.03975371f, 0.21142700f, 
    -0.23835240f, -0.18771882f, -0.06240552f, -0.10657120f, -0.00616081f, -0.01265693f, -0.03434508f, 0.00811632f, 
    -0.03918127f, -0.02735557f, -0.07538179f, -0.04317693f, 0.04832497f, 0.12765664f, 0.05458392f, 0.08371885f, 
    -0.01700051f, 0.04822557f, 0.14529969f, 0.04325378f, -0.00464036f, 0.07473216f, 0.11078505f, -0.10426375f, 
    -0.06751208f, 0.00716745f, 0.06165788f, -0.03389096f, -0.06098031f, 0.03048836f, 0.00692736f, -0.04832020f, 
    -0.01082294f, 0.01824317f, -0.01139038f, 0.00474115f, -0.00498012f, 0.01432539f, 0.05709254f, 0.04236014f, 
    0.03220789f, -0.05207920f, 0.06480268f, 0.00970147f, -0.03045350f, -0.05545928f, -0.00491599f, -0.02778647f, 
    -0.00210361f, -0.02382384f, -0.04001106f, -0.05459011f, -0.05102211f, 0.05498627f, 0.06581356f, -0.00015446f, 
    -0.06708895f, 0.05795357f, 0.00511250f, -0.04397460f, -0.02967632f, 0.06555691f, -0.06863947f, -0.04139632f, 
    -0.05714798f, -0.00965017f, 0.03436713f, 0.03412105f, 0.06570437f, -0.04432513f, -0.07507368f, 0.00786688f, 
    -0.03576032f, 0.04077182f, -0.01298596f, -0.06074763f, -0.01080511f, 0.01389722f, -0.06588041f, -0.04040080f, 
    -0.01268964f, -0.05113651f, -0.05806028f, -0.02165615f, 0.00122288f, -0.00033398f, 0.05000669f, -0.00433878f, 
    -0.06502354f, -0.02579691f, -0.01031822f, -0.07099658f, -0.07305426f, 0.01984992f, -0.02795435f, 0.04718515f, 
    0.04825462f, -0.06403986f, -0.03356423f, -0.07431219f, 0.02272554f, -0.06756014f, -0.02510598f, -0.02941084f, 
    -0.04659381f, -0.00596106f, -0.06635182f, -0.01762985f, 0.00696957f, -0.01037336f, -0.05700909f, -0.02898036f, 
    0.02397322f, -0.04068576f, -0.02685533f, -0.05886104f, 0.05042643f, -0.04308174f, 0.04841835f, 0.06507117f, 
    0.00649030f, 0.04784232f, -0.01727762f, 0.04064395f, -0.07571212f, -0.05611436f, -0.07435815f, -0.03965174f, 
    0.06181343f, -0.02768084f, 0.01189239f, -0.02849782f, -0.00181648f, -0.02849780f, -0.00608164f, -0.05987896f, 
    -0.02512520f, -0.05330320f, -0.01931714f, 0.04470284f, -0.05340659f, 0.01463573f, -0.00378642f, -0.06783873f, 
    -0.02087409f, -0.01227780f, -0.05874668f, -0.02483447f, 0.06630781f, -0.03125201f, 0.03417110f, 0.02084749f, 
    -0.05521611f, 0.01027187f, 0.06243806f, 0.02029473f, -0.04520392f, -0.04648330f, 0.02246251f, 0.04892553f, 
    0.00380110f, 0.03663882f, -0.02513829f, -0.01778317f, -0.03207593f, -0.06577139f, 0.02755050f, 0.06413728f, 
    0.02907212f, -0.07459543f, 0.05807178f, -0.04884546f, -0.00970175f, 0.05600078f, 0.04884906f, 0.05834974f, 
    0.02523149f, 0.06269643f, 0.04553928f, 0.04348733f, 0.02580699f, -0.04767985f, -0.04042637f, -0.05338462f, 
    -0.02306776f, -0.06823629f, 0.05704147f, 0.01559046f, -0.07212040f, -0.02136231f, 0.01638217f, -0.04393105f, 
    -0.05197642f, 0.01899586f, -0.06964334f, 0.03315509f, -0.05354433f, -0.01928620f, 0.04994037f, 0.02212601f, 
    -0.03174054f, -0.04632272f, -0.00139717f, 0.04876514f, -0.03347024f, -0.02589246f, -0.03828921f, 0.05862036f, 
    -0.00648463f, 0.03836199f, 0.02319446f, -0.04201958f, -0.05607505f, 0.03780503f, 0.04058932f, 0.02559175f, 
    -0.06374083f, -0.07123886f, -0.02762907f, -0.00431009f, 0.00481014f, 0.03803634f, 0.01548800f, 0.01912546f, 
    0.04276762f, -0.01790453f, -0.02160774f, -0.02448743f, -0.04907138f, -0.05796423f, -0.00796597f, -0.06017635f, 
    -0.02019334f, 0.03684361f, -0.03216406f, 0.05714008f, 0.05101861f, -0.06336108f, -0.01792935f, -0.07748246f, 
    0.07246272f, 0.02730286f, 0.03313286f, 0.01472271f, -0.03355024f, -0.02761835f, 0.05894975f, -0.04214862f, 
    -0.06564722f, 0.02298402f, -0.06526157f, -0.02722384f, 0.05982624f, -0.02382406f, 0.05382773f, 0.05218991f, 
    -0.01642202f, -0.05985250f, -0.00337890f, -0.00916476f, 0.05620812f, 0.06184958f, 0.01128869f, -0.05740761f, 
    -0.01165764f, -0.00402827f, -0.04947770f, -0.02193734f, 0.02701202f, -0.05579171f, -0.05816314f, 0.05045900f, 
    -0.00409949f, 0.04709581f, 0.02041434f, 0.01856493f, -0.07366047f, 0.00487076f, -0.06204565f, 0.05321737f, 
    0.03442966f, 0.04383475f, 0.01221521f, -0.07190715f, 0.03204573f, 0.02308689f, 0.01118924f, 0.00150732f, 
    -0.06448799f, 0.05443544f, -0.02935214f, -0.07102619f, -0.01246192f, -0.02475221f, 0.04608003f, -0.01137650f, 
    -0.01787383f, 0.04014065f, -0.01866500f, 0.04162857f, 0.00980983f, -0.03013556f, -0.06025181f, 0.03949521f, 
    -0.04786474f, -0.00698907f, 0.01781499f, -0.07087719f, 0.00478210f, 0.03046465f, -0.03695168f, -0.03837072f, 
    0.01946916f, 0.01349246f, -0.04316812f, -0.06825930f, -0.05360592f, -0.06406812f, 0.00630304f, 0.06312728f, 
    -0.07004900f, -0.00704036f, -0.03056915f, -0.04701760f, 0.04044586f, 0.04681433f, 0.04113898f, -0.06373986f, 
    0.01647332f, 0.03019224f, -0.01840085f, -0.03874862f, -0.03833692f, -0.00705006f, 0.04390381f, -0.05575557f, 
    0.04826443f, -0.00016341f, 0.03503016f, 0.00677374f, -0.01154647f, -0.00851249f, -0.07500214f, -0.03721995f, 
    0.03810379f, 0.00519222f, -0.00273254f, 0.02917618f, -0.07454000f, 0.04572899f, 0.02273235f, -0.02498493f, 
    0.00973191f, -0.07653917f, 0.01393426f, -0.02993573f, -0.00294237f, -0.04198342f, -0.05925781f, 0.02309594f, 
    0.00265500f, -0.06924123f, 0.03787887f, -0.00605136f, 0.03107061f, -0.00131499f, 0.00600482f, -0.06633092f, 
    -0.06856089f, 0.00102771f, -0.04946483f, -0.03014541f, -0.03236972f, -0.07285801f, -0.04731209f, -0.03073896f, 
    0.04660585f, -0.05838739f, 0.06656992f, -0.04765064f, -0.04356383f, -0.02179332f, -0.00156302f, -0.05387187f, 
    -0.03485407f, 0.05395082f, -0.06360663f, 0.00909799f, -0.01289157f, -0.02631438f, -0.00752957f, -0.08086190f, 
    -0.02244848f, 0.01155383f, -0.03389147f, 0.04141930f, 0.06197795f, 0.04008026f, -0.07272419f, 0.02022085f, 
    0.03474515f, -0.06398501f, -0.01119079f, -0.04067937f, -0.00834781f, -0.06699728f, -0.04799256f, -0.00457245f, 
    -0.54938376f, 0.06208713f, -0.20788033f, -0.05600742f, 0.09775968f, -0.03588882f, 0.02801063f, 0.07692377f, 
    -0.10384599f, 0.05490768f, -0.02553627f, 0.11491995f, 0.06784243f, 0.11097495f, -0.34546095f, -0.08067840f, 
    0.03200603f, 0.01904460f, 0.07829253f, 0.01372936f, -0.08779661f, 0.03868033f, 0.06608467f, 0.16426121f, 
    0.01392432f, 0.05492947f, -0.03741183f, -0.01465940f, 0.00435110f, 0.16204786f, -0.11469404f, 0.22393234f, 
    -0.09546962f, 0.18808541f, -0.08815727f, 0.13457495f, 0.20326723f, 0.24576329f, 0.04870048f, -0.21149500f, 
    0.05504559f, -0.10737126f, -0.05520409f, -0.06213102f, -0.02289596f, -0.07362358f, 0.15799013f, -0.00809342f, 
    -0.24552372f, -0.09947211f, 0.01157160f, 0.15349717f, -0.07137828f, 0.02906222f, 0.12768300f, 0.05081927f, 
    0.03811002f, 0.11011961f, 0.00156799f, 0.17840824f, -0.05922185f, 0.11517753f, -0.01017866f, 0.07897821f, 
    0.00382715f, 0.03564550f, 0.01083728f, 0.07420037f, 0.11088951f, 0.10073316f, 0.05735849f, 0.03320961f, 
    -0.11101212f, 0.17734793f, 0.06582449f, -0.20500286f, -0.11434656f, 0.04177654f, 0.03297833f, 0.04166282f, 
    0.01569415f, 0.02891065f, -0.06710204f, -0.02264018f, -0.39766747f, -0.07987548f, 0.03910957f, 0.07962497f, 
    -0.05600660f, -0.00673247f, 0.00226501f, 0.00112893f, 0.06129233f, 0.07102992f, 0.07774904f, 0.01770402f, 
    -0.13182512f, 0.04507544f, 0.13775697f, -0.02372928f, 0.03931750f, 0.12407982f, -0.03319005f, -0.07457581f, 
    0.10633772f, 0.00282231f, -0.08329836f, 0.07665441f, -0.10484666f, 0.00454326f, 0.05996175f, 0.04487070f, 
    0.11602146f, -0.05477944f, 0.10380182f, 0.15688968f, 0.07404993f, -0.01568235f, 0.06260914f, 0.02594618f, 
    -0.00570241f, -0.05396532f, -0.05435342f, 0.18815054f, 0.05452764f, 0.15750347f, 0.06302395f, 0.06955320f, 
    -0.00550005f, 0.00325991f, -0.08474198f, 0.02621525f, -0.03320208f, -0.21252058f, -0.05194869f, -0.00835963f, 
    -0.07002611f, -0.00118293f, -0.07296029f, 0.02085481f, 0.07465238f, -0.09337760f, 0.07627290f, 0.00254691f, 
    -0.14646843f, 0.02497803f, 0.02858672f, -0.00470868f, 0.02213809f, -0.00720949f, -0.04453378f, -0.02150116f, 
    0.12747282f, -0.01324546f, -0.14107034f, 0.00413255f, -0.00521691f, 0.01122277f, -0.05739774f, 0.04129930f, 
    -0.12030119f, 0.02864220f, 0.04291599f, -0.06422106f, -0.03274006f, 0.00380590f, 0.07732108f, 0.09229724f, 
    -0.33965895f, -0.01799771f, -0.02834499f, 0.08355082f, 0.09133540f, -0.04386590f, -0.02230438f, 0.06825943f, 
    0.03386715f, 0.15442148f, 0.02103494f, -0.03457062f, 0.05502085f, -0.23868063f, 0.31622022f, 0.05826375f, 
    -0.03501603f, 0.20365091f, -0.06629522f, -0.04042976f, 0.17056046f, 0.08335900f, -0.07885527f, -0.00609498f, 
    0.41685742f, -0.27263245f, -0.01906416f, 0.18342142f, 0.03427876f, 0.04908710f, 0.01956721f, -0.04222584f, 
    0.01604598f, 0.08202143f, 0.10963207f, -0.03497216f, -0.04075828f, -0.22012806f, -0.22773148f, 0.01477983f, 
    0.04806345f, -0.06942561f, -0.04988161f, -0.07569622f, -0.10532804f, 0.11053061f, -0.00106288f, 0.10273198f, 
    0.02931068f, 0.04081010f, -0.00456412f, 0.01455199f, -0.05701391f, 0.04112592f, -0.07407854f, -0.01538809f, 
    0.03895293f, -0.11864372f, -0.07932301f, 0.06589302f, 0.03268699f, -0.16416302f, -0.06437531f, 0.12139623f, 
    -0.07613094f, 0.08993376f, 0.09183978f, 0.11808020f, 0.09167048f, -0.00942894f, 0.10381901f, -0.19111091f, 
    -0.12184276f, 0.14381330f, 0.08667058f, 0.05461813f, 0.00342728f, 0.03315809f, 0.06803279f, -0.07446980f, 
    -0.00356967f, -0.02829826f, -0.00726881f, 0.17924173f, 0.00875020f, 0.04895251f, -0.17035711f, -0.12149193f, 
    0.03147510f, 0.13044511f, 0.02996748f, -0.00160858f, -0.01248709f, -0.00638748f, 0.01983792f, 0.09460546f, 
    -0.09573550f, 0.00158265f, -0.06699524f, 0.05021365f, 0.03286872f, -0.00600283f, 0.00508364f, 0.00468129f, 
    0.04714656f, 0.05197573f, -0.16184728f, -0.03444796f, 0.39594427f, -0.01415240f, -0.04781023f, -0.13785726f, 
    -0.05557673f, -0.06238808f, 0.00554470f, 0.16208948f, 0.04043996f, -0.06771438f, 0.11281735f, -0.04972724f, 
    0.07915664f, -0.21904504f, 0.08463056f, -0.12419108f, -0.00930783f, 0.04510346f, 0.03107748f, 0.01672556f, 
    0.03680238f, -0.00477768f, -0.14590491f, 0.10602605f, 0.34669939f, 0.13812496f, -0.16529943f, -0.00504101f, 
    -0.00745590f, 0.04606660f, -0.09276338f, 0.08777697f, -0.01698796f, 0.01788481f, 0.05351287f, -0.06855480f, 
    0.34519511f, -0.18419556f, -0.08905060f, -0.22259507f, -0.15892707f, -0.06510632f, 0.14704850f, -0.04962150f, 
    0.02534444f, 0.01732747f, -0.08357646f, 0.05588608f, 0.01381733f, 0.13937551f, 0.07038611f, 0.12292129f, 
    -0.09159717f, -0.06359581f, -0.00399515f, -0.07372497f, 0.05450839f, 0.03215766f, -0.04025005f, 0.06718437f, 
    0.54779482f, -0.30388987f, 0.11613408f, 0.06924770f, -0.16240181f, 0.02861205f, -0.01026007f, 0.07594867f, 
    0.01407473f, 0.00177115f, 0.14228745f, 0.07323202f, 0.11648180f, 0.16671650f, -0.19772668f, -0.08653013f, 
    0.15814503f, 0.15549158f, -0.04034188f, 0.15548828f, -0.01775618f, 0.00082270f, 0.04584457f, -0.05920450f, 
    0.20317259f, -0.10759040f, -0.11033765f, -0.05907532f, -0.05820507f, -0.06253975f, -0.03081925f, 0.08687682f, 
    0.08600893f, 0.03046613f, -0.09598272f, 0.02724292f, -0.19205293f, 0.12603202f, -0.00704013f, 0.09951240f, 
    0.12948769f, -0.06171988f, 0.02114910f, 0.06919383f, -0.08869534f, -0.05918191f, -0.07316653f, 0.04179870f, 
    -0.19383503f, -0.07600164f, 0.32102942f, -0.29172698f, -0.07577421f, -0.10606673f, 0.08304051f, 0.01004548f, 
    -0.07424439f, 0.02181361f, -0.03496116f, 0.00230127f, 0.09088244f, -0.21015744f, -0.18452547f, -0.26691321f, 
    -0.03846125f, -0.02781911f, 0.12262459f, 0.00321296f, 0.08645626f, 0.05364884f, 0.01542452f, 0.09511879f, 
    -0.11676162f, -0.19197974f, 0.05330139f, 0.01216331f, -0.06307283f, -0.05960055f, -0.01499137f, -0.02983952f, 
    -0.01338845f, 0.05843160f, -0.01141030f, -0.01534959f, 0.04195956f, -0.00859569f, 0.00799685f, -0.10974424f, 
    0.12381358f, -0.07657719f, -0.16418988f, -0.03812542f, -0.04972797f, -0.12628767f, 0.14141890f, -0.12080609f, 
    -0.22480410f, 0.08802349f, -0.13467178f, 0.15612474f, -0.06161999f, 0.11711015f, 0.20249806f, -0.03645009f, 
    0.00413083f, -0.06009874f, 0.02104292f, 0.06216070f, -0.38193771f, 0.12064485f, -0.18109602f, 0.01982883f, 
    0.02623088f, -0.03856638f, -0.03652067f, -0.02618598f, -0.03593807f, 0.03435469f, 0.08825633f, 0.15027501f, 
    0.05343173f, -0.07911316f, 0.06580699f, -0.05627955f, 0.13117826f, 0.05099186f, -0.07752107f, -0.05493890f, 
    -0.01204602f, -0.02981806f, 0.00462497f, -0.11272585f, -0.23931082f, -0.16448449f, 0.08759350f, 0.09116948f, 
    -0.17968220f, -0.10246163f, 0.12603520f, 0.08200829f, 0.13740590f, 0.10536980f, 0.11081061f, 0.17784567f, 
    0.23413414f, -0.14309883f, -0.16335706f, 0.17508514f, 0.10251218f, 0.09973218f, -0.19526549f, -0.05476670f, 
    0.05793483f, 0.02437417f, -0.01427701f, 0.09946626f, -0.05626532f, 0.32298568f, 0.12135936f, 0.11452773f, 
    0.11940053f, 0.04753825f, 0.08755837f, -0.00938798f, 0.18276803f, 0.07182523f, 0.11100245f, -0.02666201f, 
    0.28357065f, 0.31260148f, 0.07764219f, 0.03809918f, -0.04182781f, 0.11079988f, 0.08607401f, 0.05517103f, 
    -0.00697336f, -0.07884428f, -0.00776978f, -0.04070061f, 0.06619082f, -0.01997403f, 0.05096540f, -0.02138772f, 
    -0.03529039f, -0.02350578f, -0.04045337f, 0.03874589f, -0.01506418f, -0.00221031f, 0.11415844f, 0.15600538f, 
    0.15655659f, 0.26095578f, 0.03244748f, -0.02194791f, -0.03317893f, -0.05115638f, 0.14926530f, -0.07405173f, 
    -0.08517102f, -0.07042029f, 0.00766273f, -0.07392565f, -0.20108643f, -0.02558676f, 0.15419874f, 0.08989011f, 
    0.06376640f, 0.13208129f, 0.09068330f, -0.02375861f, 0.01343202f, 0.14952825f, -0.10164146f, 0.04859231f, 
    -0.14806555f, 0.08143802f, 0.00301020f, 0.09325234f, 0.00475678f, 0.06960458f, -0.06475683f, -0.02646723f, 
    -0.02430777f, 0.03929416f, 0.04532347f, -0.03291379f, -0.23826265f, -0.06073848f, 0.04228510f, -0.02264684f, 
    0.15251257f, -0.00283981f, 0.03257277f, -0.15704434f, 0.17115422f, 0.07006257f, -0.11319099f, -0.00776572f, 
    0.34368968f, 0.13165526f, -0.11258838f, -0.07960676f, 0.03307213f, -0.09972330f, 0.02338132f, -0.01005272f, 
    -0.03386953f, 0.14136119f, -0.11998745f, 0.02224771f, -0.17865156f, 0.20534508f, 0.03881362f, 0.00798745f, 
    0.08784793f, -0.24861893f, 0.07816813f, -0.12812769f, -0.03046823f, 0.09670699f, 0.07943807f, -0.02605693f, 
    0.13523513f, -0.01423255f, -0.12966010f, 0.02959645f, 0.06066419f, -0.02794199f, 0.05136572f, 0.14426151f, 
    0.08596870f, -0.12871413f, -0.10041932f, 0.09829548f, -0.03456286f, 0.16060399f, -0.00482095f, -0.06501076f, 
    -0.03894616f, -0.21153644f, 0.09164720f, -0.17338359f, 0.11282397f, -0.14963536f, 0.09717019f, 0.08242372f, 
    -0.01444978f, -0.02329938f, 0.01675130f, 0.09638786f, 0.07372408f, 0.16274814f, 0.07652672f, -0.11359140f, 
    0.02038867f, 0.09436157f, 0.10783834f, 0.01176238f, 0.13148315f, -0.27990589f, 0.00712553f, 0.04178370f, 
    0.17252865f, 0.00029327f, -0.06641653f, -0.03982400f, -0.03662513f, -0.04473407f, -0.01176887f, 0.03752331f, 
    -0.15759701f, 0.13660170f, 0.03217930f, 0.07685722f, 0.03170137f, 0.04595956f, -0.00459405f, -0.03065192f, 
    -0.03896686f, 0.17182353f, -0.20030244f, 0.08638848f, -0.13321635f, 0.20597690f, 0.10456376f, 0.18625624f, 
    0.01788760f, 0.15410836f, 0.17267527f, 0.16316210f, -0.08275704f, 0.04723941f, 0.01349940f, 0.14082412f, 
    -0.22209129f, 0.24994215f, 0.18773161f, -0.21296178f, -0.04873711f, -0.02036704f, -0.07550963f, -0.10618974f, 
    -0.08386545f, 0.00353514f, -0.05609671f, 0.01778772f, -0.19027294f, -0.30358109f, 0.16603866f, -0.05457185f, 
    0.02883754f, -0.11579661f, -0.03336181f, -0.06274950f, 0.03684729f, 0.05798444f, 0.13197118f, -0.01878064f, 
    -0.10677329f, -0.12395602f, 0.15426162f, 0.11371344f, 0.11396673f, 0.07212550f, -0.07895312f, -0.04038837f, 
    -0.06690838f, 0.07774188f, -0.19837297f, -0.09095189f, 0.06160127f, 0.13577785f, -0.11465317f, 0.15711848f, 
    -0.08244462f, 0.07020285f, 0.03300950f, 0.13787642f, -0.04581758f, 0.08268803f, 0.20741834f, 0.07738970f, 
    -0.08861230f, 0.10565839f, 0.10828397f, 0.01395885f, 0.17264402f, -0.00063367f, -0.09552265f, -0.12040230f, 
    -0.03149157f, -0.28300264f, -0.10201294f, -0.06825884f, 0.17294365f, -0.25432625f, -0.16205370f, 0.05441877f, 
    0.06344687f, -0.24105909f, -0.16846414f, -0.10126161f, -0.03955309f, -0.19962266f, 0.07558028f, -0.10132100f, 
    0.32762897f, 0.25608298f, 0.17093541f, -0.03731302f, 0.01592838f, 0.03690085f, 0.05017995f, 0.07015812f, 
    -0.01920170f, 0.03348282f, -0.02501157f, 0.12141929f, 0.25237337f, -0.00080517f, 0.25042301f, -0.18065514f, 
    -0.00835063f, 0.15478003f, -0.03315327f, -0.12070525f, 0.10309610f, -0.03465081f, 0.03901114f, 0.07507268f, 
    0.16795607f, -0.05050399f, 0.02964877f, -0.13204622f, 0.08699115f, 0.00422299f, 0.03870835f, -0.04332132f, 
    0.03019774f, 0.03053749f, -0.08491493f, 0.12550598f, -0.06229825f, -0.08345507f, -0.11936178f, -0.00202963f, 
    0.10770488f, -0.00260920f, 0.17917435f, 0.01416095f, -0.07964814f, 0.08032020f, 0.04228943f, 0.09464923f, 
    -0.06526354f, -0.01309346f, -0.00672772f, -0.03256884f, -0.08531632f, 0.00586727f, -0.07531711f, 0.08982969f, 
    0.07151149f, 0.06381942f, -0.04515809f, 0.05335787f, -0.01514692f, 0.03093571f, -0.01413251f, 0.07405641f, 
    -0.04895682f, 0.02701914f, 0.18624301f, -0.02453658f, 0.02984474f, -0.12558340f, 0.07695202f, 0.00242841f, 
    -0.04552320f, 0.25008729f, -0.03989159f, 0.19741859f, 0.06976335f, 0.10895027f, 0.04041915f, 0.09872518f, 
    -0.05136545f, 0.07248749f, -0.00558102f, 0.02362755f, 0.23205522f, -0.06318755f, -0.07726159f, -0.00899294f, 
    0.08804580f, -0.06162247f, -0.03240121f, 0.00008334f, -0.03955665f, -0.03620467f, 0.05949885f, 0.06918935f, 
    -0.09657856f, 0.19315632f, -0.15782380f, -0.19099976f, -0.06511053f, 0.11673902f, -0.01431796f, 0.04027399f, 
    0.11193620f, 0.08585242f, -0.15385456f, -0.04032236f, -0.22791120f, 0.02435329f, 0.14870207f, 0.14934519f, 
    -0.03102036f, 0.03396402f, 0.16346127f, 0.08446522f, -0.00625863f, 0.06826828f, 0.06885680f, 0.08645938f, 
    0.03311855f, 0.18939084f, -0.00343671f, -0.06175829f, -0.07957280f, 0.05814014f, -0.04010281f, -0.07087123f, 
    -0.02889804f, -0.05002729f, -0.06518088f, 0.00202689f, -0.13216612f, -0.12697694f, -0.01397165f, 0.03078137f, 
    0.11141184f, 0.00995019f, 0.15291208f, 0.00516956f, 0.05000817f, 0.04094353f, 0.00924836f, -0.03772710f, 
    -0.01156552f, -0.04032614f, 0.05199438f, 0.00178536f, -0.02784933f, -0.00296598f, 0.08786696f, -0.07494494f, 
    0.09210778f, 0.05261324f, -0.18519682f, -0.04379212f, -0.13377950f, 0.12760936f, -0.08317558f, 0.01316649f, 
    -0.03269702f, -0.00975856f, 0.08227858f, -0.04165999f, -0.02922813f, 0.02173195f, 0.10885841f, 0.17080885f, 
    -0.06273028f, 0.07673276f, -0.00887058f, 0.03153701f, 0.07939476f, 0.06993721f, 0.04592293f, -0.01778619f, 
    -0.05187306f, -0.05059281f, 0.03273352f, -0.09602031f, 0.00836464f, -0.12973152f, -0.14248905f, -0.02131320f, 
    0.01044026f, -0.09310150f, -0.13388829f, -0.10118343f, 0.02693250f, -0.06520131f, -0.05948460f, -0.07755663f, 
    0.28831956f, 0.10454787f, 0.18879832f, 0.04603651f, -0.02826776f, 0.10762304f, 0.03392646f, -0.04356776f, 
    -0.01338333f, 0.09012023f, -0.01020220f, 0.03142529f, 0.16374204f, -0.00996337f, 0.17523649f, -0.10253874f, 
    0.00255313f, 0.07524858f, -0.20844410f, -0.03560114f, 0.11242151f, 0.09912626f, 0.01396315f, 0.00553097f, 
    -0.06924538f, -0.05499056f, -0.03804107f, -0.06647050f, 0.03151385f, 0.02230289f, 0.03336168f, -0.04743801f, 
    0.00850003f, 0.05688587f, -0.02766069f, -0.03894099f, -0.00298265f, 0.05842752f, -0.07905244f, -0.03160126f, 
    -0.07949228f, -0.06373730f, -0.06902342f, 0.06177419f, 0.01464539f, 0.01727449f, 0.01278020f, -0.03449852f, 
    -0.04920166f, -0.05185709f, -0.07599888f, 0.02267889f, 0.02811528f, 0.02225388f, 0.02439747f, -0.01834293f, 
    0.03428106f, 0.02868138f, -0.02006842f, -0.02204836f, 0.00732918f, -0.04049917f, 0.04902916f, 0.06103226f, 
    -0.06710394f, 0.04680539f, 0.02899017f, -0.02794775f, -0.06843457f, -0.04706597f, 0.01350564f, -0.03496814f, 
    -0.05494880f, -0.00537336f, -0.00195031f, -0.03361065f, 0.03346983f, 0.00800172f, -0.02096348f, -0.00595897f, 
    -0.04811509f, -0.03141915f, -0.05925919f, 0.00731297f, -0.05938298f, -0.04626388f, -0.06297062f, 0.02793729f, 
    -0.01500848f, 0.02530443f, 0.00166746f, -0.01242482f, -0.00736114f, 0.01250057f, 0.05313344f, 0.00576546f, 
    -0.02282007f, -0.02107260f, 0.04326358f, -0.05844415f, 0.01816569f, 0.05765964f, 0.02234318f, -0.06472126f, 
    -0.04701579f, 0.04264881f, -0.05636520f, 0.04722096f, -0.01134445f, -0.04016134f, -0.03577132f, -0.05701486f, 
    -0.05097624f, 0.00229312f, -0.00754628f, -0.07137961f, 0.00667519f, 0.00127734f, -0.05042435f, -0.00453642f, 
    -0.06762577f, -0.05195278f, -0.06788884f, 0.04930841f, -0.03359234f, -0.03333673f, 0.05579112f, -0.05917462f, 
    0.01174943f, -0.01222917f, 0.02830146f, 0.03615155f, -0.00096872f, 0.03839206f, 0.02389120f, 0.05926920f, 
    0.03114670f, -0.05574378f, -0.03411433f, -0.01371205f, 0.00448711f, 0.01479304f, -0.00561720f, 0.00716903f, 
    -0.00855021f, -0.07031059f, -0.03150587f, 0.00308603f, -0.05962316f, 0.04846943f, -0.03214674f, -0.04761837f, 
    -0.00316298f, -0.00233658f, 0.01869477f, -0.03817239f, 0.01668802f, -0.06754746f, 0.03152652f, 0.01416036f, 
    0.02878491f, 0.00838955f, 0.02131517f, -0.00400467f, -0.06652684f, -0.00157166f, 0.05155386f, 0.01353141f, 
    0.01023220f, -0.01331290f, -0.05068840f, 0.05660126f, -0.00297715f, -0.05656585f, -0.04546110f, 0.01087079f, 
    -0.02710324f, 0.02304342f, -0.05732547f, -0.01062093f, 0.04359612f, -0.06037504f, -0.04040490f, -0.06199820f, 
    -0.01506416f, -0.01966435f, -0.03039286f, 0.03730223f, -0.00305917f, 0.03540145f, 0.02028110f, 0.03299274f, 
    0.01047346f, 0.04704795f, -0.02714438f, 0.05705903f, -0.00945762f, 0.04765785f, 0.05424038f, 0.04814284f, 
    -0.00534466f, 0.00310100f, 0.01955880f, 0.05889799f, -0.01455058f, -0.07740844f, 0.03493205f, 0.00895205f, 
    -0.00326745f, 0.03309291f, 0.04014874f, -0.05134980f, 0.00979064f, -0.07562492f, -0.06761352f, -0.04069167f, 
    0.05848227f, -0.05941210f, -0.02313715f, -0.04122014f, 0.00297984f, -0.02630157f, -0.01095852f, -0.03000845f, 
    0.03429605f, 0.00442768f, 0.04443810f, 0.04491284f, -0.02038739f, -0.07121367f, 0.00041783f, -0.05707570f, 
    -0.02425812f, 0.04322063f, 0.01416587f, -0.07395482f, -0.06096511f, 0.00411176f, -0.03687644f, -0.01947204f, 
    -0.05744090f, -0.00233132f, 0.00878286f, 0.02680283f, -0.05756179f, 0.00029765f, -0.03349520f, -0.01884046f, 
    -0.06384177f, -0.07509468f, 0.01642003f, -0.03200026f, -0.03068020f, 0.04233715f, -0.00443263f, 0.05326458f, 
    -0.03938285f, -0.03485041f, 0.03660703f, -0.01806245f, 0.06715593f, -0.04425510f, -0.00040000f, 0.01053562f, 
    -0.05447052f, 0.01465049f, -0.07551001f, 0.02256961f, -0.04657174f, 0.06990841f, 0.02204449f, -0.00426258f, 
    0.04549404f, 0.00234959f, 0.01491973f, -0.04565571f, 0.03184835f, -0.05453627f, -0.01843611f, -0.01559099f, 
    0.03232555f, 0.01693752f, 0.01455787f, -0.06214822f, -0.03811871f, -0.05242554f, -0.06577013f, 0.00482765f, 
    0.01029688f, 0.02151190f, -0.03221775f, -0.03628330f, 0.04799087f, -0.06407444f, -0.00299392f, 0.05183487f, 
    0.05407017f, -0.00094639f, 0.02040343f, 0.02360563f, 0.00981455f, 0.03166680f, 0.01812536f, -0.02692349f, 
    -0.01287318f, 0.03189415f, -0.02874057f, -0.04388350f, -0.06313940f, -0.04431588f, 0.02419867f, -0.01807489f, 
    0.02518814f, 0.00201996f, -0.01707581f, -0.04226238f, -0.03951692f, 0.01762434f, 0.04145287f, -0.00730963f, 
    -0.06322830f, 0.02111808f, -0.06632024f, -0.05275683f, 0.01559473f, -0.01065391f, 0.07249004f, 0.03592045f, 
    0.01151432f, 0.05284976f, 0.04798180f, -0.02357919f, 0.02769893f, -0.06761627f, -0.01948711f, 0.04367642f, 
    -0.00305538f, 0.00462624f, -0.06511051f, -0.04279263f, 0.04962901f, -0.06925855f, -0.05536700f, -0.04646986f, 
    0.01481217f, -0.00976325f, 0.05899190f, -0.00899265f, -0.05591704f, -0.07275048f, -0.01791409f, -0.02323208f, 
    -0.02710790f, -0.04333754f, -0.06580826f, 0.03606971f, -0.06183375f, 0.00614248f, 0.00724191f, -0.07106311f, 
    -0.02940621f, -0.03686332f, 0.02895223f, 0.05662297f, 0.05657122f, -0.02771947f, 0.02962629f, -0.02784157f, 
    -0.02845374f, 0.03978143f, -0.05300513f, -0.06025163f, -0.05195249f, 0.05671882f, -0.00359884f, -0.00810363f, 
    0.02269752f, 0.01977810f, -0.05817441f, 0.05905378f, 0.04731050f, 0.03523524f, -0.01778822f, 0.01934930f, 
    -0.01760045f, -0.06755351f, -0.03701898f, 0.01864734f, 0.04936005f, -0.04759505f, 0.04386884f, -0.01134914f, 
    -0.00862505f, -0.02266196f, 0.00007937f, 0.03661442f, 0.04676108f, -0.04387663f, 0.05316319f, 0.00622696f, 
    0.00979424f, -0.03313540f, 0.06398151f, -0.00286173f, -0.06916149f, 0.04993404f, -0.01489260f, -0.04970533f, 
    -0.09784317f, 0.01616227f, -0.15614662f, 0.17129865f, -0.10104740f, 0.08498022f, -0.06221365f, 0.00131254f, 
    0.07067249f, -0.17360426f, 0.10375796f, -0.06066252f, 0.20144594f, 0.30014434f, 0.26836750f, 0.06849536f, 
    -0.00561684f, 0.02504792f, -0.14030135f, 0.08756386f, -0.03142014f, -0.01463965f, 0.00085610f, -0.04781125f, 
    0.09859700f, 0.15381673f, -0.08232099f, 0.00424015f, 0.08399461f, 0.06801779f, 0.00190548f, 0.02592300f, 
    -0.17479053f, 0.03183934f, 0.12663066f, -0.05324689f, -0.13895218f, 0.03960172f, -0.18808372f, -0.18992330f, 
    -0.01907879f, -0.02015117f, 0.01610428f, 0.08919384f, 0.01915498f, 0.02624732f, -0.07858416f, 0.06702939f, 
    0.21448563f, -0.15889971f, 0.09295788f, -0.09582411f, 0.04443435f, -0.06472979f, 0.06743705f, -0.01306525f, 
    -0.08944945f, -0.11520708f, -0.01719297f, -0.06498221f, 0.32563898f, 0.24581717f, 0.09111638f, 0.14467531f, 
    -0.04778583f, -0.02789495f, 0.17188914f, 0.02039245f, 0.10039783f, 0.07093397f, -0.01835174f, -0.08167722f, 
    -0.07085451f, -0.01494618f, 0.11321574f, 0.14534958f, -0.13920431f, -0.03607440f, -0.07962078f, -0.03263368f, 
    -0.11226064f, -0.02815830f, 0.15452674f, -0.01104513f, 0.17612307f, 0.03385553f, -0.01208732f, 0.07055657f, 
    0.04515263f, 0.04825485f, -0.04406961f, 0.02883718f, 0.02262832f, 0.02112685f, -0.07432143f, -0.09962957f, 
    -0.31635091f, 0.01659516f, 0.04142499f, -0.16831502f, 0.08655339f, 0.03465120f, 0.10038924f, -0.03791996f, 
    -0.02823226f, -0.03025751f, 0.11136495f, -0.06728265f, 0.14397101f, -0.06014634f, -0.14374785f, 0.02111338f, 
    -0.06634305f, 0.06357093f, 0.04915663f, 0.04910953f, 0.05792094f, -0.07882090f, -0.09619728f, 0.01448435f, 
    -0.10979023f, -0.09423293f, 0.00442558f, 0.10035855f, 0.10063224f, 0.04520439f, -0.02310702f, 0.09979311f, 
    0.03442626f, 0.02508549f, 0.08298377f, 0.04102105f, -0.08163569f, -0.17765573f, -0.02773263f, -0.05138703f, 
    0.10434679f, -0.00187802f, 0.06044333f, 0.07826489f, 0.13050890f, -0.04028388f, -0.05012649f, 0.00961817f, 
    -0.16751227f, -0.07216419f, 0.06487482f, 0.01285764f, 0.01126075f, -0.04697127f, 0.01573476f, 0.07697754f, 
    0.14577515f, 0.05453329f, -0.00743824f, 0.11744563f, 0.09113664f, 0.09841570f, -0.07539887f, 0.03329714f, 
    0.14467780f, -0.06001807f, 0.04432540f, 0.01108121f, 0.01074183f, 0.04667316f, 0.00524549f, 0.18352769f, 
    0.09956339f, -0.09860752f, 0.03816752f, -0.06207052f, 0.08777476f, -0.09320091f, 0.08596964f, 0.11298008f, 
    -0.06329977f, 0.01519048f, 0.01043012f, -0.03016656f, -0.12740368f, 0.06844272f, -0.13206886f, -0.09917668f, 
    0.00631166f, 0.04595144f, 0.11411423f, 0.02699447f, -0.07029366f, -0.08152727f, -0.00822778f, 0.01947049f, 
    0.08762846f, 0.08682846f, 0.09551769f, -0.12367942f, -0.10633010f, -0.08755305f, -0.10682374f, 0.09402569f, 
    -0.08259478f, 0.07103581f, -0.01205904f, 0.06972042f, 0.31464803f, 0.23946868f, 0.04071567f, -0.11605769f, 
    -0.17787318f, 0.04507880f, 0.02374195f, 0.11659235f, 0.05095337f, 0.01446798f, 0.06626026f, 0.09045666f, 
    -0.00113017f, 0.07195638f, -0.12487547f, 0.02051561f, -0.00551952f, -0.01471500f, -0.04538889f, 0.16067673f, 
    0.01944122f, 0.02564335f, -0.09985855f, 0.01878345f, -0.03370726f, 0.08292119f, -0.02916792f, -0.22335994f, 
    0.05656983f, -0.14452642f, -0.13005839f, -0.07428094f, -0.02316140f, -0.11962824f, -0.02950946f, -0.04892061f, 
    0.01270144f, -0.20250669f, 0.05760949f, -0.00828583f, -0.09484089f, -0.10657817f, 0.14886314f, 0.09051788f, 
    -0.15227038f, -0.06125537f, 0.01839570f, 0.07534914f, -0.22408865f, 0.08459927f, 0.13003013f, 0.19324684f, 
    -0.04845093f, 0.10478799f, 0.04415607f, -0.01641999f, 0.07753976f, 0.14025615f, 0.01223758f, 0.09400833f, 
    0.01747226f, 0.01802632f, 0.25493729f, -0.15022707f, -0.21612920f, 0.01574948f, -0.05708298f, -0.01550954f, 
    0.01247224f, 0.01629881f, 0.00531689f, -0.02804310f, -0.11906762f, -0.20761938f, 0.03993187f, 0.02107081f, 
    0.07866333f, -0.05690543f, 0.01401540f, 0.02168036f, 0.04561714f, -0.11737179f, -0.03606167f, -0.06110225f, 
    -0.13590753f, -0.10880134f, 0.02755591f, 0.10168677f, 0.04372254f, -0.05130719f, -0.02023727f, -0.11163761f, 
    -0.04158276f, -0.05809049f, 0.00265398f, -0.08799507f, 0.04746287f, -0.03239768f, 0.09863436f, -0.04446841f, 
    -0.05850497f, 0.08465037f, 0.06645032f, 0.06593667f, 0.06471212f, 0.05029613f, -0.10354009f, -0.05220108f, 
    0.03688112f, 0.15729474f, 0.06215443f, 0.16565664f, 0.20637107f, 0.15247293f, 0.03140106f, 0.11490572f, 
    -0.03243565f, -0.02372104f, 0.11438620f, 0.02942545f, 0.15309919f, -0.24481453f, 0.09171867f, 0.06890651f, 
    0.07194259f, 0.01364265f, 0.03174417f, 0.07486703f, 0.10214227f, -0.01393133f, -0.05026893f, 0.01782865f, 
    -0.12905152f, 0.10487735f, 0.05899610f, 0.03847012f, 0.04116732f, 0.02246472f, 0.06727954f, 0.05090766f, 
    0.15675457f, 0.02956673f, -0.08206392f, 0.09126403f, 0.19722317f, -0.03404713f, 0.24634276f, 0.11832125f, 
    -0.09299004f, -0.01277249f, 0.05621348f, -0.12291536f, -0.04614738f, -0.00254201f, 0.04979949f, 0.10125218f, 
    -0.44246435f, 0.01683044f, -0.01531902f, 0.07871999f, -0.00480673f, -0.07639511f, 0.04534957f, 0.04055585f, 
    -0.00119166f, 0.14017352f, 0.08785003f, -0.16631958f, -0.30065432f, -0.24301946f, 0.13032153f, 0.18335211f, 
    -0.04578190f, -0.01838042f, -0.00877877f, -0.03651850f, -0.00018889f, 0.10215593f, 0.05967095f, -0.12004717f, 
    -0.08332302f, 0.17313614f, -0.06667462f, -0.13335919f, 0.06243247f, 0.02076609f, 0.08128288f, -0.06579103f, 
    -0.07796970f, -0.00705293f, 0.10800999f, -0.03457966f, -0.04753769f, -0.02340927f, -0.11378433f, -0.07820807f, 
    0.06507683f, 0.14869083f, 0.10659120f, 0.02037971f, -0.07528211f, 0.13922444f, 0.05436938f, 0.08346111f, 
    -0.09216123f, -0.02418147f, 0.02792946f, -0.01276562f, -0.00153269f, 0.01162771f, -0.07819021f, 0.11043243f, 
    0.01926965f, -0.03677314f, -0.02998942f, 0.09979489f, 0.01816839f, 0.01436752f, -0.02628725f, 0.05968077f, 
    0.07365968f, -0.19139495f, 0.04064726f, -0.12194750f, -0.04667414f, -0.04160799f, -0.00098798f, -0.17390124f, 
    0.16575959f, 0.26390997f, -0.07603896f, 0.05842530f, -0.09329236f, 0.15239951f, 0.16555351f, 0.09771132f, 
    -0.05735149f, 0.09800413f, 0.02359273f, 0.01186623f, 0.12304931f, 0.04225601f, 0.21430530f, -0.03104454f, 
    0.01625135f, -0.04693102f, -0.08077656f, -0.00246317f, -0.04658658f, 0.00613181f, 0.01578847f, 0.05999874f, 
    -0.03708367f, 0.15188284f, -0.00394132f, -0.18923274f, -0.01242598f, 0.05170007f, 0.02873200f, 0.01715048f, 
    -0.03522786f, 0.04218613f, -0.16091169f, -0.08242282f, -0.33086663f, -0.04766865f, 0.08550411f, 0.14495866f, 
    0.11724661f, 0.05745851f, 0.03447524f, 0.03535659f, 0.05147861f, 0.10112597f, 0.10725921f, 0.13895467f, 
    -0.02398611f, 0.01295965f, 0.14669527f, 0.17947778f, 0.01398469f, 0.06115245f, -0.06634462f, -0.05444602f, 
    -0.04336029f, -0.01652461f, -0.11034499f, 0.11336475f, -0.25787079f, -0.11886418f, 0.05489071f, 0.13019080f, 
    0.01095890f, 0.02853979f, 0.09847789f, 0.07640095f, -0.05581418f, 0.07587251f, 0.12753798f, 0.01068424f, 
    -0.05002312f, 0.04050603f, 0.03799107f, 0.17924017f, 0.03052323f, 0.16710450f, 0.09150983f, -0.02093643f, 
    0.04360051f, 0.12329677f, -0.12332895f, -0.02850269f, 0.03063429f, 0.01741948f, 0.00957864f, 0.22892819f, 
    -0.02196974f, -0.02101514f, 0.07140342f, -0.03591096f, 0.08857411f, -0.05877323f, 0.10298160f, 0.16722368f, 
    0.14103483f, 0.11398541f, -0.10896139f, -0.03642743f, 0.10374461f, -0.03363953f, -0.07051875f, 0.08037215f, 
    -0.05843478f, -0.02918112f, -0.05079897f, -0.18000278f, -0.12723282f, -0.25904205f, 0.11576640f, 0.04780605f, 
    -0.01462809f, -0.15943533f, 0.05254491f, -0.10801754f, 0.10164320f, -0.01300368f, -0.08671258f, -0.08813918f, 
    -0.24812977f, 0.08375988f, 0.19772640f, -0.04800823f, 0.08832773f, 0.08846410f, -0.03296525f, -0.09138776f, 
    0.04930994f, 0.16073863f, -0.13135745f, 0.09014706f, 0.25686279f, -0.04338638f, 0.14174022f, 0.11907027f, 
    -0.05459556f, -0.00326740f, -0.09709398f, -0.00339227f, 0.03396806f, -0.03483121f, 0.05464515f, -0.07713670f, 
    0.06158670f, 0.01010943f, -0.04401681f, -0.04244096f, 0.06524710f, -0.05476652f, -0.04108775f, -0.03148785f, 
    -0.00051253f, -0.04216217f, -0.01331509f, -0.01359243f, 0.01841051f, -0.06805710f, 0.01668127f, -0.03236139f, 
    0.02745264f, -0.05022462f, -0.06636478f, -0.05318920f, 0.01201214f, -0.07311179f, -0.07235804f, -0.06278782f, 
    0.02967657f, 0.00074594f, -0.00484732f, -0.02447766f, -0.01411006f, -0.00763519f, -0.07427584f, 0.01908398f, 
    -0.06178920f, 0.03952720f, 0.00742334f, 0.05400637f, -0.01784551f, 0.05140821f, 0.02760164f, 0.05576330f, 
    -0.05289123f, 0.01472075f, -0.03504943f, 0.03942420f, -0.06852821f, -0.03571862f, 0.01353960f, -0.03756211f, 
    -0.00026443f, -0.01633847f, -0.00234086f, 0.02297900f, 0.00047398f, 0.01850107f, -0.05960380f, 0.00078739f, 
    0.05112743f, -0.03774051f, -0.02403586f, -0.01908262f, 0.02421408f, -0.05956145f, -0.00007846f, 0.00751401f, 
    -0.00950961f, 0.03301163f, -0.01285809f, 0.01650053f, -0.02322518f, 0.04814983f, 0.01857014f, 0.05727436f, 
    0.05270213f, -0.07701825f, -0.03956942f, -0.01402569f, 0.01425270f, 0.04640799f, 0.04417449f, 0.06404307f, 
    -0.05995911f, -0.07486754f, -0.03870680f, -0.07272386f, -0.02785513f, -0.02539822f, 0.05974704f, -0.05352034f, 
    -0.07254134f, -0.03559659f, 0.04459540f, -0.07410860f, -0.00058070f, -0.04758348f, 0.02417303f, 0.03160340f, 
    -0.00022933f, 0.06870601f, -0.04258582f, 0.02607852f, -0.04922726f, 0.03003231f, 0.05057119f, -0.06595377f, 
    -0.03597838f, -0.02454048f, -0.03003924f, 0.03749657f, -0.00295761f, -0.03541308f, -0.05425867f, -0.06682076f, 
    0.00183484f, -0.00514168f, 0.02954487f, -0.04403279f, -0.01627017f, -0.04663729f, -0.03307618f, 0.06088483f, 
    -0.04777541f, 0.03899485f, -0.04560095f, -0.02467855f, 0.02972581f, 0.02363339f, -0.05085969f, -0.04120187f, 
    0.00484429f, -0.03174111f, -0.01360452f, -0.00750251f, 0.03965706f, -0.04863862f, -0.03336046f, 0.06278265f, 
    -0.05719884f, 0.05240185f, -0.07484779f, -0.00840255f, -0.04779294f, 0.03871796f, 0.04940219f, -0.04310222f, 
    -0.02684294f, 0.02709462f, 0.04487291f, 0.05904828f, -0.03372131f, -0.07621960f, -0.06774710f, -0.04804795f, 
    0.02234116f, -0.03578579f, -0.05932184f, 0.05533892f, -0.03894532f, -0.01188607f, -0.01754438f, 0.03587665f, 
    0.00372838f, 0.03900950f, 0.01922841f, -0.02373995f, -0.01327457f, -0.03582643f, 0.05348744f, -0.00169790f, 
    -0.04566683f, -0.06824736f, -0.05845213f, -0.01961919f, 0.00651975f, 0.06540564f, -0.07460506f, -0.00798906f, 
    -0.01766859f, -0.00491558f, 0.01211602f, -0.04785188f, 0.05110233f, -0.04368273f, -0.05420958f, 0.05374247f, 
    -0.00613788f, 0.04507772f, -0.05415832f, 0.04473790f, -0.05363607f, 0.05735682f, -0.01790765f, -0.07043323f, 
    -0.46650392f, 0.12497077f, -0.07000612f, 0.10919627f, 0.02962412f, 0.00842813f, -0.01560277f, -0.05036061f, 
    0.08463672f, -0.04718018f, 0.02977368f, -0.15419924f, 0.06313264f, -0.15109752f, 0.03353098f, -0.09347427f, 
    -0.03278384f, 0.04914956f, 0.09453628f, 0.05955307f, -0.01900742f, -0.04712746f, 0.00924134f, 0.07823789f, 
    -0.26085123f, -0.01102858f, 0.03921426f, 0.11779992f, 0.00310351f, 0.03109599f, -0.05002696f, 0.10603743f, 
    0.05244519f, -0.09859125f, 0.02177111f, 0.10575158f, 0.06377530f, -0.05964478f, 0.20905495f, -0.11555076f, 
    0.03651124f, -0.09688129f, -0.08193744f, 0.07315923f, -0.01383056f, -0.11006048f, 0.15154049f, -0.08903117f, 
    0.24980438f, -0.08381106f, 0.01872508f, -0.02857595f, 0.00978510f, -0.05850189f, 0.16482356f, -0.01807521f, 
    0.04221333f, -0.00801949f, 0.04678638f, -0.01302214f, -0.43662882f, 0.25770274f, -0.03687682f, 0.00797542f, 
    -0.19830815f, 0.10046336f, 0.09279476f, 0.09967288f, 0.09989880f, 0.10154039f, -0.06877338f, 0.02386346f, 
    0.30307209f, -0.08001857f, 0.04893498f, 0.10660326f, 0.02394769f, 0.02860459f, 0.02830771f, 0.03226286f, 
    0.02030872f, -0.02762163f, 0.00285859f, 0.19171752f, -0.06925725f, -0.04216014f, -0.07733599f, -0.19079621f, 
    -0.05050715f, -0.05535421f, 0.03254747f, -0.03541474f, 0.09486439f, 0.01066141f, 0.02296223f, 0.02777287f, 
    0.02198043f, -0.08162149f, 0.14879341f, 0.14087558f, 0.12622628f, 0.12499586f, 0.07109787f, 0.11604211f, 
    0.02237400f, 0.02726256f, 0.02055581f, -0.01013335f, 0.15583016f, 0.20018971f, -0.00310242f, 0.09772024f, 
    0.15952614f, 0.03956964f, 0.04145763f, 0.19088072f, 0.06900578f, 0.00686697f, -0.04274555f, 0.00630229f, 
    0.30081120f, 0.02969418f, -0.28249031f, 0.04715081f, -0.02308130f, -0.05924241f, -0.02294744f, 0.12920921f, 
    0.11013485f, -0.07116777f, 0.07399288f, 0.01776796f, 0.10274208f, -0.20952381f, -0.07803166f, -0.04684677f, 
    -0.17272054f, 0.10885281f, 0.04853997f, -0.13723798f, 0.01170903f, -0.09587801f, 0.08732635f, 0.14589980f, 
    0.13510798f, -0.12754403f, -0.11529624f, -0.00165891f, 0.03120741f, -0.08239114f, 0.11180693f, 0.06633183f, 
    -0.00334861f, 0.07292877f, 0.00847496f, -0.02032915f, 0.02305283f, 0.30216771f, 0.04793974f, 0.20937145f, 
    0.08810801f, 0.10602837f, 0.04587018f, 0.11177369f, -0.02692080f, -0.05858491f, -0.11974122f, 0.04049920f, 
    0.06721146f, -0.00927713f, -0.13065627f, -0.19765037f, -0.05156658f, 0.09306373f, 0.02548617f, 0.04641628f, 
    0.00940035f, 0.06246395f, -0.04638825f, -0.09885958f, -0.17718323f, 0.28581685f, 0.02865509f, 0.12457003f, 
    -0.09223748f, -0.07104600f, 0.05151388f, -0.00253716f, 0.06635655f, 0.05582280f, -0.01236781f, -0.03047189f, 
    -0.21618703f, 0.11478656f, 0.18115295f, -0.00195143f, -0.05289093f, 0.01257916f, -0.12260322f, 0.08233854f, 
    0.03266747f, -0.01926210f, 0.07767791f, 0.05618102f, 0.15828285f, 0.01802246f, 0.16048400f, -0.01423028f, 
    -0.02756942f, 0.08353053f, -0.00823578f, 0.10359772f, 0.16957559f, -0.10174937f, -0.06098782f, -0.02734022f, 
    -0.09254112f, 0.01006239f, -0.04112943f, 0.14195158f, 0.01889138f, -0.07731227f, 0.04477482f, -0.02811358f, 
    -0.06575704f, 0.05589669f, 0.07976436f, -0.01136821f, -0.02447895f, -0.03978358f, 0.14638717f, -0.08569398f, 
    0.00966648f, -0.08286897f, -0.32043135f, 0.11843599f, 0.01994382f, 0.04571113f, -0.02186601f, 0.09715806f, 
    0.09614590f, -0.31740838f, -0.14194092f, 0.08798662f, 0.01262779f, -0.10018490f, 0.00136516f, -0.02253103f, 
    0.03294923f, 0.03071529f, -0.09215110f, -0.00459690f, -0.32042927f, 0.12844440f, -0.06995995f, 0.21411625f, 
    -0.10107049f, 0.09428696f, -0.02471579f, -0.07725803f, 0.13914217f, -0.01511014f, -0.02675085f, -0.09187464f, 
    0.19140926f, -0.17397979f, 0.10263011f, 0.19115718f, 0.00180580f, -0.08166936f, -0.00615615f, -0.00895504f, 
    0.07043162f, -0.01685928f, 0.20862970f, 0.09254626f, 0.04624836f, -0.05092320f, 0.04106348f, -0.06727389f, 
    -0.02097532f, -0.01382085f, -0.09636945f, -0.13302353f, 0.03707176f, -0.14692736f, -0.04147378f, -0.14959209f, 
    0.08348361f, -0.09924200f, -0.14568304f, 0.10995545f, 0.03895111f, 0.01602118f, 0.10086201f, -0.05000425f, 
    0.06548046f, -0.01493555f, 0.10317357f, -0.01515241f, 0.08494078f, 0.18699071f, 0.18800147f, 0.09194419f, 
    0.06922248f, -0.03545341f, -0.03298424f, 0.02547912f, 0.01292922f, -0.05222356f, -0.08179852f, 0.03784460f, 
    0.29442894f, 0.44307429f, 0.16509604f, 0.04225151f, 0.02653626f, -0.07353038f, -0.00105830f, 0.22829388f, 
    -0.00112089f, -0.05336129f, 0.20127463f, 0.13451573f, 0.07636345f, -0.18967792f, 0.14429006f, -0.15307379f, 
    0.02878762f, 0.12195673f, 0.07046381f, 0.02996659f, 0.01912337f, -0.07145835f, -0.02342412f, -0.11116678f, 
    -0.11706931f, 0.09726353f, 0.01392624f, 0.00317469f, -0.12663940f, -0.02346571f, 0.08606861f, 0.00265493f, 
    0.14530937f, 0.15046342f, -0.05136594f, 0.13177267f, -0.22194955f, 0.16010940f, 0.39132807f, 0.16511305f, 
    0.06856844f, -0.02145717f, 0.02430650f, -0.04732184f, -0.02867627f, 0.04287995f, 0.01771503f, 0.14077736f, 
    0.03865001f, 0.24301711f, -0.14744742f, -0.00385694f, -0.01431611f, 0.01965104f, 0.05120807f, 0.13990274f, 
    0.02457242f, -0.08004433f, 0.04158938f, -0.03928043f, -0.14904588f, -0.11636730f, -0.33833459f, -0.08115491f, 
    0.01687670f, -0.04553123f, 0.06678985f, -0.02533193f, 0.02582097f, 0.09648798f, 0.02999910f, 0.06068787f, 
    -0.02073699f, 0.02009796f, -0.00179862f, -0.05373520f, -0.08865079f, -0.04796018f, -0.08475935f, -0.01569188f, 
    0.05872966f, -0.07486525f, -0.05111201f, -0.04968267f, 0.08042330f, -0.06502421f, 0.02756824f, 0.01386418f, 
    0.02788842f, -0.03318115f, -0.08931740f, 0.00806778f, -0.08625638f, -0.05097630f, 0.02407443f, 0.07428728f, 
    -0.04969482f, 0.04927078f, 0.04746136f, -0.06340100f, 0.01473730f, -0.00617885f, -0.04059597f, 0.05048912f, 
    -0.04144319f, 0.01430105f, -0.03078804f, -0.05087659f, -0.04915221f, 0.04989599f, -0.04014126f, 0.03936259f, 
    -0.08912743f, -0.05350649f, 0.03022509f, -0.00048145f, 0.00749838f, 0.05766952f, 0.00411290f, -0.04366549f, 
    0.06262765f, -0.08783426f, -0.01061078f, -0.04463172f, 0.03872830f, 0.00884453f, -0.05967160f, 0.01735304f, 
    -0.08414904f, -0.01521909f, 0.04596011f, -0.05612975f, 0.00864528f, -0.00236036f, 0.03099134f, 0.01979839f, 
    -0.06838357f, 0.03623410f, -0.06021073f, 0.03828632f, 0.01424401f, -0.00399335f, -0.04906857f, 0.00738495f, 
    0.05317650f, -0.03271998f, -0.04777771f, 0.01802923f, -0.00262461f, 0.00108553f, -0.05749836f, 0.01492851f, 
    -0.02834447f, 0.01927984f, 0.00194627f, -0.04412019f, 0.05664506f, -0.00703712f, -0.03531891f, -0.09586706f, 
    -0.04972955f, 0.02695017f, -0.09937488f, 0.00397985f, -0.01686545f, -0.00798157f, 0.00787269f, 0.00482705f, 
    -0.02083347f, -0.00266903f, -0.03472306f, 0.00228567f, -0.01998866f, -0.05474509f, -0.02461227f, -0.04633661f, 
    0.03174554f, 0.04551470f, -0.06452505f, -0.03563952f, -0.00545186f, -0.06237103f, -0.01388889f, 0.05844384f, 
    -0.05275093f, -0.06978785f, -0.04083440f, -0.04422474f, 0.02400079f, -0.03383058f, -0.01570908f, -0.03964401f, 
    -0.01587416f, -0.02143040f, -0.06157473f, 0.01210965f, -0.05261159f, 0.04235925f, -0.05663577f, -0.07371999f, 
    0.05206673f, 0.01764993f, -0.08017139f, -0.01214441f, -0.07597197f, -0.08757412f, 0.01259019f, 0.03981943f, 
    -0.02871216f, 0.02286972f, 0.02859668f, 0.02957285f, -0.05163123f, -0.08632967f, 0.00285338f, -0.05110142f, 
    -0.01669541f, -0.07959761f, -0.06315781f, -0.04676444f, 0.02347041f, -0.02412992f, 0.06303614f, 0.02151445f, 
    0.00834366f, 0.04946844f, -0.05068241f, -0.02543551f, -0.03071719f, 0.01999827f, -0.08101789f, 0.01925702f, 
    -0.01184368f, -0.00441006f, -0.07346069f, -0.02998639f, 0.06298124f, 0.01635635f, -0.06005581f, -0.05289998f, 
    0.04870469f, 0.00372717f, 0.05913135f, -0.00844923f, -0.05564177f, -0.01620588f, -0.02609180f, 0.05088276f, 
    -0.01617814f, -0.01270836f, -0.03933145f, 0.05237726f, 0.05229487f, 0.03882396f, 0.04265511f, 0.01848010f, 
    0.03438997f, 0.05066688f, -0.00912125f, 0.02451981f, 0.00065223f, 0.03892294f, -0.04476622f, 0.04246175f, 
    -0.02539796f, 0.04353245f, -0.04583145f, -0.00359676f, 0.00921425f, -0.01871085f, -0.03328454f, -0.04306296f, 
    0.01365919f, -0.07977556f, -0.04518253f, 0.02895135f, -0.02326353f, -0.04567057f, 0.01387639f, -0.07068039f, 
    -0.06849185f, -0.01596383f, 0.00555453f, 0.02344169f, 0.00875613f, -0.04014669f, 0.03499696f, 0.03526959f, 
    -0.05251727f, -0.05556415f, 0.00516845f, -0.05899384f, -0.06306637f, 0.05962585f, 0.00608874f, 0.01320632f, 
    0.04878464f, -0.03428509f, -0.06590489f, -0.05336452f, -0.00194333f, 0.02107854f, 0.05304785f, -0.00752795f, 
    0.01549568f, 0.02451100f, -0.06886883f, -0.01984969f, -0.06126188f, -0.06599606f, -0.04242547f, 0.03954295f, 
    -0.07595246f, 0.05854792f, -0.05116146f, 0.04860172f, 0.02582595f, -0.02656175f, -0.00240714f, 0.00024150f, 
    0.02282926f, -0.00116539f, -0.01901690f, 0.04415975f, -0.05089846f, 0.06076663f, 0.06164486f, -0.04425804f, 
    0.01112797f, -0.00460490f, 0.01575968f, 0.02796025f, -0.07779682f, -0.01761748f, 0.05913856f, -0.05370332f, 
    -0.06832023f, -0.07236863f, -0.03279315f, 0.04826730f, 0.04109561f, 0.00396761f, -0.07743537f, -0.06116641f, 
    -0.02804735f, 0.05139724f, -0.00772921f, -0.07268131f, 0.04695215f, -0.02885235f, 0.02917245f, 0.05483436f, 
    -0.04335048f, 0.05421250f, 0.06907167f, -0.03966252f, 0.00543856f, 0.01871440f, -0.07026070f, 0.01314980f, 
    -0.06951221f, 0.05368358f, -0.05814989f, -0.01525046f, 0.04634665f, -0.05558453f, 0.00760812f, -0.01171398f, 
    -0.05315185f, 0.00796681f, -0.01626407f, 0.01623436f, 0.01956175f, -0.06727332f, -0.06885968f, -0.00622843f, 
    0.05372945f, 0.01887053f, -0.02019218f, -0.07946147f, -0.03272323f, -0.05061786f, -0.07843392f, 0.05112641f, 
    -0.06144331f, -0.04559412f, -0.06664121f, -0.04351255f, -0.02230533f, 0.01959686f, -0.03705621f, -0.06441810f, 
    0.02814984f, -0.00047464f, -0.03977756f, 0.05754943f, -0.04038617f, 0.05809605f, 0.05650798f, 0.03213875f, 
    -0.04932710f, 0.01068981f, -0.00457883f, -0.02643476f, 0.01319374f, -0.02627856f, -0.04900857f, 0.05255712f, 
    0.00867791f, -0.06430966f, -0.03272018f, 0.03178573f, -0.02423443f, 0.01180996f, -0.06351021f, 0.05811851f, 
    0.04640766f, 0.05308740f, 0.03543316f, -0.05144272f, 0.05484656f, -0.01811595f, 0.03802198f, 0.04634252f, 
    -0.05731254f, 0.05017814f, 0.05437132f, -0.05994329f, -0.05149506f, -0.07892604f, 0.04901467f, 0.00959206f, 
    0.00205914f, 0.02779116f, -0.00215011f, -0.04566453f, 0.03249357f, -0.04995829f, -0.05237466f, -0.02524734f, 
    -0.04603723f, 0.02294162f, 0.02112737f, -0.05756994f, 0.03144946f, 0.03654081f, 0.04274428f, -0.00073380f, 
    -0.00428603f, -0.00237914f, -0.02324789f, -0.02337910f, 0.00658389f, 0.05354000f, -0.03751482f, 0.03184794f, 
    0.29637691f, 0.06818433f, 0.11081558f, 0.14049529f, -0.05723208f, 0.06948946f, 0.13350426f, -0.04786212f, 
    0.09361665f, -0.00402983f, 0.03790114f, -0.13760155f, -0.22143553f, -0.17469248f, 0.32244545f, 0.07898505f, 
    -0.01286810f, 0.20102035f, -0.00488329f, -0.08453117f, 0.03711273f, 0.12122970f, -0.09696862f, -0.07347053f, 
    -0.06089944f, 0.00151745f, 0.20635504f, -0.05406247f, 0.00519160f, -0.07556450f, 0.12729868f, 0.02323582f, 
    0.15015915f, -0.17176984f, 0.00378796f, -0.00353520f, -0.17894490f, -0.14223498f, 0.05408820f, 0.24107233f, 
    -0.09618609f, -0.02424794f, 0.08110052f, -0.07258829f, -0.00916161f, -0.10673362f, -0.03024089f, -0.02671937f, 
    0.39373595f, 0.19445831f, 0.02447037f, -0.15625602f, 0.01141826f, 0.02231855f, 0.05679123f, -0.03612388f, 
    0.11418422f, -0.11306436f, 0.16361167f, 0.00984589f, 0.06376939f, 0.00641682f, 0.02371671f, -0.11019129f, 
    -0.07782087f, 0.01208070f, -0.03214768f, 0.01240096f, -0.09195941f, -0.00953698f, 0.02178904f, -0.00462776f, 
    0.32898208f, -0.03709619f, 0.05229239f, 0.18238029f, 0.12023292f, 0.02129841f, -0.00060668f, 0.01371743f, 
    0.00865013f, -0.02708787f, -0.18590851f, 0.10745541f, 0.09713771f, 0.06054521f, -0.11835533f, -0.14842068f, 
    0.06532168f, -0.02207224f, -0.02005191f, 0.04335728f, 0.12310494f, -0.02056810f, 0.02972518f, 0.00927937f, 
    0.10043692f, -0.01440649f, 0.08749356f, 0.23656161f, 0.02928584f, -0.01054294f, -0.02454812f, 0.13239533f, 
    -0.01855182f, 0.06514552f, 0.03383064f, 0.06765009f, 0.00864930f, 0.06731812f, 0.08566850f, 0.04408168f, 
    -0.03496541f, 0.01520089f, -0.16858922f, -0.03551940f, -0.03382584f, -0.09105737f, 0.03805242f, -0.06312338f, 
    0.02969420f, -0.07499553f, -0.12513308f, -0.14028774f, -0.06814826f, -0.03893974f, 0.06280524f, -0.06274322f, 
    0.00442587f, -0.05928684f, -0.05548394f, 0.02233123f, 0.11102141f, 0.11293400f, 0.01945695f, 0.05239563f, 
    0.01569100f, 0.01598423f, 0.19182421f, -0.07529465f, 0.04810167f, 0.01452892f, 0.01225176f, 0.21167536f, 
    0.10467906f, -0.02919121f, -0.26912421f, -0.09591047f, 0.00413712f, -0.01451740f, 0.01311813f, 0.05488684f, 
    0.01991744f, -0.05689816f, 0.09053808f, -0.01411728f, -0.00805515f, 0.11647730f, 0.02744442f, 0.03275990f, 
    0.10709921f, -0.07637955f, 0.00080862f, 0.07823712f, -0.07457251f, -0.08860895f, -0.06259829f, -0.08434363f, 
    0.22813231f, 0.09081711f, 0.01782910f, -0.12142333f, -0.01665476f, 0.07099961f, -0.01319520f, 0.01868586f, 
    -0.07862880f, -0.04226423f, -0.09953276f, -0.05456037f, 0.11319651f, 0.34553745f, -0.21118556f, 0.08537535f, 
    -0.02380523f, -0.18886001f, 0.11443159f, 0.22554567f, -0.02333142f, 0.00337704f, 0.05479888f, -0.08813519f, 
    -0.09381668f, 0.05441989f, -0.05259344f, 0.05512130f, -0.07074643f, 0.03781632f, -0.09578425f, -0.04582663f, 
    -0.00737141f, 0.07862516f, 0.13783330f, 0.13915026f, -0.19675575f, -0.07229858f, -0.10716008f, 0.03765944f, 
    0.14047420f, -0.00267630f, -0.06324533f, -0.04714528f, 0.05856340f, 0.08630782f, -0.01422834f, 0.07412323f, 
    0.18297879f, 0.22909172f, -0.08011807f, 0.02503615f, -0.01660153f, -0.03943131f, -0.04615350f, 0.07802182f, 
    -0.08224737f, 0.04590888f, 0.07951019f, 0.23730314f, 0.11605068f, 0.08318218f, 0.07592355f, -0.02166202f, 
    0.10220900f, -0.00855771f, -0.09455677f, -0.01172588f, -0.04695724f, 0.08570424f, -0.04824959f, -0.02674920f, 
    0.09905115f, -0.14311045f, -0.15169202f, 0.19993135f, 0.19713670f, 0.03343220f, -0.13461788f, -0.08926527f, 
    0.03737973f, 0.00690864f, 0.01650395f, 0.02695572f, 0.20138663f, 0.10787752f, -0.12971894f, -0.01548042f, 
    0.16995391f, 0.03838310f, 0.07544491f, -0.04514518f, 0.11714131f, -0.01021275f, 0.06884396f, -0.09671145f, 
    -0.18237644f, -0.14224730f, -0.09419473f, 0.14569499f, 0.03975188f, 0.06110859f, 0.00025469f, 0.01118793f, 
    0.06227550f, 0.00444515f, -0.02253200f, -0.08388223f, 0.08151712f, 0.15312196f, 0.13202879f, 0.21361220f, 
    -0.09031963f, -0.16084784f, 0.06914175f, 0.10732155f, -0.05820629f, 0.06054356f, -0.04803969f, -0.12114294f, 
    0.18547009f, -0.01187261f, -0.07299291f, -0.21220055f, -0.01752399f, 0.06555588f, 0.01181552f, -0.16788106f, 
    0.06922001f, 0.04586323f, 0.01101078f, -0.04361966f, 0.19581424f, -0.02414128f, -0.03550709f, -0.00414024f, 
    -0.03855862f, 0.05428295f, -0.04947001f, 0.01646974f, -0.09735341f, 0.01201690f, -0.03780769f, -0.03640567f, 
    0.48569781f, 0.01647665f, 0.10663000f, -0.03634915f, -0.07759611f, -0.04452024f, 0.05584599f, -0.01787104f, 
    0.01343919f, 0.06966035f, -0.03010444f, -0.02971009f, -0.00448946f, 0.03482788f, 0.06328410f, 0.02473402f, 
    0.00848289f, -0.07180201f, -0.09826063f, -0.05776910f, -0.03223535f, -0.07968019f, -0.08586944f, -0.10106730f, 
    0.23853616f, -0.13495819f, 0.12818371f, 0.16776830f, -0.09412726f, 0.00434804f, -0.11167774f, -0.01731721f, 
    -0.04835636f, -0.02824148f, 0.06628639f, 0.17595306f, -0.06525606f, -0.01805735f, -0.09188958f, 0.07069410f, 
    0.13068628f, 0.13923457f, -0.03850572f, -0.00427483f, 0.03691792f, 0.07286867f, 0.10283621f, -0.07395642f, 
    0.09883199f, -0.15726802f, -0.06103498f, -0.10135692f, 0.05234471f, -0.00768314f, -0.01601663f, 0.14936131f, 
    -0.03890475f, -0.02382869f, 0.00471186f, -0.00281544f, 0.22359982f, 0.05764938f, 0.02530883f, -0.17841253f, 
    0.04738959f, -0.04582912f, 0.17212760f, -0.02811380f, -0.02131835f, 0.06901059f, -0.08977815f, 0.14273515f, 
    0.03783230f, -0.03361717f, -0.06149124f, 0.04991881f, -0.02471786f, 0.03491931f, 0.01867446f, -0.03775899f, 
    -0.07564384f, 0.00663484f, -0.01541548f, -0.00280715f, -0.00954789f, -0.02690236f, 0.04736845f, -0.03388520f, 
    0.03859521f, 0.00115453f, -0.00145778f, 0.05129505f, 0.05129979f, 0.04776676f, -0.03579356f, -0.05565554f, 
    0.01017374f, -0.07512172f, -0.00543763f, -0.02914926f, -0.02531080f, -0.05152370f, -0.06379587f, 0.02555529f, 
    -0.03022087f, -0.01120228f, 0.02260077f, 0.01021071f, 0.04698789f, 0.03202993f, 0.04439357f, -0.05251630f, 
    -0.04373806f, -0.03121863f, 0.06969853f, -0.05406398f, 0.06184649f, -0.05112019f, -0.07426895f, 0.01739221f, 
    0.03873525f, 0.03899382f, 0.01606306f, -0.07071926f, -0.08264206f, -0.08625226f, -0.04034759f, -0.04716959f, 
    -0.03125863f, 0.02290652f, 0.05743245f, 0.02505617f, -0.05086877f, -0.00899710f, -0.04312895f, 0.05660323f, 
    0.02426521f, -0.00607776f, -0.00330750f, 0.05472153f, -0.03298067f, -0.04975483f, 0.01949906f, 0.06197164f, 
    0.04976019f, -0.01125428f, 0.02016977f, -0.01894790f, 0.05067663f, -0.07857713f, -0.04212299f, -0.06115583f, 
    0.05506581f, -0.06941908f, 0.02371008f, -0.04945413f, -0.07033200f, 0.00418097f, 0.05841863f, -0.06542546f, 
    -0.08079149f, -0.03413754f, 0.06927105f, 0.03018251f, 0.03414825f, -0.07309969f, -0.03449271f, -0.00779386f, 
    0.00535272f, -0.03153032f, 0.00898142f, -0.00227477f, -0.03865426f, 0.02498090f, -0.04768300f, 0.00000536f, 
    0.04270758f, 0.00959248f, 0.06234533f, -0.04483622f, -0.05908607f, -0.06211132f, 0.02707850f, -0.02033045f, 
    -0.05284246f, -0.06794768f, -0.04657793f, -0.04619035f, 0.01778331f, -0.05993185f, -0.04477287f, 0.01671852f, 
    -0.07202003f, -0.04842412f, -0.00458052f, -0.04842928f, 0.05554869f, -0.06523158f, -0.02794861f, 0.06288961f, 
    0.01828828f, 0.00735384f, -0.07968082f, 0.00168426f, 0.03485068f, -0.04969875f, 0.00859619f, 0.03949068f, 
    -0.03673445f, -0.03246328f, -0.05866718f, 0.07983410f, 0.01700445f, 0.03734932f, -0.01589365f, 0.05818126f, 
    0.01952070f, 0.03469840f, -0.05754701f, 0.03047452f, -0.03064372f, -0.06366707f, -0.02482198f, -0.05209053f, 
    -0.05331792f, -0.00685662f, 0.02987126f, 0.01151780f, -0.02052939f, 0.06829332f, 0.07054753f, 0.02773475f, 
    0.02709963f, -0.02629552f, 0.02739743f, -0.03132326f, 0.05283889f, -0.00463780f, 0.02994516f, 0.03084404f, 
    0.04556101f, -0.06650184f, -0.00661378f, 0.03143000f, -0.02017938f, 0.03410989f, -0.02149729f, -0.05728987f, 
    -0.00570385f, 0.06231596f, 0.04794508f, -0.09147841f, -0.04314025f, -0.06581702f, 0.01193930f, 0.03653122f, 
    -0.03607625f, -0.06088357f, -0.00203244f, -0.06171525f, -0.04797136f, -0.03105755f, 0.01992651f, -0.07324059f, 
    -0.16404741f, 0.22784789f, 0.07219532f, -0.25710195f, 0.05831363f, -0.01989507f, -0.04993601f, 0.03999491f, 
    -0.08075798f, 0.03825160f, -0.04787824f, -0.02539753f, -0.08845707f, -0.20115678f, -0.00603347f, -0.31591335f, 
    0.09830692f, -0.06776883f, 0.14958389f, -0.01818100f, 0.01316371f, -0.02394748f, -0.02384868f, -0.06941910f, 
    -0.23774850f, -0.13038310f, 0.19563664f, -0.06300452f, 0.00285324f, 0.12108927f, -0.05792569f, 0.23041596f, 
    0.02550223f, -0.00100136f, -0.06196366f, 0.05786590f, -0.02758058f, -0.04615533f, 0.21039495f, 0.15773976f, 
    0.12217038f, -0.02968736f, 0.02880021f, 0.04014788f, 0.08495785f, -0.04140105f, 0.10979249f, 0.00384906f, 
    -0.08818372f, 0.07453547f, -0.16056499f, 0.06381798f, 0.00705982f, 0.15630947f, 0.14723922f, -0.03635757f, 
    0.10791053f, 0.12195755f, 0.02611708f, 0.06023527f, -0.31247327f, -0.06847528f, 0.02146339f, -0.05583780f, 
    0.02410305f, 0.04456140f, 0.04098005f, 0.08414781f, 0.04801123f, -0.03142020f, -0.02234053f, -0.09460310f, 
    0.07855294f, -0.06512610f, -0.04761519f, -0.19031726f, 0.05548279f, 0.05027481f, 0.11368727f, -0.02249014f, 
    -0.06900543f, -0.04098798f, -0.01104010f, 0.12337183f, -0.36257389f, -0.00339735f, -0.01620985f, 0.08371898f, 
    -0.04909613f, 0.11839187f, -0.02837879f, -0.00771603f, 0.07111870f, 0.00623865f, 0.05814008f, 0.08630177f, 
    0.16317697f, -0.08768668f, 0.01916433f, 0.40999222f, 0.11406337f, 0.03892415f, -0.01258235f, 0.08879384f, 
    -0.07438285f, 0.04024043f, 0.00812713f, -0.00921650f, 0.12459651f, 0.13015224f, 0.09716829f, 0.04714239f, 
    0.08343188f, 0.00650207f, 0.04661443f, 0.05173130f, -0.02214785f, 0.05263180f, 0.15581276f, 0.04211083f, 
    0.04476727f, 0.10804866f, -0.19472672f, 0.05797447f, -0.00674978f, 0.07779606f, -0.04739470f, -0.14799188f, 
    0.06448017f, 0.04638320f, 0.02328807f, -0.04017142f, 0.06783303f, -0.16006796f, -0.05000284f, 0.20163202f, 
    -0.01487982f, 0.05558436f, -0.08725796f, -0.06796193f, -0.00028251f, -0.02589707f, 0.04774137f, 0.05504008f, 
    -0.19415510f, 0.05723278f, -0.09773132f, -0.02552561f, 0.07058923f, -0.09655489f, 0.04135872f, -0.02530961f, 
    0.03301160f, 0.00573167f, -0.03693971f, -0.10730749f, 0.23857871f, 0.14812292f, 0.14300348f, 0.09365397f, 
    0.02635419f, 0.03354183f, 0.01257651f, 0.05252237f, 0.02070720f, -0.07965592f, -0.05572042f, 0.00794753f, 
    -0.12420327f, 0.08942745f, -0.07469527f, 0.00572098f, -0.01452516f, 0.10337838f, 0.02348420f, 0.01669291f, 
    -0.01879289f, 0.05072995f, -0.00638016f, -0.07948355f, -0.09500539f, -0.02166952f, 0.23497958f, 0.14521216f, 
    -0.09900834f, 0.13524437f, -0.03082095f, -0.03753391f, 0.07493483f, 0.05523704f, 0.10024377f, -0.11199851f, 
    0.20660152f, -0.01866222f, -0.17577426f, 0.18848316f, -0.01520200f, 0.04006618f, 0.11988319f, -0.17074138f, 
    0.07806298f, 0.00658399f, 0.09612044f, 0.01997259f, -0.32054800f, -0.02564157f, -0.07936097f, 0.07298378f, 
    0.09978776f, 0.04977833f, 0.05406463f, -0.12146479f, -0.13558121f, 0.01680693f, 0.02399521f, 0.03962036f, 
    -0.00456810f, 0.14880775f, -0.09270721f, 0.10560922f, -0.02697270f, 0.10182751f, 0.01154177f, 0.03259026f, 
    0.18506089f, -0.14338952f, -0.07528033f, 0.13132815f, -0.04957341f, -0.11234670f, 0.05068067f, 0.07551128f, 
    -0.07551788f, -0.04544464f, 0.14460474f, -0.01753158f, -0.01574650f, 0.02374936f, -0.00334998f, -0.07707917f, 
    0.05093306f, 0.17770739f, 0.06931010f, 0.01077176f, 0.12846191f, 0.01925243f, 0.08933798f, 0.14261486f, 
    0.03450772f, -0.00304465f, 0.10774531f, 0.09958125f, 0.46063539f, -0.00898718f, -0.02872117f, -0.10990974f, 
    0.11958463f, -0.00654275f, 0.07449953f, 0.08166456f, -0.01508095f, -0.00348620f, -0.07139391f, -0.01714874f, 
    -0.04776357f, 0.09365316f, -0.21312560f, -0.04541641f, 0.01630013f, -0.00869507f, 0.03337862f, -0.03424659f, 
    -0.05871122f, 0.12640226f, -0.30876878f, -0.01658579f, 0.09062735f, 0.15465535f, -0.00720617f, -0.03312470f, 
    -0.02744732f, -0.04217667f, 0.07711790f, 0.04279298f, 0.07372624f, 0.05607820f, 0.02963846f, 0.04268292f, 
    -0.09883739f, 0.08642717f, 0.16742417f, -0.07260916f, 0.02403447f, -0.06480656f, 0.11002140f, 0.01592114f, 
    -0.07566932f, -0.00702644f, -0.06596487f, 0.04480383f, 0.18363510f, -0.19540419f, -0.24355254f, 0.04693805f, 
    -0.11037934f, 0.07371422f, 0.05504920f, 0.07233845f, -0.04590788f, 0.04107190f, -0.14029747f, 0.02034368f, 
    0.10134555f, -0.14597307f, -0.14191404f, -0.11716161f, -0.09101513f, -0.02485878f, 0.11364155f, -0.05576747f, 
    0.00496559f, -0.07110167f, -0.12046098f, 0.02376547f, 0.06673566f, 0.16122073f, -0.03328442f, 0.07109185f, 
    -0.12084869f, -0.07832913f, 0.05258732f, -0.15493301f, 0.02701523f, -0.00477975f, -0.02103771f, 0.09071366f, 
    0.35571402f, -0.19140126f, 0.00265764f, 0.02362001f, 0.08044666f, 0.14555866f, -0.12316816f, 0.03710685f, 
    -0.09620745f, -0.01533166f, 0.02398829f, -0.05255411f, 0.07598891f, 0.03772498f, -0.25551039f, -0.01501564f, 
    0.14740407f, -0.08009023f, -0.06816287f, 0.10319076f, 0.01639836f, -0.02868611f, 0.09940311f, -0.16186455f, 
    0.28543171f, 0.04862122f, 0.01142491f, -0.20108318f, 0.08400657f, 0.03020757f, -0.02307632f, -0.01311407f, 
    0.03554355f, 0.13643812f, -0.08041063f, 0.02959716f, 0.12784708f, 0.22918886f, 0.22794095f, -0.05097550f, 
    0.01793392f, -0.13468911f, -0.00130491f, 0.11164583f, -0.09473313f, -0.12100668f, -0.03139503f, -0.03209234f, 
    0.04331506f, -0.05501113f, -0.07486077f, -0.02593008f, -0.05013594f, -0.06180429f, 0.01486042f, -0.04387213f, 
    0.00267952f, 0.01277840f, -0.01180478f, 0.06037042f, -0.01169242f, -0.01516312f, -0.07751682f, 0.02459404f, 
    0.06289541f, 0.00869560f, 0.07060196f, 0.04637084f, -0.04130089f, 0.00393436f, 0.05521298f, -0.01256855f, 
    0.03342531f, -0.03880575f, 0.04765795f, 0.00448637f, -0.03314988f, 0.00905900f, -0.05606394f, -0.00294263f, 
    -0.04379198f, -0.05338628f, 0.03645416f, -0.00041077f, 0.05935057f, 0.06049445f, -0.00451154f, -0.07418042f, 
    -0.05772318f, -0.02390084f, -0.04850374f, -0.04908833f, -0.06493074f, -0.04674908f, -0.01353636f, 0.02568590f, 
    -0.01436497f, -0.05397724f, -0.05457550f, -0.05018789f, 0.05171089f, 0.03699433f, -0.02492936f, 0.04238936f, 
    -0.02012493f, 0.01438332f, 0.00483711f, -0.07147948f, -0.06247352f, 0.06270096f, 0.03168396f, 0.02475513f, 
    -0.04872159f, 0.04111314f, -0.07249577f, -0.05081730f, -0.05965725f, 0.02397382f, -0.06443693f, 0.05471278f, 
    0.02613377f, -0.03941238f, 0.06067107f, 0.03634275f, -0.07167543f, -0.02004570f, -0.04743895f, -0.05139351f, 
    -0.00045855f, -0.08274920f, -0.01012830f, 0.02110085f, 0.05080544f, -0.03863900f, 0.01126201f, 0.02669005f, 
    -0.00278298f, -0.02706362f, -0.02152313f, 0.03538906f, 0.04676925f, -0.04584014f, -0.03624951f, -0.02304283f, 
    0.02451589f, -0.03695785f, 0.04663404f, 0.02541538f, 0.03689953f, 0.04379230f, -0.02245976f, -0.03923192f, 
    0.01603119f, 0.00885768f, -0.05329037f, -0.00628866f, 0.03573485f, -0.00179488f, -0.02213021f, 0.03536768f, 
    0.04024680f, 0.06194651f, 0.04087685f, -0.05946701f, 0.02191442f, -0.03411476f, -0.00585372f, -0.05700792f, 
    -0.06502040f, -0.03703623f, -0.01000780f, 0.01418134f, -0.03915829f, 0.02629834f, 0.01964147f, 0.00198058f, 
    -0.00737731f, -0.00109479f, 0.06199966f, 0.01841965f, 0.06250611f, -0.02213238f, -0.03356015f, -0.02205431f, 
    0.05591439f, 0.06423017f, -0.05329153f, 0.02892046f, -0.02761475f, 0.01140539f, -0.04632076f, -0.04710206f, 
    -0.04788142f, -0.07357171f, 0.02602710f, 0.03587699f, -0.06201417f, -0.07571701f, 0.06120875f, -0.07195553f, 
    -0.02242227f, -0.02466394f, -0.00155227f, -0.00853394f, -0.04773894f, -0.04946567f, 0.03146103f, 0.00909144f, 
    -0.04669837f, -0.01156435f, -0.06689798f, 0.00521928f, 0.01490117f, 0.01830029f, -0.02317405f, -0.03314000f, 
    0.04765736f, -0.01071300f, 0.00260946f, -0.08043900f, -0.07471988f, 0.00069668f, 0.03191823f, 0.00348875f, 
    -0.00469961f, 0.05418962f, 0.03047119f, -0.00185516f, 0.04264445f, 0.06041643f, 0.03434194f, -0.05771316f, 
    -0.02048443f, -0.08019737f, 0.00737589f, -0.05624201f, -0.05314552f, 0.00040166f, -0.07891773f, -0.03803258f, 
    -0.50548029f, 0.18295683f, 0.04804127f, 0.05476801f, 0.20978665f, 0.05852133f, -0.20362942f, 0.06606088f, 
    -0.03694646f, -0.09307218f, 0.01532238f, 0.01810036f, -0.18271405f, -0.06228999f, 0.21829337f, -0.18772717f, 
    -0.06576943f, -0.06946226f, -0.20164186f, -0.15771058f, 0.12606950f, 0.13050905f, 0.07324971f, -0.01595786f, 
    -0.05916551f, -0.00917157f, 0.14014290f, -0.10559318f, 0.08569933f, 0.00540820f, -0.21327232f, 0.07368875f, 
    -0.09644876f, -0.05126461f, -0.21150567f, -0.02408520f, 0.00928331f, 0.01468377f, 0.11496291f, 0.16214794f, 
    -0.07100388f, 0.11412984f, 0.04005108f, 0.03363877f, -0.10225583f, -0.08718901f, -0.15040372f, -0.02073464f, 
    0.24956177f, 0.19130459f, -0.23174180f, 0.09241769f, 0.17102498f, 0.02644095f, -0.08345759f, -0.21585101f, 
    0.18088500f, -0.05500348f, 0.12526505f, -0.09580837f, 0.31925789f, 0.05758143f, 0.02618266f, -0.09869632f, 
    0.00520696f, -0.00129171f, 0.11685066f, -0.12823635f, 0.01831612f, -0.13824172f, -0.00340048f, 0.05395907f, 
    0.04394791f, -0.10491437f, -0.15953064f, 0.08725953f, 0.43504673f, 0.04585091f, -0.11116496f, -0.00306836f, 
    0.07083318f, -0.13216595f, 0.14264198f, 0.13801681f, -0.16008569f, 0.19361061f, -0.09250462f, -0.14242944f, 
    -0.04797043f, -0.06139581f, 0.12453459f, 0.27600437f, -0.02523875f, 0.22151108f, 0.13690014f, 0.03942809f, 
    0.23761749f, 0.16412418f, 0.01327753f, 0.11528975f, -0.03165681f, 0.08685815f, 0.07846288f, -0.14566626f, 
    0.03423302f, 0.08915594f, 0.01404754f, 0.06919036f, -0.06743232f, 0.15049647f, 0.01879947f, -0.05593939f, 
    0.11415520f, -0.08365236f, 0.04237237f, 0.01741818f, 0.02715409f, -0.01185820f, 0.06641471f, 0.03500505f, 
    -0.08674056f, -0.05014914f, -0.15281089f, -0.11976582f, -0.18736997f, 0.20409076f, 0.13358822f, 0.07577913f, 
    -0.05305070f, 0.08090322f, -0.02585615f, 0.12633465f, 0.01549420f, 0.12681879f, -0.00234086f, 0.09290705f, 
    0.03443041f, 0.07197602f, 0.02049032f, 0.05339026f, -0.05939462f, 0.07398100f, 0.05798217f, 0.05833060f, 
    0.02040310f, -0.10405426f, -0.12150519f, -0.10887524f, -0.11796670f, -0.10183816f, -0.14967190f, -0.07605207f, 
    -0.28341493f, -0.07850636f, 0.03284943f, 0.03114784f, -0.04795160f, 0.10378117f, 0.03688799f, 0.13438043f, 
    0.22788393f, 0.08058592f, 0.05288605f, 0.03671513f, -0.01319214f, -0.10169642f, -0.05097979f, 0.06642061f, 
    -0.06404881f, 0.08501149f, -0.25814345f, -0.22021498f, -0.12134577f, 0.01500323f, 0.05547788f, 0.00476249f, 
    0.03363321f, -0.11308608f, 0.08967730f, -0.08271254f, 0.37237918f, 0.31100073f, 0.10986301f, -0.16574809f, 
    -0.01869627f, 0.17878263f, -0.03190563f, 0.03969137f, -0.13829507f, -0.09369794f, 0.07331946f, -0.07901514f, 
    0.64385527f, 0.02073138f, 0.04721719f, -0.06204202f, 0.03940468f, 0.03637014f, 0.07108526f, -0.07029255f, 
    0.00347561f, 0.16120584f, -0.02066261f, -0.01080815f, 0.13814950f, -0.29951397f, -0.04000510f, -0.29507843f, 
    -0.02273992f, -0.07961047f, 0.15224738f, 0.00882720f, 0.02496173f, 0.02968355f, 0.13365854f, 0.15928610f, 
    -0.06123213f, -0.07162973f, -0.19772373f, 0.04076105f, -0.18235305f, 0.09327954f, -0.02442948f, -0.00546811f, 
    0.25653279f, -0.09632235f, -0.19402508f, -0.14622666f, -0.04613458f, -0.10955372f, 0.09359045f, 0.01616976f, 
    0.11612777f, -0.23646311f, -0.14474428f, -0.04425197f, 0.08481693f, -0.13256820f, 0.09883028f, -0.12658486f, 
    -0.03566996f, 0.02575950f, 0.02308737f, 0.20304638f, 0.07932918f, -0.03494028f, 0.05813597f, -0.01081144f, 
    -0.02359031f, 0.06495903f, 0.12601602f, 0.17505093f, -0.04624449f, 0.02107171f, -0.15322116f, -0.08411867f, 
    -0.02968296f, -0.07337791f, -0.18397580f, -0.13007835f, 0.02788768f, 0.03420523f, 0.01874476f, 0.09666932f, 
    0.10184404f, 0.16618143f, -0.03492453f, 0.02320919f, 0.00668191f, 0.01000842f, -0.03103800f, -0.05946870f, 
    0.01582917f, 0.13975936f, -0.23561315f, -0.02428663f, -0.09110068f, -0.08528239f, 0.12189312f, 0.04353723f, 
    -0.07526419f, 0.06575829f, 0.22437181f, 0.08062164f, 0.09112274f, -0.05453612f, 0.12821542f, 0.12208359f, 
    -0.11312917f, 0.01621643f, -0.00651845f, 0.01161587f, 0.07951561f, 0.03257826f, -0.01258191f, -0.06671984f, 
    0.01284812f, -0.09616054f, -0.11299427f, 0.17063208f, 0.34400642f, -0.07718588f, -0.05341651f, 0.07178981f, 
    0.19333009f, -0.01165690f, -0.09111480f, -0.03132647f, -0.01117320f, 0.07279768f, 0.05834659f, 0.07722508f, 
    0.22534975f, 0.01984375f, -0.02079386f, 0.00447484f, 0.10996561f, -0.19564790f, -0.01024910f, -0.01965444f, 
    -0.05065567f, 0.05192166f, -0.28231829f, -0.06729171f, 0.10164158f, 0.08481160f, -0.06886049f, 0.10656288f, 
    -0.03699094f, 0.00830773f, 0.13006690f, -0.04823173f, 0.03384930f, -0.09511538f, 0.20441119f, 0.32873407f, 
    -0.05419403f, -0.01950206f, 0.01954306f, -0.05143292f, 0.08247904f, 0.03495287f, -0.04167697f, 0.03503081f, 
    0.01277615f, -0.23328005f, -0.10491908f, -0.18920486f, 0.03920402f, -0.02250129f, -0.09597238f, 0.05281010f, 
    0.02229420f, -0.06461855f, 0.00486808f, -0.15697257f, 0.02687696f, -0.08069913f, -0.14888236f, -0.18663132f, 
    0.68620342f, 0.26425919f, 0.08584894f, -0.05784597f, 0.01669120f, 0.04251627f, 0.04951251f, 0.10132690f, 
    -0.09752125f, 0.06533989f, 0.03513302f, 0.03748078f, -0.24151254f, 0.01164448f, 0.04502400f, 0.19799496f, 
    -0.08476999f, -0.09611755f, -0.04817615f, -0.06455236f, 0.04129183f, -0.02578969f, 0.04874780f, 0.08333705f, 
    -0.27129102f, -0.08602653f, -0.09824868f, 0.20578429f, -0.14715421f, 0.12747015f, -0.09337237f, -0.06962672f, 
    0.11336260f, -0.03126968f, 0.06825399f, 0.08859470f, 0.15168381f, 0.12311424f, -0.01906820f, 0.16904256f, 
    -0.10899619f, 0.09896983f, 0.02212797f, -0.02285263f, 0.10647695f, 0.04364945f, 0.05543596f, 0.09658337f, 
    0.02875368f, 0.13283724f, -0.08211957f, 0.04459946f, 0.03050255f, -0.09107859f, 0.10715911f, -0.06514698f, 
    -0.11207926f, 0.11123186f, 0.09064133f, -0.00355039f, -0.10304412f, 0.05405402f, 0.04144692f, -0.04869278f, 
    -0.02282712f, 0.07218900f, -0.26049104f, 0.00658769f, -0.10908522f, 0.13044818f, 0.01954289f, -0.13252984f, 
    0.33016977f, -0.11154193f, 0.00441779f, 0.04721884f, 0.16196485f, -0.11445082f, -0.09218288f, -0.07652009f, 
    0.02225139f, -0.07091194f, -0.06214371f, -0.06855109f, 0.07287796f, 0.25956562f, -0.04260578f, 0.14502791f, 
    0.01030828f, -0.04900330f, 0.02035248f, -0.11612771f, 0.05590947f, -0.01474979f, -0.02995418f, -0.02086808f, 
    0.05413575f, -0.00783158f, 0.13937441f, 0.31409642f, 0.06076029f, -0.02577668f, -0.09016410f, -0.02107179f, 
    -0.02324245f, -0.03195203f, 0.13402621f, -0.13583437f, 0.10290196f, 0.03754674f, 0.08816461f, 0.05532674f, 
    0.00765933f, -0.11638416f, -0.06106133f, -0.05158080f, -0.08410570f, 0.04650744f, -0.08608457f, -0.10690983f, 
    0.07044266f, -0.12070570f, -0.07720586f, -0.21377125f, 0.01231261f, 0.01515461f, 0.00774283f, -0.02479552f, 
    0.14830798f, 0.04701114f, -0.02305985f, -0.00405469f, -0.02192693f, 0.01356972f, 0.00778719f, 0.01949646f, 
    0.06968904f, 0.05083585f, -0.03489754f, 0.01311123f, 0.00820777f, 0.02025991f, -0.02214706f, 0.00802368f, 
    0.49348003f, 0.12679879f, 0.14356236f, 0.00262464f, -0.02492586f, -0.10182020f, 0.00784977f, 0.20661232f, 
    -0.02505755f, -0.07974512f, 0.06403767f, 0.05130102f, -0.10418466f, 0.08542151f, 0.10861556f, -0.20346202f, 
    0.02841399f, -0.07792816f, 0.03427722f, -0.18945977f, -0.07265315f, 0.04992389f, -0.10732470f, -0.19764018f, 
    0.19429292f, 0.03534001f, -0.04078636f, 0.11637427f, -0.04483480f, 0.02452219f, -0.03042496f, 0.07616026f, 
    0.00722776f, -0.06602730f, 0.03588359f, 0.18609914f, -0.37410614f, 0.02855772f, 0.06712804f, 0.04455266f, 
    0.05542882f, 0.04191342f, -0.02231140f, -0.10642410f, 0.00287380f, 0.15837353f, 0.05004946f, -0.03421647f, 
    0.02897206f, -0.11796428f, -0.06005114f, -0.12177543f, 0.16727142f, -0.03074425f, -0.06630006f, -0.00195376f, 
    0.02493526f, 0.05273396f, 0.01956881f, 0.03505746f, 0.20229314f, 0.10709813f, -0.31633455f, -0.20802046f, 
    0.12593128f, -0.18165675f, -0.00515581f, 0.00763796f, 0.07127224f, -0.00659891f, 0.01316204f, 0.15553273f, 
    -0.19243935f, -0.01476059f, -0.10478430f, 0.18997480f, -0.16205327f, -0.02115794f, 0.07825147f, -0.14531925f, 
    0.05348778f, 0.00349099f, 0.13446139f, 0.00820778f, -0.06032914f, -0.07374122f, -0.17421259f, -0.06864312f, 
    -0.01048473f, 0.01640679f, 0.03121337f, -0.11297001f, 0.00015826f, 0.03572936f, 0.04804209f, 0.05325521f, 
    -0.26811814f, 0.06461598f, -0.13495058f, 0.08370282f, -0.02847790f, 0.00053597f, -0.04138377f, -0.04270337f, 
    0.04255097f, 0.00443561f, 0.06579755f, 0.14761715f, 0.08146454f, -0.04375351f, 0.17987932f, -0.01504254f, 
    -0.06195701f, 0.02628502f, -0.07065823f, 0.14668895f, 0.01312361f, -0.00952062f, -0.05690045f, -0.04972185f, 
    0.12451968f, -0.06226848f, -0.20148486f, 0.24260639f, 0.12171244f, -0.14181188f, -0.03606944f, 0.01585699f, 
    -0.00141463f, 0.02701405f, 0.03534833f, -0.01315746f, 0.08905674f, -0.05200946f, -0.25263274f, -0.15938260f, 
    -0.13246228f, 0.04887035f, 0.02028809f, 0.01919724f, -0.05787757f, 0.04237998f, 0.06126619f, 0.03659998f, 
    -0.05584623f, 0.01902271f, -0.17590843f, 0.14175086f, -0.09193490f, -0.01172509f, -0.00631968f, 0.09181637f, 
    0.03420492f, 0.07443964f, -0.12234583f, -0.08261549f, 0.08461943f, 0.14240165f, 0.14141585f, -0.05936085f, 
    0.04650914f, -0.00160576f, 0.08074119f, 0.11479742f, 0.04785562f, 0.05240868f, -0.08180054f, -0.08878948f, 
    0.15972209f, 0.00718956f, -0.00925304f, 0.06180881f, -0.02480795f, -0.03906161f, 0.01689965f, -0.15604863f, 
    0.08433424f, 0.00073962f, 0.02101752f, -0.10263687f, 0.10012224f, 0.04841825f, -0.04335071f, 0.10179935f, 
    -0.07942187f, 0.13245733f, -0.02423972f, 0.04861219f, -0.01291610f, 0.03623393f, -0.04384082f, -0.03804943f, 
    0.41396597f, 0.07064722f, -0.04118082f, -0.02328303f, 0.01329613f, -0.02221297f, 0.25746304f, 0.04638144f, 
    -0.00477852f, -0.04764693f, -0.01259118f, -0.01177338f, 0.14531538f, 0.14177936f, 0.20075665f, 0.09645619f, 
    -0.04179454f, -0.03009740f, 0.07932322f, -0.26655445f, -0.06692833f, -0.04678539f, -0.07629524f, -0.13554920f, 
    0.32226881f, -0.14210142f, 0.14093502f, 0.22663830f, 0.01638216f, 0.12537502f, -0.01400128f, -0.00162149f, 
    0.00420892f, 0.02735032f, -0.02633228f, 0.10806873f, -0.10201748f, 0.03653127f, 0.07140988f, 0.06758270f, 
    -0.01053381f, -0.02166603f, -0.04347302f, -0.03067273f, 0.01811035f, 0.05666000f, 0.01194220f, -0.14156882f, 
    0.06920349f, 0.12406757f, -0.07065031f, -0.00421078f, 0.02665741f, -0.03387155f, 0.03497146f, 0.19394962f, 
    -0.02163180f, 0.04385070f, -0.06706313f, 0.09545358f, 0.19360435f, 0.03725480f, -0.03009542f, -0.16721871f, 
    0.13186386f, -0.18480900f, -0.05682131f, 0.03608961f, 0.01600382f, 0.06613500f, -0.05560433f, 0.16966622f, 
    0.56136465f, -0.03922403f, 0.07106633f, 0.10816364f, -0.13315189f, 0.07453678f, 0.06465405f, -0.00006086f, 
    0.00832486f, -0.05199153f, 0.10843212f, -0.06608669f, 0.14994518f, -0.10139775f, 0.33885941f, 0.02613520f, 
    0.07439335f, 0.12275713f, -0.04428159f, 0.04010040f, 0.10423631f, 0.12768929f, -0.01000412f, -0.01287648f, 
    0.31134576f, -0.01350891f, 0.11249520f, -0.03722864f, -0.02436900f, 0.06343918f, 0.07969530f, -0.03932655f, 
    0.10379311f, -0.02630199f, -0.00079762f, -0.18998568f, -0.25731564f, -0.07572139f, -0.26718068f, 0.20505820f, 
    -0.02418242f, 0.03031398f, 0.11338235f, -0.11307883f, -0.10412701f, -0.02307590f, -0.11661107f, -0.06004287f, 
    0.29523882f, 0.24771996f, 0.18873385f, -0.15850091f, -0.01762844f, 0.02971887f, 0.03750596f, 0.13365357f, 
    -0.05478210f, 0.01390387f, 0.14200260f, -0.06065950f, 0.68337786f, 0.13587317f, 0.19383706f, -0.00137658f, 
    0.08787393f, -0.06956470f, 0.08986630f, -0.00677937f, -0.00695621f, -0.05740470f, 0.12341224f, 0.02456139f, 
    -0.00133260f, 0.26654550f, 0.05793793f, -0.07864952f, 0.01755221f, 0.02439444f, -0.13054769f, -0.02910251f, 
    -0.11317263f, 0.09606079f, -0.09060245f, -0.06075873f, 0.25679237f, 0.01856129f, -0.00672456f, 0.14828165f, 
    0.19185714f, 0.04291221f, 0.09419411f, -0.11366212f, 0.18856901f, 0.02177827f, 0.06509735f, 0.00032990f, 
    -0.13605404f, -0.03916280f, -0.02477147f, 0.12597468f, -0.06729645f, -0.10910277f, 0.04395420f, -0.04762826f, 
    0.00569346f, 0.00627279f, -0.00374281f, 0.01925750f, 0.11410721f, -0.12560283f, -0.14317654f, -0.13348886f, 
    -0.12028942f, 0.09699424f, -0.02653888f, -0.03837356f, 0.03968301f, -0.05723142f, 0.05826120f, -0.10159879f, 
    -0.19622032f, -0.13514353f, 0.17472556f, 0.05261503f, 0.10439791f, 0.00870814f, 0.12167513f, -0.04491163f, 
    -0.06866173f, 0.00202821f, -0.03668857f, 0.03744440f, -0.00180145f, 0.19069320f, -0.05256141f, 0.11562480f, 
    0.08063586f, -0.13139500f, 0.12834455f, -0.07564440f, 0.09507010f, 0.07690368f, 0.01076300f, 0.10692528f, 
    -0.08611558f, 0.08260914f, 0.07746046f, -0.05785793f, 0.08527084f, 0.04439163f, 0.04109458f, 0.04672163f, 
    -0.06153385f, -0.01667845f, -0.00464281f, 0.01159699f, 0.24906032f, -0.17034496f, -0.02929674f, 0.03458380f, 
    0.07359765f, -0.08628801f, -0.06484582f, -0.13437027f, -0.01501129f, 0.00941170f, 0.01147020f, -0.09419928f, 
    0.10703513f, -0.04711729f, 0.24815120f, -0.05265420f, 0.04641581f, 0.08195351f, 0.02273024f, 0.00178214f, 
    -0.07691070f, -0.00854054f, -0.07849339f, 0.01879098f, -0.00369450f, 0.17521989f, -0.23733039f, 0.18975134f, 
    -0.06297541f, -0.10689952f, 0.08881656f, 0.04466110f, -0.02478082f, -0.13945399f, 0.04460964f, -0.16234575f, 
    0.07026222f, -0.20664868f, -0.03138936f, 0.20304166f, 0.07806381f, 0.06483463f, -0.06558803f, -0.14822957f, 
    0.06820329f, 0.10082786f, 0.08467053f, 0.11359786f, -0.06614456f, -0.16525812f, -0.20660461f, -0.04474993f, 
    0.02053593f, -0.01594077f, 0.03274588f, -0.05209215f, 0.04844275f, -0.09947553f, 0.09065048f, 0.01512191f, 
    -0.22501127f, 0.19285427f, -0.11951646f, 0.11747816f, -0.03484251f, -0.09362005f, -0.03399704f, -0.08944870f, 
    0.06962113f, -0.01059501f, 0.02943581f, 0.10393374f, 0.14468285f, -0.05860484f, 0.27427778f, -0.01751238f, 
    -0.04952470f, -0.06397200f, -0.05444387f, 0.08163194f, 0.05076786f, 0.13263373f, 0.00113854f, 0.00298798f, 
    -0.11149137f, -0.32909784f, -0.01469411f, 0.12423825f, 0.16070797f, 0.02536160f, 0.03124378f, -0.06138498f, 
    0.05262624f, -0.00088302f, 0.07105640f, 0.08000095f, -0.37004071f, -0.09623318f, -0.35532951f, -0.14553644f, 
    -0.06967348f, 0.11764079f, 0.01430529f, -0.00105474f, 0.01169275f, -0.01597152f, -0.05445159f, 0.04222005f, 
    0.00731782f, -0.15952834f, -0.05595141f, 0.20075572f, -0.03288595f, 0.01744519f, 0.00428331f, 0.04307608f, 
    0.09574914f, 0.10067928f, 0.00171458f, -0.03868526f, 0.16609989f, 0.16493477f, 0.01722447f, -0.19012171f, 
    -0.11954881f, -0.10193466f, 0.10998506f, 0.05320442f, -0.03277583f, -0.13294277f, -0.11220318f, 0.05362328f, 
    0.11934861f, -0.00774733f, 0.08753723f, -0.12583798f, 0.01294371f, 0.06347167f, 0.10144864f, -0.03364657f, 
    -0.05589004f, 0.03168890f, -0.04186849f, 0.04776841f, 0.30483890f, 0.17443435f, -0.02586508f, 0.16987011f, 
    0.08778410f, 0.07876743f, 0.04234701f, 0.05090553f, 0.06125535f, -0.00114711f, -0.06081948f, 0.04648053f, 
    0.37639487f, 0.00782733f, -0.09941052f, -0.16009261f, -0.13459279f, -0.08360374f, 0.13137075f, 0.00980288f, 
    0.03000388f, -0.08782290f, -0.06429342f, -0.04232579f, 0.15320863f, 0.08358552f, 0.08395664f, -0.10846039f, 
    -0.13381363f, -0.07465151f, 0.07863130f, -0.20320483f, -0.07862011f, 0.05546119f, 0.03465807f, -0.01300694f, 
    0.28031272f, -0.26210934f, 0.12235084f, 0.00747996f, -0.19921003f, 0.10236231f, 0.01016365f, 0.07198015f, 
    -0.13172561f, 0.01612362f, 0.02560706f, 0.03398011f, -0.14173001f, 0.18696237f, -0.08749764f, 0.05697741f, 
    0.11616980f, 0.05491688f, 0.06226099f, 0.02980807f, 0.04134246f, 0.10514738f, -0.09241678f, -0.08316765f, 
    0.49066845f, 0.12690444f, -0.18786630f, -0.00338736f, -0.12656800f, -0.01747240f, 0.00758020f, 0.15799440f, 
    -0.00127492f, 0.07044318f, 0.06347366f, 0.12905461f, -0.15554601f, 0.04820929f, 0.01203729f, -0.06935714f, 
    0.19316912f, -0.03842741f, 0.03872919f, 0.01350687f, 0.04480217f, 0.01831348f, -0.13866866f, 0.17953505f, 
    -0.07733820f, -0.11016378f, 0.02346382f, -0.04359228f, -0.05303203f, 0.03656392f, -0.08020250f, 0.07859216f, 
    0.04448692f, 0.05950634f, -0.07389618f, 0.08631240f, 0.00131160f, 0.29066953f, -0.17804995f, 0.25791052f, 
    -0.14820373f, -0.08892754f, 0.06947984f, 0.07410433f, 0.07795485f, -0.00803284f, 0.15952376f, 0.09703037f, 
    -0.03617069f, 0.08848604f, -0.02176279f, -0.08055772f, -0.05390292f, -0.19561231f, 0.12655832f, -0.01104766f, 
    -0.15724295f, 0.09762567f, 0.01530612f, 0.07700291f, -0.04068092f, 0.28145492f, -0.00043811f, -0.28971070f, 
    0.03079819f, -0.09494705f, -0.19827823f, -0.07292217f, -0.03489840f, 0.01968256f, 0.06171091f, 0.04947952f, 
    0.09407274f, -0.26743338f, 0.03444711f, 0.12999563f, 0.02112487f, 0.08001427f, 0.06253754f, -0.05122185f, 
    -0.05274425f, 0.02499236f, -0.03535754f, -0.02754922f, -0.20502611f, -0.04391111f, 0.05379224f, 0.25182858f, 
    0.08645043f, 0.00976454f, 0.03265040f, -0.01908380f, -0.00923058f, 0.10022206f, 0.08674186f, 0.04012549f, 
    -0.02331003f, -0.07478255f, 0.05262125f, 0.29204109f, -0.07161202f, 0.10482763f, -0.03586612f, 0.01002177f, 
    0.04225017f, 0.00409434f, -0.00478245f, -0.00885558f, -0.08689367f, -0.14570780f, 0.27414089f, 0.09718072f, 
    0.03014993f, 0.01869696f, -0.03190603f, 0.10206550f, -0.14419602f, 0.05416053f, 0.03801809f, -0.03039107f, 
    -0.05356665f, 0.11042257f, 0.08175820f, -0.34355190f, 0.04435347f, 0.00373121f, -0.07626947f, -0.05748873f, 
    0.07093950f, 0.04738328f, 0.01281628f, 0.04304982f, -0.24561624f, 0.07368231f, 0.26449776f, 0.01939061f, 
    0.09711067f, 0.07901008f, -0.05519719f, 0.04895749f, -0.04690849f, 0.05164345f, -0.01712022f, 0.03662130f, 
    0.05494426f, 0.10409709f, 0.16253625f, 0.16433229f, -0.01394395f, 0.06786321f, -0.09471703f, 0.22857888f, 
    0.07117239f, 0.06161126f, -0.03811751f, -0.03910690f, -0.06990624f, -0.01813070f, 0.02436932f, -0.03213858f, 
    0.05895562f, 0.03434926f, -0.00626990f, 0.11746171f, -0.08610170f, 0.02220489f, -0.00924118f, 0.00885460f, 
    -0.09524541f, 0.10256827f, -0.03574387f, 0.14079380f, 0.02911378f, 0.06232474f, 0.02686911f, -0.01745918f, 
    0.05213933f, -0.17371723f, -0.03657443f, 0.09337880f, -0.33987668f, -0.18162113f, 0.21506637f, -0.03060093f, 
    -0.01182918f, 0.08023340f, 0.02811969f, -0.08122793f, -0.00279730f, 0.12030987f, 0.03369930f, 0.08238913f, 
    -0.03904444f, 0.19286658f, 0.02744462f, -0.00320056f, 0.12605196f, -0.00822656f, -0.03574875f, 0.05714245f, 
    0.01445580f, -0.05820118f, 0.13904929f, 0.07634915f, -0.02706434f, -0.14714766f, -0.12109282f, -0.31201473f, 
    0.06211352f, 0.15924262f, -0.00235640f, -0.06783580f, 0.13837528f, -0.00113570f, 0.05384864f, 0.10359412f, 
    0.12840575f, -0.14607573f, 0.16804545f, 0.09545527f, -0.00196276f, 0.02104971f, 0.08473019f, -0.01575119f, 
    0.12982880f, -0.03736803f, -0.06723209f, -0.03221658f, 0.09368667f, -0.21430628f, 0.10807310f, 0.14128123f, 
    -0.02242025f, -0.03754120f, 0.04451248f, -0.01827580f, 0.01137471f, 0.07922423f, 0.00755168f, -0.03918283f, 
    0.08229271f, -0.18325211f, -0.02677357f, 0.05510748f, 0.05948269f, -0.00469445f, 0.08128539f, -0.11718864f, 
    0.09082902f, -0.01099259f, 0.10137372f, -0.08305409f, -0.16285472f, -0.18412617f, -0.07616859f, 0.12806295f, 
    -0.09845754f, 0.20524128f, 0.13109247f, -0.02996020f, 0.05489513f, 0.12707880f, -0.02523386f, 0.00429750f, 
    0.10964525f, 0.13926201f, 0.09080926f, 0.01026924f, 0.00337402f, -0.07733562f, -0.05782381f, 0.05938158f, 
    0.03318706f, 0.07419534f, 0.16784573f, -0.05252854f, 0.25975832f, 0.00295290f, -0.11625870f, 0.04792709f, 
    -0.01464197f, -0.06361948f, 0.05158855f, 0.02538982f, -0.07398675f, 0.03379622f, 0.05474950f, 0.08306523f, 
    0.25766754f, 0.08884809f, -0.07503130f, 0.26874158f, 0.11766472f, -0.07890622f, 0.07618392f, 0.02187345f, 
    0.03071745f, 0.02428798f, 0.11708345f, -0.02833553f, 0.11913132f, 0.13145454f, 0.05600782f, -0.11076748f, 
    0.04843969f, 0.06328912f, 0.00182703f, -0.02327744f, 0.08080671f, -0.04990729f, 0.06461288f, 0.11326051f, 
    0.11878359f, 0.17446691f, -0.13539593f, 0.01571510f, 0.00165793f, -0.05591301f, 0.08773770f, -0.00386354f, 
    -0.03965442f, -0.12471800f, 0.01163582f, -0.01687764f, -0.10921145f, 0.05792697f, 0.04749276f, -0.10955893f, 
    0.01008629f, 0.00893400f, -0.05107379f, 0.04572765f, 0.05590488f, 0.09506743f, -0.01718248f, 0.02466412f, 
    -0.09736603f, -0.12562707f, 0.05640572f, -0.18163288f, -0.06085797f, -0.23326999f, 0.03465322f, -0.04565609f, 
    0.03989620f, -0.06596207f, -0.07793351f, -0.02889197f, -0.23866539f, 0.21298647f, -0.05160474f, -0.19933228f, 
    -0.05135313f, -0.08138234f, 0.02991534f, -0.06153412f, 0.06602094f, 0.03868321f, 0.03230788f, 0.11548981f, 
    0.06278219f, -0.05797027f, 0.06174622f, -0.12908094f, 0.02358106f, 0.03250647f, -0.01859949f, 0.01717584f, 
    -0.15570083f, 0.02269306f, 0.00489137f, -0.03195398f, -0.16613244f, 0.09138572f, -0.11792068f, -0.05543996f, 
    0.05645061f, 0.04770174f, -0.03412076f, 0.05063582f, 0.10638235f, 0.04044789f, -0.04173489f, -0.08202084f, 
    0.53108609f, -0.11394921f, 0.00619551f, -0.04748542f, -0.07657972f, 0.02972217f, 0.04624378f, 0.05193821f, 
    0.04229049f, -0.07042946f, -0.01959100f, 0.07742218f, 0.27369940f, 0.31406057f, -0.25714776f, -0.01253449f, 
    -0.00014777f, -0.07499331f, -0.08074676f, 0.06591810f, 0.03200053f, 0.04388361f, -0.10840341f, 0.03005037f, 
    0.24239577f, 0.02061766f, 0.18304513f, -0.02015328f, 0.08545554f, -0.00641408f, 0.18170469f, 0.04683816f, 
    0.01489772f, 0.14523135f, -0.10656369f, -0.08514488f, -0.21572520f, 0.02987273f, -0.03841736f, 0.03782529f, 
    0.01116216f, 0.07118754f, 0.19182637f, -0.05805448f, -0.05219512f, 0.06172071f, 0.04263638f, 0.08847003f, 
    -0.03920634f, -0.02858404f, 0.18152121f, -0.11521969f, -0.02375049f, 0.00466240f, 0.00555590f, 0.07760500f, 
    0.16393428f, -0.06686217f, -0.16358219f, 0.00395136f, 0.00028645f, 0.05211706f, 0.00310411f, 0.11470360f, 
    0.03690097f, -0.07584758f, 0.13728242f, -0.05360463f, -0.02136904f, -0.04313042f, 0.06637039f, -0.10280515f, 
    0.05502298f, 0.36658406f, 0.09683961f, -0.03173954f, -0.16286938f, 0.12880355f, 0.00190298f, -0.06045833f, 
    0.01571655f, 0.02064725f, 0.04771346f, 0.11340785f, -0.14954603f, -0.18421973f, 0.28592068f, 0.02557233f, 
    -0.06530357f, -0.03994845f, 0.00254455f, 0.01029731f, -0.16168325f, -0.07448018f, 0.08666119f, 0.00234662f, 
    0.05212800f, 0.09799325f, -0.06409165f, -0.06344781f, 0.06788141f, 0.06871323f, 0.09447682f, 0.06714750f, 
    -0.06400319f, 0.00841962f, -0.23031844f, -0.01097324f, -0.13936654f, 0.00088339f, 0.05677581f, 0.00984162f, 
    0.07026518f, 0.07838546f, 0.04334621f, 0.09066563f, 0.09909841f, 0.11176384f, 0.15516621f, 0.20510928f, 
    0.07620936f, 0.05192103f, 0.18578130f, 0.09071369f, -0.04609834f, -0.04342044f, -0.15464380f, 0.07038494f, 
    -0.09396463f, 0.00857383f, -0.10035373f, 0.09687143f, -0.36678359f, 0.04488007f, 0.14499700f, -0.00729354f, 
    0.00955274f, -0.06201211f, -0.01969149f, 0.07477327f, -0.02942209f, 0.03705383f, 0.04456637f, -0.00627187f, 
    -0.19809541f, -0.13144650f, -0.05310776f, 0.01586653f, -0.08438052f, 0.17492856f, 0.04417489f, -0.05697818f, 
    0.03485716f, -0.00618888f, -0.06697715f, -0.07190348f, 0.00244535f, 0.16763255f, 0.09909403f, 0.08318754f, 
    0.08143051f, -0.06345093f, 0.15306531f, 0.05341661f, 0.00389658f, 0.02210886f, 0.11215755f, 0.26576909f, 
    0.06733167f, 0.09937721f, -0.22562505f, -0.04169071f, 0.16404265f, 0.01119363f, -0.04147168f, 0.09443580f, 
    -0.10910463f, -0.14553542f, 0.05741480f, -0.12597662f, -0.12424582f, -0.20262603f, 0.15372868f, -0.04990016f, 
    -0.01540372f, 0.02592414f, -0.02893848f, -0.05259837f, 0.10815249f, -0.02776505f, 0.03947852f, -0.15479140f, 
    -0.23717271f, 0.17360425f, 0.19941622f, -0.11139561f, 0.06264091f, 0.04418677f, 0.02732216f, -0.07129455f, 
    0.05237786f, 0.06725297f, 0.02157915f, 0.05126409f, 0.23449418f, -0.07411675f, 0.12874579f, 0.04998980f, 
    0.05681310f, 0.06040302f, -0.01653812f, 0.05416856f, 0.01318668f, 0.02163867f, 0.08177862f, -0.09951916f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06317979f, 0.06906068f, 0.05442237f, 0.03420126f, -0.05393843f, 0.06581438f, 0.04948766f, 0.01378616f, 
    0.06918789f, 0.13043615f, 0.02810030f, -0.06145428f, 0.01329076f, -0.07605299f, -0.05524566f, -0.10511936f, 
    -0.05749073f, -0.03049554f, -0.07337640f, 0.07320247f, 0.07724009f, 0.00166430f, -0.01350421f, -0.00620239f, 
    -0.03241397f, 0.03264315f, -0.05416064f, 0.07047506f, 0.05870367f, 0.02783583f, 0.04258619f, -0.00044600f, 
    -0.04078188f, 0.14957428f, -0.03049150f, -0.03398550f, 0.03342791f, 0.01567538f, -0.03124003f, 0.12007415f, 
    0.09237292f, 0.04290890f, -0.03950752f, 0.09658250f, 0.00829980f, -0.05156193f, 0.05460289f, -0.09282169f, 
    0.04565805f, -0.04996646f, -0.12512441f, 0.07963116f, 0.00211970f, 0.02086229f, 0.12475773f, 0.00614976f, 
    0.07189430f, -0.00822996f, -0.02742298f, -0.06211197f, 0.12509033f, 0.06986672f, 0.04097761f, 0.05452844f, 
    0.01060982f, 0.03118605f, -0.04912626f, -0.02245045f, 0.12298028f, -0.07838838f, 0.10392148f, -0.07082568f, 
    -0.07941231f, -0.03125359f, 0.01709907f, -0.04137590f, -0.05732024f, -0.06671005f, 0.13841458f, 0.00718920f, 
    -0.04705140f, 0.02342374f, -0.04910033f, -0.05985320f, 0.11418610f, 0.10944262f, -0.01128392f, -0.04231581f, 
    0.03925742f, 0.04118524f, -0.03481864f, -0.06947607f, 0.13348420f, 0.07677453f, 0.12718925f, 0.13997525f, 
    -0.03716241f, -0.01415196f, 0.14276907f, 0.11175339f, 0.07507518f, -0.02536215f, -0.10525805f, -0.01383009f, 
    -0.03700886f, 0.08076991f, 0.01219577f, 0.01924675f, -0.06391577f, 0.12959906f, 0.08146325f, -0.02060680f, 
    0.01296059f, -0.09809731f, 0.02678551f, -0.03832188f, 0.13515140f, 0.02124788f, -0.07206067f, 0.16432244f, 
    0.05622117f, 0.05238678f, 0.01691663f, -0.01938787f, 0.08574232f, 0.04030122f, 0.01387983f, 0.02172438f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.00090064f, 0.10000777f, -0.05413722f, -0.19532587f, 0.02956804f, -0.08581012f, -0.41328776f, -0.00789303f, 
    0.09992559f, -0.37295783f, -0.14348210f, 0.02882514f, -0.46902257f, 0.09152608f, 0.12282817f, 0.13979116f, 
    -0.01909281f, -0.02429150f, 0.15053542f, 0.12947878f, 0.08783710f, -0.05056548f, 0.26201156f, 0.00790703f, 
    -0.13516667f, 0.10921007f, 0.11362090f, -0.40462261f, 0.15365204f, 0.01109755f, -0.12056985f, -0.00346455f, 
    -0.03813732f, -0.36783862f, 0.13440098f, 0.18505959f, 0.22036800f, -0.08304510f, 0.07504436f, 0.01836928f, 
    -0.43842864f, 0.00615364f, -0.02222070f, -0.01862326f, -0.28396720f, -0.07581577f, -0.07592030f, -0.17563327f, 
    -0.38400421f, -0.03007328f, 0.26148823f, -0.06385322f, -0.16690148f, 0.06261097f, -0.07434748f, -0.02372453f, 
    -0.31534106f, -0.09440280f, -0.09301382f, 0.03518034f, -0.01535394f, 0.10941613f, -0.05561118f, -0.07006834f, 
    -0.00331340f, -0.03492982f, 0.04558689f, -0.34164149f, -0.12011775f, 0.12550429f, -0.56948113f, -0.13234596f, 
    0.07114985f, -0.09353130f, 0.04980284f, -0.06799238f, 0.22179031f, 0.25731844f, -0.24110791f, 0.03662246f, 
    0.36029756f, 0.28647459f, -0.02715577f, 0.00667224f, -0.07584627f, 0.06108547f, 0.16294932f, -0.01191698f, 
    0.08429453f, 0.05669535f, 0.01887608f, -0.06612005f, -0.72172868f, -0.15182187f, -0.04836431f, -0.02177192f, 
    -0.03879349f, 0.03915255f, -0.06202932f, 0.01565421f, -0.47869095f, 0.23973566f, 0.15736589f, 0.04697768f, 
    0.04153184f, 0.00826531f, -0.25133550f, 0.00160703f, 0.03236696f, 0.06813663f, -0.04627887f, 0.11587583f, 
    0.03187190f, 0.16319025f, -0.09811303f, -0.08336122f, -0.09123958f, 0.27175704f, 0.00007737f, -0.10599241f, 
    0.29613093f, -0.02263295f, 0.11210062f, -0.00284250f, 0.19977167f, -0.04520573f, 0.20177872f, 0.07933132f, 
    0.05366018f, -0.29983848f, 0.24738762f, -0.29656163f, -0.25286168f, 0.11779419f, 0.15947163f, 0.09657764f, 
    0.15134653f, -0.27571574f, 0.13571925f, -0.06606938f, -0.26737076f, -0.02416662f, -0.34512511f, 0.13291208f, 
    0.06957486f, 0.06103710f, -0.01074281f, -0.02592131f, 0.21765614f, -0.10278521f, -0.18970488f, 0.10662128f, 
    -0.19560379f, -0.65910548f, 0.21635611f, -0.05522691f, 0.12938839f, 0.20993124f, -0.10367901f, -0.00325946f, 
    0.02842336f, 0.10141645f, 0.01547825f, -0.10052500f, 0.17831455f, -0.16616808f, 0.02263168f, 0.04902927f, 
    -0.30251175f, 0.21764140f, 0.08443090f, -0.52197856f, -0.04680062f, -0.14613920f, 0.07008161f, -0.11871927f, 
    -0.07918323f, -0.01246981f, -0.18734723f, 0.16866522f, -0.31536075f, 0.06153755f, 0.02891850f, -0.02391511f, 
    -0.10169932f, 0.12583531f, -0.06648149f, -0.10986282f, -0.07506301f, -0.05618063f, -0.06971902f, 0.03711776f, 
    -0.09323267f, -0.03241807f, -0.06973509f, -0.21819019f, 0.10162444f, 0.12200269f, 0.43096346f, -0.02432382f, 
    -0.07555767f, 0.04255408f, 0.10935592f, 0.07911058f, -0.25578216f, 0.06042549f, 0.06643772f, -0.01280784f, 
    -0.19745269f, -0.11898065f, 0.06078793f, -0.03634894f, -0.11559153f, -0.11983371f, 0.08461548f, 0.01801971f, 
    0.21325794f, 0.06919204f, 0.19256912f, -0.03422133f, 0.22356434f, 0.03678558f, -0.17107622f, 0.08988842f, 
    0.05375589f, -0.01670890f, -0.03453410f, 0.15823108f, 0.02495923f, -0.51342934f, -0.24637398f, -0.01414287f, 
    -0.03410598f, 0.16608091f, 0.10100345f, -0.05563994f, -0.04260319f, 0.04715657f, 0.12390734f, 0.07358646f, 
    -0.03980710f, 0.05857575f, 0.10919933f, -0.04723541f, -0.39328584f, 0.04376788f, -0.06770942f, -0.12063485f, 
    -0.52634752f, 0.29404381f, 0.13423738f, 0.07599010f, -0.02104992f, 0.00297155f, 0.01037519f, -0.13501203f, 
    0.03315823f, -0.24293192f, 0.13951223f, 0.09670375f, -0.05324894f, -0.22901590f, 0.03225624f, -0.11289930f, 
    -0.01926581f, 0.19700156f, 0.11777972f, -0.04866877f, 0.04950708f, -0.46470726f, 0.08687945f, -0.17668557f, 
    -0.01524062f, 0.05587576f, -0.10883781f, 0.12409890f, 0.07231022f, -0.01309021f, 0.13132456f, 0.18266563f, 
    -0.46527922f, -0.01220031f, 0.00167434f, 0.11867464f, -0.43807343f, -0.25719807f, -0.54636973f, 0.02967545f, 
    0.03005775f, -0.22137921f, -0.14851849f, -0.04019871f, -0.37630779f, 0.26912463f, 0.06209251f, -0.17106637f, 
    -0.07652998f, 0.01163566f, -0.01425569f, -0.03679535f, -0.01783958f, -0.04664235f, -0.00042257f, 0.01794072f, 
    0.15307455f, 0.04347900f, 0.12953985f, -0.17792276f, 0.00283039f, 0.00319039f, -0.12585871f, -0.18365286f, 
    0.28917578f, 0.03836617f, -0.01195260f, 0.23516141f, -0.21367587f, -0.27270952f, 0.02597066f, -0.01728793f, 
    0.03957584f, -0.05709790f, -0.12550159f, 0.09295475f, -0.21282984f, 0.37447143f, -0.36967254f, 0.28188542f, 
    0.00952728f, -0.04553489f, 0.09653298f, 0.12134859f, 0.11903422f, 0.05739145f, 0.14680779f, -0.02822816f, 
    0.25997901f, 0.27029154f, -0.00740812f, 0.03957002f, -0.38749480f, 0.18766652f, -0.07670517f, -0.07969730f, 
    0.17663220f, 0.07164755f, -0.07861812f, -0.08399202f, -0.05995987f, -0.11034729f, -0.43159950f, -0.15105779f, 
    -0.04859664f, -0.01845680f, -0.27652651f, 0.22885904f, -0.20955382f, 0.24837613f, 0.06888733f, 0.04393141f, 
    -0.06513645f, 0.17771557f, -0.03961971f, -0.19954628f, -0.00182836f, -0.12903027f, -0.16102619f, -0.05134273f, 
    0.04438071f, 0.11739554f, 0.19884230f, -0.02152081f, -0.16470741f, 0.23776850f, 0.02416413f, -0.20830165f, 
    0.32274082f, -0.06010316f, -0.10950641f, 0.23941167f, 0.05965692f, -0.02251703f, -0.03568618f, -0.18755639f, 
    0.04859282f, 0.13370831f, -0.62079453f, 0.10383299f, -0.02720868f, 0.12910515f, 0.06778437f, -0.54540271f, 
    -0.72563785f, 0.03756073f, 0.03820117f, -0.05567792f, -0.10374566f, -0.13666667f, 0.17097813f, 0.01017925f, 
    -0.04300397f, -0.05946995f, -0.35353079f, 0.14050013f, -0.46153963f, 0.17512569f, 0.10075806f, 0.04021833f, 
    -0.09499558f, 0.06951296f, 0.00781777f, 0.09542258f, 0.23517676f, 0.05121061f, 0.20064421f, 0.05862941f, 
    -0.06861884f, 0.03534042f, 0.03653340f, 0.20320764f, 0.19488372f, -0.28226888f, -0.03310940f, -0.00337031f, 
    -0.01486904f, 0.06460187f, 0.06359810f, 0.12730797f, -0.39633891f, 0.11525733f, 0.03181577f, 0.24991864f, 
    -0.23964091f, -0.03291661f, 0.09588815f, -0.06339631f, 0.28852284f, 0.06209594f, -0.34511876f, -0.29152295f, 
    -0.41825065f, -0.21885201f, 0.00938705f, -0.00679758f, -0.25160563f, -0.03200503f, -0.01249467f, 0.04259474f, 
    -0.02498292f, -0.00136804f, 0.01906288f, -0.17663474f, -0.16992900f, 0.20726657f, 0.08657866f, -0.30927470f, 
    0.02306395f, -0.02419884f, -0.19555071f, -0.05659446f, 0.13751498f, 0.11867883f, -0.31386355f, -0.00702789f, 
    -0.17061807f, 0.05906318f, 0.00552120f, -0.06926946f, 0.06332980f, -0.14118402f, -0.08034372f, -0.00600140f, 
    -0.04563088f, -0.07497600f, -0.05869293f, -0.05929302f, 0.18366963f, 0.22341357f, 0.19962300f, 0.06236596f, 
    -0.04207271f, -0.03187049f, -0.33407199f, 0.13713299f, 0.19873600f, -0.13941067f, -0.15100160f, 0.08526271f, 
    0.07012041f, -0.48034281f, -0.21615264f, -0.07886010f, 0.01171338f, 0.14951143f, 0.15075740f, 0.04839479f, 
    -0.06731763f, 0.25196466f, 0.04900222f, -0.01546403f, 0.10022574f, -0.14434016f, 0.03027223f, 0.22665800f, 
    -0.05518969f, 0.10930160f, 0.00681166f, -0.30327573f, 0.15899712f, 0.17517464f, 0.03752668f, 0.20506215f, 
    0.08983405f, 0.28914401f, -0.20169380f, -0.05612097f, 0.16755983f, 0.19152679f, 0.06233095f, -0.06118394f, 
    0.02272291f, 0.02702452f, -0.22988586f, 0.03318389f, -0.31205776f, -0.13450022f, 0.21426389f, -0.20113499f, 
    -0.04451619f, -0.04696560f, 0.08594913f, -0.28579047f, -0.03753471f, 0.13663127f, 0.06176180f, 0.16178919f, 
    -0.05246709f, 0.08418393f, 0.12058245f, -0.06822658f, -0.15034896f, 0.11265903f, 0.13806267f, 0.05230479f, 
    -0.04336544f, -0.15865970f, -0.10410424f, 0.06747849f, 0.01678110f, -0.01306283f, 0.03582871f, 0.17339917f, 
    -0.06045826f, -0.16902836f, -0.02495752f, 0.05724648f, -0.10336453f, -0.22225411f, -0.07149305f, 0.53928107f, 
    -0.35113546f, 0.04700419f, 0.03548404f, 0.03541688f, 0.04878043f, 0.04016671f, -0.28414783f, -0.06117462f, 
    0.03836520f, 0.24835615f, -0.02004282f, -0.23109435f, -0.57659703f, 0.20399210f, -0.05776966f, 0.02911889f, 
    -0.08439334f, -0.01983025f, 0.04236123f, 0.08381610f, -0.06878376f, -0.10888544f, -0.06151133f, 0.17226385f, 
    -0.01988339f, 0.07738752f, -0.08612788f, 0.15575932f, -0.50383371f, -0.14119993f, -0.08435225f, -0.01610051f, 
    -0.27433944f, 0.42979717f, 0.01054495f, -0.08697784f, 0.11367155f, -0.10007823f, -0.16192295f, 0.05376504f, 
    -0.11999910f, -0.03937571f, 0.13783583f, 0.03267246f, 0.00368289f, -0.30246833f, 0.22693090f, 0.12277993f, 
    -0.06019389f, 0.05337918f, 0.32013169f, -0.50424552f, 0.18559258f, 0.18930191f, 0.07923171f, -0.01925067f, 
    -0.02828022f, 0.01263641f, 0.28739914f, 0.17901982f, 0.02597317f, 0.08376474f, 0.11221854f, -0.02296379f, 
    -0.01192544f, -0.18380702f, -0.06905537f, 0.06074820f, 0.15345979f, -0.24782798f, 0.05661758f, -0.09608196f, 
    -0.03279703f, 0.03294530f, -0.11523484f, -0.16437654f, -0.34468544f, 0.25051776f, -0.37601110f, 0.06682635f, 
    -0.03966858f, 0.27481613f, -0.19357058f, 0.08128707f, -0.08702739f, 0.16444719f, 0.14114410f, -0.12535243f, 
    -0.15098916f, -0.30384561f, -0.36224750f, 0.03176829f, 0.33784023f, 0.20170543f, 0.26347429f, 0.01370289f, 
    -0.01603037f, 0.04398120f, 0.13137682f, -0.42430884f, -0.02535807f, -0.09228877f, 0.12045297f, -0.13518639f, 
    0.06103405f, -0.02455953f, 0.08022676f, 0.07445190f, -0.16115022f, -0.37074929f, -0.12249213f, -0.02594070f, 
    0.01779803f, -0.03718850f, 0.17161083f, 0.08826763f, -0.05521367f, -0.12467121f, 0.03148802f, 0.03544730f, 
    0.11349884f, -0.15366259f, 0.05978340f, 0.03718378f, -0.04813907f, 0.14098494f, -0.05848890f, -0.17994839f, 
    0.26770166f, -0.02222254f, -0.27793139f, 0.15846103f, -0.13165775f, 0.08800337f, 0.17578180f, 0.24742901f, 
    -0.03594583f, -0.23438674f, -0.06158099f, 0.12616767f, 0.67409325f, -0.02850598f, -0.03718816f, 0.04009197f, 
    0.06904845f, -0.01102248f, -0.09040952f, 0.23659371f, 0.24235833f, -0.06261592f, -0.51415884f, -0.27531946f, 
    0.03127759f, -0.06160684f, 0.07816745f, 0.15755990f, 0.14505082f, -0.04250706f, 0.01963288f, 0.03522648f, 
    -0.11020061f, -0.42708597f, 0.01967286f, 0.00136125f, 0.31924230f, 0.09957505f, 0.19850735f, -0.00163979f, 
    -0.08862557f, 0.03298935f, 0.03315438f, -0.08222915f, -0.35459322f, 0.14069426f, 0.22793379f, 0.14772636f, 
    -0.04477033f, 0.05108349f, -0.07199950f, -0.32312316f, -0.37171331f, -0.07067581f, -0.26640812f, -0.03887757f, 
    -0.04064291f, 0.11704279f, 0.05950166f, -0.08493034f, -0.02874613f, 0.08474502f, 0.10278288f, -0.01200540f, 
    0.04706122f, 0.12319212f, -0.13734651f, 0.04285295f, 0.18183179f, -0.13790359f, 0.02840563f, 0.23113059f, 
    -0.60779333f, -0.20233244f, -0.22047189f, 0.01776126f, -0.38148794f, -0.21627352f, -0.06038319f, -0.05044992f, 
    -0.01350675f, -0.31989372f, 0.15619437f, 0.31400153f, 0.07166907f, 0.07652619f, 0.19274653f, -0.36458418f, 
    -0.08341622f, 0.28515112f, 0.20324275f, 0.00572993f, -0.23577970f, 0.02587910f, -0.11528345f, -0.36900467f, 
    -0.01248121f, -0.01282688f, -0.29132181f, 0.28944430f, 0.02515855f, -0.21386959f, 0.14047110f, -0.38737923f, 
    0.22792093f, -0.17891745f, -0.07174020f, 0.17798609f, 0.05549606f, -0.68326044f, 0.04203931f, -0.04775424f, 
    -0.08565742f, 0.18807507f, 0.13503347f, 0.06784887f, -0.12846081f, 0.14697036f, 0.04149261f, -0.03189309f, 
    0.19951974f, 0.01954451f, -0.07260882f, 0.16999252f, -0.04925286f, 0.30615729f, 0.06012939f, -0.28329501f, 
    -0.43678510f, -0.03072100f, -0.18466496f, 0.04347495f, -0.09673081f, 0.01999450f, -0.06219894f, -0.24720143f, 
    0.18692592f, -0.00865052f, -0.08942499f, -0.46450415f, -0.09049285f, 0.02526485f, 0.00929142f, 0.05497795f, 
    -0.04184536f, 0.05333381f, 0.12644015f, -0.23113821f, 0.18727659f, -0.40554863f, -0.15260598f, 0.14332472f, 
    -0.06287900f, -0.08344641f, -0.13058890f, -0.25707173f, -0.00858822f, -0.33882925f, 0.14310837f, 0.00248837f, 
    0.19738635f, 0.17631333f, 0.07770954f, 0.01042392f, -0.24965045f, 0.11951318f, -0.23159397f, 0.06590922f, 
    0.06756052f, -0.09139942f, -0.36546034f, 0.07861253f, -0.23772179f, 0.20883583f, -0.13306397f, 0.10997614f, 
    -0.00905577f, 0.03581680f, 0.00677394f, 0.12587325f, 0.25237629f, -0.21837142f, 0.08420703f, -0.01721484f, 
    -0.03354879f, -0.10143090f, 0.07232699f, 0.07698849f, -0.04237832f, 0.06452634f, -0.06083185f, -0.02839438f, 
    -0.04043527f, 0.12607904f, -0.42878476f, 0.02302271f, 0.18712793f, -0.07188005f, -0.03707011f, -0.38853022f, 
    0.43124831f, -0.42150226f, -0.45616135f, 0.17652774f, -0.16780196f, -0.34313771f, 0.10187756f, 0.12392727f, 
    0.04458395f, 0.17109686f, -0.06156709f, -0.13848011f, 0.20241490f, -0.04644403f, 0.08311556f, -0.01262485f, 
    0.01871943f, -0.03847875f, -0.11960035f, 0.06076967f, 0.29858768f, 0.16829991f, 0.06911195f, 0.05887264f, 
    -0.01636910f, -0.00012805f, -0.00821557f, 0.03152399f, -0.16287087f, 0.18639621f, -0.11641382f, 0.07159292f, 
    0.19520922f, 0.16162296f, -0.08763038f, 0.15337005f, -0.00156389f, 0.03602451f, -0.09789211f, -0.08124882f, 
    0.02151433f, -0.19620520f, -0.36540174f, -0.12119904f, -0.49927071f, 0.03261363f, -0.02009868f, -0.12862180f, 
    0.17270480f, -0.34013274f, -0.08552480f, 0.07819970f, 0.22302480f, 0.32702130f, -0.01913094f, 0.06798041f, 
    0.11635651f, -0.09242354f, 0.11731363f, -0.28100267f, 0.10332169f, -0.05603301f, -0.34568322f, -0.00781808f, 
    0.05303841f, -0.19302776f, 0.06718542f, 0.14022896f, -0.24281347f, -0.35751462f, -0.01429268f, -0.06332140f, 
    0.06515874f, -0.06706139f, 0.05376531f, 0.23833652f, -0.13624890f, 0.10423464f, 0.13373227f, -0.01278397f, 
    -0.05376193f, -0.06379138f, -0.38107517f, -0.04802296f, 0.10801952f, -0.30244920f, -0.22867723f, -0.07793525f, 
    0.10527212f, -0.07299358f, -0.04720878f, -0.03210673f, -0.03872374f, -0.26112732f, 0.13604799f, -0.00187101f, 
    -0.33102411f, 0.07249271f, 0.03931040f, -0.00775439f, 0.17229649f, 0.00818568f, -0.15343243f, -0.33005434f, 
    -0.07037066f, 0.03567562f, -0.55081600f, -0.06204581f, -0.02072417f, 0.23794967f, 0.05675974f, -0.01900557f, 
    -0.01151253f, -0.13658074f, 0.21956430f, 0.11081518f, 0.05402581f, -0.46364227f, 0.06757508f, -0.01756092f, 
    -0.07412288f, 0.09910242f, -0.02838069f, -0.09438722f, -0.08078291f, 0.01039118f, 0.07174504f, -0.35775909f, 
    0.20414726f, -0.01755819f, 0.10885931f, 0.26545900f, -0.09860200f, -0.07371205f, -0.11931510f, 0.13312113f, 
    -0.06600359f, 0.12115457f, 0.13636318f, 0.24774495f, -0.12468602f, -0.30382296f, -0.28304443f, 0.10631807f, 
    0.28060490f, -0.14071675f, 0.23656066f, 0.07316325f, 0.13733618f, -0.21837185f, -0.14758225f, 0.21615629f, 
    -0.08077544f, -0.05060092f, 0.04860858f, -0.22623816f, -0.09987203f, -0.35376221f, 0.01733149f, 0.04304799f, 
    -0.00806787f, -0.02560869f, -0.02499823f, 0.19464608f, 0.21139339f, -0.20850362f, -0.04639184f, 0.02797070f, 
    0.07415056f, 0.25780657f, 0.02984128f, -0.50955939f, 0.15737468f, 0.01424836f, 0.05271827f, -0.43251988f, 
    0.07176746f, -0.40766394f, -0.07140729f, -0.48277670f, 0.17889544f, 0.22049691f, -0.00350853f, 0.24376737f, 
    -0.14523131f, -0.10170769f, 0.04536276f, 0.17985195f, -0.16898932f, 0.03454108f, 0.14186491f, 0.02763003f, 
    0.29794410f, 0.07504890f, -0.01085131f, 0.09658690f, -0.15641563f, 0.18470936f, 0.06563249f, 0.00728639f, 
    -0.08617684f, -0.02526345f, -0.37262973f, -0.13388401f, -0.21293476f, -0.19246885f, -0.07290331f, 0.17417257f, 
    -0.01194803f, 0.04462564f, -0.01392161f, 0.16815528f, -0.08714098f, 0.17174892f, 0.04970188f, -0.08501239f, 
    0.11544918f, -0.33012968f, 0.02697601f, -0.06711093f, -0.26339275f, -0.37937483f, -0.29455262f, -0.01605094f, 
    0.13747580f, -0.08097951f, -0.23262569f, -0.00575498f, -0.09343436f, 0.23873913f, -0.18964358f, -0.04971561f, 
    0.03281747f, 0.04479870f, -0.12386945f, -0.24679655f, 0.03218590f, 0.08625309f, 0.09272104f, -0.00884554f, 
    0.00240452f, -0.00983545f, -0.34475958f, -0.31597027f, -0.00338216f, -0.41605848f, 0.15363495f, 0.01525934f, 
    0.03365225f, -0.32661641f, 0.08549884f, -0.02771619f, -0.33968717f, -0.50503832f, -0.07229243f, 0.00267792f, 
    -0.27826089f, 0.16637379f, -0.08500656f, -0.07905798f, -0.02956260f, 0.23226562f, 0.26104087f, -0.29828343f, 
    0.03165280f, -0.47655255f, -0.26784530f, -0.37190521f, 0.17453006f, 0.13307972f, -0.37546915f, -0.09164256f, 
    0.08776475f, 0.26115474f, 0.23441730f, -0.05708181f, -0.14718294f, -0.01813920f, -0.24761115f, -0.28264850f, 
    -0.01300441f, -0.04473159f, 0.12883306f, -0.22224000f, -0.04454345f, 0.26335108f, -0.32208067f, -0.06299879f, 
    0.05310858f, 0.30517539f, 0.13443376f, -0.10227273f, -0.40442875f, -0.07410522f, 0.21446365f, -0.00292835f, 
    -0.08637147f, 0.00610892f, -0.04650525f, 0.14519282f, -0.28023750f, 0.13804643f, 0.06913398f, -0.20847411f, 
    0.07266031f, 0.05560113f, -0.01752672f, -0.01812265f, 0.30104285f, -0.04044724f, -0.00710764f, -0.51691061f, 
    0.25219503f, 0.04816780f, -0.09965298f, -0.09528929f, -0.10624170f, -0.08164352f, 0.01846088f, 0.26685524f, 
    -0.02072209f, 0.16943978f, 0.07272527f, 0.47040623f, -0.02143288f, 0.14166033f, -0.01342430f, -0.06466110f, 
    0.00816134f, -0.06941173f, 0.18072587f, 0.02647942f, 0.07170933f, -0.30325180f, 0.04783966f, 0.02009690f, 
    0.04590449f, 0.02625560f, 0.14477962f, -0.38342905f, -0.28656787f, -0.50325608f, 0.13423100f, 0.00148716f, 
    -0.31955644f, -0.55740410f, -0.06589793f, 0.06811681f, -0.20895179f, 0.14564484f, 0.28322822f, -0.04714490f, 
    0.04029650f, 0.06355999f, 0.10267314f, 0.07252344f, 0.21670236f, 0.10776296f, -0.31845164f, 0.00276826f, 
    -0.08406279f, 0.02457066f, 0.16349733f, 0.16031455f, -0.20246026f, 0.30001420f, 0.19172890f, 0.01620819f, 
    -0.04966506f, -0.13443051f, -0.11941569f, 0.13639441f, 0.01485564f, -0.23441702f, -0.50481308f, -0.03044664f, 
    -0.06168435f, -0.12724388f, 0.03515485f, 0.03632656f, -0.03475545f, 0.22052853f, 0.01117071f, -0.03408320f, 
    -0.22876564f, -0.24429701f, -0.09945094f, -0.02093375f, -0.18643826f, -0.06044384f, -0.11527371f, 0.23734865f, 
    0.05725691f, 0.19435391f, 0.17086984f, 0.07094455f, -0.31504628f, -0.28267491f, 0.01722702f, 0.25605458f, 
    0.23535173f, 0.11829454f, -0.18079837f, -0.03728759f, -0.00644699f, 0.08522774f, 0.03029151f, -0.10999429f, 
    0.00619459f, 0.05554118f, -0.10578565f, 0.28011325f, -0.23818639f, 0.21827881f, -0.37102282f, -0.08741446f, 
    0.17782810f, -0.29708570f, -0.22343189f, 0.23964922f, -0.02716033f, 0.18843910f, -0.16707647f, 0.04652856f, 
    -0.06153099f, 0.03463451f, 0.09480332f, -0.39248550f, -0.10296910f, 0.14896293f, -0.07883874f, -0.00655614f, 
    0.18375070f, 0.11298233f, -0.03905791f, 0.23472853f, 0.11320785f, -0.36149758f, -0.01095179f, 0.19603622f, 
    0.24595509f, -0.04108922f, 0.04831768f, -0.09218089f, -0.08949436f, 0.08481731f, 0.27377409f, -0.23325983f, 
    0.17362949f, -0.02523523f, -0.04714435f, -0.09110805f, 0.01990716f, -0.35033590f, -0.00467967f, -0.04888511f, 
    0.00627158f, 0.01460612f, -0.27876154f, -0.20596632f, 0.12652689f, -0.22082475f, 0.21181558f, -0.31354615f, 
    0.02103918f, -0.01719899f, -0.14530396f, 0.02810886f, 0.31789726f, 0.19646633f, -0.07103701f, 0.04581369f, 
    0.13412005f, 0.00437455f, 0.06469444f, 0.01736135f, 0.19673422f, 0.30558744f, -0.02781412f, -0.07853502f, 
    -0.03547337f, 0.01146312f, -0.04866844f, -0.07334226f, 0.06728274f, -0.15117192f, 0.04176400f, -0.05638893f, 
    -0.07460524f, 0.01672315f, 0.12318465f, 0.23534319f, 0.08648161f, -0.33080560f, -0.25327358f, -0.04226042f, 
    0.00747428f, -0.09329095f, 0.24805985f, -0.31735280f, 0.04497752f, 0.16572787f, 0.18941326f, -0.00767555f, 
    -0.07217507f, -0.27510285f, 0.08387388f, 0.01160236f, 0.13424994f, -0.05734718f, -0.01952307f, -0.49965557f, 
    0.04367777f, -0.06703908f, 0.16014975f, -0.45988762f, 0.32143533f, -0.12684606f, -0.28192112f, -0.41592646f, 
    -0.07681126f, -0.38274541f, 0.10109963f, 0.29743019f, 0.11485972f, 0.01315525f, -0.26251742f, -0.37500930f, 
    0.02049826f, -0.10050825f, 0.14902066f, -0.09551068f, 0.24133180f, -0.15866254f, -0.40022901f, 0.14745766f, 
    0.06952940f, 0.03842223f, -0.06538713f, -0.29042110f, 0.15173157f, -0.24707164f, 0.18692657f, -0.40357900f, 
    0.08435486f, 0.15446070f, -0.43678921f, -0.17978318f, -0.01958068f, 0.26677945f, -0.14952217f, 0.00368812f, 
    0.03092677f, 0.14165689f, -0.20320830f, -0.50100958f, 0.12214367f, -0.42725205f, 0.01461952f, 0.02184841f, 
    0.20476599f, -0.19337821f, -0.03789930f, -0.10731178f, -0.28655043f, -0.22061627f, -0.05528070f, -0.16763282f, 
    0.22966589f, 0.00430484f, 0.14103918f, 0.13626033f, 0.01823550f, -0.08631232f, 0.26486877f, 0.06341541f, 
    -0.24066980f, -0.20897526f, 0.01368645f, -0.34085515f, -0.29284680f, 0.04945226f, -0.08854911f, 0.05702848f, 
    -0.02913985f, 0.06038884f, 0.11265713f, 0.13396040f, -0.03966735f, 0.08933910f, -0.12600055f, 0.19897033f, 
    0.01603005f, 0.05865365f, 0.02816342f, -0.27697301f, -0.01219786f, 0.14068429f, 0.08362138f, -0.05210864f, 
    -0.42452613f, -0.21392718f, -0.07451901f, 0.03597356f, 0.16828872f, -0.26127920f, -0.20376761f, -0.00683539f, 
    -0.07925326f, -0.03033095f, 0.05429435f, 0.06188833f, 0.02423746f, -0.18138412f, 0.16875717f, -0.06005713f, 
    0.01170598f, -0.05709374f, 0.02198769f, 0.09228639f, 0.07778239f, -0.04398087f, 0.21106640f, 0.00527446f, 
    -0.02938594f, -0.20202565f, -0.46996886f, 0.09293933f, 0.02741027f, 0.12811923f, -0.04641964f, 0.03316094f, 
    0.00388318f, 0.10842547f, 0.22756743f, -0.06647407f, 0.22487521f, 0.26667351f, 0.06601140f, 0.54664975f, 
    0.09702642f, 0.05298381f, 0.20937203f, -0.06550718f, 0.07596550f, -0.33580723f, 0.07898152f, -0.08619927f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.02481578f, 0.01277103f, -0.00616623f, 0.00433253f, 0.03404754f, 0.09171709f, 0.07851359f, -0.01110505f, 
    0.04455894f, -0.05405370f, 0.06087303f, 0.06016913f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
